/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.46425098e-01f, 3.20132524e-01f, 4.78032649e-01f, 2.50661314e-01f, 3.90549839e-01f, 2.56755561e-01f, 3.28009099e-01f, 1.29061237e-01f, 3.34291533e-02f, 1.00079142e-01f,
  1.36684284e-01f, 1.74104553e-02f, 1.41160315e-04f, 5.19494712e-02f, 1.49527803e-01f, 1.94735736e-01f, 3.50563943e-01f, 2.34582603e-01f, 2.06849590e-01f, 8.47942829e-02f,
  1.10189706e-01f, 9.38740447e-02f, 1.65928751e-01f, 1.38490036e-01f, 8.07434693e-02f, -1.69856648e-03f, 2.90590435e-01f, 2.38372371e-01f, 7.49127269e-02f, 2.30000734e-01f,
  2.45763481e-01f, 2.31906012e-01f, 4.29426767e-02f, 1.76530946e-02f, 2.00822860e-01f, 1.54301350e-03f, 1.12190448e-01f, 4.11698595e-02f, 5.38665205e-02f, 1.10539846e-01f,
  1.92755818e-01f, 8.84186476e-02f, 1.13160431e-01f, 3.80825773e-02f, 5.62412702e-02f, 1.23791434e-01f, 1.52590677e-01f, 1.43163085e-01f, 4.08989675e-02f, 1.02951773e-01f,
  1.35796160e-01f, 1.47278607e-01f, 4.93764952e-02f, 3.18544246e-02f, 1.05234109e-01f, 8.85799229e-02f, 1.18203305e-01f, 4.78346385e-02f, 4.10960689e-02f, 1.26332238e-01f,
  -5.13301864e-02f, -9.67096984e-02f, -1.51281103e-01f, -1.59408063e-01f, -1.09157465e-01f, -1.29755482e-01f, -8.88167098e-02f, -6.66583329e-02f, -8.71545821e-02f, -6.14742488e-02f,
  -1.70478553e-01f, -5.54461889e-02f, -8.06259662e-02f, -7.26982504e-02f, -1.05095424e-01f, -5.86973280e-02f, -1.09855980e-01f, -1.54533684e-01f, -1.72648579e-01f, -1.65121332e-01f,
  -1.34411961e-01f, -3.81929092e-02f, -1.17872864e-01f, -8.62931088e-02f, -3.67159955e-02f, 3.44854197e-03f, -2.63340566e-02f, -1.64826170e-01f, -1.25222385e-01f, -9.05794129e-02f,
  -7.56380782e-02f, 1.36214629e-01f, 6.53867424e-02f, 1.20444775e-01f, 9.25481692e-02f, 2.68259868e-02f, 8.67640525e-02f, -1.31463977e-02f, 4.83026057e-02f, 2.62021739e-02f,
  1.39516339e-01f, 8.69932547e-02f, 1.21557519e-01f, 9.77097899e-02f, 1.59464434e-01f, 1.19733311e-01f, 3.76248360e-02f, 1.02446347e-01f, 8.53739306e-02f, -1.91760771e-02f,
  7.24109262e-02f, 3.01279910e-02f, -5.09135351e-02f, 9.47886854e-02f, 1.52329272e-02f, 7.23318569e-03f, -2.17347778e-02f, 4.39938009e-02f, 4.85440763e-03f, -5.01539335e-02f,
  -5.20726383e-01f, -1.39191732e-01f, -8.13022405e-02f, -3.34468573e-01f, 6.44433573e-02f, 4.43288460e-02f, -6.38624979e-03f, -1.64334357e-01f, -1.96985200e-01f, -7.57108629e-02f,
  -1.61375925e-01f, -2.50316054e-01f, -1.34676233e-01f, -6.57843947e-02f, -1.76326156e-01f, 1.76879421e-01f, 1.57222241e-01f, 1.32109709e-02f, -1.25623420e-01f, -8.42237398e-02f,
  1.37911335e-01f, -1.05715707e-01f, -2.83925325e-01f, -1.23862021e-01f, 1.48431838e-01f, 1.45689681e-01f, 8.12232643e-02f, -5.68541586e-02f, 2.27402359e-01f, 2.01363862e-01f,
  -2.70815920e-02f, -2.59333402e-01f, -5.47417849e-02f, -5.16975001e-02f, -7.77940452e-02f, -8.41551553e-03f, -4.62398976e-02f, 2.31348886e-03f, -7.36773610e-02f, -1.31282747e-01f,
  -1.76387385e-01f, -1.20894194e-01f, -7.04893693e-02f, 1.56746171e-02f, -1.49989665e-01f, -1.43163309e-01f, -1.64686620e-01f, -1.87902868e-01f, -1.31570190e-01f, -1.67981282e-01f,
  -8.01814813e-03f, -4.30724770e-02f, -1.70868933e-01f, -7.42864087e-02f, -9.19743106e-02f, -2.43317839e-02f, -1.21518545e-01f, -7.38402084e-02f, -1.31602418e-02f, -1.92979518e-02f,
  1.51607573e-01f, 4.09101881e-02f, 5.27758412e-02f, 2.22622138e-02f, -2.16473080e-02f, 7.13652298e-02f, 1.36542199e-02f, 1.00671820e-01f, 8.30204934e-02f, -1.95030950e-03f,
  2.54955087e-02f, 3.77043597e-02f, 1.97365247e-02f, 2.44110953e-02f, 1.12680057e-02f, 6.55843914e-02f, 5.90190478e-02f, 4.08872478e-02f, -4.51844893e-02f, 1.87867209e-02f,
  -3.87545787e-02f, 9.56416950e-02f, 2.23667268e-02f, 6.44396991e-02f, 9.96720046e-02f, -3.82568724e-02f, 5.64585859e-03f, 6.88103363e-02f, -5.90496734e-02f, -2.40065176e-02f,
  -1.61582097e-01f, -9.36285257e-02f, -1.33549143e-02f, -8.48031491e-02f, -1.51643297e-03f, -1.10018864e-01f, -1.18966304e-01f, -7.65900090e-02f, -5.53075857e-02f, -5.68061732e-02f,
  -7.56545216e-02f, -1.24661036e-01f, -1.17902167e-01f, -1.19277604e-01f, -3.37301753e-02f, -6.33988976e-02f, -3.76031175e-02f, 2.60739438e-02f, -4.03183699e-02f, -9.05009434e-02f,
  -9.50149745e-02f, -8.32010135e-02f, -6.67136386e-02f, -1.97230615e-02f, -3.94409820e-02f, 4.46204655e-02f, -5.18294163e-02f, 8.68048146e-02f, -7.42152706e-02f, 6.36080652e-02f,
  2.85301119e-01f, -4.15950537e-01f, 4.17141542e-02f, 2.65070307e-03f, -1.92619890e-01f, -1.88837364e-01f, -3.02747786e-01f, -6.87692016e-02f, -7.26841716e-03f, -1.55454606e-01f,
  -1.17785789e-01f, 4.36666906e-02f, 6.05247058e-02f, 9.52223539e-02f, 1.10668644e-01f, -3.01758170e-01f, -2.05159798e-01f, 1.72698423e-01f, 4.08447653e-01f, 8.84351134e-02f,
  -1.59561530e-01f, 1.46852538e-01f, 2.15986654e-01f, 6.18270934e-02f, -2.83067763e-01f, 4.60401662e-02f, -2.29083374e-01f, -1.20166607e-01f, -2.28473097e-01f, -4.44643527e-01f,
  9.39095765e-02f, -2.04551876e-01f, 1.59823954e-01f, -2.35430561e-02f, -5.44877239e-02f, -6.25033900e-02f, -1.01634841e-02f, -3.81386057e-02f, -9.11597013e-02f, -1.44460723e-01f,
  -1.14374459e-01f, -1.18630163e-01f, -8.77131522e-02f, -9.37071517e-02f, -8.96981955e-02f, -6.89247102e-02f, -9.13808048e-02f, 2.54871938e-02f, 2.78393999e-02f, -2.20942631e-01f,
  -2.03373730e-01f, -2.36621335e-01f, -1.58300009e-02f, -1.27104325e-02f, -6.00664541e-02f, 5.03800735e-02f, -3.26209292e-02f, -9.50358063e-02f, -3.01354472e-02f, -9.04171988e-02f,
  1.29475966e-01f, -1.39164757e-02f, 7.71020576e-02f, -7.28032831e-03f, 1.76465847e-02f, 6.48184046e-02f, 2.71711089e-02f, 1.01267800e-01f, 2.25918088e-02f, 1.31215132e-03f,
  -4.91440110e-02f, 3.41091789e-02f, 1.08828381e-01f, 5.27921272e-03f, 7.47869462e-02f, 1.16582140e-02f, -7.62739731e-03f, 1.87843014e-02f, 5.79628069e-03f, -3.42239849e-02f,
  3.03439032e-02f, 3.22477818e-02f, 8.50649253e-02f, 3.04729734e-02f, 5.75692616e-02f, 5.21151088e-02f, -1.54778603e-02f, 7.14297891e-02f, 2.43459791e-02f, -3.79093103e-02f,
  2.74649501e-01f, 1.06240600e-01f, -8.89599025e-02f, 3.90515439e-02f, 5.33461245e-03f, -2.73567047e-02f, 1.16065787e-02f, 1.33621126e-01f, 7.33594317e-03f, -4.61475775e-02f,
  -2.68944148e-02f, 1.52888641e-01f, -6.36387467e-02f, -9.34394076e-02f, 1.48156071e-02f, -2.68352684e-02f, -9.16174799e-02f, 2.95182150e-02f, -1.25054047e-02f, -4.32459638e-02f,
  -7.23227188e-02f, 4.84540500e-02f, 1.47242814e-01f, 1.13617685e-02f, -2.75119487e-02f, 1.07527085e-01f, 1.16135404e-01f, 7.99571127e-02f, 1.59023196e-01f, 3.95473689e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.77683324e-01f, 2.80122072e-01f, 8.25568438e-02f, -7.29436725e-02f, -2.58041881e-02f, 2.13813439e-01f, 2.17361912e-01f, 9.70993340e-02f, -2.21810173e-02f, 6.37981668e-02f,
  3.15991431e-01f, 1.68305844e-01f, 1.80001706e-01f, 9.70296264e-02f, 8.53227749e-02f, -1.64024651e-01f, -2.37194076e-01f, -2.04518884e-01f, -2.00310603e-01f, -5.81923872e-02f,
  -2.21352130e-01f, -1.96215779e-01f, -1.32139057e-01f, -1.22041218e-01f, -2.49970891e-02f, -9.12455246e-02f, 4.85485457e-02f, 2.33463719e-02f, 1.12084381e-01f, -2.60507852e-01f,
  9.45316181e-02f, 3.74129504e-01f, -1.89136624e-01f, 8.78765136e-02f, 4.99657132e-02f, -1.19404774e-02f, -2.58172899e-02f, -8.52827653e-02f, 8.54142457e-02f, 2.38497965e-02f,
  -9.40883011e-02f, 2.84629948e-02f, -8.98009315e-02f, 8.80784094e-02f, 5.13450913e-02f, 1.52721629e-02f, 9.22020897e-02f, 5.48904017e-02f, 1.62096649e-01f, 1.85413599e-01f,
  2.33514026e-01f, 2.08895221e-01f, 2.30222911e-01f, 2.30405092e-01f, 2.04192236e-01f, 1.13635637e-01f, 2.35206023e-01f, 2.84960866e-01f, 2.89556891e-01f, 2.35237017e-01f,
  1.55331552e-01f, -6.22409470e-02f, 1.86658017e-02f, -2.42162626e-02f, 1.01871245e-01f, -1.53253041e-02f, -1.76376000e-01f, -7.26012588e-02f, 8.73265639e-02f, -5.57815395e-02f,
  -4.16661687e-02f, 1.33804724e-01f, 5.09751253e-02f, -1.77700669e-01f, -6.16333857e-02f, -2.71347555e-04f, -4.59675044e-02f, 1.94340367e-02f, 2.04271004e-01f, 9.61818397e-02f,
  1.28710493e-01f, -7.19012469e-02f, -5.57486294e-03f, -1.14951739e-02f, 3.57136056e-02f, 7.06777051e-02f, 1.00945987e-01f, 1.20686933e-01f, -4.45236973e-02f, 8.05321522e-03f,
  -2.22647965e-01f, 2.99123526e-01f, -1.90741584e-01f, -8.86801556e-02f, 5.86084463e-02f, -2.51921304e-02f, -2.11180784e-02f, -1.58036947e-01f, -1.72379121e-01f, -1.15946554e-01f,
  -5.91010824e-02f, -1.40312374e-01f, -4.85256128e-02f, -9.92265940e-02f, -1.17055289e-01f, 4.95582856e-02f, 1.82695180e-01f, 3.71095948e-02f, 6.28358573e-02f, 7.58927539e-02f,
  3.15751247e-02f, 5.57300746e-02f, 1.03757925e-01f, 4.85667251e-02f, 1.82449520e-02f, -1.19259775e-01f, -9.03431773e-02f, 2.70583387e-02f, 1.13632545e-01f, -9.91713554e-02f,
  -7.94128120e-01f, -1.93167537e-01f, -1.00070082e-01f, -6.19095027e-01f, -9.57556367e-02f, 1.86185136e-01f, 9.70822424e-02f, 1.11361183e-01f, -3.03926229e-01f, -3.97703260e-01f,
  -2.08450601e-01f, -1.09896742e-01f, -3.07932884e-01f, 1.10839412e-01f, 1.87401116e-01f, -7.93415010e-02f, -9.90704447e-02f, 1.33416504e-01f, 3.83270591e-01f, 2.82667994e-01f,
  3.39703187e-02f, -1.01932615e-01f, -6.59642369e-02f, -7.44653493e-02f, -3.46542627e-01f, -2.27965757e-01f, -3.45995307e-01f, -8.77525955e-02f, 9.60491691e-03f, -4.75041360e-01f,
  -4.05554533e-01f, -2.84933746e-01f, 2.16689140e-01f, -4.57801716e-03f, -9.23848078e-02f, -5.61403036e-02f, -3.45265195e-02f, -8.84421542e-02f, 1.93786975e-02f, -1.39503688e-01f,
  -2.92208672e-01f, -4.06647697e-02f, -1.86535418e-01f, 1.11831039e-01f, -5.34573086e-02f, -6.46018144e-03f, 4.46440727e-02f, 1.42272845e-01f, 3.95221449e-02f, 3.95066962e-02f,
  1.11507908e-01f, 2.42382511e-02f, -1.02283612e-01f, 2.61254936e-01f, 2.02380151e-01f, 4.41536605e-02f, 6.07166514e-02f, 1.78238034e-01f, 2.27519706e-01f, -1.43321753e-01f,
  -1.12544764e-02f, -2.90886909e-02f, 1.29677117e-01f, 3.93507164e-03f, 6.95834756e-02f, -3.21334265e-02f, -3.68403085e-02f, -1.01185389e-01f, 8.74416232e-02f, -6.08539991e-02f,
  2.27926765e-02f, 7.22380588e-03f, 2.01541632e-02f, -1.22808397e-01f, -1.30403459e-01f, -4.30389866e-02f, 9.32616889e-02f, -3.50390514e-03f, -1.73648391e-02f, -5.72738200e-02f,
  9.18222070e-02f, 1.10388629e-01f, -4.00063694e-02f, 7.95784742e-02f, 1.27428308e-01f, 1.47832136e-04f, 5.30608073e-02f, 8.48905966e-02f, 1.80621576e-02f, 1.52623914e-02f,
  -4.18401629e-01f, 4.49083179e-01f, -3.57806504e-01f, 3.16367485e-02f, -1.96567699e-01f, -3.22669297e-02f, -2.80116975e-01f, -3.33652869e-02f, -1.20430559e-01f, -2.33665984e-02f,
  8.07860121e-02f, -8.80358070e-02f, -1.80111170e-01f, 4.20825258e-02f, -2.94603873e-03f, -1.38596162e-01f, 7.87051767e-02f, 3.23295519e-02f, 2.34446809e-01f, -3.69441025e-02f,
  1.11596085e-01f, 8.64255279e-02f, -9.14076641e-02f, -9.57259908e-03f, 9.74200573e-03f, -1.69157591e-02f, -1.85323447e-01f, -2.44599562e-02f, 1.26727112e-03f, -3.68554443e-01f,
  -5.42510033e-01f, -3.66454013e-02f, 9.29802358e-02f, -4.76041317e-01f, -3.43186826e-01f, -3.32280278e-01f, -2.86830723e-01f, 2.68813930e-02f, -3.86275165e-02f, -2.09081367e-01f,
  7.90138096e-02f, -1.88721009e-02f, 4.88966107e-02f, 9.03890878e-02f, 2.44243313e-02f, -2.49319687e-01f, -3.96686524e-01f, -1.54446915e-01f, -2.52552815e-02f, -1.47065878e-01f,
  -7.69923851e-02f, -1.98110580e-01f, -1.31459609e-01f, 2.38347091e-02f, -4.09344494e-01f, -1.94273025e-01f, -2.00946718e-01f, -1.54991671e-01f, -1.25013471e-01f, -5.02166271e-01f,
  -5.79261594e-02f, -2.42230430e-01f, -1.07049935e-01f, -3.07821393e-01f, -1.99353676e-02f, 1.04488835e-01f, 1.42192952e-02f, -1.48400396e-01f, 2.40317415e-02f, 1.62483007e-02f,
  -2.62052417e-01f, 7.72083178e-02f, -3.00810009e-01f, -1.14440650e-01f, -2.15049103e-01f, -1.04109518e-01f, -1.38093354e-02f, -2.06162501e-02f, -4.29416411e-02f, 5.23419417e-02f,
  -1.69871897e-01f, -2.71790445e-01f, -2.13992417e-01f, 1.17405489e-01f, 7.71316066e-02f, 7.22959191e-02f, 1.06893383e-01f, -6.01201653e-02f, 1.18935332e-01f, -2.45472357e-01f,
  -1.46151423e-01f, 5.96863367e-02f, -1.46995127e-01f, -7.17335492e-02f, 1.68421064e-02f, -3.09383553e-02f, -1.99469730e-01f, -1.58514977e-01f, 3.96509655e-02f, -1.27816694e-02f,
  1.83925144e-02f, 1.68307886e-01f, 9.83778667e-03f, -2.29676887e-01f, -2.91228630e-02f, -3.00200343e-01f, -2.10731298e-01f, 4.79205661e-02f, 3.41183692e-03f, 1.01389615e-02f,
  -2.06801564e-01f, -8.58207271e-02f, -1.10505946e-01f, -1.63781822e-01f, -1.57278508e-01f, -1.48049863e-02f, -6.26729727e-02f, -3.61567624e-02f, -3.75527255e-02f, -1.46566972e-01f,
  8.38600844e-02f, 4.19039845e-01f, -9.69844609e-02f, -1.14157572e-01f, 1.16096146e-01f, 1.74897507e-01f, 5.49287070e-03f, 1.45502761e-01f, -1.02490395e-01f, 2.19158046e-02f,
  -1.23154394e-01f, -8.95583257e-02f, -2.94794794e-02f, 3.27683724e-02f, -4.81044466e-04f, -2.04706818e-01f, -1.75635427e-01f, -3.33215624e-01f, -6.37715682e-02f, 6.20179996e-02f,
  -8.11794549e-02f, -1.73798859e-01f, -3.34874660e-01f, 1.70141030e-02f, -1.40160024e-01f, 6.20908551e-02f, -4.60784249e-02f, -1.77238092e-01f, -1.50880277e-01f, -2.46820658e-01f,
  -9.87911761e-01f, 3.02190125e-01f, 8.51813108e-02f, -7.84124076e-01f, -3.36587816e-01f, -1.42305866e-01f, 2.45572284e-01f, 2.82889176e-02f, -2.07451358e-01f, 1.86176926e-01f,
  1.41749084e-01f, -1.87705114e-01f, -1.68958127e-01f, -1.10993110e-01f, -2.67810315e-01f, 8.02113116e-02f, -2.27165565e-01f, -5.38586915e-01f, -5.99951982e-01f, -2.06272036e-01f,
  -3.18370700e-01f, -6.03605688e-01f, -7.09980428e-01f, -2.69406974e-01f, -5.65487221e-02f, -3.33660394e-01f, -3.75807546e-02f, -4.04120982e-01f, -1.56599402e-01f, -1.26802802e-01f,
  3.98679048e-01f, -1.97205588e-01f, -3.45555469e-02f, -2.73441464e-01f, 9.75206494e-02f, 1.43996812e-03f, -3.42298858e-02f, -1.05724949e-02f, -2.08354499e-02f, 3.62020247e-02f,
  -1.97442010e-01f, -1.47048784e-02f, -1.12094492e-01f, 2.76600756e-03f, -1.27814487e-01f, -6.27880543e-02f, -8.54668692e-02f, -1.96622431e-01f, 5.06001189e-02f, 2.59671599e-01f,
  1.08813152e-01f, -2.02212721e-01f, -4.91771474e-02f, 2.75897056e-01f, 1.35930225e-01f, -1.24235213e-01f, 3.69588286e-01f, 8.43682364e-02f, 1.15855664e-01f, 2.13003606e-01f,
  4.03271914e-02f, 3.08987852e-02f, -7.44857490e-02f, -1.50609657e-01f, -2.06633173e-02f, -8.07081088e-02f, -1.79291442e-02f, 4.27924655e-02f, -2.61691213e-02f, -1.12307064e-01f,
  6.22350685e-02f, 1.36469901e-01f, 1.23212218e-01f, -1.27378076e-01f, 3.01548615e-02f, 2.05161534e-02f, -3.30121629e-02f, -5.04136942e-02f, -4.28517051e-02f, -7.61524439e-02f,
  -1.84607312e-01f, 4.16244194e-02f, -4.93228398e-02f, -2.68661901e-02f, 1.13604166e-01f, 5.15223891e-02f, 1.14224091e-01f, 8.24845880e-02f, -1.08658001e-02f, 8.41312017e-03f,
  4.81398441e-02f, -2.61159658e-01f, -3.60703319e-02f, -4.97145718e-03f, 8.04237053e-02f, 5.31748943e-02f, 7.09666461e-02f, 5.98213226e-02f, -5.49062826e-02f, -8.65137030e-04f,
  5.72563261e-02f, 1.29823148e-01f, 6.99137449e-02f, 6.20025881e-02f, 4.62602600e-02f, -1.39733732e-01f, -4.12450917e-02f, -8.21590349e-02f, 6.62339479e-03f, 2.95494348e-01f,
  6.56306669e-02f, -5.99884614e-02f, -1.83314741e-01f, 1.03525363e-01f, 1.41496718e-01f, -1.82912096e-01f, 2.45935261e-01f, 2.19753087e-01f, 3.41041386e-02f, 1.59489155e-01f,
  -1.99470334e-02f, 4.59038317e-01f, -3.96878086e-02f, -2.29547814e-01f, 3.73028159e-01f, 2.76501589e-02f, -3.44158038e-02f, -2.79765427e-01f, -7.00436309e-02f, 2.61165708e-01f,
  5.82582891e-01f, 2.62543708e-01f, 9.36013088e-02f, -1.47913247e-01f, -6.11360371e-01f, -2.85208046e-01f, -3.24923664e-01f, -5.94987094e-01f, -5.86557209e-01f, -1.70129836e-01f,
  1.66940372e-02f, -1.05202373e-03f, -2.28769511e-01f, -2.64291167e-01f, 8.56448561e-02f, 1.58023629e-02f, 2.51126319e-01f, 1.79571450e-01f, 2.58975446e-01f, 1.48313105e-01f,
  7.92376027e-02f, 3.55967015e-01f, -5.10869995e-02f, 1.42185956e-01f, 1.92179799e-01f, -1.22601427e-01f, -1.31652281e-01f, -2.01962307e-01f, 1.14154508e-02f, 5.09126578e-03f,
  3.22000414e-01f, 6.76732585e-02f, -5.23454323e-02f, -3.62853892e-02f, -1.74411252e-01f, -2.19701827e-02f, -2.14858368e-01f, -3.49003971e-01f, -1.39416397e-01f, -1.73359320e-01f,
  5.64466976e-02f, 1.91348314e-01f, -7.30339512e-02f, -1.09353863e-01f, -3.15614998e-01f, 1.18855732e-02f, 9.58210081e-02f, -1.08650751e-01f, -1.79256909e-02f, -5.63726388e-02f,
  6.69727325e-02f, -4.40821722e-02f, -3.23653258e-02f, 6.03977628e-02f, 7.96253383e-02f, 9.24530327e-02f, -7.23166717e-03f, -5.89289926e-02f, -7.62597024e-02f, -6.40859753e-02f,
  4.17548977e-02f, 1.30102396e-01f, -1.44299313e-01f, -1.33460462e-02f, -9.32836533e-02f, -3.16011235e-02f, -7.67666921e-02f, -4.51597059e-03f, 3.72178922e-03f, 8.74007270e-02f,
  -9.21994168e-03f, 2.98107769e-02f, -8.17920789e-02f, -1.53566778e-01f, 4.09933627e-02f, -1.14407837e-01f, 9.76910293e-02f, 1.11082383e-01f, 1.45238778e-02f, 1.21464357e-01f,
  -1.01136424e-01f, 1.25681892e-01f, -2.19634533e-01f, -1.62648231e-01f, 3.49263959e-02f, -1.73393562e-02f, 8.56006965e-02f, -4.76186499e-02f, 1.94248408e-01f, -1.75280064e-01f,
  -2.76550110e-02f, -1.72766626e-01f, 4.31744680e-02f, -7.78596997e-02f, -1.17863014e-01f, -4.95763682e-02f, -2.03306824e-02f, -1.14985652e-01f, -6.08679354e-02f, -2.01880589e-01f,
  -2.10391775e-01f, -2.17490084e-02f, -8.27839375e-02f, -1.89285561e-01f, -1.93163734e-02f, 1.06277660e-01f, -1.02930494e-01f, -2.79684037e-01f, -4.65345122e-02f, -3.04790467e-01f,
  7.76909828e-01f, -1.74796417e-01f, -8.59297872e-01f, 1.23618886e-01f, -2.26334274e-01f, -1.50945246e-01f, -7.80334324e-02f, 2.12901577e-01f, 1.94947690e-01f, 9.63960309e-03f,
  1.09208683e-02f, 4.35126096e-01f, 3.06180865e-01f, 2.43527889e-02f, 2.14906007e-01f, -3.93954724e-01f, -5.01014590e-01f, -2.28000656e-01f, 1.44434243e-01f, 2.06199765e-01f,
  1.80660650e-01f, 1.91033125e-01f, 2.66105890e-01f, 2.13624924e-01f, -2.50806566e-02f, 1.93917707e-01f, -3.38660896e-01f, -2.38253623e-01f, -3.24051857e-01f, -7.59769022e-01f,
  -1.26292586e-01f, -4.02611196e-01f, -1.09697163e-01f, 6.46100007e-03f, -2.03038990e-01f, 3.22837271e-02f, 6.80639967e-02f, -2.29586899e-01f, -4.32959422e-02f, -1.40554339e-01f,
  -1.67378202e-01f, -1.59022976e-02f, -1.14299782e-01f, -5.23521788e-02f, -4.33260538e-02f, -5.83994482e-03f, -9.38284472e-02f, -1.73425540e-01f, -6.65707663e-02f, -2.75976323e-02f,
  -1.66922435e-02f, -3.45647603e-01f, -3.11202735e-01f, -2.07188100e-01f, -1.73506767e-01f, -1.78047329e-01f, -3.48080188e-01f, -2.04702407e-01f, -1.45667732e-01f, -3.16581994e-01f,
  5.37439100e-02f, 5.53778373e-03f, -5.18023521e-02f, -1.07422590e-01f, 2.52548844e-01f, 2.93265213e-04f, -4.99822907e-02f, 3.53217684e-02f, 9.79572684e-02f, 9.03143361e-03f,
  -3.73562127e-02f, -3.19974907e-02f, -3.54434028e-02f, 9.36707035e-02f, 1.01535365e-01f, -1.01679623e-01f, -7.51996562e-02f, 3.83681767e-02f, -2.02134475e-02f, -1.27103804e-02f,
  -1.60762630e-02f, -1.32350642e-02f, -1.84749514e-02f, -8.52529928e-02f, -9.20740217e-02f, -1.67624637e-01f, 5.29511273e-02f, 1.30538806e-01f, 1.58208922e-01f, 2.25061574e-03f,
  5.23087978e-01f, -1.73484415e-01f, 1.76092893e-01f, 9.80928093e-02f, -1.81910530e-01f, 1.39997318e-01f, -1.13501213e-02f, -1.20523058e-01f, -4.66497652e-02f, 2.01285109e-01f,
  -1.13338521e-02f, 1.48210377e-01f, 5.43510914e-02f, -1.72170117e-01f, 8.17514136e-02f, 1.15285277e-01f, 4.02910002e-02f, 6.33323565e-02f, -8.80827941e-03f, -3.17695038e-03f,
  8.95795040e-03f, 6.74317256e-02f, 2.33763233e-01f, -8.22549835e-02f, 1.26006361e-02f, 1.30146921e-01f, 1.16413124e-01f, 7.56225884e-02f, 1.35213763e-01f, 4.36447203e-01f,
  9.74567056e-01f, -6.13471508e-01f, -7.68078744e-01f, 1.86211422e-01f, -3.76861125e-01f, -4.89723355e-01f, -8.68447006e-01f, -2.76682109e-01f, 1.03435688e-01f, -5.21904409e-01f,
  -2.81731486e-01f, 4.69575584e-01f, 2.39557415e-01f, -1.16058383e-02f, 2.46314391e-01f, -6.11529946e-01f, -4.75222558e-01f, 1.39233544e-01f, 3.64265352e-01f, -1.27475858e-01f,
  -2.14794546e-01f, 8.94996524e-02f, 4.23927873e-01f, 2.10554674e-01f, -3.47497463e-01f, 2.00656559e-02f, -4.63447273e-01f, -1.91343799e-01f, -2.58348495e-01f, -5.39198220e-01f,
  -3.66586417e-01f, -1.54441327e-01f, -8.30900371e-02f, 2.54627377e-01f, -9.42386016e-02f, 1.71020955e-01f, -8.42040032e-02f, 2.35013440e-02f, 9.51779634e-02f, -4.75797355e-02f,
  2.99249170e-03f, 1.07163318e-01f, 1.96417749e-01f, -1.59627929e-01f, -8.70609432e-02f, -6.30024001e-02f, -2.06236988e-02f, 6.08182400e-02f, -4.11112383e-02f, -1.97666332e-01f,
  -1.45645395e-01f, -3.70685533e-02f, 1.33360058e-01f, -9.32061449e-02f, -1.07270330e-01f, 1.95654497e-01f, -3.15116405e-01f, -1.85546920e-01f, -8.04489851e-02f, -2.62723446e-01f,
  -1.95070505e-01f, -7.31786489e-02f, 1.09859761e-02f, 5.27515151e-02f, 4.48792391e-02f, 4.77835126e-02f, 8.92635286e-02f, 8.54148343e-02f, -3.05063203e-02f, 4.74084169e-02f,
  -3.62085290e-02f, 3.22987214e-02f, 1.16100863e-01f, -8.15120265e-02f, 3.50931054e-03f, -1.54623138e-02f, -7.04234540e-02f, -3.16427238e-02f, -1.96024049e-02f, 7.31963962e-02f,
  1.28490388e-01f, -1.72361992e-02f, -4.44980673e-02f, 4.41425331e-02f, 7.17235431e-02f, 8.64212066e-02f, -7.56334439e-02f, -1.52582815e-02f, 1.11081162e-02f, -6.89429343e-02f,
  1.91183779e-02f, 1.31896317e-01f, -1.33123145e-01f, -1.02992542e-02f, -3.04252026e-03f, 4.44588512e-02f, -1.07944690e-01f, -2.59842966e-02f, 2.08397135e-01f, -4.35230415e-03f,
  -2.12347899e-02f, 1.28495976e-01f, 1.20076910e-01f, -6.23088889e-02f, -7.13289604e-02f, -1.93611495e-02f, 1.21734612e-01f, 1.03687927e-01f, 1.13659471e-01f, -1.33837074e-01f,
  3.33355330e-02f, 1.15754038e-01f, 2.12880641e-01f, 1.73228651e-01f, -1.24179618e-02f, 3.20380777e-01f, -7.35591352e-02f, 3.75229456e-02f, 1.48191333e-01f, -8.38708058e-02f,
  8.41010869e-01f, 3.96945000e-01f, 3.81329417e-01f, 2.90604115e-01f, 1.32612780e-01f, 2.64053524e-01f, 1.82734594e-01f, 2.98662838e-02f, -1.63332168e-02f, 9.94737670e-02f,
  1.62809864e-01f, 7.52371103e-02f, 5.15800267e-02f, 6.51509389e-02f, 4.53573056e-02f, 1.64355025e-01f, 6.18827306e-02f, 1.25909552e-01f, 1.15931459e-01f, 2.29920372e-01f,
  1.22627400e-01f, 1.85874879e-01f, 1.78908482e-01f, 1.49049401e-01f, 7.60416314e-02f, -4.48320433e-02f, 5.03832512e-02f, 1.95409670e-01f, 2.52290964e-01f, 2.58848041e-01f,
  1.49018452e-01f, 3.51689756e-01f, -2.49450162e-01f, -1.55192003e-01f, -2.11247765e-02f, -1.38153821e-01f, -1.35761857e-01f, -1.58006161e-01f, -1.37468994e-01f, -1.71006862e-02f,
  -7.65836760e-02f, -1.84566807e-02f, 3.89067717e-02f, -4.05393355e-02f, -8.32001194e-02f, -7.96817020e-02f, -3.60993445e-02f, 1.45898527e-02f, -1.31013706e-01f, 2.74502747e-02f,
  1.46063725e-02f, 9.70371217e-02f, 4.32572216e-02f, -1.73762143e-01f, 1.00697182e-01f, -1.42221823e-01f, 1.08791664e-01f, 5.19110672e-02f, 2.21301522e-02f, 8.94216076e-03f,
  -1.29603922e-01f, 1.46020263e-01f, 2.19130635e-01f, 1.08316243e-01f, 2.96244562e-01f, 8.71644020e-02f, 1.38693145e-02f, 7.58847520e-02f, 1.41521603e-01f, 1.46668360e-01f,
  -3.64769809e-02f, 7.22024366e-02f, 6.08240301e-03f, 3.91716212e-02f, 2.72450447e-02f, -5.74585050e-02f, -5.91162033e-02f, -1.39891401e-01f, -4.55525927e-02f, -8.11658353e-02f,
  2.29808018e-02f, -7.69326910e-02f, -9.53843594e-02f, -1.15739048e-01f, -1.91318527e-01f, -5.51263709e-03f, -1.49013801e-02f, -1.21212117e-01f, -1.24880269e-01f, -1.18429631e-01f,
  -7.00609922e-01f, -8.59514438e-03f, -9.57091749e-02f, -6.97817579e-02f, 1.42777249e-01f, -5.69553412e-02f, 2.07949281e-01f, -8.73060897e-02f, -9.63286832e-02f, -8.55839327e-02f,
  1.05395228e-01f, 3.55506204e-02f, 1.37698099e-01f, 2.13454776e-02f, 1.21822376e-02f, -9.69866291e-02f, -5.21680638e-02f, -1.21697463e-01f, -6.03527948e-02f, -4.10928205e-02f,
  -2.01291461e-02f, -2.41108626e-01f, -1.58186689e-01f, -1.18425876e-01f, -1.03380978e-01f, -3.23522389e-01f, -9.79338139e-02f, -1.36827469e-01f, -2.03693643e-01f, -1.79917440e-01f,
  -6.24968529e-01f, 5.14466584e-01f, 5.26166633e-02f, -7.92116225e-02f, 4.48380589e-01f, 2.42108256e-01f, 2.22169727e-01f, -5.25975972e-02f, -1.03988138e-03f, 1.30257055e-01f,
  2.64819246e-02f, -6.44627288e-02f, 3.61573994e-02f, 1.48943365e-01f, -4.51935008e-02f, 1.87111840e-01f, 3.09130967e-01f, -5.03090722e-03f, -4.30542320e-01f, -2.01112762e-01f,
  2.58731991e-01f, -1.57370031e-01f, -4.02667165e-01f, -1.30566478e-01f, 1.52119130e-01f, 9.90624800e-02f, 9.00387242e-02f, 6.57437965e-02f, 3.19862515e-01f, 4.37899113e-01f,
  -2.89838284e-01f, -2.39365652e-01f, -9.61453617e-02f, -2.18432732e-02f, 3.48263457e-02f, -2.49299556e-01f, -6.78600669e-02f, -7.87323788e-02f, -4.14220467e-02f, -1.89534500e-01f,
  1.65303394e-01f, -5.45796268e-02f, 2.05421880e-01f, -5.88825867e-02f, -3.38850439e-01f, -2.76637048e-01f, -2.54816592e-01f, -4.08138543e-01f, -3.47361177e-01f, -3.27344477e-01f,
  6.01331592e-01f, 7.59521052e-02f, -4.36031550e-01f, -8.15232024e-02f, -2.26751298e-01f, -1.61045998e-01f, -2.66334891e-01f, -3.35922748e-01f, -3.15886110e-01f, -3.27855170e-01f,
  -6.10466748e-02f, -4.54865918e-02f, 1.79118827e-01f, 8.43265280e-02f, -6.24444559e-02f, -6.02241829e-02f, 2.01269135e-01f, 6.52131662e-02f, 3.59130166e-02f, -1.06176101e-01f,
  1.85671449e-02f, -1.48994699e-01f, -2.68665820e-01f, -3.16233039e-02f, 1.75340310e-01f, -4.15480882e-02f, 6.87469542e-02f, -8.47255811e-02f, -2.01944578e-02f, -7.26447580e-03f,
  4.25120294e-02f, -1.23997658e-01f, -7.55602643e-02f, -2.04328492e-01f, -2.52370555e-02f, -4.13107015e-02f, -6.12062737e-02f, -3.86649556e-02f, -4.94038053e-02f, -1.44708352e-02f,
  -4.38960224e-01f, 2.20162198e-01f, -2.58126020e-01f, -1.72516227e-01f, 3.58317718e-02f, -3.73896323e-02f, 4.36571091e-02f, 3.10124997e-02f, 3.11707743e-02f, -2.79749840e-01f,
  -1.28094912e-01f, -1.44766912e-01f, 1.04212001e-01f, -1.71937436e-01f, -3.68685752e-01f, -5.08443378e-02f, 2.68652380e-01f, -3.70564125e-02f, -4.87783290e-02f, -1.41366467e-01f,
  2.52186447e-01f, -3.30252379e-01f, -5.13283193e-01f, -1.89150721e-01f, -5.31549975e-02f, -4.54159260e-01f, -2.81769007e-01f, -2.76955575e-01f, -3.18273932e-01f, -4.25307006e-01f,
  -1.72918722e-01f, 2.16582790e-01f, -6.49976581e-02f, 2.25918591e-02f, 1.44875497e-01f, 2.29709707e-02f, 1.68011412e-01f, -1.20765053e-01f, -9.46904942e-02f, 1.76399559e-01f,
  -5.20508625e-02f, -2.09180549e-01f, -2.40396783e-01f, -3.00417602e-01f, -4.10862416e-01f, 1.66591909e-02f, 7.55749363e-03f, -2.33798489e-01f, -8.89996886e-02f, 9.32500735e-02f,
  3.23165208e-01f, 4.77380276e-01f, 6.47427440e-02f, 1.13115767e-02f, 1.02119684e-01f, 1.40281975e-01f, 2.14929461e-01f, -2.15336200e-04f, -1.68943442e-02f, 1.60076961e-01f,
  -1.39517605e-01f, -3.25797975e-01f, -9.08080414e-02f, -7.29424506e-02f, 1.99600291e-02f, -1.04653761e-01f, -3.83642167e-02f, -1.37569785e-01f, -1.58577159e-01f, -1.84283443e-02f,
  -7.40732625e-02f, -9.73018184e-02f, -3.07971656e-01f, -5.81774898e-02f, -6.32074550e-02f, -1.34933209e-02f, 1.82740673e-01f, -1.88705221e-01f, -2.64228970e-01f, -1.43902808e-01f,
  -7.49257430e-02f, -2.19803061e-02f, -3.19794193e-02f, -8.99777934e-02f, -2.13613495e-01f, -4.73670103e-02f, -3.79826799e-02f, -2.03330711e-01f, -2.07362801e-01f, 1.66551933e-01f,
  1.82891507e-02f, 3.84758711e-02f, 6.21344745e-02f, 2.24561691e-01f, 2.97185630e-01f, 8.52273107e-02f, 3.99834812e-02f, 4.07906882e-02f, -9.63648316e-03f, 1.87582269e-01f,
  1.53375268e-02f, 1.07865632e-01f, -6.76155239e-02f, -1.84398413e-01f, -1.15290843e-01f, -1.35344729e-01f, -1.10871717e-01f, 9.26434100e-02f, -1.34698106e-02f, 2.26469096e-02f,
  -3.09213493e-02f, -1.58096790e-01f, -3.63716930e-02f, -4.13193338e-04f, -1.17359810e-01f, -3.29950973e-02f, -2.93261893e-02f, -7.97332227e-02f, 4.14589792e-02f, 1.51667725e-02f,
  2.94003695e-01f, -2.93823868e-01f, -3.23762856e-02f, 5.99669069e-02f, -3.34334224e-02f, -1.11635484e-01f, -2.20789220e-02f, -6.01451704e-03f, -1.52514920e-01f, -8.16740021e-02f,
  -1.86267450e-01f, -1.73140526e-01f, 2.23138127e-02f, -6.69295490e-02f, 4.96942140e-02f, 3.02234776e-02f, 1.22309737e-01f, 8.70792046e-02f, 1.57343317e-02f, 2.68046670e-02f,
  7.65483528e-02f, 2.89523840e-01f, 2.70188510e-01f, 1.92458048e-01f, -3.21111754e-02f, 1.64432958e-01f, 2.34712586e-01f, 2.34077811e-01f, 1.24653243e-01f, 6.16421223e-01f,
  -5.67985833e-01f, -4.92867649e-01f, 2.01694593e-01f, -2.75537726e-02f, 1.74813554e-01f, -4.62211281e-01f, -8.15266490e-01f, -7.06099033e-01f, -1.47637427e-01f, -2.01039493e-01f,
  8.76388699e-02f, 1.99554473e-01f, 1.10255353e-01f, 9.91071463e-02f, -3.70337814e-01f, -1.51746199e-01f, 7.34787285e-02f, 2.01042533e-01f, -8.17708895e-02f, -2.01896906e-01f,
  1.75169244e-01f, 1.50857970e-01f, 2.05274686e-01f, 1.14505515e-01f, 2.64540344e-01f, 3.66441831e-02f, 2.29798347e-01f, 3.76728922e-01f, 1.10702030e-01f, 3.38562995e-01f,
  2.33924910e-01f, -2.20126584e-01f, 1.24288529e-01f, 2.27056697e-01f, 4.01139498e-01f, -1.48049042e-01f, -8.78595039e-02f, 1.84330478e-01f, -1.50437457e-02f, -1.16992518e-02f,
  3.28531384e-01f, -5.37504070e-02f, 1.92081392e-01f, 4.78442721e-02f, 1.12956293e-01f, -2.42713064e-01f, -1.36441039e-02f, -5.71621284e-02f, -4.25424911e-02f, -1.67662472e-01f,
  2.85977960e-01f, 1.42876446e-01f, -2.58592874e-01f, -3.02204132e-01f, -1.71691835e-01f, 2.31646746e-01f, -1.98017940e-01f, -7.92872533e-02f, -4.24827844e-01f, -3.53948683e-01f,
  -1.32522449e-01f, 1.66598797e-01f, -8.82990956e-02f, -9.80430394e-02f, -1.80342793e-01f, -3.57514666e-03f, 1.99002132e-01f, 4.96358797e-02f, 5.60117662e-02f, -8.88173729e-02f,
  3.08355428e-02f, -2.53082011e-02f, 1.90817546e-02f, 6.04452379e-02f, 2.39499152e-01f, 3.22836824e-03f, -2.61022095e-02f, -1.51639909e-01f, 6.64338842e-02f, 4.46011610e-02f,
  8.54889303e-02f, 2.78346892e-02f, 2.53435791e-01f, -1.59695938e-01f, -2.19311282e-01f, -1.03204453e-03f, 9.64256702e-04f, -1.21480718e-01f, -8.72267485e-02f, -2.40002237e-02f,
  -7.74474591e-02f, 2.09258914e-01f, -1.69000328e-01f, -1.44018680e-01f, 3.89354378e-02f, 1.58208743e-01f, 1.15339033e-01f, 8.17864668e-03f, 4.52448800e-02f, -2.10263357e-01f,
  -1.17955871e-01f, -5.36098294e-02f, 1.48793235e-01f, -1.86707731e-02f, -3.85033898e-02f, -1.55054793e-01f, -1.02094121e-01f, -7.04612359e-02f, 1.78506803e-02f, 1.06294088e-01f,
  -1.88619383e-02f, -3.50574553e-01f, -3.96387339e-01f, -3.62393916e-01f, 4.46660183e-02f, -2.14096919e-01f, -7.29652867e-02f, -1.50465772e-01f, -4.00088996e-01f, -6.59776926e-01f,
  8.61952066e-01f, 3.18735331e-01f, 6.87868893e-02f, 1.86102942e-01f, -2.18112648e-01f, -3.20045173e-01f, -3.34148467e-01f, -1.49108842e-01f, 1.55547678e-01f, 9.44811702e-02f,
  1.25802934e-01f, 9.56523865e-02f, 6.21520355e-02f, 2.08140425e-02f, 4.74754162e-02f, -8.84916633e-02f, -8.97921175e-02f, -2.48693079e-02f, -1.41142653e-02f, -7.38926902e-02f,
  3.67664620e-02f, 1.31786525e-01f, 2.53153592e-01f, 1.60587907e-01f, 1.76431641e-01f, 8.57620910e-02f, 9.61308032e-02f, 7.92436227e-02f, 1.34248644e-01f, 4.99688357e-01f,
  1.03914276e-01f, 3.03184450e-01f, -1.25189856e-01f, 1.09906107e-01f, 3.76008488e-02f, 1.44182116e-01f, -3.31911705e-02f, 1.31816357e-01f, 5.33186598e-03f, -3.51138711e-02f,
  -1.42887169e-02f, 1.41125381e-01f, -1.18255533e-01f, 2.16662660e-02f, -1.11330442e-01f, -1.32729858e-01f, -1.65162496e-02f, 3.52397040e-02f, -1.87984586e-01f, -7.25672022e-02f,
  -1.05344690e-01f, -8.48170295e-02f, -3.54093075e-01f, -3.93746883e-01f, -1.09780543e-01f, -2.00859085e-01f, -1.83396012e-01f, -4.54131402e-02f, -9.36113298e-02f, 1.74578801e-01f,
  -5.79804517e-02f, 6.21225052e-02f, -1.70559540e-01f, -1.93474233e-01f, -1.49215862e-01f, -4.52214181e-02f, -2.11407036e-01f, -1.33410528e-01f, -1.49429336e-01f, -1.99390743e-02f,
  -1.40488490e-01f, -1.64278507e-01f, -3.68505120e-02f, -1.13468103e-01f, -1.25056863e-01f, -9.47962031e-02f, -8.14891607e-02f, -4.76327054e-02f, -2.67997712e-01f, 1.44572463e-02f,
  -2.55228560e-02f, -2.77541275e-03f, 9.03745070e-02f, -9.28499848e-02f, 6.61857650e-02f, -4.44756486e-02f, -7.40648285e-02f, -3.58432275e-03f, 7.47730657e-02f, 2.02349484e-01f,
  -1.94605350e-01f, -5.22949219e-01f, 1.15728810e-01f, 2.59497166e-01f, 1.67071968e-01f, 1.98201090e-01f, 1.94424279e-02f, 1.96571480e-02f, -9.01253000e-02f, -4.85501401e-02f,
  5.31313121e-02f, 1.44939214e-01f, 1.45237269e-02f, 3.10700219e-02f, 2.34337617e-02f, 1.57254245e-02f, 1.18278019e-01f, -1.29739486e-03f, -1.10283727e-02f, 1.07548900e-01f,
  3.67535613e-02f, -1.00638106e-01f, -2.19929948e-01f, -2.21395209e-01f, -1.56731941e-02f, -9.86904502e-02f, -2.22390648e-02f, 2.84736417e-02f, -1.20726965e-01f, -7.81638827e-03f,
  -7.96094596e-01f, 2.64901406e-04f, 4.50706892e-02f, 1.16159834e-01f, 2.87491590e-01f, -2.23917305e-01f, -3.48046035e-01f, -6.30227268e-01f, -2.92785555e-01f, 1.48888916e-01f,
  1.98294774e-01f, 2.19409540e-01f, 8.15029368e-02f, 8.48307181e-03f, -3.51607203e-01f, -1.56011164e-01f, -7.51830414e-02f, -1.50868714e-01f, -2.78705746e-01f, 8.58815238e-02f,
  2.99342334e-01f, 7.72143751e-02f, -1.26428172e-01f, -1.15940422e-01f, 2.20355257e-01f, 2.80775875e-01f, 2.06626222e-01f, 2.39883363e-01f, 2.46540070e-01f, 4.51373369e-01f,
  5.39360106e-01f, -1.41091928e-01f, -1.04500465e-01f, 5.20416023e-03f, -4.76310886e-02f, -1.11791447e-01f, -7.21177831e-02f, -2.03029975e-01f, -1.66361511e-01f, -1.48414195e-01f,
  -5.32516278e-02f, 1.19808242e-02f, -5.38908727e-02f, 8.31620842e-02f, 8.76350794e-03f, 2.11065803e-02f, 3.86029780e-02f, -6.11112528e-02f, -3.25071849e-02f, 3.24180014e-02f,
  2.16124579e-01f, 2.21210778e-01f, -8.34730417e-02f, -1.67132422e-01f, -1.86491489e-01f, -8.40403363e-02f, 3.19402181e-02f, -1.95202559e-01f, -1.42065197e-01f, 1.58475935e-02f,
  -1.47180825e-01f, -4.22465019e-02f, 8.69426355e-02f, 1.06376715e-01f, 5.93273751e-02f, -8.86351918e-04f, 1.33460388e-02f, -2.39301920e-02f, -1.30969390e-01f, 2.19908822e-02f,
  -1.57442223e-02f, -1.97984139e-03f, -6.74139932e-02f, 2.16865614e-02f, 3.05777751e-02f, -1.03550769e-01f, -1.03544727e-01f, -6.83374517e-03f, 5.88124134e-02f, -6.98190182e-02f,
  -3.69962119e-02f, -1.44200856e-02f, 1.13036409e-01f, -7.99615458e-02f, 1.51095733e-01f, -3.90799269e-02f, -3.75335030e-02f, 2.90956832e-02f, -4.38800976e-02f, -1.14876721e-02f,
  3.40673357e-01f, -1.71972409e-01f, 1.59756348e-01f, -1.34185046e-01f, 1.21749965e-02f, 1.33070238e-02f, 4.07807156e-03f, -3.08494251e-02f, 1.07912356e-02f, -1.03610292e-01f,
  -1.43559501e-01f, -1.64111644e-01f, 5.66032305e-02f, 9.26356539e-02f, 6.81053177e-02f, 1.06878243e-01f, 8.17163754e-03f, 7.56229088e-02f, 1.04693189e-01f, 3.15165371e-02f,
  -9.21588615e-02f, -5.22496030e-02f, 7.22400323e-02f, 4.02228534e-02f, 4.13201153e-02f, 8.66857246e-02f, 1.54798076e-01f, 7.04769343e-02f, 5.57533167e-02f, 9.65179503e-02f,
  -4.14795041e-01f, -6.30035818e-01f, -7.41693452e-02f, -2.36321062e-01f, -1.14257842e-01f, -2.27735728e-01f, -5.51329255e-01f, -1.98369429e-01f, -1.13420263e-01f, -5.14758706e-01f,
  -1.50749639e-01f, 1.77296549e-01f, -1.90905690e-01f, -7.39524215e-02f, -2.12899953e-01f, -5.92582762e-01f, -4.24690664e-01f, 4.51110527e-02f, 2.83747256e-01f, 1.50744602e-01f,
  -1.44376948e-01f, -1.24211095e-01f, 1.91506952e-01f, 7.71319941e-02f, -4.19432193e-01f, -3.04159783e-02f, -2.17021570e-01f, -1.35070473e-01f, -2.14942113e-01f, -4.51551884e-01f,
  -2.17136979e-01f, -1.30933225e-01f, 2.10074037e-01f, 1.33355677e-01f, -4.82444279e-02f, 2.03227818e-01f, 7.49573186e-02f, 2.51364987e-02f, 1.47006080e-01f, -1.64397836e-01f,
  2.03652158e-02f, 2.03297406e-01f, 4.28803265e-02f, 1.44359320e-01f, 4.09838697e-03f, 3.89443114e-02f, 8.37870166e-02f, 1.31944856e-02f, -1.51960015e-01f, -9.63362977e-02f,
  -2.11315706e-01f, -8.56382400e-02f, -1.04536675e-01f, 3.77832465e-02f, -5.78615591e-02f, 1.09805547e-01f, -1.26634436e-02f, -8.70288629e-03f, -4.44645174e-02f, -4.40090656e-01f,
  -1.00562014e-01f, -2.68308334e-02f, 7.09910169e-02f, 3.18185054e-02f, 6.83150291e-02f, 5.00933826e-02f, 2.15573367e-02f, -6.73033483e-03f, 4.39089574e-02f, 1.09261163e-02f,
  -1.46436403e-02f, -1.44421279e-01f, 3.60965468e-02f, -9.15214941e-02f, -1.36754969e-02f, -6.70153722e-02f, -1.71636209e-01f, -4.60341163e-02f, -5.75477304e-03f, 3.88328582e-02f,
  -5.08604720e-02f, -1.36264898e-02f, 1.18399421e-02f, -2.85612661e-02f, -3.65205742e-02f, -4.00558226e-02f, 4.12452128e-03f, 1.41777948e-01f, -5.90933785e-02f, 7.52369016e-02f,
  -3.41459066e-02f, 2.78363198e-01f, -3.45463842e-01f, -5.73490672e-02f, -4.65707593e-02f, -7.08440319e-02f, 6.66868761e-02f, 2.48422965e-01f, 8.90430138e-02f, -9.44295004e-02f,
  1.96462753e-03f, -6.46155253e-02f, 3.10868919e-02f, -4.27861512e-03f, 2.93709431e-02f, 5.43822497e-02f, -8.49160925e-02f, -9.98985544e-02f, 5.83635755e-02f, -1.10341422e-01f,
  -8.93216953e-02f, -2.38185078e-01f, -2.27805957e-01f, -1.68365985e-01f, -1.26151294e-01f, 4.17056344e-02f, -1.05314799e-01f, -2.18295559e-01f, -1.97938338e-01f, -4.77952451e-01f,
  7.91016817e-01f, 1.43800557e-01f, 1.23031221e-01f, 3.00094336e-01f, -7.38312304e-01f, -6.92601621e-01f, -6.29430711e-01f, -1.49226725e-01f, -2.59000845e-02f, -1.56115174e-01f,
  -6.18589640e-01f, -3.68428737e-01f, -2.55024713e-02f, -6.20194301e-02f, 1.19980313e-01f, 1.06519736e-01f, 2.10448667e-01f, 3.86823833e-01f, -6.46092221e-02f, -4.39805478e-01f,
  -2.71728545e-01f, 3.05974513e-01f, 4.97802705e-01f, 2.05218524e-01f, -9.99761559e-03f, -1.07478939e-01f, 2.28628665e-01f, 1.06303819e-01f, -5.90804629e-02f, 3.58648360e-01f,
  -1.57468423e-01f, -2.88918968e-02f, -1.75744683e-01f, -1.39812261e-01f, -2.22419932e-01f, 1.01573728e-01f, -1.57006025e-01f, 2.07265496e-01f, -1.00205511e-01f, -3.44287343e-02f,
  -2.92045683e-01f, -2.18546063e-01f, -7.55977035e-02f, -1.09053195e-01f, -1.99302360e-01f, -1.45579025e-01f, 2.70256519e-01f, 3.53164971e-01f, 3.08559686e-01f, -6.87820539e-02f,
  -2.18607336e-01f, -4.35802013e-01f, -1.71415180e-01f, -1.45617336e-01f, -3.13233323e-02f, -9.51013863e-02f, -1.23868465e-01f, -1.11438878e-01f, -1.10044971e-01f, 3.78019512e-01f,
  -6.57743961e-02f, -9.44216549e-02f, -2.93207280e-02f, 3.27182412e-02f, 2.14748442e-01f, -5.11611812e-02f, 6.88309744e-02f, -1.19014777e-01f, -8.99709016e-02f, -3.87469716e-02f,
  5.39224036e-03f, 1.11507505e-01f, 5.39147295e-02f, 3.60261425e-02f, -1.18902445e-01f, -2.32224092e-02f, -6.38885498e-02f, 9.84901115e-02f, 1.20660655e-01f, 2.60536429e-02f,
  7.94195458e-02f, -9.97313038e-02f, 3.74410972e-02f, 6.50785491e-02f, -3.40077281e-02f, 2.74329223e-02f, 9.12937596e-02f, -1.67219862e-02f, 1.39733955e-01f, -3.40339355e-02f,
  1.00928813e-01f, -2.36360535e-01f, -8.99370611e-02f, -8.05452168e-02f, -8.82070139e-02f, -3.45807299e-02f, -1.08863086e-01f, -7.19010606e-02f, -2.94278301e-02f, 2.42896918e-02f,
  -2.95308024e-01f, -8.14582780e-02f, 1.28625810e-01f, -1.05384760e-01f, -1.15476482e-01f, -1.13653064e-01f, 4.21016961e-02f, -1.79763958e-01f, -1.14940936e-02f, -1.56367525e-01f,
  2.57883638e-01f, -1.85175791e-01f, 2.33602654e-02f, -1.19006842e-01f, -1.49562106e-01f, -1.58557370e-01f, -8.43958557e-02f, -1.62254289e-01f, -1.91191748e-01f, 2.50281781e-01f,
  6.86441541e-01f, -1.40454665e-01f, 2.60023624e-01f, 8.85064974e-02f, -7.83918202e-02f, 3.98982652e-02f, 3.67237516e-02f, -1.93489417e-02f, 6.03584684e-02f, 7.97065422e-02f,
  6.52984306e-02f, 2.66816411e-02f, 2.19315588e-01f, 2.11059779e-01f, 1.50191829e-01f, 1.06365522e-02f, 7.60089606e-02f, 2.99457133e-01f, 2.15948492e-01f, 1.29392475e-01f,
  9.88741219e-03f, 7.68300965e-02f, 2.12173760e-01f, 1.79188609e-01f, -6.51178956e-02f, 8.71150047e-02f, -8.16998556e-02f, -2.87808124e-02f, -5.83398305e-02f, -1.11426316e-01f,
  -5.94496354e-02f, 1.30408639e-02f, 1.44835234e-01f, -5.36605828e-02f, -1.11158215e-01f, -2.60443259e-02f, 4.88616973e-02f, -1.06228113e-01f, -1.66266784e-01f, -2.77267456e-01f,
  -8.04584920e-02f, -2.29454860e-02f, -8.59283581e-02f, -7.15434179e-02f, -1.34848982e-01f, -6.06219983e-03f, -8.17683190e-02f, -8.22864771e-02f, 3.02436948e-03f, -2.20465716e-02f,
  -8.55825692e-02f, -1.15398787e-01f, -1.58220738e-01f, 5.04855067e-02f, 1.56493261e-01f, 1.11931786e-01f, -7.57301301e-02f, 7.43955076e-02f, 3.39842997e-02f, 9.77556705e-02f,
  1.88889325e-01f, 1.92535788e-01f, 1.45484969e-01f, 1.59229040e-01f, 6.87014461e-02f, -1.25378994e-02f, -1.22276535e-02f, -2.59856880e-03f, 2.19607711e-01f, 7.31861666e-02f,
  -1.19562030e-01f, 8.01089332e-02f, 1.96041749e-03f, -4.70346361e-02f, 2.19617248e-01f, -4.73550484e-02f, -9.22663882e-02f, 1.94106682e-03f, 1.27345473e-02f, -1.22900419e-01f,
  6.80439398e-02f, -5.28316721e-02f, -6.51400760e-02f, -3.64720635e-02f, -1.23996012e-01f, -1.10453814e-02f, -4.72964756e-02f, -6.48840740e-02f, -4.74335067e-03f, -5.17672077e-02f,
  -3.18596363e-01f, 3.83885145e-01f, 2.22878978e-01f, -3.78875732e-02f, 2.30880659e-02f, 1.28902663e-02f, 1.24168500e-01f, -1.07267432e-01f, -3.24721336e-01f, -1.73635304e-01f,
  1.65812075e-02f, 5.07178903e-02f, 8.57630000e-02f, 4.20856811e-02f, 6.54027089e-02f, 3.52873765e-02f, 1.09585285e-01f, 1.04225554e-01f, -8.66106618e-03f, -1.29349798e-01f,
  3.76723260e-02f, 5.80710247e-02f, -5.85157471e-03f, 8.07604641e-02f, 1.12925433e-01f, 4.92998771e-02f, -1.54432002e-02f, 6.22136556e-02f, -6.62746653e-03f, 1.46910816e-01f,
  -3.43506455e-01f, -3.10967654e-01f, 2.30002269e-01f, 4.62838322e-01f, 3.70470583e-01f, 3.57109398e-01f, 2.74171144e-01f, 2.36139134e-01f, 3.40389788e-01f, 4.36087847e-02f,
  -3.64135385e-01f, -1.32921338e-01f, -1.29062921e-01f, -1.47680685e-01f, -3.71233597e-02f, 3.38788241e-01f, 5.13478398e-01f, 1.47458583e-01f, 2.93930382e-01f, 2.86625952e-01f,
  2.75433362e-01f, 5.42545542e-02f, -3.00195701e-02f, 1.57781780e-01f, 1.79339930e-01f, 2.37228259e-01f, 2.18579993e-01f, 1.51611969e-01f, 3.86263579e-02f, 4.66247708e-01f,
  -4.60527986e-02f, -4.22118068e-01f, 1.17649965e-01f, -2.70919621e-01f, -1.94322258e-01f, -7.10696578e-02f, -3.30545194e-02f, 4.86538699e-03f, 5.04949596e-03f, 7.20670223e-02f,
  -1.23087972e-01f, -7.30407387e-02f, -5.33001721e-02f, -3.06067802e-03f, -3.34613845e-02f, -1.55801149e-02f, -1.26679793e-01f, 4.62609828e-02f, 8.21662396e-02f, 2.31027640e-02f,
  -7.20356032e-02f, 8.75162035e-02f, 2.35226363e-01f, -1.49935987e-02f, -5.08624800e-02f, 4.69961623e-03f, -8.32391456e-02f, -1.15193352e-01f, -1.68804044e-03f, -9.10647493e-03f,
  1.10609554e-01f, 1.13648273e-01f, -1.05420440e-01f, -6.37574866e-03f, -1.09493926e-01f, 8.67068488e-03f, 6.76426739e-02f, 4.25501317e-02f, -3.50651122e-03f, -3.87616865e-02f,
  3.27991284e-02f, -8.57411176e-02f, 4.92181480e-02f, 3.76121961e-02f, -1.06989279e-01f, 6.31301552e-02f, 4.64283600e-02f, -5.26818223e-02f, -1.67990506e-01f, -4.51056473e-02f,
  -8.01730901e-02f, 1.68031096e-01f, -4.55673505e-03f, -1.41817018e-01f, -1.72399245e-02f, 4.86418456e-02f, 3.34887691e-02f, -1.73252374e-02f, 1.96573604e-02f, 8.70338529e-02f,
  1.52524605e-01f, -4.59307283e-01f, 1.53168470e-01f, 3.33499461e-02f, 5.50787598e-02f, -2.10675746e-01f, -2.11517423e-01f, -1.37152672e-01f, -8.69266763e-02f, 7.68107548e-02f,
  -1.03740729e-01f, -7.94003010e-02f, -1.26046464e-01f, -3.00576463e-02f, 1.60335124e-01f, -5.83148785e-02f, -1.70067891e-01f, 1.21832192e-01f, 1.37933061e-01f, 5.83026698e-03f,
  4.32010740e-02f, 2.69808471e-01f, 2.38172650e-01f, 1.70140609e-01f, 7.53027126e-02f, 8.49217102e-02f, -2.14144383e-02f, 8.03819820e-02f, 8.20039362e-02f, 1.04357094e-01f,
  5.98610401e-01f, 5.34851968e-01f, 4.19591397e-01f, 6.72150031e-02f, 1.45086691e-01f, 3.11019063e-01f, 5.66581845e-01f, 2.10098565e-01f, -1.84631780e-01f, 1.69817433e-01f,
  5.30195385e-02f, -4.05114800e-01f, -2.80952603e-01f, -3.11783195e-01f, -3.84296440e-02f, 2.00112835e-02f, -2.05390230e-01f, -5.83084710e-02f, -2.82426983e-01f, -1.24210946e-01f,
  -2.15594411e-01f, -4.03327644e-02f, 1.34875655e-01f, -2.28048880e-02f, 9.12214741e-02f, -3.13174397e-01f, 1.20660268e-01f, 3.83529574e-01f, 3.15137267e-01f, 2.70123482e-02f,
  1.30449668e-01f, 5.26509225e-01f, -4.06012326e-01f, -1.95206776e-01f, -8.35517496e-02f, -1.72117427e-01f, -1.31665587e-01f, -1.19449787e-01f, -1.10320605e-01f, -9.05938968e-02f,
  -1.04446903e-01f, -2.41019353e-02f, -9.03051272e-02f, -1.49622038e-02f, 9.75802690e-02f, 1.47816306e-02f, 1.60054490e-02f, 6.96507692e-02f, -4.20125015e-02f, -1.15567252e-01f,
  -1.44193396e-01f, 1.60132170e-01f, 2.88112342e-01f, -4.28984389e-02f, 8.86668712e-02f, -1.49175346e-01f, 2.28973344e-01f, 9.81528983e-02f, 6.69466853e-02f, 1.33116171e-01f,
  -2.99185783e-01f, 7.62491301e-02f, 1.00925773e-01f, -3.68420109e-02f, -4.99163978e-02f, -4.56018671e-02f, -4.77557182e-02f, -1.64704525e-03f, 2.29596421e-02f, 8.03954005e-02f,
  -1.72751188e-01f, -1.08206965e-01f, -1.41625181e-02f, -2.29170006e-02f, -2.59389907e-01f, 1.61712302e-03f, 3.28917280e-02f, 4.23961952e-02f, 4.29321714e-02f, 1.36632100e-01f,
  -2.80477777e-02f, 4.12877351e-02f, 4.51825792e-03f, -7.85789713e-02f, -9.44658294e-02f, 7.71747855e-03f, -1.13705128e-01f, -1.60121799e-01f, 2.66757123e-02f, 5.33516780e-02f,
  -3.14234942e-01f, -1.06638230e-01f, -3.75845164e-01f, 2.35022232e-02f, 1.69502839e-01f, -1.65302064e-02f, -3.76057215e-02f, 2.28319801e-02f, 2.04777673e-01f, -6.46727309e-02f,
  1.53603986e-01f, -6.11716174e-02f, 4.80762459e-02f, -3.39730605e-02f, -1.50525078e-01f, -5.03197871e-02f, -5.03773764e-02f, -9.55202729e-02f, -1.06782079e-01f, -4.23343331e-02f,
  -2.05648199e-01f, -5.42824902e-02f, -2.41578475e-01f, -2.14498505e-01f, -2.09163740e-01f, -5.15809238e-01f, -4.74919006e-02f, -7.30073601e-02f, -8.97892639e-02f, -1.06264323e-01f,
  -2.20356584e-01f, -2.08747294e-02f, -4.64874208e-02f, 3.90248597e-01f, 2.25756302e-01f, 2.98777103e-01f, 2.30893195e-01f, 1.96780786e-01f, 2.58640409e-01f, 2.00806782e-01f,
  1.05564639e-01f, 2.40575269e-01f, 3.56545359e-01f, 2.47577474e-01f, 2.79350191e-01f, 1.94680586e-01f, 3.21791738e-01f, 1.72705650e-01f, 5.80427274e-02f, 1.69089913e-01f,
  2.21976355e-01f, 1.37150049e-01f, -4.04077470e-02f, 5.82650490e-02f, 2.26093858e-01f, 2.81029075e-01f, 2.09208399e-01f, 3.47296968e-02f, 1.20324574e-01f, 1.30844310e-01f,
  -2.77910292e-01f, -2.79046059e-01f, -2.35598888e-02f, 7.15191383e-03f, -1.24471635e-01f, -1.14312083e-01f, -5.64547302e-03f, -1.62922665e-01f, -1.19242206e-01f, -1.28621176e-01f,
  -7.73803145e-02f, -1.21940896e-01f, -2.54862178e-02f, -2.14320973e-01f, -1.84717983e-01f, -1.44976839e-01f, -1.25418589e-01f, -8.94403923e-03f, 4.46983874e-02f, -6.31146505e-02f,
  2.84471195e-02f, -7.92570412e-02f, -9.23971161e-02f, 1.61217321e-02f, 1.18989646e-01f, -3.21547277e-02f, -1.28691569e-01f, -8.22184458e-02f, -1.63486600e-01f, -1.92975298e-01f,
  1.71905607e-01f, -8.45782682e-02f, -7.79489800e-02f, 5.15127182e-02f, 6.59846663e-02f, 1.54117569e-01f, 1.24918774e-01f, 2.72117332e-02f, 1.92772999e-01f, -1.24143638e-01f,
  -9.83388796e-02f, 7.95298964e-02f, -4.20651399e-02f, 1.32227344e-02f, 9.96159315e-02f, -9.58333164e-02f, -2.27675617e-01f, -1.35411859e-01f, 7.51950359e-03f, 4.35380116e-02f,
  2.93107014e-02f, -1.50114626e-01f, -1.39185801e-01f, -1.44328862e-01f, -5.78744374e-02f, -1.08043924e-01f, -3.86096351e-02f, -1.57328084e-01f, -1.07526645e-01f, -3.59762460e-02f,
  2.05052167e-01f, 2.96719104e-01f, 8.83680433e-02f, -5.14239371e-02f, -2.44538128e-01f, -1.58251092e-01f, 8.30304399e-02f, -7.38471672e-02f, -1.68281663e-02f, -1.16764577e-02f,
  -3.61181460e-02f, -2.16078192e-01f, 2.10054740e-02f, -1.29509997e-02f, -1.71667859e-01f, -1.03529647e-01f, -8.06260854e-02f, -4.66073938e-02f, -2.01546270e-02f, -1.49385616e-01f,
  4.55434667e-03f, -1.46104664e-01f, -1.36430338e-01f, 3.06343492e-02f, 1.13362759e-01f, 2.77034100e-02f, -9.47076678e-02f, -9.17038023e-02f, -5.19186817e-02f, -5.33204675e-02f,
  -5.15975893e-01f, -3.43446940e-01f, -2.94996291e-01f, -3.50948602e-01f, 2.29120497e-02f, 7.56176636e-02f, -6.12678565e-02f, -1.61136780e-02f, -1.02115229e-01f, -4.02256370e-01f,
  -1.91063777e-01f, 2.00077891e-01f, -6.25023171e-02f, 3.03772800e-02f, -3.59602422e-02f, -3.46618921e-01f, -1.97416231e-01f, 8.97940099e-02f, 3.42708826e-01f, 5.06429255e-01f,
  1.92560792e-01f, 9.31552872e-02f, -5.81373200e-02f, 1.49648666e-01f, -8.89225826e-02f, 7.22877532e-02f, -1.83237657e-01f, -1.52155146e-01f, 3.65198888e-02f, -1.58255175e-01f,
  -3.98849428e-01f, -3.41836482e-01f, 1.46358177e-01f, 1.09774344e-01f, -1.41604453e-01f, -1.73058540e-01f, -4.07929346e-02f, -1.00626037e-01f, 1.31135598e-01f, -1.00916103e-01f,
  -1.58375949e-01f, 2.38488123e-01f, -8.50124285e-02f, 8.69870633e-02f, 8.03412944e-02f, 2.15069756e-01f, 2.10909322e-02f, -4.21401560e-02f, -1.90710649e-01f, -2.57406645e-02f,
  2.08553761e-01f, -7.47010186e-02f, -2.84789860e-01f, 9.87922307e-03f, -1.36645764e-01f, -3.63929197e-02f, -1.09718338e-01f, 1.09509088e-01f, 2.06433516e-02f, -1.70298561e-01f,
  8.05623829e-02f, 5.29572426e-04f, -4.49767150e-02f, 2.79662479e-02f, 8.74060988e-02f, 8.23398679e-03f, -7.18995091e-03f, 1.86967514e-02f, 2.56658405e-01f, 5.05943373e-02f,
  3.88801359e-02f, 1.96869932e-02f, 5.45766279e-02f, -1.17992111e-01f, 1.06779777e-01f, -7.92702436e-02f, 7.83737972e-02f, -2.91401427e-02f, 2.38689594e-02f, 1.23176798e-01f,
  1.30422771e-01f, 4.41628508e-02f, -7.19826669e-02f, 2.22203225e-01f, 1.37462199e-01f, 9.49168764e-03f, -6.80728331e-02f, -1.38744162e-02f, -7.78670833e-02f, -6.45031631e-02f,
  -2.09422350e-01f, -1.94634926e-02f, -3.27753872e-01f, 1.36144102e-01f, -4.30620983e-02f, 1.59172788e-02f, -1.15611911e-01f, 3.65713164e-02f, -2.02687129e-01f, -3.65555361e-02f,
  6.75444156e-02f, -2.81204563e-02f, -2.45331466e-01f, 1.25989586e-01f, 3.13742422e-02f, 5.23812473e-02f, -1.90315127e-01f, -4.13428396e-02f, 2.63619106e-02f, 7.64004886e-02f,
  -1.49288382e-02f, -9.17105824e-02f, -3.97199154e-01f, -3.36248130e-01f, -1.80444196e-01f, -2.04875678e-01f, -1.32697284e-01f, -8.61341730e-02f, -2.63789266e-01f, -2.32710645e-01f,
  8.40609968e-01f, -6.28404260e-01f, 8.43802933e-03f, 2.20909506e-01f, 1.97160423e-01f, 3.08782279e-01f, 9.10383537e-02f, 1.20115727e-01f, 2.21454531e-01f, -1.41627610e-01f,
  -1.80117548e-01f, -3.69478352e-02f, -1.79665223e-01f, -2.25431383e-01f, -9.11151543e-02f, -1.11858301e-01f, 1.92205030e-02f, 2.51344234e-01f, 3.11823249e-01f, 1.19493462e-01f,
  -9.16486681e-02f, -1.08016126e-01f, 1.10133611e-01f, -1.12733081e-01f, -3.41287881e-01f, -2.26819646e-02f, -2.43069619e-01f, -2.32348859e-01f, -4.23627645e-01f, -3.97157609e-01f,
  -5.88154793e-02f, -8.42227340e-02f, 1.69571340e-01f, -6.18593618e-02f, -1.18853636e-01f, 5.86266480e-02f, 1.02734394e-01f, -7.93884844e-02f, 1.37975847e-03f, 7.53052756e-02f,
  -8.78673568e-02f, -6.49758577e-02f, -1.22959130e-01f, -1.35958105e-01f, 6.80526122e-02f, 6.18243292e-02f, -1.39502764e-01f, -1.12154201e-01f, -1.60388902e-01f, -2.37573937e-01f,
  -3.27253014e-01f, -4.76793833e-02f, 3.86685655e-02f, 3.41039896e-02f, 4.62833643e-02f, 1.18694164e-01f, -1.71535999e-01f, 2.20462885e-02f, -8.70778225e-03f, -5.53661399e-03f,
  -2.39762589e-01f, 6.93509653e-02f, -7.01626167e-02f, 2.34092600e-04f, 3.27221751e-02f, 6.54067323e-02f, 6.51498605e-03f, -1.41804582e-02f, -1.59877837e-02f, 6.17973767e-02f,
  4.85751405e-03f, 1.84391171e-03f, -3.26141119e-02f, 1.04624785e-01f, -1.16091100e-02f, -1.67039096e-01f, 1.46615868e-02f, -1.37527332e-01f, -3.80721018e-02f, 1.11019053e-02f,
  -1.26646504e-01f, -6.42073452e-02f, -6.93383366e-02f, -1.37422800e-01f, -1.54190555e-01f, -3.15794200e-02f, -3.18396166e-02f, -7.05911964e-02f, 3.30052711e-02f, -4.83736657e-02f,
  7.09460163e-03f, -7.91191962e-03f, 9.15036947e-02f, -7.76161328e-02f, 6.38249703e-03f, -1.33417845e-01f, -8.47208872e-02f, -9.79009494e-02f, -9.26251411e-02f, -9.43007767e-02f,
  -8.32483470e-02f, -2.23211907e-02f, -1.42935395e-01f, -1.98088330e-03f, 3.24616492e-01f, 1.09580338e-01f, -8.43737740e-03f, 4.66624908e-02f, -1.10956594e-01f, -1.21545948e-01f,
  -1.07210912e-01f, 1.52415082e-01f, 3.08878869e-01f, 2.93088436e-01f, 1.94279432e-01f, 3.04425776e-01f, 2.20307931e-01f, 1.63814649e-01f, 1.75293922e-01f, 3.59733284e-01f,
  2.48510689e-01f, -1.86646372e-01f, 3.08579028e-01f, 8.43254179e-02f, 2.50663459e-01f, 3.53028119e-01f, 4.11900699e-01f, 1.52124852e-01f, -1.68571308e-01f, 5.91773689e-02f,
  -2.20939785e-01f, -2.00064480e-01f, -2.31347576e-01f, -2.05654562e-01f, -6.41043717e-03f, 1.51912510e-01f, 1.78697370e-02f, 1.37369037e-01f, 1.43960983e-01f, 8.19763318e-02f,
  -5.28842211e-02f, -1.46296639e-02f, -3.50937918e-02f, -6.33576214e-02f, -1.62451833e-01f, -6.57816455e-02f, 2.68257763e-02f, -1.18362792e-02f, -9.23565924e-02f, -1.99404955e-01f,
  1.48298979e-01f, 1.92252621e-02f, -3.11339702e-02f, -3.02528590e-01f, -8.93301964e-02f, -6.66105300e-02f, 2.58917622e-02f, -1.13638900e-02f, -1.00799553e-01f, -1.52290806e-01f,
  -1.17100082e-01f, -1.07059278e-01f, 1.20925434e-01f, -1.16447493e-01f, 1.39955282e-01f, -6.66857511e-03f, -2.03553542e-01f, -9.57771391e-02f, -7.99287632e-02f, -2.33356431e-01f,
  -1.25528872e-01f, 1.49604559e-01f, 2.99101889e-01f, 1.63044184e-01f, 5.96137010e-02f, 4.70592529e-02f, -5.78968786e-02f, -4.74356823e-02f, -7.02093076e-03f, -2.84794066e-02f,
  1.06070571e-01f, 1.71724662e-01f, 1.33185863e-01f, 2.04782307e-01f, 1.96790233e-01f, 2.00891122e-03f, 1.88301429e-01f, 3.13450366e-01f, 3.33139539e-01f, 1.65335849e-01f,
  6.10178150e-02f, 1.79396272e-01f, 2.43179455e-01f, 1.28867581e-01f, 8.21807459e-02f, 1.84959799e-01f, 3.71868968e-01f, 4.24593687e-02f, -5.47068520e-03f, 1.12801157e-02f,
  4.72627766e-02f, 2.92142719e-01f, 7.43700610e-03f, 2.25775734e-01f, 4.52040024e-02f, -1.86431617e-03f, 1.97572812e-01f, 1.23428084e-01f, 1.34678353e-02f, 6.52947230e-03f,
  1.59907699e-01f, 1.90680906e-01f, 6.48664907e-02f, -2.82719821e-01f, -6.16372153e-02f, -2.12555006e-01f, -1.49314672e-01f, -2.32451767e-01f, -7.84705877e-02f, 2.00582743e-02f,
  -1.63718581e-03f, -2.73095928e-02f, 5.07422946e-02f, 3.13497670e-02f, 2.54782856e-01f, 1.10695530e-02f, -1.48191035e-01f, 6.12848550e-02f, -7.92664513e-02f, -3.64998505e-02f,
  -1.04872242e-01f, 6.56876042e-02f, 1.81495026e-01f, 1.55282840e-01f, 4.33007814e-02f, 2.24326894e-01f, 1.61627471e-01f, 1.54694125e-01f, 9.63371098e-02f, 3.05927902e-01f,
  8.91670465e-01f, -1.54908821e-01f, -8.49841982e-02f, 1.88637570e-01f, -1.66627839e-01f, -4.07404602e-01f, -5.47980905e-01f, -1.27240002e-01f, -4.22693640e-02f, 1.11311100e-01f,
  1.84091926e-01f, 1.65994048e-01f, 2.19504625e-01f, 1.76288322e-01f, 1.17521882e-01f, -7.11035505e-02f, -1.38092302e-02f, 1.74307868e-01f, 1.37683988e-01f, 5.21762967e-02f,
  -7.49808475e-02f, 1.17794342e-01f, 2.17507154e-01f, 9.42923948e-02f, 1.26015525e-02f, -2.77635474e-02f, 5.07923365e-02f, -3.45593393e-02f, 6.07619248e-03f, 6.36898577e-02f,
  4.38783020e-01f, 3.02379549e-01f, 4.70661372e-02f, 1.81124955e-01f, 2.83083707e-01f, 1.26429647e-01f, 7.36930817e-02f, 1.51708890e-02f, -1.07139766e-01f, -1.67764910e-02f,
  1.21193223e-01f, 1.99984610e-01f, -2.94931307e-02f, -1.41256163e-02f, 5.03256619e-02f, 6.78986832e-02f, 5.65729290e-02f, -4.27240618e-02f, 5.14707901e-02f, 5.72196953e-02f,
  1.52413081e-02f, 5.14006950e-02f, -1.03808597e-01f, -1.36826083e-01f, -1.93576161e-02f, 9.40766707e-02f, 6.66076392e-02f, 1.31283373e-01f, 4.77833068e-03f, 7.27853552e-02f,
  1.75333694e-01f, 1.52323181e-02f, 1.77693650e-01f, -7.46354386e-02f, 3.87081951e-02f, 1.05293214e-01f, -5.65412128e-03f, -3.96140665e-02f, 8.32861885e-02f, 4.43082899e-02f,
  -3.68828466e-03f, 1.05708644e-01f, -1.12868570e-01f, -2.33645830e-02f, 1.70173764e-01f, 2.11706012e-01f, 6.02241047e-02f, 6.78929389e-02f, 1.89907908e-01f, 2.24266291e-01f,
  7.99732655e-02f, 5.02765812e-02f, 1.43174857e-01f, 3.54239270e-02f, 3.54177468e-02f, 1.11708261e-01f, 1.11640915e-01f, 9.92853642e-02f, 1.55228704e-01f, 1.48462623e-01f,
  -2.10521460e-01f, -1.05809430e-02f, 1.94606587e-01f, 2.14988273e-02f, 2.75166314e-02f, -3.89809199e-02f, -4.10841405e-02f, -3.24018411e-02f, -6.02666140e-02f, -1.72299087e-01f,
  -1.29358560e-01f, -8.67602676e-02f, -1.13751173e-01f, 1.49180964e-02f, -4.83282991e-02f, 2.28633638e-02f, -1.35716703e-03f, -5.37773734e-03f, -9.24675092e-02f, -5.91348186e-02f,
  -1.32291377e-01f, -1.03689916e-01f, -1.38452068e-01f, -1.88044935e-01f, -8.34722593e-02f, -9.50771421e-02f, -1.37400329e-01f, -1.21270910e-01f, -7.58397132e-02f, -2.51478612e-01f,
  -2.30017588e-01f, 7.41061196e-02f, -3.19670647e-01f, 3.45135778e-02f, -1.07962362e-01f, -3.85042727e-01f, -1.94238335e-01f, -3.33100930e-02f, 6.05367720e-02f, 1.15528340e-02f,
  -3.54377106e-02f, -2.11564124e-01f, -1.43047720e-01f, -2.83361822e-01f, -5.34569442e-01f, -4.31173444e-01f, -4.57949549e-01f, -5.58611333e-01f, -6.74821377e-01f, -3.49768579e-01f,
  -2.13812083e-01f, -2.30588228e-01f, -2.38487080e-01f, -6.62057027e-02f, 3.07857245e-01f, 3.14218923e-02f, 9.57893133e-02f, -1.14469454e-01f, 3.60285444e-03f, 1.06175974e-01f,
  -3.83901775e-01f, 2.48374548e-02f, 3.45245712e-02f, 1.23773292e-02f, -2.64466759e-02f, 4.61129546e-02f, -6.35632575e-02f, 1.07623786e-01f, -5.46196885e-02f, -6.11849092e-02f,
  1.22719713e-01f, 2.98714545e-02f, -1.50864258e-01f, -1.08592965e-01f, -2.50972182e-01f, -1.02741703e-01f, -1.37409955e-01f, -2.35744566e-01f, -2.49517351e-01f, -1.11785822e-01f,
  -2.11443573e-01f, -1.96707204e-01f, -8.94974396e-02f, 1.80260375e-01f, -9.60655808e-02f, -1.95790529e-01f, 2.85392832e-02f, 1.39233783e-01f, 2.84323674e-02f, 2.08403036e-01f,
  1.01562582e-01f, 1.68640524e-01f, 1.07430391e-01f, -9.37880799e-02f, -2.52502821e-02f, 8.54201838e-02f, 1.77075043e-01f, 1.16717085e-01f, 2.37247627e-02f, -1.33651465e-01f,
  -1.31343812e-01f, 5.08054569e-02f, -6.60669208e-02f, 7.64421374e-02f, 2.18071882e-02f, 7.09327087e-02f, 8.68821610e-03f, 1.34015173e-01f, 1.61589961e-02f, -1.22317635e-02f,
  9.24780965e-03f, -5.89768589e-02f, -2.38533244e-02f, 8.27042162e-02f, -4.71574515e-02f, -1.61175635e-02f, 6.39654920e-02f, 1.33930321e-03f, -2.02510655e-02f, 2.89208703e-02f,
  -1.61753610e-01f, -2.87093848e-01f, 8.17129165e-02f, 2.05881327e-01f, -3.44378650e-02f, -1.09965086e-01f, 1.05390452e-01f, -7.94489160e-02f, -4.20692489e-02f, -1.31552756e-01f,
  8.53614807e-02f, -3.60584259e-02f, 1.07163275e-02f, 2.05951571e-01f, 6.29590303e-02f, 1.07558884e-01f, 4.29693237e-02f, -9.78542417e-02f, 9.00310650e-02f, 1.69442520e-02f,
  1.38445180e-02f, 3.99209633e-02f, -8.18652585e-02f, -5.13523957e-03f, -1.20488610e-02f, -1.72239438e-01f, -1.29326582e-01f, 1.14727050e-01f, -1.36112675e-01f, 2.47122765e-01f,
  4.44975764e-01f, 1.13784932e-01f, -2.22885907e-01f, 5.22320330e-01f, -1.04160411e-02f, -4.18398261e-01f, -2.38160089e-01f, -1.56450480e-01f, 3.50201845e-01f, 3.47213894e-01f,
  1.53036760e-02f, -2.51868904e-01f, -3.41660753e-02f, -3.41936171e-01f, -5.22810936e-01f, -8.95601958e-02f, 3.00654732e-02f, -4.45941567e-01f, -7.37249970e-01f, -5.41426480e-01f,
  -2.25492179e-01f, 5.12703992e-02f, -8.65260512e-02f, -2.05007046e-02f, 2.63042212e-01f, -1.69537514e-01f, 2.21124440e-01f, -3.97269726e-02f, -2.30358735e-01f, 3.40802163e-01f,
  -3.27659696e-01f, 9.36450288e-02f, -1.96497589e-01f, 8.77277330e-02f, 1.87030673e-01f, -2.61953613e-03f, -1.37573346e-01f, 5.34616895e-02f, 5.82358390e-02f, 1.22650201e-02f,
  -4.54853987e-04f, -3.46572213e-02f, -1.68188244e-01f, 2.21247636e-02f, -3.81078832e-02f, -1.65961191e-01f, -4.00818102e-02f, -1.77352786e-01f, -6.14321865e-02f, 1.08862100e-02f,
  -1.20205373e-01f, -1.17972456e-01f, -3.03252004e-02f, -7.10155219e-02f, -2.44275033e-01f, -1.66583270e-01f, -1.33435696e-01f, -1.00675747e-01f, -3.56679082e-01f, 2.49825433e-01f,
  4.26150560e-02f, 9.43894498e-03f, -8.53136927e-02f, 1.72601733e-02f, 4.20680419e-02f, 1.62640077e-04f, 6.40063137e-02f, -1.29890982e-02f, -1.05029261e-02f, 4.22359146e-02f,
  -3.72871757e-02f, 2.89578773e-02f, -4.89283167e-02f, 5.81285581e-02f, -3.94842885e-02f, 7.54980091e-03f, 6.77903518e-02f, 5.20749539e-02f, -7.97774941e-02f, 6.57832250e-04f,
  -3.27231525e-03f, 7.53506348e-02f, 1.97984293e-01f, -7.28446469e-02f, -6.60131350e-02f, 2.55751610e-03f, -2.32123900e-02f, -1.22993208e-01f, -5.93222715e-02f, 3.82687524e-02f,
  1.36235192e-01f, -2.57433146e-01f, 2.34954804e-01f, -1.50181204e-01f, 6.46695029e-03f, 7.95964599e-02f, 1.48094967e-01f, -2.99004186e-03f, 1.24215089e-01f, -4.42296918e-03f,
  -1.28476113e-01f, -1.52564226e-02f, 1.06767295e-02f, -2.57436614e-02f, -8.97866637e-02f, -1.22623108e-01f, -1.77599629e-03f, 2.74390145e-03f, -1.57017201e-01f, 1.10031143e-01f,
  1.95402771e-01f, -6.36536926e-02f, 3.47531624e-02f, 1.05636036e-02f, -1.25081865e-02f, -1.36929154e-01f, -3.53253745e-02f, -7.83760101e-03f, -4.33634013e-01f, 3.28662097e-01f,
  -9.32487011e-01f, 1.52095214e-01f, 7.37986639e-02f, -8.34191740e-02f, -9.43682343e-02f, -6.31941333e-02f, 2.18974128e-01f, 6.39261156e-02f, 5.34708202e-02f, 1.72626168e-01f,
  -3.53176482e-02f, -3.21449824e-02f, -1.34480089e-01f, -1.47458296e-02f, -1.12480745e-01f, 3.24966401e-01f, 1.43966839e-01f, -1.72440857e-01f, -1.48063749e-01f, -4.78242524e-02f,
  -2.36030994e-03f, -8.61969292e-02f, -1.28324583e-01f, -1.72171384e-01f, -3.22228409e-02f, -4.50515486e-02f, 3.30460407e-02f, -1.07341811e-01f, -1.72468588e-01f, 1.33927450e-01f,
  2.44458225e-02f, -4.76969033e-01f, -6.05482571e-02f, -2.47072160e-01f, 2.35369708e-02f, -4.21401784e-02f, -5.60869183e-03f, 2.19201948e-02f, 1.44346431e-02f, 1.36362359e-01f,
  -2.85495371e-02f, 8.87422357e-03f, -7.36056119e-02f, 3.76199558e-02f, -3.77483256e-02f, 5.31138480e-03f, -3.94774787e-02f, -4.95415926e-02f, -3.50895897e-02f, -1.84283052e-02f,
  3.08632609e-02f, -6.01480119e-02f, 3.27786691e-02f, -7.90401325e-02f, -7.40341693e-02f, -1.90291896e-01f, -6.61215782e-02f, -2.17847735e-01f, -9.80437323e-02f, 1.37023047e-01f,
  -9.87234190e-02f, -5.21291159e-02f, 6.67317510e-02f, -1.74725223e-02f, 1.50387064e-01f, 1.30358547e-01f, 1.14150934e-01f, 1.28443643e-01f, 1.42697677e-01f, 2.95620002e-02f,
  2.23014623e-01f, 1.11373335e-01f, 1.83288917e-01f, 1.29209548e-01f, 3.53652202e-02f, -1.98138058e-02f, 8.94414261e-03f, 5.22220507e-02f, 8.16009343e-02f, 1.02466449e-01f,
  1.93273998e-04f, 8.42743367e-02f, 1.29695404e-02f, 9.55979452e-02f, 5.13628647e-02f, 2.22958922e-02f, 2.74999924e-02f, 3.96541953e-02f, -4.76845987e-02f, -2.53327787e-02f,
  2.74178594e-01f, -2.89539993e-01f, 5.85769005e-02f, -2.93603670e-02f, -2.06567273e-02f, -3.18001211e-03f, -1.66486762e-02f, 1.36786163e-01f, 2.20490038e-01f, 1.72838196e-01f,
  4.55758385e-02f, 5.44242375e-02f, 8.92861485e-02f, 1.31263822e-01f, 2.21378822e-02f, 1.74392045e-01f, 2.05397218e-01f, -2.18298510e-02f, -5.77893332e-02f, 9.07276869e-02f,
  1.08911090e-01f, 1.05346568e-01f, 5.90420924e-02f, 1.19188137e-01f, -8.65210034e-03f, -3.39956470e-02f, 1.41122669e-01f, -6.12717345e-02f, 6.04160465e-02f, 3.71545583e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  2.30026275e-01f, 3.07331175e-01f, 5.67317188e-01f, 5.67087233e-01f, 5.16830862e-01f, 4.35188651e-01f, 3.10124457e-01f, 5.01482248e-01f, 3.43109250e-01f, 5.52501678e-01f,
  3.64772826e-01f, 3.20712149e-01f, 4.92295504e-01f, 4.05289054e-01f, 6.95033669e-01f, 3.78927857e-01f, 6.97295591e-02f, 4.78444368e-01f, 3.82488817e-01f, 1.77150294e-01f,
  6.61016941e-01f, 4.95342046e-01f, 6.86352730e-01f, 4.07399774e-01f, 2.64082849e-01f, 4.63739634e-01f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -1.83935445e-02f, 1.69330731e-01f, 7.01392666e-02f, 8.04810598e-02f, 9.76307988e-02f, 3.66546102e-02f, -2.02247843e-01f, -2.45920032e-01f, -1.28406495e-01f, -2.69746687e-02f,
  -2.39396244e-01f, -2.68654972e-01f, -1.17800370e-01f, 2.41287142e-01f, 2.35169195e-03f, 1.28358871e-01f, 3.59423846e-01f, 1.72252461e-01f, 3.64013344e-01f, -1.25519022e-01f,
  2.33952910e-01f, 1.09237522e-01f, 4.27163765e-02f, 7.39489272e-02f, -2.88403869e-01f, -5.47692962e-02f, 1.93956405e-01f, 7.94368237e-02f, -1.25666440e-01f, -1.87108085e-01f,
  1.60544336e-01f, 9.28038284e-02f, -5.78730777e-02f, -1.19128726e-01f, -6.01443797e-02f, 7.39763230e-02f, 2.41240501e-01f, -1.55832440e-01f, 8.87371078e-02f, -1.54188201e-01f,
  -2.77161151e-01f, 5.53423800e-02f, -1.93779841e-01f, -3.49157393e-01f, 6.57558069e-02f, 5.08010499e-02f, 2.54964773e-02f, 8.20395574e-02f, -3.17943513e-01f, -1.88147411e-01f,
  5.62437018e-03f, -1.70635730e-01f, 2.02433705e-01f, 1.05902918e-01f, 2.59251177e-01f, 2.03636169e-01f, 4.30897549e-02f, 7.91663900e-02f, 5.75333722e-02f, 3.84726375e-02f,
  -4.52558100e-02f, -2.24200517e-01f, -3.43410581e-01f, 1.07136376e-01f, 8.79798457e-03f, -9.80358273e-02f, 8.14037919e-02f, 6.45414069e-02f, 6.13018572e-02f, -2.51151055e-01f,
  1.59988776e-02f, -1.53203502e-01f, 8.93635750e-02f, 2.58800060e-01f, 3.32601607e-01f, -4.55455422e-01f, -3.34328651e-01f, -8.13477188e-02f, 5.09180278e-02f, 1.01252399e-01f,
  2.81690091e-01f, -1.49508521e-01f, 3.24392587e-01f, -1.23731039e-01f, -2.99884826e-01f, 1.15164213e-01f, 1.16920099e-01f, -4.16414976e-01f, -9.53655783e-03f, 7.33553022e-02f,
  -1.04182869e-01f, 3.44422162e-02f, 6.25777692e-02f, 1.50448024e-01f, 2.46007442e-01f, 2.33063892e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  2.24495918e-01f, 4.94379960e-02f, 2.15401396e-01f, 2.08234742e-01f, 1.32143393e-01f, -2.50510365e-01f, -1.85506016e-01f, 5.94083190e-01f, -6.96761012e-02f, -1.72055867e-02f,
  3.28467876e-01f, -3.96590292e-01f, -2.51266025e-02f, -9.68160480e-02f, 7.32758284e-01f, 6.42144322e-01f, -8.96335766e-02f, 6.10428490e-02f, -5.34792617e-03f, -5.81460409e-02f,
  -4.09948289e-01f, -1.91748157e-01f, 1.02150127e-01f, 2.22866073e-01f, 1.85340464e-01f, 4.93341088e-01f, 4.84741986e-01f, 2.72193581e-01f, -4.02927220e-01f, -4.68619354e-02f,
  -4.78430688e-02f, 2.03685015e-01f, -4.60755965e-03f, 2.35316157e-02f, 2.21776888e-01f, 4.68481854e-02f, -9.84586254e-02f, -4.03708398e-01f, 1.56075850e-01f, 4.08573806e-01f,
  -5.14772460e-02f, 2.83827037e-01f, 2.09971532e-01f, 2.09920332e-01f, -3.10800731e-01f, 3.00558269e-01f, -1.72994196e-01f, -2.93414026e-01f, -4.45363492e-01f, 3.06131035e-01f,
  -4.64043140e-01f, -2.18491018e-01f, 2.14579001e-01f, 2.93424875e-01f, -4.19163108e-02f, 5.71250916e-01f, -3.48642953e-02f, -2.96824425e-01f, -2.03759313e-01f, 3.87974493e-02f,
  -1.89486623e-01f, 2.34322995e-01f, 2.03778863e-01f, 3.60134006e-01f, 5.29915914e-02f, 1.23292923e-01f, 1.50639683e-01f, 7.17928261e-02f, 5.56687377e-02f, -2.92574406e-01f,
  -4.86574531e-01f, -4.24761385e-01f, -1.55843660e-01f, -1.70921981e-01f, 2.97558885e-02f, -1.05484694e-01f, 3.57041806e-01f, 2.13848129e-01f, -1.88473120e-01f, 6.14442490e-02f,
  5.41239738e-01f, 6.78559124e-01f, 3.11072737e-01f, -1.08637968e-02f, 6.60878658e-01f, -1.00970306e-02f, 1.66696846e-01f, 7.50739919e-03f, -2.94040561e-01f, 1.01231702e-01f,
  2.57736713e-01f, 1.33382887e-01f, 6.29686415e-01f, 2.00005069e-01f, 6.61409736e-01f, -6.14246391e-02f, 2.60996241e-02f, 2.94750854e-02f, 2.90801257e-01f, -6.34914115e-02f,
  -1.74142599e-01f, -2.94414520e-01f, 9.79280546e-02f, -4.32297111e-01f, -4.53354269e-02f, -3.56816761e-02f, 1.51014611e-01f, 4.01605256e-02f, 1.98135823e-01f, -1.66164692e-02f,
  -4.97280061e-02f, 4.95635606e-02f, 4.11260188e-01f, 6.88378572e-01f, 5.65114133e-02f, 2.33089365e-02f, 8.11008751e-01f, 4.64540906e-02f, 6.08150959e-02f, -5.11273623e-01f,
  1.54385597e-01f, -3.16647321e-01f, 6.63454011e-02f, -3.70968610e-01f, 4.59934026e-01f, 7.95873031e-02f, 8.25342357e-01f, 1.12922117e-01f, 3.27878185e-02f, 1.17824212e-01f,
  2.39895079e-02f, 9.75713357e-02f, 1.42608121e-01f, -8.03370848e-02f, 2.55582839e-01f, 3.77008379e-01f, 2.30542883e-01f, 3.12256455e-01f, 5.34236193e-01f, -4.53851651e-03f,
  -2.58843973e-02f, 1.82638809e-01f, -9.02080815e-03f, 2.78368980e-01f, 3.26249152e-01f, -7.50374123e-02f, 4.12114620e-01f, 3.49622846e-01f, -5.32871366e-01f, -1.44554406e-01f,
  -5.46607852e-01f, 3.18362683e-01f, -1.07416444e-01f, 2.82832891e-01f, 8.47763866e-02f, 2.51957834e-01f, 8.16162452e-02f, 3.27619314e-01f, -2.40130842e-01f, 1.48040541e-02f,
  2.79288024e-01f, 9.32559092e-03f, 1.12865426e-01f, -2.39863485e-01f, -7.82716870e-02f, -6.38500005e-02f, 2.01600879e-01f, 2.88482696e-01f, 4.14275765e-01f, 2.56338745e-01f,
  1.42613892e-02f, 2.93041408e-01f, 4.26057667e-01f, 1.27816334e-01f, 3.78186963e-02f, -4.79045242e-01f, 4.44691688e-01f, 6.31369743e-03f, 2.77583420e-01f, 6.13012075e-01f,
  -3.01563367e-02f, 1.53991878e-01f, -3.15881938e-01f, -4.11381245e-01f, 1.98857963e-01f, 3.58880609e-01f, 2.64540970e-01f, -2.80635267e-01f, 3.67088318e-01f, 4.28626984e-01f,
  -2.46314913e-01f, -3.53072524e-01f, -1.14411190e-01f, 3.28943729e-01f, -2.25591520e-03f, -2.19291493e-01f, 3.06837350e-01f, 2.53611743e-01f, -2.00812414e-01f, -2.74774611e-01f,
  2.24269941e-01f, -6.30837828e-02f, -2.60432065e-02f, 7.46919811e-01f, 8.74697864e-01f, 9.01551321e-02f, 2.78782785e-01f, 3.56794298e-01f, -1.15533844e-01f, -3.41348171e-01f,
  1.27870485e-01f, -3.12849700e-01f, -1.14788815e-01f, 2.31139943e-01f, 2.17765301e-01f, -1.54801309e-01f, 3.27935904e-01f, -3.03511351e-01f, 6.22299135e-01f, 4.02077407e-01f,
  -4.76725064e-02f, -4.37694276e-03f, 2.28543743e-01f, 8.29671770e-02f, 8.07418674e-02f, 1.42541781e-01f, 5.48729658e-01f, -1.67062700e-01f, -2.42356613e-01f, -2.08432257e-01f,
  -6.58603907e-02f, -4.54236656e-01f, 1.10148393e-01f, 4.47570533e-01f, 5.88409781e-01f, 2.01742768e-01f, -2.98009574e-01f, 4.02553886e-01f, 1.86559662e-01f, 6.41560614e-01f,
  1.97542384e-01f, 6.96982890e-02f, 5.02041340e-01f, -3.24182838e-01f, 7.78058097e-02f, -3.23999375e-01f, -3.43337208e-01f, 6.48220122e-01f, 1.01327226e-02f, -3.57002765e-01f,
  -4.30318177e-01f, 2.02619150e-01f, 7.85881653e-02f, 4.06553417e-01f, 8.34654033e-01f, 3.96033376e-01f, 2.68341780e-01f, 2.95070261e-01f, 7.20693022e-02f, 8.48984867e-02f,
  -2.74403095e-01f, -1.05716906e-01f, 1.69721127e-01f, 3.97663593e-01f, 4.23075050e-01f, 4.89103533e-02f, 5.44865310e-01f, -6.25336528e-01f, 5.67993149e-02f, 3.85755330e-01f,
  -1.79729406e-02f, -3.48545492e-01f, 5.54405928e-01f, 2.84165919e-01f, -1.31307676e-01f, 5.56616366e-01f, 1.02223866e-01f, 6.08553290e-02f, -5.81415951e-01f, 4.51453328e-01f,
  -1.95378229e-01f, 3.92700464e-01f, -9.29175317e-02f, 3.00537914e-01f, 3.92923266e-01f, 9.99494791e-02f, -4.52383161e-02f, -4.04962361e-01f, 1.31345361e-01f, -8.60493854e-02f,
  2.50530273e-01f, -2.08529606e-01f, -2.47605011e-01f, 3.29377279e-02f, 1.13606133e-01f, -3.96336198e-01f, -4.11111414e-02f, 7.19575631e-03f, 3.69739085e-01f, 4.09562737e-01f,
  5.44432163e-01f, 4.54777591e-02f, 7.91833699e-02f, -5.26643619e-02f, 4.59776908e-01f, -8.68641436e-02f, 5.00017941e-01f, 1.21096753e-01f, -5.04143834e-01f, -1.16484985e-02f,
  -1.32806763e-01f, 2.06643552e-01f, 1.19604364e-01f, -1.06566951e-01f, 1.51661366e-01f, 7.50206038e-02f, 2.91877180e-01f, -2.23317653e-01f, 2.88902372e-01f, -1.23305745e-01f,
  2.06011668e-01f, 4.04168159e-01f, 2.39670232e-01f, 1.48344070e-01f, 2.26327553e-01f, 1.02761678e-01f, -3.37132126e-01f, 4.38139230e-01f, 2.12508589e-01f, -1.85731322e-01f,
  -2.10384861e-01f, -1.09902442e+00f, -9.53541026e-02f, 2.83766359e-01f, 4.92634594e-01f, 4.45566401e-02f, 5.93881130e-01f, 1.04894318e-01f, -1.91429909e-02f, 8.86178687e-02f,
  8.63533497e-01f, -1.13814510e-01f, -1.72128022e-01f, 4.47040915e-01f, 2.41979826e-02f, 7.18025118e-02f, -3.86871323e-02f, 2.56322771e-01f, 2.56014913e-01f, -8.45209599e-01f,
  -2.02012524e-01f, -1.01872196e-03f, -2.64142752e-01f, 3.83342430e-02f, -1.32318974e-01f, 3.50722104e-01f, -8.61796737e-02f, -1.67010814e-01f, 2.37571284e-01f, 6.48343489e-02f,
  -2.01221868e-01f, -3.26890320e-01f, -2.40886688e-01f, 6.18763864e-01f, 7.41871059e-01f, 3.33599389e-01f, 3.16421479e-01f, -1.80097073e-02f, 8.95350277e-02f, 3.55897188e-01f,
  9.75176245e-02f, 9.62764397e-02f, 4.17661011e-01f, 2.35337228e-01f, -3.17637324e-02f, -7.53422827e-02f, 2.48636454e-01f, 5.09608090e-01f, 1.14648730e-01f, -4.68963236e-02f,
  2.10118026e-01f, 2.92217042e-02f, 6.55184314e-02f, -1.24681786e-01f, -2.43167341e-01f, 1.29447743e-01f, 1.67899773e-01f, -1.54674873e-01f, 1.20668851e-01f, -4.23267126e-01f,
  6.86322227e-02f, 3.76577258e-01f, 2.31585518e-01f, 5.37046194e-01f, 6.85884476e-01f, 9.04846638e-02f, -3.30660105e-01f, -1.65811762e-01f, 4.56567317e-01f, 4.14624631e-01f,
  3.48679781e-01f, 1.36261135e-01f, 4.44232106e-01f, 2.08539173e-01f, -5.24395227e-01f, -2.37860277e-01f, 2.80768692e-01f, -2.94811308e-01f, 2.26060495e-01f, 3.54590386e-01f,
  -3.96685839e-01f, -1.24051318e-01f, -2.06770942e-01f, 3.68582040e-01f, 6.42640889e-01f, 1.98382795e-01f, -3.67062837e-02f, 1.58930510e-01f, -2.48468220e-01f, 2.07653508e-01f,
  2.86225349e-01f, 6.74615577e-02f, -6.95419759e-02f, -7.65078468e-03f, -4.83304113e-01f, -1.59992024e-01f, -7.74816871e-02f, 2.16032803e-01f, -2.92336524e-01f, 4.85076845e-01f,
  1.79241389e-01f, -2.42690474e-01f, -2.71538258e-01f, -1.41735122e-01f, -4.84050959e-02f, -3.16296965e-01f, 3.91838372e-01f, 3.79514188e-01f, 1.88206449e-01f, 1.13874577e-01f,
  2.95231462e-01f, 1.36581361e-01f, -1.17564179e-01f, 7.40782768e-02f, 2.32308656e-02f, -3.79617095e-01f, 2.44056750e-02f, -4.19564433e-02f, 1.92647040e-01f, 5.53375483e-02f,
  3.54187757e-01f, -1.46485865e-01f, 2.23454908e-01f, 9.81097072e-02f, -6.78090751e-02f, -3.76519322e-01f, -1.25681862e-01f, 4.10419762e-01f, 2.64959663e-01f, 2.06366181e-02f,
  -2.88028866e-01f, -1.74542055e-01f, 2.75009781e-01f, 5.74019492e-01f, 3.57429743e-01f, 1.85152013e-02f, 3.09999138e-01f, -2.35658526e-01f, -6.84083179e-02f, -7.74539635e-02f,
  3.47001255e-01f, -1.42144367e-01f, 8.11989233e-03f, -3.76573563e-01f, 2.86732882e-01f, 1.44531056e-01f, -1.46126626e-02f, 2.17568323e-01f, 6.46545708e-01f, 2.25392804e-01f,
  3.22222769e-01f, 3.42488110e-01f, 2.56630570e-01f, 2.99498379e-01f, 1.09481350e-01f, 6.12841189e-01f, -3.08200151e-01f, 1.29791617e-01f, 1.23353571e-01f, 6.63376078e-02f,
  -3.70618016e-01f, 8.39546144e-01f, 4.97638762e-01f, 1.61801115e-01f, -4.24308985e-01f, 5.17720819e-01f, -1.03489190e-01f, 7.49553293e-02f, 4.86404300e-02f, 5.80648668e-02f,
  5.18923819e-01f, 2.51005620e-01f, 1.78551614e-01f, -1.82957649e-01f, 2.80115455e-01f, 3.60542595e-01f, 8.90966058e-01f, 3.36431302e-02f, 8.60694200e-02f, -8.78890380e-02f,
  -3.58718306e-01f, 3.52903758e-03f, 3.62427354e-01f, 2.53440350e-01f, -1.18823022e-01f, -7.81311616e-02f, 4.71159011e-01f, -2.47351214e-01f, -1.99401245e-01f, 2.29874045e-01f,
  1.87599391e-01f, 4.91132230e-01f, 2.02872366e-01f, -3.51532876e-01f, -3.34235489e-01f, 8.19370747e-02f, 7.34101713e-01f, 4.71058369e-01f, 2.88883448e-01f, -4.54651833e-01f,
  6.14929140e-01f, -1.04152143e-01f, -6.56774461e-01f, 2.44300738e-02f, 3.18380147e-01f, 1.78667009e-01f, 2.23670870e-01f, -1.98199823e-01f, 1.99856281e-01f, 5.44305801e-01f,
  -2.10530639e-01f, -3.94443683e-02f, -2.93027401e-01f, 3.17392081e-01f, -7.81868696e-02f, 1.36733398e-01f, 4.40992713e-02f, -6.50970489e-02f, -2.40697771e-01f, -3.01757157e-01f,
  2.01086141e-02f, -1.91161260e-01f, -3.64398467e-03f, 9.49121267e-02f, 1.45429954e-01f, -2.61027902e-01f, 2.30347455e-01f, 4.85599250e-01f, 4.24269646e-01f, -3.66376400e-01f,
  7.57550001e-02f, 5.25029637e-02f, -1.14843749e-01f, 1.97959349e-01f, 3.39761585e-01f, 1.76747501e-01f, 3.07466984e-01f, 5.29363453e-01f, 2.55914003e-01f, -3.31448227e-01f,
  -1.34236157e-01f, 1.41371056e-01f, 2.77692467e-01f, 1.00098297e-01f, 5.63233733e-01f, 1.48864746e-01f, -1.52287856e-01f, 1.17512859e-01f, 3.03930938e-01f, -3.09962928e-02f,
  -2.33483762e-01f, -3.83405954e-01f, -1.27244070e-01f, -2.92804301e-01f, 9.89361014e-03f, -2.48876810e-01f, 2.65469253e-01f, 3.93595159e-01f, 6.62112355e-01f, 5.29212356e-01f,
  -2.03255489e-01f, 1.70714092e-02f, -3.20437312e-01f, 5.39950967e-01f, -1.88975975e-01f, -1.70614928e-01f, 4.02908891e-01f, 1.81459635e-02f, 9.34916586e-02f, 6.00940228e-01f,
  2.39407532e-02f, -5.16480386e-01f, 3.99332315e-01f, 5.77318311e-01f, 3.45204264e-01f, 2.54595160e-01f, 7.39981115e-01f, -1.90772623e-01f, 1.19751334e-01f, 3.89686942e-01f,
  2.68392771e-01f, 1.23558998e-01f, 3.64128590e-01f, -4.86806065e-01f, -4.19387162e-01f, 1.82061568e-01f, 2.19019324e-01f, 1.24768011e-01f, 2.43284583e-01f, -7.74144232e-01f,
  -2.58253813e-01f, -6.95833638e-02f, 6.52578533e-01f, -1.83809757e-01f, 3.68093520e-01f, 4.20951813e-01f, 5.37320554e-01f, 1.55170783e-01f, 4.52541560e-01f, -1.98796794e-01f,
  1.28608849e-02f, -2.19077975e-01f, 1.99310571e-01f, 2.21307278e-01f, -2.89558202e-01f, -7.96444938e-02f, 3.71293396e-01f, 1.44238368e-01f, 3.78343277e-02f, 2.27535695e-01f,
  2.44696826e-01f, 1.49453759e-01f, 2.12226510e-01f, -2.85473913e-01f, -2.58793861e-01f, 4.60252017e-01f, -2.43080467e-01f, 2.01493517e-01f, 3.05394858e-01f, -1.22898512e-01f,
  -2.45529935e-01f, 6.22620404e-01f, 6.11198723e-01f, -2.61558652e-01f, -2.17352554e-01f, 1.52070791e-01f, 1.65910199e-01f, -1.92018524e-02f, -2.70826668e-01f, 2.78334290e-01f,
  4.55757201e-01f, 1.97960824e-01f, -1.75444335e-01f, -4.66035068e-01f, 4.02325004e-01f, 7.66852424e-02f, -2.14011222e-02f, 2.48133615e-02f, -1.46381274e-01f, 1.38413325e-01f,
  1.36454433e-01f, -4.65573333e-02f, 4.44922775e-01f, 3.61792892e-01f, 4.17539209e-01f, -3.52231443e-01f, 3.47602218e-01f, -6.90486729e-02f, -1.12352349e-01f, 2.09758550e-01f,
  3.55414391e-01f, 2.77122170e-01f, 2.91803867e-01f, 1.52675658e-01f, -5.39469242e-01f, -3.24932963e-01f, 3.10426712e-01f, 6.30386770e-01f, 3.75970095e-01f, 3.34298168e-03f,
  6.35669053e-01f, 6.56550983e-03f, 1.98657781e-01f, 1.86247062e-02f, -3.69467407e-01f, -3.90639789e-02f, 1.92871034e-01f, 2.72566285e-02f, -4.14360642e-01f, 1.26317265e-02f,
  6.83225244e-02f, 2.88768291e-01f, 1.08712353e-01f, 4.16616470e-01f, -1.37319222e-01f, -1.54907763e-01f, -7.95267075e-02f, 1.63418114e-01f, -2.47696415e-01f, -1.54101968e-01f,
  9.84900892e-02f, 3.89921844e-01f, 3.22774798e-02f, 1.17599855e-04f, 3.02150518e-01f, -3.21756490e-03f, -3.95789035e-02f, -4.73169647e-02f, 6.06821060e-01f, -8.07677731e-02f,
  2.28363037e-01f, -2.74736553e-01f, -2.16149360e-01f, 3.19369078e-01f, -4.28645313e-01f, 3.03936675e-02f, 8.73774886e-02f, 2.09993675e-01f, 3.59114319e-01f, 5.40567696e-01f,
  -4.52132761e-01f, -2.01767370e-01f, -2.21628055e-01f, 3.45940590e-01f, 1.89377978e-01f, 2.27390736e-01f, -1.20575778e-01f, -1.17778726e-01f, -1.98733881e-01f, -6.64130375e-02f,
  -2.07094610e-01f, -2.47376800e-01f, 5.06901219e-02f, 4.70500797e-01f, 2.90194869e-01f, 8.13941285e-02f, 2.03419745e-01f, 2.31838927e-01f, 4.74920273e-01f, 4.93070126e-01f,
  -2.16381863e-01f, -4.65195149e-01f, -3.13204259e-01f, 1.55152053e-01f, -2.99303025e-01f, 3.34023476e-01f, -6.60048008e-01f, 2.86955535e-02f, -2.34017998e-01f, 2.80067712e-01f,
  1.88040704e-01f, 3.98484379e-01f, 5.55710495e-02f, 2.31421486e-01f, 8.59175995e-03f, 2.91087806e-01f, -5.99641025e-01f, -1.96777940e-01f, -3.25224772e-02f, -1.23867646e-01f,
  -1.72093198e-01f, -1.40400201e-01f, -2.55267590e-01f, 5.65132173e-03f, 1.71495184e-01f, 5.47986805e-01f, 2.78359890e-01f, 3.59071314e-01f, 1.65741786e-01f, -4.48558070e-02f,
  4.31328565e-02f, -2.29549989e-01f, 3.37613583e-01f, 1.84138075e-01f, 1.34376362e-01f, -3.34827214e-01f, 7.57965297e-02f, 5.64114988e-01f, -4.39194888e-01f, -1.82064056e-01f,
  3.62962544e-01f, 2.13264525e-02f, 3.05730969e-01f, 6.55951381e-01f, -2.17519384e-02f, -3.43605012e-01f, -5.23348808e-01f, 5.22916496e-01f, -2.00295284e-01f, 2.33209684e-01f,
  3.82996202e-02f, -1.03505619e-01f, 2.89759010e-01f, -4.11136389e-01f, -2.24381655e-01f, 7.23102018e-02f, 1.10394359e-01f, -6.89745042e-03f, 1.89915955e-01f, 5.94142258e-01f,
  1.09529480e-01f, 2.47243181e-01f, -3.13437670e-01f, -1.68682680e-01f, -9.58384350e-02f, 2.59827286e-01f, 1.88288963e-04f, -2.93168426e-01f, 1.09251430e-02f, -1.69210196e-01f,
  2.07910150e-01f, -4.06243920e-01f, -2.16445208e-01f, -2.03577653e-01f, 4.24075127e-01f, -1.62025616e-01f, 1.23782620e-01f, -7.71014914e-02f, -2.33760193e-01f, 3.90139222e-01f,
  7.42857873e-01f, 5.97221136e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  1.48297057e-01f, 1.02630295e-01f, 3.66981328e-01f, 3.09462160e-01f, 2.46254355e-01f, -1.16523886e-02f, 2.32909307e-01f, 1.41114175e-01f, 1.87904596e-01f, 2.44346619e-01f,
  1.49495259e-01f, 8.65252465e-02f, -2.45506912e-02f, 4.07971293e-02f, 2.84113228e-01f, 3.00895069e-02f, 1.29017591e-01f, 1.23941973e-01f, 4.41251807e-02f, 2.71190777e-02f,
  3.27938467e-01f, 2.66042262e-01f, 2.26879716e-01f, -9.95108709e-02f, 1.30294755e-01f, 4.30365980e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -1.54824495e-01f, -2.24282220e-01f, 2.13853776e-01f, 4.39315617e-01f, 8.34958628e-02f, 3.40481400e-02f, -2.73244828e-01f, -2.73060910e-02f, -3.87239248e-01f, -3.52534503e-01f,
  1.81694135e-01f, 2.57116139e-01f, -3.41097385e-01f, -3.25001508e-01f, 1.42598405e-01f, 7.63985664e-02f, -5.63156426e-01f, 1.81315184e-01f, 5.81147000e-02f, -8.10364902e-01f,
  -5.85540593e-01f, 3.02355558e-01f, -8.64691675e-01f, -3.40514034e-01f, -4.63122964e-01f, -3.07557344e-01f, 1.27201796e-01f, -1.54143989e-01f, 2.02020034e-01f, 3.56202364e-01f,
  3.60769451e-01f, 5.11048436e-02f, -1.62695959e-01f, 4.05818224e-02f, -2.31741607e-01f, -8.57879400e-01f, -4.99548018e-01f, 3.00212298e-02f, -3.71347487e-01f, 1.04674719e-01f,
  -2.05663294e-01f, -1.88153759e-02f, -4.75790016e-02f, 2.92745292e-01f, 3.71593714e-01f, -1.19304550e+00f, -9.69780535e-02f, 1.47905767e-01f, -5.38364053e-01f, 2.50416219e-01f,
  -5.12274086e-01f, 2.83904195e-01f, -3.18756938e-01f, 2.26315618e-01f, -1.49070948e-01f, 1.36587307e-01f, 3.26834977e-01f, -7.52959132e-01f, 2.75554091e-01f, -8.61561537e-01f,
  -3.43832374e-01f, 5.45567870e-01f, -9.07388479e-02f, -5.74856758e-01f, -6.30416572e-02f, 1.84338093e-01f, 3.56166512e-01f, 4.63214606e-01f, -5.71572855e-02f, 7.90905207e-03f,
  1.23015590e-01f, -5.14732599e-02f, -8.70288461e-02f, 1.90921918e-01f, 1.48452491e-01f, 3.30958843e-01f, -2.99114823e-01f, -1.08946157e+00f, 4.58047479e-01f, 1.52302191e-01f,
  6.41281128e-01f, 1.04220077e-01f, -5.28911054e-01f, -5.02174318e-01f, -2.87937433e-01f, 5.12299001e-01f, -3.70981663e-01f, 4.81922477e-02f, -4.33621407e-01f, 3.61673348e-02f,
  1.60857722e-01f, 1.65016159e-01f, -1.12327330e-01f, -2.52769291e-01f, -6.19669676e-01f, -6.19847536e-01f, -4.20808047e-01f, -2.58903831e-01f, 5.59094809e-02f, -1.43808126e-02f,
  -3.05094481e-01f, -7.16914097e-03f, 3.89676213e-01f, 2.51585573e-01f, -1.21683264e+00f, -6.89879179e-01f, 1.14238851e-01f, 1.07635885e-01f, -5.26479602e-01f, -1.69255376e-01f,
  6.70505613e-02f, -1.43323827e+00f, -1.69685155e-01f, -7.25455761e-01f, 3.56979340e-01f, -8.13471377e-01f, -1.62703052e-01f, -5.89309573e-01f, 5.28453350e-01f, -1.89799711e-01f,
  -6.44552946e-01f, 2.83296138e-01f, -2.96590835e-01f, 2.47844681e-01f, 3.56327854e-02f, 2.85736591e-01f, 2.70321488e-01f, 2.46532317e-02f, 1.62778407e-01f, 5.06361604e-01f,
  -6.53561652e-01f, -1.15585953e-01f, 3.96669030e-01f, 2.50602335e-01f, -5.35557687e-01f, 1.63925320e-01f, 5.63815646e-02f, 3.17826092e-01f, -1.29711106e-01f, 1.29539385e-01f,
  -4.58594024e-01f, 3.49252909e-01f, -2.89847353e-03f, -1.23811446e-01f, -6.09460950e-01f, -2.78958619e-01f, 2.03695372e-01f, 1.09006315e-01f, 1.79114357e-01f, -6.87135100e-01f,
  -1.51869193e-01f, 2.78221101e-01f, -1.78765699e-01f, 3.61894220e-02f, -1.01303175e-01f, 1.03044041e-01f, 3.81555632e-02f, -2.53308207e-01f, 1.72180772e-01f, 2.66381204e-01f,
  2.61089593e-01f, -1.58421308e-01f, 5.06156504e-01f, -5.54184854e-01f, -5.98441176e-02f, -2.08685115e-01f, -9.44216698e-02f, 1.12778507e-01f, -9.71014425e-02f, 4.19447154e-01f,
  -2.83179462e-01f, -1.54159978e-01f, 1.47792250e-01f, 3.48061621e-01f, -7.44988382e-01f, -3.86455958e-03f, -5.62672675e-01f, -8.91719013e-03f, -4.51828875e-02f, -3.09404403e-01f,
  2.11471632e-01f, 1.43440217e-01f, -5.40219426e-01f, 2.57383886e-04f, 2.34166905e-01f, -2.98257887e-01f, 3.15954626e-01f, 7.62877315e-02f, -2.70924151e-01f, -5.22894919e-01f,
  -2.88210809e-01f, 4.85650867e-01f, -3.39248300e-01f, 2.35539973e-01f, 2.59654254e-01f, 2.90262073e-01f, 3.90393317e-01f, -4.29578602e-01f, -5.83964467e-01f, 2.36142069e-01f,
  5.30805290e-01f, 3.33622813e-01f, -8.37967157e-01f, -4.21189278e-01f, -6.17511809e-01f, -1.00887276e-01f, -3.80786248e-02f, -4.19115186e-01f, 4.48603928e-01f, 2.82482088e-01f,
  -5.10395765e-01f, 1.92369707e-02f, -4.12465781e-01f, -4.44031209e-02f, -8.98230672e-01f, 6.30232021e-02f, 3.35009009e-01f, 2.89270669e-01f, -8.52494180e-01f, -1.15377493e-01f,
  -7.61108756e-01f, -2.96853930e-01f, -5.13727546e-01f, -6.43323004e-01f, 1.06860176e-01f, -8.30578268e-01f, 7.16699958e-02f, 1.69080272e-01f, 2.94972897e-01f, 3.52494806e-01f,
  4.50434387e-01f, -2.31615946e-01f, -5.30917048e-01f, -4.06861752e-01f, -6.21130466e-01f, -3.00096959e-01f, 8.69794488e-02f, -3.67385775e-01f, -4.82074678e-01f, 1.94518390e-04f,
  2.16729119e-01f, 2.16461584e-01f, 2.15010524e-01f, 1.24699041e-01f, -1.96823835e-01f, -2.25571588e-01f, 2.87533462e-01f, 1.49844319e-01f, -5.47721267e-01f, 2.81282663e-01f,
  -6.23251855e-01f, -1.51740059e-01f, 4.15105939e-01f, -2.83397049e-01f, 3.11647326e-01f, -3.49270046e-01f, -1.54044643e-01f, -1.93176754e-02f, 3.48194689e-01f, 7.46370256e-01f,
  7.26944387e-01f, -6.58531487e-01f, 4.00492936e-01f, -1.90403104e-01f, 3.61408561e-01f, -5.40711462e-01f, -5.38469911e-01f, -8.08439374e-01f, 3.82318765e-01f, -8.35011184e-01f,
  -5.69292307e-01f, -1.85621351e-01f, 5.97225409e-03f, -1.58273637e-01f, -5.61158538e-01f, -2.58593172e-01f, 3.32534134e-01f, 3.64892721e-01f, 4.76572484e-01f, -6.51550964e-02f,
  3.30035865e-01f, -3.55379105e-01f, -1.50483102e-02f, -4.17810947e-01f, -3.97993147e-01f, -3.47896487e-01f, -4.39985484e-01f, -3.89519453e-01f, -8.14963430e-02f, 1.76976979e-01f,
  -1.67994872e-01f, 1.49487764e-01f, -2.62314618e-01f, 6.14193738e-01f, -7.64042791e-03f, -8.16555679e-01f, 4.44671720e-01f, 3.24023098e-01f, 1.93891913e-01f, 1.51788089e-02f,
  -1.01398960e-01f, 5.86230233e-02f, 9.25015360e-02f, 3.24203491e-01f, -5.20714112e-02f, 7.96686634e-02f, 2.34981999e-01f, -4.72275466e-01f, 1.13914825e-01f, -4.42265689e-01f,
  -1.21458128e-01f, 1.79769075e-03f, 1.39215156e-01f, 2.81960368e-01f, -4.97192055e-01f, 7.72781596e-02f, -2.89495707e-01f, -8.84191319e-02f, -1.30810392e+00f, -7.17521608e-01f,
  7.34991357e-02f, 2.43034214e-01f, -2.47531980e-01f, 3.95823300e-01f, -6.36907756e-01f, 5.12209594e-01f, -4.09336537e-01f, -8.38475108e-01f, -8.39423954e-01f, -7.51523018e-01f,
  4.00684416e-01f, 7.01665878e-03f, 1.08741902e-01f, 4.71231937e-01f, -4.70873296e-01f, 3.21863145e-02f, -1.70768872e-01f, -6.33449733e-01f, 1.40438154e-01f, -7.08981037e-01f,
  2.49387518e-01f, 2.68256903e-01f, 5.73669612e-01f, -9.74912107e-01f, -6.26786828e-01f, -8.08382593e-03f, -7.81767666e-02f, 4.80941862e-01f, -7.90680528e-01f, -2.79531121e-01f,
  -1.87979013e-01f, 2.67764598e-01f, 3.94491583e-01f, 1.36055872e-01f, 6.19602874e-02f, 1.91279233e-01f, 2.41967499e-01f, -2.13966221e-01f, 1.34607673e-01f, 2.67288953e-01f,
  -2.32070193e-01f, -6.50818110e-01f, 3.66672158e-01f, -8.81103098e-01f, -3.57841372e-01f, 5.38370728e-01f, 3.55516344e-01f, 2.59936720e-01f, 6.46988750e-02f, -4.66946252e-02f,
  -4.50424403e-01f, -9.93549675e-02f, -4.27774608e-01f, -6.13854587e-01f, -7.68067986e-02f, 3.27037871e-01f, 4.35276419e-01f, -6.00115359e-01f, -6.30087435e-01f, -3.03902030e-01f,
  -1.01796137e-02f, 4.76029813e-01f, -6.26848042e-01f, -2.20108852e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -6.27114773e-02f, -7.64967687e-03f, 3.82919014e-01f, -3.05453509e-01f, -1.53000176e-01f, 5.49307466e-02f, 4.19060141e-02f, -4.72541973e-02f, 1.35873422e-01f, 2.03148961e-01f,
  7.49287456e-02f, 1.64520279e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    