/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.39512020e-01f, 1.99931219e-01f, 4.18985337e-02f, -2.32977018e-01f, 3.55374031e-02f, -9.08353627e-02f, -4.63020474e-01f, 1.18180640e-01f, -7.83292428e-02f, -4.68653999e-02f,
  -1.11615874e-01f, 6.93978518e-02f, -6.12958223e-02f, -5.84358089e-02f, -2.02135190e-01f, -1.10165834e-01f, -3.41067791e-01f, -2.11040810e-01f, 9.80660319e-02f, -2.15685353e-01f,
  -7.95644075e-02f, -1.57319620e-01f, 6.37042522e-02f, 1.00402415e-01f, -1.25416636e-01f, 2.58893259e-02f, -2.08283901e-01f, 9.64595899e-02f, -3.55518945e-02f, 3.48371267e-02f,
  1.89437360e-01f, -3.81495133e-02f, 1.15518682e-01f, -5.74001074e-02f, -2.68479697e-02f, -3.39855924e-02f, -3.09116058e-02f, 4.32301424e-02f, 6.18299395e-02f, -1.68425962e-02f,
  1.65969711e-02f, 5.66310287e-02f, 5.52218640e-03f, 1.82214342e-02f, -4.49947193e-02f, 4.95338365e-02f, 3.33718285e-02f, 5.62541336e-02f, 1.22401744e-01f, 9.26312134e-02f,
  4.75933850e-02f, 1.39384091e-01f, -2.65994202e-02f, -8.51789787e-02f, -7.54645793e-03f, -7.19882473e-02f, -8.38179365e-02f, 6.57149777e-02f, -3.83144617e-02f, 3.91496457e-02f,
  5.28148115e-02f, 9.04728938e-03f, 3.19408700e-02f, -7.89824501e-03f, -2.29190141e-02f, 3.19934338e-02f, -1.82037558e-02f, 1.97758023e-02f, 2.41022017e-02f, -3.49657759e-02f,
  -5.13336994e-02f, -3.11408881e-02f, -6.19947631e-03f, -1.29883336e-02f, -2.64697932e-02f, -4.86162119e-02f, 8.49502068e-03f, -1.28649557e-02f, 1.41854165e-02f, -1.87626071e-02f,
  3.40140052e-02f, -2.51976065e-02f, 5.91576658e-02f, -4.23571542e-02f, -1.46503246e-03f, 4.49527688e-02f, 8.67080688e-03f, 5.97467385e-02f, -7.23363273e-03f, -1.27341449e-02f,
  -1.00302339e-01f, -2.27471963e-01f, -2.34517697e-02f, 7.23572541e-03f, 5.48040681e-03f, 5.07523492e-02f, -1.72458291e-02f, 1.51871070e-02f, -1.38456315e-01f, -1.44386049e-02f,
  -4.72615846e-02f, -3.86709385e-02f, 1.48564242e-02f, -1.23068029e-02f, 6.12890832e-02f, -3.42227928e-02f, -6.48279265e-02f, -8.92633274e-02f, -1.23634204e-01f, 6.74984232e-02f,
  -2.27736328e-02f, -5.33388220e-02f, -6.65046624e-04f, 3.97953913e-02f, -2.98597068e-02f, -7.45973375e-04f, -3.88639676e-03f, -1.81119598e-03f, 5.42943552e-02f, -7.99786206e-03f,
  2.49015853e-01f, -2.72186220e-01f, 2.91360110e-01f, -1.07006937e-01f, 1.56942144e-01f, -2.02980384e-01f, -1.74872711e-01f, -3.99982817e-02f, -1.34692371e-01f, -2.96010494e-01f,
  -1.22562259e-01f, -1.55815572e-01f, -1.12982519e-01f, -2.81990469e-01f, 4.30981144e-02f, -3.33071709e-01f, -1.69890225e-01f, -2.20963031e-01f, -2.40740273e-02f, -8.44735876e-02f,
  5.80693297e-02f, -1.32377684e-01f, 4.85163964e-02f, 2.60052532e-02f, 1.36708543e-01f, 1.14041492e-01f, 6.60475418e-02f, 2.18766436e-01f, -2.64579896e-02f, 5.83424829e-02f,
  1.26221731e-01f, -1.49110779e-02f, 1.12905502e-01f, -3.78509797e-02f, -8.34702328e-03f, 2.18935572e-02f, -5.72119430e-02f, 6.91636279e-02f, 1.15286736e-02f, -1.06714654e-03f,
  3.41686495e-02f, 6.78288862e-02f, -1.71669982e-02f, 4.08709086e-02f, 2.39039045e-02f, 1.79411396e-02f, 1.98497362e-02f, -3.34595628e-02f, 2.05891915e-02f, 5.68205044e-02f,
  3.06066740e-02f, -2.10314821e-02f, 3.71883288e-02f, -5.83189391e-02f, 9.78287905e-02f, -4.21167724e-02f, -6.00062273e-02f, 6.78775609e-02f, -4.71917503e-02f, 2.60353816e-04f,
  -1.32011166e-02f, 2.90918723e-02f, 1.04898605e-02f, 1.05264755e-02f, -1.40482197e-02f, 3.81626375e-02f, -2.13279184e-02f, 1.37633486e-02f, 7.79503733e-02f, -8.27354640e-02f,
  1.15575679e-02f, -3.06674722e-03f, -6.08878257e-03f, 1.77392252e-02f, -5.50846271e-02f, -2.48554610e-02f, -2.94265747e-02f, -7.15761073e-03f, 4.61912267e-02f, 9.72024258e-03f,
  -3.30329202e-02f, 3.02326065e-02f, 1.64970234e-02f, 1.47156334e-02f, -1.06486166e-03f, 2.00286768e-02f, -4.48974036e-03f, -5.13204979e-03f, -2.25436594e-03f, 1.91566665e-02f,
  -3.43988597e-01f, -1.23129904e-01f, -1.11102266e-02f, 9.01193768e-02f, -6.35907948e-02f, 1.39818704e-02f, 2.37026103e-02f, 9.99698415e-03f, -5.16211428e-02f, -6.38552615e-03f,
  2.94934250e-02f, -6.87916949e-02f, 3.55411917e-02f, -4.80150841e-02f, -5.07594347e-02f, -1.37585904e-02f, -2.51599029e-02f, -8.69354978e-03f, -5.26271537e-02f, 1.50629282e-02f,
  -8.79329443e-02f, -6.95693912e-03f, -2.57853735e-02f, 9.29285064e-02f, -8.64201784e-02f, -9.33696795e-03f, -3.03011318e-03f, -1.34854659e-03f, 4.92770262e-02f, -1.02102356e-02f,
  4.49852310e-02f, -8.79966691e-02f, 3.13239470e-02f, -1.98735878e-01f, 1.88993081e-01f, 7.45704100e-02f, 1.75563544e-01f, 3.12317945e-02f, 2.84612566e-01f, -5.49599379e-02f,
  1.11078992e-01f, -2.94006944e-01f, 2.66070783e-01f, -2.66194552e-01f, 5.98223209e-02f, 1.44007146e-01f, 5.04020741e-03f, -6.67993054e-02f, 1.37534186e-01f, 2.22450886e-02f,
  -1.02827065e-01f, 2.69176401e-02f, -1.12349801e-01f, 1.42990779e-02f, -1.65362477e-01f, -8.39276165e-02f, -3.07914674e-01f, -4.54332121e-02f, -2.39196330e-01f, -8.78548995e-03f,
  1.46100849e-01f, 1.92091584e-01f, 8.28720164e-03f, -6.72805309e-02f, -1.93381980e-02f, 1.97175555e-02f, -4.54074144e-02f, 2.40546614e-02f, 1.23679955e-02f, -6.74361661e-02f,
  -4.90706079e-02f, 6.64936658e-03f, 5.11826202e-02f, 5.59166186e-02f, 1.75526750e-03f, -3.98146436e-02f, -3.66684087e-02f, 6.97221011e-02f, 4.84068878e-02f, 1.57592073e-03f,
  2.66420767e-02f, -3.52363102e-02f, -7.64023438e-02f, -3.03173978e-02f, -5.03457300e-02f, -1.95688009e-02f, -3.02658435e-02f, -8.92181024e-02f, -7.42243230e-02f, 3.56776416e-02f,
  3.79584134e-02f, -1.86163243e-02f, -1.11766625e-02f, -2.33312026e-02f, 2.00889409e-02f, 4.59672660e-02f, -8.37168470e-03f, 8.33968073e-03f, -2.57794876e-02f, 3.57676558e-02f,
  -3.05098910e-02f, -9.66726691e-02f, -1.20841116e-02f, -2.00925637e-02f, 2.06081718e-02f, -6.17732145e-02f, 6.45030895e-03f, 4.99965400e-02f, 2.97030769e-02f, -6.55771717e-02f,
  4.25933190e-02f, 9.89052374e-03f, -3.35469544e-02f, 2.11598836e-02f, 2.32138894e-02f, 1.00290207e-02f, -1.07963970e-02f, -1.00056073e-02f, -3.78132309e-03f, -2.71933991e-02f,
  3.00876517e-02f, 2.47032475e-02f, -1.69977788e-02f, -4.39874753e-02f, 2.37156507e-02f, -6.41909838e-02f, 2.51383262e-05f, -1.42524187e-02f, -1.60325821e-02f, 5.40083880e-03f,
  2.50448082e-02f, -8.35317746e-03f, -3.25120576e-02f, 2.95122410e-03f, 4.12245095e-02f, -2.43615862e-02f, 7.49712065e-02f, -8.84766728e-02f, 5.28272474e-03f, -2.94925477e-02f,
  1.54347690e-02f, -1.52725924e-03f, 1.20695811e-02f, -4.45643719e-03f, -5.50638251e-02f, -4.61757556e-02f, -6.17087772e-03f, 3.78572308e-02f, -1.38072511e-02f, -7.46811032e-02f,
  2.47075707e-02f, 4.57902998e-02f, 1.45700321e-01f, -2.03032047e-01f, -1.41658813e-01f, -6.40535131e-02f, -2.23385781e-01f, -5.66203371e-02f, -2.30397612e-01f, -5.08780591e-02f,
  -2.12844107e-02f, 6.51209652e-02f, 5.26033491e-02f, -1.73941925e-01f, -5.31660058e-02f, -1.08283229e-01f, -1.67093381e-01f, -4.78581674e-02f, -5.06494902e-02f, 9.51784030e-02f,
  -1.68143623e-02f, -5.01737855e-02f, -9.60954055e-02f, 7.51026496e-02f, 4.09842283e-02f, 9.62296873e-02f, 1.39155149e-01f, 1.56311095e-01f, 4.68003862e-02f, 3.98895554e-02f,
  -2.77850568e-01f, -7.13138655e-02f, 5.08804321e-02f, -5.37904054e-02f, 2.51512919e-02f, 1.10850595e-02f, 8.99362192e-03f, 5.31895906e-02f, -2.29798891e-02f, -3.85548100e-02f,
  5.29711843e-02f, 3.13369296e-02f, -4.05823626e-03f, -6.96415920e-03f, -1.13952835e-03f, -1.97196216e-03f, 6.25879411e-03f, -5.87826706e-02f, 3.42829488e-02f, 1.94174051e-02f,
  -7.42652118e-02f, -3.65370549e-02f, 1.55685032e-02f, 1.68646709e-03f, 2.62238905e-02f, -6.63766563e-02f, -2.82687955e-02f, 2.81404965e-02f, -8.14328417e-02f, -1.49066728e-02f,
  -2.06936821e-02f, 1.69657320e-02f, 2.95633171e-02f, -3.54307927e-02f, 1.46388998e-02f, 6.78131962e-03f, -9.00438335e-03f, 2.00060122e-02f, 4.49404269e-02f, -2.35020779e-02f,
  -6.05611131e-02f, -2.11063363e-02f, -3.79425846e-02f, -5.75473458e-02f, -3.12980562e-02f, -3.34179848e-02f, 4.45795543e-02f, 3.98890004e-02f, -1.77703239e-02f, -1.17332144e-02f,
  -8.30235705e-02f, -1.69046782e-02f, -8.97907000e-03f, -3.72231496e-03f, -1.91480853e-02f, -2.30639037e-02f, 1.71409815e-03f, 1.23860817e-02f, 1.28946546e-02f, 3.25187184e-02f,
  1.34102240e-01f, 3.12329322e-01f, -4.91939224e-02f, 1.84898917e-02f, -2.63192467e-02f, -3.94576676e-02f, -1.36918463e-02f, 1.58551224e-02f, 7.59224296e-02f, 1.59969144e-02f,
  2.05475949e-02f, -8.90864432e-03f, 3.55964340e-02f, -2.02755462e-02f, -2.42182259e-02f, 1.34709831e-02f, 6.85884133e-02f, 1.41125955e-02f, 8.18241853e-03f, 1.89435873e-02f,
  3.10928617e-02f, -1.38649263e-03f, 9.99704935e-04f, 5.42055257e-02f, -7.27030188e-02f, 9.41972621e-03f, -2.45307237e-02f, 4.36300524e-02f, 2.14301646e-02f, -4.15603071e-02f,
  -9.40584484e-03f, -2.26559281e-01f, 4.91543785e-02f, -2.50818461e-01f, 1.92610338e-01f, 8.47498775e-02f, 7.53620733e-03f, -6.82265386e-02f, -4.51813675e-02f, -2.10814565e-01f,
  -3.28341983e-02f, -1.82425827e-01f, 3.30677517e-02f, -9.61903110e-02f, 2.72979379e-01f, 9.37871933e-02f, -1.01697959e-01f, -9.13776532e-02f, -3.74279581e-02f, -1.34522200e-01f,
  1.05887480e-01f, -7.14832451e-03f, 9.18542743e-02f, 5.70219830e-02f, -4.09889147e-02f, -5.08476831e-02f, 3.82528678e-02f, 6.04532473e-02f, -1.32396579e-01f, -2.41711605e-02f,
  -5.07082120e-02f, -1.52904704e-01f, -6.26159366e-03f, 6.12114519e-02f, -3.23718674e-02f, 2.72899494e-02f, 1.32290674e-02f, 1.18488595e-02f, -5.13810925e-02f, 5.31692095e-02f,
  -9.29016434e-03f, -2.40465812e-02f, -2.87109017e-02f, 5.42936586e-02f, -3.28058563e-02f, -6.11443259e-02f, -8.28035641e-03f, 4.14314233e-02f, -4.00919765e-02f, -6.47122459e-03f,
  1.47830164e-02f, 3.75817786e-03f, -2.19324864e-02f, -4.21784483e-02f, 3.28378826e-02f, -6.71545491e-02f, -2.67528780e-02f, 1.04006790e-02f, 3.23248608e-03f, -5.71442060e-02f,
  1.97490621e-02f, -1.21702040e-02f, -7.88388192e-04f, -2.16049291e-02f, -2.22506560e-02f, 5.10426704e-03f, -3.88339646e-02f, -2.44902931e-02f, -3.54689211e-02f, -8.71888828e-03f,
  4.54402715e-02f, -1.78504437e-02f, 4.47886586e-02f, 3.00169662e-02f, -2.90867151e-03f, 8.59894138e-03f, -4.22468875e-03f, -3.37534957e-02f, 1.63980592e-02f, -1.63630431e-03f,
  2.99513415e-02f, 5.93826687e-03f, 2.44604424e-02f, 1.51638351e-02f, -1.32314395e-02f, -8.50849822e-02f, -4.87154815e-03f, -4.67737615e-02f, 3.09290141e-02f, 6.01120181e-02f,
  -2.74560839e-01f, -3.69575679e-01f, 3.19527350e-02f, -2.05162372e-02f, 2.18613166e-02f, 4.11881357e-02f, 4.75910529e-02f, -2.25401018e-02f, -2.70793755e-02f, 1.94297470e-02f,
  -1.65468883e-02f, 4.55569662e-03f, 8.22546426e-03f, -2.07878486e-03f, 1.23868855e-02f, -1.02828201e-02f, -2.66952794e-02f, -7.88838863e-02f, -4.47889306e-02f, -5.34004308e-02f,
  -2.96049807e-02f, 2.50454750e-02f, -1.93448309e-02f, 3.00485757e-03f, 6.35896623e-02f, -6.42126519e-03f, -3.66406655e-03f, -3.42557915e-02f, 1.41626531e-02f, 3.68300714e-02f,
  6.22108132e-02f, -3.90058570e-03f, -2.44336754e-01f, 1.02113634e-01f, -1.13866486e-01f, 1.89663488e-02f, 9.80320275e-02f, 9.21700243e-03f, 2.40449890e-01f, -6.58845305e-02f,
  2.03108996e-01f, -8.85325298e-02f, 1.96769848e-01f, 2.32702076e-01f, 2.86648899e-01f, 2.21209511e-01f, 1.07675314e-01f, 7.12091336e-03f, 1.76479653e-01f, 4.83404845e-02f,
  7.61933476e-02f, 2.21263662e-01f, -2.50892695e-02f, 1.48033574e-01f, -1.61056574e-02f, -1.08254343e-01f, 1.17558070e-01f, -4.81075458e-02f, -4.46158759e-02f, 7.53451213e-02f,
  1.29258215e-01f, 3.42704244e-02f, -1.71898916e-01f, -5.08963168e-02f, -1.09814979e-01f, -9.01717246e-02f, -1.36337280e-01f, 1.07319867e-02f, -1.44081805e-02f, 3.76981311e-03f,
  -5.30244671e-02f, -2.02492420e-02f, 4.08283733e-02f, 8.53098258e-02f, -6.20712750e-02f, 6.57427013e-02f, 4.56938893e-03f, -4.50949967e-02f, 5.79098705e-03f, -7.39529356e-02f,
  -9.34901536e-02f, -9.67543274e-02f, -6.84256926e-02f, -2.86833104e-02f, -3.98790836e-03f, 2.02098396e-02f, 2.92992536e-02f, -7.52828494e-02f, -7.57540837e-02f, -3.62075493e-02f,
  -8.94995183e-02f, -1.81924477e-02f, -6.34639477e-03f, 8.63492489e-03f, -3.83333787e-02f, 8.87677167e-03f, 2.31426908e-03f, 4.36102711e-02f, 1.65320374e-02f, 1.38575342e-02f,
  -1.09681085e-01f, -2.35726424e-02f, 5.77726439e-02f, -9.68340039e-02f, -1.04605593e-02f, -2.61177998e-02f, -1.30889574e-02f, 8.61491822e-03f, -9.53473616e-03f, -2.35802447e-03f,
  -1.18695069e-02f, -1.68890860e-02f, -3.47294635e-03f, 3.65678258e-02f, 2.51587201e-02f, -6.16358966e-02f, -1.01333270e-02f, 1.82478700e-03f, -6.62846118e-03f, -2.84812227e-02f,
  -1.80264011e-01f, -7.44843259e-02f, 1.45459622e-01f, -5.04667349e-02f, 3.22545022e-02f, -1.77578162e-02f, 1.46732941e-01f, -3.36722434e-02f, 3.54858153e-02f, 1.64773334e-02f,
  -8.47242549e-02f, 6.39486834e-02f, -6.30787164e-02f, -3.86386290e-02f, 1.03350114e-02f, -3.67142707e-02f, 5.35119921e-02f, -3.32325213e-02f, -2.57786773e-02f, -5.95251918e-02f,
  4.60274816e-02f, -2.90960837e-02f, 7.30095059e-02f, 3.73444607e-04f, -4.96464893e-02f, -5.75476624e-02f, -3.06712501e-02f, 3.95876504e-02f, -8.48079026e-02f, -6.05668537e-02f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.18369780e-01f, 2.34750748e-01f, 4.05507870e-02f, 1.56822249e-01f, -1.18819654e-01f, -1.56336084e-01f, 9.49344039e-03f, -1.09968692e-01f, -7.08809793e-02f, 5.83160520e-02f,
  -8.45152959e-02f, -5.86114526e-02f, -2.56254990e-02f, 1.93776771e-01f, 8.76254365e-02f, 1.21755609e-02f, -8.10670108e-02f, -6.54580593e-02f, -1.60162121e-01f, 2.02067960e-02f,
  6.64483011e-02f, 5.65717481e-02f, 7.08359256e-02f, 2.64307968e-02f, -2.19926722e-02f, -1.74418986e-01f, -1.36100715e-02f, 2.00730097e-02f, -4.68581952e-02f, 5.24489349e-03f,
  4.33382988e-02f, -2.46155392e-02f, 6.92498982e-02f, 2.37277858e-02f, -4.15502377e-02f, -9.39337909e-02f, -5.74274138e-02f, 5.55536002e-02f, -6.47441074e-02f, -3.01904660e-02f,
  1.06613794e-02f, 9.10245441e-03f, 5.20697348e-02f, -4.01754528e-02f, 3.86041887e-02f, -6.31248504e-02f, 9.78387445e-02f, -2.71176267e-02f, -1.26670580e-02f, 7.47687593e-02f,
  -2.99428646e-02f, 2.64494196e-02f, -2.39742119e-02f, -5.85848801e-02f, -9.11190826e-03f, -4.70441878e-02f, -7.43423998e-02f, 5.79100810e-02f, -3.11053563e-02f, 6.35090843e-02f,
  -1.86756365e-02f, 7.06203729e-02f, 9.49427951e-03f, -6.13587163e-02f, 9.99839790e-03f, 4.29450758e-02f, -1.44559750e-02f, 3.47697511e-02f, 6.68960856e-03f, 4.57610637e-02f,
  -5.88268004e-02f, -1.66865457e-02f, 2.40751971e-02f, 7.96837136e-02f, 4.73405309e-02f, 6.41788095e-02f, 1.13978580e-01f, 6.92194402e-02f, -3.35556604e-02f, 2.16756221e-02f,
  -5.07512875e-02f, 8.60837474e-03f, 1.88987348e-02f, -1.44091830e-01f, -1.95175875e-02f, -1.94804639e-01f, 4.50504981e-02f, -8.04405361e-02f, -5.51102161e-02f, 1.04960904e-01f,
  -4.68922518e-02f, 7.18897060e-02f, 4.52584513e-02f, -4.18064445e-02f, 2.82484125e-02f, 9.86157060e-02f, -2.63839979e-02f, 4.52889502e-02f, -8.04226995e-02f, 1.22456186e-01f,
  6.31323904e-02f, 1.55913029e-02f, -3.90504785e-02f, 1.53801190e-02f, 1.79768279e-02f, -2.66296864e-02f, 5.39044030e-02f, -1.38280109e-01f, -7.94135332e-02f, 6.21972494e-02f,
  -4.41750810e-02f, -4.40864637e-02f, -9.90918651e-02f, 7.06098825e-02f, -7.90053830e-02f, -1.17857456e-01f, -2.03925118e-01f, -4.96187359e-02f, -5.06726280e-02f, 2.93596461e-02f,
  -3.57933491e-02f, -8.39999318e-02f, -5.84113955e-01f, -2.03549668e-01f, -4.56729978e-02f, -5.21558583e-01f, -4.53192741e-01f, -5.53081036e-02f, 8.69243667e-02f, -6.73326722e-04f,
  -6.67489246e-02f, 7.96414912e-02f, -8.52493942e-03f, -1.21918902e-01f, 3.38832512e-02f, -4.08427380e-02f, -2.47469008e-01f, -2.24913895e-01f, -8.48723575e-02f, -2.79675037e-01f,
  -7.73967011e-03f, -8.78370032e-02f, -3.04451674e-01f, -9.98126641e-02f, -2.03120530e-01f, -9.40061081e-03f, 1.18729234e-01f, 1.54422689e-02f, -9.03945938e-02f, 9.09239501e-02f,
  3.60219032e-02f, 1.40467614e-01f, -3.52178067e-02f, -1.34131536e-02f, -2.17733294e-01f, -2.08666474e-02f, -3.92870829e-02f, -3.71845290e-02f, -4.17033955e-02f, -2.44742129e-02f,
  -1.14124706e-02f, 1.55817280e-02f, -9.05426778e-03f, 3.82373147e-02f, -7.66085684e-02f, -1.44526188e-03f, -1.05893582e-01f, -1.06919438e-01f, -1.42431363e-01f, -8.33892971e-02f,
  -1.24198020e-01f, -9.60591808e-02f, -9.58534107e-02f, 6.37241229e-02f, 5.58356149e-03f, 3.02879699e-02f, -8.31786245e-02f, -2.98333680e-03f, 3.62245776e-02f, -4.51237783e-02f,
  2.98222285e-02f, 1.61931645e-02f, -5.58548868e-02f, -7.57084275e-03f, -7.35897347e-02f, 3.32446098e-02f, -1.76080149e-02f, 5.59269972e-02f, -3.30896266e-02f, 1.98100740e-03f,
  -1.90032218e-02f, 4.48893830e-02f, 1.07808961e-02f, -5.49539700e-02f, -7.34405592e-02f, 5.22427484e-02f, 1.20425562e-03f, -3.93246207e-03f, -9.28113312e-02f, -5.59855700e-02f,
  2.24890783e-02f, -6.37951419e-02f, 3.46901221e-03f, -1.22663289e-01f, -5.39564639e-02f, -5.02621941e-02f, 2.54310109e-02f, -2.83339079e-02f, -2.32800357e-02f, 9.35507845e-03f,
  -2.34069854e-01f, -1.57334339e-02f, 8.97961408e-02f, 3.59465256e-02f, 9.33275893e-02f, 3.73874940e-02f, 1.61424614e-02f, 1.46073559e-02f, -1.21990569e-01f, 4.14891727e-02f,
  -5.64774983e-02f, 1.22109777e-04f, 1.62350833e-02f, 1.95491798e-02f, 5.38096903e-03f, -4.25182283e-03f, 3.13421674e-02f, 4.81447428e-02f, -4.36649211e-02f, -3.25977504e-02f,
  5.34241088e-02f, 4.24697325e-02f, 3.39744836e-02f, -6.01088628e-02f, -4.55017202e-02f, -3.96893136e-02f, 4.58258800e-02f, 4.15105373e-03f, -6.88315090e-03f, 5.24064936e-02f,
  2.99566418e-01f, -2.62781113e-01f, -6.25401318e-01f, -1.47445306e-01f, 2.68817514e-01f, 3.50028604e-01f, -8.21514651e-02f, 5.43853417e-02f, -2.49005899e-01f, 1.73903659e-01f,
  1.73989788e-01f, -2.69383579e-01f, -2.41822809e-01f, -4.84017842e-02f, 2.70295292e-02f, -2.08492562e-01f, 5.79425283e-02f, 4.41466309e-02f, -1.68830246e-01f, 7.28432983e-02f,
  -6.21267632e-02f, 2.38296241e-01f, -2.44356126e-01f, 1.72632813e-01f, 1.32397681e-01f, -1.03633283e-02f, 2.49116585e-01f, -4.33756039e-02f, 2.87735611e-01f, 5.59621863e-02f,
  -1.54428467e-01f, -1.17889464e-01f, -1.66804604e-02f, -6.33433983e-02f, 9.02885869e-02f, 8.41631591e-02f, 6.57507852e-02f, -6.23063743e-02f, -9.30866823e-02f, -5.83562329e-02f,
  4.56301635e-03f, -6.87207580e-02f, -2.86237540e-04f, 1.21723246e-02f, 1.02821330e-03f, -6.69852644e-02f, -1.02800615e-01f, -7.33939707e-02f, -9.58599448e-02f, -1.15952799e-02f,
  -5.99436574e-02f, -1.04771532e-01f, 5.72670624e-02f, -3.78495529e-02f, 1.47994934e-02f, -4.82847765e-02f, -5.92220612e-02f, -3.15336697e-02f, 1.03179421e-02f, 2.68259645e-03f,
  8.52741376e-02f, 1.02940109e-02f, 3.42148170e-02f, -3.13849887e-03f, -3.20881344e-02f, 7.22891884e-03f, 2.69431286e-02f, -1.21226078e-02f, -3.03848572e-02f, 9.67059378e-03f,
  9.36442986e-02f, 1.09449252e-02f, -7.15642273e-02f, 5.56389168e-02f, 3.95895884e-04f, -4.63527218e-02f, 1.75158344e-02f, 6.08933493e-02f, 9.22239572e-03f, -2.37222370e-02f,
  -5.28202206e-02f, -1.94666069e-02f, 3.33792865e-02f, 7.10404441e-02f, -4.91925292e-02f, -4.20090593e-02f, 5.93791604e-02f, -6.36568516e-02f, -2.05045473e-02f, 8.73690769e-02f,
  2.73776710e-01f, 2.48487085e-01f, -6.84383437e-02f, 1.54322600e-02f, -4.58712056e-02f, 7.95838013e-02f, -1.31304234e-01f, 2.76143607e-02f, 5.33007132e-03f, -3.47061530e-02f,
  7.32945725e-02f, 4.47084308e-02f, 1.17300063e-01f, -3.95255871e-02f, 2.59615947e-02f, 1.03314653e-01f, 3.82267423e-02f, 2.38341955e-03f, 1.13604181e-01f, -2.34198682e-02f,
  9.16823894e-02f, 1.09729454e-01f, -4.51724976e-02f, 7.11994246e-02f, 7.25075230e-02f, 3.95389944e-02f, 5.31891771e-02f, 8.97619054e-02f, 7.07399845e-02f, -1.30316183e-01f,
  9.47644189e-02f, -1.76689267e-01f, -6.91449493e-02f, 3.45763117e-01f, -4.93107997e-02f, -3.55076164e-01f, -5.40508270e-01f, 4.92669381e-02f, -2.54451722e-01f, -1.66954502e-01f,
  6.86742514e-02f, -9.41143483e-02f, -1.84521586e-01f, 1.56643346e-01f, 3.55833679e-01f, -3.47107321e-01f, 3.24467808e-01f, -1.10588022e-01f, -9.16290283e-02f, 8.12431872e-02f,
  8.79683495e-02f, 2.61031568e-01f, 1.51935220e-01f, 2.60463119e-01f, 5.71161732e-02f, 1.73471764e-01f, 4.46518362e-01f, 3.62456329e-02f, 3.78373206e-01f, 1.53583825e-01f,
  -1.45633161e-01f, -7.02002198e-02f, 7.68596753e-02f, 7.04721883e-02f, -6.98978873e-03f, 7.67441019e-02f, 8.92852060e-03f, -9.37438849e-03f, 1.35288434e-02f, 3.84536423e-02f,
  1.07980995e-02f, 8.58653113e-02f, 9.78458673e-03f, 1.78289264e-02f, -1.07796311e-01f, -1.79135818e-02f, -7.82798603e-02f, -1.54656321e-02f, -9.62168649e-02f, -1.33908009e-02f,
  -8.60420763e-02f, -2.08265521e-03f, -2.23612878e-02f, 3.96041572e-02f, 5.64114191e-03f, 6.86115250e-02f, -7.85512775e-02f, -2.51613222e-02f, -1.28490534e-02f, 3.74885350e-02f,
  3.64523865e-02f, -1.25255331e-01f, -5.59201650e-02f, 4.34889644e-03f, -3.61164473e-02f, 2.01427750e-02f, -2.83043794e-02f, -2.31971801e-03f, -4.25767750e-02f, 1.53424414e-02f,
  9.18205902e-02f, -8.47239513e-03f, 1.31593272e-01f, -7.63168335e-02f, -6.44979207e-03f, -8.73106718e-02f, -1.69646908e-02f, -3.75136510e-02f, -2.13101059e-02f, -5.84998168e-02f,
  1.21654160e-02f, 5.47613949e-02f, -1.90768335e-02f, 2.71293856e-02f, 3.58565561e-02f, 2.65859216e-02f, 2.79238708e-02f, 1.94271393e-02f, 6.49269065e-03f, -1.89250093e-02f,
  7.99223408e-02f, 2.20323488e-01f, -2.14171782e-02f, -4.67238650e-02f, 9.70682595e-03f, 1.91986319e-02f, 5.08630648e-02f, 8.01334251e-03f, 1.55641481e-01f, -1.16702560e-02f,
  -1.36879152e-02f, -7.52555281e-02f, -4.57530702e-03f, 5.70415296e-02f, 1.08232796e-01f, -3.72234508e-02f, 9.07555409e-03f, 9.27683264e-02f, 9.20462832e-02f, 1.26044706e-01f,
  2.91822404e-02f, 6.12382926e-02f, 8.31291080e-02f, -1.36790229e-02f, -1.67093109e-02f, -1.94147769e-02f, 1.13937974e-01f, -6.17583655e-03f, 4.21440229e-02f, 1.13140550e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  5.27320653e-02f, -3.75122786e-01f, -1.11965798e-01f, -4.13023889e-01f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  1.19932918e-02f, -7.96716988e-01f, -3.88953686e-01f, 4.79032099e-02f, 1.41241387e-01f, 2.29203492e-01f, -2.61442482e-01f, -4.58486021e-01f, 5.43724298e-02f, -4.12677020e-01f,
  -7.85447881e-02f, 4.43496585e-01f, 1.21944256e-01f, -8.40561464e-02f, -2.90494729e-02f, 4.41877097e-01f, 3.58561039e-01f, -3.11148494e-01f, 3.73274148e-01f, -8.37718099e-02f,
  3.47558498e-01f, 2.08522484e-01f, -2.41827205e-01f, 2.45615289e-01f, 4.21810418e-01f, -5.12511969e-01f, 2.42033064e-01f, -7.80056044e-02f, 1.75771460e-01f, -3.32755804e-01f,
  2.91580558e-01f, 9.76682082e-02f, 1.19823322e-01f, 2.23549232e-02f, 2.07795694e-01f, -4.21834826e-01f, 2.67425358e-01f, -2.65142500e-01f, -1.42681180e-02f, -1.97134644e-01f,
  -1.19925618e-01f, 1.74998492e-02f, -4.18861032e-01f, -2.21292585e-01f, 9.68794525e-02f, -4.39646006e-01f, 7.27232993e-01f, 2.28340968e-01f, 7.59016797e-02f, -1.55286148e-01f,
  1.39578491e-01f, 8.54583308e-02f, -2.25877762e-02f, -2.54126757e-01f, -1.16084129e-01f, -4.88770813e-01f, -4.52634782e-01f, 3.29799652e-01f, -5.27447224e-01f, 1.22787639e-01f,
  3.51321876e-01f, -1.05175354e-01f, 1.48648515e-01f, 5.36561906e-01f, 3.45817208e-01f, 2.58126706e-01f, 3.32104057e-01f, -1.97457612e-01f, 3.22521329e-01f, -1.16557553e-01f,
  -9.64693725e-02f, 3.32357943e-01f, -1.26532793e-01f, 4.28409763e-02f, 1.52851626e-01f, -1.14761487e-01f, 6.46175891e-02f, -3.21433067e-01f, -1.45801783e-01f, 5.59121609e-01f,
  2.12066129e-01f, 5.15197277e-01f, -3.63462746e-01f, -1.84456617e-01f, -1.31069317e-01f, -2.99769789e-01f, 4.66415018e-01f, -3.77949998e-02f, -5.31148970e-01f, 3.65823090e-01f,
  -3.09112489e-01f, -3.52965504e-01f, -7.98675045e-02f, 2.02108055e-01f, -1.59962118e-01f, 3.70652705e-01f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -9.44500118e-02f, 1.61988556e-01f, -6.10102806e-03f, -8.47099442e-03f, 1.14457309e-01f, -1.83682352e-01f, 1.23300992e-01f, 2.66774803e-01f, -4.53535430e-02f, 1.29391730e-01f,
  -1.31003886e-01f, -2.16074184e-01f, -2.46318683e-01f, 6.11311793e-02f, 3.26878369e-01f, 6.69307932e-02f, -1.09221287e-01f, -1.19510695e-01f, 9.58340168e-02f, -1.27678931e-01f,
  -5.69735318e-02f, -9.06376541e-02f, -2.34122097e-01f, -1.55022219e-01f, 1.27566040e-01f, 2.32359208e-02f, -1.71030357e-01f, 2.50423580e-01f, 2.85982966e-01f, 1.25504524e-01f,
  -7.66466409e-02f, 3.36280316e-01f, -5.24173938e-02f, -1.34304747e-01f, -2.80899286e-01f, 1.55979395e-01f, -9.08573121e-02f, -4.24307324e-02f, 4.79043797e-02f, -4.33001481e-03f,
  1.95562050e-01f, -2.54031211e-01f, -1.27562150e-01f, -1.63786590e-01f, -5.00099920e-02f, -4.11465652e-02f, -1.77346841e-01f, -2.83739548e-02f, -5.98231256e-02f, 3.29172820e-01f,
  1.35669291e-01f, -6.53926581e-02f, 1.64175242e-01f, 3.59578133e-01f, 3.30432117e-01f, -9.48142558e-02f, 1.00919068e-01f, 1.69338390e-01f, 1.10718034e-01f, -1.66439936e-02f,
  2.05321908e-02f, 6.03822172e-01f, -4.18226391e-01f, 7.28273466e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  2.42267977e-02f, -2.18309253e-01f, -1.75028682e-01f, -6.96984231e-02f
};

// L2_fan_Wp (Shape: 6 x 16)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  1.23271160e-01f, 2.03006759e-01f, -1.17470786e-01f, 4.07502614e-02f, -4.71071780e-01f, -1.22293808e-01f, -1.94012448e-01f, -7.89278448e-02f, 1.33446887e-01f, -4.27766778e-02f,
  2.03869715e-01f, 5.29891133e-01f, 7.08166882e-02f, -1.54678315e-01f, -1.62740514e-01f, 1.57247007e-01f, -4.11570668e-01f, 3.85417752e-02f, -1.46734595e-01f, 3.58276904e-01f,
  1.66934859e-02f, 4.16976959e-01f, 2.81953216e-01f, 4.70413834e-01f, 5.29397368e-01f, 5.81086576e-01f, 1.93186253e-01f, -5.95715716e-02f, 7.68451467e-02f, -2.64140010e-01f,
  -2.68604606e-01f, -3.31317723e-01f, 2.52721280e-01f, -4.14570212e-01f, 2.51105726e-01f, -3.46933544e-01f, -7.06857443e-01f, -3.35547090e-01f, 5.43366849e-01f, 2.80514836e-01f,
  1.40941530e-01f, 9.02440399e-03f, 4.28018987e-01f, 3.19910139e-01f, -4.13632952e-02f, 2.23996401e-01f, -1.06000610e-01f, -5.26722893e-02f, -4.18270439e-01f, -3.45479369e-01f,
  2.33349457e-01f, -5.27672529e-01f, -1.97980888e-02f, -3.61649729e-02f, 8.51668596e-01f, 5.29269099e-01f, 2.93551207e-01f, 3.10132384e-01f, -4.30695079e-02f, -4.64352936e-01f,
  -2.55752623e-01f, 3.55818272e-01f, 1.88020810e-01f, -2.31760040e-01f, -3.39660794e-02f, -3.72230709e-02f, -4.01648551e-01f, -8.12920406e-02f, -5.85784078e-01f, 1.40865728e-01f,
  7.69393402e-04f, -2.10983500e-01f, 6.02469802e-01f, 6.40998781e-01f, -1.49939910e-01f, 1.03355765e+00f, 3.30724627e-01f, 2.59293579e-02f, 1.56022355e-01f, -1.13720253e-01f,
  1.50271848e-01f, 1.92883968e-01f, 8.72326270e-02f, 1.08656093e-01f, 2.43235946e-01f, 1.81172322e-02f, 1.28862843e-01f, -6.92283154e-01f, -5.13564229e-01f, -4.27203983e-01f,
  -4.29980844e-01f, 2.83783615e-01f, -3.72272849e-01f, -1.11538410e-01f, 3.07187945e-01f, 4.74845499e-01f
};

// L2_fan_Wp_bar (Shape: 4 x 16)
const int L2_fan_Wp_bar_rows = 4;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  -6.51907250e-02f, 3.89100701e-01f, 1.33695289e-01f, 3.82987075e-02f, 3.33326638e-01f, 2.12206930e-01f, -4.97936904e-01f, 4.50076424e-02f, -2.52501965e-01f, 8.56997222e-02f,
  -2.47143239e-01f, 3.51633757e-01f, 2.76333004e-01f, 1.30882755e-01f, 7.15374053e-02f, 3.06570202e-01f, -9.55287889e-02f, 1.50376111e-01f, -7.29383007e-02f, 1.19785734e-01f,
  -2.30672166e-01f, 3.55450734e-02f, -8.98880959e-02f, -1.51960507e-01f, -9.30912867e-02f, -2.02878535e-01f, 1.29659459e-01f, 2.91995347e-01f, -3.52373719e-02f, 2.20048755e-01f,
  -1.29974768e-01f, -1.05632231e-01f, 2.15955034e-01f, 2.54595160e-01f, 5.43844044e-01f, 2.44352669e-01f, 5.40485121e-02f, 4.75872308e-02f, -4.76214647e-01f, -4.77344804e-02f,
  -4.65605378e-01f, -5.61761141e-01f, 1.44378366e-02f, 9.02729295e-03f, 1.05616182e-01f, -1.91034347e-01f, -1.13146126e-01f, 3.38623792e-01f, 2.22035795e-01f, 6.45512193e-02f,
  -2.87841648e-01f, 6.31836653e-02f, -1.82720304e-01f, -1.62169546e-01f, -1.09081909e-01f, -4.34998780e-01f, 1.17441066e-01f, 1.24543272e-02f, -3.00289184e-01f, 1.54173717e-01f,
  -1.83664352e-01f, 1.09609336e-01f, -1.29275009e-01f, 2.15677824e-03f
};

// L2_fan_Bp_bar (Shape: 1 x 4)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 4;
const float L2_fan_Bp_bar_data[] = {
  -1.22304693e-01f, -7.91317821e-02f, 2.52776146e-01f, 1.42787948e-01f
};

// L3_fan_Wp (Shape: 6 x 16)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  -7.55258976e-03f, -2.25276262e-01f, -4.09346640e-01f, 2.83532351e-01f, -5.21172881e-01f, -3.46826196e-01f, -1.15020894e-01f, 2.76602924e-01f, 7.61696994e-01f, 1.07228005e+00f,
  -1.46131823e-02f, -1.15699306e-01f, -2.49533549e-01f, -1.73954710e-01f, -1.02593057e-01f, -2.27382019e-01f, 2.60216475e-01f, 5.63910007e-01f, -2.94824362e-01f, 3.87058496e-01f,
  -6.19907916e-01f, 5.03587246e-01f, 4.83090878e-02f, -8.08262646e-01f, -2.43241906e-01f, -5.17286777e-01f, -3.14257681e-01f, 5.01384854e-01f, -1.73013844e-03f, 8.04435611e-02f,
  7.48243868e-01f, -2.12697089e-01f, -2.72169143e-01f, 4.19968188e-01f, -6.39768615e-02f, -4.40318882e-01f, 1.01935603e-01f, -2.48006031e-01f, 1.76684573e-01f, -6.81088626e-01f,
  -7.85037875e-01f, -1.82144359e-01f, -4.94797349e-01f, 7.84319103e-01f, 1.88080236e-01f, 8.44131112e-02f, 3.85186493e-01f, 2.90717483e-01f, 5.78304119e-02f, -3.02856475e-01f,
  -7.79622138e-01f, -5.49703240e-01f, 7.02315748e-01f, -5.96846104e-01f, 3.39361578e-01f, -2.17797294e-01f, 5.21070004e-01f, -4.27745044e-01f, 4.90262926e-01f, 2.19862580e-01f,
  3.86095971e-01f, 9.31767002e-02f, 1.20686628e-01f, 4.09162104e-01f, 2.39091404e-02f, -2.97025502e-01f, -7.23534524e-02f, -6.79594994e-01f, 2.51335114e-01f, -4.15345013e-01f,
  2.76544560e-02f, -3.51395993e-03f, -6.66343510e-01f, -7.10986078e-01f, 5.36344238e-02f, 9.24682021e-01f, 5.53020775e-01f, 1.72752038e-01f, 3.35531309e-02f, 1.20329998e-01f,
  -3.43267657e-02f, 5.29362798e-01f, -3.88753086e-01f, -3.52552325e-01f, -4.83307213e-01f, 2.61531323e-01f, 5.73194921e-02f, -3.99568975e-01f, -6.80026054e-01f, -8.86253417e-01f,
  -4.20988768e-01f, 7.16090798e-01f, 1.73664838e-01f, -1.99935902e-02f, 5.12245297e-01f, 1.56269908e-01f
};

// L3_fan_Wp_bar (Shape: 4 x 16)
const int L3_fan_Wp_bar_rows = 4;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  4.92830932e-01f, -1.42438263e-01f, -5.28451540e-02f, 4.61324483e-01f, 3.71702731e-01f, -9.30578560e-02f, 5.71105123e-01f, 2.76320130e-01f, 7.63876975e-01f, 5.69614410e-01f,
  5.90433061e-01f, -4.55285698e-01f, -3.17936033e-01f, 1.58722654e-01f, -6.24392033e-02f, -4.00529765e-02f, 2.02404246e-01f, 6.72600091e-01f, -2.16702148e-01f, 5.79610229e-01f,
  -6.05263650e-01f, 5.82949102e-01f, -3.22606593e-01f, -4.83724058e-01f, -2.68195659e-01f, -1.48629084e-01f, -4.89289016e-01f, 4.72917855e-01f, 8.58338475e-02f, 1.30468503e-01f,
  5.39143801e-01f, -1.82302848e-01f, 4.34058011e-01f, 1.38288409e-01f, 4.61670011e-01f, 1.81700557e-01f, -1.24949314e-01f, 1.07678235e-01f, -7.17742503e-01f, 5.88492870e-01f,
  -3.81806821e-01f, 7.20117450e-01f, -1.11866653e+00f, -8.50547105e-02f, -2.00753406e-01f, -3.72640342e-01f, -7.45046362e-02f, -2.88288891e-01f, 1.29681438e-01f, -5.94899170e-02f,
  2.65647650e-01f, 9.13015306e-02f, 6.76038682e-01f, 4.75424752e-02f, 1.00385815e-01f, 4.86472785e-01f, -5.35883248e-01f, -5.31485558e-01f, 1.91539615e-01f, -2.26533741e-01f,
  7.43866861e-02f, 3.38508710e-02f, 4.14996371e-02f, -1.37731761e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 4)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 4;
const float L3_fan_Bp_bar_data[] = {
  2.16645494e-01f, 5.15023947e-01f, 2.57988960e-01f, 3.45749468e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  7.55665079e-02f, 8.59952271e-01f, 4.33293074e-01f, -8.23821843e-01f, -2.61118859e-01f, 7.07104504e-01f, 6.60688460e-01f, -6.00882709e-01f, -2.51640052e-01f, -1.81657568e-01f,
  -2.92655140e-01f, -8.58774006e-01f, -1.31149679e-01f, -4.15429771e-01f, 9.33865368e-01f, -3.88635010e-01f, 4.88298178e-01f, -2.53274709e-01f, -3.52231078e-02f, 4.37000617e-02f,
  1.13467187e-01f, -9.47257638e-01f, -2.07099747e-02f, -8.84951055e-01f, -9.18650448e-01f, -6.94602370e-01f, -5.09385765e-01f, -8.23532045e-01f, 1.40137628e-01f, -6.67981029e-01f,
  5.55856049e-01f, 2.68432647e-01f, -4.82580930e-01f, -4.38474894e-01f, -7.44337618e-01f, 4.97608148e-02f, -5.48209064e-02f, -8.94982696e-01f, 8.31313908e-01f, -9.81865942e-01f,
  1.39321402e-01f, 1.84674844e-01f, -5.98400950e-01f, -2.41885304e-01f, 1.11491966e+00f, -4.95181561e-01f, -2.92589515e-01f, -1.54057503e-01f, -2.36313760e-01f, -8.17406595e-01f,
  -7.13172197e-01f, -3.51145715e-01f, -8.90970111e-01f, -4.18311715e-01f, -3.67284536e-01f, -1.65152729e-01f, -2.29982674e-01f, 1.34221375e+00f, 1.07108787e-01f, -1.90397039e-01f,
  -1.74212873e-01f, 4.66011912e-01f, -2.67728955e-01f, -2.07644016e-01f, -3.37864995e-01f, -1.90014005e-01f, -7.86481261e-01f, 8.87451768e-01f, 2.74497598e-01f, -5.06586075e-01f,
  -2.47428745e-01f, 2.45650951e-02f, 6.72195554e-01f, -8.40070784e-01f, 9.55764413e-01f, 2.91075826e-01f, -9.61697474e-02f, 6.95027053e-01f, 3.53455514e-01f, -2.92242676e-01f,
  5.70664823e-01f, 9.00197625e-01f, 6.17975652e-01f, -3.98172766e-01f, 5.47422647e-01f, 1.34157789e+00f, 2.10106283e-01f, 1.03287542e+00f, 1.52921617e-01f, -7.65708135e-03f,
  -4.71144736e-01f, 3.14331234e-01f, -3.65237325e-01f, 7.88632184e-02f, 8.46472204e-01f, 1.51873887e-01f, 5.39872527e-01f, -7.81823218e-01f, 6.60203457e-01f, -4.91673142e-01f,
  1.07469149e-02f, 1.01683462e+00f, 2.14567315e-03f, 6.50740683e-01f, 3.11753690e-01f, -4.03428599e-02f, -6.51328504e-01f, 9.05122578e-01f, -7.95726180e-02f, 5.91919482e-01f,
  1.91219747e-01f, -2.49439895e-01f, -2.71770298e-01f, 6.05424345e-01f, -9.53083575e-01f, -1.38317037e+00f, -8.71673524e-01f, -2.67728716e-01f, -3.25897902e-01f, 8.57401967e-01f,
  1.02272108e-01f, 6.36139572e-01f, 2.51329035e-01f, 1.11435175e+00f, -1.91630065e-01f, -4.26021814e-01f, -7.05445230e-01f, 1.61827654e-01f, 2.87923068e-01f, 8.04701030e-01f,
  8.09962377e-02f, 6.44125700e-01f, -4.96359527e-01f, 1.50785327e-01f, 8.42210352e-01f, -1.27587900e-01f, -7.82057643e-01f, 1.67100370e-01f, -4.25673604e-01f, -1.19178748e+00f,
  8.45956445e-01f, 5.60367219e-02f, -7.64519572e-01f, -2.14948520e-01f, 3.43051665e-02f, -6.83897614e-01f, 4.45782840e-01f, -2.92495817e-01f, 1.06998837e+00f, -2.22595677e-01f,
  -6.16816819e-01f, -8.99940878e-02f, 8.70622218e-01f, -6.38571084e-01f, -2.31020346e-01f, 8.59486699e-01f, -2.19468027e-01f, 6.62343323e-01f, 3.47153172e-02f, -1.85523897e-01f,
  -2.99790114e-01f, 8.74011159e-01f, 5.97492933e-01f, 9.90729928e-01f, 7.18292415e-01f, 1.00220716e+00f, -8.24024975e-01f, 3.37499492e-02f, -3.47037703e-01f, -3.33448142e-01f,
  2.43894964e-01f, 2.53834188e-01f, 5.17977178e-02f, -4.19547379e-01f, -2.96355873e-01f, 5.48323452e-01f, -7.66556919e-01f, -2.39306033e-01f, -2.34935418e-01f, 8.97129655e-01f,
  -3.93902540e-01f, -8.29080999e-01f, 1.63735420e-01f, 8.30857217e-01f, 7.35982656e-01f, 4.00021076e-01f, 1.11739707e+00f, 7.77690530e-01f, -1.48336604e-01f, 1.06905781e-01f,
  -2.74071544e-01f, 5.31137466e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -1.25407964e-01f, -1.73565194e-01f, -1.09414086e-01f, 1.23877868e-01f, -7.34587312e-02f, -5.89613393e-02f, 2.89649772e-03f, 2.72803813e-01f, -3.85641716e-02f, -1.55524850e-01f,
  3.44355434e-01f, 2.90279929e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    