/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.06241688e-01f, -1.34175420e-01f, -9.34514329e-02f, 8.91675353e-02f, -3.83523107e-02f, -2.96767000e-02f, 1.59888744e-01f, -1.39572948e-01f, -2.08381265e-01f, -7.37140030e-02f,
  1.21041618e-01f, 8.33064169e-02f, -8.76683835e-03f, 1.51602089e-01f, 4.99491721e-01f, 1.34560227e-01f, 2.15868056e-01f, 1.97268173e-01f, -5.22622792e-03f, -1.38711212e-02f,
  -3.27469371e-02f, 1.94418043e-01f, 9.23979729e-02f, -6.38217330e-02f, -1.71611577e-01f, -3.09111118e-01f, 3.48608978e-02f, 7.80912116e-03f, 2.81130187e-02f, 1.36713609e-01f,
  5.07843308e-02f, -2.70203054e-02f, -4.44207452e-02f, -1.99768506e-02f, -4.35276665e-02f, -7.58806840e-02f, 6.33026734e-02f, 9.37536284e-02f, 9.04541612e-02f, -9.97401178e-02f,
  -2.21697576e-02f, 9.63865779e-03f, -7.66754821e-02f, 1.50896847e-01f, -2.03989018e-02f, -2.61007287e-02f, -6.92031682e-02f, 3.41116898e-02f, -7.57336468e-02f, -7.52209201e-02f,
  -6.90820441e-02f, -4.45494987e-02f, -3.17380428e-02f, 3.29408310e-02f, -2.72481721e-02f, 5.07302349e-03f, -6.86243027e-02f, -2.67980956e-02f, -1.18058197e-01f, -1.26330843e-02f,
  3.97524834e-02f, -5.54335229e-02f, -7.85687342e-02f, -7.78368264e-02f, 1.18878320e-01f, -8.90532881e-02f, 1.00305282e-01f, 6.16075238e-03f, -1.04867388e-02f, 2.19186377e-02f,
  1.02926735e-02f, -2.06310190e-02f, -7.60696502e-03f, -5.69696128e-02f, -2.08390355e-02f, -1.01486087e-01f, -2.19828691e-02f, -8.38492066e-02f, 2.67942138e-02f, -8.10184181e-02f,
  8.19867179e-02f, 5.20679820e-03f, -3.15992609e-02f, -5.13867196e-03f, 7.20245466e-02f, 1.88522658e-03f, -2.30114050e-02f, -6.09904341e-03f, -1.00269213e-01f, 3.40560712e-02f,
  1.07333824e-01f, 4.11728509e-02f, -4.20224629e-02f, 6.94807619e-02f, -6.03898475e-03f, 1.32546984e-02f, 1.41048459e-02f, 6.98690265e-02f, 2.52525918e-02f, 1.67137962e-02f,
  -2.86448933e-02f, 2.13021822e-02f, 5.49561391e-03f, 1.18448295e-01f, 8.59414339e-02f, -4.81214859e-02f, -1.09681651e-01f, -1.19139664e-02f, -2.73381211e-02f, 4.38472368e-02f,
  5.27213253e-02f, -4.72374037e-02f, 2.80472934e-02f, -1.47870062e-02f, 1.89414509e-02f, 4.37792484e-03f, -7.31057161e-03f, 7.42398109e-03f, 4.89363484e-02f, -5.45532852e-02f,
  -4.29056793e-01f, -3.82855572e-02f, -1.70455072e-02f, -2.52197772e-01f, -6.65750355e-02f, 1.01259314e-01f, 2.77480483e-02f, -1.29886746e-01f, -2.13631600e-01f, 7.80610144e-02f,
  -1.43138379e-01f, -1.71742134e-03f, -5.50233461e-02f, -5.43649718e-02f, -1.89577356e-01f, 3.27669866e-02f, -7.15743378e-02f, 5.63923409e-03f, -1.28164455e-01f, -1.51475430e-01f,
  -1.69388413e-01f, -5.15505970e-02f, -6.82218522e-02f, 2.79380158e-02f, -6.08080775e-02f, -3.34727727e-02f, 2.40324158e-02f, -4.38815430e-02f, -8.13110173e-03f, 7.90153146e-02f,
  -9.49769840e-02f, 2.70007942e-02f, 4.45443625e-03f, 5.56941330e-02f, -1.07319308e-02f, 4.07230854e-02f, 9.96771231e-02f, -2.81428024e-02f, 7.79477283e-02f, -3.70436385e-02f,
  -1.63377095e-02f, -4.25329506e-02f, 5.88935129e-02f, 2.83951461e-02f, 1.15601584e-01f, -2.22791340e-02f, -5.26235513e-02f, -2.47590113e-02f, 1.13715502e-02f, -3.18803601e-02f,
  -3.95901687e-02f, 1.71027072e-02f, 1.31745413e-01f, 8.67191926e-02f, 7.45773017e-02f, 5.51703908e-02f, 4.30845842e-03f, 1.10294037e-01f, 2.17470750e-02f, -3.52979079e-02f,
  1.74481757e-02f, 8.80091861e-02f, 7.35435123e-03f, -5.66827459e-03f, -6.26788437e-02f, -8.16639140e-03f, -2.06083283e-02f, -7.03982776e-04f, 1.06817678e-01f, -8.08044747e-02f,
  -2.59839669e-02f, 2.30713235e-03f, -6.56315908e-02f, 8.24782327e-02f, -3.06313834e-03f, 6.86388314e-02f, -3.57680768e-02f, 6.37438335e-03f, 1.27481362e-02f, 1.72401015e-02f,
  -1.63479671e-02f, -3.45981196e-02f, 1.12350881e-02f, 2.69823242e-02f, 5.00297919e-03f, 4.23067585e-02f, -2.26134788e-02f, 6.12050667e-02f, -1.03147507e-01f, -3.46130948e-03f,
  -7.37948492e-02f, -5.81622608e-02f, -1.84775013e-02f, -6.50058761e-02f, 5.94314225e-02f, 2.34546158e-02f, -9.11378562e-02f, -6.31593540e-02f, 2.51142271e-02f, -3.10352780e-02f,
  2.56509800e-02f, 3.37141939e-02f, -1.20994961e-02f, 1.12106666e-01f, 5.85031919e-02f, -7.71885738e-03f, -6.54584840e-02f, -1.80627517e-02f, -4.69949469e-02f, 4.27119508e-02f,
  -1.62223075e-02f, -1.91214625e-02f, 9.83247906e-02f, -4.70175706e-02f, -1.07004680e-02f, 9.59381014e-02f, -9.18684304e-02f, 6.00355715e-02f, 1.06539682e-01f, 7.25685433e-02f,
  1.24675602e-01f, -8.24174508e-02f, -2.78228432e-01f, -7.89699703e-02f, 1.29491240e-01f, -1.92665502e-01f, -2.54622221e-01f, 4.88164127e-02f, -1.00125358e-01f, -5.39698871e-03f,
  6.94702119e-02f, -1.01183176e-01f, -1.29004404e-01f, -8.75334367e-02f, -1.00202568e-01f, -1.14932358e-01f, -5.69079816e-02f, -1.54983118e-01f, 9.55686495e-02f, 5.44429980e-02f,
  -7.55327344e-02f, 5.71400598e-02f, 4.42131795e-03f, 9.39753130e-02f, 1.06072374e-01f, 6.72238320e-02f, 3.01495135e-01f, 1.40726077e-03f, 1.68596342e-01f, 3.43409590e-02f,
  1.02661230e-01f, -1.15630284e-01f, -2.10551415e-02f, -8.63132104e-02f, 9.92676318e-02f, -4.09047678e-02f, -2.16701385e-02f, -1.09919563e-01f, -4.49073128e-02f, -3.83067206e-02f,
  -1.47989141e-02f, -2.41509024e-02f, 1.78972762e-02f, -8.58233124e-02f, 1.50418468e-02f, -1.11320697e-01f, 4.64103371e-02f, 2.82600764e-02f, -3.79846953e-02f, 7.18325898e-02f,
  -7.57154897e-02f, -1.96078978e-02f, -7.03413934e-02f, 5.91665180e-03f, -6.35440275e-02f, 1.01122633e-02f, 1.35050481e-02f, 2.32208651e-02f, 8.33347961e-02f, 7.11359754e-02f,
  -2.26583499e-02f, -3.15087512e-02f, 4.81546484e-02f, -1.11273276e-02f, 7.05234036e-02f, 6.87862113e-02f, -8.78060609e-02f, 1.18526891e-01f, -3.84201966e-02f, 2.21673381e-02f,
  3.82164083e-02f, 1.53369183e-05f, 5.72903045e-02f, -1.11778593e-02f, 7.95301348e-02f, 4.14787978e-02f, 2.97354739e-02f, 3.04289423e-02f, 5.06916419e-02f, 1.73583195e-01f,
  -5.35328314e-02f, 4.17935196e-04f, -5.06551452e-02f, -8.20597075e-03f, -5.55842370e-02f, -1.22842468e-01f, -7.68006295e-02f, -7.31282830e-02f, 1.13182729e-02f, -5.80890104e-02f,
  1.46590635e-01f, 6.22691661e-02f, 1.92884430e-02f, 4.42371182e-02f, 4.13053064e-03f, 7.13446289e-02f, -8.21437016e-02f, -3.63233648e-02f, 3.21625615e-03f, -3.72966714e-02f,
  5.92338033e-02f, 3.58530693e-02f, 5.01382165e-02f, -1.22655882e-02f, -3.90244909e-02f, 7.27726296e-02f, 4.86539491e-02f, 6.26312615e-03f, 5.97111657e-02f, 6.51149973e-02f,
  1.14400007e-01f, -5.09389117e-02f, -4.80386652e-02f, 3.69832106e-02f, 3.11134569e-02f, 5.39050438e-02f, 3.27509902e-02f, -4.77626212e-02f, 3.86353321e-02f, -1.61090381e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.84005189e-01f, 3.91745299e-01f, 2.50867039e-01f, 2.31968939e-01f, -1.27368450e-01f, -3.01473111e-01f, -1.69740647e-01f, 4.74137962e-02f, 3.83522063e-02f, -5.93185723e-02f,
  -2.65873881e-04f, 2.85838217e-01f, -1.01458207e-01f, 1.49359003e-01f, -5.50718531e-02f, -1.35490522e-01f, 2.84108110e-02f, -1.13103457e-01f, 2.81467009e-02f, 9.50586498e-02f,
  2.26658806e-01f, -4.83415611e-02f, 1.49784312e-01f, -6.71079084e-02f, 1.34813428e-01f, 1.55544654e-01f, 6.62596002e-02f, -5.62009625e-02f, 7.14966580e-02f, -2.60416605e-02f,
  -3.66678871e-02f, 1.18422307e-01f, 7.42517039e-02f, 5.17655909e-02f, 4.08589235e-03f, 2.74054278e-02f, 6.45773932e-02f, -7.12883472e-02f, -1.12323694e-01f, 9.67545807e-02f,
  2.18262635e-02f, -1.16380513e-01f, 4.03013490e-02f, 3.35170478e-02f, 4.09364626e-02f, 4.78397273e-02f, 6.62566721e-02f, 5.00176847e-02f, 5.69799915e-04f, 9.65798497e-02f,
  6.38331920e-02f, 8.95229075e-03f, 8.68834034e-02f, 9.49077122e-03f, 4.99569997e-02f, -8.28109458e-02f, -4.30286378e-02f, 3.76237556e-02f, -3.53043154e-02f, 1.30640224e-01f,
  1.45511106e-01f, -1.07549414e-01f, -5.95501475e-02f, -1.04170226e-01f, 3.50765027e-02f, 3.15782689e-02f, 9.71669853e-02f, -6.04661852e-02f, -3.10525615e-02f, -1.05245359e-01f,
  -1.08539559e-01f, -3.21739875e-02f, -6.26813024e-02f, 1.90972108e-02f, 6.71778917e-02f, -9.02670901e-03f, 2.05237679e-02f, -2.74999603e-03f, 2.79093273e-02f, 7.15002492e-02f,
  -8.90673883e-03f, -5.87232187e-02f, 2.67496090e-02f, 1.49198174e-01f, -2.11664680e-02f, -5.07262833e-02f, 7.54696056e-02f, 7.50530139e-02f, 5.43655222e-03f, 6.08956665e-02f,
  9.03829187e-03f, 1.02153644e-01f, 6.96990713e-02f, -6.69634482e-03f, -2.20915023e-02f, -2.04774970e-03f, 2.56871656e-02f, 6.97664823e-03f, 5.97986802e-02f, 3.89931202e-02f,
  1.63590536e-01f, -3.87555324e-02f, -4.40232717e-02f, 7.21941963e-02f, -5.76545112e-02f, -1.64186675e-02f, -9.37719177e-03f, 1.04991440e-03f, 7.42730349e-02f, 7.23524764e-02f,
  -9.01746191e-03f, -1.49856493e-01f, -5.06264977e-02f, 1.70199554e-02f, 5.70024177e-03f, 2.66899001e-02f, -9.51224193e-02f, 1.37271911e-01f, 1.64755285e-01f, -6.90037478e-03f,
  1.65344611e-01f, -3.00223231e-01f, -2.87202299e-01f, 1.25226229e-01f, 3.48155141e-01f, 1.96023304e-02f, -2.59099528e-02f, 1.14676818e-01f, -6.35292903e-02f, -3.55522595e-02f,
  -6.55996352e-02f, -1.56994060e-01f, -4.10069674e-01f, -1.06838442e-01f, -7.20077381e-02f, -3.96793604e-01f, 3.18161473e-02f, -2.47667953e-02f, -5.02402857e-02f, -6.34033903e-02f,
  -3.88136925e-03f, 1.33952707e-01f, -1.87192053e-01f, 9.31630954e-02f, 1.18179083e-01f, 1.32018134e-01f, -1.60872545e-02f, -3.36035341e-03f, 1.44072145e-01f, 5.19441180e-02f,
  2.49929377e-03f, -6.88800961e-02f, 2.39617806e-02f, -9.98643935e-02f, 7.58977830e-02f, 9.15903300e-02f, -4.33975086e-02f, -2.15581395e-02f, 1.03453442e-01f, 2.85489969e-02f,
  -1.19400643e-01f, 1.48917899e-01f, 2.06814874e-02f, 2.65987776e-02f, 5.40859997e-02f, -5.49363866e-02f, -2.42566969e-02f, -3.10115293e-02f, -1.82530552e-01f, -7.05236644e-02f,
  -6.97260126e-02f, -2.11347956e-02f, 3.04336660e-02f, 1.01789482e-01f, -2.94525325e-02f, -5.41764870e-02f, -1.48369625e-01f, -1.51713923e-01f, 1.96477678e-02f, 1.62842721e-02f,
  5.70929833e-02f, -8.06866288e-02f, 2.66102776e-02f, 2.62841918e-02f, 1.17115239e-02f, 1.17699258e-01f, 2.85451319e-02f, -4.44849906e-03f, -1.20452873e-01f, 1.88022647e-02f,
  3.49504761e-02f, 6.08368777e-03f, -1.50073364e-01f, 7.25490972e-03f, 3.00087593e-02f, -7.06645176e-02f, 1.55599834e-02f, 8.26517493e-02f, 8.87470767e-02f, -4.12733294e-02f,
  -6.87848628e-02f, 9.44686756e-02f, 9.57585052e-02f, -3.30622569e-02f, -3.42477895e-02f, 1.09219648e-01f, -2.35080998e-02f, -2.48324983e-02f, 1.50142144e-02f, 3.29965241e-02f,
  -1.51254488e-02f, -1.88119397e-01f, 6.47316920e-03f, -7.33871087e-02f, -3.14627495e-03f, 5.78167886e-02f, -4.14655432e-02f, 2.76548304e-02f, 1.25242457e-01f, 4.46376316e-02f,
  1.09696835e-01f, 9.01807845e-02f, 1.38274074e-01f, 3.69370393e-02f, -4.33558896e-02f, 2.70662103e-02f, -3.85594629e-02f, 1.27837718e-01f, -2.06314716e-02f, 9.27749127e-02f,
  -5.05072251e-02f, 1.04784049e-01f, -2.94969697e-02f, 1.13463119e-01f, 5.23463339e-02f, -7.91726634e-03f, 4.44023162e-02f, -2.93933302e-02f, -8.18666145e-02f, -4.12519351e-02f,
  -5.38643301e-01f, 4.23814774e-01f, -1.55426105e-02f, -3.36423218e-01f, 2.43798196e-01f, 2.79387627e-02f, -1.02819383e-01f, 1.92773677e-02f, -1.26316935e-01f, -2.62009576e-02f,
  3.21976393e-02f, -5.15992269e-02f, 6.09581918e-02f, 4.15581167e-02f, -3.33656430e-01f, -3.46587375e-02f, -1.57895416e-01f, -1.68851763e-01f, 1.17917806e-01f, 7.25347698e-02f,
  2.11705756e-03f, 7.24938214e-02f, 3.75720859e-02f, 2.46695057e-01f, 2.37523783e-02f, 1.00929275e-01f, -1.23114020e-01f, 7.40869939e-02f, -5.53937331e-02f, -7.05587678e-03f,
  3.27610783e-02f, -5.93501851e-02f, -4.89213653e-02f, -6.63781613e-02f, -2.49663070e-01f, -9.53256786e-02f, -1.42178133e-01f, -4.97085266e-02f, -2.45242249e-02f, -5.93297780e-02f,
  -2.74127051e-02f, 7.32318163e-02f, -6.81328923e-02f, 8.68246928e-02f, 1.51455989e-02f, 4.33242582e-02f, 2.70216819e-02f, 6.08559176e-02f, 3.30049247e-02f, 1.94025766e-02f,
  7.25955218e-02f, 1.35686733e-02f, -5.19762076e-02f, -1.07212767e-01f, 2.19709892e-02f, 5.14331684e-02f, -6.99074566e-02f, -3.87521088e-02f, -3.82635668e-02f, -1.66788865e-02f,
  -1.73511848e-01f, -5.33989519e-02f, 3.61647755e-02f, -6.56489562e-03f, -4.53758985e-02f, 3.22725400e-02f, 1.25946905e-02f, -1.80887971e-02f, 3.38222459e-02f, 1.79780945e-02f,
  -4.42613065e-02f, -1.90262496e-02f, 1.20648831e-01f, 3.73221040e-02f, 4.35742624e-02f, -7.16766715e-02f, 8.59866589e-02f, 4.55975123e-02f, 1.06888674e-01f, -1.78556889e-02f,
  -1.64094493e-02f, -7.13236332e-02f, -5.53093210e-04f, 8.61710906e-02f, -1.72509521e-03f, -1.72885675e-02f, 1.00633837e-01f, 4.27290946e-02f, -3.37270042e-03f, 3.48901306e-03f,
  -6.24003336e-02f, -3.58039439e-01f, -4.61980961e-02f, 2.30148043e-02f, -9.71225873e-02f, 2.97084358e-03f, -8.13776851e-02f, 9.84196644e-03f, 2.12091859e-03f, -4.76596169e-02f,
  2.68776473e-02f, 2.36514679e-05f, -5.20981364e-02f, -2.61354316e-02f, -1.12325046e-02f, -3.88112217e-02f, 2.02360153e-02f, 2.44096126e-02f, -2.66772900e-02f, 1.55602181e-02f,
  1.11030191e-02f, 1.51693290e-02f, 2.77185366e-02f, -2.47095227e-02f, -1.17032997e-01f, -1.09665647e-01f, -3.54183726e-02f, 3.67336124e-02f, 1.69004519e-02f, -5.50780632e-02f,
  -2.35498976e-02f, 2.54513651e-01f, -3.29073727e-01f, 1.29731484e-02f, -2.24377677e-01f, 3.65367353e-01f, 2.73822635e-01f, 1.32543072e-01f, -9.96490270e-02f, 4.28914577e-01f,
  2.48445615e-01f, -5.81432916e-02f, 2.30641916e-01f, 3.72954398e-01f, -1.12012126e-01f, 3.18547517e-01f, 2.24009797e-01f, 1.11820877e-01f, -1.04783148e-01f, 1.26727104e-01f,
  -8.21362287e-02f, 3.41694683e-01f, 8.60711001e-03f, 1.45022213e-01f, 8.75957757e-02f, -2.02931449e-01f, -9.35384110e-02f, -2.80012935e-01f, 1.69680286e-02f, -4.97920997e-02f,
  1.73915759e-01f, 1.07038738e-02f, -4.94531058e-02f, -5.47902100e-02f, -1.02320582e-01f, 4.12794240e-02f, -6.20713644e-02f, -4.44539040e-02f, -1.10872142e-01f, -4.91008647e-02f,
  -1.08704604e-01f, 1.10230044e-01f, 8.70166868e-02f, -1.67106260e-02f, -1.13045320e-01f, -1.17137708e-01f, -1.00925580e-01f, -7.79401064e-02f, -2.69931946e-02f, -3.33512574e-02f,
  -6.32880405e-02f, -4.67327349e-02f, 2.18598880e-02f, -1.00321742e-02f, -1.29489839e-01f, -8.25450697e-04f, 6.93630651e-02f, -1.17942855e-01f, -1.16255008e-01f, -7.05617070e-02f,
  -1.75942928e-02f, 7.22109824e-02f, 7.76138306e-02f, -4.96881530e-02f, 5.06210700e-03f, 1.34950187e-02f, -2.25443635e-02f, 1.50238611e-02f, -7.65961707e-02f, 7.98279569e-02f,
  -9.50248446e-03f, -4.98534217e-02f, -8.88341665e-03f, -2.38580117e-03f, 1.68436691e-02f, 5.76546118e-02f, -4.67767753e-02f, 1.03276320e-01f, -2.98713427e-02f, -1.83128938e-02f,
  -5.60116246e-02f, 7.83807412e-02f, 5.61506636e-02f, -2.27527902e-03f, -3.87000367e-02f, -7.65661821e-02f, -7.13543445e-02f, 8.99031237e-02f, -4.46247198e-02f, -2.66772825e-02f,
  4.39311489e-02f, 3.23494188e-02f, 8.71845335e-02f, -3.51638743e-03f, -1.29630715e-01f, 5.39929010e-02f, -4.75367298e-03f, 4.30153906e-02f, 5.17173521e-02f, 4.33248132e-02f,
  -5.54341376e-02f, 5.14018051e-02f, -1.15570337e-01f, -1.06145181e-01f, -1.45340890e-01f, 5.94501272e-02f, 4.82177362e-02f, -6.63651600e-02f, -7.45364577e-02f, -7.61569068e-02f,
  8.83546937e-03f, 9.78819430e-02f, -3.62948328e-02f, 3.79095674e-02f, -2.60488242e-02f, 4.15496379e-02f, -7.25299492e-02f, -2.33139563e-02f, -1.45085037e-01f, -3.92315676e-03f,
  3.88942420e-01f, -1.55429393e-01f, 1.19464546e-01f, 1.88666120e-01f, 2.18498290e-01f, 2.55761649e-02f, 3.30038100e-01f, 6.26034215e-02f, 1.46078929e-01f, -2.87744999e-01f,
  -7.65003935e-02f, 2.60775425e-02f, -8.00669119e-02f, -7.29616284e-02f, 3.10772628e-01f, -8.48567637e-04f, 2.32397407e-01f, 1.94379255e-01f, -1.13434745e-02f, 1.05998956e-01f,
  1.94833606e-01f, 1.60377890e-01f, -3.28572914e-02f, -1.65544003e-01f, 8.14069659e-02f, -1.69101164e-01f, -8.17214102e-02f, 2.21883561e-02f, -1.92892283e-01f, 3.10174543e-02f,
  5.18803336e-02f, 6.20942600e-02f, 9.21859816e-02f, -3.63729298e-02f, -1.23837478e-01f, -5.86418286e-02f, -1.24753326e-01f, 2.31577568e-02f, 6.04695417e-02f, -8.69977623e-02f,
  -4.38923165e-02f, -2.25974098e-02f, -3.18313800e-02f, 8.51171315e-02f, 1.27553582e-01f, -2.20246073e-02f, 3.88052873e-02f, -4.05027978e-02f, -8.86439607e-02f, -2.49298792e-02f,
  1.40895275e-02f, -4.42344055e-04f, 1.09114699e-01f, -1.28128156e-01f, -5.38229905e-02f, -4.72421348e-02f, -1.81691751e-01f, -3.52063291e-02f, -3.52983549e-02f, -8.18028823e-02f,
  1.54844616e-02f, 3.37837450e-02f, 4.27453266e-03f, 2.48739049e-02f, 1.55273482e-01f, -8.77142027e-02f, -4.12574522e-02f, -4.59138863e-02f, 1.73332021e-02f, -2.92047057e-02f,
  -3.68762277e-02f, -7.24144699e-03f, -2.50876620e-02f, 1.01646312e-01f, -1.12415209e-01f, 7.40857841e-03f, 2.10939944e-02f, -1.24614365e-01f, -6.31281137e-02f, -8.64580199e-02f,
  -3.97423953e-02f, 8.20731893e-02f, 8.65943655e-02f, -5.64099476e-02f, -5.86757995e-02f, 1.10673606e-01f, -8.24273005e-02f, 6.20601475e-02f, -6.21737614e-02f, 1.32577410e-02f,
  4.48811650e-02f, 8.06314051e-02f, 2.10962500e-02f, 7.55679756e-02f, -4.76471335e-03f, 2.27306392e-02f, 9.33222994e-02f, 3.98890898e-02f, 4.15936485e-02f, 5.86627834e-02f,
  -6.93886727e-02f, -4.70199697e-02f, -5.37021011e-02f, -9.88975093e-02f, 8.22290331e-02f, -8.88932347e-02f, -6.77854614e-03f, -5.10283187e-02f, 4.73932922e-02f, -6.25831187e-02f,
  -3.55857760e-02f, -3.95487994e-02f, 3.00712660e-02f, 6.23437315e-02f, -1.38504669e-01f, -1.67433769e-02f, -3.93313635e-03f, -3.61347920e-03f, -8.01443979e-02f, 5.61692342e-02f,
  2.74012625e-01f, -3.26610923e-01f, -8.75860080e-02f, -1.75831035e-01f, 1.04937069e-01f, -8.79537165e-02f, 1.19053848e-01f, -2.67392278e-01f, -2.04428077e-01f, -2.12604627e-01f,
  5.67775685e-03f, 5.91426231e-02f, 1.48421288e-01f, -2.73568779e-01f, 1.98047832e-01f, 1.23591851e-02f, -3.01123440e-01f, -2.42689643e-02f, 1.20941728e-01f, 4.56958488e-02f,
  5.82436323e-02f, -1.63289860e-01f, -4.26422358e-02f, -2.08941460e-01f, -6.49726167e-02f, 7.72329513e-03f, 2.84814835e-01f, 2.23458871e-01f, -8.94405842e-02f, 6.89761788e-02f,
  1.09122330e-02f, -4.94981706e-02f, -8.51577595e-02f, 2.07889862e-02f, 3.03949788e-02f, -2.57847887e-02f, 7.41806999e-02f, 4.90152501e-02f, 5.87484464e-02f, -1.23659663e-01f,
  -5.25884815e-02f, 6.24481663e-02f, -2.42843449e-01f, 1.21960334e-01f, -4.75671217e-02f, -5.72264157e-02f, 3.10835335e-02f, -7.39359409e-02f, -2.64384270e-01f, -6.22157194e-02f,
  1.00994162e-01f, -3.54353450e-02f, -2.73018721e-02f, -2.69922353e-02f, -3.08771264e-02f, -1.82042927e-01f, -1.84915923e-02f, 4.87901419e-02f, -7.07474351e-02f, -6.54566810e-02f,
  4.61382344e-02f, 8.37847590e-02f, 8.64812210e-02f, -4.34611067e-02f, -3.70729715e-02f, -9.16051418e-02f, -3.15726623e-02f, -2.75595933e-02f, 9.15460810e-02f, -3.90320793e-02f,
  -1.18684418e-01f, -8.98912326e-02f, 9.65873897e-02f, 2.24638823e-03f, 2.56849993e-02f, -1.43505663e-01f, 2.24923398e-02f, -1.07407346e-02f, 9.92672294e-02f, -9.53713134e-02f,
  9.27137025e-03f, -8.32571238e-02f, 6.32255226e-02f, -2.41330657e-02f, -2.86897421e-02f, -1.53090600e-02f, -3.90546583e-02f, -2.64086984e-02f, -4.00839150e-02f, 1.02466978e-01f,
  -1.38355583e-01f, -4.31092605e-02f, -1.14926726e-01f, 5.83857857e-02f, -1.38980215e-02f, 5.87768294e-02f, 1.22728979e-03f, -1.34443283e-01f, 1.18562222e-01f, -1.34032723e-02f,
  4.50082198e-02f, -2.00097952e-02f, 3.80994007e-03f, 4.84035872e-02f, -9.16709229e-02f, -6.85473904e-02f, 6.17594384e-02f, -8.71940516e-03f, -8.69196206e-02f, -9.08106714e-02f,
  1.32202730e-01f, 9.44031104e-02f, 1.23184040e-01f, 5.48346564e-02f, -2.71320697e-02f, 1.91480629e-02f, -2.02149691e-04f, 1.03691526e-01f, 9.24693421e-03f, -5.33879362e-02f,
  -4.79532838e-01f, 2.41317555e-01f, 4.67501521e-01f, -1.91420361e-01f, 1.58946484e-01f, 4.45141733e-01f, 2.69754261e-01f, 9.85676944e-02f, 8.27017725e-02f, -9.44117606e-02f,
  -9.71182957e-02f, -1.65282972e-02f, 5.09271100e-02f, -2.37213790e-01f, 2.51562268e-01f, 2.45499849e-01f, -7.59688243e-02f, -4.73691188e-02f, 1.84031144e-01f, -2.12369934e-02f,
  7.27901533e-02f, 7.59055838e-03f, 7.05917850e-02f, 6.14619106e-02f, 8.96077417e-03f, -9.31562558e-02f, -1.63008958e-01f, 1.25386134e-01f, -1.76151574e-01f, 1.76508054e-01f,
  2.64835060e-02f, -1.86168566e-01f, -4.37939800e-02f, 8.83820876e-02f, -3.33359689e-02f, -3.79956998e-02f, 6.58963844e-02f, 6.51021674e-03f, 6.98187426e-02f, 5.84015856e-03f,
  -2.75378209e-02f, 1.01435192e-01f, 6.61008507e-02f, -3.24021745e-03f, 8.42882395e-02f, -2.02627946e-02f, 2.25429665e-02f, 6.79470450e-02f, 9.90997907e-03f, -1.56100253e-02f,
  1.98635552e-02f, 5.11939041e-02f, -2.88945362e-02f, 2.90714583e-04f, -1.30651563e-01f, 1.73130929e-02f, 9.11489725e-02f, 2.32715702e-05f, 3.42549607e-02f, 1.22655332e-01f,
  -2.91533545e-02f, -1.36904642e-02f, 2.76810676e-02f, -3.82217877e-02f, -3.88809815e-02f, 4.79339324e-02f, -1.39690399e-01f, -1.30026847e-01f, -5.43210395e-02f, -9.57726408e-03f,
  1.38215600e-02f, -3.97591144e-02f, 9.58888531e-02f, -4.22368161e-02f, -2.60248184e-02f, -9.07030478e-02f, 3.17264535e-02f, 2.92067435e-02f, 4.81115095e-02f, -5.67023270e-02f,
  -6.51098937e-02f, 5.48582561e-02f, -2.51728017e-02f, -5.33742197e-02f, 3.04656103e-02f, 3.38112749e-02f, -1.13882788e-01f, 9.46793780e-02f, -1.37061300e-02f, 1.17978834e-01f,
  8.06297734e-02f, 9.63842124e-02f, -1.72822513e-02f, 3.54216583e-02f, -5.75031154e-02f, -2.87917480e-02f, 3.81748378e-02f, -1.31867394e-01f, 2.01535393e-02f, 2.86795869e-02f,
  8.09732974e-02f, -8.11426342e-02f, 7.11535886e-02f, -3.28799821e-02f, 3.49198207e-02f, 1.34279981e-01f, -6.89751506e-02f, 1.24237537e-02f, -1.39350705e-02f, -1.99136194e-02f,
  -4.44410406e-02f, 4.65338975e-02f, -1.47535689e-02f, -6.74972311e-02f, -5.99747747e-02f, -6.75246343e-02f, -5.86770438e-02f, 3.97269130e-02f, 1.50380656e-01f, 1.01075675e-02f,
  2.13945776e-01f, -2.70240277e-01f, -2.54398137e-01f, -3.01168352e-01f, -1.99778423e-01f, -2.84199893e-01f, -1.70732930e-01f, -1.06885448e-01f, -1.34622008e-01f, 2.10798029e-02f,
  -1.85623005e-01f, 7.79744536e-02f, 7.47228563e-02f, -2.20525667e-01f, 9.04166996e-02f, 2.17765436e-01f, -3.20535809e-01f, -1.83438078e-01f, 6.54005855e-02f, -1.36497706e-01f,
  -1.37452502e-04f, -1.93255708e-01f, 9.05459821e-02f, -1.54670760e-01f, -1.20280549e-01f, -5.33464737e-02f, 1.62683472e-01f, -1.82268769e-01f, -1.47093013e-01f, -8.13370869e-02f,
  -2.78370865e-02f, -7.23569542e-02f, -6.43357635e-02f, -3.50275300e-02f, -6.49449378e-02f, -7.98159838e-02f, -9.82189402e-02f, 3.80094759e-02f, 3.22957858e-02f, 4.10412997e-02f,
  -3.95684615e-02f, 5.20756189e-03f, 4.06651869e-02f, -8.86539146e-02f, -1.06717914e-01f, -1.08051747e-01f, -6.83053583e-02f, -2.56829187e-02f, -4.88922233e-03f, 4.48410884e-02f,
  -2.77203023e-02f, -8.05026814e-02f, -7.03730881e-02f, -8.81613567e-02f, 4.49157925e-03f, -5.53352050e-02f, 7.67182112e-02f, -1.50111513e-02f, -9.88689624e-03f, 3.99056524e-02f,
  8.06625336e-02f, -5.71066067e-02f, 9.98126417e-02f, -5.36747202e-02f, 2.56515779e-02f, 2.79483665e-02f, 1.47305233e-02f, 2.96403263e-02f, 6.33838878e-04f, 4.40321909e-03f,
  -8.40319134e-03f, -3.32580470e-02f, 8.22916105e-02f, 3.49271894e-02f, 2.20709890e-02f, 7.84755126e-02f, 4.36425097e-02f, 2.35841554e-02f, 1.64800161e-03f, -2.93697324e-02f,
  3.23215947e-02f, -1.55659830e-02f, -1.46329496e-02f, -6.45622611e-02f, -5.39415963e-02f, 4.00809683e-02f, 6.93747401e-02f, 1.06567800e-01f, -5.76008372e-02f, -1.84863284e-02f,
  -1.48911938e-01f, -1.81126762e-02f, -2.06994191e-02f, 1.81346375e-03f, -6.82986006e-02f, -2.09862320e-03f, -6.82643503e-02f, -9.02983546e-02f, 4.00385400e-03f, -4.55451794e-02f,
  -1.22252598e-01f, -8.72019082e-02f, 1.05532603e-02f, -7.81766325e-02f, -3.95724662e-02f, -4.75576818e-02f, 1.71969179e-02f, 5.52888550e-02f, -1.02344342e-01f, -1.96171124e-02f,
  -7.19042197e-02f, -3.07467524e-02f, -2.00186167e-02f, -9.54702720e-02f, -6.86578304e-02f, 5.56604192e-02f, -3.11352126e-02f, -4.63485904e-03f, 3.78197394e-02f, -1.11379912e-02f,
  -7.21008852e-02f, 1.23803139e-01f, -1.88430473e-01f, 4.44342345e-02f, -5.13608661e-03f, 1.32489279e-01f, 2.10464671e-01f, 3.80387567e-02f, 2.84939669e-02f, 3.34859341e-01f,
  7.81962648e-02f, 2.96308789e-02f, 2.47219969e-02f, 3.71807218e-01f, 1.00415185e-01f, 9.29125473e-02f, 3.03935140e-01f, 1.61472067e-01f, -2.52305605e-02f, 6.19979687e-02f,
  4.81709838e-02f, 2.99540937e-01f, -4.91388515e-02f, -3.90549786e-02f, 8.09402019e-03f, -1.20202012e-01f, 2.88281497e-02f, -1.10804737e-01f, 7.27849156e-02f, 1.82196289e-01f,
  1.03605419e-01f, -1.61886495e-03f, -5.76846227e-02f, -4.33841608e-02f, -1.39858067e-01f, -1.19865045e-01f, -1.74762141e-02f, -1.52932376e-01f, -5.36348447e-02f, -7.48081889e-04f,
  2.42367834e-02f, -6.51837960e-02f, 3.12984996e-02f, -1.09748952e-01f, 1.73895154e-02f, -3.10454075e-03f, -5.91483042e-02f, -8.77684206e-02f, -1.16332777e-01f, -7.27227004e-03f,
  -8.41911044e-03f, 3.15478817e-02f, 1.72778238e-02f, 1.52436066e-02f, -2.06372533e-02f, 1.15324207e-01f, 7.21539743e-03f, -9.75738838e-02f, 6.91242814e-02f, -8.51299986e-02f,
  -1.61072463e-02f, 2.51397826e-02f, -8.92219692e-02f, -1.25837568e-02f, -6.10094033e-02f, -1.20387800e-01f, 6.09239899e-02f, 2.85592326e-03f, -5.14398180e-02f, -1.85499787e-02f,
  9.23274271e-03f, -3.69136669e-02f, -5.11717871e-02f, 3.37292291e-02f, 1.01406783e-01f, 2.72682235e-02f, -8.85413364e-02f, 5.20524494e-02f, 4.53636535e-02f, 3.39274779e-02f,
  2.70841867e-02f, -1.87777709e-02f, 6.77857846e-02f, 3.20754535e-02f, 9.40119326e-02f, 3.53000164e-02f, 2.12850384e-02f, -2.54107406e-03f, -3.37453634e-02f, -2.01565120e-02f,
  1.53630048e-01f, 1.90550908e-01f, 9.98689886e-03f, -7.01436251e-02f, -1.57804918e-02f, -2.51717661e-02f, 6.94081187e-02f, 1.13418419e-02f, -1.03127444e-03f, -6.13078736e-02f,
  -4.64717150e-02f, -5.97538352e-02f, -6.89797550e-02f, -8.27895775e-02f, 2.65177060e-02f, 6.15472943e-02f, 6.45557716e-02f, -1.22514479e-01f, 1.72296111e-02f, 3.88965979e-02f,
  6.30570948e-02f, 5.46420999e-02f, -1.37329638e-01f, -4.79646400e-02f, 7.30816275e-02f, 1.85049102e-02f, 5.92841841e-02f, -1.18858799e-01f, -2.53133569e-03f, -4.64470591e-03f,
  -6.98462427e-01f, 2.75646567e-01f, -1.95781365e-01f, 9.65768397e-02f, -9.65081155e-02f, 1.09417856e-01f, 1.77600235e-01f, 1.94404237e-02f, 9.38376710e-02f, 1.95941031e-01f,
  -4.75773588e-02f, -1.34944916e-01f, 1.54753208e-01f, 2.51097888e-01f, -1.20297529e-01f, 2.45241269e-01f, 1.66913271e-01f, 1.43787727e-01f, 9.14306492e-02f, -1.82069138e-01f,
  4.67668697e-02f, 1.30886927e-01f, 1.10564180e-01f, -1.60175040e-02f, -5.21622002e-02f, -8.39480683e-02f, -3.73220327e-03f, -8.71827677e-02f, -1.96842980e-02f, -1.69426519e-02f,
  -1.69057086e-01f, -2.88357913e-01f, -1.74357772e-01f, -7.74654523e-02f, -1.28101766e-01f, 5.91649953e-03f, -3.17487307e-02f, -8.12006965e-02f, -1.29136726e-01f, -3.23854461e-02f,
  -1.11250594e-01f, -8.74625593e-02f, 3.19304466e-02f, -5.41261658e-02f, -6.25288039e-02f, -4.20021266e-02f, 5.01936786e-02f, -5.74218035e-02f, 1.76736824e-02f, -3.84893306e-02f,
  -3.65678556e-02f, -9.76521224e-02f, 2.23002378e-02f, 5.45319989e-02f, -7.82164708e-02f, -9.67687592e-02f, 4.23773155e-02f, 3.90738063e-03f, -1.05127007e-01f, -2.69007720e-02f,
  -1.39285559e-02f, 5.69263473e-02f, 1.08384334e-01f, -1.15853790e-02f, 7.94846937e-02f, 6.09145015e-02f, -1.01916850e-01f, 2.34361701e-02f, 1.83735956e-02f, 7.18006417e-02f,
  -6.84603155e-02f, -2.26242654e-03f, -9.87220109e-02f, 4.31472287e-02f, 4.37417217e-02f, -2.97971815e-02f, -4.75801947e-03f, 3.56753310e-03f, 2.45902520e-02f, -1.10408597e-01f,
  8.92348005e-04f, 2.96747554e-02f, 1.43716156e-01f, 7.30913207e-02f, -5.95997870e-02f, 1.09979853e-01f, -1.41541576e-02f, -3.27496156e-02f, 5.60652167e-02f, -1.06309243e-01f,
  3.90981361e-02f, -3.58512402e-02f, 1.02433607e-01f, -8.84727389e-02f, 5.18508926e-02f, -5.27222678e-02f, 1.64373703e-02f, 1.11189112e-01f, 3.19068916e-02f, 3.02750655e-02f,
  -9.36891064e-02f, -4.24008258e-03f, -5.76414317e-02f, 5.61406836e-02f, 3.56339328e-02f, -2.79488624e-03f, 7.63859004e-02f, 1.79828163e-02f, -1.76037522e-03f, 3.48153636e-02f,
  -6.07704744e-02f, -2.59452909e-02f, 4.03469603e-04f, 4.88346741e-02f, -3.47056054e-02f, 3.68013494e-02f, -7.26738498e-02f, 2.82876063e-02f, -6.60080835e-02f, 4.92183976e-02f,
  3.87986898e-01f, -3.18187445e-01f, -2.21822217e-01f, 4.39324528e-02f, 2.50961661e-01f, -1.49362013e-01f, -1.06275097e-01f, 2.12903768e-01f, -1.08845821e-02f, -4.10699248e-02f,
  1.78721577e-01f, -1.84856251e-01f, -2.86889255e-01f, 2.38335982e-01f, 1.74174055e-01f, -1.87927231e-01f, 3.31399143e-01f, -3.23531777e-02f, 4.34361175e-02f, 7.37314224e-02f,
  2.80950993e-01f, 3.77044201e-01f, 4.69071046e-02f, 1.35150716e-01f, 1.24873064e-01f, 8.98631886e-02f, 5.82677908e-02f, -2.72038937e-01f, 1.97233021e-01f, 5.20124994e-02f,
  6.58824220e-02f, 1.81135125e-02f, -7.88302496e-02f, 3.98791991e-02f, -7.39995018e-02f, -3.94753329e-02f, -1.04224510e-01f, -2.90962569e-02f, 2.25342670e-03f, -9.20761377e-02f,
  -4.44270410e-02f, 1.27869891e-02f, 2.33524181e-02f, -1.10632004e-02f, 9.24229771e-02f, 6.43850788e-02f, 3.35441960e-04f, -1.49451345e-01f, -1.06871746e-01f, 6.00996353e-02f,
  -1.30102441e-01f, 2.06765495e-02f, 5.68986218e-03f, -1.57641917e-01f, -5.17968871e-02f, 2.82412693e-02f, -5.46304807e-02f, -9.29874405e-02f, 1.05663165e-02f, 2.49276757e-02f,
  6.58699498e-02f, -7.63493627e-02f, 8.08671191e-02f, 1.38141382e-02f, -9.19668674e-02f, -1.57470666e-02f, 1.67810169e-04f, -5.03048338e-02f, -5.50307445e-02f, -1.49330981e-02f,
  -6.13364093e-02f, -1.05132386e-02f, 1.96444262e-02f, -6.96629733e-02f, 5.26897497e-02f, -3.51627693e-02f, -2.22428497e-02f, 9.00375918e-02f, -4.88300920e-02f, -3.13236900e-02f,
  -4.00955752e-02f, 1.14881083e-01f, -1.33764213e-02f, 1.96574591e-02f, 1.47711383e-02f, -4.16885084e-03f, 8.04515481e-02f, 1.55837899e-02f, -9.80010778e-02f, 1.44095495e-02f,
  -7.83410966e-02f, -9.51684713e-02f, -7.56340399e-02f, 5.69377951e-02f, -9.05245468e-02f, -5.32362685e-02f, -1.02556318e-01f, 4.80759256e-02f, -4.42953855e-02f, 8.83416180e-03f,
  4.49603237e-02f, -4.03333344e-02f, 9.04960209e-04f, 6.04719073e-02f, -2.69859452e-02f, 1.45879444e-02f, 1.55355791e-02f, -7.29831979e-02f, 4.89154235e-02f, 2.32414119e-02f,
  4.33905190e-03f, -5.22709936e-02f, 6.20321743e-02f, -1.96331274e-02f, -4.65510301e-02f, -1.27913520e-01f, 5.85033419e-03f, 5.94933257e-02f, 2.42070537e-02f, -4.59642000e-02f,
  -6.15674295e-02f, 1.58832178e-01f, -4.86624278e-02f, -1.10571653e-01f, -5.99536598e-02f, 1.35919809e-01f, 1.78476702e-02f, 7.66973346e-02f, 2.83875555e-01f, 1.75100341e-01f,
  -2.31314823e-01f, 1.77091688e-01f, 1.09969661e-01f, -1.89049274e-01f, 3.48245054e-01f, 2.96735138e-01f, -1.03448838e-01f, 8.69251322e-03f, 2.15349104e-02f, -1.24807663e-01f,
  -8.42765942e-02f, -2.70478517e-01f, -1.32214919e-01f, -1.98896393e-01f, -4.23545867e-01f, -8.18239227e-02f, -5.11965901e-02f, -1.59544826e-01f, -3.01886886e-01f, -1.07623339e-01f,
  -1.41729444e-01f, -1.05164208e-01f, -1.65328845e-01f, -6.01591095e-02f, -2.73333304e-02f, 2.58639473e-02f, 3.31669562e-02f, 4.60340120e-02f, -4.59499769e-02f, 1.19073868e-01f,
  7.86801279e-02f, 6.14753924e-02f, 1.13599546e-01f, 1.12550057e-01f, 3.57751958e-02f, 1.39136594e-02f, 4.87067439e-02f, -1.32377893e-01f, -5.16426750e-02f, -4.14563976e-02f,
  -2.24455893e-02f, -1.53525084e-01f, -1.18990742e-01f, 6.24685809e-02f, -9.36171785e-02f, 5.71002476e-02f, 6.15379028e-02f, -9.46379378e-02f, -8.06182772e-02f, 1.10605121e-01f,
  9.29389372e-02f, 1.74920902e-01f, -9.14318413e-02f, -6.50696307e-02f, -3.76750827e-02f, -2.05502719e-01f, 2.66195443e-02f, -1.95540488e-02f, -4.53851409e-02f, -2.97845732e-02f,
  8.45117681e-03f, 1.49039924e-02f, -6.11104853e-02f, -3.32736701e-04f, 6.05416931e-02f, 1.25590399e-01f, -2.19296925e-02f, -1.98708326e-02f, 2.99134534e-02f, 8.03892985e-02f,
  1.36825144e-01f, -1.90704558e-02f, -7.48043954e-02f, -7.80704916e-02f, -3.46403979e-02f, 3.27285454e-02f, -1.02479188e-02f, 2.54033748e-02f, -5.77349365e-02f, -3.89156379e-02f,
  7.97348395e-02f, 7.81319663e-02f, -9.44164917e-02f, -1.31246513e-02f, -1.29323034e-02f, -3.86390463e-02f, 1.32248253e-02f, -1.69054065e-02f, 5.16725555e-02f, -7.16201290e-02f,
  4.47974019e-02f, 2.45187841e-02f, 5.72030526e-03f, -1.04361605e-02f, -8.05491060e-02f, 6.02016971e-02f, 3.27054560e-02f, -2.77267508e-02f, -4.21953350e-02f, -1.02712244e-01f,
  7.22017884e-03f, -5.93658127e-02f, 1.79166347e-01f, -7.23758787e-02f, -1.25518143e-02f, -6.68658540e-02f, 2.58551352e-02f, 4.23142174e-03f, -1.00053415e-01f, 1.85982510e-02f,
  -1.38801262e-01f, -2.59123385e-01f, -3.48757565e-01f, -3.31909396e-02f, 1.35307103e-01f, 3.38930547e-01f, 1.22777969e-01f, -1.90971699e-02f, -2.63733208e-01f, 2.75623769e-01f,
  2.35220835e-01f, -1.19785473e-01f, 2.65469421e-02f, 2.05720544e-01f, -1.59198940e-02f, -4.42340225e-02f, 2.09594488e-01f, 1.03760496e-01f, -1.22578502e-01f, -1.09625965e-01f,
  7.31969550e-02f, 1.19627789e-01f, -1.40112750e-02f, 7.86573142e-02f, 2.12731764e-01f, -1.22537293e-01f, 1.95417583e-01f, 1.61870606e-02f, 4.16181028e-01f, 4.89991717e-02f,
  2.19928827e-02f, -1.42335638e-01f, -5.28618582e-02f, -8.95354971e-02f, 6.28849193e-02f, -2.71695238e-02f, 7.08592162e-02f, 1.16276570e-01f, 2.28754934e-02f, -1.86537765e-02f,
  1.21127233e-01f, -5.21401642e-03f, 4.75667492e-02f, -4.03780714e-02f, -1.44237112e-02f, -1.25176504e-01f, 3.11321262e-02f, -2.37061940e-02f, 1.07886381e-02f, -1.25697076e-01f,
  -6.05691671e-02f, -7.04082027e-02f, -1.18804621e-02f, -8.35658833e-02f, -4.24106605e-02f, 3.58034000e-02f, 6.17539370e-03f, -3.71831656e-02f, 1.87835712e-02f, 3.16222459e-02f,
  9.08907223e-03f, 1.15607344e-02f, -6.51855394e-02f, -5.98045476e-02f, 5.20148873e-02f, 1.26735657e-01f, 7.68528357e-02f, 4.48634923e-02f, -1.59758702e-01f, 5.04423119e-02f,
  1.23626851e-02f, -3.52623165e-02f, -5.87144606e-02f, 1.49320113e-02f, -6.21639565e-02f, -9.25613567e-02f, 1.61003415e-02f, -6.43640459e-02f, -1.68316290e-02f, 6.36219829e-02f,
  8.89131054e-02f, -2.42647994e-02f, -4.58804891e-03f, 2.56488807e-02f, 5.02585853e-03f, -8.27216655e-02f, 3.11396178e-02f, 7.82150850e-02f, -4.87585738e-02f, 1.18659809e-01f,
  2.19558142e-02f, -6.32050335e-02f, 3.22258212e-02f, -2.53287368e-02f, 4.86083888e-02f, -3.72931324e-02f, 9.04447138e-02f, 1.29555315e-02f, 3.27153224e-03f, -9.64740291e-02f,
  8.00910890e-02f, -6.75733462e-02f, 1.59607604e-01f, -1.24847740e-01f, 2.97212061e-02f, -5.16944518e-03f, 6.50063232e-02f, 3.58632579e-02f, 3.13889049e-02f, 4.81729805e-02f,
  -4.97622751e-02f, -2.47949548e-02f, -7.24995658e-02f, -1.17069758e-01f, 5.48875555e-02f, 4.51060683e-02f, -8.38070884e-02f, -1.63269173e-02f, 1.67190898e-02f, -2.16133427e-02f,
  -5.42504847e-01f, 3.01152673e-02f, 9.71880332e-02f, -4.07728404e-01f, 1.32617444e-01f, 1.56865790e-01f, -6.09613508e-02f, 9.58692059e-02f, -1.58006430e-01f, -1.33627638e-01f,
  -1.26506522e-01f, 8.91537443e-02f, 1.26454428e-01f, -8.07619691e-02f, 1.28309906e-01f, 1.26214281e-01f, -1.97835743e-01f, -2.26944551e-01f, 1.10823013e-01f, 1.97339430e-02f,
  -8.62544104e-02f, -9.37604159e-02f, 1.50750756e-01f, 1.00777112e-01f, -2.08414113e-03f, -1.38594627e-01f, -4.21482921e-02f, 8.68480876e-02f, -5.93274347e-02f, 1.08254142e-01f,
  -2.55475551e-01f, -1.67409241e-01f, -4.08874601e-02f, -7.93576241e-02f, 4.84210365e-02f, -2.07901672e-02f, -3.72393094e-02f, 7.28416964e-02f, -6.39563473e-03f, 5.06090559e-03f,
  7.65508264e-02f, -2.59081088e-02f, -1.95536315e-02f, -7.31448382e-02f, -1.46263927e-01f, -2.48622452e-03f, 5.72714545e-02f, -2.63611730e-02f, 8.55080560e-02f, 8.67797136e-02f,
  7.08612725e-02f, 1.64806172e-02f, 2.82081626e-02f, -6.17747344e-02f, 7.99420774e-02f, -4.26771753e-02f, -4.96242344e-02f, -1.03770811e-02f, -2.46024050e-04f, -8.50505680e-02f,
  -6.99469969e-02f, -1.24607682e-02f, -1.05574913e-01f, -3.13495323e-02f, 1.57112963e-02f, -1.02810308e-01f, 3.29495445e-02f, -1.13130726e-01f, -5.26447520e-02f, -2.61325631e-02f,
  -5.97848836e-03f, 7.80222379e-03f, -8.86025950e-02f, -5.75311109e-02f, -6.83841184e-02f, -1.30605087e-01f, -6.48184260e-03f, -3.17453267e-03f, -4.02734429e-03f, 6.09223023e-02f,
  -1.34414136e-01f, 5.89815937e-02f, -3.80472690e-02f, -1.24621475e-02f, 1.71893090e-02f, 3.63779478e-02f, 5.04659675e-02f, 9.20231640e-02f, -6.57569021e-02f, 6.70168996e-02f,
  -2.52767771e-01f, -2.99448013e-01f, 5.15606664e-02f, -1.01475962e-01f, -1.09485470e-01f, -3.88505193e-03f, -8.73356387e-02f, -2.35602055e-02f, -6.58961460e-02f, -1.40441852e-02f,
  -3.65302414e-02f, -4.07505743e-02f, 9.83120874e-02f, 1.63403954e-02f, -2.03234646e-02f, -1.05288967e-01f, 9.14478116e-03f, -9.44499001e-02f, -3.55645418e-02f, -5.07417619e-02f,
  -2.70014964e-02f, 3.28891887e-03f, -1.22799519e-02f, 1.07300542e-01f, -1.41528696e-02f, -1.04754448e-01f, -1.06743306e-01f, 3.53269349e-03f, 5.01163341e-02f, 5.99254332e-02f,
  2.56154180e-01f, 2.76938915e-01f, 2.42412016e-01f, 1.84677720e-01f, -1.05201103e-01f, 2.33535282e-03f, 5.54384757e-03f, 1.55067742e-01f, 3.17201525e-01f, -8.65168497e-02f,
  -2.54196730e-02f, 7.80568942e-02f, 4.62251715e-02f, -2.02891808e-02f, 2.06390768e-01f, -1.92575585e-02f, 1.57960922e-01f, -7.61992391e-03f, 2.17443913e-01f, 2.22713854e-02f,
  2.15922728e-01f, -1.40581682e-01f, 2.85129678e-02f, -3.81203443e-02f, 3.23081687e-02f, -1.32515570e-02f, -3.50772589e-02f, -5.56540638e-02f, -1.64992303e-01f, -2.79385820e-02f,
  -1.01828147e-02f, 8.12091082e-02f, 3.32573131e-02f, -2.44053472e-02f, 1.07547365e-01f, -1.76812466e-02f, 3.68652977e-02f, 8.16742366e-04f, 1.18613407e-01f, 8.03109072e-03f,
  7.79098943e-02f, -7.98276514e-02f, 1.58239841e-01f, 1.47593142e-02f, -3.52228433e-02f, -8.56817588e-02f, 5.07281087e-02f, 2.55338810e-02f, 3.19782086e-02f, -1.13359906e-01f,
  -4.65626605e-02f, 1.07705712e-01f, 6.59783706e-02f, -8.11561048e-02f, 4.41843942e-02f, 8.05810764e-02f, 2.24368125e-02f, 9.54627097e-02f, -2.84722559e-02f, 1.65250197e-01f,
  -5.89459799e-02f, 1.41221648e-02f, -1.62838638e-01f, -5.07476926e-02f, -6.72888011e-02f, 5.76192467e-03f, 1.49711579e-01f, 1.28164263e-02f, 7.14837983e-02f, 2.09773574e-02f,
  -3.70247811e-02f, -2.82407384e-02f, 2.82735713e-02f, -1.11338496e-02f, 9.56138745e-02f, -1.00651748e-01f, -1.34943542e-03f, 4.43375967e-02f, 8.37767348e-02f, 8.67378339e-02f,
  -3.82487737e-02f, 1.68808158e-02f, 7.50341117e-02f, -8.66977423e-02f, -9.42313150e-02f, -8.89753848e-02f, 3.99571508e-02f, -2.15110015e-02f, -5.22594005e-02f, -3.57280560e-02f,
  2.05617353e-01f, 1.78033605e-01f, 8.82971287e-02f, 4.16145660e-02f, 4.31242622e-02f, -5.65027818e-02f, -5.20271063e-02f, 8.11824277e-02f, 1.16555229e-01f, -2.64073182e-02f,
  3.46660055e-02f, 4.57610860e-02f, 2.31006797e-02f, -7.19400495e-02f, -3.45564969e-02f, 1.53234422e-01f, 2.51858663e-02f, 1.28512770e-01f, 2.02590451e-02f, 2.95740571e-02f,
  -7.63089657e-02f, 3.77392955e-02f, -1.14864670e-02f, -3.47468536e-03f, 3.65132168e-02f, 3.47158872e-02f, 4.94539775e-02f, -3.89824770e-02f, 4.79779541e-02f, 2.27919612e-02f,
  9.59962904e-02f, -2.03979418e-01f, 8.69737491e-02f, -2.54006237e-01f, -9.86991450e-03f, 9.23151374e-02f, 2.01931149e-01f, -3.21319133e-01f, -4.71118748e-01f, -1.69768468e-01f,
  -1.38431311e-01f, -1.08771389e-02f, 2.95261770e-01f, -3.37886840e-01f, 5.18830478e-01f, 2.08869055e-01f, -2.43268579e-01f, -1.22290961e-01f, -1.24525791e-02f, -2.16815352e-01f,
  -1.09790958e-01f, -2.65048474e-01f, 1.77352875e-01f, -1.74897313e-01f, -1.42048150e-01f, -1.99060813e-01f, 1.06656536e-01f, 1.24431260e-01f, -1.39451057e-01f, 2.75736712e-02f,
  3.18597890e-02f, -1.24325685e-01f, 8.23919196e-03f, 7.58629665e-02f, -8.85650218e-02f, 3.14284302e-02f, 5.62283732e-02f, 1.98315889e-01f, -5.98155074e-02f, 5.55872824e-03f,
  5.56124083e-04f, 2.52620270e-03f, -6.60275817e-02f, 2.30129175e-02f, -5.62209338e-02f, -8.35220069e-02f, -3.97328287e-02f, -6.26118407e-02f, -7.19849914e-02f, 1.11459635e-01f,
  1.92046985e-02f, -6.29454479e-02f, -1.09038040e-01f, -1.25700638e-01f, 3.00786346e-02f, -1.09750502e-01f, 2.52610296e-02f, 1.77656755e-01f, 2.30955007e-03f, -1.51458025e-01f,
  -8.85838494e-02f, 5.88940196e-02f, 1.65054232e-01f, -4.41027209e-02f, 8.27576742e-02f, -1.08699918e-01f, 2.21359115e-02f, 9.38533098e-02f, -1.65553857e-02f, -9.76592302e-02f,
  -5.20305941e-03f, -1.38501495e-01f, -9.38099325e-02f, 1.48945646e-02f, 4.41776253e-02f, -4.82189283e-03f, 5.51430136e-02f, -3.12799625e-02f, -1.02490112e-01f, 4.90528010e-02f,
  8.58246759e-02f, 6.71005808e-04f, 3.64300907e-02f, -8.54850039e-02f, -5.77288941e-02f, 7.30023906e-02f, -2.27640551e-02f, -9.17082354e-02f, 4.14522216e-02f, 2.34891735e-02f,
  -7.85136819e-02f, -1.19975612e-01f, 2.48282049e-02f, -4.04091626e-02f, 2.68515814e-02f, 1.00215346e-01f, 2.74347477e-02f, -4.26426977e-02f, -8.94288197e-02f, 2.32881140e-02f,
  -1.01703338e-01f, 2.04409268e-02f, 3.52137871e-02f, -5.64476997e-02f, 1.04355082e-01f, -2.29063840e-03f, -6.13872334e-03f, -6.28227443e-02f, -6.75369725e-02f, -5.19475155e-02f,
  2.68423408e-02f, 9.88911092e-02f, 5.90243414e-02f, 2.17956603e-02f, -9.91236940e-02f, 5.51579222e-02f, 2.78010778e-03f, -3.42088193e-02f, 1.03262952e-02f, -1.96146537e-02f,
  5.89106560e-01f, -1.26643896e-01f, 3.58147740e-01f, 1.15740865e-01f, 3.15883219e-01f, 2.35599428e-01f, 2.47358844e-01f, 5.68997227e-02f, 2.12312996e-01f, -2.26218402e-01f,
  -9.78098586e-02f, 9.35438871e-02f, -6.77872747e-02f, -1.06843449e-01f, 3.54174860e-02f, 1.20744212e-02f, -1.37339845e-01f, 1.48745291e-02f, 5.19517139e-02f, -1.23730479e-02f,
  -5.94963431e-02f, -3.63510042e-01f, -1.33175567e-01f, -2.95547217e-01f, -1.47317946e-02f, -4.80713807e-02f, -2.89093047e-01f, -1.19388990e-01f, -1.93004772e-01f, -3.57566476e-02f,
  -4.17449810e-02f, -1.35246674e-02f, 6.02359734e-02f, -5.73432148e-02f, -1.59452632e-02f, -2.31258618e-03f, 3.83808240e-02f, -8.32208470e-02f, 2.61274222e-02f, 7.39492401e-02f,
  -8.32109749e-02f, 9.06191487e-03f, -1.01189494e-01f, 2.71137357e-02f, 1.91267915e-02f, -2.95858495e-02f, 3.97429243e-02f, -1.76628213e-02f, -4.84179333e-02f, 7.67264068e-02f,
  1.39939025e-01f, 2.19792891e-02f, 5.17506190e-02f, -2.42455509e-02f, 6.04055375e-02f, -3.69794257e-02f, 8.35326612e-02f, 3.05067953e-02f, 8.36763307e-02f, 4.06430401e-02f,
  -6.43333569e-02f, -1.76923424e-02f, 8.24127346e-02f, -5.78583553e-02f, 5.94083443e-02f, -1.07502937e-01f, -5.90235628e-02f, -9.97466519e-02f, 4.62142490e-02f, -1.13987122e-02f,
  1.65280983e-01f, 1.01063929e-01f, 1.49800971e-01f, -1.87741108e-02f, -3.54224071e-02f, -1.70065761e-02f, -1.48952389e-02f, -1.88874863e-02f, -9.99551937e-02f, 5.87472618e-02f,
  7.77352676e-02f, -7.03616580e-03f, -1.33595511e-01f, 1.52440434e-02f, 2.54064500e-02f, -7.99521152e-03f, 2.16509011e-02f, 1.09226145e-01f, -1.20430805e-01f, -1.63688466e-01f,
  -3.06414664e-01f, -4.01633620e-01f, -5.97985908e-02f, -1.23523898e-01f, -7.25338832e-02f, -2.58190837e-02f, -3.48879248e-02f, -5.02215959e-02f, -1.59415573e-01f, -1.00557640e-01f,
  -3.20301093e-02f, -6.88193664e-02f, 7.88182840e-02f, 2.30613053e-02f, -1.08850107e-01f, 3.32197087e-04f, 1.22568468e-02f, -1.64402783e-01f, -6.95851669e-02f, -5.16084135e-02f,
  -3.93195823e-02f, -1.24626935e-01f, -3.56999561e-02f, -2.45622452e-02f, -2.79891249e-02f, -1.97947882e-02f, -1.70165952e-02f, 9.88334510e-03f, -9.25858170e-02f, -3.42835337e-02f,
  7.17026964e-02f, 2.90266424e-01f, -1.86651006e-01f, 1.41382694e-01f, -6.24199957e-02f, 3.14418018e-01f, 1.69590816e-01f, 1.23237647e-01f, 2.13985384e-01f, 2.07067102e-01f,
  8.29398111e-02f, 5.85930236e-02f, 1.14231408e-01f, 6.88133687e-02f, 9.58792791e-02f, 2.23926082e-01f, 1.63900226e-01f, 6.41292483e-02f, 3.51335891e-02f, -8.12091902e-02f,
  8.55581611e-02f, 4.68826108e-02f, -9.53247324e-02f, -1.39376849e-01f, -5.93036376e-02f, -7.70564154e-02f, -1.94950536e-01f, -7.66628757e-02f, 2.17336677e-02f, -7.82885065e-04f,
  -4.03822325e-02f, 4.44975495e-02f, -1.43281832e-01f, 1.88971516e-02f, 1.21136932e-02f, -2.85000410e-02f, -4.53515686e-02f, -9.87940952e-02f, -1.41423568e-01f, 1.59543250e-02f,
  9.59995314e-02f, 1.66429710e-02f, 1.14357091e-01f, -1.07249971e-02f, 6.93289787e-02f, -9.76364091e-02f, -6.67197257e-02f, -1.31602496e-01f, -9.15665105e-02f, -4.73454176e-03f,
  -6.46702126e-02f, -3.62879038e-02f, -9.75831077e-02f, 8.61540716e-03f, -1.10522145e-02f, 6.18420988e-02f, 1.11005895e-01f, -2.95045841e-02f, 5.61464392e-02f, 1.70272037e-01f,
  1.43083066e-01f, 1.27526626e-01f, 4.47722245e-03f, -1.14751412e-02f, -9.35951062e-03f, -3.23722959e-02f, -9.29323304e-03f, -3.04485392e-02f, -3.63540277e-02f, -1.80048123e-02f,
  7.35206008e-02f, 6.43373728e-02f, 2.57519558e-02f, 1.19315304e-01f, 1.07892461e-01f, 1.17225915e-01f, 2.53715627e-02f, -5.43750674e-02f, 7.00095296e-03f, -5.63116260e-02f,
  -3.76902558e-02f, 9.66145322e-02f, -4.94484091e-03f, -3.23887682e-03f, 5.35961688e-02f, -1.06253149e-02f, 1.74594373e-02f, 4.30508563e-03f, -9.46578905e-02f, -1.00806527e-01f,
  2.13437945e-01f, 3.44339341e-01f, 5.28929941e-02f, -9.41984064e-04f, -9.73803364e-03f, 3.02753579e-02f, -3.21304239e-02f, 9.25362781e-02f, -7.89482426e-03f, 1.43223763e-01f,
  7.58185536e-02f, -4.95070033e-03f, -8.62279255e-03f, -1.49139494e-01f, -4.01146822e-02f, 1.31754443e-01f, 1.44624934e-01f, 3.40948515e-02f, -1.57231558e-02f, 4.50742319e-02f,
  -8.64998847e-02f, 3.46703306e-02f, -1.70292724e-02f, -1.58065073e-02f, -1.12886643e-02f, 3.08982749e-02f, -4.16741930e-02f, -4.64347526e-02f, 2.86681242e-02f, -1.87201686e-02f,
  1.69820115e-01f, -3.98966163e-01f, -1.21113077e-01f, 1.00824945e-01f, 4.08677876e-01f, 2.07082257e-01f, 2.14231864e-01f, 3.06583177e-02f, -2.13212699e-01f, -2.79642016e-01f,
  1.76168948e-01f, 1.30429476e-01f, -1.21618941e-01f, -3.89394276e-02f, 3.02937269e-01f, -1.75947890e-01f, 4.35985401e-02f, 1.87174939e-02f, -9.52712968e-02f, -4.54062782e-02f,
  6.10515997e-02f, 1.21231705e-01f, 6.80031925e-02f, -6.63008764e-02f, 4.58096191e-02f, -1.61450550e-01f, 5.37201054e-02f, 9.25810486e-02f, -3.42186056e-02f, 1.56712815e-01f,
  -6.70716166e-03f, -4.56001274e-02f, 8.98403954e-03f, -1.60129294e-01f, -5.26493564e-02f, -1.73404776e-02f, -5.65782078e-02f, 8.56689587e-02f, 1.15339883e-01f, -4.67750765e-02f,
  1.28414324e-02f, -1.88797843e-02f, -1.88701116e-02f, 3.34237851e-02f, 5.36813661e-02f, -6.68434892e-04f, 2.29348969e-02f, -1.10471621e-01f, 3.98417972e-02f, 3.10907550e-02f,
  -5.24132997e-02f, 1.22588919e-02f, 5.48494188e-03f, -4.30017710e-02f, 3.72145548e-02f, 1.43984351e-02f, 5.93384430e-02f, 1.19427793e-01f, 3.62878330e-02f, 2.55368110e-02f,
  -1.47333753e-03f, 1.45674162e-02f, -4.54679839e-02f, -5.29045835e-02f, 1.87538601e-02f, -6.15179259e-03f, 2.08282825e-02f, 3.75560224e-02f, -2.39868164e-02f, -4.95462604e-02f,
  -5.50773600e-03f, 1.55603075e-02f, -5.50095597e-03f, 3.07411347e-06f, 9.34735611e-02f, 2.01745182e-02f, -2.45171059e-02f, 3.70975398e-02f, 3.31119671e-02f, 8.09585601e-02f,
  -1.38093717e-02f, -4.82439966e-04f, 3.90825085e-02f, 6.94759423e-03f, 2.28700181e-03f, 2.14375984e-02f, -6.45265207e-02f, -7.24632666e-02f, 2.44277325e-02f, -3.55787165e-02f,
  -2.76232272e-01f, -3.39858264e-01f, 5.76114021e-02f, -1.66846924e-02f, 1.13255773e-02f, -3.89754996e-02f, 5.25455996e-02f, 8.72760732e-03f, -1.42671451e-01f, 6.12093285e-02f,
  -1.48008275e-03f, -2.10133791e-02f, -5.36234416e-02f, -8.20622966e-02f, 2.46525519e-02f, -6.03065528e-02f, -8.14317726e-03f, -3.93942110e-02f, 1.06746204e-01f, 5.23150116e-02f,
  -3.73171456e-02f, -6.25265315e-02f, 4.46487684e-03f, 5.14348671e-02f, -6.62539452e-02f, 1.00522876e-01f, 2.60820128e-02f, -2.61461008e-02f, -6.34526834e-02f, 6.27961382e-02f,
  2.99645036e-01f, 3.37039709e-01f, 3.40431958e-01f, 3.86507720e-01f, -1.17732063e-01f, -3.12283337e-01f, -7.60569647e-02f, 9.72482339e-02f, 1.73666343e-01f, -1.07959099e-01f,
  -1.22705989e-01f, 2.09261000e-01f, -2.60551013e-02f, 1.85915589e-01f, 9.53255668e-02f, -2.16964763e-02f, 1.28678158e-01f, -1.64770950e-02f, -7.07711466e-03f, 2.77860940e-01f,
  9.84216407e-02f, 1.17891461e-01f, 2.71012187e-01f, 2.57183671e-01f, 1.28437504e-01f, 2.87072539e-01f, 2.12086484e-01f, 1.20677896e-01f, 8.38979930e-02f, -4.93277311e-02f,
  -1.37875363e-01f, 1.06714539e-01f, 5.25539555e-02f, -1.16974801e-01f, 8.38438794e-02f, -2.60333400e-02f, -1.74710333e-01f, -6.74989745e-02f, 8.05311725e-02f, -8.02970231e-02f,
  -1.95704978e-02f, -1.12249509e-01f, 1.56459082e-02f, 7.62303174e-02f, 1.13216694e-02f, 5.97249717e-02f, -4.21566889e-02f, -1.66406687e-02f, 7.68730566e-02f, -2.87981308e-03f,
  -2.20067762e-02f, -2.51473598e-02f, -5.00271237e-03f, -3.30687091e-02f, -9.01488662e-02f, -4.46567126e-02f, -1.38858512e-01f, 9.69075784e-03f, 3.80672477e-02f, 1.02971926e-01f,
  -1.58950314e-02f, 7.95259252e-02f, 5.66541180e-02f, 8.51822942e-02f, 6.24704100e-02f, 3.23497206e-02f, -2.28054356e-02f, -7.93489739e-02f, -3.86471525e-02f, 8.17132443e-02f,
  1.11195929e-01f, 3.91764566e-02f, 3.67641705e-03f, -2.45547816e-02f, -1.96704343e-02f, 7.70024955e-02f, 2.78035793e-02f, -1.38620824e-01f, -1.25562459e-01f, 8.90646353e-02f,
  -2.91693229e-02f, -4.42656176e-03f, 4.64840867e-02f, -6.23015724e-02f, -1.16845943e-01f, 1.06653631e-01f, 5.27962446e-02f, -2.37871185e-02f, -2.78968308e-02f, 1.27359167e-01f,
  2.22789235e-02f, 2.13125825e-01f, -1.16191685e-01f, -1.84998095e-01f, -2.34853607e-02f, 7.07602426e-02f, 7.32982811e-03f, -2.87299678e-02f, 2.85931788e-02f, 2.84979474e-02f,
  -8.55939090e-03f, -3.44364718e-02f, 3.49857323e-02f, 9.36230831e-03f, 3.55328843e-02f, -6.38843849e-02f, 7.79286474e-02f, -2.27103420e-02f, 3.45360376e-02f, 3.50387134e-02f,
  -3.01127657e-02f, -5.42613603e-02f, 5.05106933e-02f, 7.34100351e-03f, 3.61631071e-04f, 2.94572189e-02f, -1.23458192e-01f, -5.44478446e-02f, -6.51502982e-03f, 4.78399545e-02f,
  -1.36998773e-01f, 1.75826743e-01f, -2.36272290e-02f, -3.08835655e-02f, 1.39167175e-01f, 3.00590128e-01f, 3.85251582e-01f, -1.20284855e-02f, -5.18835112e-02f, 3.00377786e-01f,
  1.74257308e-01f, -2.85223313e-02f, 8.70451480e-02f, 7.83620551e-02f, 1.06119893e-01f, 1.55613184e-01f, 9.24473405e-02f, 3.62805389e-02f, -6.18626038e-03f, 5.81097119e-02f,
  -8.40976387e-02f, 1.20982021e-01f, -1.24831907e-01f, -5.53836897e-02f, 5.24776019e-02f, 1.65492874e-02f, -1.02083005e-01f, -1.23518882e-02f, 9.06481296e-02f, 1.53393432e-01f,
  6.45502955e-02f, -2.03441717e-02f, -2.38928180e-02f, -1.19731370e-02f, 2.05427911e-02f, -6.17417470e-02f, -2.60129776e-02f, 1.85563962e-03f, -2.74717174e-02f, 3.50423902e-02f,
  -4.73150648e-02f, -8.43626931e-02f, -1.08785875e-01f, -9.53013301e-02f, -1.26719087e-01f, 1.09954225e-02f, -8.17213058e-02f, -2.84970179e-02f, -1.18549921e-01f, 1.55189008e-01f,
  -8.76685232e-03f, 1.65318768e-03f, -8.99240449e-02f, 2.73581054e-02f, -5.57675399e-02f, -4.08859085e-03f, 8.77787024e-02f, -9.18608308e-02f, 9.15236026e-02f, 9.24394280e-03f,
  -1.44344829e-02f, -9.79629382e-02f, 4.42940854e-02f, -7.36174434e-02f, 5.10109961e-02f, -2.41141804e-02f, 1.20888762e-02f, 4.50995043e-02f, -1.27203288e-02f, -1.70533569e-03f,
  4.49733026e-02f, 9.31187719e-03f, -2.15733238e-02f, -1.32587805e-01f, 2.16391478e-02f, 2.72466186e-02f, 8.80791247e-02f, -3.97362746e-02f, 2.90050209e-02f, 1.00813452e-02f,
  -7.95993581e-02f, 4.62119393e-02f, -1.28528513e-02f, -7.15561286e-02f, -1.22436248e-02f, -5.00703417e-02f, 2.75835879e-02f, -3.62759568e-02f, 3.39535698e-02f, 8.19349438e-02f,
  1.91008300e-01f, 1.63894162e-01f, -5.28555512e-02f, -4.88696806e-02f, -1.74324587e-02f, 2.82101426e-02f, -9.55356658e-02f, 4.23370749e-02f, 1.46487236e-01f, 2.05595675e-03f,
  -3.96087281e-02f, -7.52639100e-02f, 9.62456837e-02f, -1.24304362e-01f, -4.70495857e-02f, 5.15373945e-02f, 1.22829229e-01f, 1.55560151e-02f, -1.88746676e-02f, -1.15839799e-03f,
  2.13915985e-02f, 7.63653442e-02f, 2.40877308e-02f, 1.12553593e-02f, 5.09921880e-03f, 2.57213805e-02f, -3.11974082e-02f, 2.17018090e-02f, -7.00486377e-02f, -1.27842605e-01f,
  1.61706433e-01f, -8.98697064e-04f, -1.15556404e-01f, 5.92613481e-02f, 1.74005285e-01f, 1.48357153e-01f, 5.27755022e-02f, 9.32489112e-02f, 2.42140442e-02f, 7.78591037e-02f,
  3.83326337e-02f, -1.05734818e-01f, -1.57942757e-01f, 1.61774561e-01f, 1.42069176e-01f, -1.24090143e-01f, 3.12241971e-01f, -2.96469014e-02f, 6.52480498e-02f, 1.77042648e-01f,
  7.72832008e-03f, 3.81428927e-01f, -2.48835385e-01f, 1.59831747e-01f, 1.34380460e-01f, -8.89017433e-02f, 2.54900381e-02f, -1.05773851e-01f, 6.70494372e-03f, 1.26881301e-01f,
  4.01255414e-02f, 4.72837910e-02f, -1.33601248e-01f, -1.20399684e-01f, 1.09577715e-01f, 1.46089405e-01f, 2.17965106e-03f, -5.66405766e-02f, -1.27256647e-01f, -1.96583103e-02f,
  3.60458232e-02f, -5.31091206e-02f, -6.27941489e-02f, 7.59575740e-02f, 1.88856333e-01f, 6.33232147e-02f, 1.98350977e-02f, -3.88483494e-03f, 3.70477475e-02f, 3.03097367e-02f,
  -4.13647294e-02f, 6.76694289e-02f, 3.14986706e-02f, -6.30133152e-02f, -6.25192299e-02f, 6.20545857e-02f, 6.85365964e-03f, -1.29524648e-01f, -1.77906398e-02f, 3.99675630e-02f,
  2.34765522e-02f, 1.00153178e-01f, -9.73926261e-02f, -4.02897596e-02f, 1.30369127e-01f, -8.15994218e-02f, -6.76827133e-02f, -1.50483265e-03f, 9.69388038e-02f, 1.27386987e-01f,
  4.46641929e-02f, -7.23090917e-02f, 1.21593229e-01f, 4.68625836e-02f, -7.84620736e-03f, 4.83682705e-03f, -4.45387252e-02f, -1.37646077e-03f, -1.03792943e-01f, -9.45943932e-04f,
  1.20439203e-02f, -4.56136242e-02f, -9.69243720e-02f, -1.08293176e-01f, -6.29538763e-03f, -1.91600379e-02f, 9.68963280e-02f, 4.24068309e-02f, 5.05133495e-02f, -1.02135390e-01f,
  6.82267770e-02f, 4.61998954e-02f, -3.44813354e-02f, -7.32100010e-02f, 5.94968833e-02f, 1.58249840e-01f, 3.32159512e-02f, 4.04822156e-02f, -1.50971517e-01f, 1.41350761e-01f,
  9.85245705e-02f, -1.06461421e-01f, -4.45613288e-04f, 5.14967479e-02f, -4.11800388e-03f, -4.35024053e-02f, -4.95604500e-02f, -3.46413776e-02f, 1.13001138e-01f, 7.88390413e-02f,
  8.35515261e-02f, 9.36045423e-02f, 3.42662074e-02f, 3.36455069e-02f, 5.72301671e-02f, -4.13092971e-03f, 1.49797082e-01f, -1.53235923e-02f, -3.64114717e-02f, 6.33727610e-02f,
  -5.19583881e-01f, 2.19750106e-02f, 8.03200379e-02f, -3.25123936e-01f, -3.14163715e-02f, -7.12152123e-02f, -2.87656933e-01f, 1.19583882e-01f, 4.07857560e-02f, 9.33442488e-02f,
  1.01479627e-01f, 5.65182418e-02f, 1.31114602e-01f, -3.63418497e-02f, -1.00063488e-01f, 7.08046556e-02f, -2.10707530e-01f, -9.29650590e-02f, 1.50964514e-03f, -6.70953095e-02f,
  -1.50027648e-01f, 9.96921510e-02f, -7.00742900e-02f, 2.36649767e-01f, -6.97800592e-02f, -1.38040036e-01f, -1.58385098e-01f, 3.42714079e-02f, -5.47997504e-02f, 2.70987172e-02f,
  -3.14793050e-01f, 8.01775977e-02f, -8.06960687e-02f, 5.95952803e-03f, 2.35260502e-02f, 4.41827402e-02f, -1.43903419e-01f, 1.01618223e-01f, -8.96012336e-02f, 8.10968801e-02f,
  -4.40575257e-02f, 1.19224615e-01f, -4.18679602e-02f, 5.50765209e-02f, -5.18086404e-02f, 3.60677689e-02f, -2.07719784e-02f, -9.60655063e-02f, -6.75737560e-02f, -6.34626523e-02f,
  5.90414181e-03f, -8.72093812e-02f, -1.27356052e-01f, -2.16173753e-02f, 5.67543227e-03f, 1.09352425e-01f, -8.46745819e-02f, -5.58795296e-02f, -1.20050527e-01f, -6.80613145e-02f,
  7.79774487e-02f, 1.00538351e-01f, -1.19718418e-01f, 1.41189829e-01f, -8.64302590e-02f, 2.36021262e-02f, -6.19857684e-02f, 3.92528996e-02f, -9.32538882e-02f, 1.05947293e-02f,
  -6.87376037e-02f, -1.12194687e-01f, 7.28780180e-02f, -7.36378357e-02f, 4.59368341e-02f, 1.77797559e-03f, 1.10208951e-02f, 1.67051144e-03f, -7.61870146e-02f, 1.71202123e-02f,
  1.01409577e-01f, 3.07192802e-02f, -5.28649278e-02f, -1.29988521e-01f, 3.54131721e-02f, 1.07581347e-01f, 1.27377361e-02f, 1.67602599e-02f, -3.32798623e-02f, 2.40462972e-03f,
  -3.46432924e-01f, -3.12006891e-01f, 1.68772005e-02f, -1.46183772e-02f, -3.46269682e-02f, -4.13766429e-02f, -3.97996828e-02f, -4.88031060e-02f, -5.99419400e-02f, -1.00233749e-01f,
  -7.22411498e-02f, -1.49736069e-02f, -8.61597136e-02f, -6.65146559e-02f, 6.39096573e-02f, -5.67082316e-02f, -4.53700870e-02f, -3.56337465e-02f, -1.51536599e-01f, 2.42182650e-02f,
  -7.83564746e-02f, 6.12132363e-02f, -5.86437322e-02f, -6.67733625e-02f, -7.75013044e-02f, -8.27954337e-02f, -1.67026874e-02f, -5.78757450e-02f, -6.06779233e-02f, 1.42363543e-02f,
  1.38425633e-01f, 2.04640985e-01f, -1.55581251e-01f, -2.51275171e-02f, -2.41030455e-01f, -4.35719252e-01f, -2.37064987e-01f, -7.05141872e-02f, 2.07078159e-01f, 1.70355231e-01f,
  -2.01192260e-01f, 4.26312983e-01f, -1.32328868e-01f, -1.20362125e-01f, -2.32105002e-01f, -2.45855097e-02f, -3.47396165e-01f, -4.27293293e-02f, -2.16603819e-02f, -3.16694438e-01f,
  -1.28509372e-01f, -1.88788265e-01f, -2.35733464e-01f, -1.29874378e-01f, -2.32081518e-01f, 1.01311885e-01f, -1.20262519e-01f, -9.03083459e-02f, -4.11190130e-02f, -7.86600858e-02f,
  -4.64249551e-02f, 1.07608616e-01f, 8.13971236e-02f, 1.10400595e-01f, -2.28094101e-01f, -9.88572687e-02f, -9.69926640e-02f, 8.72872844e-02f, 7.12722987e-02f, -5.87715767e-03f,
  1.16915740e-01f, 5.16342670e-02f, 4.67169611e-03f, 3.00502423e-02f, -8.82862974e-03f, 7.03695342e-02f, 6.80981502e-02f, -3.41046676e-02f, 7.45234713e-02f, -3.51584964e-02f,
  -1.94811018e-03f, 7.29332119e-02f, -4.48023640e-02f, 1.26992762e-01f, -6.33523315e-02f, -2.46311892e-02f, -4.30546841e-03f, -1.09369820e-02f, 4.75361124e-02f, 3.41480747e-02f,
  3.95866111e-02f, -2.25950917e-03f, -1.48641504e-02f, -2.16482463e-03f, 3.64346616e-02f, -8.10232237e-02f, -3.46331969e-02f, 4.27310802e-02f, -2.08302476e-02f, -9.24076736e-02f,
  2.29735598e-02f, 1.45623580e-01f, -5.72844082e-03f, -1.72169730e-02f, -1.46143675e-01f, 1.00508973e-01f, -1.13867581e-01f, 2.12905630e-02f, -2.03339960e-02f, -1.01836883e-01f,
  -3.91053557e-02f, -4.31803167e-02f, 9.66896638e-02f, -5.47453873e-02f, -1.98390245e-01f, -3.74851450e-02f, -5.71646914e-03f, 2.21520802e-03f, 5.92069849e-02f, -1.81588233e-01f,
  -1.63375825e-01f, -9.90083441e-02f, -1.07693076e-02f, 1.45150065e-01f, 4.08318937e-02f, -8.52745697e-02f, 6.93610832e-02f, 7.73569122e-02f, -1.57416716e-01f, -4.38686609e-02f,
  -6.88131005e-02f, -1.22378267e-01f, -6.28131852e-02f, -6.84768930e-02f, -2.85092928e-03f, -8.41343328e-02f, -5.78312688e-02f, 4.63106073e-02f, -7.59742260e-02f, 1.38246808e-02f,
  -7.86420628e-02f, -1.28602497e-02f, -2.00253800e-02f, 9.28822439e-03f, 2.69351751e-02f, -7.47307464e-02f, 8.56505558e-02f, 7.24346265e-02f, -9.85185876e-02f, -1.17403090e-01f,
  -2.45521143e-01f, -1.04019932e-01f, -2.01889262e-01f, -2.93547064e-01f, 1.67737022e-01f, 7.75862858e-02f, -7.24506984e-03f, 7.08529502e-02f, -1.09461784e-01f, 2.29176566e-01f,
  1.81119084e-01f, -2.00034678e-01f, 1.72170326e-01f, -3.43530506e-01f, -5.48131764e-01f, -1.61381081e-01f, -3.69755536e-01f, -1.77511632e-01f, -2.07284838e-01f, -1.82305835e-02f,
  -2.75076628e-01f, -6.06945567e-02f, -2.13137522e-01f, 2.09542856e-01f, 5.59755974e-03f, 5.13832830e-02f, 2.34940290e-01f, 2.36818537e-01f, -1.12526774e-01f, -5.64848967e-02f,
  1.06388345e-01f, 1.35454148e-01f, 3.26076671e-02f, 1.06564341e-02f, 8.60693827e-02f, 4.13324833e-02f, 7.57532939e-02f, -2.46728994e-02f, -1.93137731e-02f, -1.23725727e-01f,
  6.75194245e-03f, -4.53497805e-02f, -1.56310216e-01f, 2.40064561e-02f, -6.61950512e-03f, 7.58559555e-02f, -1.23977132e-01f, -5.50050288e-02f, -2.22174153e-02f, -8.49959552e-02f,
  -3.43981571e-02f, -3.09328977e-02f, -6.50981888e-02f, -6.98926970e-02f, -3.20801064e-02f, -7.44488761e-02f, -9.29367612e-04f, -2.78136656e-02f, -2.47950926e-02f, -8.34048986e-02f,
  5.24703898e-02f, 7.04198554e-02f, 5.79656065e-02f, 1.51672456e-02f, 2.93059759e-02f, 1.58703029e-01f, 1.25887583e-03f, 4.50272709e-02f, -1.10302091e-01f, -2.27708034e-02f,
  -3.04560619e-03f, -6.63103955e-03f, 7.50409588e-02f, 4.02986370e-02f, 1.67514496e-02f, -7.40640461e-02f, -4.44281697e-02f, -2.42324136e-02f, -7.77173787e-02f, -3.03885490e-02f,
  1.58997044e-01f, -3.04750018e-02f, -2.61974800e-02f, -4.94311340e-02f, 1.08895183e-01f, -1.04966685e-01f, -3.34504582e-02f, -2.07059123e-02f, -3.12381200e-02f, 4.33826968e-02f,
  6.12333268e-02f, 1.23860270e-01f, 8.02917480e-02f, 2.88488958e-02f, -1.38019389e-02f, 5.35775423e-02f, -4.66894396e-02f, -8.97113308e-02f, -4.33165058e-02f, 1.13001734e-01f,
  9.18782204e-02f, -2.10570265e-03f, 1.27580101e-02f, -1.20872445e-02f, -9.95160546e-03f, 2.33494546e-02f, 1.29931182e-01f, 4.31240499e-02f, 4.28808220e-02f, 2.88564246e-02f,
  1.37164026e-01f, 1.52083173e-01f, -8.00316706e-02f, -1.26438411e-02f, 2.24484727e-02f, 5.38106598e-02f, 1.79938804e-02f, 2.66324803e-02f, -1.07010558e-01f, -2.62064226e-02f,
  -2.00774238e-01f, 3.57126862e-01f, 2.34730214e-01f, -1.33044228e-01f, -5.04781790e-02f, -6.57842541e-03f, 3.53279430e-03f, 1.39201820e-01f, 1.30948544e-01f, 5.61110955e-03f,
  -8.21864307e-02f, 3.16639900e-01f, -1.10568523e-01f, 7.84267709e-02f, -2.19804049e-01f, -1.62979051e-01f, -1.05658090e-02f, -4.71705105e-03f, 1.84891164e-01f, -3.21024694e-02f,
  -3.26224081e-02f, -1.85789183e-01f, -9.07799155e-02f, 4.46466766e-02f, 1.51162609e-01f, 6.69665411e-02f, -2.71791548e-01f, 5.78215048e-02f, 5.41032441e-02f, 1.47531494e-01f,
  -2.66407859e-02f, 9.65886787e-02f, 1.53942108e-01f, 9.20234155e-03f, 1.09457262e-02f, -1.54322889e-02f, 8.94711912e-02f, -3.98683175e-02f, 6.05161302e-02f, 7.28271082e-02f,
  2.09056810e-02f, -7.20526949e-02f, 1.29839063e-01f, -5.33636771e-02f, -8.72064789e-04f, -7.46812765e-03f, -6.50725327e-03f, 1.54010141e-02f, 1.16581485e-01f, 8.11763778e-02f,
  9.99376401e-02f, 1.20318398e-01f, 1.51474401e-02f, -3.37316990e-02f, 3.00099868e-02f, 6.98623359e-02f, 1.09223062e-02f, -9.97312292e-02f, -4.06815484e-03f, 9.99011472e-02f,
  3.81058380e-02f, 2.74191964e-02f, -5.27674779e-02f, 7.33872578e-02f, -2.43721846e-02f, -1.16761466e-02f, -3.97212282e-02f, -2.85155717e-02f, -1.16461083e-01f, 4.62875627e-02f,
  -1.95958555e-01f, -1.40589876e-02f, -6.57872707e-02f, -2.50456911e-02f, -1.29848598e-02f, 1.18192323e-01f, -1.00403368e-01f, -5.05167507e-02f, 4.70425980e-03f, 2.47673281e-02f,
  -1.55102313e-02f, -2.24656258e-02f, -2.47095134e-02f, -4.13392968e-02f, 1.26596615e-01f, 4.26170911e-04f, 1.27078712e-01f, 2.87055243e-02f, 4.15348895e-02f, 1.51052224e-02f,
  -8.75429660e-02f, -1.49699509e-01f, -2.91118566e-02f, -1.01614960e-01f, 1.04855865e-01f, -4.83434312e-02f, -7.23518431e-02f, -8.68835952e-03f, 1.42331319e-02f, 1.20754149e-02f,
  6.69566393e-02f, 3.25889699e-02f, -9.52665359e-02f, 1.98819656e-02f, -1.19616054e-02f, -4.12783818e-03f, -8.57220963e-02f, -8.57040659e-02f, -1.46903023e-01f, 6.07855711e-03f,
  -8.47440585e-02f, -7.62119442e-02f, -6.49363026e-02f, -4.63209068e-03f, -1.35431588e-01f, -1.26662195e-01f, -6.08489737e-02f, 5.53075224e-02f, 8.02066457e-03f, -3.85646708e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.43850893e-01f, 2.63401657e-01f, 1.05351232e-01f, 1.11265704e-01f, 2.39948034e-01f, 2.65979290e-01f, 2.60099024e-01f, -1.72680900e-01f, 7.51798302e-02f, 1.46255806e-01f,
  1.09836459e-01f, 1.85227767e-02f, 2.39560202e-01f, 1.32676825e-01f, 1.91539750e-01f, 1.54986233e-01f, 3.47458422e-01f, 1.27235308e-01f, 2.89058000e-01f, 6.34671003e-02f,
  1.70231432e-01f, 8.46964493e-02f, 9.68622193e-02f, 7.77971670e-02f, 1.03740290e-01f, 1.33077845e-01f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  1.41830325e-01f, 1.99234914e-02f, 6.82556555e-02f, -1.30511820e-01f, -1.21317469e-01f, 8.26093853e-02f, 3.70128490e-02f, 1.97182328e-01f, 6.33153468e-02f, 6.27196357e-02f,
  1.76287275e-02f, -1.83387637e-01f, -1.29027054e-01f, -3.34506035e-01f, 4.32108082e-02f, -1.53002873e-01f, 1.98595941e-01f, -2.20371112e-01f, -1.04294017e-01f, -2.46845514e-01f,
  8.31670091e-02f, -2.48319030e-01f, 1.92131817e-01f, 9.10902396e-02f, -5.33438567e-03f, 3.03363711e-01f, 4.51845601e-02f, 2.25142017e-01f, -1.88054115e-01f, -1.76177025e-01f,
  2.26019714e-02f, 1.59146100e-01f, 2.01913312e-01f, 1.64133906e-02f, 1.44899547e-01f, -1.06936395e-02f, -1.84592590e-01f, -3.42556715e-01f, 7.92974755e-02f, -2.79368848e-01f,
  8.84796605e-02f, -1.99709520e-01f, 6.72500059e-02f, -2.33667016e-01f, 1.82287842e-01f, 1.34722427e-01f, -1.96052089e-01f, 2.72892043e-02f, -2.38355547e-01f, 3.11058551e-01f,
  -2.80048311e-01f, 6.52713552e-02f, 2.25004643e-01f, -3.22538354e-02f, 3.11195821e-01f, 2.91388463e-02f, -8.06715563e-02f, 3.28233987e-01f, -2.11184829e-01f, -1.49300158e-01f,
  4.29774910e-01f, 3.36529732e-01f, -2.50752121e-01f, 1.61400169e-01f, 1.07407801e-01f, 1.11419484e-01f, 1.38135433e-01f, 1.04652829e-01f, 5.86751429e-03f, -1.24294415e-01f,
  -3.64045473e-03f, 1.05085291e-01f, -1.58433184e-01f, 2.09625259e-01f, -1.30089402e-01f, -2.03305632e-01f, -6.22092858e-02f, -2.30187505e-01f, 2.51272947e-01f, 1.39358997e-01f,
  1.33248474e-02f, 1.09550267e-01f, 1.88578352e-01f, -2.53321767e-01f, 9.83046666e-02f, -2.13990465e-01f, -1.57407209e-01f, 1.99785292e-01f, 5.48973605e-02f, -6.12210156e-03f,
  1.03665538e-01f, 5.83750941e-02f, -1.19987190e-01f, -2.69925714e-01f, 3.84052806e-02f, -8.86814743e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.19239397e-01f, -2.33683735e-02f, 1.90937608e-01f, -9.92227495e-02f, 3.51012915e-01f, 5.33560589e-02f, -1.36274830e-01f, 1.79228522e-02f, 2.61286259e-01f, 8.78489017e-02f,
  -2.23663151e-01f, 9.52027291e-02f, -1.14059011e-02f, -4.67281118e-02f, -3.95066403e-02f, 2.03834355e-01f, -1.37257189e-01f, -2.74294555e-01f, 1.44758284e-01f, 1.58006206e-01f,
  -5.14156520e-02f, -1.37678951e-01f, -1.51746109e-01f, -4.51586731e-02f, 8.58824141e-03f, -5.43819405e-02f, -2.44734809e-02f, -2.69877035e-02f, 1.19934827e-01f, -7.17597678e-02f,
  3.43587011e-01f, -3.90620753e-02f, 2.67069548e-01f, -4.67641801e-02f, 2.26872023e-02f, -8.40372872e-03f, -3.77486080e-01f, 2.11555555e-01f, 4.35728878e-01f, 6.66611865e-02f,
  -2.55589843e-01f, 1.12908743e-02f, 2.50567764e-01f, 1.85894549e-01f, -5.36135137e-02f, 2.56751955e-01f, 1.91122174e-01f, -1.91153392e-01f, 3.32610965e-01f, 4.12156492e-01f,
  -9.76113752e-02f, -1.45797178e-01f, 1.92765817e-01f, 1.63542721e-02f, 2.61000454e-01f, 2.57162511e-01f, -2.65735477e-01f, 4.35494721e-01f, -5.88324629e-02f, 1.44644663e-01f,
  7.40168989e-02f, 2.45591387e-01f, -1.69352829e-01f, -1.92091033e-01f, 8.56197104e-02f, 1.82211876e-01f, -6.47696927e-02f, 7.56822899e-02f, 9.90834385e-02f, 3.53404760e-01f,
  -6.44856840e-02f, 3.68095338e-01f, -8.93737301e-02f, 3.68184894e-02f, 2.56246254e-02f, 2.68144459e-01f, 4.63888496e-02f, 2.74344802e-01f, 7.18484670e-02f, 8.24791491e-02f,
  3.25507492e-01f, 2.10306153e-01f, 3.23006690e-01f, 2.30971754e-01f, -2.05952972e-01f, 3.04830283e-01f, 2.15599447e-01f, 2.84744222e-02f, 2.45306522e-01f, -1.88364431e-01f,
  -1.45227443e-02f, 1.32831112e-01f, -1.71936363e-01f, -5.87545782e-02f, -3.09606306e-02f, -3.08465242e-01f, 2.83860505e-01f, 2.73196638e-01f, 1.20649755e-01f, 1.13114215e-01f,
  5.33387847e-02f, -7.01237619e-02f, 1.44115284e-01f, -2.10064754e-01f, 1.14734612e-01f, 4.26951349e-01f, -6.84865266e-02f, -2.63137788e-01f, 2.17047915e-01f, -1.43060282e-01f,
  2.36460224e-01f, 2.55935609e-01f, -1.08886778e-01f, 1.15777217e-01f, 1.20761260e-01f, -4.26650234e-02f, 1.58825219e-01f, -1.65510908e-01f, -1.98349342e-01f, 2.76292592e-01f,
  -2.76689410e-01f, 3.36694658e-01f, 2.52425730e-01f, 1.84530124e-01f, 8.12109932e-02f, 8.70047808e-02f, -1.37690872e-01f, -1.44572714e-02f, 2.23866969e-01f, 1.06026843e-01f,
  2.35337317e-02f, 2.71059960e-01f, -1.80069339e-02f, -2.79108971e-01f, 2.63933484e-02f, -1.53835684e-01f, 4.45643440e-02f, 4.12015438e-01f, 2.91848093e-01f, -5.92219718e-02f,
  4.09608841e-01f, -2.22771958e-01f, 2.73373753e-01f, 1.56070471e-01f, -6.59696311e-02f, 1.55810565e-01f, 9.06638727e-02f, 5.78056872e-02f, 1.72102034e-01f, 1.22033678e-01f,
  6.21063914e-03f, 2.59123266e-01f, -8.96592289e-02f, 1.68731883e-01f, 2.49618605e-01f, 1.88522384e-01f, -5.86351268e-02f, -3.46167713e-01f, -1.48448989e-01f, -2.88551357e-02f,
  -5.34155592e-02f, 8.91974643e-02f, 3.12987044e-02f, 1.02068931e-01f, 9.51633751e-02f, -6.22102134e-02f, 3.29987146e-02f, -2.30863914e-02f, -2.02211738e-02f, 2.30674669e-01f,
  7.79495835e-02f, 1.80758256e-02f, 1.82890564e-01f, -9.61465240e-02f, 1.33812591e-01f, 1.22270897e-01f, -6.51215315e-02f, -4.85817902e-02f, 3.75268795e-02f, -2.07149610e-02f,
  2.09562089e-02f, 5.31760640e-02f, -8.99460092e-02f, 8.69014263e-02f, 7.92563036e-02f, -1.31221205e-01f, 1.41234666e-01f, -4.62895930e-02f, -2.45458465e-02f, -8.69292319e-02f,
  -6.57824054e-02f, -2.02047154e-02f, -8.18537697e-02f, 7.63147622e-02f, 8.44441727e-02f, -1.19306199e-01f, -1.65910318e-01f, 3.63855332e-01f, 3.75505947e-02f, 3.83060306e-01f,
  -1.28621712e-01f, 5.52231446e-02f, 2.66574603e-02f, 1.78750291e-01f, -9.42027718e-02f, -1.93414763e-01f, 1.28561810e-01f, -1.56413577e-02f, 4.90025908e-01f, 1.71687733e-02f,
  1.36978805e-01f, -1.93011031e-01f, -4.10152636e-02f, -2.11259544e-01f, -1.34634569e-01f, 4.47356626e-02f, 1.17540836e-01f, 1.04555473e-01f, 5.04003130e-02f, 3.35259736e-01f,
  -2.71942407e-01f, -3.11445385e-01f, 2.01274872e-01f, -2.63955712e-01f, 2.93869615e-01f, 1.44296035e-01f, 4.12233621e-02f, -3.37852426e-02f, -1.30047901e-02f, 1.86112039e-02f,
  5.62816150e-02f, -1.82191789e-01f, -2.44081765e-02f, 1.93328649e-01f, -1.78237222e-02f, 8.11104402e-02f, 3.44898909e-01f, 4.26786631e-01f, 9.47120413e-02f, 2.44971111e-01f,
  -1.61534280e-01f, 2.94604063e-01f, -3.78313325e-02f, 7.18123838e-02f, 5.95412143e-02f, 3.14048558e-01f, 1.52885646e-01f, 3.15986723e-01f, -1.86695799e-01f, 2.38794461e-01f,
  2.30314627e-01f, 1.80274770e-01f, 2.45625407e-01f, 2.65370846e-01f, 1.32055953e-01f, 1.10049509e-01f, 2.85827339e-01f, 2.04617698e-02f, 1.24732070e-01f, 9.41927731e-02f,
  3.00482661e-01f, -2.22791377e-02f, -1.94813699e-01f, -2.85208318e-02f, 2.14794397e-01f, 4.03233260e-01f, -8.67741555e-02f, 1.79833043e-02f, 3.18471283e-01f, 2.03618392e-01f,
  1.29081056e-01f, 3.60735297e-01f, -2.17409089e-01f, 1.29642040e-01f, 2.62798101e-01f, 2.93512940e-01f, 6.34571863e-03f, 2.81265855e-01f, -1.76288381e-01f, 1.99118644e-01f,
  -1.35540664e-01f, -1.99088767e-01f, 9.16965306e-02f, -7.32231606e-03f, 3.10994267e-01f, 1.67051088e-02f, 1.67855904e-01f, -4.15718071e-02f, 1.56274021e-01f, 1.56517625e-01f,
  6.51089847e-02f, 2.32497424e-01f, 5.02902307e-02f, -1.69418693e-01f, -1.04865894e-01f, -1.13699874e-02f, 2.54129589e-01f, 2.73736473e-02f, 1.07213996e-01f, 9.17532519e-02f,
  4.23619330e-01f, -1.14307217e-01f, -9.95217860e-02f, -7.37030804e-02f, -2.90701807e-01f, -1.23986758e-01f, 7.42839575e-02f, 3.17697227e-01f, 1.65514469e-01f, 3.63554209e-01f,
  1.66431978e-01f, -5.35245724e-02f, 2.89611608e-01f, -1.40882745e-01f, 1.97281033e-01f, -1.24323651e-01f, 9.64122787e-02f, -2.86262661e-01f, 1.75579041e-01f, 2.36854911e-01f,
  1.03531376e-01f, 1.31497264e-01f, 1.51487187e-01f, 1.12956762e-01f, -2.41519928e-01f, 1.36897769e-02f, -1.04283625e-02f, 2.35340968e-01f, -1.73222363e-01f, 2.68547237e-02f,
  4.55743521e-01f, 6.07314445e-02f, 2.74739802e-01f, -9.49773751e-03f, 2.90511902e-02f, -5.63336164e-02f, 6.43557087e-02f, 3.12031746e-01f, 8.34596828e-02f, 1.24586657e-01f,
  2.54600167e-01f, 2.90702403e-01f, 3.62046659e-01f, 2.62938231e-01f, 3.23966593e-01f, 4.52071466e-02f, 1.28378883e-01f, 2.47137666e-01f, 3.22826244e-02f, -2.87214845e-01f,
  -2.45913953e-01f, -8.43450502e-02f, 8.08282644e-02f, 3.68343070e-02f, 1.65694550e-01f, -3.58683646e-01f, 1.70809627e-01f, 9.84294936e-02f, -5.21318130e-02f, 1.73279896e-01f,
  4.07487690e-01f, 2.53940169e-02f, 5.93020469e-02f, 2.15213716e-01f, 6.63134009e-02f, 7.13801235e-02f, -1.23026529e-02f, 3.71679366e-02f, 4.43952344e-02f, -7.15340897e-02f,
  1.86403155e-01f, 2.98580766e-01f, -1.02281280e-01f, 1.05805814e-01f, 1.11574352e-01f, -9.42600146e-02f, 1.13265604e-01f, -1.89626560e-01f, 1.24229498e-01f, 4.41533625e-02f,
  3.32038909e-01f, 3.61272931e-01f, 3.05134654e-01f, 2.97776252e-01f, 3.19232553e-01f, 1.22716814e-01f, 2.09465817e-01f, -2.71302134e-01f, 5.49797080e-02f, 1.88416918e-04f,
  1.31831795e-01f, -1.31645694e-01f, 2.01197892e-01f, 3.62789333e-01f, -5.24557382e-02f, -1.46288931e-01f, 2.05055982e-01f, 1.97414920e-01f, 1.22809298e-01f, 3.01743001e-01f,
  -9.68713164e-02f, 2.64736176e-01f, -1.93458367e-02f, 7.78863430e-02f, 2.52983779e-01f, -5.37008941e-02f, 6.15032651e-02f, 3.16938549e-01f, -2.45918930e-01f, 8.88672769e-02f,
  1.25916660e-01f, -1.10805463e-02f, 4.40931737e-01f, 4.42576259e-01f, 3.00034642e-01f, 3.82819533e-01f, 1.03159279e-01f, 2.20128372e-01f, 1.22503906e-01f, 2.17106685e-01f,
  1.10159203e-01f, 2.01892391e-01f, -2.89277434e-01f, 1.63315058e-01f, -1.40435100e-01f, -7.39135891e-02f, 7.83293992e-02f, 3.80234838e-01f, 1.24058947e-01f, 1.55285085e-02f,
  1.19881094e-01f, 1.33039936e-01f, 1.54449269e-01f, 1.45758808e-01f, 3.20677161e-01f, 1.39507473e-01f, -6.33803234e-02f, 3.79158109e-01f, 8.02032351e-02f, -3.74142043e-02f,
  3.62869054e-01f, -2.23923668e-01f, 2.42835864e-01f, 2.25707367e-01f, -1.53028563e-01f, -4.50443141e-02f, 9.40411761e-02f, -6.71595931e-02f, -5.21336719e-02f, 8.54913443e-02f,
  2.07147107e-01f, 2.55920559e-01f, 6.29261881e-02f, 6.95996433e-02f, -2.31079474e-01f, 1.43796653e-01f, 6.52334690e-02f, 4.23695594e-02f, 3.52096200e-01f, 1.93741530e-01f,
  1.74040392e-01f, -1.15736850e-01f, -1.60513874e-02f, -1.63917601e-01f, 2.59354353e-01f, -1.02646127e-01f, 2.80497968e-01f, 1.02040499e-01f, -3.29865366e-02f, 2.98557878e-01f,
  2.66802579e-01f, -1.09746374e-01f, 3.54758978e-01f, -2.21931264e-01f, 8.99377167e-02f, -1.42294774e-02f, -2.17565939e-01f, -3.86511952e-01f, 3.76185253e-02f, -4.92595360e-02f,
  1.26474679e-01f, 1.07793935e-01f, 3.65548104e-01f, -3.75592321e-01f, 7.46505857e-02f, -7.83853605e-02f, 9.69248861e-02f, 3.18065643e-01f, 3.24009657e-01f, -2.87936598e-01f,
  1.98780835e-01f, -1.75852403e-01f, 1.83376744e-01f, -2.50834793e-01f, -1.91181332e-01f, -1.45901576e-01f, 1.98706508e-01f, -2.41856456e-01f, 4.70496081e-02f, 1.38880447e-01f,
  1.57470450e-01f, -1.10342756e-01f, 4.40247983e-01f, -1.67374060e-01f, 2.01230079e-01f, -1.66619882e-01f, -1.52895719e-01f, 1.33559883e-01f, 1.95168540e-01f, 1.75955310e-01f,
  1.13720939e-01f, 2.39486694e-01f, 1.48096476e-02f, -3.46676074e-02f, 1.27339795e-01f, -6.08817749e-02f, -2.76100457e-01f, -2.96147130e-02f, 1.18657559e-01f, 3.72964889e-01f,
  -7.41589591e-02f, 4.48403507e-03f, 2.99045235e-01f, 9.91471764e-03f, 2.19611870e-03f, -1.35157526e-01f, 4.40703891e-02f, -1.82333708e-01f, 4.49267238e-01f, -7.42468536e-02f,
  -1.03419177e-01f, -1.17834844e-01f, 2.21159413e-01f, -1.55586243e-01f, 2.63218224e-01f, -4.04631235e-02f, 2.39614993e-01f, 1.68995962e-01f, -7.10563064e-02f, 1.67888656e-01f,
  -2.27637604e-01f, 4.83904444e-02f, -2.16186091e-01f, -1.61149830e-01f, -9.15567279e-02f, 7.06784874e-02f, -5.33539541e-02f, 1.39921039e-01f, 2.57140994e-01f, 2.45787084e-01f,
  -1.39699411e-02f, 2.96007484e-01f, 2.24582374e-01f, 3.06091368e-01f, -1.08268045e-01f, -1.21510155e-01f, -2.98510194e-01f, -6.33159131e-02f, 2.46863440e-01f, 3.85062546e-01f,
  3.10937107e-01f, -1.71409324e-01f, 3.18737954e-01f, 6.75530657e-02f, -1.17731176e-01f, -2.40512565e-01f, -4.00659531e-01f, 5.86114712e-02f, 9.89503264e-02f, -3.32807228e-02f,
  -6.46263883e-02f, 3.81997265e-02f, 4.15169820e-02f, -4.70795669e-03f, 2.76849151e-01f, -1.46494836e-01f, 1.87682867e-01f, 1.97593495e-01f, 2.59212494e-01f, 1.18149318e-01f,
  -5.20888939e-02f, -2.09984869e-01f, 1.56574212e-02f, -1.23093300e-01f, 1.54952034e-01f, -2.37869024e-01f, 5.99982291e-02f, 2.91059226e-01f, 4.04798537e-01f, 2.59176314e-01f,
  -1.89812630e-01f, -3.98598760e-02f, -1.40387759e-01f, 1.89111680e-01f, -1.15204612e-02f, 4.43291932e-01f, 1.26558378e-01f, 4.83000994e-01f, 3.22291583e-01f, -7.28039965e-02f,
  1.24036968e-01f, -7.08105043e-02f, 1.22047976e-01f, -1.00104362e-01f, 1.74327418e-01f, 2.24919334e-01f, -1.45875692e-01f, 8.62244070e-02f, 2.57889945e-02f, 6.82161525e-02f,
  3.26836199e-01f, -2.36382082e-01f, -5.34241237e-02f, -1.22662909e-01f, 3.50864351e-01f, 3.01718786e-02f, 2.73723543e-01f, -1.73512518e-01f, 6.74455166e-02f, -2.79159516e-01f,
  8.03014860e-02f, -2.30133608e-01f, -2.33857986e-02f, -7.18346657e-03f, -6.82202727e-02f, -1.49957994e-02f, -3.44326705e-01f, 1.04195751e-01f, 2.82177091e-01f, -2.60007471e-01f,
  2.35377371e-01f, 5.65953031e-02f, -8.62889830e-03f, 3.65552962e-01f, -8.72494951e-02f, 1.18550062e-02f, 1.06465243e-01f, 3.29065025e-01f, -7.82275572e-02f, 4.46722269e-01f,
  -3.94312181e-02f, -5.78224696e-02f, 3.37975696e-02f, 2.30342925e-01f, -2.76263624e-01f, 6.83799982e-02f, 1.28876805e-01f, 6.29667640e-02f, -2.20827699e-01f, 2.09327221e-01f,
  1.92306578e-01f, 6.98741078e-02f, -5.33698946e-02f, 9.50016733e-03f, 1.13559976e-01f, -1.16873406e-01f, 4.16112006e-01f, 1.30540477e-02f, 4.01131921e-02f, -1.65174991e-01f,
  1.09859727e-01f, 2.59653907e-02f, 7.63278902e-02f, 2.16975987e-01f, 1.70042276e-01f, 2.58502543e-01f, 1.69665039e-01f, 2.35936582e-01f, -1.56279668e-01f, -1.68003306e-01f,
  -2.17603728e-01f, -3.03417832e-01f, -6.39130548e-03f, 1.56575784e-01f, 2.95934062e-02f, 8.08099210e-02f, 1.61345959e-01f, 1.39610067e-01f, -6.15504161e-02f, 2.75040083e-02f,
  2.16808930e-01f, 4.08428788e-01f, -4.84598055e-02f, 2.36190945e-01f, 5.14054187e-02f, 2.11021692e-01f, 1.96180537e-01f, 3.80098045e-01f, 1.30542619e-02f, -2.78631207e-02f,
  3.63022983e-01f, 1.55528426e-01f, -1.60261482e-01f, 2.37998143e-01f, -2.37977326e-01f, 9.77552012e-02f, 6.59549087e-02f, -1.97335839e-01f, 1.70688525e-01f, -3.55563015e-02f,
  8.16567391e-02f, -1.26891648e-02f, 4.22115833e-01f, -9.84369814e-02f, -2.98944768e-02f, 2.93907046e-01f, 4.16117966e-01f, -4.38040465e-01f, 2.59085894e-01f, 1.79003134e-01f,
  1.11164629e-01f, 2.82711744e-01f, 1.18657477e-01f, -2.06133410e-01f, -1.36483282e-01f, 1.75443932e-01f, -1.44430220e-01f, -5.59541136e-02f, -1.44353047e-01f, -1.95130304e-01f,
  -9.18709040e-02f, -7.58262202e-02f, 7.49984849e-03f, 9.37958807e-03f, -2.03149870e-01f, -2.74926186e-01f, 7.92531893e-02f, -1.19358264e-01f, 6.74193576e-02f, 2.89997198e-02f,
  -1.99641004e-01f, 8.77569895e-03f, 1.79392159e-01f, 4.85480040e-01f, 4.77746993e-01f, 2.30335981e-01f, 1.02951244e-01f, 3.88250276e-02f, 1.10091574e-01f, 9.48510692e-02f,
  -3.68690826e-02f, -1.23145685e-01f, -9.21208262e-02f, -9.86732990e-02f, 1.00582121e-02f, 2.17340291e-01f, -8.64116754e-03f, -1.70017287e-01f, 1.02556460e-01f, -8.80355388e-02f,
  2.16268837e-01f, 3.17094117e-01f, -1.75184026e-01f, 1.34277493e-01f, 1.12878352e-01f, 9.30931494e-02f, 5.42559400e-02f, -1.66869666e-02f, -1.38770491e-01f, 1.18698575e-01f,
  -1.50644287e-01f, -1.41147554e-01f, 9.56763178e-02f, 1.03142388e-01f, 1.12179741e-02f, -4.02874649e-02f, -1.80817723e-01f, 6.82636797e-02f, 1.30204260e-01f, 2.23007053e-02f,
  1.81823567e-01f, 2.50870790e-02f, -2.37561688e-01f, -1.67568162e-01f, 3.31435621e-01f, 8.26466084e-02f, -6.59690872e-02f, -2.28485819e-02f, 2.85360038e-01f, 6.49641156e-02f,
  2.37604335e-01f, 1.31225109e-01f, -4.25718501e-02f, -1.85252130e-01f, 1.92434549e-01f, 1.69014901e-01f, -2.40219951e-01f, -2.73617376e-02f, 2.98931777e-01f, -4.17356305e-02f,
  3.45636487e-01f, 1.27045870e-01f, 2.20785931e-01f, 4.10065174e-01f, 1.31181434e-01f, 8.29439238e-02f, -3.16021554e-02f, -1.32359669e-01f, -3.64553034e-01f, 1.98180899e-02f,
  1.28223702e-01f, 1.30583093e-01f, 1.48238614e-01f, -2.43849248e-01f, 8.17145780e-02f, -2.19284892e-01f, -7.24839699e-03f, 1.33862898e-01f, 3.06744516e-01f, -3.94890681e-02f,
  2.11548626e-01f, 1.01102684e-02f, 2.21259341e-01f, -1.80574298e-01f, -1.45336017e-01f, -1.31999373e-01f, -1.20918243e-03f, -2.33735368e-02f, -1.21880949e-01f, 2.19118536e-01f,
  2.02109396e-01f, 1.12295160e-02f, 3.98602664e-01f, 2.04074588e-02f, 3.09112161e-01f, -2.02498153e-01f, 1.55328199e-01f, 9.09681618e-03f, 1.49048850e-01f, 4.59740497e-02f,
  4.63344296e-03f, 2.62716889e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  1.02148026e-01f, 1.07332449e-02f, 1.44272774e-01f, 4.91358973e-02f, 2.38920480e-01f, 1.13530405e-01f, 2.23676898e-02f, 1.75648034e-01f, 1.38462499e-01f, 1.80451527e-01f,
  3.08347374e-01f, 2.13578120e-01f, 2.60474324e-01f, 1.46093756e-01f, 1.07546441e-01f, 2.23275930e-01f, 2.32388929e-01f, 1.39063761e-01f, -8.44686199e-03f, 1.60597429e-01f,
  1.65876150e-01f, 1.40641004e-01f, 2.49737665e-01f, -4.36949581e-02f, 2.73502350e-01f, 1.56859919e-01f
};

// L2_fan_Wp (Shape: 3 x 32)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -9.76273343e-02f, 5.32362871e-02f, -1.35435253e-01f, -1.61136478e-01f, 1.13437124e-01f, -9.01540369e-02f, -1.49394199e-01f, 1.88580006e-01f, 2.83880555e-03f, 1.39944479e-01f,
  1.74304724e-01f, 7.42071122e-02f, -1.25229165e-01f, 1.44750938e-01f, 1.82014570e-01f, 4.09892835e-02f, 2.57897247e-02f, -6.09040707e-02f, -1.36445209e-01f, -1.81469381e-01f,
  -8.98950398e-02f, -2.61045009e-01f, -2.25967690e-01f, 1.14546537e-01f, 8.27381853e-03f, -1.21526554e-01f, 1.88775197e-01f, -6.42621964e-02f, -3.48200232e-01f, 9.87733603e-02f,
  4.04077992e-02f, -2.93825716e-01f, -1.66814476e-01f, -3.30926385e-03f, -1.73033401e-01f, 1.19215839e-01f, -2.34542340e-02f, 6.87921196e-02f, -7.72833303e-02f, 2.30190307e-01f,
  -3.38190165e-03f, 2.22969681e-01f, 8.33552927e-02f, -1.22118555e-02f, -5.06045632e-02f, 1.19472980e-01f, 4.00364362e-02f, -1.69394299e-01f, -1.08876847e-01f, 5.37471771e-02f,
  6.47617579e-02f, -1.41484896e-02f, -1.22459121e-01f, -1.09102778e-01f, -5.45344651e-02f, 1.00380689e-01f, -1.27681538e-01f, 4.84566130e-02f, 1.85853750e-01f, -8.35016742e-02f,
  -1.64914384e-01f, 3.12018488e-02f, -1.19748488e-01f, 6.60535097e-02f, 2.97449362e-02f, 6.72142282e-02f, -1.56531751e-01f, -2.28486329e-01f, -2.21610039e-01f, 3.29859406e-02f,
  -3.05880550e-02f, 5.99135458e-02f, 1.26787022e-01f, 6.90134838e-02f, 1.56598777e-01f, 1.29496291e-01f, 6.58719167e-02f, 1.92186266e-01f, 2.12041035e-01f, 1.48648784e-01f,
  3.54398936e-02f, 1.09142609e-01f, 1.96942061e-01f, 2.07431186e-02f, 2.14935794e-01f, -1.81911632e-01f, -6.04205541e-02f, -1.83479950e-01f, 4.64361757e-02f, -2.48169884e-01f,
  -1.32592604e-01f, 2.05930546e-01f, 8.75880048e-02f, 6.99872971e-02f, -2.04728007e-01f, -9.71317589e-02f
};

// L2_fan_Wp_bar (Shape: 26 x 32)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -1.13758659e-02f, 2.16155499e-02f, -6.49906620e-02f, -8.49483237e-02f, 6.18340559e-02f, -5.57342805e-02f, -2.73890734e-01f, 3.52447599e-01f, 3.80468190e-01f, 7.56889209e-02f,
  -9.05402750e-03f, -1.77402031e-02f, 1.40682384e-01f, 3.82050306e-01f, 2.83752754e-02f, -7.37516806e-02f, 3.01647633e-01f, -5.13260104e-02f, 1.09883673e-01f, 3.09865594e-01f,
  4.00228146e-03f, -2.59694844e-01f, 1.07410647e-01f, -2.15939790e-01f, 2.45503843e-01f, -2.03617930e-01f, 2.45370775e-01f, 1.96203645e-02f, -3.29058796e-01f, 1.53618082e-01f,
  3.71818393e-01f, -7.49790072e-02f, 2.15036303e-01f, 1.02162018e-01f, 3.24146271e-01f, -3.36289912e-01f, 2.23832890e-01f, -2.00024113e-01f, 3.87491882e-02f, -2.72604078e-01f,
  -1.00633413e-01f, -6.12413883e-03f, 3.47589374e-01f, 1.42355517e-01f, -2.46230096e-01f, 1.27750874e-01f, 3.94418910e-02f, 4.71066266e-01f, 3.09724808e-01f, 7.30598643e-02f,
  5.38801961e-02f, 5.58284149e-02f, 3.48086506e-01f, 1.70256317e-01f, -1.08925007e-01f, -4.14175510e-01f, 3.31592232e-01f, 2.00352371e-01f, -1.30566746e-01f, 5.07953689e-02f,
  -4.41170067e-01f, 1.10605292e-01f, 1.29950806e-01f, 3.55241984e-01f, 1.83919311e-01f, 8.50082189e-02f, 2.07894310e-01f, -1.05393440e-01f, 3.42648149e-01f, -3.08784038e-01f,
  -4.50973138e-02f, -1.49625540e-02f, -1.93681300e-01f, -1.58942029e-01f, 1.18684508e-01f, -3.44420113e-02f, -1.72048777e-01f, 1.16437495e-01f, 5.47476765e-03f, 2.48930112e-01f,
  1.49072587e-01f, 3.36549014e-01f, 1.55001268e-01f, -2.01421559e-01f, -8.51433650e-02f, 3.42164785e-01f, 1.93962485e-01f, -2.96516269e-01f, 1.66817755e-01f, 3.12181175e-01f,
  1.21095562e-02f, -1.44366667e-01f, -1.82266198e-02f, 3.85950645e-03f, 5.92103526e-02f, 2.66048163e-01f, 1.99596375e-22f, -2.74834603e-24f, 3.71628744e-16f, 9.81319599e-18f,
  5.60967835e-18f, -4.15706827e-28f, 4.93433623e-40f, -1.46526047e-09f, -4.56406718e-10f, -2.16042367e-13f, -1.23565798e-08f, -8.52030738e-11f, -2.91258892e-11f, -1.07969955e-09f,
  -4.15392637e-10f, -7.97655067e-11f, -2.96924174e-09f, -3.24155702e-09f, -1.55174700e-08f, -2.63359246e-09f, -5.08154074e-11f, -7.34539686e-12f, -2.75595158e-10f, -5.48521236e-20f,
  -2.21489294e-09f, -1.61476752e-14f, -7.56426810e-10f, -1.07058945e-10f, -3.75591391e-27f, -2.37029735e-28f, -5.41302914e-09f, -1.89470245e-10f, -7.97839388e-02f, -3.77975740e-02f,
  -1.79604486e-01f, 2.25058138e-01f, -1.18209660e-01f, -2.02359445e-02f, 2.28484973e-01f, 1.76220417e-01f, 1.23751901e-01f, -1.03222150e-02f, -2.59722441e-01f, -1.36057779e-01f,
  1.82221562e-01f, 1.08582154e-01f, 7.13399202e-02f, -1.42391399e-01f, -1.77228630e-01f, 3.84386092e-01f, 2.31755823e-01f, 2.94245668e-02f, -1.34448200e-01f, 2.10037082e-01f,
  6.39362186e-02f, 2.74691135e-01f, -2.42464766e-02f, 1.59824282e-01f, -3.02698184e-02f, 1.48468941e-01f, 5.98539591e-01f, -1.19799323e-01f, -9.73378792e-02f, -1.88977215e-02f,
  -1.85720678e-02f, 1.30934089e-01f, 2.65556742e-02f, 1.79838896e-01f, 1.79588109e-01f, -1.70448720e-01f, 2.72201985e-01f, -5.72519042e-02f, 3.61392163e-02f, 1.60562113e-01f,
  -2.67488748e-01f, 1.20221145e-01f, -1.49012670e-01f, -3.13452474e-04f, 1.04508102e-02f, -1.45880848e-01f, -2.51996458e-01f, 3.44415665e-01f, 2.81711221e-01f, -1.77974522e-01f,
  -8.42249840e-02f, 3.41911227e-01f, 3.87384593e-02f, 2.68495142e-01f, 1.51567027e-01f, 3.34380031e-01f, -1.78347066e-01f, 1.23947784e-01f, 4.75260079e-01f, -9.25958827e-02f,
  -6.08867407e-02f, 1.34691939e-01f, 2.95877814e-01f, 9.45220292e-02f, 1.81508325e-02f, 1.30727161e-02f, -1.19609676e-01f, 2.04870358e-01f, 1.18274823e-01f, -2.22729370e-01f,
  9.04959589e-02f, 2.80828774e-01f, 3.57242078e-01f, 1.44706801e-01f, 2.40433097e-01f, 1.08437780e-02f, 2.29672790e-01f, 8.79615266e-03f, 1.90959960e-01f, -7.34233931e-02f,
  2.00152740e-01f, 2.18320563e-01f, 1.21382348e-01f, -1.75674662e-01f, 1.82358008e-02f, 2.35343426e-01f, -9.76028666e-02f, -2.23424241e-01f, 3.22476216e-02f, 2.52461225e-01f,
  -9.42984968e-02f, 2.78862387e-01f, -2.45029747e-01f, 1.65986001e-01f, 2.29288056e-01f, -6.97832629e-02f, 6.53147399e-02f, 2.60438174e-01f, -4.69102949e-01f, 2.57552892e-01f,
  -5.00735454e-03f, -1.85855567e-01f, 2.46706173e-01f, 8.38955212e-03f, 2.11004585e-01f, 1.86501577e-01f, 2.70326048e-01f, -1.32964358e-01f, 5.47744753e-03f, -4.37994190e-02f,
  2.26783752e-01f, 1.61791891e-01f, -3.10264099e-02f, 2.27556497e-01f, 3.21565300e-01f, 5.58901355e-02f, 1.99035048e-01f, 4.06851798e-01f, -2.90795118e-01f, -2.69819051e-01f,
  2.43167102e-01f, 1.98980808e-01f, 6.25283718e-02f, 1.38499975e-01f, 2.76781991e-02f, 2.19673384e-02f, -8.77266563e-03f, -3.65144238e-02f, 1.32622555e-01f, 3.34143937e-01f,
  -7.41569325e-02f, 3.20239179e-02f, -9.22357365e-02f, 1.83883369e-01f, 1.37493327e-01f, 4.33903327e-03f, 8.27971399e-02f, 8.62964913e-02f, 3.24155003e-01f, -1.58320367e-01f,
  -3.46545905e-01f, -1.02162786e-01f, 1.18889101e-01f, 1.38009610e-02f, 7.00854659e-02f, 5.34984395e-02f, 1.45239964e-01f, 1.29062727e-01f, 4.24545676e-01f, 2.34600052e-01f,
  -1.09265342e-01f, 1.68007001e-01f, 2.09881306e-01f, -2.12161556e-01f, 5.53148463e-02f, 2.39678030e-03f, 1.79626778e-01f, -7.68007105e-03f, 1.00516923e-01f, 2.23627493e-01f,
  -3.25291939e-02f, -2.39288568e-01f, 5.46084307e-02f, 1.02215700e-01f, 9.67912674e-02f, -1.71395004e-01f, -4.15081978e-02f, 3.24136019e-01f, 3.18486035e-01f, 1.48055807e-01f,
  -1.55891478e-01f, 2.97642499e-01f, 4.23062921e-01f, 2.92899191e-01f, 1.68246776e-01f, -3.54715399e-02f, 1.42384171e-01f, -4.44786437e-02f, -4.34519909e-02f, -3.19350255e-03f,
  -2.86932170e-01f, -3.67290005e-02f, 5.06099649e-02f, 5.76694049e-02f, -1.29044652e-01f, 1.86758235e-01f, -3.89986217e-01f, 2.74303973e-01f, 5.13894446e-02f, 1.55327290e-01f,
  -1.70716399e-03f, -4.69394289e-02f, -1.90489218e-01f, -2.06768379e-01f, 2.02238813e-01f, 1.11818604e-01f, 1.22325709e-02f, 3.40553641e-01f, 1.05069876e-01f, 4.61850822e-01f,
  2.98171669e-01f, 1.14155442e-01f, 5.40193282e-02f, 3.86784524e-01f, 4.08652514e-01f, -5.75008802e-02f, 1.42218888e-01f, 2.47249946e-01f, 2.15777412e-01f, 7.40604475e-02f,
  -5.95455803e-02f, -4.56884891e-01f, -1.61611825e-01f, 9.29953065e-03f, 1.19864866e-01f, -8.71601105e-02f, 6.14017770e-02f, 3.74625891e-01f, -1.44468352e-01f, 1.86415151e-01f,
  -1.91308975e-01f, -2.96733588e-01f, 1.56323202e-02f, -1.27352014e-01f, -1.11730278e-01f, 2.89324075e-01f, -3.47324610e-01f, -7.34823421e-02f, 1.40478015e-02f, 2.58945674e-01f,
  3.58041853e-01f, -1.30219474e-01f, 6.95499554e-02f, -5.84878139e-02f, 3.88471127e-01f, -2.62583029e-02f, 5.42813679e-03f, -1.21521339e-01f, 2.37612680e-01f, 1.82795636e-02f,
  2.34907754e-02f, 2.86197335e-01f, 8.01040381e-02f, 9.12824459e-03f, 1.77001789e-01f, 3.04777145e-01f, 5.80943413e-02f, -2.66632646e-01f, 8.73014424e-03f, 2.43950740e-01f,
  2.62828559e-01f, 1.67133417e-02f, 8.24655741e-02f, -1.09955119e-02f, 1.48911417e-01f, 5.67690171e-02f, 3.57293850e-03f, 2.63428539e-01f, -3.24297071e-01f, -6.13280907e-02f,
  1.57841220e-01f, -1.21954726e-02f, 1.78452298e-01f, -3.95743176e-02f, -2.64750719e-02f, 7.43181258e-02f, 3.31863761e-01f, -1.46680370e-01f, -1.37457013e-01f, 1.82790712e-01f,
  1.82847157e-01f, 9.78848636e-02f, -3.10402691e-01f, 8.03469345e-02f, 3.85081410e-01f, 4.32272740e-02f, 2.78414935e-01f, 7.29043782e-02f, -1.65719520e-02f, -2.00870439e-01f,
  1.42314151e-01f, 8.62448514e-02f, 5.54141439e-02f, -1.37187645e-01f, 4.95780744e-02f, 9.37474370e-02f, -1.29226103e-01f, -1.63984060e-01f, -4.06671539e-02f, 2.06372112e-01f,
  1.60100043e-01f, 2.11036295e-01f, -3.14724803e-01f, 5.01635134e-01f, 1.10636361e-01f, 2.45180815e-01f, 3.44950259e-01f, 1.25275493e-01f, 1.67380661e-01f, 2.45528102e-01f,
  -3.02826334e-02f, -1.98879227e-01f, 3.14687699e-01f, -8.49432275e-02f, 1.15665697e-01f, -1.24874376e-01f, -1.55588582e-01f, -2.54414305e-02f, 2.98432559e-01f, -4.75732870e-02f,
  6.09701946e-02f, 1.07101843e-01f, 2.79935747e-01f, -9.51126143e-02f, -1.87935099e-01f, 1.51951388e-01f, 3.40660602e-01f, 2.09103469e-02f, 1.69572145e-01f, -2.03095302e-02f,
  4.82442677e-02f, 2.06539169e-01f, -1.54581442e-01f, 8.84514675e-03f, 4.28685471e-02f, -1.70782618e-02f, 1.16188549e-01f, 2.35824790e-02f, 6.41825870e-02f, -6.02587424e-02f,
  2.46211901e-01f, 1.63982421e-01f, 5.29782362e-02f, 2.10628182e-01f, 3.58659595e-01f, 1.23899192e-01f, 7.24087134e-02f, 3.42005372e-01f, 3.05405378e-01f, 1.23411238e-01f,
  9.07162577e-02f, -1.55607522e-01f, 2.46573314e-01f, -1.18607506e-01f, -1.73729789e-02f, 1.00236334e-01f, -1.68291964e-02f, 2.36306489e-02f, 1.74625412e-01f, 1.84459463e-01f,
  9.91491973e-02f, 5.60491346e-02f, 2.20487460e-01f, 1.20256059e-01f, 3.93167287e-01f, 1.19062811e-01f, -1.64379627e-01f, 3.79128695e-01f, -2.17471048e-01f, 2.31353521e-01f,
  1.73166648e-01f, 2.22164735e-01f, 1.02416404e-01f, 2.58869737e-01f, -7.24880621e-02f, -1.36446534e-02f, 3.17674786e-01f, -8.58240575e-02f, 2.52833158e-01f, -1.95595160e-01f,
  -2.10066691e-01f, 1.17729537e-01f, 1.52769268e-01f, -2.15605617e-01f, 3.82240675e-02f, 2.82547206e-01f, 2.18497917e-01f, -3.94645706e-02f, 1.22695100e-02f, 6.84805363e-02f,
  2.95415610e-01f, 2.65215993e-01f, 3.87154445e-02f, 8.87043476e-02f, 3.40537168e-03f, -6.46498203e-02f, 1.36168346e-01f, 3.04823946e-02f, 2.73847550e-01f, -2.18387187e-01f,
  -2.17886358e-01f, 1.60622492e-01f, 3.52980830e-02f, 9.80751216e-02f, -2.17597470e-01f, 1.45153046e-01f, 2.98400313e-01f, 1.15397379e-01f, -2.40592778e-01f, 2.92181969e-01f,
  4.10341769e-01f, -1.17939472e-01f, -1.52092591e-01f, 2.00923413e-01f, -1.81597933e-01f, 1.50341377e-01f, 5.61769828e-02f, 2.42360413e-01f, -2.07362071e-01f, 2.27471665e-01f,
  2.34523550e-01f, 8.99305344e-02f, -2.17525348e-01f, 1.27524227e-01f, -4.71064039e-02f, -6.54086694e-02f, 1.70538500e-01f, 7.16416864e-03f, 1.20182715e-01f, -7.23314956e-02f,
  -2.69233614e-01f, 2.63499379e-01f, -8.78817588e-03f, 2.66745668e-02f, 2.87883252e-01f, 7.67143592e-02f, 1.47987962e-01f, 3.97454463e-02f, 6.18584454e-02f, 1.15789145e-01f,
  2.97205538e-01f, -1.60209209e-01f, 1.37620941e-01f, 1.68115832e-02f, 1.70727447e-01f, -2.07933262e-01f, 1.15885988e-01f, -1.31531522e-01f, 2.33348265e-01f, 3.17384861e-02f,
  2.47554898e-01f, 9.92428605e-03f, -2.04371333e-01f, -5.25319309e-04f, 3.78542513e-01f, -2.19170321e-02f, 9.26379114e-02f, 2.10363656e-01f, 2.33718470e-01f, -1.54287681e-01f,
  -1.18332550e-01f, -2.51332849e-01f, 1.20982379e-01f, -2.81443387e-01f, 3.27518284e-01f, -3.07916433e-01f, 1.61702141e-01f, 1.48098022e-01f, 4.39192820e-03f, -9.50712264e-02f,
  1.75499357e-02f, 3.59298199e-01f, 2.66036928e-01f, 2.65620470e-01f, -2.14933857e-01f, 3.28543156e-01f, 4.45503056e-01f, 2.43459925e-01f, 6.71474487e-02f, -2.04743505e-01f,
  4.00984257e-01f, -1.64280623e-01f, 8.46741050e-02f, -1.10163227e-01f, -1.34199187e-01f, -1.60470650e-01f, -5.26679903e-02f, 1.66025668e-01f, 2.77398735e-01f, 2.51836389e-01f,
  9.76812616e-02f, -3.60250920e-01f, 2.93047756e-01f, 1.12887517e-01f, 1.69587344e-01f, -3.12101662e-01f, -2.04144567e-01f, 1.71682283e-01f, 1.30787939e-01f, 2.77340293e-01f,
  -2.92197138e-01f, 8.54804292e-02f, 3.17369819e-01f, 2.95769364e-01f, -1.49251625e-01f, 4.61891033e-02f, 1.80936381e-01f, 1.56495214e-01f, 2.75197960e-02f, 7.43842274e-02f,
  -2.27331221e-01f, 1.35147899e-01f, 1.93655878e-01f, 2.11310640e-01f, -1.72621250e-01f, 1.98356211e-01f, 7.43216127e-02f, 1.64412141e-01f, 1.15535697e-02f, 2.16164649e-01f,
  1.61232322e-01f, -2.99757700e-02f, -8.28814358e-02f, -2.76938438e-01f, -1.22033268e-01f, -2.09967062e-01f, 3.19050699e-01f, -1.26886666e-01f, 1.11061893e-01f, 1.68603361e-02f,
  1.57806516e-01f, 1.28785655e-01f, -1.15534805e-01f, 1.79195866e-01f, 3.24561030e-01f, 2.87484646e-01f, -4.43821587e-02f, 3.68873894e-01f, 3.36845517e-01f, 2.91247427e-01f,
  4.52014506e-02f, 3.46272103e-02f, -2.67840624e-01f, 2.26519838e-01f, 1.50882825e-01f, 1.36770755e-02f, -5.12290671e-02f, 4.83898759e-01f, 1.98169187e-01f, 1.77801520e-01f,
  -2.61058301e-01f, 1.36992723e-01f, 1.91737995e-01f, -7.01696798e-02f, 1.42895043e-01f, 8.88504907e-02f, -4.30468619e-01f, 7.91572407e-02f, 6.82462156e-02f, 1.83940213e-02f,
  2.17551321e-01f, -1.16740115e-01f, 1.06935441e-01f, 1.51195765e-01f, 2.04554513e-01f, -2.62693048e-01f, -1.77085623e-01f, 7.44030327e-02f, 2.58269310e-01f, 4.38137688e-02f,
  -4.09573078e-01f, 1.93970427e-01f, 3.61402154e-01f, 1.24835186e-01f, 3.09480697e-01f, 2.85128623e-01f, -4.77781938e-03f, -1.75641939e-01f, 2.51147807e-01f, -4.30646539e-02f,
  1.99940532e-01f, -1.77040994e-01f, 1.20202765e-01f, 5.05196974e-02f, -4.86715659e-02f, -4.54266928e-03f, 2.96638161e-01f, 4.29353267e-01f, 4.76939410e-01f, 1.43662155e-01f,
  -1.68676659e-01f, 2.26871163e-01f, -3.61124933e-01f, 2.44153246e-01f, 2.10250407e-01f, -7.23200142e-02f, -7.06322910e-03f, 5.19864820e-02f, -2.01746255e-01f, -1.10856779e-01f,
  1.97888643e-01f, 1.10929543e-02f, 2.32266530e-01f, -9.64939445e-02f, -1.38644904e-01f, 1.31105781e-01f, 2.46397763e-01f, -2.79455513e-01f, -2.46464252e-01f, 4.48695540e-01f,
  -2.85841580e-02f, -3.11335117e-01f, 1.14476368e-01f, -5.87532930e-02f, 3.24414492e-01f, 1.14193320e-01f, -2.23535653e-02f, 2.09777579e-01f, 3.40634733e-01f, 1.78973928e-01f,
  3.48920673e-01f, -1.91415697e-01f, 8.41895342e-02f, 2.91746169e-01f, -2.84255892e-01f, -1.21256761e-01f, 1.12856500e-01f, -2.22771037e-02f, -1.80277199e-01f, -9.86000337e-03f,
  2.36396417e-02f, 5.86356036e-02f, 1.06482431e-01f, 4.86320211e-03f, 9.10257176e-02f, -1.89584449e-01f, -1.23277880e-01f, 3.24159771e-01f, 2.73484766e-01f, -3.03655595e-01f,
  2.25157320e-01f, 4.81452912e-01f, 1.01399496e-02f, -1.60503179e-01f, 1.39398679e-01f, -1.39876023e-01f, 2.10447311e-01f, 1.75673813e-01f, 8.47344249e-02f, 9.04243663e-02f,
  5.01729511e-02f, -1.87038958e-01f, 1.78066462e-01f, -3.55744898e-01f, 1.37424633e-01f, 1.47131830e-02f, 1.89336568e-01f, -2.33387083e-01f, -2.84094870e-01f, -1.59031555e-01f,
  -4.60833535e-02f, 1.19725600e-01f, 4.53652181e-02f, 1.45805791e-01f, 1.67417899e-01f, 3.41250271e-01f, 1.77882731e-01f, 1.99046269e-01f, 1.77785695e-01f, 3.91986638e-01f,
  6.25606924e-02f, -1.91185936e-01f, 3.06859583e-01f, 2.35475883e-01f, -3.35232377e-01f, -4.30105850e-02f, 3.69767308e-01f, -1.31681740e-01f, 7.92820565e-03f, 3.28324199e-01f,
  -1.14546940e-01f, -5.69758005e-02f, 1.15152486e-01f, -1.88272402e-01f, 2.05884814e-01f, -2.10226208e-01f, -2.05533370e-01f, 2.97308773e-01f, 2.80644834e-01f, -5.53797968e-02f,
  7.99490586e-02f, 8.88567418e-02f, -1.00734338e-01f, 1.10344872e-01f, -5.76104969e-03f, 9.03783366e-02f, 2.48937443e-01f, -1.15428835e-01f, -4.22892757e-02f, 1.97362110e-01f,
  1.43274203e-01f, 2.73793302e-02f, -4.75557111e-02f, -2.45473564e-01f, 4.25264537e-01f, 3.43686752e-02f, 1.91682398e-01f, -9.32725668e-02f, -3.68812978e-01f, -2.95655336e-03f,
  3.36712867e-01f, 1.14199840e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  5.51818870e-02f, -5.96638992e-02f, 5.92266992e-02f, -6.57306647e-14f, 5.99293001e-02f, 9.89652425e-02f, 6.41810447e-02f, 3.17215244e-03f, 1.17718540e-01f, 3.92111465e-02f,
  -1.09323889e-01f, -4.61514154e-03f, 6.55150041e-02f, 2.69297231e-02f, 8.98007676e-02f, -3.83317657e-02f, 2.05457024e-02f, -4.33932096e-02f, 2.08599389e-01f, 1.45966589e-01f,
  1.49483025e-01f, -2.77848523e-02f, 1.58444971e-01f, 2.07305849e-02f, -1.51017616e-02f, 1.07999556e-01f
};

// L3_fan_Wp (Shape: 3 x 32)
const int L3_fan_Wp_rows = 3;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  1.96914747e-02f, 6.91115260e-02f, 1.48861200e-01f, 4.28530853e-03f, -1.23860873e-01f, 2.23794878e-02f, 9.36121047e-02f, -2.23846942e-01f, -1.00784816e-01f, 1.15385959e-08f,
  -5.44726998e-02f, -2.32949823e-01f, -1.99435607e-01f, -2.14813769e-01f, -5.98574169e-02f, 9.20177554e-04f, -1.98832359e-02f, -1.68056488e-01f, -1.81681052e-01f, -1.70138195e-01f,
  -6.98486567e-02f, -1.77670106e-01f, -1.23948336e-01f, 2.94598043e-02f, -5.17726988e-02f, 1.57916155e-02f, -1.48393720e-01f, -7.36973882e-02f, -2.90626973e-01f, -7.18587339e-02f,
  1.60333753e-01f, 1.23410061e-01f, -6.30317181e-02f, -8.95656347e-02f, -5.95913045e-02f, -9.23666079e-03f, -5.57754450e-02f, 3.09334733e-02f, -7.78115690e-02f, 9.95186493e-02f,
  2.26737663e-01f, 1.24364533e-07f, 1.50057450e-02f, 1.65532142e-01f, 4.72476259e-02f, -1.43017694e-01f, -3.87580432e-02f, -3.95278148e-02f, 1.98685694e-02f, -1.13141023e-01f,
  -6.20466284e-02f, 1.99969811e-03f, 9.10922661e-02f, 2.06003916e-02f, 9.35972854e-02f, -6.26049638e-02f, -2.16545141e-03f, 1.18094206e-01f, 1.67236313e-01f, -9.26523060e-02f,
  -1.23257786e-01f, -9.31737199e-02f, 2.29155108e-01f, 1.62975252e-01f, 9.20613036e-02f, 1.62447065e-01f, -7.69599453e-02f, -1.51439697e-01f, -1.23986185e-01f, 8.58238637e-02f,
  1.59074381e-01f, 2.00449303e-02f, 2.63690501e-01f, 7.76464731e-05f, 9.30945650e-02f, 9.56560075e-02f, -9.81137902e-02f, 1.25338733e-01f, 1.15293346e-01f, 8.82042646e-02f,
  -2.28071641e-02f, 1.49332374e-01f, 1.04383506e-01f, -1.32108107e-01f, 2.68116836e-02f, 1.23966364e-02f, 1.78630948e-01f, 3.43611613e-02f, 1.71008408e-01f, 1.32776543e-01f,
  1.38462454e-01f, -4.92187478e-02f, 4.72511873e-02f, 2.20385566e-01f, 2.72182584e-01f, -1.42592425e-02f
};

// L3_fan_Wp_bar (Shape: 26 x 32)
const int L3_fan_Wp_bar_rows = 26;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  1.75029337e-01f, 8.09477828e-03f, 3.99990231e-02f, 3.12130451e-01f, 9.62113291e-02f, -4.12404612e-02f, -1.91341445e-01f, 3.25696617e-01f, 3.10370505e-01f, 1.17384609e-07f,
  -9.11263227e-02f, 3.58690247e-02f, -2.32601096e-03f, -2.86152631e-01f, -1.26694188e-01f, 2.56160438e-01f, 1.80882484e-01f, -3.01441252e-01f, -2.99153745e-01f, 2.33142629e-01f,
  -6.34674057e-02f, 2.91927904e-01f, 2.91397482e-01f, 1.35352761e-01f, 1.05819575e-01f, 2.00232342e-01f, 1.81890666e-01f, -5.64800762e-02f, 2.05587924e-01f, 3.35795492e-01f,
  1.15062252e-01f, 2.22450364e-02f, 1.27582774e-01f, 6.22025952e-02f, -1.22733727e-01f, 2.80897319e-01f, -4.14803624e-02f, 7.89196566e-02f, 3.55399072e-01f, 1.50806248e-01f,
  -1.72101840e-01f, -1.58902446e-06f, -3.12985361e-01f, -4.85461682e-01f, 2.76412368e-01f, 2.84088179e-02f, -6.83832094e-02f, 3.44004601e-01f, 1.22574702e-01f, 1.96436141e-02f,
  9.98260900e-02f, 3.09315145e-01f, 2.28508398e-01f, 3.25050384e-01f, -1.27800345e-01f, 3.44396889e-01f, 1.20349359e-02f, 7.65671954e-02f, -4.21579890e-02f, 7.51857162e-02f,
  1.65004492e-01f, 1.47269946e-02f, -2.85990477e-01f, 3.09887588e-01f, -1.11520760e-01f, 3.63668054e-02f, 2.18585897e-02f, 4.02340025e-01f, -2.16478501e-02f, 2.10131168e-01f,
  2.51085073e-01f, 1.80769637e-01f, 9.69813392e-02f, -1.31355989e-07f, -2.31236726e-01f, -2.20469549e-01f, -4.82922271e-02f, -1.23069815e-01f, -2.64530778e-01f, 1.26702651e-01f,
  1.74739942e-01f, -3.75827253e-02f, -4.86495942e-02f, 2.30982937e-02f, 1.24161795e-01f, -8.01577792e-02f, -1.45881131e-01f, 2.32772022e-01f, 2.30990827e-01f, -3.02024540e-02f,
  9.46565270e-02f, -1.51655108e-01f, -9.54579711e-02f, -6.03864491e-02f, 2.18544602e-01f, 4.12053108e-01f, -4.51989435e-02f, -8.34592711e-03f, -1.45956367e-01f, 2.24519700e-01f,
  3.07763517e-01f, 3.76527645e-02f, 3.18867356e-01f, -2.63209820e-01f, -3.85946959e-01f, 2.50460985e-08f, 2.13096708e-01f, 3.57363862e-03f, 1.00168422e-01f, 1.31694868e-01f,
  -1.68556683e-02f, 1.56626672e-01f, 4.97643948e-01f, 2.75167942e-01f, -5.62338233e-02f, 3.29025537e-01f, 7.03861341e-02f, 1.24419399e-01f, 8.55219960e-02f, -6.67679906e-02f,
  -1.14038229e-01f, 4.42402624e-02f, 2.93376297e-01f, -7.06465915e-02f, -1.68955922e-01f, -3.94735843e-01f, -1.40634641e-01f, -4.78691496e-02f, -1.55701544e-02f, 1.96559653e-01f,
  1.33820642e-02f, 4.92471121e-02f, -3.65126103e-01f, -1.47619531e-01f, 3.05680245e-01f, 3.33926171e-01f, 2.62104750e-01f, 5.14719289e-09f, -1.94741488e-01f, -1.44928277e-01f,
  -2.43970938e-02f, 1.28900275e-01f, 3.38976592e-01f, 1.34972647e-01f, -2.36671016e-01f, 9.36086401e-02f, 2.90294975e-01f, 4.71349120e-01f, 2.65090764e-01f, 3.91424954e-01f,
  -1.43148020e-01f, 3.60740304e-01f, 2.75042981e-01f, -1.33321017e-01f, -2.46170327e-01f, 3.00258636e-01f, 4.66390103e-01f, 2.57180601e-01f, 5.13807833e-02f, 4.28361982e-01f,
  -1.08203514e-36f, -9.66610712e-36f, -3.02893842e-23f, 7.06742063e-23f, 6.38493767e-17f, 7.97001999e-25f, -8.25337629e-05f, -8.77729349e-07f, -1.46451617e-09f, 5.11150240e-40f,
  6.26708317e-40f, -2.48474235e-15f, -4.96684734e-05f, -6.24204986e-05f, -1.73402970e-09f, -1.94051427e-05f, 1.82268941e-05f, -5.78160098e-06f, -7.33874629e-07f, -4.07658481e-05f,
  -2.64777336e-04f, -3.36852681e-05f, 4.94256185e-40f, -1.16088713e-05f, -2.32385469e-06f, -3.05933963e-06f, -2.30293939e-04f, -9.56991971e-06f, -2.33038421e-07f, -8.15558963e-08f,
  -3.28355395e-06f, -8.98550024e-06f, 1.19021095e-01f, 2.17292517e-01f, 1.41715154e-01f, 1.76915284e-02f, -6.63099363e-02f, -4.86954413e-02f, -1.64912209e-01f, 3.76918256e-01f,
  3.39270800e-01f, -4.69543352e-07f, -1.43659130e-01f, 2.85279565e-02f, -1.69265583e-01f, -6.07893057e-02f, 8.95313099e-02f, 9.43890512e-02f, -5.70994206e-02f, -1.96662977e-01f,
  -1.51444793e-01f, 1.94069788e-01f, 1.66151628e-01f, 3.30523223e-01f, 1.01128437e-01f, -5.63595369e-02f, 7.18557984e-02f, 2.57261842e-01f, 5.83660835e-03f, -2.58674324e-01f,
  3.05044144e-01f, 1.53361633e-01f, -2.12621298e-02f, 6.73953518e-02f, -1.87982302e-02f, 1.75690562e-01f, -1.37265921e-02f, -8.40547979e-02f, -6.57507393e-04f, 1.20201103e-01f,
  1.50856584e-01f, 2.74995603e-02f, 1.78648196e-02f, -6.21325285e-08f, 7.57802576e-02f, -2.77382433e-02f, 2.56635427e-01f, 3.03042471e-01f, 7.59626478e-02f, 1.29038095e-01f,
  1.72902733e-01f, 1.71249747e-01f, 2.05494836e-01f, 3.87510769e-02f, 7.76659474e-02f, -1.11721516e-01f, 6.20808033e-03f, 7.18578994e-02f, 2.85336167e-01f, -4.85470518e-02f,
  2.90891707e-01f, 9.79909226e-02f, -2.05637798e-01f, -2.28504330e-01f, 1.03248373e-01f, -5.77252954e-02f, 3.45189050e-02f, 8.39239657e-02f, -8.72822627e-02f, -6.85115978e-02f,
  2.17100516e-01f, -3.52742493e-01f, 2.26340681e-01f, -4.61402982e-01f, -1.46254852e-01f, 1.76896401e-06f, 5.20741999e-01f, 3.85598540e-01f, -9.55401585e-02f, -2.11423337e-01f,
  9.59386528e-02f, 2.06504948e-02f, 3.14444125e-01f, 1.39762670e-01f, -2.16702014e-01f, 3.44850063e-01f, 1.10440560e-01f, 2.06485450e-01f, 1.29526317e-01f, 8.28809515e-02f,
  -4.02418584e-01f, -2.25135103e-01f, 8.57928619e-02f, -2.78980643e-01f, 1.52801350e-01f, 4.80683483e-02f, 8.54613930e-02f, 1.29936486e-01f, 2.40179613e-01f, -6.09746538e-02f,
  1.57956630e-01f, 5.55388853e-02f, -3.40453684e-02f, 1.77402154e-01f, -2.06757471e-01f, 2.43238762e-01f, 3.90983552e-01f, 1.41768140e-07f, 1.29396662e-01f, 2.93421686e-01f,
  -6.01221211e-02f, -1.34515762e-01f, -1.97265297e-01f, 2.24554479e-01f, -4.51220162e-02f, -1.94035053e-01f, 3.42949815e-02f, -3.49015146e-01f, 2.67185383e-02f, 1.44058645e-01f,
  4.47846651e-01f, 1.36172296e-02f, 2.55293578e-01f, 3.68904412e-01f, 3.31324905e-01f, -9.79616717e-02f, 9.49250013e-02f, 3.11532140e-01f, 4.02892798e-01f, -5.53605035e-02f,
  5.19004725e-02f, 1.09482326e-01f, -4.87164333e-02f, 1.90998822e-01f, 6.05496578e-02f, 3.58894914e-01f, 2.36098737e-01f, 3.95640254e-01f, 8.17444101e-02f, -5.64600305e-06f,
  -1.09012835e-01f, -1.85657367e-01f, 1.80103362e-01f, -7.32433423e-02f, -3.71169508e-01f, 3.08758706e-01f, 3.17246884e-01f, 1.43845662e-01f, 1.26406893e-01f, -2.19760165e-01f,
  2.44451061e-01f, -1.01245545e-01f, 2.13809106e-02f, 1.48410313e-02f, 2.00102121e-01f, 2.15533599e-01f, 2.88180143e-01f, 1.22226506e-01f, -3.74260366e-01f, -1.78170338e-01f,
  5.43507189e-02f, 1.42476186e-01f, 1.26375288e-01f, 7.98693672e-02f, 1.48686096e-01f, 7.66714215e-02f, -4.37667631e-02f, -1.26739979e-01f, 1.71336651e-01f, -1.08235069e-01f,
  3.10807556e-01f, 9.45053102e-07f, 4.74051870e-02f, 1.99692205e-01f, -1.81727722e-01f, -3.08909208e-01f, 1.68491304e-02f, -1.79872036e-01f, 6.11195946e-03f, -2.11637139e-01f,
  -2.31688619e-01f, 9.89056304e-02f, -1.24447040e-01f, 3.69586825e-01f, 1.11588091e-01f, 4.41897176e-02f, -1.83513477e-01f, -1.74432632e-03f, -6.03508949e-02f, -1.22097813e-01f,
  1.83623523e-01f, 2.89021671e-01f, 2.37599343e-01f, 8.27758238e-02f, 1.12685814e-01f, 8.80607292e-02f, -8.69759023e-02f, 2.56830186e-01f, 6.63705543e-02f, -1.02399692e-01f,
  -4.66590226e-02f, 5.26531525e-02f, 1.95632860e-01f, 2.61802575e-06f, 1.26260251e-01f, 2.30116546e-01f, -2.95347214e-01f, -3.44102651e-01f, -2.33748600e-01f, 1.26864344e-01f,
  -5.52592762e-02f, -3.65870409e-02f, -1.26881137e-01f, 4.05003242e-02f, -4.82150242e-02f, -1.61173582e-01f, 2.55864799e-01f, -1.80711642e-01f, 1.80970207e-01f, 1.86953768e-01f,
  1.48688197e-01f, -2.29746386e-01f, -1.88739330e-01f, 1.98663190e-01f, 3.61613125e-01f, 2.05533683e-01f, -7.26679638e-02f, 1.98430672e-01f, 4.68700081e-02f, -6.53290898e-02f,
  -6.49669617e-02f, -3.73571724e-01f, 1.11325912e-01f, 9.63872597e-02f, 3.74485612e-01f, 5.68795713e-06f, 3.34165066e-01f, 3.90004367e-01f, -2.83162236e-01f, -1.52733654e-01f,
  2.25243550e-02f, -1.47215361e-02f, -7.68972039e-02f, 1.03315309e-01f, -9.79738981e-02f, 5.77419810e-03f, 1.39242768e-01f, 1.56010613e-01f, 1.56276956e-01f, 1.10669434e-01f,
  -1.82239667e-01f, -1.29007548e-01f, -4.06361185e-02f, -1.64800629e-01f, 2.27145001e-01f, 2.86586881e-01f, 2.11970195e-01f, 1.29124179e-01f, 3.62422806e-03f, 3.95300686e-02f,
  6.78505972e-02f, 2.28133574e-01f, 1.71685785e-01f, 3.43086608e-02f, 1.57764852e-01f, 1.20099083e-01f, -1.05122156e-01f, -1.93676078e-06f, -1.92048103e-01f, -1.27440378e-01f,
  1.98179603e-01f, 1.33212388e-01f, -1.43068835e-01f, 1.18820965e-01f, -3.21335569e-02f, -7.13752508e-02f, -1.14337213e-01f, -3.44953723e-02f, 4.14276347e-02f, 4.75552119e-02f,
  6.41754270e-02f, 2.23745443e-02f, -1.30526856e-01f, 2.64830530e-01f, 1.09835863e-01f, -7.63087114e-03f, -2.35923491e-02f, -1.71105802e-01f, 1.03982445e-02f, 6.35166019e-02f,
  3.56254028e-03f, -1.10899404e-01f, 9.47428867e-02f, -6.88970760e-02f, -1.42847002e-01f, 4.67126742e-02f, -3.12242168e-03f, 1.72196358e-01f, 9.70776454e-02f, 1.48578572e-31f,
  -2.06698656e-01f, -1.03282228e-01f, -1.09327912e-01f, 4.43626940e-02f, 8.66768062e-02f, -1.29097670e-01f, -3.49340200e-01f, 1.15759941e-02f, 1.64669409e-01f, -7.66125843e-02f,
  8.45106691e-02f, -5.42039238e-02f, -1.68094203e-01f, 5.01739010e-02f, 2.82778680e-01f, -6.77612871e-02f, -1.47287980e-01f, 2.16701671e-01f, -4.56387773e-02f, 7.27257952e-02f,
  1.32407144e-01f, 1.31232798e-01f, 3.04141380e-02f, 5.38968034e-02f, 1.69986300e-02f, 1.28266752e-01f, 1.10166460e-01f, 8.01489428e-02f, 5.23122214e-02f, 1.80649549e-01f,
  1.47579834e-01f, 8.15764900e-10f, 1.12086929e-01f, 1.93477035e-01f, 1.74622014e-01f, -1.20906800e-01f, -1.60783872e-01f, 1.84476405e-01f, 1.80968076e-01f, 8.23099259e-03f,
  -1.45431146e-01f, -1.07768729e-01f, 5.25011010e-02f, 2.10174862e-02f, 3.19929957e-01f, -1.39567643e-01f, 1.78786635e-01f, 3.58495712e-01f, 3.30281675e-01f, -1.55307665e-01f,
  -6.17792532e-02f, 2.22006422e-02f, 2.19292194e-01f, 5.37592620e-02f, -1.06169418e-01f, -1.33236691e-01f, 1.17502555e-01f, 1.53457802e-02f, -9.47301015e-02f, 1.74485948e-02f,
  2.96530575e-01f, -5.57562299e-02f, -1.30230919e-01f, 7.22165936e-08f, 7.09979460e-02f, -1.75237462e-01f, -3.98001447e-03f, 7.52889961e-02f, 1.35245204e-01f, -2.79588014e-01f,
  -1.00985542e-02f, 3.18410456e-01f, 6.43704906e-02f, 1.75907940e-01f, 1.12113632e-01f, -4.53827009e-02f, -2.22120285e-01f, -9.72614344e-03f, 1.92282185e-01f, -1.28799722e-01f,
  -1.11537822e-01f, 2.33871073e-01f, -2.44462296e-01f, -1.82936147e-01f, 1.85958400e-01f, 3.16886574e-01f, 9.81068313e-02f, 7.82572571e-03f, 1.85968615e-02f, 1.97560593e-01f,
  3.18176597e-01f, 1.62140027e-01f, -5.59443608e-02f, -2.28903696e-01f, -3.17508169e-02f, -9.01758490e-09f, 2.49909118e-01f, 1.62485883e-01f, 1.11031234e-01f, 2.14274243e-01f,
  -6.02178983e-02f, 9.62659270e-02f, 3.50936830e-01f, 2.15179816e-01f, 1.33796439e-01f, 5.92280366e-02f, 6.32147118e-03f, -3.63057144e-02f, 2.82765657e-01f, -1.00182788e-02f,
  -2.20774874e-01f, 6.24483451e-02f, 2.18957558e-01f, 6.68842196e-02f, -2.05667347e-01f, -2.88013786e-01f, -2.01629680e-02f, -1.44634023e-01f, 8.37109834e-02f, 1.91782162e-01f,
  -9.84373689e-02f, 1.88376218e-01f, 5.63140400e-02f, -1.19462453e-01f, 3.52284163e-01f, 1.70504004e-02f, 2.00529113e-01f, -9.76433157e-08f, 6.07716069e-02f, -1.63139969e-01f,
  -2.32886821e-01f, -1.92029804e-01f, 1.06764600e-01f, -4.26320359e-02f, 2.94495314e-01f, 1.67421192e-01f, 1.62269901e-02f, 2.05385759e-01f, 9.21216533e-02f, 1.96711883e-01f,
  -1.84958071e-01f, 1.41147122e-01f, -1.28308624e-01f, -2.91256487e-01f, -6.47034496e-02f, -1.31630316e-01f, 3.69108409e-01f, 3.82741004e-01f, 8.88162479e-02f, 2.05939993e-01f,
  3.45455073e-02f, -1.28268763e-01f, 2.05186367e-01f, -3.97816747e-01f, -3.39393437e-01f, -1.67631567e-01f, 1.65918157e-01f, -2.57729560e-01f, -9.04515088e-02f, 5.75074364e-06f,
  2.27342427e-01f, 2.20186934e-02f, -1.78465962e-01f, 2.69945860e-01f, 3.72316211e-01f, -3.55411738e-01f, -3.58369857e-01f, 4.15453970e-01f, 4.33350682e-01f, 1.36038393e-01f,
  2.76535094e-01f, 4.08407748e-02f, -2.59048432e-01f, 1.72428325e-01f, 3.05321366e-01f, -2.33262807e-01f, 6.45526731e-03f, 4.36591208e-01f, -8.54692385e-02f, 1.18121326e-01f,
  2.44373962e-01f, 2.26092771e-01f, -4.25727516e-02f, 1.63147412e-02f, -9.72562060e-02f, 4.00742330e-02f, 8.74785648e-04f, -5.03254384e-02f, 1.35805979e-01f, -2.20993906e-01f,
  -2.16444731e-01f, -1.15426023e-10f, -1.17673919e-01f, -2.61686653e-01f, 2.13471323e-01f, 2.60191172e-01f, 2.46389255e-01f, 7.18154944e-03f, 2.27411166e-01f, 1.42310619e-01f,
  1.03726827e-01f, 3.73266667e-01f, 2.19553020e-02f, 2.37120733e-01f, -2.30171308e-01f, 2.74747908e-01f, -1.53426796e-01f, -2.01535419e-01f, -6.76833987e-02f, 1.49744108e-01f,
  1.10122524e-01f, -5.38653769e-02f, -3.30958188e-01f, 1.14346668e-01f, 1.21505763e-02f, 5.08467592e-02f, 3.01908672e-01f, -5.24556458e-01f, -2.90031105e-01f, -1.12612378e-02f,
  -1.12608679e-01f, -5.57582267e-02f, 1.20096400e-01f, -8.73629801e-07f, 2.92584419e-01f, 3.57080579e-01f, 1.53554186e-01f, 3.92469801e-02f, 1.39825821e-01f, -1.22375697e-01f,
  -3.30149263e-01f, 2.51307666e-01f, 2.55573809e-01f, -2.03798756e-01f, 2.40404069e-01f, 6.14886992e-02f, 1.98742673e-01f, -3.00523162e-01f, 2.51320779e-01f, -8.35322216e-02f,
  1.83074608e-01f, 2.68198311e-01f, 7.02082086e-03f, 4.49590236e-02f, 2.93058842e-01f, -2.39437625e-01f, 7.72450715e-02f, 4.31104526e-02f, 1.67199954e-01f, -3.92419063e-02f,
  -5.86633272e-02f, 2.34981865e-01f, -5.82449418e-03f, 5.70715293e-02f, -1.34811953e-01f, 8.81783535e-09f, 1.99224427e-01f, -7.04650655e-02f, -9.70832724e-03f, 2.61652768e-01f,
  -6.37373701e-02f, -1.04059912e-01f, -1.51477814e-01f, 1.48555100e-01f, 2.75792986e-01f, -2.85225958e-01f, 2.91036576e-01f, -3.96925732e-02f, -3.70191410e-03f, -1.07466705e-01f,
  3.84356230e-01f, -9.78124589e-02f, 2.65340149e-01f, 1.35583445e-01f, -2.45689765e-01f, -8.79286416e-03f, 3.37192893e-01f, 9.13448259e-02f, 2.91031599e-02f, 2.56482929e-01f,
  -4.14262339e-02f, 3.35799903e-03f, 2.17972502e-01f, 1.66270748e-01f, -7.52277672e-02f, 7.80162513e-02f, -1.34424446e-02f, -9.60027648e-08f, 1.12999111e-01f, 1.38502186e-02f,
  3.39901149e-01f, 1.73117638e-01f, -2.86586046e-01f, 3.70577455e-01f, 2.38191888e-01f, -7.38174096e-02f, -1.61060199e-01f, -1.37182787e-01f, 2.29156375e-01f, 9.73711442e-03f,
  3.47670704e-01f, -1.83309302e-01f, 2.61753350e-02f, 3.72084826e-01f, 1.61858380e-01f, -1.36631548e-01f, 1.57314092e-01f, 9.34156850e-02f, 7.42317066e-02f, -7.22431019e-02f,
  -1.60972670e-01f, -1.39224455e-01f, 3.59064527e-02f, 4.51840401e-01f, 1.13024369e-01f, 3.20427120e-01f, 3.39055389e-01f, 4.06128883e-01f, 3.09683122e-02f, 8.70424685e-07f,
  -2.61111498e-01f, -2.54064649e-01f, -2.55056713e-02f, -1.89632505e-01f, -2.64381111e-01f, 2.95308232e-01f, 2.68211305e-01f, -6.10992536e-02f, -5.87476306e-02f, -2.51382533e-02f,
  3.92793939e-02f, 4.47376780e-02f, -2.85110809e-02f, 1.94021791e-01f, 2.73822606e-01f, 4.03344333e-02f, 1.67817533e-01f, -1.55280232e-01f, -2.61245370e-01f, -9.39637795e-02f,
  1.95470572e-01f, 3.50652307e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 26)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 26;
const float L3_fan_Bp_bar_data[] = {
  1.77227166e-02f, 9.90759116e-03f, -7.77326897e-02f, 1.46732017e-01f, 1.26525581e-01f, -1.80970050e-15f, -1.54109104e-02f, 3.41874287e-02f, -1.32783325e-02f, 6.42152429e-02f,
  -1.96472164e-02f, -7.13515654e-02f, 6.51262142e-03f, 2.22602431e-02f, 1.10512516e-02f, -1.07307266e-02f, 4.02955785e-02f, -3.51028889e-02f, -4.76981997e-02f, -8.59480947e-02f,
  3.76266353e-02f, 7.21363910e-03f, 3.25812846e-02f, 5.17943278e-02f, 1.94971845e-01f, -3.30844894e-02f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -1.83028176e-01f, 4.07644436e-02f, 6.88040331e-02f, -2.44093612e-01f, -1.03368148e-01f, -1.95984334e-01f, 3.57168801e-02f, 1.74060494e-01f, -1.98526382e-01f, 3.23503107e-01f,
  -3.85904759e-01f, 2.74663488e-03f, -1.77355006e-01f, -4.01566457e-03f, 3.82706970e-02f, -3.73273678e-02f, 1.26672862e-02f, -1.69719487e-01f, -3.17912132e-01f, -5.85101306e-01f,
  1.92426533e-01f, -1.17547195e-02f, 9.61732119e-02f, -2.03506917e-01f, 2.34658882e-01f, -4.58486915e-01f, -4.29677010e-01f, 3.42261344e-02f, -6.13391884e-02f, -2.58879423e-01f,
  3.15907210e-01f, 8.96350518e-02f, -2.23371461e-01f, -5.22932261e-02f, -1.09331816e-01f, -2.15039641e-01f, -6.43883869e-02f, -1.60254650e-02f, -3.13779116e-01f, 1.59709841e-01f,
  3.22115491e-03f, 2.48834059e-01f, 1.11541964e-01f, -2.28042318e-03f, -2.23409966e-01f, 2.76153117e-01f, 6.97139427e-02f, -3.83322448e-01f, 1.61049679e-01f, -4.22093153e-01f,
  -2.78558165e-01f, -1.91097707e-01f, -2.77428944e-02f, -2.62051880e-01f, -1.53764278e-01f, 4.82810885e-02f, 2.38241985e-01f, 7.28965318e-03f, 2.36519706e-02f, 1.70346037e-01f,
  -1.39016375e-01f, 1.20494246e-01f, -8.40977654e-02f, -6.39357194e-02f, -9.85303298e-02f, -1.41984984e-01f, 7.88721517e-02f, -7.74090961e-02f, 4.68060300e-02f, -2.92468816e-01f,
  -4.88858402e-01f, -3.40558849e-02f, -4.39830571e-01f, -1.29449546e-01f, 2.50115186e-01f, -1.47397921e-03f, -3.66958827e-01f, 1.72616407e-01f, -3.58230174e-01f, -3.83891970e-01f,
  -1.63432747e-01f, -4.28006262e-01f, -9.27427709e-02f, -2.63827175e-01f, 5.07377312e-02f, 2.73269534e-01f, -4.18382674e-01f, 2.99693018e-01f, -5.97442361e-03f, -2.79123545e-01f,
  3.65598679e-01f, 1.41719639e-01f, 2.54061997e-01f, 1.10560670e-01f, -3.37430418e-01f, -5.44318378e-01f, 1.84890702e-02f, -4.08709887e-03f, -2.03473195e-01f, -1.06063969e-01f,
  1.80545151e-01f, -3.57799232e-02f, 2.08223447e-01f, -6.16747439e-01f, -3.55516970e-01f, -1.08724311e-01f, -6.99198246e-01f, -4.25109902e-04f, 1.90016050e-02f, -8.78245849e-03f,
  2.73539759e-02f, 3.26430798e-01f, -6.97649494e-02f, 9.65033174e-02f, 1.38941392e-01f, 3.39288302e-02f, -1.23057589e-01f, -4.10985276e-02f, 1.39922202e-01f, -3.49077493e-01f,
  1.72514424e-01f, -4.58005428e-01f, -5.06116033e-01f, -1.59790233e-01f, 8.37827846e-02f, -1.10375211e-02f, 8.95571262e-02f, -1.80259988e-01f, 9.09479707e-02f, 1.54999271e-01f,
  -1.25328928e-01f, 7.14310482e-02f, 3.15996706e-01f, 2.57626623e-01f, 1.38881907e-01f, -1.50925040e-01f, 1.77962780e-01f, -2.02699512e-01f, 1.12411253e-01f, 2.57604697e-04f,
  8.55448171e-02f, 9.07075778e-02f, -3.53621095e-01f, 1.69808537e-01f, 2.60248005e-01f, -1.76691577e-01f, 2.55717099e-01f, 5.56160994e-02f, -3.53290257e-03f, -1.96889490e-01f,
  5.90320118e-02f, -4.09962296e-01f, -1.15206994e-01f, -1.90401167e-01f, -3.83832037e-01f, -3.55427146e-01f, -1.16711490e-01f, 1.06149904e-01f, 2.12571789e-02f, 1.57278270e-01f,
  2.02637017e-01f, -9.82205272e-02f, -3.66421752e-02f, 3.77812125e-02f, -1.06503256e-01f, -3.41480941e-01f, 1.51366398e-01f, 2.93820590e-01f, 9.36230123e-02f, -1.19392499e-02f,
  1.69589758e-01f, 6.81035221e-03f, 2.72306204e-01f, 1.69245957e-03f, -6.48832461e-03f, -1.41012266e-01f, -6.18672483e-02f, 1.70171872e-01f, -3.67232054e-01f, -1.20739385e-01f,
  1.38770625e-01f, -1.72619835e-01f, -6.03793189e-02f, -1.69281960e-01f, -1.64339170e-01f, 1.84350014e-01f, -3.31072122e-01f, 2.26717927e-02f, -1.85838804e-01f, -2.84215569e-01f,
  1.46884188e-01f, 9.19878557e-02f, 1.48175240e-01f, -8.99401456e-02f, 1.04701772e-01f, 1.89789206e-01f, -9.51776952e-02f, 2.98029244e-01f, -1.23863451e-01f, 1.32518947e-01f,
  -9.80177671e-02f, -5.28868735e-01f, 3.45734835e-01f, -6.96541648e-03f, -1.20986430e-02f, 2.43270081e-02f, -1.34539381e-01f, -9.26127508e-02f, -2.48857155e-01f, 9.79000032e-02f,
  -2.56053001e-01f, 2.53477514e-01f, -2.64893174e-01f, 3.52652669e-01f, -2.61778533e-01f, 2.05605831e-02f, -2.91914761e-01f, 1.27657726e-01f, 1.76445246e-01f, -3.32400501e-02f,
  2.15388402e-01f, -1.56893339e-02f, -2.44585529e-01f, -1.58828557e-01f, -2.59023190e-01f, 1.18704088e-01f, -1.89423431e-02f, -1.87407192e-02f, 1.57451153e-01f, 1.09286986e-01f,
  -1.53644666e-01f, -1.40693083e-01f, 2.57212073e-01f, 2.30987608e-01f, -2.78705031e-01f, -1.24224948e-06f, -3.28251302e-01f, 4.27652225e-02f, 4.31299299e-01f, -1.66595817e-01f,
  7.69317746e-02f, 1.94163933e-01f, 3.28201979e-01f, 2.35682368e-01f, -1.22442037e-01f, -2.42698222e-01f, 6.64548650e-02f, 2.16288120e-01f, -1.02994539e-01f, 3.17950755e-01f,
  -1.07289091e-01f, -2.19625369e-01f, -1.63321868e-01f, 7.56707741e-03f, -7.67815933e-02f, 2.55249858e-01f, 2.33720485e-02f, -8.58152509e-02f, -1.16456546e-01f, 4.59435806e-02f,
  -6.80661500e-02f, -2.24937811e-01f, 5.59635181e-03f, 2.64426261e-01f, -1.92585617e-01f, -5.39106317e-02f, 2.47608244e-01f, 1.04701488e-04f, -1.03689037e-01f, -2.54861921e-01f,
  4.01824981e-01f, -4.21652108e-01f, -4.24434841e-01f, 1.16797507e-01f, -1.49282992e-01f, 1.82309538e-01f, -2.77175516e-01f, -2.73521841e-01f, -4.50023472e-01f, -9.50941965e-02f,
  -9.33886394e-02f, 3.73898268e-01f, -1.09233626e-03f, 2.02164859e-01f, -4.07383651e-01f, -3.24977726e-01f, -3.57924521e-01f, -2.57227838e-01f, -3.06603283e-01f, 9.92577448e-02f,
  1.30520374e-01f, 1.23297088e-01f, -2.54671574e-01f, 2.11354360e-01f, -5.36438711e-02f, 1.67842239e-01f, 2.17481852e-01f, -2.77847856e-01f, 1.35727093e-01f, -4.93645726e-04f,
  -8.30179155e-02f, -2.77786683e-02f, -6.36561811e-01f, 1.32419825e-01f, 2.45727524e-01f, -1.17193326e-01f, -2.45599844e-03f, -3.08317214e-01f, -5.14206477e-02f, 2.38352239e-01f,
  -3.82403694e-02f, 1.21921755e-01f, -2.49162853e-01f, -1.17567018e-01f, 7.23625049e-02f, -1.67262807e-01f, -1.39528841e-01f, 1.26188114e-01f, -1.57692745e-01f, 2.34878123e-01f,
  1.22073896e-01f, 1.49460912e-01f, -9.15261917e-03f, -2.18845949e-01f, -5.10553718e-02f, 1.21744521e-01f, -3.42350096e-01f, -2.05724493e-01f, -4.02345121e-01f, -1.49200847e-02f,
  -3.09766889e-01f, -1.55254071e-07f, -1.60023510e-01f, 2.20394656e-01f, -1.95767060e-02f, 7.77492076e-02f, 1.96485415e-01f, -3.04183424e-01f, -1.82263747e-01f, -2.90977452e-02f,
  -1.68841615e-01f, -7.37609565e-02f, 4.18958180e-02f, -5.86142465e-02f, -3.71199176e-02f, -2.53727198e-01f, 1.89873815e-01f, -2.46396005e-01f, 3.59806597e-01f, 3.77759188e-01f,
  2.20512331e-01f, -3.74767095e-01f, 6.81973472e-02f, 7.37999678e-02f, 3.64895677e-03f, -7.13731796e-02f, 1.58324346e-01f, 2.94483274e-01f, 1.41497806e-01f, -3.72508407e-01f,
  -2.04100877e-01f, -3.04706335e-01f, 1.76650941e-01f, -2.59128545e-04f, 1.58263281e-01f, -4.12403762e-01f, 1.82200104e-01f, 2.21344650e-01f, -3.36211890e-01f, 3.45336586e-01f,
  1.94021821e-01f, 2.64114976e-01f, -4.36406806e-02f, -1.01103269e-01f, -4.30209339e-02f, -2.76048183e-01f, -3.51928532e-01f, 4.92118821e-02f, -1.01476032e-02f, -2.50815511e-01f,
  -7.19016325e-03f, -2.21776709e-01f, -1.14313513e-01f, -2.11021543e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  1.24064200e-01f, -6.81409687e-02f, 1.35074213e-01f, -9.68493000e-02f, 7.31550679e-02f, -9.46237892e-03f, 3.18868421e-02f, -1.59988284e-01f, 1.33643642e-01f, -1.10456295e-01f,
  1.03576533e-01f, 7.07912669e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    