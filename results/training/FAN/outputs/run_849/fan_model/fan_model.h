/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.37703136e-01f, -5.28849103e-02f, 2.51454413e-01f, -1.11731648e-01f, 1.38055846e-01f, 3.49541247e-01f, 5.61127365e-01f, 4.45467532e-02f, -2.23739892e-01f, 1.12452760e-01f,
  -1.00283958e-01f, -2.08933845e-01f, -6.65958971e-02f, -2.23109629e-02f, 2.68202219e-02f, 1.50791332e-01f, 1.65608332e-01f, 8.21573138e-02f, 1.03252999e-01f, 1.55756280e-01f,
  5.60141616e-02f, -1.30872071e-01f, -2.28616714e-01f, -5.61767928e-02f, 1.98003952e-03f, -6.81816265e-02f, 3.61073613e-02f, -1.45070627e-01f, -3.91161144e-02f, -8.58186409e-02f,
  2.45771464e-02f, 1.61955982e-01f, -2.92387176e-02f, -1.08461075e-01f, -4.32740524e-02f, 1.05698228e-01f, 9.75427553e-02f, -7.57682994e-02f, -3.43067944e-02f, -3.52840796e-02f,
  -5.64843416e-02f, -3.82621884e-02f, 2.08007991e-02f, -2.15121973e-02f, -2.98251249e-02f, 1.35652468e-01f, -1.94464196e-02f, 3.62551734e-02f, 8.50157719e-03f, 4.59080115e-02f,
  5.14998399e-02f, 5.00779189e-02f, 4.13648970e-02f, 1.07238695e-01f, 1.87399924e-01f, -2.20858795e-03f, 5.03528789e-02f, 1.02653235e-01f, 1.02006970e-02f, -9.54572484e-03f,
  7.77989998e-02f, 3.38832326e-02f, 2.23513059e-02f, -5.08088022e-02f, 2.31076535e-02f, -1.12626003e-02f, -5.37635162e-02f, -5.73778637e-02f, 2.17860769e-02f, -3.71590778e-02f,
  -3.39029320e-02f, -3.02796587e-02f, 5.21643646e-02f, 1.39453448e-02f, -2.63625607e-02f, 7.49692991e-02f, 7.27915168e-02f, -2.56961416e-02f, -7.96425715e-02f, 3.63012478e-02f,
  1.27326539e-02f, 7.70719126e-02f, -5.20675629e-02f, 4.94648553e-02f, 3.15253660e-02f, 5.25453780e-03f, -6.93236813e-02f, -4.78023253e-02f, -2.34828083e-04f, -3.93713713e-02f,
  -1.48386329e-01f, 1.04022391e-01f, -7.26505145e-02f, -3.49226184e-02f, 3.87066114e-03f, -2.20788494e-02f, -7.79461861e-02f, -5.03405221e-02f, -1.38922427e-02f, -1.58481542e-02f,
  2.53291577e-02f, 2.67165154e-02f, 2.83513274e-02f, 1.97574869e-02f, 1.85532328e-02f, -5.59253991e-02f, -8.02667812e-02f, 4.14228700e-02f, -7.31858462e-02f, -1.86184177e-03f,
  -1.67731419e-01f, -6.53508306e-02f, -2.02157442e-02f, -3.02932225e-02f, -4.93846089e-02f, 9.29556973e-03f, 3.74593725e-03f, -2.15195715e-02f, 6.20821640e-02f, -9.64398235e-02f,
  -4.14241999e-01f, -2.58150727e-01f, 1.23677418e-01f, -5.25486290e-01f, -2.13443041e-01f, 1.00076549e-01f, 5.36538893e-03f, 1.39763027e-01f, -3.59012932e-02f, -1.18998624e-01f,
  -8.20286274e-02f, 1.46042174e-02f, 3.88511345e-02f, 1.60921335e-01f, 1.15679517e-01f, 5.39102405e-02f, -1.58828676e-01f, 4.15671729e-02f, 1.11050241e-01f, -2.66965814e-02f,
  -1.91265091e-01f, -3.48437130e-01f, -1.24235541e-01f, -2.31279992e-02f, -1.86643720e-01f, 8.17385130e-03f, 4.47203740e-02f, -1.90673396e-02f, 1.08112395e-01f, -3.64904881e-01f,
  1.68153085e-02f, -2.37545799e-02f, 6.05569519e-02f, -1.37872159e-01f, -4.06895876e-02f, 1.07931875e-01f, 3.02265491e-02f, 2.47543138e-02f, 4.59112198e-04f, -4.43421653e-04f,
  -6.26591444e-02f, -4.21866328e-02f, -6.03779256e-02f, 5.57813840e-03f, -5.53488694e-02f, 5.62691391e-02f, 4.46097739e-02f, 1.17901517e-02f, 5.61823621e-02f, 1.69070408e-01f,
  -1.45689085e-01f, -8.51642415e-02f, 4.64753844e-02f, 1.29045784e-01f, 1.31304264e-01f, -6.59586862e-02f, 1.99855529e-02f, 6.27043843e-02f, 6.25904649e-02f, -1.33098930e-01f,
  -1.13440387e-01f, -1.07443165e-02f, 4.84800227e-02f, -5.41037880e-02f, -2.04624720e-02f, -2.10219081e-02f, 1.11613097e-02f, -1.92049239e-02f, 2.97246706e-02f, 1.65428724e-02f,
  3.41088586e-02f, -2.06178613e-02f, 3.19677554e-02f, 1.03255156e-02f, -1.29375383e-02f, -1.63206961e-02f, 2.37437114e-02f, 1.81044871e-03f, 1.53459102e-01f, 2.88651641e-02f,
  -2.79663764e-02f, 1.12033129e-01f, -4.00603227e-02f, 3.11458651e-02f, -6.27388507e-02f, -9.77036655e-02f, 6.85323998e-02f, 7.57974088e-02f, -5.29948343e-03f, -1.53049706e-02f,
  -2.09782347e-02f, 3.13898146e-01f, -1.48380026e-01f, 2.24284157e-02f, 1.67367794e-02f, 4.48109442e-03f, -7.13281482e-02f, 1.34304566e-02f, -7.09504783e-02f, -5.57535328e-02f,
  1.65694188e-02f, -2.45446227e-02f, -3.30703403e-03f, 7.30267819e-03f, -1.26572680e-02f, 4.30547558e-02f, -1.07646391e-01f, -7.93357342e-02f, 7.31682479e-02f, -3.28165740e-02f,
  -9.91366245e-03f, -5.99473948e-03f, -3.36369909e-02f, 5.10702878e-02f, 8.00841860e-03f, -2.74048690e-02f, 1.15564436e-01f, -1.19800800e-02f, 9.70769823e-02f, 9.51250433e-04f,
  -6.31697550e-02f, 1.83577582e-01f, -5.55195212e-02f, -5.01956902e-02f, 1.65156927e-03f, 6.09250255e-02f, -3.02835684e-02f, 9.73029286e-02f, -8.07434842e-02f, -5.51062338e-02f,
  6.16310537e-02f, 7.85932913e-02f, -1.30555453e-02f, -1.19205542e-01f, -9.78265032e-02f, -2.13644624e-01f, -1.40217066e-01f, -1.69287026e-01f, -1.18605047e-01f, -1.36285260e-01f,
  1.71320587e-02f, -1.60234123e-02f, -1.06842801e-01f, -1.10356510e-02f, -8.42063800e-02f, -1.06757455e-01f, -1.62304789e-01f, -1.15258545e-01f, 1.96361467e-02f, -1.98791638e-01f,
  -2.19895497e-01f, 1.99150592e-02f, -6.91323504e-02f, 8.05840269e-02f, 4.41100672e-02f, 7.74238929e-02f, 1.43000811e-01f, -1.27355859e-01f, 3.42416875e-02f, -4.26231287e-02f,
  8.73553157e-02f, 2.65100580e-02f, -4.84829880e-02f, 4.94542569e-02f, -4.66964282e-02f, 5.71340807e-02f, 5.51215485e-02f, -5.03059179e-02f, 4.31471877e-02f, -8.96942541e-02f,
  5.98813742e-02f, 6.38643578e-02f, -6.04354888e-02f, -2.21955758e-02f, 6.66600391e-02f, -5.96096031e-02f, -3.09673138e-04f, 1.63452160e-02f, -5.97944297e-02f, -1.07091002e-01f,
  -3.64985168e-02f, -2.85653770e-02f, -1.31622143e-02f, 1.25583028e-02f, 3.31649818e-02f, -5.83852967e-03f, 2.03624591e-02f, -6.53884038e-02f, -1.05098635e-02f, -2.56181993e-02f,
  3.59614305e-02f, 6.18405221e-03f, -1.27509246e-02f, -1.64197937e-01f, -6.46985415e-03f, -7.09441528e-02f, 6.67842254e-02f, -1.38684332e-01f, -1.12165892e-02f, 2.83680949e-02f,
  -6.35043904e-02f, 2.84352712e-02f, 3.71319652e-02f, -3.96794602e-02f, -3.17056105e-02f, 1.18674291e-02f, -4.57986481e-02f, 6.18796125e-02f, -6.64796457e-02f, 8.22954439e-03f,
  -8.16975906e-02f, 1.85499400e-01f, -7.85173252e-02f, -1.36594726e-02f, 2.10617278e-02f, 5.12077473e-03f, 3.90507467e-02f, 6.29918948e-02f, 4.46897149e-02f, 3.12400535e-02f,
  -2.32142862e-02f, -7.37596080e-02f, 1.06789730e-02f, -2.32584294e-04f, 6.33719489e-02f, -1.02681115e-01f, -1.11192344e-02f, -5.32251373e-02f, 1.67662110e-02f, -8.18082765e-02f,
  6.03637733e-02f, -5.34364097e-02f, -5.14039770e-02f, -2.52241120e-02f, -9.59370732e-02f, 1.00703593e-02f, -7.96880499e-02f, -5.82606122e-02f, -1.67734735e-02f, -1.59051552e-01f,
  -1.09102465e-01f, -1.51844367e-01f, -1.73079386e-01f, -1.59073979e-01f, 1.25353783e-01f, 1.62056625e-01f, 1.50663897e-01f, 6.28185272e-02f, -4.93166037e-02f, -9.82860550e-02f,
  -2.34030038e-02f, 1.81937844e-01f, 2.37060990e-02f, 1.72576085e-01f, 1.36945054e-01f, 1.16059512e-01f, -2.61979010e-02f, -3.84348072e-02f, 2.85037428e-01f, 1.79865494e-01f,
  1.68006241e-01f, -4.05220129e-03f, -2.41315603e-01f, -1.18301352e-02f, -1.04504190e-01f, 1.40884131e-01f, -1.93917215e-01f, -1.82474241e-01f, -1.84953716e-02f, -3.18526216e-02f,
  -1.21899806e-01f, -2.35817358e-01f, 1.76466167e-01f, 5.85399643e-02f, -1.04894198e-01f, 4.78004664e-02f, 1.64375380e-02f, -1.07726052e-01f, 4.78687659e-02f, -3.52610089e-02f,
  7.43446825e-03f, -2.88122315e-02f, -1.72143579e-02f, -6.24068789e-02f, -1.22751154e-01f, -2.21052114e-02f, -1.05170809e-01f, -1.18486851e-01f, -1.96011607e-02f, -1.78683385e-01f,
  5.11685349e-02f, -1.43861383e-01f, -1.09525114e-01f, -4.60652635e-02f, -3.67241949e-02f, -9.75160208e-03f, -1.51293501e-01f, -6.12153225e-02f, -1.40868649e-01f, -1.78112209e-01f,
  8.41795746e-03f, -5.27980328e-02f, 3.14445794e-02f, 4.67410032e-03f, 3.29235540e-04f, 7.79188646e-04f, -5.09729252e-05f, 5.02801277e-02f, 2.67556813e-02f, 5.67843840e-02f,
  -6.14736453e-02f, -4.91387695e-02f, 1.49785411e-02f, -4.15823758e-02f, -7.90360644e-02f, 3.26293637e-03f, 2.40677837e-02f, 2.45527532e-02f, -2.92987805e-02f, 7.97392055e-02f,
  -3.02790012e-02f, 7.53667112e-03f, -1.51420915e-02f, -1.97283764e-04f, 4.74692322e-02f, 7.59850889e-02f, -4.52712923e-02f, 4.92087565e-02f, -1.08674737e-02f, 3.32877971e-02f,
  -7.66199362e-03f, 2.76152696e-02f, 6.02665059e-02f, 1.14860192e-01f, -5.79739250e-02f, 3.24403383e-02f, -2.56344303e-02f, 8.97938162e-02f, -3.06169894e-02f, 1.56013062e-02f,
  1.96173396e-02f, -9.61980820e-02f, -4.39208485e-02f, -2.04527713e-02f, 1.54589033e-02f, -7.02373404e-03f, -4.96057719e-02f, 1.92182243e-01f, 5.15373573e-02f, -5.48646934e-02f,
  2.67064385e-02f, 9.40169096e-02f, 1.21945947e-01f, 1.09113283e-01f, -3.67113389e-02f, 2.16568261e-01f, 7.76975974e-02f, 1.72129467e-01f, 9.30372626e-02f, 1.35055423e-01f,
  1.83061987e-01f, -2.65416075e-02f, 2.15455487e-01f, 8.79059583e-02f, 1.54380053e-01f, 1.34235442e-01f, 3.53043050e-01f, 2.05490336e-01f, -3.00898403e-03f, 1.10062934e-01f,
  -8.85604247e-02f, -1.73874229e-01f, 4.07247525e-03f, 1.08028259e-02f, 8.75776410e-02f, 2.29955345e-01f, 1.93525925e-01f, 1.29803240e-01f, 8.05110708e-02f, 1.99694827e-01f,
  -4.40653041e-02f, 1.34580126e-02f, -1.25408545e-01f, 4.69634868e-02f, -2.83573940e-02f, -3.22133563e-02f, -3.09882779e-03f, 1.04608536e-02f, -9.88618806e-02f, -3.27628702e-02f,
  -1.95160374e-01f, 1.77838221e-01f, 8.59933440e-03f, -4.09799851e-02f, -2.88686827e-02f, -5.13179637e-02f, -6.88064396e-02f, 8.93994793e-02f, 5.18935136e-02f, -1.10217534e-01f,
  9.68625303e-03f, -5.81252538e-02f, 3.27207260e-02f, -7.99933299e-02f, 3.91551703e-02f, -1.33602843e-02f, -3.73401097e-04f, 9.83644873e-02f, -1.15066189e-02f, 3.45988609e-02f,
  -4.61867712e-02f, -5.50906472e-02f, 1.50173411e-01f, 1.31235659e-01f, 5.38853779e-02f, 6.40233681e-02f, 5.03151529e-02f, -6.78180456e-02f, 1.15316920e-01f, -7.27145001e-02f,
  -3.88759077e-02f, -4.07190435e-02f, 2.03753560e-04f, -2.45558992e-02f, 1.59448162e-02f, -6.76161423e-02f, -3.65843363e-02f, -5.54986075e-02f, -3.72116715e-02f, -3.57140675e-02f,
  -5.03455801e-03f, 6.11331314e-02f, 6.26044953e-03f, 1.39076095e-02f, -3.44703346e-02f, -3.27548310e-02f, -2.90341079e-02f, -4.09216397e-02f, 4.97528575e-02f, -4.18816172e-02f,
  2.58471593e-02f, 4.77402005e-03f, 1.66558847e-02f, 1.45173548e-02f, -3.71445203e-03f, 6.43047467e-02f, 2.32774317e-02f, 4.49948460e-02f, -8.52540657e-02f, -3.54248397e-02f,
  -2.43448570e-01f, 1.62449449e-01f, -5.77924177e-02f, 5.01182256e-03f, 1.22090839e-02f, -8.80566388e-02f, -4.30483706e-02f, 1.82115342e-02f, -1.18592125e-03f, -3.49381343e-02f,
  5.53625040e-02f, 1.71311165e-03f, -4.15018313e-02f, -1.52238319e-02f, 2.20666528e-02f, 5.82080446e-02f, -9.36731100e-02f, 6.18791170e-02f, 4.41767313e-02f, -7.26475939e-02f,
  3.83709110e-02f, 6.97864741e-02f, 7.62395263e-02f, -6.45283982e-02f, -2.22935341e-02f, 4.70649190e-02f, -1.67424679e-02f, -3.21996659e-02f, 7.25905970e-02f, -5.10590225e-02f,
  1.90947622e-01f, -9.22944322e-02f, -3.37095082e-01f, -5.78898303e-02f, -1.27107250e-02f, 5.78044765e-02f, 4.87368740e-02f, 2.13771224e-01f, 2.24602386e-01f, -1.22358538e-02f,
  5.60061149e-02f, 3.03688884e-01f, 2.00171411e-01f, 4.04883958e-02f, 4.34552692e-02f, -6.40302896e-02f, -2.82501966e-01f, -1.31866410e-01f, 1.10418640e-01f, 3.13341677e-01f,
  1.71057999e-01f, -1.55706480e-01f, 1.91825796e-02f, 2.88477894e-02f, -5.40988632e-02f, 9.25351009e-02f, -2.28086188e-01f, -1.94386169e-01f, -1.35435343e-01f, -3.71416688e-01f,
  -1.69941634e-01f, -2.47464310e-02f, -1.04630142e-02f, 1.03582013e-02f, -2.01334208e-01f, -3.58572379e-02f, 4.85865632e-04f, -1.74724847e-01f, 3.25318091e-02f, 4.36608084e-02f,
  -2.21665967e-02f, 7.20431656e-03f, -6.45187199e-02f, -8.39296579e-02f, -4.70398515e-02f, 4.85634953e-02f, -1.80160165e-01f, -4.71713804e-02f, -1.16107382e-01f, -3.03265033e-03f,
  -5.91953546e-02f, -1.27807453e-01f, -2.85876226e-02f, 6.18102774e-02f, 5.23013100e-02f, 6.64604222e-03f, 1.61874108e-02f, -3.31447311e-02f, 8.38396996e-02f, -1.03059784e-01f,
  8.79824087e-02f, 9.24689025e-02f, -3.44146788e-02f, 3.17910649e-02f, 2.84933317e-02f, -2.35256739e-02f, 2.56435387e-02f, -7.38116801e-02f, 1.14248499e-01f, -9.18535888e-02f,
  6.79930001e-02f, 3.33196088e-03f, -3.19393873e-02f, 3.67039442e-02f, 5.05223237e-02f, -5.11863641e-02f, 5.10312356e-02f, -3.14446799e-02f, 4.98778094e-03f, -2.10275650e-02f,
  4.19467017e-02f, 2.84456667e-02f, -1.13031961e-01f, -2.00405512e-02f, -8.96950141e-02f, -7.59880319e-02f, 8.00255314e-02f, -3.21076103e-02f, 1.88314393e-02f, 3.19071934e-02f,
  8.44968036e-02f, 1.46668274e-02f, 4.63465638e-02f, -4.20534387e-02f, -4.93278867e-03f, -3.99340093e-02f, 2.75736023e-03f, 5.95950782e-02f, -1.23433061e-02f, 6.56138361e-02f,
  7.27012455e-02f, 3.13925855e-02f, -2.25184243e-02f, 8.17765575e-03f, 9.86080766e-02f, 1.52126193e-01f, 3.21231782e-02f, 3.30113210e-02f, 4.65444997e-02f, -2.21805442e-02f,
  -4.30563539e-02f, 4.24042605e-02f, 1.87751561e-01f, 9.57727358e-02f, 5.38125820e-02f, 1.70015007e-01f, -1.61184128e-02f, -4.19526966e-03f, 1.63761482e-01f, 2.46445581e-01f,
  1.90648943e-01f, -2.52961695e-01f, -1.96611732e-01f, 9.55375582e-02f, 4.07218225e-02f, 5.72156440e-03f, -2.75763094e-01f, -3.75654697e-02f, 1.56288713e-01f, -1.17422596e-01f,
  9.52057764e-02f, 2.77336597e-01f, 2.30127245e-01f, 1.54999182e-01f, 7.98806176e-02f, -1.82434037e-01f, -2.28048369e-01f, -3.82282562e-03f, 1.47174075e-01f, 1.30596563e-01f,
  3.78272757e-02f, -5.44895530e-02f, 6.74054846e-02f, 1.28697649e-01f, -1.63218215e-01f, 1.71217754e-01f, -1.97038397e-01f, -3.40796597e-02f, -1.14828043e-01f, -2.64293015e-01f,
  4.75154407e-02f, -2.57278197e-02f, 1.47036135e-01f, 3.27681415e-02f, 5.88747077e-02f, -9.26311389e-02f, -3.21856253e-02f, 6.53602928e-02f, -1.29282577e-02f, 1.48364715e-02f,
  1.26721375e-02f, 1.45857604e-02f, 2.94802878e-02f, -2.45121475e-02f, -1.09401038e-02f, -8.95733982e-02f, 2.12192014e-02f, 1.44439787e-02f, -9.80542377e-02f, -7.79523700e-02f,
  -5.86291216e-02f, 4.12631668e-02f, 4.29690965e-02f, -1.01760112e-01f, 9.93951596e-03f, 1.67883057e-02f, -7.39085302e-02f, -3.89900990e-02f, -8.82833228e-02f, -1.56003192e-01f,
  2.30486486e-02f, 4.21148762e-02f, -1.63031891e-02f, 3.30016250e-03f, 6.76121041e-02f, -2.49434169e-02f, -3.34676914e-02f, 4.51928303e-02f, 5.80520695e-03f, -8.93011317e-02f,
  2.98725087e-02f, -4.60122079e-02f, 1.04160562e-01f, 1.75159015e-02f, -8.72832164e-03f, 4.79384791e-03f, -6.27101772e-03f, 2.40920931e-02f, 3.53520997e-02f, -3.99039648e-02f,
  5.46248108e-02f, -3.52401170e-03f, -1.05706435e-02f, -1.68308262e-02f, 9.10169855e-02f, -2.87767109e-02f, -7.62580112e-02f, 3.03777270e-02f, 3.50693129e-02f, -4.78640608e-02f,
  4.85851876e-02f, 1.72261760e-01f, 7.94215798e-02f, -5.24938740e-02f, -3.43999714e-02f, 5.89143783e-02f, 1.53966881e-02f, 4.64353524e-02f, -1.70399668e-03f, -7.76375532e-02f,
  1.22513205e-01f, 2.82083023e-02f, 6.99145645e-02f, 2.59949882e-02f, -5.86531274e-02f, 1.96582470e-02f, 3.41664553e-02f, 4.18455079e-02f, 3.61775011e-02f, -3.36508118e-02f,
  -1.44228756e-01f, 2.13988521e-03f, 1.04024122e-02f, -2.06118450e-03f, -5.44759352e-03f, 9.74197611e-02f, -4.63153571e-02f, -6.28400072e-02f, -1.10112941e-02f, -1.94649667e-01f,
  3.70723754e-01f, 8.53767246e-02f, -9.10093859e-02f, 1.76609769e-01f, -3.41235876e-01f, -2.99909651e-01f, -4.45447057e-01f, -2.88199913e-02f, 1.65958211e-01f, -7.25448802e-02f,
  -2.60568168e-02f, 8.54334012e-02f, 1.58362940e-01f, 2.97610480e-02f, 8.32485184e-02f, -1.77530050e-01f, -2.02454969e-01f, 1.18523680e-01f, 5.66636398e-02f, -8.05950239e-02f,
  -1.55638874e-01f, 8.32350403e-02f, 4.96748000e-01f, 1.87923267e-01f, -8.46920833e-02f, -1.87150374e-01f, 9.32781622e-02f, 1.88473642e-01f, 1.07754432e-01f, -5.07796779e-02f,
  1.00506237e-02f, 2.56699741e-01f, -1.09452888e-01f, 9.58555788e-02f, -2.40505906e-03f, 1.14465669e-01f, 3.16081010e-02f, 1.45388439e-01f, 5.70891537e-02f, 8.94867033e-02f,
  4.99682389e-02f, 1.34492351e-03f, -1.39031382e-02f, -5.76566793e-02f, 5.42147681e-02f, 5.99340983e-02f, 6.56070188e-02f, 2.00016871e-01f, 1.30187362e-01f, 5.70518598e-02f,
  -1.58540577e-01f, 9.67060914e-05f, 8.16188902e-02f, -1.01068094e-01f, 1.02005467e-01f, 4.31519076e-02f, 5.84517680e-02f, 1.65119812e-01f, 4.39212546e-02f, 1.00675128e-01f,
  -1.13924416e-02f, -1.17592560e-02f, -2.84527000e-02f, 2.18924955e-02f, -2.85076117e-03f, -5.30735292e-02f, 2.26357803e-02f, -2.83677001e-02f, -2.36332528e-02f, -4.04065568e-03f,
  -1.79335270e-02f, -1.21665746e-02f, 3.33336294e-02f, 3.58971134e-02f, -7.40446895e-02f, 1.04630314e-01f, -4.77177426e-02f, 3.77287343e-02f, 8.71339533e-03f, 5.25765233e-02f,
  1.70350373e-02f, -2.19164439e-03f, 1.11761494e-02f, -3.25336196e-02f, -5.28299920e-02f, -1.52542678e-04f, -7.18783066e-02f, 2.34932117e-02f, 5.48407733e-02f, 5.26786931e-02f,
  4.93853865e-03f, 6.83521032e-02f, 1.09734293e-02f, 3.59938806e-03f, -8.43654424e-02f, 9.78425667e-02f, -2.79291999e-02f, 9.37321782e-03f, -5.75397164e-03f, 6.29911870e-02f,
  -1.14870421e-03f, -4.20738421e-02f, 1.56948566e-02f, 2.96750776e-02f, -1.08889207e-01f, -4.10414720e-03f, -4.76109684e-02f, -7.61692449e-02f, 4.93159629e-02f, 7.91214965e-03f,
  -3.08448914e-02f, -1.10827588e-01f, -1.47686854e-01f, -6.12902343e-02f, -6.88576624e-02f, -2.22933307e-01f, -1.27729177e-01f, -4.39249128e-02f, -1.66326657e-01f, -1.70600608e-01f,
  -2.11114630e-01f, 2.87288070e-01f, -2.55470544e-01f, -5.61176892e-03f, 1.25982493e-01f, -2.48509254e-02f, 1.78268582e-01f, 8.80340189e-02f, -6.64927661e-02f, 1.85168147e-01f,
  2.23804638e-01f, 2.98685580e-02f, -2.81870235e-02f, -8.55077654e-02f, 1.73698645e-02f, 6.58655316e-02f, -2.30504535e-02f, -2.13552698e-01f, -3.13245356e-01f, -4.21826504e-02f,
  5.75093441e-02f, -8.37417096e-02f, -1.36333762e-03f, -4.79907682e-03f, 6.33706897e-02f, -1.06593154e-01f, -8.47642124e-02f, 9.51741785e-02f, 3.54325399e-02f, 1.55649722e-01f,
  -1.25511393e-01f, 1.08609758e-01f, -5.43491952e-02f, 3.47171426e-02f, -1.81761160e-02f, -2.12030001e-02f, -1.08689837e-01f, 1.42500782e-02f, -3.71510237e-02f, 9.17818174e-02f,
  4.75881435e-02f, 2.43051015e-02f, 1.11675166e-01f, -7.95739982e-03f, 4.32124808e-02f, -4.53332579e-03f, -4.59386818e-02f, 2.91972253e-02f, -1.00376651e-01f, -6.64145574e-02f,
  1.51558176e-01f, 3.08312979e-02f, -6.81002885e-02f, 3.94871607e-02f, 2.39050947e-02f, -6.87926784e-02f, 6.08600751e-02f, 1.03377253e-01f, -3.68620083e-02f, 3.61332782e-02f,
  -3.53384577e-02f, 1.31239584e-02f, -5.60759194e-02f, 1.06119318e-02f, -1.33292878e-03f, -2.16762489e-03f, 5.68755716e-02f, 5.58816828e-02f, 7.02954680e-02f, -5.28909266e-02f,
  -1.27450954e-02f, -5.40800802e-02f, -4.73896340e-02f, 1.38711557e-02f, -3.60221788e-02f, -2.38788570e-03f, 3.30610573e-02f, 1.08454376e-01f, -2.39216462e-02f, -9.12260730e-03f,
  5.53605184e-02f, 2.77554654e-02f, -4.90270881e-03f, 3.74900065e-02f, 7.04131380e-04f, -4.77831289e-02f, -6.75022230e-02f, -1.47083541e-02f, -4.83374484e-02f, -3.15419436e-02f,
  -3.39196809e-02f, -5.72917275e-02f, -7.70764202e-02f, -2.98009235e-02f, -9.19346586e-02f, -7.26377517e-02f, 7.68390670e-02f, 2.39988714e-02f, -1.78245362e-02f, -6.60135671e-02f,
  7.99541771e-02f, -1.00506499e-01f, -2.05987003e-02f, -6.28068447e-02f, -2.44471971e-02f, 1.78667475e-02f, 1.03178089e-02f, -1.27672538e-01f, 5.45592085e-02f, -6.24371953e-02f,
  3.35958563e-02f, -1.29183248e-01f, -2.56319284e-01f, -5.86115941e-02f, -1.39433160e-01f, -1.29766196e-01f, -1.69497654e-02f, -1.21092543e-01f, -2.05690801e-01f, -2.34341785e-01f,
  -2.87485272e-01f, -1.07212409e-01f, 1.88015942e-02f, -3.41093361e-01f, -3.33621025e-01f, -1.61584422e-01f, -3.15435737e-01f, -1.07195593e-01f, -5.13084680e-02f, -2.38779858e-01f,
  -7.15321824e-02f, 7.39414543e-02f, 2.17805058e-02f, 2.26720378e-01f, 1.63829640e-01f, -1.30657822e-01f, -1.05539046e-01f, 9.79094207e-02f, 1.96719512e-01f, 2.48593185e-02f,
  8.19816142e-02f, -8.49851891e-02f, 8.93838555e-02f, 1.10461883e-01f, 7.36249657e-03f, 3.97196636e-02f, -3.13197821e-02f, -2.69130953e-02f, 6.32946789e-02f, 1.29007816e-01f,
  1.42395407e-01f, -6.11665919e-02f, -4.55280729e-02f, 1.81542784e-02f, -7.09198490e-02f, 9.98056233e-02f, -8.52287002e-03f, 6.16047755e-02f, -9.94993187e-03f, 9.73751396e-03f,
  -4.79513407e-02f, 2.47856174e-02f, -3.59599404e-02f, 2.17135157e-02f, -4.43835147e-02f, 2.04887390e-02f, -3.33990194e-02f, 7.15460703e-02f, 4.74436246e-02f, -6.41279900e-03f,
  6.78618252e-03f, -5.22224680e-02f, 1.18835492e-03f, -3.42423096e-02f, 7.33936951e-02f, -2.28791148e-03f, 1.99279804e-02f, 7.30458871e-02f, 4.37133461e-02f, 3.08258925e-02f,
  -1.66601576e-02f, 1.47609366e-02f, 1.89126320e-02f, -6.44172281e-02f, -7.55710667e-03f, -5.61880022e-02f, 7.23852292e-02f, 9.67409834e-03f, -8.51577073e-02f, 7.93330092e-03f,
  4.60423119e-02f, 1.72120538e-02f, -3.91093045e-02f, -4.37994227e-02f, -2.20325850e-02f, -8.52441788e-03f, 3.74443792e-02f, -3.64393666e-02f, 2.30137240e-02f, 1.75564941e-02f,
  3.71514112e-02f, 8.85719154e-03f, -1.05840579e-01f, 1.57498226e-01f, -1.95081327e-02f, 1.61868185e-02f, 4.91725430e-02f, -1.39565086e-02f, -5.32636372e-03f, -1.24472575e-02f,
  -6.15298152e-02f, 1.59000151e-03f, -8.45433213e-03f, 6.49226308e-02f, 8.18035677e-02f, 1.41971803e-03f, 1.33281306e-03f, 4.95971441e-02f, 2.76303329e-02f, 6.12418959e-03f,
  2.92705353e-02f, -4.13859338e-02f, 1.39085492e-02f, 4.99241576e-02f, 2.70580333e-02f, 3.51306088e-02f, -1.24671303e-01f, 3.81192453e-02f, 4.06726375e-02f, -2.28948612e-02f,
  -6.17816579e-03f, -9.22323167e-02f, -1.25015117e-02f, -9.98700336e-02f, -4.95274551e-02f, -4.17485200e-02f, 5.94957992e-02f, 2.13902984e-02f, -4.54384775e-04f, -3.01357061e-01f,
  -3.21087390e-01f, 1.26091972e-01f, 1.45003393e-01f, 6.68670610e-02f, 2.29860723e-01f, -3.14366519e-02f, 1.19413182e-01f, -2.71721721e-01f, -1.41663402e-01f, 1.07086524e-02f,
  1.46888807e-01f, -9.21629444e-02f, -8.24195594e-02f, -1.08576812e-01f, -6.79575652e-02f, 8.56124684e-02f, 9.19484049e-02f, -3.87989394e-02f, -3.26313227e-01f, -4.93454002e-02f,
  1.07360870e-01f, 8.69692415e-02f, -3.18867713e-02f, -7.75152519e-02f, 2.56555021e-01f, -5.66410758e-02f, 1.50143206e-01f, 2.23271012e-01f, 7.29938149e-02f, 4.66274172e-01f,
  1.24424778e-01f, 8.64798725e-02f, -6.58101216e-02f, -8.68319441e-03f, 6.98774755e-02f, -1.28151044e-01f, -7.96179250e-02f, 5.87622449e-02f, 2.33938042e-02f, -2.67873015e-02f,
  1.06462322e-01f, -3.35873179e-02f, 5.06990105e-02f, 7.45593850e-03f, -7.25043789e-02f, -7.87076578e-02f, -8.01564902e-02f, -4.00279723e-02f, -7.64093921e-02f, 2.40319632e-02f,
  1.61168098e-01f, 1.51717111e-01f, 9.19131190e-02f, 1.25883324e-02f, 4.98293005e-02f, -3.34167220e-02f, 8.34160149e-02f, -7.14452751e-03f, -2.49721929e-02f, 1.14076063e-02f,
  -1.02604525e-02f, 7.91144744e-02f, 3.87455523e-02f, 4.14734446e-02f, -7.52931386e-02f, 9.13959220e-02f, 1.46781486e-02f, 3.32462452e-02f, -1.88584961e-02f, -1.70878358e-02f,
  2.49235816e-02f, 6.14223816e-02f, 3.01693734e-02f, -7.39643276e-02f, -1.02108689e-02f, 1.08198665e-01f, -3.58660966e-02f, -1.96766742e-02f, -8.14733934e-03f, -1.58350002e-02f,
  2.05257330e-02f, -6.52649626e-02f, -7.23307719e-03f, -2.81580873e-02f, 2.35652905e-02f, 7.09514618e-02f, 4.58424017e-02f, 4.20390069e-02f, -5.00041433e-02f, -2.30766721e-02f,
  -3.61568034e-01f, 4.44546565e-02f, 2.87369601e-02f, -6.06047502e-03f, 1.63148949e-03f, -1.37450816e-02f, -5.56077389e-03f, 6.95743086e-03f, 5.75152300e-02f, -5.54273720e-04f,
  -4.62464802e-02f, -4.67857942e-02f, 2.97203064e-02f, 8.96910392e-03f, -1.11351155e-01f, 3.10226511e-02f, 2.85639819e-02f, -1.10900244e-02f, 2.33934121e-03f, -4.41304035e-02f,
  -3.28754038e-02f, -7.57405534e-02f, -1.36126146e-01f, -1.80012599e-01f, -1.20315768e-01f, -1.80602774e-01f, -1.17226928e-01f, -5.16165160e-02f, -1.83806285e-01f, -3.41185600e-01f,
  -6.79633841e-02f, 4.02151197e-02f, -1.70213766e-02f, -7.06348270e-02f, 1.37577906e-01f, 6.55301586e-02f, 7.41176903e-02f, 1.96638610e-02f, -2.52940115e-02f, -6.78715035e-02f,
  1.10698283e-01f, 1.29780158e-01f, -4.70289327e-02f, 3.67835313e-02f, 2.44798530e-02f, -7.17900172e-02f, -1.18395621e-02f, -9.02533084e-02f, -4.42055687e-02f, 1.73355117e-01f,
  7.57496208e-02f, -1.07709192e-01f, -2.13040814e-01f, -2.13144347e-02f, 1.43874392e-01f, -5.88796735e-02f, -1.05401717e-01f, 8.46742317e-02f, 6.13861382e-02f, 1.35239273e-01f,
  1.59699127e-01f, 1.87272549e-01f, -8.94294828e-02f, 3.34131382e-02f, 9.68094077e-03f, -8.34050775e-02f, 3.65127847e-02f, -1.89985558e-02f, -8.76409486e-02f, -7.69692287e-02f,
  8.12240094e-02f, 5.07200658e-02f, -2.61469949e-02f, 7.47585250e-03f, 6.28490224e-02f, 7.85352513e-02f, -3.35016437e-02f, -3.50461565e-02f, -1.22338891e-01f, 7.42570683e-02f,
  7.42770210e-02f, 4.49207239e-02f, 1.06892236e-01f, -1.34901209e-02f, 1.30646750e-01f, 6.06663227e-02f, 6.57529011e-02f, 1.23096362e-01f, -4.18884680e-02f, -1.79092102e-02f,
  -6.70103133e-02f, 6.72378391e-02f, 1.11901522e-01f, -1.46953678e-02f, 2.09864229e-02f, -2.31224634e-02f, 7.16736764e-02f, -2.77239201e-03f, 5.28028272e-02f, -7.89976642e-02f,
  6.69183508e-02f, -7.10857008e-03f, 2.85608731e-02f, -2.43336242e-02f, -6.38774708e-02f, -1.96580924e-02f, -4.15901020e-02f, -6.65091723e-02f, 8.28258768e-02f, -3.73929031e-02f,
  -8.85891914e-03f, 9.62926522e-02f, -4.14905585e-02f, 2.76585259e-02f, 2.23894082e-02f, -1.51121421e-04f, 4.09255028e-02f, -2.17239521e-02f, -6.50621252e-03f, 4.11749519e-02f,
  -2.27549732e-01f, 4.58335951e-02f, -3.22565585e-02f, 4.68734056e-02f, 5.32567166e-02f, -1.60628650e-02f, 5.96099831e-02f, 3.13038267e-02f, -9.16187465e-03f, -6.80446774e-02f,
  9.83337238e-02f, -1.33375833e-02f, -1.08635845e-02f, 1.83082856e-02f, -6.53246418e-02f, -5.71849830e-02f, -5.27855288e-03f, -3.27442065e-02f, -3.08824647e-02f, 4.67985235e-02f,
  3.77228623e-03f, -7.88053423e-02f, -8.08768570e-02f, 1.11134443e-02f, 5.86892590e-02f, 2.28392296e-02f, -3.83015499e-02f, -6.80626854e-02f, 5.49514554e-02f, -3.79832983e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.13831264e-01f, -1.07089654e-01f, 6.27298281e-02f, 5.48316501e-02f, -5.12317009e-03f, 8.37209970e-02f, 1.94447078e-02f, 1.83902100e-01f, 8.96599218e-02f, -1.40509471e-01f,
  -3.77280638e-02f, -8.67960230e-02f, -3.25989015e-02f, -1.46264091e-01f, -1.78235903e-01f, -3.36897038e-02f, -1.74142033e-01f, -1.64363354e-01f, 1.13525875e-01f, 8.09283257e-02f,
  -3.99133377e-02f, -1.24142125e-01f, -1.87696904e-01f, 3.42751443e-02f, -5.60352318e-02f, -1.68358088e-01f, -1.75495505e-01f, -1.51379019e-01f, -1.97329298e-02f, -4.09993917e-01f,
  -6.23572096e-02f, 1.36858821e-01f, 4.93619144e-02f, -4.07225499e-03f, -1.01179369e-01f, 7.96374232e-02f, 8.46993700e-02f, 2.17992980e-02f, 6.53669164e-02f, 1.24629341e-01f,
  -3.61675136e-02f, 9.12450552e-02f, -3.54989097e-02f, 5.00570908e-02f, 2.25802343e-02f, 1.17349327e-02f, 9.74683538e-02f, 4.58050855e-02f, 5.70485322e-03f, 1.36645749e-01f,
  7.71700144e-02f, 3.21230851e-02f, -1.46697536e-02f, 8.56859311e-02f, 6.29602559e-03f, -7.06446692e-02f, -5.49056828e-02f, -4.72955219e-02f, -4.12840731e-02f, -2.49726787e-01f,
  3.92983621e-03f, 9.62754898e-03f, 8.76113847e-02f, 1.85997952e-02f, -5.30621484e-02f, 4.46504243e-02f, -4.14047390e-02f, -1.66602824e-02f, -5.42618260e-02f, -1.05190957e-02f,
  -6.96504954e-03f, 7.52691925e-02f, -2.50500045e-03f, -6.67284727e-02f, 2.45155469e-02f, 2.62137204e-02f, -3.89992557e-02f, 2.82877181e-02f, -5.07825837e-02f, -3.28743942e-02f,
  -5.33534922e-02f, 4.50256607e-03f, -3.38736400e-02f, -1.95176117e-02f, 6.60284236e-02f, 1.90672111e-02f, 5.39673343e-02f, 1.12512624e-02f, 7.42251948e-02f, 3.89717408e-02f,
  -1.01192325e-01f, -1.54340506e-01f, -1.81171261e-02f, -3.86917666e-02f, 6.23565689e-02f, 1.18913576e-02f, -2.57072821e-02f, 6.69602212e-03f, -2.15787757e-02f, 6.98787943e-02f,
  7.97746405e-02f, -7.08031356e-02f, -1.28385052e-01f, 9.94197428e-02f, -2.92762108e-02f, 1.62928384e-02f, 4.91120201e-03f, -1.25372231e-01f, -1.75463632e-02f, 1.14721172e-01f,
  1.33860623e-02f, -4.59629782e-02f, -2.24693179e-01f, -9.64717567e-02f, 8.96482822e-03f, -1.20839514e-01f, -1.67020798e-01f, -1.28022909e-01f, -1.59688815e-01f, -2.70251423e-01f,
  -2.09922552e-01f, -2.02478036e-01f, -1.61553144e-01f, 9.84621719e-02f, 4.58223633e-02f, 5.08933142e-02f, -1.22968785e-01f, -5.36766276e-02f, 1.85717702e-01f, -1.56491444e-01f,
  6.38290048e-02f, 1.54968975e-02f, -4.48781997e-02f, -1.49755210e-01f, -2.11008847e-01f, -2.99700499e-01f, -2.52986759e-01f, -1.70932531e-01f, -8.29786062e-02f, -2.56653745e-02f,
  6.66654259e-02f, -1.37678506e-02f, -2.87583116e-02f, 4.35017608e-02f, 1.10204518e-01f, 1.49503931e-01f, 1.45512015e-01f, 4.49928679e-02f, 1.44916564e-01f, -4.11674120e-02f,
  -6.81627169e-02f, -6.93541765e-02f, -5.52948005e-02f, -3.69528346e-02f, -2.48616040e-02f, -6.18228763e-02f, -9.06993523e-02f, -6.25433847e-02f, -4.41068858e-02f, -5.10818027e-02f,
  -4.09158394e-02f, 6.16644137e-02f, -6.75460603e-03f, -4.16305382e-03f, 4.76980694e-02f, -5.71269765e-02f, -2.41736956e-02f, -1.75164074e-01f, -4.94049489e-02f, 5.88426739e-02f,
  -3.17738838e-02f, 7.18675107e-02f, -1.10947981e-01f, 6.71275929e-02f, -3.06772348e-02f, 7.84882829e-02f, 7.33406171e-02f, 1.28125310e-01f, 1.53092384e-01f, 2.74746865e-02f,
  3.12517211e-02f, -2.81217899e-02f, -7.70715401e-02f, -2.32879389e-02f, -5.37460446e-02f, -7.33219692e-03f, -1.64086446e-02f, -9.29569546e-03f, 1.42827083e-03f, -2.29816455e-02f,
  6.21729810e-03f, -2.20433739e-03f, 1.35269193e-02f, 4.94327433e-02f, 7.93396160e-02f, 4.98526879e-02f, 9.32285935e-02f, -1.68728866e-02f, 3.11483033e-02f, 1.77152697e-02f,
  -7.31162727e-02f, -1.16234748e-02f, -6.16125436e-03f, 7.33908564e-02f, -1.13383934e-01f, 1.64180677e-02f, 3.42838354e-02f, -3.25382943e-03f, -1.10937953e-02f, -5.17434590e-02f,
  -2.67820936e-02f, -4.98462766e-02f, -1.54284716e-01f, -8.91405270e-02f, -5.84751517e-02f, -2.46660225e-02f, -4.44074301e-03f, -3.95297743e-02f, 3.17855887e-02f, -3.87725309e-02f,
  -1.81724746e-02f, -6.87782019e-02f, -1.62381269e-02f, -6.37811944e-02f, -6.50039539e-02f, -1.98413152e-02f, -1.08947337e-01f, -3.04981950e-03f, -1.70313306e-02f, 6.55946881e-02f,
  -9.37383398e-02f, -1.22492015e-01f, -1.61613256e-01f, -5.66822626e-02f, 2.63270456e-03f, -9.02450830e-02f, -1.26988823e-02f, 6.14782274e-02f, -1.42881870e-01f, -1.53699026e-01f,
  2.62380838e-01f, -3.15412483e-03f, -1.44160315e-01f, 1.13662839e-01f, 9.59097594e-02f, 5.56802787e-02f, -6.14266358e-02f, 1.06321640e-01f, 2.41064858e-02f, 5.85997403e-02f,
  3.07908338e-02f, 2.20552251e-01f, 2.33826429e-01f, 2.18964800e-01f, 4.93416153e-02f, 7.28329048e-02f, -8.25528949e-02f, -3.82988341e-02f, 8.09208527e-02f, -2.75940448e-02f,
  -5.73564917e-02f, -1.48608565e-01f, -4.30806950e-02f, -5.74651659e-02f, -1.42532557e-01f, 1.00477822e-01f, 5.33028855e-04f, -3.16978768e-02f, -9.09539126e-03f, -7.65218958e-02f,
  9.72558409e-02f, 1.28391966e-01f, 9.06494185e-02f, 9.53822583e-02f, -8.77203792e-02f, -9.26167369e-02f, -2.95105949e-03f, -2.69332528e-02f, 1.19646192e-02f, 6.14293553e-02f,
  -8.05767067e-03f, 3.37560698e-02f, 4.82072160e-02f, -1.77079588e-02f, -2.73626149e-02f, 7.97646418e-02f, -1.90880179e-01f, 4.10617851e-02f, 5.60267083e-02f, -4.39367257e-02f,
  9.46830772e-03f, -3.50745060e-02f, 2.33868118e-02f, 1.14451926e-02f, 4.75538671e-02f, 5.41184694e-02f, -2.48543974e-02f, -1.58129837e-02f, -7.43131414e-02f, -5.11458032e-02f,
  1.61917545e-02f, -5.91754466e-02f, -3.40681300e-02f, -1.75463278e-02f, -1.66687164e-02f, 9.74344015e-02f, 5.38440943e-02f, 3.54683250e-02f, -5.25599569e-02f, -1.33131787e-01f,
  7.52979293e-02f, 7.77387545e-02f, 6.21157661e-02f, 5.06072231e-02f, 4.30538319e-02f, 2.96050101e-03f, 7.43503347e-02f, 6.72015734e-03f, 1.33963367e-02f, 2.69075334e-02f,
  3.25068459e-02f, 5.52307032e-02f, -5.58649711e-02f, -3.73996012e-02f, -6.28935397e-02f, -5.71210608e-02f, 4.89297509e-02f, -2.89719999e-02f, -1.98670682e-02f, -4.78045717e-02f,
  2.64266223e-01f, 8.80870223e-02f, 5.05897477e-02f, 5.38686849e-02f, -1.39190122e-01f, 3.13390531e-02f, 3.90353575e-02f, 5.87229319e-02f, 1.02011405e-01f, 4.31427248e-02f,
  -9.70258750e-03f, -1.68355405e-02f, 4.70243674e-03f, -1.26853123e-01f, -3.51169221e-02f, -6.47617429e-02f, -1.53983623e-01f, 1.07728027e-01f, 4.28671986e-02f, -1.20662764e-01f,
  -2.01764554e-02f, 3.06365639e-02f, 1.89007953e-01f, 1.79536685e-01f, -6.22757971e-02f, 2.51699388e-01f, -5.81744649e-02f, -1.63191613e-02f, 1.04709469e-01f, 2.21487936e-02f,
  5.24391234e-02f, 3.65904905e-02f, -3.09954733e-01f, -5.98534495e-02f, -1.30608797e-01f, -2.53986984e-01f, -1.63915798e-01f, -4.83454205e-03f, 2.60846019e-02f, -1.21294960e-01f,
  1.62272714e-02f, 1.12809250e-02f, -2.81562004e-02f, -2.23853160e-02f, 6.24030605e-02f, -2.53639072e-01f, -2.47163832e-01f, -8.25076699e-02f, -1.44599214e-01f, 3.39416997e-03f,
  -9.75911990e-02f, 3.16772005e-03f, 1.26335453e-02f, 1.19996443e-01f, -4.76568341e-02f, 3.84163787e-03f, -1.38195619e-01f, -8.60229358e-02f, -3.24953794e-02f, -1.40855938e-01f,
  -3.11686993e-01f, -1.94704961e-02f, 3.72684153e-04f, 6.25157803e-02f, -1.24865100e-02f, 3.98300402e-02f, -1.35151222e-01f, -2.56125424e-02f, 1.45045608e-01f, -1.16660818e-01f,
  -3.70590901e-03f, 1.07299224e-01f, -4.32423912e-02f, 4.38952968e-02f, -6.15386069e-02f, 3.82495821e-02f, 8.48109573e-02f, 9.38118473e-02f, -1.63827892e-02f, -1.03975236e-02f,
  1.30814195e-01f, -6.03038743e-02f, 5.13027683e-02f, 1.23818353e-01f, 1.24182604e-01f, 2.70078313e-02f, -2.80807223e-02f, 1.00132115e-01f, 1.42842561e-01f, 1.40350144e-02f,
  4.50749621e-02f, -4.72637191e-02f, 5.15897013e-02f, -8.45113210e-03f, 1.11924727e-02f, 8.95438418e-02f, -4.28042933e-02f, -1.00887334e-02f, 9.25782099e-02f, 9.39406604e-02f,
  -3.87007706e-02f, -7.00902864e-02f, 9.38515291e-02f, -3.91537063e-02f, -2.94796955e-02f, 3.36343795e-02f, -4.54940498e-02f, 6.62967712e-02f, -6.04146309e-02f, -2.92080659e-02f,
  7.90672749e-02f, 6.18603341e-02f, 3.78269819e-03f, 8.20862278e-02f, 1.49625568e-02f, 5.01450449e-02f, 1.77696324e-03f, 2.97983103e-02f, -9.15091932e-02f, -2.74084602e-02f,
  4.22460511e-02f, -6.10989295e-02f, -1.59233823e-01f, 1.22448787e-01f, 3.52384187e-02f, 9.93874017e-03f, -8.80580693e-02f, 5.93007654e-02f, 9.26597416e-03f, -4.60434370e-02f,
  9.09721628e-02f, 7.84683079e-02f, 2.18739286e-02f, 9.96468365e-02f, -8.16725753e-03f, 4.02356833e-02f, 6.61530048e-02f, -5.06591275e-02f, -3.03302296e-02f, -1.44387465e-02f,
  1.15426429e-01f, 7.43273050e-02f, 1.62201524e-01f, 4.93648723e-02f, 4.99746762e-03f, -6.33688644e-02f, 6.15422428e-02f, 2.15821117e-02f, 1.49094105e-01f, 1.73538461e-01f,
  -1.39926359e-01f, -9.26625431e-02f, 3.21928747e-02f, -2.51221180e-01f, -4.23034467e-02f, -2.53716223e-02f, 3.92505303e-02f, 3.43789086e-02f, -1.41747132e-01f, 3.18292081e-02f,
  6.02287762e-02f, -6.66166395e-02f, -5.24833277e-02f, -8.60305596e-03f, -9.65930447e-02f, 5.69396280e-02f, -9.00089815e-02f, 3.76238400e-04f, 3.28689069e-02f, 6.35620803e-02f,
  2.65811514e-02f, -7.41378441e-02f, -1.59529209e-01f, -1.04663454e-01f, -4.36220458e-03f, -4.38478170e-03f, -1.97794605e-02f, 2.94246282e-02f, 2.03235969e-02f, -1.74480607e-03f,
  3.60886157e-01f, -9.54706967e-02f, -7.66778961e-02f, -6.89062476e-02f, -8.06227103e-02f, -7.11779743e-02f, 2.03887597e-02f, -6.63429797e-02f, -4.18158993e-02f, 7.06210583e-02f,
  1.76836047e-02f, 7.86001906e-02f, -4.48765382e-02f, 9.22719091e-02f, 1.02376781e-01f, -4.87025678e-02f, -9.98652428e-02f, -1.99746192e-02f, -5.88650145e-02f, -1.35286786e-02f,
  -5.44158891e-02f, -3.70149985e-02f, 7.92538822e-02f, 3.03276889e-02f, -3.27613801e-02f, -9.87301022e-03f, 1.19306952e-01f, 2.94814389e-02f, 1.82642397e-02f, 1.75507199e-02f,
  7.97684267e-02f, -7.87560456e-03f, 5.57062775e-02f, 7.27733150e-02f, 6.93785250e-02f, 5.38331605e-02f, 3.63586284e-02f, 4.77168299e-02f, -4.66385968e-02f, -7.79833831e-03f,
  -8.10181648e-02f, 3.75430286e-03f, 5.52789085e-02f, 7.09323585e-03f, -4.93115038e-02f, -1.14332356e-01f, -1.18748300e-01f, 3.15889604e-02f, -7.47603998e-02f, -4.53170687e-02f,
  -4.42696512e-02f, 4.42964099e-02f, -8.50366205e-02f, 3.69404964e-02f, -6.29442558e-02f, 1.31714065e-02f, 2.12211683e-02f, -8.01116005e-02f, -2.23723520e-02f, -8.16665962e-02f,
  3.44504058e-01f, -1.88618660e-01f, 3.61828394e-02f, -3.91751342e-02f, -4.52111363e-02f, -8.29216540e-02f, 6.93236440e-02f, -3.97556322e-03f, -4.89270203e-02f, 6.35999814e-02f,
  6.24155328e-02f, 5.31928800e-02f, 7.36091956e-02f, 4.65080999e-02f, -4.85642403e-02f, -4.97390563e-03f, -1.49675794e-02f, -4.59708236e-02f, -5.29424064e-02f, -5.39662614e-02f,
  5.44933826e-02f, -4.35824357e-02f, 5.34414910e-02f, 1.39170468e-01f, -8.91343504e-03f, -1.35821262e-02f, 1.26085088e-01f, 2.34745946e-02f, 1.21272393e-01f, 1.84565365e-01f,
  -2.00640425e-01f, 1.25313476e-01f, -3.41863278e-03f, -4.35979180e-02f, -5.98520078e-02f, 8.34355783e-03f, 8.27317014e-02f, 1.46078002e-02f, -6.97067892e-03f, 1.29254565e-01f,
  -2.52180714e-02f, -1.16824947e-01f, 1.62285883e-02f, 7.83865452e-02f, -3.51669267e-03f, 1.08789921e-01f, 1.02089539e-01f, -1.03669442e-01f, -6.03647977e-02f, -9.02639106e-02f,
  -7.00528473e-02f, -9.29421410e-02f, -1.13992877e-01f, -5.28074615e-02f, -2.66846325e-02f, -1.28686950e-01f, 5.93095692e-03f, -1.53166950e-02f, -5.02255931e-02f, 3.95894498e-02f,
  8.54988396e-02f, -3.68214250e-02f, -9.05934647e-02f, -1.36891916e-01f, 1.47826839e-02f, 2.90676281e-02f, -5.42797241e-03f, 1.18801974e-01f, 2.99823098e-02f, 7.58025870e-02f,
  -5.13111465e-02f, -2.57239006e-02f, 1.47862835e-02f, 1.37380688e-02f, -7.64280632e-02f, 1.01524569e-01f, 3.06922430e-03f, 7.74235278e-02f, 1.29417315e-01f, 3.73629779e-02f,
  -4.43164892e-02f, 2.27893814e-02f, 3.24054994e-02f, 3.07031744e-03f, 9.27572846e-02f, -2.25497428e-02f, -6.96638599e-02f, 5.91111109e-02f, -1.79303568e-02f, 2.89318226e-02f,
  7.77794942e-02f, 4.23058495e-03f, -5.17626181e-02f, -2.58268956e-02f, -7.01101646e-02f, 1.96172334e-02f, -4.91858497e-02f, -7.35541135e-02f, 2.81034932e-02f, -2.24686638e-02f,
  2.33700983e-02f, 1.03390040e-02f, 1.02900937e-01f, 8.57169703e-02f, 6.33204132e-02f, 8.77455920e-02f, 3.36656198e-02f, 8.31250325e-02f, 3.50252278e-02f, -2.87763551e-02f,
  -1.59038343e-02f, -5.89048453e-02f, -6.12562485e-02f, -6.06049299e-02f, 1.26749709e-01f, 1.01978466e-01f, -3.74133280e-03f, 5.60266562e-02f, 9.74261761e-02f, -2.17229724e-02f,
  -5.86316697e-02f, 6.88448995e-02f, -2.91060153e-02f, -1.00932442e-01f, -5.27034104e-02f, -4.03049365e-02f, -9.93319526e-02f, 1.06403755e-03f, 4.32497896e-02f, 6.45758957e-02f,
  -1.85393546e-05f, -7.42326956e-03f, 8.91096592e-02f, 7.70696849e-02f, -6.01161867e-02f, -7.05870241e-02f, 1.22818284e-01f, -6.22941479e-02f, 2.50380803e-02f, 1.30708069e-01f,
  -3.13127376e-02f, -1.09577537e-01f, -1.64422486e-02f, 5.48747070e-02f, 5.47802541e-03f, -1.89662911e-02f, -8.18782747e-02f, -6.40630797e-02f, 5.56389708e-03f, -3.06741875e-02f,
  1.50619373e-01f, 1.12481616e-01f, -2.29414143e-02f, -6.46743774e-02f, -2.11101398e-01f, -9.11834985e-02f, 1.17556965e-02f, -1.03345357e-01f, -9.36713442e-02f, 5.34510575e-02f,
  -4.10700291e-02f, -1.17768802e-01f, 2.08982527e-02f, -9.70029309e-02f, -1.85616352e-02f, 1.74140394e-01f, 1.11029357e-01f, -3.61781716e-02f, -1.62754849e-01f, -1.70932472e-01f,
  -1.07586436e-01f, -6.28098175e-02f, -4.32437472e-02f, -9.32990760e-02f, -8.49886760e-02f, -6.40542731e-02f, 8.13381001e-02f, -9.13034305e-02f, 1.89639758e-02f, 7.57356659e-02f,
  -3.36976163e-02f, -1.23321757e-01f, -2.19533015e-02f, -4.45688143e-02f, -1.54053673e-01f, 1.05779082e-01f, -2.87551596e-03f, -3.98718799e-03f, -1.11869112e-01f, 4.50276919e-02f,
  1.47972358e-02f, 1.13371965e-02f, -1.05032668e-01f, 5.87662570e-02f, 4.98952419e-02f, 4.22605732e-03f, 6.65991008e-02f, 7.04761297e-02f, -3.03428005e-02f, -3.18830982e-02f,
  -1.54835265e-02f, -5.04848324e-02f, -1.40832722e-01f, -8.79637599e-02f, -1.08990021e-01f, -7.79221058e-02f, -6.79477602e-02f, -8.11335742e-02f, -1.94691587e-02f, 4.45570163e-02f,
  6.50064424e-02f, 2.79858131e-02f, 2.74624713e-02f, 6.97665885e-02f, 7.14850128e-02f, -1.14569068e-01f, 2.82829665e-02f, 3.62004787e-02f, 3.95873822e-02f, -2.07756031e-02f,
  -2.60391310e-02f, 2.04617139e-02f, 9.39210225e-03f, 3.75219481e-03f, 2.35855822e-02f, -6.08085878e-02f, 2.01890431e-03f, 1.31317154e-01f, 1.20561961e-02f, 8.06019753e-02f,
  -1.01601027e-01f, 6.94178184e-03f, -8.28347877e-02f, -5.39420918e-02f, 9.43052024e-02f, -5.99634647e-02f, 6.75948858e-02f, -5.35943955e-02f, 5.11070080e-02f, -9.09685418e-02f,
  -1.25802308e-01f, -2.74547841e-02f, 9.74597931e-02f, -2.82690898e-02f, -2.80051678e-02f, 6.15502074e-02f, -5.57344109e-02f, 5.72153516e-02f, -8.84936824e-02f, 7.81183019e-02f,
  5.87038808e-02f, -3.74812484e-02f, 1.27048818e-02f, 4.48410138e-02f, 2.96822563e-03f, -2.12407354e-02f, 1.24143645e-01f, 5.96074434e-03f, -8.16955119e-02f, 1.48235308e-02f,
  -6.15836941e-02f, 2.12485977e-02f, -3.42118852e-02f, 3.93114227e-04f, -3.59155331e-03f, -4.13468406e-02f, -1.13076769e-01f, -2.80486904e-02f, -7.08596334e-02f, 4.97116819e-02f,
  -3.25675219e-01f, -9.79074910e-02f, -1.16712801e-01f, -6.18781410e-02f, -3.23194498e-03f, 1.11018047e-01f, 1.40141621e-01f, 1.22166641e-01f, -9.14705638e-03f, -4.37059775e-02f,
  -6.88489759e-03f, -3.84411914e-03f, -3.27520557e-02f, 3.62077393e-02f, 1.46357670e-01f, 3.58659886e-02f, 1.35379985e-01f, 4.47697975e-02f, 9.92676988e-02f, 2.72282921e-02f,
  1.10319287e-01f, 4.66998219e-02f, -1.08516753e-01f, 7.22426400e-02f, -3.75618972e-02f, 1.08037451e-02f, -9.76445451e-02f, -9.98584926e-02f, 5.88650964e-02f, -5.88042438e-02f,
  -1.77418724e-01f, -9.80392247e-02f, -4.48256321e-02f, -7.59897009e-03f, -1.57679506e-02f, 4.67309989e-02f, -1.71908084e-02f, -2.97946632e-02f, 3.63106169e-02f, -9.39366780e-03f,
  1.61358472e-02f, -5.29401302e-02f, 2.75047664e-02f, 4.96505238e-02f, -9.79337171e-02f, -3.11086878e-05f, 3.49346735e-02f, -3.29052433e-02f, 1.30982837e-02f, 7.32950587e-03f,
  -3.74806933e-02f, -6.73892125e-02f, -1.76297307e-01f, -5.68996519e-02f, 5.65547384e-02f, -8.46207067e-02f, -1.21440500e-01f, -3.96072939e-02f, -1.33574396e-01f, -1.92274168e-01f,
  4.55946401e-02f, -1.03473164e-01f, 3.31811681e-02f, 2.85959635e-02f, 2.00539343e-02f, 5.61746284e-02f, -5.16650081e-02f, 8.70118961e-02f, -4.51324955e-02f, -5.17970026e-02f,
  -5.47803789e-02f, 2.98995208e-02f, 4.11864705e-02f, -8.75444338e-02f, 1.10363699e-01f, -1.18744904e-02f, -7.78137241e-03f, -1.40255895e-02f, -2.05953289e-02f, -7.19186738e-02f,
  -4.03221957e-02f, -6.97131678e-02f, -8.23545158e-02f, -5.61917620e-03f, 5.67698888e-02f, -3.76244560e-02f, 3.25520784e-02f, 3.09710335e-02f, 4.03692939e-05f, -1.04863912e-01f,
  -2.02112198e-02f, -1.49351563e-02f, -4.08164710e-02f, 1.47212036e-02f, -7.77925784e-03f, -4.91469391e-02f, -1.09996580e-01f, -2.88411379e-02f, 3.12455390e-02f, 6.49656281e-02f,
  -1.18940398e-01f, -7.40023516e-03f, -1.05288148e-01f, 2.04975437e-02f, -2.73833349e-02f, -1.16425399e-02f, 7.10482672e-02f, 3.01058162e-02f, 9.28671956e-02f, -5.96276559e-02f,
  -3.03649437e-02f, -8.06502029e-02f, -3.63202430e-02f, -9.03404951e-02f, -2.77399030e-02f, 6.79143611e-03f, -9.42800418e-02f, -2.45902203e-02f, -6.57059252e-02f, -1.01944022e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  -3.96753438e-02f, 6.63042627e-03f, 7.12399110e-02f, -1.82126567e-03f, 1.31297410e-01f, 1.57401428e-01f, 1.06775649e-01f, 9.19735730e-02f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  1.25531733e-01f, 1.68245196e-01f, -1.58056885e-01f, -1.89223409e-01f, -3.75160053e-02f, -9.19359177e-02f, -8.75347331e-02f, 3.90877604e-01f, 2.61883438e-02f, -1.43172428e-01f,
  -1.24684446e-01f, -4.67332862e-02f, -2.76459008e-01f, 3.64060141e-02f, 2.38169253e-01f, -1.67281672e-01f, -2.64822811e-01f, 2.78584510e-01f, 2.45822355e-01f, 2.84699440e-01f,
  1.00337140e-01f, -1.56338513e-01f, -1.50920987e-01f, 1.77241117e-01f, 2.07390830e-01f, 3.07382017e-01f, 2.26702273e-01f, 1.77551895e-01f, -1.55070163e-02f, -2.41376117e-01f,
  -2.72940755e-01f, -6.95464313e-02f, 2.58433014e-01f, -3.07540596e-01f, -1.31726399e-01f, -4.96979952e-02f, -1.00635014e-01f, 9.07319784e-02f, 3.21307741e-02f, -3.40151489e-01f,
  -9.03231204e-02f, 1.34533823e-01f, 5.96876927e-02f, 4.38725576e-02f, 3.02297801e-01f, 9.66666415e-02f, -3.60446572e-01f, 1.11320056e-02f, 3.64634022e-02f, -2.17795238e-01f,
  -1.30435854e-01f, -1.95860475e-01f, -1.70320421e-01f, 3.00529242e-01f, 1.83326513e-01f, 2.36151181e-02f, -1.06465667e-01f, -1.77247539e-01f, 8.95153284e-02f, -1.49411947e-01f,
  1.84258848e-01f, 1.22008622e-01f, -3.51091363e-02f, 8.42274278e-02f, -1.73491344e-01f, -1.25515461e-01f, 4.55701388e-02f, 3.77780125e-02f, -3.91172320e-02f, 4.69725244e-02f,
  -3.04164342e-03f, 1.30692450e-02f, -2.99058139e-01f, 2.52580047e-01f, -1.32917836e-01f, -6.23651631e-02f, 7.80599639e-02f, -1.24900199e-01f, 1.62398294e-02f, 1.78387210e-01f,
  8.21106359e-02f, 1.33595124e-01f, 6.03281707e-02f, -2.26791501e-01f, -2.16406152e-01f, 1.79649629e-02f, -5.54987863e-02f, 7.35199451e-02f, -3.59130323e-01f, -2.67101049e-01f,
  3.07937622e-01f, -5.85432649e-02f, 7.24081397e-02f, -1.38050586e-01f, 2.33264342e-01f, 1.34075075e-01f, -2.07103923e-01f, 1.29660159e-01f, 1.19330071e-01f, -1.31132886e-01f,
  -1.29872710e-01f, -1.20918632e-01f, 1.64373398e-01f, 7.04424977e-02f, -8.17356724e-03f, -1.20256074e-01f, -2.10060820e-01f, 9.79460659e-04f, 1.24578409e-01f, -1.07489996e-01f,
  1.34289384e-01f, 1.63274541e-01f, 6.11106381e-02f, 1.72701403e-01f, -1.34082600e-01f, -2.86985666e-01f, -8.02478269e-02f, -4.60147619e-01f, -3.21649373e-01f, -2.46298522e-01f,
  -6.10075891e-02f, -1.90075651e-01f, 3.40420157e-01f, 1.67657927e-01f, 2.99030364e-01f, 2.13637218e-01f, 2.05230966e-01f, -1.55919120e-01f, 1.07960895e-01f, -1.59055144e-01f,
  -1.76413078e-02f, 2.66645104e-01f, 3.02097291e-01f, -7.50765204e-02f, 1.34071663e-01f, 2.01004818e-01f, 2.61259824e-01f, 2.52519935e-01f, -2.17527524e-01f, 2.43489727e-01f,
  -5.85833907e-01f, 3.13106507e-01f, 3.49322081e-01f, 9.69426855e-02f, -6.03817582e-01f, 2.63359904e-01f, 4.77279752e-01f, 5.05235672e-01f, -4.46608942e-03f, 5.33738196e-01f,
  -3.85866433e-01f, -1.05313480e-01f, -1.52466753e-02f, 2.40231723e-01f, 4.31507640e-02f, 3.55486572e-01f, -7.38875056e-03f, -1.82197988e-01f, -2.20662225e-02f, 1.34860024e-01f,
  -8.36852863e-02f, -2.78812766e-01f, -1.86916322e-01f, 1.19182684e-01f, -2.13094801e-01f, -2.69538820e-01f, -3.34569395e-01f, 3.34801644e-01f, 1.34519339e-01f, -1.05332337e-01f,
  -1.71014100e-01f, 8.45782682e-02f, -1.26070887e-01f, -7.12848455e-02f, 1.75578624e-01f, -7.67119080e-02f, -2.42081925e-01f, 2.00421453e-01f, 2.00070038e-01f, 2.18701527e-01f,
  1.65494278e-01f, 1.17327675e-01f, 5.83060309e-02f, 2.76390851e-01f, 9.45409983e-02f, 1.61724448e-01f, 3.12289357e-01f, 3.95660773e-02f, 1.50387689e-01f, -2.06512678e-02f,
  -2.16284052e-01f, -1.44464523e-01f, 3.35964859e-02f, 2.70801216e-01f, -7.82303065e-02f, 8.14334378e-02f, 2.49291006e-02f, 8.62275250e-03f, 9.56960171e-02f, 1.33698732e-01f,
  -1.48623353e-02f, 1.41578510e-01f, -2.08387580e-02f, -1.54934317e-01f, -5.97630367e-02f, -3.13477606e-01f, 3.35817248e-01f, -3.09674948e-01f, 1.17096588e-01f, 5.29937632e-02f,
  1.48863778e-01f, 1.34343639e-01f, 3.02695721e-01f, -3.31458122e-01f, 6.38294918e-03f, -9.93338004e-02f, -5.96767552e-02f, 1.73598394e-01f, 4.51499857e-02f, 2.46756420e-01f,
  -2.57433236e-01f, 9.19687934e-03f, 3.07264905e-02f, -3.42590883e-02f, -1.47947175e-02f, 3.16107780e-01f, -1.06045371e-02f, -9.23562348e-02f, 9.85901356e-02f, 1.11751579e-01f,
  -4.27052975e-02f, -6.85621724e-02f, 1.42886505e-01f, -4.06395122e-02f, 2.89518863e-01f, 1.63824290e-01f, -3.87094438e-01f, -2.77532399e-01f, 1.19720362e-01f, -5.05620778e-01f,
  -6.70105144e-02f, -2.80358434e-01f, 6.24461658e-02f, 6.09421432e-01f, 1.26524016e-01f, 1.79163702e-02f, 2.42849559e-01f, -1.60296500e-01f, -3.04628253e-01f, -1.19899221e-01f,
  -1.22313075e-01f, 9.43308175e-02f, -2.05308557e-01f, 1.44490361e-01f, 1.62681475e-01f, -3.05856969e-02f, -1.94959298e-01f, -2.71199375e-01f, 6.98339939e-02f, 3.88896884e-03f,
  -1.68354943e-01f, 1.84286878e-01f, 2.65688658e-01f, -1.12681285e-01f, -1.80446446e-01f, 1.56492859e-01f, 4.38485481e-02f, -1.13305867e-01f, 3.25181097e-01f, -5.99138021e-01f,
  -2.10586980e-01f, -2.58375376e-01f, -2.80627012e-02f, -5.54677188e-01f, -4.40756261e-01f, -3.29166502e-01f, 3.91963094e-01f, -4.07729477e-01f, 5.79944849e-01f, 2.28511184e-01f,
  -3.90950054e-01f, -1.45998612e-01f, -2.26131469e-01f, -2.24564239e-01f, 1.00224502e-01f, 1.33000210e-01f, 2.46599555e-01f, -1.72812298e-01f, 2.99838424e-01f, -3.70161422e-02f,
  -1.10871658e-01f, -1.70436159e-01f, -5.95055223e-02f, -2.30920780e-02f, 9.53582898e-02f, -1.07139893e-01f, -1.52916312e-01f, -1.01686835e-01f, 3.72845903e-02f, -8.25187489e-02f,
  8.08276087e-02f, -1.42347813e-01f, -2.42247596e-01f, 1.56866804e-01f, -1.86215699e-01f, 2.12206766e-02f, -5.01951203e-02f, -1.45255387e-01f, -2.07802713e-01f, 2.05729067e-01f,
  -5.21055758e-02f, -1.04541391e-01f, -2.32537031e-01f, 1.64887984e-03f, -1.35786176e-01f, -2.00074583e-01f, 2.22557053e-01f, -9.30885524e-02f, 8.00407380e-02f, -3.21206301e-02f,
  -7.03561381e-02f, -2.56140023e-01f, -2.43346170e-01f, 1.05245328e-02f, 1.38213947e-01f, 2.20190734e-02f, -3.47130716e-01f, -9.09283534e-02f, -5.11263907e-01f, -1.84134096e-01f,
  -2.98069268e-01f, -5.54374419e-03f, 2.22737774e-01f, 1.50906399e-01f, 1.38332263e-01f, 4.51265067e-01f, 2.46124968e-01f, 3.91356051e-01f, 2.18355730e-01f, -2.17075661e-01f,
  -7.56400153e-02f, 1.40750632e-01f, -1.15798853e-01f, 3.43319684e-01f, 1.35523185e-01f, 5.67749105e-02f, 5.16915992e-02f, 1.24405503e-01f, -3.41583043e-01f, -1.18890435e-01f,
  -1.30111203e-01f, 2.93139726e-01f, 9.66975391e-02f, 1.65123776e-01f, 9.97646600e-02f, 3.52166630e-02f, 6.95886165e-02f, -1.77828781e-02f, 1.07869104e-01f, -1.17184438e-01f,
  -1.11880720e-01f, 4.14857082e-02f, 5.28436899e-02f, -9.97814834e-02f, 2.30247840e-01f, 1.20309584e-01f, -3.77474010e-01f, -1.00139476e-01f, 2.90928215e-01f, -2.58217871e-01f,
  -7.59662390e-02f, 1.54323950e-01f, -3.10242265e-01f, 1.83695778e-01f, 4.44033779e-02f, -9.22086760e-02f, -1.86819062e-01f, -3.14671874e-01f, -8.64434391e-02f, -3.12661052e-01f,
  -2.97638457e-02f, -1.46251097e-01f, 1.06469065e-01f, -2.14590430e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  3.34078044e-01f, -1.28120333e-01f, 1.88922025e-02f, 2.14112282e-01f, 1.41250968e-01f, 1.78132191e-01f, 1.67148620e-01f, -4.64839935e-02f, -2.76342109e-02f, 1.41169384e-01f,
  8.57453570e-02f, 1.44690529e-01f, 1.19293906e-01f, 1.69611603e-01f, -3.11999202e-01f, 2.46852309e-01f, 6.40133768e-02f, 1.10526448e-02f, -2.17647970e-01f, -1.17869109e-01f,
  -2.54484206e-01f, 7.84159359e-03f, -1.27219871e-01f, -1.33324444e-01f, 5.55716082e-02f, -2.44974300e-01f, -7.87576512e-02f, -6.90497532e-02f, 2.36505136e-01f, 1.10420041e-01f,
  2.57990748e-01f, 1.00016236e-01f, -1.86991036e-01f, 3.11932750e-02f, 3.60059086e-03f, -1.46675512e-01f, -1.19817756e-01f, -5.91223873e-02f, -8.46561417e-03f, -1.06555879e-01f,
  4.58217971e-02f, 3.39891836e-02f, 1.84483547e-02f, -1.07194431e-01f, -8.45209435e-02f, -2.09917184e-02f, -8.54011923e-02f, 2.10577801e-01f, -1.28472513e-02f, -1.70225009e-01f,
  -1.28388330e-01f, -1.22593299e-01f, 2.08644554e-01f, -1.83980107e-01f, -7.42193358e-03f, 2.50997674e-02f, 6.84010237e-02f, 1.17476620e-02f, 2.44038224e-01f, -1.42827556e-01f,
  -1.14520229e-01f, 5.65949306e-02f, -7.46401921e-02f, -5.49840480e-02f, 1.18403561e-01f, -8.04886296e-02f, 1.57705307e-01f, -1.57348573e-01f, -1.95504263e-01f, 4.88192514e-02f,
  -6.07731976e-02f, -7.50158876e-02f, -3.34512442e-02f, 2.07694948e-01f, 5.80106452e-02f, 7.27864727e-02f, -2.25619748e-01f, 2.90173978e-01f, -1.49283990e-01f, 9.61694494e-03f,
  7.92646334e-02f, -1.42174169e-01f, -5.72421849e-02f, 2.60589838e-01f, 1.69792160e-01f, 1.56359062e-01f, -8.11875612e-02f, -4.51838374e-02f, 3.11144233e-01f, 1.71991631e-01f,
  -9.53134075e-02f, 5.64584173e-02f, 3.26743186e-01f, -6.26289323e-02f, 1.85963791e-02f, -1.61784992e-01f, -1.40084270e-02f, 6.09194823e-02f, 7.99900517e-02f, -1.09215342e-01f,
  7.30682015e-02f, -1.33456476e-02f, 4.38533984e-02f, 1.36616856e-01f, -3.45789231e-02f, -8.87129158e-02f, 5.67588285e-02f, -1.34843215e-01f, 9.85517129e-02f, -2.30887517e-01f,
  -1.87749024e-02f, -1.02558024e-01f, 1.13145955e-01f, -2.39844620e-01f, -6.57353699e-02f, 1.73167944e-01f, -7.28066415e-02f, -1.23632662e-01f, 1.24555141e-01f, 2.26320490e-01f,
  9.03258380e-03f, -1.87237725e-01f, -1.48492008e-01f, 9.94958100e-04f, 1.32248789e-01f, 1.73369691e-01f, -6.47539720e-02f, 1.75869148e-02f, -3.75100523e-02f, -6.57397555e-03f,
  2.09677424e-02f, -4.72665504e-02f, -1.05005447e-02f, -1.27697483e-01f, 1.06380903e-03f, 7.05159605e-02f, -2.07429394e-01f, 1.81495249e-01f, 9.18435529e-02f, 2.61985451e-01f,
  1.28890067e-01f, 1.81299110e-03f, 1.07470639e-01f, 2.61084557e-01f, -8.82006586e-02f, 1.69717163e-01f, 1.97887391e-01f, -1.47723496e-01f, -2.12308496e-01f, 1.45795479e-01f,
  -1.73016973e-02f, 1.20693989e-01f, -1.23862334e-01f, 5.54231219e-02f, 4.15419675e-02f, 3.02042924e-02f, -1.37497231e-01f, -6.89058602e-02f, 7.54575245e-04f, 1.86382920e-01f,
  9.00688861e-03f, 3.87309164e-01f, 2.86925554e-01f, -5.26033528e-02f, -1.03580989e-01f, 1.86093912e-01f, -7.65602961e-02f, -1.59420520e-01f, -1.30513012e-01f, 4.36116233e-02f,
  -1.26556098e-01f, 1.10719502e-01f, 3.30941439e-01f, -2.14013800e-01f, 1.71221837e-01f, 2.18847897e-02f, 2.58922398e-01f, -2.38546088e-01f, -2.78845280e-01f, -2.11422563e-01f,
  3.19829851e-01f, -4.96877849e-01f, 2.41937771e-01f, 4.27829057e-01f, -1.70204297e-01f, -2.35745132e-01f, 4.09616113e-01f, -3.29291910e-01f, -1.73496734e-02f, 5.89253940e-02f,
  1.67880561e-02f, 2.54430532e-01f, 1.15845196e-01f, -2.34284222e-01f, -1.84443295e-01f, 2.07988396e-01f, 1.00005165e-01f, -3.61643359e-02f, -4.42090668e-02f, 1.25913680e-01f,
  1.65937364e-01f, 3.16472054e-01f, 2.40669712e-01f, 2.68516183e-01f, 9.04833674e-02f, 5.02268493e-01f, 1.45446602e-02f, -2.19844460e-01f, 3.74315381e-02f, -1.21925354e-01f,
  1.17808305e-01f, -1.41930789e-01f, 4.02318090e-02f, 2.19283447e-01f, 2.37711594e-01f, 3.16053957e-01f, 6.10835493e-01f, 4.65819806e-01f, -2.14232609e-01f, 1.40168026e-01f,
  -3.00046150e-02f, 2.94830233e-01f, 1.31613724e-02f, 2.78316587e-01f, 1.84998885e-01f, -4.45482850e-01f, 9.80939567e-02f, 1.24748230e-01f, 7.89184272e-02f, 2.39911452e-01f,
  2.10347459e-01f, -1.71226352e-01f, 4.77196723e-02f, 2.31806651e-01f, 8.91996250e-02f, 1.99720979e-01f, -8.02420005e-02f, -5.63156426e-01f, -7.96773732e-02f, -3.21134418e-01f,
  3.40207852e-02f, -3.89043659e-01f, -1.41235262e-01f, 3.27786326e-01f, 4.18115079e-01f, 3.53100359e-01f, 5.28600752e-01f, 3.37855875e-01f, -2.87237555e-01f, -1.42140180e-01f,
  -1.10921524e-01f, -6.56238794e-02f, -1.50990501e-01f, 1.29207253e-01f, 1.14617012e-01f, -4.48380746e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  2.80895740e-01f, 7.17006847e-02f, 6.37941062e-02f, -2.25519412e-03f, 8.73001292e-03f, 2.26228803e-01f, 1.35462448e-01f, 2.21450359e-01f
};

// L2_fan_Wp (Shape: 12 x 32)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -3.99829090e-01f, 1.27169535e-01f, -1.42862707e-01f, 1.09500244e-01f, 7.15789422e-02f, -1.07687198e-01f, -1.09812960e-01f, -1.53664658e-02f, -3.21323991e-01f, -4.76009622e-02f,
  5.13734929e-02f, -1.11052506e-01f, 4.07003194e-01f, -6.07568510e-02f, -2.20374510e-01f, -1.02347076e-01f, 1.91525053e-02f, 3.50578785e-01f, -2.31708989e-01f, -4.21128049e-02f,
  1.99214518e-01f, 3.03091444e-02f, 2.14539304e-01f, -8.21556896e-02f, -2.22846597e-01f, -8.38375301e-04f, 1.80504531e-01f, 1.56224892e-01f, 4.41167504e-02f, -1.27733663e-01f,
  2.40583569e-01f, 8.97871777e-02f, -1.63237616e-01f, 1.21515222e-01f, -1.44237891e-01f, 1.93239357e-02f, -2.26975143e-01f, 3.95352952e-02f, -8.55828822e-02f, 2.46513173e-01f,
  3.47344205e-02f, 3.35829370e-02f, -1.62295699e-01f, -2.44830884e-02f, 3.71877789e-01f, -1.08426753e-02f, -2.31313482e-01f, -1.58977628e-01f, 4.16612625e-01f, 1.80299729e-01f,
  -9.44252387e-02f, 1.98088557e-01f, -4.41248536e-01f, -3.35865989e-02f, -1.96300969e-01f, -1.58600703e-01f, 2.29136813e-02f, 1.92632582e-02f, 2.85819978e-01f, -1.48551231e-02f,
  -1.63786650e-01f, -4.08140182e-01f, 1.95990875e-01f, -2.52370596e-01f, -2.04708442e-01f, -3.27890784e-01f, -6.42347112e-02f, -1.06348675e-02f, 1.26627356e-01f, -2.60439426e-01f,
  -2.04477027e-01f, -2.83412695e-01f, -2.38262534e-01f, 8.07178169e-02f, -3.50441962e-01f, -2.07006425e-01f, -3.47380251e-01f, 1.64795950e-01f, 2.59681523e-01f, -1.14188142e-01f,
  -6.20701551e-01f, -2.51413345e-01f, -2.07147114e-02f, 9.57484916e-02f, 4.70575213e-01f, 2.44560391e-01f, -7.86664039e-02f, 3.85487616e-01f, 3.46843749e-02f, 1.90015743e-03f,
  4.86423224e-02f, 2.39301518e-01f, 1.10336728e-01f, 3.49808633e-01f, -2.81301469e-01f, 2.11419433e-01f, 3.27705353e-01f, -5.76446205e-02f, 2.66379058e-01f, -3.38663876e-01f,
  7.25888908e-02f, 1.03147089e-01f, -7.14320466e-02f, -2.11917192e-01f, 1.41034216e-01f, -1.95568636e-01f, -3.30907732e-01f, -1.32555053e-01f, -4.41228777e-01f, 4.04968977e-01f,
  -1.99519798e-01f, 9.44601744e-02f, 4.01598252e-02f, -3.03601295e-01f, -9.66302752e-02f, -1.05623424e-01f, 9.90821645e-02f, 7.37379789e-02f, -3.78405720e-01f, 5.01692772e-01f,
  1.48591429e-01f, -2.43434295e-01f, 5.32940812e-02f, 2.40867421e-01f, -1.37350351e-01f, 2.35969014e-02f, -1.61573946e-01f, 3.30766976e-01f, -2.08142966e-01f, 8.94880518e-02f,
  -1.98340163e-01f, 2.90602893e-01f, -1.71644300e-01f, 2.22956553e-01f, -1.10861868e-01f, -1.13781147e-01f, 1.39734626e-01f, -6.15763888e-02f, 1.47726715e-01f, 9.58593264e-02f,
  7.98844695e-02f, 2.47664452e-01f, -4.32272069e-03f, 1.08902171e-01f, 4.31277186e-01f, 2.45514527e-01f, -3.61668974e-01f, -3.66934627e-01f, -4.07188296e-01f, -7.92128518e-02f,
  5.58277182e-02f, -1.49132028e-01f, 5.59014566e-02f, 1.11338407e-01f, 2.54908592e-01f, -2.55080879e-01f, -1.16147406e-01f, -3.88497204e-01f, 4.38281715e-01f, -4.25113708e-01f,
  -3.48284066e-01f, -1.79668844e-01f, -2.02918947e-01f, 1.29930705e-01f, 4.26087320e-01f, -2.29895398e-01f, -7.36742765e-02f, -1.22328825e-01f, -7.13489056e-02f, -7.39628524e-02f,
  2.08641559e-01f, -1.97034627e-01f, 6.34077042e-02f, 3.09202641e-01f, 1.48821801e-01f, 9.20944512e-02f, -3.52684796e-01f, 2.24485382e-01f, -1.57862291e-01f, -3.54311466e-01f,
  2.42099866e-01f, -3.48105989e-02f, 5.05112708e-01f, 1.83418766e-03f, 6.65296689e-02f, 8.66363011e-03f, -9.47104990e-02f, 4.07390706e-02f, -7.97901675e-02f, 4.69275773e-01f,
  6.66502640e-02f, 1.19147427e-01f, 2.41477266e-01f, 7.05463886e-02f, 1.77851990e-02f, -1.44678265e-01f, -1.18024535e-01f, -7.05327317e-02f, -8.13684613e-02f, 1.68695033e-01f,
  1.11415148e-01f, -1.59242973e-01f, -2.22179934e-01f, -1.31758377e-01f, 2.22000107e-01f, -1.39148667e-01f, -2.96183079e-01f, 2.56247729e-01f, 2.88453579e-01f, -2.80305803e-01f,
  3.15670893e-02f, 2.34954536e-01f, -6.49924040e-01f, -6.16303049e-02f, -3.35847884e-01f, -1.76571041e-01f, -4.03373167e-02f, -4.09018621e-02f, 6.78006634e-02f, 7.99575076e-02f,
  -1.90752968e-01f, -3.15161616e-01f, 1.31310120e-01f, -3.97674024e-01f, -4.13435370e-01f, 9.45700184e-02f, -9.63267162e-02f, 1.54098831e-02f, -3.53833288e-02f, -9.03203115e-02f,
  -2.43800610e-01f, 1.71105593e-01f, -3.94143701e-01f, -1.66948959e-01f, 1.50242820e-01f, -3.02663177e-01f, 3.24612468e-01f, -5.54609783e-02f, 1.75502989e-02f, 1.13534562e-01f,
  -2.31157690e-01f, 4.18374479e-01f, 1.86475247e-01f, -1.86575085e-01f, 4.17461514e-01f, -1.72061533e-01f, 1.04661047e-01f, -3.16333473e-01f, -3.48079562e-01f, 1.16898026e-02f,
  3.48794390e-03f, 9.64574143e-02f, 8.23233947e-02f, 1.85309291e-01f, 4.29259725e-02f, -1.00758471e-01f, -1.77841827e-01f, 4.28050309e-02f, 5.64001463e-02f, 1.02192558e-01f,
  2.67241091e-01f, -2.58001149e-01f, 2.14937739e-02f, -1.35911420e-01f, -5.85418046e-02f, 1.01448216e-01f, -1.26881108e-01f, 1.70124739e-01f, -3.58351827e-01f, 5.99559024e-02f,
  2.68332303e-01f, -2.26570368e-01f, -2.66722649e-01f, -2.30264977e-01f, -2.77942300e-01f, -9.13911611e-02f, 3.07289034e-01f, -8.99927970e-03f, 3.42946917e-01f, 5.62191755e-02f,
  1.12437584e-01f, 1.51208162e-01f, -1.75805211e-01f, -1.60633475e-01f, 1.12807214e-01f, 3.97760600e-01f, 4.84868512e-02f, 2.59565681e-01f, 2.17707492e-02f, -5.41286990e-02f,
  -2.37684231e-02f, 2.59300977e-01f, -5.48865926e-03f, -7.54077435e-02f, -2.40773261e-01f, -1.05048493e-01f, -6.59145117e-02f, -2.92509776e-02f, -2.20545921e-02f, 4.61819172e-02f,
  -1.15586594e-01f, 1.62653327e-01f, 1.40736282e-01f, 3.05529505e-01f, -4.37388718e-01f, -3.34682703e-01f, -1.90653145e-01f, -3.86768460e-01f, -2.86108796e-02f, 1.18994556e-01f,
  1.71672791e-01f, -8.14987719e-02f, 2.96521455e-01f, 1.44348741e-01f, -6.54865464e-04f, -1.18204176e-01f, 1.80395380e-01f, 2.33160943e-01f, -3.73933613e-01f, -5.29419124e-01f,
  5.91778904e-02f, -1.42095968e-01f, -7.20311031e-02f, 5.09349108e-02f, -2.48019189e-01f, -8.38126466e-02f, -1.91454157e-01f, 1.40326589e-01f, 1.62449524e-01f, -1.10086598e-01f,
  -9.49759111e-02f, -2.59951944e-03f, 9.89734679e-02f, -1.05317747e-02f, 7.26484656e-02f, 4.21700507e-01f, -1.79006048e-02f, -1.21784955e-01f, 1.39798895e-01f, -1.43558607e-01f,
  -4.53968734e-01f, 1.45310655e-01f, -1.85995713e-01f, -2.51506362e-02f, 9.09073353e-02f, 4.68288809e-02f, -6.03617951e-02f, -4.91841957e-02f, -1.73038449e-02f, -6.13872521e-02f,
  -6.54619560e-02f, -6.21622086e-01f, -2.34104604e-01f, 1.65831298e-01f, -1.12051681e-01f, 2.44892091e-01f, 1.82865098e-01f, 1.69561431e-01f, 1.48727596e-01f, 2.46783808e-01f,
  -1.25116751e-01f, -1.84479468e-02f, 3.95246118e-01f, -8.85683000e-02f, 1.64970338e-01f, -1.46912202e-01f, 6.14918247e-02f, 9.09263268e-02f, -2.94173181e-01f, 3.09188157e-01f,
  2.00725123e-01f, -2.61917830e-01f, 2.31357545e-01f, -2.71788388e-01f, 5.56340754e-01f, -1.96341261e-01f, -3.32340039e-02f, 1.73678920e-01f, -1.73634723e-01f, -3.31474468e-02f,
  2.19860911e-01f, 5.57874262e-01f, 1.72065005e-01f, 9.91400704e-02f
};

// L2_fan_Wp_bar (Shape: 8 x 32)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  1.62788630e-01f, 5.71587346e-02f, -1.62762165e-01f, 3.16668153e-02f, 7.18700439e-02f, 1.59437377e-02f, -1.79718230e-02f, -2.73801219e-02f, 2.44486094e-01f, -3.78345959e-02f,
  -1.57218620e-01f, 1.44963153e-02f, -1.86048418e-01f, 1.18192747e-01f, 3.88838835e-02f, -4.04126905e-02f, 2.46171966e-01f, -9.47038010e-02f, -1.56712234e-01f, -7.99077898e-02f,
  -1.65826768e-01f, 4.50877734e-02f, 2.90177166e-02f, -1.74553871e-01f, -8.36279392e-02f, -7.70253167e-02f, -9.08857435e-02f, -8.38163272e-02f, 9.02993046e-03f, -1.29733145e-01f,
  3.37623417e-01f, -9.26994756e-02f, 3.45109910e-01f, 1.62442565e-01f, 2.02676594e-01f, 4.90265004e-02f, -3.32980365e-01f, 4.09204245e-01f, 8.60989019e-02f, 4.53025550e-01f,
  -5.89781404e-02f, 1.58934489e-01f, 5.15798591e-02f, 4.24275458e-01f, 4.22028750e-01f, -5.00676811e-01f, 7.05577508e-02f, 2.90316284e-01f, 1.77236386e-02f, 1.07971892e-01f,
  5.58650970e-01f, 4.04105991e-01f, -2.36393034e-01f, -4.91168588e-01f, -3.91195238e-01f, -5.03063858e-01f, -3.51022005e-01f, 1.39739260e-01f, -1.89220637e-01f, 1.26287609e-01f,
  -9.54990909e-02f, 4.49592292e-01f, -1.25957161e-01f, 9.83078852e-02f, 2.32191429e-01f, 1.87384710e-01f, 1.95915326e-01f, -9.69844311e-02f, 1.56015962e-01f, -3.29102688e-02f,
  1.32696375e-01f, 1.46742649e-02f, 2.69905329e-01f, 7.03132376e-02f, 7.70737082e-02f, 1.02708317e-01f, -2.04265174e-02f, 3.50300580e-01f, -4.03688610e-01f, -2.56646812e-01f,
  6.67148471e-01f, -2.69687861e-01f, 3.80456932e-02f, 8.82819146e-02f, -4.42426831e-01f, 6.55383244e-02f, -3.78744304e-02f, -2.41663024e-01f, 2.71472096e-01f, 3.00207846e-02f,
  -5.03421724e-02f, 4.39213179e-02f, 3.00912187e-02f, -3.91231596e-01f, 4.60587829e-01f, 2.83118218e-01f, -7.37725049e-02f, 3.59971583e-01f, -2.79403180e-01f, 2.60013621e-02f,
  -1.82892352e-01f, -8.84242728e-02f, 1.95886999e-01f, 2.61203319e-01f, 1.39514714e-01f, 2.09694073e-01f, 2.83967927e-02f, -1.75744697e-01f, 3.81798357e-01f, -2.16462523e-01f,
  -4.91807252e-01f, -3.71671796e-01f, 4.09100920e-01f, -3.72794084e-02f, 1.75463319e-01f, 2.36847736e-02f, -5.09310961e-01f, -4.42463666e-01f, -2.18027487e-01f, -4.15512711e-01f,
  -1.45106092e-01f, -8.65015760e-02f, 3.25492144e-01f, -9.14886147e-02f, -1.80323571e-01f, -5.96371964e-02f, 7.60592759e-01f, -2.49127045e-01f, 1.04868389e-03f, 2.35031135e-02f,
  2.05767080e-01f, 1.32848293e-01f, -3.42982590e-01f, 1.58155393e-02f, -4.43413630e-02f, -4.96325418e-02f, 5.80460439e-03f, 9.42031592e-02f, -2.62504101e-01f, 2.35874131e-01f,
  1.10046051e-01f, -1.77688763e-01f, -8.47999305e-02f, 2.18139470e-01f, 2.41299734e-01f, -2.24321663e-01f, 9.25830975e-02f, 3.01590532e-01f, -3.61675560e-01f, -9.84617025e-02f,
  -2.38721892e-01f, -3.08836043e-01f, -6.80276304e-02f, -3.70634161e-02f, -1.31642623e-02f, -1.01200797e-01f, -1.91822916e-01f, -1.72860995e-01f, -4.41819848e-03f, 7.54868090e-02f,
  2.09259570e-01f, 2.99245805e-01f, 4.26450104e-01f, 1.19830526e-01f, 7.36486539e-02f, 3.71135741e-01f, 3.07624102e-01f, 3.19177270e-01f, 4.08401806e-03f, 1.96380883e-01f,
  3.80857199e-01f, 1.48164287e-01f, 5.11967428e-02f, -5.79640605e-02f, 5.41020095e-01f, 5.69871843e-01f, -1.09192841e-02f, -1.96123123e-01f, -1.50972679e-01f, -5.24631441e-01f,
  -1.71538129e-01f, 1.93844497e-01f, -1.11280516e-01f, -3.05257708e-01f, 4.53886211e-01f, -5.78284785e-02f, -1.95033595e-01f, -2.37704396e-01f, 1.80375025e-01f, -2.46661529e-02f,
  -7.25734159e-02f, -5.28512239e-01f, 2.93410510e-01f, -9.20964256e-02f, -5.98963816e-03f, -2.68439911e-02f, 1.68893207e-02f, 1.40045270e-01f, -1.77321672e-01f, 1.15655497e-01f,
  -8.86289054e-04f, 2.13765293e-01f, -1.01873450e-01f, 1.94493964e-01f, 2.31511489e-01f, 2.24436820e-01f, 1.48289829e-01f, 1.69973150e-01f, 2.55619258e-01f, 3.24141622e-01f,
  -1.82494238e-01f, -1.24746868e-02f, 6.63705841e-02f, 2.33334199e-01f, -4.20121580e-01f, -2.63981014e-01f, 1.75940678e-01f, -1.92132175e-01f, 1.78040519e-01f, -1.36247754e-01f,
  4.82049547e-02f, -2.69168198e-01f, -2.90013421e-02f, 5.31386077e-01f, 1.51034504e-01f, 2.34973535e-01f, 2.60218140e-02f, -4.98073772e-02f, -9.33454856e-02f, -4.15615970e-03f,
  -2.32570171e-02f, -9.09146294e-02f, 2.02988520e-01f, 1.46174043e-01f, 1.21711604e-01f, -6.57802001e-02f, 1.08619072e-02f, 2.69984812e-01f, -1.55770734e-01f, 3.81159075e-02f,
  2.63075829e-01f, 8.77663344e-02f, -8.58062580e-02f, -1.22194141e-01f, 7.01492056e-02f, -2.08162740e-02f, 1.03839807e-01f, -1.48046181e-01f, -9.40857828e-02f, -7.15486705e-02f,
  -1.19047001e-01f, -8.01486522e-02f, 8.20323676e-02f, -1.03779092e-01f, 2.97302663e-01f, 2.11869609e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  3.37117352e-02f, 1.58768997e-01f, 1.58063829e-01f, 2.31517956e-01f, 1.50249869e-01f, 2.51435071e-01f, 1.41592637e-01f, 8.92272517e-02f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -6.23042166e-01f, 1.74594335e-02f, -4.37375724e-01f, -6.75398409e-01f, -7.65102357e-02f, 3.10405165e-01f, 2.66000897e-01f, -3.49705428e-01f, 2.78815031e-01f, -8.31129998e-02f,
  6.06359579e-02f, -6.17340267e-01f, 3.76533657e-01f, 6.13387764e-01f, -4.42316145e-01f, -3.77210647e-01f, 3.63715976e-01f, 5.17907560e-01f, -1.56611465e-02f, 7.32323945e-01f,
  -3.95026237e-01f, -8.14760402e-02f, -1.40793249e-01f, 9.73297805e-02f, -1.86955601e-01f, -3.90616238e-01f, -7.88891688e-02f, 8.35961223e-01f, -8.24205112e-03f, -2.74507850e-01f,
  -3.70000839e-01f, 8.67213160e-02f, 3.70123327e-01f, 4.90701824e-01f, -2.27478668e-01f, -1.98339701e-01f, 2.70840138e-01f, 2.16279458e-02f, 1.60649881e-01f, 3.10598999e-01f,
  3.99014473e-01f, 4.44993168e-01f, 3.67113113e-01f, -3.78173620e-01f, 1.05439402e-01f, -1.22778304e-01f, -4.99972701e-01f, -7.13273942e-01f, 2.94917196e-01f, 1.60557479e-02f,
  -2.59556532e-01f, 3.11770409e-01f, -5.65275960e-02f, 2.18887076e-01f, 1.56794507e-02f, 6.61982894e-01f, -1.18950866e-01f, 4.35553968e-01f, -4.07057583e-01f, -4.64451879e-01f,
  -2.14296460e-01f, 6.28988504e-01f, 3.69310677e-02f, 6.15547374e-02f, 7.43069733e-03f, 2.62648433e-01f, 8.46774280e-02f, 1.44743890e-01f, 7.82032013e-01f, -6.10816419e-01f,
  3.56578141e-01f, -5.64594209e-01f, 2.07829431e-01f, -2.57553697e-01f, 8.43093991e-02f, 1.17466211e-01f, -3.25075269e-01f, 4.63314414e-01f, -6.22623682e-01f, 3.19190949e-01f,
  1.68470200e-02f, -2.05086440e-01f, 5.99524975e-01f, 7.58154020e-02f, -7.60600194e-02f, -4.21309769e-01f, -5.65315008e-01f, -5.47815859e-01f, 3.26153748e-02f, 1.15809096e-02f,
  5.17855823e-01f, 2.95884311e-01f, 3.56995106e-01f, -6.76632047e-01f, -3.25121194e-01f, 5.78722656e-02f, 1.54611245e-01f, 2.11872727e-01f, -3.85005146e-01f, 4.70544845e-01f,
  -8.62266347e-02f, 5.01854897e-01f, 1.23144016e-01f, 1.00016639e-01f, -5.23503534e-02f, 1.82738749e-03f, 8.39504451e-02f, -2.90510237e-01f, 2.03260437e-01f, 4.61272150e-01f,
  3.05526525e-01f, -1.02076598e-01f, 1.46122351e-01f, 2.97083557e-01f, 1.94208503e-01f, -4.01886672e-01f, 1.82659313e-01f, -5.04067689e-02f, -2.85225868e-01f, 3.23148191e-01f,
  2.57889986e-01f, -4.89926815e-01f, 7.63369679e-01f, 3.08871120e-01f, -4.08918291e-01f, 1.35568008e-01f, -1.94426581e-01f, 4.43658501e-01f, -1.94951057e-01f, -4.62729901e-01f,
  -3.66538703e-01f, -2.20124230e-01f, -2.74782956e-01f, -3.20642918e-01f, -4.83002424e-01f, 2.80293465e-01f, -2.69095004e-01f, -2.76215017e-01f, 1.13003016e-01f, 3.54558647e-01f,
  4.39106643e-01f, -5.39933145e-02f, 8.53157565e-02f, -4.05128717e-01f, 2.86191642e-01f, -2.06104636e-01f, 1.66241422e-01f, 1.50956407e-01f, -2.71694362e-01f, 1.36016205e-01f,
  6.19451553e-02f, 6.26848340e-02f, 1.20544285e-01f, 2.26973832e-01f, 1.96165115e-01f, 8.18555474e-01f, 1.01978406e-01f, -4.01759595e-01f, 4.01967391e-03f, -8.90964121e-02f,
  -2.71295458e-01f, 4.57950905e-02f, -3.00626129e-01f, 4.36982125e-01f, 3.01327854e-01f, -5.85181355e-01f, -3.58099282e-01f, -3.52242240e-03f, -2.23968044e-01f, 6.29014254e-01f,
  1.20440193e-01f, 2.34218776e-01f, -2.98667610e-01f, 1.48172662e-01f, -1.65295854e-01f, -3.53309423e-01f, 1.52955815e-01f, -3.60622257e-01f, 5.54587841e-01f, -7.04035908e-02f,
  -3.76081765e-01f, -1.26669049e-01f, 5.93710661e-01f, -7.07581863e-02f, -2.17328385e-01f, 5.41375399e-01f, 3.03101446e-02f, 1.33328527e-01f, 4.62557197e-01f, 2.31182203e-01f,
  -1.38578992e-02f, -2.32449487e-01f, 2.65598834e-01f, 5.98460361e-02f, 2.55108029e-01f, -9.22184289e-01f, -3.33370537e-01f, 3.73501778e-01f, -2.40209326e-01f, -2.11204514e-01f,
  -8.43759626e-02f, -6.92686081e-01f, -6.46906972e-01f, 5.26043117e-01f, -1.86919242e-01f, -6.38079345e-01f, 5.75741172e-01f, 1.17456645e-01f, -3.18850219e-01f, -3.57179008e-02f,
  -5.26766717e-01f, -1.56941250e-01f, 3.36309582e-01f, -5.02472401e-01f, 3.13402385e-01f, -1.52409390e-01f, 5.07684462e-02f, -2.63461590e-01f, 2.98605978e-01f, -5.54555714e-01f,
  -2.05592126e-01f, -2.34267667e-01f, 2.96409041e-01f, -1.70822680e-01f, 1.43133864e-01f, -7.78212368e-01f, 1.09696962e-01f, 3.95331472e-01f, 3.82836498e-02f, -3.60618472e-01f,
  -5.60533404e-01f, 3.09477538e-01f, -8.79836380e-01f, 4.34614301e-01f, -3.67026702e-02f, -7.04003811e-01f, -3.25725466e-01f, -1.76898435e-01f, 7.63105690e-01f, 1.78667326e-02f,
  -4.49987203e-01f, 8.33522737e-01f, -1.06152721e-01f, 2.86511034e-02f, -1.06095493e-01f, 3.80109221e-01f, -3.71710330e-01f, -6.99744821e-02f, -1.84089497e-01f, 1.59203485e-01f,
  -1.05213612e-01f, -1.25292256e-01f, -2.27860078e-01f, 1.97647020e-01f, -2.84247726e-01f, -1.49964616e-01f, -1.51284114e-01f, -2.23354056e-01f, 4.02338415e-01f, 3.08832496e-01f,
  4.23613429e-01f, 4.22991365e-01f, 1.88882232e-01f, -2.30501145e-01f, -1.40652105e-01f, 7.39104301e-02f, 5.93511462e-01f, 4.45924968e-01f, -2.56001830e-01f, -5.09679556e-01f,
  2.78984189e-01f, 4.82616097e-01f, -3.10244799e-01f, 3.69003594e-01f, -5.16579807e-01f, -2.65232295e-01f, 6.72650754e-01f, 5.74266136e-01f, 4.61461455e-01f, 6.91541806e-02f,
  -1.02908388e-01f, -5.60655296e-01f, -3.69847983e-01f, -4.52408552e-01f, -2.10994124e-01f, 6.39223874e-01f, -2.00172693e-01f, -4.18192148e-02f, 1.05518498e-01f, 3.24757725e-01f,
  6.45687163e-01f, 9.80996639e-02f, 1.67652503e-01f, -3.28982472e-01f, 2.12767258e-01f, 4.44012992e-02f, 4.62410361e-01f, -5.21246970e-01f, -7.83143163e-01f, 3.17763001e-01f,
  2.10236147e-01f, -9.48336273e-02f, -5.53807259e-01f, 4.38221484e-01f, -7.19564676e-01f, -3.90596211e-01f, -3.92302722e-01f, -4.34493534e-02f, 9.57287177e-02f, 1.89148620e-01f,
  -8.30571055e-02f, -4.52115387e-02f, -1.22961715e-01f, 3.44950408e-01f, 2.10955694e-01f, -1.01349033e-01f, 1.76968828e-01f, -5.63527644e-01f, 4.92239952e-01f, 2.11498573e-01f,
  3.13687958e-02f, 3.78699481e-01f, 1.09119453e-01f, 2.20197946e-01f, -4.98565435e-01f, 1.50235906e-01f, 3.12002808e-01f, -1.78983226e-01f, 1.13641150e-01f, 1.55482695e-01f,
  2.00299174e-01f, 1.58404410e-01f, 5.11432998e-04f, 2.70509630e-01f, -3.27110857e-01f, 5.00116408e-01f, 6.74652815e-01f, -2.75524855e-01f, 3.03579539e-01f, -2.11329944e-02f,
  -1.15229122e-01f, 5.14783621e-01f, 4.15162057e-01f, -7.57181168e-01f, 6.61821887e-02f, -7.67600834e-01f, 1.11336172e-01f, -3.90441179e-01f, 2.59734243e-02f, 4.98215050e-01f,
  5.47279179e-01f, 7.81557858e-02f, 1.29822250e-02f, -2.33797297e-01f, 3.53905141e-01f, -1.83292314e-01f, -3.67181242e-01f, 5.82455575e-01f, 3.15136574e-02f, 3.94472569e-01f,
  8.21526423e-02f, 2.15883017e-01f, -4.31265026e-01f, -1.48105010e-01f, 2.49166712e-02f, -3.34462881e-01f, 4.95137364e-01f, 4.96376514e-01f, -8.15182254e-02f, 9.46149752e-02f,
  -4.82413113e-01f, 1.13348141e-02f, 2.99759746e-01f, -6.39317095e-01f, -4.16501224e-01f, 4.89488870e-01f, -7.26550147e-02f, 9.39256489e-01f, -5.99932194e-01f, -2.33334661e-01f,
  -3.97444740e-02f, -4.12679076e-01f, -1.04496315e-01f, -5.98145463e-02f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  7.17452168e-02f, -1.13654532e-01f, 1.52731702e-01f, -2.18537912e-01f, -1.19000852e-01f, -4.78107482e-02f, 3.69762152e-01f, -3.71579491e-02f, -2.43385080e-02f, 2.35497002e-02f,
  1.11447923e-01f, -5.32857105e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    