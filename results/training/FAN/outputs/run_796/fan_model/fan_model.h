/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  5.09569585e-01f, -4.11124349e-01f, -7.75258169e-02f, -2.40832478e-01f, -3.30710746e-02f, 2.67803907e-01f, 1.26671150e-01f, 8.87610689e-02f, 1.27000362e-01f, -1.20014451e-01f,
  -1.36577949e-01f, 5.55173494e-02f, -3.91365588e-02f, 3.89303006e-02f, 2.23600745e-01f, -1.09697022e-01f, -1.93142503e-01f, 8.05608276e-03f, 4.37078059e-01f, 1.25928923e-01f,
  -1.16755292e-01f, -3.73339988e-02f, -2.06407961e-02f, -6.25344831e-03f, -2.86151558e-01f, 1.57878518e-01f, -1.31233960e-01f, -7.36602768e-02f, 2.69592553e-02f, -5.36570072e-01f,
  -8.81693214e-02f, -2.31460214e-01f, 1.23947702e-01f, -3.79514433e-02f, -1.27752095e-01f, 9.39761400e-02f, 4.07859273e-02f, -1.25900611e-01f, -1.25599448e-02f, -2.30712667e-02f,
  -4.54757586e-02f, -1.46517798e-01f, -9.57942754e-02f, -9.02298018e-02f, -8.85276217e-03f, 4.76541370e-02f, 6.79297047e-03f, 1.11064231e-02f, 2.42469404e-02f, 4.92371954e-02f,
  -1.21175840e-01f, -7.75600746e-02f, 4.31396365e-02f, -2.55929003e-03f, 3.28079201e-02f, 2.93080043e-02f, -9.92540494e-02f, -1.20381797e-02f, 1.42632544e-01f, -8.02636147e-02f,
  4.70318571e-02f, -2.79701594e-02f, 8.68535414e-02f, -4.65883389e-02f, 2.10433491e-02f, 6.13267627e-03f, -7.76352286e-02f, 2.53718589e-02f, -2.43794695e-02f, 1.83030907e-02f,
  2.58810669e-02f, 3.36378552e-02f, -1.25122471e-02f, 4.48901206e-02f, -2.28937212e-02f, -2.67703738e-02f, 5.11685982e-02f, 7.58745149e-03f, -2.96781957e-02f, 1.54144950e-02f,
  -4.44776677e-02f, 5.91233559e-03f, -1.36769740e-02f, -4.52776477e-02f, 1.26277385e-02f, -5.14944866e-02f, 2.69862432e-02f, -4.22059894e-02f, 7.84376711e-02f, 1.79947389e-03f,
  9.48528200e-02f, 1.25884369e-01f, 1.01258624e-02f, 1.31229023e-02f, 3.44104692e-02f, 9.66350548e-03f, -5.35392612e-02f, 7.98010379e-02f, -7.86956996e-02f, 5.17288502e-03f,
  3.88781913e-02f, 4.54632454e-02f, -7.02903122e-02f, 4.38111648e-02f, 7.24749640e-02f, 6.78740218e-02f, 1.59504749e-02f, 5.75406328e-02f, 1.93490665e-02f, -8.85669068e-02f,
  -3.22467275e-02f, 1.71750605e-01f, 2.90921956e-01f, 1.07758604e-01f, 4.06876169e-02f, 2.03657568e-01f, 6.40683770e-02f, 1.20270990e-01f, 3.26386631e-01f, 2.25226015e-01f,
  -1.78291515e-01f, 3.16008866e-01f, 1.62498519e-01f, -3.28672081e-01f, -4.87406850e-02f, 1.25876248e-01f, 2.91404098e-01f, 2.58578598e-01f, -1.61037073e-01f, -1.18444096e-02f,
  2.73911715e-01f, -1.40951991e-01f, 3.54816653e-02f, 9.40918326e-02f, 1.54482976e-01f, 3.29077803e-02f, -2.59574026e-01f, -1.59808353e-01f, -1.91350013e-01f, -8.28844123e-03f,
  -3.38136196e-01f, -1.38429374e-01f, -9.00231823e-02f, 8.61302912e-02f, -1.87032565e-01f, -4.87515405e-02f, 2.77697772e-01f, 7.40911951e-03f, 1.95358738e-01f, -5.78469574e-01f,
  7.88263604e-02f, 2.58486122e-01f, -7.36904293e-02f, -7.16902539e-02f, 6.15668781e-02f, -2.05480214e-02f, -2.19023339e-02f, 2.19266731e-02f, -8.54979157e-02f, 1.66317504e-02f,
  -9.00446624e-02f, 4.89193834e-02f, -7.72293583e-02f, -6.74187467e-02f, 7.78348371e-02f, -3.05958302e-03f, 2.01065578e-02f, 8.39617848e-02f, 6.32537156e-02f, 1.20243117e-01f,
  -8.60655829e-02f, 3.06353066e-02f, 6.09050952e-02f, 6.50501698e-02f, 8.89597610e-02f, -6.95966035e-02f, 2.46819898e-01f, 4.33679819e-02f, 2.66658604e-01f, 5.36654629e-02f,
  -4.04373463e-03f, -4.00008559e-02f, -1.66566446e-02f, 6.29704744e-02f, -1.82783429e-03f, -1.47075001e-02f, -9.59630683e-02f, -6.80622831e-03f, 2.27345563e-02f, -4.26927283e-02f,
  1.63323339e-02f, 3.07478458e-02f, -4.12380174e-02f, 2.65306737e-02f, 2.90636905e-03f, -1.06383087e-02f, 8.96514673e-03f, -1.72126014e-02f, 8.16407874e-02f, 9.42701381e-03f,
  1.96149480e-02f, -1.00000827e-02f, -6.49607405e-02f, -2.21275277e-02f, 1.32433781e-02f, 8.19575936e-02f, -6.04554079e-02f, 7.33221099e-02f, 3.98814864e-02f, -6.76474199e-02f,
  -9.48383100e-03f, 1.19674332e-01f, -1.01600945e-01f, 5.41696660e-02f, -5.36746234e-02f, 2.19016019e-02f, 2.30148342e-02f, 6.11980520e-02f, 2.29739398e-03f, 1.41117144e-02f,
  7.61127993e-02f, -4.57496941e-02f, 1.12239622e-01f, 1.10252919e-02f, -5.01226149e-02f, 7.41905533e-03f, 2.70348433e-02f, -8.44683200e-02f, 1.79150719e-02f, -5.66190574e-03f,
  -4.35443223e-02f, -4.59016412e-02f, -9.29946527e-02f, 1.01413038e-02f, -1.98421199e-02f, -9.42322314e-02f, -2.63281707e-02f, -5.02483845e-02f, 7.62414485e-02f, -5.31443814e-03f,
  -2.45258093e-01f, -1.51023328e-01f, 4.58032563e-02f, -1.81753747e-02f, -1.12086043e-01f, 2.08959058e-01f, 2.00146571e-01f, 1.88280672e-01f, 4.72319536e-02f, -1.04525916e-01f,
  -2.33807474e-01f, -1.54173434e-01f, -6.17385991e-02f, 4.66054790e-02f, 2.71085858e-01f, 2.44787529e-01f, 2.44071096e-01f, 2.51611054e-01f, 3.53033900e-01f, 1.79711953e-01f,
  4.00162786e-02f, 4.99188341e-02f, 3.18026617e-02f, -3.54368761e-02f, -1.86956421e-01f, 4.88299876e-02f, -2.05865666e-01f, -7.11167678e-02f, -1.09208800e-01f, 2.19281781e-02f,
  -6.28507882e-02f, -8.84455889e-02f, 4.51112073e-03f, -4.73955162e-02f, -9.66391712e-02f, -3.27602983e-03f, 5.47887534e-02f, 6.80694282e-02f, -3.92761119e-02f, 1.16293453e-01f,
  -3.97553518e-02f, 3.10155451e-02f, -1.67221818e-02f, 3.70039865e-02f, 9.57719088e-02f, 1.72075294e-02f, 2.78784465e-02f, -3.23031517e-03f, 5.76115102e-02f, -1.03244297e-01f,
  -1.22092895e-01f, -1.61633372e-01f, -1.03223622e-01f, -2.59392313e-03f, 4.17020544e-02f, -1.06492624e-01f, -5.75258397e-02f, -7.57580251e-02f, -1.81880593e-01f, 2.76954714e-02f,
  -9.63272527e-02f, -1.21407220e-02f, -5.35242318e-04f, -5.68362214e-02f, 1.18422098e-02f, -2.90083513e-03f, 3.23917344e-03f, 3.48018929e-02f, 3.92064489e-02f, 4.09132056e-02f,
  -3.98891419e-03f, -3.31539437e-02f, -4.43592295e-03f, -5.51249087e-02f, 8.71901028e-03f, -1.93205159e-02f, 3.77869941e-02f, -2.22887602e-02f, -1.54986726e-02f, -4.55513485e-02f,
  6.14879318e-02f, 7.43064517e-03f, -1.90954097e-02f, 8.12030360e-02f, -6.08569309e-02f, -1.07736606e-02f, -5.99369854e-02f, -7.82938451e-02f, -1.41897434e-02f, -3.37814703e-03f,
  1.34260088e-01f, 4.34195399e-02f, -2.59841904e-02f, 1.02786057e-01f, 1.90198142e-02f, -5.55905402e-02f, -1.07214987e-01f, 3.54380719e-02f, 3.52274030e-02f, 3.34715806e-02f,
  -6.88700303e-02f, 7.95771927e-03f, 2.97464877e-02f, -8.70698765e-02f, 3.54534350e-02f, 7.75840972e-03f, -6.96088448e-02f, 5.67831844e-02f, 3.74756334e-03f, -3.51214446e-02f,
  2.50072982e-02f, 9.13522840e-02f, 8.50627869e-02f, 3.58004845e-03f, -3.96184847e-02f, 3.51370163e-02f, 4.36266437e-02f, 9.95483249e-02f, 2.93340683e-02f, 1.19518243e-01f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -7.96189904e-01f, 9.42382962e-02f, -1.72588319e-01f, 8.58878195e-02f, 3.17243129e-01f, 3.59378383e-02f, 1.42625019e-01f, -3.24650966e-02f, 1.02858603e-01f, 1.74687505e-01f,
  7.77406171e-02f, 4.02762890e-02f, 7.33840391e-02f, 4.71663438e-02f, -5.02570756e-02f, 3.83775353e-01f, 4.05622065e-01f, -1.80762798e-01f, -4.36888993e-01f, -2.57388234e-01f,
  1.27358958e-01f, -1.40913978e-01f, -3.71975452e-01f, -9.91627574e-02f, 1.97080061e-01f, 1.45972790e-02f, 1.71559215e-01f, 1.67355053e-02f, -5.05309142e-02f, 2.98379570e-01f,
  1.90852061e-02f, -1.59772292e-01f, -1.53262854e-01f, -2.87621822e-02f, 1.30582377e-02f, -9.32409763e-02f, -1.09317482e-01f, -2.37681996e-02f, -2.11806949e-02f, 2.03761812e-02f,
  2.89611053e-02f, -7.35711604e-02f, 1.30088523e-01f, -9.85416118e-03f, -7.29653388e-02f, 6.82736980e-03f, -6.14271834e-02f, -1.74801946e-01f, -1.40628010e-01f, -1.80249289e-01f,
  1.35036826e-01f, 7.02928752e-02f, -1.11642107e-01f, -9.98359732e-03f, -7.52220079e-02f, -8.37839097e-02f, -1.56110942e-01f, -1.01380564e-01f, -1.87771842e-01f, -2.83698678e-01f,
  -7.04719275e-02f, 3.79149914e-02f, 2.67592203e-02f, 9.07620881e-03f, -2.68159546e-02f, 1.40686026e-02f, 7.15486258e-02f, 2.21183281e-02f, 2.50569060e-02f, -3.63056138e-02f,
  1.64389331e-02f, 3.37207243e-02f, 5.27229509e-04f, -3.83844897e-02f, 3.52060460e-02f, 4.88759279e-02f, 2.23667342e-02f, -2.67639086e-02f, -7.21895248e-02f, -2.27598343e-02f,
  8.09494581e-04f, -5.84830493e-02f, 7.29792938e-02f, 2.27464885e-02f, 6.69356296e-03f, -4.58900370e-02f, -4.24848273e-02f, -4.15638462e-03f, -4.11717854e-02f, -2.11533345e-02f,
  3.70806828e-02f, 9.20207500e-02f, 1.88377462e-02f, -2.26831194e-02f, 2.64607109e-02f, 1.68679710e-02f, 9.83942077e-02f, -4.06345688e-02f, -8.50599073e-03f, -5.34376642e-03f,
  -9.74617526e-02f, -2.06430978e-03f, 8.35384503e-02f, -1.29467780e-02f, -2.55593322e-02f, -1.18087595e-02f, 1.39242522e-02f, 5.80156222e-02f, -6.15081303e-02f, 1.28988409e-02f,
  5.54698147e-02f, -1.03041738e-01f, -1.96216166e-01f, -2.99932581e-04f, 1.45536736e-02f, -9.72099975e-02f, -7.62726068e-02f, -1.28833756e-01f, -2.29376420e-01f, -1.70407608e-01f,
  -4.62126225e-01f, -1.07560463e-01f, -6.74402416e-01f, -3.31010431e-01f, -3.87455344e-01f, -1.37714550e-01f, -7.99661353e-02f, 9.29623321e-02f, 3.74492034e-02f, -1.82827637e-01f,
  1.32998645e-01f, 1.72294974e-01f, 1.40907586e-01f, 6.84856102e-02f, -7.54626766e-02f, -3.95750076e-01f, -6.46092653e-01f, -4.89316732e-01f, -1.42368302e-01f, 3.91018949e-02f,
  -1.74213856e-01f, -2.17490226e-01f, -3.68561715e-01f, -6.02610298e-02f, -9.53551531e-02f, -9.43610221e-02f, -3.42832565e-01f, -2.95403451e-01f, -2.18847841e-01f, -4.87180084e-01f,
  -9.10558626e-02f, -1.96714059e-01f, 1.64647587e-02f, -9.61266458e-02f, -1.30513474e-01f, 7.88563266e-02f, -8.64371732e-02f, -3.00803315e-02f, 5.94819970e-02f, 1.23173054e-02f,
  -8.63529891e-02f, -4.14048918e-02f, -2.79075112e-02f, 5.09657189e-02f, -1.38313934e-01f, -1.17076658e-01f, -2.66625807e-02f, -1.49157926e-01f, -1.20477527e-01f, -1.67140700e-02f,
  2.96839941e-02f, -1.44073665e-01f, -1.11933559e-01f, 4.42255214e-02f, 9.55050290e-02f, -1.83198497e-01f, 5.51527813e-02f, -1.40200499e-02f, -1.12386823e-01f, 1.60827003e-02f,
  -2.15895958e-02f, 1.06857801e-02f, 3.36373895e-02f, -1.63577069e-02f, 1.10157896e-02f, -2.98528653e-02f, 1.46846976e-02f, 2.24178620e-02f, 5.98414987e-02f, 4.64365445e-02f,
  -1.19153008e-01f, 4.71148361e-03f, 1.16070583e-02f, 2.26795226e-02f, 2.06707194e-02f, -1.10983243e-02f, 2.09802669e-03f, 5.43256178e-02f, -4.56946380e-02f, -2.03976501e-02f,
  -6.96861232e-03f, -6.84263855e-02f, -2.78885998e-02f, 6.55091256e-02f, -1.54309303e-01f, -7.61668608e-02f, -1.25933867e-02f, 6.23270124e-02f, 3.96695398e-02f, -1.42389943e-03f,
  4.73511398e-01f, -1.69167787e-01f, 3.93520407e-02f, 2.05469429e-01f, -7.55818635e-02f, 2.36433800e-02f, 1.22324392e-01f, 2.79986225e-02f, 6.26894005e-04f, -1.11864330e-02f,
  1.50286611e-02f, 1.09079249e-01f, -3.66097428e-02f, 7.48303607e-02f, -1.46032805e-02f, 9.43806693e-02f, -2.26428192e-02f, -1.09210990e-01f, 3.94769348e-02f, 3.24494839e-02f,
  -4.21599559e-02f, 6.43981546e-02f, 1.07776180e-01f, 8.81443843e-02f, 4.51950543e-02f, -8.82530212e-02f, 1.30728811e-01f, 1.57393262e-01f, 7.13792257e-03f, 1.71660438e-01f,
  2.47086629e-01f, -4.87772003e-03f, -4.76668440e-02f, 5.69024310e-02f, -5.69443330e-02f, -9.11131203e-02f, -1.05046690e-01f, -3.40830497e-02f, -3.88675667e-02f, 3.79617624e-02f,
  -7.55232796e-02f, -4.34994362e-02f, 1.06628099e-02f, -9.65697616e-02f, -2.08538234e-01f, -8.94300342e-02f, 9.28779412e-03f, -6.01225533e-02f, -1.75505534e-01f, -1.96663857e-01f,
  -8.35783184e-02f, 2.73101758e-02f, 3.83964404e-02f, -2.88188495e-02f, 7.97560960e-02f, -1.23533430e-02f, -6.90150112e-02f, -7.35576963e-03f, -1.21223293e-01f, -2.15545669e-03f,
  9.96009409e-02f, -4.46810499e-02f, -1.02751106e-01f, -2.81688198e-02f, -1.02006290e-02f, 4.54131849e-02f, 1.52061200e-02f, 1.96898598e-02f, 3.57646346e-02f, 1.25883548e-02f,
  9.01628658e-03f, -2.74494719e-02f, 2.79448051e-02f, -3.54491128e-03f, -3.44451182e-02f, -1.54336300e-02f, -8.33391547e-02f, -9.90020782e-02f, -9.83427279e-03f, 4.95224372e-02f,
  -8.00127760e-02f, -4.01274450e-02f, -6.91630542e-02f, 1.44972028e-02f, -5.30882366e-02f, -2.15419699e-02f, 4.98925298e-02f, 8.35496746e-03f, -1.15958065e-01f, 8.78167991e-03f,
  -7.47884661e-02f, 6.63377270e-02f, 2.27978150e-03f, 8.66853632e-03f, 2.39733532e-02f, 1.67148432e-03f, -3.43906544e-02f, -1.74981430e-02f, 3.83601561e-02f, -6.84582815e-02f,
  7.56140500e-02f, 9.30336944e-04f, -4.15525176e-02f, -2.82391207e-03f, 6.02169856e-02f, -3.84646771e-03f, -2.07389574e-02f, 5.96751343e-04f, 4.05003093e-02f, 8.43330696e-02f,
  -6.46163449e-02f, 8.56095031e-02f, 2.39317510e-02f, -9.20694172e-02f, -2.57445816e-02f, -1.01989336e-01f, -4.00810689e-03f, -6.30745441e-02f, 3.14837210e-02f, 7.86092952e-02f,
  1.72403514e-01f, -8.06306303e-02f, 9.59189385e-02f, -4.15135361e-02f, 6.02310747e-02f, 6.67220950e-02f, 5.39031159e-03f, 4.29955870e-02f, 4.56865169e-02f, 4.19111550e-02f,
  1.40723474e-02f, 7.65560195e-02f, 3.52254473e-02f, 1.24644469e-02f, 3.01620606e-02f, 4.44066115e-02f, 5.63642308e-02f, 4.17448319e-02f, 1.71807632e-02f, 4.25822884e-02f,
  1.10292874e-01f, 1.05572633e-01f, 1.40600223e-02f, 1.29330121e-02f, -5.81485741e-02f, 5.61748967e-02f, 8.67875963e-02f, 5.24981730e-02f, 1.10981748e-01f, 1.95741162e-01f,
  -3.93020481e-01f, -1.24142878e-01f, 3.85603249e-01f, -1.89882264e-01f, -2.75230128e-02f, 1.55091256e-01f, 1.02176689e-01f, -1.53977040e-03f, -7.12271631e-02f, 1.22071423e-01f,
  3.59448348e-03f, 7.88695961e-02f, 4.47049923e-02f, 8.16724896e-02f, 7.21788332e-02f, 1.16660856e-01f, -4.12510708e-02f, 1.10200427e-01f, 3.16057891e-01f, 2.16760024e-01f,
  5.91794811e-02f, -4.74609137e-02f, -1.44121170e-01f, -6.50080666e-02f, 7.04132989e-02f, 1.85529724e-01f, -5.64666614e-02f, -5.32834940e-02f, 6.53523654e-02f, -3.94686498e-02f,
  6.17322385e-01f, -2.96468318e-01f, 1.62358567e-01f, -1.72624454e-01f, 8.95909891e-02f, 8.14301148e-02f, 1.50162041e-01f, 2.49227472e-02f, -4.38311808e-02f, 5.76449558e-02f,
  3.66986170e-03f, -3.78965260e-03f, 3.82971130e-02f, -5.72042586e-03f, 2.64444854e-02f, 3.35796960e-02f, -1.55560389e-01f, -6.73604161e-02f, 7.03704357e-02f, 1.21039256e-01f,
  4.22091819e-02f, 2.38597877e-02f, 7.47768953e-02f, 9.90937427e-02f, -3.26165482e-02f, 8.34493432e-03f, 2.49871220e-02f, -8.83890763e-02f, -6.05852753e-02f, -7.29379207e-02f,
  4.77385074e-02f, -2.03535091e-02f, 1.07467584e-02f, 6.04510587e-03f, -6.34782463e-02f, 6.79923967e-02f, -2.48305388e-02f, -1.18070887e-02f, 6.02752483e-03f, 2.38549020e-02f,
  -1.78639162e-02f, 2.34736595e-02f, 8.17417875e-02f, 5.47345877e-02f, 1.20621152e-01f, -6.87844083e-02f, 6.81628510e-02f, 9.77297202e-02f, 4.96662445e-02f, -9.95720923e-02f,
  -2.30447371e-02f, -2.48609018e-02f, -6.05150126e-02f, 8.32717195e-02f, -8.24495964e-03f, 1.50031326e-02f, -4.68252786e-02f, 6.94907159e-02f, -2.43084109e-03f, -1.46013215e-01f,
  2.47448429e-01f, -1.11537695e-01f, 5.45601062e-02f, -6.35081008e-02f, -6.13662116e-02f, -1.29613355e-01f, 3.36864701e-04f, -1.10737056e-01f, -8.89350846e-02f, 1.00041762e-01f,
  1.18330210e-01f, 5.26664071e-02f, -3.94611359e-02f, -1.45775294e-02f, 1.75377317e-02f, -4.37860712e-02f, -3.06438580e-02f, 5.21440841e-02f, -4.22440097e-02f, -2.22112983e-02f,
  -3.42247523e-02f, 6.58130571e-02f, 2.53791511e-01f, 1.63872913e-01f, 5.06372899e-02f, 7.86340460e-02f, 2.06923187e-01f, 1.94798633e-01f, 9.69733447e-02f, 1.88482463e-01f,
  -5.66139758e-01f, 2.82113422e-02f, 2.86996126e-01f, -5.64497590e-01f, -1.06918171e-01f, 1.95200861e-01f, 1.56979844e-01f, -9.99078676e-02f, -1.77633122e-01f, 7.37817213e-02f,
  1.38158351e-01f, -1.00694157e-01f, -1.72195099e-02f, 6.26832545e-02f, 1.26713440e-01f, 1.59517795e-01f, -6.72167763e-02f, -4.07645106e-02f, -3.18488702e-02f, 8.01956579e-02f,
  -1.36653736e-01f, -2.25563839e-01f, -2.94936210e-01f, -2.62983944e-02f, -1.45068511e-01f, 3.30660194e-02f, -4.19324674e-02f, -9.33554024e-02f, 2.84597665e-01f, -8.85980427e-02f,
  1.05033271e-01f, -1.61221579e-01f, 9.64354798e-02f, -5.70024503e-03f, 3.05971801e-02f, -6.95614740e-02f, 1.25688612e-01f, -8.99521336e-02f, -5.92844635e-02f, 1.95425693e-02f,
  -6.29453957e-02f, 4.50865328e-02f, -1.07808396e-01f, 2.54788995e-02f, 9.69129708e-03f, -1.10646954e-03f, -6.32846653e-02f, 3.88327166e-02f, 7.65775971e-04f, 1.13772094e-01f,
  -8.11077282e-02f, 4.34151031e-02f, -2.41323654e-03f, 8.39619264e-02f, 9.91787910e-02f, -2.34615635e-02f, 1.16756193e-01f, -5.72089059e-03f, 1.04259446e-01f, -7.61177167e-02f,
  1.12055978e-02f, 1.07266746e-01f, 6.33275807e-02f, -7.37456605e-02f, -3.46751697e-02f, 1.65876392e-02f, 2.56656427e-02f, -3.69039699e-02f, -7.91992769e-02f, -8.69084820e-02f,
  2.26127077e-02f, -1.12428972e-02f, 4.38027158e-02f, -5.60699068e-02f, 1.61944851e-02f, -6.85690492e-02f, -3.54039134e-03f, -5.30443788e-02f, -3.01150661e-02f, -3.47329490e-02f,
  3.73842269e-02f, 1.04228176e-01f, -9.47574973e-02f, 7.69496560e-02f, 1.25995278e-01f, 4.96619567e-02f, 2.10969429e-02f, -1.42517751e-02f, -4.82208431e-02f, -4.65637189e-04f,
  -2.54747987e-01f, 2.15880513e-01f, -8.45865831e-02f, -8.62260535e-02f, 1.08866030e-02f, -1.76155772e-02f, -2.55985148e-02f, -1.50759825e-02f, 1.80744361e-02f, -1.01466328e-01f,
  9.85261574e-02f, -7.43929520e-02f, 3.53222786e-05f, 7.65403435e-02f, -9.13283881e-03f, 1.06794769e-02f, -7.86059257e-03f, -1.52573630e-01f, 4.92711104e-02f, -2.97543802e-03f,
  5.24742045e-02f, -1.00067176e-01f, -1.06658451e-01f, -1.92658119e-02f, -1.02468627e-02f, -9.63052176e-03f, -2.34166551e-02f, 4.25267294e-02f, 4.72895056e-02f, -2.85972178e-01f,
  5.60646892e-01f, -3.71303886e-01f, -1.54862702e-01f, -8.85048732e-02f, -3.10065418e-01f, -5.65403737e-02f, -1.59396589e-01f, -3.69494781e-02f, -2.74394248e-02f, -1.28459662e-01f,
  1.82037681e-01f, 3.61612529e-01f, 4.21136439e-01f, 2.44921744e-01f, 2.57537425e-01f, -1.71529248e-01f, -2.12434828e-01f, 3.14185135e-02f, 1.99091703e-01f, 3.12449001e-02f,
  -1.97513983e-01f, -1.22568712e-01f, -1.16605133e-01f, -6.86800405e-02f, -3.00112784e-01f, 1.31201848e-01f, -2.87412405e-01f, -8.27753767e-02f, 3.64742428e-02f, -2.10308969e-01f,
  1.11431360e-01f, 1.34634804e-02f, 1.02046050e-01f, 3.02888770e-02f, -5.37120551e-02f, 2.44636685e-02f, 5.45651428e-02f, 3.84452194e-03f, 1.31325563e-02f, -4.34758924e-02f,
  7.00445622e-02f, -3.29289436e-02f, 1.69089124e-01f, -3.52424234e-02f, 1.76685950e-04f, 9.16355550e-02f, -1.08884744e-01f, 1.13874543e-02f, 1.09987043e-01f, -5.94630279e-02f,
  -1.15629472e-01f, -1.26757696e-01f, -3.12824100e-02f, -9.89965424e-02f, 1.51062265e-01f, 8.59551728e-02f, -2.42092445e-01f, -2.22868249e-02f, 9.84504372e-02f, -1.15311250e-01f,
  -1.09925374e-01f, 8.15166160e-02f, 3.91882546e-02f, -7.72234276e-02f, 9.10250172e-02f, 4.36421763e-03f, -2.08723880e-02f, -9.30541381e-03f, -1.28973359e-02f, -5.24047092e-02f,
  -4.01079096e-02f, 2.79819220e-02f, -4.72240597e-02f, -2.85158064e-02f, -1.26280787e-03f, -4.46173921e-02f, 2.65711136e-02f, -5.03783450e-02f, -3.85910040e-03f, 8.16610008e-02f,
  2.87642106e-02f, 9.14365575e-02f, -8.00332986e-03f, 2.78612450e-02f, -1.07614715e-02f, 1.06546609e-02f, 1.19912056e-02f, 2.11838703e-03f, -7.33105000e-03f, 1.27790244e-02f,
  6.30159630e-04f, 2.40675554e-01f, 9.32557732e-02f, 3.38918976e-02f, -1.29631022e-02f, -1.56822777e-03f, 3.48524563e-02f, -1.63401365e-02f, 4.06928249e-02f, -5.56226708e-02f,
  7.07993507e-02f, 5.26927821e-02f, 7.59327784e-03f, -6.41549900e-02f, -9.11136121e-02f, -2.14027259e-02f, -9.37180668e-02f, 1.22214727e-01f, 3.94865721e-02f, -1.16073705e-01f,
  -1.64218888e-01f, 4.83489111e-02f, 8.35900977e-02f, 9.08996016e-02f, 7.15932325e-02f, 2.20344633e-01f, 4.43640165e-02f, 9.09798294e-02f, 1.82432130e-01f, -2.14128271e-01f,
  2.53371119e-01f, 1.43336132e-01f, 5.90884648e-02f, 2.37801708e-02f, 1.56178087e-01f, 5.90492040e-02f, 2.65215069e-01f, 1.27354264e-01f, 1.51040750e-02f, 1.38535336e-01f,
  2.86324859e-01f, 3.35870646e-02f, 4.63591423e-03f, -5.86616918e-02f, -9.03582200e-03f, 1.25159021e-03f, -1.32459570e-02f, -1.28891900e-01f, -1.10803552e-01f, 9.18838233e-02f,
  -5.32854795e-02f, 2.10203100e-02f, -6.81133103e-03f, -1.52922422e-01f, -1.37672544e-01f, -1.16239741e-01f, -1.04533788e-03f, 1.08754545e-01f, 5.27631724e-03f, -1.08991176e-01f,
  -3.25981453e-02f, 1.09572783e-01f, -2.54854802e-02f, 4.74482812e-02f, 5.34392782e-02f, -6.64612353e-02f, 3.25844139e-02f, -3.95424850e-02f, 1.01818368e-01f, 4.20549586e-02f,
  5.79576269e-02f, 5.88786304e-02f, -1.62662175e-02f, -8.83635730e-02f, 5.47852330e-02f, 8.23080242e-02f, 1.21165123e-02f, -6.19340390e-02f, 7.82995969e-02f, 3.31236757e-02f,
  6.34172633e-02f, 3.48937958e-02f, 6.75309002e-02f, 3.53386328e-02f, 1.33466586e-01f, -3.25758085e-02f, 1.17295571e-02f, -1.01847881e-02f, 1.15478523e-01f, -1.50097102e-01f,
  -3.40930410e-02f, 3.88170741e-02f, -3.17766145e-02f, -5.30589670e-02f, -5.56615107e-02f, 1.14324011e-01f, -2.26397105e-02f, -1.92282982e-02f, 4.89376746e-02f, 2.18455419e-02f,
  4.75544259e-02f, -7.40158036e-02f, -6.42978027e-02f, 3.75597402e-02f, -7.34921321e-02f, 8.15519094e-02f, -7.39166588e-02f, -7.57688507e-02f, 2.83170138e-02f, -4.45434041e-02f,
  -3.36256213e-02f, 5.81532307e-02f, -3.21190879e-02f, 3.77174132e-02f, -8.86032656e-02f, 3.71642760e-03f, -2.60014776e-02f, 6.90121204e-02f, -6.57024458e-02f, -1.85990427e-02f,
  -3.73408720e-02f, 1.51641220e-01f, -1.71498254e-01f, -4.03159149e-02f, 2.42078491e-02f, 2.01759804e-02f, 2.65953355e-02f, -6.68208823e-02f, -2.29475163e-02f, 4.20629093e-03f,
  6.10558987e-02f, 5.45466952e-02f, 1.03881061e-01f, 5.87037168e-02f, -6.09450489e-02f, -1.31100928e-03f, 7.98986703e-02f, -8.98181200e-02f, -3.91552523e-02f, 5.66503368e-02f,
  -1.75084919e-02f, 5.35457814e-03f, -6.60552233e-02f, 6.48432374e-02f, -3.46571696e-03f, -2.85816379e-02f, -3.89540456e-02f, -1.03873760e-01f, 6.54477403e-02f, -2.19207965e-02f,
  -3.75321686e-01f, -3.31505686e-01f, -1.35373130e-01f, -1.33032933e-01f, -5.89848757e-02f, -2.15306506e-02f, -9.39240120e-03f, 8.69357809e-02f, -4.87590656e-02f, -1.96332008e-01f,
  -1.13556437e-01f, -6.98975101e-02f, -2.90620998e-02f, -6.36153668e-02f, -8.19791388e-03f, -1.86106116e-01f, -9.30062011e-02f, 3.96098383e-02f, 2.65570879e-01f, 3.10985297e-01f,
  1.06152490e-01f, 6.28852695e-02f, 8.86092559e-02f, 5.23117147e-02f, -5.32878935e-02f, -5.03173023e-02f, -1.30175114e-01f, -7.87516311e-02f, 7.54159763e-02f, -3.61882359e-01f,
  -1.94304124e-01f, 3.30355093e-02f, 8.92286897e-02f, -1.85952671e-02f, -5.02115190e-02f, -4.24931198e-02f, -6.34436607e-02f, 3.94724458e-02f, 6.13905583e-03f, -7.24567026e-02f,
  1.21300342e-02f, 7.79393911e-02f, 1.16973035e-02f, 1.02203399e-01f, -2.20839512e-02f, -1.41614256e-02f, 5.80118829e-03f, 9.19501111e-03f, -3.75404246e-02f, 7.91329443e-02f,
  -5.78810945e-02f, -1.05754316e-01f, -2.03462280e-02f, 6.60997480e-02f, 4.09418680e-02f, 5.70524968e-02f, 1.91985015e-02f, -3.10989600e-02f, 3.22584882e-02f, -1.68361351e-01f,
  -4.97286692e-02f, -3.13032009e-02f, 3.43302935e-02f, -7.61398375e-02f, -4.73124161e-02f, 2.21658628e-02f, 3.19774114e-02f, -7.11167138e-03f, 8.07649344e-02f, -4.23083417e-02f,
  -2.35277172e-02f, -1.49476305e-02f, 6.19594641e-02f, -1.22070871e-01f, -2.72253733e-02f, -1.40149295e-02f, 1.64844748e-02f, 2.68008895e-02f, 1.18261306e-02f, 9.72207785e-02f,
  -1.08174287e-01f, -4.74699847e-02f, 8.30989331e-03f, -2.51129176e-02f, 3.73764173e-03f, -2.76337750e-02f, 1.11136120e-03f, 6.35806322e-02f, 4.97709177e-02f, 5.75467721e-02f,
  -1.27250805e-01f, 5.35362139e-02f, -7.57521167e-02f, 8.53601918e-02f, -1.19718961e-01f, 9.95684788e-03f, 3.16298380e-02f, 7.71871023e-03f, -4.45522228e-03f, -4.72427644e-02f,
  1.31787896e-01f, -1.38535304e-03f, -1.09254811e-02f, -2.71789376e-02f, -4.81548812e-03f, 2.19121971e-03f, 1.31140249e-02f, -7.21850172e-02f, 5.74307367e-02f, 4.52359803e-02f,
  -2.32489314e-02f, -6.84538409e-02f, -2.20581099e-01f, -1.60732597e-01f, -2.44528893e-02f, -6.56463876e-02f, -1.17947437e-01f, -7.51106739e-02f, -1.91390708e-01f, -4.18809801e-01f,
  -1.63957804e-01f, -2.57875860e-01f, 9.73762646e-02f, -1.09184563e-01f, 6.79435432e-02f, 2.62462925e-02f, -1.56592846e-01f, -1.35298237e-01f, -5.28141111e-02f, -6.69564903e-02f,
  -1.89403519e-01f, -1.01197943e-01f, -6.10198043e-02f, 8.85577723e-02f, 5.88580184e-02f, -1.63580328e-01f, -3.81233431e-02f, 1.78052664e-01f, 1.41470686e-01f, 1.77031428e-01f,
  -2.34838724e-02f, 5.70771191e-03f, 1.63724497e-01f, 1.82887316e-01f, 6.05842918e-02f, 1.40267760e-01f, 1.60509020e-01f, -2.42195800e-02f, 2.02564806e-01f, -2.76335794e-02f,
  -8.69539678e-02f, -3.77377123e-02f, 5.03422134e-03f, 2.39016162e-03f, 5.90110607e-02f, 6.68959767e-02f, -2.73030736e-02f, 4.53325883e-02f, 2.91572791e-02f, 6.87872001e-04f,
  -6.61087111e-02f, -8.72273073e-02f, -1.02945417e-01f, 6.55881688e-02f, -3.49078104e-02f, -2.80690822e-03f, 8.46294388e-02f, 4.98495735e-02f, -4.39653732e-02f, -2.40862556e-03f,
  -6.27718270e-02f, 2.08614543e-02f, -2.76615974e-02f, -4.67398465e-02f, -7.04030618e-02f, -1.13874301e-03f, 4.45128791e-02f, -7.43548498e-02f, 1.57175306e-02f, -6.92641810e-02f,
  2.89671607e-02f, 3.10689062e-02f, -4.18701172e-02f, 2.29626447e-02f, -6.83142338e-03f, 6.31077364e-02f, 7.14851310e-03f, -3.00928224e-02f, -6.82354812e-03f, -1.38213271e-02f,
  3.30233714e-03f, 9.50054638e-03f, -1.43192988e-02f, -6.07993919e-03f, 6.56007007e-02f, 1.26574207e-02f, -3.68115492e-02f, 8.93592536e-02f, 2.79880781e-02f, 5.62564805e-02f,
  -6.66495785e-02f, 8.92671421e-02f, 1.65409744e-02f, 1.16560953e-02f, 2.52772607e-02f, 9.13208630e-03f, -1.41763370e-02f, 3.90296504e-02f, -9.88612622e-02f, -4.06088792e-02f,
  -1.41512096e-01f, 1.43038303e-01f, -1.23536915e-01f, -9.17458162e-02f, 5.30651063e-02f, -2.03792262e-03f, -9.26166624e-02f, -1.35562206e-02f, -7.41134956e-02f, -1.56382211e-02f,
  -7.58405402e-02f, 2.99176071e-02f, -3.16615365e-02f, -1.93452276e-02f, -1.99196991e-02f, -1.16326623e-02f, -9.13580060e-02f, -3.03414594e-02f, 3.94037962e-02f, -2.40061730e-02f,
  -2.09869929e-02f, 3.95731442e-02f, -1.25226289e-01f, -9.78519693e-02f, -1.29161894e-01f, -7.42933676e-02f, -3.18648033e-02f, 6.06416899e-04f, -6.14112727e-02f, -9.59649757e-02f,
  4.85038102e-01f, 6.06798828e-01f, 2.22067833e-01f, 1.78965494e-01f, 8.98829028e-02f, 2.42234126e-01f, 4.61007893e-01f, 2.33053997e-01f, -6.74285367e-02f, 1.71158597e-01f,
  1.23928905e-01f, -1.56709701e-02f, 2.22689547e-02f, -2.82220785e-02f, 2.40950346e-01f, 1.20670132e-01f, 1.14287339e-01f, 1.05627635e-02f, 1.61991976e-02f, 8.82898271e-02f,
  6.88209310e-02f, 1.74652010e-01f, 1.62723571e-01f, 5.55322208e-02f, 4.55699898e-02f, -4.09958512e-02f, 8.60308260e-02f, 2.07104027e-01f, 9.35337469e-02f, 2.01086074e-01f,
  -3.96742150e-02f, 3.96264702e-01f, -2.42532238e-01f, -1.08207971e-01f, -5.29476143e-02f, -1.39710680e-01f, -1.08296461e-02f, -2.69805361e-03f, -4.49865833e-02f, -5.62533252e-02f,
  -1.68021806e-02f, -4.94434722e-02f, 8.13922063e-02f, -2.86325201e-04f, 1.01196505e-01f, 1.95412263e-02f, 2.97792424e-02f, 1.35554507e-01f, -7.03900158e-02f, 1.35944749e-03f,
  7.65805766e-02f, 5.78995124e-02f, -9.44563840e-03f, 1.25989523e-02f, 1.23745352e-01f, -1.65904373e-01f, 4.85750362e-02f, 1.45331342e-02f, 2.16169823e-02f, 4.92429361e-03f,
  -6.53774589e-02f, -2.27191392e-03f, -5.64183109e-03f, -3.95371914e-02f, 6.55579567e-02f, -6.01727888e-03f, 7.11388364e-02f, -8.32931511e-03f, -3.34424376e-02f, 1.86508447e-02f,
  -1.38188135e-02f, 1.93223432e-02f, -1.96093097e-02f, 2.27567330e-02f, -1.23016455e-03f, 5.72102219e-02f, -4.13534343e-02f, -2.28665452e-02f, -2.52747703e-02f, -7.06874132e-02f,
  2.75680143e-02f, -4.64123972e-02f, -1.15011171e-01f, -5.13399672e-03f, 2.53904779e-02f, 6.52471036e-02f, -6.02869391e-02f, 3.23769338e-02f, 5.46554141e-02f, -2.68964246e-02f,
  -1.05847515e-01f, -1.18622221e-01f, -8.49648472e-03f, -7.24789128e-02f, 2.31544673e-02f, -5.25990538e-02f, -3.31706293e-02f, -9.91974100e-02f, -5.25610708e-02f, 9.43215040e-04f,
  1.21248225e-02f, 7.45609328e-02f, 7.97629878e-02f, -2.06008554e-02f, -4.70149070e-02f, -4.70761880e-02f, -7.41256075e-03f, -1.69679709e-02f, -6.77369311e-02f, -5.86732030e-02f,
  -4.56947275e-02f, -1.40135080e-01f, -2.38860309e-01f, -1.94218799e-01f, -1.46105292e-03f, -1.87700883e-01f, -1.45345122e-01f, -1.05142437e-01f, -1.57162979e-01f, -2.01981813e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  1.92079946e-01f, 5.42457104e-01f, 9.94233415e-02f, 1.90010089e-02f, 3.30705911e-01f, -7.57807493e-02f, 3.23738009e-02f, 4.13958244e-02f, 1.45741746e-01f, 4.00757968e-01f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  9.85936448e-02f, -5.66624045e-01f, -5.25048018e-01f, -5.76970994e-01f, 4.06290531e-01f, -4.13071156e-01f, 5.60392618e-01f, -1.54114217e-01f, 1.36366382e-01f, -4.47488129e-01f,
  3.82629305e-01f, 1.18631601e-01f, 4.57356304e-01f, -1.61007881e-01f, -1.65864915e-01f, -9.39396843e-02f, -8.59532505e-02f, -3.94717902e-01f, -2.41057530e-01f, -2.05270350e-01f,
  2.14729294e-01f, -1.05495155e-01f, 6.36940360e-01f, -1.39273211e-01f, 3.35360944e-01f, -3.54166716e-01f, 1.50954667e-02f, -5.69228768e-01f, -1.20186293e-02f, -2.77492087e-02f,
  -1.10170752e-01f, -2.46575139e-02f, -1.65254027e-01f, 3.90749216e-01f, 2.07515404e-01f, 3.50384235e-01f, -4.29940790e-01f, 1.25323832e-01f, 2.89761096e-01f, -1.82947561e-01f,
  1.73390016e-01f, -4.00724173e-01f, -2.12419555e-01f, 4.98836309e-01f, 1.50583893e-01f, -3.93149793e-01f, -2.61757225e-01f, 4.46873903e-01f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  6.82557523e-01f, -2.97114998e-02f, 1.27884611e-01f, -8.51249881e-03f, 8.26268017e-01f, 1.16816740e-02f, -1.25009656e-01f, 2.20529184e-01f, -3.93031090e-01f, 1.22132130e-01f,
  9.21462417e-01f, -2.07873881e-01f, 3.70494962e-01f, 5.95095038e-01f, 2.34403238e-01f, -5.03847227e-02f, 9.01609063e-01f, 1.31209925e-01f, 7.70879745e-01f, 3.20809007e-01f,
  3.25665981e-01f, 1.57876283e-01f, -1.28448248e-01f, 3.10306072e-01f, -1.03359148e-01f, 1.24620855e-01f, 6.29790068e-01f, -4.76604432e-01f, -2.30166197e-01f, 2.65788943e-01f,
  4.10945624e-01f, -6.53331816e-01f, -3.68724793e-01f, -1.68311730e-01f, -5.65516204e-02f, 1.03966787e-01f, 1.08982056e-01f, 9.59374756e-02f, -2.28719726e-01f, 2.20684824e-03f,
  -5.35695739e-02f, 3.87202650e-01f, 3.63210551e-02f, 5.77977538e-01f, 1.24627888e-01f, -6.69457093e-02f, -1.46048516e-01f, -7.43254721e-02f, 5.83117664e-01f, 6.87566325e-02f,
  7.82729164e-02f, 1.39824778e-01f, 6.03636801e-01f, -3.14085275e-01f, -9.20164883e-02f, 7.30472922e-01f, -1.62826240e-01f, -3.54291171e-01f, 2.44370401e-01f, -3.59938562e-01f,
  1.42850667e-01f, 6.33200347e-01f, 2.28400305e-01f, 1.19404905e-01f, -7.06197917e-02f, 7.81400502e-02f, 1.21825300e-01f, 2.27120683e-01f, -1.88467979e-01f, 6.50660843e-02f,
  2.53256299e-02f, -6.66493252e-02f, -8.43840390e-02f, -7.01359138e-02f, -1.65070593e-03f, -2.29961857e-01f, 1.90841779e-01f, 4.91585769e-02f, -2.14290753e-01f, -2.38596991e-01f,
  4.37870383e-01f, -7.21802562e-02f, 2.24243224e-01f, 2.59100497e-01f, 4.70142543e-01f, -4.34318976e-03f, 6.76000714e-01f, 1.30275369e+00f, 2.35757366e-01f, -3.02407853e-02f,
  1.99444592e-01f, 2.48455107e-02f, 1.61555514e-01f, -8.88713151e-02f, -4.02022302e-01f, 1.58342138e-01f, 3.28134894e-01f, 4.50068682e-01f, 5.54947138e-01f, 1.86847463e-01f,
  5.66639960e-01f, -3.31109732e-01f, -8.22802603e-01f, 1.04985511e+00f, -1.96655288e-01f, -4.29201275e-01f, -2.06808031e-01f, 5.88588715e-01f, 2.55145878e-01f, 1.55176401e-01f,
  -3.28129560e-01f, 7.56323040e-01f, -2.37192050e-01f, -6.45730272e-02f, -1.49403559e-02f, -8.43441188e-02f, -2.11458564e-01f, -1.47433653e-01f, 3.95643085e-01f, -2.16461256e-01f,
  2.05652311e-01f, 1.27407029e-01f, 1.27707779e-01f, -2.33310107e-02f, 1.43892303e-01f, 2.51919955e-01f, -6.21214025e-02f, -4.41370998e-03f, -1.79741299e-03f, 2.38994539e-01f,
  3.64272475e-01f, -5.27224362e-01f, 3.51249911e-02f, -6.44948065e-01f, 3.83648664e-01f, 2.15671629e-01f, 1.35247484e-01f, -4.27167565e-01f, -2.05135822e-01f, -1.76150188e-01f,
  -3.89940590e-02f, 2.26483881e-01f, -6.49723485e-02f, 8.58341634e-01f, 1.33401649e-02f, -5.61854355e-02f, 1.49976893e-03f, 4.97610688e-01f, 1.14408154e-02f, 2.80656636e-01f,
  -1.71273902e-01f, 1.32504895e-01f, 8.24468136e-02f, 6.12955451e-01f, -2.30903953e-01f, 5.20171165e-01f, -7.41172731e-02f, 4.14329886e-01f, 9.61682349e-02f, 1.45111904e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  5.58902510e-02f, 2.96982259e-01f, 1.64015621e-01f, 2.09459752e-01f, -1.35741636e-01f, -1.54313771e-02f, 2.27814600e-01f, -1.13020919e-01f, 7.16860414e-01f, -8.47134367e-02f
};

// L2_fan_Wp (Shape: 3 x 16)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -1.55604944e-01f, 1.50956482e-01f, 1.00736931e-01f, -7.93038130e-01f, -5.27317464e-01f, 4.78561491e-01f, -2.43561625e-01f, 3.26147050e-01f, 3.51341605e-01f, -4.47971106e-01f,
  6.14035502e-02f, -8.13318267e-02f, 1.21116146e-01f, -3.51079665e-02f, 1.88744292e-01f, 4.01507437e-01f, -2.38982573e-01f, 7.51438215e-02f, 2.14403853e-01f, 3.00461084e-01f,
  2.80682534e-01f, 1.37859620e-02f, -4.38914001e-01f, 1.84823188e-03f, -2.40982547e-01f, -2.92209774e-01f, 2.37846285e-01f, 6.73930407e-01f, -5.73898554e-01f, 7.06865937e-02f,
  -1.03610530e-02f, -2.34427005e-01f, 2.95835227e-01f, 5.22379160e-01f, 3.60038638e-01f, 8.08066308e-01f, 5.16372323e-01f, 1.90110892e-01f, 6.48979396e-02f, 9.65904519e-02f,
  -2.37997532e-01f, -8.56675133e-02f, -2.48176694e-01f, -1.79851994e-01f, 1.17162883e-01f, 5.48834950e-02f, 1.44385070e-01f, -5.13686240e-01f
};

// L2_fan_Wp_bar (Shape: 10 x 16)
const int L2_fan_Wp_bar_rows = 10;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  5.55154346e-02f, 4.29712445e-01f, -6.37691766e-02f, 4.44291495e-02f, -2.97663480e-01f, -3.71028513e-01f, 4.08272445e-01f, 5.12413085e-01f, -3.10061842e-01f, 4.57048446e-01f,
  -9.85955168e-03f, 5.05661070e-01f, 4.86448526e-01f, -1.96143910e-01f, -1.34160146e-01f, -3.24592561e-01f, 6.61544323e-01f, 4.87726599e-01f, 3.83925550e-02f, 1.12462139e+00f,
  3.61251354e-01f, -1.91206813e-01f, 2.96938092e-01f, -2.51857370e-01f, -3.70956719e-01f, 6.16788089e-01f, -1.81225777e-01f, 5.75449765e-01f, -3.03605258e-01f, 3.73378992e-01f,
  9.54674006e-01f, -7.17643082e-01f, 1.01872146e+00f, 7.48428285e-01f, 6.30327880e-01f, 3.62855226e-01f, 3.24187391e-02f, 8.71497631e-01f, -4.45379049e-01f, -5.56489050e-01f,
  1.82880148e-01f, -3.23214754e-02f, -2.06833109e-01f, -1.93744227e-01f, 1.09751678e+00f, -1.36336327e-01f, 1.15718985e+00f, -2.86403388e-01f, -6.93998486e-02f, 2.24153116e-01f,
  -3.83752614e-01f, -4.95431684e-02f, -2.23521590e-01f, -6.41752124e-01f, 1.24947667e+00f, 1.44668984e+00f, -4.56684440e-01f, 8.33662987e-01f, -1.37181699e-01f, 3.72378170e-01f,
  2.61372894e-01f, -9.42888260e-02f, -2.15550050e-01f, -3.66590649e-01f, -3.94802056e-02f, -8.44403356e-02f, -4.42967981e-01f, -8.32111090e-02f, 2.27374151e-01f, -1.41815990e-01f,
  1.89388946e-01f, 2.05127597e-02f, -2.05023378e-01f, 5.23488641e-01f, -8.33234414e-02f, -1.54104069e-01f, 1.22864529e-01f, 1.28354058e-01f, 3.12411357e-02f, 2.38877870e-02f,
  -6.81211874e-02f, 1.16727591e-01f, -4.13948484e-02f, -1.60748705e-01f, -2.57659033e-02f, -2.79358346e-02f, 9.84919369e-02f, -1.24860674e-01f, 5.02385348e-02f, -4.68501896e-02f,
  -1.83468848e-01f, 6.53956272e-03f, -6.93929121e-02f, -6.28725886e-02f, -1.92983598e-01f, -2.36468107e-01f, -1.78289399e-01f, 1.49310529e-01f, -1.77450880e-01f, -1.78846866e-01f,
  -3.98679860e-02f, -1.99454904e-01f, 3.51385325e-02f, -5.60111627e-02f, -8.32419097e-02f, 8.47321302e-02f, -4.61834148e-02f, -2.02560246e-01f, 1.15597256e-01f, 6.75939023e-02f,
  -2.41012946e-01f, 3.56525667e-02f, -2.61996806e-01f, 1.85767755e-01f, -1.19038820e-01f, 2.37364903e-01f, -4.70581353e-02f, -7.22032338e-02f, -3.77159677e-02f, -9.94340330e-02f,
  -1.53803632e-01f, 4.64580432e-02f, 9.13043842e-02f, 1.76045895e-01f, -1.14293583e-01f, 2.39428848e-01f, -2.31099427e-01f, -1.61971852e-01f, -2.95163214e-01f, -4.44845945e-01f,
  -6.95988595e-01f, -3.13983411e-01f, -6.07028008e-02f, 1.21974545e-02f, -1.12087868e-01f, -2.19725713e-01f, -1.08465485e-01f, 3.85705143e-01f, -2.13705152e-01f, 1.16695487e+00f,
  1.47437692e+00f, -1.85038343e-01f, 1.47277236e-01f, 1.11444138e-01f, 1.63246378e-01f, 8.77725482e-01f, 5.30933440e-01f, -1.13433003e+00f, -6.89085782e-01f, 8.24699879e-01f,
  -4.95233119e-01f, 4.87465888e-01f, -1.34512588e-01f, 3.47725064e-01f, -2.02698097e-01f, -3.99669498e-01f, 2.83679873e-01f, -1.62984625e-01f, 4.22957122e-01f, -7.08994120e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 10)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 10;
const float L2_fan_Bp_bar_data[] = {
  -9.80143771e-02f, 5.31288683e-01f, 8.44819963e-01f, -6.95153847e-02f, -1.13681801e-01f, -1.15363173e-01f, -1.54371873e-01f, -1.99770093e-01f, -1.10351041e-01f, 9.17456806e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  1.52834067e-02f, -9.23949122e-01f, -7.68913329e-01f, -1.57207608e-01f, 8.70276868e-01f, -1.37237430e-01f, 5.54821305e-02f, -1.79347932e-01f, -8.36297870e-01f, 5.15789568e-01f,
  6.09296560e-01f, -2.04729557e-01f, 3.48049998e-02f, 7.93918222e-02f, 5.32069325e-01f, 9.83474329e-02f, -1.10622779e-01f, -5.42847097e-01f, -4.10654902e-01f, 2.49762610e-01f,
  -1.86332703e-01f, -7.19639361e-01f, -4.00846481e-01f, -9.45722699e-01f, 5.08613527e-01f, -4.64345336e-01f, 5.27730845e-02f, -2.01114148e-01f, 2.37076566e-01f, -1.01498375e-02f,
  1.07906854e+00f, -4.36686665e-01f, 2.14036331e-01f, -5.48716724e-01f, 8.03900898e-01f, 3.65873754e-01f, -3.34555537e-01f, 2.43284881e-01f, 8.41828212e-02f, -1.68212622e-01f,
  -1.43049031e-01f, 9.52806473e-01f, -6.40293360e-02f, -3.99048217e-02f, 2.34603360e-01f, 2.47323528e-01f, -8.83182466e-01f, 6.19053483e-01f, -4.18453723e-01f, -2.49746352e-01f,
  2.49609366e-01f, -3.78978848e-01f, 1.56852022e-01f, -9.14110709e-03f, 3.51287752e-01f, 3.46651256e-01f, -1.08968222e+00f, 1.03129065e+00f, 1.45459428e-01f, 2.15788633e-01f,
  7.77232274e-02f, -1.29128844e-01f, -3.03802937e-01f, -7.84293056e-01f, -2.64200300e-01f, -7.07936194e-03f, 2.09541351e-01f, -9.31673706e-01f, -1.29431814e-01f, 1.29796579e-01f,
  4.55506951e-01f, 7.64483452e-01f, -2.35986128e-01f, 7.69082829e-02f, -2.67261900e-02f, 7.23287016e-02f, 6.86253086e-02f, -2.25772142e-01f, 2.14668363e-01f, -3.17975938e-01f,
  -1.39305517e-01f, 3.37542951e-01f, 4.47219461e-01f, 5.10743320e-01f, 6.49837032e-02f, -6.41026139e-01f, 4.49309409e-01f, -2.23253325e-01f, 7.14879856e-02f, -1.63419787e-02f,
  -3.11391950e-01f, -1.41042694e-01f, 2.15357840e-01f, -1.04465879e-01f, 4.07291830e-01f, 4.58405226e-01f, -3.12598497e-01f, -4.05999452e-01f, 2.03786969e-01f, 2.61506349e-01f,
  -4.27056938e-01f, 3.92735213e-01f, -2.44544849e-01f, -1.93685576e-01f, 8.97891164e-01f, -9.15341914e-01f, -2.10036471e-01f, 2.40875080e-01f, 2.23784402e-01f, 1.54736061e-02f,
  -2.66658783e-01f, 6.19554937e-01f, 4.74125832e-01f, 2.36608714e-01f, -8.40438083e-02f, -5.34708560e-01f, 1.11910534e+00f, 4.66093451e-01f, -5.82379401e-01f, 1.14495361e+00f,
  3.55018139e-01f, -7.20134139e-01f, -1.98385999e-01f, 1.59443960e-01f, 1.52802318e-02f, 2.36317277e-01f, -1.67512316e-02f, -9.92184937e-01f, -3.06508899e-01f, 8.85300159e-01f,
  2.11818874e-01f, 7.92606592e-01f, -6.79779172e-01f, -1.21611226e+00f, -6.45889521e-01f, -6.16885126e-01f, 2.44959712e-01f, -7.56132841e-01f, 1.20437935e-01f, 1.20377712e-01f,
  2.45862827e-01f, 8.34845286e-03f, -5.16012847e-01f, 1.36765301e+00f, 3.91558141e-01f, 8.36162865e-01f, -2.40754798e-01f, 3.17428380e-01f, -1.03044204e-01f, 7.29066133e-01f,
  -5.58301985e-01f, 6.52808249e-01f, 1.02445340e+00f, -7.47925997e-01f, -1.66401148e-01f, -1.03309393e-01f, 5.99737279e-02f, -2.06073105e-01f, -1.32804692e+00f, 9.37633440e-02f,
  -1.59932718e-01f, 1.47474095e-01f, -5.77667177e-01f, 5.66522717e-01f, -5.57196915e-01f, -3.21591884e-01f, 3.16366881e-01f, -9.22295988e-01f, -1.42508185e+00f, 8.44693959e-01f,
  -2.50251561e-01f, -1.51000410e-01f, 1.00239143e-01f, 2.42469549e-01f, 4.71727014e-01f, -4.88661021e-01f, 2.17766210e-01f, -6.76643491e-01f, -2.64058530e-01f, -2.15513915e-01f,
  -4.26265985e-01f, 4.76047486e-01f, 3.14346105e-01f, 3.85325581e-01f, 6.67216897e-01f, -5.93456328e-02f, 1.65048048e-01f, 1.27039403e-01f, -6.94294795e-02f, -6.32714257e-02f,
  -1.44469654e-02f, -4.05253261e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -4.81181294e-01f, 2.96483766e-02f, 3.33498955e-01f, -5.03763020e-01f, -2.86487371e-01f, 6.28794208e-02f, -2.71149397e-01f, 5.18750608e-01f, 5.30124366e-01f, 2.99847722e-01f,
  -1.84914485e-01f, -3.90311867e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    