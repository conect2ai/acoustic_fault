/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.24651901e-01f, -4.23242450e-02f, -2.84369513e-02f, -7.84243550e-03f, -7.52423033e-02f, 1.44558456e-02f, 1.79696605e-01f, -3.17111909e-02f, -7.59026334e-02f, 1.21033497e-01f,
  2.33137049e-02f, 2.42126919e-02f, 8.86168852e-02f, -3.49703133e-02f, -7.08470047e-02f, -8.34551901e-02f, 4.95337397e-02f, -2.54963599e-02f, -7.64237270e-02f, 1.05061764e-02f,
  3.29330824e-02f, 1.01189598e-01f, -1.13891698e-02f, 5.52589186e-02f, 5.85822351e-02f, 6.04717480e-03f, -8.11104402e-02f, -5.14057316e-02f, -8.76196995e-02f, -8.90731663e-02f,
  -2.59529203e-02f, 6.48066634e-03f, 6.68092594e-02f, -1.68373287e-02f, -2.53856983e-02f, -5.88538907e-02f, -5.21835573e-02f, -5.80866821e-02f, -4.93747788e-03f, -1.19198717e-01f,
  5.16119041e-02f, -5.34080602e-02f, 8.06610193e-03f, -8.63058716e-02f, 6.94217384e-02f, 4.89104204e-02f, 6.87613189e-02f, 1.47434035e-02f, 8.99349228e-02f, 2.64387508e-03f,
  -4.49973233e-02f, 4.77297883e-03f, -3.06898262e-03f, 4.72544469e-02f, -7.55358487e-02f, -4.63023819e-02f, -7.31467381e-02f, -4.04211506e-02f, -1.12881571e-01f, -1.10725574e-01f,
  -1.00074142e-01f, -6.71534762e-02f, -1.48652364e-02f, 9.19832569e-03f, 2.17570923e-02f, 2.96124723e-02f, 8.18145229e-04f, 4.48577143e-02f, -5.38821034e-02f, 5.44004142e-02f,
  -1.10881291e-02f, 5.41645586e-02f, 6.17810972e-02f, 6.75210953e-02f, -7.65254796e-02f, -3.18354145e-02f, -5.99811003e-02f, 6.28722906e-02f, -7.28810430e-02f, -5.91287389e-02f,
  -4.34779115e-02f, -2.82070525e-02f, -2.51864064e-02f, -3.93444337e-02f, -8.67209882e-02f, -4.25281003e-02f, -1.75243448e-02f, -3.02601513e-02f, 6.26710206e-02f, -1.62155740e-02f,
  -7.54972100e-02f, -1.57194644e-01f, -3.90811041e-02f, -8.61883610e-02f, 6.16405495e-02f, -5.80453919e-03f, -9.00588036e-02f, -1.19744325e-02f, -8.69446769e-02f, -7.80962259e-02f,
  -1.41434539e-02f, -2.50815637e-02f, 3.41029279e-02f, -5.34794293e-02f, 5.63230291e-02f, -5.58564300e-03f, -2.82367580e-02f, 5.42766228e-02f, -8.32424909e-02f, -4.64553237e-02f,
  5.11346422e-02f, -2.07831357e-02f, -2.88660601e-02f, 4.84398641e-02f, 1.78792106e-03f, -5.84054291e-02f, -9.91649181e-02f, 3.31490710e-02f, -1.13189027e-01f, -2.98589356e-02f,
  -9.09501538e-02f, -2.26758281e-03f, 1.31643564e-01f, 5.11294790e-02f, 5.44696711e-02f, 5.88798001e-02f, 4.01906893e-02f, 5.30036911e-02f, -7.20033124e-02f, 3.46424356e-02f,
  -1.06677543e-02f, -1.12214252e-01f, 6.08342737e-02f, 1.19955480e-01f, -1.98256537e-01f, -1.25349006e-02f, 8.82347822e-02f, 1.45880105e-02f, 2.28746198e-02f, 1.66338354e-01f,
  -2.29471989e-04f, -5.33596240e-03f, -6.61801845e-02f, 1.11056902e-01f, 2.04083603e-02f, 1.66775361e-02f, 3.30950134e-02f, 5.09088375e-02f, 1.40009001e-01f, 4.22031758e-03f,
  5.89581355e-02f, 7.61354715e-02f, 3.07180290e-03f, -9.47663784e-02f, -3.27043189e-03f, -1.84298474e-02f, -6.50580898e-02f, 3.75094153e-02f, -3.73890176e-02f, -3.90902534e-02f,
  3.76230888e-02f, -6.84090331e-02f, 6.23482727e-02f, 5.30012436e-02f, -3.17798345e-03f, 4.65880819e-02f, 5.13704754e-02f, -7.50768324e-03f, 2.55985335e-02f, 5.11657521e-02f,
  3.61682549e-02f, 3.90726216e-02f, -7.70706264e-03f, -8.07962716e-02f, -2.03219359e-03f, -6.52864054e-02f, -4.17124629e-02f, 1.20623196e-02f, 9.63240862e-04f, 1.65892709e-02f,
  -8.93319771e-02f, 6.43070638e-02f, 1.83002204e-02f, 3.50914337e-02f, 6.53265566e-02f, 2.33789030e-02f, 5.08804359e-02f, -6.42007068e-02f, -4.46182787e-02f, -2.67533469e-03f,
  -4.11883816e-02f, -6.74722120e-02f, 7.20499549e-03f, 6.26009703e-02f, -1.08125145e-02f, 2.93993670e-02f, -4.00418006e-02f, 1.68151967e-02f, -6.42098561e-02f, -6.03461154e-02f,
  1.67701188e-02f, -6.75548911e-02f, 5.21106347e-02f, 2.54945103e-02f, 1.47148641e-02f, 8.47910419e-02f, 1.55626852e-02f, 7.70332515e-02f, 7.21428394e-02f, -6.17952272e-03f,
  -6.36154935e-02f, 8.82448182e-02f, 5.16488478e-02f, -6.07110746e-02f, 5.17932661e-02f, 2.30570529e-02f, -1.70817995e-03f, 8.77459794e-02f, -6.86328206e-03f, -1.40283415e-02f,
  6.83027953e-02f, 7.76066408e-02f, 3.36617604e-02f, -7.96910301e-02f, -3.71761359e-02f, -5.72773442e-02f, 3.19813564e-02f, -2.01199595e-02f, 2.18062568e-02f, -1.14806600e-01f,
  3.87474671e-02f, 3.33004706e-02f, 3.89617607e-02f, -1.88031793e-02f, -1.00665942e-01f, -3.96358110e-02f, -5.53791672e-02f, -1.02700768e-02f, -5.94537109e-02f, 5.62270880e-02f,
  -2.10076794e-01f, 2.25028411e-01f, -1.36563987e-01f, 8.96629021e-02f, 9.80773568e-02f, 1.72062829e-01f, 3.76737863e-02f, 1.06632061e-01f, 6.69422373e-02f, 8.43075737e-02f,
  -1.84018873e-02f, -1.44657984e-01f, -3.59623954e-02f, 2.12445542e-01f, -9.70843285e-02f, 1.17115118e-01f, 8.25292394e-02f, 7.39870220e-02f, -8.76750052e-02f, 3.35489027e-02f,
  6.59078062e-02f, 2.18011200e-01f, -3.12495884e-03f, 9.88070369e-02f, -5.21261953e-02f, -1.03989691e-02f, 9.63093787e-02f, -8.57701004e-02f, 4.93893959e-02f, 2.02120095e-02f,
  -4.60801572e-02f, -6.67351633e-02f, -3.01187076e-02f, -1.23826057e-01f, 5.17081805e-02f, -5.50612994e-02f, 2.34843418e-02f, -5.73799275e-02f, -5.14551699e-02f, 4.73745763e-02f,
  -1.06213808e-01f, -1.88951623e-02f, 2.83148903e-02f, 9.22180787e-02f, 9.23465565e-02f, -3.49998847e-02f, -3.93392816e-02f, 7.53860697e-02f, 3.58719416e-02f, -2.93225981e-02f,
  2.61307135e-02f, 2.40390114e-02f, 3.42063140e-03f, -4.96413792e-03f, 1.68828890e-02f, 1.24473963e-02f, 7.85730779e-02f, -9.84510127e-03f, -3.20781171e-02f, 2.53956635e-02f,
  -7.41342008e-02f, -2.87147947e-02f, 4.48956061e-03f, -1.61960199e-02f, -3.10562528e-03f, -3.80764306e-02f, 3.88212055e-02f, 4.49895598e-02f, 7.76026249e-02f, 1.91340130e-02f,
  1.62644219e-02f, -2.78196530e-03f, 2.40065698e-02f, 1.08403042e-02f, -4.41653468e-02f, 6.06073886e-02f, -8.50636233e-03f, 6.96574673e-02f, 3.58279794e-02f, 4.35537212e-02f,
  -2.77240276e-02f, 9.29870736e-03f, -2.74721477e-02f, 1.72190629e-02f, -4.96085249e-02f, -2.41957624e-02f, 1.56656876e-02f, -4.59388979e-02f, 4.52782214e-02f, 1.89461187e-02f,
  1.10366508e-01f, -7.33182160e-03f, 2.29716264e-02f, 5.71347885e-02f, -1.50567153e-02f, 1.52352378e-02f, -4.66790944e-02f, -5.93366921e-02f, 5.71343414e-02f, -3.06312516e-02f,
  1.65860802e-02f, 5.66889904e-03f, 9.75299999e-03f, -2.08177902e-02f, -2.21015196e-02f, 3.02239135e-02f, 5.35875298e-02f, 8.80798399e-02f, -3.65547021e-04f, -4.31161970e-02f,
  3.28893494e-03f, -1.78943891e-02f, 9.53729674e-02f, 1.21437691e-01f, 6.94597587e-02f, 3.41361426e-02f, 7.18764812e-02f, 5.72987609e-02f, -3.39267291e-02f, -3.34553160e-02f,
  3.21823865e-01f, -5.03108315e-02f, 1.03267722e-01f, 1.83254093e-01f, -7.86593258e-02f, 8.95645469e-02f, 1.78231105e-01f, 8.29085857e-02f, 6.21921867e-02f, -2.80136690e-02f,
  -5.15053682e-02f, 1.75839111e-01f, -1.77549109e-01f, 1.98491395e-01f, 6.98982477e-02f, -3.72816030e-05f, 7.63586909e-02f, 1.57421961e-01f, -9.48391035e-02f, 5.56436963e-02f,
  -7.75409192e-02f, 2.79710125e-02f, 1.48655504e-01f, -9.49440598e-02f, 6.03449978e-02f, 8.15297663e-03f, 1.19002730e-01f, -9.64880362e-02f, -3.84634137e-02f, -2.10722033e-02f,
  3.13941538e-02f, -7.58356531e-04f, 2.23968215e-02f, 2.75251176e-02f, 1.92214176e-02f, 2.89834514e-02f, 2.50806771e-02f, 8.03860184e-03f, 8.62593763e-03f, 1.09389061e-02f,
  9.77646038e-02f, 3.76856886e-02f, 6.44266829e-02f, 1.71752907e-02f, -6.51882365e-02f, 6.12760335e-02f, 2.36294139e-02f, -2.90566143e-02f, 9.67692118e-04f, 8.36928561e-02f,
  5.91244437e-02f, -3.18319909e-02f, 8.68248194e-02f, -1.58167519e-02f, 5.14112320e-03f, -1.48068629e-02f, 3.55141470e-04f, -8.71664733e-02f, 5.11042029e-02f, -1.85462367e-02f,
  5.61573133e-02f, -3.63251865e-02f, -7.43038282e-02f, -8.04536268e-02f, -6.94170296e-02f, 4.27371077e-02f, -3.21065858e-02f, 9.65878293e-02f, 1.62670203e-02f, -2.25853194e-02f,
  3.50595266e-02f, 5.46141192e-02f, -5.43419309e-02f, 8.75852033e-02f, -1.69866662e-02f, -3.08664776e-02f, 1.29630687e-02f, 9.31753125e-03f, -3.97240967e-02f, -7.56324828e-02f,
  5.01052625e-02f, -2.90271807e-02f, 2.12191809e-02f, 4.53966809e-03f, -1.31047636e-01f, -3.85450386e-02f, -7.02356920e-02f, -2.29633246e-02f, 2.34644599e-02f, -3.92859394e-04f,
  -1.70629874e-01f, -6.89435452e-02f, -6.79995716e-02f, -5.16304374e-02f, -1.52484002e-02f, 2.98223533e-02f, 6.97987229e-02f, 6.37778454e-03f, -5.02413288e-02f, 6.99234083e-02f,
  5.99522442e-02f, -2.29668766e-02f, -8.45945403e-02f, 2.17775218e-02f, -7.09135756e-02f, 3.07886191e-02f, -8.31393152e-02f, -8.11378211e-02f, 2.28394642e-02f, -1.92051232e-02f,
  -5.01915440e-02f, 4.89132330e-02f, 5.31285107e-02f, 2.96967272e-02f, 1.17536716e-01f, -9.82724316e-03f, 1.02529153e-01f, -7.25743221e-03f, 4.43432517e-02f, 3.19060646e-02f,
  3.06537539e-01f, 2.11730063e-01f, 7.16717467e-02f, 1.16401389e-02f, -1.84345558e-01f, 7.07892999e-02f, 2.53887355e-01f, -1.39481410e-01f, 2.46572003e-01f, -3.05337440e-02f,
  -1.23446651e-01f, 1.81697682e-01f, 1.96811199e-01f, -3.14855538e-02f, -1.83270052e-01f, 1.34705454e-01f, 5.36241988e-03f, 8.61053392e-02f, 1.74931407e-01f, -1.74769133e-01f,
  1.43085711e-03f, -2.29033858e-01f, -3.57823633e-02f, -1.59476608e-01f, 1.90214533e-02f, -2.60402001e-02f, -2.71531433e-01f, 7.33537227e-03f, -2.15160564e-01f, 4.74780835e-02f,
  1.17641009e-01f, 9.10733640e-02f, -2.70506665e-02f, 1.74669847e-02f, -4.40877341e-02f, -7.46732429e-02f, 2.46813484e-02f, 8.16706195e-03f, -2.79436037e-02f, 1.20864175e-02f,
  2.66774334e-02f, -4.22623986e-03f, -2.78011393e-02f, -5.08402474e-02f, 5.25496155e-02f, 5.53696556e-03f, 1.10887505e-01f, -2.61145784e-03f, 7.93329179e-02f, -2.20066067e-02f,
  6.84895515e-02f, -4.70077293e-03f, -5.03197983e-02f, -1.00134853e-02f, -6.31718636e-02f, -6.79784417e-02f, 6.90980628e-02f, 1.16453199e-02f, 2.85932817e-03f, 1.94303896e-02f,
  -2.15090290e-02f, -7.22047836e-02f, 2.91503798e-02f, -2.30746693e-03f, -1.79932348e-03f, -6.98482767e-02f, -7.58076366e-03f, -3.42267007e-02f, -2.89337127e-03f, -1.10443328e-02f,
  -1.67558845e-02f, -5.07205632e-03f, 4.07609493e-02f, -1.73141863e-02f, 1.88601632e-02f, 3.31524722e-02f, -7.27993436e-03f, -4.10757586e-02f, 4.76140151e-04f, -1.13720552e-03f,
  4.80711460e-02f, -7.21622109e-02f, -9.37658083e-03f, 4.48070392e-02f, -6.81100935e-02f, -6.62722439e-02f, -9.60071664e-03f, -5.99156059e-02f, 2.36838181e-02f, 1.56406984e-02f,
  -1.24951668e-01f, -1.66709170e-01f, 4.39863503e-02f, 1.63605763e-03f, -3.08517125e-02f, -8.37484654e-03f, 1.16962111e-02f, -8.61696247e-03f, 1.38931684e-02f, -1.10815885e-02f,
  -9.01689455e-02f, 4.10684906e-02f, -7.35663101e-02f, -3.43097746e-02f, -1.51392734e-02f, -1.02390066e-01f, -1.50460564e-02f, -9.12392214e-02f, -4.74454165e-02f, -8.54952727e-03f,
  -2.89148614e-02f, 4.66325469e-02f, -1.64908022e-02f, -4.88551520e-02f, -5.06535023e-02f, -4.82478440e-02f, -7.21998736e-02f, -4.39759418e-02f, 3.78128588e-02f, 3.47829843e-03f,
  -1.76238090e-01f, -2.23827828e-02f, 1.08906895e-01f, 3.80933210e-02f, -3.17569301e-02f, 5.10839149e-02f, 1.82128504e-01f, -1.00124747e-01f, 3.18293452e-01f, -4.73944843e-02f,
  4.06403393e-02f, -1.57543346e-01f, 3.07072252e-01f, -3.47814597e-02f, -3.44299246e-03f, 3.33004743e-01f, -4.15454619e-02f, -2.71740519e-02f, 1.97536245e-01f, -1.77552938e-01f,
  5.23376511e-03f, -1.46862760e-01f, 5.81318513e-02f, -1.40532002e-01f, -1.76826328e-01f, -6.90359473e-02f, -3.16889286e-01f, 6.33638427e-02f, -2.88345426e-01f, -1.30064532e-01f,
  1.28228337e-01f, 1.57019332e-01f, -7.39412149e-03f, 3.56501580e-04f, -2.85329428e-02f, -4.42258827e-02f, -8.31369609e-02f, -7.06530735e-03f, 1.07343532e-01f, 4.23575379e-03f,
  4.33996785e-03f, -8.35405886e-02f, 2.33880710e-02f, 2.14118045e-02f, -7.37887546e-02f, -3.01287733e-02f, -2.92100874e-03f, 7.57331029e-02f, 6.17029034e-02f, 3.88142094e-02f,
  -8.92157573e-03f, -5.93966693e-02f, -4.40189764e-02f, -2.69464105e-02f, 4.90789935e-02f, -1.80149302e-02f, -9.77757573e-03f, -5.31494319e-02f, -5.10146096e-02f, -3.40284184e-02f,
  -6.71657175e-02f, 1.49410940e-03f, 2.29512025e-02f, -6.83797598e-02f, -2.37083584e-02f, -2.65505798e-02f, -3.24250944e-03f, 2.21727211e-02f, -1.58708636e-02f, -3.77960280e-02f,
  -1.38993738e-02f, -2.02605743e-02f, -7.37488940e-02f, 9.13843978e-03f, -3.68664712e-02f, -2.46123085e-03f, 3.31861153e-03f, -8.60391930e-03f, 3.41632701e-02f, 3.12222634e-02f,
  -2.17001271e-02f, -6.58000037e-02f, 1.35616828e-02f, -7.16771856e-02f, -2.23141350e-02f, 8.30920637e-02f, -5.04884534e-02f, 3.23155783e-02f, -6.55615795e-03f, -2.99960729e-02f,
  -1.60436869e-01f, -1.39353812e-01f, -3.37865166e-02f, 3.05029079e-02f, 7.86859170e-03f, -3.97141390e-02f, 8.21923092e-02f, -9.35553536e-02f, -3.98671329e-02f, 1.40968440e-02f,
  -7.16640577e-02f, 5.26415445e-02f, -9.06760693e-02f, 7.16244569e-03f, 7.02342950e-03f, 2.02073231e-02f, -3.24025452e-02f, -3.23818587e-02f, -9.42635611e-02f, -9.37833712e-02f,
  2.94165574e-02f, 4.17952538e-02f, -3.47007103e-02f, -1.97808035e-02f, 2.29288228e-02f, 2.34555118e-02f, -4.74582426e-03f, 1.92481652e-02f, -8.11281130e-02f, 6.38006628e-02f,
  2.75044620e-01f, 6.07801676e-02f, -1.46826610e-01f, -4.11998779e-02f, 4.49907891e-02f, 1.82020143e-01f, 1.54188573e-01f, -3.34475636e-02f, 9.15362686e-02f, 8.32382515e-02f,
  6.70858175e-02f, -9.79693159e-02f, -5.60966954e-02f, 8.66605639e-02f, 7.41913766e-02f, -1.22845508e-02f, 6.36993274e-02f, 6.89055026e-02f, 5.96999638e-02f, 2.28659939e-02f,
  -6.50450885e-02f, 6.93148896e-02f, -1.48365363e-01f, -5.95169440e-02f, -2.52386890e-02f, -1.25282019e-01f, -1.52866349e-01f, -7.33597651e-02f, -8.20373222e-02f, 6.30702302e-02f,
  7.15578049e-02f, -1.80270132e-02f, -8.03361610e-02f, 3.08423862e-02f, -8.17598030e-03f, 3.72338928e-02f, -9.70661640e-03f, -5.40285138e-03f, -6.76684454e-02f, 4.79058586e-02f,
  3.46396975e-02f, 6.08168077e-03f, 4.74897549e-02f, -3.82864848e-03f, 1.22989163e-01f, 4.05567558e-03f, -9.59450472e-03f, -8.15643817e-02f, -5.10371439e-02f, 4.34160829e-02f,
  6.06785044e-02f, 5.96886389e-02f, 5.00905849e-02f, -5.63777424e-02f, -8.24122429e-02f, 3.69993933e-02f, -4.17025164e-02f, 4.33933958e-02f, 2.12251898e-02f, 9.33378120e-04f,
  3.04395650e-02f, -3.16393450e-02f, 5.64693958e-02f, -2.46525276e-02f, -1.49529353e-02f, -1.28010035e-01f, -8.26739520e-03f, -2.00835560e-02f, -1.87972970e-02f, -2.14810390e-02f,
  -3.77907902e-02f, -5.14695123e-02f, -4.72804569e-02f, -4.26178053e-02f, 9.48838424e-03f, 8.11316967e-02f, 4.24815416e-02f, 4.93690697e-03f, 9.85348877e-03f, 3.94552276e-02f,
  -6.65435717e-02f, -2.09577810e-02f, -3.16109657e-02f, 1.49490051e-02f, -1.20905871e-02f, -7.98831731e-02f, 4.71422598e-02f, -7.06148669e-02f, 1.94573570e-02f, 2.30572410e-02f,
  5.36296554e-02f, -1.09518439e-01f, -3.69093567e-02f, 7.79623985e-02f, -1.05953896e-02f, 6.06505293e-03f, 6.32970333e-02f, 1.27810123e-03f, -1.07110240e-01f, -2.01614220e-02f,
  2.17377068e-03f, 8.33332688e-02f, 5.18880747e-02f, -7.72712082e-02f, -6.75140470e-02f, 4.98049483e-02f, -3.05367224e-02f, -7.93918818e-02f, 4.15204652e-02f, 8.33690818e-03f,
  -5.25669232e-02f, -6.55064806e-02f, 7.53191188e-02f, 5.85517213e-02f, 6.82366565e-02f, -5.99659160e-02f, -1.55935613e-02f, 4.51013930e-02f, 6.48441613e-02f, -1.10633105e-01f,
  2.25943193e-01f, 1.18020102e-01f, -1.21029206e-01f, 9.73405689e-02f, -1.74784601e-01f, -1.57494303e-02f, 8.08783323e-02f, -1.53020561e-01f, -1.20274574e-02f, 1.06787026e-01f,
  3.51011679e-02f, 1.17026687e-01f, 2.23542467e-01f, -4.89289537e-02f, 1.46190569e-01f, 1.73157722e-01f, 1.19216770e-01f, 6.33714199e-02f, -6.87028021e-02f, -2.10279450e-02f,
  -8.27572048e-02f, -3.50309499e-02f, -2.88973209e-02f, -1.17666818e-01f, -1.31483793e-01f, -1.13767773e-01f, 1.72169674e-02f, -5.14714196e-02f, -9.98899620e-03f, -1.81784183e-02f,
  3.74599360e-02f, 9.63450298e-02f, -7.89411068e-02f, 1.43448841e-02f, 2.47045569e-02f, 3.29580121e-02f, 9.29940119e-02f, -5.46135148e-03f, -5.74881360e-02f, -9.78027508e-02f,
  2.70860754e-02f, 2.62412727e-02f, -2.72583496e-02f, 1.73371416e-02f, 2.05613840e-02f, -2.65473407e-02f, -6.56146035e-02f, -9.85582471e-02f, 1.06567638e-02f, -1.93188451e-02f,
  -7.25191608e-02f, -7.98742324e-02f, -2.24517416e-02f, 2.82389559e-02f, -2.84252930e-02f, -6.90999329e-02f, -9.74962395e-03f, -2.16474831e-02f, -2.31303163e-02f, 7.42369471e-03f,
  -8.41518193e-02f, 3.70906852e-02f, 8.55168514e-03f, -1.23076113e-02f, 5.69128394e-02f, 3.34904231e-02f, 1.07560977e-02f, -4.84526083e-02f, -2.50778310e-02f, 1.43430112e-02f,
  2.73158420e-02f, 2.54409239e-02f, -1.43277980e-02f, 7.68622011e-02f, 5.26042134e-02f, 1.13156429e-02f, -1.13581186e-02f, 2.74666697e-02f, 6.14026487e-02f, -2.21657450e-03f,
  5.10187484e-02f, -2.98969517e-03f, 1.52152227e-02f, -4.49163616e-02f, -2.53861248e-02f, 2.42847800e-02f, 2.41429061e-02f, 7.79176783e-03f, 2.38360427e-02f, 1.96762243e-03f,
  1.15140609e-01f, 1.99886754e-01f, -7.49403834e-02f, -3.22744921e-02f, 1.55054191e-02f, -3.00730802e-02f, 2.69932467e-02f, -8.05106834e-02f, 1.02746844e-01f, 1.52735338e-02f,
  -5.17292358e-02f, 2.84808837e-02f, 1.71466470e-02f, -1.10404026e-02f, 4.96165380e-02f, -1.73085779e-02f, 7.69146681e-02f, 8.50363225e-02f, -8.87596011e-02f, 1.27610499e-02f,
  -2.62657776e-02f, 5.32773994e-02f, -3.78386453e-02f, -9.09839049e-02f, 2.37943567e-02f, 1.63220633e-02f, 7.45704621e-02f, -3.35479006e-02f, -2.32684407e-02f, 7.38049820e-02f,
  -2.65628821e-03f, 1.26312241e-01f, -1.53931929e-02f, 1.65357903e-01f, 1.22088887e-01f, 1.61007941e-01f, 1.50497600e-01f, 1.03473879e-01f, 4.38580215e-02f, 2.22570617e-02f,
  -9.99192223e-02f, -1.49034277e-01f, -2.65450805e-01f, 5.73185552e-03f, -4.99633886e-02f, -1.28542632e-01f, 1.88146129e-01f, 2.20645107e-02f, 1.38717666e-01f, 1.02248625e-03f,
  1.11895360e-01f, 7.12752417e-02f, -1.54319569e-01f, 1.02862865e-01f, 9.01108757e-02f, 1.46887943e-01f, -8.82131010e-02f, 4.56911288e-02f, 1.20398365e-01f, 4.18878160e-02f,
  7.73111060e-02f, 1.23971090e-01f, -2.31159572e-03f, -5.40945120e-02f, 4.56622802e-03f, -1.08301789e-01f, -5.44450898e-03f, -8.53107893e-04f, -3.77738439e-02f, 1.57385375e-02f,
  -6.67889789e-02f, -3.54455262e-02f, 3.73474881e-02f, -5.52236475e-02f, 2.04982515e-02f, 1.23888021e-02f, 4.90235689e-04f, -7.25342706e-02f, 6.17305934e-02f, 5.42704947e-02f,
  -4.33196388e-02f, -1.17952488e-02f, 6.02053516e-02f, 1.67581644e-02f, 4.99915369e-02f, 1.11108385e-01f, 2.59034429e-03f, -8.43367130e-02f, 3.10955774e-02f, 7.00553507e-03f,
  -1.27227139e-02f, -6.17143437e-02f, -8.40401575e-02f, -3.78223658e-02f, -1.29526816e-02f, 3.80106829e-02f, 5.38005959e-03f, -9.24587324e-02f, 4.11934629e-02f, 4.29337658e-02f,
  9.02952906e-03f, 2.40211319e-02f, -5.61701953e-02f, -7.16815740e-02f, -1.11922147e-02f, 1.28415460e-02f, -1.04087926e-01f, 6.61263913e-02f, -1.59584731e-02f, 6.66692737e-04f,
  1.59662329e-02f, 6.21869937e-02f, 9.87386703e-03f, 3.80507894e-02f, -9.20000114e-03f, -6.33191839e-02f, -1.88227613e-02f, 5.90105355e-02f, -6.43573031e-02f, 3.35295498e-02f,
  2.10209250e-01f, 2.32719287e-01f, -1.57660470e-04f, 6.64931983e-02f, 2.30792258e-02f, -2.32524719e-04f, 2.62770597e-02f, 4.36516255e-02f, 1.45019874e-01f, -2.62506609e-03f,
  -3.64641659e-02f, 3.45287845e-02f, -2.15847720e-03f, -1.94716558e-03f, -1.26414723e-03f, 2.30636001e-02f, 2.56007463e-02f, 2.65483856e-02f, 8.19829255e-02f, -4.84609120e-02f,
  -5.01403511e-02f, 2.21309680e-02f, -7.18322173e-02f, 5.79736382e-02f, 3.36945318e-02f, 1.03817498e-02f, 1.41773066e-02f, 3.25246006e-02f, -4.66009639e-02f, 2.17610858e-02f,
  -8.79329517e-02f, -3.34187709e-02f, -3.48502934e-01f, 1.36667773e-01f, -1.41830564e-01f, 1.07000694e-02f, 4.32174094e-02f, 1.93677489e-02f, -2.23437622e-01f, 2.50796139e-01f,
  1.81153446e-01f, -1.71589851e-01f, -1.09413052e-02f, 3.78911674e-01f, 3.94324921e-02f, 7.29416450e-03f, 3.02362651e-01f, 1.16468526e-01f, -8.23168531e-02f, 3.15870717e-02f,
  -1.75850056e-02f, 3.84791344e-01f, 9.95007753e-02f, 2.28216425e-01f, -1.14199508e-03f, -1.48533210e-01f, 2.80716687e-01f, -1.18364051e-01f, 1.26460388e-01f, 1.41782716e-01f,
  1.07845895e-01f, -1.16651356e-01f, -6.77418113e-02f, -4.20941561e-02f, -7.56856576e-02f, 1.38437552e-02f, 4.71392758e-02f, 1.27052646e-02f, -5.16495220e-02f, -7.21176043e-02f,
  -1.06433086e-01f, 3.08592408e-03f, -5.86017268e-03f, -6.65198546e-03f, -6.59472346e-02f, -2.83896402e-02f, -5.11439778e-02f, -4.30326983e-02f, -7.19488785e-02f, -7.23298565e-02f,
  -8.54684114e-02f, 4.79637161e-02f, 1.80249028e-02f, 2.78149508e-02f, -7.23885968e-02f, 1.67590789e-02f, -1.62538625e-02f, -6.66098967e-02f, -6.26025349e-02f, -2.20657326e-02f,
  -3.76862660e-02f, -3.71676497e-02f, 4.48004678e-02f, 6.27233982e-02f, -2.73455624e-02f, 2.40041185e-02f, 4.20632251e-02f, 6.21643737e-02f, -1.07377976e-01f, 4.93773334e-02f,
  1.83470007e-02f, -4.94419299e-02f, -3.78535897e-03f, -3.58479731e-02f, 1.87162701e-02f, 3.37112173e-02f, -3.33180912e-02f, -3.06339767e-02f, 5.07560559e-03f, -1.80413947e-02f,
  -1.05356146e-02f, 4.13924232e-02f, 5.65241370e-03f, 5.05014844e-02f, 8.06545019e-02f, -4.40258756e-02f, 7.08286688e-02f, -8.88551120e-03f, -2.85620522e-02f, -3.11918315e-02f,
  1.55521818e-02f, 3.55792940e-02f, 1.92812923e-02f, 1.65041462e-02f, 3.30715850e-02f, -1.02878893e-02f, 3.03443018e-02f, -1.96973663e-02f, 9.66866389e-02f, 1.82626245e-03f,
  -5.63914962e-02f, -3.28362770e-02f, -2.09095422e-02f, 1.30364979e-02f, 8.76340121e-02f, 1.41674252e-02f, 4.59869467e-02f, 1.82545185e-02f, 9.79620367e-02f, 2.30848715e-02f,
  3.71275619e-02f, -1.73087735e-02f, 2.81679910e-02f, -5.88282757e-02f, 2.05053277e-02f, -4.06633615e-02f, -4.05724980e-02f, -2.73387674e-02f, 1.35797830e-02f, 6.37738109e-02f,
  6.08620346e-02f, 6.28197752e-03f, -1.40901422e-02f, 5.49721308e-02f, 1.54610956e-02f, 5.81061132e-02f, 3.72805633e-02f, -1.71331853e-01f, 7.60456994e-02f, -2.11604908e-01f,
  -1.88421845e-01f, 1.54023588e-01f, 4.82737646e-02f, -8.81080776e-02f, 2.80871809e-01f, 1.48677722e-01f, -1.06931679e-01f, 5.94730340e-02f, 7.08411774e-03f, -1.16230890e-01f,
  -3.76038589e-02f, -1.78060859e-01f, -4.30462286e-02f, -2.40764588e-01f, -1.33868873e-01f, -3.04315127e-02f, 1.15563525e-02f, 6.62636608e-02f, -1.32485762e-01f, 7.27373436e-02f,
  -4.95132096e-02f, -2.25273855e-02f, -6.95055798e-02f, 1.78208146e-02f, 2.37526689e-02f, -4.57944945e-02f, -8.03351328e-02f, 9.19374600e-02f, 1.00693829e-01f, -2.25215461e-02f,
  3.42084616e-02f, -2.54288837e-02f, 5.09293638e-02f, 1.71285719e-02f, 4.34895903e-02f, -1.02093287e-01f, -4.49819006e-02f, -2.67020054e-02f, -7.97639936e-02f, -3.33302096e-02f,
  5.83668845e-03f, -6.70553669e-02f, -5.67337051e-02f, 7.99613446e-02f, 4.27851863e-02f, -3.04826200e-02f, 2.40014009e-02f, -3.69448820e-03f, -3.52742895e-02f, -1.62098389e-02f,
  -1.39757050e-02f, 7.09353089e-02f, 2.94288211e-02f, -2.44376156e-02f, -7.00992020e-03f, -1.18787363e-01f, 1.49980281e-02f, -1.24123190e-02f, 7.16948360e-02f, -5.56353368e-02f,
  2.01285183e-02f, 2.65629329e-02f, 4.97160964e-02f, 6.75605983e-02f, -2.18838155e-02f, 5.68465255e-02f, 2.75976043e-02f, 9.66209695e-02f, -5.52364923e-02f, -1.31243924e-02f,
  4.30263206e-02f, -4.47640382e-02f, 4.30634990e-02f, -7.05772499e-03f, 2.21221447e-02f, 8.63974541e-02f, -3.84477042e-02f, 6.07325099e-02f, 2.71368865e-02f, 3.93810086e-02f,
  8.77995268e-02f, 7.91870430e-02f, 1.05523273e-01f, -1.12653792e-01f, 3.78668793e-02f, 6.83219172e-03f, 2.53851269e-03f, -9.24220588e-03f, 7.10332617e-02f, -3.46600115e-02f,
  -8.09212998e-02f, -1.27240997e-02f, 6.20212443e-02f, -3.28933559e-02f, 2.66287215e-02f, -1.73126888e-02f, 6.02951795e-02f, 1.35883195e-02f, 1.10563673e-01f, -5.52557297e-02f,
  8.77130590e-03f, 7.60736614e-02f, 3.00820731e-02f, -4.02482487e-02f, -3.40357386e-02f, -4.93169166e-02f, 4.83332612e-02f, 8.38843957e-02f, -4.09449413e-02f, -5.14207035e-02f,
  7.25676641e-02f, -5.71049899e-02f, 4.53928784e-02f, -8.62121582e-02f, -1.82765797e-01f, -2.41803393e-01f, -1.49142161e-01f, -4.40871753e-02f, -2.60269046e-01f, -1.61365345e-02f,
  -1.12331197e-01f, -9.40071493e-02f, 1.46886095e-01f, -9.36095715e-02f, -1.23159453e-01f, -1.42838815e-02f, -1.44748136e-01f, -3.60246822e-02f, 2.39479616e-02f, 6.51217028e-02f,
  4.99142185e-02f, -4.30829860e-02f, -4.61888686e-02f, 5.26279546e-02f, -3.92871872e-02f, 1.32329211e-01f, -1.10341348e-02f, -5.19624799e-02f, 5.82792098e-03f, -1.44929335e-01f,
  2.78844554e-02f, -1.45855574e-02f, -3.70058231e-03f, 2.66870465e-02f, 8.91909525e-02f, 4.49143089e-02f, 1.46701187e-01f, -7.04386979e-02f, -5.55709749e-02f, 7.94877822e-04f,
  9.34357718e-02f, -3.08791194e-02f, -3.45214866e-02f, -5.18413708e-02f, -6.15040734e-02f, -5.75686321e-02f, 8.86020809e-02f, -9.95540023e-02f, -3.16499248e-02f, -1.33180143e-02f,
  -1.02711432e-01f, -5.57351410e-02f, 4.40798104e-02f, -2.66128071e-02f, -2.42743585e-02f, -2.46295650e-02f, -2.72427350e-02f, -4.07983288e-02f, -7.29154050e-02f, -5.89810796e-02f,
  -5.21727018e-02f, -1.72514189e-02f, 8.49717483e-02f, 1.34576038e-02f, 2.82948855e-02f, 8.03150609e-03f, -9.62761566e-02f, 7.26111084e-02f, 1.54479779e-02f, 4.50607911e-02f,
  -3.79975066e-02f, -3.43867093e-02f, 1.17902365e-02f, -3.72770056e-02f, 5.20177260e-02f, 3.89992408e-02f, 3.31254862e-02f, 4.87139970e-02f, 2.91543975e-02f, -4.74116430e-02f,
  -4.28327024e-02f, 3.24960910e-02f, -1.02428033e-03f, -6.32306039e-02f, 5.93460805e-04f, -3.78697598e-03f, 5.26986085e-04f, -5.94914407e-02f, 8.54936987e-02f, -2.98555586e-02f,
  -1.34953884e-02f, 1.63370252e-01f, -1.10013768e-01f, 2.59327982e-03f, 7.13208392e-02f, -8.07754975e-03f, -3.44820917e-02f, 6.84899166e-02f, 4.68108896e-03f, 5.53227998e-02f,
  -6.40756488e-02f, -3.77915837e-02f, -1.02519654e-02f, 9.75416880e-03f, 5.35309687e-02f, 1.79224852e-02f, 1.66438557e-02f, 5.57441823e-02f, -5.16997576e-02f, 3.26841585e-02f,
  1.13772683e-01f, 6.44384995e-02f, 9.81033128e-03f, 1.85004101e-04f, -5.08947438e-03f, 8.92477334e-02f, -5.08913654e-04f, -2.12808158e-02f, 6.74086735e-02f, -2.31305906e-03f,
  4.42601860e-01f, -1.10129297e-01f, -2.50749178e-02f, 3.06576639e-01f, 1.02649547e-01f, -9.02427882e-02f, -1.46294624e-01f, 6.11367077e-02f, 2.12784618e-01f, -1.80203632e-01f,
  -8.69839545e-03f, 1.66618675e-01f, -8.66573304e-02f, 1.56869128e-01f, 3.46234202e-01f, 8.23812112e-02f, 1.75815761e-01f, 1.04968734e-02f, 1.28929332e-01f, 7.18027577e-02f,
  1.47983536e-01f, 9.86386761e-02f, -9.98437777e-02f, -1.26681849e-01f, -1.36558637e-01f, -3.54083255e-02f, -7.68883750e-02f, -1.50805801e-01f, -5.87255508e-02f, 2.02401802e-02f,
  -1.26081765e-01f, 5.96940070e-02f, -6.52479604e-02f, 3.63313593e-02f, -2.91534923e-02f, -4.31002676e-02f, -2.33409610e-02f, -5.47790714e-03f, -2.15845741e-03f, 4.25612964e-02f,
  2.99004931e-02f, 3.80438268e-02f, 6.06512204e-02f, 4.48278300e-02f, 3.57149588e-03f, -2.51083598e-02f, -4.52792309e-02f, -9.20847710e-03f, 3.66176642e-03f, 3.31630073e-02f,
  -1.43114235e-02f, 2.09703809e-03f, 1.83548871e-02f, 5.70819266e-02f, 4.22189012e-02f, 1.19258715e-02f, -6.63235039e-02f, -9.59948823e-02f, 2.19610222e-02f, 4.68582039e-05f,
  3.59862410e-02f, 5.40198721e-02f, -5.16765527e-02f, 6.12272285e-02f, -1.10822904e-03f, -1.34117370e-02f, 4.34034206e-02f, -3.19588743e-02f, -1.48643805e-02f, -6.04713475e-03f,
  9.83010512e-03f, -4.60659806e-03f, 5.64764664e-02f, -5.64129204e-02f, -5.62555529e-02f, -4.75392044e-02f, 1.03165843e-02f, -2.73308740e-03f, -1.71014760e-02f, 2.17360612e-02f,
  -1.22928647e-02f, 4.88070212e-03f, 3.50470701e-03f, -2.71440316e-02f, -3.09998970e-02f, -3.41628566e-02f, 3.19679193e-02f, -3.95056307e-02f, 1.35329692e-02f, 3.76803763e-02f,
  3.39338779e-02f, 1.16123192e-01f, 6.35060202e-03f, -3.68902571e-02f, 6.29556701e-02f, 3.71602364e-02f, 4.26098928e-02f, -3.61461267e-02f, 6.20021261e-02f, 1.89204291e-02f,
  4.52848040e-02f, -6.02283739e-02f, 2.45475061e-02f, -5.76778827e-03f, -1.37443356e-02f, 2.65983250e-02f, 5.07123992e-02f, -4.10190038e-02f, -1.31579814e-02f, 1.89910792e-02f,
  4.68693813e-03f, 2.42617223e-02f, 5.30208610e-02f, -6.20180070e-02f, 1.13684533e-03f, 5.59252501e-02f, 4.85266335e-02f, 2.51456480e-02f, 4.34117913e-02f, 4.44174148e-02f,
  1.37679383e-01f, -2.16185953e-02f, 3.53421196e-02f, 1.21800579e-01f, -8.85738134e-02f, -9.74133203e-04f, 1.17762603e-01f, -3.61834876e-02f, -3.38271856e-02f, 4.43714000e-02f,
  -2.32233689e-03f, 3.16345021e-02f, 2.88727656e-02f, -8.62063915e-02f, 6.88121021e-02f, 6.38252944e-02f, 3.70692722e-02f, 3.36047933e-02f, -2.94106975e-02f, 1.49992630e-02f,
  6.06420003e-02f, -1.18928300e-02f, -8.26597288e-02f, -1.23028792e-01f, 1.79237537e-02f, 5.46445884e-02f, 9.26576257e-02f, 1.14941597e-02f, 7.39891827e-02f, -6.65021911e-02f,
  4.11872119e-02f, 4.40038256e-02f, 4.18906398e-02f, 1.81590840e-02f, -2.16734447e-02f, 2.75201593e-02f, -2.59090643e-02f, 3.18765338e-03f, 2.88997069e-02f, -1.06383895e-03f,
  8.71968046e-02f, -5.71700595e-02f, -3.72879878e-02f, -1.12378120e-01f, -6.84265420e-02f, -6.78117871e-02f, 5.18486127e-02f, -2.75920555e-02f, 5.18205389e-02f, -2.82951035e-02f,
  -4.12410274e-02f, -8.30249209e-03f, 4.94748063e-04f, 9.65956002e-02f, 3.68958935e-02f, -7.46645629e-02f, 4.14779112e-02f, 9.91799608e-02f, 1.06092952e-01f, 3.35351937e-02f,
  -1.53376475e-01f, -8.44939202e-02f, -8.62710085e-03f, -4.63026613e-02f, 2.74949577e-02f, 7.58075714e-02f, -1.53995557e-02f, 6.13870844e-02f, 6.79216385e-02f, 6.29467145e-03f,
  1.46635436e-02f, -6.52013496e-02f, -3.43164615e-02f, -1.94196273e-02f, -2.67787874e-02f, 2.09588483e-02f, 9.27079841e-02f, -4.07146588e-02f, -5.07166944e-02f, -4.48591001e-02f,
  -2.96719410e-02f, 6.18537925e-02f, -2.62341257e-02f, 9.70489383e-02f, 2.57282029e-03f, -2.31915563e-02f, -4.89185899e-02f, 1.03990197e-01f, 2.34114286e-02f, -2.89961472e-02f,
  1.81191072e-01f, 1.69164613e-01f, -7.14654550e-02f, 3.86496447e-02f, 3.66898067e-02f, 7.56164640e-02f, 3.83220352e-02f, 5.76528199e-02f, 5.86168282e-02f, -4.76386100e-02f,
  -6.49648206e-03f, 7.78521821e-02f, -4.10172194e-02f, 7.30942711e-02f, -4.29892652e-02f, 1.29161086e-02f, 8.02466199e-02f, 7.66703784e-02f, 5.41248769e-02f, -5.90544529e-02f,
  1.88940261e-02f, -8.53905734e-03f, -2.97393221e-02f, 2.94639878e-02f, -3.69915180e-02f, -2.80180275e-02f, 2.43401192e-02f, -6.47935867e-02f, -5.64378733e-03f, -6.32948056e-02f,
  -5.60440533e-02f, -2.54357338e-01f, 1.13897704e-01f, -1.33170798e-01f, 4.79865596e-02f, 5.09702973e-02f, 8.22132304e-02f, -1.81743093e-02f, 3.83026376e-02f, -2.83219457e-01f,
  -7.10270628e-02f, -1.92978978e-01f, -8.32921863e-02f, -4.39972617e-02f, 2.85218507e-01f, 1.53484792e-01f, 7.50362650e-02f, -7.00414702e-02f, 9.75047424e-02f, -4.43703793e-02f,
  7.71616548e-02f, 4.48009558e-02f, 1.09809779e-01f, -1.05338313e-01f, -2.55075172e-02f, -4.54478934e-02f, 8.27833824e-03f, -8.71075317e-02f, -3.75823267e-02f, -7.80630251e-03f,
  -6.74472675e-02f, -8.61203298e-02f, -4.73985821e-03f, -4.48265187e-02f, -2.65583172e-02f, 3.86928953e-02f, 2.47770101e-02f, 8.34506378e-02f, 1.02411799e-01f, -5.99625111e-02f,
  2.24899650e-02f, 3.04663833e-02f, 6.67546988e-02f, 2.31846236e-02f, -4.16367762e-02f, -7.27980882e-02f, -3.91520262e-02f, 8.14565085e-03f, -5.69977351e-02f, 8.58150274e-02f,
  -5.96413463e-02f, 2.96682939e-02f, 3.14120464e-02f, 2.81277876e-02f, 1.17562339e-01f, 6.25302717e-02f, 8.29219669e-02f, -2.07013134e-02f, 5.07411808e-02f, -4.49950621e-02f,
  -6.04894385e-03f, 1.83183346e-02f, -6.53439835e-02f, -3.15273181e-02f, -8.26467499e-02f, -1.45303225e-02f, -1.00210339e-01f, -9.93241835e-03f, 1.74109638e-02f, -4.98005114e-02f,
  -2.39028707e-02f, -3.58490497e-02f, -4.24195267e-02f, 8.20398517e-03f, 3.97197492e-02f, -1.82917155e-02f, 7.85363745e-03f, -6.42832592e-02f, 3.44053060e-02f, 1.08137600e-01f,
  -2.33495869e-02f, 3.37778442e-02f, -8.17617700e-02f, 9.41647440e-02f, -4.02615294e-02f, -5.95683977e-03f, -3.03158518e-02f, -1.67851411e-02f, -6.00901358e-02f, 8.03246442e-03f,
  -1.62294358e-01f, -2.36663356e-01f, 3.58139426e-02f, -9.41809341e-02f, -4.88217622e-02f, -3.52065341e-04f, 4.55426648e-02f, -1.84773549e-03f, -9.07153636e-03f, -2.19900273e-02f,
  -1.53072122e-02f, -7.11654052e-02f, -2.01593861e-02f, 1.05459780e-01f, -7.08689392e-02f, 1.47452310e-01f, 6.59616813e-02f, -5.68889715e-02f, -4.12042700e-02f, -5.80436997e-02f,
  -1.47350281e-01f, -9.16018113e-02f, 1.47766788e-02f, 1.23040155e-02f, 2.95898644e-03f, -1.29303727e-02f, 4.91716377e-02f, -1.85054466e-02f, 8.98990780e-03f, 9.25519764e-02f,
  2.15204313e-01f, -1.33506611e-01f, 2.17575077e-02f, 2.75325447e-01f, -4.89557460e-02f, -1.77667663e-02f, 7.82181248e-02f, -1.07093722e-01f, 5.89372478e-02f, -1.20854430e-01f,
  7.47717023e-02f, -3.47177940e-03f, -5.77216633e-02f, 2.34754637e-01f, 3.01855922e-01f, 2.33940110e-02f, 2.30542839e-01f, 1.50917917e-01f, 1.09398022e-01f, 6.21122941e-02f,
  1.70634970e-01f, 1.29855171e-01f, 1.71151519e-01f, 2.68897004e-02f, 4.87539284e-02f, -6.81997314e-02f, 5.63310832e-02f, 5.78748435e-03f, 4.79814149e-02f, 1.53721482e-01f,
  5.49488552e-02f, -7.64964614e-03f, -5.98057918e-02f, 7.51798525e-02f, -6.89093098e-02f, 1.05323093e-02f, 2.57396810e-02f, 1.29370224e-02f, 7.61370659e-02f, -3.28042475e-03f,
  -1.75602827e-02f, 8.01032111e-02f, -4.20107096e-02f, -8.43635425e-02f, 2.89907288e-02f, 5.80853559e-02f, -3.11941449e-02f, -8.58045444e-02f, 1.02844231e-01f, -7.37606287e-02f,
  1.74669754e-02f, -2.82199364e-02f, 4.04153578e-02f, 1.23943733e-02f, 4.92095761e-02f, -2.30045114e-02f, -5.45471124e-02f, 3.47499438e-02f, 1.33531386e-04f, 3.76565428e-03f,
  -3.04400409e-03f, 5.10539301e-03f, 1.31875472e-02f, 9.58501026e-02f, 5.24886772e-02f, -1.07661346e-02f, 9.09467135e-03f, -8.25943612e-03f, -1.06656952e-02f, 6.53803814e-03f,
  -3.16343904e-02f, -5.90203516e-02f, 6.98734149e-02f, -3.41861919e-02f, 5.79219162e-02f, 2.43831370e-02f, 8.64607096e-02f, -3.91066000e-02f, 6.90918788e-02f, -7.09312335e-02f,
  -7.30043501e-02f, 6.26332313e-02f, 1.74905434e-02f, 9.33193713e-02f, 2.22917981e-02f, -1.76084694e-03f, 6.72825277e-02f, -4.92448406e-03f, 3.79588194e-02f, 3.55139077e-02f,
  -3.27057727e-02f, -1.65802628e-01f, 7.68869445e-02f, -8.47219862e-03f, 3.72326784e-02f, 2.46917829e-02f, 1.81641690e-02f, -1.49585651e-02f, -3.23581994e-02f, 7.57310726e-03f,
  -3.68671454e-02f, 1.74979772e-02f, -4.13854793e-03f, 7.29121566e-02f, 3.85075621e-02f, -1.00703470e-01f, -1.55496562e-03f, -7.60299573e-03f, 1.79004576e-02f, 1.02107124e-02f,
  -6.39666766e-02f, -1.26101160e-02f, 7.89057314e-02f, -1.16657037e-02f, -4.01583202e-02f, -6.56549037e-02f, -1.72998812e-02f, 1.47217428e-02f, -9.70908403e-02f, -6.13238551e-02f,
  8.55593458e-02f, -8.48430246e-02f, -6.82272688e-02f, 6.10569753e-02f, -1.50147844e-02f, 3.25086936e-02f, -1.15650604e-02f, 2.02677622e-02f, 4.40906025e-02f, -6.93795830e-02f,
  2.11500544e-02f, -1.14522211e-01f, -7.42004439e-03f, 1.04005903e-01f, 1.63335241e-02f, 4.19904068e-02f, 1.53880879e-01f, 1.49561092e-02f, -3.72819528e-02f, -2.01784801e-02f,
  8.30865875e-02f, 1.07458971e-01f, 7.72015974e-02f, 1.08686738e-01f, 9.55834463e-02f, -4.19352688e-02f, -3.18116881e-02f, -4.25589457e-03f, 1.27607077e-01f, 3.11193243e-02f,
  1.02681793e-01f, 3.45195904e-02f, 6.34955522e-03f, 7.00397640e-02f, 4.91900034e-02f, 9.29495245e-02f, 6.46754131e-02f, 2.19690632e-02f, -1.10784415e-02f, -1.76716950e-02f,
  -5.98839596e-02f, -4.72984202e-02f, 8.38258117e-02f, 2.85104662e-02f, -1.92072205e-02f, -2.67358068e-02f, 1.99459512e-02f, -1.00754183e-02f, -7.92685002e-02f, 5.06889448e-03f,
  -5.97440340e-02f, -6.50966028e-03f, 4.31266837e-02f, 4.86032777e-02f, 2.58531366e-02f, 1.13043740e-01f, 6.17022254e-02f, -4.36595567e-02f, -6.14286438e-02f, 6.25352003e-03f,
  -6.54409677e-02f, -2.35759113e-02f, -6.56393841e-02f, 3.54300365e-02f, 1.41951535e-02f, 1.70255974e-02f, -6.94276467e-02f, -3.32718864e-02f, 7.24709332e-02f, 3.78867052e-02f,
  9.08113047e-02f, 2.26740185e-02f, 3.75866666e-02f, -1.37671065e-02f, -8.36610794e-03f, 2.32085697e-02f, -5.99000417e-02f, 2.32150909e-02f, -2.48854444e-03f, 1.62660070e-02f,
  -5.92631660e-03f, -3.65811735e-02f, -2.90174428e-02f, -3.83845135e-03f, 5.31742256e-03f, 6.59224764e-02f, -6.37206286e-02f, 4.21292670e-02f, -5.02830260e-02f, 1.54123269e-02f,
  -4.77170944e-02f, -1.37905739e-02f, -1.51753416e-02f, -9.83405709e-02f, -3.62419523e-03f, -6.22690581e-02f, -1.71609093e-02f, 4.90088388e-02f, 5.27184792e-02f, 5.38992397e-02f,
  3.47047076e-02f, 6.01700544e-02f, -1.46451723e-02f, -3.20125669e-02f, 3.09251528e-02f, 1.70702767e-03f, -7.92048350e-02f, -6.03307746e-02f, -1.61338376e-03f, 6.80720508e-02f,
  -3.98895293e-02f, -3.49549130e-02f, -2.42266450e-02f, -3.72079201e-02f, -2.19929665e-02f, -5.03274193e-03f, -3.32653411e-02f, 3.93942036e-02f, -5.61382808e-02f, 5.54132313e-02f,
  3.85860652e-01f, -8.20126086e-02f, 1.37043461e-01f, 8.89163688e-02f, 5.14811352e-02f, 4.09319073e-01f, 5.49955249e-01f, -7.50758732e-03f, 1.51319399e-01f, 1.53857380e-01f,
  1.38044551e-01f, -1.21934116e-01f, 2.19099090e-01f, 6.87283427e-02f, 3.16789478e-01f, 1.97009712e-01f, 1.27334461e-01f, 6.89018443e-02f, -1.00286022e-01f, 2.29495671e-02f,
  -3.80353741e-02f, 9.96324942e-02f, 1.22072054e-02f, -1.12022445e-01f, 1.31388102e-02f, -1.56745031e-01f, 1.53473672e-02f, 1.86085422e-02f, -5.17002605e-02f, -5.61431656e-03f,
  9.02018398e-02f, 5.72476611e-02f, -5.79705136e-03f, 6.61527412e-03f, 6.24999478e-02f, 3.21132578e-02f, -1.65621974e-02f, 5.98558187e-02f, 2.47074813e-02f, -1.73810571e-02f,
  -2.61672661e-02f, -5.35763726e-02f, -3.89500223e-02f, 4.12403643e-02f, 4.12832052e-02f, -3.20260227e-02f, -1.08391605e-01f, -3.95994484e-02f, -7.22089633e-02f, -5.39847240e-02f,
  -6.23388328e-02f, -7.04691857e-02f, -3.01300474e-02f, 2.12731734e-02f, 3.90911214e-02f, 9.39161703e-03f, 4.99936529e-02f, 3.27307098e-02f, -5.13744988e-02f, 1.75213162e-02f,
  4.61242944e-02f, 6.16131201e-02f, 2.80039348e-02f, 5.57840802e-02f, 1.30503140e-02f, -1.52838079e-03f, 2.88687106e-02f, 9.40974336e-03f, -7.61903939e-04f, 2.88376287e-02f,
  -1.65508781e-02f, 1.43868709e-03f, 3.52836773e-03f, -2.99099665e-02f, -2.68359371e-02f, -2.56752521e-02f, -5.12272585e-03f, -6.03471249e-02f, 3.39601599e-02f, -6.75631594e-03f,
  -9.52105224e-03f, 3.89260165e-02f, -1.93571951e-02f, -5.04710600e-02f, 8.78375620e-02f, 2.75231116e-02f, -5.89502603e-03f, -1.07091758e-02f, -2.98287198e-02f, -9.21445061e-03f,
  -1.17113180e-01f, 6.02661036e-02f, -4.21135947e-02f, 1.39888525e-02f, -3.68543640e-02f, -3.85021046e-02f, 1.61886439e-02f, -1.82871241e-02f, -2.62384973e-02f, 6.49698377e-02f,
  -2.09570453e-02f, 6.12543859e-02f, 1.16376707e-03f, -2.72150361e-03f, -5.42667285e-02f, 6.66134953e-02f, 4.04317155e-02f, 2.87712775e-02f, -2.65072808e-02f, 1.61526557e-02f,
  3.20647061e-02f, 6.31342083e-02f, 8.97906795e-02f, 3.55729531e-03f, -4.54406161e-03f, 1.23247668e-01f, -5.47095388e-02f, -4.65157181e-02f, -3.73586006e-02f, 6.70464858e-02f,
  -1.56698748e-01f, -7.47474208e-02f, 6.17690086e-02f, -1.06076390e-01f, -1.00672059e-02f, -1.56118199e-01f, -1.10377772e-02f, -9.68401656e-02f, 8.48471001e-03f, -3.95899788e-02f,
  -8.07261094e-02f, 6.96456581e-02f, 1.86296791e-01f, -5.87908253e-02f, 1.80776685e-01f, 4.40209284e-02f, -1.65864021e-01f, -4.32855003e-02f, -8.20255354e-02f, -7.76744112e-02f,
  4.92229015e-02f, -7.80560672e-02f, -5.70270978e-02f, -5.39706945e-02f, -2.89120451e-02f, -8.05160776e-02f, -1.61668304e-02f, 1.17866769e-01f, 3.64751071e-02f, -7.12697301e-03f,
  5.63759655e-02f, 6.93479106e-02f, -1.03992201e-01f, 2.63601467e-02f, -8.15208033e-02f, -8.25403333e-02f, 2.41104420e-02f, 7.84204230e-02f, -4.67628762e-02f, 1.13153398e-01f,
  -4.09871675e-02f, 6.16205260e-02f, -6.86333254e-02f, 5.60037652e-03f, -1.56438164e-02f, -6.14526263e-03f, 4.46415097e-02f, -4.26005200e-02f, -6.24150177e-03f, 6.24047704e-02f,
  1.51802544e-02f, -8.59431475e-02f, -5.55543117e-02f, -4.49564904e-02f, 4.03435118e-02f, 9.27793048e-03f, -3.16060819e-02f, 7.15342909e-02f, -6.32053018e-02f, -5.47401682e-02f,
  -1.44878787e-03f, -3.47879604e-02f, -4.15312909e-02f, -3.29273082e-02f, -4.91278879e-02f, 9.54690054e-02f, 8.13735053e-02f, -1.29368771e-02f, 8.53288695e-02f, 4.78664674e-02f,
  7.79786939e-03f, -3.91231664e-02f, -4.98295054e-02f, -4.96178344e-02f, -5.06546125e-02f, 1.98494121e-02f, -3.08530740e-02f, 1.94001407e-03f, -2.41987947e-02f, -7.72349164e-02f,
  8.44186451e-03f, -4.20354642e-02f, -5.49591705e-02f, -3.77732352e-03f, -3.58271897e-02f, 2.26551183e-02f, 6.55910596e-02f, 4.10582088e-02f, 3.15153063e-03f, 9.31002796e-02f,
  -1.08627751e-01f, 9.85632092e-03f, -8.02765116e-02f, 6.99677616e-02f, -4.84389812e-02f, 1.43165709e-02f, 7.72596523e-03f, -3.38482670e-02f, -1.06773404e-02f, 5.02663516e-02f,
  1.68374758e-02f, 1.90545041e-02f, 4.95285168e-02f, -4.35946770e-02f, -4.06975448e-02f, -1.02896832e-01f, -6.94426224e-02f, 3.04763988e-02f, -6.23636916e-02f, 4.89176763e-03f,
  3.87748592e-02f, -6.41496629e-02f, 7.71878958e-02f, -7.51966089e-02f, -1.29558137e-02f, -8.39404017e-02f, 1.95647217e-03f, 7.29974592e-03f, 2.36001462e-02f, -1.38247665e-02f,
  -1.59812450e-01f, -3.34404707e-01f, 1.23241611e-01f, -1.13032453e-01f, 1.88537955e-01f, 6.56543206e-03f, 2.21049085e-01f, -1.65889084e-01f, -1.72648996e-01f, -1.58193186e-01f,
  1.61384344e-01f, -2.29756117e-01f, 3.95574160e-02f, 1.71860635e-01f, 1.87558115e-01f, 2.85196584e-02f, 8.24376643e-02f, -6.62417561e-02f, -5.27574420e-02f, -8.10766146e-02f,
  1.06044106e-01f, 1.79153308e-01f, 2.37642169e-01f, 5.59152365e-02f, 7.40129948e-02f, -1.14817247e-01f, 5.69238700e-02f, 1.20841473e-01f, 1.56428069e-02f, -2.02091206e-02f,
  1.47659674e-01f, -9.31445733e-02f, -4.35302826e-03f, -7.19472691e-02f, 6.93540275e-02f, -5.94611764e-02f, 4.25280929e-02f, 4.63602804e-02f, 1.38378162e-02f, 1.22842245e-01f,
  -5.73034100e-02f, 2.10429337e-02f, 1.25563415e-02f, -7.22060772e-03f, 6.70384616e-03f, -3.56836133e-02f, -3.04034259e-02f, -4.13740519e-03f, 3.10716499e-02f, -2.95939688e-02f,
  4.44536172e-02f, -1.17634647e-02f, 3.22291851e-02f, 1.18927164e-02f, -4.64817928e-03f, -3.63670476e-02f, -1.47356475e-02f, -8.63156468e-03f, -1.90254059e-02f, -5.61383478e-02f,
  -4.24689986e-02f, -6.96269562e-04f, 7.26507381e-02f, 6.05183979e-03f, 2.44511962e-02f, 5.38113015e-03f, 1.01707280e-01f, -2.73835994e-02f, 4.49135005e-02f, 2.61588767e-03f,
  4.92534488e-02f, 3.77355400e-03f, -4.72990647e-02f, 3.38921770e-02f, -1.15412278e-02f, -2.24898774e-02f, 2.02544988e-03f, 1.70560479e-02f, -2.47327350e-02f, -6.75321296e-02f,
  -3.04961042e-03f, -2.49246713e-02f, 7.14909509e-02f, 6.18764944e-02f, 1.35539044e-02f, -1.60818435e-02f, 9.14265588e-03f, -5.64178638e-02f, 6.46911636e-02f, -7.23097473e-03f,
  -2.46387929e-01f, -3.21494222e-01f, -2.98201721e-02f, 4.85473387e-02f, 1.86439417e-02f, 3.34121846e-02f, -2.75839642e-02f, -6.69865496e-03f, 8.98031238e-03f, -1.47342402e-03f,
  1.49355987e-02f, 4.70032468e-02f, -3.50340083e-02f, -5.55517077e-02f, -5.72410226e-02f, -3.20276208e-02f, -2.72804890e-02f, -2.50018239e-02f, -7.49118766e-03f, -2.55839750e-02f,
  -5.42062372e-02f, 9.55151021e-03f, 7.50119165e-02f, -7.89340883e-02f, -1.03129102e-02f, -5.11576608e-03f, -1.32336184e-01f, -3.80829312e-02f, -1.00880666e-02f, 2.91576516e-02f,
  -7.29767680e-02f, -1.45134896e-01f, 1.49245396e-01f, -4.09385981e-03f, -3.92821543e-02f, 1.12999909e-01f, -1.63996220e-02f, -1.11985669e-01f, -1.63526635e-03f, -1.56226113e-01f,
  5.89183755e-02f, -8.26169550e-02f, 3.61542627e-02f, -5.31106479e-02f, 1.83927193e-01f, -3.14836986e-02f, -5.27111366e-02f, -8.06503277e-03f, 1.95515323e-02f, -1.30192563e-03f,
  -3.02244499e-02f, -6.48039356e-02f, 1.72408029e-01f, 7.73622170e-02f, -4.94816108e-03f, -5.67128183e-03f, -9.68067497e-02f, -4.88783829e-02f, 3.16226035e-02f, 7.37885609e-02f,
  3.27122137e-02f, 8.85342527e-03f, 4.47824337e-02f, 1.88776273e-02f, 7.49380663e-02f, 2.30844561e-02f, 3.49473059e-02f, 7.12395236e-02f, 4.97457152e-03f, 2.21864693e-02f,
  2.38765255e-02f, -3.28129008e-02f, 3.46513372e-03f, -5.22993915e-02f, -8.09243601e-03f, 1.08736253e-03f, 1.79435499e-02f, -3.20379734e-02f, 1.92910079e-02f, -5.29839545e-02f,
  1.11871071e-01f, 5.86974919e-02f, -3.92996930e-02f, -6.52834699e-02f, -4.28846925e-02f, -2.95717940e-02f, 3.58955339e-02f, 9.43883955e-02f, -6.70488104e-02f, 1.78083312e-02f,
  -1.08285993e-01f, -4.55256328e-02f, 2.63264291e-02f, 3.48848216e-02f, 6.20063804e-02f, 4.28498872e-02f, -1.26207173e-02f, 3.29875350e-02f, -2.14909445e-02f, -1.22725517e-02f,
  -3.31278518e-02f, 4.90771793e-03f, 2.49571241e-02f, -3.43497135e-02f, -1.04217537e-01f, -2.97115501e-02f, -7.42823165e-03f, 1.50834331e-02f, 2.33437754e-02f, 6.86113611e-02f,
  2.67255325e-02f, 9.14564356e-02f, -1.00143023e-01f, -5.71091659e-02f, 5.11107445e-02f, 5.66675402e-02f, -4.65339832e-02f, -5.95267899e-02f, -6.46482334e-02f, 4.38938066e-02f,
  -2.97590881e-03f, -1.81266189e-01f, -7.38564180e-03f, -4.94063869e-02f, -5.09638861e-02f, -2.84971111e-02f, -7.15486258e-02f, -1.44623397e-02f, -2.28278302e-02f, -5.03539629e-02f,
  -1.10788159e-02f, -2.11486276e-02f, 3.19340527e-02f, 7.76597671e-03f, 8.16566348e-02f, -3.84042673e-02f, 4.30349372e-02f, 1.88374780e-02f, 5.30430116e-03f, 2.47768266e-03f,
  6.65581822e-02f, 7.93503411e-03f, -6.90611918e-03f, 5.59625700e-02f, 5.19561023e-02f, 2.23199674e-03f, -2.46147420e-02f, 2.13571899e-02f, 1.50473360e-02f, -7.65283480e-02f,
  5.99186160e-02f, 3.62684488e-01f, 1.21292390e-01f, 3.42497736e-01f, -4.29829806e-02f, 1.72419176e-01f, 1.97910652e-01f, 4.26790528e-02f, 1.52849630e-01f, -3.04340255e-02f,
  5.28376289e-02f, 1.00462519e-01f, -1.06517442e-01f, 2.42579430e-01f, 1.85417742e-01f, 3.25638987e-02f, 1.81852683e-01f, 6.67648539e-02f, 7.30932876e-02f, -1.18675809e-02f,
  -2.40922552e-02f, 8.88941810e-02f, 1.84059694e-01f, 1.97337195e-02f, 8.07845592e-02f, 3.24441418e-02f, -5.66049367e-02f, -2.80600991e-02f, 5.96677065e-02f, -1.95335019e-02f,
  1.61724359e-01f, 1.54033964e-02f, -4.70359139e-02f, -7.17775896e-02f, 4.52388898e-02f, -8.99475440e-02f, -8.85100011e-03f, 1.36096910e-01f, 1.38837323e-02f, 1.75875425e-02f,
  -1.07632689e-01f, 2.08733301e-03f, 4.56638001e-02f, 1.61971767e-02f, 1.88120324e-02f, 7.04916613e-03f, 5.63369170e-02f, 4.19635698e-02f, 7.59298876e-02f, 5.18093035e-02f,
  1.67262033e-02f, -2.89301965e-02f, 5.26560890e-03f, -3.11409775e-02f, 4.65915278e-02f, 1.13597892e-01f, 6.55548126e-02f, 1.02309454e-02f, 2.87676714e-02f, 2.40826122e-02f,
  2.54107136e-02f, 3.24958749e-03f, 2.23121010e-02f, 4.31078374e-02f, 3.26814018e-02f, 2.87103057e-02f, -3.08547802e-02f, -2.00809520e-02f, 5.51244197e-03f, 6.66804798e-03f,
  3.49386781e-02f, -6.60975277e-02f, -7.52809551e-03f, 3.97998956e-04f, 1.50311915e-02f, -8.22587125e-03f, -2.94977669e-02f, -1.04498887e-03f, 5.48513047e-02f, -3.13010886e-02f,
  5.93236424e-02f, 3.38609181e-02f, -6.64535835e-02f, -8.14256296e-02f, 7.01234862e-03f, 1.95935443e-02f, -1.90225877e-02f, -7.96506405e-02f, -3.12725641e-02f, -2.65201051e-02f,
  9.14476067e-02f, 7.16685653e-02f, -2.61776950e-02f, -2.74724457e-02f, -5.50609343e-02f, -2.94324141e-02f, 4.22176085e-02f, 1.59371663e-02f, -2.24835593e-02f, 4.32123343e-04f,
  -1.10882826e-01f, -1.36859650e-02f, -9.33331102e-02f, -5.01059601e-03f, -1.29402205e-02f, 7.30873421e-02f, -5.53108081e-02f, -2.61611510e-02f, 4.90604667e-03f, 1.83048379e-02f,
  1.14837829e-02f, -2.80249640e-02f, -7.74843618e-02f, 6.24244567e-03f, -4.99815419e-02f, -6.99691772e-02f, 2.88409647e-02f, 7.28483796e-02f, -3.17338444e-02f, -5.57648344e-03f,
  -1.45803958e-01f, 1.50556698e-01f, -1.40878931e-01f, -5.55250468e-03f, -4.93416004e-02f, -1.90917909e-01f, -1.85985297e-01f, 3.90636735e-02f, -7.91374817e-02f, 1.53188676e-01f,
  1.09162316e-01f, -1.30250931e-01f, 6.89028054e-02f, 2.78362297e-02f, -3.79807279e-02f, -9.24507435e-03f, 7.25571662e-02f, -1.60629358e-02f, -2.21186224e-02f, -1.23213768e-01f,
  -5.95242754e-02f, 5.65157011e-02f, 6.09169491e-02f, 2.44327658e-03f, -1.13153551e-02f, 3.39227878e-02f, -4.38604923e-03f, 5.62804528e-02f, -4.62909788e-02f, 5.02122380e-02f,
  -1.60314411e-01f, 3.28391604e-02f, -6.06864169e-02f, 5.54128550e-02f, -4.09912951e-02f, 6.26311675e-02f, -1.04662906e-02f, -4.32244129e-02f, 3.64724137e-02f, 1.07331444e-02f,
  -5.99775650e-03f, -6.47596270e-02f, -3.41440551e-02f, -4.24417779e-02f, 2.89584249e-02f, -4.53320779e-02f, 2.70504989e-02f, -6.89992011e-02f, -7.09056109e-02f, 5.76030603e-03f,
  2.55211573e-02f, -7.29700774e-02f, 2.07258649e-02f, -3.78785376e-03f, 8.01953720e-04f, 7.56152943e-02f, -1.12736896e-01f, -4.79722358e-02f, -7.75618926e-02f, -1.64499525e-02f,
  -1.13407470e-01f, -9.88799799e-03f, 5.83872758e-02f, -8.35412741e-03f, -5.05746603e-02f, -1.46839442e-03f, 3.07781026e-02f, -1.17977196e-02f, 7.56564513e-02f, -7.67967403e-02f,
  2.53493927e-05f, 3.64294602e-03f, -8.66109133e-02f, 3.08421701e-02f, 7.45859519e-02f, -1.22077381e-02f, 6.51571453e-02f, -8.69639888e-02f, 6.21504635e-02f, 6.13127239e-02f,
  5.48089519e-02f, 5.54485619e-02f, 5.48869409e-02f, 2.90969014e-02f, -1.99999344e-02f, -4.22344282e-02f, -9.44471732e-02f, 4.52688299e-02f, 3.92920524e-02f, -4.88392673e-02f,
  -1.36842415e-01f, -6.03172593e-02f, -8.36554840e-02f, 2.73330566e-02f, -6.82343617e-02f, 3.88137214e-02f, -2.96417187e-04f, 4.76724729e-02f, -8.58775228e-02f, -2.29716860e-02f,
  -4.57037985e-02f, 2.52791177e-02f, -1.03015035e-01f, 1.04088269e-01f, -2.33441615e-03f, 6.28948808e-02f, 1.62967518e-02f, 2.14169230e-02f, 1.37694040e-02f, -7.68127292e-02f,
  -3.52895353e-03f, -3.49614918e-02f, 7.52370730e-02f, 4.12625484e-02f, -1.94082025e-03f, 2.16594283e-02f, -2.40133852e-02f, -4.60423306e-02f, -1.89208854e-02f, 4.22838703e-02f,
  3.58102471e-02f, -8.10512528e-02f, -1.42189220e-01f, 9.17618498e-02f, 5.76903112e-03f, 2.18474958e-02f, 1.68119390e-02f, 4.56379503e-02f, -1.95433628e-02f, -3.24806347e-02f,
  7.27271140e-02f, -5.70608824e-02f, 7.97271654e-02f, 4.68835607e-02f, 9.68995690e-02f, 8.57953057e-02f, 1.61232203e-01f, -7.16013312e-02f, 8.93028826e-02f, -9.33582336e-02f,
  1.12223610e-01f, 1.55066296e-01f, 5.22767678e-02f, 1.23270728e-01f, -1.85436253e-02f, -9.73634720e-02f, 1.44688394e-02f, -1.41598471e-02f, 1.69455667e-03f, -1.43444417e-02f,
  1.19695753e-01f, -2.32225712e-02f, -2.15656571e-02f, 2.09216238e-03f, -1.12119596e-02f, -2.47579161e-02f, -4.58376519e-02f, 1.22336140e-02f, -4.78104353e-02f, 4.73072100e-03f,
  -9.12543163e-02f, -1.02910236e-01f, 3.75581942e-02f, -1.95607147e-03f, -7.50757009e-02f, 4.82554138e-02f, -7.63240308e-02f, -4.12065014e-02f, -7.46318027e-02f, 2.64880974e-02f,
  -7.70591348e-02f, -4.07002084e-02f, -7.81064555e-02f, 5.34584150e-02f, -6.59494698e-02f, 4.08131257e-02f, 2.75541330e-03f, -3.51524167e-02f, -4.41209003e-02f, -4.08089608e-02f,
  -4.15686853e-02f, -4.80158515e-02f, -1.57528371e-02f, -4.73340489e-02f, -5.94262918e-03f, 4.76649664e-02f, -8.26875959e-03f, 1.05856158e-01f, 1.93840787e-02f, 8.43482744e-03f,
  1.06441446e-01f, -3.25374007e-02f, -2.21462874e-03f, 1.45249870e-02f, -5.04542962e-02f, 1.47260362e-02f, -1.90971829e-02f, -1.49264382e-02f, 9.63985547e-02f, 3.45892757e-02f,
  6.22005388e-02f, 3.12003698e-02f, 6.62673712e-02f, 2.29466544e-03f, 5.73092997e-02f, 4.53447774e-02f, 5.95378950e-02f, 2.72037201e-02f, -4.33605015e-02f, 4.80599925e-02f,
  7.76494527e-03f, -8.71153474e-02f, 2.33824812e-02f, -1.15722371e-02f, 8.62356648e-02f, -3.09390463e-02f, -6.43059462e-02f, 3.64001691e-02f, -9.57640633e-02f, 6.42577037e-02f,
  -9.44137871e-02f, -8.38646740e-02f, -7.61005282e-02f, 5.50064892e-02f, 1.06367394e-01f, -2.52665076e-02f, 2.67577749e-02f, 4.42870148e-02f, -5.05666398e-02f, 3.19743976e-02f,
  -6.57230616e-02f, 1.13262478e-02f, 6.58429489e-02f, -7.84846768e-02f, 2.89692301e-02f, -2.48858761e-02f, -1.28906243e-03f, -4.98514399e-02f, -8.39021243e-03f, -7.74294809e-02f,
  -1.09559419e-02f, -1.10454075e-01f, -3.89940515e-02f, -9.33629870e-02f, 8.87415409e-02f, -3.09730619e-02f, 8.79388396e-03f, 7.44520947e-02f, 1.55548558e-01f, -8.79503116e-02f,
  -9.63919386e-02f, -1.10191638e-02f, -2.06957795e-02f, -1.32697418e-01f, 1.75584435e-01f, 1.81105673e-01f, 2.18133386e-02f, -1.02822162e-01f, -2.56443489e-02f, -5.06235585e-02f,
  9.02985036e-02f, 2.41636541e-02f, 3.96497361e-02f, 5.75182214e-02f, -1.22724302e-01f, -1.06299251e-01f, -8.39470923e-02f, -7.38679841e-02f, -1.87693387e-01f, 4.96528447e-02f,
  5.30600213e-02f, -7.21517205e-02f, -6.96991384e-02f, -1.11571349e-01f, 1.23310136e-02f, -2.97775399e-02f, 3.03054210e-02f, -4.12241071e-02f, -6.23317324e-02f, -9.26832017e-03f,
  -1.02356516e-01f, -7.22083151e-02f, 9.22732148e-03f, 5.04555590e-02f, -4.25298624e-02f, 3.01818661e-02f, 8.47518593e-02f, -1.08855590e-02f, -4.19412963e-02f, 5.55323586e-02f,
  -1.23347566e-01f, 1.74739063e-02f, -9.34621319e-02f, -5.37917726e-02f, -8.16079155e-02f, -3.89608219e-02f, 4.90576811e-02f, -3.08227073e-02f, -8.79924744e-03f, -5.84823154e-02f,
  -7.67173693e-02f, 9.68256518e-02f, -3.22094001e-02f, -3.93259153e-02f, 6.20741956e-02f, -5.03594130e-02f, -4.92903702e-02f, 4.31502908e-02f, -3.97228338e-02f, 5.94839901e-02f,
  -3.28366011e-02f, 6.17869571e-02f, 4.85829003e-02f, 1.10774152e-01f, -1.36374533e-02f, 7.33268037e-02f, 1.45652080e-02f, 8.95463526e-02f, -1.46826906e-02f, 7.47906864e-02f,
  1.36497407e-03f, 5.87468967e-02f, -3.33684124e-02f, -4.22573090e-02f, -3.13646011e-02f, -5.50157391e-02f, -5.84862716e-02f, 8.62008799e-03f, 1.56291807e-03f, -2.51900661e-03f,
  5.56464866e-02f, 4.38434519e-02f, 4.46085110e-02f, -1.32906698e-02f, -5.72870709e-02f, 1.51415262e-02f, -4.82195541e-02f, 6.70577139e-02f, 7.86084384e-02f, -2.02421308e-03f,
  2.39032730e-02f, -5.95910363e-02f, -4.04879749e-02f, 6.32725507e-02f, -9.36281495e-03f, 3.16669755e-02f, 2.41972227e-02f, 3.47454324e-02f, 1.92844365e-02f, -2.31447462e-02f,
  -8.68532062e-02f, -2.55942885e-02f, -1.86307356e-02f, -1.73417032e-02f, -5.18436693e-02f, 6.40280126e-03f, -3.94443385e-02f, -9.92788896e-02f, -6.92319423e-02f, 1.68578736e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.60661876e-01f, 7.91458413e-02f, 1.34720383e-02f, 4.79433648e-02f, 4.19857126e-04f, -1.02913804e-01f, -5.35046756e-02f, -1.09499276e-01f, 6.25875546e-04f, -8.78116339e-02f,
  -1.21370591e-01f, 4.99787740e-02f, 5.46606211e-03f, -1.29280895e-01f, 2.08324604e-02f, 1.92486739e-03f, -6.95410445e-02f, -9.25043784e-03f, 3.67220901e-02f, 3.09793092e-02f,
  1.34059251e-03f, -3.62217630e-04f, -3.43171991e-02f, -2.63073742e-02f, -1.25565901e-01f, 2.03913841e-02f, -1.12676263e-01f, -3.88327874e-02f, 2.59685214e-03f, -8.76330882e-02f,
  8.60744342e-02f, 5.29378951e-02f, 4.43888567e-02f, -5.52133897e-05f, -5.83092123e-02f, 1.11957259e-01f, 1.69237666e-02f, 7.25296363e-02f, 1.80460308e-02f, -5.22092767e-02f,
  -7.49652758e-02f, -6.18376732e-02f, -8.27028882e-03f, 8.99825469e-02f, 1.53998630e-02f, 1.72414184e-02f, -2.42247749e-02f, 4.52612229e-02f, -3.65313627e-02f, -6.08239621e-02f,
  2.10668519e-02f, -4.76459228e-02f, -6.23678938e-02f, -5.45699941e-03f, 7.57998601e-02f, 4.42685336e-02f, -1.94379445e-02f, 4.59220782e-02f, 4.09520417e-02f, 3.54457647e-02f,
  3.75277712e-03f, 3.57970931e-02f, 6.50148764e-02f, -2.55727246e-02f, -6.13970794e-02f, 8.69616345e-02f, 3.15583386e-02f, -7.56710544e-02f, -7.99970403e-02f, 1.25681143e-02f,
  -9.06081349e-02f, 6.10864460e-02f, 5.47860973e-02f, 5.17325513e-02f, 3.10537703e-02f, -2.72383932e-02f, -7.34980591e-03f, -7.96177015e-02f, -4.91640903e-02f, 1.47842588e-02f,
  4.36871238e-02f, 6.73243403e-02f, -8.29757284e-03f, -9.14079249e-02f, 5.05952835e-02f, -7.88591709e-03f, 3.62624624e-03f, -6.00958839e-02f, 3.46915834e-02f, 4.31351829e-03f,
  8.56188089e-02f, 5.01741432e-02f, 1.32054444e-02f, 4.97614779e-02f, 8.03117678e-02f, -1.57162976e-02f, -3.57890315e-02f, -2.61336416e-02f, -5.43318912e-02f, -9.64405760e-03f,
  -4.89764288e-02f, -4.45212722e-02f, -4.13958728e-02f, 4.22856137e-02f, 6.96875602e-02f, -5.63809462e-02f, -1.76935308e-02f, -2.63705887e-02f, 2.24381350e-02f, -2.08688583e-02f,
  -2.22054459e-02f, 3.52923349e-02f, -8.59335158e-03f, -1.35501269e-02f, -1.96564030e-02f, 8.13630235e-04f, 2.28031371e-02f, 1.32795528e-01f, 9.37108397e-02f, -4.72688973e-02f,
  -1.19016208e-01f, 1.26102194e-01f, -2.67690755e-02f, -6.43161535e-02f, -1.38086230e-01f, 4.24069837e-02f, -5.53208217e-02f, -5.92538081e-02f, -2.05497779e-02f, 1.27089858e-01f,
  2.09996495e-02f, 1.12319237e-03f, 1.08647369e-01f, 9.23729613e-02f, 5.24899550e-02f, 4.35885601e-02f, 7.86245093e-02f, 1.18384354e-01f, 4.08964567e-02f, -2.90072579e-02f,
  -5.80598153e-02f, 6.79289401e-02f, 1.50829898e-02f, -6.52671382e-02f, 9.15851668e-02f, -1.36004075e-01f, -2.89855991e-02f, -4.14948538e-02f, -2.26848642e-03f, 8.92487690e-02f,
  -6.93844929e-02f, -5.86532801e-02f, -1.03366915e-02f, -8.41295570e-02f, -5.02808578e-03f, -8.32815319e-02f, -3.70277278e-02f, -3.50553468e-02f, -6.10306449e-02f, -9.59485769e-02f,
  3.47225554e-02f, 3.24511598e-03f, -6.97542075e-03f, -4.85757776e-02f, 1.11502319e-04f, -1.84872262e-02f, -3.02188993e-02f, 6.33004010e-02f, 4.68567424e-02f, 4.24623787e-02f,
  -4.95591499e-02f, -5.95740117e-02f, 1.35719040e-02f, -7.03809932e-02f, -2.96611190e-02f, 3.73073854e-03f, -5.85508458e-02f, -9.25275497e-03f, -7.20935538e-02f, 3.79262902e-02f,
  -5.30688576e-02f, 8.31561536e-02f, 3.92691903e-02f, -4.22329130e-03f, -2.74404194e-02f, 2.17293333e-02f, 1.97099783e-02f, -6.06583385e-03f, 4.60909940e-02f, 1.99061912e-02f,
  -3.23807858e-02f, 6.70839846e-02f, -3.16453935e-03f, -2.33978052e-02f, 5.31776175e-02f, 7.97203779e-02f, -1.79359422e-03f, 7.00298399e-02f, -5.17823584e-02f, 7.78259337e-02f,
  -4.20762971e-02f, 9.77404043e-03f, 4.14983630e-02f, -2.69433912e-02f, -8.54709893e-02f, 4.41424958e-02f, 5.29179461e-02f, 8.22412148e-02f, 9.11998004e-02f, 1.81678925e-02f,
  4.06545661e-02f, 4.61979434e-02f, 6.70130476e-02f, -2.36375891e-02f, 6.87752664e-02f, 3.76337022e-03f, -5.17131723e-02f, 2.92691644e-02f, 3.94866243e-02f, -3.60618122e-02f,
  2.58241035e-02f, -2.70510633e-02f, 2.15316303e-02f, 6.13080747e-02f, -4.86715995e-02f, -5.61202457e-03f, 7.01467693e-02f, 3.45513597e-02f, 1.29232937e-02f, -4.08136249e-02f,
  -1.77739374e-02f, -9.02110934e-02f, 6.35156482e-02f, -6.95562810e-02f, 5.42024942e-03f, 4.26450111e-02f, -5.59728146e-02f, -6.40655085e-02f, 4.50500920e-02f, 2.03991421e-02f,
  -1.22594960e-01f, -9.87379104e-02f, -2.59706736e-01f, -1.98097914e-01f, -6.12583086e-02f, -8.74355212e-02f, -2.04159558e-01f, -5.47542796e-02f, 1.15144208e-01f, 3.11600585e-02f,
  -6.47774860e-02f, -1.25286937e-01f, 1.91300325e-02f, -1.77486435e-01f, -1.29972324e-01f, -9.85404328e-02f, -1.73068762e-01f, -2.32518911e-02f, -9.91468802e-02f, -5.59799783e-02f,
  -1.98412593e-02f, -1.21660352e-01f, -1.87802419e-01f, 6.87115034e-03f, -1.02487743e-01f, 3.43560055e-02f, 1.11581109e-01f, -1.71485997e-03f, 2.68333778e-02f, 1.51248761e-02f,
  -7.54371956e-02f, 1.87756959e-02f, -5.13317399e-02f, 4.03215662e-02f, -8.90899450e-02f, -4.27363515e-02f, 2.68541463e-02f, 3.80166471e-02f, -1.57622863e-02f, -1.63293742e-02f,
  -8.40744283e-03f, 8.42460245e-02f, -6.82876334e-02f, -3.84370685e-02f, -4.95541142e-03f, 6.29235059e-02f, -6.31312206e-02f, -3.42175663e-02f, 6.02736957e-02f, -6.75408468e-02f,
  -1.21552080e-01f, -1.06741279e-01f, -1.30527560e-03f, 1.74795669e-02f, -2.73579452e-02f, -8.39498639e-03f, -4.47402112e-02f, -6.12229779e-02f, -2.55986452e-02f, -1.78940687e-02f,
  6.31403178e-02f, 1.53031107e-02f, 1.06332768e-02f, 1.95380729e-02f, 8.36487673e-03f, 7.69525990e-02f, -8.11686516e-02f, 1.55946286e-02f, 2.30799355e-02f, -2.06040237e-02f,
  2.45110150e-02f, 6.35700971e-02f, -3.95011306e-02f, -7.45511204e-02f, -5.94120212e-02f, -6.14831448e-02f, -8.28041323e-03f, 8.48063093e-04f, -6.29798844e-02f, -1.04739936e-02f,
  -1.80890262e-02f, -6.23331890e-02f, 3.61828543e-02f, -1.43137891e-02f, -6.35894835e-02f, 9.81613528e-03f, 4.44578938e-02f, 3.05377170e-02f, 3.22154090e-02f, -6.83402643e-02f,
  2.38470379e-02f, 6.22617751e-02f, 1.39951110e-02f, 7.04968581e-03f, 7.68150240e-02f, -5.28010689e-02f, 1.50191141e-02f, -6.19839318e-02f, -5.97050525e-02f, 1.05948029e-02f,
  2.70824786e-02f, 4.68629925e-03f, 5.17158918e-02f, -5.41408099e-02f, 2.69121658e-02f, 1.38719194e-03f, -5.83149604e-02f, -6.50181845e-02f, 4.20402959e-02f, 6.52154610e-02f,
  5.59407147e-03f, 4.62868512e-02f, 1.05537198e-01f, 8.78219027e-03f, -4.11257781e-02f, -2.30805017e-02f, -6.92058131e-02f, 4.22704183e-02f, -5.45164458e-02f, 3.94539870e-02f,
  2.27398485e-01f, -1.28042862e-01f, -1.78520363e-02f, 2.01208457e-01f, 9.99298245e-02f, 1.17397100e-01f, 5.09865619e-02f, 1.10032119e-01f, 1.31649092e-01f, -3.47622409e-02f,
  -3.52138863e-03f, -2.09022194e-01f, -1.34408042e-01f, 8.00661277e-03f, 3.01474310e-03f, -1.06628470e-01f, 5.05898334e-02f, -7.10665584e-02f, 5.59015609e-02f, -5.68122715e-02f,
  1.38606861e-01f, -9.39351972e-03f, -2.11967248e-02f, -2.20216513e-02f, 6.43055290e-02f, 1.14418969e-01f, -1.80023406e-02f, -3.73908095e-02f, 3.02037224e-03f, -3.14602442e-02f,
  1.38837487e-01f, -2.29713712e-02f, -4.28333059e-02f, 2.95666382e-02f, -5.24939187e-02f, -8.75259787e-02f, -7.35922297e-03f, -7.78701380e-02f, -3.15399766e-02f, 4.01733704e-02f,
  -6.82486221e-02f, 5.65708540e-02f, 5.91307804e-02f, -3.64904269e-03f, -6.18482977e-02f, 1.61815819e-03f, 1.96314547e-02f, -5.86869083e-02f, -7.78876618e-02f, -8.84351656e-02f,
  -1.00526594e-01f, 2.06924174e-02f, -9.03445017e-03f, -8.42692703e-02f, -3.73665132e-02f, 1.47629855e-02f, -8.98597315e-02f, -5.13119996e-02f, -5.86334728e-02f, 4.10139076e-02f,
  2.81859376e-02f, 9.25110877e-02f, 4.24981639e-02f, 7.69602135e-02f, 2.92432830e-02f, 2.64362395e-02f, 2.57702288e-03f, -8.17105174e-02f, -7.40500242e-02f, -4.57458608e-02f,
  -1.14361726e-01f, 7.24625662e-02f, 3.64035219e-02f, 2.01701224e-02f, 3.52111310e-02f, 9.15349051e-02f, 3.13420221e-02f, -3.10157724e-02f, -6.01928681e-04f, -6.81037754e-02f,
  8.63220096e-02f, -8.40350166e-02f, 2.89526731e-02f, -1.13422947e-03f, 4.31884406e-03f, -5.06270165e-03f, 7.51145780e-02f, 9.97022390e-02f, -2.23366413e-02f, -5.92491962e-02f,
  -3.25091556e-02f, -7.54093528e-02f, 4.68540285e-03f, 1.03540495e-01f, -5.50140515e-02f, -7.67305419e-02f, -6.26311824e-02f, 7.47002885e-02f, 1.15351500e-02f, -6.88843848e-03f,
  2.46021599e-02f, -6.10518605e-02f, 7.12846592e-02f, -2.45356672e-02f, 2.20814459e-02f, -5.93467103e-03f, -1.48562063e-02f, 4.42328341e-02f, -5.82918227e-02f, -3.29747386e-02f,
  4.93283831e-02f, 6.30575290e-04f, -7.74979144e-02f, -1.96080375e-02f, 2.44961549e-02f, -1.07335135e-01f, -4.50780280e-02f, -2.12256499e-02f, 3.01496405e-02f, -5.04454710e-02f,
  -1.63031340e-01f, 4.88384143e-02f, -1.13609314e-01f, -1.78834885e-01f, -7.65852407e-02f, -1.61038116e-01f, -1.12538002e-01f, 4.62600775e-02f, 1.31879374e-03f, -6.78831488e-02f,
  2.52062501e-03f, 1.67001933e-02f, -1.07796174e-02f, -1.66982129e-01f, -1.18468560e-01f, 9.30081457e-02f, -1.58181950e-01f, -1.09533623e-01f, -3.16569917e-02f, -1.66683048e-01f,
  -8.76671672e-02f, 4.81868442e-03f, -9.20181200e-02f, -7.51783140e-03f, -8.24503750e-02f, -1.64662786e-02f, -5.22742234e-02f, 7.14854598e-02f, -1.04881145e-01f, 1.31929576e-01f,
  2.53970325e-02f, -3.56380735e-03f, -1.03073390e-02f, -6.25673160e-02f, -1.19658418e-01f, 1.40845422e-02f, -2.52006948e-02f, -1.67535730e-02f, -8.07298198e-02f, -9.99735948e-03f,
  9.23055597e-03f, 2.24316381e-02f, -3.05572003e-02f, 1.17633723e-01f, -9.04422626e-02f, 2.79888995e-02f, -8.41618106e-02f, -1.10417061e-01f, 5.58175333e-02f, 6.06616475e-02f,
  -1.99012496e-02f, -1.19642660e-01f, -5.50407134e-02f, -9.23076496e-02f, 8.21492448e-02f, 7.63648227e-02f, -3.10957395e-02f, -3.14057022e-02f, -3.73344831e-02f, -4.10413407e-02f,
  -5.76124750e-02f, -6.52903914e-02f, 1.00710355e-02f, 1.08376302e-01f, 4.96369638e-02f, 2.91372072e-02f, 3.73604409e-02f, -3.36370207e-02f, -5.02129979e-02f, 4.09999862e-03f,
  -2.33202465e-02f, 1.36699649e-02f, 5.53143397e-02f, 8.36036820e-03f, -8.27400759e-02f, 1.09099805e-01f, -7.20630065e-02f, 1.63461210e-03f, 2.60150172e-02f, -4.09051366e-02f,
  -2.27283686e-02f, 3.79172377e-02f, -3.00036985e-02f, 4.22984548e-02f, -5.95742874e-02f, 5.82033023e-02f, -9.07553658e-02f, 2.25521587e-02f, -1.85314864e-02f, -3.94237153e-02f,
  3.79771413e-03f, -1.04526535e-01f, 9.99559760e-02f, -2.39897016e-02f, 1.08489238e-01f, -9.27687436e-02f, -5.64205274e-02f, 8.33872184e-02f, -6.18543476e-02f, -3.90581936e-02f,
  -5.84769174e-02f, -1.49998590e-01f, -9.61350873e-02f, -3.76980975e-02f, 3.64844166e-02f, -3.05217598e-02f, -3.71651091e-02f, -7.35447183e-02f, -1.79195106e-02f, 1.43146804e-02f,
  -8.35389197e-02f, 8.57968777e-02f, 1.41260531e-02f, 4.57222499e-02f, 3.30092646e-02f, -2.23538335e-02f, 6.30965158e-02f, -3.11889891e-02f, -2.52158684e-03f, -1.29469177e-02f,
  -1.28814295e-01f, -6.08432665e-02f, 5.13293669e-02f, -4.00784500e-02f, 9.01770964e-02f, 6.90750927e-02f, 2.26950254e-02f, 3.41822803e-02f, -2.10336056e-02f, -2.06576195e-02f,
  7.61763752e-02f, -1.31214306e-01f, 5.97902425e-02f, -2.89646089e-02f, -5.86657003e-02f, 7.55733103e-02f, -9.57634300e-02f, 2.94119585e-02f, -1.79343503e-02f, -3.22628506e-02f,
  -8.98616537e-02f, 4.10328545e-02f, 7.90680200e-02f, 5.57042770e-02f, 6.96087554e-02f, -4.54868749e-02f, 2.39608195e-02f, 8.91271159e-02f, -5.56109585e-02f, -6.61223978e-02f,
  -6.82384074e-02f, 6.85236678e-02f, 3.64908017e-02f, 3.52729484e-02f, -3.01094144e-03f, -1.44750942e-02f, -9.51007009e-02f, -7.96954706e-02f, -4.85812910e-02f, -9.48285460e-02f,
  -3.11570950e-02f, -3.32472250e-02f, 6.62706047e-02f, -5.87996691e-02f, -3.36778499e-02f, -4.56569828e-02f, 5.69268204e-02f, 5.99195808e-02f, -3.63378786e-02f, 7.59345368e-02f,
  -1.60822924e-02f, -8.84239674e-02f, 8.88827536e-03f, 7.52657354e-02f, 6.74087256e-02f, -1.00202844e-01f, 3.54282483e-02f, -1.59072466e-02f, 4.44639251e-02f, 2.66180877e-02f,
  3.04654501e-02f, 4.67881337e-02f, 8.11711997e-02f, 7.16535300e-02f, -8.89595821e-02f, -2.52801110e-03f, 2.25528162e-02f, -2.15142928e-02f, 2.73827929e-02f, -3.69211026e-02f,
  2.43112091e-02f, -4.14681882e-02f, 8.16997513e-02f, 2.44090986e-02f, 1.35621838e-02f, 3.08945458e-02f, 1.36902062e-02f, -4.47694659e-02f, 3.93087417e-02f, -2.87391711e-02f,
  -5.66092692e-02f, -9.08120126e-02f, -1.02873281e-01f, -5.77745065e-02f, -1.73837114e-02f, -1.89551655e-02f, 6.91577867e-02f, 2.88886833e-03f, 3.23833749e-02f, 6.75633475e-02f,
  2.59062238e-02f, -8.68442133e-02f, 8.90478641e-02f, -3.02616842e-02f, -5.67901544e-02f, -2.99674347e-02f, -5.71768760e-05f, 1.89657472e-02f, 2.99962703e-02f, 5.45356050e-02f,
  -2.02211272e-02f, -4.99774180e-02f, -1.47327557e-02f, 4.81099300e-02f, -4.12354842e-02f, -1.24796969e-03f, -1.09260883e-02f, -6.47090822e-02f, 1.07660964e-02f, -4.92598675e-02f,
  1.08583802e-02f, -2.89702713e-02f, -2.67630834e-02f, 3.81918252e-02f, -2.91943494e-02f, -9.06405449e-02f, 5.48268333e-02f, -1.62198357e-02f, -2.01656204e-02f, 1.64583717e-02f,
  8.34442303e-02f, -6.98762238e-02f, 9.84180421e-02f, 2.51338780e-02f, 1.95451811e-01f, 3.09210327e-02f, -6.13963045e-02f, 7.40243793e-02f, -5.86391352e-02f, -2.00249940e-01f,
  -2.95508076e-02f, -1.57617256e-01f, -1.17207088e-01f, -2.02341210e-02f, 4.94427793e-02f, -1.25290811e-01f, 4.45398130e-02f, 2.77711563e-02f, 9.77666676e-02f, -1.40275694e-02f,
  -1.37531776e-02f, 5.13026752e-02f, -2.57364828e-02f, 8.70602280e-02f, 2.98959780e-02f, 5.29661700e-02f, -4.72162627e-02f, 5.26049100e-02f, 2.13580467e-02f, 4.89535443e-02f,
  -7.24136457e-02f, 2.47060172e-02f, -4.42976356e-02f, 3.15994285e-02f, 4.36994992e-02f, -6.07787967e-02f, 1.31174305e-03f, -9.42081213e-02f, 7.26927370e-02f, -5.77472933e-02f,
  -7.91329071e-02f, 5.01985550e-02f, 6.54635625e-03f, -4.85943221e-02f, 1.45905698e-02f, -5.87965995e-02f, 7.32807294e-02f, 5.16510010e-02f, -6.06271960e-02f, 3.74752432e-02f,
  2.12507844e-02f, 2.02899027e-04f, -2.90544312e-02f, 3.74888815e-02f, -2.33305525e-02f, 7.24113956e-02f, 5.96513674e-02f, -7.08587766e-02f, 5.96992299e-02f, -4.21429565e-03f,
  -1.49538349e-02f, -4.38402258e-02f, 7.79399425e-02f, -6.05334938e-02f, 4.76478972e-02f, 1.02228090e-01f, -5.07008890e-03f, 4.97802384e-02f, -6.62752092e-02f, -6.70424150e-03f,
  -1.85089596e-02f, 5.41763492e-02f, 1.77498814e-02f, 3.76298949e-02f, -2.63970438e-02f, 8.87572765e-02f, -2.98631713e-02f, 6.65612221e-02f, -5.38271628e-02f, 2.61182413e-02f,
  4.56803814e-02f, 4.66711521e-02f, -5.11355214e-02f, -4.75976467e-02f, -6.34177700e-02f, -3.91841643e-02f, -5.39814075e-03f, -8.47549066e-02f, 3.12560387e-02f, -7.72802830e-02f,
  -1.13521770e-01f, -2.52731144e-02f, -3.83443981e-02f, 7.36648664e-02f, -1.22873550e-02f, 3.94371822e-02f, 6.71045971e-04f, -3.83271128e-02f, 7.38166785e-03f, -2.89544687e-02f,
  -4.96239308e-03f, -9.50388163e-02f, 5.46189509e-02f, -7.56875873e-02f, 5.07989302e-02f, 2.17525773e-02f, 7.59390043e-03f, -6.82360381e-02f, -2.70314887e-02f, -2.35086903e-02f,
  -6.68057799e-02f, -1.72033794e-02f, 5.78552485e-02f, -2.26624385e-02f, -1.16646951e-02f, -7.02013299e-02f, -7.16588497e-02f, 8.64707585e-03f, 3.40535492e-02f, 9.00775194e-02f,
  8.80315714e-03f, -3.57408002e-02f, -1.40735865e-01f, -1.37582481e-01f, -1.75328955e-01f, -6.82870334e-04f, 7.58771598e-03f, -2.50684693e-02f, -5.50421327e-02f, 1.38625622e-01f,
  7.73611143e-02f, -2.58919830e-03f, 4.68790010e-02f, 8.19988027e-02f, 6.86023459e-02f, 1.60580188e-01f, 1.15856506e-01f, 9.86359864e-02f, -6.61021695e-02f, 3.43928859e-02f,
  -2.01136954e-02f, 1.17724817e-02f, -8.34657103e-02f, -1.09108754e-01f, -7.92537406e-02f, -4.42689247e-02f, 4.21279110e-02f, -3.43986526e-02f, -7.77524784e-02f, -3.84040736e-02f,
  3.07946093e-02f, -2.03021821e-02f, -6.82785548e-03f, -4.21291254e-02f, -5.30783907e-02f, -5.53017855e-02f, -8.36989805e-02f, -1.13316076e-02f, 6.96892515e-02f, 8.28770697e-02f,
  8.33060890e-02f, -1.35886893e-02f, -3.68066542e-02f, 2.09064726e-02f, -1.28533348e-01f, -7.73680583e-02f, 2.92644352e-02f, 1.06630228e-01f, -3.51131358e-03f, 2.65855435e-02f,
  4.76564951e-02f, -1.32267335e-02f, -1.92383267e-02f, -9.87276249e-03f, -1.76191982e-02f, 3.27575319e-02f, -1.71485748e-02f, 1.87716875e-02f, -2.79473644e-02f, -2.41908133e-02f,
  6.99291229e-02f, -1.53389219e-02f, -7.18731657e-02f, 2.87055261e-02f, 5.51091395e-02f, -9.48549137e-02f, -4.72644493e-02f, -3.23727429e-02f, -1.49578983e-02f, -2.35151090e-02f,
  -1.16311824e-02f, 1.21782003e-02f, 1.72182322e-02f, 1.44653125e-02f, 3.81025523e-02f, -1.04951812e-02f, 1.12658031e-02f, -3.05092055e-02f, -5.70803396e-02f, -5.60463890e-02f,
  2.16712244e-02f, 7.05004558e-02f, -6.30094558e-02f, 6.04482070e-02f, -5.83040807e-03f, 4.84892391e-02f, -4.33600992e-02f, 5.28436527e-02f, -6.02206104e-02f, -3.55675966e-02f,
  4.52920459e-02f, 8.04494768e-02f, 7.71673694e-02f, -3.73043306e-02f, 3.95486131e-02f, -8.64931149e-04f, 6.73768818e-02f, 6.43465994e-03f, -2.34623887e-02f, -3.15534659e-02f,
  -7.09730834e-02f, -6.33727834e-02f, 9.63770598e-03f, -8.44946951e-02f, -9.49976444e-02f, -5.25947064e-02f, -3.22086290e-02f, -4.70055342e-02f, 3.09050065e-02f, 3.90175991e-02f,
  9.53019038e-02f, -5.97659387e-02f, -4.76675294e-02f, -7.61300623e-02f, -3.71740311e-02f, -3.43615673e-02f, -3.06067374e-02f, 2.59018969e-02f, 4.05599177e-03f, -2.82539036e-02f,
  1.49767861e-01f, 6.90785497e-02f, 2.85946373e-02f, -3.82527709e-03f, 7.04644099e-02f, 1.74084648e-01f, 1.26762360e-01f, 9.16526467e-02f, 1.45021796e-01f, 1.98623165e-02f,
  1.98583715e-02f, 3.32823023e-02f, 5.61511703e-03f, 1.96913201e-02f, -6.00760849e-03f, -1.98761132e-02f, 1.25046492e-01f, 4.48317342e-02f, 1.02621123e-01f, 1.06166221e-01f,
  2.57745236e-02f, 2.18529571e-02f, -1.38042405e-01f, 1.05048478e-01f, 4.40168604e-02f, 3.68521735e-02f, -8.93513337e-02f, -9.80257317e-02f, -4.16339114e-02f, 1.70594919e-02f,
  -3.80909583e-03f, -1.02913743e-02f, 1.82664227e-02f, -3.61024626e-02f, -8.14032480e-02f, -6.89360127e-02f, 1.73670787e-03f, -7.90425688e-02f, 3.97893190e-02f, 6.00529350e-02f,
  -2.28864290e-02f, 9.61887762e-02f, 7.54118264e-02f, -2.81028369e-05f, -6.34363666e-02f, -2.28158534e-02f, 4.22029197e-02f, -1.36297634e-02f, 4.06506434e-02f, -7.61476308e-02f,
  -3.28222513e-02f, -1.42343314e-02f, 6.88641891e-02f, -4.54265550e-02f, -6.69415668e-03f, 3.59101668e-02f, 1.03697684e-02f, -3.53221223e-02f, -5.52149527e-02f, 1.03205413e-01f,
  6.39506895e-03f, 3.64173204e-03f, 2.27152482e-02f, -5.14155142e-02f, -3.29250395e-02f, -6.68422058e-02f, 3.18465717e-02f, 5.88963777e-02f, -4.07943688e-02f, -4.06114981e-02f,
  -7.43836956e-03f, 8.03311449e-03f, -3.38904262e-02f, -6.49626777e-02f, -5.49902301e-03f, 7.20589887e-03f, -2.50932183e-02f, -2.23530531e-02f, -5.16917109e-02f, -3.93000618e-03f,
  -9.43186060e-02f, 6.67201802e-02f, -5.91235347e-02f, -3.22654215e-03f, -3.88650298e-02f, 6.24991506e-02f, 5.00907637e-02f, -1.46298241e-02f, -4.98879105e-02f, -2.77774502e-02f,
  6.44629821e-02f, 1.88314512e-01f, 2.87523456e-02f, -1.75929330e-02f, 1.34743843e-02f, 1.57967694e-02f, 6.54089749e-02f, -1.96842919e-03f, -4.32505645e-03f, 1.21436469e-01f,
  7.43919536e-02f, -8.23051110e-02f, -3.86708267e-02f, 3.84387299e-02f, 2.86085475e-02f, 6.25740066e-02f, -6.19941354e-02f, 2.99934577e-02f, -4.73979563e-02f, -5.66676073e-02f,
  1.40345953e-02f, 3.78181823e-02f, 7.40666911e-02f, -4.92985211e-02f, 4.13756222e-02f, 2.62622572e-02f, 1.68353934e-02f, -7.09204897e-02f, -3.43207195e-02f, 1.32265547e-02f,
  1.05705462e-01f, 8.92244093e-03f, -1.57492273e-02f, -8.98432806e-02f, -1.47636339e-01f, -4.25033048e-02f, -6.26033619e-02f, -8.75309855e-02f, 4.89097349e-02f, 1.08069040e-01f,
  7.22979382e-02f, 1.03939228e-01f, 1.08193859e-01f, -9.89830028e-03f, 1.01928093e-01f, 5.86997084e-02f, 3.16528976e-02f, 4.61207628e-02f, 2.63193599e-03f, 3.36013176e-02f,
  -6.68231547e-02f, -6.74650222e-02f, -3.45837735e-02f, -9.94060114e-02f, -1.48876801e-01f, 5.11295423e-02f, -3.29653472e-02f, -3.01824585e-02f, 7.13783279e-02f, -1.19190373e-01f,
  -3.50537673e-02f, -7.10948333e-02f, -5.96427172e-02f, -6.50723092e-03f, 8.65036845e-02f, 2.37052105e-02f, -4.65964600e-02f, -9.30678472e-02f, -8.25510174e-03f, -5.28520271e-02f,
  2.26697829e-02f, -1.14462547e-01f, 4.98912297e-02f, -6.52561858e-02f, 2.01646215e-03f, 2.08250806e-02f, -4.21625040e-02f, -2.49725785e-02f, 5.19578196e-02f, 2.53592785e-02f,
  6.73175603e-02f, 6.43136650e-02f, 1.68010611e-02f, 6.05820492e-02f, 4.71689217e-02f, -8.57399553e-02f, 3.57986651e-02f, -7.57447928e-02f, 3.22520994e-02f, -7.22883344e-02f,
  9.41253006e-02f, -3.85315977e-02f, 1.08166421e-02f, 7.34354137e-03f, 4.38875854e-02f, -1.71489194e-02f, 4.69255075e-02f, 4.70341705e-02f, 4.75313850e-02f, 3.21288444e-02f,
  1.04556255e-01f, -3.02013308e-02f, -5.04883863e-02f, 8.29372332e-02f, 7.42361993e-02f, 4.20841426e-02f, -6.73438385e-02f, -4.75286227e-03f, 9.08762515e-02f, -2.99734976e-02f,
  1.95642710e-02f, -6.52820989e-02f, 6.90678321e-03f, 5.59621565e-02f, 7.03824237e-02f, -1.55768152e-02f, -5.24384975e-02f, 4.86206450e-02f, 1.87255833e-02f, 5.55308051e-02f,
  -7.11058378e-02f, -6.68284521e-02f, -6.45411992e-03f, 8.73993710e-02f, 4.88766246e-02f, 2.68200273e-03f, -1.02732942e-01f, 7.31734633e-02f, 3.02732494e-02f, 6.86042979e-02f,
  -1.78651605e-02f, -8.86737779e-02f, -1.43774338e-02f, -2.11932394e-03f, -6.23573698e-02f, 2.42528578e-04f, 1.53285991e-02f, 3.17655550e-03f, 7.55041540e-02f, 1.87418461e-02f,
  8.72248039e-02f, -3.99408862e-02f, 2.29507908e-02f, 5.26766591e-02f, 3.89651619e-02f, 6.48828000e-02f, -9.84656736e-02f, 8.54546577e-03f, -5.27715385e-02f, 4.73673530e-02f,
  3.61324511e-02f, 1.23729616e-01f, 1.17420934e-01f, 8.09709951e-02f, -5.71876206e-02f, -1.84677422e-01f, -5.13076708e-02f, 2.04345323e-02f, 1.16733415e-02f, -4.38570678e-02f,
  -1.10519361e-02f, 5.81246018e-02f, 7.29172751e-02f, 1.32662924e-02f, 2.40550563e-02f, 1.66552085e-02f, -6.93052262e-02f, -3.69950831e-02f, 8.23549628e-02f, 7.06286505e-02f,
  6.36386871e-02f, -6.35703653e-02f, 8.50659907e-02f, 4.12421413e-02f, 3.14996354e-02f, 4.83155157e-03f, 1.04404874e-01f, -2.90977955e-02f, 3.79446112e-02f, -2.91599054e-02f,
  -6.15846142e-02f, -3.29721272e-02f, 2.67290156e-02f, 4.82639149e-02f, -5.63199632e-02f, 4.06821780e-02f, 6.58009350e-02f, -5.12359291e-02f, -2.08145175e-02f, -6.56851903e-02f,
  -4.59504809e-04f, -3.81455533e-02f, 2.21835542e-03f, 6.00522533e-02f, -6.05672449e-02f, 3.76586355e-02f, 6.75405636e-02f, 2.64251661e-02f, 5.17183915e-02f, -4.82360367e-03f,
  -3.49699743e-02f, 1.18820988e-01f, 4.68316637e-02f, -8.19264054e-02f, -5.60701340e-02f, -6.18124604e-02f, -4.70164279e-03f, -5.37154414e-02f, -2.27596425e-02f, -5.50185144e-02f,
  5.53812273e-03f, 4.12101708e-02f, 8.51201080e-03f, 6.31161034e-02f, -1.51022654e-02f, 4.40788502e-03f, 6.13152757e-02f, 3.16005312e-02f, -1.73835233e-02f, 1.50371753e-02f,
  -3.51159796e-02f, 5.81147373e-02f, 8.82618781e-03f, -3.86318825e-02f, -3.35993022e-02f, 1.51012111e-02f, -6.23993911e-02f, -1.09656500e-02f, 6.78538308e-02f, 8.73287469e-02f,
  -1.90439867e-03f, 5.05079627e-02f, -5.15997224e-02f, 2.58646980e-02f, -3.61786596e-02f, 1.30036492e-02f, 2.58850902e-02f, 7.56569486e-03f, 2.29795706e-02f, -2.61514317e-02f,
  2.62179542e-02f, 1.63974956e-01f, -5.95356598e-02f, -5.26055060e-02f, -6.29783347e-02f, -6.42794296e-02f, 6.28511459e-02f, 4.77000810e-02f, 5.51054925e-02f, 1.06010467e-01f,
  -3.54832672e-02f, -3.92643595e-03f, 5.68483546e-02f, 2.81156115e-02f, 3.57333682e-02f, -2.00990662e-02f, -4.58201766e-02f, -1.93465780e-02f, -6.40817061e-02f, 5.65349497e-02f,
  1.31741792e-01f, -7.79571980e-02f, -8.35157372e-03f, -2.07039919e-02f, -2.47440115e-03f, -9.14059877e-02f, 1.24691306e-02f, -1.24920197e-02f, 8.84365737e-02f, -6.70575723e-02f,
  1.68014839e-01f, 8.12648758e-02f, 1.31729499e-01f, 1.96083829e-01f, -1.41527921e-01f, -1.46559373e-01f, -1.76016048e-01f, 1.89697649e-02f, -7.04089925e-02f, -9.76034105e-02f,
  3.86758521e-02f, -4.38078232e-02f, 1.06819556e-03f, 1.82435915e-01f, 1.00240074e-01f, 3.82157601e-02f, 1.14909731e-01f, -4.95319851e-02f, 8.82865340e-02f, 1.17675267e-01f,
  1.48035437e-01f, 1.11114774e-02f, 1.86121091e-01f, 5.72662689e-02f, 9.36564902e-05f, 2.30411813e-03f, 3.27941775e-02f, -1.82105582e-02f, 2.69153733e-02f, -6.91471994e-02f,
  -4.40676846e-02f, -1.12260859e-02f, 4.71281298e-02f, 2.66418583e-03f, -1.01968925e-02f, -9.05987434e-03f, -8.69347751e-02f, 1.30387982e-02f, 8.13037679e-02f, 1.50427558e-02f,
  4.96740628e-04f, 3.38813029e-02f, -3.49160843e-02f, -3.78188267e-02f, 2.54834555e-02f, 7.99981579e-02f, -1.94305815e-02f, -5.39384298e-02f, 2.21307389e-02f, 9.57563221e-02f,
  4.67906669e-02f, -1.16837151e-01f, -1.14995971e-01f, 3.81857641e-02f, 8.18757564e-02f, 6.36762455e-02f, -1.51245613e-02f, -7.30908988e-03f, -1.76939857e-03f, -4.15820777e-02f,
  -4.31113690e-02f, -9.54744145e-02f, 4.52764943e-04f, 2.18385383e-02f, -4.14652081e-04f, 8.23093653e-02f, -1.64809190e-02f, 4.07259539e-02f, -3.42976680e-04f, -2.57726870e-02f,
  -1.52632548e-02f, 4.98481877e-02f, 5.39015904e-02f, 1.44068412e-02f, 7.45463967e-02f, 2.11449564e-02f, -2.70576309e-02f, -1.76959448e-02f, -2.44690776e-02f, 2.13210974e-02f,
  -5.80887357e-03f, -2.46275738e-02f, 4.40510847e-02f, -8.76838565e-02f, 4.12257463e-02f, -6.46245405e-02f, -1.72938369e-02f, 2.22148597e-02f, -9.18952078e-02f, 4.41328548e-02f,
  3.98162827e-02f, 1.35931715e-01f, -4.43013646e-02f, -8.68938714e-02f, 4.03660573e-02f, 4.27650171e-04f, 1.47771901e-02f, -1.97301973e-02f, -7.19000101e-02f, 2.39640698e-02f,
  5.86201400e-02f, -5.03547788e-02f, -8.59027728e-03f, 3.08462288e-02f, -2.21844204e-02f, -1.57525502e-02f, -4.49202135e-02f, -5.07183708e-02f, -3.02257948e-03f, 3.08348145e-02f,
  -8.97125676e-02f, 3.30871604e-02f, 3.07372306e-02f, -1.15518652e-01f, 4.33266461e-02f, -7.35499784e-02f, -9.20541063e-02f, -7.04241097e-02f, -5.18877618e-02f, 1.83196701e-02f,
  1.09372951e-01f, -4.33032261e-03f, 8.69038403e-02f, 1.69801898e-02f, -1.11048155e-01f, -1.59645304e-01f, -1.50577128e-01f, 4.60752845e-02f, 2.06819084e-02f, -4.56791930e-03f,
  1.13899559e-01f, 4.82233800e-02f, 1.41383588e-01f, -3.35732661e-02f, 1.19625472e-01f, 1.61610022e-02f, 7.91837797e-02f, -9.37584117e-02f, 1.47615699e-02f, 1.25622675e-01f,
  2.79555768e-02f, -2.78341118e-03f, 1.12681799e-01f, 1.72510967e-02f, 4.23208205e-03f, 1.27100036e-01f, 1.15848117e-01f, 4.61086035e-02f, 7.43874460e-02f, -6.38228357e-02f,
  -5.27272597e-02f, 1.30375773e-01f, -7.90128633e-02f, -3.47241350e-02f, 5.08632027e-02f, -5.62139647e-03f, -4.21681963e-02f, -7.61814639e-02f, 8.23545754e-02f, 8.33880994e-03f,
  5.75214326e-02f, -2.88572274e-02f, -9.89401788e-02f, -5.20684458e-02f, -6.48906231e-02f, -3.78280915e-02f, 2.11097989e-02f, -2.95801479e-02f, 1.70857564e-03f, -8.13970044e-02f,
  -2.86683757e-02f, -9.13344473e-02f, -9.22151878e-02f, -1.14386640e-01f, -2.63333414e-03f, -2.24408545e-02f, -1.00839930e-02f, -3.86403617e-03f, 5.95765654e-03f, -4.89710271e-02f,
  1.10557094e-01f, 4.13996503e-02f, 6.87468424e-02f, -7.06547201e-02f, 6.48328289e-02f, 7.22802952e-02f, 9.44224745e-03f, -3.81586663e-02f, -7.56401569e-02f, 7.74539635e-02f,
  2.83653904e-02f, 5.83357364e-02f, 9.35066305e-03f, 3.45960706e-02f, -2.70512048e-03f, -9.42825153e-02f, 7.41595402e-03f, -1.11367423e-02f, -2.14082412e-02f, 7.18143210e-03f,
  1.08369142e-02f, 2.52671652e-02f, -1.22238770e-02f, 3.14678513e-02f, -4.71239910e-02f, 8.70754048e-02f, 4.83430736e-02f, 8.59060138e-02f, -1.06954612e-01f, -9.69297532e-03f,
  1.70338944e-01f, 2.92882562e-01f, 1.69926174e-02f, -4.16911133e-02f, -5.84318228e-02f, -7.69152446e-03f, -2.71882508e-02f, -1.12171806e-02f, 7.90590644e-02f, 3.93424034e-02f,
  1.30560831e-03f, -2.63700522e-02f, -1.39848236e-02f, 1.02270037e-01f, 4.00683396e-02f, 4.99895364e-02f, 3.67772616e-02f, 9.42495689e-02f, 2.32974663e-02f, 5.01829386e-02f,
  9.39606056e-02f, 8.90656468e-03f, -6.45987466e-02f, -3.98156270e-02f, 9.15844440e-02f, 7.48421485e-03f, -5.33030778e-02f, -6.38909191e-02f, -5.96617311e-02f, 3.58882174e-03f,
  -3.09894923e-02f, 8.89274552e-02f, -7.31347054e-02f, -9.59371123e-03f, -3.42257470e-02f, 9.16596130e-02f, 1.81404620e-01f, 5.02728038e-02f, 6.69328347e-02f, 3.27680051e-01f,
  9.88122746e-02f, 6.01897091e-02f, 1.88760623e-01f, 1.62990689e-01f, -7.54933357e-02f, 1.30953267e-01f, 2.03884900e-01f, 5.82163930e-02f, 1.06374808e-02f, -3.36991623e-02f,
  -1.29217301e-02f, 1.20388068e-01f, 4.58594263e-02f, -1.30313216e-02f, 4.88609485e-02f, -1.30954489e-01f, -7.27547333e-02f, -1.63317576e-01f, 8.88838917e-02f, -6.54702028e-03f,
  1.02578826e-01f, -4.28900644e-02f, -8.86549056e-02f, -1.80648435e-02f, -3.24044861e-02f, 2.74369959e-03f, -4.79061604e-02f, -3.20232958e-02f, -1.29703283e-01f, 7.04050716e-03f,
  7.89953396e-02f, -5.02478480e-02f, -2.71534212e-02f, -7.15599880e-02f, -4.45742309e-02f, -5.91145642e-02f, 5.76102883e-02f, -6.01102673e-02f, 3.17397043e-02f, 2.32876614e-02f,
  -5.16453646e-02f, -6.87267957e-03f, -3.50279137e-02f, 7.64629897e-03f, 1.69305932e-02f, -1.59090813e-02f, 4.97944048e-03f, -6.47414327e-02f, -1.74686629e-02f, 7.95774534e-02f,
  -4.38682996e-02f, 8.91400278e-02f, 5.67676015e-02f, -2.20995843e-02f, -4.82492745e-02f, 1.19256964e-02f, 6.57965690e-02f, -2.09174864e-02f, 3.84667441e-02f, 2.67807581e-02f,
  -4.27298062e-03f, 6.41862080e-02f, 9.74250212e-03f, 4.60470244e-02f, 8.17756876e-02f, 2.62998859e-03f, 1.81855522e-02f, 3.10670603e-02f, -6.80820495e-02f, 3.91124524e-02f,
  2.47053523e-03f, -5.24380691e-02f, -4.72329967e-02f, 6.79118931e-02f, -2.83568632e-02f, 2.37755030e-02f, 1.26003157e-02f, 3.57089564e-02f, -1.20991413e-02f, 7.79222231e-03f,
  1.52861342e-01f, -1.73884481e-02f, 1.16885304e-01f, -3.60600166e-02f, -3.93173061e-02f, 3.38107236e-02f, 1.26985144e-02f, -1.26813166e-02f, -5.52002937e-02f, -3.51522900e-02f,
  7.71056861e-02f, -1.01409527e-02f, 5.71323633e-02f, -1.22346939e-03f, 4.77246605e-02f, -2.92055635e-03f, 1.67936850e-02f, 3.51373926e-02f, 6.92452490e-02f, -1.79305803e-02f,
  -7.05550611e-02f, 5.49182184e-02f, -5.51177301e-02f, -6.89727440e-02f, -5.38353622e-02f, 2.73150615e-02f, 9.92772803e-02f, -1.26122599e-02f, 7.86669105e-02f, 5.59246838e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  2.25159340e-02f, -9.07084793e-02f, 9.54189748e-02f, -1.47200488e-02f, 1.44272354e-02f, -2.44777650e-02f, 1.02202676e-01f, -5.26749268e-02f, 4.12241183e-03f, 6.62499815e-02f,
  -5.80619015e-02f, -3.86770815e-02f, -6.43447638e-02f, -5.42950556e-02f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -6.29191697e-02f, 7.03235492e-02f, 4.54446413e-02f, 9.61931609e-03f, -1.91500142e-01f, -1.81142569e-01f, -5.43588437e-02f, 2.14196444e-01f, 1.76136225e-01f, -1.48870215e-01f,
  1.57084048e-01f, -1.34159505e-01f, -1.22163527e-01f, 1.39649600e-01f, 3.83822136e-02f, -1.33659035e-01f, 5.92542365e-02f, 1.58005968e-01f, 8.95534605e-02f, 1.44893631e-01f,
  6.71210736e-02f, -5.23686856e-02f, 9.97096077e-02f, -1.40132293e-01f, -4.08486016e-02f, -1.24479935e-01f, 6.60315007e-02f, 1.25767916e-01f, 1.63554445e-01f, -1.43658429e-01f,
  -2.66616076e-01f, 9.63796452e-02f, -6.27100021e-02f, 1.92607656e-01f, 1.17215559e-01f, -1.42891020e-01f, 7.57276043e-02f, -7.53332078e-02f, 1.57681797e-02f, -2.24465296e-01f,
  -3.31914388e-02f, 7.65470490e-02f, -1.66686222e-01f, -1.25337243e-01f, -5.86208701e-02f, -2.64631081e-02f, 5.77145431e-04f, -9.83545259e-02f, -6.40799403e-02f, -8.40433910e-02f,
  6.31921738e-02f, -6.95329607e-02f, -1.75255805e-01f, -1.83675997e-02f, -2.01139808e-01f, -8.86153877e-02f, -1.35967806e-02f, -5.94833121e-02f, 9.58087742e-02f, 6.25114236e-03f,
  1.63847968e-01f, -1.67792737e-02f, 2.07436502e-01f, -5.12920655e-02f, 1.95547170e-03f, 2.36243326e-02f, 9.40487459e-02f, -1.18339449e-01f, 1.48694649e-01f, 1.23020455e-01f,
  1.69059068e-01f, -4.98250611e-02f, -2.05388311e-02f, -4.52408344e-02f, 1.89413335e-02f, 1.49697617e-01f, -9.36583281e-02f, -3.75961326e-02f, -8.77745897e-02f, 1.06665060e-01f,
  -8.67975578e-02f, -8.56149271e-02f, 1.70568656e-02f, -9.02615581e-03f, 1.10240409e-03f, 1.44803986e-01f, -6.55625761e-02f, -2.68970132e-02f, 7.87240043e-02f, 4.21774238e-02f,
  8.00856948e-02f, 9.78908837e-02f, -1.24106877e-01f, 1.12352952e-01f, 1.98530227e-01f, 7.94856623e-02f, -1.75247341e-01f, -1.71242207e-01f, -5.80747277e-02f, -1.73144951e-01f,
  1.98915880e-02f, -3.12019467e-01f, -1.33447275e-01f, 1.21031232e-01f, 1.67084672e-02f, -5.48473224e-02f, 2.10415553e-02f, -5.70127815e-02f, 1.09879658e-01f, 8.65459293e-02f,
  -8.02146718e-02f, -4.81120385e-02f, 4.45371233e-02f, -8.90433043e-02f, -1.67546552e-02f, -5.89095131e-02f, 1.36053106e-02f, -2.94725015e-03f, 1.39398742e-02f, 1.14128239e-01f,
  -1.17823064e-01f, -1.69301089e-02f, -1.29236653e-01f, 2.74262950e-02f, -7.59824589e-02f, -7.02306405e-02f, -7.34029710e-02f, -6.93094134e-02f, 1.00205536e-03f, 2.61010993e-02f,
  -1.67357564e-01f, 9.86546353e-02f, 4.55156192e-02f, -1.07578181e-01f, -1.70141429e-01f, -7.90874735e-02f, 4.62137796e-02f, -2.38433823e-01f, -4.57289033e-02f, -7.64087290e-02f,
  -4.85014059e-02f, -8.31309557e-02f, -6.91028759e-02f, 1.12681374e-01f, -5.92068024e-02f, -9.98128355e-02f, 8.50184858e-02f, -7.62215490e-03f, -1.65559381e-01f, 2.81964391e-02f,
  1.80964004e-02f, -1.33893892e-01f, 1.80298723e-02f, 1.04860783e-01f, 1.48485303e-01f, 9.32727531e-02f, 1.13227323e-01f, -4.43393029e-02f, -1.80232413e-02f, 1.35414615e-01f,
  1.33830786e-01f, 6.48135543e-02f, 4.12979163e-02f, -4.84868810e-02f, -5.60656264e-02f, 5.11014462e-02f, -2.61763460e-03f, -6.61679283e-02f, 1.44245759e-01f, 7.20633045e-02f,
  1.43568128e-01f, 7.50635788e-02f, 4.85605374e-02f, -7.66580924e-02f, -2.67320331e-02f, 4.16587405e-02f, 5.07517457e-02f, -3.62168835e-03f, 4.75130528e-02f, 1.25541121e-01f,
  -1.84117377e-01f, 1.05267696e-01f, -2.61056982e-02f, -7.37064779e-02f, -2.56142505e-02f, 1.41073748e-01f, -4.61599529e-02f, -3.12648676e-02f, -5.68224341e-02f, 1.31248692e-02f,
  8.06574896e-02f, 1.70939460e-01f, 1.05980098e-01f, 8.54337662e-02f, -2.57620905e-02f, 6.22028746e-02f, -1.31945694e-02f, -6.75761998e-02f, 2.64379382e-02f, -8.88509080e-02f,
  4.13649483e-03f, 1.98533505e-01f, -1.30974337e-01f, 4.08181101e-02f, 1.53503604e-02f, -1.23683371e-01f, 9.49396417e-02f, -4.88577411e-02f, 9.00514349e-02f, -8.82784650e-02f,
  4.67932634e-02f, -1.15504660e-01f, -1.97779872e-02f, -4.33571041e-02f, 4.86556552e-02f, 1.10231847e-01f, 4.38550375e-02f, -9.68972221e-02f, -1.39826640e-01f, 4.84157316e-02f,
  -1.30699009e-01f, -1.38911670e-02f, -1.38213122e-02f, -8.68109316e-02f, -8.83559212e-02f, 4.81009707e-02f, -9.36796963e-02f, 1.33243397e-01f, 1.62492424e-01f, 9.52785537e-02f,
  -1.18853070e-01f, -1.20315524e-02f, -1.04038425e-01f, -1.53808221e-01f, -2.33368333e-02f, -1.31595768e-02f, 2.48321034e-02f, -1.56933703e-02f, -1.30630150e-01f, 1.01369940e-01f,
  -5.61217479e-02f, 3.02471332e-02f, -2.19626930e-02f, -8.78859684e-02f, 2.16704056e-01f, -1.19747378e-01f, 1.56061128e-01f, 4.65002470e-02f, -1.20565355e-01f, -1.78943742e-02f,
  -9.59618241e-02f, -1.21049516e-01f, -6.29422143e-02f, 1.07940979e-01f, 2.36617983e-03f, -1.58048525e-01f, -5.57822250e-02f, 1.13804959e-01f, -9.46300626e-02f, 8.33348706e-02f,
  -1.35867044e-01f, -1.72460049e-01f, -4.65420298e-02f, -3.96403782e-02f, 7.29190707e-02f, -2.57670075e-01f, 6.44722432e-02f, 7.25077018e-02f, -8.24246183e-02f, -6.28577396e-02f,
  -8.53935182e-02f, -1.97448194e-01f, -2.75589637e-02f, 4.33034338e-02f, 5.65158296e-03f, 6.41039163e-02f, 1.07192546e-01f, 1.51244104e-01f, -8.07472542e-02f, -6.27928823e-02f,
  -3.48665081e-02f, -8.17041323e-02f, -4.17332761e-02f, 1.18066624e-01f, 2.01662909e-02f, -5.85726127e-02f, 4.99213375e-02f, 2.18402762e-02f, -9.13687199e-02f, -9.65480227e-03f,
  1.39171004e-01f, -1.05216756e-01f, -5.08122928e-02f, -2.43845552e-01f, 4.38577831e-02f, 8.71829968e-03f, -5.26225194e-03f, 1.52796671e-01f, 3.62494476e-02f, -1.51596248e-01f,
  2.55998701e-01f, -1.46746384e-02f, 7.29898214e-02f, -2.43353900e-02f, -1.67444237e-02f, -1.49732158e-01f, 8.64957049e-02f, -1.65836159e-02f, -7.58682564e-02f, 6.20651944e-03f,
  -6.37773275e-02f, 1.21650971e-01f, -2.47877445e-02f, -1.46560417e-02f, -1.21577173e-01f, -6.60194978e-02f, 1.85901783e-02f, -6.44194484e-02f, -7.93016106e-02f, -7.49661005e-04f,
  -1.12791322e-01f, -1.62026152e-01f, -8.48889817e-03f, -1.44855827e-01f, -1.65255949e-01f, 5.44854105e-02f, -6.92390427e-02f, 9.91523862e-02f, 3.49655328e-03f, -6.43765703e-02f,
  -2.98814345e-02f, 1.22388229e-01f, -1.39237806e-01f, 9.32067558e-02f, -9.20949206e-02f, -1.56493876e-02f, -4.05198336e-03f, -4.22972366e-02f, 9.23478696e-03f, 8.69248509e-02f,
  -1.50740460e-01f, -3.58112007e-02f, -7.53042102e-03f, -9.61653069e-02f, 7.17904344e-02f, -4.41184901e-02f, 1.24202827e-02f, -1.33289710e-01f, -1.56891927e-01f, -1.45393834e-01f,
  -2.01260597e-01f, -2.34966964e-01f, -1.82312522e-02f, -1.21599711e-01f, -1.76198289e-01f, 1.75576173e-02f, 2.93260396e-01f, -1.16683900e-01f, 9.14287046e-02f, -1.89408049e-01f,
  -1.55111149e-01f, -1.80685490e-01f, -3.18688095e-01f, 5.72536141e-02f, -1.87998891e-01f, -1.47272959e-01f, -1.85277238e-01f, 1.90787256e-01f, -1.60291165e-01f, -1.59750417e-01f,
  3.47553715e-02f, -1.01072520e-01f, 1.57007232e-01f, -1.52385801e-01f, 1.56362116e-01f, -9.66270193e-02f, -1.60905913e-01f, -5.04616164e-02f, 2.02440005e-02f, -1.15038656e-01f,
  2.50111759e-01f, 1.20167352e-01f, 1.48069814e-01f, -9.98745784e-02f, -9.41191614e-02f, -1.53656438e-01f, -9.37714204e-02f, -5.94892800e-02f, -1.36818409e-01f, -6.29703104e-02f,
  -1.08245753e-01f, -1.04500875e-01f, -5.48652820e-02f, -1.06154375e-01f, -1.18407466e-01f, -1.66419059e-01f, 1.26496136e-01f, 1.01965956e-01f, 8.62928331e-02f, 8.45511779e-02f,
  5.01423441e-02f, -1.56095922e-01f, 2.81152204e-02f, -9.74054784e-02f, 2.12884531e-03f, -1.94888622e-01f, -2.41838954e-02f, -3.14936899e-02f, -1.16225779e-01f, 9.42914560e-02f,
  4.83414680e-02f, 7.08508864e-02f, -9.44092683e-03f, -6.69638589e-02f, -1.76038221e-01f, 1.55542409e-02f, 6.89197779e-02f, 1.13535754e-01f, 9.74067748e-02f, 1.35674268e-01f,
  5.90809174e-02f, 2.45407835e-01f, 2.37505343e-02f, -1.25292599e-01f, -8.33897144e-02f, -1.53953627e-01f, 6.71311617e-02f, -4.49213237e-02f, -2.03823149e-01f, -1.46438539e-01f,
  -8.42725020e-03f, 3.55626866e-02f, 3.79887708e-02f, 1.28302649e-01f, 1.38208503e-02f, 1.08643644e-01f, 9.78437662e-02f, -1.23558715e-01f, -5.27544059e-02f, -1.57642886e-01f,
  -1.49902150e-01f, 7.16023706e-03f, 1.63902082e-02f, 1.35436311e-01f, 6.01780973e-02f, 8.99891928e-02f, 1.89114034e-01f, 1.09606296e-01f, 3.14705856e-02f, 7.93453492e-03f,
  -2.39714067e-02f, -1.91350713e-01f, 6.75157756e-02f, 1.02631770e-01f, 1.49677977e-01f, -2.87630390e-02f, -1.78421989e-01f, 8.46840739e-02f, -1.56683639e-01f, 1.09372042e-01f,
  4.59339805e-02f, 6.70820102e-02f, -6.16249554e-02f, -1.34745613e-01f, 9.62323546e-02f, 4.83564585e-02f, 2.22062282e-02f, -1.01085074e-01f, -6.56697974e-02f, 7.34094083e-02f,
  -1.71251476e-01f, 1.64000168e-01f, 6.92415461e-02f, 7.33395442e-02f, -7.40589574e-02f, -9.22128465e-03f, -1.48860022e-01f, -6.16174713e-02f, 5.43829538e-02f, -1.48527265e-01f,
  9.66332555e-02f, -1.41234696e-01f, 1.04742028e-01f, 6.56436160e-02f, 6.52397424e-02f, -1.70628592e-01f, -1.26646191e-01f, 2.57036120e-01f, 1.54203340e-01f, -8.04321766e-02f,
  1.30749792e-01f, 1.28426045e-01f, 2.64934540e-01f, 1.63634598e-01f, -7.71966651e-02f, 1.06078044e-01f, 8.62163454e-02f, 1.33019701e-01f, 1.36062101e-01f, 2.96730325e-02f,
  1.09373480e-01f, 1.13930896e-01f, 7.74321705e-02f, -9.02136266e-02f, 1.26362429e-03f, -3.41497995e-02f, -1.04301594e-01f, -5.39744310e-02f, -1.42366499e-01f, -1.60030439e-01f,
  -1.37625992e-01f, -4.19952814e-03f, -1.26958370e-01f, 1.30591735e-01f, -6.31471276e-02f, 6.83379471e-02f, -3.05497348e-02f, 4.00792360e-02f, -1.44474715e-01f, -1.24056600e-01f,
  -3.44127119e-02f, -8.20400417e-02f, -1.45248324e-02f, -4.85405475e-02f, 1.03377797e-01f, 1.09909423e-01f, 1.04359627e-01f, 9.83303711e-02f, 1.21980896e-02f, 6.78568259e-02f,
  4.53207977e-02f, 5.79697527e-02f, 1.62086301e-02f, 9.07841546e-04f, 1.01628810e-01f, -6.03257008e-02f, -3.51547753e-03f, 7.91023672e-02f, 1.24662980e-01f, 8.08575302e-02f,
  6.55188039e-02f, 2.04703028e-04f, 1.86931863e-02f, 3.54460627e-02f, -1.16206177e-01f, -1.88807324e-02f, -1.55760631e-01f, 4.15077657e-02f, 3.72050516e-02f, 9.74879637e-02f,
  1.38523340e-01f, -8.19582716e-02f, 1.69868588e-01f, -7.63910590e-03f, 1.92778572e-01f, -1.64162740e-01f, 1.62101891e-02f, -4.04747315e-02f, 1.47342101e-01f, -7.39088282e-02f,
  -4.14462313e-02f, -5.71382269e-02f, 5.63024171e-02f, -4.48171198e-02f, -1.45050898e-01f, 1.80511311e-01f, -1.84772357e-01f, -2.18278002e-02f, -6.97396249e-02f, -3.21698338e-02f,
  3.88399139e-02f, -6.09530695e-02f, -1.83395334e-02f, 7.39749894e-02f, 3.91510781e-03f, -4.79228422e-02f, -6.12413697e-02f, 8.05067047e-02f, -3.56763750e-02f, 3.45745310e-02f,
  -2.18636729e-02f, -8.15135613e-02f, 5.32587096e-02f, -1.85621139e-02f, 6.04385734e-02f, -2.07844917e-02f, -7.15644732e-02f, -3.36097963e-02f, 8.72497559e-02f, -7.79971927e-02f,
  -3.36070284e-02f, -2.63308804e-03f, -3.55313644e-02f, 1.29561037e-01f, 7.82439336e-02f, 1.64314061e-02f, 4.78450730e-02f, -2.08546519e-01f, 7.02901855e-02f, 5.76175079e-02f,
  -9.84995067e-02f, -1.84458382e-02f, -1.27394959e-01f, 3.06267408e-03f, -9.92356166e-02f, -5.59041873e-02f, -2.16372073e-01f, 1.15985006e-01f, 2.09834486e-01f, -3.54615040e-02f,
  5.38740344e-02f, 5.70646040e-02f, 1.99325964e-01f, 1.17359035e-01f, 1.15667522e-01f, -1.03516720e-01f, -1.00182571e-01f, 5.34175187e-02f, -1.20524772e-01f, -3.87221910e-02f,
  -3.08323979e-01f, -1.78556547e-01f, -5.80176972e-02f, 3.42512713e-03f, -5.60931265e-02f, -9.71883237e-02f, 8.90590027e-02f, -5.88252768e-02f, 6.57207146e-02f, 2.99616456e-02f,
  8.45541209e-02f, 7.20739588e-02f, -1.39995784e-01f, 1.40416650e-02f, 3.55406478e-02f, 8.70039836e-02f, -3.56551148e-02f, 1.86630055e-01f, 8.62066001e-02f, -9.11603570e-02f,
  -7.33615607e-02f, -2.21836604e-02f, 1.08850680e-01f, 1.42182305e-01f, -1.60371810e-01f, -1.07832596e-01f, -8.42282549e-02f, 1.06809521e-02f, 1.14142157e-01f, -9.81001928e-03f,
  4.01810650e-03f, -3.26081291e-02f, -2.23234445e-02f, -5.02282381e-02f, -3.59110907e-02f, -4.17628698e-02f, -1.33096084e-01f, 1.19695894e-01f, 8.96277204e-02f, -3.50884311e-02f,
  1.33345008e-01f, -2.21983567e-02f, 4.78663817e-02f, -3.27241095e-03f, 1.06526650e-01f, 7.81320035e-02f, -2.28206962e-02f, 4.66787517e-02f, -6.24668412e-02f, -1.30753815e-01f,
  -1.95384800e-01f, -6.16996326e-02f, -1.15129963e-01f, -9.59345475e-02f, 9.84897017e-02f, -5.27910702e-02f, -1.78213976e-02f, -1.42936096e-01f, -3.34943905e-02f, -1.87155470e-01f,
  -1.16933081e-02f, 7.62564084e-03f, -1.17314793e-02f, -6.98341206e-02f, -7.59794638e-02f, -1.33304045e-01f, 6.51026666e-02f, 1.35404855e-01f, 2.67218258e-02f, -1.03222869e-01f,
  -1.04482904e-01f, -1.02480464e-01f, 7.47241378e-02f, -3.37772444e-02f, 9.28481594e-02f, 8.72521773e-02f, 6.34670705e-02f, -6.72272891e-02f, -5.68900146e-02f, -2.14150250e-02f,
  6.96400255e-02f, 1.21792331e-01f, 1.47550479e-02f, -1.08222432e-01f, 1.07455827e-01f, 1.33442715e-01f, 7.76784122e-02f, -7.28574619e-02f, 6.84496164e-02f, -7.60089532e-02f,
  -4.61997204e-02f, -3.19841355e-02f, 2.15490803e-01f, 2.30659451e-02f, 1.68807834e-01f, -3.22419479e-02f, -1.67669579e-02f, -1.11996986e-01f, -6.94372356e-02f, -1.06126972e-01f,
  -4.20085117e-02f, 1.51268423e-01f, 8.95433500e-02f, 1.72891095e-01f, -7.92652443e-02f, 4.84269485e-02f, 1.44773453e-01f, -7.04203993e-02f, 1.54300272e-01f, 1.60362460e-02f,
  1.02852173e-01f, 1.36782169e-01f, -1.80908535e-02f, -1.85635611e-01f, -1.42193213e-01f, 2.92910151e-02f, -1.50717437e-01f, 1.56412065e-01f, -5.00863492e-02f, -1.43658981e-01f,
  4.28574905e-02f, 2.05317643e-02f, -1.10803731e-01f, -7.07967654e-02f, 6.98270202e-02f, 2.83082910e-02f, -1.36764973e-01f, -4.42971811e-02f, 1.85581133e-01f, -3.86843085e-02f,
  9.65029746e-02f, -1.94809474e-02f, 4.76648808e-02f, 6.38851300e-02f, -1.29675508e-01f, -1.33393914e-01f, 6.20535091e-02f, 9.23474133e-02f, -6.85228258e-02f, 1.69562489e-01f,
  1.15320608e-01f, -4.56998199e-02f, -6.80145174e-02f, -1.82059422e-01f, 7.07711652e-02f, 1.76801890e-01f, 1.95960671e-01f, -4.62981649e-02f, 4.12764959e-02f, -7.09364712e-02f,
  -1.70725957e-02f, 1.29604846e-01f, 1.41726211e-01f, 4.09124382e-02f, -7.54535897e-03f, 9.20758918e-02f, 3.16798948e-02f, -3.92474681e-02f, 2.40315348e-02f, -1.18997917e-01f,
  1.56992927e-01f, -6.20871317e-03f, 6.93542808e-02f, 2.20473185e-01f, 3.38975117e-02f, 1.15176871e-01f, 1.65003404e-01f, 3.29977833e-02f, 4.54297103e-02f, 1.38544574e-01f,
  6.07916750e-02f, 7.42527172e-02f, -8.96390676e-02f, -9.26526263e-02f, 1.03340037e-01f, 7.17379600e-02f, -1.50619978e-02f, 3.42722535e-02f, -6.44965991e-02f, 4.78170393e-03f,
  1.67853534e-01f, -3.60806696e-02f, 2.54763174e-03f, -4.39003669e-02f, -6.70739934e-02f, 1.40785649e-01f, 3.08061168e-02f, -1.87611312e-01f, 1.33590907e-01f, -5.52518591e-02f,
  7.98124298e-02f, -5.04277693e-03f, -1.84277594e-01f, -1.16122350e-01f, 9.71885845e-02f, 1.08423844e-01f, 8.54817182e-02f, -1.42912507e-01f, 7.06257001e-02f, 1.13261394e-01f,
  -1.03372760e-01f, 8.24741796e-02f, -1.88188449e-01f, -1.18168192e-02f, 1.06473282e-01f, 1.13130100e-01f, 8.68172571e-02f, -6.10030442e-03f, -2.74900403e-02f, -6.02407195e-02f,
  -3.87308598e-02f, 1.76101029e-01f, -1.21344499e-01f, 1.31902456e-01f, 9.13542286e-02f, 6.22946434e-02f, -9.08260494e-02f, 2.47508995e-02f, -4.84836213e-02f, 1.18261807e-01f,
  1.25668332e-01f, -2.08386660e-01f, 1.57741651e-01f, 1.45287784e-02f, 5.15113724e-03f, 8.07073787e-02f, 1.18515424e-01f, 8.38755444e-02f, -4.12138999e-02f, -5.38655147e-02f,
  6.57913089e-02f, -7.26030916e-02f, 5.66491261e-02f, 3.12124658e-02f, 5.63242994e-02f, 5.25673479e-02f, -8.59469455e-03f, -5.51716648e-02f, -2.00018995e-02f, 1.08003251e-01f,
  7.36765489e-02f, -8.57789889e-02f, -1.91357926e-01f, -4.70325314e-02f, -7.73716196e-02f, 1.55964538e-01f, 1.51941419e-01f, -1.46948501e-01f, 5.94321033e-03f, -6.16464391e-02f,
  -7.47436881e-02f, -7.37158731e-02f, 1.08660817e-01f, 6.08776137e-02f, -3.97616960e-02f, -5.28108103e-05f, -4.79747765e-02f, 8.72304477e-03f, -4.32715528e-02f, -2.99306922e-02f,
  -9.60942507e-02f, -8.05070847e-02f, 6.07892759e-02f, 2.63560433e-02f, -8.10675025e-02f, 2.80829202e-02f, -1.78670213e-01f, 5.06485067e-02f, -2.18951125e-02f, 1.12453125e-01f,
  7.92906061e-02f, -1.32634029e-01f, 2.55947374e-02f, 1.61816001e-01f, 7.33814435e-03f, -1.24307564e-02f, 5.77502027e-02f, -2.82120071e-02f, 7.57572278e-02f, 1.42121874e-02f,
  -1.50637448e-01f, -7.82043636e-02f, 1.36350915e-01f, -6.50198385e-02f, 1.86039254e-01f, 1.00594796e-01f, 1.25151724e-01f, 4.65318151e-02f, -3.35750654e-02f, 2.24841479e-02f,
  4.79825512e-02f, -8.04109126e-02f, 1.02546558e-01f, 1.65841088e-01f, 1.49295390e-01f, 3.30024795e-03f, 1.84107176e-03f, -4.74739335e-02f, 8.28736797e-02f, 1.35153504e-02f,
  -3.32388170e-02f, -6.11685216e-02f, 1.38911217e-01f, 7.65839964e-02f, -1.16439395e-01f, -1.88302636e-01f, -9.97479409e-02f, -9.85764638e-02f, -1.19383410e-01f, 6.54733852e-02f,
  -7.97608215e-03f, 4.25575413e-02f, 7.82609880e-02f, -8.76946971e-02f, 2.15773340e-02f, -6.35015890e-02f, -1.28771126e-01f, -2.61732526e-02f, -2.19222963e-01f, -5.94554702e-03f,
  6.08672723e-02f, 2.02040449e-02f, -1.61903456e-01f, 1.03501096e-01f, -8.80146697e-02f, 3.75256427e-02f, -1.61140412e-01f, -5.28542958e-02f, 1.70784425e-02f, 6.61914051e-02f,
  8.79583433e-02f, 7.97956362e-02f, 1.41877353e-01f, -1.51896909e-01f, -1.31236434e-01f, -1.22763544e-01f, 3.82909440e-02f, 1.42836958e-01f, -3.97457881e-03f, -1.31799608e-01f,
  2.77779829e-02f, 9.92038660e-03f, 5.89347556e-02f, 1.32107124e-01f, -1.81969777e-02f, 5.34496941e-02f, -6.44385070e-02f, -4.33362126e-02f, -9.72872227e-02f, 3.62261720e-02f,
  4.18796614e-02f, -3.96805070e-02f, 9.70560610e-02f, 1.17671475e-01f, 1.38067231e-01f, 1.36843249e-01f, -7.68802017e-02f, -6.80974498e-02f, -3.54281887e-02f, 8.06455985e-02f,
  1.80816632e-02f, -1.36696264e-01f, 2.60357391e-02f, 1.23281993e-01f, 1.61058232e-02f, 3.71803194e-02f, 9.95317250e-02f, 1.44880131e-01f, -1.91475779e-01f, -1.05855644e-01f,
  -1.51675314e-01f, 8.55071750e-03f, 1.75704077e-01f, -1.84845943e-02f, 1.85561016e-01f, 8.89651291e-03f, 1.66924775e-01f, -4.04971875e-02f, 1.57800645e-01f, -1.75303310e-01f,
  6.89763017e-03f, -1.41292766e-01f, 1.22062415e-01f, 4.63245362e-02f, -2.12705001e-01f, -2.01196909e-01f, -1.44123510e-01f, 9.62767601e-02f, -2.55706832e-02f, 8.70466083e-02f,
  -1.19390953e-02f, 5.27379699e-02f, 1.58705890e-01f, -1.75072655e-01f, -8.26949403e-02f, 7.61829391e-02f, -1.49897322e-01f, 3.38671787e-04f, -5.05332537e-02f, -4.97795902e-02f,
  -6.01543188e-02f, 5.41598350e-03f, 1.46847889e-01f, 8.84398147e-02f, -8.97158235e-02f, 8.17846134e-03f, -1.13973953e-01f, 6.28228560e-02f, 8.35329592e-02f, -1.27610266e-01f,
  -8.64224285e-02f, 1.30503714e-01f, -3.95968258e-02f, -1.54798791e-01f, 5.91353327e-02f, 1.71695314e-02f, 1.85904860e-01f, 1.30425384e-02f, 1.09568045e-01f, 1.52922928e-01f,
  -1.93638578e-02f, 4.76038121e-02f, -5.55107109e-02f, -6.17498755e-02f, 1.21357441e-01f, -1.88238882e-02f, -9.29411724e-02f, 5.70456265e-03f, -8.88857469e-02f, 1.05861865e-01f,
  -1.16088808e-01f, 5.02848439e-03f, -9.54626277e-02f, -5.09356521e-02f, -1.48863405e-01f, 1.10974677e-01f, 2.75431216e-01f, -2.65445951e-02f, 2.33380914e-01f, 8.67667273e-02f,
  1.21720336e-01f, 1.15015559e-01f, 1.40892774e-01f, -1.05948038e-01f, -1.05468500e-02f, -7.37257749e-02f, 9.80552211e-02f, -8.69232267e-02f, -2.41090685e-01f, 1.86604224e-02f,
  -7.27948993e-02f, -3.77233922e-02f, 5.29656261e-02f, -1.80212811e-01f, -4.02588136e-02f, 3.30776535e-02f, 8.66758972e-02f, -1.30298272e-01f, -7.44367614e-02f, -3.81846316e-02f,
  -1.60004884e-01f, 1.44691095e-01f, -2.30506882e-02f, 6.12186417e-02f, 1.02379829e-01f, -5.61872646e-02f, -3.12344749e-02f, 9.94696990e-02f, -9.69022792e-03f, -3.22831757e-02f,
  -1.25921071e-01f, -1.55633166e-01f, 1.42939329e-01f, 1.90593556e-01f, 9.48888436e-02f, -8.94098580e-02f, -6.47569587e-03f, -3.29818390e-02f, 6.88251629e-02f, 1.09613933e-01f,
  1.36709839e-01f, 9.05645266e-03f, -1.09012639e-02f, 1.08478859e-01f, 3.02973371e-02f, -1.25194527e-02f, -7.34580159e-02f, -1.39044719e-02f, -1.19157456e-01f, 9.89152417e-02f,
  -7.47420192e-02f, 1.29236281e-01f, -8.91490281e-03f, 1.22587793e-01f, -4.24581803e-02f, -1.66124895e-01f, 4.44583893e-02f, 1.99611619e-01f, 5.02106175e-02f, -1.39313400e-01f,
  -8.95190891e-03f, -1.64585382e-01f, -1.49012625e-01f, 1.54869333e-02f, -1.41205087e-01f, -8.11642930e-02f, -9.22719836e-02f, 1.51137128e-01f, 9.99407247e-02f, -4.69738990e-02f,
  1.39173031e-01f, 1.13278128e-01f, 4.74861600e-02f, -3.08547746e-02f, 9.13053602e-02f, -9.30940732e-02f, -6.91887829e-03f, 1.26431406e-01f, 1.22791147e-02f, -9.31097567e-03f,
  -7.85175711e-02f, 9.29487571e-02f, 1.04042284e-01f, 1.26839615e-03f, 6.95216879e-02f, -2.26938948e-02f, 7.66049474e-02f, 3.64824049e-02f, 6.64634481e-02f, -1.84812352e-01f,
  -1.13976941e-01f, 1.41022075e-02f, -2.11190935e-02f, 1.62656829e-02f, 3.18241231e-02f, 3.39701772e-02f, 1.56835780e-01f, 1.77345145e-02f, 7.11526768e-03f, -6.53713942e-03f,
  -1.74314454e-01f, 2.02117160e-01f, -1.76329598e-01f, -7.40765780e-02f, 1.89815575e-04f, 5.31701893e-02f, -6.19402379e-02f, 1.81300804e-01f, 1.04296483e-01f, -1.92404106e-01f,
  6.45686314e-02f, -9.96725038e-02f, -5.41219488e-02f, -3.11604049e-02f, 9.05981138e-02f, 1.44176260e-01f, -8.53445902e-02f, 3.03833596e-02f, -5.59475832e-03f, -2.08563432e-01f,
  9.07756537e-02f, 8.81075487e-02f, 4.76395823e-02f, 7.88910463e-02f, 2.05977127e-01f, 3.57533470e-02f, -2.24060699e-01f, 2.14354053e-01f, -1.54013792e-02f, 2.85758466e-01f,
  9.97599214e-02f, 1.35790080e-01f, -6.56042434e-03f, -6.70770630e-02f, 2.15153068e-01f, 8.18502232e-02f, -2.28394210e-01f, -1.09143451e-01f, 1.27449393e-01f, -1.92264825e-01f,
  3.31140794e-02f, 7.94619247e-02f, 1.64166167e-01f, -1.23852372e-01f, -8.44249725e-02f, 6.78798705e-02f, -8.37998167e-02f, -5.62674552e-02f, 4.38685752e-02f, 1.86354816e-02f,
  1.58853158e-01f, 1.26593798e-01f, -1.18750475e-01f, 1.67748332e-02f, -1.24014623e-01f, -5.20595983e-02f, 1.21811442e-01f, 7.30516715e-03f, 1.31463319e-01f, 5.64724319e-02f,
  -1.41409621e-01f, -4.64426689e-02f, -1.12607129e-01f, 4.77429181e-02f, 1.22425020e-01f, 2.94792354e-02f, 1.08252443e-01f, -9.62944701e-02f, -1.37797654e-01f, -7.09067658e-02f,
  1.49913982e-01f, -4.25385982e-02f, 3.72535475e-02f, -8.03438667e-03f, 1.20137736e-01f, 1.67564049e-01f, 7.83516616e-02f, 1.05879195e-01f, 1.70217007e-01f, 3.66011672e-02f,
  1.37310192e-01f, -5.15177771e-02f, -3.91617715e-02f, 1.47926360e-01f, -1.10876188e-01f, -3.88574898e-02f, 9.47573036e-02f, -2.91835573e-02f, -1.03807494e-01f, 1.96309507e-01f,
  2.21499279e-02f, -1.57285277e-02f, 7.11734518e-02f, 5.81503175e-02f, -1.12512916e-01f, -9.46415737e-02f, -3.11811734e-02f, -5.81375696e-02f, 6.62618056e-02f, -1.08060859e-01f,
  -8.99095461e-02f, 4.50936221e-02f, -7.20417872e-02f, -4.67988700e-02f, -2.92942189e-02f, 3.51219065e-02f, -1.31237417e-01f, -1.17005982e-01f, -8.00884888e-02f, 1.48795143e-01f,
  1.10450700e-01f, 1.10541120e-01f, 8.22482780e-02f, -8.51413608e-02f, 6.40627071e-02f, -1.14283651e-01f, -4.07804698e-02f, 2.82603838e-02f, 1.36577860e-01f, -9.37559307e-02f,
  4.90676314e-02f, 1.92198288e-02f, -4.00702469e-02f, -1.28689632e-01f, -1.03435472e-01f, -7.92178810e-02f, 1.25370473e-01f, -2.11643651e-02f, 8.14287178e-03f, -1.48761645e-01f,
  1.19811282e-01f, -7.74265304e-02f, -1.46805778e-01f, -1.03530087e-01f, 1.92711931e-02f, 8.33589025e-03f, -3.10436473e-03f, -2.14952137e-02f, 2.59293448e-02f, -6.17271103e-02f,
  1.00258768e-01f, -6.00399636e-03f, 3.91919352e-02f, -5.18740900e-02f, 6.33145720e-02f, -1.00040091e-02f, 6.60745287e-03f, -2.61406023e-02f, 6.91899061e-02f, -1.54599950e-01f,
  -5.15777431e-02f, -1.18577681e-01f, -1.65475104e-02f, 6.27548844e-02f, 7.83071220e-02f, -1.04058959e-01f, -3.74113731e-02f, -2.34591842e-01f, -1.62791237e-01f, 7.55009428e-02f,
  -1.86008990e-01f, -7.25553185e-02f, -1.63915366e-01f, 7.57518858e-02f, 4.25084569e-02f, 1.29698828e-01f, 1.00427063e-03f, 1.68004796e-01f, -9.10325721e-02f, -7.64003992e-02f,
  -6.96518347e-02f, 6.57142028e-02f, 8.58436804e-03f, -1.44379586e-02f, 1.51279762e-01f, 1.00538865e-01f, -7.62846619e-02f, -1.31702488e-02f, -1.85870275e-01f, 9.49634388e-02f,
  -7.63042048e-02f, 1.76370800e-01f, 6.61421269e-02f, -1.09146409e-01f, -1.70429964e-02f, 2.09425241e-02f, -9.98103991e-02f, 1.63562000e-01f, -1.17374109e-02f, -5.89844622e-02f,
  -3.19310650e-03f, -6.48266822e-02f, 1.26086920e-01f, -2.20520958e-01f, 7.87248239e-02f, 5.94126694e-02f, -1.55244218e-02f, 1.15334123e-01f, -8.03766400e-02f, -8.78211856e-03f,
  9.36673656e-02f, 1.00448042e-01f, 2.84584463e-02f, -2.74732523e-02f, 6.02914654e-02f, -1.02445446e-01f, 4.72105481e-02f, 5.58344908e-02f, 3.86937112e-02f, 8.21422562e-02f,
  -6.09600805e-02f, 1.01314656e-01f, 1.20002493e-01f, 8.92230794e-02f, -4.91957180e-02f, -9.28451493e-02f, -2.45532878e-02f, -4.12936173e-02f, 8.42522383e-02f, -1.19384892e-01f,
  1.16522722e-01f, 2.98102591e-02f, 5.99764809e-02f, -1.96187273e-01f, 3.46422684e-03f, 3.86513211e-02f, -1.16988041e-01f, -1.06233634e-01f, -1.31666481e-01f, -5.89817390e-02f,
  2.71651242e-02f, 2.89349980e-03f, 1.73753295e-02f, -5.88376597e-02f, -7.23308772e-02f, 2.86657345e-02f, -1.29130155e-01f, 1.69986766e-02f, -8.89387876e-02f, -9.10217687e-02f,
  1.55894840e-02f, -9.15984530e-03f, -1.19515486e-01f, 5.17653190e-02f, 4.62908624e-03f, 5.14314473e-02f, 1.98156744e-01f, 1.56961642e-02f, -5.77812828e-02f, 8.80707651e-02f,
  -8.85381326e-02f, 6.62487298e-02f, 7.21108913e-02f, -9.97791067e-02f, 6.20202487e-03f, -7.32238078e-03f, -5.17962966e-03f, -4.70032841e-02f, 1.45100713e-01f, -1.05401076e-01f,
  -3.79730016e-02f, 1.18971489e-01f, 1.34932250e-01f, -6.91530332e-02f, -4.34306823e-02f, -8.06210563e-02f, -6.22111335e-02f, -4.78999019e-02f, 9.73450541e-02f, -5.92352301e-02f,
  -1.05309047e-01f, -6.28226623e-02f, -8.47017840e-02f, 1.45784229e-01f, -8.56047403e-03f, 1.81982175e-01f, 1.11375384e-01f, -1.24938481e-01f, -1.50228396e-01f, 1.34973660e-01f,
  5.56120239e-02f, -1.02129066e-02f, 1.31893501e-01f, -2.26158518e-02f, -1.09197870e-01f, -1.66059837e-01f, -4.71139364e-02f, -1.73646003e-01f, -1.08415775e-01f, 1.38802603e-01f,
  -1.03970461e-01f, -5.45217209e-02f, 4.77490434e-03f, 2.40047835e-03f, 1.13919556e-01f, -4.51475009e-02f, 1.09305844e-01f, -7.34289214e-02f, 4.36051097e-03f, 3.44606154e-02f,
  -1.50922343e-01f, -8.31290265e-04f, -2.01403394e-01f, 1.10721618e-01f, -6.75788298e-02f, 2.75206938e-02f, -8.14821720e-02f, 1.46179954e-02f, 1.06745400e-01f, 5.51173389e-02f,
  4.78488067e-03f, 4.79436070e-02f, -4.43251058e-02f, 1.01114713e-01f, 6.57645240e-02f, 2.07617562e-02f, 4.82711159e-02f, 5.54954894e-02f, -2.12823357e-02f, -1.17194513e-02f,
  -2.16746572e-02f, 1.94395587e-01f, -9.61351022e-02f, 7.76224956e-02f, 4.51827608e-02f, -9.70267877e-02f, 6.31413162e-02f, -1.99652109e-02f, 3.85823175e-02f, -2.00489517e-02f,
  -7.53176361e-02f, -8.28818604e-02f, -2.97030956e-02f, -1.30488828e-01f, 1.11824632e-01f, 1.39095396e-01f, -7.60160089e-02f, 6.78439885e-02f, 8.39270949e-02f, -1.00024275e-01f,
  -2.97743753e-02f, 7.08443001e-02f, 1.09669358e-01f, 2.24028602e-02f, -1.12099238e-01f, 1.22957110e-01f, -1.29276335e-01f, 3.62791792e-02f, 1.03058986e-01f, 1.23934217e-01f,
  -7.33809248e-02f, -6.25786707e-02f, 7.23948553e-02f, -1.28081694e-01f, -1.29528686e-01f, -7.60646388e-02f, 3.20534594e-02f, 6.91116080e-02f, -1.56761914e-01f, -5.34494705e-02f,
  2.51340158e-02f, 2.11027395e-02f, -9.67665762e-02f, -1.12141527e-01f, 6.97800219e-02f, -1.02890253e-01f, 1.20581008e-01f, -7.65657946e-02f, -5.03863953e-02f, -1.57790080e-01f,
  1.21921510e-01f, -4.69832756e-02f, 6.15594313e-02f, -2.99434992e-03f, 5.07826619e-02f, -1.64376423e-01f, 6.06380627e-02f, 4.88946997e-02f, -6.47216439e-02f, -8.01429525e-02f,
  2.60891646e-01f, 1.36586830e-01f, 2.47660443e-01f, 1.20242193e-01f, 2.51125712e-02f, 2.37778291e-01f, -8.51685107e-02f, 1.34508073e-01f, 4.34716381e-02f, -2.78903954e-02f,
  2.08626613e-02f, 3.62125114e-02f, 1.86591312e-01f, 9.59029794e-02f, -1.18200164e-02f, -5.87805696e-02f, 6.69006109e-02f, 2.32402924e-02f, -2.41367798e-02f, -5.22299074e-02f,
  9.09794942e-02f, 1.14224367e-01f, 1.20748945e-01f, -1.59718484e-01f, -2.68468469e-01f, -1.34426532e-02f, 1.41562760e-01f, -1.88589431e-02f, 8.72195233e-03f, -1.16493821e-01f,
  -6.70521241e-03f, 2.61291824e-02f, 1.54495433e-01f, -4.03629333e-01f, 3.55453491e-02f, -3.26293730e-03f, -1.73624575e-01f, -9.46997106e-02f, -3.02539747e-02f, 9.34249982e-02f,
  2.45407552e-01f, -8.87149200e-02f, -2.90574640e-01f, 1.24042027e-01f, 2.07589194e-02f, -3.03292815e-02f, -4.97845188e-02f, 3.78126279e-02f, 2.23506317e-01f, -2.06757784e-01f,
  1.04185566e-01f, 1.47344217e-01f, -4.74000424e-02f, -9.13377665e-03f, -3.97873372e-02f, 1.16230778e-01f, -1.88795090e-01f, -1.67850971e-01f, -1.82019383e-01f, -3.71959582e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -1.62743963e-02f, -3.05726323e-02f, -9.13554579e-02f, 5.50149102e-03f, -5.31921105e-04f, 7.36316219e-02f, -2.18054615e-02f, 7.03244135e-02f, 9.30246431e-03f, -1.11740597e-01f,
  3.73667926e-02f, -1.24664046e-01f, 1.30416960e-01f, -2.65986845e-02f, 4.50705439e-02f, -1.13893993e-01f, -4.62845201e-03f, 4.33955640e-02f, 5.41192107e-02f, 4.19187881e-02f,
  5.94437048e-02f, 4.50208448e-02f, 6.51260559e-03f, -5.70158139e-02f, -6.07324801e-02f, 6.84336275e-02f, -6.06578439e-02f, -4.22960818e-02f, -7.66068175e-02f, 7.98414126e-02f,
  1.57967601e-02f, 3.78627516e-02f, -3.43652582e-03f, 1.17009528e-01f, 4.86789979e-02f, 5.67019768e-02f, 9.95482579e-02f, 2.70422660e-02f, -6.83529228e-02f, -6.57676999e-03f,
  1.09752286e-02f, 1.15708783e-01f, 3.24430652e-02f, 2.23032273e-02f, 7.95880556e-02f, -5.55301271e-03f, 1.17203491e-02f, 4.03953828e-02f, 1.29213873e-02f, 8.53167996e-02f,
  -7.12551028e-02f, 1.15079269e-01f, -3.93042248e-03f, 3.48019786e-02f, 3.72087061e-02f, -2.34497264e-02f, -6.58067465e-02f, 6.02349527e-02f, -5.79904579e-02f, -3.67768109e-02f,
  -1.37253590e-02f, 2.05938816e-02f, 7.15617761e-02f, 2.09845603e-02f, -6.50238246e-02f, 7.70379454e-02f, -1.04505241e-01f, 1.65939018e-01f, -9.92943421e-02f, 1.10758007e-01f,
  -2.04161946e-02f, -3.50742750e-02f, 8.96255765e-03f, -8.24784636e-02f, -1.43320393e-02f, -1.02185905e-02f, -1.69730932e-02f, -7.58903176e-02f, 1.84920520e-01f, 1.30349204e-01f,
  -5.69941290e-02f, -5.23207011e-03f, 6.96640387e-02f, 1.38320416e-01f, 6.04076721e-02f, -6.42594770e-02f, -5.98437935e-02f, 4.49520610e-02f, 1.37167051e-01f, -6.03339747e-02f,
  -8.96224827e-02f, 1.65053666e-01f, 6.55757189e-02f, -2.14658096e-03f, 5.72391003e-02f, -1.46363303e-02f, 1.68419078e-01f, -3.82532813e-02f, 1.89563274e-01f, 9.55951214e-02f,
  5.03677912e-02f, 8.12187567e-02f, 1.43946812e-01f, -1.02457002e-01f, 5.50603308e-02f, 9.39389914e-02f, 1.40868604e-01f, -6.76733255e-02f, 7.29054064e-02f, -2.89083757e-02f,
  7.67153576e-02f, -3.82596590e-02f, 1.22224219e-01f, -9.77267623e-02f, -7.10632429e-02f, -6.39516637e-02f, -8.64977315e-02f, 1.11800402e-01f, -4.27282527e-02f, -1.35882711e-02f,
  -9.30358693e-02f, 5.22350743e-02f, 1.40497714e-01f, 1.24597222e-01f, 1.46538243e-01f, 1.35971397e-01f, 2.06987217e-01f, -7.08521384e-06f, -1.17547847e-01f, 7.27809072e-02f,
  4.74439524e-02f, -7.76033802e-03f, 1.10218711e-01f, -1.12237260e-01f, -1.19212195e-01f, -2.75950618e-02f, -1.21599443e-01f, -1.31979302e-01f, 9.59143136e-03f, -2.69831736e-02f,
  4.98814993e-02f, 7.98014402e-02f, 1.18500620e-01f, -3.06480993e-02f, -5.21414243e-02f, 1.17599636e-01f, -3.33440788e-02f, 5.03053069e-02f, -1.18996710e-01f, -1.14560604e-01f,
  -4.64339480e-02f, 1.04912013e-01f, -4.74945344e-02f, 1.18119620e-01f, 1.34857530e-02f, -4.07573581e-02f, 2.96496842e-02f, 8.93259272e-02f, -2.91414764e-02f, 1.13059871e-01f,
  5.79220727e-02f, 2.60363016e-02f, -4.28157188e-02f, -3.73966284e-02f, 8.16794857e-03f, -3.08489129e-02f, 1.07003003e-02f, -7.89857954e-02f, 2.39451174e-02f, -1.07511558e-01f,
  -9.35817584e-02f, 6.81866184e-02f, -3.09044849e-02f, -5.43614067e-02f, 1.02534831e-01f, 3.29151228e-02f, -4.75336835e-02f, -8.19568932e-02f, 4.76190634e-02f, -4.20678928e-02f,
  -9.19696689e-02f, -8.14179182e-02f, -1.02345943e-01f, 5.06959390e-04f, -8.55956078e-02f, -2.52986467e-03f, -7.91585594e-02f, -1.03537567e-01f, -4.62963916e-02f, 1.20055355e-01f,
  -7.17094392e-02f, 1.29728690e-01f, 7.74575025e-02f, 1.01702489e-01f, 2.32145991e-02f, 1.44125540e-02f, 1.20687351e-01f, -4.33457047e-02f, 1.96440935e-01f, -6.31705076e-02f,
  1.42197087e-01f, 6.54971004e-02f, -7.44679943e-02f, 1.69144019e-01f, 1.14463031e-01f, 1.59495831e-01f, 7.45289922e-02f, 2.00382873e-01f, 4.76677530e-02f, -5.75563908e-02f,
  -5.18821441e-02f, -6.84532896e-02f, 8.15852880e-02f, 6.17890358e-02f, 4.13320661e-02f, 7.25833606e-03f, 2.13370398e-02f, 1.13613278e-01f, -4.06013727e-02f, -3.02506816e-02f,
  2.60535791e-03f, 5.91587685e-02f, -4.80306819e-02f, 6.27846718e-02f, 5.95684871e-02f, 2.42221598e-02f, 4.40283492e-02f, -1.65304035e-01f, 4.34124842e-02f, -9.18024182e-02f,
  -1.01370640e-01f, 1.51187912e-01f, 1.76225007e-01f, 5.44727966e-02f, 1.36823133e-01f, 1.08435921e-01f, -1.93732101e-02f, 1.22846290e-01f, 1.44737437e-01f, 6.38488727e-03f,
  8.58956426e-02f, -1.05585769e-01f, 1.29632950e-02f, 2.66890973e-02f, -1.46656096e-01f, 5.63282147e-03f, -5.89887612e-02f, -4.28415462e-02f, -6.71616420e-02f, -1.01081040e-02f,
  1.11473314e-02f, 3.47485878e-02f, -1.07902437e-01f, -5.37329577e-02f, -1.75847262e-01f, -3.29873003e-02f, 9.69213694e-02f, 1.07937470e-01f, 1.58699587e-01f, -2.81676222e-02f,
  -9.71788839e-02f, 9.48081445e-03f, -1.28191441e-01f, 7.99089596e-02f, 1.07438765e-01f, -2.96047386e-02f, 2.02177271e-01f, 9.77901965e-02f, -8.97786021e-02f, 1.35032520e-01f,
  1.19860820e-01f, 4.56116013e-02f, -6.47634342e-02f, 2.12605655e-01f, 1.24401338e-01f, 1.27999917e-01f, 1.75395146e-01f, -1.24372346e-02f, 4.07801718e-02f, -4.50476073e-03f,
  1.12268381e-01f, -1.97958127e-02f, -1.73767693e-02f, 1.21205978e-01f, -1.06668249e-01f, -1.14912450e-01f, -1.44891202e-01f, -4.71839011e-02f, -6.17012009e-02f, 4.26268950e-02f,
  1.06044166e-01f, 2.31613945e-02f, 2.38730088e-02f, -1.51663180e-02f, 1.03323773e-01f, 7.24790171e-02f, -8.61544802e-04f, 1.03583321e-01f, -2.26458870e-02f, -1.90829471e-01f,
  -1.45788910e-02f, -1.06054462e-01f, 1.44006938e-01f, -3.46734822e-02f, 7.91660100e-02f, 3.99204008e-02f, -3.65768149e-02f, 2.12775096e-02f, -1.00971431e-01f, 1.85420334e-01f,
  8.61745677e-04f, 7.17660263e-02f, 7.81478360e-02f, -9.64208245e-02f, -1.97484307e-02f, -7.36634061e-02f, -7.86572695e-03f, 2.36595586e-01f, 1.28881842e-01f, -3.76384449e-03f,
  -4.98840287e-02f, -3.30481067e-04f, 1.45064108e-02f, 7.25384578e-02f, -8.40615109e-02f, 7.85575882e-02f, 3.90761010e-02f, -2.44649611e-02f, 5.37349330e-03f, 1.06323004e-01f,
  -7.39643397e-03f, -8.95226672e-02f, -9.42898914e-02f, 9.74481255e-02f, 1.20473407e-01f, -6.39702156e-02f, -9.43766534e-02f, -4.49431501e-02f, -3.24725322e-02f, 6.15464430e-03f,
  -8.42200145e-02f, -4.39697504e-02f, -1.07531011e-01f, -8.49559680e-02f, -1.41827145e-03f, 4.13889922e-02f, -2.95184869e-02f, -3.31927240e-02f, 3.23133282e-02f, 7.66315460e-02f,
  1.97029207e-02f, -9.60178003e-02f, 2.79448405e-02f, 1.13228038e-01f, -8.02147985e-02f, -1.02325156e-01f, -6.40740693e-02f, -5.38330637e-02f, -8.28829855e-02f, -5.99816106e-02f,
  6.40332103e-02f, -3.63163138e-03f, 5.20450100e-02f, -1.69633813e-02f, -5.72175793e-02f, 7.19200969e-02f, 5.36616333e-02f, 4.69290204e-02f, -8.90399516e-02f, -9.80574936e-02f,
  -9.60293934e-02f, 1.13765903e-01f, 7.07237646e-02f, 2.77256519e-02f, -1.27794817e-01f, 1.26104653e-01f, 1.02978766e-01f, -6.09293990e-02f, 5.62152192e-02f, 4.10145149e-03f,
  -2.57915407e-02f, 1.58039838e-01f, 1.45639762e-01f, 8.38453323e-02f, -4.02378105e-02f, -8.11700150e-03f, 1.67918764e-03f, 1.00402765e-01f, 2.44228193e-03f, 1.34991810e-01f,
  -8.40761513e-02f, 7.19355047e-02f, -6.67256117e-02f, 5.34129068e-02f, 4.09178175e-02f, 5.59211336e-02f, -2.53493674e-02f, -3.26416120e-02f, 7.42693767e-02f, 6.30706847e-02f,
  -6.64295768e-03f, -1.27970189e-01f, -1.27251027e-02f, 5.54943494e-02f, 4.13774811e-02f, -6.58278493e-03f, 1.53751913e-02f, -2.95318216e-02f, -2.32867580e-02f, 1.19069166e-01f,
  -8.07142183e-02f, 1.18095145e-01f, 5.60499988e-02f, 1.19746607e-02f, -3.52626443e-02f, -1.38322115e-02f, 3.74542624e-02f, 6.16269447e-02f, -7.04058260e-02f, -5.79561554e-02f,
  -9.33826044e-02f, -4.29810118e-03f, 4.59727040e-03f, -3.59207019e-02f, -1.59946159e-02f, -8.92399102e-02f, 2.20016718e-01f, 2.01024790e-03f, 1.08462930e-01f, -2.20784079e-02f,
  1.21103071e-01f, -4.16957401e-03f, 7.36493766e-02f, 3.33775803e-02f, -3.46422009e-02f, -7.32282624e-02f, 2.29836628e-02f, 1.58115864e-01f, -4.57320660e-02f, 9.95682999e-02f,
  -9.04847905e-02f, 3.94981764e-02f, 7.03839660e-02f, -1.12357982e-01f, 4.84215356e-02f, -6.11727731e-03f, 5.46195582e-02f, 1.65889695e-01f, -6.97654262e-02f, 7.49287605e-02f,
  1.23610973e-01f, 1.48807272e-01f, 6.70887008e-02f, -1.81989804e-01f, -8.57052281e-02f, -7.05936477e-02f, -6.59492612e-02f, -4.08253167e-03f, -3.01015936e-02f, -4.89677908e-03f,
  -4.49677147e-02f, -3.24960388e-02f, -3.92525792e-02f, -8.03785995e-02f, 1.06787823e-01f, -8.50393027e-02f, -5.69344778e-03f, 1.99367590e-02f, 1.35797366e-01f, -7.66314715e-02f,
  1.57054827e-01f, 9.20835212e-02f, -3.85883078e-02f, 2.32820828e-02f, -2.29495130e-02f, 1.57847688e-01f, 4.95922156e-02f, -9.76795033e-02f, -1.99052855e-01f, -3.58419456e-02f,
  1.50317594e-01f, 1.20602548e-01f, 2.24529460e-01f, 1.86124723e-02f, 4.15790500e-03f, 7.94644728e-02f, -5.41355163e-02f, -7.11561739e-02f, -8.78139585e-03f, 4.81397845e-02f,
  -3.39555070e-02f, -2.79234760e-02f, 2.66759433e-02f, -1.10831089e-01f, 1.27339572e-01f, 1.12234302e-01f, 1.02305934e-01f, -6.08675135e-03f, -4.66212593e-02f, 4.55223247e-02f,
  -8.63330439e-02f, -6.19525537e-02f, 6.49972111e-02f, 4.07867432e-02f, 5.14316633e-02f, 7.45013133e-02f, 6.59183115e-02f, -7.81209543e-02f, 9.79312211e-02f, 3.82401831e-02f,
  2.37062760e-02f, 1.02976151e-01f, 3.34879234e-02f, 1.86360419e-01f, 1.10687144e-01f, 1.79660529e-01f, 1.23044387e-01f, -3.88138890e-02f, 6.17093518e-02f, -3.11059933e-02f,
  9.27725583e-02f, -3.00127506e-01f, 1.05105147e-01f, -5.45631722e-02f, -1.36267301e-02f, 7.99050406e-02f, -2.65746545e-02f, 1.31858453e-01f, 8.75520986e-03f, 1.85938507e-01f,
  8.76033232e-02f, 2.03959480e-01f, 9.44668427e-02f, 1.51550904e-01f, 5.39452806e-02f, -3.55396681e-02f, 4.96700518e-02f, 1.04342796e-01f, 7.44764283e-02f, 1.21295191e-01f,
  1.47979176e-02f, 1.04122479e-02f, -3.12400274e-02f, 1.45939171e-01f, -5.10628596e-02f, 9.92649570e-02f, 6.95610940e-02f, -1.63792416e-01f, -1.01194166e-01f, 1.03760809e-01f,
  -3.73935960e-02f, 1.28584281e-01f, 1.29232049e-01f, 1.60341784e-01f, 2.30320588e-01f, -1.82582036e-01f, 1.74276352e-01f, 1.09465025e-01f, 3.72655690e-02f, 1.09342337e-01f,
  -2.58508231e-02f, 1.48298964e-01f, 2.46245787e-02f, 6.46768510e-02f, -1.01882212e-01f, 8.05699974e-02f, -1.07705638e-01f, -3.66148017e-02f, 1.30054861e-01f, 2.07582153e-02f,
  -3.94139113e-03f, 1.51487246e-01f, 7.76543990e-02f, -7.18922839e-02f, 9.67062265e-03f, 2.22296894e-01f, -1.34442756e-02f, 1.88208476e-01f, 1.21880043e-02f, 1.46868452e-01f,
  -3.94258052e-02f, -1.10741168e-01f, -1.21858917e-01f, -6.91307485e-02f, 7.81125873e-02f, -2.68389791e-01f, 1.10201232e-01f, -1.01125374e-01f, 3.68346646e-02f, 8.38887319e-02f,
  6.70810416e-02f, 5.34299016e-02f, 7.52745196e-02f, 3.89623828e-02f, 1.79295257e-01f, 1.63624123e-01f, 7.37709180e-02f, 2.79944032e-01f, 1.10846423e-01f, 1.34141132e-01f,
  1.35769382e-01f, 7.96441510e-02f, 8.83083791e-02f, 4.94985580e-02f, 2.21088439e-01f, 1.30528569e-01f, 3.24887782e-02f, 1.77288219e-01f, 2.51399297e-02f, -1.19674809e-01f,
  7.71381557e-02f, -1.92760348e-01f, -3.81499939e-02f, 4.84508201e-02f, 1.01970963e-01f, -9.76302922e-02f, 1.33368656e-01f, 1.85332835e-01f, 3.00758630e-01f, -1.51899189e-01f,
  1.97134316e-01f, -5.61110452e-02f, 2.28923380e-01f, 1.49055406e-01f, 1.46267861e-01f, -5.47624044e-02f, 1.69700429e-01f, 1.80791304e-01f, -2.31760889e-01f, 1.47551462e-01f,
  -3.89302224e-02f, -8.06893036e-02f, 8.88658836e-02f, 1.96659699e-01f, -4.73731011e-02f, 1.35256708e-01f, -9.80833247e-02f, 1.10509023e-01f, 7.43611455e-02f, 2.96939373e-01f,
  -7.96400681e-02f, 7.62185082e-02f, 1.05814658e-01f, 1.51207104e-01f, -3.12990695e-02f, 9.39599425e-02f, -6.42738817e-03f, 4.88883033e-02f, -1.05072707e-01f, 3.89972553e-02f,
  8.73738900e-02f, 1.00179210e-01f, 3.86342555e-02f, 1.23513833e-01f, 1.39193311e-01f, 1.87960356e-01f, -4.55569550e-02f, 5.74475788e-02f, -3.18174660e-02f, -2.49973089e-02f,
  1.19901560e-01f, 8.03593919e-02f, 2.80439332e-02f, 5.25684282e-02f, 1.27550652e-02f, 2.51268595e-03f, -9.96449515e-02f, 6.97017759e-02f, 4.28411998e-02f, 1.61883622e-01f,
  1.41159177e-01f, 7.98178688e-02f, 1.32474840e-01f, 8.40996876e-02f, -3.46827554e-03f, 1.29021317e-01f, -3.11853457e-02f, 9.47218090e-02f, 5.38927056e-02f, -5.25424955e-03f,
  1.55294657e-01f, -1.97908748e-02f, 9.78639573e-02f, 6.91707358e-02f, -7.95408934e-02f, 1.07509255e-01f, 1.58662885e-01f, -8.43692720e-02f, -1.74376480e-02f, -6.77804500e-02f,
  1.31838396e-01f, 6.99936412e-03f, -3.92301157e-02f, 1.38613790e-01f, 2.08014175e-02f, 4.11031023e-02f, 1.06196161e-02f, 1.81455296e-02f, 1.30018100e-01f, 1.67383939e-01f,
  6.35198280e-02f, -4.35787532e-03f, 9.85429715e-03f, 1.21642590e-01f, 1.30342305e-01f, -5.35730049e-02f, -9.00441185e-02f, 2.11944077e-02f, -1.57823071e-01f, -9.27107930e-02f,
  5.14286943e-02f, 1.14220403e-01f, -4.47506318e-03f, -6.06854074e-02f, 6.38790876e-02f, 8.75101686e-02f, -1.53897181e-01f, 1.03208125e-01f, -8.38366225e-02f, 6.60152882e-02f,
  -6.70330897e-02f, 1.07179530e-01f, 1.64232716e-01f, 1.14934929e-01f, -8.06996748e-02f, -3.99952419e-02f, 9.73362774e-02f, -9.53427106e-02f, 2.40673255e-02f, -1.90487206e-02f,
  -1.09815262e-01f, 9.42481011e-02f, 1.05659217e-01f, -1.65581360e-01f, -3.03834700e-03f, -7.26953000e-02f, 1.97858103e-02f, 7.31461775e-03f, 1.56865746e-01f, 9.49328169e-02f,
  -4.09961641e-02f, 1.43002346e-01f, 1.14171468e-01f, -1.04738615e-01f, 4.73436154e-02f, 8.28173310e-02f, -1.00212760e-01f, -4.64381687e-02f, 1.21561602e-01f, 5.45784384e-02f,
  2.96024214e-02f, 1.38226911e-01f, 1.59277558e-01f, -5.07111885e-02f, -7.74244266e-03f, 1.00071833e-01f, 7.94024765e-02f, 5.40628247e-02f, -1.04896568e-01f, 1.29102588e-01f,
  1.12067796e-01f, -1.07774116e-01f, -8.54865089e-02f, 5.42807989e-02f, 1.36616707e-01f, 1.19979136e-01f, 5.52461892e-02f, -3.96597609e-02f, 1.50322765e-01f, 7.97326714e-02f,
  1.70323595e-01f, -3.21557783e-02f, 1.19096130e-01f, 3.98133881e-02f, -9.97364074e-02f, 2.87979618e-02f, -7.13913888e-02f, 1.68822035e-02f, 2.88224313e-03f, 6.80317357e-02f,
  6.50321413e-03f, -4.83469293e-02f, -3.33040208e-02f, -1.34501681e-01f, 1.24882951e-01f, -3.56912427e-02f, 4.36311439e-02f, -7.67556205e-02f, 7.88081959e-02f, 9.39242393e-02f,
  5.70566840e-02f, -2.03535110e-02f, 1.38902813e-01f, 6.79711103e-02f, 9.03523490e-02f, 1.22409575e-01f, 1.15932181e-01f, -8.11276883e-02f, -1.66274067e-02f, 8.49848837e-02f,
  -1.96938872e-01f, 1.56458855e-01f, -1.54298291e-01f, 8.78737867e-02f, -1.23639666e-02f, -6.48283213e-02f, -1.36147877e-02f, 1.34971887e-01f, 1.54328449e-02f, -7.27530569e-02f,
  -1.41569123e-01f, 8.35240260e-02f, -5.32703362e-02f, -9.37687904e-02f, -3.01430840e-02f, -1.57623533e-02f, -4.39058170e-02f, -5.15451171e-02f, 1.29686132e-01f, 9.39460192e-03f,
  -3.89914541e-03f, 1.33366853e-01f, -6.02226518e-02f, 8.78302157e-02f, 6.17263503e-02f, 6.13127165e-02f, 8.47947225e-03f, -1.11785457e-01f, -9.45640728e-02f, 8.59776326e-03f,
  1.40641049e-01f, -1.27794251e-01f, -2.24089101e-02f, 2.42074784e-02f, 4.13418598e-02f, 9.57595780e-02f, 6.20052889e-02f, 1.54953882e-01f, 9.39106792e-02f, 1.26540894e-03f,
  -1.07531384e-01f, -1.40156478e-01f, -2.14570444e-02f, -7.61278421e-02f, 1.17621988e-01f, 1.50270596e-01f, 2.16792207e-04f, 1.58759534e-01f, 1.42405450e-01f, -1.44412145e-01f,
  1.01974361e-01f, -7.39176720e-02f, 1.33985773e-01f, 1.04976408e-01f, -7.43732182e-03f, -7.90104941e-02f, 1.34274572e-01f, 1.23216920e-01f, -6.29796535e-02f, 8.54536798e-03f,
  9.57450718e-02f, 4.00991775e-02f, 9.62990429e-03f, 3.34917568e-02f, 6.48630038e-02f, -2.84006540e-02f, -6.34347349e-02f, 1.70714762e-02f, 3.06520443e-02f, 5.13020232e-02f,
  1.04614729e-02f, -1.86648797e-02f, 9.92299020e-02f, 8.74635298e-04f, 2.08924204e-01f, -1.14545666e-01f, 9.12896264e-03f, -7.59104714e-02f, 1.13290824e-01f, -8.32598954e-02f,
  -6.72226325e-02f, 4.97174598e-02f, 4.11631167e-02f, -1.83943734e-02f, -5.60698472e-02f, 6.47891164e-02f, -1.14147305e-01f, -7.73277506e-02f, 1.29638631e-02f, -6.28702044e-02f,
  -1.42033799e-02f, -5.94255514e-02f, -1.00397386e-01f, -3.64726298e-02f, -1.07373700e-01f, 1.06123447e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  -1.45426579e-02f, 7.52770603e-02f, 2.57009786e-04f, -5.41116670e-02f, 1.06722005e-02f, -6.68182448e-02f, -4.91512418e-02f, 1.01838693e-01f, 1.29261583e-01f, 2.10535944e-01f,
  1.10819913e-01f, 8.29114839e-02f, 3.82023193e-02f, 1.15507074e-01f
};

// L2_fan_Wp (Shape: 25 x 64)
const int L2_fan_Wp_rows = 25;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -1.14061587e-01f, 3.77965719e-02f, 3.99805233e-02f, 5.11728711e-02f, 9.10719857e-02f, -5.12985215e-02f, 4.16446403e-02f, -3.33234086e-03f, 2.23402455e-02f, 4.32426706e-02f,
  1.11219175e-01f, -3.89814563e-02f, 3.04250196e-02f, -3.02140694e-02f, 1.67371571e-01f, 3.39926817e-02f, 2.22375151e-02f, 6.59603402e-02f, 4.63906676e-02f, 5.32612391e-02f,
  -7.91015774e-02f, -7.64052272e-02f, -4.48729843e-02f, -9.15656891e-03f, -1.08751193e-01f, -1.84848800e-01f, -5.63714206e-02f, 1.26438245e-01f, 1.05775207e-01f, -1.26878032e-02f,
  -6.81060031e-02f, 1.27225831e-01f, 9.48792398e-02f, -4.76114498e-03f, 2.92093456e-02f, -1.07996492e-02f, -1.90553129e-01f, -8.68534297e-02f, -2.12808158e-02f, -5.99105917e-02f,
  2.54058908e-03f, -4.29076925e-02f, 1.51114464e-01f, -4.63299416e-02f, -1.58154935e-01f, -1.09173842e-01f, -5.04069068e-02f, -7.02935904e-02f, 2.20729169e-02f, -1.29569406e-02f,
  8.75689611e-02f, 1.02433600e-01f, -5.23629934e-02f, -3.42246406e-02f, 2.51607075e-02f, 1.03474922e-01f, 1.39130745e-02f, -1.36659577e-01f, -1.23147801e-01f, 7.91715309e-02f,
  -5.32453619e-02f, -1.29126236e-01f, -1.76486876e-02f, -1.33158211e-02f, 4.99247434e-03f, -9.73343924e-02f, 1.96720809e-02f, -1.47579044e-01f, -9.66010913e-02f, -1.89957708e-01f,
  5.21372780e-02f, 6.32882342e-02f, 4.41126935e-02f, -4.88416553e-02f, -8.16030055e-02f, -1.87183186e-01f, -7.66042396e-02f, -2.00811386e-01f, 1.00150697e-01f, -1.40744478e-01f,
  -9.59613100e-02f, 4.38141897e-02f, -4.24870402e-02f, -9.44252685e-02f, -9.07311514e-02f, 1.53189087e-02f, -1.69296876e-01f, -7.86024705e-02f, 1.36554420e-01f, -8.80635902e-02f,
  -1.10659763e-01f, 8.74549076e-02f, -3.41189839e-02f, 1.02201715e-01f, 1.43155374e-03f, 1.07496798e-01f, 1.28201440e-01f, 7.92979226e-02f, -1.22897811e-01f, -4.65494655e-02f,
  -1.29569873e-01f, 1.67782083e-02f, 6.28604293e-02f, -3.56903225e-02f, -2.10422575e-02f, 1.56642184e-01f, 8.78725946e-03f, -3.82490680e-02f, -1.71716630e-01f, -8.14503208e-02f,
  1.55867517e-01f, 1.28328726e-01f, -1.47290871e-01f, -1.83359459e-01f, -1.40455123e-02f, -2.13311445e-02f, 7.58223981e-02f, 2.19611432e-02f, -8.28066915e-02f, -7.53623024e-02f,
  4.58432771e-02f, 4.99466397e-02f, 9.49134678e-02f, 9.20395330e-02f, 8.09534714e-02f, -4.68369946e-02f, -7.13547179e-03f, 1.52665615e-01f, 4.54489030e-02f, -1.38782203e-01f,
  9.40755084e-02f, -8.18283334e-02f, -2.30529644e-02f, 6.48819376e-03f, -1.40135735e-01f, 1.55613139e-01f, -5.11554666e-02f, 8.80552977e-02f, -7.44070932e-02f, -1.58199891e-01f,
  1.20901562e-01f, -3.37657332e-02f, 3.29125114e-02f, -1.13154225e-01f, 6.69383351e-03f, 9.78532955e-02f, -6.38154289e-03f, -1.12493798e-01f, 1.00682668e-01f, -8.23715888e-03f,
  5.84136171e-04f, -8.22877362e-02f, -1.11689501e-01f, -9.16114300e-02f, 1.13142699e-01f, -8.44887272e-02f, -1.01759821e-01f, 1.46767259e-01f, 3.35971788e-02f, -1.16367117e-01f,
  1.05273202e-01f, 4.40591872e-02f, -2.11487822e-02f, -4.34360355e-02f, 2.07924739e-01f, -7.30702579e-02f, 5.02978675e-02f, 1.83414072e-01f, -2.81876475e-01f, -2.53817886e-01f,
  1.11440703e-01f, -2.52028018e-01f, 1.04444712e-01f, 1.64713979e-01f, 8.42242595e-03f, 3.00816018e-02f, 9.12782475e-02f, -4.26578410e-02f, 1.84461083e-02f, 2.04349160e-02f,
  8.28285366e-02f, -1.11728735e-01f, 1.21114008e-01f, -6.18857108e-02f, 5.84912561e-02f, -1.69321835e-01f, 9.52005014e-02f, 1.02284998e-01f, -1.86751872e-01f, 1.19918287e-02f,
  1.32671297e-01f, 1.07270041e-02f, 7.42606744e-02f, -1.53118476e-01f, 8.99775792e-03f, -4.83153574e-02f, 5.31399064e-02f, -8.18660632e-02f, 1.02256820e-01f, 1.07922457e-01f,
  -1.23814337e-01f, -4.65171747e-02f, -1.49911001e-01f, -3.22839841e-02f, -9.19709429e-02f, -1.50018409e-01f, -2.87973266e-02f, -3.16810533e-02f, 1.13858432e-02f, 9.63042006e-02f,
  3.00161354e-03f, -4.80835995e-04f, -8.91954899e-02f, 1.77747048e-02f, 1.98212657e-02f, -6.26642928e-02f, 1.82558417e-01f, 7.35196099e-02f, -9.98762175e-02f, 1.44307762e-01f,
  -8.10881332e-02f, 1.76501155e-01f, -1.96768582e-01f, -6.07824661e-02f, -1.47220939e-01f, 6.29457086e-02f, 9.56637040e-02f, 1.61219150e-01f, 8.12829286e-02f, -3.29116844e-02f,
  7.90147707e-02f, 1.18619800e-02f, 1.15996458e-01f, 7.08539933e-02f, -1.78880543e-01f, -2.05677941e-01f, -3.12270112e-02f, 5.13823628e-02f, 7.22053796e-02f, 1.39389426e-01f,
  -2.21081719e-01f, -2.12516692e-02f, -1.45395873e-02f, 1.20970361e-01f, -8.49931762e-02f, -5.50759584e-02f, -5.30252643e-02f, 7.97001123e-02f, -1.49259372e-02f, 1.13485254e-01f,
  1.80204749e-01f, 3.10009658e-01f, 7.12166876e-02f, 1.20044172e-01f, -8.59605148e-02f, 3.48021574e-02f, 2.60889344e-02f, 6.39477745e-02f, -9.05349255e-02f, -4.65747109e-03f,
  -2.11935770e-02f, 1.19883336e-01f, 9.27958637e-02f, -3.51566933e-02f, 1.06357560e-01f, -6.08903319e-02f, -4.13771672e-03f, 7.49720261e-02f, -8.47162083e-02f, 1.85561534e-02f,
  8.98075774e-02f, 9.80898663e-02f, -8.73693265e-03f, -8.48638266e-02f, -6.63058236e-02f, 1.83257256e-02f, -7.20793828e-02f, -9.51502100e-02f, -8.16913694e-02f, 3.09031829e-02f,
  1.10864677e-01f, -2.22060189e-01f, -7.51817077e-02f, 1.23398677e-01f, -1.12359650e-01f, -1.44153293e-02f, -2.17423171e-01f, -1.49824275e-02f, 1.59690484e-01f, -5.29861413e-02f,
  3.28968652e-02f, -8.48194435e-02f, -2.34671026e-01f, -1.06350228e-01f, -1.05864815e-01f, -2.17315435e-01f, 7.29935616e-02f, 1.28200039e-01f, 1.51060253e-01f, 1.61993846e-01f,
  -1.39532492e-01f, -1.50187071e-02f, 5.94365858e-02f, -8.60641524e-02f, -1.36361510e-01f, 2.07041293e-01f, 1.17767684e-01f, 1.22017376e-01f, 3.78402974e-03f, 3.38872224e-02f,
  -8.43850449e-02f, -1.02222525e-01f, -4.84749041e-02f, -5.51531166e-02f, 9.49626341e-02f, 1.22163199e-01f, -7.27533102e-02f, -1.72726825e-01f, -1.37608439e-01f, 2.08470058e-02f,
  -8.18564892e-02f, -1.01824149e-01f, 4.98463735e-02f, 1.17643431e-01f, 1.05955638e-01f, -4.21193466e-02f, -1.32259429e-01f, -4.04862463e-02f, 2.21636575e-02f, -7.69573003e-02f,
  -4.29649912e-02f, -9.44994017e-02f, 8.41143075e-03f, 8.34597498e-02f, 1.07738320e-02f, 6.77975118e-02f, 9.02811512e-02f, -6.03195392e-02f, -4.08751518e-02f, -3.88379395e-02f,
  -8.88040662e-02f, 8.33498091e-02f, 7.00532869e-02f, 4.08346243e-02f, 4.11163904e-02f, 2.56945193e-02f, -7.20699057e-02f, 2.01245234e-03f, -3.91491205e-02f, 2.02396452e-01f,
  1.36288174e-03f, 3.15015465e-02f, 1.75815192e-04f, 2.40053367e-02f, -1.79664150e-03f, 5.36245815e-02f, 5.91071174e-02f, -1.30649656e-01f, 8.57884809e-02f, 7.01579750e-02f,
  -3.59086581e-02f, 1.35702053e-02f, -1.75679013e-01f, -2.45898560e-01f, 1.57816708e-01f, 1.16150655e-01f, 4.58743647e-02f, -1.75199881e-02f, 1.17388659e-03f, 3.58073227e-02f,
  -1.84460636e-02f, 1.47290915e-01f, 1.20792314e-01f, -7.02551454e-02f, 1.58961013e-01f, 7.96190202e-02f, -1.21230014e-01f, 1.68078542e-01f, 1.66516706e-01f, 1.13537401e-01f,
  -7.19617307e-03f, 1.16770133e-01f, 4.20369692e-02f, -5.17881885e-02f, -4.47712541e-02f, -2.30166689e-02f, 1.13885894e-01f, -1.12090260e-01f, 9.83913690e-02f, 1.20597929e-02f,
  3.37896869e-02f, 3.47450115e-02f, -8.31556767e-02f, -1.83084197e-02f, 6.72969073e-02f, -1.95963830e-02f, 3.19054052e-02f, -4.06620651e-02f, -3.87272127e-02f, 3.63386273e-02f,
  -1.13461949e-01f, 8.22209865e-02f, -3.54578234e-02f, 9.35282931e-02f, -9.33686122e-02f, 3.16365995e-02f, -1.20290250e-01f, -5.50850108e-02f, 3.33483703e-02f, -1.08863682e-01f,
  8.75162631e-02f, 1.11805752e-01f, -1.35334924e-01f, 6.06724434e-02f, -2.30581865e-01f, 8.36279318e-02f, 8.29582587e-02f, 1.05227284e-01f, 7.90586695e-03f, -1.15529087e-03f,
  -1.37279138e-01f, -7.53490329e-02f, 2.45387387e-02f, -9.33479518e-03f, -4.55284715e-02f, 1.08088134e-02f, 1.69592932e-01f, 5.34767956e-02f, 7.72084817e-02f, -1.30704284e-01f,
  8.76939595e-02f, 1.66937686e-03f, -1.02523379e-01f, 2.86310557e-02f, 4.93946187e-02f, -7.71270320e-02f, 9.38184187e-02f, 1.20183475e-01f, -2.61966046e-02f, -1.08248442e-01f,
  8.36083144e-02f, -3.84413302e-02f, 7.47452378e-02f, 1.27476826e-01f, -6.68694302e-02f, -1.38640806e-01f, 2.21735751e-03f, 1.40750423e-01f, 1.03378082e-02f, 5.37467338e-02f,
  -1.30747572e-01f, 1.70315746e-02f, 4.44960520e-02f, 1.15421399e-01f, 4.84327041e-02f, -1.07378714e-01f, 5.40522626e-03f, -1.06935456e-01f, -3.97370085e-02f, -1.36341169e-01f,
  -3.53009962e-02f, -2.00984016e-01f, -1.17682591e-01f, -2.04710029e-02f, 1.44094393e-01f, 1.06303766e-01f, 1.48137137e-01f, 1.10842912e-02f, 1.28366798e-01f, 4.80423309e-02f,
  -4.12388258e-02f, -1.64962616e-02f, 2.73506623e-02f, 2.05117434e-01f, -1.04984820e-01f, 1.67508215e-01f, -1.32673040e-01f, 1.72555178e-01f, 1.43753082e-01f, 1.46122381e-01f,
  -5.39436750e-02f, 3.20367962e-02f, 1.57757133e-01f, -8.51875823e-03f, -4.42795530e-02f, 3.46436240e-02f, 1.37307301e-01f, -1.03597306e-02f, 5.04955761e-02f, 2.05717802e-01f,
  -1.61419481e-01f, -6.51599839e-02f, 5.57332598e-02f, 1.39914572e-01f, 1.68922886e-01f, 9.10110921e-02f, -8.41897652e-02f, -1.93304047e-01f, 7.01733232e-02f, 8.98859724e-02f,
  -1.00405075e-01f, 4.59849983e-02f, 1.32126138e-01f, -4.32270169e-02f, -1.22811392e-01f, 2.08734080e-01f, 4.93108407e-02f, 1.04949668e-01f, 1.89185124e-02f, 1.25480220e-01f,
  -1.48064554e-01f, -3.10594924e-02f, -1.32603168e-01f, 1.14372931e-01f, 5.32516800e-02f, 1.04578398e-01f, 3.07836756e-02f, 4.70734872e-02f, 5.89105487e-02f, 2.04943623e-02f,
  -6.71588257e-02f, -3.44747417e-02f, -1.82217117e-02f, -6.54903054e-02f, -6.83992282e-02f, -2.54017636e-02f, -6.18876293e-02f, 5.31214513e-02f, -3.94692179e-03f, 7.88766965e-02f,
  1.12919547e-01f, -1.08475864e-01f, 6.52235821e-02f, -3.76539938e-02f, 1.20752156e-01f, 7.51846731e-02f, 1.39794454e-01f, 4.65686880e-02f, -2.34189779e-01f, 2.69173663e-02f,
  8.70125145e-02f, -1.83020979e-01f, 2.11872354e-01f, 3.54179367e-02f, -1.52472779e-01f, 1.18310198e-01f, 1.48275539e-01f, 8.65299404e-02f, -1.42557267e-03f, 1.75351091e-02f,
  -7.38588795e-02f, -3.88710797e-02f, -1.69782750e-02f, 3.73474881e-02f, -2.05266818e-01f, 4.21066321e-02f, -1.56166852e-02f, -1.09275289e-01f, 9.95427743e-03f, 9.37267989e-02f,
  1.16208360e-01f, -1.06202848e-01f, -7.05922842e-02f, 3.38703878e-02f, 5.44677563e-02f, -8.23486373e-02f, 1.76978260e-01f, 1.15424156e-01f, 5.26826307e-02f, -2.06778925e-02f,
  3.17076407e-02f, -7.75821209e-02f, 8.68026987e-02f, 1.30255416e-01f, 1.33118182e-01f, 6.18821420e-02f, 1.40513226e-01f, 9.49848667e-02f, 1.74509361e-01f, 1.40884802e-01f,
  2.91835461e-02f, 1.44278646e-01f, -8.46535042e-02f, -5.25203869e-02f, 1.27416119e-01f, 4.62258235e-02f, -4.45731357e-02f, 1.05198115e-01f, 1.98450103e-01f, 1.30854070e-01f,
  1.30330220e-01f, -2.58148294e-02f, 7.40250722e-02f, 1.05443723e-01f, 3.19015962e-04f, -3.51257063e-02f, 1.84405982e-01f, -3.36208753e-03f, 3.99486674e-03f, -5.87164499e-02f,
  -1.65127128e-01f, -1.30638629e-01f, 2.40514755e-01f, -1.12265363e-01f, -2.66725291e-02f, 1.67666003e-01f, -9.11848694e-02f, -8.55838656e-02f, 1.49672657e-01f, -5.50776795e-02f,
  -1.41031042e-01f, 9.31655467e-02f, 8.89838934e-02f, -1.05330892e-01f, -1.63848661e-02f, 6.76194057e-02f, -2.08901107e-01f, -9.97528508e-02f, 1.75018579e-01f, -1.35589629e-01f,
  -1.59150377e-01f, 1.43807963e-01f, -1.27812132e-01f, 7.60344192e-02f, -1.16748326e-01f, 1.50259241e-01f, -7.09937513e-02f, 9.40504600e-04f, 1.22410573e-01f, -5.40081486e-02f,
  -2.85398457e-02f, 4.51357253e-02f, -1.02366962e-01f, -7.89858308e-03f, -6.00980185e-02f, -3.23464982e-02f, -1.02186017e-01f, 4.35339250e-02f, -2.80054770e-02f, -3.12227737e-02f,
  -2.26403903e-02f, -1.71042792e-02f, -3.84786353e-02f, 8.22419822e-02f, 2.75313598e-03f, 1.58831418e-01f, -8.73309076e-02f, -1.01831302e-01f, 1.29991755e-01f, -6.23594336e-02f,
  8.51680934e-02f, 2.68107429e-02f, 9.47280154e-02f, -1.12744302e-01f, -7.87882730e-02f, 2.48203166e-02f, 1.58979669e-01f, -5.59212007e-02f, 3.41673978e-02f, 4.49352339e-02f,
  1.59792885e-01f, 1.06422864e-01f, -6.36939257e-02f, 1.57015339e-01f, -4.03654762e-02f, 1.08879834e-01f, 1.82082877e-03f, -2.55305141e-01f, 4.37453240e-02f, -1.86845008e-02f,
  2.70596802e-01f, -2.76199430e-02f, -1.50657564e-01f, -1.77431747e-01f, 1.20495245e-01f, 7.64826685e-02f, -1.10717483e-01f, 4.18583071e-03f, 2.89694732e-03f, 1.93974301e-01f,
  -7.23439604e-02f, -8.43828395e-02f, -5.47625236e-02f, 5.52489683e-02f, -4.89652492e-02f, 6.76484108e-02f, 1.26863256e-01f, -5.51230498e-02f, 5.22213876e-02f, 4.44468856e-02f,
  5.93552813e-02f, -6.64737597e-02f, -5.02639078e-02f, 1.68735683e-02f, -6.77457750e-02f, 1.06356554e-01f, -1.69248745e-01f, -1.26844436e-01f, -1.39632240e-01f, -2.41567865e-01f,
  -1.31587401e-01f, 7.11027160e-02f, 1.02431349e-01f, -1.64786115e-01f, 9.20334682e-02f, -1.37633756e-01f, 1.01812102e-01f, -2.96176020e-02f, 1.68802571e-02f, -7.26418272e-02f,
  -9.63509455e-02f, 2.90414109e-03f, 1.12483971e-01f, 1.19582094e-01f, 1.11233927e-01f, -1.15462594e-01f, 1.26391292e-01f, 9.89656970e-02f, -1.41662538e-01f, 1.01544961e-01f,
  1.19254544e-01f, -9.42885280e-02f, 2.10923292e-02f, -1.46164326e-02f, 7.70217404e-02f, 4.07117419e-03f, 6.08293898e-02f, 5.72612062e-02f, -8.24708939e-02f, 1.59146681e-01f,
  -5.79423383e-02f, 7.51592666e-02f, -1.80925652e-02f, -5.94695322e-02f, 2.40880072e-01f, -2.85453089e-02f, 7.07662925e-02f, -3.51984277e-02f, 2.11496893e-02f, 2.08211407e-01f,
  8.98533314e-02f, 9.68400091e-02f, 6.89958781e-02f, 1.29602239e-01f, 8.18341598e-02f, 1.07760981e-01f, -1.04809247e-01f, -1.90807842e-02f, -4.75455113e-02f, 9.87185985e-02f,
  -1.59009658e-02f, -3.46194766e-02f, 3.85568663e-02f, -8.52484405e-02f, -1.33649083e-02f, 9.43778008e-02f, -9.80108604e-02f, -1.17222764e-01f, 1.11728489e-01f, 1.23924628e-01f,
  -1.24293797e-01f, 8.90378430e-02f, -1.56017005e-01f, -1.17502771e-01f, -1.27890676e-01f, 1.09157816e-01f, 2.54742056e-02f, -1.29804254e-01f, -8.78706351e-02f, 6.74037496e-04f,
  -1.10270940e-01f, 7.50797018e-02f, -8.53909552e-02f, 1.31265923e-01f, 2.14194193e-01f, 7.13482648e-02f, 9.30253044e-02f, 1.59242719e-01f, -6.82951137e-02f, -7.64154717e-02f,
  -3.97634916e-02f, -1.49271470e-02f, 7.65247792e-02f, -2.68540885e-02f, 2.24228799e-02f, 1.11939289e-01f, -1.08527847e-01f, 1.02421485e-01f, -9.84676927e-02f, 5.85624017e-02f,
  4.50688004e-02f, -1.96520742e-02f, 1.54872760e-01f, 1.84333712e-01f, -1.23906977e-01f, -5.45368455e-02f, 2.89490283e-03f, -1.44229352e-01f, 8.37101713e-02f, 1.80075839e-01f,
  -2.38348499e-01f, 3.48949395e-02f, 2.22722381e-01f, 4.12179045e-02f, -8.67633596e-02f, 9.85385627e-02f, 1.25603959e-01f, 1.48698062e-01f, -2.02123336e-02f, 5.27549088e-02f,
  -1.71451941e-01f, 1.37313724e-01f, 9.50329453e-02f, -7.43638426e-02f, -7.47260824e-03f, 1.84484962e-02f, 6.36684299e-02f, -2.15792358e-01f, -2.57014465e-02f, -8.31564702e-03f,
  -1.12860069e-01f, -1.27616629e-01f, 8.54838565e-02f, 5.46817854e-02f, -4.44979817e-02f, 1.76853269e-01f, 6.91654757e-02f, 1.00839511e-02f, 9.93930027e-02f, -6.68321252e-02f,
  -4.64864075e-02f, -1.14840679e-02f, -4.05332670e-02f, -7.14902058e-02f, 2.18241718e-02f, -2.50876532e-03f, 6.99822232e-02f, 8.40792339e-03f, -1.15631945e-01f, -7.56061375e-02f,
  5.53472824e-02f, 2.90023740e-02f, 7.82311112e-02f, 2.46593505e-02f, -1.13370858e-01f, 3.37586477e-02f, 7.51666948e-02f, 1.44897662e-02f, -1.29463794e-02f, -9.14635733e-02f,
  1.00269556e-01f, -1.20509766e-01f, -1.10073179e-01f, -6.25778884e-02f, -7.48994648e-02f, -1.42627493e-01f, 1.38863787e-01f, 1.64461255e-01f, -1.87294669e-02f, 1.56443775e-01f,
  -1.73844531e-01f, 1.20627761e-01f, 4.52777110e-02f, -9.44877416e-02f, 2.87535898e-02f, 1.34916738e-01f, -1.16072185e-01f, 1.55627266e-01f, 1.03295855e-01f, -8.21691230e-02f,
  1.33358777e-01f, -5.10352477e-02f, 9.58233252e-02f, -8.76579285e-02f, -1.08794019e-01f, -3.23991254e-02f, 1.67600829e-02f, 6.47901073e-02f, 1.03230169e-02f, 6.61034510e-02f,
  -9.30966344e-03f, 8.41578841e-03f, 2.89156623e-02f, 4.85486677e-03f, -9.89396009e-04f, -5.47076277e-02f, 8.81028548e-02f, 1.03236675e-01f, 8.10833871e-02f, -4.77158371e-03f,
  1.59136027e-01f, 1.53492108e-01f, -1.41881570e-01f, -9.44415703e-02f, 8.86165425e-02f, -6.75249705e-03f, -6.49738610e-02f, 1.28220962e-02f, -5.11175022e-02f, 7.62688592e-02f,
  4.87996936e-02f, -1.48172557e-01f, 1.27971828e-01f, 6.47729486e-02f, -1.50311559e-01f, -1.38184667e-01f, -4.66242991e-03f, 3.03110778e-02f, -2.08449185e-01f, -8.93189609e-02f,
  7.87989870e-02f, 8.20783153e-02f, 1.82414136e-03f, 1.07553832e-01f, -1.26081601e-01f, 2.12105666e-03f, -1.31471157e-02f, -1.48979798e-01f, 2.06147078e-02f, -9.61802751e-02f,
  2.04010785e-01f, -5.55945188e-02f, 1.43966312e-02f, 2.14254767e-01f, -2.07268208e-01f, 1.00807771e-01f, -1.73451915e-01f, 1.39512464e-01f, -6.03158735e-02f, 6.22386262e-02f,
  9.17368084e-02f, 3.87358144e-02f, -1.56166375e-01f, -2.72166654e-02f, 1.71567835e-02f, -2.10170865e-01f, 2.11838633e-01f, 2.09812894e-01f, 1.28608570e-01f, 6.95384592e-02f,
  8.01282823e-02f, -1.27512172e-01f, 1.81915388e-02f, 1.32497042e-01f, -3.81739326e-02f, 7.89538547e-02f, -9.45533887e-02f, 9.73409563e-02f, 2.37171352e-02f, -6.26274571e-02f,
  5.39300218e-03f, -5.19957356e-02f, 1.30761325e-01f, -1.10887019e-02f, 1.74477413e-01f, 2.62071103e-01f, -4.84239236e-02f, 4.27835584e-02f, -3.69920908e-03f, -1.95421744e-02f,
  3.16368155e-02f, -1.50431380e-01f, 7.57591426e-02f, 1.09344684e-02f, 9.02032712e-04f, -2.82761641e-02f, 4.32022326e-02f, -7.95427561e-02f, -3.91785726e-02f, 9.38299522e-02f,
  -7.76823610e-02f, -1.83625147e-01f, -1.04093134e-01f, -3.49072367e-02f, -3.82384174e-02f, -1.17828988e-01f, -1.55446501e-02f, 3.42318192e-02f, -1.16938367e-01f, -1.77699372e-01f,
  -1.97761506e-01f, -1.39620602e-01f, 5.02154566e-02f, 3.97180803e-02f, 1.76773474e-01f, 2.23974347e-01f, -1.42710075e-01f, 1.81342885e-01f, -2.30264869e-02f, -6.46359697e-02f,
  1.21152848e-02f, 1.67646036e-01f, -2.04679489e-01f, 1.38524771e-01f, 1.11022994e-01f, 4.69964072e-02f, 1.24261267e-01f, 4.86051254e-02f, 7.70042166e-02f, -1.10851720e-01f,
  1.18264686e-02f, 1.15985021e-01f, -5.52472658e-02f, 8.04412290e-02f, 4.85043749e-02f, -1.69986233e-01f, 1.77401662e-01f, 9.62130502e-02f, -1.44099653e-01f, -1.54089496e-01f,
  -9.45533738e-02f, 1.26215860e-01f, -6.07619882e-02f, -2.16663512e-03f, 6.68283999e-02f, -5.02890383e-04f, 4.69781198e-02f, 7.36744329e-02f, 5.90437688e-02f, 5.50857075e-02f,
  7.73612186e-02f, 4.44730669e-02f, -7.37026893e-03f, 9.72820725e-03f, 8.10989216e-02f, 1.00084767e-01f, 9.22375452e-03f, 9.46219340e-02f, -2.10795067e-02f, 1.44848570e-01f,
  3.37123573e-02f, -9.22065750e-02f, -6.23397231e-02f, 2.18821783e-02f, -2.39180494e-02f, 6.43506274e-02f, -1.05974995e-01f, 1.46327272e-01f, 1.81583971e-01f, 1.49918213e-01f,
  3.35196145e-02f, 9.42887180e-03f, 2.95113903e-02f, 7.98061341e-02f, -5.19940071e-02f, 8.54027458e-03f, 5.96046597e-02f, 1.53660253e-02f, 9.71563458e-02f, -1.22169517e-01f,
  2.75256280e-02f, 4.12845276e-02f, 1.63535371e-01f, -1.94973901e-01f, 1.26817077e-01f, 3.97377722e-02f, 1.32715881e-01f, -9.27519053e-02f, 4.57747802e-02f, -1.84167519e-01f,
  -1.48872882e-01f, -3.55139039e-02f, 3.91101018e-02f, 2.80325897e-02f, 1.79352969e-01f, 8.74182284e-02f, 1.03401706e-01f, 1.49909884e-01f, -1.48667907e-02f, -9.57504585e-02f,
  -1.02033868e-01f, 4.28853091e-03f, 1.46659091e-01f, 1.22673266e-01f, -1.10257052e-01f, 1.09166510e-01f, -8.47732350e-02f, 6.17590770e-02f, -1.37230754e-01f, 3.68350446e-02f,
  -6.10835217e-02f, -4.29525338e-02f, -2.89933681e-02f, -6.84081912e-02f, 1.60099551e-01f, -2.01029837e-01f, 1.28163844e-02f, 9.53099951e-02f, -1.47849321e-01f, 1.29589871e-01f,
  -9.11119394e-03f, -3.47082131e-02f, -5.94954938e-02f, -1.03943750e-01f, -2.54847296e-02f, -1.12673245e-01f, -9.49100405e-02f, 4.30518799e-02f, -1.04078375e-01f, 1.45528212e-01f,
  1.23653732e-01f, -7.71882683e-02f, 8.58940370e-03f, -1.03126876e-02f, 8.50674976e-03f, -1.64779704e-02f, -7.60472789e-02f, 1.68787196e-01f, 6.00698590e-02f, 6.67266324e-02f,
  -4.77353483e-02f, 4.01797384e-04f, -1.33341849e-01f, -2.56369889e-01f, 1.00907020e-01f, -1.54068917e-01f, 1.85100868e-01f, -1.83638155e-01f, 4.43280153e-02f, 1.04878448e-01f,
  4.23547849e-02f, -1.79436907e-01f, -5.53543307e-03f, -9.93601512e-03f, -2.96309777e-02f, -4.01633568e-02f, -2.03202888e-01f, 2.18825266e-02f, 5.19637428e-02f, 1.20839886e-01f,
  3.82285677e-02f, 3.56126726e-02f, -9.02209431e-02f, -5.51959733e-03f, -1.13233328e-01f, -1.26231164e-01f, -4.55106795e-02f, 4.45643365e-02f, -6.76772371e-02f, -1.20048046e-01f,
  7.74111692e-03f, 7.57877156e-02f, -2.49017239e-01f, -3.58754061e-02f, -1.12839371e-01f, -1.17352724e-01f, -2.36159831e-01f, -1.22423999e-01f, 1.05442412e-01f, -2.62222365e-02f,
  -1.41923204e-01f, 1.32753365e-02f, 2.56898254e-02f, 1.18738897e-01f, 1.12980418e-01f, -7.95031041e-02f, -1.21688722e-02f, 1.40422791e-01f, 1.42090440e-01f, 8.88354629e-02f,
  6.82060942e-02f, -5.39494194e-02f, -6.11527748e-02f, -6.02509715e-02f, 6.10692725e-02f, 1.02084242e-01f, 5.90811372e-02f, 6.02200776e-02f, 1.01686515e-01f, 1.58482827e-02f,
  -9.05030668e-02f, -4.12562527e-02f, -1.39995208e-02f, 1.25615850e-01f, 1.60061177e-02f, 5.89892752e-02f, 8.95317495e-02f, 1.01583146e-01f, -2.56861467e-02f, -4.65961024e-02f,
  9.82825384e-02f, 1.38101459e-03f, 2.58348346e-01f, -4.44662273e-02f, -1.40242755e-01f, -1.68568283e-01f, 1.59306824e-01f, 1.23495638e-01f, -3.07944007e-02f, -6.35900199e-02f,
  9.03877467e-02f, 1.99581593e-01f, 1.49807528e-01f, 7.83871487e-02f, -2.59159114e-02f, -1.91130623e-01f, 1.28660575e-01f, 3.66370790e-02f, 1.21147484e-01f, -1.01088723e-02f,
  1.56136334e-01f, -7.72987679e-02f, -1.14293538e-01f, 1.31803565e-02f, -1.38372676e-02f, -1.20096885e-01f, -6.09058440e-02f, 1.13763243e-01f, -1.09800927e-01f, 1.81191936e-02f,
  -1.11282550e-01f, -1.35875270e-01f, 8.97123571e-03f, 2.66407151e-02f, 8.87689292e-02f, -7.18785599e-02f, -4.51141149e-02f, 3.68023813e-02f, -4.85582650e-02f, -8.66125003e-02f,
  5.76828569e-02f, -1.38849393e-01f, -9.95412618e-02f, -1.06943622e-01f, -1.99673269e-02f, -1.68418273e-01f, -8.30991417e-02f, -1.47281662e-01f, 1.03704177e-01f, -1.26895547e-01f,
  1.29939720e-01f, 1.06205098e-01f, 2.64839344e-02f, -1.11862470e-03f, 1.82750039e-02f, 5.90859875e-02f, -1.57092273e-01f, -3.10799275e-02f, -7.77218640e-02f, 4.85242531e-02f,
  2.44960263e-01f, 1.08706817e-01f, -1.53781682e-01f, -6.13219198e-03f, -1.21151239e-01f, 4.68942747e-02f, -2.37945467e-01f, -3.74942496e-02f, -1.08228937e-01f, 1.30839303e-01f,
  -1.05913095e-01f, 1.52621856e-02f, -4.66803424e-02f, 9.74852666e-02f, 1.08459875e-01f, 6.65119067e-02f, -2.44685218e-01f, -1.32536933e-01f, 1.68584213e-01f, 1.59081370e-01f,
  1.22440167e-01f, -1.41551107e-01f, 8.09194595e-02f, -7.19320104e-02f, 6.52050897e-02f, -2.58551329e-01f, 8.50847084e-03f, -2.23954115e-02f, -4.88691479e-02f, -1.22371756e-01f,
  1.36804968e-01f, 4.05942053e-02f, -4.94439825e-02f, -7.73314685e-02f, 1.07735798e-01f, -7.35922251e-03f, 1.45194873e-01f, 1.20558314e-01f, 1.19137228e-01f, 8.94312710e-02f,
  6.25752285e-02f, -1.66612491e-02f, 9.48821604e-02f, -9.76043493e-02f, -1.42914683e-01f, 7.23956376e-02f, 1.31709585e-02f, -1.18599594e-01f, 3.72009948e-02f, -3.28796394e-02f,
  8.27133879e-02f, -4.44089770e-02f, -9.91420671e-02f, 8.20222348e-02f, -6.55867681e-02f, -1.08049847e-01f, -2.46451013e-02f, -1.14567727e-01f, -6.08115681e-02f, 1.23153962e-01f,
  4.78859767e-02f, -1.00906879e-01f, 1.22381322e-01f, -2.13617217e-02f, -3.33770812e-02f, -1.76349908e-01f, 3.14273350e-02f, 2.54408214e-02f, -1.20913550e-01f, -2.63984650e-02f,
  -2.37681009e-02f, -1.07175000e-02f, 1.33272633e-01f, 1.06487900e-01f, 7.28074228e-03f, -9.49834511e-02f, -8.60008299e-02f, 8.92653912e-02f, 1.80557091e-02f, -1.29210591e-01f,
  -1.32454231e-01f, 4.28396165e-02f, 8.04794021e-03f, 1.09209619e-01f, -9.23895314e-02f, -1.03703074e-01f, -1.17100179e-01f, -4.83405963e-03f, 1.40391767e-01f, 7.91727230e-02f,
  -7.98288658e-02f, 6.77874908e-02f, -5.78429811e-02f, 1.43563077e-01f, -1.06282771e-01f, -7.62593448e-02f, 1.10139690e-01f, -1.41836271e-01f, 1.62813216e-02f, -1.36245847e-01f,
  -2.78522391e-02f, -8.04173797e-02f, -1.24418937e-01f, 1.74575269e-01f, -9.57334787e-02f, -8.20837617e-02f, 8.30898508e-02f, -9.55654383e-02f, 4.72864099e-02f, -4.15608101e-02f,
  -6.32648766e-02f, 3.91649492e-02f, 8.87338072e-02f, -1.04289182e-01f, 1.13812201e-01f, -7.48055801e-02f, -3.65274698e-02f, -9.08503681e-02f, -1.19524308e-01f, -5.15739247e-03f,
  -2.74989828e-02f, -5.47590591e-02f, -2.73621213e-02f, -1.44579545e-01f, 5.00367992e-02f, 1.35944150e-02f, 1.18636545e-02f, -2.54617035e-02f, 6.13432825e-02f, 2.05629960e-01f,
  -7.06363246e-02f, -4.38261684e-03f, -1.20159149e-01f, -9.08251479e-02f, 2.07897779e-02f, 1.25121102e-01f, -2.10161105e-01f, 1.38021991e-01f, -7.42414519e-02f, 3.16728279e-02f,
  1.64667945e-02f, -7.67926946e-02f, -3.65852192e-02f, 2.08399855e-02f, 5.68542741e-02f, -3.65333632e-02f, -1.10460095e-01f, -8.76298472e-02f, 1.52712464e-01f, -3.67494486e-02f,
  6.83124289e-02f, -1.14563502e-01f, -1.71106737e-02f, -9.37712714e-02f, 1.16262682e-01f, 1.49729400e-04f, -5.56176156e-02f, -6.92278743e-02f, 5.50164431e-02f, 1.23357914e-01f,
  -5.32889068e-02f, 1.16493441e-01f, -5.91768995e-02f, 5.28328978e-02f, 4.73437198e-02f, -3.41274850e-02f, 2.88309326e-04f, -1.13239422e-01f, 1.93189010e-02f, -1.81761682e-02f,
  -6.00862131e-02f, -5.23852482e-02f, -3.27850645e-03f, -4.04647775e-02f, -2.10825145e-01f, 8.92598778e-02f, -1.28223777e-01f, -1.68312058e-01f, 7.78649747e-02f, 1.55919582e-01f,
  -7.52425566e-02f, -2.74865478e-02f, -1.00739077e-01f, 8.70799348e-02f, -2.86125988e-02f, -3.30293812e-02f, -1.44463824e-02f, -4.68495861e-03f, 6.31224886e-02f, 9.14894044e-02f,
  -2.46234220e-02f, 3.13346125e-02f, 1.18229046e-01f, -1.45799592e-01f, 2.19372779e-01f, 1.04121849e-01f, -1.46914288e-01f, 2.51513392e-01f, -2.28883997e-01f, -1.28242567e-01f,
  6.80068601e-03f, 1.24570489e-01f, -2.56062239e-01f, -1.41124696e-01f, 8.38583261e-02f, -5.95512986e-02f, -4.05864641e-02f, -1.54503241e-01f, -1.35779396e-01f, 2.33078245e-02f,
  9.98582616e-02f, -1.11136474e-02f, -1.50248051e-01f, -7.93443918e-02f, 5.60053587e-02f, -2.76197167e-03f, -9.46190655e-02f, 1.46606117e-01f, -4.64885868e-02f, 1.95912253e-02f,
  -4.18560347e-03f, 1.51755586e-01f, -1.03384361e-01f, 4.46884744e-02f, 6.75674230e-02f, -1.53331876e-01f, 2.00184286e-01f, 2.22089872e-01f, -6.71211211e-03f, -1.47944149e-02f,
  1.02104954e-01f, 1.02876112e-01f, 1.53509872e-02f, 2.68407408e-02f, 9.64407846e-02f, 1.21392593e-01f, 5.08944280e-02f, 8.58656764e-02f, 5.44919744e-02f, 9.93199348e-02f,
  -2.03469191e-02f, 3.53157669e-02f, -8.91605094e-02f, -1.56979695e-01f, 1.48674518e-01f, -2.43676808e-02f, -7.06625581e-02f, -4.49379487e-03f, -6.11719973e-02f, 6.17834367e-02f,
  4.00415733e-02f, -1.16645455e-01f, -5.51070198e-02f, 8.67366865e-02f, -1.00458011e-01f, 9.27649031e-04f, -4.08205995e-03f, 7.26252869e-02f, -1.14575051e-01f, -5.73272482e-02f,
  -2.40324084e-02f, -9.18945521e-02f, 1.82079718e-01f, 4.94072884e-02f, -7.62800500e-02f, 7.03828633e-02f, 3.36493440e-02f, 1.21477410e-01f, 1.09901704e-01f, -1.36540338e-01f,
  -3.52057591e-02f, -1.86556913e-02f, 1.77984219e-02f, -9.68013629e-02f, -2.03931943e-01f, -6.03574961e-02f, 1.20562352e-01f, 1.12162977e-01f, 5.27802706e-02f, 4.80729230e-02f,
  -3.31755877e-02f, -1.02615170e-01f, -2.95454301e-02f, 9.06355307e-02f, 1.14176692e-02f, -1.09629780e-01f, 1.00448221e-01f, 3.96366529e-02f, 4.47677560e-02f, 2.17649136e-02f,
  -9.58330259e-02f, -2.46337317e-02f, -1.38053164e-01f, -1.06107639e-02f, 1.24573573e-01f, -3.25610824e-02f, -1.04515269e-01f, 7.83511475e-02f, 1.20836966e-01f, -6.94608465e-02f,
  4.26655672e-02f, 5.67997806e-02f, 1.35472849e-01f, 8.29237862e-04f, -1.56913847e-02f, 1.35821998e-01f, 1.29322454e-01f, 1.92251205e-01f, -4.94795516e-02f, -1.04685612e-01f,
  7.34796301e-02f, 3.02435290e-02f, 1.65267453e-01f, 3.71114649e-02f, 1.00272074e-01f, 1.07593268e-01f, -4.34856489e-02f, 5.59153408e-02f, -9.95056778e-02f, 8.04009736e-02f,
  2.37620994e-01f, -8.02261680e-02f, -1.80932999e-01f, 9.30751860e-02f, -3.26138735e-02f, -1.73631981e-01f, -1.33875206e-01f, 9.40747932e-02f, 3.18542570e-02f, 1.15843058e-01f,
  -1.63240805e-02f, -1.05704710e-01f, -1.40925303e-01f, 4.33780141e-02f, -4.90454026e-02f, -2.22781584e-01f, -7.08185211e-02f, 2.25406662e-01f, 1.92126587e-01f, 1.78826526e-01f,
  -3.99197787e-02f, -7.52004981e-02f, -6.10393658e-03f, -9.53253731e-02f, -1.19900852e-01f, 4.77101989e-02f, 8.91810879e-02f, 1.76438913e-01f, -9.59517807e-03f, 2.34582927e-02f,
  -1.86020836e-01f, -7.75727108e-02f, 7.79810846e-02f, 1.01257712e-01f, -8.12562034e-02f, 1.52425781e-01f, 1.11053102e-01f, -9.99732539e-02f, -6.10455722e-02f, 1.45057142e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 64)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -9.47366375e-03f, 1.17849059e-01f, -2.78886314e-02f, 1.02122746e-01f, -6.05939031e-02f, -3.72392163e-02f, -5.09498306e-02f, -6.78483769e-02f, -1.22115701e-01f, 2.49715913e-02f,
  -1.00607365e-01f, -1.01867884e-01f, -1.08799905e-01f, -1.66367590e-02f, 3.86865847e-02f, -1.20040953e-01f, -9.50244665e-02f, -7.70781636e-02f, -1.23871647e-01f, 1.20285884e-01f,
  3.23807970e-02f, 8.85617733e-03f, -1.02692604e-01f, 5.32608703e-02f, 7.79697392e-03f, -4.59493734e-02f, -7.82247726e-03f, -2.74934992e-02f, -8.96502212e-02f, 6.13069497e-02f,
  -9.07383487e-02f, -3.36841531e-02f, -6.18014112e-02f, -1.12194590e-01f, 1.08140469e-01f, 7.88651258e-02f, -9.50885564e-02f, -9.00595784e-02f, 4.27617207e-02f, 2.78611854e-02f,
  1.18913293e-01f, 6.56561926e-02f, -1.09829985e-01f, 4.45594639e-02f, -4.47957069e-02f, 1.14636764e-01f, -1.11573689e-01f, -6.56242743e-02f, 7.43543357e-02f, 4.49538454e-02f,
  -9.62284058e-02f, 3.12478766e-02f, -1.00955151e-01f, 2.78889830e-03f, -6.43864125e-02f, 8.39837044e-02f, -1.20597921e-01f, -1.33343292e-02f, 6.32361844e-02f, -1.10327572e-01f,
  5.40531278e-02f, 7.28398114e-02f, -1.23815812e-01f, -1.70886386e-02f, 9.00558978e-02f, 2.03600675e-02f, -4.69260812e-02f, 9.68894362e-03f, 1.82669312e-01f, 1.77203953e-01f,
  6.75189793e-02f, 1.93734720e-01f, -2.65023913e-02f, -1.43707357e-02f, -2.82781757e-02f, 6.58645183e-02f, 1.62083104e-01f, 5.62755726e-02f, -5.44582196e-02f, 5.42869791e-03f,
  1.32955924e-01f, 1.81614861e-01f, 8.87069444e-04f, 8.44440535e-02f, 3.25474106e-02f, 1.69372201e-01f, 1.58351168e-01f, -1.62933189e-02f, -2.31461778e-01f, 3.93009558e-02f,
  1.91268638e-01f, -3.95648107e-02f, 1.85553282e-01f, -2.36174930e-02f, 1.04572520e-01f, -1.85863405e-01f, -1.57342181e-02f, -1.44313529e-01f, -1.02970548e-01f, 1.50967255e-01f,
  1.09108478e-01f, -5.08914590e-02f, -3.81865017e-02f, 1.66142941e-01f, -1.47690192e-01f, -1.28757164e-01f, 6.18630536e-02f, -2.39689052e-01f, 1.09109573e-01f, -1.40078953e-02f,
  9.82604548e-02f, -1.26224056e-01f, -5.18770851e-02f, 1.02460198e-01f, -1.54322339e-02f, -1.28808379e-01f, 1.21447101e-01f, 6.84472844e-02f, 1.39377698e-01f, -9.93151814e-02f,
  -9.71744731e-02f, -4.97456454e-02f, -4.29129638e-02f, -1.30067840e-01f, 1.60085429e-02f, 6.39187172e-02f, 1.46086654e-02f, -1.54059872e-01f, -4.25229445e-02f, 2.18385831e-02f,
  8.95340443e-02f, 1.38658330e-01f, 4.20107186e-04f, 2.24994600e-01f, 4.50857310e-03f, 7.55935237e-02f, 1.90414310e-01f, 1.85028315e-01f, 9.88687053e-02f, 1.13491550e-01f,
  2.32217863e-01f, 4.63917665e-02f, -1.23810641e-01f, 6.59140870e-02f, -4.60705645e-02f, 1.59367695e-01f, 1.97626635e-01f, 6.47768378e-02f, 1.20861948e-01f, -2.58032642e-02f,
  1.54771015e-01f, -3.59331332e-02f, -1.66373625e-01f, 1.83074385e-01f, -4.76402156e-02f, -1.55611202e-01f, 3.34362946e-02f, 9.45113152e-02f, 1.79357827e-01f, -1.09921098e-01f,
  -9.27208588e-02f, -1.48403784e-02f, 1.81366384e-01f, 2.16613770e-01f, 1.55771747e-01f, 1.11651281e-02f, 9.70774293e-02f, 1.26901060e-01f, -9.27337557e-02f, -3.25181037e-02f,
  -3.24100778e-02f, -2.48495594e-01f, 1.20954938e-01f, 1.91238433e-01f, 1.46131609e-02f, -7.90047348e-02f, -4.40970473e-02f, 3.55959125e-02f, 2.91844010e-02f, -4.32698093e-02f,
  -1.18286557e-01f, -1.27378300e-01f, 1.07792616e-01f, 1.10129014e-01f, -1.30940795e-01f, 7.95412883e-02f, -1.60705112e-02f, -1.36848465e-01f, -1.00464307e-01f, 1.23164244e-02f,
  6.99030235e-02f, -1.56612471e-01f, 7.80213997e-02f, 4.35384884e-02f, -6.21739887e-02f, 9.58746001e-02f, 4.25480790e-02f, 8.82571638e-02f, -2.07083017e-01f, 1.48978252e-02f,
  7.91926980e-02f, 5.95689528e-02f, -8.76127407e-02f, 1.77353740e-01f, 1.97511435e-01f, -3.03618927e-02f, 7.40659609e-02f, 6.24476746e-02f, 3.03257559e-03f, -5.75808212e-02f,
  1.56898767e-01f, -2.45912261e-02f, -6.27098326e-03f, 1.58157393e-01f, 1.59530416e-01f, 9.22621936e-02f, -1.59969240e-01f, -2.06858471e-01f, 2.81508803e-01f, 9.63991433e-02f,
  -9.59023535e-02f, 8.97707716e-02f, -3.33289146e-01f, -2.71398723e-01f, 3.32921356e-01f, -7.38128787e-03f, -2.97836870e-01f, -6.78424984e-02f, 1.22857556e-01f, 3.46626006e-02f,
  2.31383890e-02f, 4.63684537e-02f, -3.18675190e-01f, -2.34703049e-01f, 1.68301985e-01f, -8.03711042e-02f, -5.26818149e-02f, -3.33051309e-02f, -1.52310386e-01f, 8.33875015e-02f,
  1.78398117e-02f, 2.27197781e-01f, -3.43638449e-03f, -9.66344923e-02f, -3.79525796e-02f, 1.70791075e-01f, 7.17918351e-02f, -1.24882691e-01f, -8.42371956e-02f, -6.25936165e-02f,
  3.03808481e-01f, 2.62033343e-01f, 8.71789008e-02f, 1.21048689e-02f, 1.18689731e-01f, -2.08519632e-03f, 1.01760291e-01f, 1.21233396e-01f, 1.52273536e-01f, 1.10397793e-01f,
  -3.55814174e-02f, 1.31541342e-01f, 1.49060845e-01f, 1.34043898e-02f, 1.07284360e-01f, 1.76441848e-01f, 9.89287067e-03f, 1.71453103e-01f, -8.30364227e-02f, 1.64565574e-02f,
  1.60214126e-01f, 1.72712341e-01f, 1.38536602e-01f, 1.16622515e-01f, 1.02096647e-01f, 6.49020821e-02f, -5.03054969e-02f, 4.68941554e-02f, 3.77822518e-02f, 2.72342712e-02f,
  1.28018230e-01f, -8.15111771e-02f, 6.02641962e-02f, 3.75581123e-02f, -1.47249326e-01f, -9.31939632e-02f, -6.96176440e-02f, 1.57740898e-03f, -1.45208284e-01f, 7.31698498e-02f,
  9.93058756e-02f, 6.14722781e-02f, -1.81041226e-01f, 1.11171462e-01f, 7.66092539e-02f, -1.91409327e-02f, -4.08232883e-02f, 1.89489678e-01f, 5.97824790e-02f, -1.12066567e-02f,
  -3.14479228e-03f, -2.63174716e-02f, 1.35180593e-01f, 1.11122973e-01f, -7.55807981e-02f, 1.08504564e-01f, 5.21964394e-02f, 4.93609942e-02f, 1.23111308e-01f, 5.48314825e-02f,
  -1.14904568e-02f, 1.01984978e-01f, -2.87708994e-02f, -7.22653419e-02f, -6.57263845e-02f, 3.11874710e-02f, 1.04452051e-01f, -1.49822682e-01f, -1.39885023e-01f, 1.97176248e-01f,
  8.94065052e-02f, -6.34195805e-02f, -1.27350015e-03f, -4.56952043e-02f, 8.94221067e-02f, -2.10174415e-02f, 1.90180577e-02f, 6.40220568e-02f, 7.43121952e-02f, -1.35954795e-02f,
  -7.67260268e-02f, -2.57639475e-02f, 1.08735204e-01f, -8.68686363e-02f, 7.00783134e-02f, -8.93347636e-02f, 7.19798580e-02f, 8.26946795e-02f, -3.06650670e-03f, -1.08509436e-01f,
  1.21868886e-01f, 8.57154429e-02f, 1.06120571e-01f, 3.73164341e-02f, -1.51945099e-01f, 1.03551298e-01f, -3.87678742e-02f, -1.35585800e-01f, 1.28490925e-01f, -2.99104862e-02f,
  -2.06389241e-02f, 1.53844813e-02f, 1.06549121e-01f, 4.37126011e-02f, 3.15627945e-03f, -2.71756132e-03f, 7.50772953e-02f, -2.39127651e-02f, -1.43730460e-04f, 1.45394087e-01f,
  9.56202969e-02f, -4.23961952e-02f, -5.43692522e-02f, -1.44945636e-01f, 1.29018098e-01f, 1.09136306e-01f, -1.27832085e-01f, 8.73740986e-02f, -1.03865430e-01f, 6.39834553e-02f,
  9.79318023e-02f, -2.91926134e-02f, -7.91810527e-02f, 6.78978488e-02f, -2.53464393e-02f, -5.06567582e-02f, 1.32631985e-02f, 4.65001464e-02f, 1.20794280e-02f, -1.07487142e-01f,
  -7.29641244e-02f, -5.80320694e-02f, 1.33916408e-01f, -5.56397401e-02f, 9.87738371e-02f, 2.21542772e-02f, -2.59729847e-02f, 5.60540669e-02f, -8.64267647e-02f, -8.22883546e-02f,
  -3.50050591e-02f, 9.11830962e-02f, 6.90323114e-03f, -3.26929763e-02f, 1.00327179e-01f, 7.70224854e-02f, -8.10303017e-02f, -8.04261789e-02f, -1.09158680e-01f, -8.49263594e-02f,
  1.23880506e-01f, -7.00259488e-03f, 1.01650424e-01f, -1.01876624e-01f, -3.32870744e-02f, -9.26149786e-02f, -1.94455236e-02f, -9.01680961e-02f, -3.07785552e-02f, 9.46153700e-02f,
  3.83049771e-02f, -5.81855625e-02f, -1.08806528e-01f, -1.09049894e-01f, -8.37932006e-02f, -8.20862874e-03f, 7.07694441e-02f, -8.52177367e-02f, -4.01914530e-02f, -6.80354461e-02f,
  -5.55438688e-03f, -8.56012404e-02f, 9.41785648e-02f, 1.72654111e-02f, 3.09639778e-02f, -4.71230261e-02f, 6.26389831e-02f, -5.07411547e-02f, 8.11747015e-02f, 9.46975797e-02f,
  -7.20746443e-02f, 6.78693280e-02f, -5.90046719e-02f, -9.19218957e-02f, -1.07189782e-01f, 3.85443196e-02f, -9.99595821e-02f, 8.06853697e-02f, 1.34732509e-02f, 8.59277323e-02f,
  6.71309754e-02f, -9.15361866e-02f, -7.87739530e-02f, -2.43912973e-02f, -1.10805277e-02f, -1.27537148e-02f, 3.02241482e-02f, -8.48785788e-02f, 3.18704988e-03f, 9.91628021e-02f,
  -4.39102165e-02f, 1.30706444e-01f, -2.66339555e-02f, -4.25345711e-02f, 2.44234294e-01f, -5.86698987e-02f, 9.58781093e-02f, 1.01960190e-01f, -4.25823871e-03f, -1.13012724e-01f,
  6.55326694e-02f, -1.68836191e-01f, -7.87338391e-02f, 5.40419063e-03f, 1.29775032e-02f, -6.09367602e-02f, 1.51077006e-03f, -5.81934713e-02f, 1.09889008e-01f, -1.16856378e-02f,
  3.72188985e-02f, 1.56211078e-01f, 2.41386726e-01f, 1.56438693e-01f, -2.88754374e-01f, 2.63942108e-02f, -6.43009096e-02f, -1.15019329e-01f, 1.38860613e-01f, 9.93597880e-02f,
  -2.37963274e-01f, 2.48128176e-01f, 1.74235687e-01f, 5.89498430e-02f, 3.79807353e-02f, 8.01292807e-02f, 7.06710294e-02f, -1.10296719e-01f, 1.29095495e-01f, 5.25998212e-02f,
  -9.81829464e-02f, -2.22627702e-03f, 2.38711655e-01f, 4.17087460e-03f, 3.93241569e-02f, 1.36128649e-01f, -1.09841086e-01f, -3.33695948e-01f, 7.31175626e-03f, 2.61928380e-01f,
  2.35710777e-02f, -1.30374342e-01f, 2.23896533e-01f, 1.21617153e-01f, 4.87246364e-02f, 7.36732781e-02f, 1.77738681e-01f, 2.50473619e-01f, 7.01569691e-02f, 1.38476118e-01f,
  6.48461580e-02f, -3.76212634e-02f, -7.43080899e-02f, 1.43091649e-01f, 1.06359534e-01f, -1.19843530e-02f, 2.05568165e-01f, 1.07346371e-01f, 9.44012851e-02f, 1.08848348e-01f,
  1.54164925e-01f, 1.88635215e-01f, 1.29144758e-01f, -3.10442573e-03f, -2.13889536e-02f, -1.07569642e-01f, -1.39787808e-01f, -6.50666580e-02f, 1.19065888e-01f, -2.96940189e-03f,
  1.67735010e-01f, 1.40266240e-01f, 2.06435755e-01f, -8.02649558e-02f, 8.72886106e-02f, 2.58553997e-02f, -2.30621044e-02f, 3.32105309e-01f, 9.30371806e-02f, 1.60541236e-01f,
  2.95878164e-02f, 2.10899621e-01f, 2.89153993e-01f, 3.49628553e-02f, -8.33947062e-02f, -1.06540089e-02f, 7.25256130e-02f, 2.50257999e-01f, 1.37100235e-01f, 1.59341544e-01f,
  2.63206035e-01f, -4.04808521e-02f, 1.58856198e-01f, 2.29063466e-01f, -2.10978001e-01f, -3.95962775e-01f, 1.23825729e-01f, 1.77112341e-01f, 2.50847578e-01f, 2.52199352e-01f,
  -5.71096912e-02f, -4.79953773e-02f, -6.01032339e-02f, 7.50943720e-02f, -7.08323866e-02f, -9.13454592e-03f, 1.43761516e-01f, -9.73501150e-03f, 6.86563551e-02f, 8.98082033e-02f,
  1.82722464e-01f, 3.13557506e-01f, -2.52617057e-03f, 1.78254738e-01f, -8.37074872e-03f, 9.97871440e-03f, 6.62462860e-02f, 1.97308630e-01f, 2.17309073e-01f, 1.39738888e-01f,
  4.75419909e-02f, 2.10094675e-02f, 9.06946808e-02f, 1.46434277e-01f, 7.67196566e-02f, 1.32626161e-01f, 1.69108629e-01f, 2.44547650e-01f, 5.75603507e-02f, 2.03514367e-01f,
  1.02713667e-01f, 2.20974088e-01f, -8.93975981e-03f, -6.61097001e-03f, 1.79931019e-02f, 1.39886454e-01f, -1.40321432e-02f, 6.21520989e-02f, 5.76697886e-02f, 3.68043855e-02f,
  4.60207388e-02f, -2.48626977e-01f, -2.00888924e-02f, -1.15207717e-01f, -8.41905549e-02f, -1.03654973e-01f, -3.70667189e-01f, -1.74483612e-01f, 1.78296909e-01f, 6.72559217e-02f,
  -1.50304928e-01f, -8.80861133e-02f, -1.18429139e-01f, 1.54343508e-02f, -7.85015896e-02f, -1.31327361e-01f, -7.21861795e-02f, -1.51518688e-01f, 3.34917158e-01f, 5.81994131e-02f,
  6.57070205e-02f, 1.35867372e-02f, -1.33529827e-01f, -5.60532995e-02f, 1.42832752e-03f, 2.27875680e-01f, -1.69924665e-02f, -1.38058856e-01f, 9.76679940e-03f, 2.43359745e-01f,
  -8.36398751e-02f, 6.60214201e-02f, 3.07364501e-02f, 2.71730572e-02f, 1.97742552e-01f, 1.31457910e-01f, 2.50583112e-01f, 3.31535563e-02f, 8.14011544e-02f, 1.33280963e-01f,
  1.41376585e-01f, 3.14768478e-02f, 3.59305777e-02f, -5.22555895e-02f, 6.87667429e-02f, -7.26421773e-02f, 6.47215396e-02f, 1.29050463e-01f, 1.62691996e-01f, -4.43556271e-02f,
  3.34858149e-02f, 2.29130406e-02f, -6.44773711e-03f, 7.73307309e-02f, 7.19113322e-03f, 7.97021389e-02f, -5.41931130e-02f, -6.65306300e-02f, 1.50621340e-01f, 6.45328611e-02f,
  6.42304346e-02f, -7.18628317e-02f, 1.65496752e-01f, 1.86430141e-02f, 2.30667386e-02f, 1.01687789e-01f, 5.42648621e-02f, 1.12885848e-01f, -2.20283404e-01f, 6.41054334e-03f,
  -1.42614499e-01f, -2.93525420e-02f, -1.64447740e-01f, 1.44663602e-01f, -1.04580939e-01f, 5.59108704e-02f, -3.55115347e-02f, 5.32398149e-02f, -3.23821381e-02f, 1.25004473e-04f,
  -5.62841166e-03f, 4.43853773e-02f, -6.40412346e-02f, 7.97415450e-02f, -4.17147316e-02f, 9.25438330e-02f, 1.54206157e-01f, 7.90178627e-02f, -2.15329304e-01f, -8.51420909e-02f,
  1.02473840e-01f, 4.34860513e-02f, 9.61583927e-02f, 1.12179577e-01f, 4.83746789e-02f, -4.69929725e-02f, -6.42432049e-02f, -5.60289137e-02f, 1.25511274e-01f, 2.57834703e-01f,
  1.72299400e-01f, 5.02102636e-02f, -2.62367614e-02f, 1.42447084e-01f, -4.74489629e-02f, -1.25391325e-02f, -3.07493676e-02f, 8.40732306e-02f, -5.58653884e-02f, 4.22815271e-02f,
  -7.47870207e-02f, 6.17253371e-02f, -2.55778665e-03f, 5.16783074e-02f, -6.92929327e-02f, 1.15926340e-01f, 1.51323318e-01f, -3.25560570e-02f, -1.21037558e-01f, -1.24800177e-02f,
  -9.85943303e-02f, -5.21346331e-02f, -4.76310737e-02f, -8.27044770e-02f, 1.01851001e-01f, 1.23731107e-01f, 4.73272055e-02f, 3.03686201e-03f, 8.97758007e-02f, -7.59977940e-03f,
  -9.49811414e-02f, -1.35038327e-02f, 1.19742185e-01f, 1.51944995e-01f, 9.61463749e-02f, -9.91634429e-02f, 1.23504689e-02f, -6.94048032e-02f, -1.73866730e-02f, 1.17478274e-01f,
  9.13509503e-02f, 4.82406840e-02f, -1.57263335e-02f, 1.67675633e-02f, 1.06413230e-01f, -8.77197534e-02f, 2.71850750e-02f, 7.65150320e-03f, 8.20967704e-02f, 1.58228520e-02f,
  7.11954311e-02f, 2.27387249e-02f, 8.96769837e-02f, -1.08931355e-01f, 2.92731188e-02f, -3.38230059e-02f, -6.95711235e-03f, -7.94696584e-02f, -3.11184954e-02f, 7.15496168e-02f,
  -6.49447441e-02f, 9.69395936e-02f, -8.30995850e-03f, 1.55831054e-01f, -5.72674833e-02f, 1.36777908e-01f, -3.17953564e-02f, 1.82174221e-02f, 4.73181792e-02f, -1.17722392e-01f,
  9.69952047e-02f, -3.34610157e-02f, 4.12057973e-02f, -8.84768963e-02f, 8.62860531e-02f, -1.15760759e-01f, 5.28716482e-02f, -9.89959016e-03f, -1.17177308e-01f, -4.13334370e-02f,
  3.39205028e-03f, 1.17527656e-01f, -2.10813358e-02f, 1.09973982e-01f, -3.37255374e-02f, 3.41986418e-02f, -1.08050428e-01f, -6.02159090e-02f, -6.63383976e-02f, -1.70763228e-02f,
  9.33787227e-03f, 5.53036630e-02f, 3.37718539e-02f, -4.27882560e-02f, -1.24011971e-01f, 9.69316140e-02f, 1.01855040e-01f, 7.85134360e-02f, 1.21652424e-01f, 9.26645398e-02f,
  -5.77301681e-02f, 1.18350508e-02f, 5.73164672e-02f, 1.20802015e-01f, 1.39927231e-02f, -3.84032130e-02f, -6.88753426e-02f, 2.34153424e-03f, 4.05484019e-03f, 7.79379830e-02f,
  -1.04830265e-01f, -8.02980810e-02f, 3.31017748e-02f, -1.99099891e-02f, -1.21202255e-02f, 2.78851092e-02f, 1.13471292e-01f, -6.39648065e-02f, 1.01001173e-01f, 5.42808920e-02f,
  -1.20511852e-01f, -1.11799501e-01f, -4.52117361e-02f, 2.21590716e-02f, -1.03927441e-01f, 9.46093425e-02f, 7.87039921e-02f, 1.00534605e-02f, 1.85248721e-02f, 5.65243140e-02f,
  7.62735978e-02f, -6.37641028e-02f, 7.72448778e-02f, 1.30482018e-02f, 4.73243631e-02f, -5.95324747e-02f, 1.83725711e-02f, 5.94770387e-02f, 7.39920884e-02f, 6.32269606e-02f,
  1.30385786e-01f, 7.56897852e-02f, 1.09771453e-01f, -1.87583491e-02f, -7.64247850e-02f, -6.32589236e-02f, 1.40103146e-01f, 6.82432875e-02f, 2.00605635e-02f, 1.25776157e-01f,
  1.52521044e-01f, 4.66302373e-02f, 1.20316625e-01f, 3.64926318e-03f, -2.40642019e-02f, -1.10507935e-01f, 1.25064880e-01f, 2.48894528e-01f, -3.28950919e-02f, 2.35537097e-01f,
  -1.59510598e-01f, 2.74719805e-01f, -9.35300812e-02f, -6.01133611e-03f, -1.97033547e-02f, 8.08672309e-02f, -3.69231254e-02f, 2.81020105e-02f, 1.89978316e-01f, 1.76642582e-01f,
  1.81097135e-01f, 2.97003221e-02f, -7.75051564e-02f, 1.39408648e-01f, 5.89361414e-02f, -1.77154377e-01f, -6.17559999e-02f, -8.63781720e-02f, 1.32964691e-02f, 1.23494633e-01f,
  -6.70869276e-02f, -9.01784077e-02f, 1.49874046e-01f, 2.37995118e-01f, 4.59048972e-02f, 1.22602984e-01f, 2.70201385e-01f, 7.04163164e-02f, 1.16472863e-01f, 5.15470281e-02f,
  3.50303233e-01f, 4.60309774e-01f, 6.34177327e-02f, 1.00948125e-01f, 1.74631272e-02f, 6.67294413e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  5.14789075e-02f, 1.58096835e-01f, -7.09053688e-03f, 1.19009882e-01f, 2.73739081e-02f, -4.45598289e-02f, -4.08139303e-02f, 1.24747597e-01f, 1.28468648e-01f, 1.12415083e-01f,
  1.15170754e-01f, 1.41074389e-01f, -5.36576845e-02f, 1.04734808e-01f
};

// L3_fan_Wp (Shape: 25 x 64)
const int L3_fan_Wp_rows = 25;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  -5.08972630e-02f, -3.97176594e-02f, 4.99373712e-02f, 4.46035527e-02f, -1.20564520e-01f, 8.33204910e-02f, -2.94124708e-02f, 1.14142895e-01f, -1.36390984e-01f, 2.44289991e-02f,
  -2.01063715e-02f, 5.00677910e-04f, 5.06034009e-02f, 3.32681425e-02f, -6.54611960e-02f, 1.79162975e-02f, 4.15177271e-02f, -1.59184739e-01f, -9.07466933e-02f, 9.72672552e-02f,
  -5.39477589e-03f, -1.23826563e-01f, -1.45030707e-01f, -1.05069526e-01f, -1.24821052e-01f, 4.55981381e-02f, -7.76069835e-02f, -1.89471349e-01f, 1.41962707e-01f, 1.14015304e-02f,
  4.22048792e-02f, -6.59038201e-02f, 6.13203868e-02f, -4.11665961e-02f, -1.30114689e-01f, -5.11695556e-02f, -8.22488815e-02f, 1.74938720e-02f, 8.24295580e-02f, 1.07877553e-01f,
  -3.33266817e-02f, 1.37962326e-01f, 3.14629376e-02f, 7.31945187e-02f, -1.77719802e-01f, 6.00321442e-02f, 5.76543882e-02f, -1.57788619e-01f, 7.02051818e-02f, 1.51285961e-01f,
  1.12543121e-01f, -8.13135952e-02f, -1.83713203e-03f, -8.44311640e-02f, 4.92475815e-02f, -1.47327885e-01f, -9.80975404e-02f, 1.11603878e-01f, 2.30101347e-01f, -4.80674803e-02f,
  1.31425023e-01f, -1.34335876e-01f, 7.12893903e-02f, -7.67605007e-02f, -6.55998811e-02f, -1.32239416e-01f, -2.59563327e-02f, 2.38505989e-01f, 6.44850805e-02f, 7.21687078e-02f,
  -3.57457902e-03f, 4.97240759e-02f, -9.51041356e-02f, -7.55883455e-02f, 6.95043206e-02f, -8.99292901e-02f, 2.97452044e-02f, -2.15233322e-02f, 1.81476355e-01f, -1.81285366e-01f,
  -8.69028196e-02f, 1.53713793e-01f, 7.12269247e-02f, -6.13698252e-02f, 1.24423288e-01f, 7.91633502e-02f, 1.71264201e-01f, 7.81008825e-02f, 1.31317735e-01f, 9.99620259e-02f,
  -8.87438804e-02f, -3.56162526e-02f, -5.60246930e-02f, -7.31893852e-02f, -3.42092924e-02f, -1.87241852e-01f, -9.43603218e-02f, 9.96223539e-02f, 1.73221424e-01f, 1.08559281e-01f,
  -4.98640770e-03f, 6.32535815e-02f, -4.41174991e-02f, -1.70330167e-01f, -9.62563679e-02f, -6.04042560e-02f, -5.61798550e-02f, 1.31551996e-01f, -1.35527119e-01f, 4.18478735e-02f,
  1.13527991e-01f, -1.70953516e-02f, 4.78819162e-02f, -1.97416142e-01f, 4.15688567e-02f, 2.46100843e-01f, 2.08280742e-01f, -2.05303412e-02f, -1.33061647e-01f, 1.28413484e-01f,
  1.02361754e-01f, -6.47125468e-02f, -2.03161255e-01f, 1.08083580e-02f, -1.71121851e-01f, -3.48698162e-02f, -6.90204352e-02f, -2.17420354e-01f, -6.94593489e-02f, 8.65453854e-03f,
  -1.40799269e-01f, -6.86784834e-02f, -1.32504180e-01f, -1.75111800e-01f, -4.26883623e-02f, -2.16606706e-01f, -1.32632256e-01f, 9.03622806e-02f, 1.01664104e-01f, 1.39542529e-02f,
  -1.63233608e-01f, -1.34270862e-01f, 1.10105425e-01f, -9.80600417e-02f, 5.44508584e-02f, -2.40239158e-01f, -1.22672878e-01f, -1.68478489e-01f, -1.85647428e-01f, 1.11091085e-01f,
  -2.17404980e-02f, -3.60123403e-02f, 1.64973602e-01f, -7.90535063e-02f, 1.45883381e-01f, 2.35227123e-02f, -3.64396609e-02f, -1.44876197e-01f, 9.89733171e-03f, 5.24146743e-02f,
  2.41913676e-01f, -1.39556658e-02f, 4.02639993e-03f, 1.01589039e-01f, 7.60929435e-02f, 1.73428565e-01f, -4.06739600e-02f, -9.70707685e-02f, 7.19706789e-02f, -2.03579783e-01f,
  2.04087105e-02f, 3.50000709e-02f, 7.16659427e-02f, -1.53871283e-01f, -4.54522073e-02f, -1.87102765e-01f, 7.88909122e-02f, -6.67217150e-02f, 1.16052352e-01f, 5.00586592e-02f,
  1.73302829e-01f, -1.11716419e-01f, -7.06824660e-02f, 6.72135353e-02f, -3.67069170e-02f, 8.02279115e-02f, -2.68729758e-02f, -3.08523744e-01f, -1.24816798e-01f, 2.38727350e-02f,
  3.29477224e-03f, 1.37161493e-01f, -2.81485729e-02f, 1.63841452e-02f, 4.53455895e-02f, 6.07599951e-02f, -4.67813089e-02f, 3.00772060e-02f, 1.79808643e-02f, -1.03684152e-02f,
  -7.49897733e-02f, 1.27968211e-02f, -1.36269763e-01f, -6.28126562e-02f, 3.86815779e-02f, 7.60491043e-02f, 7.52021670e-02f, 1.30622163e-01f, -1.10215642e-01f, -7.85061643e-02f,
  9.55073759e-02f, -5.61359785e-02f, 5.75825050e-02f, 5.05636111e-02f, -2.46818047e-02f, 1.13503650e-01f, 8.44981670e-02f, -8.84092525e-02f, 8.33058953e-02f, -1.16890371e-02f,
  7.43249282e-02f, 1.79913372e-03f, -2.16320343e-02f, 1.47456393e-01f, -1.62518010e-01f, -1.32572427e-01f, -4.91189249e-02f, -1.55109465e-01f, -1.20378271e-01f, -1.50858417e-01f,
  3.20758000e-02f, 1.25743315e-01f, 8.54128078e-02f, 1.29957916e-02f, -1.19088948e-01f, -1.95307925e-01f, 1.51318252e-01f, -8.16057175e-02f, 7.24108471e-03f, -2.21994948e-02f,
  -1.89842507e-02f, -8.01728219e-02f, 9.59855616e-02f, 7.93871433e-02f, -1.32449493e-01f, 2.25870401e-01f, -1.82399571e-01f, 2.99448688e-02f, 4.57726531e-02f, 3.54666002e-02f,
  -1.89367130e-01f, 1.80698514e-01f, 9.67318192e-02f, 1.15357205e-01f, 1.68369729e-02f, 1.32572532e-01f, -1.23435810e-01f, 1.15980268e-01f, -4.04807553e-02f, -4.19901982e-02f,
  -1.41300589e-01f, 4.43731956e-02f, -3.97407450e-03f, 1.34497687e-01f, 6.36522099e-02f, -6.99941218e-02f, -1.56745702e-01f, -1.09866753e-01f, -9.34384856e-03f, 7.54399449e-02f,
  -3.01611479e-02f, 7.27954656e-02f, -1.33675128e-01f, 1.08721092e-01f, 9.14082304e-03f, 1.55468464e-01f, -1.09390225e-02f, -6.36556819e-02f, -1.04524463e-01f, -9.83264018e-03f,
  -9.75096151e-02f, 1.43545583e-01f, 9.55903679e-02f, -2.27882609e-01f, 8.52133930e-02f, 1.83933914e-01f, 5.46917431e-02f, 7.03619421e-02f, 4.84737977e-02f, -1.29837722e-01f,
  2.65600029e-02f, -9.59010944e-02f, 2.00478248e-02f, -1.31590161e-02f, -1.14566371e-01f, 1.72745749e-01f, -2.23743506e-02f, 7.66047090e-02f, 1.26676708e-01f, 1.42810810e-02f,
  -2.38064259e-01f, 1.67269886e-01f, -1.58422105e-02f, -3.81048582e-02f, -1.45499483e-01f, 2.57984474e-02f, -3.94578204e-02f, -1.20150715e-01f, 4.76467647e-02f, 2.03319415e-02f,
  1.66838497e-01f, -2.99203601e-02f, -7.59508088e-02f, -5.07973991e-02f, 7.92890228e-03f, 4.52086516e-03f, -1.13787711e-01f, -2.88029071e-02f, -4.12832089e-02f, -1.15669670e-03f,
  -3.29807885e-02f, -3.89192402e-02f, 1.21258095e-01f, 5.83881252e-02f, 7.14643523e-02f, -1.12882890e-01f, 1.39964759e-01f, 7.99385458e-02f, 7.87325799e-02f, -1.07412249e-01f,
  2.09708124e-01f, 1.45953596e-01f, 8.60615522e-02f, 4.05530408e-02f, 1.47826090e-01f, -1.66328624e-01f, -1.17863506e-01f, -2.66932808e-02f, 6.00644834e-02f, 7.19756633e-02f,
  2.28269200e-04f, 8.44515935e-02f, 1.05090529e-01f, -5.74314035e-02f, 1.26379073e-01f, -8.85032564e-02f, -9.71114710e-02f, 1.64406151e-01f, -2.06535071e-01f, 8.24958608e-02f,
  8.47680420e-02f, 9.59455129e-03f, -1.09866142e-01f, -1.69432059e-01f, 1.38079166e-01f, -4.33730241e-03f, -4.76535447e-02f, -1.78808361e-01f, 7.97361434e-02f, -1.79011375e-01f,
  -2.20206082e-01f, 1.19894072e-01f, 1.31841768e-02f, 4.47973348e-02f, -9.88833234e-02f, -5.13668880e-02f, -1.55803576e-01f, 1.09943956e-01f, -1.15823811e-02f, 8.82342234e-02f,
  -4.78761606e-02f, 9.58789438e-02f, 1.76557377e-01f, 1.99798033e-01f, -2.78001577e-02f, -5.52993687e-03f, 8.56531784e-02f, -2.32873112e-01f, -1.67706415e-01f, 1.80226609e-01f,
  -3.86525393e-02f, -5.00846393e-02f, -7.83450082e-02f, 8.11680313e-03f, 8.26948360e-02f, -1.10169962e-01f, 2.37851329e-02f, -9.37353224e-02f, -1.19905569e-01f, -1.19267687e-01f,
  -1.34878131e-02f, -8.41714367e-02f, -8.23293328e-02f, 4.25169915e-02f, -6.97482668e-04f, 2.60244533e-02f, 1.42116785e-01f, -5.55347698e-03f, 4.63472717e-02f, 1.66357160e-01f,
  1.73946917e-01f, -6.06617518e-03f, -3.28441672e-02f, 8.85866433e-02f, 3.20369340e-02f, 9.39596668e-02f, -8.34897459e-02f, -8.95551220e-02f, 1.45413458e-01f, -6.82847425e-02f,
  3.09215859e-02f, 2.05018044e-01f, 1.28486827e-02f, -7.12105259e-02f, -2.86002215e-02f, -1.08132087e-01f, 1.48594931e-01f, 4.22259867e-02f, 1.81643486e-01f, -4.22954634e-02f,
  -4.92035300e-02f, 3.73063609e-02f, -3.60002276e-03f, -6.99142143e-02f, -8.32441449e-03f, -1.81984216e-01f, -1.08289480e-01f, 7.60830417e-02f, -1.67587578e-01f, -1.75770670e-01f,
  2.92143878e-03f, -1.85277581e-01f, 1.66731611e-01f, -1.66333362e-01f, 1.03153691e-01f, -2.69833282e-02f, 1.23164885e-01f, 1.07408941e-01f, 7.85291195e-02f, 1.03844896e-01f,
  1.22610427e-01f, -7.45768845e-02f, 2.81152189e-01f, -7.32248351e-02f, -6.54542968e-02f, 1.04279540e-01f, 5.83645739e-02f, -2.25753966e-03f, 4.14038450e-02f, 7.13175982e-02f,
  -2.50691511e-02f, 1.33262016e-02f, -1.00026689e-01f, -3.59683074e-02f, -2.32927445e-02f, -1.24821588e-01f, -1.46693334e-01f, -4.18050624e-02f, -2.58118827e-02f, -1.51535168e-01f,
  -3.18722650e-02f, -9.25256014e-02f, -6.16972595e-02f, 6.41122600e-03f, 1.21390581e-01f, 2.99583171e-02f, -1.04925767e-01f, -3.01092863e-02f, 4.49400172e-02f, 1.15458459e-01f,
  6.16472885e-02f, -1.00037910e-01f, -5.19532710e-02f, -8.31785798e-02f, -3.16707976e-03f, -4.34796549e-02f, 2.06424251e-01f, 9.49217193e-03f, 8.19822550e-02f, 6.70733601e-02f,
  1.27071470e-01f, 1.68278754e-01f, -2.71074355e-01f, -2.18927056e-01f, 3.23509946e-02f, 1.53278820e-02f, 6.93461671e-02f, 1.17047042e-01f, 2.92507917e-01f, -3.76740769e-02f,
  -8.55766907e-02f, 2.62184534e-02f, 2.11946175e-01f, 2.46066879e-02f, 5.63021377e-02f, 8.05125833e-02f, 3.95628773e-02f, -8.87720585e-02f, 1.10466070e-01f, -1.85857058e-01f,
  -1.40475139e-01f, -2.24733621e-01f, -1.47602320e-01f, 5.65863177e-02f, -1.07426479e-01f, 2.57579118e-01f, 1.13611892e-02f, -1.06499083e-01f, 1.13273501e-01f, 3.21512893e-02f,
  -3.91146019e-02f, 2.19466060e-01f, 1.71097834e-02f, 5.72515354e-02f, 9.32601318e-02f, -1.71454161e-01f, 8.83245319e-02f, -1.71119899e-01f, -7.69189373e-02f, -8.13325308e-03f,
  -2.38002725e-02f, -6.06940985e-02f, 1.20330499e-02f, -1.25771224e-01f, 1.23757288e-01f, 3.21617275e-02f, 7.44496211e-02f, 7.97686949e-02f, -3.36147361e-02f, -3.99223194e-02f,
  5.93886636e-02f, 5.41275777e-02f, 6.69485852e-02f, 5.10554649e-02f, -1.64741650e-01f, 1.03600789e-02f, -5.06466180e-02f, -1.00209288e-01f, 1.64950490e-01f, 1.25526100e-01f,
  -1.06264260e-02f, 7.51349851e-02f, -3.08146570e-02f, 4.76280712e-02f, 1.53653428e-01f, -2.03699581e-02f, 1.55333262e-02f, -7.41146579e-02f, 3.17619968e-04f, 3.09874187e-03f,
  -7.31580183e-02f, 1.17176529e-02f, 6.47734404e-02f, -1.02447607e-01f, 5.44298626e-02f, -1.61230966e-01f, -9.63888317e-02f, 6.21980838e-02f, -1.17851496e-01f, -4.69261482e-02f,
  -9.48886871e-02f, 1.32995874e-01f, -4.15837094e-02f, -6.04154430e-02f, -1.11308150e-01f, 1.31751165e-01f, -8.80652815e-02f, -4.59587649e-02f, -4.05868934e-03f, -1.29720017e-01f,
  5.79533428e-02f, 6.17216825e-02f, 4.46932912e-02f, 7.59195164e-02f, 7.16905855e-03f, 9.04358700e-02f, -3.99536304e-02f, -4.17468064e-02f, -5.74058332e-02f, 3.95907536e-02f,
  9.43993852e-02f, 1.34089440e-01f, -9.74447653e-02f, 2.66178939e-02f, -1.09512404e-01f, 1.11771628e-01f, -1.33598164e-01f, -1.97444465e-02f, -7.59276897e-02f, -5.10165244e-02f,
  6.39096797e-02f, -7.07160356e-03f, 4.24041748e-02f, -6.42592832e-02f, 5.83355874e-02f, -2.67766472e-02f, 1.20201930e-01f, 8.91730487e-02f, -6.00983612e-02f, 7.91023020e-03f,
  -1.86562017e-01f, 1.15443051e-01f, -6.11362383e-02f, -1.40078887e-01f, -3.77380929e-05f, 1.74950242e-01f, -1.09437443e-01f, 1.30812928e-01f, -5.05271927e-03f, 1.66934416e-01f,
  -2.20707342e-01f, 9.75804701e-02f, -1.04710251e-01f, 1.42714912e-02f, -1.29616648e-01f, -3.45887593e-03f, 1.39208809e-01f, 1.80080891e-01f, 1.02185428e-01f, -3.35528255e-02f,
  -7.75928125e-02f, -7.63388723e-02f, 1.27647206e-01f, -6.08617859e-03f, -9.66896042e-02f, 1.64684236e-01f, 6.59740567e-02f, -2.06736565e-01f, -2.42165416e-01f, -2.33176410e-01f,
  3.33649404e-02f, -9.38099772e-02f, 9.61843506e-02f, 7.47485682e-02f, -1.35839552e-01f, 5.04387580e-02f, 9.26314294e-02f, -5.97417578e-02f, 4.07541469e-02f, 4.75536138e-02f,
  3.61874467e-03f, 1.40796406e-02f, -5.98423742e-03f, 4.43494581e-02f, -6.44899905e-02f, -1.09587843e-02f, -1.56716611e-02f, 1.34319380e-01f, 9.99242216e-02f, 1.37804057e-02f,
  8.02611932e-02f, 1.17899619e-01f, 2.97573227e-02f, -7.02009052e-02f, 1.90844849e-01f, -1.17370203e-01f, 3.34761441e-02f, 1.58054546e-01f, 3.39930877e-02f, 1.28605776e-02f,
  1.55082196e-01f, -1.00407168e-01f, 2.97382269e-02f, 2.63994709e-02f, 9.01758671e-02f, 1.12840332e-01f, -6.83778971e-02f, 2.64685731e-02f, -2.78393537e-01f, 1.37777906e-02f,
  -1.14519611e-01f, 5.72744980e-02f, -1.86356425e-01f, -2.18404401e-02f, 2.91820526e-01f, 7.54324719e-02f, 7.47163370e-02f, -2.02730447e-01f, -1.83068916e-01f, -2.00034186e-01f,
  -2.39713222e-01f, 4.27657776e-02f, 1.64309949e-01f, 4.28383984e-02f, -1.40764965e-02f, 2.22259387e-02f, -5.13444394e-02f, 2.34617963e-02f, 6.16918616e-02f, 8.64225030e-02f,
  -1.24052390e-01f, 2.10083440e-01f, 1.56451002e-01f, 2.02552862e-02f, 1.09075999e-03f, 4.51616794e-02f, 8.61769915e-02f, -1.91027299e-01f, -5.00629172e-02f, 1.79441333e-01f,
  -1.35002688e-01f, 5.12363873e-02f, -1.28904372e-01f, -1.24964647e-01f, 4.30798531e-02f, -5.81737906e-02f, -4.78680134e-02f, -4.96516265e-02f, -5.70695885e-02f, 4.74533699e-02f,
  3.65011916e-02f, -1.92491487e-01f, -1.04468621e-01f, -5.01916930e-03f, 1.42414317e-01f, 1.08596385e-02f, -1.92237735e-01f, -1.42898504e-02f, 3.47568169e-02f, -1.83787361e-01f,
  -6.78492337e-02f, 1.68101236e-01f, -1.21181302e-01f, -3.70557467e-03f, -1.61796764e-01f, 4.54183221e-02f, 1.67460386e-02f, 7.41816014e-02f, -5.51680010e-03f, 4.17207507e-03f,
  2.42699962e-02f, -1.28181100e-01f, -1.75601438e-01f, -2.61959702e-01f, 8.92812945e-03f, -3.70862484e-02f, -1.28224753e-02f, -6.80721402e-02f, -1.51293904e-01f, 3.18960659e-02f,
  9.78345126e-02f, -3.36549915e-02f, 4.88664806e-02f, -1.82535857e-01f, 2.72314772e-02f, -4.16093841e-02f, 6.20426312e-02f, 7.49656036e-02f, -1.32300481e-01f, 5.00183702e-02f,
  7.85120353e-02f, -2.05896005e-01f, 2.04657137e-01f, -2.10785374e-01f, 1.18830204e-01f, 8.46017823e-02f, 4.17221375e-02f, -2.62983203e-01f, 5.48323542e-02f, 1.12079933e-01f,
  -3.67462705e-03f, 1.68021858e-01f, 9.44848452e-03f, -1.84364811e-01f, -1.76291894e-02f, -7.36537501e-02f, -2.16036048e-02f, -1.30797431e-01f, -3.44047770e-02f, 1.33330375e-01f,
  7.05904067e-02f, -1.83662519e-01f, 2.92006340e-02f, 4.56684791e-02f, -9.36918110e-02f, -2.37642787e-02f, 1.27444128e-02f, -3.60287130e-02f, -9.82269123e-02f, 4.40673791e-02f,
  2.46719904e-02f, -9.01872367e-02f, -2.02622131e-01f, -2.94047073e-02f, -6.63277358e-02f, -2.23327368e-01f, 1.29782632e-01f, -7.90698677e-02f, -3.37139145e-02f, -3.33872773e-02f,
  1.18847586e-01f, 9.66981053e-02f, -1.66032046e-01f, -6.04116134e-02f, 5.42557016e-02f, -1.50264055e-01f, 1.58027604e-01f, 1.26032963e-01f, -5.07632680e-02f, 1.40966401e-01f,
  1.65735438e-01f, 1.19232900e-01f, -1.98212788e-01f, -1.91369221e-01f, -1.84621692e-01f, 1.61409274e-01f, 3.28698903e-02f, 2.35304281e-01f, 1.37436777e-01f, 7.36652464e-02f,
  -1.10279463e-01f, 8.29797834e-02f, 9.81495082e-02f, -9.42718089e-02f, -4.22286987e-02f, 4.71597649e-02f, 4.04227786e-02f, 8.30929726e-02f, 1.02955319e-01f, -1.02431901e-01f,
  -1.97464928e-01f, -1.68761328e-01f, -3.22000384e-02f, 7.27893710e-02f, -7.88452253e-02f, 2.06188172e-01f, -1.11564256e-01f, 6.38992200e-03f, 6.96505308e-02f, 6.80470541e-02f,
  -8.90343413e-02f, 1.77656502e-01f, 4.97283004e-02f, -7.73228183e-02f, -5.72396107e-02f, 1.10700764e-01f, 4.59200703e-02f, 1.49741307e-01f, 4.13103253e-02f, -3.33155831e-03f,
  1.47585332e-01f, -4.40073237e-02f, 6.15536049e-02f, -1.39157055e-02f, 6.10773228e-02f, -4.41367030e-02f, 9.45275277e-02f, -1.47352610e-02f, 5.61359078e-02f, 1.61130399e-01f,
  -6.54892996e-02f, -1.10281363e-01f, 1.36147112e-01f, 1.40232779e-02f, 8.76806211e-03f, 5.79301082e-02f, 3.06328554e-02f, -4.19261009e-02f, -2.08952010e-01f, 9.10550803e-02f,
  -2.23468482e-01f, 1.21506520e-01f, -5.34407571e-02f, -2.77738962e-02f, -2.43225887e-01f, 7.48848468e-02f, 3.12471371e-02f, 6.43060654e-02f, -6.48871139e-02f, -3.73363160e-02f,
  -2.15624079e-01f, -7.79309124e-02f, -1.50495261e-01f, 1.14231214e-01f, 1.63812429e-01f, -3.94491963e-02f, -3.03246025e-02f, 6.53897226e-02f, -1.00951735e-02f, -5.09144031e-02f,
  -2.65121143e-02f, -1.02839902e-01f, 1.02002069e-01f, -8.38631857e-03f, -1.29430383e-01f, 4.04036492e-02f, -5.31584881e-02f, 9.66689289e-02f, -8.06433782e-02f, 3.40336971e-02f,
  -2.63850868e-01f, 1.92233071e-01f, -1.55153602e-01f, -1.70996897e-02f, -5.23439944e-02f, -2.08970234e-01f, 8.49997774e-02f, -1.02296039e-01f, -5.12920804e-02f, 1.37631059e-01f,
  -2.26473878e-03f, 5.90501651e-02f, 7.68759463e-04f, 9.77490023e-02f, -6.15765974e-02f, -1.02815174e-01f, -1.15444094e-01f, 7.84072727e-02f, 1.46919519e-01f, 1.84747053e-03f,
  -8.18240345e-02f, -1.19457379e-01f, -1.44946873e-02f, 5.21265715e-02f, 2.83601470e-02f, -7.23244324e-02f, 3.51443999e-02f, -1.31146446e-01f, -7.93378279e-02f, -5.58851436e-02f,
  -5.96209690e-02f, -1.36315702e-02f, -2.24642921e-02f, 1.20848842e-01f, -6.92453682e-02f, -2.80299671e-02f, 1.07867695e-01f, 1.19289629e-01f, -1.67341858e-01f, -5.31408750e-02f,
  3.64396237e-02f, -1.44273058e-01f, 6.65539205e-02f, -5.00409715e-02f, -7.66760558e-02f, 1.41242549e-01f, -1.79859307e-02f, 1.25459403e-01f, 1.02874033e-01f, -5.63626513e-02f,
  -1.55979418e-03f, 1.09271161e-01f, -1.22599952e-01f, 2.86022592e-02f, -7.67755136e-02f, 7.87544250e-02f, 5.91236427e-02f, -1.04925595e-01f, -1.68403864e-01f, 2.35987872e-01f,
  -7.41763785e-02f, -5.34521602e-02f, -6.15580305e-02f, -1.79386526e-01f, -7.67015442e-02f, 1.47645682e-01f, 5.73590677e-03f, 6.47500977e-02f, 1.16224177e-02f, 6.00782335e-02f,
  3.00162937e-02f, 1.63025837e-02f, 8.76519606e-02f, 1.06646262e-01f, 1.93553627e-01f, 1.40881315e-01f, 2.67198347e-02f, 1.84945717e-01f, 1.05222657e-01f, 9.99766365e-02f,
  -9.89871100e-03f, 3.81240956e-02f, -9.37437788e-02f, 4.76619191e-02f, 1.57545492e-01f, 1.09181277e-01f, -8.86676088e-02f, -5.76469395e-03f, 7.86555633e-02f, 5.09781428e-02f,
  -1.79491509e-02f, 4.10784706e-02f, 6.36450574e-02f, 1.49047807e-01f, 9.46934447e-02f, -6.35388643e-02f, 1.98781602e-02f, -9.76412147e-02f, -8.78922492e-02f, 1.36860222e-01f,
  -1.77112501e-02f, -1.27043528e-02f, -2.64252096e-01f, 2.34993957e-02f, 4.75229789e-03f, -6.06041700e-02f, -1.07750349e-01f, 1.11787386e-01f, -2.04784155e-01f, -5.16588353e-02f,
  -1.15796417e-01f, 1.32764176e-01f, -5.13183922e-02f, 8.60767066e-02f, 1.52669579e-01f, 1.54383764e-01f, -1.83461413e-01f, 2.02722624e-02f, -1.02343492e-01f, 1.66400149e-01f,
  -6.12316653e-02f, -8.40375721e-02f, -9.43915024e-02f, 1.99464619e-01f, 1.36779711e-01f, 1.42814973e-02f, 7.13812783e-02f, 3.18128765e-02f, -3.39901835e-01f, 1.91572651e-01f,
  -1.10910498e-01f, 5.46613187e-02f, 1.10914782e-01f, -2.11054370e-01f, -1.95012670e-02f, -1.70206740e-01f, 6.73169568e-02f, -5.16687036e-02f, 8.90227705e-02f, -1.23242196e-02f,
  8.29863697e-02f, -1.21813314e-02f, -5.43637052e-02f, -1.15099654e-01f, -4.78372956e-03f, -1.27399772e-01f, -1.17182732e-01f, 3.84619907e-02f, -2.26841290e-02f, 2.04616750e-04f,
  -3.83301191e-02f, 6.18288592e-02f, 1.61529351e-02f, 1.62723169e-01f, 7.01768398e-02f, 5.20750927e-03f, 5.64540066e-02f, 1.02963977e-01f, 1.96997404e-01f, -1.47949383e-01f,
  -3.24694365e-02f, -6.51139170e-02f, 2.84718256e-02f, -1.33765534e-01f, 6.28208369e-02f, -1.60241961e-01f, 1.58888418e-02f, 1.26987800e-01f, -1.30142123e-01f, 1.50368288e-01f,
  1.73457608e-01f, 7.17729032e-02f, -4.47365688e-03f, -1.17719956e-02f, 1.00642949e-01f, -1.20623991e-01f, -5.58515303e-02f, 1.17450260e-01f, -5.19515239e-02f, -1.98750347e-01f,
  -7.71458000e-02f, -2.02688396e-01f, 8.56090523e-03f, -1.09318934e-01f, 9.54708457e-02f, 1.65070906e-01f, 1.70963407e-01f, -7.08448887e-02f, -1.04317158e-01f, 1.49610266e-01f,
  -6.22546487e-02f, 2.78419554e-02f, 2.40823701e-01f, -2.12664649e-01f, -4.59413789e-02f, 1.01826586e-01f, -2.84979343e-02f, -1.41963303e-01f, -1.91290136e-02f, 7.23470151e-02f,
  -5.86023219e-02f, -1.42212719e-01f, -1.57445893e-02f, 8.97948816e-02f, 1.31389037e-01f, -2.19725221e-02f, -1.42619368e-02f, -2.33743582e-02f, -5.37232496e-02f, 4.51415703e-02f,
  1.05199061e-01f, 1.28899500e-01f, -6.37966767e-02f, -6.60098419e-02f, 6.91629797e-02f, 2.69200578e-02f, 1.61667377e-01f, 1.22771747e-01f, -5.62933423e-02f, 6.77625835e-02f,
  8.16680416e-02f, 1.17663451e-01f, -3.64273004e-02f, 1.43333733e-01f, 4.39696759e-02f, 1.68449944e-03f, 9.71075222e-02f, 3.16678405e-01f, -2.20621601e-02f, 4.91244532e-02f,
  -3.67291388e-03f, -2.08386242e-01f, 9.10039023e-02f, -1.51238486e-01f, -1.00193955e-01f, -1.87189534e-01f, -1.29262675e-02f, -1.99846327e-02f, 4.85514104e-03f, -7.12596402e-02f,
  1.96317267e-02f, -1.81544021e-01f, 9.14221928e-02f, 5.59826232e-02f, -1.28770918e-01f, 2.84892023e-01f, -4.39368263e-02f, 1.15885951e-01f, 1.66529808e-02f, 2.75276639e-02f,
  -1.43308789e-01f, 2.06956834e-01f, 1.25498235e-01f, -1.57395545e-02f, 7.54749924e-02f, -1.10651530e-01f, -4.79962230e-02f, 2.36547083e-01f, 4.48930562e-02f, -2.69931350e-02f,
  2.05785818e-02f, 1.45317361e-01f, -2.08869614e-02f, -1.36666209e-01f, 9.54893380e-02f, 1.68216243e-01f, -3.41657475e-02f, 1.03788815e-01f, 1.35783061e-01f, 2.33511105e-02f,
  -6.48493739e-03f, -6.17357902e-02f, 2.30816185e-01f, -5.80803752e-02f, 2.21599452e-02f, 3.61253098e-02f, 2.51239866e-01f, 7.71035068e-03f, 3.04795485e-02f, 2.23633468e-01f,
  -9.06977057e-02f, -7.49819130e-02f, -3.05271596e-02f, -2.24081278e-02f, -4.59756851e-02f, 1.55761942e-01f, 1.99679330e-01f, -7.84072056e-02f, -1.57238916e-03f, 9.02223587e-02f,
  -1.03335865e-01f, -1.68756828e-01f, -4.26320061e-02f, -1.51389062e-01f, -2.03310862e-01f, 5.39063960e-02f, 1.66127667e-01f, 1.97759956e-01f, 4.11915258e-02f, 6.52230484e-03f,
  4.39660996e-02f, -1.84774652e-01f, -2.37204343e-01f, 8.11875146e-03f, 1.31841853e-01f, 1.06573775e-01f, -6.64500147e-02f, -6.37620836e-02f, -1.05513863e-01f, 2.87613384e-02f,
  -4.15940507e-04f, 4.53136750e-02f, -1.20516352e-01f, 1.46068558e-01f, 1.61772728e-01f, 1.57771513e-01f, -1.98833775e-02f, 7.59764910e-02f, 1.24220788e-01f, -1.90290734e-01f,
  -1.09679557e-01f, 1.33584375e-02f, 4.46202196e-02f, -2.05646679e-02f, 6.46220073e-02f, -1.91521436e-01f, 4.89273714e-03f, -1.58899557e-02f, 1.12320140e-01f, -6.00572070e-03f,
  -1.14861302e-01f, 5.39621823e-02f, -9.93979126e-02f, -4.46242243e-02f, 2.71171089e-02f, -1.66206378e-02f, -2.18943909e-01f, 7.07605556e-02f, -5.76137118e-02f, 9.02151465e-02f,
  -9.51643735e-02f, 1.78101249e-02f, 1.85966849e-01f, -1.81971535e-01f, -1.37757227e-01f, 7.49770999e-02f, -8.45277458e-02f, -2.87480187e-02f, -1.72655523e-01f, -8.63242373e-02f,
  -5.50694764e-02f, -1.45455271e-01f, 1.23684034e-01f, 9.06056687e-02f, 8.41664597e-02f, -1.25701688e-02f, 7.48440251e-03f, -5.13965823e-02f, 1.53767094e-01f, 1.22654468e-01f,
  -8.79908502e-02f, -9.88294929e-03f, 3.38564888e-02f, 8.09182227e-03f, 2.10393384e-01f, 1.68407068e-01f, 9.20151770e-02f, 3.69124301e-02f, -1.77443743e-01f, -6.57670349e-02f,
  -3.34902592e-02f, -2.98475232e-02f, 3.80905978e-02f, 1.24953799e-01f, -2.25381320e-03f, -3.20414640e-02f, 2.42889281e-02f, 1.15526989e-02f, 1.41005693e-02f, -7.91453943e-03f,
  -2.08565947e-02f, 4.03083637e-02f, -1.50495823e-02f, 1.90909952e-01f, 3.07073295e-01f, -1.04032390e-01f, 7.35993683e-02f, -6.70925900e-02f, 5.08844433e-03f, 2.88550347e-01f,
  -9.36680660e-02f, -1.09847441e-01f, 9.13169831e-02f, 2.12004967e-02f, 8.83173719e-02f, 4.52192500e-02f, -3.69637981e-02f, 1.52171850e-02f, 9.09827054e-02f, -2.12210044e-02f,
  -1.36414424e-01f, 4.26548161e-02f, 1.80315495e-01f, -2.72937901e-02f, -1.12703413e-01f, 9.96635109e-02f, 7.46644512e-02f, 1.92353148e-02f, -1.90827716e-02f, -9.63941664e-02f,
  7.66672716e-02f, 2.88971383e-02f, -2.02880856e-02f, 5.02294116e-02f, 1.69033706e-01f, -1.24681383e-01f, 1.84650943e-01f, 1.81590021e-01f, -5.98834045e-02f, -2.76962444e-02f,
  2.00075448e-01f, 1.38460547e-01f, 1.48917496e-01f, -6.65069148e-02f, -3.07222363e-02f, -2.18568165e-02f, -1.43020585e-01f, -9.52109545e-02f, 1.52127057e-01f, -2.62760893e-02f,
  -9.60499570e-02f, -4.81501743e-02f, -1.89404413e-01f, -1.89367920e-01f, -9.62422509e-03f, -7.41912350e-02f, 3.15928683e-02f, 1.17042020e-01f, 1.06326915e-01f, -1.38564393e-01f,
  3.55664305e-02f, 1.02564797e-01f, -2.99250782e-02f, 1.84287474e-01f, -1.22213542e-01f, -4.86208946e-02f, -6.63867518e-02f, -7.49972090e-02f, 1.44931540e-01f, -9.85370353e-02f,
  1.46155700e-01f, 6.97803199e-02f, 1.02514178e-01f, 2.03664616e-01f, -1.04778260e-01f, -1.08976148e-01f, -2.70270295e-02f, -9.62329656e-02f, -4.68265712e-02f, -1.22361593e-01f,
  6.58676121e-03f, -1.06907539e-01f, 6.03276230e-02f, -7.36173764e-02f, -1.32490322e-01f, -1.61783233e-01f, 3.63638960e-02f, 8.16004276e-02f, -1.11436278e-01f, -3.81536111e-02f,
  1.09404229e-01f, 4.62929085e-02f, 2.70727146e-02f, -1.09416544e-01f, -1.36360943e-01f, 3.06052696e-02f, -2.09972784e-01f, -1.61307260e-01f, 1.81688279e-01f, -5.26805408e-02f,
  -8.84055197e-02f, 1.66250363e-01f, 1.26699895e-01f, -3.04780062e-02f, 1.04966745e-01f, -6.79076789e-03f, 1.37849180e-02f, -2.20501557e-01f, 2.19569951e-01f, -8.19217339e-02f,
  1.25498727e-01f, -1.39262244e-01f, 1.22084498e-01f, -1.46510199e-01f, -1.52192101e-01f, -1.89872369e-01f, -1.20307058e-01f, 5.29888906e-02f, -1.81631461e-01f, -1.02140516e-01f,
  -4.13982756e-02f, -7.48055428e-02f, 4.18033153e-02f, -2.56718338e-01f, -8.09060410e-02f, 1.49991587e-01f, -2.90894192e-02f, 1.63538203e-01f, -1.95423484e-01f, 3.00526414e-02f,
  -2.62146872e-02f, -9.41569433e-02f, 9.89829525e-02f, -2.07211852e-01f, 7.20993876e-02f, 1.16961047e-01f, -1.04031265e-01f, 7.50908107e-02f, 1.70894004e-02f, 8.82553682e-02f,
  1.56494305e-01f, -1.61276907e-02f, -1.43146932e-01f, 1.52247250e-01f, 4.86595370e-02f, 9.96298566e-02f, 2.99059716e-03f, -4.56129611e-02f, -4.17481326e-02f, -8.83020759e-02f,
  -6.04360215e-02f, 6.12666570e-02f, 6.26357868e-02f, -1.23486042e-01f, -5.83439246e-02f, 1.90676004e-01f, -9.32645202e-02f, 6.74026310e-02f, 1.69368327e-01f, -1.28015071e-01f,
  -2.20358185e-02f, 5.65297939e-02f, -1.54424861e-01f, 1.40863150e-01f, -1.15439877e-01f, -1.47905558e-01f, -1.89020753e-01f, 2.09692180e-01f, -1.96649417e-01f, 1.38048217e-01f,
  -4.34628595e-03f, -1.74434111e-01f, 2.08064973e-01f, 4.11716364e-02f, -8.32157508e-02f, -1.23647057e-01f, -3.57414298e-02f, -5.67421550e-03f, -1.42972961e-01f, 9.71559063e-02f,
  5.70757240e-02f, -8.53812397e-02f, -1.52985319e-01f, 3.34131420e-02f, -8.19612518e-02f, -8.46099854e-03f, -1.46383077e-01f, 1.14374198e-01f, 2.66694147e-02f, 5.57257868e-02f,
  -1.75641418e-01f, 6.01386353e-02f, 9.05213505e-02f, -1.03028595e-01f, -6.27527311e-02f, -2.47665361e-01f, -2.61394531e-02f, 1.03485443e-01f, 6.70213625e-02f, -7.40779266e-02f,
  1.06269896e-01f, -5.43183312e-02f, -4.58764918e-02f, 2.78167576e-02f, 4.00713012e-02f, -1.49181947e-01f, 4.29303199e-02f, -2.08702073e-01f, -1.50634825e-01f, -1.84590034e-02f,
  -1.29262447e-01f, 1.66026223e-02f, -1.33564085e-01f, -1.96759731e-01f, 7.66465664e-02f, -3.85158658e-02f, 3.60185727e-02f, -2.25165822e-02f, 1.33831084e-01f, -1.94572940e-01f,
  -1.72254816e-01f, 4.42669354e-02f, -1.19211040e-01f, -5.73140057e-03f, -1.23820551e-01f, -5.57650663e-02f, 2.10254312e-01f, 2.12296490e-02f, 1.15273051e-01f, 2.47386754e-01f,
  1.04920857e-01f, -1.41129479e-01f, 1.18073158e-01f, 4.92752008e-02f, 6.12570066e-03f, 1.02783322e-01f, -8.95841867e-02f, 6.37407675e-02f, 1.06034301e-01f, -6.96541741e-02f,
  1.78590283e-01f, -7.12425485e-02f, -2.72961576e-02f, -2.30732068e-01f, -1.18776530e-01f, -3.24760824e-02f, 9.72388461e-02f, 8.52519646e-03f, 9.01242271e-02f, -2.84775030e-02f,
  1.22604050e-01f, -4.73449677e-02f, 4.69317939e-03f, -6.23660721e-02f, 2.65593920e-02f, 1.05244495e-01f, -1.36081561e-01f, -2.98172999e-02f, 3.50428373e-02f, 9.62430015e-02f,
  2.00085044e-01f, -1.26501143e-01f, -4.05185893e-02f, -9.57986414e-02f, -9.36250463e-02f, 1.57719374e-01f, -3.64399031e-02f, 1.09577633e-01f, 1.40272424e-01f, 8.89914408e-02f,
  8.50634351e-02f, -3.17142569e-02f, 1.50061920e-01f, -1.65292621e-02f, 2.05902811e-02f, -4.70457673e-02f, -6.82010278e-02f, 1.17873006e-01f, -5.45332283e-02f, 8.08318183e-02f,
  -1.10903280e-02f, 1.13016769e-01f, -8.08255300e-02f, 4.33279835e-02f, 6.43111318e-02f, 1.65591598e-01f, 9.59530622e-02f, 7.09137842e-02f, 3.16164568e-02f, -1.84800867e-02f,
  -8.47768337e-02f, 6.62533715e-02f, 2.58379485e-02f, -2.89098889e-01f, 6.75752526e-04f, 2.86717176e-01f, -1.34382457e-01f, 2.71096975e-02f, 5.35869114e-02f, 4.19146940e-02f,
  -6.53713420e-02f, -9.81101915e-02f, -1.35704905e-01f, -7.54797831e-02f, 8.25266540e-02f, 1.93367496e-01f, 2.34880596e-02f, 2.24945322e-01f, 8.03928226e-02f, -3.65979709e-02f,
  9.53101367e-02f, 2.23153103e-02f, -1.51098922e-01f, 1.58783887e-02f, -7.00256824e-02f, 9.97534171e-02f, -5.40957712e-02f, -9.83220860e-02f, -8.45936388e-02f, -1.25565499e-01f,
  2.77718127e-01f, 6.04368234e-03f, 1.23383306e-01f, -1.07391745e-01f, 7.83790573e-02f, 4.33150567e-02f, 1.07903771e-01f, 5.53050451e-02f, -3.26105533e-03f, -7.65412375e-02f
};

// L3_fan_Wp_bar (Shape: 14 x 64)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  -7.98051804e-02f, -5.85123524e-02f, -5.71446195e-02f, 9.14081708e-02f, -8.31969604e-02f, 2.44233645e-02f, 1.20040074e-01f, 2.27244813e-02f, 1.35021172e-02f, 5.92233380e-03f,
  1.60079405e-01f, 2.96824370e-02f, 8.40331540e-02f, 5.82563654e-02f, 1.50840089e-01f, 1.34368196e-01f, 1.82326719e-01f, -1.63271964e-01f, 7.15272874e-02f, -8.70428085e-02f,
  1.69814620e-02f, 1.09303072e-01f, -5.76519817e-02f, 1.22749366e-01f, 1.81556299e-01f, -1.67791799e-01f, -2.98491735e-02f, 2.62849689e-01f, 1.51691496e-01f, -1.80968329e-01f,
  -5.15052378e-02f, -1.18731141e-01f, 1.36839032e-01f, -1.56479962e-02f, 8.82832706e-02f, 7.92681202e-02f, 7.57291093e-02f, -2.36971434e-02f, 5.29583655e-02f, 9.31164771e-02f,
  -1.94589200e-03f, -1.13867968e-01f, -2.15683594e-01f, 4.63162437e-02f, 6.20052740e-02f, -9.59917232e-02f, 9.89643335e-02f, 9.14819166e-02f, 6.82846308e-02f, 5.36533538e-03f,
  -6.79712594e-02f, 1.49696827e-01f, 2.56575018e-01f, 1.06736094e-01f, 9.23069566e-02f, -8.20962936e-02f, -7.75511339e-02f, 1.75176516e-01f, 3.20616037e-01f, -2.51221545e-02f,
  2.14385301e-01f, 8.78032669e-02f, -2.53416710e-02f, 1.94225535e-01f, 1.16262235e-01f, 5.26202433e-02f, -3.29150297e-02f, -1.08363129e-01f, -8.30340534e-02f, 8.13441873e-02f,
  4.04839516e-02f, 2.69981865e-02f, -2.42185760e-02f, -1.48100415e-02f, -4.36649844e-02f, -2.24353150e-02f, 1.75493862e-02f, 2.08035875e-02f, 8.83478597e-02f, -1.49659123e-02f,
  6.73818365e-02f, -7.28898421e-02f, 6.10741787e-03f, -1.06505185e-01f, 7.09830299e-02f, -9.84905958e-02f, 1.13342814e-01f, -5.50309792e-02f, -8.26039612e-02f, 3.86423096e-02f,
  2.19526608e-02f, 8.27056989e-02f, 4.45293672e-02f, -6.63482845e-02f, -6.81398213e-02f, 1.08373240e-01f, -1.16173200e-01f, 1.05344087e-01f, 1.05204657e-01f, 9.85386148e-02f,
  9.13227797e-02f, 1.11598566e-01f, 5.23931347e-02f, -6.98258206e-02f, 4.35567424e-02f, -3.08857276e-03f, 1.60918534e-02f, 4.36417237e-02f, 1.15405358e-01f, -6.79740459e-02f,
  5.15432581e-02f, 3.25420611e-02f, 1.25715451e-04f, -1.18811712e-01f, -7.05931857e-02f, -5.34336902e-02f, -6.81130216e-02f, 6.08535632e-02f, -1.97589993e-02f, -1.22774437e-01f,
  6.41599065e-03f, 7.33716786e-02f, -6.40449896e-02f, 3.89521220e-03f, -7.79112577e-02f, 8.80409628e-02f, 1.24828279e-01f, -7.28246421e-02f, 2.06076324e-01f, -1.63751692e-01f,
  3.07116713e-02f, 1.15029678e-01f, 1.50494650e-01f, 1.22822806e-01f, 5.32694757e-02f, 2.00883314e-01f, 2.22472921e-01f, -5.50341494e-02f, 1.41204953e-01f, 4.94302064e-02f,
  2.26944640e-01f, 1.61963686e-01f, 1.03140235e-01f, 6.88774735e-02f, 7.27806380e-03f, 1.86527848e-01f, 2.44329162e-02f, 2.45683149e-01f, 3.21306996e-02f, 4.21061106e-02f,
  2.49782763e-02f, 4.02565859e-02f, 2.54603505e-01f, -1.68417856e-01f, -2.05838412e-01f, 1.24071293e-01f, -1.89168260e-01f, -1.26591489e-01f, 4.45888191e-02f, -5.30701987e-02f,
  -7.55145550e-02f, 3.69165628e-03f, 1.80487126e-01f, 1.51209742e-01f, 2.50646532e-01f, -6.85997456e-02f, -4.07459326e-02f, -2.74355173e-01f, -2.81014591e-01f, 1.68163851e-01f,
  -5.67459036e-03f, 2.89022863e-01f, -2.96330959e-01f, -2.06357196e-01f, -1.09540774e-02f, -2.59251207e-01f, 1.31956965e-01f, -1.70466259e-01f, 1.85970012e-02f, 3.94588649e-01f,
  2.20791653e-01f, -6.66954042e-03f, 5.59291244e-02f, 2.33011693e-01f, -8.38510767e-02f, -1.02516897e-01f, 2.63040930e-01f, 7.47738481e-02f, -4.69512306e-02f, 1.12531722e-01f,
  -8.59024227e-02f, -1.60629764e-01f, 1.22598186e-02f, 1.23010352e-01f, -6.65930733e-02f, -8.81377831e-02f, -6.16383553e-02f, -6.46465644e-02f, 1.31441411e-02f, -1.29207104e-01f,
  -1.04181059e-01f, 1.23986274e-01f, 2.18258593e-02f, -3.52636389e-02f, 2.66367812e-02f, -9.54351127e-02f, 1.15175797e-02f, -4.82807169e-03f, 6.87106773e-02f, -4.10954840e-03f,
  -6.46863282e-02f, 1.47609711e-01f, 5.49928658e-02f, -2.27249339e-02f, 4.49628681e-02f, 9.07162726e-02f, 7.62911811e-02f, 6.71694279e-02f, 9.31617692e-02f, 3.21858525e-02f,
  1.27960712e-01f, -1.03284428e-02f, 8.95118788e-02f, -5.03674001e-02f, 1.81428954e-01f, -8.89707729e-03f, -1.59797847e-01f, 5.46130445e-03f, 1.72492519e-01f, 1.82225361e-01f,
  -4.78196889e-02f, -1.80318039e-02f, 1.06473669e-01f, -7.53022283e-02f, -4.29990627e-02f, 1.69197083e-01f, 1.60055056e-01f, -2.26698979e-03f, 1.28606394e-01f, -1.70375347e-01f,
  1.80738315e-01f, 6.96481615e-02f, 7.82011151e-02f, 3.77371684e-02f, 5.48668355e-02f, -1.06564343e-01f, 8.90847016e-03f, -6.73897341e-02f, 3.67832035e-02f, 3.56121272e-01f,
  3.20338190e-01f, -1.69390067e-01f, 9.20481980e-02f, 5.59118874e-02f, 8.94783363e-02f, 2.49720737e-01f, 8.92636925e-02f, 1.67384520e-01f, 1.21484704e-01f, -1.53318167e-01f,
  -1.09994099e-01f, 4.58905511e-02f, 4.97494601e-02f, 9.29761231e-02f, 1.29884467e-01f, 1.17435642e-01f, -1.59947187e-01f, 6.47590011e-02f, 3.34611349e-02f, -5.57980724e-02f,
  -1.49759591e-01f, 5.50177768e-02f, -6.51163831e-02f, -1.01031937e-01f, 2.19337586e-02f, 1.06035009e-01f, -4.69545834e-02f, -9.12714899e-02f, -1.24511637e-01f, -8.49538147e-02f,
  -1.04171664e-01f, 3.60925980e-02f, 1.24089539e-01f, -5.64221479e-02f, 5.25310636e-03f, 2.36001741e-02f, -1.10939398e-01f, 6.94639161e-02f, 9.83485878e-02f, -8.33355859e-02f,
  1.61729574e-01f, -5.48241921e-02f, -1.18359953e-01f, -1.22214742e-01f, 1.04668982e-01f, 1.17257454e-01f, -1.22308336e-01f, -1.79003971e-03f, 2.87881475e-02f, 1.73002705e-02f,
  7.08457008e-02f, 1.61411762e-01f, -3.85864004e-02f, 6.85767308e-02f, -1.38570160e-01f, 2.92366631e-02f, -5.05585931e-02f, -1.14387423e-01f, -1.58900559e-01f, 2.07382157e-01f,
  1.57395955e-02f, 9.61384624e-02f, 7.14426637e-02f, 4.80768681e-02f, 6.47530407e-02f, 1.33135512e-01f, 5.91952761e-04f, 6.24647699e-02f, -1.34989604e-01f, 2.12682679e-01f,
  -8.19565803e-02f, 5.04801758e-02f, -2.17211414e-02f, -2.16235027e-01f, 5.29684275e-02f, -1.20100779e-02f, 6.79814890e-02f, 9.02674645e-02f, 5.54132871e-02f, -1.30827785e-01f,
  1.59455519e-02f, -7.84868747e-02f, 1.00964298e-02f, 2.00487878e-02f, -1.67259470e-01f, 1.62734054e-02f, 8.48996788e-02f, -2.09918004e-02f, 1.33144438e-01f, 2.35682368e-01f,
  -1.10476635e-01f, 5.21371290e-02f, -7.45235682e-02f, -1.50726791e-02f, 6.66135103e-02f, 6.75011724e-02f, -4.19173911e-02f, -1.45576969e-01f, 1.44807249e-01f, 1.79939657e-01f,
  1.36646956e-01f, 1.27013385e-01f, 2.14611158e-01f, 1.52748646e-02f, 6.46136189e-03f, -1.17115878e-01f, 9.93823186e-02f, 8.57109055e-02f, 1.22829229e-01f, -6.49370477e-02f,
  -1.59674585e-02f, 1.15692183e-01f, -1.06911339e-01f, 4.37274203e-02f, -8.99671167e-02f, 8.96111690e-03f, -2.36440729e-02f, 1.29120573e-01f, -3.07944454e-02f, 1.30093515e-01f,
  1.05102099e-01f, 1.75748691e-02f, 3.60551737e-02f, 8.00039247e-02f, 1.42634392e-01f, 1.17687382e-01f, 1.01938576e-01f, -4.46744673e-02f, 2.16378346e-01f, -1.44237056e-02f,
  1.88699797e-01f, -8.42514783e-02f, -1.06112972e-01f, 5.65336458e-02f, -1.85046606e-02f, -4.77141468e-03f, 8.38550925e-02f, -8.75166729e-02f, -7.67866299e-02f, -3.48171741e-02f,
  3.26557495e-02f, -4.89956625e-02f, 7.99944401e-02f, 1.65311303e-02f, 5.48331775e-02f, -2.57597417e-02f, -2.05550119e-02f, -1.20450556e-01f, 5.26224673e-02f, -8.61057341e-02f,
  -1.49797916e-03f, -8.93999189e-02f, 8.83190930e-02f, -1.15219072e-01f, -6.21213578e-02f, -1.11674614e-01f, 7.49583021e-02f, -1.58731677e-02f, -7.60703534e-02f, 7.15650544e-02f,
  2.11194977e-02f, -9.52778384e-02f, 9.70859975e-02f, -8.15867707e-02f, -1.29352622e-02f, 5.09095155e-02f, -9.29165259e-02f, -1.04485177e-01f, -4.65799086e-02f, 1.06054522e-01f,
  -1.10072114e-01f, 8.00585970e-02f, 8.42248648e-02f, -8.41520429e-02f, 3.59781906e-02f, 7.28222653e-02f, -9.96801332e-02f, 4.88745682e-02f, -7.10790828e-02f, 2.74804439e-02f,
  -8.99177864e-02f, 2.04860680e-02f, 5.21630049e-03f, 7.31532574e-02f, -8.33767056e-02f, -5.15446626e-02f, -1.49299577e-02f, -5.48446439e-02f, 9.62995738e-02f, 6.66157156e-03f,
  -3.02915182e-02f, 7.17156678e-02f, -4.15122062e-02f, -9.37879756e-02f, -5.56497537e-02f, 9.89342555e-02f, -5.15287593e-02f, -1.17563553e-01f, 6.21588752e-02f, 1.56561490e-02f,
  2.23069806e-02f, -9.64287594e-02f, -9.88578796e-02f, 9.49651524e-02f, 1.32013962e-01f, -1.27755761e-01f, 1.66427791e-02f, -6.65624812e-02f, -4.85335737e-02f, -7.76575878e-02f,
  -1.01418369e-01f, -1.21039078e-01f, -1.51252031e-01f, -1.16808653e-01f, 4.27850476e-03f, -1.36721566e-01f, -6.93437085e-02f, 1.92849822e-02f, -5.04292063e-02f, -1.06226146e-01f,
  1.41674712e-01f, 1.18226476e-01f, 5.97119778e-02f, -2.18604971e-02f, 3.28920223e-02f, 2.21956801e-02f, 4.19291221e-02f, -2.47801840e-02f, 1.19135030e-01f, 4.99357805e-02f,
  1.29176661e-01f, 7.15665668e-02f, -1.13830090e-01f, -1.19521683e-02f, 3.19043640e-03f, 4.55795834e-03f, 2.34344285e-02f, 1.00937262e-01f, 1.32327497e-01f, -1.01090394e-01f,
  -8.40976983e-02f, 7.80192614e-02f, 1.15979597e-01f, -6.94516227e-02f, -3.92301343e-02f, 6.42415434e-02f, 7.95490593e-02f, -5.27979210e-02f, 1.86828114e-02f, 3.38233300e-02f,
  5.94340861e-02f, -3.43209393e-02f, -7.65062794e-02f, 5.51904365e-02f, 9.56022069e-02f, 1.85926229e-01f, 6.72842860e-02f, -1.23752013e-01f, -6.52855858e-02f, 3.71576101e-02f,
  -4.28030565e-02f, 6.38497174e-02f, -6.34280965e-02f, 1.29399732e-01f, 1.44104257e-01f, 1.39910787e-01f, 6.72914684e-02f, 1.41675740e-01f, -6.00505322e-02f, 6.77817920e-03f,
  1.15602039e-01f, -6.02038950e-02f, -1.55893853e-03f, -6.86709061e-02f, -1.12683717e-02f, -5.01677841e-02f, 6.74182177e-02f, -8.95586386e-02f, 7.76027068e-02f, 7.92993456e-02f,
  4.88653183e-02f, 8.00221041e-02f, 6.63941205e-02f, -6.03467263e-02f, -1.77475750e-01f, -1.22980803e-01f, -7.07212836e-02f, 1.07388780e-01f, 5.35974838e-02f, 1.99787080e-01f,
  -1.17043786e-01f, 3.16275880e-02f, -3.30147828e-04f, -7.77054753e-04f, -1.71566203e-01f, -1.00046322e-01f, 5.76003492e-02f, -8.52749422e-02f, 5.97037189e-02f, -2.20731348e-01f,
  5.83678335e-02f, 6.51885867e-02f, -6.25650585e-02f, 5.65530024e-02f, -8.76289159e-02f, -8.38379338e-02f, 1.42450541e-01f, 6.30868375e-02f, 1.81048252e-02f, 1.25886872e-01f,
  7.48268813e-02f, 9.72686857e-02f, -5.66765368e-02f, -3.90418097e-02f, -4.29248624e-02f, 1.78354681e-01f, -9.42745134e-02f, -9.43394229e-02f, 2.03729291e-02f, -2.01329112e-01f,
  -5.47111332e-02f, 9.13596824e-02f, 7.40836784e-02f, 7.70957209e-03f, 4.18108702e-02f, 7.99082965e-02f, 9.38185975e-02f, -1.37391184e-02f, -3.34787145e-02f, 1.26752973e-01f,
  2.56590527e-02f, -6.63479194e-02f, 6.98465407e-02f, -6.63543493e-02f, -2.74314508e-02f, 9.42645893e-02f, 4.63469774e-02f, -1.16033673e-01f, -1.15131594e-01f, 3.95300165e-02f,
  -5.65361530e-02f, -1.06847249e-01f, 1.22994684e-01f, -7.15822056e-02f, 1.19486153e-02f, -1.01885937e-01f, -1.35612100e-01f, 4.18481380e-02f, -1.57029033e-02f, 8.71540532e-02f,
  -5.65428101e-02f, 5.68588153e-02f, -1.43318519e-01f, 3.42676118e-02f, -1.53043643e-02f, -7.65382126e-02f, 4.98054661e-02f, -1.92822009e-01f, -1.05029151e-01f, -5.82319163e-02f,
  -1.50126502e-01f, -7.22433180e-02f, 8.47989470e-02f, -9.25055444e-02f, -5.10550290e-02f, -1.21659547e-01f, 1.36416614e-01f, 1.13699593e-01f, 2.06069872e-02f, 1.51080102e-01f,
  -2.04672411e-01f, -4.06152271e-02f, -5.14807105e-02f, -2.05397993e-01f, 1.69060975e-01f, -1.88654810e-01f, -9.37561132e-03f, 5.75320097e-03f, 1.91617519e-01f, -1.14923224e-01f,
  5.98476594e-03f, 1.06262885e-01f, -5.82078518e-03f, 1.88491344e-01f, 1.68870345e-01f, -1.91944391e-01f, -1.34429306e-01f, 1.38783725e-02f, 6.87718242e-02f, -3.45083959e-02f,
  7.50746951e-02f, -1.32940292e-01f, 6.51938841e-02f, 2.59315461e-01f, 4.21187514e-03f, 2.34862745e-01f, 5.98565601e-02f, 8.37222636e-02f, 2.25849256e-01f, -1.37927562e-01f,
  1.75890297e-01f, 5.82145415e-02f, 1.67552173e-01f, 1.24892853e-01f, 2.42714450e-01f, -1.77832823e-02f, 2.10082740e-01f, 1.83893129e-01f, 1.27632797e-01f, 2.63337456e-02f,
  1.42474905e-01f, 1.38784304e-01f, -1.75261963e-02f, 3.04862927e-03f, 1.11290544e-01f, 4.93200049e-02f, -1.94159687e-01f, 2.27322862e-01f, -7.25474656e-02f, -3.59630026e-02f,
  2.29872707e-02f, 9.59419832e-02f, -3.25568825e-01f, -9.55417976e-02f, 2.15632483e-01f, -6.85522258e-02f, -6.78858906e-02f, -6.08775765e-02f, -9.30397660e-02f, -2.08657116e-01f,
  -2.67009586e-01f, 1.82220086e-01f, -1.17011890e-01f, -5.41434065e-02f, -1.71485334e-03f, -1.75648574e-02f, -7.74670914e-02f, 1.04523480e-01f, -3.23266573e-02f, -4.07337621e-02f,
  -2.95273773e-02f, 2.66139567e-01f, 2.91190054e-02f, 4.67479706e-01f, -2.40958780e-02f, -8.91347826e-02f, 6.21286668e-02f, -1.95883766e-01f, -1.00265175e-01f, 3.18504751e-01f,
  1.25200953e-02f, -1.07314572e-01f, 8.84089321e-02f, 2.52916086e-02f, 1.72761939e-02f, -8.32917448e-03f, 5.10009229e-02f, 3.23941857e-02f, 1.42893363e-02f, -6.28947467e-02f,
  1.72644496e-01f, 1.25423029e-01f, -5.79673573e-02f, 1.85045883e-01f, -2.53109895e-02f, 1.15078762e-01f, -5.57989292e-02f, 1.11108281e-01f, 4.49405275e-02f, 2.29218006e-01f,
  1.08784162e-01f, -4.74404804e-02f, -8.09871107e-02f, 1.33654140e-02f, 1.16353966e-01f, 8.86450186e-02f, 2.61121899e-01f, 1.25302628e-01f, 7.60491937e-02f, -2.10062727e-01f,
  -8.71062651e-02f, -1.42411053e-01f, 1.61919415e-01f, -9.62360352e-02f, -4.85641835e-03f, -3.31725553e-02f, 2.63385624e-01f, 2.24194080e-01f, -1.84955984e-01f, 1.19101584e-01f,
  1.04775093e-01f, 2.75305718e-01f, 1.32140681e-01f, 8.55797976e-02f, 1.88574523e-01f, -3.92536260e-02f, -2.10438967e-01f, 2.86441091e-02f, 7.19087422e-02f, -9.93743166e-02f,
  1.28558099e-01f, -2.72099953e-02f, 2.09283546e-01f, -1.35061676e-02f, 8.43588635e-02f, 1.66030899e-02f, 2.86243260e-01f, -2.22186714e-01f, 2.06438437e-01f, 5.65434247e-02f,
  -5.58765531e-02f, 3.92707765e-01f, 4.94362205e-01f, -5.02283871e-02f, 1.37394309e-01f, 1.54920757e-01f, -4.43923287e-02f, 4.44358349e-01f, -3.88410427e-02f, -4.82489765e-02f,
  1.07422590e-01f, -5.92393801e-02f, -1.33007942e-02f, 9.25406069e-02f, 1.42878145e-01f, 1.31334234e-02f, 7.01342989e-03f, 4.81754728e-03f, -1.96575567e-01f, 2.27238331e-02f,
  1.13885276e-01f, 6.90622255e-02f, -3.20180431e-02f, 1.38483241e-01f, 3.29615027e-02f, 4.48679086e-03f, 8.58993232e-02f, -5.06407730e-02f, 7.32442886e-02f, 6.62776604e-02f,
  3.00140269e-02f, 6.09718114e-02f, -8.05525705e-02f, 9.03149098e-02f, 1.41660869e-01f, 1.13869041e-01f, 1.92000672e-01f, 1.80798948e-01f, 7.58166090e-02f, 7.44852647e-02f,
  3.86812016e-02f, -1.21424511e-01f, -3.15855145e-02f, -1.31950332e-02f, -1.30130067e-01f, 2.14378294e-02f, 2.10862681e-01f, 1.12811908e-01f, 5.73269837e-02f, 4.77351137e-02f,
  2.67103594e-02f, -1.65629342e-01f, 1.49923235e-01f, -5.41555956e-02f, -1.65423006e-03f, 1.52516022e-01f, -6.43460453e-02f, -9.52285889e-04f, 6.91005513e-02f, -2.75941119e-02f,
  -1.58873126e-01f, 1.13588214e-01f, 1.45428926e-01f, -6.65505901e-02f, -4.04123217e-02f, 1.94440454e-01f, 1.38298169e-01f, 6.45731017e-02f, 2.58818895e-01f, 2.44245827e-02f,
  1.56294480e-02f, 1.94385603e-01f, 1.21085402e-02f, 1.21661425e-01f, 2.07200035e-01f, 1.17715396e-01f, 1.49299994e-01f, 1.75956473e-01f, 1.17475018e-01f, 1.42230287e-01f,
  9.24723223e-02f, 1.35686234e-01f, 3.73486131e-02f, 2.08261445e-01f, 2.36371338e-01f, 1.82959422e-01f, 3.26018408e-02f, 2.22418785e-01f, 4.08353098e-02f, 2.06991732e-02f,
  6.80803061e-02f, 2.56725168e-03f, 1.79718420e-01f, -2.47956757e-02f, -2.99406033e-02f, 1.22349504e-02f, -7.47571466e-03f, -2.08832081e-02f, -2.81214677e-02f, -2.64918078e-02f,
  1.56335279e-01f, 3.31885964e-01f, 6.83541745e-02f, 1.84658363e-01f, -1.19930267e-01f, -1.58070743e-01f, 3.71495821e-02f, -3.51103693e-01f, -2.19603091e-01f, -7.97353685e-02f,
  1.77048221e-01f, 1.90916330e-01f, -1.03451326e-01f, -2.26593334e-02f, -2.78304338e-01f, -2.89171100e-01f, 2.83440530e-01f, -9.58855264e-03f, -6.14096858e-02f, 3.84115010e-01f,
  -2.50450760e-01f, 2.59309649e-01f, 5.42706549e-02f, -1.55087829e-01f, -1.19476654e-01f, 4.16996837e-01f, 3.01451057e-01f, 9.69195366e-02f, -4.45903242e-02f, -1.09909158e-02f,
  -1.61513716e-01f, 5.59552133e-01f, 2.72791713e-01f, -9.59991291e-02f, -6.91819489e-02f, 3.04977387e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  -8.14852268e-02f, -9.18593705e-02f, -1.93969160e-03f, -4.82969955e-02f, 1.74291525e-02f, -6.33484591e-03f, 7.70272240e-02f, 5.64817563e-02f, 9.60358381e-02f, -2.51182411e-02f,
  1.72607183e-01f, 1.52405396e-01f, 6.03721365e-02f, -1.55768180e-02f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  -1.74374521e-01f, -9.56522748e-02f, -3.62648845e-01f, -1.09592691e-01f, 1.10875852e-01f, 7.81337023e-02f, -1.06819265e-01f, 1.75026283e-01f, -2.97660619e-01f, 4.90898527e-02f,
  -3.19870375e-03f, -6.40006885e-02f, -1.26336589e-01f, -3.94212395e-01f, 6.10810667e-02f, 2.21980929e-01f, -3.56351286e-02f, 2.39616409e-02f, -1.63181096e-01f, -3.46022546e-01f,
  -3.66876900e-01f, 2.19971702e-01f, 2.33629778e-01f, 2.41610140e-01f, -1.29632652e-01f, 2.58604288e-01f, 2.33698830e-01f, -1.53820261e-01f, 7.45247304e-02f, 3.55450302e-01f,
  3.59061956e-02f, 2.28992924e-01f, 7.00985789e-02f, 1.46984458e-01f, -1.53598879e-02f, -2.16010302e-01f, 2.82246679e-01f, 2.78368652e-01f, -2.71349549e-01f, 1.08026855e-01f,
  -2.05478400e-01f, -3.34922262e-02f, -2.61939853e-01f, -3.02543789e-01f, -1.55291721e-01f, -1.51896698e-03f, 6.58727735e-02f, 2.71839321e-01f, 2.28135198e-01f, 1.76560163e-01f,
  4.01123986e-02f, -1.20933212e-01f, -1.83400422e-01f, -1.60150230e-01f, 3.83891195e-01f, 3.59200567e-01f, 1.18628494e-01f, -2.15194032e-01f, 1.83872823e-02f, 3.79273593e-02f,
  -9.44585502e-02f, -1.76120356e-01f, 2.88213819e-01f, 3.31268728e-01f, 5.85636310e-02f, -2.09025964e-01f, 3.06755394e-01f, 5.30865462e-03f, 3.49473245e-02f, -2.55059041e-02f,
  1.92053199e-01f, -3.02765250e-01f, 3.81579399e-02f, 1.75229430e-01f, -3.69120806e-01f, -8.09720308e-02f, -4.01649654e-01f, -3.16367686e-01f, 1.69969723e-01f, 3.43161188e-02f,
  2.63840139e-01f, -7.62500092e-02f, -4.17620271e-01f, -1.37083121e-02f, -2.03515932e-01f, -1.15841180e-01f, 9.21557005e-03f, 5.93325198e-02f, -1.65060908e-02f, 4.76371460e-02f,
  7.89510384e-02f, -2.68063784e-01f, 2.33027376e-02f, -2.26920489e-02f, -2.87044913e-01f, -7.84747750e-02f, 8.97829160e-02f, -4.43908758e-02f, 2.07012102e-01f, -1.42063618e-01f,
  -2.55411863e-01f, 4.81505506e-02f, -1.09676793e-01f, -2.67079100e-02f, -2.24043503e-01f, 4.48328850e-04f, 8.12735260e-02f, -1.14758618e-01f, -1.55949771e-01f, -7.23267794e-02f,
  -2.18731880e-01f, -3.79804552e-01f, 7.54605681e-02f, 1.04284003e-01f, -4.63889167e-02f, 1.01018474e-01f, -2.91716576e-01f, 2.44488224e-01f, 1.06678307e-01f, 2.24814832e-01f,
  1.20118447e-02f, 2.56669700e-01f, -1.96365371e-01f, 2.52565816e-02f, -6.29005194e-01f, 3.21697265e-01f, 3.13248783e-01f, 2.90541779e-02f, 1.00250311e-01f, -3.10806245e-01f,
  3.42675656e-01f, -1.09645635e-01f, -7.60491714e-02f, 2.56316274e-01f, -3.11521113e-01f, 1.89221755e-01f, 7.42855715e-03f, -3.13761562e-01f, 5.12706041e-02f, -1.56362981e-01f,
  8.25142711e-02f, -3.70493799e-01f, -4.56352159e-02f, 1.65402398e-01f, 1.88475043e-01f, 2.09199578e-01f, 2.19139621e-01f, -3.34472060e-01f, -2.02994972e-01f, 1.24411955e-02f,
  -2.75718242e-01f, -7.91195706e-02f, 1.83383808e-01f, -2.16839939e-01f, -3.33889425e-01f, 2.22278789e-01f, 5.62906377e-02f, -1.88903928e-01f, 7.67023414e-02f, 1.81079790e-01f,
  3.59517783e-01f, 1.88641563e-01f, -2.20665738e-01f, -3.71281207e-01f, -1.51852772e-01f, 3.20859194e-01f, -2.56451666e-01f, 2.19180360e-02f, -1.74529463e-01f, 1.97599500e-01f,
  2.94982523e-01f, -3.47718865e-01f, 1.22217990e-01f, 9.90437642e-02f, 2.24729463e-01f, -2.76716858e-01f, 4.36199069e-01f, -2.24196747e-01f, 2.78530329e-01f, 1.78863574e-02f,
  -7.60399103e-02f, 9.81172696e-02f, 1.47617489e-01f, 8.30143914e-02f, 9.73343253e-02f, 6.74820691e-02f, -9.17294025e-02f, -2.37277269e-01f, -2.24631086e-01f, 2.89368331e-01f,
  6.88869357e-02f, -3.95235866e-02f, -1.41778722e-01f, -9.01425853e-02f, 1.59015149e-01f, 7.77524114e-02f, -6.78563723e-03f, -2.44333163e-01f, -3.84159386e-02f, -3.17414761e-01f,
  -7.61625692e-02f, -2.36250177e-01f, -1.16210930e-01f, 1.94814950e-01f, -1.37333259e-01f, 5.19249290e-02f, 1.57045171e-01f, 3.04175820e-02f, -1.16036147e-01f, 3.38117778e-01f,
  -2.80102432e-01f, 2.52505928e-01f, 1.30833805e-01f, 2.28307113e-01f, 2.24747315e-01f, 6.14477359e-02f, 1.29527688e-01f, -1.68020353e-01f, 1.97448641e-01f, -1.42272562e-01f,
  -1.31957233e-01f, -6.93408400e-02f, 1.69512838e-01f, 5.24440445e-02f, -1.97263107e-01f, -2.23338082e-01f, -1.70904756e-01f, 1.65466025e-01f, 1.67829633e-01f, -3.30284476e-01f,
  3.78604114e-01f, 1.24860881e-02f, 1.37373833e-02f, 2.14832187e-01f, 1.20719513e-02f, 1.25808552e-01f, -1.99487925e-01f, -5.87530471e-02f, 2.77030230e-01f, -5.38802240e-03f,
  -1.09310202e-01f, -2.55873740e-01f, -5.20646982e-02f, -1.09314948e-01f, 6.26272798e-01f, -2.13806063e-01f, -1.21511362e-01f, -2.23821431e-01f, -9.21989908e-04f, 1.06344089e-01f,
  -1.21664114e-01f, 1.27472922e-01f, 3.51765126e-01f, -1.78435698e-01f, -1.77846566e-01f, -7.03921199e-01f, -1.03985839e-01f, 2.76765257e-01f, -3.05172950e-01f, -6.10646755e-02f,
  -1.01865895e-01f, -3.15357178e-01f, 1.43439054e-01f, -5.29685058e-03f, 3.03703453e-02f, -1.15430824e-01f, -1.36485159e-01f, -1.68694735e-01f, 4.95439395e-02f, 1.42445862e-01f,
  1.36577144e-01f, -4.19670902e-02f, 3.90086621e-01f, -3.38559270e-01f, -1.30487829e-01f, 3.72726172e-01f, -8.17594975e-02f, 1.42218903e-01f, 1.79070845e-01f, 1.04960485e-03f,
  1.34480298e-01f, -2.56074965e-01f, 2.32541695e-01f, -2.64631375e-03f, 1.50591880e-01f, -1.60909593e-01f, -2.53232449e-01f, 1.11528106e-01f, -9.81760100e-02f, -3.76267657e-02f,
  -2.54045427e-01f, 9.70629156e-02f, -2.59318322e-01f, -1.57414988e-01f, 9.74921584e-02f, 1.15600348e-01f, 1.73056290e-01f, -1.45194799e-01f, 2.41705492e-01f, 3.06267977e-01f,
  1.47376163e-02f, 1.61180422e-01f, 1.85479954e-01f, 1.99017972e-01f, -1.03156641e-01f, -1.90235153e-01f, 7.31313005e-02f, 1.03694595e-01f, 2.09367931e-01f, -1.17940366e-01f,
  -2.29427710e-01f, 7.49523044e-02f, -8.44125524e-02f, 5.64565770e-02f, 3.00512500e-02f, -1.78222299e-01f, 5.05069494e-01f, -3.17619711e-01f, -7.46357441e-02f, 2.43258715e-01f,
  1.50729455e-02f, -2.88035601e-01f, -1.56221643e-01f, -1.74964771e-01f, -2.88449205e-03f, 3.26376349e-01f, 1.39917165e-01f, 1.60018466e-02f, 1.81471169e-01f, 7.65744597e-02f,
  8.43826681e-02f, -1.61064997e-01f, -3.85413378e-01f, 9.75160375e-02f, 1.08639866e-01f, -1.43528774e-01f, -4.26015034e-02f, -2.33378500e-01f, -3.07588559e-02f, -5.71499094e-02f,
  3.73482913e-01f, -5.02172351e-01f, 1.35840312e-01f, -1.50443152e-01f, -3.49961400e-01f, 4.89059575e-02f, -2.42285818e-01f, 5.24581447e-02f, 2.21568942e-01f, 1.40515551e-01f,
  -7.66317025e-02f, -3.56171310e-01f, 3.54966402e-01f, 6.68068137e-03f, 4.01087731e-01f, -3.50895435e-01f, -1.07602112e-01f, 3.59426051e-01f, -1.57417223e-01f, 7.50323460e-02f,
  3.42326611e-01f, -2.63870567e-01f, 6.93219155e-02f, -5.39491296e-01f, 3.30641985e-01f, 1.33676663e-01f, 3.53199849e-03f, 1.27869043e-02f, -3.82080317e-01f, 1.88739032e-01f,
  -2.64336526e-01f, -6.36999235e-02f, -3.65843713e-01f, -2.04824194e-01f, 3.89006324e-02f, 2.24660207e-02f, 1.16286449e-01f, -6.20776229e-02f, -2.56606579e-01f, 2.54895557e-02f,
  -1.78982437e-01f, 1.73398077e-01f, 1.80794030e-01f, 4.93696272e-01f, -6.41016886e-02f, -1.77560240e-01f, -2.58817136e-01f, -2.90494204e-01f, 5.16807958e-02f, 4.14389148e-02f,
  1.08106151e-01f, 4.09537017e-01f, 5.23208566e-02f, 1.80048853e-01f, 3.44453424e-01f, -2.14734763e-01f, 2.63610601e-01f, 2.86677152e-01f, -4.10359427e-02f, -1.67092994e-01f,
  -2.35486239e-01f, -7.24381506e-02f, 4.22506422e-01f, -1.37600347e-01f, -2.01824456e-01f, 4.68222201e-02f, 2.50662714e-01f, 1.52221501e-01f, 2.16419071e-01f, -7.80927688e-02f,
  -3.86033833e-01f, -8.95996988e-02f, -1.62415355e-01f, -2.31390178e-01f, 2.64468908e-01f, -5.48309088e-02f, 5.07289842e-02f, 1.51496246e-01f, -9.84003302e-04f, 2.55507976e-02f,
  2.35418081e-01f, 3.68183345e-01f, -4.75682020e-02f, 2.18394056e-01f, 1.97197616e-01f, -1.50136039e-01f, 1.39017865e-01f, -1.24868922e-01f, 3.14086825e-01f, 1.04684733e-01f,
  -1.75918460e-01f, 4.31200862e-02f, 1.41832262e-01f, 6.54943958e-02f, 1.17959619e-01f, -5.52134290e-02f, -3.87669563e-01f, -3.56067032e-01f, 5.14287353e-02f, -2.58829951e-01f,
  -1.14533827e-01f, -4.30583544e-02f, 2.22516119e-01f, 3.87150533e-02f, 2.98831403e-01f, -3.43495220e-01f, 1.99084342e-01f, 4.21903998e-01f, 2.49311119e-01f, 2.54846632e-01f,
  -7.65758008e-02f, 1.71632409e-01f, 2.45074078e-01f, -1.74740791e-01f, 1.93445072e-01f, -2.86899120e-01f, 5.97131364e-02f, 3.22526723e-01f, -3.53317797e-01f, 1.52523562e-01f,
  2.14912623e-01f, -8.08983371e-02f, 8.00256580e-02f, -3.21296036e-01f, 1.92085236e-01f, 2.32685074e-01f, 5.02965376e-02f, 7.41612688e-02f, 1.27150625e-01f, -3.03292900e-01f,
  -8.46178383e-02f, -2.86586791e-01f, 1.21935554e-01f, 3.32385488e-02f, 1.58292413e-01f, -2.31598794e-01f, -1.73215330e-01f, 2.46108964e-01f, 1.69111997e-01f, -1.25336573e-01f,
  -2.92900264e-01f, 2.75033563e-02f, 3.33410054e-01f, 3.06047857e-01f, -2.93439150e-01f, -1.61788672e-01f, 5.18753767e-01f, -7.69274682e-02f, 2.94960797e-01f, -1.36444539e-01f,
  2.26708025e-01f, 2.25381136e-01f, -4.22950208e-01f, -5.66389620e-01f, -3.33983570e-01f, 3.77866596e-01f, -3.18104565e-01f, 2.17757896e-01f, -4.43015695e-01f, 7.18493089e-02f,
  3.51746023e-01f, -6.76479861e-02f, -2.95856036e-02f, -8.33887011e-02f, 1.19989425e-01f, -6.45774007e-02f, -1.16882131e-01f, -1.29881412e-01f, 2.18886480e-01f, -2.78023511e-01f,
  -2.73553312e-01f, -1.59995332e-01f, -1.77509710e-01f, -1.19336113e-01f, 8.24698433e-03f, -2.08167452e-02f, -5.09737842e-02f, -1.46319652e-02f, -1.55592054e-01f, -2.06388503e-01f,
  -6.91053718e-02f, -7.56806135e-02f, -2.69114614e-01f, 7.80149996e-02f, 1.26654297e-01f, -2.12710366e-01f, -1.58995897e-01f, 4.21849117e-02f, -3.27911586e-01f, 2.25877538e-01f,
  3.17620933e-02f, -9.69503969e-02f, 1.57605603e-01f, 1.30333140e-01f, -1.72923729e-01f, -2.55730093e-01f, 3.17597389e-02f, 2.18245894e-01f, -1.77925393e-01f, 3.35857928e-01f,
  -9.18029994e-02f, -1.79426596e-01f, -4.60753798e-01f, 8.68947133e-02f, 2.29241952e-01f, -6.64500073e-02f, 9.52848792e-02f, -2.62651563e-01f, 4.15995628e-01f, 2.01978609e-01f,
  -1.71784103e-01f, -1.37906596e-01f, -3.12203020e-01f, 2.47615099e-01f, -4.23334152e-01f, -1.96435720e-01f, -1.17286816e-01f, 8.81484598e-02f, 1.03797816e-01f, -1.42962709e-01f,
  1.22999512e-01f, -6.68799952e-02f, 2.09389448e-01f, 7.79083893e-02f, -2.52017379e-01f, 4.63443458e-01f, -2.30381608e-01f, -6.06906638e-02f, -3.56911961e-03f, 5.51086925e-02f,
  6.96920305e-02f, 3.32360715e-01f, -3.20197165e-01f, 3.82937104e-01f, 3.94656807e-02f, -5.87147772e-01f, -3.64852548e-02f, 6.28458709e-02f, -2.24682108e-01f, -1.10733889e-01f,
  9.07858238e-02f, -3.71959180e-01f, 2.09198892e-02f, -3.58155146e-02f, -3.87788378e-02f, -1.43402060e-02f, -1.83451682e-01f, -2.62108326e-01f, 1.18788779e-01f, -5.13775414e-03f,
  -2.46067598e-01f, -9.69047323e-02f, -4.19192284e-01f, -1.78243533e-01f, 7.25529417e-02f, 2.08474159e-01f, 1.76335290e-01f, -9.17294025e-02f, -4.97808218e-01f, -3.41269791e-01f,
  -2.50815034e-01f, -1.67512715e-01f, -2.53788054e-01f, 1.93872496e-01f, 4.73121367e-02f, 2.32588395e-01f, 5.97609766e-03f, -3.89330328e-01f, -2.04271570e-01f, -1.59344040e-02f,
  -1.93223841e-02f, 3.74510378e-01f, -5.61682507e-02f, -2.35744074e-01f, 1.63687050e-01f, 5.09487912e-02f, -1.07318394e-01f, -1.90382436e-01f, -1.50606647e-01f, 1.74375549e-01f,
  -1.22391090e-01f, 5.11865765e-02f, -6.53511472e-03f, 5.11537045e-02f, -2.47515529e-01f, 7.39883482e-02f, -3.65635246e-01f, 3.19083482e-02f, -2.62177646e-01f, -2.31181160e-01f,
  2.43108541e-01f, -4.16784286e-02f, -6.21121638e-02f, 4.16353717e-03f, 3.58144015e-01f, 8.99958014e-02f, 3.47092718e-01f, -6.60345674e-01f, 3.67077477e-02f, 4.59845394e-01f,
  -6.81440383e-02f, 1.12745382e-01f, 2.60038733e-01f, 6.61930293e-02f, 2.98855267e-02f, 4.01388794e-01f, -2.77139902e-01f, 3.07549059e-01f, 6.64065480e-02f, -8.95337984e-02f,
  2.03031525e-01f, 1.86591730e-01f, -1.28183588e-01f, 1.63911000e-01f, 3.38954595e-03f, -8.92933086e-03f, -3.06237102e-01f, 1.59244090e-01f, 1.96022727e-02f, -1.44177884e-01f,
  -1.28988996e-01f, 1.12256430e-01f, -2.96437461e-03f, 1.41916037e-01f, 5.42984679e-02f, 1.22644141e-01f, 2.01225072e-01f, 2.08202183e-01f, -1.77354366e-01f, -2.80198511e-02f,
  -1.30245283e-01f, -2.06825007e-02f, -3.61139961e-02f, -1.34824947e-01f, -7.09670559e-02f, 8.18825811e-02f, 1.69242933e-01f, -3.10717434e-01f, -1.97608575e-01f, -2.62120247e-01f,
  -2.10893214e-01f, 1.70111015e-01f, -4.51012254e-01f, 4.12934363e-01f, 2.03230605e-01f, 8.97806659e-02f, 2.64657915e-01f, -3.35002124e-01f, 3.45888883e-01f, -1.50442123e-01f,
  8.32018554e-02f, 1.06957585e-01f, 4.72836941e-01f, 1.00375086e-01f, -1.04784854e-01f, -2.24074293e-02f, -8.82542059e-02f, 6.32081106e-02f, 9.10349190e-02f, 2.60517478e-01f,
  -2.28798971e-01f, 3.92681211e-01f, -3.17539096e-01f, -6.06070876e-01f, 1.08623356e-01f, 3.86216104e-01f, 8.03907663e-02f, 2.51994818e-01f, -6.86477572e-02f, 7.39400163e-02f,
  -1.48620494e-02f, 3.22538912e-01f, -5.23350202e-04f, 2.67788231e-01f, 3.87432396e-01f, 8.26399326e-02f, 2.00883046e-01f, 1.13383427e-01f, 1.29410282e-01f, 1.87881604e-01f,
  2.37811565e-01f, 3.70377183e-01f, 1.16044499e-01f, 9.76459756e-02f, 1.77286863e-01f, -9.30645466e-02f, 2.04098210e-01f, 2.69977480e-01f, 6.04995876e-05f, 6.57356307e-02f,
  -1.45764336e-01f, -7.99038559e-02f, -1.88026041e-01f, -7.79462233e-02f, 1.81448624e-01f, 1.28122836e-01f, -2.83178091e-01f, -1.06084049e-01f, -2.34208450e-01f, 1.14447556e-01f,
  -1.87230930e-01f, -1.53403208e-01f, -2.68925279e-01f, -2.29218245e-01f, 2.70870984e-01f, 2.91049451e-01f, 1.31401405e-01f, 3.51011157e-01f, 2.28366047e-01f, 1.29106855e-02f,
  -2.61780649e-01f, -6.90588206e-02f, -1.18962392e-01f, 1.35610595e-01f, 2.76940793e-01f, -3.29269581e-02f, 8.15102756e-02f, 2.43153200e-02f, -9.83926579e-02f, 8.05034414e-02f,
  -4.10644114e-02f, -1.94577575e-01f, -1.52787670e-01f, -2.68782914e-01f, 5.31669222e-02f, 3.62055987e-01f, 5.92282116e-02f, -4.01524268e-02f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  2.16573868e-02f, -1.12544499e-01f, 3.93700525e-02f, -1.18870050e-01f, -3.37525867e-02f, 1.18399590e-01f, -5.40694594e-02f, 2.18945086e-01f, 7.37812892e-02f, -1.24355510e-01f,
  -1.51335765e-02f, -1.06093995e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    