/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.37590778e-02f, 2.31112108e-01f, -1.94765672e-01f, -1.81353927e-01f, -2.02196747e-01f, -1.07648805e-01f, 8.14695656e-02f, 1.10444643e-01f, -4.99994159e-02f, 1.61207691e-01f,
  1.15467384e-01f, 4.55919318e-02f, 1.01991817e-01f, 1.71519388e-02f, 5.83470166e-02f, -4.64585945e-02f, -2.44919494e-01f, -2.79639274e-01f, -1.86645597e-01f, -1.00614339e-01f,
  -1.04754999e-01f, -1.50325313e-01f, -1.40344873e-01f, -1.73994318e-01f, -3.40949715e-04f, -1.81256667e-01f, -1.30157396e-01f, -1.06997803e-01f, -2.07638651e-01f, -1.10585541e-01f,
  -6.36404604e-02f, 9.95643213e-02f, -1.17593937e-01f, -6.81786016e-02f, -1.70278978e-02f, 6.13474883e-02f, -2.27612518e-02f, 3.20869125e-02f, -2.03777570e-03f, 1.05388299e-01f,
  -3.83431502e-02f, -6.88356683e-02f, 5.77941202e-02f, 4.76239249e-02f, -3.99537161e-02f, -5.21205785e-03f, 3.03164814e-02f, 1.39795495e-02f, -6.14214223e-03f, 7.13307261e-02f,
  1.27527401e-01f, -2.49982048e-02f, 2.94195376e-02f, 7.52172694e-02f, 5.96031658e-02f, -1.44365311e-01f, 1.09590432e-02f, 1.39719080e-02f, -6.86905906e-02f, 6.69658706e-02f,
  4.30653282e-02f, 3.07917651e-02f, 1.26030579e-01f, 8.99087489e-02f, 8.14496428e-02f, 3.31706628e-02f, 4.09770682e-02f, 6.72298744e-02f, 7.85646588e-03f, 1.58632278e-01f,
  1.21182844e-01f, 1.43961146e-01f, 4.83218431e-02f, 1.39996290e-01f, 2.48872899e-02f, 6.00987151e-02f, 2.77730413e-02f, 1.71142250e-01f, 1.13164023e-01f, 1.13952115e-01f,
  7.79436529e-02f, 2.25309450e-02f, 6.63907379e-02f, 1.00777782e-01f, 1.23558439e-01f, 5.70455380e-02f, 1.02695033e-01f, 9.33120251e-02f, 8.01923499e-02f, 7.35019073e-02f,
  1.40235974e-02f, -1.75651863e-01f, 2.38618199e-02f, 5.98360002e-02f, -3.28693539e-02f, 1.76286567e-02f, -3.54435667e-02f, 9.02682822e-03f, -1.86345093e-02f, -5.56282513e-03f,
  -2.08490510e-02f, 5.33919223e-02f, -4.44735810e-02f, -4.42164093e-02f, 2.30379887e-02f, 5.93479490e-03f, 4.20799069e-02f, -8.42344388e-02f, 4.38565053e-02f, -2.65574642e-02f,
  6.65228888e-02f, -1.47904912e-02f, -1.14560522e-01f, -5.76150343e-02f, 4.06548642e-02f, -4.69705984e-02f, 2.06255354e-02f, -9.82526392e-02f, -9.82800871e-02f, 3.75594199e-03f,
  1.76951528e-01f, -1.24231949e-01f, 5.08342460e-02f, 1.18399188e-01f, 7.71019906e-02f, -2.77847033e-02f, -3.45430784e-02f, 1.84095539e-02f, 8.91892463e-02f, -3.13107967e-02f,
  1.21872686e-01f, 3.30770642e-01f, 2.27068529e-01f, 2.10030928e-01f, 2.58685857e-01f, 1.10154487e-01f, 7.77272508e-02f, 3.33446443e-01f, 1.81207269e-01f, 6.77627623e-02f,
  1.41416183e-02f, 1.78522110e-01f, 1.94767848e-01f, 1.01755790e-01f, -1.18109025e-02f, 5.56255244e-02f, 6.04945049e-02f, 1.33782849e-01f, -1.80366766e-02f, 1.02302745e-01f,
  8.07589069e-02f, -4.72474210e-02f, 3.78471985e-02f, 1.19919367e-01f, 9.06238258e-02f, 9.14605055e-03f, 5.99863939e-02f, 1.87588036e-02f, 7.99608678e-02f, -4.55899127e-02f,
  3.45027074e-02f, 7.51451626e-02f, -4.20246599e-03f, 8.59295204e-03f, 7.44157284e-03f, 8.44007265e-03f, 4.35832776e-02f, 1.42412990e-01f, 1.83952436e-01f, 1.47785813e-01f,
  5.79337962e-03f, -4.46914025e-02f, -1.93454027e-02f, 9.35526274e-04f, 4.04013433e-02f, 1.59301043e-01f, -2.20907908e-02f, -7.88611472e-02f, -3.50229517e-02f, -8.13929960e-02f,
  -1.55650437e-01f, 1.27795026e-01f, 9.73830223e-02f, 5.82861416e-02f, -2.08753236e-02f, 3.79644409e-02f, 1.28290191e-01f, 7.16556758e-02f, -5.21687157e-02f, -1.92581173e-02f,
  9.56232846e-02f, 9.78825334e-03f, 1.32182077e-01f, -1.50922942e-03f, 3.53066325e-02f, -2.75795031e-02f, 1.05347738e-01f, -4.94757551e-05f, -3.49395089e-02f, 1.03350796e-01f,
  7.87237808e-02f, -1.43231992e-02f, 5.58835873e-03f, 6.17395155e-02f, 3.36956531e-02f, 9.83737856e-02f, 9.02440697e-02f, 2.18199566e-02f, 1.25018537e-01f, 5.01448065e-02f,
  3.13542709e-02f, 1.19976521e-01f, 8.10310170e-02f, 9.33418348e-02f, 1.67411212e-02f, 1.06968619e-01f, 3.61423343e-02f, 1.27122268e-01f, 1.44264534e-01f, 6.55315593e-02f,
  2.35062521e-02f, 4.23342809e-02f, 1.15337215e-01f, 5.08651137e-02f, 2.29469165e-02f, 8.48260149e-02f, -2.30615363e-02f, 1.09073535e-01f, 8.16735849e-02f, -1.23516396e-02f,
  3.16652581e-02f, 1.92719232e-02f, -3.14242505e-02f, -8.07791278e-02f, 6.13706047e-03f, 1.36783421e-02f, 3.94666195e-02f, -8.83350074e-02f, -5.15700318e-02f, -1.49272516e-01f,
  -4.69311178e-01f, 1.71868816e-01f, -7.72048607e-02f, -1.83330715e-01f, -1.22313999e-01f, -1.31739467e-01f, -1.30952969e-01f, -1.80387735e-01f, -1.59224659e-01f, -5.82150444e-02f,
  1.08211078e-02f, -1.52802411e-02f, -2.36172732e-02f, -1.06815755e-01f, -1.30216092e-01f, -1.71018958e-01f, -5.14958203e-02f, -1.56292960e-01f, -1.17018782e-01f, -1.14907801e-01f,
  1.78109426e-02f, -1.96522884e-02f, -1.42086416e-01f, -1.20700344e-01f, -1.72373578e-02f, 7.91121460e-03f, -2.67935777e-03f, -7.04939216e-02f, 1.05853252e-01f, 1.37139603e-01f,
  4.87256385e-02f, -8.57151598e-02f, -1.69436887e-01f, -2.14576852e-02f, 5.81220649e-02f, 1.65398587e-02f, -1.16998486e-01f, -9.64583308e-02f, 7.40959367e-04f, 3.24519165e-02f,
  -2.60684565e-02f, -4.60441522e-02f, -1.45057857e-01f, -5.30072376e-02f, -2.73299050e-02f, -3.40718068e-02f, -3.50646041e-02f, -1.41696492e-02f, 4.33692932e-02f, 5.01553938e-02f,
  4.34462652e-02f, -5.13891801e-02f, -4.95628715e-02f, -1.21989608e-01f, -1.61857568e-02f, -5.14349788e-02f, 7.21903294e-02f, -3.51636149e-02f, -1.08991340e-01f, -2.06585005e-02f,
  2.42033415e-02f, 1.34976460e-02f, 9.05192271e-02f, 1.02276281e-02f, 1.23572737e-01f, -6.12495933e-03f, -1.15051791e-02f, 2.49531888e-03f, 9.86800119e-02f, 4.80927601e-02f,
  7.49312267e-02f, 9.46883559e-02f, 7.56464973e-02f, -8.21951106e-02f, 7.03171492e-02f, 1.87056065e-02f, 2.59133596e-02f, 4.57862131e-02f, 2.00029127e-02f, 6.49070591e-02f,
  -2.59218700e-02f, 7.37715438e-02f, 7.50684887e-02f, 6.47496879e-02f, 1.00748226e-01f, -8.51148516e-02f, 3.17270006e-03f, 6.24753200e-02f, 4.38727140e-02f, 9.70379189e-02f,
  -3.03492565e-02f, -1.68789327e-02f, 8.80395062e-03f, -6.36862591e-03f, 5.33821573e-03f, -3.12324669e-02f, 9.69027728e-03f, 6.17958456e-02f, -7.50830099e-02f, -1.09976090e-01f,
  -1.34226652e-02f, -1.28453165e-01f, -8.73346031e-02f, 4.82797176e-02f, -3.70462164e-02f, 1.02570131e-02f, 2.71626748e-03f, -1.62558377e-01f, -7.82056004e-02f, 9.16862413e-02f,
  -9.34357569e-02f, -7.01179579e-02f, -2.27921292e-01f, -1.12792067e-01f, -1.39921874e-01f, -1.64057747e-01f, -1.06421128e-01f, -1.10697909e-03f, -1.41193673e-01f, -7.51390755e-02f,
  -1.87178493e-01f, -1.61935791e-01f, 9.55158472e-02f, 1.19736329e-01f, 1.02655202e-01f, 1.36642173e-01f, 5.60173839e-02f, 2.49016173e-02f, 1.36462718e-01f, 1.02341868e-01f,
  -9.26996544e-02f, 1.48214800e-02f, -9.19752382e-03f, 1.73180461e-01f, 1.50815353e-01f, 2.70738006e-01f, 2.82801181e-01f, 1.99321851e-01f, 1.33447662e-01f, 1.14050910e-01f,
  1.48757502e-01f, 1.52684078e-01f, 8.27226937e-02f, 1.82487786e-01f, 1.23025082e-01f, 3.72090079e-02f, 5.63390441e-02f, 1.10771395e-01f, 1.55667320e-01f, 1.18797921e-01f,
  1.45314261e-03f, -1.25048876e-01f, -9.07671731e-03f, 2.24000681e-02f, 5.28832823e-02f, -1.37317508e-01f, 1.62466764e-02f, -3.68184894e-02f, 2.24139821e-02f, 6.66869953e-02f,
  3.89667340e-02f, 3.58450711e-02f, 5.01523688e-02f, -6.99185804e-02f, -1.91513188e-02f, 6.71220059e-03f, 1.77941006e-02f, 2.60192864e-02f, 1.28757834e-01f, -9.86219794e-02f,
  -1.96971837e-03f, 5.98786920e-02f, -5.63985966e-02f, 7.97815621e-02f, -1.93003099e-03f, 1.77130345e-02f, 4.35839817e-02f, -2.72634085e-02f, -2.63227094e-02f, 9.08051431e-02f,
  5.37065454e-02f, 1.11771241e-01f, 2.05381382e-02f, 7.39057511e-02f, 4.85985056e-02f, 5.36436439e-02f, 7.29913637e-02f, 1.06325775e-01f, 8.79745185e-02f, 4.77337129e-02f,
  4.78160046e-02f, 1.08501144e-01f, 4.53713387e-02f, 9.79435369e-02f, 1.12467118e-01f, 2.97439303e-02f, 2.19292968e-04f, 5.08586355e-02f, 7.95300156e-02f, 8.13109148e-03f,
  5.53200692e-02f, 1.12677276e-01f, 4.47978042e-02f, 1.09360062e-01f, 2.20917650e-02f, 9.27472636e-02f, 5.67757711e-02f, 6.52584359e-02f, 3.05383150e-02f, 7.03371763e-02f,
  -8.99344608e-02f, -9.38223898e-02f, -6.70818891e-03f, -1.58814751e-02f, 5.91363460e-02f, -1.24782123e-01f, -4.45364267e-02f, -6.60301521e-02f, -1.27069950e-01f, -1.12142228e-01f,
  7.20108114e-03f, -1.24670133e-01f, -4.58720289e-02f, -3.99398319e-02f, 2.49582641e-02f, 4.62593995e-02f, 2.14021783e-02f, 4.99481000e-02f, 2.03874633e-02f, -2.83059124e-02f,
  -5.37963063e-02f, 5.74561656e-02f, 1.13501279e-02f, 4.25897092e-02f, -2.17458680e-02f, -8.22775885e-02f, 5.24937175e-02f, -1.77298356e-02f, 3.38800298e-03f, 1.74201485e-02f,
  -3.13501239e-01f, -6.65854961e-02f, -1.06828667e-01f, 3.32418308e-02f, -2.93267090e-02f, -3.95298377e-02f, -8.11680630e-02f, 1.22131314e-02f, -2.89827082e-02f, 6.76017255e-02f,
  5.99747943e-03f, 8.95881504e-02f, 4.52936999e-02f, -4.79363948e-02f, -4.78394739e-02f, -1.21512927e-01f, 8.39413926e-02f, -6.46673366e-02f, -6.92365766e-02f, 2.16934010e-02f,
  9.31848064e-02f, 5.49782738e-02f, 3.98411527e-02f, 9.79848653e-02f, 9.01071727e-02f, 6.98656440e-02f, 1.72361080e-02f, 1.18372306e-01f, -5.23646595e-03f, 7.30256587e-02f,
  -2.52458841e-01f, 4.21890430e-02f, -6.10041097e-02f, 1.39030663e-03f, 2.86847260e-02f, 2.63095065e-03f, 6.11019135e-02f, 7.71274269e-02f, 6.89150468e-02f, 1.63388811e-02f,
  6.10348172e-02f, 6.60997629e-02f, 4.49224887e-03f, 1.44786425e-02f, -5.60005866e-02f, -3.62148210e-02f, 6.29786626e-02f, 8.86504054e-02f, -2.36978233e-02f, 2.59780278e-03f,
  9.27897692e-02f, -4.07758243e-02f, 2.43007317e-02f, -3.05651892e-02f, -5.78372329e-02f, -5.92430234e-02f, 1.21782264e-02f, -4.41870205e-02f, -2.03901660e-02f, -1.14215598e-01f,
  -4.33974788e-02f, 4.23841970e-03f, 4.35702950e-02f, -1.30975135e-02f, -1.34839239e-02f, 6.89733699e-02f, 2.03658286e-02f, 3.75928096e-02f, 4.21248563e-02f, -1.05002150e-02f,
  -1.38906548e-02f, 2.27529760e-02f, -4.30400521e-02f, 8.58827773e-03f, 2.87210103e-02f, -5.43579496e-02f, -1.25499321e-02f, 5.40828109e-02f, 1.04526833e-01f, 1.97046380e-02f,
  2.38036830e-03f, 8.40561986e-02f, 9.16519612e-02f, -3.18561884e-04f, 6.01584464e-02f, 8.42832699e-02f, 5.33299446e-02f, 1.11104205e-01f, 2.92469072e-03f, 8.46922398e-02f,
  -1.17888890e-01f, 2.36201156e-02f, -8.87109339e-02f, 1.23365195e-02f, -2.42348947e-02f, -5.99558167e-02f, -4.33145091e-02f, 3.13410014e-02f, -5.71055003e-02f, 1.24841854e-02f,
  4.66260947e-02f, -6.57027587e-02f, 7.05598742e-02f, -5.48031516e-02f, -7.32322037e-02f, -1.19939595e-01f, 3.91155407e-02f, 3.32185254e-02f, -9.69889984e-02f, -4.00792174e-02f,
  2.62858067e-02f, -1.01109572e-01f, -2.24031702e-01f, -1.17208391e-01f, -1.51024796e-02f, -2.14782119e-01f, -6.03593662e-02f, -1.23625606e-01f, -2.07599983e-01f, -1.24590039e-01f,
  -1.39055908e-01f, 2.66022354e-01f, 2.89846122e-01f, -5.33116907e-02f, 2.12142453e-01f, 2.58144975e-01f, 3.30780447e-01f, 2.20002577e-01f, 1.48521036e-01f, 2.05946237e-01f,
  2.58365065e-01f, 1.23987243e-01f, 1.62327603e-01f, 2.26638228e-01f, 1.33570537e-01f, 3.34550887e-01f, 2.48798534e-01f, 1.50135746e-02f, -1.79839227e-02f, -3.82566787e-02f,
  4.85033765e-02f, -7.35627562e-02f, -6.16036355e-02f, -3.43143311e-03f, 3.16464305e-02f, -1.21270660e-02f, 1.02382459e-01f, 6.97778463e-02f, 2.15818390e-01f, 1.22873520e-03f,
  3.08413178e-01f, 1.86210901e-01f, 2.58276820e-01f, 1.40148163e-01f, 2.85425246e-01f, 1.79919362e-01f, 1.99594274e-01f, 2.94343740e-01f, 1.88501596e-01f, 3.49485993e-01f,
  2.25880131e-01f, 2.98010141e-01f, 1.86121315e-01f, 2.96256870e-01f, 2.88727820e-01f, 2.69021213e-01f, 2.96664923e-01f, 1.02516048e-01f, 2.00018361e-01f, 3.27527434e-01f,
  2.92714834e-01f, 2.02765062e-01f, 3.16870093e-01f, 2.53547013e-01f, 2.21848294e-01f, 1.84160531e-01f, 3.06731164e-01f, 2.71584064e-01f, 2.17068091e-01f, 2.40506634e-01f,
  -6.05947189e-02f, -1.31703779e-01f, -9.84112695e-02f, -1.41476688e-03f, -1.14618398e-01f, -8.96875858e-02f, -4.02884781e-02f, -9.80666503e-02f, -9.67086926e-02f, -2.32195370e-02f,
  -2.91451029e-02f, -5.98810241e-02f, -9.43816751e-02f, -6.11154130e-03f, -5.03876470e-02f, -7.34750330e-02f, -5.89578152e-02f, 3.04138381e-03f, -4.78015430e-02f, -8.43671039e-02f,
  -3.41114067e-02f, -1.10896818e-01f, -1.30798295e-01f, -4.78597581e-02f, -1.02157280e-01f, -3.06438394e-02f, -2.55794674e-02f, -1.11733600e-01f, -4.97849248e-02f, -1.31749511e-01f,
  1.40118137e-01f, 2.62287259e-01f, 1.98668271e-01f, 1.31330371e-01f, 1.71401098e-01f, 2.11717963e-01f, 2.04104990e-01f, 1.75039113e-01f, 2.29593992e-01f, 2.29340658e-01f,
  1.58900872e-01f, 1.42514035e-01f, 2.80565441e-01f, 1.36075392e-01f, 1.19934328e-01f, 2.22765595e-01f, 2.51115441e-01f, 1.74162164e-01f, 1.70343682e-01f, 2.88533241e-01f,
  2.74150401e-01f, 2.50006348e-01f, 2.40910903e-01f, 3.22072864e-01f, 1.72812372e-01f, 1.42266527e-01f, 3.11912119e-01f, 3.14578921e-01f, 2.89851815e-01f, 3.28975171e-01f,
  1.74579583e-02f, -2.39739940e-01f, -7.19385669e-02f, -2.28467807e-01f, -2.05857605e-01f, -5.44499122e-02f, -1.03400178e-01f, -1.23575591e-01f, -1.02947533e-01f, -5.84059283e-02f,
  -5.37957847e-02f, 3.62056494e-02f, -3.68189700e-02f, -9.42879468e-02f, 1.64777748e-02f, -1.79368407e-01f, -1.39979169e-01f, 2.06148960e-02f, 5.06023467e-02f, -1.41337052e-01f,
  -1.89083386e-02f, 2.24687904e-02f, 6.63742563e-03f, -7.68612474e-02f, -1.62669480e-01f, 2.87519721e-03f, -1.40622044e-02f, -7.16133192e-02f, -7.41698667e-02f, -1.10411324e-01f,
  -1.81114867e-01f, 1.71475895e-02f, 1.18968345e-01f, 2.18150377e-01f, 2.10541263e-02f, 9.17052403e-02f, 1.27320644e-02f, 1.65301040e-01f, 1.77588806e-01f, 2.50408873e-02f,
  6.62588626e-02f, 7.11658150e-02f, 1.76697485e-02f, 2.26389430e-02f, 1.00419134e-01f, 3.12462673e-02f, 1.45104975e-01f, 6.47517964e-02f, 8.47706497e-02f, 3.86665054e-02f,
  -2.46359548e-03f, 9.66760665e-02f, 1.88891873e-01f, 1.39322951e-01f, 5.49391992e-02f, 1.94929749e-01f, 1.59876049e-02f, 9.24888551e-02f, 7.44636506e-02f, 1.22185521e-01f,
  7.24433810e-02f, -7.54018500e-02f, -1.64073296e-02f, -2.95733511e-02f, -1.19122967e-01f, -2.42539905e-02f, -1.89911261e-01f, -1.39364883e-01f, -8.56472179e-02f, -9.14463177e-02f,
  -1.82441756e-01f, -1.38549492e-01f, -7.00095966e-02f, -1.77912518e-01f, -1.48530126e-01f, -7.54294246e-02f, -1.68345526e-01f, -8.55728760e-02f, -1.15115523e-01f, -2.82512102e-02f,
  -1.21593520e-01f, -1.11078136e-01f, -8.69413614e-02f, -8.38349462e-02f, -1.61339059e-01f, -1.45451933e-01f, -1.17706366e-01f, -6.83259219e-02f, -1.93773210e-01f, -1.42239958e-01f,
  2.63399221e-02f, 2.31424302e-01f, 1.09552499e-02f, 4.89119887e-02f, 8.60305876e-02f, 1.24160998e-01f, 8.11058879e-02f, 9.05724466e-02f, 9.65026394e-02f, 5.34288958e-03f,
  1.45888822e-02f, -1.86725272e-04f, -3.35931638e-03f, 1.21684387e-01f, 6.58528553e-03f, 1.42177165e-01f, 1.24217935e-01f, 3.77294198e-02f, 6.94854632e-02f, 9.98247713e-02f,
  5.82983680e-02f, 1.73956037e-01f, 7.15475902e-02f, 1.16435461e-01f, 8.14456642e-02f, 1.10654801e-01f, 1.50719419e-01f, 4.33575101e-02f, 1.75182626e-01f, 1.45367533e-01f,
  9.08635184e-02f, 2.15800285e-01f, 3.27281237e-01f, 1.27195716e-01f, 2.31457844e-01f, -2.07860768e-02f, 1.73862521e-02f, -2.74211485e-02f, 4.17337976e-02f, 3.27695394e-03f,
  1.02346897e-01f, -5.54711074e-02f, -3.74570787e-02f, -8.40832964e-02f, -2.30137065e-01f, -5.14929518e-02f, 1.40391752e-01f, 3.29275653e-02f, -5.81681281e-02f, -1.19893759e-01f,
  -4.20057308e-03f, 6.23853318e-02f, 8.33295509e-02f, -4.40945179e-04f, 1.68406218e-01f, 1.07056089e-02f, 2.14961514e-01f, 1.39554039e-01f, 5.33010848e-02f, 2.30477214e-01f,
  5.98750524e-02f, 5.49034141e-02f, -1.08675785e-01f, -9.55833495e-02f, 9.74615514e-02f, -7.09671807e-03f, -1.66789815e-02f, 1.37165654e-02f, 1.48831820e-02f, -1.90560892e-02f,
  5.80690615e-02f, -8.27274024e-02f, -3.50202844e-02f, 5.10756448e-02f, 7.89906532e-02f, 4.42045256e-02f, -2.23248862e-02f, -3.24851945e-02f, 6.49696141e-02f, -7.64137432e-02f,
  3.80118899e-02f, 7.67785311e-02f, 6.11049794e-02f, -3.27822454e-02f, -1.04057626e-03f, -4.79401164e-02f, 1.05781727e-01f, 6.04620911e-02f, -5.40060699e-02f, -5.38978279e-02f,
  1.75145790e-02f, 8.32819715e-02f, -9.75196774e-04f, 1.13611817e-01f, -4.71545793e-02f, 5.63989282e-02f, 7.55756795e-02f, 3.55877094e-02f, 2.58190744e-02f, 1.11928642e-01f,
  -8.17509592e-02f, -2.55425600e-03f, 1.05897740e-01f, -6.03468809e-03f, 5.25004305e-02f, 1.18999042e-01f, -2.74494872e-03f, 6.44612759e-02f, 8.00986066e-02f, 2.40997188e-02f,
  7.14761913e-02f, -3.06660216e-03f, 4.86600911e-03f, 1.86691545e-02f, -7.43899122e-02f, 5.59774451e-02f, -6.27775816e-03f, -6.15767762e-03f, 1.21502906e-01f, 1.69050135e-02f,
  -1.88078750e-02f, -4.55946550e-02f, -4.60113958e-02f, -1.49922639e-01f, -1.66608039e-02f, -6.15184307e-02f, -3.81802581e-02f, -9.47933644e-02f, 4.82657254e-02f, 3.37024443e-02f,
  -8.73247385e-02f, -4.77714352e-02f, -4.49250154e-02f, -1.35362327e-01f, -2.76837386e-02f, -2.35799756e-02f, -6.19032085e-02f, -2.02522124e-03f, -1.06060088e-01f, 7.34377801e-02f,
  -2.41623800e-02f, 8.36927220e-02f, 9.14455503e-02f, 2.34071780e-02f, -1.72124617e-02f, -3.39438096e-02f, -9.18946266e-02f, -8.58292878e-02f, 1.70279667e-02f, -1.12172283e-01f,
  6.13254011e-02f, -4.80965152e-02f, 2.06989780e-01f, -2.47134138e-02f, -4.22892235e-02f, -7.23129809e-02f, -9.99399722e-02f, -4.25863974e-02f, -9.24457423e-03f, -6.63801059e-02f,
  -1.16955355e-01f, 7.02000130e-03f, 6.04828633e-02f, 1.51688740e-01f, 1.69867709e-01f, 2.02491000e-01f, 2.47757047e-01f, 1.69241235e-01f, 4.49441783e-02f, 8.95127654e-02f,
  8.91942978e-02f, 8.00917819e-02f, 1.53789788e-01f, 9.42466855e-02f, 4.41485457e-02f, 7.76466876e-02f, 1.46931812e-01f, 1.83145300e-01f, 1.65348291e-01f, 2.35703245e-01f,
  6.92000836e-02f, 3.45152915e-02f, -1.74447834e-01f, -8.77754688e-02f, -8.12010467e-02f, -8.32834244e-02f, -1.30366459e-01f, -4.42182757e-02f, -5.51722609e-02f, -4.80321385e-02f,
  -2.87560970e-02f, -1.74313392e-02f, -5.83644249e-02f, 5.01761101e-02f, -2.84415521e-02f, 4.03245911e-02f, -4.33090376e-03f, 8.27185288e-02f, -7.64272884e-02f, 2.70118262e-03f,
  -6.44847080e-02f, -5.59002301e-03f, 3.11065353e-02f, 9.11934115e-03f, 2.22106967e-02f, -1.09600529e-01f, -7.67167062e-02f, -4.26889956e-02f, -1.69898272e-02f, -4.12038937e-02f,
  8.78188387e-02f, -1.42650716e-02f, 1.62318368e-02f, 3.16635855e-02f, -8.99498537e-02f, -1.23286084e-03f, -5.27379364e-02f, -1.06962398e-02f, 1.15190409e-02f, -3.15736677e-03f,
  -8.87888893e-02f, -3.12364418e-02f, -2.94247847e-02f, 3.05394139e-02f, -7.04598241e-03f, -2.88058687e-02f, -1.65005773e-02f, -1.62954070e-02f, -2.19770577e-02f, -6.93227649e-02f,
  -3.76492962e-02f, -5.69112934e-02f, -9.29724146e-03f, -2.85345037e-02f, 7.35582858e-02f, -5.24917319e-02f, -3.34756002e-02f, -6.24432042e-02f, -3.80804166e-02f, -5.14823683e-02f,
  -1.19273119e-01f, -6.00267276e-02f, -1.35487154e-01f, -4.10794392e-02f, 5.40081635e-02f, -4.36310507e-02f, -5.18900119e-02f, -4.92005758e-02f, -7.27514597e-03f, -7.36686122e-03f,
  -1.07334919e-01f, -5.55089340e-02f, -9.89210531e-02f, 2.94856895e-02f, 1.40612759e-02f, -8.39550141e-03f, -1.06686600e-01f, -2.29009204e-02f, -2.28970945e-02f, -4.13960293e-02f,
  -1.30712733e-01f, -7.98835680e-02f, -9.00538117e-02f, -1.96184263e-01f, -5.68248145e-02f, -1.30300134e-01f, -8.60860348e-02f, -8.83103460e-02f, -3.17556597e-02f, -1.37006611e-01f,
  -1.25335336e-01f, -2.20892817e-01f, -2.71342725e-01f, -3.39926071e-02f, -1.39673084e-01f, -3.06399643e-01f, -2.98510849e-01f, -1.60384342e-01f, -3.43958773e-02f, -1.25086665e-01f,
  -9.05904993e-02f, 1.85374230e-01f, -2.32666489e-02f, -1.41609469e-02f, -7.22924918e-02f, -3.20781499e-01f, -1.12225987e-01f, -1.53165963e-02f, 9.37218815e-02f, 6.76706880e-02f,
  -3.20538916e-02f, 7.83243030e-02f, 3.14026475e-02f, -4.28996868e-02f, 1.61028616e-02f, 1.28130570e-01f, -1.65530577e-01f, 1.45797972e-02f, -3.29191722e-02f, -4.67427969e-02f,
  8.50106850e-02f, -2.91206092e-01f, -5.36637418e-02f, -1.49469581e-02f, -1.34318754e-01f, -4.89781890e-03f, -5.33705093e-02f, -1.30141541e-01f, -1.72403708e-01f, -1.44424170e-01f,
  -6.00328781e-02f, -1.81376305e-03f, -8.26645643e-02f, -2.72959797e-03f, -8.85082260e-02f, -7.20631182e-02f, -7.49625117e-02f, -1.18509635e-01f, -1.12045929e-01f, -8.49451572e-02f,
  -3.47506404e-02f, -9.82913375e-02f, -2.84118861e-01f, -2.00840890e-01f, -2.10120112e-01f, -2.14909781e-02f, -1.88819095e-01f, -2.00004652e-01f, -7.46825933e-02f, -1.04985749e-02f,
  -1.32327452e-02f, 3.16958688e-02f, 2.15904973e-02f, 5.66130951e-02f, -2.52033975e-02f, 5.16222091e-03f, 8.93841907e-02f, -1.73850618e-02f, 5.29439002e-03f, 7.55351484e-02f,
  2.18046438e-02f, 4.37198095e-02f, -5.93764894e-02f, -5.14599606e-02f, 8.52644593e-02f, 1.61592010e-02f, 4.91709560e-02f, 2.43114941e-02f, 9.72463414e-02f, -1.10660037e-02f,
  2.61109006e-02f, -3.38792242e-02f, 6.39693290e-02f, 2.05672346e-02f, -5.75551838e-02f, 9.00726579e-03f, 1.04354620e-02f, 5.74275181e-02f, 9.09469277e-02f, -4.66366820e-02f,
  1.81523323e-01f, -9.66349542e-02f, -8.84751081e-02f, -2.19498072e-02f, -1.21407650e-01f, -7.55777955e-02f, -1.65360365e-02f, -9.24045444e-02f, -5.65263852e-02f, -7.30617568e-02f,
  -4.62535359e-02f, -3.84343159e-03f, -2.69009583e-02f, -1.14890382e-01f, 3.92189734e-02f, -8.46180394e-02f, -2.64862855e-03f, 3.32038291e-02f, -1.62428871e-01f, -1.17453955e-01f,
  -8.76016393e-02f, -2.48711050e-01f, -3.56201865e-02f, -9.94188711e-02f, -9.08456743e-02f, 4.14646380e-02f, -5.83222471e-02f, -7.90707320e-02f, -9.86515433e-02f, -1.24467328e-01f,
  -3.39724571e-01f, -3.83277833e-01f, -6.11197762e-02f, 1.67464856e-02f, 5.36376722e-02f, -9.29360744e-04f, -7.28003085e-02f, -1.55116588e-01f, -1.46937117e-01f, -2.10795999e-01f,
  -1.94981650e-01f, 6.82604406e-03f, 4.35832329e-02f, -2.31827255e-02f, -1.01389445e-01f, -1.77201509e-01f, -7.71413967e-02f, 7.93122053e-02f, 7.10507631e-02f, -8.85639526e-03f,
  -8.55895691e-03f, -8.08583647e-02f, -1.62157744e-01f, -6.91761225e-02f, -2.14287713e-01f, -1.10827833e-01f, -1.86287880e-01f, -2.09706873e-01f, -2.86986262e-01f, -1.97586179e-01f,
  -3.50784898e-01f, -3.96435708e-01f, 6.68584928e-03f, -9.85624865e-02f, -7.95851797e-02f, -2.11980641e-01f, -8.37268457e-02f, -8.88535678e-02f, -1.15693979e-01f, -2.35454053e-01f,
  -4.07770723e-02f, -4.98877279e-02f, -2.40161326e-02f, -1.58796474e-01f, -1.09542213e-01f, -1.46783680e-01f, -1.38797119e-01f, -8.74982029e-02f, -9.55614001e-02f, -2.47046351e-01f,
  -9.64575559e-02f, -1.61743402e-01f, -1.43893257e-01f, -1.78816572e-01f, -1.74241766e-01f, -8.43345225e-02f, -2.07587138e-01f, -2.19158992e-01f, -1.22791387e-01f, -2.54708439e-01f,
  8.12482163e-02f, 1.38443425e-01f, 1.29637629e-01f, 1.35395914e-01f, 1.39127567e-01f, 1.20172113e-01f, 9.09879357e-02f, 4.26108092e-02f, 1.42453209e-01f, 1.42063901e-01f,
  4.74833809e-02f, 8.53064433e-02f, 1.58082426e-01f, 5.40936813e-02f, 1.64902315e-01f, 6.48060068e-02f, 1.22257717e-01f, 8.96474421e-02f, 5.11234999e-02f, 1.05440535e-01f,
  4.78584394e-02f, 1.55170575e-01f, 1.79662272e-01f, 1.36128902e-01f, 7.95052052e-02f, 1.68815687e-01f, 1.20003663e-01f, 9.34579894e-02f, 1.54327571e-01f, 8.88872296e-02f,
  -1.47875457e-03f, 7.63092190e-02f, -2.24627510e-01f, -1.33432329e-01f, -1.71041369e-01f, -1.26013413e-01f, -1.87222257e-01f, -1.51395530e-01f, -6.70798793e-02f, -1.62817165e-01f,
  -1.07397564e-01f, -1.24264888e-01f, -1.95767209e-01f, -1.03492029e-01f, -9.08968672e-02f, -1.90315843e-01f, -7.51891732e-02f, -6.69965670e-02f, -4.63633314e-02f, -1.45825952e-01f,
  -1.84198946e-01f, -5.48598394e-02f, -8.00672919e-02f, -1.33815572e-01f, -1.13709822e-01f, -3.52089070e-02f, -5.85195869e-02f, -1.07870258e-01f, -1.67487990e-02f, -1.45328417e-01f,
  -1.93132326e-01f, 1.60349742e-01f, 1.19108506e-01f, 1.00560598e-02f, 5.38432598e-02f, 2.02498138e-01f, 1.17870212e-01f, 4.30252068e-02f, -2.24925345e-04f, -2.10587978e-02f,
  -3.97958234e-02f, -2.35253796e-01f, -3.26515555e-01f, -3.17512751e-01f, -1.57077029e-01f, -4.20799367e-02f, 5.48387766e-02f, -3.12819093e-01f, -2.59465903e-01f, -3.68990488e-02f,
  -1.98730290e-01f, -1.41344115e-01f, -2.33398274e-01f, -1.83079198e-01f, 1.17876718e-03f, -7.59342536e-02f, 8.78669471e-02f, 6.01672716e-02f, -3.69601026e-02f, -3.01025938e-02f,
  -1.98742509e-01f, -3.63979191e-02f, -2.92456418e-01f, -1.74148098e-01f, -1.38135448e-01f, -1.65301979e-01f, -1.30780891e-01f, -8.45151991e-02f, -2.42235377e-01f, -6.27759770e-02f,
  -1.12034746e-01f, -1.38885126e-01f, -2.01243192e-01f, -1.09889634e-01f, -6.62240982e-02f, -5.46161383e-02f, -2.50354588e-01f, -2.37841696e-01f, -1.82961524e-01f, -5.72451428e-02f,
  -2.10398987e-01f, 5.89023121e-02f, -2.89552994e-02f, -4.72428203e-02f, -1.46989584e-01f, -1.71637475e-01f, -1.45969659e-01f, -5.69056422e-02f, -1.99120566e-01f, -9.44122821e-02f,
  -3.48496698e-02f, 2.04932690e-01f, 1.43411458e-01f, 1.10738844e-01f, 1.88854635e-01f, 2.24208504e-01f, 1.78965986e-01f, 1.80757746e-01f, 1.60768792e-01f, 2.18974724e-01f,
  1.18669517e-01f, 2.23292202e-01f, 2.17946053e-01f, 2.48986036e-01f, 1.32591799e-01f, 2.69918412e-01f, 1.57425866e-01f, 1.27931446e-01f, 1.52015507e-01f, 1.57390669e-01f,
  1.81788221e-01f, 1.89158976e-01f, 1.27574325e-01f, 1.83282346e-01f, 1.52707532e-01f, 1.92494303e-01f, 1.47334486e-01f, 2.36448526e-01f, 1.51845351e-01f, 2.51559913e-01f,
  -2.82166034e-01f, -9.50849280e-02f, -2.09014446e-01f, -1.61907613e-01f, -1.90323815e-02f, -1.14714831e-01f, -1.37072131e-01f, -1.73563629e-01f, -8.36039931e-02f, -1.15530290e-01f,
  -1.28591806e-01f, -1.13851346e-01f, -1.85774371e-01f, -1.19942576e-01f, -1.87202558e-01f, -7.49835894e-02f, -9.61098298e-02f, -8.24370980e-02f, -1.39582753e-01f, -1.34885997e-01f,
  -1.19132258e-01f, -5.26333302e-02f, -1.34078160e-01f, -3.60861868e-02f, -8.15427080e-02f, -1.47092387e-01f, -8.24195296e-02f, -1.14390701e-02f, -6.41148686e-02f, -5.48384003e-02f,
  3.21653813e-01f, 2.79175669e-01f, -1.99823275e-01f, 9.56633240e-02f, -1.54542223e-01f, -1.18093982e-01f, -8.31118971e-02f, 2.86363363e-02f, 2.33770981e-02f, 1.26097396e-01f,
  1.36201054e-01f, 1.83956459e-01f, 1.56062290e-01f, -2.09360067e-02f, 6.14384823e-02f, -6.60896376e-02f, -2.06048951e-01f, -1.31655872e-01f, -2.21440718e-01f, -1.85570255e-01f,
  -4.33157049e-02f, -5.98068163e-02f, -4.20795530e-02f, -8.23444128e-02f, -8.48548189e-02f, -2.94894502e-02f, -1.16807319e-01f, -6.46843836e-02f, -7.30615333e-02f, -4.27876711e-02f,
  -5.17338775e-02f, 2.02022091e-01f, -8.63960385e-02f, 1.02549113e-01f, 6.08686954e-02f, -5.79415960e-03f, -8.79049003e-02f, 2.95269005e-02f, -4.85285670e-02f, -3.07570789e-02f,
  -3.91303040e-02f, 8.64525586e-02f, 6.14429824e-02f, -6.04883581e-02f, 1.55278072e-02f, 7.38933170e-03f, -2.79658008e-03f, -2.82646492e-02f, -3.02900076e-02f, -7.72309722e-03f,
  3.28410305e-02f, 2.32891981e-02f, 5.27585670e-02f, -1.08172871e-01f, -8.16626251e-02f, -4.95425202e-02f, -2.22679805e-02f, -1.02568686e-01f, -6.64789155e-02f, -5.12202494e-02f,
  1.14856467e-01f, -6.85276091e-02f, 3.03861257e-02f, 4.08855006e-02f, 2.81088147e-02f, -3.64143141e-02f, 2.75132209e-02f, -1.08862802e-01f, 7.66635034e-03f, -2.17247996e-02f,
  4.29357179e-02f, 1.87767055e-02f, -3.25595178e-02f, 1.35068297e-02f, -7.83424601e-02f, -2.61638388e-02f, -2.39512827e-02f, -1.56493448e-02f, -1.16677303e-02f, -5.25502302e-02f,
  6.84042722e-02f, -9.66154411e-02f, -1.60999354e-02f, -2.01383065e-02f, -2.80481987e-02f, 6.09635040e-02f, -9.18151438e-02f, -8.50730613e-02f, -2.35128310e-03f, -1.89259667e-02f,
  4.74552698e-02f, 5.50029287e-03f, -7.96702430e-02f, 5.91979623e-02f, -1.00387847e-02f, -5.92901148e-02f, 6.65921569e-02f, -8.81659985e-02f, 7.69642368e-02f, 9.03063687e-04f,
  3.04639768e-02f, 4.21558693e-02f, 3.49503718e-02f, -8.63759371e-04f, -9.79388282e-02f, 1.18235592e-02f, -2.34350003e-02f, 3.32367234e-02f, 3.75376339e-03f, -3.56686488e-02f,
  -1.42789411e-03f, -1.86279267e-02f, -1.13490790e-01f, 2.84027364e-02f, -9.85472873e-02f, -8.15018639e-02f, -1.15853563e-01f, -1.68413863e-01f, -1.40265644e-01f, -3.25339697e-02f,
  9.19468775e-02f, 1.46608561e-01f, 6.19147308e-02f, 2.18647808e-01f, 2.41206884e-02f, -2.24284958e-02f, 1.26887262e-01f, 2.28380114e-02f, 5.57868332e-02f, 1.14199094e-01f,
  -7.08535220e-03f, -9.33711138e-03f, -4.16006409e-02f, -4.32933234e-02f, 6.28781468e-02f, 2.34949693e-01f, 1.31201908e-01f, 1.42410710e-01f, 1.04365855e-01f, 5.66309094e-02f,
  1.35066360e-01f, 1.08338639e-01f, 4.38698567e-02f, 5.83661906e-02f, 1.91700682e-01f, -3.34297717e-02f, 1.16004840e-01f, 1.21689752e-01f, 4.97128405e-02f, 2.33293638e-01f,
  3.68962586e-02f, -1.30738616e-01f, -4.24999930e-03f, -7.54800811e-02f, -1.65439341e-02f, -1.02816105e-01f, -3.26259322e-02f, -5.35761081e-02f, -7.60712326e-02f, -3.83783728e-02f,
  -1.11187197e-01f, -6.82466999e-02f, 4.22155745e-02f, -7.32235089e-02f, -3.19118239e-02f, -6.50614500e-02f, 7.63243139e-02f, 7.54726678e-02f, 2.73997094e-02f, -1.80890299e-02f,
  4.49264469e-03f, 1.29279003e-01f, 5.69875278e-02f, -8.50060582e-02f, -9.06746089e-02f, -1.22621423e-02f, -2.23959778e-02f, 1.96825713e-02f, -1.43743068e-01f, 6.88189939e-02f,
  -2.57199295e-02f, 1.36345662e-02f, 5.10630719e-02f, 5.30450325e-03f, 8.42138529e-02f, 7.81175494e-02f, 7.39250407e-02f, 7.45821686e-04f, 1.06291808e-01f, 8.61894488e-02f,
  2.74428055e-02f, 8.54367092e-02f, 2.32069846e-02f, 1.34675160e-01f, 1.19818233e-01f, 1.29030615e-01f, 1.78167030e-01f, 1.57784805e-01f, 7.52386302e-02f, 1.00402743e-01f,
  1.52758524e-01f, 3.35760750e-02f, 2.47127768e-02f, 9.99479815e-02f, 6.13314100e-02f, -1.11942394e-02f, 4.72656824e-02f, 6.74135312e-02f, 5.40777594e-02f, 1.09655567e-01f,
  3.62528078e-02f, -2.21456975e-01f, 4.42013554e-02f, 2.58076787e-02f, -2.45645307e-02f, -4.34429757e-02f, -6.72251210e-02f, 5.74469455e-02f, -1.02225639e-01f, -6.36641588e-03f,
  -9.10866782e-02f, -1.22429982e-01f, -2.01957282e-02f, 6.13172650e-02f, 5.86355850e-02f, 3.00013367e-02f, 7.30164498e-02f, 7.14421943e-02f, 2.55101603e-02f, 6.60300329e-02f,
  -2.48125624e-02f, 1.33278877e-01f, 1.30001813e-01f, -5.35227545e-02f, -4.55627255e-02f, -3.65938731e-02f, 1.05441483e-02f, 4.17021886e-02f, -3.53169627e-02f, 2.80514080e-02f,
  -1.25889510e-01f, 1.38588265e-01f, 1.13839336e-01f, 1.01400137e-01f, 1.71235040e-01f, 1.81624219e-01f, 2.33930409e-01f, 7.71277770e-03f, -6.75591379e-02f, 4.80026007e-02f,
  -1.06745116e-01f, -2.40290817e-02f, -1.08545743e-01f, 6.24587089e-02f, 7.48539809e-03f, 1.54074192e-01f, 2.07908288e-01f, 1.23071343e-01f, -5.13906926e-02f, 4.90761027e-02f,
  1.17598332e-01f, 1.55567557e-01f, -4.94049862e-03f, -6.83449395e-03f, 1.37898207e-01f, -8.20481312e-03f, 3.59857827e-02f, 1.26952425e-01f, 1.70292795e-01f, 1.01932690e-01f,
  1.18127935e-01f, -9.73465741e-02f, -5.96482381e-02f, 2.88729798e-02f, 3.44616920e-02f, 2.11310294e-02f, 6.15775660e-02f, 3.59800607e-02f, -1.14011308e-02f, 1.55067621e-02f,
  -1.69998016e-02f, 7.25549534e-02f, 5.93063980e-02f, 1.47889182e-01f, -1.27491762e-03f, 7.94543028e-02f, 7.23335370e-02f, 5.79306930e-02f, 3.32725830e-02f, 1.61269099e-01f,
  6.99075311e-02f, 1.38610259e-01f, 2.02550441e-02f, 1.57824099e-01f, 5.71694560e-02f, 8.15542042e-02f, 4.63113934e-02f, 1.09675162e-01f, -5.74594066e-02f, 1.59469500e-01f,
  2.31425725e-02f, -5.77646904e-02f, -1.92912538e-02f, -3.83072533e-02f, 2.09857505e-02f, 4.01697271e-02f, -3.22860032e-02f, -2.24163439e-02f, 1.04778856e-01f, 5.31777367e-02f,
  -7.95256123e-02f, 4.09380570e-02f, 6.70023635e-02f, 3.51924747e-02f, -3.79995145e-02f, -5.03760464e-02f, -6.38674721e-02f, 5.07767648e-02f, -3.44795105e-03f, -9.85469595e-02f,
  2.17579142e-03f, 1.85393617e-02f, 4.45073359e-02f, -5.69432005e-02f, 1.98482368e-02f, -2.30116285e-02f, -7.64589757e-02f, -1.20402969e-01f, -1.26561802e-02f, -4.68025990e-02f,
  1.95422798e-01f, -1.09819792e-01f, 5.19603230e-02f, 1.09155193e-01f, 4.94688042e-02f, 1.55367926e-01f, -1.61572488e-03f, 1.36246562e-01f, 1.10822298e-01f, 9.50260758e-02f,
  4.54454906e-02f, 1.12066232e-01f, 1.09309398e-01f, 1.22571394e-01f, 7.19093159e-02f, 3.77364941e-02f, 1.73364341e-01f, 1.53146371e-01f, 4.25937995e-02f, 6.66793212e-02f,
  1.13280341e-01f, 1.60072923e-01f, 1.13794453e-01f, 1.93621799e-01f, 7.16695711e-02f, 1.17445484e-01f, 1.12958372e-01f, 1.27537444e-01f, 1.89342096e-01f, 2.97042340e-01f,
  -4.06666398e-01f, 7.92378038e-02f, -2.67720193e-01f, -1.42156765e-01f, -1.87572181e-01f, -2.58354366e-01f, -1.52116820e-01f, -5.35504483e-02f, -8.52130800e-02f, -7.05623701e-02f,
  -9.39392969e-02f, -2.08165750e-01f, -1.60395771e-01f, -1.96965829e-01f, -2.38334686e-01f, -1.62478685e-01f, -2.42332041e-01f, -3.46749216e-01f, -1.83602750e-01f, -2.09513426e-01f,
  -1.50999874e-01f, -9.45317000e-02f, -1.50252357e-01f, -1.69150978e-01f, 2.81171408e-02f, -1.10028580e-01f, -8.46076980e-02f, -1.45550370e-01f, -1.72596514e-01f, 2.56745107e-02f,
  -6.89656436e-02f, -2.31412306e-01f, -2.16752738e-01f, -2.80359894e-01f, -1.89921767e-01f, -2.78169066e-01f, -2.41726190e-01f, -1.91812187e-01f, -2.24386990e-01f, -1.75329477e-01f,
  -2.64875144e-01f, -2.79228777e-01f, -2.08986744e-01f, -9.47675630e-02f, -1.81531832e-01f, -1.74521759e-01f, -1.58816800e-01f, -2.52611250e-01f, -2.78729767e-01f, -6.36523589e-02f,
  -2.27673203e-01f, -2.96024829e-01f, -2.93317795e-01f, -1.54735446e-01f, -1.67446598e-01f, -2.27455258e-01f, -1.07185796e-01f, -1.33332521e-01f, -1.25993386e-01f, -1.04478404e-01f,
  1.23400167e-01f, 1.28373459e-01f, 1.61276683e-01f, 1.61003500e-01f, 1.09904498e-01f, 1.34196386e-01f, 1.30000114e-01f, 1.42271280e-01f, 2.03120783e-01f, 1.93628863e-01f,
  1.74503177e-01f, 2.24945053e-01f, 1.71794713e-01f, 1.84579104e-01f, 1.20273784e-01f, 1.95925772e-01f, 5.09368666e-02f, 2.99277633e-01f, 1.47891209e-01f, 1.71314999e-01f,
  9.08930972e-02f, 1.26259848e-01f, 1.91756189e-01f, 2.95069933e-01f, 1.66168347e-01f, 1.65052041e-01f, 2.11287692e-01f, 1.55630305e-01f, 1.33723453e-01f, 1.15792550e-01f,
  -1.18306026e-01f, -3.01479638e-01f, -1.04736000e-01f, -1.84482589e-01f, -1.75474793e-01f, -1.45320937e-01f, -1.30483389e-01f, -1.76434398e-01f, -2.44387224e-01f, -2.20581710e-01f,
  -2.58241773e-01f, -1.29341900e-01f, -2.12164998e-01f, -1.69212535e-01f, -2.98943400e-01f, -1.58820540e-01f, -2.08320722e-01f, -3.05651039e-01f, -2.29044318e-01f, -1.28172785e-01f,
  -2.28578150e-01f, -1.85166463e-01f, -2.94577509e-01f, -1.53659552e-01f, -1.11514330e-01f, -3.30484360e-01f, -2.26871833e-01f, -1.31495833e-01f, -1.88473091e-01f, -2.11830050e-01f,
  -6.72783926e-02f, 1.21149421e-01f, 5.09104924e-03f, 1.71683393e-02f, -4.51692156e-02f, -1.19120061e-01f, -1.29018009e-01f, -1.30194992e-01f, 1.16843149e-01f, 1.40092552e-01f,
  1.06971182e-01f, 2.54697770e-01f, 3.25142920e-01f, 1.42468572e-01f, 1.93402007e-01f, 1.67890698e-01f, 5.46325259e-02f, 5.79724610e-02f, -7.48970173e-03f, -2.28142738e-01f,
  -1.19787276e-01f, -1.11198172e-01f, -2.18011569e-02f, -5.15047926e-04f, -5.60020097e-03f, 1.30637169e-01f, 6.92759007e-02f, -1.32714972e-01f, -1.07569173e-01f, 6.89976960e-02f,
  5.93988262e-02f, -1.70573458e-01f, -7.91245773e-02f, -8.61632973e-02f, -1.14519626e-01f, -1.22766256e-01f, -1.10608742e-01f, -1.79235950e-01f, -4.58694734e-02f, -1.00134134e-01f,
  -5.60748540e-02f, -1.16784848e-01f, -5.17605729e-02f, -7.99108967e-02f, -1.38596386e-01f, -5.32713495e-02f, -1.27657130e-01f, -1.29955620e-01f, -1.46269500e-01f, -7.97094181e-02f,
  -1.58319801e-01f, -1.87059566e-01f, -1.49442509e-01f, -4.87842970e-02f, -7.59713873e-02f, -1.81980673e-02f, -1.80658519e-01f, -2.16651902e-01f, -1.28720775e-01f, -1.05828382e-01f,
  -9.56914946e-03f, 1.58121482e-01f, 8.92297029e-02f, 9.61812660e-02f, 3.58193852e-02f, 2.48219877e-01f, 6.57633990e-02f, 9.03248414e-02f, 1.12739757e-01f, 8.77178088e-02f,
  6.23342283e-02f, 1.86333552e-01f, 5.35506420e-02f, 1.25841260e-01f, 2.09621102e-01f, 6.80388957e-02f, 1.13753214e-01f, 9.16648209e-02f, 4.96768169e-02f, 1.43380374e-01f,
  6.70804977e-02f, 1.11629099e-01f, 1.12395339e-01f, 5.01374565e-02f, 1.02497160e-01f, 1.96696129e-02f, 1.11859560e-01f, 7.27860257e-02f, 9.41984206e-02f, 7.11347014e-02f,
  1.31111905e-01f, -3.98351587e-02f, 4.52172421e-02f, 1.20012229e-02f, -8.38176161e-02f, -1.01015262e-01f, -4.07760069e-02f, -3.17900777e-02f, -4.80227061e-02f, -6.61266670e-02f,
  -8.89046490e-02f, 1.03740804e-02f, 3.26770288e-03f, -1.12330221e-01f, -5.70187531e-02f, -8.98952335e-02f, -4.43449467e-02f, -9.98663437e-03f, 1.98659543e-02f, -2.08581060e-01f,
  -7.04264119e-02f, 5.39309299e-03f, 1.00493707e-01f, 9.16297175e-03f, -2.95154583e-02f, 8.97567347e-02f, -8.04809183e-02f, -1.37189329e-01f, -2.21368857e-02f, -9.15181339e-02f,
  -3.95258456e-01f, 1.52773887e-01f, 2.81545430e-01f, 8.48024189e-02f, 8.62419307e-02f, 1.19234338e-01f, 1.03742272e-01f, -2.94264536e-02f, 7.78663009e-02f, 1.46340877e-01f,
  -1.36670753e-01f, -1.50359109e-01f, -1.31153733e-01f, -1.75976858e-01f, -1.18507691e-01f, 1.50472850e-01f, 2.60049284e-01f, 2.74716746e-02f, -3.81640568e-02f, 3.12524140e-02f,
  -5.53703047e-02f, 2.44639907e-02f, -1.77244529e-01f, 7.43386224e-02f, 1.25571445e-01f, 3.93655971e-02f, 8.99117440e-02f, 1.71853364e-01f, 2.92013194e-02f, 2.27233872e-01f,
  2.38882244e-01f, -4.46761474e-02f, 2.44275555e-02f, -1.56516731e-02f, -1.00069121e-02f, 9.35140159e-03f, 4.45431694e-02f, 6.84875622e-02f, -4.41130958e-02f, 8.69881511e-02f,
  -1.21426322e-02f, -5.73184267e-02f, -5.70617206e-02f, 6.04327023e-02f, 4.61150706e-02f, 2.21858770e-02f, -1.12570403e-02f, 8.06749761e-02f, 1.06126070e-01f, -1.44237792e-02f,
  6.08287640e-02f, 1.42341822e-01f, 1.42345309e-01f, -1.57331228e-02f, 2.76905317e-02f, 2.50781905e-02f, -3.15906778e-02f, -1.07087020e-03f, 9.21293423e-02f, 4.94760051e-02f,
  -2.65459623e-03f, -8.69308412e-02f, -4.30367626e-02f, -5.99700734e-02f, -1.50772974e-01f, -5.94639182e-02f, -1.00111537e-01f, -3.07789184e-02f, -7.26699829e-02f, -1.31947652e-01f,
  -1.50246695e-01f, -1.22213535e-01f, -1.01558112e-01f, -6.39331490e-02f, -5.28156906e-02f, 2.07907502e-02f, -9.95539688e-03f, -9.24824551e-02f, -7.48752728e-02f, -6.50951937e-02f,
  -9.43317711e-02f, -1.20429903e-01f, -5.87603711e-02f, -1.07398987e-01f, -5.62515333e-02f, -1.54513419e-01f, -9.53321010e-02f, -1.17258616e-01f, -9.72819477e-02f, -1.37607679e-01f,
  1.17463348e-02f, -2.32693985e-01f, -4.55733447e-04f, -6.03667758e-02f, 8.86907801e-02f, 5.91349714e-02f, 1.07732264e-03f, -3.79040278e-02f, 9.21276808e-02f, 5.53207733e-02f,
  4.79217656e-02f, -6.13868684e-02f, -3.23432386e-02f, 8.38617161e-02f, 3.21747065e-02f, -9.55969188e-03f, 1.80238392e-02f, 2.90634558e-02f, 7.41073266e-02f, 2.04619598e-02f,
  1.23162806e-01f, 7.18933195e-02f, -5.74445948e-02f, 1.06542677e-01f, 2.06692200e-02f, -1.33410851e-02f, 8.64604935e-02f, -5.50570479e-03f, -6.49098158e-02f, 1.31835505e-01f,
  5.45528419e-02f, -2.68402547e-02f, 2.95339644e-01f, -1.01209462e-01f, 1.20625772e-01f, 2.62264460e-01f, 2.22759366e-01f, 2.34029874e-01f, -9.36403871e-02f, -1.59793217e-02f,
  -2.47672461e-02f, -2.20447965e-02f, -1.19868718e-01f, 8.21976587e-02f, 2.68980682e-01f, 1.88362718e-01f, 8.77716169e-02f, 1.20142937e-01f, 2.69042045e-01f, 2.85317719e-01f,
  1.09287545e-01f, 3.60049643e-02f, 1.31933749e-01f, 5.69187663e-02f, -5.03961965e-02f, -1.14432154e-02f, -3.09302583e-02f, 2.32155193e-02f, 9.21441913e-02f, -9.49089974e-02f,
  1.57544583e-01f, 2.71008641e-01f, 1.62562817e-01f, -4.37340736e-02f, 7.69766793e-02f, 9.32856947e-02f, 9.27589089e-02f, 4.97113802e-02f, -1.04784099e-02f, -4.57936339e-03f,
  -2.64280215e-02f, 1.11552728e-02f, 1.77078471e-01f, 1.78169310e-01f, 7.88494274e-02f, 2.13173851e-01f, 4.53481600e-02f, 1.21368095e-01f, 1.26170337e-01f, 1.49377465e-01f,
  3.21331881e-02f, 1.76756084e-01f, 2.55335480e-01f, 7.31305778e-02f, 1.52130261e-01f, 1.82865057e-02f, 1.74964413e-01f, 2.10825965e-01f, 2.49382898e-01f, 8.96397531e-02f,
  -1.83876500e-01f, -7.23845586e-02f, -2.81786807e-02f, -1.25457600e-01f, -1.08124197e-01f, -1.60566255e-01f, -9.60454345e-02f, -1.06253155e-01f, -6.54794127e-02f, -9.73263197e-03f,
  -9.29507837e-02f, -3.24575906e-03f, -1.06012756e-02f, -1.27869353e-01f, -1.08901367e-01f, -6.46246895e-02f, -1.60497297e-02f, -1.51365861e-01f, -1.10789826e-02f, -1.18663751e-01f,
  -1.19656809e-01f, -2.20591091e-02f, -1.12603307e-01f, -1.01690635e-01f, -2.40214337e-02f, -7.18337297e-02f, -3.11600883e-02f, -4.06887308e-02f, -1.23825893e-01f, -2.93266214e-02f,
  -7.27866292e-02f, 2.14540541e-01f, 3.11520193e-02f, 1.53825015e-01f, 3.74311730e-02f, 1.28827035e-01f, 9.78098512e-02f, 8.74321535e-02f, 9.55988467e-02f, 1.62257716e-01f,
  1.00182556e-01f, 1.78701207e-01f, 1.12433672e-01f, 1.05376832e-01f, 1.32504597e-01f, 6.70374855e-02f, 1.19132668e-01f, 4.92834374e-02f, 1.53733179e-01f, 1.21147603e-01f,
  5.41663356e-02f, 9.20477435e-02f, 5.99384084e-02f, 1.84637129e-01f, 1.70501500e-01f, 6.70254454e-02f, 1.67410821e-01f, 3.97105590e-02f, 1.63455397e-01f, -6.65300786e-02f,
  1.64469361e-01f, 2.68222868e-01f, 2.85412222e-02f, -1.29153877e-02f, 3.88771333e-02f, 2.08308306e-02f, 2.19634116e-01f, 5.62259704e-02f, 1.62296370e-02f, -9.50853899e-02f,
  -1.77508965e-01f, -3.50199699e-01f, -2.94018745e-01f, -1.52154550e-01f, -6.33840784e-02f, 1.12942949e-01f, 1.53088316e-01f, -9.12017748e-02f, -1.02804564e-01f, -1.07126519e-01f,
  -4.15882561e-03f, -7.70437345e-02f, -4.43220288e-02f, 1.50536839e-03f, -1.91541538e-02f, -1.51438881e-02f, 6.25053048e-02f, 1.88011618e-03f, 1.44005604e-02f, 8.90989453e-02f,
  -2.84528792e-01f, 5.30247614e-02f, -2.12301686e-01f, -1.17324203e-01f, -1.46478951e-01f, -1.04415743e-02f, -1.15660571e-01f, -5.46225533e-02f, -5.74149750e-02f, 4.01054416e-03f,
  -1.80621788e-01f, -1.83795154e-01f, -1.86622173e-01f, -1.90061823e-01f, -4.04972956e-02f, -6.04052283e-02f, 5.26700020e-02f, -1.87957380e-02f, -1.46766022e-01f, -1.65546492e-01f,
  -1.89300701e-01f, -9.09387507e-03f, -4.95232418e-02f, -4.48895805e-03f, -2.57375296e-02f, -1.70967638e-01f, -9.77451727e-02f, -1.24273272e-02f, 2.33421270e-02f, 6.15463145e-02f,
  9.03592855e-02f, 4.53909636e-02f, 6.91805184e-02f, 1.19732752e-01f, 3.81882712e-02f, 1.84911620e-02f, 7.92081878e-02f, 9.70035642e-02f, 7.27755651e-02f, 6.64155558e-02f,
  5.43687940e-02f, -1.02729155e-02f, 7.13890418e-02f, 1.42422631e-01f, 4.05315049e-02f, 7.77825490e-02f, 3.87088656e-02f, 8.90118703e-02f, 4.70353402e-02f, 1.02875538e-01f,
  -2.88204849e-02f, 1.09435804e-01f, 1.42281488e-01f, 1.05826400e-01f, 1.94277182e-01f, 1.38848633e-01f, 6.00605085e-02f, 1.14051707e-01f, 4.02954258e-02f, 8.72193426e-02f,
  -1.61025599e-01f, -1.09711140e-01f, -2.33008191e-01f, -7.85517618e-02f, -1.08670322e-02f, -9.60352197e-02f, -1.85987234e-01f, -6.06764816e-02f, -1.11718811e-01f, -1.25763386e-01f,
  -8.72308388e-02f, -9.39224437e-02f, -8.50324258e-02f, -1.66222334e-01f, -8.98341388e-02f, -5.54720871e-02f, -6.61721900e-02f, -4.36111726e-02f, -1.65882573e-01f, -1.95229769e-01f,
  -6.93237782e-02f, -1.23980001e-01f, -2.04987779e-01f, -1.64789215e-01f, -1.14114687e-01f, -9.58082378e-02f, -1.18705846e-01f, -4.55208607e-02f, -2.58919746e-02f, 4.01208550e-02f,
  3.57666284e-01f, -2.74785161e-02f, 2.82722563e-01f, 7.07844645e-02f, -5.04504927e-02f, 1.04212776e-01f, 8.17403868e-02f, 1.43754587e-01f, -5.33053093e-02f, 8.80343691e-02f,
  9.14995819e-02f, 1.39685780e-01f, 8.44698120e-03f, 1.79706663e-01f, 2.69144356e-01f, 1.22246355e-01f, 3.03780679e-02f, 3.03628772e-01f, 3.29439461e-01f, 1.65451899e-01f,
  1.31198596e-02f, 1.30764455e-01f, 3.51703972e-01f, 1.19033970e-01f, -3.56191061e-02f, -9.83294994e-02f, 6.98124617e-02f, 5.59934527e-02f, 1.01071689e-02f, -1.13516785e-01f,
  2.13649288e-01f, 3.46233472e-02f, 1.98780149e-01f, 1.46653578e-01f, 2.37424355e-02f, 9.85482037e-02f, 1.67336792e-01f, 1.53579861e-01f, 1.20194852e-01f, 1.53345689e-01f,
  1.05430484e-01f, 7.82225132e-02f, 9.60896015e-02f, 1.43393964e-01f, 1.20625630e-01f, 2.26901993e-01f, 2.63049275e-01f, 2.36382157e-01f, 2.65797436e-01f, 8.17615092e-02f,
  1.35292128e-01f, 1.71745747e-01f, 1.77105710e-01f, 2.29276374e-01f, 1.13165915e-01f, 2.14460209e-01f, 1.59855291e-01f, 9.68946218e-02f, 1.90374523e-01f, 1.16861649e-01f,
  -4.10698280e-02f, -7.52858073e-02f, -5.47028966e-02f, -4.99324277e-02f, -1.84797809e-01f, -1.02808543e-01f, -1.65845245e-01f, -1.21795960e-01f, -6.86204731e-02f, -7.15655982e-02f,
  -6.12866580e-02f, -1.45077005e-01f, -6.11451305e-02f, -1.02400690e-01f, -6.24194518e-02f, 2.72982959e-02f, -1.33317277e-01f, -1.02248810e-01f, -9.54214111e-02f, -1.40550956e-01f,
  -9.35249478e-02f, -9.02317390e-02f, -4.94277216e-02f, -9.77082774e-02f, -1.33597851e-01f, -5.39991297e-02f, -6.72644377e-02f, -1.40364528e-01f, -3.93007882e-02f, -3.18640582e-02f,
  1.42389789e-01f, 2.77945727e-01f, 3.67121771e-02f, 8.29201862e-02f, 1.61766276e-01f, 4.16995212e-02f, 1.23560213e-01f, 1.54046923e-01f, 7.40217790e-02f, 1.86352804e-01f,
  1.56797975e-01f, 8.11111927e-02f, 2.11657614e-01f, 2.16751337e-01f, 1.53757304e-01f, 1.45403728e-01f, 1.54631153e-01f, 1.01521544e-01f, 2.14618072e-01f, 1.78585991e-01f,
  1.44893184e-01f, 2.27980956e-01f, 3.15510839e-01f, 9.53032151e-02f, 3.86644565e-02f, 2.49165162e-01f, 1.03734143e-01f, 9.64825675e-02f, 1.57800928e-01f, 1.91912249e-01f,
  -1.03273019e-01f, -1.15848467e-01f, -8.30454603e-02f, 9.27435160e-02f, -9.90000069e-02f, -2.75534630e-01f, -1.06488794e-01f, -7.34111071e-02f, -8.00346807e-02f, -9.97053906e-02f,
  -2.20779359e-01f, 5.97640052e-02f, 1.34607062e-01f, 1.04962848e-01f, 1.38551146e-01f, 1.67410858e-02f, 1.36680067e-01f, 1.36403427e-01f, 5.37817515e-02f, -4.11615409e-02f,
  1.49433702e-01f, 1.39908329e-01f, 1.48989692e-01f, 1.28105134e-01f, -2.85375677e-02f, 7.59724602e-02f, -6.91881850e-02f, -2.72997562e-02f, -1.76335517e-02f, 1.39813945e-01f,
  -1.88116953e-01f, -1.40803635e-01f, -1.37133254e-02f, 7.21293911e-02f, -3.85212414e-02f, -1.53839067e-01f, -6.04582466e-02f, 4.66958396e-02f, 3.40894125e-02f, -9.71479490e-02f,
  -1.06718600e-01f, -1.22762196e-01f, -1.08855076e-01f, -5.41359857e-02f, -7.97431320e-02f, -3.71678285e-02f, -1.42431688e-02f, -8.21803659e-02f, 3.96850798e-03f, -4.43275832e-02f,
  -4.86972556e-02f, -6.45889118e-02f, -1.61327556e-01f, 8.28015059e-03f, -1.52050525e-01f, 7.95208886e-02f, -3.19252834e-02f, -1.04802743e-01f, -1.15605205e-01f, -1.12622373e-01f,
  2.18993798e-03f, 4.28935364e-02f, 1.46534648e-02f, 1.48425391e-02f, 1.46123730e-02f, 4.40848656e-02f, -1.87908839e-02f, 3.83420438e-02f, 7.86355287e-02f, 8.66334662e-02f,
  -4.08496661e-03f, -2.66448241e-02f, 1.07371777e-01f, -2.36564185e-02f, 9.67036560e-02f, 7.68729392e-03f, -8.32788832e-03f, -1.84089448e-02f, 5.49170002e-02f, 7.89040048e-03f,
  9.74367559e-03f, -1.45162595e-02f, -5.92798479e-02f, 1.47404686e-01f, -4.24154736e-02f, 1.66855771e-02f, -2.08960269e-02f, -5.95856085e-02f, -4.17503938e-02f, -1.32259773e-02f,
  2.74268508e-01f, 7.10835457e-02f, -2.33418103e-02f, -4.94875275e-02f, 1.61163546e-02f, 4.71961088e-02f, 1.23512326e-02f, -1.49123222e-02f, -1.00887613e-02f, -3.31416503e-02f,
  -9.36646312e-02f, 1.00018792e-02f, 6.03404120e-02f, -9.13704559e-03f, -2.70554479e-02f, -2.00720746e-02f, 7.66018182e-02f, 4.23742495e-02f, -5.11380509e-02f, -5.82440868e-02f,
  -3.98976877e-02f, 9.97311249e-02f, 6.85489029e-02f, 7.02685714e-02f, -7.54628256e-02f, -6.70817727e-03f, 3.21419314e-02f, 7.65104890e-02f, -1.51674431e-02f, 1.34746760e-01f,
  -2.16696143e-01f, 2.66538411e-02f, -1.07880875e-01f, -6.23834133e-02f, -2.47827455e-01f, -2.60709256e-01f, -1.06226385e-01f, -1.63043529e-01f, -4.44582552e-02f, -1.34192303e-01f,
  -1.93996280e-01f, -2.66009748e-01f, -1.10065408e-01f, -1.46973759e-01f, -1.11294188e-01f, -1.22861437e-01f, -9.17214062e-03f, -8.21301341e-02f, -2.06272051e-01f, -2.64196575e-01f,
  -1.15103915e-01f, -2.17690557e-01f, -2.33659878e-01f, -1.59758925e-01f, -6.73919097e-02f, -1.79507300e-01f, -1.77191868e-01f, -9.40939263e-02f, -1.12019278e-01f, -7.45339096e-02f,
  -1.62303478e-01f, -1.44111505e-02f, -1.78743616e-01f, -9.63258445e-02f, -1.45905420e-01f, -1.07942917e-03f, -1.35634884e-01f, -1.46621957e-01f, -1.01615027e-01f, -1.46589756e-01f,
  -1.29124314e-01f, -1.66411679e-02f, 8.74854997e-03f, -1.88487209e-02f, -8.47475082e-02f, -1.28209919e-01f, 3.69669050e-02f, 4.48512333e-03f, -3.79949883e-02f, -2.32292023e-02f,
  -5.60280085e-02f, -8.11633766e-02f, -2.03396320e-01f, -1.69883803e-01f, 7.67391501e-03f, -1.73006579e-01f, -4.61980291e-02f, -1.79856136e-01f, -2.46155545e-01f, -1.93937514e-02f,
  4.50884923e-02f, 7.55592436e-03f, -4.24619718e-03f, 1.13782436e-02f, 1.00898057e-01f, 6.37602583e-02f, 9.44426209e-02f, -8.95347854e-04f, -8.54027923e-03f, -4.85085067e-04f,
  3.38437781e-02f, 1.69196748e-03f, 6.81594387e-02f, -4.32103910e-02f, 1.96240786e-02f, -1.20985238e-02f, 4.90283556e-02f, 7.96113089e-02f, -5.07203536e-03f, 1.05998851e-01f,
  1.21761441e-01f, 4.87575084e-02f, -1.44029493e-02f, 2.58258195e-03f, -2.74340808e-02f, 8.42688680e-02f, -1.07949991e-02f, 1.67915213e-03f, 4.47310582e-02f, 5.21776564e-02f,
  -1.42996177e-01f, -1.23524792e-01f, -3.14258337e-02f, -6.31118640e-02f, -1.53293952e-01f, -1.11827165e-01f, -8.31837505e-02f, -1.08630054e-01f, -1.27768144e-01f, -6.12489656e-02f,
  -4.97938916e-02f, -9.90012586e-02f, -1.09915271e-01f, -5.24028987e-02f, -7.04428852e-02f, -9.47515368e-02f, -2.31325980e-02f, -9.50112194e-02f, -1.13626167e-01f, -4.84980792e-02f,
  -1.42044827e-01f, -1.91151962e-01f, -2.28415951e-01f, -9.45520103e-02f, -1.06021360e-01f, -2.25981846e-01f, -2.59153426e-01f, -2.57152200e-01f, -2.58050650e-01f, -2.01522037e-01f,
  -5.97299151e-02f, -2.98456043e-01f, 1.00179218e-01f, -2.03013122e-01f, -8.32706317e-02f, 2.01657891e-01f, 6.36292025e-02f, 6.33875355e-02f, -3.74112725e-02f, -1.41805068e-01f,
  1.31167874e-01f, 1.24971405e-01f, 1.09557822e-01f, 2.51327064e-02f, 1.61837727e-01f, -4.86577377e-02f, -1.91067442e-01f, 7.38122538e-02f, 2.08612576e-01f, 9.98809561e-02f,
  -1.98560372e-01f, -1.21840492e-01f, -1.06326930e-01f, -1.01694122e-01f, -2.01678246e-01f, -1.23544976e-01f, -1.34055436e-01f, -6.97479770e-02f, -5.30388951e-02f, -2.59781450e-01f,
  5.79635575e-02f, 6.54533431e-02f, 1.04712322e-01f, -1.01736106e-01f, -5.28478548e-02f, -4.75581875e-03f, -7.24061579e-02f, -4.63249907e-02f, -8.07107538e-02f, -7.02868178e-02f,
  1.43037802e-02f, -4.25880030e-02f, -6.61855424e-03f, -1.45282084e-02f, 6.36088522e-03f, 2.75943838e-02f, 1.23906406e-02f, 7.23390430e-02f, 1.09616220e-01f, 9.06115919e-02f,
  -1.17006347e-01f, -5.21141998e-02f, 3.13777663e-02f, 8.71897042e-02f, 1.00376513e-02f, 9.00717005e-02f, 1.12924933e-01f, 1.25292003e-01f, 4.34924513e-02f, -1.28570840e-01f,
  -3.43826637e-02f, 1.02605589e-01f, 9.25387442e-02f, 1.38153791e-01f, 2.79674195e-02f, 1.58281967e-01f, 8.74689296e-02f, 1.23284720e-01f, 4.43924963e-02f, 4.48278263e-02f,
  2.19237670e-01f, 8.73486698e-02f, 2.05336347e-01f, 1.04395352e-01f, 7.86031336e-02f, 1.38792112e-01f, 8.52690041e-02f, 4.12716828e-02f, 1.30760819e-01f, 7.66031519e-02f,
  1.80553705e-01f, 7.77413845e-02f, 1.56729981e-01f, 1.70451224e-01f, 2.42813542e-01f, 9.17565748e-02f, 1.16991773e-01f, 1.68220013e-01f, 1.62539676e-01f, 4.57684025e-02f,
  -8.14728439e-02f, 2.59649456e-01f, -8.62354711e-02f, 1.18591357e-02f, -8.35865140e-02f, 3.35684568e-02f, -4.46722023e-02f, 5.56884147e-02f, -7.65557811e-02f, 1.00801373e-02f,
  6.56567216e-02f, 1.08202480e-01f, -7.58440122e-02f, -3.43874879e-02f, 4.37273867e-02f, -6.78993668e-03f, -1.07992925e-01f, 7.72850886e-02f, -2.44646575e-02f, -6.99918419e-02f,
  -1.00112185e-01f, -9.94145721e-02f, -2.51225997e-02f, 6.48719743e-02f, 6.85361214e-03f, 8.12138543e-02f, -7.80759305e-02f, -5.14922217e-02f, 5.05480729e-02f, -2.03773424e-01f,
  -2.55587727e-01f, 3.30908775e-01f, 1.92606583e-01f, -7.74596110e-02f, 1.39563367e-01f, 2.54049003e-01f, 3.36191922e-01f, 1.14400007e-01f, -3.21490616e-02f, 6.91956878e-02f,
  -1.47930279e-01f, -2.31121317e-01f, -1.56596243e-01f, -1.30074233e-01f, 5.27945608e-02f, 2.33085722e-01f, 2.76670963e-01f, -1.59282740e-02f, -7.35459179e-02f, 6.31615669e-02f,
  6.97788969e-02f, 3.78601961e-02f, -1.15592837e-01f, 9.23072323e-02f, 3.31251100e-02f, -1.07447192e-01f, 2.25925092e-02f, 1.30241945e-01f, 5.98241128e-02f, 1.43715605e-01f,
  -2.02190466e-02f, -1.43818902e-02f, 3.83595899e-02f, -8.85130763e-02f, 5.98416664e-02f, -3.18751717e-03f, -9.22768656e-03f, -8.74414369e-02f, -4.43605855e-02f, 6.78063035e-02f,
  -6.73086271e-02f, -6.61396384e-02f, -6.63297251e-02f, 6.02850989e-02f, -2.98686791e-02f, 4.17139474e-03f, 9.53342393e-02f, -6.85108304e-02f, 8.58614296e-02f, 5.84832355e-02f,
  1.13840535e-01f, 6.65675625e-02f, 2.82845274e-02f, 1.07836843e-01f, -1.16255013e-02f, 2.25298461e-02f, -3.40347178e-02f, 5.24945296e-02f, -3.81080694e-02f, 6.58844132e-04f,
  -7.51326531e-02f, 3.77729237e-02f, 3.85847539e-02f, 2.81734504e-02f, 1.41915372e-02f, 1.58675350e-02f, 4.30261251e-03f, -6.48458255e-03f, -4.05692495e-02f, -2.88139768e-02f,
  2.35768966e-02f, 8.85079727e-02f, -1.57968495e-02f, -8.13764781e-02f, -6.14357442e-02f, 2.43344810e-02f, -1.67195201e-02f, -7.18026161e-02f, -4.81036939e-02f, -5.07008992e-02f,
  6.10074550e-02f, -4.79332954e-02f, -7.93518499e-03f, -5.95748685e-02f, 8.76434054e-03f, 6.29010331e-03f, -1.29700662e-03f, -6.20311312e-02f, 1.28501495e-02f, 4.51836735e-02f,
  -1.92088693e-01f, -4.14262619e-03f, 8.66623595e-03f, -3.57313976e-02f, 4.45920862e-02f, 1.69222299e-02f, 3.68228219e-02f, 6.33223206e-02f, 3.95873263e-02f, 5.85758053e-02f,
  -2.04573739e-02f, 3.95256169e-02f, -3.78399231e-02f, 5.60236573e-02f, 4.80271801e-02f, 5.58254421e-02f, 2.13939287e-02f, -1.78589467e-02f, 4.58871834e-02f, 5.31058013e-02f,
  1.70405298e-01f, -1.73286982e-02f, 6.35360032e-02f, -5.07270135e-02f, -2.21774187e-02f, -5.91673516e-02f, -4.87512797e-02f, 8.21519941e-02f, -5.55124357e-02f, 1.34504974e-01f
};

// L0_fan_Wp_bar (Shape: 78 x 120)
const int L0_fan_Wp_bar_rows = 78;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.12612271e-01f, 3.63575310e-01f, 1.15979962e-01f, -2.32202664e-01f, 2.24343702e-01f, 2.67091155e-01f, 2.71232128e-01f, -7.11779445e-02f, -2.76531190e-01f, 3.95492688e-02f,
  3.31240684e-01f, -5.87214939e-02f, -1.29876077e-01f, -2.84233898e-01f, -2.46429130e-01f, -1.70550585e-01f, -2.60621130e-01f, -2.94599682e-01f, -2.39963427e-01f, -8.08119550e-02f,
  -6.13710433e-02f, 3.26225199e-02f, -4.75577228e-02f, -1.77408606e-01f, 5.10348454e-02f, -1.86438516e-01f, 1.73572041e-02f, 2.40526080e-01f, 2.96551496e-01f, -6.34565949e-02f,
  1.20298781e-01f, 2.99046963e-01f, -3.03756893e-01f, 1.76748931e-02f, 1.55801013e-01f, -1.49336457e-01f, -1.24204658e-01f, -8.14289227e-02f, -4.02701758e-02f, -1.82336077e-01f,
  1.30701214e-01f, 1.01595996e-02f, 2.96220407e-02f, 1.51771819e-02f, 1.45491706e-02f, -7.57283568e-02f, -7.95114506e-03f, -1.48836449e-01f, -2.70370543e-01f, 5.26642390e-02f,
  4.27309684e-02f, 2.98156887e-01f, 2.60809660e-01f, -9.38098878e-02f, -6.85647801e-02f, -4.54453006e-02f, 1.36448056e-01f, 1.30679846e-01f, 3.18083121e-03f, -1.39017358e-01f,
  -9.08070207e-02f, 2.30121091e-02f, 1.25827134e-01f, 1.03047946e-02f, -1.07066102e-01f, -1.18647255e-01f, -1.21392623e-01f, 5.46530932e-02f, -1.45873772e-02f, 1.03820476e-03f,
  -1.27842024e-01f, -2.78246850e-02f, -1.46499261e-01f, -1.22314773e-01f, -2.16226697e-01f, -5.02099423e-03f, -4.22104709e-02f, -6.00659214e-02f, -1.76141784e-02f, 8.89518484e-03f,
  4.76293452e-02f, -1.27916934e-03f, -3.11220735e-02f, -5.48683517e-02f, -6.03620708e-02f, -1.24900132e-01f, -1.19195342e-01f, -7.73543771e-03f, 2.95740180e-02f, 4.19421196e-02f,
  -1.87883988e-01f, 1.36927217e-01f, -2.69698441e-01f, -2.39382833e-02f, 8.04404914e-02f, 4.31921780e-02f, 5.76616451e-02f, -2.68093520e-03f, 1.24743305e-01f, -1.36031955e-01f,
  1.22037537e-01f, -6.23736270e-02f, 4.72806580e-02f, -1.33432513e-02f, -1.53401181e-01f, 9.90719162e-03f, 1.14526398e-01f, -4.20763567e-02f, -1.32372543e-01f, 1.39396071e-01f,
  -1.08596101e-01f, -8.84712711e-02f, -1.43495962e-01f, -2.81933755e-01f, -1.61013678e-01f, -2.77281344e-01f, -8.22270513e-02f, -3.47329900e-02f, -2.33141240e-02f, -2.61803925e-01f,
  -3.74804348e-01f, 1.43286988e-01f, 4.91748117e-02f, -9.71899107e-02f, 4.11840260e-01f, 1.07394390e-01f, -2.31046140e-01f, -2.55257487e-01f, 3.75994202e-03f, 1.73104480e-02f,
  3.69107753e-01f, 2.67662078e-01f, -2.02534925e-02f, -5.14061712e-02f, -3.53468239e-01f, -2.17993453e-01f, -1.39004260e-01f, -2.71445125e-01f, -1.48465365e-01f, 1.30980179e-01f,
  2.08325475e-01f, -1.16535172e-01f, -2.57497758e-01f, -2.21711800e-01f, 8.77702087e-02f, 3.31565030e-02f, -7.67724812e-02f, 6.16263412e-02f, -1.83831155e-02f, 5.83811328e-02f,
  -1.23932548e-01f, 9.33582988e-03f, 7.66446516e-02f, 1.94970846e-01f, 2.25846127e-01f, -2.07321241e-01f, -1.03591949e-01f, -8.15095603e-02f, -1.42557332e-02f, -1.08769566e-01f,
  1.49138421e-01f, 8.86324495e-02f, 9.21616703e-02f, -5.91316447e-02f, -4.22574691e-02f, -1.19278990e-01f, -1.38778433e-01f, -1.87115073e-01f, -2.10345864e-01f, 3.65959620e-03f,
  2.10545167e-01f, 2.49821037e-01f, -8.46969187e-02f, -1.21475324e-01f, -2.53910899e-01f, -1.53052792e-01f, -2.01570258e-01f, -1.74755290e-01f, -3.79854739e-01f, -3.23487699e-01f,
  -4.15337458e-02f, 1.83174703e-02f, -3.37542109e-02f, 5.64789586e-03f, -1.58553421e-01f, 5.73722906e-02f, 3.97622259e-03f, -3.75065058e-02f, -6.24421577e-04f, -2.51369011e-02f,
  1.62444323e-01f, 8.05828869e-02f, 5.27789854e-02f, 3.01202871e-02f, 4.72786725e-02f, 1.28256649e-01f, 5.98545894e-02f, -1.39303446e-01f, -9.97523442e-02f, -2.14614142e-02f,
  4.92378213e-02f, -4.68603000e-02f, 7.01775551e-02f, -3.89453210e-02f, 4.78389254e-03f, -1.01280928e-01f, -1.61429904e-02f, 6.43248409e-02f, 9.32345837e-02f, 1.41555397e-02f,
  -2.13539168e-01f, -1.37237623e-01f, -1.15905359e-01f, 9.18250233e-02f, 1.74925271e-02f, -9.86949541e-03f, -3.51491780e-03f, 2.38143336e-02f, 4.93829735e-02f, -1.31364027e-02f,
  6.16579652e-02f, -2.93106288e-02f, -7.36625493e-02f, -3.75415608e-02f, -1.13635644e-01f, -2.48658173e-02f, -8.43617618e-02f, 1.00354990e-03f, 6.67741476e-03f, 4.11823019e-02f,
  -8.68366063e-02f, -2.37318203e-01f, -2.04057679e-01f, -2.20179319e-01f, -1.60146728e-01f, -2.48907238e-01f, -3.40532929e-01f, -2.25490540e-01f, -4.04558450e-01f, -5.73161662e-01f,
  -6.51016086e-02f, -2.57668234e-02f, -9.20365453e-02f, 1.20893151e-01f, 6.27361238e-02f, -1.78880781e-01f, -2.88897276e-01f, -1.93126976e-01f, 1.11128964e-01f, -3.45474519e-02f,
  5.89228608e-02f, 3.69638950e-03f, -8.32151622e-02f, -2.30180755e-01f, -4.43426251e-01f, -3.35211217e-01f, -1.87446684e-01f, -3.17299902e-01f, -3.84389430e-01f, -2.79978633e-01f,
  6.34847209e-03f, -6.42141774e-02f, -1.74524501e-01f, -1.18686050e-01f, 1.79249972e-01f, 1.37115821e-01f, 1.22587726e-01f, 5.99469803e-02f, -6.19040206e-02f, 1.34149164e-01f,
  -1.11696370e-01f, -5.43611459e-02f, -8.39576423e-02f, 2.05155183e-03f, 1.07536942e-01f, 3.53828333e-02f, -2.97197029e-02f, 7.68587664e-02f, -1.24557652e-02f, -9.55025256e-02f,
  3.81127037e-02f, -3.33303735e-02f, 3.71102020e-02f, 8.36043134e-02f, -1.08857285e-02f, -1.36128977e-01f, -3.71620357e-02f, -1.91086411e-01f, -6.99643865e-02f, -4.07385081e-02f,
  6.06669188e-02f, -3.52714546e-02f, -2.13925868e-01f, -5.17983697e-02f, -1.39671698e-01f, 3.06185484e-02f, -7.31583461e-02f, 3.92527729e-02f, -4.50374931e-03f, 5.31593747e-02f,
  1.10583482e-02f, -9.39639211e-02f, 2.43875030e-02f, 3.72762568e-02f, -2.65416000e-02f, 6.89789951e-02f, -1.88558828e-02f, -5.01162782e-02f, -2.94331275e-02f, -6.36211932e-02f,
  2.03822069e-02f, 3.34573053e-02f, -1.03119807e-02f, -1.43223740e-02f, -9.00212154e-02f, -7.05996826e-02f, 5.78069035e-03f, -5.38247526e-02f, -6.17208816e-02f, -2.78817792e-03f,
  -2.83687413e-02f, -3.04358406e-03f, 1.40919581e-01f, -5.00657074e-02f, 8.19026399e-03f, 5.77629590e-03f, 1.72677599e-02f, -7.63329193e-02f, -3.94443162e-02f, -2.78133508e-02f,
  1.37606010e-01f, -5.39248362e-02f, -1.34327998e-02f, -1.19470365e-01f, -8.54993984e-02f, 2.35249251e-01f, 2.07706496e-01f, 8.34422410e-02f, 1.88218765e-02f, -3.80745456e-02f,
  -1.33333012e-01f, -3.35041508e-02f, -2.65368037e-02f, 3.62448134e-02f, -8.64430740e-02f, -4.92263958e-02f, -7.02188313e-02f, 7.65825156e-03f, -5.96340671e-02f, 1.43677816e-01f,
  5.03959320e-03f, -1.04226224e-01f, -2.16492489e-01f, -8.68891850e-02f, -7.18847439e-02f, -1.03035606e-01f, -8.39783326e-02f, -4.37869914e-02f, -1.92039013e-01f, -1.13314129e-01f,
  -7.24219322e-01f, 3.99943590e-02f, -7.45777786e-02f, -3.43598425e-01f, -4.13390279e-01f, -3.51163000e-01f, -1.37026310e-01f, -2.04455137e-01f, -2.23635867e-01f, 1.22049250e-01f,
  1.20725811e-01f, 8.70683566e-02f, 1.53823957e-01f, 1.83036961e-02f, 7.68188247e-03f, 7.12882802e-02f, -9.50340033e-02f, -3.63667279e-01f, -4.42409605e-01f, -3.65113974e-01f,
  -2.92880028e-01f, -4.22288507e-01f, -5.11094451e-01f, -2.81923950e-01f, -9.64101255e-02f, -3.30482543e-01f, -1.43021613e-01f, -4.12518144e-01f, -3.08486938e-01f, -2.93346018e-01f,
  3.16259027e-01f, -2.63533562e-01f, -1.11886226e-01f, -1.54890180e-01f, -4.60257530e-02f, 1.54303003e-03f, -8.66261050e-02f, 2.16136742e-02f, -1.22764166e-02f, 1.67266697e-01f,
  -7.67015852e-03f, 1.47910612e-02f, -2.93678418e-02f, 4.44538929e-02f, -8.27026814e-02f, 2.17938889e-02f, 1.14964388e-01f, -1.14478111e-01f, -1.04328208e-02f, 1.30260095e-01f,
  1.61611542e-01f, -5.32878600e-02f, -5.48787601e-02f, 7.46850669e-02f, -4.61863242e-02f, -1.56620681e-01f, 1.28894225e-01f, 1.49881234e-02f, -1.03031673e-01f, 4.79985401e-02f,
  -2.83202846e-02f, 2.09522665e-01f, -3.51817831e-02f, -9.52697173e-02f, 7.28944615e-02f, 2.61920542e-02f, -1.38730817e-02f, 5.35884872e-02f, -2.94730123e-02f, -4.32252288e-02f,
  -3.88053544e-02f, -9.49753355e-03f, -1.38927409e-02f, -1.14335202e-01f, 1.45594841e-02f, -2.41515860e-02f, 2.43241545e-02f, 8.93261507e-02f, 4.58030999e-02f, 2.70126220e-02f,
  -4.37409952e-02f, -8.14581662e-02f, -3.15718129e-02f, 7.98368901e-02f, -9.34042409e-02f, 1.69847067e-02f, 2.95079034e-02f, 2.09649783e-02f, 4.31707539e-02f, 8.29343349e-02f,
  4.88510169e-02f, -1.58325940e-01f, 6.61248050e-04f, -2.88087316e-02f, 2.45634690e-02f, 1.67602003e-01f, 4.18505222e-02f, -2.93191765e-02f, -2.10123938e-02f, 7.83651099e-02f,
  -9.28961392e-03f, 1.34573519e-01f, 7.23710507e-02f, 7.96268061e-02f, 6.96039898e-03f, 5.17153405e-02f, 1.99430406e-01f, 5.04932541e-04f, 5.93414642e-02f, 2.28162244e-01f,
  2.76991725e-01f, 1.39889672e-01f, 1.85071841e-01f, 1.62472278e-01f, -2.33039837e-02f, -7.15220198e-02f, 1.55646011e-01f, 5.81075549e-02f, 2.82283127e-02f, 1.98131487e-01f,
  -3.57456982e-01f, -4.23250139e-01f, 1.25707120e-01f, 7.21742138e-02f, 1.04697332e-01f, -8.20545554e-02f, -2.74673671e-01f, -9.46870670e-02f, 9.96318161e-02f, -1.31374016e-01f,
  -1.53207004e-01f, 4.99605015e-02f, 5.22506721e-02f, 7.01606348e-02f, 1.14416137e-01f, 1.17398217e-01f, 3.64785969e-01f, 3.75661165e-01f, 1.78802237e-01f, -7.41506740e-02f,
  3.97528410e-02f, 8.54353458e-02f, 1.19198948e-01f, 1.04068175e-01f, -8.54928046e-02f, 1.60399303e-01f, 6.31092712e-02f, 1.11106806e-01f, -1.20264463e-01f, 1.73691273e-01f,
  1.72502939e-02f, -7.80290663e-02f, 9.17844325e-02f, 1.30364373e-01f, -6.17659315e-02f, -6.76044903e-04f, -3.22793014e-02f, -5.96707687e-04f, -8.06533790e-04f, 6.63390383e-02f,
  -1.22513168e-03f, 3.46289761e-02f, 6.84109330e-02f, -3.67004797e-02f, -7.60289095e-03f, 1.66033152e-02f, -1.29522264e-01f, -2.80603021e-02f, 8.09320062e-02f, -6.63592247e-03f,
  5.73797617e-03f, -2.06192601e-02f, 4.20726761e-02f, -2.02414431e-02f, -6.07060343e-02f, 1.09735772e-01f, -4.63773124e-02f, -9.99622494e-02f, 1.02176689e-01f, -1.27307609e-01f,
  8.39899853e-03f, -5.51461168e-02f, 1.64050490e-01f, 1.11064136e-01f, 9.87662822e-02f, -7.86014460e-03f, 4.81390115e-03f, -8.83641001e-03f, 1.64155841e-01f, 6.26766682e-02f,
  -1.82487611e-02f, 1.79452613e-01f, 1.36301026e-01f, -2.28077844e-02f, 1.93918362e-01f, -3.58332172e-02f, -1.48152479e-03f, 1.06098808e-01f, 1.56378895e-01f, 8.35731477e-02f,
  8.63484070e-02f, -5.25954701e-02f, 1.19457170e-01f, 8.37978274e-02f, -9.96638536e-02f, 1.77926850e-02f, 5.69182634e-02f, 1.90395489e-02f, 2.03844812e-03f, -9.08334777e-02f,
  -1.57778747e-02f, 4.10748631e-01f, 1.42947227e-01f, 6.28302246e-02f, -4.84205931e-02f, -2.54817661e-02f, 8.09322298e-02f, -5.27036265e-02f, 2.27961186e-02f, 6.53826594e-02f,
  5.92345893e-02f, 1.05272613e-01f, 2.21851922e-04f, -9.43618938e-02f, 3.54954191e-02f, -3.15591842e-02f, -1.88127920e-01f, -1.37191519e-01f, 9.06641185e-02f, 2.17693355e-02f,
  -9.30770114e-02f, -1.11868784e-01f, 7.33336955e-02f, 3.56704146e-02f, -3.55677120e-02f, 4.68483455e-02f, 2.76835095e-02f, -4.50977124e-02f, 9.68049243e-02f, -1.12047732e-01f,
  -4.21736389e-01f, -1.16576597e-01f, -6.08013198e-02f, 2.53188699e-01f, 2.87719637e-01f, 3.56524885e-01f, 1.58404246e-01f, 2.40861580e-01f, 2.67852247e-01f, 1.71225652e-01f,
  1.75947145e-01f, 1.27575129e-01f, 2.62730658e-01f, 2.32378170e-01f, 2.06231058e-01f, 2.05020577e-01f, 3.22845966e-01f, -3.47422552e-03f, 1.51888520e-01f, 1.96505949e-01f,
  2.80616999e-01f, 1.23541586e-01f, 2.12821756e-02f, 1.64163709e-01f, 9.94664207e-02f, 2.31046319e-01f, 2.74121404e-01f, 1.71108663e-01f, 1.87063962e-01f, 1.63655221e-01f,
  3.35296690e-02f, -1.61292300e-01f, 3.69936675e-02f, -6.88579008e-02f, -2.27069035e-01f, -1.47592649e-01f, -1.64570920e-02f, -2.18909588e-02f, -1.33785829e-01f, -9.09196213e-02f,
  -2.62400806e-02f, -1.79174289e-01f, -1.16250023e-01f, -3.01343966e-02f, -9.91089195e-02f, -1.03122003e-01f, -7.44007528e-02f, 3.13402489e-02f, -2.24652383e-02f, 4.06312011e-02f,
  -3.76446284e-02f, -6.12802571e-03f, 5.40439337e-02f, 1.05180487e-01f, 8.58120695e-02f, -6.97215423e-02f, -5.50956614e-02f, -7.94943869e-02f, -1.69439297e-02f, -5.47971055e-02f,
  2.12210268e-01f, 8.25603455e-02f, 1.89566873e-02f, 5.59709482e-02f, 8.63152295e-02f, -6.37347922e-02f, 1.42847255e-01f, 1.66914195e-01f, 1.43335596e-01f, 2.84990035e-02f,
  4.25884090e-02f, 4.42774743e-02f, 1.31981866e-02f, 1.02959752e-01f, -1.53836980e-01f, -3.24870348e-02f, -1.08631447e-01f, -2.55375467e-02f, -1.59461617e-01f, -8.78745839e-02f,
  -8.42475817e-02f, 3.94843556e-02f, -1.69033080e-01f, -1.29455179e-01f, -2.50646169e-03f, 1.31074395e-02f, 1.33860990e-01f, -2.77266577e-02f, 1.03101879e-02f, -1.68907959e-02f,
  3.25939536e-01f, -4.37474763e-03f, 1.24198422e-01f, -4.59895059e-02f, -9.67058390e-02f, -1.76264733e-01f, 7.94169977e-02f, -6.16862103e-02f, -5.96436448e-02f, -2.38326583e-02f,
  -2.50993986e-02f, -1.13039553e-01f, 4.19597253e-02f, 1.34462386e-01f, 1.03135640e-02f, -5.03892936e-02f, -2.41168346e-02f, 5.51649928e-02f, 1.76053926e-01f, 5.39377481e-02f,
  -1.31036742e-02f, 1.58463374e-01f, 1.40336886e-01f, 1.17550470e-01f, 2.48084068e-01f, 9.57934037e-02f, 1.75644144e-01f, 1.69612020e-02f, 1.15421385e-01f, 2.19347626e-01f,
  -1.65964812e-01f, -5.08337989e-02f, -4.09732997e-01f, -1.91546679e-01f, -1.49062157e-01f, 1.03263920e-02f, 1.37361705e-01f, 2.39587985e-02f, -1.23781813e-02f, 4.95345658e-03f,
  -2.49805935e-02f, -2.01078787e-01f, -3.54725122e-01f, -2.00700685e-01f, -1.96300507e-01f, -1.31743237e-01f, -2.09942564e-01f, -3.25009495e-01f, -9.78529006e-02f, 1.45781100e-01f,
  -2.30394490e-03f, -1.84906736e-01f, -2.20275089e-01f, -1.49067089e-01f, -6.00113943e-02f, -2.35396609e-01f, -2.28194416e-01f, -2.04150021e-01f, -1.11649558e-01f, -2.21918702e-01f,
  -1.72202930e-01f, -1.87964082e-01f, 2.99867918e-03f, -7.64403492e-02f, -2.03277450e-02f, 3.93887050e-02f, 3.94472443e-02f, -1.07692704e-01f, -1.71557218e-02f, 1.29042296e-02f,
  -5.60301691e-02f, 9.93154868e-02f, -6.12967368e-03f, -3.74969654e-02f, -5.73837496e-02f, 3.21835466e-02f, -1.65312931e-01f, -1.15574159e-01f, -1.00290671e-01f, 1.27785757e-01f,
  1.07470505e-01f, -1.06759541e-01f, -2.58669853e-01f, 5.00383181e-03f, 3.88009287e-03f, -1.06777005e-01f, -2.42256746e-02f, 9.52839330e-02f, -6.60997853e-02f, 1.26307335e-04f,
  2.22884580e-01f, 3.68860289e-02f, -6.76434562e-02f, 1.04645401e-01f, 8.49205479e-02f, -8.31358358e-02f, -1.06810369e-02f, 5.36618456e-02f, 5.27874157e-02f, -3.36499289e-02f,
  4.09752615e-02f, 6.40936494e-02f, 5.79448305e-02f, -9.48393866e-02f, -4.68377545e-02f, -5.69224954e-02f, -7.20800832e-03f, 2.56200116e-02f, -4.30900566e-02f, -4.75257589e-03f,
  -6.66048601e-02f, -1.56559031e-02f, -2.72928621e-03f, 7.58419409e-02f, 3.63343544e-02f, -1.62194781e-02f, -5.27867749e-02f, 5.18520065e-02f, -1.62893217e-02f, 7.42345005e-02f,
  -2.85582662e-01f, -1.18795902e-01f, -1.19730398e-01f, -6.01190254e-02f, -4.38593701e-02f, 6.96562529e-02f, -6.72491938e-02f, 9.27218869e-02f, 5.55895793e-04f, 1.12196244e-01f,
  5.91746122e-02f, 1.74737066e-01f, -4.88240756e-02f, 8.32921863e-02f, 7.67859221e-02f, 3.28633003e-04f, 3.10489871e-02f, -1.32458702e-01f, -1.02094047e-01f, 9.17661637e-02f,
  -8.20284151e-03f, -5.52508943e-02f, -1.42283723e-01f, -1.50788695e-01f, 6.75474480e-02f, -1.92594334e-01f, -1.07189871e-01f, -1.09359715e-02f, -8.17812830e-02f, 1.99342053e-02f,
  -3.79777014e-01f, -1.55413404e-01f, 3.75202626e-01f, -3.21129680e-01f, 8.03898051e-02f, -1.43818617e-01f, -5.56737244e-01f, -5.51935196e-01f, -2.38233268e-01f, -3.26444626e-01f,
  6.24433309e-02f, 2.71385401e-01f, 2.73147196e-01f, 3.43089513e-02f, -3.70319128e-01f, -5.18212974e-01f, -2.89512396e-01f, 2.40086708e-02f, 8.16831961e-02f, -2.50765055e-01f,
  -1.02910064e-01f, -9.18368325e-02f, -5.29688131e-03f, 2.95211505e-02f, -7.70316273e-03f, 3.01470846e-01f, 1.98353440e-01f, 7.82557726e-02f, 1.35015056e-01f, 1.04280397e-01f,
  1.11133251e-02f, -2.84415871e-01f, 1.01295143e-01f, 1.04898930e-01f, 1.50681688e-02f, -3.45195904e-02f, -1.64511055e-01f, -1.31078549e-02f, 3.27507481e-02f, -1.38593704e-01f,
  1.55977294e-01f, -5.73579315e-03f, -1.09182596e-01f, 5.13567328e-02f, -2.40702659e-01f, -1.18161164e-01f, -1.14040062e-01f, -6.04286492e-02f, -9.16039050e-02f, -2.81017236e-02f,
  3.18835117e-02f, 3.41667421e-02f, 1.01392426e-01f, 1.92453526e-02f, -1.21677913e-01f, 2.45787054e-01f, 2.14338601e-01f, 1.01610392e-01f, 8.74723494e-03f, -9.61836353e-02f,
  1.44340424e-02f, 1.20310858e-01f, 6.43779114e-02f, 3.92383561e-02f, 5.08229434e-02f, 1.38979182e-01f, -9.01505500e-02f, -9.78025049e-02f, 1.20330408e-01f, -1.50920134e-02f,
  6.25967160e-02f, 1.77915059e-02f, 6.36754483e-02f, -9.94047225e-02f, 1.61883175e-01f, 3.52166779e-02f, -5.14674708e-02f, 3.92725952e-02f, 7.35269710e-02f, 1.97324958e-02f,
  7.50997737e-02f, 9.49879643e-03f, 7.31890574e-02f, -3.33218426e-02f, 2.58808732e-02f, -4.12051231e-02f, 4.13408838e-02f, 1.24445423e-01f, 6.94516599e-02f, 8.39512125e-02f,
  8.77561420e-02f, 2.41949167e-02f, -1.71727911e-01f, -7.12361634e-02f, -4.99137379e-02f, 1.94915280e-01f, 1.57736301e-01f, 4.07341914e-03f, 1.21002041e-01f, 3.55671979e-02f,
  6.68717083e-03f, -7.46607706e-02f, -1.07464403e-01f, 2.55244481e-03f, -9.12404433e-02f, 1.02605008e-01f, -2.01602861e-01f, 5.03648408e-02f, 2.79181264e-02f, 1.09288983e-01f,
  -1.35204017e-01f, -2.80076146e-01f, -2.09778979e-01f, 6.98236655e-03f, -1.62828296e-01f, -1.43766515e-02f, 1.88815758e-01f, 1.22112915e-01f, -6.68409020e-02f, -2.68988729e-01f,
  -3.98548394e-01f, 2.69390970e-01f, -1.12319872e-01f, -6.86351508e-02f, -5.55281676e-02f, -3.82390618e-01f, -1.00922287e-01f, -2.83681929e-01f, -1.64073974e-01f, 1.96018726e-01f,
  1.80114344e-01f, -5.35457879e-02f, -6.04905188e-02f, -2.23089680e-01f, -3.20159167e-01f, -2.28013024e-02f, -1.45769283e-01f, -4.63554710e-01f, -6.09208286e-01f, -3.72888178e-01f,
  -1.03869088e-01f, -1.80638507e-01f, -3.27573687e-01f, -1.14196062e-01f, 1.74246386e-01f, 1.30764276e-01f, 7.66643137e-02f, -5.99840581e-02f, 9.00333673e-02f, 3.02532434e-01f,
  2.60819077e-01f, -1.84929281e-01f, -9.30190235e-02f, -4.07694057e-02f, -5.58970571e-02f, -5.38874529e-02f, -1.04600906e-01f, -2.12231517e-01f, -1.77153721e-02f, 5.20039052e-02f,
  -4.72881161e-02f, -7.19143823e-02f, -1.57314971e-01f, -4.11377139e-02f, -1.28488898e-01f, -7.83921853e-02f, -5.03161340e-04f, -3.14407609e-02f, -4.28121118e-03f, 1.30185500e-01f,
  1.06335334e-01f, -1.23515166e-02f, -1.28929950e-02f, -3.44604440e-02f, -7.14050233e-02f, -6.58776835e-02f, 1.25519201e-01f, -8.02446306e-02f, -9.45022926e-02f, 7.97100812e-02f,
  -2.44539231e-02f, 3.12386602e-02f, -1.08196303e-01f, 5.83576597e-02f, 8.01018924e-02f, -1.97619572e-02f, 3.02530155e-02f, -4.72424552e-02f, -8.83891732e-02f, -5.71428798e-02f,
  6.30233586e-02f, 9.47381929e-02f, -5.06207757e-02f, 2.60307007e-02f, -3.38975601e-02f, -4.50532399e-02f, 2.29216856e-03f, 9.73634645e-02f, 3.88359912e-02f, 1.99041087e-02f,
  -6.63012043e-02f, -2.44373605e-02f, 1.00701839e-01f, -4.96640913e-02f, 2.89882272e-02f, 1.39768599e-02f, 2.74515874e-03f, 3.67647898e-03f, -9.35007259e-02f, -1.19717464e-01f,
  2.08526343e-01f, -2.44230822e-01f, 1.12712607e-01f, -4.77121286e-02f, -1.75347656e-03f, -1.96758583e-02f, 6.91965893e-02f, 5.55482656e-02f, 8.18288699e-02f, -8.81182179e-02f,
  -2.06057448e-02f, -1.00807711e-01f, 6.22741319e-03f, 1.93328653e-02f, -1.37135208e-01f, -2.53166556e-02f, 1.24698713e-01f, 5.36088869e-02f, -4.86139469e-02f, 2.25359038e-01f,
  1.82175070e-01f, -2.91565154e-02f, 4.93261106e-02f, 6.89132288e-02f, 1.19547723e-02f, -1.16078578e-01f, 3.48064117e-02f, 5.17290980e-02f, -8.32586959e-02f, 2.84110308e-01f,
  5.27085781e-01f, 4.00655158e-02f, 2.01922804e-01f, 5.58629520e-02f, -3.15208048e-01f, -5.93042821e-02f, -1.52536593e-02f, 1.83290362e-01f, 7.37675726e-02f, -4.39514257e-02f,
  -2.33328670e-01f, -2.35349283e-01f, -1.75748497e-01f, -1.25346169e-01f, 8.02976415e-02f, 1.06933847e-01f, 5.83220795e-02f, 1.62132457e-01f, 1.22598939e-01f, -5.66495350e-03f,
  -9.14533213e-02f, 1.12681434e-01f, 1.84438974e-01f, 5.63592948e-02f, 7.50597715e-02f, -1.03088886e-01f, 1.26092499e-02f, -3.75792272e-02f, -1.07869752e-01f, 1.31166592e-01f,
  -5.40381745e-02f, 7.58167207e-02f, -1.25587881e-01f, -1.57748356e-01f, -3.53624821e-02f, 3.03226691e-02f, -1.71769727e-02f, 7.38700479e-02f, -6.83746710e-02f, 4.29677889e-02f,
  -9.65400338e-02f, 1.99848157e-03f, -2.41478547e-01f, -7.29537010e-02f, -4.49889936e-02f, -9.42501202e-02f, 6.93719611e-02f, 2.27540750e-02f, 4.65490203e-03f, -9.33317095e-02f,
  -1.54566392e-01f, -9.54672098e-02f, -2.54445360e-03f, -3.78251411e-02f, -1.03017181e-01f, -2.37734258e-01f, -5.31637743e-02f, -7.04992414e-02f, -4.11362797e-02f, 1.07377321e-01f,
  -6.63401559e-03f, 9.71357524e-02f, -7.59564266e-02f, 9.37595032e-03f, -8.32922980e-02f, -5.24708861e-03f, -2.51013711e-02f, -3.46723534e-02f, -4.64515686e-02f, 4.97978628e-02f,
  3.19694877e-02f, -1.04423769e-01f, -6.72199801e-02f, 3.24542783e-02f, -7.99195319e-02f, 1.00307083e-02f, -2.00674459e-02f, 2.35590469e-02f, -3.91372363e-04f, -7.94636551e-03f,
  -1.36333644e-01f, 3.01872268e-02f, 6.13491423e-02f, -1.93335419e-03f, 5.79183698e-02f, 1.73193570e-02f, 2.86954511e-02f, -5.70697710e-02f, 8.34909305e-02f, -2.51560584e-02f,
  -2.48532772e-01f, -3.71430606e-01f, 2.57152710e-02f, 1.64263267e-02f, -2.00438891e-02f, -6.28698766e-02f, -2.26976067e-01f, -7.76040480e-02f, -8.26272834e-03f, 3.88476811e-02f,
  -6.87980652e-02f, 2.94834916e-02f, -9.99190509e-02f, -8.77125785e-02f, -5.74811175e-02f, -3.61542068e-02f, -1.21644184e-01f, 1.75691955e-02f, -4.00554836e-02f, -3.75104435e-02f,
  -3.00118346e-02f, -8.73682182e-03f, 6.42590597e-02f, -8.54338929e-02f, -9.08397064e-02f, -1.14218734e-01f, -7.29795918e-02f, -5.37677519e-02f, 7.30581656e-02f, 2.04803899e-01f,
  -3.87175530e-01f, 1.84630647e-01f, 3.45087707e-01f, 8.45365152e-02f, 2.25088850e-01f, 6.30225763e-02f, -3.55445854e-02f, -5.30203097e-02f, -3.43194976e-02f, 1.30578056e-01f,
  8.21188092e-02f, -1.11421578e-01f, 9.72470194e-02f, -2.96116304e-02f, -1.51956752e-01f, 1.77038148e-01f, 2.23147616e-01f, -1.25707671e-01f, -3.26630890e-01f, -3.36827546e-01f,
  -2.64441166e-02f, -9.43661258e-02f, -1.47785962e-01f, -7.31949210e-02f, 2.46252060e-01f, 4.68371399e-02f, 3.02074492e-01f, 1.10830583e-01f, 6.46242127e-02f, 1.95679367e-01f,
  -5.85666858e-02f, -7.38906413e-02f, -2.28791296e-01f, -1.90619037e-01f, 8.89391154e-02f, -1.67419314e-01f, -1.06856376e-01f, 1.52707230e-02f, -1.06927879e-01f, -9.69689488e-02f,
  -1.25099150e-02f, -9.15714577e-02f, 1.76045522e-01f, -1.03231624e-01f, -1.20220333e-01f, -1.79163128e-01f, -1.24570161e-01f, -2.62139082e-01f, -1.63509771e-01f, -1.34751305e-01f,
  -2.39118608e-03f, -1.01371720e-01f, 4.86137420e-02f, -8.47975258e-03f, 6.23861551e-02f, -5.19886129e-02f, -8.13605934e-02f, -1.62934065e-01f, -1.79388955e-01f, -1.67199239e-01f,
  -1.66551247e-01f, -1.83427513e-01f, 1.68569796e-02f, 1.14505412e-02f, -3.49017642e-02f, 1.84450578e-02f, 7.05522671e-02f, 6.32598400e-02f, 3.46201770e-02f, -6.41404139e-03f,
  -9.57565382e-02f, -6.13176823e-02f, -6.80917948e-02f, 5.02131879e-02f, 2.51941308e-02f, -6.25224560e-02f, -1.22685269e-01f, -5.17465323e-02f, 8.26026499e-02f, -6.90576583e-02f,
  2.22565047e-02f, 1.53225839e-01f, 8.10810700e-02f, -7.89679936e-04f, -9.25594196e-03f, 5.89656308e-02f, -1.26592770e-01f, -8.81753266e-02f, -2.80640852e-02f, -1.82319339e-02f,
  -1.47109956e-01f, -5.08049875e-02f, -1.59960672e-01f, -7.58328438e-02f, 2.84814481e-02f, 8.90947878e-02f, -3.70232010e-04f, 7.65207922e-03f, 9.33731273e-02f, -9.09405947e-02f,
  -4.85289469e-02f, -1.07806429e-01f, 1.78419128e-01f, -1.31210536e-01f, -2.04029709e-01f, -3.47173586e-02f, -6.27824813e-02f, 1.09632360e-02f, -5.36582135e-02f, 6.13941886e-02f,
  6.08989410e-02f, -2.08356500e-01f, -5.91640584e-02f, 9.28456858e-02f, 4.39548120e-02f, -2.02838615e-01f, -1.20049313e-01f, -1.85798332e-01f, -1.28944308e-01f, -2.32122049e-01f,
  6.22605264e-01f, -6.21398985e-01f, -3.47702652e-01f, -1.88759491e-01f, -1.09465353e-01f, 5.33054657e-02f, -2.93930560e-01f, 7.58329332e-02f, 6.29259571e-02f, -3.31369460e-01f,
  -2.66994298e-01f, 1.85390431e-02f, -1.73895434e-01f, -9.62556303e-02f, -3.05110309e-02f, -3.24199796e-01f, -2.41908863e-01f, 2.09268644e-01f, 4.60978836e-01f, 3.31456333e-01f,
  -8.23999289e-03f, 9.05956924e-02f, 2.95641512e-01f, -3.61688435e-02f, -2.93802083e-01f, -1.32578209e-01f, -2.47692615e-01f, -1.84462249e-01f, -2.51889616e-01f, -4.56426710e-01f,
  -3.53355944e-01f, -6.35932386e-02f, 2.13080302e-01f, 1.02422237e-01f, -1.25115529e-01f, 3.57536711e-02f, -2.57148128e-02f, -6.71417117e-02f, -3.58403698e-02f, -1.10593468e-01f,
  -8.12689587e-02f, 8.77931193e-02f, 1.28715299e-02f, -4.21091691e-02f, 8.59416649e-02f, 5.49099855e-02f, 1.46361366e-01f, 1.37404623e-02f, -2.97541935e-02f, -2.39373833e-01f,
  -2.01824680e-01f, -2.89957933e-02f, 2.85652000e-02f, 1.56145275e-01f, 1.88940555e-01f, 1.82017177e-01f, 2.70665362e-02f, -1.62404682e-02f, 1.78308055e-01f, -1.34801827e-02f,
  -4.54535894e-02f, -5.45509234e-02f, 5.85515276e-02f, 1.33765325e-01f, 1.70148894e-01f, 1.81594029e-01f, 4.44585271e-02f, 6.60367459e-02f, 1.56640589e-01f, -1.45677254e-02f,
  -1.18395142e-01f, -7.22126663e-02f, 7.13662058e-02f, 2.13976502e-02f, -1.39741912e-01f, -9.27518010e-02f, 6.07093833e-02f, -9.83804986e-02f, 5.82066737e-02f, 1.47622300e-03f,
  1.25199482e-01f, -1.20949738e-01f, -1.80765748e-01f, -4.23246399e-02f, -9.18531194e-02f, -2.35695634e-02f, -8.10602382e-02f, -1.17558077e-01f, -5.49422130e-02f, -4.00185734e-02f,
  -1.21524848e-01f, 1.77867293e-01f, 1.33663090e-02f, 7.50255138e-02f, 2.48174202e-02f, -7.79308332e-03f, -6.50345013e-02f, 8.93424228e-02f, -1.49222119e-02f, 4.44245376e-02f,
  -1.26425810e-02f, 1.99278221e-02f, -9.91921052e-02f, -5.49925724e-03f, 1.69377968e-01f, 2.67663717e-01f, 1.22305565e-01f, 9.63852480e-02f, -8.61489400e-02f, -1.16720125e-01f,
  -1.53905615e-01f, 1.80770174e-01f, 9.99830440e-02f, 6.03055991e-02f, 1.31331831e-01f, 2.54609853e-01f, 1.03240438e-01f, 1.26701593e-01f, 2.36823246e-01f, 1.24577500e-01f,
  -1.95043102e-01f, -5.87082028e-01f, 4.59594935e-01f, -2.01547801e-01f, -3.07490587e-01f, -3.78862977e-01f, -5.51817656e-01f, -3.10219198e-01f, -2.46518537e-01f, -3.80776912e-01f,
  -3.31011266e-01f, 3.45189450e-03f, 4.01614189e-01f, 1.38976455e-01f, 1.24439768e-01f, -1.22129932e-01f, 1.08313397e-01f, 3.02269489e-01f, 4.73844819e-02f, -5.90060234e-01f,
  -4.33043659e-01f, -4.49661352e-02f, 9.06302780e-02f, 1.22248843e-01f, -1.51159599e-01f, 1.92602500e-01f, 2.72562623e-01f, -7.42389113e-02f, -1.47725627e-01f, -1.92401707e-02f,
  1.89169109e-01f, -2.05983460e-01f, 1.93128392e-01f, -5.23837321e-02f, -7.60382682e-04f, -5.78851849e-02f, -4.92389351e-02f, 1.62747562e-01f, -1.10171892e-01f, -6.54898882e-02f,
  -8.55730847e-02f, -1.60547882e-01f, -3.39676514e-02f, 3.06806564e-02f, -1.14821881e-01f, -2.44421456e-02f, -3.34187746e-02f, -1.36661297e-02f, 8.20303708e-02f, -1.85893327e-01f,
  -2.17064574e-01f, -1.70529306e-01f, 1.10655978e-01f, 2.83454191e-02f, -1.63339302e-02f, 6.61679134e-02f, 7.31273368e-02f, -7.61649758e-02f, 2.15932503e-02f, -5.22850864e-02f,
  -1.00532174e-01f, 2.21005470e-01f, -1.59826763e-02f, 1.14336247e-02f, 6.82597086e-02f, -3.67651731e-02f, 6.42509311e-02f, 1.85123682e-02f, 1.14661843e-01f, 7.37019926e-02f,
  5.16005000e-03f, -2.97334213e-02f, 6.14243001e-02f, 4.64783683e-02f, 1.76325496e-02f, 2.48135719e-02f, 1.77109186e-02f, 1.18687920e-01f, -8.51758756e-03f, -6.37313630e-03f,
  4.09005173e-02f, 6.84464648e-02f, 2.91289594e-02f, 1.11227259e-01f, -9.63024721e-02f, -4.13282923e-02f, -1.22629383e-04f, -7.87175223e-02f, -8.61155167e-02f, -1.98862463e-01f,
  1.24893241e-01f, 1.32526401e-02f, 5.90129122e-02f, 9.46261436e-02f, -3.97302061e-02f, -1.38209462e-01f, -9.77940634e-02f, 3.14646214e-02f, -5.82007132e-02f, 3.63271870e-02f,
  -9.82058942e-02f, -1.13450512e-01f, 1.44793540e-01f, -7.90793728e-03f, -7.86847249e-02f, -4.09740657e-02f, -2.18383923e-01f, -5.73481359e-02f, -8.13858658e-02f, -9.82167721e-02f,
  -3.45468596e-02f, -9.86112654e-02f, 1.09912090e-01f, 1.90033749e-01f, -2.89644860e-02f, 8.84475559e-02f, 2.98964351e-01f, -1.16632283e-02f, 1.13566190e-01f, -5.26342774e-03f,
  -3.20463449e-01f, -5.58714494e-02f, 2.89730847e-01f, -9.98657644e-02f, 1.79657876e-01f, 2.12328181e-01f, 2.79631317e-01f, -3.16180736e-02f, -1.53427005e-01f, -1.26256675e-01f,
  -1.27503559e-01f, -3.57191384e-01f, -3.16824287e-01f, -2.97939688e-01f, -6.78334758e-02f, -4.88833860e-02f, -2.04255097e-02f, -9.82813304e-04f, 1.51299790e-01f, -2.12267763e-03f,
  -1.65961519e-01f, -4.33927812e-02f, -1.00377865e-01f, -1.84656829e-01f, -1.64717123e-01f, -8.30865726e-02f, -5.86702675e-02f, 1.19270980e-01f, 3.71018387e-02f, -2.92622626e-01f,
  3.46842736e-01f, 2.32980654e-01f, -1.67481489e-02f, -1.44199029e-01f, -1.52249669e-03f, -4.40458134e-02f, 9.21446308e-02f, -1.35457637e-02f, -7.50985593e-02f, 2.20280420e-02f,
  -1.93336811e-02f, 6.51578680e-02f, 2.89113587e-03f, 1.83210969e-01f, 2.74890214e-01f, 1.41425237e-01f, 1.00143760e-01f, -6.39820620e-02f, -1.11581199e-01f, 9.81441140e-02f,
  1.61873475e-02f, 1.68828264e-01f, 2.12952942e-01f, 7.91421309e-02f, 6.14861213e-02f, 9.20350030e-02f, 7.38502070e-02f, 2.41110139e-02f, 1.58728138e-01f, -1.06049120e-01f,
  -1.16845921e-01f, -2.13663921e-01f, 3.27889696e-02f, 1.03125542e-01f, 7.21549913e-02f, 8.01336765e-02f, -3.41596417e-02f, -9.17319730e-02f, -2.49827076e-02f, 3.52235064e-02f,
  1.05470151e-01f, 2.80376840e-02f, 8.74997973e-02f, 8.40407982e-02f, 9.22787786e-02f, 7.26733431e-02f, 5.47787324e-02f, 4.14061360e-02f, 8.37072954e-02f, 4.45997640e-02f,
  8.87437984e-02f, 2.45254207e-02f, 8.13344344e-02f, 1.62576422e-01f, 1.33308187e-01f, 1.46715939e-01f, 8.07008967e-02f, 1.19598508e-02f, 3.76626439e-02f, -3.14105451e-02f,
  6.84843212e-02f, 2.82562971e-01f, -1.94216982e-01f, -1.11309685e-01f, 4.87996601e-02f, -1.02653943e-01f, 2.83252243e-02f, 3.35804597e-02f, -5.37386537e-02f, 4.66834754e-02f,
  7.26755410e-02f, -1.05852084e-02f, 1.06651239e-01f, 1.46787688e-01f, 2.04638943e-01f, 1.15952246e-01f, -1.06981032e-01f, -1.42484009e-01f, -1.02041103e-01f, -4.38030101e-02f,
  -1.06483988e-01f, 7.61014745e-02f, 3.31567898e-02f, -7.95148953e-04f, -5.77976406e-02f, 8.26679245e-02f, 9.57596675e-02f, 5.67355715e-02f, 1.81734756e-01f, 6.51532784e-02f,
  -4.96986508e-01f, -8.31142515e-02f, 9.92786586e-02f, -1.74151167e-01f, 1.27171770e-01f, 1.15410939e-01f, 3.07793826e-01f, 5.29516116e-02f, -2.16158673e-01f, -3.01412016e-01f,
  -6.19963408e-02f, -1.54675484e-01f, -2.09547535e-01f, 6.04215637e-02f, 1.79480746e-01f, -2.10823100e-02f, 7.37029985e-02f, 1.42566979e-01f, 2.81916916e-01f, 1.69410735e-01f,
  9.07230005e-02f, 5.44883423e-02f, 2.67899949e-02f, 6.79500550e-02f, -2.71486372e-01f, -9.55820903e-02f, -1.27634823e-01f, -1.15038343e-02f, 6.89515322e-02f, -2.49975622e-01f,
  -2.68618226e-01f, -5.28331064e-02f, 1.10813051e-01f, 2.41053086e-02f, 6.92532733e-02f, -1.60934731e-01f, 3.55522404e-03f, -5.90535812e-02f, -3.39949913e-02f, -1.50847167e-01f,
  -5.39093353e-02f, 3.52981389e-02f, 1.62435102e-03f, 1.28910124e-01f, 8.38797539e-02f, 1.02191381e-01f, 8.10836256e-02f, 1.20364010e-01f, 9.91540551e-02f, 1.37170255e-01f,
  1.04998074e-01f, 6.02859911e-03f, 1.87455267e-02f, 1.60546064e-01f, 8.45231414e-02f, -6.36725267e-03f, 7.82964900e-02f, 5.89020699e-02f, 5.37639372e-02f, -3.58407617e-01f,
  6.01667315e-02f, 9.34010651e-03f, 1.11884929e-01f, -1.15976423e-01f, -1.51216937e-03f, -1.61926672e-01f, -1.68742165e-02f, -2.17099488e-02f, -6.51737303e-02f, -5.03364950e-02f,
  9.41991061e-02f, 3.72286998e-02f, 1.37194127e-01f, -9.41352248e-02f, -6.74849227e-02f, 8.52171273e-04f, 6.81663752e-02f, 1.71629190e-02f, -2.22554561e-02f, 6.10929914e-02f,
  -2.61870516e-03f, -2.15545427e-02f, 4.06984948e-02f, 8.21823329e-02f, -3.57798785e-02f, 8.73778537e-02f, -9.90574881e-02f, -6.43308684e-02f, -1.05713502e-01f, -4.63239998e-02f,
  -1.45564094e-01f, 4.53899592e-01f, -3.06233734e-01f, 1.26980633e-01f, -4.43829037e-02f, 9.31812152e-02f, -6.06529322e-03f, 7.91840106e-02f, 2.01956555e-03f, -4.75737778e-03f,
  7.69169256e-02f, 8.10522065e-02f, -9.21267457e-03f, 1.87795684e-01f, 6.84907958e-02f, -2.79205218e-02f, 8.67033377e-02f, 5.12180515e-02f, 1.61149353e-01f, 5.12876548e-02f,
  4.82011065e-02f, -8.18840414e-02f, -2.15003222e-01f, 6.02792539e-02f, -3.59661505e-02f, -1.76922709e-01f, -1.16854697e-01f, -4.93490584e-02f, -4.17934358e-02f, -3.38567019e-01f,
  2.32572392e-01f, 3.02671880e-01f, 1.79406166e-01f, 3.41413409e-01f, 2.31932253e-01f, 2.04790518e-01f, 2.86109418e-01f, 2.02631935e-01f, 1.77035034e-01f, 1.85116485e-01f,
  1.97931468e-01f, 1.45412952e-01f, 2.24036589e-01f, 1.46356642e-01f, 1.72874898e-01f, 1.10174000e-01f, 7.37609491e-02f, 1.15172170e-01f, 7.53022730e-02f, -2.42330041e-02f,
  1.29533634e-01f, -5.49197458e-02f, 4.68215579e-03f, -1.07996007e-02f, 7.62034878e-02f, 1.17652796e-01f, 8.09912086e-02f, 2.60291714e-02f, 1.17445029e-01f, -1.13497041e-01f,
  -1.04737349e-01f, 3.98831964e-02f, -1.58984914e-01f, -6.42813444e-02f, -1.24947391e-01f, -6.58159927e-02f, -9.39198434e-02f, -1.53615251e-01f, -2.71897651e-02f, -1.40843615e-01f,
  -1.60330907e-01f, -1.41389340e-01f, -5.38517125e-02f, -2.52823113e-03f, -1.53726012e-01f, -1.41043007e-01f, -1.52685016e-01f, -1.48965806e-01f, 8.22383016e-02f, 3.17591093e-02f,
  -7.27825016e-02f, -7.17350841e-02f, -7.49842823e-02f, 5.21155000e-02f, 6.21368969e-03f, -7.22966418e-02f, -4.08427417e-02f, -8.30505863e-02f, -8.58988985e-02f, 7.98981418e-05f,
  5.29188290e-02f, -1.10707479e-02f, -7.87366629e-02f, 8.57554227e-02f, -2.13889573e-02f, 3.65503579e-02f, -7.76148960e-02f, 8.63000080e-02f, 5.51627437e-03f, -1.35678247e-01f,
  9.51683149e-03f, 5.03331460e-02f, 1.68772303e-02f, 4.39810799e-03f, 1.48398593e-01f, 2.11518295e-02f, 2.05836911e-02f, 6.96414113e-02f, 9.47156101e-02f, 2.48571709e-02f,
  -3.65509912e-02f, -1.74315587e-01f, -1.24804757e-03f, 4.45415229e-02f, -1.37008950e-01f, -4.72571887e-03f, 9.38574299e-02f, 5.22080176e-02f, 8.48460123e-02f, -7.14695081e-02f,
  -1.85206726e-01f, -1.80906039e-02f, -1.24846071e-01f, -1.13989204e-01f, -1.05042078e-01f, -4.25181799e-02f, 9.86977220e-02f, -1.10357188e-01f, -3.32394987e-02f, -7.98456594e-02f,
  -1.29144192e-01f, 3.29879373e-02f, -4.36479449e-02f, -1.15038358e-01f, -1.61098033e-01f, -4.75729592e-02f, -5.63451573e-02f, 1.94843225e-02f, -3.78657430e-02f, -3.33488546e-03f,
  -2.56777201e-02f, -1.24773972e-01f, -1.50594354e-01f, -4.38151732e-02f, -7.53205270e-02f, -1.23744100e-01f, -1.48774490e-01f, -8.46235678e-02f, -1.37334794e-01f, -1.17246069e-01f,
  3.70171756e-01f, -6.65267259e-02f, -7.88479522e-02f, 1.66023880e-01f, 5.40816374e-02f, 9.39733312e-02f, 1.02983028e-01f, 9.56045166e-02f, 1.39672458e-01f, 1.01589702e-01f,
  -3.25997407e-03f, 4.98348754e-03f, -4.59643677e-02f, -8.00402388e-02f, -2.42937859e-02f, 7.46275932e-02f, -5.69078177e-02f, 4.30510240e-03f, 9.30678248e-02f, 8.68372023e-02f,
  8.80798325e-02f, 1.23134039e-01f, 6.61965832e-02f, 2.79230438e-03f, 2.75763869e-02f, -3.85368504e-02f, 7.56274909e-02f, -1.55494064e-02f, -6.31569698e-02f, -1.17143348e-01f,
  -1.35447681e-01f, -1.24459788e-01f, 7.47587159e-02f, -3.59677859e-02f, -5.67262359e-02f, 1.09336395e-02f, 8.57694298e-02f, -5.52507583e-03f, 1.63235012e-02f, -8.92423540e-02f,
  -2.59955470e-02f, -6.27089962e-02f, 9.25812591e-03f, -4.42682579e-02f, -6.38294145e-02f, -3.95121649e-02f, -2.02402085e-01f, -3.34153473e-02f, -1.92104653e-02f, -1.07900128e-01f,
  -1.85399190e-01f, -1.14028886e-01f, -1.28273126e-02f, -4.44738045e-02f, -1.89084813e-01f, -1.20270945e-01f, -9.29640457e-02f, -1.15842335e-01f, -1.33452177e-01f, -2.98071671e-02f,
  7.95695335e-02f, 9.84715596e-02f, 1.35677323e-01f, 1.70625940e-01f, 9.69190001e-02f, 6.46951720e-02f, 1.02672972e-01f, 1.65884465e-01f, 1.52267173e-01f, 6.90970942e-02f,
  9.58758816e-02f, 1.19460084e-01f, 2.63989329e-01f, 2.16431543e-01f, 7.32999370e-02f, 1.59972191e-01f, 1.22536242e-01f, 1.37320414e-01f, 8.01280811e-02f, 1.70615077e-01f,
  2.01782227e-01f, 1.54344574e-01f, 1.68193251e-01f, 8.92120972e-02f, 1.51922628e-01f, 1.13143072e-01f, 2.31068507e-01f, 2.18951806e-01f, 9.93395373e-02f, 1.65068194e-01f,
  1.74522728e-01f, 2.38638725e-02f, -5.33830753e-05f, -1.52114123e-01f, -1.03408314e-01f, -9.61356331e-03f, 1.59299765e-02f, 8.15044045e-02f, -2.39816587e-02f, 5.56638651e-02f,
  -9.76634845e-02f, 3.77668925e-02f, 5.51396385e-02f, -2.14537382e-02f, 1.62766770e-01f, 1.36565432e-01f, -6.56629130e-02f, 7.16699511e-02f, -7.93013796e-02f, -2.28515230e-02f,
  -2.31188885e-03f, 1.41793624e-01f, 2.11637229e-01f, 1.49564371e-01f, -4.56622615e-02f, 3.54883745e-02f, 6.81120157e-02f, 1.24791535e-02f, 7.10287988e-02f, 2.71765769e-01f,
  3.13645184e-01f, 4.77573425e-01f, 4.02564377e-01f, -1.90821603e-01f, -1.16398185e-01f, -3.99863534e-02f, 5.49555011e-02f, 4.20587994e-02f, -9.53997672e-02f, 6.81942031e-02f,
  1.99354365e-02f, -8.52985904e-02f, -2.20297873e-02f, -5.63502796e-02f, 4.75797765e-02f, 6.30099848e-02f, 9.71104801e-02f, 1.46442279e-01f, -7.42577808e-03f, -1.24300100e-01f,
  -8.71431008e-02f, 1.12968788e-01f, 2.21877262e-01f, 1.21600954e-02f, 1.44229814e-01f, -8.72853175e-02f, 6.86581805e-02f, 1.17759362e-01f, 1.87015772e-01f, 1.90135136e-01f,
  2.35652953e-01f, 3.37649673e-01f, -1.84449703e-01f, 5.48096746e-02f, 2.34233681e-02f, -3.07169203e-02f, -5.45371231e-03f, 1.49880117e-02f, -1.08108811e-01f, -1.68101355e-01f,
  -4.05433811e-02f, 1.67068690e-01f, 8.49444792e-03f, 7.13878963e-03f, -4.28694906e-03f, -1.75941866e-02f, -3.02269310e-02f, -2.37398408e-02f, -5.18085174e-02f, -2.09745169e-02f,
  -1.27938949e-02f, -1.21458910e-01f, -5.77907413e-02f, -1.41496286e-01f, -7.01060221e-02f, -2.11071059e-01f, 3.40719782e-02f, -1.21100895e-01f, -4.85554561e-02f, -1.35646626e-01f,
  -1.05349824e-01f, -3.36537771e-02f, 2.85375640e-02f, -1.26694590e-01f, -1.42324165e-01f, -3.37811232e-01f, -1.97536215e-01f, -1.94624558e-01f, -4.73793708e-02f, -1.61777303e-01f,
  -2.04199567e-01f, -9.49523672e-02f, -9.80957448e-02f, -1.27286643e-01f, -7.79392272e-02f, 7.92539418e-02f, -1.86009239e-02f, -4.33327071e-02f, -9.81205329e-03f, -8.28597844e-02f,
  -1.40067399e-01f, -5.37855774e-02f, -8.70959163e-02f, -8.50524679e-02f, -1.93505213e-01f, -2.13511690e-01f, -1.43416807e-01f, -8.87037441e-02f, -1.21382698e-01f, -7.53311068e-02f,
  -1.50584176e-01f, 1.13321982e-01f, -5.03097586e-02f, 2.65177518e-01f, 1.75240800e-01f, 2.45717481e-01f, 1.28656939e-01f, 1.45816848e-01f, 2.28315908e-02f, -5.59876114e-02f,
  1.30548656e-01f, 1.60053506e-01f, 1.75343379e-01f, 9.46524292e-02f, -8.10784921e-02f, -1.01139605e-01f, 6.17627837e-02f, 2.07053088e-02f, -1.08072735e-01f, 1.82794854e-02f,
  -6.19189329e-02f, -5.99833019e-02f, -1.86323628e-01f, -2.43643045e-01f, -1.19461268e-01f, -2.58872688e-01f, -1.36657506e-01f, -8.43779519e-02f, -5.98926172e-02f, -3.09666872e-01f,
  -1.96565777e-01f, 6.33858681e-01f, 2.70046741e-01f, -3.25499833e-01f, -1.20561041e-01f, 3.51784438e-01f, 6.46164596e-01f, 3.09504956e-01f, -1.75367981e-01f, 8.91195163e-02f,
  3.57901938e-02f, -2.52509326e-01f, -1.12044416e-01f, -6.07395694e-02f, 2.85955101e-01f, 2.81015038e-01f, 1.79178178e-01f, -5.34787700e-02f, -5.00731282e-02f, -1.33573394e-02f,
  3.93168256e-03f, -1.02953933e-01f, -1.79461226e-01f, -8.21847394e-02f, -1.39155418e-01f, -1.30887598e-01f, 3.35867479e-02f, -4.90476899e-02f, 2.09032789e-01f, -1.21051975e-01f,
  -1.79285541e-01f, 1.91338643e-01f, -2.58640856e-01f, -2.16573134e-01f, -1.24439962e-01f, 3.30555066e-02f, 5.76371467e-03f, -1.18066467e-01f, 5.54917194e-02f, 1.28649324e-01f,
  -2.25913171e-02f, 2.57672425e-02f, -1.01379998e-01f, 9.10558272e-03f, -4.62562181e-02f, 1.21008053e-01f, 3.36032994e-02f, 6.87404275e-02f, 3.10648791e-02f, 7.09366351e-02f,
  3.81025299e-02f, -1.38356596e-01f, -2.87895072e-02f, 1.14178218e-01f, 1.54429108e-01f, -2.11165071e-01f, 1.23527423e-01f, 3.47103700e-02f, 1.81233823e-01f, -9.40563008e-02f,
  -1.28392071e-01f, 1.20235700e-02f, 1.14634924e-01f, 1.07456490e-01f, 6.87535182e-02f, 2.52634417e-02f, -6.31785765e-03f, 1.21615063e-02f, -4.69067279e-04f, 6.27044067e-02f,
  -1.92383546e-02f, -8.14872384e-02f, -3.00980471e-02f, -1.13842869e-02f, -1.94052294e-01f, -7.47876465e-02f, 4.89154160e-02f, -2.02429816e-02f, -4.53309976e-02f, -4.29573990e-02f,
  -9.95960459e-02f, -6.76502064e-02f, -1.75165832e-01f, -4.71819229e-02f, -7.29371980e-02f, -4.81487364e-02f, -1.38853282e-01f, -1.15064733e-01f, -1.42895192e-01f, 9.35729295e-02f,
  -2.51132697e-01f, 1.23715512e-01f, -3.43231618e-01f, -5.60111329e-02f, -1.64404884e-01f, -3.17353606e-02f, -8.25875178e-02f, -4.42636274e-02f, 2.11074180e-03f, 3.20078433e-02f,
  1.00492068e-01f, -7.55600706e-02f, -6.35952922e-04f, 9.82225239e-02f, -1.20206587e-01f, -9.16248858e-02f, -1.68694202e-02f, -2.28258938e-01f, -5.94098791e-02f, -1.71329141e-01f,
  -4.70285751e-02f, -7.86506012e-02f, -3.53243083e-01f, -9.45963785e-02f, -2.29065299e-01f, -3.90796155e-01f, -1.73389941e-01f, -1.90815791e-01f, -3.99027131e-02f, -1.26715884e-01f,
  2.16837123e-01f, -2.58566737e-01f, 5.04785359e-01f, -4.22741473e-02f, 4.07934606e-01f, 4.64835286e-01f, 3.14901412e-01f, 6.88945949e-02f, -1.60969403e-02f, 5.31027392e-02f,
  -2.31121927e-01f, -3.46687019e-01f, -3.59450668e-01f, -2.35698313e-01f, -1.33083925e-01f, 2.18888015e-01f, 2.47131705e-01f, 8.09758678e-02f, 3.75748314e-02f, 8.72990936e-02f,
  -1.68986961e-01f, -2.59802848e-01f, -2.37904638e-01f, -1.60271734e-01f, -1.82581797e-01f, -1.37313604e-01f, -9.45752263e-02f, -1.05193011e-01f, -2.88823131e-03f, -3.05158496e-01f,
  -3.56942862e-02f, 5.40846251e-02f, -3.43583263e-02f, -1.43761322e-01f, -1.87589735e-01f, -5.87003713e-04f, 4.00887653e-02f, -1.88773811e-01f, -8.53269622e-02f, -2.13600192e-02f,
  -8.86000469e-02f, -5.81114255e-02f, -1.25905246e-01f, -1.89555094e-01f, -1.09197171e-02f, -6.30383147e-03f, -1.92929268e-01f, -1.06624380e-01f, -1.84887394e-01f, -8.67303181e-03f,
  -1.30928025e-01f, 6.19206764e-02f, 4.57741134e-02f, 1.15530074e-01f, -3.17757353e-02f, -3.91966738e-02f, -4.07797620e-02f, -5.26844263e-02f, 3.91681008e-02f, -1.12833627e-01f,
  -1.66826621e-02f, 1.45887226e-01f, 5.87062053e-02f, -1.22287488e-02f, -2.60319617e-02f, 4.20653895e-02f, 3.92178446e-02f, 3.23959962e-02f, 4.78280708e-02f, -9.68406349e-02f,
  2.24936400e-02f, 3.38652804e-02f, 1.24519700e-02f, -3.84679921e-02f, -5.88506274e-02f, 2.33675335e-02f, 2.99147274e-02f, -3.38985398e-02f, -4.17872667e-02f, -3.58424373e-02f,
  -1.25653461e-01f, -6.59124181e-02f, -1.94898415e-02f, -7.98552558e-02f, 1.19560445e-02f, 2.65564714e-02f, -3.54431421e-02f, -6.47223815e-02f, -3.98968942e-02f, -3.11909094e-02f,
  -4.67704028e-01f, 1.62475035e-01f, 7.93486238e-02f, -1.27018481e-01f, 4.96165864e-02f, -1.32394418e-01f, -1.91935915e-02f, 5.34604788e-02f, -6.03908263e-02f, 4.17071544e-02f,
  -2.91872583e-03f, -1.13815799e-01f, -1.01825871e-01f, -1.97789967e-01f, 5.71196638e-02f, 4.44967672e-03f, -1.59112394e-01f, -8.05705786e-02f, -1.51351854e-01f, -6.57190308e-02f,
  -9.56126023e-03f, 1.62856162e-01f, 1.64256856e-01f, 1.70589179e-01f, 1.18687116e-02f, 1.57615691e-01f, -2.40540467e-02f, 1.24866888e-01f, 1.79211900e-01f, 9.46261138e-02f,
  7.08989978e-01f, -7.57063553e-02f, 1.42150506e-01f, 1.34764150e-01f, -6.46041259e-02f, 1.47412838e-02f, 6.66145235e-02f, 2.89926082e-01f, 2.18890324e-01f, 5.43517508e-02f,
  -1.51021525e-01f, 2.98034702e-03f, 7.97831565e-02f, 3.13762873e-02f, 1.20976776e-01f, 6.57134280e-02f, 4.16614525e-02f, 2.24020928e-01f, 2.28163391e-01f, 1.66519657e-01f,
  -6.95687979e-02f, 5.84522560e-02f, 2.50364006e-01f, 9.66001824e-02f, 8.90028924e-02f, 3.55110615e-02f, 6.64954633e-02f, -1.91309936e-02f, -9.37530026e-02f, 1.11229435e-01f,
  -1.74129710e-01f, 1.28211319e-01f, 1.72762379e-01f, -1.34109840e-01f, -1.54147103e-01f, 9.69709903e-02f, 7.64079345e-03f, 8.71645566e-03f, -7.81590417e-02f, 8.22488312e-03f,
  -9.98498574e-02f, -6.42269030e-02f, 2.04636063e-03f, 4.03594971e-02f, 4.28925045e-02f, -6.42354041e-02f, 2.79757399e-02f, 9.05203167e-03f, -9.61356089e-02f, -1.28189884e-02f,
  -1.29304513e-01f, -1.24333009e-01f, -6.04171567e-02f, 2.05647964e-02f, -1.34436437e-03f, -3.49856205e-02f, 1.63047705e-02f, -2.19580922e-02f, 9.50614214e-02f, 2.61297226e-01f,
  -5.30901067e-02f, 5.89812882e-02f, -3.17453034e-02f, 3.72200869e-02f, 2.31845547e-02f, 1.01291962e-01f, 8.78443718e-02f, -1.08485200e-01f, 7.11139059e-03f, 2.77994592e-02f,
  7.31972530e-02f, -2.00542901e-02f, 9.56095085e-02f, 6.53511658e-02f, 1.02006331e-01f, -6.30908832e-02f, -1.77551794e-03f, -1.59548223e-02f, -1.05247416e-01f, -3.15172821e-02f,
  6.96138516e-02f, 2.77730986e-03f, 7.52637461e-02f, -6.31587729e-02f, -6.40709475e-02f, 1.10576488e-03f, 4.41143923e-02f, -9.05355960e-02f, -9.13491473e-03f, -3.93823460e-02f,
  -3.47087413e-01f, -6.93956837e-02f, 2.13932991e-01f, 1.37983626e-02f, -1.05203308e-01f, 1.67112742e-02f, 7.85649419e-02f, 5.10541315e-04f, -1.84920430e-01f, -6.64104372e-02f,
  -2.77473629e-02f, 5.24290800e-02f, -1.09614572e-02f, 1.94240231e-02f, 6.24563955e-02f, -2.76641417e-02f, -7.87895843e-02f, 8.51041973e-02f, -4.16897014e-02f, -1.03526853e-01f,
  -1.50678009e-01f, 8.32887590e-02f, -1.39403967e-02f, 7.24170804e-02f, -2.41677277e-03f, 3.20427045e-02f, -1.08344406e-02f, 2.63700858e-02f, 7.97380507e-02f, 2.03607604e-01f,
  4.82979566e-01f, -2.46583223e-01f, -6.26866162e-01f, 1.75396558e-02f, -3.13327193e-01f, -3.68833601e-01f, -2.75123686e-01f, -1.11519760e-02f, 8.37874785e-02f, -2.51473308e-01f,
  -1.74057499e-01f, 3.66670899e-02f, -1.35965139e-01f, -1.44983260e-02f, 8.48374292e-02f, -3.04830194e-01f, -3.11860770e-01f, -1.86236352e-01f, 1.13108501e-01f, 1.46542013e-01f,
  2.70037316e-02f, 1.10462531e-01f, 2.55901307e-01f, -2.36089285e-02f, -2.63856769e-01f, -1.04510069e-01f, -3.23492736e-01f, -2.19094813e-01f, -2.63838053e-01f, -3.93968016e-01f,
  -3.33214790e-01f, -2.20310748e-01f, -7.21033737e-02f, 9.50358957e-02f, -7.79543445e-02f, 8.58227462e-02f, -3.57397534e-02f, 2.04489920e-02f, 7.99259841e-02f, -7.28115663e-02f,
  -5.88754341e-02f, 4.25928868e-02f, -7.22606666e-04f, -3.92916091e-02f, -8.03368539e-02f, -1.38096102e-02f, -4.01217155e-02f, -9.59209818e-03f, -5.74874915e-02f, -1.26370147e-01f,
  -8.24622065e-02f, -1.11716233e-01f, -1.41870767e-01f, -6.40365258e-02f, -1.01383865e-01f, -1.31200794e-02f, -1.71842948e-01f, -1.15762725e-01f, -7.04703480e-02f, -1.05786495e-01f,
  2.12310776e-02f, -8.72451961e-02f, -2.63762455e-02f, -3.33677083e-02f, 3.62877399e-02f, -4.43211831e-02f, -9.60108042e-02f, 5.25495596e-03f, -5.70192225e-02f, -3.66851091e-02f,
  5.13505451e-02f, -5.97004592e-02f, -5.59914485e-03f, -9.71640944e-02f, -9.50064063e-02f, -1.75479222e-02f, -4.19569053e-02f, 1.89569555e-02f, 1.81349944e-02f, 2.70230789e-02f,
  -4.31495830e-02f, -2.57928781e-02f, -3.25904973e-02f, 4.05856594e-02f, -6.17052019e-02f, -6.09000251e-02f, -1.12386486e-02f, 6.28099367e-02f, 7.31748566e-02f, -5.71055822e-02f,
  1.17721394e-01f, -3.64389317e-03f, -1.85340241e-01f, 2.48624459e-02f, -5.79775572e-02f, -7.22424015e-02f, -9.87899974e-02f, 1.14697717e-01f, 7.07121519e-03f, -4.23904583e-02f,
  -2.69311890e-02f, 7.42518678e-02f, -4.37666150e-03f, -2.82029491e-02f, 1.54411765e-02f, -7.22588673e-02f, 7.71245882e-02f, -4.38009426e-02f, 4.68073152e-02f, -2.04037782e-02f,
  5.99259771e-02f, 1.08191244e-01f, 1.80933759e-01f, 3.81573774e-02f, 5.64535893e-03f, 1.07042082e-01f, -9.29152295e-02f, -1.01776712e-01f, 9.25261378e-02f, 9.00430232e-02f,
  -7.92813540e-01f, 1.44477814e-01f, 1.81083933e-01f, -5.90777457e-01f, 1.48615902e-02f, 5.07524192e-01f, 6.37464821e-01f, 2.44830862e-01f, -2.01458514e-01f, 1.13797367e-01f,
  -7.92556256e-02f, -3.00055593e-01f, -1.79251865e-01f, 1.29631430e-01f, 1.98049009e-01f, 5.30813217e-01f, 2.48075977e-01f, 3.14888172e-02f, 7.78830796e-02f, 1.70874178e-01f,
  1.39414281e-01f, -2.64054000e-01f, -4.26219523e-01f, -2.27143481e-01f, -1.99741110e-01f, -8.96897912e-02f, -1.06402948e-01f, -2.70620227e-01f, 2.12291524e-01f, -3.12923566e-02f,
  3.55495028e-02f, -4.92061377e-01f, 2.18604162e-01f, -2.27048844e-01f, -1.36931300e-01f, 1.20842978e-02f, -2.76905540e-02f, -2.24238232e-01f, 1.74166244e-02f, 4.89620306e-02f,
  -1.75487652e-01f, -6.67477027e-02f, -2.42623121e-01f, 2.43148115e-02f, -1.71864480e-01f, -4.71101254e-02f, -1.91923648e-01f, -7.76623264e-02f, -1.65419742e-01f, 1.40936179e-02f,
  1.33508787e-01f, -2.59132951e-01f, -1.36627987e-01f, 4.01631519e-02f, -3.47051546e-02f, -1.33204103e-01f, -7.62911141e-02f, -2.25793626e-02f, -2.86002085e-02f, -2.12372556e-01f,
  1.29894475e-02f, -2.72435267e-02f, 6.50499165e-02f, 2.79416889e-02f, 6.80656955e-02f, -5.50994510e-03f, -1.71140432e-02f, 1.36990203e-02f, 8.18081293e-03f, -2.26487443e-02f,
  3.53568010e-02f, 1.03171788e-01f, 1.81441437e-02f, -8.81733466e-03f, -2.43460163e-02f, -7.78174326e-02f, 1.52023271e-01f, -2.30028033e-02f, -6.37439787e-02f, 7.68175721e-02f,
  -4.98160534e-02f, -5.65292574e-02f, -1.10940270e-01f, 9.24674869e-02f, 1.94603577e-01f, -5.18293083e-02f, -1.28155589e-01f, 8.94780457e-02f, -1.10340364e-01f, 4.45107231e-03f,
  -3.26731652e-01f, 1.33417338e-01f, -7.51170889e-02f, -4.88252565e-02f, -1.24869041e-01f, 8.50987062e-03f, -1.98121220e-01f, -3.96118797e-02f, -8.68569016e-02f, 9.66101419e-03f,
  2.05045706e-03f, -4.00633104e-02f, -1.56117886e-01f, 1.28281027e-01f, 2.93906890e-02f, 6.02983013e-02f, 4.43014912e-02f, 7.23353541e-03f, -1.60823413e-03f, -2.34000366e-02f,
  1.59271002e-01f, 1.43648207e-01f, 4.42156345e-02f, 2.18542069e-01f, -3.53870466e-02f, 1.45791490e-02f, 2.86426879e-02f, 5.31019643e-02f, 9.66381803e-02f, 1.91900924e-01f,
  4.87196684e-01f, 3.64696383e-02f, -1.11428432e-01f, 3.68406385e-01f, -7.80984163e-02f, -2.22451136e-01f, -3.27020913e-01f, -5.42323105e-02f, 1.47282824e-01f, -2.04727706e-02f,
  6.74109012e-02f, 8.18946436e-02f, 1.35545790e-01f, -1.32385314e-01f, -1.11879706e-01f, -2.17435330e-01f, -1.30080134e-01f, -1.79733366e-01f, -3.36930782e-01f, -4.49957818e-01f,
  -3.35490286e-01f, -2.37800837e-01f, -1.74986005e-01f, -1.06439479e-01f, -7.62230381e-02f, -5.51781431e-02f, -4.03064024e-03f, -1.31812304e-01f, -1.66281059e-01f, -4.91096824e-02f,
  -4.06825572e-01f, -3.16735008e-03f, -3.22813331e-03f, 7.62493834e-02f, 4.71037105e-02f, 4.79923040e-02f, 9.32212174e-02f, 6.91822693e-02f, 1.54316112e-01f, -2.36406233e-02f,
  5.53716570e-02f, 1.00070044e-01f, 2.67177895e-02f, -2.83834990e-02f, -1.24475479e-01f, -1.77994326e-01f, -2.70226449e-02f, 2.20930250e-03f, -3.43742706e-02f, -7.14416131e-02f,
  -3.58198844e-02f, 8.87297839e-02f, 1.05119310e-01f, 6.82376977e-03f, 1.04952417e-01f, 8.39695558e-02f, -5.31533808e-02f, 2.56743561e-02f, 3.37523036e-02f, 1.52467340e-01f,
  -1.85099449e-02f, 1.85505860e-02f, -1.86843444e-02f, -3.14508267e-02f, -8.11779201e-02f, -3.25223841e-02f, 4.57771793e-02f, -2.22040582e-02f, -9.72238109e-02f, -1.29128650e-01f,
  5.01164719e-02f, -2.55533382e-02f, -1.95111928e-03f, 8.91419780e-03f, -1.34463282e-02f, 3.26659866e-02f, -4.40194570e-02f, -1.16695732e-01f, -1.24737501e-01f, 1.35995634e-02f,
  -3.52950543e-02f, -1.66621506e-01f, -9.62825939e-02f, -2.07536444e-01f, -6.91526011e-02f, 5.49230585e-03f, -3.30306701e-02f, -5.52393794e-02f, -4.22130786e-02f, -4.12319005e-02f,
  -5.30811166e-03f, 9.95259546e-03f, 2.44066231e-02f, -4.75980118e-02f, 5.59527092e-02f, 1.21560171e-01f, 2.89168879e-02f, -8.64451528e-02f, -5.24372384e-02f, -1.11038275e-01f,
  -1.47276655e-01f, 1.18225105e-02f, -3.03194709e-02f, 3.19614448e-02f, -1.33833498e-01f, -5.11636250e-02f, -7.67044425e-02f, -2.34406590e-02f, -4.45820652e-02f, 1.50578935e-02f,
  5.39397299e-02f, 9.22049358e-02f, 2.18895346e-01f, 2.10677609e-01f, 2.65142862e-02f, 5.37659880e-03f, -5.90637289e-02f, -3.09863631e-02f, 4.26080227e-02f, 1.22217596e-01f,
  5.85817456e-01f, -1.14633637e-02f, 5.95817864e-02f, 1.64148793e-01f, 3.40503752e-01f, 2.63390958e-01f, 2.16366783e-01f, 1.16324574e-01f, 1.68024823e-01f, 3.46997194e-02f,
  8.28997046e-02f, -5.01476638e-02f, -2.81655211e-02f, -2.22381994e-01f, -4.06198809e-03f, -4.58293185e-02f, 5.25847152e-02f, -1.29568085e-01f, 4.29377481e-02f, 9.25076827e-02f,
  1.07532896e-01f, 2.26365432e-01f, 2.03841597e-01f, 7.12763518e-02f, -1.67976573e-01f, -7.55420700e-02f, 1.63336601e-02f, -3.79660539e-02f, -2.53638532e-02f, -3.32601756e-01f,
  -3.69571537e-01f, 7.58940279e-02f, -2.36986745e-02f, -2.25838851e-02f, -1.48334160e-01f, 3.16496715e-02f, -8.10079202e-02f, -1.29355099e-02f, 9.34760179e-03f, -3.41677815e-02f,
  -5.09531312e-02f, -6.56943396e-02f, -1.48980007e-01f, 3.06019839e-02f, 7.86088482e-02f, 2.37384681e-02f, -5.67465974e-03f, -1.06648386e-01f, -1.47758365e-01f, -1.09476969e-01f,
  -1.95631102e-01f, -8.51155221e-02f, 5.35277724e-02f, -3.44036296e-02f, -1.31889001e-01f, -1.19512632e-01f, -8.60670358e-02f, -5.42031303e-02f, -6.30709082e-02f, 1.57967452e-02f,
  -2.17333719e-01f, -8.40699226e-02f, -2.00218737e-01f, -1.21133164e-01f, 5.92324249e-02f, 4.85925972e-02f, -1.03494115e-01f, -3.68693396e-02f, -6.84757531e-02f, -3.79959904e-02f,
  3.96162979e-02f, -1.61569938e-01f, -1.16221942e-01f, -2.10606791e-02f, -2.08832517e-01f, -1.51967749e-01f, -6.65747598e-02f, -1.19726494e-01f, -1.21194489e-01f, -1.49542186e-02f,
  -1.15497112e-01f, -2.89133079e-02f, -1.20505840e-01f, -2.11560532e-01f, -1.16447613e-01f, -9.98150036e-02f, -9.46648940e-02f, -1.45899594e-01f, -1.98026709e-02f, -4.26452458e-02f,
  -2.96534836e-01f, -2.26902530e-01f, -1.37965113e-01f, -9.49684456e-02f, -2.71090996e-02f, -9.26246494e-02f, -2.63360500e-01f, -1.69649273e-01f, 3.41478437e-02f, 1.84465181e-02f,
  -4.73925471e-03f, -3.47181670e-02f, -4.12535220e-02f, -1.08329922e-01f, 1.95843875e-01f, -3.99153158e-02f, -7.84502327e-02f, -4.22893502e-02f, -6.11208417e-02f, -1.56698465e-01f,
  -4.17931378e-03f, 1.08973876e-01f, 1.96780458e-01f, 1.45645924e-02f, -2.62077805e-02f, 5.61675020e-02f, 7.44283497e-02f, 8.54219347e-02f, 9.37810987e-02f, 2.69371837e-01f,
  -1.58088103e-01f, -4.20427062e-02f, -8.56194273e-02f, 1.83820471e-01f, 1.31183356e-01f, 2.26559564e-01f, 2.63207525e-01f, 2.46868387e-01f, 1.72001839e-01f, 1.93150759e-01f,
  5.32273315e-02f, 2.37751231e-01f, 1.36434227e-01f, 1.40249863e-01f, 2.06204847e-01f, 2.73840427e-01f, 2.88608730e-01f, 5.95506020e-02f, 8.93737972e-02f, 1.05210148e-01f,
  2.14342266e-01f, -2.60884129e-02f, -1.31878167e-01f, 1.01738319e-01f, 8.78504813e-02f, 1.83435127e-01f, 5.65863289e-02f, 1.23283088e-01f, -3.11639789e-03f, 5.44406846e-02f,
  -1.91201881e-01f, -1.01752244e-02f, 1.23804770e-02f, -9.62717608e-02f, -2.13781908e-01f, -9.05052051e-02f, -3.95786241e-02f, -1.15512088e-02f, 2.99922167e-03f, -6.16754331e-02f,
  -6.43768767e-03f, -6.33078292e-02f, -2.75382251e-02f, -1.04817018e-01f, -1.52589157e-01f, -7.94188157e-02f, 1.52488071e-02f, 1.65970221e-01f, 2.03652054e-01f, -4.70556803e-02f,
  7.50866309e-02f, 1.12169452e-01f, 2.39552045e-03f, 5.86330928e-02f, 3.53349224e-02f, 7.56401941e-02f, -5.00416718e-02f, 5.91878220e-02f, 4.60352898e-02f, 7.73916170e-02f,
  2.32301787e-01f, 1.24916144e-01f, 2.46185716e-02f, 1.51675373e-01f, 5.03931269e-02f, -5.90690523e-02f, 3.27914581e-02f, 3.43648903e-02f, 1.00026034e-01f, -1.18283175e-01f,
  -2.47895196e-02f, 6.44098893e-02f, 1.65422037e-01f, -6.68091699e-02f, -1.73516899e-01f, 3.70149640e-03f, -8.02127346e-02f, -3.12995501e-02f, -1.25624359e-01f, 2.94684544e-02f,
  -4.16881666e-02f, 2.33013798e-02f, -1.93040788e-01f, -6.97927475e-02f, -1.05909072e-01f, -5.22902496e-02f, -7.43384212e-02f, -8.83475617e-02f, -1.62529070e-02f, -1.37709314e-02f,
  2.05949739e-01f, 1.21154197e-01f, 5.49818911e-02f, 1.49691403e-01f, -1.66776516e-02f, -1.24187715e-01f, 1.43751100e-01f, -3.88888270e-02f, -1.42696559e-01f, 4.95695062e-02f,
  -5.06231524e-02f, -3.56936865e-02f, -2.81283837e-02f, -1.11075700e-03f, -1.33145258e-01f, -6.08186834e-02f, 1.05716132e-01f, 1.52947754e-01f, 1.46201089e-01f, -6.22519404e-02f,
  6.62028641e-02f, 1.43835843e-01f, 9.23599899e-02f, 3.84406443e-03f, 1.49013981e-01f, 1.22429337e-03f, -1.36632830e-01f, -4.26793471e-02f, -7.41225407e-02f, 1.20354444e-02f,
  5.13579547e-01f, -3.16994011e-01f, 5.73782530e-03f, 9.17376801e-02f, 2.76357472e-01f, 2.85923809e-01f, 1.53174520e-01f, 7.23145157e-02f, 1.40724704e-01f, 5.96978441e-02f,
  1.14909545e-01f, 1.16507582e-01f, 1.95041060e-01f, 1.06682204e-01f, 1.12547778e-01f, -9.15020704e-03f, 2.69108340e-02f, 1.12338521e-01f, 2.58806467e-01f, 6.19095862e-02f,
  6.38579577e-02f, 8.77644941e-02f, 1.36002034e-01f, 8.39134082e-02f, -1.43645182e-01f, 9.78376791e-02f, -9.18114707e-02f, -1.77487042e-02f, -7.66479820e-02f, -2.42009103e-01f,
  -2.01068401e-01f, -4.02407423e-02f, 5.66084273e-02f, 4.28133234e-02f, -1.39692366e-01f, -1.49754465e-01f, 7.01682344e-02f, -2.78217439e-02f, -1.28610104e-01f, -3.56403999e-02f,
  -5.76223386e-03f, -4.78351451e-02f, -7.33605772e-02f, -9.25256312e-02f, -5.85904345e-02f, -6.88228905e-02f, -1.14589177e-01f, -6.38711974e-02f, 4.74029332e-02f, -8.21631998e-02f,
  -6.45520836e-02f, -1.42691834e-02f, -3.37471291e-02f, 1.37060778e-02f, -3.80506329e-02f, 1.83640465e-01f, -1.21508371e-02f, -6.37247115e-02f, 9.15692151e-02f, -1.49517491e-01f,
  1.44954413e-01f, -6.93838820e-02f, 9.74388123e-02f, 8.81365985e-02f, 8.81449953e-02f, 5.28430529e-02f, -1.09130768e-02f, -7.49214366e-02f, 1.21915802e-01f, -1.62841201e-01f,
  -1.04579151e-01f, 9.53538045e-02f, -6.88493028e-02f, -7.15342462e-02f, 7.96103757e-03f, 1.92479100e-02f, -1.18901588e-01f, -8.27282369e-02f, 1.07156463e-01f, 6.31988570e-02f,
  9.80057791e-02f, -5.06709553e-02f, 9.04083475e-02f, -1.71428211e-02f, 2.28245873e-02f, 3.16249058e-02f, 2.54081395e-02f, 8.60505179e-03f, -7.14713186e-02f, 5.26725613e-02f,
  -2.65912533e-01f, 2.03399748e-01f, 7.58440373e-03f, -4.33681235e-02f, -2.33822707e-02f, 1.95656419e-02f, 6.53358996e-02f, -5.45707531e-02f, -2.38633025e-02f, -2.94122566e-03f,
  2.31381059e-02f, -1.13807723e-01f, -1.49358865e-02f, -4.48122919e-02f, 3.48535329e-02f, 9.65252072e-02f, -4.84326631e-02f, -3.11615989e-02f, -7.94573128e-02f, -6.74913377e-02f,
  -8.91362056e-02f, 8.73469710e-02f, 1.43489659e-01f, -4.00331952e-02f, -4.64364560e-03f, 1.39239520e-01f, 6.10280558e-02f, 5.93372397e-02f, 6.73403442e-02f, 5.56963347e-02f,
  5.53522110e-01f, -6.83572218e-02f, -4.69124019e-01f, 2.38403887e-01f, -1.63450703e-01f, -3.03967208e-01f, -4.16130036e-01f, -1.11380024e-02f, 2.92876720e-01f, -8.51595998e-02f,
  -2.59024762e-02f, 2.05694631e-01f, -1.38343364e-01f, -4.09151763e-02f, -1.71911210e-01f, -2.90590376e-01f, -2.56760687e-01f, -2.07427323e-01f, 1.08696129e-02f, 1.54218704e-01f,
  1.66091591e-01f, 2.22859144e-01f, 2.30631173e-01f, 1.14373110e-01f, 1.94256902e-01f, 1.92194637e-02f, -1.36576399e-01f, 8.10471699e-02f, -1.98101223e-01f, 1.46576660e-02f,
  5.59479482e-02f, 2.00391844e-01f, -2.47894540e-01f, 1.12120789e-02f, -8.46288633e-03f, 1.64912060e-01f, 9.75937396e-02f, 6.47329986e-02f, 9.32258647e-03f, 3.30853313e-02f,
  9.50863305e-03f, 1.20746858e-01f, 1.14352599e-01f, 8.33023340e-02f, 2.10018650e-01f, 4.53281179e-02f, -2.58222278e-02f, -9.48042721e-02f, -4.23443951e-02f, 4.70007770e-02f,
  -8.66958946e-02f, -1.53884619e-01f, -3.37842196e-01f, -2.61176288e-01f, 2.94321533e-02f, -1.64552599e-01f, -1.47383302e-01f, 1.73302636e-01f, -1.77919969e-01f, 1.66858703e-01f,
  -5.55733405e-02f, -1.18681351e-02f, 6.55323341e-02f, 1.66965455e-01f, 4.76293936e-02f, 3.27012055e-02f, 4.70033325e-02f, 3.86812426e-02f, 1.44640744e-01f, 1.34155480e-02f,
  2.26750877e-03f, 1.14052743e-02f, 8.95625353e-02f, 3.80050950e-02f, 2.59438623e-02f, -1.35176498e-02f, -1.63155869e-02f, -4.79022935e-02f, -3.79088111e-02f, 1.04983732e-01f,
  1.07403070e-01f, 3.71791865e-03f, 1.10870779e-01f, 4.10526693e-02f, -5.05913086e-02f, -3.95458564e-02f, 1.41081512e-01f, 8.62982348e-02f, 2.42507402e-02f, 9.65239331e-02f,
  1.69434622e-01f, -4.35970813e-01f, 9.18751806e-02f, -1.69250630e-02f, 3.72241475e-02f, 7.14129061e-02f, 5.08445688e-02f, -6.38399869e-02f, 7.46830702e-02f, 5.53791448e-02f,
  3.34524810e-02f, 9.52562243e-02f, 9.48038697e-02f, 3.73862684e-02f, 1.32416219e-01f, 1.57946330e-02f, -4.21728007e-03f, -2.21474990e-01f, -1.24144554e-02f, 1.98780745e-01f,
  -1.58427320e-02f, -1.68467402e-01f, -2.80972242e-01f, -2.79187649e-01f, 2.74263266e-02f, -2.29259431e-01f, -2.29249910e-01f, -9.34971496e-02f, -3.43850166e-01f, -2.46251136e-01f,
  -4.32871819e-01f, -2.23792121e-02f, -1.68643873e-02f, -3.45706165e-01f, -5.02361618e-02f, 8.77610371e-02f, 1.99866220e-02f, 1.13277277e-02f, 2.16454566e-02f, -7.27886930e-02f,
  9.90212038e-02f, -1.64609347e-02f, -9.45820138e-02f, -1.04018494e-01f, -2.32082561e-01f, -3.09336215e-01f, -3.28464895e-01f, -2.78505057e-01f, -1.20941572e-01f, 8.95638168e-02f,
  -5.00497371e-02f, -1.58102602e-01f, -2.35670269e-01f, 1.64793022e-02f, 9.58847776e-02f, 5.63878827e-02f, 3.16274911e-02f, -7.83860087e-02f, -1.26853921e-02f, -1.01189926e-01f,
  1.27197042e-01f, 1.35470703e-01f, 1.66297212e-01f, -6.31029531e-02f, 2.89050229e-02f, -2.88315304e-02f, 1.83139052e-02f, 1.70731507e-02f, -5.82495332e-02f, -4.55573164e-02f,
  -8.13736394e-03f, -1.14030046e-02f, -1.54377278e-02f, 3.95497307e-02f, -2.05787495e-02f, 1.68038849e-02f, -1.04503699e-01f, -5.11412472e-02f, -1.68144658e-01f, 8.12570453e-02f,
  -1.06774054e-01f, -1.04483478e-01f, -4.41542976e-02f, 1.99560337e-02f, 1.12902507e-01f, -1.25700250e-01f, 2.10557505e-01f, 2.01345250e-01f, 9.52585638e-02f, 1.84781943e-02f,
  -2.29508318e-02f, 1.51832094e-02f, -7.35889226e-02f, 5.83204143e-02f, -1.08847186e-01f, -6.11549169e-02f, -3.92053127e-02f, -4.63123284e-02f, 2.20908653e-02f, -3.17226239e-02f,
  2.42021978e-02f, 6.83967620e-02f, 8.29855800e-02f, 6.84798956e-02f, 4.92898822e-02f, -7.95155540e-02f, -8.19116384e-02f, -2.17972137e-02f, -1.63124467e-03f, 5.43855987e-02f,
  -9.85467508e-02f, -2.19465308e-02f, -4.35408950e-02f, 6.95511922e-02f, -8.31382275e-02f, -5.48289344e-02f, 5.15304692e-03f, 5.66286445e-02f, 2.18636394e-02f, 3.30874231e-04f,
  9.93895903e-02f, -6.60800785e-02f, -2.84435581e-02f, 1.25168944e-02f, -2.20941771e-02f, 3.34464721e-02f, -7.06373304e-02f, -5.63576594e-02f, -1.76285971e-02f, -4.58903727e-04f,
  7.98540562e-02f, -5.49271852e-02f, 3.61891910e-02f, 1.24490550e-02f, -6.60315081e-02f, 1.05732866e-02f, -2.20495582e-01f, -1.29025534e-01f, -3.61270830e-02f, 9.75620374e-03f,
  -2.22877234e-01f, -2.19613433e-01f, -2.91474313e-01f, -6.49851486e-02f, 4.40982692e-02f, -1.98897660e-01f, 3.95778120e-02f, 1.61964253e-01f, -1.19271360e-01f, -1.39997110e-01f,
  2.64713198e-01f, 3.32380623e-01f, 3.46690387e-01f, -5.57397269e-02f, -1.19828619e-01f, -4.94801551e-02f, 7.35847792e-03f, 4.05023433e-02f, 2.52597146e-02f, 6.15532622e-02f,
  1.65317282e-02f, -3.56091619e-01f, -9.88489911e-02f, -1.93300217e-01f, -1.91140339e-01f, 6.94494322e-02f, 6.57377839e-02f, -3.07391118e-02f, -3.85217398e-01f, -5.01229227e-01f,
  -3.46372336e-01f, -1.48924589e-01f, -3.35104614e-02f, 1.60183869e-02f, 2.24557608e-01f, -3.02214790e-02f, 3.84619653e-01f, 1.98039860e-01f, 1.04733929e-01f, 2.74183035e-01f,
  1.67414457e-01f, 4.47418213e-01f, -3.04514676e-01f, -2.69295454e-01f, -7.29516745e-02f, -2.00470723e-02f, -5.33306524e-02f, 1.13665111e-01f, -2.99449265e-02f, 4.63218167e-02f,
  1.70834176e-02f, -5.25377179e-03f, 1.38641879e-01f, -2.48639975e-02f, -3.97347519e-03f, -1.23649530e-01f, 3.22061740e-02f, 1.16455533e-01f, -9.56967101e-02f, 4.98840176e-02f,
  -3.33623350e-01f, -8.59855115e-02f, 2.68761367e-01f, 7.78800696e-02f, 1.52630299e-01f, -2.70165265e-01f, 9.36652571e-02f, 7.80421570e-02f, 1.84196621e-01f, 2.19440714e-01f,
  -1.31799623e-01f, 2.27968860e-02f, 6.41947985e-02f, 1.09879851e-01f, -9.07385349e-02f, 5.17098233e-02f, 1.06092475e-01f, -6.19457103e-04f, 2.53231488e-02f, -4.93080122e-04f,
  2.13330743e-04f, 4.07478996e-02f, 8.07774216e-02f, 1.94567978e-01f, 5.76346833e-03f, 9.22708958e-02f, -9.49020535e-02f, -1.90305198e-03f, 5.08096255e-02f, 1.10940486e-01f,
  -1.25659746e-03f, 1.44684697e-02f, 1.80220921e-02f, 1.99565459e-02f, 1.31239504e-01f, -5.98083995e-03f, -4.44444455e-02f, -7.64818687e-04f, 5.48480116e-02f, 6.87151477e-02f,
  -2.31010690e-01f, -1.77695781e-01f, 2.94113755e-02f, -2.87542045e-02f, 6.33249730e-02f, 1.64571181e-02f, 3.91965397e-02f, -1.31055191e-01f, -2.19598189e-02f, -5.66820018e-02f,
  6.87696263e-02f, -1.18573252e-02f, 2.33557045e-01f, -8.60831439e-02f, -3.14029872e-01f, -7.29270130e-02f, -1.98963448e-01f, -2.46178702e-01f, -1.32433206e-01f, 1.12267314e-02f,
  -9.80893821e-02f, -2.93202907e-01f, -3.06198269e-01f, -1.89984903e-01f, -5.97632118e-02f, -3.31077218e-01f, -1.17978454e-01f, -1.64184615e-01f, -1.80153146e-01f, -3.00303340e-01f,
  3.50749433e-01f, -2.10054979e-01f, -4.34360236e-01f, 1.01112358e-01f, -2.89667934e-01f, -3.39993924e-01f, -2.94866502e-01f, -5.89048713e-02f, 1.58687741e-01f, -1.76782206e-01f,
  -8.74606892e-02f, 1.07359506e-01f, -3.45589407e-02f, -1.16410673e-01f, -1.49518639e-01f, -3.94801140e-01f, -3.17644745e-01f, -3.23382735e-01f, -8.28148946e-02f, -3.07142679e-02f,
  -6.53670952e-02f, 4.29691114e-02f, 6.36060834e-02f, -4.49355952e-02f, -5.53058609e-02f, -1.25144660e-01f, -3.26776117e-01f, -2.14176312e-01f, -2.20296204e-01f, -3.33823979e-01f,
  -3.71929169e-01f, -5.33481035e-03f, -5.18416539e-02f, 4.36058193e-02f, -6.04795106e-02f, 1.09222680e-01f, -2.83546709e-02f, 9.90775228e-02f, 1.60151243e-01f, -4.38098200e-02f,
  -2.93597057e-02f, 1.03227668e-01f, 8.80432650e-02f, -2.77104080e-02f, -1.01712830e-02f, 8.62032101e-02f, 6.39407560e-02f, -3.69576737e-02f, -9.07563642e-02f, 2.13164613e-02f,
  -1.27018124e-01f, -4.68105413e-02f, -1.67944115e-02f, 3.39071942e-03f, -1.50019944e-01f, -2.93127261e-02f, -1.13826461e-01f, 2.00452190e-03f, -1.71522930e-01f, 5.39969690e-02f,
  -1.04309954e-02f, -7.06570130e-03f, 2.86780410e-02f, 1.09259337e-01f, 1.64961040e-01f, 1.11997956e-02f, 8.84580538e-02f, -2.03224290e-02f, 6.49396330e-02f, -2.87148226e-02f,
  5.44014908e-02f, 1.50780957e-02f, 6.09677881e-02f, 3.89670543e-02f, 3.83024625e-02f, -4.55099791e-02f, -3.83449495e-02f, 5.07561825e-02f, 1.25333905e-01f, 1.05923697e-01f,
  4.75057364e-02f, -4.63419966e-02f, 9.42700431e-02f, 9.86174792e-02f, -5.53980656e-02f, -3.56208235e-02f, -5.64933568e-02f, 1.43729812e-02f, 1.29631802e-01f, -1.21959927e-03f,
  2.12856114e-01f, -2.13717848e-01f, -1.78616308e-03f, 8.42553079e-02f, -8.11923668e-02f, 2.65945774e-02f, 1.76858548e-02f, 7.98522830e-02f, 2.70958301e-02f, 8.52885619e-02f,
  -1.85055565e-02f, 9.47632939e-02f, 1.65697634e-02f, -1.83588639e-02f, -3.13705914e-02f, -8.51863101e-02f, 7.57572204e-02f, 1.04298266e-02f, -1.11533720e-02f, -5.18836118e-02f,
  -6.48089200e-02f, 7.08073825e-02f, 1.81125522e-01f, -6.08808883e-02f, 4.55245711e-02f, 1.34659465e-02f, -1.51640579e-01f, -1.09109104e-01f, 6.98604737e-04f, 1.76599741e-01f,
  5.63421026e-02f, -1.41713589e-01f, 5.46718799e-02f, 1.28248841e-01f, -1.15969799e-01f, -1.59633055e-01f, -1.91844165e-01f, 5.09388819e-02f, 5.09843342e-02f, -1.06632203e-01f,
  -1.64592907e-01f, 1.23965092e-01f, 2.59002388e-01f, 2.13914052e-01f, 2.11376220e-01f, 9.99968722e-02f, 1.89563185e-01f, 3.12022895e-01f, 1.23369500e-01f, -1.76191643e-01f,
  -6.80452883e-02f, -1.50405457e-02f, 1.60753429e-01f, 1.34828597e-01f, 1.59628317e-02f, 7.35683888e-02f, -1.24969147e-02f, -7.39112645e-02f, -4.45415564e-02f, 1.76308632e-01f,
  -2.31980041e-01f, -1.88278675e-01f, 1.00204766e-01f, -1.12406313e-01f, -1.56157777e-01f, -3.03939078e-02f, -9.50433165e-02f, -9.41350237e-02f, -8.88307691e-02f, -2.52497792e-02f,
  -1.93306729e-01f, -1.93096735e-02f, -5.53469621e-02f, -3.03357560e-02f, -1.94357812e-01f, -1.14245012e-01f, 4.08409834e-02f, 1.55398279e-01f, 1.66248098e-01f, -1.23372197e-01f,
  -5.62387295e-02f, -2.79234946e-01f, -2.25860968e-01f, -1.99532192e-02f, 4.91990112e-02f, 1.13905363e-01f, -1.81116834e-01f, -1.59879506e-01f, -6.90199761e-03f, -1.18802622e-01f,
  -2.61261687e-02f, 2.00085249e-02f, 3.08738519e-02f, -1.26144774e-02f, 1.25615999e-01f, -9.61982980e-02f, 1.02058522e-01f, 6.23582341e-02f, -1.76298451e-02f, -4.74845842e-02f,
  9.50721726e-02f, -3.98429856e-02f, -2.66609769e-02f, -1.12762198e-01f, 3.93780619e-02f, -1.60659283e-01f, -8.31788480e-02f, -7.61359408e-02f, -7.28391707e-02f, -6.29366487e-02f,
  8.07018727e-02f, 5.80497645e-02f, -2.23934185e-02f, 1.88190058e-01f, 6.40293956e-02f, 7.39677949e-03f, -1.55636193e-02f, -8.55773762e-02f, -1.49810985e-01f, -2.58677751e-01f,
  -1.60278380e-02f, 1.31958067e-01f, -5.80065511e-02f, 3.51682343e-02f, -1.33619919e-01f, -6.08064532e-02f, -1.80634689e-02f, -3.61554995e-02f, -7.37852752e-02f, 2.01775506e-02f,
  -2.01864496e-01f, 2.54330803e-02f, -5.91866747e-02f, 2.26781447e-03f, -4.43755463e-02f, -1.52041465e-01f, -1.04856431e-01f, 9.93156135e-02f, -1.93794016e-02f, -1.40212476e-02f,
  7.00592175e-02f, -2.56265134e-01f, -1.45859584e-01f, 2.72500906e-02f, -1.46970034e-01f, -7.36542558e-03f, -3.19985375e-02f, -1.50232956e-01f, -7.23599195e-02f, -1.95389673e-01f,
  -5.47977863e-03f, -3.88566881e-01f, 1.71382561e-01f, 2.01651379e-01f, 1.74504910e-02f, -1.45928741e-01f, -4.06428784e-01f, -3.33186090e-01f, -1.32275015e-01f, -7.93523043e-02f,
  -1.09536059e-01f, 7.45731518e-02f, 9.50561091e-03f, -6.74846172e-02f, -3.13250273e-01f, -2.23967925e-01f, -1.16587646e-01f, -3.15143503e-02f, -9.86308977e-03f, -1.09360442e-01f,
  -4.61233929e-02f, -5.69889694e-02f, -4.43849452e-02f, -1.83728963e-01f, 6.45088330e-02f, 1.48532912e-01f, 9.88521799e-03f, 1.76052153e-02f, -3.41600273e-03f, 1.40738294e-01f,
  2.53595710e-01f, -6.10548258e-03f, -1.01069147e-02f, -1.57490194e-01f, -2.19503511e-02f, -9.99567136e-02f, -1.59588799e-01f, -3.73992063e-02f, -1.59276932e-01f, -1.80937409e-01f,
  -8.84887874e-02f, -3.10335550e-02f, -7.66645893e-02f, -3.41117717e-02f, -9.44893360e-02f, -7.89175630e-02f, -2.15350896e-01f, -6.84131235e-02f, -1.48819134e-01f, -1.17532365e-01f,
  -1.01926014e-01f, -1.48287714e-01f, -1.09819330e-01f, -1.81459352e-01f, -1.96125075e-01f, -7.88932890e-02f, -1.45279929e-01f, -6.85956255e-02f, -1.78119093e-01f, 2.15221792e-02f,
  -3.03315103e-01f, -2.45021299e-01f, -2.43865445e-01f, 7.69558847e-02f, -8.80849287e-02f, -1.98416874e-01f, -4.76270206e-02f, -1.72638312e-01f, -7.34485537e-02f, -9.95076969e-02f,
  -1.62410676e-01f, -6.02611825e-02f, -1.15141556e-01f, -9.87013131e-02f, -9.92693976e-02f, -5.13834655e-02f, -1.97259858e-01f, -2.20549598e-01f, -1.34048209e-01f, -1.35180816e-01f,
  -1.68403059e-01f, -1.11477382e-01f, 1.34575106e-02f, -1.94167957e-01f, -2.71503747e-01f, -2.47268274e-01f, -2.20860004e-01f, -1.86656624e-01f, -8.78640115e-02f, -2.14975893e-01f,
  1.64391443e-01f, 1.58974066e-01f, 2.35506058e-01f, -7.19391927e-02f, 7.62867322e-03f, -1.72718894e-02f, 1.33517966e-01f, 1.35218501e-01f, -1.46207623e-02f, 3.27366404e-02f,
  3.08139739e-03f, -2.15373226e-02f, 1.64705925e-02f, 9.33655426e-02f, 1.11359544e-01f, 4.76616211e-02f, -1.14684053e-01f, 1.31454185e-01f, -1.25721350e-01f, -1.79053977e-01f,
  -1.93419486e-01f, 3.27666663e-02f, 7.45018423e-02f, 1.53260469e-01f, -3.02135497e-02f, 7.40212481e-03f, 1.49372607e-01f, 1.33602157e-01f, 1.24492766e-02f, 3.20944898e-02f,
  -7.73909688e-02f, -1.16306543e-01f, -4.64534044e-01f, 4.70555902e-01f, 2.82322705e-01f, 1.07744791e-01f, 3.72873783e-01f, 3.51565629e-01f, 1.47236109e-01f, -4.15661968e-02f,
  -3.38956654e-01f, -4.34104830e-01f, -5.07411063e-01f, -3.37515622e-01f, -2.05612242e-01f, 1.78117514e-01f, 1.49741068e-01f, -1.26165718e-01f, -4.60419841e-02f, 3.02541316e-01f,
  3.57283413e-01f, 3.71980727e-01f, 1.11286193e-01f, 1.64157808e-01f, 2.26559564e-01f, 7.82323256e-03f, -8.21037591e-02f, -2.49607489e-02f, -2.15721130e-01f, -1.13261975e-01f,
  -5.48239887e-01f, -2.63263583e-01f, 5.17055094e-02f, -1.11055724e-01f, -4.15376425e-02f, -1.79340005e-01f, 4.67113815e-02f, -1.44949868e-01f, -1.52355656e-01f, 1.75214056e-02f,
  -6.70987442e-02f, -7.81449601e-02f, -3.89571130e-01f, -7.23876357e-02f, -1.35631654e-02f, -1.97391454e-02f, -8.97906721e-02f, -9.08837989e-02f, -1.85028955e-01f, -3.18845779e-01f,
  -7.43169561e-02f, -8.44578221e-02f, -2.12079063e-01f, -3.14700119e-02f, -2.15229988e-01f, -1.83222413e-01f, -9.41375196e-02f, -1.99699998e-01f, -3.77696723e-01f, 7.40322396e-02f,
  5.25285378e-02f, 2.95448843e-02f, 1.28672287e-01f, 2.32749209e-02f, 5.10197058e-02f, -5.91406561e-02f, -1.38683366e-02f, 3.04244682e-02f, 1.10913932e-01f, 1.66211575e-01f,
  5.16664721e-02f, -9.55625251e-02f, -1.28822792e-02f, 2.79641394e-02f, -9.62726027e-03f, -8.54516849e-02f, 1.03920642e-02f, 7.02065751e-02f, -3.71977799e-02f, 4.91486304e-02f,
  4.16531563e-02f, 1.17469259e-01f, -5.65590821e-02f, 6.59155622e-02f, -1.23371974e-01f, -1.77595034e-01f, 2.75675463e-03f, -3.87327708e-02f, 4.47239205e-02f, 1.34445587e-03f,
  1.10003598e-01f, -1.81334302e-01f, -4.52431589e-02f, 8.95447880e-02f, 1.01595290e-01f, -1.28061742e-01f, -1.33619130e-01f, -7.36117065e-02f, -9.27292407e-02f, -8.92953873e-02f,
  3.39303240e-02f, 3.10564339e-02f, -2.53590852e-01f, 2.03339774e-02f, -7.66680688e-02f, -6.84752688e-02f, 3.08954250e-02f, 9.68158767e-02f, 3.12865041e-02f, -8.03869218e-03f,
  2.53114313e-01f, 3.73118401e-01f, 1.26973018e-01f, 1.85928699e-02f, 1.24930739e-02f, 9.18050855e-02f, 9.20036137e-02f, 3.75836641e-02f, -1.29463837e-01f, 5.75945616e-01f,
  -5.58709979e-01f, -3.35955650e-01f, 7.59785697e-02f, -5.86604714e-01f, 8.50703716e-02f, 2.59744197e-01f, 3.67853940e-01f, 6.34594709e-02f, -2.69979596e-01f, -1.38580292e-01f,
  -7.62718841e-02f, -1.70660630e-01f, -1.45360872e-01f, -2.53387988e-02f, 2.49467473e-02f, 1.69736311e-01f, 5.16894907e-02f, 2.57340912e-03f, 2.44873554e-01f, 3.03805202e-01f,
  -1.10100778e-02f, -2.72106469e-01f, -3.00225109e-01f, -2.63468862e-01f, -2.96903580e-01f, -7.44494498e-02f, -2.81063080e-01f, -2.16437787e-01f, 2.42523830e-02f, -3.09778839e-01f,
  2.04892769e-01f, -2.48198450e-01f, 1.05548359e-01f, -1.57704562e-01f, -1.95282474e-01f, -9.83021110e-02f, -4.74224463e-02f, -8.96195024e-02f, -7.27706179e-02f, -1.32850349e-01f,
  -2.35526532e-01f, -1.06944039e-01f, -1.66281182e-02f, 9.06194188e-03f, -3.99223529e-02f, 1.34462994e-02f, -1.70612097e-01f, -1.03976957e-01f, -7.95916542e-02f, -7.64184371e-02f,
  -8.89520422e-02f, -7.35103115e-02f, 8.24650303e-02f, -3.57357934e-02f, -1.73912160e-02f, -3.09159905e-02f, -3.80080715e-02f, -8.40176791e-02f, 3.94875705e-02f, -1.42484114e-01f,
  1.24529734e-01f, 4.33824807e-02f, 8.45975727e-02f, 1.75196424e-01f, 5.87569699e-02f, 5.90079948e-02f, 1.10077076e-02f, 4.70333956e-02f, -2.30791532e-02f, -2.46011335e-02f,
  2.22526994e-02f, -1.61867812e-02f, -1.62310638e-02f, -2.18862901e-03f, -4.02636966e-03f, -9.06564388e-03f, -2.00913325e-02f, -8.04241151e-02f, -3.37246194e-04f, -9.80511382e-02f,
  -6.91991970e-02f, -2.80752797e-02f, -3.45015638e-02f, -1.01869078e-02f, -6.61656260e-02f, 3.25585017e-03f, 1.57725401e-02f, -9.79011320e-03f, 7.13709462e-03f, -3.40182930e-02f,
  2.80653834e-02f, 7.25647584e-02f, -2.70044114e-02f, -4.95883897e-02f, -1.13774590e-01f, -4.55376394e-02f, -9.66483653e-02f, 2.41021123e-02f, -1.14288166e-01f, 1.44072771e-01f,
  6.64267465e-02f, 8.64837393e-02f, -1.13266766e-01f, -3.80096212e-02f, 4.79106307e-02f, 1.12540588e-01f, -6.90354556e-02f, -2.08314545e-02f, -6.46402538e-02f, -8.07545148e-03f,
  -1.23934755e-02f, 1.05368979e-01f, 1.48290142e-01f, 1.02933973e-01f, 7.05577992e-03f, 2.02435538e-01f, 1.69946492e-01f, 2.01854110e-01f, 1.26297221e-01f, 2.09144019e-02f,
  -1.08362816e-01f, 2.25279834e-02f, -2.27495030e-01f, -2.80934628e-02f, -2.26222366e-01f, -2.33281896e-01f, -1.04115739e-01f, -7.41481362e-03f, 3.88491601e-02f, 1.26960754e-01f,
  -6.03641458e-02f, -2.01460257e-01f, -2.52908692e-02f, -1.13377355e-01f, -1.55999660e-01f, 1.25295952e-01f, -2.65341233e-02f, -3.21426183e-01f, -5.19440949e-01f, -3.67438823e-01f,
  -2.36910835e-01f, -2.43875951e-01f, -2.22462237e-01f, -1.54218584e-01f, 6.69725761e-02f, -2.23947000e-02f, 1.07252300e-01f, -1.23873830e-01f, -1.15225188e-01f, -1.32989530e-02f,
  -1.01907849e-01f, 5.49659468e-02f, -1.03403449e-01f, -8.99707973e-02f, -6.32521883e-02f, -8.00744370e-02f, -1.14114113e-01f, 4.46855137e-03f, -1.10242464e-01f, -6.77169487e-02f,
  -1.99744612e-01f, -1.38061836e-01f, -2.12042987e-01f, -7.96947032e-02f, -7.24442825e-02f, -1.19366772e-01f, -1.00986399e-01f, -2.40785405e-01f, -7.24463239e-02f, -6.76570013e-02f,
  -1.37670949e-01f, -1.86931774e-01f, -6.71946034e-02f, 2.14774795e-02f, -3.16575356e-02f, -1.55640423e-01f, 2.39085630e-02f, -6.49483204e-02f, 3.18721309e-02f, 1.60632640e-01f,
  7.63615146e-02f, -1.09692886e-02f, -4.05588970e-02f, -7.07280114e-02f, 3.08327246e-02f, 1.07313469e-01f, 4.76571545e-02f, -2.20827200e-02f, 1.65012144e-02f, -1.13696687e-01f,
  3.09238657e-02f, 9.54947397e-02f, -7.94538110e-02f, 6.61296695e-02f, 1.23844380e-02f, -4.99443477e-03f, 2.23430265e-02f, 2.78472695e-02f, -2.13966500e-02f, 4.41049365e-03f,
  -9.72007513e-02f, -4.28167954e-02f, -1.92001578e-03f, -1.99380871e-02f, -9.58696902e-02f, 9.11387149e-03f, -1.73450541e-02f, -8.31407383e-02f, -4.28146534e-02f, -6.50866553e-02f,
  4.89779413e-02f, 5.51380254e-02f, 1.03939027e-01f, -1.77793242e-02f, 6.56036958e-02f, 4.39524539e-02f, 3.59625854e-02f, 1.75012201e-02f, -5.04617989e-02f, -1.77187115e-01f,
  -1.41505226e-01f, -1.54590765e-02f, 9.00464412e-03f, 3.61271873e-02f, -8.88448060e-02f, -1.07227564e-01f, 5.76024689e-02f, -1.32433429e-01f, -9.56746936e-02f, 1.94647051e-02f,
  4.74589430e-02f, -6.26436099e-02f, 4.18211101e-03f, 4.74372730e-02f, -5.60159720e-02f, -1.78840801e-01f, 6.68971092e-02f, 1.85775086e-02f, 6.26744553e-02f, 2.86688209e-01f,
  9.00140777e-02f, -1.13421291e-01f, 4.45616722e-01f, 7.54418178e-03f, -4.77886468e-01f, -5.02451777e-01f, -4.29847181e-01f, -1.01626173e-01f, -9.28723216e-02f, -8.22023079e-02f,
  -3.27079058e-01f, -3.72275740e-01f, -8.48788470e-02f, 3.60249914e-02f, 1.04033068e-01f, 1.32135019e-01f, 3.05075288e-01f, 4.22747493e-01f, 6.13899529e-02f, -2.58988142e-01f,
  -2.25672498e-01f, 1.79207459e-01f, 3.43890548e-01f, 2.80269980e-01f, 7.48328716e-02f, -3.82922217e-02f, 2.33352557e-01f, 7.54428655e-02f, -1.46985538e-02f, 2.95377582e-01f,
  7.31044114e-02f, 1.42403334e-01f, -2.58733593e-02f, -2.74239443e-02f, -1.56484425e-01f, 9.37645659e-02f, -2.25287415e-02f, 2.46946216e-01f, -2.12663502e-01f, 1.75155979e-02f,
  -2.40193591e-01f, -1.62017003e-01f, -1.97263613e-01f, 3.47398105e-03f, -6.78864494e-02f, -9.89754125e-02f, 2.43028671e-01f, 1.97738811e-01f, 1.52877599e-01f, -1.45263476e-02f,
  -4.32540685e-01f, -3.09689343e-01f, -1.30959794e-01f, -6.05422482e-02f, 1.36277497e-01f, -1.53866008e-01f, 6.46497309e-02f, -1.35724926e-02f, 1.46016270e-01f, 3.13013911e-01f,
  1.45839360e-02f, -2.24433579e-02f, 3.88287567e-02f, 9.32573751e-02f, -6.43132776e-02f, 1.07976645e-02f, 1.25497282e-01f, -6.39206097e-02f, 1.16946891e-01f, -5.85852331e-03f,
  -1.14049815e-01f, 5.65071851e-02f, 1.48020806e-02f, 2.31043864e-02f, 5.46524711e-02f, 1.17870405e-01f, -1.09805115e-01f, 6.32582456e-02f, 7.22827390e-03f, 4.16593477e-02f,
  -6.62640259e-02f, 5.11493348e-03f, 1.46093890e-01f, 1.57171711e-01f, -9.06160008e-03f, 1.69514492e-01f, 5.09622768e-02f, 7.49750137e-02f, 1.64525524e-01f, 3.14285196e-02f,
  -1.33107334e-01f, 4.79866099e-03f, -5.42077497e-02f, 1.57027498e-01f, 4.64307293e-02f, 3.52477133e-02f, -7.62428120e-02f, -6.25329912e-02f, -1.45121217e-01f, -6.86591566e-02f,
  -1.79505199e-01f, -5.26463538e-02f, 6.17574416e-02f, 1.32611608e-02f, -9.44661722e-02f, -1.25435084e-01f, -1.70930460e-01f, -3.08748156e-01f, -1.57838583e-01f, -1.00894757e-01f,
  -8.15960914e-02f, -2.18976036e-01f, -3.42796475e-01f, -2.84889787e-01f, -1.99274585e-01f, -3.76131028e-01f, -2.74237413e-02f, -1.70709565e-01f, -2.80036420e-01f, -2.18495876e-01f,
  -6.48860335e-01f, -9.44808125e-02f, -1.23236425e-01f, -3.59944373e-01f, 6.20535575e-02f, 1.18936017e-01f, 1.91155553e-01f, 1.69424582e-02f, -1.93150714e-01f, -1.72108799e-01f,
  6.59350231e-02f, 1.47655793e-02f, -6.83283061e-02f, 1.45895302e-01f, 1.58451259e-01f, 4.69535813e-02f, 4.38424945e-02f, 1.03976950e-01f, 1.67394638e-01f, 3.12370718e-01f,
  1.42373785e-01f, -3.07444669e-03f, -7.50642344e-02f, -5.31892711e-03f, -2.42701188e-01f, -3.14393714e-02f, -1.24170683e-01f, -1.32935299e-02f, 3.25447917e-02f, -1.62693739e-01f,
  -4.57881987e-01f, -3.93988281e-01f, 1.39117420e-01f, 9.20049474e-03f, 1.00664785e-02f, -1.37079448e-01f, -3.49205658e-02f, -1.21989377e-01f, -3.64453695e-03f, -1.48448855e-01f,
  1.77071372e-03f, 2.63183527e-02f, -1.31615391e-02f, -2.80830022e-02f, -7.62706622e-02f, 2.28583589e-02f, 4.49057110e-02f, -3.67160328e-02f, -1.26892719e-02f, 5.82089536e-02f,
  1.92363009e-01f, 4.28558514e-02f, -2.10576609e-01f, 9.20814797e-02f, -1.19463533e-01f, -1.41977519e-02f, -4.60845120e-02f, -3.91212031e-02f, -6.74751103e-02f, -3.63787949e-01f,
  1.19024627e-01f, 7.61628225e-02f, -2.48635858e-02f, -4.09585722e-02f, 4.69445884e-02f, -5.24852388e-02f, -3.52643281e-02f, -4.48793266e-03f, -1.41972350e-02f, 5.59382048e-03f,
  1.55960694e-02f, 4.06752201e-03f, 4.07819152e-02f, -1.06433824e-01f, -1.16153337e-01f, -9.05481279e-02f, -1.03408201e-02f, 8.04680064e-02f, 1.60240903e-02f, 1.52449282e-02f,
  -2.43381020e-02f, -9.77959782e-02f, -2.87609678e-02f, -4.72025312e-02f, -1.25247668e-02f, 1.39464140e-01f, -1.08674124e-01f, -5.25368229e-02f, -7.29317740e-02f, -1.83864497e-02f,
  -2.97573417e-01f, 3.44989896e-01f, -3.36233556e-01f, 1.07158292e-02f, -8.98069590e-02f, 7.51476083e-03f, -5.54191768e-02f, -7.26203900e-03f, -8.13143626e-02f, -6.96147457e-02f,
  -6.07580394e-02f, -8.87857825e-02f, -1.54318750e-01f, 7.16965348e-02f, 2.72234567e-02f, -1.47439525e-01f, -7.89557174e-02f, -1.66455612e-01f, 1.00230295e-02f, -7.05329925e-02f,
  -9.31212753e-02f, -1.15028076e-01f, -3.97689700e-01f, -2.54435092e-01f, -1.30637884e-01f, -1.77086726e-01f, -1.89367145e-01f, -1.85121983e-01f, -6.65647984e-02f, -3.68690729e-01f,
  4.76782233e-01f, 9.58645567e-02f, -4.08301651e-01f, 2.24432960e-01f, -1.86631367e-01f, -2.14067787e-01f, -2.30329465e-02f, 5.87745905e-02f, 3.97409908e-02f, 1.01892591e-01f,
  1.76819041e-04f, 1.46204278e-01f, 2.96264350e-01f, 8.07633772e-02f, 3.00651882e-02f, 7.07594082e-02f, 4.17474024e-02f, -1.77473649e-01f, -3.62511069e-01f, -2.98348635e-01f,
  2.04915385e-04f, 5.97881190e-02f, 2.49660257e-02f, -1.11587904e-01f, -5.34758344e-02f, -1.21509237e-02f, 2.70335674e-02f, -9.97841731e-02f, -1.65368691e-01f, -9.15175527e-02f,
  -1.63139090e-01f, -1.60224229e-01f, -2.50476211e-01f, -8.98539945e-02f, -2.09744334e-01f, -1.93407722e-02f, -1.72759175e-01f, -1.38142645e-01f, -6.46656156e-02f, -8.44203904e-02f,
  -9.11160111e-02f, -4.20582108e-02f, -8.47388618e-03f, -4.25131358e-02f, -2.91359350e-02f, -7.33485520e-02f, 6.41492940e-03f, -1.54432073e-01f, -2.08220836e-02f, -6.72761947e-02f,
  2.78966110e-02f, -2.02826008e-01f, -1.52223811e-01f, -1.20556779e-01f, -1.63728371e-01f, -3.90896313e-02f, -1.47290111e-01f, -1.62253782e-01f, -1.85252964e-01f, -4.87247743e-02f,
  -2.42072809e-02f, 7.07387924e-02f, 1.25547023e-02f, -1.08170379e-02f, 3.71202789e-02f, 6.39015585e-02f, 2.53391881e-02f, -4.07521613e-02f, 5.70103666e-03f, -7.43599460e-02f,
  -8.51073535e-04f, -1.46829914e-02f, -1.60898909e-01f, 1.30537003e-02f, 7.79969841e-02f, -6.19916171e-02f, -1.22464605e-01f, -3.67865316e-03f, -7.18623474e-02f, -6.12153253e-03f,
  -3.04460302e-02f, -2.82258149e-02f, -5.34831733e-02f, -4.57223356e-02f, -1.24930263e-01f, -5.59901111e-02f, 3.52362469e-02f, -8.75230432e-02f, -4.27919291e-02f, -3.66737768e-02f,
  3.98391634e-01f, 2.20545530e-02f, 1.52991608e-01f, 5.37844226e-02f, -7.38082156e-02f, -1.05030924e-01f, 1.03343233e-01f, -1.24035433e-01f, -3.55586782e-02f, -6.14311025e-02f,
  -9.37783271e-02f, 6.91395402e-02f, 1.15820609e-01f, 5.57835586e-02f, -4.15422618e-02f, 3.68469059e-02f, 1.20443046e-01f, 3.44670229e-02f, 3.64318788e-02f, 1.38682919e-02f,
  1.90689772e-01f, 7.63532221e-02f, 1.42062455e-01f, 1.11736745e-01f, 1.39304046e-02f, 9.69003066e-02f, 1.38500810e-01f, 5.25659919e-02f, 6.76213205e-02f, 3.56781304e-01f,
  7.27685019e-02f, -1.49678275e-01f, -6.10201836e-01f, -2.93896556e-01f, -3.02723527e-01f, -4.01862860e-02f, -1.29520297e-02f, 3.01106218e-02f, -1.06992237e-01f, -1.10649914e-01f,
  -2.19462942e-02f, 6.40769079e-02f, -1.62295729e-01f, 7.70588145e-02f, 1.88176692e-01f, -1.10091500e-01f, -2.75925249e-01f, -1.64663985e-01f, 6.69091046e-02f, 3.03888112e-01f,
  1.08962238e-01f, -8.99726301e-02f, 2.12132582e-04f, -3.81873846e-02f, -3.09867114e-01f, -1.54978961e-01f, -4.44797933e-01f, -1.89923227e-01f, -4.70319651e-02f, -3.49213213e-01f,
  -3.51183712e-01f, -1.49829313e-01f, 5.11339270e-02f, 8.74145404e-02f, -1.41224205e-01f, -1.55660855e-02f, -3.25199962e-02f, -1.65747702e-01f, 1.02671760e-03f, -7.30757341e-02f,
  -1.45750582e-01f, 5.12378104e-02f, -7.05406144e-02f, -1.11331493e-01f, -9.34419110e-02f, 5.44947945e-02f, -1.41660303e-01f, -4.94764261e-02f, -6.43991493e-03f, -1.52665633e-03f,
  1.83778897e-01f, 3.81075107e-02f, -9.03943777e-02f, 2.14475673e-02f, 8.86883959e-02f, 2.89851632e-02f, 1.25771649e-02f, 8.23257715e-02f, 8.65834206e-02f, -1.83219444e-02f,
  1.76565304e-01f, 3.03403698e-02f, -6.81479520e-04f, 1.38441930e-04f, 1.89087316e-01f, -5.79364374e-02f, 3.71998698e-02f, 7.43009001e-02f, 1.32726341e-01f, 2.16718800e-02f,
  4.09429111e-02f, 9.75559428e-02f, 4.37327698e-02f, -5.49414083e-02f, 2.20917761e-02f, -5.91443432e-03f, 1.40110075e-01f, 1.65890917e-01f, 5.22130355e-02f, 2.72723734e-02f,
  4.69350889e-02f, 6.63299114e-02f, -1.86109226e-02f, 1.18635453e-01f, 7.78226852e-02f, 4.92957793e-02f, -9.87813808e-03f, 1.76758841e-01f, 7.78564066e-02f, 5.50427325e-02f,
  -1.97973490e-01f, 3.62209946e-01f, -1.71800807e-01f, -7.75710354e-03f, -1.69882923e-01f, -6.74271286e-02f, -3.78948860e-02f, 5.05782999e-02f, -1.72365323e-01f, -5.07325605e-02f,
  3.16113643e-02f, 5.12088798e-02f, -1.53185353e-01f, 4.12396938e-02f, 1.86228342e-02f, 6.65189698e-03f, 8.41518268e-02f, -1.09982476e-01f, 1.73740745e-01f, 2.61103660e-02f,
  6.27262816e-02f, 1.75543740e-01f, 7.68548846e-02f, 2.71809883e-02f, 9.96325389e-02f, 5.00668511e-02f, -4.89339381e-02f, 3.99629436e-02f, 1.75580859e-01f, 5.07829785e-02f,
  -6.80764467e-02f, 1.94599777e-01f, -9.62185040e-02f, 3.53094228e-02f, -6.21814169e-02f, -9.80168954e-02f, 1.89555004e-01f, 4.86859828e-02f, -1.10841903e-03f, 2.33661920e-01f,
  -3.80738825e-02f, -2.10680723e-01f, -1.25258923e-01f, -1.60427943e-01f, -8.30839947e-02f, 1.91894785e-01f, 9.41275284e-02f, -1.94829255e-01f, -3.54962349e-01f, -2.81473368e-01f,
  -2.18872979e-01f, -2.92495359e-02f, -1.62444308e-01f, -1.51574627e-01f, -8.03613588e-02f, -2.92472690e-01f, 5.62718660e-02f, 2.60667112e-02f, -1.54005066e-01f, -9.39429272e-03f,
  -6.93892539e-02f, 1.78940818e-02f, -1.80267021e-01f, -8.59799162e-02f, 3.30563076e-02f, 2.10779414e-01f, 7.50578567e-02f, 1.68864295e-01f, 1.47858322e-01f, 2.03438640e-01f,
  -1.10049777e-01f, 4.64477427e-02f, 6.88916594e-02f, 9.56873670e-02f, 1.22694388e-01f, 4.25401405e-02f, 9.41343680e-02f, -6.85255975e-02f, 3.43508348e-02f, 3.00973281e-02f,
  5.94129264e-02f, 1.03959593e-03f, 5.13896393e-03f, 6.25638617e-03f, 2.42714919e-02f, -9.80737507e-02f, -1.98910274e-02f, -5.71768433e-02f, -4.63194810e-02f, 1.98902898e-02f,
  8.65437537e-02f, 7.19320253e-02f, 6.51146621e-02f, 6.70408607e-02f, 1.95252329e-01f, 4.19203751e-02f, 2.40950242e-01f, 1.18080951e-01f, 1.44409284e-01f, 1.18265279e-01f,
  6.64847791e-02f, 2.62998819e-01f, 1.21805765e-01f, 2.72036105e-01f, 1.11986689e-01f, 1.83778241e-01f, 1.84433773e-01f, 2.12003365e-01f, 1.39696538e-01f, 1.32863566e-01f,
  -1.51324468e-02f, 1.09209880e-01f, 7.68250972e-02f, 1.66037515e-01f, 1.35197952e-01f, 1.46608055e-02f, 1.27243817e-01f, 1.00396238e-01f, 1.18367910e-01f, 1.63644552e-02f,
  -1.78539380e-01f, -4.18380424e-02f, 4.71872091e-02f, -1.25288740e-01f, -2.91867573e-02f, 1.03885889e-01f, 4.18800637e-02f, 1.20199844e-01f, 1.93722382e-01f, 1.16253853e-01f,
  9.71923545e-02f, 4.26439531e-02f, 1.51178837e-01f, -1.97111312e-02f, 2.31474228e-02f, -2.39238180e-02f, 8.50857869e-02f, -5.77608496e-02f, -7.81225692e-03f, 2.28421185e-02f,
  1.04235500e-01f, -9.69481170e-02f, -1.28157362e-01f, 4.75027692e-03f, -1.42991930e-01f, -1.08112618e-01f, -6.18223511e-02f, -1.15686454e-01f, -9.09159407e-02f, 1.87580064e-01f,
  -6.22393966e-01f, -4.77831066e-01f, 2.44458631e-01f, -2.28449211e-01f, 1.18304253e-01f, 1.69938669e-01f, 1.30368218e-01f, -6.20941706e-02f, -1.74581230e-01f, -2.44037867e-01f,
  -2.84112304e-01f, -1.65647924e-01f, -3.76285911e-01f, -9.14258659e-02f, -1.29093230e-01f, -2.94653494e-02f, 1.19459458e-01f, 1.63227051e-01f, 3.60994250e-01f, 3.22806150e-01f,
  1.35042779e-02f, 7.69526735e-02f, -3.75190098e-03f, 7.00725615e-02f, -1.58871576e-01f, -6.21641688e-02f, -7.17628077e-02f, -1.41119570e-01f, -1.73012409e-02f, -2.74986178e-01f,
  2.18248099e-01f, -4.01357144e-01f, 4.38111909e-02f, -1.16259657e-01f, -9.18848366e-02f, -1.25743330e-01f, -1.74776223e-02f, -2.56607961e-02f, -7.60408938e-02f, -1.22537442e-01f,
  -8.69604573e-02f, 3.44995782e-02f, 7.34765828e-02f, -4.79266569e-02f, 1.78622566e-02f, 1.07662015e-01f, 1.89541597e-02f, -1.77609608e-01f, -5.25170155e-02f, -6.29995018e-02f,
  -8.37569237e-02f, -4.27927785e-02f, 4.29085270e-02f, -6.25156611e-02f, -4.73672859e-02f, -8.94097835e-02f, -8.40684623e-02f, 5.23673138e-03f, -4.95866090e-02f, -2.98352018e-02f,
  3.57410192e-01f, 1.40086496e-02f, -1.20716609e-01f, -1.29835401e-02f, -4.47921939e-02f, -7.61301070e-03f, -7.71131516e-02f, -1.91913061e-02f, -1.18140861e-01f, -1.42554656e-01f,
  -1.27679452e-01f, 1.00850174e-02f, -9.99046043e-02f, -4.03734595e-02f, -4.77877222e-02f, -1.28723592e-01f, -1.68227509e-01f, 1.30412690e-02f, 1.35402512e-02f, -1.98736936e-01f,
  -9.22890976e-02f, -9.13641080e-02f, -9.22632217e-02f, 3.52752097e-02f, -4.83566336e-02f, -6.72890479e-03f, -1.11765312e-02f, -2.41711885e-02f, -2.18807627e-02f, -1.20890684e-01f,
  -6.98982254e-02f, 3.69051062e-02f, -7.85263479e-02f, -1.12247877e-01f, -8.48821476e-02f, -3.89211997e-02f, -6.25630543e-02f, -1.52327428e-02f, -7.20717609e-02f, -4.93348716e-03f,
  1.33318469e-01f, 1.40984580e-01f, -6.93643047e-03f, -6.80724811e-03f, 4.34855781e-02f, 4.06513028e-02f, -6.87209293e-02f, -8.66914615e-02f, 1.02706820e-01f, 4.53626141e-02f,
  1.56278357e-01f, 7.16689378e-02f, 7.81803727e-02f, -1.49172982e-02f, 1.35545909e-01f, 2.21072435e-01f, 9.84034985e-02f, 1.22028284e-01f, 1.56686008e-01f, 1.95090041e-01f,
  -6.33322835e-01f, -2.91230470e-01f, -1.48551643e-01f, 4.48473804e-02f, 3.41059655e-01f, -1.27199322e-01f, -5.39361954e-01f, -3.48565996e-01f, 7.03173578e-02f, -1.82790428e-01f,
  1.19421966e-01f, 1.54422075e-01f, 9.39288959e-02f, 6.45026565e-02f, -3.04294854e-01f, -7.36834705e-02f, 1.04292206e-01f, -4.06212918e-02f, -1.85513347e-01f, -6.07686341e-02f,
  2.51965433e-01f, 6.36830553e-02f, -9.91347730e-02f, -1.65645890e-02f, 2.67645270e-01f, 1.55776247e-01f, 1.11400291e-01f, 1.40748575e-01f, -4.45157252e-02f, 1.45313829e-01f,
  -2.54042894e-01f, -3.53855997e-01f, 1.05486475e-01f, 2.36617431e-01f, 1.83557808e-01f, -1.54406607e-01f, -1.62749261e-01f, -4.03804481e-02f, 9.31172539e-03f, -1.03357717e-01f,
  1.82990029e-01f, -9.99940746e-03f, 1.65145785e-01f, 4.77691926e-02f, 4.62072566e-02f, -2.03912467e-01f, 5.12866164e-03f, -2.44102404e-01f, -2.26717398e-01f, -1.39214635e-01f,
  2.08946407e-01f, 7.82639533e-02f, -1.91616416e-01f, -1.01143084e-01f, -1.88077599e-01f, 8.16746131e-02f, -1.91814303e-01f, -2.25795239e-01f, -3.97699386e-01f, -3.14698279e-01f,
  -1.84174776e-02f, 7.60124400e-02f, 6.31304085e-03f, -9.54627618e-02f, -2.96960883e-02f, 1.03095450e-01f, 8.75068307e-02f, -8.22735298e-03f, 1.79863963e-02f, -5.04073203e-02f,
  -2.18071565e-02f, -3.88258994e-02f, -2.19726078e-02f, -2.43197195e-02f, 8.33677128e-02f, 9.21913087e-02f, 2.92438865e-02f, 1.21172294e-02f, -2.38201730e-02f, -5.42109534e-02f,
  -3.58752459e-02f, -6.79292902e-02f, 1.58940598e-01f, -9.95375589e-03f, -3.47688468e-03f, -4.17996617e-03f, -1.66179705e-02f, -6.53318465e-02f, -3.61123979e-02f, -6.13512471e-02f,
  -7.33808130e-02f, 1.13843970e-01f, -1.32317498e-01f, 1.60425268e-02f, 3.35516554e-04f, 1.60371080e-01f, -6.29449589e-03f, -7.72238448e-02f, 3.58899571e-02f, -6.75275773e-02f,
  -7.91312605e-02f, -1.19043931e-01f, 1.03368886e-01f, 2.95279399e-02f, -1.07538536e-01f, -1.50057413e-02f, 7.46829286e-02f, 5.56548089e-02f, -7.34424740e-02f, 9.05113071e-02f,
  -2.41086655e-03f, -2.98014730e-01f, -3.11239779e-01f, -2.06086248e-01f, -2.75476892e-02f, -1.63797945e-01f, -1.65965930e-01f, -1.77115291e-01f, -3.15033436e-01f, -5.23762643e-01f,
  7.21334517e-01f, 2.42254332e-01f, 1.68807447e-01f, 1.30003363e-01f, -1.59445871e-02f, 4.60562594e-02f, 8.94237235e-02f, 1.01477221e-01f, 4.10467051e-02f, 1.58716515e-01f,
  1.95292309e-01f, 4.84651662e-02f, 3.25494930e-02f, 1.31587654e-01f, 1.11903578e-01f, 1.55951276e-01f, 3.01944576e-02f, 1.85617670e-01f, 2.73793459e-01f, 1.21693030e-01f,
  4.55166213e-04f, 1.09699249e-01f, 1.74584374e-01f, 6.40933663e-02f, 1.81615222e-02f, -2.08501294e-02f, 1.09075233e-01f, 6.21078499e-02f, 1.20521374e-01f, 9.23738927e-02f,
  5.87088391e-02f, 3.87947500e-01f, -1.55303821e-01f, -1.08214647e-01f, -1.15389042e-01f, -4.58110347e-02f, -5.85058751e-03f, 6.36060610e-02f, -1.08118476e-02f, -1.55000001e-01f,
  -1.13759398e-01f, -1.67324468e-02f, 7.81512633e-02f, 3.72960530e-02f, -6.64408952e-02f, 4.12572734e-02f, 1.12148784e-01f, 5.14472425e-02f, 4.93984818e-02f, 5.16713485e-02f,
  -4.05620560e-02f, 5.27630113e-02f, -7.46496096e-02f, 6.10711006e-03f, 3.54985483e-02f, 1.15454234e-02f, -4.19753641e-02f, 8.48463029e-02f, 2.67812777e-02f, 1.26486659e-01f,
  -4.48566750e-02f, 7.53217265e-02f, 1.15119942e-01f, 2.03219011e-01f, 2.91793317e-01f, 2.78632432e-01f, 1.60456479e-01f, -5.40584624e-02f, 1.55461878e-02f, 1.12846546e-01f,
  9.06673968e-02f, 6.58836812e-02f, 9.56941247e-02f, 3.76378885e-03f, 6.60244897e-02f, 6.73932806e-02f, 1.63322929e-02f, 1.81754548e-02f, -7.49010779e-03f, -4.82901484e-02f,
  2.11664811e-02f, 1.16545342e-01f, 1.97404563e-01f, 1.37021199e-01f, 1.40778467e-01f, 1.35742858e-01f, 3.01752612e-02f, -2.86555439e-02f, 1.62658412e-02f, 3.11691780e-02f,
  -5.17387033e-01f, -9.67982933e-02f, 1.32403791e-01f, 1.12613089e-01f, -3.06226071e-02f, -2.92791389e-02f, -2.23031919e-02f, -1.96089614e-02f, -2.02976853e-01f, -4.86588068e-02f,
  -1.77153405e-02f, 3.07026319e-02f, 7.55781913e-03f, -8.22432116e-02f, 8.88332445e-03f, -1.19617999e-01f, -4.56875227e-02f, 9.16807428e-02f, -9.84392762e-02f, -1.58273280e-01f,
  -1.39556900e-01f, 1.58696603e-02f, -3.51804346e-02f, -8.27115402e-02f, -5.92496954e-02f, -9.62165818e-02f, -9.01477411e-02f, -3.25155444e-02f, -1.21963732e-01f, -7.68500268e-02f,
  6.88699245e-01f, 2.90143192e-01f, -7.01453924e-01f, 3.64321768e-01f, -1.61089897e-02f, -3.73233646e-01f, -2.07971215e-01f, 6.77515641e-02f, 3.74190062e-01f, 1.81802304e-03f,
  -1.17079906e-01f, -4.68915254e-02f, -1.98087275e-01f, -3.00325722e-01f, -4.11311358e-01f, -4.25005227e-01f, -4.43529159e-01f, -5.71975052e-01f, -4.23939705e-01f, -7.87759274e-02f,
  2.26799875e-01f, 3.11816424e-01f, 1.40231922e-01f, -7.05167353e-02f, 2.82796174e-01f, -6.95169792e-02f, -1.86249763e-01f, 7.27139637e-02f, -2.97922581e-01f, -5.05698286e-02f,
  -2.37936035e-01f, 9.18412060e-02f, -2.80305922e-01f, 3.76305841e-02f, -3.59316065e-04f, -6.95651304e-03f, -1.37787074e-01f, 5.86536862e-02f, 2.76912227e-02f, -2.52948236e-02f,
  -1.08258381e-01f, -2.06131060e-02f, -3.69479950e-03f, -4.76515256e-02f, 6.43168688e-02f, 4.49557714e-02f, 3.63911763e-02f, -1.49193004e-01f, -4.89971451e-02f, -3.68644623e-03f,
  2.97223628e-02f, -9.50438678e-02f, -2.59462774e-01f, -8.49008933e-02f, -1.44316211e-01f, -1.33362696e-01f, -1.27208903e-01f, 3.02035604e-02f, -2.65741497e-01f, 1.77800670e-01f,
  -2.20909202e-03f, -8.64358693e-02f, 9.20095295e-02f, 1.83044672e-01f, 1.48403972e-01f, -2.44282112e-02f, -1.30128171e-02f, -7.65499100e-02f, -2.78047416e-02f, 1.26850316e-02f,
  -9.04118735e-03f, 7.30253989e-03f, -3.13901603e-02f, -4.71314229e-02f, -5.05617373e-02f, -1.50871156e-02f, -5.30072860e-02f, 1.70592312e-02f, -2.04185136e-02f, 1.22707281e-02f,
  -4.14080434e-02f, -1.57256443e-02f, -7.70627633e-02f, 6.22548573e-02f, 1.31345075e-02f, -1.91003811e-02f, -2.63072308e-02f, 1.71233471e-02f, 2.07025260e-02f, 1.47510897e-02f,
  1.81260467e-01f, -2.83991277e-01f, 8.26968476e-02f, -1.45723134e-01f, -1.00694016e-01f, -8.53718221e-02f, 4.02121209e-02f, -2.57866643e-02f, 3.95919867e-02f, -1.70857273e-02f,
  -1.07351743e-01f, -1.26473382e-01f, -8.38627294e-02f, -7.39314780e-02f, -1.17909841e-01f, 3.05491444e-02f, -8.83651003e-02f, -1.26865134e-01f, -8.22310299e-02f, 1.71953768e-01f,
  9.88146290e-02f, -3.73846032e-02f, 1.13654606e-01f, -8.45640227e-02f, 7.16112331e-02f, -5.81290573e-03f, -9.37583391e-03f, -5.23598567e-02f, -2.75163352e-01f, 2.76354432e-01f,
  -3.22520196e-01f, -2.22477213e-01f, 4.05180342e-02f, -6.91890538e-01f, -3.17008853e-01f, -4.34536561e-02f, -3.14201027e-01f, -3.47595096e-01f, -3.63452792e-01f, -3.01054925e-01f,
  3.81144471e-02f, 2.23258823e-01f, 2.24001095e-01f, 2.66272664e-01f, 3.20641845e-01f, -9.75494161e-02f, 4.22482379e-02f, 2.17062667e-01f, 1.81080684e-01f, -1.63076952e-01f,
  -1.90911278e-01f, -2.36146897e-01f, -1.67320613e-02f, -1.09825537e-01f, -5.18762946e-01f, -8.80461037e-02f, -7.27366582e-02f, -8.91926959e-02f, 9.11369994e-02f, -1.42522752e-01f,
  -7.52060637e-02f, -3.20978880e-01f, 6.18267059e-02f, 5.43998964e-02f, -8.40924457e-02f, 5.70338741e-02f, -1.35268793e-01f, -7.46946707e-02f, -6.60816953e-02f, -9.74436030e-02f,
  -2.23869197e-02f, 6.78369123e-03f, -4.15901206e-02f, -5.56194559e-02f, -2.36660987e-01f, -8.64464790e-02f, -1.75957158e-01f, 2.36500148e-02f, 1.14655323e-01f, 4.45215218e-02f,
  1.48005143e-01f, 2.46366542e-02f, 1.24981709e-01f, 1.11598276e-01f, -2.30373200e-02f, 2.51417369e-01f, -8.99081007e-02f, 8.78312998e-03f, 2.05587193e-01f, -3.07298690e-01f,
  -7.33000264e-02f, 9.70063880e-02f, -1.89048387e-02f, 1.18879396e-02f, 1.13532223e-01f, 1.72595531e-01f, -7.73651451e-02f, 1.82766393e-02f, 6.40299544e-02f, 1.42278478e-01f,
  -2.36893278e-02f, -2.99150310e-03f, 4.42058854e-02f, 7.67626762e-02f, 8.64142329e-02f, 1.15997240e-01f, 3.47245298e-02f, -2.37587392e-02f, -1.46972260e-03f, 2.23957840e-02f,
  9.14876834e-02f, 7.24760368e-02f, -5.52401543e-02f, 5.90352826e-02f, 1.83675036e-01f, -8.96884426e-02f, -4.77665849e-02f, 9.84755009e-02f, -6.43848628e-02f, 9.42102745e-02f,
  -3.01183254e-01f, 4.69698995e-01f, -1.06142879e-01f, -2.78091300e-02f, -9.98611748e-02f, 4.84941714e-02f, 1.37299811e-02f, -9.89415869e-02f, -2.81564109e-02f, -1.63450211e-01f,
  8.82883817e-02f, -4.42377031e-02f, -9.62528363e-02f, -5.42642875e-03f, -1.18414536e-01f, -2.13502767e-03f, -1.77483037e-02f, 8.51409584e-02f, 1.43544972e-01f, -9.98993888e-02f,
  1.24667563e-01f, 9.60116386e-02f, 3.52698192e-02f, 1.28056249e-02f, -7.37181902e-02f, 1.52941898e-01f, 7.94514269e-02f, 7.50764236e-02f, 2.24353462e-01f, -1.47534832e-01f,
  -1.59645647e-01f, 2.06362635e-01f, 1.09819993e-01f, 6.96376413e-02f, -1.71711281e-01f, -2.90740490e-01f, -1.51936352e-01f, 6.60602450e-02f, 1.66932613e-01f, 2.37977117e-01f,
  1.31574478e-02f, -2.11388394e-01f, 7.48773217e-02f, -5.88090084e-02f, -1.40774161e-01f, 1.00092128e-01f, 7.17664510e-02f, -2.59165615e-01f, -4.57403988e-01f, -4.77071136e-01f,
  -3.02840203e-01f, -1.63097739e-01f, -1.69759646e-01f, -1.23618759e-01f, 6.22832105e-02f, -4.63835662e-03f, 2.41473705e-01f, 3.21065411e-02f, -1.61649734e-01f, 2.32569892e-02f,
  8.25370252e-02f, 8.60849023e-02f, -1.81120753e-01f, -2.44228899e-01f, 1.24845020e-01f, -8.78019854e-02f, -8.75513926e-02f, 4.72825244e-02f, -1.60984099e-01f, 9.33321342e-02f,
  -1.93019152e-01f, -1.93331420e-01f, -1.56890079e-01f, -2.16963496e-02f, -1.53141457e-03f, -1.32696599e-01f, -1.60037521e-02f, -1.83917537e-01f, -8.22180733e-02f, -6.00072891e-02f,
  -2.03320846e-01f, -3.31737876e-01f, -9.13461447e-02f, 4.44367900e-02f, -1.18575878e-02f, -2.32058734e-01f, 3.91893908e-02f, -8.38960484e-02f, -2.34444197e-02f, 2.13474900e-01f,
  6.96352273e-02f, 2.58532278e-02f, -3.21572721e-02f, 1.15811452e-01f, 5.28761670e-02f, 5.71946725e-02f, 4.63453867e-02f, -6.94644377e-02f, 1.24963410e-02f, 6.09351583e-02f,
  1.06015518e-01f, 1.55257612e-01f, 9.72900465e-02f, 1.71505973e-01f, 4.01722603e-02f, -8.09865147e-02f, -5.92420138e-02f, 4.46027704e-02f, -5.73192909e-02f, 3.07965893e-02f,
  -5.89672700e-02f, -7.41429478e-02f, -4.64728251e-02f, 6.39560819e-02f, -2.39205565e-02f, 3.48467715e-02f, -9.58468486e-03f, -2.19113287e-02f, 2.63875555e-02f, -9.73162651e-02f,
  1.76199079e-01f, -1.86905906e-01f, 1.10385105e-01f, -1.35164246e-01f, 9.11884978e-02f, 9.58895162e-02f, -3.54570337e-03f, 1.87076218e-02f, 7.68258097e-03f, -2.78539024e-02f,
  -1.82669908e-01f, -5.66257387e-02f, 6.03234656e-02f, -9.84116644e-03f, -1.45269439e-01f, -6.71826601e-02f, -2.96355635e-02f, -9.70816165e-02f, -1.63712408e-02f, -5.57455905e-02f,
  8.25729966e-02f, -1.38616204e-01f, -4.43363329e-03f, 1.14618257e-01f, 8.34103953e-03f, -2.29577363e-01f, 1.28214240e-01f, 5.79792708e-02f, -3.63856927e-03f, 3.86164606e-01f,
  5.60515523e-01f, 2.05937073e-01f, 3.33514959e-01f, 2.04506427e-01f, 1.26139194e-01f, 6.47858530e-02f, -1.21299863e-01f, -9.17225182e-02f, -8.15024003e-02f, 1.42778024e-01f,
  4.10489030e-02f, 1.46404341e-01f, 1.67975321e-01f, 8.68760049e-02f, 3.36190872e-02f, -4.69968095e-03f, -9.02856141e-03f, 2.28489161e-01f, 8.66863877e-02f, 5.11725806e-02f,
  5.85572757e-02f, 1.38385624e-01f, 1.26581714e-01f, 1.12415753e-01f, 1.19025104e-01f, 1.34233713e-01f, -3.11605837e-02f, 6.76601902e-02f, 1.18343487e-01f, 1.90787703e-01f,
  4.35711369e-02f, 1.75658658e-01f, -6.77740797e-02f, -3.00348345e-02f, 3.16490754e-02f, -5.94312400e-02f, -1.53242704e-03f, -3.94718908e-02f, 1.67931654e-02f, -1.43181130e-01f,
  -2.70794127e-02f, -1.63500383e-02f, 1.58182103e-02f, 3.73607054e-02f, -3.02844103e-02f, -1.37995789e-02f, -1.08034231e-01f, 6.50096908e-02f, -4.87669325e-03f, -3.85850519e-02f,
  1.19635677e-02f, 1.26464248e-01f, 1.15858071e-01f, -6.36015534e-02f, 1.15022749e-01f, 1.23943686e-01f, -5.42237908e-02f, 1.06526554e-01f, 1.19988315e-01f, 5.32652698e-02f,
  2.19437197e-01f, 2.45938450e-01f, 1.34073272e-01f, 7.79578015e-02f, -4.96738171e-03f, -2.37176474e-02f, -1.52172670e-02f, 9.52364579e-02f, 7.88276047e-02f, 4.36425991e-02f,
  5.81411161e-02f, 1.23949215e-01f, 9.70284492e-02f, 4.81909048e-03f, 1.31697580e-01f, 3.40032093e-02f, -1.58297829e-02f, -5.81071489e-02f, 1.30690843e-01f, -3.02824471e-02f,
  4.37891074e-02f, -9.16702747e-02f, -3.09923999e-02f, 5.43304980e-02f, -4.50024754e-02f, 9.83079895e-02f, 6.38993531e-02f, 3.00700143e-02f, 1.29954055e-01f, 4.57529314e-02f,
  -4.90335345e-01f, 1.10725895e-01f, 8.10186192e-02f, -3.78084043e-03f, 7.65581653e-02f, -6.25761002e-02f, 7.45763183e-02f, -9.57714990e-02f, -1.70358866e-01f, -1.56511128e-01f,
  -3.83747928e-02f, 8.53708610e-02f, 2.36021541e-02f, -1.07501313e-01f, -4.05955687e-02f, -1.38093561e-01f, -7.60723138e-04f, -6.00123145e-02f, -6.03156397e-03f, 8.69159587e-03f,
  -5.59003688e-02f, -7.95267671e-02f, -3.13475877e-02f, -1.13744847e-01f, -1.77058540e-02f, -7.48512894e-02f, 9.35784483e-04f, -1.15288600e-01f, -1.00711949e-01f, -1.36057884e-01f,
  -5.94009697e-01f, 2.07512379e-01f, 2.52381802e-01f, -5.30029312e-02f, 3.25182617e-01f, 7.78980926e-02f, -8.41713976e-03f, -2.19150260e-01f, -3.08175795e-02f, 2.33291253e-01f,
  1.74022257e-01f, -4.21327762e-02f, 1.80267960e-01f, -4.07886691e-02f, -1.87468320e-01f, 1.69663861e-01f, 2.49392092e-01f, -2.45166093e-01f, -5.22107244e-01f, -2.97080249e-01f,
  -3.34408842e-02f, -2.27475241e-01f, -4.55126792e-01f, -1.34729207e-01f, 2.31787354e-01f, 5.23228524e-03f, 2.99020499e-01f, 1.67978689e-01f, 1.46464184e-01f, 3.09528142e-01f,
  1.27591461e-01f, -2.97678225e-02f, -9.37665924e-02f, 2.47679316e-02f, 1.73505649e-01f, -2.09911183e-01f, -9.46598426e-02f, 5.47212549e-02f, 1.86910611e-02f, 3.23785953e-02f,
  1.03654996e-01f, -2.19340948e-03f, 1.50282785e-01f, -5.41591384e-02f, -1.46840379e-01f, -1.87257245e-01f, -1.79168656e-01f, -4.08150166e-01f, -1.99330285e-01f, -1.56662688e-01f,
  1.38432905e-01f, -3.91030423e-02f, -4.05700728e-02f, -6.18864670e-02f, -9.14736539e-02f, -1.49437711e-01f, -1.12418711e-01f, -2.75411457e-01f, -3.24559420e-01f, -2.30789572e-01f,
  2.47385893e-02f, -7.43498374e-03f, 1.16209075e-01f, -1.17600495e-02f, -8.46369714e-02f, 1.63165465e-01f, 1.16168156e-01f, 9.03634056e-02f, 2.87642088e-02f, -8.40202197e-02f,
  7.30730966e-02f, -1.63014531e-02f, -1.02557860e-01f, 1.00240879e-01f, -3.22318301e-02f, -2.85906866e-02f, -4.99577262e-02f, -4.89750169e-02f, 6.59463345e-04f, -5.27586974e-02f,
  -6.48458377e-02f, -1.38894720e-02f, 3.53104956e-02f, 3.63115175e-03f, 1.43859953e-01f, 4.44165990e-03f, -1.48420138e-02f, -6.67844042e-02f, -5.76947443e-02f, -3.95033583e-02f,
  -1.43362507e-01f, -6.06579222e-02f, 2.44539138e-02f, -4.25203219e-02f, 7.78981447e-02f, 8.65047947e-02f, -5.09339534e-02f, -1.40566076e-03f, 4.50645126e-02f, -9.99686867e-02f,
  -6.32898062e-02f, 1.92558784e-02f, 2.18064457e-01f, -5.17295785e-02f, -1.35416806e-01f, 4.51731607e-02f, 9.61873010e-02f, 1.52211380e-03f, -1.20659746e-01f, 3.52542624e-02f,
  1.86062942e-04f, -2.84548253e-01f, -2.58072823e-01f, -1.19254693e-01f, -2.11862307e-02f, -2.35563204e-01f, -1.31955773e-01f, -2.76965708e-01f, -3.17814380e-01f, -4.05481189e-01f,
  4.82187539e-01f, -3.32166016e-01f, 1.77843273e-01f, 1.16598547e-01f, 2.17495617e-02f, -4.57031541e-02f, -2.59203583e-01f, -1.48511240e-02f, -1.46295773e-02f, 1.98769774e-02f,
  7.15628713e-02f, 9.84309986e-02f, 2.13865861e-01f, 1.39447749e-01f, 4.72129509e-02f, -4.22311202e-02f, 6.39487728e-02f, 3.14435452e-01f, 1.58272430e-01f, 6.60622269e-02f,
  -1.57091662e-01f, -5.52967042e-02f, 1.06780775e-01f, 1.96951374e-01f, -4.63014208e-02f, 1.75948068e-01f, 6.18202165e-02f, -3.73936407e-02f, -3.60687301e-02f, -1.04106441e-01f,
  5.41138351e-02f, 2.24115238e-01f, 2.35769004e-01f, 1.48633108e-01f, 9.33583360e-03f, 4.33119424e-02f, 1.36892170e-01f, 6.53677806e-02f, -4.14790325e-02f, -5.77034056e-02f,
  1.08495653e-02f, 1.31935045e-01f, 1.78016573e-02f, 5.15368283e-02f, 1.27804205e-01f, 1.26570836e-02f, 4.85783443e-02f, -2.03181505e-02f, -3.11041065e-02f, 6.09990442e-03f,
  -1.86006855e-02f, 4.26748656e-02f, 8.08904916e-02f, -2.30577718e-02f, -4.26933020e-02f, 2.02402815e-01f, 2.38277316e-02f, 6.66680485e-02f, 9.89188179e-02f, -5.72133660e-02f,
  1.30413443e-01f, 1.08852521e-01f, 1.33227766e-01f, 5.98599240e-02f, 1.42299414e-01f, 6.49094656e-02f, -4.88166399e-02f, -1.57303717e-02f, 1.98699594e-01f, 1.72498852e-01f,
  6.23231009e-02f, 3.22166942e-02f, 3.20672654e-02f, 6.40288293e-02f, 3.84802401e-01f, 1.43010512e-01f, 7.72085041e-02f, -2.58512124e-02f, 2.11630359e-01f, 4.42833118e-02f,
  2.06976250e-01f, 2.55457964e-02f, 3.58108461e-01f, 4.17030305e-02f, -2.80319583e-02f, 1.19543694e-01f, 1.22963905e-01f, 1.71825871e-01f, 2.50877589e-01f, 1.88139915e-01f,
  -1.90285727e-01f, 2.97772139e-01f, 4.58354466e-02f, -7.34834969e-02f, 3.36533645e-03f, 1.05705205e-02f, -7.62073994e-02f, -1.61092877e-01f, -1.86826244e-01f, -2.43256375e-01f,
  -4.63957079e-02f, 3.35840285e-02f, -6.73508048e-02f, 5.61759435e-02f, 1.35765910e-01f, -4.61178683e-02f, -1.16437981e-02f, 1.15815857e-02f, -7.16717094e-02f, -1.52707368e-01f,
  -1.95746779e-01f, -6.53502345e-02f, -3.04136276e-02f, -3.81933525e-02f, 2.55769938e-02f, 2.15569869e-01f, 4.73265089e-02f, -6.32329434e-02f, 8.11410099e-02f, -1.43503591e-01f,
  7.83138514e-01f, 4.31287676e-01f, 2.10068434e-01f, 2.44278476e-01f, 2.33370826e-01f, 1.19262099e-01f, 8.56367126e-02f, -3.27635743e-02f, 2.25285087e-02f, 1.50518686e-01f,
  2.94591874e-01f, 2.82168478e-01f, 1.51531696e-01f, 8.23014304e-02f, 1.41515046e-01f, 1.83378737e-02f, -6.13142215e-02f, 1.26244456e-01f, 3.82352732e-02f, 1.47845060e-01f,
  1.02004752e-01f, 3.74840200e-02f, 1.22680478e-01f, 8.96448717e-02f, 4.70731109e-02f, 1.06542125e-01f, 1.26872629e-01f, 1.38661966e-01f, 1.75156280e-01f, 5.37755452e-02f,
  9.37586203e-02f, 1.55343190e-01f, -2.47284904e-01f, -6.20806776e-02f, 5.56526855e-02f, -1.87812671e-01f, 2.48508286e-02f, -1.49468824e-01f, -1.34538740e-01f, -1.68318897e-01f,
  2.94888373e-02f, -8.31485540e-02f, 1.96448695e-02f, 1.76035725e-02f, -8.15249085e-02f, -2.02672824e-01f, -1.84995681e-01f, -6.14000335e-02f, -8.71791914e-02f, 5.33606037e-02f,
  5.28273210e-02f, 8.17224309e-02f, -1.02328295e-02f, -4.61286604e-02f, 1.52321860e-01f, -5.84197883e-03f, -4.49048020e-02f, 8.80778730e-02f, -7.21488148e-03f, 9.02535915e-02f,
  8.11944082e-02f, 1.49729535e-01f, 2.22890586e-01f, 1.15177548e-02f, 1.31564006e-01f, -1.28578544e-02f, -2.11037155e-02f, 8.79364535e-02f, 9.29108113e-02f, 8.15503895e-02f,
  -1.34956792e-01f, -1.50472308e-02f, 6.05497742e-03f, 1.21665634e-02f, 6.60302788e-02f, 1.26565486e-01f, -2.43139043e-02f, -1.31142780e-01f, 8.05027708e-02f, -1.70326773e-02f,
  5.52218482e-02f, -1.18572928e-01f, 4.14977521e-02f, -1.39825299e-01f, -1.68233171e-01f, 4.68862206e-02f, 6.42311871e-02f, -1.55365514e-02f, -5.95147349e-02f, -1.68573320e-01f,
  -5.10470033e-01f, 1.22789675e-02f, -8.07349011e-03f, -1.29647464e-01f, 1.20878831e-01f, -4.59650420e-02f, 1.14531890e-01f, 4.41843048e-02f, -8.24029595e-02f, -5.56212701e-02f,
  6.07610401e-03f, 5.22714593e-02f, 4.10428084e-02f, -9.17480439e-02f, -2.01525465e-01f, -1.73289001e-01f, -6.15939125e-02f, -6.28036708e-02f, -1.48651585e-01f, -1.45035461e-01f,
  -6.65589944e-02f, -7.49764070e-02f, -1.41054362e-01f, -7.11340457e-02f, -5.38830087e-02f, -6.58748224e-02f, -5.39638363e-02f, -5.98198548e-02f, -4.74802628e-02f, -1.40056506e-01f,
  2.59804755e-01f, 1.89014524e-01f, 1.43042520e-01f, -7.99531192e-02f, -3.86561245e-01f, -4.78062570e-01f, -5.28573751e-01f, -3.35276365e-01f, -1.39485791e-01f, -1.25070363e-01f,
  -2.77874172e-01f, -2.88152933e-01f, -2.46263638e-01f, -3.83530296e-02f, 4.99283075e-02f, 8.92247185e-02f, 2.53382027e-01f, 3.78373474e-01f, 2.36032769e-01f, 1.31534725e-01f,
  1.17884591e-01f, 3.89637440e-01f, 4.51627225e-01f, 1.62897095e-01f, 2.04412371e-01f, 2.23372038e-02f, 2.63609756e-02f, 3.09291836e-02f, 3.43825966e-02f, 3.70167494e-01f,
  3.20878059e-01f, -1.05404250e-01f, -1.06179245e-01f, 4.24522385e-02f, 1.01263061e-01f, 2.06664532e-01f, 9.25285369e-02f, 1.94528162e-01f, -9.22141671e-02f, 6.95926100e-02f,
  -1.05426535e-01f, 5.72732612e-02f, -1.77937388e-01f, 7.45084658e-02f, 2.40016468e-02f, -8.10038745e-02f, 4.19583619e-02f, 5.04338667e-02f, 1.70199778e-02f, 9.41258445e-02f,
  -9.29320604e-02f, -6.08282238e-02f, -1.86420903e-01f, -2.18956172e-01f, -2.15991259e-01f, -7.52840042e-02f, -1.95656046e-01f, 5.57891838e-03f, -4.27567773e-02f, 1.04202479e-01f,
  -1.52624995e-01f, 1.00833811e-01f, -5.55411801e-02f, -1.99683197e-02f, 1.35124058e-01f, -4.70318906e-02f, 1.61870047e-02f, 6.87533116e-04f, 1.82497613e-02f, -5.60010411e-02f,
  3.13954777e-03f, 7.53239617e-02f, 4.36337106e-02f, 1.91395264e-02f, -1.11654110e-01f, -8.06228910e-03f, 5.72579738e-04f, 1.06104247e-01f, 3.70393693e-02f, 1.09756380e-01f,
  4.99925204e-03f, -3.33375968e-02f, 2.19208188e-02f, 2.63358746e-02f, 2.84998491e-02f, -5.49477898e-03f, 1.20182998e-01f, 2.96523087e-02f, -2.10150727e-04f, -1.17322102e-01f,
  7.92061836e-02f, -2.24803910e-01f, 1.18023939e-01f, 6.59087077e-02f, 8.24730992e-02f, 2.04060543e-02f, 2.38456242e-02f, 1.49667710e-01f, -1.75679382e-02f, 1.17296971e-01f,
  -1.36399686e-01f, -6.05918802e-02f, -6.10381812e-02f, -4.51426506e-02f, 3.41925025e-02f, -1.92847967e-01f, 1.61618963e-01f, 1.23877078e-02f, 2.28725676e-03f, 1.27334908e-01f,
  -5.97520433e-02f, -1.23075508e-01f, -1.96773797e-01f, -2.11051211e-01f, -1.53999403e-01f, -1.91772729e-01f, -1.44531325e-01f, -1.07027061e-01f, -2.10599318e-01f, 6.60258234e-02f,
  8.00364137e-01f, 2.19064709e-02f, -3.91793251e-01f, 7.52458796e-02f, -1.62071541e-01f, -1.26538157e-01f, -1.85573265e-01f, -2.99605262e-02f, 4.01643366e-02f, -2.03186157e-03f,
  9.44231972e-02f, 2.06166759e-01f, -2.12894455e-02f, -1.47223920e-01f, -1.58559337e-01f, -3.69153917e-01f, -3.67552429e-01f, -2.14816421e-01f, -8.16633105e-02f, 3.41464691e-02f,
  3.53362858e-02f, 1.52558103e-01f, 1.97237954e-01f, 5.83649985e-02f, -1.85948431e-01f, -9.80093330e-02f, -3.43256086e-01f, -2.09027618e-01f, -3.02929729e-01f, -3.78409773e-01f,
  -4.53050822e-01f, 2.31388912e-01f, 3.05771902e-02f, 1.08227372e-01f, 1.25229135e-01f, 2.36017406e-01f, 8.32861364e-02f, 3.42389345e-02f, 1.84462637e-01f, -1.01838604e-01f,
  -7.45054614e-03f, -5.85904298e-03f, 6.01091608e-02f, -7.55779969e-04f, 6.80605993e-02f, 1.28591940e-01f, 2.43928462e-01f, 7.65365735e-02f, -4.08691987e-02f, -9.22794491e-02f,
  6.88151047e-02f, 9.08692554e-02f, -8.95207822e-02f, 1.04834512e-01f, 9.96925086e-02f, 5.41052595e-02f, 6.34561479e-02f, -1.28258299e-02f, 3.23059224e-02f, 1.79123610e-01f,
  -1.08592302e-01f, 3.02580819e-02f, -1.31974136e-03f, 2.13104323e-01f, 1.64499268e-01f, 3.15619521e-02f, -5.30945845e-02f, 2.28031371e-02f, -3.60997282e-02f, 2.09054887e-01f,
  -4.64967154e-02f, -1.68075502e-01f, 2.85705701e-02f, 1.20411500e-01f, 2.17328575e-02f, -1.19762369e-01f, -7.68570602e-02f, -3.55953053e-02f, 1.72293074e-02f, -6.88061416e-02f,
  -2.77519841e-02f, -5.72885536e-02f, 3.99600863e-02f, 1.88012570e-02f, -5.24914376e-02f, 4.15087119e-02f, -1.56140581e-01f, -9.23813507e-02f, -3.43901925e-02f, -1.02617376e-01f,
  -2.21070409e-01f, -5.45128472e-02f, 7.04757944e-02f, -5.15792742e-02f, -9.29802954e-02f, 1.55576885e-01f, 1.41771421e-01f, 1.24850616e-01f, -7.94104487e-02f, -9.10792723e-02f,
  -7.42692947e-02f, 5.48672080e-02f, -1.03241075e-02f, -1.76574849e-02f, 1.17775835e-01f, 5.43567576e-02f, 2.06594706e-01f, 1.36115193e-01f, -1.28078371e-01f, -7.72461668e-02f,
  -4.71424423e-02f, -8.60805903e-03f, 9.28927884e-02f, 3.33314016e-02f, -4.09207903e-02f, 3.89922112e-02f, 3.06502599e-02f, -5.64818867e-02f, 2.72792447e-02f, 1.74796715e-01f,
  6.81245029e-02f, 3.23434919e-01f, 1.99801177e-01f, 6.94146827e-02f, -2.11902931e-01f, -1.17445283e-01f, 4.28904826e-03f, 1.30267620e-01f, 1.19258888e-01f, 1.66648194e-01f,
  1.38325254e-02f, 8.80773738e-02f, 1.33601338e-01f, 1.66561738e-01f, 9.96333510e-02f, 1.54948160e-01f, 1.61800221e-01f, 1.91460341e-01f, -1.71440821e-02f, 1.60137415e-02f,
  -1.45130716e-02f, -4.94362153e-02f, 2.61645671e-02f, 1.29779547e-01f, -1.27317756e-02f, -5.33954911e-02f, 2.24708989e-02f, -6.13553561e-02f, 1.88976917e-02f, 9.98362061e-03f,
  1.67629778e-01f, 1.10373117e-01f, 1.49881821e-02f, 1.67661086e-01f, 1.46954551e-01f, 2.26788983e-01f, 9.47545394e-02f, 5.25939874e-02f, 1.45189408e-02f, 3.72498073e-02f,
  1.26289710e-01f, 6.49040192e-02f, 1.08124368e-01f, -6.12183698e-02f, -4.78598736e-02f, 1.01047628e-01f, 1.48421288e-01f, 9.06499475e-02f, 1.07923895e-01f, 2.33392105e-01f,
  1.16493486e-01f, 6.48644492e-02f, 5.07393368e-02f, 1.23271577e-01f, 1.01872301e-02f, 1.49029382e-02f, -2.62881294e-02f, -1.02017466e-02f, -2.15387158e-02f, -5.99790551e-03f,
  2.10030079e-01f, 1.84386790e-01f, 1.19491749e-01f, 5.61230890e-02f, -3.40680555e-02f, 1.71108693e-02f, -1.77625120e-01f, -1.19676240e-01f, 4.53739539e-02f, 1.09362882e-02f,
  -2.90936902e-02f, -1.50852412e-01f, -3.80878034e-03f, -1.40372753e-01f, -1.93636585e-02f, 7.74327591e-02f, -2.10309699e-02f, -2.96701398e-02f, -3.95228118e-02f, 2.26561688e-02f,
  -5.35132810e-02f, 6.95140585e-02f, 5.56043908e-03f, 5.32006519e-03f, 8.35592598e-02f, -6.66071707e-03f, -4.46554720e-02f, 1.00502513e-01f, -9.67804156e-03f, -1.03470311e-01f,
  1.38292193e-01f, -8.32433403e-02f, -1.06235920e-02f, 5.00174202e-02f, -2.17299331e-02f, 1.49565609e-02f, 8.85800552e-03f, -8.80725980e-02f, -7.33371451e-02f, -2.37793922e-02f,
  2.03440804e-03f, 4.10211980e-02f, 5.08279838e-02f, 2.37409193e-02f, -2.05979526e-01f, -7.04023167e-02f, 8.19518641e-02f, 6.00857567e-03f, 1.14057034e-01f, 1.45602882e-01f,
  7.82755986e-02f, 3.88638340e-02f, -8.63206107e-03f, -8.99359062e-02f, -7.39910528e-02f, -3.62223387e-02f, -1.11988187e-01f, -3.98505703e-02f, -1.37675524e-01f, -1.90471649e-01f,
  -4.28422242e-01f, -2.76354700e-01f, -2.46743858e-01f, -3.88914645e-01f, -3.46999049e-01f, -9.15545821e-02f, -1.08232424e-01f, -4.28804681e-02f, -1.29229411e-01f, -3.03522646e-01f,
  -1.41670480e-01f, 2.66240947e-02f, -7.56930560e-02f, -9.16145295e-02f, -7.50823542e-02f, -3.73910397e-01f, -2.68744707e-01f, -3.01709086e-01f, -7.10350741e-03f, 1.29568741e-01f,
  -2.11202472e-01f, -3.98191839e-01f, -2.55503476e-01f, -1.96175203e-01f, -2.31068790e-01f, -2.56556422e-01f, -3.38306934e-01f, -3.06798071e-01f, -2.22227678e-01f, -4.15773928e-01f,
  -1.79508612e-01f, -3.09377518e-02f, 6.05972931e-02f, -8.65105987e-02f, -6.13220893e-02f, -7.69129489e-03f, -7.66613148e-03f, -7.97533020e-02f, 3.86917107e-02f, -1.47930905e-01f,
  -1.89942736e-02f, 5.28676510e-02f, -7.54155591e-02f, 1.85676571e-02f, -1.04063638e-01f, -1.02164820e-01f, 2.28805002e-02f, -9.20172557e-02f, 1.66943893e-02f, 2.99256090e-02f,
  1.41395539e-01f, 1.10218540e-01f, -5.44397021e-03f, 9.08422284e-03f, 1.36401996e-01f, 3.43067385e-02f, 1.67582538e-02f, 2.95001660e-02f, 8.00771713e-02f, -4.52885702e-02f,
  -2.35535502e-02f, -3.55417072e-03f, 1.05146751e-01f, -7.13439938e-03f, 1.48772985e-01f, 6.58610016e-02f, -9.34600160e-02f, -5.99430576e-02f, 2.03348864e-02f, -5.54759279e-02f,
  -2.87352148e-02f, 3.51892151e-02f, -2.40582563e-02f, -1.33272082e-01f, -6.14915453e-02f, 1.81476353e-03f, -1.79646187e-03f, 8.11883155e-03f, 3.78768407e-02f, -3.26459073e-02f,
  4.13142741e-02f, 7.07279146e-02f, -5.82475848e-02f, -6.70776516e-02f, -5.84342703e-02f, 6.22157706e-04f, 1.09856926e-01f, 1.10461526e-01f, 4.74276356e-02f, 1.26677886e-01f,
  -1.32753924e-01f, -1.16294287e-02f, -1.64020017e-01f, 1.07093342e-01f, -1.06859542e-01f, -2.49721073e-02f, 4.40462418e-02f, -8.66883248e-03f, -4.21453565e-02f, 2.83804312e-02f,
  1.48218051e-01f, -1.93647183e-02f, 2.45319419e-02f, 1.04348063e-01f, -2.52307188e-02f, 9.59940329e-02f, 6.57167882e-02f, -3.77002396e-02f, 1.10655144e-01f, 1.30764917e-01f,
  1.41902804e-01f, 8.43166932e-02f, 3.47853755e-03f, 4.18206938e-02f, 1.50576252e-02f, 2.57613901e-02f, 4.50537913e-02f, 1.17110491e-01f, -1.23566194e-02f, -1.18710898e-01f,
  -1.32242516e-01f, -6.86024606e-01f, 2.97124535e-01f, 5.71907796e-02f, 2.12390438e-01f, 8.25125650e-02f, -1.75509676e-01f, 1.36307860e-02f, 8.57983381e-02f, -1.99677438e-01f,
  -1.57889381e-01f, 4.16958285e-03f, -8.67290273e-02f, -1.00644805e-01f, -1.06398746e-01f, -2.80787259e-01f, -1.69646218e-01f, 1.18968152e-01f, 2.31549531e-01f, 6.37294278e-02f,
  -5.13002612e-02f, -1.12809809e-02f, -2.04863157e-02f, 9.95910689e-02f, 9.02526751e-02f, 2.09323578e-02f, -8.66559707e-03f, -7.74067044e-02f, -1.76875532e-01f, -1.16415791e-01f,
  2.96611011e-01f, -2.09881052e-01f, 7.44227832e-03f, -8.97875205e-02f, -1.33680180e-01f, -5.22944406e-02f, -8.11460540e-02f, 1.24301109e-02f, -1.90997601e-01f, -3.30521092e-02f,
  -9.58705787e-03f, -1.02779180e-01f, -2.73330044e-03f, -9.08680027e-04f, 1.54737145e-01f, 1.08065687e-01f, -4.68111318e-03f, -9.46798697e-02f, -3.88985910e-02f, 1.35264155e-02f,
  -1.86166078e-01f, -7.98169672e-02f, 8.76517072e-02f, 8.54658261e-02f, -3.62797789e-02f, 7.98747838e-02f, 1.50708593e-02f, 1.02682365e-02f, 4.17152978e-02f, -1.11162782e-01f,
  -8.05824474e-02f, 1.58830151e-01f, 1.34592116e-01f, 7.38457367e-02f, -4.97345328e-02f, -3.90536003e-02f, -3.90439183e-02f, 5.86577803e-02f, 1.75884634e-01f, 1.30019203e-01f,
  4.76776734e-02f, -1.69493988e-01f, -9.81054977e-02f, -1.77779317e-01f, -2.74249185e-02f, 4.09307927e-02f, 5.74545041e-02f, -4.97668125e-02f, 9.93527621e-02f, 5.15458509e-02f,
  -1.10058195e-03f, 1.59705684e-01f, -3.19224875e-03f, -5.59355244e-02f, -5.33831455e-02f, 5.73255457e-02f, 7.56793544e-02f, -5.73259499e-03f, 1.15657579e-02f, 5.83519675e-02f,
  1.47501886e-01f, -3.10654402e-01f, -1.72665622e-02f, 1.97310708e-02f, -5.56780212e-02f, -1.15494728e-01f, -7.07043931e-02f, 6.23075105e-02f, 7.99765904e-03f, 7.22803399e-02f,
  -5.98996729e-02f, -4.08857614e-02f, 3.81548367e-02f, 1.25486091e-01f, 1.01712078e-01f, 5.32203056e-02f, -6.08003922e-02f, 7.37420395e-02f, -1.37740105e-01f, 5.89600727e-02f,
  -1.65289223e-01f, -4.42465208e-02f, 1.99630991e-01f, 1.69183835e-02f, -5.49896024e-02f, 1.46567151e-01f, 1.21022560e-01f, 6.63601309e-02f, 5.07407002e-02f, -5.57701625e-02f,
  6.54827356e-01f, -4.80665386e-01f, -3.06582022e-02f, 4.11549479e-01f, 2.13201642e-02f, -3.38061929e-01f, -7.47225404e-01f, -1.71728536e-01f, 2.59400934e-01f, -3.04955125e-01f,
  -2.64571644e-02f, 3.68529677e-01f, 3.55335474e-01f, 1.74423069e-01f, -7.67497197e-02f, -3.88981611e-01f, -1.80971459e-01f, 1.30514324e-01f, 1.90309361e-01f, -2.11304083e-01f,
  -1.79087490e-01f, 1.44111570e-02f, 2.42357492e-01f, 1.50602823e-02f, -7.67716095e-02f, 1.30931273e-01f, -6.86011165e-02f, 2.51129288e-02f, -2.69509465e-01f, -3.71258333e-03f,
  7.23072886e-02f, -5.01375869e-02f, -1.72114357e-01f, 2.36357674e-01f, 8.34762976e-02f, 5.95560186e-02f, -1.41315401e-01f, 3.54238749e-02f, -1.07257545e-01f, -4.84258197e-02f,
  9.52818543e-02f, -4.18431759e-02f, 1.30856276e-01f, 3.84022109e-02f, -8.79242364e-03f, -1.14237629e-01f, -7.72559121e-02f, -4.73530069e-02f, -1.04413167e-01f, -1.09598167e-01f,
  -2.44016781e-01f, -3.47161926e-02f, 2.62890533e-02f, -2.34747708e-01f, -3.19769755e-02f, 1.93092316e-01f, -2.16036215e-01f, -2.88137700e-02f, -1.95650280e-01f, -1.53382078e-01f,
  7.73087442e-02f, 2.03241825e-01f, -5.45097329e-02f, -1.07549235e-01f, -1.17340259e-01f, 2.06394680e-02f, 4.86153923e-02f, -4.65319268e-02f, -1.77046601e-02f, -9.37193334e-02f,
  -3.09370644e-02f, -3.10012884e-02f, -3.49021517e-02f, -5.28529845e-02f, 2.49965955e-02f, -8.44886526e-02f, -5.46429418e-02f, -1.15252964e-01f, -2.47093812e-02f, 4.11377251e-02f,
  5.51252589e-02f, -5.97415864e-02f, -2.31331326e-02f, -6.48162216e-02f, -6.30264059e-02f, 3.75210792e-02f, 1.16557062e-01f, 1.04116261e-01f, 1.39172703e-01f, -9.33944955e-02f,
  1.71764895e-01f, -5.40336519e-02f, 3.81303094e-02f, -4.09294367e-02f, -1.38060614e-01f, -5.53056970e-03f, -1.13998748e-01f, 2.88382871e-03f, 1.73661456e-01f, 4.92666624e-02f,
  -1.06381439e-01f, -7.97589123e-02f, -4.72349077e-02f, -2.31733732e-02f, -1.23499624e-01f, -9.62984562e-02f, -1.44779712e-01f, -2.15671994e-02f, -1.98865548e-01f, -4.31574658e-02f,
  -1.42739713e-01f, -1.95245668e-01f, 4.32551056e-02f, -3.36775593e-02f, -1.44012094e-01f, 9.92328897e-02f, -2.07510322e-01f, -1.99404821e-01f, -1.67426869e-01f, -3.47039014e-01f,
  4.12840724e-01f, 3.93796206e-01f, 1.43597633e-01f, 2.11304184e-02f, 5.00213774e-03f, -2.07567230e-01f, -1.42002448e-01f, -5.91188595e-02f, 7.40323067e-02f, 1.83671102e-01f,
  9.83512253e-02f, -1.03315853e-01f, 2.98615526e-02f, -5.11214919e-02f, -1.83981862e-02f, -6.55666664e-02f, -1.03096709e-01f, 5.58896959e-02f, -4.43783551e-02f, -2.84346342e-02f,
  3.66755053e-02f, 1.70431554e-01f, 2.00665489e-01f, 4.40033153e-02f, 1.54596180e-01f, -6.06280528e-02f, 1.35351673e-01f, 5.18712848e-02f, 1.33236811e-01f, 2.67029107e-01f,
  6.39819680e-03f, 4.84057143e-02f, -1.72364369e-01f, 7.69951865e-02f, 1.60319343e-01f, 9.30723995e-02f, -5.68595119e-02f, 1.00804456e-01f, 9.28244814e-02f, -6.20261133e-02f,
  9.15954188e-02f, 1.59574106e-01f, 6.79282025e-02f, -1.09199947e-02f, 2.41735298e-03f, 3.92818376e-02f, 3.85025553e-02f, -1.01382643e-01f, -1.78674415e-01f, 5.86241037e-02f,
  5.11649251e-02f, -7.06770197e-02f, -8.01282898e-02f, -2.13732585e-01f, -2.66109765e-01f, -7.64168724e-02f, -5.37583940e-02f, -1.53583735e-01f, -1.17879964e-01f, 3.85974757e-02f,
  -8.15689042e-02f, -1.02859311e-01f, -3.40783820e-02f, -2.05280736e-01f, -2.11480007e-01f, -6.94819465e-02f, -1.32149570e-02f, -7.23621696e-02f, -2.70437837e-01f, -1.62845924e-01f,
  -1.13962553e-01f, -1.40122861e-01f, -9.29661319e-02f, -4.05155495e-02f, -1.73770189e-02f, 2.33514085e-02f, -3.06180343e-02f, -5.25360219e-02f, -1.80762812e-01f, 1.09834904e-02f,
  -6.17935099e-02f, -8.18077922e-02f, 1.54041678e-01f, -6.11840673e-02f, 1.05315484e-01f, -1.12152528e-02f, 1.60999484e-02f, -1.85516179e-02f, 4.35522571e-02f, 4.95689288e-02f,
  -1.34471834e-01f, -2.99669623e-01f, -6.07439764e-02f, 9.01897103e-02f, 1.63912192e-01f, 1.27909511e-01f, 7.07813399e-03f, 7.37288296e-02f, 1.22534305e-01f, 3.33143249e-02f,
  7.47519657e-02f, 1.80720106e-01f, -2.01566378e-03f, -1.90744959e-02f, -5.54414615e-02f, 3.03463377e-02f, 7.48046041e-02f, 4.53906357e-02f, 8.82922113e-02f, 1.74827665e-01f,
  9.01645422e-02f, -5.06853014e-02f, -9.48025510e-02f, -1.50978506e-01f, -1.07575215e-01f, -1.27975509e-01f, -7.17936978e-02f, -2.86276583e-02f, 4.86496761e-02f, 6.37689456e-02f,
  1.38174653e-01f, -6.39651194e-02f, -5.29830456e-01f, -7.43683577e-02f, -3.85976583e-01f, -2.91364700e-01f, -1.49985760e-01f, 8.57678726e-02f, -2.50933953e-02f, -1.90813646e-01f,
  -1.18956752e-01f, 3.81602198e-02f, -7.10851252e-02f, -5.40118515e-02f, 3.25996019e-02f, -3.28991145e-01f, -3.51466298e-01f, -3.15529615e-01f, -6.61529973e-02f, 1.06324051e-02f,
  3.83237451e-02f, 7.03918487e-02f, 4.78877090e-02f, -5.22870608e-02f, -7.58230761e-02f, -5.69358319e-02f, -2.68365413e-01f, -2.08456367e-01f, -2.47064307e-01f, -2.70169705e-01f,
  -5.50211184e-02f, -1.25960499e-01f, 5.00097387e-02f, 3.40127647e-02f, -5.74204698e-02f, -1.98176992e-03f, -5.36810309e-02f, -1.15209229e-01f, 4.24937829e-02f, -6.18903972e-02f,
  -3.36351730e-02f, 3.55335362e-02f, -2.54084766e-02f, -5.64105324e-02f, -3.83204445e-02f, -7.00741336e-02f, -1.06360026e-01f, -1.48500428e-01f, -1.12715267e-01f, -8.40584412e-02f,
  -1.54962420e-01f, -2.57507771e-01f, -2.84651555e-02f, -4.77233566e-02f, -1.10969611e-01f, -1.41323879e-01f, 1.46649685e-02f, 1.10707888e-02f, -1.43549040e-01f, 4.57304753e-02f,
  -2.38273144e-02f, -7.27151660e-03f, 2.54495963e-02f, 4.17713337e-02f, 1.16952732e-01f, -4.47013676e-02f, 4.32033278e-02f, 5.95711134e-02f, -3.36717744e-03f, 9.60176811e-02f,
  1.66968089e-02f, 9.54424683e-03f, 1.92640387e-02f, -1.24621734e-01f, -1.70747880e-02f, -1.10485340e-02f, -4.02048201e-04f, 5.46375997e-02f, 1.22360205e-02f, -2.85222195e-03f,
  2.03785188e-02f, -1.23851905e-05f, -4.47476730e-02f, 1.55452564e-01f, -1.01077214e-01f, -3.18654962e-02f, -3.77041213e-02f, 1.21953018e-01f, 7.77078867e-02f, -9.02856812e-02f,
  4.26540852e-01f, -1.68560207e-01f, 2.23787546e-01f, -1.60725527e-02f, -1.05129570e-01f, -7.80769214e-02f, -1.67823527e-02f, 6.23194575e-02f, 3.98921892e-02f, 1.56965125e-02f,
  3.12090144e-02f, 6.81530908e-02f, -1.52764870e-02f, 1.62724573e-02f, -3.00020352e-02f, -1.33876085e-01f, 1.43669685e-02f, -4.27982137e-02f, -8.12184252e-03f, 5.03704324e-02f,
  -2.76711695e-02f, 2.57356912e-02f, 2.81084239e-01f, 1.36631146e-01f, 4.06246595e-02f, 1.56638563e-01f, 1.24620937e-01f, 1.64598331e-01f, 1.60475716e-01f, 2.74326205e-01f,
  -2.55937308e-01f, -1.29482225e-01f, -3.60796124e-01f, 1.93654016e-01f, 2.23853841e-01f, -1.61896199e-01f, -2.55025059e-01f, -1.39884070e-01f, 4.29961085e-02f, -1.64762437e-01f,
  -8.35537687e-02f, 1.18572518e-01f, -5.68110868e-02f, 9.94950980e-02f, -1.19294934e-01f, -7.46723413e-02f, 1.62754625e-01f, 7.79008865e-02f, 2.41168588e-02f, 1.11308441e-01f,
  2.81342983e-01f, 2.94750661e-01f, 1.68987274e-01f, 1.87621385e-01f, 1.72786713e-01f, 1.94799870e-01f, 3.13737579e-02f, 1.80927873e-01f, 9.43181738e-02f, 1.56088963e-01f,
  -3.63835216e-01f, -3.29342484e-01f, 8.82380158e-02f, 1.94709226e-01f, 1.12447403e-01f, -2.35149190e-01f, -1.34968832e-01f, -4.75478033e-03f, -6.15702495e-02f, -8.27056989e-02f,
  7.25283921e-02f, -1.27207741e-01f, 6.23176545e-02f, -2.26487480e-02f, -6.40158430e-02f, -2.47295052e-01f, 5.00301160e-02f, -1.04216754e-01f, -1.32168189e-01f, -1.91359207e-01f,
  2.52993762e-01f, -1.74929446e-03f, -3.57001215e-01f, -1.04189001e-01f, -2.78633773e-01f, 8.54319632e-02f, -1.82434469e-01f, -1.94803759e-01f, -2.76389569e-01f, -1.74424544e-01f,
  -1.31827658e-02f, 1.30523825e-02f, -4.02614661e-02f, -6.98110536e-02f, 1.87602818e-01f, 1.27599478e-01f, 1.04245096e-01f, 1.20886207e-01f, -2.47591361e-02f, -1.46661133e-01f,
  4.63969959e-03f, 3.80991958e-03f, 9.64107923e-03f, -1.26102984e-01f, 6.63637966e-02f, -1.09935544e-01f, 5.64757213e-02f, 6.69551715e-02f, -3.56573932e-04f, -9.14983526e-02f,
  -6.59801811e-03f, -7.77952299e-02f, 4.62767147e-02f, 6.34391457e-02f, -2.31445618e-02f, -4.68158983e-02f, -3.63656282e-02f, -4.86030877e-02f, -2.90792566e-02f, -1.18664011e-01f,
  -3.52772698e-02f, -8.30649678e-03f, -2.04553977e-01f, -2.34708376e-02f, -2.61848066e-02f, 6.35644868e-02f, -6.22847164e-03f, 1.03905126e-01f, -9.26717967e-02f, -5.89222014e-02f,
  -1.59940928e-01f, -1.21565059e-01f, 7.36392140e-02f, -3.38567570e-02f, -8.90527517e-02f, -1.20028406e-01f, 1.92351922e-01f, 1.55138388e-01f, 3.76616456e-02f, -1.02088451e-01f,
  5.14825918e-02f, -4.30204235e-02f, -1.04030132e-01f, -1.82520837e-01f, -5.63661344e-02f, 1.35323955e-02f, -7.99920335e-02f, -1.11375913e-01f, -1.89109877e-01f, -1.67350635e-01f,
  -1.63854927e-01f, -4.61936817e-02f, 2.10457340e-01f, 1.58179507e-01f, 2.58956194e-01f, 3.98736596e-01f, 4.86902714e-01f, 3.09469938e-01f, 1.31479591e-01f, 1.08913496e-01f,
  -6.26284629e-02f, -1.47667170e-01f, -1.61552116e-01f, -1.04026951e-01f, -3.34833078e-02f, 2.05053583e-01f, 3.59697491e-01f, 7.62748569e-02f, 6.12525530e-02f, 2.02532426e-01f,
  1.95308179e-02f, 1.36422917e-01f, -6.89689294e-02f, -4.50495258e-02f, -4.35011089e-02f, -1.13270320e-01f, 1.24527223e-01f, 2.12850466e-01f, 7.66413286e-02f, 3.12990397e-02f,
  -3.38106424e-01f, -5.97395673e-02f, -1.24070160e-01f, -1.74075603e-01f, -3.47904265e-02f, -1.16042450e-01f, -7.89431855e-02f, -1.62602395e-01f, -9.05707330e-02f, -2.00436488e-02f,
  -4.44229431e-02f, -7.50274211e-02f, -5.74334413e-02f, -8.09630901e-02f, 1.13304883e-01f, 1.00842468e-01f, -9.58755910e-02f, 7.96204805e-02f, 8.50130338e-03f, -8.59288424e-02f,
  1.56087708e-03f, 1.70506343e-01f, 2.29181334e-01f, 1.73845470e-01f, 3.27025689e-02f, 9.07188356e-02f, -4.27937806e-02f, 4.98693846e-02f, 6.76402524e-02f, 6.02345802e-02f,
  9.22233909e-02f, 1.41287511e-02f, -1.18833527e-01f, -8.47497508e-02f, 2.09304597e-02f, 6.16987832e-02f, 4.90892902e-02f, 8.42019096e-02f, 1.30363718e-01f, 1.07473647e-02f,
  1.19720072e-01f, 3.76175120e-02f, -3.47097442e-02f, 2.07070708e-02f, -9.94998068e-02f, 7.77756562e-03f, 4.01155883e-03f, 5.65522760e-02f, 5.52839600e-03f, -1.60389126e-03f,
  4.37502041e-02f, 8.29217955e-02f, 4.61425520e-02f, -2.74435407e-03f, 6.81781769e-02f, 2.95367884e-03f, 9.77012888e-02f, -7.82241300e-03f, 5.26306927e-02f, 5.65930344e-02f,
  -1.09330863e-01f, -8.60775337e-02f, -1.69348612e-01f, -8.01601782e-02f, -1.34104034e-02f, -1.07396424e-01f, -1.59946367e-01f, -5.22060543e-02f, -2.48543359e-02f, 9.82648805e-02f,
  -7.64227733e-02f, -7.79859573e-02f, 1.31178938e-03f, -3.63611616e-02f, 1.62091315e-01f, -1.78240482e-02f, -1.02473281e-01f, 1.51231557e-01f, 1.13661764e-02f, 1.41777188e-01f,
  8.78249332e-02f, 1.75758153e-01f, 1.10573694e-01f, 1.30214855e-01f, 1.61895394e-01f, 8.60027820e-02f, 2.17181165e-02f, 3.72679420e-02f, 1.49947748e-01f, 1.37456819e-01f,
  -3.48734766e-01f, 3.62764508e-01f, 9.66495797e-02f, -1.28183439e-01f, 2.29255646e-01f, 4.07489479e-01f, 5.09789288e-01f, 2.53553450e-01f, -9.86349881e-02f, 5.30516729e-02f,
  9.22578201e-02f, -2.36568913e-01f, -1.88330740e-01f, -1.06695466e-01f, 8.15480575e-02f, 1.70863360e-01f, -2.70170737e-02f, -2.20635399e-01f, -1.40091687e-01f, -3.33351716e-02f,
  1.60638951e-02f, -6.46234304e-02f, -2.28986949e-01f, -2.56704837e-01f, -2.13920444e-01f, -3.28533322e-01f, -8.39847922e-02f, 1.68814898e-01f, 1.37335896e-01f, -2.08205834e-01f,
  1.22750551e-02f, 2.38739982e-01f, -1.47922233e-01f, -1.02456190e-01f, 8.28561112e-02f, -1.45718023e-01f, 4.62538609e-03f, -2.89926715e-02f, -3.42997722e-02f, 6.34570746e-03f,
  5.38500696e-02f, 4.09338344e-03f, 3.07759307e-02f, -1.31357117e-02f, 1.05592951e-01f, -5.14694490e-02f, 8.03915411e-02f, 8.30502212e-02f, 4.21508588e-02f, 1.16892926e-01f,
  1.00537024e-01f, 1.99564844e-01f, 1.68213964e-01f, 2.01576218e-01f, 1.91513091e-01f, 7.01568788e-03f, 1.33994356e-01f, 1.24680689e-02f, 9.09370482e-02f, -1.74758434e-01f,
  -5.39387353e-02f, 5.90298185e-03f, 7.90564269e-02f, 2.06673853e-02f, -5.80365863e-03f, 7.00080842e-02f, 2.14969646e-02f, 7.84707367e-02f, 1.06176630e-01f, -5.10969618e-03f,
  1.88096222e-02f, 1.54642507e-01f, 1.04638271e-01f, -1.04073714e-02f, -1.30221918e-01f, 8.08218122e-02f, 6.42532706e-02f, 6.16315268e-02f, 1.91970780e-01f, 1.53897777e-01f,
  1.11667462e-01f, 9.08122212e-02f, 1.90885328e-02f, 1.04085840e-01f, 1.62623182e-01f, -2.01958325e-02f, 1.63588915e-02f, 9.62266512e-03f, 4.58145374e-03f, -2.39305221e-03f,
  5.91292493e-02f, 2.70614624e-01f, -1.84949934e-01f, 2.57568937e-02f, -6.10717572e-02f, -8.65100026e-02f, -9.73445475e-02f, -1.06860489e-01f, 6.84583783e-02f, -2.12179474e-03f,
  -1.98521838e-02f, -1.06119104e-01f, 8.80969465e-02f, -8.33625868e-02f, -1.59386814e-01f, -1.00135803e-01f, -3.20731066e-02f, -4.99752574e-02f, 4.35874313e-02f, 1.29541135e-04f,
  2.63818838e-02f, 6.35049189e-04f, -4.85877059e-02f, -1.40047669e-01f, -4.35455963e-02f, -2.18572587e-01f, -5.11442311e-02f, -1.25212476e-01f, -4.74307798e-02f, -2.79863060e-01f,
  -3.84999394e-01f, -2.65215877e-02f, 1.05368711e-01f, -2.09506437e-01f, 8.32747668e-03f, 8.92701373e-02f, -4.24826927e-02f, 1.21152168e-03f, 3.49796675e-02f, -6.66590631e-02f,
  8.44654068e-02f, -1.49302214e-01f, -1.49223238e-01f, -1.67480707e-01f, -2.28502005e-01f, -1.20405130e-01f, -2.19829947e-01f, -2.52073616e-01f, -1.58614367e-01f, -1.16270863e-01f,
  -1.48616627e-01f, -2.42149532e-01f, -2.54476130e-01f, -1.89086258e-01f, -1.11123972e-01f, -2.09047139e-01f, -8.65034759e-02f, -1.20132290e-01f, -7.73377419e-02f, -1.82106107e-01f,
  -3.09769735e-02f, 1.43545970e-01f, 8.10587257e-02f, -6.36824444e-02f, -6.57667220e-02f, -7.32288361e-02f, 1.17724286e-02f, -6.16796780e-04f, -3.57864872e-02f, -3.73444222e-02f,
  -2.44258763e-03f, 1.01442393e-02f, -4.14367579e-02f, -3.06323310e-03f, -2.73137931e-02f, 7.96898678e-02f, 1.28052188e-02f, -6.03542663e-03f, 3.04591246e-02f, 1.14084512e-01f,
  -6.07043728e-02f, -1.13289312e-01f, -7.67726451e-02f, 3.94425616e-02f, 5.55159003e-02f, -9.69818234e-02f, 1.54834297e-02f, 3.48033244e-03f, -5.54583110e-02f, -2.15675384e-01f,
  -6.39491007e-02f, 4.51077446e-02f, 9.05800536e-02f, 3.66119146e-02f, -1.10285394e-01f, 4.73226160e-02f, -1.41553119e-01f, -1.48799300e-01f, 3.74871306e-02f, -6.66571334e-02f,
  2.06607953e-02f, 2.62516476e-02f, -9.30056274e-02f, -4.57311869e-02f, -4.21631373e-02f, -4.51177321e-02f, -6.68085739e-02f, -9.40326452e-02f, -8.07676762e-02f, -6.99291080e-02f,
  -1.02161646e-01f, -2.87591182e-02f, 1.98122282e-02f, -4.11734879e-02f, 5.05021885e-02f, 1.19917784e-02f, 7.24948347e-02f, 2.98578315e-03f, 8.44714344e-02f, 8.00515115e-02f,
  -1.83322430e-01f, 4.11394015e-02f, -8.53287205e-02f, -1.04139149e-01f, -7.29190977e-03f, 3.09878178e-02f, -2.01243218e-02f, -1.75944145e-03f, -6.91069802e-03f, -2.70863343e-02f,
  5.91710582e-02f, -8.77475813e-02f, 1.34250317e-02f, 1.20905088e-02f, -4.25660983e-02f, 8.22770596e-03f, -1.01772003e-01f, -1.07401021e-01f, 4.57815938e-02f, 3.09713511e-03f,
  -7.84848928e-02f, -1.63270801e-01f, -3.47177744e-01f, -1.53626338e-01f, -1.36310264e-01f, -3.06382298e-01f, -2.02727661e-01f, -1.34952679e-01f, -2.58139610e-01f, -3.65241975e-01f,
  -3.13996226e-01f, 2.04427615e-01f, -3.34133327e-01f, -4.73661311e-02f, -1.41583651e-01f, -2.40737230e-01f, -2.14685872e-01f, -3.97412688e-01f, -1.21977441e-01f, 1.65034190e-01f,
  2.65083909e-01f, 2.31951296e-01f, 1.09307334e-01f, 3.09431273e-02f, -1.59852028e-01f, -3.15570869e-02f, -1.69646010e-01f, -2.51421094e-01f, -1.91720545e-01f, 1.52053908e-01f,
  3.78033966e-01f, 2.20120668e-01f, 4.92703430e-02f, -9.33549553e-02f, 3.33607405e-01f, 3.25829029e-01f, 1.89753070e-01f, 1.98173329e-01f, 1.60982832e-01f, 2.40477875e-01f,
  4.24285561e-01f, -9.82722640e-02f, -3.49503785e-01f, -6.84533566e-02f, 8.61401856e-02f, -4.86307740e-02f, -5.97515404e-02f, -1.92284703e-01f, -1.09303616e-01f, -4.61402312e-02f,
  1.04348473e-01f, 7.51678459e-03f, -7.69010484e-02f, 1.23198852e-01f, 1.53950350e-02f, -1.06543444e-01f, -5.09363450e-02f, -2.12609887e-01f, -2.45127186e-01f, 1.14696838e-01f,
  2.17436269e-01f, 2.05864441e-02f, -1.34040609e-01f, -1.97694093e-01f, -1.04846261e-01f, 1.01776049e-01f, 1.14793882e-01f, -5.42648695e-02f, -2.38890186e-01f, 1.87246159e-01f,
  1.17403984e-01f, 2.22802296e-01f, 2.67024469e-02f, 2.87497025e-02f, 1.59904420e-01f, 8.60137120e-02f, 1.34909004e-01f, 9.50820670e-02f, 4.04645503e-02f, 1.14679337e-02f,
  -1.52357578e-01f, -8.98956582e-02f, 7.21827429e-03f, -3.34540978e-02f, 7.84630701e-02f, -6.98066652e-02f, 3.01975012e-02f, 9.49385017e-02f, -4.90789711e-02f, -7.72380531e-02f,
  -4.27609421e-02f, -6.77996427e-02f, -2.43147463e-03f, -4.67694364e-03f, 1.31799979e-02f, -9.79287028e-02f, 3.68307121e-02f, 6.45285519e-03f, 9.31828916e-02f, 1.26999423e-01f,
  3.67534429e-01f, -3.17650408e-01f, 1.42643288e-01f, -2.04632282e-01f, -1.27813101e-01f, -6.17774799e-02f, 5.63968867e-02f, -3.18654537e-01f, -1.30213499e-01f, 2.14853045e-02f,
  -6.33090883e-02f, -2.08461825e-02f, 5.58127426e-02f, 1.06858145e-02f, 1.12924930e-02f, 2.08463632e-02f, 1.02394046e-02f, -2.23902594e-02f, -1.16765723e-01f, 9.53041241e-02f,
  -1.13793321e-01f, -1.76114380e-01f, 1.24675006e-01f, -6.64929152e-02f, 5.17005250e-02f, -1.50208976e-02f, 1.47581011e-01f, 1.02967881e-01f, -1.58102959e-01f, 2.26937234e-01f,
  7.62920901e-02f, 5.65058947e-01f, 3.97648454e-01f, -3.80225688e-01f, 1.75553262e-02f, 2.35779002e-01f, 4.16576296e-01f, 5.55974022e-02f, -3.21393490e-01f, 2.52399892e-01f,
  2.39681527e-01f, -1.91383883e-01f, -1.87361509e-01f, -1.41020671e-01f, 7.03533217e-02f, 1.71167910e-01f, 2.47025024e-03f, -3.73104103e-02f, -1.46224648e-01f, -9.59141739e-03f,
  -1.88359827e-01f, -1.15004919e-01f, -8.72047897e-03f, -8.08722153e-02f, -8.52152035e-02f, -2.81077296e-01f, 1.83652341e-01f, 2.00171515e-01f, 2.63236046e-01f, -7.45360330e-02f,
  2.54788011e-01f, 3.05030376e-01f, -3.80200684e-01f, -2.15319991e-01f, 1.58678249e-01f, 5.15417121e-02f, -7.38938823e-02f, 2.14214940e-02f, -1.62215419e-02f, -1.21124117e-02f,
  6.77462667e-02f, 1.05062522e-01f, -4.20961529e-02f, 7.45200887e-02f, 5.01286946e-02f, -2.01746449e-02f, 1.35496601e-01f, -2.39690347e-03f, 1.93454847e-02f, 8.48085061e-02f,
  -6.63913935e-02f, 1.20196939e-01f, 1.02649771e-01f, -3.64260823e-02f, -1.10134119e-02f, -3.20947379e-01f, 2.00248137e-01f, 5.79123683e-02f, 7.83532262e-02f, -2.42724009e-02f,
  -1.25666425e-01f, 1.71888500e-01f, 1.42056704e-01f, 9.62385093e-04f, -5.88035211e-02f, -2.54676715e-02f, 5.86348474e-02f, 3.74091864e-02f, 4.32275198e-02f, 1.11455761e-01f,
  -1.38522997e-01f, 2.57950579e-03f, 3.08586378e-02f, 1.23193592e-01f, -1.18092082e-01f, -3.18749528e-03f, 4.07729447e-02f, 1.99776962e-02f, -1.47768790e-02f, 6.78720996e-02f,
  -6.58940077e-02f, -5.88084683e-02f, -2.08620597e-02f, -4.46989015e-03f, -5.51752336e-02f, -1.08945861e-01f, -1.22343116e-01f, -3.74457128e-02f, -5.38030639e-02f, 1.51687581e-02f,
  -4.10984933e-01f, 1.30189717e-01f, -3.80561292e-01f, -5.66728115e-02f, 1.81500435e-01f, 9.01848003e-02f, 1.61242730e-03f, 7.94532448e-02f, 2.06201617e-02f, -3.16562764e-02f,
  1.11921556e-01f, -2.17258185e-02f, 6.48341328e-02f, 7.21204374e-03f, -1.19027220e-01f, -1.04618810e-01f, 1.34784669e-01f, -1.78205550e-01f, -1.17197320e-01f, 1.29841715e-01f,
  -6.29645362e-02f, -1.72359034e-01f, -3.15471113e-01f, -2.99174458e-01f, -3.56909424e-01f, -5.19983113e-01f, -1.35598674e-01f, -1.42637044e-01f, -1.44832999e-01f, -1.98216349e-01f,
  -1.14691742e-01f, -4.33535278e-02f, -3.78298104e-01f, 3.75144929e-03f, -8.61123111e-03f, -2.69973427e-01f, -2.44265690e-01f, -2.97252357e-01f, -1.47526667e-01f, -1.00431904e-01f,
  -2.79663876e-02f, 7.53634349e-02f, -7.49977604e-02f, 8.57060999e-02f, -1.35679215e-01f, 3.03103924e-02f, 8.96684602e-02f, 1.23313263e-01f, 1.20655028e-02f, 2.05679655e-01f,
  3.20935249e-01f, 1.23021550e-01f, 9.17772111e-03f, 1.90282717e-01f, 3.52920979e-01f, 1.80529863e-01f, -1.16493754e-01f, 8.86754245e-02f, 1.39318943e-01f, 4.13853139e-01f,
  7.07233325e-02f, -4.46542539e-02f, -1.32097676e-01f, 7.46775120e-02f, 4.94142585e-02f, -1.97042301e-02f, -5.13735053e-04f, 1.56106707e-02f, 7.62520209e-02f, 2.90322620e-02f,
  6.17589988e-02f, 1.35236150e-02f, 1.48611348e-02f, -6.27256706e-02f, -1.35159284e-01f, -1.86803624e-01f, -1.22891188e-01f, -7.37825781e-02f, -1.52013361e-01f, -2.52342429e-02f,
  2.79918015e-01f, 1.50815219e-01f, -2.15272084e-01f, -1.86771318e-01f, -1.98392063e-01f, -1.18485160e-01f, -1.44885361e-01f, -1.93027183e-02f, -3.81516427e-01f, 9.46959406e-02f,
  5.67765422e-02f, -5.63236400e-02f, -1.23906106e-01f, -9.83839631e-02f, 6.64346963e-02f, 1.49816480e-02f, 9.94653478e-02f, 8.78029838e-02f, 5.31101972e-02f, 1.03912704e-01f,
  -2.22752765e-02f, -8.78312904e-03f, 6.74347952e-02f, -3.88779631e-03f, 5.28792143e-02f, -1.32098481e-01f, 1.06613681e-01f, 1.97506081e-02f, -2.02565026e-02f, -1.28500581e-01f,
  4.25030291e-02f, -2.92813908e-02f, -1.01841748e-01f, 7.56646469e-02f, -7.97535703e-02f, -1.25481099e-01f, -4.60839048e-02f, -6.40227869e-02f, -1.64519012e-01f, -1.13932706e-01f,
  -3.68471771e-01f, -3.95659626e-01f, 1.44300848e-01f, 2.73322854e-02f, 9.27303955e-02f, -6.05119392e-02f, -1.97115894e-02f, -5.65896630e-02f, -7.71282315e-02f, 1.60933826e-02f,
  -1.13931887e-01f, -6.88116848e-02f, -7.45300502e-02f, -2.51118876e-02f, -4.04531732e-02f, -1.06187388e-01f, 1.07368849e-01f, 4.57933992e-02f, -6.86040819e-02f, 2.03483663e-02f,
  -1.03032090e-01f, -1.34749860e-01f, -2.25241989e-01f, -2.91145504e-01f, -3.61046121e-02f, -1.79180562e-01f, -1.36409596e-01f, -4.50841635e-02f, -4.41137880e-01f, -3.18339735e-01f,
  3.29334289e-02f, -5.33213377e-01f, -3.43080550e-01f, -3.92414421e-01f, -1.40527695e-01f, 2.05416679e-01f, -2.96340082e-02f, 1.78170368e-01f, -7.79490396e-02f, -3.29677671e-01f,
  1.16604924e-01f, 3.85953128e-01f, 2.72569001e-01f, 3.19482565e-01f, 3.40237916e-01f, -3.60467672e-01f, -3.53690714e-01f, 4.83337641e-02f, 5.24096549e-01f, 3.84609133e-01f,
  -6.64456841e-03f, -1.31196231e-01f, 2.23982949e-02f, 2.95190234e-02f, -4.31869537e-01f, -5.63012138e-02f, -4.39811289e-01f, -2.65657067e-01f, -9.07719806e-02f, -4.91082758e-01f,
  -2.36082897e-01f, -6.96658865e-02f, 3.29401851e-01f, 3.21019918e-01f, -3.84876579e-02f, 2.64316853e-02f, -2.90642343e-02f, -2.12252930e-01f, 1.10377580e-01f, -1.02527358e-01f,
  -5.88438734e-02f, 1.52766585e-01f, -6.54409379e-02f, -1.48321033e-01f, -2.50601172e-01f, 5.27945906e-02f, -1.96248353e-01f, 3.97775508e-02f, 9.20538828e-02f, 2.27553509e-02f,
  -3.33376974e-02f, -1.08319432e-01f, -1.59900963e-01f, -2.16328934e-01f, -1.18464269e-01f, -4.25805263e-02f, -1.97120368e-01f, -6.77022189e-02f, 2.67984997e-02f, -5.42638838e-01f,
  -4.64519225e-02f, -2.48641565e-01f, -7.90068805e-02f, -1.82730295e-02f, 5.11067249e-02f, -2.35970300e-02f, 5.01102060e-02f, 1.82278022e-01f, -5.52203367e-03f, -6.30858094e-02f,
  3.92598324e-02f, 1.09330639e-02f, 1.55703411e-01f, 4.13655676e-02f, -3.47244777e-02f, -1.77287444e-01f, -1.12123471e-02f, 1.01565814e-03f, 4.33668531e-02f, 4.42626551e-02f,
  9.53721181e-02f, 3.37315425e-02f, -1.92732215e-01f, 1.65265083e-01f, 1.48684323e-01f, -1.05233021e-01f, -1.00709215e-01f, -4.79430929e-02f, -1.52615905e-01f, 4.25888039e-02f,
  -1.71231613e-01f, 1.87497154e-01f, -1.77496560e-02f, 1.65622532e-01f, 3.88896652e-02f, -1.12268828e-01f, -5.86452102e-03f, -4.42522839e-02f, -1.65798906e-02f, 1.14956841e-01f,
  -4.91216518e-02f, -1.19924255e-01f, -2.75672376e-01f, -1.25787873e-02f, 1.61018685e-01f, 4.20894623e-02f, 5.61276190e-02f, 1.63367480e-01f, 2.98992675e-02f, -1.22979276e-01f,
  -2.26620451e-01f, 1.05803199e-01f, 2.90613882e-02f, 3.97394188e-02f, -2.04743505e-01f, 1.33395746e-01f, -2.32350811e-01f, -7.63606578e-02f, 6.55864552e-02f, -3.56662303e-01f,
  -5.72749496e-01f, 2.51030773e-01f, 7.99237564e-02f, -2.99784601e-01f, -5.82943559e-02f, 1.01169303e-01f, 1.63986832e-01f, -5.11717349e-02f, -1.33496583e-01f, 2.80009836e-01f,
  1.70187756e-01f, -3.17651868e-01f, -2.46066049e-01f, -2.67237514e-01f, -8.91189501e-02f, 2.55252242e-01f, -2.24550422e-02f, -3.62440705e-01f, -5.18229306e-01f, -2.89433032e-01f,
  -2.50058711e-01f, -3.73891413e-01f, -3.85230303e-01f, -2.28542462e-01f, -2.01733634e-01f, -4.95993257e-01f, -1.26156747e-01f, -3.77259344e-01f, -2.02360302e-01f, -2.42799997e-01f,
  1.41856194e-01f, -2.02972069e-01f, -6.53203428e-02f, -5.74622117e-02f, 9.75529402e-02f, 2.65680999e-02f, -1.34005249e-02f, -2.47716215e-02f, 1.01266369e-01f, 1.78648859e-01f,
  1.17872648e-01f, 7.46723041e-02f, 1.34842135e-02f, 2.05708202e-02f, 2.35748347e-02f, 3.74765098e-02f, 4.01339270e-02f, -8.75933748e-03f, 8.91921222e-02f, 1.20603882e-01f,
  2.46303886e-01f, -6.72957450e-02f, 9.84462351e-02f, 6.37331828e-02f, -2.43490282e-02f, -3.73525731e-02f, 7.97713026e-02f, -1.82332531e-01f, -1.39791504e-01f, -5.10232113e-02f,
  1.50832489e-01f, 2.54613519e-01f, -6.47621928e-03f, 4.99045616e-03f, 9.23244581e-02f, 1.08066887e-01f, 7.84644783e-02f, 7.98294395e-02f, -7.06041902e-02f, 4.68581803e-02f,
  1.60461187e-01f, -1.69525146e-02f, 1.81567259e-02f, -1.87137478e-03f, 1.92715712e-02f, 4.94711753e-03f, -6.09984738e-04f, 6.40520155e-02f, 1.60556305e-02f, -9.73358378e-03f,
  3.26869376e-02f, 9.64844692e-03f, 8.81851017e-02f, 3.44120078e-02f, 9.09261331e-02f, 1.45942897e-01f, 3.19736861e-02f, 1.02092009e-02f, 2.91060917e-02f, -2.15247218e-02f,
  -2.94898987e-01f, -1.72426358e-01f, 3.66620235e-02f, -1.55893624e-01f, 1.56003190e-02f, 3.80087830e-02f, 1.32449372e-02f, 4.02367674e-02f, 7.29675172e-03f, 7.84725845e-02f,
  9.20416415e-02f, -7.12040300e-03f, 1.70732141e-01f, 5.46016097e-02f, 1.24980696e-01f, -2.83085480e-02f, 2.04782039e-01f, 8.55038092e-02f, 9.62183028e-02f, 3.05107504e-01f,
  2.71799952e-01f, 8.55112355e-03f, -2.70029753e-02f, 1.06325485e-01f, -3.80709022e-02f, -1.79738685e-01f, 3.01489253e-02f, 5.92015274e-02f, -1.01087250e-01f, 3.46255302e-02f,
  2.25682184e-01f, -2.00286955e-01f, -1.37969732e-01f, -2.77408123e-01f, -4.30712819e-01f, -1.97104141e-01f, -9.98568386e-02f, 1.46547079e-01f, -2.06356123e-01f, -3.54601681e-01f,
  -2.35014662e-01f, -6.05442747e-02f, -1.57023966e-01f, -8.66877753e-03f, 3.27141762e-01f, -1.97685763e-01f, -1.70602918e-01f, 2.40822569e-01f, 5.75277030e-01f, 3.13407451e-01f,
  -8.61457139e-02f, -2.00532600e-02f, 4.08898175e-01f, 2.82547683e-01f, -3.01984876e-01f, -1.89537972e-01f, -2.47075081e-01f, -1.41369089e-01f, -7.67685771e-02f, -3.17002684e-01f,
  -2.07233936e-01f, 2.34792590e-01f, 4.31642942e-02f, 5.62058277e-02f, -2.73960620e-01f, 1.59111708e-01f, 1.65974110e-01f, 4.95587811e-02f, 6.82793856e-02f, 9.48472917e-02f,
  -2.23794743e-01f, 1.45103425e-01f, -1.21694885e-01f, -4.70052883e-02f, -4.72516865e-02f, 1.23024397e-01f, 7.72684366e-02f, 4.15559024e-01f, 1.13319047e-01f, 8.11949819e-02f,
  -2.04158485e-01f, -7.07189068e-02f, 1.50245260e-02f, -1.10003687e-02f, 2.73452133e-01f, 1.72395129e-02f, 1.09386779e-01f, 2.72550315e-01f, 1.90890133e-01f, -1.80559859e-01f,
  -1.38557762e-01f, -1.18637443e-01f, -3.43619399e-02f, 6.86642602e-02f, -1.49573362e-03f, -5.12921959e-02f, 3.04232910e-02f, 2.81103596e-04f, 4.84898798e-02f, 8.32058489e-03f,
  9.66000333e-02f, 2.31101029e-02f, 1.27683043e-01f, 2.47979928e-02f, -1.54595420e-01f, -6.07170239e-02f, -2.58123074e-02f, 6.11546896e-02f, -3.11675966e-02f, -6.50648251e-02f,
  1.30835474e-01f, 2.83189993e-02f, -1.37490243e-01f, 1.29922763e-01f, 9.46964771e-02f, 2.20906045e-02f, -6.57690838e-02f, 6.98145628e-02f, -7.26885423e-02f, -2.84257866e-02f,
  -3.36540282e-01f, 9.72251445e-02f, -2.25599065e-01f, 1.91115767e-01f, -1.30580768e-01f, -7.04836100e-02f, -1.13265634e-01f, 2.68268660e-02f, -5.28897531e-02f, 4.65913974e-02f,
  1.26247317e-01f, 6.00435734e-02f, -1.88886747e-01f, -4.65719141e-02f, 1.47492541e-02f, -3.31736021e-02f, -9.08729807e-02f, -1.46643847e-01f, 4.06135153e-03f, -9.21380967e-02f,
  -1.31935582e-01f, -1.45158798e-01f, -1.94952771e-01f, -2.55904824e-01f, -1.62465662e-01f, -8.55226144e-02f, -1.79823905e-01f, -1.73518404e-01f, -1.53803319e-01f, -3.76866966e-01f,
  5.46146631e-01f, 3.43587995e-01f, 2.95453459e-01f, 1.44913867e-01f, 1.47377290e-02f, 2.88650483e-01f, 3.44345480e-01f, 3.18738043e-01f, 1.38910562e-01f, 4.44674864e-02f,
  -1.17928252e-01f, -1.67466044e-01f, -6.42446578e-02f, -3.63271986e-03f, 5.15859909e-02f, 9.90397856e-02f, 8.83264393e-02f, 7.11189136e-02f, 1.42774973e-02f, -6.81948336e-03f,
  -1.20640770e-01f, 4.69111018e-02f, 8.13976228e-02f, 1.18570127e-01f, -1.28158564e-02f, 4.03982662e-02f, 1.13099972e-02f, -6.07013516e-02f, -2.10481435e-02f, -1.87573619e-02f,
  -2.79944688e-01f, 1.19394310e-01f, -7.88500160e-02f, -2.48185560e-01f, -1.05546847e-01f, -1.14406191e-01f, 6.58891797e-02f, -8.03496167e-02f, -3.78273390e-02f, -8.84802192e-02f,
  -8.57001022e-02f, -9.60356444e-02f, -1.04617581e-01f, -7.37510398e-02f, -3.71106938e-02f, -3.58402580e-02f, -1.21622957e-01f, 6.68267459e-02f, 2.97585260e-02f, -7.04456344e-02f,
  -1.67346299e-01f, -9.99067128e-02f, -3.64849810e-03f, 5.58464266e-02f, -5.98871447e-02f, -3.04442458e-02f, 6.35708570e-02f, 3.53757665e-02f, 3.92663851e-03f, 4.73025138e-04f,
  1.81306116e-02f, 1.27626613e-01f, 3.95129658e-02f, 1.09679691e-01f, 2.16803569e-02f, 1.07031792e-01f, 3.90595384e-02f, -3.28941196e-02f, -1.88599490e-02f, 4.46943231e-02f,
  -2.34014951e-02f, 9.95152444e-03f, 2.22506285e-01f, 7.78894648e-02f, 6.13856316e-02f, 1.15114801e-01f, 2.15041135e-02f, 4.26167585e-02f, -4.88665141e-02f, 3.13923210e-02f,
  3.25812958e-02f, 3.69065292e-02f, 4.87379404e-03f, 6.90772256e-04f, -5.49202859e-02f, -2.67041419e-02f, -1.00297116e-01f, -1.59906950e-02f, -1.11220740e-01f, 8.92849732e-03f,
  -2.35867813e-01f, -9.34346542e-02f, -4.23207209e-02f, -5.27201071e-02f, -1.44627718e-02f, -3.07803582e-02f, 1.04467854e-01f, -9.48583558e-02f, -7.87658691e-02f, 1.42558489e-03f,
  1.23389419e-02f, 4.65771705e-02f, 6.48335144e-02f, 2.83435863e-02f, -7.21098334e-02f, -9.88691971e-02f, -1.03632472e-01f, -3.53603549e-02f, -3.07361111e-02f, 2.75368076e-02f,
  -5.56530207e-02f, -3.09709217e-02f, -7.75782019e-02f, 5.59099810e-03f, -2.20413480e-04f, -7.81016871e-02f, -3.20050754e-02f, -3.81091051e-02f, -1.05282322e-01f, -4.96113002e-02f,
  -4.98768389e-01f, -5.11659943e-02f, -1.13320477e-01f, -5.92705786e-01f, -3.78032237e-01f, -1.50809333e-01f, -1.07288882e-01f, -1.67915896e-01f, -3.45454186e-01f, -1.92290992e-01f,
  7.79659674e-02f, 3.38546008e-01f, 1.97400272e-01f, 2.77957648e-01f, 2.22813919e-01f, -2.30335936e-01f, -3.11508805e-01f, 2.53754407e-02f, 3.12082350e-01f, 2.29860470e-01f,
  6.06495254e-02f, -2.37349600e-01f, -1.36582747e-01f, -3.45817059e-02f, -2.81520933e-01f, 4.93962169e-02f, -2.94268876e-01f, -2.95316666e-01f, -8.53353068e-02f, -4.20997947e-01f,
  2.16183439e-01f, -1.92028850e-01f, -2.93091442e-02f, -8.42728000e-03f, -1.61559299e-01f, -6.86138347e-02f, 2.30837706e-02f, -1.47067800e-01f, -1.54350340e-01f, -2.10748091e-01f,
  -9.52404290e-02f, -4.95586433e-02f, 7.84339607e-02f, -4.63792793e-02f, -1.13803692e-01f, -5.70041826e-03f, -9.93685722e-02f, -5.25443740e-02f, -7.99773857e-02f, 6.39227927e-02f,
  4.43976447e-02f, -1.15175806e-02f, 5.08186482e-02f, -5.98413236e-02f, 2.14719102e-02f, 1.56246778e-02f, 7.00165108e-02f, -6.15476295e-02f, -5.11032268e-02f, -1.42369837e-01f,
  7.29275569e-02f, 6.70198277e-02f, 5.88206835e-02f, -5.43498285e-02f, -2.77592726e-02f, -2.97774281e-02f, -4.91786636e-02f, -3.62733714e-02f, 3.00842393e-02f, 1.03239797e-01f,
  2.64688171e-02f, 8.38876069e-02f, -2.12499630e-02f, -2.35235281e-02f, -7.18127564e-02f, -5.47518171e-02f, -4.04037116e-03f, 1.23105086e-01f, -5.37696294e-02f, -5.06406315e-02f,
  -2.94488631e-02f, -4.09499817e-02f, -1.45201487e-02f, 4.88984734e-02f, 3.72241922e-02f, -6.29076269e-03f, -2.69887852e-03f, 2.02896163e-01f, 1.52012482e-02f, -6.51555508e-02f,
  2.10346788e-01f, 1.02694072e-01f, -8.93737972e-02f, -1.83968004e-02f, -6.36641383e-02f, -1.10472562e-02f, -9.43848863e-02f, -1.09775864e-01f, -8.11940879e-02f, -7.89715648e-02f,
  3.31142917e-02f, 7.83644989e-02f, 1.34860769e-01f, -2.74803489e-02f, 2.51927972e-02f, -7.73035437e-02f, 2.37811711e-02f, -4.11688425e-02f, -1.16687017e-02f, -4.13303971e-02f,
  -6.26238361e-02f, -2.93688439e-02f, 1.12203620e-01f, 9.01093557e-02f, 3.73548456e-02f, 1.43599778e-01f, 1.18548110e-01f, 1.73164874e-01f, 1.42593130e-01f, -3.77864875e-02f,
  4.71223921e-01f, 3.07963882e-02f, -1.11490853e-01f, 3.42178419e-02f, 5.48350904e-03f, 5.21435216e-02f, 1.91723734e-01f, 2.82898724e-01f, 1.37682065e-01f, 1.77477077e-01f,
  2.33264983e-01f, 2.56102324e-01f, 1.94448292e-01f, 1.87304661e-01f, 4.50797640e-02f, 3.79897207e-02f, 4.78389487e-02f, 1.15764448e-02f, 9.04149041e-02f, 1.14017516e-01f,
  1.14933951e-02f, -6.76084459e-02f, -3.59361880e-02f, 8.22701305e-02f, -8.35421085e-02f, 6.78536966e-02f, -1.52632901e-02f, -1.11936666e-01f, -1.12330578e-01f, -2.35526457e-01f,
  -6.05737627e-01f, -1.47727713e-01f, 1.04849547e-01f, 7.88922831e-02f, -2.24779844e-02f, -6.26627952e-02f, 3.89440879e-02f, -8.10428988e-03f, -1.71499550e-02f, -3.06883715e-02f,
  -2.87321005e-02f, 1.23546002e-02f, -9.34327692e-02f, 6.84697628e-02f, 4.29501347e-02f, 2.23216973e-02f, 6.80965185e-02f, 7.43583366e-02f, -5.45863174e-02f, 2.79151723e-02f,
  -6.05874397e-02f, 1.01102412e-01f, 4.99496087e-02f, 9.77834389e-02f, 1.15225390e-01f, 1.08747661e-01f, 1.07319616e-01f, 5.78480065e-02f, 2.64652935e-03f, 1.74303219e-01f,
  1.59784093e-01f, -8.18080902e-02f, -4.25510556e-02f, 6.35477379e-02f, -6.89251814e-03f, -1.27995089e-02f, 3.53164924e-03f, 3.92658934e-02f, 8.69751722e-02f, 1.13522522e-01f,
  -5.74173545e-03f, 2.36651395e-02f, 6.42654821e-02f, -3.93482670e-02f, -1.63480490e-01f, -3.08348667e-02f, -5.60938828e-02f, -1.42396584e-01f, -2.96670273e-02f, -9.39306691e-02f,
  4.04316783e-02f, -9.01230499e-02f, -1.56538129e-01f, -1.97158903e-01f, -1.49433374e-01f, 9.10985023e-02f, 4.64129746e-02f, 9.54129174e-02f, 7.76674747e-02f, 8.71776119e-02f,
  -1.20928429e-01f, -5.55174612e-02f, -6.42197281e-02f, -1.34790260e-02f, -1.44983172e-01f, -1.43787906e-01f, -1.18116111e-01f, -1.27337277e-01f, -1.95712045e-01f, -1.19843394e-01f,
  -1.10769317e-01f, -1.09602354e-01f, -1.83237031e-01f, 9.16400738e-03f, -1.47208525e-02f, 4.25675884e-02f, 5.40122353e-02f, -3.25589278e-03f, -2.02147439e-02f, -1.83060721e-01f,
  -9.46479589e-02f, 1.94519565e-01f, 8.75109062e-02f, 1.75950408e-01f, 3.45309675e-02f, 6.47259653e-02f, -3.96816805e-02f, 1.26922848e-02f, 8.15350637e-02f, 2.62916684e-01f,
  4.32726532e-01f, -8.46451148e-02f, -2.63459772e-01f, 5.04296757e-02f, 2.08113175e-02f, 3.47691625e-02f, 2.05003068e-01f, 1.19697219e-02f, 4.94623408e-02f, 1.94086269e-01f,
  -1.75736882e-02f, -4.82660495e-02f, -1.56347647e-01f, -4.75918092e-02f, 4.12415825e-02f, 8.51286948e-02f, -1.04666270e-01f, -3.19657207e-04f, 1.17964759e-01f, 1.56691596e-01f,
  8.76115263e-02f, 2.23293349e-01f, 1.50547415e-01f, -1.00507975e-01f, -1.92784563e-01f, -1.81958508e-02f, -9.97142568e-02f, -1.40063882e-01f, -1.47995979e-01f, -2.84235746e-01f,
  1.29683644e-01f, -2.12306976e-01f, 5.33013232e-02f, -8.09905529e-02f, -3.39359380e-02f, 6.36792853e-02f, -9.90982540e-03f, -1.31761074e-01f, -6.03724718e-02f, -5.52231781e-02f,
  -7.70921335e-02f, 7.92464707e-03f, -1.80227861e-01f, -7.01998323e-02f, 7.59938508e-02f, -3.47280800e-02f, -1.23810224e-01f, -1.07259013e-01f, -1.40372261e-01f, -1.69709608e-01f,
  -2.20656231e-01f, -8.41283202e-02f, -5.96576594e-02f, -1.63100034e-01f, -2.40444690e-01f, -1.21091984e-01f, -2.02205628e-01f, -2.26800680e-01f, -9.19150785e-02f, 3.88487019e-02f,
  -1.12469736e-02f, 1.76431332e-02f, -3.99714150e-02f, 4.25596163e-03f, 1.46764979e-01f, -4.66923080e-02f, -1.04109459e-01f, -5.97839840e-02f, 4.80417599e-04f, 1.26005888e-01f,
  -3.51576209e-02f, 1.38836831e-01f, 5.98309003e-02f, 3.83554697e-02f, -4.73649837e-02f, -7.82719329e-02f, 7.79063553e-02f, 5.08242622e-02f, -2.47582067e-02f, 1.22336872e-01f,
  5.23986807e-03f, 1.02823777e-02f, 4.27450985e-02f, -8.47758353e-02f, 1.72228720e-02f, -2.40278561e-02f, 2.15799436e-02f, 1.11707173e-01f, -6.36544153e-02f, -1.00448523e-02f,
  3.71941179e-01f, -1.67490438e-01f, 2.13895634e-01f, -7.11664334e-02f, -6.65496513e-02f, -9.37039703e-02f, -5.44996038e-02f, -7.17336088e-02f, -1.86842661e-02f, -2.74126269e-02f,
  -3.47297788e-02f, 7.06291869e-02f, -1.27572715e-01f, -8.55293646e-02f, 1.75240263e-01f, 7.76260421e-02f, 4.65610363e-02f, 3.12497304e-03f, -2.60938369e-02f, 6.75505847e-02f,
  1.48985591e-02f, 1.54802710e-01f, 3.16700161e-01f, 8.75257552e-02f, -4.71854135e-02f, 2.57689029e-01f, 1.54355437e-01f, 5.10523617e-02f, 1.21152401e-01f, 2.96436459e-01f,
  3.68840814e-01f, 5.45359969e-01f, -3.47189724e-01f, 4.32890356e-02f, -2.87317604e-01f, -2.32109517e-01f, 1.62386715e-01f, 3.22760165e-01f, 1.85906529e-01f, 2.37978473e-01f,
  -1.15175873e-01f, -1.18825719e-01f, -2.04035509e-02f, 3.62488963e-02f, 8.08724761e-02f, 3.63979369e-01f, 2.09397003e-01f, -1.58484757e-01f, -2.71956325e-01f, -9.14597884e-02f,
  1.98856145e-01f, 1.37792051e-01f, 2.31191382e-01f, 5.27375452e-02f, 2.13672314e-02f, -4.84650694e-02f, 5.55403195e-02f, -9.08205435e-02f, -9.09337774e-02f, 1.81691751e-01f,
  -3.67598563e-01f, -1.51057497e-01f, 1.31153259e-02f, 1.77244678e-01f, -6.71291426e-02f, 2.23440856e-01f, 1.37781218e-01f, 5.06722778e-02f, 9.31085646e-02f, 1.35991827e-01f,
  1.58812311e-02f, 5.60708717e-02f, -2.62974165e-02f, -2.14720028e-03f, -1.36956312e-02f, -9.57319811e-02f, 9.42791924e-02f, 1.51481673e-01f, 1.25697196e-01f, -1.20215327e-01f,
  -3.88965234e-02f, -2.95637488e-01f, -2.75500745e-01f, -5.40030450e-02f, -1.86726362e-01f, -2.21244574e-01f, -6.88941404e-02f, -2.18022898e-01f, -1.84407040e-01f, 1.73350379e-01f,
  -2.85124406e-02f, 3.92806791e-02f, -2.19201282e-01f, -1.18290640e-01f, -3.46379727e-02f, -8.76548663e-02f, -8.88976902e-02f, -4.21008356e-02f, -8.49892050e-02f, 4.37062643e-02f,
  1.00171836e-02f, -2.33233705e-01f, -2.24284574e-01f, 1.15295677e-02f, -6.42785663e-03f, -1.12721480e-01f, -6.69483840e-02f, 4.25011069e-02f, -9.89124551e-02f, -7.43071213e-02f,
  -1.14509985e-01f, -2.62306128e-02f, 7.82753062e-03f, 1.91872362e-02f, 1.89547278e-02f, 5.27928285e-02f, 1.08084723e-01f, 4.09398839e-04f, 8.00200552e-02f, 1.86307162e-01f,
  1.41663507e-01f, -4.88732398e-01f, 1.87766165e-01f, 2.54024357e-01f, -3.45499292e-02f, -3.78150232e-02f, -2.00747073e-01f, -9.26424414e-02f, -2.16578823e-02f, -1.24784619e-01f,
  -2.95674521e-02f, -4.77576219e-02f, 8.80288184e-02f, 6.54568747e-02f, -1.70402378e-01f, -1.26257092e-01f, 1.26527637e-01f, 4.02088370e-03f, 3.79083604e-02f, -1.88857187e-02f,
  1.80735230e-01f, 3.96142667e-03f, 1.51808665e-03f, 7.49441832e-02f, 2.42813434e-02f, 9.01242867e-02f, -6.72921613e-02f, 6.07301109e-02f, -6.67537004e-02f, 3.89602870e-01f,
  6.97445571e-01f, -2.10209772e-01f, 3.41295958e-01f, 4.93750982e-02f, -2.05737084e-01f, -1.56592205e-01f, -3.86507243e-01f, -1.09012410e-01f, -1.36027515e-01f, -1.43505707e-01f,
  4.21530269e-02f, 1.73865572e-01f, 1.46299973e-01f, 4.98680845e-02f, 1.19366840e-01f, -7.42823407e-02f, -9.76367146e-02f, 3.75719130e-01f, 3.37479979e-01f, 1.93325669e-01f,
  2.32469160e-02f, 1.24171861e-01f, 2.43817747e-01f, 2.19937310e-01f, -7.69092739e-02f, -2.51227454e-03f, -4.98720631e-02f, -1.34217436e-03f, 9.16094035e-02f, 7.36973286e-02f,
  2.90514026e-02f, 2.43226066e-01f, -1.68521069e-02f, 1.47391498e-01f, 4.70689945e-02f, -7.45780487e-03f, -1.13000117e-01f, -3.34473848e-02f, -9.14497226e-02f, -1.16818771e-02f,
  -5.48725501e-02f, 8.88893977e-02f, 6.02475852e-02f, -4.13412340e-02f, 6.39705732e-02f, 3.83994654e-02f, 1.25771597e-01f, 2.32500270e-01f, -1.32536683e-02f, -5.52733056e-02f,
  -6.47965893e-02f, 1.63489729e-02f, 9.82951671e-02f, -4.72207703e-02f, 8.43135044e-02f, 1.87976018e-01f, -7.69404741e-03f, 6.53832257e-02f, 1.50709465e-01f, -1.55941891e-02f,
  1.28615975e-01f, 2.69648314e-01f, 1.39282927e-01f, 2.41798144e-02f, 5.53600080e-02f, 7.81488642e-02f, -2.38817092e-02f, -5.93270250e-02f, 7.95263723e-02f, 1.70042634e-01f,
  1.38486236e-01f, 1.88148588e-01f, -3.60603677e-04f, 6.36327267e-02f, 7.37097636e-02f, 8.12605470e-02f, -8.60353746e-03f, -1.91636365e-02f, 1.00316778e-01f, 1.54945450e-02f,
  1.76593810e-01f, 4.85599376e-02f, 1.25806555e-01f, 1.22007363e-01f, 4.76872064e-02f, 1.56564713e-01f, 1.29815549e-01f, 6.55900836e-02f, 1.80142168e-02f, 1.26672134e-01f,
  -4.90024835e-01f, 4.59423922e-02f, 2.05811374e-02f, 4.95684855e-02f, -1.04282454e-01f, -8.76515806e-02f, -1.41387463e-01f, -6.93514869e-02f, -1.35289341e-01f, -7.38242194e-02f,
  -1.09387554e-01f, -3.43596749e-02f, -4.56084833e-02f, -5.14635220e-02f, -1.11436956e-01f, -1.07429311e-01f, -3.50007713e-02f, -1.13346472e-01f, -1.41472563e-01f, -1.48598492e-01f,
  -1.76012948e-01f, -1.44168630e-01f, -7.16843680e-02f, -1.86870351e-01f, 3.85388685e-03f, 3.81250195e-02f, -1.69786096e-01f, -8.87941942e-02f, -6.15666173e-02f, -2.74961084e-01f,
  -3.00339043e-01f, -2.18475446e-01f, -1.47156343e-01f, -2.53410220e-01f, -2.41447419e-01f, -1.70395404e-01f, -2.86691248e-01f, -1.05492830e-01f, -9.40093473e-02f, -1.41915262e-01f,
  -1.60010174e-01f, -2.69089520e-01f, -1.59781173e-01f, -1.91334784e-01f, -1.63232327e-01f, -4.60542887e-02f, -1.70733929e-02f, -2.25465313e-01f, -3.12766254e-01f, -3.01099926e-01f,
  -2.65856117e-01f, -2.76531577e-01f, -2.22278148e-01f, -8.14520493e-02f, -1.52814716e-01f, -1.55117005e-01f, -9.29949339e-03f, -1.58832446e-01f, 1.79739669e-03f, -6.81698099e-02f,
  -1.55464008e-01f, -8.30417946e-02f, -1.05418660e-01f, -1.26245484e-01f, -1.59123793e-01f, -2.87308544e-02f, -7.00915828e-02f, -1.50653776e-02f, -7.75220990e-02f, -9.03802216e-02f,
  -1.91128120e-01f, -1.55150622e-01f, -8.42791125e-02f, -1.06213227e-01f, -1.48236871e-01f, -2.86157932e-02f, -2.91204136e-02f, -7.99197480e-02f, 9.76145640e-02f, 7.77037814e-02f,
  -3.67376991e-02f, -1.52303418e-02f, 1.20667722e-02f, 1.36649579e-01f, 1.06641188e-01f, -1.14432396e-02f, -6.70572296e-02f, -2.89741140e-02f, 1.57714114e-01f, -5.98042980e-02f,
  -5.81814907e-03f, 6.11026138e-02f, -5.37833981e-02f, -5.04753739e-02f, 5.97389750e-02f, 1.86063915e-01f, -4.33900394e-02f, -8.49794224e-02f, 1.90072507e-03f, -6.29949793e-02f,
  -7.66482344e-03f, 5.24846688e-02f, -7.46590421e-02f, 3.22755091e-02f, 3.77690941e-02f, -1.39044765e-02f, 8.50615054e-02f, 1.44754527e-02f, 2.57246685e-03f, 1.69952530e-02f,
  -1.15095355e-01f, -2.82065999e-02f, 3.49471718e-02f, 2.55402867e-02f, 2.96937302e-02f, 4.86704260e-02f, 2.24953257e-02f, -4.50973026e-02f, -8.06530565e-02f, -6.03273883e-02f,
  -1.24933258e-01f, 1.91714063e-01f, -1.19250774e-01f, -1.26199901e-01f, -8.34361762e-02f, 9.14218500e-02f, -4.90377098e-02f, 2.32810173e-02f, -8.71043354e-02f, -1.66083142e-01f,
  -1.52056471e-01f, -5.30654341e-02f, -1.07879080e-01f, -2.67988238e-02f, -1.04570165e-01f, 8.91527534e-03f, 3.85460407e-02f, -1.86566696e-01f, 1.20137349e-01f, 7.87518099e-02f,
  1.53385922e-01f, 6.54544085e-02f, -1.43539369e-01f, -3.70825045e-02f, 4.21669893e-02f, -1.92181706e-01f, -9.71151963e-02f, -3.95994633e-02f, 6.31127656e-02f, -9.12403613e-02f,
  -3.97154361e-01f, 1.03253253e-01f, -6.94172978e-01f, -5.17900251e-02f, -3.80015187e-03f, -1.72821842e-02f, 1.83123022e-01f, 9.82969925e-02f, 1.49904698e-01f, 1.10501431e-01f,
  7.75451362e-02f, 2.53452323e-02f, -7.23200813e-02f, -2.47906049e-04f, 1.40018892e-02f, 2.01488167e-01f, 1.44301340e-01f, -2.35687315e-01f, -2.11512819e-01f, 2.09309995e-01f,
  3.39436263e-01f, 1.46639198e-01f, -1.05665654e-01f, -7.29846582e-02f, 4.41057906e-02f, 8.32310468e-02f, -6.84207380e-02f, -2.15799939e-02f, 1.47628821e-02f, -8.23674798e-02f,
  -4.07391340e-01f, -3.02603960e-01f, -1.31429970e-01f, -8.80447552e-02f, -1.43492326e-01f, -1.47535488e-01f, -1.33024650e-02f, -2.40447879e-01f, -1.74751952e-02f, 3.67074199e-02f,
  -8.89823064e-02f, -7.95349628e-02f, 1.36419430e-01f, -3.59756052e-02f, 2.27152370e-02f, -5.23663238e-02f, -2.12138817e-01f, -2.66081929e-01f, -1.68432474e-01f, -3.13859940e-01f,
  1.88743189e-01f, -9.71415117e-02f, -5.09631515e-01f, -8.66747499e-02f, -1.31629720e-01f, -1.14916198e-01f, -3.17075700e-01f, -2.13046581e-01f, -3.46719444e-01f, -2.50654936e-01f,
  -9.01168361e-02f, -3.97908017e-02f, -1.78580154e-02f, 1.99244060e-02f, 1.74648985e-01f, -7.65386457e-03f, -2.52409652e-02f, 3.96817140e-02f, 5.46879806e-02f, -8.69412441e-03f,
  -1.06804341e-01f, -6.58551455e-02f, -1.61122829e-02f, -7.22121671e-02f, 4.99618202e-02f, -1.16242453e-01f, 4.56843637e-02f, 7.33909160e-02f, 8.27887852e-05f, 6.36130273e-02f,
  9.14184451e-02f, -5.92138693e-02f, -8.06438038e-04f, -4.54740264e-02f, 5.08574434e-02f, -5.59049807e-02f, 8.19332525e-02f, -1.24848094e-02f, -7.59107992e-02f, 6.38413429e-02f,
  1.39277980e-01f, 7.78702796e-02f, -8.34227502e-02f, 3.95908067e-03f, -1.21956751e-01f, -3.88740301e-02f, 1.25731185e-01f, -3.37646119e-02f, -6.99412078e-02f, -1.09457463e-01f,
  -2.98699401e-02f, 3.04861721e-02f, 9.00386870e-02f, 5.31993099e-02f, 6.21436574e-02f, -2.51089060e-03f, 7.58170560e-02f, -1.75577670e-01f, 9.69495624e-03f, -4.45655882e-02f,
  1.15853071e-01f, 1.52403757e-01f, -1.92348778e-01f, -1.60689801e-01f, 5.19415401e-02f, 1.66621227e-02f, -1.73800260e-01f, -1.34626746e-01f, -1.46650240e-01f, 4.88384776e-02f,
  1.47681832e-01f, -2.73001492e-01f, -2.92599738e-01f, -5.19276373e-02f, -1.21762641e-01f, 3.56641039e-02f, 1.57669201e-01f, 1.02673844e-01f, 2.49295472e-03f, -8.18812698e-02f,
  9.53199435e-03f, 1.13266282e-01f, 2.01940216e-04f, 8.98635536e-02f, 1.32898346e-01f, -1.15956746e-01f, -2.17773721e-01f, -5.33047318e-02f, 3.02653849e-01f, 2.81417847e-01f,
  9.53345448e-02f, 1.22580596e-03f, 3.39487009e-02f, -4.50591510e-03f, -1.80747926e-01f, -4.80518527e-02f, -2.44750723e-01f, -2.98937857e-01f, -2.78470486e-01f, -4.33392525e-01f,
  1.93066537e-01f, -2.96702743e-01f, -5.17948791e-02f, -1.38339087e-01f, -8.75603557e-02f, 2.00963411e-02f, 9.06491950e-02f, -2.57903840e-02f, 4.34449725e-02f, 3.37800733e-03f,
  -8.39927122e-02f, -1.42317280e-01f, -5.72773144e-02f, -3.12167499e-02f, 5.95647097e-02f, -2.36046482e-02f, 1.39314411e-02f, -3.16094197e-02f, -7.65600652e-02f, -9.81740728e-02f,
  -8.03566650e-02f, -1.50318310e-01f, 6.35588467e-02f, 3.67827900e-02f, -8.11540186e-02f, -5.09091206e-02f, -1.04873665e-01f, -8.96308124e-02f, 2.26153461e-05f, -5.25707677e-02f,
  7.37388879e-02f, -7.00739492e-03f, -7.74708688e-02f, -1.36619741e-02f, 6.44361302e-02f, 2.28672531e-02f, 1.30849615e-01f, 7.78029040e-02f, -8.59094560e-02f, -8.31748080e-03f,
  4.43555154e-02f, 4.32430506e-02f, 4.24644761e-02f, -7.70152807e-02f, -6.05120743e-03f, -1.11540206e-01f, -3.12113296e-02f, -5.08367755e-02f, -9.66435969e-02f, -5.65655231e-02f,
  -1.44537333e-02f, -1.26924679e-01f, -1.23403005e-01f, -5.20294458e-02f, -2.68993489e-02f, -1.18055604e-02f, -9.14558619e-02f, 8.34668726e-02f, 1.38449520e-01f, -1.08369216e-02f,
  3.55673105e-01f, -2.02216178e-01f, 8.72783437e-02f, -5.27578332e-02f, -1.99488953e-01f, -1.41064301e-01f, -1.40069529e-01f, -1.61867008e-01f, -1.25404298e-01f, -2.59299073e-02f,
  -6.44773990e-02f, -5.98978112e-03f, -9.60907061e-03f, -3.80549394e-02f, 1.18729092e-01f, -3.90434414e-02f, -1.25206739e-01f, -1.90522335e-02f, -1.78323522e-01f, -5.44074699e-02f,
  -3.75704616e-02f, 9.93757322e-02f, 2.24123955e-01f, 1.16156109e-01f, 4.11219671e-02f, 1.75970107e-01f, 1.58739910e-01f, 1.01060934e-01f, 4.04417180e-02f, 2.27724403e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 78)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 78;
const float L0_fan_Bp_bar_data[] = {
  4.45040703e-01f, 1.09887786e-01f, 2.58698672e-01f, 3.87834191e-01f, 2.73688465e-01f, 2.64710277e-01f, 1.95057929e-01f, 5.03477156e-01f, 4.69502062e-01f, 3.34577084e-01f,
  2.55545467e-01f, 2.21565872e-01f, 3.62909436e-01f, 4.00602609e-01f, 4.34950203e-01f, 1.14415817e-01f, 3.37420732e-01f, 3.60625386e-01f, 2.98243463e-01f, 5.63888311e-01f,
  2.64007837e-01f, 2.70089924e-01f, 4.29145396e-01f, 2.23249614e-01f, 4.29231226e-01f, 5.72545864e-02f, 4.17639434e-01f, 3.78570914e-01f, 2.06475481e-01f, 4.40031499e-01f,
  2.00232252e-01f, 3.29145133e-01f, 3.62652004e-01f, 6.00285769e-01f, 3.27209085e-01f, 2.88142234e-01f, 4.58647192e-01f, 3.22526574e-01f, 4.16163921e-01f, 2.30399713e-01f,
  2.76154310e-01f, 4.78832424e-01f, 3.43043625e-01f, 3.00389856e-01f, 4.45268005e-01f, 2.59482890e-01f, 2.85581976e-01f, 3.23236793e-01f, 1.79002911e-01f, 3.54164898e-01f,
  4.05739486e-01f, 3.57706279e-01f, 3.89328063e-01f, -7.73196965e-02f, 5.18600419e-02f, 4.04388458e-01f, 6.24795794e-01f, 2.15528324e-01f, 2.52301067e-01f, 3.16510558e-01f,
  3.30467403e-01f, 3.31088156e-01f, -2.79244408e-02f, 4.48835492e-01f, 4.99894381e-01f, 1.29869841e-02f, 1.34503916e-01f, 3.23044479e-01f, 3.79310310e-01f, 2.53537089e-01f,
  2.06618384e-01f, 1.87479705e-01f, 5.29327631e-01f, 4.26954210e-01f, 4.73785907e-01f, 3.11236113e-01f, 3.50323290e-01f, 5.11926532e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -2.29818776e-01f, -1.73394516e-01f, -6.27450049e-02f, -1.53957576e-01f, -6.57480583e-02f, -1.25059873e-01f, -4.16826494e-02f, -3.25737149e-01f, -2.69705385e-01f, -6.01166189e-02f,
  -5.34183681e-02f, -2.09748801e-02f, -1.83969066e-01f, -4.65847105e-02f, -2.20489278e-01f, -8.70474204e-02f, -7.63169304e-02f, -2.26669863e-01f, 4.09996742e-03f, -7.02781901e-02f,
  -7.46740922e-02f, -1.73239768e-01f, 8.05540234e-02f, -1.36135235e-01f, -5.54525852e-02f, 1.19857930e-01f, -3.89560089e-02f, -7.63967410e-02f, 4.10823822e-02f, 1.43304959e-01f,
  4.72104177e-02f, 3.87267763e-04f, -1.61284566e-01f, 5.98981343e-02f, 6.68917596e-02f, 3.51101272e-02f, -1.08587213e-01f, -1.71353847e-01f, -1.10723943e-01f, 5.99358678e-02f,
  5.13156801e-02f, -1.54248685e-01f, -2.56212801e-01f, 1.75389960e-01f, -6.13136031e-02f, 9.89681855e-02f, -1.10921234e-01f, -5.59031107e-02f, 9.30464789e-02f, -1.90903842e-01f,
  -6.28405511e-02f, 2.11060941e-01f, 7.18549639e-02f, -1.87178150e-01f, -2.79186871e-02f, -6.41769052e-01f, 2.76334643e-01f, 2.84676603e-03f, -3.13389570e-01f, -1.84657156e-01f,
  -6.68754339e-01f, 3.22881848e-01f, -3.91114563e-01f, 9.97589156e-02f, 3.19834441e-01f, -6.42318949e-02f, -2.48863891e-01f, -4.32964742e-01f, -1.36052743e-01f, -1.21155344e-01f,
  -2.38100681e-02f, 3.24347436e-01f, -3.48103285e-01f, -2.36106180e-02f, -3.18422943e-01f, -7.25580603e-02f, -6.23782314e-02f, 3.95222127e-01f, 1.92829534e-01f, -7.72548795e-01f,
  2.50418335e-01f, -1.55179143e-01f, -3.56952250e-01f, 3.04130703e-01f, 1.33447954e-02f, -1.02763295e-01f, -4.46181983e-01f, 2.54403502e-01f, -3.94055724e-01f, 3.04329842e-01f,
  -4.74230319e-01f, 4.19015326e-02f, 1.34385213e-01f, -1.51639476e-01f, 3.21419984e-01f, -2.38182545e-01f, -2.67181337e-01f, -1.64771810e-01f, -5.64045131e-01f, -2.98848063e-01f,
  -7.61300474e-02f, -2.13977784e-01f, 2.49224395e-01f, 8.49617273e-02f, 1.83441281e-01f, 1.97898239e-01f, 3.74312624e-02f, -1.48789018e-01f, 2.34888941e-01f, 1.95780575e-01f,
  -2.08396345e-01f, 1.12449721e-01f, 1.58420384e-01f, -9.96428281e-02f, -4.96370673e-01f, 2.74298102e-01f, 4.55013543e-01f, -1.18231945e-01f, 4.97303069e-01f, -7.32439533e-02f,
  1.43493637e-01f, -5.40150842e-03f, -1.79841727e-01f, -5.16148686e-01f, -1.11619368e-01f, 1.11251492e-02f, 1.53941140e-01f, 1.03540003e-01f, 1.68587372e-01f, 7.71924481e-02f,
  8.23557936e-03f, 5.36349341e-02f, 1.33553386e-01f, 4.20197621e-02f, -3.37815762e-01f, 4.21305001e-02f, -8.63755196e-02f, -2.32293122e-02f, 1.55151561e-01f, 7.95688182e-02f,
  8.53818059e-02f, -3.64074111e-02f, 1.63122028e-01f, 3.44018755e-03f, -9.92799327e-02f, 1.69419236e-02f, 1.93479448e-03f, 5.84720522e-02f, 5.82879931e-02f, 1.55540004e-01f,
  6.10003918e-02f, -3.42500918e-02f, -3.43463212e-01f, 9.95634198e-02f, 9.56355929e-02f, -2.20704079e-01f, -3.45702142e-01f, -3.29336226e-01f, -1.27819777e-01f, -9.81957912e-02f,
  -1.75954461e-01f, -1.09356530e-01f, 4.33067940e-02f, 2.26743355e-01f, -3.12762052e-01f, 8.26583207e-02f, -1.85874909e-01f, -2.95946985e-01f, -1.74603909e-01f, 2.76907593e-01f,
  -1.90707758e-01f, -1.13228731e-01f, -1.65700823e-01f, 1.02124043e-01f, 6.77338243e-02f, -5.06254062e-02f, 2.83714592e-01f, -2.96104252e-01f, -3.13507706e-01f, -4.92766470e-01f,
  -1.52579054e-01f, -2.52643466e-01f, 1.19458057e-03f, 4.82167564e-02f, -2.89355278e-01f, -2.12557018e-02f, -3.21307600e-01f, -6.58156499e-02f, -3.44803870e-01f, 3.25643927e-01f,
  2.94385254e-01f, -1.85977474e-01f, -2.41222844e-01f, 2.75483727e-01f, 2.82873493e-02f, -1.25082821e-01f, -4.49359596e-01f, 8.59119091e-03f, 2.01838434e-01f, 3.17921460e-01f,
  -5.10273397e-01f, 2.25233659e-01f, 3.57891954e-02f, 3.23636793e-02f, 2.51296163e-01f, -2.35356912e-01f, -5.76085865e-01f, -4.81080115e-01f, 2.15623766e-01f, 2.52098054e-01f,
  1.40313441e-02f, -9.17954743e-01f, -1.49448648e-01f, -5.26109003e-02f, -8.50812554e-01f, -4.13690329e-01f, 2.48781726e-01f, 2.38358647e-01f, -3.47563446e-01f, -3.55605602e-01f,
  -7.17753649e-01f, 2.09106058e-01f, -3.36368650e-01f, 7.87575006e-01f, -3.64716083e-01f, 2.54809946e-01f, -2.60520756e-01f, 1.68583423e-01f, 4.18717653e-01f, -5.07541299e-01f,
  1.73905134e-01f, -3.90588604e-02f, 1.37155786e-01f, -7.18578994e-02f, 6.95133030e-01f, -1.84856206e-01f, 2.67299861e-01f, -4.04555172e-01f, -1.06536619e-01f, -2.17332557e-01f,
  -4.45731789e-01f, -5.30009270e-01f, -5.47763407e-01f, -2.96964735e-01f, 9.76277351e-01f, -5.43270767e-01f, 2.71049440e-01f, 1.17169432e-01f, 2.12353200e-01f, 1.10148288e-01f,
  1.63039982e-01f, -1.93688363e-01f, 3.33451927e-01f, 1.77235961e-01f, -4.42822576e-01f, 3.10724508e-02f, 8.83959383e-02f, -1.24767825e-01f, 4.16270532e-02f, -6.16285903e-03f,
  4.78124479e-03f, 5.95037788e-02f, 2.23504946e-01f, 5.25201075e-02f, 2.58240551e-01f, 4.72451821e-02f, -8.81332010e-02f, -3.65948528e-02f, 9.78738293e-02f, 8.31530169e-02f,
  -2.45857965e-02f, 2.48980626e-01f, -2.55423468e-02f, 2.93770917e-02f, 8.54024366e-02f, 4.50307317e-02f, 2.59618647e-02f, -7.84463361e-02f, 1.27592841e-02f, 1.22441441e-01f,
  1.65665925e-01f, -2.78618783e-01f, 2.07361519e-01f, 2.40939438e-01f, 2.19122857e-01f, 1.89378440e-01f, -2.19616219e-01f, 9.56023186e-02f, -3.29097966e-03f, 2.27864087e-01f,
  1.66573793e-01f, 1.03532739e-01f, -2.46325910e-01f, -1.91915482e-01f, -6.04953133e-02f, -2.04584211e-01f, -1.50066525e-01f, -2.95495577e-02f, -7.81334564e-02f, -1.94546022e-02f,
  -2.09586233e-01f, 2.17407525e-01f, 2.37444282e-01f, -1.54762994e-02f, 2.06897035e-01f, -6.92773610e-02f, -3.47857356e-01f, -1.92987472e-01f, -4.40181643e-02f, -2.28008687e-01f,
  1.97824568e-01f, -4.40274000e-01f, -3.32800686e-01f, 5.66932738e-01f, -3.10460716e-01f, -7.44229481e-02f, 9.38405916e-02f, 1.31885499e-01f, 5.62963545e-01f, 1.03453234e-01f,
  3.86095107e-01f, -2.98781961e-01f, -1.75630689e-01f, -1.06527187e-01f, -4.60596643e-02f, -2.07862958e-01f, -1.67462423e-01f, 1.86181255e-02f, -1.34610534e-01f, -1.52418673e-01f,
  -1.35150164e-01f, -3.01825821e-01f, 8.44859555e-02f, -3.19877416e-01f, -3.77431393e-01f, -1.75639361e-01f, -2.84750938e-01f, 5.72009981e-01f, -4.45141969e-03f, -1.91714019e-01f,
  7.18493238e-02f, -2.88015902e-01f, 6.85274839e-01f, 5.08314669e-01f, -2.81961590e-01f, -1.37092367e-01f, -2.81448603e-01f, 3.26356560e-01f, 3.65268618e-01f, -5.10154486e-01f,
  -5.99784613e-01f, 3.60436916e-01f, -9.32220519e-02f, -1.01703107e-01f, -1.69908777e-01f, 3.47322226e-01f, -3.45318943e-01f, 1.72629327e-01f, 2.66802832e-02f, 6.43587634e-02f,
  -2.18835726e-01f, 8.55233073e-02f, 5.65744698e-01f, 8.16394482e-03f, -5.04755735e-01f, 3.55012238e-01f, -2.28906706e-01f, -1.60405070e-01f, -7.34106302e-02f, -5.03699899e-01f,
  -1.40448883e-01f, -2.80448496e-01f, 2.75283754e-02f, -2.55768061e-01f, 4.69152987e-01f, -1.48792654e-01f, -4.65931967e-02f, -1.22873880e-01f, -2.47794852e-01f, -2.62597293e-01f,
  1.07871279e-01f, 5.79208583e-02f, -2.66932517e-01f, -5.55245318e-02f, -7.35664666e-02f, -6.34902269e-02f, -1.71265751e-01f, 7.40922391e-02f, -1.28409043e-01f, 4.59712744e-02f,
  -4.28445414e-02f, -1.82706177e-01f, 5.75190187e-02f, -1.18833274e-01f, -6.20979350e-03f, -4.15089540e-02f, -7.71987587e-02f, -1.01680551e-02f, -6.82677254e-02f, -4.25414648e-03f,
  4.63897511e-02f, -7.74631873e-02f, 9.48482826e-02f, -5.40343439e-03f, -6.63806424e-02f, -1.65199712e-01f, 6.62879273e-02f, -1.38379723e-01f, -1.25791743e-01f, -2.68499833e-02f,
  4.72924300e-02f, 2.22075567e-01f, -6.06912076e-02f, 5.59754930e-02f, 2.54259288e-01f, 1.83112174e-02f, -3.02388191e-01f, 7.12084621e-02f, -1.78931713e-01f, -1.63931437e-02f,
  6.55758977e-02f, -2.23102495e-01f, 1.32163614e-02f, -4.21740161e-03f, 1.03832506e-01f, -1.41633302e-01f, 1.49934832e-02f, 1.77668542e-01f, -7.35659748e-02f, -8.39195698e-02f,
  -1.10156059e-01f, 3.76693569e-02f, 1.30156919e-01f, 2.37650409e-01f, 6.24345429e-02f, 1.57705605e-01f, -6.05370216e-02f, 1.25871882e-01f, -3.41272384e-01f, -3.00928742e-01f,
  2.31594279e-01f, 3.85916606e-02f, 1.08722039e-01f, -1.94486216e-01f, 3.87685299e-02f, -3.02036077e-01f, -4.88112122e-01f, 4.52426113e-02f, 2.41071492e-01f, -2.76056558e-01f,
  -3.39329958e-01f, 6.38397336e-02f, 4.30406243e-01f, 3.43526036e-01f, -5.29785939e-02f, -2.72552162e-01f, 8.11775982e-01f, -1.89347818e-01f, -3.45347464e-01f, -2.55798668e-01f,
  -2.47776974e-02f, -6.10844254e-01f, 1.21886291e-01f, -8.28272924e-02f, -3.94666791e-01f, -1.97466299e-01f, -3.77994359e-01f, -3.59762490e-01f, 5.03121138e-01f, 8.21226761e-02f,
  -2.92110950e-01f, 3.64574313e-01f, -3.96625817e-01f, 1.97571293e-01f, 1.77015606e-02f, 2.71321923e-01f, 4.47484441e-02f, -2.08129868e-01f, -8.07915628e-01f, 4.24928606e-01f,
  -3.73914689e-02f, -1.15843110e-01f, 2.63155460e-01f, -4.04250205e-01f, -2.09905684e-01f, -4.84697409e-02f, -5.86703360e-01f, -3.29215080e-01f, 1.67418063e-01f, -4.86025512e-01f,
  -9.36523974e-01f, -3.25344920e-01f, -3.27541143e-01f, -2.81321496e-01f, 1.57040879e-01f, 2.93348938e-01f, 1.98354721e-01f, -3.57727975e-01f, 4.70661730e-01f, -1.40773088e-01f,
  2.24909931e-01f, 3.19292903e-01f, 6.70250952e-02f, -2.86436409e-01f, 1.36940747e-01f, 6.37330562e-02f, -2.65706927e-01f, -2.40327135e-01f, -2.88103074e-01f, 2.13138685e-01f,
  1.91950545e-01f, -3.75723243e-01f, -6.32647127e-02f, -1.53221175e-01f, -8.98799747e-02f, -2.17916489e-01f, -5.53457439e-02f, 1.13874093e-01f, 4.85386513e-02f, 3.54720801e-01f,
  8.65848213e-02f, -2.91813072e-02f, -2.11317435e-01f, -2.77025159e-02f, -1.61428407e-01f, -3.45736071e-02f, -5.60885444e-02f, -1.33843318e-01f, -1.34471297e-01f, 3.48196812e-02f,
  -5.02300225e-02f, -1.92365572e-01f, -4.70066816e-01f, 1.27347156e-01f, -1.79602429e-01f, 2.73815572e-01f, -7.04389289e-02f, 9.46242139e-02f, 1.43353641e-01f, 9.59302261e-02f,
  -9.62675288e-02f, 6.86313957e-02f, -2.68961093e-03f, 1.77841723e-01f, 3.30562815e-02f, -2.45221496e-01f, -2.18649253e-01f, -2.14661762e-01f, 1.32029936e-01f, 1.50714874e-01f,
  -2.35591203e-01f, -1.36703119e-01f, 7.57809281e-02f, -2.21338496e-02f, 1.90136001e-01f, -2.38956198e-01f, 1.18001051e-01f, -1.18186027e-01f, -2.10484743e-01f, 6.36189356e-02f,
  1.05674728e-03f, -1.06378756e-01f, -2.20020078e-02f, 2.09282890e-01f, 2.67163903e-01f, 2.83531249e-01f, 1.66479417e-03f, 4.64670509e-02f, -5.24271987e-02f, 2.22179219e-01f,
  2.80601978e-01f, -7.45350346e-02f, 2.66929120e-01f, -4.39202935e-01f, 3.04406852e-01f, -1.38564438e-01f, -5.47537625e-01f, -1.15879856e-01f, -3.40397954e-01f, -2.96902619e-02f,
  -8.80200863e-02f, -2.62841314e-01f, 5.78343496e-02f, -2.52768219e-01f, -7.87954807e-01f, 2.67444700e-01f, -1.61859393e-01f, 1.39446422e-01f, -1.24336295e-01f, 1.23855762e-01f,
  1.99765310e-01f, 5.53084850e-01f, 4.51246500e-02f, -2.24200189e-01f, -1.07957035e-01f, -5.30647397e-01f, -4.12781358e-01f, 2.62185931e-01f, 3.38333488e-01f, -2.22857103e-01f,
  -9.88948438e-03f, -4.26759571e-01f, 1.26872584e-01f, -1.65992573e-01f, 2.43279427e-01f, 8.05227235e-02f, 9.94800329e-02f, -2.69202292e-01f, 3.90325338e-01f, -2.84214139e-01f,
  3.41295630e-01f, 2.41237916e-02f, -2.67110139e-01f, -4.90236551e-01f, -1.92551408e-02f, 1.45098403e-01f, 1.21132270e-01f, 2.19444156e-01f, 1.60801664e-01f, 4.97590899e-02f,
  -6.21714629e-02f, -2.17215404e-01f, 1.74981896e-02f, -7.70223737e-02f, 2.03340292e-01f, 1.17684817e-02f, -6.42187893e-02f, -2.39309177e-01f, -4.39691603e-01f, 3.34984124e-01f,
  -4.20867801e-01f, 8.17435384e-02f, -2.49138966e-01f, 1.57289058e-01f, -3.84226590e-01f, -1.05528217e-02f, -4.33182806e-01f, 1.60934716e-01f, -1.76421836e-01f, -4.85072494e-01f,
  -4.55734730e-02f, 1.23102210e-01f, 9.18431506e-02f, 3.42407322e-04f, 2.59374619e-01f, 1.18985204e-02f, 3.41885611e-02f, 1.13098294e-01f, 8.21574479e-02f, -4.33239015e-03f,
  1.01619177e-01f, 7.49724731e-02f, 8.70291665e-02f, -1.67440940e-02f, 7.08105117e-02f, -8.91715288e-02f, 5.69662377e-02f, 3.43880616e-02f, 4.15631011e-02f, 8.44235569e-02f,
  2.13767812e-01f, 2.18304023e-02f, 1.15390442e-01f, 1.58398136e-01f, 1.96399510e-01f, 9.47344080e-02f, 4.52547185e-02f, -1.80531248e-01f, 5.84121160e-02f, 1.07590973e-01f,
  5.56156635e-02f, 3.80929977e-01f, -1.76490590e-01f, -1.48271158e-01f, -1.49680600e-01f, -1.33516833e-01f, 1.28597217e-02f, 1.85231850e-01f, 1.24809623e-01f, 1.78723469e-01f,
  1.39862597e-01f, 8.95591304e-02f, -2.24166632e-01f, -2.55807251e-01f, 3.91216218e-01f, -4.46953662e-02f, 2.23730817e-01f, -9.63285044e-02f, -3.42659414e-01f, 1.09166298e-02f,
  -3.03867489e-01f, -6.69888496e-01f, 5.19408695e-02f, 2.58753002e-02f, -1.74917087e-01f, 3.93866226e-02f, 2.21911773e-01f, -8.90820026e-01f, 3.30675021e-02f, 1.86832681e-01f,
  -2.08348602e-01f, 1.33369090e-02f, -2.75858462e-01f, -3.64885211e-01f, -4.33885038e-01f, -3.60557102e-02f, 2.85528362e-01f, -3.33708763e-01f, -1.79504797e-01f, -2.01697737e-01f,
  2.01917700e-02f, 3.12120765e-01f, -3.52806419e-01f, 1.08910404e-01f, 2.70839095e-01f, -7.65498728e-02f, -4.09854986e-02f, 3.80401939e-01f, -3.62045854e-01f, -5.48912108e-01f,
  2.92895824e-01f, -1.16495483e-01f, -1.84453666e-01f, 6.37971818e-01f, -2.33665094e-01f, 3.83681953e-01f, -4.93888296e-02f, -3.18233937e-01f, 4.82198089e-01f, 2.27229178e-01f,
  4.49537277e-01f, -3.21164548e-01f, -1.36113152e-01f, -2.47725278e-01f, 7.61336565e-01f, -5.39306700e-01f, 4.48077738e-01f, -2.47440010e-01f, -5.44041872e-01f, -4.00831699e-01f,
  -3.44466060e-01f, 1.19874462e-01f, 1.69714004e-01f, -4.07349132e-03f, -2.48454362e-01f, -6.04617476e-01f, -2.56334066e-01f, 1.00835375e-01f, 3.93494755e-01f, 1.84075028e-01f,
  -2.90050525e-02f, -2.84003675e-01f, -3.08680385e-01f, 3.71296018e-01f, -6.06935501e-01f, -4.79346871e-01f, -6.49762988e-01f, 1.39243305e-02f, -5.72157979e-01f, -6.24464825e-02f,
  -3.72098416e-01f, 1.56248733e-01f, 4.24798131e-01f, 4.93746787e-01f, -6.46400392e-01f, 1.32071257e-01f, 6.05039775e-01f, 1.72835201e-01f, 9.87814888e-02f, 7.33749121e-02f,
  6.31624693e-03f, 1.54050916e-01f, -9.15067643e-02f, -1.06235454e-02f, -1.85230374e-01f, -8.46790746e-02f, -3.95987779e-01f, 1.74168367e-02f, -6.63482472e-02f, 8.01585317e-02f,
  6.84348121e-03f, 3.24173272e-02f, 5.09170480e-02f, 6.12602532e-02f, 2.30375137e-02f, 1.26298204e-01f, 2.18900397e-01f, 5.62505564e-03f, 3.18446420e-02f, 1.03820197e-01f,
  2.18343213e-02f, -5.26892431e-02f, 8.65199268e-02f, 2.10033953e-02f, -6.94480538e-02f, -6.81152218e-04f, 1.90847740e-01f, 3.29602472e-02f, -9.71739814e-02f, -3.32727104e-01f,
  8.55404586e-02f, 7.56917894e-02f, 1.18495323e-01f, -3.36390555e-01f, -1.56782895e-01f, 9.80869681e-02f, 1.87755436e-01f, -9.70390365e-02f, 1.32037904e-02f, -2.68447194e-02f,
  1.38384417e-01f, 1.68812558e-01f, 2.39469763e-02f, 8.84882212e-02f, 7.44476318e-02f, 2.35613689e-01f, -1.84096634e-01f, 4.49157022e-02f, -3.53095740e-01f, -6.54864073e-01f,
  -4.80113536e-01f, -2.49006659e-01f, -6.73885271e-02f, -2.48742193e-01f, -2.66459525e-01f, -6.46058500e-01f, -2.13989854e-01f, 3.22774291e-01f, -2.08082482e-01f, -2.07756862e-01f,
  -8.88904929e-02f, -4.68049705e-01f, -2.66201288e-01f, -1.56421795e-01f, -1.40779406e-01f, 3.13684911e-01f, -8.04838613e-02f, -4.79016900e-01f, 2.26495638e-01f, -3.03823590e-01f,
  -1.01423830e-01f, -2.38395259e-01f, -2.86844492e-01f, -7.64929950e-02f, -4.90069687e-01f, 4.16454345e-01f, -2.94257700e-01f, 5.49585044e-01f, -3.42767537e-01f, 1.58525378e-01f,
  3.11730430e-02f, -1.14449002e-01f, -5.42525016e-02f, -2.17314661e-01f, 6.70858383e-01f, -5.92427313e-01f, -1.21841803e-01f, -1.30959228e-01f, 2.84915790e-02f, -2.43382365e-01f,
  -6.72117472e-01f, 2.66157269e-01f, -1.26206046e-02f, -2.92800158e-01f, -5.60404584e-02f, 1.18897408e-01f, -4.40707088e-01f, -2.77461767e-01f, 8.56952518e-02f, 5.29549062e-01f,
  2.84592714e-02f, 1.09392822e-01f, -1.44109488e-01f, -1.99658215e-01f, -2.02168599e-02f, 2.79854447e-01f, -9.50997248e-02f, -2.68738300e-01f, -5.24526954e-01f, -4.94797140e-01f,
  -2.77840555e-01f, -1.09014891e-01f, 2.23578572e-01f, 2.31556073e-01f, -3.40543449e-01f, -2.24635631e-01f, 6.03798091e-01f, 8.74282271e-02f, -1.42996401e-01f, -3.08080077e-01f,
  -2.90692955e-01f, 4.15230215e-01f, 2.22868174e-01f, -2.83754140e-01f, -6.34988427e-01f, -1.40414730e-01f, 1.40185151e-02f, -6.85539320e-02f, -1.40298307e-01f, -1.71491668e-01f,
  -2.66725160e-02f, 6.17014877e-02f, -8.57577547e-02f, -9.40014869e-02f, -1.96554527e-01f, 4.85651530e-02f, 7.92670548e-02f, -1.84419364e-01f, 3.41125168e-02f, -7.92274252e-02f,
  -3.32876071e-02f, -1.39596835e-01f, -9.22936480e-03f, 2.19320618e-02f, -9.66008529e-02f, -1.87753156e-01f, -5.24165761e-03f, -6.52753189e-02f, -5.85737731e-03f, -3.39294165e-01f,
  -1.10825047e-01f, 1.04439378e-01f, -1.72801912e-01f, 6.80440888e-02f, 8.30702037e-02f, 2.41194621e-01f, -3.63050727e-03f, 8.57372507e-02f, 8.18055272e-02f, 2.82241795e-02f,
  3.40853259e-02f, 2.64921993e-01f, 1.65307179e-01f, -9.51169208e-02f, 1.21673405e-01f, 2.38077313e-01f, 1.35121644e-01f, 1.17092237e-01f, 2.13590786e-01f, -7.20323995e-02f,
  -2.44980920e-02f, -1.11907147e-01f, 3.25831681e-01f, 1.71167672e-01f, -1.25688743e-02f, 1.72951922e-01f, -2.55800962e-01f, 2.34420598e-01f, -1.80009931e-01f, -4.08601016e-01f,
  1.65891245e-01f, 2.86304414e-01f, -2.50685155e-01f, -2.11315334e-01f, 1.82303339e-01f, -3.14885437e-01f, 3.92441094e-01f, -4.87395465e-01f, -4.86767776e-02f, -1.14042506e-01f,
  1.41225100e-01f, 3.91050465e-02f, -1.58656508e-01f, -3.85657847e-01f, 2.79444486e-01f, -2.12069765e-01f, -1.48698986e-01f, -9.02042314e-02f, 4.08673972e-01f, -1.75446689e-01f,
  -3.43863875e-01f, 2.29269996e-01f, -2.00848937e-01f, -3.46890867e-01f, -1.95320264e-01f, -3.66213396e-02f, -5.87447658e-02f, 2.23308787e-01f, -5.48672639e-02f, 4.23214644e-01f,
  9.92286727e-02f, -2.07693681e-01f, -5.15009701e-01f, 2.43987232e-01f, 2.38784686e-01f, -3.52619082e-01f, -1.68771759e-01f, 8.50584805e-02f, 3.39310765e-01f, -3.14690024e-01f,
  1.38513178e-01f, -2.74811208e-01f, -1.55191660e-01f, -1.64083391e-01f, 4.95404840e-01f, -8.24413896e-02f, -6.10938966e-02f, -4.38063145e-01f, -4.54174191e-01f, 6.12537526e-02f,
  -1.43909425e-01f, -1.68141708e-01f, -6.04355514e-01f, -2.59820163e-01f, -1.00045085e-01f, 2.85674036e-01f, 1.03254274e-01f, 1.08709209e-01f, -2.10658610e-01f, -5.00980318e-02f,
  -3.34839940e-01f, 1.81288704e-01f, -7.06963390e-02f, -1.56302899e-01f, -2.17957884e-01f, -6.82565570e-02f, -2.06393570e-01f, -9.37666837e-03f, -5.21421790e-01f, 8.45249593e-02f,
  -5.08678555e-01f, -2.62882024e-01f, 4.49706644e-01f, -8.38155448e-02f, -3.73751670e-02f, -1.47182062e-01f, -6.35426566e-02f, 2.59657707e-02f, -7.42156580e-02f, 2.08004713e-01f,
  8.63482058e-02f, 1.35196939e-01f, 1.10250041e-01f, 1.00298651e-01f, -4.04449515e-02f, -3.75756877e-03f, 1.03468239e-01f, -4.01061885e-02f, 1.46097941e-02f, 1.31020751e-02f,
  1.72269657e-01f, 3.36131305e-02f, 8.19858685e-02f, 7.06332028e-02f, -3.03587317e-03f, 1.86907768e-01f, -8.94232169e-02f, 5.80384284e-02f, 4.78309244e-02f, -3.72621655e-01f,
  -1.36400893e-01f, -2.86194980e-01f, 3.23840201e-01f, -3.86688188e-02f, 3.83395366e-02f, 5.84231168e-02f, 1.31600112e-01f, -1.19974889e-01f, 2.59745084e-02f, 2.18736947e-01f,
  2.96046704e-01f, -2.56156802e-01f, 1.49501756e-01f, 3.12475920e-01f, -1.75299391e-01f, -2.07654431e-01f, 1.93927690e-01f, 2.08236262e-01f, 9.96098146e-02f, 1.44579142e-01f,
  -7.66112506e-02f, -1.61899045e-01f, 2.02030744e-02f, 5.44058681e-02f, -3.75131130e-01f, 5.04888557e-02f, -1.30731702e-01f, -4.48822290e-01f, 3.85051668e-02f, 4.35027033e-02f,
  -1.92395404e-01f, -1.64413422e-01f, -4.80840117e-01f, 2.57526577e-01f, -7.66971335e-02f, 3.72101039e-01f, -2.32116133e-02f, 1.81974202e-01f, -3.88871431e-02f, -2.46017754e-01f,
  2.44038567e-01f, -1.77473858e-01f, -3.48529816e-01f, 6.65488183e-01f, 1.91594958e-01f, -1.15616821e-01f, 2.78455406e-01f, -3.09505383e-03f, 3.62037867e-01f, -1.33598909e-01f,
  1.75869450e-01f, -4.15956706e-01f, -1.78706974e-01f, -3.12422037e-01f, -2.52807021e-01f, -2.40884691e-01f, 2.43416190e-01f, 7.89281845e-01f, 3.06193739e-01f, -4.81460959e-01f,
  6.27235696e-02f, -2.27165729e-01f, -1.22149803e-01f, -4.76839155e-01f, -3.08384765e-02f, 4.02717203e-01f, -3.63401249e-02f, 4.18805005e-03f, -3.68302077e-01f, -3.26725215e-01f,
  -4.31574672e-01f, -6.42758310e-02f, -8.14292803e-02f, 1.05815455e-01f, -4.98550922e-01f, -4.35031876e-02f, -2.87424386e-01f, -3.26542020e-01f, -2.30581403e-01f, 4.97545570e-01f,
  -4.18645203e-01f, -1.92855969e-01f, -3.11704993e-01f, -1.48199210e-02f, 2.98970073e-01f, -4.23606157e-01f, -5.03513515e-02f, -2.88864374e-01f, -3.42378765e-01f, 3.33686471e-02f,
  -4.93379235e-01f, -4.23589319e-01f, -1.96568280e-01f, 1.26074314e-01f, -3.67511630e-01f, -1.05735876e-01f, 3.79282057e-01f, -3.19897681e-01f, -7.89976045e-02f, -1.90938339e-01f,
  -3.08091193e-01f, 1.93702921e-01f, -9.22072977e-02f, 1.16403438e-01f, 5.83539158e-03f, -1.36648506e-01f, -1.18904062e-01f, -1.24963239e-01f, 1.39638215e-01f, -1.31299302e-01f,
  1.15579233e-01f, -1.79070503e-01f, 8.29046145e-02f, 1.16248755e-02f, 1.08303931e-02f, -1.07766269e-02f, -1.38848811e-01f, -6.82272613e-02f, 2.96194963e-02f, -2.68310844e-03f,
  -1.33221179e-01f, 1.66488722e-01f, -1.76070910e-02f, 1.51916118e-02f, 4.23392747e-03f, -9.33927223e-02f, 7.62569010e-02f, -5.51692694e-02f, 5.80675304e-02f, 2.82924354e-01f,
  -2.67229915e-01f, 1.67663112e-01f, -1.30254850e-01f, -5.29081151e-02f, 3.15937132e-01f, 7.54355490e-02f, 7.09938109e-02f, -7.17527792e-02f, -1.27760321e-01f, 3.19893807e-01f,
  2.47189905e-02f, 7.82446414e-02f, 5.02190478e-02f, 1.16517507e-02f, 3.26159410e-02f, -1.67225078e-01f, -1.53222278e-01f, -1.87016800e-01f, 4.94309142e-03f, 6.86972067e-02f,
  -2.95552433e-01f, -5.01371585e-02f, 2.44254157e-01f, 5.68087161e-01f, 4.11262155e-01f, -4.29160774e-01f, 5.13569750e-02f, 7.78403180e-03f, 4.90757190e-02f, 3.68666410e-01f,
  3.18018854e-01f, -2.53984421e-01f, 8.68914425e-02f, -1.24428891e-01f, -6.35745764e-01f, 6.02876022e-02f, -2.36595184e-01f, -1.52552828e-01f, 2.13986654e-02f, 6.57462329e-02f,
  -7.12024570e-01f, -2.17994705e-01f, -2.99515367e-01f, -1.29714251e-01f, -4.75711912e-01f, -8.80362391e-02f, -2.23130003e-01f, -1.64129928e-01f, -8.92716274e-02f, 3.00888449e-01f,
  -1.94612876e-01f, -1.43096417e-01f, 3.09898425e-02f, -1.51688382e-01f, 3.74447018e-01f, -2.64721334e-01f, -1.18709520e-01f, -3.74851733e-01f, -2.71705061e-01f, -1.77604273e-01f,
  -2.40240350e-01f, -4.54838686e-02f, 8.91851634e-02f, -5.02070248e-01f, 5.29342651e-01f, 2.94464687e-03f, 4.22783107e-01f, -2.29250491e-01f, -4.34408337e-01f, 1.95849359e-01f,
  4.02627021e-01f, 1.40228197e-01f, 1.94412872e-01f, 2.71587491e-01f, 1.86532363e-01f, -1.06271997e-01f, -3.23649943e-01f, -4.07778332e-03f, 3.44003022e-01f, 2.42617622e-01f,
  -4.20396715e-01f, 3.63240898e-01f, -4.50491905e-01f, -4.14249271e-01f, -1.89550012e-01f, 5.75420499e-01f, -2.50677466e-01f, 5.54121673e-01f, -3.85675609e-01f, -1.86389074e-01f,
  -7.71924496e-01f, -5.28134108e-01f, -3.54639411e-01f, -3.53380263e-01f, -3.02108526e-01f, -3.46286923e-01f, 1.78728327e-01f, -3.49061042e-01f, -5.50578386e-02f, -3.42459023e-01f,
  4.15110365e-02f, 7.91723132e-02f, 3.13262083e-02f, -2.13425700e-03f, -6.02419153e-02f, -1.76232427e-01f, 1.33542508e-01f, 8.99595916e-02f, -3.02026588e-02f, 9.51337069e-03f,
  1.13961495e-01f, 4.27732319e-02f, 6.74501574e-03f, 4.67670113e-02f, 3.08339503e-02f, 1.00859717e-01f, -7.95494691e-02f, 2.70774625e-02f, 1.89336238e-03f, -1.09132223e-01f,
  1.78326666e-01f, 1.15915827e-01f, -7.14201406e-02f, 2.36670356e-02f, -2.89937593e-02f, 1.92155495e-01f, -1.28197700e-01f, 1.98063925e-01f, 9.65376347e-02f, -1.63479075e-01f,
  1.81336403e-01f, -5.17879874e-02f, 2.14798860e-02f, -7.09698647e-02f, 7.87744150e-02f, -1.56105766e-02f, -1.28824748e-02f, -1.87685981e-01f, -6.98866695e-02f, 1.53086215e-01f,
  2.43509606e-01f, 2.68036276e-01f, 1.11870475e-01f, -7.09903706e-03f, -2.34538153e-01f, 1.07819431e-01f, 1.48790762e-01f, -1.72912851e-01f, 5.44597842e-02f, -3.26173194e-02f,
  -1.89115867e-01f, -3.16376090e-01f, -3.72516602e-01f, 3.59027654e-01f, -2.53852576e-01f, 1.23266466e-01f, -2.11524636e-01f, 2.11364836e-01f, 2.48958156e-01f, -1.39559358e-01f,
  -2.82117069e-01f, -3.24372351e-01f, 3.50401133e-01f, 7.14999288e-02f, -1.90296352e-01f, -2.91913655e-02f, 1.19960047e-01f, 2.90715136e-02f, -9.01641473e-02f, -2.53124863e-01f,
  -3.35303038e-01f, -4.37335163e-01f, 5.01871943e-01f, -4.16182965e-01f, -2.07692515e-02f, -1.46780685e-01f, -3.49934846e-01f, -1.49660334e-01f, 1.90430835e-01f, -2.85290837e-01f,
  -2.33252779e-01f, -6.13759570e-02f, 2.96005875e-01f, -1.46334022e-01f, 4.70474958e-01f, -1.74219370e-01f, -1.99783474e-01f, -2.84271032e-01f, 4.07156721e-02f, -3.39383245e-01f,
  -1.56245366e-01f, 3.23005408e-01f, -3.91938865e-01f, -8.06757659e-02f, -5.66049516e-01f, 1.71506763e-01f, 1.55157030e-01f, -2.56803185e-01f, -2.07061440e-01f, -2.56132603e-01f,
  -1.90145910e-01f, 1.14874117e-01f, -3.35135698e-01f, -8.29933807e-02f, -3.05416249e-02f, 2.08774582e-01f, -3.13606471e-01f, -2.54602641e-01f, 2.32499033e-01f, -2.91955709e-01f,
  -4.66873556e-01f, -2.16202796e-01f, -4.10607070e-01f, 5.27417421e-01f, -1.08871251e-01f, -1.58119425e-02f, -1.85441151e-01f, 3.82074229e-02f, -1.50950566e-01f, -1.23291492e-01f,
  5.61330557e-01f, -9.31948572e-02f, 2.10250854e-01f, -1.12184323e-01f, -1.72684953e-01f, -6.05918288e-01f, -2.19809905e-01f, 3.91490310e-01f, 1.55123487e-01f, 6.56455979e-02f,
  -4.10701931e-02f, 4.09491546e-02f, 1.84499659e-02f, 2.89655961e-02f, -6.70345454e-03f, -1.33748144e-01f, 1.65040597e-01f, -6.42569140e-02f, 8.37397873e-02f, -6.47123307e-02f,
  1.80396829e-02f, 1.40870601e-01f, 2.20496058e-02f, 1.38618186e-01f, 4.84153442e-03f, 1.07149914e-01f, -5.59314415e-02f, -6.07197359e-02f, 2.27329042e-02f, -5.96920028e-02f,
  2.24240366e-02f, 6.41775429e-02f, 5.87923042e-02f, -4.54135947e-02f, -1.41741052e-01f, -9.89946127e-02f, -1.99192867e-01f, -6.31258413e-02f, 4.38688584e-02f, -1.09857768e-01f,
  3.48070681e-01f, 1.12855449e-01f, -2.27015078e-01f, -1.32547930e-01f, 3.43470842e-01f, 2.76881725e-01f, 5.18252477e-02f, -1.37456000e-01f, -1.48292139e-01f, -2.60305107e-01f,
  -6.56960756e-02f, 1.57894224e-01f, 2.32139081e-01f, 9.22017470e-02f, -2.13442177e-01f, -6.30527511e-02f, 4.69703041e-02f, 9.43009034e-02f, 6.39442861e-01f, 1.03274070e-01f,
  -2.66372323e-01f, -3.72191638e-01f, -3.95905286e-01f, -2.99205810e-01f, -2.64118701e-01f, -1.26432642e-01f, -2.91883767e-01f, -6.81142230e-03f, 1.24576807e-01f, -3.01943094e-01f,
  -1.83311507e-01f, 2.34328896e-01f, 3.49073082e-01f, 3.08308899e-02f, 2.24807393e-02f, 4.65163499e-01f, 4.97426599e-01f, 1.91830188e-01f, -3.08220237e-01f, -1.44178942e-01f,
  -2.51823217e-01f, -2.56651103e-01f, 1.97402790e-01f, -1.86012611e-01f, -5.93817569e-02f, -3.54971200e-01f, -1.94143094e-02f, 2.98031658e-01f, -1.65104493e-01f, -4.19024467e-01f,
  -1.80143148e-01f, -2.07345665e-01f, -1.00124024e-01f, -1.77004859e-01f, -3.58797163e-01f, -7.23494682e-03f, -9.74460766e-02f, -1.33523449e-01f, 2.24556088e-01f, -2.15111598e-01f,
  -3.13784659e-01f, 1.31977111e-01f, -2.53958604e-03f, -2.04153135e-01f, -2.02876404e-01f, 7.49288797e-02f, 2.02941317e-02f, 5.07233059e-03f, 2.01016590e-01f, -3.98948312e-01f,
  -2.36096397e-01f, -2.46702507e-01f, -2.09303111e-01f, -1.96580365e-01f, -4.68780845e-01f, -5.98026775e-02f, -7.46715069e-02f, -5.19337118e-01f, 9.82979536e-02f, 5.32078564e-01f,
  3.61911580e-02f, -1.99661016e-01f, 7.94589520e-01f, -5.85931361e-01f, -2.25920960e-01f, 5.85963130e-02f, 1.25343194e-02f, 2.67048448e-01f, -1.14640705e-01f, -2.21621484e-01f,
  -8.04887991e-03f, -1.37209907e-01f, 3.75791565e-02f, -2.21093684e-01f, -2.89447010e-01f, -1.89864472e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.56198099e-01f, 6.94853812e-02f, -1.89359020e-02f, -4.66987863e-02f, 2.89495394e-04f, -7.27190229e-04f, -2.20899545e-02f, 3.73335518e-02f, -5.97298481e-02f, 4.31445763e-02f,
  -1.36845801e-02f, -7.90905580e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 78
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    