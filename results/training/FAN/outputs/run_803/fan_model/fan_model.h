/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  7.82300770e-01f, 3.91083539e-01f, -3.36371332e-01f, 1.47134274e-01f, -1.70390099e-01f, -1.68592781e-01f, 1.80124193e-02f, -1.79836880e-02f, -4.08356078e-02f, -1.14960168e-02f,
  1.73210651e-01f, 1.27267819e-02f, 4.63050418e-02f, 2.82958765e-02f, 2.94604693e-02f, -1.55825585e-01f, -2.13929415e-01f, 1.06798775e-01f, -2.74492681e-01f, 3.46293449e-02f,
  -2.35140827e-02f, 2.31675044e-01f, 1.97495207e-01f, 5.24772750e-03f, 8.21029097e-02f, -3.19157869e-01f, -1.93673521e-01f, 2.23988052e-02f, -2.70714872e-02f, 2.12309778e-01f,
  1.75870225e-01f, 8.54814649e-02f, -1.12357579e-01f, -2.53519788e-02f, -2.97824964e-02f, 1.95567459e-02f, -2.15893164e-02f, 7.92837760e-04f, 4.94289249e-02f, 3.35927606e-02f,
  2.07268689e-02f, -5.89466840e-02f, 1.17890805e-01f, -9.43421721e-02f, -1.90201420e-02f, 1.60858799e-02f, 8.30333773e-03f, 9.19803008e-02f, -6.91491598e-03f, -2.72847922e-03f,
  1.01380542e-01f, 1.09099738e-01f, 5.50467595e-02f, -9.78274718e-02f, 8.46476778e-02f, 1.20247742e-02f, 2.22075172e-02f, 1.66378114e-02f, -8.90306756e-03f, 6.54995861e-03f,
  -2.64754202e-02f, 3.48181501e-02f, 5.35518816e-03f, 9.73357726e-03f, 2.64366698e-02f, -1.41947353e-02f, 2.65113451e-02f, -6.46349927e-03f, 1.61289629e-02f, -1.55685479e-02f,
  -2.67289393e-02f, -2.12417953e-02f, 5.32536069e-03f, -3.56215052e-03f, 4.07746658e-02f, 4.61091660e-03f, -2.38907039e-02f, 2.12829374e-02f, 1.68235670e-03f, 3.43956389e-02f,
  1.29984263e-02f, 2.34619416e-02f, -1.59336403e-02f, 1.32141691e-02f, 8.84545967e-03f, 1.99407712e-02f, 6.36660960e-03f, -4.92054522e-02f, -1.22381262e-02f, 7.56567903e-03f,
  -1.86365053e-01f, -6.62135035e-02f, 1.71637647e-02f, 4.33449969e-02f, 1.08605204e-02f, -3.58755630e-03f, 2.45116856e-02f, 6.31411597e-02f, -2.00499594e-02f, 6.51593804e-02f,
  1.28403045e-02f, 1.55091966e-02f, 1.16183665e-02f, 3.07068247e-02f, -2.56087948e-02f, 1.55785521e-02f, 3.13971341e-02f, -1.65008083e-02f, -5.38537838e-02f, -4.75750631e-03f,
  4.69680764e-02f, -4.47801463e-02f, -1.13519937e-01f, 2.43387520e-02f, 1.07443416e-02f, -1.73215196e-02f, -1.33896843e-01f, -5.64066172e-02f, -1.36932358e-01f, -1.52496949e-01f,
  4.92095768e-01f, 2.86305416e-02f, -2.19023213e-01f, 1.46440789e-01f, -1.96513072e-01f, 8.70017558e-02f, -3.25394601e-01f, -5.87898912e-03f, 9.22803655e-02f, -1.97603852e-01f,
  2.36478969e-01f, 3.09610844e-01f, 1.76394299e-01f, 1.99452773e-01f, 1.11111283e-01f, -2.90577948e-01f, -2.37922996e-01f, -8.39548260e-02f, 1.31048068e-01f, 2.35867769e-01f,
  1.21154681e-01f, -1.07399285e-01f, 1.79185137e-01f, 2.06455007e-01f, -3.41536015e-01f, -1.13408559e-03f, -2.53791183e-01f, -1.13841213e-01f, 4.84901331e-02f, -6.37238145e-01f,
  5.36314584e-03f, 5.73166646e-02f, 3.16858813e-02f, 6.71013668e-02f, -2.52044331e-02f, -3.01928036e-02f, -4.96051982e-02f, -9.61743519e-02f, 1.03074387e-01f, 2.19564978e-03f,
  5.95999882e-02f, 3.74120884e-02f, 2.72545908e-02f, -7.45543763e-02f, -5.17171621e-02f, -5.50972205e-03f, -5.30303596e-03f, -3.74116153e-02f, -1.12579148e-02f, 5.40676489e-02f,
  2.45189890e-02f, -5.85450558e-04f, -6.67924359e-02f, -2.50589717e-02f, 6.23932891e-02f, 3.41634313e-03f, -4.94727381e-02f, -7.95223862e-02f, -1.97902527e-02f, -3.15521806e-01f,
  -7.56771630e-03f, -1.71402853e-03f, 8.64288304e-03f, -5.53171756e-03f, 2.63799764e-02f, -2.39313189e-02f, 1.59685984e-02f, 2.42028013e-02f, 5.40786516e-03f, -6.60221726e-02f,
  5.53982146e-02f, -2.21064575e-02f, -1.16752053e-03f, 1.02851316e-02f, -5.35746850e-03f, -7.44668359e-04f, -1.42764021e-02f, -4.12574783e-02f, 4.78795394e-02f, -2.63172556e-02f,
  5.48539832e-02f, 2.91722286e-02f, -9.32442248e-02f, 3.02572083e-02f, -2.25830022e-02f, 5.70204780e-02f, -3.08822840e-02f, 6.89487206e-03f, 2.50640977e-02f, 5.69175258e-02f,
  4.85478304e-02f, 1.42589167e-01f, -4.65865880e-02f, 1.77819580e-02f, 1.71489734e-02f, 1.22713586e-02f, 3.76054533e-02f, -3.20790671e-02f, 3.35024893e-02f, -1.53293752e-03f,
  5.88651299e-02f, 2.96008382e-02f, 3.63656990e-02f, 8.78319703e-03f, 1.40589280e-02f, 2.27626413e-02f, -8.76557361e-03f, 1.06082693e-01f, 7.49220699e-02f, -6.00563549e-02f,
  1.22123603e-02f, -8.00404407e-04f, 8.20772126e-02f, 4.43571098e-02f, 2.29768008e-02f, 5.91770075e-02f, -3.42064537e-02f, 3.72388936e-03f, 1.03282869e-01f, -3.23379077e-02f,
  -4.87874418e-01f, 4.33738768e-01f, -8.82927477e-02f, -1.25293866e-01f, 2.20404848e-01f, -8.95169154e-02f, 2.06465334e-01f, -1.70432419e-01f, -1.98780864e-01f, 1.73999012e-01f,
  2.68843085e-01f, 1.29423901e-01f, 1.21945076e-01f, 7.19839334e-02f, -2.02675343e-01f, -2.17789486e-02f, -6.42688870e-02f, -2.06585348e-01f, -2.20529452e-01f, -1.24285899e-01f,
  1.01338960e-01f, -1.82959288e-01f, -2.23282814e-01f, -5.30088805e-02f, 1.54485449e-01f, -1.31483883e-01f, 1.03116289e-01f, 2.64723003e-02f, 1.23850778e-01f, 2.90741891e-01f,
  1.40897840e-01f, 2.81444073e-01f, -7.60798827e-02f, 4.23466787e-03f, 1.25405028e-01f, -9.92575660e-02f, -3.11240368e-02f, -4.56683636e-02f, -4.88269702e-03f, -3.09949759e-02f,
  7.93469772e-02f, 5.00542670e-02f, -3.49028371e-02f, 6.74561784e-02f, 5.71450591e-03f, -3.06193009e-02f, -6.70899898e-02f, -8.60769600e-02f, -2.08379719e-02f, 7.87269622e-02f,
  1.40169472e-01f, 7.69740343e-02f, 1.58295520e-02f, -1.13611175e-02f, -9.21874568e-02f, -7.49835521e-02f, 1.36188015e-01f, -8.55688844e-03f, 6.92544430e-02f, 7.68899694e-02f,
  1.17225824e-02f, 3.88563983e-02f, 9.99807846e-03f, 7.91285280e-03f, -4.73674685e-02f, -3.97201478e-02f, 2.65591801e-03f, 1.26159629e-02f, -9.25609935e-03f, -2.34617740e-02f,
  1.52908675e-02f, 4.97653522e-02f, -4.59252857e-02f, 8.55353475e-03f, -9.31301445e-04f, 3.09909675e-02f, -4.25047763e-02f, 8.64504278e-03f, 4.60046306e-02f, -4.88071553e-02f,
  3.80001403e-02f, 3.10912845e-03f, 1.57628879e-02f, 3.37776802e-02f, -3.24175507e-02f, -1.77584980e-02f, -5.01134545e-02f, 4.46631387e-02f, -2.54045390e-02f, 4.59438078e-02f,
  1.66456494e-02f, -4.32480611e-02f, -8.20015296e-02f, 2.15513594e-02f, -1.24017475e-02f, 5.81718571e-02f, 6.01734333e-02f, -5.30490279e-02f, 1.44187152e-01f, -2.01898348e-02f,
  7.49500981e-03f, 2.15443000e-02f, 1.18485838e-02f, -1.85145568e-02f, -1.49234682e-02f, 2.72492040e-02f, 5.05049862e-02f, 4.59835865e-02f, 6.53693303e-02f, -5.34444526e-02f,
  3.35886888e-02f, -1.39975354e-01f, -1.44940615e-01f, -1.45028830e-02f, 1.38901155e-02f, -8.61187503e-02f, -4.18501813e-03f, 3.73977348e-02f, -1.53296098e-01f, -1.38463408e-01f,
  -5.01796424e-01f, 2.98660453e-02f, 2.20748454e-01f, -1.45360574e-01f, -3.24511668e-03f, -3.62727791e-01f, -1.90156147e-01f, -2.77492732e-01f, -2.78409839e-01f, 4.10717428e-02f,
  1.37347758e-01f, 1.21008471e-01f, 1.16165698e-01f, 1.88131645e-01f, -9.57269445e-02f, -4.05737720e-02f, 4.78249155e-02f, 1.79842398e-01f, -2.87734903e-03f, -1.25531003e-01f,
  4.88502681e-02f, 1.43579021e-01f, -3.57300299e-03f, -6.50199130e-02f, -3.34913768e-02f, -3.72353084e-02f, 2.14741588e-01f, 2.71340031e-02f, 8.84455740e-02f, 4.08866107e-01f,
  2.40633905e-01f, -1.38222739e-01f, 1.84154585e-02f, 8.37357640e-02f, 7.97927305e-02f, -4.58806120e-02f, -4.96950448e-02f, 6.79652840e-02f, 5.83198145e-02f, -6.53120354e-02f,
  1.30360231e-01f, 4.51205596e-02f, 1.95831456e-03f, 4.12011296e-02f, 4.73052301e-02f, -5.61913699e-02f, -1.50207682e-02f, 8.94239023e-02f, -1.54392635e-02f, -2.52010226e-02f,
  1.55188814e-01f, 1.45923579e-02f, -1.21914987e-02f, -1.06560268e-01f, -1.11669309e-01f, 1.48456926e-02f, 4.25358862e-02f, -1.23701580e-01f, 5.72522506e-02f, -1.87974982e-02f,
  -8.42920970e-03f, -3.28145847e-02f, 2.09535081e-02f, 4.01260108e-02f, 5.01689464e-02f, -2.88253762e-02f, 5.21151833e-02f, 3.04269660e-02f, -4.44585048e-02f, -1.93011872e-02f,
  -5.28894644e-03f, 4.40782793e-02f, -2.06625126e-02f, -2.87341010e-02f, 6.89868554e-02f, -8.46679439e-04f, -1.78144816e-02f, 2.32170783e-02f, -3.24104875e-02f, -1.11532360e-02f,
  -8.14229250e-03f, -2.43369825e-02f, 4.61736582e-02f, 2.52215397e-02f, -1.34521611e-02f, 2.41952892e-02f, -3.17087211e-02f, 1.22294910e-02f, -1.73854139e-02f, -8.77248496e-02f,
  -1.58908516e-02f, 5.90550341e-02f, -3.11476216e-02f, -7.67701259e-03f, 2.65199393e-02f, 3.12398449e-02f, 8.43113288e-02f, 1.06631005e-02f, -1.35411303e-02f, -4.07974124e-02f,
  -6.70309067e-02f, -1.34859113e-02f, 9.83784422e-02f, 2.80048214e-02f, -8.75023156e-02f, -9.96837020e-02f, 1.95155069e-02f, 1.58023366e-04f, 1.02632884e-02f, 1.61065198e-02f,
  -5.53796515e-02f, -1.23160876e-01f, -1.48142174e-01f, -6.11676136e-03f, -8.81186686e-03f, -7.84391165e-02f, 3.66086960e-02f, -1.13181770e-03f, -1.03017129e-01f, -1.48790807e-01f,
  -2.32124060e-01f, 1.99970245e-01f, -3.50068122e-01f, -1.95822433e-01f, 1.01982791e-03f, 1.17505796e-01f, 1.94941267e-01f, -3.35707329e-02f, -8.52274522e-02f, 1.66760981e-01f,
  2.09339961e-01f, 8.42698067e-02f, 4.03957143e-02f, -1.18911423e-01f, -2.19784260e-01f, -5.13138250e-02f, -3.19220573e-01f, -4.09881532e-01f, -2.80627310e-01f, 2.56687440e-02f,
  1.44745559e-01f, -1.35590240e-01f, -2.92723626e-01f, -9.79840308e-02f, 6.18950762e-02f, 7.01357350e-02f, 6.47881329e-02f, -7.93716609e-02f, 1.43323410e-02f, -1.85013905e-01f,
  -4.52179322e-03f, -1.33100346e-01f, -7.29076415e-02f, -4.61620167e-02f, 1.93648227e-02f, -2.97314804e-02f, 2.95117870e-02f, -7.76294544e-02f, 1.22146502e-01f, 8.06595236e-02f,
  3.15528773e-02f, 7.38366926e-03f, -9.58327278e-02f, -5.57429641e-02f, -9.04479623e-02f, -2.30411794e-02f, -4.60329540e-02f, -1.08703189e-01f, -8.62539336e-02f, 6.00688085e-02f,
  9.69736725e-02f, 7.26217031e-02f, -1.05590798e-01f, 2.02036612e-02f, -1.41382411e-01f, -1.63728893e-01f, 1.39608514e-03f, -6.57100081e-02f, -4.60575037e-02f, 6.18880317e-02f,
  2.34593414e-02f, 4.37681414e-02f, 7.05945771e-04f, 4.33610156e-02f, -7.42697250e-03f, 7.85473511e-02f, -3.14894617e-02f, 4.33209240e-02f, -2.32479796e-02f, 1.17976137e-03f,
  2.22031958e-02f, 2.42795032e-02f, -4.87066321e-02f, 1.48848072e-03f, 2.61666719e-02f, -1.81764644e-02f, -8.88625905e-02f, 5.29455170e-02f, -1.01405019e-02f, -1.39908884e-02f,
  1.17274765e-02f, -9.46114073e-04f, 3.97156104e-02f, 1.37614524e-02f, -1.91568714e-02f, 4.54984559e-03f, 1.15170320e-02f, -1.51954098e-02f, -6.48294948e-03f, 2.14854758e-02f,
  1.53416529e-01f, -5.23515865e-02f, 8.40423331e-02f, 3.43227293e-03f, -3.03730890e-02f, 3.23939249e-02f, 5.06047606e-02f, 3.97297665e-02f, 2.70397831e-02f, 8.74615274e-03f,
  -1.22083686e-02f, -4.08227146e-02f, 1.08748429e-01f, 2.21826434e-02f, -5.67901246e-02f, 3.90621461e-02f, 1.16591081e-01f, 1.53199499e-02f, -4.62463722e-02f, -2.12535523e-02f,
  7.62546211e-02f, 8.14030785e-03f, -6.92093140e-03f, 1.10341720e-01f, 6.41359389e-02f, 5.99658638e-02f, 1.40860565e-02f, -1.16452677e-02f, -8.32428634e-02f, 2.63932556e-01f,
  -6.30317032e-02f, 4.91738945e-01f, 4.04437512e-01f, 1.43471109e-02f, 7.99811408e-02f, 1.25787288e-01f, 4.18781698e-01f, -4.60316101e-03f, -2.19386667e-01f, 1.73491389e-01f,
  1.01774327e-01f, -1.97300464e-01f, -7.73799866e-02f, -1.47267789e-01f, -7.55990797e-04f, 3.08562428e-01f, 2.24301800e-01f, 2.50178203e-02f, -1.90842509e-01f, -6.14435971e-02f,
  -9.77072045e-02f, 3.97171266e-02f, -1.66115120e-01f, -2.02483565e-01f, 4.93857376e-02f, -1.90933719e-01f, 1.11921303e-01f, 1.08325534e-01f, -7.90104941e-02f, 1.50049012e-03f,
  1.49085643e-02f, 2.68972665e-01f, -9.84551236e-02f, -3.48157771e-02f, 8.13749954e-02f, -1.14862230e-02f, -5.88876829e-02f, 2.31012832e-02f, -2.35236567e-02f, -3.07534039e-02f,
  -1.65725611e-02f, -6.47072643e-02f, -7.72397891e-02f, -8.44097957e-02f, 5.05106077e-02f, -9.56312008e-03f, -2.09750980e-03f, 8.63648504e-02f, 2.84921639e-02f, 1.12332873e-01f,
  -6.28576381e-05f, 5.73276877e-02f, 5.03095873e-02f, -1.87441185e-02f, 8.34603235e-02f, 3.90051752e-02f, 2.30274349e-02f, -4.38463241e-02f, 7.45021999e-02f, 1.39426524e-02f,
  -3.85338813e-02f, 1.53778866e-02f, -2.67074648e-02f, 4.22370695e-02f, -3.69393006e-02f, 2.20517904e-05f, 4.44896519e-02f, -3.05159986e-02f, 2.08032876e-02f, -4.71809059e-02f,
  5.43366335e-02f, 2.57699676e-02f, -2.82652024e-02f, 2.13104170e-02f, -8.66463706e-02f, 3.76337059e-02f, -1.67895090e-02f, -2.57560033e-02f, -9.85244289e-02f, -4.99107167e-02f,
  1.97987333e-02f, -1.27748679e-03f, 3.70231792e-02f, -4.85815480e-02f, 4.65041362e-02f, 9.66311060e-03f, -5.82506992e-02f, 6.32974785e-04f, -1.24588767e-02f, 5.23183569e-02f,
  -1.21083781e-01f, 3.32206860e-02f, -6.33628964e-02f, 3.83694796e-03f, 8.95941071e-03f, 1.71807259e-02f, 1.71758775e-02f, -5.62557802e-02f, 4.72241528e-02f, 1.31811807e-02f,
  6.45266771e-02f, 1.49080285e-03f, 1.58911094e-01f, -1.34614287e-02f, -1.21886274e-02f, 7.84576125e-03f, -1.75488126e-02f, -3.24097499e-02f, -1.45720253e-02f, -1.44503387e-02f,
  -4.07452546e-02f, 1.20488200e-02f, 3.94396251e-03f, 3.06820986e-03f, -6.07796647e-02f, -5.82400970e-02f, 1.13402987e-02f, -2.82959081e-03f, -5.31438272e-03f, -2.41442192e-02f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.49198687e-02f, 8.13594367e-03f, -1.01146549e-01f, 3.55770737e-02f, -1.02640457e-01f, 7.43100420e-02f, -3.69840451e-02f, 8.92316699e-02f, 1.10874437e-02f, 3.64949405e-02f,
  -7.36374259e-02f, -6.82267472e-02f, 1.65178981e-02f, 6.62580207e-02f, -7.14982767e-03f, -5.94878122e-02f, 5.74643053e-02f, -5.00287348e-03f, 6.78190961e-02f, 8.15365389e-02f,
  -3.84183414e-02f, -1.25486955e-01f, -2.94005033e-02f, 2.65462324e-02f, 2.47653611e-02f, -4.05768082e-02f, 2.65548639e-02f, -2.71858089e-02f, -7.70096928e-02f, -1.38869330e-01f,
  3.59635241e-02f, 1.97235923e-02f, -6.98087588e-02f, 5.22068329e-02f, 5.04236594e-02f, 8.00793767e-02f, 6.76150844e-02f, 2.52654888e-02f, -5.77915236e-02f, 1.86029915e-02f,
  -3.15264352e-02f, -4.87292856e-02f, 9.31556746e-02f, 3.42024975e-02f, 7.14898705e-02f, -5.14042266e-02f, 2.25571226e-02f, 1.15964212e-01f, -5.60183860e-02f, 1.75303724e-02f,
  -4.67035361e-02f, -5.60132526e-02f, 3.88796590e-02f, 1.55730667e-02f, -3.74335758e-02f, -8.84476826e-02f, 3.35210003e-02f, -3.61026591e-03f, -1.80679448e-02f, 5.03140166e-02f,
  -2.27578916e-02f, 8.75004381e-02f, -5.88619560e-02f, 3.17756124e-02f, -3.66116315e-02f, -6.95705712e-02f, -6.67205453e-02f, 4.91750352e-02f, 6.11053919e-03f, -9.69226435e-02f,
  4.03818022e-03f, 1.39221419e-02f, -5.13936207e-02f, 1.01138465e-01f, 2.40781922e-02f, -7.40824416e-02f, 7.18602538e-03f, -5.01422863e-03f, 4.59150299e-02f, 2.25618435e-03f,
  -6.16512913e-03f, -1.15334550e-02f, 4.59130257e-02f, 8.89951587e-02f, 6.78453641e-03f, -1.70917492e-02f, 9.39172059e-02f, -5.76087236e-02f, -9.15737003e-02f, -9.50055197e-03f,
  4.38292697e-02f, 9.17210709e-03f, -4.78234179e-02f, -5.90873323e-02f, 7.75343701e-02f, 6.50776625e-02f, 1.34515926e-01f, 5.93007393e-02f, 1.58926006e-02f, 5.77442758e-02f,
  8.44005197e-02f, -1.67457759e-02f, 6.73023537e-02f, -2.65884567e-02f, -7.38845915e-02f, -2.28642877e-02f, -5.93755022e-02f, -4.27760929e-02f, -2.63003190e-03f, 3.64879556e-02f,
  5.27608655e-02f, -5.76897748e-02f, 5.73774129e-02f, -8.38070512e-02f, 2.96111777e-02f, -1.23283733e-02f, -9.77880135e-02f, 3.46871503e-02f, 3.49280685e-02f, -1.40061498e-01f,
  -3.52847517e-01f, -3.26969172e-03f, 1.79132000e-02f, 6.93239495e-02f, -1.06128961e-01f, 1.64247137e-02f, -2.38328651e-01f, 6.55727461e-02f, 1.10350944e-01f, -1.53247744e-01f,
  -1.07342876e-01f, -1.96958601e-01f, -2.81854749e-01f, -2.67653853e-01f, -2.18007967e-01f, -3.09672296e-01f, -1.46108225e-01f, -3.48378867e-01f, -1.48219272e-01f, 1.44884707e-02f,
  -8.13940316e-02f, -3.54016542e-01f, -2.95453370e-01f, -5.33915497e-02f, 2.28900369e-02f, -2.16926217e-01f, -1.87748462e-01f, -1.69299558e-01f, -1.46721825e-01f, -3.32372189e-01f,
  -2.76101202e-01f, 2.47058138e-01f, -8.44204053e-03f, 3.54272127e-02f, -3.63915339e-02f, 5.50131239e-02f, -4.15587611e-02f, 8.16080719e-02f, 3.08025945e-02f, -3.22853937e-03f,
  3.39889503e-03f, 4.70400006e-02f, 6.71252329e-03f, 1.04360588e-01f, -2.88499594e-02f, 1.66579820e-02f, 7.14551508e-02f, -1.89350396e-02f, 4.94612381e-02f, 1.29926845e-01f,
  8.74562413e-02f, -7.76713565e-02f, -1.01571463e-01f, 1.24613263e-01f, 7.35651925e-02f, -7.24448934e-02f, 9.39217806e-02f, 6.52706772e-02f, 1.64257530e-02f, 4.71813744e-03f,
  3.65226821e-04f, -3.16995867e-02f, 3.33533734e-02f, 5.26467301e-02f, -3.15608531e-02f, 9.41045284e-02f, 5.78827485e-02f, -9.10308585e-02f, 2.94863302e-02f, -6.89128190e-02f,
  2.08831336e-02f, 1.84446592e-02f, 7.51224434e-05f, 1.08005898e-02f, 2.91699134e-02f, 6.36536926e-02f, -3.88810262e-02f, 2.72902790e-02f, -4.76429760e-02f, -7.39800781e-02f,
  1.42858492e-03f, 2.60982942e-02f, 5.92938848e-02f, 4.17334959e-02f, -1.36422338e-02f, -6.98314682e-02f, -4.47732136e-02f, 3.17877233e-02f, 6.84000850e-02f, -4.69210558e-02f,
  -9.66430604e-02f, -2.29577169e-01f, -1.49335161e-01f, 4.50378768e-02f, 4.75198030e-02f, 1.17512181e-01f, 6.21687202e-03f, 1.80243060e-01f, -5.01372106e-03f, -9.60672460e-03f,
  -1.54159637e-02f, -5.26171131e-03f, -1.21696685e-02f, 5.02206311e-02f, -6.20946586e-02f, 3.28139104e-02f, -3.66216488e-02f, -7.03776330e-02f, -6.63415119e-02f, 1.56241357e-01f,
  1.36207892e-02f, -4.81031649e-02f, -2.22175166e-01f, -4.04912643e-02f, -5.15366830e-02f, -2.04222545e-01f, 5.75259700e-03f, -4.99692857e-02f, -1.04370281e-01f, -4.94827405e-02f,
  -9.54854846e-01f, 3.81038003e-02f, -4.24616635e-01f, -4.26695377e-01f, 2.58656442e-01f, 2.12042779e-01f, 4.40027088e-01f, 1.72220424e-01f, -5.84151074e-02f, 8.84335255e-04f,
  3.06592062e-02f, -1.16507150e-01f, -7.23756850e-02f, 1.73274502e-01f, 1.05885543e-01f, 3.82058918e-01f, 1.47893637e-01f, -1.80520430e-01f, -2.01195851e-01f, 8.23435411e-02f,
  4.04128462e-01f, -1.52837902e-01f, -5.20001113e-01f, -2.66154371e-02f, 1.55050069e-01f, 6.61463886e-02f, 1.03260398e-01f, -1.03307538e-01f, 5.26631773e-02f, 8.13644752e-03f,
  -2.35597953e-01f, -2.33176827e-01f, 8.98281857e-02f, -8.80439505e-02f, -3.17621082e-02f, -6.61965758e-02f, 1.15715796e-02f, -8.25679302e-02f, -3.58410366e-02f, -2.15198062e-02f,
  -6.82220086e-02f, -3.90000828e-02f, 6.21706136e-02f, 5.25379293e-02f, -1.31105170e-01f, 2.55028214e-02f, -1.96045283e-02f, -8.75216499e-02f, -6.31151302e-03f, 2.87804194e-02f,
  2.65180022e-01f, -6.93793362e-03f, -9.15947556e-02f, 1.55289829e-01f, 7.73394108e-02f, -6.55553192e-02f, -3.40475589e-02f, 6.99984259e-04f, 8.73190761e-02f, -1.26993775e-01f,
  1.90686006e-02f, -1.47235580e-03f, 3.36135030e-02f, -7.78843090e-02f, 2.04451848e-02f, 4.11936194e-02f, -3.63260158e-03f, 3.65849398e-02f, 6.54671267e-02f, -1.58463940e-01f,
  1.00173168e-02f, -7.84731284e-03f, 2.44826544e-02f, -8.63531232e-02f, 4.19249907e-02f, 2.78210677e-02f, 1.93437245e-02f, -4.37942483e-02f, 2.92950273e-02f, 7.71541893e-03f,
  -6.89498782e-02f, 1.50264229e-03f, -9.47284605e-03f, 4.74742129e-02f, 2.75332052e-02f, 2.05176370e-03f, 4.60522398e-02f, 2.16114353e-02f, -5.27426861e-02f, -1.20987464e-02f,
  -1.46177858e-01f, 2.00544953e-01f, -4.39336617e-03f, 3.98293622e-02f, -9.39029362e-03f, -3.44682336e-02f, -6.37229159e-02f, 2.69642789e-02f, -3.35038528e-02f, 1.52783804e-02f,
  1.00091740e-01f, -3.90340425e-02f, -5.80546036e-02f, 1.70138832e-02f, -1.17920032e-02f, 9.88676772e-03f, -1.50777213e-02f, -4.82265316e-02f, 9.56160948e-02f, -8.00937116e-02f,
  -7.19890324e-03f, -2.65515987e-02f, -1.69194728e-01f, 1.26841506e-02f, 8.38743821e-02f, -2.17390694e-02f, -1.12830907e-01f, -8.38203058e-02f, 2.86910087e-02f, -1.06576905e-01f,
  4.14762378e-01f, 2.08777692e-02f, 6.67907372e-02f, 5.66131882e-02f, -3.78684849e-02f, -1.06172442e-01f, -6.53441995e-02f, 2.98792813e-02f, 1.47433326e-01f, 8.32213834e-02f,
  8.45340192e-02f, 3.83685082e-02f, 1.20737687e-01f, 1.48367643e-01f, 1.81388050e-01f, 7.89687112e-02f, -5.33705167e-02f, 1.02692008e-01f, 5.46413809e-02f, 4.74169515e-02f,
  8.63186046e-02f, 3.45648788e-02f, 5.07030673e-02f, 1.13560103e-01f, -4.92883697e-02f, -6.84279352e-02f, -3.41361612e-02f, -7.55186900e-02f, -8.63578245e-02f, -7.11498931e-02f,
  -1.22592926e-01f, -5.96757568e-02f, 4.22328152e-02f, 3.45596261e-02f, -1.33103713e-01f, -6.90239891e-02f, -3.06938570e-02f, -5.66831417e-02f, 3.50594781e-02f, 8.01326521e-03f,
  -3.21290409e-03f, -1.19627491e-01f, -1.82205886e-01f, 4.79629748e-02f, -8.73655453e-02f, 7.68502429e-02f, 1.10584430e-01f, 2.52098888e-01f, 1.80540115e-01f, -3.56665477e-02f,
  -9.41669717e-02f, -2.29892470e-02f, 8.59326869e-02f, 8.41787234e-02f, 1.26401886e-01f, 4.02616970e-02f, -1.86213255e-02f, 7.25263776e-03f, 1.37153745e-01f, 2.30299681e-01f,
  -1.92896780e-02f, -4.79961894e-02f, -4.07678150e-02f, 1.11459568e-02f, -2.77413782e-02f, -7.42834946e-03f, -3.38048637e-02f, -3.57093476e-02f, 3.66762802e-02f, 1.95392296e-02f,
  -2.38773376e-02f, 1.29549786e-01f, -5.18200211e-02f, 1.09626442e-01f, -1.23209953e-02f, -4.00581397e-02f, -2.89410241e-02f, -2.85072587e-02f, 3.34938988e-02f, 1.94377657e-02f,
  1.95970256e-02f, -2.80317441e-02f, -8.47564917e-03f, -5.75500168e-03f, 9.40220132e-02f, 9.80967656e-02f, -4.02628668e-02f, -5.54305837e-02f, 1.66332759e-02f, -7.43407682e-02f,
  9.24354419e-02f, 5.97045422e-02f, 2.58788969e-02f, -1.13799870e-02f, -8.05096030e-02f, -1.55470269e-02f, 6.49236375e-03f, -6.73375949e-02f, -7.69496039e-02f, 3.79782803e-02f,
  -3.55697609e-02f, 5.80656603e-02f, -5.54909185e-02f, 6.33678883e-02f, 2.03850456e-02f, 7.26405531e-03f, 5.20063043e-02f, 1.06471598e-01f, 3.72861214e-02f, 2.19675004e-02f,
  4.39479724e-02f, 1.39346927e-01f, 2.18716580e-02f, 8.94394070e-02f, -9.84413028e-02f, -1.09203994e-01f, -1.11479647e-01f, -3.76717746e-02f, -4.76080831e-03f, 1.47953942e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  1.89106129e-02f, -2.68387571e-02f, 6.26743063e-02f, -1.92500738e-04f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  3.00725579e-01f, -6.20426595e-01f, -3.16943318e-01f, 5.09298854e-02f, 1.56880766e-01f, -3.69317740e-01f, -3.20543468e-01f, 3.92385513e-01f, 1.69251472e-01f, -3.06829751e-01f,
  -4.76622619e-02f, 2.51518905e-01f, 7.22364113e-02f, 3.61305296e-01f, 6.15761697e-01f, 5.05334198e-01f, -2.50499934e-01f, -3.29495482e-02f, 2.96307534e-01f, 3.29748154e-01f,
  3.91733162e-02f, -5.19220233e-01f, 5.30680895e-01f, -5.60578331e-02f, 4.21731114e-01f, 1.20813973e-01f, 1.63847193e-01f, 2.33960301e-01f, -1.40785366e-01f, -2.01892570e-01f,
  8.19858193e-01f, -1.95099562e-01f, 2.08146527e-01f, 6.17386168e-03f, -2.95813959e-02f, -3.89663696e-01f, -1.63114980e-01f, 6.37092233e-01f, -2.83879191e-01f, -4.71923128e-03f,
  8.49567577e-02f, 3.49156976e-01f, 5.97355545e-01f, -3.97518575e-01f, -1.63504019e-01f, 3.30337547e-02f, -2.01945171e-01f, -1.33812517e-01f, 7.48940855e-02f, -5.00635386e-01f,
  1.26882777e-01f, 1.43621176e-01f, -1.62636250e-01f, -2.37641335e-01f, 2.28620201e-01f, -3.40028793e-01f, -6.89268589e-01f, -6.07592821e-01f, -4.11488056e-01f, 3.77494574e-01f,
  9.96847227e-02f, -1.21893428e-01f, 4.20290798e-01f, 1.99763820e-01f, -2.34909147e-01f, 5.35434186e-01f, -1.00754775e-01f, -2.60387301e-01f, -3.01186025e-01f, 2.89181858e-01f,
  -3.05042773e-01f, -4.04541165e-01f, -3.03788751e-01f, 5.82370572e-02f, -2.09194779e-01f, -1.60628688e-02f, -2.73609251e-01f, -2.52377301e-01f, -1.68302655e-01f, 2.69137830e-01f,
  -5.33871591e-01f, 4.20637190e-01f, 1.75567284e-01f, 2.65657119e-02f, -5.23202181e-01f, 3.59982520e-01f, 6.17662847e-01f, -5.47546864e-01f, 3.64660621e-01f, 4.03841257e-01f,
  -2.38760978e-01f, 3.09391171e-01f, -2.48587821e-02f, -3.10834348e-01f, 3.24900597e-01f, 2.36219674e-01f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -2.79772785e-02f, -7.33286515e-02f, 1.54475182e-01f, -1.56036139e-01f, 3.38947833e-01f, 2.48420715e-01f, 1.17219863e-02f, 7.63052329e-02f, 4.08607088e-02f, -1.41459376e-01f,
  3.50094616e-01f, -1.84893951e-01f, -7.23827407e-02f, -3.17945108e-02f, -1.68949112e-01f, 3.49160999e-01f, 6.24692217e-02f, -6.97985739e-02f, 4.63050216e-01f, 2.11373553e-01f,
  3.91915321e-01f, 3.21205586e-01f, 4.65248257e-01f, 1.57551765e-02f, 3.62733543e-01f, 6.49644732e-01f, -4.74137694e-01f, -1.92100659e-01f, -7.31544150e-03f, -8.57786313e-02f,
  1.07735641e-01f, -2.35393345e-02f, 1.03299372e-01f, 6.49115860e-01f, 5.25355637e-02f, 3.06490272e-01f, 1.43540762e-02f, 5.11001647e-01f, -6.45554185e-01f, -1.55663520e-01f,
  3.54366094e-01f, -1.77937925e-01f, 7.77924597e-01f, 2.34294459e-01f, -6.52504265e-02f, 9.08238411e-01f, 6.29980922e-01f, -6.63897991e-02f, 8.48228991e-01f, -2.57606298e-01f,
  4.91890967e-01f, 8.37532133e-02f, 3.06395054e-01f, -1.82917818e-01f, 2.70245939e-01f, 7.51798093e-01f, -7.81652689e-01f, -3.57050538e-01f, 3.38139713e-01f, -4.47254390e-01f,
  -8.73595029e-02f, 6.11995757e-01f, -5.47453642e-01f, 1.62820354e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  -2.17101779e-02f, 3.35571975e-01f, 5.58509052e-01f, 3.22809309e-01f
};

// L2_fan_Wp (Shape: 6 x 16)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -4.40360129e-01f, 3.06325734e-01f, 2.85562068e-01f, -2.84705907e-01f, -6.06519222e-01f, 1.71233922e-01f, 1.37126788e-01f, -2.94565737e-01f, 7.11787343e-01f, -4.04953748e-01f,
  3.29460889e-01f, -2.56067276e-01f, -4.16070707e-02f, -1.03939839e-01f, 3.13217878e-01f, -2.26500630e-01f, -3.15773338e-01f, 5.62815666e-01f, 1.27229705e-01f, 5.64225912e-02f,
  6.82628006e-02f, 2.61122733e-01f, -2.41614491e-01f, -2.82631099e-01f, 4.38546777e-01f, -6.40228987e-01f, -1.38676763e-01f, 3.25137109e-01f, 2.67915279e-01f, 1.25056922e-01f,
  -3.60175073e-01f, 6.12256706e-01f, -3.85592550e-01f, 2.13159397e-01f, 2.20414892e-01f, 2.05680504e-01f, 3.85832824e-02f, -1.11807978e+00f, -1.37390181e-01f, 1.81672469e-01f,
  -4.25352871e-01f, 3.74761790e-01f, -3.64214242e-01f, 8.01420331e-01f, -4.05234814e-01f, 5.56588590e-01f, -3.69454890e-01f, 4.03325588e-01f, -6.89241648e-01f, -2.70877749e-01f,
  1.28533274e-01f, -9.54733565e-02f, -2.09101692e-01f, -1.14520860e+00f, 2.43291557e-01f, 3.67085278e-01f, -2.83979207e-01f, 6.78844810e-01f, -1.10862494e-01f, 1.37540340e-01f,
  2.06259713e-01f, 7.66784651e-03f, -3.71910818e-02f, 1.87682081e-02f, 2.18050871e-02f, 3.47734183e-01f, -5.21110892e-01f, -3.37403864e-01f, -3.63595903e-01f, -2.21813202e-01f,
  7.23573506e-01f, 4.52396631e-01f, 2.32297182e-01f, 1.54570237e-01f, -5.38270712e-01f, -5.93973815e-01f, 2.75461912e-01f, -1.28689885e-01f, -2.41690334e-02f, 5.10894537e-01f,
  3.52009118e-01f, 1.52993232e-01f, 2.42427707e-01f, 2.13755354e-01f, -8.22038278e-02f, 6.53172970e-01f, -6.45463705e-01f, -9.48524535e-01f, 6.03004694e-01f, -1.20093100e-01f,
  7.02142358e-01f, -3.58726412e-01f, -7.30568767e-02f, -4.00409847e-01f, -8.34564343e-02f, -5.79674393e-02f
};

// L2_fan_Wp_bar (Shape: 4 x 16)
const int L2_fan_Wp_bar_rows = 4;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  -6.37638010e-03f, 7.66953230e-01f, 7.81754017e-01f, 8.53328764e-01f, 2.98236370e-01f, -2.61032462e-01f, -9.73885238e-01f, -6.79305553e-01f, 1.44816294e-01f, -4.64996099e-01f,
  2.49349579e-01f, 6.11661613e-01f, -1.14878125e-01f, 5.19560516e-01f, -4.33262289e-01f, 6.51152492e-01f, 5.16423821e-01f, 4.68941294e-02f, 3.55581224e-01f, 2.74474233e-01f,
  2.31184825e-01f, -4.51131910e-01f, 6.73434317e-01f, -9.25419271e-01f, -2.37260371e-01f, 3.04969847e-01f, -3.14490348e-01f, -6.87497914e-01f, 1.86489642e-01f, 2.28675269e-02f,
  2.80832320e-01f, 1.27678072e+00f, 9.98503417e-02f, 3.14676046e-01f, 4.53532767e-03f, 3.45106840e-01f, 1.55724600e-01f, 7.60323346e-01f, 4.05728817e-02f, 1.54528722e-01f,
  1.86481550e-01f, -1.95513919e-01f, 1.10908911e-01f, -5.51793873e-01f, -1.83711439e-01f, -5.06327212e-01f, 1.31986749e+00f, 3.45550776e-01f, -3.07575583e-01f, 5.75413346e-01f,
  9.08372477e-02f, -5.35799026e-01f, 5.38209558e-01f, 6.17065728e-01f, 3.45246866e-02f, 2.32202128e-01f, 7.33593225e-01f, -8.73702884e-01f, -1.46434069e-01f, 4.81518239e-01f,
  4.59962040e-02f, 5.76838732e-01f, 9.24336433e-01f, -5.24226844e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 4)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 4;
const float L2_fan_Bp_bar_data[] = {
  6.61318004e-01f, 5.80095470e-01f, 3.90267760e-01f, 1.97890252e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  -4.45535958e-01f, -3.52156669e-01f, 5.04645169e-01f, 3.13511312e-01f, -5.11978269e-01f, -1.97355807e-01f, 4.83531713e-01f, 1.23533912e-01f, 4.23264831e-01f, 7.70061255e-01f,
  3.09708238e-01f, -5.40886879e-01f, -3.39685202e-01f, 4.62062448e-01f, 5.85492790e-01f, -5.03897667e-01f, 9.57790855e-03f, -2.00979829e-01f, 1.71684727e-01f, 3.70032340e-01f,
  3.17583680e-02f, 8.06748807e-01f, 7.92786554e-02f, 2.07151711e-01f, 5.56642771e-01f, 4.17618155e-01f, 8.78808975e-01f, 5.20269930e-01f, 2.46005371e-01f, 9.46796536e-01f,
  -7.39368021e-01f, -6.43281698e-01f, 1.83367327e-01f, -3.65976244e-01f, 1.03577554e+00f, -7.25066721e-01f, -4.74037558e-01f, -6.54538274e-01f, 1.24242678e-01f, 6.58709466e-01f,
  -4.50948216e-02f, -4.60055321e-02f, -3.11772704e-01f, 9.34726417e-01f, 9.22100186e-01f, -2.48695552e-01f, -2.68612385e-01f, -1.05930582e-01f, -2.57719725e-01f, -1.73211560e-01f,
  -5.16739413e-02f, 1.99554805e-02f, 3.01159203e-01f, 1.74652152e-02f, 4.91048135e-02f, -7.07709432e-01f, -5.64801812e-01f, -3.43985781e-02f, 4.84307289e-01f, -5.91906488e-01f,
  -9.50200856e-01f, -7.26696253e-01f, 7.08510935e-01f, 5.38417697e-01f, -2.94772536e-01f, 7.45193884e-02f, -5.52877963e-01f, -6.68780267e-01f, -2.93271095e-01f, 7.44885564e-01f,
  3.65164638e-01f, 1.19775228e-01f, -8.62869322e-01f, -4.25082892e-01f, 4.81236100e-01f, 1.26860499e-01f, -8.63732338e-01f, 5.89250803e-01f, 1.57850787e-01f, 3.18004191e-01f,
  3.70584607e-01f, -5.02088547e-01f, 6.22054458e-01f, -4.66967434e-01f, 3.34709644e-01f, -1.46119431e-01f, 7.42926076e-02f, 2.97061056e-01f, -7.12469697e-01f, -2.08427280e-01f,
  1.34088600e+00f, 9.52012122e-01f, 3.61102745e-02f, 4.43403989e-01f, 4.00655389e-01f, -5.46620905e-01f, 5.93082942e-02f, 5.65413058e-01f, -9.74858165e-01f, 3.70470524e-01f,
  -2.55072236e-01f, 7.50452399e-01f, -4.26472992e-01f, 1.80332899e-01f, 2.67056644e-01f, 7.05896854e-01f, -5.27663589e-01f, -2.51617730e-02f, 9.98488307e-01f, -4.18492734e-01f,
  -9.60964322e-01f, -5.48068702e-01f, 1.17576905e-01f, -2.77366936e-01f, 7.84617066e-02f, 4.95540261e-01f, 3.85450214e-01f, -1.02212620e+00f, -7.63919413e-01f, -9.26499128e-01f,
  1.00874615e+00f, 9.32089925e-01f, -4.21911478e-01f, -5.89750409e-01f, -9.19748247e-01f, 4.10948157e-01f, -4.03004885e-03f, 4.13335472e-01f, 4.62990850e-01f, 5.33841729e-01f,
  -3.77632529e-01f, -2.20374987e-01f, 3.99699211e-01f, -1.02692258e+00f, 3.63637894e-01f, -1.36739984e-01f, -1.04747117e+00f, -7.45711148e-01f, -1.03946567e+00f, 6.01735353e-01f,
  -1.01605095e-01f, 3.04338396e-01f, 3.21514457e-01f, -8.04948568e-01f, 3.36996406e-01f, -6.15254819e-01f, -2.70260242e-03f, 1.79824352e-01f, -2.78471023e-01f, 6.30465567e-01f,
  -8.85617360e-03f, 4.10578996e-01f, 6.90500319e-01f, -4.68469888e-01f, -2.83720225e-01f, 3.37524384e-01f, 6.35032117e-01f, -8.75417829e-01f, -8.34133625e-01f, 9.53309178e-01f,
  -1.97100922e-01f, 1.25339031e-01f, -2.60899633e-01f, -7.97960699e-01f, 3.25650722e-01f, -2.83769667e-01f, 4.07738447e-01f, 4.83709186e-01f, -9.17018414e-01f, 1.63071684e-03f,
  -4.89703923e-01f, 7.67520845e-01f, -2.05885977e-01f, -1.05583346e+00f, 2.32487828e-01f, 8.43517125e-01f, -7.40765810e-01f, 9.05550957e-01f, 2.27819532e-01f, 5.77394366e-01f,
  5.60405970e-01f, 1.23403326e-01f, -7.25696564e-01f, -2.24890053e-01f, 1.12516260e+00f, -7.44980752e-01f, -5.32683790e-01f, -1.10028827e+00f, 1.98927805e-01f, -1.91308990e-01f,
  8.95705447e-02f, -1.16837904e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -3.09119701e-01f, 1.01700006e-03f, -2.97831334e-02f, -1.95736229e-01f, -1.56195432e-01f, -4.36351821e-02f, 4.15349193e-02f, 3.91675234e-01f, 6.93093762e-02f, -7.44785890e-02f,
  7.57071376e-02f, 5.21817684e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    