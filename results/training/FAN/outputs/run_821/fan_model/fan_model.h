/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.43581212e-01f, 1.56803340e-01f, -1.03791039e-02f, -1.21103466e-01f, 1.96577042e-01f, 1.14933401e-01f, 1.78639039e-01f, 3.28343101e-02f, -4.59333770e-02f, 1.65679768e-01f,
  3.66453558e-01f, 2.34183237e-01f, -4.98830639e-02f, -1.50896132e-01f, -1.89391091e-01f, -1.66057006e-01f, -4.14188832e-01f, -4.67540324e-01f, -2.25281626e-01f, 2.06085555e-02f,
  -1.37479203e-02f, -1.14687592e-01f, -1.46628559e-01f, -2.56556034e-01f, -1.52334198e-01f, -1.67173147e-01f, -7.55384564e-02f, -4.25576791e-02f, -3.62656754e-03f, -3.25491279e-01f,
  2.01216444e-01f, 1.59905583e-01f, 4.76109460e-02f, 1.51310666e-02f, 8.55309516e-03f, -5.40700443e-02f, 6.72260597e-02f, -3.97574678e-02f, 6.30347133e-02f, -3.11964448e-03f,
  1.67784780e-01f, 9.77807567e-02f, -6.46014884e-02f, 5.73734790e-02f, -1.20476726e-02f, -3.57396230e-02f, -7.46537074e-02f, -1.01331182e-01f, -4.85145068e-03f, 1.33472800e-01f,
  1.24935485e-01f, -6.69986308e-02f, -6.26886860e-02f, 2.91426666e-02f, -6.60592988e-02f, -9.96816829e-02f, 4.70667332e-02f, -3.85032594e-02f, -1.04082525e-01f, -2.54148841e-01f,
  4.23503444e-02f, -7.86738023e-02f, 1.49458193e-03f, 5.95333222e-06f, 4.89314459e-02f, -8.27883277e-03f, -4.35937271e-02f, 7.56842736e-03f, 8.58145882e-04f, -7.97407329e-02f,
  -1.70729589e-02f, 6.33337721e-02f, -4.29769047e-02f, -8.04783478e-02f, 5.67093771e-03f, -4.02646288e-02f, -1.99847724e-02f, -9.24780443e-02f, -2.15665661e-02f, 3.64692286e-02f,
  -4.42128927e-02f, -2.83709727e-02f, 1.56393945e-02f, -8.28335341e-03f, -9.60065946e-02f, -9.42161903e-02f, -1.81602780e-02f, 7.46697485e-02f, 1.39107615e-01f, 7.69110098e-02f,
  4.39769439e-02f, 6.90520033e-02f, 2.94980053e-02f, -9.20619443e-02f, 2.33397749e-03f, 2.50655841e-02f, 1.33269563e-01f, -1.39804147e-02f, 8.17611739e-02f, 3.95345837e-02f,
  7.47569501e-02f, -7.80777037e-02f, 5.16124666e-02f, 2.94737425e-03f, 1.07117839e-01f, 1.39578760e-01f, -2.53001489e-02f, 6.92362012e-03f, -2.06586421e-02f, 1.19302593e-01f,
  -1.72644667e-02f, -8.30118805e-02f, -5.90151958e-02f, -2.01297570e-02f, -2.45457725e-03f, -1.38138711e-01f, 4.47132811e-02f, -9.91903804e-03f, -1.36085555e-01f, -1.26283571e-01f,
  -3.47944759e-02f, -4.22191799e-01f, -5.66426575e-01f, 4.46524918e-02f, 3.27437110e-02f, -7.23587498e-02f, -2.18315184e-01f, 1.99287124e-02f, 1.58195540e-01f, -1.19325295e-01f,
  -5.59760854e-02f, 5.59317172e-02f, 9.55459625e-02f, 8.18644017e-02f, 4.09262069e-02f, -1.67424396e-01f, -1.34556070e-01f, -8.83985870e-03f, 2.20676154e-01f, 1.38564870e-01f,
  2.68732905e-01f, 1.19208388e-01f, 1.31280899e-01f, 1.28919289e-01f, -7.20347837e-02f, 9.53034908e-02f, -2.32487053e-01f, -1.06204338e-01f, -1.79368794e-01f, -2.25065723e-02f,
  -5.61012447e-01f, -3.10876936e-01f, 1.09166220e-01f, 1.82070315e-01f, -2.15841904e-02f, -9.25965831e-02f, -1.98588166e-02f, -9.43950042e-02f, 7.92509317e-02f, 4.15706396e-04f,
  -6.59563998e-03f, 4.95215952e-02f, 4.75684479e-02f, -7.66682252e-02f, 6.49661720e-02f, 5.37863560e-02f, 4.44000959e-02f, -6.94484115e-02f, 3.10215298e-02f, -1.66903630e-01f,
  1.12561010e-01f, -6.97024912e-02f, -1.66802987e-01f, -9.99186933e-03f, -4.97915223e-03f, 6.80112839e-02f, -7.32590705e-02f, 6.11042790e-03f, -5.88626303e-02f, -5.85596003e-02f,
  8.52970779e-02f, -5.00739142e-02f, 3.56508564e-04f, -1.90118495e-02f, 8.27606320e-02f, -8.25283155e-02f, -4.51804735e-02f, 5.25856987e-02f, -6.66172570e-03f, 8.67934618e-03f,
  -2.98046041e-02f, -2.51070857e-02f, -5.04094213e-02f, -2.79286671e-02f, -3.76042090e-02f, -5.78202829e-02f, -1.54984025e-02f, 5.00622503e-02f, 4.74623479e-02f, 3.70447263e-02f,
  -1.26760209e-03f, 1.32682268e-02f, -7.29444111e-03f, 8.87850020e-03f, -9.00890213e-03f, -3.74584645e-02f, 1.28742075e-02f, 3.90937477e-02f, -3.24956961e-02f, 4.40069735e-02f,
  8.90980475e-04f, 2.29177654e-01f, -5.44874929e-02f, -5.24988538e-03f, 2.20088800e-03f, 1.92648079e-02f, 3.67850550e-02f, 7.35414922e-02f, -5.71688823e-03f, 1.63706206e-02f,
  -2.73993537e-02f, 1.80613492e-02f, -3.71042527e-02f, 2.75386851e-02f, 2.51252167e-02f, 6.88271523e-02f, 7.15768710e-02f, 2.04964145e-03f, 4.86147813e-02f, -1.40593663e-01f,
  9.06206891e-02f, 4.65221144e-02f, -9.06655192e-02f, -5.44766523e-02f, 7.42626414e-02f, 5.30401580e-02f, -1.66872993e-01f, -4.68401834e-02f, 6.06567599e-02f, -4.25907187e-02f,
  -5.61282262e-02f, 3.92974690e-02f, -3.22948307e-01f, -1.82475671e-01f, -3.33871275e-01f, -2.47175604e-01f, -8.17771479e-02f, -1.35196940e-04f, -5.38524911e-02f, -2.26795059e-02f,
  3.92332971e-02f, 1.54626384e-01f, -7.18068145e-03f, -2.91319191e-02f, 4.47573885e-02f, -2.26280719e-01f, -2.13445485e-01f, -1.42873436e-01f, -6.27837479e-02f, -7.36224428e-02f,
  -1.26542687e-01f, -2.18658626e-01f, -3.71554457e-02f, -1.12488680e-01f, -1.93148062e-01f, -3.44817042e-02f, -2.45013181e-02f, -1.47878751e-01f, -1.92597404e-01f, -3.20066124e-01f,
  -1.65042803e-01f, 7.92181417e-02f, 7.28196874e-02f, 5.26712276e-02f, 3.32565606e-02f, 4.75073904e-02f, -7.50264674e-02f, 7.19707645e-03f, 7.80183896e-02f, 4.65428047e-02f,
  4.26450097e-05f, 6.30535185e-02f, -5.91456182e-02f, -3.77794728e-02f, 2.12274324e-02f, -3.41519602e-02f, 1.05100721e-01f, -6.44434243e-02f, -7.06968755e-02f, 5.25833666e-02f,
  -6.75617531e-02f, -1.68772489e-01f, 1.18388467e-01f, 1.24154225e-01f, 1.03467945e-02f, -4.87162359e-02f, 1.77603751e-01f, 1.85736045e-01f, 6.03210069e-02f, 6.46063909e-02f,
  -2.77744737e-02f, 3.71477902e-02f, 4.70516533e-02f, 6.87469095e-02f, 4.39460315e-02f, 8.76706094e-02f, 8.18819702e-02f, 4.95162010e-02f, 9.12605878e-03f, 8.80920812e-02f,
  -8.80313944e-03f, -1.78793408e-02f, -1.38044301e-02f, -7.90835321e-02f, -2.19025696e-03f, -3.05656437e-02f, 5.58542237e-02f, 2.83770896e-02f, -3.70335095e-02f, -1.53029449e-02f,
  3.30986381e-02f, 1.09220510e-02f, -1.76323596e-02f, 8.55160654e-02f, -3.83101627e-02f, -7.42659271e-02f, -2.70619728e-02f, -5.14950491e-02f, 1.03876996e-03f, -4.75739501e-02f,
  3.05945009e-01f, 4.18949164e-02f, -6.25910833e-02f, 5.56076691e-02f, -6.12703040e-02f, 7.67436111e-03f, 2.16090102e-02f, 6.65710075e-04f, -7.51347840e-02f, -4.47118878e-02f,
  4.26500700e-02f, 9.70366597e-03f, -1.94236694e-03f, 2.74068303e-02f, -2.75784899e-02f, -1.70393114e-03f, 1.77088100e-02f, -4.33317162e-02f, -9.94225368e-02f, -4.33756411e-02f,
  2.20919251e-02f, 5.70969982e-03f, 1.46288112e-01f, 1.11675523e-01f, 5.92621714e-02f, -6.36879578e-02f, 1.89485073e-01f, -3.39796068e-03f, 1.88751947e-02f, 8.26438889e-02f,
  8.02692324e-02f, 7.43024766e-01f, -7.03901500e-02f, 2.16828417e-02f, -5.85428253e-02f, 2.46269871e-02f, 4.47507054e-01f, 1.49483904e-01f, -5.25418893e-02f, 1.84755221e-01f,
  -4.37761806e-02f, -3.23255420e-01f, -3.79822165e-01f, -3.82729352e-01f, -7.80203119e-02f, 3.47320467e-01f, 3.10295284e-01f, -3.16502661e-01f, -3.59679461e-01f, -6.64597973e-02f,
  1.49723170e-02f, 8.30668584e-02f, -3.66219431e-02f, 2.99166888e-02f, 1.60935521e-01f, -1.87519372e-01f, 2.88698494e-01f, 7.41052628e-02f, 1.12831652e-01f, 3.87846142e-01f,
  -1.30362079e-01f, 3.40418279e-01f, -2.92689830e-01f, -1.08369328e-01f, -2.03096960e-02f, -3.48349176e-02f, -2.97608711e-02f, 2.20706221e-02f, -6.30416442e-03f, 1.62626147e-01f,
  -3.90417017e-02f, -1.44379139e-02f, 1.96291842e-02f, -6.59564734e-02f, 8.50688592e-02f, -1.07665546e-02f, 7.78114498e-02f, 2.30049547e-02f, -8.22499171e-02f, -4.96499725e-02f,
  2.43187044e-02f, 4.16119173e-02f, -3.24956775e-02f, 4.73580584e-02f, -5.82740977e-02f, -1.28369883e-01f, 1.66281220e-02f, 6.19914336e-03f, -1.03879906e-01f, 1.23928830e-01f,
  4.43437919e-02f, 1.78232267e-02f, 1.52653679e-02f, 6.40089884e-02f, 6.92571094e-03f, 3.28985928e-03f, 9.65475012e-03f, 9.98108368e-03f, -2.27771569e-02f, 4.37022001e-02f,
  -3.89511660e-02f, -1.36668636e-02f, -8.14176723e-03f, 5.43623455e-02f, 9.92099755e-03f, 1.81421731e-02f, 7.85085745e-03f, 4.69319001e-02f, -1.31394625e-01f, 5.82517944e-02f,
  -9.10223201e-02f, -1.27585143e-01f, 7.53664505e-03f, -1.27574345e-02f, 6.45115972e-02f, 1.99716948e-02f, 5.18117137e-02f, 2.70514768e-02f, 3.16861533e-02f, 4.48630899e-02f,
  -1.94536746e-01f, -2.31981575e-01f, 4.71272096e-02f, 1.26219320e-03f, -2.37008110e-02f, -5.57102356e-03f, -3.49971950e-02f, -2.47479286e-02f, 1.49418339e-02f, 1.08809769e-02f,
  2.28621345e-02f, -6.67352986e-04f, 3.45426686e-02f, 1.10014960e-01f, -5.72954081e-02f, -3.14392187e-02f, 1.26133502e-01f, -9.87237394e-02f, -2.35620495e-02f, 9.04018879e-02f,
  8.53185803e-02f, 1.60411932e-02f, -2.55964130e-01f, -1.21478073e-01f, -5.60297864e-03f, -2.05935851e-01f, -4.45200652e-02f, -7.50464872e-02f, -1.54844657e-01f, 7.56156519e-02f,
  3.44209701e-01f, 2.33212132e-02f, -2.07622334e-01f, 1.14067070e-01f, -2.17509061e-01f, -3.31008881e-01f, -3.89356405e-01f, -5.99864125e-02f, 1.14494532e-01f, -5.10829985e-02f,
  1.31012900e-02f, -1.10446334e-01f, -1.10176772e-01f, -1.23451628e-01f, -1.63022235e-01f, -1.92277208e-01f, -2.04794049e-01f, -1.60632759e-01f, -8.29767063e-02f, -7.98199698e-02f,
  -6.19839691e-02f, 2.60767341e-02f, 1.73056647e-01f, 1.75086841e-01f, 7.57873580e-02f, 2.86636478e-03f, -5.31356297e-02f, 1.40705898e-01f, -1.92716997e-02f, -2.77916510e-02f,
  -7.31814727e-02f, 3.00631523e-01f, -1.45304635e-01f, 7.05337822e-02f, -5.16782217e-02f, 7.20618479e-03f, -9.96648371e-02f, -4.72390614e-02f, -1.06931411e-01f, -2.20638420e-02f,
  -1.47551507e-01f, 1.56492228e-03f, -7.59779662e-02f, 7.39042386e-02f, 9.27941203e-02f, 5.25175817e-02f, 1.03675447e-01f, 2.17454415e-02f, -4.59123077e-03f, 1.10295005e-01f,
  7.62215350e-03f, -3.93043458e-02f, -7.30589256e-02f, -2.95252744e-02f, 1.42986953e-01f, -1.27520472e-01f, 1.43557340e-01f, 1.56487674e-01f, 1.35600582e-01f, 2.61459678e-01f,
  1.11762416e-02f, 8.08543898e-03f, -3.37535068e-02f, 6.08918034e-02f, -2.31444277e-02f, -6.62589371e-02f, 4.66742031e-02f, -4.99486411e-03f, 2.23025493e-02f, 2.57403832e-02f,
  1.90527749e-03f, -2.53399350e-02f, 5.57960663e-03f, -3.98074416e-03f, -1.15728397e-02f, -5.70793562e-02f, -1.11427881e-01f, 6.47123205e-03f, 1.83614679e-02f, 1.84720976e-03f,
  2.72318628e-02f, 1.34379137e-02f, -2.20426694e-02f, 1.32499225e-02f, -1.13756843e-02f, 1.26016457e-02f, -1.06004123e-02f, 5.37842326e-02f, 8.24564397e-02f, -5.08135243e-04f,
  -3.08454596e-02f, -1.64411217e-01f, 2.03886908e-02f, 5.26626594e-02f, -8.37916322e-03f, -7.22505525e-02f, -2.70135850e-02f, 1.57500692e-02f, -3.09413159e-03f, 2.35096309e-02f,
  4.07117233e-03f, 2.06388775e-02f, -1.94167104e-02f, 3.67502645e-02f, 8.58606771e-03f, 1.25686834e-02f, -6.86875284e-02f, -1.13750331e-01f, -5.38257509e-02f, 6.50385916e-02f,
  -2.92114615e-02f, -2.35901251e-01f, -2.02055618e-01f, -2.01149926e-01f, -4.11474667e-02f, -3.07121426e-01f, -2.55234480e-01f, -1.45929262e-01f, -2.61079043e-01f, -9.58169401e-02f,
  2.93432474e-01f, 4.40835245e-02f, 1.53882176e-01f, -8.08455341e-04f, 1.18069887e-01f, 3.84494483e-01f, 5.29652834e-01f, 2.19085321e-01f, -7.73850530e-02f, 4.02798951e-02f,
  -1.55471517e-02f, -1.09819986e-01f, -1.18502669e-01f, -1.35427564e-01f, 5.72052449e-02f, 1.39916763e-01f, 4.89256270e-02f, 3.39108333e-02f, 1.10567585e-01f, 1.54471233e-01f,
  -1.52511135e-01f, -1.04452297e-01f, -1.71445385e-01f, -1.94875628e-01f, -1.89909771e-01f, -1.90016359e-01f, -8.40423629e-02f, -1.88720912e-01f, -1.06616989e-01f, -2.03637451e-01f,
  6.38741106e-02f, 1.44598916e-01f, 5.76645434e-02f, -4.56004515e-02f, -9.75595564e-02f, 2.04312522e-02f, 7.20796287e-02f, -1.58287138e-02f, -2.84451842e-02f, -6.27468377e-02f,
  -5.02993204e-02f, -9.20227766e-02f, 3.29677984e-02f, -1.02342725e-01f, 5.67781627e-02f, 2.95763444e-02f, -8.49197507e-02f, -3.98918502e-02f, -6.74698793e-04f, 9.71487612e-02f,
  -1.83373928e-01f, 8.52670223e-02f, 1.20810077e-01f, 1.21925101e-01f, 5.53536639e-02f, 2.37404350e-02f, 1.74743608e-02f, -1.06342345e-01f, 6.67370036e-02f, -1.24067746e-01f,
  -6.23442233e-02f, -1.87768880e-02f, -4.44719009e-03f, -5.60036786e-02f, 1.76205114e-02f, -2.05350388e-02f, 5.83547205e-02f, -3.62403989e-02f, -2.12325044e-02f, -2.02628076e-02f,
  -1.82690984e-03f, -2.58974954e-02f, 2.75237914e-02f, -2.55299415e-02f, -8.06365386e-02f, 2.74110734e-02f, -6.93249702e-02f, -1.81090776e-02f, -2.76790224e-02f, -3.86882983e-02f,
  4.21877112e-03f, 7.84075707e-02f, -3.59633081e-02f, -4.50041927e-02f, 3.55646946e-02f, -8.95654131e-03f, 7.21712038e-03f, -5.50366603e-02f, -2.10378151e-02f, 4.37745340e-02f,
  -9.90190580e-02f, 8.86334330e-02f, 4.63916920e-02f, 8.20133984e-02f, 2.95928512e-02f, -5.15802950e-02f, -1.05470128e-03f, -3.96440029e-02f, -5.78770377e-02f, 7.02061355e-02f,
  3.64294276e-02f, 8.42602327e-02f, 1.01128407e-01f, -8.70175809e-02f, 5.50225675e-02f, -1.79242954e-04f, -4.65822108e-02f, -5.09502925e-02f, 7.71110505e-02f, -8.34504068e-02f,
  -7.47174025e-02f, 1.61536753e-01f, 9.26446617e-02f, 1.57039419e-01f, 7.66964853e-02f, 2.12145492e-01f, 7.00177401e-02f, 2.07608379e-02f, 2.97938079e-01f, 1.48089319e-01f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.63413996e-01f, -8.71327296e-02f, 3.82710576e-01f, -5.05951941e-02f, -3.86601746e-01f, -3.20926905e-01f, -3.38686973e-01f, -1.19813494e-01f, -1.78008139e-01f, -1.14759587e-01f,
  -3.14587921e-01f, -1.30824193e-01f, -1.37194991e-02f, 9.31676552e-02f, 2.78709710e-01f, 1.26897320e-01f, 1.13377027e-01f, 4.96924341e-01f, 3.33564520e-01f, 8.89511108e-02f,
  1.28196310e-02f, 8.19040537e-02f, 3.93949211e-01f, 2.30499119e-01f, -3.45302522e-02f, -1.95052922e-02f, 3.77310440e-02f, 3.28299180e-02f, -5.23270257e-02f, 1.88544527e-01f,
  4.99053858e-02f, -2.55913567e-02f, 1.63800977e-02f, -7.45627806e-02f, -9.20332372e-02f, 9.04198214e-02f, 2.32881960e-02f, 6.50317147e-02f, 2.81046294e-02f, -2.21963990e-02f,
  -9.84618291e-02f, 3.06999101e-03f, -4.45021763e-02f, -6.50492031e-03f, -5.46166264e-02f, 3.54170129e-02f, 1.47792354e-01f, 2.79224247e-01f, 5.28730229e-02f, -7.23984838e-02f,
  -1.26912281e-01f, -1.87454686e-01f, -2.92239226e-02f, -8.13526288e-02f, 1.33487172e-02f, -1.10693201e-02f, 7.91472197e-03f, -2.95824353e-02f, 9.15789232e-02f, 1.56896526e-03f,
  5.30189835e-02f, 2.50752494e-02f, -2.15486381e-02f, -1.68040674e-02f, 1.67612899e-02f, -6.91829547e-02f, -1.89022291e-02f, -1.40504604e-02f, -2.67642606e-02f, -5.10808565e-02f,
  1.98713839e-02f, 6.13049418e-02f, 1.05622657e-01f, -4.45126407e-02f, 1.34202791e-03f, 4.36645150e-02f, -1.81529578e-02f, 7.61449803e-03f, -3.71964015e-02f, 2.09459029e-02f,
  -4.06525955e-02f, 4.89247069e-02f, 1.77625343e-02f, 4.60147671e-02f, 8.36438090e-02f, 7.77096972e-02f, -4.55210842e-02f, 1.97871290e-02f, -4.80021611e-02f, 2.39986344e-03f,
  -1.26368061e-01f, 2.93489732e-02f, -1.04112983e-01f, 5.30687999e-03f, -2.40905583e-02f, 5.82324266e-02f, -5.29886819e-02f, 1.07702449e-01f, -1.02227099e-01f, -5.94230294e-02f,
  -1.55270427e-01f, 4.97256592e-02f, -2.10600477e-02f, 6.10474730e-03f, 3.28757949e-02f, -9.29201096e-02f, -4.31397222e-02f, 3.84554788e-02f, -6.48348918e-03f, -8.66335928e-02f,
  -1.12869456e-01f, -1.56903222e-01f, -1.45863369e-01f, -1.03661522e-01f, -1.48604289e-01f, -1.20994031e-01f, -8.82970095e-02f, -1.62639081e-01f, -1.35945529e-01f, -1.68826669e-01f,
  -4.60017323e-01f, -2.30953455e-01f, -6.33517578e-02f, 3.75733040e-02f, -3.74845671e-03f, -2.35652700e-02f, -8.54908898e-02f, 7.58790076e-02f, 5.07532954e-02f, -1.27087086e-01f,
  -1.55272745e-02f, -1.35008484e-01f, -8.34922567e-02f, 4.36389595e-02f, -4.63411622e-02f, -5.95280305e-02f, -1.06551506e-01f, -1.22974850e-01f, -5.81609383e-02f, -1.04756236e-01f,
  -2.04990245e-02f, -4.15262431e-02f, -2.31298044e-01f, -1.19051576e-01f, -3.18379663e-02f, 1.40183736e-02f, 6.46982118e-02f, 4.59161103e-02f, -6.36393726e-02f, -8.61639455e-02f,
  -1.52062416e-01f, 1.67115722e-02f, 6.48339391e-02f, -4.08428796e-02f, 2.24208925e-02f, -8.82572010e-02f, 1.48181999e-02f, 8.51013958e-02f, 6.84080273e-02f, 4.55655605e-02f,
  7.50146508e-02f, -8.16640630e-02f, -3.89701761e-02f, -9.61565971e-02f, 3.40454802e-02f, -6.65931329e-02f, -9.21151787e-02f, 1.56451128e-02f, 4.67999652e-02f, 1.51814930e-02f,
  -1.02477066e-01f, -1.18460231e-01f, -1.85273796e-01f, -2.98720635e-02f, 1.28824621e-01f, 2.90669072e-02f, 7.16790697e-03f, 7.69317523e-02f, -2.25486439e-02f, -2.56133564e-02f,
  -2.95155589e-02f, 8.78223591e-03f, 4.78102639e-02f, -1.96415707e-02f, -6.94992691e-02f, -2.43730899e-02f, 5.86344413e-02f, 5.59609346e-02f, 5.03605455e-02f, 3.95397097e-03f,
  6.74124733e-02f, 8.19156915e-02f, -2.55418550e-02f, 4.35890928e-02f, -3.48943919e-02f, -4.78193797e-02f, 1.18926810e-02f, -4.65229675e-02f, 2.35121492e-02f, 9.82800778e-03f,
  -4.20413017e-02f, 1.03600882e-02f, 7.13198110e-02f, 1.04684979e-01f, -4.27476801e-02f, 7.86194429e-02f, 3.58244963e-02f, -6.03777692e-02f, -3.55675332e-02f, -8.61335248e-02f,
  2.11066240e-03f, 7.34262168e-02f, -1.13175049e-01f, 7.29689514e-03f, 4.45545502e-02f, 5.62673137e-02f, 2.28955206e-02f, 5.70217185e-02f, 3.42396013e-02f, -1.02253780e-01f,
  -1.09051866e-02f, -5.34763932e-02f, -9.74323973e-02f, -1.13623410e-01f, -1.39444157e-01f, -7.14154616e-02f, -9.82522592e-02f, -1.06543794e-01f, -8.58641565e-02f, -1.32934302e-02f,
  -8.18092450e-02f, -1.54030934e-01f, -2.14828774e-01f, -1.53160572e-01f, -3.23459990e-02f, -1.84238940e-01f, -1.18842192e-01f, -1.47913203e-01f, -8.10251758e-02f, -2.57994592e-01f,
  3.06762960e-02f, -2.50334173e-01f, 2.81802535e-01f, 1.82358190e-01f, 3.24761808e-01f, 4.44885105e-01f, 3.50136518e-01f, 7.95623511e-02f, 2.25299187e-02f, -8.01380500e-02f,
  -2.33472526e-01f, -2.90294945e-01f, -1.51409298e-01f, -1.54281437e-01f, -3.88846211e-02f, 1.44068360e-01f, 2.71079928e-01f, 2.00305641e-01f, 2.43970037e-01f, 1.62246883e-01f,
  -2.84379069e-02f, 1.91460520e-01f, -3.07667372e-03f, 1.27671644e-01f, 3.18314582e-02f, 5.83311170e-02f, 2.43038759e-02f, 9.89896953e-02f, -2.57516857e-02f, -8.48955661e-03f,
  -1.60915658e-01f, -1.75316095e-01f, 2.01751962e-01f, -2.45548427e-01f, -1.18162237e-01f, -1.46579072e-01f, 2.53370199e-02f, 3.40598100e-03f, -1.07979923e-01f, 7.06778467e-02f,
  -2.47665215e-02f, -1.21355727e-01f, -1.01748057e-01f, -6.88471198e-02f, 8.36798027e-02f, -4.84806597e-02f, -1.59560129e-01f, -1.77031104e-02f, 8.04001279e-03f, -1.72859102e-01f,
  -1.17870830e-01f, -1.97821315e-02f, 4.71056737e-02f, 5.06128259e-02f, -7.58380517e-02f, -3.56914215e-02f, -4.28535901e-02f, -1.00117885e-01f, 2.96201576e-02f, -1.59462363e-01f,
  5.24442196e-02f, -1.83792282e-02f, -2.43999176e-02f, 3.96977514e-02f, 3.97680588e-02f, 6.82020485e-02f, 7.13691860e-02f, 1.72804985e-02f, 9.29943919e-02f, 7.94076361e-03f,
  -4.40859348e-02f, 7.81906620e-02f, 4.16996367e-02f, 3.26448306e-02f, 2.63094362e-02f, 9.19272751e-02f, 5.35196476e-02f, -1.53856695e-01f, -7.94871300e-02f, 9.35294107e-02f,
  -6.31614700e-02f, 1.08024955e-01f, 2.80148461e-02f, 2.66395267e-02f, -1.22638263e-01f, 5.85883893e-02f, 5.91434538e-03f, -1.32243698e-02f, -9.34426114e-02f, 3.96764316e-02f,
  6.50710836e-02f, 1.03145748e-01f, 4.96919379e-02f, -1.12418413e-01f, 1.06970422e-01f, -9.55250710e-02f, -9.11467299e-02f, -7.14474022e-02f, 1.58311985e-02f, 7.17635751e-02f,
  -8.85625556e-02f, -1.31721005e-01f, -7.23271891e-02f, 3.23751196e-02f, 2.00777054e-01f, 1.63709968e-01f, -1.55914366e-01f, 1.97162870e-02f, 5.14707761e-03f, -9.52891707e-02f,
  -2.43997667e-03f, 1.19883329e-01f, 2.71912068e-01f, 1.58004969e-01f, -7.33439550e-02f, 1.68821335e-01f, 1.55610412e-01f, 9.66429114e-02f, 6.32045865e-02f, 2.21063375e-01f,
  -6.39148176e-01f, -3.54304016e-02f, 1.01807728e-01f, -2.51761138e-01f, 8.06444138e-02f, 3.25482860e-02f, -8.39764401e-02f, -1.88036844e-01f, -5.49010187e-02f, -1.19904183e-01f,
  -1.51188254e-01f, -3.17225941e-02f, 1.04723215e-01f, 1.18439302e-01f, 5.28914891e-02f, 1.57846645e-01f, 3.05099308e-01f, 1.84971660e-01f, 9.37143788e-02f, 3.60944532e-02f,
  -3.31518948e-02f, -1.43930186e-02f, -1.21710010e-01f, 1.13421101e-02f, 2.74356566e-02f, 6.68874085e-02f, 1.23019442e-01f, -4.17977050e-02f, 3.70496772e-02f, 6.08621947e-02f,
  -2.02384386e-02f, -2.38380119e-01f, 8.91900733e-02f, -5.17642796e-02f, 9.68137681e-02f, -7.28346035e-02f, -7.80737102e-02f, -5.87882400e-02f, -5.65327443e-02f, 1.81808118e-02f,
  -3.92082967e-02f, -8.06529075e-02f, 5.24535999e-02f, 5.67985959e-02f, -1.64154947e-01f, -1.00949466e-01f, 7.57420734e-02f, 4.70606796e-02f, 1.11905083e-01f, -4.10777964e-02f,
  1.73618108e-01f, -5.23079075e-02f, -1.00273989e-01f, 1.92934871e-02f, 4.32791114e-02f, 3.30858491e-02f, -9.63309258e-02f, -1.08734958e-01f, -2.66227294e-02f, -1.20033853e-01f,
  6.16794778e-03f, 1.06667802e-02f, -6.40883017e-03f, -4.03085724e-02f, -8.30120221e-02f, 5.22157513e-02f, 1.04261130e-01f, -4.42890525e-02f, 8.03398862e-02f, 6.85070641e-03f,
  -1.45346671e-03f, -1.64747052e-02f, 4.78047691e-02f, -5.40621355e-02f, 8.58963206e-02f, 2.97873765e-02f, -4.62169200e-02f, -1.05312495e-02f, -1.56045211e-02f, -4.00693156e-02f,
  2.27573998e-02f, -2.91232150e-02f, 4.35535470e-03f, 6.78157732e-02f, 7.80835897e-02f, 6.21947348e-02f, -3.40490527e-02f, -7.02627450e-02f, -2.23054811e-02f, 2.18689926e-02f,
  -2.22565308e-01f, 2.06531405e-01f, -1.99893162e-01f, -1.22129992e-01f, -6.81963786e-02f, -4.16718386e-02f, -4.41739522e-02f, 3.24384533e-02f, -4.57836799e-02f, -6.00492358e-02f,
  -9.69648361e-02f, -8.73085782e-02f, -3.77827324e-02f, 5.95096424e-02f, 2.44758651e-02f, -1.30386472e-01f, -1.32246777e-01f, 4.95345145e-02f, -8.94224085e-03f, -9.81246755e-02f,
  5.10544293e-02f, -2.04835102e-01f, -2.44568288e-01f, -1.01954481e-02f, -1.24423780e-01f, -1.14190489e-01f, -1.40478149e-01f, -1.81198701e-01f, -1.12683833e-01f, -2.87338823e-01f,
  4.88366485e-01f, 9.05175805e-02f, -9.54679027e-02f, 2.57756025e-01f, 1.88341632e-01f, 5.36157712e-02f, 1.11266784e-01f, -4.98864502e-02f, 9.28926691e-02f, 1.90594807e-01f,
  1.95399404e-01f, 1.94413617e-01f, 1.33615568e-01f, 8.83920938e-02f, 8.26035589e-02f, -4.32121120e-02f, -5.56553081e-02f, -7.77154490e-02f, 5.18258289e-02f, 1.64738938e-01f,
  1.26396969e-01f, 9.77599770e-02f, -2.64270883e-03f, -3.11999265e-02f, -7.02913925e-02f, 6.23215362e-03f, -1.58993807e-03f, 1.26447409e-01f, 7.40516260e-02f, -1.73229296e-02f,
  1.69315487e-02f, 2.49937281e-01f, -5.05877212e-02f, 1.09590307e-01f, 8.86990726e-02f, -8.23564678e-02f, 8.08317587e-02f, -2.17274316e-02f, 8.35225824e-03f, -1.79589674e-01f,
  -7.13306814e-02f, -3.22948247e-02f, 1.41346091e-02f, -1.05166785e-01f, -7.39298314e-02f, -1.51619995e-02f, -5.01674674e-02f, -1.31822065e-01f, -3.72253805e-02f, 4.57463041e-03f,
  3.04456819e-02f, 1.16122775e-01f, 1.37236277e-02f, -7.95222595e-02f, 3.31544057e-02f, 2.11080834e-02f, -5.55930333e-03f, 5.04209846e-02f, -9.08887833e-02f, 3.02305724e-02f,
  1.57822356e-01f, 1.42184973e-01f, 8.38453099e-02f, 4.47862297e-02f, 6.22994900e-02f, 3.17432173e-02f, -2.64621880e-02f, 5.14701754e-02f, 1.98743772e-02f, -2.95979269e-02f,
  3.86934206e-02f, 2.27076765e-02f, 9.18383151e-02f, 7.70657212e-02f, 5.77323884e-02f, -5.88092618e-02f, -3.26369479e-02f, -3.57596986e-02f, 4.38417606e-02f, -8.40520114e-03f,
  7.90982619e-02f, 3.31164780e-03f, 7.11927637e-02f, 2.36774012e-02f, 1.64951030e-02f, 6.36401027e-02f, -3.91401490e-03f, 5.04653342e-02f, 4.58482504e-02f, 3.89286205e-02f,
  -1.37515888e-01f, 2.06833497e-01f, 2.21056361e-02f, 2.24609226e-02f, -4.12944183e-02f, -6.34885356e-02f, 1.38085753e-01f, -2.46628392e-02f, -1.39434293e-01f, -1.40020818e-01f,
  -5.69762774e-02f, 5.95452785e-02f, 4.09995057e-02f, -1.45344242e-01f, -1.15102731e-01f, 2.84106657e-03f, 1.70676541e-02f, 2.91456338e-02f, 8.51557497e-03f, -9.09517184e-02f,
  -7.85910990e-03f, -1.21929750e-01f, -1.66608039e-02f, -1.00795195e-01f, 2.64686812e-02f, 1.80899337e-01f, -5.49199507e-02f, -2.10842062e-02f, -8.66049528e-02f, -1.51631474e-01f,
  2.08180025e-01f, 2.67374903e-01f, -4.05069394e-03f, 1.90931290e-01f, -9.49441269e-02f, -1.22851841e-01f, 2.11572484e-03f, 2.54817694e-01f, 1.39470473e-01f, 1.56205907e-01f,
  1.09552272e-01f, 2.29754657e-01f, 2.47888267e-01f, 1.84484839e-01f, 2.89755285e-01f, 2.13443562e-01f, 1.69950292e-01f, 3.72688062e-02f, 4.80632596e-02f, 1.45654857e-01f,
  1.29278764e-01f, 6.18290491e-02f, -9.21340100e-03f, 9.86183137e-02f, 6.62301853e-02f, 1.80118799e-01f, 5.02958521e-02f, 5.22472188e-02f, 3.77173536e-02f, 3.13829541e-01f,
  9.04272944e-02f, -3.86240296e-02f, 4.76288795e-02f, 1.77144259e-02f, -8.84758607e-02f, 9.49244574e-02f, -4.35492024e-02f, -6.61257058e-02f, -1.31727353e-01f, 5.13276793e-02f,
  -1.71485811e-01f, -4.33175564e-02f, 3.63099538e-02f, -9.09888744e-02f, -1.84464920e-02f, -9.82647091e-02f, -6.26089275e-02f, 1.59328029e-01f, 1.76499095e-02f, 2.44759023e-02f,
  2.08043866e-02f, -1.77349791e-01f, -1.58941582e-01f, 4.20834720e-02f, 1.37447134e-01f, -5.71102463e-02f, -1.22729212e-01f, -2.67957710e-02f, -3.70856449e-02f, 4.04876061e-02f,
  -1.18851000e-04f, -1.37705328e-02f, -6.51354715e-03f, 6.98069558e-02f, 6.30999580e-02f, -3.85354348e-02f, 5.37738577e-02f, 1.34236850e-02f, -1.76202110e-03f, 1.19664920e-02f,
  -3.52334380e-02f, -2.97135692e-02f, 4.38910574e-02f, -3.13037820e-03f, 7.40314741e-03f, -8.07019398e-02f, -3.35815214e-02f, 1.63523871e-02f, -1.41355157e-01f, -5.69198001e-03f,
  -2.02251337e-02f, -9.95125473e-02f, -1.57488391e-01f, -5.52223660e-02f, -1.12697728e-01f, -3.13837938e-02f, 1.89531576e-02f, -4.19996306e-02f, 4.82799998e-03f, -1.12806268e-01f,
  -1.04040941e-02f, -2.98293203e-01f, 1.94866017e-01f, 1.40156850e-01f, -9.88789573e-02f, -7.97728747e-02f, 7.58386999e-02f, 5.75120002e-03f, -1.05999373e-01f, 7.11314902e-02f,
  -7.25525171e-02f, -8.60781074e-02f, 5.94363995e-02f, -4.51562777e-02f, -1.08567126e-01f, -8.22867267e-03f, 5.95872588e-02f, 7.73214400e-02f, 3.09393406e-02f, -8.41858834e-02f,
  -3.62120569e-02f, -8.35690647e-02f, -1.28905205e-02f, 7.27040470e-02f, -3.81980501e-02f, 5.55708166e-03f, -2.24718563e-02f, -7.80882537e-02f, -1.45216361e-01f, 2.14454103e-02f,
  4.37715203e-01f, 1.92236677e-01f, 3.75813007e-01f, -1.13206953e-02f, -1.11359142e-01f, -4.47999686e-03f, 1.73348978e-01f, 8.06433856e-02f, -1.23681366e-01f, -2.90085543e-02f,
  -1.61013275e-01f, -6.96448162e-02f, -6.54587820e-02f, 2.17007287e-02f, 1.56924963e-01f, 1.45867601e-01f, 1.46544591e-01f, 2.78406620e-01f, 1.10881366e-01f, 3.66500142e-04f,
  -1.97733894e-01f, 1.84530884e-01f, 3.39048743e-01f, 4.00860310e-02f, -1.36261731e-01f, -5.32036535e-02f, -5.53068565e-03f, 2.63602622e-02f, -5.32940514e-02f, -1.04267366e-01f,
  -1.48439124e-01f, 3.65389168e-01f, -6.21586181e-02f, -1.12582020e-01f, 6.24625431e-03f, -2.81219073e-02f, -7.00313374e-02f, 4.02653106e-02f, -3.70866768e-02f, -3.68121117e-02f,
  -1.39168454e-02f, -3.63759161e-03f, -2.57762931e-02f, 7.31298402e-02f, -4.01642360e-02f, -7.12189600e-02f, 1.19794369e-01f, 2.87500143e-01f, 1.24973677e-01f, 6.41406029e-02f,
  -1.74611673e-01f, -1.37117669e-01f, 1.60753444e-01f, 2.90359147e-02f, 1.64927885e-01f, -5.75794168e-02f, 9.22292322e-02f, 7.58415982e-02f, -2.21786294e-02f, 1.77793223e-02f,
  -6.09725295e-03f, 5.67086115e-02f, 3.20282616e-02f, 6.86237067e-02f, -3.79979387e-02f, 2.95138825e-02f, -4.35150741e-03f, -4.55425829e-02f, -2.41904017e-02f, 7.15843141e-02f,
  5.79946190e-02f, 4.45777327e-02f, 1.89690739e-02f, -1.01500321e-02f, -2.12081615e-02f, 3.29344459e-02f, -1.82640161e-02f, -9.09029692e-03f, 7.27770180e-02f, -4.46499474e-02f,
  1.07308254e-01f, 1.31907269e-01f, -3.13794240e-02f, 4.77492549e-02f, -2.50098705e-02f, -2.60439739e-02f, -2.32850779e-02f, 7.81076327e-02f, -3.75612043e-02f, 3.66842858e-02f,
  -1.87750146e-01f, 1.73609808e-01f, -2.18987912e-01f, 6.13442548e-02f, -8.90010372e-02f, -2.07841434e-02f, -1.27433255e-01f, -7.08940718e-03f, -8.41035228e-03f, 4.98069003e-02f,
  7.74602732e-03f, 2.90701650e-02f, -7.35312933e-03f, 2.56938767e-02f, -1.28040746e-01f, -2.77772825e-02f, -1.04940988e-01f, -2.40341499e-02f, 9.04040039e-02f, -1.00275978e-01f,
  -1.45636782e-01f, -1.12053528e-01f, -1.72475412e-01f, -1.79819405e-01f, -9.31953713e-02f, -2.18725339e-01f, -8.40812400e-02f, -1.12161346e-01f, 1.16870590e-02f, -6.99837208e-02f,
  1.05315849e-01f, 5.47747463e-02f, 8.66074208e-03f, 6.34931326e-02f, -3.16146910e-02f, 2.02148743e-02f, 5.43049071e-04f, -7.26645514e-02f, 1.01949256e-02f, 1.36487439e-01f,
  1.08112469e-01f, 2.98063576e-01f, 2.26353899e-01f, 7.33485520e-02f, 1.15119532e-01f, 2.34173406e-02f, 3.13630551e-02f, 1.36288570e-03f, 1.28019288e-01f, 8.75440463e-02f,
  1.58302769e-01f, -6.58684671e-02f, 4.08449247e-02f, -6.76883981e-02f, 1.30142584e-01f, 9.99279320e-02f, 7.68488795e-02f, 1.92037281e-02f, 1.43600374e-01f, 1.20817438e-01f,
  3.26924354e-01f, 8.32249969e-02f, 6.84497133e-03f, -8.40261132e-02f, -1.18696317e-02f, -8.81394744e-02f, -6.21189773e-02f, -8.11298266e-02f, -4.10549007e-02f, -1.14772804e-01f,
  -7.23235086e-02f, 6.62425626e-03f, 3.99988182e-02f, -3.29381973e-02f, 2.67759003e-02f, -8.17553475e-02f, -9.91400518e-03f, -9.19976905e-02f, -2.47576963e-02f, 4.21498157e-02f,
  1.15347654e-01f, 8.79103839e-02f, -3.59731019e-02f, -3.44685018e-02f, 4.88965549e-02f, -2.48356145e-02f, -8.09891894e-02f, 1.00713238e-01f, -1.69545580e-02f, -1.14250164e-02f,
  1.37519017e-01f, 1.75159618e-01f, 4.64490913e-02f, -4.37662564e-02f, 1.49787575e-01f, 3.36035178e-03f, 6.04574718e-02f, 6.05490990e-02f, 4.30102907e-02f, 6.78957999e-02f,
  3.97866480e-02f, 1.68956127e-02f, -6.79708198e-02f, 5.34771681e-02f, 3.66678499e-02f, -5.85588925e-02f, -4.55895215e-02f, 3.55579443e-02f, 8.78542587e-02f, 4.24955338e-02f,
  9.39715654e-02f, -1.74239744e-02f, 4.41706739e-02f, 6.27844259e-02f, -1.26176709e-02f, 1.16437227e-01f, 1.02814548e-01f, -7.67162517e-02f, 1.35891391e-02f, 1.14187133e-02f,
  -1.09283142e-01f, -1.92525592e-02f, 1.88233867e-01f, 5.27267754e-02f, 5.24020977e-02f, -6.13057390e-02f, 2.55257394e-02f, -1.35775015e-01f, -2.20594350e-02f, -9.71977711e-02f,
  3.48073542e-02f, -1.41174474e-03f, -1.73217058e-02f, -1.05653005e-02f, 9.90128983e-03f, -5.62029742e-02f, -3.54909487e-02f, 5.40512241e-02f, -1.71537045e-02f, -1.04962952e-01f,
  -1.96348410e-02f, -1.54530972e-01f, 2.02500392e-02f, 3.80340591e-02f, -4.29462194e-02f, 1.32657113e-02f, -2.21289601e-02f, 5.04505001e-02f, -1.05526648e-01f, -6.59768730e-02f,
  2.29531035e-01f, 3.03306192e-01f, 2.95373112e-01f, -6.51038289e-02f, 1.31144509e-01f, 3.08641553e-01f, 4.06307846e-01f, 8.30447301e-02f, -1.63611382e-01f, 7.98685849e-02f,
  8.96807984e-02f, -1.80001780e-01f, -1.59970596e-01f, -1.75107032e-01f, -1.58604980e-02f, 9.11967736e-03f, -5.70563488e-02f, 2.45512817e-02f, -2.64394339e-02f, 9.33731496e-02f,
  -1.05114885e-01f, -7.34734833e-02f, 7.12937117e-03f, -9.47011113e-02f, -1.89059779e-01f, -2.91478872e-01f, 2.52437852e-02f, 1.78363025e-01f, 1.68659225e-01f, -1.83716685e-01f,
  -4.59032431e-02f, 4.23372239e-01f, -2.08186343e-01f, -7.87907839e-02f, 1.22992449e-01f, 1.08681363e-03f, -9.18218959e-03f, 3.72246467e-02f, 1.48506816e-02f, -7.30975345e-02f,
  3.87313291e-02f, -2.96142511e-02f, 5.74900489e-03f, -1.56924594e-02f, 1.48261592e-01f, 1.00149713e-01f, -2.85556000e-02f, -3.90182845e-02f, -4.45901267e-02f, 1.16955161e-01f,
  -8.41733292e-02f, 2.04827115e-01f, 2.61183977e-01f, 6.91082552e-02f, 3.62424627e-02f, -1.53087646e-01f, 4.36764285e-02f, 7.64951459e-04f, 5.54701500e-02f, -7.06863850e-02f,
  -1.00926302e-01f, -2.70715207e-02f, 2.72956993e-02f, -6.97366968e-02f, -6.32592440e-02f, -9.62960795e-02f, 2.57705562e-02f, 7.55293891e-02f, -1.62685271e-02f, -3.00029851e-02f,
  -2.00879537e-02f, 3.70113216e-02f, -4.03018780e-02f, -1.47397453e-02f, -2.12687343e-01f, 4.05653603e-02f, 8.09828117e-02f, 3.14168707e-02f, 9.16626826e-02f, 2.01632008e-02f,
  1.10002095e-02f, 1.08605158e-02f, -1.52012771e-02f, -5.45883849e-02f, 4.36055213e-02f, -1.23066582e-01f, -4.17860486e-02f, -1.09611727e-01f, -6.08156584e-02f, -3.79078425e-02f,
  -3.00876707e-01f, 2.50909925e-01f, -1.76509604e-01f, -1.40857816e-01f, 1.97389591e-02f, 3.65549140e-02f, -6.11612275e-02f, -1.08073456e-02f, 1.72004029e-02f, -6.34756014e-02f,
  1.21419370e-01f, 1.08477458e-01f, 3.42154875e-02f, -4.32198234e-02f, -5.12327254e-02f, 1.83638849e-03f, 2.40479596e-02f, -1.08285740e-01f, -4.49290238e-02f, 6.30855709e-02f,
  -1.74269360e-02f, -1.81120094e-02f, -1.28537446e-01f, -9.52605978e-02f, -1.38495028e-01f, -1.64133877e-01f, -1.27216056e-01f, -1.65266886e-01f, -7.05192611e-03f, -3.52074593e-01f,
  -5.04379511e-01f, 3.32818598e-01f, 2.53254026e-01f, -1.80445388e-01f, 3.30559863e-03f, 1.13595851e-01f, 3.69769394e-01f, 1.28407136e-01f, 5.18750399e-02f, 2.24066183e-01f,
  6.14350662e-02f, -1.13909535e-01f, -8.25678706e-02f, -2.74837893e-02f, -5.50790131e-03f, 2.86809891e-01f, 2.20185876e-01f, -2.30467111e-01f, -3.52370799e-01f, -3.77089798e-01f,
  -9.69501138e-02f, -2.09576845e-01f, -3.94812256e-01f, -1.53277248e-01f, -2.22895797e-02f, -1.73716217e-01f, 6.82715550e-02f, -1.44760594e-01f, 3.91628630e-02f, -1.50394469e-01f,
  -3.99311110e-02f, -1.12662040e-01f, -2.06594378e-01f, -2.02594876e-01f, 9.18818116e-02f, 5.77799091e-03f, -4.50299010e-02f, -4.58348468e-02f, 2.54304931e-02f, -3.73792052e-02f,
  9.46204923e-03f, -1.17002167e-01f, -1.14148453e-01f, -2.71473266e-02f, -1.18834220e-01f, -2.45320853e-02f, -3.60946245e-02f, -1.80210158e-01f, -7.17934500e-03f, -6.06218018e-02f,
  5.14761955e-02f, -1.87257398e-02f, -5.27560562e-02f, -6.48904517e-02f, -1.33482562e-02f, -3.99002023e-02f, -2.96628866e-02f, -1.77262336e-01f, -7.90225044e-02f, -2.42480114e-01f,
  -6.79359436e-02f, 6.87351376e-02f, -6.97985291e-03f, -5.80799468e-02f, 5.63770942e-02f, 4.04550098e-02f, -2.66586281e-02f, -4.48984951e-02f, -2.24642754e-02f, 2.56925505e-02f,
  -5.05403131e-02f, 5.33499159e-02f, 1.52356867e-02f, 5.02998801e-03f, -1.04371412e-02f, 8.46080482e-03f, -5.92470355e-03f, 9.13501978e-02f, 3.91128398e-02f, 3.99233885e-02f,
  -7.57037103e-02f, -3.71588953e-02f, 3.30492072e-02f, -9.53246653e-02f, 9.67912674e-02f, 5.14222793e-02f, 1.07573986e-01f, -8.46697986e-02f, 2.21463554e-02f, 8.65578875e-02f,
  -8.79173428e-02f, 1.94800884e-01f, -4.54626083e-02f, -1.44886971e-01f, 3.14449482e-02f, -1.74525995e-02f, -1.45874382e-03f, -1.07152313e-02f, 1.22123724e-02f, -6.90391883e-02f,
  -7.09415600e-02f, -7.78375268e-02f, 8.89900178e-02f, -9.74206924e-02f, -1.05130404e-01f, -5.64169511e-02f, 9.53792706e-02f, -4.85136807e-02f, -2.36682058e-03f, 1.12032183e-01f,
  -6.96549052e-03f, -1.00705914e-01f, -2.28523433e-01f, -4.34920117e-02f, 3.88994738e-02f, -2.40367338e-01f, -1.51486769e-01f, -1.68508485e-01f, -6.15616888e-02f, -8.50220099e-02f,
  -1.25705078e-01f, -2.56737977e-01f, -2.85394251e-01f, -2.04852641e-01f, -5.62539101e-02f, 9.05939960e-04f, 6.46772087e-02f, 7.28276670e-02f, 2.13932022e-02f, -8.55870694e-02f,
  -1.39711961e-01f, 4.34674509e-02f, -5.18398844e-02f, -4.61510103e-03f, -6.66024163e-02f, -1.12382710e-01f, -2.28416920e-01f, -1.03380539e-01f, 2.22162396e-01f, 2.29815796e-01f,
  1.02817357e-01f, -4.39582318e-02f, -8.52264836e-02f, -1.07499249e-01f, -8.17594677e-02f, -1.13830715e-02f, -2.26555824e-01f, -1.57841265e-01f, -1.21047609e-01f, -2.26506755e-01f,
  2.55214602e-01f, -1.41741633e-01f, 3.31745949e-03f, -5.39976098e-02f, -6.80153817e-02f, -8.98103341e-02f, -5.91452308e-02f, -1.34433329e-01f, -1.41086560e-02f, -2.06199568e-02f,
  -9.78966355e-02f, -2.95296628e-02f, 7.92307928e-02f, -2.58641373e-02f, 5.29728644e-02f, 6.79330006e-02f, -1.26987949e-01f, -1.24010267e-02f, -8.82556438e-02f, -2.83856895e-02f,
  -1.26977012e-01f, -5.45466579e-02f, -2.23890804e-02f, -6.56953752e-02f, -8.21782872e-02f, -1.23441987e-01f, 3.29993502e-03f, 7.16837943e-02f, -9.95227471e-02f, -3.47630456e-02f,
  1.72578245e-02f, -2.37987693e-02f, 6.75318614e-02f, -1.62724182e-02f, -9.56041645e-03f, -3.53459455e-03f, 4.99717556e-02f, 4.40920368e-02f, 8.04034546e-02f, 1.30149331e-02f,
  6.72636777e-02f, -8.49266127e-02f, 5.39295888e-03f, -4.04119603e-02f, -6.98892325e-02f, 1.75784733e-02f, -1.08314911e-02f, -1.24151129e-02f, -2.60969065e-02f, -2.98556616e-03f,
  2.58492418e-02f, -1.64929044e-03f, 3.19218151e-02f, -1.02199977e-02f, -2.08170265e-02f, -2.02278234e-02f, -4.57410961e-02f, -6.17235415e-02f, -3.16556506e-02f, -4.28970233e-02f,
  3.44788700e-01f, -2.49430656e-01f, -3.83063145e-02f, 7.76404962e-02f, -1.45248979e-01f, -1.05594158e-01f, -1.17592216e-01f, -8.70896354e-02f, -1.46502957e-01f, 9.53360721e-02f,
  7.93821290e-02f, 1.03109688e-01f, -3.89457978e-02f, 1.11828454e-01f, 1.50641695e-01f, 2.81654056e-02f, -1.50369189e-04f, -1.06548145e-01f, -2.03750338e-02f, 2.19256468e-02f,
  -1.37214929e-01f, -1.80798732e-02f, 3.19195241e-02f, -4.23529297e-02f, -8.98433384e-03f, 2.96969842e-02f, 1.00018397e-01f, 1.79080665e-01f, -2.37230249e-02f, 1.96666852e-01f,
  -8.36073101e-01f, 1.38086140e-01f, 1.92207813e-01f, -4.39112663e-01f, -1.41807646e-01f, -8.42317194e-02f, 1.71996504e-01f, -1.65815711e-01f, -2.46634156e-01f, -5.21867089e-02f,
  1.08097874e-01f, -5.21764942e-02f, 6.77995011e-02f, 7.80324563e-02f, -4.97403331e-02f, 1.27492920e-01f, -6.72417751e-04f, -8.46765190e-02f, -1.05278201e-01f, -8.71872976e-02f,
  -1.64185420e-01f, -2.69483894e-01f, -3.67235363e-01f, -1.31045327e-01f, -4.75018881e-02f, -3.26491967e-02f, 5.99447712e-02f, -9.50364769e-02f, 6.96076304e-02f, 6.52570426e-02f,
  6.16947055e-01f, -2.57831663e-01f, -3.51565294e-02f, -1.26490325e-01f, 8.95207003e-02f, -1.09369352e-01f, 2.63974071e-02f, -3.27464640e-02f, -1.20593823e-01f, 3.83665599e-02f,
  2.58444790e-02f, -9.76169333e-02f, -1.13491744e-01f, 6.06662855e-02f, -1.89865585e-02f, -7.21602142e-02f, -1.46568075e-01f, -5.04784659e-02f, 6.04171902e-02f, 6.88871294e-02f,
  5.49321296e-03f, -1.23124667e-01f, 1.35915233e-02f, 8.86696428e-02f, 2.60608401e-02f, -1.30758122e-01f, 1.41935021e-01f, -3.13956290e-02f, 3.72483744e-03f, 2.70374306e-02f,
  3.16076688e-02f, 6.09820262e-02f, 3.31978463e-02f, -2.93915793e-02f, -4.25471738e-02f, 2.62112860e-02f, -1.35721406e-02f, 9.09325331e-02f, -7.31581822e-02f, 3.42281014e-02f,
  -6.82381243e-02f, 2.43047103e-02f, 2.36988626e-02f, 2.86449604e-02f, 3.42313275e-02f, -8.72191601e-03f, 7.20993197e-03f, 6.74604550e-02f, 6.28674999e-02f, -1.02263436e-01f,
  -6.77552596e-02f, -5.48925297e-03f, -6.32896423e-02f, 7.70111829e-02f, 7.63608962e-02f, -1.17216915e-01f, -9.91147161e-02f, 7.19078258e-02f, -2.41581127e-02f, -4.32534628e-02f,
  2.21918866e-01f, -1.90144610e-02f, 2.32602488e-02f, -6.49521053e-02f, 2.96210833e-02f, -4.38166410e-02f, 7.18216971e-02f, -6.20185062e-02f, -6.61517158e-02f, -2.23209653e-02f,
  -3.62169975e-03f, 3.98165034e-03f, -1.56497695e-02f, 1.48606524e-02f, 3.25190695e-03f, -2.31657680e-02f, 4.08346020e-02f, -6.33281022e-02f, 1.34410569e-02f, -2.83092670e-02f,
  1.04392484e-01f, -4.39625829e-02f, 1.51356794e-02f, 2.39037499e-01f, 8.71385187e-02f, 2.93317647e-03f, 1.71075761e-01f, 9.46107581e-02f, 1.49556711e-01f, 1.50372460e-01f,
  -2.00499296e-01f, -5.21980345e-01f, -4.14742231e-01f, -3.68958265e-01f, -2.94787884e-01f, 1.93293300e-02f, -1.51114792e-01f, -1.23937488e-01f, -1.11201651e-01f, -4.35569227e-01f,
  -1.10772163e-01f, 1.17713287e-01f, -7.03346804e-02f, 7.46534765e-02f, 3.61075960e-02f, -3.36720914e-01f, -3.06467116e-01f, 3.97812901e-03f, 2.51751959e-01f, 7.69185741e-03f,
  -1.07036904e-01f, -3.15590173e-01f, -6.96747079e-02f, -6.42086416e-02f, -3.49774480e-01f, -1.35185510e-01f, -3.89485359e-01f, -3.08977246e-01f, -1.96234211e-01f, -3.25144589e-01f,
  -3.31751496e-01f, 1.61791369e-01f, 1.09899677e-01f, 8.67898911e-02f, -1.17065743e-01f, 1.40307143e-01f, -7.69746527e-02f, 5.41527160e-02f, 2.06133835e-02f, -1.10610545e-01f,
  -8.31774101e-02f, 1.44707020e-02f, -4.86977473e-02f, 3.93320359e-02f, -1.21111386e-01f, 2.69521959e-02f, -9.41933021e-02f, 8.69193524e-02f, 6.83108941e-02f, -9.05926302e-02f,
  -1.53728008e-01f, 4.10097986e-02f, 1.23143112e-02f, 1.32074952e-03f, 1.03048354e-01f, 1.08424790e-01f, -4.14026864e-02f, 2.50299368e-03f, 1.25332206e-01f, -3.18338096e-01f,
  -1.79818198e-01f, -1.97083363e-03f, 7.43442625e-02f, 2.16740482e-02f, -3.87649774e-03f, 3.12216748e-02f, -4.67911549e-02f, -3.07290461e-02f, -7.25392178e-02f, -1.02425605e-01f,
  -3.79521446e-03f, -5.35969287e-02f, 2.17653699e-02f, 5.40049700e-03f, -5.45210429e-02f, 1.43929254e-04f, 2.09514368e-02f, -9.14567113e-02f, 2.79873963e-02f, -5.75458119e-03f,
  3.10452171e-02f, -2.70901844e-02f, -7.66393840e-02f, 2.47756243e-02f, -1.81683770e-03f, -7.68015981e-02f, -1.85234826e-02f, 9.87491310e-02f, 1.43446615e-02f, 9.77604762e-02f,
  -3.36937815e-01f, 4.61163402e-01f, -1.23985671e-01f, 1.99673939e-02f, -2.24511735e-02f, 2.23344751e-02f, -1.48054019e-01f, -3.67872529e-02f, 1.23563670e-01f, -6.12280704e-02f,
  6.79551661e-02f, -8.20465982e-02f, -1.90010756e-01f, 9.58041940e-03f, 2.59698685e-02f, -4.13289890e-02f, -1.45465970e-01f, -1.06264476e-03f, 1.72818691e-01f, -1.15648108e-02f,
  -1.85503036e-01f, -1.07209779e-01f, 5.81797548e-02f, 3.96500751e-02f, 3.15903164e-02f, 9.75247845e-02f, -1.04435347e-01f, -1.21953366e-02f, 3.33516151e-02f, -4.09021616e-01f,
  1.29295746e-03f, -1.98477596e-01f, -2.47370631e-01f, 1.38844043e-01f, -7.84397200e-02f, -3.39492500e-01f, -2.90129423e-01f, -3.24861426e-03f, 3.62551957e-02f, -4.36753221e-02f,
  -1.27689958e-01f, -4.45487760e-02f, -7.59164989e-02f, -3.01646858e-01f, -3.32295567e-01f, -3.29016298e-01f, -1.97046638e-01f, -3.90273392e-01f, -3.43573511e-01f, -3.31931949e-01f,
  -2.33391508e-01f, -7.74692968e-02f, 2.74909078e-04f, -6.12759106e-02f, 1.13193691e-01f, 1.11952394e-01f, 7.96878934e-02f, 2.43884064e-02f, -2.46936664e-01f, 4.13304940e-02f,
  -2.27272227e-01f, -1.93449538e-02f, -1.01988733e-01f, 9.54064261e-03f, 5.62406443e-02f, 2.21701842e-02f, -3.86105739e-02f, 1.39792189e-02f, -5.63400649e-02f, -6.87167495e-02f,
  -6.10831268e-02f, -1.06802970e-01f, -3.23587768e-02f, 3.30101768e-03f, -8.10704008e-02f, -1.54213877e-02f, -3.90682444e-02f, 2.25180294e-03f, -1.14469409e-01f, -2.83966288e-02f,
  -9.98834148e-02f, -2.21028298e-01f, -7.13048577e-02f, 1.39709283e-02f, -2.54368633e-02f, 3.04880203e-03f, -1.78157929e-02f, 7.77699500e-02f, 2.26840135e-02f, 1.98021695e-01f,
  -6.76192567e-02f, 1.06606595e-02f, 3.71035226e-02f, 2.26494297e-02f, 5.52000254e-02f, -1.21985879e-02f, 4.17852571e-04f, -1.23711117e-01f, 2.53008436e-02f, -3.82982194e-03f,
  2.73651220e-02f, 3.24976817e-02f, -4.22191061e-02f, 6.74390048e-02f, -2.27203406e-02f, -4.88989502e-02f, -1.01330556e-01f, -6.36223182e-02f, -3.26221399e-02f, 4.08592485e-02f,
  -5.99305071e-02f, 2.48752292e-02f, 3.47457826e-02f, 2.81198695e-02f, -3.96296270e-02f, 1.08691622e-02f, -5.67586012e-02f, 5.45390770e-02f, 6.79131299e-02f, 6.93206787e-02f,
  3.69951725e-01f, -2.53046900e-01f, 4.35652211e-03f, -4.24651131e-02f, -1.68523435e-02f, 2.94428878e-02f, 1.71220191e-02f, -3.64483247e-04f, -5.89712001e-02f, -1.12311900e-01f,
  -9.00473371e-02f, 3.90961133e-02f, 9.19989720e-02f, -6.49690628e-02f, -3.81111577e-02f, -3.70342247e-02f, -6.84618130e-02f, -8.25046655e-03f, -1.36576453e-02f, 6.76304698e-02f,
  -6.10103598e-03f, -1.44541755e-01f, -1.99976981e-01f, -5.19781411e-02f, 3.42528336e-02f, -1.33111864e-01f, -1.24366097e-01f, -1.95292830e-02f, -1.88908651e-01f, 8.84802490e-02f,
  -2.43991733e-01f, -4.99767661e-02f, -3.59937906e-01f, -4.93070960e-01f, -2.19724685e-01f, 8.01309571e-02f, 1.56650841e-01f, 2.98936199e-02f, -2.27058068e-01f, -1.83559582e-01f,
  8.93614441e-03f, -5.84819689e-02f, -1.35766625e-01f, 1.80907547e-03f, 1.50115207e-01f, 3.49949263e-02f, -1.13085285e-01f, -1.87356472e-01f, -2.20860355e-02f, 1.02577664e-01f,
  -7.33860657e-02f, -2.76590466e-01f, -2.13398755e-01f, -1.62209690e-01f, -3.10946405e-01f, -1.23542294e-01f, -3.70782465e-01f, -2.69562185e-01f, 2.59047225e-02f, -3.20512384e-01f,
  -2.68689960e-01f, -1.11778878e-01f, 2.13611145e-02f, 1.02864958e-01f, -2.17390478e-01f, -6.36300668e-02f, 1.60181355e-02f, -1.82186306e-01f, -4.33486812e-02f, -1.25934854e-01f,
  -6.38769418e-02f, 4.26519960e-02f, -1.46314561e-01f, -7.06409886e-02f, -4.30084281e-02f, 5.15899844e-02f, -1.01655304e-01f, -1.14741229e-01f, 4.45600040e-02f, 1.33267239e-01f,
  1.31250635e-01f, 7.35975103e-03f, 6.41486198e-02f, 4.79357876e-02f, -5.17788902e-02f, -1.13229230e-02f, 5.45443147e-02f, 4.35776301e-02f, -1.78539213e-02f, -1.08263671e-01f,
  8.91902223e-02f, 8.85781273e-03f, 1.15411275e-03f, 1.01769362e-02f, 1.73564572e-02f, -3.98067608e-02f, -7.98997376e-03f, 4.81550656e-02f, -5.65419793e-02f, 5.26341982e-02f,
  3.83624025e-02f, 7.75390714e-02f, 2.13430189e-02f, -6.03311062e-02f, 2.32955553e-02f, 2.47621443e-02f, 1.88697223e-02f, 4.01354320e-02f, 4.62967828e-02f, -2.89621428e-02f,
  3.77738662e-02f, 1.46145774e-02f, -3.66230793e-02f, -4.57652509e-02f, 5.84934279e-02f, -1.24128032e-02f, 4.56906818e-02f, 1.33197308e-01f, 2.27422621e-02f, 5.02619110e-02f,
  -2.09395543e-01f, 1.43980309e-01f, 1.37417950e-02f, 8.40604901e-02f, -1.79980025e-01f, -4.05493490e-02f, -1.07837491e-01f, 3.72137665e-03f, -1.36358455e-01f, -4.99358103e-02f,
  7.23277628e-02f, 3.90538201e-02f, -3.85670550e-02f, 8.19666758e-02f, -4.16967236e-02f, 9.48951170e-02f, 2.88016591e-02f, -9.66766402e-02f, 3.09772864e-02f, -7.52179185e-03f,
  8.34449157e-02f, 1.14509195e-01f, 1.14485182e-01f, 2.19903514e-02f, 1.32215116e-02f, 8.24389756e-02f, 5.32513075e-02f, 7.75294527e-02f, 1.28216013e-01f, 1.27905816e-01f,
  7.20812917e-01f, 4.99835201e-02f, -2.14457676e-01f, 2.06697688e-01f, -9.37748849e-02f, -1.37824267e-01f, -1.34439692e-01f, 1.90725308e-02f, 1.04607165e-01f, 6.59618825e-02f,
  -1.28429964e-01f, -6.54881895e-02f, -1.99732427e-02f, -1.89633310e-01f, -1.23108529e-01f, 2.41136774e-02f, -3.19201015e-02f, -4.22659181e-02f, -2.02215925e-01f, -2.34896109e-01f,
  -8.77415687e-02f, 1.49766952e-02f, 1.00791864e-02f, -2.95053143e-02f, -1.16321981e-01f, -1.02312014e-01f, -1.42460186e-02f, -1.77416608e-01f, -3.19647819e-01f, -1.06647216e-01f,
  -3.64345759e-01f, -5.61404116e-02f, -1.53200909e-01f, 8.17525610e-02f, -6.92434832e-02f, 1.25339329e-01f, 2.57014688e-02f, 1.01712324e-01f, 7.07723498e-02f, -2.07787324e-02f,
  -9.53949615e-02f, 3.02258432e-02f, 2.17532180e-02f, -8.72743428e-02f, 5.60558550e-02f, -1.03871219e-01f, 5.40832132e-02f, -6.78313524e-02f, -7.16287717e-02f, -6.26815706e-02f,
  -1.54079407e-01f, -9.17236581e-02f, 4.70247604e-02f, -6.32750541e-02f, -2.16170728e-01f, -4.93824147e-02f, -1.98089078e-01f, -1.68609455e-01f, -5.65022975e-02f, 2.98990346e-02f,
  -4.20038402e-02f, -1.26514044e-02f, -1.25272095e-01f, 2.59560160e-02f, 2.47566886e-02f, -2.91895475e-02f, 9.15727019e-02f, -5.41954476e-04f, -2.61099823e-02f, 9.23743993e-02f,
  -1.61108635e-02f, -1.74198055e-03f, -6.11418374e-02f, 1.39626563e-01f, -5.26676737e-02f, -2.71995030e-02f, 4.96034697e-02f, 3.61608751e-02f, -4.16046306e-02f, 1.54344095e-02f,
  2.23020446e-02f, -8.30552056e-02f, -6.98614717e-02f, -4.06233072e-02f, -5.68895601e-04f, -2.62553934e-02f, 7.62074068e-03f, -6.14890009e-02f, 2.72183511e-02f, -6.10011891e-02f,
  2.06324503e-01f, -7.14481808e-03f, 6.33564591e-02f, -6.86391396e-03f, -1.13579603e-02f, -2.41715927e-02f, -5.41791320e-02f, -4.23401631e-02f, -9.18546766e-02f, -4.25826684e-02f,
  -1.96470559e-01f, -4.51102704e-02f, -4.60136421e-02f, -8.97488743e-02f, -1.77655872e-02f, -4.98452149e-02f, 2.22398937e-01f, 5.20042889e-02f, -2.40705572e-02f, -3.00907828e-02f,
  1.17885828e-01f, 1.87327430e-01f, 3.50238025e-01f, 2.42584735e-01f, -9.40734148e-02f, 1.53678536e-01f, 7.41652846e-02f, -1.33502958e-02f, 1.24830134e-01f, 4.75459099e-01f,
  8.89204815e-02f, 1.91508189e-01f, 1.14982769e-01f, 3.10593069e-01f, 9.01429877e-02f, -2.55411714e-01f, -3.50183308e-01f, -4.45106059e-01f, 1.57477912e-02f, 4.50639613e-02f,
  2.45154142e-01f, 1.15243167e-01f, 2.07371078e-03f, -2.17044055e-01f, -4.58164424e-01f, -1.77768469e-01f, 1.88404210e-02f, -2.19421670e-01f, -3.26012164e-01f, -1.65134773e-01f,
  1.48251265e-01f, -3.91853100e-04f, -7.62504200e-03f, -1.96643383e-03f, 2.86874592e-01f, 6.85198531e-02f, 1.47699833e-01f, 1.66849837e-01f, 8.88197720e-02f, 4.20846522e-01f,
  3.37248057e-01f, 2.33269721e-01f, -2.24247769e-01f, 1.14081010e-01f, 1.67859480e-01f, 1.48919562e-03f, -6.56876117e-02f, 1.46698691e-02f, -3.84628065e-02f, -6.12180941e-02f,
  2.35652059e-01f, 8.99696350e-02f, 1.39209166e-01f, 3.73177081e-02f, -5.30940406e-02f, -7.20018893e-02f, -1.09023266e-01f, -2.15708449e-01f, -2.04544619e-01f, -7.29999170e-02f,
  2.05237791e-01f, 2.44858995e-01f, -8.18261430e-02f, -2.89703488e-01f, -1.86405182e-01f, -8.80971923e-02f, -9.67937410e-02f, -1.41262203e-01f, -3.02619368e-01f, -1.23926684e-01f,
  3.12060607e-03f, 2.33749188e-02f, 3.49267088e-02f, 3.16113862e-03f, -1.14745989e-01f, 6.73693642e-02f, 1.05561949e-01f, 4.32234220e-02f, -9.44163948e-02f, -4.28237915e-02f,
  -1.70373067e-04f, -7.87273943e-02f, -8.71651247e-03f, -4.40051481e-02f, 7.91179668e-03f, 8.66344869e-02f, 4.18932289e-02f, -1.15979873e-01f, -3.73238176e-02f, -4.07762900e-02f,
  3.61707546e-02f, -1.06325559e-02f, 6.21784069e-02f, -5.88925369e-02f, 5.29882498e-02f, -5.26570603e-02f, 4.15576948e-03f, -3.57362591e-02f, -7.60347769e-02f, 3.18979584e-02f,
  -8.07733685e-02f, -2.44945616e-01f, -3.46322954e-02f, -8.42746422e-02f, 1.10828795e-01f, -1.32089127e-02f, 4.23927903e-02f, 7.03994790e-03f, 7.27954134e-02f, -1.47974677e-02f,
  -3.08300965e-02f, -6.02576546e-02f, -6.99504018e-02f, -5.71631826e-02f, -1.14204034e-01f, -1.18891552e-01f, 1.23160360e-02f, -6.54826984e-02f, -7.91469291e-02f, 1.33654764e-02f,
  -1.73619285e-01f, -2.27506816e-01f, -2.54486620e-01f, -2.53040642e-01f, -1.16249464e-01f, -1.42695278e-01f, -2.41428778e-01f, -1.88295186e-01f, -4.25220817e-01f, -4.62259501e-01f,
  -4.35058117e-01f, -7.58222267e-02f, 5.32396883e-02f, -6.82423264e-02f, 2.95369118e-01f, 4.12677735e-01f, 3.85691971e-01f, 1.60201266e-01f, 1.29892742e-02f, -5.71007468e-03f,
  -1.43578619e-01f, -2.96283871e-01f, -2.45559514e-01f, -1.30976915e-01f, -1.70197919e-01f, 1.98554233e-01f, 2.64712602e-01f, -2.66224425e-02f, -4.06448804e-02f, 1.42318636e-01f,
  6.60970882e-02f, -7.00707361e-02f, -2.15684548e-01f, -1.74742699e-01f, -3.57934870e-02f, -1.32781982e-01f, -1.00283995e-01f, -7.12909177e-02f, -1.19796656e-02f, -1.22671919e-02f,
  2.76200362e-02f, -3.02706927e-01f, 5.01297787e-02f, -2.01762646e-01f, 4.35988232e-02f, -1.13498084e-01f, -3.24367732e-02f, -1.79655984e-01f, -1.05088197e-01f, -7.00885952e-02f,
  -1.64283365e-01f, -9.16607454e-02f, -1.30890965e-01f, -4.86596338e-02f, -5.88597767e-02f, 1.18253857e-01f, -6.32560775e-02f, -4.44322340e-02f, -1.24579355e-01f, 1.84442699e-02f,
  -5.95841818e-02f, -4.72235791e-02f, 4.74182740e-02f, 5.90373240e-02f, -8.49924162e-02f, 2.02334728e-02f, 1.58087183e-02f, -5.92288934e-02f, -8.18843618e-02f, 6.65989220e-02f,
  1.08147129e-01f, -3.65138315e-02f, 3.05508524e-02f, -4.82500084e-02f, -4.45867218e-02f, 1.07456911e-02f, 1.70668995e-03f, -6.30482286e-02f, -3.31135839e-02f, 2.58032866e-02f,
  -6.71763942e-02f, 3.10179777e-02f, -3.66211459e-02f, -5.44908047e-02f, -6.20051585e-02f, -9.33903009e-02f, 1.62495617e-02f, 2.14784034e-02f, 2.38281339e-02f, -5.44049367e-02f,
  -8.94754380e-02f, -5.19494005e-02f, -8.68334696e-02f, 1.79976597e-02f, 4.27298099e-02f, -1.89188998e-02f, 1.79512072e-02f, -1.20410010e-01f, 2.29309294e-02f, 2.26175343e-03f,
  -1.93757877e-01f, -5.94942011e-02f, -2.64441618e-03f, -4.36869636e-02f, -3.17682624e-02f, -3.89479361e-02f, -9.24000517e-02f, -5.41392565e-02f, -1.13426141e-01f, -9.17571783e-03f,
  -1.22162700e-01f, 5.26340958e-03f, -8.92238095e-02f, 9.61086303e-02f, 1.14723645e-01f, 2.55021527e-02f, 1.31226033e-01f, 5.14831692e-02f, 7.07839131e-02f, 2.73055788e-02f,
  9.68475565e-02f, 2.03018770e-01f, 1.21363960e-01f, 3.09800748e-02f, 1.12096272e-01f, -2.08322816e-02f, 2.44441703e-02f, 1.12206176e-01f, 1.35757774e-01f, 2.67141193e-01f,
  -6.67540848e-01f, 1.38619229e-01f, 2.95791384e-02f, 3.17530520e-02f, 3.49450231e-01f, 2.89852560e-01f, 1.54672980e-01f, 7.28353187e-02f, -6.87312335e-02f, 3.34247164e-02f,
  5.47976978e-02f, 5.10707833e-02f, 2.54629236e-02f, 6.15918972e-02f, 6.84221238e-02f, 1.78685069e-01f, 9.40077975e-02f, -1.28113125e-02f, -2.27109626e-01f, -1.00914143e-01f,
  1.93416968e-01f, -8.62246752e-02f, -2.13987917e-01f, -9.59203765e-02f, 1.02066979e-01f, 5.67448838e-03f, 1.94771755e-02f, 1.06664680e-01f, 2.20208820e-02f, 1.83896869e-01f,
  -2.84359008e-01f, -1.38074815e-01f, -1.02563761e-01f, -4.45084013e-02f, 9.52207856e-03f, -1.72863930e-01f, -1.50752049e-02f, -1.60945848e-01f, -3.92501764e-02f, -1.16289042e-01f,
  8.93534571e-02f, -7.63376802e-02f, 1.06317841e-01f, -1.39848329e-02f, -1.45282343e-01f, -1.35344058e-01f, -2.42172871e-02f, -1.72245845e-01f, -1.32368341e-01f, -6.22631870e-02f,
  1.71780720e-01f, 5.98048717e-02f, -5.55065945e-02f, 2.20189262e-02f, -6.15312643e-02f, 3.57146449e-02f, -1.42451644e-01f, -1.27440453e-01f, -1.75049439e-01f, -1.67946383e-01f,
  1.79043680e-03f, -1.19633116e-02f, 7.07808509e-03f, -2.26132968e-03f, 5.61689306e-03f, -1.40385367e-02f, 1.84562479e-04f, 1.20306704e-02f, 1.46090733e-02f, -1.55404303e-02f,
  9.59663764e-02f, -1.32231005e-02f, 3.62482332e-02f, -7.57102370e-02f, -2.77757011e-02f, 9.17997435e-02f, 1.28974123e-02f, 3.51779498e-02f, -1.97971817e-02f, 7.99294095e-03f,
  1.80561580e-02f, 2.82977764e-02f, -5.68357296e-02f, -1.30370473e-02f, 2.82563958e-02f, -6.95323423e-02f, -1.31721422e-02f, -4.73354273e-02f, 3.06447968e-02f, -9.59765464e-02f,
  -2.28613839e-01f, 3.96895707e-02f, -1.11633293e-01f, -5.98110221e-02f, 8.42810783e-04f, -3.91373560e-02f, 2.11045537e-02f, -7.32644796e-02f, 3.10489181e-02f, -9.62808058e-02f,
  3.70053798e-02f, -5.42292371e-02f, -3.62688266e-02f, 3.65143791e-02f, -3.78308222e-02f, -1.42482579e-01f, 1.81008652e-02f, -1.37571190e-02f, -1.05605043e-01f, -4.20252308e-02f,
  -4.05860543e-02f, -6.93407208e-02f, -2.87730902e-01f, -1.29835084e-01f, -1.21519886e-01f, -3.57368663e-02f, -1.56212211e-01f, -1.92374766e-01f, -1.28304794e-01f, -3.29367876e-01f,
  -3.51161361e-01f, -3.82203832e-02f, 2.62470067e-01f, -1.50401115e-01f, -2.02334195e-01f, -2.15495061e-02f, -9.61513631e-03f, -1.13528874e-02f, -1.19944312e-01f, -3.01834680e-02f,
  -1.18609831e-01f, -2.10341588e-01f, 9.56629030e-03f, 2.52500679e-02f, 1.47134453e-01f, 7.03318045e-02f, 2.36907095e-01f, 2.28156134e-01f, 1.29347801e-01f, 8.90134182e-03f,
  1.47688016e-02f, -1.19806938e-01f, 1.19595833e-01f, 4.15451042e-02f, -8.70697126e-02f, -2.88536400e-03f, 9.85512584e-02f, 3.05967461e-02f, -1.65347215e-02f, 4.01119143e-02f,
  -1.87706620e-01f, -5.12601845e-02f, -3.48255746e-02f, -2.02351939e-02f, 8.03311467e-02f, 1.65237077e-02f, 1.47158541e-02f, 1.12682832e-02f, 7.35694319e-02f, -1.87859219e-02f,
  -1.38159499e-01f, 4.46889699e-02f, 1.71493106e-02f, -5.37934527e-02f, 3.24287042e-02f, -7.97578916e-02f, 1.53441057e-01f, 7.57724196e-02f, 1.65060297e-01f, 7.16749504e-02f,
  2.64015291e-02f, -9.05819237e-02f, -1.59588739e-01f, 5.40622249e-02f, 1.09139252e-02f, -8.53683427e-02f, -6.33048080e-03f, -9.37241390e-02f, -2.42578033e-02f, -1.73138604e-01f,
  6.58317879e-02f, -4.52167019e-02f, 8.27070251e-02f, 1.42101105e-02f, -9.82026011e-03f, 3.51995938e-02f, 9.01611373e-02f, 9.05402079e-02f, -8.10439978e-03f, -6.64149970e-02f,
  7.19957948e-02f, -6.29848838e-02f, -7.88745061e-02f, -8.44282806e-02f, 6.95472537e-03f, -6.53696135e-02f, 1.58612970e-02f, -3.16230692e-02f, 6.76375180e-02f, 9.03386101e-02f,
  -3.32939848e-02f, -5.73688559e-02f, 4.89250496e-02f, 7.76689053e-02f, -1.87833997e-04f, 6.53605014e-02f, -2.99052130e-02f, -1.49470260e-02f, -4.75050062e-02f, -6.50893226e-02f,
  -1.61920726e-01f, 2.46483341e-01f, -5.09605110e-02f, -9.00276825e-02f, -6.71156645e-02f, 8.23075548e-02f, -1.02023028e-01f, -4.79512988e-03f, -5.41697107e-02f, -8.96682739e-02f,
  1.60373151e-02f, -3.55989821e-02f, 8.53491109e-03f, -5.52148931e-02f, -1.45227425e-02f, -1.08434379e-01f, -3.09059210e-02f, -7.55133405e-02f, 3.72406244e-02f, -1.35356868e-02f,
  -3.38218175e-03f, -1.73846081e-01f, -1.28691182e-01f, -1.01761922e-01f, -8.99352208e-02f, -1.12160221e-01f, -1.95513777e-02f, -1.23715654e-01f, -5.07306121e-02f, -1.65885791e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  3.50504100e-01f, 1.06159262e-01f, 3.29907984e-01f, 2.13620842e-01f, 1.09224476e-01f, 1.72319874e-01f, 3.42264771e-01f, 1.36239558e-01f, 3.04209948e-01f, 2.83085316e-01f,
  1.32571653e-01f, 2.21703872e-01f, 2.68126041e-01f, 1.70995846e-01f, 2.26769120e-01f, 5.38944960e-01f, 2.14425400e-01f, 3.68652880e-01f, 1.14489213e-01f, 1.40850246e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -4.94534194e-01f, -6.19322419e-01f, -3.79414231e-01f, -3.27160865e-01f, -4.76795346e-01f, -3.25158626e-01f, 1.82021081e-01f, 5.28874516e-01f, 3.18522453e-02f, -4.35640574e-01f,
  2.72373259e-01f, -8.73183385e-02f, -1.81084394e-01f, 3.69001895e-01f, -1.57207862e-01f, -1.42206207e-01f, -1.56655926e-02f, -1.42961666e-02f, -1.58653960e-01f, -1.72315672e-01f,
  1.03080951e-01f, -4.34618533e-01f, 5.61186612e-01f, -5.47493219e-01f, 8.87885034e-01f, 3.05244267e-01f, 3.77029061e-01f, -3.82376671e-01f, -2.44709015e-01f, -1.30004317e-01f,
  -1.32056758e-01f, -1.10957764e-01f, 6.55191183e-01f, 1.68634187e-02f, -3.16841304e-01f, -6.41387165e-01f, 3.97788316e-01f, 1.71345681e-01f, -1.04886621e-01f, 2.40116686e-01f,
  1.99102938e-01f, -8.49385083e-01f, -4.68955696e-01f, 5.47843695e-01f, -1.66934356e-01f, -3.67519468e-01f, -1.31249040e-01f, -3.40509892e-01f, 5.69449604e-01f, 3.88695270e-01f,
  9.05770734e-02f, 3.68657887e-01f, -2.50107050e-01f, -5.56887329e-01f, -5.68263009e-02f, -4.94697988e-01f, 9.07525361e-01f, -2.14088321e-01f, 4.62916821e-01f, 5.19555509e-01f,
  -4.60250527e-01f, -5.36130250e-01f, -2.19896853e-01f, -3.18353295e-01f, -2.42602248e-02f, 8.64493027e-02f, 5.09757757e-01f, 3.23543459e-01f, 4.63950843e-01f, -2.42837325e-01f,
  -6.02736354e-01f, 5.36951661e-01f, -2.37897143e-01f, -6.90235436e-01f, 3.58560294e-01f, -5.39309561e-01f, 7.28205562e-01f, 2.84087718e-01f, -8.22882913e-03f, 6.51785731e-01f,
  -3.86115521e-01f, -4.93157536e-01f, 3.50100368e-01f, -3.37984651e-01f, -1.35027124e-02f, -1.65591557e-02f, -2.31741473e-01f, -7.48261660e-02f, 1.05827369e-01f, 4.60774079e-02f,
  -3.64429891e-01f, -1.44725442e-01f, -3.65097612e-01f, -2.09360570e-01f, 8.31812620e-03f, 6.26569450e-01f, -2.67573893e-01f, -2.23391652e-02f, 1.67914227e-01f, 1.78871021e-01f,
  2.42203727e-01f, 7.84631521e-02f, 3.35978195e-02f, -1.22722194e-01f, 5.21582775e-02f, 3.85341376e-01f, -7.28389248e-02f, 1.78796202e-01f, -2.81502038e-01f, 1.61067113e-01f,
  -2.99479425e-01f, 3.98432672e-01f, -2.16757804e-01f, -3.68359774e-01f, -2.94856131e-01f, -2.64922917e-01f, 2.13161349e-01f, 7.47740686e-01f, -2.98284471e-01f, 5.01549661e-01f,
  3.69338185e-01f, -6.30532086e-01f, 7.87760496e-01f, -5.46383023e-01f, -2.31304169e-01f, 5.92218876e-01f, 2.89502203e-01f, 3.35776925e-01f, -6.34045541e-01f, 5.76285124e-01f,
  -1.34929538e-01f, -2.92384680e-02f, -5.42797267e-01f, -6.00578785e-02f, 5.59483588e-01f, -5.02519667e-01f, 4.84568208e-01f, 2.22352713e-01f, 5.14234483e-01f, -4.07733917e-01f,
  -3.68873775e-01f, 4.42551821e-01f, -1.74982026e-01f, -1.34934261e-01f, -1.84327930e-01f, 6.30009621e-02f, -2.89480507e-01f, -1.56873673e-01f, -1.05739161e-01f, 4.63640541e-01f,
  -2.53999084e-01f, 1.76919714e-01f, 6.27280474e-02f, 8.23105514e-01f, -2.65611380e-01f, -8.43018442e-02f, 5.04121184e-01f, -2.68949956e-01f, -1.92916438e-01f, -2.28569910e-01f,
  6.38108313e-01f, 4.97336119e-01f, -2.27951139e-01f, 1.00066018e+00f, 3.59058589e-01f, 6.47397578e-01f, 2.21978277e-01f, 5.56693017e-01f, 6.60578370e-01f, 2.08827436e-01f,
  1.66079417e-01f, 1.88511554e-02f, -2.55059838e-01f, -1.59757704e-01f, 5.75640518e-03f, -4.67161477e-01f, 8.59707817e-02f, 2.26494819e-01f, -1.08035095e-01f, -2.07486600e-01f,
  -3.58165413e-01f, 2.12984025e-01f, 1.06694967e-01f, -2.46971875e-01f, -5.25925934e-01f, 4.15282637e-01f, 2.94795781e-01f, 9.38678086e-01f, -2.77026355e-01f, 7.11097717e-02f,
  -2.10551485e-01f, -1.58313930e-01f, -1.91894144e-01f, -6.19313531e-02f, -4.55046818e-02f, -5.29957116e-01f, -3.21135253e-01f, 1.61068007e-01f, -6.15365088e-01f, -5.12198746e-01f,
  -5.59237838e-01f, 7.74773598e-01f, 5.57966232e-01f, -4.60277975e-01f, 7.53316045e-01f, -2.63637751e-01f, -4.02632833e-01f, -8.80637988e-02f, -2.41705835e-01f, 2.87149757e-01f,
  5.87723970e-01f, -1.08267507e-02f, 1.68255959e-02f, -3.89715344e-01f, -1.03693500e-01f, -2.15349317e-01f, -5.25727034e-01f, -3.06286693e-01f, -3.61321151e-01f, -6.49712011e-02f,
  9.31687281e-02f, -1.84184194e-01f, -4.34871852e-01f, 1.95861980e-01f, -3.61014158e-01f, -2.14246035e-01f, -2.99079001e-01f, -3.29875022e-01f, -2.51931310e-01f, 1.61953062e-01f,
  -2.49792412e-01f, 4.95001882e-01f, -8.03419650e-02f, 1.06949799e-01f, -4.15729702e-01f, -1.20631620e-01f, -4.56095397e-01f, 2.50766695e-01f, 2.74658144e-01f, 5.48750520e-01f,
  -1.84869230e-01f, 3.55318010e-01f, -2.00120345e-01f, 1.00908369e-01f, -3.44470859e-01f, 3.95127177e-01f, -1.84931353e-01f, 7.07531273e-02f, -4.03189629e-01f, 2.98591852e-02f,
  -3.43976080e-01f, -2.88237482e-01f, 4.59266677e-02f, 3.97370934e-01f, 9.65525568e-01f, 2.11336896e-01f, 1.71818003e-01f, 8.60177055e-02f, 1.78709641e-01f, 3.18962634e-01f,
  -2.45795637e-01f, -4.62719232e-01f, -4.84521747e-01f, -7.34454095e-02f, -3.59501421e-01f, -6.95594773e-02f, -5.75676501e-01f, 5.25841355e-01f, -7.79065564e-02f, -3.70046534e-02f,
  1.13048804e+00f, -1.74177319e-01f, -1.77313551e-01f, -4.00121033e-01f, -6.66093975e-02f, -1.71248794e-01f, -1.12309970e-01f, -1.85630769e-01f, 9.06230584e-02f, -3.48092526e-01f,
  -3.52818578e-01f, -2.37748653e-01f, -3.06345135e-01f, 3.19197685e-01f, -3.20431918e-01f, 7.37822294e-01f, -2.23046929e-01f, -1.54642016e-01f, 3.76463115e-01f, 2.43837476e-01f,
  1.16700076e-01f, 6.73419178e-01f, 1.96040096e-03f, -4.59066540e-01f, 2.46283978e-01f, 1.92556575e-01f, -4.10563439e-01f, 3.33399564e-01f, 3.57089281e-01f, -6.42709970e-01f,
  -1.94656044e-01f, -1.46808669e-01f, -3.43469739e-01f, 1.60111189e-01f, 2.96496123e-01f, -9.91300866e-02f, -5.34072161e-01f, 3.82658035e-01f, -2.52352864e-01f, -4.28851426e-01f,
  -2.79014945e-01f, -1.98505104e-01f, -4.10946786e-01f, 1.26070410e-01f, -2.66569674e-01f, -1.36578202e-01f, 1.34546840e+00f, -1.42414048e-01f, 2.90936977e-01f, -2.14668289e-01f,
  9.59753469e-02f, -2.68102646e-01f, 2.10876055e-02f, -3.15775841e-01f, 9.76618007e-02f, 3.21714908e-01f, 4.90117580e-01f, -6.15493953e-01f, 4.64526236e-01f, -6.02534294e-01f,
  -6.23522699e-01f, 1.85995221e-01f, -6.50081113e-02f, -5.78941144e-02f, 3.57261188e-02f, 3.95915993e-02f, -3.97961587e-01f, -3.29041369e-02f, -1.97776437e-01f, 1.63526744e-01f,
  -2.56575257e-01f, -6.00027889e-02f, 6.24985993e-01f, 9.80484188e-01f, -3.56945097e-01f, -1.74669728e-01f, 1.00927219e-01f, -3.04375827e-01f, -3.63553852e-01f, 1.87515661e-01f,
  -2.84424573e-01f, -7.23825619e-02f, 1.75329745e-01f, -2.49730051e-01f, 2.40769014e-01f, -5.63686907e-01f, 1.33865938e-01f, 4.72236909e-02f, 3.71131480e-01f, -6.75173223e-01f,
  -3.23574871e-01f, 6.01937592e-01f, -1.10660531e-01f, 7.11389065e-01f, -3.71665031e-01f, -2.71418728e-02f, 7.29796365e-02f, -1.71401054e-01f, 2.64426768e-01f, -3.74520868e-01f,
  5.83364725e-01f, -4.86948714e-02f, 1.09194958e+00f, 2.92957157e-01f, -8.43152329e-02f, -1.35751739e-01f, -3.17488253e-01f, -1.97176620e-01f, -1.80217713e-01f, -2.91037597e-02f,
  8.93652067e-02f, 1.70750059e-02f, 2.10686713e-01f, -1.59232207e-02f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -2.28717595e-01f, 8.19249004e-02f, 5.42759262e-02f, -1.59742445e-01f, 2.05672476e-02f, 3.77216071e-01f, 5.72767444e-02f, -3.90966564e-01f, -3.31654353e-03f, -5.29156532e-03f,
  -3.52766342e-03f, -3.07761114e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    