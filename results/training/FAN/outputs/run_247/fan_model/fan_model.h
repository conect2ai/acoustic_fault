/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.24516392e-01f, -3.40172350e-01f, -2.35054493e-01f, -5.23830159e-03f, 3.43029499e-01f, -1.78851515e-01f, -2.15411425e-01f, 6.09234013e-02f, -1.43818334e-01f, -3.25428456e-01f,
  1.03117544e-02f, -1.64541267e-02f, -2.30032012e-01f, -1.80263832e-01f, 2.15739429e-01f, -2.47617245e-01f, 7.30949566e-02f, -6.85256394e-03f, 1.09039515e-01f, 1.93723306e-01f,
  1.82137609e-01f, 2.59061068e-01f, 9.79889929e-02f, 2.04726681e-01f, 1.25821173e-01f, 1.22453608e-01f, 2.54818469e-01f, 5.30393571e-02f, 4.80446359e-03f, 6.92104325e-02f,
  2.34777089e-02f, -1.00873254e-01f, -2.94968784e-02f, -4.88550775e-02f, 9.87243578e-02f, 3.05288564e-03f, 2.42282692e-02f, -4.20830026e-02f, 4.23717685e-02f, 4.75680009e-02f,
  -2.92824507e-02f, 6.11760728e-02f, 6.56520389e-03f, -6.36354759e-02f, 3.70351458e-03f, -8.24244786e-03f, 4.16446961e-02f, -1.52065158e-02f, -4.07195510e-03f, -2.50066090e-02f,
  -2.30435394e-02f, -4.64032143e-02f, -1.08197518e-02f, -7.84982741e-02f, 1.15532242e-02f, -4.16928828e-02f, -6.51724562e-02f, -2.98926281e-03f, -6.48422092e-02f, 7.84137845e-03f,
  -3.12739871e-02f, 3.98002826e-02f, -1.53442891e-02f, 3.97874489e-02f, -3.66714038e-02f, 2.81743295e-02f, -4.19211648e-02f, 5.63776605e-02f, 2.84986012e-03f, -1.22621264e-02f,
  1.53871635e-02f, 1.12928879e-02f, 1.63599607e-02f, -6.44785389e-02f, 6.79407939e-02f, -9.93790664e-03f, 3.52750458e-02f, 3.71849816e-03f, 2.81185694e-02f, 3.53805497e-02f,
  -5.31696565e-02f, 1.07239466e-02f, -1.07439253e-02f, 4.07853909e-02f, -1.81167126e-02f, 2.17519663e-02f, -5.37994541e-02f, -7.25966766e-02f, 3.96623351e-02f, 7.32998848e-02f,
  7.31809735e-02f, 2.61590499e-02f, 1.74517352e-02f, 6.88908920e-02f, -1.22470763e-02f, 2.51131915e-02f, -2.92331036e-02f, 1.20569021e-02f, -4.30317745e-02f, -7.42984051e-03f,
  9.64608043e-02f, -1.54246101e-02f, 1.80228837e-02f, 1.63069274e-02f, -2.19076872e-02f, 2.69315322e-03f, 2.34649051e-02f, 4.81571555e-02f, 3.06137539e-02f, 7.16878399e-02f,
  5.01877405e-02f, 8.25537965e-02f, -3.25279720e-02f, 1.13532469e-01f, -2.86044111e-03f, 1.57373268e-02f, 7.00609684e-02f, -2.73885820e-02f, 1.93538307e-03f, -7.72309452e-02f,
  5.75698987e-02f, 1.61281526e-02f, -5.36177494e-02f, -8.75772163e-02f, 1.12926431e-01f, -3.26249003e-01f, -4.06510919e-01f, 5.34004644e-02f, 5.02715148e-02f, -1.18472066e-03f,
  -1.06128342e-01f, 6.93183988e-02f, -1.69095635e-01f, -2.96970159e-01f, -4.98364955e-01f, -2.69618273e-01f, -3.12602460e-01f, -1.21052526e-01f, 6.02365322e-02f, 5.58817573e-02f,
  1.36415251e-02f, -1.34335428e-01f, -2.24473462e-01f, 8.99201035e-02f, 5.47402911e-02f, 2.72527933e-01f, 9.38385800e-02f, 8.07781518e-02f, 5.66260852e-02f, -1.24849580e-01f,
  -1.24409296e-01f, 4.94959317e-02f, 7.30931386e-02f, -6.41153976e-02f, 3.29392817e-04f, 3.82505432e-02f, -1.89754665e-02f, -9.59664136e-02f, 3.78456456e-03f, -1.84170194e-02f,
  4.63061471e-04f, -1.75975636e-03f, -1.78035609e-02f, 1.74892023e-02f, 6.65761530e-02f, 4.50527929e-02f, 9.52722132e-03f, 4.45302837e-02f, 2.29421835e-02f, 2.64209672e-03f,
  -1.84710473e-02f, -1.17036877e-02f, 5.72212711e-02f, -2.01307163e-02f, 5.67666441e-03f, 1.10649178e-02f, -7.50531033e-02f, 2.23360043e-02f, 7.67523721e-02f, -2.63539638e-04f,
  -4.48181555e-02f, 3.50389630e-03f, 4.84496122e-04f, -2.69006249e-02f, -2.46337578e-02f, 1.45246629e-02f, -1.44494213e-02f, -3.38307917e-02f, 3.00267152e-03f, -8.42798594e-03f,
  1.71059389e-02f, 2.70244610e-02f, -4.63056788e-02f, 9.48574208e-03f, -2.00535730e-02f, 2.67155040e-02f, -4.04015519e-02f, 2.40272284e-02f, -4.96173184e-03f, 8.66293442e-03f,
  -2.38649026e-02f, -2.31882799e-02f, 4.26090974e-03f, -1.26681710e-02f, -7.07267001e-02f, 2.02832669e-02f, 2.22117677e-02f, 2.37088110e-02f, 2.41358969e-02f, -2.16658618e-02f,
  -1.03420287e-01f, -4.67734272e-03f, -2.21840404e-02f, 5.19001149e-02f, -5.84390387e-03f, 1.06298979e-02f, -4.73059341e-02f, 1.22380462e-02f, 2.91827274e-03f, 1.27157401e-02f,
  2.63177771e-02f, -1.86016615e-02f, 4.96007241e-02f, -1.12417936e-02f, -3.01942026e-04f, -3.76931056e-02f, -1.62842441e-02f, -4.38059028e-03f, 6.05212897e-03f, 2.84394305e-02f,
  5.25944717e-02f, 1.43751716e-02f, -3.66933867e-02f, 6.51976839e-02f, 2.24972405e-02f, -1.69352423e-02f, 5.22955991e-02f, -6.52159471e-03f, -2.22300962e-02f, 2.27102800e-03f,
  6.99758306e-02f, -3.38745952e-01f, -2.01174438e-01f, -7.23287836e-02f, 2.48365566e-01f, 4.72453713e-01f, 2.75732398e-01f, 1.16144463e-01f, 7.72699490e-02f, -6.40038997e-02f,
  1.57956421e-01f, -1.78895056e-01f, -1.52105287e-01f, 1.71434164e-01f, 2.93113351e-01f, 3.12917563e-03f, 2.31485426e-01f, 7.98441321e-02f, 2.14088764e-02f, 8.63281041e-02f,
  8.76320079e-02f, 2.63127208e-01f, -9.91021171e-02f, 8.59766155e-02f, 1.14417627e-01f, -1.48996949e-01f, -8.81081969e-02f, -1.00145727e-01f, -6.46098107e-02f, -2.61360854e-02f,
  7.93249682e-02f, -1.14968978e-01f, -1.84828267e-02f, -2.88990624e-02f, 5.17781675e-02f, -1.64595675e-02f, -5.71229979e-02f, -4.29550633e-02f, -1.25575541e-02f, -2.33703014e-03f,
  -5.37001267e-02f, 2.22511645e-02f, 8.18646625e-02f, 1.28828892e-02f, 3.94719429e-02f, -4.05861903e-03f, -1.70023255e-02f, 1.40589639e-03f, -2.18983926e-02f, 1.35237370e-02f,
  5.59563981e-03f, -1.90291386e-02f, 1.38765229e-02f, -1.29916137e-02f, -2.70637050e-02f, 4.29475121e-02f, 2.04661228e-02f, -5.70798181e-02f, 1.97586417e-02f, 4.93417913e-03f,
  2.34820554e-03f, 3.06404792e-02f, 2.51042228e-02f, -6.85350737e-03f, 3.52552719e-02f, -1.15785180e-02f, 3.33569944e-02f, -1.55873992e-03f, -5.78236803e-02f, 6.03453778e-02f,
  4.33066376e-02f, 2.19293647e-02f, 4.05968875e-02f, 5.26421480e-02f, 6.63195997e-02f, 2.91706366e-03f, 3.24940830e-02f, -4.60680798e-02f, 3.93378437e-02f, 7.05215186e-02f,
  -2.56097578e-02f, 7.82363340e-02f, 2.85476819e-02f, -4.10724878e-02f, 8.39989632e-03f, -7.43451156e-03f, 2.11400632e-03f, -2.77497470e-02f, 1.35104591e-03f, -1.26060722e-02f,
  1.04050219e-01f, -5.52160032e-02f, 3.16551439e-02f, -3.66932228e-02f, -4.49179038e-02f, 4.13566120e-02f, 1.59165706e-03f, 5.65830469e-02f, 8.27522669e-03f, 8.33577514e-02f,
  -6.42730435e-03f, -3.82536873e-02f, 3.64735397e-03f, -6.30715638e-02f, 1.10678440e-02f, 6.99101388e-02f, -1.80358253e-02f, -1.50943566e-02f, 3.62934545e-02f, -4.62427102e-02f,
  2.92392843e-03f, 2.49522869e-02f, -2.57847738e-02f, 1.82971098e-02f, 4.07780614e-03f, -3.36361080e-02f, 1.98876914e-02f, -4.37733456e-02f, -2.63902303e-02f, -2.36802362e-02f,
  -6.15351498e-01f, 8.74328986e-02f, -1.28368720e-01f, -3.71148914e-01f, 8.19454193e-02f, -1.14087202e-01f, -2.81193078e-01f, 1.56982735e-01f, -2.37924159e-01f, 1.95228517e-01f,
  -6.59116209e-02f, -3.17165166e-01f, -3.30684781e-02f, -1.13796532e-01f, -4.45868492e-01f, -9.67149958e-02f, -2.39074856e-01f, -2.06981957e-01f, 3.32635939e-02f, -1.68955028e-01f,
  -1.40522882e-01f, 7.49249533e-02f, 3.20596918e-02f, 3.33897561e-01f, 4.40745195e-03f, 8.90144408e-02f, 6.80857375e-02f, 1.08218640e-01f, 6.64715841e-02f, 6.12415262e-02f,
  1.10738026e-02f, 7.96134472e-02f, 6.76346421e-02f, 2.47682277e-02f, -2.42351647e-02f, 1.20260837e-02f, -6.62819371e-02f, 3.58164823e-03f, -1.17013408e-02f, -7.43416022e-04f,
  -8.80521238e-02f, -5.13593331e-02f, 2.87777111e-02f, -1.47853252e-02f, 6.53780205e-03f, -2.51117884e-03f, -1.75167806e-02f, -3.00805215e-02f, 6.37311675e-03f, -2.54229773e-02f,
  -1.61536261e-02f, -1.78902168e-02f, -7.99867511e-02f, -6.59438968e-02f, -1.09246522e-02f, -1.21535286e-02f, -1.56191448e-02f, -4.52620070e-03f, -5.94564863e-02f, 1.69663981e-04f,
  -4.08350937e-02f, 6.00044802e-03f, 1.42047098e-02f, 4.17956524e-02f, -1.79572683e-02f, 8.94390345e-02f, -4.55288999e-02f, 5.00012636e-02f, -6.34039640e-02f, -1.68950204e-02f,
  -9.15381219e-03f, -1.58051774e-02f, 2.43075434e-02f, 3.78311891e-03f, -2.13241037e-02f, 3.85199860e-02f, -4.58591506e-02f, 2.85678599e-02f, -4.39595710e-03f, 2.09598467e-02f,
  2.73237620e-02f, -3.02966461e-02f, 2.38271356e-02f, 2.99395472e-02f, 1.87876783e-02f, -2.06303261e-02f, -1.98703520e-02f, 3.54399197e-02f, 2.81031914e-02f, -5.46155982e-02f,
  -8.39910135e-02f, -7.84169883e-02f, -6.42926898e-03f, 6.32026093e-03f, 2.33132765e-02f, 1.13549642e-02f, -6.48691831e-03f, -1.00425474e-04f, -3.85846831e-02f, 4.55107633e-03f,
  -1.22472653e-02f, -2.12226864e-02f, -4.08186130e-02f, -1.92744881e-02f, -1.76944248e-02f, -3.64947952e-02f, -5.45732751e-02f, 3.35601978e-02f, -4.72677834e-02f, -3.24714482e-02f,
  -1.15083372e-02f, -5.59843890e-02f, 6.35321997e-03f, 4.64651510e-02f, -2.33619809e-02f, -4.18210626e-02f, -5.30650020e-02f, 5.42896874e-02f, -1.69641897e-02f, -8.55789706e-03f,
  1.40664056e-01f, -8.24213549e-02f, 3.06520581e-01f, 5.55961207e-02f, -6.49807230e-03f, -2.55684435e-01f, 5.95315062e-02f, -1.45304084e-01f, 2.26781696e-01f, -2.72480279e-01f,
  -2.12035507e-01f, 3.82854730e-01f, 3.26062180e-02f, -2.67571151e-01f, 8.94799307e-02f, -2.97549777e-02f, -3.34391266e-01f, -1.24327697e-01f, 1.20074697e-01f, -1.27283394e-01f,
  3.54995392e-02f, -3.46540987e-01f, -8.03800183e-04f, -1.74204960e-01f, -4.15810570e-02f, 8.50029141e-02f, -1.90349475e-01f, 1.14842646e-01f, -2.26214886e-01f, 9.45677012e-02f,
  -1.64468884e-01f, 1.64814651e-01f, 9.48826224e-02f, 8.20463449e-02f, -1.22219086e-01f, -7.27395713e-03f, 1.22951698e-02f, 9.93622467e-02f, 3.76333110e-02f, 2.64710467e-02f,
  9.53337774e-02f, 6.42052293e-03f, 1.62734538e-02f, 2.59346925e-02f, -2.59235259e-02f, 1.60112903e-02f, 3.91281322e-02f, -2.00176649e-02f, 1.06257193e-01f, 3.61403972e-02f,
  6.93873987e-02f, 3.56311202e-02f, -1.08637975e-03f, -3.02605126e-02f, 6.85376301e-02f, 1.02672232e-02f, 5.74547835e-02f, 5.17585315e-02f, -2.81695146e-02f, -2.59102918e-02f,
  6.30336553e-02f, -2.35892776e-02f, 1.41310990e-02f, -7.08132759e-02f, -3.57362418e-03f, -2.31846739e-02f, -3.32937054e-02f, -1.51945194e-02f, 1.21127889e-02f, -4.58532497e-02f,
  -6.02490157e-02f, 2.86705121e-02f, 3.26610394e-02f, 4.56409209e-04f, -5.14105633e-02f, -1.51035062e-03f, 1.48307709e-02f, -2.49323752e-02f, -2.37186477e-02f, 5.62985241e-03f,
  4.25361395e-02f, 8.94556101e-03f, -5.39436527e-02f, -4.31698821e-02f, -3.19031067e-02f, 7.63197094e-02f, -4.24403101e-02f, 8.41362309e-03f, 1.73634309e-02f, -1.59116723e-02f,
  -4.43335235e-01f, -2.26507232e-01f, 2.56539956e-02f, 3.14804725e-02f, -3.13920975e-02f, -7.85936788e-02f, 8.65756720e-03f, 1.73734073e-02f, -4.40458953e-02f, 2.08979025e-02f,
  -8.42973962e-02f, -1.72096416e-02f, -3.29378136e-02f, -3.08396574e-02f, 4.17975932e-02f, -5.73660806e-02f, -5.65478355e-02f, -1.50176063e-02f, -9.29438919e-02f, -7.84682482e-02f,
  -8.90081972e-02f, -1.46833565e-02f, 4.68064062e-02f, 3.49464938e-02f, -3.36349346e-02f, -1.01406761e-02f, 1.15363179e-02f, 5.46445921e-02f, -4.20536287e-02f, -5.50217964e-02f,
  -5.54709971e-01f, -1.84737630e-02f, 5.02550080e-02f, -3.61507326e-01f, -1.53966561e-01f, -8.20775330e-02f, -1.08517610e-01f, -1.73557609e-01f, -8.41350257e-02f, 4.00321968e-02f,
  1.88890379e-02f, -1.27207503e-01f, 3.17045212e-01f, -1.09651357e-01f, -2.02180848e-01f, 3.16774517e-01f, -2.03771397e-01f, -5.37294336e-02f, 9.97979790e-02f, -2.79927790e-01f,
  -6.25769645e-02f, -1.30526006e-01f, 2.17126310e-02f, 4.04390953e-02f, -2.10729748e-01f, -1.00045420e-01f, -6.57015741e-02f, 1.23006083e-01f, -1.26817077e-01f, 2.57719457e-02f,
  -5.14066629e-02f, -4.63025533e-02f, 3.78468893e-02f, 1.93487573e-02f, -6.85822219e-02f, -4.43331674e-02f, -5.92571823e-03f, 9.09911245e-02f, 2.49309614e-02f, 8.45873728e-03f,
  -2.36952701e-03f, -2.44749896e-02f, -2.78091915e-02f, 1.02649547e-01f, -5.10567054e-02f, 3.21807675e-02f, 2.36098077e-02f, 3.04013342e-02f, 1.73354335e-02f, -1.36819687e-02f,
  6.35480061e-02f, 1.51460655e-02f, -2.17212364e-02f, 5.61188608e-02f, -5.24497703e-02f, -1.25857061e-02f, 1.37044406e-02f, -1.54916965e-03f, -7.59461448e-02f, -7.57193118e-02f,
  4.90255542e-02f, -2.13461183e-02f, 3.64912972e-02f, -1.50885126e-02f, -1.49675668e-03f, 2.05712430e-02f, -3.41980089e-03f, 2.39702407e-02f, 3.62725705e-02f, -4.98427637e-02f,
  -3.02608367e-02f, -1.07254326e-01f, -1.49332425e-02f, -1.80212129e-02f, -2.01566182e-02f, -4.37920243e-02f, -1.77913271e-02f, 5.01392316e-03f, -3.31717283e-02f, -3.60828377e-02f,
  5.31791383e-03f, -3.75048295e-02f, -3.54376584e-02f, 3.39041948e-02f, 1.27042187e-02f, 6.10813219e-03f, 1.31447678e-02f, 5.26493555e-03f, 1.38955684e-02f, -1.55604882e-02f,
  -1.83024436e-01f, -3.65770757e-01f, 2.45859884e-02f, -2.88626067e-02f, 5.71776778e-02f, -8.74924101e-03f, -5.96515089e-03f, 8.03974457e-03f, 7.13841524e-03f, -6.78188726e-02f,
  2.34012511e-02f, -3.85386944e-02f, -1.24222618e-02f, -2.23194305e-02f, 2.61159372e-02f, -2.79869977e-02f, -2.83589493e-03f, -2.44706087e-02f, -1.23530194e-01f, -1.95130333e-02f,
  -6.59303367e-02f, 4.91537387e-03f, 4.00200263e-02f, -4.10769284e-02f, 1.76646449e-02f, -3.45382318e-02f, -9.47821960e-02f, 6.42349292e-03f, 1.04750469e-02f, 1.01812268e-02f,
  -1.95047513e-01f, -5.75284585e-02f, 1.55270040e-01f, 4.81270328e-02f, 4.79484443e-03f, -2.05726013e-01f, 2.39515707e-01f, -3.08653340e-03f, 2.89201885e-01f, -1.24277674e-01f,
  1.28475085e-01f, -3.40401858e-01f, 3.73722136e-01f, -1.94190636e-01f, 1.60484612e-02f, 2.71279275e-01f, -1.35440886e-01f, -1.42444655e-01f, 1.63059786e-01f, -2.68155877e-02f,
  1.14257699e-02f, -7.05673620e-02f, 1.13242872e-01f, -1.00737408e-01f, -1.44391194e-01f, -7.46407732e-02f, -1.05744131e-01f, 1.37624174e-01f, -3.71574432e-01f, -1.15322351e-01f,
  -4.68861684e-03f, 1.25446856e-01f, -4.97927256e-02f, -9.79547016e-03f, -8.36461633e-02f, -5.45421839e-02f, -1.11412860e-01f, 8.90889391e-02f, 3.21291089e-02f, 3.39845829e-02f,
  -5.15140966e-02f, -2.42614429e-02f, -5.29338457e-02f, 4.36379723e-02f, -5.42088300e-02f, -2.15034150e-02f, -1.06069058e-01f, -3.21038142e-02f, -5.98701881e-03f, 2.13109124e-02f,
  -6.22349279e-03f, -7.53589943e-02f, -3.74453478e-02f, -1.00938998e-01f, 5.17730601e-02f, 1.43682593e-02f, -1.71782970e-02f, -3.36348861e-02f, -5.02566248e-02f, -5.27195521e-02f,
  -8.64970013e-02f, 3.87073793e-02f, -9.34123620e-03f, 3.22300307e-02f, 2.10817941e-02f, -1.53682837e-02f, -1.26717333e-02f, -1.25844823e-02f, -1.37433619e-03f, 1.03438040e-02f,
  1.37731219e-02f, -3.40779051e-02f, -1.73843894e-02f, -3.95935774e-02f, 3.50402854e-03f, 1.24657657e-02f, -4.62113917e-02f, -5.77627756e-02f, 2.66689854e-03f, -4.60250396e-03f,
  6.04791641e-02f, -2.59129014e-02f, 1.01908473e-02f, -3.37634534e-02f, 2.06784569e-02f, 1.23424456e-02f, -3.64886969e-02f, 2.78071519e-02f, 8.41511860e-02f, 2.66821531e-04f,
  -8.47382173e-02f, -1.05270535e-01f, 7.26914555e-02f, -3.17716785e-02f, 3.28683443e-02f, -6.13089604e-03f, 8.82636234e-02f, -1.01344861e-01f, 5.51549457e-02f, 2.23243851e-02f,
  -7.08101541e-02f, -2.16180794e-02f, -8.13258812e-02f, -5.71367405e-02f, 1.41596943e-02f, 3.96784768e-02f, 2.34402511e-02f, -3.14219631e-02f, -7.47354850e-02f, -3.62858102e-02f,
  7.28270551e-03f, -1.78634953e-02f, -1.06883431e-02f, 1.15431584e-02f, -1.27169341e-01f, -4.88484837e-02f, -2.27065329e-02f, -4.25868481e-02f, -8.91425833e-02f, 4.23698574e-02f,
  -3.22368704e-02f, 3.14435244e-01f, -7.19445199e-02f, 7.38275424e-02f, -3.63599956e-01f, -2.74442658e-02f, -7.42488503e-02f, -7.11380243e-02f, 1.51095137e-01f, 1.57205731e-01f,
  -9.13635492e-02f, 1.42885804e-01f, 3.87929752e-02f, 8.40031356e-02f, 3.45273614e-01f, 2.96632171e-01f, 1.68325812e-01f, 1.10181779e-01f, 5.05411364e-02f, 8.31113607e-02f,
  2.45215893e-02f, 1.89353283e-02f, -3.38169597e-02f, -6.76024109e-02f, -2.18807653e-01f, -1.62005544e-01f, 8.55767634e-03f, -1.30358353e-01f, -8.15526918e-02f, 3.12617160e-02f,
  -5.75409420e-02f, -2.78435405e-02f, -7.71886334e-02f, 5.61752021e-02f, -1.58073083e-02f, -1.08854510e-01f, -8.14511534e-03f, -3.86190526e-02f, -2.42098700e-02f, -2.27488950e-02f,
  4.77471855e-03f, -1.97427720e-02f, 1.86595265e-02f, 3.29647884e-02f, -5.44773079e-02f, -3.41058932e-02f, -8.53274912e-02f, -1.25711545e-01f, -4.68748808e-02f, -8.85398686e-02f,
  -8.11714679e-02f, -6.36408105e-02f, -2.42725853e-02f, 1.62396189e-02f, -7.06490204e-02f, -3.98347639e-02f, -2.92648003e-02f, -7.88429081e-02f, -1.61055904e-02f, 1.42069737e-04f,
  1.74072353e-04f, 2.77250409e-02f, -6.29937975e-03f, -8.20488296e-03f, 3.43428068e-02f, -1.00483254e-01f, 2.65947990e-02f, -4.71164137e-02f, -2.30181813e-02f, -2.58325692e-02f,
  1.20623745e-02f, -1.52608966e-02f, -8.38690903e-03f, -3.53261828e-02f, 3.10330801e-02f, 1.26097891e-02f, -1.96122425e-03f, -1.98008143e-03f, -4.94049452e-02f, -4.04513814e-02f,
  4.14196178e-02f, 3.02549638e-02f, 2.50636190e-02f, -6.01466857e-02f, 7.51895234e-02f, -2.05544773e-02f, -5.51636443e-02f, -3.87164094e-02f, 2.68914141e-02f, -3.42550017e-02f,
  2.73210436e-01f, 4.35096085e-01f, 9.52347275e-03f, -4.78392839e-03f, 4.33354676e-02f, 1.77745167e-02f, 7.55289346e-02f, -2.09223758e-02f, 5.32151684e-02f, 5.00680357e-02f,
  -4.91098091e-02f, -5.00664450e-02f, 3.45528126e-02f, -4.43634391e-02f, 4.32639159e-02f, 1.16439927e-02f, 9.40291807e-02f, 7.82645196e-02f, -2.55178334e-03f, 1.71462763e-02f,
  2.43889540e-02f, -3.32919173e-02f, -6.20645955e-02f, -6.52876422e-02f, -4.68874909e-02f, -4.36888821e-02f, 5.22373952e-02f, 4.90039513e-02f, -3.48465927e-02f, 2.07533408e-02f,
  1.37974173e-01f, -3.74480426e-01f, -5.14853746e-04f, 2.25351989e-01f, -8.40301532e-03f, -1.74683288e-01f, 2.83320367e-01f, -2.67728269e-01f, 4.68922071e-02f, -7.59048536e-02f,
  7.23915249e-02f, 6.94010872e-03f, 1.04800658e-02f, 1.33870319e-01f, 1.59802020e-01f, 9.47233513e-02f, -5.22284992e-02f, 9.90597531e-02f, -9.89589393e-02f, -1.69171035e-01f,
  2.23433487e-02f, 2.29814202e-02f, 1.31695926e-01f, -3.25137228e-01f, 1.10186465e-01f, -1.65592030e-01f, -8.40233266e-03f, -1.18214838e-01f, -4.09727963e-03f, 1.01838142e-01f,
  -7.33894333e-02f, 5.12461271e-03f, 9.58494097e-02f, -2.03079470e-02f, -6.42597210e-03f, 7.83674344e-02f, 2.18164697e-02f, 7.25290850e-02f, 8.70945677e-02f, -5.56984078e-03f,
  -1.45490179e-02f, -4.95105013e-02f, -7.59927230e-03f, 2.26686951e-02f, 1.65560674e-02f, -4.83132750e-02f, 4.03167158e-02f, 5.29345423e-02f, -5.50369779e-03f, 8.45174193e-02f,
  6.14204854e-02f, 7.99611956e-02f, 4.89367880e-02f, 7.15033209e-04f, 3.43075991e-02f, -2.15164735e-03f, 5.64587861e-02f, 4.59334441e-02f, -8.79359767e-02f, -2.10358878e-04f,
  -4.20448333e-02f, 1.56433992e-02f, 9.39350761e-03f, 3.29237618e-02f, -3.40406559e-02f, 3.12944315e-03f, 6.99470809e-04f, 3.06216404e-02f, 4.66227811e-03f, -1.59815755e-02f,
  -6.75030285e-03f, 1.08606471e-02f, 3.00490689e-02f, 2.35284884e-02f, 1.75699070e-02f, 2.85695139e-02f, 2.48446129e-03f, -3.36771011e-02f, 1.30192190e-02f, 3.28187160e-02f,
  2.56159678e-02f, -1.07683195e-02f, 2.05601775e-03f, -8.57831538e-03f, -1.11432103e-02f, 3.98474410e-02f, -5.00584841e-02f, -2.57500578e-02f, 1.45733384e-02f, 2.81379316e-02f,
  -3.93948585e-01f, -5.86718380e-01f, -1.14505135e-01f, -1.05964078e-03f, -7.89287388e-02f, -2.10422426e-02f, -4.90187444e-02f, -2.84103099e-02f, -1.04096889e-01f, -3.20184715e-02f,
  -1.45724732e-02f, 6.92853108e-02f, -6.76668212e-02f, 3.43381725e-02f, -2.49717087e-02f, -3.78738083e-02f, 2.49145292e-02f, 2.84398217e-02f, -6.17265627e-02f, -6.10838346e-02f,
  -4.86734919e-02f, -8.60359054e-03f, 5.83769195e-03f, 2.50608176e-02f, -5.20765260e-02f, 7.35012665e-02f, -8.33474696e-02f, 8.82476289e-03f, -4.72014472e-05f, -3.70951071e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.92981893e-01f, 3.00847620e-01f, 5.49573660e-01f, 3.27160150e-01f, -1.64036438e-01f, -7.97549337e-02f, -5.80702499e-02f, 2.02131018e-01f, 3.64545763e-01f, -1.03420705e-01f,
  -2.53042161e-01f, 3.25420916e-01f, -1.08311422e-01f, 1.72948509e-01f, -1.78595990e-01f, -2.11511120e-01f, 3.80500518e-02f, -5.71120977e-02f, 5.97914197e-02f, 2.09231526e-01f,
  1.04292385e-01f, -2.63322026e-01f, -3.32625117e-04f, -6.06108829e-02f, 1.73098341e-01f, 2.63398439e-01f, -3.38428438e-01f, -1.25338227e-01f, 6.16830736e-02f, -1.57857716e-01f,
  4.54572141e-02f, 3.36498842e-02f, 2.07200989e-01f, 2.07371101e-01f, 1.02742640e-02f, -5.11991382e-02f, -4.79221791e-02f, -8.28327462e-02f, -7.31569761e-03f, 4.82297465e-02f,
  7.02531869e-03f, 6.30684048e-02f, 4.11209390e-02f, -7.25207403e-02f, 8.96879509e-02f, 1.20660760e-01f, 4.57086489e-02f, 1.52328208e-01f, 7.75585100e-02f, 1.37093961e-01f,
  1.77078530e-01f, 1.32021770e-01f, 1.36635050e-01f, -7.59990048e-03f, 2.43887939e-02f, -5.01985773e-02f, 4.73175086e-02f, 4.80500832e-02f, 1.39242381e-01f, 1.07029252e-01f,
  -1.94835048e-02f, 1.12568401e-02f, -4.51762974e-02f, 5.78590147e-02f, 3.14957388e-02f, 2.86626611e-02f, 5.77347875e-02f, -4.69954982e-02f, 6.45394102e-02f, 4.07990592e-04f,
  2.45874245e-02f, 1.13397762e-02f, 1.37556521e-02f, 8.63410160e-02f, -9.96214058e-03f, -3.87364812e-02f, -6.03723293e-03f, -3.75166684e-02f, 1.82634499e-02f, 1.75612867e-02f,
  -7.55090415e-02f, -2.72615179e-02f, -2.56468598e-02f, -8.29215795e-02f, 1.66083761e-02f, 2.58605592e-02f, 7.05771372e-02f, 1.21690504e-01f, -6.96878135e-02f, -1.11024126e-01f,
  -9.38008074e-03f, -1.00214630e-01f, 3.47275194e-03f, -3.90081890e-02f, -3.21262367e-02f, 9.56424512e-03f, 3.91170792e-02f, 7.03479201e-02f, -2.49980353e-02f, 3.78249884e-02f,
  -1.81161724e-02f, 1.75296105e-02f, -1.51132196e-02f, 1.77025683e-02f, -2.46161036e-02f, -2.41958816e-02f, 4.43060063e-02f, -2.29135361e-02f, 9.93947778e-03f, -1.20068155e-02f,
  1.08629223e-02f, 1.98437762e-03f, -1.10735940e-02f, 1.20412894e-02f, -5.08998297e-02f, -1.73700205e-03f, 5.46843596e-02f, 3.22905806e-04f, -5.79608306e-02f, 2.46216226e-02f,
  -1.47573307e-01f, 3.07955772e-01f, 1.02479547e-01f, 8.71369988e-02f, 9.26104262e-02f, 1.86153576e-01f, 6.77195117e-02f, 3.10059160e-01f, 3.48263830e-01f, 6.80221692e-02f,
  -3.92759815e-02f, 2.90805131e-01f, -7.47961923e-02f, 1.04802765e-01f, -1.04160726e-01f, -3.37727889e-02f, 7.92169943e-02f, 3.05166468e-02f, 2.05257356e-01f, 8.43490735e-02f,
  -9.69621688e-02f, -8.99436325e-02f, -2.68638283e-01f, 1.02160103e-03f, -9.03304368e-02f, -9.15923044e-02f, -4.01946038e-01f, -7.79748484e-02f, 1.87604877e-04f, 1.31942660e-01f,
  -5.28754294e-02f, 9.42886397e-02f, -1.49184251e-02f, -5.55068441e-02f, -1.91741996e-02f, 2.71196831e-02f, 1.11803748e-02f, -6.85293078e-02f, -4.38145408e-03f, 2.04124022e-02f,
  6.45261258e-02f, 8.83609653e-02f, 1.14864416e-01f, -5.76536730e-02f, 1.13103233e-01f, -1.28781796e-02f, 5.74696697e-02f, -3.18307924e-04f, 1.39132738e-01f, -3.74244116e-02f,
  1.16528803e-02f, 2.24773474e-02f, -5.93474768e-02f, 3.65210548e-02f, -7.03517422e-02f, -3.53010036e-02f, 5.35660349e-02f, -4.68498431e-02f, 3.59577276e-02f, 1.23781264e-01f,
  -3.54030430e-02f, -3.57843079e-02f, 1.87223163e-02f, -7.22309425e-02f, -1.72320791e-02f, -7.48352110e-02f, -4.49095247e-03f, -7.41874948e-02f, -4.02852260e-02f, -2.98867449e-02f,
  -6.57434613e-02f, -8.68565310e-03f, -1.92819126e-02f, -1.47441942e-02f, -5.99095151e-02f, 3.85667682e-02f, -1.11901522e-01f, -2.92893089e-02f, 5.89704514e-02f, -7.24933520e-02f,
  -6.11378364e-02f, 6.03669286e-02f, 1.28374656e-03f, -9.53594521e-02f, 3.31005678e-02f, 1.37313427e-02f, 3.07495687e-02f, 2.18215548e-02f, -6.90115765e-02f, 1.86542924e-02f,
  1.73656438e-02f, 1.31280392e-01f, -3.16142890e-04f, 4.17409390e-02f, 1.47833843e-02f, 5.43716587e-02f, -5.07082231e-02f, 1.04934432e-01f, -3.74721666e-03f, 8.08547139e-02f,
  1.06175020e-02f, -8.58263075e-02f, 7.22843334e-02f, -1.08172623e-02f, -2.43245363e-02f, 1.20174684e-01f, -3.49112377e-02f, -3.82435434e-02f, 1.85521301e-02f, 8.68190255e-04f,
  6.56206682e-02f, 4.87963185e-02f, -9.20686051e-02f, -2.46843379e-02f, 4.30127382e-02f, -4.40563373e-02f, -2.88926251e-02f, -7.60620367e-03f, -3.17964405e-02f, -5.14610251e-03f,
  -1.05378464e-01f, 7.40835816e-03f, -2.17524603e-01f, -1.12479150e-01f, 1.75066292e-01f, -3.72983307e-01f, -1.69986054e-01f, 9.10796449e-02f, 3.33594322e-01f, -2.02752817e-02f,
  6.63527325e-02f, -9.65894461e-02f, 2.27572203e-01f, -2.52948672e-01f, -2.73817301e-01f, -2.23853439e-02f, -4.77974504e-01f, -2.72159219e-01f, 1.31680682e-01f, -1.25796452e-01f,
  -1.75525621e-01f, 5.51381968e-02f, -1.74995974e-01f, 1.35741800e-01f, -2.08177473e-02f, -1.60586443e-02f, 1.05840918e-02f, 2.12564260e-01f, -1.82556137e-01f, -4.66690771e-03f,
  -1.11610577e-01f, 1.76605389e-01f, -2.14742012e-02f, -2.37282701e-02f, -1.42556772e-01f, -1.43966451e-01f, -8.17584619e-02f, -2.22189035e-02f, -8.99292752e-02f, 3.54727730e-02f,
  -7.16622323e-02f, 8.80309269e-02f, 5.08281253e-02f, 8.66534710e-02f, 1.10671856e-01f, 4.87304069e-02f, 3.20587382e-02f, -5.16709760e-02f, 1.28509449e-02f, -3.41295861e-02f,
  -1.14623951e-02f, -5.94675764e-02f, -6.42259866e-02f, -8.68158340e-02f, -7.50425607e-02f, 1.27099250e-02f, -9.12751555e-02f, -1.68082237e-01f, -4.13735136e-02f, 2.07575271e-03f,
  7.53985047e-02f, -1.90138239e-02f, -2.61035226e-02f, 1.00003086e-01f, 3.21062133e-02f, 1.40104340e-02f, -4.01033014e-02f, -2.49450672e-02f, 3.82997692e-02f, -5.83169423e-02f,
  -1.69172660e-02f, 4.56740148e-02f, 1.18296579e-01f, -5.33620678e-02f, -7.51279518e-02f, 6.63482025e-02f, -8.67294334e-03f, -1.35777816e-02f, -9.56610125e-03f, -1.96541920e-02f,
  1.12326585e-01f, -5.28539903e-02f, 8.37710425e-02f, -8.10756758e-02f, -8.23293924e-02f, 8.09772983e-02f, 5.38999327e-02f, -1.97920650e-02f, -4.43443730e-02f, -1.63236223e-02f,
  -2.48728812e-01f, -1.07226431e-01f, 5.49688935e-02f, 6.99211881e-02f, -5.48311286e-02f, -1.20396107e-01f, -4.28989753e-02f, -7.88616017e-03f, -5.40616512e-02f, 6.07179739e-02f,
  -1.27731591e-01f, -1.35267694e-02f, -8.04550126e-02f, 2.50133071e-02f, 1.60835516e-02f, 6.78658625e-03f, -5.88969290e-02f, -8.22779164e-02f, -2.50096545e-02f, -2.14541368e-02f,
  4.53748129e-04f, 5.88398539e-02f, -5.16915228e-03f, 1.57388467e-02f, -5.61209060e-02f, 2.46226825e-02f, -7.76385963e-02f, 4.74141277e-02f, -6.04392737e-02f, -1.22243054e-01f,
  -4.39274371e-01f, 7.43405847e-03f, 4.72710311e-01f, -3.04527551e-01f, 5.71243688e-02f, 3.35676938e-01f, 1.41353607e-01f, -7.05372393e-02f, -4.83124644e-01f, -1.67177036e-01f,
  -1.10410824e-01f, -1.52158767e-01f, 2.85457700e-01f, -2.11709708e-01f, 2.19740286e-01f, 6.82364106e-02f, -1.40500695e-01f, -6.45162314e-02f, 3.80837247e-02f, -2.48058010e-02f,
  6.15345920e-03f, -1.63637131e-01f, 3.61703217e-01f, 1.88378096e-02f, 3.06152645e-02f, -9.33687314e-02f, -1.40088618e-01f, 2.80496061e-01f, 3.36039290e-02f, 1.26664564e-01f,
  -9.84925702e-02f, -2.38847092e-01f, 1.27944304e-02f, 3.03673558e-02f, 1.40619308e-01f, -6.12389855e-03f, 7.63908848e-02f, 9.35074016e-02f, -1.08156480e-01f, -3.11822724e-02f,
  -2.88589410e-02f, 9.24327299e-02f, -1.15437374e-01f, 2.28228886e-02f, -6.12883009e-02f, -3.04519944e-02f, 5.01706414e-02f, -1.20749278e-02f, 7.42804855e-02f, 1.34288162e-01f,
  1.72383279e-01f, 7.68108815e-02f, 4.70433868e-02f, -2.13271379e-03f, 1.06078885e-01f, 3.70123461e-02f, 3.01710796e-02f, 1.90448344e-01f, 2.12551858e-02f, -6.30505234e-02f,
  -2.63203997e-02f, 3.52114141e-02f, -2.20652837e-02f, 1.15451217e-02f, -8.80735368e-02f, -8.41642842e-02f, -5.22120371e-02f, -5.85855031e-03f, -6.07036762e-02f, 1.59427430e-02f,
  -4.96682748e-02f, -2.78532933e-02f, -4.41609994e-02f, -4.56314012e-02f, 1.69605669e-02f, -5.52020818e-02f, 4.14261147e-02f, 2.59802733e-02f, -1.33049497e-02f, -2.75318250e-02f,
  -6.00967109e-02f, 3.72607410e-02f, 5.69747575e-02f, -3.32304016e-02f, -2.53152996e-02f, 3.61567773e-02f, -2.36393921e-02f, 3.03698294e-02f, 5.43313986e-03f, 8.14341754e-02f,
  8.79575387e-02f, -4.65463176e-02f, 1.22088511e-02f, 2.17240374e-03f, -5.06337509e-02f, 7.88540840e-02f, -4.05213386e-02f, -5.76276071e-02f, 1.33800134e-02f, 1.48050729e-02f,
  6.59151599e-02f, 1.34772984e-02f, 3.89272254e-03f, -3.08409333e-02f, 7.96058103e-02f, 2.07739267e-02f, 8.05538241e-03f, -6.28150348e-03f, 7.13304058e-03f, -1.32440927e-03f,
  -6.36355355e-02f, -7.38970889e-03f, 2.41971146e-02f, 2.47940123e-02f, -6.02633394e-02f, -3.47729167e-03f, -8.58335346e-02f, -5.94910011e-02f, 3.90307941e-02f, -2.32300013e-02f,
  -9.19827744e-02f, 3.52459103e-02f, 1.67366028e-01f, -2.66269177e-01f, 5.49202710e-02f, -7.51658753e-02f, -9.07121599e-02f, -6.07570782e-02f, -4.79216613e-02f, -3.24526936e-01f,
  -2.64946997e-01f, 5.79084978e-02f, 3.11218649e-02f, -2.38236487e-01f, 1.47404730e-01f, 1.38105795e-01f, -2.42589250e-01f, -8.15471560e-02f, 4.98098359e-02f, -1.75869241e-01f,
  2.16132272e-02f, -2.63212442e-01f, 1.04937486e-01f, -1.30727261e-01f, -1.24813892e-01f, -9.59702432e-02f, -7.59755373e-02f, 1.23301074e-01f, -1.21961996e-01f, 7.41409436e-02f,
  -1.85971141e-01f, -2.05025718e-01f, -1.21238947e-01f, -2.69719642e-02f, -1.36042282e-01f, 4.45290357e-02f, -4.79226895e-02f, 7.76659697e-02f, -7.02831969e-02f, -1.15655111e-02f,
  -1.48012554e-02f, -1.28441080e-02f, -3.16283666e-02f, 7.44259311e-03f, 4.11705626e-03f, -2.22095586e-02f, 7.84764811e-02f, -4.06667143e-02f, 2.59170160e-02f, 1.21798791e-01f,
  -5.86908683e-03f, -5.67247532e-02f, -6.28794581e-02f, -3.28861065e-02f, -5.85640664e-04f, -3.29564721e-03f, -2.35221423e-02f, 9.60906409e-03f, -3.29483747e-02f, 5.78866675e-02f,
  -6.29127845e-02f, -7.16661364e-02f, -5.11886962e-02f, 5.78980632e-02f, -6.20608665e-02f, 2.51869932e-02f, -9.18927416e-02f, -2.38766614e-02f, -7.14772660e-03f, -3.31469253e-02f,
  4.72802855e-02f, -2.43226625e-02f, 4.02633287e-02f, -4.33750488e-02f, -3.70896910e-03f, -1.78073477e-02f, 4.59651798e-02f, -1.53824119e-02f, 3.51739191e-02f, 6.99671656e-02f,
  -3.02530732e-02f, -4.00350392e-02f, 3.76261920e-02f, 6.09475859e-02f, 1.65549163e-02f, 1.11341327e-02f, -6.82062879e-02f, 2.19289884e-02f, -4.64552715e-02f, -3.19673344e-02f,
  -1.76816672e-01f, -3.36364418e-01f, -1.22147530e-01f, -7.84207955e-02f, -2.14628596e-03f, -8.95644072e-03f, -1.46195451e-02f, 2.15374790e-02f, -8.46576989e-02f, -4.02305126e-02f,
  -2.39970759e-02f, -2.36032270e-02f, -6.33460730e-02f, -4.09870334e-02f, -4.72582392e-02f, -9.43631381e-02f, -2.29335427e-02f, -1.08973183e-01f, -2.16724034e-02f, 5.05024642e-02f,
  6.62091002e-03f, -5.78755215e-02f, 1.76577102e-02f, -8.10570195e-02f, 1.46263475e-02f, -3.25441621e-02f, -4.73518483e-02f, 4.92850132e-02f, 9.38888453e-03f, -1.90649438e-03f,
  -1.70431033e-01f, -5.29781654e-02f, -1.77630529e-01f, -1.34243637e-01f, 1.64065864e-02f, -7.57409409e-02f, -2.74686992e-01f, 5.17320111e-02f, -1.46386847e-02f, 1.60484433e-01f,
  3.62839922e-02f, -4.28562760e-02f, -6.99611828e-02f, -3.82146597e-01f, -2.35429272e-01f, -2.56945133e-01f, -2.44167119e-01f, -1.66440368e-01f, -1.56215206e-01f, 4.48787771e-03f,
  -9.23317000e-02f, -1.88637212e-01f, -2.35668480e-01f, 1.88134536e-02f, -1.78951338e-01f, 1.25509679e-01f, 2.63765872e-01f, 6.21013306e-02f, -3.97999510e-02f, -3.66341099e-02f,
  -1.84859172e-01f, -1.98638849e-02f, -9.52286720e-02f, 5.06529510e-02f, 6.52724504e-02f, 1.24021843e-01f, 1.32240176e-01f, 2.77401432e-02f, 2.50378828e-02f, 2.44977139e-02f,
  3.16485427e-02f, 2.19203290e-02f, -7.93044120e-02f, 3.46566588e-02f, -3.19945440e-02f, 8.91204085e-03f, 5.66569082e-02f, 3.87612940e-03f, 8.11220929e-02f, 1.06035322e-02f,
  -1.01401351e-01f, -3.02456245e-02f, -2.42524128e-02f, 3.30665447e-02f, 1.12800989e-02f, 9.97410156e-03f, -6.86410232e-04f, -9.64035280e-03f, 3.36642936e-02f, -4.16388735e-02f,
  3.59888934e-02f, 1.21019684e-01f, -4.97238897e-02f, -1.35339960e-01f, -3.26788053e-02f, 7.95316324e-03f, -3.96893583e-02f, -3.45301218e-02f, -2.60905325e-02f, 7.09906146e-02f,
  -2.41426448e-03f, 5.46823964e-02f, -4.31372151e-02f, -1.22641986e-02f, 3.45897786e-02f, 1.63929595e-03f, -2.45352779e-02f, -3.27121653e-02f, 2.29803398e-02f, -8.71984810e-02f,
  2.98353061e-02f, -2.71929521e-02f, -5.96401505e-02f, -6.47876337e-02f, 1.74940750e-02f, -1.12104258e-02f, 5.89587318e-04f, 2.96545364e-02f, -6.92064986e-02f, 3.32042202e-02f,
  8.00700411e-02f, 2.24846885e-01f, -3.14424150e-02f, -2.64372234e-03f, -2.31170598e-02f, -9.20339720e-04f, 5.91209456e-02f, 2.79363357e-02f, 2.92475913e-02f, -7.87223577e-02f,
  4.73662540e-02f, 3.43660899e-02f, -1.97557500e-03f, -8.94550327e-03f, -1.60236179e-03f, -3.31045762e-02f, 2.49184556e-02f, 9.75975320e-02f, 5.68532012e-02f, 9.74110141e-02f,
  4.43102792e-02f, 7.09901825e-02f, 7.73797259e-02f, 1.60856713e-02f, -4.49354015e-03f, 9.08716768e-02f, 4.46672142e-02f, 4.73124795e-02f, 2.62111444e-02f, 5.09476885e-02f,
  4.15353835e-01f, 1.68964103e-01f, 3.36290658e-01f, 5.39072573e-01f, 2.22464465e-02f, -2.49648094e-01f, 5.49674444e-02f, 1.36372104e-01f, 4.53259408e-01f, -1.02104157e-01f,
  -1.29585966e-01f, 9.27159935e-02f, -1.93513066e-01f, -1.49466563e-02f, -1.75402418e-01f, -1.24736093e-01f, 3.96148562e-02f, 3.96941137e-03f, 1.93897933e-01f, 2.82568604e-01f,
  1.61593318e-01f, -1.85454443e-01f, 8.45966712e-02f, -1.99553058e-01f, 2.30498329e-01f, 1.82255134e-01f, -2.07212061e-01f, -1.09243184e-01f, -2.02048868e-02f, -1.38197348e-01f,
  -1.39670363e-02f, 2.77395338e-01f, 1.28048420e-01f, -5.51633723e-02f, 1.26798198e-01f, -6.07384415e-03f, 1.51322177e-02f, -3.87304798e-02f, 8.16440731e-02f, -3.47133689e-02f,
  2.08816659e-02f, -7.42044449e-02f, 1.33778853e-03f, -1.54758804e-03f, 1.03327364e-01f, 7.14134276e-02f, 9.05358195e-02f, 1.39710650e-01f, 6.85296729e-02f, 9.61833596e-02f,
  8.93796682e-02f, 5.94103299e-02f, 7.32835159e-02f, 3.04598603e-02f, 1.12232842e-01f, 8.78315866e-02f, -1.22224502e-02f, -2.25942191e-02f, 4.17595282e-02f, 1.10720083e-01f,
  1.09152094e-01f, -4.62377779e-02f, -6.26776069e-02f, 4.91335541e-02f, -5.55904098e-02f, -2.28578746e-02f, -9.25478637e-02f, -9.17970985e-02f, -5.04884645e-02f, -3.60502899e-02f,
  5.14548197e-02f, -9.07193962e-03f, 3.00905854e-02f, -4.46821824e-02f, 7.61083066e-02f, 1.65039692e-02f, -6.40993938e-03f, 1.72185246e-02f, 1.19943388e-01f, 1.22643951e-02f,
  -4.91441935e-02f, -4.88661751e-02f, -4.55943607e-02f, 4.76949327e-02f, -7.26421848e-02f, -6.41856641e-02f, -1.37268030e-03f, 1.94085445e-02f, 2.44007092e-02f, -4.83141188e-03f,
  -7.65222358e-03f, 1.67766377e-01f, 6.18330576e-02f, -4.90948372e-02f, -6.26061857e-02f, -2.45852359e-02f, -7.97413960e-02f, 5.60309505e-04f, -2.75318827e-02f, 4.15461138e-02f,
  2.22897939e-02f, 4.34974581e-02f, -7.50748441e-02f, -2.81649781e-03f, -8.04042667e-02f, -1.16537223e-02f, 1.07679628e-02f, -5.39835021e-02f, -3.94941792e-02f, -2.67256591e-02f,
  -5.28615378e-02f, -6.96640238e-02f, 6.14833273e-02f, 5.12871556e-02f, 1.01364795e-02f, -4.11045551e-02f, -8.53909776e-02f, 5.76403700e-02f, -4.90406230e-02f, -5.58198728e-02f,
  4.02231991e-01f, -2.34253734e-01f, -2.09859848e-01f, -1.57766178e-01f, -1.81828454e-01f, -2.72497714e-01f, -2.84675509e-01f, -3.22068036e-01f, -1.50916442e-01f, -2.80093163e-01f,
  -2.52207488e-01f, 1.42823830e-01f, 1.46578653e-02f, -2.66671300e-01f, 3.10042262e-01f, 9.49177071e-02f, -1.94624245e-01f, -7.65378401e-03f, -5.77089086e-04f, -1.84703976e-01f,
  6.15602033e-03f, -1.52136356e-01f, 4.34930176e-02f, -3.28777581e-01f, -1.94204733e-01f, -8.34289938e-02f, 6.12747762e-03f, -2.25679483e-02f, -2.16918498e-01f, 2.93481182e-02f,
  -1.19585823e-02f, -6.79575056e-02f, -6.43745586e-02f, 2.78099682e-02f, -4.52707522e-02f, 1.10408656e-01f, 4.08441052e-02f, 7.40108341e-02f, 8.71922970e-02f, 5.06423377e-02f,
  9.34948698e-02f, 8.21503550e-02f, -2.79049724e-02f, 4.04717810e-02f, -2.56619211e-02f, -3.24769355e-02f, 2.26722211e-02f, 5.50910048e-02f, -7.42691010e-02f, -1.11049572e-02f,
  -5.91003671e-02f, -4.44978923e-02f, -3.14971246e-02f, 8.76630321e-02f, 1.66792981e-02f, -7.52678467e-03f, 4.67513502e-02f, 5.94764091e-02f, -1.11571923e-02f, 7.89547116e-02f,
  -2.37569343e-02f, 5.37717976e-02f, -2.22079307e-02f, -2.70042140e-02f, -1.59647241e-02f, -3.75711918e-02f, 3.49721313e-02f, -1.47455325e-02f, -2.86285337e-02f, -5.88679239e-02f,
  -4.02734540e-02f, -6.44930378e-02f, -1.71171746e-03f, 8.10906477e-03f, 8.16712528e-02f, 7.96943009e-02f, -1.40266176e-02f, -1.41338985e-02f, -1.00414660e-02f, -3.22057419e-02f,
  -5.86028863e-03f, 1.00291772e-02f, -5.29854652e-03f, -1.53059780e-03f, -1.60369519e-02f, -6.96324110e-02f, 8.42145979e-02f, -6.34421334e-02f, 4.54531573e-02f, -5.89635298e-02f,
  -8.82887095e-02f, -1.48400977e-01f, -8.73398632e-02f, -6.17295206e-02f, -3.92198935e-02f, 3.81840616e-02f, 1.40218716e-02f, 2.82507632e-02f, -6.66088518e-03f, -8.47149044e-02f,
  -3.88350873e-03f, 1.84204557e-03f, -2.52342038e-02f, -2.51391972e-03f, -9.32345465e-02f, -1.15197189e-01f, -7.23912194e-02f, 5.16532734e-02f, -3.71608213e-02f, -6.43757507e-02f,
  -5.29632643e-02f, 3.62665318e-02f, 8.38322490e-02f, -7.60524571e-02f, -2.43138392e-02f, 5.37392497e-03f, -1.28608253e-02f, 6.80721551e-03f, 2.38942746e-02f, -3.04837059e-02f,
  8.02198946e-02f, -2.59541161e-02f, 8.26333985e-02f, 6.31441548e-03f, 9.79771093e-02f, 7.28320107e-02f, -1.32894767e-02f, 1.79190546e-01f, 5.99238038e-01f, -3.00197095e-01f,
  -3.67700368e-01f, -3.40142436e-02f, -2.44954489e-02f, -2.89409608e-01f, 3.49140912e-01f, 2.21297115e-01f, 9.57755670e-02f, -1.01203173e-01f, 2.90172666e-01f, -1.87385753e-01f,
  1.32106841e-01f, -4.36129570e-01f, -2.07885414e-01f, -2.18474343e-01f, -4.00230378e-01f, -1.67110354e-01f, -3.51128995e-01f, -4.00402062e-02f, -4.01490003e-01f, 2.03401111e-02f,
  -1.80741306e-02f, 4.41839620e-02f, -8.90059695e-02f, 1.30885299e-02f, 8.48543644e-02f, -4.40612361e-02f, -5.20650819e-02f, -6.97656646e-02f, 7.70089701e-02f, 1.16670787e-01f,
  -8.07163492e-02f, -4.53742556e-02f, 2.39203647e-02f, -2.79550496e-02f, 4.65153344e-02f, -3.28437053e-02f, 1.46861980e-02f, -3.27394418e-02f, -1.67024834e-03f, -1.39173232e-02f,
  -2.61662677e-02f, 3.71539546e-03f, -2.48521976e-02f, 4.44530584e-02f, 1.87729429e-02f, 5.82279339e-02f, 4.30129282e-02f, 3.14119719e-02f, 2.84642670e-02f, 1.17756642e-01f,
  -5.62738702e-02f, 1.60066307e-01f, 4.17519510e-02f, 2.08473150e-02f, -4.00480488e-03f, 1.43110463e-02f, -5.76509871e-02f, 3.45679261e-02f, 1.13299839e-01f, -9.43084508e-02f,
  3.33492905e-02f, -6.48055002e-02f, 1.20269567e-01f, -1.38657261e-03f, 8.78661685e-03f, -1.69636179e-02f, 4.83858865e-03f, 6.71498626e-02f, 4.93663661e-02f, -3.87833975e-02f,
  -1.07330328e-03f, 4.01190259e-02f, -8.58761072e-02f, -3.70424613e-02f, -1.20404493e-02f, -3.79945640e-03f, -8.66010860e-02f, 1.22448448e-02f, -3.09474710e-02f, -9.28473324e-02f,
  1.27954721e-01f, 1.95927471e-01f, -4.81141061e-02f, -5.47701195e-02f, 3.70514691e-02f, -1.00402609e-01f, 9.88147780e-03f, 1.67970697e-03f, 1.05665244e-01f, -5.06299473e-02f,
  -2.91423276e-02f, 2.26141252e-02f, 2.03539059e-03f, 3.21455747e-02f, 1.66494381e-02f, -2.46488322e-02f, -4.29650135e-02f, 6.61109686e-02f, 3.27439383e-02f, -6.24263771e-02f,
  -1.79095536e-01f, 2.79307645e-02f, 6.86622262e-02f, -6.11130372e-02f, -1.49338795e-02f, -4.70334031e-02f, 9.02611911e-02f, 5.03229164e-02f, -2.03407966e-02f, 2.19841097e-02f,
  2.89719343e-01f, -6.55249417e-01f, 8.78923982e-02f, 6.25690699e-01f, 2.80952036e-01f, -1.03364676e-01f, -1.74083978e-01f, 1.37349963e-01f, 1.98704928e-01f, -4.61643368e-01f,
  -5.29592596e-02f, -3.01540703e-01f, -5.64547122e-01f, 3.16194415e-01f, 3.33572507e-01f, -2.48687819e-01f, 1.46835148e-01f, -4.33824435e-02f, 5.18774688e-02f, 5.68100661e-02f,
  3.60971242e-01f, 3.19007158e-01f, 2.36733690e-01f, 2.34460115e-01f, 1.43681481e-01f, 2.29346931e-01f, 1.68094724e-01f, -9.25599784e-02f, 3.12545031e-01f, 1.27740324e-01f,
  -1.19983340e-02f, 2.23713880e-03f, -6.78574713e-03f, -4.36738841e-02f, -4.29127552e-02f, -8.89645424e-03f, -4.12843749e-02f, 4.82959813e-03f, 5.30324988e-02f, -3.52465957e-02f,
  -1.12892196e-01f, 8.24209750e-02f, 1.15867674e-01f, 1.14521638e-01f, 1.19024850e-01f, 9.34662595e-02f, 2.39971783e-02f, -5.92056923e-02f, 3.12792137e-02f, -1.20748892e-01f,
  -5.15525267e-02f, -6.72731400e-02f, 2.01055929e-02f, -2.18925811e-03f, 1.33474609e-02f, 6.30890280e-02f, -2.69198362e-02f, -5.72741814e-02f, -9.92786326e-03f, 3.14360708e-02f,
  -5.71505092e-02f, -6.49011806e-02f, -7.66077563e-02f, 9.65123549e-02f, 3.13158110e-02f, 8.28504860e-02f, 1.66730136e-02f, -2.03877408e-02f, 6.52152998e-03f, 8.66980292e-04f,
  6.52708486e-02f, -4.31367895e-03f, 1.73545051e-02f, -1.06015187e-02f, 1.26344748e-02f, -2.61862371e-02f, -4.14064601e-02f, 1.45771187e-02f, -1.25371423e-02f, 1.01893684e-02f,
  -5.49687147e-02f, 6.58412203e-02f, -7.10496008e-02f, 3.00908592e-02f, 5.19339256e-02f, -5.35388775e-02f, 3.79159972e-02f, -1.28287394e-02f, -1.97781883e-02f, 2.71198507e-02f,
  -1.83675393e-01f, -1.56844243e-01f, -3.24719697e-02f, 5.74805439e-02f, 3.54646170e-03f, -2.94900425e-02f, 1.86436083e-02f, 3.96969877e-02f, -7.61606032e-03f, 1.87931943e-03f,
  -1.79382414e-02f, 9.18482766e-02f, -4.36564647e-02f, -3.00577213e-03f, 2.29458846e-02f, -7.82103240e-02f, 1.91616174e-02f, -6.19231947e-02f, 6.48362264e-02f, 9.14229173e-03f,
  -4.24635522e-02f, -8.91505182e-02f, 4.95702177e-02f, -1.15132250e-03f, 6.53717071e-02f, -9.29456726e-02f, -3.04453243e-02f, -6.21316843e-02f, -1.57218110e-02f, -4.04031165e-02f,
  -8.26723054e-02f, -1.24101480e-03f, 3.11634928e-01f, 2.91726351e-01f, -1.55860484e-01f, -4.08325553e-01f, -2.25924790e-01f, -4.78926636e-02f, -1.84389904e-01f, -3.57766449e-01f,
  2.69341227e-02f, 1.52570009e-01f, -1.97184961e-02f, 2.47194499e-01f, 3.79119217e-01f, 1.68437496e-01f, 7.31741115e-02f, -6.07917495e-02f, 4.34643887e-02f, 1.37623772e-01f,
  2.09576085e-01f, 1.74955860e-01f, 4.25058454e-01f, 1.85428172e-01f, 1.36625096e-01f, 2.70076603e-01f, 3.22155327e-01f, 2.10196868e-01f, 2.98492670e-01f, 1.78440392e-01f,
  -2.08964065e-01f, 6.13642782e-02f, 2.76560560e-02f, -6.37176409e-02f, -7.69715682e-02f, -1.15140721e-01f, 4.75194231e-02f, 6.45174757e-02f, 6.62511811e-02f, -1.33829676e-02f,
  -4.86379564e-02f, 3.33951041e-02f, 5.84039688e-02f, -1.38373149e-03f, -6.07753024e-02f, -1.61361787e-02f, -1.14498949e-02f, -5.54011390e-02f, -1.53386658e-02f, 8.44371412e-03f,
  -3.48458104e-02f, -1.31914159e-02f, -5.69797792e-02f, 5.17510213e-02f, 1.18368365e-01f, -1.16922269e-02f, -2.98729949e-02f, 8.16441849e-02f, 3.68185826e-02f, 3.67793487e-03f,
  -7.49693885e-02f, 1.93203278e-02f, -5.71737066e-03f, -3.83581705e-02f, 3.57677303e-02f, 1.10636267e-03f, -1.13661243e-02f, 1.07152611e-02f, 5.93944527e-02f, -1.83491607e-03f,
  -5.30008646e-03f, 6.46600276e-02f, -4.13099788e-02f, -1.13656530e-02f, -1.47656538e-02f, 7.32817501e-03f, 6.11255178e-03f, -1.89219147e-03f, -5.52997477e-02f, 5.58437780e-02f,
  4.52404395e-02f, 4.03857641e-02f, 4.47777621e-02f, -6.32310100e-03f, -8.75387266e-02f, 3.49138416e-02f, 5.50506301e-02f, -1.40902018e-02f, -3.06345653e-02f, 4.43575718e-02f,
  -9.18822363e-02f, 3.56414825e-01f, 3.15979123e-02f, -9.01137814e-02f, 3.23486775e-02f, -1.97513588e-03f, 4.08731289e-02f, 3.00283581e-02f, 3.58941816e-02f, 4.89215031e-02f,
  -5.22133484e-02f, -1.13713201e-02f, -8.10966343e-02f, 5.53519987e-02f, 1.13523873e-02f, 2.04776432e-02f, 7.09250718e-02f, 5.47557808e-02f, 2.73195542e-02f, 8.30928534e-02f,
  4.34301123e-02f, -1.89363677e-02f, 7.81237930e-02f, -2.58670505e-02f, -5.33121265e-02f, -1.03625236e-02f, 1.36914093e-03f, 6.78515434e-02f, 8.18502977e-02f, 4.47643958e-02f,
  3.51264805e-01f, -1.79398984e-01f, -4.61422116e-01f, -4.08692956e-02f, 2.08916366e-01f, 2.99865007e-01f, 1.30501404e-01f, 2.21833531e-02f, -3.50876339e-02f, 7.10148513e-02f,
  1.68623313e-01f, -6.21779636e-02f, -2.34942526e-01f, 8.75320062e-02f, 1.59906030e-01f, -2.12796122e-01f, 2.47495785e-01f, 6.14227057e-02f, -6.64025545e-02f, 7.48332515e-02f,
  -1.15384720e-01f, 3.08247417e-01f, -3.02835047e-01f, 1.61927193e-01f, 2.24591240e-01f, -6.98176324e-02f, 1.03298157e-01f, -3.76000851e-02f, 2.20737487e-01f, 2.73720890e-01f,
  8.47344403e-04f, 1.52156465e-02f, -6.22150302e-02f, 5.80211356e-02f, -5.60631566e-02f, 1.30721405e-01f, -1.22710643e-02f, 9.62101370e-02f, -8.25452060e-02f, 2.85038408e-02f,
  -1.08028436e-02f, 1.62801966e-02f, 1.74631644e-02f, 3.54182199e-02f, 1.92895380e-03f, -8.16682205e-02f, -1.37880951e-01f, -1.39716506e-01f, -1.54372916e-01f, -2.33798865e-02f,
  -1.23296469e-01f, 1.31718034e-03f, -3.38838585e-02f, -7.17113540e-02f, -2.49409843e-02f, -1.77203119e-02f, -8.66846517e-02f, 2.91398191e-03f, 1.29637318e-02f, 8.84019211e-02f,
  4.10607085e-02f, 1.22045144e-01f, 4.38224226e-02f, 3.64420414e-02f, 7.64564425e-02f, 1.87103804e-02f, -3.26768160e-02f, -5.11329472e-02f, 1.82941202e-02f, -1.46841789e-02f,
  2.29522679e-02f, -6.69531524e-02f, 2.10188683e-02f, 6.23789728e-02f, 3.68677564e-02f, 9.72191803e-03f, -2.60006562e-02f, -1.84795260e-02f, -9.94935036e-02f, -1.20436922e-01f,
  1.05352588e-02f, 5.98794483e-02f, -7.19985589e-02f, -7.35841319e-02f, -4.35061716e-02f, -1.73881594e-02f, 6.84611276e-02f, 5.64829856e-02f, -7.41741434e-02f, -2.19449401e-03f,
  5.05960286e-02f, 2.32018560e-01f, -2.48752125e-02f, -7.38041699e-02f, -1.01507939e-02f, 1.51610017e-01f, 1.08907647e-01f, -8.46639555e-03f, 7.54539520e-02f, -4.05356893e-03f,
  4.97364812e-02f, -1.93974841e-02f, 7.76005760e-02f, 4.19879891e-02f, -2.50625331e-02f, 9.85559523e-02f, 2.47715926e-03f, 5.74638620e-02f, 3.78461219e-02f, 2.29252968e-02f,
  3.11330371e-02f, 4.49018329e-02f, -4.58276868e-02f, 2.77005509e-03f, -6.63679093e-02f, 5.63520938e-02f, 1.65806543e-02f, -3.60086150e-02f, 9.02186185e-02f, -4.12543751e-02f,
  -2.26484790e-01f, 1.57722503e-01f, -4.39395130e-01f, -4.04929034e-02f, -2.46207446e-01f, -1.45295277e-01f, 9.90462527e-02f, -3.94593365e-02f, -6.99269623e-02f, 6.59117520e-01f,
  3.62563670e-01f, -2.22908795e-01f, 3.47195983e-01f, 2.20952600e-01f, -3.12907010e-01f, 4.67511490e-02f, 2.24490076e-01f, 1.04024053e-01f, -1.20531924e-01f, 1.62748903e-01f,
  -6.64221495e-02f, 3.56986403e-01f, -1.29296616e-01f, 1.54203936e-01f, 5.22251800e-02f, -3.21861915e-02f, 2.80262113e-01f, -6.94142506e-02f, 1.19675994e-01f, -1.14817396e-01f,
  2.88531650e-02f, 8.83509889e-02f, -5.47508411e-02f, -1.75433919e-01f, 5.44048734e-02f, 6.39192313e-02f, -5.68136238e-02f, -1.12376474e-01f, -1.64423496e-01f, -4.99984296e-03f,
  -2.36428361e-02f, -8.36928859e-02f, 3.14019881e-02f, -1.02102794e-01f, -2.19661351e-02f, -6.33625537e-02f, -6.02722950e-02f, -2.93079764e-02f, 1.23217506e-02f, -1.33415982e-01f,
  -9.26751345e-02f, -4.17390019e-02f, 1.06165178e-01f, 1.09050713e-01f, -1.44305862e-02f, 2.56030634e-02f, 7.30933016e-03f, 3.61209060e-03f, 5.39907701e-02f, -3.15124877e-02f,
  4.86394726e-02f, 1.85006135e-03f, 3.71758342e-02f, -5.57321534e-02f, -8.84670019e-02f, 1.75950602e-02f, 7.69831613e-02f, 8.06604028e-02f, -5.16309813e-02f, 2.15325132e-02f,
  2.85948664e-02f, -6.72609136e-02f, 5.07951491e-02f, 5.83491363e-02f, 2.60183346e-02f, -3.64180766e-02f, 4.20624912e-02f, 6.54944554e-02f, 1.95983257e-02f, -4.77905348e-02f,
  -6.60344912e-03f, 1.06661581e-02f, -8.10368545e-03f, 1.17084809e-01f, -6.86342344e-02f, 2.33778767e-02f, 9.00111198e-02f, 1.38783990e-03f, 8.61694850e-03f, -1.30171813e-02f,
  3.00707556e-02f, 3.33877981e-01f, 3.45524214e-02f, -4.32878509e-02f, 8.86957422e-02f, 1.76368803e-02f, -4.06951271e-03f, -8.78664255e-02f, 4.71591987e-02f, 3.21758091e-02f,
  6.53051808e-02f, 5.21963462e-02f, -2.48976192e-03f, 1.10970223e-02f, 2.90108547e-02f, 4.67930622e-02f, 1.04568973e-01f, -5.31695485e-02f, 7.96641186e-02f, -3.27077881e-02f,
  1.29631953e-02f, 9.45796371e-02f, 4.60243560e-02f, -5.55551089e-02f, 6.71331212e-02f, 3.27794328e-02f, 1.87048167e-02f, -1.02519873e-03f, -4.23873737e-02f, 3.96646075e-02f,
  2.63704151e-01f, -3.59086841e-01f, 9.37019140e-02f, 1.20112188e-01f, 1.27831906e-01f, 1.46548375e-01f, 2.70583212e-01f, -4.92282361e-02f, 2.87628192e-02f, -3.66338044e-01f,
  1.03002256e-02f, -3.99732180e-02f, 1.72273293e-01f, -1.12227738e-01f, 2.12486222e-01f, 1.62122935e-01f, -1.25204235e-01f, -5.57925440e-02f, -5.77982515e-03f, 1.02422126e-02f,
  3.22883413e-03f, -4.38071787e-02f, -3.67361568e-02f, -2.60169595e-01f, -4.29257676e-02f, -2.14863777e-01f, -8.87700617e-02f, 1.64188549e-01f, -2.75954783e-01f, 8.43173340e-02f,
  -2.20818222e-02f, 2.95644049e-02f, 9.95190442e-02f, -3.58566679e-02f, 8.14460292e-02f, -4.06184606e-02f, 6.05360195e-02f, 4.18988466e-02f, -2.41555367e-02f, -1.33873941e-02f,
  5.96466660e-02f, -7.09578544e-02f, -1.14327662e-01f, 5.13526574e-02f, 5.90394251e-02f, -6.61143735e-02f, -1.08947612e-01f, -5.29097840e-02f, -1.00833379e-01f, -7.64381886e-02f,
  1.08950716e-02f, -6.97744414e-02f, 6.92021241e-03f, -1.20611310e-01f, 5.38416654e-02f, -5.59688732e-02f, -2.54140496e-02f, 1.01516247e-01f, 4.32330854e-02f, 2.16197930e-02f,
  3.13159078e-02f, 9.26742144e-03f, 1.17915817e-01f, 7.43411705e-02f, 9.13100168e-02f, 2.98551694e-02f, 1.76295415e-02f, -1.68419853e-02f, 1.10031161e-02f, 8.56492743e-02f,
  6.35930449e-02f, 1.87123157e-02f, -5.69756050e-03f, -3.71457525e-02f, -5.57978563e-02f, -3.49449180e-02f, -5.62438071e-02f, -3.71285304e-02f, 2.51586437e-02f, -1.06656484e-01f,
  -8.50600973e-02f, 1.75194256e-02f, 1.02165283e-03f, -1.82732996e-02f, 3.67608480e-02f, -3.94207751e-03f, -6.05189689e-02f, 3.11535113e-02f, -1.68140158e-02f, -1.72999240e-02f,
  -9.88782495e-02f, -6.98452964e-02f, 4.50254604e-02f, -2.27026157e-02f, -1.28761560e-01f, 4.15104553e-02f, 4.47443454e-03f, -4.12135981e-02f, 5.18687740e-02f, -5.36595024e-02f,
  -2.17279997e-02f, -2.59170793e-02f, -4.77498360e-02f, 1.57757029e-02f, -9.18693617e-02f, -1.00206546e-02f, -3.40910815e-02f, -7.22803175e-02f, 2.87977103e-02f, -1.10307574e-01f,
  -3.56068537e-02f, 5.19470870e-03f, 4.33823504e-02f, -7.38256276e-02f, -7.81801622e-03f, -8.45716670e-02f, -4.94348630e-02f, 3.13338488e-02f, 4.30565979e-03f, -1.28621176e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  3.75575691e-01f, 3.08152556e-01f, 2.29674205e-01f, 4.50427592e-01f, 3.11787903e-01f, 3.36005658e-01f, 3.47695291e-01f, 1.52217597e-01f, 4.52738851e-01f, 2.08964288e-01f,
  1.87572196e-01f, 3.24839115e-01f, 5.27782559e-01f, 1.75308809e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -4.99283880e-01f, -4.18657750e-01f, 3.45027834e-01f, 5.06686211e-01f, -1.31380245e-01f, -1.07537575e-01f, 2.18584836e-01f, 1.32960185e-01f, 3.93976659e-01f, -8.48588586e-01f,
  -6.34856999e-01f, 3.63698781e-01f, 2.72562325e-01f, -6.05328739e-01f, 8.21977615e-01f, 2.25289881e-01f, 5.49367309e-01f, 5.62933624e-01f, -3.33536744e-01f, -8.78738761e-02f,
  -1.86118960e-01f, 5.06276898e-02f, -2.12651387e-01f, -2.76115328e-01f, -1.96128637e-01f, -3.35716099e-01f, -4.50857878e-01f, -3.82270277e-01f, -1.73951700e-01f, -2.19229475e-01f,
  8.48181784e-01f, -1.02488855e-02f, 3.69321436e-01f, -6.88738301e-02f, -5.46210408e-01f, 2.66504943e-01f, -6.09205961e-01f, -9.90887284e-02f, -6.95003867e-02f, 2.46514782e-01f,
  2.38633499e-01f, 2.94811219e-01f, -4.24735457e-01f, 2.39203572e-01f, -5.56133389e-01f, -6.47023559e-01f, -6.06893599e-01f, -8.14894497e-01f, 5.24152875e-01f, -3.01137835e-01f,
  -3.78673494e-01f, 2.81747669e-01f, -1.82573140e-01f, -1.77372560e-01f, -3.00731301e-01f, -2.08315849e-01f, -3.15809429e-01f, 3.49337935e-01f, -4.89455223e-01f, -1.81870773e-01f,
  -2.87713259e-01f, 8.99949908e-01f, 4.44790661e-01f, 1.97045013e-01f, -4.22889620e-01f, -1.07651791e-02f, -2.02657133e-01f, -2.46818781e-01f, 1.26853094e-01f, -2.07416117e-01f,
  -4.37411040e-01f, 1.25485854e-02f, 2.09244061e-02f, 3.46856922e-01f, -2.35026404e-01f, 2.76473731e-01f, 2.09607229e-01f, -2.69340962e-01f, -1.41034350e-01f, -5.11713624e-01f,
  -3.41903716e-01f, 5.22018671e-01f, -2.29953289e-01f, -1.58933580e-01f, -1.38394624e-01f, -2.82835662e-01f, -1.70013338e-01f, 4.26554717e-02f, -3.90947253e-01f, 7.59688169e-02f,
  -2.81814069e-01f, 1.16853082e+00f, 2.35728934e-01f, 2.58754343e-01f, -4.35514063e-01f, -2.81568974e-01f, 2.58195281e-01f, -2.04915181e-01f, -9.99974236e-02f, -6.33749962e-01f,
  2.58747131e-01f, -5.97326815e-01f, -4.52783294e-02f, 3.48891271e-03f, -1.05567060e-01f, -5.01398921e-01f, 6.50998056e-01f, -6.22396648e-01f, 4.94009286e-01f, 3.27695489e-01f,
  5.35479128e-01f, 6.12428963e-01f, -3.15642923e-01f, -2.25561857e-01f, -1.29297912e-01f, 1.43313855e-01f, 1.00387406e+00f, -1.89235270e-01f, 1.76276013e-01f, 3.28640938e-01f,
  -1.14918485e-01f, -3.82963330e-01f, -3.32546800e-01f, -1.84170663e-01f, -8.97987559e-03f, -1.55501008e-01f, 2.91866541e-01f, 1.09962769e-01f, -1.93738177e-01f, 6.33342445e-01f,
  3.22556168e-01f, 4.02491778e-01f, 3.79017502e-01f, -2.62022436e-01f, 2.49672621e-01f, 4.23390746e-01f, 5.34821510e-01f, 1.78350545e-02f, -3.46322566e-01f, 1.31309718e-01f,
  1.06102538e+00f, 1.58010125e-01f, 7.52438784e-01f, 4.65944707e-01f, -1.84880629e-01f, -3.52708250e-01f, 1.88758835e-01f, 1.68166950e-01f, -3.25839594e-02f, 9.12584245e-01f,
  5.17467499e-01f, -3.61403897e-02f, -2.81346887e-01f, -1.72964782e-01f, 3.13837081e-01f, -3.62467766e-01f, 6.57188967e-02f, -2.66982436e-01f, -4.78425413e-01f, -1.71189718e-02f,
  2.49525402e-02f, 1.15962356e-01f, 3.52579713e-01f, -5.05027324e-02f, 7.28096008e-01f, 2.79427916e-01f, 8.33760574e-02f, -4.73989666e-01f, 4.10811812e-01f, -5.47850847e-01f,
  -2.99123853e-01f, 4.33499634e-01f, -6.51819885e-01f, -1.09683312e-01f, -2.95536578e-01f, 7.27945566e-02f, 9.32319343e-01f, -4.78698552e-01f, 1.91141650e-01f, 5.52969158e-01f,
  -1.46276191e-01f, -1.76349506e-01f, -1.80997133e-01f, 3.45005579e-02f, 1.66616634e-01f, -2.26826876e-01f, 8.03594589e-01f, -2.75827527e-01f, -1.27229273e-01f, 1.13427125e-01f,
  -4.90424335e-02f, 1.53061403e-02f, 1.25278741e-01f, 4.42445397e-01f, -1.98367253e-01f, -2.18931362e-01f, 1.36618003e-01f, 1.13406658e-01f, 1.38104437e-02f, -1.24311924e-01f,
  -2.26972654e-01f, 4.48390812e-01f, -1.59152281e-02f, 4.99303848e-01f, 6.06429875e-02f, 3.57686371e-01f, -5.85406125e-01f, 5.90820432e-01f, -5.26547849e-01f, 3.92304152e-01f,
  3.59016120e-01f, -4.62545641e-02f, 2.70510525e-01f, -5.83738089e-01f, -3.51321287e-02f, -1.73977926e-01f, 6.73708677e-01f, -9.53462496e-02f, 4.90253657e-01f, 6.52380824e-01f,
  -6.15558028e-01f, -2.16147676e-01f, -3.32518756e-01f, 4.10857439e-01f, -1.85997531e-01f, -4.34560180e-02f, -2.48744145e-01f, 1.40982389e-01f, -3.24823290e-01f, -2.04195067e-01f,
  -3.90844911e-01f, -1.85478032e-01f, -1.57990009e-01f, 3.17203969e-01f, 4.42522764e-01f, -4.59681809e-01f, 2.74072774e-02f, 2.22215608e-01f, 2.88934916e-01f, -4.50868681e-02f,
  3.60566467e-01f, 2.99658239e-01f, -1.74770370e-01f, -3.24817479e-01f, 2.69657940e-01f, -6.27700686e-02f, 4.99846160e-01f, 3.68689954e-01f, -3.26385826e-01f, 7.91891396e-01f,
  5.50000191e-01f, -3.15020233e-01f, 1.25519074e-02f, -3.28971356e-01f, -2.48745278e-01f, 1.33444622e-01f, -2.87985444e-01f, 5.21594808e-02f, -4.90062609e-02f, 8.98519997e-03f,
  -1.84742257e-01f, -1.97484002e-01f, -9.56536504e-04f, -2.10623294e-01f, -2.94456065e-01f, 4.15371031e-01f, -1.29601536e-02f, -6.72796190e-01f, -2.34767810e-01f, -2.56946772e-01f,
  -1.49534643e-01f, 1.57942951e-01f, 2.65315980e-01f, -4.45223600e-01f, 2.47503832e-01f, -2.68759400e-01f, -1.79465562e-01f, 4.02956530e-02f, -2.90770501e-01f, 1.26031369e-01f,
  4.26194102e-01f, -2.07832634e-01f, -3.08160394e-01f, 3.46792161e-01f, 9.88685668e-01f, -2.98646837e-01f, 3.84637713e-01f, -1.49456427e-01f, 5.26749671e-01f, -1.52939841e-01f,
  2.75477797e-01f, -2.37244338e-01f, -1.55181721e-01f, 3.36167604e-01f, -1.70434639e-02f, 4.00675595e-01f, -5.40202320e-01f, 2.25904733e-02f, -4.67045844e-01f, 2.18072116e-01f,
  -1.03938258e+00f, 5.67657113e-01f, 1.93629012e-01f, 3.55363488e-01f, -4.59955603e-01f, 6.10999465e-01f, -2.76169568e-01f, -4.10233140e-01f, -1.17655307e-01f, 6.13792121e-01f,
  3.42249483e-01f, -1.36016697e-01f, -2.84480751e-01f, 3.08404416e-01f, -2.97913663e-02f, -2.00759217e-01f, 1.84814855e-01f, -1.79862976e-01f, -4.11877900e-01f, 7.02045202e-01f,
  2.86189139e-01f, -2.98038572e-01f, 2.38464743e-01f, 3.06756571e-02f, 1.83076765e-02f, 6.07249916e-01f, 7.46666789e-02f, -5.18166181e-03f, -2.23993033e-01f, 5.41214526e-01f,
  8.85890484e-01f, -5.05772419e-02f, 6.29773021e-01f, -6.56766295e-01f, -1.97635248e-01f, -3.70819956e-01f, -7.75117874e-01f, -6.38864517e-01f, -2.71489948e-01f, -2.79187411e-01f,
  -7.42903650e-02f, 2.73199558e-01f, -2.96369880e-01f, 7.85695076e-01f, -5.60125560e-02f, -2.61125624e-01f, -2.54828632e-01f, -2.28437662e-01f, -4.14833754e-01f, 2.81302303e-01f,
  4.78635937e-01f, -1.55092373e-01f, 2.55810946e-01f, -1.96652442e-01f, -2.64069796e-01f, 2.84081042e-01f, -5.98112121e-02f, 1.66611582e-01f, 1.69716752e-03f, 1.11952856e-01f,
  1.38246462e-01f, -4.32660580e-01f, 6.78780675e-01f, -6.98647559e-01f, -1.52581304e-01f, 3.59540701e-01f, -2.24376768e-01f, -4.85324591e-01f, -3.90687734e-01f, 7.37368613e-02f,
  1.03142655e+00f, 3.24472457e-01f, -3.28042477e-01f, 1.80895589e-02f, 5.49069792e-02f, 5.24389595e-02f, 6.63975239e-01f, 2.26255544e-02f, -2.59221494e-01f, -4.35830623e-01f,
  -2.14105323e-01f, -4.07571524e-01f, -2.00570613e-01f, -3.48471165e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  3.20087582e-01f, 1.32742450e-01f, -1.44625798e-01f, -6.76459521e-02f, -3.74521539e-02f, -1.01259172e-01f, 3.96245066e-03f, -3.78937244e-01f, -2.94361979e-01f, 9.29413438e-02f,
  1.76284283e-01f, 6.82984591e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    