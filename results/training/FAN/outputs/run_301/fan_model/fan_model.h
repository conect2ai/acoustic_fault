/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.50214031e-01f, -5.28140068e-02f, -1.00603744e-01f, 7.16416761e-02f, -7.56212464e-03f, 2.03760505e-01f, 1.54110789e-01f, -1.11153066e-01f, -1.14928238e-01f, 9.39549506e-02f,
  1.09028108e-01f, -7.84517974e-02f, 1.42798964e-02f, 8.68360698e-02f, 2.29249030e-01f, 1.16356025e-02f, 2.54095316e-01f, 1.52072072e-01f, -6.72704652e-02f, -1.75014045e-02f,
  6.80325329e-02f, 2.04906806e-01f, 6.75014481e-02f, 6.93290681e-02f, 2.15363670e-02f, -1.36145800e-01f, 1.25628024e-01f, -6.62677810e-02f, 1.78429082e-01f, 4.44450155e-02f,
  4.44709100e-02f, -1.20683886e-01f, -9.88820419e-02f, -7.46350512e-02f, 5.93305714e-02f, 1.66377984e-02f, 1.08847477e-01f, -2.75601428e-02f, -4.69332114e-02f, 3.54420580e-03f,
  4.02355231e-02f, -4.88660745e-02f, -6.35570660e-02f, -2.88171577e-03f, 1.09752435e-02f, -6.67235989e-04f, 3.71646718e-03f, 1.56453345e-02f, -5.07092029e-02f, 4.57606725e-02f,
  3.03817000e-02f, 4.10602316e-02f, -6.06106110e-02f, 5.52466288e-02f, 3.91280726e-02f, -3.76246572e-02f, 5.28828949e-02f, 4.06808816e-02f, 4.44040410e-02f, 2.86956262e-02f,
  3.97456288e-02f, 1.38156386e-02f, 9.07562859e-03f, -8.11396260e-03f, 5.28741488e-03f, 8.81052855e-03f, 2.29360126e-02f, 4.72541936e-02f, -2.77710762e-02f, 3.57921384e-02f,
  -4.89101261e-02f, -2.31464691e-02f, 3.77680659e-02f, 5.36251701e-02f, 1.37495557e-02f, -8.13682526e-02f, 6.60598353e-02f, -2.59826239e-02f, -6.99811790e-04f, 4.28495072e-02f,
  -2.49382351e-02f, 3.85253169e-02f, -2.88654976e-02f, 7.64116272e-03f, -7.43781775e-03f, -2.02502683e-02f, 3.34857255e-02f, -4.59537841e-02f, 5.22776283e-02f, 5.87785542e-02f,
  1.68398187e-01f, 8.68160427e-02f, 1.43818455e-02f, 5.31729311e-03f, -2.06129349e-04f, -3.30074131e-02f, -1.15331179e-02f, -2.21312121e-02f, 2.00160332e-02f, -8.74101766e-04f,
  6.93246424e-02f, -9.87654552e-03f, 2.51123738e-02f, -6.23810813e-02f, 2.81449761e-02f, 4.76513021e-02f, 7.56256431e-02f, -1.14767589e-02f, 2.74453610e-02f, 1.55377667e-02f,
  -1.96663216e-02f, 6.90517575e-02f, 3.42825353e-02f, -1.23521909e-02f, 2.40454394e-02f, -3.75108756e-02f, 3.67059372e-02f, -7.00659379e-02f, 4.59647505e-03f, 1.95651525e-03f,
  -1.89343631e-01f, 9.32650343e-02f, 1.67203054e-01f, -9.88411605e-02f, 2.15756968e-01f, 1.90459982e-01f, -4.18459065e-02f, 1.02356344e-01f, 3.08960173e-02f, -7.24741369e-02f,
  1.31641224e-03f, 4.92804833e-02f, 5.11566140e-02f, -6.17310293e-02f, -4.16437298e-01f, -6.39393628e-02f, -1.11379206e-01f, -3.19490093e-03f, 1.59317419e-01f, 1.06423134e-02f,
  6.75520003e-02f, -2.04558045e-01f, 1.03690550e-02f, 1.45399690e-01f, 1.07125960e-01f, 1.48164406e-01f, -3.04413974e-01f, 1.21605881e-01f, -1.09952964e-01f, -7.99243003e-02f,
  6.29373565e-02f, 1.32589370e-01f, -2.37732399e-02f, 4.89639230e-02f, 5.87711968e-02f, -1.22420406e-02f, -4.69868071e-02f, -9.84984040e-02f, 2.58909464e-02f, 2.06041941e-03f,
  7.40366504e-02f, -7.29628326e-03f, -3.49530727e-02f, -2.83406135e-02f, 5.30007035e-02f, 1.17169740e-02f, 1.01210259e-01f, 9.99494717e-02f, 5.22291102e-02f, 8.61290023e-02f,
  1.41868442e-01f, 1.13836966e-01f, 3.64276133e-02f, -1.37009304e-02f, 4.97532673e-02f, 3.40697393e-02f, -4.13824320e-02f, -2.98445541e-02f, 3.28523479e-02f, 1.86309889e-02f,
  -5.52402362e-02f, -2.26492845e-02f, 4.96149920e-02f, 5.96652785e-03f, -2.27199346e-02f, -3.80614214e-02f, 5.07632270e-03f, -8.81601796e-02f, 2.31685992e-02f, -2.00470034e-02f,
  2.73113959e-02f, -5.93706220e-02f, 6.14178143e-02f, 5.23282960e-02f, 5.62096722e-02f, -2.46680155e-02f, -7.19970539e-02f, 2.09110677e-02f, 5.36358580e-02f, -3.06219161e-02f,
  -5.77555224e-02f, -5.14944866e-02f, 2.13267226e-02f, -4.95869666e-03f, 1.42356222e-02f, 5.27083967e-03f, 7.31584802e-02f, 1.56082883e-02f, 1.83927920e-02f, -4.22886722e-02f,
  -6.37754425e-02f, -2.27870077e-01f, 5.77390864e-02f, -1.61570236e-02f, -6.42993450e-02f, -7.61068687e-02f, 5.45609929e-03f, -1.83814077e-03f, -7.10152760e-02f, -3.21672327e-04f,
  6.05898313e-02f, -1.17965310e-03f, -3.36106606e-02f, -4.79211770e-02f, 1.76229905e-02f, -2.66693365e-02f, -5.00565059e-02f, -6.13872781e-02f, -6.76184073e-02f, -5.26211970e-02f,
  -2.91199274e-02f, -3.89388017e-03f, -3.10460571e-02f, 3.74681801e-02f, -3.10349017e-02f, -5.96809275e-02f, 2.95905978e-03f, -2.06072908e-02f, 6.68213796e-03f, -2.80889776e-02f,
  -1.42017439e-01f, 3.52433890e-01f, -3.39300752e-01f, -1.30854681e-01f, 2.79463883e-02f, 2.31101289e-01f, -1.02892131e-01f, 6.23927340e-02f, -2.17885301e-02f, 3.20306420e-01f,
  4.68003377e-02f, -6.97564930e-02f, 2.93422211e-02f, 1.90915689e-01f, -3.18418682e-01f, 1.04402415e-01f, 1.13047212e-01f, 1.04765229e-01f, 6.68196240e-03f, 1.09086715e-01f,
  -1.17638707e-01f, 2.01610580e-01f, -2.38705024e-01f, 1.58809945e-01f, -3.37509206e-03f, -1.46879777e-01f, 3.88173759e-02f, -1.17360666e-01f, 1.14885971e-01f, -9.44297761e-02f,
  1.13833517e-01f, -2.34417729e-02f, -2.72539984e-02f, 3.82437147e-02f, 1.99860008e-03f, 7.46753591e-04f, 1.16486372e-02f, -8.21680427e-02f, -8.23348612e-02f, 5.34772594e-03f,
  1.32660428e-02f, -1.55180981e-02f, -3.10707074e-02f, -1.15390448e-02f, 1.03492737e-02f, -4.01879586e-02f, -4.08294797e-02f, -1.91844273e-02f, 3.93786356e-02f, -5.08162454e-02f,
  -2.34875418e-02f, -9.77609656e-04f, 7.17830611e-03f, 1.71543807e-02f, -1.26200750e-01f, -1.63685028e-02f, -3.42350043e-02f, -6.16053343e-02f, 8.37341975e-03f, 2.95408182e-02f,
  -5.34429513e-02f, -2.48288717e-02f, 4.60526207e-03f, 1.82604995e-02f, 2.96371169e-02f, -1.02566434e-02f, 4.89423610e-02f, -2.23380812e-02f, -2.21149512e-02f, 1.35398032e-02f,
  -1.92165188e-02f, -2.32833680e-02f, 1.73076540e-02f, 1.84978805e-02f, 3.79600525e-02f, 4.69773784e-02f, -3.53851058e-02f, 9.61720273e-02f, -6.87788427e-03f, -2.86905970e-02f,
  -8.05210229e-03f, 2.08557881e-02f, 1.39322840e-02f, 2.77046878e-02f, 7.51958368e-03f, -2.22561546e-02f, 1.20709226e-01f, 2.59265695e-02f, -3.56404227e-03f, -6.21705130e-02f,
  4.15508062e-01f, 1.81218550e-01f, 5.02241701e-02f, 7.32020810e-02f, 5.85016496e-02f, 4.08666357e-02f, 3.59446071e-02f, 3.97467464e-02f, 2.26336550e-02f, 7.15174079e-02f,
  3.10042910e-02f, 2.30483478e-03f, 3.33225615e-02f, -1.11336093e-02f, -6.48641065e-02f, 7.37611344e-03f, 3.61078084e-02f, 1.88911539e-02f, 5.55656850e-03f, 7.45925903e-02f,
  5.92804030e-02f, 1.57354865e-02f, -6.38119802e-02f, -2.92712506e-02f, 2.20305938e-02f, -2.12031659e-02f, 3.69259864e-02f, -3.42632867e-02f, 1.15684364e-02f, 1.20250881e-02f,
  3.26212168e-01f, -7.19136223e-02f, -2.41544768e-01f, 1.36902288e-01f, 1.37089998e-01f, 2.42669418e-01f, 1.44808620e-01f, 1.21669695e-01f, 9.59289167e-03f, 1.59176383e-02f,
  -1.52458418e-02f, -1.64863244e-01f, -1.91292375e-01f, 2.44197920e-02f, 8.74180049e-02f, -1.95980057e-01f, 2.63747066e-01f, 9.88482386e-02f, -9.57732201e-02f, 1.79198444e-01f,
  -3.94103639e-02f, 1.49825662e-01f, -1.62623957e-01f, -4.18637171e-02f, 7.94265494e-02f, -5.39070219e-02f, -7.96660956e-04f, -1.93856984e-01f, 1.29797786e-01f, -9.64527484e-03f,
  4.90211286e-02f, -7.32338354e-02f, -3.63361835e-02f, -7.30621293e-02f, 1.48194030e-01f, 1.22881252e-02f, -3.62459943e-02f, -1.11051038e-01f, -6.62287623e-02f, 4.74615581e-03f,
  2.08262242e-02f, -2.12327149e-02f, 6.72595873e-02f, -4.53995131e-02f, 8.31012726e-02f, -9.70874354e-02f, -4.77918163e-02f, -3.58774178e-02f, -4.41730134e-02f, -8.96299258e-04f,
  -3.29925604e-02f, 1.68110318e-02f, 3.94232990e-03f, 4.93513700e-03f, -9.46043730e-02f, -1.65889971e-02f, -2.84160394e-02f, -8.74179648e-04f, 2.29415726e-02f, 2.46172631e-03f,
  -8.41275752e-02f, -6.08418323e-03f, -2.56046690e-02f, 3.78797762e-02f, 2.17826925e-02f, 2.74531427e-04f, 3.93094532e-02f, -2.82496102e-02f, -2.45453813e-03f, -1.80548169e-02f,
  5.48609756e-02f, 5.98298162e-02f, -1.22769913e-02f, 1.86193082e-02f, 7.59543404e-02f, 2.50728074e-02f, 1.55354375e-02f, 2.10345276e-02f, 8.00531656e-02f, 5.06028607e-02f,
  -1.16697341e-01f, 2.70718355e-02f, -1.77382100e-02f, 4.55547832e-02f, -7.64562488e-02f, -2.85649784e-02f, -4.61015478e-02f, -2.76667289e-02f, -1.34089012e-02f, 4.37127948e-02f,
  3.32642078e-01f, 3.87006290e-02f, -1.84839945e-02f, 3.13377753e-02f, -1.09738549e-02f, -5.51870419e-03f, -4.14532386e-02f, 2.76922230e-02f, -8.86888057e-03f, 7.07830563e-02f,
  -3.79415676e-02f, 8.92843530e-02f, 5.50883785e-02f, -2.26526242e-02f, -4.68622558e-02f, 9.51133668e-02f, -4.94861323e-03f, 4.72895466e-02f, 9.89753380e-02f, 6.91048102e-03f,
  3.86848338e-02f, -3.84987146e-02f, -4.20247316e-02f, -7.18565285e-03f, 8.06217790e-02f, -4.64968756e-03f, 1.95994712e-02f, -4.07709926e-02f, -8.90642125e-03f, -2.75520049e-02f,
  -8.15787353e-04f, -3.12242895e-01f, -2.33599320e-01f, -1.34339079e-01f, 1.58026442e-01f, 2.69961089e-01f, 2.80841798e-01f, -1.22524470e-01f, -3.01571548e-01f, -2.52840929e-02f,
  2.72767067e-01f, -1.21115021e-01f, -9.21589583e-02f, 1.74501613e-01f, 1.32554144e-01f, -1.66595280e-01f, 8.46465677e-02f, 5.27032837e-03f, -2.16626018e-01f, -2.93675549e-02f,
  -7.17918649e-02f, 2.57448107e-01f, -3.61279473e-02f, -3.51965777e-03f, 4.71762829e-02f, -1.46133557e-01f, 1.49787232e-01f, 4.11555544e-02f, 1.05002366e-01f, 5.69014810e-02f,
  1.46317884e-01f, -8.34551454e-02f, 1.10993907e-02f, 7.27234920e-03f, 3.99454534e-02f, 9.69839543e-02f, 8.52740631e-02f, 5.88730015e-02f, 5.02038412e-02f, -6.47437796e-02f,
  -2.68269386e-02f, 3.84026766e-02f, -7.54233375e-02f, -4.23686318e-02f, 4.52539604e-03f, -7.56150335e-02f, -1.29281534e-02f, 1.24112405e-02f, -4.00211513e-02f, 2.64886394e-02f,
  -2.76148152e-02f, -8.12698994e-03f, 1.26928380e-02f, -2.00439300e-02f, 1.08024683e-02f, 1.49208377e-03f, -4.42245379e-02f, 3.07367034e-02f, 8.09374172e-03f, -5.21045625e-02f,
  -4.68213856e-02f, -3.69822118e-03f, 2.75341235e-02f, -3.02519184e-02f, 3.47979702e-02f, -2.42157169e-02f, 4.27198708e-02f, 9.85923503e-03f, 1.82963312e-02f, 1.29808171e-03f,
  1.65828015e-03f, -2.09238566e-02f, 1.80460960e-02f, -5.52668124e-02f, 8.58117733e-03f, -1.62786152e-02f, 1.17517198e-02f, 4.30508051e-03f, -1.99160296e-02f, -1.54166073e-02f,
  -8.03342927e-03f, 1.65414531e-03f, 6.61610346e-03f, 1.18758650e-02f, 2.59514526e-02f, -8.22267309e-03f, 2.12302851e-03f, 1.44576570e-02f, -4.85847704e-02f, 3.37142535e-02f,
  -5.03560491e-02f, -1.33368209e-01f, -8.75743777e-02f, -2.44307779e-02f, -8.51657391e-02f, 3.18168886e-02f, -4.44628932e-02f, -5.95292263e-02f, -4.65917736e-02f, 5.81867434e-03f,
  5.37903979e-02f, 2.28144769e-02f, 3.91215272e-02f, 3.43014151e-02f, 3.85990441e-02f, -5.88341337e-03f, 2.25999709e-02f, -1.40979337e-02f, 4.93427701e-02f, 3.88132930e-02f,
  8.04879665e-02f, 2.10707486e-02f, 3.81145626e-02f, 1.50949476e-04f, 5.24770133e-02f, 1.64370798e-02f, -5.36729256e-03f, -3.86378132e-02f, 6.65908232e-02f, -5.37258126e-02f,
  1.20667927e-02f, 1.79581985e-01f, 7.93775097e-02f, 1.39503881e-01f, -1.51798287e-02f, 2.03401163e-01f, 1.46508232e-01f, 5.74860610e-02f, 1.41559944e-01f, -1.22015039e-02f,
  -7.30071962e-02f, 1.18009835e-01f, 1.62625220e-02f, 9.25747901e-02f, 2.25256503e-01f, 6.55573383e-02f, 3.13515574e-01f, 7.32810050e-02f, 4.58557978e-02f, 1.57911301e-01f,
  7.68902227e-02f, 1.06549896e-01f, -5.61561212e-02f, -7.42994770e-02f, -7.73712397e-02f, 5.84879471e-03f, 9.35106911e-03f, -1.31095529e-01f, 1.96221545e-02f, -4.83816005e-02f,
  -1.06286198e-01f, 3.08291614e-02f, 4.18978417e-03f, -4.67086136e-02f, 1.33500565e-02f, -4.85815108e-02f, 4.24599787e-03f, 1.79151651e-02f, 1.84592362e-02f, 6.96652848e-03f,
  -1.97801590e-02f, 3.55965346e-02f, 8.27368796e-02f, 4.31802794e-02f, -3.76260676e-03f, 1.58996190e-05f, -6.25228286e-02f, 3.01990062e-02f, -6.79084426e-03f, -2.11429205e-02f,
  -2.18235496e-02f, -3.07608582e-02f, -6.39355415e-03f, -1.21417372e-02f, 4.51884791e-03f, 9.54309572e-03f, 8.87717456e-02f, -2.51842998e-02f, 2.69653829e-04f, 9.88804549e-02f,
  -2.11727284e-02f, 8.14458877e-02f, -1.65257528e-02f, -5.65371960e-02f, 3.40575166e-03f, -5.18414862e-02f, 2.66832598e-02f, -3.04022580e-02f, 7.19080353e-03f, -2.71091275e-02f,
  5.18662781e-02f, -6.69174492e-02f, 1.22173568e-02f, 9.02166881e-04f, 4.45126407e-02f, 6.14799075e-02f, -2.40029003e-02f, 7.23790750e-03f, 4.65456061e-02f, -2.86996607e-02f,
  -1.31247258e-02f, 3.31868045e-02f, 2.73331217e-02f, -5.15485480e-02f, 6.21579885e-02f, -1.86590645e-02f, -4.28916365e-02f, 1.32964971e-02f, -8.46973248e-03f, 1.80168841e-02f,
  9.57963094e-02f, 2.69126832e-01f, 3.98351178e-02f, -3.78898834e-03f, 3.46964337e-02f, 4.11008894e-02f, 1.31243858e-02f, 6.83787838e-02f, 2.78162453e-02f, 6.35249987e-02f,
  -2.41512153e-02f, -6.35015639e-03f, 2.04078779e-02f, -5.50208651e-02f, 1.17843067e-02f, 3.64489458e-03f, 5.73653914e-02f, -3.36651504e-02f, 4.14022477e-03f, -1.21259522e-02f,
  2.99569443e-02f, 1.83742065e-02f, 4.56129685e-02f, 3.85071011e-03f, 3.41186598e-02f, -5.75248757e-03f, 3.90642919e-02f, 3.89680453e-02f, -7.02788029e-03f, 4.41265889e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.68883463e-02f, 8.47231746e-02f, 2.13976845e-01f, 1.41048625e-01f, -8.93847365e-03f, -8.99285302e-02f, -3.64522934e-02f, 1.20226135e-02f, -7.37948855e-03f, -1.04978278e-01f,
  -1.48716271e-01f, 1.63836256e-01f, -1.67913109e-01f, 7.61119872e-02f, -9.62219536e-02f, -2.02158570e-01f, 8.74064490e-02f, -6.39546067e-02f, -1.14748422e-02f, 2.05800965e-01f,
  1.43825367e-01f, -4.70850840e-02f, 4.28540260e-02f, 9.52216908e-02f, 3.87299173e-02f, 2.31855854e-01f, 1.59265697e-02f, -3.05960774e-02f, 1.85666189e-01f, -8.10845941e-02f,
  -7.12096915e-02f, 3.10312677e-02f, 7.91686475e-02f, -2.42934059e-02f, -2.99826488e-02f, -4.38392684e-02f, -5.82622625e-02f, -4.39591184e-02f, -6.62802830e-02f, -7.28579685e-02f,
  7.34066963e-02f, 5.76514676e-02f, 4.00489233e-02f, -7.49853849e-02f, -2.44626943e-02f, 1.22005261e-01f, 1.75927710e-02f, 7.82179832e-02f, -7.40096271e-02f, 1.08329214e-01f,
  2.93988604e-02f, 1.01652876e-01f, 1.08574517e-01f, 4.88662161e-02f, 7.17744380e-02f, -6.00048378e-02f, -3.29674967e-02f, -1.19885346e-02f, 6.44096360e-02f, -4.88991034e-04f,
  -7.92747810e-02f, -1.75772849e-02f, -2.13832464e-02f, -6.26819488e-03f, -1.00401072e-02f, -6.39259443e-02f, 3.72968465e-02f, 3.16644870e-02f, 2.60764640e-02f, -2.72694305e-02f,
  -4.66400124e-02f, 9.24835280e-02f, 1.40127921e-02f, -7.97370728e-03f, 6.45646080e-02f, 6.43473342e-02f, 4.84938137e-02f, 7.82996602e-03f, 9.39097703e-02f, 9.57787856e-02f,
  -3.73112666e-03f, -2.95696612e-02f, -5.22910208e-02f, 6.19645603e-03f, 3.47622856e-02f, -2.49747001e-03f, -3.50634381e-02f, 4.99223284e-02f, -5.00347978e-03f, -3.11217317e-03f,
  -5.28178876e-03f, -1.06648073e-01f, 4.65879440e-02f, -3.30557898e-02f, 3.55754010e-02f, -8.18108320e-02f, 2.96479128e-02f, 2.15387158e-02f, -1.18581923e-02f, 3.82451601e-02f,
  1.14756599e-01f, -4.38247882e-02f, 4.58799681e-04f, 8.23843032e-02f, -7.90413767e-02f, -6.56196699e-02f, 8.53586644e-02f, -5.67958802e-02f, -5.26548736e-02f, 5.51858544e-02f,
  8.87144282e-02f, 8.81260335e-02f, -2.88542174e-02f, 1.17298052e-01f, -5.59890904e-02f, 1.73723660e-02f, 1.28481090e-01f, 6.67069778e-02f, 2.45868936e-02f, 6.56441599e-02f,
  -1.73441656e-02f, 1.62544265e-01f, 9.66061780e-04f, -6.41641095e-02f, 5.51015651e-03f, 1.87860690e-02f, 6.92918003e-02f, -4.11217101e-03f, 1.15374535e-01f, 1.51756719e-01f,
  -2.84527987e-02f, 2.96818186e-02f, -4.26028334e-02f, 9.80825648e-02f, -1.65200323e-01f, 1.13826459e-02f, 4.96234931e-02f, 3.32768895e-02f, 7.94931427e-02f, -7.80887604e-02f,
  -3.71848084e-02f, -9.45662186e-02f, -1.13378368e-01f, -9.26988721e-02f, -1.30884852e-02f, -3.56192980e-03f, -1.29264727e-01f, 5.51331937e-02f, -5.28547950e-02f, 1.15979083e-01f,
  2.89096702e-02f, 4.75397073e-02f, 4.28947508e-02f, -3.62067185e-02f, -7.74765313e-02f, -5.59720257e-03f, -1.49400448e-02f, 2.82270592e-02f, -4.56869602e-02f, 6.55704290e-02f,
  2.36978494e-02f, 6.95147812e-02f, -9.65057686e-03f, -8.82315040e-02f, 7.51631856e-02f, 7.63203278e-02f, 5.90641573e-02f, 5.59492186e-02f, 1.11176915e-01f, -6.00234680e-02f,
  5.33470884e-02f, -5.19594252e-02f, -9.07824859e-02f, 8.66190642e-02f, 4.87677427e-03f, -3.89034934e-02f, 5.85732497e-02f, -3.23229581e-02f, -4.38604057e-02f, 3.17969248e-02f,
  1.28439143e-02f, -5.93973771e-02f, 5.59858344e-02f, -6.97966516e-02f, 5.54516166e-02f, -3.96678969e-02f, -4.05127332e-02f, -3.76503766e-02f, 1.14175782e-01f, 6.44893572e-02f,
  -4.32789214e-02f, -3.98519337e-02f, 7.40996599e-02f, -5.65060526e-02f, -4.33630012e-02f, 3.24253291e-02f, -3.73233631e-02f, 4.73798960e-02f, -7.24981427e-02f, -5.37954085e-02f,
  -8.59043598e-02f, 7.66197667e-02f, -3.64363641e-02f, 4.70071398e-02f, 1.05283357e-01f, -6.43200055e-03f, -8.01182464e-02f, 8.16387907e-02f, 2.56035533e-02f, -3.29612792e-02f,
  1.08193859e-01f, 4.18715626e-02f, 1.02788083e-01f, 4.64093462e-02f, -5.89122474e-02f, -1.00998946e-01f, 3.46113816e-02f, 5.26807122e-02f, 6.32209703e-02f, -2.99117770e-02f,
  7.45422691e-02f, 9.71742533e-03f, -7.45341042e-03f, 2.40850430e-02f, -6.00668881e-03f, -8.04676414e-02f, 3.83804590e-02f, -3.17617543e-02f, -3.86042073e-02f, 5.60221113e-02f,
  -1.51278386e-02f, -3.39901112e-02f, -1.56961065e-02f, 9.69011802e-03f, -2.60169320e-02f, -4.07570638e-02f, 5.28403604e-03f, -5.31045347e-03f, 4.09725234e-02f, 7.95231536e-02f,
  8.75473693e-02f, -6.62854686e-02f, -2.15851031e-02f, 1.02317348e-01f, 1.17333837e-01f, -4.34930027e-02f, -8.24390352e-02f, 1.15531860e-02f, -1.46792307e-01f, -6.71405941e-02f,
  2.88133565e-02f, -4.87234965e-02f, -2.07582086e-01f, 6.88095987e-02f, 2.12225556e-01f, -6.47292845e-03f, 2.04740524e-01f, -5.63805774e-02f, 8.92608836e-02f, 4.21966761e-02f,
  7.29640946e-02f, 1.45020410e-01f, 1.23794585e-01f, 2.11937010e-01f, 9.30090845e-02f, 5.53057417e-02f, 1.48983568e-01f, 2.77556106e-02f, 1.24095373e-01f, 5.85017093e-02f,
  -6.58461601e-02f, -7.52365366e-02f, 3.08589917e-02f, -8.87031630e-02f, 3.80972661e-02f, -2.11316254e-02f, -7.18374178e-02f, 6.99025840e-02f, -2.95004342e-02f, 1.24819679e-02f,
  -9.44437608e-02f, 3.47279236e-02f, 6.98426664e-02f, -7.75963860e-03f, 4.40934375e-02f, -5.99144958e-03f, 3.60048264e-02f, -1.18514635e-02f, -9.81732756e-02f, -5.07205129e-02f,
  -8.83665681e-02f, 6.26399443e-02f, -6.80685341e-02f, -4.63626757e-02f, 5.45290112e-02f, -5.48531599e-02f, 3.08473762e-02f, 3.26349139e-02f, 6.81192130e-02f, 1.41108520e-02f,
  2.79263686e-02f, 5.66484891e-02f, -2.73590367e-02f, 9.27683339e-02f, -4.47792895e-02f, 6.76175430e-02f, -3.11713628e-02f, -1.94679890e-02f, 3.47404964e-02f, 4.80649956e-02f,
  2.14759223e-02f, -8.82192254e-02f, -4.07344848e-02f, 2.14771312e-02f, 5.34433350e-02f, 1.91011801e-02f, -6.20160392e-03f, 8.82966593e-02f, -7.87021369e-02f, -2.68007722e-02f,
  -5.77827394e-02f, -1.75442267e-02f, -5.71315922e-02f, -2.75544189e-02f, -1.64025985e-02f, 4.84572574e-02f, 5.87629080e-02f, 4.16498147e-02f, 2.34906897e-02f, -2.83240271e-03f,
  5.41798212e-02f, 3.91964316e-02f, 2.21532173e-02f, 7.65681043e-02f, -4.33566496e-02f, -5.54573163e-02f, 2.76982728e-02f, -1.94891486e-02f, 2.50434894e-02f, -3.38766128e-02f,
  -5.87408915e-02f, 5.14866300e-02f, 9.49912332e-03f, 1.07674641e-04f, 1.94973908e-02f, 2.90496983e-02f, 7.93425739e-03f, -8.97055045e-02f, -5.08708355e-04f, 3.65401655e-02f,
  1.42072309e-02f, -1.65424421e-02f, 2.93435231e-02f, -3.07666212e-02f, 3.59313302e-02f, -5.55508919e-02f, 4.61174361e-02f, -4.41729128e-02f, -4.39247452e-02f, -4.01364453e-02f,
  -1.46175921e-02f, 2.44293828e-02f, -1.67822316e-01f, 1.33689448e-01f, -2.56163608e-02f, 2.29055747e-01f, 9.37630832e-02f, 7.13970885e-02f, 2.24430621e-01f, 1.30335316e-01f,
  7.68657923e-02f, 1.17086582e-01f, -1.43490257e-02f, 1.95564032e-01f, 2.04353556e-01f, 6.59866333e-02f, 2.83684373e-01f, 1.77547544e-01f, -6.36913162e-03f, -4.23566401e-02f,
  5.76366186e-02f, 2.31746137e-02f, -9.73890275e-02f, -8.89560115e-03f, 2.55055707e-02f, -1.36598364e-01f, -6.28653169e-02f, -1.45360187e-01f, -5.47224693e-02f, 6.93511665e-02f,
  -2.55896174e-03f, 3.92085966e-03f, -6.26067296e-02f, -4.92668599e-02f, -4.21811491e-02f, -3.62565629e-02f, -8.18073824e-02f, 1.02997746e-03f, -6.13681087e-03f, 6.65847585e-02f,
  1.00941937e-02f, 1.26568507e-02f, 2.10186355e-02f, -6.85840175e-02f, 3.76445726e-02f, -1.07491128e-01f, 1.36023434e-02f, -6.84701875e-02f, -4.92343493e-02f, -3.64055042e-03f,
  -6.88028410e-02f, -1.15692653e-02f, 3.78503278e-02f, 6.51374683e-02f, 1.70055199e-02f, -5.38852215e-02f, 7.99890161e-02f, -3.19348276e-02f, 9.42260474e-02f, 5.70946932e-02f,
  7.68037215e-02f, 4.78876717e-02f, -3.05459127e-02f, -2.57876515e-02f, 1.15403282e-02f, -8.97165760e-02f, 1.95437986e-02f, -8.23078770e-03f, -7.02492567e-03f, 4.62431274e-02f,
  3.39218825e-02f, 6.65063411e-02f, 5.19817807e-02f, -1.04897851e-02f, -5.53690642e-02f, 6.10868186e-02f, -5.84343448e-02f, -8.83602723e-03f, -8.35644230e-02f, -4.71788757e-02f,
  -2.87385471e-02f, -3.68538648e-02f, -1.31128272e-02f, -2.35118135e-03f, -4.34538163e-02f, -6.52672946e-02f, 1.23793267e-01f, 2.71906424e-02f, 2.46777609e-02f, -3.39196287e-02f,
  1.39892042e-01f, 1.98917955e-01f, -4.62212414e-02f, 1.15949092e-02f, -8.26357678e-02f, 2.60549113e-02f, 6.89843297e-02f, 5.03819026e-02f, 6.62147254e-02f, -1.51752783e-02f,
  5.09365723e-02f, -1.02044038e-01f, 6.37196600e-02f, 5.49944304e-02f, 1.55418999e-02f, 1.05352052e-01f, -2.73669045e-02f, 7.67877251e-02f, 7.69017562e-02f, -1.00268140e-01f,
  -1.94042902e-02f, -2.78181303e-02f, 1.54247805e-02f, 4.50453013e-02f, -4.64006513e-02f, 1.24784475e-02f, 5.34392446e-02f, -6.32412061e-02f, 2.27296054e-02f, -4.22241762e-02f,
  -1.06379457e-01f, 3.89176495e-02f, -1.06261969e-01f, 1.78817827e-02f, 1.09208331e-01f, -1.94223002e-01f, -1.59030452e-01f, -1.67646781e-02f, -1.53148621e-01f, 1.56321079e-01f,
  5.86622506e-02f, -1.40595704e-01f, -7.65695646e-02f, -1.87629580e-01f, -3.63647282e-01f, -2.97942162e-01f, -8.59164670e-02f, -1.76624671e-01f, -1.44866154e-01f, 5.59973018e-03f,
  -5.83239011e-02f, 1.01673126e-01f, -9.74609405e-02f, 2.20238656e-01f, 3.56132239e-02f, 1.68347150e-01f, 1.80048719e-01f, 2.12824449e-01f, 6.60312176e-02f, 2.17313841e-02f,
  -1.10526904e-01f, -4.34410274e-02f, 2.98175849e-02f, -7.12529123e-02f, -3.74153256e-02f, -2.36422066e-02f, -6.12710714e-02f, -1.24022223e-01f, -1.43278018e-03f, -1.05668001e-01f,
  1.06350277e-02f, -4.34010029e-02f, 8.33929554e-02f, -8.06479529e-02f, 5.46894670e-02f, -1.08661734e-01f, -1.59757379e-02f, 6.73453743e-03f, 1.64215229e-02f, -2.77084485e-02f,
  -1.07278779e-01f, -5.80361709e-02f, 6.53016865e-02f, 6.43162951e-02f, -4.80801845e-03f, -3.35735381e-02f, 7.09278835e-03f, -4.54463027e-02f, 1.21823568e-02f, 2.06641369e-02f,
  4.92218249e-02f, 6.54723048e-02f, -5.97271733e-02f, -5.00996225e-02f, -7.97004253e-02f, 3.74423563e-02f, -2.63718236e-03f, -2.88120862e-02f, 5.30906059e-02f, -1.98218692e-02f,
  5.41091226e-02f, -4.49679373e-03f, 1.00967079e-01f, -5.80925867e-02f, 3.45061831e-02f, 6.12303130e-02f, -9.79245305e-02f, 5.61699905e-02f, -1.42984120e-02f, 2.30025630e-02f,
  -4.05735075e-02f, 1.08871553e-02f, 1.58530138e-02f, 1.90958418e-02f, 2.61219982e-02f, 4.73776981e-02f, 5.31422086e-02f, -7.20380172e-02f, 2.59590838e-02f, 6.07090369e-02f,
  -2.48581208e-02f, 1.41567588e-01f, 5.90821393e-02f, 4.32062037e-02f, 5.75412661e-02f, 2.00597011e-03f, -4.06702757e-02f, 7.50007853e-03f, -5.41556440e-02f, 3.49549614e-02f,
  4.63486686e-02f, 5.00966981e-02f, -1.83927566e-02f, 6.78133592e-02f, -6.45481199e-02f, -6.08094186e-02f, 4.47619297e-02f, 5.62085621e-02f, 1.15927912e-01f, -3.03698201e-02f,
  1.07824750e-01f, -2.77809687e-02f, -8.54566577e-04f, 2.89088320e-02f, 5.06205857e-02f, 5.04954904e-02f, 6.64378926e-02f, 6.94889501e-02f, -8.49384535e-03f, -1.23013603e-02f,
  6.96713850e-02f, -1.12465687e-01f, -2.92598326e-02f, -2.75420323e-02f, 1.44610643e-01f, 1.44946873e-01f, 6.63036993e-03f, 3.02297994e-02f, -2.38081843e-01f, -8.34261328e-02f,
  -1.65039056e-03f, -7.47023523e-02f, -1.43271059e-01f, -6.48296252e-02f, 1.02907000e-02f, -7.73185268e-02f, 6.32157607e-05f, 8.89575556e-02f, -1.34781048e-01f, 5.59517741e-02f,
  2.78114080e-02f, 8.12174231e-02f, -6.06618598e-02f, 1.07114203e-01f, 7.27389054e-03f, -5.68690710e-02f, 3.23476060e-03f, 3.94884422e-02f, 8.98285434e-02f, 1.38292480e-02f,
  1.36291571e-02f, -3.55177931e-02f, -8.44979435e-02f, -6.40907362e-02f, -7.32887834e-02f, 5.58137931e-02f, 6.82424679e-02f, -3.04043069e-02f, 7.70553648e-02f, 1.48662683e-02f,
  -3.70866433e-02f, 6.73345178e-02f, -2.37794146e-02f, 1.19365985e-02f, -2.15045568e-02f, 2.90866811e-02f, 8.86952281e-02f, -5.85956946e-02f, 5.04465355e-03f, 5.89888617e-02f,
  -3.29566486e-02f, 9.91096646e-02f, 1.36735188e-02f, -8.19663033e-02f, -1.33286798e-02f, 5.00739105e-02f, 4.66121808e-02f, 8.17920566e-02f, 8.28525648e-02f, 6.19995873e-03f,
  1.26538604e-01f, 6.69114962e-02f, 8.78577977e-02f, 1.72710437e-02f, 5.71535602e-02f, 9.99745429e-02f, -4.72263396e-02f, -4.35760431e-02f, -2.29190197e-02f, -4.30391580e-02f,
  3.91704589e-02f, 1.11821305e-03f, -3.27256024e-02f, 4.42054234e-02f, -6.47341236e-02f, 6.10872619e-02f, 9.78438258e-02f, -8.85032713e-02f, -8.48172829e-02f, -8.85927603e-02f,
  -1.11226246e-01f, -7.12597296e-02f, 3.93663272e-02f, 2.16941163e-02f, 2.65439432e-02f, 6.87363148e-02f, 3.61142084e-02f, -8.28201547e-02f, 4.93623167e-02f, -4.79590781e-02f,
  3.89412418e-02f, -1.38554610e-02f, -4.42291833e-02f, -1.76477786e-02f, -2.00156942e-02f, -4.38253731e-02f, 2.45463736e-02f, -7.43424222e-02f, 6.34906348e-03f, 3.94176841e-02f,
  9.39233899e-02f, 8.42989013e-02f, 7.82885179e-02f, -2.29854770e-02f, 7.70141510e-03f, 5.06898277e-02f, -2.87687108e-02f, 7.41508529e-02f, 4.76609580e-02f, 1.17806852e-01f,
  -6.32245839e-02f, 8.25291798e-02f, 4.00648005e-02f, 9.92533788e-02f, -3.91284116e-02f, 1.58834849e-02f, -9.12316367e-02f, -8.37508496e-03f, 4.56232950e-02f, -9.32483748e-02f,
  -3.22798312e-01f, 1.50560617e-01f, 6.38845516e-03f, -2.04356015e-01f, 6.57535493e-02f, 9.20440778e-02f, -6.00740127e-02f, 1.21807851e-01f, -7.33479336e-02f, 1.44154161e-01f,
  -7.58757629e-03f, -1.43538207e-01f, 1.08220957e-01f, -9.76168215e-02f, -2.28219569e-01f, -4.89853434e-02f, -4.36942019e-02f, 2.84198206e-02f, -1.05582073e-01f, -5.87523095e-02f,
  -2.01929566e-02f, 7.81493858e-02f, -6.75106719e-02f, 1.65174842e-01f, 6.50667474e-02f, -5.98240085e-03f, 3.97762842e-02f, 1.48230866e-01f, -1.40328314e-02f, -1.73843578e-02f,
  -8.10372308e-02f, 2.39442214e-02f, 5.48972040e-02f, 8.69234651e-02f, 5.93654299e-03f, 4.09201197e-02f, -3.89862657e-02f, 5.20332828e-02f, -7.65979290e-02f, -9.33138840e-03f,
  3.13396975e-02f, 2.75168996e-02f, -8.15000907e-02f, 6.12214804e-02f, -1.14298668e-02f, 4.71450761e-02f, -1.33787403e-02f, -1.77053232e-02f, -7.80179501e-02f, -7.81016797e-02f,
  2.44722031e-02f, 2.21879110e-02f, 6.89304695e-02f, -3.48721370e-02f, 3.87644246e-02f, 4.48261946e-02f, 1.63217634e-02f, 2.35803761e-02f, -8.34909175e-03f, 2.96414597e-03f,
  1.06623117e-02f, -4.04371470e-02f, -6.50060102e-02f, 2.43556648e-02f, -6.71246424e-02f, 3.62323187e-02f, 3.19406646e-03f, 2.81762499e-02f, -4.27891985e-02f, -3.79789248e-02f,
  -7.00791106e-02f, -2.28548869e-02f, 7.23179132e-02f, -3.03298868e-02f, -1.35115450e-02f, 1.73322856e-02f, -7.81505555e-02f, 5.37888892e-02f, -1.33671397e-02f, 1.50318770e-02f,
  4.30813804e-02f, -6.98988512e-02f, 4.61906977e-02f, 1.98121779e-02f, -3.36214751e-02f, -2.89484113e-02f, 8.42376798e-02f, 5.91388680e-02f, 5.80809154e-02f, -7.13454336e-02f,
  -6.27321675e-02f, -5.02284542e-02f, -1.81659050e-02f, 5.80735430e-02f, 5.58208376e-02f, 8.10094699e-02f, 3.59411351e-02f, 4.33483720e-02f, 3.32696512e-02f, -3.87272537e-02f,
  6.45032013e-03f, -4.03220318e-02f, 1.00228190e-02f, -3.80096138e-02f, -8.65093246e-02f, -2.16827225e-02f, -5.82204852e-03f, 1.22697707e-02f, 8.73593241e-03f, -2.15132013e-02f,
  9.59690660e-02f, 3.01121967e-03f, 9.12723318e-03f, 7.83102512e-02f, 3.04474849e-02f, -7.55352229e-02f, -4.73887213e-02f, 7.26793930e-02f, 5.55545418e-03f, -2.12627091e-03f,
  7.03805238e-02f, 1.97889116e-02f, 4.25006971e-02f, 6.99566454e-02f, 9.16253999e-02f, 1.10588327e-01f, 1.53549999e-01f, 4.59473990e-02f, 1.09469213e-01f, -2.36016586e-02f,
  -1.18893690e-01f, 3.43818180e-02f, -8.23740736e-02f, -9.97690186e-02f, 2.50087548e-02f, 2.22745370e-02f, 3.61377187e-02f, -9.73095093e-03f, 2.46589854e-02f, -3.63033563e-02f,
  -5.70303127e-02f, -1.08346239e-01f, -7.97980800e-02f, -1.55997537e-02f, -5.97287007e-02f, 2.34414358e-02f, -3.36078070e-02f, 9.26242471e-02f, -3.98352593e-02f, 2.19731200e-02f,
  -2.62904838e-02f, -3.78669165e-02f, 5.99488690e-02f, -9.51954275e-02f, 7.22754151e-02f, -4.57878821e-02f, 7.65554905e-02f, -4.41425852e-02f, 1.08583622e-01f, 2.61724927e-02f,
  -9.26840231e-02f, -2.85231248e-02f, -7.00994581e-02f, 2.10380051e-02f, 9.21182111e-02f, -2.65633296e-02f, 3.91213745e-02f, 6.96700905e-03f, -8.85891095e-02f, -9.14869457e-02f,
  -9.75329801e-02f, 5.23916110e-02f, -8.03663582e-02f, 5.17042056e-02f, -7.73562044e-02f, 1.07569434e-02f, 7.11753592e-02f, 5.00951596e-02f, 5.51505126e-02f, 5.12651168e-02f,
  3.89174074e-02f, 6.94942102e-02f, -1.82114281e-02f, 3.63180079e-02f, -8.31744671e-02f, -7.49759302e-02f, -4.42474298e-02f, 7.97331391e-04f, -3.60882096e-02f, 3.04500628e-02f,
  -2.23339517e-02f, -3.11951600e-02f, -2.95699611e-02f, 2.65021157e-03f, 8.01720917e-02f, -5.71157373e-02f, -5.95764481e-02f, 5.83830662e-02f, 3.84988338e-02f, 2.21114755e-02f,
  -3.56791280e-02f, -6.69559911e-02f, 9.40173957e-03f, 4.62728217e-02f, 2.73740385e-02f, -7.45911449e-02f, -3.33138034e-02f, 2.96559520e-02f, -6.98138326e-02f, -4.92300801e-02f,
  7.34653845e-02f, 4.74201292e-02f, 5.67147173e-02f, -8.18688124e-02f, 4.91871238e-02f, 3.81610058e-02f, 4.03575711e-02f, -1.76565535e-02f, 1.21743836e-01f, 5.38760563e-04f,
  -6.78603202e-02f, -2.86565982e-02f, -1.72268208e-02f, 1.18327644e-02f, -1.92691442e-02f, -9.63082612e-02f, 5.47243766e-02f, -1.77038403e-03f, 3.68125271e-03f, 3.29764150e-02f,
  -5.29400911e-03f, -2.99831405e-02f, 6.23209886e-02f, -5.20036668e-02f, -8.04091617e-03f, 1.70364417e-02f, -3.09041496e-02f, 5.73942959e-02f, 4.25787829e-02f, -5.20300195e-02f,
  -1.08011868e-02f, -6.89951470e-03f, 5.89306094e-02f, -2.80444212e-02f, 4.07457240e-02f, 3.09578665e-02f, -5.48082218e-02f, -1.48329185e-03f, 1.02609610e-02f, 9.18298662e-02f,
  2.36614160e-02f, 6.37192205e-02f, 1.01076134e-01f, -7.56879747e-02f, -5.57668740e-03f, -1.64991077e-02f, -1.07373474e-02f, -3.87271903e-02f, -8.15114826e-02f, 5.51651865e-02f,
  -4.75162119e-02f, 2.83616292e-03f, 4.51989509e-02f, 1.12783805e-01f, 5.67268953e-02f, 9.77527052e-02f, 3.58673669e-02f, 7.28059411e-02f, 3.89545746e-02f, 7.10177422e-02f,
  -6.59029037e-02f, 6.41387999e-02f, 1.22808911e-01f, -8.21141060e-04f, -4.76833954e-02f, 8.43183789e-03f, 5.56354993e-04f, 5.44038713e-02f, 8.00009593e-02f, 2.63129976e-02f,
  -1.04798228e-02f, -7.16804489e-02f, -1.65862162e-02f, 4.65410464e-02f, 3.15665528e-02f, -6.38559386e-02f, 3.96676399e-02f, 4.24086638e-02f, -6.33765236e-02f, 3.94980833e-02f,
  9.73292217e-02f, -4.77562062e-02f, 4.95969765e-02f, -4.94547188e-02f, 8.35775360e-02f, -3.12163103e-02f, -6.93727955e-02f, 7.54187480e-02f, -6.23084679e-02f, 1.79113466e-02f,
  2.09429469e-02f, -8.38613287e-02f, -7.25018084e-02f, 2.44444665e-02f, -2.85279937e-04f, -1.38794575e-02f, 7.48803094e-02f, -1.38480030e-02f, 5.74829504e-02f, 9.21667740e-02f,
  -3.54382619e-02f, 1.85721777e-02f, -6.18937165e-02f, 3.75211053e-02f, -6.40194640e-02f, 5.60999289e-02f, 6.62805289e-02f, 4.01381329e-02f, 5.90264760e-02f, 9.81109589e-02f,
  -2.16633566e-02f, 1.60697121e-02f, -2.83758007e-02f, -9.30533111e-02f, -2.22272091e-02f, 7.26227388e-02f, -3.31643671e-02f, -1.00615877e-03f, 6.65008575e-02f, -6.13995902e-02f,
  1.77024715e-02f, 1.33323714e-01f, 1.96881704e-02f, 7.46931359e-02f, -1.70773380e-02f, 3.90136354e-02f, -2.71112993e-02f, 7.60725737e-02f, 8.09119195e-02f, 6.93537993e-03f,
  6.37341067e-02f, 1.08623933e-02f, 6.49481267e-02f, -2.07906794e-02f, -2.54164711e-02f, -7.97535700e-04f, -5.89801148e-02f, -9.87813622e-02f, -5.36985174e-02f, 1.16203755e-01f,
  4.48642410e-02f, -7.71387443e-02f, -8.97978768e-02f, -9.24110711e-02f, -7.34248608e-02f, 6.77419603e-02f, 5.14168330e-02f, 3.77355665e-02f, 5.39317653e-02f, -4.25041169e-02f,
  7.56724477e-02f, -8.40840861e-02f, -2.08206266e-01f, -1.26234308e-01f, 8.31023604e-03f, -2.21947152e-02f, -1.35651559e-01f, 8.22372618e-04f, -4.89758328e-02f, 6.79493546e-02f,
  1.19060963e-01f, -1.94171090e-02f, -1.11713866e-02f, -7.63792545e-02f, -1.13315471e-01f, -1.11931413e-01f, -9.79582146e-02f, -9.78297666e-02f, -2.63092387e-02f, 3.81425098e-02f,
  -2.79347245e-02f, 1.77932605e-02f, -1.19693711e-01f, 6.03822432e-02f, -1.90326832e-02f, 5.75732738e-02f, 9.29161683e-02f, 1.09754868e-01f, 5.50441183e-02f, -2.46408898e-02f,
  -3.53665426e-02f, 3.05079948e-02f, -9.82761905e-02f, 4.41881977e-02f, 2.32171435e-02f, -8.45037922e-02f, -5.45778237e-02f, 2.43283175e-02f, 1.67810898e-02f, -6.92833960e-02f,
  -6.11229055e-02f, 5.57463132e-02f, -4.04079482e-02f, -7.21953213e-02f, -1.96348447e-02f, 5.30723594e-02f, -4.53479104e-02f, -1.57847665e-02f, -8.80475193e-02f, -5.25277220e-02f,
  1.60047505e-02f, -6.63417503e-02f, 4.57525142e-02f, -4.23641764e-02f, -3.52833630e-03f, -4.24741767e-02f, 2.76846085e-02f, -3.57577903e-03f, -7.70574659e-02f, 1.55550791e-02f,
  5.14604338e-03f, 3.59010510e-02f, -6.89320862e-02f, 5.43700047e-02f, -5.83864190e-02f, -2.65435986e-02f, -6.10017441e-02f, 1.30123552e-02f, 8.78524315e-03f, 4.37982529e-02f,
  -4.03826125e-02f, 4.36816886e-02f, -3.74808609e-02f, 1.15547441e-02f, -7.31541067e-02f, -6.51018396e-02f, 5.54836495e-03f, -7.12094977e-02f, -5.27194962e-02f, -9.89696085e-02f,
  2.08287835e-02f, 2.57905256e-02f, -6.23498484e-02f, -8.10442269e-02f, -5.20702712e-02f, -2.66009625e-02f, 6.67238459e-02f, 2.49582995e-02f, -1.25176413e-02f, 5.64208403e-02f,
  -6.77041784e-02f, -7.97225460e-02f, -6.69718310e-02f, -7.24094128e-03f, 1.23546431e-02f, -9.44860280e-02f, -1.79783124e-02f, 5.99407889e-02f, 5.41535905e-03f, -7.62597173e-02f,
  -4.70670201e-02f, 1.92573033e-02f, -4.63187182e-03f, 7.72778913e-02f, 4.26546894e-02f, 3.85955833e-02f, 1.04613714e-01f, 3.90669256e-02f, -7.94905871e-02f, 3.35008977e-03f,
  -3.94011885e-02f, -2.98055112e-02f, -9.14281234e-02f, -1.61274821e-02f, -7.40168914e-02f, 2.93100122e-02f, -1.02615833e-01f, -2.07365062e-02f, -5.20583801e-02f, 5.08800671e-02f,
  1.74334824e-01f, -4.96536456e-02f, -1.61874697e-01f, -3.72078381e-02f, -7.23682046e-02f, -9.19165611e-02f, -1.02539256e-01f, -4.36477363e-03f, -1.50742620e-01f, -1.03913313e-02f,
  1.29141182e-01f, 3.24053615e-02f, -4.90634516e-02f, 2.41981253e-01f, 1.29992187e-01f, 1.72008313e-02f, 1.32071406e-01f, 2.57871710e-02f, 2.14036647e-02f, 9.10123214e-02f,
  5.77457212e-02f, 2.67929733e-01f, 8.47496018e-02f, 1.01676900e-02f, 7.99057912e-03f, 5.52040301e-02f, 8.47998485e-02f, -5.12144342e-03f, 1.17872499e-01f, -7.80872703e-02f,
  4.13307957e-02f, 1.07833058e-01f, -6.81342483e-02f, -3.61811779e-02f, 6.61427621e-04f, 8.68634135e-02f, -2.11356636e-02f, -8.57957453e-03f, -9.54948515e-02f, -6.66369032e-03f,
  1.23170193e-03f, -3.83242331e-02f, 1.13684759e-01f, 5.73799014e-02f, 2.19581146e-02f, 6.27622614e-03f, -1.99173223e-02f, 1.92499943e-02f, -1.30452797e-01f, -2.24854816e-02f,
  1.45611940e-02f, 3.93244904e-03f, -1.08057493e-02f, -3.32612209e-02f, 5.19395806e-02f, 6.47880286e-02f, 4.18657102e-02f, 7.07146898e-02f, -1.01454603e-02f, -3.16044539e-02f,
  1.01716585e-01f, -1.11124352e-01f, 8.07964355e-02f, -6.01501390e-02f, 2.36322340e-02f, 1.07217608e-02f, -6.19114898e-02f, 4.39877622e-02f, 2.82663200e-02f, 8.59038066e-03f,
  4.84199114e-02f, -9.09910165e-03f, -4.80156839e-02f, 7.60547593e-02f, 2.31423676e-02f, -7.76835531e-02f, 5.81264645e-02f, -1.53665477e-03f, -2.21401104e-03f, 4.66130264e-02f,
  9.45437932e-04f, 7.38525465e-02f, -5.53234592e-02f, 5.91430776e-02f, -5.06633334e-02f, -5.91857359e-02f, 7.55148847e-03f, -2.20593158e-02f, -1.23569600e-01f, 7.00335652e-02f,
  -2.79189311e-02f, 1.53730616e-01f, 2.19157208e-02f, 1.20322648e-02f, -1.59628615e-02f, 8.08253065e-02f, -1.05990320e-01f, 5.77427000e-02f, -2.43433956e-02f, -2.00636722e-02f,
  1.08365692e-01f, 5.06925955e-02f, 5.34994639e-02f, -1.44119165e-03f, -5.64269312e-02f, 1.06371179e-01f, -7.93514401e-02f, -1.06728211e-01f, 4.43623438e-02f, 3.16998363e-03f,
  -3.87625908e-03f, -3.42503339e-02f, -1.05231360e-01f, -5.93729317e-02f, -4.29732632e-03f, -7.62697384e-02f, -5.50522096e-03f, -8.38465244e-02f, 1.09502986e-01f, -4.68857102e-02f,
  2.34247241e-02f, 2.12532654e-02f, -1.87206089e-01f, 1.12595290e-01f, -1.75194159e-01f, -2.35773191e-01f, -1.07701175e-01f, -1.47361280e-02f, -7.86245689e-02f, 7.65347481e-02f,
  9.85243917e-02f, -2.22524256e-03f, 2.97484752e-02f, 2.03187510e-01f, 8.50792229e-02f, 6.39452040e-02f, -5.60835749e-03f, 6.29805177e-02f, 7.64596388e-02f, -2.14262102e-02f,
  4.82704316e-04f, 7.18091205e-02f, 1.22361355e-01f, 1.14836209e-01f, -3.28238234e-02f, 4.51340154e-02f, 1.96732819e-01f, -3.03685609e-02f, 1.24934465e-01f, -4.06775298e-03f,
  -1.15810163e-01f, 1.31397918e-02f, -1.51275480e-02f, 4.39922474e-02f, -3.83178182e-02f, -1.31183460e-01f, -8.75565186e-02f, -6.74069449e-02f, -8.92387033e-02f, -4.45112549e-02f,
  5.38868532e-02f, -3.68543044e-02f, 5.69259636e-02f, 1.19063901e-02f, -1.00301526e-01f, -2.16343179e-02f, -4.54615317e-02f, -2.44758315e-02f, -1.65975224e-02f, 6.43013641e-02f,
  4.49925698e-02f, -1.03909671e-01f, 4.96858824e-03f, 9.24790502e-02f, -6.38505965e-02f, 5.00034727e-02f, -5.85989095e-02f, -2.83701196e-02f, -8.48836079e-02f, 6.46419078e-02f,
  7.46170990e-03f, -6.09885976e-02f, 7.45525584e-02f, -5.81184775e-02f, -1.23075582e-02f, -9.22653452e-02f, 3.53846550e-02f, 7.24444687e-02f, -2.13832664e-03f, 5.38346171e-02f,
  -2.35296376e-02f, -1.02115078e-02f, 6.85088560e-02f, -4.20987345e-02f, 3.61782126e-02f, 2.74926536e-02f, -4.04955586e-03f, -1.99747439e-02f, 2.16362830e-02f, 4.52911817e-02f,
  2.38139573e-02f, -8.24159905e-02f, 5.60259335e-02f, -3.14591303e-02f, 4.94851768e-02f, 8.81381184e-02f, -5.94118908e-02f, -8.58157575e-02f, -8.88342112e-02f, -6.12789690e-02f,
  3.63276117e-02f, -1.49884121e-02f, -5.01876324e-02f, 3.33791263e-02f, 4.56326045e-02f, -2.65957452e-02f, -4.75302823e-02f, 7.39106908e-02f, 9.09513270e-04f, 6.26032874e-02f,
  -5.68444580e-02f, -1.60226226e-02f, 1.77815575e-02f, -4.51400802e-02f, 2.61615608e-02f, -2.83373408e-02f, 1.63480435e-02f, 1.87733639e-02f, 3.61560360e-02f, -3.32791433e-02f,
  -6.93828315e-02f, 4.29527685e-02f, -7.72733986e-02f, -9.56496000e-02f, 4.82326597e-02f, 9.31702778e-02f, 6.63041845e-02f, -7.15618348e-03f, -2.17103940e-02f, 4.61327210e-02f,
  3.08422595e-01f, -8.72300416e-02f, 2.12215185e-02f, 2.13044643e-01f, 1.64299041e-01f, 1.15240090e-01f, 2.19287574e-01f, 1.56077936e-01f, 3.99186581e-01f, -9.17176902e-02f,
  -7.61801377e-02f, -2.05898628e-01f, -1.13703065e-01f, -5.19514009e-02f, 8.20710212e-02f, 4.24233153e-02f, 1.32325009e-01f, 1.25452336e-02f, 6.43214509e-02f, -2.55182162e-02f,
  7.34069198e-02f, -7.22177550e-02f, -1.13027960e-01f, -1.77033454e-01f, -6.23917058e-02f, -4.25264649e-02f, -1.16630726e-01f, 5.41224377e-03f, -2.28619158e-01f, -1.31465644e-01f,
  1.68955594e-03f, 9.21143070e-02f, -7.90601820e-02f, 6.53854087e-02f, 6.87666312e-02f, -2.41070031e-03f, -7.35436603e-02f, -9.46705565e-02f, 4.10554148e-02f, 2.48933341e-02f,
  -8.62508491e-02f, -4.58475165e-02f, 7.49770924e-02f, -3.86893414e-02f, 9.77180302e-02f, -4.77863066e-02f, 2.26610173e-02f, 4.10263911e-02f, -6.75665811e-02f, -1.01916224e-01f,
  5.24768233e-02f, -9.47573856e-02f, 4.76562046e-02f, -9.04020518e-02f, 9.25717279e-02f, 9.37355533e-02f, -2.81041255e-03f, -3.20722610e-02f, -2.09467560e-02f, 9.59053189e-02f,
  9.32568219e-03f, 1.49087822e-02f, 4.31402624e-02f, -4.12706174e-02f, 5.22882231e-02f, 1.08349854e-02f, -4.07830663e-02f, -4.99122962e-02f, 1.08344510e-01f, 3.13581638e-02f,
  2.12224852e-02f, -1.40221287e-02f, 8.16601738e-02f, 1.34518361e-02f, -4.61599752e-02f, -1.42987035e-02f, 2.41009500e-02f, -1.43677136e-02f, 3.75900492e-02f, -5.06097265e-03f,
  1.04522323e-02f, 8.47613290e-02f, -3.35535891e-02f, -1.84140038e-02f, -4.60135899e-02f, 6.06135651e-03f, -4.62473445e-02f, 3.62201631e-02f, -2.40591448e-02f, 5.18630333e-02f,
  -9.10024846e-06f, -1.83438845e-02f, 3.13835703e-02f, -2.98579708e-02f, -5.57281598e-02f, -4.70906757e-02f, 8.37896541e-02f, -3.81567739e-02f, -2.43899077e-02f, -1.65326353e-02f,
  3.32536958e-02f, 7.20796064e-02f, -1.55179519e-02f, -3.92429754e-02f, -1.54133663e-02f, -1.56240712e-03f, -9.74509418e-02f, -4.66443226e-02f, 1.62228700e-02f, -3.33145782e-02f,
  -4.04182002e-02f, 5.79833128e-02f, 2.22106706e-02f, 7.26114586e-02f, -6.50554821e-02f, -5.84405512e-02f, -3.45608741e-02f, -9.99204069e-03f, -7.06163198e-02f, -9.40139890e-02f,
  -1.38558701e-01f, -1.57372415e-01f, 2.83261538e-01f, -9.55762193e-02f, -5.89584112e-02f, 1.49161845e-01f, 1.57488838e-01f, -2.50336658e-02f, -2.25262120e-01f, -8.82034302e-02f,
  -9.02719572e-02f, -7.23137408e-02f, 2.61078566e-01f, -1.35656983e-01f, 1.20607533e-01f, 1.90636426e-01f, 2.12931968e-02f, 3.77387628e-02f, -5.17196469e-02f, -9.16635245e-02f,
  -1.01618432e-01f, -1.47883207e-01f, 1.14351936e-01f, -1.58709675e-01f, -8.67985096e-03f, -1.05681397e-01f, -1.13710333e-02f, 2.07164809e-01f, -4.12473828e-02f, 6.20306842e-02f,
  -7.85143152e-02f, -1.02748096e-01f, -9.35432594e-03f, 7.06480956e-03f, -6.81512803e-02f, 5.87176792e-02f, 2.00638492e-02f, 1.04159638e-01f, -6.01739138e-02f, -2.72641014e-02f,
  1.80054903e-02f, -3.55356745e-02f, -1.25564501e-01f, 6.17441023e-03f, -2.62931008e-02f, -2.62828898e-02f, -7.98254684e-02f, 3.01941838e-02f, 7.30548501e-02f, 8.80208910e-02f,
  8.49366561e-03f, -1.74253266e-02f, 6.30759075e-02f, 1.33929076e-03f, 8.58947337e-02f, -7.95404539e-02f, 6.22239411e-02f, 7.13343844e-02f, -3.81755233e-02f, -1.00625470e-01f,
  5.63611798e-02f, -5.09630553e-02f, 2.95665171e-02f, 2.28055455e-02f, -4.94045839e-02f, -1.93368662e-02f, -5.79897910e-02f, 3.89478914e-03f, 9.08599198e-02f, 3.55759412e-02f,
  -5.42043969e-02f, -8.08385462e-02f, -6.32465333e-02f, 2.09891703e-02f, -6.65057590e-03f, 6.82877824e-02f, 5.49387485e-02f, 2.17233077e-02f, -4.30087484e-02f, 5.38064679e-03f,
  -9.49690193e-02f, 1.88574009e-02f, -3.22144292e-02f, 9.23269019e-02f, 4.39424291e-02f, 7.09250495e-02f, 2.04090052e-03f, -5.91537133e-02f, -4.83944230e-02f, 6.86181262e-02f,
  -1.51836932e-01f, -2.28749037e-01f, -9.23640877e-02f, -1.15743093e-01f, 6.16113916e-02f, -2.65212860e-02f, 3.45531665e-03f, 6.07239380e-02f, -3.45495269e-02f, -8.40002857e-03f,
  2.74667237e-02f, 8.07458360e-04f, -7.00193923e-03f, -7.07197040e-02f, -6.04668222e-02f, -5.05344458e-02f, 5.62897846e-02f, 4.59892750e-02f, -4.90801781e-02f, -7.69120827e-02f,
  -2.77391449e-02f, -7.01790005e-02f, 1.08652487e-02f, -9.04517621e-02f, 5.42295128e-02f, -9.19628236e-03f, 8.52573570e-03f, -4.51092841e-03f, 3.62002268e-03f, -5.08728474e-02f,
  -8.47482122e-03f, 3.19110751e-02f, 5.99760674e-02f, 6.25582263e-02f, -7.60298669e-02f, -2.62962908e-01f, -1.46704435e-01f, 1.26133636e-01f, -1.98959768e-01f, 1.54076619e-02f,
  1.37159303e-01f, 6.86735883e-02f, 1.59455482e-02f, 6.17565587e-02f, -5.15162684e-02f, -9.88679379e-02f, -7.37626851e-02f, -7.62895644e-02f, -1.55815959e-01f, 2.13632718e-01f,
  1.05263561e-01f, 2.69007552e-02f, 1.83095962e-01f, 1.72428042e-01f, 9.88660529e-02f, 2.23596007e-01f, 2.32021421e-01f, 1.71895817e-01f, 8.32069665e-02f, -2.65646651e-02f,
  -1.33275583e-01f, -2.62350030e-02f, -3.10179288e-03f, -4.96391505e-02f, -3.14680338e-02f, 4.71777655e-02f, 6.67766258e-02f, 1.53771248e-02f, -3.12487688e-02f, 3.42173278e-02f,
  3.75554524e-02f, -2.31677070e-02f, 6.50971383e-02f, -9.34221596e-02f, -1.63893737e-02f, -8.33492950e-02f, -5.99834919e-02f, -4.76889126e-02f, 7.25798309e-02f, 6.04580492e-02f,
  1.01931617e-01f, -4.12224829e-02f, 7.48498663e-02f, 1.53448079e-02f, -1.27471089e-02f, -1.01886606e-02f, -3.31139117e-02f, 6.68502450e-02f, -4.00620252e-02f, 3.66181433e-02f,
  5.55448383e-02f, 4.22578081e-02f, -2.26734467e-02f, -4.41229269e-02f, 3.26772183e-02f, 2.93527395e-02f, -7.59011731e-02f, -1.23737426e-02f, 6.29619602e-03f, -1.50390482e-02f,
  -1.55224064e-02f, -4.87638637e-02f, 1.91334616e-02f, -4.07155603e-02f, -6.11447394e-02f, 2.19883099e-02f, 4.77166586e-02f, -5.15923128e-02f, -1.54143600e-02f, -6.60411566e-02f,
  -4.60199565e-02f, -6.85844198e-02f, 7.98560232e-02f, -2.70002475e-03f, -2.17163265e-02f, -4.79607917e-02f, 3.35629731e-02f, -1.07944431e-02f, 5.19087948e-02f, 5.20105064e-02f,
  5.67662939e-02f, 2.33213291e-01f, 2.82237455e-02f, -6.15970753e-02f, 1.32907135e-02f, 1.67917889e-02f, 2.43912078e-02f, -2.67643109e-02f, 8.39230418e-02f, -1.11882478e-01f,
  1.16263837e-01f, 8.63570273e-02f, -8.21158811e-02f, 3.68683785e-02f, 4.24432941e-03f, 6.78526759e-02f, 5.82215749e-02f, 6.35620207e-02f, 6.18784986e-02f, 1.71551132e-03f,
  6.08444065e-02f, -2.21093073e-02f, 4.40951101e-02f, 9.62016452e-03f, 3.12706344e-02f, 9.89515428e-03f, 1.45989759e-02f, 5.89423068e-02f, 7.77376536e-03f, 1.74946729e-02f,
  -2.26140525e-02f, -2.31633894e-02f, -9.10696536e-02f, -1.20796077e-01f, -9.77257639e-02f, -1.19896956e-01f, -1.47412926e-01f, 3.59266251e-02f, -6.05292767e-02f, -9.83972773e-02f,
  -1.78466648e-01f, 2.59649679e-02f, 4.12597097e-02f, -6.02321103e-02f, 1.15461573e-01f, 1.13377318e-01f, -1.03272773e-01f, -7.68562853e-02f, -1.47747509e-02f, -7.60443807e-02f,
  9.80604291e-02f, -2.01252654e-01f, 7.29403496e-02f, -1.88270472e-02f, -1.81967497e-01f, -1.12015299e-01f, 3.00566386e-02f, -1.22867525e-02f, -9.29345712e-02f, -2.28740051e-02f,
  -1.49060979e-01f, -4.62752171e-02f, -2.61534061e-02f, -5.17073199e-02f, -7.13958219e-02f, 4.93223332e-02f, -8.38158354e-02f, -6.64861426e-02f, 1.30081754e-02f, 9.30818729e-03f,
  -1.22273434e-02f, -3.88242975e-02f, 2.46016658e-03f, 7.20058754e-02f, -2.92574931e-02f, 6.95109442e-02f, 7.09566325e-02f, -4.90962602e-02f, -5.38549721e-02f, 6.74287379e-02f,
  -1.44569660e-02f, 7.95207694e-02f, -7.28849620e-02f, -5.12016192e-02f, -1.12841744e-02f, -9.35464352e-02f, -5.02380878e-02f, -7.29565993e-02f, 1.85609926e-02f, -3.36472206e-02f,
  3.44839469e-02f, -4.36440967e-02f, 4.27339934e-02f, -9.77051333e-02f, 2.24661473e-02f, -7.87498802e-02f, 8.11976045e-02f, 5.75988740e-02f, 3.06655630e-03f, -8.43013637e-04f,
  -8.95032883e-02f, -9.75731686e-02f, 6.85278177e-02f, 7.07280561e-02f, 3.31576206e-02f, -5.79805113e-02f, -2.78244540e-02f, 7.98973739e-02f, -9.45509877e-03f, 6.55010641e-02f,
  9.65151098e-03f, -4.43397984e-02f, 1.98606122e-03f, -6.09665513e-02f, 5.39586432e-02f, 1.97553337e-02f, -8.05304497e-02f, -4.74643745e-02f, -3.56583134e-03f, 1.00268023e-02f,
  -1.02669194e-01f, -4.76358049e-02f, -4.63078357e-02f, 3.64544354e-02f, -5.65183945e-02f, 9.33747292e-02f, -4.93899658e-02f, -1.10937152e-02f, -8.67266878e-02f, -6.26924187e-02f,
  2.53516492e-02f, 5.24046831e-02f, 3.38101536e-02f, 7.26313218e-02f, 2.30472479e-02f, 2.44168602e-02f, -8.18183422e-02f, 4.08325605e-02f, -4.94313166e-02f, 1.35076744e-02f,
  5.20107038e-02f, -3.09103541e-02f, 8.34227726e-03f, 4.81048226e-02f, -9.39292461e-03f, -3.47159952e-02f, 5.55020608e-02f, -4.28355150e-02f, 3.21815386e-02f, -3.74771059e-02f,
  6.28604889e-02f, -6.51875436e-02f, -8.76042172e-02f, 7.55660012e-02f, 2.11850982e-02f, 6.64352323e-04f, -1.65408224e-01f, -3.73274051e-02f, -1.36117652e-01f, -2.38090218e-03f,
  3.97387892e-02f, 4.69791256e-02f, -6.27332702e-02f, -9.69114527e-02f, -1.63698513e-02f, -9.50375646e-02f, 7.82666653e-02f, 2.30501872e-02f, -7.35662803e-02f, 1.12861268e-01f,
  1.35881096e-01f, -5.58721684e-02f, 1.07042909e-01f, 1.20811045e-01f, 3.50086913e-02f, 1.23710893e-01f, 1.99958220e-01f, -1.38004851e-02f, 1.03907876e-01f, 2.27415804e-02f,
  -8.57680067e-02f, -5.18855965e-03f, -2.09494401e-02f, -6.96692325e-04f, 1.41249180e-01f, 4.52115200e-02f, -5.73750213e-02f, -2.68221423e-02f, -2.47932877e-02f, 6.14000298e-02f,
  7.62707740e-02f, 1.71044096e-02f, -8.42384920e-02f, -6.13848679e-03f, -3.06297429e-02f, 1.25214050e-03f, 3.04595307e-02f, -4.19566333e-02f, -4.12961841e-02f, 3.60463783e-02f,
  -1.18081376e-01f, 1.21768396e-02f, 3.52110527e-03f, 6.68067038e-02f, 4.68533970e-02f, 6.41134903e-02f, -1.84297767e-02f, 1.85683127e-02f, 1.46614965e-02f, -5.23769520e-02f,
  -3.40772457e-02f, -1.48608526e-02f, -1.61722619e-02f, 5.76719716e-02f, -4.44044955e-02f, -5.85669130e-02f, 1.12866806e-02f, -2.83642169e-02f, 1.90809295e-02f, -2.43383460e-02f,
  -3.67385335e-02f, 5.42467646e-02f, 2.45364420e-02f, -1.65717900e-02f, 6.11176481e-04f, -8.68356898e-02f, 3.63727473e-02f, 1.55264894e-02f, 1.12327665e-01f, -1.21423230e-02f,
  4.83896630e-03f, 2.49554589e-02f, -1.01560438e-02f, -1.76513940e-02f, 1.55869089e-02f, 9.76249799e-02f, 4.24981527e-02f, 7.84853920e-02f, -2.24368516e-02f, 7.66265988e-02f,
  1.04849160e-01f, 8.85816738e-02f, -1.26406206e-02f, -1.10511199e-01f, -8.19039270e-02f, 5.53003252e-02f, -2.54350062e-02f, 6.96831383e-03f, 4.34139967e-02f, 3.56166773e-02f,
  1.18748173e-01f, 4.20736745e-02f, 1.35351187e-02f, 1.60917863e-02f, -5.07465079e-02f, 1.02394715e-01f, -5.60837705e-03f, -4.64542769e-03f, 9.87923741e-02f, 1.15827255e-01f,
  8.03435072e-02f, 6.27537444e-02f, 7.41927177e-02f, -2.13617850e-02f, -6.69699907e-02f, 2.91879638e-03f, -1.63471382e-02f, -3.54039669e-02f, -7.08808303e-02f, -2.05311589e-02f,
  2.16579258e-01f, -1.79702103e-01f, -3.33850533e-01f, -1.75486833e-01f, -2.75106728e-01f, -1.77396938e-01f, -2.69218117e-01f, -1.75177798e-01f, 7.97435567e-02f, 1.44559657e-02f,
  -1.33439481e-01f, 3.04991920e-02f, 3.16807419e-01f, -3.52751523e-01f, 2.51984477e-01f, 2.63191551e-01f, -2.54626751e-01f, -3.50076519e-02f, -6.97678095e-03f, -1.80577576e-01f,
  -4.34042066e-02f, -1.91480160e-01f, -1.17867224e-01f, -2.09223092e-01f, -3.12874049e-01f, -2.05254331e-01f, -2.62929630e-02f, -1.35807768e-01f, -2.64902085e-01f, -7.40552507e-03f,
  -1.20116845e-02f, -1.03314584e-02f, -1.02363154e-01f, 4.37990539e-02f, -5.60512915e-02f, 6.08056411e-02f, -3.37685662e-04f, 5.42724803e-02f, -5.50308600e-02f, -1.53212249e-02f,
  1.20368205e-01f, 1.95539203e-02f, -6.73082769e-02f, 7.41019249e-02f, -4.11796151e-03f, -1.21211149e-01f, 1.75543111e-02f, 1.61752906e-02f, 1.23690683e-02f, 3.36324424e-02f,
  -5.81770353e-02f, -6.55261874e-02f, -9.18883607e-02f, 1.29325008e-02f, -2.49760412e-02f, -1.14473691e-02f, 1.44192739e-03f, 5.64290434e-02f, -4.68252338e-02f, 2.39053494e-04f,
  8.26966017e-02f, 4.68443781e-02f, 5.74406795e-02f, -4.18952145e-02f, 2.13894341e-02f, -4.62055914e-02f, -4.85288128e-02f, -1.43449716e-02f, 3.39049995e-02f, -6.75105229e-02f,
  -2.07872149e-02f, -4.07590568e-02f, 4.69828025e-02f, -4.56886657e-04f, 9.08841789e-02f, 3.56232226e-02f, -6.59951493e-02f, -3.24731953e-02f, -1.08456612e-02f, -6.98706955e-02f,
  4.45743501e-02f, 2.91685779e-02f, -2.70983726e-02f, 3.51281278e-02f, -4.84717311e-03f, 4.84459065e-02f, -4.86433366e-03f, 5.77078313e-02f, -1.20338863e-02f, -1.14661586e-02f,
  -9.83362719e-02f, 9.48803127e-02f, -2.23010536e-02f, -3.15040015e-02f, -1.52577925e-02f, -3.24745476e-02f, 4.69203293e-02f, 2.24727746e-02f, 5.76920882e-02f, 3.88825051e-02f,
  3.78656834e-02f, -4.64955950e-03f, -3.11269891e-02f, 9.73571092e-03f, 1.34010240e-02f, 2.32128669e-02f, 3.38160470e-02f, 6.28832206e-02f, -4.37080190e-02f, -1.34825297e-02f,
  -1.49510112e-02f, 8.03971812e-02f, 1.21463791e-01f, 4.39525954e-02f, 1.83055084e-02f, -7.80074224e-02f, 8.26393515e-02f, 3.16310935e-02f, 1.32765219e-01f, 3.62154432e-02f,
  -7.65445381e-02f, -4.32832539e-02f, -8.39532539e-02f, -3.60038057e-02f, 6.50548041e-02f, -1.40638072e-02f, -8.67989808e-02f, -2.62680352e-02f, 5.47232851e-02f, -1.36476494e-02f,
  -5.11937737e-02f, 2.45899167e-02f, -8.59253332e-02f, -2.12593805e-02f, -2.66682003e-02f, 4.97081429e-02f, -5.75118139e-02f, -6.21259697e-02f, -7.51795396e-02f, 1.95070868e-03f,
  4.72695846e-03f, 7.01855049e-02f, 5.84422015e-02f, 1.31974623e-01f, 3.80170122e-02f, -8.58164653e-02f, -9.14825723e-02f, 5.09221526e-03f, 8.20719078e-02f, 1.00245290e-01f,
  -1.33045688e-02f, -7.14593530e-02f, -8.02079812e-02f, 7.24183917e-02f, 1.09966071e-02f, 4.90808375e-02f, 1.00358564e-03f, 4.16639261e-02f, -5.35381809e-02f, 6.76809028e-02f,
  7.72009604e-03f, 3.28733250e-02f, -6.44513639e-03f, 8.54498595e-02f, -8.99742357e-03f, 9.50282514e-02f, -6.57120273e-02f, -3.61950025e-02f, -6.98678121e-02f, 3.87164541e-02f,
  -2.35360600e-02f, -6.15929216e-02f, 6.55699000e-02f, -7.65944123e-02f, -2.70142630e-02f, -8.59923065e-02f, 4.05360805e-03f, -4.43869755e-02f, 2.38718428e-02f, 4.34818445e-03f,
  6.13217987e-02f, 4.93898578e-02f, -4.70685028e-02f, 7.94122666e-02f, -8.34611058e-02f, 7.01024905e-02f, 9.55851004e-03f, 4.20548171e-02f, -5.86312218e-03f, -1.84151176e-02f,
  -3.39972600e-02f, 5.35871238e-02f, -6.46133572e-02f, -7.38235414e-02f, 5.54933771e-02f, -5.06169982e-02f, 6.00655302e-02f, 2.96014100e-02f, 4.55541052e-02f, -3.89000289e-02f,
  6.92394227e-02f, -2.68690288e-02f, 7.68455863e-02f, -4.72934358e-03f, -3.83366309e-02f, -4.41556834e-02f, -4.43800874e-02f, -1.17133372e-02f, -9.95623544e-02f, -5.14315553e-02f,
  2.53325365e-02f, -1.86875265e-03f, 4.51457426e-02f, 4.97057177e-02f, 1.38287432e-02f, 4.32283580e-02f, -6.91863894e-02f, -3.26232389e-02f, -6.65433034e-02f, -2.35859007e-02f,
  4.50962298e-02f, -9.74740013e-02f, -3.64743248e-02f, 4.88807559e-02f, 5.49685545e-02f, -2.73366440e-02f, -1.01983219e-01f, 3.66456136e-02f, -2.38163620e-02f, -3.13584097e-02f,
  8.75109341e-03f, 7.88543969e-02f, 7.20862150e-02f, 7.64987469e-02f, -8.24038610e-02f, 8.06547999e-02f, 4.34048586e-02f, -5.96437491e-02f, -9.96591616e-03f, 5.13127930e-02f,
  1.07186720e-01f, -1.12786219e-01f, 7.83369765e-02f, 7.43602365e-02f, 4.54429723e-02f, 6.75680563e-02f, 2.72115786e-02f, -5.95154278e-02f, -8.05266276e-02f, -9.99160111e-02f,
  2.31873197e-03f, 6.56125769e-02f, -6.67148270e-03f, -5.56646474e-02f, 1.32025734e-01f, 2.87587028e-02f, -7.94238597e-02f, -6.20909855e-02f, 4.79022041e-02f, 7.96657205e-02f,
  2.43287105e-02f, -2.29852516e-02f, 8.81488398e-02f, -1.05332762e-01f, -4.22697589e-02f, 6.48311526e-02f, 5.23485802e-02f, 4.89729941e-02f, -7.00466856e-02f, -1.27258850e-02f,
  1.20577708e-01f, 2.35658903e-02f, 3.22899185e-02f, 3.35871391e-02f, -5.67748472e-02f, -2.18261648e-02f, 6.96654245e-02f, 6.75963238e-02f, 1.36414105e-02f, -2.49124411e-02f,
  3.62744718e-03f, 8.67514387e-02f, 1.90030225e-02f, -3.88227142e-02f, -7.59376436e-02f, -2.75700353e-02f, -7.82824010e-02f, -2.85477024e-02f, 9.67179798e-03f, 9.00207181e-03f,
  -4.82858457e-02f, -6.64275661e-02f, 9.22155287e-03f, 4.05552834e-02f, -8.15263297e-03f, 1.10893669e-02f, -6.06593676e-02f, 7.85707403e-03f, 7.22997859e-02f, -8.75570625e-02f,
  3.90226096e-02f, -9.73673724e-03f, -1.77571084e-02f, -1.94701161e-02f, -8.33571404e-02f, -2.54802983e-02f, 7.19495267e-02f, 5.36636189e-02f, 1.10654971e-02f, 1.86487399e-02f,
  4.17784601e-02f, -5.57427593e-02f, 5.75986132e-02f, 7.51450509e-02f, 2.70082001e-02f, 6.05507977e-02f, 4.48931679e-02f, -1.29532246e-02f, 1.05259614e-02f, -6.70013726e-02f,
  -7.81038254e-02f, -3.04249041e-02f, -8.97954330e-02f, 7.34390467e-02f, 1.02641284e-01f, -7.77983889e-02f, -2.31350213e-02f, 1.29371295e-02f, -5.32590337e-02f, -3.31668602e-03f,
  2.17751432e-02f, 3.69539522e-02f, 8.09691027e-02f, -6.18559122e-02f, 5.26397824e-02f, 4.01658565e-02f, 6.47582784e-02f, -1.52198654e-02f, -4.81606908e-02f, 3.39931399e-02f,
  -6.81898147e-02f, -4.33872864e-02f, 8.16684663e-02f, 4.43072803e-02f, -6.63924739e-02f, -5.63867092e-02f, -3.60615179e-02f, 8.77525955e-02f, -1.65808317e-03f, 6.70483410e-02f,
  4.90818769e-02f, 8.80516991e-02f, -8.96553993e-02f, 3.68770235e-03f, 1.68988016e-02f, 2.37738173e-02f, -7.40234554e-02f, -6.04152307e-03f, -1.03555657e-02f, -4.14220393e-02f,
  -1.96754009e-01f, 7.48378644e-03f, -1.53236702e-01f, -2.60074958e-02f, 1.13393664e-01f, -9.55584422e-02f, -1.11899994e-01f, 3.10677774e-02f, -6.03488535e-02f, 1.50187030e-01f,
  6.62078410e-02f, -1.37140378e-01f, 1.46492928e-01f, -5.68076037e-02f, -2.97759801e-01f, -1.64180435e-03f, -4.55976985e-02f, -4.42712680e-02f, -2.48772260e-02f, 7.43373632e-02f,
  -1.44546211e-01f, 8.32270235e-02f, -9.58913416e-02f, 8.10869858e-02f, 7.08734989e-02f, -5.58244959e-02f, 9.74296033e-02f, 1.09964810e-01f, 7.83389360e-02f, -7.72252008e-02f,
  -2.00043656e-02f, -7.00556338e-02f, 9.64220986e-03f, -9.36650261e-02f, 5.77063002e-02f, -1.97337065e-02f, -1.66453626e-02f, -8.96661654e-02f, 3.65606067e-03f, -9.73628014e-02f,
  1.96700040e-02f, -8.46699178e-02f, -6.40675500e-02f, 6.25842363e-02f, -6.40181266e-03f, -7.29811862e-02f, -3.30828689e-02f, -2.82306748e-04f, 6.34977454e-03f, -8.03854242e-02f,
  4.99003716e-02f, 1.88547317e-02f, -4.23221476e-02f, 3.17414589e-02f, -1.21474368e-02f, -1.96671970e-02f, -9.15990993e-02f, 8.00329610e-04f, -7.74347857e-02f, -1.49074513e-02f,
  -8.83603320e-02f, 1.06952414e-01f, 3.63439694e-02f, -6.55389130e-02f, 7.51638645e-03f, 1.27930986e-02f, 1.82863586e-02f, 6.36106953e-02f, -1.13555661e-03f, 3.99497151e-03f,
  4.82897051e-02f, 2.01675459e-03f, -5.33490814e-02f, 2.72571892e-02f, 4.94862534e-02f, -6.86168596e-02f, 8.63764957e-02f, -3.56313922e-02f, 5.60142435e-02f, -3.85532342e-02f,
  1.24356365e-02f, 5.85815348e-02f, -3.16627249e-02f, 1.07036553e-01f, 8.68813507e-03f, 1.33650629e-02f, 2.16159429e-02f, -8.86279810e-03f, 3.38827223e-02f, 3.80206481e-03f,
  -2.96954415e-04f, 7.71164820e-02f, -8.33630655e-03f, 5.58918901e-02f, -5.12751937e-02f, 3.61171514e-02f, -5.97477779e-02f, -5.25126159e-02f, -6.59242868e-02f, 2.33585499e-02f,
  -2.43905075e-02f, 2.23219860e-02f, 4.20537889e-02f, -4.46931124e-02f, -7.54945055e-02f, 3.15023810e-02f, 7.68031999e-02f, 2.11521015e-02f, 1.72700323e-02f, -7.81826675e-02f,
  9.11264271e-02f, 6.69096634e-02f, 3.76855321e-02f, 9.14571732e-02f, 3.50943767e-02f, -3.35022211e-02f, -7.54477605e-02f, 6.65776283e-02f, 1.04088932e-02f, -3.86511870e-02f,
  1.47259727e-01f, 1.51899561e-01f, 1.12472035e-01f, 1.13435440e-01f, -1.74717560e-01f, -2.44386256e-01f, -8.66197199e-02f, -9.36898682e-03f, -1.53460160e-01f, -7.36432225e-02f,
  1.01382650e-01f, 1.02099203e-01f, -1.92678124e-02f, 1.33849770e-01f, 7.07325786e-02f, 2.38965712e-02f, 1.46873236e-01f, -5.21859415e-02f, 9.37369540e-02f, 9.73844007e-02f,
  1.59138009e-01f, 1.24426447e-01f, 2.94963837e-01f, 1.41530409e-01f, 1.38337597e-01f, 1.18295789e-01f, 1.20393470e-01f, 1.23357251e-01f, 1.97577596e-01f, 6.57429472e-02f,
  5.71183674e-02f, 9.80550572e-02f, -3.43503989e-02f, 1.24224974e-03f, 7.52598271e-02f, -6.28095418e-02f, 4.66581434e-02f, -1.37414243e-02f, 4.29090671e-02f, -5.41856959e-02f,
  4.73739952e-02f, -2.77713612e-02f, 9.57013399e-05f, -2.90316157e-02f, 2.33365130e-03f, 2.30514240e-02f, -6.53380603e-02f, 2.08933558e-02f, -6.68457672e-02f, -2.20275135e-03f,
  6.21664226e-02f, -3.37508619e-02f, 4.10331637e-02f, 6.19390607e-02f, 8.75420570e-02f, -2.88507175e-02f, -4.56170551e-03f, -1.16024408e-02f, 7.84163270e-03f, -6.29910268e-03f,
  9.70717445e-02f, 2.57861782e-02f, 7.27372942e-03f, -8.08762945e-03f, -2.22312454e-02f, -1.22212351e-03f, 4.99050878e-02f, -6.56256229e-02f, -4.79045659e-02f, -5.19511104e-03f,
  7.64276879e-03f, 2.52535064e-02f, 1.33300740e-02f, -1.51449367e-02f, 5.12463786e-02f, 2.86882813e-03f, -7.88215175e-02f, 7.37712905e-02f, -7.99921714e-03f, 2.88093388e-02f,
  4.74062674e-02f, 9.14710835e-02f, 2.88613942e-02f, -1.71549618e-02f, -1.75301230e-03f, -1.27776451e-02f, 8.81488994e-02f, 7.43655779e-04f, -4.15342674e-03f, 3.46046425e-02f,
  5.87089434e-02f, 2.95363426e-01f, -2.53757462e-02f, 1.61369424e-02f, 6.46858588e-02f, -2.33128369e-02f, 2.36362722e-02f, 7.51366764e-02f, -1.85563136e-03f, 8.52075666e-02f,
  -3.59716080e-02f, -7.18763545e-02f, -8.86238441e-02f, -5.98314079e-03f, -4.64819511e-03f, -2.03896910e-02f, 1.47043735e-01f, -5.23851514e-02f, 9.17292386e-02f, 1.01414874e-01f,
  1.06598742e-01f, -2.63998825e-02f, 7.90733621e-02f, -1.27061874e-01f, 4.92471457e-03f, -2.75245141e-02f, -1.51742240e-02f, 1.01077877e-01f, 3.37826423e-02f, -5.22693284e-02f,
  9.74160805e-02f, -1.28739268e-01f, 3.67742293e-02f, 6.93319589e-02f, 1.68305233e-01f, 6.86523411e-03f, 4.46225032e-02f, -3.24446633e-02f, 1.62298977e-02f, -6.84707239e-02f,
  -4.27552946e-02f, -4.30841371e-02f, -8.07652697e-02f, -1.15126900e-01f, 1.05873860e-01f, -7.01767504e-02f, -3.28936167e-02f, 3.18919308e-02f, 7.74364918e-02f, -4.42820676e-02f,
  4.67339493e-02f, 4.57518995e-02f, 1.12905368e-01f, 8.27333182e-02f, 9.66235027e-02f, 1.35758609e-01f, -1.00590065e-01f, -5.60317934e-03f, 9.26553458e-02f, 1.91444922e-02f,
  2.76090205e-02f, -4.37865853e-02f, -6.19454756e-02f, 5.15111201e-02f, 5.87823950e-02f, -1.31758619e-02f, -1.07298819e-02f, 9.62223858e-02f, 4.00541984e-02f, 9.33268815e-02f,
  -9.94001701e-02f, -6.99448586e-03f, 7.38548487e-03f, 9.85190794e-02f, 1.16098545e-01f, 6.44804016e-02f, -2.85881036e-03f, 6.61693886e-02f, -4.35593203e-02f, -3.69691551e-02f,
  -4.14825417e-02f, -5.29014431e-02f, 2.43645953e-03f, -2.98008565e-02f, 5.01796938e-02f, 6.70633465e-02f, 5.88354282e-02f, 7.80652389e-02f, 3.40364352e-02f, -4.75617349e-02f,
  2.99167391e-02f, -2.99103688e-02f, 5.21384962e-02f, 2.59423833e-02f, -4.97340150e-02f, -4.14478630e-02f, -6.59178421e-02f, -6.48598075e-02f, -4.06901445e-03f, -6.18199259e-02f,
  -1.07645281e-02f, 2.54687686e-02f, 8.18491429e-02f, -8.23319480e-02f, 2.38123462e-02f, 1.30016459e-02f, 5.50057068e-02f, 7.48250410e-02f, -3.87643687e-02f, -5.64575680e-02f,
  -1.62104685e-02f, 9.40665603e-03f, -4.97404262e-02f, 6.94640726e-02f, -1.89554449e-02f, -3.38346176e-02f, -6.91902786e-02f, 4.89806347e-02f, -8.39746837e-03f, 5.16561456e-02f,
  -1.58382475e-01f, -4.43266071e-02f, -1.62115749e-02f, -1.68133955e-02f, 1.35716414e-02f, -8.77983868e-02f, -8.54872689e-02f, -7.79398903e-02f, -7.68962428e-02f, 1.62763186e-02f,
  7.34737888e-02f, -1.61909650e-03f, 9.32972936e-04f, 1.38563989e-02f, -1.72126684e-02f, -2.91495565e-02f, 4.92447950e-02f, -1.01132333e-01f, 1.43158045e-02f, -7.57886246e-02f,
  7.54615292e-02f, -3.76057401e-02f, 7.02192560e-02f, -3.93122807e-02f, 6.74858019e-02f, 3.39651331e-02f, -2.41806358e-03f, -2.76750326e-02f, 2.90574972e-02f, -3.99650112e-02f,
  3.54472548e-02f, -3.93378317e-01f, 1.79307833e-01f, 3.47596593e-02f, 1.87531382e-01f, 7.48849735e-02f, 1.46152498e-02f, -2.01204598e-01f, -2.92810291e-01f, -3.85896653e-01f,
  -1.04459845e-01f, 9.19326842e-02f, 5.18345051e-02f, -7.19067752e-02f, 2.46160895e-01f, 6.79930998e-03f, -1.04296885e-01f, -1.31585896e-02f, -5.83913326e-02f, -7.86755309e-02f,
  1.13614788e-02f, -9.04116109e-02f, 8.54511708e-02f, -1.33851692e-01f, 4.91570197e-02f, -1.05642885e-01f, 4.79736626e-02f, 7.96672106e-02f, 1.94331408e-02f, 1.31764069e-01f,
  2.09459998e-02f, -1.86628148e-01f, -8.53703767e-02f, -8.39355439e-02f, -6.50536343e-02f, -2.62617078e-02f, 9.54682752e-02f, 1.28367513e-01f, -2.01672222e-03f, -9.58356075e-03f,
  4.97727357e-02f, 5.42427488e-02f, -1.22455135e-02f, 4.47771102e-02f, -4.54935767e-02f, -8.52098912e-02f, -2.40465067e-02f, -4.11589108e-02f, -4.19754758e-02f, 6.63527548e-02f,
  3.80470082e-02f, 1.64725760e-03f, 4.82722744e-02f, 2.23510601e-02f, 2.17903429e-03f, -4.91389632e-02f, 4.61735055e-02f, 1.03756435e-01f, -1.22156981e-02f, 6.88552782e-02f,
  -5.01259230e-03f, -3.47452275e-02f, 8.82323645e-03f, -8.82642344e-02f, 1.48838386e-02f, 1.51401646e-02f, 6.67530596e-02f, -1.90830305e-02f, 2.78159790e-02f, 4.97449301e-02f,
  -3.90148796e-02f, 7.02495202e-02f, -1.65701192e-02f, -5.85655980e-02f, 2.16205213e-02f, -4.60471436e-02f, 7.04371929e-02f, 2.05098968e-02f, -9.49144550e-03f, 3.90393473e-02f,
  -3.10640484e-02f, 2.12160274e-02f, -5.89273609e-02f, 6.90299943e-02f, -2.82184090e-02f, -4.02600020e-02f, -8.11368078e-02f, -5.25462907e-04f, -1.38061512e-02f, -1.39316404e-02f,
  -2.33305112e-01f, -1.86697423e-01f, 1.07154099e-03f, 4.43747342e-02f, -4.83913273e-02f, -4.56959568e-02f, 3.72439027e-02f, 1.53409329e-03f, -2.43883189e-02f, -6.29453138e-02f,
  -5.19475192e-02f, -6.90074812e-04f, 2.21294891e-02f, -5.42852059e-02f, -8.87144171e-03f, -1.12206275e-02f, -1.52299078e-02f, -4.78785165e-04f, -5.09263873e-02f, -7.37312734e-02f,
  -7.06699044e-02f, 5.16972654e-02f, 2.99442466e-02f, -8.92736204e-03f, -7.05263168e-02f, 1.94392763e-02f, 6.85672462e-02f, 2.70053614e-02f, -3.38458829e-03f, -2.52802595e-02f,
  -1.53422683e-01f, 5.64070120e-02f, 7.80109316e-02f, -4.47430946e-02f, -2.76876301e-01f, 3.94887291e-02f, 1.63496464e-01f, -1.79324344e-01f, 7.90732577e-02f, 1.34662315e-01f,
  -7.75757059e-03f, 4.04232144e-02f, 1.16797373e-01f, -6.00586422e-02f, 2.36953557e-01f, 2.58126706e-01f, -1.96201205e-02f, 6.66009635e-02f, 2.94241123e-02f, -7.72451460e-02f,
  -8.10572878e-02f, -2.08027437e-01f, -1.35236494e-02f, -1.84757262e-01f, -2.34843731e-01f, -1.46824539e-01f, -8.89819413e-02f, -4.73578237e-02f, -1.49984583e-01f, -6.20153658e-02f,
  -1.17939495e-01f, -1.23393230e-01f, 3.72187160e-02f, 6.68984875e-02f, -2.03836709e-02f, 1.60765704e-02f, -9.16450284e-03f, -2.29044668e-02f, -2.22083945e-02f, 6.78066835e-02f,
  -3.71395098e-03f, -5.94653422e-03f, -7.64335617e-02f, -8.83505028e-03f, -7.95963109e-02f, -5.63198961e-02f, -1.32742435e-01f, -6.56941310e-02f, 2.40588430e-02f, 3.20938081e-02f,
  -4.03226763e-02f, 7.43888989e-02f, 5.85468039e-02f, 8.96952897e-02f, 7.79698119e-02f, -4.20517735e-02f, 3.03326100e-02f, 7.20683411e-02f, 5.85589968e-02f, 4.99707311e-02f,
  -9.60659832e-02f, 3.80327404e-02f, -9.95267835e-03f, -8.61185044e-03f, 1.41092865e-02f, -9.63308662e-02f, -4.41894941e-02f, -8.86235572e-03f, -1.65400002e-02f, -2.28710119e-02f,
  2.25518569e-02f, -4.12223898e-02f, -5.83263375e-02f, 9.94525999e-02f, 4.07631993e-02f, -5.56887537e-02f, -2.29702219e-02f, -2.24434882e-02f, -3.21588889e-02f, 8.45289752e-02f,
  -1.47770150e-02f, -1.77859189e-03f, 1.55889643e-02f, -2.00912263e-02f, 2.21787486e-03f, 5.28840534e-02f, 4.27649952e-02f, 1.54591408e-02f, 1.25232181e-02f, 2.87337359e-02f,
  -9.21641365e-02f, -1.03332542e-01f, -7.92575255e-02f, -8.47043935e-04f, 2.90043373e-02f, -6.90915585e-02f, -3.70174199e-02f, 3.19269411e-02f, 6.80310233e-03f, -6.31809086e-02f,
  6.16395772e-02f, 9.49065313e-02f, 4.83494215e-02f, -4.87600788e-02f, 7.62389824e-02f, -5.79814687e-02f, 5.87339588e-02f, 4.89102931e-05f, -1.42092323e-02f, -9.44420248e-02f,
  5.17930239e-02f, -2.31600180e-02f, -4.44843620e-02f, -6.36016810e-03f, -4.34628539e-02f, 7.43149966e-02f, -4.33316603e-02f, -3.59273836e-04f, -5.80021553e-02f, 1.94880143e-02f,
  -9.95864347e-02f, 2.38142777e-02f, -2.35182807e-01f, -3.09203207e-01f, 1.94204032e-01f, 1.04930416e-01f, -1.29465997e-01f, 4.28781323e-02f, -2.58779317e-01f, 2.58783311e-01f,
  1.20577380e-01f, -1.82954863e-01f, -1.68213025e-02f, -2.90982574e-01f, -4.92302865e-01f, -3.12965035e-01f, -2.52628267e-01f, -1.10363439e-01f, -1.77933052e-01f, -3.49007500e-03f,
  -1.86817408e-01f, 1.67941172e-02f, -1.49685279e-01f, 2.47332811e-01f, 7.27880225e-02f, 2.03809679e-01f, 1.06853046e-01f, 1.91306263e-01f, 9.60217193e-02f, -5.54383136e-02f,
  -6.45925254e-02f, 1.84267312e-02f, -8.04884732e-03f, 5.15169688e-02f, 3.48104984e-02f, 1.25461131e-01f, 1.46872535e-01f, -3.72125134e-02f, -1.83578413e-02f, 1.27348853e-02f,
  6.75430000e-02f, 2.96810567e-02f, 4.93100844e-03f, 1.15228789e-02f, 1.48015795e-02f, -1.92351285e-02f, -3.63898389e-02f, -2.49746256e-02f, -9.39972624e-02f, 1.25975413e-02f,
  -3.27104367e-02f, -3.39593291e-02f, -2.01757643e-02f, -5.46005778e-02f, -8.03968385e-02f, 3.42861861e-02f, 5.28482981e-02f, 8.55018292e-03f, 1.73091143e-02f, -1.12726197e-01f,
  8.34132060e-02f, 6.99613541e-02f, -1.91088188e-02f, 2.36816350e-02f, -1.23369433e-02f, 4.55600917e-02f, -7.75299966e-03f, 4.42539528e-02f, 4.46753688e-02f, 7.04968274e-02f,
  4.81636487e-02f, -2.62388587e-02f, -1.37074839e-03f, 1.02910101e-01f, 1.12268450e-02f, -4.59023118e-02f, 7.74497613e-02f, 8.09801072e-02f, -8.83427039e-02f, -9.12316330e-03f,
  7.98166469e-02f, 2.63661854e-02f, 2.44328678e-02f, 2.49108449e-02f, -6.71817660e-02f, 1.88318044e-02f, 5.89237437e-02f, -6.79900795e-02f, -5.46739921e-02f, 7.17937276e-02f,
  6.46205470e-02f, 1.99028980e-02f, -1.69668589e-02f, 5.80236018e-02f, 2.48123333e-02f, 7.14528635e-02f, -3.55522297e-02f, 1.32927531e-02f, -7.38063455e-03f, 2.87040062e-02f,
  1.29083648e-01f, -4.73073237e-02f, 1.29339859e-01f, 4.46337601e-03f, 8.58113468e-02f, 4.55906652e-02f, 3.77506338e-04f, 5.07529825e-02f, 9.39919800e-02f, 1.93398097e-03f,
  1.15045840e-02f, 5.77545613e-02f, -1.36219049e-02f, -4.59722430e-02f, 8.75278860e-02f, 8.43019560e-02f, 8.29178169e-02f, -2.52401140e-02f, 1.45077184e-02f, -4.30218056e-02f,
  -1.40903844e-03f, -6.82125986e-02f, -1.39299110e-01f, -6.34437567e-03f, 9.74071100e-02f, -2.56827157e-02f, -1.89838022e-01f, -6.81424290e-02f, -8.09760094e-02f, -1.98943824e-01f,
  -1.60616562e-01f, -9.72431675e-02f, -1.68736354e-01f, -7.33752474e-02f, 1.47224009e-01f, 1.15199862e-02f, 1.03895389e-03f, 9.11604892e-03f, -1.43881449e-02f, -4.53629978e-02f,
  1.06385231e-01f, 6.90615475e-02f, 1.33627027e-01f, 3.43314670e-02f, 4.26659025e-02f, 8.78920183e-02f, 6.29104525e-02f, 3.01568699e-03f, 4.51911315e-02f, 1.41255155e-01f,
  7.40104914e-02f, -8.86777416e-02f, -9.79330242e-02f, 5.78979477e-02f, 1.07108140e-02f, -1.69132724e-02f, -6.12059310e-02f, 8.56930390e-02f, 9.49978903e-02f, 6.55955374e-02f,
  7.10334256e-02f, 1.10761240e-01f, 1.21709429e-01f, 7.99532384e-02f, 1.00448184e-01f, 3.53769585e-02f, 2.45693922e-02f, -6.29540682e-02f, 5.41600697e-02f, 2.98012961e-02f,
  -1.26207456e-01f, 4.05721888e-02f, -4.37868200e-02f, -3.05253267e-02f, 6.92264512e-02f, 1.35678221e-02f, 2.45895442e-02f, -6.70780540e-02f, -3.59625071e-02f, -8.06236640e-02f,
  2.91785933e-02f, -3.34908813e-02f, 3.18789785e-03f, 7.45259970e-02f, -4.99253087e-02f, -2.24294458e-02f, 5.78783229e-02f, 3.45829725e-02f, 5.18817343e-02f, 3.41390842e-03f,
  -2.30030641e-02f, 8.52535479e-03f, -2.69930251e-02f, 2.07757251e-03f, -1.25627322e-02f, -7.43352175e-02f, -7.94841070e-03f, 6.64581656e-02f, -7.87769258e-02f, 3.88295949e-02f,
  2.32721586e-02f, 5.51374778e-02f, -3.45936744e-03f, 5.40535226e-02f, -4.56093661e-02f, 4.76387143e-03f, -2.34686173e-02f, -5.10990955e-02f, 8.07338730e-02f, -3.97515818e-02f,
  -4.27448656e-03f, -1.29976690e-01f, 1.90204512e-02f, -1.40197631e-02f, -2.76452722e-03f, 2.94759739e-02f, 9.08730179e-02f, 1.92867983e-02f, -1.03939667e-01f, -4.08431254e-02f,
  3.25082988e-02f, -2.50710789e-02f, -3.52235064e-02f, -2.82083713e-02f, -1.69621352e-02f, -5.51548181e-03f, 7.16379136e-02f, -8.88340920e-03f, 1.63550221e-03f, -4.73059416e-02f,
  6.04262501e-02f, -5.72254024e-02f, -2.99958196e-02f, 5.90956211e-02f, 6.67041913e-02f, 3.93308327e-02f, 4.64020893e-02f, -8.54740143e-02f, -5.84409498e-02f, -3.08006001e-03f,
  3.07655614e-02f, 1.35047361e-01f, -1.10341292e-02f, 5.83541230e-04f, 3.56585323e-03f, -1.49477899e-01f, -6.27361014e-02f, 3.58859561e-02f, 1.50565123e-02f, 4.09356840e-02f,
  -3.15518230e-02f, 8.16821828e-02f, 3.17067467e-02f, 4.37631495e-02f, 4.93142679e-02f, -9.25267264e-02f, 3.50139700e-02f, 3.10471356e-02f, -2.79293191e-02f, 1.33698344e-01f,
  5.43063171e-02f, 4.11192030e-02f, 9.60102379e-02f, 7.44516477e-02f, 9.55214500e-02f, 4.50247303e-02f, 8.15662071e-02f, -2.59095896e-02f, -3.17549072e-02f, 4.28773090e-02f,
  2.86144633e-02f, 1.91398729e-02f, 2.46499293e-02f, -1.12012446e-01f, 1.00276973e-02f, -2.13601403e-02f, 2.45295931e-02f, 3.96492630e-02f, 7.18505168e-03f, -1.19455233e-02f,
  -9.77661237e-02f, 4.25394289e-02f, 5.97741045e-02f, -1.90881025e-02f, -5.93314618e-02f, 2.73521468e-02f, 3.49633694e-02f, 1.70062985e-02f, 4.29354468e-03f, -4.50340705e-03f,
  4.74750809e-02f, -7.90136307e-02f, -1.36417262e-02f, -1.57302746e-03f, 3.41913737e-02f, 4.67154905e-02f, -5.34324124e-02f, 6.21665549e-03f, 3.14816311e-02f, -4.63487906e-03f,
  5.25161922e-02f, -8.13109726e-02f, -6.01515034e-03f, -3.46112102e-02f, 1.80999730e-02f, -7.65328482e-03f, 4.65444177e-02f, -8.70104507e-02f, 2.56621023e-03f, -8.90873075e-02f,
  6.75164685e-02f, -8.20630118e-02f, 7.51454756e-02f, 4.95006442e-02f, 6.88845143e-02f, 5.10001741e-02f, -7.83284307e-02f, 1.03968466e-02f, 1.33292843e-02f, 5.06001227e-02f,
  -7.99437910e-02f, 5.52258082e-02f, 1.09582497e-02f, 5.25186285e-02f, -6.15300499e-02f, -5.32557257e-02f, 3.26976441e-02f, 8.11868310e-02f, 1.58388484e-02f, 5.26121631e-03f,
  2.18398101e-03f, 7.42458478e-02f, 7.55530968e-02f, -9.01632681e-02f, -5.92498071e-02f, 5.27531654e-03f, 4.94745746e-02f, -8.13831240e-02f, 8.69063959e-02f, -8.73205625e-03f,
  1.38131520e-02f, -2.06176937e-02f, -8.16282909e-03f, -4.69921902e-02f, 7.03809084e-03f, -5.52031538e-03f, 1.04058133e-02f, 7.88549334e-02f, -4.70626615e-02f, 2.46883947e-02f,
  -9.46685020e-03f, -7.90398642e-02f, -6.99932966e-03f, -2.45437473e-02f, 9.52920169e-02f, -7.44184032e-02f, 6.95849583e-02f, 5.90250976e-02f, -9.50064324e-03f, 6.04041331e-02f,
  -1.04711786e-01f, 1.56810060e-01f, 1.08959891e-01f, -1.52189896e-01f, 2.76236888e-02f, 4.03540842e-02f, 5.67760654e-02f, 7.76586384e-02f, 4.01247330e-02f, 4.93805259e-02f,
  7.71086570e-03f, 1.14821009e-01f, 1.58796787e-01f, 4.17241864e-02f, -1.69234395e-01f, -6.79448172e-02f, -1.89807445e-01f, 1.15020890e-02f, 5.48061952e-02f, -6.75021410e-02f,
  -1.82264492e-01f, -1.07252620e-01f, 1.58758350e-02f, 2.04886440e-02f, -7.13794157e-02f, 6.87222695e-03f, -6.21695071e-02f, 1.20412529e-01f, 4.00484800e-02f, 1.57669768e-01f,
  -1.02164745e-01f, -1.76954623e-02f, -4.07930277e-02f, 7.45255733e-03f, -3.81639763e-03f, -5.02975658e-02f, -3.05135474e-02f, 4.01192298e-03f, -7.50583261e-02f, 2.01438535e-02f,
  6.33658767e-02f, 7.46289194e-02f, 3.65553908e-02f, 8.88324156e-02f, -6.13690466e-02f, 4.12657745e-02f, 8.84881914e-02f, -3.93790975e-02f, 4.16130163e-02f, 4.01195884e-02f,
  3.91369350e-02f, -3.37331779e-02f, -1.31859556e-02f, -1.71249434e-02f, 6.61108829e-03f, -1.84344836e-02f, -2.59933509e-02f, 4.35694531e-02f, -5.89557365e-03f, 1.66011241e-03f,
  1.51303057e-02f, -1.64276119e-02f, 1.60149802e-02f, -6.41859323e-02f, 1.75323859e-02f, 1.28884744e-02f, -2.30029915e-02f, -8.08435604e-02f, 2.69628819e-02f, -8.60249922e-02f,
  -3.63875143e-02f, -9.94786322e-02f, 5.76834418e-02f, -8.79789740e-02f, -6.44443780e-02f, 4.75345291e-02f, -8.29535648e-02f, -4.43978570e-02f, -7.00178146e-02f, 4.80349697e-02f,
  -1.58852451e-02f, 6.33287802e-02f, 8.94148424e-02f, -1.13785483e-01f, 4.36499203e-03f, -1.03645595e-02f, -6.78826543e-03f, 7.09412396e-02f, 1.50773535e-02f, -4.15078849e-02f,
  -1.60574704e-01f, -2.08157510e-01f, 1.33625148e-02f, -2.93009095e-02f, -7.31718764e-02f, -5.85943386e-02f, -4.96571027e-02f, 7.91556314e-02f, 4.32495959e-02f, 5.43853901e-02f,
  2.68714875e-02f, -9.94266644e-02f, -8.19188207e-02f, 4.57676267e-03f, 4.03176360e-02f, -2.14185864e-02f, -5.98307177e-02f, -1.74320471e-02f, -3.90734822e-02f, 6.20595291e-02f,
  6.25841841e-02f, -3.56225893e-02f, 3.15201692e-02f, 4.14404385e-02f, -1.00978956e-01f, -7.39044162e-06f, -8.40838179e-02f, -5.03025539e-02f, 2.26006415e-02f, 7.34582394e-02f,
  -1.59017548e-01f, 2.78253108e-01f, 3.52342390e-02f, 6.84435889e-02f, -1.86584622e-01f, -1.97226495e-01f, -1.33721709e-01f, 2.30175015e-02f, -1.33797163e-02f, 1.09720387e-01f,
  -8.75106528e-02f, -3.21156643e-02f, -7.52767548e-03f, -1.56471580e-02f, -6.62771836e-02f, 6.44392669e-02f, -6.02289056e-03f, -7.15165809e-02f, -1.76535975e-02f, -2.52971047e-04f,
  4.47262526e-02f, -2.38584839e-02f, 7.36305565e-02f, 9.15803313e-02f, -3.25109176e-02f, 5.04774190e-02f, 2.24356521e-02f, 4.84547168e-02f, -5.55555560e-02f, -6.20391890e-02f,
  -4.92134085e-03f, -2.11393703e-02f, -2.19730921e-02f, 3.67499962e-02f, -1.77951641e-02f, -1.15097404e-01f, 7.11009875e-02f, -6.53074980e-02f, -7.69758373e-02f, 5.84415207e-03f,
  2.12578196e-02f, -9.56394523e-03f, -2.67622322e-02f, 4.14464101e-02f, 1.19191194e-02f, -3.02806776e-02f, -4.99272123e-02f, -6.02697954e-02f, -7.57040977e-02f, 6.34450465e-02f,
  1.72710866e-02f, 5.28867990e-02f, -1.06824990e-02f, -2.58419737e-02f, -6.23905547e-02f, 1.14528937e-02f, -8.28111172e-02f, 7.44579285e-02f, 4.04965542e-02f, -3.51795144e-02f,
  -9.75034237e-02f, 3.41909472e-03f, 2.64797285e-02f, -6.16109781e-02f, 5.47359549e-02f, 4.73029502e-02f, 4.63027991e-02f, 7.04204896e-04f, -3.24579999e-02f, 5.87750040e-02f,
  -2.38209348e-02f, -1.48683656e-02f, -1.12945490e-01f, -5.46840280e-02f, -9.07020122e-02f, -2.31802110e-02f, -3.32879797e-02f, -3.71409357e-02f, 6.95075933e-03f, 1.01895049e-01f,
  -1.82234365e-02f, -9.96287763e-02f, 4.30784933e-02f, 1.53286057e-02f, -1.25325732e-02f, -6.23734519e-02f, 8.65055844e-02f, 8.37916210e-02f, -4.66491729e-02f, -7.04284199e-03f,
  -1.00956060e-01f, 4.00243364e-02f, 6.13198336e-03f, -7.52083808e-02f, -2.12026145e-02f, -4.52283137e-02f, 1.04374327e-02f, 5.25065474e-02f, -7.29854107e-02f, -4.44165319e-02f,
  -2.67004296e-02f, 8.24764669e-02f, -5.23644611e-02f, 4.25218511e-03f, -5.78060038e-02f, -6.01879284e-02f, 6.70359284e-02f, -1.00117950e-02f, -8.29929933e-02f, 1.66282803e-02f,
  -9.15761292e-03f, -3.24455975e-03f, 1.96953840e-03f, -2.99595408e-02f, 6.09098785e-02f, -8.84551778e-02f, 3.59685570e-02f, 4.16139811e-02f, 6.28656447e-02f, 1.58712473e-02f,
  -3.97070590e-03f, -1.27526969e-01f, 2.28801161e-01f, 9.36539322e-02f, 6.90168738e-02f, 1.56575009e-01f, -1.72980165e-03f, 7.61556998e-02f, 1.35492399e-01f, -6.44763559e-02f,
  -1.08565733e-01f, -1.29782304e-01f, -9.40121338e-02f, -6.50230423e-02f, -3.26796584e-02f, -1.38956651e-01f, -7.40153119e-02f, 4.83146141e-04f, -1.27554918e-02f, -5.19424211e-03f,
  5.13798259e-02f, -1.68914542e-01f, 9.10824072e-03f, 3.30112465e-02f, 6.30071908e-02f, 6.18572347e-02f, -1.20319813e-01f, -3.52405943e-02f, 3.49730290e-02f, -1.46470815e-01f,
  8.36233869e-02f, -6.80428073e-02f, -3.07828747e-02f, 4.56808992e-02f, 5.25804833e-02f, -3.30277905e-02f, 2.97513995e-02f, -1.42390460e-01f, -3.42303738e-02f, 7.27481246e-02f,
  -8.60099792e-02f, -6.93582222e-02f, 2.07881276e-02f, 2.45336927e-02f, -3.80920656e-02f, -1.61580481e-02f, 8.59427303e-02f, 7.09907338e-02f, -1.67466868e-02f, 8.83945376e-02f,
  6.15829341e-02f, -3.24750878e-02f, 1.02588914e-01f, -9.22326595e-02f, 3.89552489e-02f, -5.48027158e-02f, 8.05631056e-02f, -2.47649965e-04f, 6.87292069e-02f, 4.58071344e-02f,
  2.56215017e-02f, 5.69203831e-02f, 4.37294766e-02f, 9.16486755e-02f, -1.99059714e-02f, 8.24814960e-02f, 1.08214326e-01f, 1.90870315e-02f, -2.78663300e-02f, -3.86330038e-02f,
  -3.76204029e-02f, -6.72653988e-02f, 1.10021897e-01f, 3.30979208e-04f, -4.99589108e-02f, 9.02800169e-03f, -9.44007561e-02f, -8.11611582e-03f, -6.16856292e-03f, -2.48331279e-02f,
  2.41425796e-03f, 1.98630560e-02f, -9.52133685e-02f, 2.31874688e-03f, -1.83293670e-02f, 3.82585973e-02f, 4.97727841e-02f, -2.91412491e-02f, 3.35442312e-02f, -7.70064592e-02f,
  -7.33582973e-02f, -1.38380781e-01f, -8.68280679e-02f, -8.02553818e-02f, 1.57033056e-02f, -7.89750218e-02f, -1.36560425e-02f, 1.76146179e-02f, -7.12711662e-02f, 3.57133858e-02f,
  -6.24735206e-02f, 8.41417816e-03f, 5.80431223e-02f, -7.46892691e-02f, -4.50722538e-02f, 1.99828483e-03f, -1.02591261e-01f, -5.19696176e-02f, -6.51639551e-02f, -6.23603389e-02f,
  -1.37551641e-02f, -5.53737953e-02f, 2.50769202e-02f, -4.68239263e-02f, -1.09001152e-01f, -6.06063865e-02f, 3.07740066e-02f, -7.07003772e-02f, -3.61118689e-02f, -4.24455181e-02f,
  7.01341853e-02f, -9.74581987e-02f, 9.28633437e-02f, 9.79857147e-02f, 1.75075337e-01f, 9.08233970e-02f, 2.54052449e-02f, 1.76654667e-01f, 1.14197522e-01f, -8.28955919e-02f,
  -7.64669776e-02f, -1.13499850e-01f, -6.14186414e-02f, -4.85250503e-02f, -5.97426519e-02f, -2.21231561e-02f, 1.02697715e-01f, 7.33446255e-02f, 2.98785493e-02f, -3.51975602e-03f,
  -1.37026943e-02f, -9.57505107e-02f, -1.72051005e-02f, -1.04389846e-01f, -1.30918622e-02f, -9.07173231e-02f, -1.47158042e-01f, -9.38631743e-02f, -2.83735059e-02f, 5.56982763e-04f,
  3.48765887e-02f, -4.25530151e-02f, -3.75655256e-02f, 3.30793336e-02f, -1.40818097e-02f, -1.88960023e-02f, 1.01101818e-02f, 2.02710629e-02f, 5.78632280e-02f, -7.66756237e-02f,
  -1.89712364e-02f, 1.42876990e-02f, 3.45031731e-02f, 7.67249539e-02f, 7.67714158e-02f, -2.91719195e-02f, 6.33872598e-02f, 7.77466642e-03f, 9.12384875e-03f, -4.26226594e-02f,
  3.85225266e-02f, 7.76168108e-02f, -2.88757384e-02f, 4.15267609e-02f, -4.83578220e-02f, 5.10965884e-02f, -8.98510963e-02f, -8.57914388e-02f, 5.11467531e-02f, 6.30740002e-02f,
  -6.33620471e-02f, 3.66793871e-02f, -2.86672264e-03f, -3.76657285e-02f, 5.31671904e-02f, 3.89168262e-02f, -5.94661646e-02f, 2.40747835e-02f, -1.72547624e-02f, 6.22448213e-02f,
  6.93539530e-02f, -2.91542448e-02f, 2.39404831e-02f, -4.28616777e-02f, 6.40130565e-02f, 5.52681200e-02f, -5.74734323e-02f, -3.69454734e-02f, -5.67724183e-02f, 7.01958090e-02f,
  -1.02858692e-01f, 2.31661741e-02f, -6.23984374e-02f, -1.18702259e-02f, 6.94909096e-02f, 3.08702663e-02f, -5.30258799e-03f, 4.02274281e-02f, -2.96839699e-02f, -6.78491741e-02f,
  5.76266684e-02f, 1.33259660e-02f, 2.18857527e-02f, 1.74872088e-03f, -2.98639461e-02f, 4.80754748e-02f, 3.30448598e-02f, -6.40126467e-02f, 8.18115622e-02f, -5.75455874e-02f,
  1.15892487e-02f, -6.59422651e-02f, 6.81137741e-02f, -5.60933203e-02f, 5.12073189e-02f, 1.17663458e-01f, 2.81456895e-02f, 9.63816121e-02f, 7.37055317e-02f, -7.76665509e-02f,
  6.74473867e-02f, -6.09950721e-02f, 7.98996389e-02f, 7.12202862e-02f, 5.29418588e-02f, 3.62688079e-02f, -3.26141305e-02f, 4.77276184e-02f, 6.35458622e-03f, 7.83027261e-02f,
  2.99593419e-01f, 3.58207643e-01f, 2.65454531e-01f, 2.28963703e-01f, -2.55904317e-01f, -3.06824356e-01f, -3.01332325e-01f, -3.95744331e-02f, 2.56953062e-03f, 6.41108602e-02f,
  -2.36487046e-01f, 5.08279860e-01f, -1.08506769e-01f, 2.30389312e-02f, -1.78219587e-01f, -2.25811809e-01f, -1.16347849e-01f, 9.52493474e-02f, -4.67466377e-02f, 8.98928642e-02f,
  -9.50731114e-02f, -3.10409844e-01f, -1.84352249e-02f, -1.50588244e-01f, 5.06294779e-02f, 2.64138490e-01f, -1.07273191e-01f, -1.25722170e-01f, 1.06282651e-01f, -1.07883431e-01f,
  -1.20834999e-01f, 7.68673560e-03f, 1.18269041e-01f, 7.86480010e-02f, -2.83310432e-02f, -1.17816478e-02f, 7.81765580e-02f, -1.09024584e-01f, 5.38764037e-02f, 5.47331907e-02f,
  4.58573885e-02f, 3.89897935e-02f, 5.90255260e-02f, 7.53440754e-03f, 4.34122011e-02f, 1.04180031e-01f, 7.32980818e-02f, 1.21841781e-01f, 1.22389279e-01f, 6.77272528e-02f,
  1.31385922e-01f, 1.81811735e-01f, 4.50469702e-02f, 1.20501131e-01f, 2.73130052e-02f, -7.85593968e-03f, 1.81772187e-02f, 5.69897257e-02f, -5.04812691e-03f, -1.11507755e-02f,
  4.31974279e-03f, -9.50327143e-02f, -7.38954395e-02f, 4.25787009e-02f, -9.06398296e-02f, -3.20053250e-02f, -5.35187982e-02f, -7.74745569e-02f, -1.09195721e-03f, -6.25008419e-02f,
  2.61629205e-02f, 6.19846396e-02f, -2.59038284e-02f, 7.09508806e-02f, 7.78607577e-02f, 6.38317093e-02f, -2.69510224e-03f, 7.02613071e-02f, -1.68510135e-02f, 1.84256025e-02f,
  -1.15325429e-01f, -8.59479681e-02f, 6.19611442e-02f, 1.20090917e-02f, -1.22090600e-01f, 7.03833904e-03f, 4.70519848e-02f, 7.60410577e-02f, -6.87953606e-02f, -9.41453353e-02f,
  7.58179417e-03f, 3.29246856e-02f, -5.20320199e-02f, 7.09265918e-02f, 1.03036230e-02f, 2.16923431e-02f, -4.88642193e-02f, 1.01202331e-01f, -7.69502223e-02f, -1.10156149e-01f,
  -1.17735723e-02f, -2.03551035e-02f, 6.20972626e-02f, -1.97602659e-02f, -3.14537510e-02f, 3.49547528e-03f, -1.02283157e-01f, 2.15334017e-02f, -1.57732870e-02f, 4.16890718e-03f,
  -4.28535044e-02f, -9.06732380e-02f, 2.38702409e-02f, -1.11362942e-01f, 2.65206844e-02f, -3.42514813e-02f, -2.03091204e-02f, -5.02236700e-03f, 2.45850496e-02f, 1.57674626e-02f,
  -4.85864311e-01f, 3.34492326e-01f, 9.70989186e-03f, -2.18989447e-01f, 1.41171142e-01f, -9.67367068e-02f, -1.40671954e-01f, 1.28242940e-01f, -8.46635252e-02f, 5.37495269e-03f,
  4.73504923e-02f, -1.13720939e-01f, 1.58752263e-01f, -1.86408963e-02f, -2.39233494e-01f, 1.91478312e-01f, -1.70869499e-01f, -2.23238990e-01f, 1.60671517e-01f, -1.33039325e-01f,
  -1.52847245e-01f, 5.12170158e-02f, 2.86974795e-02f, 2.46894985e-01f, -1.94951996e-01f, -9.02847275e-02f, -9.46944058e-02f, 1.54106632e-01f, -1.51663557e-01f, -3.24998377e-03f,
  -1.65644318e-01f, -2.03945056e-01f, -2.33982969e-02f, -8.16013813e-02f, -1.60571247e-01f, -1.13944218e-01f, -1.29571199e-01f, 5.31075113e-02f, -6.50230721e-02f, 1.48784202e-02f,
  -5.53109832e-02f, -2.53777225e-02f, -2.99981683e-02f, 8.90754238e-02f, 1.36831459e-02f, -3.95405814e-02f, 7.68087357e-02f, -5.34336828e-02f, 4.11336944e-02f, 6.80137798e-02f,
  4.41546664e-02f, 6.15009433e-03f, -1.00306943e-01f, -3.08776777e-02f, -4.77557145e-02f, 4.95232344e-02f, 6.97365543e-03f, -3.80465910e-02f, -5.47572412e-02f, -4.08832021e-02f,
  -6.24065427e-03f, 4.04552408e-02f, 2.39254273e-02f, 5.13367578e-02f, 2.89302636e-02f, -3.58516164e-02f, -5.73056079e-02f, 2.89943740e-02f, -5.30253910e-02f, 7.48055503e-02f,
  -3.78878489e-02f, -3.86809446e-02f, 5.48770949e-02f, 1.24360444e-02f, 1.57934371e-02f, -1.03060808e-02f, 2.83235926e-02f, -3.39023434e-02f, 5.32510516e-04f, -6.07486069e-03f,
  8.30084644e-03f, -7.03708902e-02f, -4.51993532e-02f, -1.44928787e-02f, 2.63619609e-02f, 1.94343384e-02f, 6.08706661e-03f, -3.60731175e-03f, -2.09082151e-03f, 4.33768658e-03f,
  -2.01037809e-01f, -2.61789501e-01f, 6.74340315e-03f, 8.42006318e-03f, -7.28696235e-04f, 2.97514759e-02f, 7.12172082e-03f, -5.62301502e-02f, -1.50952069e-02f, -7.40656108e-02f,
  -2.94593591e-02f, 3.31175659e-04f, -3.61200911e-03f, -4.93023582e-02f, -3.12269456e-03f, 3.72381471e-02f, -1.51343178e-02f, -6.91618919e-02f, -6.30697608e-02f, -5.60677499e-02f,
  -1.14197619e-01f, -4.41951081e-02f, -5.16748838e-02f, -2.74297632e-02f, -1.04199231e-01f, -6.17028959e-02f, -6.79683611e-02f, -5.79588749e-02f, -4.05902304e-02f, -3.55450362e-02f,
  -7.30484575e-02f, 1.18186101e-01f, 1.22564189e-01f, -1.22806482e-01f, 1.01587392e-01f, -4.55817915e-02f, 5.09786904e-02f, 7.10078925e-02f, 1.30363792e-01f, 7.06478283e-02f,
  4.35531959e-02f, 2.96976585e-02f, 6.15663454e-02f, -8.21034238e-02f, -2.85464171e-02f, -8.46060514e-02f, -6.95669279e-02f, -1.44044489e-01f, 2.89900191e-02f, 1.34271057e-02f,
  -6.83635399e-02f, 3.28094326e-02f, -7.71917254e-02f, 9.34781209e-02f, 5.95476404e-02f, -6.00021034e-02f, -1.02755323e-01f, 2.49194298e-02f, 3.67830656e-02f, -7.57817030e-02f,
  -1.00650057e-01f, 6.51195943e-02f, -6.56726630e-03f, -3.06099504e-02f, -1.22662418e-01f, 3.81979458e-02f, -7.27512985e-02f, -7.57314712e-02f, -3.57731171e-02f, 3.55920419e-02f,
  -3.43793444e-02f, -6.81428239e-02f, 8.89001042e-02f, 6.65658116e-02f, 3.32884677e-02f, 1.03938416e-01f, 1.44280884e-02f, -5.01726680e-02f, 6.94750920e-02f, 9.50852111e-02f,
  3.82472612e-02f, 9.47091728e-03f, -3.95551696e-02f, -4.73026037e-02f, -4.99676988e-02f, 4.55956198e-02f, -5.65516129e-02f, -1.04910955e-01f, -5.90510853e-02f, -4.59960476e-02f,
  -5.01984879e-02f, -2.52040643e-02f, 2.04122663e-02f, 1.22128632e-02f, 7.27174878e-02f, 7.49812052e-02f, 7.82443881e-02f, 5.40644154e-02f, -2.45918576e-02f, -6.23101480e-02f,
  2.06335299e-02f, 9.22492370e-02f, -1.05306236e-02f, -9.37830191e-03f, -8.21256712e-02f, 1.00878701e-02f, 4.03441861e-02f, -4.41553667e-02f, 1.14876218e-02f, -1.93304140e-02f,
  4.29918878e-02f, -3.16933692e-02f, 3.81004475e-02f, 2.17799731e-02f, -1.33852853e-04f, 6.39929390e-03f, 8.87141079e-02f, 4.54280525e-02f, -7.05112889e-02f, -3.50743309e-02f,
  2.16416344e-02f, -5.90996854e-02f, 1.10749276e-02f, -4.99355346e-02f, -6.77965805e-02f, -1.07975639e-01f, 7.16279298e-02f, -2.27487665e-02f, -8.36804658e-02f, 5.57192415e-02f,
  -1.32321250e-02f, 4.98891212e-02f, -3.65232565e-02f, 2.04072945e-04f, 5.72810769e-02f, -3.68216448e-02f, -2.23773215e-02f, 8.55512160e-04f, -1.02376230e-01f, -4.19088043e-02f,
  -4.10291404e-02f, -8.24195072e-02f, 8.69690627e-02f, -4.45281230e-02f, 3.02130878e-02f, 2.18544081e-02f, 5.89068644e-02f, 2.65191798e-03f, -9.05538797e-02f, -4.58031185e-02f,
  -5.16626565e-03f, -1.39886811e-01f, 1.39108390e-01f, -9.54687670e-02f, 3.92652079e-02f, 3.60354036e-02f, 3.01602036e-02f, -1.73130017e-02f, 1.46478247e-02f, -1.47724643e-01f,
  -3.86978500e-02f, 8.25356767e-02f, 1.45618886e-01f, -1.49810584e-02f, 1.22711122e-01f, 1.08699895e-01f, 5.18717654e-02f, -1.00987069e-02f, -7.33338147e-02f, -9.67094302e-02f,
  -1.05154738e-01f, -1.56861693e-01f, 8.85520354e-02f, -1.24973036e-01f, -1.94293559e-02f, -1.17582552e-01f, -1.42145818e-02f, 7.13029504e-02f, -8.51452723e-02f, 1.94168668e-02f,
  -6.10145666e-02f, -9.65004116e-02f, 5.35572879e-02f, 2.47789696e-02f, -2.35386416e-02f, 1.02981672e-01f, 1.10959068e-01f, 1.45280513e-03f, -3.06252297e-02f, -7.46579245e-02f,
  -3.57129015e-02f, 6.25216067e-02f, 6.22743042e-03f, -8.71521607e-02f, -7.32825324e-02f, -9.08550322e-02f, 2.09027752e-02f, -2.48987097e-02f, -8.71016607e-02f, 1.88333672e-02f,
  1.73508991e-02f, -5.93132451e-02f, -5.61203547e-02f, 4.61342856e-02f, 1.71597563e-02f, -6.63389564e-02f, 3.70162092e-02f, 3.93467732e-02f, -3.86828333e-02f, -1.10335127e-01f,
  7.16956258e-02f, 9.40557476e-03f, -4.35505807e-02f, 6.25690038e-04f, 1.64115187e-02f, -6.44031167e-02f, -7.55736828e-02f, 7.78155699e-02f, -4.69691269e-02f, -5.59861772e-02f,
  -8.09005722e-02f, 3.80066857e-02f, 1.03177883e-01f, -5.14711738e-02f, -7.90720433e-03f, 4.57492732e-02f, 8.46068412e-02f, -2.86418553e-02f, 1.10593168e-02f, -7.50277936e-02f,
  2.33614612e-02f, 3.32558192e-02f, 4.07603607e-02f, -3.78509536e-02f, 6.56660786e-03f, -6.56843325e-03f, 3.01371627e-02f, 8.36488232e-02f, -5.79219982e-02f, -3.58448327e-02f,
  -1.60749763e-01f, -1.20295532e-01f, 2.87292395e-02f, 5.65025993e-02f, 2.76032705e-02f, -1.19914943e-02f, -4.35747504e-02f, -2.37564556e-03f, -8.85034353e-02f, 4.11823504e-02f,
  -8.92071426e-03f, -2.39837375e-02f, -4.50965092e-02f, 7.99645185e-02f, -1.85631402e-02f, 5.46304137e-02f, 4.42472957e-02f, 2.38064192e-02f, -7.83827454e-02f, 6.53616935e-02f,
  1.97493918e-02f, -6.93361610e-02f, -4.68301848e-02f, -8.41704607e-02f, 6.76010698e-02f, -9.92242899e-03f, -4.08973284e-02f, 2.69301385e-02f, 3.13269068e-03f, -7.58384317e-02f,
  9.85056236e-02f, -6.76237568e-02f, 4.22395989e-02f, -1.29315615e-01f, 4.66399677e-02f, 6.63506463e-02f, -9.72670391e-02f, 1.92212537e-02f, -5.17766997e-02f, 7.89818019e-02f,
  8.71649757e-02f, 2.17844192e-02f, -6.76351562e-02f, -7.62773976e-02f, -1.54538766e-01f, -1.49833202e-01f, -3.85511317e-03f, 8.06084722e-02f, 1.08163059e-02f, -1.15346853e-02f,
  -8.51829275e-02f, -4.18906100e-02f, -4.39911969e-02f, 6.18031770e-02f, 9.74457487e-02f, -2.16821637e-02f, 6.22610077e-02f, 4.92248945e-02f, 8.79676938e-02f, -2.79174838e-02f,
  6.51718974e-02f, 1.18894996e-02f, -5.53849619e-03f, 3.52832265e-02f, -2.67563276e-02f, -3.38069126e-02f, 3.50662833e-03f, 4.23891805e-02f, -7.75282225e-03f, 3.79284881e-02f,
  -4.04459685e-02f, 3.53695937e-02f, -5.94656877e-02f, 1.07528204e-02f, -4.80455905e-02f, 7.08900318e-02f, 4.12879363e-02f, 2.49331212e-03f, 1.00058436e-01f, -5.40433191e-02f,
  -1.90816913e-02f, -4.20722254e-02f, -3.12780589e-02f, -8.93467218e-02f, 4.44665439e-02f, -4.12337556e-02f, -2.67001279e-02f, 2.71281116e-02f, -7.42071420e-02f, 1.37508688e-02f,
  2.04995014e-02f, -4.93680276e-02f, -8.42781588e-02f, -6.67776689e-02f, -2.23828834e-02f, 3.02035827e-02f, 3.17817740e-02f, 5.09820990e-02f, 5.37412614e-02f, -3.83178331e-03f,
  -6.91827759e-02f, 9.69368070e-02f, -8.05251002e-02f, 2.63541359e-02f, -8.08671266e-02f, -2.40295641e-02f, 6.57972693e-02f, 5.99681176e-02f, -5.60819581e-02f, 7.04622567e-02f,
  -1.29880756e-01f, -8.68410766e-02f, -7.91624654e-03f, 5.16841300e-02f, -2.70432699e-02f, 1.91105176e-02f, -5.55483885e-02f, 2.83144694e-02f, -2.00947234e-03f, 1.44669879e-02f,
  -4.91411798e-02f, -2.35178042e-02f, -5.76385371e-02f, 7.31508806e-02f, 9.10366792e-03f, -1.42937582e-02f, -7.58580640e-02f, -3.11417412e-02f, 4.66852169e-03f, 9.17710736e-03f,
  3.20417136e-02f, -7.38378465e-02f, -1.65620930e-02f, 5.07621244e-02f, 8.26641247e-02f, -1.42521836e-04f, -8.10877904e-02f, -1.07113510e-01f, -8.25774372e-02f, 2.96633765e-02f,
  -4.01966460e-02f, 6.02672584e-02f, -1.30796835e-01f, -8.55708495e-03f, -5.57664745e-02f, 3.82966436e-02f, 9.99858454e-02f, 4.10758294e-02f, -5.67895360e-02f, -7.83225447e-02f,
  2.40905568e-01f, 5.14651611e-02f, 7.72767141e-02f, 2.11231142e-01f, 3.69469710e-02f, -9.78532806e-02f, -5.84091386e-03f, -1.70044675e-02f, 1.96344897e-01f, -7.58493319e-02f,
  -2.54411474e-02f, 4.81739603e-02f, -1.82260796e-01f, -6.50302395e-02f, -1.24929570e-01f, -1.11531645e-01f, 5.00490516e-02f, 6.40771864e-03f, 7.66381621e-02f, 6.74816072e-02f,
  4.70557855e-03f, -6.28893971e-02f, -8.79861563e-02f, -1.31236166e-01f, 1.17922820e-01f, 8.32995400e-02f, 4.99085598e-02f, -7.81586170e-02f, 5.69431707e-02f, -1.78167701e-01f,
  -5.76041080e-02f, -2.97326799e-02f, 8.15012828e-02f, -4.04652469e-02f, 4.18164581e-02f, 7.51070678e-02f, -2.18208432e-02f, -3.52547430e-02f, -2.24336190e-03f, 1.75788328e-02f,
  7.02641457e-02f, -2.57096626e-02f, -1.01500116e-01f, -6.97354823e-02f, 2.40646470e-02f, 6.93420395e-02f, -4.12198305e-02f, 5.24218641e-02f, 3.77757885e-02f, 1.24246277e-01f,
  4.10201289e-02f, -5.66786863e-02f, 2.82915514e-02f, -1.00757126e-02f, 5.88316731e-02f, -5.90135865e-02f, 7.51131354e-03f, 8.19341689e-02f, 7.67461285e-02f, 2.23842263e-02f,
  -3.28680389e-02f, 1.12043610e-02f, 2.18187310e-02f, 8.16748142e-02f, -5.95065132e-02f, 2.65444703e-02f, 4.92023937e-02f, 3.23561244e-02f, -4.09890525e-02f, 7.14761913e-02f,
  7.88246393e-02f, -5.88546358e-02f, -6.31929263e-02f, -2.39071082e-02f, -4.16098870e-02f, -1.44156264e-02f, 6.49873400e-03f, -4.85187806e-02f, 3.65542620e-02f, -1.00302859e-03f,
  4.89106923e-02f, 6.93555102e-02f, -6.68153390e-02f, -1.27031496e-02f, -9.42024514e-02f, -6.78922310e-02f, 8.13242123e-02f, 6.57215714e-02f, 7.46746957e-02f, 1.76926120e-03f,
  -5.02517931e-02f, 2.83656213e-02f, -1.37078287e-02f, 2.41583772e-02f, -1.18410185e-01f, 1.01095945e-01f, -8.10308978e-02f, -2.49540899e-02f, -8.47251788e-02f, -7.27025867e-02f,
  -1.91828404e-02f, 2.95474213e-02f, -1.74547662e-03f, -1.12971256e-03f, -8.79760310e-02f, -3.62626575e-02f, 4.30897474e-02f, 3.18493806e-02f, -1.01245634e-01f, 2.31218822e-02f,
  1.22973114e-01f, -4.12143543e-02f, -5.75081930e-02f, 7.36682117e-02f, -1.52921984e-02f, -3.46581545e-03f, -2.06536036e-02f, -9.16771293e-02f, 4.63376008e-03f, -5.02424464e-02f,
  -1.00198649e-01f, -1.13550648e-01f, 6.21193126e-02f, -6.53551444e-02f, 5.94949797e-02f, 4.73327264e-02f, 6.44657761e-02f, -8.69552344e-02f, -1.90957144e-01f, -2.20774695e-01f,
  -1.16674215e-01f, -4.82371636e-02f, 5.62252626e-02f, -1.69413641e-01f, 1.58772856e-01f, 3.54812518e-02f, -2.01991379e-01f, -1.02298155e-01f, 8.30249116e-02f, -1.78308547e-01f,
  -1.85526311e-02f, -1.45188525e-01f, 1.38100222e-01f, -1.79671884e-01f, -1.19575039e-01f, -8.23718533e-02f, -3.54167297e-02f, 1.43570481e-02f, -2.01910600e-01f, 1.09726179e-03f,
  -2.36798893e-03f, 8.97261351e-02f, 9.95082315e-03f, -2.49116011e-02f, 4.49384078e-02f, -9.56340805e-02f, -4.05861065e-02f, 7.96166137e-02f, 8.24828297e-02f, 6.84681833e-02f,
  -2.57765390e-02f, -4.33261953e-02f, -9.41049829e-02f, 2.06701290e-02f, -1.04280718e-01f, -2.36530658e-02f, 4.68635559e-02f, 4.88551371e-02f, 4.95384485e-02f, 1.40934318e-01f,
  5.41090705e-02f, 4.52288333e-03f, -2.82296091e-02f, -5.78482524e-02f, -6.08007684e-02f, -2.93056164e-02f, 4.90820557e-02f, 4.95916754e-02f, -2.14542113e-02f, 4.71565016e-02f,
  -1.37501523e-01f, -8.84444788e-02f, -7.57927671e-02f, 1.02526635e-01f, -3.66502218e-02f, -9.44827683e-03f, 2.50229239e-02f, 3.30244633e-03f, -6.93343133e-02f, 1.72139946e-02f,
  6.71577007e-02f, -8.24746639e-02f, -1.76427737e-02f, 2.78830752e-02f, -6.88244700e-02f, 3.90696377e-02f, -3.84781994e-02f, -9.43225902e-03f, -5.19557633e-02f, -5.28740138e-03f,
  4.42800522e-02f, 2.28508469e-02f, -5.73117323e-02f, -3.83048248e-03f, 3.75098661e-02f, 6.97450116e-02f, -1.75134521e-02f, -9.07373205e-02f, 2.13333592e-02f, 9.55527797e-02f,
  9.66911316e-02f, -4.60265651e-02f, 1.99477803e-02f, 3.00418306e-02f, 5.12771716e-04f, 2.52288673e-02f, 5.19137420e-02f, -6.60399199e-02f, -1.23122782e-02f, 4.64755148e-02f,
  -6.83163404e-02f, -6.41416619e-03f, -4.35607322e-02f, -4.49409373e-02f, -3.41649540e-02f, 2.92362552e-02f, -8.57115239e-02f, -5.04400022e-02f, 5.33194020e-02f, -5.81477992e-02f,
  -3.46136689e-02f, 5.76871857e-02f, -5.90758249e-02f, -1.00299917e-01f, -2.35356204e-02f, 4.78214100e-02f, -8.63921829e-03f, -4.34600674e-02f, 7.69305881e-03f, -9.61036757e-02f,
  2.95708850e-02f, -3.54667187e-01f, -7.16178194e-02f, 1.03207402e-01f, 1.24638356e-01f, -4.93565667e-03f, 9.27222446e-02f, 5.21185622e-02f, 1.20297279e-02f, -1.83691308e-01f,
  3.83306220e-02f, -6.44319057e-02f, -1.83539584e-01f, -6.07377896e-03f, 1.09499782e-01f, -1.34510487e-01f, 1.22149885e-01f, 3.92111950e-03f, 8.89450535e-02f, 9.08766612e-02f,
  1.97758585e-01f, 1.54571965e-01f, 1.18285075e-01f, 6.22061640e-02f, 1.08740263e-01f, -6.93674237e-02f, -2.38915421e-02f, 1.32312011e-02f, 1.14872403e-01f, 3.57453898e-02f,
  -3.49739082e-02f, 2.22652424e-02f, 1.32445484e-01f, 1.35910707e-02f, -2.55083549e-04f, 4.94542830e-02f, 6.29314641e-03f, -3.38273309e-02f, 8.27753767e-02f, -7.93883577e-02f,
  -1.53157758e-02f, 7.53608868e-02f, 4.46618125e-02f, -6.08065166e-02f, -9.38512757e-03f, -5.91470078e-02f, -1.07149957e-02f, -6.08735904e-03f, -3.09723150e-02f, -2.72452105e-02f,
  7.47330710e-02f, -8.86417087e-03f, 6.30792603e-02f, -6.35477155e-02f, 6.37486428e-02f, 4.28706668e-02f, 2.51431670e-02f, 3.47016193e-02f, -8.83592758e-03f, -5.15889302e-02f,
  5.97992092e-02f, 7.69679621e-02f, -3.57574262e-02f, 7.56015629e-02f, -6.40416816e-02f, 3.85879055e-02f, -4.49065641e-02f, -1.10537298e-02f, 2.68552750e-02f, -9.01229605e-02f,
  3.48880067e-02f, 3.21337320e-02f, -1.29107516e-02f, 4.00062017e-02f, -5.98684512e-02f, 3.98195488e-03f, -1.70117728e-02f, -3.17937359e-02f, 4.45099063e-02f, 9.36054289e-02f,
  3.34399492e-02f, -4.31094840e-02f, 1.55765135e-02f, 3.89167517e-02f, -4.68014777e-02f, 1.38449413e-03f, -1.57652367e-02f, -9.86365154e-02f, 1.11842714e-01f, -2.87489817e-02f,
  -2.22292036e-01f, -2.74695516e-01f, -2.13822667e-02f, -7.46878833e-02f, -1.25942528e-01f, 3.32316048e-02f, -8.89080204e-03f, 5.99106364e-02f, 1.03030074e-02f, 3.63648264e-03f,
  3.66072766e-02f, -2.07537096e-02f, -6.16283482e-03f, 6.65729791e-02f, -5.22094406e-03f, -7.72033632e-02f, -3.62429060e-02f, -3.97488959e-02f, 5.72913550e-02f, 1.66034512e-02f,
  -7.01253116e-02f, -4.02218364e-02f, 7.37391189e-02f, 8.55169259e-03f, 3.35174389e-02f, -7.24892393e-02f, 3.32193412e-02f, -1.87085494e-02f, -1.09908758e-02f, -1.25609655e-02f,
  -4.22127023e-02f, 1.10124923e-01f, 4.02862988e-02f, -4.85666431e-02f, -6.89929575e-02f, -1.37042522e-01f, 2.84499135e-02f, 1.48625866e-01f, 1.61984548e-01f, 7.80802071e-02f,
  -1.04629878e-04f, -2.13090070e-02f, 2.68561561e-02f, -8.13472047e-02f, -7.44062513e-02f, 9.50953662e-02f, -1.13366798e-01f, -7.93405101e-02f, -6.52898522e-03f, -6.74205795e-02f,
  -6.88096359e-02f, 4.77118380e-02f, -2.32572015e-02f, 1.50235429e-01f, -8.51756800e-03f, -1.44793689e-02f, -2.00711749e-02f, 1.30297303e-01f, 2.76336595e-02f, 4.14454043e-02f,
  -7.75638327e-04f, 1.66328341e-01f, -1.17969345e-02f, 7.85366669e-02f, 3.97054106e-02f, -6.09382521e-04f, -4.00292724e-02f, -8.32803473e-02f, 3.83700803e-02f, 5.29603139e-02f,
  3.67426611e-02f, 5.87414876e-02f, -4.48496640e-02f, -1.24429734e-02f, 3.37765925e-02f, 3.14926822e-03f, -8.06380063e-02f, -5.28605245e-02f, -5.45625202e-02f, -3.22937481e-02f,
  5.69331087e-02f, -6.01989888e-02f, 3.70235508e-03f, 1.80383623e-02f, -1.90503672e-02f, 1.27168685e-01f, 6.95892274e-02f, 7.22439885e-02f, 7.30395988e-02f, -2.41492689e-02f,
  5.82985431e-02f, -4.53042015e-02f, 7.33712986e-02f, -5.84231429e-02f, 1.01956293e-01f, -2.90218685e-02f, 6.91537634e-02f, 6.03455082e-02f, 6.46345988e-02f, -3.89580764e-02f,
  -7.28023797e-02f, 4.86472510e-02f, -1.07028168e-02f, -4.64462563e-02f, 2.10030302e-02f, -5.92794567e-02f, 1.92198232e-02f, 1.49699543e-02f, 3.28401923e-02f, 4.55875993e-02f,
  -7.19462112e-02f, -3.12066860e-02f, 4.18848172e-02f, -5.57790436e-02f, 7.54158050e-02f, 2.79401541e-02f, -2.78750695e-02f, 8.66526812e-02f, -2.99478155e-02f, -7.51204789e-02f,
  3.50656472e-02f, 1.48218662e-01f, -4.52416837e-02f, 4.87321913e-02f, 7.87989516e-03f, -1.02415778e-01f, -8.44252408e-02f, 2.45639551e-02f, 4.62614633e-02f, 5.94253354e-02f,
  -4.10085991e-02f, 4.97689918e-02f, -7.98314065e-02f, 7.56170005e-02f, 8.46415609e-02f, -5.30510582e-02f, 3.76540124e-02f, -2.89049298e-02f, 6.00348553e-03f, 5.65108620e-02f,
  -3.74688245e-02f, -5.91010340e-02f, 3.77463672e-04f, 3.14520001e-02f, 6.91496879e-02f, -4.24185507e-02f, -3.01640499e-02f, -4.82571982e-02f, 6.99993148e-02f, -1.82520375e-02f,
  -5.77242300e-02f, -8.85575358e-03f, -4.76045012e-02f, 1.43887132e-01f, 6.76475838e-02f, -2.30368450e-02f, -3.77213247e-02f, 8.81586969e-02f, 7.41753280e-02f, 2.33990233e-03f,
  3.22541185e-02f, 6.78057224e-02f, -6.83186203e-02f, 6.68407530e-02f, -5.06929727e-03f, 1.10988049e-02f, -2.98899412e-02f, -1.08415969e-02f, -1.42770223e-02f, 6.72001094e-02f,
  -2.36816369e-02f, 4.06439230e-02f, 2.43798029e-02f, 1.27348900e-01f, 1.00098789e-01f, 9.28822383e-02f, 1.86663289e-02f, -4.82633412e-02f, 3.79818864e-02f, 7.70854279e-02f,
  -3.04424372e-02f, 3.37502547e-02f, -2.72254879e-03f, -1.86236650e-02f, 8.25268030e-02f, -2.37113107e-02f, 3.22818644e-02f, 3.58261466e-02f, -1.05903387e-01f, -1.63235571e-02f,
  -3.37733328e-02f, 4.01655473e-02f, -8.26935172e-02f, 8.23143572e-02f, -6.24655895e-02f, 9.57188383e-02f, 6.32851571e-02f, -7.82881528e-02f, 8.98820907e-03f, 8.90038069e-03f,
  -1.43469125e-02f, -7.66645595e-02f, -1.99717674e-02f, -8.10934324e-03f, 5.90370446e-02f, 1.32040447e-02f, 3.85499671e-02f, 2.07635965e-02f, 9.02108699e-02f, 4.18707319e-02f,
  2.46113632e-02f, -1.15002155e-01f, -3.62563170e-02f, -5.96950725e-02f, -4.25367728e-02f, -4.98238616e-02f, 3.28849144e-02f, -1.21509135e-02f, 4.97686341e-02f, 3.17394361e-03f,
  -8.23770463e-02f, -3.11476067e-02f, 8.89026821e-02f, -4.89831902e-02f, -2.94898753e-03f, 3.28416452e-02f, -1.01241581e-01f, 4.69119176e-02f, 1.28681157e-02f, 6.95093423e-02f,
  7.64893219e-02f, -2.88280081e-02f, -9.79285105e-04f, 2.57827751e-02f, -9.58355963e-02f, 9.32287276e-02f, 5.00229970e-02f, 3.96992154e-02f, 6.29564300e-02f, -7.25321323e-02f,
  1.09679721e-01f, 1.62790388e-01f, -7.89251104e-02f, -7.28426650e-02f, -3.76250371e-02f, 4.60659247e-03f, 6.58365041e-02f, -1.23446174e-02f, 2.78896969e-02f, -4.57166955e-02f,
  -5.19328006e-02f, -3.12219933e-02f, -6.67509362e-02f, 1.54144811e-02f, -3.09737362e-02f, 1.07902698e-01f, -3.03903613e-02f, 1.06011899e-02f, -2.18726154e-02f, 9.24054012e-02f,
  2.02731937e-02f, 3.67591195e-02f, 3.83353680e-02f, 6.43823370e-02f, -5.95238395e-02f, 4.48830500e-02f, 3.76380868e-02f, 8.13926235e-02f, 1.93318557e-02f, -9.23591480e-03f,
  -6.17752150e-02f, 8.15391466e-02f, 1.35553464e-01f, -1.49824128e-01f, 5.93269765e-02f, 8.52507055e-02f, 9.70639139e-02f, -7.10240901e-02f, -1.19091451e-01f, -1.02719009e-01f,
  -6.21426031e-02f, 1.06739022e-01f, 8.82584304e-02f, -1.69139281e-01f, 5.16000716e-03f, -1.13027552e-02f, 4.91748638e-02f, 9.29367766e-02f, 6.99876323e-02f, -1.22251082e-02f,
  2.57822983e-02f, -1.32103339e-01f, 6.16210029e-02f, -8.82969275e-02f, 2.12743580e-02f, -1.35676460e-02f, -2.02757806e-01f, 1.41766027e-01f, 5.63780963e-02f, -2.17062011e-02f,
  8.51523876e-02f, -9.25346017e-02f, -2.94043170e-03f, 5.28255068e-02f, 1.19682848e-01f, 2.99447011e-02f, -3.31775993e-02f, 3.46640907e-02f, 4.17301171e-02f, -5.00934906e-02f,
  2.83937603e-02f, -8.06287304e-03f, -7.15342239e-02f, -5.59387803e-02f, 6.61465451e-02f, 2.50829756e-02f, 1.22677036e-01f, 7.78378695e-02f, 6.39424473e-02f, 1.39243841e-01f,
  1.50859296e-01f, 1.02777541e-01f, -2.07661539e-02f, -6.68276027e-02f, 1.71800256e-02f, 3.33875865e-02f, 5.97488508e-02f, 5.15050590e-02f, -1.95890758e-02f, 7.52621219e-02f,
  -1.15202025e-01f, -4.75221779e-03f, -1.27347102e-02f, -1.61090791e-02f, -9.77230445e-03f, 6.33584037e-02f, 6.45344332e-02f, -3.17689963e-02f, 2.57252343e-02f, -5.25691658e-02f,
  -5.80879301e-02f, 4.27267030e-02f, 4.66036648e-02f, -2.29485868e-03f, -5.51314279e-02f, -1.76114421e-02f, 5.00541516e-02f, -3.80461626e-02f, 8.84344205e-02f, 3.45665701e-02f,
  -2.13596411e-02f, 1.73932221e-02f, -7.83637315e-02f, 1.01752840e-01f, -7.86567330e-02f, -7.62433782e-02f, 4.26111370e-02f, -1.13699434e-03f, -5.33227809e-02f, 2.09576134e-02f,
  -2.32390016e-02f, -4.09956351e-02f, 6.87285066e-02f, 8.20622668e-02f, 9.15555134e-02f, 5.25940135e-02f, -2.03793030e-02f, 7.55066276e-02f, -3.46121229e-02f, -6.68908730e-02f,
  7.25050867e-02f, 7.78883416e-03f, -7.47206295e-03f, 1.56446151e-03f, -8.48864168e-02f, -9.27657634e-03f, -2.72381660e-02f, -7.06740245e-02f, -5.14318533e-02f, -3.30633996e-03f,
  1.04164638e-01f, 6.04726151e-02f, 1.16176028e-02f, -9.93074775e-02f, 3.88713367e-03f, -6.00877777e-02f, -3.37614715e-02f, 1.01491034e-01f, 7.06163794e-02f, 5.50163463e-02f,
  1.32533610e-01f, -4.32516634e-01f, -1.09956026e-01f, 3.41048300e-01f, 1.92011908e-01f, -4.92600910e-02f, -2.23575145e-01f, 3.52530070e-02f, 6.54348508e-02f, -2.57325858e-01f,
  8.73177778e-03f, 1.16006227e-03f, -4.31104392e-01f, 2.29980364e-01f, 2.86168009e-01f, -2.22493991e-01f, 7.15090111e-02f, 2.45169587e-02f, 4.77991253e-02f, -1.98595058e-02f,
  2.29179725e-01f, 2.30960473e-01f, 6.73890561e-02f, 1.40375227e-01f, 2.39413306e-01f, 9.81412008e-02f, 1.65111899e-01f, -1.50142431e-01f, 9.93948206e-02f, 6.47327602e-02f,
  -4.29115146e-02f, 2.39141826e-02f, 9.77949612e-03f, -4.09215651e-02f, -6.87419847e-02f, -6.28053918e-02f, -2.08123047e-02f, 3.20895873e-02f, 9.00978446e-02f, -1.17773060e-02f,
  -4.99661174e-03f, 8.09603091e-03f, -1.62742287e-02f, 7.79024288e-02f, 7.31801018e-02f, 9.48019400e-02f, 5.44134676e-02f, -3.47260423e-02f, 3.26547213e-02f, -5.92682213e-02f,
  -1.39082484e-02f, -2.38894299e-02f, -2.88819429e-02f, -6.28864616e-02f, 1.56430844e-02f, -6.40560116e-04f, -5.49677424e-02f, -6.48932680e-02f, -6.51473552e-02f, 8.26850832e-02f,
  -1.28933147e-01f, -1.06015511e-01f, -5.08174039e-02f, -1.36029720e-02f, 6.74823150e-02f, 4.47288752e-02f, -1.67589467e-02f, 2.57965121e-02f, -3.12512815e-02f, 3.13884914e-02f,
  7.95848444e-02f, 1.61555409e-02f, -4.59145335e-03f, 2.37353984e-02f, 1.81844626e-02f, 3.57665047e-02f, 4.36234549e-02f, 4.66759652e-02f, -3.84235382e-03f, 4.05583605e-02f,
  -9.34946388e-02f, 2.20927391e-02f, -6.76744953e-02f, 4.82747108e-02f, -3.53751332e-02f, -5.02130724e-02f, 1.00009896e-01f, -1.99488178e-02f, -6.09862991e-02f, 3.44551764e-02f,
  -6.92017376e-02f, -1.07794084e-01f, -5.49841747e-02f, 7.82479644e-02f, -7.27496808e-03f, 4.44929935e-02f, -5.78218661e-02f, 7.56403357e-02f, -4.47369441e-02f, -3.52926031e-02f,
  -2.55067330e-02f, 7.15413317e-02f, -3.48694846e-02f, -3.15994546e-02f, -6.01380169e-02f, -4.45359107e-03f, 2.63186134e-02f, 3.58975381e-02f, 1.29593313e-02f, 1.27928974e-02f,
  -6.61504120e-02f, -1.06414557e-01f, -1.51781151e-02f, 4.65586111e-02f, 3.18096913e-02f, -3.09481416e-02f, -9.14510190e-02f, -1.58197004e-02f, -1.67591255e-02f, -5.06612137e-02f,
  1.37133136e-01f, 1.82457324e-02f, 7.68184364e-02f, 4.91330549e-02f, 1.28704980e-02f, -7.19539002e-02f, -5.64206950e-02f, -1.25325233e-01f, 2.06114322e-01f, -6.86996728e-02f,
  -5.10644764e-02f, 2.10224092e-01f, -1.90101355e-01f, -6.17886987e-03f, -6.56729862e-02f, -1.54756337e-01f, 8.06559063e-03f, 1.17868604e-02f, 6.59852624e-02f, -5.11817783e-02f,
  3.13631557e-02f, -7.56783113e-02f, -1.29734538e-03f, -1.58599272e-01f, 5.31706959e-04f, -6.32837266e-02f, -1.09380737e-01f, -8.78395289e-02f, -1.93939246e-02f, -1.30345032e-01f,
  3.11382785e-02f, 8.12929273e-02f, 3.30533739e-03f, 1.28101213e-02f, 2.85217054e-02f, 7.36311302e-02f, -6.20458722e-02f, 2.96730688e-03f, 7.04867169e-02f, 4.01995815e-02f,
  7.46118501e-02f, 3.65965664e-02f, -1.20860944e-02f, -5.22969700e-02f, -5.61356544e-02f, 6.62233122e-03f, 9.73656476e-02f, -3.70870866e-02f, 8.37648213e-02f, 8.56880024e-02f,
  1.39606550e-01f, 5.75374067e-02f, -3.47358896e-03f, 3.50872688e-02f, 1.80325564e-02f, 3.38176712e-02f, 4.14520800e-02f, 1.14607885e-02f, -2.20016539e-02f, -3.66974287e-02f,
  6.63878173e-02f, 6.83362409e-02f, -7.22993091e-02f, 3.65413539e-02f, 2.53522322e-02f, 6.26821071e-02f, -1.93283185e-02f, 2.02945918e-02f, -4.37846268e-03f, 4.92357649e-02f,
  -7.82148913e-02f, 4.14815880e-02f, -2.99714785e-03f, 2.79832631e-03f, -3.86028849e-02f, -5.01564424e-03f, 5.51493354e-02f, -1.40613914e-01f, 2.32837126e-02f, 4.48137429e-03f,
  6.03071302e-02f, 4.52357158e-02f, -8.59173667e-03f, 1.25496229e-02f, 4.05732635e-03f, 7.25397691e-02f, 1.22184018e-02f, -6.80652484e-02f, -1.47966575e-03f, 4.58782241e-02f,
  -2.48675756e-02f, -2.13598292e-02f, 3.90432924e-02f, 6.04047719e-03f, 3.29197347e-02f, 4.54900078e-02f, -4.27519754e-02f, 6.86850548e-02f, -7.04497769e-02f, 2.75467872e-03f,
  -1.49764204e-02f, -2.19331682e-02f, -5.29798381e-02f, -7.11496100e-02f, 6.42092824e-02f, 3.54197808e-02f, -2.61525949e-03f, -4.83265407e-02f, 8.08315650e-02f, -1.01896999e-02f,
  1.96089055e-02f, -1.02593778e-02f, 5.26640844e-03f, 1.06074125e-01f, -5.52457459e-02f, -3.03452276e-02f, -2.92501617e-02f, -9.22055356e-03f, -4.73236516e-02f, -1.93594175e-03f,
  -8.31413940e-02f, 6.16930649e-02f, -1.41519353e-01f, -7.47370198e-02f, -1.91488173e-02f, -9.07690004e-02f, 3.03149950e-02f, 4.98767644e-02f, -3.88743989e-02f, 1.67828515e-01f,
  5.86537234e-02f, 1.89676136e-02f, 2.91567259e-02f, -1.53285906e-01f, -2.52666354e-01f, -1.21387258e-01f, -1.06790408e-01f, 5.77833578e-02f, 1.44510558e-02f, 3.52526009e-02f,
  -1.30149692e-01f, -2.89707631e-02f, -1.40157610e-01f, -3.98200341e-02f, 3.62829529e-02f, 1.97498165e-02f, 9.94265825e-02f, 5.25907129e-02f, 5.85183222e-03f, 2.43577734e-02f,
  -6.33968785e-02f, -1.81482863e-02f, 8.35270882e-02f, 4.98629138e-02f, -4.25156765e-02f, 4.05700840e-02f, -5.41454516e-02f, 1.95548106e-02f, -3.22250873e-02f, -3.11362147e-02f,
  4.86830138e-02f, 4.40329127e-02f, -2.49651168e-02f, 2.74272561e-02f, -3.47814411e-02f, 2.41226610e-02f, 1.33051462e-02f, -2.25220597e-03f, -1.36370212e-02f, 4.22719568e-02f,
  -8.14089552e-02f, -3.21346819e-02f, -2.66386699e-02f, -5.57174124e-02f, -1.03598041e-02f, -7.40530267e-02f, -1.05723456e-01f, 4.85313646e-02f, 4.93467376e-02f, -1.20112516e-01f,
  7.37821907e-02f, 2.96499878e-02f, -5.98091297e-02f, -1.63530316e-02f, 1.63263585e-02f, 1.93827376e-02f, 4.73632403e-02f, -5.23410738e-02f, -5.43868393e-02f, 7.10821897e-02f,
  2.99633052e-02f, -8.87826979e-02f, 4.22858857e-02f, 1.95953511e-02f, 5.96142840e-03f, 1.01413332e-01f, -4.55314852e-02f, -1.35105047e-02f, -8.01656097e-02f, 2.08630059e-02f,
  1.63587462e-02f, -3.93861271e-02f, -3.56169604e-03f, 2.35223807e-02f, -3.74888591e-02f, -5.57246991e-02f, -9.35798660e-02f, -3.55820060e-02f, -3.19074541e-02f, -1.11711733e-02f,
  -5.97497113e-02f, 4.37433049e-02f, 6.98052198e-02f, -4.71338583e-03f, 4.37494628e-02f, 2.97950916e-02f, -5.60606681e-02f, -2.56571546e-02f, -3.40892933e-02f, -8.96840170e-02f,
  -5.60802817e-02f, 4.16665599e-02f, 5.00559062e-02f, -6.25096858e-02f, -5.20432889e-02f, -1.90278180e-02f, 4.63813469e-02f, -7.39588216e-02f, 3.89245749e-02f, -6.88062459e-02f,
  -3.50082405e-02f, 3.78400646e-02f, 2.36564577e-02f, -2.74184588e-02f, 6.71360493e-02f, -1.78452879e-02f, -8.31330270e-02f, 3.33505906e-02f, -1.93149075e-02f, -4.21953686e-02f,
  -2.43691102e-01f, 7.82228261e-03f, -3.35239843e-02f, -1.78697526e-01f, -1.45639151e-01f, -1.10140510e-01f, 8.74048248e-02f, -7.52786696e-02f, -5.04250266e-02f, 2.02955693e-01f,
  1.50303438e-01f, -2.84003429e-02f, 2.59007931e-01f, 3.27405594e-02f, 8.72132927e-02f, 2.48989090e-01f, -7.99337476e-02f, 7.41635635e-02f, -1.26237676e-01f, -9.45172608e-02f,
  -1.43958330e-01f, -3.97319719e-02f, 1.80788457e-01f, -1.58731937e-01f, -1.06501557e-01f, -1.28729254e-01f, -5.91936521e-02f, 5.61048836e-03f, -1.74707472e-01f, -3.68828699e-02f,
  -1.24697506e-01f, -1.38718918e-01f, -8.42207763e-03f, 3.88892516e-02f, -6.73705116e-02f, -3.84609401e-02f, -4.53729443e-02f, -3.21514159e-02f, 1.08249215e-02f, -7.69723877e-02f,
  -6.07671440e-02f, -1.52328303e-02f, -8.40913802e-02f, 9.17345956e-02f, -8.66184458e-02f, -8.84234011e-02f, 1.91096682e-02f, 3.34801860e-02f, -8.14464912e-02f, -3.20906006e-02f,
  5.80594949e-02f, 6.04604557e-03f, 7.50740618e-02f, -2.68235262e-02f, 1.40934167e-02f, -4.48577702e-02f, 1.43383760e-02f, 8.14396515e-02f, -3.03500928e-02f, -1.07604504e-01f,
  3.23669761e-02f, -7.54359737e-02f, 7.62623101e-02f, 5.37648313e-02f, -7.46410787e-02f, 1.12021632e-01f, -1.12076914e-02f, 9.28420480e-03f, 5.12629375e-02f, 1.78819057e-02f,
  7.75942281e-02f, 6.75776005e-02f, 5.56124263e-02f, -4.81100287e-03f, -7.31896907e-02f, 6.50860295e-02f, -9.59234487e-04f, 8.70791089e-04f, 5.87027483e-02f, 3.09012774e-02f,
  8.34954157e-02f, 4.25524600e-02f, -4.33970354e-02f, 7.42831603e-02f, 3.07661835e-02f, -5.17422818e-02f, -4.45881039e-02f, 7.41758421e-02f, 7.09605739e-02f, 1.50956241e-02f,
  -6.67946264e-02f, -1.49223447e-01f, 4.35422696e-02f, 1.07684799e-01f, -3.19008119e-02f, -6.34862259e-02f, -2.24503577e-02f, -7.28585273e-02f, -1.12957247e-01f, 4.78777364e-02f,
  -5.14320806e-02f, 4.67934795e-02f, 1.21115912e-02f, -8.75715613e-02f, -1.38602043e-02f, 6.78418763e-03f, -6.92444295e-02f, -8.62915441e-02f, 3.36663350e-02f, -3.95325534e-02f,
  7.65510201e-02f, -5.60326055e-02f, 8.78828764e-02f, -2.00521350e-02f, -4.95588072e-02f, 2.43387036e-02f, -4.84611057e-02f, -8.12062919e-02f, -4.83197942e-02f, 5.88208772e-02f,
  -2.27747098e-01f, -1.42009733e-02f, -1.83415134e-02f, -1.00293785e-01f, -9.28746313e-02f, 1.87863678e-01f, 2.57375807e-01f, -1.82466522e-01f, -1.85782343e-01f, 1.54791698e-01f,
  8.74274448e-02f, -1.35620564e-01f, 1.98226571e-01f, 8.84764045e-02f, 1.41539931e-01f, 2.65385807e-01f, 1.64904803e-01f, 1.90303460e-01f, -9.05037820e-02f, -1.17360741e-01f,
  7.22191259e-02f, 7.27289543e-02f, 2.16238797e-01f, -1.72497537e-02f, -2.28737518e-02f, -1.35069028e-01f, -2.79364120e-02f, 3.19528058e-02f, 6.59438819e-02f, -3.65780629e-02f,
  -5.16814962e-02f, -2.03296274e-01f, -6.27204962e-03f, -1.21235900e-01f, 7.98090175e-03f, -3.47681493e-02f, -5.20048430e-03f, 8.19140375e-02f, -9.46029648e-02f, 1.02893682e-02f,
  5.06699197e-02f, -8.29330087e-02f, 2.18770411e-02f, -4.89245402e-03f, -2.67535057e-02f, -1.44227482e-02f, 5.32130487e-02f, 4.43588868e-02f, 3.82128581e-02f, -1.93864480e-03f,
  1.05673961e-01f, -6.52308092e-02f, -6.06811792e-02f, 8.86596441e-02f, 2.35458966e-02f, 5.06399125e-02f, -5.86536853e-03f, 3.11416686e-02f, -1.85433012e-02f, 4.86602820e-02f,
  6.60328269e-02f, 3.80023085e-02f, 3.46822478e-02f, -5.95728075e-03f, 4.71634045e-03f, 2.04649959e-02f, 1.95667055e-02f, 1.30895078e-02f, -7.53206611e-02f, 3.55760753e-02f,
  2.73474213e-02f, -4.83839326e-02f, -7.36698657e-02f, 2.75188796e-02f, 3.26589425e-03f, -1.20147076e-02f, -3.31730023e-02f, -1.52170323e-02f, 1.29220281e-02f, -5.47965914e-02f,
  -4.18182909e-02f, -2.60528866e-02f, 5.94253764e-02f, -6.61420263e-03f, -4.61771823e-02f, 6.64472729e-02f, 3.94828245e-02f, 1.63802076e-02f, -3.54554430e-02f, -4.75637941e-03f,
  -2.03133702e-01f, -1.95716456e-01f, -1.11027867e-01f, -9.14693251e-02f, -2.00193673e-02f, 6.03535352e-03f, -1.58304498e-02f, -3.82333733e-02f, 2.95490138e-02f, -6.54772446e-02f,
  3.58943418e-02f, -3.48899737e-02f, -9.36225876e-02f, -5.63310236e-02f, 5.97625449e-02f, 4.59578447e-02f, -8.07251260e-02f, -1.38871009e-02f, 2.68880017e-02f, -8.40822514e-03f,
  -2.71017905e-02f, -1.01946078e-01f, 5.03055826e-02f, 7.63212740e-02f, -5.09715229e-02f, -4.33242656e-02f, -1.08815067e-01f, 4.54363152e-02f, 5.01781069e-02f, -3.44490930e-02f,
  3.09839100e-01f, -2.25115404e-01f, -1.01329796e-01f, -6.94574639e-02f, 2.73330882e-02f, 1.95231766e-01f, 5.91769330e-02f, -7.56971464e-02f, -2.33004749e-01f, -5.63019253e-02f,
  -5.67585565e-02f, -6.77058771e-02f, -7.15848282e-02f, 2.70282966e-03f, 4.12775911e-02f, -3.28450426e-02f, -9.60800424e-03f, 3.60321021e-03f, -8.21748748e-03f, -6.20220453e-02f,
  -8.64694302e-04f, 1.80982828e-01f, -3.52682061e-02f, 1.00643635e-01f, 1.35411754e-01f, 2.97337268e-02f, -2.55324878e-03f, -4.32022698e-02f, 1.42632812e-01f, 1.51392519e-01f,
  -1.76695809e-02f, -9.31770131e-02f, -4.05725129e-02f, -8.45471397e-02f, 6.13574199e-02f, 9.50669050e-02f, -3.92684303e-02f, 1.04491107e-01f, -9.18611512e-02f, 4.38185409e-02f,
  4.72444892e-02f, 1.93647910e-02f, -7.79888853e-02f, 5.32371737e-02f, -5.36571182e-02f, 2.58675925e-02f, -1.79529283e-02f, -2.82850899e-02f, -3.15488242e-02f, -5.93970045e-02f,
  -5.01899756e-02f, -1.01497628e-01f, 8.37880522e-02f, -8.91644284e-02f, -1.45591795e-01f, 3.82955708e-02f, 8.63998085e-02f, -9.33174193e-02f, 9.67099890e-02f, 8.08989182e-02f,
  5.63287474e-02f, 5.94418570e-02f, -5.24553917e-02f, -4.20021005e-02f, -6.76176399e-02f, -2.50711422e-02f, 5.02326451e-02f, -1.06216427e-02f, -9.20063928e-02f, 5.03372736e-02f,
  3.01020406e-02f, 1.84286460e-02f, -6.01047724e-02f, 9.02501270e-02f, -2.09078602e-02f, 6.44064322e-02f, -4.40357579e-03f, 3.06007508e-02f, -2.80518178e-02f, -2.66640577e-02f,
  2.38903761e-02f, -1.16916455e-03f, 1.96327697e-02f, -5.10287732e-02f, 1.83192845e-02f, -8.05458575e-02f, 7.83594847e-02f, -8.77358858e-03f, -4.45951074e-02f, -4.23364639e-02f,
  -7.76949711e-03f, -6.94222152e-02f, 1.76413637e-02f, 5.56430742e-02f, -9.02331434e-03f, 7.78060332e-02f, 7.38317221e-02f, -4.50966619e-02f, -3.38620972e-03f, 4.07119282e-02f,
  2.82790810e-02f, 2.13746838e-02f, -4.73774187e-02f, -8.10060203e-02f, 7.72805512e-02f, -8.53227973e-02f, 8.09513703e-02f, -2.76409276e-02f, -4.06623296e-02f, -2.77021751e-02f,
  1.38020944e-02f, 5.87719493e-02f, 6.90997839e-02f, 7.20516294e-02f, -5.18313386e-02f, 2.96843355e-04f, 8.36584195e-02f, -5.29854968e-02f, 6.26859143e-02f, 3.86347026e-02f,
  1.89354405e-01f, -2.88788527e-01f, 9.38842222e-02f, 1.28471836e-01f, 5.45822941e-02f, 7.11954534e-02f, 2.52103865e-01f, -1.06624663e-01f, 2.14702293e-01f, -2.50434011e-01f,
  1.16872694e-02f, 2.72630155e-02f, 7.06626773e-02f, -9.03336108e-02f, 2.05273181e-01f, 8.04351922e-03f, -5.29318266e-02f, 2.80790627e-02f, 1.50141016e-01f, -6.34352025e-03f,
  3.18793356e-02f, -3.00089214e-02f, -9.57803205e-02f, -2.22880378e-01f, -1.03042439e-01f, -8.28840882e-02f, -2.84701604e-02f, 3.24956067e-02f, -1.69156790e-01f, 2.42112130e-02f,
  1.79083366e-02f, -3.10993716e-02f, 7.70330131e-02f, -3.17983143e-02f, -5.18742092e-02f, -7.19522014e-02f, 1.12589262e-03f, 5.15179336e-02f, -1.28455432e-02f, -1.41319437e-02f,
  3.54525186e-02f, -7.75443763e-02f, -8.84290412e-02f, 3.44049446e-02f, 8.33532661e-02f, -5.50889224e-03f, -3.92360203e-02f, -1.37435808e-03f, -6.77891970e-02f, -2.76010167e-02f,
  3.48426471e-03f, -5.86076379e-02f, -3.97569798e-02f, -5.67277707e-02f, -6.98408261e-02f, 3.30649875e-02f, -4.74550128e-02f, -8.77074024e-04f, -5.66926822e-02f, 4.22653966e-02f,
  -3.56341973e-02f, 6.13398775e-02f, -6.55115163e-03f, -2.35647312e-03f, 2.70291269e-02f, -6.49719089e-02f, 2.97842622e-02f, -4.37457971e-02f, -1.09603023e-02f, 2.48589031e-02f,
  2.27235388e-02f, -3.68021205e-02f, 8.97591859e-02f, 6.69081360e-02f, -1.84219256e-02f, 5.23531735e-02f, -7.39174802e-03f, 3.43001112e-02f, 7.31866360e-02f, -1.83315238e-03f,
  -1.54471491e-02f, -1.83322541e-02f, -3.77797447e-02f, -8.59290734e-02f, 2.20210059e-03f, 2.39133183e-02f, -2.31633913e-02f, -7.30126798e-02f, 3.89200933e-02f, 1.18005825e-02f,
  -5.15034162e-02f, -1.47379398e-01f, -5.53000197e-02f, -6.59198612e-02f, -1.11835068e-02f, -7.09183142e-02f, -2.84416936e-02f, -5.20944223e-02f, -5.62937148e-02f, 4.07440923e-02f,
  3.01584750e-02f, -6.42735064e-02f, 7.04607889e-02f, 7.44615644e-02f, -1.41446842e-02f, 6.55541662e-04f, 7.26129189e-02f, -6.02607429e-02f, 2.05501728e-03f, 3.91186541e-03f,
  -1.54142790e-02f, 3.24155390e-02f, 5.09860590e-02f, -1.81837976e-02f, -4.09745127e-02f, -4.77187447e-02f, 6.87668696e-02f, 2.04608217e-02f, -4.33456190e-02f, -5.35625871e-03f,
  -1.88370332e-01f, 1.91802815e-01f, -1.34911641e-01f, -2.81571820e-02f, -5.06894663e-02f, -6.65203035e-02f, 1.27168983e-01f, 1.33874686e-02f, 1.61962658e-02f, 1.78372532e-01f,
  1.28320962e-01f, -9.29433107e-02f, 4.11999337e-02f, 1.51007280e-01f, 7.96882063e-02f, 8.15244485e-03f, 1.09465130e-01f, 1.41179889e-01f, -2.08002552e-02f, 5.12659810e-02f,
  -6.18565716e-02f, 1.64655238e-01f, -5.21636531e-02f, -2.60397550e-02f, 1.30476020e-02f, -1.02959538e-03f, 6.53004795e-02f, -1.86763391e-01f, 9.11163166e-03f, -9.12498508e-04f,
  7.01776147e-02f, -1.02066146e-02f, -1.14429975e-02f, -1.00018457e-01f, 2.28307378e-02f, -2.97954138e-02f, -3.99710648e-02f, -7.04034120e-02f, -1.00788653e-01f, 1.24822836e-02f,
  -7.92782605e-02f, -6.42886199e-03f, -6.63399100e-02f, 4.47881743e-02f, -4.76789959e-02f, -8.90475512e-02f, -6.47726236e-03f, -7.78335240e-03f, -5.42952418e-02f, 6.37612678e-03f,
  -6.45544752e-02f, -5.58857284e-02f, 2.76651159e-02f, -6.22232771e-03f, 5.02130762e-02f, 3.32385749e-02f, 7.19527528e-02f, -2.02808250e-03f, 4.50242758e-02f, 3.36298868e-02f,
  -5.67257553e-02f, -3.06551997e-02f, 2.54041664e-02f, 8.42730626e-02f, -1.28062800e-01f, 3.60254385e-02f, -2.03199666e-02f, -3.45504060e-02f, -1.08047523e-01f, 7.32579604e-02f,
  -7.65763363e-03f, 4.16549668e-02f, 6.86311945e-02f, 5.14713190e-02f, 5.25615625e-02f, 9.20473784e-02f, 7.04079447e-03f, 5.13995700e-02f, -6.01809993e-02f, 2.59424876e-02f,
  8.88457755e-04f, -5.67677766e-02f, -2.81719607e-03f, 2.46979389e-02f, -2.46069860e-02f, -4.82402928e-02f, -3.80771011e-02f, -9.28303003e-02f, 3.59078161e-02f, -3.15480935e-03f,
  1.36259526e-01f, 1.74302146e-01f, 7.75902625e-03f, 4.49288301e-02f, -8.30103382e-02f, 5.98198595e-03f, 5.00436276e-02f, -1.87056866e-02f, 3.26702483e-02f, 1.42379515e-02f,
  -9.47875064e-03f, 8.09046626e-02f, 1.07013702e-01f, -2.25838069e-02f, -9.05360952e-02f, 6.90324306e-02f, 1.35988712e-01f, -6.46152049e-02f, -3.67153287e-02f, 4.61704470e-02f,
  -2.04413403e-02f, 5.43385744e-02f, -3.94760147e-02f, -5.14430925e-03f, 2.67571770e-02f, -1.82224978e-02f, -4.13436964e-02f, -6.16747141e-02f, -9.92529243e-02f, 1.25707332e-02f,
  -3.03804994e-01f, -1.16730832e-01f, -1.21515192e-01f, 5.55893704e-02f, -6.12242147e-02f, 8.67110416e-02f, 1.60853609e-01f, -9.99001861e-02f, -1.29870176e-01f, 2.06011489e-01f,
  1.47479206e-01f, -3.69118117e-02f, 3.52085195e-02f, 2.86758155e-01f, 7.30072185e-02f, 1.74692705e-01f, 1.09592304e-01f, 1.16488606e-01f, -3.52676585e-02f, -1.54492348e-01f,
  -5.87502159e-02f, 1.78661287e-01f, 8.57012197e-02f, 5.23059182e-02f, 5.35034835e-02f, 6.25526160e-03f, 3.01236734e-02f, -1.30133197e-01f, 1.88431591e-01f, 1.20179050e-01f,
  -7.62789771e-02f, -5.78552373e-02f, -3.25669795e-02f, -1.32676408e-01f, -1.61915161e-02f, -7.31755188e-03f, -3.54772038e-03f, 2.88296305e-02f, -5.73093444e-02f, 2.75754370e-02f,
  -8.44136328e-02f, -1.65865533e-02f, 6.45184293e-02f, -9.19627920e-02f, -8.61275345e-02f, 5.15428074e-02f, -5.30350432e-02f, 3.02897710e-02f, -7.19198585e-02f, -7.16022253e-02f,
  4.54051624e-04f, -4.04419377e-03f, 3.18411738e-02f, 6.98829964e-02f, -4.55412827e-02f, 2.74092890e-02f, 6.94585815e-02f, -3.09457090e-02f, -4.54302505e-02f, -5.17198294e-02f,
  -4.13184473e-03f, 3.90961394e-02f, -5.34637570e-02f, -9.02355835e-03f, 2.66671367e-02f, 2.73258705e-02f, -1.40012614e-02f, 6.14936724e-02f, 1.57840550e-02f, 3.19257341e-02f,
  2.05927882e-02f, -2.66608000e-02f, 4.49186824e-02f, 2.03984864e-02f, 2.38035172e-02f, 1.53426584e-02f, 5.32404371e-02f, -6.10143170e-02f, -3.07336859e-02f, 4.98896465e-02f,
  3.12047936e-02f, -4.87129912e-02f, 4.32566181e-02f, 4.10921685e-02f, -4.29264456e-02f, -2.80377618e-03f, -1.34813236e-02f, -1.65266637e-02f, 1.14827164e-01f, 5.24568073e-02f,
  -1.85341433e-01f, -2.09495515e-01f, 2.59590931e-02f, 8.81037489e-03f, 4.11135517e-02f, -1.49559099e-02f, 3.16887051e-02f, 1.23153697e-03f, -3.51280044e-03f, -4.76455316e-02f,
  -1.49747068e-02f, 2.05341005e-03f, -8.37646350e-02f, 3.74316797e-02f, 1.44787049e-02f, 1.32747451e-02f, -4.18121926e-02f, 1.65290926e-02f, 1.68622117e-02f, -5.70411608e-02f,
  3.82039044e-03f, 5.69688566e-02f, 3.77948880e-02f, -3.07222605e-02f, 8.08944274e-03f, -1.34081282e-02f, -1.26187608e-01f, -3.68618406e-02f, 3.34784351e-02f, 7.36498684e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  1.19928554e-01f, 2.32967827e-02f, 6.72009662e-02f, 2.42179826e-01f, 1.98520869e-01f, 1.20127641e-01f, 1.71913445e-01f, -2.70518959e-02f, 6.77817836e-02f, 6.30410165e-02f,
  7.96077494e-03f, 9.88621637e-02f, 1.16128348e-01f, 1.07262298e-01f, 1.82435811e-01f, -2.25219261e-02f, 5.02878167e-02f, 9.63787436e-02f, -9.43532139e-02f, -4.04151268e-02f,
  5.92049286e-02f, 3.48175205e-02f, 3.14443484e-02f, 2.71083653e-01f, 1.59018800e-01f, 3.08948338e-01f, 5.25412299e-02f, 4.08664495e-02f, 1.49147376e-01f, 2.27786019e-01f,
  2.10102111e-01f, 9.77209657e-02f, 2.78641999e-01f, 1.69137299e-01f, -3.74047048e-02f, 4.19924594e-02f, 1.35142654e-01f, 1.89715296e-01f, 1.74137712e-01f, 1.53563827e-01f,
  1.40736192e-01f, -1.46622881e-02f, 1.29887983e-01f, 2.86928773e-01f, 5.57075180e-02f, 2.76451651e-02f, 1.78408712e-01f, 2.22718298e-01f, 1.98393822e-01f, 1.94101170e-01f,
  1.07690364e-01f, 9.83141214e-02f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -3.04915402e-02f, -1.22052953e-01f, 1.62762314e-01f, 1.30551279e-01f, 1.46375149e-01f, -4.30427939e-02f, -1.60047457e-01f, 1.74848866e-02f, -1.77975446e-01f, -4.09836560e-01f,
  -2.34990492e-01f, -7.62757435e-02f, -3.68683413e-02f, -5.98143004e-02f, 5.33233397e-02f, -2.01291040e-01f, 7.13418275e-02f, -1.78228170e-01f, 1.22225046e-01f, -8.59655514e-02f,
  -3.31373513e-02f, -9.69025195e-02f, -1.03401966e-01f, 1.19032627e-02f, -2.18046233e-02f, 1.54017359e-01f, 2.03495234e-01f, 9.21344087e-02f, 8.83336216e-02f, 6.87492117e-02f,
  -3.96804996e-02f, 7.75391087e-02f, 1.51105210e-01f, 1.69882447e-01f, -1.07999437e-01f, -1.09282337e-01f, -2.90305410e-02f, -1.71875432e-01f, -8.45734701e-02f, 4.68443930e-02f,
  2.59505250e-02f, 1.74774468e-01f, 1.04167923e-01f, 4.12535900e-03f, 1.75106570e-01f, 2.17903212e-01f, 4.93651405e-02f, -6.25159368e-02f, -1.44167453e-01f, -1.96974288e-04f,
  3.00332997e-02f, -1.14026712e-02f, 1.40725866e-01f, 1.26467869e-01f, -1.78183860e-03f, -1.12160690e-01f, 6.04704879e-02f, -4.64452729e-02f, 1.52730271e-01f, -7.75368139e-02f,
  -1.98050037e-01f, -1.34024054e-01f, 7.03714713e-02f, -5.77994138e-02f, -4.87444438e-02f, 4.52491865e-02f, -1.98480174e-01f, -2.20649131e-02f, -3.77213173e-02f, 1.60234734e-01f,
  1.31479716e-02f, 6.67299032e-02f, -3.52414697e-01f, -3.81167054e-01f, 2.31198624e-01f, -2.57173061e-01f, -1.78667590e-01f, -7.24355727e-02f, 8.99997950e-02f, -2.33339876e-01f,
  -6.45236149e-02f, -1.24575660e-01f, -7.09765498e-03f, 2.81545538e-02f, 9.40445289e-02f, 7.75150284e-02f, -7.25616738e-02f, 8.29284489e-02f, -1.24805398e-01f, 1.23184219e-01f,
  -1.06588483e-01f, -4.10557725e-02f, -9.88450348e-02f, 9.48574990e-02f, 2.27866266e-02f, 8.74412134e-02f, -2.60045100e-03f, 5.48560284e-02f, 1.19253896e-01f, 2.74300009e-01f,
  -1.94811281e-02f, -1.27732754e-01f, 1.80861503e-01f, 5.41879758e-02f, 1.76116541e-01f, -8.90883133e-02f, 1.14242854e-02f, -4.14885208e-02f, -3.21980298e-01f, 2.53144830e-01f,
  2.82670017e-02f, 1.69007212e-01f, 2.09072679e-02f, -1.01976365e-01f, 2.12910086e-01f, 8.49490687e-02f, -7.57145658e-02f, -9.52303931e-02f, -2.12891586e-02f, -6.71843365e-02f,
  -1.49305254e-01f, -8.43880326e-02f, 1.66219592e-01f, 1.74667999e-01f, -6.65576681e-02f, -1.23212906e-02f, 5.22703119e-02f, 1.65386155e-01f, -1.14357166e-01f, 1.28188625e-01f,
  -1.81898654e-01f, -1.40922651e-01f, -5.23126610e-02f, -1.93343721e-02f, 3.52920480e-02f, -1.17944330e-01f, 1.31408975e-01f, -9.88560244e-02f, 1.66163951e-01f, 4.55494076e-02f,
  -1.58366129e-01f, -1.81753021e-02f, -1.19787224e-01f, 1.30166650e-01f, -2.41343990e-01f, -4.10856083e-02f, -8.00725669e-02f, 5.46694361e-02f, -3.31406593e-02f, 4.96260151e-02f,
  2.28583440e-02f, 1.14829354e-01f, 1.99153405e-02f, 1.74715489e-01f, -2.30692625e-01f, 1.34360075e-01f, -1.10611916e-01f, 2.50265449e-01f, 1.23930223e-01f, 8.55985656e-03f,
  1.33517906e-02f, 4.07025255e-02f, -5.85884936e-02f, -7.53650293e-02f, 1.35196343e-01f, -7.21833333e-02f, -5.28232120e-02f, -1.57766148e-01f, 7.64526874e-02f, -8.22234601e-02f,
  -1.86061338e-01f, -6.23436160e-02f, -2.95528620e-01f, 2.22229660e-01f, 6.45408183e-02f, -3.65816653e-02f, -4.62194420e-02f, -2.01315761e-01f, 6.06950186e-02f, -1.08610570e-01f,
  1.41671926e-01f, 1.00211047e-01f, 9.00836941e-03f, -2.36084700e-01f, -1.40641794e-01f, -1.04119986e-01f, 2.72183985e-01f, 2.07983330e-01f, -3.79417017e-02f, -2.46666130e-02f,
  1.25475571e-01f, 2.32054472e-01f, -6.80439547e-02f, -2.95703206e-02f, -1.73613191e-01f, -1.35348111e-01f, -1.64200887e-01f, 4.53022495e-02f, 1.06175542e-02f, 6.22628145e-02f,
  2.21556678e-01f, 3.51116963e-04f, 2.39596277e-01f, -1.83377236e-01f, -1.65320009e-01f, 1.09648623e-01f, -8.63235965e-02f, 1.97973661e-02f, 2.04009250e-01f, 7.52428994e-02f,
  1.54641420e-01f, -1.35179430e-01f, 3.34073417e-02f, 1.14814319e-01f, -2.04089675e-02f, -6.03655875e-02f, -2.74687201e-01f, 5.12974076e-02f, 1.02155022e-01f, 2.45407801e-02f,
  1.42496973e-02f, -4.44145910e-02f, 7.28605837e-02f, -8.99083316e-02f, 1.91005528e-01f, -5.10131307e-02f, -1.32630691e-01f, 9.25018191e-02f, 2.23913584e-02f, 2.56266564e-01f,
  3.41947712e-02f, -1.31076917e-01f, 3.00354324e-02f, 8.39008763e-02f, 2.07967069e-02f, -1.12853348e-01f, -1.28045395e-01f, -4.32451809e-04f, -8.89598057e-02f, -6.91044480e-02f,
  9.90922749e-02f, -1.01526335e-01f, -3.50220799e-02f, -1.26904726e-01f, 8.55991915e-02f, 2.22552158e-02f, 1.32987434e-02f, -2.11071506e-01f, -1.55990586e-01f, 3.09190154e-02f,
  2.58657169e-02f, -3.30602340e-02f, 7.27435723e-02f, -1.37140200e-01f, 8.86599794e-02f, 3.44055593e-02f, -1.27119804e-02f, 2.59846933e-02f, -9.17472020e-02f, 5.09837363e-03f,
  2.02463791e-01f, 8.61048847e-02f, -8.43485668e-02f, 2.33979821e-01f, 1.60157934e-01f, -1.00511134e-01f, 7.82969370e-02f, 7.81563073e-02f, -1.36793211e-01f, 1.11784689e-01f,
  4.65321173e-05f, 1.64305903e-02f, -1.42101884e-01f, 9.79002714e-02f, 1.45001173e-01f, 1.61339447e-01f, 1.23413736e-02f, 6.76601157e-02f, -1.45180032e-01f, -1.00522473e-01f,
  2.15459540e-02f, 1.00648776e-01f, -1.31959930e-01f, -9.65463519e-02f, -1.34027600e-01f, 1.65229455e-01f, -9.39697847e-02f, 1.40564833e-02f, 8.13474730e-02f, -1.59309968e-01f,
  3.32065858e-02f, 5.72582074e-02f, 9.96565372e-02f, 7.89604709e-02f, -1.23113468e-01f, 2.50726417e-02f, 2.14067861e-01f, -2.36449838e-02f, 5.01222871e-02f, -1.35334581e-03f,
  -2.72289902e-01f, 2.64764488e-01f, 2.08486289e-01f, 5.86159974e-02f, -5.02921566e-02f, 2.61409464e-03f, 1.43727034e-01f, -1.76541761e-01f, 5.32846563e-02f, 5.02422079e-02f,
  1.40387028e-01f, -2.16418922e-01f, -9.50702131e-02f, 1.21761218e-01f, 8.36888235e-03f, 1.03074864e-01f, 7.43768513e-02f, 1.98410019e-01f, -3.42054591e-02f, -8.43873098e-02f,
  -5.82702085e-02f, 6.13828376e-02f, -1.00239173e-01f, 7.79903606e-02f, -2.44904533e-02f, 7.36884028e-02f, -1.92968562e-01f, 7.29751866e-03f, -4.00771618e-01f, -2.54294779e-02f,
  1.66224599e-01f, -2.07010344e-01f, -7.88553506e-02f, -6.22904710e-02f, 5.60287870e-02f, -1.08518101e-01f, 1.12954982e-01f, 7.42762489e-03f, -8.60907882e-02f, -3.60186733e-02f,
  -6.82629496e-02f, -5.18835820e-02f, -8.29610229e-02f, 8.92638322e-03f, 1.79931715e-01f, -1.22276386e-02f, -1.64057866e-01f, 1.16388477e-01f, 8.95076394e-02f, 1.98734015e-01f,
  4.81829122e-02f, 3.10374461e-02f, -1.71591509e-02f, -2.42785707e-01f, 4.43357676e-02f, 1.27189845e-01f, 2.77970247e-02f, 1.13377228e-01f, 1.17694080e-01f, -9.69168097e-02f,
  -7.95866251e-02f, -1.60503060e-01f, 9.76299495e-02f, -5.41893840e-02f, -6.69165179e-02f, 7.61104673e-02f, 1.07306361e-01f, 1.32076308e-01f, -4.40994650e-02f, -2.17928700e-02f,
  7.56660774e-02f, 1.00534596e-01f, -1.05940238e-01f, 1.92999858e-02f, -4.50878479e-02f, 2.62685567e-01f, 5.55515587e-02f, 5.00273481e-02f, -5.70643023e-02f, -1.72983542e-01f,
  1.50658429e-01f, 2.29115024e-01f, -2.50045449e-01f, -8.09860509e-03f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.70045584e-01f, 1.05077989e-01f, 2.20633209e-01f, 2.47790337e-01f, 2.62989193e-01f, 9.14422888e-03f, 2.18997076e-01f, -4.85859811e-02f, 5.59301257e-01f, 2.06139848e-01f,
  -1.29330218e-01f, 3.55651051e-01f, -1.25329778e-01f, 2.48074830e-01f, 9.74185318e-02f, 2.45837212e-01f, -1.27435014e-01f, -6.21583275e-02f, 1.03445642e-01f, 4.22680117e-02f,
  2.62684934e-02f, -8.17080885e-02f, 1.68052256e-01f, 1.93410292e-01f, -1.27383340e-02f, -8.25524926e-02f, 1.05849527e-01f, 3.60277966e-02f, 4.92547303e-02f, 1.90992370e-01f,
  -1.08800363e-02f, -4.68024053e-03f, 7.35546201e-02f, 2.28667557e-01f, -9.76608992e-02f, -2.42140040e-01f, 2.39591584e-01f, 1.57864168e-01f, -1.36187881e-01f, 1.77084789e-01f,
  -2.40920428e-02f, 7.26232529e-02f, -1.46143278e-02f, -3.44256647e-02f, -1.07104525e-01f, 3.48322503e-02f, 1.17526516e-01f, 3.42999324e-02f, 3.12638916e-02f, -1.13678455e-01f,
  -1.56817257e-01f, -2.10439980e-01f, 3.08327936e-02f, 1.91022709e-01f, -3.99998613e-02f, -1.61089629e-01f, 5.36194723e-03f, 7.44830742e-02f, 1.46124378e-01f, 1.56360060e-01f,
  1.17160074e-01f, -5.90334348e-02f, 2.50060320e-01f, 2.29035348e-01f, 1.51839122e-01f, -4.61443700e-02f, 2.21415624e-01f, 5.28531037e-02f, -2.93334033e-02f, 3.48167419e-02f,
  -1.89832836e-01f, 1.13258168e-01f, -2.39922658e-01f, -5.79689927e-02f, -1.67033359e-01f, 5.65442629e-02f, 2.15127155e-01f, 6.60248101e-02f, -6.96829185e-02f, 4.14339043e-02f,
  -1.29878044e-01f, 9.88060459e-02f, -4.77729738e-02f, 1.09121643e-01f, 7.10863248e-02f, 1.52491219e-02f, -6.80418536e-02f, -5.66750504e-02f, 1.69688329e-01f, -4.34084684e-02f,
  5.30788451e-02f, 2.14558706e-01f, 1.57915745e-02f, 2.75050282e-01f, 5.33088781e-02f, 9.57783610e-02f, -6.61542267e-02f, -1.11155964e-01f, 9.16413367e-02f, 4.33186330e-02f,
  1.59233272e-01f, 6.80425167e-02f, 1.53091382e-02f, -8.59552845e-02f, 1.25004306e-01f, 1.67628154e-01f, 2.25331355e-02f, 3.36975306e-02f, 4.11675423e-01f, 9.96417925e-03f,
  9.57950726e-02f, 7.43546635e-02f, -4.61801775e-02f, 2.33642593e-01f, 4.65875641e-02f, -7.34574646e-02f, -1.98899116e-02f, 5.35099879e-02f, 1.22202642e-01f, 1.35502562e-01f,
  2.24025249e-01f, -1.13685362e-01f, 1.33818742e-02f, -1.15926471e-02f, 5.20723797e-02f, 9.54487100e-02f, -1.56295616e-02f, -1.44242689e-01f, 4.47902158e-02f, -3.99290770e-03f,
  -4.87652309e-02f, 1.58509523e-01f, 5.68012409e-02f, 7.17670694e-02f, 1.06953643e-01f, -1.10439241e-01f, 8.04238170e-02f, 2.93975230e-02f, -8.94958526e-02f, 8.65144581e-02f,
  8.92962292e-02f, 7.02355430e-03f, -2.50061117e-02f, 8.46705511e-02f, -6.24937341e-02f, 8.95849243e-02f, 2.63618808e-02f, 1.25289440e-01f, 1.32205188e-01f, 3.22414748e-02f,
  -1.33589610e-01f, -4.42215912e-02f, 6.34272546e-02f, -4.36079595e-03f, -8.65704864e-02f, 6.50681853e-02f, -1.16598718e-01f, 9.74537730e-02f, -8.35486427e-02f, -8.69833585e-03f,
  -9.90142450e-02f, -7.03822747e-02f, 1.45342082e-01f, 2.85268743e-02f, -6.67418689e-02f, -8.95529017e-02f, -1.98905310e-03f, -1.14557594e-01f, 9.78768021e-02f, -1.24061190e-01f,
  6.25837445e-02f, -6.55697808e-02f, -3.37675735e-02f, -1.79359660e-01f, -8.90079290e-02f, 9.49674286e-03f, -9.12462845e-02f, 3.99600044e-02f, 4.70330790e-02f, -1.19920574e-01f,
  1.75008476e-02f, -1.44515345e-02f, 1.26838222e-01f, -2.11403593e-02f, -5.32261543e-02f, -4.00859416e-02f, 1.05651930e-01f, 2.02358533e-02f, 5.75923957e-02f, 1.35746449e-01f,
  -1.00891784e-01f, 3.85758542e-02f, 3.79292220e-02f, -1.11623049e-01f, 1.40067384e-01f, 2.56793443e-02f, -4.56106886e-02f, 1.82627872e-01f, 7.18444884e-02f, -1.48250051e-02f,
  -1.05707027e-01f, -3.53164263e-02f, 9.65423957e-02f, -7.89627805e-03f, 5.13496622e-02f, 1.29346162e-01f, 1.78894535e-01f, -9.44268778e-02f, -3.44657116e-02f, 1.67704567e-01f,
  5.68919890e-02f, 1.62376482e-02f, 5.92297800e-02f, 2.76042130e-02f, 5.64697385e-02f, -7.40863308e-02f, 6.53620139e-02f, 4.84549552e-02f, -2.42097114e-04f, 4.56505120e-02f,
  -4.77904752e-02f, -1.73346370e-01f, -3.08122654e-02f, -3.79897058e-02f, -1.29574463e-01f, -1.02797471e-01f, 1.82804279e-02f, 3.67942117e-02f, 5.88952415e-02f, 4.35180925e-02f,
  1.56624932e-02f, -5.41864112e-02f, 4.77912202e-02f, -6.75453171e-02f, 7.63390437e-02f, -3.42908390e-02f, -1.81833580e-01f, 2.06125565e-02f, -4.90137376e-02f, 1.40348479e-01f,
  -6.80376217e-02f, -1.71663195e-01f, 1.09139113e-02f, 1.87903076e-01f, 1.41976429e-02f, 5.72762601e-02f, 1.15818039e-01f, 7.74581134e-02f, 3.74370515e-02f, 5.82168251e-03f,
  1.14303872e-01f, 2.69357622e-01f, 1.91244796e-01f, 8.19709972e-02f, -6.71810657e-03f, 1.19508751e-01f, -5.90429790e-02f, -1.19133234e-01f, 2.80416831e-02f, -1.21123046e-01f,
  -4.61414531e-02f, 1.49040734e-02f, 1.58139989e-01f, -2.07934707e-01f, 7.50002488e-02f, 2.79327203e-02f, 1.22737572e-01f, -9.12763104e-02f, 4.65630367e-02f, -5.54801375e-02f,
  3.02510023e-01f, 1.24280035e-01f, -9.57242921e-02f, 1.07177176e-01f, 3.98063175e-02f, -9.83746722e-02f, 1.60376765e-02f, 8.19963515e-02f, 1.45273089e-01f, 1.23909988e-01f,
  -1.50738955e-01f, 7.35511351e-03f, -3.65526937e-02f, 7.83563480e-02f, 9.49879810e-02f, 2.68806845e-01f, 6.93716668e-03f, 3.92731577e-02f, -1.37386307e-01f, 2.45818585e-01f,
  -6.90057427e-02f, 2.50771999e-01f, -4.24431413e-02f, -1.13571338e-01f, 2.87309080e-01f, 2.10604891e-02f, 4.65380438e-02f, 1.25781879e-01f, -3.80033962e-02f, -4.24254425e-02f,
  -5.33113144e-02f, -3.56186666e-02f, -1.77843422e-02f, 1.67274326e-02f, 5.21784537e-02f, -9.46972053e-03f, 3.75147536e-02f, 1.01123437e-01f, 6.79591075e-02f, 5.47941141e-02f,
  -1.21683449e-01f, 3.86236995e-01f, -3.12123820e-02f, -1.07461222e-01f, -6.15129247e-03f, 1.40038222e-01f, 2.13487968e-01f, -9.58905295e-02f, 1.46124199e-01f, 1.79023266e-01f,
  1.84248816e-02f, -2.98987515e-02f, 3.15811723e-01f, 1.40886530e-01f, 2.57125378e-01f, 1.21519864e-01f, -2.63316900e-01f, 3.66978705e-01f, 4.67673950e-02f, -3.65362376e-01f,
  -2.17482135e-01f, -1.87636554e-01f, 1.25697881e-01f, 2.11637408e-01f, -8.90877545e-02f, -1.94780141e-01f, 1.98415473e-01f, -6.13440759e-02f, 3.32417786e-01f, -7.22386241e-02f,
  1.81389511e-01f, 1.36925727e-01f, -2.44597122e-02f, -8.41401294e-02f, -1.26601502e-01f, 9.03674513e-02f, 1.24122366e-01f, 6.91141039e-02f, 4.78088520e-02f, -1.04731284e-01f,
  4.90914807e-02f, -1.30767360e-01f, 1.40674099e-01f, -2.32863426e-02f, 1.35512194e-02f, -2.50778589e-02f, -1.79953098e-01f, 4.23168153e-01f, 7.84974918e-02f, -6.32216185e-02f,
  2.63901621e-01f, 2.36074507e-01f, 1.14164799e-01f, 9.95775312e-02f, 2.33505145e-01f, 4.34883177e-01f, 1.72645539e-01f, 6.98310435e-02f, 1.78921402e-01f, 1.56571224e-01f,
  2.61505805e-02f, -9.71842334e-02f, 2.69004256e-01f, 8.26964974e-02f, -6.83226883e-02f, -1.14726208e-01f, -6.10686652e-02f, 2.20114946e-01f, -3.97884622e-02f, -8.75468925e-02f,
  -6.32164478e-02f, -5.34370355e-02f, 2.86885817e-03f, -1.37458280e-01f, 8.91829431e-02f, 1.19152986e-01f, -1.30619869e-01f, -7.64760226e-02f, -3.38886455e-02f, -9.06528980e-02f,
  1.14021860e-01f, -1.35404274e-01f, 1.59349665e-02f, -2.45209653e-02f, -7.14395344e-02f, 1.33607253e-01f, -9.45832282e-02f, 1.87484943e-03f, -5.44583537e-02f, 8.16024169e-02f,
  1.25446558e-01f, -8.06728080e-02f, -1.05657868e-01f, -1.15084782e-01f, -5.92253618e-02f, -7.41992518e-02f, 9.87753868e-02f, 9.03796479e-02f, -1.10569209e-01f, -7.70010054e-02f,
  2.67965682e-02f, -6.43121637e-03f, 9.36023593e-02f, -9.96088535e-02f, 3.63110506e-04f, -3.09208930e-02f, -6.61065504e-02f, -1.03719227e-01f, 1.17420433e-02f, -6.73175650e-03f,
  -6.32314757e-02f, -2.99397316e-02f, 1.56632587e-02f, -6.98234513e-02f, 5.61922900e-02f, -5.25212176e-02f, -8.66573155e-02f, 4.88496125e-02f, -8.71951729e-02f, -8.81312191e-02f,
  8.47530365e-02f, -1.11365356e-01f, -2.03280579e-02f, -1.70540554e-03f, -3.52940187e-02f, 1.53110743e-01f, -1.12331755e-01f, -4.89601903e-02f, 4.59262257e-04f, 3.18953507e-02f,
  1.54038202e-02f, -7.49037638e-02f, -6.77546039e-02f, 1.04811206e-01f, 1.32309258e-01f, -6.34969994e-02f, 3.26179378e-02f, 1.06172271e-01f, 2.01744065e-01f, -6.33727536e-02f,
  1.11779556e-01f, 2.27027163e-01f, 1.35247573e-01f, 3.41937125e-01f, -2.00757891e-01f, 3.60424131e-01f, -3.72933775e-01f, -2.05222413e-01f, 1.20093614e-01f, -9.46694091e-02f,
  1.77768692e-01f, -4.49654013e-02f, 1.44419089e-01f, -1.66996330e-01f, -2.10757524e-01f, 9.71099585e-02f, 1.40977874e-01f, -1.51622146e-02f, 1.57348573e-01f, -1.65999562e-01f,
  -1.30901620e-01f, -1.16357401e-01f, 8.40105955e-03f, 2.25007638e-01f, -7.55224004e-02f, -1.62140783e-02f, -4.94256876e-02f, -2.95020163e-01f, -1.20568583e-02f, 1.79737300e-01f,
  -1.61350220e-01f, 1.19954310e-01f, 1.41887978e-01f, 3.56434733e-01f, 6.29196763e-02f, -2.11671084e-01f, 7.20877573e-02f, 5.61941005e-02f, 2.24755839e-01f, -7.03705400e-02f,
  1.93784013e-01f, 6.80779219e-02f, 2.06717134e-01f, 1.08967602e-01f, 3.96601707e-02f, -1.48038641e-02f, 1.63149074e-01f, -7.45913526e-03f, 2.13383451e-01f, 2.47507542e-01f,
  6.66184202e-02f, -4.85133231e-02f, 2.76081979e-01f, -1.60002299e-02f, 6.46007359e-02f, -8.04172382e-02f, -1.27014160e-01f, 1.15571402e-01f, 1.51073337e-01f, 1.85641535e-02f,
  -2.07866326e-01f, -5.25314063e-02f, 7.76198432e-02f, -9.41158645e-03f, 7.39905015e-02f, -3.68736908e-02f, -1.13147654e-01f, -3.10949162e-02f, 1.41296625e-01f, -1.02221213e-01f,
  -4.04121019e-02f, -1.93025947e-01f, 1.39219925e-01f, -1.32315129e-01f, 8.47938061e-02f, 7.94138908e-02f, 8.92462134e-02f, -1.78024665e-01f, 2.14425802e-01f, 7.53661245e-02f,
  1.72033161e-01f, -1.07477261e-02f, -1.63569059e-02f, 3.61986570e-02f, -3.71285602e-02f, 1.78927988e-01f, -6.77121803e-02f, 1.89988449e-01f, 1.54581413e-01f, 5.23982756e-02f,
  3.58944051e-02f, -1.35981470e-01f, 3.66261862e-02f, 7.21796649e-03f, 1.78564578e-01f, 1.55866042e-01f, 9.97758284e-02f, 1.98799208e-01f, 1.01534061e-01f, 6.89681387e-03f,
  1.04585141e-01f, 6.12596199e-02f, 6.99880570e-02f, 1.59552574e-01f, -1.11765534e-01f, -4.59074154e-02f, 7.37153143e-02f, 1.39982536e-01f, -7.15904823e-03f, 1.68657936e-02f,
  7.46038184e-02f, -7.51052005e-03f, 8.92440528e-02f, 1.24509782e-01f, -7.57361948e-02f, 6.86137751e-02f, -2.49566603e-02f, -1.13789374e-02f, -5.29380850e-02f, 1.31124735e-01f,
  5.45239151e-02f, 2.01094329e-01f, -1.00833647e-01f, 2.83089224e-02f, 7.73911402e-02f, 1.94667786e-01f, 1.67266298e-02f, -3.00753117e-02f, -1.06968559e-01f, 1.38536096e-01f,
  4.46940698e-02f, 7.87975714e-02f, -9.87391993e-02f, 7.34942555e-02f, -6.62421510e-02f, 1.04847513e-01f, 1.54230343e-02f, 1.07840784e-01f, 3.76620777e-02f, -5.45942336e-02f,
  -5.83025441e-02f, -1.11485355e-01f, -6.86671510e-02f, -4.91831787e-02f, -1.02246203e-01f, -1.06456866e-02f, -1.36804432e-02f, 1.80983962e-03f, -8.17220286e-02f, -8.11098963e-02f,
  2.00005010e-01f, -7.50170201e-02f, -8.77126455e-02f, 8.85776132e-02f, -3.57702449e-02f, -2.37376429e-02f, -7.51092806e-02f, 1.68928057e-02f, -8.07863250e-02f, -1.04060754e-01f,
  -1.59506258e-02f, 5.30075133e-02f, -9.93764624e-02f, -1.17354728e-01f, 5.88016137e-02f, -1.32979196e-03f, -8.67959112e-02f, 3.80030833e-02f, -8.00539404e-02f, 3.25509645e-02f,
  -4.06497717e-02f, -5.57409264e-02f, -5.60107864e-02f, 7.15975612e-02f, 9.97086987e-02f, -4.14436236e-02f, -4.09546345e-02f, 1.43648669e-01f, 9.98957306e-02f, 6.60817092e-03f,
  -2.71955179e-03f, 1.17832407e-01f, 8.30326974e-03f, 3.13597508e-02f, 3.03241313e-02f, 9.28323567e-02f, -1.45770814e-02f, 5.74986637e-02f, -9.24623534e-02f, -3.08852755e-02f,
  -8.10687169e-02f, -3.09961066e-02f, 8.22718143e-02f, -4.28122729e-02f, 1.13737419e-01f, -9.88179520e-02f, -5.10647222e-02f, 1.29226342e-01f, -2.48476081e-02f, 6.40780777e-02f,
  2.67467089e-02f, -7.81238750e-02f, -8.02782774e-02f, -1.76025592e-02f, -1.35066472e-02f, -3.29716504e-02f, 8.22896063e-02f, -1.09999925e-02f, 1.31548777e-01f, -2.23781466e-02f,
  1.11491606e-01f, 9.46540609e-02f, 1.14179030e-01f, -4.27584536e-02f, 1.50762796e-01f, -1.19697385e-01f, -1.03969008e-01f, 9.33879912e-02f, -3.18995267e-02f, -9.56251752e-03f,
  7.06313318e-03f, -4.76598591e-02f, -2.18902864e-02f, -9.83757898e-02f, 6.25023991e-02f, 9.88306571e-03f, 9.43286270e-02f, -5.17227687e-02f, 8.42407495e-02f, -1.16120681e-01f,
  -7.80748352e-02f, -4.19716574e-02f, -4.06361781e-02f, -6.08468428e-02f, -3.93155776e-02f, 1.29877329e-01f, 1.17576793e-01f, -2.17082333e-02f, -2.72075622e-03f, 1.71025656e-02f,
  -1.13308467e-01f, -6.61151558e-02f, 1.31119773e-01f, -1.78874452e-02f, -1.14216097e-01f, 1.05586043e-02f, 6.86426312e-02f, 1.83701850e-02f, -4.59793061e-02f, 7.57427737e-02f,
  -3.86339538e-02f, 6.32528961e-02f, 5.48589602e-02f, -1.10507071e-01f, 1.72287244e-02f, 1.13962062e-01f, 3.94007526e-02f, 9.40020531e-02f, -7.16322660e-02f, 1.77916929e-01f,
  9.11655426e-02f, 1.20712155e-02f, 2.39371732e-01f, 3.49048555e-01f, 5.42541981e-01f, -2.03418970e-01f, 7.59357661e-02f, -9.90867149e-04f, 2.27442801e-01f, 8.63124281e-02f,
  3.94259483e-01f, 2.62781173e-01f, 2.64333040e-01f, -1.56544652e-02f, 3.49285454e-03f, 2.90689975e-01f, 2.00511172e-01f, -3.41144428e-02f, -1.30971977e-02f, -6.09496683e-02f,
  1.46446526e-01f, -3.47681455e-02f, 1.42031834e-01f, -1.07637450e-01f, -2.81676417e-03f, 7.97268078e-02f, 2.10741356e-01f, -5.53499497e-02f, 6.03029206e-02f, 1.10304132e-01f,
  -2.10834518e-01f, 5.33064723e-01f, 2.16974884e-01f, -7.42742047e-02f, -1.93507373e-02f, -5.40925786e-02f, 5.12727797e-02f, 3.14142741e-02f, -2.67999917e-01f, 3.60492319e-02f,
  -4.20885049e-02f, -1.37643129e-01f, 2.07963884e-01f, 1.10849291e-02f, -1.61582351e-01f, 2.07420468e-01f, -6.80054575e-02f, 1.05377644e-01f, -4.67190407e-02f, 2.76247025e-01f,
  -1.23851985e-01f, 9.74621028e-02f, -5.61516285e-02f, 1.53685868e-01f, 3.24874163e-01f, -4.93377224e-02f, 1.47861406e-01f, 2.92168051e-01f, 1.40773505e-01f, 8.71608481e-02f,
  -1.16367817e-01f, 5.68898022e-02f, -1.75337158e-02f, 1.38351649e-01f, -5.31038009e-02f, -1.23814002e-01f, -1.26508206e-01f, 8.05141255e-02f, 4.27871570e-03f, 1.38291717e-01f,
  -1.89753640e-02f, 9.45983455e-02f, 1.63484155e-03f, 2.01362401e-01f, -5.02123721e-02f, 9.90561023e-02f, -1.26426250e-01f, 1.40154615e-01f, -9.49272141e-02f, 1.07352234e-01f,
  -6.16437458e-02f, -7.50068203e-02f, 1.15976669e-01f, 1.96845114e-01f, 7.30973929e-02f, -4.36396040e-02f, -6.24079183e-02f, 3.51976067e-01f, -2.70197783e-02f, 3.39784883e-02f,
  -1.23537503e-01f, -2.97736134e-02f, -3.96251082e-02f, 1.59491792e-01f, 1.30591914e-01f, -1.95564166e-01f, -1.81088671e-02f, -1.11929029e-01f, 1.06882444e-02f, -1.58498213e-01f,
  -1.07368529e-02f, 1.76382825e-01f, 2.92423349e-02f, -1.11003205e-01f, -9.89262983e-02f, 1.48802385e-01f, 6.84224963e-02f, 1.61501709e-02f, 1.52587444e-01f, -3.53150293e-02f,
  -6.53415546e-02f, 5.10562398e-02f, 5.56187257e-02f, 1.15138024e-01f, 5.52100576e-02f, 1.00152031e-01f, 9.87356305e-02f, -1.28220424e-01f, 1.51201868e-02f, 3.00341725e-01f,
  -1.07457057e-01f, -1.74510822e-01f, 4.61469963e-02f, -1.13694459e-01f, -1.03627488e-01f, -6.87878504e-02f, -1.71282426e-01f, 7.51797557e-02f, -3.33218537e-02f, -3.06810021e-01f,
  8.43521655e-02f, -4.69496287e-02f, -1.20765619e-01f, 1.36713292e-02f, 1.25141874e-01f, 2.36171037e-02f, 1.87181816e-01f, 1.51832551e-01f, 1.57932043e-01f, -4.81651798e-02f,
  2.30536936e-03f, -5.16075604e-02f, 1.47186950e-01f, 8.03678930e-02f, 1.95815474e-01f, 2.80776560e-01f, -1.40161468e-02f, -4.16677669e-02f, 2.00242445e-01f, 2.51500875e-01f,
  1.92327768e-01f, 4.91867244e-01f, 2.77788918e-02f, -6.70345202e-02f, 5.08383811e-02f, 1.77624747e-01f, -1.23071171e-01f, -3.67556214e-02f, 8.36250409e-02f, 7.25535527e-02f,
  6.15900941e-02f, 1.90121561e-01f, -1.16905300e-02f, 1.34597048e-01f, -5.58675490e-02f, -1.27059251e-01f, 1.54127494e-01f, 1.17749564e-01f, -3.92257497e-02f, -9.76169035e-02f,
  -7.44964853e-02f, 1.27243549e-01f, 5.30625656e-02f, -1.02234306e-02f, 7.27046132e-02f, 1.39163300e-01f, -1.09190024e-01f, 1.33186594e-01f, -6.27887994e-02f, 1.15254655e-01f,
  -5.83757428e-05f, -3.54934894e-02f, 9.25762504e-02f, -1.25977278e-01f, 3.32077220e-03f, -6.65826276e-02f, 9.71002504e-03f, 1.18610691e-02f, 3.01342726e-01f, 1.23949088e-01f,
  2.04117209e-01f, 6.02513105e-02f, -2.21671566e-01f, 2.27058366e-01f, 3.64210755e-02f, -5.75670600e-02f, -9.79309976e-02f, -9.10046473e-02f, 1.41300634e-01f, 1.84203207e-01f,
  6.52220994e-02f, 1.36020064e-01f, 1.38708176e-02f, 8.05779025e-02f, 1.91521756e-02f, 4.23653349e-02f, -5.25817536e-02f, -7.16733634e-02f, -2.82599684e-03f, -1.12838149e-02f,
  1.09077916e-01f, -7.40624741e-02f, -1.11764602e-01f, -4.44368459e-02f, -1.05271831e-01f, -1.07457526e-01f, -5.99763989e-02f, -1.11950152e-01f, 1.18389346e-01f, -5.16931750e-02f,
  -7.17195347e-02f, 2.57782545e-02f, -7.94313923e-02f, 2.79541522e-01f, -3.93981077e-02f, -2.34521255e-02f, 1.92625925e-01f, -1.22434378e-03f, 1.26875520e-01f, 7.33740777e-02f,
  2.57932752e-01f, 1.31005660e-01f, 8.78038704e-02f, -6.47694096e-02f, 1.55204028e-01f, 5.07524349e-02f, -4.15197946e-02f, 4.72957678e-02f, 7.97670707e-02f, 8.64895340e-03f,
  1.89137414e-01f, -1.63968667e-01f, 1.63791493e-01f, 5.44861443e-02f, -1.01058565e-01f, 4.44031246e-02f, 7.21261278e-02f, -1.22711748e-01f, 1.05963061e-02f, -1.59128979e-01f,
  4.17477004e-02f, -3.19228508e-02f, 1.38964966e-01f, 3.97760049e-02f, -2.22179331e-02f, 1.28010511e-01f, -9.79081541e-02f, 1.40526474e-01f, -2.04859450e-01f, -7.52342269e-02f,
  -1.06095113e-01f, -8.18471164e-02f, 2.49464348e-01f, 9.33151469e-02f, -1.32911354e-02f, -1.13349080e-01f, 1.77232116e-01f, 4.75888187e-03f, -8.37297142e-02f, -4.52663191e-02f,
  1.66535109e-01f, 8.76229554e-02f, 2.06177793e-02f, 1.17668740e-01f, 4.11579162e-02f, 7.74660259e-02f, 1.07540317e-01f, -2.13770904e-02f, 1.55570239e-01f, -2.06179917e-01f,
  8.28503966e-02f, -8.38326588e-02f, -9.26449150e-02f, 1.96397021e-01f, 1.44456774e-01f, 2.98414212e-02f, -8.28997344e-02f, 5.04902117e-02f, 2.93296240e-02f, 4.07749340e-02f,
  1.44911990e-01f, 1.74259230e-01f, 2.14917228e-01f, -8.89121518e-02f, 2.78494656e-01f, 8.49209819e-03f, 2.17535757e-02f, -5.75435720e-02f, 3.94013189e-02f, 2.00979412e-01f,
  1.87167618e-02f, 3.29504684e-02f, 1.80542842e-02f, 1.29920065e-01f, -7.48217255e-02f, 1.18442729e-01f, 6.73673302e-02f, 1.01920694e-01f, -1.37530252e-01f, 6.80467337e-02f,
  -8.96362960e-02f, 1.89139936e-02f, 3.43904942e-02f, -7.70900175e-02f, 1.90776721e-01f, 1.90199956e-01f, 4.12132367e-02f, 2.93781698e-01f, 2.68508494e-01f, 3.17808092e-01f,
  1.37320712e-01f, -9.88585353e-02f, -2.74600118e-01f, -3.83850992e-01f, -3.89219150e-02f, -2.10243706e-02f, -1.26085296e-01f, -2.57657259e-03f, -1.00283436e-01f, -9.16972756e-03f,
  -2.67380148e-01f, -7.29375854e-02f, 9.28033050e-03f, -4.67313156e-02f, -3.17151211e-02f, -1.23518273e-01f, -2.57146079e-02f, 6.17288053e-03f, -8.85599032e-02f, 3.95108491e-01f,
  -1.74963742e-01f, 2.97111869e-01f, -7.37520773e-03f, 3.50351185e-01f, -7.91376010e-02f, 1.30833969e-01f, -1.12151422e-01f, 1.00696318e-01f, -2.55798046e-02f, 3.01775366e-01f,
  4.27533239e-01f, -1.99836478e-01f, 8.62410441e-02f, -1.23368166e-01f, 9.70302001e-02f, 1.80346966e-01f, 8.22354406e-02f, -3.72810848e-02f, 9.29813012e-02f, 1.54285386e-01f,
  -5.26146069e-02f, 2.44126350e-01f, -5.44319600e-02f, -6.15603998e-02f, 3.53956908e-01f, 1.86891537e-02f, -9.96742491e-03f, -1.38876051e-01f, 3.32468748e-01f, -1.78639218e-01f,
  -6.03056997e-02f, 8.00254643e-02f, 4.86513138e-01f, 4.14555818e-01f, -8.40793699e-02f, 1.69733882e-01f, 2.61029769e-02f, 2.46193334e-01f, 1.17903426e-01f, 4.38511483e-02f,
  1.42567707e-02f, 5.20523190e-02f, 7.88440332e-02f, 9.45365727e-02f, -8.37898478e-02f, 1.32018328e-01f, 8.13478455e-02f, -3.00035486e-03f, 2.63987649e-02f, 1.59328394e-02f,
  1.61861643e-01f, -1.32400155e-01f, -1.34238139e-01f, -1.19696826e-01f, 1.45504326e-01f, 1.69047505e-01f, 1.02811471e-01f, 1.04861364e-01f, 1.05569810e-01f, -7.27092624e-02f,
  -2.92605546e-04f, -5.55148907e-02f, -8.20702761e-02f, 1.37466018e-03f, 1.82376221e-01f, -2.38097217e-02f, 1.59296706e-01f, -6.85121864e-02f, -2.34971046e-02f, -4.31369878e-02f,
  6.10687174e-02f, -1.48809537e-01f, 5.50940409e-02f, 1.62992358e-01f, 8.52221772e-02f, 2.69661665e-01f, -9.12081897e-02f, 4.29834351e-02f, -1.15322851e-01f, -1.34387016e-01f,
  1.76193595e-01f, 3.18195932e-02f, 8.76753107e-02f, -1.62381515e-01f, -1.09238915e-01f, 2.41307123e-03f, 9.72022787e-02f, 4.58537266e-02f, 8.54255806e-04f, 6.17292747e-02f,
  -8.54749531e-02f, 1.96053144e-02f, 1.74016610e-01f, -9.56082791e-02f, 1.39257506e-01f, -2.61927638e-02f, -9.38552395e-02f, 3.36885229e-02f, 1.65120915e-01f, -5.07873669e-02f,
  -6.23051003e-02f, -7.10525364e-02f, 2.15657458e-01f, 2.00597290e-03f, 1.40168080e-02f, 7.85997286e-02f, -1.75639838e-02f, 7.73511827e-02f, 7.91922733e-02f, 1.70121208e-01f,
  6.50494918e-02f, -1.26619309e-01f, 2.14980856e-01f, -9.40662846e-02f, 3.25929783e-02f, -1.57736111e-02f, -2.26030909e-02f, -3.82093117e-02f, 3.47168557e-02f, 1.72479212e-01f,
  1.87444642e-01f, -5.55884577e-02f, -4.38927151e-02f, -8.29360336e-02f, -8.61626491e-03f, -1.09963723e-01f, -1.00645319e-01f, 1.16901204e-01f, 1.31148607e-01f, -8.30062944e-03f,
  8.11966062e-02f, 1.12081366e-02f, 2.90922206e-02f, 1.22829698e-01f, 8.12594369e-02f, 3.74677889e-02f, -5.22687938e-03f, 1.18402675e-01f, -1.16523243e-01f, 3.06126982e-01f,
  -5.32486886e-02f, -3.64397354e-02f, -9.56506729e-02f, 1.06286556e-01f, -8.94796029e-02f, 7.97483027e-02f, -2.04485863e-01f, 5.16024865e-02f, 6.91559166e-02f, 1.91014148e-02f,
  -1.46698346e-02f, -3.08758374e-02f, 1.36725917e-01f, -2.35575251e-02f, 7.97520280e-02f, -1.27285182e-01f, 9.62347686e-02f, -2.81133112e-02f, -2.76088379e-02f, 1.18956186e-01f,
  -1.26182707e-02f, 4.06226292e-02f, 7.52043054e-02f, -2.91300490e-02f, -5.29279746e-02f, -1.16510242e-01f, 5.73840644e-03f, 6.28374889e-02f, -1.15817912e-01f, -6.57346752e-03f,
  -3.05503234e-02f, 1.31339058e-01f, -1.33540407e-01f, -9.49835330e-02f, 1.29936142e-02f, 1.42542109e-01f, 9.21708345e-02f, -1.21042617e-01f, -6.58402443e-02f, -1.80161875e-02f,
  -1.07881092e-01f, -5.26644476e-02f, 1.59656122e-01f, 1.92901865e-02f, 6.10561408e-02f, 1.23667173e-01f, 7.95585662e-02f, 1.51334271e-01f, 5.34486361e-02f, 1.18431464e-01f,
  1.78893581e-01f, 6.54430538e-02f, 1.20829463e-01f, 5.76926954e-02f, -5.58023639e-02f, 3.13594788e-02f, -2.86503751e-02f, 9.44491997e-02f, 7.30453432e-02f, -1.32362768e-01f,
  4.92735840e-02f, 4.92040887e-02f, -5.03031723e-02f, 4.51405607e-02f, -7.47042820e-02f, -1.04019269e-01f, 1.05788000e-02f, 1.01070806e-01f, -3.51489373e-02f, 3.17922160e-02f,
  3.49552184e-02f, -6.40492514e-02f, -1.93440425e-03f, -9.07690823e-02f, 1.29242420e-01f, 7.45144188e-02f, 6.69330209e-02f, 1.16428643e-01f, 1.40963808e-01f, 1.25516117e-01f,
  -1.90270972e-02f, -4.46253233e-02f, 9.93319005e-02f, 1.89366892e-01f, 6.91468790e-02f, -3.87099758e-02f, 2.45373137e-03f, 2.32219368e-01f, 1.22954093e-01f, -1.28910214e-01f,
  -8.03363621e-02f, -2.54211389e-02f, 1.26566375e-02f, 2.26171762e-02f, -9.91265178e-02f, -8.37129354e-02f, 2.57627806e-03f, 2.08057929e-02f, -1.24857053e-01f, -7.37063661e-02f,
  -3.20149325e-02f, -5.19866459e-02f, 2.17394918e-01f, -9.30035561e-02f, 7.12793693e-03f, -2.85756425e-03f, 8.19341689e-02f, 5.44756949e-02f, 9.07183364e-02f, -1.19365200e-01f,
  -1.22822868e-02f, -1.70244928e-02f, 1.37977749e-01f, 1.15233310e-01f, -1.67692512e-01f, -4.51980084e-02f, 1.97001666e-01f, -3.38937752e-02f, 1.17879219e-01f, -1.37417972e-01f,
  -5.34552187e-02f, 1.22115649e-01f, -6.70505017e-02f, 2.33272374e-01f, 1.43927112e-02f, 9.00873467e-02f, 3.75758931e-02f, -6.40854463e-02f, 1.00154735e-01f, 1.90346524e-01f,
  7.00364634e-02f, 1.78886414e-01f, 4.80522662e-02f, -3.31088193e-02f, 2.61291027e-01f, -1.18714824e-01f, 1.11368857e-01f, -1.24371260e-01f, 1.05304487e-01f, 9.44598839e-02f,
  -5.50554283e-02f, -4.29918952e-02f, 7.71728307e-02f, 8.47359970e-02f, -3.56717631e-02f, 2.44831517e-01f, -4.48009335e-02f, -1.00290019e-03f, 1.73501913e-02f, 2.48304885e-02f,
  -6.47531450e-02f, -1.74947605e-01f, -2.41559111e-02f, 1.54707104e-01f, 7.25565404e-02f, -1.26464412e-01f, -9.06361192e-02f, -8.48833099e-02f, -9.15609580e-03f, 8.74775723e-02f,
  4.53640595e-02f, -5.94681874e-03f, -1.28333375e-01f, -1.45686315e-02f, -1.10304333e-01f, -8.15859810e-02f, -3.08528412e-02f, -5.63948043e-02f, 9.17568151e-03f, -1.07187986e-01f,
  3.46599519e-03f, 1.44894287e-01f, -9.24677774e-02f, 1.32615522e-01f, 9.31989700e-02f, 1.24552205e-01f, 6.65060729e-02f, 4.67519313e-02f, -1.10493906e-01f, 1.43295303e-01f,
  -9.49850678e-02f, 1.46436524e-02f, 7.61998519e-02f, 1.78605795e-01f, 6.97178096e-02f, -8.74862596e-02f, -2.25316063e-02f, -5.40219359e-02f, -4.34846878e-02f, 1.06527083e-01f,
  1.09060220e-01f, -2.89990138e-02f, 1.80450365e-01f, 3.02357879e-03f, 1.05859851e-02f, 1.19591914e-01f, 5.27010523e-02f, -6.41153529e-02f, 1.27220437e-01f, 3.48948352e-02f,
  -4.55604196e-02f, 6.56038225e-02f, 2.51144655e-02f, 2.97114602e-03f, 1.63643479e-01f, -7.07076341e-02f, -7.84231052e-02f, -8.08766708e-02f, 2.91406438e-02f, -2.71752197e-02f,
  3.36127020e-02f, 3.21187228e-02f, -5.39896190e-02f, 1.02542691e-01f, 1.61089346e-01f, -8.68398622e-02f, -6.83183968e-02f, -6.39095679e-02f, 1.21516056e-01f, -3.01746931e-02f,
  1.54380873e-01f, 1.61704570e-01f, 1.87896062e-02f, 3.66614684e-02f, -1.11491382e-01f, -1.07524753e-01f, -3.12388837e-01f, -1.33126780e-01f, -9.26763564e-02f, 5.93451932e-02f,
  1.70648079e-02f, 6.09898241e-04f, 1.39376193e-01f, 5.92784397e-03f, -5.86807076e-03f, 7.80050159e-02f, 4.70942259e-02f, 2.49706637e-02f, -1.51809314e-02f, -5.52911051e-02f,
  -5.68711981e-02f, 1.14909433e-01f, -1.32908776e-01f, -1.02416582e-01f, 2.20581636e-01f, -6.38672244e-03f, -6.61347732e-02f, -4.31464575e-02f, 1.02306180e-01f, -6.14518747e-02f,
  8.50191265e-02f, 1.14900433e-01f, 1.13614634e-01f, 1.82818964e-01f, 1.41128555e-01f, -1.71245933e-01f, 5.50126880e-02f, -2.80542057e-02f, -6.52383640e-02f, 9.53450203e-02f,
  4.28322963e-02f, -1.03961281e-01f, 2.06900328e-01f, 7.02277347e-02f, -1.07409962e-01f, 3.91094051e-02f, -1.14408091e-01f, -3.06651425e-02f, 1.13040633e-01f, 1.67483196e-01f,
  1.22779548e-01f, 8.94508138e-02f, -8.63152891e-02f, 3.58393461e-01f, 9.50911418e-02f, -4.44703698e-02f, -1.26342028e-01f, -1.24638267e-01f, 3.59583348e-02f, 2.68648397e-02f,
  -3.30244983e-03f, -5.21743819e-02f, 2.77459621e-01f, 5.69360144e-02f, 1.94382697e-01f, 2.20602348e-01f, 9.33871642e-02f, 3.89540978e-02f, -3.60495225e-02f, 7.32273757e-02f,
  -3.26254308e-01f, 1.70124054e-01f, -8.52446929e-02f, 9.45967138e-02f, 1.62305295e-01f, 4.36767153e-02f, 3.27106491e-02f, 9.21164826e-02f, 1.57921556e-02f, 2.90454365e-03f,
  -1.70185298e-01f, 1.77113175e-01f, -4.95903194e-03f, -2.42270157e-02f, -6.52599009e-03f, -5.20182326e-02f, 4.12223250e-01f, 9.24535468e-02f, 2.12386042e-01f, 1.49001300e-01f,
  1.70761123e-01f, 9.37908143e-02f, -7.79998451e-02f, -4.54028808e-02f, -7.12577924e-02f, 1.42802194e-01f, 1.01056457e-01f, 1.47030115e-01f, 1.07026629e-01f, -9.63346660e-02f,
  -1.97938038e-03f, 8.80912468e-02f, -1.24467783e-01f, 1.20970145e-01f, 2.37541184e-01f, 1.12112679e-01f, 2.07672492e-01f, -1.82434276e-01f, -4.21443060e-02f, 1.42058328e-01f,
  8.52874145e-02f, 2.84022301e-01f, 1.52120784e-01f, 6.35843500e-02f, 1.11161590e-01f, 9.10006985e-02f, 1.11558370e-01f, 2.24899039e-01f, 2.21377194e-01f, -3.06464806e-02f,
  1.33219846e-02f, -1.03237532e-01f, 4.60691825e-02f, 2.95632929e-01f, -7.75024993e-03f, -2.26735547e-01f, 2.84218192e-02f, 1.14241183e-01f, 8.42391029e-02f, -1.01731410e-02f,
  5.19067794e-02f, 1.18052140e-01f, 5.76855429e-02f, -3.09795961e-02f, -9.78567377e-02f, -2.33125418e-01f, 1.86674744e-01f, 5.58756553e-02f, -9.41066891e-02f, -1.18802913e-01f,
  2.04095468e-01f, -4.21846844e-02f, 9.71274003e-02f, 1.60135075e-01f, -3.62094007e-02f, 2.01311279e-02f, 1.62319541e-01f, 7.21188337e-02f, 4.75739641e-03f, 7.94352293e-02f,
  -2.05630481e-01f, 1.95638359e-01f, 1.56740457e-01f, -9.17136222e-02f, -5.83180673e-02f, -1.95227280e-01f, 8.95161834e-03f, 1.34306133e-01f, 7.23667536e-03f, 4.33284901e-02f,
  -1.63813904e-02f, 2.32227623e-01f, -1.18958175e-01f, 1.56598747e-01f, 3.94447781e-02f, 8.94166753e-02f, 1.50315031e-01f, -6.85890093e-02f, -1.04127802e-01f, -7.96139240e-02f,
  -5.35201281e-02f, 2.33836308e-01f, 1.29102115e-02f, 1.15855113e-01f, -3.52423713e-02f, -1.39001504e-01f, 1.67471498e-01f, 1.40386388e-01f, 4.40985896e-02f, -6.09322935e-02f,
  -3.64530645e-02f, 1.58076778e-01f, -9.70525518e-02f, 2.24905852e-02f, 1.03109710e-01f, 1.07017465e-01f, -3.63562368e-02f, 5.23560755e-02f, -1.51615888e-01f, -1.28767022e-03f,
  -1.25657478e-02f, -3.46065052e-02f, 1.83241904e-01f, 7.94692338e-02f, 1.16720952e-01f, -4.34814356e-02f, 1.51398689e-01f, -6.34667417e-03f, -8.89367983e-03f, -3.69884335e-02f,
  -1.73084721e-01f, 2.65546385e-02f, 4.70030606e-02f, 1.75802425e-01f, 8.69084969e-02f, 5.61009673e-03f, -5.33547737e-02f, -3.84128764e-02f, 1.02643937e-01f, 9.82673839e-02f,
  -6.77189007e-02f, -1.07254079e-02f, -8.50705206e-02f, -4.95202169e-02f, -5.79791889e-02f, 9.45493206e-02f, 3.34980525e-02f, 8.23174641e-02f, -2.04850566e-02f, 1.77825820e-02f,
  -1.54869417e-02f, -7.43237659e-02f, -1.11622915e-01f, 4.78956364e-02f, -1.03074446e-01f, -8.81061703e-02f, 2.10071966e-01f, 2.89699174e-02f, -9.14495736e-02f, -6.31093234e-02f,
  1.00599423e-01f, -7.19430670e-02f, 2.04716679e-02f, 5.97449988e-02f, 1.59335300e-01f, -1.03146084e-01f, 8.30987766e-02f, 1.72573794e-02f, -3.20157618e-03f, 9.96767208e-02f,
  -8.37043300e-02f, -1.09987944e-01f, -7.88225308e-02f, -6.88252077e-02f, 1.53595611e-01f, -5.60802445e-02f, 2.89589260e-02f, -7.75949135e-02f, -4.75144573e-02f, 1.25144362e-01f,
  9.12835672e-02f, 5.62664866e-02f, 4.63642590e-02f, -3.91294882e-02f, 7.83679560e-02f, 6.54563159e-02f, -5.42623326e-02f, -1.05617322e-01f, -1.27818316e-01f, -7.95884430e-02f,
  7.24025965e-02f, -1.11341290e-01f, -9.21501312e-03f, -8.36882461e-03f, 8.22335184e-02f, -1.08721673e-01f, -7.83643648e-02f, 4.64279465e-02f, 1.02844164e-02f, -1.12518884e-01f,
  -1.05438232e-01f, -1.45081831e-02f, 6.59923255e-02f, -7.05192145e-03f, 1.11255430e-01f, 8.90778825e-02f, -2.32760794e-02f, 6.21247627e-02f, -1.12238213e-01f, -8.22376981e-02f,
  -8.99691507e-02f, 2.89307069e-02f, 3.92922275e-02f, 4.32853438e-02f, -5.65397926e-02f, 7.70279989e-02f, -1.00978956e-01f, -1.40489405e-02f, -1.66072454e-02f, -7.60458782e-02f,
  -7.50346715e-03f, -6.74774721e-02f, -7.71626383e-02f, -9.28685665e-02f, 8.10004622e-02f, 1.79997087e-03f, -2.07479410e-02f, -1.16859682e-01f, -9.68446434e-02f, 1.06529128e-02f,
  8.21712315e-02f, -5.31213321e-02f, 9.60285738e-02f, -1.75216347e-02f, -6.57162070e-02f, 4.52148281e-02f, -5.31732738e-02f, 1.07799619e-02f, -4.20049615e-02f, -6.41467422e-02f,
  -7.17411414e-02f, 9.62507054e-02f, 2.19959430e-02f, -8.71124789e-02f, -8.33107308e-02f, -9.55414250e-02f, -6.37311721e-03f, 8.44006836e-02f, -5.66019528e-02f, -9.17961299e-02f,
  -1.55662954e-01f, 1.75142977e-02f, -9.16435197e-02f, -1.08691985e-02f, -2.48559743e-01f, 3.55514139e-02f, -6.26082793e-02f, -1.31386533e-01f, -5.85931651e-02f, -2.43562266e-01f,
  -1.20344892e-01f, 1.06288739e-01f, -1.26135364e-01f, -1.01918489e-01f, 6.49053752e-02f, -1.03342794e-01f, 4.17258851e-02f, 2.35722121e-02f, -4.75267395e-02f, 1.15843579e-01f,
  3.14221345e-02f, 1.20363243e-01f, -7.67013729e-02f, 9.91150215e-02f, 5.19037507e-02f, -2.79040001e-02f, -1.06767952e-01f, 2.63001770e-01f, -9.76024494e-02f, 2.60899477e-02f,
  2.08709817e-02f, -7.68934786e-02f, 2.25719381e-02f, 2.50383735e-01f, 2.54927650e-02f, 1.19424034e-02f, 1.82397328e-02f, 9.25690979e-02f, 2.17735589e-01f, 3.76321771e-03f,
  -1.78758465e-02f, 8.07259418e-03f, 2.83268988e-01f, 1.65603328e-02f, 1.15363434e-01f, 1.75541639e-01f, 1.37585938e-01f, 8.97044688e-02f, 1.20410815e-01f, -1.09650567e-01f,
  5.64455502e-02f, 2.91837882e-02f, 1.35515794e-01f, 2.73888018e-02f, 1.46246970e-01f, 1.53567448e-01f, 2.42909603e-02f, -3.97310965e-02f, 8.87697414e-02f, 2.98634861e-02f,
  -2.75866222e-02f, -2.41096113e-02f, -4.68227714e-02f, 1.87281948e-02f, 7.43092969e-02f, 4.26290594e-02f, 8.37087110e-02f, -7.44820014e-02f, 1.13040999e-01f, 7.99964368e-02f,
  -2.14549638e-02f, 8.89910832e-02f, 2.72370055e-02f, 1.88194506e-03f, 2.13510338e-02f, 3.11629511e-02f, 2.76220273e-02f, 8.99055600e-02f, 8.94584879e-02f, -8.33616480e-02f,
  5.37271313e-02f, -5.65155037e-02f, 1.03704035e-02f, -8.74459520e-02f, -7.70196840e-02f, -2.53379587e-02f, 3.94176878e-02f, -1.13753833e-01f, -9.63262618e-02f, 2.89828167e-03f,
  -6.17553219e-02f, -1.21530667e-01f, 1.21871486e-01f, 3.35853919e-02f, -1.08633399e-01f, -8.09603408e-02f, -7.99857974e-02f, 1.41136929e-01f, 3.17062326e-02f, 4.98374477e-02f,
  4.21653688e-02f, -1.08978271e-01f, -8.17035884e-02f, -1.14228480e-01f, 5.38833588e-02f, -2.07644403e-02f, -9.77315754e-02f, 2.05921121e-02f, -7.50136226e-02f, -5.67412637e-02f,
  2.36294195e-02f, 1.22458935e-01f, -8.73831809e-02f, 1.69284105e-01f, -7.94027653e-03f, -3.99922132e-02f, -8.83846655e-02f, 1.56119853e-01f, 1.38318971e-01f, -4.93776388e-02f,
  -7.08286092e-02f, -4.95587066e-02f, -4.61419523e-02f, -1.62855312e-02f, -4.38467376e-02f, 2.30105631e-02f, 1.49645105e-01f, 9.54068676e-02f, 1.50819644e-01f, 3.17911655e-01f,
  1.54510513e-01f, 1.72918677e-01f, -1.70659527e-01f, 1.90898284e-01f, -3.51468623e-01f, -9.53607932e-02f, -3.85016762e-02f, -1.27235753e-02f, -4.79732640e-03f, -3.32555398e-02f,
  -1.07308172e-01f, 2.88835652e-02f, -1.92018688e-01f, -5.08478098e-03f, -2.63298042e-02f, 7.35407397e-02f, -5.67967631e-02f, -1.60539970e-01f, -4.62413877e-02f, -3.75268795e-02f,
  1.72497958e-01f, 2.80802548e-01f, -1.39620170e-01f, 1.34285435e-01f, -1.97155308e-02f, 1.06794097e-01f, -6.67161942e-02f, 9.03591514e-02f, -1.52052924e-01f, -1.46107465e-01f,
  3.12868282e-02f, 2.08006218e-01f, 2.58876413e-01f, -6.17055260e-02f, 1.32528663e-01f, -3.83000560e-02f, 5.70860542e-02f, -7.08693936e-02f, 1.46498978e-01f, 1.87519267e-01f,
  1.98438503e-02f, -6.19357191e-02f, 1.31288558e-01f, 2.12260976e-01f, -4.89094965e-02f, 1.03029989e-01f, 2.38699913e-01f, 2.06659824e-01f, 4.92566228e-02f, -1.34565473e-01f,
  7.91269392e-02f, 1.31646320e-01f, 1.57319561e-01f, -1.48760647e-01f, 5.79189621e-02f, 1.81097776e-01f, 8.12546760e-02f, 1.04784079e-01f, -2.70877499e-02f, 1.53371111e-01f,
  -5.76555803e-02f, -5.21075651e-02f, 3.57263931e-03f, 3.85603681e-02f, -1.27600744e-01f, 4.35367078e-02f, -3.06503251e-02f, 4.65918183e-02f, -1.00425906e-01f, -7.51812384e-02f,
  7.93545917e-02f, 7.27649173e-03f, 1.37271926e-01f, 8.88699442e-02f, -1.39120847e-01f, -1.19996918e-02f, -6.70288652e-02f, -8.15833434e-02f, -1.27090603e-01f, 4.72865440e-02f,
  -7.88666084e-02f, 7.70893842e-02f, 1.26239732e-01f, -1.13566794e-01f, 5.60225956e-02f, -7.46519342e-02f, 5.58061861e-02f, -4.53581065e-02f, -6.95012882e-02f, 1.71069168e-02f,
  8.96766707e-02f, -8.72804318e-04f, -9.22993720e-02f, 7.67645910e-02f, 1.37350000e-02f, -2.82220114e-02f, -6.13188632e-02f, 1.11273639e-02f, 9.06134248e-02f, 7.42632300e-02f,
  1.14258587e-01f, 1.36897951e-01f, -1.80938113e-02f, 3.99062000e-02f, 2.88768589e-01f, -3.45842051e-03f, 5.93106002e-02f, -9.95873883e-02f, 3.27286646e-02f, 3.85897979e-02f,
  -1.34998532e-02f, -7.93993473e-02f, -9.23350379e-02f, -9.43254530e-02f, 1.43618315e-01f, -1.94568504e-02f, 1.21032350e-01f, 1.13986515e-01f, -1.25389011e-03f, -8.57150555e-02f,
  8.50744992e-02f, 6.06623478e-02f, -1.58561673e-02f, -4.61048074e-02f, -6.45331442e-02f, 1.25312790e-01f, -9.44639146e-02f, -5.33322021e-02f, 4.34000827e-02f, 1.48141101e-01f,
  1.53179511e-01f, -2.23800316e-01f, 3.72978657e-01f, 5.43687157e-02f, 8.62549990e-02f, -1.65818334e-02f, -4.13231999e-02f, -8.65903571e-02f, 7.59590790e-02f, 1.35929674e-01f,
  -1.44327348e-02f, 1.37635008e-01f, 2.59592175e-03f, 8.88089538e-02f, 2.03399062e-02f, 1.44280583e-01f, 2.24624529e-01f, 1.30466580e-01f, -2.00828887e-03f, -1.34377390e-01f,
  1.77200109e-01f, -5.92387095e-02f, 1.62517548e-01f, -4.24282812e-02f, -8.20296779e-02f, 8.86217803e-02f, 2.17827708e-02f, 1.92431763e-01f, -1.13086224e-01f, -3.94388884e-02f,
  -1.57246221e-04f, 9.79782455e-03f, -1.01700038e-01f, 8.12107399e-02f, 2.26939879e-02f, 2.49941237e-02f, -1.46848261e-01f, 1.00807540e-01f, 1.54496850e-02f, -7.17967227e-02f,
  -7.12978616e-02f, 6.32449314e-02f, -5.18607982e-02f, 7.93400332e-02f, -5.31291291e-02f, -4.48126998e-03f, 3.81996781e-02f, 4.91318479e-02f, -5.85736334e-02f, -3.10339183e-02f,
  3.66099253e-02f, 1.15761466e-01f, 9.20867920e-02f, 1.18394993e-01f, 1.71320215e-01f, -6.36479855e-02f, 2.67172396e-01f, -3.72519046e-02f, 7.30780512e-02f, -7.49256462e-02f,
  -1.08801961e-01f, -6.18938096e-02f, 7.75995031e-02f, -1.22372761e-01f, 3.48552242e-02f, 1.13537975e-01f, -8.21876377e-02f, 2.39823554e-02f, 3.42857018e-02f, -6.10102601e-02f,
  -1.12373002e-01f, 4.72387373e-02f, 7.95177668e-02f, -2.77252421e-02f, -1.11416310e-01f, -1.20334446e-01f, -5.90964854e-02f, -7.27169514e-02f, 6.63828403e-02f, -8.17803442e-02f,
  -7.75175244e-02f, 2.88501251e-02f, -7.13029131e-02f, -1.91688985e-02f, -6.98635057e-02f, -1.28514105e-02f, 8.08752403e-02f, 2.99098194e-02f, 1.33225452e-02f, -5.57537191e-02f,
  1.73448492e-02f, 1.07321732e-01f, 3.13870460e-02f, -6.77743787e-03f, -6.60121739e-02f, 9.38898548e-02f, 4.94167432e-02f, -1.30499348e-01f, -1.12767719e-01f, 7.16191530e-02f,
  -1.19581439e-01f, 5.89547232e-02f, 9.22034755e-02f, -7.71395862e-03f, -4.89246882e-02f, -1.10945478e-01f, -2.64105015e-02f, 1.20290399e-01f, -1.16896875e-01f, -2.63699200e-02f,
  -3.54687907e-02f, -3.68993506e-02f, 5.37258899e-03f, -9.55179855e-02f, -3.07821687e-02f, 9.01958942e-02f, 8.08334723e-03f, 6.44645914e-02f, 6.67523444e-02f, -1.82869043e-02f,
  1.13421850e-01f, -3.82728502e-03f, 1.53722078e-01f, -3.14598493e-02f, 5.69643080e-02f, 1.54132590e-01f, 1.05164252e-01f, -1.10985927e-01f, -5.58696641e-03f, 7.77643993e-02f,
  2.21796706e-01f, 6.48107454e-02f, -2.44330466e-01f, -8.02091435e-02f, 5.07837646e-02f, 7.42731690e-02f, -1.21086137e-02f, 1.38459757e-01f, 1.87061220e-01f, -9.12710875e-02f,
  9.00389031e-02f, 1.06410578e-01f, 2.85546221e-02f, 1.37044191e-01f, -5.90725280e-02f, 2.70910431e-02f, -3.29788285e-03f, 5.07881679e-02f, -7.59156793e-02f, -9.54851508e-02f,
  -1.07189320e-01f, -5.00456207e-02f, -2.62230597e-02f, 9.39529985e-02f, 4.05546539e-02f, -6.28244597e-03f, -1.29492089e-01f, -3.70369554e-02f, -4.68165837e-02f, 2.19818085e-01f,
  -3.18719037e-02f, 4.55149412e-02f, -7.34637911e-03f, 4.84188125e-02f, -1.16499243e-02f, -5.29657230e-02f, 3.08381706e-01f, 1.16818212e-01f, 3.14429812e-02f, 7.89222308e-03f,
  -4.83013205e-02f, 9.81553346e-02f, -1.09354563e-01f, -1.79443076e-01f, 1.00760028e-01f, -8.28853399e-02f, 5.07643968e-02f, -7.24249557e-02f, 1.67997301e-01f, 1.24253757e-01f,
  7.35501572e-02f, -7.74077922e-02f, -5.92286736e-02f, 7.10328519e-02f, 1.31518528e-01f, 5.92197059e-04f, 2.89942116e-01f, -4.96599674e-02f, 3.73969406e-01f, 2.62840748e-01f,
  3.87065917e-01f, 3.04678436e-02f, -8.80217403e-02f, 3.72188389e-01f, 1.70515776e-01f, -1.46283492e-01f, -3.62112194e-01f, 5.98711409e-02f, 1.44916251e-01f, 1.13778181e-01f,
  1.28596351e-01f, 1.34100482e-01f, 9.32680443e-02f, -2.10569836e-02f, 2.29417190e-01f, 9.67401117e-02f, 1.13243409e-01f, 9.31909599e-04f, -2.59952601e-02f, -1.41749561e-01f,
  1.63179487e-01f, -1.32779330e-02f, 1.32753998e-01f, 7.83917010e-02f, -5.26787229e-02f, -1.87940955e-01f, 1.63989469e-01f, -1.85651407e-02f, 1.30373195e-01f, -4.69958596e-02f,
  -3.55728380e-02f, -1.96379066e-01f, -3.24778557e-02f, 2.61970758e-01f, 6.19890653e-02f, 1.44284844e-01f, 1.11747898e-01f, 1.54593840e-01f, 2.98281580e-01f, 1.82974264e-01f,
  3.36427614e-02f, 4.75763381e-01f, 9.96437967e-02f, -1.12900808e-01f, 1.68850020e-01f, 2.20317114e-03f, 9.81473178e-02f, -3.83783840e-02f, 2.09436730e-01f, -2.55560111e-02f,
  8.85110945e-02f, -9.89072472e-02f, -1.78185329e-02f, -1.36725707e-02f, 7.76850358e-02f, 4.96165175e-03f, -1.17579520e-01f, -1.27702072e-01f, 3.77434827e-02f, -7.77808875e-02f,
  1.25151962e-01f, 8.92533213e-02f, -1.35568872e-01f, 2.87107229e-02f, 5.43029001e-03f, 2.30627134e-02f, 1.06223799e-01f, -7.86283538e-02f, -3.79368514e-02f, 1.18043274e-01f,
  1.42622694e-01f, 2.12630928e-01f, 5.54739833e-02f, -7.56009668e-02f, 1.24312848e-01f, 7.80260935e-02f, 2.76160818e-02f, 1.22502260e-01f, -3.07630617e-02f, 7.74776712e-02f,
  1.12977490e-01f, 3.12220678e-02f, 2.08390385e-01f, -3.25383879e-02f, 1.57970622e-01f, 1.39478460e-01f, 1.66588217e-01f, -7.68723264e-02f, 1.57842096e-02f, 9.85785946e-02f,
  3.61751467e-02f, 3.27895582e-02f, 9.68453288e-02f, 1.93900958e-01f, -9.81427357e-03f, 4.25306633e-02f, -2.20691841e-02f, -1.25079453e-01f, -1.48383593e-02f, 5.92480339e-02f,
  4.06585373e-02f, -9.49384719e-02f, -3.18282582e-02f, 9.24486741e-02f, -6.89987913e-02f, -1.27721339e-01f, 9.06268582e-02f, 9.85415652e-02f, -1.16564929e-01f, -1.73793342e-02f,
  -6.33739904e-02f, -6.52553439e-02f, -1.21276826e-01f, -8.08229595e-02f, -6.37593418e-02f, -6.00953167e-03f, 8.47486332e-02f, 6.69582142e-03f, 1.93507493e-01f, 2.30001256e-01f,
  -1.98857319e-02f, 4.62145135e-02f, 1.52351916e-01f, 1.88566864e-01f, 3.47472429e-02f, -6.57506660e-02f, 8.37192833e-02f, -2.70644389e-03f, 4.53208853e-03f, 1.22794390e-01f,
  -2.28036463e-01f, 1.97550267e-01f, -2.21054722e-02f, -3.79445218e-02f, -1.48251384e-01f, -1.54044002e-01f, 1.90626651e-01f, -6.54514581e-02f, -4.68812585e-02f, -1.46736309e-01f,
  1.54830709e-01f, -1.41282603e-02f, 1.08466502e-02f, 9.74973887e-02f, -2.08328795e-02f, -6.91316426e-02f, 1.16784722e-01f, 1.02555722e-01f, 1.28450677e-01f, -1.26942527e-02f,
  1.96218908e-01f, -9.57057327e-02f, 4.46746759e-02f, -1.33420438e-01f, -1.28305564e-02f, -7.42364824e-02f, 2.39536706e-02f, 1.33234009e-01f, 3.70093174e-02f, 3.24704796e-02f,
  -1.32238358e-01f, 7.67541081e-02f, 5.55582903e-02f, 7.78799057e-02f, 1.78276971e-01f, 4.21731919e-02f, 1.41897246e-01f, -2.80348584e-02f, 2.86890030e-01f, -2.78492924e-02f,
  2.20708456e-02f, -1.21820480e-01f, 1.75803825e-01f, 1.79902360e-01f, -7.89559335e-02f, -7.12538138e-02f, -5.30367531e-02f, 1.19918793e-01f, -6.10643215e-02f, 6.76770806e-02f,
  -4.54383232e-02f, 1.70443386e-01f, -5.80841070e-03f, 4.00712043e-02f, -8.92686173e-02f, -3.29711325e-02f, -9.40890163e-02f, -4.45680991e-02f, -1.07148856e-01f, 1.13739856e-01f,
  8.81282985e-02f, 6.73950510e-03f, 5.91090880e-02f, 1.32306531e-01f, 2.50199009e-02f, -6.39902195e-03f, -4.95094955e-02f, -3.95118117e-01f, 5.94849773e-02f, -9.27576572e-02f,
  -1.26137167e-01f, 7.33489841e-02f, -9.50678214e-02f, -1.51629016e-01f, 1.33437917e-01f, -1.05426751e-01f, 1.10748142e-01f, -1.84545424e-02f, 5.86344637e-02f, 5.82976900e-02f,
  -9.58921239e-02f, -8.16731062e-03f, -7.53822699e-02f, 1.01037256e-01f, 1.06895596e-01f, 1.34932131e-01f, -3.89414579e-02f, 5.84302135e-02f, 1.31967500e-01f, -9.65151638e-02f,
  5.26206419e-02f, 9.40616727e-02f, -4.53295037e-02f, -2.78560109e-02f, 2.01173991e-01f, 1.89369678e-01f, -3.53088346e-03f, 1.88860632e-02f, 2.40617380e-01f, 1.92383587e-01f,
  2.70509068e-02f, -1.26112103e-01f, -1.33702550e-02f, 4.00281280e-01f, 8.58091041e-02f, 1.28121629e-01f, -5.04791252e-02f, -1.77129030e-01f, 9.44519341e-02f, -7.71815181e-02f,
  9.94511917e-02f, 4.34523299e-02f, 6.95622042e-02f, 2.97786500e-02f, 7.97842816e-02f, 1.55886531e-01f, 2.74943024e-01f, -4.53712605e-03f, -6.04765825e-02f, -3.91388424e-02f,
  3.75483483e-02f, 1.49665281e-01f, -1.29489722e-02f, -7.77002648e-02f, 9.87481996e-02f, -1.13702277e-02f, 1.58762351e-01f, 5.36451824e-02f, 2.23530885e-02f, 1.26202658e-01f,
  1.18878990e-01f, 3.26708779e-02f, 1.00526892e-01f, 1.50473509e-02f, 1.65606007e-01f, -6.88741878e-02f, -8.88009667e-02f, 4.34371121e-02f, 1.71785336e-02f, 1.07851304e-01f,
  -1.49249174e-02f, 1.25540078e-01f, 2.59849206e-02f, -3.54257785e-02f, -1.64641663e-02f, 6.26728758e-02f, -1.28384471e-01f, 7.15646297e-02f, 7.58987069e-02f, 4.06858586e-02f,
  1.68654174e-01f, -9.81526151e-02f, -1.22034267e-01f, -4.25760001e-02f, -3.01133711e-02f, 3.96623858e-04f, 8.58224407e-02f, -4.82578799e-02f, 2.56117564e-02f, 2.32761875e-01f,
  1.42425718e-02f, -2.54851673e-02f, -6.11044280e-02f, -8.60776082e-02f, 1.20770507e-01f, -7.05913305e-02f, 2.14720041e-01f, -8.31330568e-02f, -2.24861242e-02f, 4.08483716e-03f,
  1.20770082e-01f, 1.41205534e-01f, -9.18556154e-02f, -5.23029752e-02f, 3.31602879e-02f, 1.82477403e-02f, 1.59830868e-01f, -8.62590596e-02f, -8.28327537e-02f, -1.09363124e-02f,
  -3.74454372e-02f, -9.91721228e-02f, -4.35210317e-02f, -7.93522075e-02f, -1.04136385e-01f, -9.44887772e-02f, -2.93188300e-02f, 6.46791011e-02f, -6.06389940e-02f, -1.07887931e-01f,
  6.92757079e-03f, 1.67460516e-01f, -4.85761836e-02f, -3.42017561e-02f, 1.95218965e-01f, 1.90874264e-02f, 1.10586852e-01f, -5.68705276e-02f, 3.81137989e-02f, -8.27185214e-02f,
  -9.18859616e-02f, 6.05490915e-02f, 1.99547634e-02f, 9.82505009e-02f, -6.70781210e-02f, 6.04268722e-02f, 5.24516702e-02f, -9.02062207e-02f, -3.03591304e-02f, 1.51857048e-01f,
  1.63586047e-02f, 9.05484483e-02f, 9.65491217e-03f, 1.71752572e-02f, -9.08040330e-02f, 1.23230860e-01f, 6.64818361e-02f, 2.28236206e-02f, -4.75587882e-02f, -1.34335607e-01f,
  3.96982804e-02f, -2.59482041e-02f, 1.51109412e-01f, 6.64635450e-02f, 9.58514512e-02f, -5.37630124e-03f, 9.34927724e-03f, 9.11775082e-02f, -1.46009192e-01f, -8.78697559e-02f,
  6.35110959e-02f, 4.70219590e-02f, 5.57995960e-02f, 1.44595459e-01f, -8.21519420e-02f, -1.24382913e-01f, -3.57730053e-02f, 2.19924189e-02f, -1.51579846e-02f, -2.43540704e-02f,
  -1.00847408e-01f, 3.37675139e-02f, 9.13445577e-02f, 1.52722627e-01f, 1.00826152e-01f, 2.21184656e-01f, 1.08252637e-01f, 5.97378761e-02f, -2.48013716e-02f, 1.57380581e-01f,
  -8.44769031e-02f, -6.37029577e-03f, 4.03276756e-02f, -1.46875223e-02f, 2.11895742e-02f, 5.90908341e-02f, 8.59715864e-02f, -8.24302137e-02f, 7.91272372e-02f, -9.81412977e-02f,
  -4.75441404e-02f, -1.05921112e-01f, 3.78022678e-02f, 5.09237759e-02f, -6.62231743e-02f, -8.70849639e-02f, 4.69693419e-04f, -7.85723925e-02f, 1.22061118e-01f, 1.47025974e-03f,
  -1.06705584e-01f, 1.06262647e-01f, 1.63027346e-02f, -6.84432164e-02f, -7.28254020e-02f, 1.04948990e-01f, 5.69593683e-02f, -8.49189684e-02f, 7.72368014e-02f, 8.59017391e-03f,
  6.32977113e-02f, -8.54138732e-02f, 1.26827080e-02f, -1.01543032e-01f, 5.33185415e-02f, -1.07934363e-01f, -8.19122642e-02f, -4.87972833e-02f, -1.24753535e-01f, -1.14550896e-01f,
  1.09423138e-02f, 3.70275192e-02f, 9.74194147e-03f, 7.65675446e-03f, -3.43635380e-02f, -9.84006003e-02f, 6.60429671e-02f, -4.95719835e-02f, -1.23676062e-01f, -6.87478781e-02f,
  -4.51403596e-02f, -1.13306738e-01f, 2.35368088e-02f, 1.08493611e-01f, 1.09257556e-01f, 4.57844473e-02f, 7.47373551e-02f, -9.42681730e-03f, -1.82025917e-02f, -1.43427402e-02f,
  -6.79888129e-02f, -9.17964205e-02f, -9.13044959e-02f, 9.92797688e-03f, 1.91350114e-02f, -5.60333617e-02f, -3.83500643e-02f, 6.87338561e-02f, 1.79807141e-01f, -1.33399488e-02f,
  -8.29314161e-03f, 7.06776455e-02f, -1.05689324e-01f, 1.65521145e-01f, -1.14738308e-01f, -1.03182225e-02f, 8.52696598e-02f, 6.99492171e-02f, 9.06901062e-02f, -2.76754368e-02f,
  5.52055351e-02f, -1.08551607e-02f, -2.75636371e-02f, 1.42468333e-01f, -3.68351042e-02f, 6.27579913e-02f, -7.92211667e-02f, -6.76773069e-03f, 2.49344751e-01f, 4.35031112e-03f,
  -4.74481955e-02f, 1.12097904e-01f, -4.14794348e-02f, -8.41850489e-02f, 6.96750656e-02f, 5.41094365e-03f, -3.16629652e-03f, -1.03037633e-01f, 4.98748720e-02f, -1.05707444e-01f,
  -9.82719958e-02f, -4.58013415e-02f, 5.54674305e-02f, 9.84845683e-02f, -1.08509727e-01f, -1.17895730e-01f, 1.04884930e-01f, 4.03524376e-02f, -4.91139814e-02f, -1.11125045e-01f,
  -3.69602181e-02f, -6.36034831e-02f, -1.05307192e-01f, -1.34200919e-02f, -3.04507501e-02f, 1.01130577e-02f, 9.01949555e-02f, 8.40700045e-02f, -1.24163926e-01f, -1.20433299e-02f,
  -5.36886156e-02f, 7.17295259e-02f, 1.14065476e-01f, -6.21147417e-02f, 7.22219199e-02f, 1.94353789e-01f, 3.55843641e-02f, -1.47129923e-01f, -5.16420938e-02f, 5.50606027e-02f,
  -8.32135752e-02f, -4.42768633e-02f, 3.47321527e-03f, 1.01610489e-01f, 7.03118835e-03f, 5.23144491e-02f, -9.54580382e-02f, 9.42399055e-02f, -1.00993067e-01f, 1.08609818e-01f,
  -5.20941727e-02f, 5.59110865e-02f, -1.08428255e-01f, 8.85395147e-03f, -7.41275102e-02f, 1.07528470e-01f, 9.18816552e-02f, 1.05656669e-01f, -9.44731981e-02f, 3.02884560e-02f,
  8.02845806e-02f, -1.18295923e-01f, 1.93895132e-03f, -4.21793126e-02f, -1.47148237e-01f, -2.94339918e-02f, -8.13870057e-02f, 1.47867113e-01f, -1.14840344e-01f, -1.12154007e-01f,
  -1.28139049e-01f, 1.07567258e-01f, 4.65772562e-02f, -1.73375867e-02f, -1.96458641e-02f, 8.08797255e-02f, -7.17684701e-02f, 1.17069922e-01f, 1.64215453e-02f, 1.18048534e-01f,
  3.86080816e-02f, 1.36172175e-02f, -8.70782509e-02f, -3.65746319e-02f, -5.18663265e-02f, 2.32007485e-02f, -6.70116916e-02f, 1.68003850e-02f, -7.43448958e-02f, -1.01209730e-02f,
  1.32268876e-01f, -6.45780340e-02f, -9.76342186e-02f, 1.73006997e-01f, 9.60656777e-02f, 1.33838221e-01f, -4.59326319e-02f, -7.54518211e-02f, 6.90348595e-02f, 1.66588381e-01f,
  7.90932029e-02f, -4.22781892e-02f, 1.47228986e-01f, 1.82442784e-01f, 7.44156763e-02f, 1.80153713e-01f, 1.27286911e-01f, 2.87601203e-01f, 2.65967101e-01f, -6.74990937e-02f,
  1.40432447e-01f, 8.81513115e-04f, 3.11585397e-01f, -1.14297450e-01f, -1.23727806e-01f, 3.48586440e-02f, -1.05902210e-01f, -5.72192948e-04f, 1.94579363e-02f, -6.67741671e-02f,
  1.85288250e-01f, -7.70374760e-02f, 9.31928530e-02f, 2.74727810e-02f, -1.12209275e-01f, 1.48879111e-01f, -1.57444015e-01f, 2.37538651e-01f, 5.14773466e-02f, -5.78529797e-02f,
  1.22061446e-01f, -1.55862823e-01f, -1.25957415e-01f, 1.23282827e-01f, 1.73780426e-01f, -8.37822855e-02f, -1.07969977e-01f, 3.67607847e-02f, 7.30516016e-02f, 2.01384947e-01f,
  -1.75207984e-02f, 1.41383680e-02f, -4.16189209e-02f, 7.09476098e-02f, 3.12753692e-02f, 8.04682970e-02f, -1.61432967e-01f, -1.78817242e-01f, -1.03358157e-01f, 5.93859255e-02f,
  -3.09461933e-02f, -1.42701015e-01f, 1.00276312e-02f, -7.22766891e-02f, 6.11224677e-03f, -1.06172554e-01f, 1.13135971e-01f, -2.23416671e-01f, 1.00373521e-01f, 7.84579441e-02f,
  1.81610629e-01f, 3.09216380e-01f, 9.42972153e-02f, 9.55214351e-02f, 2.00036556e-01f, 1.41837046e-01f, -3.76983956e-02f, -9.47173014e-02f, -1.06089965e-01f, -4.29564118e-02f,
  -1.78729394e-03f, -3.10499780e-03f, -1.02254763e-01f, 2.70534977e-02f, 1.87141165e-01f, -4.86980304e-02f, 9.64346230e-02f, 4.01645713e-02f, -1.13973916e-01f, -9.32988822e-02f,
  4.92278337e-02f, 1.24181576e-01f, -1.29574716e-01f, -7.39920884e-02f, 1.37088180e-01f, 8.01414028e-02f, -5.29132895e-02f, -6.10329956e-02f, 1.77799284e-01f, 6.09490052e-02f,
  -3.72501537e-02f, -3.46708819e-02f, -1.36140846e-02f, -7.89744034e-02f, 3.79235111e-02f, 3.61080393e-02f, 1.34985161e-03f, 1.29610911e-01f, 4.84269150e-02f, 7.35796914e-02f,
  3.26352529e-02f, 1.00128520e-02f, -1.29968241e-01f, 1.55992284e-01f, -9.08553321e-03f, 3.79534066e-02f, -6.34144545e-02f, -5.69240488e-02f, -7.04949126e-02f, 6.65777922e-02f,
  -9.13083786e-04f, 1.19612515e-01f, 6.41501602e-03f, 4.06763442e-02f, 8.48948732e-02f, 5.46447746e-02f, 1.21993467e-01f, 3.93706150e-02f, -4.85613011e-02f, 8.19455609e-02f,
  3.74220014e-02f, -1.09277934e-01f, -2.49300934e-02f, 1.06028922e-01f, 9.96381417e-02f, -8.40359926e-02f, 9.50320512e-02f, -3.30408327e-02f, -6.41275123e-02f, -4.40222248e-02f,
  -8.51568580e-02f, -1.15865082e-01f, 8.35203379e-02f, -1.16786838e-03f, -1.07427992e-01f, 7.96172172e-02f, -5.14523461e-02f, -9.25189927e-02f, -1.44724637e-01f, 4.57123891e-02f,
  1.52999973e-02f, -1.25620127e-01f, 8.37473944e-03f, -1.07723214e-02f, 1.05993487e-01f, 6.09971583e-02f, -1.86042674e-02f, 7.96544328e-02f, -1.03289187e-01f, 9.46066380e-02f,
  -4.78452109e-02f, 2.21510101e-02f, -3.40090655e-02f, 9.47988406e-02f, 1.07052974e-01f, -1.06967397e-01f, 3.91507111e-02f, 7.47136697e-02f, -1.16371840e-01f, -9.77487117e-02f,
  3.32514495e-02f, -9.50945765e-02f, 4.21262272e-02f, -9.93415266e-02f, -6.03358708e-02f, -5.46072945e-02f, -4.40140665e-02f, 1.17950283e-01f, 7.05369702e-03f, 9.02823061e-02f,
  -1.16125114e-01f, -6.76590279e-02f, 6.27749711e-02f, 3.77054624e-02f, 1.43349215e-01f, 4.90189670e-03f, 1.22248538e-01f, 4.51370776e-02f, 3.33487652e-02f, 3.09293997e-02f,
  -4.44658883e-02f, 7.53911063e-02f, 4.76623914e-04f, -4.89019603e-02f, 9.79833007e-02f, 3.48012932e-02f, -5.21340072e-02f, -8.58200118e-02f, 1.09959833e-01f, -8.14657286e-02f,
  -4.75262329e-02f, -6.51461482e-02f, -6.79956824e-02f, -4.57855649e-02f, 2.46408746e-01f, 1.97074041e-01f, -5.86726144e-02f, 2.07783222e-01f, 3.53227258e-02f, 2.37710834e-01f,
  1.05230607e-01f, -1.62643597e-01f, -1.79932833e-01f, 3.13350827e-01f, 2.99781501e-01f, 5.83584607e-02f, 1.39772752e-02f, -8.36632028e-03f, -6.32011332e-03f, 1.86345980e-01f,
  1.32112429e-01f, 8.45713466e-02f, -1.21504933e-01f, -5.80601878e-02f, -9.52503532e-02f, -1.85941458e-02f, 1.12060048e-01f, 9.04162750e-02f, 1.36958137e-01f, 3.62852379e-03f,
  4.99258339e-02f, -1.17774770e-01f, 1.01300567e-01f, -7.46421441e-02f, -4.41221036e-02f, 1.52527783e-02f, 1.11745685e-01f, 2.71964632e-02f, 1.26727402e-01f, 6.51681647e-02f,
  5.46079017e-02f, 2.13224381e-01f, -5.80772050e-02f, -1.81058478e-02f, -4.85415682e-02f, -8.57977942e-02f, 1.98075309e-01f, 1.30021259e-01f, -1.05512261e-01f, -2.68646121e-01f,
  4.71921414e-02f, 6.99892789e-02f, -1.91277098e-02f, 1.88737944e-01f, -3.70944962e-02f, 2.54615396e-01f, -1.67052492e-01f, 4.13980894e-02f, 8.72938486e-04f, 3.48939151e-01f,
  4.98388298e-02f, 1.08561158e-01f, 7.24363998e-02f, 6.42277077e-02f, 2.60656953e-01f, 2.18287066e-01f, -1.45580107e-02f, -1.82068534e-02f, 2.51409989e-02f, -9.32807922e-02f,
  6.22774810e-02f, 7.78901577e-02f, -9.72236246e-02f, -7.02005103e-02f, -1.24942064e-01f, -8.06955770e-02f, -3.15295644e-02f, -7.81939328e-02f, -8.82170126e-02f, -1.98972169e-02f,
  -1.10003211e-01f, 1.86663195e-02f, 5.60814142e-02f, -1.30115256e-01f, 9.55118798e-03f, 9.24461633e-02f, -8.83992240e-02f, -9.83658656e-02f, -3.16329636e-02f, -9.96213704e-02f,
  8.28846619e-02f, -7.56491395e-03f, -6.39637485e-02f, 1.31303087e-01f, -1.01536818e-01f, 8.64087120e-02f, 1.79972220e-02f, 1.75562769e-01f, -1.06196187e-01f, 3.91196311e-02f,
  -9.31830555e-02f, 1.81526542e-02f, -5.87241501e-02f, 6.76053315e-02f, -7.10879117e-02f, 9.32243317e-02f, 4.94935736e-02f, -6.17665164e-02f, -8.02093884e-04f, -8.07405636e-02f,
  1.24371454e-01f, -1.73737537e-02f, -9.53186024e-03f, 1.44130215e-01f, 1.08156636e-01f, 1.38813863e-02f, -7.01983124e-02f, -9.01473612e-02f, 1.16427094e-01f, -1.13962013e-02f,
  -9.71222296e-02f, 6.86627403e-02f, -9.02039632e-02f, 6.76232129e-02f, -4.78215367e-02f, -5.61281741e-02f, -1.51242584e-03f, 4.94372891e-03f, -2.78613474e-02f, 1.16129234e-01f,
  -3.81131470e-02f, -7.82234222e-02f, 5.40637504e-03f, -5.79144359e-02f, 1.22090064e-01f, 1.36673972e-01f, -5.67639321e-02f, -4.61324602e-02f, 2.33573951e-02f, 4.82751504e-02f,
  -1.08923480e-01f, -1.55302420e-01f, -3.04762758e-02f, 2.04153033e-03f, -2.80510783e-02f, -5.56104667e-02f, 4.06727716e-02f, 4.54109013e-02f, -2.38583218e-02f, 2.12643966e-02f,
  4.32176469e-03f, -6.04715273e-02f, -7.34075531e-02f, 3.10117174e-02f, 5.64504322e-03f, 1.10994361e-01f, -3.20090838e-02f, 1.03883967e-02f, -1.77272186e-02f, 8.40806738e-02f,
  -1.64825879e-02f, -8.63204822e-02f, -8.45088512e-02f, -5.76997474e-02f, -1.05678275e-01f, 1.62185654e-01f, 1.19247034e-01f, -3.51202860e-02f, -7.94022828e-02f, -4.38227169e-02f,
  -5.48876077e-02f, -6.05263785e-02f, 5.51148206e-02f, 8.61013532e-02f, -2.20810827e-02f, 9.11418498e-02f, -3.82815078e-02f, -6.29506307e-03f, -2.41986010e-02f, 4.81508188e-02f,
  8.23108926e-02f, -8.83441642e-02f, -2.80236844e-02f, 9.15354043e-02f, 1.26360938e-01f, 2.52761412e-02f, 5.06556816e-02f, -7.48493820e-02f, -9.98296961e-02f, 3.01889628e-02f,
  3.33877355e-02f, 6.49883896e-02f, 1.31191701e-01f, -9.84193087e-02f, 2.37029120e-02f, -7.98797607e-02f, 5.81164062e-02f, -1.74943879e-02f, 2.43481323e-02f, -8.26651305e-02f,
  1.31808743e-01f, -8.89062434e-02f, 2.19083298e-03f, -2.71624569e-02f, 1.48618162e-01f, 1.79262027e-01f, 9.61225480e-03f, 1.76476419e-01f, 6.44111633e-02f, -9.02770087e-02f,
  1.41864985e-01f, 2.15990812e-01f, -7.69915245e-03f, 6.39181286e-02f, -1.43824279e-01f, -1.30120382e-01f, 1.53679416e-01f, -2.61265207e-02f, 2.01101333e-01f, 1.53936923e-01f,
  -8.95597786e-02f, -7.83862621e-02f, 2.20922768e-01f, 1.17965743e-01f, -2.70914510e-02f, 9.26206782e-02f, 7.99935833e-02f, -1.89986750e-02f, -4.65668514e-02f, 2.75328547e-01f,
  -1.56195769e-02f, -3.65673826e-04f, -1.52630448e-01f, -1.81796208e-01f, -2.13071592e-02f, 1.32196456e-01f, -6.35576546e-02f, 9.27921012e-03f, -9.07986537e-02f, -9.52772796e-02f,
  5.90098873e-02f, -5.77813387e-02f, 6.50994629e-02f, -5.94865084e-02f, 9.84051079e-02f, 1.20096423e-01f, -2.88246907e-02f, -7.96443075e-02f, 2.19350979e-02f, 8.60040262e-02f,
  -1.31377382e-02f, 1.00712098e-01f, -8.80285874e-02f, 6.11939430e-02f, 2.99146604e-02f, -6.81784516e-03f, 1.24379799e-01f, -4.21840325e-02f, 1.40849680e-01f, -8.55994448e-02f,
  1.11764260e-01f, -6.76768180e-03f, 1.05657019e-01f, 1.22234330e-01f, -4.67011929e-02f, -5.40007912e-02f, -1.24635117e-03f, -1.13580845e-01f, -4.97403815e-02f, 1.81259662e-01f,
  -2.50585581e-04f, -5.94161525e-02f, 6.51023015e-02f, 2.61120591e-02f, 1.49454936e-01f, 4.90149483e-02f, 9.05561745e-02f, 3.66742387e-02f, 4.28806767e-02f, -7.03177229e-02f,
  -1.28458649e-01f, 5.92693388e-02f, -3.92126143e-02f, 1.04201064e-01f, -9.80011374e-03f, -9.46416929e-02f, -8.01760480e-02f, -9.78562906e-02f, 5.38168126e-04f, -2.95489188e-02f,
  4.25265096e-02f, 1.12690970e-01f, -6.14897460e-02f, -1.12208165e-01f, 1.69783056e-01f, 9.60810557e-02f, -4.01650444e-02f, 1.71752840e-01f, 2.15251639e-01f, 1.08483300e-01f,
  -6.42480254e-02f, -3.59911434e-02f, 8.53477195e-02f, 1.47832260e-01f, -1.50319323e-01f, -1.09558657e-01f, 4.00025137e-02f, -3.15996483e-02f, 3.45174894e-02f, 6.78781839e-03f,
  -8.41671303e-02f, 1.41152859e-01f, -5.21449633e-02f, -6.48973882e-02f, 2.67395377e-02f, 3.82204413e-01f, 3.22039984e-02f, 5.81819825e-02f, -1.27783477e-01f, -3.79528552e-02f,
  9.23355594e-02f, 1.10404231e-01f, -4.62719463e-02f, 1.04341857e-01f, 1.01192415e-01f, -7.66932368e-02f, 9.77437571e-02f, 8.21115747e-02f, -6.26842603e-02f, 1.07366301e-03f,
  1.33560197e-02f, 8.57410431e-02f, -5.06899692e-02f, 7.58250430e-02f, -1.54165298e-01f, 1.11894429e-01f, 5.09837316e-03f, 5.32592684e-02f, -8.98968950e-02f, 1.17367715e-01f,
  -8.14848542e-02f, 9.63687003e-02f, -1.02440916e-01f, 1.36950985e-01f, 4.28132229e-02f, 1.33726355e-02f, -7.52524287e-02f, -1.12138383e-01f, 1.02136157e-01f, 8.66832435e-02f,
  -7.60684311e-02f, -5.02392557e-03f, 6.02894500e-02f, 1.33716762e-01f, -3.37836444e-02f, 9.53231007e-02f, -1.11114040e-01f, -8.73983558e-03f, -3.27002071e-03f, -1.51154101e-01f,
  1.64925233e-01f, -4.66860235e-02f, -5.08050397e-02f, -1.09417357e-01f, 2.53651831e-02f, -4.70860638e-02f, -6.70545595e-03f, 3.40212695e-02f, 5.24860919e-02f, 4.75539267e-02f,
  -1.08366013e-02f, -4.30477113e-02f, -1.80057287e-02f, -7.03000277e-02f, -2.99804509e-02f, -1.37396961e-01f, -3.78580950e-02f, 4.77299951e-02f, -4.88392040e-02f, -4.87479419e-02f,
  -8.96577723e-03f, 4.59656417e-02f, 8.44190642e-02f, -4.20853347e-02f, -4.74806763e-02f, 3.74785997e-03f, 3.11896484e-02f, -4.14844006e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  3.75152558e-01f, 6.82717040e-02f, -5.69301751e-03f, 1.26441017e-01f, 1.79882050e-01f, 9.16362926e-02f, 7.67336413e-02f, 1.82109639e-01f, -2.58129612e-02f, 3.24038826e-02f,
  6.49847835e-02f, 1.19061522e-01f, 2.18602359e-01f, 1.42059579e-01f, 1.91116333e-01f, -2.28881487e-04f, 4.78185639e-02f, 2.01007381e-01f, 4.42689322e-02f, -2.43534837e-02f,
  1.47098735e-01f, 1.44755319e-01f, 6.96212947e-02f, 2.54593372e-01f, 4.93426397e-02f, 1.12748072e-01f, -7.45719969e-02f, -3.70321646e-02f, 1.26442865e-01f, 1.94842204e-01f,
  -3.88033018e-02f, 1.45525172e-01f, 1.03953145e-01f, -4.22200821e-02f, 2.87488401e-01f, 2.50810981e-01f, 1.36419550e-01f, 1.32944092e-01f, 9.70588252e-02f, 8.14641416e-02f,
  -7.16644451e-02f, 1.02938257e-01f, 1.35130405e-01f, 2.55784877e-02f, 8.25139061e-02f, 6.34689331e-02f, 5.89656532e-02f, 5.80432564e-02f, -1.06003461e-02f, 6.79398105e-02f,
  3.99484560e-02f, 1.32776797e-01f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  3.04512620e-01f, 2.08479270e-01f, -2.84817517e-01f, 1.00425363e-01f, 7.88556561e-02f, 4.97232787e-02f, 3.07836607e-02f, 3.16218376e-01f, 3.63395602e-01f, 1.50218740e-01f,
  4.76488732e-02f, -2.80399799e-01f, 4.77483511e-01f, -4.57674444e-01f, -6.40612319e-02f, 6.99463189e-02f, -3.57219130e-02f, -1.68954968e-01f, -8.77127573e-02f, -3.57175201e-01f,
  2.31441036e-01f, -1.30531460e-01f, 9.32205766e-02f, 1.27183259e-01f, -3.16821605e-01f, -1.41694114e-01f, -1.34436265e-01f, -1.87205851e-01f, 5.99426806e-01f, -1.81316331e-01f,
  -1.13712706e-01f, -9.09764841e-02f, -5.28593920e-02f, -2.08371997e-01f, -1.23329267e-01f, -4.56403285e-01f, -7.44013786e-02f, 6.61888048e-02f, 5.18972538e-02f, -2.67933816e-01f,
  -1.25235543e-01f, 9.31315199e-02f, 5.83979785e-02f, 1.24701381e-01f, 1.10555895e-01f, 4.22241725e-02f, -7.56554604e-02f, 2.59846628e-01f, -1.34272426e-01f, 2.41709530e-01f,
  -1.07020155e-01f, 2.48141319e-01f, 6.00774996e-02f, 3.03341839e-02f, -5.72489062e-03f, 6.27889156e-01f, -2.56848261e-02f, 7.32048228e-02f, 3.75403278e-02f, -4.22485732e-02f,
  -1.35459006e-01f, -1.29087210e-01f, -1.73880532e-01f, -7.72911534e-02f, -3.72936353e-02f, 2.88298488e-01f, 3.71710807e-01f, 2.24907219e-01f, 2.75801718e-01f, 1.93367928e-01f,
  -5.32537580e-01f, -3.35662872e-01f, 4.68683392e-01f, 1.07360139e-01f, -6.35938570e-02f, -3.33727688e-01f, 4.42140430e-01f, -2.93817937e-01f, -8.33534300e-02f, -3.43880095e-02f,
  4.27895486e-01f, -4.63641971e-01f, 1.29800871e-01f, -3.71652573e-01f, -2.01116025e-01f, -1.12306215e-01f, -2.24608909e-02f, 5.61229169e-01f, 6.60608560e-02f, 2.33545184e-01f,
  -9.52893943e-02f, -2.94443130e-01f, -4.47123021e-01f, -8.92453548e-03f, 1.14561403e-02f, 1.09082825e-01f, -1.33736208e-01f, 2.14418955e-02f, -4.41584259e-01f, -1.59268647e-01f,
  -7.27374181e-02f, -1.74590021e-01f, -1.02873437e-01f, 8.81999210e-02f, 7.04602674e-02f, -4.04792994e-01f, 1.43430829e-01f, 5.28391540e-01f, -4.80689742e-02f, -1.65763006e-01f,
  -3.45410377e-01f, 2.56389439e-01f, -7.43841827e-02f, -3.92363071e-01f, -9.51655209e-02f, 1.87278882e-01f, -8.42756499e-03f, -1.00851260e-01f, 6.98487163e-02f, -9.11223644e-04f,
  2.17756242e-01f, -7.90981427e-02f, 2.51028150e-01f, 8.27687904e-02f, -8.08095187e-02f, 4.08730358e-01f, -2.22743731e-02f, -1.51126519e-01f, -8.96359980e-02f, 5.43689057e-02f,
  -4.18383256e-02f, -1.13622263e-01f, -2.13140115e-01f, -1.37078241e-01f, -3.36050570e-01f, 5.70723936e-02f, -2.42849633e-01f, 5.62089495e-03f, -4.08181876e-01f, 3.02724719e-01f,
  -3.60547125e-01f, -1.52949274e-01f, -1.07867725e-01f, 2.30433956e-01f, 4.38649476e-01f, -2.10179120e-01f, 9.64294076e-02f, -2.95874290e-02f, 2.37088844e-01f, -1.02097325e-01f,
  -9.92635339e-02f, 6.46360576e-01f, -1.39546514e-01f, 1.41419168e-03f, -1.69388548e-01f, 1.49188647e-02f, -2.98607230e-01f, -8.91225040e-02f, -1.25731036e-01f, -1.72129527e-01f,
  2.07571656e-01f, -3.87975089e-02f, 3.22446644e-01f, -3.56026851e-02f, 2.69782871e-01f, -4.25202549e-02f, 7.00260475e-02f, -3.29517350e-02f, 1.04225636e-01f, -4.35608998e-02f,
  -1.17699228e-01f, -2.16010824e-01f, 7.78143108e-02f, -1.88627109e-01f, -3.97170484e-01f, -7.19702989e-02f, -1.14271179e-01f, -1.10072762e-01f, -9.58367959e-02f, -9.62622557e-03f,
  -5.79653010e-02f, -8.87569040e-02f, 6.06672466e-03f, -1.76246360e-01f, -1.74374226e-03f, 1.05425574e-01f, 3.62951100e-01f, -2.77124206e-03f, -5.97486272e-02f, -2.79260352e-02f,
  4.96836752e-01f, 6.02305792e-02f, -2.99418449e-01f, -2.37466935e-02f, 2.22035006e-01f, -3.90599817e-02f, -3.66160393e-01f, 6.89010173e-02f, 2.70272225e-01f, 1.98568299e-01f,
  1.47858649e-01f, 3.95712107e-01f, 3.08672369e-01f, 9.09449086e-02f, 4.95658740e-02f, -1.74540833e-01f, 1.88643821e-02f, -1.97234407e-01f, -2.10139945e-01f, 8.53244662e-01f,
  3.59769240e-02f, -2.00348601e-01f, 1.10066816e-01f, 5.40712364e-02f, 1.11077383e-01f, -3.47840376e-02f, -2.51505673e-01f, 3.38564515e-02f, 2.80463904e-01f, 8.60395283e-03f,
  -4.31539267e-01f, -1.56144902e-01f, 6.32724687e-02f, 1.74938187e-01f, -8.41453746e-02f, -7.43272528e-02f, -3.37570049e-02f, -5.35744905e-01f, 2.02371627e-01f, -9.60933864e-02f,
  -1.18636094e-01f, 3.12363088e-01f, -1.06648497e-01f, -3.37566197e-01f, -2.19689682e-02f, -1.26815408e-01f, -1.18513241e-01f, 3.37065160e-01f, 4.44606900e-01f, -2.73546964e-01f,
  1.91221446e-01f, 4.96970981e-01f, -1.64827526e-01f, 1.49772391e-02f, 4.77521457e-02f, 8.46200883e-02f, 9.81925130e-02f, -2.31362566e-01f, 1.52540535e-01f, -1.91715900e-02f,
  -4.87928420e-01f, 1.06200181e-01f, -1.22826710e-01f, 3.38630788e-02f, -2.18635336e-01f, -5.25164455e-02f, -1.10486850e-01f, -7.48028383e-02f, 2.50770032e-01f, 2.62038112e-01f,
  -1.77257270e-01f, 9.37935114e-02f, 2.62259334e-01f, 2.87011087e-01f, 1.50455251e-01f, -2.85147838e-02f, 2.56035149e-01f, -6.92954212e-02f, -3.37844975e-02f, 4.94504496e-02f,
  -1.65668100e-01f, 2.96928614e-01f, -2.83691026e-02f, 4.07003820e-01f, -1.28261253e-01f, 6.72557831e-01f, 4.94692475e-02f, -8.52474123e-02f, -9.74320993e-02f, -1.13358609e-01f,
  -2.75676250e-01f, -3.80406767e-01f, 2.27056667e-01f, 1.59324557e-02f, 3.93775821e-01f, 6.70138339e-04f, 2.30648249e-01f, -3.07914227e-01f, -2.03407452e-01f, 1.32043317e-01f,
  -6.07138276e-02f, -1.70780614e-01f, 1.48505136e-01f, 1.73741300e-02f, -5.22931591e-02f, -8.86444449e-02f, -1.00950986e-01f, 3.54481369e-01f, -1.51394308e-01f, -1.49111331e-01f,
  7.58087859e-02f, -1.98404193e-01f, 5.38756788e-01f, -1.85208201e-01f, -6.97009340e-02f, 2.03920037e-01f, -2.16152780e-02f, -5.71739487e-02f, -6.87901601e-02f, -8.33815709e-02f,
  -2.57488303e-02f, -3.55426669e-02f, 3.64350751e-02f, -1.93823893e-02f, -3.83642584e-01f, 1.17856741e-01f, 1.49457693e-01f, -1.14402369e-01f, -2.47314312e-02f, 6.91419914e-02f,
  4.61406976e-01f, 1.20474927e-01f, 4.21781629e-01f, -1.98116545e-02f, 1.67989537e-01f, 5.18156528e-01f, -1.23869821e-01f, -6.14030302e-01f, 1.48515448e-01f, -4.88480151e-01f,
  2.26517826e-01f, -2.83733726e-01f, 7.03930736e-01f, 1.44565716e-01f, 2.42473230e-01f, -1.17639609e-01f, -1.98421299e-01f, -1.82102650e-01f, -1.42392352e-01f, -2.84358501e-01f,
  -3.56754094e-01f, -1.30209297e-01f, 1.00397177e-01f, -4.34739351e-01f, 3.36757809e-01f, 1.09616527e-02f, 1.71573356e-01f, -2.34614715e-01f, 1.07037984e-01f, -1.13091893e-01f,
  -1.50844082e-01f, -2.69729663e-02f, -1.94909096e-01f, -1.38677537e-01f, 1.15417391e-02f, 3.90575171e-01f, -2.46901631e-01f, 2.77869821e-01f, 2.73125544e-02f, -2.23168537e-01f,
  -5.01405336e-02f, 1.63168311e-01f, 3.70676033e-02f, -2.52823867e-02f, 8.41499120e-03f, 2.51751661e-01f, 3.60458702e-01f, 9.93005335e-02f, -2.05911338e-01f, -1.83580622e-01f,
  -8.61813650e-02f, -3.24035101e-02f, -5.20089120e-02f, 1.65339127e-01f, 1.27351657e-01f, -1.52523115e-01f, -1.77245334e-01f, -1.24904133e-01f, 8.04122910e-03f, -7.77502656e-02f,
  1.94781777e-02f, 7.68572837e-02f, 3.67171504e-02f, 3.13216835e-01f, 5.65676391e-02f, 3.39384913e-01f, 8.44913274e-02f, -3.71093333e-01f, 2.67525434e-01f, -1.88641801e-01f,
  -5.39558195e-03f, 3.82697694e-02f, -4.29645896e-01f, -4.04043794e-01f, 9.55301449e-02f, 4.56394553e-01f, -4.31682110e-01f, 1.54543966e-01f, -2.32623778e-02f, -3.20642777e-02f,
  -2.43561700e-01f, -3.54601257e-02f, 2.88349800e-02f, 2.12545529e-01f, -2.85069287e-01f, 2.07494870e-01f, 1.03431888e-01f, -2.78396476e-02f, 2.21144795e-01f, -3.18909436e-01f,
  3.15891318e-02f, 1.60016313e-01f, -1.66337371e-01f, 4.25004102e-02f, -2.22094789e-01f, 2.14481160e-01f, -2.44765833e-01f, -1.98221937e-01f, 4.87170741e-02f, 5.90974927e-01f,
  -2.60485858e-01f, -1.57579750e-01f, 1.35779250e-02f, -1.84825644e-01f, 1.22859865e-01f, 4.64581460e-01f, -4.68591228e-03f, -2.49508426e-01f, 2.68137641e-02f, -1.64944649e-01f,
  8.34049657e-02f, 7.13086426e-02f, 1.31649941e-01f, -3.12904894e-01f, -2.10447639e-01f, -1.02982014e-01f, 1.17856920e-01f, 3.45541477e-01f, 2.18645260e-01f, -2.57685393e-01f,
  -1.41115293e-01f, 5.02662584e-02f, 4.52992141e-01f, -4.06410061e-02f, 3.74979377e-02f, -1.26732707e-01f, 2.03607008e-01f, -5.32264486e-02f, -2.49158964e-01f, -9.69288573e-02f,
  -1.17042288e-01f, -1.73694715e-01f, -1.75972596e-01f, -2.08705336e-01f, 3.50532532e-01f, 1.87226757e-01f, 1.95871606e-01f, -1.28005613e-02f, -2.38639206e-01f, 1.52898565e-01f,
  -1.93633318e-01f, 3.50150317e-01f, -7.70941749e-02f, -2.43190557e-01f, 2.29982063e-01f, -4.11766991e-02f, 4.43848222e-02f, -3.04045290e-01f, -2.39633657e-02f, -1.20875016e-01f,
  -2.79449504e-02f, -5.07875323e-01f, 2.34559849e-01f, 5.31200290e-01f, -1.16296105e-01f, -1.43152446e-01f, 5.83612800e-01f, -2.42654175e-01f, -1.86058104e-01f, 4.65111881e-02f,
  -9.48026031e-02f, 2.49649942e-01f, 9.94153991e-02f, 1.76383108e-01f, -2.55010217e-01f, -5.60809672e-02f, -6.47161826e-02f, 3.03394854e-01f, -5.47363348e-02f, 2.00540513e-01f,
  -6.46389229e-03f, -1.05986454e-01f, -7.29500502e-02f, -5.05589284e-02f, -3.24466020e-01f, -1.10051453e-01f, -4.49469127e-02f, 2.20200554e-01f, -2.76665445e-02f, 1.22638650e-01f,
  2.61666346e-02f, -3.62627627e-03f, 6.86966032e-02f, -3.24584752e-01f, -5.16349562e-02f, 7.13632852e-02f, -2.83300817e-01f, 2.06998393e-01f, -1.31632820e-01f, 6.94393814e-02f,
  -3.94692868e-02f, 1.50495082e-01f, -2.14293256e-01f, -4.49911729e-02f, -2.07188845e-01f, -9.01388153e-02f, -3.36396933e-01f, 4.36102301e-02f, 4.18739051e-01f, -7.94804394e-02f,
  -2.17796579e-01f, -1.09359525e-01f, -3.78921688e-01f, -3.68877500e-01f, 1.34207875e-01f, -1.16358735e-01f, -1.14780426e-01f, -2.11883187e-01f, 1.37432456e-01f, -2.77328826e-02f,
  4.45906483e-02f, -9.36058760e-02f, 2.09932566e-01f, 1.10467426e-01f, -8.85634273e-02f, -8.85999873e-02f, -8.12113136e-02f, 4.15337265e-01f, -1.97810486e-01f, 3.46096456e-01f,
  -3.19146723e-01f, -7.43512288e-02f, -1.18411981e-01f, -7.49281421e-02f, 4.44449991e-01f, -1.62565872e-01f, 3.51693451e-01f, 2.59947836e-01f, 1.44062236e-01f, -7.19658844e-03f,
  8.32745731e-02f, -1.76952302e-01f, -8.17998350e-02f, -4.22940254e-01f, -8.95963013e-02f, 1.86464354e-01f, -9.59813129e-03f, -1.01875581e-01f, -1.82334054e-02f, 1.68984726e-01f,
  2.89536297e-01f, -4.46877331e-02f, 9.02522430e-02f, -2.86407024e-01f, 5.22824302e-02f, -1.15517572e-01f, -1.17186211e-01f, -1.86012834e-01f, -1.18392482e-01f, 8.66318494e-02f,
  6.12144824e-03f, 9.15695578e-02f, 1.09727375e-01f, 3.94896001e-01f, -1.09694131e-01f, 8.23034942e-02f, -3.86630222e-02f, -3.55706602e-01f, 2.32229665e-01f, -6.65145963e-02f,
  -7.38774091e-02f, -1.47991091e-01f, -9.77222696e-02f, 4.61005121e-01f, 2.13375613e-01f, 8.08961764e-02f, 2.32842490e-01f, 2.80819565e-01f, -4.07449871e-01f, -1.28692240e-01f,
  1.79437980e-01f, 9.35476944e-02f, -4.00207154e-02f, -4.03295815e-01f, -1.50316492e-01f, 4.64674026e-01f, 1.36107191e-01f, 6.12537675e-02f, 5.23736551e-02f, -1.80076927e-01f,
  3.84624124e-01f, -3.19353580e-01f, -3.07042062e-01f, -1.04092032e-01f, 5.64671397e-01f, 1.07408926e-01f, 1.19691916e-01f, 1.43479452e-01f, -1.25563249e-01f, 5.98266311e-02f,
  6.79732934e-02f, 1.55178517e-01f, 2.99057543e-01f, -2.34254692e-02f, -2.44171526e-02f, 1.93922445e-01f, -6.64842501e-02f, 3.48240703e-01f, -1.09434985e-01f, -1.59216687e-01f,
  -6.88868836e-02f, -5.91035485e-02f, -7.19527483e-01f, 2.07217291e-01f, -1.98104158e-01f, -2.87826303e-02f, -1.33441016e-01f, 2.68928800e-02f, 6.97127953e-02f, -1.33550942e-01f,
  -8.47339407e-02f, 2.67753780e-01f, -8.21535215e-02f, -7.72686601e-02f, 2.10662425e-01f, 8.13147351e-02f, -8.90128836e-02f, -2.93187983e-02f, -1.38311595e-01f, -1.50444165e-01f,
  -7.93732554e-02f, -4.44405787e-02f, -2.42939830e-01f, -7.19296634e-02f, 1.51430205e-01f, 7.00784207e-04f, -1.34079054e-01f, -2.91425526e-01f, -3.06322634e-01f, 4.45633322e-01f,
  1.15205571e-01f, -3.31553095e-03f, 6.87834546e-02f, -1.38624087e-01f, 4.74920049e-02f, -1.42170578e-01f, -3.83338392e-01f, 3.07335436e-01f, -1.38435036e-01f, -3.02298725e-01f,
  1.42966572e-03f, 6.07651174e-02f, -9.38818231e-02f, 7.22410798e-01f, -2.71962229e-02f, -2.87096985e-02f, 2.27109596e-01f, 1.76392607e-02f, -6.25681698e-01f, 4.63435352e-01f,
  3.71016294e-01f, 1.90823287e-01f, -1.86436027e-01f, -3.32994759e-02f, -2.34616190e-01f, -1.10372111e-01f, -1.96503904e-02f, -1.47849113e-01f, 4.66422364e-02f, -1.77650630e-01f,
  -9.17475149e-02f, -2.67800421e-01f, -1.28666252e-01f, 1.01140879e-01f, 6.30000681e-02f, 1.55030534e-01f, 2.17540801e-01f, -1.82831272e-01f, 1.24451295e-01f, -7.16370717e-02f,
  2.88606852e-01f, -6.30515516e-02f, -1.12595536e-01f, 9.44703445e-02f, -7.66684562e-02f, 3.36730182e-01f, -3.10288440e-03f, -3.46706808e-02f, 1.86789408e-01f, 8.02728087e-02f,
  9.36707854e-02f, -1.44188598e-01f, 5.86402342e-02f, 4.29456793e-02f, -7.16797030e-03f, -1.53456017e-01f, -4.76721674e-01f, 1.75408646e-02f, 1.45375937e-01f, 3.14548649e-02f,
  1.91358432e-01f, -3.55782062e-01f, -3.75906527e-01f, -9.18278992e-02f, -1.59076899e-01f, -1.58863455e-01f, -2.23986194e-01f, 4.11695629e-01f, 3.56980525e-02f, -2.07863256e-01f,
  -2.99390227e-01f, 4.16771293e-01f, 6.22754246e-02f, 4.09619689e-01f, -8.98674801e-02f, -2.55096518e-02f, -1.53919786e-01f, -3.71529102e-01f, -1.53006822e-01f, -1.79293260e-01f,
  4.65533376e-01f, 3.66263807e-01f, -1.40179217e-01f, 2.30539531e-01f, -2.14374170e-01f, -2.56232470e-02f, 1.67890370e-01f, 2.99427304e-02f, 1.05074339e-01f, 1.54135704e-01f,
  -3.06194931e-01f, 1.74524069e-01f, 5.66091649e-02f, 2.74444580e-01f, -1.29637085e-02f, 2.05868334e-02f, 2.90218443e-01f, -1.62121490e-01f, 4.78129089e-02f, 2.72965312e-01f,
  8.30100626e-02f, -2.52583504e-01f, 3.66044134e-01f, -1.08458214e-01f, 1.98176578e-01f, -3.31586867e-04f, -1.14441998e-01f, -6.96735643e-03f, -1.53134195e-02f, -1.37183160e-01f,
  6.31750897e-02f, 9.33269933e-02f, -1.85749471e-01f, -1.31560341e-01f, -6.56025633e-02f, -7.23069012e-02f, -2.24640280e-01f, -1.09961936e-02f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  6.31366223e-02f, 2.13108778e-01f, -1.36971429e-01f, -9.23165083e-02f, -2.03846656e-02f, 3.33849311e-01f, 1.37626171e-01f, -2.35093966e-01f, -6.66045398e-02f, 3.28498185e-02f,
  -5.54574281e-02f, -1.33429959e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    