/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.22253500e-01f, 2.59954184e-01f, -1.38479203e-01f, 1.42038748e-01f, 1.11987859e-01f, -7.87600279e-02f, -1.26458824e-01f, -6.17830195e-02f, -9.03938990e-03f, 2.37885088e-01f,
  2.00520962e-01f, 6.02031685e-02f, 1.22749256e-02f, -8.58757868e-02f, -2.63363510e-01f, -1.65481776e-01f, -2.69724160e-01f, -3.74519497e-01f, -3.73376131e-01f, -1.33432284e-01f,
  5.04581593e-02f, -3.66260707e-02f, -7.97882080e-02f, -5.50199635e-02f, 2.24616632e-01f, -3.22312582e-03f, 1.50997251e-01f, 1.32797927e-01f, -1.87817507e-03f, 1.67913795e-01f,
  1.17473967e-01f, 3.63391161e-01f, -1.78840920e-01f, 1.03711158e-01f, 9.49492976e-02f, -6.66666627e-02f, -6.40381128e-02f, 1.03492230e-01f, 7.77896643e-02f, 3.67781799e-03f,
  6.53100982e-02f, 4.46254238e-02f, 8.24576095e-02f, 6.92766160e-02f, 2.21614614e-02f, 6.21405877e-02f, 7.44970590e-02f, 1.79172326e-02f, -1.42965913e-01f, 7.74784535e-02f,
  1.27905264e-01f, 1.84905514e-01f, 9.40327495e-02f, -7.97881708e-02f, -3.98808978e-02f, -4.60810475e-02f, 9.35545489e-02f, 1.20804638e-01f, -1.00183897e-01f, 1.21344969e-01f,
  -4.73736748e-02f, -9.02278572e-02f, 4.28382233e-02f, -2.68352684e-02f, 5.42701930e-02f, 4.78467089e-04f, -1.68994851e-02f, -2.49945540e-02f, 2.18556523e-02f, -5.47847897e-03f,
  -4.38494943e-02f, -3.61571796e-02f, -2.80231354e-03f, -4.67135273e-02f, 4.27744277e-02f, -1.81460064e-02f, -2.00464018e-02f, -5.47478832e-02f, 2.71002315e-02f, 6.98279738e-02f,
  -6.28582155e-03f, -1.37137650e-02f, 6.81315511e-02f, 1.99616961e-02f, 1.93675421e-02f, -6.58182874e-02f, 5.72425537e-02f, 2.79176757e-02f, 3.46595682e-02f, 7.64868781e-02f,
  1.27195895e-01f, -2.22627610e-01f, 9.09867510e-02f, -4.69309241e-02f, 5.20799421e-02f, 3.00185252e-02f, 8.32356140e-02f, -7.03410953e-02f, 7.38494396e-02f, 2.54466617e-03f,
  -1.38132870e-02f, -5.84024787e-02f, -9.20535717e-03f, -1.83130130e-02f, -1.72223244e-02f, 2.64209788e-03f, 2.54431665e-02f, -7.72240832e-02f, -8.09006318e-02f, 1.45449564e-01f,
  -4.75674272e-02f, -1.26979873e-01f, -6.95521310e-02f, -3.06351371e-02f, 1.45365354e-02f, -1.00482278e-01f, -1.05316557e-01f, -1.02323271e-01f, -2.35630825e-01f, -3.06586046e-02f,
  -1.97489396e-01f, 4.09321673e-02f, 8.45178515e-02f, -1.45409450e-01f, -1.71854012e-02f, 1.07304499e-01f, 3.02150697e-01f, 2.15616181e-01f, -7.10407048e-02f, -1.29630938e-02f,
  4.13121991e-02f, -1.09500282e-01f, -1.84840076e-02f, -8.54106843e-02f, 9.63490084e-02f, 8.67566243e-02f, 8.17836374e-02f, -1.66676998e-01f, -1.34195043e-02f, -7.27573177e-03f,
  -1.89728551e-02f, 4.07815389e-02f, -1.13328904e-01f, -1.11388899e-01f, 9.31807533e-02f, 6.09376729e-02f, 2.95779947e-02f, -9.26814526e-02f, 1.01973027e-01f, -1.08502269e-01f,
  4.05729264e-02f, -3.95915359e-02f, 8.50336701e-02f, -1.00452051e-01f, -4.66934703e-02f, 5.09429500e-02f, 6.81295246e-02f, 1.89587753e-02f, 4.08921205e-02f, -1.36295287e-02f,
  -9.29610506e-02f, -9.42920297e-02f, -2.98235118e-02f, 7.29189068e-02f, 6.20400496e-02f, 3.73422913e-02f, -2.25951709e-02f, -2.71618329e-02f, -9.86568555e-02f, 6.29353337e-03f,
  2.98153479e-02f, -1.03738375e-01f, -2.86563337e-02f, 1.36356160e-01f, 1.99972838e-02f, -6.08420298e-02f, 1.46383688e-01f, 6.19918108e-02f, 1.18845269e-01f, 7.40583539e-02f,
  4.83906381e-02f, 1.22463591e-02f, 3.04287970e-02f, 2.44778749e-02f, 6.80415407e-02f, -4.00386006e-02f, -1.46677652e-02f, 3.53933126e-02f, -3.87326814e-02f, 4.54190746e-02f,
  5.49159311e-02f, -3.10894661e-02f, 2.52991114e-02f, 5.19930273e-02f, 3.13313352e-03f, 1.98402405e-02f, -8.05416629e-02f, -5.79061499e-03f, 2.97349095e-02f, -3.73393372e-02f,
  3.60797904e-02f, -1.17789535e-02f, -8.04477111e-02f, -7.45731294e-02f, 1.41002014e-02f, -1.75321964e-03f, 3.56365442e-02f, -2.16311421e-02f, -2.18200944e-02f, 4.68782410e-02f,
  1.17265999e-01f, -9.99730080e-02f, 5.47753014e-02f, 5.33399284e-02f, -4.00116630e-02f, -1.07996590e-01f, -4.58069146e-02f, -6.73888698e-02f, -1.50190994e-01f, 1.53841246e-02f,
  -5.46199493e-02f, 8.54260996e-02f, -5.06044850e-02f, -1.23348096e-02f, 7.23702908e-02f, 1.01047315e-01f, 1.07172385e-01f, 1.48462551e-02f, 4.96415310e-02f, 4.18439955e-02f,
  -6.02931390e-03f, 1.28946882e-02f, 2.10733544e-02f, 4.44192588e-02f, 4.81607690e-02f, 5.87331578e-02f, 1.25817135e-01f, 1.09181479e-01f, 6.48842975e-02f, 2.88758129e-01f,
  7.55542070e-02f, -1.92411035e-01f, -3.68775278e-02f, 9.95370075e-02f, 1.86111659e-01f, 2.29507640e-01f, 6.67710975e-02f, 1.50745641e-02f, 7.73667544e-02f, -7.68911690e-02f,
  -9.28087160e-02f, -2.54179925e-01f, -3.02349329e-01f, -2.43660063e-01f, -2.08903939e-01f, -1.70842946e-01f, -5.73097616e-02f, -9.86777842e-02f, 7.28685036e-02f, 1.72562107e-01f,
  -3.53434607e-02f, 1.25668198e-01f, 4.66486961e-02f, 5.40991947e-02f, 1.08937256e-01f, -9.36948806e-02f, -6.60623088e-02f, 5.48019558e-02f, 4.67347391e-02f, 5.40908873e-02f,
  -1.75009906e-01f, 9.98658314e-02f, 2.04609949e-02f, -1.03740767e-01f, -8.16684216e-02f, -1.21458033e-02f, -7.03263581e-02f, -1.44273005e-02f, -2.53483802e-02f, 2.29892787e-02f,
  9.15751225e-05f, 2.90511400e-02f, 3.72872278e-02f, 2.57406160e-02f, 5.87597266e-02f, 1.23751834e-01f, 3.71966064e-02f, -7.06718937e-02f, -1.11090936e-01f, 1.06393121e-01f,
  -2.03859154e-02f, 1.34755418e-01f, 4.21665758e-02f, 7.39089325e-02f, 6.23874404e-02f, -1.50408931e-02f, 6.43338636e-02f, 9.53532457e-02f, 8.82285312e-02f, -1.40344547e-02f,
  2.39662509e-02f, -1.65474582e-02f, 7.35380128e-02f, -1.72992963e-02f, 1.04358392e-02f, -1.14691928e-01f, 3.96455638e-03f, -1.75340082e-02f, -3.32335718e-02f, 5.16192503e-02f,
  -2.02471223e-02f, 4.87555517e-03f, -1.28625138e-02f, -3.96336578e-02f, 7.96780083e-03f, 2.21844073e-02f, -4.57760058e-02f, -9.51039121e-02f, 3.46483625e-02f, -2.38339119e-02f,
  2.15790942e-02f, -7.03461608e-03f, 3.01687196e-02f, -4.02511135e-02f, 7.63350055e-02f, 9.83175542e-03f, -4.70556207e-02f, 6.83088377e-02f, 3.53000611e-02f, 8.32353458e-02f,
  -2.93814182e-01f, -9.01323110e-02f, -1.00278161e-01f, 2.31037247e-05f, 6.39457777e-02f, 6.50286227e-02f, -6.96853623e-02f, -4.88186814e-02f, -2.42248159e-02f, -7.82589149e-03f,
  -2.42218785e-02f, 2.25386117e-02f, -1.27749324e-01f, 2.23459881e-02f, 4.21873704e-02f, 7.12525696e-02f, 2.28556097e-02f, 3.94855700e-02f, 4.93573199e-04f, 1.06996391e-02f,
  -1.50611708e-02f, -2.80187018e-02f, -1.30767211e-01f, -6.93647489e-02f, 9.22355056e-02f, -7.71174878e-02f, -8.82522985e-02f, -2.57802419e-02f, -4.33662124e-02f, -2.23318756e-01f,
  -6.32414222e-02f, 2.96956480e-01f, 3.27929348e-01f, 6.61788136e-02f, 4.28331159e-02f, -4.76552732e-02f, 7.05622956e-02f, -7.87356123e-02f, -5.50166778e-02f, 1.05435267e-01f,
  -4.24941182e-02f, -1.62516594e-01f, -1.22151755e-01f, -1.23191744e-01f, -3.83109748e-02f, 1.86993539e-01f, 2.07562596e-01f, 8.55966881e-02f, -1.41013592e-01f, -7.91945308e-02f,
  -1.50233790e-01f, 9.83848423e-03f, -6.88788146e-02f, 5.46672568e-02f, 2.31436521e-01f, 4.52505285e-03f, 2.63284951e-01f, 7.93733224e-02f, 1.37019202e-01f, 2.77003139e-01f,
  1.59499228e-01f, 1.50572732e-01f, -2.06047475e-01f, -3.88729461e-02f, 4.57553156e-02f, -6.06357679e-02f, 4.94794101e-02f, -4.91407476e-02f, -1.23164929e-01f, 4.79681306e-02f,
  -6.47716448e-02f, 2.39251759e-02f, 1.65560283e-03f, 4.73693572e-02f, -1.68442633e-02f, -7.73321167e-02f, 5.50523051e-04f, 1.15225039e-01f, 4.09104154e-02f, 3.08944732e-02f,
  -6.38685599e-02f, 9.37481374e-02f, 7.86511600e-02f, 9.27909184e-03f, -1.74613707e-02f, -9.88852307e-02f, 1.35482088e-01f, 1.23556502e-01f, 6.94673955e-02f, 2.13203520e-01f,
  -2.79992493e-03f, 1.12160444e-02f, -8.21692124e-03f, -3.22841629e-02f, -4.75242659e-02f, -6.55221636e-04f, 2.42396295e-02f, 1.86299235e-02f, -5.92866428e-02f, 7.36371875e-02f,
  -5.03089540e-02f, 5.95252924e-02f, 1.14385374e-02f, 3.44476439e-02f, -1.85929984e-02f, 1.28621832e-01f, -4.00110111e-02f, -1.59869362e-02f, 3.76650281e-02f, -9.69968960e-02f,
  -2.79577095e-02f, -2.07629222e-02f, 8.92507806e-02f, -3.00665461e-02f, 6.04172871e-02f, 8.99266750e-02f, -4.57484610e-02f, -8.19852129e-02f, -2.15392094e-02f, -4.76872846e-02f,
  -1.28664240e-01f, -1.89633340e-01f, 3.67669202e-03f, 1.03556663e-02f, 1.65262893e-02f, 3.61215994e-02f, 2.16913037e-02f, -2.16084737e-02f, -1.00474171e-02f, 3.69791761e-02f,
  -6.19670972e-02f, -7.58091658e-02f, 6.30665645e-02f, 3.28768753e-02f, -2.67930422e-02f, -3.96540090e-02f, -6.53897524e-02f, 1.04653463e-02f, 1.64850184e-03f, -1.17696659e-03f,
  4.50222604e-02f, -5.05353585e-02f, -1.05704747e-01f, -1.48931844e-02f, -1.18319010e-02f, -1.05603486e-01f, 7.93111697e-02f, -6.67473152e-02f, -4.83678132e-02f, 8.53212774e-02f,
  1.51597589e-01f, -3.05146307e-01f, -3.02899569e-01f, 1.47984087e-01f, 1.36006922e-01f, -9.00840163e-02f, -1.87741354e-01f, 5.34098968e-02f, 2.06966266e-01f, 3.85184027e-02f,
  7.24324211e-02f, 5.33455983e-02f, -6.14136420e-02f, -8.41041561e-03f, -1.83222800e-01f, -2.51260877e-01f, -2.95473695e-01f, -2.64742225e-01f, 4.26368900e-02f, 5.83213568e-02f,
  -4.50845100e-02f, -4.13518362e-02f, 2.97661405e-02f, -8.01117346e-02f, 2.42125461e-04f, 1.28283262e-01f, -7.51265064e-02f, 2.54519489e-02f, -1.06818698e-01f, -6.51009008e-02f,
  -3.76490690e-02f, -5.57771176e-02f, 1.25695467e-01f, 5.65348715e-02f, -4.11950462e-02f, 3.14491726e-02f, 3.86303738e-02f, -6.96742013e-02f, 2.05127615e-02f, -6.09194078e-02f,
  2.12812126e-02f, 8.07839409e-02f, -2.96675768e-02f, 1.88680012e-02f, -2.72448845e-02f, 8.18217173e-02f, -1.22211561e-01f, -2.09622197e-02f, 2.37344485e-02f, 5.48229255e-02f,
  -4.05649170e-02f, -1.02048747e-01f, -1.32113755e-01f, -4.29865047e-02f, -6.65940270e-02f, 1.16608076e-01f, -4.56216410e-02f, -3.96897905e-02f, 1.98748894e-02f, -4.79743723e-03f,
  -2.97136847e-02f, 3.96982580e-03f, -3.72854136e-02f, 6.65107667e-02f, 4.49220696e-03f, 1.94593128e-02f, -3.29250693e-02f, -7.67455772e-02f, 4.64850403e-02f, -7.21904188e-02f,
  1.03498036e-02f, 2.09709853e-02f, -6.30732451e-04f, -4.51421104e-02f, -7.19524324e-02f, -1.92249678e-02f, -3.41741070e-02f, -7.03469664e-02f, -7.94478953e-02f, 2.65486073e-02f,
  5.62082455e-02f, 8.24219175e-03f, 8.52596536e-02f, -1.48876179e-02f, 7.48221064e-04f, -6.82802051e-02f, -1.51445167e-02f, 1.25367209e-01f, 6.05748296e-02f, 9.23859775e-02f,
  9.47093442e-02f, -1.14695154e-01f, 2.95307511e-03f, 9.30078235e-03f, -4.89117429e-02f, 1.11860827e-01f, 4.88452539e-02f, 2.26985998e-02f, 1.04901418e-01f, 2.47221775e-02f,
  -4.18447778e-02f, 2.39519477e-02f, 6.74858398e-04f, 2.42950004e-02f, 5.31960763e-02f, 1.93142965e-02f, -6.10481948e-02f, -9.16427001e-02f, 3.44063789e-02f, -7.77741289e-03f,
  3.25253978e-02f, -6.84863254e-02f, 2.29125414e-02f, 8.41422065e-04f, -1.28688999e-02f, 3.81476320e-02f, 3.14228772e-03f, 6.21234737e-02f, 3.86070125e-02f, -4.19913325e-03f,
  4.92703855e-01f, -8.20299312e-02f, -2.78169870e-01f, 2.52874047e-01f, -6.17694631e-02f, -1.06160767e-01f, 3.38191763e-02f, 5.49101010e-02f, 9.79009941e-02f, 3.62628922e-02f,
  -1.69654235e-01f, -2.17468850e-02f, -2.64734589e-02f, 6.95814984e-03f, -3.00067496e-02f, -7.80375674e-03f, 9.76807028e-02f, 6.36430532e-02f, 5.28356247e-02f, 9.33240578e-02f,
  1.88621953e-01f, 1.68673486e-01f, 2.06196189e-01f, 9.94349718e-02f, 4.01117839e-02f, -3.90921719e-02f, -5.33513390e-02f, -6.14644550e-02f, -8.39453265e-02f, 3.47226113e-02f,
  -6.37204051e-02f, -9.21067744e-02f, -5.47040813e-03f, 9.61776525e-02f, -1.45993590e-01f, 5.26968110e-03f, -8.00707191e-03f, -7.38987923e-02f, 8.88283481e-04f, 3.61073762e-02f,
  -6.08923174e-02f, 1.10387407e-01f, -7.25446045e-02f, 4.65223417e-02f, 8.99610892e-02f, -1.49428509e-02f, 1.12515390e-02f, 8.31099749e-02f, -1.51970498e-02f, -8.25063437e-02f,
  4.68778890e-03f, -3.70964743e-02f, -1.16398863e-01f, -4.45257984e-02f, -4.78225276e-02f, -8.42817649e-02f, -1.04030736e-01f, -1.30688429e-01f, -6.25531375e-02f, 1.13463439e-01f,
  8.84428769e-02f, -5.01032313e-03f, -2.25339774e-02f, -2.14851927e-02f, 5.91503344e-02f, -1.00193590e-01f, 3.27474996e-02f, -6.05182839e-04f, 2.41309069e-02f, 1.13555780e-02f,
  -6.02931008e-02f, -7.06948936e-02f, 2.68784482e-02f, 5.68411611e-02f, -4.04577032e-02f, -2.84458324e-02f, 1.30684851e-02f, 1.24611950e-04f, -8.87160227e-02f, -8.43166187e-02f,
  1.45372339e-02f, 6.65416592e-04f, -5.79044856e-02f, -3.01113725e-02f, -6.59926087e-02f, 3.62128951e-02f, -7.45265931e-03f, -2.17162352e-02f, -6.03231192e-02f, 7.79610202e-02f,
  2.28029639e-01f, -2.14196384e-01f, 1.92503318e-01f, 1.56489134e-01f, 3.76678184e-02f, 4.00311127e-02f, -5.07511245e-03f, 3.87911685e-02f, 3.06562744e-02f, 3.80206034e-02f,
  -4.98440824e-02f, 8.10550302e-02f, -1.34710642e-03f, -4.34558317e-02f, 4.03990448e-02f, 9.23882723e-02f, 3.82331088e-02f, 3.17193195e-02f, 1.52001036e-02f, -8.51100963e-03f,
  8.36906657e-02f, 1.01646692e-01f, 2.28533193e-01f, 2.40745042e-02f, 8.13269764e-02f, 5.94582632e-02f, 8.18680599e-03f, 3.49559225e-02f, 1.34004250e-01f, 2.58910060e-01f,
  3.42704415e-01f, -5.25287017e-02f, 1.60750434e-01f, 6.85165375e-02f, 3.45652760e-03f, 1.59459054e-01f, 1.37367025e-01f, 1.44304052e-01f, -2.65397653e-02f, 3.62761156e-03f,
  4.59382422e-02f, 1.94783770e-02f, 4.12856862e-02f, -4.94353287e-02f, 4.64683771e-02f, -5.46975667e-03f, -7.01739788e-02f, -3.50956023e-02f, 4.31095250e-02f, 5.01149520e-02f,
  -9.81619135e-02f, -5.19660525e-02f, 1.34860441e-01f, -9.39905867e-02f, -1.64929807e-01f, -1.12854011e-01f, 7.27458373e-02f, -6.99762776e-02f, -8.16819444e-02f, -3.45356554e-01f,
  9.65808108e-02f, 3.27232033e-02f, 2.46868785e-02f, -8.92262086e-02f, 2.03158315e-02f, -1.24729173e-02f, 8.27454999e-02f, 1.44027360e-02f, -1.71498826e-03f, -4.96753864e-02f,
  -7.59290978e-02f, -8.66653770e-02f, 3.66495736e-02f, -6.78728968e-02f, 1.08528130e-01f, 9.52719897e-02f, 5.87283485e-02f, 2.22821273e-02f, 1.29886419e-01f, -8.10580328e-03f,
  -1.54187113e-01f, -7.89006501e-02f, 1.97454274e-01f, 8.18626285e-02f, -2.72991974e-02f, 2.11714357e-02f, 1.23068079e-01f, 1.67881825e-03f, 3.06975208e-02f, 2.89062802e-02f,
  -3.65824848e-02f, -6.29904270e-02f, 6.66546524e-02f, 5.56355752e-02f, -2.58342084e-03f, -9.25347116e-03f, -2.64505036e-02f, -1.95900165e-02f, -4.89488803e-03f, 2.14997288e-02f,
  5.00850044e-02f, 5.26203215e-02f, -6.11790456e-03f, -4.08419259e-02f, 9.94690601e-03f, -2.28533726e-02f, -5.02203926e-02f, 4.74780947e-02f, 1.33347716e-02f, 9.02221054e-02f,
  3.32746021e-02f, 6.26030117e-02f, -1.96385924e-02f, -2.87425779e-02f, -2.85294242e-02f, 4.30303887e-02f, 4.14506942e-02f, -5.13182096e-02f, 7.68347830e-02f, 5.00793150e-03f,
  1.84765011e-01f, 5.56065403e-02f, 9.59379524e-02f, -5.62374759e-03f, -4.02079001e-02f, 3.11790779e-02f, -5.37226982e-02f, -7.46547431e-03f, -2.36795507e-02f, 6.88030347e-02f,
  6.00301586e-02f, -3.48575860e-02f, 3.97461392e-02f, -5.53022772e-02f, 6.47787517e-03f, 3.79227400e-02f, 1.94322411e-02f, 8.02449808e-02f, 7.67437592e-02f, 1.07233964e-01f,
  8.28227028e-03f, 2.59896994e-01f, 2.97426254e-01f, 1.51385427e-01f, 8.96396860e-02f, 2.08890587e-01f, 1.70603707e-01f, 1.26405597e-01f, 3.02265853e-01f, 2.89794147e-01f,
  2.73077220e-01f, 1.12638608e-01f, 3.07234198e-01f, 1.99847594e-01f, 1.72595456e-01f, 2.39097103e-01f, 2.02579781e-01f, 1.16640598e-01f, 1.35656908e-01f, 1.83802783e-01f,
  6.43888488e-02f, 7.63688833e-02f, 1.33326665e-01f, -1.15641868e-02f, 9.12067816e-02f, 2.09123328e-01f, 2.68774450e-01f, 1.34006321e-01f, 8.53951201e-02f, 7.49446973e-02f,
  1.94402590e-01f, 2.30712205e-01f, 1.55865878e-01f, 4.64873537e-02f, 5.85005097e-02f, -3.43819521e-02f, 1.21680722e-02f, 7.98415989e-02f, 1.24213360e-01f, 2.01110959e-01f,
  3.12652349e-01f, 1.08824812e-01f, -6.60506263e-02f, -8.90207887e-02f, -1.30385719e-02f, 9.95310838e-04f, -7.19853956e-03f, 3.00832484e-02f, -6.04848303e-02f, 3.26477997e-02f,
  1.04792304e-02f, -4.03957963e-02f, 1.77119821e-02f, 5.60563020e-02f, -1.99443977e-02f, 9.12546739e-02f, 1.28920265e-02f, 5.16446419e-02f, -1.02175489e-01f, 2.61226054e-02f,
  -1.30545935e-02f, 6.14550412e-02f, 4.07846570e-02f, -3.87448594e-02f, -4.83329631e-02f, -7.34848669e-03f, 1.39316181e-02f, -1.12130113e-01f, -1.44450411e-01f, 7.04424307e-02f,
  1.88650694e-02f, -9.59547423e-03f, -2.90126968e-02f, -6.31724074e-02f, 1.83788070e-03f, -1.10783093e-02f, -3.77097204e-02f, 1.53441820e-02f, -2.90862061e-02f, -1.86982825e-02f,
  -3.56721692e-02f, 4.97031733e-02f, -4.17750739e-02f, 7.57751688e-02f, 2.31001396e-02f, 2.13530790e-02f, 2.12271512e-02f, 2.67753174e-04f, -4.40821871e-02f, -1.94262411e-03f,
  -3.00644170e-02f, -8.40724483e-02f, -3.81576866e-02f, 1.98091250e-02f, -5.53646870e-02f, 1.37721458e-02f, 6.42633662e-02f, -5.87736629e-02f, 7.10836947e-02f, 5.18637197e-03f,
  -2.05462687e-02f, -1.81193218e-01f, 9.12900716e-02f, -3.23780417e-03f, 9.36882012e-03f, -6.21363632e-02f, -4.60469816e-03f, -1.32706553e-01f, -1.14733810e-02f, -7.72532774e-03f,
  -7.14861378e-02f, 4.18777578e-02f, 8.64703357e-02f, -7.61935487e-02f, 6.14525191e-02f, 3.26134600e-02f, 2.86776330e-02f, 2.31921747e-02f, -5.58184870e-02f, -8.20621476e-02f,
  -6.19814098e-02f, 4.19947132e-02f, -3.26950140e-02f, -7.13270009e-02f, -9.55015793e-02f, -9.41349268e-02f, -5.71679324e-02f, -1.88952114e-03f, -1.23730145e-01f, 4.77132723e-02f,
  2.26640314e-01f, 2.66913623e-01f, 1.16010495e-01f, -4.12624069e-02f, 6.91535175e-02f, 2.77897447e-01f, 3.32250595e-01f, 1.00575022e-01f, 4.65335585e-02f, 1.02886736e-01f,
  -1.19362630e-01f, -2.63830125e-01f, -1.34916425e-01f, -1.18752599e-01f, -5.86854368e-02f, 2.02197328e-01f, 1.67550966e-01f, 3.77007313e-02f, 3.21835764e-02f, 1.55967735e-02f,
  -9.45362914e-03f, -3.28045711e-02f, -3.24511677e-02f, 2.39842739e-02f, -5.91536798e-02f, 9.23707336e-03f, 1.16129667e-01f, 1.31617516e-01f, -1.76610444e-02f, 4.93416153e-02f,
  1.11664936e-01f, 1.54366374e-01f, -1.21189035e-01f, -1.73560455e-01f, -1.38150737e-01f, 7.41533712e-02f, 1.87554546e-02f, 3.63182463e-02f, -1.20219305e-01f, 5.78338616e-02f,
  -1.18308008e-01f, -8.53251666e-02f, -7.68681020e-02f, 1.98457558e-02f, -2.82541476e-02f, 7.73394853e-02f, -1.12296179e-01f, -2.92242207e-02f, -2.27915291e-02f, -6.43203929e-02f,
  -7.07823336e-02f, 1.36414496e-02f, 1.65935501e-01f, 2.35491563e-02f, -1.55984787e-02f, -1.70849428e-01f, 1.73196588e-02f, 9.65318978e-02f, -1.05300974e-02f, 2.91700512e-01f,
  -6.22750111e-02f, 1.19000329e-02f, -3.54415774e-02f, 3.97266913e-03f, -1.58314744e-03f, 3.07936780e-02f, -2.24291608e-02f, 1.98647529e-02f, -6.74707349e-03f, 3.14008147e-02f,
  -3.80193844e-04f, 9.10097174e-03f, -3.74597758e-02f, 4.67899628e-02f, -2.55795084e-02f, -1.08774109e-02f, 7.68242776e-02f, -9.12818825e-04f, 1.61644667e-02f, 3.26697119e-02f,
  -1.31548587e-02f, -3.44837792e-02f, 4.39748093e-02f, -3.59159224e-02f, -4.40607294e-02f, -3.61968949e-02f, -2.24889964e-02f, -9.24949050e-02f, -1.71911772e-02f, 3.61458100e-02f,
  -8.64240676e-02f, -1.49765372e-01f, 1.30263463e-01f, -4.67042476e-02f, 4.22663130e-02f, -1.88850146e-02f, -2.82727997e-03f, -1.86939221e-02f, 2.67995726e-02f, 1.05690241e-01f,
  7.51238540e-02f, 4.07534614e-02f, 3.61180911e-03f, -2.97375344e-04f, 7.33536482e-02f, 1.48370545e-02f, -1.58031341e-02f, -5.87055124e-02f, -4.80508022e-02f, 9.99551117e-02f,
  4.50778939e-02f, 1.47466481e-01f, 9.30091292e-02f, 1.31244034e-01f, 1.18445955e-01f, 1.49945598e-02f, 8.98369253e-02f, 1.95990041e-01f, 1.94470301e-01f, 2.68874884e-01f,
  1.97665811e-01f, -1.36528581e-01f, -9.57041904e-02f, 8.29898694e-04f, 2.21910626e-02f, 7.91619346e-02f, 9.05457288e-02f, -8.63497437e-04f, 3.30064708e-04f, -4.02066149e-02f,
  1.78882718e-01f, 1.47591576e-01f, 1.64607644e-01f, 3.68978754e-02f, 8.42880458e-02f, -1.85520843e-01f, -1.65281892e-01f, 1.01158015e-01f, 8.43221247e-02f, 6.84338063e-02f,
  -5.25575131e-03f, -5.26291691e-02f, -1.04043139e-02f, 2.85312836e-03f, -3.03922355e-01f, -1.52002787e-02f, -2.22369313e-01f, -1.98417991e-01f, -9.09137279e-02f, -3.76284301e-01f,
  9.64887589e-02f, -2.49254722e-02f, 8.00623521e-02f, -1.38917193e-02f, 5.80972731e-02f, -4.01966758e-02f, 3.13603915e-02f, 2.95762029e-02f, 3.60478507e-03f, -1.53118307e-02f,
  7.47728497e-02f, 2.27696486e-02f, 6.05829358e-02f, -1.10012189e-01f, 6.96283132e-02f, 2.83814669e-02f, 3.55261229e-02f, -5.57322763e-02f, 7.73724243e-02f, -6.93019480e-02f,
  -6.53087301e-03f, -1.83520000e-02f, 5.92114143e-02f, -5.34700043e-02f, -4.68447730e-02f, 8.31343979e-02f, 2.74132527e-02f, 1.27296140e-02f, 1.02944583e-01f, -1.70378298e-01f,
  -4.91264239e-02f, 4.75916155e-02f, -5.16407602e-02f, -8.34219456e-02f, -2.39241756e-02f, -5.03558740e-02f, -2.30567232e-02f, 7.63695687e-03f, -2.33413242e-02f, -5.09435646e-02f,
  3.76446694e-02f, -5.37872203e-02f, 1.45545546e-02f, -2.44388543e-02f, -1.11975567e-02f, 1.33294193e-02f, -6.02294803e-02f, -6.12373091e-02f, -2.15502884e-02f, 4.62754397e-03f,
  5.05529940e-02f, 3.44975293e-02f, -3.25861759e-02f, -5.36192358e-02f, -3.76065522e-02f, -6.46997849e-03f, -2.95656137e-02f, -1.53254420e-02f, 1.29140109e-01f, 2.03735917e-03f,
  8.94968584e-02f, 2.57746637e-01f, -7.12431520e-02f, 1.34865288e-02f, 1.75644476e-02f, 6.23463653e-03f, 4.03580479e-02f, -5.47741121e-03f, 7.03543350e-02f, -6.82750493e-02f,
  4.53990372e-03f, 2.13005822e-02f, -5.11006676e-02f, -2.78475508e-02f, 9.67720523e-03f, 6.91320151e-02f, -1.18417755e-01f, 6.49227947e-02f, 9.12364200e-03f, 1.24349631e-02f,
  -7.28775337e-02f, -9.11603100e-04f, 1.78214684e-01f, 9.81042832e-02f, 1.63995679e-02f, 1.53442606e-01f, 1.56888701e-02f, 1.06873708e-02f, 1.22423314e-01f, -1.04820952e-02f,
  -4.70891654e-01f, 1.52482077e-01f, -1.51625752e-01f, -1.89565852e-01f, 2.45737031e-01f, 2.26200625e-01f, 1.85202047e-01f, -5.17906174e-02f, -1.01593934e-01f, 4.95969281e-02f,
  2.02450842e-01f, 8.86082202e-02f, 1.80911049e-02f, -3.75037938e-02f, -3.71130295e-02f, 4.19713892e-02f, 4.14303616e-02f, -1.67110503e-01f, -6.83235237e-04f, 1.79180771e-01f,
  1.10526703e-01f, 3.25970948e-02f, -1.47181362e-01f, -1.48113742e-01f, 5.14108539e-02f, 1.10323101e-01f, -1.12059586e-01f, 4.84361723e-02f, 1.63614243e-01f, 1.45965606e-01f,
  1.16171904e-01f, -1.54716372e-01f, 9.17168427e-03f, -5.76140322e-02f, 1.07949138e-01f, -8.16213638e-02f, -1.01556266e-02f, -1.47514254e-01f, -2.34103464e-02f, -3.29478346e-02f,
  1.66145340e-02f, -4.41298559e-02f, -6.27930909e-02f, 5.42978011e-02f, 5.35936840e-02f, -2.31740177e-02f, -6.89090937e-02f, -1.78464025e-01f, 3.71105084e-03f, -2.46344414e-02f,
  7.38110691e-02f, 2.74057984e-02f, -1.90768484e-02f, -1.11335693e-02f, -1.12317435e-01f, 1.01390844e-02f, -4.72655222e-02f, -1.03532910e-01f, -1.04438759e-01f, -6.11804314e-02f,
  3.05484165e-03f, -5.21826036e-02f, 1.28230667e-02f, -2.95110000e-03f, 1.44977272e-02f, 1.50084570e-02f, -2.56651808e-02f, 4.93612187e-03f, -4.46255803e-02f, 2.60610064e-03f,
  5.46229146e-02f, 4.97556441e-02f, -5.03862128e-02f, -1.45808738e-02f, -1.43044407e-03f, 5.91757474e-04f, -2.16865842e-03f, 4.17305678e-02f, -5.92875248e-03f, -2.86834463e-02f,
  -5.19389892e-03f, -2.69116201e-02f, 2.61656493e-02f, 1.20355757e-02f, -5.38919158e-02f, -6.90849796e-02f, 7.86365755e-03f, -2.82918699e-02f, -2.48276871e-02f, 2.08817292e-02f,
  1.70040838e-02f, -9.23174154e-03f, 2.40985546e-02f, 5.82036935e-02f, -3.25338244e-02f, 5.05867042e-02f, 5.32834269e-02f, 1.70926340e-02f, 7.62760118e-02f, 7.35456571e-02f,
  -3.32931103e-03f, -5.68777360e-02f, 2.95979138e-02f, -2.00382550e-03f, 5.71884029e-02f, 5.62046431e-02f, 1.34393666e-02f, -4.43720222e-02f, 1.29498672e-02f, 1.04013160e-01f,
  -2.94649228e-02f, 7.23877698e-02f, -2.97936015e-02f, 4.51722220e-02f, 2.90030930e-02f, -8.75578225e-02f, 1.86366984e-03f, 2.93595716e-02f, -3.52855437e-02f, -1.31078996e-02f,
  3.47813457e-01f, -6.41768202e-02f, -4.81086187e-02f, -2.33262684e-02f, -1.37270197e-01f, -1.40388191e-01f, -1.59715801e-01f, -1.50247231e-01f, 2.73769982e-02f, 1.83647778e-02f,
  -8.57500583e-02f, 2.72023715e-02f, -2.46985513e-03f, 1.33210406e-01f, 5.35345413e-02f, -1.02520138e-01f, -8.13217014e-02f, 1.32687792e-01f, 1.73274189e-01f, 8.23238865e-03f,
  -1.28270358e-01f, -8.41734260e-02f, 1.25264898e-01f, 5.06453179e-02f, 6.33264482e-02f, 9.06385705e-02f, 9.40299034e-02f, -1.85121000e-02f, 9.76225138e-02f, 1.55978158e-01f,
  1.50712594e-01f, 6.54843599e-02f, -6.64998358e-03f, 6.08083420e-02f, -9.40094963e-02f, -8.15383159e-03f, -6.12209253e-02f, -3.79035994e-02f, 2.88091805e-02f, 4.43303734e-02f,
  -1.25086293e-01f, 3.08493730e-02f, -7.80190527e-02f, 1.10891629e-02f, -9.11996290e-02f, -2.58156341e-02f, -1.57410391e-02f, 1.13458909e-01f, 4.43537608e-02f, -1.23720979e-02f,
  -1.70581210e-02f, 2.80739423e-02f, 4.18251604e-02f, 6.21464774e-02f, 8.28249156e-02f, 1.99051984e-02f, 2.56827641e-02f, 2.80694086e-02f, 1.68282345e-01f, 2.52914935e-01f,
  7.93424398e-02f, -7.04888254e-02f, -6.15352616e-02f, -2.01009568e-02f, -4.19278853e-02f, 1.79466903e-02f, 2.65365690e-02f, -5.66754416e-02f, 4.06048521e-02f, -8.05874467e-02f,
  7.23428726e-02f, 5.46407793e-03f, 4.59845141e-02f, -8.61445628e-03f, 3.71766612e-02f, 1.33909313e-02f, -6.69822544e-02f, -4.02817689e-02f, 4.45375852e-02f, -3.14114504e-02f,
  5.93326129e-02f, -3.24758538e-03f, -8.32512379e-02f, 2.54925005e-02f, 5.92897087e-02f, -8.14480036e-02f, -8.04686770e-02f, 2.42394372e-03f, -2.23476049e-02f, 1.24868359e-02f,
  6.45125508e-02f, -1.02226749e-01f, 3.22867036e-02f, 4.07749936e-02f, 1.07583711e-02f, 6.35257214e-02f, -2.44547939e-03f, -5.83071522e-02f, -4.12820745e-03f, -4.26384620e-02f,
  -3.26125734e-02f, 9.26752761e-02f, -7.90426880e-02f, 3.44371423e-02f, -3.42417881e-02f, 3.07392725e-03f, -3.43864411e-02f, 6.80667982e-02f, -3.87155241e-03f, -1.78979822e-02f,
  -8.86604935e-02f, 3.32174897e-02f, 1.47764385e-01f, -2.10752655e-02f, -3.87260877e-02f, 8.10162202e-02f, 5.20021096e-02f, 1.19337372e-01f, 1.23417154e-01f, 9.31121334e-02f
};

// L0_fan_Wp_bar (Shape: 104 x 120)
const int L0_fan_Wp_bar_rows = 104;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -9.67777520e-02f, -1.07858535e-02f, 4.70723920e-02f, 6.64793923e-02f, 3.51082385e-02f, 2.47149225e-02f, -1.89804152e-04f, -1.17442764e-01f, 2.06461381e-02f, 4.85826805e-02f,
  -1.83959510e-02f, 3.65438797e-02f, -4.72379178e-02f, -4.83004231e-04f, -1.95119649e-01f, 3.66210379e-02f, 4.50340612e-03f, 3.07030929e-03f, -1.70445949e-01f, -8.63643736e-02f,
  -7.13663250e-02f, -8.24377239e-02f, -1.57581508e-01f, -4.82329018e-02f, 4.78415526e-02f, 1.32080197e-01f, 3.81002314e-02f, -6.94489256e-02f, -5.67223355e-02f, 1.19314931e-01f,
  2.21338153e-01f, -1.72850847e-01f, -9.21768174e-02f, 1.45086441e-02f, 2.52423994e-02f, 6.91603050e-02f, -4.23745885e-02f, 7.08257481e-02f, -1.51910968e-02f, 8.80548432e-02f,
  -3.90665568e-02f, -8.68061185e-02f, 4.66667255e-03f, -3.61605249e-02f, -5.45732416e-02f, -4.86888131e-03f, -1.10132515e-01f, -1.38260424e-01f, 1.99136976e-02f, -1.73161440e-02f,
  -5.29797114e-02f, -2.33967993e-02f, -6.98784774e-04f, -7.93887302e-02f, -1.02272332e-01f, -4.73201275e-02f, 2.66778134e-02f, 5.20639792e-02f, -4.66099493e-02f, 2.47683432e-02f,
  -1.06567629e-02f, 5.86841218e-02f, 6.08613603e-02f, 4.85808551e-02f, -1.91983171e-02f, 3.86394709e-02f, 5.00000231e-02f, 1.06846601e-01f, -3.08751632e-02f, 5.03583290e-02f,
  -6.53551891e-02f, 7.32333167e-03f, 8.25306773e-02f, -1.85668785e-02f, 4.88662310e-02f, 5.47125228e-02f, -5.66110983e-02f, 7.19885603e-02f, 3.25048491e-02f, -9.58213024e-03f,
  8.56522396e-02f, -7.20082819e-02f, 1.17850482e-01f, 4.07708958e-02f, -8.05056319e-02f, 5.56064732e-02f, 3.04498784e-02f, 2.22720532e-03f, 4.00912464e-02f, -3.91253345e-02f,
  2.33212531e-01f, -1.58917591e-01f, 1.71002939e-01f, -4.52007651e-02f, 5.46214543e-02f, 5.21104783e-02f, -1.73438508e-02f, 6.42537177e-02f, 9.50866640e-02f, 2.83861607e-02f,
  1.82494167e-02f, -2.83686891e-02f, -2.73936018e-02f, 9.15365592e-02f, 2.70925947e-02f, 4.98194434e-02f, 9.67015103e-02f, -7.63947815e-02f, 4.37694117e-02f, 3.74078192e-02f,
  8.59599188e-03f, 3.40240709e-02f, 4.08946052e-02f, 5.03950827e-02f, 4.53954004e-02f, -8.23625624e-02f, 8.84350464e-02f, 4.46875393e-02f, 3.76459770e-02f, 1.61154464e-01f,
  9.53376368e-02f, -1.12630963e-01f, 6.86094537e-02f, -1.04928231e-02f, -1.45906538e-01f, -1.54011860e-01f, -1.91638902e-01f, -4.26046140e-02f, -2.65611839e-02f, -1.81587130e-01f,
  -5.07525690e-02f, 5.95033616e-02f, -2.06694417e-02f, 6.10840917e-02f, 9.35407206e-02f, 2.18180716e-02f, 6.85177818e-02f, 7.41973445e-02f, 4.06958163e-03f, -8.36251825e-02f,
  -3.10960282e-02f, 1.00057553e-02f, -9.61400475e-03f, -5.88269681e-02f, 9.30973701e-03f, -8.61370564e-02f, 1.23603325e-02f, -2.51983255e-02f, -2.69946698e-02f, -8.00331086e-02f,
  -5.42228902e-03f, 4.28343564e-02f, -2.72399746e-02f, -6.04681149e-02f, -8.31249228e-04f, -2.21521966e-02f, -1.25169069e-01f, 1.19754151e-01f, 3.50246504e-02f, -9.53296572e-02f,
  -2.95924153e-02f, 4.92438069e-03f, 1.20886844e-02f, -5.76287620e-02f, 3.56283151e-02f, 4.35840823e-02f, 7.11080879e-02f, 1.51855081e-01f, 1.20523818e-01f, -7.28952512e-02f,
  -2.98680216e-02f, 4.55529103e-03f, 6.39247000e-02f, -7.07278922e-02f, -5.20886667e-02f, 4.21081744e-02f, -4.50013839e-02f, 1.84483360e-02f, 1.23568304e-01f, -8.44707116e-02f,
  -8.61575976e-02f, 8.50669295e-02f, 1.01579539e-01f, 6.19869940e-02f, -3.20227630e-02f, -6.11350872e-02f, 8.20759386e-02f, -9.57836807e-02f, 3.70482542e-02f, 5.76783679e-02f,
  4.81393822e-02f, -6.43010139e-02f, -5.13973981e-02f, 2.63623372e-02f, 5.69498874e-02f, -7.66863301e-03f, -3.90495472e-02f, -5.87089546e-02f, -7.01438263e-02f, -2.30779499e-02f,
  1.73279475e-02f, 7.22482800e-02f, 4.48449329e-02f, 2.99803726e-02f, -1.00779543e-02f, -3.05085983e-02f, 7.34056383e-02f, -1.85689318e-03f, 5.34114651e-02f, -5.25963008e-02f,
  -8.77170935e-02f, 1.79090872e-01f, -1.16642945e-01f, 8.23393837e-02f, -2.99862437e-02f, -2.09599081e-02f, 1.05820335e-02f, 2.27780230e-02f, -1.18200136e-02f, -6.54554442e-02f,
  -1.05229944e-01f, 7.16064498e-02f, -3.35130692e-02f, -2.75854319e-02f, -2.13208552e-02f, -4.88477200e-02f, -6.99832365e-02f, -6.99666962e-02f, 1.99146140e-02f, 1.54605054e-03f,
  -1.39466822e-01f, -1.33473590e-01f, -7.99993500e-02f, -1.13858432e-01f, -2.51746438e-02f, 2.19313279e-02f, -8.33876207e-02f, -4.78581227e-02f, -4.59215716e-02f, -1.16818227e-01f,
  -8.70471373e-02f, -3.91799547e-02f, -5.26367314e-02f, -2.01828986e-01f, 2.30625812e-02f, -4.23425063e-03f, 9.97725576e-02f, 2.10150741e-02f, -3.24331485e-02f, 2.55966168e-02f,
  7.59429783e-02f, 8.79067089e-03f, 2.07091738e-02f, -6.53560162e-02f, -2.64518000e-02f, 3.55964564e-02f, -1.01747476e-01f, -4.67791259e-02f, -2.37047616e-02f, -1.16929496e-02f,
  4.16397713e-02f, -1.42565712e-01f, -2.05543973e-02f, 2.63344543e-03f, -8.57180506e-02f, -1.03563756e-01f, -6.94682300e-02f, -4.04379107e-02f, -5.05887531e-02f, -9.84108299e-02f,
  -7.29929656e-02f, -4.64225560e-02f, 1.03735395e-01f, 1.42348275e-01f, 2.57873675e-03f, -2.59367470e-02f, 6.42581210e-02f, 5.68201281e-02f, 2.58373786e-02f, -8.09644163e-02f,
  -7.39391744e-02f, -7.61285052e-02f, -4.16596979e-02f, 6.54942766e-02f, 5.78490198e-02f, -4.50407341e-02f, -3.90560692e-03f, 9.44307446e-02f, -3.26868333e-02f, 7.54840896e-02f,
  3.45902443e-02f, 1.06048174e-01f, -2.49113385e-02f, -1.56784977e-03f, 3.64368036e-02f, 4.57103960e-02f, 1.33778406e-02f, 7.37591982e-02f, -2.17093062e-02f, -1.16157532e-02f,
  -6.13005320e-03f, 6.32324144e-02f, 1.00078948e-01f, -7.18014091e-02f, -2.81097349e-02f, -4.13030088e-02f, 3.96661786e-03f, 6.61374703e-02f, -4.61948588e-02f, 2.38922313e-02f,
  4.11198437e-02f, 7.50725865e-02f, 5.13358526e-02f, -6.38945326e-02f, 6.72338009e-02f, -3.16368192e-02f, -6.12408631e-02f, -5.24841435e-02f, -7.51454607e-02f, -3.80750746e-02f,
  7.68557340e-02f, 9.90816671e-03f, -8.56999531e-02f, 3.06911170e-02f, 4.09270637e-02f, 9.61189643e-02f, 6.53728917e-02f, 8.45987946e-02f, -7.66414478e-02f, -4.44112569e-02f,
  -3.34136002e-02f, 2.23843791e-02f, 4.55112606e-02f, 5.23877256e-02f, -3.50362435e-02f, -1.93118323e-02f, -4.53066938e-02f, 2.01849509e-02f, -1.05934456e-01f, -5.26567772e-02f,
  -4.41937372e-02f, 5.44251464e-02f, 3.27676572e-02f, -2.69442890e-02f, 4.05599587e-02f, 3.72737050e-02f, -5.55794723e-02f, -1.43010067e-04f, 4.02329788e-02f, 2.91174892e-02f,
  3.01317349e-02f, -2.16422928e-03f, -4.27366719e-02f, -2.33486332e-02f, 4.27026413e-02f, 9.03198346e-02f, -5.71363531e-02f, -1.07202101e-02f, 6.68831468e-02f, -8.57924893e-02f,
  -5.91941178e-03f, 1.87910181e-02f, 2.09361650e-02f, -7.41635412e-02f, 2.74540149e-02f, -8.72715041e-02f, 3.69217247e-02f, -9.45751965e-02f, 2.96856705e-02f, 1.20320491e-01f,
  4.96695808e-04f, -9.53384265e-02f, -6.42455220e-02f, 4.60583456e-02f, 3.50523763e-03f, 7.39612728e-02f, -4.90372488e-03f, -1.38498098e-01f, -1.40748382e-01f, -9.78271589e-02f,
  -7.40754232e-02f, -6.22246191e-02f, 2.73002461e-02f, 3.81656997e-02f, 7.43587017e-02f, -1.05408713e-01f, -2.03978531e-02f, -7.91023020e-03f, -4.94074309e-03f, -3.07165887e-02f,
  -3.63318659e-02f, 3.55204158e-02f, -9.26977396e-02f, 7.62929544e-02f, 1.90223195e-02f, 5.29569164e-02f, -7.88141321e-03f, -3.23308371e-02f, -5.15406113e-03f, 3.58051099e-02f,
  1.01239651e-01f, -6.63182288e-02f, -4.84553389e-02f, 2.34116316e-02f, -5.94788194e-02f, -6.60986220e-03f, 1.02681533e-01f, -2.48513408e-02f, -1.25644477e-02f, 8.15377161e-02f,
  1.15000322e-01f, 3.88489850e-03f, 3.98564264e-02f, -1.46512864e-02f, -7.46164396e-02f, 3.09237521e-02f, 7.69125298e-02f, -1.74048878e-02f, -8.42666849e-02f, 5.91833629e-02f,
  1.25376442e-02f, 3.21502872e-02f, -2.31493288e-03f, 9.08735543e-02f, 4.94767725e-02f, 7.62568787e-02f, 9.93576795e-02f, 2.71962546e-02f, 1.99904591e-02f, 1.54095571e-02f,
  8.80837217e-02f, 9.04896781e-02f, 2.26555988e-02f, -4.31704000e-02f, 6.15615286e-02f, 3.49292066e-03f, -6.89683184e-02f, -3.70143242e-02f, 3.69305164e-02f, 2.99048927e-02f,
  -5.48572131e-02f, 2.03484986e-02f, -8.16905200e-02f, -3.16018462e-02f, -1.55830346e-02f, 9.84938368e-02f, 8.54952931e-02f, 1.27695818e-02f, -7.43346214e-02f, -6.37225360e-02f,
  3.69591415e-02f, -1.10860914e-01f, -1.35383187e-02f, -5.90420030e-02f, 2.56650895e-02f, 4.77772914e-02f, -2.29506660e-02f, 2.41083512e-03f, 8.42908323e-02f, -1.71478726e-02f,
  3.28609645e-02f, 9.13872719e-02f, 1.59956496e-02f, -4.66103181e-02f, -7.81711936e-03f, 9.11580212e-03f, 7.39595518e-02f, -5.99625986e-03f, -1.40000349e-02f, 9.47344303e-03f,
  -1.91170219e-02f, -7.25228712e-02f, 1.03654778e-02f, -8.21275860e-02f, -5.26353605e-02f, -9.16705132e-02f, -1.68310832e-02f, -6.30001947e-02f, -7.08403364e-02f, 7.49375746e-02f,
  2.08954141e-02f, -1.03758782e-01f, -5.31033054e-02f, -2.22583339e-02f, -3.56635898e-02f, -6.33039847e-02f, -1.08449481e-01f, 2.97106225e-02f, -8.64866078e-02f, -1.23984717e-01f,
  -4.77416106e-02f, 8.44317749e-02f, -1.62232611e-02f, 2.97804624e-02f, -2.64343582e-02f, -1.25497058e-01f, -1.17084540e-01f, -7.79918209e-02f, 6.31326362e-02f, 8.55727717e-02f,
  -2.87982859e-02f, 3.30081061e-02f, 2.26202561e-03f, -1.18473852e-02f, 5.37498705e-02f, 5.25626093e-02f, -3.47114354e-02f, 6.79420121e-03f, -6.98680878e-02f, -1.14111379e-01f,
  -1.04485869e-01f, 8.64471197e-02f, -6.11413643e-03f, 1.69168524e-02f, 4.22087908e-02f, 7.89784044e-02f, -7.26768821e-02f, -2.65175439e-02f, -5.77497669e-02f, 1.78547688e-02f,
  7.25602265e-03f, -8.46304372e-03f, -7.42907375e-02f, -5.13969325e-02f, -2.41473177e-03f, -7.52772298e-03f, 5.53236492e-02f, -6.44169897e-02f, 8.18906799e-02f, 2.56558284e-02f,
  -2.79885828e-02f, 6.42481148e-02f, -8.29100534e-02f, 6.53274655e-02f, -6.05367348e-02f, 8.43845606e-02f, 3.30365747e-02f, -2.41060928e-02f, -6.83157295e-02f, 3.73494141e-02f,
  -5.06696030e-02f, 1.33559015e-02f, 4.44257148e-02f, 3.65424529e-02f, 7.11190626e-02f, 8.11978430e-02f, 2.73609702e-02f, 7.87809864e-02f, 4.52075386e-03f, 7.15733171e-02f,
  7.89171923e-03f, 7.40585402e-02f, -4.20146585e-02f, -6.42856881e-02f, -6.37916550e-02f, 6.57594576e-02f, 8.84638205e-02f, 6.06122427e-02f, 8.03414211e-02f, 4.73151393e-02f,
  3.17049101e-02f, 5.60610332e-02f, -2.01628841e-02f, -5.05120829e-02f, 5.48336096e-02f, 9.27045867e-02f, 3.32360454e-02f, 8.30320567e-02f, 5.55465333e-02f, 3.34676951e-02f,
  6.45861775e-02f, 9.95938666e-03f, -4.33018664e-03f, 5.43118455e-02f, -4.18582931e-02f, 1.96474791e-03f, 2.33182479e-02f, 7.29745477e-02f, 8.20776820e-02f, -1.19106313e-02f,
  -5.92417344e-02f, -7.10722953e-02f, -7.13073686e-02f, -6.41037747e-02f, -5.35839982e-02f, -5.55926375e-02f, 6.95415959e-03f, -7.71366507e-02f, -6.19856901e-02f, -7.90804252e-03f,
  9.13678482e-03f, 4.42817248e-02f, -2.68918797e-02f, -1.07399836e-01f, -3.64384837e-02f, -6.14785068e-02f, 1.52763426e-02f, 1.18611241e-02f, 4.32068780e-02f, -8.90524387e-02f,
  -1.34551898e-01f, -1.66995421e-01f, -3.31313759e-01f, -1.78601846e-01f, 4.74128872e-03f, 9.97518152e-02f, 9.56229344e-02f, 8.38451460e-02f, -1.30738467e-01f, -7.87729919e-02f,
  1.51647981e-02f, 2.90663131e-02f, -3.10702845e-02f, -5.30972779e-02f, -6.47988543e-02f, -1.37737423e-01f, -1.32104561e-01f, -3.27193625e-02f, 3.31294462e-02f, 1.61160499e-01f,
  1.00285329e-01f, -9.32002515e-02f, -1.71615519e-02f, -9.97546613e-02f, -4.21766937e-02f, -1.60223380e-01f, -1.71834052e-01f, -2.03736633e-01f, -1.46065935e-01f, -1.55178025e-01f,
  -1.63336217e-01f, 5.16550131e-02f, 5.86857200e-02f, 1.39056472e-02f, 4.15521190e-02f, 5.39764911e-02f, -3.79085466e-02f, -1.04592353e-01f, 3.29577737e-03f, -1.09292619e-01f,
  -4.44846824e-02f, -9.77886654e-03f, 2.60939449e-03f, 3.19753662e-02f, 1.81403458e-02f, -2.58821752e-02f, -9.17486846e-02f, 3.66591103e-02f, -9.62873828e-03f, 4.57684509e-02f,
  -1.66126825e-02f, 6.53817281e-02f, -1.38164446e-01f, 3.78696173e-02f, -8.63571838e-02f, -7.31200129e-02f, 2.13558357e-02f, -2.00909786e-02f, -3.58135961e-02f, -6.55814558e-02f,
  1.88694168e-02f, -1.06459849e-01f, 1.68854464e-02f, -4.68177721e-02f, 2.11503785e-02f, -9.53631103e-02f, -6.11023866e-02f, 6.52543306e-02f, 8.48174840e-02f, -2.20343564e-02f,
  4.84425686e-02f, -1.40724741e-02f, -5.67896813e-02f, -3.20349187e-02f, -6.17517196e-02f, 1.01539427e-02f, 1.67696439e-02f, 1.79341342e-02f, -1.95861477e-02f, 3.16878036e-02f,
  -6.06662631e-02f, -3.58534083e-02f, -9.14090592e-03f, -5.02249971e-02f, -7.27881342e-02f, -7.82271102e-03f, -3.21834311e-02f, 3.35803293e-02f, 3.88808548e-02f, -2.40023602e-02f,
  -1.75860718e-01f, 9.72972885e-02f, -4.31983620e-02f, 5.11714444e-02f, -4.52946275e-02f, 7.19131529e-02f, -1.06940329e-01f, -4.75060120e-02f, 4.09635156e-02f, 1.28547149e-02f,
  1.15432717e-01f, 5.36606610e-02f, 2.12252736e-02f, 2.35736296e-02f, 1.80240930e-03f, 4.41035591e-02f, 2.10016277e-02f, -2.34439205e-02f, 4.03945111e-02f, -3.46302055e-02f,
  2.21744627e-02f, -1.43189607e-02f, -1.24133408e-01f, -1.27483845e-01f, -9.29220393e-02f, -9.59237888e-02f, 1.46980844e-02f, -1.19922094e-01f, 2.22992599e-02f, -1.69458672e-01f,
  5.35828760e-03f, -1.25969723e-01f, -3.15277338e-01f, -1.56540915e-01f, -9.35887918e-02f, 1.26323909e-01f, 1.35976613e-01f, 3.51569355e-02f, 1.39931850e-02f, 2.31138207e-02f,
  9.29140076e-02f, 3.49399522e-02f, 3.96449193e-02f, 9.74771678e-02f, 8.88274983e-02f, -6.45728484e-02f, -1.69797406e-01f, -7.94651359e-02f, 5.59893548e-02f, 1.64280273e-02f,
  1.11665189e-01f, -1.53300181e-01f, -1.21854953e-01f, -1.44009039e-01f, -1.08790338e-01f, -1.69103146e-01f, -1.63075745e-01f, -7.82898664e-02f, 2.47331634e-02f, -8.23464766e-02f,
  -1.14764571e-01f, -6.79952800e-02f, -5.90509623e-02f, -4.23356928e-02f, -8.52486268e-02f, 6.92112967e-02f, 9.01181251e-03f, -1.35891974e-01f, -2.02203374e-02f, 4.15479913e-02f,
  -7.24907368e-02f, -5.52003309e-02f, -1.12653770e-01f, -8.54521319e-02f, 5.33808731e-02f, -7.23208338e-02f, -4.33884077e-02f, -7.04105012e-03f, -1.00230232e-01f, 5.89061156e-02f,
  -1.27194738e-02f, -2.29048654e-02f, -3.13469879e-02f, -7.48850927e-02f, -3.29774315e-03f, -6.21631043e-04f, -1.73011646e-02f, -2.20265128e-02f, 3.52745429e-02f, -1.11978285e-01f,
  1.13960564e-01f, 5.07499613e-02f, -5.18402979e-02f, 3.69789191e-02f, 1.32979721e-01f, -3.61357257e-02f, 4.97724451e-02f, -5.04358448e-02f, -4.76958007e-02f, -8.93664807e-02f,
  -6.93967938e-02f, 9.28637851e-03f, 8.33606422e-02f, -1.12914331e-02f, -1.09059718e-02f, -1.58793256e-02f, -6.39213296e-03f, -5.67892054e-03f, -4.71683703e-02f, -6.53240234e-02f,
  3.27465944e-02f, -9.20097753e-02f, -1.05360962e-01f, -6.46103099e-02f, 5.99901862e-02f, 9.11306962e-03f, -3.12104635e-02f, 2.47759949e-02f, 8.95194709e-03f, -4.71648201e-02f,
  -1.34885442e-02f, -4.43110503e-02f, 6.00255607e-03f, -1.57546587e-02f, -4.38043401e-02f, -1.75170656e-02f, -1.10436909e-01f, 1.31375790e-02f, -3.49673592e-02f, -3.94602828e-02f,
  7.39903823e-02f, -1.76347047e-02f, -4.61660773e-02f, -2.12573651e-02f, 9.20803621e-02f, 1.18824877e-01f, 5.86546548e-02f, -2.76995730e-02f, 7.45698214e-02f, -6.39644731e-03f,
  -4.82718237e-02f, -5.30868676e-03f, 9.58404019e-02f, -8.14943984e-02f, 6.31372780e-02f, -5.53659275e-02f, 6.92419149e-03f, -1.06001766e-02f, 7.48011619e-02f, 4.99530509e-02f,
  1.84772611e-02f, 5.16475644e-03f, 7.38723800e-02f, 5.08771166e-02f, -1.21438978e-02f, -5.00893518e-02f, -1.09465554e-01f, -6.26014993e-02f, -3.56989279e-02f, -2.73917452e-04f,
  -3.18771042e-02f, 2.24640705e-02f, -7.11217597e-02f, -6.74511269e-02f, -5.42383529e-02f, 1.85134318e-02f, 6.16812408e-02f, 7.27395266e-02f, 5.05878516e-02f, 6.06824346e-02f,
  1.27255323e-03f, 5.20433336e-02f, 8.74119923e-02f, -2.31628064e-02f, 7.41815986e-03f, -1.79834850e-02f, -5.15429154e-02f, 4.01222594e-02f, 2.49726977e-02f, 9.04529616e-02f,
  -4.32358123e-02f, -8.33438188e-02f, -7.44426325e-02f, -1.13863595e-01f, -4.29284992e-03f, -5.35559878e-02f, -2.57267002e-02f, 2.06672922e-02f, -1.14930635e-02f, -4.77455482e-02f,
  3.37343663e-02f, -1.99183580e-02f, -1.14581078e-01f, -5.21612316e-02f, 7.98960477e-02f, -5.37105873e-02f, 1.91045459e-02f, 7.69353211e-02f, 2.56383009e-02f, -1.01028113e-02f,
  -9.73714795e-03f, 2.43741591e-02f, 3.60755175e-02f, -2.02458836e-02f, 2.54233158e-03f, 2.63620857e-02f, 2.64498442e-02f, 5.70164528e-03f, 3.28980200e-02f, 7.62088150e-02f,
  -2.43240558e-02f, -8.78667384e-02f, 5.50392307e-02f, -4.98929322e-02f, -1.25336200e-02f, -1.70081877e-03f, -3.26718949e-02f, -5.74971922e-02f, -2.67408080e-02f, -8.16406980e-02f,
  -6.42765537e-02f, -1.90890357e-02f, -5.19698635e-02f, 1.59143768e-02f, 5.08356616e-02f, -5.96420169e-02f, 5.80334701e-02f, 7.97551766e-04f, 7.13399053e-02f, 4.10279743e-02f,
  -5.74548170e-02f, -7.65998363e-02f, 3.97326276e-02f, 3.74002010e-02f, 2.12276280e-02f, 1.25143025e-02f, -2.51330640e-02f, -1.47878351e-02f, 1.26925213e-02f, -6.66724816e-02f,
  -5.15766405e-02f, -8.34558532e-02f, 7.22029135e-02f, -2.95769591e-02f, 1.07277408e-01f, 7.28420541e-03f, -2.85533853e-02f, 1.02140367e-01f, 7.98145533e-02f, 6.22654781e-02f,
  7.14678019e-02f, -2.27403436e-02f, 2.79800631e-02f, -8.85466784e-02f, 1.08273946e-01f, 9.66493562e-02f, 2.73646079e-02f, 6.24418445e-02f, 6.82573095e-02f, 1.60230584e-02f,
  4.65406338e-03f, -1.83818117e-03f, 2.13364474e-02f, 2.47140210e-02f, 2.93378439e-02f, -7.19713047e-02f, 4.93766293e-02f, 4.26931083e-02f, 3.66810411e-02f, 9.96990651e-02f,
  1.53921485e-01f, -2.01519445e-01f, -2.19268706e-02f, 6.42011315e-02f, -1.17785901e-01f, -1.38952911e-01f, -2.22929224e-01f, -7.93321133e-02f, -3.15064914e-03f, -3.01444661e-02f,
  2.66385730e-02f, 2.20401995e-02f, 1.90405369e-01f, 8.55130181e-02f, 1.59738094e-01f, -4.81007621e-02f, -4.69750091e-02f, 1.67872861e-01f, 1.71804860e-01f, -1.33350477e-01f,
  -9.86553580e-02f, -3.92977819e-02f, 1.08266860e-01f, 1.30193144e-01f, -8.86394531e-02f, -4.59569208e-02f, 1.71637759e-02f, 6.07367717e-02f, -1.73010863e-02f, 2.19621249e-02f,
  -2.26825029e-02f, -3.23168421e-03f, 1.06632061e-01f, 3.72785963e-02f, -6.07658178e-03f, 6.68046251e-02f, -5.68532422e-02f, 8.15393850e-02f, -4.38519288e-03f, 2.06235312e-02f,
  4.16491255e-02f, -1.96952075e-02f, 1.12234233e-02f, -1.06288768e-01f, -7.85687193e-02f, 7.86109939e-02f, 6.74866140e-03f, 1.46157131e-01f, 8.31716731e-02f, -9.32458043e-02f,
  -1.15749091e-01f, -5.08461371e-02f, 6.39984384e-02f, 8.41940418e-02f, 8.51356238e-03f, 8.23851898e-02f, -1.13630295e-02f, 3.53339016e-02f, 1.23535834e-01f, -9.87787098e-02f,
  -1.03924412e-03f, -3.89675163e-02f, 1.15537904e-01f, -6.44676834e-02f, 4.36327383e-02f, 6.29334822e-02f, -9.98275131e-02f, -7.21252710e-02f, 5.42326421e-02f, -3.32935266e-02f,
  -1.85292400e-02f, 4.12874296e-02f, 5.90201728e-02f, -2.90246978e-02f, -3.06346305e-02f, -6.07232898e-02f, 6.61566434e-03f, 7.74932280e-02f, 1.17013238e-01f, -3.63701694e-02f,
  7.26284906e-02f, -2.33688243e-02f, -1.61431046e-04f, 7.07215071e-02f, -6.48466051e-02f, -4.52130511e-02f, 2.34610830e-02f, 7.04976469e-02f, 6.27033263e-02f, 5.53594716e-02f,
  -1.94308478e-02f, 2.94103742e-01f, -4.11870368e-02f, 6.62159501e-03f, 3.08597200e-02f, 9.80378166e-02f, -1.90726724e-02f, 6.41353577e-02f, -3.61449309e-02f, -1.07274555e-01f,
  4.73932177e-02f, 5.97900599e-02f, -7.40309879e-02f, -1.27489753e-02f, -6.13937480e-03f, 5.11779785e-02f, -3.82324122e-02f, -1.32611487e-02f, 8.24193433e-02f, -5.89718446e-02f,
  -2.25303229e-03f, -9.22232270e-02f, -6.22008368e-02f, 6.65175840e-02f, 7.01878453e-03f, 1.41467556e-01f, 6.55454993e-02f, -6.73359167e-03f, 4.57766764e-02f, -1.51566043e-01f,
  -3.03819478e-01f, 3.26939747e-02f, 1.03620850e-01f, -2.62320548e-01f, -1.32150605e-01f, -1.00773364e-01f, -1.04090549e-01f, -8.15694556e-02f, -1.86418325e-01f, -6.55606017e-02f,
  7.16852248e-02f, 1.59681246e-01f, 1.71617731e-01f, 1.02183953e-01f, -6.57434016e-03f, -6.15252405e-02f, 3.28017659e-02f, 2.84655187e-02f, 1.20151535e-01f, 3.98269705e-02f,
  7.96486139e-02f, -1.21104792e-02f, -1.32140085e-01f, -3.10595557e-02f, -4.11179326e-02f, -5.50095774e-02f, 5.53775504e-02f, -8.75839405e-03f, 9.94511470e-02f, -2.51520649e-02f,
  3.65799010e-01f, -2.48527646e-01f, 4.10512872e-02f, -1.14844993e-01f, -2.60338504e-02f, -2.54747439e-02f, 6.47575548e-03f, -6.45386726e-02f, -4.75732721e-02f, -1.89625062e-02f,
  6.05760096e-03f, -7.61365816e-02f, 6.26299977e-02f, -2.46384293e-02f, -4.78701107e-02f, 3.81471254e-02f, -1.18541919e-01f, -1.05901323e-01f, 6.88867236e-04f, 8.41111019e-02f,
  9.76123661e-03f, -7.78694695e-04f, -3.97331733e-03f, -3.94766405e-02f, -8.68488569e-03f, 9.03104693e-02f, 6.07555136e-02f, 2.76743528e-02f, 4.43039201e-02f, 1.15440171e-02f,
  5.43902256e-02f, 1.80773083e-02f, -1.28170913e-02f, 6.35206178e-02f, 1.46082677e-02f, -5.57191707e-02f, -2.47738585e-02f, -6.52057230e-02f, 3.29198167e-02f, -2.66563930e-02f,
  -3.17679122e-02f, 3.71692516e-02f, 4.31976356e-02f, 6.64431006e-02f, 5.29112816e-02f, -4.48858999e-02f, -2.72862036e-02f, -4.33146916e-02f, -4.20678556e-02f, -6.90493407e-03f,
  -9.16125346e-03f, 4.08093929e-02f, -5.03718853e-02f, 9.58630145e-02f, -8.16762298e-02f, -3.55785787e-02f, 1.58054177e-02f, 5.45198657e-03f, -6.13830462e-02f, -9.65207517e-02f,
  1.82791144e-01f, -8.57894644e-02f, 5.76260462e-02f, -7.72965625e-02f, -2.30664033e-02f, 3.87428626e-02f, -1.67734344e-02f, -8.84057581e-02f, -3.70641463e-02f, -5.83515950e-02f,
  6.32303059e-02f, -2.11416781e-02f, 2.97752582e-03f, 5.25000272e-03f, -2.42932998e-02f, 7.80760050e-02f, -1.08178169e-01f, 2.36819368e-02f, -5.50137162e-02f, -5.51171415e-02f,
  3.16845290e-02f, 4.60268222e-02f, 3.18159349e-02f, 2.34029237e-02f, 4.62459438e-02f, 1.23920724e-01f, 1.97998136e-01f, 1.48954736e-02f, 1.43575752e-02f, 1.33551687e-01f,
  -3.80860977e-02f, 7.30103925e-02f, 5.36122546e-02f, 1.73320938e-02f, -9.30159464e-02f, -3.47721502e-02f, -2.17467640e-03f, 5.02109118e-02f, 1.37599319e-01f, 1.04931667e-01f,
  1.22011825e-01f, 8.42096359e-02f, 4.80645113e-02f, 8.61664563e-02f, 6.75413981e-02f, 1.32576719e-01f, -5.62319122e-02f, 9.16835442e-02f, 1.84613802e-02f, -1.34115871e-02f,
  -8.07445720e-02f, -9.93097425e-02f, -5.34263141e-02f, 5.86478077e-02f, 1.13815263e-01f, -4.00902107e-02f, 4.85364124e-02f, 4.26972322e-02f, -2.41253860e-02f, 3.18309143e-02f,
  -2.63222377e-03f, -8.74417927e-03f, -1.06431335e-01f, -7.46816844e-02f, -9.59262550e-02f, 1.71412639e-02f, 3.75743136e-02f, 5.17441072e-02f, -5.09351902e-02f, -3.91082354e-02f,
  -1.53597007e-02f, -3.36265638e-02f, 4.80592288e-02f, 4.54011839e-03f, -8.18250980e-03f, -2.59214994e-02f, -1.56752430e-02f, -2.68225446e-02f, -6.19976898e-04f, 2.67082243e-03f,
  -5.22731170e-02f, 3.10290363e-02f, -8.52465555e-02f, 1.23426048e-02f, 4.02559265e-02f, 7.88002163e-02f, 4.87640388e-02f, 2.03619674e-02f, 6.18802942e-02f, -6.64772233e-03f,
  7.96446670e-03f, -2.59706788e-02f, 9.41510219e-03f, 9.90341157e-02f, -3.80693600e-02f, 9.79442969e-02f, -7.97333270e-02f, -7.34612122e-02f, -1.22059416e-02f, 4.65517305e-02f,
  -1.86466500e-02f, 8.63176659e-02f, 7.87494779e-02f, -1.12983640e-02f, 2.26677977e-03f, -2.04075165e-02f, -1.75515062e-03f, 8.81813616e-02f, -4.86749038e-03f, -3.78994159e-02f,
  -5.24472892e-02f, 8.58073831e-02f, -1.61330607e-02f, 6.85661584e-02f, 2.36908384e-02f, -8.66758078e-02f, 7.63227371e-03f, 3.99201289e-02f, -9.60145146e-02f, -7.50013813e-02f,
  -5.71071208e-02f, -3.19402516e-02f, 5.21528870e-02f, 6.23327494e-02f, -2.29328610e-02f, -7.37786591e-02f, 6.33404870e-03f, 6.06391914e-02f, 6.02263734e-02f, 1.50430389e-02f,
  2.68594380e-02f, 6.38012886e-02f, 5.63618839e-02f, 5.40281609e-02f, -6.90987632e-02f, -5.65906093e-02f, -2.17952449e-02f, -7.00628310e-02f, -5.82904480e-02f, 2.41695344e-02f,
  4.78605442e-02f, 2.01174058e-04f, 7.34589472e-02f, -3.20933908e-02f, -5.86674958e-02f, -6.34562671e-02f, -6.68835193e-02f, 2.71451231e-02f, 3.11738066e-03f, 1.02929221e-02f,
  1.94597587e-01f, -6.87744990e-02f, 1.29782602e-01f, 1.57882005e-01f, 1.79040536e-01f, 8.53734687e-02f, 1.05143815e-01f, -1.63520072e-02f, 1.81039181e-02f, -4.64705266e-02f,
  7.34035149e-02f, 8.69988650e-02f, 8.15592259e-02f, 1.95865761e-02f, -6.03184253e-02f, -2.17827745e-02f, -7.01693669e-02f, -8.08080938e-03f, 1.11832932e-01f, 7.21115470e-02f,
  6.94097802e-02f, -6.15451392e-03f, 7.04228431e-02f, 5.14733456e-02f, -3.00381593e-02f, 5.34952758e-03f, -1.84566621e-02f, 5.73640838e-02f, 4.78621349e-02f, -9.79307517e-02f,
  7.01605603e-02f, -3.61164659e-02f, 6.12602830e-02f, 3.85380648e-02f, 7.19440822e-03f, 2.67831571e-02f, -2.92453952e-02f, -4.50116992e-02f, -1.03201486e-01f, -7.06895739e-02f,
  -7.71865994e-02f, -5.23775853e-02f, -2.48921011e-02f, 3.95361707e-03f, -3.30728479e-02f, 4.43243869e-02f, -2.46086996e-02f, -1.13722637e-01f, 2.84841955e-02f, 1.28241431e-03f,
  7.39251263e-03f, -3.57337226e-03f, 8.13293830e-02f, 1.86132770e-02f, 5.18432483e-02f, 7.65469819e-02f, -8.28672200e-02f, -8.78923293e-03f, -1.81103610e-02f, -9.12335366e-02f,
  3.90331559e-02f, 1.16154803e-02f, 1.33962128e-02f, -7.80225843e-02f, -7.65866339e-02f, 5.78178093e-02f, -5.95000833e-02f, 3.42995450e-02f, -1.75210629e-02f, 1.59613043e-02f,
  3.74410972e-02f, -2.61811092e-02f, 3.69181670e-02f, 8.85071456e-02f, 6.02690838e-02f, 8.95409659e-02f, 2.81435810e-02f, -4.07167487e-02f, -4.95657697e-02f, -3.28826085e-02f,
  2.27192901e-02f, -4.67864797e-02f, 5.86029217e-02f, 7.84454644e-02f, -5.91174960e-02f, 4.32418697e-02f, -3.60034108e-02f, 7.95865208e-02f, 3.33562158e-02f, -5.71018271e-02f,
  -3.03151719e-02f, 5.36099784e-02f, -8.20320379e-03f, -4.52866852e-02f, 5.61617725e-02f, -7.01550245e-02f, 8.01846310e-02f, -1.01694591e-01f, -6.09817877e-02f, -6.83289096e-02f,
  9.51475501e-02f, -6.64300546e-02f, -5.91912270e-02f, -2.22705901e-02f, -4.98846499e-03f, -1.98145472e-02f, -2.37671733e-02f, 5.32958619e-02f, -9.41914227e-03f, -2.97729149e-02f,
  -2.18432825e-02f, 7.66025260e-02f, 7.69968405e-02f, 6.98447675e-02f, 7.01800138e-02f, -3.43132019e-02f, -9.91104264e-03f, -7.59834573e-02f, 1.06060980e-02f, 1.31244035e-02f,
  2.13507518e-01f, -8.97226259e-02f, 1.56199381e-01f, -1.57044735e-02f, 1.21359685e-02f, -5.85490242e-02f, -1.62651520e-02f, 8.00992921e-02f, 3.37815247e-02f, -6.86092451e-02f,
  1.50892651e-02f, -1.17753372e-01f, -9.76549461e-02f, -3.85873057e-02f, 2.06534807e-02f, -1.05882166e-02f, -7.55285025e-02f, 8.01215842e-02f, 9.25671607e-02f, 6.30319417e-02f,
  1.79712323e-03f, 1.28751352e-01f, 1.40830547e-01f, -3.55734676e-02f, -3.40921544e-02f, 2.99527925e-02f, -2.02031787e-02f, 7.73687288e-02f, -2.24744380e-02f, -4.23313752e-02f,
  -6.25619143e-02f, 1.02825411e-01f, -7.83592314e-02f, 4.13966253e-02f, -7.45874196e-02f, -1.27668679e-02f, -2.58933250e-02f, 1.03578053e-01f, -6.56013340e-02f, 5.33199161e-02f,
  -4.60379347e-02f, -9.02662799e-02f, -6.89262152e-02f, 1.02872383e-02f, 1.93253495e-02f, 1.17238509e-02f, 1.01867773e-01f, 2.43508420e-03f, -3.95275988e-02f, -8.29747841e-02f,
  -8.35797712e-02f, 1.85203347e-02f, -6.55135326e-03f, -7.00098202e-02f, 4.75198217e-02f, -4.59890440e-02f, -3.41232121e-02f, -6.52063638e-02f, 1.05913877e-02f, 3.40722054e-02f,
  4.43190560e-02f, -6.42479509e-02f, -1.02079198e-01f, -7.80937374e-02f, 5.89968450e-02f, 4.49119061e-02f, -2.92638373e-02f, -3.51915223e-04f, 2.25679483e-02f, 6.87846467e-02f,
  7.84916356e-02f, -6.71290830e-02f, -5.42495586e-02f, -1.25419199e-02f, 6.04392476e-02f, -4.89224866e-02f, -3.81446071e-02f, -4.80848998e-02f, -9.15586203e-02f, -3.44662517e-02f,
  -7.28072831e-03f, -4.70730336e-03f, -7.49851391e-02f, -2.60893088e-02f, -1.05413429e-01f, 3.19122672e-02f, -2.56071817e-02f, 5.14543056e-02f, -7.52331242e-02f, 4.99921031e-02f,
  -7.90950283e-02f, -7.52039552e-02f, 8.71519148e-02f, 4.46163751e-02f, -3.76452692e-02f, 6.51408806e-02f, -2.20411122e-02f, 3.45559395e-03f, 1.56377088e-02f, 6.18805587e-02f,
  -4.95165307e-03f, 5.42784259e-02f, 4.50813118e-03f, -7.60907009e-02f, 8.26354399e-02f, 5.20404279e-02f, -9.32971761e-02f, 3.22265774e-02f, 3.79769839e-02f, -1.67168193e-02f,
  -9.61107314e-02f, 1.13247046e-02f, 4.12376598e-02f, -3.53901386e-02f, -3.23511139e-02f, 1.57546438e-02f, 2.38307863e-02f, -2.00043954e-02f, 1.09105378e-01f, 6.33595362e-02f,
  -7.05254450e-02f, -1.80146113e-01f, 9.56246629e-02f, -1.02377892e-01f, -1.19318224e-01f, -1.60014093e-01f, -1.54819146e-01f, -1.42754734e-01f, -2.54173391e-02f, -1.34957835e-01f,
  -2.22844109e-02f, -4.11910452e-02f, 3.30522843e-02f, -6.48354590e-02f, 7.84105435e-02f, -1.87400803e-02f, 2.72742566e-02f, 4.94857505e-02f, -7.12316260e-02f, -1.58884078e-01f,
  -1.43619135e-01f, 4.45474945e-02f, -9.09318402e-02f, -9.45781246e-02f, -1.01863733e-02f, -5.12749469e-03f, -2.55711153e-02f, 5.64452112e-02f, -1.41253144e-01f, -1.15409084e-01f,
  2.16055829e-02f, 5.83751239e-02f, 4.96278889e-02f, -3.29303034e-02f, 6.68004528e-02f, 6.65823072e-02f, 2.88884435e-02f, -5.98412678e-02f, 3.46091054e-02f, 1.95599310e-02f,
  3.57864052e-02f, -9.44069773e-02f, -1.93784311e-02f, 6.60990477e-02f, -3.32986377e-02f, -7.38610998e-02f, 8.41606222e-03f, 7.19777271e-02f, 7.06349760e-02f, -7.94146024e-03f,
  -4.52424400e-02f, 6.11061510e-03f, 5.80457877e-03f, -5.69351129e-02f, -5.93474768e-02f, -2.00111251e-02f, 7.84129351e-02f, -8.47195014e-02f, 5.63889816e-02f, -6.34069517e-02f,
  -2.85978476e-03f, 5.34853549e-04f, -2.21039336e-02f, -6.26364946e-02f, 5.56746237e-02f, 6.31726235e-02f, -6.76725879e-02f, 1.52353831e-02f, -3.73999476e-02f, -4.56592031e-02f,
  -2.34729368e-02f, -5.49439900e-02f, 7.71077126e-02f, -7.02593252e-02f, -5.54564558e-02f, -6.53180331e-02f, 9.12554264e-02f, 3.82141545e-02f, 8.18395801e-03f, -2.56616846e-02f,
  -6.37667999e-02f, -2.23649666e-02f, -6.15869276e-02f, -4.21169214e-02f, -9.75522995e-02f, -5.32696471e-02f, -6.66637644e-02f, 1.58128086e-02f, 1.01118617e-01f, 3.24843675e-02f,
  1.47774413e-01f, 3.27395983e-02f, -4.94346283e-02f, -1.02727674e-02f, 7.15323314e-02f, -4.15834859e-02f, -6.51577637e-02f, 8.26330855e-02f, 7.92914405e-02f, -6.37659580e-02f,
  3.60095724e-02f, -4.37918566e-02f, 4.48307097e-02f, 5.17762527e-02f, -8.11096281e-03f, -5.30406088e-02f, -1.30641028e-01f, -5.04919142e-02f, -4.78948765e-02f, -1.30485758e-01f,
  -6.30772533e-03f, 4.50271666e-02f, 2.72622611e-02f, -1.08622608e-03f, 4.39735944e-04f, 8.56171176e-02f, 2.39251032e-02f, 8.99912640e-02f, 1.04483366e-01f, -1.39857521e-02f,
  1.20226473e-01f, 4.73671518e-02f, -3.29639435e-01f, 8.23931694e-02f, -1.37929603e-01f, -1.36392295e-01f, -2.21584722e-01f, -9.32916403e-02f, 8.40583295e-02f, -2.22222675e-02f,
  2.16865521e-02f, 2.68198010e-02f, -5.88093139e-02f, -1.12369165e-01f, -4.35928926e-02f, -1.90545157e-01f, -2.46110022e-01f, -1.68601498e-01f, -1.79531068e-01f, -7.63651282e-02f,
  4.65505794e-02f, -3.43060233e-02f, -6.59079850e-03f, -2.16405764e-02f, 4.64561470e-02f, 2.41521597e-02f, -1.35302588e-01f, -1.20478041e-01f, -7.52911270e-02f, -1.19586386e-01f,
  -1.96165353e-01f, -1.47899799e-02f, -6.17673732e-02f, 7.96516016e-02f, -6.96490034e-02f, 1.23817530e-02f, -1.86763648e-02f, -4.55868663e-03f, -5.02872579e-02f, 3.55478935e-02f,
  7.59358853e-02f, 8.79496634e-02f, 1.57640576e-02f, 6.06215671e-02f, -4.61746231e-02f, -5.68370568e-03f, 1.48056112e-02f, -6.86927214e-02f, 2.86923014e-02f, -8.01214427e-02f,
  -3.92708108e-02f, -1.22011065e-01f, -1.92960128e-02f, -9.43686217e-02f, -9.70585793e-02f, -8.84051397e-02f, -3.60004678e-02f, 5.97027019e-02f, -6.33325577e-02f, 1.28010631e-01f,
  -8.41872618e-02f, -6.92929700e-02f, 4.28513139e-02f, 1.80822145e-02f, 1.14908785e-01f, 6.22581206e-02f, 3.57900672e-02f, 1.75623000e-02f, 1.06389366e-01f, 2.34360751e-02f,
  1.00662299e-01f, -2.47861408e-02f, -8.43149871e-02f, -6.51206821e-02f, -4.30229828e-02f, -2.06959117e-02f, -7.53910467e-02f, 1.81897040e-02f, 4.95484844e-02f, -5.38796149e-02f,
  6.39698375e-03f, 5.72253019e-02f, 4.51804921e-02f, 4.06941846e-02f, -4.69392724e-02f, -4.31930013e-02f, -6.33815005e-02f, -1.25564402e-02f, -8.68789628e-02f, -7.07618222e-02f,
  1.96447074e-01f, -9.97123122e-02f, 1.26978785e-01f, 7.99002051e-02f, 1.88528690e-02f, 1.78559460e-02f, 8.30830038e-02f, 5.30021936e-02f, 1.92754231e-02f, -7.67907798e-02f,
  -1.17682658e-01f, 1.43671604e-02f, -7.08865045e-05f, 5.58928102e-02f, 3.87464138e-03f, -8.98859799e-02f, 1.32414415e-01f, -2.55183205e-02f, 1.27873421e-02f, 8.41291845e-02f,
  6.31612390e-02f, 4.68045622e-02f, 9.71457362e-02f, 7.67756402e-02f, -3.07478495e-02f, -5.76916188e-02f, 5.30067272e-02f, 3.59833762e-02f, -8.19902495e-02f, 1.07092120e-01f,
  -2.00292572e-01f, 7.91118741e-02f, -7.19383061e-02f, 6.68986142e-02f, 7.48777837e-02f, 8.95960182e-02f, 2.54879504e-01f, 1.91697881e-01f, 1.57188565e-01f, 6.08961992e-02f,
  -7.18317628e-02f, -8.96096081e-02f, 3.83645855e-02f, -6.74357191e-02f, -3.33322883e-02f, 1.85677886e-01f, 7.67692477e-02f, -7.85768148e-04f, -1.08955257e-01f, 1.89434774e-02f,
  7.52025342e-04f, 9.77372006e-02f, -1.06869236e-01f, -8.09751637e-03f, 3.59011889e-02f, 8.93113464e-02f, 3.80771719e-02f, 1.14381567e-01f, -5.22925742e-02f, 7.56612793e-02f,
  -5.62006682e-02f, -1.05723448e-01f, 4.99360263e-02f, -5.53626008e-02f, -8.18266124e-02f, -8.70971158e-02f, 7.75064304e-02f, -4.33602333e-02f, 2.60202624e-02f, 1.48868915e-02f,
  2.12748405e-02f, 3.49163227e-02f, -6.35269061e-02f, 7.63119012e-02f, -5.86380959e-02f, 9.34359152e-03f, -5.12185693e-02f, 4.42032591e-02f, 3.64561565e-02f, -9.08992663e-02f,
  -8.25700387e-02f, -8.12007785e-02f, 1.12376884e-01f, 7.36439452e-02f, -6.29361346e-02f, -4.02600020e-02f, 3.47331949e-02f, 6.26729652e-02f, 4.42305803e-02f, -8.55315477e-02f,
  -9.41868126e-02f, -5.75387999e-02f, 1.72449481e-02f, -7.71793425e-02f, -4.68181297e-02f, 6.38746992e-02f, 7.57858157e-02f, -2.11433005e-02f, 6.32030703e-03f, 8.68580565e-02f,
  -6.35772794e-02f, -7.74741918e-02f, -1.23867467e-02f, -4.91664670e-02f, -1.83250625e-02f, 4.78259176e-02f, -1.73626821e-02f, -6.17817529e-02f, 6.58265799e-02f, -3.68909426e-02f,
  -9.17016417e-02f, 9.59104076e-02f, -4.98059578e-02f, 1.45497881e-02f, 3.87410112e-02f, 7.54822940e-02f, -5.59808724e-02f, 5.28745651e-02f, -1.70726087e-02f, 3.02256141e-02f,
  4.94356044e-02f, 2.83058081e-02f, 6.78237230e-02f, 2.52912901e-02f, 3.68319042e-02f, -9.01016146e-02f, -7.74192736e-02f, -2.91530769e-02f, 2.43749563e-02f, 2.34027542e-02f,
  -7.75005370e-02f, -3.27256843e-02f, 8.78646374e-02f, 4.23612110e-02f, -5.74811138e-02f, 1.68517679e-02f, -2.81632971e-02f, 1.83156237e-03f, -5.14663421e-02f, 6.44128248e-02f,
  4.29937765e-02f, 5.66927828e-02f, 8.41808841e-02f, 7.81012252e-02f, -1.59749147e-02f, 3.78125869e-02f, -3.32664959e-02f, 7.01206774e-02f, -4.12076935e-02f, -3.07365134e-02f,
  3.34784359e-01f, 2.10323364e-01f, -5.80899790e-03f, 4.81404327e-02f, 6.93853898e-03f, -1.41105503e-01f, -1.81717366e-01f, -1.14270255e-01f, -8.80193412e-02f, 1.33968070e-01f,
  -4.54110978e-03f, 7.20882714e-02f, 1.24368742e-02f, -7.46892989e-02f, -9.36928615e-02f, -6.57700449e-02f, 5.03755882e-02f, 2.74272487e-02f, -2.00002268e-02f, -1.07834749e-01f,
  5.86351082e-02f, 1.21212073e-01f, 1.08283445e-01f, 6.62657544e-02f, 1.55406058e-01f, 8.51795971e-02f, -5.00714742e-02f, 8.96045938e-02f, 1.65069290e-02f, 2.78999239e-01f,
  1.29327148e-01f, 2.29040995e-01f, -2.36684114e-01f, -4.70951609e-02f, 8.99726078e-02f, 9.24026687e-03f, -6.12284094e-02f, 8.78826380e-02f, -5.82522228e-02f, 3.79242748e-02f,
  -2.47642957e-02f, 3.73075306e-02f, -7.51723116e-03f, 5.53843118e-02f, -2.26261895e-02f, -4.25321907e-02f, 2.43794620e-02f, -7.62244388e-02f, -7.68653024e-03f, 6.32875785e-02f,
  -2.87812464e-02f, 1.17895856e-01f, 4.30670232e-02f, -8.93647149e-02f, -3.98263708e-02f, 2.40384415e-02f, 4.69592661e-02f, 5.40978350e-02f, -5.36582731e-02f, 1.40900552e-01f,
  -6.40089810e-02f, -4.22232561e-02f, 1.02794049e-02f, -2.49209702e-02f, -6.74236566e-02f, -5.17212879e-03f, 1.36075122e-02f, -6.34871572e-02f, -2.84500886e-03f, -6.20824620e-02f,
  -5.76903634e-02f, -7.29157729e-03f, -3.40936966e-02f, -5.73842078e-02f, -6.64891601e-02f, -6.52213544e-02f, -1.25119425e-02f, -3.36282812e-02f, -1.15795126e-02f, -4.54802141e-02f,
  7.23270401e-02f, -4.23585437e-02f, 7.64071718e-02f, -5.85821718e-02f, -8.02434701e-03f, -5.72881252e-02f, 8.75215307e-02f, -5.71832098e-02f, 6.26712292e-02f, 5.67888189e-03f,
  8.21620598e-03f, -2.13654518e-01f, -3.66660915e-02f, 5.35458513e-02f, -1.87153381e-03f, 3.00788768e-02f, 4.30857651e-02f, 5.70754558e-02f, -3.10588889e-02f, -5.92567176e-02f,
  9.45662633e-02f, 5.93584031e-02f, -1.82413273e-02f, -5.41970553e-03f, -1.07515998e-01f, -5.83659718e-03f, -4.23630662e-02f, -7.00872764e-02f, -8.78788978e-02f, -5.34068011e-02f,
  -1.37542218e-01f, -1.24790668e-01f, -6.22227080e-02f, -2.18110830e-01f, -1.36448955e-02f, -7.88812116e-02f, -1.30804211e-01f, -1.08660109e-01f, -9.07329544e-02f, -7.63943121e-02f,
  -1.11738510e-01f, -1.43278493e-02f, 9.64164883e-02f, 4.80664223e-02f, -3.09769763e-03f, -9.32390057e-03f, -1.88336279e-02f, -3.54874087e-03f, 5.81590496e-02f, 3.84895615e-02f,
  5.98697178e-02f, 1.40950736e-02f, 3.28517184e-02f, -1.39429243e-02f, 3.22726183e-02f, -2.97227539e-02f, 1.26045411e-02f, -3.66836716e-03f, 4.24415320e-02f, 2.37918105e-02f,
  -7.86729306e-02f, -7.68915117e-02f, -4.95788716e-02f, -7.17792213e-02f, 4.59821261e-02f, 5.07213548e-02f, -2.89153215e-02f, 2.92850938e-02f, -5.82126230e-02f, 3.78318597e-03f,
  9.84271765e-02f, 3.46688777e-02f, -5.02253920e-02f, -4.53464203e-02f, 2.70998683e-02f, 7.21524209e-02f, 4.12320048e-02f, -6.61570802e-02f, -6.52382225e-02f, -1.88100506e-02f,
  8.09375942e-02f, 6.55731335e-02f, -6.83423802e-02f, -3.94035093e-02f, 2.64911763e-02f, -3.24594826e-02f, 3.72545584e-03f, -2.13371292e-02f, 3.11058536e-02f, -2.69087330e-02f,
  6.64114356e-02f, -1.40323536e-02f, 9.72267315e-02f, 9.47131068e-02f, -1.00689419e-02f, 4.47955951e-02f, -6.31289706e-02f, 5.81086241e-02f, 7.83066973e-02f, -3.06624975e-02f,
  7.27605745e-02f, -5.16829304e-02f, -9.00761131e-03f, 7.75099248e-02f, -7.10497722e-02f, 6.80315793e-02f, -2.35978439e-02f, 1.51963029e-02f, 1.57803986e-02f, -6.25808612e-02f,
  -3.51505317e-02f, -5.33111654e-02f, 2.37399638e-02f, 7.92591497e-02f, -1.41766779e-02f, 3.22832428e-02f, 3.07283015e-03f, -1.61735038e-03f, 8.71342495e-02f, -5.50214015e-03f,
  -4.45158631e-02f, 6.15685806e-02f, -4.59488854e-02f, -4.96480986e-02f, 3.60747240e-02f, 5.32348640e-03f, -5.12473397e-02f, 4.69822884e-02f, 5.79604022e-02f, 3.30030881e-02f,
  4.21392992e-02f, 1.10954605e-02f, -3.41956294e-03f, -8.08422565e-02f, -4.25260700e-02f, 4.15725708e-02f, -3.46494908e-03f, 6.20755777e-02f, -6.97542056e-02f, -9.50628147e-02f,
  -6.17623031e-02f, 2.17209142e-02f, 2.82788388e-02f, 1.45682283e-02f, -3.69871520e-02f, -2.97744442e-02f, 3.57081443e-02f, 2.87389308e-02f, -7.32653514e-02f, -5.08249365e-02f,
  -3.00713032e-02f, 2.53629871e-02f, 1.66852195e-02f, -1.64012238e-02f, 9.04483125e-02f, 3.12412716e-02f, -6.08791150e-02f, 9.95590687e-02f, -4.86238562e-02f, 3.31616588e-02f,
  -6.77041560e-02f, -1.16759419e-01f, -2.96704173e-02f, 1.20122559e-01f, 3.61726806e-02f, -3.96397375e-02f, -1.09072126e-01f, 1.67455524e-02f, 8.17055404e-02f, 2.45172642e-02f,
  1.20080255e-01f, 3.86062451e-02f, 1.29025891e-01f, 5.55349700e-02f, -9.02822167e-02f, -6.68722689e-02f, -1.86932627e-02f, -6.37169927e-02f, 7.25371838e-02f, 1.41049162e-01f,
  1.33861125e-01f, 1.89742465e-02f, 1.20760966e-02f, 7.26812892e-03f, 1.02664061e-01f, 6.05374016e-02f, -3.57899405e-02f, 1.34641603e-02f, -4.61212955e-02f, -2.80360524e-02f,
  5.79893962e-02f, -1.16089091e-01f, 9.72388871e-03f, 1.16884328e-01f, -1.09250005e-02f, -8.57200474e-02f, 4.56995852e-02f, -4.00576703e-02f, 3.61540727e-02f, 1.26519417e-02f,
  -6.53707236e-02f, 4.90549542e-02f, -1.52057717e-02f, -4.71231863e-02f, 7.88867846e-02f, 6.95817843e-02f, -9.81948599e-02f, -4.65255752e-02f, 1.29182031e-02f, 5.87244444e-02f,
  2.37222593e-02f, 1.74080022e-02f, 3.49347852e-02f, -6.61877319e-02f, 4.57504317e-02f, 7.80563876e-02f, -3.28851640e-02f, 2.90387142e-02f, 3.78756523e-02f, -6.74525052e-02f,
  -9.07970499e-03f, 3.07050198e-02f, -1.61323119e-02f, -4.05124761e-02f, -8.01056549e-02f, 5.13800159e-02f, -4.70598638e-02f, 7.89292455e-02f, -7.32486472e-02f, -5.86091056e-02f,
  -1.60166025e-02f, 1.75197516e-02f, 3.68329547e-02f, -2.43143886e-02f, -3.83927976e-03f, -2.65453793e-02f, 4.73708799e-03f, -2.57523376e-02f, 9.03648417e-03f, -5.96272796e-02f,
  -5.57093509e-03f, -9.48614702e-02f, 2.77221929e-02f, -3.56144309e-02f, -9.58399102e-02f, -4.90468033e-02f, 1.72808357e-02f, 8.05086866e-02f, -1.25845633e-02f, 5.43055907e-02f,
  7.31739253e-02f, -7.98798800e-02f, 2.41910722e-02f, -2.22600251e-02f, 3.66345234e-02f, -6.84952885e-02f, 5.06486893e-02f, -6.00749813e-02f, -2.49028504e-02f, 5.06365709e-02f,
  2.41570305e-02f, -9.51616541e-02f, 3.69873159e-02f, -2.72371490e-02f, 1.00081384e-01f, 2.20697802e-02f, -3.88634799e-04f, 2.16999054e-02f, 3.53821032e-02f, -1.30779138e-02f,
  -1.01826578e-01f, 1.09673357e-02f, -4.03952748e-02f, -6.43993169e-02f, 7.85964653e-02f, 6.22072034e-02f, 1.43579971e-02f, 2.31691469e-02f, -9.99278948e-02f, 2.06861133e-03f,
  -1.37658253e-01f, 1.30510241e-01f, -1.05017953e-01f, -3.00504584e-02f, 2.20577903e-02f, -6.11336529e-02f, 6.26076087e-02f, -1.09706502e-02f, 6.66541234e-02f, 1.22755654e-01f,
  1.27482384e-01f, 1.40546309e-02f, 1.53684571e-01f, 5.17708845e-02f, -1.47138517e-02f, 2.71243360e-02f, 4.56004627e-02f, -6.37755683e-03f, -8.09543431e-02f, 8.60676020e-02f,
  1.72431573e-01f, 3.73667777e-02f, 7.87840337e-02f, -3.76136391e-03f, 1.25591204e-01f, 9.99869257e-02f, 1.45864906e-02f, -3.94568145e-02f, 3.15860584e-02f, 1.31570980e-01f,
  1.82779923e-01f, -1.88613012e-01f, 2.42776982e-03f, -5.08774966e-02f, -2.44154818e-02f, 6.01327792e-02f, -7.57717788e-02f, -3.37471589e-02f, -4.49257232e-02f, 2.69320197e-02f,
  -6.40523061e-02f, -4.35422286e-02f, 7.80370971e-03f, -5.10036051e-02f, -7.28032514e-02f, 4.88052517e-02f, -7.67278597e-02f, -1.19407229e-01f, -7.36725330e-02f, -8.77978802e-02f,
  8.63578096e-02f, -4.48670611e-02f, -1.03378206e-01f, 1.54122198e-02f, -1.06525831e-01f, 3.82324010e-02f, -6.88210055e-02f, 1.58118717e-02f, -1.59065291e-01f, 5.36773764e-02f,
  7.53698871e-02f, -3.87027338e-02f, -1.13057278e-01f, -6.55080983e-03f, -7.71993473e-02f, 6.87068403e-02f, -4.22690138e-02f, 8.63107294e-02f, 7.67645463e-02f, -5.11719584e-02f,
  -6.65792525e-02f, 5.45440912e-02f, -1.91272050e-02f, 4.08411957e-02f, 8.33425596e-02f, -4.97001298e-02f, -5.09753637e-02f, -6.47227913e-02f, 8.23981315e-03f, -1.34848999e-02f,
  4.27595107e-03f, 1.64970418e-03f, -8.38782191e-02f, -1.55392149e-02f, -6.51149303e-02f, -9.75927934e-02f, -5.06628640e-02f, 3.92830633e-02f, -6.88039064e-02f, 1.59835964e-02f,
  2.72568285e-01f, -1.40850961e-01f, 7.79314935e-02f, -3.35023105e-02f, -9.76118743e-02f, -1.09408878e-01f, -2.09947936e-02f, -1.54704405e-02f, 4.37775366e-02f, -4.23324034e-02f,
  -5.33825681e-02f, -1.34751797e-02f, 1.01545036e-01f, -7.23192468e-02f, -9.32660606e-03f, -3.67192589e-02f, -5.18793762e-02f, 7.65520856e-02f, -2.11637910e-03f, -7.97897652e-02f,
  3.89452800e-02f, 1.87179986e-02f, 8.59366506e-02f, -2.68495246e-03f, -2.94712447e-02f, 3.06701325e-02f, 8.84150341e-02f, 9.35329311e-03f, 3.47307231e-03f, 1.24104917e-01f,
  2.09743336e-01f, -1.84927925e-01f, -1.86033055e-01f, 2.93766838e-02f, 6.11669533e-02f, -7.18955025e-02f, -8.13671127e-02f, -1.82465874e-02f, 6.33693263e-02f, -1.23669967e-01f,
  -4.47322726e-02f, -4.81325015e-03f, -4.03506309e-02f, -7.79132620e-02f, -8.37601721e-02f, -1.62160635e-01f, -4.87925075e-02f, 5.67122698e-02f, 7.58004487e-02f, 1.04388714e-01f,
  -1.67909246e-02f, 4.70474511e-02f, 6.83423132e-02f, 2.23234463e-02f, -2.78604291e-02f, -7.18867183e-02f, -8.46462548e-02f, -1.37422651e-01f, -1.08638555e-01f, -5.84040061e-02f,
  -1.53184906e-01f, -3.95833552e-02f, 1.36841848e-01f, 2.78632483e-03f, -6.94765225e-02f, -8.74883588e-03f, -4.78267632e-02f, -4.32293937e-02f, -1.01564102e-01f, -9.75189656e-02f,
  -3.20268758e-02f, -3.85707282e-02f, -2.48860028e-02f, -5.95544912e-02f, -3.49348336e-02f, -6.71298355e-02f, 4.57696579e-02f, -4.16747443e-02f, -1.48308324e-02f, -4.75210324e-02f,
  -1.10449292e-01f, -1.26656638e-02f, 1.35462992e-02f, 2.66830027e-02f, -1.17091812e-01f, 5.91912419e-02f, -7.45274574e-02f, -4.98079322e-02f, -4.69661765e-02f, 6.04786687e-02f,
  -4.67115752e-02f, -9.79473293e-02f, 9.86279547e-02f, -3.73773947e-02f, -4.47262116e-02f, -4.08546887e-02f, 3.81677449e-02f, -3.81201543e-02f, 4.73799296e-02f, 6.37686402e-02f,
  -3.39741930e-02f, -6.05675466e-02f, -3.00086127e-03f, 2.56202333e-02f, -7.09594646e-03f, -6.74538687e-02f, -6.19416647e-02f, 3.42484452e-02f, 7.82431290e-02f, 8.91078636e-02f,
  3.20104733e-02f, 1.96430199e-02f, 5.35664409e-02f, -3.35932486e-02f, -6.38256669e-02f, -7.44790658e-02f, -7.75419828e-03f, -6.53395951e-02f, 2.75648814e-02f, 3.87068093e-02f,
  1.85917184e-01f, -3.97650264e-02f, 1.06470071e-01f, -6.60812184e-02f, 5.17107062e-02f, 4.82844226e-02f, -1.02667280e-01f, 3.70892622e-02f, -8.36507902e-02f, 3.72317992e-02f,
  -2.65787132e-02f, -8.43765885e-02f, -1.62743852e-02f, 1.43087711e-02f, 4.20999713e-02f, -1.73800234e-02f, -2.76186168e-02f, 4.42121737e-02f, -1.00349747e-01f, 2.31902162e-03f,
  -8.80806067e-04f, 1.21987186e-01f, 1.98547076e-02f, -4.57800478e-02f, -3.15487646e-02f, -3.81497922e-03f, 1.03024423e-01f, -2.15531848e-02f, 1.06522694e-01f, 1.86512157e-01f,
  1.65190637e-01f, 1.74757197e-01f, 2.39824191e-01f, -6.14211056e-03f, -5.07294983e-02f, 1.33731201e-01f, 1.73749998e-01f, 1.01501673e-01f, -8.81312340e-02f, 5.73760867e-02f,
  -1.00923322e-01f, -1.13506489e-01f, -1.33762777e-01f, -1.35589436e-01f, -4.31243256e-02f, 6.41156435e-02f, 1.44888069e-02f, 2.29315739e-02f, -5.35751805e-02f, 6.25217482e-02f,
  -4.59056310e-02f, -5.70215769e-02f, 2.69518513e-02f, 1.59830730e-02f, -1.14652529e-01f, -1.87723599e-02f, 1.29218191e-01f, -3.04370299e-02f, -5.29684275e-02f, 1.13397054e-02f,
  8.40624515e-03f, 2.67351687e-01f, -7.83600807e-02f, -6.57227337e-02f, 5.82069792e-02f, -9.98824388e-02f, 7.01221898e-02f, 6.87898025e-02f, -3.50127481e-02f, 1.76027324e-02f,
  -9.90482345e-02f, 4.83967625e-02f, 3.05888709e-02f, 8.33489671e-02f, -9.76797566e-03f, 8.80946964e-02f, -5.79750389e-02f, -4.63499241e-02f, 2.50252672e-02f, -9.20497347e-03f,
  -2.29704063e-02f, -3.56499781e-03f, 1.33893505e-01f, 8.55639428e-02f, -9.53383464e-03f, -1.03252418e-01f, 3.84857267e-04f, 1.12410486e-02f, 1.03393003e-01f, 6.88549727e-02f,
  2.70386562e-02f, 7.72666708e-02f, -7.24522322e-02f, 1.03607334e-01f, -7.23476335e-02f, 2.14909147e-02f, 4.86353748e-02f, -6.62473217e-02f, -1.06574874e-03f, -2.26394404e-02f,
  7.49708116e-02f, -5.18745072e-02f, 4.23518866e-02f, 4.33940701e-02f, 3.94247100e-03f, 2.02995557e-02f, 1.03826784e-01f, -1.82247758e-02f, 3.20639869e-04f, -5.10552004e-02f,
  -5.80465272e-02f, 4.50096019e-02f, 2.79460475e-02f, 1.96001753e-02f, 1.02235273e-01f, -3.05093955e-02f, 4.67290692e-02f, 8.63082632e-02f, 3.44103277e-02f, 5.96517026e-02f,
  -2.14772578e-02f, 8.24612826e-02f, -1.56029001e-01f, -7.30049461e-02f, 3.30491252e-02f, -2.06178911e-02f, -9.06205550e-02f, 7.19919056e-02f, 9.01989057e-04f, -1.26449643e-02f,
  4.87820944e-03f, 1.27358297e-02f, -1.35537880e-02f, -7.02188015e-02f, 2.23195795e-02f, 6.90983236e-02f, 2.83955019e-02f, -3.62588763e-02f, 1.13289449e-02f, -4.14286815e-02f,
  -9.76453125e-02f, 1.88917797e-02f, -3.37149054e-02f, -7.47901946e-02f, 4.63579409e-02f, -4.26484458e-02f, -3.96398306e-02f, -4.29727882e-02f, -5.32818027e-02f, -1.20995641e-02f,
  1.85510933e-01f, 1.95588082e-01f, 1.05946787e-01f, -9.91825685e-02f, 2.21314877e-02f, 3.84249948e-02f, 1.31473485e-02f, 8.75734165e-02f, -4.67231348e-02f, 6.03979416e-02f,
  1.13700209e-02f, -1.25142862e-03f, -6.06515147e-02f, -4.10335101e-02f, -6.38303682e-02f, 8.18094239e-02f, -4.58471365e-02f, 2.84820553e-02f, 3.38055426e-03f, -6.56902641e-02f,
  4.19617929e-02f, -8.91435966e-02f, 3.37509066e-02f, 7.73074701e-02f, 6.28287420e-02f, -5.65017089e-02f, 1.11977728e-02f, 2.65695602e-02f, 3.26765105e-02f, 9.39968452e-02f,
  5.45298569e-02f, 9.63716730e-02f, -1.64436072e-01f, -1.16357401e-01f, 6.84548765e-02f, 9.80665758e-02f, -7.82993063e-02f, 6.12487495e-02f, -1.11990795e-02f, -7.48714525e-03f,
  -6.32912293e-02f, -2.70624720e-02f, 3.33520621e-02f, 7.71969631e-02f, -8.21483508e-02f, -3.00212428e-02f, 8.28929245e-02f, -1.30739715e-02f, -5.58988228e-02f, -4.05536629e-02f,
  -9.45573151e-02f, -6.01514690e-02f, -5.47188558e-02f, 5.65199479e-02f, -9.35860444e-03f, -1.16792945e-02f, -5.64848818e-02f, 7.78869614e-02f, 3.36325429e-02f, 9.01318416e-02f,
  -1.53525430e-03f, 2.28834036e-03f, -1.10139148e-02f, -1.00691266e-01f, -8.09790716e-02f, -8.79911035e-02f, 5.34392111e-02f, -1.52534395e-02f, -1.28489807e-01f, -2.46806368e-02f,
  -5.36624603e-02f, 4.70811129e-02f, -5.86773790e-02f, 5.75543307e-02f, -1.06461287e-01f, -9.53894183e-02f, 1.75067149e-02f, 1.52795827e-02f, 9.46929026e-03f, -3.82607840e-02f,
  -5.29548787e-02f, -4.35787588e-02f, -3.36155966e-02f, -1.63976057e-03f, -8.77166092e-02f, -7.37842098e-02f, -7.28135929e-02f, -1.32630374e-02f, -5.94396070e-02f, -4.69306298e-02f,
  -9.12656412e-02f, -1.21104054e-01f, 9.10031497e-02f, 8.08610581e-04f, -4.17926647e-02f, 6.92835748e-02f, 3.87122743e-02f, 9.88581497e-03f, 1.79218464e-02f, -2.03174688e-02f,
  3.38511504e-02f, 4.11263928e-02f, 9.09620523e-03f, -7.80548826e-02f, -1.06491797e-01f, -8.88837799e-02f, 1.57676265e-02f, -8.72012947e-07f, -9.21166036e-03f, 7.00405389e-02f,
  5.81884235e-02f, 1.79832950e-02f, -1.21572338e-01f, 4.37475219e-02f, 8.32144916e-03f, -4.38585505e-02f, -6.61199912e-02f, -1.05608724e-01f, -3.53534743e-02f, 1.48540139e-02f,
  2.01413691e-01f, 7.17547685e-02f, -8.38588104e-02f, 5.99642331e-03f, -9.37288329e-02f, -1.22837469e-01f, 4.05381806e-02f, -9.21567786e-04f, 2.81178094e-02f, -6.03121892e-02f,
  8.34732056e-02f, -4.84163268e-03f, -5.17290346e-02f, -7.93741867e-02f, -4.87215444e-02f, -1.54663734e-02f, 5.49655519e-02f, -3.23816203e-02f, -1.40184551e-01f, -1.33176088e-01f,
  3.82246450e-02f, -1.14248455e-01f, -6.20850287e-02f, -1.16798460e-01f, 7.10352371e-03f, 2.92134229e-02f, 4.93212081e-02f, -8.87601599e-02f, -1.41766205e-01f, -2.23207865e-02f,
  -1.40588105e-01f, -2.48013698e-02f, 4.91666012e-02f, -1.20200375e-02f, 4.88292240e-02f, 2.40249913e-02f, 2.12801341e-02f, 1.17947226e-02f, 7.39909038e-02f, -9.00497735e-02f,
  -5.04533052e-02f, -4.57250588e-02f, -2.14125048e-02f, -1.61833204e-02f, -4.35709320e-02f, 4.14063744e-02f, -6.96476996e-02f, -2.49382276e-02f, 4.46766019e-02f, 1.19839041e-02f,
  2.36595608e-02f, -5.09874299e-02f, 7.95195922e-02f, -8.65803286e-02f, -9.49372947e-02f, 7.81651735e-02f, -1.04202352e-01f, -1.01107657e-01f, -1.00333296e-01f, 8.92584994e-02f,
  -1.31350651e-03f, 4.41158377e-02f, -6.41848221e-02f, -6.29298165e-02f, -2.83548124e-02f, -1.44871778e-03f, -1.28020104e-02f, -5.70153911e-03f, -1.45844724e-02f, -6.56180158e-02f,
  4.68352325e-02f, -5.64053319e-02f, -3.75078134e-02f, -8.04035068e-02f, 5.92086166e-02f, -9.64979082e-03f, 9.49771851e-02f, -1.45389605e-03f, 4.20981795e-02f, 2.76386999e-02f,
  -2.94290110e-02f, -1.01737559e-01f, -6.92985281e-02f, 3.08504421e-02f, 6.46177679e-02f, -6.64539635e-02f, -3.72376479e-02f, -1.27248866e-02f, 8.23956355e-02f, -3.86772007e-02f,
  -5.97331002e-02f, 4.59919088e-02f, 5.46962605e-04f, 6.77477717e-02f, 7.32096136e-02f, -6.63701296e-02f, -6.02172427e-02f, 3.10905762e-02f, 1.46291340e-02f, -2.23219246e-02f,
  2.84606288e-03f, 1.74843352e-02f, -9.42850262e-02f, -2.93795057e-02f, -3.88283245e-02f, 2.99864411e-02f, 6.22535683e-02f, 7.53543377e-02f, -7.70629570e-02f, 8.24184790e-02f,
  1.22018963e-01f, 9.15923044e-02f, 1.28913835e-01f, 1.20953694e-01f, 4.58749756e-02f, 8.06476474e-02f, 6.05621487e-02f, 5.54616041e-02f, 8.53297114e-02f, 1.77110314e-01f,
  -1.48143694e-02f, 1.63095489e-01f, 2.03227326e-01f, -6.30128533e-02f, 1.13993064e-01f, 2.25677937e-01f, 2.37601086e-01f, 5.32322973e-02f, -1.27131030e-01f, -1.35277482e-02f,
  -9.33704376e-02f, -1.35273024e-01f, -7.85930008e-02f, -1.20944396e-01f, -1.01143867e-01f, -1.03362091e-02f, 5.84459417e-02f, 8.51389095e-02f, -4.90920320e-02f, 7.75681809e-02f,
  -8.06308761e-02f, 8.00443888e-02f, 3.80639248e-02f, -8.60838220e-02f, -8.37411508e-02f, -1.13587469e-01f, -3.91911861e-04f, -1.77190378e-02f, 1.28303334e-01f, -4.04999778e-02f,
  6.82064295e-02f, 1.29276022e-01f, -6.41472917e-03f, -2.34523267e-02f, -2.83019673e-02f, 3.62519287e-02f, -5.31640537e-02f, -5.88083416e-02f, 3.91526558e-02f, 8.24592486e-02f,
  2.28989106e-02f, -6.93643317e-02f, 2.97312215e-02f, 7.84023013e-03f, -1.13232322e-02f, -7.70504996e-02f, -9.98339728e-02f, -2.83056740e-02f, -2.28353497e-02f, -4.78800572e-02f,
  -3.15699354e-02f, 4.48960550e-02f, 4.13123779e-02f, -3.43508609e-02f, 5.49582206e-02f, -2.55380273e-02f, 4.53009531e-02f, 7.34246671e-02f, 1.00238509e-02f, -7.91375637e-02f,
  -8.36483836e-02f, 1.28431646e-02f, -5.13932481e-02f, -2.87695806e-02f, -1.64829660e-02f, 2.00409461e-02f, -4.74478044e-02f, 5.82280103e-03f, 4.59834859e-02f, 8.54968354e-02f,
  -9.77996513e-02f, 8.23092908e-02f, 3.29874456e-03f, -5.73046356e-02f, -3.29220518e-02f, 2.67954115e-02f, 8.68088454e-02f, 1.07131228e-02f, 1.26705971e-04f, 6.62494600e-02f,
  2.56574503e-03f, -4.34326939e-02f, -8.32101256e-02f, -2.26520486e-02f, -9.37713869e-03f, 1.75192785e-02f, 5.57005145e-02f, -6.96515143e-02f, 5.87731600e-02f, -4.12626490e-02f,
  -2.58425713e-01f, -2.53706053e-02f, -3.50152105e-02f, -1.16308779e-01f, -4.24293354e-02f, -3.99548560e-04f, -1.22118443e-01f, -3.42230164e-02f, -7.38304034e-02f, 3.87594365e-02f,
  -3.61501724e-02f, 1.11850500e-02f, -5.75284846e-02f, -8.91437829e-02f, 7.64124766e-02f, 1.60411727e-02f, 2.02373154e-02f, -3.40351574e-02f, -1.02146246e-01f, 7.54185989e-02f,
  -3.97647396e-02f, 8.33679065e-02f, -3.95837687e-02f, 5.71442535e-04f, -6.55817857e-04f, -9.76908356e-02f, -2.48226657e-04f, 1.66255515e-02f, 5.79925328e-02f, -7.85484090e-02f,
  1.25158668e-01f, -5.47130667e-02f, -6.44284412e-02f, 2.79776454e-02f, 1.56771913e-01f, 9.91139039e-02f, 6.07325844e-02f, 2.49811504e-02f, 1.39181718e-01f, -1.44607695e-02f,
  -1.33095428e-01f, -2.54367683e-02f, -6.40643388e-02f, 2.93393545e-02f, -3.50985266e-02f, 4.39300910e-02f, 1.18109398e-01f, 6.62265643e-02f, -8.50188509e-02f, 4.76712035e-03f,
  7.87124932e-02f, 7.22659230e-02f, -1.05543891e-02f, 6.29754066e-02f, 2.90005989e-02f, -5.43028042e-02f, -9.77683663e-02f, -2.67404355e-02f, -9.26232263e-02f, -2.49087531e-02f,
  -1.22063875e-01f, -1.32491691e-02f, -8.07560831e-02f, -1.14997447e-01f, -9.46420059e-02f, -5.05055711e-02f, -5.01612835e-02f, 8.54821969e-03f, -4.97690625e-02f, -2.66786162e-02f,
  4.62560542e-02f, -1.35125695e-02f, 5.73905595e-02f, -6.14180155e-02f, 8.46238285e-02f, 6.46339059e-02f, -4.64146025e-02f, -5.43148331e-02f, 4.77242470e-03f, -4.10781056e-02f,
  -8.40475410e-02f, -9.08029079e-02f, -6.38935640e-02f, -3.11142858e-02f, 2.75390521e-02f, -6.06242009e-02f, 2.63638347e-02f, -4.60545756e-02f, -2.72667222e-02f, 2.05051638e-02f,
  6.57740161e-02f, 6.82276040e-02f, 1.96596831e-02f, 5.95039725e-02f, 3.61808687e-02f, 1.10649660e-01f, -3.79347540e-02f, 8.31689090e-02f, -6.44921884e-02f, 3.88080515e-02f,
  -5.67423590e-02f, -2.75370609e-02f, 2.69863680e-02f, -7.35738650e-02f, -6.58641979e-02f, -4.58830111e-02f, -6.98094293e-02f, 4.81514744e-02f, -7.16954321e-02f, -7.80208549e-03f,
  -5.84664941e-02f, 3.28375911e-03f, -3.47256549e-02f, 8.17316398e-03f, -3.81799750e-02f, -2.33649258e-02f, -6.41152188e-02f, 2.24022334e-03f, 6.98610097e-02f, -8.96827355e-02f,
  1.14275917e-01f, -1.45428658e-01f, -2.75187977e-02f, -7.20489472e-02f, 6.94365874e-02f, -1.01292491e-01f, -2.98276935e-02f, 2.83747949e-02f, -3.73482779e-02f, 1.66108869e-02f,
  4.45483625e-02f, 2.55095325e-02f, 5.57194725e-02f, 1.92263331e-02f, 3.03044226e-02f, 6.07085414e-02f, -1.08491331e-02f, -5.79061359e-02f, 3.02105490e-02f, -5.29204309e-02f,
  -3.85936759e-02f, 6.61037639e-02f, 1.29343837e-01f, -2.69074701e-02f, 4.65061814e-02f, 5.52145541e-02f, 2.62472760e-02f, 1.15129389e-01f, -1.56847648e-02f, 2.22179964e-01f,
  1.23647273e-01f, 1.31889254e-01f, 8.80261362e-02f, -3.15788947e-02f, -2.04291314e-01f, -1.79299861e-01f, -1.59460783e-01f, -1.23143218e-01f, 2.39576376e-03f, -6.69131204e-02f,
  -5.57506271e-02f, 7.88859371e-03f, -6.57019019e-02f, -2.14322805e-02f, 3.46296392e-02f, -3.88114937e-02f, -4.53543179e-02f, 1.58072814e-01f, -6.15482703e-02f, 6.46644607e-02f,
  7.11663291e-02f, 1.09457023e-01f, 8.10816735e-02f, 8.65358412e-02f, 6.04272187e-02f, 9.97390747e-02f, 1.31581664e-01f, 8.43713060e-02f, -1.66667327e-02f, 2.10465685e-01f,
  1.31618649e-01f, 8.57285485e-02f, -6.92429990e-02f, -7.01978877e-02f, -3.56273875e-02f, 6.57007247e-02f, 7.31788874e-02f, -4.28733369e-03f, 3.29070911e-02f, -8.44235066e-03f,
  7.77051896e-02f, -6.65125553e-04f, -3.06970607e-02f, 4.79228143e-03f, -1.35829393e-03f, -9.88020673e-02f, 5.32028563e-02f, 8.00569206e-02f, 6.95756301e-02f, 4.42511328e-02f,
  -1.90056991e-02f, 1.76478401e-02f, -8.44774246e-02f, -9.81912166e-02f, -1.12130813e-01f, -5.61766401e-02f, 3.14030387e-02f, 5.19758575e-02f, 1.13042127e-02f, 1.53909996e-01f,
  -2.66788471e-02f, -7.40945190e-02f, -6.41400889e-02f, 8.69952887e-02f, -4.96275956e-03f, -4.85532843e-02f, -6.74716681e-02f, 2.40279119e-02f, 7.49010816e-02f, 2.86288057e-02f,
  3.27175669e-02f, -6.37186021e-02f, 1.26029672e-02f, -1.08098118e-02f, 1.18779307e-02f, -6.56789690e-02f, 3.60989682e-02f, -2.95209717e-02f, -1.52926212e-02f, -2.90077422e-02f,
  -5.19368388e-02f, 5.82865849e-02f, 3.78134511e-02f, -2.56840885e-02f, 2.40740795e-02f, 9.53219682e-02f, -7.48891849e-03f, 5.14296582e-03f, 6.87814653e-02f, -3.28844339e-02f,
  -1.14918742e-02f, -1.74028918e-01f, 1.91839170e-02f, -4.30690981e-02f, 4.11164872e-02f, 8.40788186e-02f, 7.56019726e-02f, -3.89387868e-02f, 2.59813806e-03f, -1.91988051e-02f,
  -9.56192985e-02f, -3.57656367e-02f, -1.13845676e-01f, 2.31013130e-02f, 1.77583881e-02f, -9.20872465e-02f, 7.98222050e-02f, 9.21852812e-02f, 5.90835586e-02f, 3.65418531e-02f,
  -3.12964544e-02f, -8.81531835e-02f, -1.56416878e-01f, -7.92947635e-02f, -1.23159975e-01f, -1.44768432e-01f, -1.03177078e-01f, -4.89809364e-02f, -1.07483447e-01f, 4.49589677e-02f,
  -3.57245803e-01f, -1.12883955e-01f, 8.00355077e-02f, -1.39339224e-01f, -8.07920322e-02f, -5.64951040e-02f, -1.86017454e-02f, 3.53497900e-02f, -5.47702573e-02f, 2.46553980e-02f,
  4.04333137e-03f, -1.28045961e-01f, -1.50297573e-02f, -3.84223973e-03f, -4.82924581e-02f, 5.71762919e-02f, -9.58623886e-02f, -1.27565444e-01f, -1.12922035e-01f, 6.56924173e-02f,
  -1.17565999e-02f, -1.23373672e-01f, -6.26921207e-02f, 5.22710197e-03f, 9.92722809e-02f, 4.59792316e-02f, 6.21784828e-04f, -3.18402499e-02f, 2.09435052e-03f, 5.48126027e-02f,
  2.27532536e-01f, -8.98949355e-02f, 1.17022600e-02f, 1.78336892e-02f, 1.31002907e-03f, 4.22037989e-02f, -5.85472360e-02f, 7.36560524e-02f, -5.95593043e-02f, 6.12778813e-02f,
  -7.10432157e-02f, -9.23502594e-02f, -1.04601912e-01f, 8.89168829e-02f, 2.36507226e-02f, 8.65805224e-02f, -9.25272852e-02f, 4.11262475e-02f, -6.04996271e-03f, 1.21823557e-01f,
  5.94133437e-02f, 3.60342264e-02f, 8.10513794e-02f, -1.81714632e-02f, -5.86008169e-02f, -9.25815627e-02f, 1.26846343e-01f, 8.76541585e-02f, -1.74162649e-02f, -3.49639007e-03f,
  -2.31634192e-02f, 8.65036920e-02f, 5.48895039e-02f, -7.18995780e-02f, -5.22026084e-02f, -7.30397478e-02f, 3.16746011e-02f, 9.43018869e-02f, -4.61688414e-02f, -1.40445558e-02f,
  1.63610280e-02f, 4.24996242e-02f, 3.88440229e-02f, -8.51385444e-02f, -3.01987994e-02f, -2.47720182e-02f, 3.06666214e-02f, -3.70556563e-02f, 9.64135025e-03f, 2.63889693e-02f,
  -6.70647845e-02f, 8.25438723e-02f, -6.29143640e-02f, 9.55118686e-02f, 7.09109455e-02f, 6.97270595e-03f, -8.28220099e-02f, -8.02232474e-02f, 5.49802892e-02f, -9.44687650e-02f,
  1.25306711e-01f, -7.20887408e-02f, -3.30472142e-02f, 3.41032185e-02f, -2.76436433e-02f, 3.04942802e-02f, 5.45593351e-02f, -7.72271603e-02f, 2.04156116e-02f, 1.17417529e-01f,
  8.34682360e-02f, 4.53405920e-03f, 2.41705477e-02f, 8.45566839e-02f, 9.75511745e-02f, -5.33247255e-02f, -2.33158879e-02f, -7.01790825e-02f, 8.87403786e-02f, 3.48976515e-02f,
  9.40984935e-02f, -3.13628092e-02f, 1.22518212e-01f, 8.81885588e-02f, -3.33081856e-02f, 5.92038631e-02f, 7.73797836e-03f, 1.72224909e-01f, 8.88297185e-02f, 1.14523031e-01f,
  -9.44216177e-02f, -2.39797205e-01f, 1.05421968e-01f, -3.16863135e-02f, 8.43515918e-02f, 3.64179425e-02f, -1.02196224e-01f, -1.73853189e-02f, -8.51337686e-02f, -1.05256349e-01f,
  -1.49775043e-01f, 1.96468160e-02f, 1.07986946e-02f, 9.39478874e-02f, 5.46776988e-02f, -1.39383264e-02f, -6.90072626e-02f, 1.61486492e-01f, 1.49996161e-01f, 4.85754609e-02f,
  6.29955251e-03f, -2.95479503e-02f, -1.30202398e-02f, -8.14178139e-02f, -3.30462977e-02f, 5.23311552e-03f, -9.44178328e-02f, -3.11185932e-03f, -1.33314759e-01f, -3.75639871e-02f,
  1.56222746e-01f, -7.56550506e-02f, 1.30773723e-01f, -8.15042704e-02f, -1.10834226e-01f, -7.33624771e-02f, 2.88399849e-02f, -5.38658574e-02f, -5.42756543e-02f, -8.09458867e-02f,
  -1.28305089e-02f, -7.65605189e-04f, 2.56580301e-02f, 5.97494887e-04f, -4.65685129e-02f, 8.07021186e-02f, -7.97289386e-02f, -7.21948072e-02f, 2.61100400e-02f, -1.38613760e-01f,
  -1.04154773e-01f, -5.16936854e-02f, 7.65635595e-02f, 8.09080899e-02f, -4.16750945e-02f, 1.12320937e-01f, -8.21486562e-02f, 3.96944955e-03f, 7.61883929e-02f, -6.41751289e-02f,
  -6.67751431e-02f, 9.74749997e-02f, 7.63488114e-02f, -1.11072361e-02f, -1.37370387e-02f, 1.74479056e-02f, 3.88770849e-02f, 8.95963907e-02f, -6.56621233e-02f, 4.44435664e-02f,
  7.98031837e-02f, -4.26081531e-02f, 4.24095131e-02f, 2.03423034e-02f, -3.57251652e-02f, -6.08233884e-02f, -5.20291291e-02f, -6.34827092e-02f, -7.15482607e-02f, -6.95156306e-02f,
  5.31057157e-02f, 8.77650753e-02f, -5.52776158e-02f, -4.52177860e-02f, -9.70659479e-02f, 4.97864261e-02f, -5.55226393e-02f, 6.63927495e-02f, -2.66949330e-02f, 3.77685577e-02f,
  5.98673113e-02f, 1.00958914e-01f, 3.28004025e-02f, 6.67415559e-02f, 4.56338041e-02f, 5.20984121e-02f, 3.60001065e-02f, 5.93402535e-02f, -8.52910727e-02f, -1.24959275e-02f,
  1.30149778e-02f, -3.75241414e-02f, -3.57441641e-02f, -5.68262786e-02f, 1.52560443e-01f, -3.52798067e-02f, -1.34911746e-01f, 1.11886472e-01f, 6.38673007e-02f, -1.16239168e-01f,
  -4.03508879e-02f, 7.87395686e-02f, 1.53171167e-01f, 1.52115732e-01f, 2.61703636e-02f, 1.06342189e-01f, 1.24311976e-01f, -4.65563638e-03f, 1.14581071e-01f, 8.76530632e-03f,
  -2.13257417e-01f, 9.41004604e-02f, -1.66623041e-01f, -1.53229520e-01f, -1.56688452e-01f, -1.64421096e-01f, -4.63130244e-04f, 6.96081221e-02f, -2.18250714e-02f, -1.02606162e-01f,
  5.90837635e-02f, -7.01870993e-02f, -1.54775232e-01f, -2.66494285e-02f, -1.55946329e-01f, -6.87776133e-02f, -1.75289080e-01f, -1.66029781e-01f, -1.92581072e-01f, -1.41914830e-01f,
  -7.58616999e-02f, -2.43767515e-01f, -2.35085651e-01f, -1.43831447e-01f, -1.21900238e-01f, -2.30482876e-01f, -1.98307022e-01f, -2.15020642e-01f, -1.54264420e-01f, -2.35467762e-01f,
  8.73302016e-03f, -3.76146734e-02f, -8.23584348e-02f, -2.23352574e-02f, -1.41708106e-02f, -9.54238698e-02f, 3.11166310e-04f, 4.93166484e-02f, 3.82386595e-02f, 1.23348022e-02f,
  -1.18240796e-01f, -9.08976197e-02f, -6.35579973e-02f, -1.13109037e-01f, 5.80695644e-03f, -2.40398664e-02f, 3.89468223e-02f, -6.11248985e-02f, -1.22496292e-01f, -2.71677487e-02f,
  3.08037661e-02f, -2.64420789e-02f, -2.66262377e-03f, 5.28282635e-02f, -1.02323763e-01f, -1.12727448e-01f, 5.07554486e-02f, -4.48796749e-02f, -5.10205925e-02f, -4.59798723e-02f,
  -3.35400831e-03f, -8.88286158e-02f, 6.65645227e-02f, 1.04773259e-02f, -1.23474523e-02f, 7.07542971e-02f, 1.20655512e-02f, -8.33424926e-02f, 4.42141816e-02f, 4.61251736e-02f,
  5.08673638e-02f, -2.29338799e-02f, 9.61317122e-02f, 1.30303670e-02f, 5.97024374e-02f, -5.23010008e-02f, 6.23273775e-02f, -2.67262049e-02f, -1.86911579e-02f, 2.69860458e-02f,
  8.10130034e-03f, 6.90934509e-02f, -7.02372342e-02f, 2.97959857e-02f, -4.80705537e-02f, -3.42088491e-02f, 2.18476336e-02f, -6.59004152e-02f, 2.84761190e-02f, -4.64668078e-03f,
  2.30648294e-01f, -9.39059556e-02f, 3.53120007e-02f, -9.35833622e-03f, 2.93363389e-02f, 5.42670675e-03f, -5.60420305e-02f, -3.16856094e-02f, 4.05737571e-02f, -7.46933818e-02f,
  -3.20063271e-02f, 1.05819777e-02f, 5.82332127e-02f, 1.20391492e-02f, -1.50359394e-02f, 2.60932986e-02f, 9.64832529e-02f, -3.39007266e-02f, -8.63961428e-02f, 6.96638823e-02f,
  -2.52917483e-02f, -5.31940535e-02f, 4.04755436e-02f, 1.74487755e-02f, -5.08281887e-02f, -1.77428350e-02f, -1.84957292e-02f, 2.88584176e-02f, -1.14240475e-01f, 1.73975974e-01f,
  2.05084741e-01f, -1.20241970e-01f, -2.64612436e-01f, -7.13591352e-02f, 1.47469027e-03f, -7.76365623e-02f, -7.01304600e-02f, -6.87874183e-02f, -6.42621517e-02f, -2.80287559e-03f,
  -8.68671201e-03f, -1.76501423e-02f, 9.62768421e-02f, -5.91246821e-02f, 6.13970198e-02f, -7.87439197e-02f, -1.15957439e-01f, -9.43063013e-03f, 1.60752252e-01f, 3.49190310e-02f,
  9.12351981e-02f, -2.38874741e-02f, 7.47381970e-02f, 1.58621501e-02f, -1.21479191e-01f, -9.15905014e-02f, -2.80898456e-02f, -2.20709592e-02f, -1.20324716e-01f, -6.14689998e-02f,
  -1.34271175e-01f, -4.62314254e-03f, 1.30754009e-01f, 1.10534348e-01f, -1.07763812e-01f, 1.14010066e-01f, -5.71477301e-02f, 1.00119643e-01f, 8.15330222e-02f, -2.45329887e-02f,
  -8.05845112e-02f, 4.01859954e-02f, -1.32226991e-02f, -6.18294477e-02f, 9.05155670e-03f, 1.67103056e-02f, 2.64799688e-02f, 5.22477087e-04f, 3.74790616e-02f, -1.56765897e-02f,
  -9.71234739e-02f, -6.52185977e-02f, 5.70847504e-02f, -7.13359490e-02f, 1.00807801e-01f, -2.34393869e-02f, -4.23877575e-02f, -6.29535466e-02f, -5.23973033e-02f, -3.07640638e-02f,
  -3.60489674e-02f, 3.98471914e-02f, -1.96800642e-02f, 2.09658351e-02f, 3.71073186e-02f, -6.90004602e-02f, -2.44252500e-03f, -6.33205995e-02f, 5.84479701e-03f, -5.24873659e-02f,
  1.63750525e-03f, -5.30185830e-03f, 4.81698364e-02f, -5.63030206e-02f, -7.88218621e-03f, 3.95742767e-02f, -6.14425018e-02f, -6.38279095e-02f, -1.21549936e-03f, 2.24138200e-02f,
  -8.60495046e-02f, -4.45269570e-02f, 1.97582096e-02f, 7.28525296e-02f, -4.91088219e-02f, 5.25423326e-03f, -3.29348929e-02f, 5.74800819e-02f, -1.69763602e-02f, 4.35691699e-02f,
  -7.22433776e-02f, 2.29133386e-02f, 6.68363571e-02f, 6.19882718e-02f, -3.99304517e-02f, -2.67794151e-02f, 1.27602769e-02f, -3.85765731e-02f, 8.21411610e-03f, 3.88895497e-02f,
  -3.02595459e-02f, -2.87783686e-02f, 4.95072640e-02f, 6.54691458e-02f, 6.23836666e-02f, 1.66473594e-02f, 6.48677424e-02f, 4.51145396e-02f, 1.07489219e-02f, -5.13161458e-02f,
  -1.40229408e-02f, 1.19838901e-01f, 6.59951195e-02f, 5.53468615e-03f, 8.65288526e-02f, 3.37284617e-02f, 6.17779419e-02f, -6.54033870e-02f, 5.78030646e-02f, 4.50236397e-03f,
  -2.62299597e-01f, 7.32922405e-02f, 5.02611659e-02f, 2.90949475e-02f, 1.25881940e-01f, -1.71003435e-02f, 1.47764347e-02f, -9.72496811e-03f, -1.09901890e-01f, 6.59037083e-02f,
  -8.89229774e-03f, -5.08884750e-02f, 1.78343859e-02f, -4.79114056e-02f, -8.49877223e-02f, -2.98975501e-02f, 1.68303117e-01f, 1.06039764e-02f, -4.81967963e-02f, -1.25148937e-01f,
  -1.73147686e-03f, -5.71709909e-02f, -8.04418847e-02f, 4.32718173e-02f, 5.87327443e-02f, 6.69271825e-03f, 8.58816039e-03f, 3.09055932e-02f, 2.83433194e-03f, 1.89029843e-01f,
  -7.32691307e-03f, -3.39628458e-02f, 5.54798841e-02f, 1.24566127e-02f, -8.11899919e-03f, -1.22956596e-01f, 7.91981351e-03f, -3.39103676e-02f, 2.63883900e-02f, -1.07671797e-01f,
  9.97861177e-02f, -5.77636138e-02f, 5.68018444e-02f, -8.52145851e-02f, -7.54668117e-02f, -4.23607863e-02f, -1.15294263e-01f, -1.03407510e-01f, 3.41574997e-02f, -1.01050213e-01f,
  -2.34958660e-02f, 1.40697956e-02f, -1.51949510e-01f, -1.52769133e-01f, -8.23345929e-02f, -3.48163513e-03f, -1.13592461e-01f, -1.60002038e-01f, -1.75761044e-01f, -2.10839599e-01f,
  1.00892246e-01f, -4.60783876e-02f, -5.90538085e-02f, -8.12811926e-02f, 4.18983810e-02f, 8.67518261e-02f, -2.52586249e-02f, 1.02020185e-02f, -6.10909089e-02f, 6.18428737e-02f,
  6.85552601e-03f, -7.48785883e-02f, -8.26450959e-02f, -3.96501049e-02f, 1.46638034e-02f, 5.38985692e-02f, -7.54385022e-04f, 2.29543261e-02f, 6.98425174e-02f, 6.79981261e-02f,
  -5.03896736e-02f, -4.97294739e-02f, -1.19858645e-02f, 1.59272812e-02f, -2.36960556e-02f, -4.81786579e-02f, 4.89863679e-02f, -9.84007642e-02f, 2.55885106e-02f, 3.68775129e-02f,
  -1.60742953e-01f, 3.84266116e-02f, -7.63117298e-02f, -1.01062670e-01f, 4.77039861e-03f, -6.19072188e-03f, -4.61238734e-02f, 6.44370019e-02f, 9.70839784e-02f, -1.11425951e-01f,
  4.80916835e-02f, -9.10662562e-02f, 7.05090240e-02f, -1.01139486e-01f, -1.18431009e-01f, -7.92948604e-02f, -6.43240958e-02f, 2.24876441e-02f, -8.92732367e-02f, -2.57586334e-02f,
  2.66288295e-02f, -1.80487886e-01f, -9.73068029e-02f, -9.51116383e-02f, -1.18189976e-01f, -1.56243026e-01f, -1.76136941e-01f, -1.20878369e-01f, -9.53763947e-02f, -2.98231781e-01f,
  1.89350486e-01f, 6.14081370e-03f, 1.02900811e-01f, 1.31288216e-01f, -1.63240254e-01f, -6.13237508e-02f, -2.46371433e-01f, -1.28844887e-01f, 2.45213192e-02f, -3.03850486e-03f,
  4.57882881e-02f, 1.31066859e-01f, 1.07804522e-01f, 8.40807259e-02f, -3.50285769e-02f, 6.48501441e-02f, 9.93412137e-02f, 2.39809584e-02f, 1.67097226e-01f, 1.03422977e-01f,
  -2.80186185e-03f, 1.57066882e-02f, 1.31984428e-01f, 7.67562538e-02f, 2.25100927e-02f, 1.04101919e-01f, 1.06827050e-01f, 6.44721696e-03f, -6.22163303e-02f, 1.88015088e-01f,
  1.60627663e-01f, 9.62658226e-02f, -2.09499132e-02f, -4.45295125e-02f, -1.06370777e-01f, 2.03448888e-02f, 2.49334332e-02f, 6.82242289e-02f, 4.06491794e-02f, -7.42655322e-02f,
  3.08038797e-02f, 7.70471618e-02f, -6.22166432e-02f, 3.64572816e-02f, -7.82829802e-03f, -4.89844084e-02f, 4.01941463e-02f, 1.09157853e-01f, 8.69677402e-03f, -1.75329838e-02f,
  -3.68367098e-02f, -5.94145171e-02f, -2.63010971e-02f, -1.16568834e-01f, -6.99591115e-02f, 1.77368745e-02f, -8.50297947e-05f, 1.19507767e-01f, 2.06197314e-02f, -1.39157576e-02f,
  -1.22726243e-03f, 4.52774167e-02f, 1.16067310e-03f, 6.25658929e-02f, 9.38748661e-03f, 4.51949425e-02f, -1.18464453e-03f, 1.52645567e-02f, 1.24143064e-02f, -4.11646105e-02f,
  -1.24325892e-02f, 1.95795260e-02f, -5.99971078e-02f, 3.48186344e-02f, 8.09565037e-02f, 1.58852786e-02f, -3.99950929e-02f, 6.65689930e-02f, 7.32766613e-02f, 1.10669106e-01f,
  -3.66255008e-02f, -8.22036713e-02f, 7.33557940e-02f, -2.72685345e-02f, 9.16403756e-02f, 1.48309153e-02f, 4.30468880e-02f, 4.63151671e-02f, -5.14638685e-02f, -5.54515282e-03f,
  -9.20825452e-02f, -1.66419968e-01f, 3.59724276e-02f, -3.45403329e-02f, 5.73232956e-02f, -8.85967985e-02f, -8.65338966e-02f, 6.54662848e-02f, -8.67710561e-02f, -3.28243338e-03f,
  5.25179096e-02f, 5.85674644e-02f, 6.34169253e-03f, -1.14007955e-02f, 4.37247045e-02f, -9.85043570e-02f, -7.30546862e-02f, 6.05846792e-02f, 4.26348224e-02f, -3.93131636e-02f,
  -1.95872132e-02f, -1.41909033e-01f, -7.72497198e-03f, -1.19845234e-01f, -8.06672648e-02f, -9.68005881e-02f, -9.81780328e-03f, -4.79913466e-02f, -3.45519297e-02f, 2.33656261e-02f,
  -9.90260094e-02f, -8.34992900e-03f, 1.07279271e-01f, 1.27039582e-01f, 5.22493832e-02f, -9.17091444e-02f, -2.55867988e-01f, -8.18564147e-02f, -1.10468075e-01f, -9.14952829e-02f,
  1.99863240e-02f, 1.21215209e-02f, -3.66771072e-02f, 5.80677502e-02f, -1.07521735e-01f, 6.17623553e-02f, 1.40186101e-01f, 1.58172578e-01f, -6.23477250e-02f, 6.82961419e-02f,
  1.29014656e-01f, 1.68601125e-01f, 7.56696090e-02f, 1.08229108e-01f, 3.89100201e-02f, 1.27035946e-01f, 1.20487198e-01f, 1.11798063e-01f, 2.33249534e-02f, 8.69290009e-02f,
  -6.49408251e-02f, -6.79956898e-02f, -7.92826861e-02f, 2.39319187e-02f, 6.84902519e-02f, 2.46301182e-02f, -9.38990116e-02f, -5.40453792e-02f, 3.74458469e-02f, -7.20277801e-02f,
  4.65478338e-02f, 6.40941272e-03f, -5.12478240e-02f, 3.04462556e-02f, -1.02221213e-01f, -1.09642230e-01f, 5.00044487e-02f, -1.16253998e-02f, -7.83861205e-02f, -1.90631747e-02f,
  7.80744702e-02f, 4.84206825e-02f, 1.25085060e-02f, -8.48055780e-02f, -2.36799046e-02f, -9.26075056e-02f, -1.30473107e-01f, -1.00739188e-01f, -5.10411598e-02f, -2.42619626e-02f,
  2.12840531e-02f, -6.21103868e-03f, 4.82390113e-02f, 3.10401153e-02f, 5.54596744e-02f, -9.15747322e-03f, 5.30680567e-02f, 9.01579484e-02f, -2.96667907e-02f, -6.20007440e-02f,
  4.09420654e-02f, -4.43688370e-02f, -5.71682565e-02f, 5.68163507e-02f, -5.52056246e-02f, -4.17706966e-02f, 8.98219794e-02f, -2.06226427e-02f, 2.63015064e-03f, -8.12076703e-02f,
  6.95615634e-03f, 1.24989916e-02f, 6.00937083e-02f, -2.06183195e-02f, 7.15473890e-02f, -5.82928583e-02f, -2.57326402e-02f, -7.48438537e-02f, -7.50569776e-02f, -2.56557800e-02f,
  -1.00439884e-01f, -9.65755731e-02f, -7.70433918e-02f, -3.15964371e-02f, 1.47901624e-02f, -4.78823520e-02f, 4.53047454e-03f, -6.21468462e-02f, 6.62719607e-02f, -9.03722048e-02f,
  -1.28782779e-01f, -7.93888569e-02f, 1.33054787e-02f, -2.21135169e-02f, 1.05474433e-02f, 3.15228361e-03f, 7.22066537e-02f, -6.73083141e-02f, -2.49882601e-03f, -1.03200182e-01f,
  7.30353147e-02f, -1.67041514e-02f, -1.62648022e-01f, -6.93665743e-02f, 3.48932855e-03f, -1.25741303e-01f, -7.91756809e-02f, -1.38304815e-01f, -1.69167176e-01f, -5.52771725e-02f,
  -1.75784454e-02f, 1.44416720e-01f, 3.72202182e-03f, -1.11956149e-01f, 5.18640168e-02f, -2.55893767e-02f, 1.14467010e-01f, 8.53636265e-02f, -6.91354722e-02f, 6.77849352e-03f,
  -6.07903441e-03f, -1.77614287e-01f, -1.26737252e-01f, -4.65729125e-02f, -2.46514962e-03f, 5.36881350e-02f, 8.35559368e-02f, -2.89805070e-03f, -1.32362038e-01f, -8.09288695e-02f,
  -1.25730574e-01f, -9.62477848e-02f, -7.64937699e-02f, -1.29359752e-01f, -1.26582161e-01f, -1.19211763e-01f, 3.75459753e-02f, -9.51429605e-02f, -8.33557099e-02f, -1.29893161e-02f,
  -1.80598155e-01f, 6.34983480e-02f, -8.37725699e-02f, 2.66031958e-02f, -6.94158450e-02f, 8.49277526e-02f, -6.06415095e-03f, -1.04822792e-01f, -1.41312676e-02f, 2.44824458e-02f,
  5.83700724e-02f, -1.15799278e-01f, -9.07819793e-02f, -7.66266212e-02f, -5.27517200e-02f, -6.56365827e-02f, 5.50131537e-02f, -6.10191785e-02f, -7.62614189e-03f, 2.39148531e-02f,
  3.70561928e-02f, -3.88806476e-03f, 8.81430879e-02f, 4.53937706e-03f, -1.83907114e-02f, -6.95842206e-02f, 8.57337564e-02f, 8.03651288e-03f, -7.08279908e-02f, -2.64891572e-02f,
  -2.97015719e-02f, -2.92891152e-02f, 1.19042788e-02f, -7.66409263e-02f, 3.58132422e-02f, 4.79280874e-02f, -3.63100171e-02f, -1.63673088e-02f, -3.68444212e-02f, 6.95583373e-02f,
  6.68986440e-02f, 6.54217675e-02f, -1.57416500e-02f, 4.51999791e-02f, 2.91281845e-02f, 4.22208384e-02f, 9.68224090e-03f, 1.07940711e-01f, 3.30717377e-02f, 2.76730601e-02f,
  -4.48892005e-02f, 2.83901468e-02f, -5.95226735e-02f, -1.86827797e-02f, 8.79736692e-02f, -6.27984777e-02f, -1.36307823e-02f, 2.36982387e-02f, -5.16718104e-02f, -9.24117193e-02f,
  -2.46902164e-02f, 9.18925740e-03f, -1.18463106e-01f, 3.16063762e-02f, -1.05899305e-03f, 6.02642260e-02f, -7.31643438e-02f, 9.83692035e-02f, -8.64260271e-02f, 7.42448270e-02f,
  -8.58823135e-02f, 1.23904608e-02f, -6.30196482e-02f, 2.02362109e-02f, -2.25138478e-02f, 4.16572168e-02f, 8.28059241e-02f, -1.58451265e-03f, 5.91731705e-02f, 8.83992016e-02f,
  5.22129945e-02f, 3.86393722e-03f, -4.06698510e-02f, 4.56408449e-02f, -4.18645516e-02f, -5.42357452e-02f, -7.69762918e-02f, 1.57653708e-02f, 5.39334156e-02f, 8.49336968e-04f,
  -1.19828330e-02f, -2.97811404e-02f, -6.28909543e-02f, -2.31980402e-02f, -6.13932423e-02f, -4.21778895e-02f, -2.51703970e-02f, -4.12373208e-02f, 5.13934009e-02f, -1.01345681e-01f,
  -2.74678739e-03f, 1.17152743e-02f, 6.62278160e-02f, 9.54132602e-02f, 1.12979874e-01f, -7.99551085e-02f, -7.60228485e-02f, 2.02687480e-03f, 1.08865857e-01f, 4.25602160e-02f,
  -1.07690290e-01f, -2.74881683e-02f, -4.24046665e-02f, -2.91383583e-02f, 1.10708084e-02f, -1.34658009e-01f, -1.25347540e-01f, -5.50370850e-02f, -5.84931672e-03f, -6.67984933e-02f,
  2.52373721e-02f, 1.10023893e-01f, 3.12891081e-02f, -1.75993275e-02f, -2.50630137e-02f, 1.00922652e-01f, 8.43767263e-03f, 5.72520047e-02f, 2.56220587e-02f, 6.37195131e-04f,
  8.05588514e-02f, -7.46886209e-02f, 3.16968262e-02f, 7.50624342e-03f, -4.67216522e-02f, -4.63406183e-02f, 9.27300230e-02f, -1.05990646e-02f, 1.05277762e-01f, -3.44354212e-02f,
  3.04734949e-02f, 5.30003570e-02f, 1.87244918e-02f, -3.23098805e-03f, 7.75391236e-02f, 3.39395069e-02f, 4.19785529e-02f, 6.09705225e-02f, 4.00519669e-02f, -8.98264274e-02f,
  -6.75208271e-02f, 1.80943124e-02f, -2.58204602e-02f, 6.84349611e-02f, -2.57895924e-02f, -5.26087768e-02f, -6.86994344e-02f, 1.70085989e-02f, 4.62068729e-02f, 4.65498418e-02f,
  2.39909603e-03f, -7.11446535e-03f, -2.96500064e-02f, -9.14985910e-02f, 2.36500762e-02f, 7.68393725e-02f, -6.81660548e-02f, -6.35645259e-03f, 3.82862017e-02f, -2.70778630e-02f,
  -1.69246867e-02f, 6.96125478e-02f, 5.58994673e-02f, 1.01166256e-02f, -4.88164322e-03f, -3.90114002e-02f, -2.23477446e-02f, 4.00461927e-02f, 4.56556492e-02f, -6.98874332e-03f,
  -1.13465272e-01f, 5.76779097e-02f, -5.92321120e-02f, 9.37103704e-02f, -9.44242626e-02f, -7.18168095e-02f, -3.75976972e-02f, 5.52635379e-02f, -6.12343103e-02f, -4.19152156e-02f,
  8.46500602e-03f, -1.60068087e-02f, -8.87756795e-02f, 6.54901639e-02f, -5.29489517e-02f, 6.42762035e-02f, 3.15038636e-02f, -7.18852207e-02f, 1.15955375e-01f, -2.54822839e-02f,
  6.14011486e-04f, -7.38841621e-03f, 5.32565527e-02f, -5.94471321e-02f, 5.86542413e-02f, 1.28442189e-02f, 1.00960359e-02f, -9.59480032e-02f, -6.02726229e-02f, -3.54042533e-03f,
  -4.73787397e-01f, 6.58574402e-02f, -8.93527418e-02f, -3.95057917e-01f, -1.67664498e-01f, 1.30519653e-02f, 1.06290750e-01f, 4.64243494e-04f, -2.49669358e-01f, -8.01083818e-03f,
  -2.49449853e-02f, -5.17623313e-02f, -2.41903253e-02f, -5.67886643e-02f, -3.24235260e-02f, 4.41092588e-02f, -4.22796719e-02f, -1.56833336e-01f, 3.64713883e-03f, -4.84797321e-02f,
  -9.84820500e-02f, -2.71596849e-01f, -1.72890052e-01f, -8.05238709e-02f, -1.65600881e-01f, -1.10463537e-01f, -1.00583009e-01f, -1.55492261e-01f, -5.22247516e-02f, -3.31008472e-02f,
  1.98603868e-01f, -3.37308012e-02f, -4.23676334e-02f, -6.75455257e-02f, 2.49924380e-02f, -4.96690236e-02f, 4.50700261e-02f, -1.04033902e-01f, -3.47502008e-02f, -6.95619807e-02f,
  -3.72652002e-02f, -4.48295325e-02f, 1.46517018e-02f, 3.39799561e-02f, -1.43515036e-01f, 1.62132327e-02f, -7.37173110e-02f, -9.03039426e-02f, 6.64423108e-02f, 2.70760395e-02f,
  1.50339454e-01f, 1.84526504e-03f, 6.72345757e-02f, 1.30501509e-01f, 2.34982390e-02f, -2.81601977e-02f, 1.81814786e-02f, 6.68125525e-02f, 5.07961065e-02f, -5.66139966e-02f,
  -5.32830618e-02f, -4.77908738e-03f, 6.55717328e-02f, -2.83148214e-02f, 3.03085651e-02f, -2.55217869e-02f, -6.67423308e-02f, 5.07502779e-02f, -5.28383963e-02f, 3.75253968e-02f,
  -1.81565937e-02f, -3.98205779e-02f, -6.64720684e-02f, -7.58793950e-02f, -1.67115219e-02f, -2.09629741e-02f, 1.43725062e-02f, 4.51772474e-02f, 1.00179404e-01f, -1.00041116e-02f,
  5.29584922e-02f, 4.35778163e-02f, -9.04272944e-02f, 6.28237575e-02f, 5.25115840e-02f, 3.92511766e-03f, 4.43777032e-02f, 1.10987376e-03f, 6.40151724e-02f, 3.34823951e-02f,
  -6.32363511e-03f, 1.22709654e-01f, -1.53771071e-02f, -5.63137680e-02f, -8.94971862e-02f, 8.82283971e-02f, 2.40763230e-03f, -5.02923690e-02f, -2.51578633e-02f, -4.56144195e-03f,
  7.52983789e-04f, 2.70774756e-02f, 7.02628121e-02f, -2.30802037e-02f, -1.34142824e-02f, -2.88847350e-02f, 3.26263383e-02f, -7.32971504e-02f, -1.93201657e-02f, 8.69211741e-03f,
  3.33921127e-02f, 1.02696367e-01f, 9.06216949e-02f, 5.47872297e-02f, 1.03369005e-01f, 1.63943339e-02f, 1.40286222e-01f, 1.26036361e-01f, 7.58182853e-02f, -1.01013025e-02f,
  -2.48627454e-01f, -3.58864442e-02f, -3.80632766e-02f, -6.80972785e-02f, 8.19615368e-03f, 7.83002079e-02f, 1.32865002e-02f, 8.03832039e-02f, -8.58174935e-02f, -5.26951160e-03f,
  2.94202846e-02f, -6.82403222e-02f, -1.11785047e-01f, -2.12845560e-02f, 1.30344741e-02f, 2.98552308e-02f, 1.07992098e-01f, -6.32648021e-02f, 5.14398068e-02f, -5.90190142e-02f,
  4.67478111e-02f, -4.68119010e-02f, 5.97570576e-02f, -4.31617461e-02f, -5.99495508e-02f, -2.09309924e-02f, 1.84976757e-02f, 9.37798247e-02f, 9.49637517e-02f, -8.52157772e-02f,
  -9.17928889e-02f, 5.22222137e-03f, -3.16251740e-02f, -7.59231448e-02f, 3.41661237e-02f, -9.11145657e-02f, -5.62416129e-02f, -1.03709288e-01f, -3.60990129e-02f, 2.39630919e-02f,
  -2.31637899e-02f, 7.41130710e-02f, -8.89448076e-02f, -5.47449552e-02f, 3.15593965e-02f, -2.31899377e-02f, 9.85012390e-03f, -8.14010724e-02f, 6.34421930e-02f, -7.08524361e-02f,
  1.28764182e-01f, 8.47560819e-03f, -1.20240428e-01f, -4.46599275e-02f, 2.75205411e-02f, -8.74686465e-02f, 1.88288111e-02f, -1.30896242e-02f, -4.90033552e-02f, -9.25298929e-02f,
  -7.54382368e-03f, -3.62871727e-03f, 5.97613491e-02f, 5.32973148e-02f, 7.56456330e-02f, -5.87791279e-02f, 2.58477740e-02f, -3.29453424e-02f, -7.23633021e-02f, 6.91133216e-02f,
  -6.70980141e-02f, -1.21940384e-02f, 3.18635777e-02f, 4.54006679e-02f, 5.15290871e-02f, -3.86675075e-02f, -3.60627696e-02f, 2.26482954e-02f, -1.89780369e-02f, 2.23779678e-02f,
  7.34649599e-02f, -2.64327787e-03f, -8.73907506e-02f, 3.40656117e-02f, -4.76805270e-02f, -3.06137297e-02f, -7.29809776e-02f, -8.53231847e-02f, 1.82933845e-02f, 6.99693710e-02f,
  -1.65108502e-01f, 1.54521152e-01f, -1.23671010e-01f, -1.06865831e-01f, 2.37773806e-02f, -4.91366833e-02f, -3.67632098e-02f, 5.39441779e-02f, -5.30955680e-02f, -1.62593424e-02f,
  2.77374312e-02f, -6.13765754e-02f, 4.39564027e-02f, 6.08966723e-02f, -1.03479892e-01f, 4.76025529e-02f, -1.29193496e-02f, 4.02323417e-02f, -2.55405307e-02f, -8.61308947e-02f,
  6.33987039e-02f, -1.31986246e-01f, -4.41187732e-02f, 8.53985921e-03f, -9.46514979e-02f, -1.24415107e-01f, 7.58465612e-03f, -8.60533789e-02f, 1.27622187e-02f, -1.39397800e-01f,
  -3.33097547e-01f, -1.29268095e-02f, 2.80540884e-02f, -6.58371300e-02f, 4.61421534e-02f, 6.44891709e-03f, -3.70175019e-02f, 1.04125597e-01f, 5.90587482e-02f, 7.50961602e-02f,
  -8.19352493e-02f, -2.47379839e-02f, -4.26017642e-02f, 9.51487944e-02f, 1.95703190e-03f, 8.05043131e-02f, -3.86467464e-02f, -8.23903456e-02f, -3.53393592e-02f, 1.18525187e-02f,
  -3.27830128e-02f, -1.43255264e-01f, -6.06246516e-02f, -1.20034965e-03f, -5.62448613e-02f, -8.49616379e-02f, -1.05442770e-01f, -1.37939766e-01f, 4.90709953e-02f, -1.00533597e-01f,
  -3.13716456e-02f, -1.45242184e-01f, 7.04316795e-02f, -4.37233038e-02f, -6.98931664e-02f, -2.03042421e-02f, 1.63017269e-02f, -6.09317794e-02f, -2.03766525e-02f, -2.43671387e-02f,
  -6.11977279e-03f, -2.72872448e-02f, 3.52199338e-02f, 8.81577581e-02f, -1.53131010e-02f, 3.17154452e-02f, -6.99302107e-02f, -1.87395625e-02f, 5.18852696e-02f, -7.81705678e-02f,
  2.18165684e-02f, -9.76443738e-02f, -1.93568498e-01f, 3.05788312e-02f, 9.06994045e-02f, -1.53777719e-01f, -8.70390236e-02f, -1.15400672e-01f, -1.22955656e-02f, -2.07369123e-02f,
  6.02392368e-02f, 6.11335784e-02f, 3.11126858e-02f, -4.84356321e-02f, -1.18848798e-03f, 2.34499685e-02f, 7.88219124e-02f, -1.43274982e-02f, -1.73301268e-02f, -5.90487011e-02f,
  4.67716530e-02f, -3.19735333e-02f, 1.18308645e-02f, -4.46637608e-02f, -7.62471035e-02f, 1.17037687e-02f, 5.32938838e-02f, -6.77075237e-02f, -3.13707590e-02f, -6.28453344e-02f,
  -3.04174256e-02f, 7.69074783e-02f, -5.12733907e-02f, 8.56595263e-02f, 8.54385272e-03f, 5.37876301e-02f, -8.40839818e-02f, 5.24676405e-02f, 5.46738878e-02f, -5.90554327e-02f,
  3.83262299e-02f, -2.70312652e-02f, -6.85279146e-02f, -8.49212632e-02f, -1.88026391e-02f, -6.98629245e-02f, -3.31015773e-02f, 1.15147419e-02f, -5.83913997e-02f, -8.86452943e-02f,
  3.07921190e-02f, 4.89690043e-02f, 1.45378252e-02f, -7.49899596e-02f, -3.28282416e-02f, -9.81981773e-03f, -1.03781871e-01f, 3.35938437e-03f, -7.70141557e-02f, 9.69980098e-03f,
  -4.78881262e-02f, -1.54881284e-01f, -1.79119676e-01f, 3.75078758e-03f, 5.85349798e-02f, -1.15697160e-01f, -8.05061534e-02f, 2.17333324e-02f, -1.50922269e-01f, -1.09299399e-01f,
  2.17018321e-01f, 7.26127252e-02f, -2.42484614e-01f, 1.20563582e-01f, -5.49837463e-02f, -1.55421406e-01f, -5.12449397e-03f, 7.26728886e-02f, 1.37721017e-01f, -6.23307489e-02f,
  -1.46143595e-02f, -7.75999278e-02f, -1.44396588e-01f, -1.69989005e-01f, -3.80743369e-02f, -1.55888140e-01f, -1.09278075e-01f, -5.21604791e-02f, -1.21688515e-01f, -9.65263024e-02f,
  -5.53763751e-03f, -1.70832966e-02f, 6.10429496e-02f, 3.11796926e-03f, 7.44273514e-02f, -8.61018803e-03f, -6.37659878e-02f, -1.80777349e-02f, -5.80264479e-02f, -1.64333940e-01f,
  -1.80217475e-01f, 5.75051047e-02f, -1.09858528e-01f, 1.30979519e-03f, 1.83633268e-02f, 7.35434741e-02f, -5.38749509e-02f, 1.64990278e-03f, -2.58587394e-02f, 2.43742727e-02f,
  -9.60951522e-02f, 3.50950435e-02f, -6.76218569e-02f, -9.54580903e-02f, 1.37112131e-02f, -1.08621426e-01f, -6.83795512e-02f, -2.52102893e-02f, -7.02141970e-02f, -6.31551147e-02f,
  2.26235464e-02f, -3.64661440e-02f, -9.93927866e-02f, -2.72112079e-02f, -1.22210784e-02f, -5.91646247e-02f, -6.99967295e-02f, -1.86401736e-02f, 6.90168589e-02f, 8.72577280e-02f,
  -1.53546175e-03f, 6.99826051e-03f, -8.97288248e-02f, 1.90906506e-02f, -3.00270654e-02f, 6.72606677e-02f, -3.14952210e-02f, 2.96315979e-02f, 1.33414147e-03f, 4.48985174e-02f,
  5.98613508e-02f, -1.46013862e-02f, -1.50636947e-02f, 1.07553430e-01f, -2.73399502e-02f, 4.22126986e-02f, 1.24773430e-02f, -1.55170709e-02f, 7.24863335e-02f, -5.67998588e-02f,
  -1.09096046e-03f, -8.03916603e-02f, 6.63955733e-02f, -8.69744122e-02f, -2.12029880e-03f, 3.47753167e-02f, 1.31129939e-02f, 1.66081004e-02f, 8.03612098e-02f, 7.06152916e-02f,
  -1.06175849e-02f, -1.08641893e-01f, -6.97696656e-02f, -2.01503336e-02f, -8.42460617e-02f, 4.94170003e-03f, 6.43659532e-02f, 4.65765595e-03f, -6.64682910e-02f, -5.20752221e-02f,
  -3.24038938e-02f, -7.35134482e-02f, -3.39518785e-02f, -2.69038901e-02f, 1.88711416e-02f, -7.01039955e-02f, -2.89807636e-02f, 2.21260060e-02f, -2.60853134e-02f, -1.72657166e-02f,
  7.20213261e-03f, 7.48274699e-02f, -1.85960587e-02f, 5.61267026e-02f, 7.55594745e-02f, -1.23262875e-01f, 1.89295821e-02f, -4.36552987e-02f, -1.72077247e-03f, 1.41285449e-01f,
  -2.35908106e-01f, 5.91873452e-02f, 1.03987262e-01f, -8.30004066e-02f, -8.51494372e-02f, -3.08454428e-02f, -1.61528468e-01f, -1.10451795e-01f, -9.08956490e-03f, 3.07441447e-02f,
  6.46435991e-02f, 5.35755940e-02f, -7.48348236e-02f, -4.87589128e-02f, 2.96803173e-02f, -1.02710091e-01f, -1.12831078e-01f, -5.53460745e-03f, -1.41885161e-01f, -1.60576493e-01f,
  -7.55844731e-03f, -1.57068014e-01f, -3.99197340e-02f, -9.75738764e-02f, 3.68914120e-02f, -5.16108982e-02f, -2.01414935e-02f, -1.26411334e-01f, -1.50791869e-01f, -1.38857365e-01f,
  1.66081771e-01f, -1.61990315e-01f, 6.05330728e-02f, -6.40545934e-02f, -7.87090790e-03f, -1.52593348e-02f, -2.90733743e-02f, -3.62780355e-02f, -6.69523403e-02f, -4.71277833e-02f,
  -7.63746500e-02f, 1.01204940e-04f, -3.52738723e-02f, 8.48675147e-02f, 5.97081333e-02f, -1.09558105e-02f, -9.02509019e-02f, 7.26267993e-02f, 6.39537070e-03f, -1.24291098e-02f,
  2.21682340e-02f, -4.34590504e-02f, -2.77084615e-02f, 2.55218539e-02f, -5.32098562e-02f, -4.01020944e-02f, 9.80166122e-02f, -9.95523706e-02f, -8.95381812e-03f, 5.77913597e-02f,
  -5.72014488e-02f, 2.11759862e-02f, 3.96473035e-02f, 2.02017352e-02f, -1.98120568e-02f, 1.21082189e-02f, -2.87329797e-02f, -5.88174090e-02f, 3.29996226e-03f, -5.26359417e-02f,
  -1.72766373e-02f, 7.87882060e-02f, 4.94250841e-02f, -1.77061185e-04f, -3.19792591e-02f, 1.11989276e-02f, 3.28515321e-02f, -5.38164526e-02f, -2.57991273e-02f, -1.02233693e-01f,
  -1.91591922e-02f, -7.10052475e-02f, -1.75529849e-02f, -8.25568065e-02f, 4.29592803e-02f, -5.44073246e-02f, -7.02207163e-03f, -1.93302426e-02f, 7.09663853e-02f, 9.90745705e-03f,
  2.14148253e-01f, -1.52831376e-01f, -3.58777419e-02f, -5.60926571e-02f, 2.35309042e-02f, -3.53769697e-02f, 7.52289444e-02f, 6.16918271e-03f, 7.38268439e-03f, -4.25088294e-02f,
  6.26413599e-02f, 4.92467694e-02f, 1.32219046e-01f, 8.93749148e-02f, 3.00288852e-02f, 9.61663947e-03f, 5.09418361e-02f, -4.71326597e-02f, -2.07859222e-02f, -2.63478905e-02f,
  8.31518248e-02f, -9.67215300e-02f, -3.22176069e-02f, 7.24678338e-02f, 6.08087257e-02f, 2.94398703e-02f, 8.05214867e-02f, -4.52752858e-02f, 7.86694288e-02f, 1.49707079e-01f,
  8.78198445e-02f, 1.37254775e-01f, 1.38123363e-01f, -1.10612658e-03f, -1.31509215e-01f, -1.58745140e-01f, -1.06419906e-01f, 2.41453554e-02f, 3.78455222e-02f, 8.48055538e-03f,
  6.76165149e-03f, -1.17789686e-01f, 7.08108246e-02f, -6.34841174e-02f, -5.27488478e-02f, 8.98680016e-02f, -5.61837014e-03f, -5.30085079e-02f, -9.94075611e-02f, -9.47582349e-02f,
  -5.64321317e-02f, 6.35285750e-02f, 1.03197172e-02f, 1.24144532e-01f, -1.68247446e-02f, -1.01588942e-01f, 8.19253772e-02f, -4.45316453e-03f, -8.88373777e-02f, 1.07172333e-01f,
  8.69052932e-02f, 1.42657861e-01f, -1.21124290e-01f, 1.38747627e-02f, -2.49798745e-02f, 3.56185399e-02f, 3.35072950e-02f, 1.64702877e-01f, 1.17641337e-01f, -2.09336709e-02f,
  1.17106706e-01f, 1.41137689e-02f, 4.47942838e-02f, 3.40766758e-02f, 4.04525101e-02f, 5.93164191e-02f, 7.83047304e-02f, 1.36129588e-01f, 6.20790794e-02f, 3.72166261e-02f,
  4.62825745e-02f, 4.04515490e-02f, 8.67992989e-04f, 1.93575001e-03f, -4.99602854e-02f, -8.35369006e-02f, 3.16361301e-02f, 2.39635501e-02f, -4.88898344e-02f, -6.55898545e-03f,
  5.48334159e-02f, 9.50664356e-02f, -5.20022511e-02f, -1.79100223e-02f, 6.29041344e-02f, -3.44024673e-02f, 2.79684979e-02f, -2.14678738e-02f, -6.77236021e-02f, -6.93106558e-03f,
  -4.68275286e-02f, -5.14092781e-02f, -2.33126916e-02f, -6.35562185e-03f, 1.28437774e-02f, 4.29880209e-02f, -1.00179411e-01f, -6.50184695e-03f, 3.31077725e-02f, 1.56416744e-02f,
  3.13135013e-02f, 3.51203270e-02f, -5.57438703e-03f, -7.30506144e-03f, 5.60030490e-02f, -4.81312489e-03f, -1.05755769e-01f, 1.89761445e-02f, -3.89030017e-03f, -9.12203803e-04f,
  2.22049635e-02f, -1.06922202e-01f, -1.83224175e-02f, -4.24262322e-02f, 2.56543066e-02f, 1.01113923e-01f, 7.74831250e-02f, 3.14391106e-02f, -3.49423774e-02f, 4.01490852e-02f,
  -1.16121145e-02f, 6.66728094e-02f, 6.80259168e-02f, -1.92285038e-03f, -2.13854611e-02f, 3.99686322e-02f, 5.49334325e-02f, 7.27029666e-02f, 5.67630818e-03f, 4.72991541e-02f,
  6.97000772e-02f, -4.38159145e-02f, -4.34192382e-02f, -1.45421270e-02f, -7.81820565e-02f, -1.26677155e-01f, -2.53236052e-02f, -2.18027104e-02f, -2.61388496e-02f, -7.87088871e-02f,
  1.65247452e-02f, -5.92460055e-05f, -9.57067870e-03f, 1.80126357e-04f, -2.42017359e-02f, -1.04601216e-02f, -8.39560181e-02f, -7.77047575e-02f, -6.28913715e-02f, -2.12586559e-02f,
  1.55786067e-01f, 1.30991610e-02f, 3.91554506e-03f, -2.29771845e-02f, 8.93812925e-02f, -1.01953432e-01f, 6.73886538e-02f, 1.11531541e-02f, 6.24068752e-02f, 2.51220353e-02f,
  -6.73328468e-04f, -6.59802323e-03f, 1.13469690e-01f, -4.77615856e-02f, -5.31053580e-02f, 9.97388363e-02f, 6.48513362e-02f, 7.45304376e-02f, 9.60821807e-02f, -5.07475734e-02f,
  1.21111058e-01f, -4.98875082e-02f, -3.24346907e-02f, -2.00595967e-02f, 5.60715683e-02f, 6.58708736e-02f, 6.24861270e-02f, -6.57756254e-02f, 4.33146581e-02f, 9.83166695e-03f,
  9.82885286e-02f, -7.64509570e-03f, -6.12916350e-02f, -5.69115132e-02f, 7.51139894e-02f, -2.84388755e-03f, -3.76300290e-02f, -9.24188420e-02f, -3.33580486e-02f, 1.10110240e-02f,
  -6.60837581e-03f, -2.98100896e-02f, -3.73962112e-02f, 2.49383189e-02f, -4.09043543e-02f, -5.19454218e-02f, -2.89093982e-02f, 8.40378739e-03f, -5.94738722e-02f, -4.36906517e-02f,
  -4.69784997e-02f, 2.35353298e-02f, -7.77776614e-02f, -1.54079893e-03f, -1.19800568e-02f, -2.63405498e-02f, -2.79800110e-02f, -6.05174415e-02f, -2.80443709e-02f, -9.38118249e-02f,
  4.98999702e-03f, 5.95098622e-02f, -3.65030393e-02f, -6.08140714e-02f, 6.62613586e-02f, 6.74478710e-02f, -1.48269637e-02f, -8.35338682e-02f, -2.78500374e-02f, -3.26810963e-02f,
  -1.68933608e-02f, -1.38102882e-02f, 4.85579334e-02f, -1.02657489e-01f, -9.68328305e-03f, -5.74639626e-02f, -9.59873050e-02f, -5.81540652e-02f, 6.77627623e-02f, -7.02551454e-02f,
  -1.07761085e-01f, 4.27420400e-02f, 6.75327331e-02f, 2.12168191e-02f, 5.20025901e-02f, 6.66692257e-02f, 2.35329941e-02f, 8.42403844e-02f, -6.98009133e-02f, -3.93781438e-02f,
  9.85086709e-02f, -3.76108177e-02f, -2.73548868e-02f, -8.38321447e-02f, -6.15121573e-02f, 2.52749491e-02f, -5.59909157e-02f, 4.39495221e-02f, -3.08170151e-02f, -1.63537581e-02f,
  5.34125837e-03f, -8.77286270e-02f, 5.05239852e-02f, 2.07685642e-02f, 3.22885737e-02f, -6.53258637e-02f, 6.99391440e-02f, 4.95087616e-02f, -7.83265904e-02f, -1.03138424e-01f,
  -3.30531329e-01f, 5.59384860e-02f, 1.09640755e-01f, -1.51609913e-01f, 2.82544323e-04f, 1.56046629e-01f, 2.16634512e-01f, 1.11380585e-01f, -3.84716280e-02f, 1.81196928e-02f,
  -1.25475869e-01f, -1.48072854e-01f, -1.85321551e-02f, 2.65381224e-02f, 8.16877931e-02f, 9.84004140e-02f, 1.23396836e-01f, 1.42496629e-02f, -5.76238474e-03f, 7.08990023e-02f,
  -3.73278372e-02f, -1.39183640e-01f, -1.30670592e-01f, -1.06514871e-01f, -2.29943730e-02f, -9.54665765e-02f, 5.22548221e-02f, 3.43378261e-02f, 6.13020808e-02f, -8.84232596e-02f,
  -1.82893679e-01f, -1.70028836e-01f, 9.49661806e-03f, -1.33116603e-01f, -7.10045323e-02f, -5.15419990e-03f, -9.74214002e-02f, -2.37847455e-02f, 4.55518067e-02f, -4.64876095e-04f,
  -6.42539710e-02f, -7.97180980e-02f, 1.20330825e-02f, 5.08586951e-02f, -1.34518638e-01f, -2.27858741e-02f, -4.96652238e-02f, -5.28441221e-02f, -8.64303187e-02f, 3.60860378e-02f,
  -5.05109616e-02f, 2.56208796e-03f, 6.42728806e-03f, 3.22604738e-02f, -4.55400422e-02f, -6.91723898e-02f, 9.54656955e-03f, -1.01989351e-01f, 3.85328904e-02f, -1.31037638e-01f,
  -5.80538623e-03f, 1.10436112e-01f, 1.33084180e-02f, 4.28665094e-02f, -4.32898104e-02f, -9.70656925e-04f, 1.13796843e-02f, 4.31717187e-02f, 5.01165837e-02f, -8.19693133e-02f,
  -1.88836530e-02f, 7.39303678e-02f, 2.45028138e-02f, -5.51201776e-02f, -1.31136701e-02f, -1.42160188e-02f, -6.18087687e-02f, -5.18192835e-02f, -4.04931791e-02f, -2.37137824e-02f,
  -8.47022906e-02f, -7.80979497e-03f, -6.54610172e-02f, -6.53475057e-03f, 1.06447533e-01f, 1.31919794e-02f, -6.50277585e-02f, -6.96568936e-02f, -7.99069479e-02f, 8.76102671e-02f,
  -2.14144796e-01f, 7.17098862e-02f, -7.79275000e-02f, -4.67475690e-02f, -6.24142326e-02f, -3.89904641e-02f, 2.59449147e-02f, 6.76101372e-02f, 2.81862691e-02f, -6.78342804e-02f,
  5.96932508e-02f, 2.49857232e-02f, -1.03748836e-01f, 3.00545003e-02f, -8.52246806e-02f, -5.25196828e-02f, 6.93507046e-02f, 3.58413011e-02f, 2.27664392e-02f, -7.45296404e-02f,
  3.90091874e-02f, 3.10404245e-02f, -5.97086921e-02f, 7.59214908e-02f, 2.00838372e-02f, 6.92778453e-03f, -5.59108369e-02f, -1.07634895e-01f, -2.78814174e-02f, 6.88622668e-02f,
  4.35016863e-03f, -1.11567311e-01f, -6.94508553e-02f, 5.70597872e-03f, 8.77641737e-02f, -4.49467972e-02f, -5.79513423e-02f, 8.18979964e-02f, -4.58158441e-02f, 7.65479580e-02f,
  2.73295399e-02f, 3.49143334e-02f, 1.15441374e-01f, 3.37283015e-02f, -3.48774008e-02f, 5.05052730e-02f, -2.59337644e-03f, 2.29106322e-02f, -5.72710373e-02f, 2.90145166e-02f,
  -8.99606943e-02f, 8.23804513e-02f, 4.15992700e-02f, -1.01059370e-01f, -9.31108370e-02f, -1.15716504e-02f, -1.65241342e-02f, -6.06291555e-02f, 7.11153448e-03f, 6.82939449e-03f,
  -1.54618863e-02f, 6.01637959e-02f, -6.69266377e-03f, -8.65870193e-02f, 7.26315156e-02f, -1.67948846e-02f, -7.59830922e-02f, 1.09525984e-02f, 5.09714223e-02f, 6.10192679e-02f,
  4.92430234e-04f, 4.52153943e-02f, 2.99600232e-02f, -6.52037859e-02f, -4.79547083e-02f, 3.56446169e-02f, 4.11866792e-02f, -1.12791233e-01f, -9.59243029e-02f, 2.42063422e-02f,
  3.67179327e-02f, 4.86056246e-02f, -8.36012438e-02f, -3.33234668e-02f, -1.13121293e-01f, 7.30699152e-02f, 6.06943406e-02f, -7.23955557e-02f, -1.46693699e-02f, -1.06383882e-01f,
  -1.70229636e-02f, -1.22285895e-02f, 4.84784618e-02f, -1.91556364e-02f, 7.38920197e-02f, 2.46534795e-02f, 3.89176756e-02f, 1.59943420e-02f, -8.13326146e-03f, 9.42025185e-02f,
  -7.47185647e-02f, -1.56863054e-04f, -3.35821323e-02f, 7.02332705e-02f, -2.64594331e-02f, 7.02478439e-02f, 5.56673994e-03f, -1.22230304e-02f, 4.46920358e-02f, 2.50168853e-02f,
  -7.10205585e-02f, -4.71577682e-02f, 5.77463359e-02f, 1.25680706e-02f, 7.84975812e-02f, -6.84172511e-02f, 3.84745412e-02f, 6.22094423e-03f, -2.48086397e-02f, -1.78677216e-02f,
  1.60867974e-01f, 5.94658442e-02f, 9.40996110e-02f, -8.78483057e-02f, -8.13458338e-02f, 7.81189278e-03f, -3.75422426e-02f, -1.07415123e-02f, 5.41545190e-02f, -7.62846917e-02f,
  6.19922020e-02f, 8.10938701e-02f, -8.42228606e-02f, -3.25717814e-02f, -6.22608103e-02f, -5.52586513e-03f, -2.94213854e-02f, 2.35414207e-02f, -3.84125896e-02f, -1.02444626e-01f,
  -3.63416187e-02f, -1.74726229e-02f, 8.95531848e-02f, 5.76668531e-02f, 5.77005707e-02f, 9.56974104e-02f, 7.27191567e-02f, -1.08928904e-02f, 9.64396372e-02f, -1.32966023e-02f,
  6.77481517e-02f, -6.06871136e-02f, -3.49485539e-02f, 9.66989100e-02f, -2.17865370e-02f, -2.25932077e-02f, 5.71182258e-02f, -7.49575496e-02f, -8.10184330e-02f, 3.42407078e-02f,
  4.39503379e-02f, -3.00904438e-02f, -6.26775846e-02f, -1.15414448e-01f, -8.55445769e-03f, -1.31680109e-02f, 8.72286037e-02f, -6.81475550e-03f, 7.12143853e-02f, 2.01621070e-03f,
  -4.25668508e-02f, -5.12686232e-03f, -9.99937654e-02f, -2.51117740e-02f, -3.22547816e-02f, 3.12803052e-02f, 5.87987937e-02f, -1.10279648e-02f, -7.98063874e-02f, 2.26111282e-02f,
  -1.00053009e-02f, -5.08605465e-02f, 7.20191002e-02f, -5.91321774e-02f, -3.73721845e-03f, -3.10635865e-02f, -1.97610874e-02f, -8.36653784e-02f, 2.12504435e-02f, -8.67879670e-03f,
  -6.56775832e-02f, -9.79157165e-03f, 3.39993574e-02f, 3.32972333e-02f, -2.41753664e-02f, 6.96423873e-02f, -7.36134648e-02f, 1.51912766e-02f, -2.72860210e-02f, -7.64499903e-02f,
  1.82459373e-02f, 9.29525569e-02f, 7.69935548e-02f, 3.29761542e-02f, -7.94001482e-03f, -1.76311992e-02f, 6.89356998e-02f, -7.93698281e-02f, 6.52146563e-02f, -1.02224611e-01f,
  -4.68476564e-02f, -5.95456474e-02f, -7.24681094e-02f, -2.85504479e-02f, -6.13665059e-02f, 1.10871131e-02f, 1.31463828e-02f, -9.05037522e-02f, 4.92736064e-02f, 7.99976587e-02f,
  -1.65988151e-02f, 4.16688472e-02f, 5.04898392e-02f, 3.47246304e-02f, -5.07203750e-02f, -2.75801346e-02f, -8.06201473e-02f, 2.49255970e-02f, -5.96631654e-02f, -7.25021958e-02f,
  -8.22118893e-02f, -4.63196002e-02f, -2.13052407e-02f, -8.08740035e-02f, -4.94665019e-02f, 8.61193091e-02f, 3.22165042e-02f, -5.06609716e-02f, 1.73632037e-02f, 8.04965347e-02f,
  3.43264826e-03f, 5.78159466e-02f, -5.12213185e-02f, 4.11864035e-02f, -5.98925054e-02f, 9.65278712e-04f, -5.13957739e-02f, -9.25590917e-02f, 5.37286326e-02f, -1.79375091e-03f,
  3.23098637e-02f, 3.63726057e-02f, -3.49870436e-02f, 3.60382237e-02f, 1.91238001e-02f, -5.50687462e-02f, 4.34669107e-02f, 4.29291092e-02f, 1.33612100e-02f, -9.34415981e-02f,
  6.92693144e-02f, 1.16689906e-01f, 5.61038218e-02f, 1.08569572e-02f, 2.94806175e-02f, 7.60100037e-02f, 1.50490552e-02f, 1.73157826e-02f, -4.01185229e-02f, -3.79247218e-02f,
  -1.15133356e-04f, -2.41008878e-01f, -1.28825501e-01f, 1.66719723e-02f, -5.22068376e-03f, -2.58164536e-02f, -2.31183410e-01f, -5.17755635e-02f, 1.41780693e-02f, -1.65188983e-01f,
  -9.49697644e-02f, -8.99993107e-02f, -9.34077986e-03f, -1.10213995e-01f, -4.90576029e-02f, -1.73811108e-01f, -1.46989673e-01f, -1.39878467e-01f, 5.20671941e-02f, -1.10746911e-02f,
  -4.90715206e-02f, -6.79371208e-02f, 4.63044643e-02f, 3.96689922e-02f, 3.20225768e-02f, -7.72017092e-02f, -3.05653829e-02f, 1.81778725e-02f, 3.83484215e-02f, -5.26806852e-03f,
  -6.64025545e-02f, 1.09143242e-01f, 2.31587626e-02f, 1.07479267e-01f, 8.65382105e-02f, 4.53453064e-02f, -1.31001952e-03f, 8.17794260e-03f, 2.92230193e-02f, -3.21758762e-02f,
  5.68280332e-02f, -5.56614399e-02f, 1.05970569e-01f, 4.64187413e-02f, -2.61708070e-02f, -1.82814486e-02f, -3.01977154e-03f, 1.02869548e-01f, 1.49933761e-02f, 3.79161499e-02f,
  -4.74948324e-02f, -7.63161778e-02f, -1.03647441e-01f, 6.56422898e-02f, 1.39816180e-01f, -1.12033011e-02f, 1.60991829e-02f, 3.73584591e-02f, 1.02428779e-01f, 3.41398306e-02f,
  -7.63083622e-02f, 9.18549602e-04f, -2.91006472e-02f, -1.74276661e-02f, -5.60194701e-02f, -2.53503378e-02f, -3.54680978e-02f, 3.34407315e-02f, 2.42177751e-02f, 2.62035523e-02f,
  -2.19745021e-02f, 3.38210315e-02f, -2.70207655e-02f, 1.09511649e-03f, 3.84864993e-02f, 4.19467539e-02f, -7.61095807e-02f, 5.41983405e-03f, 5.86489253e-02f, -1.44917583e-02f,
  -1.70233361e-02f, -5.76756746e-02f, -2.08432302e-02f, -8.02630335e-02f, -4.94074300e-02f, 6.91505224e-02f, -3.37974876e-02f, 5.50857559e-02f, 3.69809493e-02f, 2.24791951e-02f,
  3.01272999e-02f, 1.81992780e-02f, -4.96551096e-02f, -2.01403983e-02f, 6.69817999e-02f, 1.70026254e-02f, 4.40924466e-02f, 5.48840165e-02f, 9.04933214e-02f, 8.19494203e-02f,
  1.85353868e-02f, 7.09216520e-02f, -8.08568895e-02f, 8.44865218e-02f, -1.11783547e-02f, 9.09177810e-02f, -4.05392237e-02f, 2.55730911e-03f, -8.79512131e-02f, 9.07868668e-02f,
  3.97714600e-02f, -1.13405317e-01f, -4.64316867e-02f, -1.35067984e-01f, 8.91935751e-02f, -1.43045068e-01f, -9.08013657e-02f, -4.77089360e-02f, -9.13276523e-02f, -1.09005295e-01f,
  -2.44409010e-01f, 1.77786127e-01f, 5.28605049e-03f, 9.41054896e-03f, -5.33373207e-02f, -4.11812291e-02f, -1.39766023e-01f, 7.19365152e-03f, -3.52548785e-03f, 4.39473763e-02f,
  -3.71420644e-02f, -1.59033388e-01f, -1.31644592e-01f, -2.04174325e-01f, -2.10038006e-01f, 1.04199246e-01f, 2.22494341e-02f, -2.51585901e-01f, -3.90560389e-01f, -3.35101187e-01f,
  -2.68424243e-01f, -2.93041527e-01f, -3.18156779e-01f, -8.71433169e-02f, -3.15971184e-03f, -1.34801883e-02f, 8.83512795e-02f, -8.12715814e-02f, -4.23610210e-02f, 9.92810428e-02f,
  3.59561145e-02f, 7.90721644e-03f, -9.21521410e-02f, -4.38732058e-02f, 5.99532686e-02f, 7.31514301e-03f, -1.78206377e-02f, 5.37260920e-02f, -2.32827086e-02f, -5.65990806e-02f,
  -2.02032439e-02f, 3.02637182e-02f, -1.17434360e-01f, -8.82768184e-02f, -8.41508135e-02f, -1.16402872e-01f, -1.86262128e-04f, -1.20640270e-01f, 7.05267489e-02f, 6.90813139e-02f,
  -3.38462070e-02f, -7.74143189e-02f, -8.38459507e-02f, -5.74118923e-04f, 7.93463886e-02f, -7.02904835e-02f, -6.63352236e-02f, 1.87718403e-02f, 5.16079254e-02f, 2.46833917e-02f,
  3.81536856e-02f, 8.30446929e-02f, 4.17137221e-02f, -5.28579205e-02f, -7.16866879e-03f, 9.97361541e-02f, -6.65246546e-02f, -5.76894097e-02f, -8.07334781e-02f, 1.88711379e-02f,
  1.73997339e-02f, 1.20978691e-01f, -2.95831952e-02f, 6.49938434e-02f, 4.24372964e-02f, 7.18927383e-02f, -2.45680958e-02f, -3.08539402e-02f, -1.05168842e-01f, -3.19398455e-02f,
  -1.02178834e-01f, 5.45491800e-02f, -3.61803162e-04f, -5.66341765e-02f, 8.82549658e-02f, 1.01490803e-01f, 7.18945812e-04f, 2.86403317e-02f, -1.13155015e-01f, 6.89357072e-02f,
  -1.21311806e-01f, 1.56235853e-02f, 9.07667130e-02f, -1.90223642e-02f, 6.44612387e-02f, 1.01379998e-01f, 3.01439837e-02f, 8.27289373e-02f, 1.02283275e-02f, -2.23805420e-02f,
  -1.38946906e-01f, 1.55515047e-02f, -1.35760084e-02f, -4.02046777e-02f, -1.22655325e-01f, 1.29891671e-02f, 3.14664915e-02f, -1.31987497e-01f, -7.27066025e-02f, 1.19115315e-01f,
  6.19846284e-02f, -1.35655195e-01f, -2.31838733e-01f, -1.06524289e-01f, 4.77429898e-03f, -2.97057889e-02f, 4.91525885e-03f, -1.33455947e-01f, -1.50084257e-01f, 2.91999709e-02f,
  -8.54954496e-02f, -3.71702276e-02f, 4.80058379e-02f, -1.81862772e-01f, 1.57405753e-02f, -5.24519831e-02f, 8.54516402e-02f, -2.56111622e-02f, -8.67103711e-02f, -3.63867581e-02f,
  -1.66964028e-02f, -9.38275829e-03f, 3.59092513e-03f, -8.16205740e-02f, -2.30258293e-02f, -6.13320023e-02f, -3.17527205e-02f, -1.10568695e-01f, -1.45412490e-01f, -7.18944520e-02f,
  -1.80151686e-01f, -1.62060246e-01f, -2.13198096e-01f, -4.21394296e-02f, -1.19099990e-01f, -1.43197522e-01f, 5.10774367e-02f, 7.76009820e-03f, 5.89364432e-02f, -4.95371483e-02f,
  -3.53578525e-03f, 2.32311897e-02f, 3.20472084e-02f, -1.01128593e-01f, 5.31509332e-02f, 8.48613903e-02f, -7.56178144e-03f, 6.55673742e-02f, -2.37024389e-03f, -1.37270726e-02f,
  6.66569322e-02f, -8.85327831e-02f, 4.93913330e-02f, -9.67226103e-02f, -1.07816700e-02f, -4.88051139e-02f, -5.14452308e-02f, -1.68137066e-02f, -1.70594398e-02f, -1.85376480e-02f,
  -2.27233414e-02f, -1.07772164e-01f, -4.52754758e-02f, 6.26358856e-03f, 2.31389096e-03f, -1.07779428e-01f, 2.47159190e-02f, -1.96556672e-02f, 1.26457855e-01f, -1.05283126e-01f,
  -2.18871348e-02f, -4.43972386e-02f, 2.73524988e-02f, -3.04471180e-02f, -5.01666516e-02f, 6.05255552e-02f, 6.19038232e-02f, 6.67506903e-02f, -7.93855488e-02f, -1.80177148e-02f,
  -4.01700698e-02f, -3.49163227e-02f, 2.75909584e-02f, -8.64028931e-02f, -4.79463581e-03f, -3.71932164e-02f, -3.90921161e-02f, -9.22195092e-02f, -3.81811731e-03f, -9.09077760e-04f,
  2.21799966e-02f, 3.48163731e-02f, 6.12247922e-02f, 6.00379193e-03f, -5.70968213e-03f, 4.00159359e-02f, -6.73374459e-02f, 1.57383382e-02f, 7.45832324e-02f, 8.82818922e-02f,
  -8.94442722e-02f, 7.17356279e-02f, -1.26178721e-02f, -7.45475665e-02f, 4.97729853e-02f, 4.24995720e-02f, 3.10398676e-02f, -1.01112919e-02f, 5.33039793e-02f, 6.01088181e-02f,
  -5.32660969e-02f, -3.77558917e-02f, -9.09190997e-02f, 4.83983662e-03f, -4.73370850e-02f, -1.61623061e-02f, -4.51842286e-02f, -9.02643129e-02f, 2.57617105e-02f, -6.66329265e-02f,
  -2.75654811e-02f, -7.19828978e-02f, -1.15439326e-01f, -3.03062815e-02f, -7.21562505e-02f, -3.38617563e-02f, 2.60562170e-02f, 7.47856684e-03f, -1.63474884e-02f, -1.42961100e-01f,
  6.04683086e-02f, -1.70067608e-01f, -1.14856087e-01f, -1.70736670e-01f, -9.29212645e-02f, -1.95450544e-01f, -1.52352706e-01f, -1.39165699e-01f, -2.52443906e-02f, -8.51032585e-02f,
  9.90114659e-02f, 1.29873425e-01f, 1.36008739e-01f, 4.64444719e-02f, 1.01408437e-01f, -1.44805759e-01f, -2.04252005e-01f, 3.05466689e-02f, 6.63787797e-02f, -6.01265542e-02f,
  -1.60857424e-01f, 3.00170621e-03f, -6.58849850e-02f, -2.87810173e-02f, -9.69456583e-02f, 1.36197926e-02f, -1.15251221e-01f, -7.07282051e-02f, 3.19211446e-02f, -3.46712694e-02f,
  2.30373546e-01f, 1.14499908e-02f, 1.32748395e-01f, -4.85512707e-03f, -5.83532304e-02f, 3.43950093e-02f, -3.62511426e-02f, -4.26181406e-02f, 1.52142020e-02f, 3.68696861e-02f,
  -3.79352495e-02f, 5.95868938e-02f, -4.20837291e-02f, 5.94926924e-02f, -7.11505041e-02f, 2.96805482e-02f, -1.27217695e-01f, -3.15709189e-02f, -5.21985814e-02f, -7.82607049e-02f,
  -1.32299542e-01f, -1.27966374e-01f, 8.61898065e-02f, 3.40127051e-02f, -9.63314064e-03f, 1.01422422e-01f, 1.47681050e-02f, -5.99763617e-02f, -8.14878047e-02f, -1.59001678e-01f,
  -1.00478470e-01f, 3.33719887e-03f, -6.51956126e-02f, 5.42172790e-02f, 1.45003889e-02f, 7.78257474e-02f, -8.22286382e-02f, 7.21000284e-02f, -2.12764069e-02f, 2.48112809e-02f,
  3.23063657e-02f, -7.52649233e-02f, 4.64796238e-02f, 4.92050126e-02f, 7.11878911e-02f, 6.11897595e-02f, 7.03969412e-03f, 1.59215312e-02f, 6.70711249e-02f, 6.69913590e-02f,
  -3.95212583e-02f, 2.28982233e-02f, 2.50382684e-02f, -3.78784537e-03f, -6.94577768e-03f, -6.85396492e-02f, -5.04915528e-02f, -6.10429756e-02f, -1.94345377e-02f, -5.95953614e-02f,
  6.74224198e-02f, 1.40452646e-02f, 1.18969411e-01f, 1.30452394e-01f, -1.77906435e-02f, -4.94915023e-02f, 2.55893636e-02f, 1.24218240e-02f, 2.19527707e-02f, 3.62314284e-02f,
  6.42117206e-03f, -2.02500597e-02f, 1.63342129e-03f, -5.95025346e-02f, -3.99394855e-02f, -1.05775064e-02f, 5.95459016e-03f, 3.32708731e-02f, -3.53536308e-02f, -6.65077195e-02f,
  -1.43931895e-01f, 4.76743188e-03f, 1.52167067e-01f, 3.02243680e-02f, -9.01847631e-02f, 1.70010671e-01f, 1.05237132e-02f, 5.19034900e-02f, 1.52730301e-01f, -9.20435637e-02f,
  2.36162953e-02f, -2.04110727e-01f, -3.48709464e-01f, -1.33969516e-01f, -1.28176585e-01f, 7.27049448e-03f, -5.37552871e-02f, 9.22105536e-02f, 3.26314010e-02f, -1.41882166e-01f,
  -6.28757477e-03f, 9.50125754e-02f, -1.39103066e-02f, 2.26972941e-02f, 2.69009639e-02f, -1.77720621e-01f, -8.52754936e-02f, -1.31763175e-01f, 1.16674073e-01f, 4.78643253e-02f,
  -3.00172362e-02f, -3.17444578e-02f, -4.56381291e-02f, -9.23707858e-02f, -2.04082400e-01f, -3.75675485e-02f, -1.90946266e-01f, -1.97801143e-01f, -2.74576358e-02f, -1.66258320e-01f,
  -1.93687171e-01f, -9.52128246e-02f, 1.20859422e-01f, 6.85911626e-03f, 5.21569978e-03f, 3.42843905e-02f, 4.95748632e-02f, -4.57496243e-03f, 3.01552676e-02f, -5.26063703e-02f,
  3.35134864e-02f, 7.61492252e-02f, -9.86143500e-02f, 3.94623131e-02f, -7.97468200e-02f, 1.10260494e-01f, -9.76953655e-02f, -8.29676092e-02f, -2.20441911e-02f, 2.39500701e-02f,
  -1.79964351e-03f, -2.88361423e-02f, 3.16171534e-02f, 3.11863162e-02f, -5.02768680e-02f, 7.48405159e-02f, -9.98864919e-02f, -4.36867401e-02f, 4.01196927e-02f, -6.42798766e-02f,
  5.75520098e-02f, -7.51239881e-02f, 4.57602963e-02f, -2.26325709e-02f, 9.99878533e-03f, -9.69641283e-03f, -1.03806995e-01f, -5.59173897e-02f, 7.57561624e-02f, -2.95408648e-02f,
  -6.38521984e-02f, 5.24267107e-02f, 2.09391713e-02f, 3.60923298e-02f, -3.57561745e-02f, 2.25879997e-02f, 7.92228580e-02f, -5.71535081e-02f, 6.39477670e-02f, 2.62467302e-02f,
  1.12632392e-02f, 4.55402695e-02f, 1.92742981e-02f, 6.02030754e-02f, 6.38326211e-03f, 3.46975476e-02f, 6.19407184e-02f, -3.04477103e-02f, 2.39714831e-02f, -6.06361628e-02f,
  -9.90461633e-02f, 5.25999404e-02f, 1.76035631e-02f, 2.93871183e-02f, -2.24420633e-02f, -5.68168163e-02f, -1.01896755e-01f, 4.38173360e-04f, -1.11125410e-02f, -8.50775465e-02f,
  5.43646924e-02f, 2.05938220e-02f, -9.14046019e-02f, -1.92540828e-02f, 1.18906885e-01f, 2.72461139e-02f, -8.70404169e-02f, -7.15874135e-02f, 7.08275065e-02f, -6.34193514e-03f,
  -2.55663767e-02f, -3.63337696e-02f, 5.76400273e-02f, 5.97513355e-02f, 5.92677258e-02f, 6.18302152e-02f, -3.31621617e-02f, 5.61324395e-02f, -5.15893241e-03f, -4.13622484e-02f,
  4.95726228e-01f, -7.61205284e-03f, 8.87561440e-02f, -2.03016624e-02f, -3.63510177e-02f, -2.22995412e-02f, -1.10245802e-01f, 1.20517284e-01f, 5.51007465e-02f, -5.34435399e-02f,
  -8.72152299e-02f, -6.06534332e-02f, 6.39365017e-02f, 4.81077582e-02f, 1.27390489e-01f, 8.40565264e-02f, 9.98845417e-03f, 2.20895872e-01f, 1.67651162e-01f, 4.08677272e-02f,
  -1.07884474e-01f, 9.06263664e-02f, 1.44233897e-01f, -5.00906259e-03f, 2.83032469e-02f, -2.69383099e-02f, 5.90250045e-02f, -5.00203446e-02f, -6.02920912e-02f, -7.83543848e-03f,
  1.71090867e-02f, 2.17861637e-01f, -3.56169604e-02f, -6.75749257e-02f, -1.50841549e-01f, 8.84397924e-02f, 9.50676352e-02f, 6.84191585e-02f, -3.49592902e-02f, -5.97764999e-02f,
  -6.90334663e-02f, -2.52945088e-02f, -1.03857823e-01f, -1.03101812e-01f, 3.40967663e-02f, 3.47927655e-03f, 5.20858653e-02f, 1.52839825e-01f, -3.73657383e-02f, 4.70742397e-02f,
  -1.66782647e-01f, -6.07559755e-02f, 6.74936548e-02f, -3.07328310e-02f, 6.70623481e-02f, 1.10031188e-01f, -7.98200294e-02f, -6.55977521e-03f, -1.55247105e-02f, -1.03487109e-03f,
  -5.96588328e-02f, 8.65245331e-03f, 4.07690592e-02f, 1.03748143e-01f, 7.81384408e-02f, -4.86373492e-02f, 9.23534781e-02f, 4.79411595e-02f, 4.80125546e-02f, -9.70655233e-02f,
  -5.06136343e-02f, 6.93637058e-02f, -3.31273451e-02f, 8.37749988e-02f, -9.02442709e-02f, 3.86956185e-02f, -3.87844592e-02f, -7.67746791e-02f, 2.94639217e-03f, 7.94921592e-02f,
  1.06665917e-01f, 7.66884536e-02f, -5.90674542e-02f, -1.16664413e-02f, -2.93870308e-02f, -7.83769414e-03f, 7.23310187e-02f, 3.86220263e-03f, -5.56583405e-02f, -1.62749030e-02f,
  -1.48288801e-01f, 2.25577932e-02f, 1.87790133e-02f, 1.02874391e-01f, -1.03474915e-01f, -1.11956753e-01f, -8.30625147e-02f, -4.14147936e-02f, 6.22586301e-03f, -7.63818249e-03f,
  -1.11718416e-01f, -5.10712527e-02f, 1.86710842e-02f, -6.30745217e-02f, 1.21997092e-02f, -3.29641551e-02f, 1.28259156e-02f, -2.77399998e-02f, 6.78054988e-02f, -1.07602417e-01f,
  -1.48931548e-01f, 8.74657407e-02f, 3.92138474e-02f, 6.85191005e-02f, -4.66012582e-02f, 7.91239440e-02f, 8.19342490e-03f, -6.20445125e-02f, 2.31829821e-03f, 1.58122610e-02f,
  -3.10522884e-01f, 7.40218535e-02f, 1.82197571e-01f, -3.65438685e-02f, 1.49940670e-01f, 2.02785030e-01f, 2.02361554e-01f, -1.55410320e-02f, 4.70362529e-02f, -7.22682029e-02f,
  -1.07696518e-01f, -7.22846538e-02f, -5.97617067e-02f, -9.85032022e-02f, 5.92757761e-02f, 1.22589268e-01f, 8.65864903e-02f, 7.83812478e-02f, 5.61041087e-02f, 8.48517865e-02f,
  5.37710115e-02f, -8.77169818e-02f, -9.43437591e-02f, 3.39886453e-03f, 7.00277016e-02f, -2.50356440e-02f, 4.80085835e-02f, -8.13552737e-03f, -5.80313206e-02f, -3.66801247e-02f,
  -1.42122999e-01f, -1.91652477e-01f, -6.08069003e-02f, -9.29162130e-02f, 6.58713728e-02f, -1.11556821e-01f, -6.15880229e-02f, 6.38963468e-03f, -2.80197635e-02f, 6.53563961e-02f,
  2.45769061e-02f, -7.03158751e-02f, 2.20648013e-02f, -1.52759133e-02f, -4.44797352e-02f, -2.33486127e-02f, -6.88357465e-03f, -4.70190048e-02f, -1.06572889e-01f, -4.71105613e-03f,
  -4.98280525e-02f, 7.52551705e-02f, -2.83057708e-02f, -2.76395828e-02f, -5.63109573e-03f, -7.01331347e-02f, 1.40781328e-02f, -8.64610914e-03f, -6.45555407e-02f, -1.46334112e-01f,
  -2.85878778e-02f, 3.77413817e-02f, -7.49374554e-02f, -6.90760091e-02f, -4.87136096e-02f, 3.83543670e-02f, 2.09724274e-03f, -3.38602322e-03f, -4.67902943e-02f, 7.25723198e-03f,
  -2.20234543e-02f, -8.57305601e-02f, 5.89229390e-02f, 4.37986180e-02f, 6.62862360e-02f, -3.03259809e-02f, 7.11220503e-02f, 2.57947873e-02f, 2.92971265e-02f, 4.52713929e-02f,
  -1.52178006e-02f, 2.26594992e-02f, 3.72299552e-02f, 9.08463672e-02f, 2.77065989e-02f, 9.92237125e-03f, 7.73130581e-02f, 3.90451634e-03f, -8.27403367e-02f, -1.31178470e-02f,
  -6.22005016e-02f, 6.92779571e-02f, 1.00911548e-02f, -1.19259253e-01f, -6.51222244e-02f, -6.03244044e-02f, -7.41708055e-02f, -1.21275662e-02f, 6.82821721e-02f, -1.03056587e-01f,
  4.16741818e-02f, -1.03017323e-01f, -1.01903558e-01f, -5.82446605e-02f, 6.80785179e-02f, 1.50807137e-02f, -7.13767484e-02f, 4.41747047e-02f, -5.93280420e-02f, -4.37919013e-02f,
  -1.07830791e-02f, -4.35500629e-02f, 3.82561460e-02f, 3.29960175e-02f, 2.13507786e-02f, -6.72455058e-02f, -9.30311307e-02f, -3.54626551e-02f, -4.76226769e-02f, 3.12219877e-02f,
  -1.58109531e-01f, 5.95981181e-02f, -8.72895569e-02f, 1.28913000e-02f, 7.86129236e-02f, 7.30315074e-02f, -1.28830537e-01f, -1.00830130e-01f, -1.81165412e-02f, 9.04933587e-02f,
  8.61240253e-02f, 9.62629244e-02f, 3.08146589e-02f, -8.62569213e-02f, -1.44691199e-01f, 3.14777158e-02f, 4.52638566e-02f, -2.97351517e-02f, -1.46384805e-01f, -9.92128700e-02f,
  -1.66432057e-02f, 6.54227883e-02f, -1.47117987e-01f, -9.12254676e-02f, 4.70577292e-02f, 9.05098990e-02f, 1.25811309e-01f, 6.60022870e-02f, 5.74125014e-02f, 1.72766987e-02f,
  9.25897956e-02f, -7.04871938e-02f, -8.35986659e-02f, 4.57623228e-02f, -5.80914766e-02f, -7.98377693e-02f, 5.54380268e-02f, 4.56268899e-02f, 3.21240537e-03f, -3.82193252e-02f,
  -3.47717628e-02f, -5.60996048e-02f, 7.57285208e-02f, -1.43344107e-03f, -9.08017084e-02f, -9.21409652e-02f, -1.12549119e-01f, -1.55947164e-01f, -1.92833189e-02f, 5.21061122e-02f,
  -3.18895169e-02f, 7.47016519e-02f, -1.20657265e-01f, -8.48237798e-02f, -6.69321641e-02f, 7.15747923e-02f, 2.46642027e-02f, -3.24095711e-02f, -9.17412490e-02f, 7.01658502e-02f,
  7.92252645e-02f, -8.37433562e-02f, -5.84367774e-02f, -2.88028456e-02f, 4.01537381e-02f, -7.26203471e-02f, 3.74830849e-02f, -3.89702469e-02f, -5.56126563e-03f, -5.38026504e-02f,
  -1.19480267e-01f, -7.30808750e-02f, 5.17048500e-02f, -8.89703110e-02f, 1.73092987e-02f, -6.85926974e-02f, 8.25264584e-03f, 2.30773948e-02f, -1.81745049e-02f, 2.41609607e-02f,
  -4.12605330e-02f, 1.68287735e-02f, 3.95203605e-02f, -8.89467373e-02f, 7.15494603e-02f, 8.08907077e-02f, 1.85527727e-02f, -6.46168739e-02f, -8.04797933e-03f, 6.15988187e-02f,
  2.08621696e-02f, -6.70965575e-03f, 4.81588542e-02f, 4.67839316e-02f, 2.56923046e-02f, -1.12863109e-02f, -6.28781924e-03f, 1.92936864e-02f, -1.00953929e-01f, -7.66774118e-02f,
  -3.48974243e-02f, 3.41394357e-02f, -3.82759683e-02f, 1.03951069e-02f, -9.90069658e-02f, -4.03057560e-02f, -4.68927175e-02f, 2.42406428e-02f, -3.88473384e-02f, -5.19869439e-02f,
  -3.73633914e-02f, -8.74727406e-03f, -5.07501476e-02f, -6.00270666e-02f, 2.04838756e-02f, -7.41655529e-02f, -1.22739919e-01f, -2.66829003e-02f, 1.69849265e-02f, 1.68440328e-03f,
  2.69811094e-01f, 4.73045781e-02f, 1.40047267e-01f, 7.58326128e-02f, -3.55301127e-02f, -9.38858837e-02f, -1.07709587e-01f, -6.59757387e-03f, -9.52991694e-02f, -6.21208102e-02f,
  -2.15944961e-01f, -4.64757085e-02f, -1.34885922e-01f, 5.95867038e-02f, 3.47035676e-02f, 3.83726060e-02f, 7.87775293e-02f, 2.52013534e-01f, 2.17079148e-01f, -1.54267754e-02f,
  1.80716254e-02f, 6.00183532e-02f, 9.36392695e-02f, 1.37198240e-01f, 4.68946947e-03f, -7.52960443e-02f, 3.02062444e-02f, -9.30903479e-03f, 4.23321724e-02f, 1.35186538e-01f,
  8.96503627e-02f, 1.61736563e-01f, 4.34034988e-02f, -1.03214711e-01f, 1.56119643e-02f, 6.05455860e-02f, 4.39401343e-02f, 5.70892580e-02f, -1.82137229e-02f, 5.88498190e-02f,
  -4.63199131e-02f, 2.96720229e-02f, 4.44591083e-02f, 5.86275347e-02f, 9.90335923e-03f, 6.30925298e-02f, 1.29234884e-02f, 1.76147625e-01f, 2.28814613e-02f, 9.60689317e-03f,
  -1.37468904e-01f, -1.05033815e-01f, -7.12663531e-02f, -6.92771748e-02f, 4.65079844e-02f, -8.39458629e-02f, 2.39527486e-02f, -6.52760267e-03f, 5.92630282e-02f, -3.90502326e-02f,
  -4.55865003e-02f, -9.27489344e-03f, 7.38716051e-02f, -6.25010505e-02f, -8.57319012e-02f, 8.08558390e-02f, -2.76936758e-02f, -1.27131820e-01f, 4.09609154e-02f, 1.85954738e-02f,
  -1.44043879e-03f, 2.31698714e-02f, -6.55450299e-02f, -5.97940339e-03f, -9.62360501e-02f, 5.18730171e-02f, -1.14812199e-02f, -5.35618216e-02f, 2.96767130e-02f, -1.03816707e-02f,
  4.99266647e-02f, -2.80085597e-02f, -5.80241494e-02f, 2.41617411e-02f, -3.17548178e-02f, 1.05839726e-02f, -1.68148428e-02f, 2.77190749e-02f, -7.53634423e-02f, 3.77046987e-02f,
  -1.68233290e-01f, -1.30639806e-01f, -4.50611636e-02f, -2.09065210e-02f, 2.54362114e-02f, -2.87893116e-02f, -8.57998617e-03f, 4.22367603e-02f, -4.24071364e-02f, 9.76074934e-02f,
  1.59756895e-02f, -7.59834517e-03f, -3.70156765e-02f, -5.28781079e-02f, -4.65029804e-03f, -7.16408938e-02f, -4.68798764e-02f, -1.76781360e-02f, 6.36717603e-02f, -7.46268705e-02f,
  -1.15295313e-01f, 2.60697082e-02f, 5.56239113e-02f, -1.05848916e-01f, 5.86324558e-02f, 3.63235697e-02f, -4.25100103e-02f, 8.31013247e-02f, -6.03470430e-02f, 6.10642554e-03f,
  1.03307955e-01f, 1.91998295e-02f, 3.09855938e-02f, 1.16497971e-01f, 1.07670523e-01f, 1.54488578e-01f, 4.66968939e-02f, 5.70054241e-02f, -7.75794452e-03f, 4.23426069e-02f,
  5.89111373e-02f, 1.38544664e-02f, 2.08753683e-02f, 1.31501975e-02f, 1.64484493e-02f, -3.68448198e-02f, -1.21430382e-01f, -4.11209241e-02f, -1.38810473e-02f, 4.84116152e-02f,
  -2.18719281e-02f, 6.58109784e-02f, -2.13985834e-02f, 2.51945690e-04f, 8.61570388e-02f, 4.62957881e-02f, 6.16971180e-02f, 1.20005943e-01f, 1.10016435e-01f, 6.61623105e-02f,
  6.00958131e-02f, 1.65506065e-01f, -4.26823273e-02f, 6.11270703e-02f, 2.49735098e-02f, -7.88962990e-02f, -1.53837148e-02f, -9.82287228e-02f, -1.54181318e-02f, -4.13133688e-02f,
  9.19565558e-02f, 4.57072444e-02f, 3.31212804e-02f, -9.89866853e-02f, -3.03202868e-02f, 2.56321710e-02f, -9.48773772e-02f, -1.18539155e-01f, -3.01114786e-02f, -5.22125065e-02f,
  8.19471329e-02f, 5.38136251e-02f, 7.20775649e-02f, -4.66662645e-02f, -9.17251855e-02f, 6.60397403e-04f, 2.71004755e-02f, -1.20127387e-02f, -4.82387543e-02f, -1.19868420e-01f,
  3.06031592e-02f, 1.03096209e-01f, -2.99634561e-02f, -7.39829913e-02f, 8.52975547e-02f, -3.30253169e-02f, -3.01244352e-02f, 8.55260938e-02f, 5.52028492e-02f, 2.35507321e-02f,
  2.75816750e-02f, 4.71751988e-02f, 8.04415345e-02f, -2.64864936e-02f, -2.78547667e-02f, 1.04747422e-01f, 4.13138457e-02f, -7.81719610e-02f, 9.75539982e-02f, -9.74457562e-02f,
  4.64576716e-03f, 8.51810837e-05f, 4.81222235e-02f, -1.09983243e-01f, 8.02775398e-02f, -6.05441965e-02f, -5.67867197e-02f, 9.66256559e-02f, -1.08249336e-02f, 7.25343153e-02f,
  -8.24968964e-02f, -3.36166122e-03f, 5.90948537e-02f, -9.51150954e-02f, 1.07820176e-01f, -1.07485004e-01f, 4.88491803e-02f, -4.58539240e-02f, 7.36762732e-02f, 1.74614764e-03f,
  9.07368362e-02f, 6.00667670e-02f, 1.11991949e-02f, -4.81442846e-02f, -5.37790321e-02f, 1.92171875e-02f, 5.97036369e-02f, -6.35492727e-02f, -7.28651732e-02f, -3.50217298e-02f,
  -1.15229018e-01f, -3.86144519e-02f, 8.50060508e-02f, -1.38696000e-01f, 4.39039506e-02f, 3.92426737e-02f, 6.77076727e-02f, -8.72211307e-02f, -8.00606888e-03f, -1.89705025e-02f,
  2.56215520e-02f, 1.32432327e-01f, 3.29414047e-02f, 4.68422025e-02f, 8.82679597e-02f, -6.48357868e-02f, -2.28031762e-02f, 4.40876707e-02f, -3.76269780e-02f, -1.09029533e-02f,
  4.27448675e-02f, 1.02945328e-01f, -2.19100043e-02f, 1.04985900e-01f, -4.55967523e-03f, 4.49064299e-02f, -4.77427281e-02f, -5.38837798e-02f, 4.38696332e-02f, 5.00884764e-02f,
  2.17936859e-02f, 9.94565040e-02f, -2.42502782e-02f, 5.90092205e-02f, -1.33805722e-02f, -6.09202348e-02f, 2.06124019e-02f, -3.43495235e-02f, 4.69833352e-02f, 5.04961684e-02f,
  3.24172564e-02f, 9.25380513e-02f, -9.83063411e-03f, -7.36365095e-02f, -4.85625155e-02f, -3.86823118e-02f, 3.03647239e-02f, -4.89290245e-02f, -3.67377028e-02f, -4.95934747e-02f,
  1.00635536e-01f, 7.16241524e-02f, 2.99891196e-02f, 3.17660607e-02f, -6.08976372e-02f, -5.76076731e-02f, 2.42479593e-02f, -1.10186763e-01f, 5.44689521e-02f, 5.78925908e-02f,
  -1.99505035e-02f, -6.48419112e-02f, 3.63626145e-02f, 3.45628262e-02f, -2.77646016e-02f, -3.16338316e-02f, 8.89217183e-02f, 2.69601885e-02f, 4.47205976e-02f, -2.26425063e-02f,
  1.62000339e-02f, 6.96603674e-04f, -2.56867558e-02f, -5.96037274e-03f, 3.51850241e-02f, 1.09016933e-02f, -6.01907186e-02f, -2.68846974e-02f, -6.89146295e-02f, 2.60367449e-02f,
  5.72613208e-03f, -5.20871505e-02f, -1.25767831e-02f, 5.98258711e-03f, 2.10616104e-02f, 2.62086168e-02f, 2.52075493e-02f, -7.82429203e-02f, -8.43372419e-02f, -1.84608717e-02f,
  5.23853563e-02f, -6.63484856e-02f, -3.33946832e-02f, -8.77442881e-02f, 8.12506229e-02f, 4.74393554e-02f, 5.98884188e-02f, -1.67921185e-02f, 5.80649525e-02f, -5.95343933e-02f,
  1.04914457e-01f, 7.61230141e-02f, -7.13690072e-02f, 5.98403327e-02f, -5.60761131e-02f, -4.27298248e-02f, 8.00153613e-02f, -7.47011155e-02f, 9.70765017e-03f, 2.17343196e-02f,
  9.89624709e-02f, -6.09000120e-03f, 4.61488329e-02f, 5.77646643e-02f, -4.38374002e-03f, -4.98056598e-02f, -7.09965266e-03f, 4.72144261e-02f, -3.87091227e-02f, 2.21507140e-02f,
  3.92061248e-02f, 1.80304330e-02f, -2.59338915e-02f, -1.07589990e-01f, -8.59432574e-03f, -4.07207534e-02f, -6.00174852e-02f, -6.23355480e-03f, 8.07254240e-02f, -8.09176341e-02f,
  1.86621577e-01f, -3.92395556e-01f, -2.26747587e-01f, -1.76880330e-01f, -4.11013551e-02f, 7.25661442e-02f, -1.24699451e-01f, -2.27197018e-02f, -3.24152112e-02f, -1.82618767e-01f,
  -1.26442224e-01f, 2.40241438e-02f, 4.08892334e-03f, 7.87395984e-03f, 4.20997888e-02f, -8.81521776e-02f, -1.65334925e-01f, -3.42045426e-02f, 2.76485831e-01f, 1.60931602e-01f,
  -3.85154970e-02f, -2.83823796e-02f, 3.08061428e-02f, -9.67588276e-03f, -2.35995233e-01f, -5.47452755e-02f, -1.53818473e-01f, -1.90769956e-01f, -8.72952938e-02f, -3.13749909e-01f,
  -2.37173542e-01f, -5.83280064e-02f, 6.33617565e-02f, 1.52535662e-01f, -1.36363029e-01f, 1.40810264e-02f, -4.48026992e-02f, 4.27944846e-02f, 9.65755209e-02f, -1.84729546e-02f,
  -5.70236519e-02f, 4.33139838e-02f, 9.11815371e-03f, 9.96237993e-03f, 5.27388193e-02f, -8.87054950e-03f, -3.49865779e-02f, -7.47480849e-03f, -2.41595116e-02f, -1.49060534e-02f,
  -3.07513736e-02f, 1.26039878e-01f, 1.27944931e-01f, 1.42727261e-02f, -6.39730040e-03f, 1.03088148e-01f, -4.40338627e-02f, -1.94119904e-02f, 1.07282400e-01f, -7.07624182e-02f,
  -7.95304962e-03f, -9.81802195e-02f, -1.24860369e-02f, -3.08430730e-03f, -2.42642425e-02f, 1.27593009e-03f, 5.00587299e-02f, -2.85641700e-02f, 5.82321249e-02f, -8.60869437e-02f,
  -5.63120395e-02f, 1.92151740e-02f, 2.47405507e-02f, -1.06588043e-01f, 2.43457854e-02f, 3.74093018e-02f, -2.68739164e-02f, -9.49043036e-02f, 7.73105174e-02f, -3.90036665e-02f,
  4.09196280e-02f, 5.13290651e-02f, -2.80615110e-02f, 7.98733998e-03f, 5.19014103e-03f, -3.84444408e-02f, 5.30649573e-02f, 1.07292728e-02f, 4.73774184e-04f, 6.21653385e-02f,
  -6.59055039e-02f, 2.12923244e-01f, -6.42557591e-02f, 1.41017318e-01f, -1.12865128e-01f, -2.74620783e-02f, 1.83582690e-03f, 2.63397489e-02f, -2.33610757e-02f, -5.06076179e-02f,
  2.73625217e-02f, 9.21488404e-02f, 3.53022828e-03f, 5.45012914e-02f, 5.36123551e-02f, 4.30213846e-02f, 1.04532680e-02f, 9.47245732e-02f, 2.91374605e-02f, -9.78156999e-02f,
  -9.74881425e-02f, 5.93506657e-02f, 1.77196473e-01f, 2.03207731e-02f, 7.08558783e-02f, 9.28308219e-02f, 5.27191572e-02f, -4.26653365e-04f, 2.06460625e-01f, -1.09375112e-01f,
  4.80080172e-02f, -8.55571479e-02f, 5.03302924e-02f, 9.03294683e-02f, -6.94577917e-02f, -4.34610993e-02f, -5.19507118e-02f, -2.74957009e-02f, 4.96742949e-02f, -5.16064800e-02f,
  1.57625929e-01f, 1.86685219e-01f, 5.60399964e-02f, 1.31032601e-01f, 3.56732756e-02f, 5.39932810e-02f, 2.46537328e-02f, 4.04193858e-03f, -2.04816386e-02f, -7.06830397e-02f,
  9.51770470e-02f, -5.87845258e-02f, 8.37916061e-02f, 7.69503787e-02f, 1.08963870e-01f, -1.68097988e-02f, -2.02525798e-02f, 2.50072367e-02f, -3.66315581e-02f, -8.27228837e-03f,
  -5.72502725e-02f, 1.20348185e-01f, 8.63641053e-02f, -1.15540009e-02f, 1.77816730e-02f, -1.66586209e-02f, -3.34511399e-02f, -4.33447435e-02f, 2.53762268e-02f, -3.09618115e-02f,
  1.23282216e-01f, 9.35247838e-02f, 3.05094700e-02f, -5.85370436e-02f, 5.85334189e-02f, 9.02204812e-02f, 1.25651419e-01f, -4.16592099e-02f, 4.81628925e-02f, 5.84652051e-02f,
  1.02015860e-01f, 1.11258671e-01f, 5.69376126e-02f, 7.52240345e-02f, 8.60740170e-02f, 2.67865844e-02f, -6.88789412e-03f, -3.38297375e-02f, -2.60872226e-02f, 6.04614466e-02f,
  -6.12505861e-02f, 2.39633378e-02f, 5.21379299e-02f, 6.12100512e-02f, 5.74829541e-02f, 8.21787044e-02f, 2.00251732e-02f, 3.23558003e-02f, -7.93654472e-02f, -5.38824201e-02f,
  -5.90152219e-02f, 4.46649678e-02f, 3.55123207e-02f, -8.53022784e-02f, 3.63919958e-02f, 4.61580642e-02f, -1.58698484e-02f, 3.59713174e-02f, -1.25865564e-02f, -3.37554663e-02f,
  7.76494369e-02f, 7.57742003e-02f, 7.50225633e-02f, 1.17004719e-02f, -4.85924855e-02f, 8.70848745e-02f, -5.47654778e-02f, -1.18315518e-02f, -7.23336637e-02f, -3.65359373e-02f,
  1.20579712e-02f, 3.27515900e-02f, 4.52635996e-02f, 1.19814411e-01f, -5.12258895e-02f, 5.56480885e-02f, 9.34458151e-02f, 4.72174175e-02f, 2.64628753e-02f, 1.35431830e-02f,
  7.92808011e-02f, 1.98909808e-02f, -2.29665805e-02f, -2.11522076e-02f, -5.64879812e-02f, 7.24390969e-02f, -2.08750484e-03f, -3.80776823e-02f, -3.47271636e-02f, 6.99110329e-02f,
  -6.05573505e-02f, -9.82275307e-02f, -2.81585734e-02f, -2.91800834e-02f, -1.85319292e-03f, -1.42327892e-02f, 2.61227116e-02f, 4.31887098e-02f, -1.97486486e-02f, 6.89361291e-03f,
  1.09447181e-01f, -5.79859354e-02f, 3.49378698e-02f, -1.10845119e-02f, 6.59937710e-02f, 6.76223934e-02f, 5.43694012e-02f, -3.04029267e-02f, -1.91168245e-02f, 1.16369024e-01f,
  8.25901777e-02f, 1.22884316e-02f, 3.83889191e-02f, -7.47577697e-02f, -8.09932202e-02f, 6.85216188e-02f, 1.27036450e-02f, -1.06650911e-01f, -3.62481400e-02f, 6.99926913e-02f,
  -2.13326998e-02f, 4.91838679e-02f, 7.46058375e-02f, 4.10097577e-02f, 6.97051883e-02f, 3.20230946e-02f, -2.69620083e-02f, 7.99949765e-02f, -3.63624170e-02f, 2.98388973e-02f,
  -4.62602898e-02f, 1.03565138e-02f, -4.14703786e-02f, 1.00705214e-02f, 3.67505625e-02f, 8.59179255e-03f, -7.61769563e-02f, -4.57830215e-03f, 8.31596851e-02f, -9.95926559e-03f,
  2.51667574e-02f, -5.79715371e-02f, 1.46237165e-02f, -2.74616238e-02f, 8.83305352e-03f, 8.54883716e-02f, -3.34103517e-02f, -6.00676127e-02f, -8.93589780e-02f, 3.84347029e-02f,
  3.70943472e-02f, 2.60184631e-02f, 5.73400001e-04f, 4.66834232e-02f, -8.10894892e-02f, -3.40538882e-02f, 4.28608656e-02f, -5.59659488e-02f, -3.84398587e-02f, 3.22915651e-02f,
  -1.29822278e-02f, 2.15016920e-02f, -3.44917849e-02f, 7.95045570e-02f, 1.45065030e-02f, -4.06677052e-02f, 2.39240844e-02f, -6.78763539e-03f, -3.43265198e-02f, -3.32154557e-02f,
  2.62998361e-02f, 1.69258397e-02f, -5.53952204e-03f, -7.96999335e-02f, 2.34005675e-02f, 7.69198015e-02f, 6.23892359e-02f, -3.22486162e-02f, -3.23466281e-03f, -4.00314629e-02f,
  4.66659945e-03f, -2.26807240e-02f, 6.68438002e-02f, 4.76568379e-02f, -3.61414067e-02f, 1.14293676e-02f, -1.06192974e-03f, 3.90641205e-02f, 7.82047808e-02f, -6.58178702e-02f,
  -9.78410989e-02f, -2.98146512e-02f, 3.99561739e-03f, -6.00333884e-02f, 4.75845039e-02f, -4.98646908e-02f, -8.55852365e-02f, -4.21612002e-02f, 8.67613405e-02f, 4.47187126e-02f,
  -2.95529910e-03f, 5.45521639e-02f, -5.57979196e-02f, -7.18674883e-02f, 3.54444385e-02f, 3.04924101e-02f, -5.94793521e-02f, -6.39905259e-02f, -2.82761138e-02f, 7.66557902e-02f,
  -3.26554514e-02f, 5.99437244e-02f, -4.74980101e-02f, 4.82230261e-03f, 6.37788251e-02f, -6.84898943e-02f, 5.69647364e-02f, 3.14163826e-02f, 1.01348840e-01f, 9.66699943e-02f,
  1.94864497e-01f, -4.71595563e-02f, 8.27410594e-02f, -7.21086422e-03f, 1.96923688e-02f, -3.28358486e-02f, -1.57702751e-02f, 8.12308937e-02f, -4.26280163e-02f, 9.19984505e-02f,
  8.76487046e-02f, 3.64985839e-02f, 3.97339612e-02f, 7.82981329e-03f, 6.94804043e-02f, -2.04320271e-02f, 3.23837698e-02f, 3.89386863e-02f, 3.76609042e-02f, 8.39543715e-02f,
  1.17830038e-02f, 8.99840519e-03f, 1.03163682e-01f, 2.41160188e-02f, -5.62126786e-02f, -2.26366036e-02f, -1.25458045e-02f, 4.13213298e-02f, 1.92655753e-02f, 2.45725475e-02f,
  -3.34616266e-02f, 5.98595589e-02f, -5.62007912e-02f, 4.21091914e-02f, 1.09236874e-02f, -3.08376979e-02f, 9.13713202e-02f, 3.37922685e-02f, -6.36150967e-03f, -5.07735275e-02f,
  -7.90177807e-02f, 1.61806885e-02f, -8.08753148e-02f, -5.04503511e-02f, 1.20665310e-02f, 9.86605138e-03f, -1.72510725e-02f, -3.48115824e-02f, 3.34663428e-02f, 4.51582447e-02f,
  2.11130176e-02f, -8.13572556e-02f, -1.07316934e-02f, -8.54583755e-02f, 1.36075793e-02f, 3.82463122e-03f, -4.39703129e-02f, 3.90219092e-02f, -8.28271359e-02f, 8.20950642e-02f,
  5.33303358e-02f, 8.59311372e-02f, -8.14221352e-02f, -2.07958538e-02f, 4.69155759e-02f, 2.45428681e-02f, -3.07704341e-02f, -3.34105045e-02f, 8.59253705e-02f, 7.57912770e-02f,
  7.41787208e-03f, -1.90932173e-02f, -3.36589850e-02f, 2.06228942e-02f, 4.31814119e-02f, -9.27157924e-02f, -3.27133946e-03f, 1.73081663e-02f, -5.04091308e-02f, -7.43413949e-03f,
  -3.14488374e-02f, 1.22860484e-02f, -2.37383909e-04f, 2.02668402e-02f, -1.40059562e-02f, 4.63339910e-02f, 5.08212075e-02f, -2.95341071e-02f, -1.49237120e-03f, -6.05192930e-02f,
  -7.47641772e-02f, -1.33840263e-01f, 9.90552679e-02f, -4.02129367e-02f, 4.54929797e-03f, 2.87642423e-02f, -6.54233545e-02f, 1.04200072e-03f, -7.16200471e-02f, 6.02350272e-02f,
  1.55862067e-02f, 8.97394586e-03f, 7.41863698e-02f, -4.06414829e-02f, -8.38856623e-02f, -1.23307714e-02f, -4.65300605e-02f, -3.79705839e-02f, -3.48831788e-02f, -6.72513396e-02f,
  4.26481552e-02f, 5.89138903e-02f, 8.80311355e-02f, -5.89899048e-02f, -4.08523269e-02f, 6.56023547e-02f, -3.26909833e-02f, 2.34496314e-02f, 3.91174480e-02f, -3.11699267e-02f,
  1.38540655e-01f, 2.19194293e-02f, -3.32584232e-02f, 1.15539789e-01f, -1.11241922e-01f, -1.96600944e-01f, -2.30145063e-02f, -1.20502152e-01f, -3.19569558e-03f, -5.22432402e-02f,
  -9.97153521e-02f, 2.12161317e-02f, 8.10966566e-02f, 2.32994985e-02f, -6.00759611e-02f, -2.00840272e-02f, -6.70928359e-02f, -2.93039251e-02f, -1.44014686e-01f, -1.35245144e-01f,
  9.31614079e-03f, 3.16788480e-02f, 6.86879316e-03f, -7.41546080e-02f, -8.32450762e-02f, -6.18502358e-03f, -1.05924949e-01f, -1.95164257e-03f, -1.10503875e-01f, -2.75050979e-02f,
  -9.46311727e-02f, 8.29949751e-02f, 5.02765886e-02f, 7.31293038e-02f, 1.23688672e-02f, -4.49573696e-02f, 2.55024638e-02f, -4.30392064e-02f, 1.14255086e-01f, 1.57093145e-02f,
  -7.44799664e-03f, 7.46710896e-02f, -7.56669715e-02f, -1.98328011e-02f, -1.33369723e-02f, -6.58196583e-02f, 2.52224449e-02f, 1.37326661e-02f, 5.38083352e-02f, 1.08309612e-02f,
  -4.14451621e-02f, -1.99277457e-02f, -5.52261285e-02f, -5.97495511e-02f, -9.68004763e-02f, -4.54297625e-02f, 4.94974246e-03f, 5.32150790e-02f, 7.34441029e-03f, 1.18747525e-01f,
  -8.95091146e-02f, -7.10874051e-02f, -4.99338284e-02f, -4.38354798e-02f, 3.39284800e-02f, 7.86086321e-02f, -8.26922730e-02f, -4.54424843e-02f, -7.58731812e-02f, 3.86081412e-02f,
  -2.89874077e-02f, 4.84613106e-02f, -5.45247085e-02f, 3.43446918e-02f, 7.35814264e-03f, -8.83289333e-03f, 6.55921735e-03f, -2.88962163e-02f, -4.60429750e-02f, 6.20135851e-02f,
  3.74398753e-02f, -4.35444787e-02f, 2.32483330e-03f, -6.53652623e-02f, -6.57532364e-02f, -7.41786063e-02f, 8.02254081e-02f, 2.05338113e-02f, -2.05810256e-02f, 1.77378058e-02f,
  -5.78339174e-02f, -1.22461200e-01f, 8.04180503e-02f, 4.72349934e-02f, -2.51158443e-03f, 8.15207809e-02f, -7.61551708e-02f, 4.76727039e-02f, 4.21614386e-02f, -1.71684437e-02f,
  1.16007486e-02f, -4.09223884e-02f, 1.82359237e-02f, 2.52038939e-03f, -8.49849731e-02f, -5.09859994e-02f, 7.04731867e-02f, -5.62674599e-03f, -2.91106813e-02f, -4.87780459e-02f,
  -8.11303109e-02f, 1.02224760e-01f, 6.74555674e-02f, 9.52002034e-02f, -7.82505795e-02f, 4.61963043e-02f, 6.19173311e-02f, -6.52976856e-02f, -6.14304654e-02f, 6.50997981e-02f,
  -3.33624855e-02f, -3.72498482e-03f, -8.43809992e-02f, 8.02196264e-02f, 8.35661963e-02f, 5.92788607e-02f, -5.52138947e-02f, -4.02257182e-02f, -8.83513689e-02f, 3.10484767e-02f,
  -1.02293887e-03f, 1.11495748e-01f, 2.09307410e-02f, -4.29519042e-02f, -2.08448872e-01f, -1.48887023e-01f, -1.57814652e-01f, -1.89550728e-01f, -5.07313162e-02f, 1.54748582e-03f,
  2.70482823e-02f, 3.57006043e-02f, -1.69582605e-01f, 3.09860092e-02f, 5.82304411e-02f, -7.57248327e-03f, 1.84891131e-02f, -5.30998595e-02f, 5.79221137e-02f, 2.87664030e-02f,
  1.26976341e-01f, -6.42262516e-04f, -2.73762103e-02f, 5.10331988e-02f, -1.53285908e-02f, -6.92369342e-02f, 9.47635323e-02f, -6.25443235e-02f, -5.14240889e-03f, 6.81478456e-02f,
  6.55654296e-02f, -5.94777539e-02f, -5.15955687e-02f, -5.92240505e-02f, -3.14286314e-02f, 2.97115427e-02f, -1.12897009e-01f, -9.45502147e-02f, -1.02497175e-01f, -5.83596528e-02f,
  4.72777560e-02f, -2.49292608e-02f, -1.17967501e-02f, -2.15020459e-02f, 4.92196791e-02f, -1.57942064e-02f, -2.97081713e-02f, -8.18673372e-02f, -1.95784327e-02f, -2.30019055e-02f,
  9.83127579e-03f, -2.38988418e-02f, 5.72072640e-02f, -3.18687893e-02f, 7.20416978e-02f, -4.47029583e-02f, 6.22200295e-02f, 7.12038353e-02f, 5.11389300e-02f, 7.74379745e-02f,
  -6.24131933e-02f, -4.50671054e-02f, -1.34086683e-02f, -6.61943629e-02f, 9.67671871e-02f, 5.82305156e-02f, -7.12604523e-02f, -4.09963280e-02f, -6.97291642e-02f, -7.66444504e-02f,
  -2.62648035e-02f, -2.74761952e-02f, 1.29405074e-02f, 7.71969035e-02f, 4.85174544e-02f, 4.14887294e-02f, -5.20558245e-02f, -2.22186912e-02f, -3.22312005e-02f, 5.90352416e-02f,
  9.02526602e-02f, -6.80207610e-02f, -7.27224424e-02f, -6.04338609e-02f, -1.80254392e-02f, -4.99191023e-02f, 6.03499748e-02f, 2.20302609e-03f, 7.75774047e-02f, 6.78066835e-02f,
  4.78442200e-02f, 8.48121010e-03f, 2.97240969e-02f, -6.95006102e-02f, -7.21711889e-02f, 3.71529907e-02f, -1.08003065e-01f, 6.28599972e-02f, -7.08677098e-02f, 7.11297542e-02f,
  -8.66188779e-02f, -1.34189785e-01f, -1.50654256e-01f, -6.74750358e-02f, -4.21798183e-03f, 5.62094599e-02f, -2.21728440e-02f, -7.38471448e-02f, -1.15467988e-01f, -1.18566193e-02f,
  2.17676461e-02f, 9.19827446e-03f, -5.66449501e-02f, 8.89591351e-02f, 8.80458765e-03f, -5.00056334e-02f, -5.17347129e-03f, 8.68622884e-02f, 8.31061155e-02f, -4.83830348e-02f,
  -3.62257212e-02f, -6.42412305e-02f, -6.63941801e-02f, -7.74640068e-02f, 4.46124300e-02f, 1.39246866e-01f, -1.38188927e-02f, 3.40826735e-02f, -4.75825183e-02f, 1.18619084e-01f,
  1.56954169e-01f, 5.82571467e-03f, 5.83239794e-02f, 1.17352948e-01f, -2.58068158e-03f, -4.14563529e-02f, 9.08282623e-02f, -6.06165342e-02f, -4.50512804e-02f, 1.65801942e-01f,
  2.45434642e-02f, -8.36749077e-02f, 6.49813786e-02f, 8.75912011e-02f, 2.87736561e-02f, 2.20103394e-02f, 3.19918394e-02f, 1.63568575e-02f, 1.35384640e-02f, 1.31146163e-01f,
  3.67930811e-03f, 6.13369159e-02f, -6.34292513e-02f, -1.50801605e-02f, -6.15561903e-02f, 4.00266203e-04f, -2.35682763e-02f, 5.80458716e-02f, 4.41763103e-02f, -2.08555739e-02f,
  7.54567906e-02f, -7.50952959e-02f, -2.06118431e-02f, -7.88678154e-02f, -7.08818585e-02f, -2.02787668e-02f, -9.12913829e-02f, -5.76960258e-02f, -1.81903709e-02f, 1.16198421e-01f,
  1.59345083e-02f, -3.60684134e-02f, -6.72560781e-02f, 2.16131844e-03f, 1.03982007e-02f, 8.37604553e-02f, -2.84959543e-02f, -1.16478037e-02f, 4.65139896e-02f, 7.15990290e-02f,
  -1.34953242e-02f, -2.42220126e-02f, -7.43693784e-02f, 1.20443180e-02f, -5.79945780e-02f, -5.07977642e-02f, -1.87394135e-02f, -3.13354768e-02f, -7.60398731e-02f, -6.92506135e-02f,
  7.39712939e-02f, -8.56895372e-02f, -8.37067235e-03f, -2.16003582e-02f, -3.11998092e-02f, -5.00683486e-02f, -4.16639857e-02f, -4.04939651e-02f, 2.53626611e-03f, 3.89107391e-02f,
  1.32688880e-01f, -1.35170028e-01f, 2.64962073e-02f, 2.50110272e-02f, -5.60399927e-02f, 5.17833829e-02f, -7.62862116e-02f, 7.41944760e-02f, 2.83229817e-02f, 1.29307061e-01f,
  8.36335942e-02f, 6.01295009e-02f, 8.46733153e-02f, -1.99779291e-02f, 7.19425082e-02f, -1.35071278e-02f, 3.35417292e-03f, -1.11251753e-02f, 8.69975761e-02f, -6.89590722e-03f,
  2.61674561e-02f, 7.00041279e-02f, 7.16422796e-02f, 8.71426612e-02f, 7.60203507e-03f, 4.56941798e-02f, -2.19442584e-02f, -4.60101962e-02f, -8.49371254e-02f, -4.27613221e-03f,
  1.64331794e-01f, 3.59265953e-01f, 2.24529013e-01f, 5.85131533e-02f, 9.65826511e-02f, 1.59435421e-01f, 3.15937102e-01f, 1.08343899e-01f, -6.70618415e-02f, 4.62431721e-02f,
  1.90231100e-01f, 3.14488858e-02f, 3.89830470e-02f, -8.90910849e-02f, -6.05257824e-02f, 6.18394949e-02f, -9.77152810e-02f, -1.39899835e-01f, -1.95975527e-01f, -1.12522244e-01f,
  -1.38982147e-01f, -6.02650046e-02f, -8.41452330e-02f, -9.86911133e-02f, -8.12173858e-02f, -9.79198739e-02f, 6.08516261e-02f, 1.52059540e-01f, 8.54398981e-02f, -1.93858087e-01f,
  1.31565973e-01f, 2.80244738e-01f, -1.34124547e-01f, -7.05934167e-02f, 8.57196897e-02f, 7.04618124e-03f, 1.34874051e-02f, -3.41188759e-02f, 3.40989269e-02f, -9.20237899e-02f,
  8.69284645e-02f, -8.52218568e-02f, 4.57844585e-02f, -3.61129194e-02f, 4.72893454e-02f, 1.78928096e-02f, 5.48302792e-02f, -7.22272396e-02f, 4.88673225e-02f, -8.73952210e-02f,
  1.03765223e-02f, 1.18927278e-01f, 8.21319371e-02f, 1.05914161e-01f, 1.42357992e-02f, -3.11279576e-02f, 9.99058709e-02f, -8.38005973e-04f, -6.86487556e-02f, 4.87137474e-02f,
  1.70336626e-02f, -7.67155364e-02f, -3.73460464e-02f, 1.60221960e-02f, -4.18729633e-02f, -7.84073472e-02f, 4.16741483e-02f, 5.78518696e-02f, 1.81299746e-02f, 8.78647193e-02f,
  -6.53088838e-02f, -1.41798398e-02f, -6.51506800e-03f, -6.15660772e-02f, -2.93879416e-02f, 3.69101837e-02f, 2.54486389e-02f, -6.16382957e-02f, 1.06576003e-01f, 4.51560095e-02f,
  -4.38664556e-02f, 1.83763821e-02f, 8.36714953e-02f, 6.42870218e-02f, 2.69865338e-02f, -3.92137617e-02f, -6.99907839e-02f, 6.65727854e-02f, 2.73923352e-02f, -3.39416862e-02f,
  8.54671758e-04f, -2.58922894e-02f, -1.48770168e-01f, -1.51121303e-01f, -4.58117947e-02f, -1.10045768e-01f, -4.87469137e-02f, 3.23426872e-02f, 7.06521273e-02f, 4.11646022e-03f,
  -3.27435881e-02f, 7.04146624e-02f, 7.29497150e-03f, -3.55890878e-02f, -9.11325142e-02f, 4.64475267e-02f, -8.36317241e-03f, 3.61466482e-02f, -5.40555194e-02f, -3.10773663e-02f,
  -1.76214054e-02f, -9.47333053e-02f, 2.08348781e-02f, -9.21472833e-02f, 3.51633411e-03f, -9.23908278e-02f, 1.02749653e-01f, 2.64586527e-02f, 8.48156363e-02f, -1.03098422e-01f,
  6.28378838e-02f, -2.90612876e-02f, -1.49936438e-01f, -7.65779242e-02f, -1.22101761e-01f, 4.08605905e-03f, -3.26263309e-02f, 4.19201702e-02f, 9.71426964e-02f, 3.81564014e-02f,
  6.63201660e-02f, -7.48254284e-02f, -9.75765139e-02f, 3.21122073e-02f, -5.12846233e-03f, 4.28670757e-02f, -1.69507600e-02f, -3.75015512e-02f, -1.45450220e-01f, -6.73937723e-02f,
  -4.22508456e-02f, -7.57632926e-02f, 1.21211577e-02f, 8.50403495e-03f, 9.49802175e-02f, -3.07531599e-02f, 7.05168620e-02f, -8.70936438e-02f, 4.29613423e-03f, 3.81882414e-02f,
  -3.87829393e-02f, -6.78543895e-02f, 3.64421308e-02f, 7.80571476e-02f, 1.68526303e-02f, 2.78197601e-02f, 1.67893968e-03f, -2.34299079e-02f, 1.95583645e-02f, 1.21436499e-01f,
  -2.39843000e-02f, -4.68225554e-02f, 8.20807964e-02f, -3.39001939e-02f, -1.95387192e-02f, 9.36861858e-02f, 1.24648698e-01f, -4.32761982e-02f, 7.98197389e-02f, 4.40495089e-03f,
  2.10698973e-02f, 5.51450066e-02f, -5.37026972e-02f, -7.79257864e-02f, -3.23013999e-02f, -9.69441533e-02f, 8.88469815e-02f, 3.15485895e-02f, 3.96907628e-02f, 6.51156977e-02f,
  -5.46328723e-02f, -8.75262171e-02f, -3.48540284e-02f, -3.17929499e-02f, 3.15019228e-02f, -5.66447452e-02f, -5.67413457e-02f, -9.57548767e-02f, -8.47170129e-02f, 8.14419910e-02f,
  -2.55201454e-03f, 2.16496037e-03f, 6.54199496e-02f, -6.83899298e-02f, -7.64472177e-04f, -7.01470450e-02f, -5.09230886e-03f, 5.78516200e-02f, -9.11368579e-02f, -6.59791604e-02f,
  -9.55400243e-02f, 5.09948470e-02f, 3.16323303e-02f, -2.38816477e-02f, 5.79203703e-02f, 6.37900233e-02f, 2.13732533e-02f, 5.81952371e-02f, -5.67860678e-02f, 1.93563700e-02f,
  -3.15171182e-02f, -1.42542124e-01f, 3.50018367e-02f, 1.67513546e-02f, 4.82367650e-02f, 7.61735067e-02f, -9.01296958e-02f, 2.02834327e-02f, 5.69146797e-02f, 5.85845374e-02f,
  3.19140144e-02f, -1.88808795e-02f, 7.56713822e-02f, 1.11025870e-01f, -1.07355826e-02f, 6.24454804e-02f, 4.83030491e-02f, -7.29048392e-03f, 1.44195072e-02f, -3.40014622e-02f,
  8.29667300e-02f, 8.43362138e-02f, -3.60611267e-02f, 7.56521821e-02f, -2.22783722e-02f, -8.54449198e-02f, 8.55665579e-02f, 9.62778926e-03f, -3.67781594e-02f, 1.07620090e-01f,
  -1.44894719e-01f, -1.91863209e-01f, -2.02075630e-01f, -2.00518042e-01f, -1.09021038e-01f, 9.45359915e-02f, 2.82686856e-02f, -5.04920557e-02f, -6.37750700e-03f, -1.80924490e-01f,
  1.76905170e-02f, 2.29793806e-02f, -3.01844580e-03f, 1.42063061e-03f, 8.46657008e-02f, -9.45276022e-02f, -1.55383319e-01f, -4.22869846e-02f, 1.44637823e-01f, 1.50896460e-01f,
  1.40488058e-01f, -9.11140740e-02f, 2.74974224e-03f, -7.11616501e-02f, -9.28229019e-02f, 5.67275425e-03f, -5.95460236e-02f, -9.56411511e-02f, -4.29586992e-02f, -1.64929897e-01f,
  -1.22238100e-01f, 7.53609613e-02f, 5.25568798e-02f, 7.73381889e-02f, -7.48653337e-02f, -9.02716592e-02f, 7.04642832e-02f, -5.35819866e-02f, 4.81061302e-02f, -8.44138637e-02f,
  -5.66811673e-02f, 5.59834465e-02f, -9.33735520e-02f, 4.37560752e-02f, -4.43510041e-02f, -3.34765278e-02f, -5.01251444e-02f, 8.34580697e-03f, 8.21363255e-02f, -5.83180375e-02f,
  -1.55042973e-03f, -9.79296044e-02f, -4.38114181e-02f, 2.85537820e-02f, -5.06849550e-02f, -1.11794159e-01f, 5.65335341e-02f, 9.10635144e-02f, -4.53245342e-02f, -4.91112396e-02f,
  -8.09009187e-03f, -6.28495738e-02f, -2.01308038e-02f, 5.78184761e-02f, -1.11165605e-02f, 4.12066653e-02f, -8.87371600e-04f, 1.95869673e-02f, -8.44248012e-03f, 1.83500350e-02f,
  -8.20020866e-03f, -5.77680543e-02f, 8.37503523e-02f, -6.83862790e-02f, 5.10170963e-03f, -6.42000064e-02f, 6.87191114e-02f, -3.78536656e-02f, 6.59616441e-02f, -4.07176912e-02f,
  -8.43118578e-02f, 1.02707064e-02f, -7.77857495e-04f, 6.00613505e-02f, 1.78470984e-02f, -3.86924073e-02f, -1.67319737e-02f, 8.13242942e-02f, -1.79365445e-02f, -2.93023195e-02f,
  -1.38068512e-01f, -5.06562181e-02f, -2.83942670e-02f, 2.99952142e-02f, -2.35996265e-02f, 4.22261804e-02f, -1.27139911e-01f, 3.49180610e-03f, -7.08327740e-02f, 9.11762044e-02f,
  6.44387156e-02f, -4.60899062e-03f, -1.10506207e-01f, 4.09658924e-02f, 2.03942545e-02f, 3.17294486e-02f, 1.88071150e-02f, -1.28165290e-01f, 1.19378027e-02f, 1.66375574e-03f,
  -8.87014642e-02f, -7.24278316e-02f, -1.73192307e-01f, -9.74145383e-02f, -9.46381018e-02f, -7.74153471e-02f, -1.54483512e-01f, -2.58041807e-02f, -1.01486757e-01f, -1.83951959e-01f,
  -1.93936273e-01f, -3.31372730e-02f, -1.02840990e-01f, -9.88119468e-02f, 4.49335389e-02f, -1.81905199e-02f, -1.25742823e-01f, 6.57972395e-02f, 6.01174720e-02f, 5.89957684e-02f,
  1.92164872e-02f, 8.99963155e-02f, -1.38022779e-02f, 9.01439339e-02f, 8.12025890e-02f, 1.12478686e-02f, -7.74011910e-02f, 8.46738294e-02f, 3.56348492e-02f, -8.97455439e-02f,
  5.01858518e-02f, -8.98371562e-02f, 5.69043383e-02f, 1.05081782e-01f, -4.80240956e-02f, 5.03118187e-02f, 7.82970190e-02f, 2.22910699e-02f, 8.21893290e-02f, -2.26146318e-02f,
  -5.79810999e-02f, -3.96198109e-02f, -7.26283938e-02f, -2.41531990e-02f, -2.44840793e-02f, -1.02430709e-01f, -5.71890641e-03f, -3.46132927e-02f, -5.26424572e-02f, -1.00319289e-01f,
  -1.01629660e-01f, 2.04172917e-02f, 5.61305583e-02f, -2.19852272e-02f, -1.05342813e-01f, 8.79238732e-03f, 7.22116008e-02f, 5.67578245e-04f, 8.99723917e-02f, 9.23688523e-03f,
  2.32872441e-02f, -1.33816257e-01f, -6.71727657e-02f, 4.94224019e-02f, -8.51528421e-02f, 3.21599804e-02f, -6.00637868e-02f, 2.56883409e-02f, 7.37956911e-02f, 1.64668392e-02f,
  4.05671075e-02f, -5.16551733e-02f, -7.67559856e-02f, 2.50610430e-02f, -6.25566691e-02f, -3.50517258e-02f, 6.61090240e-02f, 6.88093156e-02f, 6.86672702e-02f, 2.18135044e-02f,
  -5.58482073e-02f, 1.36584090e-02f, -2.99002025e-02f, 1.77676082e-02f, 2.68279947e-02f, 5.71840741e-02f, 6.87900335e-02f, -8.18130299e-02f, -6.41341358e-02f, -2.04838091e-03f,
  6.02128319e-02f, -6.55014068e-02f, -9.67958942e-03f, 1.02305055e-01f, 3.83601226e-02f, -5.61778322e-02f, -1.90696307e-02f, -3.16651613e-02f, 2.08815001e-02f, -7.72631466e-02f,
  -4.31091040e-02f, 9.04318467e-02f, 1.17571205e-02f, -1.42885940e-02f, -7.20827729e-02f, -2.59631295e-02f, 3.21141556e-02f, -2.00054478e-02f, -6.10366054e-02f, -3.46196406e-02f,
  5.74000962e-02f, 5.84909022e-02f, 8.78838543e-03f, -6.35008002e-03f, -1.12865202e-01f, 4.02774885e-02f, 7.68322945e-02f, 5.92050143e-03f, -4.74485606e-02f, -1.07665267e-02f,
  4.82523516e-02f, -8.42768624e-02f, -1.61309779e-01f, -5.62513992e-02f, 3.20696235e-02f, -8.76546502e-02f, -1.20618537e-01f, -2.30133384e-02f, -9.57766026e-02f, -7.25808814e-02f,
  -1.58810228e-01f, -1.82900593e-01f, 8.38141143e-03f, 6.42434359e-02f, 1.07360147e-02f, -1.39960170e-01f, -2.21155167e-01f, -7.00368434e-02f, -1.02746524e-01f, -1.40069634e-01f,
  -2.25376058e-02f, 5.53824455e-02f, 1.36746827e-03f, 9.56336707e-02f, 7.38683119e-02f, -1.19781150e-02f, 2.89834458e-02f, -1.52300182e-03f, -3.52888135e-03f, 5.63124977e-02f,
  -5.23669831e-02f, -1.23002315e-02f, 1.57702535e-01f, 4.11533453e-02f, 5.26903458e-02f, -4.89225909e-02f, 5.26521169e-02f, -4.13928367e-02f, 2.44177468e-02f, -8.00078586e-02f,
  -1.68292478e-01f, -1.00830525e-01f, -6.22252375e-03f, -3.67493816e-02f, -5.98274618e-02f, 4.19163816e-02f, -1.34161636e-01f, 9.46664885e-02f, 7.21477941e-02f, 3.21170799e-02f,
  -1.33451493e-02f, -4.14694101e-02f, -7.55883381e-02f, -6.51743487e-02f, 5.27088568e-02f, -4.93943281e-02f, -5.77111468e-02f, 5.75346500e-02f, 7.01603070e-02f, 1.77334412e-03f,
  1.30159259e-02f, 3.70457657e-02f, -5.73083945e-02f, 2.10800413e-02f, 5.97348344e-03f, 1.97708923e-02f, -5.24018221e-02f, -1.16300747e-01f, -1.14146257e-02f, -1.15529373e-01f,
  3.35050598e-02f, -2.41753720e-02f, 6.36057137e-03f, -2.43982635e-02f, -2.25781798e-02f, -9.36224591e-03f, -5.61458468e-02f, -6.04538582e-02f, 3.66977267e-02f, 6.25900552e-02f,
  7.96540827e-02f, 3.23356204e-02f, 3.75966472e-03f, -8.24231207e-02f, -6.69669956e-02f, 4.19770367e-02f, 4.55878824e-02f, 4.81804349e-02f, -4.36390154e-02f, 7.56286085e-02f,
  3.33603173e-02f, -5.68247326e-02f, 7.76719227e-02f, -5.69771118e-02f, -5.81876338e-02f, 8.90618712e-02f, -1.86297987e-02f, 1.60606652e-02f, -9.70046744e-02f, -4.81297188e-02f,
  1.73593946e-02f, 1.75839454e-01f, -1.35626554e-01f, -1.01313934e-01f, -4.91588749e-03f, 2.60337070e-02f, -7.08531886e-02f, 1.40981739e-02f, 7.64729530e-02f, -6.06366880e-02f,
  -2.97057461e-02f, -6.52204677e-02f, -2.65821666e-02f, -7.36093670e-02f, -2.73079355e-03f, 8.44154973e-03f, 2.70813815e-02f, 3.27853411e-02f, -8.10080022e-02f, 2.55420562e-02f,
  2.90619880e-02f, -1.16952769e-01f, -1.60724893e-01f, -1.23226546e-01f, -5.99498339e-02f, -1.30432360e-02f, -1.12811498e-01f, -8.41480121e-02f, -1.98035594e-02f, -1.32693544e-01f,
  3.22336257e-01f, 1.22130383e-02f, 6.51973188e-02f, 1.30727112e-01f, 5.28802387e-02f, 1.73967481e-02f, -1.45296715e-02f, 6.48294762e-02f, 1.16954297e-01f, 3.01038921e-02f,
  6.65591210e-02f, 1.96322408e-02f, 8.41516852e-02f, 1.19699709e-01f, -1.27441073e-02f, 3.72382589e-02f, 4.40150499e-03f, 9.21370015e-02f, 8.80363137e-02f, 1.82113163e-02f,
  -3.85787524e-02f, -4.08904441e-03f, -1.02506289e-02f, 5.10992706e-02f, -1.26507372e-01f, -3.15336813e-03f, 1.90639365e-02f, -2.64256634e-02f, -3.67552717e-03f, -6.58287853e-02f,
  5.41717932e-02f, 1.06897078e-01f, -5.82879372e-02f, 3.30812708e-02f, -1.28280163e-01f, 6.61074370e-02f, 9.25705656e-02f, -8.74796659e-02f, -8.36825445e-02f, 4.55074161e-02f,
  -1.23094827e-01f, -3.99896614e-02f, -9.54551809e-03f, -6.87178075e-02f, -3.11721489e-02f, -1.30415866e-02f, -7.41912574e-02f, 7.32547976e-03f, 3.71531881e-02f, -8.82064775e-02f,
  9.70430300e-03f, -8.21906030e-02f, -3.63705829e-02f, 1.51854698e-02f, 7.63138533e-02f, 1.01419292e-01f, -6.91869110e-02f, -8.25607404e-02f, -4.50626537e-02f, 1.64413210e-02f,
  -5.34559786e-02f, 6.83328509e-02f, 8.05520639e-02f, 1.40812844e-02f, 9.77784693e-02f, -7.85291344e-02f, 2.99849138e-02f, -9.65169370e-02f, 7.99986254e-03f, -9.31583941e-02f,
  -9.97681078e-03f, -4.40285765e-02f, 2.16541272e-02f, -1.31722316e-02f, 6.06773868e-02f, 3.76682654e-02f, -9.49829631e-03f, 5.87610677e-02f, -7.88894296e-02f, -7.45778382e-02f,
  6.44269735e-02f, -1.71746444e-02f, -2.78360192e-02f, -6.08208776e-02f, 6.59840629e-02f, 6.15873337e-02f, 4.94514406e-02f, -1.28361853e-02f, 2.83577461e-02f, -7.64472038e-02f,
  4.18776609e-02f, 5.35334051e-02f, 8.10840130e-02f, 7.18854144e-02f, -9.02841240e-03f, -5.62569201e-02f, -3.22316624e-02f, 4.77023609e-03f, -1.09726630e-01f, -3.26598063e-02f,
  3.87490727e-02f, 2.96605267e-02f, -2.21205950e-02f, -9.67306187e-05f, 3.84528041e-02f, -4.17544544e-02f, -5.74822016e-02f, 8.63104388e-02f, -9.14395303e-02f, -8.42480734e-02f,
  -9.46776196e-02f, 9.22799706e-02f, 1.48585185e-01f, 1.03801638e-01f, -3.49313654e-02f, 1.12484254e-01f, 3.07002123e-02f, -2.08942238e-02f, 7.25028440e-02f, 1.12684645e-01f,
  6.18091263e-02f, 3.14864129e-01f, 8.31650496e-02f, 6.84240237e-02f, 1.02062233e-01f, 1.55732751e-01f, 2.81748176e-01f, 1.75795361e-01f, -5.36857694e-02f, 1.00990281e-01f,
  1.26631334e-01f, -4.19237018e-02f, -7.32150227e-02f, 3.26639786e-02f, 1.05224736e-01f, 4.31308337e-02f, 1.00200988e-01f, -8.19843635e-03f, -1.22389477e-02f, 4.63932939e-02f,
  8.99239331e-02f, 4.95944545e-03f, 2.37862598e-02f, 9.92365628e-02f, 1.37946516e-01f, -9.79974642e-02f, 5.74788190e-02f, 3.16610634e-02f, 6.24226360e-03f, -3.19988728e-02f,
  -6.72308803e-02f, 1.92072108e-01f, -1.28234252e-01f, -6.25447184e-02f, -7.86723718e-02f, -2.42755213e-03f, -3.26200277e-02f, -3.47113125e-02f, 3.43819261e-02f, -4.73560132e-02f,
  4.32735495e-02f, -5.60051249e-03f, 3.56830955e-02f, 5.69635294e-02f, 4.73066419e-02f, -5.49298003e-02f, -8.96377936e-02f, -2.12351866e-02f, -5.87023720e-02f, 6.99312538e-02f,
  2.22272128e-02f, -7.29018496e-03f, 4.98167947e-02f, 8.68472308e-02f, -7.93687440e-03f, -9.78055224e-02f, -4.01563011e-03f, 2.02861279e-02f, -5.89008555e-02f, -4.85425964e-02f,
  -5.64785413e-02f, -2.77867261e-02f, -5.57793565e-02f, 1.12684898e-01f, -4.58364468e-03f, -2.78256834e-02f, 9.01371017e-02f, -2.27567386e-02f, 8.37328006e-03f, -6.78245500e-02f,
  6.65251464e-02f, -6.07349724e-02f, 3.82834636e-02f, 3.70384082e-02f, -9.96123999e-02f, 1.38985086e-03f, -4.45485450e-02f, -2.83676330e-02f, -2.15478484e-02f, -8.38883314e-03f,
  8.75048935e-02f, 1.12831248e-02f, 2.00447403e-02f, -3.14137824e-02f, -6.88530505e-02f, 2.02620439e-02f, 1.24289896e-02f, -3.53477038e-02f, -5.12580983e-02f, -2.26591323e-02f,
  -1.91367894e-01f, -7.88879618e-02f, -1.16265692e-01f, 4.59310748e-02f, 2.23394502e-02f, -1.36321252e-02f, 3.30813602e-02f, -7.97012374e-02f, 6.02137260e-02f, -4.93542589e-02f,
  7.03592673e-02f, -4.46754992e-02f, 6.67147385e-03f, 5.41817360e-02f, -4.22765091e-02f, -7.39275590e-02f, -1.97066516e-02f, 6.24166504e-02f, -4.86878641e-02f, 1.39495600e-02f,
  -8.13144669e-02f, -8.52072164e-02f, -5.47914729e-02f, -1.33579507e-01f, -8.58158544e-02f, -1.32684380e-01f, -5.23865409e-02f, -1.00666434e-01f, -1.31874725e-01f, -1.17782138e-01f,
  -3.66452113e-02f, -8.98411423e-02f, 1.29224867e-01f, -7.42610253e-04f, 7.64442459e-02f, 7.08467588e-02f, 1.87078658e-02f, 4.18085121e-02f, 5.95181175e-02f, 8.66708905e-02f,
  -1.64536610e-01f, -1.90805003e-01f, -2.16899924e-02f, -8.23684707e-02f, -4.51637134e-02f, 6.84078485e-02f, 2.56791040e-02f, 5.96160367e-02f, -9.75977406e-02f, -3.62530537e-02f,
  -1.31520063e-01f, 2.95253359e-02f, -7.91847408e-02f, -2.47337390e-02f, -3.16352881e-02f, 1.82683449e-02f, 4.98034642e-04f, -7.75721809e-03f, -2.83593480e-02f, 2.81878468e-02f,
  5.29962629e-02f, -7.38030020e-03f, -7.69453794e-02f, -1.42005920e-01f, 6.36703474e-03f, -3.12854014e-02f, 6.95751086e-02f, 4.76021580e-02f, 5.10954112e-02f, -7.67043009e-02f,
  3.61391716e-02f, -9.18646827e-02f, -8.78481194e-02f, 7.58608151e-03f, 7.99657255e-02f, 2.24071722e-02f, -5.89754395e-02f, -3.00379694e-02f, -7.30882362e-02f, -6.12904765e-02f,
  -3.78020331e-02f, 3.57627124e-02f, -5.39918840e-02f, 1.10733368e-01f, -4.15822752e-02f, -3.77114490e-02f, 6.53708652e-02f, 6.66785613e-02f, -3.86155546e-02f, 4.44603199e-03f,
  -5.80861233e-02f, -7.39114434e-02f, -3.79019082e-02f, 1.90494116e-02f, 3.06350887e-02f, -5.51794991e-02f, 1.05274422e-02f, 6.44913986e-02f, -2.26756372e-02f, -9.15013254e-02f,
  -9.01415125e-02f, 1.35445665e-03f, 4.66131460e-04f, 3.42908353e-02f, -6.55551255e-02f, 2.85652075e-02f, -3.50591317e-02f, 7.48401284e-02f, 2.10869368e-02f, 2.88172383e-02f,
  -1.77551471e-02f, -5.60310557e-02f, 9.27225947e-02f, 8.33178125e-03f, -8.25434774e-02f, 3.48562375e-02f, 2.64639165e-02f, 7.21114222e-03f, -7.67380465e-03f, 1.31456768e-02f,
  -1.87657848e-02f, -1.38401002e-01f, -4.38982919e-02f, -1.20401504e-02f, 7.52806440e-02f, -7.11916760e-02f, 3.98264937e-02f, -5.81867546e-02f, -1.15852475e-01f, 8.60749334e-02f,
  -9.07391403e-03f, -8.37692246e-02f, -4.84339483e-02f, -8.05515349e-02f, -2.67675277e-02f, 7.44722933e-02f, 6.40085340e-02f, 2.73057111e-02f, 6.93129599e-02f, 4.50292975e-02f,
  -7.06668496e-02f, -4.15414805e-04f, 4.35269922e-02f, 8.33209977e-02f, 5.85250780e-02f, -8.86783525e-02f, 1.58536546e-02f, 1.10278986e-01f, 1.22147523e-01f, 6.46328628e-02f,
  2.15154767e-01f, -3.10919364e-03f, -2.24874958e-01f, 1.49862319e-01f, -6.71349615e-02f, -1.59358799e-01f, -1.27384260e-01f, -8.67070109e-02f, 5.98559864e-02f, -1.31441290e-02f,
  1.96670387e-02f, -1.52061898e-02f, -4.73888591e-02f, -6.10601306e-02f, -5.64566888e-02f, -6.20525442e-02f, -1.16787843e-01f, -1.94957450e-01f, -2.30999634e-01f, -1.97266892e-01f,
  -3.70994098e-02f, -5.53684048e-02f, 7.99691975e-02f, -8.92535597e-02f, 7.24236742e-02f, -5.78676648e-02f, 3.58329015e-03f, -4.71357219e-02f, -1.26566077e-02f, -4.71274815e-02f,
  -1.82861209e-01f, -1.69320498e-03f, -1.98787954e-02f, -1.63996906e-03f, -5.14597930e-02f, -6.84343427e-02f, -7.11103678e-02f, -7.88355172e-02f, 7.44960308e-02f, -8.35495293e-02f,
  -4.77607362e-02f, -9.26959813e-02f, 7.78105557e-02f, -6.30788282e-02f, 2.34460663e-02f, -2.31880024e-02f, -5.12390514e-04f, -6.62160739e-02f, -8.58141035e-02f, -1.12731509e-01f,
  8.81987065e-02f, -3.64129879e-02f, -7.13156015e-02f, 2.45091952e-02f, -3.58031280e-02f, -1.63573306e-02f, -1.15195982e-01f, -1.19934559e-01f, -1.28629114e-02f, -4.23615351e-02f,
  1.41771641e-02f, 2.96834670e-02f, 2.30266973e-02f, 9.57826525e-03f, 5.38525684e-03f, -3.43511775e-02f, -1.09910714e-02f, -6.49267212e-02f, -8.29186514e-02f, -5.71509153e-02f,
  6.04677163e-02f, -2.76599843e-02f, -1.19616129e-02f, 7.90272504e-02f, -1.41284596e-02f, -5.13071045e-02f, -8.95637125e-02f, 5.61552197e-02f, 8.61666352e-03f, 3.53584662e-02f,
  7.97644034e-02f, 8.34245794e-03f, -2.69834604e-02f, -9.61932987e-02f, -3.83805707e-02f, -3.37275974e-02f, -1.40052997e-02f, -4.09710631e-02f, -1.14996843e-02f, 2.23654956e-02f,
  1.44095168e-01f, -1.60085827e-01f, -3.99530195e-02f, -1.42080085e-02f, -7.83942118e-02f, 6.13352917e-02f, -5.16624376e-02f, -9.88565907e-02f, -7.45780841e-02f, -3.95503193e-02f,
  3.34531367e-02f, 1.75740607e-02f, 1.06998101e-01f, -9.05183479e-02f, 6.11201562e-02f, 6.04567118e-02f, -3.94866467e-02f, -5.20828702e-02f, -7.77515769e-02f, -7.88421929e-02f,
  7.84892738e-02f, 8.10432527e-03f, -3.32783051e-02f, 6.61658007e-04f, 5.54702207e-02f, 2.59086192e-02f, -3.81845534e-02f, -6.68866038e-02f, -7.18527213e-02f, 5.43106161e-02f,
  2.69117087e-01f, 1.81311950e-01f, -3.02526891e-01f, 1.93230715e-02f, -1.15109339e-01f, -1.11915670e-01f, 1.25456825e-01f, 1.14959940e-01f, 1.03533931e-01f, -1.56509876e-02f,
  -9.97414216e-02f, -1.07987911e-01f, -2.37615127e-03f, 2.01974902e-02f, 6.82610124e-02f, -6.57145530e-02f, 2.07052641e-02f, -9.68670398e-02f, -1.31043896e-01f, 8.93248245e-02f,
  7.78000057e-02f, 1.73351273e-01f, 1.02717243e-02f, 3.74439079e-03f, -7.73837045e-02f, -5.92442229e-02f, 1.47168050e-02f, -9.82947797e-02f, -1.13875754e-01f, -3.87565494e-02f,
  -2.10738420e-01f, -1.57243222e-01f, -1.45720661e-01f, -1.05286941e-01f, -1.30679905e-01f, -7.28157908e-02f, -9.19406563e-02f, -1.09103233e-01f, -3.45486626e-02f, -2.10647099e-02f,
  -2.07446963e-01f, -1.31586790e-01f, -5.13873063e-02f, 2.32976163e-03f, 1.17328642e-02f, -4.98050675e-02f, 5.11559993e-02f, -6.75882697e-02f, -2.78762598e-02f, -1.52234510e-01f,
  -1.14280600e-02f, -1.95230484e-01f, -1.49844676e-01f, -9.14437845e-02f, -1.23763448e-02f, -1.20782278e-01f, -1.65943265e-01f, -8.57859179e-02f, -3.73649113e-02f, 1.68244481e-01f,
  4.32200357e-02f, -8.21401849e-02f, -8.28923211e-02f, 7.26023838e-02f, 9.87075921e-03f, -6.06686510e-02f, 5.50616300e-03f, 8.04284215e-02f, -6.87994936e-04f, -6.14675060e-02f,
  -4.27613445e-02f, -6.99955076e-02f, -2.66968571e-02f, 3.96328196e-02f, 1.65516138e-03f, 4.32714671e-02f, 5.66258579e-02f, 1.12000391e-01f, 4.61919047e-02f, -2.16030236e-02f,
  -3.01093087e-02f, -5.35935629e-03f, 1.76993087e-02f, 7.82564729e-02f, 2.19030771e-03f, -6.88643754e-02f, 4.24361527e-02f, 3.35266218e-02f, 1.63975172e-02f, 5.81917837e-02f,
  3.27599049e-01f, -4.34733555e-02f, 3.83089622e-03f, 1.01629831e-01f, -9.37907919e-02f, -2.45616008e-02f, -1.17163593e-03f, 4.89624264e-03f, -1.47272170e-01f, -5.74191585e-02f,
  -6.10095225e-02f, -1.01430528e-01f, -2.99698785e-02f, 2.33647390e-03f, -7.60671273e-02f, 1.62243731e-02f, 7.69606382e-02f, -7.21924659e-03f, -1.54833570e-02f, 1.60314962e-02f,
  9.89121851e-03f, 1.39241487e-01f, 8.00357983e-02f, 8.54367837e-02f, 3.57040130e-02f, -8.26572776e-02f, -7.89742172e-02f, 7.18621612e-02f, 3.32934856e-02f, 2.89599508e-01f,
  1.55035064e-01f, -6.06757812e-02f, -1.79499686e-02f, 1.64130360e-01f, 5.99199347e-02f, -7.18329474e-02f, -4.92913611e-02f, -2.49707811e-02f, 2.85697524e-02f, -1.48024438e-02f,
  2.89661530e-02f, 4.83969133e-03f, 1.14550568e-01f, 8.71692300e-02f, 2.32979879e-02f, 1.22139372e-01f, 1.81396324e-02f, 1.69451386e-01f, -2.65623741e-02f, 7.03542084e-02f,
  1.93968564e-01f, 1.39905408e-01f, 6.10838644e-02f, 8.32342729e-02f, 6.53271228e-02f, 1.21653281e-01f, 8.31594765e-02f, 7.23078623e-02f, 9.51695740e-02f, 1.44494459e-01f,
  -6.93707988e-02f, -5.54027893e-02f, -5.05750589e-02f, 1.23678856e-01f, -1.12523213e-01f, 4.62217480e-02f, -1.41479960e-02f, 6.35499507e-02f, 6.06511012e-02f, 3.23420390e-02f,
  5.58130518e-02f, -4.20188382e-02f, 4.39418927e-02f, 3.52272093e-02f, -8.53058770e-02f, 1.71906799e-02f, -3.06328349e-02f, -4.54512052e-02f, -7.92335793e-02f, -1.14895739e-01f,
  -5.27677266e-03f, -8.74560550e-02f, -3.71415652e-02f, -1.03114098e-01f, -8.32648277e-02f, -4.27784286e-02f, -7.27709159e-02f, 2.98306835e-03f, -8.52855295e-02f, 2.33094487e-02f,
  -1.00990515e-02f, -6.37011603e-02f, -9.06600133e-02f, 7.48563632e-02f, 7.91058876e-03f, 5.53043820e-02f, -5.90119883e-02f, -7.12601840e-02f, -2.46700384e-02f, 3.05773076e-02f,
  -5.03996685e-02f, 1.72565430e-02f, -1.18494397e-02f, 8.12020749e-02f, 1.05358280e-01f, -1.46523323e-02f, 2.43235752e-02f, -5.60773723e-02f, 8.60966593e-02f, -7.05330744e-02f,
  1.01195253e-01f, -8.38298630e-03f, -5.37767075e-02f, 3.17046344e-02f, -2.89449245e-02f, -1.38121853e-02f, 7.60951564e-02f, -5.52691221e-02f, 5.15432358e-02f, -2.62873694e-02f,
  4.57187034e-02f, -7.18621612e-02f, -2.29313467e-02f, -8.67435634e-02f, -6.16552532e-02f, 2.67211497e-02f, -8.87045860e-02f, 1.17417378e-02f, -9.91305113e-02f, -7.12222531e-02f,
  -1.97241474e-02f, -9.98495445e-02f, -1.05270661e-01f, -9.95857790e-02f, 7.95735344e-02f, 3.31969373e-02f, 1.56675149e-02f, 5.73743284e-02f, -4.79648896e-02f, -1.20426923e-01f,
  -4.27019522e-02f, 7.58327842e-02f, 1.51793445e-02f, 5.40457964e-02f, -5.47004305e-02f, -2.90592089e-02f, -8.20120648e-02f, -1.07261717e-01f, -8.69688094e-02f, 6.83131278e-04f,
  -3.74624357e-02f, 3.24074179e-02f, -2.46274248e-01f, 6.92105815e-02f, -1.30457804e-02f, -1.18744031e-01f, 9.79138836e-02f, -2.70131715e-02f, 1.39741004e-01f, 1.29126042e-01f,
  -6.66557476e-02f, -9.44654271e-02f, 2.03575706e-03f, 2.86504012e-02f, -7.47253299e-02f, 3.17424834e-02f, 1.01947077e-01f, -4.26960401e-02f, -2.24198159e-02f, 6.33276179e-02f,
  7.30008781e-02f, -4.46208566e-03f, 8.68081674e-02f, 2.04863921e-02f, 6.54064119e-02f, 9.57135763e-03f, -1.56323181e-03f, -1.47929313e-02f, -7.58366510e-02f, -6.62299916e-02f,
  -2.39288405e-01f, -2.28423625e-01f, -3.29232216e-02f, 5.79894846e-03f, -6.42209053e-02f, 8.97481516e-02f, -2.24525910e-02f, -7.95205906e-02f, -9.30345431e-03f, 6.84955344e-02f,
  -6.34020939e-02f, -1.99046824e-02f, -8.84186998e-02f, -1.66911795e-03f, 1.39822289e-02f, -5.06381877e-02f, -6.98831007e-02f, -5.12431748e-02f, -1.30981877e-01f, -8.47438127e-02f,
  -1.04064448e-02f, -3.42822336e-02f, -5.02472259e-02f, -9.13399234e-02f, -9.41730663e-02f, -2.74672415e-02f, 9.46797337e-03f, -5.00419587e-02f, -7.08944872e-02f, 8.56543854e-02f,
  -4.44816984e-02f, 9.18695107e-02f, 7.21966624e-02f, 2.93582771e-02f, 8.88622701e-02f, -4.11614068e-02f, -3.59122939e-02f, 2.38056257e-02f, 1.08905628e-01f, 3.40229198e-02f,
  3.29142176e-02f, 1.71120483e-02f, 1.61824736e-03f, 5.75298890e-02f, -1.38646038e-02f, -7.65708387e-02f, 5.96024916e-02f, 7.93670043e-02f, 7.98604414e-02f, 5.91128878e-03f,
  5.92110828e-02f, -5.15320040e-02f, -7.33393505e-02f, 3.00832540e-02f, -9.62385014e-02f, 4.50925007e-02f, -5.09967618e-02f, 7.87283406e-02f, -4.01879698e-02f, 3.81613374e-02f,
  1.07472204e-01f, -1.60696745e-01f, 3.15128220e-03f, 5.50791435e-02f, -6.52097389e-02f, -4.42840643e-02f, 7.76027590e-02f, 5.82662858e-02f, -1.67805254e-02f, 1.24022290e-02f,
  -3.90456021e-02f, 4.77550142e-02f, 4.30778973e-02f, 4.77199182e-02f, -9.11319926e-02f, 7.55811930e-02f, 6.38790950e-02f, -4.35781591e-02f, 3.95421162e-02f, 3.42160783e-04f,
  1.19975105e-01f, 7.91666582e-02f, 3.35952863e-02f, 5.80093823e-02f, 5.69032170e-02f, -3.28242108e-02f, 6.47421740e-03f, -9.01237130e-02f, 5.31337336e-02f, 2.41260797e-01f,
  6.48856014e-02f, -3.18219922e-02f, 5.68407476e-02f, 2.45536976e-02f, -8.87470320e-02f, -9.94133428e-02f, -2.34448630e-02f, -1.35309562e-01f, 2.55658943e-03f, -2.85733715e-02f,
  7.01456666e-02f, 1.43923372e-01f, 2.47808341e-02f, 8.62060189e-02f, -2.62607690e-02f, -1.06025860e-01f, 2.59794034e-02f, -3.31168734e-02f, 2.55044159e-02f, 9.52422619e-02f,
  7.46458694e-02f, -5.56938574e-02f, 7.27921203e-02f, -3.40371877e-02f, 5.22404313e-02f, 9.92424414e-02f, -9.74153727e-02f, 2.27609128e-02f, -5.14855869e-02f, 9.91867930e-02f,
  3.15658450e-01f, -1.12751886e-01f, 5.99944890e-02f, -8.84443987e-03f, 6.40956834e-02f, -3.18864211e-02f, 3.49442065e-02f, -6.15114272e-02f, 4.26969714e-02f, -8.54057297e-02f,
  6.26148209e-02f, -5.33742309e-02f, -2.54038237e-02f, -6.16277680e-02f, -4.54533426e-03f, -9.31064934e-02f, -5.72378077e-02f, 1.11309364e-02f, -6.44005388e-02f, -2.18450446e-02f,
  -4.37538698e-02f, -1.41361887e-02f, 6.31116554e-02f, -1.13725096e-01f, -1.28422128e-02f, 2.57614572e-02f, -8.59371647e-02f, 1.76372975e-02f, -1.25191599e-01f, -1.52514763e-02f,
  -1.35341650e-02f, -3.57733779e-02f, 9.10205618e-02f, 8.75210389e-02f, 3.80425118e-02f, 1.19233951e-02f, 5.13487905e-02f, 8.10854435e-02f, -5.14709242e-02f, 5.07652434e-03f,
  7.69190118e-02f, -5.90028353e-02f, -7.34862909e-02f, 3.50795127e-02f, 5.24279550e-02f, 8.00627917e-02f, -1.45211983e-02f, 4.75555174e-02f, 4.99279015e-02f, -3.78693938e-02f,
  3.34231853e-02f, 1.01671055e-01f, -6.62776604e-02f, -1.92414690e-02f, -2.93564443e-02f, -1.10417465e-02f, 7.70360678e-02f, -5.62542081e-02f, 9.27855819e-02f, 7.94778392e-02f,
  1.69065610e-01f, -6.63833469e-02f, -1.20951459e-02f, 7.09016994e-02f, 1.69818792e-02f, -1.19996332e-01f, 6.15316890e-02f, -3.39551866e-02f, 1.02957180e-02f, 5.09854779e-02f,
  6.98397905e-02f, -2.52494384e-02f, 1.60879232e-02f, -7.80771486e-04f, -6.11803122e-02f, 5.03806118e-03f, 1.97818466e-02f, 7.22301379e-02f, 1.41704106e-03f, 3.76885086e-02f,
  -7.48060942e-02f, -8.04684609e-02f, 1.33010745e-01f, -6.42946213e-02f, -4.53957133e-02f, -8.60172976e-03f, 5.96236698e-02f, 7.28513896e-02f, 7.03898370e-02f, -1.80306938e-02f,
  2.44524419e-01f, 2.78627098e-01f, 1.29910052e-01f, -3.50598916e-02f, 8.12900718e-03f, 1.80335507e-01f, 2.79815584e-01f, 1.23070262e-01f, -1.15812458e-01f, 6.36050776e-02f,
  1.33439437e-01f, -1.28079429e-01f, -7.15331733e-02f, -1.27233416e-01f, 8.48522335e-02f, -4.66452204e-02f, -9.02890041e-02f, -3.62104997e-02f, -1.19310342e-01f, 8.18033004e-04f,
  -5.75551726e-02f, 3.13950032e-02f, -6.38836920e-02f, -1.26531810e-01f, -5.53317405e-02f, -1.79523066e-01f, -2.11203285e-02f, -1.90702844e-02f, 1.10350229e-01f, -1.26993641e-01f,
  -3.01646087e-02f, 3.70767474e-01f, -9.11749825e-02f, -1.00883864e-01f, -3.78311761e-02f, 3.68380919e-02f, -8.57094117e-03f, -6.47644252e-02f, 7.94347450e-02f, -8.23732018e-02f,
  -2.98805325e-03f, 3.46179530e-02f, 4.62115705e-02f, 5.73267369e-03f, 5.16464002e-03f, -5.64389490e-02f, 4.16278876e-02f, -3.59212644e-02f, 1.33438446e-02f, -3.23708653e-02f,
  2.21134201e-02f, 1.09580699e-02f, 4.36586253e-02f, 8.89499784e-02f, 5.91044948e-02f, 1.15361670e-02f, -2.04722676e-02f, -6.73220456e-02f, 3.95741984e-02f, -1.04081415e-01f,
  2.01568119e-02f, 1.90725457e-02f, 7.71075264e-02f, -3.72708850e-02f, -2.52658613e-02f, 8.45796242e-02f, -7.98278376e-02f, -2.91012302e-02f, 9.06726792e-02f, -9.23805870e-03f,
  -6.84852302e-02f, 5.70561551e-02f, -3.31119001e-02f, 4.40610908e-02f, 3.27917300e-02f, -3.23441252e-02f, -1.94808515e-03f, 8.73335376e-02f, -4.99486737e-03f, 8.87409896e-02f,
  -2.02826634e-02f, 1.64034609e-02f, 2.32382142e-03f, -5.87443002e-02f, 7.10803941e-02f, 6.73418045e-02f, 7.47369602e-02f, 6.84245452e-02f, -6.32047802e-02f, -3.20943967e-02f,
  -1.51894331e-01f, 2.25001231e-01f, -5.82224652e-02f, -1.21592857e-01f, 6.92701116e-02f, -1.74824819e-02f, 6.69312105e-02f, -9.93458461e-03f, 3.09168659e-02f, 1.51179377e-02f,
  1.05032489e-01f, 5.19871376e-02f, 2.20255530e-03f, -7.36915320e-02f, -4.35542166e-02f, -9.11891684e-02f, 3.65094170e-02f, 4.74843662e-03f, 3.34121995e-02f, 3.49889020e-03f,
  -1.24842718e-01f, 8.65231827e-03f, -9.93587971e-02f, -1.10491596e-01f, 2.75355559e-02f, -1.57160625e-01f, 4.22010496e-02f, -1.50197120e-02f, -8.68372619e-03f, -4.14310321e-02f,
  1.21981077e-01f, -4.11146879e-02f, 4.96397540e-02f, 1.40989244e-01f, 1.80944577e-02f, -2.66023371e-02f, -3.71061973e-02f, 3.42547931e-02f, 1.59279853e-02f, 6.06681081e-03f,
  -2.64415089e-02f, 1.64311558e-01f, 1.72833532e-01f, 1.53082728e-01f, 8.10695216e-02f, 4.83855829e-02f, 1.71559677e-01f, 2.11747378e-01f, 1.53728038e-01f, -5.80889471e-02f,
  3.51749510e-02f, 1.00179195e-01f, 1.01511300e-01f, 9.32229757e-02f, 1.21768013e-01f, 1.26629367e-01f, -5.87590784e-02f, 1.07097387e-01f, 7.03036934e-02f, 1.74839631e-01f,
  -3.73524241e-02f, -6.85615540e-02f, -1.11735268e-02f, -3.73788029e-02f, 7.01353047e-03f, 3.65046188e-02f, 5.75780449e-03f, 4.70939241e-02f, 9.08808559e-02f, 3.19284722e-02f,
  6.43230379e-02f, 1.46086635e-02f, -5.09073958e-02f, -1.58540718e-02f, -2.08446826e-03f, -1.00799531e-01f, -6.03670254e-02f, -1.81161822e-03f, 8.91299695e-02f, -2.90052406e-02f,
  -3.96574698e-02f, -7.22665563e-02f, 1.05315959e-02f, -1.17109179e-01f, -6.29133061e-02f, -5.10921292e-02f, -9.27594490e-03f, -8.35984424e-02f, -6.47115707e-02f, -4.17802529e-03f,
  -2.19988395e-02f, -1.73155200e-02f, 9.79751945e-02f, 1.05478384e-01f, 4.55932915e-02f, 2.41277479e-02f, 9.84899700e-02f, 1.71782903e-03f, 5.94961233e-02f, 7.93025494e-02f,
  7.83284754e-02f, -2.42321678e-02f, 6.56644329e-02f, 1.06305800e-01f, -1.00115202e-02f, -7.83607960e-02f, -8.02851375e-03f, 9.40628126e-02f, 1.80134457e-02f, 7.14832544e-02f,
  2.69395802e-02f, -6.55444413e-02f, -6.26400486e-02f, 1.32775605e-02f, -2.12927628e-02f, 5.29889986e-02f, 7.13161975e-02f, -1.24309110e-02f, 3.13856490e-02f, 8.41413252e-03f,
  -1.32114381e-01f, 3.33733596e-02f, -3.73262726e-03f, 8.72889757e-02f, -1.33748585e-02f, -9.71619189e-02f, -5.47760613e-02f, -7.73078129e-02f, 2.28497814e-02f, -9.23529193e-02f,
  -7.02518523e-02f, 4.04765084e-02f, -3.45929973e-02f, -6.26751333e-02f, -6.20276965e-02f, -6.72938526e-02f, -2.42628735e-02f, 9.41350758e-02f, -4.58961166e-02f, 6.81555644e-02f,
  -7.95645118e-02f, -1.18336037e-01f, -1.10020414e-02f, -7.72779137e-02f, -6.46795034e-02f, -7.53452629e-02f, -6.35897070e-02f, -1.23180710e-01f, -9.64155123e-02f, -6.10870607e-02f,
  1.14216365e-01f, 1.24944393e-02f, 9.55972150e-02f, 1.48863271e-01f, 1.44561455e-01f, -3.09003945e-02f, -6.18702918e-02f, -1.72232613e-01f, 4.34227772e-02f, -1.57555658e-02f,
  1.58230618e-01f, 5.71699925e-02f, -5.74837960e-02f, -1.68102831e-01f, -2.52363503e-01f, -2.18791351e-01f, -1.43121645e-01f, -1.72302917e-01f, -2.18966931e-01f, -1.17581084e-01f,
  -7.17267841e-02f, -8.27349722e-02f, -1.07160762e-01f, -9.47783962e-02f, 1.79422811e-01f, 5.30831106e-02f, 1.43496513e-01f, 2.29780432e-02f, 5.31887673e-02f, 9.25255939e-02f,
  1.87062427e-01f, 3.65014598e-02f, -1.01069927e-01f, -1.94017403e-02f, 7.45245665e-02f, -8.98842365e-02f, -3.56442481e-03f, -4.88008521e-02f, 7.92260244e-02f, -8.49977806e-02f,
  4.07326818e-02f, -7.84084722e-02f, -2.39509214e-02f, 6.19129278e-02f, -3.77291702e-02f, -1.37222841e-01f, -1.55294970e-01f, -1.17908135e-01f, -1.16930559e-01f, -3.26011702e-02f,
  7.75521919e-02f, 5.72708957e-02f, 2.27663610e-02f, -8.62771869e-02f, -2.92887427e-02f, 6.87469691e-02f, 8.11529756e-02f, -9.02764034e-03f, -7.35870153e-02f, 7.52988383e-02f,
  -1.01556510e-01f, 1.60870627e-02f, 8.66015814e-03f, -2.94994209e-02f, -9.92780030e-02f, 2.56762356e-02f, 6.66785762e-02f, -3.68104875e-02f, -4.65341024e-02f, 1.00685181e-02f,
  2.64677741e-02f, -7.98198488e-03f, -6.99465573e-02f, 5.92342950e-02f, -2.51562353e-02f, 3.53065170e-02f, 7.32308580e-03f, -6.79953620e-02f, -2.60861460e-02f, -4.95726243e-02f,
  3.22342478e-02f, 8.75051543e-02f, 3.61799984e-03f, -5.97476326e-02f, -7.29594156e-02f, -8.40341225e-02f, -4.08515930e-02f, -1.81836952e-02f, 4.44131084e-02f, -6.63340390e-02f,
  2.90425289e-02f, -3.19619887e-02f, -2.09431723e-03f, -3.31064239e-02f, 6.31058589e-02f, 8.21370706e-02f, 5.93986474e-02f, -8.49440023e-02f, -3.86369973e-02f, -6.39565364e-02f,
  -5.39121665e-02f, 2.12992448e-02f, 7.02641606e-02f, -8.09184611e-02f, -7.56408498e-02f, -5.22496067e-02f, -1.14800408e-01f, 3.57518457e-02f, -3.58935352e-03f, -9.99897197e-02f,
  -8.17678347e-02f, -5.11339009e-02f, -3.53744961e-02f, -8.26355666e-02f, 4.07479294e-02f, -6.76404983e-02f, -3.20636481e-02f, 2.91538779e-02f, -5.96650131e-02f, -1.62644356e-01f,
  -8.07848424e-02f, -8.53452086e-02f, 6.55511245e-02f, -1.20231509e-03f, 6.15442581e-02f, -1.59718513e-01f, -2.17091694e-01f, -1.36240989e-01f, 4.34985012e-02f, -1.16240151e-01f,
  -5.86236315e-03f, -5.88070303e-02f, 6.56900033e-02f, -2.03379616e-02f, -9.78610292e-02f, -9.89137292e-02f, -8.79286751e-02f, 8.25621486e-02f, 4.26800586e-02f, 4.81823012e-02f,
  -5.28405868e-02f, 5.12095764e-02f, -1.45431226e-02f, -2.52415761e-02f, 3.24741751e-02f, 9.34108272e-02f, 7.79939517e-02f, -4.94797826e-02f, -4.11144681e-02f, 1.14711508e-01f,
  -2.89417920e-03f, -5.19016348e-02f, -3.15803625e-02f, -2.85152420e-02f, 9.09844860e-02f, 5.18710539e-02f, 3.43380123e-02f, -6.51483983e-02f, -9.65502113e-02f, -6.29790947e-02f,
  9.26242247e-02f, -6.64949194e-02f, -6.47963658e-02f, 7.83363134e-02f, -8.12272131e-02f, -5.82590736e-02f, -2.63039637e-02f, -4.99083102e-02f, -4.61520255e-02f, -8.93008262e-02f,
  -5.48858196e-02f, 5.30237332e-02f, -9.97949466e-02f, -8.43902081e-02f, 2.00590994e-02f, 5.49224801e-02f, -1.22878626e-01f, -1.16983876e-01f, -8.76750201e-02f, -2.63496325e-03f,
  -1.26012936e-02f, 8.15158859e-02f, -2.45064730e-03f, 4.28562164e-02f, -7.93489516e-02f, 6.87910244e-02f, 6.54663593e-02f, 3.53773385e-02f, 4.06567045e-02f, -7.68851787e-02f,
  1.45512531e-02f, 6.60016984e-02f, -5.51686734e-02f, 8.02389532e-02f, -3.71951088e-02f, -6.26175255e-02f, -9.72305685e-02f, -2.06467919e-02f, 7.17902854e-02f, -4.13068272e-02f,
  -2.63916631e-03f, 4.17891704e-02f, -8.45221896e-03f, 4.43217531e-03f, -5.44681661e-02f, 4.72069494e-02f, 1.83815248e-02f, 3.33011225e-02f, -6.02656938e-02f, 2.38178968e-02f,
  6.70520291e-02f, 8.31578746e-02f, -7.68672004e-02f, 5.43966256e-02f, -7.83025771e-02f, -2.88933627e-02f, 4.12110128e-02f, 2.83500943e-02f, 3.35362107e-02f, -2.99504176e-02f,
  -4.85672578e-02f, -2.32614074e-02f, -7.43617788e-02f, -5.03987409e-02f, -1.01447813e-02f, 4.20206487e-02f, -1.00545688e-02f, -6.62108287e-02f, 6.07695207e-02f, 7.16725364e-02f,
  2.02184115e-02f, -1.10318951e-01f, -1.98669195e-01f, -8.60283896e-02f, 2.86510959e-02f, 9.78178438e-03f, -1.12256266e-01f, -1.27153816e-02f, -1.59237221e-01f, -3.96115035e-02f,
  -3.05011153e-01f, -6.00356236e-02f, -6.71635419e-02f, -2.35730812e-01f, -5.48618324e-02f, 3.25575806e-02f, 7.89566487e-02f, -8.89612585e-02f, -1.60282597e-01f, -6.89784884e-02f,
  1.25604691e-02f, 8.17799568e-02f, 8.34734887e-02f, 8.20332244e-02f, -5.10317013e-02f, 1.02556594e-01f, -5.61820865e-02f, 4.86494675e-02f, -2.57667992e-02f, -6.22615814e-02f,
  -3.20326500e-02f, -1.57108739e-01f, -2.71337293e-02f, -1.39041543e-01f, -1.01883225e-01f, -3.76881659e-02f, 4.36371304e-02f, -8.66986886e-02f, -2.25387095e-03f, -5.52105382e-02f,
  2.33067051e-01f, -2.41752397e-02f, -6.80389926e-02f, 5.33189764e-03f, 1.67646427e-02f, -8.48984718e-03f, 3.52195464e-02f, -3.54591832e-02f, -5.61131537e-02f, -3.20939869e-02f,
  -4.25227918e-02f, -1.65705066e-02f, -3.05808429e-02f, -1.05733774e-03f, -8.29238743e-02f, -8.77856370e-03f, 3.89656238e-02f, -2.31168512e-02f, 7.78712332e-02f, 8.75366032e-02f,
  -5.91001324e-02f, -2.92130094e-02f, -9.52538624e-02f, 5.36949560e-02f, -9.23187956e-02f, -9.74126160e-02f, 7.55021423e-02f, -7.69550502e-02f, -5.84007539e-02f, 5.20437909e-03f,
  -7.63108805e-02f, 3.06188911e-02f, 2.80636828e-02f, -6.60709962e-02f, -3.36844586e-02f, -1.17374118e-02f, 4.18050624e-02f, -6.31900802e-02f, 6.33409098e-02f, -4.97664288e-02f,
  9.20607448e-02f, -7.71622658e-02f, -5.31694442e-02f, -1.20027708e-02f, -5.95164970e-02f, -8.21979716e-02f, 2.41175219e-02f, 1.01532288e-01f, -7.33609498e-02f, 5.68440137e-03f,
  -1.74169021e-03f, -1.87266280e-03f, -9.07809734e-02f, 1.98725946e-02f, 6.59675896e-02f, -6.40722597e-03f, 3.65589261e-02f, 1.46396924e-02f, 5.43599464e-02f, -2.40662321e-02f,
  8.74638259e-02f, 2.80538015e-02f, -4.29221056e-02f, -1.26469424e-02f, -8.15158412e-02f, -1.00806439e-02f, 2.97262836e-02f, -4.45922837e-02f, -1.07181109e-01f, 4.07398678e-02f,
  -3.31504121e-02f, -1.85432974e-02f, -4.88045290e-02f, 8.95306244e-02f, -2.35752985e-02f, 4.01636362e-02f, -6.63905665e-02f, -1.19948406e-02f, 2.71688402e-02f, -4.14383551e-03f,
  1.69560835e-02f, 2.31062919e-02f, -5.07461205e-02f, 4.34679985e-02f, 4.23896983e-02f, 5.13353385e-03f, 1.07583962e-01f, 1.24413982e-01f, -8.18773173e-03f, 5.82479574e-02f,
  2.12360770e-01f, -1.50242820e-01f, -3.39377224e-01f, 4.74324711e-02f, -1.81169793e-01f, -3.07734936e-01f, -2.03318924e-01f, -1.57771725e-02f, 1.26633838e-01f, -1.61862448e-01f,
  -8.23571235e-02f, -6.30306229e-02f, 9.79529507e-03f, -1.64379001e-01f, -2.16949284e-01f, -3.21350515e-01f, -2.51199275e-01f, -2.02618867e-01f, -1.42870158e-01f, -1.87873498e-01f,
  -1.80094168e-02f, -2.00912692e-02f, -7.80579448e-02f, -8.57860669e-02f, -6.07841238e-02f, -9.70951766e-02f, -1.85306236e-01f, -1.09891430e-01f, -1.53833643e-01f, -2.26730108e-01f,
  -2.61389196e-01f, 1.45159125e-01f, -8.10853019e-02f, -5.58589920e-02f, 4.18740548e-02f, 6.88658953e-02f, -3.17961387e-02f, 1.13634735e-01f, -9.94550437e-03f, -8.71428773e-02f,
  4.88381684e-02f, -6.88408501e-03f, 5.91466799e-02f, -7.34196146e-05f, -3.79140582e-03f, 5.34620620e-02f, -1.72421988e-03f, -6.54749051e-02f, -6.58576116e-02f, -9.60298702e-02f,
  -1.42243385e-01f, -9.30219516e-02f, -1.13836462e-02f, 6.32132143e-02f, -6.11400567e-02f, 2.04900037e-02f, -1.32545665e-01f, 7.12230280e-02f, -2.82817073e-02f, 5.09766228e-02f,
  -7.75878727e-02f, 6.24974892e-02f, -3.63558307e-02f, 1.59381256e-02f, -4.89067212e-02f, 5.02863601e-02f, -1.17710838e-02f, -5.44702038e-02f, -6.47275895e-02f, 3.70960757e-02f,
  1.16385203e-02f, -1.87536143e-02f, 4.42767292e-02f, 9.76343900e-02f, -9.13518220e-02f, 3.59870680e-02f, -4.99739647e-02f, 2.38326285e-02f, -9.80419219e-02f, 1.18336491e-02f,
  -1.59676522e-02f, -5.26605137e-02f, 4.08961587e-02f, 3.05561405e-02f, -5.99867553e-02f, 1.62907653e-02f, -6.78935573e-02f, -8.92832279e-02f, -2.49510910e-02f, 1.45660387e-02f,
  1.50458887e-01f, -1.80228099e-01f, -1.91982612e-02f, 1.12266652e-01f, -8.17519426e-02f, -3.75098996e-02f, 1.39792953e-02f, -6.52336553e-02f, 3.20079513e-02f, -6.68979809e-02f,
  4.30747569e-02f, -7.03030303e-02f, 7.38848746e-02f, -7.72757307e-02f, -9.06613991e-02f, -8.17667767e-02f, -7.18478812e-03f, -5.38142845e-02f, 4.01734710e-02f, -2.59342138e-02f,
  -1.69039834e-02f, -1.11766100e-01f, 6.40604421e-02f, -7.43917823e-02f, 5.27900048e-02f, 5.68609349e-02f, -5.94986510e-03f, -2.75971200e-02f, -9.64983627e-02f, -1.18626714e-01f,
  1.82297099e-02f, -2.07192793e-01f, -2.76313156e-01f, 3.54606844e-02f, 1.24109671e-01f, -1.73416317e-01f, -2.12451607e-01f, -2.15859324e-01f, 1.22381099e-01f, -7.96929747e-02f,
  7.15528205e-02f, 1.01361446e-01f, -2.98097655e-02f, -9.80717689e-02f, -2.93623954e-01f, -3.30818772e-01f, -2.66975343e-01f, -1.60893127e-01f, -2.06716154e-02f, -1.27150891e-02f,
  6.58425018e-02f, 1.05347440e-01f, -4.97461669e-03f, 1.85752101e-03f, 1.59080252e-01f, 9.88832787e-02f, -6.85261637e-02f, 1.19154260e-01f, 7.70889744e-02f, 9.66630429e-02f,
  6.27390714e-03f, -6.16130838e-03f, 5.13638593e-02f, 1.07605770e-01f, 1.33156359e-01f, -5.60231581e-02f, -7.79179037e-02f, -6.96830973e-02f, 1.84116624e-02f, -7.89139122e-02f,
  2.10373197e-02f, 6.56399205e-02f, -3.24131688e-04f, 3.47817726e-02f, 2.82829907e-02f, -7.83704687e-03f, -1.40649229e-01f, -1.94722623e-01f, -4.34011817e-02f, -9.27874818e-02f,
  1.52641004e-02f, 1.11844480e-01f, -2.07883902e-02f, -1.61589414e-01f, -1.26973376e-01f, -2.07389891e-02f, -6.83365613e-02f, 2.84085590e-02f, -1.89716548e-01f, -2.31781993e-02f,
  9.13409814e-02f, 4.59257439e-02f, 8.12287331e-02f, 6.94579333e-02f, 1.86273176e-02f, 5.28050438e-02f, -2.61468813e-02f, 8.01411420e-02f, -3.84197868e-02f, 2.10050549e-02f,
  -5.61290011e-02f, 3.22230384e-02f, -4.86773103e-02f, -2.17067320e-02f, 4.17603329e-02f, -5.38539439e-02f, 6.81218356e-02f, -1.13409378e-01f, -4.11799587e-02f, 5.92407361e-02f,
  -2.62583746e-03f, 4.40421440e-02f, 2.83755381e-02f, 8.64580926e-03f, -2.85523906e-02f, -1.57002416e-02f, 7.52630606e-02f, -2.07670368e-02f, -8.18626732e-02f, 4.50268239e-02f,
  1.02369078e-01f, -1.26358420e-01f, -6.82013705e-02f, -4.02337015e-02f, -2.71078385e-03f, 5.70770260e-03f, 1.12473883e-01f, 4.93602939e-02f, -6.37549907e-02f, -3.45319211e-02f,
  -3.39536704e-02f, -7.91992545e-02f, -7.10743368e-02f, -2.78771278e-02f, -5.46876825e-02f, 1.15774106e-02f, -1.10767119e-01f, -6.49893209e-02f, -9.28435400e-02f, 4.40903939e-02f,
  -1.11290641e-01f, -1.89294472e-01f, -1.81574196e-01f, -8.02876875e-02f, -4.72645042e-03f, -1.13335840e-01f, -9.82712507e-02f, -2.63602789e-02f, -1.23079628e-01f, -1.41283453e-01f,
  9.54714715e-02f, 2.31340438e-01f, 1.99036039e-02f, 8.82842466e-02f, 4.33418229e-02f, 1.53245077e-01f, 2.52272248e-01f, 8.47656131e-02f, 1.17077604e-01f, 3.09545291e-03f,
  8.66853595e-02f, 8.43743309e-02f, 1.45550385e-01f, 5.37698343e-02f, 1.85192287e-01f, 1.60424337e-01f, 1.39862671e-01f, 8.17445107e-03f, 1.05179235e-01f, 9.06212702e-02f,
  3.76217701e-02f, -6.72595203e-02f, 6.24583922e-02f, 1.11968458e-01f, -4.47086208e-02f, 1.01449363e-01f, -6.64184894e-03f, 3.18909921e-02f, 6.70247525e-02f, 6.62581250e-03f,
  -1.70648009e-01f, 3.06254327e-02f, 7.12612551e-03f, 2.17646305e-02f, -1.16449006e-01f, -5.89756705e-02f, -7.83787295e-02f, -7.15107992e-02f, -3.40233557e-02f, -5.94865531e-02f,
  2.41847499e-03f, -5.45674935e-02f, 8.44397470e-02f, -2.31914278e-02f, -9.21373069e-02f, -6.83933944e-02f, -9.33373198e-02f, -5.00056986e-03f, 2.10093483e-02f, -4.88062650e-02f,
  -2.37763245e-02f, -4.21208255e-02f, 7.31920376e-02f, 5.34449555e-02f, 1.03184357e-01f, -1.11297697e-01f, 4.19883355e-02f, 1.60681847e-02f, 5.60007319e-02f, 7.17002153e-03f,
  -6.46443591e-02f, 2.13969126e-02f, 9.06112343e-02f, 4.43975925e-02f, -4.17099036e-02f, -2.45901514e-02f, -4.31377394e-03f, 6.41382709e-02f, 4.77547124e-02f, 3.15324888e-02f,
  -4.37533334e-02f, -3.56492698e-02f, -6.71181083e-02f, -6.34942725e-02f, -3.30871567e-02f, 3.41303237e-02f, 1.45723755e-02f, -7.35573173e-02f, -8.24109465e-02f, -1.00893350e-02f,
  -3.54942307e-02f, -7.34171122e-02f, -4.36927602e-02f, -8.13726429e-03f, -6.65925890e-02f, -8.84236302e-04f, -3.10819466e-02f, -2.07149070e-02f, 3.51274163e-02f, 5.36163673e-02f,
  2.42449273e-03f, -7.78916329e-02f, -6.55923560e-02f, 8.20103139e-02f, 3.54303941e-02f, 6.08300641e-02f, 7.29516074e-02f, -1.05369516e-01f, 1.87962186e-02f, 9.68817994e-02f,
  -6.71861097e-02f, 8.02763253e-02f, 7.56619200e-02f, 6.33666590e-02f, -8.19736198e-02f, -3.59017663e-02f, -9.48241428e-02f, 1.00998254e-02f, -1.07984873e-04f, 2.09685024e-02f,
  -7.57654533e-02f, 2.92237345e-02f, -6.58871885e-03f, 3.61294001e-02f, -2.53480971e-02f, -7.20928162e-02f, -3.73904109e-02f, 7.31621915e-03f, 4.29577520e-03f, 9.17005166e-03f,
  -2.77401298e-01f, -1.00833990e-01f, 8.22368544e-03f, 5.21535464e-02f, 2.65814513e-02f, 2.44408369e-01f, 1.57367870e-01f, 6.54785484e-02f, 7.47108236e-02f, -7.35377818e-02f,
  -9.76215973e-02f, -3.91748361e-03f, 9.94824469e-02f, 2.33391337e-02f, 6.43085465e-02f, 1.24857001e-01f, 2.03486439e-02f, 8.15570951e-02f, 1.23551369e-01f, 7.63348341e-02f,
  2.47851051e-02f, -7.53432065e-02f, -1.24509543e-01f, 4.83764783e-02f, 4.73393165e-02f, -1.27791492e-02f, 3.32398922e-03f, -1.11230634e-01f, 4.24032696e-02f, 3.48118618e-02f,
  2.39838958e-02f, -1.77480474e-01f, 1.41420335e-01f, -1.50298793e-03f, -5.94803207e-02f, -6.62011802e-02f, 1.23759881e-02f, 6.46869245e-04f, -7.81005397e-02f, 8.32873862e-03f,
  -5.60376607e-02f, -1.34900110e-02f, -2.56239716e-03f, -1.33958571e-02f, -6.30552322e-02f, 4.66028303e-02f, -1.32689059e-01f, -6.10319823e-02f, -5.17943464e-02f, -7.16042295e-02f,
  -8.32244977e-02f, -2.47882456e-02f, 5.87596842e-05f, -1.98632549e-03f, -2.85466183e-02f, -9.10886750e-03f, 2.01949924e-02f, 5.25452010e-02f, -2.01827716e-02f, -9.36535224e-02f,
  2.26011015e-02f, -7.85554796e-02f, 7.10133910e-02f, -6.08039759e-02f, 4.70802784e-02f, 2.66561937e-02f, 1.02517474e-03f, -6.26525059e-02f, 7.72639457e-03f, -5.74354045e-02f,
  7.56632537e-02f, 2.51597483e-02f, -3.42182070e-02f, 4.62991558e-02f, 4.73061278e-02f, 4.12984006e-02f, 1.87001526e-02f, -5.90364374e-02f, 1.06225193e-01f, 3.49034071e-02f,
  3.73749249e-02f, 3.94929051e-02f, -5.45888916e-02f, -6.70700073e-02f, -4.84852418e-02f, -5.38448840e-02f, 9.13123637e-02f, -2.78776102e-02f, -1.20479660e-02f, -4.96832095e-02f,
  -7.84965828e-02f, 6.24973886e-02f, -3.40891816e-02f, 2.40792497e-03f, 1.05048288e-02f, 4.86035645e-02f, -2.12452374e-02f, 4.33702022e-02f, 5.49420565e-02f, 2.88723391e-02f,
  -3.48689742e-02f, -3.76140699e-02f, -9.45230797e-02f, -2.02402137e-02f, 2.58165821e-02f, -1.85525827e-02f, -2.56287418e-02f, 2.07073241e-02f, 6.11662045e-02f, 4.11459468e-02f,
  4.33593057e-02f, 4.81577292e-02f, 8.32417309e-02f, 1.15698658e-01f, 1.09153099e-01f, 9.51800644e-02f, 1.03252586e-02f, -1.15830163e-02f, 5.14617190e-03f, -3.79379801e-02f,
  2.01674670e-01f, -7.74927959e-02f, 7.98845440e-02f, 1.39220953e-01f, 1.62570149e-01f, 1.46669894e-01f, 1.25673771e-01f, 1.58461362e-01f, 4.65204492e-02f, 5.99197894e-02f,
  1.62380323e-01f, 1.62550792e-01f, 2.50898059e-02f, 1.03144847e-01f, 2.42150179e-03f, 6.87550977e-02f, -3.68134193e-02f, -6.42236695e-02f, 7.35843033e-02f, 1.42351180e-01f,
  1.17877588e-01f, 1.92181626e-03f, 2.37630866e-02f, 8.90574455e-02f, 3.67283970e-02f, 2.37519257e-02f, 3.99925262e-02f, 3.47915292e-02f, -1.95563268e-02f, -8.93995818e-03f,
  -5.14904298e-02f, 8.13292712e-02f, 7.78403878e-02f, -1.50672439e-02f, -9.97676551e-02f, -5.13723306e-02f, 2.36284938e-02f, 2.96551976e-02f, 6.61374331e-02f, 3.14797834e-02f,
  -2.11580819e-03f, 5.69445565e-02f, 5.14064506e-02f, -8.58445764e-02f, 2.02466585e-02f, -5.38910031e-02f, -4.70440909e-02f, -4.59759310e-03f, -7.31401071e-02f, -2.07148436e-02f,
  -1.10487472e-02f, 9.12484005e-02f, -5.05640209e-02f, 3.18125561e-02f, -4.69124429e-02f, 3.26542929e-02f, -8.95207450e-02f, -2.28965562e-02f, -8.43494311e-02f, -3.35575715e-02f,
  -1.10648256e-02f, 8.63232091e-02f, 4.70882375e-03f, 5.58794774e-02f, 9.24721733e-02f, -3.97942699e-02f, 7.02112764e-02f, -2.25298591e-02f, 9.69790146e-02f, -1.40733691e-02f,
  -6.64840639e-02f, 7.71394894e-02f, -4.45706844e-02f, -4.87625152e-02f, 8.51733331e-03f, -8.43143016e-02f, 2.02523340e-02f, 5.74854761e-02f, -7.55327269e-02f, -7.70563260e-02f,
  7.12083280e-02f, -8.35789666e-02f, -8.22540522e-02f, 4.68600728e-02f, 5.59478663e-02f, -1.25679933e-02f, 1.28469532e-02f, 5.78634441e-02f, -3.05626579e-02f, -5.76050133e-02f,
  -1.08635634e-01f, -2.64139026e-02f, -3.99960466e-02f, -1.10183492e-01f, -8.09699818e-02f, -9.26732738e-03f, -3.09989974e-02f, -6.67070225e-02f, -5.85894510e-02f, 3.47355641e-02f,
  1.78691745e-02f, 9.99478623e-03f, -5.86535074e-02f, -6.46428987e-02f, -5.14854081e-02f, -4.43072207e-02f, 3.33483666e-02f, -2.02771407e-02f, 2.36791112e-02f, 3.26701254e-02f,
  1.89306159e-02f, 5.17060012e-02f, -2.87163667e-02f, -2.95837633e-02f, -5.55248931e-02f, 1.30515754e-01f, 2.46267170e-02f, 6.42378703e-02f, -5.64295053e-02f, 3.12308464e-02f,
  8.01488981e-02f, -1.64470389e-01f, 1.74627498e-01f, 1.74940720e-01f, 1.85154453e-01f, 2.74742991e-01f, 1.32928252e-01f, 1.62662998e-01f, 1.54429585e-01f, 3.62923332e-02f,
  1.67756341e-02f, 3.44542861e-02f, -6.20129518e-02f, -1.08702227e-01f, -3.99418063e-02f, 1.19773023e-01f, 6.06279355e-03f, 3.55032422e-02f, 1.71094775e-01f, 8.86808708e-02f,
  -1.09540345e-02f, 2.30303849e-03f, 4.60201083e-03f, 1.77133195e-02f, 2.98966337e-02f, 5.34538412e-04f, 8.38888064e-02f, -5.96607104e-02f, 5.65939583e-02f, -8.79254192e-02f,
  -4.52639535e-02f, 1.18412441e-02f, 6.30905405e-02f, -8.36350098e-02f, -9.62948054e-02f, -1.16307698e-01f, -6.46472201e-02f, -9.31608155e-02f, -7.66019970e-02f, 4.60136384e-02f,
  -2.68585212e-03f, -8.00298750e-02f, 3.06108296e-02f, -1.42592657e-02f, -8.45318586e-02f, -2.58886851e-02f, -4.28068079e-02f, -2.08554398e-02f, -5.54521643e-02f, -1.51244700e-02f,
  -7.08779693e-02f, 1.03367426e-01f, 2.87428126e-02f, 8.34256113e-02f, -3.95884104e-02f, 1.07481085e-01f, -8.52566306e-03f, 6.48140535e-02f, 1.10686809e-01f, 8.49603564e-02f,
  -2.09912360e-02f, -2.78137648e-03f, 1.60706341e-02f, 8.39183033e-02f, -2.20406707e-02f, 9.39022675e-02f, 9.96089075e-03f, -2.77289264e-02f, 7.75420889e-02f, 8.40034187e-02f,
  -1.01166544e-02f, 5.59978187e-02f, 5.73851052e-04f, 1.61267798e-02f, -3.66498567e-02f, -5.71684837e-02f, 2.42103301e-02f, -9.54268128e-02f, -6.48343489e-02f, -2.92980578e-02f,
  6.50276914e-02f, 2.34452039e-02f, -4.74394932e-02f, -2.82331798e-02f, -4.79045063e-02f, -5.80702499e-02f, 5.40029109e-02f, 6.61742389e-02f, -5.76092005e-02f, -4.41376641e-02f,
  -9.93749052e-02f, 1.22573758e-02f, 7.42296726e-02f, -2.31786091e-02f, 7.36111924e-02f, 1.42247938e-02f, -5.71522228e-02f, -1.25096649e-01f, -1.05895847e-01f, 5.63384145e-02f,
  -1.02218077e-01f, 1.35683268e-02f, -1.19432658e-01f, -1.90295056e-02f, 1.26791492e-01f, 1.59708597e-02f, -1.47432769e-02f, 6.45814836e-03f, -1.01678967e-01f, -1.39883906e-01f,
  -9.81158242e-02f, 9.23016220e-02f, 1.40451252e-01f, 1.26256060e-03f, 6.26661256e-02f, 1.53664961e-01f, 5.92322499e-02f, 1.59955248e-02f, 1.38734385e-01f, 1.43343121e-01f,
  1.65661708e-01f, -1.81922972e-01f, -2.46814471e-02f, 2.06094280e-01f, 1.72531903e-01f, 2.11009067e-02f, 1.00083694e-01f, 4.40646410e-02f, 8.15563947e-02f, 1.25514954e-01f,
  5.48126400e-02f, 1.25486210e-01f, 1.89168658e-02f, 4.05990891e-02f, -7.58422678e-03f, 5.15093235e-03f, 3.52893062e-02f, 6.04350753e-02f, 7.51816779e-02f, -1.75493192e-02f,
  7.28976279e-02f, -1.42173059e-02f, 6.05311804e-02f, 8.46254975e-02f, -5.60974032e-02f, 6.60342649e-02f, -5.47318310e-02f, 4.98386845e-02f, -9.93971154e-02f, -3.10903564e-02f,
  5.35178594e-02f, -1.05754629e-01f, 1.43602088e-01f, 5.67812659e-02f, 9.03278887e-02f, -5.05335443e-02f, 7.17542842e-02f, -1.05804525e-01f, -8.37470815e-02f, 4.12334204e-02f,
  2.63331877e-03f, 4.78439331e-02f, 4.41163667e-02f, -5.05768433e-02f, -5.49621284e-02f, -6.72000200e-02f, -2.19314154e-02f, 3.36678438e-02f, 1.25710219e-02f, -1.14844456e-01f,
  -9.66213197e-02f, -6.81560859e-02f, 5.59481271e-02f, -7.89843127e-02f, -5.77107705e-02f, -3.41150537e-02f, 3.46137770e-02f, 4.80739959e-02f, -2.01344546e-02f, -4.24307920e-02f,
  1.27673283e-01f, 8.00063834e-02f, 7.56708300e-03f, -1.13223642e-02f, -3.57731692e-02f, -7.74995536e-02f, 3.55440341e-02f, 3.52038606e-03f, -3.24761458e-02f, -5.06136790e-02f,
  3.80460620e-02f, 8.33929479e-02f, 6.47043884e-02f, 2.43427791e-02f, 5.96149080e-02f, 4.44749370e-03f, 2.22972203e-02f, 5.43758012e-02f, 1.16773099e-01f, 1.67586450e-02f,
  -6.69629350e-02f, 1.09049231e-01f, 1.15962736e-01f, -6.24299701e-03f, 1.05532400e-01f, 1.19974054e-01f, 9.48209465e-02f, 6.41727969e-02f, 6.66998103e-02f, 1.50268851e-02f,
  -5.28338086e-03f, 1.66503992e-02f, -1.37655381e-02f, -1.92769319e-02f, -2.35539079e-02f, -9.70870927e-02f, 1.74543075e-02f, 3.35260555e-02f, -2.15956084e-02f, 2.31992975e-02f,
  4.95843589e-02f, -6.60068318e-02f, 1.85069945e-02f, -9.92364287e-02f, 8.68777260e-02f, -1.88067574e-02f, 4.43278849e-02f, -7.38217821e-03f, 1.82661004e-02f, 3.17883998e-04f,
  2.15712562e-02f, 1.59377933e-01f, 5.97257800e-02f, 1.13944896e-01f, 5.55691347e-02f, 1.77698568e-01f, -1.54033024e-02f, 2.18145885e-02f, 1.67786255e-02f, -3.34109962e-02f,
  9.88523127e-04f, 1.62285104e-01f, 1.58705696e-01f, -6.91505207e-04f, 2.17505455e-01f, 2.63612449e-01f, 2.66254604e-01f, 1.50189355e-01f, -9.88867506e-02f, -8.55017267e-03f,
  -1.68386418e-02f, -1.31215915e-01f, -2.19705865e-01f, -1.62377581e-01f, 4.31362651e-02f, -5.86298853e-03f, -5.14054671e-04f, 5.39621264e-02f, -1.71123464e-02f, 8.22249874e-02f,
  -3.17093469e-02f, 4.58923653e-02f, 8.03629160e-02f, -8.34874064e-02f, -9.49296430e-02f, -1.08531071e-03f, 1.18661493e-01f, 1.70804914e-02f, -6.61137924e-02f, -1.86621100e-01f,
  -7.62927309e-02f, 2.03467637e-01f, -1.07365645e-01f, -1.29620954e-01f, -3.04962546e-02f, -8.24426766e-03f, -1.29178343e-02f, 4.67726104e-02f, 6.89062523e-03f, 4.15804796e-03f,
  5.73082156e-02f, 3.45969014e-02f, 9.95262712e-03f, 4.02278230e-02f, 8.62991214e-02f, -2.14754771e-02f, 5.99111393e-02f, -7.35121295e-02f, -1.90237407e-02f, -5.81631996e-02f,
  5.14531620e-02f, 1.02549672e-01f, 2.08188817e-01f, -2.49756053e-02f, -6.39791042e-02f, -6.77457005e-02f, 5.63519746e-02f, -6.21525533e-02f, 1.12626739e-01f, -7.91827440e-02f,
  -3.99357901e-04f, -1.10755973e-01f, 3.86465825e-02f, -3.17702838e-03f, -4.77188304e-02f, -3.35887191e-04f, 1.93746807e-03f, -3.06907967e-02f, -5.64220808e-02f, 4.64218520e-02f,
  1.00205299e-02f, 6.28604665e-02f, -2.02502795e-02f, -1.47142503e-02f, -1.27539486e-01f, 5.63247986e-02f, 8.88587758e-02f, -4.63841669e-03f, 5.50977774e-02f, 2.63879634e-02f,
  -2.85105798e-02f, 4.78225499e-02f, 6.08411282e-02f, 1.98926702e-02f, -9.90807340e-02f, -6.22664839e-02f, -2.87813996e-03f, -3.28845344e-02f, -9.15311556e-03f, -4.52958494e-02f,
  -8.53981450e-02f, 1.42993152e-01f, -1.08279876e-01f, -1.11193724e-01f, 8.87023658e-03f, -2.88334768e-02f, -4.65405127e-03f, -7.45779052e-02f, 2.78180689e-02f, 6.91583678e-02f,
  7.07537755e-02f, 5.69611276e-03f, -4.90558054e-03f, 1.68347210e-02f, 5.08353710e-02f, -5.72357848e-02f, -3.72887179e-02f, 4.78910618e-02f, 4.85272929e-02f, 1.77582204e-02f,
  -8.06822926e-02f, -2.07129121e-02f, 8.47265273e-02f, -1.35477316e-02f, -1.96895152e-02f, -1.07620105e-01f, -2.99780872e-02f, 2.34311484e-02f, -3.95050226e-03f, -2.85136905e-02f,
  5.01688831e-02f, -2.95048863e-01f, 1.10459581e-01f, 7.31061175e-02f, 1.34961689e-02f, -1.95283778e-02f, -9.66015980e-02f, -5.07863387e-02f, 5.23856049e-03f, -1.30867168e-01f,
  -5.14912233e-02f, -8.60547274e-02f, -9.13547203e-02f, -4.35190387e-02f, -7.09698861e-03f, -9.57848206e-02f, 1.12595513e-01f, 1.52642354e-01f, 1.28224850e-01f, 2.17133090e-02f,
  -2.88325865e-02f, -4.65822034e-02f, -3.53791602e-02f, -8.33353847e-02f, -1.46863028e-01f, 8.81444514e-02f, 2.12970823e-02f, -2.01372895e-02f, -7.73379952e-02f, -1.32097090e-02f,
  2.68341117e-02f, -5.80204688e-02f, 9.40442085e-02f, -4.85931672e-02f, 3.72547321e-02f, -3.68365273e-02f, -9.33414400e-02f, 1.69284362e-02f, 2.52752192e-02f, 9.18319263e-03f,
  -1.18501641e-01f, -1.10923156e-01f, -1.03606060e-02f, -3.24253961e-02f, -3.38021070e-02f, 7.26149902e-02f, 2.33607180e-02f, 1.73636526e-02f, -6.03835506e-04f, -1.63165778e-01f,
  -6.34005368e-02f, 4.90887687e-02f, 3.06993723e-02f, 6.09290972e-02f, 4.52328213e-02f, 8.73473436e-02f, -8.54192749e-02f, 4.96959053e-02f, 8.21008757e-02f, -1.80987790e-02f,
  -2.78586559e-02f, 6.35080859e-02f, -5.78380143e-03f, -2.71103140e-02f, -5.73367951e-03f, 6.98107257e-02f, 2.89819972e-03f, -4.29166369e-02f, -5.21139726e-02f, -7.21857771e-02f,
  1.46261770e-02f, 6.86412305e-02f, -5.18766567e-02f, 7.68569252e-03f, 7.56534413e-02f, -4.55268174e-02f, -9.11478233e-03f, 5.44503592e-02f, -3.22798751e-02f, -6.91633970e-02f,
  -3.08591239e-02f, 4.35560234e-02f, 4.69448045e-02f, -3.95990387e-02f, -1.09027736e-01f, -5.73656857e-02f, -9.76955146e-03f, -5.60678430e-02f, -8.30686539e-02f, -1.44534474e-02f,
  -4.95265387e-02f, 1.43012032e-01f, 1.30508533e-02f, -9.14990678e-02f, 9.29700956e-02f, -4.85238843e-02f, -2.98701860e-02f, -6.28246740e-02f, -3.07056960e-02f, 5.54041751e-03f,
  -1.16737776e-01f, -7.80218989e-02f, -4.94557917e-02f, 4.40104213e-03f, 3.57947946e-02f, 5.34179434e-02f, 2.36200932e-02f, 7.26607889e-02f, -3.45486663e-02f, -7.59751350e-02f,
  -4.53433618e-02f, 1.19991086e-01f, 6.15463853e-02f, -1.84626635e-02f, 2.11233962e-02f, 1.68850407e-01f, 4.92726900e-02f, 1.26232952e-01f, 1.06262885e-01f, 1.41314000e-01f,
  1.28763884e-01f, 1.34038582e-01f, -1.16337359e-01f, 4.99651618e-02f, 5.93540780e-02f, 2.79297866e-02f, -4.94026765e-02f, -4.13179882e-02f, 1.00392565e-01f, 2.78027318e-02f,
  1.83818609e-01f, 5.81220817e-03f, 5.72147891e-02f, -2.68844068e-02f, -9.62826088e-02f, -5.56215383e-02f, -2.00139005e-02f, 5.46913967e-02f, -5.81033193e-02f, -4.14199531e-02f,
  1.62965328e-01f, 2.18050592e-02f, -4.18147668e-02f, -5.04380502e-02f, 9.90885645e-02f, 5.07186912e-02f, 9.23712552e-02f, 1.18737847e-01f, 1.12756275e-01f, 9.13935304e-02f,
  1.41230881e-01f, 7.98748210e-02f, -1.32453050e-02f, 1.01348013e-01f, -3.22804041e-03f, 6.36617246e-04f, 5.45738358e-03f, -1.01857074e-01f, 6.91139549e-02f, -3.13023329e-02f,
  2.99756378e-02f, 6.89020231e-02f, -6.11309670e-02f, 5.47110997e-02f, 6.77103475e-02f, -8.04559216e-02f, -1.12466879e-01f, -1.40869722e-01f, -7.19713122e-02f, 3.09067760e-02f,
  9.88383591e-02f, 7.93211833e-02f, 5.18419333e-02f, -6.18321188e-02f, -8.83182064e-02f, -3.89202610e-02f, -1.10348603e-02f, -4.38073277e-02f, -3.24537680e-02f, -1.08851254e-01f,
  1.40650580e-02f, 3.81871760e-02f, 6.61945120e-02f, 8.89265165e-02f, -3.62300314e-02f, -1.42903067e-02f, 4.02608253e-02f, -1.50315985e-02f, 9.03981850e-02f, -3.41596715e-02f,
  -3.71492952e-02f, 1.04032107e-01f, 1.22674424e-02f, -3.71106602e-02f, 6.13313876e-02f, 2.56542824e-02f, 5.77096269e-02f, -3.24379764e-02f, 1.08919837e-01f, 7.37034753e-02f,
  6.63306415e-02f, -4.61667366e-02f, -2.59772576e-02f, -6.21964894e-02f, 4.19102758e-02f, 5.04067764e-02f, -5.73583879e-02f, 2.31780391e-02f, 2.28753667e-02f, 4.80286665e-02f,
  2.59820409e-02f, 4.54271585e-03f, 2.19527781e-02f, 1.48628484e-02f, -1.68162603e-02f, -6.12944402e-02f, 1.44567983e-02f, 9.60152596e-03f, -5.04013970e-02f, -1.20787148e-03f,
  -1.57029089e-02f, -2.01317910e-02f, 2.77282260e-02f, -3.05863526e-02f, -7.71177560e-02f, 6.16535023e-02f, 9.22680050e-02f, 7.97377154e-02f, 8.51344317e-03f, -2.85216924e-02f,
  1.17212906e-02f, 3.83038409e-02f, -8.45395699e-02f, -7.93443546e-02f, 7.31744617e-02f, -3.84308323e-02f, -1.53905088e-02f, -2.66610626e-02f, -1.30207703e-01f, 3.33645451e-03f,
  -2.79357553e-01f, 3.00720651e-02f, 1.09681100e-01f, -3.38072330e-03f, 2.51637727e-01f, 2.39479348e-01f, 2.97328681e-01f, 3.83895449e-02f, 9.46409628e-02f, -2.51004267e-02f,
  -6.68100044e-02f, -1.21313869e-03f, -2.26335879e-02f, -8.87507796e-02f, -3.86646427e-02f, 1.52412489e-01f, 1.15534090e-01f, 5.92235029e-02f, -6.05171211e-02f, 5.26297688e-02f,
  -3.63667347e-02f, -2.28748694e-02f, -1.65097445e-01f, -8.40403438e-02f, -9.86331999e-02f, -6.31733909e-02f, -5.82466871e-02f, -6.70210868e-02f, 6.53082952e-02f, -5.84209450e-02f,
  -8.90343636e-02f, -5.40859159e-03f, 4.88667525e-02f, -7.62986094e-02f, -3.30832191e-02f, -1.15589939e-01f, 2.26610694e-02f, -9.22247544e-02f, -9.95277837e-02f, -9.13367793e-02f,
  2.28093900e-02f, -1.09865822e-01f, 2.57123429e-02f, -1.00156642e-01f, -8.11387450e-02f, -4.68672775e-02f, 1.27692092e-02f, -1.16720293e-02f, -9.50802043e-02f, -7.74548426e-02f,
  -3.20462175e-02f, 3.18640694e-02f, -4.43963967e-02f, -2.51174048e-02f, 3.10134999e-02f, 6.39060512e-02f, -7.60535672e-02f, 6.41151592e-02f, -7.68673271e-02f, -1.64814778e-02f,
  -4.99624126e-02f, -6.65219575e-02f, 1.69378929e-02f, -2.27216370e-02f, -8.36920086e-03f, -4.75190058e-02f, 8.68457109e-02f, 4.20073234e-02f, 6.82163760e-02f, 1.78916156e-02f,
  3.15767638e-02f, -2.44300421e-02f, -1.01484276e-01f, 1.36118876e-02f, -1.10814460e-01f, -1.13315443e-02f, 5.84313758e-02f, -5.37238456e-02f, -7.10101649e-02f, 5.14488928e-02f,
  -1.57597791e-02f, -2.93863919e-02f, -2.12290697e-02f, 1.13345147e-03f, -7.07351938e-02f, -5.88228786e-03f, -8.90218094e-02f, -5.77517338e-02f, -4.18872871e-02f, 6.57778932e-03f,
  -6.05869405e-02f, 5.28830849e-02f, -1.31565984e-02f, -9.10119712e-02f, 1.27224894e-02f, -7.44695542e-04f, 5.82863875e-02f, -1.94974132e-02f, 3.80388014e-02f, -6.91054985e-02f,
  -2.58972887e-02f, -1.04898751e-01f, -1.09418370e-01f, -1.58212185e-02f, 6.09264821e-02f, 8.99108350e-02f, 2.67278068e-02f, -3.16789187e-02f, 1.43015236e-02f, 8.98597986e-02f,
  -3.52929607e-02f, 2.23131645e-02f, 6.23818301e-02f, 6.25634268e-02f, 1.48063982e-02f, 4.53319140e-02f, 2.23814957e-02f, 9.62702371e-03f, 1.09972566e-01f, 9.49089602e-02f,
  -2.39268050e-01f, -3.63854459e-03f, 8.58051032e-02f, -2.14963377e-01f, -2.72782724e-02f, 1.46136861e-02f, 1.67162910e-01f, -5.62765114e-02f, -3.15649770e-02f, -2.13351063e-02f,
  1.02594197e-01f, -7.89549276e-02f, -5.63503914e-02f, -6.55063242e-02f, 1.18932677e-02f, 6.59370273e-02f, -1.88277066e-02f, -8.58614892e-02f, -1.21310748e-01f, 3.74322981e-02f,
  -1.29439875e-01f, -8.50041956e-02f, -1.36396080e-01f, 8.01412947e-03f, -1.04274951e-01f, -1.69068530e-01f, 5.18948771e-02f, 3.88929620e-02f, 1.46751981e-02f, -8.92424732e-02f,
  6.40896410e-02f, -1.33866668e-02f, -5.51450439e-02f, -1.15763292e-01f, 2.91917864e-02f, -3.92322391e-02f, -1.81669891e-02f, -1.05965465e-01f, -4.86279726e-02f, -1.30684255e-02f,
  1.15885132e-03f, 2.68146340e-02f, -9.09513310e-02f, 9.36111063e-02f, -3.14161144e-02f, 8.78147632e-02f, -3.54717858e-02f, 5.83950318e-02f, 4.83864248e-02f, 6.39342219e-02f,
  -7.77772348e-03f, -2.97880154e-02f, 7.02383667e-02f, 1.29227996e-01f, 7.35640526e-02f, -6.20167926e-02f, 3.21785398e-02f, 6.96479762e-03f, 1.67431645e-04f, 9.45384055e-03f,
  4.92993072e-02f, 1.68767627e-02f, 6.95994049e-02f, 4.53514755e-02f, -4.05772366e-02f, 5.77023476e-02f, 2.01658290e-02f, 8.34569708e-03f, -4.37617209e-03f, -1.13162488e-01f,
  -8.46240371e-02f, 5.97170144e-02f, -3.78671773e-02f, -1.08208984e-01f, -6.33257553e-02f, 4.49988432e-02f, 5.63067123e-02f, 7.57351145e-02f, 1.79212857e-02f, -1.01613469e-01f,
  -4.09452394e-02f, -1.32046035e-02f, -2.84901331e-03f, 6.58054277e-02f, 9.33132842e-02f, 3.93244475e-02f, 3.18500325e-02f, 7.43906125e-02f, 3.65769379e-02f, 4.05984297e-02f,
  -1.53886437e-01f, 3.55195184e-03f, -8.23667198e-02f, -1.19147465e-01f, 2.16544457e-02f, -2.35011932e-02f, 2.37294585e-02f, -7.43684992e-02f, -6.82343096e-02f, -1.90018155e-02f,
  -4.15340299e-03f, 1.38953300e-02f, 2.80466937e-02f, 3.54389176e-02f, -7.57646039e-02f, -1.33009050e-02f, -6.29584268e-02f, -1.16846815e-01f, 4.38956432e-02f, -1.12017440e-02f,
  -3.01083680e-02f, 2.00929716e-02f, -5.23994006e-02f, -4.75189015e-02f, 7.21800700e-02f, -2.13853754e-02f, 4.75184992e-02f, -1.08220078e-01f, 8.31784233e-02f, 3.51775847e-02f,
  5.00190593e-02f, 2.76748259e-02f, -2.93360874e-02f, 3.77260172e-03f, -4.20161784e-02f, -4.38473001e-02f, -7.54899606e-02f, -6.56895563e-02f, -1.52295697e-02f, -3.88457328e-02f,
  -1.05628707e-01f, -1.39979064e-01f, -9.83193219e-02f, -1.32423081e-02f, 7.72764310e-02f, 3.69969904e-02f, 3.87309827e-02f, 2.90168379e-03f, -5.06945048e-03f, -3.30102928e-02f,
  4.75077443e-02f, 8.12912211e-02f, 1.80825852e-02f, 2.90991156e-03f, 8.70352834e-02f, -9.14174840e-02f, 4.40410413e-02f, 6.42420873e-02f, -4.19803075e-02f, 1.11662365e-01f,
  -1.50054753e-01f, -3.09484638e-02f, 5.27389757e-02f, 4.51805256e-02f, -1.08920457e-02f, 3.32440548e-02f, -1.04772419e-01f, -4.73917499e-02f, -4.98388987e-03f, 1.04294354e-02f,
  2.61569899e-02f, 4.41721678e-02f, -9.00838524e-02f, -2.03857813e-02f, 5.57605550e-02f, -1.73152629e-02f, -4.65019867e-02f, 1.05226738e-02f, 1.10183097e-01f, -1.62813030e-02f,
  -1.13392873e-02f, -1.61025804e-02f, -5.63183874e-02f, 7.42527395e-02f, -2.98725404e-02f, -1.04782298e-01f, 7.39238784e-02f, 8.12972561e-02f, 1.43676242e-02f, 1.16303161e-01f,
  5.07091396e-02f, 2.52875127e-02f, -6.64685965e-02f, 2.61039678e-02f, 1.03413220e-03f, -6.79726005e-02f, -4.93045114e-02f, -7.66405836e-02f, 5.49342707e-02f, -7.40060657e-02f,
  9.14262384e-02f, 2.29059458e-02f, -2.72414517e-02f, 9.50699821e-02f, -2.09298283e-02f, 9.09555554e-02f, 9.10898745e-02f, -3.40417698e-02f, -4.27264869e-02f, 5.39502949e-02f,
  6.24132948e-03f, 2.24532094e-02f, -5.65237589e-02f, 5.67790866e-02f, 2.43313480e-02f, -2.09192489e-03f, -6.72890097e-02f, 8.53729397e-02f, -8.57226178e-02f, -1.05899498e-02f,
  -1.33477017e-01f, -9.18362215e-02f, -3.22408862e-02f, -9.98758152e-03f, -9.61947218e-02f, 9.89134461e-02f, -3.04071885e-02f, -6.00093119e-02f, -5.12005985e-02f, -1.03385951e-02f,
  -5.53935692e-02f, -6.62343577e-02f, -1.17785394e-01f, 3.62324864e-02f, 2.18573567e-02f, -1.03898942e-01f, 3.40817906e-02f, -9.05143172e-02f, 2.86619030e-02f, -4.66145538e-02f,
  -8.50595161e-02f, -5.17310575e-02f, -8.46442953e-03f, -8.18386227e-02f, 1.76032055e-02f, -1.36383787e-01f, 3.11430935e-02f, -8.20577070e-02f, -8.77154171e-02f, -5.47896475e-02f,
  -3.55775319e-02f, -6.30046427e-02f, 1.40816435e-01f, -5.50327823e-02f, -1.72873482e-01f, -2.56405890e-01f, -1.36660859e-01f, -1.43373072e-01f, -5.91533557e-02f, -4.88269478e-02f,
  1.84225794e-02f, -5.69926798e-02f, -2.17543617e-02f, -7.33049512e-02f, -7.88456947e-02f, -4.11265381e-02f, 3.60665880e-02f, 1.21919394e-01f, 1.10111162e-01f, -7.20381811e-02f,
  -5.80043010e-02f, -3.22371833e-02f, 9.17301103e-02f, 6.04019016e-02f, 7.17669725e-02f, -1.10190967e-02f, 1.18891738e-01f, 4.42320444e-02f, 3.60566191e-02f, 8.82163644e-02f,
  1.95941657e-01f, -2.84237657e-02f, -7.23780021e-02f, -3.27266492e-02f, 3.91715541e-02f, -2.62016170e-02f, -6.77514449e-02f, 1.21066399e-01f, 5.90638928e-02f, -7.75344595e-02f,
  4.98528033e-02f, 6.70153052e-02f, -9.53079090e-02f, -1.07061766e-01f, 4.84263115e-02f, -3.95920463e-02f, 4.48926119e-03f, 1.10556796e-01f, 6.35447726e-02f, 1.83657631e-02f,
  -2.15296838e-02f, -1.43698677e-01f, 7.06917271e-02f, 1.73414946e-02f, 2.11557876e-02f, 3.64259370e-02f, -3.98831926e-02f, -3.17055616e-04f, 8.33840370e-02f, 4.07174835e-03f,
  -4.84166443e-02f, -1.66643783e-02f, -3.34218331e-02f, -1.22049330e-02f, 1.26290768e-02f, 8.40468556e-02f, -3.83669301e-03f, -1.51176378e-02f, -3.94889899e-02f, 1.34392921e-02f,
  5.08029051e-02f, -2.22219229e-02f, -3.18174176e-02f, 5.40180840e-02f, 8.00974742e-02f, 1.47147961e-02f, 3.87118272e-02f, -5.73979840e-02f, -1.14089120e-02f, 2.65835281e-02f,
  -3.13900132e-03f, -4.49608192e-02f, 1.08863637e-01f, 4.55190949e-02f, 8.59206915e-02f, 3.85853276e-02f, -1.34590501e-02f, -4.51515242e-02f, -7.23010600e-02f, -1.54253524e-02f,
  1.49523005e-01f, -8.33450537e-03f, -2.48174928e-02f, 1.08217150e-02f, -3.16152796e-02f, 2.41804421e-02f, -8.09156224e-02f, -1.48160160e-02f, 2.65158452e-02f, -1.29488725e-02f,
  -9.98412892e-02f, 1.73924323e-02f, -4.67944890e-02f, 2.59697146e-04f, -1.34091293e-02f, -1.17758833e-01f, -1.17331833e-01f, -2.01498512e-02f, -1.01595506e-01f, -6.26829714e-02f,
  -1.01499669e-01f, -1.41581953e-01f, -6.15892038e-02f, 3.38568948e-02f, -4.45108563e-02f, 1.00076059e-02f, -2.97834892e-02f, 1.97647568e-02f, -9.31307971e-02f, -5.22730649e-02f,
  -2.53275260e-02f, 4.78162207e-02f, -4.09516059e-02f, -1.53869996e-02f, -3.16237845e-02f, -1.04340047e-01f, -1.56742379e-01f, -9.75734612e-04f, -5.38215414e-02f, -8.95617455e-02f,
  7.69059062e-02f, -4.91140317e-03f, -3.15257311e-02f, -3.85858752e-02f, -4.95223440e-02f, -1.02394462e-01f, -1.19150177e-01f, -8.71174131e-03f, 2.90815402e-02f, -1.22245349e-01f,
  3.27146091e-02f, 5.51066883e-02f, 6.70075342e-02f, -7.84292668e-02f, -2.98667438e-02f, -3.46329287e-02f, -3.99419479e-02f, 8.56152773e-02f, -6.09486084e-03f, 7.58395949e-03f,
  1.67868380e-02f, -4.75696698e-02f, -8.62375498e-02f, 6.09564297e-02f, 2.59689298e-02f, -6.18034229e-02f, -6.70688823e-02f, -8.22082311e-02f, 5.44847287e-02f, 1.05628734e-02f,
  7.79525563e-02f, -6.62269294e-02f, -4.51877564e-02f, -6.88568875e-02f, -6.87712207e-02f, -9.33565274e-02f, 1.72804799e-02f, -3.83716123e-03f, 1.96369700e-02f, 6.11726567e-02f,
  9.17242914e-02f, 4.13074046e-02f, 2.91082468e-02f, -9.69119295e-02f, -5.48612177e-02f, -7.78415054e-02f, -5.30915968e-02f, 4.71910927e-03f, -2.34523751e-02f, -1.18643731e-01f,
  -6.91747591e-02f, -3.74789648e-02f, -1.66362673e-02f, -6.56351298e-02f, 6.29383475e-02f, 3.38305421e-02f, -2.33113002e-02f, 7.52731338e-02f, 1.47269554e-02f, 6.21286929e-02f,
  -1.56384166e-02f, -5.10997251e-02f, 6.51731491e-02f, 1.98665890e-03f, 3.12441271e-02f, 2.30579618e-02f, -4.34905104e-02f, -9.20859426e-02f, 5.33737754e-03f, 3.89298834e-02f,
  6.43691644e-02f, 6.00497648e-02f, 3.82813253e-03f, -6.71909600e-02f, 6.60099015e-02f, 1.37867611e-02f, -8.91808420e-02f, -7.22479224e-02f, 4.31246050e-02f, -5.12563363e-02f,
  5.27344551e-03f, 1.03971720e-01f, 4.72073071e-02f, -1.21191375e-01f, 6.68852702e-02f, 2.04697135e-03f, -4.40501422e-02f, 9.20107141e-02f, 8.03163424e-02f, 7.88204931e-03f,
  7.35283196e-02f, -7.97468517e-03f, -7.01969564e-02f, -3.84342596e-02f, 3.68300937e-02f, -4.20416072e-02f, -8.21027532e-02f, -1.56636499e-02f, 5.71880862e-02f, -2.52366737e-02f,
  1.03844628e-02f, -1.21482484e-01f, -1.41159827e-02f, -2.43452354e-03f, 3.60023566e-02f, -3.37643176e-02f, -7.53106251e-02f, -2.47065388e-02f, -6.37246221e-02f, -7.77816921e-02f,
  4.46783841e-01f, 2.54914939e-01f, 7.84344152e-02f, 8.72325003e-02f, -4.96038422e-02f, -1.44398361e-01f, -1.14258006e-01f, 8.76359735e-03f, -6.48887455e-02f, 1.23337761e-01f,
  1.52215600e-01f, 4.91245911e-02f, -9.95998085e-02f, 1.81986019e-02f, -1.37493163e-02f, -2.60449015e-02f, 4.05676924e-02f, 4.25124764e-02f, -3.46725719e-04f, -8.21198430e-03f,
  8.08513686e-02f, 1.76941648e-01f, 1.65677443e-01f, 1.17261693e-01f, 8.33604336e-02f, -2.90915817e-02f, 4.52071838e-02f, 1.21193297e-01f, 1.39291883e-01f, 2.64921665e-01f,
  1.28480211e-01f, 2.71761686e-01f, -2.38631219e-01f, 3.29457074e-02f, 1.16665727e-02f, 5.44588491e-02f, 5.68564571e-02f, -8.01273212e-02f, 7.55655840e-02f, 4.92818281e-02f,
  6.94415718e-02f, -5.26969554e-03f, 9.45000052e-02f, 3.82688944e-03f, 6.75342456e-02f, 1.58161167e-02f, 3.90746966e-02f, -7.77443498e-02f, -8.52258205e-02f, 1.23393007e-01f,
  -1.54298069e-02f, 1.16043285e-01f, 5.28856069e-02f, -1.13792174e-01f, -7.34819695e-02f, -5.50219975e-02f, -2.62460727e-02f, -6.06785417e-02f, -5.51759684e-03f, 1.28561124e-01f,
  2.97529660e-02f, 3.61239836e-02f, 6.33090688e-03f, 9.17360038e-02f, -2.30441783e-02f, -1.57362819e-02f, -9.13157221e-03f, 4.93770316e-02f, -1.93594117e-02f, 5.02291275e-03f,
  1.35706281e-02f, 7.11550098e-03f, -4.06373404e-02f, -6.48196414e-02f, 6.75027966e-02f, 8.88126493e-02f, 1.70095079e-02f, -2.07239715e-03f, -5.73163256e-02f, 3.88622954e-02f,
  5.10444865e-02f, 7.85091743e-02f, 4.97768400e-03f, 1.69649608e-02f, -1.58962272e-02f, -4.26175306e-03f, -3.39406393e-02f, 4.45073172e-02f, -1.83665063e-02f, 1.14203528e-01f,
  -1.27320454e-01f, -1.63124070e-01f, -3.38862278e-02f, 4.05136496e-02f, 3.89052331e-02f, -6.46058694e-02f, 7.63188989e-04f, -6.77334517e-02f, 4.74103764e-02f, 5.48579656e-02f,
  6.04979321e-02f, 1.37241110e-02f, -2.41551511e-02f, -8.58493969e-02f, -9.30969566e-02f, -1.85402029e-03f, -7.47775882e-02f, -8.99280980e-02f, -6.57591447e-02f, -4.83579263e-02f,
  1.77446492e-02f, -1.17205568e-01f, -1.58403382e-01f, -7.13134557e-02f, -6.49740845e-02f, -1.06900789e-01f, -3.53393070e-02f, -1.40191376e-01f, -1.33017212e-01f, -7.76461065e-02f,
  -9.93764549e-02f, -1.62636444e-01f, -8.50641355e-02f, -2.20910802e-01f, -1.12814605e-01f, -3.94581147e-02f, 2.07369607e-02f, -5.50319478e-02f, -9.68316123e-02f, -8.57527703e-02f,
  2.62076687e-02f, 3.66039835e-02f, 4.53758240e-02f, 4.39534262e-02f, 1.06798202e-01f, -4.90203779e-03f, -2.03313883e-02f, -2.17718910e-02f, -7.75302527e-04f, 6.50171414e-02f,
  -6.90535903e-02f, -5.02979755e-02f, -4.25901497e-03f, -1.19976729e-01f, -2.06909269e-01f, 1.92534886e-02f, -1.66887477e-01f, -5.26579134e-02f, -5.89635735e-03f, -7.78888017e-02f,
  -1.81056470e-01f, 5.24474755e-02f, 1.48646245e-02f, 8.46791789e-02f, -3.69781777e-02f, 5.90203665e-02f, 8.30343738e-02f, -1.32791221e-01f, -8.20445791e-02f, -1.12192467e-01f,
  6.64172024e-02f, 5.44820800e-02f, 3.09324209e-02f, 7.84026575e-04f, -3.28170061e-02f, 6.39505833e-02f, 4.74451343e-03f, -6.18152134e-02f, 3.47237401e-02f, 4.09662835e-02f,
  1.26673654e-01f, -6.13684906e-03f, 9.18021649e-02f, -6.64910814e-03f, 4.17113341e-02f, 8.03515837e-02f, -2.05938891e-03f, 5.19259423e-02f, 9.00122970e-02f, -1.09665833e-01f,
  -3.74363475e-02f, 6.07080087e-02f, 1.19569115e-02f, 6.10837229e-02f, 6.84684440e-02f, 6.71866909e-02f, -6.42177761e-02f, -1.69829023e-03f, -3.45306247e-02f, 5.86741185e-03f,
  -1.39408354e-02f, 2.40038931e-02f, 1.11685405e-02f, 5.08427881e-02f, 5.18308617e-02f, -4.71257791e-02f, 2.02912055e-02f, -8.17661881e-02f, -4.95819701e-03f, -7.76151642e-02f,
  1.04433566e-01f, -1.32740382e-03f, -1.10265568e-01f, -1.51187051e-02f, -2.41967831e-02f, -2.16294336e-03f, -5.02674468e-02f, 1.98887680e-02f, -6.78776875e-02f, 5.88367097e-02f,
  -1.67414516e-01f, 1.80655688e-01f, 1.49554887e-03f, 5.53639494e-02f, 9.46402177e-03f, -1.00845456e-01f, 7.19384104e-02f, -8.14158842e-02f, 1.67724595e-03f, 2.91121807e-02f,
  3.92988771e-02f, -8.13740417e-02f, 2.74905078e-02f, -1.05119452e-01f, 8.05627368e-03f, 2.62655877e-02f, 2.82605626e-02f, -4.80631962e-02f, -1.21656293e-02f, 4.30553034e-02f,
  -2.91090254e-02f, 8.60821530e-02f, 1.19368359e-01f, 2.81444788e-02f, 6.98050112e-02f, 8.55854601e-02f, 8.19462836e-02f, 1.90031361e-02f, 8.06170776e-02f, -6.04067333e-02f,
  -2.16018632e-01f, -1.42516255e-01f, -1.32768368e-02f, -1.22597709e-01f, -4.60780561e-02f, -3.56776305e-02f, -1.06333988e-02f, -1.26453474e-01f, -1.65635839e-01f, -1.37274697e-01f,
  2.05561332e-02f, -3.89109515e-02f, -8.10858607e-02f, 7.03086331e-02f, 2.08686013e-02f, -7.06416816e-02f, -1.42176345e-01f, 2.35570665e-03f, -4.22017388e-02f, -9.85592753e-02f,
  -8.91934335e-02f, -4.81665619e-02f, -1.94438487e-01f, -1.11117557e-01f, -1.18837699e-01f, -3.90563086e-02f, -1.07165702e-01f, -8.25253129e-02f, 1.46073131e-02f, -7.61682540e-02f,
  1.63043588e-01f, -6.80846125e-02f, 1.14866020e-02f, -1.87373273e-02f, -4.24164310e-02f, -7.84702525e-02f, 9.86932125e-03f, -4.64894846e-02f, 8.67303647e-03f, 1.05974507e-02f,
  7.50885978e-02f, 8.33067298e-02f, 1.34596350e-02f, -9.22438595e-03f, 3.95608842e-02f, -3.82593758e-02f, -1.56840626e-02f, -1.11475058e-01f, -9.50644314e-02f, -3.80524211e-02f,
  -6.37466684e-02f, -3.94195281e-02f, -4.24221233e-02f, -7.48305842e-02f, -9.42231789e-02f, 5.24961464e-02f, -3.13781910e-02f, -6.02817871e-02f, -1.07276976e-01f, -1.43200979e-01f,
  5.87355085e-02f, 1.84830297e-02f, -9.89137590e-02f, 2.81355493e-02f, -8.13229382e-02f, 3.03405169e-02f, 4.32905518e-02f, -3.85874920e-02f, -5.88417239e-02f, -1.03274502e-01f,
  7.81548470e-02f, 7.69275427e-02f, -9.79935303e-02f, 2.51349863e-02f, -7.26810992e-02f, 5.13919890e-02f, 2.95865238e-02f, -3.27251689e-03f, 6.40991703e-02f, -8.06305632e-02f,
  -9.16135311e-02f, 6.07582070e-02f, -3.11850221e-04f, -1.25322863e-02f, -8.60830862e-03f, 4.22681272e-02f, -1.55078135e-02f, 6.32398427e-02f, 5.04660383e-02f, -7.77187869e-02f,
  1.27103822e-02f, -4.28503286e-03f, -6.11755811e-02f, -1.01000734e-01f, -4.27310169e-02f, -7.42730498e-02f, 3.84053419e-04f, -6.31870478e-02f, 8.50480720e-02f, 3.47229578e-02f,
  6.98072985e-02f, -8.51140916e-03f, -1.44374650e-02f, 9.32276671e-05f, -9.06780362e-02f, 2.50782855e-02f, -6.20635785e-02f, -4.81466167e-02f, 8.54813959e-03f, -3.75076719e-02f,
  -8.73158500e-02f, -1.66772231e-01f, -1.19078062e-01f, -8.94661695e-02f, 3.60577516e-02f, -2.02696081e-02f, 1.26688341e-02f, 1.87121779e-02f, -1.16292752e-01f, -2.21146375e-01f,
  -3.41777235e-01f, 9.46938619e-02f, -1.12911478e-01f, 2.40707118e-02f, 1.84452280e-01f, 1.57609835e-01f, 1.90743819e-01f, 2.30398387e-01f, 7.57072493e-02f, 1.08577050e-01f,
  2.67560482e-02f, 9.56560969e-02f, 8.58995039e-03f, 8.04435983e-02f, 1.57431543e-01f, 1.28760949e-01f, 1.48191243e-01f, 6.40301853e-02f, 4.73181196e-02f, 7.80309588e-02f,
  1.78193793e-01f, -3.16296481e-02f, -5.48885651e-02f, -1.26847001e-02f, 9.61880013e-02f, 2.47073621e-02f, 3.70627493e-02f, 7.26051703e-02f, 9.54732895e-02f, 4.14578766e-02f,
  -2.60108501e-01f, -1.68516487e-01f, -4.43924889e-02f, -2.02077776e-02f, -6.19200617e-03f, -1.03634402e-01f, -1.05065338e-01f, -2.60254485e-03f, -8.51346776e-02f, 6.69281632e-02f,
  4.74805832e-02f, 7.92368222e-03f, -1.58528611e-02f, -8.77122059e-02f, 5.21930866e-02f, 5.35614090e-03f, -9.85044017e-02f, 3.99485379e-02f, -9.44964704e-04f, 2.78870761e-02f,
  4.78448346e-02f, 1.03836654e-04f, 1.01206014e-02f, 4.39728536e-02f, -4.38471995e-02f, 1.91649366e-02f, -1.01385057e-01f, -1.01748846e-01f, -1.28432363e-01f, -8.87585357e-02f,
  1.51716201e-02f, 1.02745015e-02f, 8.78391862e-02f, -1.70859359e-02f, -2.91701034e-02f, -9.27367806e-03f, -2.96152607e-02f, 6.95492700e-02f, -4.44398336e-02f, -7.34884590e-02f,
  -6.22318052e-02f, -4.00405377e-02f, -7.29381815e-02f, 7.87758157e-02f, 4.31263745e-02f, -9.87000205e-03f, -6.01123348e-02f, 7.39711821e-02f, -6.22305423e-02f, -7.73621947e-02f,
  3.57572059e-03f, 3.39681143e-03f, -6.72538429e-02f, -1.17588472e-02f, 8.64855573e-02f, -3.07915080e-02f, 4.52988818e-02f, 3.44659504e-03f, 3.93792801e-02f, -7.39972442e-02f,
  5.23240538e-03f, -3.48546630e-04f, -7.12319985e-02f, 3.17015946e-02f, 6.84556961e-02f, 3.86845954e-02f, 7.45726153e-02f, 1.52112572e-02f, -4.17368785e-02f, -3.48939039e-02f,
  8.87819752e-03f, -9.07925144e-03f, 3.51576284e-02f, 1.45532023e-02f, -9.66265723e-02f, -3.74741256e-02f, 5.40741570e-02f, 1.38048623e-02f, 3.80640030e-02f, -8.74021575e-02f,
  -4.80270907e-02f, -5.05590886e-02f, 9.03341733e-03f, -4.86061256e-03f, -4.33519334e-02f, -9.22164228e-03f, -5.22043519e-02f, -5.06909154e-02f, -5.45342900e-02f, -5.35973720e-02f,
  -8.86853226e-03f, 7.72596076e-02f, -6.87822178e-02f, 8.98292139e-02f, 8.12378898e-02f, 4.68121096e-03f, 4.61108014e-02f, 6.72767609e-02f, 8.49960558e-03f, 6.05586059e-02f,
  1.65159374e-01f, 2.32333601e-01f, 8.38628262e-02f, 1.74844801e-01f, 6.84606284e-02f, -6.94964528e-02f, -4.49037319e-03f, 3.46670114e-02f, 2.87984367e-02f, 3.78989726e-02f,
  6.69264272e-02f, 4.43321466e-03f, 6.88429736e-03f, 1.25374496e-01f, -1.94705240e-02f, 1.47379473e-01f, 1.40756041e-01f, 9.55311581e-02f, 8.44448432e-02f, 4.80741896e-02f,
  -4.49868590e-02f, -1.26195082e-03f, -2.88669448e-02f, 3.75034139e-02f, 1.48547679e-01f, 4.90750782e-02f, 4.20526303e-02f, 6.98744357e-02f, 4.05560769e-02f, -3.08433324e-02f,
  8.68498012e-02f, -6.55333698e-02f, -2.75844289e-03f, 8.46725851e-02f, -4.49392498e-02f, -2.15095412e-02f, -4.49078046e-02f, -1.17842648e-02f, 2.26869378e-02f, -6.84313700e-02f,
  1.22978468e-03f, 5.06455190e-02f, -1.80063192e-02f, -8.75656530e-02f, 2.59393826e-02f, 1.02352202e-01f, -1.89801417e-02f, -7.62821957e-02f, 8.97515041e-04f, 2.77241655e-02f,
  2.18471475e-02f, -3.18253711e-02f, -7.58948252e-02f, 1.51782529e-02f, -9.63135883e-02f, -8.27625543e-02f, -9.25153121e-02f, -1.46445697e-02f, -5.61757348e-02f, -9.05671045e-02f,
  6.18097410e-02f, 4.95659076e-02f, -4.56016660e-02f, -6.55708387e-02f, 9.43728238e-02f, -8.72438550e-02f, -4.66753356e-03f, -5.01200296e-02f, -8.01444352e-02f, -2.85581090e-02f,
  -7.45694116e-02f, -9.42891985e-02f, -8.32312331e-02f, -5.39346784e-02f, -4.77521643e-02f, 3.07172406e-02f, -9.15376991e-02f, 4.89749089e-02f, -6.38836697e-02f, -2.11650017e-03f,
  6.16816944e-03f, 1.84944466e-01f, 5.83244190e-02f, -9.09388810e-02f, 6.06186464e-02f, -3.92850749e-02f, 1.07105523e-01f, -1.07422657e-02f, 8.08837041e-02f, -3.39329359e-03f,
  -6.96479306e-02f, 1.60245609e-03f, -7.08686784e-02f, 3.30710188e-02f, 2.35728342e-02f, 2.25802902e-02f, 8.59982595e-02f, -1.62867159e-02f, 5.67330047e-02f, -7.22576007e-02f,
  -6.35427237e-02f, 2.59822905e-02f, -7.12723881e-02f, -5.11717945e-02f, -2.63877381e-02f, -5.01776561e-02f, -1.02119491e-01f, 1.14682242e-02f, 5.37310466e-02f, -1.27471805e-01f,
  -3.78474290e-03f, -1.36115268e-01f, 7.43178278e-02f, 1.44016917e-03f, 2.24655300e-01f, 2.33083785e-01f, 2.55657196e-01f, 1.51550665e-01f, 9.92584080e-02f, -5.07421382e-02f,
  -7.55734593e-02f, -1.49531201e-01f, 3.72500680e-02f, -4.74093482e-03f, -2.98842005e-02f, 1.31057516e-01f, 5.30538484e-02f, 1.26941472e-01f, 5.06784469e-02f, 1.17847659e-02f,
  -1.15211681e-02f, -4.69046868e-02f, -3.87092791e-02f, -6.40110672e-02f, 7.42025450e-02f, -5.40037751e-02f, -2.57373992e-02f, 1.08310871e-01f, 6.94981068e-02f, -1.53299011e-02f,
  -1.30728066e-01f, -4.07042168e-02f, -9.10953060e-03f, 1.84104778e-03f, 4.07786891e-02f, -7.23496750e-02f, 4.20965487e-03f, -9.37323198e-02f, 5.63440807e-02f, 5.39202355e-02f,
  -4.89138402e-02f, -5.09586893e-02f, 9.96608380e-03f, 1.21946456e-02f, 2.64149997e-02f, -1.39845973e-02f, 4.34925407e-02f, -4.83147055e-03f, -5.68138473e-02f, -2.70900466e-02f,
  -8.75846371e-02f, -3.27793532e-03f, 1.20942578e-01f, 4.21293378e-02f, 2.88499799e-02f, 6.10602908e-02f, -4.66446690e-02f, -1.21481288e-02f, -6.19843416e-02f, -1.37411669e-01f,
  -2.96393945e-03f, 3.66223417e-02f, -6.30466342e-02f, 4.05613445e-02f, 7.74883339e-03f, 6.80033118e-02f, 6.97149560e-02f, 2.15936843e-02f, 3.48177403e-02f, -4.28924188e-02f,
  6.79755136e-02f, 7.33765811e-02f, -4.93541509e-02f, -3.71069312e-02f, 6.01905994e-02f, 3.62110958e-02f, 7.36654550e-02f, -7.92668238e-02f, 5.27926274e-02f, 1.95955876e-02f,
  3.02172266e-02f, 2.36950144e-02f, -1.10618360e-02f, -2.51257494e-02f, -4.51153470e-03f, 9.50289443e-02f, 7.85253346e-02f, -5.63333370e-02f, -6.61324561e-02f, -2.90338397e-02f,
  -4.72735465e-02f, 6.70074075e-02f, 1.70321427e-02f, -4.49808910e-02f, -1.54308425e-02f, -7.04683810e-02f, -5.07972538e-02f, 7.99517892e-03f, -8.56250972e-02f, 5.37102781e-02f,
  -3.23560499e-02f, 5.69204129e-02f, 1.77718874e-03f, -6.41335323e-02f, 9.49076042e-02f, -1.59268156e-02f, -1.25153333e-01f, 3.22518358e-03f, 3.18611488e-02f, 6.86704516e-02f,
  6.38058083e-03f, 1.37649998e-01f, 1.94388665e-02f, 1.43371627e-01f, 6.04784079e-02f, 2.87473928e-02f, 9.08281095e-03f, 7.27870539e-02f, 1.94270201e-02f, -9.19565558e-03f,
  2.62429267e-01f, -1.60173461e-01f, 2.77992308e-01f, -1.29522253e-02f, -4.41676080e-02f, -2.01272875e-01f, -1.87237561e-01f, -1.35946915e-01f, -8.46413597e-02f, -2.02643685e-02f,
  -1.32570267e-01f, 2.95322053e-02f, 8.86179321e-03f, 1.17546991e-01f, 9.75618958e-02f, -6.18387051e-02f, 9.78017524e-02f, 3.25302064e-01f, 2.00019941e-01f, 1.62724988e-03f,
  -6.48139641e-02f, 1.00939699e-01f, 2.23597884e-01f, 4.40133177e-02f, 6.36618137e-02f, 3.80014926e-02f, -4.29061539e-02f, -5.58008440e-02f, 1.97585486e-02f, 1.20629080e-01f,
  -2.37868298e-02f, 4.68852967e-02f, 1.38949096e-01f, -6.94159344e-02f, 7.43800476e-02f, 8.99102166e-02f, -5.20609170e-02f, 8.54523182e-02f, -3.01459059e-02f, -2.58390270e-02f,
  5.49720507e-03f, -5.80151714e-02f, 3.17562371e-02f, -6.82713240e-02f, 4.27502096e-02f, 4.75451984e-02f, 2.60209702e-02f, 1.94074661e-01f, 7.29403868e-02f, 6.00866489e-02f,
  -1.79901809e-01f, -1.22650713e-01f, -1.00203312e-03f, -1.12185823e-02f, 2.92593017e-02f, -1.11396634e-03f, -5.40156141e-02f, -3.05204783e-02f, 1.38355568e-01f, -5.90932891e-02f,
  6.78643137e-02f, 4.12063301e-02f, 7.35349720e-04f, -6.96206838e-02f, -8.96323174e-02f, -5.58097176e-02f, -3.69889736e-02f, -3.39401662e-02f, 4.94734496e-02f, 3.93232107e-02f,
  6.70062974e-02f, -2.21658051e-02f, -4.61609513e-02f, 2.97997445e-02f, 1.25290286e-02f, 3.45265754e-02f, 1.62457470e-02f, 4.95749079e-02f, 8.36248547e-02f, -1.43307727e-02f,
  -2.14113500e-02f, 9.03369859e-02f, 3.52743156e-02f, -5.21431006e-02f, -4.50831801e-02f, 1.17679968e-01f, -3.80771123e-02f, -7.72939324e-02f, 2.64201220e-03f, -5.67213725e-03f,
  -1.71460077e-01f, 7.50004649e-02f, -2.91599222e-02f, -5.13813691e-03f, 4.64991182e-02f, 7.32759237e-02f, -1.07790478e-01f, 9.24327299e-02f, -2.39886716e-02f, -3.50598730e-02f,
  -8.89917761e-02f, 9.05455276e-03f, -9.11602601e-02f, 9.36392099e-02f, -6.39507100e-02f, 3.98787297e-02f, -1.29380673e-01f, 1.70476791e-02f, -4.37721945e-02f, -9.99911204e-02f,
  -1.07785471e-01f, -5.46174534e-02f, 3.95806730e-02f, -3.31557393e-02f, -9.32579115e-02f, -4.58029844e-02f, -1.00392222e-01f, 4.25820798e-02f, -1.42970355e-02f, -2.96219747e-04f
};

// L0_fan_Bp_bar (Shape: 1 x 104)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 104;
const float L0_fan_Bp_bar_data[] = {
  6.58168718e-02f, 1.55588593e-02f, 5.70064560e-02f, -3.31716798e-02f, 2.41468679e-02f, 9.67060030e-02f, 1.41821459e-01f, 9.41987112e-02f, 1.11593977e-01f, 2.12746039e-01f,
  7.24358037e-02f, -2.12497022e-02f, 1.13945611e-01f, -3.22379284e-02f, 1.50446609e-01f, 9.38567817e-02f, 1.31734863e-01f, -1.64648574e-02f, 3.42003331e-02f, 4.52511385e-02f,
  1.95617363e-01f, 1.51979774e-01f, 3.32480930e-02f, 1.02233984e-01f, 1.66279837e-01f, 1.17164180e-01f, 1.13021217e-01f, 5.36590144e-02f, 1.77851215e-01f, 1.50003880e-01f,
  5.28599396e-02f, 1.31147549e-01f, 8.61369297e-02f, 1.65588230e-01f, 8.56246278e-02f, 3.93167809e-02f, 7.79385120e-02f, 1.28005771e-02f, 1.20695680e-01f, 1.40561029e-01f,
  4.47093472e-02f, 1.10290274e-01f, -5.83856665e-02f, 2.18206018e-01f, 7.30280876e-02f, 7.02294195e-03f, 1.52687114e-02f, 6.78662360e-02f, -7.14843813e-03f, 1.91656962e-01f,
  -4.15385291e-02f, 1.35282248e-01f, 8.81832018e-02f, 4.32555713e-02f, 7.91606754e-02f, 1.37075439e-01f, 5.03803827e-02f, 1.12651132e-01f, -4.87822369e-02f, 1.52044240e-02f,
  -2.74345372e-02f, 2.20668428e-02f, 7.49568939e-02f, -5.99528104e-03f, 2.73355782e-01f, 9.69039183e-03f, -2.65388191e-02f, 1.19787239e-01f, 5.04233651e-02f, 1.30841315e-01f,
  7.01651722e-02f, 9.53399613e-02f, 1.52110592e-01f, 2.47825205e-01f, 1.62769273e-01f, 1.81489497e-01f, 1.13563843e-01f, 2.10320845e-01f, 3.29035483e-02f, 1.26082465e-01f,
  1.47831276e-01f, -1.42812124e-02f, 7.07797632e-02f, 1.63659424e-01f, 9.58403945e-02f, 1.18397944e-01f, 1.03335828e-01f, 7.66312405e-02f, 7.17026442e-02f, 2.16502279e-01f,
  1.78902850e-01f, 1.35195836e-01f, 1.16636686e-01f, 7.01982155e-02f, 1.13916509e-01f, 1.93747282e-01f, 1.75260229e-03f, 1.33069679e-01f, -1.14207780e-02f, 7.29984567e-02f,
  9.55755264e-02f, 3.05263866e-02f, 1.46528095e-01f, 1.83978170e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -1.28052190e-01f, -2.02632025e-01f, -1.72058433e-01f, -5.62228024e-01f, -4.81181800e-01f, 1.98504962e-02f, -4.53596152e-02f, -2.28582636e-01f, -2.56557673e-01f, -2.08529025e-01f,
  -1.16293050e-01f, -1.44550592e-01f, -1.63026527e-03f, 2.21548453e-02f, 4.09474224e-01f, -4.89796996e-02f, 1.61931276e-01f, 1.61684491e-02f, -1.12270802e-01f, 4.88216244e-02f,
  -7.36539215e-02f, 1.26814902e-01f, 5.26275299e-02f, -8.94098952e-02f, -1.99939355e-01f, 9.46120545e-02f, 1.42405152e-01f, -1.02192037e-01f, 1.53138235e-01f, 5.34302771e-01f,
  2.87757695e-01f, -3.88150699e-02f, -5.72653785e-02f, -1.62603736e-01f, -9.78952497e-02f, 3.48874740e-02f, 1.26128634e-02f, -1.40202194e-02f, 2.55620718e-01f, -4.37213369e-02f,
  -1.48125470e-01f, -1.72051396e-02f, 1.43852904e-01f, -9.12052020e-02f, 1.77926987e-01f, -1.02556005e-01f, -1.91403851e-01f, -1.89829901e-01f, -1.39557675e-01f, 2.53833476e-02f,
  -9.77672637e-02f, 4.79596853e-02f, 1.48701249e-02f, 2.04982415e-01f, 2.10553631e-01f, -1.74392849e-01f, 2.07135994e-02f, -8.72451365e-02f, -1.12820454e-01f, 1.87357873e-01f,
  -1.17197912e-03f, 8.29963293e-03f, 1.33538067e-01f, 1.73851922e-01f, -3.31925489e-02f, -6.87976405e-02f, -8.32805410e-02f, -1.44716695e-01f, -3.48191299e-02f, -6.86726943e-02f,
  3.64953876e-01f, -3.02225232e-01f, -4.79049310e-02f, 7.43172541e-02f, 4.29507822e-01f, -4.26267646e-02f, -1.11779727e-01f, -9.56069529e-02f, 4.64256108e-02f, 2.15928461e-02f,
  -6.21998534e-02f, 3.91547292e-01f, 1.32013127e-01f, -1.51905147e-02f, 1.43638076e-02f, -7.12965876e-02f, 1.18907787e-01f, -6.96710916e-03f, -2.07851082e-01f, 8.74418467e-02f,
  4.69651312e-01f, 8.43001157e-02f, 1.64859056e-01f, -1.13218762e-01f, -5.61776310e-02f, -5.72692975e-02f, 9.82804298e-02f, 9.70580801e-02f, 6.60976581e-03f, 2.42226248e-04f,
  -1.93432607e-02f, -4.71104085e-02f, -4.39298302e-02f, -1.22682326e-01f, 9.94118899e-02f, -1.31836440e-02f, 4.68773842e-01f, 4.34820503e-01f, -1.54167235e-01f, 5.17808050e-02f,
  1.53464423e-02f, 2.77229175e-02f, -9.52747464e-02f, -5.22656515e-02f, -3.03098210e-03f, -4.19722870e-02f, -1.19529322e-01f, -9.00236294e-02f, 5.17827608e-02f, -1.31198004e-01f,
  2.70729680e-02f, -1.64230950e-02f, 6.10136949e-02f, 1.36968657e-01f, 2.05854401e-02f, -1.80291887e-02f, -9.21060368e-02f, -1.06918678e-01f, 1.56126112e-01f, 1.01972952e-01f,
  1.53292224e-01f, -2.63521850e-01f, 3.04090846e-02f, 3.41325849e-02f, 1.71199575e-01f, -4.18928802e-01f, 2.97428548e-01f, -2.32905075e-01f, -1.72150806e-01f, 2.01928094e-02f,
  -3.78417760e-01f, -1.91916361e-01f, -4.86151606e-01f, -3.56131583e-01f, 1.97957352e-01f, 1.85189083e-01f, 5.40181935e-01f, -3.94467674e-02f, -2.13335991e-01f, 5.78531742e-01f,
  -1.74604863e-01f, 3.47457170e-01f, -2.04059333e-01f, 1.39294982e-01f, 1.05496153e-01f, -1.63636908e-01f, 3.82001698e-02f, 7.45841488e-02f, 1.83917195e-01f, -1.47830486e-01f,
  3.28465879e-01f, -5.67943119e-02f, 1.21131226e-01f, 2.16961369e-01f, 5.10459840e-02f, 2.19721168e-01f, 1.24928281e-01f, -1.82446405e-01f, -6.20334670e-02f, 4.07671817e-02f,
  4.45604920e-02f, -3.97702083e-02f, 1.40717968e-01f, -9.25855860e-02f, -2.09201202e-02f, 2.01370612e-01f, -2.13610530e-01f, -4.26252820e-02f, -1.96651340e-01f, -3.48956674e-01f,
  1.55692756e-01f, 1.66813359e-02f, 2.93247133e-01f, -1.34373888e-01f, 1.13073349e-01f, -2.62117267e-01f, -1.18065268e-01f, 1.34712040e-01f, 6.90990165e-02f, -1.69186592e-01f,
  -2.08747819e-01f, -4.31335829e-02f, -1.32758766e-01f, -1.93701386e-01f, 7.25296959e-02f, -1.83024243e-01f, 1.39889508e-01f, 2.51791887e-02f, -7.82135203e-02f, -2.14968666e-01f,
  3.92223857e-02f, 4.81694728e-01f, 2.94146508e-01f, 3.96154344e-01f, -2.10314140e-01f, -1.41203031e-01f, -2.42635347e-02f, 1.16278723e-01f, 2.72732712e-02f, 5.44915259e-01f,
  1.00043826e-01f, -8.47596303e-03f, 1.49090901e-01f, 1.90269887e-01f, -1.29842341e-01f, -1.67326495e-01f, -7.27428049e-02f, -1.72875494e-01f, -8.12155381e-02f, -4.73005697e-03f,
  -7.35134184e-02f, 4.10886616e-01f, 1.15012817e-01f, -1.60613060e-01f, 8.73234123e-02f, -6.97321296e-02f, 9.93563235e-02f, -1.03343002e-01f, 1.21410683e-01f, 7.49772117e-02f,
  2.89539963e-01f, -1.21580645e-01f, -1.08609900e-01f, -7.04372898e-02f, 3.11063528e-01f, -7.86088631e-02f, 2.46711031e-01f, 8.98954272e-02f, 3.11619550e-01f, 1.94450766e-01f,
  2.53183335e-01f, -2.04755098e-01f, 1.70184255e-01f, 7.96358287e-03f, -8.36622044e-02f, -1.64579287e-01f, -2.03249946e-01f, -8.59367996e-02f, 4.61474154e-03f, 4.79774214e-02f,
  3.08530897e-01f, -4.86526117e-02f, 3.36453952e-02f, 2.08054945e-01f, 3.54105607e-02f, 1.82640299e-01f, 1.50977045e-01f, 5.31182364e-02f, 1.86754912e-01f, 4.49946523e-01f,
  1.61077574e-01f, 1.66204050e-01f, 2.44510964e-01f, 3.78049731e-01f, -9.66087058e-02f, 3.19206476e-01f, 1.22090220e-01f, 2.11291596e-01f, -6.20870173e-01f, -3.63469154e-01f,
  -6.71106726e-02f, -8.87888074e-02f, -1.66808188e-01f, -3.02441716e-01f, -3.77966046e-01f, -3.28342438e-01f, -5.58311284e-01f, -6.66154698e-02f, -2.99410403e-01f, 5.13805598e-02f,
  -2.15697423e-01f, 3.52312624e-01f, -3.20257060e-02f, -7.14503676e-02f, 9.39819068e-02f, -5.76526448e-02f, -2.20699281e-01f, 4.15736735e-02f, 4.80849683e-01f, 3.78865637e-02f,
  -1.06053770e-01f, -3.09795775e-02f, 3.79113927e-02f, 1.20113097e-01f, -1.73484564e-01f, -1.32776216e-01f, -1.91247910e-01f, 2.71772500e-03f, -3.65022793e-02f, -1.94338784e-01f,
  4.78675105e-02f, -3.23479511e-02f, -1.94144741e-01f, -1.24376617e-01f, -8.76967311e-02f, -1.76864088e-01f, 9.53287184e-02f, -7.20990524e-02f, 1.36039957e-01f, -2.90572077e-01f,
  4.96948175e-02f, 1.93491012e-01f, 7.23637566e-02f, 2.71188140e-01f, -3.00547704e-02f, 7.94349685e-02f, -1.69831425e-01f, 1.86481014e-01f, 2.78516691e-02f, -1.19929701e-01f,
  1.78673845e-02f, 8.29238296e-02f, 4.39262390e-02f, 7.87416920e-02f, -2.73750871e-02f, -2.41380930e-03f, 1.43702164e-01f, -8.57429579e-02f, -4.01743948e-02f, 3.20886336e-02f,
  -1.26297250e-01f, -1.05554955e-02f, 7.96939805e-02f, -1.37271374e-01f, 1.21009871e-01f, -2.19617113e-01f, -1.65395029e-02f, 4.88279350e-02f, 9.00985077e-02f, -1.03387631e-01f,
  -1.20673835e-01f, -1.04665644e-01f, -1.75875828e-01f, -9.98426303e-02f, -3.04912806e-01f, -8.24785009e-02f, 3.76643762e-02f, 1.79008767e-01f, 4.47547406e-01f, -1.57728687e-01f,
  -2.56093174e-01f, -9.59898904e-02f, -9.79494005e-02f, -1.79151684e-01f, 2.11166497e-02f, -8.01209137e-02f, -9.27714407e-02f, -2.04601958e-01f, 1.62605569e-01f, -1.61197662e-01f,
  2.82285392e-01f, -5.14602400e-02f, -2.35691667e-01f, -7.27238581e-02f, -1.67968780e-01f, -3.35003808e-02f, -1.75374389e-01f, -1.48664221e-01f, -2.97493227e-02f, -1.73315555e-02f,
  2.17428818e-01f, -2.19993219e-01f, -1.37091622e-01f, -6.70420602e-02f, 1.26895085e-01f, 3.53619874e-01f, 1.42074540e-01f, -2.66136408e-01f, -1.75081547e-02f, 6.49587363e-02f,
  -1.00875720e-01f, 1.29831940e-01f, -3.92998308e-02f, 4.71759617e-01f, 1.60792187e-01f, 1.31239500e-02f, 4.28497493e-02f, 4.16768752e-02f, 2.08991706e-01f, -4.26027507e-01f,
  -1.24371134e-01f, -3.30782793e-02f, 1.06293552e-01f, 7.43828788e-02f, -2.31176428e-02f, -2.60083348e-01f, -1.79013088e-01f, 1.93157524e-01f, 1.02572046e-01f, -2.10836604e-01f,
  -1.06484890e-01f, -3.06986690e-01f, -1.96183905e-01f, -1.63660720e-01f, -6.56464994e-02f, -6.38918504e-02f, 3.64180028e-01f, -1.84068143e-01f, -1.13195278e-01f, -2.57973280e-02f,
  2.51029730e-01f, 1.03372462e-01f, -1.07611664e-01f, 3.58047903e-01f, 2.73126692e-01f, -4.01262082e-02f, -1.64586410e-01f, 9.62908864e-02f, 7.09489807e-02f, 1.97391082e-02f,
  -1.86427161e-01f, -8.06424171e-02f, -2.50894308e-01f, 1.53049603e-02f, -2.35484570e-01f, 7.66163692e-02f, -1.44260779e-01f, -1.41977027e-01f, -3.24422002e-01f, 6.83077797e-02f,
  7.08951876e-02f, 5.02395257e-02f, 1.84495673e-01f, -1.49673343e-01f, -1.46798775e-01f, 1.82825491e-01f, -2.26819348e-02f, 2.25494877e-01f, -1.00830480e-01f, 2.58388013e-01f,
  -2.09930390e-01f, -1.68465227e-01f, 2.77515352e-01f, 7.48859718e-02f, 6.53180957e-01f, 2.74553716e-01f, 2.53264070e-01f, -2.06302270e-01f, -7.38535356e-03f, -1.19767167e-01f,
  -1.75011903e-02f, 3.98111939e-01f, -1.20880648e-01f, 5.48075177e-02f, -1.25462264e-01f, 4.20207739e-01f, 3.33457679e-01f, -1.53156862e-01f, 8.78005698e-02f, -1.88909054e-01f,
  2.08183482e-01f, 7.46206790e-02f, -4.78718728e-02f, -1.28558785e-01f, -4.44947965e-02f, 5.95566854e-02f, -7.79218897e-02f, -2.48785201e-03f, -4.34967354e-02f, -1.68314070e-01f,
  -2.54855677e-02f, -1.24149285e-01f, -3.28940861e-02f, 6.41107783e-02f, 2.18583331e-01f, 7.92596638e-02f, 1.51738850e-02f, -1.41573772e-01f, -6.64582849e-02f, 8.47903043e-02f,
  -2.17943981e-01f, -2.07558349e-01f, -1.95593819e-01f, -4.72997800e-02f, -2.31816977e-01f, 2.09329411e-01f, -9.69762802e-02f, -1.71993315e-01f, -3.01490668e-02f, 2.25805104e-01f,
  -3.58383000e-01f, -2.27259606e-01f, -1.61587402e-01f, 2.08211452e-01f, -1.04780152e-01f, -4.54138219e-02f, -1.07375018e-01f, 8.37014392e-02f, 4.39782888e-02f, -1.15130708e-01f,
  2.88601249e-01f, 4.02001083e-01f, 5.74230589e-02f, -2.35002741e-01f, -1.41143454e-02f, -1.82411313e-01f, 2.86921024e-01f, 2.89326459e-01f, 3.12707908e-02f, -1.03491679e-01f,
  1.03756942e-01f, -1.43282041e-01f, -3.63231182e-01f, -7.19292685e-02f, -8.58407095e-03f, 2.05919027e-01f, -8.23501423e-02f, -9.59073678e-02f, 4.06139307e-02f, -1.66163936e-01f,
  -1.30314872e-01f, -4.02279422e-02f, -2.88454928e-02f, -2.26251259e-01f, 6.35713398e-01f, -1.54803498e-02f, 5.38301170e-02f, -1.30499333e-01f, 3.04013014e-01f, -5.04363537e-01f,
  -1.71499297e-01f, -4.51778412e-01f, -6.72877431e-02f, -2.11902186e-01f, -1.66735500e-01f, -1.10188313e-01f, 2.41015971e-01f, 9.16186795e-02f, -1.02408178e-01f, 9.38597098e-02f,
  -6.58688396e-02f, -1.81711748e-01f, -2.47299865e-01f, 1.51698748e-02f, 6.97986176e-03f, -7.57106617e-02f, 1.12184688e-01f, -1.25582740e-01f, -9.78679210e-02f, 1.79172233e-01f,
  1.37220740e-01f, 4.86938208e-02f, 9.43870023e-02f, 4.31402549e-02f, -6.41649356e-03f, -9.92079824e-02f, -1.54883653e-01f, 6.48140311e-02f, 6.34820461e-02f, 4.73424345e-02f,
  -1.36446580e-01f, -5.78293726e-02f, 1.00773580e-01f, 1.97774202e-01f, -1.32538363e-01f, 2.80303538e-01f, -2.30650201e-01f, 1.51679069e-01f, -2.42217467e-03f, 1.39647716e-04f,
  1.06040183e-02f, 1.51319487e-03f, -2.38374574e-03f, -1.08103015e-01f, 1.40114695e-01f, 1.38025850e-01f, 2.29417473e-01f, 2.67966300e-01f, -6.63651228e-02f, -1.85025364e-01f,
  -3.25527526e-02f, -2.61740386e-02f, 2.28162989e-01f, 7.05064535e-01f, 2.50601023e-01f, 2.53136791e-02f, -2.70557910e-01f, -1.03857279e-01f, -1.01024218e-01f, 1.88554481e-01f,
  -1.18110113e-01f, -3.50257680e-02f, -7.78277172e-03f, -3.49115551e-01f, 1.37985483e-01f, 8.44490230e-02f, -3.98450010e-02f, 5.97417094e-02f, 1.84308812e-01f, -7.18243420e-02f,
  1.21013664e-01f, 1.29533142e-01f, -2.52312690e-01f, 4.71874811e-02f, 5.65694794e-02f, 1.11410953e-02f, -1.18565969e-01f, 1.95058867e-01f, 2.20097810e-01f, -2.01785743e-01f,
  -1.94999889e-01f, -9.12527367e-02f, -6.15965910e-02f, 2.30344795e-02f, -1.75053850e-01f, 4.00329381e-01f, 1.73503190e-01f, -8.99076909e-02f, 4.12451565e-01f, 2.67592907e-01f,
  -1.65839456e-02f, -9.72276926e-02f, -4.82003391e-02f, 7.84082562e-02f, 3.20560709e-02f, -7.41636157e-02f, -1.68352574e-02f, -2.56010722e-02f, -1.34047896e-01f, -2.73778196e-02f,
  5.44102676e-02f, 1.90502465e-01f, 8.62595513e-02f, -6.15836643e-02f, -2.20029637e-01f, 1.44235760e-01f, -6.99969754e-02f, -4.32281047e-02f, -7.18935579e-02f, -7.91805610e-02f,
  3.59040707e-01f, 1.89386845e-01f, 2.20254809e-01f, 2.24342823e-01f, 1.15468018e-01f, 4.38023470e-02f, 3.24181110e-01f, 1.52292818e-01f, 2.33277738e-01f, 2.91328311e-01f,
  1.11220114e-01f, 2.48736292e-01f, 1.97951138e-01f, 2.06955612e-01f, -3.25559944e-01f, -3.77558261e-01f, 1.74372584e-01f, 6.44397080e-01f, 4.10478920e-01f, -2.80307502e-01f,
  2.14440212e-01f, -1.02991192e-02f, -1.36807978e-01f, -1.93512365e-02f, 1.15460627e-01f, -2.37438425e-01f, -2.61265580e-02f, 1.47482082e-01f, -1.15686459e-02f, -5.75995930e-02f,
  1.92155957e-01f, 7.34739099e-03f, -2.01540545e-01f, -2.43984655e-01f, -3.59634422e-02f, -6.30097985e-02f, 6.62418380e-02f, -1.10257186e-01f, 4.84484881e-01f, 9.18395296e-02f,
  -1.04685221e-02f, -1.00652508e-01f, 4.76327576e-02f, 2.32841372e-01f, 2.54656762e-01f, 5.66849485e-03f, -2.15307553e-03f, 3.51520717e-01f, -1.94972023e-01f, 2.70860344e-01f,
  -4.50120680e-03f, -1.24894783e-01f, -2.97279626e-01f, 3.70001972e-01f, 1.10713959e-01f, -2.33759955e-01f, -8.18531662e-02f, -5.21710888e-02f, 2.06991881e-01f, -9.32955295e-02f,
  -1.13112241e-01f, -7.66920075e-02f, -8.85894224e-02f, 3.67500782e-01f, 5.55013120e-02f, 6.91912621e-02f, -1.50047645e-01f, -1.95717886e-02f, 3.03199980e-02f, 1.28027070e-02f,
  -1.53203562e-01f, 1.73444554e-01f, -1.66180819e-01f, -2.19287977e-01f, -1.67194940e-02f, -3.50497626e-02f, -1.68936893e-01f, -1.28576660e-03f, -1.36865318e-01f, -8.76209512e-02f,
  3.59149240e-02f, -1.96252763e-01f, -5.85182048e-02f, 9.58721489e-02f, 4.58218269e-02f, 1.85586289e-01f, -8.81102383e-02f, 1.43036380e-01f, -4.03738990e-02f, 1.97130665e-01f,
  -2.35132784e-01f, -2.47980338e-02f, -7.84407035e-02f, 5.64664491e-02f, -9.66493711e-02f, 4.26791273e-02f, 3.63966376e-01f, 7.59696901e-01f, 2.01942444e-01f, 4.69915479e-01f,
  -1.22745566e-01f, -2.98009049e-02f, -1.23507440e-01f, -9.40624326e-02f, -2.67003458e-02f, -1.05526611e-01f, 1.95119694e-01f, -6.06507733e-02f, 8.77257735e-02f, -2.21577123e-01f,
  9.82696488e-02f, -5.77970892e-02f, -1.98314316e-03f, -5.08681759e-02f, -4.85754497e-02f, 5.13261706e-02f, -2.73457803e-02f, -1.37625381e-01f, 5.60813472e-02f, -9.67082754e-02f,
  -2.01919675e-02f, -7.05512287e-03f, -1.90753534e-01f, -2.49901325e-01f, 2.74777524e-02f, 1.18238725e-01f, -1.40782684e-01f, -2.49418736e-01f, 1.48114473e-01f, 3.12083811e-02f,
  -5.82802407e-02f, -2.44228110e-01f, -1.68563810e-03f, 7.23663941e-02f, 4.43160236e-02f, -1.83809519e-01f, 1.35739312e-01f, -2.36859322e-01f, 9.01587009e-02f, -8.86636749e-02f,
  8.01527575e-02f, -1.29062742e-01f, 8.29632357e-02f, 3.96884948e-01f, -3.75563025e-01f, 2.87333697e-01f, -2.53579170e-01f, 4.49433535e-01f, 2.35761836e-01f, -3.64769042e-01f,
  -4.16622013e-01f, 3.56926978e-01f, -6.82025924e-02f, 1.47639662e-01f, -1.15777969e-01f, 2.59629562e-02f, -8.15329924e-02f, -2.16336638e-01f, -1.10693455e-01f, 1.45065233e-01f,
  8.81283171e-03f, -1.69228911e-01f, 1.30642012e-01f, -1.84652880e-01f, 1.83999464e-01f, -2.09281016e-02f, -1.38985202e-01f, -1.39958680e-01f, 4.61276233e-01f, -7.22407103e-02f,
  -1.43752694e-01f, -9.63966027e-02f, -6.71686977e-02f, 1.07747950e-01f, 2.98329294e-01f, -9.03266855e-03f, 8.73953626e-02f, 7.83481821e-03f, 4.28718150e-01f, -1.13159299e-01f,
  -1.35208026e-01f, -1.14398099e-01f, 2.24055778e-02f, -1.28936172e-01f, 3.65290999e-01f, 8.36267620e-02f, -5.78570142e-02f, 5.12676165e-02f, -6.51099905e-02f, -4.22531515e-02f,
  -9.25455689e-02f, 1.07420599e-02f, -1.83103547e-01f, 2.75511265e-01f, -5.22755794e-02f, -1.70727849e-01f, -1.40271246e-01f, -1.36498109e-01f, -1.95022835e-03f, -1.11523613e-01f,
  -5.60422540e-02f, -1.05463840e-01f, -1.12080738e-01f, 3.97693187e-01f, -1.96487516e-01f, -2.21976072e-01f, 4.72140163e-01f, -1.45544514e-01f, 2.78409151e-03f, -2.10558861e-01f,
  8.93426221e-03f, -7.40453079e-02f, 1.65418774e-01f, 8.30483660e-02f, -2.01972529e-01f, 1.83468238e-01f, -2.12933213e-01f, 6.43770173e-02f, 4.65525463e-02f, -6.49163052e-02f,
  -9.67138857e-02f, 7.35921115e-02f, 1.05607443e-01f, 7.36399516e-02f, -7.32343718e-02f, 9.33062658e-02f, 1.12897292e-01f, -9.62831303e-02f, 1.04653714e-02f, -3.48450504e-02f,
  2.36268982e-01f, -2.67726094e-01f, -9.48756263e-02f, -6.55080006e-02f, -2.42857769e-01f, -3.39640975e-01f, 4.29938547e-02f, -2.13766098e-01f, -1.16723865e-01f, -2.48085111e-01f,
  -2.87010074e-01f, -1.79193512e-01f, -1.36224315e-01f, -1.16989620e-01f, -2.83448488e-01f, -2.75088679e-02f, 1.98030606e-01f, 1.97849423e-01f, -1.34123117e-01f, 5.18600166e-01f,
  -1.58195972e-01f, -2.39420861e-01f, -2.96016186e-01f, -1.47792652e-01f, -1.98840767e-01f, 3.48259270e-01f, -7.63338283e-02f, -1.12554416e-01f, -1.50688007e-01f, -1.21185370e-01f,
  -9.11208466e-02f, -5.67810200e-02f, -4.10240322e-01f, -1.44665822e-01f, 4.85394523e-02f, -3.47402126e-01f, -2.12416053e-01f, -1.39277086e-01f, -2.42184743e-01f, -1.48703596e-02f,
  6.61311746e-02f, 1.66699946e-01f, -2.47293785e-01f, -7.19623417e-02f, -2.79203475e-01f, 2.26251438e-01f, -1.54805288e-01f, -2.58558750e-01f, 3.25552195e-01f, -2.72182912e-01f,
  1.30078182e-01f, -6.38520569e-02f, -3.96686234e-02f, -3.53562534e-02f, -1.59383520e-01f, 2.99895760e-02f, 1.04426136e-02f, 4.00347693e-04f, -9.94840451e-03f, -6.45512715e-02f,
  6.22534901e-02f, -1.19491123e-01f, -2.18349397e-01f, -5.77541701e-02f, -1.23787954e-01f, 3.49150509e-01f, -1.78988427e-01f, -3.34353969e-02f, 8.24459791e-02f, 2.01154128e-01f,
  -4.55555245e-02f, -2.00815529e-01f, -1.28117993e-01f, -4.65008505e-02f, 2.10647248e-02f, 1.02296859e-01f, -1.82443798e-01f, -2.28888784e-02f, -8.20136666e-02f, -1.71688452e-01f,
  -7.25971684e-02f, 3.45968634e-01f, -2.22868934e-01f, 2.17132986e-01f, -3.81588452e-02f, -7.68445283e-02f, -1.36672884e-01f, 2.06722036e-01f, 2.18489587e-01f, -3.77389453e-02f,
  -1.38011545e-01f, -1.55431911e-01f, -1.35867938e-01f, 2.61470377e-01f, 4.02638465e-02f, -5.79786152e-02f, -3.33267078e-02f, -8.53596553e-02f, -1.03126891e-01f, -1.66955337e-01f,
  -1.11883849e-01f, -2.33451352e-01f, 3.34655255e-01f, 4.03704904e-02f, -1.52883887e-01f, -2.87658591e-02f, 1.52722178e-02f, -1.51321232e-01f, 7.69215263e-03f, -2.02748496e-02f,
  -5.86778484e-02f, -1.52676895e-01f, 1.68626141e-02f, 1.48202106e-01f, -1.17599107e-01f, -7.70266429e-02f, 6.17977977e-02f, 1.48578644e-01f, 2.86662448e-02f, -1.08132325e-01f,
  2.70405680e-01f, 4.61847112e-02f, -4.56107967e-03f, 6.42522424e-02f, 1.26269877e-01f, 1.81609869e-01f, -1.40623629e-01f, -1.95258155e-01f, 1.92307368e-01f, -1.23001575e-01f,
  -4.21314798e-02f, 1.70562323e-02f, -1.80669934e-01f, -6.32909983e-02f, 2.84702629e-01f, 2.66795903e-01f, 3.91809195e-02f, -2.00713892e-02f, -1.48602258e-02f, 3.02331150e-03f,
  -9.70212966e-02f, 3.26578901e-03f, 2.57638961e-01f, -6.48204982e-02f, 3.25942673e-02f, -1.76348642e-01f, -1.34288639e-01f, -1.46457434e-01f, 3.12946290e-02f, -1.64018497e-01f,
  5.66768467e-01f, 1.04159206e-01f, 2.17958033e-01f, -2.25439146e-01f, -1.00440435e-01f, 1.08724572e-01f, 2.09418982e-02f, 1.74396247e-01f, 8.60551521e-02f, -4.91550043e-02f,
  -2.22694576e-01f, 1.73338562e-01f, -3.03465784e-01f, 9.55620706e-02f, 1.12397023e-01f, 8.18500146e-02f, -4.15982813e-01f, 2.31352761e-01f, 3.30779135e-01f, 5.00785466e-03f,
  9.61753055e-02f, 4.29684848e-01f, 2.87721962e-01f, 3.56262445e-01f, 5.33534288e-01f, 4.94857542e-02f, -5.08124530e-02f, 1.07840814e-01f, 1.23378336e-01f, -5.96356429e-02f,
  -1.18657403e-01f, -1.76099733e-01f, -1.12368785e-01f, -9.50469375e-02f, -1.17940865e-02f, 1.43247947e-01f, -1.40006781e-01f, -9.98238921e-02f, -7.79985636e-02f, 2.06727758e-01f,
  2.17694968e-01f, 3.86352986e-02f, -2.54851460e-01f, 1.49537444e-01f, -1.93934172e-01f, 4.15888429e-02f, 1.38365943e-02f, -2.65626106e-02f, 2.87713736e-01f, 1.36197925e-01f,
  -4.87365276e-02f, 6.71733245e-02f, 2.26750642e-01f, 2.92539597e-01f, -7.45019391e-02f, -2.72445679e-02f, 3.38277847e-01f, -3.35763991e-01f, 4.50397879e-02f, -1.76665142e-01f,
  -5.68080842e-02f, 2.08137538e-02f, -7.26955310e-02f, -1.16792120e-01f, -2.36839488e-01f, -3.55573073e-02f, -1.67073295e-01f, -8.75112116e-02f, -1.37641594e-01f, -1.67808607e-01f,
  -6.62112758e-02f, 1.01255842e-01f, 3.64208706e-02f, 1.12982817e-01f, -1.13005839e-01f, -2.21815348e-01f, -1.00279920e-01f, -1.32815585e-01f, -5.97782545e-02f, 1.97020486e-01f,
  2.15481743e-01f, -3.63466479e-02f, 1.97028443e-01f, 6.50303140e-02f, -1.75041720e-01f, 2.09629118e-01f, -2.26561397e-01f, 1.11441843e-01f, 5.28606400e-02f, -8.22888091e-02f,
  -5.34716696e-02f, 5.63855954e-02f, -1.51204199e-01f, -9.69949216e-02f, -2.08549216e-01f, -2.55257010e-01f, -2.73486376e-02f, 1.51511520e-01f, -1.09256580e-01f, 2.58717269e-01f,
  -2.18664855e-01f, -9.89521015e-03f, 9.93229523e-02f, 3.23046856e-02f, 2.52550691e-02f, -1.24955051e-01f, -1.17186308e-01f, -4.29266952e-02f, -5.67693859e-02f, -1.65744469e-01f,
  -2.77686745e-01f, -1.71226189e-01f, -7.22290352e-02f, 2.33555824e-01f, 9.16524455e-02f, 5.00213623e-01f, 2.75353253e-01f, 2.32833833e-01f, 4.58735466e-01f, -1.14881240e-01f,
  3.34730059e-01f, -1.29388735e-01f, -2.26798728e-02f, -6.41792715e-02f, -1.94715351e-01f, -2.03378975e-01f, -5.74243022e-03f, -2.50242442e-01f, -7.87994191e-02f, -2.82195330e-01f,
  3.57269108e-01f, 1.51787654e-01f, -1.16690025e-01f, -2.53683835e-01f, 7.00033009e-02f, 2.38129348e-01f, -1.84968561e-02f, 1.02583185e-01f, -3.13404977e-01f, 2.13091150e-01f,
  7.42176697e-02f, -7.28948340e-02f, 1.21156365e-01f, 2.03807190e-01f, 5.69749594e-01f, -2.80572236e-01f, 8.08316469e-02f, 1.74897850e-01f, 1.99249700e-01f, 8.29784796e-02f,
  -4.13380086e-01f, 4.93219830e-02f, -4.92545307e-01f, -2.51910239e-01f, 3.08739692e-01f, 1.98463500e-02f, 1.33652881e-01f, -1.28607720e-01f, -3.19194384e-02f, 8.81512687e-02f,
  8.65800902e-02f, -1.62642114e-02f, -6.46205321e-02f, 8.71581137e-02f, -8.12197998e-02f, 7.44829997e-02f, -3.68113667e-02f, 1.06951818e-01f, -1.11647293e-01f, -1.96735457e-01f,
  1.11990936e-01f, -2.00713322e-01f, 4.16706860e-01f, 3.30213718e-02f, 1.91452399e-01f, 2.08022892e-01f, -4.55397591e-02f, -2.24779144e-01f, -2.38642767e-02f, 5.26282974e-02f,
  -6.03076667e-02f, -1.04627177e-01f, 1.87825769e-01f, -9.35480595e-02f, -1.68182790e-01f, -2.40191102e-01f, -2.27577928e-02f, 2.81080335e-01f, 2.11118504e-01f, 3.62402797e-01f,
  -1.55173108e-01f, -1.62544027e-01f, -2.45609269e-01f, 7.68795086e-04f, -1.99879408e-01f, -5.76199144e-02f, -1.58289909e-01f, 6.35171309e-03f, 1.84926182e-01f, -2.75155842e-01f,
  9.96452570e-03f, 2.56098621e-02f, 4.22394276e-02f, -2.26215995e-03f, -1.44958630e-01f, -3.05118109e-03f, -7.14736283e-02f, -2.28286326e-01f, -1.14710972e-01f, 2.25412056e-01f,
  -1.43005162e-01f, 2.35983714e-01f, 7.60644153e-02f, -2.38675490e-01f, 1.22771189e-01f, 6.87341392e-02f, 4.01907824e-02f, 4.53363582e-02f, 2.55427033e-01f, 4.09693532e-02f,
  -2.06708193e-01f, 2.54180338e-02f, -4.20329198e-02f, -2.05990914e-02f, 6.80651842e-03f, -1.11451514e-01f, -1.00033090e-01f, -1.60440892e-01f, 1.68983817e-01f, -2.87583172e-01f,
  2.46563882e-01f, -1.49262613e-02f, 2.56349862e-01f, -2.02547014e-01f, 1.30523235e-01f, 3.63139451e-01f, 2.03752816e-01f, -1.15473107e-01f, 2.12689117e-02f, 5.37066042e-01f,
  -2.29121804e-01f, -1.52769163e-01f, 1.91710666e-02f, -1.91133797e-01f, 6.52945489e-02f, -2.20171973e-01f, -1.08745597e-01f, 3.35622281e-01f, -1.54894307e-01f, -1.70020834e-01f,
  -4.65815254e-02f, 1.01445485e-02f, 1.49164468e-01f, 3.98933977e-01f, -2.99597550e-02f, 1.23662343e-02f, -7.62285739e-02f, 2.30118632e-01f, -2.02890486e-01f, -6.60281926e-02f,
  3.28299962e-03f, -1.75004289e-01f, -2.97245294e-01f, 1.36842296e-01f, 1.45084068e-01f, 2.02092871e-01f, 2.26627849e-02f, 1.57657444e-01f, 1.03365041e-01f, 6.03679679e-02f,
  7.99066052e-02f, 1.40978143e-01f, -7.59348348e-02f, 3.07490557e-01f, -4.72112000e-01f, -5.96286803e-02f, -8.89635682e-02f, -7.27635697e-02f, 3.15716147e-01f, -5.08304015e-02f,
  1.44748688e-01f, 8.52543488e-02f, 4.20007408e-01f, 1.06360622e-01f, 2.92786092e-01f, -1.38973460e-01f, -1.50792664e-02f, -7.01006874e-02f, -8.15379471e-02f, -1.20669216e-01f,
  4.67710495e-02f, -6.78761229e-02f, -1.60194606e-01f, 6.25430703e-01f, 8.65100324e-03f, -5.74025512e-02f, -8.11428279e-02f, 1.90798268e-01f, -4.26915586e-02f, 3.52017134e-02f,
  -1.21376671e-01f, 7.84555152e-02f, 7.93937072e-02f, 3.46463770e-01f, -4.83618602e-02f, -4.14150357e-02f, -4.52595651e-02f, -5.71938939e-02f, -9.57076102e-02f, -3.67810437e-03f,
  -6.87307194e-02f, 3.19623441e-01f, 2.39285946e-01f, 2.50576705e-01f, -1.30922288e-01f, -1.69875145e-01f, -4.91628088e-02f, -1.60743088e-01f, -1.94837987e-01f, -7.72983506e-02f,
  3.99482727e-01f, -1.04302876e-01f, 4.61016521e-02f, -2.79343575e-01f, 3.82105112e-01f, -3.28581370e-02f, 4.89119068e-02f, -4.88816239e-02f, 1.08189009e-01f, -4.93217669e-02f,
  -1.51708528e-01f, -1.64166823e-01f, -2.29792409e-02f, 3.32280815e-01f, -5.47365062e-02f, -2.39758670e-01f, 8.22499674e-03f, 8.24554008e-04f, -1.04851864e-01f, -1.27350707e-02f,
  2.90660560e-02f, -1.78978443e-01f, -1.71168432e-01f, -7.07577094e-02f, -7.20124170e-02f, -1.28864720e-01f, 7.41294250e-02f, -1.76410889e-03f, 1.19820319e-01f, -5.74794821e-02f,
  -5.97323328e-02f, -5.35671040e-02f, -1.86150715e-01f, -5.04720546e-02f, -7.68041387e-02f, 6.42687976e-02f, -2.11314127e-01f, 2.71267705e-02f, -1.71636641e-01f, -2.29079258e-02f,
  2.67133474e-01f, -1.14114821e-01f, -1.71495497e-01f, 3.02357562e-02f, -5.15476242e-02f, 3.82097542e-01f, -2.60499567e-01f, -1.23690598e-01f, -3.06357369e-02f, 7.51251131e-02f,
  -2.21830279e-01f, -1.08960539e-01f, -8.98675025e-02f, -1.09105326e-01f, 5.74941300e-02f, -2.61598062e-02f, 6.14061095e-02f, 2.95041371e-02f, -2.09164470e-01f, 2.06810057e-01f,
  -4.76462655e-02f, -1.99266627e-01f, -1.31823197e-01f, 1.69509724e-01f, -8.86032060e-02f, -1.42920345e-01f, -1.48089811e-01f, -2.26888075e-01f, 8.88736770e-02f, 1.27934650e-01f,
  -2.12379526e-02f, 1.09928166e-02f, -9.33750197e-02f, 2.48604771e-02f, 1.90405071e-01f, 7.24338070e-02f, -2.90500578e-02f, 2.30598152e-01f, 4.37876880e-02f, 6.00593984e-02f,
  3.13282251e-01f, -5.02198897e-02f, 2.63299197e-01f, 1.71395317e-01f, -2.73318678e-01f, -2.81262696e-01f, 2.43781269e-01f, 2.20478311e-01f, 3.00744832e-01f, 1.14601001e-01f,
  1.78334061e-02f, -1.67016163e-01f, -1.69588447e-01f, 3.61891207e-03f, -4.76035196e-03f, -5.97773213e-03f, -1.52076390e-02f, 1.73660535e-02f, -5.93204834e-02f, -8.76413137e-02f,
  -2.73281764e-02f, -2.42124960e-01f, -5.22866398e-02f, 9.64214429e-02f, 6.73680604e-02f, -1.52645810e-02f, -1.52206302e-01f, 4.06331681e-02f, 1.70126274e-01f, -1.22830067e-02f,
  -1.90344110e-01f, -2.25706607e-01f, -1.29241273e-01f, 4.28248465e-01f, 1.47450969e-01f, -1.93109754e-02f, 3.77514422e-01f, -6.16358081e-03f, -1.47012517e-01f, -1.61970690e-01f,
  -1.86213985e-01f, -1.19301453e-01f, -3.50582041e-02f, -2.97070369e-02f, -2.21596733e-01f, -5.11253886e-02f, 1.35857090e-01f, 6.55934736e-02f, -7.75947468e-03f, 1.11046635e-01f,
  -1.98806524e-01f, 9.59008634e-02f, -1.01789445e-01f, 1.08847059e-01f, 4.87290882e-02f, 2.39021592e-02f, 2.00327169e-02f, -1.65696256e-02f, -3.44073847e-02f, -9.49049070e-02f,
  3.48535776e-02f, -1.14155710e-01f, -8.44284371e-02f, 4.81269322e-02f, 5.03946692e-02f, -1.41842216e-01f, -2.07108110e-02f, 2.63823003e-01f, 1.31758139e-01f, -1.22456670e-01f,
  -1.08288378e-02f, 9.32130441e-02f, -1.91219058e-02f, -7.75890574e-02f, -5.12940995e-03f, -2.32957050e-01f, 6.33316219e-01f, -8.17213878e-02f, -9.11482871e-02f, -1.62583411e-01f,
  -1.15481861e-01f, -5.64218014e-02f, 4.60514635e-01f, 2.51724124e-02f, 2.11245455e-02f, -1.49169087e-01f, -2.09589705e-01f, -2.37730965e-01f, -1.44947410e-01f, 5.99971652e-01f,
  -1.37462199e-01f, 2.35164925e-01f, -1.56466022e-01f, -1.30574971e-01f, -6.63522333e-02f, -1.65009633e-01f, 1.51203379e-01f, -1.97609946e-01f, 4.27452102e-02f, -8.58597364e-03f,
  -7.74456188e-02f, 5.48368156e-01f, -1.74247593e-01f, 9.40904096e-02f, 8.39644596e-02f, 9.53469574e-02f, -9.45004672e-02f, -1.17196813e-01f, 3.12896147e-02f, 3.04545283e-01f,
  -7.15816915e-02f, -1.29086703e-01f, -3.64529081e-02f, 3.29466760e-02f, 1.05559550e-01f, -1.01626590e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.21637031e-01f, 4.56782356e-02f, 8.06576461e-02f, 1.03081041e-03f, 5.19411229e-02f, 1.15780562e-01f, -1.16375871e-01f, -6.75306693e-02f, 3.70037258e-02f, 1.19421422e-03f,
  -6.95575029e-02f, -4.43784408e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 104
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    