/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.70504165e-01f, 9.55008343e-02f, 3.06481063e-01f, -1.77952945e-01f, 8.38986337e-02f, -3.42104360e-02f, 2.71815538e-01f, -4.53500412e-02f, -1.90558374e-01f, 3.09071764e-02f,
  -2.45289683e-01f, -2.96851128e-01f, -2.71150023e-01f, -3.01349401e-01f, -2.24504054e-01f, 1.67536005e-01f, 1.63809404e-01f, -1.76656973e-02f, -9.53991339e-02f, -8.71883184e-02f,
  -1.23086497e-01f, 5.80393039e-02f, -3.94039303e-02f, -1.98281948e-02f, 2.90022433e-01f, 2.22901441e-02f, 1.82780430e-01f, 2.42209941e-01f, 5.96417040e-02f, 4.61712301e-01f,
  1.73326746e-01f, -9.54881608e-02f, -9.09540057e-02f, -1.63618550e-01f, -7.74288476e-02f, -1.82231009e-01f, -6.99082315e-02f, -6.83834925e-02f, -7.95521364e-02f, -8.24640840e-02f,
  -1.40719548e-01f, -8.53921175e-02f, -9.19470415e-02f, -2.54730657e-02f, -7.24053308e-02f, -3.74351814e-02f, -3.17625776e-02f, 5.15296683e-03f, -2.52462048e-02f, -1.14695663e-02f,
  -5.36150970e-02f, -1.79106090e-03f, 6.15961477e-02f, -2.37990152e-02f, 1.42203039e-02f, 2.67561208e-02f, 1.00547694e-01f, 1.19706489e-01f, 5.35880998e-02f, 2.36704707e-01f,
  1.24022983e-01f, 2.66386457e-02f, -2.42635123e-02f, 7.50557184e-02f, 3.66338715e-03f, -6.76405965e-04f, 9.39266384e-03f, -1.64536592e-02f, -2.63663065e-02f, 9.81784165e-02f,
  -3.37423384e-02f, 6.64367825e-02f, -1.90046441e-03f, 1.42683163e-02f, -1.43825924e-02f, 4.75534126e-02f, 2.29072701e-02f, -9.75458045e-03f, -1.84893247e-03f, 2.58944836e-02f,
  -2.94408575e-03f, 3.55088115e-02f, -2.05397466e-03f, 2.99214246e-03f, 3.69967930e-02f, -2.27113366e-02f, -1.57309864e-02f, -9.11026075e-02f, -2.62822974e-02f, 2.94977576e-02f,
  -1.38176933e-01f, -1.36730716e-01f, -2.92234924e-02f, -7.56360814e-02f, -1.14918731e-01f, -7.30954390e-03f, -6.62887469e-02f, -4.61188927e-02f, -1.05054222e-01f, 1.63325630e-02f,
  -2.76632924e-02f, -8.13366473e-02f, -1.04977943e-01f, 2.28196252e-02f, -1.42193884e-02f, -5.60093932e-02f, -8.04093294e-03f, -1.89569853e-02f, 5.72988112e-03f, 7.03650154e-03f,
  -1.03377912e-03f, 1.97870247e-02f, -1.21015169e-01f, -1.25345737e-01f, -1.10376198e-02f, -1.68421119e-01f, 5.85962199e-02f, 9.88576859e-02f, -1.14738703e-01f, 1.84557319e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.08059287e+00f, -3.53339225e-01f, -1.12019384e+00f, 3.23883742e-01f, -1.07895397e-01f, -8.39782953e-02f, 1.63538493e-02f, 3.74290526e-01f, 4.06535119e-01f, -3.16535197e-02f,
  -2.19283015e-01f, 2.07737535e-02f, -2.17710540e-01f, -2.60569721e-01f, 5.09408452e-02f, -3.16184998e-01f, -3.52469325e-01f, -2.24357069e-01f, 1.71106681e-01f, 1.45355344e-01f,
  1.46087497e-01f, 3.17907125e-01f, 3.46242279e-01f, 1.92917734e-02f, -2.91318864e-01f, -2.13704705e-02f, -5.64096510e-01f, -5.45671999e-01f, -5.90876818e-01f, -6.80216312e-01f,
  -9.73984003e-01f, -3.76761824e-01f, 9.42099094e-02f, 2.31676653e-01f, -6.80832863e-02f, 1.69601962e-01f, 3.89654972e-02f, 9.21589956e-02f, 1.80546612e-01f, 8.37406814e-02f,
  -1.13877192e-01f, 8.98084491e-02f, 1.67741418e-01f, -3.12851593e-02f, 6.65609911e-02f, 9.28800832e-03f, 5.24935126e-02f, 1.35180384e-01f, -4.51636016e-02f, -2.41059393e-01f,
  -1.13022767e-01f, -5.41839823e-02f, -7.18589500e-02f, 5.39463349e-02f, -1.77209213e-01f, -1.38399331e-02f, -2.14952514e-01f, -1.43557593e-01f, -1.64908111e-01f, 1.50593087e-01f,
  -4.53196093e-02f, -3.78538854e-02f, -9.62594524e-02f, -3.51281948e-02f, 1.44724846e-01f, 3.21988799e-02f, -3.38279530e-02f, 2.19303258e-02f, 6.37895539e-02f, 1.58781588e-01f,
  1.18030004e-01f, -1.29723484e-02f, -5.25156856e-02f, 1.24856951e-02f, -1.57236025e-01f, -1.05745740e-01f, 7.99823031e-02f, -5.02830930e-02f, -7.03237727e-02f, 2.06155583e-01f,
  6.24371283e-02f, -7.44037479e-02f, -4.31537330e-02f, -7.74246007e-02f, -2.14621812e-01f, -2.97098700e-02f, -6.15837127e-02f, -1.39463590e-02f, 2.41667815e-02f, 7.56606683e-02f,
  3.82205665e-01f, 5.15988916e-02f, -1.07682003e-02f, -3.39790583e-02f, -2.11133108e-01f, -9.12067145e-02f, -2.94490457e-01f, -9.02936161e-02f, -4.43941802e-02f, -8.47875029e-02f,
  -2.47177392e-01f, 7.50749977e-03f, -1.70783192e-01f, -2.47945227e-02f, 1.76729575e-01f, -5.28019741e-02f, 5.31138182e-02f, 9.95065272e-03f, -1.12004876e-01f, -7.14073628e-02f,
  -2.57615745e-02f, 2.35576212e-01f, 4.02894020e-01f, 1.74724936e-01f, -3.89732197e-02f, 2.42636383e-01f, -5.60106821e-02f, 3.28663960e-02f, 1.22527778e-01f, 6.37761116e-01f,
  -1.12232184e+00f, 2.67648786e-01f, 2.92645805e-02f, -1.60912797e-01f, 4.99532849e-01f, 7.74584234e-01f, 1.12597370e+00f, 3.67296368e-01f, -1.82650179e-01f, 2.06884503e-01f,
  -8.63848925e-02f, -3.34950328e-01f, -2.73863643e-01f, -4.71972562e-02f, 9.82976556e-02f, 5.33095896e-01f, 5.33470333e-01f, -1.94211707e-01f, -7.92364776e-02f, 2.29696572e-01f,
  3.29572707e-01f, -1.13465138e-01f, -5.35003245e-01f, -1.59685925e-01f, -1.01789765e-01f, 3.83351408e-02f, 1.25050440e-01f, -1.04626954e-01f, 3.22919428e-01f, 6.53491169e-02f,
  -6.87322974e-01f, -5.41097641e-01f, 1.79446965e-01f, -2.15707079e-01f, -2.81673431e-01f, -1.42644137e-01f, -2.03494579e-02f, -3.27692211e-01f, -1.13144137e-01f, 1.29803076e-01f,
  -1.36634156e-01f, 2.09443271e-03f, 4.44005094e-02f, 8.73688981e-02f, 1.43150957e-02f, -4.03465591e-02f, -2.27668315e-01f, -3.93685251e-01f, -3.55722994e-01f, -2.74202555e-01f,
  4.20660555e-01f, -3.27673964e-02f, -3.71396095e-01f, -3.19889910e-03f, -5.93239814e-02f, -3.28423947e-01f, -3.03959846e-01f, -5.12139916e-01f, -3.67984265e-01f, -6.06670320e-01f,
  9.80471149e-02f, -8.87247548e-02f, 1.93345934e-01f, 5.72932027e-02f, 1.47844255e-01f, -1.22579157e-01f, 8.83707926e-02f, 1.61192432e-01f, 1.49171010e-01f, -4.93208990e-02f,
  4.56170924e-03f, 9.92045831e-03f, -1.69489712e-01f, -9.05824751e-02f, 8.98615941e-02f, -1.71025962e-01f, 6.64330050e-02f, -3.71831805e-02f, -4.67967726e-02f, 1.20613053e-01f,
  -1.24537870e-01f, -1.92170925e-02f, -1.76031083e-01f, -1.06617264e-01f, 1.31347269e-01f, -2.72646528e-02f, -4.87196855e-02f, -5.24387062e-02f, -7.41244406e-02f, 2.54170690e-02f,
  -8.74280483e-02f, 3.40544730e-01f, -2.72261739e-01f, -7.30615109e-02f, 2.60411110e-02f, -1.04345374e-01f, 1.80973578e-02f, -4.52896655e-02f, 4.37086374e-02f, -5.89841120e-02f,
  1.08625293e-01f, -1.14313535e-01f, -1.27014264e-01f, 5.49693517e-02f, 1.81124836e-01f, 5.81894331e-02f, 1.03128985e-01f, 1.42991364e-01f, 1.52350083e-01f, -5.73055930e-02f,
  2.11368814e-01f, 4.02281493e-01f, -1.93638563e-01f, 3.99697386e-02f, -1.20214283e-01f, -1.37134001e-01f, -8.90039355e-02f, -7.65267834e-02f, -1.65065274e-01f, 2.03448668e-01f,
  -5.78659177e-01f, 1.54398590e-01f, -2.36355782e-01f, -2.94228405e-01f, -4.21178520e-01f, -2.32550293e-01f, -3.00278902e-01f, -2.15055551e-02f, 2.95080364e-01f, 1.52718455e-01f,
  -1.11603752e-01f, -5.71798742e-01f, -2.11609259e-01f, -4.11564380e-01f, -5.33740461e-01f, 2.15138793e-02f, -5.54387718e-02f, -7.19595015e-01f, -1.11423647e+00f, -9.09375787e-01f,
  -6.74532831e-01f, -7.90167689e-01f, -7.25652337e-01f, -3.53943795e-01f, 1.07068837e-01f, -2.75088102e-01f, 2.90555626e-01f, -2.54653037e-01f, -1.50094464e-01f, 1.17242813e-01f,
  -2.44314745e-01f, 1.13829106e-01f, -2.00017869e-01f, -3.65824699e-01f, -8.76054615e-02f, -1.93519905e-01f, -3.04368854e-01f, -8.20672959e-02f, -2.62703925e-01f, -1.54605918e-02f,
  -3.99265081e-01f, -2.36516133e-01f, -4.03308213e-01f, -3.44046414e-01f, -4.49061453e-01f, -3.09339821e-01f, 8.38296115e-02f, -2.37858504e-01f, -5.08525781e-02f, 2.68343031e-01f,
  -5.14163487e-02f, -3.47163156e-02f, 1.27180859e-01f, 3.84285390e-01f, 2.03369245e-01f, -1.36166245e-01f, 1.27692357e-01f, 1.46845430e-01f, 1.46680728e-01f, 3.74878079e-01f,
  1.03764035e-01f, 2.27403164e-01f, 8.43950510e-02f, -9.70058292e-02f, -7.46488199e-02f, 1.77874774e-01f, -2.45447978e-02f, 3.28809991e-02f, 1.46531640e-02f, -1.33271322e-01f,
  9.95521098e-02f, 8.05445760e-02f, -5.88137433e-02f, 4.59841676e-02f, -8.82034004e-02f, -1.79898307e-01f, -4.29655500e-02f, 1.08701684e-01f, -4.10267431e-03f, 1.37759835e-01f,
  -2.12946832e-01f, 4.60394509e-02f, 8.01077038e-02f, -1.08931936e-01f, 2.21132234e-01f, -6.40444905e-02f, 3.47600766e-02f, -4.71793823e-02f, -9.11136568e-02f, -1.51960561e-02f,
  -1.42298326e-01f, 2.35335141e-01f, -9.48344078e-03f, -4.96639490e-01f, -1.88407362e-01f, -8.98536816e-02f, 5.83908381e-03f, -8.49648789e-02f, -1.27454162e-01f, -1.04430825e-01f,
  -1.68647766e-01f, 5.27006201e-02f, -5.04661351e-03f, 2.63156623e-01f, -2.74690390e-01f, -6.71090186e-02f, 1.69226468e-01f, 6.72774389e-02f, -8.96400586e-02f, 2.64373291e-02f,
  1.49206400e-01f, 3.92314643e-02f, -1.22636519e-01f, 1.72604501e-01f, 7.05324858e-02f, -3.93695086e-01f, 6.14335611e-02f, -4.78591099e-02f, 5.17903119e-02f, 3.27113926e-01f,
  1.00603342e+00f, -3.02188516e-01f, 5.43059647e-01f, 2.26402894e-01f, 3.91880363e-01f, 5.16153038e-01f, 4.26071376e-01f, 1.41464263e-01f, -7.42005091e-03f, 4.47954647e-02f,
  -7.78540447e-02f, -2.87029803e-01f, -2.75682688e-01f, -4.05655831e-01f, -5.35635464e-02f, -1.41733840e-01f, -6.85612485e-02f, 1.92767411e-01f, 4.68819410e-01f, 1.15008160e-01f,
  -2.05083162e-01f, 3.82409692e-02f, 1.98822320e-01f, 1.28913075e-02f, -2.70105362e-01f, -1.20174408e-01f, 9.24611166e-02f, 1.22012449e-02f, -2.16578171e-01f, -4.96984214e-01f,
  -1.19481802e-01f, 1.50595978e-01f, -3.43021266e-02f, -3.19271773e-01f, 5.50161637e-02f, 5.27395234e-02f, 1.47444278e-01f, 2.29932442e-02f, 8.28631595e-02f, -7.41606578e-02f,
  -3.10162622e-02f, -7.61579126e-02f, 4.06225808e-02f, -1.61341652e-02f, 2.76033968e-01f, 1.69868484e-01f, 4.79385210e-03f, -1.97414849e-02f, -7.33698457e-02f, -1.27226943e-02f,
  -2.19561011e-01f, 1.38688430e-01f, 4.16267328e-02f, 2.27110437e-03f, 8.88415053e-02f, 7.30860010e-02f, 2.70371754e-02f, -6.42415360e-02f, 1.92550108e-01f, -8.64085481e-02f,
  5.31040169e-02f, -1.83082595e-02f, -7.95323104e-02f, 5.31191984e-03f, 4.39373441e-02f, 6.30986616e-02f, 1.78843975e-01f, 5.26538305e-02f, 1.15222462e-01f, 1.16085252e-02f,
  -1.29132673e-01f, 6.54384727e-03f, 1.31856024e-01f, 5.76605555e-03f, -2.27814198e-01f, -5.45667931e-02f, 9.81853679e-02f, -1.33821398e-01f, -6.26893714e-02f, -8.76749083e-02f,
  -5.54293431e-02f, 6.49100915e-02f, 2.04697438e-03f, -7.10330009e-02f, -9.24082026e-02f, 6.06459938e-03f, 9.70350429e-02f, -1.40542984e-01f, 6.53341711e-02f, -8.08204859e-02f,
  -6.54196262e-01f, -6.48888275e-02f, -1.68986291e-01f, -1.57419488e-01f, 1.51821956e-01f, -6.31842017e-02f, -8.52112472e-02f, -1.26656294e-01f, -1.59322515e-01f, -8.32075551e-02f,
  3.21102291e-02f, 5.10469601e-02f, -5.24242930e-02f, 4.79489611e-03f, 2.33658031e-01f, 1.52205959e-01f, -1.20787397e-01f, 8.54939520e-02f, -1.65371090e-01f, -4.45877388e-02f,
  -1.78347215e-01f, 6.78247735e-02f, 4.99302149e-02f, 1.05487056e-01f, 1.34256154e-01f, 1.46876708e-01f, -5.99446334e-03f, 1.88638773e-02f, 1.35194018e-01f, 3.94509472e-02f,
  -1.74465757e-02f, -8.92182767e-01f, 5.02151787e-01f, -3.72887373e-01f, -1.16043545e-01f, -6.96857646e-02f, -4.00436878e-01f, -2.94891298e-01f, -2.63728559e-01f, -4.24952626e-01f,
  -1.82164818e-01f, 1.12292133e-01f, 1.33956149e-01f, 1.17832221e-01f, 3.28123540e-01f, -8.27343613e-02f, 2.47692883e-01f, 8.11737120e-01f, 7.67204583e-01f, -3.04441839e-01f,
  -2.77062356e-01f, -1.08212911e-01f, 2.65927732e-01f, 1.78666130e-01f, -7.39412189e-01f, 7.37634897e-02f, -7.04631209e-02f, -3.11411381e-01f, -6.25183135e-02f, -3.98343772e-01f,
  -2.11368233e-01f, -3.04951340e-01f, 3.30992222e-01f, 2.11673126e-01f, -6.56301081e-02f, 1.04864635e-01f, -9.97644942e-03f, -8.58941451e-02f, 7.31196702e-02f, -3.12938467e-02f,
  2.14747842e-02f, 7.51954839e-02f, 4.45483513e-02f, -1.48820326e-01f, -1.83711872e-01f, -9.04147997e-02f, -3.38079184e-02f, 8.43581930e-02f, 2.79904217e-01f, -2.83134639e-01f,
  -3.12138885e-01f, -9.92769003e-03f, 9.81138498e-02f, -1.37978539e-01f, -7.01478347e-02f, 3.24732006e-01f, -2.38585770e-01f, -5.23479097e-02f, 2.22231269e-01f, -5.99044740e-01f,
  2.85200719e-02f, -3.54299024e-02f, -9.72497836e-02f, -1.16033368e-02f, -3.90599445e-02f, -1.73165910e-02f, -1.21829482e-02f, -8.29391629e-02f, 1.39092759e-03f, 1.54412715e-04f,
  6.99073598e-02f, -5.97186238e-02f, 4.33231853e-02f, -6.52339906e-02f, -8.22840910e-03f, 1.92815550e-02f, -7.00461352e-03f, -7.76454508e-02f, -1.30394772e-02f, -1.42164761e-03f,
  3.94893773e-02f, 1.10529087e-01f, 7.89859220e-02f, -1.62886661e-02f, 1.14407420e-01f, 1.54059961e-01f, 6.08485453e-02f, 1.93505865e-02f, -5.08426726e-02f, 1.06758820e-02f,
  -1.83956012e-01f, 6.17181540e-01f, -1.97063953e-01f, 4.61174324e-02f, -4.33788002e-02f, 6.67302907e-02f, -6.54347474e-03f, 1.52938962e-01f, -1.09345168e-02f, -1.10403113e-01f,
  -6.98412061e-02f, 9.23315883e-02f, -2.76439954e-02f, -1.73563227e-01f, -2.62454059e-02f, -8.45482500e-05f, -5.87318242e-02f, 2.11843401e-02f, 8.86537954e-02f, -2.02357188e-01f,
  -4.10697609e-02f, 1.65479034e-01f, 5.97572103e-02f, -4.25306596e-02f, -1.23088263e-01f, 3.20174754e-01f, -4.16110456e-02f, -1.03612155e-01f, 3.03036243e-01f, -1.40731737e-01f,
  1.03177868e-01f, -9.48141236e-03f, -6.07213140e-01f, 5.35487831e-01f, 3.00793797e-01f, -4.62233990e-01f, -7.57142782e-01f, -3.93881053e-01f, 4.56185758e-01f, 1.02197565e-01f,
  3.43919694e-01f, 3.91390324e-01f, -6.02754578e-02f, -1.12214178e-01f, -4.20256168e-01f, -2.93474048e-01f, -1.44158509e-02f, -2.89549530e-01f, -3.86931926e-01f, 1.30983025e-01f,
  3.46454531e-01f, 3.15008163e-01f, 1.34933076e-03f, -8.50389898e-02f, 4.68389660e-01f, 1.84041947e-01f, 9.00649503e-02f, 3.50335300e-01f, 7.66772404e-02f, 2.54127085e-01f,
  -4.67277654e-02f, 3.00188307e-02f, -4.10784543e-01f, 6.58328682e-02f, 2.34968185e-01f, -4.38873649e-01f, -2.18941644e-01f, -2.27764636e-01f, -2.72700787e-01f, -2.83249915e-01f,
  2.22788334e-01f, -1.78342924e-01f, 2.34872535e-01f, -2.82232732e-01f, -8.01854953e-02f, -3.71138215e-01f, -2.46237963e-01f, -6.02643430e-01f, -1.70491144e-01f, -1.91396549e-01f,
  4.79730457e-01f, 4.71844077e-01f, -3.21044266e-01f, -3.15567136e-01f, -4.45454568e-01f, -6.79394901e-02f, -4.11363184e-01f, -1.19792879e-01f, -3.80209833e-01f, -1.87658310e-01f,
  2.83630621e-02f, -1.60086676e-01f, -1.11387536e-01f, 8.61139819e-02f, 6.14364818e-02f, -6.41082749e-02f, -2.63293716e-03f, -1.18727833e-01f, 1.65276006e-02f, -9.75912437e-02f,
  -2.21889138e-01f, -1.66751474e-01f, 4.42391112e-02f, 2.48215534e-02f, -1.35973573e-01f, -1.60470501e-01f, -7.76877925e-02f, -1.48908497e-04f, -1.90730646e-01f, -1.40326172e-02f,
  1.58067107e-01f, -1.31780624e-01f, 1.42477646e-01f, -6.55330867e-02f, 8.14210027e-02f, 8.87488350e-02f, -1.02566749e-01f, 9.52499546e-03f, -2.02997893e-01f, -4.31053936e-02f,
  2.52658188e-01f, -2.01291051e-02f, -9.11922157e-02f, -1.05183467e-01f, 1.80158898e-01f, -2.21858211e-02f, 1.51058912e-01f, -1.85031042e-01f, -7.36451969e-02f, -3.89829040e-01f,
  -4.22611572e-02f, -3.79241705e-01f, 1.75661951e-01f, -2.06526622e-01f, -6.12693373e-03f, -9.47010645e-04f, 4.15536612e-02f, -2.23364562e-01f, -4.55535389e-02f, 1.24267004e-01f,
  1.46521449e-01f, 3.77920009e-02f, -2.44345233e-01f, -4.35506642e-01f, 1.67975813e-01f, -9.83012766e-02f, -1.92184761e-01f, -1.44083172e-01f, -6.40498519e-01f, -4.40105468e-01f,
  1.33619726e-01f, -6.76921070e-01f, -5.84572017e-01f, -3.84507239e-01f, -1.95566520e-01f, 1.81792170e-01f, -2.09588856e-01f, 2.06500545e-01f, 1.08532935e-01f, -3.81811649e-01f,
  -5.24330921e-02f, 4.29992110e-01f, 1.51446164e-02f, 6.99799880e-02f, 7.67179132e-02f, -7.42618501e-01f, -5.99768281e-01f, -8.08577314e-02f, 4.87172991e-01f, 7.08761811e-01f,
  1.95288658e-01f, -3.98053974e-02f, 3.69203202e-02f, 6.15273975e-02f, -1.92196727e-01f, -7.28168860e-02f, -5.35915911e-01f, -2.30010480e-01f, -1.46129146e-01f, -6.10269368e-01f,
  -2.18189120e-01f, 2.93428302e-01f, 2.99616724e-01f, 1.90293610e-01f, -2.01406822e-01f, -2.21057478e-02f, -9.57245231e-02f, -6.84095100e-02f, -4.69878651e-02f, -2.04627573e-01f,
  -3.33959199e-02f, 7.89842103e-03f, -2.67337356e-02f, 1.12106971e-01f, -9.17922184e-02f, 1.18761569e-01f, 1.78128436e-01f, 5.25361449e-02f, -3.04605421e-02f, 7.14140236e-02f,
  -1.11432135e-01f, 6.99695200e-02f, 4.98991832e-02f, 2.59179264e-01f, 2.72176236e-01f, 1.09106831e-01f, 1.78852260e-01f, 3.81511182e-01f, 1.63011730e-01f, -4.84835468e-02f,
  -1.08224101e-01f, 6.92118239e-03f, 1.65141359e-01f, 5.06972447e-02f, 6.18675239e-02f, 5.61823361e-02f, -7.80386031e-02f, -7.05073029e-02f, 6.78981394e-02f, 5.88784227e-03f,
  -2.02794120e-01f, -8.00618678e-02f, 3.47490609e-02f, -7.06911087e-02f, 5.74192479e-02f, -1.73508618e-02f, -2.28631329e-02f, 1.20515108e-01f, 7.98724815e-02f, -8.84333160e-03f,
  1.10129997e-01f, 4.66560246e-03f, -1.62197411e-01f, 1.62910894e-01f, 5.33009805e-02f, -4.06093411e-02f, 5.68689816e-02f, 1.40202746e-01f, -1.13707557e-01f, -1.55840918e-01f,
  -1.47513047e-01f, 2.69537985e-01f, -2.39961550e-01f, 6.75390065e-02f, -1.49152711e-01f, -1.59189068e-02f, -4.02620062e-02f, -3.96307893e-02f, -1.10865176e-01f, 5.34737017e-03f,
  2.38155052e-01f, -2.83580832e-02f, -1.59589499e-01f, 9.36125144e-02f, 5.68725653e-02f, 8.04746896e-02f, 2.99339071e-02f, -3.34224440e-02f, 1.81920230e-01f, -1.70937598e-01f,
  -2.64027622e-02f, 2.84389220e-02f, 7.31405243e-03f, -3.90821369e-03f, 1.25182822e-01f, 4.29741442e-02f, 2.24540625e-02f, 4.04917225e-02f, -7.63278976e-02f, -4.31381434e-01f,
  6.84703767e-01f, 2.29892254e-01f, 9.06046778e-02f, 2.65359849e-01f, -1.55205876e-01f, 8.01735744e-02f, 2.74585664e-01f, 3.15452188e-01f, 3.13866943e-01f, 1.17655203e-01f,
  2.15698555e-02f, 2.08385110e-01f, 3.81825924e-01f, 3.63695323e-01f, 3.84301394e-01f, 3.99900764e-01f, 2.88630813e-01f, 2.25534320e-01f, 8.85463059e-02f, -1.04549043e-01f,
  1.08897924e-01f, 4.80326824e-02f, 2.47464236e-02f, 2.43269548e-01f, -5.30794859e-02f, 5.42942695e-02f, 1.49535701e-01f, -6.48706257e-02f, -2.87508406e-02f, 1.71659946e-01f,
  -3.43906730e-02f, 1.38480991e-01f, 5.00593632e-02f, -2.01938897e-02f, -2.22339556e-01f, 1.00118764e-01f, -8.24406371e-02f, -6.15872182e-02f, -7.17163086e-02f, -6.74923882e-02f,
  -1.92659125e-01f, -9.99307632e-02f, -1.66020021e-02f, -1.67937964e-01f, -2.93020308e-01f, -1.73441559e-01f, -3.40006538e-02f, 1.85699746e-01f, 2.19714686e-01f, 1.44907594e-01f,
  -1.11259893e-01f, -7.53672123e-02f, 1.06244246e-02f, -1.56835813e-04f, 8.41077790e-02f, 3.37724611e-02f, -7.36857653e-02f, 1.38620466e-01f, 1.12953782e-01f, 2.09454283e-01f,
  2.04607278e-01f, 1.47366986e-01f, 1.23882927e-02f, 8.22045803e-02f, 4.46772166e-02f, -1.99617952e-01f, -2.70702153e-01f, -1.54227495e-01f, 1.03348762e-01f, -6.92624673e-02f,
  -2.21034452e-01f, 7.48276263e-02f, 6.22944683e-02f, -6.54328167e-02f, -6.42260090e-02f, 5.72001003e-02f, -4.61443849e-02f, 5.81963919e-02f, -1.46828741e-01f, 1.12554319e-01f,
  3.25331697e-03f, -7.86128119e-02f, -2.40119055e-01f, -9.35111493e-02f, -4.76944409e-02f, -3.38642076e-02f, -3.21601368e-02f, 7.61398375e-02f, -4.13147472e-02f, 4.04655673e-02f,
  1.34891391e-01f, 4.38357890e-03f, 1.45351529e-01f, 3.75702262e-01f, -9.74678621e-02f, -2.04798862e-01f, 1.33274093e-01f, -7.50537664e-02f, -2.78004885e-01f, -2.08869390e-02f,
  -2.04371631e-01f, -2.90867072e-02f, -1.73944771e-01f, -1.84999213e-01f, -3.41439515e-01f, -2.39898846e-01f, -6.41384125e-02f, 2.73270030e-02f, 1.35156170e-01f, -3.44001576e-02f,
  2.39700843e-02f, 5.13861477e-02f, 1.32610677e-02f, -6.88856989e-02f, 1.40361026e-01f, 3.54211219e-02f, -2.01009169e-01f, -1.84575185e-01f, -5.10619096e-02f, -7.37633854e-02f,
  7.28672326e-01f, -6.57414019e-01f, 5.56994796e-01f, 5.27282178e-01f, 5.54729700e-01f, 6.16766751e-01f, 3.74365598e-01f, 1.62640348e-01f, 2.11313412e-01f, 3.14706676e-02f,
  -1.36957198e-01f, -9.19071436e-02f, -9.80167463e-03f, -1.72876075e-01f, -8.48558173e-02f, 3.45235541e-02f, 1.89362496e-01f, 1.08808935e-01f, 3.61696333e-01f, 2.98953801e-01f,
  -8.16658586e-02f, 1.03966303e-01f, -8.67009722e-03f, -4.29155491e-02f, -1.20699011e-01f, 1.00703806e-01f, -9.43006426e-02f, -1.65425584e-01f, -2.20119029e-01f, -2.00405642e-01f,
  -6.90345764e-02f, -2.55395144e-01f, 1.46183968e-01f, -1.25656813e-01f, -1.46812394e-01f, -3.86849418e-02f, 5.81515655e-02f, -1.42728940e-01f, -8.82897526e-02f, -1.43389240e-01f,
  -9.26832929e-02f, -7.31956586e-02f, -7.39039406e-02f, -1.25313431e-01f, 2.30107605e-02f, -3.46750543e-02f, -2.68899828e-01f, -8.24694782e-02f, -1.20435292e-02f, -1.19259633e-01f,
  -1.57839462e-01f, 1.03430459e-02f, 8.27084556e-02f, 1.03429846e-01f, 2.14404799e-02f, 7.58217201e-02f, -1.07012197e-01f, -2.92539014e-03f, 6.84449077e-02f, -2.34632473e-02f,
  1.66512132e-01f, 1.58048347e-01f, 1.16948768e-01f, -2.62752157e-02f, -5.90324365e-02f, 7.14023486e-02f, -4.21993621e-02f, -1.02802828e-01f, 7.67589211e-02f, 9.36532579e-03f,
  -5.30383773e-02f, 9.14918631e-02f, 4.66195755e-02f, -4.90522832e-02f, 1.97938666e-01f, 1.91699415e-01f, 5.87753858e-03f, -1.01689070e-01f, -7.53169730e-02f, 1.30772397e-01f,
  -1.76302828e-02f, 1.12998001e-02f, -2.75707953e-02f, -7.87163302e-02f, -1.88394248e-01f, -1.48947224e-01f, 2.16734260e-02f, -4.19718027e-02f, -1.05715923e-01f, 3.55417766e-02f,
  -3.13251615e-01f, -5.57996742e-02f, -2.01780749e-05f, -2.03376144e-01f, -4.95935231e-02f, -2.07841739e-01f, -3.27886082e-02f, -8.38754103e-02f, -1.60632476e-01f, -1.18649848e-01f,
  -1.00950778e-01f, -1.65049821e-01f, -1.99852899e-01f, -3.39702703e-02f, 5.54048084e-02f, 5.43819293e-02f, -2.19822720e-01f, 3.23194005e-02f, 7.95900002e-02f, -1.61299221e-02f,
  -3.04299742e-02f, 6.80342093e-02f, 1.70043185e-01f, 1.45028129e-01f, -4.73936722e-02f, 1.97200119e-01f, 8.03846344e-02f, 1.01237133e-01f, 1.44982889e-01f, -1.83196226e-03f,
  -2.91582018e-01f, -5.74459732e-01f, -4.26295966e-01f, -5.15360534e-01f, -4.69491065e-01f, -2.55126238e-01f, -1.75434127e-01f, -1.19634643e-01f, -3.95481735e-01f, -2.44549632e-01f,
  7.48862571e-04f, 5.85243106e-01f, 3.37626368e-01f, 3.62901449e-01f, 4.69170243e-01f, -2.39191905e-01f, -5.48531592e-01f, 1.31742787e-02f, 6.74403429e-01f, 4.48232174e-01f,
  1.69603124e-01f, -1.00273810e-01f, -1.36394262e-01f, -1.24948300e-01f, -4.10514146e-01f, 1.28400475e-02f, -5.88885784e-01f, -3.95134360e-01f, -1.56136677e-01f, -7.21393943e-01f,
  7.54541576e-01f, -5.15705347e-01f, 3.90603882e-03f, -2.44836092e-01f, -2.22881898e-01f, -1.77397922e-01f, -4.48425785e-02f, -3.72277468e-01f, -2.17483953e-01f, -2.03656957e-01f,
  -2.81517506e-01f, -8.00215602e-02f, 9.37741324e-02f, -4.16815057e-02f, 9.35488567e-03f, -1.96352247e-02f, -1.85099334e-01f, -1.89771742e-01f, -1.81048512e-01f, -1.95727739e-02f,
  -1.54408664e-01f, -1.34443372e-01f, 1.34142891e-01f, 1.00198232e-01f, -8.76615047e-02f, 9.27776098e-02f, -1.17442079e-01f, -8.05190876e-02f, -1.14602044e-01f, -1.97508354e-02f,
  1.39787540e-01f, 2.13318765e-02f, -6.38038144e-02f, -2.52564475e-02f, 2.46341825e-02f, 6.78628236e-02f, 5.03355600e-02f, 1.72713935e-01f, -5.84952272e-02f, 3.17270570e-02f,
  -1.88771561e-02f, -1.08083086e-02f, 1.51810363e-01f, -6.33952767e-02f, -1.39755964e-01f, -7.34069869e-02f, 8.26866925e-02f, -3.23101431e-02f, -1.53538913e-01f, -7.00235739e-02f,
  -4.21287417e-02f, -9.19700935e-02f, -1.02234393e-01f, 1.23531073e-01f, -2.29108423e-01f, -7.38043860e-02f, -1.60723384e-02f, 1.40836937e-02f, 6.22008182e-02f, -1.14509523e-01f,
  7.34416008e-01f, -6.22005574e-02f, 2.69121587e-01f, 4.12641540e-02f, -1.70218885e-01f, -2.00925440e-01f, -5.95684573e-02f, -1.44644961e-01f, -1.73152998e-01f, 1.27256110e-01f,
  -2.03231335e-01f, 1.39110506e-01f, -2.05007084e-02f, -9.81839187e-03f, 7.75290355e-02f, -3.49248275e-02f, -1.83132812e-01f, 1.12267591e-01f, -6.26732260e-02f, 2.51775701e-02f,
  -1.97665066e-01f, 1.81335628e-01f, 5.66136658e-01f, 3.75156611e-01f, 6.69039935e-02f, 4.51916307e-01f, 3.62730324e-01f, 2.60839611e-01f, 4.29879159e-01f, 3.64697129e-01f,
  -1.11846995e+00f, -4.80657369e-01f, -2.61314154e-01f, -4.29170787e-01f, -1.95509233e-02f, -1.87107876e-01f, -5.00269413e-01f, -7.70245790e-02f, 2.62334019e-01f, -1.08070865e-01f,
  4.46752133e-03f, -5.11457883e-02f, -7.51306117e-02f, -1.65010139e-01f, -6.28123760e-01f, -4.11594987e-01f, -4.10337836e-01f, -3.68652791e-01f, -3.22790712e-01f, 3.99462916e-02f,
  -7.09170699e-02f, -3.21494877e-01f, -4.19407636e-01f, -1.80308163e-01f, 4.78057005e-02f, -6.69543445e-02f, 2.50675459e-03f, -2.21339732e-01f, -2.05259427e-01f, -4.36419487e-01f,
  4.59825038e-04f, -3.93003792e-01f, 2.95971364e-01f, 1.09929278e-01f, 8.18220824e-02f, 4.30124439e-02f, 1.73772022e-01f, 1.97619021e-01f, 1.49871156e-01f, 1.33798718e-01f,
  -1.65360764e-01f, 2.14532658e-01f, 3.55553329e-02f, 2.95453388e-02f, -1.09000228e-01f, -8.11664108e-03f, -2.40213946e-02f, -1.54417098e-01f, -9.18686911e-02f, 1.40262827e-01f,
  -2.35795267e-02f, -2.20246673e-01f, -5.86248577e-01f, -2.96681702e-01f, -1.28756478e-01f, 2.35670134e-02f, -3.97736952e-02f, 8.51755366e-02f, -3.09453428e-01f, -4.74059314e-01f,
  1.58219323e-01f, 1.13883920e-01f, 4.09474634e-02f, -6.44079670e-02f, -1.43082291e-02f, 1.00845672e-01f, 7.24204928e-02f, 9.65154544e-02f, 2.05299914e-01f, 1.23194493e-02f,
  2.79425811e-02f, 1.82946362e-02f, -2.49582976e-02f, -6.93150684e-02f, -1.10676870e-01f, -1.09692052e-01f, -1.00683995e-01f, -1.73523858e-01f, -1.57946885e-01f, -1.44591630e-02f,
  -9.23776552e-02f, -5.76537475e-02f, 1.85211062e-01f, -1.02384329e-01f, -1.93544209e-01f, -3.72578427e-02f, 5.78442328e-02f, -4.41390276e-02f, 7.65958205e-02f, 1.60192862e-01f,
  -1.04671098e-01f, -1.48364101e-02f, -1.72742277e-01f, -1.90487444e-01f, -2.62475878e-01f, 1.22371562e-01f, -7.72863030e-02f, 1.73057634e-02f, 1.30963430e-01f, 2.16020867e-02f,
  -9.56840143e-02f, 3.06370649e-02f, 1.06293701e-01f, 1.18561303e-02f, 1.23758115e-01f, -1.30230814e-01f, -4.17504966e-01f, -9.07040760e-02f, -2.56957531e-01f, 8.35159272e-02f,
  -2.08841473e-01f, -6.96780026e-01f, -9.28019881e-01f, -5.81011772e-01f, -1.05352364e-01f, -4.72579539e-01f, -3.64263594e-01f, -1.71989202e-01f, -4.79988486e-01f, -8.46770704e-01f,
  3.34151417e-01f, 2.37052798e-01f, 6.30056381e-01f, 3.28359395e-01f, -5.14114261e-01f, -3.27260286e-01f, -3.64131123e-01f, -1.22373275e-01f, -3.05849433e-01f, -2.21870586e-01f,
  -5.67387342e-01f, -3.09118509e-01f, -4.55054305e-02f, 1.71469823e-01f, 2.43310481e-01f, 2.89782673e-01f, 5.96309960e-01f, 7.05526292e-01f, 2.04127207e-01f, -1.28370523e-01f,
  -1.54324761e-02f, 1.17825434e-01f, 3.56695443e-01f, 2.93213367e-01f, 1.74490154e-01f, -1.69607267e-01f, 1.87211588e-01f, 2.29021013e-01f, 1.23285241e-01f, 9.00984108e-01f,
  1.59666874e-02f, 2.88871229e-01f, -2.44367987e-01f, -1.53405145e-01f, -6.25147447e-02f, 1.81288928e-01f, -1.04561500e-01f, 1.89175084e-01f, -2.57459898e-02f, 9.97851640e-02f,
  -1.59112811e-02f, 8.94962475e-02f, -1.02509193e-01f, -1.65448766e-02f, -1.27486020e-01f, 1.37746260e-02f, 2.35871777e-01f, 4.15186495e-01f, 7.08998442e-02f, -2.38812223e-01f,
  7.89246336e-02f, -2.76539356e-01f, -1.60799578e-01f, -3.56986195e-01f, 9.48696658e-02f, -1.34397745e-01f, -9.28616077e-02f, 2.50070363e-01f, -1.64476007e-01f, 3.65023166e-01f,
  -1.45345375e-01f, 7.23427460e-02f, 1.42504387e-02f, 2.90822923e-01f, 4.70555499e-02f, 8.67299810e-02f, 2.81779528e-01f, 5.91142364e-02f, -3.51129882e-02f, 1.53857380e-01f,
  -5.77661507e-02f, -1.57505304e-01f, 2.56494079e-02f, -6.17106305e-03f, -2.31483385e-01f, 5.48554882e-02f, -1.49343237e-01f, 1.03687219e-01f, -6.23657741e-02f, 5.02198152e-02f,
  -1.85179636e-02f, 1.51746839e-01f, -6.29628003e-02f, 1.67830080e-01f, -1.95607468e-01f, 2.29718074e-01f, -1.37068570e-01f, -1.59611218e-02f, -5.15874997e-02f, -1.05135411e-01f,
  -4.41555619e-01f, -1.07851893e-01f, -2.42785305e-01f, 8.14316049e-02f, -1.74643889e-01f, -7.71863386e-02f, 1.94273947e-03f, -2.19107985e-01f, -9.28609073e-02f, 1.41206821e-02f,
  -2.95630276e-01f, 1.21791065e-01f, -1.86328322e-01f, 1.97733819e-01f, 8.51560943e-03f, -1.15496017e-01f, -1.62116647e-01f, -2.24592432e-01f, -2.00530991e-01f, -8.58136415e-02f,
  -8.42531025e-03f, -2.42594868e-01f, -4.26794380e-01f, -3.22564483e-01f, -5.17920852e-01f, -6.34901345e-01f, -3.51733506e-01f, -2.42518291e-01f, -5.75201452e-01f, -4.66632038e-01f,
  -3.88629213e-02f, 6.05658889e-01f, 4.61563587e-01f, -5.38310945e-01f, 2.39879772e-01f, 4.74843651e-01f, 7.30639517e-01f, 3.11189264e-01f, -4.09039617e-01f, 1.80385724e-01f,
  4.49430734e-01f, -3.53438914e-01f, -1.90121055e-01f, -2.23000750e-01f, 2.26136208e-01f, 1.94964662e-01f, -1.15004294e-01f, -8.52349699e-02f, -9.95904282e-02f, -9.43337902e-02f,
  -2.69223124e-01f, -1.85338587e-01f, -1.53577805e-01f, -2.20971346e-01f, -4.15551722e-01f, -4.46187705e-01f, 8.08785670e-03f, 8.60156342e-02f, 3.90513390e-01f, -4.04059559e-01f,
  2.07000434e-01f, 3.48595262e-01f, -3.52629244e-01f, -1.85613841e-01f, 1.17723003e-01f, -1.90505072e-01f, -1.63722038e-01f, -1.40827030e-01f, -2.91814320e-02f, -2.22292289e-01f,
  3.63061130e-02f, 7.92280957e-03f, 1.07545704e-02f, 5.01606241e-02f, 7.49858692e-02f, 3.55797410e-02f, -9.46316049e-02f, 7.99723417e-02f, 4.99941371e-02f, 2.48318031e-01f,
  -1.62501544e-01f, 2.79936969e-01f, 3.32185924e-01f, 8.55829474e-03f, 7.80208185e-02f, -2.82141939e-02f, 2.46170551e-01f, -6.85159490e-02f, 1.96923763e-01f, -4.29709882e-01f,
  -9.93563756e-02f, -9.53999236e-02f, 3.04221828e-03f, -1.39894992e-01f, 3.33743915e-02f, -4.10472900e-02f, -9.06836912e-02f, 5.73340282e-02f, -9.85921845e-02f, -1.53940231e-01f,
  3.45801152e-02f, 7.11807748e-03f, 3.79113033e-02f, -7.72811770e-02f, -1.76254630e-01f, 8.00502226e-02f, 1.40801137e-02f, -5.17929308e-02f, 4.24060896e-02f, -5.07150171e-03f,
  1.72042176e-02f, 3.80202420e-02f, -1.91209242e-02f, 3.38229537e-02f, 7.78557956e-02f, -1.66759174e-02f, -2.02051222e-01f, 1.32355355e-02f, -1.24302253e-01f, 2.53597498e-02f,
  -3.13423038e-01f, 3.36999476e-01f, -2.69351631e-01f, 3.85295190e-02f, 2.29952447e-02f, 1.19327353e-02f, -1.70778438e-01f, -4.64580916e-02f, -3.71745490e-02f, -1.69427976e-01f,
  1.37020782e-01f, -1.92534357e-01f, 2.07840815e-01f, -3.63233313e-03f, -1.86721116e-01f, -8.66127238e-02f, 1.54413702e-02f, -1.19290642e-01f, 7.85685554e-02f, 3.68133821e-02f,
  -2.21953150e-02f, -1.74229339e-01f, -1.85601071e-01f, -2.17608392e-01f, -1.52007222e-01f, -2.44817793e-01f, -7.39585608e-02f, -7.90979899e-03f, 2.61778921e-01f, -3.92756402e-01f,
  7.20550179e-01f, 3.50990564e-01f, 1.46482781e-01f, 3.14633429e-01f, 4.55665886e-01f, 3.39345664e-01f, 1.87564045e-01f, 1.25545189e-01f, 1.37843549e-01f, 4.14333224e-01f,
  4.92263407e-01f, 5.45626223e-01f, 3.65641534e-01f, 2.50077009e-01f, 4.91693094e-02f, 1.02443442e-01f, -7.13628111e-03f, -5.32497317e-02f, 1.15367495e-01f, 1.37161374e-01f,
  3.32670808e-01f, 1.55866057e-01f, -5.71241155e-02f, -6.21688440e-02f, 1.53083980e-01f, 3.62535596e-01f, 2.54096806e-01f, 3.43191475e-01f, 3.21059585e-01f, 8.33124667e-02f,
  4.18275446e-01f, 2.15347707e-01f, -6.65928125e-02f, 1.64837748e-01f, 1.52989075e-01f, -2.54574329e-01f, -9.50156748e-02f, -3.12636971e-01f, 8.53520483e-02f, -1.41765967e-01f,
  -8.00623670e-02f, -1.31585017e-01f, -1.31699508e-02f, -2.37268396e-02f, -7.73264989e-02f, -1.44106448e-01f, -1.34652719e-01f, -1.83063298e-01f, -1.20308004e-01f, -5.19693308e-02f,
  -7.71860778e-02f, -2.49020942e-02f, -5.26428185e-02f, -1.69974238e-01f, -1.21600941e-01f, 1.28199220e-01f, 8.52287784e-02f, 2.22311094e-02f, -1.90433174e-01f, -2.27363557e-01f,
  2.69381851e-01f, 1.31249309e-01f, 3.32220435e-01f, 2.48424113e-01f, 3.92101169e-01f, 1.99269995e-01f, 2.39995942e-02f, 1.44787535e-01f, 8.46094638e-02f, -3.42893191e-02f,
  4.51438548e-03f, 1.10697962e-01f, -1.97705090e-01f, -1.05826341e-01f, 2.07819581e-01f, 5.24824187e-02f, -9.18742865e-02f, 3.47518059e-03f, 1.17838487e-01f, 9.70287472e-02f,
  3.90063748e-02f, -1.24652281e-01f, 6.49188831e-02f, -1.46998212e-01f, -4.36654873e-02f, 7.78306872e-02f, 1.11881113e-02f, 8.06977898e-02f, 1.09711915e-01f, -5.78233600e-02f,
  -3.23978662e-01f, 9.60917249e-02f, 2.28938043e-01f, -1.13147266e-01f, 4.79332823e-03f, -1.39409825e-01f, 1.28552407e-01f, -8.12095255e-02f, 1.19780399e-01f, -5.84716685e-02f,
  -1.21355847e-01f, -1.03602558e-01f, -1.17190175e-01f, -1.63218543e-01f, -2.45441183e-01f, -1.36059433e-01f, 1.50808439e-01f, -1.18827619e-01f, -1.89079553e-01f, -1.69471264e-01f,
  -1.67655498e-01f, -2.52805918e-01f, -3.22386324e-01f, -2.09041268e-01f, -1.79362744e-01f, -7.92671740e-02f, -1.27012447e-01f, -8.50342810e-02f, -1.31721824e-01f, -3.06693673e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  7.38655329e-01f, 5.73162615e-01f, 5.45478106e-01f, 2.88856000e-01f, 7.90434003e-01f, 6.18898273e-01f, -2.96486504e-02f, 2.56306320e-01f, 3.05837065e-01f, 1.13239622e+00f,
  5.38373351e-01f, 9.70235527e-01f, 7.22685933e-01f, 9.72850323e-01f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  1.22388184e-01f, -9.90118980e-02f, -2.06610188e-01f, -3.74299377e-01f, 3.99126559e-02f, -1.41091660e-01f, -3.09075981e-01f, -6.35056868e-02f, -3.23400944e-01f, 1.90470237e-02f,
  -1.44774407e-01f, 2.17488296e-02f, -7.83274174e-02f, 2.76928693e-01f, -1.71832770e-01f, 6.04690835e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  4.97433871e-01f, 1.19826376e-01f, 1.11351836e+00f, 4.47698474e-01f, 3.80037054e-02f, 2.11970106e-01f, -1.55275002e-01f, 5.76513588e-01f, -4.99934077e-01f, 4.66346443e-02f,
  1.54266149e-01f, -8.78243074e-02f, -1.48650572e-01f, 5.00409305e-01f, -1.21624613e+00f, -3.46727967e-02f, 1.39024347e-01f, 4.99315113e-02f, -2.83945829e-01f, -1.00727558e+00f,
  -1.21265836e-02f, -5.64834364e-02f, 9.83140111e-01f, 5.22197664e-01f, 7.46645033e-01f, -1.12555824e-01f, 1.10683501e-01f, -2.21156403e-01f, 6.63942873e-01f, 1.01627517e+00f,
  -5.00823021e-01f, 3.90089005e-01f, 1.12287819e+00f, 3.89695466e-01f, 1.10910453e-01f, 1.85857952e-01f, 2.33550265e-01f, -7.12478399e-01f, -8.86801817e-03f, 5.73934197e-01f,
  -1.15036166e+00f, -5.59126884e-02f, -3.19729447e-01f, 1.86162785e-01f, 1.02501467e-01f, 3.43700081e-01f, -7.27820516e-01f, 1.42100543e-01f, 4.52988118e-01f, 8.06524605e-02f,
  3.31261635e-01f, 4.30575013e-01f, -4.79415506e-02f, 2.92309195e-01f, 1.29566920e+00f, -1.19155478e-02f, -1.02605891e+00f, -1.08462475e-01f, 8.21867347e-01f, 9.27265644e-01f,
  -1.48286954e-01f, -8.05276483e-02f, -8.67864788e-01f, 9.06284228e-02f, 7.38929063e-02f, 7.22983405e-02f, -7.61034608e-01f, 1.13878226e+00f, 2.49418244e-01f, -5.06431639e-01f,
  7.66662002e-01f, -4.53868359e-01f, -4.74671423e-02f, 2.81811357e-01f, -1.58829570e-01f, -2.00084642e-01f, 1.84541140e-02f, 9.30793285e-01f, 3.76576483e-01f, -2.11910889e-01f,
  6.26151025e-01f, -2.73634106e-01f, -1.27612603e+00f, 1.70914963e-01f, 6.33462906e-01f, -2.24598832e-02f, 2.18196526e-01f, -1.00684136e-01f, -3.10087651e-01f, 3.54828209e-01f,
  -2.30717897e-01f, -4.11243141e-01f, 2.80339748e-01f, 5.79237759e-01f, 9.89233077e-01f, -1.31384641e-01f, 3.08673948e-01f, -5.42021580e-02f, 8.33249688e-01f, 7.31226921e-01f,
  -5.18503562e-02f, 5.70698857e-01f, 7.45362520e-01f, 2.56229132e-01f, 5.80999076e-01f, -1.54192612e-01f, 8.37945282e-01f, 7.40406513e-01f, -7.42007270e-02f, -1.46912143e-01f,
  8.04319680e-01f, 7.32408881e-01f, 1.52951896e-01f, 2.53338695e-01f, -6.06079519e-01f, -6.86626357e-04f, -3.16733330e-01f, -2.28684306e-01f, -9.96008277e-01f, 7.38102198e-01f,
  -1.53745130e-01f, 4.04539764e-01f, 1.62816927e-01f, -1.60458490e-01f, -2.92789280e-01f, 5.62055767e-01f, -3.28771710e-01f, 8.70764613e-01f, 1.96907613e-02f, -5.71861386e-01f,
  8.06242228e-01f, -1.31023574e+00f, 5.65618753e-01f, 1.96151510e-01f, -3.78046423e-01f, 8.08902264e-01f, 1.29019648e-01f, 4.39603955e-01f, 8.96618739e-02f, -3.46647501e-01f,
  1.38236523e-01f, 3.49311042e-03f, -3.96758974e-01f, 4.59497780e-01f, -1.76817909e-01f, -8.37791041e-02f, -1.47823811e-01f, 9.50200796e-01f, 2.57963926e-01f, -2.54581153e-01f,
  5.55733025e-01f, -2.21986994e-02f, 6.91329777e-01f, 2.58855432e-01f, 1.74866756e-03f, 9.21131372e-01f, 2.96590805e-01f, -1.08921356e-01f, 2.83376157e-01f, 1.95658728e-01f,
  6.55186594e-01f, 5.79807818e-01f, -7.41507053e-01f, -2.44726494e-01f, -2.24101722e-01f, 2.78176844e-01f, -1.62876055e-01f, 2.44687289e-01f, -1.59531921e-01f, -5.22637606e-01f,
  -6.75563812e-02f, 6.43240869e-01f, 1.39819616e-02f, 2.53866583e-01f, 1.04800725e+00f, 3.89606029e-01f, 1.99199587e-01f, -2.65707493e-01f, 5.32580316e-01f, 9.31109309e-01f,
  4.41804737e-01f, -7.56544352e-01f, -1.17951703e+00f, 9.00468111e-01f, 2.08161965e-01f, -5.29284716e-01f, -1.95426628e-01f, 3.36410254e-02f, 9.13814664e-01f, -3.12070072e-01f,
  -6.39951527e-01f, 3.57648313e-01f, -5.60663491e-02f, -5.29857695e-01f, 6.43790364e-01f, 2.75547206e-01f, 4.30098563e-01f, -8.14764917e-01f, 7.23960638e-01f, -3.87297273e-01f,
  -2.86181401e-02f, -2.65498281e-01f, -8.13080609e-01f, 8.02433610e-01f, -5.59267253e-02f, 1.60571635e-01f, 1.44221276e-01f, 1.36968896e-01f, 4.29042399e-01f, -2.30679333e-01f,
  -1.13040291e-01f, 4.89794612e-02f, 7.53186464e-01f, -6.18987203e-01f, -8.92465591e-01f, 6.45424068e-01f, 2.82359779e-01f, -6.25472665e-01f, -2.76141465e-01f, 5.77175021e-01f,
  9.12989736e-01f, -4.77746129e-01f, -3.94936830e-01f, 5.82066476e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  8.29618931e-01f, 3.82900804e-01f, 9.87869322e-01f, 5.23441672e-01f, 3.12609553e-01f, 5.44007480e-01f, -1.82189405e-01f, 9.21734095e-01f, 3.38659912e-01f, -4.02839303e-01f,
  5.68259776e-01f, 3.92338604e-01f, 2.65208725e-02f, 9.80745614e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  -6.81848168e-01f, 9.87825990e-01f, -3.86189520e-01f, 4.26558614e-01f, -7.36390650e-01f, -6.20468080e-01f, -4.87130076e-01f, -1.03713715e+00f, 2.42721751e-01f, -8.05720210e-01f,
  8.73201564e-02f, 1.62931904e-01f, -4.82725263e-01f, 4.29389149e-01f, -7.86031708e-02f, 2.80460477e-01f, -5.31258583e-01f, -1.15814544e-01f, -3.22468132e-01f, -7.98194706e-02f,
  -9.96836901e-01f, 2.48038977e-01f, -8.44209671e-01f, -1.63131058e-01f, 4.05922949e-01f, 4.23486710e-01f, 4.00239021e-01f, 3.71192813e-01f, -1.03343701e+00f, -9.25364316e-01f,
  6.37208223e-01f, -5.09008706e-01f, 1.32042095e-01f, -8.75901103e-01f, 2.48956066e-02f, 9.67653692e-01f, 6.96368933e-01f, -4.94326837e-02f, 4.59123433e-01f, 4.20567542e-02f,
  5.14511503e-02f, -1.14865649e+00f, -1.81105554e-01f, -2.70226032e-01f, -2.90983111e-01f, -6.33044422e-01f, 1.16200626e-01f, -8.48717511e-01f, -2.15490982e-01f, -1.87569797e-01f,
  -8.93109620e-01f, -4.78019625e-01f, -5.76752424e-01f, -9.05805528e-01f, 6.91645682e-01f, 4.74645704e-01f, 2.14798208e-02f, -9.07519400e-01f, -8.53804469e-01f, 5.62460721e-01f,
  -2.54281104e-01f, -1.73655804e-03f, 6.07748210e-01f, 1.82198733e-01f, 5.51254809e-01f, -9.50177133e-01f, -4.67755377e-01f, 1.74428612e-01f, 1.39725819e-01f, -2.61409283e-01f,
  -4.38275695e-01f, 5.79577923e-01f, -8.59952331e-01f, -1.58118114e-01f, 5.81033409e-01f, -1.41764134e-01f, -4.73990113e-01f, 2.05299020e-01f, -4.56760041e-02f, 4.45170075e-01f,
  -1.75794110e-01f, -8.08892250e-01f, 7.52090454e-01f, -1.26116335e+00f, 4.64401335e-01f, 2.28966847e-02f, -9.26227808e-01f, -5.86807370e-01f, 2.14221664e-02f, -2.00422723e-02f,
  4.78964806e-01f, -5.68242729e-01f, -7.87447035e-01f, 5.97760677e-01f, 2.80495465e-01f, -1.54910693e-02f, -4.85735238e-01f, 8.46376359e-01f, 4.20653164e-01f, 5.76919794e-01f,
  3.18505764e-01f, -3.90933663e-01f, 3.29733461e-01f, 1.87467918e-01f, -1.12908542e+00f, 4.54041034e-01f, 1.98208794e-01f, -7.79536545e-01f, -6.37700409e-02f, -1.54364777e+00f,
  -5.47885597e-01f, -1.59986997e+00f, -8.42505991e-02f, -2.03983024e-01f, 1.33295089e-01f, -1.19216895e+00f, 1.76961035e-01f, -3.82432193e-02f, 6.52377427e-01f, 4.60830182e-01f,
  -3.96039188e-01f, 3.14810276e-01f, -2.07997277e-01f, 5.69564223e-01f, -7.72677600e-01f, 1.55154914e-01f, -7.21808374e-01f, -5.44888198e-01f, -1.93114161e-01f, -3.89117867e-01f,
  6.75189078e-01f, -5.65044045e-01f, -4.06552076e-01f, 9.71077323e-01f, 1.94082260e-01f, -7.15063274e-01f, 5.49543440e-01f, -4.20746684e-01f, -9.57576215e-01f, -3.15033346e-01f,
  1.72960848e-01f, -9.08230901e-01f, -1.07296014e+00f, -1.02698219e+00f, 3.04017395e-01f, 7.09235013e-01f, 2.58146584e-01f, 1.71194032e-01f, 6.30573869e-01f, -3.12618881e-01f,
  -6.35409534e-01f, -4.34511811e-01f, -7.35287666e-01f, 3.87905777e-01f, 9.83608216e-02f, -8.24111402e-01f, 4.76000577e-01f, 4.17640477e-01f, -6.90919638e-01f, 3.21843743e-01f,
  1.07065141e-01f, 7.62723088e-01f, -9.58196521e-01f, -7.82602549e-01f, 4.19185251e-01f, 4.57272232e-01f, -3.22616637e-01f, -7.42081463e-01f, -1.00049026e-01f, -5.87095201e-01f,
  -1.16148973e+00f, 1.56621248e-01f, 8.43418717e-01f, -3.97492588e-01f, 2.37265423e-01f, 4.00337547e-01f, 5.27853221e-02f, -2.53009140e-01f, -3.89472723e-01f, -5.61205208e-01f,
  -6.66258991e-01f, -9.06386852e-01f, -1.43180341e-02f, 5.96188068e-01f, 4.70321983e-01f, 2.09440794e-02f, -5.47156453e-01f, 1.16439581e-01f, 1.16197741e+00f, -8.34187984e-01f,
  -5.24352133e-01f, -2.67519027e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -5.38299799e-01f, -6.69517030e-04f, 3.06872964e-01f, -1.35604024e-01f, 3.66676420e-01f, 1.52319774e-01f, 4.26687479e-01f, 4.71359827e-02f, 2.10789949e-01f, -8.33347365e-02f,
  -2.38414347e-01f, 2.33102366e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    