/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.25093770e-01f, 1.67969242e-02f, 3.16724740e-02f, 5.37245236e-02f, 2.39038080e-01f, 3.65198366e-02f, 6.14884449e-03f, -3.85208167e-02f, 1.08125947e-01f, 2.28218902e-02f,
  2.52059475e-02f, 1.79836527e-02f, 2.96187717e-02f, -2.74870195e-03f, -1.39673069e-01f, 1.23135351e-01f, 1.46925777e-01f, -2.81776600e-02f, -2.82665640e-01f, -1.37929961e-01f,
  9.83375125e-03f, -4.91876118e-02f, -1.13307454e-01f, -9.94609147e-02f, 1.59775317e-01f, 2.00701430e-02f, 1.15809336e-01f, 2.28454173e-02f, 6.99631423e-02f, 2.31242210e-01f,
  -7.53931925e-02f, -1.50728419e-01f, -2.58707665e-02f, 2.69367937e-02f, 1.63476244e-02f, -3.96717973e-02f, -2.23470218e-02f, 4.28146608e-02f, -1.77999008e-02f, -2.78323274e-02f,
  4.01299745e-02f, -7.18687400e-02f, -1.17619010e-02f, -8.65783449e-03f, -6.03614822e-02f, -4.62250188e-02f, 3.27109806e-02f, -1.99846506e-01f, -5.74621111e-02f, -1.63276583e-01f,
  1.43880725e-01f, 9.29263905e-02f, -3.90749983e-02f, -7.11938217e-02f, -1.58153087e-01f, 4.19415347e-02f, 2.50911787e-02f, -1.05253100e-01f, -1.22718215e-01f, -5.96207194e-02f,
  -1.30816875e-03f, 4.64675203e-02f, 3.42311375e-02f, -3.31693031e-02f, -5.14793061e-02f, 2.21287087e-02f, 2.29961481e-02f, 6.29966110e-02f, -2.64204945e-02f, -2.11578999e-02f,
  6.50693625e-02f, -1.29947346e-02f, 2.78453939e-02f, -2.11725738e-02f, 2.21757237e-02f, -1.57595798e-02f, 1.88514870e-02f, -1.45970779e-02f, 6.31516706e-03f, 5.00102527e-02f,
  -3.63459326e-02f, 3.11556123e-02f, -5.03186136e-02f, 2.92456690e-02f, 2.31722929e-02f, 4.22935076e-02f, -4.92006540e-02f, -2.66262721e-02f, -6.67240843e-02f, -4.54844311e-02f,
  -8.97740200e-02f, 7.14455098e-02f, 1.33730900e-05f, -8.91112611e-02f, 1.55996867e-02f, 5.66192158e-02f, 1.10243402e-01f, -4.04228568e-02f, -1.28747784e-02f, -7.95579329e-02f,
  -7.08230361e-02f, -7.91713744e-02f, 7.40823373e-02f, 1.84447598e-02f, -8.09753023e-04f, 1.94281731e-02f, -1.34968816e-03f, 7.82943666e-02f, -2.41487138e-02f, -8.16937760e-02f,
  4.57535218e-03f, -3.70801352e-02f, -1.19570337e-01f, -5.83401285e-02f, -2.81851795e-02f, -4.82097380e-02f, -5.04262187e-02f, -1.17997199e-01f, -1.08572073e-01f, -1.40854105e-01f,
  -1.07480861e-01f, 3.75739560e-02f, 1.75879419e-01f, -6.22358453e-03f, 1.23538084e-01f, 2.79351681e-01f, 3.23535740e-01f, 6.52748048e-02f, 4.86427546e-02f, 1.93463583e-02f,
  9.71404556e-03f, -1.42639518e-01f, -6.99829236e-02f, -1.18253507e-01f, 9.43732709e-02f, 1.90562874e-01f, 1.16626769e-01f, 6.69489941e-03f, -9.78475362e-02f, -9.95909516e-03f,
  5.00872359e-02f, -5.78597710e-02f, -1.75548270e-02f, -9.77574065e-02f, -1.08434027e-02f, -2.47456320e-02f, -1.22061428e-02f, -5.55628398e-03f, 9.97728668e-03f, 6.51329532e-02f,
  -4.75201244e-03f, 2.98683252e-02f, -1.65649620e-03f, -8.79861712e-02f, -7.77883455e-04f, -1.41883036e-02f, 1.94912907e-02f, -1.02437325e-01f, -3.34959514e-02f, -4.32876125e-03f,
  7.15902969e-02f, -8.01260695e-02f, 4.12435718e-02f, -5.88184744e-02f, 6.02904670e-02f, -5.84644191e-02f, -8.85284245e-02f, -2.25393078e-03f, 1.00085802e-01f, 2.31470782e-02f,
  8.08237791e-02f, 7.59084895e-02f, 4.52558361e-02f, 4.37370054e-02f, 1.68071818e-02f, -6.31100498e-03f, -1.94498356e-02f, 3.64771485e-02f, -2.18917020e-02f, 1.16188843e-02f,
  2.85928547e-02f, 2.33848784e-02f, 9.51368585e-02f, -6.95800111e-02f, 7.82904308e-03f, -2.41318420e-02f, -5.64270541e-02f, 1.23442961e-02f, 9.85799879e-02f, -7.10488530e-03f,
  4.72699031e-02f, -4.03670855e-02f, 2.92776711e-02f, -6.65955171e-02f, -7.23109245e-02f, 8.00304860e-02f, 6.86336756e-02f, 3.18761356e-02f, -5.03757782e-02f, 7.15038273e-03f,
  -7.12778121e-02f, 3.48249041e-02f, 7.57693723e-02f, 7.46377856e-02f, 6.51392015e-03f, 8.64644125e-02f, 2.52238549e-02f, -4.31471951e-02f, -3.92678566e-02f, -2.70633250e-02f,
  -3.26347575e-02f, -8.34177248e-04f, -1.23109110e-02f, -2.22732816e-02f, 1.17705762e-01f, 6.38734847e-02f, 9.29720700e-02f, -3.63680944e-02f, -9.04372931e-02f, 4.02037725e-02f,
  -4.35671322e-02f, -3.42555083e-02f, 2.28474773e-02f, -2.97265351e-02f, -6.78693503e-02f, 1.63350757e-02f, 4.40858454e-02f, -2.48167086e-02f, -4.93672006e-02f, 1.03501296e-02f,
  1.48938686e-01f, -1.02085441e-01f, -1.48765266e-01f, 1.70738120e-02f, 4.91504930e-03f, -9.58264396e-02f, -6.24385402e-02f, -4.47377898e-02f, 5.17496727e-02f, -3.92500162e-02f,
  7.55123556e-01f, -1.26358271e-01f, 2.13995978e-01f, -5.37051484e-02f, -2.50173151e-01f, -1.11651085e-01f, -1.99632458e-02f, -9.76374522e-02f, -9.19439197e-02f, -2.03141198e-03f,
  -8.44564140e-02f, -1.80488393e-01f, -4.75122407e-02f, -3.70810442e-02f, -3.89352627e-02f, 3.89934331e-02f, -1.08756743e-01f, 1.88227773e-01f, -4.18517888e-02f, -2.17336699e-01f,
  -2.35960916e-01f, 1.93709917e-02f, 1.68251082e-01f, -1.09101675e-01f, -2.35483181e-02f, -1.24289773e-01f, 1.31666303e-01f, 1.57125339e-01f, 5.87952323e-03f, 2.25995615e-01f,
  1.13143921e-01f, 9.84688401e-02f, -6.86109960e-02f, -6.14144541e-02f, 1.60258953e-02f, 8.73012394e-02f, -4.15016934e-02f, 1.19074192e-02f, 3.87832406e-03f, 6.55399188e-02f,
  1.56277884e-02f, -8.83007944e-02f, 8.91840085e-02f, -4.90578115e-02f, 6.58123121e-02f, 3.86812799e-02f, 1.06766626e-01f, 8.84552523e-02f, 1.10747419e-01f, -5.40110357e-02f,
  -7.94267803e-02f, -2.86766440e-02f, 5.63305579e-02f, 1.66677777e-02f, 4.05555638e-03f, -7.01011717e-03f, 5.51959388e-02f, 1.19232357e-01f, 2.13833060e-02f, 1.79595798e-01f,
  -7.40651265e-02f, 8.97197500e-02f, -2.84486655e-02f, -3.29307057e-02f, -5.80701604e-02f, 3.66065726e-02f, 4.08507399e-02f, 7.58569269e-03f, -2.18802989e-02f, 4.27914821e-02f,
  -2.81990448e-04f, -6.41521364e-02f, -2.83579845e-02f, -2.01286450e-02f, 7.66661251e-03f, 5.26937060e-02f, -2.35774945e-02f, 7.07276305e-03f, 5.09225857e-03f, 7.00371414e-02f,
  2.13339319e-03f, -1.32140648e-02f, -3.38189630e-03f, -4.63424474e-02f, 5.18426895e-02f, -4.79078740e-02f, -2.06962675e-02f, -9.60906129e-03f, 5.33202756e-03f, 2.62880698e-04f,
  -3.51715013e-02f, 7.02326223e-02f, 1.89704485e-02f, -7.99173191e-02f, 5.96089959e-02f, -8.16914961e-02f, 9.05483738e-02f, 2.78482586e-02f, 3.76569368e-02f, -4.56639379e-02f,
  -2.20977608e-02f, -2.14748085e-02f, 1.79107171e-02f, 1.56393799e-03f, 3.51583958e-02f, -1.13681909e-02f, -5.55881783e-02f, -8.13715439e-03f, -8.55283663e-02f, -1.34523317e-01f,
  -5.70857711e-02f, 3.83339566e-03f, 5.46817929e-02f, -7.82239735e-02f, -6.24527857e-02f, -1.46300718e-02f, -2.76458506e-02f, -4.45635058e-02f, 1.21159881e-01f, -3.40954438e-02f,
  -4.69886810e-01f, 2.45494433e-02f, -2.52028197e-01f, -9.60396156e-02f, -7.69575941e-04f, 1.00052074e-01f, 1.44361377e-01f, 1.35231182e-01f, 1.95350591e-02f, -1.61668975e-02f,
  -2.52168775e-02f, -1.33292049e-01f, -1.78945765e-01f, -4.99330200e-02f, -1.13561898e-01f, -4.27050292e-02f, -1.86009631e-01f, -2.90191740e-01f, 2.91682016e-02f, 1.99776515e-01f,
  2.05069587e-01f, -1.65964514e-02f, -1.34549052e-01f, 8.47004056e-02f, 1.24311030e-01f, 1.33072108e-01f, -1.37079850e-01f, -5.62455729e-02f, 1.86591923e-01f, -5.18486686e-02f,
  -9.74793278e-04f, -1.21472575e-01f, -7.91334510e-02f, -8.73906836e-02f, -7.98989087e-02f, -1.21427149e-01f, -5.69872819e-02f, -9.69604999e-02f, -8.66977405e-03f, 4.02963720e-02f,
  -4.94064651e-02f, -3.31841446e-02f, -1.04837738e-01f, 1.14268057e-01f, 6.03362918e-02f, 2.42389012e-02f, 2.09149700e-02f, -7.98788592e-02f, -1.24034688e-01f, -3.51890060e-03f,
  4.16768938e-02f, -6.12364113e-02f, -7.70895481e-02f, 2.25276779e-03f, -1.48900854e-03f, -1.08925268e-01f, 9.47113037e-02f, -1.12225977e-03f, -9.71006155e-02f, 2.30456576e-01f,
  1.93296690e-02f, 3.01978830e-02f, -1.75812207e-02f, -1.38389459e-02f, 7.86099881e-02f, 1.69812627e-02f, 1.98966041e-02f, 4.36251536e-02f, 2.53789444e-02f, 3.51143964e-02f,
  -6.88517466e-02f, -6.42268080e-03f, -3.43627483e-02f, -9.99682248e-02f, 2.65265871e-02f, 3.09431204e-03f, 5.10389395e-02f, 1.27428947e-02f, -5.42892888e-02f, -1.21853466e-03f,
  3.33182998e-02f, -2.28890814e-02f, 7.47011155e-02f, 3.98226418e-02f, 2.87155565e-02f, -3.88684832e-02f, -7.37447813e-02f, 6.41174465e-02f, 4.31522261e-03f, -4.81609739e-02f,
  1.08037435e-01f, -2.12474391e-01f, 4.78918478e-02f, 4.19730917e-02f, 4.31358293e-02f, -8.14470463e-03f, 4.11530137e-02f, 3.32486629e-02f, -1.03860795e-02f, 1.86351705e-02f,
  2.49548294e-02f, 4.28980868e-03f, -2.60630641e-02f, -9.97694116e-03f, -6.22409955e-03f, 1.00006498e-01f, 3.16537246e-02f, 5.76027259e-02f, 3.02771535e-02f, -4.23839167e-02f,
  -1.36412424e-03f, 1.24994963e-01f, -2.44931597e-02f, -6.39493465e-02f, 3.15057263e-02f, -1.20886259e-01f, 1.74360152e-03f, 1.01973549e-01f, -5.59028126e-02f, 2.22727284e-01f,
  -4.87122275e-02f, 1.23697042e-01f, 6.93587214e-03f, -1.04944624e-01f, 2.03218572e-02f, 1.18531317e-01f, 1.07397713e-01f, 8.37246180e-02f, 1.49954949e-02f, 4.93434258e-02f,
  1.51955411e-01f, 6.62107542e-02f, 1.12129346e-01f, 3.13184522e-02f, 1.09382309e-01f, -6.00701608e-02f, -1.85690433e-01f, -2.94106603e-02f, 9.43926871e-02f, 3.66686247e-02f,
  4.10787342e-03f, -1.39944240e-01f, -2.81897765e-02f, -3.31105627e-02f, -1.50574937e-01f, -5.34502752e-02f, -6.93128556e-02f, 1.34470230e-02f, 7.05531910e-02f, -2.62825161e-01f,
  -9.24901068e-02f, 1.78659275e-01f, 8.23407322e-02f, 3.75459567e-02f, 5.98859228e-02f, 4.10722345e-02f, 1.10507682e-01f, -7.45253563e-02f, 2.61543598e-02f, -8.87251049e-02f,
  5.22985086e-02f, 7.16943070e-02f, -2.39676349e-02f, -1.02075078e-01f, 3.00090667e-02f, -8.15741122e-02f, -1.64202198e-01f, -3.60220559e-02f, -3.94435003e-02f, -4.94020879e-02f,
  -5.60802259e-02f, -3.39219347e-02f, 1.69069171e-02f, 6.88018557e-03f, 4.21407493e-03f, -7.14343265e-02f, 6.32461160e-02f, 4.26429249e-02f, -1.33135053e-03f, -1.30688503e-01f,
  1.18676824e-02f, 2.78688222e-02f, 8.16441048e-03f, -2.03735307e-02f, -3.49740088e-02f, -4.41081710e-02f, 6.30849376e-02f, 2.19639800e-02f, -4.34448496e-02f, -2.90581696e-02f,
  -9.95188486e-03f, -3.69018875e-02f, -3.40025015e-02f, -3.57905738e-02f, 7.32474774e-03f, -2.64500659e-02f, -4.58342098e-02f, -2.26192307e-02f, -6.09829389e-02f, -5.79217356e-03f,
  -6.31408244e-02f, -3.36274542e-02f, -1.35574043e-02f, -4.25818302e-02f, -3.90144661e-02f, 3.00850347e-02f, 6.12812443e-03f, 1.47055485e-03f, 1.23789340e-01f, 8.76589306e-03f,
  -5.67318313e-03f, 1.82036176e-01f, -5.72960041e-02f, 9.70117562e-03f, 1.34647153e-02f, -8.49738494e-02f, -1.28253102e-02f, 6.68517053e-02f, 7.42772920e-03f, 4.25668024e-02f,
  -5.13253827e-03f, -1.88161749e-02f, -6.18047360e-03f, -9.97293182e-03f, 9.15273800e-02f, -1.23506300e-02f, 1.87458303e-02f, 2.90957727e-02f, -5.21422811e-02f, -1.03935391e-01f,
  -1.35190159e-01f, -1.07653089e-01f, -3.95915508e-02f, -1.05857313e-01f, -1.62853315e-01f, 3.74086648e-02f, -2.91731376e-02f, -1.10998996e-01f, 1.17309518e-01f, -3.97989154e-02f,
  2.13743612e-01f, 3.00995737e-01f, 1.10094935e-01f, 1.38054609e-01f, -1.81608170e-01f, -7.43672475e-02f, 1.40887037e-01f, 9.14891344e-03f, -1.15487035e-02f, 2.11943597e-01f,
  4.97646518e-02f, 4.58405912e-02f, 1.57836139e-01f, -2.73038074e-02f, 9.24235806e-02f, 2.40903422e-01f, 3.98405679e-02f, -7.93349966e-02f, -2.49136955e-01f, -2.50223428e-01f,
  -3.30575705e-02f, 8.29656199e-02f, 2.78379302e-04f, -9.38472748e-02f, 1.62079796e-01f, 1.71146661e-01f, 2.14566976e-01f, 1.64523512e-01f, -9.33892876e-02f, 3.28659207e-01f,
  1.10723451e-01f, -1.82060674e-02f, 3.12866047e-02f, 2.60131843e-02f, 2.94225793e-02f, 4.65746298e-02f, 3.76471765e-02f, 4.54628393e-02f, 6.73035681e-02f, 1.08667584e-02f,
  4.33006957e-02f, -5.42486459e-02f, -5.49519882e-02f, 7.23442212e-02f, -3.26257497e-02f, -1.15233418e-02f, -1.22219451e-01f, -1.43083498e-01f, 2.79722232e-02f, -1.03521995e-01f,
  -5.41709699e-02f, -1.07047968e-01f, -5.13292477e-02f, -3.03952284e-02f, -5.52703030e-02f, -1.37427822e-01f, 5.44167086e-02f, 9.05587375e-02f, -5.44887327e-04f, 2.90326148e-01f,
  5.75827211e-02f, 3.59217939e-03f, -3.07949707e-02f, -2.07160171e-02f, -1.59759391e-02f, 4.88413498e-02f, -2.34947316e-02f, 1.07517406e-01f, -8.63212645e-02f, 1.01026110e-01f,
  -6.72833920e-02f, 1.24696288e-02f, -3.68452445e-02f, 8.23814422e-02f, -3.19287404e-02f, -1.77213009e-02f, -3.40737179e-02f, 2.91926339e-02f, 8.28363482e-05f, -4.82184552e-02f,
  9.00519546e-03f, -3.53561416e-02f, 3.61746736e-02f, -2.44978797e-02f, -7.40754679e-02f, -9.43947360e-02f, -4.79450002e-02f, -5.68619790e-03f, 5.56624085e-02f, 4.27229004e-03f,
  2.96460956e-01f, -5.35140373e-02f, 1.78141356e-01f, -1.90405063e-02f, -8.96617025e-03f, -1.82052031e-02f, 6.40018238e-03f, -1.03190631e-01f, -5.00893267e-03f, -8.25985055e-03f,
  -5.49279451e-02f, 9.78266522e-02f, 1.63294859e-02f, -2.85446532e-02f, 1.82747152e-02f, 1.33427531e-02f, 4.50463928e-02f, 1.23897225e-01f, -6.55421317e-02f, -7.21743107e-02f,
  4.87714969e-02f, 1.08239852e-01f, 2.27273181e-01f, 1.40128911e-01f, -2.65294258e-02f, 1.06053926e-01f, 1.39020965e-01f, 9.85731110e-02f, 9.56245512e-02f, 4.75698203e-01f,
  4.94856313e-02f, -1.54506397e-02f, -7.53801912e-02f, 2.35223919e-01f, 1.62229896e-01f, 2.63598878e-02f, 4.52594161e-02f, 6.19255081e-02f, 1.56253397e-01f, 1.17299482e-01f,
  8.32988471e-02f, 3.51668596e-02f, 1.12327673e-01f, 3.25626992e-02f, -2.39543598e-02f, -3.28450985e-02f, 1.67636842e-01f, -3.52468230e-02f, -4.09259126e-02f, -1.22171072e-02f,
  8.25419724e-02f, 1.39737785e-01f, -2.98692714e-02f, 2.50603948e-02f, 1.06033094e-01f, 1.30384549e-01f, -6.48498461e-02f, -5.04928753e-02f, -1.71799451e-01f, 3.07554185e-01f,
  1.45293683e-01f, -2.31583923e-01f, 4.84081097e-02f, -1.67576913e-02f, -2.53354590e-02f, -3.69404443e-02f, -4.76522371e-02f, -3.73507626e-02f, -9.56134056e-04f, 2.29177088e-03f,
  -4.79513556e-02f, 3.81892622e-02f, -8.48684739e-03f, -1.46939801e-02f, 4.63121645e-02f, -4.89613451e-02f, -4.43238579e-02f, -1.06097937e-01f, 2.66610086e-02f, -4.28274740e-03f,
  7.51197860e-02f, -9.15922895e-02f, -1.38111860e-01f, -6.85596392e-02f, -2.17776634e-02f, -3.06153968e-02f, -1.12270407e-01f, -1.65437177e-01f, -1.25801876e-01f, 7.21395090e-02f,
  2.36664508e-02f, 3.43212709e-02f, 1.02875922e-02f, 2.21295301e-02f, 1.08842039e-02f, 6.22455329e-02f, 7.22026750e-02f, 3.32242437e-02f, -1.20489746e-02f, 5.93373813e-02f,
  -5.06137237e-02f, 1.83908902e-02f, 1.59321222e-02f, -5.35790250e-02f, 6.96950629e-02f, -6.77106082e-02f, -3.27387415e-02f, 3.95606831e-02f, -7.24189058e-02f, -3.33438106e-02f,
  7.59898126e-03f, -5.01535460e-03f, -5.08205220e-02f, 3.68937366e-02f, -2.02706084e-02f, -2.18248330e-02f, 4.55414355e-02f, -1.63834505e-02f, -5.66866696e-02f, 1.14878628e-03f,
  1.65927589e-01f, -2.13874102e-01f, 1.47300258e-01f, 6.30177632e-02f, -6.54333225e-03f, -5.99660799e-02f, 1.16263358e-02f, 3.64756100e-02f, 2.89080497e-02f, 7.04746246e-02f,
  -5.91416610e-03f, -5.54052275e-03f, 9.54755489e-03f, -6.16938621e-02f, 9.05533321e-03f, 8.35401844e-03f, -2.16261316e-02f, 1.22476377e-01f, -1.83742773e-02f, 2.01509465e-02f,
  1.73737928e-02f, 6.71917573e-02f, -2.95248237e-02f, 4.89411457e-03f, -4.34935763e-02f, 7.19431043e-02f, 9.41993818e-02f, 1.01096109e-01f, -3.08942944e-02f, 5.29589802e-02f,
  2.51375854e-01f, -1.13886893e-01f, 3.41142952e-01f, 2.54022300e-01f, 2.78963566e-01f, 1.15157701e-01f, 9.14749056e-02f, -7.86559191e-04f, -4.24888916e-02f, 1.66650712e-01f,
  -9.51391980e-02f, -1.73831165e-01f, -6.50218725e-02f, -1.50369897e-01f, -1.61871925e-01f, -4.59042378e-02f, 2.16077462e-01f, 4.31387499e-02f, 3.12685361e-03f, 1.64563011e-03f,
  5.97369857e-02f, 1.36407718e-01f, 6.98935166e-02f, -1.82568263e-02f, 1.01215087e-01f, -5.70623949e-02f, 4.53092605e-02f, 4.64717560e-02f, -4.07228284e-02f, 1.75118119e-01f,
  1.41241610e-01f, 1.93445235e-01f, 4.30313833e-02f, -7.84286410e-02f, -2.24251244e-02f, -2.34514996e-02f, 1.76014230e-02f, 1.04376085e-01f, -7.53734186e-02f, 7.56995985e-03f,
  7.19151199e-02f, -9.30080265e-02f, 2.79296990e-02f, -3.26012857e-02f, 9.04161558e-02f, 9.59231034e-02f, -8.83740932e-02f, -2.90115904e-02f, 1.52244838e-02f, 8.10454041e-02f,
  5.80612943e-02f, 1.20488428e-01f, 8.45296532e-02f, -8.16649720e-02f, 5.04610641e-03f, 3.00280005e-02f, 5.30779473e-02f, 6.50952905e-02f, -9.30553824e-02f, -5.26219048e-03f,
  5.68910241e-02f, -8.65194574e-02f, -3.81689854e-02f, -4.55687046e-02f, -1.26001902e-03f, -1.36209987e-02f, -8.64282530e-03f, 4.27365229e-02f, -7.42220506e-02f, -4.85737436e-03f,
  -1.03795612e-02f, -6.64408319e-03f, 3.03562637e-03f, -6.17712270e-04f, -2.19353149e-03f, 2.84599550e-02f, 1.28744133e-02f, -8.36159438e-02f, 9.40900072e-02f, -6.76532760e-02f,
  -9.80326999e-03f, 8.71537030e-02f, 5.44222491e-03f, -5.01971841e-02f, 3.13343890e-02f, 2.60997172e-02f, -1.02771230e-01f, 9.51731671e-03f, 3.56521904e-02f, 1.04054451e-01f,
  -1.27290979e-01f, -5.61643802e-02f, 1.54837035e-02f, -1.77670680e-02f, 7.05207116e-04f, -5.84620796e-02f, 5.69204353e-02f, -5.27831018e-02f, 3.95307951e-02f, 1.46111231e-02f,
  -1.05529875e-02f, 4.95650657e-02f, -8.97043347e-02f, 5.82733713e-02f, 9.05167218e-03f, 7.25909993e-02f, -3.25357877e-02f, 6.04052357e-02f, -8.28188937e-03f, 4.90466692e-02f,
  1.95812574e-03f, -4.80687954e-02f, 4.90608532e-03f, -8.96916837e-02f, -1.79310795e-02f, 3.02016595e-03f, -7.49959238e-03f, -1.09200172e-01f, -2.69104596e-02f, -2.03452572e-01f,
  -3.38928014e-01f, 4.67529178e-01f, 3.81017804e-01f, -8.23630020e-02f, 8.49513188e-02f, 2.95088261e-01f, 5.16216278e-01f, 5.46422228e-02f, -1.22511253e-01f, 1.24410369e-01f,
  -5.62344790e-02f, -3.63206714e-01f, -3.67426872e-01f, -1.95561767e-01f, -1.39390677e-01f, 2.43962839e-01f, 1.30683362e-01f, -1.03428863e-01f, -2.66640157e-01f, 2.61846259e-02f,
  7.79204294e-02f, -9.37287603e-03f, -8.34659040e-02f, 9.49930400e-03f, 1.72317222e-01f, -1.86211437e-01f, 7.51623325e-03f, 1.66464776e-01f, 1.31915659e-01f, 1.00310437e-01f,
  5.19665554e-02f, 1.01546273e-01f, -9.95120704e-02f, -5.32231033e-02f, 4.27791588e-02f, -6.70821294e-02f, -1.46482345e-02f, -2.35154275e-02f, -2.87053846e-02f, 5.82265519e-02f,
  -9.31382459e-03f, -9.27513558e-03f, -2.11732257e-02f, 2.41112374e-02f, 4.05348912e-02f, 7.11883903e-02f, 2.86178235e-02f, 1.24621168e-02f, 8.77422392e-02f, 8.12984351e-03f,
  9.56377909e-02f, 5.51704615e-02f, 1.51750699e-01f, 5.04159555e-02f, 7.25748539e-02f, -6.40270710e-02f, 7.66766295e-02f, 6.46426976e-02f, 1.00343950e-01f, 8.99361372e-02f,
  3.26430239e-03f, -2.22523860e-03f, -4.21812423e-02f, 3.19925137e-02f, -1.95044130e-02f, -3.22216712e-02f, -1.05156645e-03f, -6.37070388e-02f, 2.75920965e-02f, 1.28288683e-03f,
  -1.05191935e-02f, 2.79224310e-02f, -4.80164401e-03f, 3.75845693e-02f, -4.00962941e-02f, 4.96438332e-02f, -4.52932017e-03f, 5.75233921e-02f, -5.24636693e-02f, 1.74101591e-02f,
  -3.31254713e-02f, 4.41579930e-02f, 7.55676627e-03f, 4.67961133e-02f, 4.14492190e-02f, -4.68690507e-02f, -4.19581719e-02f, -4.43334132e-02f, -4.03557904e-03f, 2.40287334e-02f,
  -1.41037405e-01f, 2.00693589e-02f, -1.38131186e-01f, -7.79895186e-02f, -2.62221880e-03f, -2.26288997e-02f, -3.95826548e-02f, -1.33187999e-03f, -1.95818068e-03f, 3.88695747e-02f,
  6.48711473e-02f, -8.66983086e-02f, 1.34944059e-02f, 4.93738055e-02f, -3.54645886e-02f, -4.18495163e-02f, -2.60270503e-03f, -9.23092514e-02f, -1.10982038e-01f, 1.18958257e-01f,
  3.17085348e-02f, -2.82791024e-03f, -1.93276092e-01f, -3.83233242e-02f, -3.89738083e-02f, -1.88338920e-01f, 4.42073718e-02f, -8.01187530e-02f, -6.93182275e-02f, -8.52263197e-02f,
  -7.29891598e-01f, -2.69643702e-02f, 1.64952606e-01f, -3.50842446e-01f, 6.36026859e-02f, 9.37978625e-02f, -1.66465908e-01f, -2.96195030e-01f, -1.02031469e-01f, 2.09222808e-02f,
  2.42392868e-01f, 1.68238312e-01f, 7.40937442e-02f, 9.47093517e-02f, -1.73380286e-01f, -9.82823148e-02f, -1.51711643e-01f, -2.67692525e-02f, -2.78553050e-02f, 1.32669047e-01f,
  3.94762978e-02f, -6.25948235e-02f, -2.08759338e-01f, 2.57510040e-02f, 4.36222628e-02f, 1.95306733e-01f, 1.49166927e-01f, 4.12232168e-02f, 1.92257166e-01f, -1.13908187e-01f,
  3.91336381e-01f, -4.26426381e-02f, 1.90445757e-03f, -5.21456152e-02f, 8.38690475e-02f, -3.41070071e-03f, -1.01298742e-01f, -9.86321718e-02f, -9.06464551e-03f, 2.58914921e-02f,
  6.27079308e-02f, 7.49740899e-02f, -5.49635440e-02f, 8.10184255e-02f, 3.64574082e-02f, -1.18295783e-02f, -2.39735823e-02f, -1.37880474e-01f, 1.74801443e-02f, -2.51150690e-02f,
  7.98424929e-02f, 4.79336008e-02f, 3.00541259e-02f, -7.52155716e-03f, 1.75224878e-02f, 5.60607389e-02f, 1.15041152e-01f, 6.67332709e-02f, 1.35542423e-01f, -5.85668162e-02f,
  -7.36381188e-02f, 5.99806271e-02f, -3.92545685e-02f, -1.46603258e-03f, -4.06226590e-02f, 3.59441377e-02f, -4.13508387e-03f, 1.48777133e-02f, 8.73321574e-03f, 2.32012440e-02f,
  -1.56817660e-02f, 4.12737094e-02f, -2.80780513e-02f, -5.78949861e-02f, 4.15183902e-02f, 2.94184927e-02f, -1.04046412e-01f, 2.03736741e-02f, 4.63396274e-02f, 8.26831255e-03f,
  -5.52610271e-02f, 3.49483304e-02f, 2.60590278e-02f, 2.27298755e-02f, -7.17383157e-03f, 1.04291132e-02f, -9.48259383e-02f, 6.75788447e-02f, -2.77816169e-02f, 6.16184808e-02f,
  -7.61910975e-02f, -5.52229472e-02f, 7.45804310e-02f, -3.14036496e-02f, -2.62938198e-02f, -2.88662799e-02f, 6.78281039e-02f, -2.61900090e-02f, 7.23624155e-02f, 8.71331431e-03f,
  1.61580015e-02f, -8.34106281e-02f, 1.47344526e-02f, 4.60704938e-02f, -2.06193011e-02f, 1.20541230e-02f, 2.66485531e-02f, 2.38181688e-02f, -1.24581042e-03f, 5.09510078e-02f,
  5.05449541e-04f, -9.82234627e-02f, -5.85925877e-02f, -4.02218103e-02f, -6.41882196e-02f, -9.91105847e-03f, 3.20712142e-02f, -1.91423390e-02f, -2.95867100e-02f, -1.41726121e-01f,
  -1.03374921e-01f, 1.65902108e-01f, -3.50907221e-02f, 1.99637166e-03f, 1.07759856e-01f, -6.21851012e-02f, 2.17249114e-02f, 4.54079956e-02f, -6.34638742e-02f, -3.39115853e-03f,
  1.00087494e-01f, -9.96889770e-02f, 4.77337874e-02f, 2.05399524e-02f, 1.15748383e-01f, -6.90621417e-03f, 1.27887219e-01f, 3.45006771e-02f, -7.27415308e-02f, -3.21184881e-02f,
  -3.99455912e-02f, 1.58411507e-02f, -9.18701366e-02f, -6.86431304e-04f, -2.36749332e-02f, 3.18315625e-02f, 6.15219139e-02f, 1.31081134e-01f, 9.11195725e-02f, 1.04680099e-01f,
  -4.84103076e-02f, 1.23307340e-01f, -7.36920610e-02f, 7.13970289e-02f, -8.19589756e-03f, -7.22788125e-02f, -1.97403803e-02f, -6.54292386e-03f, 1.07252687e-01f, 2.70830709e-02f,
  -4.73733619e-02f, 5.77159338e-02f, 4.51427288e-02f, -7.55564123e-03f, 7.23895878e-02f, -4.35510688e-02f, 5.06786220e-02f, 8.29586983e-02f, 2.52196398e-02f, 7.45690614e-02f,
  2.39161588e-02f, 1.12594299e-01f, 3.84257585e-02f, 2.80405916e-02f, 8.28100443e-02f, 1.60328206e-02f, 4.80310507e-02f, 5.61075844e-02f, 4.04369384e-02f, -9.93248541e-03f,
  -4.47967239e-02f, -5.19864028e-03f, -6.87615201e-02f, -3.36477421e-02f, 6.33021817e-02f, -2.12118533e-02f, 1.52553504e-04f, -2.24303007e-02f, -4.99497429e-02f, -3.49255726e-02f,
  1.72462370e-02f, -3.20161730e-02f, 4.40197103e-02f, -5.19064292e-02f, -2.67059226e-02f, 3.85540240e-02f, -3.63568179e-02f, -2.34651379e-02f, -1.17393225e-01f, 5.49385063e-02f,
  5.63925467e-02f, 6.17583580e-02f, -3.08428053e-02f, -2.00542230e-02f, 6.65271655e-03f, 4.02336232e-02f, 1.79117115e-03f, 1.30723296e-02f, -1.13117322e-01f, 6.45241588e-02f,
  -1.98611617e-01f, 5.55712879e-02f, 4.97779250e-02f, -2.05721203e-02f, 9.81845334e-03f, 6.83700806e-03f, -1.09968863e-01f, 8.06593522e-03f, -3.01164556e-02f, 2.74477359e-02f,
  1.47397267e-02f, 3.77575168e-03f, 8.32113624e-02f, -2.57526860e-02f, -3.56137045e-02f, -7.51610175e-02f, 4.08627354e-02f, 2.53915135e-02f, -1.02807162e-02f, -4.63541821e-02f,
  2.56838687e-02f, -1.92799661e-02f, -1.72321931e-01f, -9.06547010e-02f, 5.90314977e-02f, 1.05212349e-02f, -1.56713843e-01f, -2.32911166e-02f, -1.00807374e-04f, -1.86221376e-01f,
  -2.11531043e-01f, 2.73821741e-01f, 2.18770817e-01f, -3.26351449e-02f, -4.53620031e-02f, -1.42884523e-01f, -4.17721272e-02f, -8.81745070e-02f, -1.06190071e-01f, 5.16581647e-02f,
  9.22282338e-02f, -5.33047691e-02f, 1.92168858e-02f, 7.61981010e-02f, -5.10210283e-02f, 3.44742695e-03f, 5.39758801e-02f, -3.33502367e-02f, -2.49927700e-01f, -9.19324011e-02f,
  -1.79040991e-02f, 4.32322621e-02f, -4.62470017e-03f, -6.33401722e-02f, 8.07397068e-02f, -1.19156517e-01f, 2.09679514e-01f, 1.85195059e-01f, 5.58425114e-02f, 5.10394454e-01f,
  -4.44946550e-02f, 2.69594043e-01f, -1.00766212e-01f, 5.80556430e-02f, 1.04270227e-01f, -4.57196943e-02f, -3.70689146e-02f, -6.80040615e-03f, -4.21342393e-03f, -2.84910277e-02f,
  6.86834976e-02f, -4.84270528e-02f, -7.42644370e-02f, 5.26138768e-02f, 1.15773370e-02f, 3.79542746e-02f, 8.01180005e-02f, 7.94057697e-02f, -5.76275587e-02f, -9.55658313e-03f,
  9.78876054e-02f, 1.04421243e-01f, 6.29232302e-02f, -4.02297154e-02f, 8.83027017e-02f, 9.04405937e-02f, 8.43866765e-02f, 9.13049504e-02f, 3.19392495e-02f, 7.56478459e-02f,
  -2.67756209e-02f, 2.05643419e-02f, 3.35996002e-02f, 4.81060594e-02f, -9.51532647e-03f, -2.70688776e-02f, 5.54254763e-02f, -8.68423656e-02f, 3.72860059e-02f, -4.04266780e-03f,
  7.35044181e-02f, -7.15966225e-02f, 1.56833883e-02f, -8.47686008e-02f, 5.86583279e-02f, 2.69627161e-02f, -4.87483181e-02f, 5.67495413e-02f, 7.35285282e-02f, 3.03096715e-02f,
  -2.73666568e-02f, 1.89275704e-02f, -6.54863715e-02f, 2.96575371e-02f, 1.16108105e-01f, 2.04374120e-02f, -3.78558338e-02f, 7.99201056e-02f, -1.73630975e-02f, -1.01548880e-02f,
  -2.77722538e-01f, 4.41383496e-02f, -9.59228277e-02f, -8.46885070e-02f, -3.68665420e-02f, -7.76073383e-03f, 5.66755272e-02f, 3.04033868e-02f, 1.84186897e-03f, -2.50861458e-02f,
  -2.16486156e-02f, -2.39770934e-02f, 2.21355632e-02f, -2.81382222e-02f, 1.16607604e-04f, -4.36637215e-02f, 2.61695068e-02f, -1.67549238e-01f, 3.94795686e-02f, 6.21681400e-02f,
  -1.32420501e-02f, -1.07671969e-01f, -2.41236061e-01f, -1.26869857e-01f, -1.18338458e-01f, -1.77208126e-01f, -1.03427015e-01f, -6.13818839e-02f, -2.31415704e-01f, -3.39715689e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  8.31847861e-02f, 9.59995687e-02f, -1.63520444e-02f, 1.01747818e-01f, -7.21140280e-02f, -3.86487931e-01f, -2.65009999e-01f, -2.95934498e-01f, 5.25760800e-02f, 3.62972245e-02f,
  1.10234283e-01f, 3.08643319e-02f, 6.54656738e-02f, 3.59221585e-02f, -1.96417138e-01f, -7.75514916e-02f, -3.03358138e-02f, -1.42454542e-02f, -2.41147891e-01f, -7.39672408e-02f,
  1.30715862e-01f, 7.85280392e-02f, 9.60521027e-02f, -2.42571570e-02f, 2.22010881e-01f, 7.19108954e-02f, 7.62777701e-02f, 9.74667892e-02f, 9.05049127e-03f, 4.57777709e-01f,
  2.30218172e-01f, 2.98015103e-02f, -6.11074902e-02f, 1.44443318e-01f, 6.18119277e-02f, -2.25154757e-02f, 3.83266248e-02f, 6.97939396e-02f, -4.35544848e-02f, 2.90697254e-02f,
  4.18823846e-02f, 6.16455935e-02f, 5.38768694e-02f, -6.64033517e-02f, -6.91795871e-02f, -1.16123423e-01f, 6.57503456e-02f, -4.44055609e-02f, -8.08292627e-02f, 7.72320181e-02f,
  7.16714486e-02f, -5.69304526e-02f, -9.03007090e-02f, -1.89663157e-01f, -5.63420579e-02f, -2.74628866e-02f, -6.10344857e-02f, -8.14564526e-04f, -1.50210589e-01f, 3.52723114e-02f,
  -3.67377326e-02f, -4.62269820e-02f, 3.28573883e-02f, 3.46547849e-02f, 5.33901416e-02f, -2.04502717e-02f, -5.71141578e-02f, -3.04848887e-03f, 2.31422000e-02f, -5.88525273e-02f,
  -1.11117689e-02f, -5.82741722e-02f, -1.88904516e-02f, -8.60663652e-02f, 8.87443870e-03f, -7.30736973e-03f, 2.66154353e-02f, 1.61011587e-03f, 1.14683375e-04f, 3.60993631e-02f,
  -7.48272315e-02f, -2.89587080e-02f, 9.46304873e-02f, 1.45038804e-02f, 3.42349000e-02f, 3.47887985e-02f, 3.23655494e-02f, 1.47199873e-02f, 5.29445037e-02f, -1.89533699e-02f,
  5.79324216e-02f, -3.43541682e-01f, 1.10424936e-01f, -7.98214693e-03f, -5.22091202e-02f, 4.37052995e-02f, 2.48808842e-02f, -1.11215319e-02f, 1.25612719e-02f, 3.08983075e-03f,
  -7.08978344e-03f, -8.27883780e-02f, 4.60368842e-02f, 1.70058641e-03f, -5.15096970e-02f, -3.61538939e-02f, 5.74037991e-02f, -7.02036843e-02f, -8.46638829e-02f, 8.07092804e-03f,
  -3.27264033e-02f, -1.31186292e-01f, -9.60908234e-02f, -1.47854999e-01f, -3.18205543e-02f, -7.16424286e-02f, -1.29406825e-01f, -2.73808334e-02f, -2.74635673e-01f, -1.40318528e-01f,
  -3.46028656e-01f, -6.51054457e-02f, -5.79953976e-02f, 9.73695219e-02f, 1.46430165e-01f, 3.35585847e-02f, 1.23190321e-01f, 8.78249183e-02f, 1.16567142e-01f, 6.25092685e-02f,
  8.38567317e-02f, 6.79739267e-02f, 6.79237619e-02f, 1.28238142e-01f, -5.91552816e-03f, 2.25581780e-01f, 2.10221082e-01f, -4.78461049e-02f, -8.73881131e-02f, 2.92442162e-02f,
  5.37702553e-02f, -8.29756260e-02f, -1.48241505e-01f, -3.52456346e-02f, 5.32695241e-02f, 1.06214486e-01f, -6.98448271e-02f, 4.83628511e-02f, -6.45084009e-02f, 1.32442489e-01f,
  -9.96984318e-02f, -5.25843650e-02f, -4.92433347e-02f, -4.22693081e-02f, -8.44036415e-02f, -5.92079870e-02f, -6.79766089e-02f, -5.11886142e-02f, 2.50529218e-02f, -1.87601857e-02f,
  -8.10273588e-02f, 6.49420545e-03f, -5.04210480e-02f, 4.53271084e-02f, 2.08090059e-02f, -1.03446998e-01f, 2.26639048e-03f, 2.33900975e-02f, -7.90312365e-02f, -4.63616066e-02f,
  8.26542526e-02f, -9.24078673e-02f, -9.49499384e-02f, 5.95419817e-02f, 1.73896905e-02f, 1.78590864e-02f, -8.37723389e-02f, -1.88104622e-02f, -6.59246296e-02f, -8.56735632e-02f,
  6.65705949e-02f, 3.91530432e-02f, -3.27484086e-02f, -8.23055655e-02f, 9.07704830e-02f, -2.83993362e-03f, 3.23581174e-02f, 8.18973631e-02f, 3.32789146e-03f, -4.63735349e-02f,
  -1.41761685e-02f, -9.15621445e-02f, -9.43559185e-02f, 3.01288944e-02f, -1.02492541e-01f, -2.10879929e-02f, 5.22509664e-02f, 2.04833783e-02f, -3.92382070e-02f, -2.40474734e-02f,
  2.52168532e-02f, -8.81367698e-02f, 2.29024850e-02f, -5.82437776e-02f, 1.61392950e-02f, 6.59860522e-02f, 2.17625108e-02f, 1.58179691e-03f, -4.94405851e-02f, -7.12191835e-02f,
  -8.18929374e-02f, -9.40296650e-02f, 5.09397350e-02f, 9.54616964e-02f, -1.34427631e-02f, -2.42031123e-02f, -3.37091312e-02f, 4.75472733e-02f, -6.44802228e-02f, -3.36834393e-03f,
  4.51311935e-03f, 4.46682610e-02f, -2.30422709e-03f, 3.22483294e-02f, 2.27811057e-02f, -4.50437218e-02f, 2.98689306e-02f, -4.55127023e-02f, 6.90607429e-02f, -1.18414350e-01f,
  -3.18634845e-02f, -5.07714525e-02f, -1.60536259e-01f, 8.57383087e-02f, -8.98494348e-02f, -8.20844248e-02f, -1.41272530e-01f, -1.42380625e-01f, -8.57487842e-02f, -8.90670121e-02f,
  2.21924365e-01f, 9.24308524e-02f, 1.64470583e-01f, 2.41472200e-01f, 1.88618496e-01f, 2.57751405e-01f, 2.88678646e-01f, 2.31851578e-01f, 1.22489989e-01f, 1.04151234e-01f,
  1.00559257e-01f, 3.68612446e-02f, 1.05699793e-01f, 7.02665299e-02f, 2.16369964e-02f, 7.82582909e-02f, 3.85837182e-02f, -2.03530882e-02f, 8.94777477e-02f, 1.15930215e-01f,
  -5.05032763e-02f, 3.27826652e-04f, -7.45802149e-02f, 1.87960267e-02f, -5.67267556e-03f, 7.18011707e-02f, 6.87202960e-02f, -1.18718237e-01f, -7.31166676e-02f, -1.18467703e-01f,
  4.78476807e-02f, 2.35926583e-01f, 1.19977221e-01f, -4.65653390e-02f, 2.73557790e-02f, -6.03372864e-02f, -1.98827665e-02f, -1.32525474e-01f, 6.05059117e-02f, -2.53354991e-03f,
  -1.01545416e-01f, -5.64460456e-02f, 5.38542420e-02f, -1.67105291e-02f, 4.59480435e-02f, 1.02835603e-01f, -1.07429445e-01f, -7.95234442e-02f, -6.20433083e-03f, -6.38251752e-02f,
  -4.58202558e-03f, 5.72835281e-02f, 1.29260406e-01f, 2.89793648e-02f, 1.02254443e-01f, 1.22662090e-01f, 8.55487306e-03f, -1.26538174e-02f, -4.89595812e-03f, -4.00044955e-02f,
  7.48099983e-02f, -1.61552168e-02f, 4.49410193e-02f, 1.42598124e-02f, -6.24776632e-02f, 4.46207635e-02f, -2.76201088e-02f, -3.96242291e-02f, 1.09926984e-02f, -9.39590037e-02f,
  -5.66264912e-02f, 5.27392235e-03f, 3.43688503e-02f, -9.97769460e-03f, 3.99838351e-02f, -3.31229642e-02f, -2.51664757e-03f, -4.62482534e-02f, 5.12235202e-02f, 4.98061590e-02f,
  2.85419114e-02f, -1.26567800e-02f, -6.84949234e-02f, 1.29720243e-02f, -2.18061507e-02f, 6.22014068e-02f, -4.75030690e-02f, -6.81175962e-02f, -6.29206002e-02f, 2.43691402e-03f,
  -1.71179220e-01f, 1.63999334e-01f, -2.18259785e-02f, -6.08614013e-02f, -7.15511069e-02f, -7.71097317e-02f, 1.87894125e-02f, 2.16020066e-02f, -3.65166552e-02f, 2.74840891e-02f,
  1.98723804e-02f, 2.15869602e-02f, 4.92915139e-02f, -9.95540768e-02f, -9.45897549e-02f, 6.23400100e-02f, -1.05708078e-01f, 6.10673912e-02f, -4.24621301e-03f, -7.26398826e-03f,
  -7.14966655e-02f, 1.33215323e-01f, 3.62675032e-03f, 1.66917630e-02f, 4.29182872e-02f, 1.29742995e-01f, 8.06904510e-02f, 1.75452605e-02f, 2.00722627e-02f, -7.35977441e-02f,
  1.80684820e-01f, 2.40352470e-02f, 2.82373041e-01f, 8.38036090e-02f, 1.35772064e-01f, 1.66623771e-01f, 2.65128225e-01f, 8.53395611e-02f, 3.10546812e-02f, 4.67967875e-02f,
  -1.10881828e-01f, -1.56752884e-01f, -2.38670677e-01f, -1.42079994e-01f, 4.55640554e-02f, 1.73735544e-01f, 2.59823889e-01f, 2.49047011e-01f, 1.37261108e-01f, 1.47387251e-01f,
  -4.84749861e-03f, 6.86439872e-02f, 5.53504862e-02f, 1.25470430e-01f, 1.68969363e-01f, -3.33231539e-02f, -9.88159794e-03f, -8.90921894e-03f, -7.01995194e-02f, 1.71921358e-01f,
  9.20234919e-02f, 8.70042518e-02f, -6.05336204e-02f, -9.67430323e-02f, -2.77051162e-02f, 6.52371719e-02f, 2.93199681e-02f, -4.29860465e-02f, -1.59293056e-01f, 9.14676413e-02f,
  -3.31808701e-02f, -7.08731562e-02f, 2.87145060e-02f, 2.13131588e-02f, 5.77732250e-02f, 4.89105545e-02f, 2.38783546e-02f, 1.03633748e-02f, 3.38118151e-03f, -7.02405721e-02f,
  -1.78816959e-01f, 4.78286445e-02f, 3.92396115e-02f, -2.09640921e-03f, 4.83593456e-02f, -5.99198267e-02f, 3.10252849e-02f, 1.43571552e-02f, -2.64410693e-02f, 1.77631024e-02f,
  2.53441315e-02f, 6.77602598e-03f, 4.28582728e-02f, 3.21677737e-02f, -1.05834365e-01f, 1.28451018e-02f, -5.24802990e-02f, 4.56986092e-02f, -9.32973635e-04f, 4.52434458e-02f,
  -7.53431842e-02f, 5.41152293e-03f, 1.89493559e-02f, 3.46931219e-02f, -7.47492462e-02f, 6.72987029e-02f, 1.45943062e-02f, -9.56137553e-02f, -8.61357227e-02f, 1.35339424e-02f,
  -6.71683326e-02f, 1.86811388e-02f, -2.69400403e-02f, -4.95369770e-02f, 4.16631587e-02f, -3.03225350e-02f, 3.52961719e-02f, 2.21715355e-03f, -4.30927658e-03f, -5.08450717e-02f,
  -1.33102998e-01f, -2.41077349e-01f, 1.24102443e-01f, -2.46269256e-02f, 5.69910109e-02f, -5.71706481e-02f, -8.23786184e-02f, 2.80571114e-02f, -9.17000100e-02f, -4.68847807e-03f,
  3.95656889e-03f, 5.64791113e-02f, -1.43729299e-01f, 5.02925999e-02f, 5.49084693e-02f, -2.07281653e-02f, -9.63389948e-02f, -4.32496006e-03f, -3.33524868e-02f, 6.76896144e-03f,
  3.00427843e-02f, 3.19368914e-02f, 4.61797565e-02f, 6.09877892e-03f, -4.57159616e-02f, -9.13321152e-02f, 7.82870427e-02f, 1.85455475e-02f, 1.00164330e-02f, 1.55484468e-01f,
  -5.75116016e-02f, -2.53056251e-02f, 8.27805623e-02f, 1.12632420e-02f, -7.74521977e-02f, 3.46168429e-02f, 8.60265195e-02f, -7.62107447e-02f, 8.04420486e-02f, -6.91684559e-02f,
  2.71191280e-02f, 5.16500995e-02f, 4.20542695e-02f, 1.93155126e-03f, 3.78198959e-02f, 5.63062876e-02f, 1.02558080e-02f, 9.06873420e-02f, 7.04687759e-02f, 4.26962972e-02f,
  -5.41289784e-02f, -5.72016202e-02f, -9.68777016e-02f, 5.85913938e-03f, 4.96952161e-02f, 5.25089689e-02f, -1.88326128e-02f, -9.30591598e-02f, -3.27297673e-02f, 3.93258333e-02f,
  5.21423556e-02f, -1.45073351e-03f, 5.04711419e-02f, -6.79665282e-02f, -2.53518969e-02f, -3.88265438e-02f, -9.69196297e-03f, 2.43262295e-02f, 6.97480217e-02f, 4.57044244e-02f,
  1.52671644e-02f, 5.56333065e-02f, -7.20324069e-02f, -3.62326317e-02f, 7.33914524e-02f, 9.85929519e-02f, -1.83347065e-03f, 4.34322320e-02f, 4.41262018e-05f, -4.12558056e-02f,
  -8.76587704e-02f, 8.23605433e-02f, -1.75057240e-02f, -2.08443608e-02f, 4.44487408e-02f, -2.91623082e-02f, 1.01723023e-01f, -3.23923677e-02f, 7.58176297e-02f, 1.01855606e-01f,
  1.01303540e-01f, 7.90257007e-02f, -1.68631021e-02f, 1.88439284e-02f, -6.13093451e-02f, 4.85990047e-02f, 1.81771368e-02f, -1.40339090e-02f, 2.04772390e-02f, -2.00970974e-02f,
  -4.85654585e-02f, -5.05519547e-02f, -5.04178135e-03f, -2.33286209e-02f, 5.55367814e-03f, -2.62655560e-02f, -7.53879100e-02f, -6.84172660e-02f, -7.58961961e-02f, -8.55016857e-02f,
  -3.46181095e-02f, -3.82849537e-02f, -2.09129453e-02f, -1.88137107e-02f, -1.12797230e-01f, -5.97750489e-03f, 1.39148161e-02f, -1.45494682e-03f, -5.60229979e-02f, -2.34545637e-02f,
  6.21158853e-02f, -4.60457765e-02f, 5.62868603e-02f, -6.22322373e-02f, -6.70372471e-02f, -2.47441381e-02f, -4.08270918e-02f, -1.32303936e-02f, -5.81321493e-02f, 1.34606704e-01f,
  -3.07719428e-02f, 8.86262103e-04f, -5.85691407e-02f, 4.01669256e-02f, 1.22890264e-01f, -3.62979546e-02f, 1.76808797e-02f, -2.56291497e-03f, -1.68270990e-02f, 6.77276030e-02f,
  6.17283536e-03f, 1.92772504e-02f, 1.06410673e-02f, 1.07286125e-01f, -1.28238807e-02f, 6.61649406e-02f, 1.74577489e-01f, 9.14959386e-02f, 1.01357952e-01f, 8.61330405e-02f,
  -2.99558312e-01f, -1.17070220e-01f, -6.31743073e-02f, 2.32981160e-01f, 2.79225558e-01f, 1.72905788e-01f, 1.62692726e-01f, 1.94257125e-01f, 1.89062506e-01f, 3.56006213e-02f,
  4.52554263e-02f, 1.01007551e-01f, -2.01739557e-02f, -9.08577815e-03f, 1.26967192e-01f, 1.36129573e-01f, 2.39649132e-01f, 8.48362222e-03f, 5.18567711e-02f, 1.59499839e-01f,
  5.77908233e-02f, 5.06427586e-02f, -6.54382184e-02f, -2.79505737e-02f, 8.24755877e-02f, 1.80461243e-01f, 1.97809171e-02f, -5.71938269e-02f, -8.01767781e-02f, 1.53141364e-01f,
  -4.28695008e-02f, -1.69500858e-01f, 1.21011078e-01f, -1.77216418e-02f, 3.61256558e-03f, -4.41039912e-02f, -2.36378442e-02f, -7.70585090e-02f, -2.22972557e-02f, -3.38060707e-02f,
  -7.39714578e-02f, -9.04109627e-02f, 1.24575906e-01f, 1.66829769e-02f, -1.33518279e-01f, 1.12736747e-02f, -2.39497703e-02f, -1.02363549e-01f, 4.90647927e-02f, -6.10215552e-02f,
  1.40096590e-01f, 3.44901271e-02f, -1.06184639e-01f, -3.25311758e-02f, 1.90472137e-02f, 8.12439322e-02f, 8.49032495e-03f, -7.98349455e-02f, -8.11544899e-03f, -4.36486639e-02f,
  5.67747839e-02f, 4.71979752e-02f, -9.72737186e-03f, 6.03999719e-02f, 4.33949009e-02f, -2.86031645e-02f, 9.05660167e-02f, 3.21936943e-02f, 4.50140014e-02f, 5.06584998e-03f,
  -5.62903397e-02f, -6.57296181e-02f, -3.89659754e-03f, 5.19878268e-02f, -4.25460078e-02f, 5.97160533e-02f, 4.31656614e-02f, -2.31565200e-02f, -1.12003885e-01f, 1.06973597e-03f,
  -5.18392026e-02f, -2.18857676e-02f, 3.66226286e-02f, -4.02268469e-02f, 6.34850189e-03f, 4.53145802e-02f, -4.93356539e-03f, -1.43426666e-02f, -3.38072106e-02f, -1.19454926e-02f,
  5.19246981e-02f, -2.31967904e-02f, 1.67529270e-01f, 2.45598666e-02f, -5.27911410e-02f, -1.21376589e-01f, 2.55427603e-02f, -7.07919970e-02f, -1.64880212e-02f, -1.36259366e-02f,
  -7.31785893e-02f, -9.99799371e-02f, -4.06972468e-02f, -4.08931402e-03f, -1.02336772e-01f, -1.21342679e-02f, 1.55693106e-02f, 2.80036628e-02f, 7.16883391e-02f, -1.12821804e-02f,
  -9.36543196e-03f, 1.15163192e-01f, -2.20564101e-02f, 1.04740143e-01f, -3.71034704e-02f, 1.99716815e-04f, -2.80101486e-02f, 1.09207898e-01f, 4.32483032e-02f, 6.76388592e-02f,
  1.60018533e-01f, -6.43574968e-02f, -1.91964407e-03f, 1.30034223e-01f, 5.02002165e-02f, -5.54522611e-02f, -2.35229768e-02f, -5.93717210e-02f, 4.55353782e-02f, 1.29714489e-01f,
  2.72304770e-02f, 5.70557229e-02f, 3.65800411e-02f, 5.87556278e-03f, 3.22620831e-02f, -1.72811579e-02f, -5.64321596e-03f, 1.37608588e-01f, 1.62333697e-01f, 6.31070137e-02f,
  9.40867886e-02f, 3.72687615e-02f, 1.01556629e-01f, -2.29403395e-02f, 7.53004476e-02f, 3.43147516e-02f, 1.85490446e-03f, 7.66303316e-02f, 1.05701312e-01f, 1.86932623e-01f,
  2.02031836e-01f, 3.84229273e-02f, -4.54461090e-02f, 3.00103780e-02f, 6.96375519e-02f, 7.43974298e-02f, 3.03161722e-02f, -2.23115832e-02f, 2.01353841e-02f, 5.45575060e-02f,
  -6.00176165e-03f, -1.02496380e-02f, 1.11871734e-02f, -5.84501624e-02f, 1.39818164e-02f, -1.77517693e-04f, -1.03439927e-01f, 6.65640309e-02f, -2.38124598e-02f, 8.51208791e-02f,
  -1.02993309e-01f, -2.98114512e-02f, -5.20570464e-02f, -7.97029659e-02f, 7.90981296e-03f, 8.10180306e-02f, -8.33864734e-02f, -5.83072230e-02f, 2.66389754e-02f, -4.20226902e-02f,
  -1.99673325e-02f, 2.05413401e-02f, -5.18825911e-02f, 2.27721147e-02f, -9.44497287e-02f, 2.73323562e-02f, -8.49946290e-02f, -7.94750005e-02f, -5.00525907e-02f, -9.64847729e-02f,
  5.11942543e-02f, -3.83866727e-02f, -2.50878539e-02f, 4.00379039e-02f, -1.36420294e-03f, 7.99940377e-02f, -4.60624248e-02f, 5.96103333e-02f, 6.71919361e-02f, 7.31197372e-02f,
  -2.82798689e-02f, 2.33237632e-02f, 2.33385004e-02f, -1.33245923e-02f, 3.98942344e-02f, -1.09091699e-02f, 7.83123225e-02f, 1.30148223e-02f, -9.41509232e-02f, -5.33760674e-02f,
  2.56514512e-02f, -1.22115938e-02f, 4.81469296e-02f, -3.47810201e-02f, 1.03563234e-01f, 7.94983283e-02f, 4.89306152e-02f, 9.86375883e-02f, 3.54473181e-02f, 1.00376129e-01f,
  1.00252427e-01f, 5.62596694e-02f, 1.03398757e-02f, 6.97463825e-02f, 7.05275917e-03f, -3.60931940e-02f, -6.66825473e-02f, 1.00595519e-01f, -4.43380289e-02f, -3.88482033e-04f,
  8.13199654e-02f, -1.75240394e-02f, 6.30308911e-02f, -7.93269649e-02f, 1.62522830e-02f, -6.48124069e-02f, 6.08715713e-02f, 1.09369941e-01f, 2.75444351e-02f, -4.06935401e-02f,
  -2.17749625e-01f, 1.39185458e-01f, -5.19093089e-02f, 8.36699829e-02f, 9.24104229e-02f, -4.11210135e-02f, -1.02318443e-01f, -1.08560897e-01f, -4.83132713e-03f, 5.16428053e-02f,
  1.41435675e-02f, -5.68197928e-02f, -2.20371094e-02f, -2.14789271e-01f, -4.34550762e-01f, -1.08864635e-01f, -1.16775781e-01f, -3.56545955e-01f, -4.27538276e-01f, -2.49813393e-01f,
  -1.33929849e-01f, -1.50752485e-01f, -3.08502287e-01f, -1.10402673e-01f, 3.90652046e-02f, 4.41522710e-02f, 1.37037337e-01f, 5.34745492e-02f, -1.21964268e-01f, 1.70035154e-01f,
  3.02541722e-02f, 4.75736223e-02f, -1.62662476e-01f, -2.51561478e-02f, 5.10643348e-02f, 3.37868892e-02f, 5.45993075e-02f, 1.93969943e-02f, 3.98136340e-02f, 1.03232272e-01f,
  4.18352671e-02f, 2.27173511e-02f, 5.94671890e-02f, -2.81184744e-02f, -7.14500248e-02f, -6.28153607e-02f, -1.33533165e-01f, -1.33784413e-01f, -6.14186823e-02f, 6.80764671e-03f,
  -8.45903382e-02f, -6.00506701e-02f, -1.51531398e-01f, 4.52204905e-02f, -9.27372742e-03f, 7.08262809e-03f, -7.53247440e-02f, 1.97010543e-02f, -1.21407256e-01f, 5.58241047e-02f,
  2.49511208e-02f, -1.61450803e-02f, -1.42942322e-02f, -5.80517836e-02f, -5.86999655e-02f, 2.16880627e-02f, -1.25932340e-02f, 5.73683344e-03f, -1.02879442e-01f, 1.47342158e-03f,
  -2.58703716e-02f, 1.90086830e-02f, 2.19643768e-02f, 8.45100731e-02f, -5.86429089e-02f, 4.21377309e-02f, -4.57067601e-02f, 2.27659699e-02f, -3.54103372e-02f, -1.39581598e-02f,
  2.02704370e-02f, 4.36703488e-02f, 8.56277198e-02f, -1.86279672e-03f, 1.94703825e-02f, -3.72160748e-02f, 5.03505319e-02f, -7.05656856e-02f, -2.68895309e-02f, 4.70741605e-03f,
  7.57002160e-02f, -1.24146923e-01f, -7.37012327e-02f, -1.90109592e-02f, 1.07894875e-01f, 5.59065454e-02f, 1.55363023e-01f, 5.90272993e-02f, 9.12305638e-02f, -1.56255960e-02f,
  -8.22427869e-02f, -9.19880122e-02f, 2.33170413e-03f, -9.62616056e-02f, -9.02311355e-02f, -3.24935839e-02f, -5.82456067e-02f, -2.03623460e-03f, -6.96247742e-02f, -6.36455463e-03f,
  2.76982673e-02f, -4.44337800e-02f, -2.15854764e-01f, -1.07022980e-02f, -5.60201034e-02f, -1.10346586e-01f, -1.37561530e-01f, -1.25774443e-01f, -1.20783217e-01f, -3.25198434e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  4.28269990e-02f, 8.62215906e-02f, 2.02760234e-01f, 7.87114073e-03f, 3.49976234e-02f, 6.38655201e-02f, -1.26200449e-02f, 1.99341401e-01f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -1.42304778e-01f, -1.55008703e-01f, 4.82463874e-02f, 1.34934232e-01f, 1.21723088e-02f, 2.59277552e-01f, -8.00544992e-02f, 9.07902271e-02f, 1.83730438e-01f, -1.06827430e-01f,
  -2.03688860e-01f, -1.44466728e-01f, 1.03648007e-01f, -2.98365112e-02f, 1.40997082e-01f, -1.91362172e-01f, -6.14986792e-02f, -1.91278920e-01f, 1.02893583e-01f, 2.13304147e-01f,
  -6.73935711e-02f, 8.94947276e-02f, 2.36736819e-01f, 3.63276392e-01f, 3.22740048e-01f, 3.84354801e-03f, -1.32002264e-01f, 1.29058316e-01f, -1.03656404e-01f, 1.67557642e-01f,
  1.69089243e-01f, 3.16410571e-01f, 2.24394962e-01f, 8.74617621e-02f, 1.26494065e-01f, 1.37259945e-01f, 8.15771073e-02f, 1.14350058e-01f, 1.82770163e-01f, -2.26195723e-01f,
  2.62245387e-01f, 4.97261174e-02f, -7.91272223e-02f, -1.40295103e-01f, -1.25295192e-01f, 6.43652678e-02f, 2.00789958e-01f, -7.40989372e-02f, -2.71898031e-01f, 2.21876502e-01f,
  1.28819913e-01f, 9.48705599e-02f, 2.95743290e-02f, -3.00637037e-01f, -1.17342226e-01f, -6.38960116e-03f, 6.67009875e-02f, -1.78137556e-01f, -2.58969486e-01f, 2.69688427e-01f,
  1.43592685e-01f, -1.69796094e-01f, -6.56838194e-02f, -7.17076957e-02f, -9.14734304e-02f, -1.10971190e-01f, -1.72947258e-01f, -2.63248384e-01f, -2.19192654e-01f, -4.40296739e-01f,
  1.48434743e-01f, 1.17965718e-03f, 1.09414302e-03f, -4.02595520e-01f, -1.48693815e-01f, 1.49445295e-01f, -1.69326603e-01f, -1.02572605e-01f, -2.20485345e-01f, 3.38765621e-01f,
  1.60018861e-01f, 1.38100237e-01f, -1.52509794e-01f, -2.08838344e-01f, 1.34395510e-01f, 4.39329296e-01f, 2.85300072e-02f, -1.11406043e-01f, -3.05957854e-01f, -4.09603938e-02f,
  -2.51511276e-01f, -7.79006556e-02f, 1.85564324e-01f, -2.54309118e-01f, 5.72796538e-02f, 1.66757982e-02f, 3.37862857e-02f, 5.51470406e-02f, 1.77361164e-02f, 1.15767848e-02f,
  2.64996082e-01f, -1.71731442e-01f, 3.75421047e-02f, -2.39186943e-01f, -1.09366521e-01f, 1.21269286e-01f, -3.18901753e-03f, -6.79047480e-02f, -1.08750708e-01f, 1.49627300e-02f,
  1.39118517e-02f, 4.31962430e-01f, 9.57008153e-02f, 4.74054545e-01f, 1.50872186e-01f, -2.32601911e-01f, -2.59653509e-01f, -2.79707193e-01f, -5.07848859e-01f, -8.68765295e-01f,
  -2.29106829e-01f, -2.40247443e-01f, 1.10995084e-01f, 3.91883589e-03f, 1.76643714e-01f, -7.38904625e-02f, 8.49932879e-02f, -2.62333930e-01f, 1.69602156e-01f, 1.95414409e-01f,
  8.97640958e-02f, -2.06275269e-01f, -6.49112612e-02f, 1.59523860e-02f, -1.05441183e-01f, -1.77157402e-01f, 1.69602469e-01f, 7.17612728e-02f, 6.46232069e-02f, 2.04587251e-01f,
  -4.31830063e-02f, -2.43873507e-01f, -1.45143062e-01f, -4.83791158e-02f, 2.20291063e-01f, -7.43775442e-02f, -8.24065804e-02f, -1.80716902e-01f, -3.69918823e-01f, 1.16509639e-01f,
  -2.01195702e-01f, -4.38544065e-01f, -1.28847033e-01f, -1.87619537e-01f, -2.28556227e-02f, -2.94319749e-01f, -9.48202536e-02f, -2.28835382e-02f, 2.62713134e-02f, -7.98657089e-02f,
  -6.36940151e-02f, -8.48582461e-02f, 1.02425560e-01f, -1.11864440e-01f, -1.39749169e-01f, -1.37607887e-01f, -9.97986794e-02f, 7.70450532e-02f, -5.20969748e-01f, 6.49850024e-03f,
  -5.76410480e-02f, 2.14332789e-01f, -1.10288695e-01f, 1.81941450e-01f, 3.60928313e-03f, -2.34750912e-01f, 4.55193549e-01f, -3.42641711e-01f, -3.72944027e-01f, -2.15147734e-01f,
  2.62727477e-02f, 3.43247205e-02f, 1.60269380e-01f, 4.85606194e-02f, -3.54306042e-01f, -1.65844291e-01f, 2.98687011e-01f, -6.88950792e-02f, -1.79176461e-02f, -2.97786951e-01f,
  -2.15173706e-01f, -6.14590086e-02f, 3.25982839e-01f, -1.45994034e-02f, 5.29478155e-02f, 1.63092673e-01f, 2.85130233e-01f, 2.14626148e-01f, 1.76358074e-01f, -8.16280097e-02f,
  -4.02006358e-01f, 3.36450994e-01f, 1.34952553e-02f, -8.01318884e-02f, -2.94037461e-01f, -3.80651243e-02f, 3.95832002e-01f, -3.76912087e-01f, 2.10801572e-01f, -2.96063609e-02f,
  -3.26073468e-02f, 1.61174536e-01f, -1.57769784e-01f, -3.22015822e-01f, -7.78401783e-03f, -1.72619179e-01f, -1.51382640e-01f, -6.53857812e-02f, 1.09167518e-02f, 2.89609790e-01f,
  -1.85862958e-01f, -1.59382939e-01f, 4.31809127e-02f, -2.05233485e-01f, -2.40209792e-02f, -2.12054312e-01f, -6.21871538e-02f, -2.54978746e-01f, -1.19521059e-01f, -4.48372245e-01f,
  1.49691239e-01f, -6.83552697e-02f, -8.37764889e-02f, -1.11633964e-01f, -9.80269685e-02f, 5.39173838e-03f, -2.18384922e-01f, -2.39752635e-01f, -2.57519372e-02f, 1.04361340e-01f,
  4.91370037e-02f, 1.78465337e-01f, -2.58267850e-01f, -2.65024096e-01f, 8.73164907e-02f, 2.14380473e-01f, -2.95619704e-02f, -7.77131394e-02f, 2.85486784e-02f, -1.41153365e-01f,
  -3.86898845e-01f, -9.15405080e-02f, 1.03411153e-01f, -1.25881404e-01f, -2.04521388e-01f, -8.63688961e-02f, 9.20053795e-02f, -3.46850641e-02f, 2.83385724e-01f, -1.34943962e-01f,
  -3.88095528e-02f, 5.56769744e-02f, 7.25014135e-02f, 1.66467473e-01f, -1.48981726e-02f, 1.35556847e-01f, -1.09535038e-01f, 4.03017141e-02f, 1.02137715e-01f, -1.53351352e-01f,
  1.89648300e-01f, -2.41981596e-01f, 1.66750625e-01f, -7.04480037e-02f, 7.68760741e-02f, -1.04286097e-01f, -2.44020388e-01f, 2.96527088e-01f, 1.02077849e-01f, 6.25843331e-02f,
  3.07729412e-02f, -1.15968309e-01f, 1.67422846e-01f, -1.06018439e-01f, 5.97142465e-02f, -2.57692337e-02f, 2.45613907e-03f, -7.74955153e-02f, -1.11917146e-01f, -2.46354997e-01f,
  -9.42546502e-02f, 9.49431434e-02f, -1.03687890e-01f, 2.95963436e-01f, -1.11585207e-01f, -1.59382746e-01f, -4.50810164e-01f, 3.65518749e-01f, 3.76662053e-02f, -2.21120924e-01f,
  -1.82690844e-01f, 6.78730980e-02f, 4.43417579e-01f, -7.27332830e-02f, -8.96431729e-02f, -2.29019731e-01f, -1.08674608e-01f, 1.32962940e-02f, 2.04334214e-01f, -5.29341221e-01f,
  3.23633775e-02f, -2.61747330e-01f, -2.18968764e-01f, 2.02555329e-01f, 2.85921305e-01f, 3.08014721e-01f, -1.16806284e-01f, 6.43965900e-02f, -2.37294972e-01f, -2.64034301e-01f,
  1.05776101e-01f, -8.44516680e-02f, -1.42959980e-02f, -5.72443753e-02f, 6.61460534e-02f, 1.47998929e-01f, 2.33931184e-01f, -1.35049686e-01f, -1.73001751e-01f, 6.55892417e-02f,
  -3.07950582e-02f, 2.13757697e-02f, -3.27869147e-01f, -3.26795205e-02f, 3.77488583e-01f, -4.22891110e-01f, 5.53701306e-03f, 3.02525401e-01f, -1.10994458e-01f, 8.77458975e-02f,
  -1.55694366e-01f, -2.47177586e-01f, -2.13916123e-01f, -2.98903048e-01f, -3.55954990e-02f, -2.85956532e-01f, 5.16142771e-02f, 2.71690220e-01f, -2.65592694e-01f, -4.41984423e-02f,
  -1.02811277e-01f, -2.68702973e-02f, -2.41719224e-02f, 5.36319576e-02f, 1.15149751e-01f, -1.84697911e-01f, -2.25023124e-02f, -4.84695192e-03f, -5.24534993e-02f, -6.76980987e-02f,
  -2.96428591e-01f, 9.27953944e-02f, 2.10367799e-01f, 2.68294122e-02f, -6.08631819e-02f, 1.32321849e-01f, -2.92490602e-01f, -2.82798022e-01f, 2.62187749e-01f, -2.71194935e-01f,
  -2.82029003e-01f, -2.78898031e-01f, -5.18832803e-02f, 3.04986775e-01f, 7.79712126e-02f, -8.21148232e-02f, -3.88169348e-01f, 3.21979225e-02f, -1.83648318e-02f, -3.13583016e-01f,
  -1.13165462e-02f, -1.40196830e-01f, 4.33851555e-02f, -2.17870042e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -1.82516910e-02f, -1.15696579e-01f, 1.87051624e-01f, 8.93625095e-02f, 9.90823731e-02f, 3.71065689e-03f, 6.28878847e-02f, -1.23611793e-01f, -1.53400287e-01f, 5.83445542e-02f,
  8.36704448e-02f, -7.90547859e-03f, -8.83973911e-02f, 3.28340358e-03f, 1.37808189e-01f, -2.58176737e-02f, 6.81600720e-02f, -6.79971874e-02f, 5.41264713e-02f, 9.13484097e-02f,
  -1.06197022e-01f, -7.92322215e-03f, -2.01139525e-01f, -4.09102105e-02f, -1.71469510e-01f, 1.73525244e-01f, 3.22784007e-01f, -2.89453398e-02f, 1.57085434e-01f, 3.36919010e-01f,
  2.29839772e-01f, -1.62072867e-01f, 3.31248671e-01f, 3.03986460e-01f, 2.41839260e-01f, -3.99872512e-02f, 2.59870104e-02f, -6.83909059e-02f, 1.90019980e-01f, -3.69698405e-02f,
  4.51612055e-01f, -7.68643990e-02f, 3.51718776e-02f, 9.04466361e-02f, -1.96789801e-01f, -3.22754294e-01f, -1.82484627e-01f, 4.15826112e-01f, 9.42062512e-02f, 5.91582894e-01f,
  9.38172191e-02f, -1.47898197e-01f, -2.72386342e-01f, -3.19129050e-01f, -3.11029792e-01f, -3.95688146e-01f, 7.41789192e-02f, -4.92662378e-02f, 6.65454566e-02f, 1.66124240e-01f,
  7.63641894e-02f, 3.35975550e-02f, -4.93105240e-02f, 2.25335583e-01f, 2.16417834e-01f, 2.82114297e-01f, 1.00421168e-01f, -4.83178943e-02f, 6.95800334e-02f, -2.81438947e-01f,
  2.04494178e-01f, 4.44388948e-02f, 3.46808940e-01f, -1.86281279e-01f, 2.14757368e-01f, -4.64530289e-02f, 8.74955133e-02f, -2.09157526e-01f, -2.25177407e-01f, 9.85841826e-02f,
  3.15727629e-02f, 1.98169291e-01f, -1.79496586e-01f, -4.18133624e-02f, -3.44600827e-01f, 3.92247766e-01f, 3.50299627e-02f, 8.88281986e-02f, 1.04975544e-01f, -1.35707343e-02f,
  -1.02468565e-01f, -5.78193404e-02f, -1.78064965e-02f, -9.33991373e-02f, -8.77532065e-02f, 6.14343345e-01f, 2.84863353e-01f, -3.22028659e-02f, 1.96795389e-01f, -1.15059160e-01f,
  -1.86686742e-03f, -5.98534234e-02f, 1.18020318e-01f, -1.51826546e-01f, -1.11116163e-01f, 2.55145580e-02f, 2.51359195e-01f, 2.90691525e-01f, -1.37586161e-01f, -1.73982561e-01f,
  -3.23573232e-01f, 1.85273409e-01f, 2.73675561e-01f, 6.48152828e-02f, -2.79443830e-01f, -1.34264424e-01f, -4.16895598e-02f, -1.06067933e-01f, 8.97316933e-02f, 1.40621036e-01f,
  -1.54473767e-01f, -8.29116348e-03f, 2.56810695e-01f, -1.55699104e-01f, 8.72568861e-02f, -1.21055491e-01f, 6.11144006e-02f, 1.17458031e-01f, 2.85786122e-01f, 2.03758493e-01f,
  8.32693130e-02f, 1.28044203e-01f, 2.56856561e-01f, 3.56050611e-01f, 3.81891727e-01f, 7.47579858e-02f, 2.05859721e-01f, 2.97264636e-01f, 1.24803014e-01f, -6.42833859e-02f,
  1.10037625e-01f, 3.51463482e-02f, 5.83296835e-01f, -3.20229679e-01f, -2.56292582e-01f, -2.01313525e-01f, -2.02159241e-01f, 4.12055105e-01f, -2.75474966e-01f, 1.89721689e-01f,
  1.29262418e-01f, 5.32083750e-01f, 5.77805042e-01f, -2.06074789e-01f, 3.69365923e-02f, 2.20060304e-01f, -6.69774935e-02f, -3.43937129e-01f, 3.26136023e-01f, 3.28522235e-01f,
  3.11565995e-01f, 2.82685786e-01f, 4.15705182e-02f, 2.28197649e-01f, 2.99490720e-01f, -3.89088839e-01f, 2.90487617e-01f, -2.09625214e-02f, 2.45425135e-01f, 1.46777019e-01f,
  2.99543262e-01f, 4.51983184e-01f, 9.64435637e-02f, 8.19759220e-02f, -3.77998650e-01f, 5.83280325e-02f, 1.20096020e-01f, -3.11083853e-01f, -4.61246967e-01f, -1.56476498e-01f,
  3.66419144e-02f, 4.61958170e-01f, 2.95900982e-02f, 2.78546214e-01f, -1.90353483e-01f, 3.03106084e-02f, -1.94411337e-01f, -1.27544999e-01f, -1.64331511e-01f, -3.30473900e-01f,
  -1.60239413e-01f, 3.25208455e-01f, -1.15050465e-01f, 1.21867940e-01f, 6.30651116e-02f, 3.11327148e-02f, 8.62523988e-02f, 1.18495934e-01f, 1.61329005e-02f, -2.71176659e-02f,
  -8.08903128e-02f, -1.13628291e-01f, -1.33808494e-01f, 3.25974412e-02f, 1.17067061e-01f, -9.68454927e-02f, -1.73831537e-01f, -1.59146607e-01f, -2.39505209e-02f, 1.03113078e-01f,
  1.46394476e-01f, -1.47505105e-01f, -2.25387797e-01f, 5.62751442e-02f, -7.26531669e-02f, -2.24853113e-01f, 9.05607119e-02f, -1.00863114e-01f, -1.16416765e-02f, -1.61896110e-01f,
  -2.35230774e-02f, 9.30520818e-02f, 8.90145451e-02f, 8.30545202e-02f, -1.26468956e-01f, 8.05221964e-03f, -8.02900866e-02f, 7.64764622e-02f, 7.47585744e-02f, 1.78930447e-01f,
  7.15216845e-02f, -4.30168547e-02f, -5.93817346e-02f, -1.39097840e-01f, -3.26285996e-02f, 1.70778379e-01f, 2.86559105e-01f, 2.20404506e-01f, -1.45920441e-01f, 2.07003132e-01f,
  2.18900606e-01f, -2.47480616e-01f, 1.49804372e-02f, 1.28817987e-02f, 2.53121465e-01f, 1.23378687e-01f, -7.22809602e-03f, 3.89532804e-01f, -2.56904145e-03f, 3.01640928e-01f,
  2.01351404e-01f, -6.82480112e-02f, -8.55570957e-02f, 2.19969571e-01f, -1.93914756e-01f, 3.31296533e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  4.63441424e-02f, 8.89102295e-02f, 3.02546978e-01f, 8.07907656e-02f, 2.38695934e-01f, 2.61697650e-01f, 1.33711368e-01f, 2.82225549e-01f
};

// L2_fan_Wp (Shape: 12 x 32)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -1.64872885e-01f, 4.20448892e-02f, 1.21124729e-03f, -1.96555704e-01f, 1.77014977e-01f, -1.26672044e-01f, 1.76136822e-01f, -5.31959115e-03f, 1.56865180e-01f, 2.55326688e-01f,
  1.82396904e-01f, -1.95929646e-01f, 1.32550988e-02f, 2.08406240e-01f, 8.45540613e-02f, -2.53536582e-01f, -1.28182068e-01f, -3.07105035e-01f, -1.20331254e-02f, -2.54364938e-01f,
  -2.74600029e-01f, -3.24293375e-01f, -1.81212634e-01f, -2.69925505e-01f, -2.97823548e-01f, 9.98435840e-02f, 8.45842957e-02f, -2.06546411e-01f, -5.35163246e-02f, -7.20897242e-02f,
  -5.50250746e-02f, 1.08771034e-01f, -1.13803729e-01f, -5.51720597e-02f, -5.13540730e-02f, -3.12308252e-01f, 2.60064248e-02f, -3.61978054e-01f, 2.46340215e-01f, 1.23389006e-01f,
  -4.72131744e-02f, -1.94254309e-01f, 6.88975528e-02f, -1.39418006e-01f, 1.97872236e-01f, 7.72852078e-02f, -5.01084775e-02f, -1.54399320e-01f, 1.83440402e-01f, -5.13685286e-01f,
  -4.16039765e-01f, -9.09243003e-02f, 1.12552933e-01f, -2.81100124e-01f, -1.91122174e-01f, -1.78673372e-01f, 5.08761092e-04f, 8.88866484e-02f, 2.63400167e-01f, -3.51027012e-01f,
  2.10838035e-01f, -3.77996653e-01f, 1.73059106e-01f, -1.70972690e-01f, -1.03180185e-01f, 1.00111783e-01f, 1.83257058e-01f, 7.89925382e-02f, 2.89519489e-01f, -2.35136986e-01f,
  2.03722328e-01f, 1.28987253e-01f, 8.18455312e-03f, -1.44542053e-01f, -4.18546766e-01f, -2.17670381e-01f, -8.37339386e-02f, -6.25500306e-02f, 3.94267678e-01f, -2.98981041e-01f,
  1.27156988e-01f, -1.53695062e-01f, -2.03127623e-01f, 3.30569535e-01f, 6.56203032e-02f, -7.19435930e-01f, -4.13488656e-01f, 3.80984426e-01f, 3.90703492e-02f, -2.71808594e-01f,
  3.21365654e-01f, 1.32997662e-01f, -5.15899956e-02f, 2.99787313e-01f, -7.01985359e-02f, 2.87675634e-02f, 1.00013509e-01f, -5.79870455e-02f, -3.14560443e-01f, -1.40857056e-01f,
  -1.63958386e-01f, -1.99809834e-01f, -1.43580949e-02f, -6.32845983e-02f, 2.00613230e-01f, 2.51976907e-01f, 1.12941727e-01f, -2.00140595e-01f, 2.90256798e-01f, 3.02509278e-01f,
  -4.83256131e-01f, 3.13818594e-03f, -2.30517492e-01f, -3.98248166e-01f, 5.29399030e-02f, -4.56103623e-01f, -2.05600724e-01f, 3.39614868e-01f, 2.81778634e-01f, -3.73445749e-01f,
  2.44863499e-02f, -7.82245025e-02f, -2.98072129e-01f, -9.51572731e-02f, 5.10672433e-03f, -3.07371795e-01f, -1.36590898e-01f, 2.84580048e-02f, -1.55304864e-01f, 3.39855462e-01f,
  9.15499032e-02f, 1.32884175e-01f, -1.57959372e-01f, 2.16273680e-01f, 8.58051404e-02f, -5.92374615e-02f, -2.07191005e-01f, -2.30477955e-02f, -2.55519748e-01f, 9.90340635e-02f,
  8.89247134e-02f, -4.05090481e-01f, -1.54807083e-02f, -5.75454950e-01f, 4.42941897e-02f, 3.65346402e-01f, -2.06399813e-01f, -1.46234095e-01f, 5.96534461e-02f, -1.69828430e-01f,
  -4.68397260e-01f, 4.30376679e-02f, 3.90103236e-02f, -4.52003896e-01f, 1.24100767e-01f, 1.72738776e-01f, 5.19802459e-02f, 3.16903651e-01f, -1.23405652e-02f, 2.67029971e-01f,
  -2.72450835e-01f, -1.18107058e-01f, -2.80553699e-01f, -2.24979743e-01f, 1.01959728e-01f, 3.35556641e-02f, -2.07484588e-01f, -1.48975149e-01f, -1.38637900e-01f, -1.79169308e-02f,
  6.80063292e-02f, -6.95382580e-02f, 3.31434876e-01f, 2.97719892e-02f, -3.64939600e-01f, -5.86271405e-01f, -1.27194181e-01f, -1.03965320e-01f, -8.25208202e-02f, -1.70131430e-01f,
  2.44314745e-01f, 3.04803066e-02f, -1.36444382e-02f, -3.47468741e-02f, -6.86751753e-02f, -9.99326631e-02f, -2.15636343e-01f, -1.61050320e-01f, 3.25439692e-01f, -1.82102874e-01f,
  4.55935486e-02f, 1.16661705e-01f, 1.42120823e-01f, 3.07017475e-01f, 1.80404186e-01f, 5.27064465e-02f, -8.03259611e-02f, 1.77214190e-01f, 2.28772759e-01f, -5.41743748e-02f,
  1.80095717e-01f, 1.07357847e-02f, -1.01860791e-01f, 2.62871504e-01f, 4.33469191e-02f, -1.17445633e-01f, -2.26748921e-02f, -4.88828659e-01f, 9.42311883e-02f, 7.67063275e-02f,
  -1.79130137e-01f, -6.12881295e-02f, 2.23499939e-01f, -2.51072764e-01f, -2.48307928e-01f, -1.48208113e-02f, -3.84074152e-02f, -8.61948282e-02f, 2.61776626e-01f, -2.00147741e-02f,
  -4.23321500e-02f, 3.56042832e-01f, 6.01326860e-02f, 1.03425629e-01f, -9.67893898e-02f, -2.92576432e-01f, -2.50741422e-01f, -1.18634500e-01f, -1.59671903e-01f, -1.76250935e-01f,
  6.33377060e-02f, 1.10032141e-01f, 2.37573668e-01f, 8.15492794e-02f, 1.12383097e-01f, -2.44188622e-01f, 6.08852319e-02f, 2.04952270e-01f, -3.68206590e-01f, 1.55573860e-01f,
  -3.16390336e-01f, -5.52021444e-01f, 2.60892838e-01f, -3.35694999e-01f, 1.48104643e-02f, 2.38431811e-01f, 8.24953616e-02f, -4.07011688e-01f, -8.31628684e-03f, 1.09491274e-01f,
  3.97189613e-03f, -2.11809859e-01f, 1.46737117e-02f, -4.04865354e-01f, -3.58280651e-02f, -6.49358258e-02f, 1.28467139e-02f, -5.77215478e-03f, 1.79440573e-01f, 1.07122503e-01f,
  1.14101075e-01f, -2.44999491e-02f, 1.19257756e-01f, 9.48153511e-02f, 7.00384676e-02f, -7.69798318e-03f, 3.06140482e-02f, 1.62339047e-01f, -2.47782484e-01f, -1.71546578e-01f,
  9.60748568e-02f, 6.33003533e-01f, 4.35845435e-01f, 1.55323058e-01f, 2.15150014e-01f, 4.26216274e-01f, 1.16598308e-01f, -4.79817949e-02f, 1.62176847e-01f, 1.28909305e-01f,
  2.80009788e-02f, 2.84314245e-01f, -1.31296471e-01f, 1.96234256e-01f, -2.26824611e-01f, 6.57771677e-02f, 1.76542014e-01f, -2.08621413e-01f, 3.22091132e-01f, 2.61225820e-01f,
  2.08807886e-02f, 6.97628409e-02f, 6.65511340e-02f, 4.32821661e-01f, -1.62639901e-01f, 2.72385199e-02f, 1.48836747e-01f, 3.36824208e-02f, -1.93884447e-01f, -3.83068584e-02f,
  -2.06736609e-01f, -1.69510722e-01f, -9.38230976e-02f, -4.03025001e-01f, -7.14844093e-03f, 2.58325785e-01f, -1.15689211e-01f, -1.95655495e-01f, 2.08550796e-01f, 6.49200231e-02f,
  -2.41269961e-01f, 4.33818728e-01f, 1.96199507e-01f, -4.19878453e-01f, -3.01443070e-01f, 3.99124697e-02f, -3.11934710e-01f, 4.03858870e-01f, 2.56625228e-02f, 4.52069491e-02f,
  1.62831135e-02f, -3.24363440e-01f, -5.42734824e-02f, -1.86587140e-01f, 1.40281498e-01f, -1.76788330e-01f, 2.98468679e-01f, 1.71354175e-01f, -9.64308083e-02f, 2.13142514e-01f,
  -6.24218509e-02f, -3.08358103e-01f, -2.42798299e-01f, 2.51809955e-01f, 3.96369956e-02f, 3.69800448e-01f, -6.94511905e-02f, -2.41615340e-01f, -1.64684188e-02f, -1.28805369e-01f,
  -1.06383145e-01f, -1.82775110e-01f, 6.91002561e-03f, -4.26000625e-01f, -7.80187100e-02f, 4.56469357e-01f, 7.57847205e-02f, 1.44256458e-01f, 2.54247226e-02f, -3.94917428e-02f,
  -2.09525779e-01f, -4.45837528e-01f, 2.20907360e-01f, -1.63056433e-01f, -1.83707774e-01f, -1.00393243e-01f, -6.51156530e-02f, 1.26322150e-01f, -2.81116992e-01f, 6.70113415e-02f,
  -6.74302280e-02f, 7.12276995e-02f, 5.28293364e-02f, -2.36643508e-01f, 4.78238016e-02f, 1.77424610e-01f, -2.07463637e-01f, -1.99320167e-01f, -3.10169041e-01f, 7.00765476e-02f,
  2.87119865e-01f, -3.75502348e-01f, 8.74567591e-03f, 4.70467448e-01f, 4.18426394e-01f, -1.27249360e-01f, 2.81137586e-01f, -3.05228978e-01f, -2.14474320e-01f, -1.71189889e-01f,
  2.50045896e-01f, -2.86588460e-01f, -1.26960665e-01f, -1.12571076e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 32)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  1.92415848e-01f, 4.32133786e-02f, 1.69222150e-02f, 2.99621761e-01f, -1.16171800e-01f, -1.07363993e-02f, 2.13497598e-02f, 1.04423024e-01f, 2.90762931e-01f, -3.11451349e-02f,
  -4.26961362e-01f, 9.51580927e-02f, 1.06573753e-01f, -4.10378546e-01f, 1.35424659e-01f, -2.25527361e-01f, 9.01725143e-02f, 2.00479671e-01f, -4.53683436e-01f, -7.32774436e-02f,
  -1.11086175e-01f, -1.28059715e-01f, -4.48918194e-01f, 2.79594332e-01f, -1.26380503e-01f, -2.74777263e-01f, 1.33042186e-01f, 2.16806456e-01f, -3.04228682e-02f, 4.57705319e-01f,
  -1.18709043e-01f, 4.63059366e-01f, 2.63069451e-01f, 7.09272251e-02f, 9.07194689e-02f, -4.01356108e-02f, 3.54544252e-01f, 3.36748749e-01f, -2.76829630e-01f, 5.49427904e-02f,
  1.62642717e-01f, 2.52993643e-01f, 1.55394942e-01f, 2.94621922e-02f, -1.19293727e-01f, 1.16197042e-01f, -4.33958381e-01f, 4.14161652e-01f, 2.23932564e-01f, -1.19896501e-01f,
  4.02964503e-01f, -1.33145422e-01f, 1.20777942e-01f, 3.80501419e-01f, 3.58123213e-01f, 5.56858964e-02f, 2.16056705e-01f, 5.64815477e-02f, -9.39289033e-02f, 1.37449041e-01f,
  2.16638148e-01f, -5.77439331e-02f, 4.03028876e-02f, -1.49407819e-01f, 1.62810519e-01f, 3.13319206e-01f, 4.17088568e-01f, 1.12141967e-01f, 2.43893638e-01f, 2.81841040e-01f,
  4.37305391e-01f, 3.71295244e-01f, 1.68138683e-01f, 3.19155633e-01f, 1.29612908e-01f, 2.68958777e-01f, -1.56988159e-01f, -1.64233908e-01f, 3.94996345e-01f, 1.01008549e-01f,
  4.83799815e-01f, -1.55801401e-01f, -3.47617447e-01f, 1.64923385e-01f, 1.35520279e-01f, -6.53350770e-01f, -3.49556506e-01f, 1.17093839e-01f, -6.99579418e-02f, 5.16179442e-01f,
  6.42258108e-01f, 3.79188418e-01f, -2.80066747e-02f, 6.93676949e-01f, 8.35478380e-02f, 4.83523794e-02f, -5.26149273e-02f, -1.12242587e-01f, -1.57568842e-01f, -2.17858419e-01f,
  -6.72409311e-02f, -1.54199302e-01f, 4.78037260e-02f, -2.11238638e-01f, 1.75758824e-01f, 9.49000791e-02f, 7.28120208e-02f, -1.69127941e-01f, 1.62782952e-01f, 4.63574789e-02f,
  1.56677932e-01f, -2.02492699e-01f, -9.75193009e-02f, -1.73451126e-01f, 9.46616977e-02f, 8.47223923e-02f, -7.81359747e-02f, 6.29341826e-02f, -4.99226563e-02f, -8.77946243e-02f,
  4.20805693e-01f, -2.04294771e-02f, -6.46142811e-02f, -2.04488665e-01f, -7.81005919e-02f, 5.11140861e-02f, 4.82492993e-04f, 1.35296181e-01f, 1.01056524e-01f, 1.09370768e-01f,
  4.27017435e-02f, -1.75686002e-01f, -6.43683001e-02f, 6.62670285e-02f, 4.70256619e-02f, -1.29410505e-01f, -1.68912988e-02f, -1.16333865e-01f, -1.08153792e-02f, 1.52638882e-01f,
  -4.77842912e-02f, -8.62857550e-02f, 2.18082488e-01f, 1.05913192e-01f, 2.31052890e-01f, -1.25710353e-01f, -1.48451716e-01f, 6.76002130e-02f, 2.15516537e-01f, 1.67517271e-02f,
  4.57311422e-02f, 7.50746727e-02f, -8.75765532e-02f, 1.65018570e-02f, 2.07421988e-01f, -6.09155595e-02f, 4.63468023e-02f, -2.11078897e-02f, 7.36399442e-02f, -1.28033563e-01f,
  -5.92468828e-02f, 7.35905692e-02f, 2.30904333e-02f, 7.26918057e-02f, 3.02442193e-01f, -4.50398847e-02f, 2.75839549e-02f, 2.82696158e-01f, 4.24406677e-02f, -9.57292244e-02f,
  2.90734947e-01f, 1.11954726e-01f, 5.02375543e-01f, 2.26313785e-01f, -2.74646014e-01f, -8.72705102e-01f, -3.98804486e-01f, 1.59119815e-01f, 6.61142468e-02f, -3.87218624e-01f,
  3.85657787e-01f, -3.93771768e-01f, -5.88616543e-02f, -1.38413474e-01f, -2.19641417e-01f, -3.90757680e-01f, 5.11989966e-02f, -7.56311417e-02f, 1.01035523e+00f, 1.89396560e-01f,
  -7.96486903e-03f, -5.30901656e-04f, 1.53993875e-01f, -1.91843316e-01f, 2.85413768e-02f, 1.75335675e-01f, 2.29979560e-01f, 1.46784350e-01f, 4.37179804e-02f, 3.36608499e-01f,
  2.08499223e-01f, 2.70231366e-01f, 3.55666697e-01f, 7.44134560e-02f, 1.82255656e-01f, 5.09514570e-01f, -3.47567171e-01f, -2.09966630e-01f, -2.82652080e-01f, -9.20244381e-02f,
  3.11057597e-01f, -3.84203047e-01f, 1.76688295e-03f, 3.96583183e-03f, 3.87414008e-01f, -4.25217032e-01f, -1.17873847e-01f, 9.48631838e-02f, -4.37442325e-02f, -6.77516386e-02f,
  7.91292906e-01f, 1.95063278e-01f, -1.16375804e-01f, -2.92998761e-01f, 1.82860792e-02f, -1.05365187e-01f, 1.54290080e-01f, -6.72820164e-03f, 1.22445196e-01f, -1.21194474e-01f,
  1.07019255e-02f, 3.55813056e-02f, 1.09963398e-03f, -1.00727700e-01f, -1.26835197e-01f, -1.43393338e-01f, 6.90848976e-02f, -1.02277704e-01f, -2.01289162e-01f, 3.11271008e-02f,
  2.91999392e-02f, -1.82697941e-02f, 1.40799537e-01f, 1.29319310e-01f, 1.08832112e-02f, -1.65139481e-01f, 6.64005876e-02f, -2.53150668e-02f, -9.64621603e-02f, 5.15403822e-02f,
  -9.90321189e-02f, 6.73186928e-02f, 2.72675287e-02f, 1.83623210e-02f, -5.85083812e-02f, -2.06831202e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  1.39840469e-01f, 3.09800446e-01f, 9.73438770e-02f, 8.05324093e-02f, 1.54534370e-01f, 8.30725878e-02f, -2.67066527e-02f, 1.84518799e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -2.18725026e-01f, -1.94306001e-01f, -3.59079361e-01f, -1.90324634e-01f, 2.39033759e-01f, -5.26653886e-01f, -2.61759371e-01f, -4.89565462e-01f, -4.16838825e-01f, 1.41936168e-01f,
  1.89410090e-01f, -1.92793980e-01f, -3.07023764e-01f, -3.91403139e-01f, 4.21617687e-01f, -8.07091966e-02f, 6.72114551e-01f, 2.14867339e-01f, 4.52042632e-02f, -3.77829641e-01f,
  1.82942942e-01f, 1.91088229e-01f, 2.49283776e-01f, 8.52258652e-02f, 1.36522591e-01f, -5.03150932e-02f, 7.24833727e-01f, 2.37823185e-02f, 1.15505263e-01f, -7.50585079e-01f,
  -4.01323438e-01f, -1.33655742e-01f, -6.91835582e-02f, 2.22102568e-01f, 1.71884689e-02f, 5.57453215e-01f, 6.43384159e-02f, 3.44910353e-01f, 2.31752664e-01f, 5.25669038e-01f,
  -8.46620053e-02f, 3.37073982e-01f, 7.41134107e-01f, 5.66351652e-01f, -6.79092884e-01f, -4.08642977e-01f, -2.78471202e-01f, -1.43752143e-01f, -7.50448048e-01f, -3.83592784e-01f,
  -2.60783017e-01f, 8.95790607e-02f, 7.23637342e-01f, 9.01391357e-02f, -1.57203421e-01f, 4.03805494e-01f, -2.93011099e-01f, 6.77900195e-01f, -3.74062061e-01f, 8.53203535e-02f,
  3.91617268e-02f, -5.06431043e-01f, -1.42410353e-01f, 4.26775962e-02f, 8.65319446e-02f, 2.60616153e-01f, 1.96620986e-01f, 5.68055272e-01f, -4.90594432e-02f, 3.96109432e-01f,
  -5.63025534e-01f, 3.37199986e-01f, 3.29736769e-01f, 4.98072952e-02f, -3.46768014e-02f, 6.21132612e-01f, -1.14369966e-01f, 1.11142106e-01f, 4.36131775e-01f, -6.24772608e-01f,
  3.75258356e-01f, 3.51217330e-01f, 5.21921143e-02f, -7.42387474e-01f, -2.41151214e-01f, 5.39685786e-01f, -1.76957265e-01f, -2.99257398e-01f, -2.00137466e-01f, -1.79774296e-02f,
  2.27373093e-02f, -1.66459665e-01f, 7.22006932e-02f, 5.43938577e-01f, 3.61781269e-01f, 8.59246999e-02f, 1.07927635e-01f, -1.39662206e-01f, -2.82776445e-01f, -4.31030840e-02f,
  -2.46287003e-01f, -1.17428720e-01f, -3.44816029e-01f, -3.05507153e-01f, 3.46606940e-01f, -9.78881061e-01f, -7.40172565e-02f, -3.39747399e-01f, -5.45150079e-02f, -3.62442493e-01f,
  -1.55627623e-01f, -2.73759902e-01f, 1.13360465e-01f, -3.72390538e-01f, -1.40076846e-01f, -3.41365263e-02f, -7.88439587e-02f, 4.20422941e-01f, -2.13589042e-01f, -4.23881590e-01f,
  8.75315309e-01f, -3.01386774e-01f, 3.77243668e-01f, -6.08616807e-02f, -9.03838351e-02f, -2.57669270e-01f, -5.46059906e-01f, -4.42619547e-02f, -2.29223952e-01f, 1.29393592e-01f,
  -5.25948107e-01f, -3.36002171e-01f, -3.60717773e-01f, 1.41095445e-01f, -2.07518756e-01f, -2.64998972e-01f, 2.05694035e-01f, 2.77752399e-01f, 1.18701600e-01f, -4.82567132e-01f,
  -2.09670700e-02f, 6.03951335e-01f, 3.72679323e-01f, -4.87068921e-01f, 3.66336107e-01f, -1.12955064e-01f, -2.43982986e-01f, -4.27478462e-01f, -1.62163466e-01f, 5.60001209e-02f,
  -1.44193321e-01f, -4.87648815e-01f, 3.09654504e-01f, -3.32894713e-01f, 3.52981240e-01f, 2.24228024e-01f, 2.14955971e-01f, 3.99419874e-01f, 4.11729664e-02f, -1.40722841e-01f,
  2.91899025e-01f, 2.29389846e-01f, 3.96310002e-01f, 5.02369761e-01f, -2.32234746e-01f, -2.52782274e-02f, 2.85094202e-01f, 3.62243503e-01f, -7.10137039e-02f, -1.37262359e-01f,
  -3.87633204e-01f, 3.52675021e-01f, 3.38031352e-01f, -1.89682618e-01f, -3.68968755e-01f, 8.49509165e-02f, -3.51310194e-01f, -5.15918553e-01f, 1.72800019e-01f, 2.60035932e-01f,
  4.65742767e-01f, -2.11672977e-01f, 4.08340275e-01f, -6.13256156e-01f, -2.19747514e-01f, 1.15826637e-01f, 4.65495139e-01f, -8.99436101e-02f, -2.00978220e-01f, -3.22703272e-01f,
  3.28304082e-01f, 9.55316350e-02f, -2.97102243e-01f, -2.53322497e-02f, -1.57203332e-01f, -5.47478139e-01f, 1.39679998e-01f, -8.58474970e-02f, 2.01837033e-01f, -5.81815600e-01f,
  -3.88436228e-01f, -3.25678170e-01f, 9.79201049e-02f, -6.31192088e-01f, 2.74492148e-02f, 4.49172437e-01f, -2.93119729e-01f, 9.15212408e-02f, -5.22708118e-01f, 2.16134205e-01f,
  -3.36770892e-01f, 2.86144316e-01f, -4.43972051e-01f, -3.19593340e-01f, 3.06452662e-01f, -4.50219028e-03f, -9.73394588e-02f, -1.61743417e-01f, -6.41251028e-01f, 7.87039623e-02f,
  -1.14339598e-01f, 4.07690644e-01f, 5.53181767e-01f, 1.31692603e-01f, 2.57116091e-02f, 1.91776514e-01f, 3.90780747e-01f, -1.98782578e-01f, -2.32663713e-02f, 1.92844227e-01f,
  -1.75655854e-03f, 2.71242291e-01f, -3.45824450e-01f, 1.79255307e-01f, -7.62950331e-02f, 3.46399367e-01f, 2.32278898e-01f, 1.74281299e-01f, -3.44599038e-01f, 5.00949204e-01f,
  6.94767356e-01f, 6.50156975e-01f, 3.77792001e-01f, 5.01496255e-01f, -6.65077448e-01f, 4.77056444e-01f, -6.48869634e-01f, 1.06026299e-01f, 3.08587283e-01f, -3.85391921e-01f,
  -4.08817381e-01f, 4.34130341e-01f, -6.21276498e-02f, -6.11084290e-02f, -5.99861264e-01f, -2.24650398e-01f, 9.44010392e-02f, 6.39389455e-02f, -4.08240795e-01f, -4.83016253e-01f,
  -5.27467668e-01f, 2.91936189e-01f, 2.10296169e-01f, -6.44444287e-01f, 5.95717967e-01f, -3.37301828e-02f, -3.93130660e-01f, -1.40912801e-01f, 7.68306628e-02f, 1.28696620e-01f,
  -2.09039956e-01f, 2.97141016e-01f, -1.97154328e-01f, -2.04922467e-01f, -4.75789875e-01f, 4.07389760e-01f, 1.79264992e-01f, -3.41135085e-01f, 2.72912145e-01f, 6.72247231e-01f,
  -1.74786553e-01f, 4.19536144e-01f, -6.73855126e-01f, 8.24244022e-02f, 1.06103709e-02f, -4.58514541e-01f, 5.36673129e-01f, -5.18495068e-02f, -2.66781121e-01f, -6.12086535e-01f,
  6.28824413e-01f, 3.63068730e-01f, 2.85328269e-01f, -1.83164567e-01f, -1.80525020e-01f, 1.70093343e-01f, -2.68865019e-01f, -3.13252002e-01f, 1.54749930e-01f, 4.25046265e-01f,
  1.28637895e-01f, 4.93962467e-01f, 6.00931406e-01f, 2.89469242e-01f, 4.39110458e-01f, 3.09256375e-01f, 2.05583706e-01f, 3.29907596e-01f, -3.17442715e-01f, -4.50718433e-01f,
  2.80777812e-01f, 1.25737414e-01f, -2.26009741e-01f, -3.62834930e-01f, -2.97102213e-01f, 5.52442223e-02f, 1.86648642e-04f, 8.08591068e-01f, 1.48082718e-01f, -8.69963020e-02f,
  -2.07396653e-02f, 5.17929979e-02f, 2.83715725e-01f, -2.51302868e-01f, 7.52526000e-02f, -3.47973764e-01f, 6.69585466e-02f, 3.28942865e-01f, -2.86713600e-01f, 4.79692630e-02f,
  -1.23110086e-01f, -3.84915501e-01f, 1.90392092e-01f, 5.62235117e-01f, 5.98608971e-01f, -6.66447222e-01f, -6.44230664e-01f, -3.48671347e-01f, 2.37741545e-01f, -5.19764841e-01f,
  4.77116466e-01f, -5.74108064e-01f, 2.14877188e-01f, -4.31639940e-01f, -4.59928572e-01f, -4.23149496e-01f, 7.72765934e-01f, 7.24768937e-02f, 3.11007351e-01f, -4.80268240e-01f,
  -5.48352897e-01f, -2.12898329e-02f, -5.60709182e-03f, -2.67186433e-01f, -5.56933820e-01f, 1.05835155e-01f, 2.49949440e-01f, 1.60186529e-01f, -3.89725156e-02f, 4.03915077e-01f,
  -7.08195344e-02f, 3.93550098e-01f, -7.97285438e-02f, -5.29824913e-01f, -3.96137446e-01f, -7.94739008e-01f, -5.23659229e-01f, 3.38344932e-01f, 2.63501316e-01f, 4.06376600e-01f,
  8.59699249e-02f, 3.78382020e-02f, -5.42594194e-01f, 4.19961989e-01f, -4.69402641e-01f, 3.59543949e-01f, -1.37065843e-01f, 6.68565631e-02f, -6.47946179e-01f, -2.65715778e-01f,
  -1.80004120e-01f, 5.80977559e-01f, 2.69584745e-01f, -1.75501421e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -3.28827687e-02f, 2.82923758e-01f, -1.83056816e-01f, 7.39388540e-02f, -1.96692124e-01f, -2.28426885e-02f, -1.57887980e-01f, 2.40229219e-01f, -7.30857849e-02f, -1.45988882e-01f,
  -1.96123928e-01f, -1.55800730e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    