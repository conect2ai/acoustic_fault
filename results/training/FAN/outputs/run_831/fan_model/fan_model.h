/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.20978692e-01f, 1.78945988e-01f, -1.65708810e-01f, 1.53942078e-01f, -4.39012013e-02f, -1.93767413e-01f, -2.13265568e-01f, -8.86361152e-02f, 7.33108353e-03f, 2.53664404e-01f,
  -3.03652976e-02f, 3.79566737e-02f, 5.14520407e-02f, 2.99199708e-02f, -2.42052123e-01f, 1.03528045e-01f, 2.61896014e-01f, -1.10567033e-01f, -3.74405116e-01f, -3.19859713e-01f,
  1.31756008e-01f, 7.81945437e-02f, -1.59723386e-01f, -9.05333161e-02f, 2.35809281e-01f, 9.06787440e-02f, 2.12207079e-01f, 4.52849343e-02f, 5.29589765e-02f, 6.40830100e-01f,
  -8.97365957e-02f, -5.40127493e-02f, -1.15230031e-01f, 1.78117887e-03f, 2.04273127e-02f, -4.97545637e-02f, -6.81438223e-02f, 1.80723667e-02f, -5.99596985e-02f, 4.17146310e-02f,
  5.52592576e-02f, -3.25211994e-02f, 4.66699116e-02f, 5.87236732e-02f, -4.16863188e-02f, 3.42980064e-02f, 4.88736629e-02f, -7.04001933e-02f, -4.35379185e-02f, -1.14745602e-01f,
  1.75687104e-01f, 1.61148328e-02f, -1.89742237e-01f, -3.51527333e-02f, -1.50669530e-01f, -8.73210281e-02f, -1.21837221e-01f, -5.64862192e-02f, -1.27266198e-01f, 2.68398970e-01f,
  -3.89462262e-02f, 1.40959248e-02f, -1.44647108e-02f, -2.76955683e-02f, 2.90837046e-03f, -3.93577339e-03f, 6.65525869e-02f, 8.98660123e-02f, -3.44599485e-02f, 6.67858124e-02f,
  -6.88654259e-02f, -1.28120380e-02f, 2.43299082e-02f, -1.55780949e-02f, 4.79498841e-02f, 4.89314869e-02f, -1.21091530e-02f, 4.87304479e-02f, 5.92093617e-02f, -3.39181721e-02f,
  -1.76382586e-02f, -1.55671630e-02f, 2.03128811e-02f, 6.61914498e-02f, 7.33183995e-02f, 2.06652321e-02f, -2.27547288e-02f, -5.64264394e-02f, -5.01220599e-02f, -4.25308235e-02f,
  1.05312750e-01f, -1.31506905e-01f, 1.72604218e-01f, -2.45403182e-02f, 7.89425448e-02f, 9.37670171e-02f, 5.87585121e-02f, 9.67430603e-03f, 2.97629163e-02f, -7.49386440e-04f,
  -7.02091679e-02f, -4.41515855e-02f, 4.66851145e-03f, -4.03863797e-03f, -2.13329345e-02f, -5.63331763e-04f, 8.90660286e-02f, 3.48946266e-02f, 1.76473744e-02f, 5.17474189e-02f,
  7.92505443e-02f, -2.51183417e-02f, -5.13029546e-02f, 1.41494824e-02f, 7.01732561e-02f, -3.84612344e-02f, 3.51625457e-02f, -9.95193981e-03f, -1.32736281e-01f, 1.36176765e-01f,
  -2.91079376e-02f, 6.95177987e-02f, 8.12632367e-02f, -3.21263038e-02f, -1.74853727e-01f, -3.68852198e-01f, -4.90314126e-01f, -1.20754808e-01f, 5.08284681e-02f, -1.93251166e-02f,
  7.51171634e-02f, 1.60021797e-01f, 1.54690817e-01f, 1.89138129e-01f, -6.96994811e-02f, -2.04117388e-01f, -3.72395590e-02f, 1.86254121e-02f, -9.00415927e-02f, -1.84042796e-01f,
  -1.01915479e-01f, 1.05136566e-01f, 1.79160714e-01f, 3.72019038e-02f, 2.06653520e-01f, -1.20813129e-02f, 1.44116044e-01f, 1.50457010e-01f, -6.18040301e-02f, 1.19271591e-01f,
  2.14169383e-01f, 1.34893626e-01f, -1.36819363e-01f, 6.39267042e-02f, 6.09107874e-02f, 5.41300178e-02f, 2.77689826e-02f, 9.51389596e-02f, 1.26459207e-02f, 3.13197188e-02f,
  6.17134832e-02f, 2.30464414e-02f, -2.31680414e-03f, 3.79899121e-03f, -1.96869322e-03f, -1.84302665e-02f, 9.57692340e-02f, 1.62243992e-02f, 1.54259591e-03f, 1.06345624e-01f,
  -4.99120690e-02f, -1.14427254e-01f, -1.38954967e-01f, -5.49106253e-03f, 4.98289280e-02f, -4.90441583e-02f, -6.29767403e-02f, 5.49003594e-02f, -1.44003453e-02f, 1.66063458e-02f,
  9.25728008e-02f, -2.59628869e-03f, 9.96489171e-03f, -3.89306359e-02f, 4.60746931e-03f, -1.80010218e-02f, -2.82512885e-02f, -2.94652879e-02f, 4.94018644e-02f, 1.29736783e-02f,
  5.87110408e-04f, 3.55661586e-02f, -4.08363454e-02f, 1.77094098e-02f, -1.80605110e-02f, -5.62940836e-02f, -8.89880136e-02f, -4.36883308e-02f, 5.43271638e-02f, -4.25596312e-02f,
  -1.57570839e-02f, -1.28103822e-01f, 3.34534459e-02f, -3.82458344e-02f, 5.19009912e-03f, 4.11895923e-02f, -9.07658323e-05f, 7.47113004e-02f, -2.19894778e-02f, 1.81011837e-02f,
  -1.78498793e-02f, -4.61679734e-02f, 8.59708637e-02f, -1.22565031e-02f, 3.22555099e-03f, 1.34480512e-02f, 6.40569031e-02f, 2.03082599e-02f, 3.27252746e-02f, -8.79073329e-03f,
  5.22742141e-03f, 2.92017795e-02f, 5.62108541e-03f, 2.21173503e-02f, -8.30702335e-02f, -4.66037579e-02f, -4.04800102e-02f, 3.97258885e-02f, -1.00310236e-01f, 5.30725345e-02f,
  1.92462537e-03f, -1.70850173e-01f, -5.67167904e-03f, -6.16514273e-02f, -2.27140058e-02f, -7.91049004e-02f, -6.78688511e-02f, -7.07123280e-02f, -1.51754364e-01f, -5.16045019e-02f,
  1.03527442e-01f, -2.12550715e-01f, -4.56608772e-01f, 2.95466095e-01f, -4.92463224e-02f, -2.77670413e-01f, -1.73148215e-01f, 3.63174155e-02f, 2.45935351e-01f, -8.99165720e-02f,
  -6.06402792e-02f, 1.44355282e-01f, 7.25236014e-02f, 5.05619161e-02f, -9.88896098e-03f, -1.29865155e-01f, -1.31301165e-01f, -1.40855610e-01f, 6.17850348e-02f, 6.71904162e-02f,
  2.32190803e-01f, 7.47744516e-02f, 1.00281358e-01f, 9.54718702e-03f, 1.18103594e-01f, 2.12983012e-01f, -1.11500673e-01f, -1.12346694e-01f, -1.37645394e-01f, -4.04029191e-02f,
  -2.50445724e-01f, -1.32998005e-01f, 1.46765307e-01f, 7.31211230e-02f, -6.21510372e-02f, 3.16707343e-02f, 2.62186453e-02f, 1.16850540e-01f, 5.05576879e-02f, -9.55743715e-04f,
  -9.67979524e-03f, 3.99933718e-02f, 7.13518709e-02f, -1.80599261e-02f, -3.65955271e-02f, -3.08541972e-02f, -3.56163606e-02f, -1.06639177e-01f, -1.62852125e-03f, -3.89518142e-02f,
  -3.36646065e-02f, -1.49578437e-01f, -1.39065832e-01f, -1.25501826e-01f, -1.12549268e-01f, -1.19888701e-01f, -1.63356215e-01f, -3.89796756e-02f, -1.91114724e-01f, 1.76922545e-01f,
  1.11121863e-01f, -4.84049357e-02f, -1.11977709e-02f, 6.09066933e-02f, 1.63597800e-02f, 3.80168743e-02f, 3.62736918e-03f, -4.77073863e-02f, -1.52265066e-02f, 1.65322721e-02f,
  -9.15114135e-02f, -7.46223480e-02f, -2.09485255e-02f, -1.08334720e-02f, 3.20436321e-02f, -5.75714596e-02f, -1.99990161e-02f, 6.38623089e-02f, -6.07021898e-03f, 2.63287779e-02f,
  -3.29166814e-03f, -5.54549322e-02f, 1.22710085e-02f, -6.45009950e-02f, -7.53849149e-02f, 1.39588281e-03f, 4.38541509e-02f, -1.52897174e-02f, 1.05138533e-01f, -2.88742352e-02f,
  3.01510155e-01f, -1.86194405e-01f, 1.92411676e-01f, 4.82620597e-02f, 1.15889795e-02f, 8.00862759e-02f, -7.57972244e-03f, -2.70377891e-03f, 6.42190268e-03f, 3.47121023e-02f,
  -1.50262881e-02f, 5.37463315e-02f, -9.09075886e-02f, -4.39643636e-02f, 5.61089888e-02f, 3.83694433e-02f, 7.30637163e-02f, 8.94917473e-02f, -1.25442557e-02f, 2.51798891e-02f,
  -7.69534800e-03f, 8.84968638e-02f, 1.50418088e-01f, 1.75013077e-02f, 1.77541703e-01f, 1.35850511e-03f, -6.99634664e-03f, 2.44921912e-02f, -5.25676319e-03f, 1.85234293e-01f,
  1.30771413e-01f, 3.12163553e-04f, -2.38837227e-01f, -3.23178875e-03f, -1.66118532e-01f, -6.28768802e-02f, -2.13059969e-02f, 1.64720356e-01f, 1.44634694e-01f, 2.16314141e-02f,
  3.83751616e-02f, -8.00135359e-02f, -6.31904155e-02f, -1.27991652e-02f, 2.59863213e-03f, -3.22557874e-02f, -2.21073851e-01f, -1.59487560e-01f, -2.02065974e-01f, -8.95920917e-02f,
  -1.46010205e-01f, -1.00652240e-01f, -1.30988911e-01f, -9.59732533e-02f, -1.37836859e-01f, -2.47154552e-02f, -1.01643309e-01f, -3.40131633e-02f, -1.33322626e-01f, -3.71382535e-01f,
  -4.90313694e-02f, 4.01891097e-02f, -5.57618178e-02f, -3.31909489e-03f, 1.14783548e-01f, 3.72354081e-03f, 7.27414619e-03f, 5.78208044e-02f, 4.95375507e-02f, 4.10449319e-02f,
  -2.15594936e-02f, -1.32867359e-02f, -1.92460825e-03f, -1.11205958e-01f, -1.60007067e-02f, -4.37417626e-02f, 9.24815238e-02f, 3.36208269e-02f, -7.16778785e-02f, 9.48257670e-02f,
  2.66129412e-02f, -1.06118582e-01f, 3.38460356e-02f, 8.59141424e-02f, -1.61865577e-02f, -1.31769598e-01f, 3.25803012e-02f, -1.06918424e-01f, 3.48747112e-02f, 4.19416502e-02f,
  2.67838780e-02f, -5.90882376e-02f, -8.00951645e-02f, -4.00564149e-02f, -5.92126064e-02f, 1.80622172e-02f, -3.58904861e-02f, -1.67420004e-02f, -8.11598264e-03f, 4.88859043e-02f,
  9.69889909e-02f, 3.64037976e-02f, -5.45161404e-02f, 1.49332024e-02f, -3.70559134e-02f, 1.36202499e-02f, 1.75626222e-02f, -7.48754889e-02f, -1.91947147e-02f, -4.88514677e-02f,
  -5.66230491e-02f, -1.85901523e-02f, 6.37037680e-02f, 5.97261041e-02f, -9.41614807e-02f, 5.85876256e-02f, 7.98881461e-04f, -1.02613904e-01f, -4.60422561e-02f, -6.75323084e-02f,
  2.55656630e-01f, -1.94787397e-03f, 4.19519562e-03f, 6.10464551e-02f, -1.36673190e-02f, 6.34631217e-02f, 3.46740298e-02f, -8.29162598e-02f, -2.58147772e-02f, 4.03426625e-02f,
  5.09387553e-02f, 9.14372131e-02f, 2.25181598e-02f, 4.63541178e-03f, 4.66144783e-03f, 1.64171644e-02f, 1.15165040e-01f, -7.59676769e-02f, -7.12027028e-02f, -1.51468245e-02f,
  4.73863259e-02f, 1.13271937e-01f, 8.40805694e-02f, 1.85614273e-01f, 3.84246409e-02f, 8.65382180e-02f, 1.56196848e-01f, 5.22530228e-02f, 1.14865467e-01f, 2.97991931e-01f,
  -3.40621583e-02f, 4.76720445e-02f, -2.80199289e-01f, 1.74903218e-02f, -1.15915695e-02f, -4.72883545e-02f, 1.05544468e-02f, 2.10774511e-01f, 1.19415388e-01f, 8.83224905e-02f,
  8.45740810e-02f, 5.64276846e-03f, 2.84894016e-02f, 3.52263413e-02f, 1.50516778e-02f, -3.31368595e-02f, -1.68618917e-01f, -2.59701341e-01f, -8.94159600e-02f, 3.13549936e-02f,
  1.74591601e-01f, 1.13503039e-01f, -4.27627861e-02f, -2.64037363e-02f, -1.60584468e-02f, -7.41146924e-03f, -1.10186376e-01f, -1.36434346e-01f, -8.48058239e-02f, -2.50555992e-01f,
  -2.40759268e-01f, 1.95126384e-02f, 5.02482653e-05f, 9.91811827e-02f, -2.80938633e-02f, 4.50577736e-02f, 8.57073441e-02f, -7.74068981e-02f, -1.12426223e-03f, -4.40542251e-02f,
  -4.85354550e-02f, 1.71295907e-02f, -5.45173809e-02f, -2.01720186e-02f, 1.84634645e-02f, -3.88840474e-02f, 2.74156667e-02f, -5.37281856e-02f, -2.84578204e-02f, -6.21873215e-02f,
  1.06142955e-02f, -1.36184439e-01f, -2.11154550e-01f, 3.47069390e-02f, -1.10564187e-01f, -7.07864687e-02f, -1.10962922e-02f, -2.04688236e-02f, -8.67222846e-02f, -1.52856810e-02f,
  3.74425240e-02f, -6.51216283e-02f, -9.66565404e-03f, 1.28856692e-02f, 3.93729843e-02f, -7.82515407e-02f, 4.77095228e-03f, 4.22538854e-02f, 4.31167707e-02f, 7.00661214e-04f,
  3.10596377e-02f, 4.34999689e-02f, 4.86473925e-02f, 2.87272967e-02f, 1.59789473e-02f, 2.13639308e-02f, -4.99773137e-02f, 4.55120802e-02f, -8.58568326e-02f, -4.51703407e-02f,
  -5.26069961e-02f, -1.01475932e-01f, -1.92123372e-02f, 9.56422358e-04f, -6.20055385e-02f, -9.24919844e-02f, 2.60403529e-02f, 1.82514600e-02f, 7.26760626e-02f, 4.40821983e-02f,
  2.80132204e-01f, -1.56923551e-02f, 7.34291412e-03f, -8.06628689e-02f, 3.06266802e-03f, -6.19338565e-02f, 3.79412025e-02f, -3.27750593e-02f, -1.11326471e-01f, 2.66154241e-02f,
  -4.35915217e-02f, -2.12937891e-02f, 2.35028751e-02f, 5.60977720e-02f, 2.28159986e-02f, 2.96081305e-02f, 3.28853689e-02f, -1.05982818e-01f, -5.86222596e-02f, -8.34053233e-02f,
  2.94285715e-02f, -2.11679507e-02f, -7.42799044e-02f, 2.35429946e-02f, -2.27568150e-02f, -9.65445340e-02f, 1.81888752e-02f, -6.32545054e-02f, 4.33638692e-03f, 1.73379734e-01f,
  9.55209658e-02f, 3.35099518e-01f, 1.45318374e-01f, 7.43339509e-02f, -1.17393658e-01f, 5.93328215e-02f, 3.32667619e-01f, 8.97068754e-02f, -1.03317559e-01f, 2.58466750e-01f,
  -2.92351633e-01f, -4.29126889e-01f, -2.50396788e-01f, -2.14135796e-01f, 1.37037337e-02f, 3.49197388e-01f, 2.61726588e-01f, -1.10396788e-01f, -3.50764453e-01f, -2.63830692e-01f,
  -4.45340239e-02f, -1.21090643e-01f, -6.63063228e-02f, -4.55706641e-02f, 1.54891193e-01f, -1.65603906e-01f, 1.88803583e-01f, 5.03572170e-03f, 4.07968722e-02f, 4.62164253e-01f,
  2.79695690e-02f, 1.78147957e-01f, -1.07736856e-01f, -8.20440352e-02f, -5.28681688e-02f, 6.59981743e-02f, -1.02517474e-02f, 8.33333582e-02f, 9.24333856e-02f, 7.96367452e-02f,
  -2.14302521e-02f, -3.27544063e-02f, -8.54779184e-02f, -5.48856594e-02f, 5.31267188e-02f, 2.98428126e-02f, 7.52086714e-02f, 8.05144385e-02f, 8.23085606e-02f, 9.26822498e-02f,
  -2.10135384e-03f, -6.35930970e-02f, 6.53205886e-02f, 3.74338999e-02f, -8.52195453e-03f, -9.91574600e-02f, 1.07189305e-01f, 1.60266429e-01f, 2.28875093e-02f, 3.58001947e-01f,
  5.52495010e-03f, -4.71075550e-02f, -1.67631097e-02f, 5.43363653e-02f, 8.84987786e-03f, -3.68148834e-02f, 1.45778880e-02f, -2.84113940e-02f, -6.68057874e-02f, 7.03385100e-02f,
  -3.69974971e-02f, 1.70322973e-02f, 1.82429962e-02f, 4.19393294e-02f, -5.00864759e-02f, 7.33731538e-02f, 6.01067431e-02f, 4.21202779e-02f, -6.44641146e-02f, 5.39020263e-02f,
  -2.63712090e-02f, -5.55053614e-02f, -7.36042261e-02f, 5.00588445e-03f, 2.40636095e-02f, 3.04437485e-02f, 3.62244993e-02f, -3.41498740e-02f, 2.99563408e-02f, 3.59306000e-02f,
  -4.68141213e-02f, -1.76557675e-01f, 6.80121407e-02f, 2.06999816e-02f, 1.43775996e-02f, -9.75948870e-02f, 5.89753361e-03f, 2.71758195e-02f, -7.50302672e-02f, 3.26118544e-02f,
  -8.97872224e-02f, -5.73485568e-02f, -3.86591926e-02f, 1.93772803e-03f, -1.00447990e-01f, -3.25870141e-02f, 2.57618297e-02f, -1.12756364e-01f, 7.27115013e-03f, -1.42002981e-02f,
  1.18675623e-02f, 1.49516478e-01f, -1.60609055e-02f, 9.78571251e-02f, 1.63696762e-02f, -9.26282182e-02f, -1.30009027e-02f, 7.21216723e-02f, 8.16794485e-03f, 3.74115169e-01f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.80783598e-02f, 7.27781728e-02f, 1.20964415e-01f, 5.78861162e-02f, -6.09621368e-02f, -1.30841002e-01f, -7.01618521e-03f, 1.32816229e-02f, -9.67214406e-02f, 3.92227657e-02f,
  -6.71433136e-02f, -7.54089057e-02f, -8.19280818e-02f, 1.23439403e-02f, 8.30546618e-02f, 1.26323014e-01f, 8.69594440e-02f, 1.80010766e-01f, 6.54291064e-02f, 1.15622178e-01f,
  -3.05355750e-02f, 7.82366022e-02f, 1.78015187e-01f, 5.34994453e-02f, 1.57373026e-01f, 1.00377470e-01f, -1.25638936e-02f, 1.30664289e-01f, 1.14020616e-01f, 1.54815525e-01f,
  1.41320363e-01f, -5.68118542e-02f, 3.58192809e-02f, 4.21036594e-02f, -8.06159675e-02f, 3.42677981e-02f, 5.86743578e-02f, 2.67692469e-02f, 7.38641853e-03f, -4.15845588e-02f,
  6.77368194e-02f, 6.51765764e-02f, 4.83251102e-02f, 7.08136484e-02f, -5.44371344e-02f, 8.12937766e-02f, 9.09146145e-02f, -1.69749442e-03f, -5.28085977e-02f, -2.46233344e-02f,
  1.29889892e-02f, 1.76674910e-02f, -1.39829312e-02f, -5.67483604e-02f, -3.55136693e-02f, 3.37597243e-02f, 9.04274434e-02f, -2.46811155e-02f, 4.97427629e-03f, -5.95637504e-03f,
  -8.47322792e-02f, 8.52774363e-03f, -6.91178441e-02f, 5.98359033e-02f, -5.80690568e-03f, -5.02029769e-02f, 2.38998737e-02f, -2.72459798e-02f, -1.67232044e-02f, -1.32971080e-02f,
  -6.88943192e-02f, 1.02280369e-02f, 6.92159608e-02f, 2.11817268e-02f, 5.29500432e-02f, 7.43999705e-03f, 3.95698324e-02f, 7.11157992e-02f, -7.99134970e-02f, -2.64378404e-03f,
  4.07036617e-02f, -1.36169521e-02f, -3.96593893e-03f, 2.21161470e-02f, -2.34789364e-02f, -2.57234797e-02f, 9.41039342e-03f, 7.79788047e-02f, -4.12476063e-02f, -1.32746678e-02f,
  -1.68769807e-02f, -1.17233591e-02f, -5.84263448e-03f, 1.56989917e-02f, 5.16852140e-02f, 2.76204776e-02f, 3.22407037e-02f, 7.35317469e-02f, 1.95851251e-02f, 4.75842468e-02f,
  8.62638373e-03f, 1.35524273e-01f, -2.47206930e-02f, -3.59431282e-02f, 3.32526304e-02f, 7.56103843e-02f, -2.85515133e-02f, 3.19696963e-02f, 4.03660461e-02f, 4.67681140e-02f,
  2.84163989e-02f, -3.30630019e-02f, 2.88292803e-02f, 4.07354236e-02f, 4.37241197e-02f, -5.18818833e-02f, 1.62212297e-01f, 8.86892900e-02f, 4.40983847e-02f, 1.36524394e-01f,
  -2.89862543e-01f, -3.63402292e-02f, 1.43925056e-01f, -1.61938503e-01f, -1.11704029e-01f, -6.07505701e-02f, 3.23397703e-02f, -7.74393007e-02f, -1.31669790e-01f, 2.54275538e-02f,
  6.39382377e-02f, 5.10140099e-02f, 1.04712822e-01f, 1.03169434e-01f, 1.38048818e-02f, 7.22018331e-02f, -7.76773393e-02f, -5.94191961e-02f, -5.52438870e-02f, -4.08632196e-02f,
  -5.81552228e-03f, -1.20623289e-02f, -1.54182568e-01f, -1.48965865e-01f, -6.20462038e-02f, -3.67794372e-02f, -6.01499192e-02f, -1.41381137e-02f, -2.33724993e-02f, -9.88947302e-02f,
  4.75915700e-01f, -2.22760186e-01f, -5.43199666e-02f, -2.49603406e-01f, 6.93909004e-02f, 2.62203161e-02f, 1.21924710e-02f, 2.54917834e-02f, -1.08886369e-01f, -2.90853847e-02f,
  1.66425630e-02f, -8.16819668e-02f, 9.40508842e-02f, 8.54623853e-04f, 3.01542506e-02f, -3.58164497e-02f, -1.06958158e-01f, -8.49408433e-02f, -4.03793110e-03f, 2.32739728e-02f,
  8.09168443e-03f, -1.21098906e-01f, 6.82545230e-02f, 2.44408031e-03f, -8.11392814e-02f, -1.62370026e-01f, 9.72234756e-02f, -9.75889266e-02f, -1.00039676e-01f, 2.68739201e-02f,
  7.14286342e-02f, 5.74665368e-02f, 1.94030218e-02f, 2.20389441e-02f, 7.59933442e-02f, -3.43503393e-02f, -1.89389102e-02f, 6.89887181e-02f, 3.66103910e-02f, 3.05038149e-04f,
  -4.81196940e-02f, -3.96680124e-02f, 6.74593076e-02f, -2.68827192e-02f, 6.07529767e-02f, -5.56344613e-02f, -3.29966918e-02f, 3.00640445e-02f, 1.36442650e-02f, -7.52340704e-02f,
  -2.83608809e-02f, -5.08244075e-02f, -6.21943697e-02f, -1.39540490e-02f, -8.81955475e-02f, -1.03287265e-01f, 6.55015856e-02f, -1.46632316e-03f, -1.62149388e-02f, -5.17055877e-02f,
  2.99245685e-01f, -2.15097651e-01f, 1.26909941e-01f, -3.72024439e-02f, 3.97584997e-02f, -1.31919459e-01f, -2.34544352e-02f, -1.36771768e-01f, -1.01256394e-03f, -1.03021826e-04f,
  -6.39590770e-02f, -3.48186307e-02f, 6.84632212e-02f, -5.79280173e-03f, 6.19703196e-02f, -4.22670394e-02f, -1.30971029e-01f, 2.37519965e-02f, -2.19941009e-02f, 2.32668445e-02f,
  -1.33696105e-03f, 1.31389999e-03f, 1.29694715e-01f, 4.74948548e-02f, -4.63107741e-03f, 5.28846271e-02f, 1.74942285e-01f, 1.76737741e-01f, 8.97745937e-02f, 2.58946687e-01f,
  -5.05842030e-01f, 1.03756443e-01f, -1.42893866e-01f, 6.20193370e-02f, 2.13857338e-01f, 8.38162452e-02f, 2.60451049e-01f, 4.72917669e-02f, 9.85127222e-03f, 5.03561795e-02f,
  4.74032685e-02f, -1.79717299e-02f, -7.01747909e-02f, 2.05750167e-02f, 3.68214212e-02f, 1.97560281e-01f, 1.45085946e-01f, -4.52685542e-02f, -1.92428470e-01f, -1.16951816e-01f,
  3.11035439e-02f, -9.93704051e-02f, -2.83808112e-01f, 1.56502035e-02f, 1.07129939e-01f, -2.93962639e-02f, -6.17712624e-02f, 6.48072138e-02f, 2.14907117e-02f, 1.17486812e-01f,
  -2.54342537e-02f, -1.03290059e-01f, 4.16439176e-02f, -9.89908818e-03f, -4.63097058e-02f, -8.30822214e-02f, -5.42296804e-02f, -1.08223297e-01f, 6.78140623e-03f, 2.83252466e-02f,
  5.86604364e-02f, 1.96143109e-02f, 5.27154747e-03f, -5.62299751e-02f, -9.44006220e-02f, -6.72396570e-02f, -7.84290880e-02f, -1.42988354e-01f, -1.32787332e-01f, 4.87799197e-03f,
  1.85813367e-01f, 7.24175945e-02f, -9.86727849e-02f, 9.20504052e-03f, 4.80429083e-02f, -9.41987336e-02f, -1.18191540e-01f, -1.18030131e-01f, -1.17795736e-01f, -9.08411667e-02f,
  1.43171335e-03f, -3.50125246e-02f, 5.85637428e-02f, 7.49078626e-03f, 6.55880496e-02f, 3.41503136e-02f, 8.10523517e-03f, 1.67422760e-02f, -4.00598869e-02f, -6.37643710e-02f,
  -4.97849360e-02f, -3.40750031e-02f, -5.21668941e-02f, -1.00641929e-01f, 4.85678427e-02f, -6.39488026e-02f, 6.00739382e-02f, -1.86081734e-02f, -2.30642408e-02f, -3.19371037e-02f,
  -1.16617031e-01f, -3.55306431e-03f, -1.17682759e-02f, -3.74175422e-02f, -3.01750507e-02f, 1.67389195e-02f, 4.65260744e-02f, -1.53509965e-02f, -7.60454014e-02f, -8.04410223e-03f,
  -1.29678205e-01f, -6.36597797e-02f, -1.26366064e-01f, -3.21514085e-02f, 1.01435333e-02f, -2.84135491e-02f, 5.21706603e-02f, -3.72635163e-02f, 5.82300387e-02f, -4.95493598e-02f,
  -5.50691076e-02f, 2.13173907e-02f, 1.91571228e-02f, 3.59909087e-02f, -2.94280965e-02f, -3.55220065e-02f, 1.06450833e-01f, 1.62655637e-02f, -5.91046587e-02f, -5.24667241e-02f,
  -4.63472456e-02f, -5.72587140e-02f, -5.15399165e-02f, 3.63218336e-04f, 1.91700757e-02f, -7.02146143e-02f, -5.92873693e-02f, -1.47816792e-01f, -1.86703384e-01f, -8.35054144e-02f,
  -2.59663582e-01f, 8.99212807e-02f, -3.13914329e-01f, 2.47633606e-01f, 1.69477403e-01f, -1.14634283e-01f, -2.04611361e-01f, -1.74441233e-01f, 7.51009136e-02f, 2.00566784e-01f,
  7.98937455e-02f, 2.89752126e-01f, 5.50536737e-02f, -1.43704396e-02f, -1.83364764e-01f, 3.77824716e-02f, 1.32375896e-01f, 4.59402464e-02f, -1.40514657e-01f, -7.26515353e-02f,
  2.81800061e-01f, 1.61266953e-01f, -2.71387473e-02f, -9.25574824e-02f, 2.61193186e-01f, 1.59120277e-01f, -4.11529932e-03f, 3.76749374e-02f, 2.04323176e-02f, 4.72519010e-01f,
  1.22446910e-01f, -2.52629519e-01f, -1.47438226e-02f, 1.97320074e-01f, -3.05109359e-02f, -6.71987459e-02f, -4.04426008e-02f, -1.46894781e-02f, -6.56973645e-02f, -8.72417465e-02f,
  1.62498225e-02f, -3.03338952e-02f, 9.14221108e-02f, 8.73955637e-02f, -6.55413494e-02f, -1.12284146e-01f, -1.62777767e-01f, -1.51184246e-01f, -4.50534970e-02f, -1.99817326e-02f,
  2.22947344e-01f, 1.67163238e-02f, -1.91153288e-01f, -2.47137323e-01f, -5.83865121e-02f, 3.31037976e-02f, -6.88110963e-02f, -1.17565379e-01f, -2.32100993e-01f, -1.05328642e-01f,
  9.58230533e-03f, -2.18888819e-02f, -1.66489370e-03f, -1.17092207e-03f, 2.98598427e-02f, 2.98023503e-02f, 9.41198543e-02f, 2.85681263e-02f, 4.54210117e-02f, -6.86014816e-02f,
  3.78740653e-02f, -4.69047911e-02f, 2.43719537e-02f, -1.16824552e-01f, 3.87461744e-02f, -2.90954635e-02f, -1.17674349e-02f, 2.12561898e-02f, -1.34069324e-01f, 1.54101644e-02f,
  6.05645664e-02f, -4.77583483e-02f, -2.18901155e-03f, -2.46437208e-04f, -1.10657327e-02f, -7.61826336e-02f, 6.01284839e-02f, -1.61704756e-02f, -3.83571312e-02f, -3.52271437e-03f,
  2.29547843e-02f, -1.56784371e-01f, 7.27771670e-02f, -2.32969224e-03f, 4.62237336e-02f, -5.02443612e-02f, 4.00287770e-02f, -5.17981350e-02f, 1.08484505e-02f, -2.07411367e-02f,
  -2.86086891e-02f, -9.26722214e-02f, -4.28925380e-02f, -3.18119228e-02f, -1.07800320e-01f, -6.36917306e-03f, 6.44778907e-02f, -7.57014602e-02f, -1.54082933e-02f, -8.46693665e-02f,
  3.73216420e-02f, -4.86393720e-02f, -2.21662447e-01f, -7.23122805e-02f, -7.26444051e-02f, 6.47115409e-02f, -1.65465042e-01f, -1.64913520e-01f, -2.48214781e-01f, -1.41300246e-01f,
  -1.03431560e-01f, -1.03612855e-01f, -4.41461056e-01f, -2.67706305e-01f, -2.60268420e-01f, -1.70130238e-01f, -3.18929777e-02f, 3.78094986e-03f, -7.81134069e-02f, -2.34169036e-01f,
  -1.11714214e-01f, -6.20875694e-02f, -1.35835439e-01f, 8.49303138e-03f, -3.24038294e-04f, -6.97701350e-02f, -2.03631490e-01f, -9.61342305e-02f, -2.56890934e-02f, 1.11667246e-01f,
  -5.39373383e-02f, -1.98092192e-01f, -7.93158561e-02f, -5.34796044e-02f, -6.72248825e-02f, -1.74315780e-01f, -2.62854695e-01f, -7.29652047e-02f, -2.60138046e-02f, -1.53846681e-01f,
  -4.04944599e-01f, -4.72391658e-02f, -2.02624388e-02f, 1.00862339e-01f, -8.48662630e-02f, -5.38300723e-02f, -5.17477952e-02f, 1.76012535e-02f, 5.74453585e-02f, -1.03507236e-01f,
  -9.38005224e-02f, 4.60188389e-02f, -4.02259938e-02f, -1.03363462e-01f, -9.44900140e-02f, 2.78445873e-02f, 1.47477174e-02f, -3.61175160e-03f, -9.88331810e-02f, 4.29999903e-02f,
  -1.93082523e-02f, -6.04061373e-02f, 2.67340299e-02f, 6.42694011e-02f, 2.30138898e-02f, 2.04205513e-02f, 3.46064679e-02f, 6.17323481e-02f, 2.55826470e-02f, 3.02314069e-02f,
  -2.81473659e-02f, -5.15403859e-02f, 4.74585639e-03f, -7.78193586e-03f, 6.57826290e-02f, -3.91580164e-02f, -5.90223931e-02f, -3.07817664e-02f, 1.14856966e-01f, -6.37711063e-02f,
  -1.67872403e-02f, -2.38335244e-02f, -4.14255671e-02f, -2.04980690e-02f, 1.49829583e-02f, -8.56040940e-02f, 1.91596635e-02f, 1.07498363e-01f, 4.27649952e-02f, 6.47169352e-02f,
  5.89507595e-02f, -1.11691933e-02f, -1.05740964e-01f, 1.04524285e-01f, 1.06067464e-01f, 2.12279186e-02f, 1.15262065e-02f, 1.15148425e-01f, -1.67747668e-03f, 8.73712748e-02f,
  -6.05160855e-02f, 4.93599139e-02f, -9.35923979e-02f, 1.25159249e-01f, -5.03502674e-02f, -7.18093589e-02f, -1.12639390e-01f, 8.15042779e-02f, -9.98302028e-02f, 2.71277339e-03f,
  -2.62001175e-02f, 2.64000706e-02f, -5.70408069e-02f, 1.53773502e-02f, -8.86022225e-02f, 8.64077955e-02f, 4.93130945e-02f, -1.50546851e-02f, 1.32464007e-01f, 1.06439434e-01f,
  1.34935588e-01f, 6.76815733e-02f, 6.54794797e-02f, 9.14134681e-02f, 1.06412672e-01f, 4.02779058e-02f, -4.28337604e-02f, -1.53242303e-02f, 4.21499796e-02f, 7.57819489e-02f,
  -3.53132904e-01f, -2.29968175e-01f, 7.63081536e-02f, -1.05861202e-02f, -4.02066298e-02f, -3.52586396e-02f, -1.67007372e-01f, -3.63400541e-02f, -2.40816977e-02f, -6.99358732e-02f,
  -6.24042936e-04f, -2.33016093e-03f, -9.97161120e-02f, -5.43595813e-02f, -1.21844433e-01f, -2.23182887e-01f, -9.67122167e-02f, -1.18172564e-01f, 5.60735725e-02f, -1.19061880e-01f,
  -1.49269961e-02f, -1.36851311e-01f, -1.40110031e-01f, -5.82533292e-02f, 8.44775289e-02f, 1.26901316e-03f, 5.99180572e-02f, -3.05758361e-02f, -8.26441795e-02f, -5.30872457e-02f,
  2.00477317e-02f, 1.54388621e-01f, 7.55858421e-02f, 2.61331983e-02f, 1.07532971e-01f, -7.31815100e-02f, -1.69696566e-02f, 9.54083279e-02f, 6.68583810e-02f, 3.48498933e-02f,
  -5.58574200e-02f, -7.03344643e-02f, -4.37685251e-02f, 6.47093309e-03f, 1.19117592e-02f, -2.85066795e-02f, -1.00792125e-01f, 2.34028995e-02f, 3.77914868e-02f, -9.62104350e-02f,
  -9.73047689e-03f, -9.04754773e-02f, -1.15038268e-01f, -5.89576624e-02f, 5.84963001e-02f, 7.02433363e-02f, 6.52857050e-02f, 4.82440519e-04f, -3.41043645e-03f, -3.53414901e-02f,
  -2.20777076e-02f, 5.15522137e-02f, 8.67888797e-03f, -1.97803192e-02f, 2.44417861e-02f, 7.22216035e-04f, 2.02386361e-02f, -6.17640419e-03f, -2.29431912e-02f, -9.11938772e-02f,
  5.29437102e-02f, 5.58451191e-02f, -7.22303614e-02f, -1.99400075e-03f, -3.98683064e-02f, 9.46821570e-02f, -5.29325269e-02f, -4.63117212e-02f, 4.41415422e-02f, -1.85197797e-02f,
  -5.72685944e-03f, -7.20523414e-04f, -3.10577154e-02f, 6.04458200e-03f, -4.79790121e-02f, 7.94681981e-02f, 5.39083295e-02f, -3.46116861e-03f, 5.71620017e-02f, -4.20325547e-02f,
  -1.91853698e-02f, 9.53963324e-02f, 1.31598311e-02f, -1.48945212e-01f, -1.12447264e-02f, -5.11585549e-02f, -1.27336467e-02f, 8.82194340e-02f, 1.81003269e-02f, -3.73341478e-02f,
  -5.11319898e-02f, -9.24862996e-02f, -6.41192868e-02f, -1.34567795e-02f, -1.16507053e-01f, -1.00182451e-01f, -1.49467975e-01f, -1.21526569e-02f, -2.78104804e-02f, -4.22910154e-02f,
  -1.38997450e-01f, -2.64420211e-01f, -1.38022289e-01f, -7.13431016e-02f, -1.14145741e-01f, -7.07671717e-02f, -2.14805547e-02f, 2.65390333e-03f, -1.73241660e-01f, -3.35635185e-01f,
  -5.83794892e-01f, 1.45412430e-01f, 1.14260316e-01f, -2.13263035e-01f, 6.61119595e-02f, 2.69250661e-01f, 2.51037568e-01f, 1.21357135e-01f, -1.27209514e-01f, 1.35366498e-02f,
  5.20332232e-02f, -1.85156658e-01f, -6.89222738e-02f, 1.68144666e-02f, 6.14144728e-02f, 1.87768742e-01f, 2.41772756e-01f, -8.32346529e-02f, -1.79254547e-01f, -1.36108408e-02f,
  2.65611038e-02f, -8.39274600e-02f, -2.50404656e-01f, -1.22895099e-01f, -7.64735118e-02f, -1.03665702e-01f, 2.87543889e-02f, 1.75683741e-02f, 7.58311003e-02f, 1.08279921e-01f,
  1.85994580e-02f, -2.85668429e-02f, -9.45495218e-02f, -6.87257275e-02f, -6.33111000e-02f, 4.86966483e-02f, -4.53952067e-02f, 2.72738803e-02f, -4.68272008e-02f, -1.79737266e-02f,
  3.46346758e-02f, -5.67162335e-02f, 8.03001672e-02f, 4.05692076e-03f, -2.49507334e-02f, -1.42514054e-02f, -1.13552801e-01f, -5.91002032e-02f, -8.55231658e-02f, -3.50880735e-02f,
  7.56675079e-02f, -1.26577437e-01f, 4.54362994e-03f, -6.91437200e-02f, -9.21668410e-02f, -1.26633346e-01f, -1.21125318e-02f, -1.30388364e-01f, 4.83215004e-02f, -1.41027302e-01f,
  1.05305113e-01f, 2.23219581e-02f, -1.54391695e-02f, -2.10382510e-03f, 5.74347912e-04f, 7.08281063e-03f, 2.64927465e-02f, 5.30364970e-03f, -4.72197914e-03f, -2.56754421e-02f,
  2.75321882e-02f, -3.49707417e-02f, -3.39338779e-02f, 8.94047134e-03f, -2.05052979e-02f, 7.27478936e-02f, -1.19293211e-02f, 6.59814402e-02f, 4.78701340e-03f, -9.67620090e-02f,
  -4.00275700e-02f, 5.09344647e-03f, -6.91539422e-02f, -4.28844504e-02f, 4.89076041e-02f, 4.38907221e-02f, -6.78690672e-02f, -2.61681154e-02f, -1.05939895e-01f, 2.27014977e-03f,
  -2.05215156e-01f, 1.45352826e-01f, -2.51237825e-02f, -1.52341485e-01f, 4.16914970e-02f, -7.10107535e-02f, 5.47710946e-03f, -6.83000460e-02f, -4.33831029e-02f, 1.99300200e-02f,
  7.44296536e-02f, -8.23345035e-02f, 2.96906289e-02f, 2.14020591e-02f, -4.41483445e-02f, -1.81361977e-02f, 5.93130887e-02f, 4.34619421e-03f, -8.03758129e-02f, -8.29397514e-02f,
  4.74307686e-02f, -4.20705900e-02f, -1.72165900e-01f, -2.27519218e-02f, -7.20451698e-02f, -2.08780289e-01f, -2.53048819e-02f, -1.37326598e-01f, -5.61941303e-02f, -1.33166149e-01f,
  4.58938330e-01f, 1.79381281e-01f, 1.28309980e-01f, 7.26954415e-02f, -1.54943123e-01f, -8.38671029e-02f, 6.86442256e-02f, 7.45434836e-02f, 2.61944402e-02f, 1.64194942e-01f,
  -1.30857127e-02f, -2.58025043e-02f, 8.22697207e-03f, 5.47819436e-02f, 1.46763131e-01f, 2.64554799e-01f, 1.18182875e-01f, 2.42752865e-01f, 2.04868361e-01f, 1.50805950e-01f,
  2.25212425e-02f, 1.74778566e-01f, 2.23124340e-01f, 1.32719815e-01f, 8.72630551e-02f, 4.33905832e-02f, -5.09166755e-02f, 8.66032317e-02f, 6.47542179e-02f, 2.37826139e-01f,
  -1.61573943e-02f, 1.98071226e-01f, -1.89417060e-02f, -7.61440210e-03f, -1.42587885e-01f, 1.61926463e-01f, 1.04485219e-03f, 9.67310816e-02f, -5.76145463e-02f, 1.09554738e-01f,
  -9.93116274e-02f, 3.33929621e-02f, -4.90846038e-02f, -5.44198379e-02f, -4.36663069e-02f, 4.58642729e-02f, 1.59741893e-01f, 1.36091799e-01f, 1.15306556e-01f, 7.87837207e-02f,
  -1.32173106e-01f, -1.08118720e-01f, 9.93472245e-03f, 5.34843653e-02f, 1.26089409e-01f, -8.74183625e-02f, -8.62116814e-02f, 4.31594551e-02f, 8.82564485e-02f, 1.48358852e-01f,
  -1.00181077e-03f, 2.00538374e-02f, -6.80470988e-02f, 6.98265731e-02f, -2.90273372e-02f, 1.74032953e-02f, 2.37035621e-02f, -2.81205587e-02f, -4.51480448e-02f, -4.54997271e-02f,
  3.99974883e-02f, -7.66756525e-03f, -2.76841410e-02f, -2.66501959e-02f, -1.28826089e-02f, -1.06140748e-01f, -2.35813465e-02f, 4.09989432e-03f, -5.46001643e-02f, -2.59751864e-02f,
  7.44587928e-03f, -3.12054493e-02f, -6.93452954e-02f, -7.02776834e-02f, -8.49881768e-02f, 1.26566198e-02f, -6.10461496e-02f, 1.10428771e-02f, -7.60777518e-02f, 3.94478366e-02f,
  -1.16743803e-01f, -3.02464783e-01f, 7.84544647e-02f, 5.50011434e-02f, 4.29531152e-04f, -2.76593715e-02f, -9.48475450e-02f, -4.09138249e-03f, -6.11399747e-02f, 9.88230258e-02f,
  -5.55172116e-02f, 8.05287436e-03f, -6.87966049e-02f, 3.61004174e-02f, -1.41337097e-01f, -4.17116582e-02f, -5.34922928e-02f, 7.01091439e-02f, 2.13904260e-03f, -2.88001914e-02f,
  1.71019081e-02f, -8.33261311e-02f, -2.00368986e-02f, -3.44384797e-02f, -8.12996551e-02f, -4.20135260e-02f, -4.58354354e-02f, -6.14175126e-02f, -2.68519070e-04f, 1.25423633e-03f,
  1.67643949e-01f, -7.63936564e-02f, -8.04195702e-02f, 2.00453885e-02f, -1.27286445e-02f, 6.27476051e-02f, 5.61679294e-03f, -4.81142662e-02f, 1.29464315e-02f, 6.54278398e-02f,
  9.91053358e-02f, 4.94688153e-02f, 2.04633430e-01f, 1.05893604e-01f, 9.82792601e-02f, -8.35774764e-02f, -1.72920097e-02f, -3.28651704e-02f, 9.12530199e-02f, 1.09715849e-01f,
  -6.05887882e-02f, 5.74479699e-02f, 1.17187127e-02f, 4.29586507e-02f, -1.31064635e-02f, 1.33095190e-01f, -3.72920893e-02f, -3.50396559e-02f, -3.84767540e-02f, -6.96660727e-02f,
  -7.64639527e-02f, -9.24499482e-02f, 1.19726978e-01f, 1.09236658e-01f, -8.71187076e-03f, -4.81222058e-03f, 5.49780317e-02f, 6.93663433e-02f, 5.30583747e-02f, 3.29543627e-03f,
  5.51748797e-02f, -2.32959893e-02f, -9.37407166e-02f, -1.19980477e-01f, 5.25385216e-02f, -7.89299905e-02f, -5.85187376e-02f, 2.23018825e-02f, 3.89816128e-02f, -2.97146235e-02f,
  1.71915945e-02f, 4.97699194e-02f, 7.39740729e-02f, -5.03322948e-03f, 9.79331881e-03f, 1.18342444e-01f, 5.62940463e-02f, -4.24412228e-02f, 7.54270144e-03f, -6.79741800e-02f,
  1.97152770e-03f, 5.67475148e-02f, 3.23720090e-02f, -2.12686136e-02f, 1.50561810e-01f, 4.48332354e-02f, 7.37093613e-02f, 8.61535687e-03f, -2.24961862e-02f, 1.04224598e-02f,
  -1.74721552e-03f, 3.65262181e-02f, 6.67677969e-02f, 4.55785058e-02f, -3.37378830e-02f, 4.13455032e-02f, -9.69253778e-02f, 1.09725550e-01f, -4.44573909e-02f, 4.43131430e-03f,
  3.23345922e-02f, -7.65588135e-02f, -3.04150097e-02f, -1.15312107e-01f, -4.07520086e-02f, -7.53938407e-02f, 5.50524257e-02f, -6.75987229e-02f, -5.83727807e-02f, -7.65005574e-02f,
  1.02396779e-01f, 1.47121564e-01f, 1.48462988e-02f, -3.23074684e-02f, -1.31085202e-01f, -1.02838419e-01f, 4.63642292e-02f, -6.97819293e-02f, -4.45095524e-02f, -7.97154754e-02f,
  -1.17457181e-01f, -1.54597871e-02f, -1.32753830e-02f, -1.03203647e-01f, 3.96049842e-02f, -6.57598972e-02f, 3.54320891e-02f, 8.38165507e-02f, 2.90072579e-02f, -2.17828881e-02f,
  4.97389399e-02f, 3.18892824e-04f, 1.26248971e-01f, 9.10855159e-02f, 3.36489826e-03f, 7.00615868e-02f, -2.16210503e-02f, -7.15306476e-02f, 8.42710733e-02f, 2.50175055e-02f,
  -4.17317301e-01f, -2.80302852e-01f, -1.78587176e-02f, -3.83046240e-01f, -5.26117086e-02f, -5.23070581e-02f, -1.84278209e-02f, 8.79426487e-03f, -1.18991807e-01f, -1.13287844e-01f,
  -6.55922815e-02f, -7.50594065e-02f, -8.67583007e-02f, 3.93660776e-02f, 1.77266285e-01f, -1.59014404e-01f, -9.05634090e-02f, -2.81257275e-02f, 2.25840032e-01f, 1.18388377e-01f,
  -2.34761788e-03f, -1.59610033e-01f, -4.96551841e-02f, 4.61528599e-02f, -1.61353290e-01f, -7.08967745e-02f, -9.64093432e-02f, -7.64892697e-02f, 4.83729597e-03f, -2.24765107e-01f,
  -1.37213901e-01f, -1.43964648e-01f, 1.57366693e-01f, 7.52466097e-02f, -1.28931686e-01f, 1.28283799e-02f, -3.96259800e-02f, -5.61484396e-02f, 6.68010116e-02f, -2.74261665e-02f,
  -5.53875379e-02f, 1.06332824e-02f, -2.78858356e-02f, -5.04514538e-02f, -6.42510802e-02f, 7.93668330e-02f, -2.83123762e-03f, 9.46683735e-02f, 9.96890515e-02f, 6.92642927e-02f,
  9.80158523e-02f, -2.45829411e-02f, 1.43449586e-02f, 3.89386155e-02f, 7.50338063e-02f, 6.37099668e-02f, 4.58432883e-02f, 5.90274297e-02f, 1.50099039e-01f, -2.48042002e-01f,
  9.30389836e-02f, -9.02521685e-02f, 6.03192188e-02f, 5.94627997e-03f, -1.47071239e-02f, 9.14993975e-03f, -5.25103100e-02f, 3.98735665e-02f, 2.97591686e-02f, -1.19620878e-02f,
  -1.13064200e-02f, 6.40195385e-02f, -6.13029413e-02f, -5.30850217e-02f, 2.35360563e-02f, -3.46757844e-02f, -6.17126040e-02f, 1.85957029e-02f, 6.97570816e-02f, 1.43242655e-02f,
  -1.57503560e-02f, 3.05782445e-02f, -1.16641380e-01f, 7.29012350e-03f, 5.70846908e-02f, 6.32413290e-03f, 1.79090165e-02f, 1.09169707e-01f, -1.11719333e-01f, 3.17234211e-02f,
  -2.68992335e-01f, 2.80210108e-01f, -1.65983453e-01f, 5.54506108e-02f, -4.50040624e-02f, -1.78496484e-02f, -7.54097551e-02f, -5.21005429e-02f, -7.68027827e-02f, -3.60185914e-02f,
  3.88189517e-02f, -1.01971209e-01f, -3.62715609e-02f, 2.65162550e-02f, 2.77405186e-03f, 5.87410480e-03f, 3.04616094e-02f, -1.14188686e-01f, 3.86217907e-02f, 4.71289530e-02f,
  7.61286765e-02f, -1.98714784e-03f, -8.30439329e-02f, -6.18682466e-02f, 4.51815426e-02f, 1.35316728e-02f, -4.22171727e-02f, -6.40824959e-02f, 4.72722538e-02f, -1.25162795e-01f,
  -2.50158429e-01f, 3.91611829e-02f, -1.24703757e-01f, -2.22065389e-01f, -2.66780347e-01f, -7.87726045e-02f, -6.88884854e-02f, -1.01945490e-01f, -1.09875746e-01f, -9.60687697e-02f,
  1.22341208e-01f, 5.17296009e-02f, 7.82045573e-02f, -6.41650930e-02f, -1.04694366e-01f, -1.26012594e-01f, -1.62619933e-01f, -1.72577515e-01f, -1.33569136e-01f, -8.57264325e-02f,
  -9.67275277e-02f, -1.82672068e-01f, -2.55616128e-01f, -8.49111304e-02f, -2.27900017e-02f, -4.10597101e-02f, -6.52757706e-03f, -5.35247326e-02f, -1.08147800e-01f, -1.32641867e-01f,
  2.08359033e-01f, -9.65175107e-02f, 3.50042880e-02f, -9.29722860e-02f, 1.16482582e-02f, -3.06596304e-03f, 5.37604168e-02f, -2.96900440e-02f, 6.35138107e-03f, -4.39496897e-02f,
  -1.98145844e-02f, -3.85425389e-02f, -1.24119474e-02f, 9.18793827e-02f, -1.52794272e-02f, 3.07942498e-02f, 3.48499902e-02f, -1.09492563e-01f, 5.12403734e-02f, 6.43850192e-02f,
  -1.89065523e-02f, -8.64482298e-02f, -2.88772285e-02f, 8.81474391e-02f, 1.31732792e-01f, -1.67420674e-02f, 2.00106502e-02f, 1.22245282e-01f, 1.45943183e-02f, 1.32908300e-01f,
  5.16798161e-02f, 1.04441978e-01f, 1.13749299e-02f, 7.75056779e-02f, 6.87624961e-02f, 3.71622629e-02f, -6.14517694e-03f, 5.36843576e-02f, -4.86777127e-02f, -4.21524122e-02f,
  -4.03013639e-02f, 9.24414247e-02f, -6.57488257e-02f, -1.13465846e-01f, -1.57219619e-02f, -7.02402666e-02f, 2.27565994e-03f, 4.19726735e-03f, 6.79274974e-03f, 1.04492344e-01f,
  7.99323544e-02f, 6.21225089e-02f, 2.35636495e-02f, 9.19364691e-02f, 3.02559771e-02f, -3.75469066e-02f, 2.34497562e-02f, -1.49427047e-02f, -5.49322402e-04f, -9.92988944e-02f,
  1.70486048e-01f, -9.77199748e-02f, 1.04139503e-02f, 2.25955881e-02f, -4.06288765e-02f, 8.08211416e-02f, 1.94822978e-02f, -3.95270623e-02f, 3.80713008e-02f, 5.18307462e-02f,
  6.92690536e-02f, 7.97265209e-03f, 3.46469134e-02f, 9.08931345e-02f, -1.25629112e-01f, 2.09732316e-02f, -4.83394936e-02f, -1.59819773e-03f, -2.37953756e-02f, 1.23807900e-01f,
  -6.49861097e-02f, 5.84820211e-02f, 2.81906370e-02f, 1.40657842e-01f, -7.42855575e-03f, -4.46483903e-02f, 1.15599073e-01f, 1.66251391e-01f, 1.03954002e-01f, 2.50743963e-02f,
  1.30038843e-01f, -9.22306851e-02f, -4.30729389e-02f, 1.19188696e-01f, 7.84056932e-02f, -3.76969315e-02f, -1.01844124e-01f, -2.90286131e-02f, -2.92045306e-02f, -6.79606795e-02f,
  1.88336391e-02f, -5.74150123e-02f, 4.71174195e-02f, -9.23423991e-02f, 1.58065576e-02f, -4.94249128e-02f, 1.64957736e-02f, 5.82373887e-02f, 4.68741022e-02f, -5.70719428e-02f,
  -5.06762601e-02f, -6.83793658e-03f, -1.54229570e-02f, -4.69271019e-02f, 5.59756197e-02f, -1.08681126e-02f, -9.10289437e-02f, -5.74961342e-02f, 6.32171780e-02f, 3.56062665e-03f,
  -1.68735921e-01f, -1.41177261e-02f, 1.40567213e-01f, 5.26707880e-02f, 3.71064171e-02f, -8.31812695e-02f, 3.74494642e-02f, 8.29592273e-02f, 5.31297326e-02f, 5.03854714e-02f,
  9.03646499e-02f, -5.67763820e-02f, 4.40763645e-02f, -5.18579930e-02f, 3.64842475e-03f, 7.51486272e-02f, 4.98551363e-03f, -4.76606041e-02f, 4.32594456e-02f, -1.45016581e-01f,
  -1.27265885e-01f, 5.42033054e-02f, 1.73798159e-01f, -5.84805086e-02f, 7.29243830e-02f, 2.08924827e-03f, 2.71775182e-02f, 4.80961613e-03f, 1.05137400e-01f, -6.53415024e-02f,
  -2.63960590e-03f, -4.22454365e-02f, 1.83250923e-02f, -1.92924459e-02f, 2.25919671e-02f, 1.04827248e-01f, 1.15094028e-01f, 1.67437140e-02f, 5.58219925e-02f, -6.63254261e-02f,
  -4.98253852e-02f, 7.65879755e-04f, 3.84117551e-02f, 1.85955074e-02f, -2.43766420e-02f, 7.10552484e-02f, -1.53799895e-02f, 4.06414792e-02f, -8.27859417e-02f, 6.09418824e-02f,
  -9.28064883e-02f, -3.72088961e-02f, -9.55241621e-02f, -9.84505638e-02f, -5.34589402e-02f, -1.43758499e-03f, -3.37580312e-03f, -8.63768440e-03f, -1.39701748e-02f, -8.01237226e-02f,
  -3.61063369e-02f, 1.68544948e-01f, 8.14575553e-02f, -1.86762195e-02f, 4.51717749e-02f, 5.77579439e-02f, -4.80434299e-03f, 6.69202507e-02f, 8.77310112e-02f, -1.28933582e-02f,
  -1.26012666e-02f, 6.84832186e-02f, -4.32468876e-02f, -2.26811133e-02f, 7.20391795e-02f, 8.33273157e-02f, 7.36724678e-03f, 1.59352511e-01f, -6.50196373e-02f, -8.26078206e-02f,
  -9.63011533e-02f, 1.46097913e-01f, 1.68117747e-01f, 4.66270112e-02f, 1.12972282e-01f, 1.50685355e-01f, 3.04954182e-02f, 1.13058820e-01f, 2.06360251e-01f, 4.13069800e-02f,
  1.52549043e-01f, -6.96774572e-02f, -1.86898746e-02f, -5.92287704e-02f, -5.19094318e-02f, 5.28219342e-03f, -3.68287489e-02f, 4.99768406e-02f, -2.92819310e-02f, 1.43596292e-01f,
  2.40225434e-01f, 2.17822209e-01f, 1.55659497e-01f, 5.84610216e-02f, 1.55075565e-01f, -1.09600678e-01f, -3.20299305e-02f, -8.02326426e-02f, 7.84210395e-03f, -4.10752669e-02f,
  1.54069467e-02f, -1.00466989e-01f, 7.99768642e-02f, 4.85080928e-02f, 1.32304400e-01f, 1.08112238e-01f, 6.83422089e-02f, 3.17869037e-02f, -5.47011048e-02f, 1.65219363e-02f,
  7.42004858e-03f, 1.42200336e-01f, 1.17555551e-01f, 3.33889127e-02f, -3.56936008e-02f, 7.14088008e-02f, -7.41257053e-03f, -2.39308774e-02f, -7.19641894e-02f, 6.02886081e-03f,
  3.70305963e-02f, 8.10238719e-02f, 6.15651421e-02f, 2.89597139e-02f, -6.02125488e-02f, 6.46439847e-03f, -6.75610378e-02f, -5.39913848e-02f, 4.01035026e-02f, -2.13275272e-02f,
  5.78547344e-02f, -5.40958978e-02f, 4.21502851e-02f, -4.94144298e-02f, 8.21456760e-02f, 3.19931917e-02f, 2.90058572e-02f, 1.02863863e-01f, 1.04124509e-01f, 7.78731331e-02f,
  1.84367076e-02f, 1.32106896e-03f, 3.20154093e-02f, 1.56583562e-01f, -1.87288392e-02f, -1.20215479e-03f, 7.24962205e-02f, -6.74478114e-02f, -6.94785789e-02f, -2.14909366e-03f,
  -1.19217597e-02f, -2.42389720e-02f, 1.35161653e-02f, 6.82693496e-02f, 3.18235829e-02f, 3.07888445e-02f, 3.00510470e-02f, -6.27521574e-02f, -3.46712396e-02f, -3.32870930e-02f,
  1.09483693e-02f, -1.56912123e-04f, 7.86135122e-02f, -9.32542235e-02f, 3.57878096e-02f, -6.93242997e-02f, 3.62388045e-02f, 3.12302727e-02f, 3.32477652e-02f, -8.55634585e-02f,
  -2.44619772e-02f, 1.07148401e-01f, 1.00108929e-01f, 1.55098848e-02f, 7.11715370e-02f, -4.41736095e-02f, -6.65615313e-03f, 2.38813348e-02f, 5.27694449e-02f, 3.83806266e-02f,
  3.59984934e-02f, 4.24519479e-02f, -1.00344427e-01f, -1.04857972e-02f, -4.26179217e-03f, -2.94134393e-02f, 3.52944247e-02f, -2.40932452e-03f, 5.81518002e-02f, -1.35568837e-02f,
  -5.29122986e-02f, -6.20152801e-02f, -9.89415571e-02f, 5.60875237e-02f, -6.95781410e-02f, 7.65975192e-02f, 7.94434994e-02f, 2.43613943e-02f, 1.08676635e-01f, -4.50919233e-02f,
  -2.53728002e-01f, 1.56957060e-01f, 1.56070113e-01f, -2.66682833e-01f, -2.91072130e-01f, -2.49935225e-01f, -1.48517847e-01f, -1.65739879e-01f, -1.00786895e-01f, 2.22162204e-03f,
  -6.38355091e-02f, 1.69215634e-01f, 1.23170689e-01f, 8.06726143e-02f, 1.53147876e-01f, -4.72075418e-02f, 3.93790491e-02f, 3.75561230e-02f, 6.16246015e-02f, -2.04688326e-01f,
  -8.28453749e-02f, -1.14920780e-01f, 6.17892249e-03f, -9.85279679e-02f, -1.27992779e-01f, 8.63427646e-04f, 7.14075612e-03f, -9.93773937e-02f, -1.13798361e-02f, -1.21499322e-01f,
  3.13354969e-01f, -3.35365981e-01f, -3.11748143e-02f, -2.53885742e-02f, -1.05792411e-01f, 1.93798095e-02f, -4.35732007e-02f, -3.17007937e-02f, -9.42184497e-03f, 2.67381575e-02f,
  -1.12360530e-01f, -1.16723128e-01f, -1.35906830e-01f, -3.52235995e-02f, -2.33759061e-02f, -6.98785633e-02f, 1.74430162e-02f, 5.20344973e-02f, 1.68009847e-02f, -8.32765996e-02f,
  2.89259688e-03f, -2.22035229e-01f, -3.54373679e-02f, -7.20963180e-02f, 1.60847623e-02f, 1.72611047e-02f, -9.48882382e-03f, -1.51754454e-01f, -1.42944053e-01f, 2.99777631e-02f,
  -5.31391241e-02f, 6.53292611e-02f, -9.10471082e-02f, -6.54174238e-02f, 5.45360744e-02f, 1.56982392e-02f, 2.22366918e-02f, 1.29002929e-01f, 2.12520715e-02f, 1.02511220e-01f,
  2.89205518e-02f, 2.62765866e-02f, 6.51633814e-02f, 3.05377245e-02f, 8.51370841e-02f, -1.67512000e-02f, -6.16650023e-02f, 6.37004972e-02f, 5.07998280e-02f, -3.87929790e-02f,
  -4.89985570e-02f, -1.65968388e-02f, -7.75084272e-03f, -2.75738835e-02f, 1.57691464e-02f, -2.86146477e-02f, -7.87123740e-02f, 9.43961740e-02f, 1.90272257e-02f, -3.32577154e-02f,
  2.21470281e-01f, 5.90887070e-02f, 7.37639591e-02f, 4.06418182e-03f, -1.23509496e-01f, -4.97306522e-04f, 1.28957536e-02f, -6.20159991e-02f, -8.38459060e-02f, -2.14650203e-02f,
  -3.02379113e-02f, -1.82855353e-02f, 7.94407502e-02f, -1.15425494e-02f, 1.98705159e-02f, -4.04939801e-02f, 9.33575851e-04f, -6.32535368e-02f, -4.71177883e-02f, -7.57292956e-02f,
  4.69406229e-03f, -2.42047012e-02f, 1.39501691e-01f, 1.93439033e-02f, 3.27260606e-02f, 1.19842903e-03f, 2.28124559e-01f, -1.79506131e-02f, 9.21774581e-02f, 2.59503841e-01f,
  4.47120607e-01f, -6.49207294e-01f, 4.31102555e-04f, 1.65747732e-01f, 9.04040858e-02f, 2.13062197e-01f, -1.35319382e-02f, 7.34117180e-02f, 6.93113804e-02f, -1.57294944e-01f,
  -1.18739590e-01f, 1.08119786e-01f, 4.21315059e-02f, 1.96142755e-02f, 1.08264796e-02f, 3.52580175e-02f, -2.90636942e-02f, 1.88307405e-01f, 4.44432974e-01f, 1.40073523e-01f,
  1.36732664e-02f, -8.54136422e-02f, -5.22854887e-02f, 3.04048471e-02f, -2.46523470e-01f, 1.85206324e-01f, -1.88074708e-01f, -1.61659375e-01f, -1.53708890e-01f, -2.07125634e-01f,
  1.46604041e-02f, -2.76025742e-01f, 1.61596492e-01f, 6.47497270e-03f, -1.32285208e-01f, 8.52013007e-02f, 5.57664223e-02f, -4.25611064e-02f, -8.30001384e-02f, -3.99334431e-02f,
  -1.99130345e-02f, -9.94099528e-02f, 2.60071922e-02f, -1.31160229e-01f, -1.40926288e-02f, 6.70309290e-02f, -1.17021956e-01f, -5.90259917e-02f, -5.85439354e-02f, -2.05819264e-01f,
  -3.29058170e-01f, -8.28892887e-02f, -9.43239033e-02f, -2.72544250e-02f, -6.79338425e-02f, 1.15419134e-01f, -2.75365472e-01f, -2.14426175e-01f, 3.26192449e-03f, -1.04182616e-01f,
  -2.86239274e-02f, -1.46359429e-02f, 5.66025712e-02f, -1.87567510e-02f, 3.33722830e-02f, -1.17641315e-02f, 2.85705701e-02f, 3.36267576e-02f, 2.13629827e-02f, 4.49828655e-02f,
  2.24039238e-02f, 3.11417207e-02f, -1.69142094e-02f, 3.04761529e-02f, -2.28698030e-02f, -4.10067216e-02f, 2.47736834e-03f, -8.50538760e-02f, 3.88594368e-03f, -4.30213623e-02f,
  -2.96996231e-03f, 2.99163871e-02f, -6.65914416e-02f, 5.50026307e-03f, -5.55940345e-02f, -8.27136170e-03f, 1.30297631e-01f, -4.81428616e-02f, 3.68580688e-03f, 3.04891821e-02f,
  1.73996955e-01f, 7.96399936e-02f, 1.25503615e-01f, 6.33400455e-02f, -3.90883796e-02f, -8.17785114e-02f, 2.36032601e-03f, 1.03819957e-02f, -2.27778591e-02f, -8.57345667e-03f,
  6.10757805e-02f, 9.71123725e-02f, -1.23622172e-01f, -4.61622402e-02f, 1.07193530e-01f, 2.84646153e-02f, -1.11865051e-01f, 1.02190070e-01f, 1.10630624e-01f, 2.36128662e-02f,
  -1.24379314e-01f, 1.62454963e-01f, 3.75070423e-01f, 1.68400705e-01f, 4.39489856e-02f, 3.61603588e-01f, 1.51817486e-01f, 9.76687372e-02f, 2.70298660e-01f, 1.97357357e-01f,
  2.77368668e-02f, -1.80443063e-01f, -3.52825701e-01f, 3.46361808e-02f, -1.20636903e-01f, -1.53927222e-01f, -3.51774752e-01f, -8.94996747e-02f, 1.84880555e-01f, -2.23635957e-01f,
  -5.22580706e-02f, -4.92198542e-02f, -2.20902503e-01f, -2.44606286e-01f, -4.46076393e-01f, -4.32789505e-01f, -4.32950079e-01f, -3.59985054e-01f, -2.39562094e-01f, 3.17519642e-02f,
  -1.56766232e-02f, -1.92930683e-01f, -1.24239795e-01f, -2.31471304e-02f, 9.38914269e-02f, 1.28654733e-01f, -1.12175852e-01f, -7.80466106e-03f, -6.79065660e-02f, -1.58590659e-01f,
  -1.77207530e-01f, 3.67833301e-02f, -7.46028796e-02f, -7.46293068e-02f, -2.51301862e-02f, 2.22015232e-02f, -6.90014288e-02f, 7.59584317e-03f, 3.51100303e-02f, -2.27275472e-02f,
  -2.52167340e-02f, -5.45264371e-02f, 1.91413667e-02f, 7.37018734e-02f, 7.19244927e-02f, -1.54570676e-02f, 6.36164565e-03f, -2.52786092e-02f, -1.13487892e-01f, -7.48377526e-03f,
  -1.09056942e-02f, -1.29816279e-01f, -8.20241943e-02f, -4.19609249e-02f, 9.35684741e-02f, -2.11142525e-02f, -1.19078942e-02f, 1.91161230e-01f, -6.85006529e-02f, 4.65195403e-02f,
  -9.94507745e-02f, 1.27813593e-02f, -3.54945511e-02f, 1.70041751e-02f, 1.41752698e-02f, 6.24040514e-02f, 9.19656921e-03f, -1.01243956e-02f, 3.17158066e-02f, 5.69182374e-02f,
  -3.09640858e-02f, -5.71215227e-02f, 5.77407815e-02f, -7.86285009e-03f, -2.31443308e-02f, -4.33364585e-02f, -3.93446675e-03f, -1.19726144e-01f, -6.22098073e-02f, -4.52235565e-02f,
  -5.29050268e-02f, 2.59154346e-02f, 4.49034609e-02f, 3.64497975e-02f, -1.02498807e-01f, -1.01383321e-01f, -1.55260796e-02f, 5.31407259e-02f, 3.94463800e-02f, 3.08230910e-02f,
  1.71134382e-01f, -3.09770048e-01f, -6.96633756e-02f, 1.37983598e-02f, -9.95738134e-02f, 2.48999894e-02f, 2.17925608e-02f, -5.92197850e-02f, 6.89919889e-02f, -2.67371591e-02f,
  2.30489597e-02f, 2.97555197e-02f, -1.41441515e-02f, -2.50867161e-04f, -5.71753271e-02f, -3.04805674e-02f, -9.51849893e-02f, -1.78271621e-01f, -1.23867936e-01f, -1.92573741e-02f,
  3.01581318e-03f, -1.12347253e-01f, -1.67589739e-01f, -1.09230742e-01f, 1.12618012e-02f, -1.52795628e-01f, -3.91756110e-02f, -3.24877687e-02f, -9.93889868e-02f, -6.47621006e-02f,
  -3.82456154e-01f, -2.40814298e-01f, 7.91040957e-02f, -2.25338340e-01f, -2.55806863e-01f, -1.97549492e-01f, -3.36992353e-01f, -2.05119044e-01f, -1.16640516e-01f, -2.41218254e-01f,
  -1.33299485e-01f, 1.54196573e-02f, 1.53755814e-01f, 1.91530392e-01f, 1.99185625e-01f, -1.25730962e-01f, -5.34592122e-02f, 6.60938993e-02f, 1.79617047e-01f, 1.31875724e-02f,
  -1.15973569e-01f, -5.01314662e-02f, 9.60651264e-02f, -1.61704440e-02f, -2.33692095e-01f, -5.06057590e-02f, -7.73091540e-02f, -1.00529283e-01f, -8.85305926e-02f, -2.58911759e-01f,
  5.00522517e-02f, -1.12873465e-01f, 1.58225745e-01f, 1.18624754e-02f, -6.27981424e-02f, 4.15188819e-02f, 4.04132307e-02f, 7.73260593e-02f, 4.15935516e-02f, 3.78154702e-02f,
  -2.49844138e-02f, 8.29382762e-02f, -2.73016170e-02f, -5.80771873e-03f, -2.93008238e-02f, -8.98510441e-02f, 7.99257867e-03f, 5.44238687e-02f, 7.60167092e-02f, 2.16749683e-02f,
  -3.59463431e-02f, -1.66435745e-02f, 9.36238561e-03f, 8.65571797e-02f, 1.42064035e-01f, 9.04723555e-02f, 4.93821017e-02f, 8.64369869e-02f, 1.66431054e-01f, -1.93258151e-01f,
  -7.37076178e-02f, 4.41806912e-02f, -9.83738899e-03f, -4.10471037e-02f, 2.63951626e-02f, -1.25317238e-02f, 4.83225584e-02f, -9.90604907e-02f, 1.99827994e-03f, -9.35053676e-02f,
  -5.23524964e-03f, -2.06579324e-02f, 3.36650945e-02f, -8.74146223e-02f, 1.60272641e-03f, 5.03379386e-03f, 8.32522288e-02f, -5.64999990e-02f, -8.59940425e-03f, -6.44371510e-02f,
  -1.14515694e-02f, 1.74244847e-02f, 2.62945537e-02f, 6.14112988e-02f, 2.49151490e-03f, -2.60342918e-02f, 7.58400187e-02f, -1.86482705e-02f, -3.39302868e-02f, 2.04763021e-02f,
  -1.56711359e-02f, 2.92706519e-01f, -8.79873261e-02f, 4.02012579e-02f, 4.60490361e-02f, 4.37252522e-02f, 4.22662161e-02f, 4.19225506e-02f, -2.23477744e-02f, 4.34542969e-02f,
  2.22141817e-02f, -2.41458640e-02f, -9.78934690e-02f, 6.39576018e-02f, -1.28139973e-01f, 5.98564297e-02f, -8.58113617e-02f, 3.73588130e-02f, 6.16623238e-02f, -1.21485129e-01f,
  -1.02243342e-01f, -1.06483951e-01f, 3.34303416e-02f, -1.76700447e-02f, -3.59988138e-02f, 2.76325736e-02f, 4.46087606e-02f, -1.17673147e-02f, 4.00414839e-02f, -2.47309223e-01f,
  -3.03027350e-02f, -5.39293000e-03f, 2.05915242e-01f, 1.89931408e-01f, 2.11377189e-01f, 1.27020061e-01f, 3.07817101e-01f, 2.38459036e-01f, 1.37220860e-01f, 1.13097526e-01f,
  -9.76431370e-02f, -1.20767392e-01f, -1.07736647e-01f, 1.14741493e-02f, 1.22761726e-01f, 1.53804153e-01f, 1.82917923e-01f, 6.88902065e-02f, 1.38344705e-01f, 9.72391292e-03f,
  -4.94324951e-04f, 8.65001306e-02f, -4.41582277e-02f, 5.26040122e-02f, 1.28357977e-01f, 8.48227218e-02f, 9.30616111e-02f, 3.50393541e-02f, -3.48710716e-02f, 1.14932068e-01f,
  -1.36972621e-01f, 9.69527960e-02f, 2.75035165e-02f, -1.92457065e-01f, -3.92029844e-02f, -4.97179031e-02f, 4.64088842e-02f, -6.08168580e-02f, -1.11881219e-01f, -2.21087392e-02f,
  -3.04423552e-02f, -7.30030388e-02f, 4.90475595e-02f, -7.30035082e-02f, 6.14305809e-02f, -6.68090731e-02f, -9.05235112e-02f, 4.80794907e-02f, 1.19231924e-01f, -2.05085613e-03f,
  7.00091794e-02f, -9.46537927e-02f, -8.40402266e-04f, 1.33948013e-01f, 4.89436984e-02f, -9.05916840e-02f, -8.73542801e-02f, 4.75085750e-02f, -5.75376749e-02f, 5.53224944e-02f,
  -2.43739281e-02f, -6.32804958e-03f, 3.85550782e-02f, -7.23825861e-03f, -7.83204101e-03f, -6.07286915e-02f, 1.07563481e-01f, 4.13211808e-02f, 1.56981841e-01f, 9.65964645e-02f,
  -2.13528257e-02f, 1.05152316e-01f, 7.87839517e-02f, 6.73230067e-02f, -7.37506747e-02f, -1.68126973e-03f, 6.07965924e-02f, 4.06123213e-02f, -5.25050275e-02f, -1.27978757e-01f,
  -6.55580088e-02f, 7.30938762e-02f, 1.47879645e-02f, 6.83782697e-02f, -4.15398255e-02f, 1.18407067e-02f, 3.75260934e-02f, 3.52308415e-02f, -4.57126275e-02f, -7.98105374e-02f,
  -1.24400906e-01f, -1.38229221e-01f, 8.53513479e-02f, 6.33213595e-02f, -1.74520090e-02f, -8.03858414e-02f, -6.98496997e-02f, -6.30723462e-02f, -5.72487079e-02f, 8.12647641e-02f,
  3.39451544e-02f, -8.78522322e-02f, -8.40397738e-03f, 1.15569465e-01f, 1.25059009e-01f, 2.68057976e-02f, -7.59849185e-03f, 1.89302787e-02f, -1.41205145e-02f, 3.46943364e-02f,
  -5.91438338e-02f, 5.48688769e-02f, -6.95977733e-02f, 1.36898607e-01f, -3.58865298e-02f, -4.11988720e-02f, -7.17860982e-02f, -3.31384651e-02f, -2.90526096e-02f, 1.28701285e-01f,
  -3.72943908e-01f, -1.04164489e-01f, -1.35567531e-01f, -2.53912330e-01f, -4.35728952e-02f, 1.99044541e-01f, 1.70862913e-01f, 1.44863322e-01f, 1.85817443e-02f, 3.63185778e-02f,
  7.68867657e-02f, -1.31432101e-01f, -9.73424017e-02f, -8.79476815e-02f, -2.18959078e-02f, 4.93445806e-02f, 5.02435938e-02f, -1.71997532e-01f, -1.67065948e-01f, 1.42862365e-01f,
  -7.44997412e-02f, -1.51517272e-01f, -2.43805453e-01f, -9.64259058e-02f, -1.54487446e-01f, -2.10987970e-01f, -9.73183066e-02f, -1.70893312e-01f, -9.60316975e-03f, -7.38769397e-02f,
  -1.84490569e-02f, -1.28177866e-01f, -8.79104529e-03f, -5.37119098e-02f, -8.45693424e-02f, 1.00681454e-01f, 4.51544672e-02f, -1.29608801e-02f, 5.06151505e-02f, -1.87007859e-02f,
  -9.14940983e-02f, -5.04381955e-02f, -4.48862091e-02f, -9.12187248e-03f, -9.66429934e-02f, -7.89104030e-03f, -8.13340545e-02f, -1.57455370e-01f, 3.12162992e-02f, 7.85219818e-02f,
  9.30527374e-02f, -5.15456088e-02f, -7.02860355e-02f, -4.65756208e-02f, 7.38253519e-02f, -5.53170033e-02f, -8.98279548e-02f, -6.42157272e-02f, -9.98705328e-02f, -1.16002038e-01f,
  1.02030143e-01f, 1.91916693e-02f, -8.60984251e-03f, -2.48153955e-02f, -4.48192507e-02f, 6.20773388e-03f, 5.76250218e-02f, -1.31006190e-03f, 2.78115347e-02f, -2.44215950e-02f,
  -5.75608686e-02f, -2.40050931e-03f, 7.13439509e-02f, -8.08769688e-02f, 1.09976875e-02f, -1.00318044e-02f, 3.19766924e-02f, 7.84676448e-02f, 3.19990590e-02f, 2.83283219e-02f,
  -8.59475955e-02f, 4.72344048e-02f, -5.23517728e-02f, -3.78963090e-02f, 2.92198267e-02f, -6.68835416e-02f, -1.49751164e-03f, -2.69521270e-02f, -4.87139300e-02f, 6.63572550e-02f,
  -5.49613461e-02f, 2.96967868e-02f, -9.63621885e-02f, -5.74049354e-02f, -9.83435847e-03f, 8.06741416e-02f, -4.96241674e-02f, 6.73746765e-02f, -7.57255107e-02f, 5.22777773e-02f,
  1.16036959e-01f, 8.78692698e-03f, -1.33120969e-01f, 8.28320906e-02f, 8.49366859e-02f, -2.50311773e-02f, 5.23233674e-02f, -3.60252149e-02f, -2.74349339e-02f, -1.70264412e-02f,
  -5.15647754e-02f, -1.33585319e-01f, -1.68008164e-01f, -9.25007463e-02f, -8.46842378e-02f, -7.95889571e-02f, -6.80561066e-02f, -1.06164524e-02f, -3.85021046e-02f, -9.10054594e-02f,
  1.69460848e-02f, 2.91980386e-01f, 8.31513405e-02f, 2.18048334e-01f, 2.64828831e-01f, 3.80887926e-01f, 3.85423988e-01f, 2.87627399e-01f, 1.10279620e-01f, 1.05579391e-01f,
  3.02167743e-01f, 7.27492273e-02f, 1.60246655e-01f, -3.90166454e-02f, 9.70388055e-02f, 9.66851339e-02f, 8.87824818e-02f, -1.53869227e-01f, 6.91650086e-04f, 3.18318233e-02f,
  5.68670407e-02f, -2.28012335e-02f, -1.23803563e-01f, -1.25226051e-01f, 7.46711865e-02f, 4.07592058e-02f, 3.54516990e-02f, 8.07501525e-02f, 8.86783469e-03f, -1.16359651e-01f,
  -1.50847986e-01f, 2.63779819e-01f, -1.05922721e-01f, 4.27019522e-02f, 4.48374590e-03f, -1.69884041e-01f, 1.92423724e-02f, -1.01506226e-01f, 7.67441839e-02f, 3.45499925e-02f,
  6.24353737e-02f, -1.13070644e-02f, 6.93365186e-02f, -1.00709520e-01f, -9.51281656e-03f, -1.04073551e-03f, 2.10412052e-02f, -5.13021974e-03f, -1.05343005e-02f, 4.64028195e-02f,
  1.16304914e-02f, -1.25290425e-02f, -4.10091728e-02f, 8.79906937e-02f, 5.44458069e-02f, -3.49050313e-02f, 1.41446816e-03f, -4.74271886e-02f, -1.69784278e-02f, -9.50922668e-02f,
  6.30003661e-02f, 2.36190185e-02f, 6.11413643e-03f, 3.56240012e-02f, -4.65524532e-02f, -3.37439924e-02f, -2.17313864e-04f, 8.98752958e-02f, 2.55920663e-02f, -5.42554632e-02f,
  4.99782301e-02f, -3.10694035e-02f, 2.11133119e-02f, 4.21085022e-02f, -5.34894094e-02f, 1.40453409e-02f, 1.34569267e-02f, -4.46776487e-02f, 3.70176025e-02f, -1.04482211e-02f,
  4.86614406e-02f, -4.65473421e-02f, -3.63713317e-02f, -1.72763802e-02f, 5.40035740e-02f, -7.43182749e-02f, -8.91368464e-03f, -5.18689640e-02f, 6.40884936e-02f, -3.62052210e-02f,
  -9.80934948e-02f, 1.38649300e-01f, -2.32986044e-02f, -8.02971870e-02f, 5.22238668e-03f, -5.66615090e-02f, 1.27794653e-01f, -3.86572741e-02f, 4.82950769e-02f, -7.23817125e-02f,
  -8.72248933e-02f, -5.29047437e-02f, 2.10707597e-02f, -8.28439966e-02f, -6.45268708e-02f, -6.03722893e-02f, -7.37962052e-02f, 3.80733758e-02f, -4.32602055e-02f, -8.34653229e-02f,
  -5.20321168e-02f, -1.36334583e-01f, -7.23010153e-02f, -3.83277312e-02f, 5.99380061e-02f, -4.89781611e-02f, 2.50458848e-02f, -6.12142049e-02f, -7.44544491e-02f, -7.38221332e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  4.18243296e-02f, 4.99843396e-02f, 4.97861067e-03f, 1.74558461e-01f, 3.15951914e-01f, 1.54702350e-01f, 1.58078983e-01f, 8.42593163e-02f, 1.20190486e-01f, 1.66258067e-01f,
  1.07766584e-01f, 8.29604790e-02f, 6.93697901e-03f, 3.88161987e-01f, 6.80137396e-01f, 2.10826099e-01f, 3.79335344e-01f, 1.00986674e-01f, 2.02616234e-03f, 1.93146169e-01f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  3.08453798e-01f, -6.19717017e-02f, 1.66271850e-01f, -7.36509562e-02f, 2.27813318e-01f, 2.34712809e-01f, 3.39512527e-01f, 4.41131741e-01f, 7.68297687e-02f, -2.64817059e-01f,
  -2.00768992e-01f, 4.40530002e-01f, 1.99702367e-01f, 3.62532139e-01f, -2.26642445e-01f, 1.22845195e-01f, -2.49728456e-01f, 3.87005624e-03f, -2.77301252e-01f, 1.19550318e-01f,
  -1.75715715e-01f, -2.35683277e-01f, 1.22325253e-02f, -3.21164280e-01f, -2.03836277e-01f, 2.23192021e-01f, -3.12227041e-01f, -1.05866902e-01f, 2.57541742e-02f, 1.06184753e-02f,
  -1.20625049e-01f, -3.22299808e-01f, -1.84224639e-02f, -6.51645660e-03f, -1.00176781e-01f, -1.05263308e-01f, 2.88328193e-02f, 1.41129792e-01f, 4.28511977e-01f, 1.70020655e-01f,
  3.38392973e-01f, 8.71018041e-03f, 3.36299360e-01f, -4.30599183e-01f, 1.84836641e-01f, 4.76310402e-02f, 6.27263039e-02f, 4.88450676e-01f, -6.72715083e-02f, 1.54878110e-01f,
  7.76526704e-02f, -3.98422182e-01f, -8.13572109e-02f, 1.35854676e-01f, 6.14431016e-02f, 3.94248553e-02f, 9.60532203e-02f, 2.95669466e-01f, -3.03378701e-01f, -1.02569632e-01f,
  -7.87972808e-02f, -1.84694961e-01f, -1.98484302e-01f, 1.59611329e-01f, -1.40481055e-01f, 3.18093687e-01f, -3.59627128e-01f, 5.73779419e-02f, -1.70871377e-01f, -3.41313720e-01f,
  -1.80116221e-01f, 6.47690818e-02f, 1.22042172e-01f, 1.53065726e-01f, 4.86698240e-01f, -2.03484207e-01f, -1.06523015e-01f, -8.50803554e-02f, -1.69289470e-01f, -1.57413762e-02f,
  3.04172873e-01f, -1.58179626e-01f, -3.34991872e-01f, -2.11488500e-01f, 8.26195255e-02f, 5.98495677e-02f, 3.98771465e-02f, -6.83247671e-02f, 9.04455036e-02f, -2.54967302e-01f,
  -3.16484630e-01f, 3.07848901e-01f, -1.73208758e-01f, -2.67385900e-01f, 2.15371981e-01f, 2.68527657e-01f, -5.62997572e-02f, 1.88253388e-01f, 5.32854237e-02f, 2.31726795e-01f,
  1.19112454e-01f, -1.33291543e-01f, -4.26851869e-01f, -9.68031213e-02f, -3.11161969e-02f, 1.21815108e-01f, -2.28413083e-02f, -6.36010051e-01f, -1.56298891e-01f, -2.21814349e-01f,
  3.56581528e-03f, -3.50280404e-02f, 2.13128686e-01f, -6.94334731e-02f, -1.30028099e-01f, -7.49363005e-02f, 1.53388038e-01f, 1.82827577e-01f, -1.07778959e-01f, 1.11094989e-01f,
  2.22737014e-01f, -1.35072604e-01f, 1.35982215e-01f, 9.34128091e-02f, 3.19182873e-01f, -1.87882900e-01f, -7.37976283e-02f, 8.32435861e-02f, 4.74878699e-02f, 3.38178314e-02f,
  -2.53142804e-01f, -1.56190678e-01f, 1.61863670e-01f, 4.96726409e-02f, 2.15769514e-01f, 2.73901075e-01f, -2.42945313e-01f, -2.43112937e-01f, -1.03879362e-01f, -3.08313906e-01f,
  -1.59616321e-01f, -2.98942029e-01f, 1.30917549e-01f, 1.78960040e-01f, -6.22332701e-03f, -7.15589970e-02f, 9.51287746e-02f, -1.17390670e-01f, -1.34777445e-02f, -1.64737344e-01f,
  -3.46012682e-01f, 3.24440375e-02f, -7.42340386e-02f, 1.90587472e-02f, -6.06070518e-01f, -1.49014026e-01f, 4.89379689e-02f, -1.11851282e-01f, -2.45322421e-01f, 2.00326011e-01f,
  2.02456608e-01f, 2.38169488e-02f, -8.75723362e-02f, 1.16345212e-01f, -4.66465615e-02f, -2.78386861e-01f, -2.20237821e-01f, 1.55284166e-01f, -2.76473552e-01f, 1.19619049e-01f,
  3.36150348e-01f, -4.69409764e-01f, -1.88745514e-01f, -1.82642981e-01f, 1.77509822e-02f, -1.81962699e-01f, 1.83933198e-01f, 1.77745625e-01f, -3.48018408e-02f, -1.64167166e-01f,
  6.49678782e-02f, 2.30778068e-01f, -2.88106836e-02f, 5.21040102e-03f, 1.27716422e-01f, -1.87250059e-02f, -3.12289149e-01f, 2.11146086e-01f, 1.46653101e-01f, -2.34340787e-01f,
  8.85274634e-02f, 3.15806895e-01f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -3.92572396e-02f, 1.50712714e-01f, -2.24295050e-01f, -1.60093620e-01f, 1.23492196e-01f, -2.01579675e-01f, -1.68558002e-01f, -1.63327381e-01f, 3.87505680e-01f, 1.71118125e-01f,
  1.77437246e-01f, 1.41612917e-01f, -3.41254063e-02f, -1.30311608e-01f, -1.97724104e-02f, 3.43832932e-02f, 3.22288871e-01f, -8.62972364e-02f, -2.18747169e-01f, -2.17811968e-02f,
  1.26099393e-01f, 6.51216432e-02f, -1.61303967e-01f, 2.63536423e-01f, -1.11708604e-01f, -9.99320745e-02f, 3.98156434e-01f, 4.14945185e-01f, -1.12230912e-01f, 3.72977629e-02f,
  4.88451421e-02f, -1.03685267e-01f, -1.38082609e-01f, -1.10575952e-01f, -5.84384054e-02f, 8.44880715e-02f, 1.08190924e-01f, 1.22725740e-01f, 3.51573139e-01f, -2.07480475e-01f,
  -6.26844391e-02f, -2.32402489e-01f, -8.70160013e-02f, -2.71837562e-01f, -9.31694433e-02f, 3.58316861e-02f, 5.15622199e-01f, 5.26788175e-01f, -9.35422108e-02f, -3.52908969e-02f,
  3.65356743e-01f, -3.16371799e-01f, -1.57059222e-01f, -2.59458292e-02f, 1.36920601e-01f, -3.54965031e-02f, -4.05155942e-02f, -1.39249682e-01f, -1.91838950e-01f, 1.35803491e-01f,
  -6.33778125e-02f, 1.16302140e-01f, 2.26848006e-01f, 1.15735874e-01f, 1.93250597e-01f, 1.38218537e-01f, 2.15548858e-01f, 1.16977982e-01f, 2.60652333e-01f, 3.97478968e-01f,
  -3.23988259e-01f, -3.80285829e-01f, 2.90670156e-01f, -6.64266199e-03f, 1.05528735e-01f, -2.91899871e-02f, -6.41571358e-02f, 2.04965219e-01f, 7.47181326e-02f, 2.14128837e-01f,
  2.48333782e-01f, -2.30696023e-01f, -9.49378386e-02f, -2.07040295e-01f, 1.23448133e-01f, -6.56277779e-03f, -3.67105417e-02f, 1.72000349e-01f, -2.10123405e-01f, 3.63256782e-01f,
  9.04034913e-01f, -1.07079066e-01f, 5.14225326e-02f, 2.23642170e-01f, -2.42439404e-01f, 1.28142402e-01f, -4.57290821e-02f, 3.83745551e-01f, 6.27536848e-02f, -2.77092487e-01f,
  -8.16215351e-02f, 6.61148652e-02f, 4.62486297e-02f, -3.88138294e-01f, 5.04877388e-01f, 2.27742925e-01f, 3.08512658e-01f, -4.66934033e-02f, -1.36547536e-01f, 1.91014558e-01f,
  4.96834666e-02f, 1.17613018e-01f, 3.56709570e-01f, -3.07841748e-01f, -1.74551591e-01f, 8.81511047e-02f, 1.85772225e-01f, -8.03112760e-02f, 5.30211162e-03f, 1.32073238e-01f,
  7.24635422e-02f, 2.63827592e-01f, 2.94529021e-01f, 5.69491764e-04f, -1.21755995e-01f, 1.42771065e-01f, 4.99594286e-02f, 3.57773304e-02f, 5.17856956e-01f, 4.55918282e-01f,
  -1.10991977e-01f, 6.74469471e-02f, -7.41603151e-02f, 4.87897336e-01f, 8.91794264e-02f, -8.08897987e-02f, 3.85614932e-02f, 2.82380283e-01f, 2.89644629e-01f, 4.57221657e-01f,
  8.96744877e-02f, 3.54599684e-01f, -1.33812711e-01f, 2.87698060e-02f, 2.62750655e-01f, -1.48989618e-01f, 9.70182475e-03f, 3.74201328e-01f, -4.29765992e-02f, -5.53881377e-02f,
  4.27412987e-01f, -2.13193387e-01f, -2.57476382e-02f, 3.34033698e-01f, -1.80109859e-01f, 5.06066233e-02f, -2.49948010e-01f, -1.77954435e-02f, 2.10403621e-01f, 3.01291436e-01f,
  1.49708301e-01f, 3.00039113e-01f, 1.78724512e-01f, 1.55200258e-01f, -1.23943850e-01f, -2.28130613e-02f, -1.87579095e-01f, -6.18073456e-02f, 6.15280457e-02f, -5.84982261e-02f,
  2.44694188e-01f, -2.67438442e-01f, -1.62033993e-03f, -2.87086755e-01f, 3.72619443e-02f, 2.27345899e-02f, 5.79847693e-01f, 2.95966089e-01f, 3.07476670e-01f, -1.13424212e-01f,
  4.11743224e-02f, 6.69650912e-01f, 8.32809880e-02f, -9.24811214e-02f, -1.50763914e-01f, 4.46521677e-02f, 2.51950119e-02f, 1.50226206e-01f, 4.56229150e-01f, -1.47872061e-01f,
  3.74011964e-01f, -1.37860730e-01f, -7.45418146e-02f, 1.29209518e-01f, 8.70158672e-02f, 8.10895935e-02f, 4.72912453e-02f, -4.41807359e-02f, -1.20980971e-01f, 9.11850296e-03f,
  -1.97749525e-01f, 8.30464140e-02f, 5.42294122e-02f, -1.53686777e-01f, -1.43179148e-01f, 5.89537341e-03f, -1.54161483e-01f, 4.15838789e-03f, -7.05563053e-02f, 3.62332501e-02f,
  -5.48398346e-02f, 2.07502749e-02f, -8.11648816e-02f, -6.60715699e-02f, -3.18754651e-02f, -1.07632145e-01f, -8.55953805e-03f, -1.41023263e-01f, -1.41867548e-01f, -4.38679429e-03f,
  -1.11417480e-01f, -1.37611732e-01f, -5.70885763e-02f, 1.09901801e-01f, -3.41417566e-02f, 2.62942791e-01f, -1.05829246e-01f, -4.09949124e-02f, 1.88958287e-01f, 2.96870977e-01f,
  -3.51159483e-01f, 5.97797520e-02f, 4.15816121e-02f, 4.70158234e-02f, -2.01665521e-01f, -4.72243726e-01f, -3.54729109e-02f, 1.58222452e-01f, 6.50128052e-02f, -4.46081944e-02f,
  -3.52211297e-02f, -5.63203432e-02f, 8.23027864e-02f, 1.89981312e-01f, 3.58087681e-02f, 1.60461202e-01f, 2.72644818e-01f, -1.50970399e-01f, 2.81282425e-01f, 3.41825128e-01f,
  1.13071814e-01f, -1.81578338e-01f, 3.85323495e-01f, 2.62446553e-01f, -2.52569169e-02f, 1.89688310e-01f, 4.48241644e-02f, 7.62336627e-02f, 4.28291708e-02f, -2.92942286e-01f,
  1.93499267e-01f, -7.49408156e-02f, 2.30308905e-01f, 7.15918913e-02f, 3.40586424e-01f, -1.97927892e-01f, 1.59923494e-01f, 1.25329807e-01f, -5.44409454e-03f, -5.81095293e-02f,
  -6.16632700e-02f, 1.73232108e-01f, 2.42177248e-01f, -1.49690742e-02f, -1.39253944e-01f, 4.67802763e-01f, 2.08336174e-01f, 1.42018259e-01f, -1.63104922e-01f, 1.01492316e-01f,
  8.31302851e-02f, 5.22278156e-03f, 1.04124755e-01f, 3.40114862e-01f, -1.11314766e-02f, 2.72942185e-01f, 3.47552337e-02f, 1.11269519e-01f, 1.94916785e-01f, 3.74381512e-01f,
  4.12367761e-01f, 3.73252183e-02f, 2.07784146e-01f, -6.64585903e-02f, 1.26918077e-01f, 6.12994313e-01f, 7.77346939e-02f, -3.43122259e-02f, -7.07134381e-02f, -5.94319344e-01f,
  -4.94024977e-02f, 1.97072715e-01f, -1.57558888e-01f, 3.44199717e-01f, 3.11947256e-01f, 3.90830666e-01f, -2.34630585e-01f, -9.19876844e-02f, 1.96355909e-01f, -2.32607126e-02f,
  2.72351444e-01f, 6.54253438e-02f, 1.87309682e-01f, 3.84423554e-01f, -1.99254211e-02f, 6.00423396e-01f, 4.63812500e-01f, -1.47868127e-01f, -5.85530140e-02f, -8.81752893e-02f,
  2.73411602e-01f, 2.57207423e-01f, 4.61856544e-01f, -1.26494601e-01f, 9.05813575e-02f, 6.04976416e-01f, 7.79443920e-01f, 1.87165320e-01f, 6.18398786e-02f, 1.05353609e-01f,
  2.07553998e-01f, 4.56366599e-01f, -1.18873551e-01f, -5.75456731e-02f, 4.16680008e-01f, 6.28006101e-01f, 9.60074142e-02f, 8.29124299e-04f, 3.52836162e-01f, 9.26547945e-02f,
  -1.20306715e-01f, -2.18091086e-01f, -3.84155996e-02f, 7.07270429e-02f, -1.59113497e-01f, 8.15814361e-02f, -3.26747924e-01f, 1.64390624e-01f, -3.14382792e-01f, -4.58228849e-02f,
  4.02022481e-01f, -4.37007882e-02f, -6.34811223e-02f, 4.50655632e-02f, 1.06496856e-01f, -2.82808933e-02f, -9.47267264e-02f, 9.85653251e-02f, -1.58781901e-01f, 1.82509780e-01f,
  -1.23641498e-01f, -2.18567193e-01f, -4.96863052e-02f, -2.18593568e-01f, 5.88690601e-02f, 1.07106259e-02f, -2.14237310e-02f, 3.22814919e-02f, -6.73587173e-02f, 3.73743773e-01f,
  1.38338417e-01f, -4.79220711e-02f, 9.08712894e-02f, 2.43025973e-01f, -1.13804951e-01f, -1.63739040e-01f, 1.75488254e-04f, -6.45910054e-02f, 2.43311599e-02f, 1.11094669e-01f,
  1.73036590e-01f, -1.11375928e-01f, 2.61391610e-01f, -1.90987661e-01f, 5.16388237e-01f, 1.66504398e-01f, 4.90511626e-01f, 2.65837789e-01f, 2.42728606e-01f, 9.00020823e-02f,
  7.87631273e-02f, 3.14043194e-01f, -6.06945693e-01f, -6.41906619e-01f, -2.61711001e-01f, -2.95508027e-01f, 2.26890713e-01f, -4.50558700e-02f, -1.68172851e-01f, 5.37810959e-02f,
  7.98561648e-02f, 7.98780918e-02f, 6.46283058e-03f, 3.95011753e-01f, -2.80946821e-01f, 3.92586172e-01f, -2.45253861e-01f, -4.62421067e-02f, 4.66671772e-02f, 1.10101223e-01f,
  -1.17540993e-01f, -1.53896868e-01f, 2.31754959e-01f, -1.60394758e-01f, 1.04944564e-01f, -3.07877272e-01f, 5.68156280e-02f, -3.88309322e-02f, -7.14457780e-02f, 1.87719345e-01f,
  4.26579490e-02f, 1.33324936e-01f, -1.09429143e-01f, -4.09647226e-02f, -2.47413114e-01f, -1.51161715e-01f, -2.33642370e-01f, 2.49381792e-02f, -6.43406734e-02f, 4.10559103e-02f,
  -3.28725353e-02f, 2.18955845e-01f, -4.53920066e-02f, 4.79701683e-02f, 2.29331121e-01f, -6.69412129e-03f, 2.99534276e-02f, 1.51294190e-02f, -1.83521703e-01f, -1.84497729e-01f,
  3.61582525e-02f, -6.14343807e-02f, -2.41352394e-01f, -3.34193148e-02f, 3.04716581e-04f, 4.74458337e-02f, 2.38624066e-02f, 4.54344861e-02f, 3.49996418e-01f, 8.25617090e-02f,
  -1.78112045e-01f, 2.90949285e-01f, 4.24981296e-01f, 4.08944994e-01f, -5.76288879e-01f, -5.28975666e-01f, -5.51410794e-01f, -1.68017864e-01f, -1.86925665e-01f, 2.07743138e-01f,
  -8.55083391e-03f, -1.35973856e-01f, 3.64775956e-01f, -1.99347049e-01f, 2.68283337e-02f, 9.47698578e-03f, 4.27820116e-01f, -4.62379940e-02f, -8.18081573e-02f, 1.97723120e-01f,
  3.36228125e-02f, 3.15443188e-01f, -1.04679726e-01f, -1.16077498e-01f, 1.87803686e-01f, -7.90882558e-02f, 1.98234946e-01f, 4.22927171e-01f, 4.02135169e-03f, 4.67780471e-01f,
  4.10922468e-02f, -3.94293778e-02f, 1.84531108e-01f, 1.18238069e-01f, -1.45121485e-01f, -9.74963084e-02f, -1.84128687e-01f, -1.87375754e-01f, -3.18293273e-01f, 7.70731969e-03f,
  9.09890831e-02f, 1.26125207e-02f, 7.25769028e-02f, 6.03738129e-02f, 7.66618922e-02f, 4.34764251e-02f, 2.29169562e-01f, 2.03353703e-01f, 3.17629039e-01f, 1.33366685e-03f,
  -7.09311068e-02f, 2.80498594e-01f, 2.44841129e-01f, 2.16512885e-02f, 1.14903972e-01f, 4.89187464e-02f, -2.60143727e-01f, -6.32884055e-02f, 2.09366500e-01f, -1.05417006e-01f,
  3.42306554e-01f, -7.12488070e-02f, -4.78834026e-02f, 5.77831566e-02f, 4.46952909e-01f, 1.56070605e-01f, 8.30218419e-02f, 6.78240955e-02f, 3.34278971e-01f, 2.16337964e-01f,
  3.16405803e-01f, 1.51029333e-01f, -1.49188861e-01f, -4.05610800e-01f, 2.06730321e-01f, -2.87728012e-01f, -2.03304626e-02f, 4.60187644e-01f, 4.63185366e-03f, 3.98644924e-01f,
  -2.59575576e-01f, -5.39704412e-02f, 4.04555835e-02f, -1.41657472e-01f, -7.06934184e-02f, 1.58937395e-01f, 1.98145062e-01f, -2.84526110e-01f, 3.97458285e-01f, 6.20462418e-01f,
  -1.58753738e-01f, 1.45421237e-01f, -3.91146578e-02f, -8.65502506e-02f, 4.65723157e-01f, 4.02047008e-01f, 2.79771507e-01f, 9.97480899e-02f, 4.25696760e-01f, 5.64502418e-01f,
  -1.62354335e-01f, -7.99552500e-02f, -4.25426327e-02f, 5.51640205e-02f, -1.12193236e-02f, -1.64161846e-01f, -2.02846453e-01f, 4.10290152e-01f, -1.66821390e-01f, -1.84718147e-01f,
  2.46835444e-02f, -8.77134651e-02f, 7.44825453e-02f, -2.07155034e-01f, 2.28797927e-01f, -1.00936137e-01f, 1.11928403e-01f, 1.92117207e-02f, -2.35758618e-01f, 5.97423971e-01f,
  4.50325698e-01f, -2.99919605e-01f, 3.33937883e-01f, 2.22791620e-02f, -9.55678523e-02f, -1.34240389e-01f, 1.00927904e-01f, -6.99413568e-02f, 2.42924333e-01f, -7.34116063e-02f,
  -4.60178182e-02f, -8.00798014e-02f, -1.19266473e-01f, 1.24544673e-01f, 4.13277984e-01f, 4.82728302e-01f, 3.11424434e-01f, 7.80020282e-02f, 9.41022709e-02f, 3.56983989e-01f,
  -2.09296405e-01f, -1.97551325e-01f, 3.69751640e-02f, 1.24843225e-01f, -3.58061492e-01f, 2.29886651e-01f, -2.29704864e-02f, -3.90476957e-02f, 3.99054050e-01f, -1.69359833e-01f,
  1.77022144e-02f, 1.68017253e-01f, 1.04038373e-01f, 6.37771130e-01f, 1.68984860e-01f, -7.73182288e-02f, -1.20364763e-01f, 1.05128676e-01f, -1.32182062e-01f, 1.50932804e-01f,
  -5.77976555e-02f, -2.19758421e-01f, -1.06529161e-01f, 3.61115113e-02f, -1.99082866e-02f, -1.14472605e-01f, -4.34503853e-02f, 4.07787338e-02f, -8.33144858e-02f, -1.88992083e-01f,
  -2.04972729e-01f, -7.54937008e-02f, 2.85111636e-01f, 2.56875396e-01f, 1.73499480e-01f, 9.36646163e-02f, -9.31725372e-03f, 1.34474725e-01f, 1.79715082e-01f, 2.74819613e-01f,
  1.56453237e-01f, -1.64205864e-01f, -3.66911888e-02f, 3.13863554e-03f, 2.64787227e-01f, -6.16127402e-02f, 2.52748609e-01f, 1.71807900e-01f, 2.65732575e-02f, 3.56935173e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  2.20500827e-01f, 9.59803071e-03f, 2.86314022e-02f, 2.17806488e-01f, 1.91493109e-01f, 4.47406992e-02f, -1.03708804e-01f, -6.54548630e-02f, -7.08462717e-03f, 2.39818513e-01f,
  4.49268728e-01f, 1.93487495e-01f, 5.02145588e-01f, 7.51147047e-02f, 2.33372182e-01f, -5.08026965e-02f, 3.62371951e-01f, 1.42227292e-01f, 8.62707794e-02f, -8.58495943e-03f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -3.44205678e-01f, -1.99914095e-03f, -7.00415313e-01f, -4.56680954e-01f, -3.28207724e-02f, -3.16172928e-01f, -1.88815266e-01f, -4.80866171e-02f, 2.69072652e-01f, 2.39768982e-01f,
  2.45250672e-01f, 1.51509881e-01f, 4.23351169e-01f, -1.50882810e-01f, -1.77493885e-01f, 7.44140595e-02f, -3.30959320e-01f, 5.41062474e-01f, -1.32495731e-01f, -1.38940439e-01f,
  1.92159146e-01f, 5.29073060e-01f, -7.10921943e-01f, 2.02380419e-01f, -3.02477449e-01f, 1.40628934e-01f, -3.28207076e-01f, 2.33101502e-01f, 1.94868639e-01f, -6.28234565e-01f,
  5.29500902e-01f, -2.99555603e-02f, -5.44543207e-01f, 2.12062806e-01f, 2.54063755e-01f, -6.17214084e-01f, -2.48245239e-01f, 2.15389684e-01f, -6.53073907e-01f, -2.63196379e-01f,
  -1.05564408e-01f, 8.79294649e-02f, -3.69261742e-01f, 6.10196367e-02f, -3.34316418e-02f, 5.05296551e-02f, 4.21165496e-01f, 2.22288296e-01f, -2.77347475e-01f, 1.40750155e-01f,
  -1.55255035e-01f, 6.19074523e-01f, 2.40536109e-01f, 3.82583767e-01f, -7.50690699e-01f, -3.03142160e-01f, -2.39298418e-01f, -7.73024857e-02f, 1.45032674e-01f, -2.61240005e-01f,
  -5.42655848e-02f, 2.17118070e-01f, 6.19925931e-02f, 5.08006632e-01f, 3.35204363e-01f, 8.88550580e-02f, 1.11072476e-03f, -9.92241353e-02f, 2.97471464e-01f, 5.74034676e-02f,
  3.51035297e-01f, 2.05390424e-01f, -2.89344132e-01f, 5.17682314e-01f, 3.82045209e-01f, 4.14950132e-01f, -2.31420517e-01f, -1.43198520e-01f, 4.95408289e-02f, -3.35722506e-01f,
  -6.39497161e-01f, 3.91572773e-01f, 7.51801580e-02f, 1.53676197e-01f, -1.34704560e-01f, 4.08151388e-01f, -5.22813261e-01f, 3.47156286e-01f, 8.54683220e-01f, 2.97693238e-02f,
  -3.57004218e-02f, 3.63647528e-02f, 1.60881475e-01f, 4.34717238e-01f, -5.12303174e-01f, -2.13436753e-01f, -3.71360004e-01f, 9.75267217e-02f, 8.40093791e-02f, -1.30616277e-01f,
  -1.82233006e-01f, -2.06255034e-01f, -4.48738843e-01f, -2.39345923e-01f, 4.16620791e-01f, 4.32363689e-01f, -2.60078251e-01f, 1.94350034e-01f, -1.67320192e-01f, 2.31259614e-01f,
  -2.42932409e-01f, -1.69561595e-01f, 2.41471291e-01f, 7.20845997e-01f, 4.45380211e-02f, 8.44992325e-02f, -4.02773619e-01f, -1.01244673e-01f, 1.56599358e-01f, 1.95153937e-01f,
  2.94043183e-01f, 8.12602118e-02f, 2.84877002e-01f, 7.45163500e-01f, -5.09134531e-01f, 1.18460715e-01f, -4.07694578e-01f, 1.91413552e-01f, 4.81833816e-01f, -1.11838557e-01f,
  2.82350004e-01f, 1.42753407e-01f, -2.18856901e-01f, -5.14793456e-01f, -2.02526167e-01f, -1.05850950e-01f, 4.31597203e-01f, 2.36267790e-01f, -3.85681927e-01f, 4.51475114e-01f,
  -3.21673483e-01f, -3.90913635e-02f, -6.66344404e-01f, -4.06793505e-01f, 2.63611197e-01f, 4.88186479e-02f, 9.06555429e-02f, -1.02123627e-02f, -1.45189660e-02f, 5.88656723e-01f,
  2.69041836e-01f, 2.04576001e-01f, -1.06138080e-01f, -2.31386989e-01f, -1.71257257e-01f, 1.05058603e-01f, 5.54236710e-01f, -2.22911596e-01f, 4.99591500e-01f, -2.19210491e-01f,
  6.89562082e-01f, 1.70712650e-01f, 4.25505936e-01f, 3.71410787e-01f, -5.21267168e-02f, 3.05194110e-01f, -4.29057814e-02f, 1.49660274e-01f, 4.28596795e-01f, 2.26257998e-03f,
  -7.00064063e-01f, 1.15097344e-01f, 4.40254271e-01f, -1.84287325e-01f, 2.42777914e-01f, 6.98930800e-01f, 7.05155969e-01f, -8.22129920e-02f, -1.03608064e-01f, -3.30297828e-01f,
  2.00989217e-01f, -1.58114702e-01f, 3.57052714e-01f, -3.42151552e-01f, -6.70224905e-01f, -1.84034899e-01f, -3.52615356e-01f, -1.70991868e-01f, 1.87957119e-02f, 1.37686133e-01f,
  2.85650164e-01f, -2.46585831e-01f, -3.51164550e-01f, 5.38377464e-01f, -3.68173063e-01f, -1.18080549e-01f, 3.31539929e-01f, -1.10105470e-01f, 6.91763282e-01f, -3.25209588e-01f,
  -5.14225066e-01f, -8.03544581e-01f, 1.01112403e-01f, -5.37867606e-01f, -1.32619347e-02f, -3.88549805e-01f, -3.81564796e-01f, -2.23562121e-01f, 1.68376938e-01f, -2.97151446e-01f,
  -2.24666409e-02f, -1.71005651e-01f, 3.47283125e-01f, -2.89194643e-01f, 5.78983843e-01f, -5.76000325e-02f, 7.48503327e-01f, 1.67902827e-01f, -2.75392205e-01f, 3.16949263e-02f,
  -2.33810499e-01f, -4.18083489e-01f, -2.63164610e-01f, -1.06563546e-01f, -2.60244869e-02f, -1.42713264e-01f, -3.63235027e-01f, -1.42473236e-01f, 2.72965953e-02f, -2.40993664e-01f,
  -1.94477409e-01f, 3.49359423e-01f, 7.17765689e-02f, -3.78259420e-01f, 4.45509821e-01f, -2.24161059e-01f, 2.26755068e-01f, 7.92334497e-01f, 2.24914506e-01f, 3.30177128e-01f,
  -3.03562194e-01f, 4.53395583e-02f, 1.24332331e-01f, 1.13961279e-01f, 2.30705574e-01f, -4.58857954e-01f, 5.54053128e-01f, 8.73325467e-02f, -4.66948271e-01f, 9.40166935e-02f,
  3.20187718e-01f, -3.49950530e-02f, -1.18338298e-02f, -4.85009581e-01f, 1.48354158e-01f, 2.05067009e-01f, 3.35123509e-01f, -4.84627366e-01f, -5.62505364e-01f, 1.93981141e-01f,
  -4.34634835e-01f, -2.88211465e-01f, -2.78200686e-01f, -4.67232108e-01f, -3.12793374e-01f, -7.65713304e-02f, -2.12929383e-01f, -6.42243922e-01f, 2.75090188e-01f, -1.50210962e-01f,
  8.32205176e-01f, 3.28447632e-02f, -3.78388137e-01f, -4.33563620e-01f, -8.41597468e-02f, -2.60238141e-01f, -2.22394004e-01f, -6.42243683e-01f, -3.16842318e-01f, 5.46295680e-02f,
  -2.81792492e-01f, -1.64712161e-01f, 5.10394216e-01f, -5.86119201e-03f, 1.29493088e-01f, 3.59300762e-01f, 1.09976884e-02f, -2.20675617e-01f, 4.01423760e-02f, -1.15627505e-01f,
  1.65679634e-01f, 1.46912292e-01f, -1.75143350e-02f, 3.22721392e-01f, 4.72264647e-01f, 7.01464355e-01f, -5.56176640e-02f, -1.56742960e-01f, 4.68524158e-01f, -7.72357062e-02f,
  6.35893550e-04f, 4.10016537e-01f, -2.63029337e-01f, -1.69311717e-01f, -3.90226990e-01f, -3.88590425e-01f, -7.04913437e-02f, -2.63710380e-01f, -6.98131928e-03f, 4.93554413e-01f,
  6.80598140e-01f, 1.23184942e-01f, 1.42110601e-01f, 1.70836046e-01f, -6.33017957e-01f, -7.01329410e-02f, 7.72298872e-01f, -3.12751532e-01f, -2.24618807e-01f, -3.49477716e-02f,
  -1.90450206e-01f, -3.48208025e-02f, -1.61358804e-01f, 2.26049215e-01f, -2.04328433e-01f, -5.67592010e-02f, 7.30797827e-01f, 1.60428315e-01f, -2.23382294e-01f, -3.16809982e-01f,
  -5.59463501e-02f, -2.59513140e-01f, -5.13573468e-01f, 7.40387142e-02f, 2.73534715e-01f, 1.61977589e-01f, 3.98585737e-01f, -3.91878158e-01f, -1.49153128e-01f, 4.63594764e-01f,
  -3.62092078e-01f, 4.28279251e-01f, -4.31567192e-01f, -3.46635245e-02f, -2.98911422e-01f, 2.41101272e-02f, -2.76015371e-01f, -1.68189802e-03f, -5.81989110e-01f, 7.43265986e-01f,
  4.20410484e-01f, -2.08583906e-01f, 4.55889851e-01f, 2.39284977e-01f, 4.63946193e-01f, 2.28852510e-01f, 4.77482051e-01f, 6.29719019e-01f, -2.72079796e-01f, -3.32813561e-01f,
  -2.97201961e-01f, -2.04266445e-03f, 4.84912276e-01f, 2.21637338e-01f, -9.50940698e-02f, 5.92753850e-02f, -1.56879678e-01f, -2.68312812e-01f, 2.21270964e-01f, -3.25214505e-01f,
  9.24779475e-02f, 9.69576910e-02f, -3.27377975e-01f, -5.09433031e-01f, -2.29020700e-01f, -6.40037805e-02f, 1.14320353e-01f, 3.08636248e-01f, 1.06748748e+00f, -6.16269819e-02f,
  -5.09634733e-01f, -6.41113147e-02f, -2.83840626e-01f, -1.04866005e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -9.53377783e-02f, -1.05898850e-01f, 8.27866718e-02f, 1.87739136e-03f, 1.30556421e-02f, 1.17513902e-01f, 1.95604369e-01f, -2.94774503e-01f, 2.01773867e-01f, 9.95388255e-02f,
  -1.40140876e-01f, 3.29102635e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    