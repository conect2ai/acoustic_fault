/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -6.62802756e-02f, 1.99350372e-01f, -1.35648688e-02f, -1.88891649e-01f, -3.44941877e-02f, 9.70649626e-03f, 1.54259577e-01f, 1.27847731e-01f, -7.83150792e-02f, 2.49744933e-02f,
  -3.44384089e-02f, -1.33369580e-01f, -5.18424623e-02f, 2.55045369e-02f, 9.26019996e-02f, -1.33813508e-02f, 2.47491114e-02f, -1.95820276e-02f, -6.76015392e-02f, -1.09430663e-01f,
  -1.63696501e-02f, -5.17333262e-02f, -1.22398064e-02f, 2.61637419e-02f, -9.62736383e-02f, -2.26934642e-01f, 2.00385395e-02f, -3.64061072e-02f, 9.99341998e-03f, -8.30883607e-02f,
  -2.68993080e-01f, 1.79476231e-01f, -1.14899352e-01f, -9.70289558e-02f, 7.80209526e-02f, 2.47502178e-02f, -8.65271166e-02f, 1.57520846e-02f, 6.46770075e-02f, -1.78461913e-02f,
  -3.02488729e-02f, -4.87997755e-02f, -7.14463145e-02f, -6.23202100e-02f, 2.11428553e-02f, -2.47670896e-03f, 1.58359021e-01f, 1.34527177e-01f, 4.19804789e-02f, -1.71862226e-02f,
  1.90187134e-02f, 7.69198015e-02f, 1.49315283e-01f, 8.91105086e-02f, 1.39974188e-02f, -2.16166978e-03f, 1.14848129e-01f, 4.27277461e-02f, 8.08188021e-02f, -4.72855009e-03f,
  -2.88153160e-02f, -1.14906095e-01f, 8.36667567e-02f, 3.79691832e-02f, -2.19949149e-02f, -8.13354775e-02f, 1.68865509e-02f, -6.12808317e-02f, -1.08965479e-01f, 7.79028758e-02f,
  -3.84037867e-02f, 1.98070668e-02f, 1.01728395e-01f, -1.61456205e-02f, -1.42882451e-01f, -7.21674487e-02f, 1.22959120e-03f, -3.84127372e-03f, -4.19568904e-02f, 3.38680632e-02f,
  1.08794617e-02f, -7.40543976e-02f, 4.10116836e-02f, 6.15504235e-02f, 2.59244051e-02f, 1.07001476e-01f, 3.02952826e-02f, 1.44324660e-01f, -3.39177139e-02f, -2.88026836e-02f,
  -1.69642240e-01f, 1.52337119e-01f, -2.75647789e-01f, -9.24255624e-02f, 5.36468402e-02f, 2.99231913e-02f, -1.84346527e-01f, 7.00049102e-02f, 2.66882358e-03f, -8.73255655e-02f,
  -3.20492610e-02f, -1.95935145e-01f, -9.97799262e-02f, -3.06812557e-03f, -5.76194897e-02f, -1.04051538e-01f, -6.09248644e-04f, -7.28961229e-02f, -4.03183252e-02f, 6.53104559e-02f,
  1.22161582e-01f, 9.78153050e-02f, -1.13125719e-01f, -9.38663706e-02f, 2.47497484e-02f, -1.79195583e-01f, -1.31468445e-01f, -1.57835737e-01f, -2.51026209e-02f, -6.08996898e-02f,
  -4.33856761e-03f, 2.40749475e-02f, 6.31676689e-02f, 6.26527965e-02f, 7.15331286e-02f, 1.77971631e-01f, 1.65783122e-01f, 2.42371082e-01f, 2.15298086e-01f, 2.19021901e-01f,
  -2.77123917e-02f, -2.20898315e-01f, -2.52525151e-01f, -2.06284687e-01f, -1.17889084e-01f, 3.97155769e-02f, 1.10509127e-01f, -1.84924752e-01f, -2.59082168e-01f, -9.12373587e-02f,
  1.92116499e-02f, 8.28830153e-02f, 1.24341026e-01f, 3.50468755e-02f, 2.45151982e-01f, -1.16637154e-02f, 2.87439287e-01f, 2.00389341e-01f, 2.57782340e-02f, -1.10346247e-02f,
  -1.51043320e-02f, 8.17819610e-02f, -2.05126822e-01f, -2.06512347e-01f, -6.05102554e-02f, 3.47395651e-02f, 1.75893772e-02f, -2.68569160e-02f, -4.88458015e-02f, 7.70113692e-02f,
  -9.37492698e-02f, -4.54966873e-02f, -9.60599408e-02f, 1.05160223e-02f, 4.97698784e-02f, -6.94177672e-02f, 8.24321806e-02f, 2.23119184e-02f, 4.05324176e-02f, -5.65558719e-03f,
  -1.03689060e-01f, 1.93507820e-02f, 2.04065815e-02f, -6.09742478e-02f, 8.01535845e-02f, -1.20714180e-01f, -5.92247806e-02f, -5.92421256e-02f, 3.17235254e-02f, 5.13574444e-02f,
  -6.31799102e-02f, -1.61597222e-01f, -6.24148287e-02f, 1.04188114e-01f, -1.22309783e-02f, 1.27212450e-01f, 4.35319683e-03f, 3.02420612e-02f, 5.23406155e-02f, 1.34050354e-01f,
  -4.08864059e-02f, 9.39471126e-02f, 1.00173146e-01f, 1.60607398e-01f, 7.25934133e-02f, 1.97724357e-01f, -4.00003232e-02f, 5.25418334e-02f, -2.86465604e-02f, 1.29365444e-01f,
  5.23580983e-02f, -3.90354320e-02f, 2.04788875e-02f, 2.94196215e-02f, 1.24013029e-01f, 4.46388731e-03f, 1.73728898e-01f, 4.63100150e-02f, -7.95647278e-02f, 5.21223992e-02f,
  1.22168334e-02f, -1.47170395e-01f, -3.42791043e-02f, -1.55619413e-01f, -6.70985654e-02f, -3.57665904e-02f, 3.56339337e-03f, 9.06938221e-03f, -1.21020582e-02f, -1.03206821e-01f,
  -1.28774330e-01f, -4.58415821e-02f, -1.48566887e-02f, -7.85205420e-03f, -1.74647540e-01f, -3.56320925e-02f, 4.91696745e-02f, -1.07471973e-01f, -1.59491658e-01f, 3.34356166e-02f,
  -1.09391384e-01f, -4.84358519e-02f, -2.16015596e-02f, -6.12349845e-02f, 5.53059652e-02f, -1.37409821e-01f, -1.46012649e-01f, -2.42383908e-02f, -1.51043072e-01f, -1.02171730e-02f,
  -3.27706486e-01f, -2.93727785e-01f, -1.28492862e-02f, 8.89925212e-02f, 8.17649439e-03f, -3.56382579e-02f, -3.34446907e-01f, -2.36920998e-01f, 5.85802794e-02f, -6.44685775e-02f,
  8.98283571e-02f, 2.95529932e-01f, 2.44333848e-01f, 2.21463323e-01f, -1.77417919e-01f, -1.18744902e-01f, -1.17021307e-01f, -3.25741395e-02f, 6.05819821e-02f, -3.52695631e-03f,
  5.38547412e-02f, -1.16359800e-01f, -1.85379878e-01f, -2.12370753e-02f, -4.61258478e-02f, 1.07163303e-01f, -9.61954892e-02f, 6.31392524e-02f, 1.22481678e-02f, 2.00673506e-01f,
  2.62405984e-02f, -2.34302804e-01f, 9.44912806e-02f, 8.55066627e-02f, 7.13781640e-02f, -8.31701681e-02f, 8.02952703e-03f, -7.14449883e-02f, 1.43265426e-02f, -8.22895691e-02f,
  1.28817752e-01f, 4.18667588e-03f, 5.16223982e-02f, 3.43758538e-02f, -1.00380495e-01f, -1.38508096e-01f, -1.13465972e-01f, -1.06121980e-01f, 5.97539805e-02f, -5.56201637e-02f,
  7.70965591e-02f, 1.13963904e-02f, -3.44175287e-02f, -6.59771338e-02f, -3.99532467e-02f, 1.72595471e-01f, -1.82946753e-02f, 6.90280944e-02f, 3.58227305e-02f, -7.64098242e-02f,
  -2.44288072e-02f, 5.54955415e-02f, 2.51734983e-02f, -5.39467409e-02f, 8.07249825e-03f, -8.18421878e-03f, -4.80430424e-02f, -1.23688146e-01f, -7.68667608e-02f, -8.28179568e-02f,
  1.47073914e-03f, -9.14807469e-02f, -1.95059646e-02f, -9.38891470e-02f, -1.72978882e-02f, -2.45279279e-02f, -3.96246053e-02f, 5.32352971e-03f, -1.21482518e-02f, -4.99558076e-02f,
  -7.32786506e-02f, -5.05596027e-02f, -4.10338789e-02f, 2.96992045e-02f, -1.18449032e-01f, -3.89360785e-02f, 3.05572618e-03f, -7.15227872e-02f, 4.35531959e-02f, -7.61393830e-02f,
  -3.16644162e-02f, 3.81707889e-03f, 3.86143774e-02f, 1.13959201e-02f, 1.08400248e-01f, 1.20938055e-01f, 1.09397620e-01f, 5.90314083e-02f, 1.13551967e-01f, 1.17063396e-01f,
  -4.65667062e-02f, 3.55136730e-02f, 3.57042812e-02f, -1.06592812e-02f, 1.06814548e-01f, -9.74450447e-03f, 1.31657375e-02f, 1.11830831e-01f, 5.91023676e-02f, 3.61546949e-02f,
  8.32593255e-03f, -1.93187818e-02f, -3.75384726e-02f, 2.32406892e-03f, 4.93591912e-02f, 1.73128024e-02f, 3.42085771e-02f, 1.13801867e-01f, -2.86755133e-02f, -1.50965929e-01f,
  7.19606653e-02f, 7.78809190e-02f, 3.06167215e-01f, -2.55485997e-02f, 8.55668485e-02f, 2.68301934e-01f, 4.20134366e-01f, 1.73334796e-02f, -1.75292030e-01f, 6.30521625e-02f,
  -7.45289773e-02f, -2.99040586e-01f, -2.73064435e-01f, -2.15282794e-02f, 5.52598620e-03f, 2.36741662e-01f, 1.60193041e-01f, 2.38883436e-01f, 1.15307327e-02f, 4.07960638e-02f,
  2.15849634e-02f, 1.19471766e-01f, 7.58926943e-02f, -3.91073599e-02f, -4.03037779e-02f, -1.91724762e-01f, -1.25297038e-02f, -6.51725894e-03f, 7.20403120e-02f, 4.05938253e-02f,
  -1.38465017e-02f, 6.68375045e-02f, -3.74875739e-02f, 6.52451441e-02f, 3.34322676e-02f, -3.08706723e-02f, 1.26791731e-01f, 2.99866907e-02f, -1.12765767e-01f, 5.53019270e-02f,
  -1.54203363e-02f, -7.52942031e-03f, -4.99018207e-02f, 1.04228640e-02f, 1.34589151e-01f, 4.29474935e-02f, 8.70382562e-02f, 1.50575876e-01f, 9.09667537e-02f, 5.60733639e-02f,
  3.53261568e-02f, 1.52455434e-01f, 2.15888754e-01f, 9.51757655e-02f, 1.73414126e-01f, -4.05298322e-02f, 1.76009819e-01f, 9.44341868e-02f, 1.31263733e-01f, 1.19745083e-01f,
  8.88394099e-03f, 8.15153960e-03f, -3.49888243e-02f, 5.26874848e-02f, 5.69021404e-02f, -5.05192317e-02f, 1.21150669e-02f, 5.59819229e-02f, 8.59124062e-04f, 1.32659644e-01f,
  -7.96693712e-02f, 7.45621398e-02f, 6.88160509e-02f, -4.32135761e-02f, 1.80308893e-02f, 4.12118919e-02f, 4.48064804e-02f, -1.07881995e-02f, 6.60424605e-02f, -1.31504340e-02f,
  -4.62715840e-03f, 7.30013996e-02f, -3.34597193e-02f, 5.33133112e-02f, 8.03145692e-02f, 5.11273704e-02f, 4.67230268e-02f, 8.88380185e-02f, 5.33856228e-02f, 7.88431242e-02f,
  -2.97134727e-01f, 1.34124830e-01f, 2.54277959e-02f, 1.33165140e-02f, 3.64903472e-02f, -1.31900892e-01f, -2.23226417e-02f, 3.75373624e-02f, -1.34979367e-01f, 9.47722942e-02f,
  5.72971143e-02f, 5.82778975e-02f, -4.20169048e-02f, 1.13761961e-01f, 1.01869047e-01f, -3.58985341e-03f, -3.21710110e-02f, -1.12616001e-02f, 7.98222125e-02f, 1.02930158e-01f,
  -6.01580888e-02f, 1.83512121e-01f, -3.41077559e-02f, -4.35193861e-03f, 2.61983499e-02f, 2.14564260e-02f, 3.80008779e-02f, 1.30601963e-02f, 5.39121330e-02f, 8.57239664e-02f,
  5.19763887e-01f, 2.54490912e-01f, -4.70763855e-02f, 1.72301427e-01f, 4.10065912e-02f, -2.12058336e-01f, -1.09956667e-01f, 6.32958636e-02f, 9.03441161e-02f, -3.89613211e-02f,
  -4.96720634e-02f, -2.84868572e-02f, 6.90050870e-02f, -1.38500363e-01f, 3.58236134e-02f, -4.83309068e-02f, 2.79385746e-02f, -6.59796000e-02f, -2.17058599e-01f, -2.45806858e-01f,
  -1.91549048e-01f, -7.79835209e-02f, 7.03126891e-03f, 4.87538092e-02f, 7.56966025e-02f, -9.19486359e-02f, 6.22191317e-02f, 3.34533527e-02f, -2.21342240e-02f, 5.67751601e-02f,
  -1.09412722e-01f, 1.94188401e-01f, -4.05763201e-02f, 1.04724221e-01f, 1.77011549e-01f, 6.05386682e-02f, 8.22649300e-02f, 7.60884732e-02f, 1.52302489e-01f, 1.49401709e-01f,
  1.12538084e-01f, 6.45802245e-02f, 7.91150331e-02f, 1.99383590e-02f, 9.33676660e-02f, 5.73105812e-02f, 9.44568217e-02f, 8.20670947e-02f, 2.10216478e-01f, 7.35890642e-02f,
  9.30979475e-02f, 7.81676546e-02f, 6.08528219e-02f, -5.57673117e-03f, 1.47160396e-01f, 2.28218772e-02f, -1.96378566e-02f, 1.48541853e-01f, 3.87405232e-02f, 1.22041635e-01f,
  -5.15115522e-02f, -1.59209371e-02f, -6.86707571e-02f, -2.58806050e-02f, 1.62990298e-02f, 1.91678219e-02f, 1.55129284e-01f, -9.79488492e-02f, -8.33384544e-02f, 9.20114890e-02f,
  6.00025337e-03f, 4.56263963e-03f, 3.88967618e-02f, 5.26160793e-03f, -8.26552585e-02f, 3.19234468e-02f, -4.06174064e-02f, -1.17031597e-02f, 1.21131636e-01f, 1.31962508e-01f,
  5.17442748e-02f, 8.26758072e-02f, -3.70007530e-02f, 4.81602512e-02f, 6.93309829e-02f, -9.41283703e-02f, 1.31921330e-02f, -1.18201770e-01f, -1.62147696e-03f, -1.64707571e-01f,
  -2.12936196e-02f, 3.05249933e-02f, -4.15924639e-02f, 3.48438919e-02f, 1.11834668e-01f, 2.00705111e-01f, 1.59389004e-01f, 1.09669074e-01f, 7.39434883e-02f, 3.87089662e-02f,
  3.74943875e-02f, 1.02978542e-01f, 5.18858954e-02f, 4.64495048e-02f, -1.76323187e-02f, -6.30211011e-02f, -1.44697065e-02f, 5.09178489e-02f, 1.12608738e-01f, 5.82207404e-02f,
  2.19776258e-02f, -1.34480044e-01f, -6.36582822e-02f, 5.57895079e-02f, 2.74031591e-02f, -6.28290400e-02f, -7.87742287e-02f, -1.19201623e-01f, -7.11824894e-02f, -1.22878179e-01f,
  -3.67266297e-01f, -3.07392776e-01f, -6.50836015e-03f, 1.24118917e-01f, -8.73876140e-02f, 7.67029002e-02f, -1.29744694e-01f, -1.20192833e-01f, 1.38627961e-01f, -8.28804076e-03f,
  4.26326729e-02f, 2.54891515e-01f, 2.80443639e-01f, 2.83124059e-01f, 1.55021131e-01f, 1.89161878e-02f, 4.69356515e-02f, 9.70130712e-02f, 2.21640840e-01f, 2.60344017e-02f,
  1.00080937e-01f, 9.11940727e-03f, -2.06692889e-02f, -1.60932317e-02f, -2.75006648e-02f, 2.43628591e-01f, 5.84282912e-02f, -2.58351658e-02f, 8.96981210e-02f, 1.67137489e-01f,
  1.53730467e-01f, -7.04054236e-02f, 2.00257584e-01f, 1.24927163e-01f, 9.67585519e-02f, -3.64767313e-02f, 1.09487645e-01f, 7.91918710e-02f, 9.45662335e-02f, -2.96595525e-02f,
  4.32991721e-02f, 5.19072674e-02f, 1.15194045e-01f, 1.79915354e-02f, -7.08981305e-02f, 5.61489575e-02f, -1.71213634e-02f, -3.62160825e-03f, -1.07688308e-02f, -2.26273462e-02f,
  4.19766791e-02f, 5.99021241e-02f, 3.92943993e-02f, 1.00204580e-01f, 7.20088705e-02f, 1.76663801e-01f, 1.48976460e-01f, 3.88849936e-02f, 1.12124234e-01f, 7.51594305e-02f,
  4.04315703e-02f, -3.08714733e-02f, 1.39212050e-02f, -3.88981141e-02f, -3.07376329e-02f, -8.29304084e-02f, -3.80167514e-02f, -5.20558171e-02f, -3.65875438e-02f, -2.64224224e-02f,
  -8.41004699e-02f, 1.09293293e-02f, -6.42449558e-02f, -1.02111012e-01f, 6.89495504e-02f, -4.40374874e-02f, 3.32959257e-02f, 3.41830589e-02f, 4.70213182e-02f, -1.31280944e-01f,
  -3.88325751e-02f, 1.33086637e-01f, -6.28363267e-02f, -1.31407399e-02f, -9.57476273e-02f, 4.33079787e-02f, -8.69330391e-02f, -8.79274830e-02f, -1.13797069e-01f, -5.00069447e-02f,
  1.12575978e-01f, 1.25804096e-01f, 1.35148212e-01f, 6.98620155e-02f, 1.65324882e-01f, 8.66101384e-02f, 9.40384120e-02f, 1.34313062e-01f, 2.59037074e-02f, 9.66534112e-03f,
  3.66937704e-02f, 1.80272341e-01f, 1.00922406e-01f, 1.36438444e-01f, 1.28417864e-01f, 1.22906163e-01f, -2.15880852e-02f, 1.38003692e-01f, 9.45203602e-02f, 1.33847715e-02f,
  -3.28140408e-02f, -6.16500154e-02f, 3.69774066e-02f, 1.33814633e-01f, 3.67521644e-02f, 8.46944749e-02f, 1.37555912e-01f, 3.44256908e-02f, 2.00403318e-01f, 1.16407927e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.71530887e-01f, -2.36743405e-01f, -1.32518813e-01f, -3.33545744e-01f, -1.08759433e-01f, 8.23380128e-02f, 3.36948372e-02f, 5.85251004e-02f, -5.44620641e-02f, -1.70858592e-01f,
  4.50636353e-03f, 9.55898762e-02f, 1.37130931e-01f, 1.49610654e-01f, 1.54813990e-01f, -8.50462988e-02f, -2.69036591e-01f, -3.54403965e-02f, 2.11910069e-01f, 2.22393334e-01f,
  5.50341886e-03f, 3.49488109e-03f, -9.47596282e-02f, 6.34654388e-02f, -1.99192345e-01f, -4.13332283e-02f, -2.52882153e-01f, -5.01304083e-02f, 6.97389664e-03f, -2.31370062e-01f,
  1.39004588e-01f, -9.12935659e-02f, -9.35573652e-02f, -2.36114666e-01f, -9.24912244e-02f, -1.27456769e-01f, 6.21899031e-02f, -1.19260848e-01f, -1.64934233e-01f, 1.90879684e-02f,
  -1.25084057e-01f, 3.22212316e-02f, -1.94401965e-02f, 8.61455724e-02f, -1.42588601e-01f, 1.40812919e-01f, 4.38877307e-02f, -3.25713232e-02f, -1.27345711e-01f, 2.72033587e-02f,
  2.62363460e-02f, -1.95718512e-01f, -1.89367980e-01f, -7.35944659e-02f, 1.38163753e-02f, 9.23330337e-03f, -3.43547948e-02f, -4.94537689e-02f, -5.82141913e-02f, -2.86967367e-01f,
  7.62780234e-02f, -5.94365001e-02f, -8.99271853e-03f, 9.36006382e-03f, 1.04143275e-02f, 4.44458006e-03f, 1.75904576e-02f, -8.04199930e-03f, 5.58336787e-02f, 8.18260945e-03f,
  -1.36423305e-01f, -1.09029293e-01f, 4.65516467e-03f, -5.63520491e-02f, -7.14527890e-02f, -3.33558209e-02f, -3.15080769e-02f, 3.07843229e-03f, -3.28612402e-02f, -2.39010267e-02f,
  -1.31022751e-01f, -2.84451991e-02f, -6.27370104e-02f, -2.49055941e-02f, -4.47985791e-02f, -4.71996069e-02f, -3.72304320e-02f, 7.69292787e-02f, 3.22717205e-02f, -6.71126023e-02f,
  1.02323964e-01f, 1.97633542e-02f, -1.11696467e-01f, 2.75942534e-02f, 1.00581646e-02f, -1.15607224e-01f, -1.37053179e-02f, 2.63244882e-02f, 4.84666564e-02f, 1.07473381e-01f,
  2.36341488e-02f, 7.11206570e-02f, -1.22826114e-01f, 9.11253318e-02f, -5.23206592e-03f, 9.30081308e-02f, 3.18971351e-02f, 9.18952003e-03f, -8.99244025e-02f, 6.74125031e-02f,
  -1.19442254e-01f, -3.55097502e-02f, 6.61470667e-02f, 5.79912812e-02f, 4.27179635e-02f, 4.50333254e-03f, 1.31794721e-01f, 1.25934571e-01f, 1.96618542e-01f, 4.57362719e-02f,
  -4.10861820e-01f, 1.51797548e-01f, 3.14178457e-03f, 7.02440292e-02f, 7.51735941e-02f, 1.44639162e-05f, -5.73511645e-02f, 1.73333921e-02f, 1.89509511e-01f, 3.87495309e-02f,
  -2.42624003e-02f, -2.93827206e-01f, -1.50775433e-01f, -2.21049890e-01f, -4.02638286e-01f, -1.31771713e-02f, -9.61172301e-03f, -2.74950087e-01f, -4.44718122e-01f, -2.81968713e-01f,
  -1.87565848e-01f, -2.09782735e-01f, -3.54733229e-01f, -1.63970098e-01f, 6.33925796e-02f, -1.32352680e-01f, 1.06806383e-01f, -6.28292859e-02f, -9.74401645e-03f, 2.56462079e-02f,
  -7.33816922e-02f, -2.98937038e-02f, 1.06240176e-02f, -6.33046255e-02f, -1.07131980e-03f, -2.07448341e-02f, 4.79797684e-02f, 2.16202382e-02f, 7.87070543e-02f, 1.04474671e-01f,
  3.31867523e-02f, 2.16096044e-02f, -1.15481459e-01f, 3.35900970e-02f, -1.92105860e-01f, -3.26567926e-02f, 9.03475955e-02f, -1.07535850e-02f, 2.33111829e-02f, 1.93979815e-01f,
  -1.59649947e-03f, 8.19680169e-02f, -1.85185615e-02f, -2.31667366e-02f, 3.48194651e-02f, -8.05113092e-02f, 1.31022647e-01f, 8.74384493e-02f, 7.75090903e-02f, 1.32657558e-01f,
  1.37998596e-01f, 7.39200488e-02f, 3.31612229e-02f, 4.28706495e-04f, -6.23277761e-02f, 2.40279343e-02f, -1.29285287e-02f, 5.24575114e-02f, -8.28436613e-02f, 1.09997474e-01f,
  1.78020194e-01f, -8.11769664e-02f, 4.67682593e-02f, -4.82631437e-02f, -8.27767849e-02f, 1.02614194e-01f, 7.09373653e-02f, -5.95183969e-02f, -5.39478883e-02f, 7.20423236e-02f,
  -4.83390354e-02f, 2.05901220e-01f, -3.36795077e-02f, -2.25963630e-02f, 2.15834733e-02f, 1.22970603e-02f, 8.06284845e-02f, 4.85426225e-02f, 1.53380837e-02f, -1.67764332e-02f,
  -2.11003795e-01f, -2.02852711e-01f, -6.26088306e-02f, 2.85891909e-02f, 5.28664403e-02f, 5.03715910e-02f, 9.91861243e-03f, 2.78418176e-02f, 7.24960864e-02f, 1.05356283e-01f,
  3.12379729e-02f, 8.64520967e-02f, -4.17391434e-02f, 7.91030824e-02f, -1.28779918e-01f, 1.55293550e-02f, 3.58912684e-02f, -5.70518635e-02f, -3.52799781e-02f, 1.66461274e-01f,
  1.32717997e-01f, 1.43560037e-01f, -8.42095613e-02f, 1.09312877e-01f, 9.40146968e-02f, -8.27443078e-02f, -1.19991846e-01f, 1.01955608e-01f, -6.87509179e-02f, 2.41013281e-02f,
  -2.49868438e-01f, -3.88951004e-01f, 2.15724871e-01f, -1.99850380e-01f, 5.09149283e-02f, 1.94889888e-01f, 2.38942847e-01f, -4.92272936e-02f, -1.53426856e-01f, -5.20933121e-02f,
  -1.44778281e-01f, -7.49172717e-02f, -9.42050889e-02f, -4.75515760e-02f, 5.99012561e-02f, 7.36072063e-02f, 1.22173531e-02f, 1.98346347e-01f, 2.91291505e-01f, 1.52731746e-01f,
  -6.82543144e-02f, -1.45967245e-01f, -3.21108885e-02f, -1.81684405e-01f, -3.31758529e-01f, -8.57078731e-02f, -9.98485535e-02f, -2.12085322e-01f, -1.75913379e-01f, -2.67351955e-01f,
  -1.36143610e-01f, 4.88199554e-02f, 2.43666619e-01f, 3.61422636e-02f, -1.36626102e-02f, -1.03984028e-01f, -5.43517880e-02f, -2.38289535e-01f, -1.56289577e-01f, 4.76112589e-02f,
  -4.86473888e-02f, -1.61703881e-02f, -8.94594043e-02f, 2.67052534e-03f, -5.93775213e-02f, -6.60451362e-03f, 5.13015240e-02f, 1.00053132e-01f, 1.40221357e-01f, 1.11704171e-01f,
  1.31253377e-01f, 1.10707894e-01f, 4.35815342e-02f, 3.54293704e-01f, 1.46294266e-01f, 2.15759918e-01f, 1.56759620e-01f, 1.65716082e-01f, 2.53654391e-01f, 5.84189929e-02f,
  9.90234688e-02f, -4.63008918e-02f, 6.18116930e-02f, 1.64745897e-02f, 2.09720433e-02f, 9.41529572e-02f, -3.28254364e-02f, -5.54915369e-02f, 9.81654152e-02f, 1.65687017e-02f,
  -5.76688573e-02f, 1.57244489e-01f, 1.97159588e-01f, -8.48562345e-02f, -8.82167518e-02f, 6.70466498e-02f, -4.08219397e-02f, -6.81621283e-02f, 2.30962571e-04f, 2.21020970e-02f,
  -6.51241513e-03f, -1.71269160e-02f, -1.30537197e-01f, 3.84555534e-02f, 5.57126664e-02f, 4.86368611e-02f, -9.62665007e-02f, -2.73012612e-02f, -1.43639997e-01f, 1.29279131e-02f,
  -2.90384173e-01f, 4.62935299e-01f, -2.05074415e-01f, -4.05686982e-02f, -1.57342881e-01f, -4.87515293e-02f, -7.85640329e-02f, -8.30806568e-02f, -2.06408247e-01f, -7.34658316e-02f,
  3.32849957e-02f, -7.95567930e-02f, -8.48253220e-02f, 4.53082621e-02f, -2.14211307e-02f, 1.03852833e-02f, -5.12828790e-02f, 1.92411616e-02f, 1.30843028e-01f, 3.01372372e-02f,
  -4.75672968e-02f, 1.49426728e-01f, 9.83699337e-02f, 4.39498648e-02f, 1.10545233e-01f, 1.34820305e-03f, 2.80050747e-03f, -1.01789953e-02f, 1.09060951e-01f, -1.28101319e-01f,
  2.16458648e-01f, 3.12180191e-01f, 2.54467696e-01f, 2.53635971e-03f, 1.64963365e-01f, 1.26094595e-01f, 1.45528570e-01f, -8.74297693e-03f, -1.29398599e-01f, 1.26129240e-01f,
  3.42356861e-01f, -1.14573158e-01f, -1.34831984e-02f, -1.42302573e-01f, -1.52164072e-01f, 5.10532372e-02f, -9.33029652e-02f, -9.53071415e-02f, -2.75867224e-01f, -7.40623847e-02f,
  -2.12285385e-01f, -4.82239984e-02f, -8.55383724e-02f, -1.42778620e-01f, 3.28043699e-02f, -2.14290380e-01f, 1.33988231e-01f, 1.06358595e-01f, 8.55733454e-02f, 7.39591271e-02f,
  2.87203372e-01f, 3.57800215e-01f, -1.86259568e-01f, -3.59520949e-02f, 8.25258195e-02f, -1.12793572e-01f, -1.08026914e-01f, -5.00931181e-02f, -3.66455093e-02f, -5.44559658e-02f,
  2.18433097e-01f, 1.84909225e-01f, 4.41916995e-02f, 3.04003768e-02f, -2.98246630e-02f, -1.60140753e-01f, 7.34714745e-03f, -1.09759100e-01f, -1.57257598e-02f, 3.68978456e-02f,
  -5.25857210e-02f, 7.82980621e-02f, 2.39300966e-01f, 1.88138261e-02f, -5.12168780e-02f, -1.63809285e-01f, 2.41679803e-01f, 1.63609073e-01f, 7.82176629e-02f, 4.93185967e-02f,
  -5.17423488e-02f, 9.36034918e-02f, 7.93098584e-02f, -2.97496617e-02f, -4.16129753e-02f, 5.74496090e-02f, -4.87191491e-02f, -8.29593465e-02f, -8.01186892e-04f, 7.32701831e-03f,
  8.36690702e-03f, -2.88919061e-02f, -3.13651562e-02f, 4.37017344e-02f, 5.41450875e-03f, -1.37981698e-02f, -8.42616558e-02f, -8.02319571e-02f, -5.79183064e-02f, -2.03908049e-02f,
  -1.14112929e-01f, -7.19056278e-02f, 8.63127708e-02f, -9.21728835e-02f, -1.03908069e-02f, -1.01132110e-01f, -7.77796283e-02f, -8.52417722e-02f, -2.74010804e-02f, 1.28562972e-01f,
  -2.11463302e-01f, 1.52788283e-02f, -4.78591025e-02f, -1.14530459e-01f, 6.54995069e-02f, 1.96408834e-02f, -9.86582972e-03f, -3.45308930e-02f, 3.50189582e-02f, -7.42874146e-02f,
  5.05167022e-02f, -1.26279786e-01f, -2.31292769e-02f, -1.45720586e-01f, -2.74964929e-01f, 2.80948728e-02f, -1.61396582e-02f, -1.59923956e-01f, -1.40402496e-01f, -2.38383580e-02f,
  -1.98555008e-01f, -2.73941934e-01f, -8.99545252e-02f, -1.37603238e-01f, -1.76138818e-01f, -3.29306126e-01f, -9.95988324e-02f, 1.37960352e-02f, -1.02115989e-01f, -3.64374109e-02f,
  5.35360098e-01f, 5.43155521e-02f, -4.56540547e-02f, 3.59228961e-02f, 5.71392141e-02f, -1.31024018e-01f, -4.53950018e-02f, -2.96681561e-03f, -7.77417570e-02f, 1.41342014e-01f,
  -3.88544984e-02f, 9.74384428e-04f, 3.10186539e-02f, -1.01724222e-01f, 1.06799148e-01f, 3.34661058e-03f, 3.30317803e-02f, 1.34989560e-01f, 4.64725718e-02f, 1.78167224e-02f,
  -1.01909405e-02f, 5.65337613e-02f, 1.20629266e-01f, 1.30800279e-02f, 1.25369236e-01f, -5.73754944e-02f, -3.50038297e-02f, 1.20492935e-01f, 8.51908401e-02f, 2.69648135e-01f,
  2.09120899e-01f, 2.63678938e-01f, -2.19844311e-01f, -8.68546441e-02f, 2.79617757e-02f, 9.34824571e-02f, 4.28161398e-02f, -3.67332064e-02f, -9.43299755e-02f, 3.45289931e-02f,
  1.62865564e-01f, 5.91611527e-02f, -1.36328220e-01f, 4.95416857e-03f, -2.89604403e-02f, -8.54537040e-02f, -4.54610847e-02f, 1.11426719e-01f, -4.46889475e-02f, 6.45521507e-02f,
  7.17689544e-02f, 6.40486479e-02f, 8.51972923e-02f, -1.60301670e-01f, -2.28360072e-02f, 6.45543709e-02f, 7.19822869e-02f, 1.74412012e-01f, 7.81592280e-02f, 7.93539882e-02f,
  1.04554139e-01f, 5.12553267e-02f, 1.43552974e-01f, 1.63676292e-01f, 5.77517636e-02f, -5.07459342e-02f, 7.37693235e-02f, 6.04325607e-02f, -5.64793609e-02f, 9.44276229e-02f,
  1.79961640e-02f, 9.32781100e-02f, 6.03321008e-02f, 2.14850083e-02f, 1.74866319e-02f, 2.77677625e-02f, -7.21231401e-02f, 7.35663101e-02f, 4.89047868e-03f, 1.14702794e-03f,
  -5.04489094e-02f, -1.53584667e-02f, 1.46632120e-02f, -5.20247556e-02f, 9.65690892e-03f, -4.34361845e-02f, 1.48568794e-01f, 4.32559773e-02f, 1.52585596e-01f, 1.26495674e-01f,
  -1.37423187e-01f, -2.39696980e-01f, -3.43994088e-02f, -1.88276947e-01f, -8.28227028e-03f, -1.88204013e-02f, -1.63296517e-02f, -1.29211754e-01f, -6.61822706e-02f, 4.89874147e-02f,
  -3.59101817e-02f, -5.49532510e-02f, -1.09237559e-01f, -1.34547353e-01f, -7.85686374e-02f, -6.62616417e-02f, -1.18975878e-01f, -1.75514624e-01f, -1.37422502e-01f, -5.83727323e-02f,
  -8.88256058e-02f, -1.87047899e-01f, -1.84766248e-01f, -1.99961722e-01f, -1.51134938e-01f, 1.61567535e-02f, -5.17336875e-02f, -6.19754121e-02f, -1.64036825e-01f, -7.50370249e-02f,
  4.06088501e-01f, -2.94575840e-01f, -1.49921522e-01f, -3.35540026e-02f, -7.14570805e-02f, -4.86550629e-02f, -2.71641284e-01f, 2.54533030e-02f, 8.28434005e-02f, -3.08654428e-01f,
  -1.61898017e-01f, 2.43273824e-01f, 3.81433181e-02f, 7.13224337e-02f, 7.88397044e-02f, -3.75327885e-01f, -2.38308251e-01f, 1.03943557e-01f, 3.76788586e-01f, 2.28159949e-01f,
  -7.64734820e-02f, 1.27484007e-02f, 1.91053495e-01f, 1.16866842e-01f, -2.31933311e-01f, 3.36594768e-02f, -3.39768171e-01f, -1.48018926e-01f, -2.05961317e-01f, -4.04433906e-01f,
  -1.45146832e-01f, -6.03331253e-03f, 4.30459604e-02f, 7.57043734e-02f, 5.14863059e-02f, 1.86617434e-01f, 4.14534882e-02f, 8.70446116e-03f, 9.92040709e-02f, -1.06441248e-02f,
  -1.06294677e-02f, 2.82541942e-02f, 6.96117580e-02f, -3.29959430e-02f, -1.85927581e-02f, 1.86335128e-02f, -8.68372396e-02f, -3.85229066e-02f, 6.04518019e-02f, -5.97230010e-02f,
  -1.11751854e-01f, -1.93114821e-02f, 2.25835741e-02f, 8.41515064e-02f, 1.74963981e-01f, 9.95248090e-03f, -3.40821892e-02f, 4.94011566e-02f, 1.34919882e-01f, -1.70993105e-01f,
  -9.25236717e-02f, 2.99004149e-02f, -3.88196739e-03f, 8.31469297e-02f, 1.92478057e-02f, -1.57241449e-02f, 1.26391172e-01f, -1.30941337e-02f, -2.09258720e-02f, -3.79694998e-02f,
  -1.97626688e-02f, -6.62732646e-02f, 1.20511085e-01f, -3.61064821e-02f, -7.23625049e-02f, -2.39265675e-04f, -7.63137266e-02f, -3.68455648e-02f, 7.15129524e-02f, 1.48837278e-02f,
  1.17914435e-02f, 4.12861556e-02f, -4.68327515e-02f, 1.33572176e-01f, 1.33665306e-02f, -1.27410283e-02f, -2.11122874e-02f, 7.22637326e-02f, -3.88469659e-02f, -8.34893808e-02f,
  2.86405664e-02f, 5.40817045e-02f, -1.01415880e-01f, 2.39322837e-02f, 9.19898301e-02f, -5.89672625e-02f, -5.24779819e-02f, 1.10447161e-01f, 6.34252951e-02f, -7.49216648e-03f,
  4.85639311e-02f, -2.80867014e-02f, -6.09982759e-02f, -2.25887517e-03f, 2.25980254e-03f, -1.04643349e-02f, -4.79264706e-02f, -2.17360631e-03f, 3.06726620e-02f, -1.76544175e-01f,
  -2.19565585e-01f, 8.51173401e-02f, 1.48908630e-01f, 1.81216337e-02f, -4.75952700e-02f, 4.72919606e-02f, 2.20245477e-02f, 3.48189063e-02f, 1.25566348e-01f, -7.38303214e-02f,
  -1.65105492e-01f, -1.44263759e-01f, 2.50815693e-02f, -1.12886280e-01f, 2.91252255e-01f, 5.33618033e-02f, -1.49490625e-01f, -1.85654581e-01f, -3.89090292e-02f, 4.13002074e-02f,
  2.75145769e-01f, 7.95019493e-02f, 1.25979304e-01f, -1.96840856e-02f, -1.47944331e-01f, -7.85519034e-02f, -1.11538641e-01f, 1.08424714e-02f, -7.02809617e-02f, 1.70277357e-01f,
  9.75410789e-02f, 3.02242860e-02f, -1.60000771e-01f, -1.68389305e-01f, -1.58061370e-01f, -1.56932231e-02f, 3.48339453e-02f, 3.54657788e-03f, 1.06215954e-01f, -4.43268605e-02f,
  1.26017213e-01f, -2.01351076e-01f, 7.09692165e-02f, 1.35443866e-01f, 8.11666995e-02f, -1.33061126e-01f, 2.53970157e-02f, -6.79333657e-02f, 2.77413558e-02f, -1.57703325e-01f,
  3.53373066e-02f, 7.26198480e-02f, -2.36347783e-02f, 2.13167742e-01f, 3.85376103e-02f, -1.22838579e-01f, -1.41616583e-01f, -1.03787258e-01f, -1.97779581e-01f, 1.87411811e-02f,
  -1.78045947e-02f, 7.01991692e-02f, -8.58395621e-02f, -1.59721762e-01f, -1.45414725e-01f, 6.24968857e-03f, -1.54438823e-01f, -1.42838284e-01f, -2.14378193e-01f, -2.34424472e-01f,
  -8.39847326e-02f, -4.92931902e-02f, 6.67296024e-03f, -1.27089441e-01f, -7.51599250e-03f, -6.65506646e-02f, -3.92815992e-02f, 1.80078596e-01f, -1.73626263e-02f, -2.15330329e-02f,
  6.46156222e-02f, 6.27754033e-02f, -8.52148887e-03f, -2.88350265e-02f, -4.85742651e-02f, 3.93919758e-02f, 1.08189590e-03f, -1.22348174e-01f, 4.50695632e-03f, 4.12819441e-03f,
  -2.48616165e-03f, 3.88693996e-02f, -2.32862737e-02f, -7.95685127e-02f, -4.94240522e-02f, 4.52751182e-02f, -6.35113046e-02f, -1.10007077e-01f, -1.46525636e-01f, -3.00344005e-02f,
  -2.14603305e-01f, 1.41823694e-01f, -4.18815874e-02f, -3.43559906e-02f, -6.73826411e-02f, 2.54184678e-02f, 6.92326128e-02f, 7.05084875e-02f, 1.86451167e-01f, -1.09901182e-01f,
  -1.37623504e-01f, -8.46585110e-02f, -1.15944885e-01f, -6.45975098e-02f, 4.44884263e-02f, -1.28368318e-01f, -8.79094973e-02f, 6.03590012e-02f, -5.99917546e-02f, -1.03833683e-01f,
  -8.88388753e-02f, -1.38058722e-01f, -8.93611088e-02f, -1.23059943e-01f, -1.49502397e-01f, -1.63730621e-01f, -1.85277998e-01f, -1.52865306e-01f, -1.72100410e-01f, -2.87425756e-01f,
  4.71276753e-02f, -2.40063742e-01f, -7.28917271e-02f, 1.60742432e-01f, 1.04250990e-01f, 9.15041491e-02f, -3.29601914e-01f, 9.57791805e-02f, 2.72240758e-01f, -1.46511272e-01f,
  -2.63140704e-02f, 1.48049489e-01f, -2.70184986e-02f, 1.51101753e-01f, -9.29810479e-02f, -3.74026239e-01f, -2.02733934e-01f, -4.72450592e-02f, 3.06459308e-01f, 1.38405949e-01f,
  8.32834467e-02f, 1.68433204e-01f, 1.28389448e-01f, 9.36236382e-02f, 3.32780890e-02f, 3.94014232e-02f, -5.64611629e-02f, -3.05610374e-02f, -1.82616770e-01f, -3.71196181e-01f,
  -1.61576733e-01f, 2.09901519e-02f, 2.61736102e-02f, 5.98815270e-02f, -5.87637462e-02f, -6.54593052e-04f, -6.81027621e-02f, 1.04213692e-01f, 4.78024036e-02f, 5.42955808e-02f,
  6.80444837e-02f, 6.73154891e-02f, 1.36204749e-01f, 1.17475383e-01f, 8.09740722e-02f, 6.08093999e-02f, -1.36038261e-02f, 1.97478309e-02f, -1.07953727e-01f, -7.00085387e-02f,
  -1.18650049e-01f, -6.07216619e-02f, -1.00334495e-01f, -1.36390015e-01f, -3.40603455e-03f, 5.79700880e-02f, -6.48680925e-02f, -4.78402153e-02f, -8.93486887e-02f, -2.93756992e-01f,
  4.06285934e-02f, 6.57948554e-02f, 1.40851364e-01f, 5.18712364e-02f, 6.56143352e-02f, 1.09991645e-02f, 1.18965493e-03f, -5.96760623e-02f, 7.96376020e-02f, 6.71931282e-02f,
  2.25220136e-02f, 5.73661700e-02f, -3.41309011e-02f, -6.98600709e-03f, 6.85019940e-02f, -2.23991871e-02f, -1.19064346e-01f, 1.65643841e-02f, 8.61529112e-02f, 2.38998607e-03f,
  6.01203134e-03f, 1.19369552e-02f, 9.16842073e-02f, 1.37356177e-01f, 4.64603268e-02f, -1.37898477e-03f, -1.87421218e-02f, 2.19914913e-02f, 4.56046201e-02f, 4.35727425e-02f,
  1.96741700e-01f, -3.65072936e-02f, -1.03831343e-01f, 8.14576223e-02f, 4.36472744e-02f, -3.78837921e-02f, -8.06687251e-02f, 1.08459942e-01f, 3.28319259e-02f, -4.12605293e-02f,
  9.88409892e-02f, -1.61846280e-02f, -9.06724110e-02f, -8.02717358e-02f, 3.90108712e-02f, 8.06796327e-02f, -7.67194629e-02f, 2.52505094e-02f, 1.90822352e-02f, 1.59053523e-02f,
  -4.96850349e-03f, -4.99296226e-02f, -1.59172505e-01f, -8.22618753e-02f, -2.29224712e-02f, -1.41257107e-01f, -3.71907763e-02f, -2.06014708e-01f, -1.23268656e-01f, -1.48071095e-01f,
  6.44310176e-01f, -1.85340703e-01f, -2.78766483e-01f, 1.64125010e-01f, -3.88567299e-02f, 1.43486872e-01f, 7.43733570e-02f, 1.04925998e-01f, 1.86564475e-01f, -8.10803473e-02f,
  -3.19895409e-02f, 8.19369406e-02f, 9.55676958e-02f, 4.96565886e-02f, 9.67494175e-02f, -2.68860877e-01f, -2.39093363e-01f, -6.72539324e-03f, 2.71585494e-01f, 1.29718110e-01f,
  -1.97052993e-02f, 3.58940139e-02f, 1.51315838e-01f, -5.90138435e-02f, -2.59920806e-01f, -1.48441587e-02f, -2.44799078e-01f, -1.15525134e-01f, -2.31216103e-01f, -4.08749789e-01f,
  -7.32557476e-02f, -6.06275238e-02f, 1.42163157e-01f, 4.04802896e-02f, -4.77282628e-02f, 1.03516467e-01f, 1.29331993e-02f, -1.34750102e-02f, 1.02071099e-01f, -2.99838316e-02f,
  -4.80868742e-02f, 6.87537063e-03f, 7.02590942e-02f, -1.71336215e-02f, -6.62378743e-02f, 4.99832593e-02f, -9.02963728e-02f, -2.26161554e-02f, 3.01729925e-02f, -5.25334142e-02f,
  -1.23471759e-01f, -8.82587433e-02f, -7.15236589e-02f, -5.69706634e-02f, 7.89578725e-03f, 9.35808942e-02f, -1.81617230e-01f, -6.08425029e-02f, 8.42915177e-02f, -1.26410410e-01f,
  9.80242044e-02f, -1.14083156e-01f, -6.64562955e-02f, 1.56674795e-02f, 8.93781409e-02f, 4.07568403e-02f, -9.34390426e-02f, -2.36954503e-02f, -3.95362601e-02f, -3.76935415e-02f,
  -5.82716502e-02f, -5.62749989e-03f, -6.66682646e-02f, 5.28159514e-02f, -6.38437644e-02f, -6.39121905e-02f, -6.11439757e-02f, -2.44392268e-02f, -3.91254164e-02f, 4.04775739e-02f,
  3.82271335e-02f, 7.30766961e-03f, -6.89133182e-02f, -6.16212338e-02f, -5.91841452e-02f, 1.74265797e-03f, -2.97553577e-02f, 2.95329876e-02f, -4.84438688e-02f, 1.26960054e-01f,
  9.03810114e-02f, -1.61752626e-02f, 7.22457841e-02f, 7.45362490e-02f, -1.01190291e-01f, -1.25753321e-02f, -1.33375600e-01f, -3.89411412e-02f, -1.27729392e-02f, 3.22562605e-02f,
  -5.77686876e-02f, -1.87087506e-02f, -1.19012810e-01f, -6.99341223e-02f, 8.65310729e-02f, 1.95730049e-02f, 4.43415828e-02f, 8.13754722e-02f, -3.13087553e-02f, -2.65458617e-02f,
  -1.23358317e-01f, 1.47782475e-01f, 2.08701834e-01f, 9.28446203e-02f, 3.71255726e-02f, 6.79579824e-02f, 2.42909174e-02f, -5.56433685e-02f, 1.56750828e-01f, 1.73667371e-01f,
  -1.42574266e-01f, 3.66239585e-02f, 1.57920524e-01f, -3.63334157e-02f, 1.13247745e-01f, 1.26320288e-01f, -1.08865716e-01f, 8.64532590e-03f, 5.97222373e-02f, 6.72109472e-03f,
  1.99987069e-02f, -1.40980884e-01f, -2.75551192e-02f, -1.26972184e-01f, -3.27962220e-01f, -1.97327152e-01f, -1.07794888e-01f, -3.37626457e-01f, -3.99221450e-01f, -2.21103370e-01f,
  -1.51455123e-02f, -2.01004952e-01f, -2.51003295e-01f, -5.93174174e-02f, 2.43070662e-01f, 4.10800353e-02f, 2.32538730e-01f, 7.41148591e-02f, 1.83870494e-01f, 1.70442626e-01f,
  2.19463587e-01f, 2.05745876e-01f, -1.01849802e-01f, -1.67969033e-01f, 8.67739171e-02f, 6.75043613e-02f, 2.07063258e-02f, 1.11023657e-01f, -8.54675397e-02f, -1.22527771e-01f,
  -6.89201057e-02f, -1.34602278e-01f, -1.73309609e-01f, -1.49763316e-01f, -2.08601817e-01f, -9.62754637e-02f, -2.28889719e-01f, -3.17954868e-01f, 2.74193822e-03f, -1.51754186e-01f,
  -7.67596662e-02f, 3.90723348e-02f, -4.64847423e-02f, -5.32269478e-02f, 7.61917606e-02f, 7.81076029e-04f, 2.03100964e-01f, 5.52368835e-02f, 1.21646523e-01f, 2.54750639e-01f,
  1.91355273e-02f, -1.46671280e-01f, -7.36476704e-02f, -4.31442149e-02f, -1.64148554e-01f, 6.01351857e-02f, -9.61019695e-02f, -6.00559125e-03f, 8.82832780e-02f, -1.11547008e-01f,
  -1.61514372e-01f, -2.25113109e-02f, 5.82479499e-02f, 4.47066128e-03f, 5.41221835e-02f, 3.28244492e-02f, 2.72721034e-02f, -6.14453806e-03f, -1.03349522e-01f, 4.28365953e-02f,
  -3.67986932e-02f, 3.92232426e-02f, 9.12275985e-02f, 4.07294594e-02f, -1.08936215e-02f, -8.67816806e-02f, 1.82810336e-01f, 1.19895123e-01f, 3.07740122e-02f, 8.31495747e-02f,
  2.59007867e-02f, -1.05185518e-02f, -5.78998914e-03f, -6.90068752e-02f, 4.90665808e-03f, 8.79539177e-02f, -1.65952295e-02f, 5.61736599e-02f, 2.02502050e-02f, -6.57040700e-02f,
  -1.54450729e-01f, 3.73467803e-02f, -9.46696028e-02f, -1.51185513e-01f, -1.03489853e-01f, -5.49202971e-02f, -2.62223810e-01f, -1.91499898e-03f, -9.76768509e-02f, -1.99901477e-01f,
  -6.47117868e-02f, -1.25682950e-01f, -1.69000745e-01f, 1.05185837e-01f, 1.47346437e-01f, 1.00213131e-02f, 1.53077677e-01f, 1.96246102e-01f, -1.21249910e-02f, 2.73866951e-02f,
  6.33062601e-01f, 3.88809443e-02f, 7.63156787e-02f, 2.31490627e-01f, 7.70517439e-02f, 5.57202883e-02f, -3.74720357e-02f, 1.58124164e-01f, 1.06691338e-01f, 2.16227304e-02f,
  7.45843500e-02f, 1.51893556e-01f, 2.58660540e-02f, 1.89022105e-02f, 4.94465716e-02f, -4.82935868e-02f, -2.24572066e-02f, 6.89919442e-02f, 1.71967328e-01f, 7.58150667e-02f,
  1.80197246e-02f, -2.65781172e-02f, 1.47735685e-01f, -1.99949020e-03f, 4.94414009e-02f, 5.49156070e-02f, -2.03310922e-02f, -2.61899438e-02f, -1.17587015e-01f, -2.81947274e-02f,
  2.14883164e-01f, 9.49691236e-02f, 8.00666660e-02f, 1.01211488e-01f, 5.13795158e-03f, 1.01687543e-01f, 8.99515152e-02f, -1.02450334e-01f, -7.59734660e-02f, -7.85011575e-02f,
  -1.01843379e-01f, -6.81304485e-02f, -1.37700424e-01f, -1.08693309e-01f, -6.74105063e-02f, 3.81417237e-02f, -1.98658019e-01f, -6.13008998e-02f, -3.40378992e-02f, -4.24562097e-02f,
  -1.93860397e-01f, -8.74188244e-02f, -3.88556942e-02f, -8.66245329e-02f, 2.90699881e-02f, 2.46955771e-02f, -3.92803028e-02f, -6.85392544e-02f, -5.32992277e-03f, 6.65702298e-03f,
  1.66296944e-01f, 1.39533341e-01f, -1.92279071e-02f, 8.26293230e-02f, 9.80334356e-02f, -1.62849687e-02f, -1.77216362e-02f, -1.04217445e-02f, 8.08597952e-02f, -1.45910427e-01f,
  -1.51027679e-01f, 9.26266313e-02f, 5.41204400e-02f, 9.80584472e-02f, 2.30373256e-02f, -7.58503228e-02f, -1.38034135e-01f, -3.16370279e-02f, -8.73370096e-02f, -1.10186264e-01f,
  9.77479294e-02f, 1.11232428e-02f, 3.26700211e-02f, -1.24586381e-01f, -7.31261000e-02f, 1.99825615e-02f, -1.03410482e-02f, -2.27395110e-02f, 2.95189451e-02f, -2.08180044e-02f,
  -2.77952813e-02f, 7.45760184e-03f, 1.39390752e-01f, -1.01441443e-01f, -1.76885091e-02f, 6.96045607e-02f, 8.48388076e-02f, 4.96612750e-02f, -1.29350007e-01f, 4.60531712e-02f,
  1.83560848e-02f, 2.54642852e-02f, -1.35264814e-01f, -1.22048840e-01f, 6.41525351e-03f, 1.05227120e-01f, -3.45988199e-02f, 4.99737374e-02f, -5.05350567e-02f, -4.08873409e-02f,
  -1.12877294e-01f, 5.44603206e-02f, 1.36431083e-01f, 1.00223847e-01f, 7.35063329e-02f, 1.88189328e-01f, -6.93736374e-02f, -3.76937725e-02f, 1.07831873e-01f, 6.06193691e-02f,
  5.08222103e-01f, -1.17290460e-01f, 1.45383701e-01f, 2.15045199e-01f, 2.23086968e-01f, 1.94171533e-01f, 7.73686841e-02f, 4.60101701e-02f, 9.51207653e-02f, 9.20861438e-02f,
  1.54011652e-01f, 2.76432842e-01f, 2.94192314e-01f, 1.54987931e-01f, 5.32657560e-03f, -3.59264761e-03f, -6.37246445e-02f, 1.17690153e-01f, 1.93271518e-01f, 9.53090657e-03f,
  1.96225606e-02f, -2.15499382e-02f, 4.28497791e-02f, 6.53724968e-02f, -6.25030994e-02f, 1.40269175e-01f, -6.72530159e-02f, -1.08639477e-02f, 2.48834547e-02f, 4.31212969e-03f,
  5.85595751e-03f, 1.11738771e-01f, 1.19042456e-01f, 2.17990689e-02f, -2.68124994e-02f, -1.10978134e-01f, -1.06338309e-02f, -1.57065794e-01f, -2.90154368e-02f, -8.36080611e-02f,
  -5.69070987e-02f, -8.54677036e-02f, 4.22590151e-02f, -1.54791847e-02f, -9.77687687e-02f, 8.51131883e-03f, -1.33345142e-01f, -5.80097921e-02f, -7.51463557e-03f, 2.70070117e-02f,
  1.95424035e-02f, 7.36639649e-02f, 6.76080734e-02f, 4.27644737e-02f, 1.23388872e-01f, 2.12370783e-01f, 5.35908751e-02f, 1.38097540e-01f, 3.40592340e-02f, -1.82058271e-02f,
  3.15060258e-01f, 2.14835908e-02f, 1.33562952e-01f, 4.37156707e-02f, -4.88354266e-03f, 6.82995692e-02f, -8.42779782e-03f, 2.25826930e-02f, 5.41827492e-02f, -4.17188480e-02f,
  3.27881612e-02f, 2.62863617e-02f, -2.15468816e-02f, -9.96054709e-02f, 1.37341350e-01f, 1.45793790e-02f, -7.01382160e-02f, -6.28630817e-02f, -3.94303119e-03f, -3.29823755e-02f,
  8.09004344e-03f, -1.77574337e-01f, -8.61717463e-02f, -4.62520123e-02f, -1.18687086e-01f, 9.58469361e-02f, 8.54676142e-02f, 1.54766981e-02f, -5.74103780e-02f, -6.13068752e-02f,
  -3.50922942e-01f, 2.21878067e-01f, 2.74970178e-02f, -3.71964276e-02f, -1.70282975e-01f, -1.42519549e-01f, 1.73355833e-01f, -1.21651337e-01f, -1.74943238e-01f, -1.55081436e-01f,
  -7.39060566e-02f, -6.72696233e-02f, -1.35976925e-01f, -7.11586624e-02f, -9.39914659e-02f, -3.19920965e-02f, 3.88702899e-02f, 2.44184304e-02f, -3.94202881e-02f, -1.84603170e-01f,
  -5.36873005e-02f, -5.30690094e-03f, -3.79141457e-02f, 4.11043502e-02f, 4.48841192e-02f, 6.10779747e-02f, 4.90042344e-02f, -6.95136115e-02f, 7.60279596e-02f, -9.28739756e-02f,
  5.35176754e-01f, 1.58317983e-01f, 4.34162244e-02f, 7.08188713e-02f, 3.72812152e-02f, -1.94649138e-02f, -2.60202661e-02f, -1.20582528e-01f, -8.83841515e-02f, 1.21598199e-01f,
  -5.24609908e-02f, -1.68828160e-01f, -1.01844452e-01f, -2.54621506e-01f, -1.77363917e-01f, 5.69920614e-02f, 1.18865252e-01f, -1.05648801e-01f, -2.03372240e-01f, 4.17587673e-03f,
  7.30421096e-02f, 2.39893064e-01f, 2.82062799e-01f, -7.82702770e-03f, 2.00858667e-01f, -1.01955727e-01f, 1.31300300e-01f, 2.06366211e-01f, 6.68471158e-02f, 2.00624138e-01f,
  1.03222206e-01f, -6.12486573e-03f, -1.22226715e-01f, 1.32563055e-01f, -8.58645812e-02f, -9.47737917e-02f, -9.56939831e-02f, -1.19815491e-01f, -9.85351428e-02f, 3.30635644e-02f,
  5.81032820e-02f, 1.12799071e-01f, -6.62161503e-04f, -1.66182205e-01f, 8.49662572e-02f, -6.54549673e-02f, -5.48895635e-02f, -1.05876192e-01f, -1.64859146e-01f, -8.66452828e-02f,
  2.43270472e-02f, 4.99166511e-02f, -8.21971968e-02f, -1.72655016e-01f, -2.49035478e-01f, -1.25088811e-01f, -9.99920070e-02f, 1.65706556e-02f, -6.23467937e-02f, 8.03381205e-02f,
  -1.68163657e-01f, 1.07043140e-01f, -1.70739479e-02f, 1.11091454e-02f, -1.28173918e-01f, -3.40424888e-02f, -1.64026432e-02f, -2.76268870e-02f, -9.46068689e-02f, -1.03003845e-01f,
  -1.18381590e-01f, -4.83397506e-02f, -1.46779239e-01f, -6.15334995e-02f, -1.14858106e-01f, -6.56934530e-02f, -7.28726387e-02f, 5.09628803e-02f, 4.94954400e-02f, -1.35430604e-01f,
  3.89822689e-03f, -1.34521261e-01f, -3.50386091e-02f, 8.61973315e-03f, -4.67463098e-02f, -3.50089092e-03f, -9.22362134e-02f, -1.08865537e-01f, -1.25321848e-02f, -5.17381839e-02f,
  1.69075206e-02f, -2.42641598e-01f, 8.26862156e-02f, -3.22372727e-02f, 3.04943398e-02f, -2.75414139e-02f, -7.85575584e-02f, -2.56622098e-02f, 5.18710259e-03f, 1.04758851e-01f,
  4.39864770e-02f, -8.84562954e-02f, -1.64046735e-02f, -9.57190469e-02f, -9.34984442e-03f, -1.07035525e-02f, 7.39340410e-02f, 7.42100775e-02f, 1.17301255e-01f, 8.35835040e-02f,
  6.49205297e-02f, 3.53200063e-02f, 1.18371379e-02f, 7.79260881e-03f, 3.49835493e-02f, 3.89994904e-02f, 9.22451317e-02f, -4.14641527e-03f, -2.16808990e-02f, 1.75285146e-01f,
  -5.89922011e-01f, -5.37149273e-02f, -2.28471115e-01f, -9.68180299e-02f, 1.78959906e-01f, 3.47884148e-01f, 4.05147165e-01f, 1.92478731e-01f, 9.52066332e-02f, 3.93861718e-02f,
  -4.02265880e-03f, -4.39156257e-02f, -1.44117707e-02f, 1.22667193e-01f, 8.19129720e-02f, 8.41541216e-02f, 3.59975696e-02f, -1.38218865e-01f, -2.96695717e-02f, 1.91661730e-01f,
  2.32560128e-01f, -6.04760684e-02f, -2.11379707e-01f, -4.85166237e-02f, -9.51678529e-02f, -8.61276835e-02f, -1.23272449e-01f, -1.71901330e-01f, 5.27569512e-03f, -2.48897955e-01f,
  -5.03067672e-01f, -1.49384677e-01f, 1.73177466e-01f, 5.78651242e-02f, -1.41441241e-01f, -1.14844479e-02f, 1.67176917e-01f, -1.88280746e-01f, 8.78587291e-02f, -5.68685606e-02f,
  -6.23658411e-02f, -5.08260094e-02f, 2.37442125e-02f, 3.04749142e-02f, 4.87757009e-03f, 1.52210861e-01f, -1.16671445e-02f, -7.40775689e-02f, -1.95306659e-01f, -8.11079517e-03f,
  2.39050090e-01f, -9.45188254e-02f, -2.63473570e-01f, 7.29862526e-02f, -3.98129076e-02f, -8.19981992e-02f, -3.75300050e-02f, 1.45653530e-03f, -6.55519068e-02f, -1.97519615e-01f,
  6.68066442e-02f, -7.55781531e-02f, -2.44414136e-02f, 9.80782136e-02f, 7.05729797e-02f, -1.11007541e-02f, -1.30494043e-01f, -5.51978722e-02f, -7.47437477e-02f, -1.08575873e-01f,
  1.11384600e-01f, -3.47111709e-02f, 5.61126284e-02f, 1.77243892e-02f, 2.52919570e-02f, -1.17072212e-02f, -3.97207960e-02f, -1.49342502e-02f, -1.11747921e-01f, -3.35712917e-02f,
  3.67392488e-02f, -1.14298120e-01f, -2.61432566e-02f, -9.57645755e-03f, -9.83237028e-02f, 3.77118774e-02f, -5.52562885e-02f, 1.10182926e-01f, 1.72670349e-01f, 7.63920415e-03f,
  -1.45045429e-01f, 8.58648866e-02f, -1.69256195e-01f, 5.89081086e-02f, -5.77165857e-02f, -1.64310187e-01f, -9.18245316e-02f, -4.70674559e-02f, -4.57354374e-02f, -2.47554518e-02f,
  8.92131701e-02f, -8.60339180e-02f, -1.57946125e-01f, 1.89718887e-01f, 1.51320755e-01f, 1.08385935e-01f, -1.57264471e-02f, -6.09639846e-02f, 2.90831495e-02f, 4.19401936e-02f,
  1.44298196e-01f, 1.35894688e-02f, -2.20974609e-01f, 4.20492850e-02f, -1.29696667e-01f, -1.16829887e-01f, 7.98992068e-02f, 4.17574532e-02f, -3.56248929e-03f, -3.01753525e-02f,
  -3.70025069e-01f, 4.62586656e-02f, -1.06880859e-01f, -2.54074275e-01f, 8.28533322e-02f, 2.55823731e-01f, 2.64693320e-01f, 1.19074628e-01f, 1.02935165e-01f, -5.11081591e-02f,
  6.90800250e-02f, -3.13267186e-02f, -1.03432812e-01f, -1.02193534e-01f, -4.44307104e-02f, -4.28360067e-02f, -1.93051726e-01f, -1.52648717e-01f, 2.15084739e-02f, 2.04258010e-01f,
  -8.97772610e-03f, -9.64021832e-02f, -1.67527929e-01f, -1.05317775e-02f, -2.27723524e-01f, -2.54687935e-01f, -1.58636361e-01f, -2.47712970e-01f, -8.09694827e-03f, -2.34386787e-01f,
  -2.31849805e-01f, -1.31545857e-01f, 1.39241949e-01f, -1.21210307e-01f, -4.47748713e-02f, 9.71081182e-02f, 1.05373994e-01f, 7.24738911e-02f, 4.47273739e-02f, 6.94175661e-02f,
  4.51215729e-02f, 2.30508819e-01f, -7.99058974e-02f, -6.78708330e-02f, 1.51082166e-02f, 7.10998029e-02f, 1.33123294e-01f, 1.22551396e-02f, 2.47599166e-02f, 1.19647592e-01f,
  -9.69919749e-03f, -2.42704432e-02f, -1.11615472e-01f, 9.83418599e-02f, 1.34955138e-01f, -1.22073386e-02f, 7.87751563e-03f, 3.74734141e-02f, 2.85131820e-02f, -1.65929928e-01f,
  1.30681917e-01f, -9.69163477e-02f, 2.98289838e-03f, 5.09022959e-02f, -3.12271304e-02f, -5.81417009e-02f, 1.27309386e-03f, 1.13585060e-02f, -5.39462790e-02f, -8.34949762e-02f,
  -7.55477920e-02f, 9.13227648e-02f, -4.18558568e-02f, -1.12008035e-01f, -2.22531874e-02f, -5.71611710e-02f, -2.06385836e-01f, -1.29796058e-01f, -1.01783551e-01f, 3.13274860e-02f,
  -2.25964263e-02f, -6.27401844e-02f, 2.13199463e-02f, -1.12111680e-01f, -5.25135398e-02f, 1.84914619e-02f, -5.34599908e-02f, -2.41289977e-02f, -1.03294989e-02f, 2.64601074e-02f,
  -3.15712243e-01f, 1.27633706e-01f, -1.58965617e-01f, 1.44336835e-01f, -5.09491451e-02f, -4.89847474e-02f, -7.81115815e-02f, 4.87068072e-02f, -3.21456194e-02f, 1.44986242e-01f,
  8.13837871e-02f, 2.52286484e-03f, -1.84709519e-01f, -6.28072023e-02f, 1.04002297e-01f, -6.44289106e-02f, -9.86261889e-02f, -7.30254054e-02f, -3.16798538e-02f, 7.96508938e-02f,
  1.54112028e-02f, 3.42821218e-02f, -9.60142463e-02f, -4.92446423e-02f, -4.90849130e-02f, -2.42935404e-01f, -1.79410040e-01f, -1.63767859e-01f, -1.78260922e-01f, -2.71307856e-01f,
  -1.89088508e-01f, -2.89544493e-01f, -2.17241764e-01f, -1.73375189e-01f, -1.89211443e-02f, 1.41073570e-01f, 7.95307234e-02f, 1.06072716e-01f, -1.94470495e-01f, -2.37805158e-01f,
  -1.44296229e-01f, 5.32939769e-02f, -4.87665012e-02f, 8.69058818e-02f, 9.48113799e-02f, -1.76014915e-01f, -1.83290899e-01f, 1.74762419e-04f, 3.99131268e-01f, 2.44583264e-01f,
  -2.25295685e-02f, -4.11929451e-02f, -2.56597232e-02f, -4.22400944e-02f, -2.56314874e-01f, -1.99419837e-02f, -2.44557828e-01f, -3.69474404e-02f, -1.46204606e-02f, -2.36895055e-01f,
  5.78522459e-02f, -1.33776948e-01f, 7.59894634e-03f, -4.59450074e-02f, -3.40014547e-02f, -6.85326606e-02f, -6.75460845e-02f, -5.32564633e-02f, 2.21453458e-02f, -6.82350621e-02f,
  -1.29909858e-01f, 7.96734169e-02f, -6.42423332e-02f, -9.66527686e-03f, 6.99588358e-02f, 3.57724763e-02f, -1.53956171e-02f, 4.26303633e-02f, -1.65537313e-01f, 1.38826831e-03f,
  -3.75994742e-02f, 2.11101882e-02f, 1.01227365e-01f, 7.03654736e-02f, 5.60816266e-02f, 1.65250972e-02f, 8.17168783e-03f, 8.42050612e-02f, -2.56253853e-02f, -3.40514146e-02f,
  1.23072900e-02f, -5.02472837e-03f, -9.69236344e-02f, 9.52633377e-03f, 1.26292869e-01f, 9.22021270e-03f, 1.45004004e-01f, -1.86716411e-02f, 9.66643468e-02f, 9.35004503e-02f,
  4.03735749e-02f, -8.56451020e-02f, 2.33982783e-02f, -1.72284488e-02f, 4.03530151e-02f, 3.44156437e-02f, 2.28983480e-02f, -8.69245455e-02f, -2.63491739e-02f, -1.20452560e-01f,
  -4.98461984e-02f, -1.38721302e-01f, -6.68355227e-02f, 2.98410133e-02f, -1.17627025e-01f, -2.37805508e-02f, -4.68647107e-02f, 8.00347850e-02f, 2.85913516e-02f, -6.89050183e-02f,
  1.44709662e-01f, -2.15922326e-01f, 2.08597723e-02f, 6.26048446e-02f, -1.24391606e-02f, -1.06325172e-01f, -1.42684028e-01f, 1.99919175e-02f, -6.46542534e-02f, 7.55310804e-02f,
  -2.38602646e-02f, 1.23653956e-01f, -1.25289097e-01f, -8.13115016e-02f, 1.42584115e-01f, -9.84029751e-03f, -1.03844821e-01f, 6.17931634e-02f, -1.02462590e-01f, -1.16295539e-01f,
  -5.94334416e-02f, 1.42304793e-01f, 1.15440145e-01f, 2.64354534e-02f, 5.12736887e-02f, 1.66589454e-01f, 7.76188523e-02f, 7.60722011e-02f, 9.12181288e-02f, 7.81717673e-02f,
  -6.02341890e-01f, 1.24855697e-01f, -6.24474371e-03f, -5.12413010e-02f, -6.42747676e-04f, 3.91009897e-02f, 2.85697300e-02f, 2.34622713e-02f, 6.35835379e-02f, 1.09674528e-01f,
  1.57372653e-01f, 2.29516193e-01f, 9.31888819e-02f, 1.48375779e-01f, 1.06551396e-02f, 1.60895497e-01f, 1.48650751e-01f, -9.06769484e-02f, -9.96055752e-02f, 2.94294790e-03f,
  1.58689827e-01f, -4.22655791e-02f, -2.09962174e-01f, -6.19929656e-02f, 8.44055414e-02f, 2.06154734e-01f, 1.11938246e-01f, 1.57125108e-02f, 2.08005309e-01f, 5.29090092e-02f,
  3.91708732e-01f, -1.19667619e-01f, 6.85037896e-02f, -3.09101939e-02f, 1.07763652e-02f, -2.10535824e-01f, -4.90669906e-02f, -6.86725900e-02f, -6.13569394e-02f, 8.34740773e-02f,
  7.62250945e-02f, -7.31051862e-02f, -7.60267898e-02f, -5.64821288e-02f, -1.97661724e-02f, 1.54293831e-02f, 7.24112391e-02f, 6.20971918e-02f, 6.97374418e-02f, 3.28446701e-02f,
  1.68825164e-01f, 1.02792829e-01f, 2.32165843e-01f, 1.03979081e-01f, 5.56163117e-02f, 3.80312651e-02f, 9.39768553e-02f, 8.19658414e-02f, 1.29638031e-01f, 1.06735438e-01f,
  1.30793706e-01f, 3.45318355e-02f, 1.07148051e-01f, 7.02103451e-02f, -5.43566681e-02f, -9.01989713e-02f, -1.67896692e-02f, -4.73719090e-02f, -4.65576760e-02f, -3.25383544e-02f,
  -7.58579075e-02f, 9.28381607e-02f, -4.40209405e-03f, 1.35455644e-02f, 1.54877938e-02f, -1.40699726e-02f, 5.02741747e-02f, 2.30479583e-01f, 1.83360707e-02f, -1.12113170e-01f,
  1.73160266e-02f, -1.08573198e-01f, -8.96864086e-02f, -1.54286131e-01f, 3.69819440e-02f, 6.14380203e-02f, -1.30916074e-01f, -8.43454674e-02f, -5.28251044e-02f, -9.79292989e-02f,
  2.30694488e-01f, -5.10064363e-02f, -2.81016044e-02f, 3.26430909e-02f, -6.23934856e-03f, -4.69764173e-02f, 7.06980899e-02f, -5.58327883e-02f, -4.12535332e-02f, 1.33173272e-01f,
  2.64569968e-02f, -1.18432246e-01f, -7.83120841e-02f, -3.56555991e-02f, -1.06971666e-01f, 2.00479515e-02f, 2.74302978e-02f, 6.22049253e-03f, 3.34345289e-02f, 8.54786783e-02f,
  -3.04036215e-02f, 1.32808939e-01f, 2.12342605e-01f, 1.55078620e-01f, 2.78715678e-02f, -9.99808218e-03f, 6.38537556e-02f, -1.33124264e-02f, 9.21317264e-02f, 1.30338455e-02f,
  -3.38396989e-02f, -1.35411337e-01f, -5.46478629e-02f, 1.40390053e-01f, 1.73485950e-01f, 3.03582381e-02f, -1.83825836e-01f, 1.04491331e-01f, 1.44026294e-01f, -9.34576020e-02f,
  -1.47642232e-02f, 1.29388586e-01f, -1.20446905e-01f, -1.96713075e-01f, -4.29932415e-01f, -2.31924459e-01f, -3.16977918e-01f, -2.75043547e-01f, 9.31395777e-03f, 8.25412124e-02f,
  1.46635145e-01f, -1.58758610e-02f, 3.24589293e-03f, -7.90232420e-02f, 1.44505754e-01f, -5.60006686e-02f, -8.18805303e-03f, -7.38219470e-02f, -4.02271040e-02f, -1.55734017e-01f,
  -2.94018984e-02f, 2.44748026e-01f, 1.86496392e-01f, -7.01189861e-02f, -1.22965485e-01f, -2.95058042e-02f, 8.62149224e-02f, 8.26502442e-02f, 3.61421034e-02f, -7.55825713e-02f,
  -8.50508362e-02f, 2.42678523e-02f, -3.52701470e-02f, 1.08285241e-01f, -5.71272634e-02f, -9.03688148e-02f, 2.59001162e-02f, -2.60601845e-02f, -5.66794574e-02f, -1.27909416e-02f,
  -1.40891090e-01f, 1.03340484e-01f, -1.33242896e-02f, 1.29013546e-02f, -3.30548622e-02f, 3.74347866e-02f, 9.89106372e-02f, -5.89066790e-03f, -1.32296950e-01f, -1.14252090e-01f,
  5.37802726e-02f, -5.81435394e-03f, 1.58838779e-01f, 5.87625839e-02f, 3.43952700e-02f, 1.20758247e-02f, 5.10763982e-03f, 2.36515328e-02f, 6.90753013e-02f, -6.76114038e-02f,
  -3.87998745e-02f, -1.30696476e-01f, 2.21533515e-03f, -8.90338235e-03f, -5.82745075e-02f, 2.64224336e-02f, -9.95659269e-03f, -1.16845675e-01f, -7.16653913e-02f, -2.33158786e-02f,
  -9.29820165e-03f, -7.15631898e-03f, 2.72579771e-02f, 1.41980918e-02f, -1.63259834e-01f, 2.47424711e-02f, -1.71185029e-03f, 9.78541821e-02f, 5.80871059e-03f, -9.47645493e-03f,
  -3.34024914e-02f, -6.66547641e-02f, -1.80203579e-02f, 3.20165642e-02f, -2.76916306e-02f, -3.29497568e-02f, -9.62786749e-02f, -8.57137963e-02f, 1.26420930e-01f, 8.86135250e-02f,
  -8.60837772e-02f, -1.05729867e-02f, -3.12674642e-02f, 4.07489203e-02f, 2.86085717e-02f, 1.09699937e-02f, -9.60368663e-02f, -4.55391146e-02f, -1.12969406e-01f, 4.40021269e-02f,
  -2.98309531e-02f, -1.75613195e-01f, -1.58757091e-01f, -8.49870816e-02f, 1.72206946e-02f, -1.90623254e-01f, -3.40076759e-02f, -2.25319508e-02f, -1.98246807e-01f, -2.31489211e-01f,
  1.77752852e-01f, -2.36481845e-01f, 1.69340186e-02f, -1.03778630e-01f, -1.37202993e-01f, 1.02958679e-02f, 1.78672913e-02f, -2.48465054e-02f, -1.33365065e-01f, -7.84474909e-02f,
  -3.51786762e-02f, 9.26498845e-02f, 1.26835734e-01f, 8.62674490e-02f, 1.24784708e-02f, -1.82562217e-01f, -2.22189933e-01f, 1.23694122e-01f, 1.42378330e-01f, 9.65213627e-02f,
  -8.59200060e-02f, -6.36186227e-02f, -9.27037187e-03f, -4.11525834e-03f, -4.57683802e-02f, 2.31046230e-02f, -1.78751826e-01f, -9.52704325e-02f, -8.95466059e-02f, -1.86086744e-01f,
  3.00213158e-01f, -1.42111242e-01f, 1.08273417e-01f, -5.81978112e-02f, 7.02959150e-02f, 2.51128152e-02f, 1.28498286e-01f, 4.02540192e-02f, -3.07021383e-02f, 1.82849374e-02f,
  -6.56994106e-03f, -6.80949688e-02f, 7.09431767e-02f, -1.13671608e-02f, -3.23087722e-02f, 3.73652168e-02f, -8.82871002e-02f, -6.40620664e-02f, -4.95066680e-02f, 3.18453610e-02f,
  -1.75271794e-01f, 3.51484977e-02f, 8.10593553e-03f, 1.18619697e-02f, -7.34291319e-03f, -6.83167577e-03f, 3.70213427e-02f, -6.96684718e-02f, 8.13244432e-02f, -8.54855329e-02f,
  3.26743536e-03f, 6.04490824e-02f, 1.19865105e-01f, 1.53710857e-01f, 3.43381017e-02f, 4.97217588e-02f, -6.19492941e-02f, 1.01133570e-01f, -3.99914309e-02f, -1.85152162e-02f,
  2.52685882e-03f, -1.33996099e-01f, 2.15615910e-02f, 1.00926407e-01f, 8.11420977e-02f, 2.16985140e-02f, -7.24069700e-02f, 4.11905274e-02f, -1.16512716e-01f, -2.92984173e-02f,
  -7.97538832e-02f, 5.12682647e-02f, -2.21033990e-02f, 7.68270940e-02f, -1.34030310e-02f, 2.47399248e-02f, -1.42960057e-01f, -2.72683240e-02f, -1.16506174e-01f, -3.11409235e-02f,
  2.69906223e-01f, 3.18623185e-02f, 3.26116122e-02f, -1.52654603e-01f, -1.25321463e-01f, -7.63559639e-02f, -2.81428173e-02f, -1.02487355e-01f, -5.51335737e-02f, 4.31118608e-02f,
  -1.11506104e-01f, -1.05364799e-01f, -3.43750864e-02f, -2.62088738e-02f, 3.49518247e-02f, -1.92565750e-02f, -3.27081084e-02f, -6.11319430e-02f, -2.75068060e-02f, -9.24057215e-02f,
  -7.28882551e-02f, 8.63488391e-02f, 8.93801749e-02f, 1.25612289e-01f, -1.44342640e-02f, 8.79180059e-02f, 4.09287587e-03f, -8.18477795e-02f, 6.84574097e-02f, 6.16405271e-02f,
  2.49816328e-01f, -2.58077919e-01f, 1.27209991e-01f, 2.57280767e-01f, -5.91862351e-02f, -5.50575182e-02f, -1.50863647e-01f, 5.01521565e-02f, 1.62761629e-01f, -1.42711848e-01f,
  -2.14536548e-01f, 1.33641716e-02f, 1.37350932e-01f, 1.39513798e-02f, 9.19261500e-02f, 5.17725274e-02f, 3.27844411e-01f, 3.00584555e-01f, 1.81216061e-01f, 8.83580297e-02f,
  3.19557339e-02f, 4.38648723e-02f, 1.12844691e-01f, 1.30253792e-01f, 1.29446939e-01f, 1.18880257e-01f, -7.56996358e-03f, 3.47737316e-03f, -6.15972467e-02f, 3.17460269e-01f,
  -7.66878426e-02f, -8.10046718e-02f, 1.50724903e-01f, -7.50841871e-02f, -1.30091086e-01f, 9.13105011e-02f, -2.20316201e-02f, -3.17097269e-02f, -8.84877816e-02f, -3.84143665e-02f,
  -1.51269317e-01f, -1.39753208e-01f, 1.78579222e-02f, 4.72983904e-02f, -1.84143577e-02f, -1.08046368e-01f, -2.35404111e-02f, 1.37651384e-01f, 1.12844832e-01f, -3.22564580e-02f,
  -4.63683978e-02f, -9.30305757e-03f, 1.29905447e-01f, 4.26930934e-02f, 9.87950563e-02f, 1.54125884e-01f, 3.00797038e-02f, 8.82319957e-02f, 3.84867452e-02f, 1.16620943e-01f,
  2.16720715e-01f, 1.33631686e-02f, -8.71295203e-03f, 1.02853991e-01f, -3.60627309e-04f, 1.06820809e-02f, 4.42722738e-02f, -1.28803691e-02f, 1.12696774e-01f, 5.14259003e-02f,
  -8.32448434e-03f, 1.85834449e-02f, -2.11692508e-02f, -1.37421027e-01f, 6.06347099e-02f, -7.82535411e-03f, 1.46196794e-03f, -8.43302682e-02f, -1.73163116e-01f, -7.50704557e-02f,
  -4.53487746e-02f, 2.54143625e-02f, -1.03660583e-01f, 4.11341637e-02f, -7.73598999e-02f, 5.43022491e-02f, 9.11791846e-02f, -5.89843560e-03f, -1.69230588e-02f, 4.29486111e-03f,
  -1.33392632e-01f, -2.98760086e-02f, 3.30602787e-02f, -6.14221096e-02f, -9.80000496e-02f, -1.48793846e-01f, 1.33112520e-01f, -4.55316007e-02f, -9.16615799e-02f, -1.17564529e-01f,
  -1.77657679e-01f, -6.78283796e-02f, 5.17570339e-02f, 2.08455417e-02f, 5.95820695e-02f, -6.35849237e-02f, -9.41539854e-02f, 1.28040519e-02f, -3.72405834e-02f, -1.55920431e-01f,
  -1.21717818e-01f, -1.87660232e-02f, -2.28456152e-03f, -6.26223758e-02f, 5.01068085e-02f, 1.29382625e-01f, 7.75202811e-02f, -4.34127972e-02f, 1.90173928e-02f, -9.07841027e-02f,
  -5.28015137e-01f, 1.73229724e-01f, 9.70125794e-02f, -2.40067855e-01f, 2.03417972e-01f, 1.22231834e-01f, 3.30956906e-01f, 2.17582714e-02f, -5.88242114e-02f, 7.90793449e-02f,
  -2.04797275e-02f, -1.12475991e-01f, -7.23092854e-02f, 8.90483409e-02f, 3.21649341e-03f, 2.59557843e-01f, 2.85516053e-01f, -2.18269937e-02f, -2.11458519e-01f, -2.79537719e-02f,
  1.59235746e-01f, -1.11463957e-01f, -2.52190799e-01f, -1.86384663e-01f, -2.02807486e-02f, -1.35372549e-01f, -3.40175256e-02f, 1.31732514e-02f, 1.49630055e-01f, 2.40115091e-01f,
  -2.47312542e-02f, -1.73174635e-01f, 1.29402369e-01f, -9.40401703e-02f, -5.04580699e-02f, -1.81878477e-01f, -1.37351200e-01f, -1.39593750e-01f, 7.53030479e-02f, -9.16100517e-02f,
  -4.26899940e-02f, 8.92914012e-02f, 2.42179986e-02f, 3.88652645e-02f, -1.49432674e-01f, -1.01495050e-01f, -1.30589575e-01f, -1.41899973e-01f, -1.26071110e-01f, -6.41740263e-02f,
  2.52415031e-01f, 1.44326642e-01f, -2.07373723e-01f, -1.18461572e-01f, -1.56626940e-01f, -7.38222823e-02f, -1.66968554e-01f, -9.20720845e-02f, -7.85788074e-02f, -8.28358606e-02f,
  -2.01218631e-02f, 1.89879145e-02f, 1.28043532e-01f, 5.44345751e-03f, 1.05385862e-01f, 1.45532414e-01f, 9.79157016e-02f, 5.59589081e-02f, 1.95157379e-02f, -1.01780869e-01f,
  -1.31699637e-01f, -1.22843385e-01f, -7.93590322e-02f, 8.34244937e-02f, 6.03496768e-02f, -7.58415367e-03f, 1.19674057e-01f, 1.44625979e-03f, 3.29645462e-02f, -1.07940277e-02f,
  -7.30987871e-04f, 8.08261987e-03f, -6.95647895e-02f, 6.47349656e-02f, 8.88409317e-02f, 6.77822828e-02f, 6.37398362e-02f, 5.41260354e-02f, -7.83388466e-02f, -2.51648519e-02f,
  -3.33699465e-01f, 8.11644793e-02f, 3.11669335e-02f, 8.05790797e-02f, 3.29810306e-02f, 9.53681674e-03f, 9.58875343e-02f, 7.14073107e-02f, 3.14606950e-02f, -5.65535538e-02f,
  9.20327455e-02f, -1.32839099e-01f, -1.23401154e-02f, 7.96745047e-02f, 5.99430269e-03f, 8.12529493e-03f, -4.17500138e-02f, 5.70314238e-03f, -6.16189316e-02f, -7.89895430e-02f,
  -2.21904423e-02f, -1.66180715e-01f, -1.37069568e-01f, -1.03118367e-01f, -1.99275002e-01f, -2.35032618e-01f, -1.45027414e-01f, -8.94326344e-02f, -5.37787974e-02f, -2.37167135e-01f,
  -1.95558012e-01f, -1.37953207e-01f, 3.08859814e-02f, 2.05810741e-01f, 6.35696277e-02f, 1.66466445e-01f, 2.60725543e-02f, 1.10668503e-01f, 9.08478424e-02f, 7.67653435e-02f,
  2.59015057e-03f, 2.10578442e-01f, 2.14240104e-01f, 1.70249775e-01f, 3.80126387e-02f, 2.13592410e-01f, 2.69340545e-01f, 1.95028901e-01f, 5.67556210e-02f, 9.99211520e-02f,
  1.80790380e-01f, 3.54023017e-02f, -1.65664330e-01f, 1.32493675e-01f, 1.76873788e-01f, 1.96009487e-01f, 7.03634992e-02f, -4.06080112e-03f, 1.08345829e-01f, 3.48611444e-01f,
  -2.38214761e-01f, 5.72492834e-04f, 2.10589305e-01f, -2.99018342e-02f, -1.55215755e-01f, -1.51392117e-01f, 4.00080904e-02f, -5.36893159e-02f, -1.11585058e-01f, 2.73674875e-02f,
  -8.58017579e-02f, -8.99557620e-02f, 7.78907388e-02f, -1.29930126e-02f, -7.13631734e-02f, -3.94021645e-02f, -1.35821849e-01f, 1.16528742e-01f, 1.87394813e-01f, -1.89627036e-02f,
  3.62843983e-02f, 5.24247028e-02f, 8.01406726e-02f, 7.89837241e-02f, 7.96909332e-02f, 3.67977731e-02f, 1.08626276e-01f, 2.89137438e-02f, 3.65978703e-02f, 1.31550785e-02f,
  2.67045796e-01f, -8.65420327e-03f, 3.73067101e-03f, -1.83993429e-02f, 1.14125535e-01f, -8.82764831e-02f, -9.23999622e-02f, 7.91611522e-02f, 1.43800795e-01f, -1.29925206e-01f,
  1.07390814e-01f, 1.19291641e-01f, 4.76668812e-02f, 2.13881861e-02f, 9.43452585e-03f, 5.28525515e-03f, -1.65231869e-01f, 7.51762092e-02f, -6.30676863e-04f, -1.77438170e-01f,
  -8.80368650e-02f, 3.55247483e-02f, -1.51792252e-02f, -1.15262002e-01f, 6.40241727e-02f, 8.99793655e-02f, 5.31812124e-02f, -1.31787825e-02f, -1.07228450e-01f, -3.31299775e-03f,
  -8.57415497e-02f, 1.20042607e-01f, -1.18477261e-02f, -3.91296437e-03f, -3.88814136e-02f, -1.51836932e-01f, -1.95702165e-02f, -4.34166845e-03f, -3.60802636e-02f, -5.73323257e-02f,
  -1.73692089e-02f, -2.27218736e-02f, -8.66849273e-02f, -6.67999089e-02f, -1.47204638e-01f, -1.01091839e-01f, -1.28180802e-01f, 2.38557663e-02f, 8.45008418e-02f, -1.27645090e-01f,
  -8.30830708e-02f, 8.83406922e-02f, 6.11000694e-02f, -1.02168564e-02f, 1.61415674e-02f, -3.72556373e-02f, -9.38909501e-02f, -6.97273239e-02f, -9.53518748e-02f, -2.07931884e-02f,
  4.35128748e-01f, -2.05337182e-01f, -1.89979389e-01f, 2.54482388e-01f, 1.13178238e-01f, 1.02441959e-01f, 1.23601839e-01f, 1.58626541e-01f, 7.10503086e-02f, -3.44980173e-02f,
  -3.26156855e-01f, -3.14059496e-01f, -3.39073747e-01f, -3.65570366e-01f, -1.15305126e-01f, -6.09069597e-03f, 1.06588364e-01f, 8.05786029e-02f, 8.18188265e-02f, 1.56524256e-02f,
  -9.15655941e-02f, 1.94323882e-01f, 2.10853413e-01f, -4.52468619e-02f, -1.36150360e-01f, -4.46324684e-02f, -5.42261526e-02f, 1.41861653e-02f, -2.38023072e-01f, -1.92553163e-01f,
  -1.01306230e-01f, -2.27744356e-01f, -3.98302861e-02f, -1.29701003e-01f, 6.09271368e-03f, -3.02798338e-02f, -1.96009260e-02f, -1.21762700e-01f, -1.41438350e-01f, 1.37658697e-02f,
  -7.95628652e-02f, -1.17415242e-01f, -2.92993248e-01f, -1.70094550e-01f, -4.62473510e-03f, -2.06810813e-02f, 5.37682697e-03f, -2.46219635e-02f, -2.14294657e-01f, -8.02165419e-02f,
  -2.57508337e-01f, 1.69796625e-03f, -3.54043171e-02f, -3.81786302e-02f, -6.15870655e-02f, -1.02967672e-01f, -1.03858367e-01f, -1.19747393e-01f, -5.82291149e-02f, 1.18069030e-01f,
  5.39664291e-02f, -7.16482010e-03f, -2.54134964e-02f, 6.68177605e-02f, 5.72345592e-02f, 3.90050896e-02f, 2.31967680e-02f, 4.65710200e-02f, -2.95252390e-02f, 5.85252158e-02f,
  -1.05224051e-01f, 1.30643938e-02f, -1.16908118e-01f, 6.83919108e-03f, -7.80396238e-02f, -6.43155398e-03f, -2.22559664e-02f, 4.83699292e-02f, -8.67140573e-03f, 6.80362806e-03f,
  8.92055854e-02f, -9.53012556e-02f, -4.13641036e-02f, -1.04852259e-01f, -9.44012851e-02f, -4.52090614e-02f, -7.70368725e-02f, 2.07003262e-02f, 1.21395541e-02f, 8.75045136e-02f,
  1.58491224e-01f, -1.70001641e-01f, 1.46059170e-01f, -9.19497013e-02f, 6.62320666e-03f, -2.01000609e-02f, -9.16819721e-02f, -5.39161004e-02f, -3.32740396e-02f, -9.36482400e-02f,
  -1.07112519e-01f, -4.72932048e-02f, -1.55467153e-01f, -1.96737811e-01f, 2.77725770e-03f, 4.46042791e-02f, 4.96581197e-02f, 1.87875643e-01f, -7.20085874e-02f, 2.39277948e-02f,
  -2.68085320e-02f, 2.71340966e-01f, 3.05725992e-01f, 4.95852605e-02f, 8.16986561e-02f, 9.81196314e-02f, 1.82381853e-01f, 1.40955061e-01f, 1.02785021e-01f, 2.10421816e-01f,
  1.59760535e-01f, -2.53378630e-01f, -2.49108851e-01f, -3.81021529e-01f, -3.10353220e-01f, -1.63381442e-01f, -1.25641704e-01f, -9.85027924e-02f, -1.55407876e-01f, -2.05903143e-01f,
  -1.22936264e-01f, 2.86104172e-01f, 9.37697142e-02f, 1.66638047e-01f, 3.37302685e-01f, -3.24124187e-01f, -2.13983744e-01f, 5.50375357e-02f, 2.70089895e-01f, 2.10617959e-01f,
  -3.12126596e-02f, 1.75037775e-02f, 6.28001392e-02f, 1.84293538e-02f, -3.00407261e-01f, -1.00339139e-02f, -2.11082995e-01f, -9.80973989e-02f, 3.10300849e-03f, -3.12207222e-01f,
  -7.73257017e-02f, -7.58748576e-02f, 1.30472898e-01f, 7.57694244e-02f, -9.62844938e-02f, 2.29931809e-02f, -1.33352429e-01f, -5.36634251e-02f, -1.85135901e-02f, -1.00361928e-01f,
  -3.41277570e-02f, -3.04169953e-02f, -7.35712722e-02f, -7.33999163e-02f, -2.18459055e-01f, 2.04768907e-02f, -3.69897857e-02f, -3.66026759e-02f, 3.23529765e-02f, -5.88477403e-02f,
  -2.68421937e-02f, 4.00568619e-02f, 3.87146436e-02f, -2.34520510e-02f, 1.69916209e-02f, 4.20706384e-02f, -3.72088468e-03f, -2.38873530e-03f, 2.47166321e-01f, -1.93893909e-01f,
  -5.59059903e-02f, -6.75238892e-02f, -2.65225936e-02f, -2.90203616e-02f, -1.00008473e-01f, -1.92284826e-02f, 4.06577140e-02f, -5.67632243e-02f, -7.00379582e-03f, -4.56221066e-02f,
  6.98664114e-02f, 5.48438765e-02f, 3.27010937e-02f, -7.16226967e-03f, -9.57997702e-03f, 2.08107363e-02f, 6.44527525e-02f, -5.79809397e-02f, 6.81813732e-02f, -1.76133085e-02f,
  1.17635742e-01f, 8.10860191e-03f, -1.04106277e-01f, 5.04154861e-02f, 1.02914758e-01f, -6.61436692e-02f, -7.08759623e-03f, 7.04154447e-02f, -9.71022528e-03f, 9.25311819e-02f,
  -2.13702530e-01f, 2.99315006e-01f, -1.91508204e-01f, 5.92780262e-02f, -1.46780640e-01f, 5.69488294e-02f, -1.24488316e-01f, -4.69798893e-02f, -9.32263434e-02f, -7.06284717e-02f,
  1.16546646e-01f, 6.00332767e-02f, -9.63566974e-02f, 9.72828418e-02f, 3.59255895e-02f, -2.52031088e-02f, 7.61254691e-03f, 5.48596457e-02f, 1.79261982e-01f, 1.90281291e-02f,
  -7.24868327e-02f, 9.48207229e-02f, 1.14357919e-01f, 1.28485695e-01f, 2.82990430e-02f, 1.40575051e-01f, 4.08175737e-02f, 6.84382170e-02f, 3.23800594e-01f, 2.72983555e-02f,
  2.99783885e-01f, -3.00777793e-01f, 3.31812114e-01f, 2.39893183e-01f, 4.29032534e-01f, 4.44245189e-01f, 4.78593796e-01f, 2.98733979e-01f, 1.29956082e-01f, 1.05520390e-01f,
  -4.06653397e-02f, -3.12579960e-01f, -2.63465703e-01f, -2.59268761e-01f, -1.37379646e-01f, 1.07994296e-01f, 9.57992300e-02f, 1.09382808e-01f, 9.92176756e-02f, 2.37669438e-01f,
  -1.14821069e-01f, -5.45089738e-03f, 6.28356636e-02f, -8.25548396e-02f, -4.78403829e-02f, -4.95777801e-02f, -4.97294357e-03f, 9.61128324e-02f, -9.30719897e-02f, -2.55660713e-01f,
  -9.53742266e-02f, 1.17539920e-01f, -5.47196604e-02f, -1.26885429e-01f, 7.14707375e-03f, -5.80653995e-02f, -7.91198984e-02f, -2.01794840e-02f, 1.39923105e-02f, -1.31859213e-01f,
  -5.93450777e-02f, -1.67717889e-01f, 1.78572647e-02f, -1.38295874e-01f, 1.43911153e-01f, 1.38730541e-01f, -1.24125503e-01f, -1.61983430e-01f, -1.50607601e-01f, -1.41172916e-01f,
  -1.50859177e-01f, -7.92501345e-02f, 1.50956780e-01f, 7.81241953e-02f, -6.66040406e-02f, -6.57053664e-02f, 2.89283078e-02f, 2.67912494e-03f, -8.60126410e-03f, -1.77249372e-01f,
  5.60548976e-02f, 1.44055421e-02f, -7.88977668e-02f, -6.25522360e-02f, 1.33129200e-02f, -2.22363193e-02f, 9.64548960e-02f, -1.49275795e-01f, -2.27744672e-02f, -1.04992986e-01f,
  -1.67086907e-02f, -6.96614757e-03f, -4.52003404e-02f, -8.65945816e-02f, -1.10154644e-01f, 4.29827496e-02f, -4.45737690e-02f, -1.15103997e-01f, -1.01428375e-01f, 9.57309753e-02f,
  -6.14487864e-02f, 3.85532342e-02f, 3.11609115e-02f, -7.62190521e-02f, -3.17913704e-02f, 3.82136852e-02f, -8.01514983e-02f, -3.71497869e-02f, -8.78903195e-02f, 4.13069762e-02f,
  -2.71552026e-01f, -1.65633752e-03f, -4.38175201e-02f, -1.39879242e-01f, 8.38977471e-02f, -8.16108659e-02f, -7.83075579e-03f, -1.17817923e-01f, -1.69793870e-02f, -1.33074775e-01f,
  7.45441020e-02f, -5.50133511e-02f, -2.82555670e-02f, -1.25066757e-01f, 2.34440695e-02f, 4.51851524e-02f, -8.57572109e-02f, -1.16641931e-01f, 1.15804076e-02f, -1.58883650e-02f,
  -1.36826247e-01f, 1.04773365e-01f, 1.26999423e-01f, 3.67148742e-02f, -3.90148945e-02f, -4.63362038e-02f, 6.30220100e-02f, 3.70212309e-02f, 2.11079195e-02f, 1.50067970e-01f,
  2.08945051e-01f, -1.78902852e-03f, -5.16552106e-02f, 1.67848706e-01f, 1.76232755e-01f, -1.20889477e-01f, -1.42206773e-01f, -2.36975059e-01f, -6.83054999e-02f, 6.97108880e-02f,
  1.04836546e-01f, 1.81383744e-01f, 9.13699642e-02f, 1.69806294e-02f, -1.32626429e-01f, -2.74629146e-02f, 4.96422313e-02f, 1.07001208e-01f, -4.79554944e-02f, -7.32331052e-02f,
  2.01310501e-01f, 8.24397504e-02f, -2.11404953e-02f, -1.06395818e-01f, 1.11928441e-01f, 8.96433294e-02f, 1.57499150e-03f, 4.40419838e-02f, 7.87600204e-02f, 3.71186823e-01f,
  1.78783476e-01f, 4.59478684e-02f, -2.67473489e-01f, 6.99267313e-02f, 1.13492131e-01f, -9.20649618e-02f, -1.52630076e-01f, -1.76043838e-01f, -1.32803857e-01f, -3.52696069e-02f,
  2.57337570e-01f, 1.85665004e-02f, 1.57159045e-01f, 5.71869612e-02f, 5.26960604e-02f, -2.33576000e-01f, -2.09458604e-01f, -4.24226746e-02f, -9.30670425e-02f, -7.19362721e-02f,
  2.50955939e-01f, 2.24818900e-01f, 4.65800203e-02f, -3.18209261e-01f, -2.93641001e-01f, -3.22573222e-02f, -2.27307007e-01f, -9.61480066e-02f, -1.94840103e-01f, 1.08102009e-01f,
  -4.46785428e-02f, -3.77236158e-02f, -1.46654276e-02f, 7.79753178e-02f, 7.27497414e-02f, -1.39984516e-02f, 7.52347410e-02f, 1.87486294e-03f, -5.46093807e-02f, 5.16489074e-02f,
  -3.60011384e-02f, -5.10778613e-02f, -1.09189205e-01f, -1.49291724e-01f, 3.75864953e-02f, 2.15142556e-02f, -7.42425248e-02f, -1.02792107e-01f, -8.78947154e-02f, -2.25037504e-02f,
  2.84082908e-02f, 6.24901205e-02f, -3.19235921e-02f, -1.78172137e-03f, -9.89798382e-02f, 1.14698485e-02f, -3.99287045e-02f, -1.31222144e-01f, 3.70929353e-02f, 4.03076671e-02f,
  -2.46241838e-02f, -1.19510137e-01f, -4.35408168e-02f, -1.46631151e-01f, -2.14628242e-02f, -9.39060748e-02f, -4.68484275e-02f, -7.19304606e-02f, -4.20004986e-02f, 8.40815436e-03f,
  3.28429528e-02f, -1.01393364e-01f, 1.03940450e-01f, -7.91074429e-03f, 2.75616013e-02f, -8.91438574e-02f, -1.32540157e-02f, 3.90816964e-02f, -1.32506117e-01f, 3.76591273e-03f,
  -5.04497327e-02f, 2.31556455e-03f, -4.68274318e-02f, -1.77846894e-01f, -1.10524878e-01f, -4.08781432e-02f, -9.03312191e-02f, 1.22028496e-02f, -3.10070664e-01f, -2.09087685e-01f,
  -8.94408897e-02f, 3.10885340e-01f, 2.00716257e-01f, -3.03296030e-01f, 9.67589542e-02f, 2.51557708e-01f, 4.42419261e-01f, 8.37988332e-02f, -2.50723571e-01f, 1.24956831e-01f,
  1.00961037e-01f, -2.53641903e-01f, -1.91235375e-02f, 8.47815275e-02f, 1.08540244e-01f, 2.59166628e-01f, 2.24542007e-01f, 1.05282746e-01f, -7.10840374e-02f, -1.66528467e-02f,
  -1.13360230e-02f, -7.22345486e-02f, -5.40266223e-02f, -1.12356514e-01f, -1.43808976e-01f, -2.33981043e-01f, -5.09334058e-02f, 1.80301070e-02f, 1.39593720e-01f, 9.13539901e-02f,
  -7.91402385e-02f, 5.62416725e-02f, -1.73977658e-01f, -2.91452166e-02f, 9.17512104e-02f, -1.22256592e-01f, 2.38618609e-02f, 8.31242651e-03f, -9.91133624e-04f, -1.16537414e-01f,
  -1.08464882e-02f, 6.22830801e-02f, -2.32664868e-02f, -6.08858131e-02f, -1.26828134e-01f, 1.41572773e-01f, -5.68803027e-02f, 2.27913409e-02f, 1.89413093e-02f, -2.19576061e-02f,
  8.53431672e-02f, -4.45957743e-02f, 8.35459307e-03f, 1.09524593e-01f, 6.74980879e-02f, -2.26441368e-01f, -2.96597555e-02f, 9.08305719e-02f, -3.84005569e-02f, -1.06257563e-02f,
  1.01047665e-01f, 2.59392262e-02f, 7.67973065e-02f, -1.05083855e-02f, -6.27020821e-02f, -7.12051541e-02f, 2.12314129e-02f, -1.24707324e-02f, -4.80845794e-02f, -5.67403808e-02f,
  -1.06141493e-01f, -1.34515107e-01f, -7.69469887e-02f, -6.61361441e-02f, -9.42323506e-02f, 1.80682484e-02f, 4.31532562e-02f, 3.65203395e-02f, 3.67264785e-02f, 1.08950241e-02f,
  -4.25208285e-02f, 2.60009896e-02f, -1.53118134e-01f, -6.68330416e-02f, 3.80270183e-02f, -3.43071781e-02f, -2.04361781e-01f, -7.23464862e-02f, 2.22564861e-02f, -7.06906840e-02f,
  -3.31516743e-01f, 1.47104010e-01f, -2.58829474e-01f, 3.71576771e-02f, -6.98966812e-03f, 3.84500101e-02f, -3.79969589e-02f, -9.60360542e-02f, 3.16410884e-02f, -8.60020593e-02f,
  1.73564613e-01f, -1.31594077e-01f, -9.81164873e-02f, -4.10861485e-02f, -1.60699949e-01f, 8.03237259e-02f, 9.81389359e-03f, 1.05715552e-02f, -5.77910766e-02f, 2.18360871e-02f,
  -1.31640628e-01f, -1.73799098e-01f, -1.60986125e-01f, -1.05074003e-01f, -1.11881420e-01f, -3.28344464e-01f, -1.76939636e-01f, -4.04613763e-02f, -4.60225642e-02f, -1.74676120e-01f,
  -4.17510450e-01f, -6.55524060e-02f, 1.60390895e-03f, 2.65494943e-01f, 8.78009275e-02f, 1.10629983e-01f, 1.34255528e-01f, 7.31784478e-02f, 1.80344984e-01f, -8.67954642e-02f,
  -9.97991264e-02f, 1.33077353e-01f, 2.19056681e-01f, 2.19813317e-01f, 6.84593767e-02f, 2.32277513e-01f, 3.55973065e-01f, 1.40494823e-01f, 3.29974219e-02f, 6.16367953e-03f,
  1.45307198e-01f, 1.28151491e-01f, -1.44229069e-01f, 1.24503568e-01f, 7.45630711e-02f, 1.86301962e-01f, 1.19242005e-01f, 5.48186004e-02f, 1.23096481e-01f, 3.66281271e-01f,
  -2.01730922e-01f, -2.44003937e-01f, 1.71688840e-01f, -8.82345513e-02f, -8.37153494e-02f, -1.00469276e-01f, -1.44568220e-01f, -1.22599058e-01f, 5.61368726e-02f, 9.84892622e-02f,
  -1.02017969e-01f, -1.33830190e-01f, 5.91926128e-02f, -9.63598788e-02f, -9.29854810e-02f, -1.17610358e-01f, -1.04897350e-01f, 1.09233297e-01f, 2.25252941e-01f, -6.21864758e-02f,
  1.93177044e-01f, -4.14624326e-02f, 1.82585772e-02f, 8.88617188e-02f, 1.58658057e-01f, 7.61868134e-02f, -7.37987086e-02f, -4.27144915e-02f, 6.85937107e-02f, -8.90245289e-02f,
  1.82193518e-02f, -6.35223277e-03f, -6.37308583e-02f, -4.53358553e-02f, -6.36723191e-02f, 2.27879249e-02f, 1.93035323e-02f, 8.50151554e-02f, 1.33831993e-01f, -1.53039247e-02f,
  1.20872460e-01f, 4.61616032e-02f, 1.05869204e-01f, -4.21983898e-02f, 6.29033446e-02f, -1.53301125e-02f, -5.23582362e-02f, -2.46951208e-02f, -8.14085156e-02f, -6.30689189e-02f,
  -6.95932657e-02f, 8.70033801e-02f, -7.74535611e-02f, 5.52378297e-02f, 2.22273283e-02f, 8.48518461e-02f, 9.62414742e-02f, -1.33096755e-01f, -3.30271050e-02f, -6.25298768e-02f,
  2.02113226e-01f, -1.21290458e-03f, -2.23921426e-02f, 8.24063644e-02f, -4.91396412e-02f, -1.21690087e-01f, -4.30715196e-02f, 3.12927887e-02f, 6.04935996e-02f, 1.24100596e-01f,
  -1.22848079e-01f, -6.77734315e-02f, -7.04861656e-02f, -8.48816037e-02f, -1.22165956e-01f, -1.76908538e-01f, -8.61119702e-02f, 3.41598038e-03f, 1.96775272e-01f, -1.95234753e-02f,
  8.68303180e-02f, -3.09485495e-02f, 3.83867733e-02f, 6.51629502e-03f, 5.13860397e-02f, 2.44159661e-02f, -7.23981187e-02f, -1.42213600e-02f, -1.27904668e-01f, -4.76078875e-02f,
  2.05951422e-01f, -1.39811382e-01f, -2.78306054e-03f, 2.09412456e-01f, 9.94516164e-02f, 1.78203821e-01f, 6.30847588e-02f, 1.32758528e-01f, 1.03606597e-01f, 5.15491031e-02f,
  5.28386887e-03f, 1.46336243e-01f, 1.64123163e-01f, -5.17325196e-03f, 7.52474070e-02f, 3.74111421e-02f, -1.94546711e-02f, -2.11133976e-02f, 8.91503468e-02f, 1.74544349e-01f,
  2.51959618e-02f, -3.37835662e-02f, 1.36919543e-02f, -4.69056629e-02f, -1.18555706e-02f, 1.00711226e-01f, -8.03162754e-02f, -3.21318321e-02f, -1.24379113e-01f, -2.59286650e-02f,
  8.58731419e-02f, -1.77772203e-03f, 3.79748270e-02f, -4.04293947e-02f, -1.03587039e-01f, -1.65374860e-01f, -8.51461366e-02f, -1.90478459e-01f, -6.70784339e-02f, -1.27188921e-01f,
  -1.04463451e-01f, -1.05474293e-01f, 1.06397815e-01f, 1.96391139e-02f, -8.79248604e-02f, -3.90186831e-02f, -8.64021629e-02f, -1.01444580e-01f, -2.10073441e-02f, -8.26162174e-02f,
  -6.84018284e-02f, -7.79208392e-02f, 2.06281058e-02f, -6.27527460e-02f, -5.46350069e-02f, 9.25805494e-02f, -1.10291898e-01f, -5.90370744e-02f, 5.13071232e-02f, -1.73215270e-01f,
  1.52419716e-01f, 2.88539398e-02f, 6.55625314e-02f, -8.29112306e-02f, -4.43391241e-02f, -2.02616062e-02f, 1.33631257e-02f, -5.21071926e-02f, -1.04140509e-02f, 3.06937601e-02f,
  1.58798203e-01f, 8.44855681e-02f, 4.60338267e-03f, 5.78628108e-02f, 1.69713236e-02f, -1.18711017e-01f, -1.04444958e-02f, -5.81211934e-04f, 3.75963114e-02f, 2.17892714e-02f,
  9.42992717e-02f, 5.49888276e-02f, 6.92788288e-02f, 1.23735555e-01f, 1.30053028e-01f, 8.36513042e-02f, 3.65492664e-02f, 6.61431104e-02f, 1.25782028e-01f, 4.63014133e-02f,
  -4.25897017e-02f, -7.43944645e-02f, -5.73888719e-02f, -7.02949613e-02f, -8.76869038e-02f, 3.20133269e-02f, -1.22801088e-01f, -2.19778642e-01f, -1.90356240e-01f, -9.11277384e-02f,
  9.85308662e-02f, -5.16490526e-02f, 4.77732383e-02f, -7.65236444e-04f, 5.41989170e-02f, 6.99176500e-03f, -2.74557322e-02f, -5.02020977e-02f, 2.18912624e-02f, -1.04322501e-01f,
  -1.18679315e-01f, -6.14212938e-02f, -3.38083021e-02f, 4.87530679e-02f, -3.86840105e-02f, 7.10808411e-02f, -5.44757508e-02f, -3.30989584e-02f, 1.14315093e-01f, 8.68707672e-02f,
  6.07196450e-01f, 3.77580673e-01f, 1.04779735e-01f, 3.18323495e-03f, -1.77724529e-02f, -1.76637009e-01f, -1.00027502e-01f, -2.38348171e-02f, -1.23482302e-01f, 8.58491436e-02f,
  6.45012707e-02f, -4.83291689e-03f, -5.73285110e-02f, -5.96211059e-03f, 5.53624555e-02f, -1.82930976e-02f, 1.76627729e-02f, 1.74005777e-01f, -8.16559419e-03f, 9.59154218e-02f,
  1.09565221e-02f, 1.34131938e-01f, 3.08009326e-01f, 6.96506277e-02f, 2.05342293e-01f, -1.23689100e-01f, 7.44855851e-02f, 2.58807123e-01f, 1.08765177e-01f, 3.24295431e-01f,
  1.94243252e-01f, 2.98101485e-01f, -2.49494955e-01f, 1.27922118e-01f, 1.57623887e-02f, 1.07516855e-01f, -6.14867583e-02f, 6.64599314e-02f, -2.59505715e-02f, -7.32183903e-02f,
  2.48564463e-02f, 1.32916793e-01f, 1.07522532e-01f, -6.50318488e-02f, 2.33870489e-03f, -5.65828718e-02f, -6.46951199e-02f, -9.59264208e-03f, -8.93162750e-03f, -2.59681549e-02f,
  -3.83210890e-02f, 8.98392722e-02f, 3.92808905e-03f, -2.71977454e-01f, -7.61541873e-02f, -4.48149815e-02f, -2.19987892e-02f, 4.89540882e-02f, -1.84123978e-01f, -9.82664898e-02f,
  -9.32099149e-02f, -1.25630861e-02f, -9.97692626e-03f, -9.59950164e-02f, -1.51519198e-02f, -6.02487661e-02f, 1.03482129e-02f, -1.36149794e-01f, -2.09626541e-01f, 9.42648202e-02f,
  -9.05522853e-02f, -4.19480801e-02f, -3.99728902e-02f, 3.32076102e-02f, 5.71526028e-02f, 7.77085684e-03f, 1.10208422e-01f, 4.57954034e-02f, -8.76807421e-02f, -3.69753055e-02f,
  -3.77660021e-02f, -6.59633130e-02f, 7.56273344e-02f, -8.54217261e-03f, 4.32483144e-02f, 8.14355165e-03f, 1.73953637e-01f, 4.39830720e-02f, 4.82927971e-02f, 5.75051829e-02f,
  -1.08547129e-01f, -1.71538800e-01f, 3.00432574e-02f, 6.89089149e-02f, 1.23704664e-01f, 1.79354906e-01f, 7.36291409e-02f, 4.16986234e-02f, 9.88406166e-02f, -7.86481798e-02f,
  1.39384881e-01f, 1.86018661e-01f, 1.37074053e-01f, 8.24205205e-02f, 6.40045702e-02f, -1.55399535e-02f, 8.28241482e-02f, -2.36002170e-02f, 7.66013330e-03f, 8.78645554e-02f,
  -1.88612249e-02f, -1.33772388e-01f, -1.77056432e-01f, -2.09012255e-01f, -3.83858755e-02f, -1.73197011e-04f, -8.58949646e-02f, 2.90277340e-02f, -2.44867187e-02f, -2.34695569e-01f,
  -1.23406678e-01f, -2.52037883e-01f, 1.58676622e-03f, 1.94378383e-02f, -2.47208308e-02f, -1.59961566e-01f, -4.85213459e-01f, -4.02712166e-01f, 1.84498057e-02f, -1.83019876e-01f,
  -3.63256782e-02f, 1.93230480e-01f, 9.58246365e-03f, 1.45374108e-02f, -1.47606745e-01f, -2.17541859e-01f, -5.89481182e-02f, 1.61020413e-01f, 7.99128860e-02f, -4.29733582e-02f,
  6.05123565e-02f, 1.64452538e-01f, 1.80630088e-01f, 9.01099443e-02f, 1.44881755e-01f, 1.27704605e-01f, 1.23139106e-01f, 2.17186570e-01f, 1.34821504e-01f, 1.97312936e-01f,
  6.37223870e-02f, -1.50452495e-01f, 4.55511771e-02f, 1.52830482e-01f, 1.19785659e-01f, -4.25564423e-02f, -6.51808605e-02f, 3.55557948e-02f, 1.13899522e-01f, -4.60212044e-02f,
  1.97366595e-01f, 8.48773718e-02f, 6.64201006e-02f, 1.04867332e-01f, 6.23938143e-02f, 4.98236949e-03f, -3.64654064e-02f, -3.83018740e-02f, -1.72541328e-02f, -5.76438233e-02f,
  3.04258168e-02f, 1.42884791e-01f, -7.25009143e-02f, -2.28365555e-01f, -1.65528372e-01f, 1.96806416e-01f, -7.89064392e-02f, -4.97053638e-02f, -7.70195648e-02f, -1.79498076e-01f,
  6.65020496e-02f, 1.42289266e-01f, 1.49741858e-01f, 1.54254856e-02f, 2.95752590e-03f, 9.26089063e-02f, -3.51261906e-02f, -2.23014946e-03f, 1.87588390e-02f, 3.72622274e-02f,
  1.02450192e-01f, 6.21906482e-02f, -1.60799753e-02f, -2.78701540e-02f, 2.07180187e-01f, 1.00678578e-01f, 6.80399165e-02f, 1.48546666e-01f, 2.67391533e-01f, -3.95847205e-03f,
  1.25474691e-01f, 2.08406039e-02f, 1.76556051e-01f, 9.06670243e-02f, 8.40455741e-02f, 1.30210379e-02f, 3.45083661e-02f, -1.52050868e-01f, -6.33212402e-02f, 1.73550352e-01f,
  -5.20903021e-02f, 4.63908687e-02f, 2.70694867e-03f, 7.36170541e-03f, 2.01740433e-02f, -5.00747971e-02f, 4.84967232e-02f, -4.31651957e-02f, 4.53480659e-03f, -1.48008421e-01f,
  -6.41441122e-02f, -1.35906816e-01f, -1.86937317e-01f, -1.02246009e-01f, -4.62769121e-02f, 4.38043661e-02f, -1.46438563e-02f, -3.90070081e-02f, 1.50874294e-02f, -8.16982687e-02f,
  -1.18647128e-01f, -1.20802231e-01f, -1.85306862e-01f, -1.85168713e-01f, -1.01590194e-01f, 2.84547172e-02f, -9.84503776e-02f, -6.98221326e-02f, -1.65808976e-01f, -4.84406501e-01f,
  2.56447703e-01f, -3.16818386e-01f, 4.99143898e-01f, -1.56961624e-02f, -3.05617779e-01f, -7.18440637e-02f, 2.80389264e-02f, 7.98687935e-02f, -6.80859014e-02f, -2.39818022e-01f,
  -6.09871149e-01f, -3.78225952e-01f, -2.58844793e-01f, -1.24563307e-01f, 2.44599819e-01f, 2.34376639e-01f, 4.05545086e-01f, 5.40847063e-01f, 3.00118178e-01f, -1.01249963e-02f,
  -1.74472183e-01f, 1.20620981e-01f, 3.32464963e-01f, 1.76693261e-01f, -3.09034605e-02f, -7.50919804e-02f, 1.15385368e-01f, 5.89976385e-02f, -5.80336414e-02f, 2.16371238e-01f,
  8.89985561e-02f, 1.70806378e-01f, 4.60619666e-02f, -2.40147009e-01f, -1.22285776e-01f, 5.38925268e-02f, -8.43620021e-03f, 1.16928943e-01f, -1.52749941e-01f, 6.92284033e-02f,
  -2.96822429e-01f, -1.16527207e-01f, -1.54640198e-01f, -1.29549518e-01f, 4.64377366e-02f, 2.15484686e-02f, 7.04789236e-02f, 2.62747049e-01f, 2.18089134e-01f, 1.55478660e-02f,
  -2.85770118e-01f, -2.31649950e-01f, 3.88605446e-02f, -3.65092866e-02f, 4.70169149e-02f, -5.68913333e-02f, -4.68274802e-02f, 1.24881119e-01f, 1.53263107e-01f, 1.37963951e-01f,
  1.59749985e-02f, -3.21521834e-02f, -8.24424159e-03f, -2.25912640e-03f, -1.17649762e-02f, -2.28353534e-02f, 1.19601162e-02f, -1.39687434e-01f, 2.27766857e-02f, 2.91410554e-02f,
  6.11545481e-02f, 2.30540223e-02f, 1.74663693e-03f, 2.52690464e-02f, -4.27097753e-02f, 5.34998402e-02f, -6.89910278e-02f, 4.25067991e-02f, -4.62182276e-02f, 6.41078502e-02f,
  1.28961727e-02f, 4.53088200e-03f, -1.15732700e-01f, 5.85497878e-02f, -2.09923480e-02f, 1.22434422e-01f, 4.94245514e-02f, -8.89361352e-02f, 2.77900696e-02f, 1.64110698e-02f,
  -5.04986234e-02f, -4.99618948e-02f, -7.48423906e-03f, -7.65978172e-02f, -3.25140469e-02f, 2.51703598e-02f, -4.51827012e-02f, -8.38365853e-02f, -7.35856369e-02f, 1.35073692e-01f,
  -1.36465743e-01f, -1.66115481e-02f, 1.74815429e-03f, 1.22907013e-01f, 8.73280838e-02f, -4.24451418e-02f, -1.85486093e-01f, -1.49515823e-01f, -1.62798651e-02f, 7.35704526e-02f,
  -5.68734668e-02f, -4.64109816e-02f, 1.15751335e-02f, 1.30671067e-02f, -6.68800622e-02f, -9.90066901e-02f, 8.03124681e-02f, -1.40985791e-02f, 2.50994181e-03f, -1.17301583e-01f,
  -9.90893781e-01f, -2.17612013e-01f, 1.82718188e-01f, -1.12406343e-01f, 1.17270522e-01f, 1.92998096e-01f, 2.17112988e-01f, 5.94652072e-02f, -4.02291827e-02f, -2.26494558e-02f,
  -5.25874197e-02f, -3.55323479e-02f, 3.59998457e-02f, 1.65856797e-02f, -1.04385346e-01f, 2.61142731e-01f, 2.14680940e-01f, 8.20311457e-02f, 6.28702193e-02f, 6.45816326e-02f,
  1.68420002e-01f, -3.30268852e-02f, -2.94155926e-01f, -2.07934901e-02f, 1.90601815e-02f, 2.25204945e-01f, 1.20208442e-01f, -7.43415090e-04f, 7.44050220e-02f, 8.13934878e-02f,
  3.52853417e-01f, -2.89619654e-01f, 1.38842508e-01f, -2.05287009e-01f, -5.15415631e-02f, -2.04269633e-01f, -3.10182385e-02f, -7.23922774e-02f, -7.93207213e-02f, 1.28291979e-01f,
  3.35840397e-02f, -1.81909353e-01f, 1.95550360e-02f, -9.14387684e-03f, -3.08738593e-02f, -1.28418371e-01f, -2.66271949e-01f, -2.89835259e-02f, 1.52973339e-01f, 7.00540319e-02f,
  -5.60137145e-02f, -6.33737147e-02f, 5.64872175e-02f, 1.78992167e-01f, 1.77433677e-02f, 6.75974861e-02f, 2.11121328e-02f, -8.44829530e-02f, -6.73128515e-02f, -1.14342272e-02f,
  6.31517842e-02f, -5.78021184e-02f, 1.88429505e-02f, -4.04682495e-02f, -2.14567482e-02f, 5.35229705e-02f, 9.57569107e-02f, 5.09879068e-02f, 1.70620456e-01f, 5.19872755e-02f,
  2.59002559e-02f, 1.56758100e-01f, 1.89112067e-01f, 1.30748481e-01f, -1.79987308e-02f, 8.45794752e-03f, 3.34401429e-02f, 6.17515249e-03f, -9.02425647e-02f, -9.44172144e-02f,
  1.11430734e-02f, 3.39951366e-02f, -4.65714894e-02f, 8.41527209e-02f, -7.57874548e-03f, -4.44609076e-02f, -5.09429835e-02f, -5.59466034e-02f, -1.18239172e-01f, 2.51262765e-02f,
  3.57855678e-01f, -1.52510136e-01f, 9.75188240e-02f, 1.49636164e-01f, 7.27887526e-02f, -1.24209799e-01f, 4.61843908e-02f, -8.44277814e-03f, 2.69697029e-02f, 1.00348033e-01f,
  2.96533164e-02f, -1.92326810e-02f, -1.02757253e-01f, -5.78535385e-02f, 2.20006797e-02f, -5.75001240e-02f, -1.43085510e-01f, 1.26541391e-01f, 1.38550416e-01f, 8.67972672e-02f,
  -3.84080373e-02f, 8.78554508e-02f, 1.13618426e-01f, 8.97790343e-02f, 5.02566099e-02f, 7.27361515e-02f, 1.11083023e-01f, 8.93237963e-02f, 1.15572765e-01f, 1.70200840e-01f,
  1.22699663e-01f, -2.39199832e-01f, -1.34597927e-01f, 3.69871072e-02f, -1.02600446e-02f, -2.21054748e-01f, -3.68318111e-01f, -1.21238545e-01f, 5.93573740e-03f, -3.59823972e-01f,
  6.36527091e-02f, 4.14474219e-01f, 1.90511301e-01f, -5.18986583e-03f, -1.93592850e-02f, -5.25426388e-01f, -4.10288751e-01f, -1.14619009e-01f, 1.24900974e-01f, 1.49212554e-01f,
  4.57949042e-02f, -3.71815898e-02f, -6.48418590e-02f, 3.37050557e-02f, -1.44183505e-02f, 1.55576080e-01f, -2.43020460e-01f, -3.80970463e-02f, -9.09153149e-02f, -1.10261522e-01f,
  1.86394304e-02f, 1.75519735e-01f, -2.68185697e-02f, -9.05789714e-03f, -1.09854698e-01f, 3.65823098e-02f, -3.89750898e-02f, -3.40948403e-02f, -9.55913141e-02f, -9.18137878e-02f,
  1.02859020e-01f, 8.88304561e-02f, 2.63875891e-02f, 1.95693411e-02f, -4.19505797e-02f, -2.65741479e-02f, 1.64708234e-02f, 4.90589105e-02f, -3.08833574e-03f, 4.03559543e-02f,
  1.15071565e-01f, 1.40576079e-01f, 6.00341111e-02f, -6.90969229e-02f, 2.76636183e-02f, 1.70107588e-01f, -3.66614410e-03f, 9.03309435e-02f, 1.21453106e-01f, 1.05469413e-01f,
  -3.01968623e-02f, 5.44327646e-02f, 9.38920304e-02f, 1.30051628e-01f, -1.96921565e-02f, -1.99638102e-02f, -6.05121441e-02f, -1.48500025e-01f, 5.18034622e-02f, -4.80715893e-02f,
  8.86705890e-03f, 4.47162203e-02f, -7.51020163e-02f, -1.75360218e-01f, -9.22539160e-02f, 4.46602143e-02f, -9.48726907e-02f, 1.01528014e-03f, 4.18800525e-02f, 5.70467161e-03f,
  6.36339933e-02f, 7.92188719e-02f, 2.28754487e-02f, -3.42108100e-03f, -6.81919381e-02f, 2.74539329e-02f, 1.04035832e-01f, 1.42147653e-02f, 1.42907053e-02f, 5.10152951e-02f,
  8.13581124e-02f, 7.12332577e-02f, -1.16935998e-01f, -1.14089847e-02f, 1.12038337e-01f, 6.18368462e-02f, 9.91814509e-02f, -4.80469242e-02f, -1.23245500e-01f, -4.94803600e-02f,
  1.03079751e-01f, 8.08413252e-02f, -5.59494225e-03f, -1.86160468e-02f, 1.96511727e-02f, 9.17366669e-02f, 3.73956710e-02f, 1.77417211e-02f, -5.34050390e-02f, 7.05075189e-02f,
  -1.84127867e-01f, -1.42851342e-02f, -3.05020786e-03f, -8.40785876e-02f, -1.95455924e-02f, -1.29771493e-02f, -3.21476273e-02f, -1.87676176e-02f, 1.42626792e-01f, -1.70002013e-01f,
  2.51898259e-01f, -3.21604669e-01f, -5.81296533e-02f, 1.95576787e-01f, 2.57314835e-02f, 6.23992570e-02f, -1.11641861e-01f, -2.29689945e-02f, 1.00742839e-03f, -2.88645234e-02f,
  1.40122607e-01f, 2.71313816e-01f, 2.63550937e-01f, 9.86078456e-02f, 1.15208603e-01f, -2.27229074e-02f, 1.45187020e-01f, 1.60593748e-01f, 1.63426563e-01f, 1.45255864e-01f,
  1.14418410e-01f, -7.24740624e-02f, -1.05863221e-01f, -5.57865985e-02f, 1.80211309e-02f, 1.38629764e-01f, -1.67342722e-01f, -5.34856245e-02f, 5.33353202e-02f, 1.74543798e-01f,
  2.88967103e-01f, 7.15295449e-02f, -1.69383623e-02f, 1.29182160e-01f, -6.89168973e-03f, -1.20670564e-01f, -1.33958459e-01f, 1.18062971e-02f, 1.63947977e-03f, -6.88684657e-02f,
  2.26459489e-03f, 1.21899713e-02f, -5.06146140e-02f, 6.06878381e-03f, -1.10705696e-01f, 1.19295344e-02f, 6.07383205e-03f, -3.61808725e-02f, 2.74764877e-02f, 6.97090626e-02f,
  -3.98078747e-03f, 3.60692129e-03f, 1.40714357e-02f, -4.43302915e-02f, -7.12374225e-04f, 1.18856438e-01f, -7.29726255e-02f, -2.31464393e-02f, -1.13253914e-01f, -5.76896891e-02f,
  1.24039665e-01f, 5.76676354e-02f, -2.21195035e-02f, 2.04956774e-02f, 2.14397505e-01f, 1.43911213e-01f, 4.10072226e-03f, 1.41642243e-01f, -2.29890980e-02f, 4.95014302e-02f,
  6.83408305e-02f, 3.73285711e-02f, 4.15660590e-02f, 7.53509775e-02f, 7.06294477e-02f, -9.57487449e-02f, -1.61805581e-02f, 9.60672423e-02f, -7.55306408e-02f, -9.80985090e-02f,
  2.57294308e-02f, 1.91693921e-02f, 2.66809575e-02f, -5.69058102e-05f, 1.18843112e-02f, 1.27970800e-01f, -2.94305738e-02f, -2.68298164e-02f, -1.05664663e-01f, -2.14987863e-02f,
  -3.15885246e-01f, 8.94145388e-03f, 6.70006201e-02f, 7.88684841e-03f, -4.92445640e-02f, 2.51222793e-02f, -9.08396095e-02f, -3.77596505e-02f, 5.92098609e-02f, -7.34466361e-03f,
  -1.02157891e-01f, -1.24515548e-01f, -3.36965248e-02f, -1.06333144e-01f, 9.32625607e-02f, -8.34694952e-02f, -1.34795113e-02f, 1.12247571e-01f, -1.26282603e-01f, -1.29686028e-01f,
  -1.61643863e-01f, -1.76344872e-01f, -9.50971246e-02f, -5.32220714e-02f, -5.44758886e-02f, 7.09068552e-02f, -8.47076327e-02f, 1.31421471e-02f, -1.83839709e-01f, -2.07381308e-01f,
  2.75061965e-01f, -8.18513259e-02f, -1.77611172e-01f, 2.49441579e-01f, 7.02687725e-02f, -1.69959575e-01f, -4.65377420e-01f, -1.37770668e-01f, 2.58131206e-01f, -2.94416904e-01f,
  -1.40962109e-01f, 1.39677301e-01f, -4.19093966e-02f, -2.26090118e-01f, -3.21719408e-01f, -5.04659593e-01f, -3.14832270e-01f, -2.32660919e-01f, -1.24707863e-01f, 8.33539851e-03f,
  1.60953462e-01f, 1.65568382e-01f, 1.34657383e-01f, 1.09365620e-01f, 1.73114851e-01f, 2.68877298e-02f, -9.91775692e-02f, 6.15462400e-02f, -9.93423387e-02f, -4.71085943e-02f,
  -1.61728457e-01f, 2.50490755e-01f, -6.01371825e-02f, 5.03394715e-02f, 4.26196214e-03f, -4.39185370e-03f, -8.88339989e-03f, 3.77762946e-04f, -9.54789147e-02f, -5.54581061e-02f,
  2.62017082e-02f, 8.00995305e-02f, 1.76120386e-01f, 1.61089785e-02f, 5.79230115e-02f, 6.58231080e-02f, -4.37450372e-02f, -1.75931066e-01f, -2.29864195e-01f, 6.56521544e-02f,
  2.29729749e-02f, 6.59744963e-02f, 3.27513292e-02f, -3.64136212e-02f, -1.17895424e-01f, 1.18683055e-01f, -1.12901121e-01f, -3.52161862e-02f, -1.87364072e-01f, 2.76563764e-02f,
  -2.14112084e-02f, -4.82039191e-02f, -6.40877858e-02f, 5.59639670e-02f, 4.45797518e-02f, 2.78889295e-02f, 3.70811075e-02f, -1.21366763e-02f, 6.40951609e-03f, 4.91447784e-02f,
  6.02409476e-03f, -6.94682524e-02f, 8.65679085e-02f, 2.69458052e-02f, -5.80717670e-03f, -4.59142635e-03f, -5.57865389e-02f, -2.18709260e-01f, -9.81099345e-03f, -2.76364088e-02f,
  4.09016348e-02f, 1.91103090e-02f, -1.05777774e-02f, 4.55032326e-02f, -4.04433981e-02f, -1.51247770e-01f, -8.76523554e-02f, -7.14781880e-02f, -5.71321435e-02f, 1.81840062e-02f,
  6.40747175e-02f, -2.10578695e-01f, -2.35632099e-02f, -6.67324364e-02f, -1.81432545e-01f, -1.49066914e-02f, 5.84616810e-02f, -1.01931475e-01f, 6.80767819e-02f, -7.19086155e-02f,
  -5.79375364e-02f, -7.25392103e-02f, 2.39094682e-02f, 4.09264080e-02f, -1.06238062e-02f, 5.45323454e-02f, -2.14650899e-01f, 8.02252069e-03f, -5.84330522e-02f, 9.17144343e-02f,
  1.66034456e-02f, -1.83135316e-01f, -7.29872361e-02f, -1.05728976e-01f, 2.43771039e-02f, 3.90247628e-02f, -1.43767819e-01f, 7.37464102e-03f, -2.84710288e-01f, -2.79084653e-01f,
  6.00152373e-01f, 1.56587154e-01f, 8.69868323e-02f, 1.76992342e-01f, 8.95305276e-02f, 4.29052189e-02f, 2.71363378e-01f, 1.64859518e-01f, 5.67349866e-02f, 1.01145737e-01f,
  1.04706503e-01f, 8.33718330e-02f, 1.51248947e-02f, 7.13365376e-02f, 1.51001453e-01f, 2.76748464e-02f, -1.09870695e-01f, 1.01114109e-01f, 1.65832043e-01f, -3.81964855e-02f,
  -1.07748143e-01f, 1.30856745e-02f, 2.54394542e-02f, -8.98738578e-03f, -1.04171738e-01f, -6.65704980e-02f, 8.69515166e-03f, -1.43798813e-01f, 4.30935845e-02f, -9.35224444e-02f,
  -2.17811465e-01f, 2.17386618e-01f, 6.80802613e-02f, 3.45549695e-02f, -5.65932468e-02f, -3.37821767e-02f, -8.59626755e-02f, 1.75775401e-02f, -1.11566953e-01f, -1.74287081e-01f,
  -6.41909149e-03f, 8.43286887e-03f, 1.38896957e-01f, 3.80252376e-02f, -4.84931208e-02f, 5.43076210e-02f, -4.33707722e-02f, 1.07764527e-01f, 2.75365710e-02f, 4.74933647e-02f,
  3.05452347e-02f, 1.89000461e-02f, 8.24922323e-02f, 7.95194060e-02f, 1.38491794e-01f, 1.28741935e-01f, 1.32118940e-01f, 9.10542067e-03f, 1.36290386e-01f, 6.54083416e-02f,
  1.55092627e-01f, 7.35212490e-02f, 5.28745241e-02f, 1.28356308e-01f, -1.18306996e-02f, 1.27022397e-02f, -8.72282907e-02f, -9.84997004e-02f, 1.81788821e-02f, 5.29056750e-02f,
  2.72739250e-02f, 3.62485796e-02f, -1.11636899e-01f, -2.63890382e-02f, -3.54841091e-02f, 3.52148600e-02f, 2.11577192e-02f, -1.02264032e-01f, 1.04464471e-01f, 2.90156193e-02f,
  8.96380632e-04f, -4.40180525e-02f, 1.09004900e-02f, -4.64310087e-02f, 1.61530636e-02f, 1.25066992e-02f, 2.08650418e-02f, -3.91169488e-02f, 1.12445891e-01f, 5.26059419e-03f,
  -4.15186793e-01f, 1.46685869e-01f, -1.14737108e-01f, -5.00448868e-02f, -4.17110659e-02f, -3.22111994e-02f, 1.87595151e-02f, -1.20875791e-01f, -3.20901215e-01f, -1.01236336e-01f,
  -6.77353293e-02f, -5.64857125e-02f, 7.30522769e-03f, 1.22847222e-02f, -1.35041624e-01f, -7.07829967e-02f, -5.20906225e-02f, -3.22671756e-02f, 1.29515529e-02f, -1.88602135e-01f,
  -1.17033750e-01f, 7.14619681e-02f, -3.04917246e-02f, 1.26656100e-01f, -4.76929732e-03f, -7.15140700e-02f, -3.33380252e-02f, 2.38743145e-03f, 1.86479479e-01f, 7.91609734e-02f,
  7.00077042e-02f, 1.73376024e-01f, -3.19325984e-01f, 1.16041310e-01f, -4.87487614e-02f, -2.36279815e-01f, -9.97964218e-02f, -2.05440703e-03f, 1.32286146e-01f, 4.14685458e-02f,
  -3.78953330e-02f, -1.83082763e-02f, -1.02552444e-01f, -2.37361770e-02f, -2.07855344e-01f, -8.66879821e-02f, -1.96538493e-01f, -2.82885045e-01f, -2.10773528e-01f, 5.88702150e-02f,
  1.68512449e-01f, 9.37641785e-02f, 7.81579986e-02f, 9.48624872e-03f, 1.60828233e-01f, 1.74035043e-01f, 5.81028461e-02f, 1.69613361e-01f, 7.22378911e-03f, -9.24380422e-02f,
  -2.00556397e-01f, -2.89317854e-02f, -2.08447084e-01f, -4.49950472e-02f, -6.17511831e-02f, -1.57934323e-01f, -1.38222212e-02f, -1.04006775e-01f, -7.28083551e-02f, -1.30022943e-01f,
  -9.59578082e-02f, -1.36548996e-01f, -2.96283334e-01f, 6.67092651e-02f, -9.59808659e-03f, -2.14348018e-01f, 8.32234621e-02f, 6.28066286e-02f, -2.10449278e-01f, -4.34496673e-03f,
  -4.89163026e-02f, -8.98606256e-02f, -1.58694491e-01f, -6.17673285e-02f, -1.72994718e-01f, -1.85248077e-01f, 5.34267984e-02f, -1.50146578e-02f, -1.52085662e-01f, 3.12967509e-01f,
  -1.44222761e-02f, 7.86762089e-02f, -4.80106473e-03f, 1.34583071e-01f, 9.06265453e-02f, 1.37423038e-01f, -2.23823041e-02f, 1.44931450e-01f, -3.98509316e-02f, 1.13934509e-01f,
  -8.67641792e-02f, -8.52429047e-02f, 9.50611532e-02f, 2.98298951e-02f, -1.04113534e-01f, -5.16670644e-02f, -4.44909371e-02f, 5.54876775e-02f, -6.22053631e-02f, -9.72745046e-02f,
  -8.73847902e-02f, -1.34331584e-01f, 4.58467565e-02f, -1.86954755e-02f, -6.53649718e-02f, -1.20180987e-01f, -5.58716170e-02f, -7.50292316e-02f, -7.35498685e-03f, -8.03257674e-02f,
  3.19113821e-01f, -2.31971741e-01f, 6.34185821e-02f, -1.36132628e-01f, 2.53165718e-02f, -1.33469468e-02f, 5.37241884e-02f, -1.17207676e-01f, -1.17599979e-01f, -1.59223244e-01f,
  -2.53179342e-01f, -1.54467240e-01f, 4.81485017e-02f, 4.41621020e-02f, -1.91665231e-03f, -2.30297185e-02f, 1.07944645e-01f, 8.77188460e-04f, 5.96160293e-02f, -8.74083210e-03f,
  6.62457049e-02f, 1.77821115e-01f, 9.35663879e-02f, 6.21681288e-03f, 3.40271555e-02f, -4.70622145e-02f, 6.51395544e-02f, 1.20950714e-01f, 5.45107499e-02f, 3.18369508e-01f,
  1.96103379e-01f, 9.85985473e-02f, 2.74263233e-01f, 7.70551637e-02f, 3.77240270e-01f, 3.32497299e-01f, 2.56467938e-01f, 1.38964996e-01f, 7.25813359e-02f, 2.31681406e-01f,
  1.89317331e-01f, 3.63943540e-03f, -8.75168219e-02f, -1.61633074e-01f, -1.25986010e-01f, -5.63156046e-02f, -4.76637110e-02f, 3.95492949e-02f, 2.34679744e-01f, 2.10741505e-01f,
  -3.39979455e-02f, 3.65263857e-02f, 7.17559084e-02f, -9.74869505e-02f, 3.54033895e-02f, -7.59365261e-02f, 3.98103781e-02f, 1.42737702e-01f, 4.78721969e-03f, -1.67208552e-01f,
  6.23011291e-02f, 2.93949306e-01f, -1.37596652e-01f, 7.97118843e-02f, 1.40223131e-01f, 1.68362446e-02f, 3.18666808e-02f, -9.32572223e-03f, -5.25651164e-02f, 3.57108079e-02f,
  2.00416028e-01f, -4.24044989e-02f, -1.08954772e-01f, 2.48273183e-02f, 1.32347062e-01f, 7.26877376e-02f, 1.39292199e-02f, 1.52755035e-02f, 1.01094611e-01f, 1.25198752e-01f,
  -4.75588255e-02f, 1.30424857e-01f, 2.97291100e-01f, 1.08201131e-01f, -8.99484102e-03f, 5.57196699e-02f, 1.94289610e-01f, 1.37506008e-01f, 9.74230990e-02f, 8.43128422e-04f,
  1.31181404e-01f, 1.46538168e-02f, 3.96030247e-02f, -3.62601392e-02f, -1.37728244e-01f, -2.07089167e-02f, 2.23000394e-03f, -5.41594811e-02f, -1.00481808e-01f, 7.23678619e-02f,
  4.60378863e-02f, 1.14574231e-01f, 1.30546063e-01f, -1.09332195e-02f, 1.12835951e-01f, 4.98842224e-02f, 7.22378567e-02f, -4.54305448e-02f, 4.90787718e-03f, -2.87430249e-02f,
  2.34842394e-02f, -5.33818267e-02f, 7.30299354e-02f, -3.11720502e-02f, 3.89884342e-03f, 9.17460322e-02f, 7.20546544e-02f, 2.46260548e-03f, -6.96845651e-02f, -2.79060248e-02f,
  -8.68194848e-02f, -1.54910898e-02f, -1.23639315e-01f, -1.87283933e-01f, 5.91977723e-02f, 2.56904718e-02f, -3.81487273e-02f, 6.43187726e-04f, 7.61843771e-02f, 1.19041726e-02f,
  2.66060233e-01f, 2.02981029e-02f, -3.63318659e-02f, -3.26027237e-02f, 2.09017675e-02f, 1.96184367e-01f, -2.82914843e-02f, 1.45792495e-02f, 7.01195095e-03f, 8.01525787e-02f,
  -9.86586884e-02f, 1.98119327e-01f, 1.15868635e-01f, -4.63417917e-02f, -6.78360881e-03f, 4.01449353e-02f, 1.25514254e-01f, 2.81684007e-02f, 1.46950051e-01f, 8.65342170e-02f,
  2.54895926e-01f, -1.33112192e-01f, 2.34657064e-01f, 1.57592028e-01f, 3.33072275e-01f, 3.89898151e-01f, 3.87881637e-01f, 1.09572038e-01f, 8.31994489e-02f, 1.07481871e-02f,
  9.80734825e-02f, -2.70382278e-02f, -5.56924865e-02f, -1.21801235e-01f, 5.69979250e-02f, 5.25376052e-02f, -4.93728481e-02f, 4.35274765e-02f, 2.00384006e-01f, 1.09390803e-01f,
  -2.35093888e-02f, -6.28831908e-02f, 1.55685293e-02f, -9.04533342e-02f, 1.55652715e-02f, -5.99276982e-02f, 6.63814470e-02f, -9.28137451e-03f, -2.42194645e-02f, -2.14536890e-01f,
  1.83477014e-01f, 1.98406041e-01f, -5.05999438e-02f, -1.54020131e-01f, 7.75257573e-02f, -1.42128468e-01f, -5.41255884e-02f, 1.53368607e-03f, -1.62304550e-01f, -1.39988512e-01f,
  -1.22705020e-01f, 5.53194471e-02f, 4.71444502e-02f, 3.22835296e-02f, 1.20422937e-01f, 9.23639350e-03f, -3.06733679e-02f, 5.84939346e-02f, -6.73979670e-02f, 7.02433381e-03f,
  -9.35505480e-02f, 4.26654071e-02f, 4.68725003e-02f, 8.64669532e-02f, -3.08277663e-02f, 6.52440190e-02f, 1.46381473e-02f, -5.15259579e-02f, 5.00764064e-02f, -1.85714308e-02f,
  -1.07408026e-02f, 8.09832439e-02f, 7.85505250e-02f, -4.03372920e-04f, -2.09664926e-02f, 3.33196186e-02f, 2.21589915e-02f, 1.45629076e-02f, -8.17184709e-03f, 1.09982431e-01f,
  7.77658597e-02f, 1.95938841e-01f, 1.55728906e-01f, 2.06724554e-01f, 2.04402193e-01f, 5.14819324e-02f, 1.39188498e-01f, -5.30651361e-02f, 1.49674743e-01f, 4.84396927e-02f,
  8.21827427e-02f, 1.32967860e-01f, 1.67705134e-01f, 1.01766035e-01f, 1.33573174e-01f, 8.62456784e-02f, 1.88259095e-01f, 2.16440726e-02f, 6.57292753e-02f, 1.00390136e-01f,
  -6.12555770e-03f, 2.40615457e-01f, -9.50811431e-02f, -6.56291395e-02f, 1.71600759e-01f, -2.00510345e-04f, -3.92322987e-02f, -4.17820252e-02f, -1.33730605e-01f, -7.17496276e-02f,
  -8.04649964e-02f, 6.92294985e-02f, 5.67603437e-03f, 1.45649984e-01f, 1.32293746e-01f, 1.46438301e-01f, -1.68483719e-01f, -8.51988140e-03f, -7.16280863e-02f, -1.55666187e-01f,
  -1.14615835e-01f, 9.55487862e-02f, 6.50410727e-02f, -2.07341518e-02f, -8.49459320e-03f, 1.46146193e-01f, -8.72090273e-03f, 6.90705106e-02f, 5.45727015e-02f, 6.14657290e-02f,
  -1.20660007e-01f, 9.77310315e-02f, -1.56878754e-01f, 1.39176086e-01f, 1.98787540e-01f, -8.90830383e-02f, -2.42457181e-01f, -2.87997156e-01f, 5.85746244e-02f, 4.93967347e-02f,
  1.21033691e-01f, 1.24112926e-01f, -8.85095447e-03f, -2.29496453e-02f, -6.17279559e-02f, 4.07370776e-02f, 1.19769737e-01f, 1.12296361e-03f, -8.66077766e-02f, -2.78885453e-03f,
  1.97682530e-01f, 6.97339699e-02f, -1.79153774e-02f, -2.32375488e-02f, 9.68314111e-02f, 1.13870077e-01f, 6.61881492e-02f, 1.80075765e-01f, 1.61055014e-01f, 2.82876521e-01f,
  -7.82319345e-03f, -1.44513756e-01f, -1.76912650e-01f, 7.59130716e-02f, -7.01834112e-02f, -2.28720680e-01f, -5.53890280e-02f, -2.36424819e-01f, -1.21544674e-01f, -5.59021980e-02f,
  7.52695426e-02f, 1.98246427e-02f, 4.50604707e-02f, -3.30634862e-02f, 2.77940067e-03f, -1.32023081e-01f, -7.04438910e-02f, -5.63599961e-03f, -2.15149835e-01f, -8.29392001e-02f,
  2.07638666e-01f, 2.53883660e-01f, -5.96630871e-02f, -2.91924804e-01f, -3.39772165e-01f, -4.43813540e-02f, -2.78288037e-01f, -2.33339652e-01f, -3.46471965e-01f, -4.54078205e-02f,
  1.19694784e-01f, 1.08573332e-01f, 1.23750577e-02f, -1.48924934e-02f, 1.16838165e-01f, 3.24304390e-04f, 2.96505559e-02f, 3.55266929e-02f, 9.73245576e-02f, -5.89479739e-03f,
  2.76816115e-02f, -3.76521237e-02f, 4.26233839e-03f, -9.14758593e-02f, -8.84860847e-03f, 5.35917236e-03f, -3.66369709e-02f, 1.13257483e-01f, 1.54599072e-02f, -1.35744944e-01f,
  5.03487810e-02f, -7.84542635e-02f, 1.08895876e-01f, 3.16670872e-02f, 3.45904715e-02f, -2.06192071e-03f, 2.40702610e-02f, -2.77142935e-02f, -9.94496346e-02f, -2.34214235e-02f,
  5.64964227e-02f, -6.25992492e-02f, -1.55277811e-02f, 6.87423907e-03f, 5.73933404e-03f, 2.77444813e-02f, 7.29504153e-02f, -6.02994449e-02f, 1.31607968e-02f, -1.29290819e-01f,
  -1.15205266e-01f, -1.66569009e-01f, -1.87867065e-03f, -1.87975504e-02f, 6.82498291e-02f, -2.67456770e-02f, 4.30831164e-02f, 1.21156096e-01f, -1.05599649e-01f, -1.32770672e-01f,
  -2.56394073e-02f, 9.44728851e-02f, -4.19969670e-02f, -1.40945569e-01f, -1.27297983e-01f, 5.69236167e-02f, -1.96026176e-01f, -6.70934096e-02f, -2.17205361e-01f, -2.30720341e-01f,
  -3.67128670e-01f, -2.87521929e-01f, 1.66007906e-01f, 2.79810816e-01f, 3.59291613e-01f, 2.66274601e-01f, 3.11141014e-01f, 1.36023998e-01f, 1.62117466e-01f, -3.09314411e-02f,
  -4.30072904e-01f, -1.58821002e-01f, -1.83236763e-01f, -1.04865320e-01f, -9.45294946e-02f, 2.50900954e-01f, 4.48412627e-01f, 6.91881776e-02f, 1.65015250e-01f, 5.64422235e-02f,
  5.73904142e-02f, 5.73513061e-02f, -1.46612957e-01f, 6.51320517e-02f, 5.20226285e-02f, 2.00368494e-01f, 1.48859605e-01f, -5.53228073e-02f, -1.57336202e-02f, 2.86528438e-01f,
  -3.52505207e-01f, -2.78927833e-01f, 5.22030927e-02f, -1.85650304e-01f, -1.68103099e-01f, -1.77439854e-01f, -1.16267353e-01f, -7.97758624e-02f, 5.54412007e-02f, 1.08317882e-01f,
  -2.62995046e-02f, -4.18825857e-02f, -1.60507450e-03f, 2.20242031e-02f, 1.52119443e-01f, 5.33241704e-02f, -1.17789447e-01f, -1.00583546e-01f, -5.73679917e-02f, -1.32808104e-01f,
  -1.05591759e-01f, -1.27172610e-02f, -5.04437350e-02f, 3.29232290e-02f, 2.63667684e-02f, 1.09405695e-02f, -6.91840099e-03f, 3.68056027e-03f, -3.69874313e-02f, -6.26904368e-02f,
  -2.22998913e-02f, 6.80813845e-03f, -7.54562467e-02f, -6.00184985e-02f, -1.13099620e-01f, 1.33681297e-01f, 1.61761746e-01f, -1.86740197e-02f, 4.15256657e-02f, -6.11855313e-02f,
  -4.92248796e-02f, -1.25966400e-01f, 5.91830760e-02f, -7.72617087e-02f, -5.24933264e-02f, -6.57652989e-02f, 6.99517503e-02f, -5.52492626e-02f, -1.34205714e-01f, -1.09062217e-01f,
  -2.35132053e-02f, 9.83515680e-02f, -7.69283064e-03f, -1.76665420e-03f, -8.71690270e-03f, -1.97501741e-02f, -9.45385918e-03f, -1.93625122e-01f, 3.35157812e-02f, 2.59124357e-02f,
  3.50629352e-02f, -1.51385814e-01f, -1.38357636e-02f, -7.41656423e-02f, 8.51917267e-02f, -1.07984744e-01f, -9.21531841e-02f, -1.11241885e-01f, 5.20932339e-02f, -2.00293008e-02f,
  -4.45046201e-02f, -1.47701681e-01f, -4.49805409e-02f, -1.96149927e-02f, 1.46459639e-01f, 5.17701469e-02f, -1.38678879e-01f, 1.11543521e-01f, -2.17832942e-02f, -5.70724681e-02f,
  8.46995786e-03f, 2.08305985e-01f, 1.23674169e-01f, 1.55632436e-01f, 1.28927767e-01f, 1.95844218e-01f, 1.34952560e-01f, 8.27818885e-02f, 9.14212838e-02f, 6.77904859e-02f,
  3.83317411e-01f, 3.70864198e-02f, 1.31121660e-02f, 2.65984416e-01f, 8.35087895e-02f, 1.09755717e-01f, -1.46056237e-02f, 4.01194505e-02f, -2.38498650e-03f, 2.45310515e-02f,
  1.27552658e-01f, 1.64151043e-01f, 1.44546032e-01f, 1.93486065e-01f, 1.93281680e-01f, -8.09770152e-02f, -7.77153624e-03f, 1.22583717e-01f, 1.56108364e-02f, -9.86073315e-02f,
  -1.61247879e-01f, -1.52317360e-01f, -9.89657640e-03f, -1.59490749e-01f, -1.32690653e-01f, -2.62711626e-02f, -1.18396387e-01f, 1.11217611e-03f, 5.94193190e-02f, 7.17719942e-02f,
  3.60771120e-01f, 3.81788015e-01f, -5.58519028e-02f, 3.62705179e-02f, 4.89128828e-02f, -1.05010927e-01f, -3.09824180e-02f, -2.29332224e-02f, -3.69865112e-02f, -1.01868823e-01f,
  5.49633354e-02f, -6.84284121e-02f, -4.99600954e-02f, 2.36636978e-02f, -8.47612172e-02f, -8.96772295e-02f, -1.70314535e-02f, 1.77916750e-01f, 2.42270589e-01f, 4.80479654e-03f,
  -5.53794466e-02f, 1.05886720e-01f, 5.81529886e-02f, 3.96523476e-02f, -2.49812603e-02f, 3.47693488e-02f, -6.91329166e-02f, 6.55295998e-02f, 7.57965818e-03f, -3.78436819e-02f,
  -2.86750078e-01f, -3.64395790e-02f, -2.39515528e-02f, -3.19260098e-02f, -1.00021839e-01f, -1.39818400e-01f, 1.55126020e-01f, 8.94965827e-02f, -5.62266670e-02f, -1.51549906e-01f,
  -1.80194583e-02f, 1.00697331e-01f, 1.02715291e-01f, 1.93093028e-02f, 1.83198601e-01f, 1.46406293e-02f, -1.01646343e-02f, -7.26984441e-02f, -6.83565140e-02f, -1.28740985e-02f,
  1.91106170e-01f, -3.45490687e-02f, 7.24121034e-02f, 4.67752740e-02f, 1.43237874e-01f, 1.23565495e-01f, -2.05229651e-02f, -2.80413087e-02f, -1.05802901e-01f, -5.10340184e-02f,
  2.14770049e-01f, 1.78961635e-01f, -1.18475690e-01f, -3.58693823e-02f, -7.15736300e-03f, -7.00327754e-02f, 5.52738123e-02f, 1.60527021e-01f, 7.58819655e-02f, 7.89222643e-02f,
  -7.69742876e-02f, 4.54522856e-03f, 6.14594072e-02f, -9.53208283e-02f, -1.24911226e-01f, -6.52954578e-02f, 8.46020505e-02f, 7.85837993e-02f, 4.47985306e-02f, -8.61643106e-02f,
  -1.91083521e-01f, 4.84844260e-02f, 6.87761754e-02f, 9.17400941e-02f, -1.72416985e-01f, -1.17697038e-01f, -6.28787354e-02f, -1.08448692e-01f, -4.30051088e-02f, -2.83709824e-01f,
  2.01805830e-01f, 6.30546287e-02f, -3.95427793e-01f, 2.09723875e-01f, -6.18511550e-02f, -2.32121497e-01f, -2.22874805e-01f, 2.20672756e-01f, 2.10451365e-01f, 1.83839817e-02f,
  -6.36533797e-02f, 1.55964459e-03f, -1.21934161e-01f, -1.66988164e-01f, -8.51527900e-02f, -1.46716744e-01f, -1.30461782e-01f, -1.43296227e-01f, -7.95246884e-02f, -2.66038757e-02f,
  1.02791227e-01f, 1.64622247e-01f, 4.25143801e-02f, 7.77732208e-02f, 1.25289023e-01f, 3.98529880e-02f, -3.83618958e-02f, -2.33370382e-02f, -9.79827419e-02f, -1.60741270e-01f,
  -2.00120494e-01f, -3.91981192e-02f, -1.40458122e-01f, 5.96225820e-02f, -1.65871069e-01f, -1.56881809e-01f, -1.14248380e-01f, 4.92129773e-02f, -3.27473171e-02f, -2.28384770e-02f,
  -1.37896061e-01f, -1.41616300e-01f, -6.22740649e-02f, -3.35142650e-02f, 1.11960903e-01f, -1.51775792e-01f, 2.37903092e-02f, -1.76391706e-01f, -1.53666347e-01f, -1.01893745e-01f,
  -1.19112171e-01f, -1.95579857e-01f, -1.36762068e-01f, -1.57173783e-01f, -1.38322383e-01f, -1.79311007e-01f, 1.31501118e-02f, -6.74186274e-02f, -1.41723171e-01f, 2.14888543e-01f,
  -2.13650912e-02f, -4.51795943e-02f, -2.27996528e-01f, 4.49525155e-02f, -4.82897088e-02f, 7.19473436e-02f, -9.01485682e-02f, 3.39944959e-02f, 7.68805295e-02f, -4.00712341e-02f,
  3.38089466e-03f, -5.37862396e-03f, 2.14601811e-02f, -2.83995960e-02f, 1.60368066e-02f, -8.43369309e-03f, 2.43816096e-02f, 4.40361202e-02f, -2.37150863e-02f, 3.99521664e-02f,
  -8.10167938e-02f, 3.46890502e-02f, 1.75456405e-01f, 7.60760680e-02f, -6.76197512e-03f, 2.14081109e-02f, 1.01151861e-01f, 5.47433570e-02f, 1.26012221e-01f, 4.89414148e-02f,
  2.66621321e-01f, -3.13103169e-01f, 1.26594994e-02f, 8.79826862e-03f, -2.78314091e-02f, -9.41817239e-02f, 4.90651652e-02f, 6.62355274e-02f, 1.23536605e-02f, -3.66326757e-02f,
  -1.42542705e-01f, 1.02694899e-01f, 9.71867703e-03f, -5.96396364e-02f, -9.29656252e-03f, -1.87702328e-01f, -2.74597891e-02f, 3.23505253e-02f, -1.18218854e-01f, 8.96542966e-02f,
  1.70663819e-01f, 1.06022894e-01f, 2.56004371e-02f, -6.88951686e-02f, 9.31907520e-02f, -6.99530020e-02f, 1.00086614e-01f, 1.61793590e-01f, 2.42583808e-02f, 3.41335505e-01f,
  2.51741499e-01f, 3.52174565e-02f, 2.61489511e-01f, 2.61893999e-02f, -3.86938184e-01f, -2.06292167e-01f, -8.65678564e-02f, -1.60199124e-04f, 8.37953240e-02f, 3.29002440e-02f,
  -3.44177216e-01f, -5.20200208e-02f, 8.48089457e-02f, 1.55556232e-01f, 2.99137771e-01f, 1.74816042e-01f, 2.80944258e-01f, 3.93250674e-01f, 2.44933471e-01f, -4.22145538e-02f,
  -1.11943984e-03f, 6.11828230e-02f, 1.18896857e-01f, 2.69848973e-01f, 1.81002378e-01f, 7.46593922e-02f, 1.14419304e-01f, -2.23914608e-02f, -1.16300084e-01f, 2.77526766e-01f,
  -3.46384943e-02f, -2.69491207e-02f, 1.66889176e-01f, -2.23847255e-02f, -1.10752828e-01f, 2.07212687e-01f, 1.14325628e-01f, 6.46913350e-02f, 3.46264876e-02f, -5.98111823e-02f,
  -2.59200521e-02f, -5.98802753e-02f, 6.01775944e-02f, -5.99502027e-02f, -4.04903628e-02f, -9.92964655e-02f, -1.50460266e-02f, 2.24851862e-01f, 1.43513769e-01f, 3.69706601e-02f,
  -6.65724128e-02f, -1.58286005e-01f, -1.07361481e-01f, -2.04826929e-02f, 1.93886040e-03f, -1.73606966e-02f, -1.43678971e-02f, 6.60647452e-02f, 2.81448923e-02f, 9.27384347e-02f,
  9.07921493e-02f, 1.21091232e-01f, 2.12389193e-02f, -3.34168263e-02f, -1.35156900e-01f, -2.84683742e-02f, -2.06955746e-02f, -5.65039553e-02f, -2.52663735e-02f, -2.83376314e-02f,
  -1.12062097e-01f, 8.20793658e-02f, 2.48194439e-04f, -1.30803391e-01f, 1.01436563e-01f, -1.45206517e-02f, -9.54739302e-02f, -1.75136819e-01f, -1.41089514e-01f, -2.61467174e-02f,
  -1.99516024e-02f, -1.62264879e-03f, -2.39741690e-02f, 3.52520347e-02f, 3.63731757e-02f, 9.41718444e-02f, 3.95836048e-02f, -3.91060151e-02f, -3.24295573e-02f, -5.09390607e-02f,
  -1.74109578e-01f, -1.60015315e-01f, 1.44578740e-01f, 1.01917528e-01f, -3.21459360e-02f, 4.16603200e-02f, -6.60917759e-02f, -4.08954546e-02f, -2.05556348e-01f, 3.11446525e-02f,
  -6.70905039e-02f, -6.58774888e-03f, 6.83839098e-02f, 9.13456455e-02f, -1.46703541e-01f, -1.94342867e-01f, 3.12250317e-03f, 1.11346200e-01f, 2.16456838e-02f, -1.33632943e-01f,
  4.21916274e-03f, -4.43212166e-02f, -1.48845315e-01f, -6.21656552e-02f, -1.30884245e-01f, -2.82995850e-02f, -4.93352488e-02f, -7.77508169e-02f, -4.82028648e-02f, -1.17425747e-01f,
  -2.22773954e-01f, 2.14964971e-01f, 3.29066932e-01f, -1.66933537e-01f, 1.18543006e-01f, 9.15473476e-02f, 1.65697455e-01f, -8.98035020e-02f, -1.60335690e-01f, 6.69366345e-02f,
  1.19531810e-01f, -1.10097595e-01f, -1.92515533e-02f, -2.19918922e-01f, -2.05477312e-01f, 1.27861455e-01f, 1.21228658e-02f, -1.01618454e-01f, -3.34919065e-01f, -3.00326228e-01f,
  -1.60906330e-01f, -3.04511070e-01f, -3.09156805e-01f, -9.45416689e-02f, 2.41987389e-02f, -2.17037395e-01f, 1.41980112e-01f, 4.40115295e-02f, 8.45629200e-02f, 9.82440356e-03f,
  2.09583461e-01f, 1.64319381e-01f, 7.35476539e-02f, 9.50305536e-03f, 2.04088435e-01f, 2.86555383e-03f, -6.84618652e-02f, -2.38877218e-02f, 9.86791626e-02f, 3.90784144e-02f,
  7.78931230e-02f, 2.28587352e-02f, -8.17030221e-02f, -9.85464379e-02f, -1.00684591e-01f, -2.27742881e-01f, -1.65262163e-01f, -1.00340672e-01f, 6.56105727e-02f, 3.00393254e-02f,
  4.44212221e-02f, -1.15087843e-02f, -5.63921630e-02f, 4.19417135e-02f, 1.97846116e-03f, -1.70188770e-01f, 7.03504235e-02f, 3.20544280e-02f, 1.85026769e-02f, -1.42585590e-01f,
  6.56250194e-02f, 6.35594800e-02f, 1.49996867e-02f, 8.74592215e-02f, 3.72165851e-02f, 6.19111396e-02f, 7.99241215e-02f, 7.52065256e-02f, -1.79149806e-02f, -8.62602815e-02f,
  -7.87779018e-02f, 1.38660237e-01f, -1.18956164e-01f, 4.69420999e-02f, -1.02075897e-02f, 3.08814459e-02f, -9.27339196e-02f, 1.54108740e-02f, 9.07273069e-02f, 1.22926496e-02f,
  -1.01624951e-02f, -4.26433571e-02f, -8.66961256e-02f, -1.30292214e-02f, 7.97735080e-02f, 5.57357930e-02f, 3.96230258e-02f, 4.43944782e-02f, -1.35408118e-02f, -5.81971370e-02f,
  -2.13465139e-01f, 1.80350676e-01f, 5.44399805e-02f, -6.86487108e-02f, -4.65821959e-02f, -9.21677500e-02f, -9.88242403e-03f, -1.13698756e-02f, 4.82925549e-02f, 3.85252833e-02f,
  3.93027142e-02f, 5.20971715e-02f, -6.20821714e-02f, -2.31302083e-02f, -1.31189778e-01f, 4.59484011e-02f, -2.92161219e-02f, -1.19945608e-01f, -1.46743685e-01f, 9.58096050e-03f,
  -1.58852354e-01f, -1.42703265e-01f, -2.04900280e-01f, 3.62678245e-02f, -7.73406476e-02f, -1.44829184e-01f, -8.75650123e-02f, -8.13636929e-02f, -8.31138417e-02f, -2.35135946e-02f,
  1.08593784e-01f, -7.33520836e-02f, 2.10078329e-01f, 1.39390260e-01f, 1.13102123e-01f, 2.80976236e-01f, 3.97334427e-01f, 1.72452375e-01f, 4.79280949e-02f, 1.91219002e-02f,
  4.21687253e-02f, -1.11097232e-01f, -4.92896140e-02f, -1.29118618e-02f, 1.41281918e-01f, 8.86994600e-02f, 1.10907845e-01f, 6.95705712e-02f, 1.57913372e-01f, -1.08451778e-02f,
  -5.13056554e-02f, -1.14391975e-01f, 5.02059162e-02f, -2.08782107e-02f, -2.06300821e-02f, -1.21304810e-01f, -2.18446553e-02f, 1.50338924e-02f, -6.83166236e-02f, -3.70091107e-03f,
  -1.98281601e-01f, 2.00088501e-01f, 2.51946468e-02f, -1.41187534e-01f, -1.51959568e-01f, -4.60330443e-03f, -1.18046552e-02f, -1.01736374e-01f, -1.76892981e-01f, -9.05708000e-02f,
  -1.55391730e-02f, -4.55752164e-02f, 1.09863006e-01f, -1.18141212e-02f, 3.17727365e-02f, 4.36937958e-02f, -2.19047405e-02f, 1.35027841e-01f, 1.43328711e-01f, -3.54696736e-02f,
  2.87586953e-02f, 2.73708459e-02f, 5.54473139e-02f, 1.33199558e-01f, 1.42900035e-01f, -8.30914602e-02f, -4.20237072e-02f, 4.32634540e-02f, -1.55183673e-02f, -1.09148035e-02f,
  2.18272116e-02f, -4.34287824e-03f, 2.66721919e-02f, -2.79914681e-02f, 9.02016927e-03f, 7.73919672e-02f, 5.44976182e-02f, 1.13347545e-01f, 2.86870133e-02f, -1.29706077e-02f,
  7.15260161e-03f, 5.45218885e-02f, 4.65854704e-02f, 3.57508659e-02f, 1.44283706e-02f, -4.24366072e-02f, 3.37540209e-02f, 3.30304131e-02f, -8.03078040e-02f, -1.91754829e-02f,
  1.42315507e-01f, 1.77249104e-01f, -1.59721021e-02f, 5.18383458e-02f, 1.65738672e-01f, -3.29824202e-02f, 5.41245304e-02f, 6.65114522e-02f, 1.88083258e-02f, 6.47585243e-02f,
  -2.97989100e-01f, 4.21570390e-02f, -1.04423910e-01f, -3.33566703e-02f, 4.20205593e-02f, 1.27559062e-03f, 4.96919975e-02f, 8.20510613e-04f, -1.12541169e-01f, -4.30903398e-02f,
  -3.59793031e-03f, -1.00635134e-01f, 1.32230148e-01f, -7.77672278e-03f, 6.32558316e-02f, 4.20427062e-02f, -8.35246891e-02f, 7.93662015e-03f, 7.21530244e-02f, -6.86190724e-02f,
  1.07855638e-02f, -4.43222001e-02f, -5.19616976e-02f, 1.39151990e-01f, -2.81435642e-02f, 3.31019200e-02f, -3.12844524e-03f, 1.77589841e-02f, 7.70710409e-02f, -1.26218079e-02f,
  -6.00992858e-01f, 1.25267178e-01f, 6.30374551e-02f, -2.94161141e-02f, 1.18043786e-02f, -1.90922707e-01f, -2.13120937e-01f, -1.37515858e-01f, -1.01880789e-01f, 1.07395977e-01f,
  8.65572989e-02f, -1.57293305e-01f, -4.79286201e-02f, -1.21778250e-01f, -3.76420408e-01f, 4.39284518e-02f, -2.00191870e-01f, -3.82593185e-01f, -4.32883322e-01f, -2.38379076e-01f,
  -1.32037923e-01f, -3.00897807e-01f, -2.73930073e-01f, -1.91439793e-01f, 2.00274229e-01f, -5.10123149e-02f, 1.27296910e-01f, -2.85262838e-02f, -4.71471585e-02f, 7.55281299e-02f,
  2.82382071e-01f, -3.42923217e-02f, -1.27988039e-02f, -1.70667380e-01f, 6.01025373e-02f, -7.20489845e-02f, -9.72816795e-02f, -1.43452451e-01f, -6.03148937e-02f, 1.56526342e-02f,
  -1.11361369e-01f, -6.45103082e-02f, -8.18585679e-02f, 5.78677580e-02f, -2.60026902e-02f, -1.34063408e-01f, 7.34402761e-02f, -1.05934896e-01f, 9.11891311e-02f, 9.95392576e-02f,
  7.65384063e-02f, 5.77059835e-02f, 6.09313995e-02f, 1.22257173e-01f, -2.85484791e-02f, -4.39775959e-02f, 9.92907062e-02f, 2.67938748e-02f, 1.03176303e-01f, 1.42545372e-01f,
  3.22633572e-02f, 8.88642147e-02f, -5.81977777e-02f, 4.34860811e-02f, -1.53604252e-02f, -3.65834241e-03f, 4.29090299e-02f, 3.21986042e-02f, -1.16765901e-01f, 5.85804582e-02f,
  4.61547859e-02f, 5.97571284e-02f, -1.30580151e-02f, -4.67980169e-02f, 3.64840925e-02f, 3.10586859e-02f, -1.14818014e-01f, 9.84607041e-02f, -4.40862216e-02f, 4.17472236e-02f,
  -8.28108788e-02f, 1.13773812e-03f, -3.51353250e-02f, 1.17515892e-01f, 4.54942957e-02f, -3.47509794e-02f, 1.05194636e-02f, -2.10458711e-02f, -1.63943067e-01f, 5.68553880e-02f,
  1.60339847e-01f, -1.41566843e-01f, 1.21296465e-01f, -7.91125000e-02f, 8.12174082e-02f, 4.01049480e-02f, 1.40766367e-01f, 2.74502635e-02f, 3.14658470e-02f, 4.05672751e-02f,
  -1.28535435e-01f, -8.43899846e-02f, 1.46116856e-02f, 8.48561227e-02f, -6.10585772e-02f, -4.21860144e-02f, 8.60004574e-02f, 6.57507554e-02f, 4.95548509e-02f, 1.28080770e-01f,
  1.23038590e-02f, 1.78783219e-02f, 3.29387337e-02f, 1.68798752e-02f, 2.43346449e-02f, -9.78408754e-02f, 1.23569466e-01f, 8.05539191e-02f, -5.10840975e-02f, 2.49153987e-01f,
  4.40309286e-01f, 4.56219129e-02f, 2.05730498e-01f, 1.32058963e-01f, 2.25915477e-01f, 2.12780923e-01f, 4.16873634e-01f, 2.76807576e-01f, 3.25238816e-02f, 9.50584114e-02f,
  1.76244125e-01f, 2.51076464e-02f, -6.23671636e-02f, -8.66594687e-02f, -3.62711363e-02f, -1.35639524e-02f, -1.20543860e-01f, -2.20446847e-02f, 9.87281203e-02f, 8.17207620e-02f,
  -1.18655749e-01f, 6.33547753e-02f, 1.38632432e-01f, -9.24087539e-02f, -4.75169532e-02f, -1.22137778e-01f, 4.14935648e-02f, -1.03476770e-01f, -1.25087559e-01f, -3.73870730e-01f,
  -3.11457247e-01f, 1.11422226e-01f, 3.11456751e-02f, -1.49034830e-02f, 1.01358883e-01f, -4.92350720e-02f, 7.01620579e-02f, -2.90804356e-02f, -4.53509726e-02f, -9.12493244e-02f,
  -6.29588738e-02f, -7.64395818e-02f, 1.08576052e-01f, 5.35920113e-02f, 7.10695833e-02f, -1.60491001e-02f, 2.55245017e-03f, -3.70212272e-02f, -2.69761588e-02f, -1.44880518e-01f,
  -1.46246716e-01f, 1.12487823e-01f, 6.86015487e-02f, 8.44767019e-02f, 3.63294631e-02f, 3.51855531e-02f, 4.82417271e-02f, -1.73557326e-02f, -5.39396778e-02f, -8.79974738e-02f,
  -3.31042446e-02f, 1.51314372e-02f, 5.62667884e-02f, 1.10892661e-01f, 1.96054742e-01f, 4.62447032e-02f, -6.53482452e-02f, 5.45738377e-02f, 9.36442092e-02f, 1.28512964e-01f,
  -4.42926325e-02f, -1.08762877e-02f, 5.50348051e-02f, 4.73127067e-02f, -1.09264798e-01f, 6.26848042e-02f, -7.79318064e-03f, 4.26242091e-02f, 4.87925485e-02f, -2.15344112e-02f,
  7.74567872e-02f, -9.49907601e-02f, -1.25447795e-01f, -1.71348438e-01f, -5.38941137e-02f, -4.78463881e-02f, -1.02601402e-01f, 6.73570037e-02f, -1.96284000e-02f, -4.48773615e-02f,
  -2.44371131e-01f, 1.95963413e-01f, 8.62504728e-03f, -8.18247721e-02f, -2.96227708e-02f, 7.56242871e-02f, -1.36171626e-02f, -1.17371537e-01f, -1.14394508e-01f, -1.22012600e-01f,
  9.97141749e-02f, -4.97739576e-02f, 8.85309950e-02f, -3.23504061e-02f, 1.81679100e-01f, 1.76342186e-02f, -4.23182622e-02f, 9.59385335e-02f, -2.29315639e-01f, -1.23178490e-01f,
  -3.64022367e-02f, 1.26798108e-01f, 1.88669771e-01f, 1.11260330e-02f, -6.70282617e-02f, 6.61653057e-02f, 5.03302878e-03f, 6.49678633e-02f, 9.70766246e-02f, 2.30552748e-01f,
  -5.45325428e-02f, 9.31249633e-02f, 1.66127294e-01f, 6.01138510e-02f, 6.62179440e-02f, 7.62087181e-02f, 2.89480537e-01f, 1.42503947e-01f, 2.61377990e-02f, 7.00221732e-02f,
  -2.18893677e-01f, -2.34950215e-01f, -8.99546891e-02f, -5.38473465e-02f, 5.87100089e-02f, 1.93488449e-01f, 1.87955588e-01f, 1.10084586e-01f, 7.99493417e-02f, 2.63202116e-02f,
  -8.57528374e-02f, -1.94440814e-04f, 2.86503807e-02f, -9.46261957e-02f, 4.52785678e-02f, -8.70127827e-02f, -3.85173671e-02f, -6.89984784e-02f, -2.80232523e-02f, 1.77732274e-01f,
  -2.49463558e-01f, 2.10068119e-03f, -1.79496095e-01f, -2.52119064e-01f, -5.46213202e-02f, -2.87279170e-02f, -7.13577820e-03f, -2.55061220e-02f, -4.51376848e-02f, -5.27732521e-02f,
  -1.69629440e-01f, -8.38920698e-02f, -6.41685352e-02f, 7.58725926e-02f, 5.78892678e-02f, 9.66075286e-02f, 2.89606396e-03f, 4.11916673e-02f, 2.01280005e-02f, 1.78410262e-02f,
  -7.25392327e-02f, -9.13514942e-02f, 1.12391235e-02f, 8.89854655e-02f, 1.77725047e-01f, -9.21598151e-02f, -5.81674976e-04f, 5.13358377e-02f, -5.89210652e-02f, 6.16556592e-02f,
  -1.28930971e-01f, 4.33309823e-02f, -7.80005124e-04f, 4.47793268e-02f, 1.61844436e-02f, -6.70654140e-03f, 2.39544705e-01f, 3.55721116e-02f, 8.34764540e-02f, 7.65691847e-02f,
  1.11843176e-01f, 9.01946202e-02f, -3.08905193e-03f, 3.48190814e-02f, -1.18221276e-01f, -4.91176359e-02f, 5.72394729e-02f, -6.52654916e-02f, -3.80356163e-02f, 6.85668215e-02f,
  1.05327338e-01f, -2.95381024e-02f, -1.24353662e-01f, 3.25002223e-02f, -5.44755273e-02f, 1.62788630e-02f, 5.29100783e-02f, 1.61146512e-03f, -3.93971838e-02f, 2.90648583e-02f,
  -2.33122826e-01f, -1.89876288e-01f, -4.56581675e-02f, 5.72732985e-02f, 1.31165370e-01f, -6.46411851e-02f, 8.79610404e-02f, -1.05370991e-01f, 2.19683331e-02f, -3.07645164e-02f,
  -1.38278514e-01f, -9.84802395e-02f, 8.92970636e-02f, 1.64304584e-01f, 1.67703647e-02f, 2.00697649e-02f, -3.65272015e-02f, 1.14155352e-01f, 7.03909770e-02f, -9.81498957e-02f,
  8.13864619e-02f, 5.65160289e-02f, -2.61358134e-02f, 7.37451836e-02f, 1.84461415e-01f, -1.94749311e-01f, 5.49478717e-02f, -7.68591985e-02f, 6.15345985e-02f, -7.77041167e-02f,
  1.95990484e-02f, -2.98758835e-01f, -1.28925368e-01f, 4.65504825e-02f, 7.64857978e-02f, 1.75835881e-02f, -3.22366327e-01f, -4.41447273e-02f, 7.01250806e-02f, -2.27020741e-01f,
  5.02248891e-02f, 2.09988385e-01f, -4.73568663e-02f, -1.91108525e-01f, -3.84854376e-01f, -4.71742719e-01f, -3.38481873e-01f, -1.91000387e-01f, 6.98998570e-02f, 1.15291908e-01f,
  7.29906783e-02f, 1.27237752e-01f, -1.10393101e-02f, 1.51750773e-01f, 1.53867751e-01f, 2.15521589e-01f, -2.79168580e-02f, 8.02143514e-02f, -6.93351552e-02f, -6.41005486e-02f,
  -1.37664318e-01f, 1.71332777e-01f, 6.00613356e-02f, 1.16273090e-02f, -7.66622201e-02f, -5.97135350e-02f, -9.22432095e-02f, -3.28210108e-02f, 3.17972377e-02f, -6.61623776e-02f,
  4.57872730e-03f, -6.36492763e-03f, 1.18462980e-01f, -7.92176947e-02f, -4.16686665e-03f, -1.61760047e-01f, -1.17286474e-01f, -9.99674648e-02f, -1.11808427e-01f, -1.44273475e-01f,
  -2.86119916e-02f, -3.03531010e-02f, -3.42463329e-02f, -8.50281492e-02f, 3.70670594e-02f, 5.14686629e-02f, 8.28885585e-02f, 6.88356832e-02f, -1.55771365e-02f, 5.57662100e-02f,
  -1.42910644e-01f, 5.93755618e-02f, -6.69435933e-02f, -7.16202781e-02f, -3.46600153e-02f, -6.90590367e-02f, -7.70257488e-02f, -1.32482275e-01f, 4.63671051e-02f, -4.47068224e-03f,
  -4.13864590e-02f, -4.60176123e-03f, 5.34206145e-02f, -8.84509906e-02f, 1.67690217e-02f, 6.06440790e-02f, -7.64832124e-02f, -5.48741519e-02f, 7.20892753e-03f, 1.07671907e-02f,
  -2.13067196e-02f, 1.05267512e-02f, 4.19415273e-02f, 9.37789828e-02f, -8.05964023e-02f, -1.02984281e-02f, -3.35350782e-02f, -4.20847498e-02f, -4.05709958e-03f, -8.18804428e-02f,
  -4.47445847e-02f, 3.76462005e-02f, -9.88828987e-02f, -8.78940970e-02f, -9.10149664e-02f, 7.37185702e-02f, 3.78349498e-02f, -1.48555815e-01f, -2.63636559e-02f, -5.10185547e-02f,
  3.93880857e-03f, -1.66244749e-02f, -1.24389052e-01f, 6.62134821e-03f, -1.67946815e-01f, -4.42292653e-02f, -2.24810794e-01f, -7.43449777e-02f, 9.73020494e-02f, 3.56893502e-02f,
  -1.72782153e-01f, -1.39616251e-01f, -1.67480409e-01f, -2.04487249e-01f, 3.89451459e-02f, 1.43630514e-02f, -7.58244768e-02f, 1.27749965e-01f, -9.89566669e-02f, -2.33175233e-01f,
  -1.76361024e-01f, -4.68381569e-02f, 8.00125077e-02f, 8.06334093e-02f, 5.37704304e-02f, -2.65897177e-02f, 6.48631081e-02f, -7.64712989e-02f, 2.29287031e-03f, 7.05747455e-02f,
  2.85672098e-01f, 3.26213837e-01f, 2.19138101e-01f, 1.00005642e-01f, 8.49960372e-02f, 1.10234134e-02f, -1.72047809e-01f, 9.45050269e-02f, 1.08793214e-01f, 1.40089527e-01f,
  6.41442910e-02f, -6.56626970e-02f, -5.83541729e-02f, -4.55623083e-02f, -4.56941314e-02f, 2.33178869e-01f, -1.66093512e-03f, -1.36284918e-01f, -5.89142600e-03f, -7.79816955e-02f,
  4.69834358e-01f, -4.51107472e-02f, 1.44715011e-01f, -9.02903825e-02f, -7.79805519e-03f, -1.48631155e-01f, 1.48724243e-01f, -1.25147179e-01f, -8.72712210e-02f, -6.43897057e-02f,
  -2.57973690e-02f, -4.24417183e-02f, -7.99730942e-02f, -1.88536942e-01f, -1.59666479e-01f, -8.10860917e-02f, -2.64570862e-01f, -1.16554230e-01f, 7.88946375e-02f, 6.38666078e-02f,
  -1.45144880e-01f, -6.39512986e-02f, 1.03011131e-01f, 5.24084792e-02f, 9.48765948e-02f, 9.15559288e-03f, 1.74509808e-02f, -8.91690776e-02f, 1.27779376e-02f, 5.39065227e-02f,
  1.45736486e-01f, 1.33399934e-01f, -9.65699926e-03f, 3.97877507e-02f, 1.11246511e-01f, -3.63429636e-02f, 3.20100300e-02f, 1.56029807e-02f, 6.71648458e-02f, -3.53519469e-02f,
  2.47599487e-03f, 1.67890623e-01f, 1.44344956e-01f, 6.58797845e-02f, 8.92469287e-02f, 8.52556899e-02f, 4.67761718e-02f, -8.47210234e-04f, -6.36497065e-02f, -1.27670452e-01f,
  -7.92647228e-02f, 2.80525461e-02f, -1.00020379e-01f, -8.27587247e-02f, -3.53049836e-03f, -3.96285410e-04f, -1.39045596e-01f, 3.12015181e-04f, -5.24357632e-02f, -1.52261570e-01f,
  3.62414002e-01f, -1.03273220e-01f, 1.40573829e-01f, -4.86828983e-02f, -6.51864931e-02f, -7.29040280e-02f, 4.87462394e-02f, 1.21748475e-02f, -5.15074134e-02f, 1.06296599e-01f,
  6.93123639e-02f, -2.05659214e-02f, -1.43665910e-01f, -6.58357218e-02f, -6.96391314e-02f, -4.68993280e-03f, -1.05123252e-01f, 4.76417281e-02f, 2.24739388e-02f, -3.81008498e-02f,
  -2.38569841e-01f, 3.42018381e-02f, 1.47632405e-01f, 2.32919767e-01f, 9.61619541e-02f, 1.30258664e-01f, 2.02193141e-01f, 7.27612898e-02f, 1.59791753e-01f, -6.36645183e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  1.27812058e-01f, 3.17064635e-02f, 2.07336947e-01f, 5.39060868e-02f, 6.87830523e-02f, 1.60622552e-01f, 2.00522393e-02f, 3.93373631e-02f, 1.82363585e-01f, 1.06364600e-01f,
  -1.13533270e-02f, 8.07706192e-02f, 1.38787508e-01f, 2.23205760e-01f, 3.32127996e-02f, 2.38083862e-02f, -2.28868216e-01f, -9.18879360e-02f, -5.25842942e-02f, 1.46202624e-01f,
  2.02992380e-01f, 1.30761837e-04f, 7.53650516e-02f, 6.18106723e-02f, 5.20986356e-02f, -3.06717344e-02f, 1.04564629e-01f, 8.37957337e-02f, -1.08892307e-01f, 5.14209755e-02f,
  1.15447193e-01f, 2.68785834e-01f, 1.13042094e-01f, 8.25752318e-03f, -1.54406959e-02f, -1.68253388e-03f, 1.74442418e-02f, 5.40445261e-02f, -1.03588060e-01f, -4.48171757e-02f,
  6.45859912e-02f, -2.34327409e-02f, 8.70835483e-02f, 6.18565530e-02f, 1.00945560e-02f, 3.11314221e-02f, 2.61080191e-02f, 1.98536336e-01f, 1.46070838e-01f, 1.09843500e-02f,
  9.66986045e-02f, -3.80996019e-02f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -4.40232344e-02f, 1.64168328e-02f, 1.93275452e-01f, 1.26983255e-01f, -4.40031365e-02f, 1.88719079e-01f, 1.45664923e-02f, 4.50780019e-02f, 1.45437449e-01f, -6.96618482e-02f,
  1.50657305e-02f, -5.05774356e-02f, 9.06116739e-02f, 1.19948834e-01f, -8.69770441e-03f, 5.38623743e-02f, -1.34658307e-01f, -1.15626216e-01f, 7.94819184e-03f, 1.64716035e-01f,
  6.29803017e-02f, 1.48624137e-01f, 8.39424506e-02f, -1.18821017e-01f, -1.80944845e-01f, 3.12585592e-01f, 2.66361684e-01f, -4.50004637e-02f, 1.79774106e-01f, 7.94039816e-02f,
  3.78474779e-02f, -1.41727477e-01f, 2.89865196e-01f, 1.33024361e-02f, -9.04467553e-02f, -1.26261503e-01f, -1.11687064e-01f, -7.06348717e-02f, -1.53217807e-01f, -1.43226394e-02f,
  5.40999733e-02f, -5.26356883e-02f, 2.43216027e-02f, -2.11251646e-01f, 1.73809841e-01f, 1.53320760e-01f, -9.46655646e-02f, -7.86712766e-02f, -1.94944795e-02f, 1.42096519e-01f,
  2.64120866e-02f, -1.46597579e-01f, 2.13994786e-01f, -6.60430174e-04f, -4.62261215e-02f, 1.37743190e-01f, -1.08865432e-01f, 1.91904560e-01f, -4.35446501e-02f, 1.68585315e-01f,
  -3.76274362e-02f, -1.21739276e-01f, 1.02350049e-01f, 1.22951418e-01f, -1.25273466e-01f, -1.16140790e-01f, 4.22130823e-02f, 3.03377733e-02f, -1.04323164e-01f, -2.39719748e-02f,
  6.41523451e-02f, -3.09578516e-02f, 9.28458571e-02f, -2.48176992e-01f, -9.12831947e-02f, 1.65835358e-02f, 1.06654562e-01f, -7.85721987e-02f, -1.32116392e-01f, -3.43822777e-01f,
  -3.71859074e-02f, 2.21881807e-01f, 8.79500434e-02f, 9.32828337e-02f, 1.05621256e-01f, -2.64846593e-01f, 1.01325683e-01f, 2.05407277e-01f, -2.05624744e-01f, 6.77316710e-02f,
  -7.93125406e-02f, 3.91215310e-02f, 6.40887097e-02f, -8.90418887e-02f, -1.10193603e-01f, -2.78929342e-02f, 1.19271490e-03f, 2.12487534e-01f, -1.62236437e-01f, 1.56105652e-01f,
  -1.48809686e-01f, 9.22159702e-02f, -2.15351075e-01f, 1.17722683e-01f, 1.13491379e-01f, -4.86392528e-03f, 2.36228064e-01f, -1.14691697e-01f, -9.26201791e-02f, 1.10514693e-01f,
  9.65619180e-03f, 1.35984689e-01f, 2.69352011e-02f, -1.69231265e-03f, -1.04962923e-01f, -9.49792638e-02f, 2.04603821e-01f, 5.93517674e-03f, 1.03183776e-01f, -3.68470093e-03f,
  1.00876063e-01f, -2.78670967e-01f, -1.05251662e-01f, -2.73389876e-01f, -4.39741351e-02f, -1.88663200e-01f, 2.11559609e-02f, 1.01116888e-01f, -3.34701426e-02f, 3.31261978e-02f,
  3.46799530e-02f, -6.38577938e-02f, 9.94805247e-02f, 1.66174211e-02f, -6.74415380e-02f, -5.47138490e-02f, -1.51561812e-01f, -6.79370016e-02f, 1.26617327e-01f, 4.68040369e-02f,
  -4.85512502e-02f, -9.62511003e-02f, -8.46319199e-02f, -2.59943157e-01f, 1.19881816e-01f, 2.16401860e-01f, -1.60768285e-01f, 8.31328109e-02f, 1.17604673e-01f, -1.90781236e-01f,
  4.32665274e-02f, -5.09229377e-02f, 2.77848572e-01f, -3.38506281e-01f, -1.48605593e-02f, -1.29057571e-01f, -2.20191360e-01f, -1.71812281e-01f, 2.57382318e-02f, 9.13368091e-02f,
  -2.81344801e-01f, -1.41236082e-01f, 2.75974810e-01f, 4.45160195e-02f, 7.32582137e-02f, -3.88049940e-03f, -1.45402148e-01f, -1.63127601e-01f, -6.95484877e-02f, 7.33084008e-02f,
  5.62635064e-02f, 1.86162472e-01f, -2.67515719e-01f, -3.20607238e-02f, -4.06628586e-02f, 2.77154893e-01f, -1.80354714e-01f, 1.31097985e-02f, 3.30443308e-02f, 3.30296010e-02f,
  -2.39561442e-02f, -1.13984033e-01f, -3.37014883e-03f, 1.63118467e-01f, 8.04762542e-02f, -2.90961534e-01f, -6.57501519e-02f, -1.66625977e-01f, -7.03138635e-02f, -1.63030028e-01f,
  9.15996954e-02f, -5.13422899e-02f, -2.53314655e-02f, -8.56722612e-03f, 8.13247785e-02f, -4.11159806e-02f, -1.55126303e-01f, -2.48896610e-02f, -6.88902959e-02f, -1.71619639e-01f,
  2.63599902e-01f, -3.17870438e-01f, -4.07775380e-02f, 7.88210779e-02f, 6.69773072e-02f, -9.81429070e-02f, -1.15378059e-01f, -9.74990986e-03f, -5.48852570e-02f, 1.51836231e-01f,
  1.78570330e-01f, 1.41198292e-01f, 4.77571003e-02f, 8.74656737e-02f, -1.42377783e-02f, 7.17258155e-02f, -1.65639251e-01f, -6.66305274e-02f, -2.55401284e-02f, -4.61447425e-02f,
  6.96510151e-02f, -4.14087065e-02f, 6.20576181e-02f, -1.62462220e-01f, -1.99152857e-01f, -3.79314758e-02f, -1.64041385e-01f, 1.06692106e-01f, -1.10476688e-01f, 1.62683442e-01f,
  -2.79979944e-01f, 5.10338135e-02f, 1.30270600e-01f, 8.64636600e-02f, 1.71823919e-01f, -3.52115095e-01f, -1.55823886e-01f, 2.82027930e-01f, 2.06747845e-01f, 1.80233106e-01f,
  1.72053352e-02f, 1.63538586e-02f, 6.71535358e-02f, 5.27009256e-02f, 1.04640037e-01f, -3.95521224e-01f, 8.80718455e-02f, 4.46249358e-03f, -1.50602579e-01f, -1.18683226e-01f,
  1.15972079e-01f, 5.37261553e-02f, 6.19666316e-02f, -3.81289124e-02f, 1.25419483e-01f, 1.16942838e-01f, 1.52723894e-01f, -1.01121217e-01f, 1.07081205e-01f, 1.14711769e-01f,
  2.07943581e-02f, 1.07943133e-01f, -6.80190995e-02f, -5.43821901e-02f, -2.36503452e-01f, -9.39967260e-02f, -2.01581493e-02f, 9.78844147e-03f, 1.81794211e-01f, -2.22754404e-01f,
  -7.39792138e-02f, 8.58503431e-02f, 7.44909272e-02f, 6.02276735e-02f, -1.88138396e-01f, -1.47062123e-01f, 1.79015175e-01f, -1.68754458e-01f, 2.28846356e-01f, -8.06655269e-03f,
  6.81005465e-03f, -2.47680634e-01f, -2.17299044e-01f, 2.76619922e-02f, -8.27802196e-02f, -2.01600522e-01f, 1.65712833e-01f, -3.96279655e-02f, -1.99371859e-01f, -1.79935291e-01f,
  1.30470484e-01f, 5.10202833e-02f, 1.86573751e-02f, 8.01347755e-03f, -2.30391100e-02f, -2.55022675e-01f, 1.53051205e-02f, 7.08589777e-02f, -1.69282854e-01f, 3.02449465e-01f,
  2.33639013e-02f, -6.92442656e-02f, 7.95683712e-02f, -2.49036536e-01f, -6.65279329e-02f, -4.79294956e-02f, 4.33633402e-02f, -1.04692928e-01f, -1.51254505e-01f, -7.39874914e-02f,
  1.77792281e-01f, 8.92933551e-03f, 1.83580313e-02f, -3.70976143e-02f, -9.33239534e-02f, 7.89591670e-03f, -5.71578816e-02f, -8.69729593e-02f, -2.31821850e-01f, 1.96005851e-01f,
  2.21950412e-02f, 1.09151853e-02f, -3.88225280e-02f, -1.36562586e-01f, -6.39877245e-02f, 1.46161793e-02f, -4.83922251e-02f, 4.80504595e-02f, -1.32465169e-01f, 3.16628255e-02f,
  2.17323154e-01f, -1.15080170e-01f, -3.34063888e-01f, -9.79803577e-02f, -1.60000548e-02f, 8.42247456e-02f, 2.06909180e-02f, -2.02075452e-01f, 3.20525393e-02f, -2.16790974e-01f,
  -2.21862495e-01f, -1.81088954e-01f, 1.85229108e-02f, -9.25576389e-02f, 2.25072846e-01f, 7.42966216e-03f, -7.89952949e-02f, -2.09826410e-01f, 9.47724432e-02f, -2.40380466e-02f,
  -1.58078775e-01f, -2.44707358e-03f, 1.47518247e-01f, 4.25783657e-02f, 4.33530174e-02f, -2.53037125e-01f, -3.70606594e-03f, 1.46402597e-01f, 2.55693253e-02f, 5.30363880e-02f,
  -1.83026388e-01f, 2.35037208e-01f, -1.14042975e-01f, -2.66547233e-01f, 4.25809287e-02f, -9.68580991e-02f, -7.18168393e-02f, 1.19819611e-01f, -3.38595808e-02f, 1.45086795e-01f,
  1.59407124e-01f, -1.28074080e-01f, 1.03880741e-01f, 1.90711603e-01f, -8.65654498e-02f, 1.47798046e-01f, -3.17323916e-02f, -5.51022701e-02f, 9.51802731e-02f, -1.55833706e-01f,
  4.11129445e-02f, 6.14654943e-02f, -1.54307127e-01f, 5.85191101e-02f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  2.78387554e-02f, -9.80053619e-02f, 8.55135173e-02f, 5.10833599e-02f, 2.03950807e-01f, -2.14232598e-02f, 3.47019285e-02f, -1.87628403e-01f, 2.67968953e-01f, 1.94197074e-01f,
  -1.22665457e-01f, 7.78054073e-02f, 1.08903721e-01f, -8.06592628e-02f, 1.67398844e-02f, 9.42063779e-02f, -4.21025008e-02f, -1.91909119e-01f, 1.70008928e-01f, -1.76488340e-01f,
  4.24876250e-02f, -7.71776587e-02f, -6.57304153e-02f, 2.53883121e-03f, 1.66310593e-01f, 6.73042703e-03f, -4.43604961e-02f, -5.37896417e-02f, 2.75403005e-03f, -7.70713342e-03f,
  -2.48381421e-02f, -5.00389561e-02f, 1.39852747e-01f, -3.30085009e-02f, -1.31153002e-01f, 7.62705579e-02f, -1.55087516e-01f, 4.54293936e-02f, 1.67360231e-01f, 8.62320140e-02f,
  -6.18084222e-02f, 9.75393653e-02f, -5.36981365e-03f, 2.51498399e-03f, -1.07906170e-01f, 3.14683467e-02f, 5.03699668e-02f, -6.09330423e-02f, -1.40070796e-01f, -1.52404919e-01f,
  -2.02294067e-01f, -3.48178553e-03f, 1.16943382e-01f, 1.18610337e-02f, 9.30281803e-02f, -1.47610649e-01f, 5.98968416e-02f, 3.15065309e-02f, 9.14129391e-02f, -1.64532065e-01f,
  -5.46024088e-03f, -8.76284018e-02f, 8.05149146e-04f, -2.39359051e-01f, 1.49191245e-01f, -2.01290636e-03f, -1.54594220e-02f, 2.23504938e-02f, 6.58513084e-02f, 1.21235989e-01f,
  -1.16140842e-01f, -1.90259650e-01f, 2.43212834e-01f, -5.76051846e-02f, -1.84483409e-01f, 2.35039026e-01f, 1.61477089e-01f, 1.58129632e-02f, 2.29722053e-01f, -2.34705821e-01f,
  7.23175332e-02f, 5.13879918e-02f, 2.42173716e-01f, -4.41412739e-02f, 3.98360305e-02f, -7.15780333e-02f, 6.71165287e-02f, 1.15467854e-01f, -3.10172111e-01f, 1.08671874e-01f,
  1.35721967e-01f, 1.10545754e-01f, 5.15159145e-02f, 1.03504248e-01f, -4.21573557e-02f, -1.47692384e-02f, 1.28463730e-01f, 1.56669989e-01f, -2.11052582e-01f, 4.17378664e-01f,
  6.32836223e-02f, 9.55974162e-02f, 2.83161160e-02f, 2.53583223e-01f, 1.66254684e-01f, -5.21650128e-02f, -1.35858366e-02f, -2.07361564e-01f, 2.21461236e-01f, 1.65288925e-01f,
  1.74058065e-01f, -1.08023800e-01f, 3.87088619e-02f, -2.30961755e-01f, -8.07107389e-02f, -3.86443511e-02f, 9.00997445e-02f, 7.72051839e-03f, 1.41311258e-01f, -2.72036374e-01f,
  -4.43044417e-02f, 7.28807971e-02f, 6.35898812e-03f, -6.65484071e-02f, -5.22042029e-02f, -7.64822438e-02f, -3.20265554e-02f, 1.31371081e-01f, 2.22024143e-01f, 1.36373058e-01f,
  2.84689397e-01f, 2.01540664e-01f, 3.14002126e-01f, 1.74165741e-01f, -1.12601116e-01f, -7.45489150e-02f, -1.75412178e-01f, 1.14933923e-01f, -2.34356418e-01f, -7.16240332e-02f,
  1.21540010e-01f, 1.83079183e-01f, 1.06827512e-01f, -4.84985486e-02f, -1.37866169e-01f, -4.61862534e-02f, -1.60495445e-01f, -1.81876436e-01f, 1.42279521e-01f, 1.72629450e-02f,
  -1.38103351e-01f, -7.35063925e-02f, 1.54372305e-01f, 3.90443683e-01f, 1.25945374e-01f, 1.31238133e-01f, -8.20877999e-02f, -3.08692306e-01f, 8.10247101e-03f, -3.96078825e-02f,
  2.66136795e-01f, 6.76730797e-02f, 1.80775434e-01f, -2.44373064e-02f, 2.51326352e-01f, -5.03980182e-02f, 2.22775102e-01f, -4.26787511e-03f, 8.62144753e-02f, -2.36809388e-01f,
  -2.11340234e-01f, -4.32495065e-02f, 2.05094606e-01f, -3.45266759e-01f, -2.66080469e-01f, -4.33728456e-01f, -1.29223034e-01f, 2.84129560e-01f, 6.61478788e-02f, 1.93380758e-01f,
  -7.24687707e-03f, 1.52328223e-01f, -3.19016606e-01f, 1.99864775e-01f, -1.62744641e-01f, 1.60776198e-01f, -4.49397266e-02f, 2.30728686e-01f, 2.95082599e-01f, 1.12998240e-01f,
  -1.79766744e-01f, 5.86499870e-02f, -2.47267019e-02f, 3.33617106e-02f, 1.43000945e-01f, 8.94439071e-02f, 5.26291654e-02f, -5.34195527e-02f, -8.05211291e-02f, 2.07814887e-01f,
  5.66763282e-02f, -1.07829183e-01f, -4.33977693e-02f, 7.42128938e-02f, 7.41773099e-02f, 2.10449159e-01f, -3.12623233e-01f, 7.73660615e-02f, 2.52397005e-02f, 1.26865432e-01f,
  1.33818507e-01f, 1.36245921e-01f, 2.21873121e-03f, 7.34518617e-02f, -8.57404768e-02f, 1.67637736e-01f, 1.28097102e-01f, -9.71579552e-03f, -2.42927428e-02f, 6.53617010e-02f,
  8.86637941e-02f, 1.75356090e-01f, -1.20760918e-01f, -6.20213151e-02f, -8.01806226e-02f, 3.38061340e-02f, 5.39192967e-02f, 9.01100188e-02f, -1.49534285e-01f, 1.86184138e-01f,
  -2.31776237e-01f, -1.19761564e-02f, 2.27358025e-02f, 4.19321954e-02f, 2.31638044e-01f, -3.27100188e-01f, -1.40478939e-01f, 1.64864913e-01f, 3.91805060e-02f, 2.75571316e-01f,
  -1.89056098e-01f, 2.54824430e-01f, -9.84034166e-02f, -1.02805883e-01f, 7.91380927e-02f, -1.12136796e-01f, -1.74967244e-01f, 2.23884180e-01f, -3.18289578e-01f, -8.35207328e-02f,
  -1.91112742e-01f, 2.08149627e-02f, 1.10944942e-01f, -1.63503781e-01f, 2.06310168e-01f, 4.30701487e-02f, -1.62701234e-01f, 2.15964913e-02f, -5.37598953e-02f, -1.04068145e-01f,
  -1.84043899e-01f, -1.92388631e-02f, -3.26256640e-02f, 9.46293771e-03f, 9.56648812e-02f, -1.26450166e-01f, -1.31966844e-01f, -4.69144359e-02f, 5.20283058e-02f, 5.41589921e-03f,
  1.58594608e-01f, -2.54162401e-01f, 3.93831618e-02f, 1.87958837e-01f, 4.17715237e-02f, 2.18424261e-01f, 2.13054404e-01f, -1.26999533e-02f, 3.29935066e-02f, 2.17894629e-01f,
  -2.52840370e-01f, 2.39647739e-02f, 2.56322101e-02f, 1.21776327e-01f, 8.21998566e-02f, 1.60325453e-01f, 5.39289936e-02f, 1.42779186e-01f, -1.10482275e-02f, 5.73524833e-02f,
  1.32602051e-01f, 2.63201207e-01f, 7.28349686e-02f, 7.20752552e-02f, -1.72152787e-01f, -8.55029002e-02f, 9.42262821e-03f, 3.51041905e-04f, 5.16852550e-02f, -1.49766624e-01f,
  -2.40731478e-01f, 1.09323421e-02f, 7.59238303e-02f, 2.15844139e-01f, -2.54577752e-02f, 4.88039106e-02f, 1.58344656e-01f, -1.12875834e-01f, -4.91095409e-02f, 4.21173647e-02f,
  -2.50818860e-03f, 1.13780804e-01f, 7.62516558e-02f, -1.39449969e-01f, -1.21857315e-01f, -7.38629699e-02f, 1.53088480e-01f, -1.54424503e-01f, 2.12986976e-01f, -4.39009070e-02f,
  -7.95273855e-02f, -1.60425566e-02f, -1.86854079e-02f, 3.53542604e-02f, 9.27228574e-03f, -1.38336778e-01f, 1.02473766e-01f, 1.15141764e-01f, -6.03104010e-02f, -1.04070015e-01f,
  -1.81931540e-01f, 1.05850361e-01f, 1.33640736e-01f, 3.23159993e-02f, -3.50032337e-02f, -8.22388455e-02f, 2.64851060e-02f, 1.20375887e-01f, 5.59188500e-02f, 5.90400910e-03f,
  -2.89988667e-02f, 1.67482793e-01f, -1.04394250e-01f, -2.67549872e-01f, -9.68521833e-02f, -7.51991943e-02f, 1.59336120e-01f, 2.55192846e-01f, 1.06530540e-01f, 1.23969316e-01f,
  1.97286740e-01f, -1.29047260e-01f, -1.73174113e-01f, 1.03889257e-01f, -2.91578169e-03f, 1.58637911e-01f, -2.52896219e-01f, -1.30148515e-01f, -2.71068186e-01f, 1.42185822e-01f,
  -1.25664100e-01f, -3.53250392e-02f, 1.56688035e-01f, 5.63577525e-02f, 2.82073021e-01f, 1.13750510e-01f, -1.19846776e-01f, 1.80139050e-01f, -1.33353949e-01f, 3.40250954e-02f,
  -1.90056384e-01f, -5.01209013e-02f, -7.50316903e-02f, -1.36826470e-01f, -2.08522916e-01f, 6.94573997e-03f, 7.69908652e-02f, -1.23866240e-03f, -2.68299550e-01f, 4.12577093e-02f,
  -4.71754558e-03f, 2.86569446e-02f, 5.66754751e-02f, 2.39375785e-01f, 6.18707277e-02f, 1.25484332e-01f, 2.10384667e-01f, 3.30368951e-02f, 9.68807712e-02f, 5.07165752e-02f,
  -1.37572929e-01f, -3.88994515e-02f, 8.84440914e-02f, 1.03487357e-01f, -2.42506161e-01f, 2.34512687e-02f, 1.53040335e-01f, -2.03265026e-01f, 9.83482003e-02f, -2.75388956e-01f,
  -1.73857808e-01f, 1.07438110e-01f, -5.46349734e-02f, -4.55607213e-02f, 5.07898666e-02f, -1.26665711e-01f, -8.11922178e-02f, 1.25196546e-01f, -2.56193131e-01f, 2.81469852e-01f,
  -2.01016530e-01f, 1.48707375e-01f, 3.32558565e-02f, -2.47114360e-01f, -4.15722132e-02f, 1.20518781e-01f, 7.42179602e-02f, 5.69950826e-02f, -2.22075079e-02f, -1.19736813e-01f,
  1.22475982e-01f, -1.05871096e-01f, -7.54753426e-02f, 1.68768018e-01f, 8.60679820e-02f, -2.92601705e-01f, -1.06343739e-01f, 3.94370370e-02f, 3.18921298e-01f, -8.02940503e-02f,
  4.53710780e-02f, -2.65596747e-01f, -9.34597850e-03f, -1.63656510e-02f, -1.78249717e-01f, -9.26072225e-02f, -1.39625654e-01f, 9.48451981e-02f, -1.26186565e-01f, 4.94969711e-02f,
  2.83806934e-03f, -5.83704002e-02f, 2.94614378e-02f, 1.98207080e-01f, -9.00218561e-02f, 4.76056756e-03f, -1.63549073e-02f, 1.60368770e-01f, 1.29356205e-01f, 2.35800192e-01f,
  6.21637553e-02f, 2.91002840e-01f, 2.76092172e-01f, 1.61792666e-01f, 1.41801730e-01f, -2.66162753e-01f, 1.30895540e-01f, -1.71507075e-01f, 3.82875428e-02f, 1.53348520e-01f,
  4.56700586e-02f, -2.78263018e-02f, 7.03270435e-02f, -3.12058538e-01f, -8.48467126e-02f, 3.51361543e-01f, 6.63848817e-02f, 2.03439131e-01f, 2.29008928e-01f, -2.77959555e-01f,
  -4.34059054e-02f, -7.05276579e-02f, -1.83325678e-01f, 2.74194568e-01f, 4.29738164e-02f, 2.08111018e-01f, -3.03341776e-01f, -2.58395616e-02f, 1.06538899e-01f, -4.28228267e-02f,
  -2.10167244e-02f, -8.64881929e-03f, -7.45236874e-02f, 4.07162786e-01f, -1.96429104e-01f, -6.50504827e-02f, 9.50690955e-02f, 2.44563103e-01f, 1.98350698e-01f, -1.24437481e-01f,
  1.52451903e-01f, -1.15594879e-01f, -2.21469045e-01f, 2.56100982e-01f, -6.54925872e-03f, -5.36130858e-04f, 1.33478075e-01f, 2.13897764e-03f, -4.34260249e-01f, 5.27376793e-02f,
  1.88275263e-01f, -8.14788975e-03f, 1.46189079e-01f, -6.83197081e-02f, -8.74641836e-02f, -1.75815225e-01f, 1.29898548e-01f, -1.94388002e-01f, -3.97225544e-02f, -1.43338040e-01f,
  7.75430202e-02f, -1.99345313e-02f, -4.55512060e-03f, 4.81022969e-02f, 5.02176117e-03f, 7.70159960e-02f, 7.08257332e-02f, 7.47808591e-02f, -9.36600491e-02f, -2.52802875e-02f,
  6.67799562e-02f, -7.75442575e-04f, -9.62414443e-02f, 4.30685803e-02f, -1.69908702e-01f, 1.95453689e-03f, 1.52922899e-01f, 1.20635532e-01f, 6.65049255e-03f, 1.21159693e-02f,
  4.64294963e-02f, -6.14598915e-02f, -4.11705345e-01f, 6.73260540e-02f, -1.12655729e-01f, -2.29298621e-01f, -1.77777708e-01f, -2.23978400e-01f, -2.29108423e-01f, -1.98514581e-01f,
  1.59507737e-01f, 1.29426539e-01f, 5.25407568e-02f, 2.73948479e-02f, -5.54348230e-02f, 5.27753755e-02f, -9.67223570e-02f, 1.24055734e-02f, -3.13367665e-01f, 6.53954595e-02f,
  -7.28326365e-02f, 6.29372383e-03f, -1.44908980e-01f, 5.31245731e-02f, 1.36676431e-01f, 2.74337769e-01f, 1.34108916e-01f, -1.56331938e-02f, -7.22524822e-02f, -4.91320081e-02f,
  -1.46482304e-01f, -1.14482865e-01f, 3.49853747e-02f, -1.57884970e-01f, 2.93754060e-02f, 3.59642357e-02f, 2.10148275e-01f, -5.76699451e-02f, 1.04796253e-01f, 2.38679245e-01f,
  -1.87908337e-01f, 1.19466372e-01f, -3.68032873e-01f, 5.55051975e-02f, 1.85776912e-02f, -7.75864124e-02f, 1.36703938e-01f, -6.20497204e-02f, 5.16229384e-02f, 1.60317153e-01f,
  1.18625708e-01f, 1.37889106e-02f, 1.34169787e-01f, 3.38114575e-02f, 4.91139442e-02f, -7.53526092e-02f, -2.03058526e-01f, 2.98542492e-02f, 1.71839982e-01f, -7.73449540e-02f,
  9.51306224e-02f, -2.50921905e-01f, 4.59576361e-02f, 5.00576720e-02f, -2.75586564e-02f, 2.60213371e-02f, 3.51821519e-02f, -1.33722708e-01f, -1.73080280e-01f, 3.25385034e-02f,
  -2.22029701e-01f, 2.67938286e-01f, 1.16271704e-01f, 7.71080330e-02f, 2.59875599e-02f, 9.03953612e-02f, -6.42421618e-02f, 9.02672410e-02f, 2.27934256e-01f, 1.59291208e-01f,
  -1.18254922e-01f, 1.20595910e-01f, -1.61134422e-01f, -6.39177784e-02f, -1.49559195e-03f, 2.35503271e-01f, 1.16666660e-01f, -1.29913867e-01f, -5.61635457e-02f, -1.27689883e-01f,
  1.70076892e-01f, -4.95594479e-02f, -1.05441092e-02f, -1.31326407e-01f, 9.82115343e-02f, -1.58560187e-01f, 1.32774767e-02f, -8.12082440e-02f, 5.27493395e-02f, -7.71503747e-02f,
  8.47750381e-02f, 9.97695029e-02f, 8.99926424e-02f, 4.32083458e-02f, 9.64799076e-02f, -8.87273923e-02f, -9.97942612e-02f, 1.14265978e-01f, 5.43205366e-02f, -3.98413613e-02f,
  3.48054655e-02f, -9.91533473e-02f, 9.96589102e-03f, 1.16276182e-01f, -6.60351291e-03f, -3.61073986e-02f, -8.84966031e-02f, -1.06270751e-02f, 1.60516530e-01f, -9.67683196e-02f,
  9.20542255e-02f, 1.47793353e-01f, 5.66251623e-03f, -2.27692440e-01f, -1.46142870e-01f, 7.77440444e-02f, 1.02382846e-01f, 1.62539586e-01f, -9.15801600e-02f, -8.03234577e-02f,
  1.34392738e-01f, -1.21319965e-01f, 9.02603641e-02f, 5.75456358e-02f, 1.46212429e-01f, -2.27313325e-01f, -1.25896230e-01f, 1.17025800e-01f, -9.02255550e-02f, 5.68185784e-02f,
  2.93635521e-02f, 2.98436228e-02f, 7.90506899e-02f, 9.27896574e-02f, 1.35978963e-02f, 1.50236577e-01f, 9.84280631e-02f, 1.17872000e-01f, 4.97041829e-03f, 2.06367046e-01f,
  2.32763782e-01f, 3.08345437e-01f, -1.84219591e-02f, -5.07949702e-02f, -2.53327012e-01f, -5.92374280e-02f, 6.69079944e-02f, 2.10507378e-01f, 1.44281253e-01f, 5.17575592e-02f,
  1.11244723e-01f, -1.36064857e-01f, 7.12855160e-02f, -6.71844110e-02f, 1.26181185e-01f, 1.48587395e-02f, 1.51321560e-01f, -3.66044253e-01f, -3.90401296e-02f, -1.67275205e-01f,
  7.00976625e-02f, -2.47908831e-02f, -4.21727858e-02f, -3.30497175e-02f, 1.75889269e-01f, 9.37228799e-02f, 1.49078714e-02f, 1.71931550e-01f, 1.62049413e-01f, 5.33262193e-02f,
  2.19313219e-01f, -6.64541684e-03f, 1.27713040e-01f, 1.18854001e-01f, 5.43512069e-02f, 1.03829233e-02f, -1.92655802e-01f, -1.02469698e-01f, 5.07696904e-02f, 2.91966237e-02f,
  1.00354195e-01f, -8.46809223e-02f, -4.16414924e-02f, -1.51954114e-01f, -2.24893510e-01f, -1.44120276e-01f, -9.82751772e-02f, -4.06136662e-02f, 7.02173859e-02f, 2.21547112e-01f,
  -9.46436077e-02f, 9.06726271e-02f, -1.58286765e-02f, -6.15299493e-02f, -1.71026796e-01f, 1.75127700e-01f, 2.37929657e-01f, -3.24148796e-02f, 1.20618574e-01f, -5.24277762e-02f,
  -5.15378406e-03f, 1.69042170e-01f, 1.66747287e-01f, 2.19242349e-01f, -3.60673219e-02f, 1.45177290e-01f, 3.28494571e-02f, 9.39947367e-02f, -1.59961991e-02f, -1.90839302e-02f,
  -8.66848882e-03f, -9.40539688e-02f, -3.03932838e-02f, 4.12477553e-02f, -2.69085139e-01f, -1.76630050e-01f, 2.08695769e-01f, 3.24161381e-01f, -6.09345362e-02f, -3.03806692e-01f,
  9.23247337e-02f, 4.28142510e-02f, -1.60440095e-02f, -7.38461092e-02f, -3.49228689e-03f, 1.44471675e-01f, 2.15843171e-02f, -3.05381268e-01f, 2.21556529e-01f, 6.24640509e-02f,
  8.88776407e-02f, 1.98725224e-01f, 2.24673510e-01f, 2.37375379e-01f, 2.29872331e-01f, -1.48973942e-01f, 2.02936798e-01f, 7.45919123e-02f, -1.84463561e-02f, 1.99153438e-01f,
  2.93206926e-02f, 6.22975118e-02f, 3.62536639e-01f, -1.40420064e-01f, 8.28095973e-02f, -4.40549180e-02f, 1.91256419e-01f, -5.86073548e-02f, -2.17368856e-01f, -1.30110279e-01f,
  -3.67269278e-01f, 5.75412475e-02f, -1.23535641e-01f, 2.74814159e-01f, 1.12497643e-01f, 7.22430572e-02f, -1.88910246e-01f, -2.09007040e-02f, -1.72734454e-01f, 2.15184957e-01f,
  2.01520607e-01f, 1.50060594e-01f, -2.19005853e-01f, 2.34071001e-01f, -2.26168320e-01f, 1.01797134e-01f, 2.02253446e-01f, 2.32776657e-01f, -9.54994559e-02f, 2.15060469e-02f,
  8.57096910e-02f, 3.23258638e-01f, 4.91583422e-02f, -1.31557569e-01f, -4.93425736e-03f, -2.11217761e-01f, -3.56377028e-02f, -1.98958203e-01f, -3.59686404e-01f, -5.44660203e-02f,
  1.14224426e-01f, 2.89775431e-01f, -8.37496519e-02f, -2.89943397e-01f, 1.49961084e-01f, 8.42194408e-02f, 1.83353648e-01f, -6.05195872e-02f, -2.09530100e-01f, 9.96473655e-02f,
  -1.32298693e-01f, -3.72035086e-01f, -7.59358882e-05f, -2.77346168e-02f, -3.28028426e-02f, -2.33907610e-01f, 1.85285568e-01f, -9.86719280e-02f, 2.31074810e-01f, -2.65094582e-02f,
  -1.08306564e-01f, 2.42838591e-01f, 1.70870572e-01f, 7.37662334e-03f, -1.60593875e-02f, 1.12078354e-01f, 2.71177143e-01f, 4.43809390e-01f, -7.99411982e-02f, -2.05635339e-01f,
  1.17125429e-01f, -1.68672949e-01f, -9.72430222e-03f, 1.50061399e-01f, 7.53250578e-03f, 1.97188959e-01f, -2.42640659e-01f, 9.88639817e-02f, -1.78295467e-02f, -1.80134729e-01f,
  1.91528335e-01f, -1.25748783e-01f, 1.01221971e-01f, -8.88941512e-02f, 1.15635820e-01f, -1.22773938e-01f, -3.50350648e-01f, 2.13942409e-01f, -2.84732711e-02f, -9.40337703e-02f,
  4.31520939e-01f, -2.47562909e-03f, -4.39200737e-02f, -7.34549090e-02f, -2.06133977e-01f, -2.85630912e-01f, -1.60146132e-01f, -1.83178604e-01f, -1.15514383e-01f, -1.15445457e-01f,
  1.26569912e-01f, -1.86770603e-01f, 2.53607392e-01f, 2.95730084e-02f, 5.63449189e-02f, -2.24624068e-01f, 4.61104885e-02f, -8.62424225e-02f, -3.11179738e-02f, 2.33986348e-01f,
  3.20803598e-02f, 1.75565839e-01f, 1.83136851e-01f, 6.67295530e-02f, 1.50598720e-01f, 5.88228889e-02f, 6.83028698e-02f, 6.40622526e-02f, 9.49770883e-02f, 2.01089755e-01f,
  2.70189136e-01f, -2.11343840e-02f, 2.04717949e-01f, 1.13721542e-01f, -1.24885812e-01f, 2.10226759e-01f, 5.19451275e-02f, -1.36839837e-01f, -1.50514767e-01f, 7.37754405e-02f,
  -1.23383492e-01f, 3.02133620e-01f, 1.13268033e-01f, -1.16963036e-01f, 1.60211548e-02f, 1.51293650e-02f, -3.78639512e-02f, 2.17297792e-01f, -2.05405634e-02f, 3.42283547e-02f,
  4.83236946e-02f, -1.70116559e-01f, 1.27931342e-01f, -1.61770463e-01f, -3.33046764e-02f, 4.13044095e-02f, -7.77715221e-02f, -7.12129921e-02f, -3.68533097e-02f, -7.16148689e-02f,
  -5.88030331e-02f, -1.38319418e-01f, 1.24523956e-02f, 1.87882215e-01f, 3.01523000e-01f, -9.34408307e-02f, 1.21131288e-02f, 2.29389757e-01f, 4.85501029e-02f, -4.67169806e-02f,
  -9.43017304e-02f, -1.43197611e-01f, 7.07454681e-02f, 1.27598010e-02f, 5.38794883e-02f, 1.09904878e-01f, 2.01290734e-02f, 7.10113868e-02f, 1.55621246e-01f, -2.51884401e-01f,
  1.67488068e-01f, 9.57406983e-02f, -1.24006301e-01f, 6.13383725e-02f, 1.00873858e-02f, 1.13407597e-01f, 1.17907979e-01f, -7.30284676e-02f, -8.84736981e-03f, -2.06202954e-01f,
  -5.65442815e-02f, 8.46194103e-02f, 1.69316843e-01f, 8.21929350e-02f, -1.13677531e-01f, 4.44213338e-02f, -2.68289149e-01f, -7.32154325e-02f, 1.36956722e-01f, -1.17791593e-01f,
  -1.54426157e-01f, -5.04371012e-03f, -1.50911480e-01f, 1.34749845e-01f, -4.65801544e-02f, 3.98154110e-02f, 2.09749073e-01f, -1.24963205e-02f, 1.88755155e-01f, -1.56007186e-02f,
  -1.68597624e-01f, 1.48376837e-01f, -9.74298269e-02f, 2.69038994e-02f, 2.50171900e-01f, -2.22923964e-01f, -1.20161399e-01f, -2.28377149e-01f, -2.03219168e-02f, 3.18007171e-02f,
  -1.36620710e-02f, -1.15584530e-01f, 1.90168282e-03f, -9.28083360e-02f, -1.36844456e-01f, -1.39337003e-01f, -2.07798198e-01f, 2.46818036e-01f, -1.80874407e-01f, -4.91719209e-02f,
  1.21712238e-01f, 2.54525065e-01f, 3.55655879e-01f, -6.62345365e-02f, -7.01467022e-02f, -3.82939652e-02f, 1.35198049e-02f, 5.63245378e-02f, -1.45396441e-01f, 6.42792806e-02f,
  1.16812624e-01f, 6.23624623e-02f, 2.33526304e-01f, -1.00378230e-01f, -2.40345877e-02f, -6.23125071e-03f, -7.43226483e-02f, 3.73656601e-02f, -1.42035067e-01f, 2.30761215e-01f,
  -1.96408197e-01f, -1.68456018e-01f, 1.60147801e-01f, -5.72263636e-02f, 9.11401063e-02f, 7.30506554e-02f, -6.95082694e-02f, -7.45521039e-02f, 8.33440349e-02f, -1.32740870e-01f,
  -2.53475696e-01f, -6.25994056e-02f, 8.25081766e-02f, -3.37877534e-02f, -1.16779022e-01f, 5.02594467e-03f, -1.15104854e-01f, 1.94986582e-01f, -2.61247218e-01f, 1.92458183e-01f,
  2.37832099e-01f, -2.15230346e-01f, 1.58068255e-01f, 1.21975489e-01f, -1.23001914e-02f, 1.59272984e-01f, -8.17012340e-02f, -9.72437486e-03f, 1.74416602e-01f, -2.41845384e-01f,
  7.54453912e-02f, -2.48664171e-01f, -1.38775334e-01f, -6.48441864e-03f, -1.61994576e-01f, 1.35014758e-01f, 7.13929608e-02f, 2.58196308e-03f, 2.61409730e-02f, -8.95725563e-02f,
  -1.57468438e-01f, 2.44495183e-01f, -7.10499808e-02f, -1.14386111e-01f, 3.42457406e-02f, 1.77860469e-01f, 2.63520628e-01f, -2.07673907e-01f, -1.21832304e-01f, 7.07523599e-02f,
  1.44565552e-01f, 2.50452310e-02f, -1.58873573e-01f, -2.74613663e-03f, -1.36531070e-02f, 3.17003019e-02f, 1.84256330e-01f, -1.05663501e-01f, -1.25645235e-01f, -7.14419410e-02f,
  -2.29657575e-01f, 1.90567419e-01f, -1.85169637e-01f, 2.03930631e-01f, -6.61316290e-02f, -2.18848273e-01f, 9.14023444e-02f, 8.32318515e-02f, 9.46261510e-02f, 1.01785280e-01f,
  6.72260448e-02f, 2.56890744e-01f, 3.28782201e-01f, 9.63797420e-02f, 1.33390069e-01f, -1.05410784e-01f, 3.66583839e-02f, 2.09805578e-01f, 1.00186914e-01f, -3.59483659e-02f,
  3.51028033e-02f, -3.33958045e-02f, 5.46716630e-01f, -1.35903805e-01f, -4.43408899e-02f, 2.93167382e-01f, -2.08728686e-02f, 1.24692850e-01f, -2.64135581e-02f, -1.21431589e-01f,
  -2.15204224e-01f, -1.22178085e-02f, -3.06495428e-01f, 1.22482352e-01f, 1.46587715e-01f, 8.56322274e-02f, -2.97434896e-01f, -4.57358509e-02f, 3.96285355e-02f, 2.22553626e-01f,
  1.69619724e-01f, -8.98400694e-02f, 1.34956911e-01f, 4.10121918e-01f, -1.05371751e-01f, -7.21203163e-02f, 1.82315066e-01f, 2.03853786e-01f, -8.98156241e-02f, 2.60160919e-02f,
  8.67387056e-02f, 5.48356295e-01f, -7.00156251e-03f, 2.52370816e-02f, -5.75728752e-02f, -8.43138397e-02f, -2.35798191e-02f, -1.95046768e-01f, -3.81978482e-01f, -1.72120500e-02f,
  -1.26587912e-01f, 7.33134523e-02f, 6.27241656e-02f, -2.49029040e-01f, 2.27557600e-01f, -3.59327495e-02f, -1.19612543e-02f, -8.36178958e-02f, -2.46161401e-01f, -1.68031901e-02f,
  1.49038404e-01f, -1.40476242e-01f, -5.08751981e-02f, -8.24239999e-02f, -4.22349013e-02f, -8.54144171e-02f, -3.69915962e-02f, 3.46838981e-02f, 1.27313033e-01f, -3.54091898e-02f,
  2.88841091e-02f, 6.21738844e-02f, -1.00159170e-02f, -9.24355760e-02f, -3.19106996e-01f, -1.32456142e-03f, -6.47186786e-02f, -2.46909752e-01f, -1.09908976e-01f, 5.79269864e-02f,
  8.23523700e-02f, 9.94758159e-02f, -2.10646048e-01f, -1.37920752e-01f, 6.92131044e-03f, 1.66860074e-02f, -1.68900222e-01f, -6.90843537e-02f, -9.83462259e-02f, -1.10244803e-01f,
  4.48581092e-02f, -5.60451411e-02f, -8.44475776e-02f, -3.98974977e-02f, 1.13007762e-01f, 1.99916914e-01f, -1.54361770e-01f, -3.43339384e-01f, 9.45400912e-03f, 2.99790725e-02f,
  -6.47276407e-04f, 1.77982777e-01f, 8.69210511e-02f, -5.89494407e-02f, 1.49747476e-01f, -1.43600225e-01f, 2.60071248e-01f, -1.26160964e-01f, 1.49392858e-01f, 5.24558611e-02f,
  -1.20639212e-01f, -1.50455773e-01f, -2.65733749e-02f, -1.35787413e-01f, 1.45177571e-02f, 1.73021942e-01f, 3.48340161e-02f, -1.54392004e-01f, 1.47599980e-01f, -9.27143469e-02f,
  2.36731302e-02f, -1.05354577e-01f, -2.72189170e-01f, 1.18835248e-01f, -5.33910505e-02f, 3.00562605e-02f, -9.67752282e-03f, 9.77078304e-02f, 1.16159849e-01f, 6.81530684e-02f,
  1.25080170e-02f, 2.71584038e-02f, 2.19620824e-01f, 1.70705467e-01f, 8.67743939e-02f, -8.36963803e-02f, -7.20705613e-02f, -2.02283897e-02f, 6.90242350e-02f, 5.71657643e-02f,
  3.46444607e-01f, -8.00372511e-02f, -2.05041438e-01f, 2.02429444e-01f, 1.75996587e-01f, 2.09757656e-01f, -1.03468858e-01f, -4.10210062e-03f, -3.45371455e-01f, -1.05637116e-02f,
  -3.54182988e-01f, 2.78204441e-01f, 2.32415915e-01f, -8.10049698e-02f, 3.35654020e-02f, 7.28551969e-02f, -1.39934361e-01f, 8.84340554e-02f, -1.57525502e-02f, 8.04390833e-02f,
  -1.87900811e-01f, -6.15844950e-02f, -6.30946830e-02f, -1.46913212e-02f, 1.26006883e-02f, 2.24855155e-01f, -6.03964590e-02f, -2.66861528e-01f, 2.75101781e-01f, 2.00898901e-01f,
  1.77698210e-02f, 1.40379015e-02f, -9.39444751e-02f, 1.13205172e-01f, -8.91610980e-02f, -9.20309424e-02f, 5.87233417e-02f, -3.16974223e-01f, 3.31988521e-02f, 3.17389630e-02f,
  6.79313345e-03f, 3.96858305e-02f, 2.26813480e-02f, -9.13219340e-03f, -1.28402159e-01f, 8.39190732e-04f, -1.64856061e-01f, 1.03611769e-02f, 2.18464509e-01f, -4.39606719e-02f,
  1.66717932e-01f, 1.59819767e-01f, 1.27730966e-01f, 1.13563940e-01f, 1.94588318e-01f, 6.79668691e-03f, -8.82447287e-02f, 5.07548526e-02f, 2.76520640e-01f, 8.13216195e-02f,
  -1.35508746e-01f, 1.92040488e-01f, 9.24192145e-02f, -3.89861292e-03f, 8.16259906e-02f, -2.28626564e-01f, 3.10507026e-02f, 2.01468961e-03f, 1.86291739e-01f, 5.79136796e-02f,
  -3.19141567e-01f, -4.58523408e-02f, -2.08888516e-01f, -6.10937290e-02f, -1.92774609e-02f, 2.16033861e-01f, 9.43835229e-02f, 6.85043335e-02f, 1.80977091e-01f, 1.36316806e-01f,
  -7.39976317e-02f, 5.62650710e-02f, 2.51247734e-01f, -1.77125894e-02f, -2.96849728e-01f, 7.21786544e-02f, -2.67441094e-01f, 1.35484427e-01f, 1.49012148e-01f, 2.94595748e-01f,
  3.23875993e-02f, -4.23058346e-02f, 3.25528860e-01f, -8.28232393e-02f, 3.10827196e-01f, -1.99483335e-02f, 7.00719208e-02f, 8.57586265e-02f, -1.64112061e-01f, -6.15700074e-02f,
  -2.10569650e-01f, -1.89414471e-01f, 1.26280844e-01f, 1.70860022e-01f, -1.23213470e-01f, -1.95995435e-01f, 9.52728391e-02f, -7.81408474e-02f, -1.61657155e-01f, -5.12237288e-03f,
  -3.09394449e-01f, -9.67986360e-02f, 4.29199375e-02f, 4.23613340e-02f, 8.44016820e-02f, 5.60100712e-02f, 1.87057883e-01f, 7.40053058e-02f, 1.41472727e-01f, 3.49697322e-02f,
  9.76195782e-02f, -2.18579233e-01f, -2.93205947e-01f, 2.77722299e-01f, 2.47692704e-01f, 1.31619796e-01f, 1.15803434e-02f, -2.57649302e-01f, 2.34612718e-01f, 2.65471905e-01f,
  6.11363240e-02f, 9.89536270e-02f, -9.36283097e-02f, -2.97124773e-01f, 5.45378327e-02f, -1.10398695e-01f, -1.35254085e-01f, 2.25554287e-01f, -6.58587879e-03f, -2.66726524e-01f,
  -1.99581116e-01f, 4.99527380e-02f, -2.32808545e-01f, -1.01850539e-01f, -5.02736599e-04f, 1.02132224e-01f, 2.41302643e-02f, -3.28923599e-03f, 1.72592595e-01f, 3.10684703e-02f,
  1.91494539e-01f, -2.01180801e-02f, 2.38703072e-01f, -5.91587014e-02f, 1.40585080e-01f, -2.39120405e-02f, -7.81020299e-02f, 1.41684543e-02f, 1.74723919e-02f, 9.36859697e-02f,
  7.61714429e-02f, -1.25958130e-01f, -1.62757356e-02f, -3.00197273e-01f, 1.03148911e-02f, 2.26384759e-01f, -1.13511868e-01f, 1.08483851e-01f, 9.52120051e-02f, -1.75927803e-01f,
  -1.71138402e-02f, 4.02887352e-02f, 1.06895596e-01f, -1.94393739e-01f, 6.64703501e-03f, 4.96048145e-02f, 8.65070373e-02f, 1.30536472e-02f, 1.55174091e-01f, -1.28313657e-02f,
  3.23368646e-02f, 1.39599651e-01f, 9.33855549e-02f, -1.85598470e-02f, -1.35200778e-02f, -2.67933637e-01f, 2.77405232e-01f, -4.33657542e-02f, 1.27715170e-01f, 1.00270770e-02f,
  9.09036025e-02f, -2.16520041e-01f, 2.67351866e-01f, 6.90125749e-02f, 4.81603071e-02f, 3.02996486e-01f, 3.27706158e-01f, 6.63919821e-02f, 2.37655770e-02f, -1.61857918e-01f,
  1.45466328e-01f, 3.15681934e-01f, -1.10250384e-01f, -4.72914100e-01f, -1.88172355e-01f, -3.89831141e-02f, 6.35549277e-02f, 3.47005250e-03f, 4.30145487e-02f, 2.91837603e-01f,
  -1.85925022e-01f, 1.38390973e-01f, -1.49848849e-01f, 4.71971303e-01f, -8.68608728e-02f, 1.09890096e-01f, -1.43897742e-01f, -1.24568641e-01f, 3.11115268e-03f, -1.47418492e-02f,
  1.44998936e-04f, -1.94338471e-01f, -3.34237039e-01f, 3.29864711e-01f, 3.48493636e-01f, 8.29829201e-02f, 2.64982074e-01f, -2.58846998e-01f, -1.22683449e-02f, 6.02381192e-02f,
  5.18403091e-02f, -3.17568362e-01f, 1.48469627e-01f, -1.37301266e-01f, 8.39346796e-02f, -1.80587903e-01f, 3.81046832e-02f, -2.40020588e-01f, 1.92236304e-01f, -2.40867943e-04f,
  1.89127713e-01f, 1.54771134e-01f, 9.94889140e-02f, -1.21064251e-02f, 1.77233040e-01f, 4.00806278e-01f, 1.31082162e-02f, 1.50750116e-01f, -9.31722373e-02f, -1.76733077e-01f,
  1.89277634e-01f, -9.70663801e-02f, -1.60145804e-01f, 1.30171776e-01f, 2.78464139e-01f, -2.52051532e-01f, -1.08096994e-01f, -6.06722981e-02f, -1.21221855e-01f, 2.45947000e-02f,
  -2.68197060e-01f, -2.71708399e-01f, 1.79455519e-01f, -1.10556483e-02f, -1.10017926e-01f, -8.30387548e-02f, 3.51328403e-02f, 2.84668710e-02f, -3.74417126e-01f, 9.39272419e-02f,
  -1.60574675e-01f, -4.07588452e-01f, 1.05177037e-01f, -4.13301103e-02f, 8.87764990e-02f, -1.09513499e-01f, 2.21360609e-01f, -2.26816423e-02f, 1.46382138e-01f, -2.42451672e-02f,
  4.53789998e-03f, -9.97711793e-02f, -1.00384533e-01f, -2.94990838e-01f, 4.95278761e-02f, 3.99003997e-02f, 3.44198555e-01f, 7.25512654e-02f, -5.64751215e-02f, -4.02001858e-01f,
  -9.81914476e-02f, 9.69125982e-03f, -1.48372382e-01f, -9.05736536e-02f, -5.69494069e-02f, 1.06439553e-01f, -2.35164911e-01f, 2.12796722e-02f, -8.37728009e-02f, -1.27557546e-01f,
  -6.85606077e-02f, 3.05180758e-01f, -2.13313904e-02f, -4.54233922e-02f, -2.67360955e-01f, 1.13980986e-01f, 1.35399193e-01f, 1.30615249e-01f, 1.57844815e-02f, 2.07363978e-01f,
  -5.84199391e-02f, 1.24277219e-01f, -1.24151155e-01f, -5.51416688e-02f, 2.21906260e-01f, -1.26824394e-01f, -1.96326673e-02f, 1.30500600e-01f, -2.64490485e-01f, 8.57419968e-02f,
  -1.75516352e-01f, -4.11156798e-03f, 1.70015633e-01f, -2.09974810e-01f, 9.25450176e-02f, -1.38280734e-01f, -2.17655092e-01f, 1.74742430e-01f, -1.95596516e-02f, 4.73683216e-02f,
  1.93241179e-01f, -1.23572439e-01f, -1.01472400e-02f, -2.87765086e-01f, 8.23291205e-03f, -1.47479903e-02f, 3.83188054e-02f, 5.63641787e-02f, 6.95172027e-02f, -3.06412131e-02f,
  -1.47651806e-01f, -4.84552085e-02f, -3.14130008e-01f, 2.71013528e-01f, -1.09824821e-01f, -9.31945629e-03f, -4.96962704e-02f, 6.34561405e-02f, 2.32475773e-01f, -3.67378928e-02f,
  7.34767094e-02f, 1.93851665e-01f, 1.26547307e-01f, 9.71956179e-03f, -2.99641371e-01f, 1.01977468e-01f, -7.39822015e-02f, -1.50084717e-03f, 2.99713522e-01f, 7.89003298e-02f,
  -3.57154235e-02f, -2.99346782e-02f, 2.53904127e-02f, -6.89785182e-02f, -1.87790930e-01f, 2.41026163e-01f, -3.75938326e-01f, -3.84476706e-02f, 1.94725953e-02f, 8.26416239e-02f,
  4.22132313e-02f, -7.32918754e-02f, 4.44406569e-02f, 1.10002480e-01f, 9.41140726e-02f, -3.07363924e-02f, 3.00881267e-02f, -1.40550137e-01f, 3.39540504e-02f, -4.73696478e-02f,
  -3.44988644e-01f, 3.62604186e-02f, 1.61557138e-01f, -1.69238284e-01f, 4.44687344e-02f, -1.46077693e-01f, -2.21438289e-01f, -5.65051138e-02f, 1.08669616e-01f, -2.16518849e-01f,
  -7.49440044e-02f, 1.16598941e-01f, -7.58124739e-02f, 1.19171245e-02f, -1.38204843e-01f, 3.85665834e-01f, 1.81013048e-01f, 2.71335930e-01f, 1.41266540e-01f, -2.23559723e-03f,
  9.84469578e-02f, 7.58706480e-02f, 3.44732076e-01f, 6.03808947e-02f, -2.30943680e-01f, 8.59502405e-02f, -4.75194417e-02f, 8.76689553e-02f, 9.98676568e-02f, 2.41667390e-01f,
  -9.79454070e-02f, -2.30488718e-01f, -1.29569992e-01f, 5.35388710e-03f, 4.69290704e-01f, -5.15844859e-02f, 2.37615369e-02f, -3.21429610e-01f, -1.25723734e-01f, -9.49468687e-02f,
  1.51839964e-02f, -9.48350430e-02f, -4.09119390e-02f, 1.30748019e-01f, 7.76608810e-02f, -2.04875767e-01f, -7.94263557e-02f, -1.41834700e-02f, 2.83578550e-03f, 1.27120078e-01f,
  -2.62703020e-02f, 3.53129990e-02f, -7.68426955e-02f, 2.76296556e-01f, 2.75159907e-02f, -1.33282272e-02f, -4.89376672e-03f, -1.15999758e-01f, -1.52136475e-01f, 9.31601450e-02f,
  2.86856256e-02f, 5.42489849e-02f, -1.92350075e-01f, 1.62362710e-01f, 2.00059071e-01f, -5.56330234e-02f, -1.68819919e-01f, -3.71060185e-02f, -1.48061574e-01f, 2.12739006e-01f,
  1.02473743e-01f, -1.74093172e-01f, -1.28414467e-01f, -2.14358836e-01f, -1.53371364e-01f, 7.49643520e-02f, -8.40888172e-02f, 4.63758707e-02f, 3.10591042e-01f, -2.51689553e-02f,
  -1.24733955e-01f, -5.74428439e-02f, -1.26349851e-01f, 1.05201036e-01f, -1.17613308e-01f, 1.33689493e-01f, 6.24827780e-02f, -9.26947892e-02f, 8.52691308e-02f, -9.92303118e-02f,
  8.05571973e-02f, 1.09777771e-01f, 8.71514678e-02f, 9.86345634e-02f, 4.87228371e-02f, 1.09855711e-01f, 7.83925429e-02f, -1.07718036e-01f, -7.73585886e-02f, -4.81873238e-03f,
  8.45417157e-02f, 1.88705102e-01f, 1.84376463e-02f, -6.31784126e-02f, -1.11941658e-01f, -1.61745563e-01f, 2.09712699e-01f, -1.59317583e-01f, -9.61082354e-02f, -4.72566895e-02f,
  -1.94436759e-02f, 3.15848924e-02f, 2.03518514e-02f, -7.36575052e-02f, 4.36361432e-02f, 5.83689287e-02f, -6.62870854e-02f, -1.71673536e-01f, 2.22090319e-01f, -2.41132248e-02f,
  1.40069192e-02f, 1.98189858e-02f, 1.23052210e-01f, 7.52332434e-02f, 7.63462111e-02f, 1.47942960e-01f, -3.92933100e-01f, 1.50570646e-01f, 2.61060715e-01f, -2.27595985e-01f,
  -8.35235640e-02f, 1.41075879e-01f, -2.78774828e-01f, 2.67822623e-01f, 2.60283113e-01f, -1.79191932e-01f, -2.65671104e-01f, -1.01730488e-01f, 7.57883266e-02f, 5.06820204e-03f,
  8.95346925e-02f, -1.20064981e-01f, 2.45024666e-01f, -2.38101244e-01f, -1.70872033e-01f, -3.71747762e-02f, 5.98125271e-02f, 3.09332442e-02f, -7.00289384e-02f, -1.54636428e-01f,
  -1.32845536e-01f, -1.72980085e-01f, 1.67963579e-01f, -1.84821367e-01f, 4.37959507e-02f, 1.04635440e-01f, 1.97333783e-01f, -1.23099692e-01f, -9.30609778e-02f, 1.87145457e-01f,
  -4.81896363e-02f, 6.69637173e-02f, -2.69649863e-01f, -1.84330568e-01f, 1.62560008e-02f, 1.77645370e-01f, 7.06858486e-02f, 2.72643715e-01f, -2.71467846e-02f, 1.74173601e-02f,
  4.44462262e-02f, -2.70002574e-01f, 7.54168034e-02f, 2.08719313e-01f, 1.42835215e-01f, 5.50793558e-02f, -2.82922834e-02f, 1.40081316e-01f, -8.01142305e-04f, 1.07984200e-01f,
  -3.86289619e-02f, -1.43593848e-01f, 1.83162212e-01f, 1.73604712e-01f, 1.14124164e-01f, 1.08270183e-01f, 1.99967772e-01f, -6.77666515e-02f, -1.02832869e-01f, -4.87404168e-02f,
  2.82150805e-01f, 1.53583094e-01f, -1.64684623e-01f, 4.48408276e-02f, -1.22331135e-01f, 8.93066823e-02f, 1.37096241e-01f, 2.15403736e-02f, -6.33260831e-02f, -2.07953975e-01f,
  1.98804751e-01f, 3.30922031e-03f, -1.92315832e-01f, 1.07411295e-01f, 1.17165968e-01f, -7.24780858e-02f, 6.49122074e-02f, 3.04394178e-02f, 2.55063176e-02f, -2.07454294e-01f,
  1.15898345e-02f, -3.39115895e-02f, -4.28349599e-02f, -1.54394042e-02f, 2.12842703e-01f, 1.76861230e-02f, -2.86881357e-01f, -1.47848561e-01f, 2.82620061e-02f, 1.18626252e-01f,
  1.06972612e-01f, 1.31379500e-01f, -3.72050926e-02f, 1.02430314e-01f, 3.44306566e-02f, -2.68764436e-01f, 3.19975972e-01f, -1.51357323e-01f, 4.08171536e-03f, -3.62635218e-02f,
  -2.71474779e-01f, -1.64310768e-01f, -1.84229597e-01f, 1.76369175e-01f, 1.82034850e-01f, 1.35983810e-01f, 1.23675196e-02f, -1.85378447e-01f, -5.61506338e-02f, 1.70830712e-01f,
  -5.53492494e-02f, 1.84439123e-01f, -2.44906783e-01f, -2.07222253e-01f, -2.20599510e-02f, 1.23371214e-01f, 1.68289378e-01f, -1.18684175e-03f, 9.49943140e-02f, 1.43054068e-01f,
  6.67926073e-02f, 8.59432593e-02f, 7.28428215e-02f, 8.48061144e-02f, -1.04860425e-01f, 6.45310283e-02f, -3.44765671e-02f, -1.30159989e-01f, -2.28883047e-02f, 3.98110487e-02f,
  -6.58813771e-03f, -3.03157926e-01f, 3.74846160e-02f, 1.22866169e-01f, 5.51531687e-02f, 1.78288072e-02f, 3.04675668e-01f, -2.80774981e-01f, 1.08216256e-01f, -5.69681916e-03f,
  -1.10276928e-02f, 3.01489174e-01f, 3.20996456e-02f, 1.00193515e-01f, -1.34223431e-01f, 1.88397765e-02f, -7.35107884e-02f, 1.51912481e-01f, -4.40071151e-02f, 1.04839630e-01f,
  3.27997118e-01f, 1.76317811e-01f, 1.23173542e-01f, -1.49042353e-01f, -1.42110452e-01f, 8.19274187e-02f, 1.05416626e-01f, -6.35518357e-02f, -2.26422086e-01f, -3.14645562e-03f,
  -7.73377344e-02f, -8.65023881e-02f, -5.60545586e-02f, -1.43224567e-01f, 1.53848201e-01f, 1.40972048e-01f, -6.92795739e-02f, -2.26120297e-02f, -3.13764624e-02f, 2.74886340e-01f,
  -3.54389809e-02f, 2.31863394e-01f, -6.23014607e-02f, 1.94253270e-02f, -6.87211603e-02f, -8.79194364e-02f, 1.90005943e-01f, -5.68993688e-02f, -1.95836797e-02f, -1.33506097e-02f,
  6.67918921e-02f, 1.87758952e-02f, 1.28339425e-01f, 9.55217108e-02f, -2.64993489e-01f, 1.31166160e-01f, -1.98158368e-01f, -4.45114309e-03f, 1.59580633e-02f, 1.10127315e-01f,
  -2.75272936e-01f, 1.60531893e-01f, 3.14152092e-01f, -1.49382755e-01f, 2.40953460e-01f, -1.06947012e-01f, -6.90056607e-02f, 2.31545419e-01f, -8.48446786e-03f, 4.66341600e-02f,
  7.46093467e-02f, 2.16308296e-01f, 6.44321889e-02f, -1.89080611e-01f, -1.85005367e-02f, 1.45602733e-01f, -6.04404695e-02f, 1.63064674e-01f, 2.07236603e-01f, 6.90285414e-02f,
  1.32573232e-01f, 1.62827759e-03f, -2.61035468e-03f, -8.98969024e-02f, 1.66648835e-01f, -1.23952277e-01f, 2.33578309e-01f, -1.36556953e-01f, -2.19221935e-01f, 4.49366570e-02f,
  4.36985306e-02f, -2.91756421e-01f, 5.80258891e-02f, 3.47406268e-01f, 3.75841111e-01f, 1.36018753e-01f, 9.23018157e-03f, 4.89657791e-03f, -2.38827109e-01f, -7.03780651e-02f,
  1.00981496e-01f, 1.82064384e-01f, -3.79635058e-02f, 2.00681373e-01f, -1.97636634e-01f, -2.06836220e-02f, -1.03541784e-01f, -6.39773309e-02f, -5.60153313e-02f, 6.83787614e-02f,
  5.53732477e-02f, 6.00861013e-02f, 2.30804440e-02f, 2.32743602e-02f, -1.54728204e-01f, -3.46736014e-02f, -2.68952013e-03f, -1.69680398e-02f, -1.29657760e-01f, -4.05149534e-02f,
  -4.10831831e-02f, 1.10873215e-01f, 1.08678535e-01f, -4.82246391e-02f, -1.19146995e-01f, 7.74467969e-03f, -2.79005140e-01f, -1.86199114e-01f, -2.46867269e-01f, -2.53464341e-01f,
  1.86840370e-01f, -3.75994563e-01f, -1.66262090e-01f, -2.50504166e-02f, -8.94775242e-02f, -1.12594277e-01f, 1.11245774e-01f, 7.59441778e-02f, 1.18496537e-01f, 3.39318514e-02f,
  -1.72650620e-01f, -1.56859264e-01f, 7.79720843e-02f, 7.52662420e-02f, -6.53776303e-02f, 2.69403636e-01f, 1.15934484e-01f, 3.07582945e-01f, -2.61428475e-01f, -5.57218432e-01f,
  -7.94446692e-02f, 2.60397960e-02f, -8.93780962e-02f, 3.31815183e-01f, 1.76430732e-01f, 8.78822953e-02f, 1.19976014e-01f, 7.52042085e-02f, 2.87917405e-01f, -1.86137438e-01f,
  1.06888779e-01f, 1.40355214e-01f, 3.21664438e-02f, -1.23389035e-01f, 1.58969462e-02f, -9.64405853e-03f, 2.81668931e-01f, 1.91033542e-01f, -7.19383359e-02f, -2.72830538e-02f,
  1.15723044e-01f, -1.18398100e-01f, 3.82558107e-02f, -5.32433800e-02f, -4.70651239e-02f, 1.56218596e-02f, -2.03561276e-01f, 1.29159331e-01f, 8.42309296e-02f, 1.41967952e-01f,
  3.79410088e-02f, 1.08813331e-01f, 4.43158746e-02f, 6.38034195e-02f, 1.97012722e-01f, 1.15897618e-01f, 3.24227922e-02f, 1.49520545e-03f, 9.87521112e-02f, 1.65029928e-01f,
  -2.93563306e-02f, -1.96874738e-01f, 1.04479857e-01f, 1.50639161e-01f, 1.26115665e-01f, 1.91837057e-01f, -6.69825673e-02f, -1.41863689e-01f, 2.10368838e-02f, -1.39395699e-01f,
  1.46979958e-01f, 2.21485198e-01f, -1.62274808e-01f, -2.26173267e-01f, -9.56089608e-03f, 6.97062686e-02f, -1.15052566e-01f, -3.46674472e-02f, -1.44669525e-02f, 1.75998747e-01f,
  -1.50966486e-02f, 1.61441535e-01f, -1.53435200e-01f, 1.75957531e-02f, -3.75347994e-02f, -6.24715202e-02f, 1.75728127e-02f, -5.83488904e-02f, 1.20865218e-01f, 1.12146176e-01f,
  -8.45766440e-02f, 1.50301591e-01f, -1.36810914e-03f, 1.05395339e-01f, 2.35416412e-01f, -6.98963255e-02f, 7.25771040e-02f, -2.00454101e-01f, -1.31159693e-01f, 1.90762594e-01f,
  -1.66155204e-01f, -1.29619315e-01f, 1.35507315e-01f, -1.75323963e-01f, 1.09316938e-01f, -1.37194380e-01f, 1.45019144e-01f, -1.62817076e-01f, 9.71722603e-02f, 8.26498643e-02f,
  -1.40980864e-02f, 1.36234105e-01f, 1.89114604e-02f, 6.58335462e-02f, 4.78495695e-02f, 3.52259241e-02f, 6.96099736e-03f, 2.96219788e-03f, 1.38980001e-01f, 1.16685167e-01f,
  -3.48855197e-01f, 3.30278873e-01f, 3.31749022e-02f, -5.65336123e-02f, -5.50073907e-02f, -9.00427848e-02f, 1.23146392e-01f, 2.82968640e-01f, 1.17324367e-01f, 9.13949609e-02f,
  -3.56375545e-01f, -2.77042687e-01f, -1.43860877e-02f, 7.10177720e-02f, -2.08531573e-01f, 2.79994705e-03f, 2.53438205e-01f, -2.16470823e-01f, 1.62345931e-01f, 1.90752745e-01f,
  -1.65910080e-01f, -1.12905793e-01f, -1.57018661e-01f, 1.00170530e-01f, -1.67647615e-01f, 1.08522354e-02f, 2.09155023e-01f, -3.93153399e-01f, 2.80113041e-01f, 6.83749393e-02f,
  1.21251024e-01f, -1.14493690e-01f, 7.39298090e-02f, 1.57350525e-01f, -2.18874902e-01f, 2.11849734e-01f, -4.69881073e-02f, -6.17362224e-02f, -9.75338891e-02f, -9.96270701e-02f,
  3.04568838e-02f, -4.49658893e-02f, -7.92075647e-04f, 2.50737607e-01f, 2.37438772e-02f, 1.86417237e-01f, 1.60522051e-02f, -1.95091248e-01f, -1.18119605e-01f, 1.23907723e-01f,
  1.59577161e-01f, -2.56878197e-01f, 1.48572996e-01f, 3.84736471e-02f, 4.98641171e-02f, 1.49740949e-02f, -1.15438318e-03f, 9.62171331e-02f, 6.92040892e-03f, -8.06813035e-03f,
  9.96836871e-02f, 2.31474787e-02f, -1.26943588e-02f, -6.51259348e-03f, -1.48896962e-01f, -8.20488706e-02f, -4.47685830e-02f, -1.09806629e-02f, 7.66549334e-02f, 4.97712679e-02f,
  -2.43985765e-02f, -1.82581350e-01f, 1.26191974e-01f, 1.47101372e-01f, -1.98279217e-01f, 1.94824412e-01f, 1.02730311e-01f, -1.50613442e-01f, 1.22976050e-01f, 1.11955151e-01f,
  -3.39653753e-02f, 5.32844104e-02f, 4.51981798e-02f, -8.44123214e-02f, -2.28222776e-02f, -1.62524909e-01f, 4.11301404e-02f, 6.64751232e-02f, -3.06432694e-01f, 9.80842337e-02f,
  6.25650883e-02f, 1.31071538e-01f, 4.24049497e-02f, -9.58498865e-02f, -1.84497654e-01f, 1.15579434e-01f, -2.67618243e-02f, -1.32107623e-02f, -2.38157287e-02f, 6.99521229e-02f,
  -7.59898722e-02f, -1.11036636e-02f, -6.96499720e-02f, 3.93232666e-02f, 5.25684580e-02f, 1.78106561e-01f, -1.38258487e-01f, -7.70528289e-03f, -1.24543905e-01f, 8.11488330e-02f,
  4.03544344e-02f, 2.58540750e-01f, 1.18952722e-03f, -2.44884491e-01f, 6.71435595e-02f, -2.05119908e-01f, 1.41453743e-01f, 3.65500376e-02f, -3.76833454e-02f, -6.83052242e-02f,
  3.58562507e-02f, 8.36080462e-02f, 2.21155897e-01f, 1.64829269e-01f, -5.53316958e-02f, 1.72674224e-01f, 1.39389280e-02f, 9.22567546e-02f, -1.24750853e-01f, 2.18696386e-01f,
  9.01283696e-02f, -1.06134064e-01f, -1.98021028e-02f, -1.80535689e-02f, -1.66278318e-01f, -2.42741331e-01f, 1.80938572e-01f, 1.12541474e-01f, -1.90901667e-01f, -2.69615259e-02f,
  1.66258425e-01f, -7.13307410e-02f, 7.50257671e-02f, 1.15578204e-01f, 1.42352611e-01f, -1.98528990e-02f, -1.18896618e-01f, 1.98642805e-01f, 6.67101098e-03f, -1.02613434e-01f,
  -3.40007804e-02f, 7.31758103e-02f, -8.27425346e-02f, 1.03596278e-01f, 2.69521892e-01f, -2.81588823e-01f, 2.49086916e-01f, 8.52658525e-02f, -1.56009361e-01f, 1.84997723e-01f,
  6.15787283e-02f, 9.50354934e-02f, -5.95509186e-02f, 3.25071990e-01f, 2.59419642e-02f, -7.47301206e-02f, -9.74706933e-02f, -1.03518032e-01f, -2.60690916e-02f, -5.30023640e-03f,
  -3.94980377e-03f, 1.13357939e-01f, 7.81817883e-02f, 3.41661215e-01f, -1.25177633e-02f, 2.14188159e-01f, 1.86638892e-01f, -1.96948156e-01f, -2.07722448e-02f, -3.31738800e-01f,
  5.27290218e-02f, 1.18961073e-01f, -5.47224917e-02f, -9.28613171e-02f, 6.52027950e-02f, -5.53643145e-03f, 3.24426289e-03f, -4.23456356e-02f, -5.00944350e-03f, 1.46260560e-01f,
  -2.21999232e-02f, -1.17976237e-02f, -1.76988080e-01f, 1.56890154e-01f, 2.72673666e-01f, 5.62922321e-02f, 8.47546905e-02f, -2.06965774e-01f, 5.20649850e-02f, 2.27385119e-01f,
  1.42451078e-01f, -5.30328862e-02f, -2.13893801e-02f, -2.08827615e-01f, 1.63563974e-02f, -1.08809449e-01f, -2.02969322e-03f, 2.14582980e-01f, 3.01235225e-02f, -3.96767259e-01f,
  -5.77161722e-02f, -1.23686064e-02f, -1.80200994e-01f, 2.54079830e-02f, -5.33227548e-02f, 1.10783756e-01f, -1.59274980e-01f, 3.40741165e-02f, -7.49985129e-02f, 1.43134594e-01f,
  -8.76611769e-02f, 6.63775504e-02f, -3.32922451e-02f, -1.03483954e-02f, 2.78324764e-02f, 2.25639835e-01f, -1.31551921e-02f, 1.07256837e-01f, -1.17503211e-01f, 1.13473631e-01f,
  1.46355614e-01f, 1.07428201e-01f, 2.26658404e-01f, -2.28624508e-01f, 1.72520187e-02f, 2.85950273e-01f, -1.83855683e-01f, -1.62269324e-01f, -3.93881055e-04f, -2.56317317e-01f,
  5.80005571e-02f, 2.19749082e-02f, 1.51473582e-01f, -1.39401570e-01f, 1.86425269e-01f, 1.05351746e-01f, 1.27337307e-01f, -5.47390357e-02f, 9.74573120e-02f, 7.34961554e-02f,
  1.20182626e-01f, 1.52175203e-01f, 3.35723609e-01f, 8.24605823e-02f, 1.47649363e-01f, -3.73349115e-02f, -2.27239635e-02f, 3.45882550e-02f, 9.34081152e-03f, 3.71194966e-02f,
  -2.48016879e-01f, -3.59271020e-01f, -1.54911071e-01f, -1.69700503e-01f, 2.03855053e-01f, 2.16927286e-02f, -1.57552838e-01f, 2.34133244e-01f, -1.81917116e-01f, -1.57365963e-01f,
  -7.68702448e-05f, -1.00328133e-01f, 7.70165473e-02f, -3.19107622e-01f, -1.80385381e-01f, -1.88202798e-01f, -8.61500204e-02f, 1.57262646e-02f, 1.37219235e-01f, 2.32515082e-01f,
  -8.25195536e-02f, -4.25324254e-02f, -8.31136778e-02f, -3.02411299e-02f, -3.83300781e-01f, 1.52327865e-02f, -1.59397587e-01f, -7.13751167e-02f, -1.89978071e-02f, 3.74266684e-01f,
  3.34109068e-01f, 6.21393263e-01f, -2.30692208e-01f, -3.45390327e-02f, 1.14460364e-01f, 5.58776446e-02f, -2.42537230e-01f, -9.30377394e-02f, -7.55499974e-02f, -3.60259235e-01f,
  -4.47187796e-02f, -4.58594203e-01f, -1.07875086e-01f, -1.21840782e-01f, 4.75118876e-01f, -1.92932889e-01f, -1.07811682e-01f, -2.12878034e-01f, -3.96489292e-01f, 9.42294970e-02f,
  9.25793722e-02f, -8.66487622e-02f, 3.42378765e-02f, -1.78903677e-02f, 5.76811135e-02f, 1.37106061e-01f, 4.64599691e-02f, 1.16070800e-01f, -6.52801469e-02f, 4.93592881e-02f,
  -2.68785488e-02f, 1.19146377e-01f, 7.14925528e-02f, -7.73682892e-02f, -2.01926738e-01f, -2.82789320e-01f, -2.70625710e-01f, 1.84478000e-01f, 6.77300394e-02f, -2.98805267e-01f,
  2.29354994e-03f, -3.20242047e-01f, -9.85257253e-02f, 5.89915775e-02f, 1.68670282e-01f, -2.32043609e-01f, 1.38034865e-01f, -2.97615767e-01f, -3.51213902e-01f, -1.28087163e-01f,
  9.73875299e-02f, -2.76417993e-02f, -5.56625128e-02f, 5.28078061e-03f, 7.22860470e-02f, -1.90552369e-01f, -1.43415451e-01f, -2.62368977e-01f, 3.56588587e-02f, 1.56020537e-01f,
  6.83867186e-02f, -7.83862323e-02f, 2.18822975e-02f, 2.65570700e-01f, 2.45570112e-02f, 1.51144132e-01f, -4.24457863e-02f, -3.99719924e-02f, 3.80235119e-03f, 2.12217599e-01f,
  -8.15358907e-02f, 3.65934893e-02f, 1.73971891e-01f, -1.76857579e-02f, 3.79647687e-02f, 9.84980166e-02f, 9.81692597e-02f, -2.33617306e-01f, -1.31723369e-02f, -6.49877191e-02f,
  -9.37589630e-02f, -2.25568116e-01f, -1.52040467e-01f, 4.78189401e-02f, 3.79239842e-02f, 3.76451351e-02f, -7.95394555e-02f, 1.58244185e-02f, 1.12500042e-01f, 1.31730765e-01f,
  3.68227214e-02f, 1.10008828e-01f, -4.71340865e-02f, 2.74568684e-02f, 7.03059807e-02f, -7.57213756e-02f, -8.62615630e-02f, 4.95512225e-03f, 2.09423199e-01f, -2.30826084e-02f,
  1.24403134e-01f, -1.16152033e-01f, 5.22624217e-02f, 1.51746556e-01f, 6.40777126e-02f, -5.34348711e-02f, 4.54488359e-02f, 3.95097472e-02f, -4.64549623e-02f, -2.05813915e-01f,
  -2.99985483e-02f, 1.82117477e-01f, 1.65114388e-01f, 1.05379581e-01f, -3.15957367e-02f, 1.83889151e-01f, -1.09902974e-02f, -8.01296532e-02f, 4.87577058e-02f, -5.02367467e-02f,
  5.25454851e-03f, 1.10614307e-01f, -3.82835940e-02f, 8.22126959e-03f, -1.76871583e-01f, 9.23432186e-02f, 3.21989916e-02f, 9.53416165e-04f, 2.57033445e-02f, -8.66725594e-02f,
  -2.99577247e-02f, 7.61682317e-02f, 3.54413539e-02f, 1.08753867e-01f, -1.14866130e-01f, -4.29408215e-02f, -2.32166797e-01f, -3.10835820e-02f, -7.19108209e-02f, -1.08646251e-01f,
  -2.01697543e-01f, 9.24952552e-02f, -3.70116197e-02f, 8.22746307e-02f, -7.17031136e-02f, 2.05477811e-02f, -1.60779327e-01f, 1.17235787e-01f, -3.20317410e-02f, 1.79071233e-01f,
  4.43895161e-02f, 1.69318601e-01f, 1.25907481e-01f, 9.49775577e-02f, 6.08134493e-02f, -9.03124269e-03f, 1.04290945e-03f, 1.10366857e-02f, 1.54347718e-01f, 1.89171851e-01f,
  -1.32904742e-02f, 1.11911632e-01f, 4.66030352e-02f, 2.29044855e-01f, 7.84323215e-02f, 1.28913194e-01f, 5.36529860e-03f, -1.70409054e-01f, 1.83279902e-01f, 1.08909803e-02f,
  -1.86807111e-01f, 1.57809675e-01f, -1.38651758e-01f, -9.52904373e-02f, 6.76143169e-02f, 6.36223629e-02f, 1.08751580e-01f, -1.05932303e-01f, -2.29764134e-01f, 1.48397982e-02f,
  -2.39845678e-01f, 7.08224773e-02f, 2.55369037e-01f, 5.22523858e-02f, -2.93137014e-01f, -3.98618169e-03f, -1.40251011e-01f, 6.80069849e-02f, 2.30320618e-01f, -5.76053821e-02f,
  -1.05256617e-01f, 1.20142281e-01f, 1.88000545e-01f, 9.82173532e-02f, -8.92693847e-02f, -8.80025700e-02f, 7.29797408e-02f, 8.93514901e-02f, 4.73816134e-02f, -2.03536317e-01f,
  -7.74331912e-02f, 1.96929649e-02f, 1.82089329e-01f, -8.72395411e-02f, -1.14653215e-01f, -2.05836818e-01f, -1.32480813e-02f, 2.04143167e-01f, 2.12651938e-02f, 2.19851166e-01f,
  -1.21298268e-01f, 2.05801651e-02f, 5.48880221e-03f, -2.17439815e-01f, 1.47627145e-01f, 1.08010046e-01f, 2.49458421e-02f, -1.23233616e-01f, 6.09144531e-02f, 7.03347847e-02f,
  4.25018333e-02f, 9.85442773e-02f, 7.15343375e-03f, 6.88711479e-02f, 2.04485610e-01f, 3.56213003e-02f, 8.15250501e-02f, 1.11102194e-01f, -3.03874835e-02f, 3.39273065e-01f,
  1.27468601e-01f, -1.84884489e-01f, 1.22282960e-01f, -1.04502514e-01f, -2.62260795e-01f, 1.97785899e-01f, -3.81450355e-02f, -7.77739435e-02f, -7.55651388e-03f, -1.19207419e-01f,
  -7.84616396e-02f, -1.11171082e-01f, -3.01819164e-02f, 4.45176475e-02f, 8.01564604e-02f, -2.62889534e-01f, 1.95554912e-01f, -7.48456717e-02f, -8.66395608e-02f, -1.51786730e-01f,
  1.91753030e-01f, 3.20396014e-02f, 1.47857487e-01f, -1.64019555e-01f, 1.05550542e-01f, 7.69439712e-02f, -8.51614326e-02f, -2.11545691e-01f, 5.53243011e-02f, 1.11632735e-01f,
  -6.00406490e-02f, 8.98548961e-02f, 4.13356237e-02f, -1.46581739e-01f, -1.91720296e-02f, 1.90161243e-01f, -5.10800555e-02f, -8.62068161e-02f, 6.00456037e-02f, -4.59861942e-02f,
  -3.55996639e-01f, 3.51304352e-01f, 5.01693115e-02f, 1.26787990e-01f, 1.53898254e-01f, 1.36171822e-02f, 1.16978595e-02f, -6.95040748e-02f, 4.86623421e-02f, -4.12216783e-02f,
  -2.86884196e-02f, 1.45529052e-02f, 8.12665448e-02f, 1.67842641e-01f, -2.51284651e-02f, -6.01588329e-03f, -2.05936357e-01f, -6.62010536e-03f, 8.90872926e-02f, -7.12035522e-02f,
  -5.82701489e-02f, 1.64147243e-01f, -5.15588224e-01f, -1.93216145e-01f, 7.07582086e-02f, 1.33524537e-01f, -3.14023852e-01f, 8.77447873e-02f, 4.27024402e-02f, -2.23517641e-01f,
  7.16335624e-02f, 1.39473811e-01f, 1.78444937e-01f, 9.55834836e-02f, -6.94250390e-02f, 1.44448340e-01f, -1.98948979e-01f, -1.35462493e-01f, 8.32569227e-03f, 5.94951659e-02f,
  -1.01012163e-01f, 1.84695646e-01f, 1.96260199e-01f, 8.16763341e-02f, -7.25223571e-02f, 5.58480062e-02f, -1.54822301e-02f, 1.80423334e-01f, 6.54781610e-02f, 2.61481740e-02f,
  -1.74820766e-01f, -9.22910422e-02f, -8.82450491e-02f, -6.40480816e-02f, -8.53935406e-02f, -2.45792861e-03f, 1.54105932e-01f, 2.83714026e-01f, 2.60287002e-02f, -1.32960260e-01f,
  9.13738385e-02f, -1.18305564e-01f, 9.19430703e-03f, 3.77394140e-01f, 8.34650025e-02f, -2.48773500e-01f, 1.03810266e-01f, -6.37629330e-02f, 4.65890653e-02f, 8.00954923e-02f,
  -1.46614835e-01f, -1.05111241e-01f, -4.59585302e-02f, 7.06690103e-02f, -1.02386922e-02f, 8.75774771e-03f, 1.17816981e-02f, -7.08049163e-02f, -3.90306972e-02f, -2.85857059e-02f,
  1.34826049e-01f, -1.80760875e-01f, 3.48512828e-02f, 1.02547333e-01f, -1.29563987e-01f, 1.38123721e-01f, -2.17850655e-01f, -1.81564003e-01f, 7.30867758e-02f, 1.38185963e-01f,
  2.33193524e-02f, 1.83635831e-01f, -3.74906510e-02f, 1.73811287e-01f, -1.52253211e-01f, 3.66013199e-02f, 1.20197885e-01f, 5.37195466e-02f, -2.22737584e-02f, -5.39734699e-02f,
  1.77831315e-02f, 8.79143775e-02f, 7.58863613e-02f, 9.64841321e-02f, 1.79683983e-01f, 1.16540678e-01f, -1.74569309e-01f, -1.80627510e-01f, -3.49323149e-03f, 1.71492100e-01f,
  -1.80354550e-01f, 7.55221164e-03f, -4.89114001e-02f, -8.04525837e-02f, 2.28790641e-01f, -2.93795228e-01f, 1.84957460e-01f, 2.99862713e-01f, 1.67996138e-02f, 3.01223278e-01f,
  -2.52296358e-01f, -9.23265982e-03f, 4.82281893e-02f, -1.83436006e-01f, 3.43250871e-01f, 9.05687828e-03f, 1.56038776e-01f, 5.39039522e-02f, -1.45157903e-01f, -7.44994655e-02f,
  -1.88142031e-01f, 8.61436352e-02f, -2.25879461e-01f, 4.47114632e-02f, 2.55516350e-01f, 6.01833984e-02f, 2.83551455e-01f, 1.05249792e-01f, 4.25718203e-02f, 1.50190398e-01f,
  1.82923570e-01f, 2.30788421e-02f, 3.08383733e-01f, 5.31319492e-02f, -2.55169153e-01f, 2.77506560e-01f, 1.49350658e-01f, -1.01711348e-01f, 4.01362441e-02f, 1.23622730e-01f,
  2.58262306e-01f, 3.80599529e-01f, -3.04865353e-02f, -8.58707204e-02f, -7.25025460e-02f, -8.81610718e-03f, -1.65981948e-01f, 5.88877872e-02f, -2.30691850e-01f, 2.26896033e-02f,
  1.03237405e-01f, 1.77499741e-01f, 2.29641303e-01f, 7.69711286e-02f, 6.10130047e-03f, 1.03299879e-02f, 4.53042686e-02f, -1.05504818e-01f, 1.82096571e-01f, 4.08972092e-02f,
  -1.70245111e-01f, 8.78675003e-03f, 2.07385942e-01f, -8.15051422e-02f, 5.32242298e-01f, 6.10062890e-02f, -1.41254365e-01f, 3.35577130e-02f, -1.08578980e-01f, 5.59236482e-03f,
  -2.38612946e-02f, -3.16152096e-01f, -1.40162542e-01f, -2.31399506e-01f, 1.49683475e-01f, -1.91456437e-01f, -8.97916481e-02f, 2.08658669e-02f, 7.09242523e-02f, -1.15530908e-01f,
  2.41721541e-01f, -1.14431292e-01f, -4.08246331e-02f, 1.94358781e-01f, 7.72885457e-02f, -1.90608539e-02f, 1.71364903e-01f, -3.44488621e-02f, -9.46375132e-02f, -1.67119160e-01f,
  -1.12250715e-01f, 2.81039644e-02f, 2.40609944e-02f, 1.31534263e-01f, 9.93694738e-02f, 1.31472489e-02f, -5.25490306e-02f, -3.58156487e-02f, -2.05404729e-01f, -3.00412606e-02f,
  -7.63337165e-02f, -9.28376690e-02f, 5.27048707e-02f, 2.60248259e-02f, -1.63680017e-01f, -1.92553446e-01f, -1.07334420e-01f, 2.47694939e-01f, 1.66568588e-02f, 1.01613469e-01f,
  1.95863932e-01f, 2.07138378e-02f, -1.28727943e-01f, -1.11887246e-01f, -1.07565664e-01f, -2.65017934e-02f, 1.41975567e-01f, 2.29829252e-01f, -1.70197651e-01f, 1.71953887e-01f,
  -2.84561068e-02f, -1.21883385e-01f, -2.78762728e-01f, -6.61488548e-02f, 1.21905036e-01f, 1.96981892e-01f, -7.11041316e-02f, -9.03866068e-02f, -1.47280455e-01f, 1.38400093e-01f,
  1.44150630e-01f, -5.32142967e-02f, -6.81388453e-02f, -9.64215994e-02f, -2.96109796e-01f, 1.22965656e-01f, -1.98882535e-01f, 2.47716650e-01f, 1.61473855e-01f, 2.11033627e-01f,
  -1.00770853e-01f, -1.19634628e-01f, -1.00329164e-02f, -1.59430310e-01f, -1.48773789e-01f, 1.41858101e-01f, 8.10850635e-02f, -2.36855924e-01f, -1.60326883e-01f, -7.85694807e-04f,
  7.77852759e-02f, 1.89633793e-05f, 1.98234934e-02f, -2.86845639e-02f, 2.33975008e-01f, 3.00182164e-01f, 1.85677096e-01f, 8.50569457e-02f, 2.33748555e-01f, 1.71885297e-01f,
  8.90853703e-02f, 1.20104849e-01f, 4.31186073e-02f, -1.86367333e-01f, 9.02164578e-02f, 1.39349827e-03f, 1.63744986e-02f, 2.39496186e-01f, 9.49991643e-02f, -6.10151067e-02f,
  -1.39411330e-01f, -2.17149165e-04f, 1.59463257e-01f, 1.57061040e-01f, 9.09406319e-02f, 1.87414974e-01f, -7.76785091e-02f, -1.08238824e-01f, 5.71991354e-02f, 1.91220984e-01f,
  2.03053638e-01f, 1.19449586e-01f, -4.97332551e-02f, -1.57109601e-03f, -1.28098547e-01f, -5.17949536e-02f, -5.02514467e-02f, -3.52587849e-02f, 1.47648424e-01f, 1.89626023e-01f,
  -3.32127541e-01f, -6.21679798e-02f, -1.06291100e-01f, 2.79027298e-02f, -1.06688634e-01f, -2.98841268e-01f, 3.14892977e-02f, -2.29389742e-02f, -1.24052115e-01f, 6.22203127e-02f,
  -1.92476511e-01f, 1.78382710e-01f, 1.33118600e-01f, 3.45900953e-01f, -1.49425954e-01f, -2.88262427e-01f, -1.63262915e-02f, -2.20138475e-01f, -2.93297946e-01f, 1.89349324e-01f,
  -3.87242027e-02f, -4.08571027e-03f, -1.23799704e-01f, 2.24180505e-01f, 5.20531461e-02f, -9.33563933e-02f, 2.30197400e-01f, -7.73378015e-02f, -1.98448612e-03f, -3.01051680e-02f,
  9.02734995e-02f, 2.67482251e-01f, -1.02114253e-01f, -9.58503503e-03f, -1.48157537e-01f, -1.40176564e-01f, -1.97458677e-02f, -1.89546600e-01f, -7.19035938e-02f, 1.25258237e-01f,
  1.65718600e-01f, -7.17948005e-03f, -2.78556645e-01f, -1.28392428e-01f, 7.90805146e-02f, 1.40105993e-01f, -4.88160029e-02f, -1.45282641e-01f, -3.10483370e-02f, 1.63696595e-02f,
  -1.49672344e-01f, 6.45033047e-02f, -8.51479098e-02f, -6.53230250e-02f, -1.84811085e-01f, 2.14476094e-01f, 1.20891847e-01f, -1.26723677e-01f, -2.96954717e-02f, -1.34081289e-01f,
  -1.52660340e-01f, 5.64912558e-02f, -3.92521359e-02f, 1.78343788e-01f, -1.44211426e-01f, -1.58288449e-01f, -2.39469051e-01f, 8.63555819e-02f, 2.05158889e-02f, -2.77246982e-02f,
  -2.32628733e-02f, -1.84828356e-01f, 2.18827054e-01f, 2.51068085e-01f, 1.09069690e-01f, -9.64646265e-02f, -7.61789903e-02f, 8.27386156e-02f, -3.03064764e-01f, -8.05124566e-02f,
  -3.35205309e-02f, -2.27437317e-01f, -6.94680661e-02f, 1.56294763e-01f, -6.59502596e-02f, -2.16376901e-01f, -2.32189730e-01f, 1.97565436e-01f, 4.07883385e-03f, -2.14445181e-02f,
  5.11322059e-02f, 1.80218637e-01f, -4.83714454e-02f, 8.79359841e-02f, 1.65621921e-01f, 9.53714848e-02f, 8.73625055e-02f, -1.66345411e-03f, 1.44915640e-01f, 1.39861584e-01f,
  -1.58363730e-01f, 7.15851635e-02f, -1.38475820e-01f, 4.03462611e-02f, 1.31635532e-01f, 1.86236396e-01f, 6.57112077e-02f, 7.75763318e-02f, -1.34566501e-01f, -3.30786966e-02f,
  1.16151825e-01f, 2.86025107e-02f, 7.75925517e-02f, 1.31933302e-01f, -1.15933061e-01f, 1.29381167e-02f, -7.92619810e-02f, 3.46214056e-01f, 1.68893680e-01f, 8.47477615e-02f,
  -1.03581630e-01f, 1.81165680e-01f, -8.99250805e-02f, 3.94913480e-02f, 7.33195618e-02f, 1.72658741e-01f, 3.87636162e-02f, 5.68903387e-02f, -2.02114284e-01f, -2.76788473e-01f,
  1.43190563e-01f, -8.17738771e-02f, -1.04276896e-01f, -2.02878445e-01f, 5.95190041e-02f, 3.65233235e-02f, -8.46123546e-02f, -1.41070411e-01f, -9.40609202e-02f, 9.28944498e-02f,
  1.90603226e-01f, 3.29205729e-02f, -4.12584133e-02f, -1.70929894e-01f, -9.04720202e-02f, -1.38357818e-01f, -1.99563533e-01f, 8.23727995e-03f, 8.00338238e-02f, -7.47176111e-02f,
  -1.68191418e-02f, -2.78719561e-03f, 4.41300906e-02f, 7.88756534e-02f, 9.89463776e-02f, -5.41489397e-04f, -7.15846270e-02f, -9.55659077e-02f, -7.72632752e-03f, -4.64961194e-02f,
  -2.20077232e-01f, -1.07870027e-01f, -1.04125209e-01f, 1.75045475e-01f, 7.72975013e-02f, -1.48494750e-01f, -6.50074631e-02f, 1.10226862e-01f, -8.25594068e-02f, 1.48783606e-02f,
  -8.77060220e-02f, 9.08816084e-02f, -1.10914716e-02f, 6.84083626e-03f, -5.12490198e-02f, 1.39787421e-01f, 7.80827329e-02f, 2.65039384e-01f, -6.86850995e-02f, -9.13192630e-02f,
  4.75935005e-02f, 1.04268640e-02f, -4.34632003e-02f, -3.09489155e-03f, 8.36148188e-02f, 1.18159093e-01f, 2.05881335e-02f, -1.41532436e-01f, -1.28153041e-01f, 1.32345051e-01f,
  -1.97589293e-01f, -3.09955385e-02f, 7.52408523e-03f, -4.73310724e-02f, -2.70463169e-01f, -1.06955998e-01f, 2.67753433e-02f, -4.55887653e-02f, 1.93614915e-01f, -8.74813646e-02f,
  1.88193560e-01f, 1.34898573e-01f, 1.02783523e-01f, 2.32760787e-01f, -1.07972831e-01f, 1.65245980e-01f, -1.37693107e-01f, -5.83612248e-02f, 2.69228816e-01f, -5.89521080e-02f,
  2.38420181e-02f, 1.04754202e-01f, -4.47809659e-02f, 7.14643374e-02f, 5.05019724e-03f, 1.95836443e-02f, -1.48743853e-01f, 8.61378312e-02f, 2.53816783e-01f, 9.44905877e-02f,
  9.28251669e-02f, -7.92572182e-03f, 2.38922894e-01f, 4.12954465e-02f, 1.69947252e-01f, 5.19818701e-02f, -7.24648908e-02f, 8.14905539e-02f, 7.21106976e-02f, 4.11264896e-02f,
  -3.08468670e-01f, 4.67702709e-02f, 1.23837821e-01f, -1.72302928e-02f, -4.77424532e-04f, -2.20146134e-01f, -6.48678020e-02f, -6.39491677e-02f, 3.85317318e-02f, 9.15292352e-02f,
  6.72616735e-02f, -2.48623453e-02f, 6.01614341e-02f, -7.78267160e-02f, -4.40214388e-02f, 2.45801449e-01f, -9.65008363e-02f, 1.06274948e-01f, -1.88694954e-01f, -5.49148768e-02f,
  -7.62454122e-02f, -2.17751320e-03f, 1.12295255e-01f, -2.94065308e-02f, 6.41633347e-02f, 1.41607376e-03f, 1.76611289e-01f, 5.93262687e-02f, -1.14425987e-01f, 1.72896564e-01f,
  1.30335122e-01f, -2.34236956e-01f, -1.17825978e-01f, -7.68304691e-02f, 1.72604233e-01f, -9.16311443e-02f, 2.39060484e-02f, -2.14591399e-01f, -1.65336117e-01f, 2.98232958e-02f,
  -9.05592218e-02f, 1.01492358e-02f, 1.99693143e-02f, 1.68924049e-01f, -7.53446221e-02f, 2.91904863e-02f, -9.28317383e-03f, -3.67112528e-03f, -9.31982696e-03f, 1.70643941e-01f,
  6.29883111e-02f, -1.02754973e-01f, -2.21515611e-01f, -6.30339086e-02f, -1.49605438e-01f, 5.57546131e-03f, 1.00447789e-01f, 1.87325537e-01f, 1.16314828e-01f, 1.48045674e-01f,
  -8.62630159e-02f, -1.93019003e-01f, -7.22260177e-02f, -2.10055619e-01f, -6.67934269e-02f, -2.91705150e-02f, 1.97626889e-01f, -8.14722553e-02f, -1.82196237e-02f, -1.44398257e-01f,
  -6.91682324e-02f, 2.61421233e-01f, -1.32847458e-01f, 7.82734156e-02f, 2.08654732e-01f, -2.53429562e-01f, 1.44066408e-01f, 1.53057888e-01f, -1.07123218e-01f, -5.07610850e-02f,
  -4.19800468e-02f, 1.94789320e-01f, -1.70498475e-01f, 4.77593355e-02f, 3.09534427e-02f, 8.45871195e-02f, -1.47883043e-01f, -1.63449638e-03f, 3.14435586e-02f, 2.58378267e-01f,
  1.55589581e-01f, -1.30476728e-01f, -2.72811830e-01f, -8.43142346e-03f, 1.70840338e-01f, -1.52928546e-01f, -4.53787856e-02f, -1.94773629e-01f, -2.05650389e-01f, 8.62458646e-02f,
  -1.12244338e-02f, 2.85261869e-02f, 1.23734944e-01f, -3.07848845e-02f, -1.36248410e-01f, -5.79056442e-02f, -1.55033037e-01f, -1.96943507e-01f, 6.61320686e-02f, 2.28803828e-01f,
  -2.78680511e-02f, -3.10744137e-01f, -1.12761743e-01f, -6.68765381e-02f, 1.18640400e-01f, -2.32890606e-01f, -7.70837953e-03f, 1.56079948e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  9.02790129e-02f, 5.07723242e-02f, 2.94265866e-01f, 2.24047415e-02f, -1.69038251e-01f, 1.57269210e-01f, 1.03912853e-01f, -6.88460097e-03f, 1.54253602e-01f, -1.12378433e-01f,
  -9.03139561e-02f, -3.74055803e-02f, 1.28666207e-01f, -2.07272619e-02f, 1.72671676e-01f, 1.95321754e-01f, 1.23450138e-01f, 8.33264440e-02f, -2.23004520e-02f, 9.68135074e-02f,
  1.51375964e-01f, 1.59312651e-01f, -5.06285802e-02f, 8.79136622e-02f, 3.61526310e-02f, -7.77045265e-02f, 1.04887582e-01f, 2.62316585e-01f, 1.80957213e-01f, 1.63335159e-01f,
  2.42299237e-03f, -7.55226836e-02f, 4.54390422e-02f, 5.77793829e-02f, -3.43224453e-03f, 2.14949712e-01f, 2.87517272e-02f, 8.83988217e-02f, 6.92548603e-02f, -2.24661827e-02f,
  8.70121084e-03f, 3.12198363e-02f, 2.13752553e-01f, 2.52736546e-02f, 2.14788169e-01f, 3.25546451e-02f, 2.93371409e-01f, 2.07955539e-02f, -4.50494699e-02f, -1.21505111e-02f,
  1.01261862e-01f, -1.95290875e-02f
};

// L2_fan_Wp (Shape: 6 x 64)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  3.17651451e-01f, 1.47572562e-01f, -7.72108287e-02f, 1.91750437e-01f, 1.78468511e-01f, 1.09813884e-01f, -8.43664110e-02f, -9.64834616e-02f, -4.19801660e-02f, 5.36187254e-02f,
  2.59291023e-01f, -2.03163847e-01f, -5.70420399e-02f, -1.47777295e-03f, 5.76679297e-02f, -1.33859262e-01f, -7.87726343e-02f, 3.03988103e-02f, 1.39249101e-01f, -1.07895605e-01f,
  1.51721582e-01f, -4.95671667e-02f, -7.19840974e-02f, -1.57688916e-01f, -7.98325799e-03f, 1.62396189e-02f, -1.73470512e-01f, -9.08961892e-02f, -1.02050237e-01f, 1.28143132e-01f,
  -9.54006165e-02f, 3.16802934e-02f, -1.12825938e-01f, 9.95415449e-02f, 1.39780492e-01f, -1.33056222e-02f, 5.30028366e-04f, 3.68652306e-02f, -3.20725441e-01f, -1.90012809e-02f,
  -8.41566324e-02f, -1.06805652e-01f, 1.92652643e-01f, -1.55759141e-01f, 1.18768059e-01f, -1.94798738e-01f, 8.52822214e-02f, -2.63567399e-02f, 9.92604792e-02f, 1.90029517e-01f,
  -4.90636565e-02f, 2.72791684e-02f, -8.42665434e-02f, 1.02919400e-01f, -1.31910577e-01f, -6.18549772e-02f, -1.10703334e-01f, -2.16809988e-01f, -1.67976230e-01f, 1.44449830e-01f,
  8.66817404e-03f, -7.95559287e-02f, 1.05813175e-01f, 1.03071921e-01f, -1.73895713e-02f, -4.23318222e-02f, -3.75053361e-02f, 1.33018762e-01f, -6.26494288e-02f, 3.00948638e-02f,
  4.03328314e-02f, 2.10872620e-01f, -1.14834368e-01f, 2.34237060e-01f, -7.17860088e-02f, 1.02347665e-01f, 3.48493159e-02f, 1.20901212e-01f, 4.66693230e-02f, 2.15099931e-01f,
  -1.23087480e-03f, 9.68032926e-02f, -6.28741905e-02f, 2.80320019e-01f, -4.19493094e-02f, 4.15325426e-02f, -1.70933902e-02f, 5.58377616e-02f, 6.39117062e-02f, 1.00598626e-01f,
  -2.87860278e-02f, 3.70157287e-02f, 4.33080457e-02f, -1.97443932e-01f, -1.32523313e-01f, 1.48796588e-01f, 1.43561050e-01f, -1.58885434e-01f, 1.88766763e-01f, 8.35067108e-02f,
  1.89235345e-01f, 1.08516350e-01f, -3.81940193e-02f, -1.49510354e-01f, -8.92749652e-02f, 1.14734629e-02f, -1.53036878e-01f, 7.72335678e-02f, 4.19931188e-02f, -2.34956667e-01f,
  -4.56163362e-02f, -1.68495581e-01f, -1.09829515e-01f, -1.20506205e-01f, -1.53023571e-01f, -6.98458776e-02f, 4.22480665e-02f, -1.06112853e-01f, -2.02293172e-02f, 1.48386225e-01f,
  -3.13919000e-02f, 2.10672721e-01f, 1.82792678e-01f, 1.91041574e-01f, -1.24857407e-02f, 2.67118635e-03f, -9.70554426e-02f, 1.71019867e-01f, -2.34137289e-02f, 2.61026144e-01f,
  -7.93629065e-02f, -8.10901448e-02f, -2.12123487e-02f, 8.86341855e-02f, 2.77503192e-01f, -2.20529214e-01f, -1.20160788e-01f, -1.29760519e-01f, -6.40306026e-02f, -4.76521328e-02f,
  -3.22389714e-02f, -2.03997511e-02f, -2.40298063e-02f, -1.54333562e-01f, -1.25735849e-01f, -2.57739723e-02f, 3.78221050e-02f, -2.72617757e-01f, 1.57313481e-01f, 1.12713844e-01f,
  -1.06441304e-01f, 7.34109571e-03f, 9.32604894e-02f, -1.35734186e-01f, 2.33186111e-02f, -2.37967372e-02f, -4.92561795e-02f, -3.74597535e-02f, -1.77622303e-01f, -5.69035932e-02f,
  1.89954806e-02f, -5.67420572e-02f, -1.25448620e-02f, 2.08728924e-01f, 1.32830933e-01f, -1.59361973e-01f, 1.18279800e-01f, 2.11955588e-02f, -1.64576575e-01f, -7.24564716e-02f,
  -1.52778924e-01f, 1.37521066e-02f, 6.94834220e-04f, 1.00577489e-01f, 9.94992703e-02f, -3.93396765e-02f, 1.49179801e-01f, -6.07347116e-03f, -2.73093849e-01f, -1.74069762e-01f,
  4.89637554e-02f, -9.13156718e-02f, 1.67108148e-01f, 9.59444698e-03f, 6.07052296e-02f, -7.47680590e-02f, -1.27438679e-01f, 1.11308999e-01f, -1.31590798e-01f, -8.91449600e-02f,
  -5.81523553e-02f, -1.59182101e-01f, -4.49601449e-02f, 4.44884524e-02f, -1.82332486e-01f, 3.86853255e-02f, -3.95127013e-02f, 2.92155356e-03f, 3.90526168e-02f, -1.43740699e-01f,
  1.75578058e-01f, -1.16547689e-01f, 6.61394671e-02f, 1.52966842e-01f, -3.28564942e-02f, 1.00819662e-01f, 5.13573661e-02f, -6.71154261e-02f, 2.99027264e-02f, 2.00954657e-02f,
  1.18259616e-01f, -6.15873560e-02f, -1.68309286e-01f, -1.66716930e-02f, 1.50400981e-01f, 5.41039556e-02f, 1.77345276e-01f, 1.53742451e-03f, -9.88717079e-02f, 6.55424297e-02f,
  -9.12628248e-02f, -9.24741104e-02f, 1.09114401e-01f, -4.57011014e-02f, 2.99662333e-02f, 3.39813717e-02f, -9.79844108e-03f, -9.28032771e-02f, -9.76195261e-02f, -5.54518476e-02f,
  9.02235955e-02f, -1.06457047e-01f, 1.00807054e-02f, 2.83488445e-02f, -8.11499581e-02f, 1.88873187e-01f, 9.40157101e-02f, 3.78373675e-02f, 1.11661274e-02f, 2.89209664e-01f,
  -1.07971892e-01f, 7.61567876e-02f, -3.98846045e-02f, -1.01352438e-01f, 1.30399987e-01f, -5.84088527e-02f, 2.10599229e-01f, -1.71131954e-01f, 5.99358194e-02f, -1.54866278e-01f,
  -9.44857001e-02f, -1.16447590e-01f, -7.49278516e-02f, -4.96675037e-02f, 1.45944115e-02f, -8.14725310e-02f, 1.93419710e-01f, -3.58392484e-02f, -6.01107776e-02f, 9.89254639e-02f,
  2.35126242e-02f, 9.75259766e-02f, -8.82718042e-02f, -9.23202187e-02f, 4.66802344e-02f, -1.92267165e-01f, 7.42332041e-02f, -1.23497903e-01f, 1.46045983e-01f, 1.24502227e-01f,
  5.57309948e-02f, -8.86980221e-02f, -8.07540864e-02f, 2.66699642e-02f, 5.27687334e-02f, -1.24715596e-01f, 9.18357521e-02f, 7.85717089e-03f, 4.45880555e-03f, 1.05070964e-01f,
  1.49498746e-01f, 8.77332538e-02f, 1.19449340e-01f, 1.35171384e-01f, 1.99233770e-01f, -1.84612617e-01f, 1.30764335e-01f, -1.11169539e-01f, 1.43807694e-01f, 1.24859281e-01f,
  7.55072683e-02f, 2.59588957e-02f, 1.92644149e-01f, 1.51044935e-01f, -2.63916422e-02f, 1.13933116e-01f, 2.07534716e-01f, -4.04857658e-02f, 2.02587172e-01f, 4.26454656e-02f,
  3.00237536e-02f, -6.93002492e-02f, -4.29530703e-02f, 1.28022581e-01f, -1.06479950e-01f, 2.15713046e-02f, 1.22294284e-01f, -1.20054230e-01f, 1.51540026e-01f, 9.43388790e-02f,
  -4.57895957e-02f, -3.49275619e-02f, -1.27144530e-01f, -8.84504914e-02f, -8.57734531e-02f, -1.49875358e-02f, -5.51742539e-02f, 9.00567044e-03f, 1.72260642e-01f, -1.48345977e-01f,
  -1.90969646e-01f, -9.77001861e-02f, -1.20078407e-01f, -1.35180503e-01f, -1.18962012e-01f, 9.05369315e-03f, 4.99150492e-02f, 1.19212791e-01f, -1.18227325e-01f, 6.65163100e-02f,
  6.04183003e-02f, -1.31804779e-01f, -2.18823347e-02f, 2.14758202e-01f, -9.96710360e-02f, 8.73366296e-02f, 1.57886609e-01f, 1.50545269e-01f, 5.47194816e-02f, 4.23622318e-02f,
  4.70884182e-02f, 4.39533219e-02f, 7.60535598e-02f, 3.36609408e-02f, 1.03575615e-02f, -1.17769070e-01f, -2.26324588e-01f, 5.83493784e-02f, 2.32783537e-02f, -8.42238516e-02f,
  -1.90251898e-02f, -1.57813922e-01f, 1.35510698e-01f, 4.09431159e-02f, 4.77149859e-02f, 9.40427780e-02f, 1.58419684e-01f, 1.24316089e-01f, -9.00031626e-02f, -1.65818378e-01f,
  1.56847179e-01f, -7.16313869e-02f, 1.90291747e-01f, 1.56630218e-01f, 1.18906453e-01f, 6.59651356e-03f, 6.78314120e-02f, -8.85024946e-03f, -3.72046046e-02f, 5.62073700e-02f,
  9.77875143e-02f, 1.22749545e-01f, -1.02479398e-01f, 8.33529159e-02f, -1.03491340e-02f, 1.98514625e-01f, -2.39956215e-01f, -8.18262547e-02f, -4.42656353e-02f, 1.39103740e-01f,
  5.55721000e-02f, 1.99014440e-01f, -1.76119357e-02f, 8.89483374e-03f
};

// L2_fan_Wp_bar (Shape: 52 x 64)
const int L2_fan_Wp_bar_rows = 52;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -8.27250332e-02f, -7.39402473e-02f, -2.00957358e-02f, 5.19690919e-04f, -2.94689119e-01f, -1.04014330e-01f, 6.54998049e-02f, 1.27430990e-01f, -1.48499340e-01f, -4.67711762e-02f,
  -2.07897753e-01f, -5.95916174e-02f, 1.50977131e-02f, 6.47725761e-02f, -1.04707934e-01f, 6.95629716e-02f, 1.23083077e-01f, 1.17269330e-01f, 1.25151068e-01f, 2.97705978e-01f,
  6.54701516e-02f, 1.75284967e-01f, 1.10416695e-01f, 2.07457021e-01f, 1.61142707e-01f, -4.47688587e-02f, -6.84901550e-02f, -1.03400990e-01f, 4.69714589e-02f, 1.66623414e-01f,
  4.45277877e-02f, 9.72814113e-02f, 1.38763458e-01f, -9.00828838e-03f, 5.26532270e-02f, 2.33996678e-02f, -2.00533569e-02f, 1.56774700e-01f, 9.00345370e-02f, -2.15241924e-01f,
  3.51683795e-02f, 3.78033780e-02f, 7.73262084e-02f, -9.26834568e-02f, -1.33457240e-02f, -5.48440665e-02f, 1.68360267e-02f, -2.15654988e-02f, 5.93581349e-02f, -1.59440920e-01f,
  4.37377905e-03f, 6.03763619e-03f, 2.06213184e-02f, 4.86652665e-02f, -6.50729164e-02f, 9.45653617e-02f, 1.80611551e-01f, 1.04417823e-01f, 3.90513241e-02f, -1.28608704e-01f,
  2.16856543e-02f, -8.75010937e-02f, 1.60017669e-01f, 1.16134547e-02f, 1.75961494e-01f, 2.65742153e-01f, 6.42167926e-02f, 1.13570832e-01f, 3.26259583e-01f, 3.48817676e-01f,
  2.46696204e-01f, 7.56726563e-02f, 2.09441245e-01f, 1.59428865e-01f, 2.75695413e-01f, -2.32657626e-01f, -8.71022269e-02f, -4.35384661e-02f, 2.79698074e-01f, 3.22000822e-03f,
  -1.34406254e-01f, 4.67575528e-02f, 2.46335700e-01f, -2.15064570e-01f, -2.66587138e-01f, 1.79143041e-01f, -6.41276082e-03f, -1.68831676e-01f, -2.94556141e-01f, -2.52094477e-01f,
  -1.35395110e-01f, 2.70151887e-02f, 9.89424214e-02f, -2.51670450e-01f, -1.01014055e-01f, -2.66101480e-01f, -2.36499235e-02f, 6.89878091e-02f, 3.28135937e-02f, 3.67412955e-01f,
  3.95460986e-02f, 6.01295233e-02f, -1.53385522e-02f, 1.19463392e-01f, 8.03365186e-02f, 1.84234262e-01f, -9.69452336e-02f, 5.91262057e-02f, 1.63124725e-01f, 9.85014662e-02f,
  6.72859699e-02f, 1.49214253e-01f, 2.15067387e-01f, -2.37489715e-01f, -1.44084498e-01f, 1.18310042e-01f, -1.92284986e-01f, -1.40770540e-01f, 1.03364252e-01f, -1.16053000e-01f,
  -1.00850992e-01f, 1.54299721e-01f, 1.52675748e-01f, 3.37375402e-01f, -6.00065337e-03f, -7.21866488e-02f, 1.42269224e-01f, 9.52940807e-02f, -2.28958670e-02f, 1.61143348e-01f,
  9.71270800e-02f, 1.58156320e-01f, 2.25503102e-01f, 3.59781802e-01f, 2.78350711e-01f, 8.26836913e-04f, -3.52686495e-01f, -1.86302975e-01f, 2.65502501e-02f, 2.12681085e-01f,
  -1.09486036e-01f, -2.10375965e-01f, 3.65537047e-01f, 1.45793557e-01f, -8.84477496e-02f, -2.56014057e-02f, 4.40506153e-02f, 1.73905604e-02f, -1.56086788e-01f, 1.47196263e-01f,
  -1.84208080e-02f, -3.65461427e-04f, -3.60177130e-01f, 2.66272694e-01f, 2.40068331e-01f, -6.12546364e-03f, 1.19494103e-01f, -3.38338912e-01f, -2.12298647e-01f, 6.59395456e-02f,
  -3.64500619e-02f, 1.02902846e-02f, -4.21302080e-01f, -5.77641129e-02f, -1.84089541e-02f, -2.00332422e-03f, 8.90630037e-02f, 2.94559717e-01f, 5.94383851e-02f, 4.66430634e-02f,
  -1.27160102e-01f, -1.44440427e-01f, 6.64633065e-02f, 5.56261428e-02f, 9.75965783e-02f, -2.09204163e-02f, 4.16534357e-02f, -4.33031917e-01f, -2.42711157e-01f, -8.56238827e-02f,
  6.19315542e-02f, -2.08535213e-02f, 3.62469077e-01f, -9.81642082e-02f, 1.86241195e-01f, 1.22151405e-01f, 2.03174084e-01f, 5.68033345e-02f, 1.70394346e-01f, -7.10702315e-02f,
  7.99481815e-04f, -1.38769893e-03f, 2.06357598e-01f, -9.41138566e-02f, 8.45124796e-02f, -5.29475771e-02f, -5.85735263e-03f, 3.92296255e-01f, -6.61683828e-02f, -1.26074791e-01f,
  2.29505688e-01f, -1.36712223e-01f, 5.66949211e-02f, -4.49049383e-01f, -8.38530436e-03f, -9.15340558e-02f, -4.32755835e-02f, 1.83105730e-02f, 9.26110819e-02f, 2.45341398e-02f,
  8.62842202e-02f, 2.71626621e-01f, 4.47377145e-01f, -1.00209743e-01f, 7.34602362e-02f, -5.63706681e-02f, 1.68022305e-01f, 1.52572379e-01f, 2.73637678e-02f, 1.77096903e-01f,
  -1.34738432e-02f, 3.98513436e-01f, -8.91235396e-02f, 1.64342821e-01f, 7.09994584e-02f, 1.70049667e-01f, 1.40406817e-01f, -5.31223305e-02f, -6.26894995e-04f, -1.98282301e-01f,
  4.21318747e-02f, 1.28224820e-01f, -4.97507714e-02f, -2.59728301e-02f, 1.04461513e-01f, -2.85926700e-01f, 5.72152250e-02f, -2.84505449e-02f, 7.11208805e-02f, -6.76601613e-03f,
  -1.38866963e-04f, 5.22925794e-01f, 8.21119100e-02f, 1.72985867e-02f, 7.00060651e-02f, 1.78212691e-02f, -4.02228860e-03f, -4.79044951e-02f, 8.51525813e-02f, -5.33098504e-02f,
  9.62482467e-02f, -4.65582758e-02f, 1.81254733e-03f, 6.83984309e-02f, 1.67701896e-02f, 8.86098854e-03f, -1.27817541e-02f, 9.73856524e-02f, -8.52587819e-03f, 1.04389772e-01f,
  -3.02648127e-01f, 3.75994854e-02f, -3.44307199e-02f, 7.29110464e-02f, -1.75179809e-01f, -2.35370666e-01f, -3.32958251e-01f, -1.77129451e-02f, 2.25119799e-01f, 2.17230111e-01f,
  2.13235930e-01f, -1.11719914e-01f, -1.65474877e-01f, 3.67309973e-02f, 1.81460455e-01f, 3.49696010e-01f, 5.26853465e-02f, 1.63771331e-01f, -3.85929383e-02f, 1.88013792e-01f,
  4.14244354e-01f, -5.73932054e-03f, 6.05222993e-02f, -8.98435041e-02f, -4.12870497e-02f, 1.56824857e-01f, 1.55430466e-01f, 2.53154665e-01f, 1.58515707e-01f, -7.72883445e-02f,
  8.24387651e-03f, -1.79004595e-01f, 1.04675397e-01f, 2.63908148e-01f, -7.41018727e-02f, -2.83078820e-01f, 2.35639274e-01f, 8.89015198e-02f, -9.73309353e-02f, 6.33877004e-03f,
  -1.00475878e-01f, -3.02048266e-01f, -1.36050761e-01f, -3.49002779e-02f, -2.59320587e-01f, -5.34451008e-02f, -1.43751413e-01f, 1.81440726e-01f, 1.81628823e-01f, 8.00309330e-02f,
  -5.00854626e-02f, -7.56604448e-02f, 2.88079083e-01f, -1.32137522e-01f, 2.14738458e-01f, -2.29649693e-01f, 2.16512531e-01f, -6.24018461e-02f, 1.85054630e-01f, -1.72019884e-01f,
  1.66843221e-01f, 1.23815581e-01f, 8.60936008e-03f, 7.36177713e-02f, 3.86772379e-02f, 4.96979095e-02f, 1.07501917e-01f, -2.17227310e-01f, -4.20866072e-01f, 3.28425735e-01f,
  -2.48364776e-01f, 1.01693183e-01f, -1.49578735e-01f, -1.53124303e-01f, -7.77231604e-02f, 1.31930530e-01f, -1.99298486e-01f, 5.41322865e-03f, -1.95744425e-01f, -2.24602818e-01f,
  8.77110660e-02f, -2.67207712e-01f, -1.74203321e-01f, 3.65930758e-02f, -3.81345063e-01f, 8.20196494e-02f, 4.26452458e-02f, 6.66398406e-02f, 2.40861792e-02f, -2.38879621e-01f,
  3.15388013e-03f, -8.10130090e-02f, -5.20421788e-02f, 8.32333509e-03f, -9.16064456e-02f, -3.32994491e-01f, 2.04781905e-01f, -2.86836028e-01f, 8.81709158e-02f, 1.83142900e-01f,
  9.33463275e-02f, -2.52464741e-01f, -7.51644522e-02f, -1.72057956e-01f, 2.64665112e-02f, 1.14718929e-01f, -2.65496045e-01f, 4.10743291e-03f, 1.12860702e-01f, -3.17534804e-01f,
  1.88598186e-02f, -9.57502797e-02f, 1.67470962e-01f, 2.15302974e-01f, -2.86927313e-01f, 2.33353212e-01f, -2.47016679e-02f, 1.06063977e-01f, 1.54474989e-01f, -4.22002487e-02f,
  4.91306856e-02f, 2.29137585e-01f, -3.27072054e-01f, -2.23577470e-01f, 9.91094038e-02f, 2.83421427e-02f, 2.27338403e-01f, 2.70501040e-02f, 9.54243392e-02f, 1.45412728e-01f,
  1.67990744e-01f, -2.63505071e-01f, -3.09317764e-02f, 1.97500527e-01f, -1.82012185e-01f, 1.57477453e-01f, -3.27168102e-03f, -8.38669762e-02f, -1.95669845e-01f, 7.75598213e-02f,
  -1.80089757e-01f, -1.00388065e-01f, -2.41075203e-01f, -2.71347761e-02f, -1.48592899e-02f, -1.54271245e-01f, -1.43165449e-02f, -3.33226509e-02f, -6.95831701e-02f, -1.58195317e-01f,
  5.64515777e-02f, 2.81622827e-01f, 2.48483732e-01f, -3.04723322e-01f, -7.78671773e-03f, -1.29999548e-01f, 8.82755592e-02f, 4.51942496e-02f, -5.67041561e-02f, -2.27962762e-01f,
  2.50001371e-01f, -7.41941035e-02f, 1.88919500e-01f, 1.75698131e-01f, 2.12422833e-01f, -2.12133259e-01f, -1.33537665e-01f, 1.11695513e-01f, 5.00995964e-02f, 1.24518815e-02f,
  -3.51702496e-02f, -7.27468580e-02f, -7.50453994e-02f, -8.72795954e-02f, 2.14252826e-02f, 3.34082320e-02f, 3.95845324e-02f, 1.72813788e-01f, -4.98001277e-02f, 9.49091539e-02f,
  1.55679341e-02f, -9.15277749e-02f, 1.09489463e-01f, -1.31786987e-01f, 1.60335992e-02f, 1.00219607e-01f, -4.20346782e-02f, -8.35353285e-02f, 1.90651685e-01f, 6.05025515e-02f,
  1.35098044e-02f, 1.00850932e-01f, -7.36832842e-02f, 1.28148898e-01f, 2.41390526e-01f, -1.31710202e-01f, -1.97398383e-02f, 1.58878356e-01f, -3.92887175e-01f, -3.66349402e-03f,
  2.92538945e-02f, 9.31060091e-02f, 3.64534222e-02f, 1.97335646e-01f, -1.91916615e-01f, -1.14964753e-01f, -3.16371508e-02f, -1.28087386e-01f, 1.34203255e-01f, -7.59935677e-02f,
  -4.74250987e-02f, -3.34236398e-02f, -2.08013994e-03f, -5.81314182e-03f, 1.83355480e-01f, 2.75117010e-01f, 1.79158926e-01f, -2.70486176e-01f, 1.18581295e-01f, 4.23676595e-02f,
  2.11745337e-01f, -8.91737118e-02f, -3.80398147e-02f, -1.88364804e-01f, 7.11273476e-02f, -2.64079813e-02f, 1.62044078e-01f, -8.49008858e-02f, 2.79821813e-01f, -3.59761536e-01f,
  -5.96708879e-02f, -3.11003812e-02f, -6.55458570e-02f, -2.05885902e-01f, -1.89415649e-01f, -1.80331290e-01f, 1.59595460e-02f, -1.12323508e-01f, -1.02457017e-01f, 1.92153472e-02f,
  2.40056261e-01f, 2.31817141e-01f, -4.90755327e-02f, 1.10671856e-01f, 6.46799803e-02f, -5.75822331e-02f, -5.06365635e-02f, -2.41089687e-01f, 7.91966319e-02f, 3.45826894e-02f,
  2.21773889e-02f, -2.84730315e-01f, 2.31190875e-01f, 1.22673690e-01f, 6.56146789e-03f, -4.03531753e-02f, 1.65013835e-01f, -2.74124146e-02f, -2.59526461e-01f, -3.15326661e-01f,
  -1.07596908e-03f, -2.91992575e-01f, 3.40248406e-01f, -7.14265853e-02f, -3.03095410e-04f, 1.32892309e-02f, 4.93755378e-02f, -1.69948608e-01f, -1.12791583e-01f, -1.87558830e-01f,
  -5.03991358e-02f, -1.96613148e-01f, -2.51008362e-01f, -5.15619889e-02f, -1.64470479e-01f, -1.05887847e-02f, -2.43612826e-01f, 1.49146365e-02f, -1.82234701e-02f, -1.67037975e-02f,
  -3.21642458e-02f, -7.12977722e-02f, -5.69211952e-02f, -1.18495673e-01f, -2.87272930e-02f, 1.46069542e-01f, 9.11491141e-02f, -2.18287762e-03f, -1.30661055e-01f, -5.98176681e-02f,
  2.08465219e-01f, 8.92196074e-02f, -7.39040673e-02f, -3.59944142e-02f, 1.00103453e-01f, 7.98571333e-02f, 1.34471238e-01f, 1.81855187e-01f, -9.90996733e-02f, 2.77695786e-02f,
  2.36758247e-01f, -1.45009592e-01f, 5.53253964e-02f, -1.86656222e-01f, -4.38111052e-02f, 1.61615789e-01f, -6.90571293e-02f, -2.05648899e-01f, 2.25138113e-01f, -3.42536360e-01f,
  -3.35888684e-01f, -1.11492932e-01f, -1.52072638e-01f, -1.24710381e-01f, -1.43994708e-02f, -3.94215481e-03f, -3.75476223e-03f, 1.63582012e-01f, 1.02485016e-01f, 2.70374596e-01f,
  1.77357316e-01f, 1.25562400e-01f, 2.49448553e-01f, -6.27249628e-02f, -4.78995323e-01f, 2.69011557e-01f, 4.44358587e-02f, 8.19493234e-02f, 8.43207315e-02f, -1.98639423e-01f,
  1.61321625e-01f, 1.02171637e-01f, -2.22751617e-01f, 1.99705631e-01f, 9.22569409e-02f, -2.58382261e-01f, 8.03650320e-02f, -1.10117689e-01f, -1.36478841e-01f, -4.16733176e-02f,
  -3.15886110e-01f, -7.85576180e-02f, 2.55519301e-01f, 1.23587638e-01f, 1.02833077e-01f, -4.38040286e-01f, -1.43288836e-01f, 7.82200769e-02f, 9.83158201e-02f, 9.84906480e-02f,
  -1.91183358e-01f, 1.48235217e-01f, 3.02637834e-02f, 1.63524732e-01f, 1.59514770e-01f, 1.38554588e-01f, 1.18606091e-01f, -5.92784397e-02f, -1.23684239e-02f, -2.18579337e-01f,
  -4.42823470e-02f, 1.38264120e-01f, -1.96781233e-02f, -8.01160559e-02f, -8.50112066e-02f, -4.44324970e-01f, 3.42090949e-02f, 6.29064813e-03f, 5.75223304e-02f, 9.64809433e-02f,
  -5.45686185e-02f, 1.03057809e-02f, 3.56840827e-02f, -7.73556754e-02f, 1.24351010e-01f, 1.71449631e-01f, -9.51800845e-04f, 9.86729115e-02f, 2.67262962e-02f, -3.41455825e-02f,
  -1.86305255e-01f, 2.77094562e-02f, 4.85610217e-02f, -2.22405382e-02f, -2.28539124e-01f, -1.00820482e-01f, 2.17152201e-02f, -4.91957217e-02f, -3.62031966e-01f, 4.64941673e-02f,
  -1.73085794e-01f, 2.03214921e-02f, -1.38362974e-01f, -1.85720310e-01f, -1.94735363e-01f, 1.68409377e-01f, 4.68923375e-02f, 2.08065078e-01f, -1.11525975e-01f, 7.30222389e-02f,
  -7.57293263e-03f, -1.28033414e-01f, -2.01858729e-01f, 5.10640908e-03f, -2.95164585e-01f, -2.99863070e-01f, 5.40910363e-02f, 2.07322668e-02f, -5.54282963e-02f, -3.67736234e-03f,
  9.94399413e-02f, 2.02520579e-01f, 1.15870990e-01f, -2.76976964e-03f, -3.73676643e-02f, -1.40402541e-01f, -1.34185821e-01f, -1.75824925e-01f, 5.33671081e-02f, 1.67217162e-02f,
  -7.54007250e-02f, -6.98809400e-02f, 7.29659870e-02f, 7.72501230e-02f, -1.50912508e-01f, 8.42621773e-02f, -1.40417114e-01f, -1.71967790e-01f, -4.64288592e-02f, -1.88320607e-01f,
  -1.04317196e-01f, 2.45787092e-02f, 2.55135412e-04f, 1.01231419e-01f, -1.80016786e-01f, 1.42960519e-01f, 4.33033742e-02f, 2.21969008e-01f, 1.27901822e-01f, -4.15806659e-03f,
  1.68030560e-01f, 1.67759567e-01f, -1.16575100e-01f, 7.66624287e-02f, -1.19796924e-01f, -7.89575130e-02f, -1.10963896e-01f, 3.63244489e-02f, -2.25186795e-01f, -1.25334695e-01f,
  -4.69313897e-02f, 1.51061714e-01f, -3.18260372e-01f, 2.17702150e-01f, -3.17623354e-02f, 5.20502068e-02f, -3.37208845e-02f, 2.22509596e-02f, -2.37963855e-01f, 1.94763944e-01f,
  1.28069997e-01f, 6.20860532e-02f, -1.55856935e-02f, 1.72283486e-01f, 9.95099172e-03f, -5.84341548e-02f, -1.68316796e-01f, -1.06575832e-01f, -7.36074969e-02f, -1.87366053e-01f,
  8.02039355e-02f, 1.37690231e-01f, -2.41705813e-02f, -8.25477950e-03f, 3.93279642e-02f, 2.41876617e-02f, 6.92015234e-03f, -6.72108904e-02f, -9.07470360e-02f, -1.02517113e-01f,
  2.55930163e-02f, -4.15338464e-02f, 1.14200272e-01f, 1.15225606e-01f, -5.52197173e-02f, -1.10034175e-01f, 4.13377881e-02f, -1.14933513e-01f, 1.19938388e-01f, -9.77469492e-04f,
  -9.82168093e-02f, -1.40350267e-01f, -9.73237008e-02f, -3.49970683e-02f, 1.13143108e-03f, -2.92860828e-02f, -3.27650569e-02f, 9.89075080e-02f, -1.08961158e-01f, 1.55770704e-01f,
  -6.46595657e-02f, 2.24393606e-01f, 6.57977015e-02f, -2.31359396e-02f, 1.31150141e-01f, 1.43945470e-01f, -1.50935411e-01f, -6.64873198e-02f, 1.67207137e-01f, 1.87785625e-01f,
  2.20673174e-01f, 1.65928423e-01f, 2.96639413e-01f, 2.27471292e-01f, 3.11476886e-01f, 2.76781142e-01f, 8.73940587e-02f, 2.00507820e-01f, 1.59977525e-01f, 3.98781290e-03f,
  -1.19661808e-01f, -1.91603929e-01f, 1.73391297e-01f, 1.65883496e-01f, 1.55558765e-01f, 9.88494381e-02f, 9.74921808e-02f, 1.06461652e-01f, -7.22060427e-02f, 1.28235474e-01f,
  1.13981687e-01f, 5.38044907e-02f, -3.45898211e-01f, -2.25436449e-01f, 4.92470041e-02f, -5.86772077e-02f, -4.89745811e-02f, -3.02070379e-01f, -1.06182896e-01f, 1.90352276e-01f,
  -1.35099301e-02f, -2.13769332e-01f, -3.23948085e-01f, 1.39047995e-01f, 3.33468691e-02f, -9.15826708e-02f, 1.38209835e-02f, 2.19750836e-01f, -4.06746715e-02f, 2.14606062e-01f,
  -9.18159857e-02f, 1.36805654e-01f, -5.82765862e-02f, 6.81323046e-03f, 1.10923089e-02f, 1.52821735e-01f, -6.93860650e-02f, -2.71282554e-01f, -6.01960346e-02f, 1.43807903e-01f,
  6.78081578e-03f, -1.93993878e-02f, 1.44044101e-01f, 1.63418263e-01f, -1.34789497e-01f, 1.55414492e-01f, 9.99723375e-02f, 1.83649868e-01f, 1.64445937e-01f, 1.65922329e-01f,
  1.42866448e-01f, 2.02598765e-01f, 1.72546983e-01f, 6.51765764e-02f, -3.81470472e-02f, -9.40141305e-02f, -2.59951167e-02f, -1.60272062e-01f, -2.49697998e-01f, -5.21791540e-02f,
  2.16568321e-01f, -1.49089143e-01f, 7.96289891e-02f, 1.36357933e-01f, 9.25711170e-02f, -1.29242996e-02f, -6.84436187e-02f, -9.98357609e-02f, -1.28834158e-01f, -9.81990620e-02f,
  -6.46188855e-02f, -1.57866962e-02f, -2.78845709e-02f, -3.70158665e-02f, 6.93980902e-02f, 1.82782769e-01f, 2.46870056e-01f, -1.65192530e-01f, 2.36679897e-01f, 8.20808932e-02f,
  1.30065069e-01f, 6.23120628e-02f, 3.07047702e-02f, -9.67795122e-03f, 1.82331294e-01f, 1.36031955e-01f, -4.25991602e-02f, -6.46221265e-02f, 4.42673871e-03f, -6.53689727e-02f,
  1.64510339e-01f, 3.06476722e-03f, 1.42265946e-01f, 1.30740404e-02f, -2.20121175e-01f, 5.94828976e-03f, -6.60477504e-02f, 3.88303660e-02f, -1.17454931e-01f, -6.65690228e-02f,
  5.24961278e-02f, 1.51771203e-01f, 1.11946784e-01f, -7.34889358e-02f, 7.54599348e-02f, 1.47121862e-01f, 1.94826588e-01f, -3.12050823e-02f, 1.60136282e-01f, -9.01131779e-02f,
  -1.60147116e-01f, -3.04206740e-02f, 5.19888438e-02f, -1.60830602e-01f, -1.50816739e-02f, -2.11243644e-01f, 3.41625847e-02f, 2.56794006e-01f, 6.16535731e-02f, 2.15964932e-02f,
  1.27546966e-01f, 1.28189564e-01f, 8.67362134e-03f, -3.61674607e-01f, 1.54056206e-01f, -3.62615526e-01f, 1.35821134e-01f, 4.43421155e-02f, 7.16463253e-02f, 1.69803835e-02f,
  2.97337532e-01f, -2.67284185e-01f, -4.21679132e-02f, -5.29604852e-02f, 1.37906566e-01f, -3.03548604e-01f, -2.11363971e-01f, 9.29639861e-03f, 2.87436275e-03f, 1.34302661e-01f,
  -1.14546657e-01f, 9.29244794e-04f, 1.67375267e-01f, 4.68069091e-02f, -6.15557237e-03f, 1.74054086e-01f, -8.54779482e-02f, -6.96159601e-02f, -1.31692976e-01f, 1.14625126e-01f,
  3.14493142e-02f, 2.05945283e-01f, -1.62412331e-01f, -8.81550089e-03f, 1.56766742e-01f, 1.64178133e-01f, 1.22370809e-01f, 5.63670248e-02f, 1.48654848e-01f, -8.11105147e-02f,
  1.52949885e-01f, 1.32923633e-01f, -4.35934700e-02f, 6.72180131e-02f, 1.22655317e-01f, -1.29616350e-01f, -9.49988738e-02f, -1.37528598e-01f, -4.08335999e-02f, 1.62895560e-01f,
  5.34059145e-02f, -4.13210869e-01f, 2.10657701e-01f, -1.81602150e-01f, -2.69416682e-02f, -5.16930073e-02f, -5.35470657e-02f, -2.38815114e-01f, 4.83571067e-02f, 6.55783489e-02f,
  3.80328111e-03f, 2.68118739e-01f, 4.78295535e-02f, -1.21676430e-01f, -3.33914876e-01f, -1.64281264e-01f, 3.86597076e-03f, 1.66696578e-01f, -3.20966803e-02f, 1.11088410e-01f,
  1.91917438e-02f, -8.34360272e-02f, 2.95919422e-02f, 1.20595105e-01f, -1.96396440e-01f, -8.93521458e-02f, 2.90054791e-02f, 1.06911123e-01f, 1.09757230e-01f, 2.73707449e-01f,
  -3.81218782e-03f, 1.37247592e-02f, 3.26957256e-02f, 1.54321656e-01f, 4.89881672e-02f, 7.80840442e-02f, -3.91434245e-02f, -2.94371873e-01f, -2.61917055e-01f, 8.66384283e-02f,
  1.88947961e-01f, 1.80697571e-02f, 1.00559741e-01f, -1.26052201e-01f, 2.16641352e-01f, -2.54222304e-02f, -1.78155378e-01f, 1.75455958e-01f, 1.26012683e-01f, -2.97509074e-01f,
  6.46125674e-02f, 3.77567932e-02f, -1.54056460e-01f, 1.68792993e-01f, 3.27250026e-02f, -2.62996286e-01f, 7.23408014e-02f, -7.73669407e-02f, 2.91620847e-02f, -2.87423462e-01f,
  2.82562245e-02f, -1.36913851e-01f, -2.45863907e-02f, -8.18339512e-02f, 1.11429401e-01f, 8.70516989e-03f, -3.67325507e-02f, 6.20622970e-02f, -1.86114237e-01f, -1.11986287e-02f,
  -2.08700791e-01f, -1.77560560e-03f, 5.13669699e-02f, -5.53969964e-02f, -1.89512506e-01f, 8.04912532e-04f, -1.44137859e-01f, 1.66682303e-01f, -4.21886519e-02f, 2.07210016e-02f,
  -6.23993427e-02f, 5.02126850e-02f, -3.16301167e-01f, -3.69629860e-02f, -1.33773640e-01f, -5.53360954e-02f, -8.26567262e-02f, 9.98843238e-02f, -5.91435209e-02f, 7.05343410e-02f,
  2.12080464e-01f, 1.82462350e-01f, 5.45262024e-02f, -3.49573307e-02f, 7.18295872e-02f, 8.39384273e-02f, -2.61376381e-01f, 1.26665616e-02f, -3.04995388e-01f, 6.75996989e-02f,
  1.10767320e-01f, -3.12179700e-02f, 1.23275772e-01f, 1.26696099e-02f, -4.56105508e-02f, 2.79216021e-01f, 5.63071407e-02f, -2.55813100e-03f, 7.45720863e-02f, 1.55879809e-02f,
  7.57281780e-02f, 6.32161647e-02f, 1.17341191e-01f, 4.98222634e-02f, -2.41367608e-01f, -1.94297079e-02f, 1.85333803e-01f, -3.29944134e-01f, -1.79384023e-01f, -1.54037014e-01f,
  4.02261354e-02f, -3.41730088e-01f, -1.02880493e-01f, 3.66633721e-02f, -1.08071581e-01f, 1.82895973e-01f, -8.97165760e-02f, -8.92540291e-02f, -1.56423360e-01f, 1.22575022e-01f,
  3.56370620e-02f, 6.61507621e-02f, -1.83108672e-02f, 1.14481546e-01f, -3.58955525e-02f, 9.70646646e-03f, 2.61201132e-02f, 1.54555723e-01f, -9.33793038e-02f, -7.14225397e-02f,
  6.00085668e-02f, 1.16215222e-01f, -1.04616441e-01f, -4.29908745e-02f, 2.62352496e-01f, -7.90835246e-02f, -4.74075466e-01f, 2.57845968e-01f, 9.20959190e-02f, -1.08906657e-01f,
  -7.17870146e-02f, 2.88205221e-02f, -4.49554026e-02f, 2.57558543e-02f, -9.06982496e-02f, 1.96440250e-01f, 1.48218229e-01f, -3.72817367e-02f, -4.96508665e-02f, -1.05983444e-01f,
  -3.27418685e-01f, 1.22481748e-03f, -1.21086054e-01f, -1.79111943e-01f, -1.23398028e-01f, -6.93139955e-02f, -7.79077262e-02f, -2.98688561e-01f, -1.96664870e-01f, 5.63224070e-02f,
  1.40550286e-01f, -1.46119803e-01f, -2.07732022e-01f, 2.24038363e-01f, 1.25683576e-01f, 7.35114068e-02f, -9.37310457e-02f, 5.78879043e-02f, -3.08807474e-02f, -1.22538574e-01f,
  9.94201675e-02f, -2.44322628e-01f, -1.45355850e-01f, -1.81833223e-01f, -1.54307028e-02f, -1.43706501e-01f, -1.42404154e-01f, -1.64229035e-01f, -2.08813459e-01f, 1.06919214e-01f,
  -8.99488106e-02f, 1.22506596e-01f, -1.37678862e-01f, 7.58296177e-02f, -8.73388425e-02f, -7.38500291e-03f, 2.12639853e-01f, 6.04661554e-02f, -2.16692197e-03f, 2.09417552e-01f,
  8.21331218e-02f, 4.31822278e-02f, 2.31610879e-01f, -7.39064068e-02f, -1.22591630e-01f, -8.21562558e-02f, -2.14023933e-01f, -3.63383740e-02f, 4.71669473e-02f, 3.19736660e-01f,
  -1.15869842e-01f, 1.40083730e-01f, 2.30196461e-01f, -5.52558042e-02f, -4.93007973e-02f, 1.77738830e-01f, -2.20143739e-02f, 6.28319457e-02f, -7.34341964e-02f, 1.34292588e-01f,
  1.07860699e-01f, 3.00871164e-01f, -3.36066425e-01f, 7.67074376e-02f, 1.42700285e-01f, 3.48977409e-02f, 1.59776099e-02f, -1.73223659e-01f, -2.03180671e-01f, -2.70816684e-01f,
  -2.60318100e-01f, 5.89773245e-03f, 2.01989278e-01f, -2.41516549e-02f, -4.84852772e-03f, 1.42821223e-01f, 2.19449475e-01f, 1.17363885e-01f, -2.22477227e-01f, -1.29815161e-01f,
  -1.20836467e-01f, -4.59338091e-02f, 7.07846284e-02f, 1.35637060e-01f, -2.65838087e-01f, 4.32690680e-02f, 6.18025437e-02f, -6.78243265e-02f, -1.14006245e-04f, 7.93388039e-02f,
  2.16265973e-02f, -3.09788764e-01f, -5.92805855e-02f, 2.02308521e-01f, -1.61872223e-01f, -8.34637582e-02f, 1.63214542e-02f, -5.13317548e-02f, -1.91604197e-02f, 1.23625815e-01f,
  3.51678804e-02f, 1.39741197e-01f, 6.42691478e-02f, -8.06258023e-02f, -1.06307194e-02f, 1.86193705e-01f, -5.69936708e-02f, 1.12578593e-01f, 8.66684392e-02f, -6.31578490e-02f,
  4.32475060e-02f, -2.16946766e-01f, 6.64282739e-02f, -1.67455450e-01f, 1.38082236e-01f, -1.79309607e-01f, 1.27429992e-01f, 4.50031042e-01f, 1.38995960e-01f, -1.53273284e-01f,
  7.68386424e-02f, -1.44876167e-01f, -1.40708713e-02f, -2.92646945e-01f, 7.14186803e-02f, -1.69531718e-01f, -5.59254773e-02f, 1.03572786e-01f, 7.38554746e-02f, 2.73744255e-01f,
  1.06180511e-01f, -1.15595296e-01f, -2.08348632e-01f, -5.09203114e-02f, -1.13398626e-01f, -1.21989489e-01f, 3.32845598e-02f, -8.41698702e-03f, 8.86078775e-02f, 7.36999437e-02f,
  -1.65051833e-01f, 2.02428009e-02f, 7.62818009e-02f, 1.18110061e-01f, 5.43062985e-02f, 1.17594771e-01f, 1.45086646e-01f, 1.06862202e-01f, 2.36177191e-01f, 1.21431641e-01f,
  1.25172059e-03f, 3.55447903e-02f, 6.79358616e-02f, 2.54671544e-01f, -1.60558954e-01f, 2.36060992e-02f, 1.60439700e-01f, -2.65442133e-01f, 1.71140768e-02f, -2.73803025e-02f,
  -7.85517767e-02f, -6.59101531e-02f, -1.83150128e-01f, -2.92792648e-01f, -5.91390967e-01f, -1.84832603e-01f, -1.67877510e-01f, 4.65591252e-02f, 1.54094815e-01f, 4.86655422e-02f,
  4.15514335e-02f, 1.09864958e-01f, 1.38748527e-01f, 8.39766562e-02f, -2.89958175e-02f, 1.59548894e-01f, 2.44406238e-01f, -2.13297158e-01f, -9.62156802e-02f, 1.79691851e-01f,
  -2.90448099e-01f, 5.77887297e-02f, 6.06912980e-03f, 3.95282358e-02f, -3.05784289e-02f, 3.51779237e-02f, -2.48196006e-01f, -1.31685566e-02f, -1.75773129e-01f, -9.48050022e-02f,
  1.31047443e-01f, -4.14380021e-02f, -1.41473398e-01f, 5.76033769e-03f, -6.10959576e-03f, 1.55742556e-01f, 2.17482314e-01f, 7.19974265e-02f, 2.31143668e-01f, -5.32524399e-02f,
  -1.22923627e-01f, -7.07603097e-02f, 2.26964224e-02f, 1.93622693e-01f, 3.52372527e-02f, -3.20327163e-01f, 5.91565557e-02f, -1.33213669e-01f, -6.53636362e-03f, -4.44216765e-02f,
  2.29516536e-01f, -2.65252888e-01f, -9.19030830e-02f, -1.83809146e-01f, -1.50972962e-01f, -5.96313039e-03f, -3.21430445e-01f, -1.39631927e-01f, 3.18931974e-02f, -3.34540486e-01f,
  9.52784121e-02f, 1.54639361e-02f, 2.47217551e-01f, 1.88292801e-01f, -2.06069395e-01f, -4.91708294e-02f, 1.31339833e-01f, -1.38098136e-01f, 1.40630439e-01f, -1.85802341e-01f,
  -3.91167365e-02f, -1.45856543e-02f, -6.47449121e-02f, -2.17782289e-01f, 3.00672323e-01f, 1.31722465e-01f, 3.02602798e-01f, 1.56898737e-01f, 1.66799620e-01f, 1.86459169e-01f,
  3.12620431e-01f, 1.56090945e-01f, 3.07311565e-01f, 4.68877107e-02f, 3.23212087e-01f, 3.81701887e-02f, -1.33033842e-01f, -5.05829081e-02f, 2.15670198e-01f, 2.71230757e-01f,
  1.78356662e-01f, -1.38250496e-02f, 1.17911234e-01f, 2.03691870e-01f, -2.98574299e-01f, -2.28250828e-02f, 9.13099498e-02f, -9.07314122e-02f, -1.71106756e-01f, -4.97305393e-02f,
  -8.38788524e-02f, 4.52341372e-03f, 5.81016950e-03f, -1.28077270e-04f, 2.00394168e-02f, 1.05667002e-02f, -8.91288444e-02f, 6.82034418e-02f, -2.33327914e-02f, 4.18943614e-02f,
  -1.31894559e-01f, -1.13375165e-01f, -1.50646046e-01f, -1.50490344e-01f, -1.25985011e-01f, 3.95448446e-01f, 9.29406881e-02f, 8.92965868e-02f, 3.74832749e-02f, 2.46025212e-02f,
  2.59684026e-01f, 1.03371702e-01f, -1.76466674e-01f, -3.57162625e-01f, -2.24378049e-01f, 6.46901205e-02f, -2.38746360e-01f, -2.31449232e-01f, 2.83075333e-01f, -9.87851322e-02f,
  -1.39802814e-01f, 2.83704817e-01f, 1.89024508e-01f, 1.32090911e-01f, 2.29824428e-02f, -9.54497792e-03f, 9.66341645e-02f, 1.09674275e-01f, 2.29752719e-01f, 2.17451274e-01f,
  1.13580979e-01f, 9.61238444e-02f, -1.02972817e-02f, 1.13601737e-01f, -2.14369103e-01f, 1.03643909e-01f, 3.51522923e-01f, 2.70371083e-02f, 1.80085927e-01f, 3.27939242e-02f,
  -5.28138950e-02f, 2.25571282e-02f, -1.34827927e-01f, -5.58379143e-02f, -1.24398656e-01f, -5.20526171e-02f, -4.74878177e-02f, 2.84131229e-01f, 1.18145160e-01f, 1.14306077e-01f,
  -6.48797527e-02f, -3.60867418e-02f, 2.27212012e-01f, -2.21275836e-01f, 4.54258695e-02f, 2.77100541e-02f, -1.06762461e-01f, 3.03091109e-01f, 1.80935226e-02f, 2.19921604e-01f,
  1.74068913e-01f, -7.94690549e-02f, 6.91454038e-02f, -4.58936058e-02f, 1.20886862e-01f, -6.53333366e-02f, 6.51701391e-02f, 1.11505903e-01f, -7.56025128e-03f, -7.92025849e-02f,
  -2.04702511e-01f, 9.99086425e-02f, 1.22732334e-01f, -1.76209599e-01f, 6.16508424e-02f, -2.99268123e-02f, 1.29597694e-01f, 5.01432776e-01f, 9.44185182e-02f, 3.60653736e-02f,
  1.12785026e-01f, -1.81321383e-01f, -4.59136516e-02f, -1.41015604e-01f, -3.91262211e-02f, -1.47360023e-02f, 7.58982683e-03f, 6.04935214e-02f, 3.14350277e-02f, -1.34894863e-01f,
  2.68511623e-02f, 1.66896313e-01f, 4.39011753e-01f, 1.47912726e-01f, 3.37127715e-01f, 2.21000463e-01f, 1.52472496e-01f, 2.99611837e-01f, 9.28863660e-02f, 3.19030285e-01f,
  5.19887149e-01f, 1.17599189e-01f, 1.83984011e-01f, -2.29355469e-02f, 1.54874936e-01f, -1.82835590e-02f, -8.36495608e-02f, 1.93716452e-01f, 3.53083760e-03f, 8.60302672e-02f,
  1.39118368e-02f, 4.07482028e-01f, -1.95936054e-01f, 4.07611057e-02f, 6.41406402e-02f, 4.17285673e-02f, 9.97256953e-03f, -1.36234358e-01f, 2.48365011e-02f, 1.69544980e-01f,
  4.31054682e-02f, 2.69830618e-02f, 1.22646809e-01f, -4.40888144e-02f, 1.02059096e-01f, 1.52398050e-02f, 1.48831695e-01f, 9.13293138e-02f, 1.44999743e-01f, -2.90408909e-01f,
  1.91901587e-02f, 7.06112757e-02f, -3.15481164e-02f, 1.35997266e-01f, -3.19098324e-01f, 1.33461446e-01f, 1.23748966e-01f, -1.07343318e-02f, 2.06244484e-01f, 9.92914289e-02f,
  5.77311181e-02f, 6.50415272e-02f, -1.34512380e-01f, -3.06487717e-02f, -1.15486734e-01f, -3.31660867e-01f, 3.25709820e-01f, 7.22732469e-02f, -1.23307228e-01f, 2.59870052e-01f,
  5.64816445e-02f, 6.09190352e-02f, 8.26557651e-02f, 3.03429794e-02f, 4.30918895e-02f, 2.67307997e-01f, 1.46823257e-01f, 3.04170400e-02f, 2.21160039e-01f, 2.50761151e-01f,
  1.70062765e-01f, 1.50166929e-01f, 1.49739549e-01f, 1.82971671e-01f, -1.73999265e-01f, 4.99581873e-01f, -1.84550241e-01f, 1.38097242e-01f, 3.86451334e-02f, 1.53067887e-01f,
  -7.74473399e-02f, 2.70702183e-01f, 2.96271183e-02f, 7.67628103e-02f, 4.17915918e-02f, -2.31988486e-02f, -6.42017573e-02f, 1.55884130e-02f, 8.03049561e-03f, 2.32622966e-01f,
  -1.15114599e-01f, -1.72126919e-01f, 2.13505235e-02f, 3.22584033e-01f, 2.56992608e-01f, -4.26950574e-01f, 4.34708409e-02f, -1.03547506e-01f, 1.38284221e-01f, -1.42174825e-01f,
  2.24403422e-02f, -1.50452092e-01f, 3.75972331e-01f, -8.52102488e-02f, 1.27575219e-01f, -9.79528725e-02f, 1.71924353e-01f, -2.64604352e-02f, -7.45395124e-02f, -1.49191869e-02f,
  -4.87846136e-02f, -2.11212784e-02f, -5.68043515e-02f, -5.01807146e-02f, -1.42537570e-02f, -2.20606193e-01f, -1.52571157e-01f, 5.24650849e-02f, -7.43574230e-04f, 1.38932034e-01f,
  -3.63391265e-02f, 3.54591101e-01f, -1.66892543e-01f, 3.96813340e-02f, 4.00467366e-02f, 9.68414247e-02f, -1.29508272e-01f, 9.60601866e-02f, -5.56626767e-02f, -1.57169268e-01f,
  1.57830879e-01f, 1.05475411e-01f, -2.90408246e-02f, 3.13414633e-01f, 2.01043174e-01f, -1.04330979e-01f, 1.60231039e-01f, 9.30532515e-02f, 1.10471353e-01f, 8.05986375e-02f,
  2.44489402e-01f, -6.14299439e-02f, 1.02240972e-01f, -6.03026785e-02f, -5.26360460e-02f, -6.37300499e-03f, -5.96484877e-02f, -2.44940352e-02f, 1.97063640e-01f, 1.28625587e-01f,
  -1.57158047e-01f, -1.36375139e-02f, 9.47378129e-02f, 6.40922738e-03f, -1.98298823e-02f, -1.07549235e-01f, -3.63107808e-02f, -5.74016571e-02f, -1.63059384e-01f, 8.55019689e-02f,
  1.80046171e-01f, -2.48187885e-01f, -1.91736314e-02f, 1.76173389e-01f, -1.01655342e-01f, 6.19904026e-02f, -7.25263506e-02f, -8.29591975e-02f, -1.77083425e-02f, -1.25706583e-01f,
  1.99480996e-01f, 8.10308903e-02f, -8.29945579e-02f, 4.13072333e-02f, 8.07723552e-02f, 7.01349303e-02f, 4.97382842e-02f, 8.06621686e-02f, 1.15091629e-01f, -3.09500307e-01f,
  -9.47514623e-02f, 1.21987045e-01f, -1.35220185e-01f, -1.25935614e-01f, 8.44954252e-02f, -1.49748370e-01f, 3.03974524e-02f, 1.09593585e-01f, -1.07620373e-01f, 2.79721450e-02f,
  -1.39540657e-01f, -4.94493917e-02f, 4.60296422e-02f, 1.97309986e-01f, -1.42902970e-01f, 1.44945994e-01f, -4.07981575e-02f, 1.97820008e-01f, 1.14673480e-01f, 2.73166120e-01f,
  2.13223189e-01f, 4.80811819e-02f, -3.85363281e-01f, 1.46447346e-01f, -1.82998911e-01f, -5.57110272e-02f, -1.87295601e-01f, -1.79938391e-01f, -1.27380257e-02f, 1.04905248e-01f,
  5.73924780e-02f, 5.88436984e-02f, -1.67992964e-01f, -3.05520976e-03f, 4.32528555e-02f, -1.94334596e-01f, -3.77777576e-01f, -1.54517397e-01f, -2.59839892e-01f, 9.14843529e-02f,
  9.82770622e-02f, 2.36535887e-03f, 5.93034038e-03f, -2.87106782e-01f, -6.59253299e-02f, 1.29656643e-01f, -1.25579894e-01f, -9.14488733e-02f, -2.60147810e-01f, -7.38519356e-02f,
  6.17296956e-02f, -1.57871529e-01f, 2.65016481e-02f, 2.13669538e-01f, -1.96041852e-01f, -8.56411904e-02f, 2.07412899e-01f, -3.48518342e-01f, -1.46620736e-01f, -1.28909677e-01f,
  -8.63449275e-02f, -2.58017302e-01f, -1.63686395e-01f, -2.25530982e-01f, -2.99841940e-01f, -9.26438197e-02f, 2.96694203e-03f, 3.38465162e-03f, 2.31680851e-02f, 1.55986339e-01f,
  -1.00912273e-01f, 1.62217654e-02f, 1.21439986e-01f, 3.94821391e-02f, -9.96184163e-03f, 3.30814421e-02f, -3.75778638e-02f, -1.48215778e-02f, 1.76156387e-01f, -2.17655510e-01f,
  -6.87414035e-02f, 1.34349927e-01f, 5.53036146e-02f, -6.82008266e-02f, -1.47144839e-01f, 1.97713181e-01f, 6.25089742e-03f, 1.52050689e-01f, 4.43794392e-02f, -2.03852672e-02f,
  1.28699675e-01f, 7.19092879e-03f, -1.15945302e-02f, -9.09802318e-03f, 2.69936562e-01f, 8.76799300e-02f, -1.06072649e-01f, 2.47261047e-01f, -7.77665451e-02f, 1.01512700e-01f,
  1.82757735e-01f, -1.51498303e-01f, -1.37902126e-01f, 2.11761490e-01f, -1.14681408e-01f, -1.46021485e-01f, -1.25678211e-01f, 1.17674835e-01f, -7.86221400e-02f, 1.72791377e-01f,
  -9.87233818e-02f, -3.28838639e-02f, 3.16734284e-01f, -3.38302590e-02f, -1.17620632e-01f, -5.38580492e-02f, -1.35888010e-01f, -7.04096705e-02f, 3.47147882e-03f, 7.06190430e-03f,
  9.16898102e-02f, -6.99774846e-02f, 1.35169616e-02f, 4.59935740e-02f, 1.21162042e-01f, 5.73666990e-02f, 1.12543054e-01f, 1.41457781e-01f, -7.15494202e-03f, 1.29377931e-01f,
  -1.20530926e-01f, -5.46338558e-02f, 3.35843004e-02f, -1.34624941e-02f, -1.34965986e-01f, 1.68377429e-01f, 4.05910052e-02f, 8.39250907e-02f, 7.24292770e-02f, -4.62199263e-02f,
  9.27357748e-02f, 2.36608163e-01f, 2.55841631e-02f, 5.07171825e-02f, 1.80372685e-01f, 1.07472710e-01f, 2.14927256e-01f, 7.61590824e-02f, -1.85565025e-01f, -2.22899348e-01f,
  -3.99706215e-02f, -1.10191375e-01f, 2.46048227e-01f, 2.03735575e-01f, -1.69540592e-03f, -1.75520971e-01f, 9.47011784e-02f, -3.62556353e-02f, -2.22131982e-01f, -9.70294327e-02f,
  -3.65980435e-03f, -3.20852362e-02f, -1.39163196e-01f, -2.08309755e-01f, -1.02758132e-01f, 7.99553022e-02f, -2.43246645e-01f, -1.36971354e-01f, 2.69766390e-01f, 1.17004596e-01f,
  -8.68150741e-02f, -1.54527500e-01f, -8.27430859e-02f, -2.06613541e-01f, -2.11027175e-01f, 1.91537768e-01f, 7.42623135e-02f, 5.99918962e-02f, -6.19214913e-03f, -2.07843095e-01f,
  2.04864275e-02f, 1.39690965e-01f, -9.96350050e-02f, -6.39158711e-02f, -4.36244458e-02f, -2.10957110e-01f, 7.99012259e-02f, 1.88451782e-01f, 7.05215037e-02f, -9.83479097e-02f,
  1.25530049e-01f, 9.31562260e-02f, -9.84050427e-03f, -6.72619566e-02f, -5.81716634e-02f, 2.19060734e-01f, -2.78770342e-03f, -2.75742024e-01f, 2.29478747e-01f, 2.80625932e-02f,
  -9.49340165e-02f, 5.13471365e-02f, -1.12021141e-01f, -1.78574502e-01f, -1.09865606e-01f, 7.52346311e-03f, 2.36275673e-01f, 3.20948213e-02f, -2.22887471e-03f, 3.87244113e-02f,
  -7.80011341e-02f, -2.19675332e-01f, -1.67321876e-01f, 1.20937645e-01f, 2.56435084e-03f, 3.96560669e-01f, 3.10917407e-01f, -2.09169120e-01f, -3.91375758e-02f, 1.88655853e-01f,
  -3.62689719e-02f, -1.71113461e-01f, 1.26385927e-01f, 7.82439560e-02f, 2.03309253e-01f, 1.28983974e-01f, -1.95890188e-01f, 5.89382909e-02f, -9.90603268e-02f, -1.10160597e-01f,
  -4.15704679e-03f, 7.72959441e-02f, -4.53608096e-01f, -4.17326272e-01f, -1.40127048e-01f, 2.71307200e-01f, -1.31898224e-02f, -8.53156075e-02f, -2.97188967e-01f, 1.12083577e-01f,
  2.61785865e-01f, 9.82461199e-02f, -1.42406002e-01f, 6.02909029e-02f, -2.05065116e-01f, -1.27401367e-01f, -1.07717164e-01f, -3.78213935e-02f, 1.14016021e-02f, 4.62100059e-02f,
  1.38941273e-01f, 8.66285264e-02f, 1.05960608e-01f, -3.27283032e-02f, 2.71777213e-01f, 4.49772105e-02f, -6.51666895e-02f, 2.11991351e-02f, -2.82530218e-01f, -1.51753455e-01f,
  -7.33356401e-02f, -2.22401261e-01f, -1.84541345e-01f, -3.11482493e-02f, 1.71898620e-03f, 5.66478726e-03f, -2.23243013e-01f, -1.34556502e-01f, 2.94893812e-02f, 7.77193382e-02f,
  1.90546811e-02f, 1.88856065e-01f, 6.51822686e-02f, -5.78604313e-03f, -6.36106953e-02f, 2.13880703e-01f, 2.79366493e-01f, 2.90571284e-02f, -2.44411021e-01f, 2.27998912e-01f,
  -1.90146133e-01f, 1.94897819e-02f, -2.97195673e-01f, -1.85494661e-01f, -5.83748259e-02f, 1.63037047e-01f, 1.89953104e-01f, 1.72939181e-01f, -1.10884808e-01f, -9.08460617e-02f,
  1.03609703e-01f, -1.15513392e-02f, -3.49175215e-01f, -1.98690236e-01f, -3.35837960e-01f, -1.18514456e-01f, -3.95033583e-02f, 1.50083035e-01f, 7.13111088e-02f, -1.65287539e-01f,
  -1.94429532e-01f, 2.33579606e-01f, -3.68392579e-02f, -2.37217352e-01f, -1.64039060e-01f, -1.01846784e-01f, 3.01783700e-02f, -1.91685066e-01f, 5.10673821e-02f, 4.97978814e-02f,
  -2.53681809e-01f, 1.80587862e-02f, 1.35548428e-01f, -1.60131171e-01f, -1.25236347e-01f, -1.68145671e-02f, -1.01669528e-01f, -1.43299803e-01f, -1.66883111e-01f, -2.21597165e-01f,
  -1.33936614e-01f, 1.69762626e-01f, 7.80258775e-02f, -1.77195370e-02f, -7.53369853e-02f, 1.23579614e-01f, 6.27031028e-02f, 6.35161027e-02f, 1.91863984e-01f, 5.26052192e-02f,
  1.00033142e-01f, 1.48998335e-01f, -1.16681866e-01f, 1.23118296e-01f, 2.29843244e-01f, 2.83789426e-01f, 1.86149567e-01f, 3.78110399e-03f, 1.01188920e-01f, 1.49079099e-01f,
  1.53251946e-01f, -1.39202729e-01f, 1.13874801e-01f, -2.46400967e-01f, 2.24491879e-01f, -6.64577112e-02f, -2.70345509e-02f, -9.63173658e-02f, 1.70439512e-01f, 3.02365515e-04f,
  4.12108637e-02f, 4.84911315e-02f, 1.67301729e-01f, -2.81224251e-01f, -1.20383255e-01f, -6.12033382e-02f, -1.00999631e-01f, 3.81242260e-02f, -1.10956050e-01f, -4.16870177e-01f,
  -1.46852270e-01f, 2.36681066e-02f, -1.25382647e-01f, -1.63598955e-02f, -4.86628003e-02f, -2.43453234e-01f, 1.26351327e-01f, 1.41542703e-01f, -1.51579991e-01f, 3.15697134e-01f,
  1.53082069e-02f, 4.34444360e-02f, 2.58390456e-02f, -9.92470533e-02f, 1.17023192e-01f, 4.77013849e-02f, 8.26181844e-02f, -1.95520222e-01f, -7.67692178e-02f, 6.30768985e-02f,
  1.01804815e-01f, 2.37236321e-01f, -6.05353639e-02f, -3.07078123e-01f, -8.23346376e-02f, 7.35573918e-02f, -1.15380451e-01f, -1.73421830e-01f, -5.48734069e-02f, -5.02514355e-02f,
  -5.61771281e-02f, -1.40766770e-01f, -4.26271223e-02f, 3.27724785e-01f, -7.27540180e-02f, 3.51373777e-02f, 1.41147569e-01f, 5.32054231e-02f, 1.21711493e-01f, 2.76402533e-01f,
  1.23732775e-01f, 1.44936323e-01f, 2.55119771e-01f, 4.00255412e-01f, 3.30482656e-03f, -3.10387909e-01f, 1.31950244e-01f, -5.07531464e-01f, 1.49663806e-01f, -1.76874362e-02f,
  -1.01409078e-01f, -2.47186020e-01f, 2.04319105e-01f, 8.16165470e-03f, -3.61166932e-02f, 1.98626565e-03f, 9.38549191e-02f, -2.25800127e-01f, 2.43444219e-01f, -1.23911075e-01f,
  -3.36611643e-02f, 3.53171565e-02f, -1.21920787e-01f, -7.15078861e-02f, 1.98202938e-01f, 8.80318210e-02f, 4.00009714e-02f, -9.42972209e-03f, -4.63526994e-02f, 1.87894760e-03f,
  -1.04383659e-02f, 1.58488438e-01f, -1.85643122e-01f, 1.66180775e-01f, -3.28197517e-02f, -1.81983560e-01f, -1.37360975e-01f, 4.11792174e-02f, -4.84216399e-02f, 1.61710888e-01f,
  7.51505271e-02f, -1.11897849e-02f, -7.81692043e-02f, 1.47848174e-01f, 1.38839604e-02f, 7.16950297e-02f, 1.10500731e-01f, -8.78403932e-02f, 8.20021257e-02f, -2.58816034e-03f,
  8.38664696e-02f, -4.24833074e-02f, -6.55619130e-02f, -3.06085557e-01f, 1.89965829e-01f, -1.08412020e-01f, 6.91136196e-02f, 5.60630718e-03f, -2.54798718e-02f, -8.44385754e-03f,
  4.79267873e-02f, 2.20959708e-02f, 1.22745372e-01f, 1.97264194e-01f, 3.57407071e-02f, -9.99857336e-02f, -2.23504812e-01f, -7.35111162e-02f, -1.46700278e-01f, -1.81906566e-01f,
  2.49800906e-01f, -3.50004822e-01f, 8.38696584e-02f, 5.10171838e-02f, -3.44076417e-02f, 7.67223211e-03f, 1.90567210e-01f, -3.46778274e-01f, -9.15374905e-02f, -4.44341779e-01f,
  1.13066912e-01f, -2.59441167e-01f, -2.68502980e-02f, 8.20354596e-02f, -1.08076073e-01f, 2.76300877e-01f, 1.94764629e-01f, -2.05334425e-01f, -1.47211775e-01f, -1.41944483e-01f,
  -1.82073742e-01f, 1.60965666e-01f, -1.95645988e-02f, -1.88158620e-02f, -3.33481692e-02f, 1.23290211e-01f, -2.04076871e-01f, 1.09274887e-01f, 7.98195526e-02f, -1.76071073e-03f,
  4.63548414e-02f, 2.69966107e-02f, -7.58503973e-02f, 2.73719821e-02f, 4.71740887e-02f, 4.03324468e-03f, -8.21756572e-02f, 2.54687220e-01f, -3.21760178e-02f, 5.35736345e-02f,
  -5.94445243e-02f, 1.03833295e-01f, 5.75639680e-02f, -2.10310727e-01f, -5.34229632e-03f, 6.60287142e-02f, 1.65274032e-05f, -3.87817249e-02f, -1.05766810e-01f, -3.73729795e-01f,
  -6.61798596e-01f, -2.81354487e-01f, -1.10969141e-01f, -8.90578255e-02f, 1.42382115e-01f, 3.20978090e-02f, 4.82813776e-01f, 5.16504720e-02f, 1.19261786e-01f, 2.24527776e-01f,
  2.90939137e-02f, 2.60654598e-01f, 1.93566248e-01f, 5.01561277e-02f, 1.09152466e-01f, 2.10220590e-01f, 3.22232962e-01f, -1.82981253e-01f, -1.01097703e-01f, -2.76332833e-02f,
  -7.04127774e-02f, 3.75593379e-02f, -7.46616349e-02f, -4.71404307e-02f, 5.40307127e-02f, 2.58989334e-01f, -2.21117631e-01f, -8.31031352e-02f, 9.04791206e-02f, -1.90631330e-01f,
  -2.23655969e-01f, -7.84363374e-02f, 2.14528423e-02f, -1.59925073e-01f, -5.66722564e-02f, 1.27770856e-01f, 1.06722854e-01f, -2.27569163e-01f, -2.83086568e-01f, 2.38139138e-01f,
  2.01144770e-01f, -6.72437176e-02f, -2.56664664e-01f, -1.34078920e-01f, -1.98499307e-01f, -1.37387797e-01f, -3.35918814e-02f, 2.01151580e-01f, -3.16436112e-01f, 5.35589904e-02f,
  2.54320443e-01f, 2.13702526e-02f, 8.53370056e-02f, 1.17153220e-01f, 1.36561751e-01f, -3.97320479e-01f, -9.03129354e-02f, 2.21581310e-02f, -1.65848717e-01f, -1.12731047e-01f,
  1.95049882e-01f, -2.92322278e-01f, 1.22472040e-01f, 9.75486487e-02f, 1.83625817e-01f, 9.76168439e-02f, 1.18525717e-02f, -2.04198956e-01f, 3.20255049e-02f, 2.34139204e-01f,
  7.59386318e-03f, 1.37929365e-01f, 9.57364738e-02f, 4.58586887e-02f, 3.78935151e-02f, 8.63696784e-02f, 1.09132893e-01f, -4.85079773e-02f, 3.60309444e-02f, 4.17441517e-01f,
  -1.25272289e-01f, 2.83804297e-01f, 9.21414942e-02f, -1.59935874e-03f, -3.43812853e-01f, 5.59440777e-02f, 6.85971901e-02f, -1.78714301e-02f, -2.29083344e-01f, -2.11120993e-01f,
  1.50251999e-01f, -2.32472017e-01f, -3.46408449e-02f, 3.58167477e-02f, -1.07857727e-01f, -1.83973968e-01f, 2.32695773e-01f, 2.54517466e-01f, 2.68623292e-01f, -1.00359336e-01f,
  -5.61421402e-02f, -9.41576138e-02f, 1.40593782e-01f, -7.76212215e-02f, -2.37631220e-02f, -2.63882726e-01f, 2.66386092e-01f, -9.88979414e-02f, 4.03837971e-02f, 2.01696321e-01f,
  3.75298113e-02f, -3.48246574e-01f, -1.29160210e-01f, 5.80895282e-02f, -2.23755874e-02f, 3.30461226e-02f, -2.15601921e-01f, 1.17530122e-01f, 1.36468085e-02f, 1.02607958e-01f,
  2.83930093e-01f, 6.37155026e-02f, 1.11100167e-01f, 8.14753100e-02f, 6.20615743e-02f, 2.06904426e-01f, -2.17550412e-01f, -8.68811235e-02f, 1.85450315e-02f, 9.88798290e-02f,
  -1.94578707e-01f, 1.26345128e-01f, -8.85838717e-02f, -3.19170266e-01f, -1.21662147e-01f, 2.31262073e-01f, -3.43747362e-02f, 6.28159717e-02f, 8.33338797e-02f, 3.07611227e-01f,
  1.70393199e-01f, -1.82652831e-01f, -2.63494074e-01f, -4.64396477e-02f, -1.69575095e-01f, -2.52298057e-01f, 1.89131312e-02f, 1.98606446e-01f, 1.36573792e-01f, -1.08281948e-01f,
  -3.19357850e-02f, 2.57401139e-01f, 2.05830574e-01f, 6.50105327e-02f, 1.72753662e-01f, 6.22989573e-02f, -2.76289284e-01f, -6.98141381e-02f, 1.78693458e-01f, 1.32880181e-01f,
  1.36915922e-01f, -6.27143010e-02f, 1.26143128e-01f, 1.89181045e-01f, 6.43812343e-02f, 1.14807792e-01f, 1.22407325e-01f, -1.25704035e-01f, -1.33454248e-01f, 1.26441732e-01f,
  -1.96422338e-02f, 7.03506619e-02f, 2.27556285e-02f, 5.17075285e-02f, 1.17686182e-01f, -2.30067268e-01f, 1.32644922e-01f, -6.75717741e-02f, 7.59254321e-02f, -2.10647017e-01f,
  -1.20852888e-01f, -1.22745089e-01f, -1.52222753e-01f, 2.57416070e-02f, 1.50719266e-02f, 2.09184423e-01f, 2.32388973e-01f, 2.43447907e-02f, -3.86238277e-01f, -1.13830216e-01f,
  -7.40082818e-04f, -9.93953347e-02f, 9.74729434e-02f, 1.30727634e-01f, 1.45291388e-01f, 1.11098722e-01f, -5.02484180e-02f, -1.47390261e-01f, 1.61891580e-01f, 4.67766300e-02f,
  1.20340757e-01f, 6.74262270e-02f, 1.53038800e-01f, 1.82691872e-01f, 1.16073549e-01f, 1.29800681e-02f, -2.18827009e-01f, 1.14626646e-01f, -3.44948947e-01f, -5.62141016e-02f,
  -1.69231053e-02f, 1.26286626e-01f, -7.75815360e-03f, 2.24611059e-01f, 9.75174271e-03f, 5.23151308e-02f, -8.93174708e-02f, 1.65962819e-02f, 4.92462218e-02f, -3.64420973e-02f,
  -2.29721606e-01f, 2.36883387e-03f, 1.12504534e-01f, -1.17438644e-01f, 9.18790698e-02f, 2.06822470e-01f, 1.44881204e-01f, 1.56402707e-01f, -2.28309147e-02f, 2.78470423e-02f,
  2.75184125e-01f, -2.42445320e-02f, -7.42826387e-02f, -1.96409523e-01f, 2.07622856e-01f, 4.87150662e-02f, -7.00064423e-03f, -2.04370290e-01f, 1.64431915e-01f, -2.04771399e-01f,
  -9.62225497e-02f, -1.42496601e-01f, -7.83214197e-02f, -1.10935410e-02f, -8.47111195e-02f, -1.89454839e-01f, -1.74752563e-01f, -2.71332078e-02f, 2.56632064e-02f, 9.94581506e-02f,
  6.44475669e-02f, -2.86246706e-02f, -1.12378627e-01f, 1.15284383e-01f, 8.75495747e-02f, 4.78372611e-02f, 7.94017240e-02f, -1.63374186e-01f, 1.37736306e-01f, 1.22523107e-01f,
  -4.70874570e-02f, -9.44570899e-02f, 8.67947191e-02f, 3.32494199e-01f, 9.85400230e-02f, -1.75601602e-01f, -1.63885087e-01f, 2.04729624e-02f, -5.53710433e-03f, -1.02797501e-01f,
  3.60128611e-01f, -5.99877834e-01f, -5.95194921e-02f, -1.54754639e-01f, 2.13043056e-02f, -5.69566227e-02f, 3.33876997e-01f, -4.25769500e-02f, -1.97009414e-01f, 2.63818614e-02f,
  1.95217595e-01f, -5.72539121e-02f, 1.08535498e-01f, 3.90552683e-03f, -2.44543210e-01f, 2.39575058e-01f, 3.60120893e-01f, -1.78884730e-01f, -8.16008300e-02f, -7.28880242e-02f,
  -9.66432393e-02f, 2.97630638e-01f, 6.21140599e-02f, 2.52306134e-01f, 1.74466878e-01f, -5.75932115e-02f, -3.33629936e-01f, 1.91478133e-02f, -8.53366479e-02f, 1.10656448e-01f,
  6.48013502e-02f, 3.42885181e-02f, 1.10224774e-02f, 2.17971087e-01f, 1.26506463e-01f, -7.53495246e-02f, 9.24299732e-02f, 5.51734567e-02f, 5.51092923e-02f, 1.64693415e-01f,
  8.39248952e-03f, 5.95563129e-02f, -1.48139834e-01f, -2.06602067e-02f, 3.98652405e-02f, -9.33942199e-02f, 2.49916036e-02f, -1.51092932e-01f, 1.87337130e-01f, -2.33868122e-01f,
  -2.62330044e-02f, -1.65734142e-01f, 2.40640007e-02f, -1.76641256e-01f, 1.69056430e-01f, 2.35624285e-03f, 3.79896387e-02f, -1.19757988e-01f, -1.30127734e-02f, -4.35818266e-03f,
  2.46844769e-01f, -1.55763552e-01f, -1.66231468e-01f, -2.68934518e-02f, 1.26676783e-01f, 4.65465300e-02f, 2.49157902e-02f, 3.77068192e-01f, 1.27690092e-01f, 5.90665545e-03f,
  -1.32313237e-01f, -2.25741148e-01f, -1.53044954e-01f, -1.05200246e-01f, -2.57348597e-01f, -1.36250794e-01f, 4.23749387e-02f, 3.62140834e-02f, 1.51717916e-01f, 1.00371903e-02f,
  -1.99226931e-01f, 9.01392177e-02f, 1.24546327e-01f, 1.33511407e-04f, 1.00717448e-01f, -1.93836242e-02f, 3.96156050e-02f, -4.21905160e-01f, -1.33319676e-01f, 2.04196751e-01f,
  -6.98303357e-02f, -1.23569123e-01f, 6.88070729e-02f, -1.08926885e-01f, 1.63549453e-01f, 2.46366441e-01f, -4.05505635e-02f, -1.79052189e-01f, -2.56484866e-01f, 3.76678780e-02f,
  1.41973063e-01f, 1.42893255e-01f, -1.95041478e-01f, 7.46692196e-02f, 9.44705233e-02f, 3.37826163e-02f, 1.74799845e-01f, -1.04826756e-01f, 5.36270300e-03f, 2.34877229e-01f,
  4.11102511e-02f, -2.71472514e-01f, 3.02707613e-01f, -1.09866075e-01f, -1.57916471e-01f, -1.02932332e-02f, -2.68906116e-01f, -9.04568285e-02f, -1.44304633e-01f, -2.11557180e-01f,
  -2.97897458e-01f, 1.40327081e-01f, -8.39614421e-02f, -3.22892852e-02f, -1.54147208e-01f, -1.26338795e-01f, 2.60574371e-02f, 2.22862095e-01f, -3.46392423e-01f, 2.06798434e-01f,
  -1.17722310e-01f, -1.88514233e-01f, 1.30728353e-02f, 5.14042675e-02f, -9.84279290e-02f, 2.75135506e-02f, -1.67747408e-01f, 3.09113026e-01f, 2.84044325e-01f, 4.57471684e-02f,
  1.37124255e-01f, 1.80635825e-01f, -6.69904426e-02f, 7.84239173e-02f, 1.35828525e-01f, 3.37379836e-02f, 1.27150774e-01f, 1.17891133e-02f, -1.19727910e-01f, 8.80050007e-03f,
  1.22023568e-01f, 3.34428623e-02f, 2.38843605e-01f, -1.62491977e-01f, -5.36012501e-02f, 2.99325407e-01f, -1.09866664e-01f, 2.07040280e-01f, -3.32120657e-02f, -1.27469061e-03f,
  4.18196432e-02f, -1.41153336e-01f, 4.12162505e-02f, -3.01875696e-02f, 6.36604950e-02f, -4.27580699e-02f, -2.05985636e-01f, -1.59463987e-01f, -1.55391663e-01f, 1.59039851e-02f,
  -7.92311355e-02f, 1.54581100e-01f, -4.70084734e-02f, -2.52948422e-02f, -2.94528455e-01f, -3.22417729e-02f, 4.47044373e-02f, 6.06222488e-02f, -1.80949853e-03f, 1.52743980e-01f,
  4.49936129e-02f, 2.45421126e-01f, 8.55955258e-02f, -1.99453644e-02f, 4.04633470e-02f, -1.71832368e-02f, -2.59144045e-02f, -3.25247124e-02f, 2.84873582e-02f, -6.51790127e-02f,
  -8.70913714e-02f, -2.43344799e-01f, 6.01990968e-02f, -5.82610629e-02f, 9.10298675e-02f, 3.02099168e-01f, 6.69710711e-02f, -1.21357217e-01f, -1.07954636e-01f, 7.76171535e-02f,
  -2.73162037e-01f, -1.94743015e-02f, -1.74213439e-01f, -2.22943779e-02f, 8.50661322e-02f, -1.01862244e-01f, -1.13025727e-02f, 1.65674984e-01f, -9.51365083e-02f, -3.12272515e-02f,
  4.70869988e-03f, 1.96785536e-02f, 2.15941072e-02f, 4.45351703e-03f, 7.91345835e-02f, -2.51941919e-01f, 4.25347909e-02f, 5.58458678e-02f, 1.05789274e-01f, -1.33882120e-01f,
  6.61751702e-02f, -9.47854668e-02f, 9.51820537e-02f, 1.51681006e-01f, 9.17429924e-02f, -3.81226204e-02f, -2.11058781e-01f, -6.07547797e-02f, 6.40897155e-02f, 5.33399060e-02f,
  -7.36561418e-02f, -4.35406454e-02f, 9.36591178e-02f, 2.27749407e-01f, 2.94716675e-02f, -1.00802071e-02f, 1.58472508e-01f, 2.24198461e-01f, 6.75421879e-02f, -6.51151687e-02f,
  1.46101519e-01f, -4.90374081e-02f, -3.99579778e-02f, -1.14194766e-01f, -1.43965289e-01f, -2.16699481e-01f, -1.20769463e-01f, -1.20093763e-01f, -3.28778587e-02f, 2.76559889e-02f,
  -2.90271044e-02f, -9.63955373e-02f, -3.47069263e-01f, -2.18028277e-01f, -1.09065175e-01f, 3.63748670e-01f, -1.28034517e-01f, 1.15374811e-01f, -9.89514869e-03f, -1.00494153e-03f,
  1.03654236e-01f, 2.30272517e-01f, -2.50325590e-01f, -6.04329780e-02f, -2.81269923e-02f, 1.56197175e-01f, 4.25766688e-03f, 2.83154458e-01f, 9.90445018e-02f, 2.28368089e-01f,
  -5.51951453e-02f, 1.27918884e-01f, 1.25164479e-01f, -7.90608525e-02f, -6.68196529e-02f, -1.93248615e-01f, -1.96721335e-03f, 2.14350268e-01f, 8.07310566e-02f, 1.41939878e-01f,
  2.19220534e-01f, 4.26298752e-02f, 1.05638728e-01f, 1.72613300e-02f, -8.31439998e-03f, 1.38142154e-01f, 6.56765071e-04f, -1.92988455e-01f, 4.91330735e-02f, 2.60940157e-02f,
  -5.39723895e-02f, 3.98522019e-02f, 1.45188406e-01f, -1.54925272e-01f, -3.03542223e-02f, 8.47320855e-02f, -1.33676842e-01f, -3.57211418e-02f, 1.60425771e-02f, 1.46842480e-01f,
  5.52967936e-02f, -2.53041506e-01f, 2.03620084e-03f, 2.23590489e-02f, 1.14895046e-01f, 1.03194490e-01f, 1.06031433e-01f, 7.28372559e-02f, -6.00970909e-02f, -4.83991317e-02f,
  2.01435499e-02f, 4.62885061e-03f, 2.03430150e-02f, -2.02794492e-01f, 3.85413952e-02f, -3.72265764e-02f, 1.95470139e-01f, -3.08727890e-01f, -1.08472593e-01f, -1.43544869e-02f,
  -7.91134965e-03f, 2.82764733e-01f, 2.55729079e-01f, 1.34444565e-01f, 2.12132454e-01f, 2.04785883e-01f, -7.54639655e-02f, -2.67607402e-02f, 2.97655370e-02f, 9.31119025e-02f,
  3.29830474e-03f, -8.69842097e-02f, 1.46865221e-02f, 1.20880269e-01f, -5.41478992e-02f, 1.80222616e-01f, 7.96332862e-03f, -1.36703268e-01f, -1.87195614e-02f, 3.22222449e-02f,
  -1.69071951e-03f, -1.20985344e-01f, 6.60781711e-02f, -1.13013752e-01f, 2.89114080e-02f, 1.95583165e-01f, 2.26031542e-01f, 4.50321585e-02f, 1.21003941e-01f, 4.21179011e-02f,
  1.02986537e-01f, -6.23758435e-02f, 1.67650729e-01f, 1.86259523e-02f, 7.34112337e-02f, 2.06776485e-01f, -2.61225575e-03f, 1.93379596e-01f, 1.95093621e-02f, -5.35161830e-02f,
  1.41715989e-01f, -4.41358417e-01f, 4.93929163e-03f, -3.38283144e-02f, 3.44444439e-02f, 1.17229901e-01f, -6.73413500e-02f, -1.07767239e-01f, 1.01172827e-01f, -9.06184316e-03f,
  -9.01239440e-02f, 6.97362199e-02f, -1.55077279e-01f, -1.84386573e-03f, -1.11232270e-02f, 1.87396199e-01f, 1.01017006e-01f, 8.27677175e-02f, 1.97406158e-01f, 2.29632869e-01f,
  2.09265184e-02f, 3.57702017e-01f, 2.24300086e-01f, -6.96365982e-02f, 6.69159219e-02f, -4.18673716e-02f, -3.21980476e-01f, -1.87244788e-01f, 1.06009342e-01f, 1.71428267e-02f,
  8.28941390e-02f, 1.16204776e-01f, -8.29558745e-02f, 1.04493871e-02f, 4.58248854e-02f, 1.04896568e-01f, 2.74607297e-02f, 9.32002589e-02f, -2.57053435e-01f, 3.01206647e-03f,
  1.07471421e-01f, -1.15432218e-01f, 3.66493687e-02f, 9.22126397e-02f, 1.18400909e-01f, 6.96915984e-02f, -7.51856118e-02f, 2.11401984e-01f, 1.67319879e-01f, -6.80262148e-02f,
  -1.33000106e-01f, -1.08356155e-01f, 4.86185104e-02f, -1.58365920e-01f, -1.11815937e-01f, -3.40017676e-02f, 9.77934599e-02f, -2.51511838e-02f, -1.06227405e-01f, -2.16336921e-01f,
  -5.00793941e-02f, -1.21765375e-01f, -8.37419331e-02f, -1.21760152e-01f, -1.77334771e-01f, 4.10462841e-02f, -1.50216654e-01f, 1.15994602e-01f, 1.78854898e-01f, 1.66236311e-01f,
  -1.31378040e-01f, 1.02833331e-01f, 1.37647986e-01f, 3.10926288e-02f, 2.40349457e-01f, 8.06061327e-02f, 3.34729254e-02f, 2.20893528e-02f, -4.68882136e-02f, -1.05637059e-01f,
  -3.44997309e-02f, 7.37296268e-02f, 1.92681715e-01f, 2.03691930e-01f, 1.38026699e-01f, 1.21863917e-01f, 2.45828986e-01f, -2.20450573e-02f, -2.85126001e-01f, -3.78039591e-02f,
  -2.25011513e-01f, -1.19298421e-01f, -1.80414401e-03f, -6.92367032e-02f, 1.01199821e-01f, 2.52607614e-02f, -9.13148448e-02f, 1.47457466e-01f, -4.63773832e-02f, -2.33519953e-02f,
  1.41087964e-01f, 2.61246483e-03f, -3.99807721e-01f, -8.71513560e-02f, 2.07238749e-01f, -1.72018975e-01f, 4.60686162e-02f, 9.69207212e-02f, -8.28303695e-02f, 1.23085290e-01f,
  -2.84141116e-02f, 1.71542197e-01f, 1.67350620e-01f, -1.25613078e-01f, -3.89843047e-01f, 7.78386295e-02f, 4.50914428e-02f, -4.91427071e-02f, -1.34320900e-01f, -3.69067341e-02f,
  1.06941082e-01f, -1.03092089e-01f, 7.49338195e-02f, -2.61680752e-01f, 1.04838595e-01f, -8.01367089e-02f, -7.30153695e-02f, -1.40541658e-01f, -6.50402009e-02f, 3.00426424e-01f,
  -7.22796842e-02f, 6.75508976e-02f, 1.60484146e-02f, -1.29377857e-01f, -1.09525755e-01f, -7.15824068e-02f, 4.48039994e-02f, 1.60821036e-01f, 3.21601965e-02f, 2.49472126e-01f,
  1.81687027e-01f, 1.86192542e-01f, 1.77551305e-03f, 4.66530584e-02f, 5.23569994e-02f, 5.87739162e-02f, -5.85560091e-02f, 4.09546457e-02f, -4.59366962e-02f, -2.86752731e-01f,
  1.36465356e-01f, 4.34130952e-02f, 2.98170745e-02f, -7.18047544e-02f, 9.88320336e-02f, -1.47893000e-02f, -5.37562966e-02f, 1.50079802e-01f, 9.63764712e-02f, -8.10757205e-02f,
  7.99635574e-02f, -3.85266379e-04f, 1.99020386e-01f, 1.69613604e-02f, 7.51288906e-02f, 1.50069878e-01f, -1.27986493e-02f, -2.95116082e-02f, 6.43837973e-02f, -1.77499577e-01f,
  -3.28304321e-01f, -2.64404744e-01f, -2.85321504e-01f, 4.58601452e-02f, 1.25988752e-01f, 2.88814865e-02f, 3.62500809e-02f, -9.12794936e-03f, -7.46130049e-02f, 2.46528208e-01f,
  -7.91086331e-02f, 2.38930538e-01f, -6.53573051e-02f, -2.49154046e-01f, 1.11081168e-01f, 9.08800066e-02f, 2.29190528e-01f, 2.45927826e-01f, 1.13095216e-01f, 1.45410687e-01f,
  -1.49806991e-01f, 1.49312332e-01f, -3.66763510e-02f, -3.97019684e-01f, -6.25430271e-02f, 2.05264501e-02f, -7.86310583e-02f, -7.14377388e-02f, -3.79996672e-02f, -4.16090004e-02f,
  -1.61723018e-01f, -1.20772868e-01f, -2.37053335e-01f, 2.54135519e-01f, -2.04832405e-01f, 3.89128886e-02f, 1.28314599e-01f, -1.69212092e-02f, -1.39316022e-01f, -7.85989221e-03f,
  -8.24931562e-02f, 6.31893128e-02f, 2.95990752e-03f, -1.24054037e-01f, -1.69059545e-01f, -2.99844369e-02f, 1.30935689e-03f, 1.16429806e-01f, 2.45930012e-02f, 5.47547042e-01f,
  3.20207030e-02f, 2.41749734e-02f, -3.67369987e-02f, 1.75834112e-02f, 5.13916202e-02f, -1.98541015e-01f, 1.26506656e-01f, 4.69197370e-02f, -4.47067171e-02f, 9.41412076e-02f,
  1.29699454e-01f, 5.71915321e-02f, 1.69604585e-01f, -9.36461962e-04f, -1.52420402e-01f, -9.59361903e-03f, 1.17472544e-01f, -2.65686691e-01f, 1.42702848e-01f, -2.13429958e-01f,
  6.69981092e-02f, -8.47055912e-02f, 4.21366617e-02f, -9.46262181e-02f, 1.82952628e-01f, 1.91775978e-01f, 1.71831220e-01f, 1.15606133e-02f, 2.16745436e-01f, -9.01866183e-02f,
  -6.08503856e-02f, 3.46634805e-01f, 7.00912848e-02f, 2.01569833e-02f, 1.31890709e-02f, 1.89698562e-01f, -1.13964476e-01f, 3.24509777e-02f, 1.28698528e-01f, -1.11280099e-01f,
  9.37310904e-02f, -2.85902530e-01f, 6.29669428e-02f, -1.06314747e-02f, -1.77296624e-02f, -1.13156021e-01f, -4.27646607e-01f, -2.31473669e-01f, -7.28708804e-02f, 6.66700751e-02f,
  1.08301640e-01f, -1.95469111e-01f, 1.90061763e-01f, 2.46596023e-01f, 3.54948878e-01f, -3.23793963e-02f, 1.78065062e-01f, 1.65064394e-01f, -3.22112709e-01f, 7.93614909e-02f,
  3.38007331e-01f, -6.80099055e-02f, -3.12567279e-02f, 1.49798632e-01f, 1.20347723e-01f, -6.36002123e-02f, -2.40936086e-01f, -1.10271480e-02f, -1.65877745e-01f, -9.94197354e-02f,
  2.89972462e-02f, 2.15813100e-01f, 2.83990115e-01f, -2.68613850e-03f, 3.88689316e-03f, 1.74499601e-01f, 3.70855927e-01f, -6.04228020e-01f, -4.56673559e-04f, 1.44783422e-01f,
  1.49097228e-02f, 3.52214903e-01f, 6.81397552e-03f, 1.02889709e-01f, 2.54610389e-01f, -8.43537599e-02f, -2.99596414e-02f, -7.46927857e-02f, 3.50409716e-01f, -1.51012838e-01f,
  5.97622730e-02f, -2.46009752e-02f, 2.69150231e-02f, -8.74730870e-02f, 1.07889153e-01f, 1.21528320e-02f, -1.81017313e-02f, -7.16178194e-02f, 1.22525357e-01f, 1.17348984e-01f,
  3.55697796e-02f, 6.77749038e-01f, 1.74405836e-02f, -2.13303298e-01f, 5.20338677e-02f, -2.45132297e-01f, 9.04663093e-03f, 6.46789521e-02f, -4.28296700e-02f, -1.79054081e-01f,
  -1.08599909e-01f, -1.54821187e-01f, -8.37014467e-02f, -1.16770536e-01f, 1.09005747e-02f, -2.11299419e-01f, 4.05047163e-02f, 2.05409564e-02f, 1.31794512e-01f, 4.07418869e-02f,
  1.58359967e-02f, 4.90747057e-02f, 3.01095635e-01f, 2.99369961e-01f, -9.47959870e-02f, -2.40933802e-03f, -3.75215895e-02f, -1.32711634e-01f, 1.10792950e-01f, 1.93925187e-01f,
  1.15556180e-01f, -1.13491137e-02f, -1.11914515e-01f, 1.93970218e-01f, 2.67393351e-01f, 2.01724172e-01f, -5.10651581e-02f, 1.68695390e-01f, -1.09268509e-01f, 1.26416206e-01f,
  1.72826976e-01f, -1.22049555e-01f, -9.40570161e-02f, -4.72242795e-02f, -1.30216882e-01f, 9.13404897e-02f, 1.62467524e-01f, 8.07722807e-02f, 2.91356623e-01f, 1.38483578e-02f,
  -1.82539389e-01f, -9.86016169e-03f, 6.91086054e-02f, 1.06983699e-01f, -1.05065495e-01f, -6.61182329e-02f, 1.09812610e-01f, 1.78413972e-01f, -8.23249072e-02f, 1.49728253e-01f,
  -6.75263405e-02f, -6.20155735e-03f, 1.11797601e-01f, 6.19422421e-02f, -1.32528588e-01f, -1.95816770e-01f, -9.41847712e-02f, 2.21027538e-01f, 4.36758101e-02f, -1.41198710e-01f,
  1.54100537e-01f, 1.77810863e-01f, 1.33338720e-01f, 1.88648447e-01f, -1.01146018e-02f, 5.36538335e-03f, 1.47471890e-01f, -9.06959996e-02f, 2.01981574e-01f, 1.10954583e-01f,
  1.30597204e-01f, 2.63051957e-01f, 1.67369962e-01f, -1.38912886e-01f, 5.62016964e-02f, -3.80317159e-02f, 1.02323517e-01f, 1.54770717e-01f, 3.65307033e-01f, 3.08193445e-01f,
  1.69747904e-01f, 1.97372168e-01f, 1.52299136e-01f, -1.42166510e-01f, -3.27876300e-01f, -5.59551194e-02f, 4.67533171e-02f, -1.08678989e-01f, 7.84179792e-02f, 1.10714786e-01f,
  2.38885224e-01f, 3.83513942e-02f, 1.03122473e-01f, 1.52887806e-01f, 2.93460310e-01f, -1.94821566e-01f, 7.31095374e-02f, 2.63059497e-01f, 1.84960634e-01f, 2.25646645e-01f,
  1.55938461e-01f, -7.44068921e-02f, 5.41634709e-02f, -1.90340221e-01f, 9.68141854e-02f, -4.70880745e-03f, 3.33682686e-01f, 1.70804318e-02f, 6.87769800e-02f, 1.75919250e-01f,
  1.31202012e-01f, -3.46126147e-02f, -4.35209014e-02f, 1.71783179e-01f, 8.31899270e-02f, -1.52442649e-01f, -5.48476465e-02f, 1.21851943e-01f, 1.00850090e-01f, 6.18931293e-01f,
  2.63750345e-01f, -7.99297392e-02f, -2.03545075e-02f, -3.34377319e-01f, 9.19008777e-02f, 1.12071618e-01f, -2.63742834e-01f, 3.53440531e-02f, -9.66166928e-02f, -2.70426478e-02f,
  -1.58708483e-01f, 6.72607943e-02f, -6.10769130e-02f, 5.93913421e-02f, -4.92419638e-02f, 1.51273474e-01f, 1.00430109e-01f, 1.72908068e-01f, 7.16054291e-02f, 4.80768710e-01f,
  2.15943813e-01f, 1.98083483e-02f, 1.90592021e-01f, -3.45989138e-01f, -2.75599122e-01f, -2.71019012e-01f, 7.20140412e-02f, -1.44345000e-01f, 1.85897186e-01f, 1.90490112e-02f,
  1.23473145e-01f, -6.68387637e-02f, -1.44559279e-01f, 9.33086053e-02f, 2.47706428e-01f, 4.71248031e-02f, 7.67402574e-02f, 3.78838331e-02f, 1.85521141e-01f, 1.29867256e-01f,
  1.16211645e-01f, 1.72075972e-01f, -4.40709554e-02f, 1.21911913e-01f, -1.65587693e-01f, 6.28679991e-02f, 2.30527043e-01f, -1.68266192e-01f, -1.30693465e-01f, -3.81566808e-02f,
  -8.72874036e-02f, -4.78942925e-03f, -1.38851151e-01f, -2.39489991e-02f, 4.69651259e-02f, 1.74869657e-01f, -6.53092265e-02f, -1.45392954e-01f, 1.11918375e-02f, 1.01247849e-02f,
  1.29966602e-01f, -8.21124613e-02f, -1.62239388e-01f, 1.92228615e-01f, 1.72011942e-01f, 6.18522279e-02f, 1.80098504e-01f, -5.64757027e-02f, 1.03045024e-01f, -1.14525080e-01f,
  2.00557753e-01f, 4.60570082e-02f, 1.79153696e-01f, -3.47398780e-02f, 1.93323687e-01f, -7.19072595e-02f, 1.33557200e-01f, -2.25845482e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 52)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 52;
const float L2_fan_Bp_bar_data[] = {
  -1.03595048e-01f, 9.03855339e-02f, 2.22321779e-01f, 2.18171388e-01f, -6.91248700e-02f, -4.03010808e-02f, 1.27922252e-01f, 8.66442919e-02f, 1.38140842e-01f, 9.17701125e-02f,
  -4.31536660e-02f, -5.63203618e-02f, 1.76263019e-01f, 1.04136407e-01f, 4.06762883e-02f, 9.48584266e-03f, -1.48317814e-01f, 4.21805419e-02f, 1.07975967e-01f, 2.09802054e-02f,
  1.18851878e-01f, 1.07463531e-01f, -5.09605892e-02f, 1.01019917e-02f, 1.23996429e-01f, 2.65361574e-02f, 1.40409440e-01f, -8.68118107e-02f, 1.90742180e-01f, 5.84193654e-02f,
  3.33448388e-02f, 1.55775875e-01f, 2.71489054e-01f, 1.00862406e-01f, 8.51431191e-02f, 1.22570522e-01f, -7.74019286e-02f, -3.09791304e-02f, 2.09467083e-01f, -1.22474579e-04f,
  -1.04997188e-01f, 7.89657757e-02f, -1.30473137e-01f, 5.56862727e-02f, 2.33967051e-01f, 1.90625966e-01f, 1.01167798e-01f, -1.25483096e-01f, 3.96454334e-02f, -2.03816164e-02f,
  1.33270454e-02f, 1.36826217e-01f
};

// L3_fan_Wp (Shape: 6 x 64)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  3.93087743e-03f, -1.29645348e-01f, -8.54393914e-02f, -2.29642391e-02f, 6.10155426e-02f, 5.39484853e-03f, 1.07031792e-01f, -8.38069990e-02f, -4.15220261e-02f, 1.27049154e-02f,
  -5.47950482e-03f, 1.48295239e-01f, -5.54634146e-02f, 6.40453696e-02f, 7.87826851e-02f, -7.86736608e-02f, 5.68889454e-02f, -1.10548490e-03f, 5.31222969e-02f, 6.37327507e-02f,
  1.59752637e-01f, -1.93628892e-02f, -8.32761675e-02f, 4.74806204e-02f, 4.83430773e-02f, -4.29607145e-02f, 1.24285273e-01f, -7.45801777e-02f, -6.71805292e-02f, 8.37146267e-02f,
  2.41064634e-02f, 9.36175361e-02f, -5.39740957e-02f, -9.13481861e-02f, -3.47083136e-02f, -1.97247982e-01f, -4.32650559e-02f, 4.10543336e-03f, 1.14138626e-01f, -1.95482090e-01f,
  -2.01885432e-01f, -8.12803730e-02f, -6.22701570e-02f, 1.17238425e-02f, -8.55730549e-02f, 9.13415924e-02f, -3.74449492e-02f, -1.18704267e-01f, 1.17507398e-01f, -6.24160916e-02f,
  1.96273491e-01f, -8.45361128e-02f, 1.56323895e-01f, -1.41854614e-01f, 3.92637849e-02f, -3.85429375e-02f, 3.96908559e-02f, 3.62333581e-02f, 1.09334297e-01f, -1.15016215e-02f,
  -4.89735864e-02f, 5.48843406e-02f, -2.15407424e-02f, 4.45227027e-02f, 2.09309142e-02f, -1.41169101e-01f, 1.14904404e-01f, -5.88902719e-02f, 7.73476511e-02f, -1.71222985e-02f,
  2.58760899e-02f, 1.08620688e-01f, -7.63681084e-02f, 1.03020579e-01f, 4.96415459e-02f, 1.82062462e-01f, -8.99650753e-02f, 1.61954403e-01f, -3.75743695e-02f, -1.44319579e-01f,
  -1.87419385e-01f, -2.46024549e-01f, -6.58486038e-02f, -1.79536715e-01f, 1.82682976e-01f, -1.37254864e-01f, -9.91040915e-02f, 2.08856314e-02f, 3.71210985e-02f, 3.68552767e-02f,
  1.74683288e-01f, -1.44266456e-01f, -5.54838739e-02f, 1.49379438e-02f, 3.33811678e-02f, -1.10019147e-01f, -2.50474781e-01f, -1.15825400e-01f, -2.26034671e-02f, -9.75567997e-02f,
  -3.91711034e-02f, -2.03077327e-02f, 2.98126359e-02f, -9.33780614e-03f, 6.03052042e-02f, -2.03485355e-01f, -7.07718264e-03f, 1.71607822e-01f, 7.40873888e-02f, 8.70713517e-02f,
  -2.07998580e-03f, 6.12575077e-02f, -9.47650075e-02f, -2.37063810e-01f, -4.03733514e-02f, 1.32112816e-01f, -1.72381580e-01f, -1.47157654e-01f, -1.21625349e-01f, 2.14516409e-02f,
  -1.51780337e-01f, -4.78919446e-02f, -1.16816729e-01f, 3.16656902e-02f, -3.36837582e-02f, -1.36922792e-01f, 1.08801983e-01f, -6.94919527e-02f, 1.34176286e-02f, 3.90877351e-02f,
  6.44983575e-02f, 1.50929734e-01f, 8.64860415e-02f, 1.57623336e-01f, 5.06599955e-02f, 2.65689760e-01f, -1.86131552e-01f, 1.86004862e-02f, 9.11631510e-02f, 6.03340799e-03f,
  5.70179056e-03f, 1.10289983e-01f, -1.42011251e-02f, -1.12017877e-01f, -4.54480350e-02f, -1.24999031e-01f, -1.37152418e-01f, -1.33103535e-01f, -1.14304930e-01f, -1.29690930e-01f,
  -2.32570007e-01f, -2.58539617e-01f, 4.92650941e-02f, -4.08829339e-02f, -1.13569289e-01f, 1.96974769e-01f, -2.84863617e-02f, -6.98814839e-02f, -1.72569714e-02f, -6.01087660e-02f,
  -2.14106217e-01f, -2.74130106e-02f, -9.84898433e-02f, 4.24775332e-02f, -1.13959886e-01f, 1.95782557e-02f, -1.79879427e-01f, 1.12636320e-01f, -2.03865707e-01f, 1.19648017e-01f,
  5.09564485e-03f, 5.67037389e-02f, -1.35330647e-01f, -2.43319739e-02f, 1.32836685e-01f, -1.56202137e-01f, 1.34042069e-01f, -6.68827221e-02f, -5.05662486e-02f, -1.39693841e-01f,
  1.22580513e-01f, -1.73824042e-01f, -4.46131006e-02f, 2.72595417e-03f, 1.24996174e-02f, 4.69028875e-02f, 7.58804753e-02f, 1.27461702e-01f, -1.73805699e-01f, 3.22947763e-02f,
  3.09417415e-02f, -2.54013464e-02f, -1.32792756e-01f, -1.97552461e-02f, 1.90179795e-01f, 1.44599797e-03f, 1.49400234e-01f, -2.02434927e-01f, 9.76996794e-02f, -1.11694358e-01f,
  -2.29842156e-01f, 1.15747210e-02f, 6.10727677e-03f, -3.81496064e-02f, 1.17294295e-02f, -1.09106332e-01f, -5.95355779e-02f, -1.82583749e-01f, -5.08155338e-02f, 9.23607573e-02f,
  2.84219477e-02f, 1.18664831e-01f, 2.56114136e-02f, 1.10564850e-01f, -4.81944382e-02f, -9.89338942e-03f, -1.00856721e-01f, -2.31087893e-01f, 7.93157890e-03f, -7.49709383e-02f,
  -8.54995027e-02f, 1.28627390e-01f, 3.91993187e-02f, 2.46873740e-02f, 1.46643773e-01f, 3.38435918e-02f, -2.25804314e-01f, -1.95022479e-01f, 1.43137760e-02f, 5.08152023e-02f,
  1.10761039e-01f, -2.16989070e-01f, 3.95752229e-02f, -3.53715532e-02f, -3.22633050e-02f, 1.54565856e-01f, 9.32899192e-02f, -6.75361082e-02f, -9.72747952e-02f, -7.64245987e-02f,
  3.95449661e-02f, 3.41875255e-02f, -9.58083868e-02f, -1.69813961e-01f, 1.25182942e-01f, -1.55680189e-02f, -1.86318904e-02f, -4.47877720e-02f, -2.15779450e-02f, 2.48202235e-02f,
  8.48914124e-03f, -1.41184479e-01f, -1.05153166e-01f, -3.79337482e-02f, -2.16490865e-01f, -7.14473659e-03f, 5.79494759e-02f, -3.04913726e-02f, -1.71913147e-01f, 1.04923815e-01f,
  -1.62058398e-01f, -3.34642977e-02f, 4.00217436e-03f, -1.75615102e-01f, 3.75812389e-02f, -9.84259471e-02f, -7.85419717e-02f, -3.12738679e-03f, -1.04323685e-01f, -1.86437011e-01f,
  -3.89020555e-02f, 1.04952961e-01f, 6.41600490e-02f, -6.46037832e-02f, 8.74508470e-02f, -9.71674994e-02f, 3.51755396e-02f, -1.62433684e-01f, -5.91785014e-02f, -1.63877130e-01f,
  -8.86606276e-02f, 1.53524458e-01f, -7.93510824e-02f, 5.05295396e-02f, 6.18277006e-02f, -1.62637070e-01f, -1.85212895e-01f, -6.26704991e-02f, 4.03017662e-02f, -6.86841682e-02f,
  1.36426479e-01f, -9.63123441e-02f, 6.34412169e-02f, -2.34183595e-01f, -7.33949915e-02f, -1.21674620e-01f, 1.38165101e-01f, -1.80990651e-01f, -2.04928428e-01f, -2.48137444e-01f,
  -4.42908928e-02f, -4.07368094e-02f, -1.50884474e-02f, 1.17623448e-01f, -5.28326444e-02f, -8.08405429e-02f, 2.45203488e-02f, 4.08184119e-02f, -1.44580141e-01f, 2.03203093e-02f,
  -1.34807825e-01f, -2.05401719e-01f, -9.93831307e-02f, -3.97450440e-02f, -7.79143646e-02f, -7.24232197e-03f, 1.83443993e-01f, -1.22657150e-01f, 6.67511523e-02f, 1.23894960e-01f,
  9.64779779e-02f, 1.01456173e-01f, 1.59500182e-01f, 2.90454552e-02f, -5.51460125e-02f, 1.08215928e-01f, -9.87601951e-02f, 4.77385260e-02f, 1.58264711e-01f, 1.74022421e-01f,
  -2.00367287e-01f, -1.06360413e-01f, 7.23177642e-02f, -7.30099678e-02f, 6.46671057e-02f, 1.61430553e-01f, -5.54008037e-02f, -8.76254961e-02f, 1.88916437e-02f, 1.33800864e-01f,
  1.08958527e-01f, -4.77007031e-02f, -6.92187324e-02f, -6.73774928e-02f, 5.93507811e-02f, 4.20808531e-02f, -1.05825759e-01f, -1.52648734e-02f, 2.35091206e-02f, -1.33464336e-01f,
  -7.12343380e-02f, 7.81671256e-02f, 3.38942036e-02f, -5.32858707e-02f, 3.57906111e-02f, -1.15335465e-03f, 2.50755399e-01f, 7.51804113e-02f, 4.84571308e-02f, 2.71606684e-01f,
  1.45429552e-01f, 5.27681522e-02f, -9.06316489e-02f, 5.46940453e-02f, 4.93066646e-02f, -1.83536366e-01f, -1.48386195e-01f, 3.26548927e-02f, -1.60133615e-01f, 6.32256921e-03f,
  -8.85948911e-02f, 1.26146853e-01f, 6.41605929e-02f, 1.43063784e-01f, -1.14595359e-02f, 9.35671106e-03f, 1.72940325e-02f, -1.31391793e-01f, -5.65627031e-02f, 1.09032974e-01f,
  1.23134151e-01f, -1.08173214e-01f, 1.01770617e-01f, 4.59888652e-02f
};

// L3_fan_Wp_bar (Shape: 52 x 64)
const int L3_fan_Wp_bar_rows = 52;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  1.47733942e-01f, -3.49470079e-02f, 1.04107983e-01f, 1.12040713e-01f, 4.80213352e-02f, 1.67645380e-01f, 1.84911400e-01f, 2.50415429e-02f, -1.11918405e-01f, -7.31310323e-02f,
  1.59151688e-01f, 1.91439374e-03f, -1.81024130e-02f, 2.11029768e-01f, 1.41134888e-01f, -3.21596116e-03f, -1.89578488e-01f, -2.36722171e-01f, -1.91579923e-01f, -4.70458791e-02f,
  1.06779791e-01f, 2.68308014e-01f, -7.44167566e-02f, -6.72583133e-02f, 4.93871719e-02f, -1.77737847e-01f, 2.84271032e-01f, -2.73227364e-01f, -1.00517338e-02f, 2.95723528e-01f,
  6.57915547e-02f, 1.38513848e-01f, -3.86838347e-01f, 1.07766464e-01f, -1.54644132e-01f, -6.57421583e-03f, -3.95197980e-02f, -5.19227944e-02f, -5.08167930e-02f, -1.59570977e-01f,
  3.27278711e-02f, -1.09344870e-02f, 1.03270091e-01f, 3.84846389e-01f, 2.03981236e-01f, 2.28542447e-01f, -1.29213795e-01f, 1.07613221e-01f, 1.59722511e-02f, -7.53613710e-02f,
  2.93628842e-01f, -2.26733118e-01f, 2.22994283e-01f, -2.52749681e-01f, -3.47326130e-01f, -1.24928661e-01f, -1.21001087e-01f, 9.75878909e-02f, 2.07868531e-01f, -5.66140339e-02f,
  1.30896315e-01f, 7.20132217e-02f, -8.36836994e-02f, 8.06585699e-02f, 2.12305307e-01f, 5.37940599e-02f, 2.27600150e-02f, 1.17264852e-01f, 3.20030376e-02f, 7.49013498e-02f,
  -1.50585294e-01f, -6.85714558e-02f, 1.38327047e-01f, -7.14218691e-02f, 3.15823555e-01f, 1.74282402e-01f, 2.99446136e-02f, -1.66550145e-01f, -1.99778438e-01f, 1.03144206e-01f,
  -1.37916794e-02f, 1.44254668e-02f, 1.88112572e-01f, 8.52126703e-02f, -9.07991901e-02f, -9.90556404e-02f, 1.50541052e-01f, 1.08351082e-01f, 7.86297098e-02f, 9.69914347e-02f,
  -1.97713450e-01f, -6.55976236e-02f, 2.07210844e-03f, 8.37447792e-02f, -5.48700020e-02f, -6.84343427e-02f, 4.05011401e-02f, -1.11101687e-01f, 2.35779628e-01f, 1.16908200e-01f,
  5.47263511e-02f, -9.42410454e-02f, -1.07047051e-01f, -9.91536453e-02f, 1.31881861e-02f, -1.56901866e-01f, 5.67250848e-02f, -1.38443694e-01f, 1.86439920e-02f, 2.60554198e-02f,
  -7.09744468e-02f, 2.97134608e-01f, -5.77952191e-02f, 1.46526560e-01f, -2.20104884e-02f, -1.21675275e-01f, -6.64784312e-02f, -1.28885452e-02f, -2.87119094e-02f, -1.03583604e-01f,
  2.63638049e-02f, 1.10402793e-01f, -3.06812912e-01f, 4.80155796e-02f, 4.13966537e-01f, -1.02149718e-01f, 1.75958410e-01f, 9.92583930e-02f, 2.76651442e-01f, -9.19036567e-03f,
  1.09495156e-01f, 5.12612015e-02f, -5.60278632e-02f, -5.22057433e-03f, -4.17325087e-02f, -3.44849885e-01f, 1.84268191e-01f, 1.05554491e-01f, 1.10786088e-01f, 3.44268046e-02f,
  -8.10907930e-02f, 1.13818534e-01f, -3.44726592e-01f, 8.38613510e-02f, -2.48706341e-01f, -2.23566473e-01f, 7.70506188e-02f, -3.09804976e-01f, -4.08573449e-02f, -2.39178255e-01f,
  -6.68281093e-02f, -1.60959810e-01f, 1.42355621e-01f, -5.98573349e-02f, -7.72699639e-02f, -2.23380521e-01f, -1.20004952e-01f, 3.46251503e-02f, -2.89654732e-02f, 1.87539995e-01f,
  -1.25382617e-01f, 1.08349688e-01f, 3.47811431e-02f, 4.36041653e-02f, -2.18868211e-01f, 3.39262448e-02f, -5.69465989e-03f, 1.35352858e-03f, 3.32030207e-02f, -2.69680083e-01f,
  -7.30614439e-02f, 3.92539173e-01f, 2.00057015e-01f, 1.56054884e-01f, -1.32310554e-01f, 1.98910564e-01f, -3.68285388e-01f, -3.62230599e-01f, 2.22985089e-01f, -1.35825396e-01f,
  -1.02300651e-01f, 4.36603054e-02f, -1.48582026e-01f, -2.56903082e-01f, -2.35007748e-01f, -3.05202812e-01f, 9.37500149e-02f, 9.67362598e-02f, 2.05154702e-01f, -3.31679247e-02f,
  1.64226159e-01f, -2.12705266e-02f, 1.09725185e-01f, 9.16161686e-02f, 1.36769369e-01f, 1.18712448e-01f, 2.30179921e-01f, 2.67735004e-01f, 3.60462591e-02f, 2.74712592e-01f,
  -4.70817462e-02f, 4.60937843e-02f, -3.46578658e-02f, 5.36108017e-02f, -9.68448073e-02f, 3.51958461e-02f, 3.81429940e-01f, -2.21849326e-02f, 1.29107982e-01f, -7.12389648e-02f,
  5.80155924e-02f, -5.31605929e-02f, -1.11679278e-01f, 2.68763393e-01f, -5.40272482e-02f, 3.98265803e-03f, 2.08551213e-01f, -1.28182322e-01f, 1.33353606e-01f, -1.14795364e-01f,
  1.96664423e-01f, 2.47300178e-01f, -5.83546422e-02f, -2.74205029e-01f, -1.55247301e-02f, -1.16514070e-02f, -9.01674852e-02f, -1.39914513e-01f, 1.12236470e-01f, -2.54243109e-02f,
  2.20439747e-01f, -2.69589704e-02f, 4.18850891e-02f, -1.84852853e-01f, 1.76233515e-01f, 7.49382079e-02f, 1.33479208e-01f, -2.16883421e-01f, -5.84877580e-02f, -1.96422681e-01f,
  2.45248973e-01f, 1.79280624e-01f, 1.74385443e-01f, -2.03315869e-01f, -1.40895769e-02f, -7.98950195e-02f, -1.91636175e-01f, -2.28136092e-01f, 1.73711672e-01f, 8.64548981e-02f,
  -1.17890351e-01f, -2.46861562e-01f, -3.60968024e-01f, 7.68231302e-02f, -4.24540758e-01f, 1.24136508e-01f, 7.53351524e-02f, 2.80929208e-01f, -2.47272834e-01f, 1.50244847e-01f,
  -2.29373604e-01f, -2.06142634e-01f, 2.41643757e-01f, 1.43608838e-01f, 1.67935655e-01f, -1.04356430e-01f, -5.42293228e-02f, 2.29528502e-01f, -3.15689892e-02f, 4.64934520e-02f,
  -1.29391104e-01f, 1.34324118e-01f, -7.83072710e-02f, -2.54537493e-01f, -1.45406947e-01f, -1.97799653e-01f, -1.60374388e-01f, 1.77744366e-02f, 4.55945842e-02f, -4.03539883e-03f,
  2.07106292e-01f, -1.03774197e-01f, -1.58209633e-02f, 4.39906232e-02f, 1.56565413e-01f, 1.33227184e-01f, 2.12793171e-01f, -1.43820018e-01f, -1.60076231e-01f, 2.36095473e-01f,
  1.96488366e-01f, 2.33393133e-01f, 5.55480309e-02f, 1.23280315e-02f, 2.37913076e-02f, 1.41032606e-01f, -8.16414431e-02f, 1.51843622e-01f, -6.31273165e-02f, -2.09496114e-02f,
  -1.07321344e-01f, -2.13241994e-01f, 1.00835040e-01f, -1.61276489e-01f, 1.40352219e-01f, 1.06332116e-01f, -2.31442899e-01f, -8.52544755e-02f, 3.49797048e-02f, -6.39540479e-02f,
  4.71723750e-02f, -3.22671570e-02f, 3.53542045e-02f, 1.69132754e-01f, -6.74373880e-02f, -2.14386940e-01f, 1.50566474e-01f, 1.03594959e-01f, -1.21866234e-01f, 3.86416190e-03f,
  1.84550256e-01f, 1.42106280e-01f, 1.02668758e-02f, 9.71873626e-02f, 1.06031798e-01f, 3.62836361e-01f, -1.59319416e-01f, 2.39188686e-01f, -2.66678244e-01f, 4.98453714e-02f,
  -2.19018728e-01f, -7.70642683e-02f, 4.36891355e-02f, -2.85092485e-03f, 3.49957526e-01f, 1.28152430e-01f, 2.12187245e-01f, 3.30331475e-02f, 5.43421283e-02f, 9.71446652e-03f,
  -1.14129789e-01f, -2.60682236e-02f, 5.60560599e-02f, -2.93771885e-02f, 1.60792410e-01f, -2.58147018e-03f, 2.97475606e-02f, -1.06341004e-01f, 1.70641154e-01f, -5.40130846e-02f,
  6.98589385e-02f, -2.63501912e-01f, -3.40465531e-02f, 1.96498662e-01f, -4.73464839e-02f, 1.41380921e-01f, 6.01304173e-02f, 9.23336893e-02f, 9.82323587e-02f, -4.16652597e-02f,
  -8.93396977e-03f, -1.27545610e-01f, 1.28778592e-01f, -1.60095662e-01f, 2.09646404e-01f, -2.76100188e-01f, 1.86786562e-01f, -3.24077278e-01f, 1.67702749e-01f, 7.25057069e-03f,
  -7.84028023e-02f, -1.39309362e-01f, -1.53454170e-01f, -5.77171370e-02f, -1.60898939e-01f, -2.80241996e-01f, 2.14626133e-01f, 1.36669964e-01f, -2.40637243e-01f, -1.74160168e-01f,
  -3.10922951e-01f, 1.69068158e-01f, -3.10414195e-01f, 2.16925815e-01f, 8.88981372e-02f, -2.45865017e-01f, 8.53109211e-02f, -7.46573582e-02f, -1.13137566e-01f, 1.38254121e-01f,
  -2.96242058e-01f, 2.61479095e-02f, 1.80408448e-01f, 1.62289783e-01f, -2.12872833e-01f, -1.04752682e-01f, -1.83375925e-03f, -1.73919290e-01f, 1.04640335e-01f, -6.25793636e-02f,
  6.30506128e-02f, 2.30610818e-02f, 1.14503913e-01f, -2.97393687e-02f, 3.04001663e-02f, 3.61586846e-02f, 1.99145004e-01f, -3.81644219e-02f, -1.52370393e-01f, 2.12254152e-01f,
  4.49985377e-02f, 1.97481975e-01f, -6.41549751e-02f, 8.18241164e-02f, -5.12794852e-02f, 8.37635547e-02f, 4.95191589e-02f, -2.05657303e-01f, -1.19899362e-01f, 6.86553959e-03f,
  -3.76660116e-02f, -2.10135076e-02f, 1.00768782e-01f, -3.39617170e-02f, 2.03725040e-01f, -3.13395597e-02f, 1.30551934e-01f, -5.04019409e-02f, 5.43487677e-03f, 2.63854843e-02f,
  -3.23443487e-02f, 2.77622659e-02f, -9.36414301e-02f, 1.82239469e-02f, -7.08290786e-02f, 2.52919167e-01f, -1.11389451e-01f, 2.49094829e-01f, 1.14984281e-01f, -2.13978346e-02f,
  5.93572780e-02f, 1.17901087e-01f, -1.09996848e-01f, 1.29896373e-01f, -5.93427196e-02f, -9.42444727e-02f, 1.38588533e-01f, 8.76236632e-02f, 1.81931838e-01f, 2.04846308e-01f,
  1.15400471e-01f, -3.36315408e-02f, 2.75634408e-01f, 3.05458233e-02f, -3.47410329e-02f, -1.50809763e-02f, -7.30234161e-02f, 1.26508936e-01f, -4.31118682e-02f, 2.79063173e-03f,
  -9.42167640e-02f, 4.17063497e-02f, 2.52971023e-01f, 4.78257202e-02f, -1.08110577e-01f, -1.61680415e-01f, 3.46257798e-02f, -2.35175952e-01f, -5.48723266e-02f, 2.96962336e-02f,
  -3.25753056e-02f, 1.17246052e-02f, 1.28277376e-01f, -1.49070919e-01f, 1.70224562e-01f, -1.24240801e-01f, -3.04810386e-02f, 1.86837614e-01f, -3.66355060e-03f, -1.68406844e-01f,
  -2.71733969e-01f, 1.12488061e-01f, 3.97004113e-02f, 6.38856664e-02f, 4.25349437e-02f, -1.12556010e-01f, 3.42917472e-01f, -1.15297921e-01f, 7.72637427e-02f, -2.81994849e-01f,
  3.84838805e-02f, -7.81454220e-02f, 1.74297601e-01f, -2.11486429e-01f, -7.88379312e-02f, -1.82887390e-01f, 6.26278967e-02f, 6.30032911e-04f, 8.24406445e-02f, -2.19267547e-01f,
  5.70459105e-02f, -1.25337290e-02f, 7.90372938e-02f, -1.93014205e-01f, 1.27389193e-01f, 2.33537942e-01f, -2.96047479e-01f, -2.41905913e-01f, 1.84989676e-01f, 1.55019447e-01f,
  1.18202053e-01f, 1.57661214e-01f, 1.39715020e-02f, -1.62955821e-02f, 3.48958410e-02f, 7.32568800e-02f, -2.56740928e-01f, 1.52045012e-01f, -2.65767425e-01f, 5.95244877e-02f,
  2.23341748e-01f, 6.37470111e-02f, -3.61561663e-02f, 2.45689787e-03f, 1.21794403e-01f, -3.23491752e-01f, -6.02145158e-02f, -7.20352978e-02f, 1.67993382e-01f, 5.52293472e-02f,
  1.32400602e-01f, -2.76148468e-02f, -1.85594276e-01f, 1.36224339e-02f, 8.13544765e-02f, 1.44933537e-01f, 8.56726780e-04f, 1.71806380e-01f, -2.24935770e-01f, 2.48206198e-01f,
  -9.39629674e-02f, -2.26627961e-02f, 6.31967708e-02f, -1.90111682e-01f, 1.05216965e-01f, -1.78209096e-01f, -6.91274777e-02f, -5.06917983e-02f, -3.31615619e-02f, 6.93763494e-02f,
  -2.41123457e-02f, 9.02667716e-02f, -7.91328251e-02f, -7.57858455e-02f, 1.13326102e-01f, -8.48888978e-02f, -5.00185341e-02f, -1.18218981e-01f, -1.45777106e-01f, -1.77676529e-01f,
  -1.31268268e-02f, 2.04769731e-01f, 2.61804968e-01f, -1.34673744e-01f, 7.05825537e-02f, 6.83335587e-02f, 1.58995569e-01f, 6.53215572e-02f, 1.55660003e-01f, 1.64064050e-01f,
  -4.96573448e-02f, 3.97900753e-02f, -2.58872844e-02f, 1.50109962e-01f, 1.20517172e-01f, 1.05469704e-01f, -1.79007743e-02f, -1.06112622e-01f, 2.45481357e-01f, -5.15337056e-03f,
  1.47243977e-01f, 8.67632776e-02f, -3.47403158e-03f, -2.03203365e-01f, -1.28776640e-01f, 1.43218517e-01f, 8.20727572e-02f, -1.48304656e-01f, -1.39362976e-01f, 1.63369358e-01f,
  5.50612770e-02f, 1.86434701e-01f, -1.32462725e-01f, -2.70341814e-01f, -5.89657463e-02f, -1.73627302e-01f, -2.74067037e-02f, 7.21007437e-02f, -6.71490580e-02f, -8.59198719e-02f,
  5.23916504e-04f, 1.49932802e-02f, 1.96425125e-01f, -2.87938006e-02f, -6.09913208e-02f, -1.08494731e-02f, -1.57769486e-01f, 1.64682254e-01f, 2.72157621e-02f, 2.22367272e-01f,
  -1.19666293e-01f, 8.03148076e-02f, -1.15802184e-01f, 1.31127611e-01f, -8.60687941e-02f, -2.17868403e-01f, 1.93294048e-01f, -2.04317585e-01f, 2.84056608e-02f, 2.49574542e-01f,
  1.79794371e-01f, 2.32331350e-01f, -5.24750315e-02f, -7.31427968e-02f, -3.15702707e-02f, -6.15425073e-02f, 1.05346411e-01f, 5.86373219e-03f, -1.92348257e-01f, -1.01622986e-02f,
  -2.13064119e-01f, -1.27840802e-01f, -1.24267070e-02f, 4.94024716e-02f, -2.28486117e-02f, -1.10478312e-01f, 5.65385632e-02f, -1.09057225e-01f, -1.50609195e-01f, 2.40375772e-02f,
  -7.91083649e-02f, -6.31677546e-03f, 1.01604052e-02f, 8.22084248e-02f, -2.37833083e-01f, 1.07904620e-01f, -1.24026109e-02f, 4.59255539e-02f, -3.94769572e-02f, 8.44571441e-02f,
  1.58409163e-01f, -3.07134986e-02f, -1.00215869e-02f, -3.07083637e-01f, 1.15182415e-01f, 6.59205317e-02f, 1.54388592e-01f, 1.44460723e-01f, 1.43215090e-01f, -8.36083200e-03f,
  3.90795013e-03f, 1.14578128e-01f, 3.84458601e-02f, -7.20512448e-03f, -1.80680364e-01f, 2.95555163e-02f, 9.62450951e-02f, -4.80577014e-02f, 1.61003773e-04f, 2.45507564e-02f,
  -6.94406256e-02f, -2.03843549e-01f, 2.58469433e-01f, -1.55449823e-01f, -1.97876900e-01f, -1.11400262e-01f, 2.91743539e-02f, -3.02910190e-02f, -4.67318110e-02f, -1.61451027e-01f,
  -3.10472380e-02f, -4.16428316e-03f, -3.01290825e-02f, -1.71147734e-01f, 1.87714934e-01f, -7.98015818e-02f, 1.45072579e-01f, -8.40004906e-02f, 6.73882663e-02f, 1.99092403e-01f,
  6.23572618e-02f, 1.24425158e-01f, -5.65676615e-02f, 5.87489046e-02f, -2.70586312e-02f, -6.88027963e-02f, 6.15614839e-02f, -9.28507186e-03f, -1.10096283e-01f, -1.16397381e-01f,
  -3.17650408e-01f, -6.71654716e-02f, -1.79830685e-01f, 1.92251086e-01f, 7.63163995e-03f, 1.56765774e-01f, 3.18266183e-01f, -7.47307530e-03f, 7.42995888e-02f, 7.18268156e-02f,
  -1.08316481e-01f, -2.11730331e-01f, -1.74576044e-01f, 1.26047760e-01f, 4.83954474e-02f, -7.08166063e-02f, -4.96162772e-02f, 1.52369127e-01f, 3.46071757e-02f, -3.87402773e-02f,
  -2.40532219e-01f, -1.24538556e-01f, 2.65325755e-01f, 6.15239777e-02f, 1.76329553e-01f, 1.74589291e-01f, -7.20118582e-02f, -3.98809165e-02f, 1.12473488e-01f, 6.84906309e-03f,
  1.37703866e-01f, -1.07042022e-01f, 4.35593091e-02f, 7.78442845e-02f, -2.31104389e-01f, 1.57125905e-01f, 2.26237066e-02f, 9.48039368e-02f, 7.43153021e-02f, 2.87657194e-02f,
  1.03325933e-01f, 1.04429707e-01f, -9.92746577e-02f, 1.08163707e-01f, 2.28125572e-01f, -2.33600318e-01f, 1.34942695e-01f, 1.86398521e-01f, 5.51329367e-02f, 6.06181333e-03f,
  -3.42578744e-03f, 2.41452023e-01f, -3.30348536e-02f, -1.26083180e-01f, -8.36675838e-02f, 1.77699074e-01f, -2.00887963e-01f, 1.69845328e-01f, -1.56063691e-01f, 1.29987061e-01f,
  -6.13553077e-03f, -2.13672563e-01f, 3.33142001e-03f, -9.23282746e-03f, 7.51627907e-02f, -1.69993250e-03f, 9.98810008e-02f, 8.81010517e-02f, -2.02054624e-03f, 1.27353027e-01f,
  1.25459820e-01f, -1.63712323e-01f, 9.90367308e-02f, -8.72904211e-02f, -1.70742631e-01f, 1.93847786e-03f, 1.73540786e-02f, -1.83152214e-01f, -2.02234626e-01f, -1.94897935e-01f,
  7.06783533e-02f, 1.30820543e-01f, 3.99755925e-01f, -2.77194411e-01f, 1.32647440e-01f, 2.52872054e-02f, 9.32247937e-02f, 1.22117840e-01f, 1.85575351e-01f, 1.15075663e-01f,
  5.88892438e-02f, -5.86269423e-03f, 1.70030981e-01f, 1.00697152e-01f, 1.76007673e-01f, -8.44208226e-02f, 5.67076430e-02f, -7.78949186e-02f, -5.08549027e-02f, 6.35203868e-02f,
  6.40411898e-02f, 5.18659651e-02f, -3.20450850e-02f, 6.71594068e-02f, 1.79302588e-01f, 6.95893764e-02f, 9.39388350e-02f, -1.43878236e-01f, 4.66976091e-02f, -2.36583516e-01f,
  1.32673785e-01f, -7.27616251e-02f, 2.95601804e-02f, 1.85580373e-01f, 1.07583292e-01f, -1.65246595e-02f, -3.76746170e-02f, 1.09720431e-01f, 1.90089107e-01f, 9.56295282e-02f,
  -1.62145108e-01f, -6.94788247e-02f, -1.27064615e-01f, -2.20154282e-02f, 6.52724281e-02f, -1.21630929e-01f, -3.27255391e-02f, -6.80535883e-02f, -9.64931324e-02f, 1.03329800e-01f,
  -1.16390951e-01f, -7.89473951e-02f, 1.01918019e-01f, 1.60717085e-01f, -3.94528992e-02f, 2.35536784e-01f, 1.61465749e-01f, 6.33796230e-02f, 8.37455392e-02f, 1.50589675e-01f,
  -5.17659247e-01f, -6.00345507e-02f, -2.77974810e-02f, -2.66515672e-01f, 3.99606712e-02f, 9.40540358e-02f, 2.47310743e-01f, -2.32685078e-02f, 4.48967218e-02f, 6.48819059e-02f,
  1.53337717e-01f, 3.53176333e-02f, 6.69052228e-02f, 1.98141441e-01f, -6.50442243e-02f, 7.69878039e-03f, 6.60507455e-02f, 1.67056650e-01f, -1.32491777e-03f, 8.15201402e-02f,
  -8.47244449e-03f, -1.54602483e-01f, 1.65833071e-01f, 2.88478673e-01f, 7.00298324e-02f, 1.25764757e-01f, -1.03855282e-02f, 2.44614989e-01f, 2.23571405e-01f, 3.39202248e-02f,
  1.33833766e-01f, -8.49236548e-02f, 7.22396821e-02f, -4.16205749e-02f, 5.94644397e-02f, -1.36348858e-01f, -8.84576440e-02f, 1.00819562e-02f, 2.01489821e-01f, 2.26736426e-01f,
  -8.52437764e-02f, -1.18340321e-01f, -1.56706735e-01f, 1.35979518e-01f, -7.96247944e-02f, 1.17617853e-01f, -1.23818688e-01f, 1.47207424e-01f, -1.59791544e-01f, -2.18951344e-01f,
  1.21167332e-01f, 2.58302480e-01f, -1.00644551e-01f, 1.59266457e-01f, 1.18680432e-01f, -7.87161961e-02f, -8.65249932e-02f, 1.61999345e-01f, -1.16740651e-01f, 1.47778481e-01f,
  -6.47131801e-02f, 7.03023095e-03f, 1.42622679e-01f, 1.46925390e-01f, 2.47691665e-02f, -1.47866290e-02f, -7.93728754e-02f, 2.72022374e-02f, -5.84633574e-02f, 3.13836455e-01f,
  1.03527591e-01f, -7.52599910e-02f, 3.93571258e-02f, -1.82270944e-01f, -8.96603391e-02f, 3.96889634e-02f, 5.27209882e-03f, -8.88257399e-02f, 1.24198906e-01f, -1.21221887e-02f,
  2.30098039e-01f, -4.35160212e-02f, -7.20365271e-02f, -1.25951990e-01f, 1.59186721e-01f, 1.20560132e-01f, 3.00373256e-01f, -2.09826037e-01f, -1.43861860e-01f, 1.34289056e-01f,
  7.77506828e-02f, 3.13971460e-01f, 5.05705439e-02f, 1.87974647e-01f, -8.42688829e-02f, 1.57487273e-01f, 5.15119433e-02f, 1.31295426e-02f, -8.69033486e-02f, 2.41017435e-02f,
  -1.20369375e-01f, -1.87765136e-01f, 3.71731609e-01f, -1.71708196e-01f, 8.54271576e-02f, -3.11834961e-02f, -2.60568827e-01f, -5.07705957e-02f, 1.04593888e-01f, 6.95443600e-02f,
  3.42842452e-02f, -6.09873235e-02f, -9.99981421e-04f, 1.27385303e-01f, -1.05679072e-01f, 4.27087164e-03f, -1.44726813e-01f, 1.14755295e-01f, 3.34012858e-03f, -3.63745145e-03f,
  -3.15290801e-02f, -2.42511749e-01f, -4.81294915e-02f, 3.29209268e-02f, 3.46605256e-02f, 5.84127307e-02f, 2.51225919e-01f, 6.76695406e-02f, -2.32628807e-01f, -1.24458976e-01f,
  1.32975474e-01f, 1.88270554e-01f, 1.68533325e-01f, -7.71267340e-03f, -1.91370979e-01f, -1.23989237e-02f, -1.23548135e-01f, 2.58685052e-01f, 1.44532733e-02f, 1.48684755e-01f,
  2.09871307e-01f, 1.54750854e-01f, 6.94585592e-02f, 4.69632000e-02f, -1.03145629e-01f, -1.58548504e-02f, 1.55444801e-01f, 1.73387051e-01f, 1.59218565e-01f, 1.48790941e-01f,
  9.23063308e-02f, -7.83944502e-02f, 1.95611119e-01f, 1.07959859e-01f, -1.23561665e-01f, -5.31327054e-02f, -1.17982671e-01f, 1.82746038e-01f, 1.26559898e-01f, 1.97728112e-01f,
  7.16565475e-02f, 2.93799907e-01f, -2.51638684e-02f, -2.34204605e-02f, 1.94459110e-01f, 9.11935940e-02f, 2.30960011e-01f, -2.12737024e-02f, -1.04065500e-02f, -5.47592863e-02f,
  9.44410451e-03f, 8.72514322e-02f, 1.93213709e-02f, -1.24562858e-02f, 1.53813139e-01f, 1.87109545e-01f, -6.68136105e-02f, -5.07655293e-02f, 1.63080394e-01f, 6.20171390e-02f,
  -3.61469150e-01f, -1.05699211e-01f, -1.05350688e-02f, -1.58710256e-01f, 9.99590755e-02f, -7.39353299e-02f, -3.59135658e-01f, 2.54924059e-01f, -8.91106576e-02f, 1.09466381e-01f,
  3.24106008e-01f, -2.73438469e-02f, -2.66142786e-01f, 1.60349637e-01f, 4.23114806e-01f, 1.96706831e-01f, 2.07484867e-02f, -2.74060145e-02f, -4.16762829e-01f, 2.51175072e-02f,
  2.50185013e-01f, -2.61677086e-01f, -2.21247941e-01f, -1.94621503e-01f, 1.74570173e-01f, -4.01064038e-01f, -1.95486292e-01f, 2.07956936e-02f, -1.86701685e-01f, 6.90569058e-02f,
  1.94997609e-01f, 2.42159769e-01f, -1.47355244e-01f, -1.90001383e-01f, 2.70308912e-01f, 1.01238757e-01f, -2.09517360e-01f, -8.99044648e-02f, 1.71936914e-01f, 2.10788682e-01f,
  -1.52169377e-01f, 1.53453350e-01f, -3.29364359e-01f, 1.41573384e-01f, 1.15366258e-01f, 3.25467408e-01f, -2.48512790e-01f, -1.58667490e-01f, 4.28934135e-02f, 1.07383221e-01f,
  3.18564802e-01f, -3.13132838e-03f, 8.02543201e-03f, -2.18738914e-01f, 3.29130217e-02f, -7.35452026e-02f, 1.00166373e-01f, 1.21889159e-01f, 6.03065677e-02f, 6.76965192e-02f,
  1.01911008e-01f, -2.65241247e-02f, 1.47234090e-02f, 8.96757022e-02f, -2.59165317e-02f, -6.02163281e-03f, -3.52634564e-02f, -1.21896289e-01f, -5.36657833e-02f, 1.77719563e-01f,
  -2.05808952e-01f, 1.16007939e-01f, -2.87405461e-01f, -2.28450105e-01f, 1.21525325e-01f, 5.57540320e-02f, -8.74195099e-02f, -1.23776719e-01f, 1.21514671e-01f, -1.48272719e-02f,
  3.51266265e-02f, -6.41061664e-02f, -2.60243025e-02f, 1.38014376e-01f, 9.12240148e-02f, -1.47423282e-01f, 1.43725485e-01f, 2.05261216e-01f, 5.09878919e-02f, -5.81572717e-03f,
  -1.58525169e-01f, -2.06492888e-03f, -2.57580310e-01f, 1.04732059e-01f, 1.15458682e-01f, 4.81713004e-02f, -7.37866983e-02f, -2.92182118e-01f, -8.85668993e-02f, -1.20757259e-01f,
  8.24748203e-02f, -2.93662399e-01f, -2.31277924e-02f, 9.95179191e-02f, 7.55155757e-02f, -1.14302663e-02f, -3.47947240e-01f, 3.82591523e-02f, 1.67839304e-01f, -9.24675167e-02f,
  -3.59524608e-01f, -1.33851126e-01f, -4.90531400e-02f, -2.71814801e-02f, 5.19270711e-02f, 1.14184685e-01f, -3.98684889e-02f, 8.16593245e-02f, 8.75482485e-02f, 4.92755696e-02f,
  -1.23590445e-02f, 6.24498688e-02f, 8.26553330e-02f, 4.14139740e-02f, 2.10508499e-02f, -1.16994701e-01f, -3.94561738e-02f, -1.32741466e-01f, 1.35756910e-01f, 8.15656781e-02f,
  -4.96555679e-03f, -1.18703302e-03f, -1.03229478e-01f, -7.54033402e-02f, 3.42538863e-01f, 5.70064671e-02f, 2.35456392e-01f, 6.43268973e-02f, 1.05395831e-01f, 1.44484758e-01f,
  -1.53226361e-01f, -2.62614638e-01f, -5.32084657e-03f, 2.65209582e-02f, -6.42981827e-02f, 1.18077062e-01f, 5.38157187e-02f, -4.51185629e-02f, -1.89441085e-01f, 2.44079679e-01f,
  1.03705309e-01f, 6.05687639e-03f, 8.67927745e-02f, 2.64042199e-01f, 6.37478158e-02f, -5.94573393e-02f, -1.05529487e-01f, -6.22376539e-02f, 1.01673059e-01f, 1.20977961e-01f,
  1.39000818e-01f, 2.39956230e-01f, 6.25173673e-02f, -7.36714602e-02f, 4.87816632e-02f, -1.24438375e-01f, -9.77055207e-02f, -3.65111232e-01f, 1.71369806e-01f, 1.29167095e-01f,
  2.26685032e-01f, -3.23529057e-02f, 1.84260547e-01f, 8.65630135e-02f, -3.21190767e-02f, 1.63600370e-01f, -2.11524442e-02f, 4.35739495e-02f, 1.22700520e-02f, -6.89315572e-02f,
  7.92464092e-02f, 8.00231770e-02f, 8.29154998e-03f, 2.49971971e-01f, 1.38807610e-01f, -6.33234903e-02f, 1.81784928e-02f, 1.33054644e-01f, -6.15069792e-02f, 8.44380409e-02f,
  2.58446515e-01f, 3.09449118e-02f, -5.78838587e-02f, -6.33179024e-02f, -1.42159611e-01f, -1.07848525e-01f, 1.82919428e-01f, -1.56183735e-01f, 7.67630860e-02f, -1.85262024e-01f,
  5.89180142e-02f, 1.52302086e-01f, -1.25988021e-01f, -8.67221132e-02f, 3.09265070e-02f, 2.32656687e-01f, 9.00130644e-02f, 1.92712825e-02f, -1.98035643e-01f, 2.22910374e-01f,
  -2.51033425e-01f, -2.27330048e-02f, -2.52439886e-01f, -1.55755371e-01f, -1.61677405e-01f, -2.80952454e-01f, 4.43027215e-03f, -2.77250648e-01f, -1.06679052e-02f, 3.23693529e-02f,
  6.41084462e-03f, 1.28737614e-01f, 1.00069039e-01f, 3.69274206e-02f, -6.11016201e-03f, -9.33373719e-02f, 1.58709005e-01f, 1.93239674e-01f, -1.19043440e-01f, 3.09783995e-01f,
  6.46593273e-02f, 9.16132629e-02f, -3.69376153e-01f, 1.48344472e-01f, -9.97864641e-03f, 8.78221989e-02f, 2.98641436e-02f, 6.48772940e-02f, 1.80421602e-02f, 1.80870056e-01f,
  1.45514265e-01f, 2.66717792e-01f, 1.73180804e-01f, 9.57676116e-03f, -1.58101976e-01f, -4.30622160e-01f, 1.36480033e-01f, 8.31941143e-02f, -1.25388578e-01f, 1.02817319e-01f,
  -1.35966972e-01f, -1.24066718e-01f, -3.22805405e-01f, -1.42937779e-01f, 7.74721503e-02f, -5.09831421e-02f, 4.41701673e-02f, 4.08463441e-02f, 2.06987143e-01f, -1.20996349e-02f,
  3.09726838e-02f, -5.04233241e-02f, 1.50007039e-01f, 1.23195991e-01f, 1.74295813e-01f, -3.26568335e-02f, -1.12630278e-01f, -5.78892604e-02f, -1.54402569e-01f, -1.65263176e-01f,
  2.47257814e-01f, 1.51051149e-01f, -1.58610508e-01f, -3.44766408e-01f, -1.20346583e-02f, 5.49075520e-03f, -1.62717015e-01f, 1.66286156e-01f, 1.24428876e-01f, 1.03599638e-01f,
  -2.87874024e-02f, 2.33870924e-01f, 1.25101402e-01f, 5.98867424e-02f, 7.99829513e-02f, -1.33897662e-01f, -1.64628029e-01f, -3.55720893e-02f, 3.93295065e-02f, 1.55452281e-01f,
  -1.62156194e-01f, 1.66450664e-01f, 9.13197920e-03f, -4.26173925e-01f, -1.03233963e-01f, -1.38720423e-01f, 9.95786339e-02f, -1.30591348e-01f, 2.25908369e-01f, -3.65339845e-01f,
  -4.51080166e-02f, -1.21092081e-01f, -4.16536070e-03f, -2.85320252e-01f, -4.59897071e-02f, 4.72409055e-02f, -2.65443206e-01f, 1.97422951e-01f, 1.61313191e-01f, 1.46390021e-01f,
  -2.91045129e-01f, -6.16282336e-02f, 8.70747194e-02f, 1.51236001e-02f, -1.96223632e-01f, -9.94385555e-02f, -9.51444134e-02f, 6.92575425e-02f, -6.95392638e-02f, -2.14295872e-02f,
  -1.32907048e-01f, -2.09137663e-01f, 5.32152355e-02f, -4.36525755e-02f, 1.25399321e-01f, -6.39259666e-02f, 4.79741059e-02f, -2.12374441e-02f, -4.73611727e-02f, 8.42370391e-02f,
  -1.00917645e-01f, -1.30301014e-01f, 9.19034481e-02f, 1.25986800e-01f, 1.74660876e-01f, -6.87092990e-02f, -2.06635594e-01f, -4.14800532e-02f, -5.98330982e-02f, 1.14237880e-02f,
  -2.25918680e-01f, 1.40245184e-01f, 2.09717259e-01f, -4.45356853e-02f, 4.94112223e-02f, 1.23472605e-02f, 2.87751872e-02f, 5.49976602e-02f, 1.56308897e-02f, 1.75394297e-01f,
  -2.64533963e-02f, -1.19523913e-01f, -4.93262373e-02f, -2.73536122e-03f, -7.13544562e-02f, -2.05130465e-02f, 1.44279286e-01f, -3.40610117e-01f, 1.58251300e-01f, 5.07049002e-02f,
  -4.50267307e-02f, 8.99441689e-02f, 7.97945559e-02f, -7.58147463e-02f, 3.38563412e-01f, -8.18264335e-02f, -4.04800288e-02f, -9.86586660e-02f, 2.08465680e-01f, -3.16430815e-02f,
  8.85384232e-02f, 2.36475542e-01f, -8.19147527e-02f, -1.98764563e-01f, -3.26586217e-02f, 3.75740081e-01f, -9.21764746e-02f, 2.61709422e-01f, 4.35004793e-02f, 3.77313420e-02f,
  -2.34149590e-01f, -2.42023051e-01f, -2.77063668e-01f, -1.78561471e-02f, 1.35470301e-01f, -2.56517440e-01f, 2.07326531e-01f, -7.84620717e-02f, -2.84254938e-01f, -3.95051390e-02f,
  -8.64213258e-02f, 7.39351586e-02f, 1.19629294e-01f, -1.81396872e-01f, -1.31026432e-02f, 2.95367151e-01f, 9.40352157e-02f, -1.48879364e-01f, -6.12379834e-02f, 1.10791050e-01f,
  8.96326080e-02f, -8.65557347e-04f, -9.10819247e-02f, -1.78053714e-02f, 3.03200427e-02f, 3.80372927e-02f, 1.10456973e-01f, 1.18250027e-01f, -2.34592497e-01f, 1.70804784e-01f,
  1.99795812e-01f, 2.07787350e-01f, 3.16831842e-02f, 5.00977635e-02f, -3.35175455e-01f, 4.06411737e-02f, 2.66681742e-02f, 2.00032026e-01f, 3.39220352e-02f, -1.43082468e-02f,
  1.10008173e-01f, 2.74251923e-02f, -1.07621141e-01f, -6.89747371e-03f, 2.24239066e-01f, 1.45171937e-02f, -4.20325771e-02f, -1.20968916e-01f, -1.94962546e-01f, 5.58585376e-02f,
  -4.31016684e-02f, 2.53882837e-02f, -7.69291297e-02f, -7.99157917e-02f, 3.22362781e-02f, 1.59932256e-01f, 1.13034524e-01f, 5.97940460e-02f, -9.37610120e-02f, 5.61191747e-03f,
  2.31003493e-01f, 7.70033449e-02f, 9.66344476e-02f, 1.17562888e-02f, 1.08977243e-01f, 7.23209903e-02f, 1.39359638e-01f, -1.20141797e-01f, -8.84823650e-02f, 8.64746720e-02f,
  1.21571481e-01f, -3.56290825e-02f, -1.55287400e-01f, -1.72103066e-02f, 5.52465096e-02f, -3.39115232e-01f, -1.43292099e-01f, -2.87032902e-01f, -3.10527861e-01f, -8.02480280e-02f,
  4.26206708e-01f, -4.93996330e-02f, -5.79407215e-01f, -1.25087276e-01f, 1.29831403e-01f, -2.08442092e-01f, -4.48499136e-02f, -7.31551647e-03f, 5.46381101e-02f, -4.81771259e-03f,
  1.57893628e-01f, 1.05906770e-01f, -8.50331485e-02f, 3.07440590e-02f, 8.93208012e-02f, 6.71452582e-02f, 1.25795692e-01f, 9.15170461e-02f, -1.32314458e-01f, 9.73197073e-02f,
  -6.00063577e-02f, 7.48859942e-02f, -4.57992144e-02f, 1.01579137e-01f, -2.36659929e-01f, 4.36581038e-02f, 7.90025368e-02f, 7.84725547e-02f, 3.77793498e-02f, 5.63266054e-02f,
  6.56342581e-02f, 1.33916125e-01f, -3.47579122e-02f, -2.29502290e-01f, 2.03460082e-01f, -1.09774442e-02f, -1.64854035e-01f, 2.85229925e-02f, -3.39734018e-01f, 5.31707704e-02f,
  -1.60053223e-01f, -4.32597585e-02f, 1.12554915e-01f, -8.20873752e-02f, 1.50779307e-01f, 9.63981897e-02f, 1.51666954e-01f, 5.95939308e-02f, 8.05390924e-02f, 9.91162211e-02f,
  1.09360144e-01f, 2.02927306e-01f, -7.11477071e-04f, 2.23110437e-01f, 1.09051861e-01f, 1.28996655e-01f, -1.01309180e-01f, 4.42620069e-02f, -1.97535947e-01f, -9.08278078e-02f,
  -1.58612385e-01f, -3.67220305e-02f, 2.77311087e-01f, 1.26364082e-01f, -1.34803325e-01f, 4.83516566e-02f, 4.42298427e-02f, 1.42902598e-01f, 3.43165211e-02f, 1.84571430e-01f,
  -1.28630986e-02f, 1.97824523e-01f, 8.95755291e-02f, -3.59761529e-02f, -7.45371133e-02f, -6.49010614e-02f, 3.98597457e-02f, -1.18169688e-01f, -1.15971100e-02f, -9.83214453e-02f,
  8.50212723e-02f, 2.97016483e-02f, 9.06144679e-02f, -4.54175584e-02f, 1.41431749e-01f, 9.14928913e-02f, 2.19508484e-01f, -1.51385916e-02f, 5.46692759e-02f, 1.14716358e-01f,
  1.14470877e-01f, -5.21635674e-02f, 2.08662692e-02f, 7.46504068e-02f, -4.29176539e-02f, 1.64025828e-01f, -1.27481982e-01f, 1.52872518e-01f, -1.11118078e-01f, -9.91352946e-02f,
  -1.47990033e-01f, -1.76978171e-01f, 2.63355345e-01f, -2.06039131e-01f, 1.56055123e-01f, 8.28565657e-02f, -1.78000197e-01f, 2.06008870e-02f, 4.43796031e-02f, -4.24391851e-02f,
  -1.69610586e-02f, 5.13412654e-02f, 6.98814318e-02f, -1.78379696e-02f, 6.37056679e-02f, 7.45246708e-02f, -2.69121140e-01f, 1.02705702e-01f, -1.88196811e-03f, 1.19530842e-01f,
  2.26754621e-02f, -3.05109620e-01f, 1.19237557e-01f, -2.41737947e-01f, -1.23795733e-01f, 1.02372326e-01f, 8.07516873e-02f, -2.47352257e-01f, 1.20924152e-01f, 2.56345063e-01f,
  2.91447878e-01f, -2.59887073e-02f, -2.30309978e-01f, 6.89108595e-02f, -1.84931442e-01f, 3.84251811e-02f, -2.39527434e-01f, -1.46163136e-01f, -1.71626024e-02f, -1.26039609e-01f,
  1.81845590e-01f, -9.87518206e-02f, 5.40898629e-02f, -1.42963678e-01f, -2.05498740e-01f, 2.08844766e-01f, 2.57800281e-01f, -6.15324751e-02f, -1.43533503e-03f, 9.61607620e-02f,
  -2.02166244e-01f, 7.86468610e-02f, -6.20019175e-02f, 6.89630583e-02f, 7.24274442e-02f, -1.21456705e-01f, -2.93595523e-01f, -3.76353227e-02f, -4.30770703e-02f, -1.58623427e-01f,
  1.77543014e-01f, 4.93462048e-02f, -1.09934494e-01f, 2.78768688e-01f, 2.40318060e-01f, 2.25132555e-01f, -1.18468339e-02f, -4.01991643e-02f, -7.34765232e-02f, -2.96278000e-01f,
  2.48659924e-01f, 3.15248907e-01f, -7.41932094e-02f, 2.03497827e-01f, -5.56937270e-02f, 6.56833425e-02f, -4.12272662e-01f, -2.10492417e-01f, -1.30339041e-01f, -1.08752877e-01f,
  -1.81637457e-04f, -1.28864244e-01f, 1.02335578e-02f, -1.69708095e-02f, 1.52598053e-01f, 1.33647472e-02f, 3.43612164e-01f, 1.71292633e-01f, 2.75133967e-01f, 1.79345354e-01f,
  4.11403552e-02f, 3.17968316e-02f, -3.09014708e-01f, -6.08064793e-02f, 1.07494317e-01f, -8.88765976e-02f, -7.75299594e-02f, 3.43934476e-01f, 1.76090434e-01f, -6.88257366e-02f,
  -1.74694017e-01f, -7.39295827e-03f, -2.43620817e-02f, -2.89660320e-02f, 2.12863415e-01f, 1.11590549e-01f, -1.91640809e-01f, -1.55998975e-01f, 7.45224208e-02f, -1.02751091e-01f,
  1.73221827e-01f, -9.30911750e-02f, -3.78571381e-03f, 8.19619671e-02f, -6.22481294e-02f, 1.38154164e-01f, 1.65747702e-01f, 2.21471354e-01f, -1.16447762e-01f, -2.60730851e-02f,
  7.82008246e-02f, 1.11895218e-01f, 1.11378923e-01f, 7.21939132e-02f, 7.41459057e-02f, 1.53218076e-01f, 6.51418865e-02f, 1.96621895e-01f, 1.47384718e-01f, 3.18897665e-02f,
  2.07911972e-02f, -4.56939526e-02f, 2.66623013e-02f, 4.25710008e-02f, -4.44343016e-02f, 1.61005482e-01f, -1.31350204e-01f, -6.97749630e-02f, -1.41172111e-01f, 1.98331252e-01f,
  2.22391617e-02f, 1.05827853e-01f, 1.74846217e-01f, 6.88650012e-02f, -1.87156215e-01f, 7.14175701e-02f, -1.55087978e-01f, 4.24428023e-02f, 8.07066485e-02f, 1.15839586e-01f,
  -5.15863448e-02f, 1.11637391e-01f, -4.91249263e-02f, 6.63888529e-02f, 2.61681855e-01f, 5.83398417e-02f, -3.16778719e-01f, -1.20721944e-01f, 4.95168567e-01f, 2.52939820e-01f,
  -1.29519075e-01f, -1.04098767e-01f, -1.34736411e-02f, 4.11073081e-02f, -4.83403392e-02f, -4.59845737e-02f, 7.82742426e-02f, 6.08190931e-02f, 1.28745615e-01f, 1.01612080e-02f,
  -1.62606388e-01f, -4.58761491e-02f, -7.68823028e-02f, -2.28217021e-02f, 6.89205080e-02f, 6.34342879e-02f, 1.80188399e-02f, -1.73215643e-01f, -4.26253825e-02f, 4.54583056e-02f,
  2.86123790e-02f, -1.53594658e-01f, 1.27810255e-01f, 6.00177050e-02f, 5.97921258e-04f, 7.05295429e-02f, -1.14685729e-01f, -6.34526387e-02f, 9.01611596e-02f, 6.08237414e-03f,
  1.45443473e-02f, -5.09748701e-03f, 7.09512411e-03f, 5.34817539e-02f, -1.22739794e-02f, 7.75447488e-02f, -7.31531307e-02f, -5.98362535e-02f, 5.87123372e-02f, 3.96586070e-03f,
  2.12191977e-02f, 1.26648262e-01f, 1.17047846e-01f, -1.61692929e-02f, -2.23951533e-01f, -1.73091590e-01f, -3.01938187e-02f, 7.15317130e-02f, 1.40286572e-02f, -2.54301876e-01f,
  -4.16604504e-02f, -3.68609913e-02f, -9.72283483e-02f, 4.25716676e-02f, 1.20365575e-01f, -5.69142736e-02f, 1.42120376e-01f, -9.96567756e-02f, -8.09435323e-02f, -1.63959831e-01f,
  6.32072520e-03f, -2.31937066e-01f, 1.57222096e-02f, -1.36419848e-01f, -1.05046079e-01f, -2.83266753e-01f, 3.03378254e-02f, 6.79181442e-02f, -9.92493331e-02f, 2.48731345e-01f,
  2.26841435e-01f, -5.53855002e-02f, 1.10875525e-01f, 2.17827961e-01f, 2.11074978e-01f, 1.39452785e-01f, 1.43996477e-02f, 9.52016786e-02f, 1.06069684e-01f, 5.69041166e-03f,
  1.04142666e-01f, 1.96811125e-01f, 8.09551850e-02f, 3.65221351e-02f, -6.12898904e-04f, -1.88985616e-01f, 5.76867871e-02f, 1.46605994e-03f, 2.09912613e-01f, 4.00328562e-02f,
  2.31708929e-01f, -2.50647604e-01f, 2.47380435e-01f, -2.17750177e-01f, 1.95164338e-01f, -2.52494395e-01f, 5.53428419e-02f, 7.91367367e-02f, -7.77703598e-02f, 2.54234314e-01f,
  -7.14876354e-02f, 1.18999936e-01f, -3.50439221e-01f, 2.63432682e-01f, -7.93174803e-02f, 1.89940974e-01f, 2.47664042e-02f, -6.99983118e-03f, 4.93363701e-02f, -4.12142351e-02f,
  -2.94584662e-01f, 3.88122201e-02f, -9.42898989e-02f, -1.58680186e-01f, -7.77416676e-02f, 2.71218251e-02f, 3.06233972e-01f, 6.97482899e-02f, 2.31822163e-01f, 1.75594479e-01f,
  1.59708411e-01f, 1.51239216e-01f, 1.55960741e-02f, -1.35761052e-02f, -2.62464732e-01f, 1.26891777e-01f, 3.10114950e-01f, 2.77498942e-02f, -1.49202928e-01f, 1.02965802e-01f,
  3.80758643e-01f, -1.97083391e-02f, 4.31381464e-02f, -5.90802170e-02f, 5.77841103e-02f, 7.24760294e-02f, 1.58444687e-03f, -8.01459327e-02f, 4.32250649e-02f, -1.42303929e-01f,
  -9.10079200e-03f, -4.01191860e-02f, 8.36229026e-02f, -5.93947694e-02f, 5.91395907e-02f, 7.94318616e-02f, -8.89826491e-02f, -3.35796505e-01f, 1.33798167e-01f, 1.57116931e-02f,
  5.22509441e-02f, 1.48361400e-01f, -7.90844560e-02f, -5.45616820e-02f, 3.32296677e-02f, -1.23408839e-01f, 1.36442110e-01f, -2.78457046e-01f, 2.10919734e-02f, -1.23722211e-01f,
  3.03499967e-01f, -2.61746585e-01f, 1.38265580e-01f, 2.97084991e-02f, 1.46709293e-01f, 1.73278481e-01f, 7.47572817e-03f, 7.53227668e-03f, -3.18692774e-02f, 3.09991539e-02f,
  -1.52317300e-01f, -1.23545654e-01f, 1.56351209e-01f, 2.52332687e-01f, -3.16121697e-01f, -8.34701210e-02f, -7.32789040e-02f, -4.28438708e-02f, -6.84446096e-02f, 2.68387854e-01f,
  1.14244260e-01f, 1.35278016e-01f, 2.45783143e-02f, 1.72748685e-01f, 1.12655163e-01f, 8.40419978e-02f, 1.30075872e-01f, 2.41310567e-01f, -2.97764838e-01f, -5.04270084e-02f,
  -8.11490417e-02f, 2.10882351e-02f, -6.76516816e-02f, 3.66248131e-01f, 5.25736958e-02f, -8.49587843e-02f, -2.27143496e-01f, -1.97670594e-01f, -6.34456500e-02f, -5.36414050e-02f,
  1.41821295e-01f, 2.13741586e-02f, -1.72779374e-02f, -1.75871298e-01f, 2.47842357e-01f, -2.29230151e-01f, 1.79955661e-02f, -1.17456391e-01f, 7.45232822e-03f, -2.47685872e-02f,
  5.18063344e-02f, 1.50737002e-01f, -2.33900547e-01f, 1.18606128e-01f, 7.10463822e-02f, 2.21144840e-01f, -7.06818849e-02f, 4.29517776e-02f, 1.79879755e-01f, 2.77485251e-02f,
  -6.12403005e-02f, 6.25652298e-02f, 7.26019442e-02f, 1.37032449e-01f, 1.89181596e-01f, -1.17748931e-01f, 3.42623919e-01f, -1.43697392e-02f, -7.65334889e-02f, -2.17432991e-01f,
  -6.06811568e-02f, -2.39293694e-01f, -3.22445005e-01f, -1.70307279e-01f, -7.48220906e-02f, 5.04747108e-02f, -1.07384749e-01f, 5.15429564e-02f, 8.34513903e-02f, -3.37884799e-02f,
  -1.02054656e-01f, 1.15390688e-01f, -2.45751906e-02f, -2.78722607e-02f, 3.22442323e-01f, 1.99034765e-01f, -7.39267841e-02f, 2.71424413e-01f, -3.69822472e-01f, -1.29172280e-01f,
  -9.80409831e-02f, -9.74146351e-02f, -1.31356314e-01f, 1.49907842e-01f, 1.48754001e-01f, 1.94146454e-01f, 5.13164178e-02f, -1.37945488e-01f, -9.06371623e-02f, 8.22965130e-02f,
  3.68514448e-01f, -2.66123086e-01f, 2.46847291e-02f, 1.28285848e-02f, 9.59304813e-03f, -1.38109073e-01f, -2.47271359e-01f, -1.67733625e-01f, -1.88118502e-01f, 1.29755452e-01f,
  1.53822929e-01f, 3.04827094e-02f, -2.81593472e-01f, -9.22828838e-02f, -3.39891277e-02f, -3.76053117e-02f, -4.52538133e-02f, -2.59995431e-01f, 1.05561368e-01f, -7.77858198e-02f,
  -1.89018607e-01f, 7.35599315e-03f, -4.46479440e-01f, -8.61494318e-02f, -6.07856177e-02f, -1.02176048e-01f, -3.29503089e-01f, 1.01666957e-01f, 9.21742693e-02f, 9.73455831e-02f,
  -1.85855508e-01f, -2.27127314e-01f, 1.71993420e-01f, 3.99356857e-02f, 4.27095503e-01f, 9.29976851e-02f, 1.24965876e-01f, -6.66645318e-02f, 1.20925389e-01f, 3.89650427e-02f,
  2.45054960e-01f, 6.07622825e-02f, -4.89245914e-02f, -5.43613844e-02f, 2.07162380e-01f, 2.48481378e-01f, -6.25133738e-02f, 2.09809840e-01f, -4.64923717e-02f, 5.75076789e-02f,
  1.86106578e-01f, 1.77204743e-01f, 4.08963524e-02f, 6.39067441e-02f, 2.07978025e-01f, 1.00462005e-01f, -1.44660011e-01f, -1.22233525e-01f, 9.20938551e-02f, -6.17650039e-02f,
  -1.29852649e-02f, 1.46437600e-01f, 3.10883284e-01f, -1.81518331e-01f, 6.49511889e-02f, -5.94440885e-02f, -1.58858318e-02f, 2.16056369e-02f, -1.11576706e-01f, 3.93562794e-01f,
  -1.56662446e-02f, -2.16899842e-01f, 8.30363855e-02f, -2.05338940e-01f, 3.91303226e-02f, -7.66563714e-02f, -3.79862264e-02f, 2.30931342e-01f, -3.14279161e-02f, -1.60778329e-01f,
  1.39735892e-01f, -2.47203913e-02f, -1.67064011e-01f, -2.04947084e-01f, 7.93552548e-02f, 7.61145428e-02f, 8.53873864e-02f, -1.66895419e-01f, -8.41121227e-02f, 5.20899473e-03f,
  1.32340685e-01f, 7.50446394e-02f, 1.85439512e-01f, -2.81999558e-01f, -1.12086348e-01f, -1.93177104e-01f, 2.66924679e-01f, 1.05632633e-01f, 6.77265227e-02f, -1.40124410e-01f,
  3.54052067e-01f, -8.20165053e-02f, -1.22815065e-01f, -2.02445939e-01f, 1.09362327e-01f, 1.41737103e-01f, 3.04391887e-02f, -1.73226133e-01f, -2.29453444e-01f, 1.64272204e-01f,
  -2.90757388e-01f, 1.11829259e-01f, -1.09440275e-01f, 1.53175086e-01f, -1.70545027e-01f, 5.43721318e-02f, -1.99703798e-01f, -2.68161118e-01f, 3.20615888e-01f, 2.18658194e-01f,
  -1.58670962e-01f, 3.65475789e-02f, 5.94238974e-02f, 2.53617138e-01f, 1.58930138e-01f, 1.23061940e-01f, -6.27631024e-02f, 2.09467918e-01f, 1.81037933e-01f, -2.33718395e-01f,
  -1.40508860e-01f, 5.04664779e-02f, 4.21698093e-02f, 3.28060314e-02f, -4.61285450e-02f, -6.51742369e-02f, -9.13301855e-02f, 2.74222791e-02f, 9.02282596e-02f, -5.77928610e-02f,
  1.81330904e-01f, -9.14349332e-02f, 2.35994056e-01f, -2.68784594e-02f, -3.94408889e-02f, 1.59269869e-01f, 9.32654664e-02f, -4.32501361e-03f, -1.40486419e-01f, 6.94301352e-02f,
  -1.21659011e-01f, 4.14994471e-02f, -7.38411620e-02f, 1.83771402e-01f, -7.67255798e-02f, -1.71995908e-01f, -8.83453414e-02f, -2.32025366e-02f, 2.96835184e-01f, -1.54515013e-01f,
  1.70372009e-01f, -2.61056796e-03f, -1.02889715e-02f, -1.34737179e-01f, 2.09688440e-01f, 1.16118817e-02f, 3.09087783e-02f, -1.11736439e-01f, 6.23007957e-03f, 9.27616283e-02f,
  7.71160722e-02f, -4.42749122e-03f, -1.18796907e-01f, 1.53776109e-01f, -1.04695059e-01f, 1.04980014e-01f, 1.91927373e-01f, -3.17154266e-02f, 5.18928692e-02f, 1.41864523e-01f,
  6.28777146e-02f, 4.64243218e-02f, 4.20260169e-02f, -4.14633229e-02f, 2.21113041e-01f, -3.77811901e-02f, -2.48567358e-01f, 1.54252246e-01f, 2.36124247e-01f, -1.35080904e-01f,
  5.12590781e-02f, 3.79325062e-01f, 5.86525574e-02f, -6.82982430e-02f, -9.85147730e-02f, 1.10835150e-01f, 1.10955518e-02f, -8.22769180e-02f, 2.10790873e-01f, 5.98733574e-02f,
  9.76287127e-02f, -1.77594990e-01f, -1.05945177e-01f, 1.39563709e-01f, 2.80307710e-01f, -1.26302065e-02f, 1.36955619e-01f, -5.27250953e-02f, 1.33346289e-01f, -2.21788604e-02f,
  2.51355488e-02f, 3.72117409e-03f, 1.00294642e-01f, -8.17366019e-02f, 1.79903314e-01f, 2.26420328e-01f, -1.22912116e-01f, 4.81393598e-02f, 1.71796367e-01f, -1.16854899e-01f,
  1.04206622e-01f, -1.37358904e-01f, 2.13016465e-01f, -6.01036064e-02f, 1.25498161e-01f, 1.16248727e-02f, 4.58495691e-02f, -7.10968152e-02f, -1.74331322e-01f, -1.28356367e-01f,
  3.07617038e-02f, -7.91239440e-02f, 1.28208771e-01f, 7.78318793e-02f, -2.90513664e-01f, 6.18731417e-02f, -3.07263955e-02f, 8.49061906e-02f, -1.13944724e-01f, 1.52414978e-01f,
  2.73802131e-02f, 1.74323916e-01f, 1.12984397e-01f, -2.53903307e-02f, -2.90696949e-01f, -7.03180134e-02f, 4.99002635e-02f, -2.36297280e-01f, 1.24377489e-01f, 9.81355384e-02f,
  1.13856174e-01f, 1.55640364e-01f, 1.16434559e-01f, -1.42343700e-01f, 2.70039607e-02f, 3.35436642e-01f, 2.32288629e-01f, -1.23365156e-01f, -1.56600792e-02f, -6.54334798e-02f,
  7.05361040e-03f, -5.18756881e-02f, 6.84283301e-02f, 8.80628824e-02f, -3.55034545e-02f, -9.96934250e-02f, 3.77955399e-02f, -1.59215480e-01f, 1.33310333e-01f, 6.07262878e-03f,
  -1.02683343e-01f, -3.49022985e-01f, -3.98588702e-02f, -1.20023109e-01f, 1.79256778e-02f, 4.64919768e-03f, 1.03355814e-02f, -2.09297165e-01f, -1.35242999e-01f, 2.65158325e-01f,
  -1.90215215e-01f, 3.05826161e-02f, -5.83298840e-02f, -9.59981531e-02f, 1.47019506e-01f, -2.42196545e-01f, -5.02034044e-03f, -6.42493144e-02f, 8.58933032e-02f, 1.62257373e-01f,
  -3.00055575e-02f, -1.75188318e-01f, 5.79083934e-02f, 1.84084999e-03f, 8.48647614e-04f, -1.23832449e-01f, 3.49304476e-03f, 1.84507072e-01f, -3.78750652e-01f, -3.04630071e-01f,
  3.91619503e-02f, 1.00887425e-01f, -1.91384070e-02f, 2.52656251e-01f, -1.12356037e-01f, 6.52991235e-02f, -4.82714884e-02f, -1.55470110e-02f, 6.22164570e-02f, 6.35124892e-02f,
  -1.83816358e-01f, -1.16777621e-01f, 6.57734349e-02f, -9.96063277e-03f, 6.45817891e-02f, 2.95625180e-02f, -1.60244539e-01f, 5.96220344e-02f, 3.72153670e-02f, -9.97130293e-03f,
  -2.18470916e-01f, 6.26684129e-02f, 2.06827730e-01f, 1.38571030e-02f, -1.92501489e-02f, 4.07302789e-02f, 1.04606166e-01f, 5.49368225e-02f, 1.22327700e-01f, 1.31201670e-01f,
  3.06074563e-02f, -6.55844435e-02f, -1.53530166e-01f, -1.54296130e-01f, 1.44353230e-02f, -6.74686879e-02f, 2.44638711e-01f, -5.67258336e-02f, 1.64991431e-02f, 1.09202616e-01f,
  -6.75193816e-02f, -1.26386121e-01f, 7.19421580e-02f, -7.09267333e-02f, 2.35369697e-01f, -2.05796957e-01f, -2.29425915e-02f, -5.03319912e-02f, 9.72972214e-02f, 4.85992469e-02f,
  -6.02114163e-02f, 2.46436656e-01f, -2.06099689e-01f, -1.17974309e-02f, -2.83068538e-01f, 3.00552189e-01f, -7.16258809e-02f, 2.80168712e-01f, 1.07008666e-02f, 3.29803564e-02f,
  -1.63012654e-01f, -1.97752327e-01f, -2.05288768e-01f, 5.56323910e-03f, 2.18487129e-01f, -1.21807970e-01f, 2.73274451e-01f, -8.68662223e-02f, 2.21815318e-01f, 2.62417682e-02f,
  -1.21078782e-01f, -1.83961429e-02f, -3.95897388e-01f, 3.23409438e-02f, 2.14370694e-02f, -1.75398976e-01f, 3.10556144e-01f, 4.56778184e-02f, 1.28218397e-01f, 1.50401354e-01f,
  1.30877495e-01f, 5.48998863e-02f, -1.49437875e-01f, 2.04439223e-01f, 1.69184078e-02f, -2.33384222e-01f, -1.14139304e-01f, -1.61485523e-01f, 8.39571655e-02f, -2.22016498e-01f,
  5.60716763e-02f, 1.52096614e-01f, -8.82165879e-02f, 1.67251959e-01f, 4.25538979e-02f, 4.80349772e-02f, 2.04170749e-01f, -7.51252174e-02f, 2.68550720e-02f, -9.46715251e-02f,
  2.05424745e-02f, -9.14063212e-03f, 4.93862703e-02f, 4.35901247e-02f, -1.38726756e-01f, -1.44481227e-01f, -1.50070533e-01f, 3.43550369e-02f, 6.76703751e-02f, -4.17094268e-02f,
  8.07938799e-02f, -6.65020272e-02f, -8.33313353e-03f, 1.27267733e-01f, -1.57803699e-01f, -1.13849759e-01f, 3.19643840e-02f, 1.37425987e-02f, 2.99833357e-01f, -9.80046950e-03f,
  1.08849220e-01f, -5.84467314e-02f, 1.18730754e-01f, -1.81844667e-01f, 6.65594712e-02f, 3.42226066e-02f, -2.75932580e-01f, -1.01636857e-01f, 2.11882293e-01f, 4.38175574e-02f,
  1.04578875e-01f, 2.09009588e-01f, 1.00684851e-01f, -1.22578934e-01f, 1.55106457e-02f, 1.91129163e-01f, -1.85135342e-02f, -1.83053732e-01f, 2.45713978e-03f, -1.51584715e-01f,
  -3.41886044e-01f, -9.23527777e-02f, 3.77872527e-01f, 1.88091367e-01f, -1.30561322e-01f, 1.00065403e-01f, 1.20767899e-01f, 1.38288289e-01f, 2.25019157e-01f, 1.97992399e-01f,
  1.40293792e-01f, 2.12155119e-01f, 1.48516700e-01f, 2.75304317e-01f, 6.99927434e-02f, 1.07180066e-01f, -2.45237142e-01f, -4.06096652e-02f, 1.92489445e-01f, -4.45027761e-02f,
  -8.76548216e-02f, -5.92204109e-02f, -1.60896868e-01f, -2.17725813e-01f, 3.67278963e-01f, -4.70718086e-01f, -1.45798489e-01f, -2.50405967e-01f, -3.60267237e-02f, 4.63404730e-02f,
  -2.94124763e-02f, -6.62315860e-02f, 1.74812287e-01f, -8.25086534e-02f, -1.04872249e-02f, -8.09846222e-02f, 1.19426951e-01f, -1.21923886e-01f, 1.86756119e-01f, 1.39067248e-02f,
  2.02876046e-01f, 5.77941686e-02f, -9.97298583e-02f, 9.04751290e-03f, 6.22086413e-02f, 7.17728436e-02f, -9.29201618e-02f, 4.67003882e-02f, 2.25360677e-01f, 3.87549214e-02f,
  -9.42708030e-02f, -1.24094971e-01f, -2.85720468e-01f, -4.34324928e-02f, -6.82635680e-02f, 5.85108921e-02f, 3.75257671e-01f, -8.68170485e-02f, 1.15806758e-01f, -5.64511260e-03f,
  -1.73899904e-02f, 1.39081225e-01f, -8.45291093e-02f, -2.31925800e-01f, 1.70735121e-01f, 2.41319433e-01f, -3.81109118e-02f, 2.94939876e-02f, -1.47682885e-02f, -7.53743276e-02f,
  7.51434341e-02f, 2.05961645e-01f, -5.45493886e-02f, -2.72346914e-01f, -3.62064602e-04f, -2.70190060e-01f, -1.91184767e-02f, -3.99850272e-02f, -3.18201296e-02f, -2.30617777e-01f,
  1.01234473e-01f, 5.07889874e-03f, 1.69427454e-01f, -6.55552819e-02f, -1.96174756e-01f, 2.51381192e-02f, -1.39360100e-01f, 6.90183863e-02f, -1.88488513e-01f, 1.40619323e-01f,
  1.14360191e-01f, -5.69828004e-02f, -3.94462347e-01f, 7.08892494e-02f, 3.18180956e-02f, -1.07509671e-02f, 1.82871327e-01f, -1.81598112e-01f, 6.79195598e-02f, 2.28497669e-01f,
  2.15490296e-01f, 2.34195814e-01f, -2.53302045e-02f, -1.04270160e-01f, -1.11288533e-01f, -1.78695217e-01f, 3.55593741e-01f, 2.42809933e-02f, -3.30467857e-02f, 7.98199102e-02f,
  -1.51522368e-01f, 2.89828479e-02f, -7.70866051e-02f, 1.11363314e-01f, -6.00293279e-02f, -3.98900285e-02f, 2.13148251e-01f, -3.06140948e-02f, -8.55513364e-02f, 9.71295983e-02f,
  2.71045566e-01f, 9.96064469e-02f, -9.95505974e-02f, 2.27283239e-01f, -6.07757568e-02f, 1.14172101e-01f, 5.35251647e-02f, 5.49941361e-02f, -4.22410965e-01f, 1.21181188e-02f,
  3.93580288e-01f, 2.49831349e-01f, -1.75847299e-02f, 1.25851110e-01f, -1.15551598e-01f, 1.74573675e-01f, 1.16965055e-01f, -1.31329238e-01f, 1.12787031e-01f, 3.05755995e-02f,
  -1.28729725e-02f, -1.46528408e-01f, -1.69493690e-01f, -1.92903295e-01f, 5.25852032e-02f, 4.66637611e-02f, -1.01601869e-01f, -3.12523320e-02f, -2.19366074e-01f, -8.65436271e-02f,
  2.69742310e-02f, 8.80241115e-03f, 1.26079256e-02f, 2.62926310e-01f, 2.08533540e-01f, 3.01990211e-01f, 1.92159608e-01f, 2.45489739e-02f, -1.72680378e-01f, -5.80336228e-02f,
  3.45370127e-03f, 4.60820869e-02f, 7.61621259e-03f, 7.52641335e-02f, 1.24283228e-02f, 1.16723582e-01f, 2.42214352e-01f, 1.31474376e-01f, -8.73853415e-02f, -2.06125583e-02f,
  1.02973692e-01f, -2.71495044e-01f, -3.70800227e-01f, -6.63297772e-02f, 3.36128138e-02f, -1.13400973e-01f, 5.53806014e-02f, -9.66589451e-02f, 8.90125260e-02f, -5.05068414e-02f,
  3.46473724e-01f, 1.15162775e-01f, 1.87055796e-01f, 2.07189620e-01f, -2.72591442e-01f, -9.19968486e-02f, 1.27028272e-01f, -1.92553461e-01f, -1.57629415e-01f, -2.93349117e-01f,
  9.42057669e-02f, -1.31326795e-01f, 2.31067851e-01f, -2.86682751e-02f, -1.25845760e-01f, -1.85948893e-01f, 9.90757346e-02f, 6.79850280e-02f, -2.31406838e-02f, 1.72993839e-01f,
  1.06129935e-02f, -4.54164222e-02f, -1.27236858e-01f, 7.58254901e-02f, -4.56339754e-02f, -1.98807344e-02f, 1.21613033e-01f, 1.86847895e-01f, 1.73415899e-01f, 9.30544585e-02f,
  -6.77222759e-02f, 6.54081106e-02f, 1.91723511e-01f, 9.25501138e-02f, 5.45825772e-02f, 1.43450927e-02f, -9.54565853e-02f, 1.18693717e-01f, 8.75446713e-04f, 9.12682265e-02f,
  1.52915061e-01f, 6.16919734e-02f, -3.90128344e-02f, 3.40168178e-02f, 1.58349171e-01f, -9.41760093e-02f, 4.53968719e-02f, 1.85966231e-02f, -2.00031567e-02f, -5.51352873e-02f,
  -2.96397461e-03f, 4.80809361e-02f, 1.26543686e-01f, 5.33994287e-02f, -1.62458539e-01f, 1.53270423e-01f, 1.54986739e-01f, -4.87158522e-02f, 8.46472681e-02f, 8.43650773e-02f,
  6.82007298e-02f, -2.65780743e-02f, -1.69925615e-01f, -7.53498524e-02f, -2.74751671e-02f, 1.84892595e-01f, -1.67653069e-01f, -1.13655686e-01f, -5.36291413e-02f, -1.29093593e-02f,
  -2.47935995e-01f, 7.82549679e-02f, -4.37630296e-01f, -7.23128989e-02f, -3.16052623e-02f, 1.40121326e-01f, 9.29480493e-02f, 7.97248259e-02f, -1.20733052e-01f, -2.90709566e-02f,
  1.32359385e-01f, -1.41696587e-01f, -9.71847996e-02f, -7.79935047e-02f, 3.22716326e-01f, -1.33975774e-01f, 5.73631264e-02f, 1.11187719e-01f, -9.00563672e-02f, 1.12448186e-01f,
  -1.18481606e-01f, -1.83054432e-01f, -2.60041207e-01f, 4.48485687e-02f, -6.80585653e-02f, 1.42437071e-01f, -1.25555217e-01f, -6.69407919e-02f, 2.01882310e-02f, 1.05206206e-01f,
  -3.47501412e-02f, -1.19740315e-01f, 1.13800615e-01f, -6.62072375e-02f, -1.50022984e-01f, -5.35242185e-02f, -1.74931154e-01f, -1.72666743e-01f, -1.31550997e-01f, -1.66655451e-01f,
  -1.53911844e-01f, -1.51389375e-01f, 4.87630442e-02f, 1.06186852e-01f, -2.43921235e-01f, -8.46053138e-02f, 2.20680167e-03f, 1.07798152e-01f, 1.59768924e-01f, -8.65899399e-02f,
  4.12529893e-02f, 1.45988822e-01f, 2.06525773e-01f, -7.46602938e-02f, -7.94985145e-02f, -1.19935917e-02f, 1.27539203e-01f, 1.62564695e-01f, 9.99527350e-02f, 7.31887072e-02f,
  -6.87075928e-02f, 1.46206349e-01f, -3.04705679e-01f, -1.28504694e-01f, 1.27186716e-01f, -5.03182597e-02f, -1.62163913e-01f, -2.56069545e-02f, -5.25187813e-02f, 1.90989241e-01f,
  1.82895303e-01f, -1.70164574e-02f, -1.08642457e-02f, 7.32202455e-02f, 1.27198160e-01f, -1.19536342e-02f, 3.45384479e-02f, -1.99861750e-01f, 2.33862415e-01f, 9.86950994e-02f,
  -6.66994005e-02f, 1.80108532e-01f, 1.33989617e-01f, 8.31929669e-02f, -4.05326448e-02f, 3.57874557e-02f, -4.39907759e-02f, 1.65270288e-02f, 1.03721730e-01f, -3.40396427e-02f,
  1.10695083e-02f, 2.74291784e-01f, 9.76950675e-02f, 2.00776327e-02f, 4.10663448e-02f, -5.88523932e-02f, -5.52780256e-02f, -3.30341578e-01f, 7.26225674e-02f, -5.29882265e-03f,
  -1.01958536e-01f, -8.14602822e-02f, -1.59918815e-01f, 7.31269792e-02f, 8.39856789e-02f, 3.59325469e-01f, -3.10597029e-02f, 1.87128976e-01f, -9.14377272e-02f, -2.33268425e-01f,
  1.86258540e-01f, -1.33175114e-02f, 3.93277526e-01f, -7.60281533e-02f, 3.13084096e-01f, 3.54137458e-02f, 2.43500128e-01f, 1.15299538e-01f, 1.95837617e-02f, 1.74867600e-01f,
  1.90114558e-01f, -2.07822677e-03f, -9.40039456e-02f, 2.15824604e-01f, -2.15008706e-01f, 2.21294127e-02f, 1.14212252e-01f, 5.68066686e-02f, 3.02117497e-01f, 1.28922179e-01f,
  1.90457717e-01f, 3.39694560e-01f, 4.83513298e-03f, 6.25999048e-02f, -2.45879844e-01f, 1.19245298e-01f, 2.89274722e-01f, 8.20134059e-02f, 1.31970029e-02f, 2.49654621e-01f,
  2.48992234e-03f, 9.92648536e-04f, 1.08945765e-01f, -1.71890520e-02f, -7.89589994e-03f, 6.62925933e-03f, -9.53005180e-02f, 1.49669573e-01f, -1.58742979e-01f, -1.36830583e-01f,
  1.36379942e-01f, 8.04814473e-02f, 2.37719372e-01f, -1.33445233e-01f, -8.44321251e-02f, 8.78524631e-02f, -1.74356446e-01f, -1.45478129e-01f, -4.70864549e-02f, -4.13332600e-03f,
  6.63231164e-02f, -2.78348196e-03f, 1.54019259e-02f, -7.71753723e-03f, 5.79493754e-02f, 1.26566216e-02f, -1.33073092e-01f, -1.58793017e-01f, -1.03505068e-01f, 1.85582131e-01f,
  1.82770267e-01f, -1.19490344e-02f, 1.56293988e-01f, -7.68372267e-02f, 6.25544563e-02f, -5.07598966e-02f, 2.04199940e-01f, -4.26395327e-01f, -4.59169261e-02f, 8.27948377e-02f,
  -1.83730751e-01f, -3.15108418e-01f, 1.47428244e-01f, 1.63922206e-01f, 2.33740732e-02f, -2.95340836e-01f, 6.27187714e-02f, 4.10682261e-02f, -7.29471818e-02f, 3.69928824e-03f,
  1.80809498e-01f, 2.01022938e-01f, -8.10572586e-04f, 2.09401667e-01f, -1.12938926e-01f, 2.64655352e-02f, 1.07397750e-01f, 7.99060389e-02f, -2.44898424e-02f, 3.45356762e-02f,
  4.23730999e-01f, 3.47863108e-01f, 7.62601420e-02f, -2.72617698e-01f, -1.38136655e-01f, 1.38687134e-01f, 1.84585571e-01f, -2.14703288e-02f, -7.76558835e-03f, 2.62520276e-02f,
  -1.59309402e-01f, 5.18935872e-03f, -1.70318335e-01f, -1.37549579e-01f, -2.66361624e-01f, 1.58979788e-01f, -4.83391136e-02f, 2.63882782e-02f, -2.89487273e-01f, -8.10148418e-02f,
  -9.20905396e-02f, -1.19746797e-01f, 1.63076207e-01f, -3.75708014e-01f, 2.34467730e-01f, 1.37288764e-01f, 2.53700372e-02f, -2.15756372e-01f, -2.37592518e-01f, -1.14668705e-01f,
  -9.73553807e-02f, 4.54925187e-02f, -2.65420020e-01f, -1.85692653e-01f, 1.48775458e-01f, -1.21213622e-01f, -2.79344410e-01f, 9.10912603e-02f, 5.97088225e-03f, 1.67351604e-01f,
  2.49006495e-01f, -2.65552640e-01f, -1.35994032e-02f, -6.85581518e-03f, 1.95315972e-01f, -5.26041398e-03f, 5.91740422e-02f, 9.34638176e-03f, -3.51905217e-03f, -8.39945599e-02f,
  3.76549542e-01f, 1.62682593e-01f, 2.89073110e-01f, 2.06755891e-01f, -1.27646789e-01f, -7.41431713e-02f, 1.73574194e-01f, -1.48907050e-01f, -1.58552080e-01f, -1.03179328e-01f,
  -5.30127697e-02f, -2.20801495e-02f, 2.63411283e-01f, 8.39306116e-02f, -6.46438599e-02f, 5.19778430e-02f, 1.41423047e-01f, -2.37037092e-01f, 2.34854445e-01f, 8.44556168e-02f,
  1.28542483e-01f, 7.46235177e-02f, -1.96201485e-02f, 1.34235516e-01f, -2.01033399e-01f, 7.55794626e-03f, 1.38205126e-01f, 1.06847093e-01f, 8.35020933e-03f, -1.22213818e-01f,
  -8.69775116e-02f, -1.80119470e-01f, 1.81066826e-01f, 1.19283259e-01f, -2.76769921e-02f, -2.85296321e-01f, 1.02602780e-01f, 1.59297325e-02f, -8.89093354e-02f, -1.07037917e-01f,
  2.03571301e-02f, -8.27318281e-02f, 2.84543801e-02f, 5.38082682e-02f, 3.24210450e-02f, -9.40000545e-03f, 1.80914789e-01f, -1.19838797e-01f, 6.27069771e-02f, 2.66440678e-02f,
  -6.43872321e-02f, -1.82877973e-01f, 2.64238089e-01f, 1.21391803e-01f, -2.66946964e-02f, -6.95123002e-02f, 1.19453063e-02f, 3.33310738e-02f, 7.53839985e-02f, -1.44708619e-01f,
  1.65362120e-01f, 3.26177292e-02f, -2.72893190e-01f, -2.35438645e-01f, -2.83447206e-01f, 1.43891096e-01f, -3.94290000e-01f, 4.19543944e-02f, 5.05897105e-01f, 1.53761879e-01f,
  -8.06597546e-02f, 3.02636653e-01f, 1.50574803e-01f, 1.45473510e-01f, 1.89672057e-02f, -1.26119563e-02f, -1.46333978e-01f, 4.56442013e-02f, -1.54314414e-01f, 7.11909533e-02f,
  9.08575729e-02f, 7.29460095e-04f, 1.37338936e-01f, 1.45032257e-01f, -1.88080952e-01f, -2.76201755e-01f, -2.09306777e-01f, -2.15022475e-01f, 4.94586602e-02f, -2.86966383e-01f,
  -1.32747740e-01f, -2.71387368e-01f, 1.54838964e-01f, -8.12869817e-02f, -3.52012250e-03f, 9.52504203e-02f, -5.78109697e-02f, -1.53902724e-01f, 1.82165444e-01f, 2.41762817e-01f,
  -2.93202996e-01f, 6.93470463e-02f, 1.46856889e-01f, 1.92933515e-01f, -1.27580106e-01f, -1.17748762e-02f, 1.58661142e-01f, 3.45984161e-01f, 7.62671884e-03f, 2.30338890e-02f,
  -2.70842686e-02f, 9.92208067e-03f, 8.87935907e-02f, 5.53659461e-02f, 9.49603394e-02f, 1.51960179e-02f, -4.11217846e-02f, -2.71436274e-01f, 2.57395923e-01f, 1.00549743e-01f,
  -2.13789329e-01f, -1.03651404e-01f, 7.14370608e-02f, 6.41616806e-02f, 3.38383159e-03f, -1.03613816e-01f, 5.86188920e-02f, 2.47916132e-01f, 1.33545995e-01f, -6.39105514e-02f,
  1.98786929e-01f, 9.90353525e-02f, 3.40412855e-02f, 1.68806165e-01f, 1.69469267e-01f, 4.06386610e-03f, 3.63842517e-01f, -1.33434638e-01f, 1.54554352e-01f, 2.40156129e-01f,
  -3.10750324e-02f, -2.48469204e-01f, -3.44308764e-01f, -7.84821957e-02f, 8.07380155e-02f, 1.04297496e-01f, -6.76221494e-03f, -7.58163854e-02f, -8.19669217e-02f, 1.21927485e-01f,
  -5.00204228e-02f, -2.34792233e-02f, -1.08706899e-01f, 7.19215348e-02f, 2.71539073e-02f, 2.43850611e-02f, 2.63407052e-01f, 8.01486522e-02f, -8.05865899e-02f, 1.59368128e-01f,
  2.83376902e-01f, 2.08234638e-01f, 2.47345507e-01f, -2.70723226e-03f, -2.98533235e-02f, 3.76451463e-02f, 4.88486178e-02f, 2.35226661e-01f, 1.94892034e-01f, 1.85462132e-01f,
  1.93416893e-01f, 1.35449395e-01f, 2.31066868e-02f, -5.73377386e-02f, 2.28556439e-01f, -1.08187934e-02f, -7.92405829e-02f, -2.47619897e-01f, 2.09156573e-01f, -1.06963344e-01f,
  -2.47436878e-03f, 7.83190355e-02f, -1.80463389e-01f, -9.33400020e-02f, 1.80992670e-02f, -1.46259874e-01f, 1.42495960e-01f, 7.90509805e-02f, 1.51162267e-01f, 1.45293280e-01f,
  2.40909591e-01f, 1.96015030e-01f, -2.17293296e-02f, 1.69194221e-01f, 1.56995445e-01f, 5.27247339e-02f, 1.96021572e-01f, 5.21477833e-02f, 3.34693715e-02f, 2.63527542e-01f,
  -7.16644339e-03f, -2.32791267e-02f, -4.34392020e-02f, 1.45407185e-01f, -2.46001154e-01f, -1.60951868e-01f, 4.45635408e-01f, 3.01495284e-01f, -6.21280037e-02f, -2.38614097e-01f,
  8.85225981e-02f, 3.67190167e-02f, 1.90549567e-01f, 5.12256324e-02f, 9.34230089e-02f, 1.80636659e-01f, -1.07781276e-01f, 5.20553477e-02f, -8.98865089e-02f, -9.67563242e-02f,
  -5.92491515e-02f, 1.23898938e-01f, -1.99550360e-01f, -2.38711946e-02f, 9.07278154e-03f, -1.16484411e-01f, -2.00427771e-01f, 5.48543176e-03f, 2.18346596e-01f, -2.90546358e-01f,
  1.29128471e-02f, -2.07455501e-01f, 1.63987368e-01f, -1.51551768e-01f, -1.00588746e-01f, -6.09529950e-02f, -1.39517233e-01f, -2.62771584e-02f, -4.53394093e-03f, -1.96683019e-01f,
  4.61021885e-02f, -2.10004076e-01f, -2.62134701e-01f, 2.24015340e-01f, 1.96665362e-01f, 1.15656227e-01f, 4.79896255e-02f, -6.56101704e-02f, 7.15045929e-02f, 1.52964175e-01f,
  -5.41804060e-02f, -1.00343131e-01f, 8.49047899e-02f, 1.33492425e-01f, -2.14820430e-02f, -1.85161769e-01f, -2.01281738e-02f, 2.96672005e-02f, -5.84025234e-02f, 2.15079673e-02f,
  1.26752272e-01f, 1.63871139e-01f, 2.47729331e-01f, 2.13747337e-01f, 4.96793389e-02f, 4.95649427e-02f, -2.56642222e-01f, -5.73641546e-02f, -9.58605409e-02f, -8.62727407e-04f,
  5.93887046e-02f, -7.89442435e-02f, -4.72282842e-02f, -3.39798853e-02f, 1.88589454e-01f, 1.46449611e-01f, -4.46161330e-02f, -6.89881574e-03f, 3.03085417e-01f, 1.25827387e-01f,
  -2.12616161e-01f, 2.79441867e-02f, -3.19864899e-02f, -6.06553536e-03f, 1.78609803e-01f, 1.59876913e-01f, -1.85752153e-01f, -5.95466718e-02f, -2.09254753e-02f, -8.92776772e-02f,
  -8.72224718e-02f, 2.00030245e-02f, 2.46253818e-01f, 1.77457988e-01f, -8.31029285e-03f, 1.88373700e-01f, 3.54640275e-01f, -2.73598940e-03f, 1.02344319e-01f, 1.09995273e-03f,
  3.94616686e-02f, -2.98346281e-01f, 2.17271820e-02f, 2.96103936e-02f, 2.68584967e-01f, -1.32483646e-01f, -9.78622660e-02f, 1.70375645e-01f, 4.81588617e-02f, 2.14435495e-02f,
  -1.44853875e-01f, 5.48944343e-03f, -1.68379501e-01f, 6.71296492e-02f, -1.26039207e-01f, 8.05669948e-02f, 1.40746370e-01f, 1.16203971e-01f, -1.83238015e-01f, 1.16723582e-01f,
  1.53454825e-01f, -1.03983484e-01f, 1.37437597e-01f, 1.79861456e-01f, 1.79111511e-01f, -1.22337617e-01f, 1.56937644e-01f, 1.69569910e-01f, 1.13268659e-01f, -2.48315614e-02f,
  -2.26101741e-01f, 2.32679009e-01f, -3.48278433e-01f, -2.19395626e-02f, -9.15585365e-03f, -1.63968995e-01f, 1.10948302e-01f, -1.21753044e-01f, 3.46221924e-02f, -9.89946723e-02f,
  5.01604900e-02f, 1.80497035e-01f, 2.34278873e-01f, 2.35538334e-01f, -7.07299039e-02f, 1.34170940e-03f, 9.55654494e-03f, -3.99558023e-02f, 7.96844885e-02f, 8.93484876e-02f,
  7.50051066e-03f, 1.95975065e-01f, -4.15952988e-02f, -2.30504456e-03f, -2.02074766e-01f, 1.93660468e-01f, 6.20677955e-02f, -1.64610837e-02f, -1.68602452e-01f, -7.71690384e-02f,
  1.32012993e-01f, 6.96308538e-02f, 1.42905399e-01f, -3.53162810e-02f, -1.08183630e-01f, 5.75004928e-02f, 1.87362283e-02f, -9.53123197e-02f, 9.27088782e-02f, 1.20596789e-01f,
  -2.11100116e-01f, 1.46387503e-01f, -3.23775969e-02f, 2.28440315e-02f, 1.05395883e-01f, -5.39272502e-02f, 2.88418382e-02f, 7.17198178e-02f, -3.01152980e-03f, 1.12481387e-02f,
  -2.86926758e-02f, -1.32908151e-01f, 1.31542355e-01f, 1.87728077e-01f, -4.80034240e-02f, 4.41120416e-02f, -8.06994215e-02f, 2.11607218e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 52)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 52;
const float L3_fan_Bp_bar_data[] = {
  2.04443663e-01f, 1.46067575e-01f, 1.78677171e-01f, 1.61416054e-01f, 1.31998464e-01f, 8.21938217e-02f, 5.76889217e-02f, 1.07420854e-01f, -1.88689940e-02f, 1.14815801e-01f,
  -1.77209117e-02f, 5.66530153e-02f, 2.75754351e-02f, 2.42104143e-01f, 8.21908191e-02f, 5.78943007e-02f, 1.34663224e-01f, 1.22122273e-01f, 2.16422006e-02f, 5.70527045e-03f,
  4.47776504e-02f, 1.17466405e-01f, 7.86874890e-02f, 4.05732505e-02f, -1.51945651e-02f, 1.92213841e-02f, 2.04521477e-01f, 2.26390481e-01f, 1.18874520e-01f, 8.75900537e-02f,
  2.03597516e-01f, 8.90381187e-02f, -1.36998789e-02f, 3.41952480e-02f, 3.89056206e-02f, 3.22123878e-02f, 1.29186705e-01f, 1.38852984e-01f, 5.15449755e-02f, 8.05013478e-02f,
  2.17483997e-01f, -1.42729143e-02f, 2.15371344e-02f, -1.40378863e-01f, 1.67967230e-01f, 1.85570106e-01f, -1.62153706e-01f, 1.35576442e-01f, 9.43529084e-02f, 3.04303542e-02f,
  9.41991284e-02f, 2.26731673e-01f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  -1.98142290e-01f, -3.44400847e-04f, 7.66297504e-02f, -3.64953578e-02f, 4.41947617e-02f, -8.23997334e-02f, -4.17806357e-02f, -4.30890955e-02f, -4.73451391e-02f, -3.44335847e-02f,
  8.52660611e-02f, -6.02969825e-02f, -2.29213014e-01f, 1.83073338e-02f, -8.37080777e-02f, 2.50224490e-02f, 2.03628778e-01f, 1.09340236e-01f, 6.47831932e-02f, 1.32566959e-01f,
  5.98065220e-02f, -4.44374643e-02f, 4.78303954e-02f, -1.55652300e-01f, 1.01292416e-01f, -2.53574550e-01f, 1.96196854e-01f, -5.61695658e-02f, -2.73935199e-01f, 5.90483919e-02f,
  -1.99644715e-01f, -3.19225401e-01f, -1.92567706e-02f, -1.34666011e-01f, 1.55534282e-01f, 2.08020464e-01f, 1.09504737e-01f, 1.03512049e-01f, -2.81860441e-01f, -2.24997312e-01f,
  2.44799294e-02f, -2.23918650e-02f, -1.59845278e-01f, -1.15597688e-01f, -1.37194442e-02f, 1.13902390e-01f, 2.18536571e-01f, 1.29091546e-01f, 2.56484821e-02f, 1.96698874e-01f,
  -1.65334672e-01f, -4.65875641e-02f, -1.57203868e-01f, 1.76512495e-01f, -1.81167364e-01f, 4.42036316e-02f, -3.05650532e-01f, -2.66935199e-01f, 1.95441350e-01f, -9.13214907e-02f,
  1.29891694e-01f, -3.65896761e-01f, 1.00777317e-02f, -3.83425474e-01f, 6.05029017e-02f, 3.54809314e-02f, -1.57276303e-01f, -1.51424468e-01f, 3.83991115e-02f, 1.18859537e-01f,
  -1.18527442e-01f, -4.27716374e-02f, 2.28568330e-01f, -2.77796745e-01f, -1.55127883e-01f, 2.18308315e-01f, -2.56044537e-01f, -2.64539897e-01f, -6.51582778e-02f, -2.55808145e-01f,
  1.78705886e-01f, 2.81012412e-02f, -2.11629823e-01f, -2.50520796e-01f, -2.40638256e-01f, -1.92141727e-01f, -1.20281525e-01f, -6.93482608e-02f, -1.26351088e-01f, 1.52320072e-01f,
  2.42291003e-01f, 1.50765806e-01f, 2.22634792e-01f, -4.10355926e-02f, 1.81715433e-02f, 9.92251262e-02f, -2.34894633e-01f, -1.05905302e-01f, 1.71821825e-02f, -1.69480368e-01f,
  1.35324910e-01f, -5.81172369e-02f, 9.31922719e-02f, 8.97337794e-02f, -1.70369551e-01f, -3.72502208e-01f, 1.93485737e-01f, -3.74847353e-01f, -3.05493742e-01f, 1.66190222e-01f,
  8.92617106e-02f, -1.53419167e-01f, -3.26307416e-02f, -4.52817343e-02f, -1.14418352e-02f, -1.86080426e-01f, 1.56117693e-01f, -5.49050905e-02f, -6.18960299e-02f, -1.22260980e-01f,
  -1.55755550e-01f, -1.36566862e-01f, -2.83417881e-01f, 1.37569949e-01f, 1.73193187e-01f, 4.45990898e-02f, -2.58998454e-01f, 1.63652599e-02f, 2.24586308e-01f, 5.49433380e-02f,
  2.69820988e-01f, -9.77462232e-02f, 3.21069248e-02f, -4.71075550e-02f, -1.93975717e-01f, -1.10697761e-01f, -1.66986018e-01f, -1.45261467e-01f, 3.04556936e-01f, 3.03522348e-01f,
  -4.29339297e-02f, 1.62812427e-01f, -3.51613835e-02f, -4.16683912e-01f, 1.77208155e-01f, -4.44608718e-01f, -7.96310529e-02f, 2.54920483e-01f, 2.35760231e-02f, -5.16029214e-03f,
  -1.13950543e-01f, -2.38568604e-01f, -4.28272575e-01f, -2.81206787e-01f, -7.18825459e-02f, -8.67243931e-02f, 1.42902210e-01f, 1.70026422e-01f, -2.70652056e-01f, -2.07018316e-01f,
  -2.61806279e-01f, -1.30197018e-01f, -8.80714133e-02f, -2.05885485e-01f, -7.81776905e-02f, -6.98134527e-02f, -2.23066285e-01f, 3.34683545e-02f, -3.27110738e-01f, 1.74574345e-01f,
  -1.45463198e-01f, 3.43656242e-01f, -4.47358698e-01f, 3.80745567e-02f, 6.35875091e-02f, 1.30512431e-01f, -1.17593147e-01f, 2.58253694e-01f, 1.16904870e-01f, 1.82727635e-01f,
  1.93610951e-01f, -1.66744620e-01f, -6.68037161e-02f, -3.47854376e-01f, 1.50049523e-01f, 3.08409989e-01f, -3.19135308e-01f, 9.05589759e-02f, -8.53617340e-02f, 1.40632704e-01f,
  8.07832703e-02f, -1.43933296e-01f, -2.63147682e-01f, -1.18809573e-01f, -4.35008220e-02f, 1.22121178e-01f, 2.53467020e-02f, 3.72512303e-02f, 1.51337283e-02f, -9.12216082e-02f,
  4.88172693e-04f, 9.23019722e-02f, -6.87945634e-02f, -5.68393692e-02f, 4.79675643e-02f, -4.13631387e-02f, -1.83611810e-02f, 1.02385685e-01f, -1.03235424e-01f, 9.82401073e-02f,
  1.00095026e-01f, -2.10011732e-02f, 9.30109397e-02f, -1.43038509e-02f, 1.22522272e-01f, -1.50057018e-01f, -1.00383791e-03f, -3.97200465e-01f, 1.92947444e-02f, -2.02691033e-01f,
  -1.40564784e-01f, 4.34416905e-02f, -3.05518121e-01f, -6.24237470e-02f, -7.48137012e-02f, -2.04377130e-01f, -6.12888448e-02f, -1.38588697e-01f, 5.70759252e-02f, 7.22442046e-02f,
  -9.13668498e-02f, -2.47346312e-01f, -1.81133434e-01f, 4.31486964e-02f, -8.67641643e-02f, 2.18826666e-01f, 6.02291375e-02f, 1.08084425e-01f, 5.67281060e-03f, 5.96763864e-02f,
  -1.43675447e-01f, -1.31424973e-02f, 1.50401682e-01f, -1.98208746e-02f, -7.62944520e-02f, -2.09683314e-01f, 2.47307658e-01f, 1.29892126e-01f, 1.48006111e-01f, 5.82665466e-02f,
  1.40237018e-01f, -3.77256781e-01f, -2.46585339e-01f, 1.29631266e-01f, 9.70475283e-03f, -2.84377486e-02f, -1.64300010e-01f, -1.25334576e-01f, -4.42614220e-02f, 7.73440599e-02f,
  -1.73321947e-01f, 3.07811294e-02f, 6.97657615e-02f, -1.23697463e-02f, -1.26166135e-01f, 3.99438322e-01f, 1.16561174e-01f, -3.08821648e-01f, -2.41225734e-01f, 4.02907543e-02f,
  -2.40565374e-01f, 1.46604344e-01f, -2.18842849e-01f, 7.67263994e-02f, 1.30069703e-01f, 5.83730303e-02f, 8.11280981e-02f, -7.75577128e-02f, 1.24888316e-01f, -2.01446086e-01f,
  5.22048362e-02f, -4.75192852e-02f, -2.06013978e-01f, 1.78841725e-01f, 4.13378403e-02f, -3.07693511e-01f, 6.52402118e-02f, 3.20298187e-02f, 2.57388026e-01f, -1.40074492e-01f,
  1.16029359e-01f, 6.01311848e-02f, -5.26269618e-03f, -1.63330585e-01f, 4.15566796e-03f, -1.23864368e-01f, 1.67535886e-01f, 7.52850100e-02f, -6.14096001e-02f, -4.30497229e-01f,
  9.26910490e-02f, -1.37901798e-01f, 1.49441764e-01f, -5.80057725e-02f, -1.78495944e-01f, -2.45948941e-01f, 2.03198746e-01f, -2.53066719e-01f, -2.25372463e-01f, -1.17405370e-01f,
  -1.29097551e-01f, 2.99504735e-02f, 2.85521299e-02f, -1.07152857e-01f, 1.96986243e-01f, 1.57956794e-01f, 1.14729002e-01f, 1.04605772e-01f, 6.13397360e-02f, 1.08880349e-01f,
  2.75870800e-01f, 3.13873261e-01f, 2.14868054e-01f, 5.51444590e-02f, 1.51667997e-01f, -1.14266060e-01f, -2.01181564e-02f, -6.36704937e-02f, 1.61671460e-01f, -1.21113867e-01f,
  -1.80009797e-01f, 9.80288908e-02f, 5.91122173e-02f, -6.83939531e-02f, 1.52137950e-01f, 2.49683350e-01f, -9.56890360e-03f, 2.94201553e-01f, -6.95907921e-02f, 2.38749549e-01f,
  -1.91761062e-01f, 1.09094149e-02f, -9.66941193e-02f, 1.27497584e-01f, 1.99209228e-01f, 1.73674390e-01f, 1.34048432e-01f, -2.59281933e-01f, -2.95092672e-01f, -1.39463186e-01f,
  -7.82955810e-02f, 4.29624245e-02f, -1.46574080e-01f, -2.03311831e-01f, -1.00507416e-01f, 2.04860851e-01f, -9.59823281e-02f, -3.01337093e-01f, 1.62258267e-01f, -1.74381211e-01f,
  -2.65248358e-01f, 1.67106748e-01f, 1.94384381e-01f, -2.62783885e-01f, 8.87895674e-02f, -1.45412385e-01f, 1.49769364e-02f, -1.50001124e-01f, 1.45675400e-02f, -9.82589200e-02f,
  -3.65493000e-01f, 1.37909308e-01f, 7.56352022e-02f, -7.69952089e-02f, -2.66464408e-02f, -2.87606835e-01f, 1.43103570e-01f, -1.99754596e-01f, -6.89738691e-02f, 1.48185775e-01f,
  1.30473316e-01f, -1.88727602e-01f, 2.11442009e-01f, 1.27444550e-01f, 3.66755202e-02f, -8.73457715e-02f, 4.70623411e-02f, -2.39865333e-01f, 3.85885574e-02f, 2.71789450e-03f,
  -1.68907478e-01f, 2.79224694e-01f, -5.21107018e-02f, -8.52846205e-02f, 1.01623915e-01f, -7.58114830e-02f, -6.07602745e-02f, 1.64668024e-01f, 3.20639223e-01f, -2.32715998e-02f,
  -1.35615364e-01f, -2.14954726e-02f, 1.17540695e-01f, -7.41083324e-02f, -8.52598250e-02f, -8.99447724e-02f, -2.99028754e-01f, 6.32839426e-02f, -2.84898192e-01f, -5.77308424e-03f,
  -2.63224170e-03f, -3.41884971e-01f, 4.60047685e-02f, 4.50943373e-02f, -1.87266380e-01f, 2.23353609e-01f, -2.53806878e-02f, 2.27189422e-01f, -2.27083415e-01f, -3.12841460e-02f,
  -2.45013431e-01f, 2.09528536e-01f, -3.00762087e-01f, 9.96404961e-02f, 6.56049997e-02f, -4.50471900e-02f, -2.02178940e-01f, 5.10241017e-02f, 7.27422312e-02f, -2.86115080e-01f,
  -1.64891243e-01f, -2.88394749e-01f, 2.09440142e-01f, 2.21517503e-01f, -2.62585491e-01f, 2.50833452e-01f, 2.10842136e-02f, -1.06430247e-01f, 2.04505380e-02f, -1.19393051e-01f,
  -2.99908221e-01f, 1.07994014e-02f, 1.39613980e-02f, 1.32545710e-01f, -2.67871708e-01f, -1.39328524e-01f, 5.27601428e-02f, -6.87068999e-02f, -1.46655098e-01f, -5.57576027e-03f,
  -5.05185351e-02f, 3.96869108e-02f, -3.83907631e-02f, 2.29664352e-02f, 1.76901683e-01f, -8.10325742e-02f, -4.21236344e-02f, -4.63482551e-03f, -1.37755811e-01f, 2.10941136e-01f,
  -1.63399071e-01f, -1.57917216e-01f, -2.97019303e-01f, -3.06027532e-01f, -1.76401585e-01f, -2.47062430e-01f, 4.79128137e-02f, -1.02020495e-01f, 8.99679363e-02f, -6.10917388e-03f,
  -2.44171336e-01f, -2.88515508e-01f, 1.63582265e-01f, 9.43464860e-02f, -1.54402882e-01f, -1.01154782e-01f, 1.01997331e-01f, 6.60820305e-02f, -1.13153271e-01f, -1.56829562e-02f,
  -9.49810147e-02f, -1.25993863e-01f, 9.34867263e-02f, 2.21525505e-01f, -4.89784852e-02f, -4.94524315e-02f, -1.94168836e-01f, 9.32937767e-03f, -1.13782443e-01f, -3.15219998e-01f,
  -1.32838190e-01f, 1.94346875e-01f, -3.38269509e-02f, 3.60317566e-02f, -1.77133605e-01f, -4.19446409e-01f, -9.20676887e-02f, 4.59896475e-02f, -1.60241663e-01f, 6.84536397e-02f,
  2.09817905e-02f, -3.32570449e-02f, 2.12918088e-01f, 1.92884803e-01f, -2.60270953e-01f, 3.04811411e-02f, -1.07105814e-01f, 1.39864702e-02f, 5.84883839e-02f, -1.32647352e-02f,
  -3.07354867e-01f, 1.39084756e-01f, -7.66194388e-02f, -6.32506162e-02f, 1.04181767e-01f, 1.08764939e-01f, 1.01032406e-01f, 2.19799414e-01f, 3.20448667e-01f, 2.01865360e-01f,
  5.43872751e-02f, 2.78848022e-01f, 5.97906224e-02f, -7.44791254e-02f, 2.90857077e-01f, -2.70519536e-02f, 2.69485265e-01f, -1.90701187e-01f, -1.39133349e-01f, -3.61167550e-01f,
  -3.60824019e-01f, -1.46010801e-01f, -1.70743287e-01f, 2.73481578e-01f, -1.65488482e-01f, 3.75690944e-02f, 9.60642621e-02f, -3.13703045e-02f, -3.28176707e-01f, 1.00297242e-01f,
  2.44532339e-02f, -9.47584361e-02f, 9.45741162e-02f, 1.50180966e-01f, 8.88940617e-02f, -2.43813112e-01f, -1.97942942e-01f, -1.44433573e-01f, -1.48091167e-01f, 1.96693346e-01f,
  1.66401714e-01f, 5.63669093e-02f, -2.18097627e-01f, -3.30570370e-01f, 7.53805712e-02f, -1.00570302e-02f, -8.39347020e-02f, -7.17583522e-02f, -1.23619437e-01f, -3.08646530e-01f,
  -2.31164217e-01f, -1.43165654e-02f, -3.38625222e-01f, 2.44548365e-01f, 1.02189861e-01f, -7.87145868e-02f, -1.94138214e-01f, 2.30859727e-01f, 2.17417017e-01f, -7.46471435e-02f,
  2.13731490e-02f, 4.52259704e-02f, -2.60185331e-01f, -1.05789825e-02f, -3.05641353e-01f, 6.27264827e-02f, -8.22859704e-02f, 2.00963721e-01f, -1.85268193e-01f, 2.45094687e-01f,
  -1.08453892e-01f, 2.44504854e-01f, -1.38186842e-01f, 2.07545217e-02f, 1.19208843e-01f, -1.75380975e-01f, 2.30476614e-02f, -9.13165808e-02f, 1.11796044e-01f, 1.71863571e-01f,
  -5.20153418e-02f, -1.71496451e-01f, -3.14470798e-01f, -2.11423993e-01f, 4.22244295e-02f, -2.14647830e-01f, 1.71504039e-02f, -1.93541095e-01f, 2.94583458e-02f, 5.32020293e-02f,
  -1.72192696e-02f, 1.79925278e-01f, -1.26839638e-01f, -3.40121657e-01f, -1.91425040e-01f, 1.39750406e-01f, -1.40332520e-01f, -1.54004410e-01f, 1.82393014e-01f, 8.43710899e-02f,
  2.31793001e-01f, 2.65459120e-02f, -3.47885758e-01f, -3.62188935e-01f, -5.90681322e-02f, 1.19370259e-01f, 1.60591304e-01f, -5.04467487e-02f, -1.84263796e-01f, -4.61792536e-02f,
  -1.20425910e-01f, -2.38841295e-01f, -4.88101721e-01f, -1.46977589e-01f, 1.75647631e-01f, -9.79979709e-02f, 1.89596012e-01f, -3.04035217e-01f, 1.40958741e-01f, -4.02122214e-02f,
  1.77741926e-02f, -2.82284677e-01f, -8.55188668e-02f, 1.52855679e-01f, -2.08347604e-01f, -8.99676383e-02f, 4.36148047e-03f, 1.39519006e-01f, 2.40982279e-01f, 1.57957360e-01f,
  -2.83472836e-01f, -3.61137092e-03f, -1.52649745e-01f, 5.56079224e-02f, 1.06895401e-04f, -1.77230053e-02f, 1.53438121e-01f, 1.30265325e-01f, 1.60563394e-01f, 3.57621878e-01f,
  7.02667609e-02f, -2.66627133e-01f, 2.96484113e-01f, -1.95473894e-01f, -9.51817483e-02f, 1.38893589e-01f, 1.54148489e-01f, -2.63715446e-01f, -1.94223836e-01f, -4.29002987e-03f,
  -1.64843753e-01f, -2.08693102e-01f, -2.30473980e-01f, -1.04063645e-01f, -1.06472224e-01f, -4.37794179e-01f, 1.43312037e-01f, 6.82136193e-02f, -3.45135689e-01f, -9.31617990e-02f,
  3.22060227e-01f, -2.55074471e-01f, 9.00452361e-02f, -8.92507657e-02f, 2.39250138e-01f, -1.51002809e-01f, 7.82058686e-02f, -5.43702170e-02f, 1.37453675e-01f, -9.28401053e-02f,
  -1.71831980e-01f, -1.54106259e-01f, 4.72715907e-02f, 1.69179440e-02f, 2.87064821e-01f, 8.60021040e-02f, -2.10465059e-01f, -2.46311575e-01f, -3.25341821e-02f, -2.52190858e-01f,
  1.64921954e-02f, -3.00118476e-01f, -2.82435983e-01f, 6.93508536e-02f, -1.58864632e-01f, 3.45820934e-01f, 9.66166705e-02f, -5.26144952e-02f, -1.29943490e-02f, -5.24861515e-01f,
  1.70228407e-01f, -2.66484190e-02f, -3.38399976e-01f, -2.36087367e-01f, -4.59821671e-02f, -1.08726852e-01f, -1.36085972e-01f, 1.86684147e-01f, 5.39473668e-02f, -1.05866589e-01f,
  -1.40981138e-01f, 1.59174930e-02f, 1.03562936e-01f, 2.49451682e-01f, 1.70929775e-01f, 1.95032105e-01f, -2.42058739e-01f, -2.60399908e-01f, -2.48039305e-01f, -1.13590635e-01f,
  -2.18133301e-01f, -1.48435354e-01f, 9.62733999e-02f, -2.45950192e-01f, -3.12952280e-01f, 1.66756675e-01f, 8.59757960e-02f, 1.60117224e-01f, 1.89443484e-01f, 1.21106900e-01f,
  -7.20403530e-03f, 4.44060415e-02f, -1.83675513e-02f, 7.94964284e-02f, 1.09764189e-01f, -4.00339207e-03f, -8.92082080e-02f, 1.38571247e-01f, -3.22004735e-01f, -2.98767626e-01f,
  -2.34410495e-01f, 2.34216169e-01f, 1.75055429e-01f, 9.70833674e-02f, 1.87710285e-01f, 5.05115315e-02f, -1.71798140e-01f, 5.97694553e-02f, 8.23630113e-03f, -2.17923641e-01f,
  -3.05425495e-01f, -1.40383765e-01f, 9.37488452e-02f, -1.66184500e-01f, 3.24961126e-01f, 1.22287318e-01f, -2.50634551e-01f, 1.19827360e-01f, -2.77551085e-01f, -2.49103203e-01f,
  -2.83783108e-01f, -2.31277511e-01f, 3.99713293e-02f, -1.28525212e-01f, -1.49724424e-01f, -1.55662689e-02f, -2.54603010e-02f, 3.65758948e-02f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -5.12295105e-02f, -1.52408984e-02f, 1.41288317e-03f, -3.75372283e-02f, 3.66693065e-02f, 1.59089252e-01f, -9.95335430e-02f, -5.33897504e-02f, -7.86935911e-02f, 1.42139092e-01f,
  -3.51731740e-02f, -1.00102201e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    