/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.40412289e-01f, -1.34115247e-02f, -7.74694830e-02f, 1.60201013e-01f, -1.64956644e-01f, -2.12913170e-01f, -3.60435471e-02f, 4.19290327e-02f, 7.94058070e-02f, -2.31828988e-02f,
  -1.27753913e-01f, 2.01427918e-02f, -1.07901379e-01f, 7.56961852e-03f, -2.75324825e-02f, -6.04666173e-02f, 6.59384532e-03f, -9.43065342e-03f, -2.77338014e-03f, -1.43232197e-01f,
  -5.10924719e-02f, 1.12781644e-01f, 4.01284322e-02f, 1.10107273e-01f, 2.22953465e-02f, -3.33757065e-02f, 4.57042754e-02f, 3.68224271e-02f, -9.18224007e-02f, 1.23220019e-01f,
  -6.65841252e-02f, 2.35427506e-02f, -7.96688423e-02f, 7.11727589e-02f, 3.04879267e-02f, 1.54461682e-01f, 1.00051329e-01f, 6.52263388e-02f, -8.27889144e-02f, 8.68354440e-02f,
  -5.25981598e-02f, 5.18963374e-02f, 4.64643352e-02f, -5.92117608e-02f, 3.48256640e-02f, 3.94555787e-03f, -5.23518845e-02f, -5.34202978e-02f, -4.67788288e-03f, 2.66303979e-02f,
  -9.13840979e-02f, -3.41849737e-02f, -2.75920536e-02f, -1.47308797e-01f, -5.03834486e-02f, -8.98024067e-02f, -6.41588718e-02f, -3.94938737e-02f, -9.38393921e-02f, 1.40168607e-01f,
  8.11091345e-03f, 4.26020212e-02f, -4.60232310e-02f, -1.00970566e-01f, -8.16525891e-03f, 3.96924317e-02f, -1.65105965e-02f, -1.36993756e-03f, 3.82816792e-02f, -3.65557112e-02f,
  -2.97319703e-02f, -2.24629939e-02f, 2.85786465e-02f, 7.07373098e-02f, -4.35731076e-02f, -9.27543640e-03f, -1.00754909e-02f, 3.48611586e-02f, -6.39920458e-02f, 6.69269040e-02f,
  -3.88086699e-02f, -1.82836950e-02f, -2.52742264e-02f, 2.24003009e-02f, -4.04748842e-02f, -2.08532456e-02f, 7.67721534e-02f, -8.17340314e-02f, -2.28619520e-02f, -8.73262295e-04f,
  2.15390921e-01f, -2.10013092e-01f, 7.33008310e-02f, 2.26508360e-02f, 7.41444202e-03f, -8.99156332e-02f, 2.86181513e-02f, 1.08201418e-03f, 5.21811321e-02f, -4.26111035e-02f,
  1.13985734e-02f, 6.31333608e-03f, 1.16323359e-01f, 4.00156602e-02f, 3.28554981e-03f, -8.18309281e-03f, -1.63056999e-02f, -5.13772704e-02f, -7.35160485e-02f, -9.27145630e-02f,
  -4.28936295e-02f, 4.99232635e-02f, -1.37823401e-02f, -7.76777640e-02f, -1.61881912e-02f, 4.34724987e-02f, 1.14321969e-01f, -1.34494866e-03f, -5.78851765e-03f, 1.57334045e-01f,
  -1.18637286e-01f, -1.52721405e-01f, -2.65567726e-03f, 4.09152824e-03f, 9.93894786e-02f, 1.65917829e-01f, 1.02301165e-01f, -2.22130604e-02f, -8.98588896e-02f, -1.70494244e-01f,
  -1.35179654e-01f, 7.74245188e-02f, 1.12389199e-01f, 5.75111508e-02f, 3.67156230e-02f, 1.74314692e-03f, -1.16030045e-01f, 1.76624939e-01f, 1.77290186e-01f, 1.99670985e-01f,
  2.18988191e-02f, -4.13540863e-02f, 1.13356322e-01f, 1.06995441e-01f, -8.74088034e-02f, -1.48319383e-03f, -1.41704336e-01f, -9.36857983e-02f, 4.32719067e-02f, -2.86675513e-01f,
  4.92188223e-02f, 5.01763225e-02f, 7.42135495e-02f, 5.35612814e-02f, 2.46324074e-02f, -4.36067879e-02f, 1.32248253e-01f, 1.07783690e-01f, 3.76279615e-02f, -5.15371934e-02f,
  3.23197506e-02f, 4.78589013e-02f, 5.15099801e-02f, 5.60724996e-02f, 6.56181127e-02f, 1.15721740e-01f, 3.98168303e-02f, 3.73435840e-02f, 2.69620493e-02f, 1.03888391e-02f,
  -6.65269867e-02f, -3.87781300e-02f, 3.95299345e-02f, -1.07466035e-01f, 5.05295172e-02f, -3.94808920e-03f, -8.28982890e-02f, 2.85816006e-03f, -3.64483707e-03f, -1.16302237e-01f,
  -1.45520985e-01f, -4.22137119e-02f, -6.61758482e-02f, -8.67811441e-02f, -1.42256040e-02f, -6.25720173e-02f, -2.17019822e-02f, -1.27193499e-02f, 3.71178761e-02f, 3.74302231e-02f,
  5.24365604e-02f, 5.35552464e-02f, 3.28453593e-02f, -1.14693874e-02f, -4.98385960e-03f, -2.93346830e-02f, 2.97115650e-03f, -2.66609527e-03f, 5.85540608e-02f, 1.00611020e-02f,
  4.14414629e-02f, -3.48866172e-02f, 6.65376112e-02f, 3.61548215e-02f, 1.63957325e-03f, -2.10259277e-02f, 2.91799903e-02f, 4.15040506e-03f, -4.78125410e-03f, 2.98301894e-02f,
  8.50267708e-02f, 6.75284937e-02f, -1.07327737e-01f, 6.97456822e-02f, -3.74414027e-02f, 3.30917239e-02f, 2.17794012e-02f, 4.02965620e-02f, -4.54377790e-04f, 2.44217254e-02f,
  5.11246286e-02f, 4.63496707e-02f, 6.97441632e-03f, -3.76731269e-02f, -1.19562191e-03f, 6.54376373e-02f, -9.52098370e-02f, 1.02181345e-01f, 7.08596557e-02f, -2.61904746e-02f,
  -1.05758183e-01f, -5.07985568e-03f, 6.90559372e-02f, -4.78343070e-02f, -4.76872362e-02f, 1.16010383e-02f, 9.71283987e-02f, 7.33129606e-02f, -1.60786361e-02f, -1.04869753e-01f,
  -2.47972846e-01f, -9.90232974e-02f, 4.70943376e-02f, -3.76110128e-03f, -2.17055380e-02f, 7.21086487e-02f, -5.30648082e-02f, 2.64915768e-02f, 2.81093754e-02f, -4.61684242e-02f,
  7.28372186e-02f, 1.00598566e-01f, 7.65185207e-02f, 3.21870409e-02f, 6.09519109e-02f, -6.24198467e-02f, -2.83868704e-02f, 2.39226781e-03f, -2.05388628e-02f, 1.31733656e-01f,
  6.84061646e-02f, 8.73249844e-02f, 1.74957588e-02f, 5.77776022e-02f, 9.96639859e-03f, 6.39077201e-02f, -3.89396958e-02f, -3.48045230e-02f, 1.06921762e-01f, -4.66158502e-02f,
  6.18903302e-02f, 2.90546212e-02f, -3.52171808e-02f, -6.28761724e-02f, 8.49022269e-02f, 1.86370593e-02f, 3.81017998e-02f, -1.16380595e-01f, -1.97598375e-02f, 4.85628136e-02f,
  6.19441122e-02f, -7.35609904e-02f, 1.66015290e-02f, 3.62621881e-02f, 5.48827574e-02f, -2.28297804e-02f, -4.67708968e-02f, -1.49380974e-03f, -8.08187015e-03f, -3.20628770e-02f,
  3.42375748e-02f, 1.43939881e-02f, -6.20055534e-02f, 1.39674973e-02f, 3.64726484e-02f, 2.15884093e-02f, -1.23309009e-02f, -3.70213315e-02f, 4.31933105e-02f, 3.78828272e-02f,
  -7.25416690e-02f, -1.28614172e-01f, -3.31890583e-02f, 1.12596480e-02f, 1.79131310e-02f, 4.01018001e-02f, -1.14691369e-02f, 8.36973786e-02f, 4.25313413e-02f, 4.62261997e-02f,
  -6.35355785e-02f, -3.49996649e-02f, 5.95817603e-02f, -3.42652388e-02f, 8.43259096e-02f, 4.55017053e-02f, 6.14882819e-02f, -3.13625392e-03f, 3.56359482e-02f, -2.33849455e-02f,
  -9.41896141e-02f, -4.64327447e-02f, -4.64628972e-02f, 3.76553424e-02f, -1.98644642e-02f, 2.74888370e-02f, 8.53939578e-02f, 2.05400996e-02f, -9.45695564e-02f, 3.69157791e-02f,
  -3.95797268e-02f, 4.06245068e-02f, 3.92821692e-02f, 7.57700112e-03f, 3.90911847e-02f, -6.27634972e-02f, 4.10910919e-02f, 1.95504355e-04f, 2.56512109e-02f, 7.65788853e-02f,
  -4.37182859e-02f, -3.82394008e-02f, -1.09135069e-01f, 7.18949735e-02f, -1.71989091e-02f, -1.76781253e-03f, 2.41174959e-02f, 4.11884896e-02f, -5.07478751e-02f, -1.01846391e-02f,
  9.12734587e-03f, 6.49705231e-02f, -2.24649236e-02f, -5.70031640e-04f, -4.11038147e-03f, -2.48601362e-02f, 7.86620528e-02f, -2.36527920e-02f, 2.62823757e-02f, -8.78222585e-02f,
  1.56092614e-01f, 6.24102056e-02f, -3.56079310e-01f, -6.95914924e-02f, -3.92577529e-01f, -3.12686294e-01f, -4.18212742e-01f, -8.43103975e-02f, 9.07321870e-02f, -6.12990744e-02f,
  5.17180772e-04f, 2.60554045e-01f, 3.21549296e-01f, 2.81271875e-01f, 1.17823124e-01f, -1.33658245e-01f, -2.16704860e-01f, 1.41520500e-01f, -1.54192653e-02f, -1.47525445e-01f,
  1.02887407e-01f, 2.74032522e-02f, 1.77624345e-01f, 9.20306370e-02f, -3.10677607e-02f, 1.87185392e-01f, -1.17492035e-01f, -8.65639746e-02f, 1.64223492e-01f, -4.44449522e-02f,
  -1.70455035e-02f, -1.81362331e-02f, -3.99903581e-03f, 7.21955150e-02f, -1.40747791e-02f, 4.86213788e-02f, 6.50816655e-04f, 4.60116006e-02f, 2.29282379e-02f, 1.43904714e-02f,
  -8.17032456e-02f, 8.42866302e-02f, 4.60351557e-02f, 5.95604181e-02f, -7.19774291e-02f, -7.82030672e-02f, 1.21285930e-01f, 5.72350621e-02f, 1.40773177e-01f, -7.37703368e-02f,
  6.55531064e-02f, -1.23314314e-01f, -1.70169756e-01f, -1.41462207e-01f, 1.46097420e-02f, -5.01810648e-02f, -4.98769395e-02f, -4.51624990e-02f, -8.94721299e-02f, 7.81552643e-02f,
  -3.90122943e-02f, 2.10296065e-02f, -4.16778140e-02f, -1.07633043e-02f, 4.54507023e-02f, -3.28914635e-03f, 1.66617204e-02f, 1.46445809e-02f, -1.10793211e-01f, 1.31592946e-02f,
  6.08773604e-02f, -4.83999727e-03f, -2.40788180e-02f, -4.86826487e-02f, -3.85797918e-02f, -3.09948325e-02f, 1.65025785e-03f, 3.70030059e-03f, -5.55346385e-02f, 5.80347367e-02f,
  7.80474618e-02f, -3.99327539e-02f, -5.06292358e-02f, 1.05746031e-01f, -1.65795628e-02f, 5.60397990e-02f, 8.83845985e-03f, 2.58310679e-02f, 1.42602250e-02f, -2.33277287e-02f,
  1.62846982e-01f, -9.95792225e-02f, 1.06312834e-01f, 2.12475192e-02f, -5.63234426e-02f, 9.90412906e-02f, -4.25756834e-02f, -7.94535968e-03f, -8.90337117e-03f, -1.42757818e-02f,
  -2.45840158e-02f, 4.03757058e-02f, 1.86768118e-02f, -7.18749240e-02f, -3.90601046e-02f, -1.12875767e-01f, 3.36996652e-02f, -3.14476853e-03f, 3.35071087e-02f, -2.12005023e-02f,
  2.56439336e-02f, 3.22725275e-03f, 7.39692822e-02f, 4.47369628e-02f, 2.46754475e-02f, 9.89291631e-03f, -1.74986422e-01f, -7.30087832e-02f, -5.25649786e-02f, 9.41992104e-02f,
  4.43071216e-01f, 1.77487746e-01f, 3.61849546e-01f, -1.49618924e-01f, -2.27320015e-01f, -7.62430429e-02f, 1.39122099e-01f, 1.80500839e-03f, -1.83812037e-01f, 6.94716573e-02f,
  8.80673062e-03f, -2.58607268e-01f, -2.91980729e-02f, -2.30741147e-02f, 2.36205623e-01f, 4.81217401e-03f, -3.62426788e-02f, -1.45808328e-02f, 8.21516141e-02f, -9.98803414e-03f,
  -2.45315433e-01f, 3.45065333e-02f, 2.21012935e-01f, -2.70335539e-03f, -1.13511123e-01f, -8.51216726e-03f, 8.85121971e-02f, 1.52327009e-02f, 6.71817660e-02f, -2.93854237e-01f,
  9.33614150e-02f, 1.19886845e-02f, -4.68953662e-02f, -3.34943272e-02f, 4.79451753e-03f, 3.67240421e-02f, -7.23006949e-02f, -8.40776972e-03f, 3.42308134e-02f, 1.73633918e-02f,
  -7.07834661e-02f, -2.82747820e-02f, -2.16170419e-02f, 8.68285075e-02f, 8.34745094e-02f, -4.21897415e-03f, -7.79667124e-03f, 1.06922708e-01f, 7.45882317e-02f, 4.34483178e-02f,
  -9.24680904e-02f, -1.53959051e-01f, 1.19154066e-01f, -7.52134807e-03f, 8.32304806e-02f, -9.58703384e-02f, -2.54127895e-03f, -2.94928974e-03f, 1.12719558e-01f, 3.30077000e-02f,
  1.92678813e-02f, -6.90859556e-02f, -3.04880980e-02f, 2.31457874e-02f, 6.21785857e-02f, -3.43639031e-02f, 2.29971576e-03f, 4.07746295e-03f, 1.06938963e-03f, 1.07853658e-01f,
  -7.09031224e-02f, 4.90961336e-02f, 2.41944529e-02f, -6.49766251e-02f, 3.86659205e-02f, 1.08057819e-01f, -9.19681638e-02f, -7.17445277e-03f, -2.89451554e-02f, -4.10483964e-02f,
  -1.16036227e-03f, 3.23595735e-03f, -3.00798193e-02f, -1.36941493e-01f, -6.62459433e-02f, 7.08783790e-03f, -7.69009441e-03f, 5.25312424e-02f, 7.26366267e-02f, -1.49350297e-02f,
  2.59849668e-01f, 2.79280776e-03f, 4.25132690e-03f, 7.14402422e-02f, -3.73319425e-02f, -1.27106354e-01f, -6.84094056e-03f, 2.11249664e-03f, -3.17919962e-02f, 4.67228517e-02f,
  4.31109816e-02f, 7.66773298e-02f, 2.66860481e-02f, -1.26281101e-02f, 6.86238334e-02f, 4.51360270e-02f, 6.82952926e-02f, -4.71341386e-02f, -1.31785452e-01f, -6.68893829e-02f,
  2.26257909e-02f, 9.82196033e-02f, 5.80565110e-02f, 6.47974461e-02f, -2.45348681e-02f, -2.37504374e-02f, 1.78857222e-01f, 5.38990572e-02f, 1.29163757e-01f, 4.52155203e-01f,
  -2.38793880e-01f, 4.72109839e-02f, -6.19999133e-02f, -1.60761759e-01f, -1.07361920e-01f, 9.48714837e-02f, -1.16269693e-01f, 1.10979199e-01f, -1.51099991e-02f, 5.00409231e-02f,
  9.11655948e-02f, 1.95891619e-01f, 1.14485152e-01f, 1.04508080e-01f, -2.43345276e-02f, -5.64640574e-02f, -1.62057906e-01f, -5.73519282e-02f, 1.19992800e-01f, 5.42856567e-02f,
  -9.63627361e-03f, -1.90278858e-01f, -1.16554014e-01f, -1.43390773e-02f, -5.53023107e-02f, -1.91337522e-02f, -1.27695352e-01f, -1.07507475e-01f, -4.07494344e-02f, -3.06653202e-01f,
  9.30903926e-02f, 6.92143152e-03f, -2.28324905e-02f, -1.65465800e-03f, -6.56217933e-02f, 7.78835043e-02f, 2.01382414e-02f, -8.94989893e-02f, 3.60214151e-02f, 1.13749743e-01f,
  -2.81465352e-02f, 5.58603518e-02f, 3.69413905e-02f, 1.31385550e-02f, 4.42414265e-03f, -6.25321222e-03f, -1.19831212e-01f, -1.23923369e-01f, -9.28903818e-02f, -3.05138584e-02f,
  -4.37149741e-02f, 1.44209927e-02f, -4.25869375e-02f, 2.35852338e-02f, 1.61902308e-02f, -3.54027115e-02f, -5.55896852e-03f, 9.33708996e-02f, 4.45860252e-02f, -5.47060557e-02f,
  2.71514640e-03f, 7.76159465e-02f, 5.21023609e-02f, 4.14707251e-02f, -4.22820449e-02f, 2.49659386e-03f, 7.50422478e-02f, -5.43304682e-02f, -2.05685049e-02f, -6.65528029e-02f,
  -4.99828048e-02f, -3.24321561e-03f, -2.77071372e-02f, 3.84141952e-02f, 4.58521955e-02f, -1.18517332e-01f, -5.91142615e-03f, 2.10474222e-03f, 3.18874605e-02f, -3.67496088e-02f,
  -7.13081807e-02f, -1.18919311e-03f, -6.05050894e-03f, 4.38460447e-02f, -4.54485044e-02f, -7.20661432e-02f, -8.80180486e-03f, 3.60194407e-02f, -1.95481330e-02f, -9.28767696e-02f,
  2.85215266e-02f, 1.61346886e-02f, -4.43124026e-03f, 1.28985094e-02f, 2.01721080e-02f, 9.02958810e-02f, -3.63348350e-02f, -3.75191458e-02f, 6.49557412e-02f, -3.71836834e-02f,
  9.03255399e-03f, -1.93871409e-02f, 3.51077914e-02f, 7.44479373e-02f, 5.75681329e-02f, -7.51946401e-03f, -4.07158621e-02f, 2.55377237e-02f, -2.21968051e-02f, 9.34913233e-02f,
  4.71524633e-02f, 3.38018276e-02f, -3.51079949e-03f, -2.14571226e-02f, -4.07099910e-02f, -3.53490040e-02f, 1.06762880e-02f, -2.62076817e-02f, 8.60458463e-02f, 5.23194447e-02f,
  -1.38897076e-01f, 1.18682859e-02f, -6.20806925e-02f, -2.57809069e-02f, 9.87593085e-02f, -6.53956831e-02f, -1.60345614e-01f, -6.22736476e-02f, 5.88842407e-02f, 6.16296846e-03f,
  4.48172651e-02f, 5.20006940e-03f, 1.60182435e-02f, 3.77146155e-02f, -2.42145583e-01f, -1.73711628e-01f, -7.13077635e-02f, -8.80078748e-02f, -8.27747285e-02f, 9.60755199e-02f,
  4.18000184e-02f, 1.61723979e-02f, -3.87591571e-02f, 2.39756424e-02f, 1.33701131e-01f, 8.37159008e-02f, 1.93887595e-02f, 1.10467762e-01f, -1.07944217e-02f, 1.55501077e-02f,
  8.87322947e-02f, 7.67501220e-02f, -6.71482533e-02f, -3.36245224e-02f, -8.13064817e-03f, -2.45701857e-02f, -5.12750447e-02f, -8.59653130e-02f, 4.58748452e-02f, 1.26101792e-01f,
  2.73369923e-02f, 5.21717370e-02f, 1.94026306e-02f, 3.22591257e-03f, 6.53936937e-02f, -6.88831881e-02f, -2.53616273e-02f, -9.81314629e-02f, 2.90803704e-02f, 6.02007173e-02f,
  -5.72849065e-02f, 1.38001386e-02f, 8.03713650e-02f, -1.29767451e-02f, -7.25397281e-03f, 2.14609187e-02f, 2.13407185e-02f, 5.28239608e-02f, -3.22736762e-02f, 8.58088508e-02f,
  3.24900672e-02f, 4.18122560e-02f, -7.79839754e-02f, -8.61365274e-02f, 2.00419240e-02f, -3.18269879e-02f, 1.13241643e-01f, 6.72906339e-02f, -4.60007377e-02f, -2.51848195e-02f,
  -5.52172251e-02f, 1.16699468e-02f, 5.94080724e-02f, -1.82480570e-02f, 8.30685943e-02f, 7.51158521e-02f, -2.84601282e-02f, 5.91828972e-02f, -5.23623750e-02f, 7.72941411e-02f,
  1.33792954e-02f, 7.67361894e-02f, 7.66156390e-02f, -3.31947692e-02f, -2.39531100e-02f, 1.35451229e-02f, 4.20811810e-02f, -9.17403251e-02f, 3.55032608e-02f, -7.05871824e-03f,
  -5.08598946e-02f, -4.06748094e-02f, 6.51663393e-02f, -1.95361804e-02f, -5.38756140e-02f, -7.33555853e-03f, 1.78148001e-02f, -7.32636824e-02f, 1.06429867e-01f, 5.24047911e-02f,
  6.92299157e-02f, 5.25207026e-03f, -5.76946214e-02f, -6.11529164e-02f, -9.27292742e-03f, -1.91768203e-02f, -8.55550021e-02f, -1.10609800e-01f, -2.41693705e-02f, 8.92331898e-02f,
  3.35686356e-02f, -3.10373269e-02f, -7.08948299e-02f, -1.02583982e-01f, 6.00427063e-03f, 1.45203378e-02f, 6.86667711e-02f, 9.09089670e-02f, -1.16837688e-01f, -1.65305436e-01f,
  6.41057670e-01f, -1.58023730e-01f, 2.54900232e-02f, 5.92983365e-02f, 6.68864995e-02f, 9.90976468e-02f, 8.54328722e-02f, 1.85818728e-02f, 6.49159253e-02f, -1.38196889e-02f,
  9.58259180e-02f, -2.25804776e-01f, -1.19907029e-01f, -2.44225115e-01f, 2.56592445e-02f, -1.86159834e-02f, -9.62016508e-02f, -7.95505419e-02f, 6.78465441e-02f, -2.47336365e-02f,
  -1.28279090e-01f, 3.77695896e-02f, 2.64622420e-01f, 2.18444794e-01f, -8.33879411e-02f, -5.59358969e-02f, 1.79536473e-02f, 4.38779183e-02f, 9.71544906e-03f, -3.38191539e-01f,
  1.93010822e-01f, 8.09434801e-02f, -1.72850356e-01f, -1.68673590e-01f, -8.41516703e-02f, -2.79463325e-02f, 7.07938299e-02f, -4.65740785e-02f, -2.76050214e-02f, 7.63422251e-02f,
  -3.30349989e-02f, -7.25295842e-02f, -8.92746970e-02f, -3.49639505e-02f, 7.12511018e-02f, 1.22761782e-02f, 7.90427104e-02f, -9.79001299e-02f, -8.00746009e-02f, 2.20291894e-02f,
  -9.88997817e-02f, 6.95596933e-02f, 1.11604586e-01f, -6.77833855e-02f, -3.18519808e-02f, -1.23943631e-02f, 5.81168719e-02f, 8.80060345e-03f, 3.66590731e-02f, 3.02111376e-02f,
  -1.74075048e-02f, 2.52539776e-02f, -1.62164718e-02f, 2.36341842e-02f, 1.14146611e-02f, 2.74443254e-02f, -7.58440644e-02f, 1.50665073e-02f, -3.88959795e-02f, 7.61033818e-02f,
  -2.42372677e-02f, 2.33429465e-02f, -8.23314860e-02f, 9.81620550e-02f, -1.12671359e-02f, -1.42652476e-02f, 1.84306987e-02f, 2.46526161e-03f, -5.05666155e-03f, 6.16182052e-02f,
  -9.05140489e-02f, -2.85154730e-02f, -3.31211388e-02f, -1.11376066e-02f, 1.39258355e-02f, -1.04691619e-02f, -4.79649082e-02f, -4.06345241e-02f, -3.58490422e-02f, -3.71809490e-02f,
  -1.17203616e-01f, -5.03966734e-02f, -3.97354923e-02f, -1.39330700e-01f, 1.08894065e-01f, -1.00007258e-01f, -5.96907102e-02f, -1.91655755e-02f, -1.28953066e-02f, 5.79390600e-02f,
  -6.81370795e-02f, 8.86958018e-02f, -6.84093218e-03f, 3.07355803e-02f, -8.86154845e-02f, -1.11112511e-02f, -5.39654829e-02f, 2.36863792e-02f, -6.03356361e-02f, 1.40092537e-01f,
  8.98793861e-02f, 7.75204897e-02f, 6.17669895e-02f, 4.03341092e-02f, -2.35257391e-02f, 2.96749864e-02f, -3.13587673e-02f, -3.58485617e-02f, 1.15278229e-01f, 1.08065933e-01f,
  2.59630591e-01f, -1.25127465e-01f, -1.21328048e-02f, 6.83364049e-02f, -1.62793435e-02f, -1.63793713e-01f, -1.00709215e-01f, -5.17352223e-02f, 2.09172759e-02f, 1.00072458e-01f,
  -1.42142057e-01f, 2.24875286e-02f, 4.94208932e-02f, -9.82035398e-02f, 1.59023120e-03f, 2.15374697e-02f, 4.37600054e-02f, 7.25441724e-02f, -4.03905027e-02f, -9.62752253e-02f,
  6.73888158e-03f, 6.53683916e-02f, 3.00054774e-02f, 9.67657641e-02f, 5.08887470e-02f, -2.17092130e-02f, 6.83066696e-02f, 4.77487408e-02f, -1.41092405e-01f, -3.06010302e-02f,
  1.64753627e-02f, -2.46097371e-02f, -2.78655868e-02f, -1.49171092e-02f, -2.43696682e-02f, 7.22231250e-03f, -8.27663168e-02f, 8.44347700e-02f, 7.18693621e-03f, -3.02168932e-02f,
  7.97735155e-02f, 5.31018153e-02f, 4.15462404e-02f, -3.17386352e-02f, -4.62232046e-02f, -9.68622882e-03f, 1.02524132e-01f, 8.16439465e-02f, 5.36744408e-02f, 4.97542471e-02f,
  -7.72391930e-02f, -9.01997462e-02f, 5.48136346e-02f, 2.94179544e-02f, 3.75892743e-02f, -5.67420982e-02f, -7.51501322e-02f, 1.65792499e-02f, -3.33922394e-02f, 3.58910449e-02f,
  -2.98753995e-02f, -1.53202834e-02f, -7.18842074e-02f, -1.24313459e-02f, 5.00788353e-02f, 6.02478199e-02f, -3.85196544e-02f, -6.70315756e-04f, 1.05997408e-02f, 5.74870221e-02f,
  -1.22701684e-02f, -3.58623303e-02f, -5.67011237e-02f, 8.72335136e-02f, 3.61187086e-02f, -3.65211703e-02f, 4.31724526e-02f, -8.49773958e-02f, 6.11205213e-02f, -2.01831968e-03f,
  -2.79292241e-02f, -1.47584770e-02f, 2.46678982e-02f, 5.66444080e-03f, -5.80993928e-02f, -3.99607830e-02f, 4.36639600e-02f, -9.33093391e-03f, -7.90226366e-03f, 5.71369231e-02f,
  1.32510588e-01f, -6.30335137e-02f, 9.95790809e-02f, 3.36859822e-02f, -3.20671387e-02f, -5.16717806e-02f, -6.85415044e-02f, -3.40057835e-02f, 3.99898626e-02f, 8.80176667e-03f,
  -6.61149621e-02f, 7.39588914e-03f, -3.14141512e-02f, -6.76282048e-02f, 3.56963798e-02f, 7.55363032e-02f, -3.23984995e-02f, 7.64735322e-03f, -8.51623490e-02f, 5.69298714e-02f,
  2.93407179e-02f, -5.94733190e-03f, 3.43645290e-02f, -3.83486114e-02f, 1.79807562e-03f, -3.85311693e-02f, 2.42878199e-02f, 4.51643951e-02f, 1.71105471e-02f, 1.49578631e-01f,
  -2.07125157e-01f, -1.72981769e-01f, 7.49654472e-02f, -1.97630167e-01f, -5.66805750e-02f, 1.24149255e-01f, -9.92901474e-02f, 1.57036632e-01f, 6.60342425e-02f, -1.61671072e-01f,
  -5.07820062e-02f, 8.59052613e-02f, 8.14203024e-02f, 2.18814269e-01f, 1.60033822e-01f, 3.84969190e-02f, -1.76975787e-01f, 1.33710369e-01f, 2.73179978e-01f, 1.74997330e-01f,
  -2.78710946e-02f, -7.04042837e-02f, -7.27981329e-02f, 1.88422173e-01f, -1.64267644e-01f, 2.16010213e-01f, -1.14461295e-01f, -8.25873390e-02f, 9.19345245e-02f, -3.18126619e-01f,
  -1.37900397e-01f, -4.86201979e-02f, 1.04466900e-01f, -7.48976991e-02f, 3.51684391e-02f, -3.43395025e-03f, -4.22114320e-02f, 1.24805002e-02f, 2.31342111e-02f, 2.16701608e-02f,
  -1.23170994e-01f, 2.62739742e-03f, -1.03578471e-01f, -3.40356790e-02f, 4.44705263e-02f, 1.85549054e-02f, 4.40890715e-03f, 9.19239968e-02f, 6.44866526e-02f, 7.00967461e-02f,
  -4.53937873e-02f, -1.73499078e-01f, 3.45396958e-02f, 6.09247051e-02f, 4.30354774e-02f, 1.02528960e-01f, 6.20846525e-02f, -9.57435369e-02f, 4.01063412e-02f, -1.23147286e-01f,
  8.34016427e-02f, -1.81518681e-02f, -1.52217755e-02f, -3.03694867e-02f, -6.14826195e-02f, 2.36847065e-02f, -5.32096289e-02f, 1.92254726e-02f, 1.40805170e-02f, -2.97459029e-02f,
  5.62702045e-02f, -4.56132628e-02f, 2.74509676e-02f, 9.22882855e-02f, 3.33247939e-03f, -9.42421705e-02f, 8.99167266e-03f, -1.92208700e-02f, -2.56230757e-02f, -3.46648060e-02f,
  4.80693504e-02f, 3.19341347e-02f, -4.94871512e-02f, 3.35296616e-02f, -9.42424387e-02f, 2.42222939e-02f, -8.26236978e-02f, -1.03114517e-02f, -4.71035205e-03f, 2.81002950e-02f,
  -1.05030470e-01f, 1.00817032e-01f, -7.79343024e-02f, -1.81073062e-02f, -5.33855706e-03f, -5.45304865e-02f, -1.20190382e-01f, -3.05976253e-02f, -7.09856078e-02f, -6.11212216e-02f,
  3.83276306e-02f, -2.62002870e-02f, 3.55835282e-03f, -1.41956313e-02f, 1.95859447e-02f, 5.26891183e-03f, -3.42689790e-02f, -2.57427096e-02f, -3.09183747e-02f, -1.14089362e-01f,
  -5.28219007e-02f, 2.71531455e-02f, 4.17537540e-02f, -9.18044802e-03f, -1.09532960e-01f, 1.41776484e-02f, 4.75104377e-02f, -9.13421158e-03f, 5.56455255e-02f, 4.61706556e-02f,
  2.21644431e-01f, -2.27620572e-01f, -3.08240414e-01f, 4.63019349e-02f, 5.12852035e-02f, 1.48687020e-01f, 1.68087855e-01f, 1.21610589e-01f, 7.50394464e-02f, -6.36627078e-02f,
  -3.58254202e-02f, 3.35146883e-03f, 4.73843142e-02f, 3.25946547e-02f, 1.34630412e-01f, -2.37477887e-02f, -4.44776639e-02f, -4.53467146e-02f, 2.63590664e-01f, 1.96843758e-01f,
  2.07407642e-02f, -1.10979907e-01f, -1.08568676e-01f, -4.35201786e-02f, -1.23998635e-01f, 2.05235943e-01f, -1.12552986e-01f, -2.72064239e-01f, -9.89658311e-02f, -3.95190269e-01f,
  -4.77937981e-02f, -2.58945078e-01f, 8.15630183e-02f, 7.77499601e-02f, -8.46076384e-02f, 4.03818563e-02f, 2.84427702e-02f, -9.73045677e-02f, -8.76873285e-02f, -8.36313665e-02f,
  -2.11733077e-02f, 5.46023669e-03f, 9.59896948e-03f, -4.40460555e-02f, -5.92505839e-03f, 4.24948744e-02f, -1.04899786e-01f, -4.05918360e-02f, -2.78022438e-02f, 1.94444191e-02f,
  5.05046621e-02f, -1.16757661e-01f, -6.18404113e-02f, -1.04544871e-02f, 2.40610354e-02f, -5.52691072e-02f, 4.29185340e-03f, -1.47609219e-01f, -3.18721607e-02f, 3.42057608e-02f,
  4.34903726e-02f, -5.19252494e-02f, -1.28222900e-02f, -4.27942574e-02f, 4.45527881e-02f, -1.23794582e-02f, -2.82567572e-02f, -1.44679165e-02f, 4.43404205e-02f, -2.93132775e-02f,
  -1.06125679e-02f, 1.05244569e-01f, -1.90592688e-02f, 1.27424868e-02f, -1.30504032e-03f, -7.38251507e-02f, 4.15288657e-03f, 7.22878501e-02f, -4.95385267e-02f, 6.08413592e-02f,
  3.35364230e-02f, -8.90016854e-02f, 5.38987927e-02f, -4.51728236e-03f, -6.59443438e-02f, -8.54407847e-02f, 6.35853736e-03f, 2.28210632e-02f, 4.82281223e-02f, -9.07290075e-03f,
  2.62020797e-01f, -1.17533088e-01f, 1.26848936e-01f, 8.82097557e-02f, 2.52224188e-02f, 1.48914717e-02f, 8.15931649e-04f, -1.57918017e-02f, -5.79105653e-02f, 3.44055220e-02f,
  9.30727087e-03f, -4.37096283e-02f, -1.01159476e-02f, -1.48112152e-03f, 1.07184201e-01f, -9.83239384e-04f, 9.29999948e-02f, 8.73786509e-02f, 6.28141165e-02f, 5.72615825e-02f,
  4.90143374e-02f, 1.87673151e-01f, 1.64668307e-01f, 6.08635060e-02f, 6.05079941e-02f, 2.30134025e-01f, 1.42842203e-01f, 1.92109823e-01f, 1.48852199e-01f, 3.06212008e-01f,
  -4.40497696e-01f, 2.34893829e-01f, -3.29033285e-02f, -1.37995854e-01f, -1.43875033e-01f, -2.15992928e-01f, -2.82924592e-01f, -1.28485203e-01f, -2.85265278e-02f, -1.23183675e-01f,
  1.34563660e-02f, 1.22077279e-01f, 1.32470250e-01f, 1.79371700e-01f, -7.87543878e-02f, -1.54994309e-01f, -1.94365934e-01f, -3.49698216e-02f, -4.35739197e-02f, 9.15239081e-02f,
  1.03464149e-01f, 3.72291431e-02f, 9.47469547e-02f, 6.50037527e-02f, -7.26285158e-04f, 1.07812762e-01f, -2.45019849e-02f, 8.74859244e-02f, 1.94449425e-02f, 6.24142103e-02f,
  2.18015596e-01f, -1.39849618e-01f, -1.41330987e-01f, -6.24996098e-03f, -2.50123665e-02f, -1.19192928e-01f, 3.17918397e-02f, 5.06239906e-02f, 1.83068644e-02f, -2.22629998e-02f,
  2.08139922e-02f, 8.65836069e-02f, 1.07856253e-02f, 3.21438946e-02f, 5.89474030e-02f, -6.58851191e-02f, 3.81305777e-02f, 4.37300093e-02f, -5.59363998e-02f, 2.45720893e-02f,
  1.34947792e-01f, -2.33525154e-03f, 7.44826198e-02f, 6.41098693e-02f, -3.72620858e-02f, -3.87987420e-02f, 1.02499753e-01f, 3.69942226e-02f, -2.18477063e-02f, 1.40001163e-01f,
  2.18267441e-02f, 3.67136635e-02f, -8.37746337e-02f, -1.72202457e-02f, 3.09181469e-03f, 7.80112967e-02f, -4.27539833e-02f, 2.47413293e-02f, -5.24842087e-03f, 2.98421383e-02f,
  2.03641579e-02f, -5.14838398e-02f, 7.01661408e-02f, -5.65732718e-02f, 6.66743964e-02f, -2.50654528e-03f, -4.13983539e-02f, -4.83240903e-04f, -2.19359845e-02f, -4.81435806e-02f,
  -2.59920396e-02f, -2.09989529e-02f, -2.65967567e-02f, -3.90389226e-02f, -7.73308650e-02f, -3.75484638e-02f, 4.21143733e-02f, 4.39095758e-02f, 7.15805218e-02f, 2.55917311e-02f,
  2.89773881e-01f, -1.00282140e-01f, -4.74640951e-02f, 9.53666866e-02f, 7.11639076e-02f, -1.46415129e-01f, -7.73087963e-02f, -2.31470093e-02f, 1.95399560e-02f, 5.46960272e-02f,
  -1.08342776e-02f, 5.44846058e-02f, 4.77032587e-02f, 1.04239294e-02f, -1.19878575e-02f, -1.36267710e-02f, 8.37835521e-02f, -6.92495853e-02f, -3.54322493e-02f, 1.55786006e-03f,
  -1.05740968e-02f, -1.31345391e-02f, 5.74464798e-02f, 2.51567159e-02f, 6.54701665e-02f, -1.62216444e-02f, 5.26581034e-02f, 6.01753369e-02f, -8.52747336e-02f, 7.28926584e-02f,
  -1.79355234e-01f, 4.64604162e-02f, 1.08715788e-01f, -8.43008533e-02f, 1.37869999e-01f, 1.64766684e-02f, 4.93411534e-02f, -4.63155881e-02f, 6.41673952e-02f, -4.25109081e-02f,
  -3.55107374e-02f, 4.79114950e-02f, 4.39530127e-02f, -1.49299633e-02f, -3.42361145e-02f, -3.70453894e-02f, -6.93865716e-02f, -5.93990386e-02f, -2.61387229e-02f, 8.34772736e-02f,
  -2.34438963e-02f, -1.38781630e-02f, -7.69975707e-02f, -7.79966414e-02f, 2.32567210e-02f, -8.30236226e-02f, -5.78964166e-02f, 7.03195110e-02f, 9.06684250e-02f, 1.01460330e-01f,
  -1.31674767e-01f, -3.52186747e-02f, 6.41075149e-02f, -8.47668648e-02f, -5.21413833e-02f, -2.12613624e-02f, 5.28742112e-02f, -2.34822016e-02f, 2.94407140e-02f, -5.06161563e-02f,
  3.30450088e-02f, -2.67347973e-02f, -1.34253547e-01f, -9.36930552e-02f, 2.00384879e-03f, -3.44351418e-02f, 6.26572669e-02f, -7.15640634e-02f, -6.40166178e-02f, -2.10314873e-03f,
  3.09181157e-02f, 4.16998565e-02f, 5.83807677e-02f, -6.59376904e-02f, -5.68155572e-02f, 4.50511947e-02f, 5.62386252e-02f, 7.45330602e-02f, -1.47024598e-02f, 7.28414133e-02f,
  4.82914317e-03f, -1.01358509e-02f, -5.59703857e-02f, -5.51606603e-02f, -7.25516584e-03f, 2.53687683e-03f, 6.22023479e-04f, -1.04838111e-01f, 5.04608713e-02f, 2.45955796e-03f,
  7.40205795e-02f, 1.88239996e-04f, 5.45375682e-02f, 7.31687099e-02f, -2.39195228e-02f, 7.40964413e-02f, 5.34140356e-02f, -3.83276008e-02f, 1.49297543e-04f, 6.56282306e-02f,
  -1.01613559e-01f, -6.86871335e-02f, -3.10122296e-02f, 3.53958085e-02f, 1.79583933e-02f, 2.46436354e-02f, -7.21316487e-02f, -6.97806999e-02f, 6.40974045e-02f, 7.60132596e-02f,
  -8.69879127e-02f, 2.39035580e-02f, -3.99642326e-02f, -7.71104917e-02f, -3.79821546e-02f, 2.60679703e-02f, -4.09169346e-02f, -3.32323126e-02f, 1.81775764e-02f, 1.41380494e-02f,
  -2.49005426e-02f, 4.32506278e-02f, -1.50474459e-02f, 5.19008487e-02f, 4.83609512e-02f, 3.21440659e-02f, 4.04397473e-02f, 1.69744156e-02f, 4.79006507e-02f, -3.62789705e-02f,
  5.96336760e-02f, 7.60840476e-02f, -7.52607733e-02f, -2.24781223e-02f, 3.17288153e-02f, -5.39146699e-02f, -7.99059048e-02f, 2.87248101e-02f, -5.98885119e-02f, -8.39970559e-02f,
  2.81652004e-01f, -2.32273601e-02f, -1.63576789e-02f, 8.64911154e-02f, 4.81633767e-02f, -1.43611044e-01f, -1.03803009e-01f, -2.22077981e-01f, -5.02973162e-02f, -7.07085580e-02f,
  -1.26437590e-01f, 1.78013742e-01f, 1.10014617e-01f, 2.38760076e-02f, 4.47605625e-02f, -1.75597407e-02f, 1.04214452e-01f, 2.39017949e-01f, 7.04512671e-02f, 1.21984981e-01f,
  6.01910688e-02f, 1.83714062e-01f, 1.67326599e-01f, 7.97316507e-02f, 6.69532120e-02f, 1.38458267e-01f, 7.86979869e-02f, 2.16068417e-01f, 1.33119583e-01f, 2.91472882e-01f,
  6.69504702e-02f, -5.57814017e-02f, -3.55049013e-03f, 1.52410850e-01f, 3.69286388e-02f, 1.74994227e-02f, 1.91256199e-02f, 9.34177339e-02f, 4.77475934e-02f, -3.76418158e-02f,
  1.28823102e-01f, -2.74493713e-02f, 1.15685552e-01f, 7.79784173e-02f, 9.54888314e-02f, -6.21920899e-02f, -2.30334029e-02f, 5.91109954e-02f, -8.42184424e-02f, -5.11788838e-02f,
  -5.98487630e-02f, 2.68172324e-02f, 5.62169142e-02f, -4.62826118e-02f, -1.04243532e-01f, -2.85905972e-03f, 4.03554961e-02f, 1.28310341e-02f, -2.09188852e-02f, 3.76750864e-02f,
  -3.88733228e-03f, -1.05685472e-01f, -8.89876485e-02f, 4.19394672e-03f, -2.55780835e-02f, -3.94353352e-04f, 7.82021880e-02f, 4.99858856e-02f, 1.77194551e-02f, -2.24605436e-03f,
  -5.49565852e-02f, -3.09681222e-02f, -5.43372631e-02f, 2.79487502e-02f, -9.45199877e-02f, 8.94377083e-02f, -4.49008755e-02f, -2.70366576e-02f, 4.21900442e-03f, 4.18084040e-02f,
  2.14103572e-02f, -2.35473365e-02f, -1.55597627e-02f, -2.16591265e-02f, -4.10290062e-02f, 6.31518709e-03f, 4.76111658e-02f, -6.25450835e-02f, 1.10671006e-03f, -8.05683620e-03f,
  -3.13314945e-02f, 1.06532397e-02f, 4.93882820e-02f, 1.88106094e-02f, 9.42456946e-02f, 9.81139857e-03f, -2.43814327e-02f, 6.32262835e-03f, 6.79405257e-02f, -6.79035261e-02f,
  1.76709741e-02f, -2.38529462e-02f, -6.84155058e-03f, -3.76564786e-02f, -6.27903491e-02f, 2.35181078e-02f, -4.21672054e-02f, 5.34697482e-03f, -2.30045989e-02f, -1.12329520e-01f,
  -8.94242153e-02f, 7.12138042e-03f, -1.44729670e-02f, -1.33678555e-01f, 3.24545987e-02f, 4.78238650e-02f, -9.32691153e-04f, 2.69317180e-02f, -2.50825807e-02f, -9.17157456e-02f,
  -5.23610376e-02f, -6.40595034e-02f, -1.36356130e-01f, 1.52199730e-01f, 1.41998097e-01f, -1.01331808e-02f, -1.24717869e-01f, 1.29123926e-01f, 8.23109448e-02f, -1.22256711e-01f,
  -8.99618119e-02f, 5.17988577e-02f, -6.29998669e-02f, -5.82188442e-02f, -6.37507066e-02f, -1.00902848e-01f, -1.97264478e-01f, -2.46966053e-02f, -5.59970662e-02f, 1.58023179e-01f,
  -4.50866483e-03f, -4.65414226e-02f, -5.99324936e-03f, 1.15374051e-01f, 1.76969878e-02f, -3.08834221e-02f, -8.98907632e-02f, 8.21342841e-02f, 4.66044508e-02f, -1.40110970e-01f,
  -1.79293051e-01f, -1.20181125e-02f, -1.37046371e-02f, -4.79411483e-02f, -1.66038629e-02f, 7.39532858e-02f, -1.88610237e-02f, 7.05120265e-02f, 3.12202517e-02f, -4.37871646e-03f,
  2.98566390e-02f, 7.74597749e-02f, -3.76097783e-02f, -6.43849932e-03f, -4.47752960e-02f, -3.59658189e-02f, -4.95273247e-02f, -1.22695537e-02f, -2.62677316e-02f, 6.25573099e-02f,
  -5.65822609e-02f, -1.09009128e-02f, -8.97226203e-03f, -4.97590601e-02f, -6.24944344e-02f, -1.72948614e-02f, 5.23605496e-02f, -2.82627810e-02f, 1.66334771e-02f, 6.47117803e-03f,
  -8.19075927e-02f, -7.32882414e-03f, 5.13755232e-02f, -2.65478678e-02f, -3.75106335e-02f, 9.46104601e-02f, -1.00725479e-01f, -7.53670111e-02f, 5.60352877e-02f, 1.66059472e-02f,
  4.82538017e-04f, -6.90583140e-02f, -6.94474503e-02f, 3.69558576e-03f, -3.32845317e-04f, -2.45117838e-03f, 4.09874953e-02f, 4.45715077e-02f, -7.13655427e-02f, 4.83854162e-03f,
  -8.65048636e-03f, 8.68490860e-02f, -8.96363109e-02f, 1.91540326e-04f, -9.82172880e-03f, -1.85239241e-02f, 6.98417425e-02f, 8.25500041e-02f, 9.52179208e-02f, 1.11465149e-01f,
  -2.81807445e-02f, -7.92815462e-02f, -2.72684135e-02f, -6.36585355e-02f, 3.27706710e-02f, -3.87181826e-02f, 4.50412072e-02f, -2.94332765e-02f, 2.20830254e-02f, -8.35546665e-03f,
  8.89359862e-02f, 2.41806284e-02f, 3.65253426e-02f, 5.44124749e-03f, -2.97773648e-02f, -2.73058116e-02f, -5.43901883e-02f, 1.57154202e-02f, 5.76613694e-02f, 1.37443572e-01f,
  8.77380967e-02f, 3.20520177e-02f, 2.44454443e-02f, -1.15341786e-02f, 1.24767289e-01f, -1.20253570e-03f, -7.43670389e-02f, -5.33130653e-02f, -5.94486147e-02f, 8.53831600e-03f,
  -1.25432014e-01f, -8.23887885e-02f, -2.61587828e-01f, -2.57191043e-02f, 4.94376495e-02f, 1.46252587e-01f, 1.19381703e-01f, 7.62692094e-02f, 8.82006139e-02f, -4.99045104e-02f,
  3.00499462e-02f, -6.69827536e-02f, -1.57974079e-01f, -1.00623980e-01f, -1.51993588e-01f, -1.60123780e-01f, -1.69270098e-01f, -1.99921042e-01f, -1.20396525e-01f, 1.48564041e-01f,
  1.40778735e-01f, 4.80272844e-02f, -1.30525678e-01f, -3.69960666e-02f, 1.73967987e-01f, -4.71967384e-02f, -1.81461588e-01f, -1.59107819e-02f, -1.38996527e-01f, -3.44437249e-02f,
  -2.32989579e-01f, 1.32951930e-01f, -7.93258175e-02f, -4.27868217e-02f, -7.41822720e-02f, -2.98829377e-02f, -1.50684699e-01f, -1.69531524e-03f, 1.65330190e-02f, -1.46471579e-02f,
  -1.72379129e-02f, 1.05282459e-02f, -2.59206034e-02f, 1.50928646e-02f, 5.68781747e-03f, -8.50992873e-02f, 5.50365262e-02f, -4.50502746e-02f, -6.08761190e-03f, -8.81284624e-02f,
  1.20670408e-01f, -2.24776706e-03f, -5.80511875e-02f, -2.11344808e-02f, 2.77809799e-02f, -6.74715191e-02f, 1.02380179e-02f, 2.27279868e-02f, 1.98661517e-02f, -5.90480007e-02f,
  -1.85814574e-02f, 4.52489629e-02f, -1.68026257e-02f, 4.14816029e-02f, 9.27258097e-03f, 1.82726979e-02f, -2.30302848e-03f, 4.19849046e-02f, -5.08719906e-02f, 1.58692431e-02f,
  5.54667879e-03f, 3.88131738e-02f, 7.15001971e-02f, -9.28622633e-02f, 4.94004749e-02f, 2.06579265e-04f, -4.50196043e-02f, -7.87284523e-02f, -1.22662999e-01f, 3.87518331e-02f,
  -8.22328962e-04f, 1.31741296e-02f, -2.89897900e-02f, -1.15099200e-03f, -8.50773975e-02f, 3.99313271e-02f, -5.80717623e-03f, 3.95103060e-02f, -2.62326356e-02f, 8.63141380e-03f,
  -1.56283304e-01f, -7.32484832e-02f, 4.38138563e-03f, 6.64656162e-02f, -7.27563053e-02f, -5.36297075e-03f, 1.10236472e-02f, -5.60805202e-02f, 7.27952123e-02f, 1.22974077e-02f,
  -1.31076602e-02f, 1.36506787e-04f, -1.48095459e-01f, -3.62609327e-02f, 4.69265953e-02f, 5.20755770e-03f, -4.56602089e-02f, -8.54843706e-02f, -1.36327893e-02f, 4.65009883e-02f,
  -1.34524748e-01f, -2.34973840e-02f, -1.63486704e-01f, -3.67419012e-02f, 4.62103859e-02f, -9.45453867e-02f, -1.03266016e-01f, -3.73002663e-02f, -1.25340119e-01f, -2.48309642e-01f,
  1.73820063e-01f, -6.47837818e-02f, -4.97713163e-02f, 3.58728669e-03f, 1.13772325e-01f, 1.65264860e-01f, 1.42547294e-01f, 5.02543226e-02f, -1.09041937e-01f, 2.70642973e-02f,
  8.28519091e-03f, -1.24797167e-03f, 6.05031066e-02f, -9.06038005e-03f, 1.43689528e-01f, 1.45208701e-01f, -6.71673715e-02f, 1.27493283e-02f, 1.93062127e-01f, 1.94602530e-03f,
  -8.92023295e-02f, -7.43246377e-02f, -3.02770250e-02f, -8.41490924e-02f, -1.88731268e-01f, 1.20768100e-02f, -1.06856927e-01f, -1.00938164e-01f, 1.08594835e-01f, -1.27537489e-01f,
  -1.36780426e-01f, -8.66316482e-02f, -3.06885317e-03f, 1.16269384e-02f, -4.45454866e-02f, -4.77704890e-02f, 9.75853577e-02f, -8.35078433e-02f, -9.28945839e-02f, 3.71645950e-02f,
  -1.62208267e-02f, -6.66911202e-03f, 4.50732894e-02f, -1.13482140e-01f, -5.02856933e-02f, -1.03008233e-01f, -6.31079823e-02f, -1.28143787e-01f, 3.25232260e-02f, -7.68829137e-03f,
  -7.59414807e-02f, -3.11577395e-02f, -7.67235681e-02f, 6.64819404e-03f, 4.53154258e-02f, 4.69687469e-02f, -1.21148139e-01f, -3.17719616e-02f, -4.57803644e-02f, -1.87318861e-01f,
  6.44299015e-02f, -1.90307703e-02f, -4.33150753e-02f, -3.84444259e-02f, 4.82140779e-02f, 4.19364721e-02f, -2.21137926e-02f, 5.99053875e-03f, -2.33180095e-02f, -1.59559189e-03f,
  -8.10974911e-02f, -7.13571757e-02f, 8.87485966e-03f, -4.41564200e-03f, -2.05280874e-02f, 7.84277990e-02f, 5.79884201e-02f, 5.32029904e-02f, -4.34118398e-02f, 3.72051112e-02f,
  -4.44976911e-02f, 9.58802551e-02f, -4.02275659e-02f, -2.59036422e-02f, 4.06420380e-02f, 4.23425958e-02f, -1.05751706e-02f, -2.49803904e-02f, 4.10884134e-02f, 8.55218992e-02f,
  -1.27019778e-01f, 1.28485411e-01f, -1.87660381e-02f, 4.62286659e-02f, 6.13491721e-02f, -9.30225663e-03f, 1.58973485e-02f, -3.11970282e-02f, 8.05168226e-02f, 5.36597259e-02f,
  1.49246037e-01f, -4.27810438e-02f, -8.67577493e-02f, -2.71934569e-02f, 3.54159772e-02f, -1.71346404e-02f, 4.10537496e-02f, 9.77770016e-02f, -3.63314687e-03f, 9.13885795e-03f,
  4.04767171e-02f, 8.25630352e-02f, -3.55426371e-02f, 6.00626022e-02f, -3.14332172e-03f, 7.16560185e-02f, 4.70985509e-02f, 3.07006873e-02f, 9.22893956e-02f, -1.10194050e-01f,
  1.01268522e-01f, 4.46908511e-02f, -3.51566225e-02f, 1.09746151e-01f, -2.51386613e-02f, 1.03009552e-01f, 2.17774376e-01f, -4.01601568e-02f, -2.51312573e-02f, 1.12864628e-01f,
  -6.01278022e-02f, -1.12666316e-01f, -1.08461663e-01f, -6.22797422e-02f, 2.72885561e-02f, 4.38448787e-02f, 1.41658336e-01f, 5.16056120e-02f, -1.60257414e-01f, -8.28420967e-02f,
  -5.73369786e-02f, 8.26545060e-02f, -1.18762255e-02f, -6.17782511e-02f, 3.66351791e-02f, -8.58622044e-02f, 7.86203071e-02f, 1.14019148e-01f, -4.91460264e-02f, 5.21252342e-02f,
  1.16590969e-02f, 6.36990368e-02f, -4.70592491e-02f, -8.08152650e-03f, 9.03655887e-02f, 2.87242094e-03f, 6.05646567e-03f, 4.22785878e-02f, 3.10005471e-02f, 5.94050363e-02f,
  3.09557957e-03f, -4.34802286e-02f, 1.70950498e-02f, -7.71315694e-02f, 9.41840261e-02f, 3.82147878e-02f, -8.30775946e-02f, -8.26498400e-03f, -2.49107927e-02f, -7.87750352e-03f,
  3.25360782e-02f, 2.57903303e-04f, -1.98578369e-02f, -1.76461060e-02f, -2.83561125e-02f, 5.44037409e-02f, -5.04641756e-02f, 9.69621986e-02f, 1.03931921e-02f, 1.87365599e-02f,
  -8.93500522e-02f, -7.37472717e-03f, -4.53918381e-03f, 1.00139752e-02f, -3.65253687e-02f, 1.38936378e-02f, 5.96428439e-02f, -4.10127034e-03f, 1.76709816e-02f, -9.91611555e-03f,
  3.96618024e-02f, -1.78811438e-02f, 5.28853871e-02f, 1.09977066e-03f, -5.33162057e-02f, -1.17344297e-02f, -4.93653789e-02f, 5.98382056e-02f, -4.34026122e-02f, 2.49932986e-02f,
  1.48487911e-02f, 1.86545271e-02f, 2.32600793e-02f, 7.02450201e-02f, 7.47129992e-02f, -7.30124265e-02f, -5.54198958e-02f, 2.33411063e-02f, -5.96590266e-02f, 1.09383449e-01f,
  -1.14211617e-02f, -1.38682887e-01f, -9.75593701e-02f, 3.18755186e-03f, -1.48817082e-03f, 4.36029993e-02f, -6.44130036e-02f, -4.02827784e-02f, 5.88417351e-02f, -5.23579940e-02f,
  1.75728444e-02f, -2.44617608e-04f, 5.32236509e-02f, 5.97755723e-02f, -5.46170957e-02f, 3.13316798e-03f, 3.11939828e-02f, -3.33139463e-03f, 7.98622370e-02f, -1.19840829e-02f,
  7.37919956e-02f, 1.50505118e-02f, -6.16486780e-02f, 3.18476856e-02f, -3.15384418e-02f, -4.01754910e-03f, 4.51615080e-03f, -6.69318289e-02f, 1.80513337e-02f, 8.16080905e-03f,
  3.35249782e-01f, -9.23540965e-02f, -1.42376885e-01f, 1.31467119e-01f, -2.02073380e-01f, -2.09918901e-01f, -3.11915427e-01f, -1.58956662e-01f, 1.29091516e-01f, -1.25889927e-01f,
  -1.40188500e-01f, 2.75234245e-02f, 6.86121881e-02f, -1.03161514e-01f, -9.06670541e-02f, -5.13899811e-02f, -1.05773248e-01f, -2.07150560e-02f, -8.12804550e-02f, -3.00915074e-02f,
  -5.06082997e-02f, 1.25387892e-01f, 1.14383034e-01f, 1.15649760e-01f, 4.72232588e-02f, -6.30547777e-02f, -1.06497146e-01f, -3.61838937e-02f, -6.72587706e-03f, 1.38558755e-02f,
  -1.19336180e-01f, 1.55060599e-02f, 9.40145738e-03f, 7.93812349e-02f, -7.05947950e-02f, 4.89246333e-03f, -7.12603033e-02f, 7.81809315e-02f, 5.87615408e-02f, 1.08636320e-02f,
  -9.72074792e-02f, -7.02624992e-02f, -6.17160313e-02f, -1.09399818e-01f, -1.60365794e-02f, 2.67735682e-02f, 3.33380587e-02f, 6.91098720e-02f, -5.20685278e-02f, -8.99065286e-02f,
  -7.48384297e-02f, 4.30350080e-02f, 7.23758363e-04f, 9.40382015e-03f, 5.17647788e-02f, -9.76603478e-03f, -8.70571509e-02f, -6.99773729e-02f, -6.56891316e-02f, 1.15548037e-01f,
  -6.39679749e-03f, 4.65149060e-02f, -8.69775563e-02f, 4.01386246e-03f, -2.38623675e-02f, -6.55731037e-02f, 4.63090055e-02f, -3.55804488e-02f, 4.81194258e-03f, 3.23729590e-02f,
  -6.95313811e-02f, 1.14078831e-03f, -6.22865148e-02f, -5.24208993e-02f, 1.23080416e-02f, -6.72389269e-02f, -5.31162433e-02f, 1.39742140e-02f, 1.01447709e-01f, 9.76794958e-02f,
  7.95210674e-02f, 5.61218709e-02f, 1.50669469e-02f, -6.55073971e-02f, -7.52677396e-02f, 9.18067023e-02f, -5.36950864e-02f, -3.83651331e-02f, 8.54827166e-02f, 1.01284496e-01f,
  1.34412855e-01f, -4.26540785e-02f, 1.19189575e-01f, 7.48896673e-02f, 1.52351499e-01f, 1.56790778e-01f, -2.36937348e-02f, 3.43605876e-02f, 3.79747599e-02f, -5.48046567e-02f,
  -6.33517951e-02f, -1.91281736e-02f, -3.69956307e-02f, -3.63966040e-02f, 1.16695492e-02f, 6.19054921e-02f, -3.34679373e-02f, -1.58490818e-02f, 7.52985030e-02f, 3.93834449e-02f,
  -1.91034414e-02f, 5.33278026e-02f, 1.21276174e-02f, 6.61669895e-02f, 6.60661887e-03f, 8.80161002e-02f, 5.56863435e-02f, -1.59103554e-02f, 1.92580291e-03f, 1.18796378e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.84245005e-01f, -1.02008805e-01f, 1.20465145e-01f, 1.61147729e-01f, 1.70380577e-01f, 1.24361403e-01f, -2.60672420e-02f, -1.03109702e-02f, 9.94313434e-02f, 1.00240014e-01f,
  1.15542933e-01f, 6.07851297e-02f, 4.95865755e-02f, 9.62351263e-02f, 7.57770427e-03f, -4.83521223e-02f, 6.02763258e-02f, -8.07079580e-03f, 1.16487205e-01f, 5.20926602e-02f,
  6.08475739e-03f, 1.36388307e-02f, -1.35500571e-02f, -2.15704162e-02f, -5.48257791e-02f, 1.39413655e-01f, -2.18518637e-02f, -1.36736304e-01f, -7.23318607e-02f, -1.02307260e-01f,
  4.99175079e-02f, -8.28101579e-03f, 1.58390015e-01f, 3.42605216e-03f, -2.69422699e-02f, 1.23174442e-02f, 3.86347882e-02f, -7.53164738e-02f, 6.67913556e-02f, 2.19016299e-02f,
  -8.99409503e-02f, -2.39852723e-02f, -2.04323847e-02f, 1.66179135e-03f, 4.85576466e-02f, 3.19726318e-02f, -1.17072761e-01f, 5.46741188e-02f, 5.50838821e-02f, 3.20265361e-04f,
  1.03348615e-02f, 5.98680638e-02f, 5.53451777e-02f, 8.46670717e-02f, -6.05030470e-02f, -3.04649435e-02f, 3.28026190e-02f, 3.01246494e-02f, -9.19408724e-03f, -5.35310134e-02f,
  -1.58446524e-02f, -4.67552729e-02f, 6.27030211e-04f, -4.61936258e-02f, -5.57984039e-02f, 1.03995807e-01f, 1.88302353e-03f, 6.95129931e-02f, -5.83658665e-02f, -1.05082393e-01f,
  -2.90435795e-02f, 1.09559685e-01f, 6.19068136e-03f, 4.21114564e-02f, 5.25242127e-02f, 4.55670878e-02f, -6.56540617e-02f, 4.90426086e-02f, -3.15623805e-02f, 4.94294893e-03f,
  -7.15660676e-02f, -3.30484882e-02f, -6.76032901e-03f, 4.52166237e-02f, 3.04584466e-02f, 1.93953570e-02f, 9.63133350e-02f, -1.62273385e-02f, -4.07391088e-03f, -5.76544963e-02f,
  3.98008339e-02f, 4.82609347e-02f, 1.28189683e-01f, -5.18271737e-02f, 2.36565107e-03f, -1.48012647e-02f, 6.90019038e-03f, -3.45975496e-02f, 1.95490513e-02f, 6.25173980e-03f,
  3.65160853e-02f, 6.92629442e-02f, -8.18566531e-02f, -3.84062193e-02f, 1.03612393e-01f, -4.50132824e-02f, 2.12797653e-02f, -3.18989232e-02f, 3.79359312e-02f, 5.54153174e-02f,
  -4.77443337e-02f, 6.46669641e-02f, 8.33880529e-02f, 8.69806185e-02f, -2.65818220e-02f, 4.50077318e-02f, 2.98930481e-02f, 2.30827229e-03f, 1.18026398e-01f, 5.26494384e-02f,
  1.36008382e-01f, 1.12656035e-01f, -5.26253618e-02f, 9.08878669e-02f, -3.61541919e-02f, -4.61596437e-02f, 7.23591819e-02f, 6.65900931e-02f, 1.97964758e-02f, 1.10293321e-01f,
  -5.52619696e-02f, 5.87748438e-02f, -3.12969945e-02f, -4.83964160e-02f, 2.38769762e-02f, 3.63344401e-02f, 4.88970950e-02f, -5.62823452e-02f, -4.51023597e-03f, -5.77058606e-02f,
  -1.37021681e-02f, 1.05394788e-01f, 6.04423098e-02f, -5.89356050e-02f, -6.87447563e-02f, 7.43469521e-02f, -6.94546103e-02f, 8.93475488e-02f, 2.04214230e-02f, -5.48479566e-03f,
  -4.16056179e-02f, 3.12943012e-02f, -3.66936587e-02f, 1.49089266e-02f, -6.03523292e-02f, 4.36477625e-04f, -2.82116625e-02f, 7.74086267e-02f, -3.31718549e-02f, 1.06081888e-01f,
  -5.31343482e-02f, 1.11026101e-01f, 6.67069405e-02f, 9.88015756e-02f, 6.82801008e-02f, -5.53216189e-02f, 7.11055240e-03f, 1.52522568e-02f, -3.25637273e-02f, -2.18884628e-02f,
  -5.97755201e-02f, -3.56458500e-02f, 3.72848623e-02f, -8.66760612e-02f, -6.17133975e-02f, 1.03898291e-02f, 7.12828338e-02f, 2.77893692e-02f, -7.39136711e-02f, 4.57292795e-02f,
  2.05192529e-02f, -3.51012945e-02f, -4.66222875e-02f, -2.30740514e-02f, -1.67437550e-02f, -1.54543566e-02f, -2.76398435e-02f, 1.25540607e-02f, -7.10299984e-02f, 3.63714658e-02f,
  3.52268526e-03f, -4.66919877e-02f, 5.29531799e-02f, -4.36250046e-02f, 1.51000917e-03f, -1.43978819e-02f, -1.42523097e-02f, -2.54995432e-02f, -6.45899177e-02f, -2.10629143e-02f,
  4.92810011e-02f, 4.24707010e-02f, -1.36667509e-02f, 4.73450720e-02f, 3.48967463e-02f, 1.79197509e-02f, -7.35301897e-03f, 2.83709671e-02f, 2.30366085e-03f, 4.28970903e-02f,
  -3.26074474e-03f, -5.76416310e-03f, -8.80310461e-02f, 9.04681608e-02f, 4.59260046e-02f, 4.50614206e-02f, 5.12290001e-02f, -4.51998413e-02f, 8.37637484e-03f, 4.69784923e-02f,
  8.37004781e-02f, -4.58519459e-02f, -3.40053849e-02f, -2.95267794e-02f, 3.80952209e-02f, 4.25482430e-02f, 7.03158900e-02f, 5.03720641e-02f, 7.51172900e-02f, -1.91022586e-02f,
  9.69450101e-02f, -4.56259996e-02f, -2.44009662e-02f, -1.97460204e-02f, -2.83704866e-02f, 8.80871564e-02f, 1.97181273e-02f, -1.99450497e-02f, -6.29670322e-02f, 8.95781629e-03f,
  -1.02489017e-01f, 1.46758392e-01f, -5.11482023e-02f, 4.21217531e-02f, 1.20580994e-01f, 6.14127666e-02f, 1.35943353e-01f, 2.03976825e-01f, 1.38651028e-01f, 1.03823267e-01f,
  1.78105533e-02f, 1.26956433e-01f, 6.75439090e-02f, 1.15641430e-01f, 1.70908004e-01f, 1.16618924e-01f, 1.09234676e-01f, -2.59268284e-03f, 7.92416111e-02f, 1.46519365e-02f,
  1.34618431e-02f, 2.53224783e-02f, 3.29417177e-02f, 9.64015201e-02f, 1.18926622e-01f, -4.65042703e-02f, 1.88644119e-02f, 3.87770869e-02f, 9.21815261e-03f, 1.31374151e-01f,
  -1.21597223e-01f, 8.79295766e-02f, -5.72029203e-02f, -8.47929996e-03f, 2.25223582e-02f, -2.12114640e-02f, -5.08785360e-02f, -6.66603521e-02f, -7.89596047e-03f, -2.92103123e-02f,
  9.33385193e-02f, -9.32968222e-03f, -4.56244238e-02f, -6.93201870e-02f, 2.74645053e-02f, -2.61049550e-02f, 4.30959314e-02f, 1.06559828e-01f, 7.77942780e-03f, -5.37518822e-02f,
  -1.44513911e-02f, -5.12850545e-02f, 1.62959415e-02f, 1.01279929e-01f, 1.55630440e-01f, 3.31315771e-02f, 4.27880138e-02f, 1.13836922e-01f, 1.22882444e-02f, 5.13934791e-02f,
  -7.79324844e-02f, -1.29351094e-02f, 1.53468959e-02f, -2.12495439e-02f, 9.77402180e-02f, -7.64918700e-02f, 5.11305816e-02f, -4.05813679e-02f, 4.34598513e-02f, -2.42981389e-02f,
  -9.00009796e-02f, -1.56536549e-02f, 6.28788322e-02f, 2.33714818e-03f, 1.27747031e-02f, 9.18874890e-02f, 4.88373861e-02f, 1.05635539e-01f, 1.80058777e-02f, -3.00339758e-02f,
  1.25885606e-01f, 2.44718511e-03f, 2.38650162e-02f, 1.27835363e-01f, 5.69057511e-03f, -9.44993459e-03f, -3.02702710e-02f, 1.61731578e-02f, -5.15429443e-03f, 3.15794833e-02f,
  1.01801977e-01f, 4.04771827e-02f, -5.34448624e-02f, -6.16537109e-02f, 2.09848098e-02f, 1.01134265e-02f, 8.84179920e-02f, 9.12857335e-03f, 4.72737439e-02f, 7.72818252e-02f,
  -5.21255396e-02f, 2.09728405e-02f, 5.86431182e-04f, -2.08613425e-02f, -1.20296022e-02f, -4.30987217e-02f, 2.09981073e-02f, -1.43703651e-02f, -5.44477860e-03f, -3.18575017e-02f,
  1.14950441e-01f, 1.36405183e-02f, 4.76788245e-02f, -3.31049748e-02f, -1.21952977e-03f, 4.82119359e-02f, 5.90150505e-02f, 3.92272882e-03f, -2.89837867e-02f, -6.65114745e-02f,
  8.31733495e-02f, -1.60037786e-01f, 7.62978643e-02f, -4.27290052e-02f, 1.89261250e-02f, 7.85767660e-02f, -4.36113626e-02f, 5.99906370e-02f, 8.50565732e-03f, -1.37202427e-01f,
  -1.15025632e-01f, 3.65037993e-02f, -3.58341001e-02f, 7.06244037e-02f, -6.05306961e-02f, 1.21121267e-02f, 2.33398806e-02f, 3.90243828e-02f, 1.11591503e-01f, 9.14544985e-02f,
  6.42556464e-03f, -1.02141565e-02f, -5.84206991e-02f, -9.27291811e-02f, -1.45137254e-02f, -6.38869479e-02f, 2.49825418e-02f, -2.64366921e-02f, 4.92835371e-03f, -1.45089701e-01f,
  -1.31277610e-02f, 2.40575224e-02f, 9.88679603e-02f, -2.67440621e-02f, 3.67290415e-02f, 8.17037001e-03f, -4.48643370e-03f, 5.44567108e-02f, 6.39059544e-02f, 8.58613476e-03f,
  4.45020683e-02f, 6.64209872e-02f, 3.71867865e-02f, -5.05883284e-02f, 1.11641333e-01f, -2.49630753e-02f, -5.76896034e-02f, -8.51792563e-03f, -7.73544610e-02f, -6.87236562e-02f,
  -1.92364752e-02f, -3.12844589e-02f, -2.82776877e-02f, -5.67421578e-02f, -1.09081361e-02f, 6.61963299e-02f, -1.91687346e-02f, 3.73479798e-02f, 2.98282076e-02f, -2.73277350e-02f,
  7.41391033e-02f, -6.99244663e-02f, 2.52397731e-02f, 4.11491096e-02f, 2.19153892e-02f, 8.02806467e-02f, 1.21304043e-01f, -1.99249797e-02f, 2.56532133e-02f, -1.13272436e-01f,
  -7.93470293e-02f, 2.62313578e-02f, -3.29719819e-02f, 4.54409830e-02f, 4.96046524e-03f, -9.07364190e-02f, 2.83693708e-02f, -1.00103568e-03f, -3.98886055e-02f, 2.05199160e-02f,
  1.29416073e-02f, -4.28469442e-02f, -2.33087875e-02f, -7.63408700e-03f, 2.49756705e-02f, -1.04054458e-01f, -7.66365975e-02f, 8.19006190e-03f, 1.40730701e-02f, -3.81992478e-03f,
  9.96388867e-02f, -2.63848621e-02f, 4.80700731e-02f, 8.31618160e-02f, 7.07994739e-04f, -7.07704276e-02f, 1.81002375e-02f, 4.27837297e-02f, 6.87568337e-02f, 5.65627441e-02f,
  -3.79666500e-02f, -2.78771240e-02f, 6.01952337e-02f, -4.40950021e-02f, 6.51150495e-02f, 7.14743286e-02f, -8.11967701e-02f, 2.77875680e-02f, -3.51531841e-02f, -3.35939303e-02f,
  -3.64001095e-02f, 1.66801378e-01f, 1.81713015e-01f, 3.10514960e-02f, 1.03751272e-02f, 1.29633561e-01f, -1.48521848e-02f, 9.33342203e-02f, 9.10767838e-02f, 8.78921673e-02f,
  8.88891518e-02f, -1.39310673e-01f, -5.33748902e-02f, -1.04477048e-01f, -4.27747183e-02f, -1.05500944e-01f, -8.48425329e-02f, -4.36810264e-03f, 3.85868945e-03f, -1.25212386e-01f,
  6.81335628e-02f, 4.44735251e-02f, -4.58751172e-02f, 1.07775450e-01f, 5.39921373e-02f, -1.22052751e-01f, -1.18158676e-01f, 2.21312279e-03f, -2.84844525e-02f, -7.89089873e-02f,
  -4.70433161e-02f, 3.89274321e-02f, -6.11783415e-02f, 9.30418149e-02f, -5.03502116e-02f, 7.99923316e-02f, -1.19993426e-01f, -1.30652308e-01f, 6.60574660e-02f, -8.54401849e-03f,
  -6.23836629e-02f, -6.07824400e-02f, -2.42131259e-02f, -3.46190631e-02f, -6.48077503e-02f, -4.09918390e-02f, -2.42808592e-02f, -3.94473113e-02f, -1.62972715e-02f, -9.78628919e-02f,
  1.51075562e-02f, -7.19239712e-02f, 3.63679416e-02f, 3.46623622e-02f, -9.63226333e-03f, -7.29611441e-02f, -5.74996769e-02f, 7.29775429e-02f, -3.38907577e-02f, -1.60604808e-02f,
  3.48607674e-02f, -2.58353422e-03f, 5.46387285e-02f, -9.54721496e-02f, 8.18846188e-03f, 9.86413751e-03f, -6.33740202e-02f, 5.16944528e-02f, -2.32838653e-02f, -5.88723756e-02f,
  -8.57927799e-02f, 9.62086171e-02f, 9.59362760e-02f, -4.43424433e-02f, 3.95303555e-02f, 2.52075549e-02f, 9.58853960e-03f, 4.84619699e-02f, 6.37982339e-02f, -8.95099789e-02f,
  -4.78212796e-02f, 8.76388699e-02f, 4.81993593e-02f, -5.85977100e-02f, 2.59152632e-02f, 2.09189188e-02f, -7.22746924e-02f, -3.85832065e-03f, -4.80185114e-02f, 5.32337986e-02f,
  -3.47696058e-02f, -4.91464511e-02f, -1.08102639e-03f, -3.11000179e-02f, 5.11635579e-02f, 1.72683168e-02f, 4.47453745e-02f, -1.29762487e-02f, -7.60383084e-02f, 5.03766127e-02f,
  9.13165286e-02f, 7.16484338e-02f, -6.54091910e-02f, 7.80366063e-02f, -3.34414877e-02f, 5.45298681e-02f, 7.14409724e-02f, 4.31004725e-02f, 1.30622443e-02f, -8.43204837e-03f,
  -1.99780613e-02f, 2.97991168e-02f, -5.80933243e-02f, -5.43168709e-02f, -2.97186431e-02f, -4.49502468e-03f, -3.97373363e-02f, 2.21618079e-03f, 6.18521012e-02f, -7.66067505e-02f,
  -3.63897905e-02f, -7.96211436e-02f, 3.58780250e-02f, 4.62663472e-02f, 7.02022314e-02f, 4.15915847e-02f, 2.92703826e-02f, 6.19205907e-02f, -3.15117948e-02f, -1.17225491e-01f,
  -3.07356358e-01f, 7.07236528e-02f, 1.08795930e-02f, -1.32457614e-01f, -6.40847161e-02f, 1.05986632e-01f, -3.61561477e-02f, -4.68967929e-02f, -5.64798824e-02f, -2.17422154e-02f,
  2.37666769e-03f, -3.91021520e-02f, -3.50883864e-02f, 4.66542803e-02f, 3.54968347e-02f, -1.13697238e-01f, -1.20484218e-01f, -1.69434667e-01f, -2.88577881e-02f, 1.01917863e-01f,
  -8.59889761e-02f, -1.71283320e-01f, -1.48735300e-01f, -4.96437261e-03f, -2.81633195e-02f, 1.60305668e-02f, 2.26618294e-02f, -2.34203096e-02f, 9.15734842e-02f, -2.23352723e-02f,
  1.55087650e-01f, -1.14677615e-01f, 3.26223671e-02f, 3.07241045e-02f, -2.12494005e-02f, -3.45672667e-02f, -3.31045478e-03f, 8.93717818e-03f, -6.30498827e-02f, -2.20813844e-02f,
  -6.46576881e-02f, -5.88407144e-02f, -5.95698245e-02f, 7.61261582e-02f, -7.29478300e-02f, -4.63090949e-02f, -6.94137439e-02f, -8.29749554e-02f, -7.88268745e-02f, -3.00099365e-02f,
  8.82964060e-02f, 2.66122408e-02f, 4.69120927e-02f, 1.11115389e-01f, 5.18314280e-02f, 1.11037248e-03f, 1.62357315e-01f, 1.18712895e-01f, 1.62926972e-01f, 1.80184469e-01f,
  -8.44779387e-02f, 4.00329642e-02f, 3.83755788e-02f, 5.95338875e-03f, -1.00228235e-01f, 1.58285331e-02f, -5.27132824e-02f, -2.59082615e-02f, 4.19462137e-02f, -3.82919349e-02f,
  6.37170821e-02f, -9.64291114e-03f, 2.79084011e-03f, -5.25162630e-02f, -7.33048096e-02f, 1.11094164e-02f, -5.21964170e-02f, -9.81551036e-03f, -9.83137637e-03f, 6.35184199e-02f,
  -1.09931035e-02f, 3.87499928e-02f, 2.99324468e-02f, -4.70974017e-03f, 7.73168206e-02f, -4.90567535e-02f, 2.98607200e-02f, -4.56857644e-02f, 2.22053789e-02f, -5.72179221e-02f,
  3.94703485e-02f, -5.80421090e-02f, -8.47415179e-02f, -6.07563779e-02f, 4.95244898e-02f, -4.16235030e-02f, 2.86304913e-02f, 2.03510225e-02f, -8.47149566e-02f, -1.04992772e-02f,
  8.88803974e-02f, 7.71368295e-02f, -1.72622874e-02f, 9.08695161e-02f, 1.89461522e-02f, -9.95242875e-03f, -1.04780344e-03f, -1.01271570e-01f, 4.48532328e-02f, -2.32871585e-02f,
  5.69344871e-02f, 2.19914224e-03f, 2.97963917e-02f, 2.40512118e-02f, 9.20708030e-02f, -3.48663740e-02f, 7.89046362e-02f, 1.29010037e-01f, 8.68754610e-02f, 5.22055477e-02f,
  -5.94050065e-02f, -7.40912035e-02f, -7.73846582e-02f, 1.01047292e-01f, 3.38975862e-02f, 3.52261402e-02f, -1.17774919e-01f, 4.91779745e-02f, 1.68921605e-01f, -3.50163281e-02f,
  -7.47978389e-02f, 7.54209841e-03f, -1.08700946e-01f, -1.18987024e-01f, -1.54798463e-01f, -7.60108232e-02f, -1.29799113e-01f, -3.49501409e-02f, -7.72521570e-02f, 2.34675799e-02f,
  5.51369376e-02f, 3.45535227e-03f, -2.22441964e-02f, -4.51688021e-02f, 6.23641014e-02f, -1.38627574e-01f, -4.95801084e-02f, -1.09282032e-01f, -1.59125268e-01f, -2.50886306e-02f,
  -3.08397785e-02f, 4.66322750e-02f, -6.02470264e-02f, -1.14511894e-02f, 6.87022507e-02f, -7.98358992e-02f, -4.46751490e-02f, -6.92030117e-02f, 1.35996774e-01f, -3.89756598e-02f,
  3.20880972e-02f, 1.18477747e-01f, -4.49555926e-03f, 9.74724814e-02f, -5.26731722e-02f, 4.37865555e-02f, 5.88013679e-02f, -5.61971515e-02f, -8.36658403e-02f, 5.10733225e-04f,
  5.97658120e-02f, -1.03942201e-01f, 1.46883354e-03f, -1.06616266e-01f, 2.55608894e-02f, -1.93614792e-02f, -1.14735849e-01f, 2.53557377e-02f, -2.24456079e-02f, -3.44228894e-02f,
  -5.07066473e-02f, -4.80718240e-02f, 7.27134272e-02f, 9.13414285e-02f, 4.54103723e-02f, -6.10147491e-02f, -3.62965614e-02f, -2.29963232e-02f, 2.33408138e-02f, 5.02942316e-02f,
  4.02432717e-02f, 3.48020457e-02f, 1.14868628e-02f, 3.77690084e-02f, -6.87870383e-02f, -2.27613151e-02f, 3.64533663e-02f, -1.30007759e-01f, -7.78946504e-02f, -2.34376080e-02f,
  3.11166272e-02f, -3.31878997e-02f, -3.36813703e-02f, -3.37496549e-02f, 1.75843686e-02f, 4.15422283e-02f, 1.13993883e-01f, 1.27814636e-02f, 5.95857017e-02f, 9.87164825e-02f,
  1.49537688e-02f, -1.95530578e-02f, -1.24462545e-02f, 5.38102649e-02f, 2.73775645e-02f, -6.16116934e-02f, -8.33468363e-02f, 4.06837650e-02f, -1.18646985e-02f, -1.47588290e-02f,
  -3.39697674e-02f, -1.97425429e-02f, -2.95666214e-02f, 2.61927824e-02f, 9.52145383e-02f, 2.19133925e-02f, -3.54986638e-02f, 4.57723625e-02f, 2.55974606e-02f, 1.01705916e-01f,
  -1.18002094e-01f, -4.64426205e-02f, -9.92892385e-02f, -1.27557412e-01f, -9.55181476e-03f, -1.44697860e-01f, -1.14358358e-01f, -1.31245568e-01f, -1.07318535e-01f, -7.52131194e-02f,
  1.39586598e-01f, -1.04100876e-01f, 6.19406030e-02f, 3.68581787e-02f, 9.74669456e-02f, 1.10598594e-01f, 3.20520289e-02f, -7.21127540e-02f, 5.82129769e-02f, -5.67963766e-03f,
  -7.32033178e-02f, 6.42405823e-03f, -2.68447809e-02f, -5.20545356e-02f, -3.03740390e-02f, -5.27485609e-02f, -5.34638800e-02f, 9.30150673e-02f, 1.49796739e-01f, 9.60955918e-02f,
  -6.53222278e-02f, 4.18818835e-03f, 7.23471493e-02f, -5.15507944e-02f, 1.87310949e-02f, 2.72126356e-03f, 2.42869724e-02f, 3.33998613e-02f, 2.12796479e-02f, -1.02591061e-03f,
  1.52717397e-01f, 1.62065148e-01f, 7.82623217e-02f, 8.54168087e-03f, 6.02842420e-02f, 6.21274337e-02f, -2.94102132e-02f, -3.56676877e-02f, 3.19997966e-02f, -5.63074313e-02f,
  -2.96786502e-02f, -9.69292447e-02f, 7.21460506e-02f, 5.58954291e-02f, 3.51483822e-02f, 4.58988845e-02f, -3.42640392e-02f, 4.63624932e-02f, 1.13498151e-01f, -5.01474664e-02f,
  -6.40152618e-02f, 4.97770868e-02f, 3.43326777e-02f, 8.81288797e-02f, 6.16846010e-02f, 1.41914830e-01f, 9.71811637e-02f, 1.59665439e-02f, -4.32634130e-02f, -7.84887820e-02f,
  5.76597229e-02f, 3.28331487e-03f, 1.10641472e-01f, -7.74832964e-02f, -6.63588718e-02f, -3.42025943e-02f, -3.35978270e-02f, 4.70905378e-02f, -7.29106665e-02f, -1.23862326e-01f,
  -4.18232335e-03f, -1.03391102e-02f, 8.65681004e-03f, 4.38825712e-02f, 4.67533879e-02f, 1.74462125e-02f, -6.08387962e-02f, -8.22602957e-02f, -6.30408153e-02f, -3.72708105e-02f,
  4.12479676e-02f, 3.01647708e-02f, 4.34885081e-03f, -7.13473000e-03f, -9.72091127e-03f, 6.80634826e-02f, -7.11402744e-02f, -3.06365415e-02f, -1.19918883e-02f, 4.72670943e-02f,
  -4.77284379e-02f, 1.34630248e-01f, -6.65979013e-02f, -6.40233308e-02f, 7.92221501e-02f, -5.25217988e-02f, -4.63552177e-02f, 7.45951310e-02f, -2.30422243e-02f, 1.50734847e-02f,
  4.64348346e-02f, 4.25662510e-02f, 4.85484228e-02f, -1.60388295e-02f, 3.25537361e-02f, 4.52236123e-02f, -1.50841668e-01f, 2.05273144e-02f, 4.16122153e-02f, -5.81418239e-02f,
  -4.52877767e-02f, 4.80688214e-02f, 4.58050668e-02f, -1.62758343e-02f, 5.60018308e-02f, -2.47443728e-02f, 5.54971769e-02f, 3.64860371e-02f, -1.98785751e-03f, 4.89780642e-02f,
  5.78684509e-02f, -5.45563921e-02f, -8.68731737e-02f, 3.77805196e-02f, 7.09183663e-02f, -5.18552773e-02f, 3.35511542e-03f, 3.51153724e-02f, -3.28655429e-02f, 3.88213375e-04f,
  -2.84841154e-02f, 8.82697478e-02f, -6.14019223e-02f, -8.45574588e-02f, 3.72889190e-04f, -1.25715375e-01f, -7.54997181e-03f, -4.24143597e-02f, -1.01719141e-01f, -9.05984268e-02f,
  -9.38616470e-02f, 8.57016724e-03f, 1.36303483e-02f, -2.85383221e-02f, -5.01017040e-03f, -9.60121527e-02f, 7.56704248e-04f, -4.31206543e-03f, -1.24342926e-01f, 1.15693863e-02f,
  -6.94969296e-02f, -6.16932660e-03f, 8.92566368e-02f, -6.93687564e-03f, -4.18292433e-02f, -3.00948173e-02f, 1.09476475e-02f, 1.47544891e-02f, 4.44787964e-02f, 5.43136634e-02f,
  -5.89923710e-02f, -6.68375120e-02f, 8.67659375e-02f, 9.02107283e-02f, 4.94943783e-02f, -6.82297796e-02f, 1.78455375e-02f, -1.00913066e-02f, -6.36832044e-02f, -6.99589700e-02f,
  -8.08045194e-02f, 4.34399880e-02f, -7.94550125e-03f, -2.37913020e-02f, 5.24507202e-02f, -6.83755055e-02f, -8.73639509e-02f, 1.41704800e-02f, -1.12789363e-01f, -1.51818749e-02f,
  4.27589901e-02f, -1.76770575e-02f, -1.06577761e-02f, 2.82133427e-02f, -7.77876377e-02f, -4.68598865e-02f, -2.13931426e-02f, -2.54740473e-03f, -1.63815578e-03f, -7.57829323e-02f,
  -3.33862528e-02f, 5.27816033e-03f, -7.42519051e-02f, 9.08797681e-02f, -2.16130018e-02f, -1.08694099e-01f, -7.46185333e-02f, -8.40810910e-02f, 2.18151473e-02f, -5.66935800e-02f,
  -5.02234362e-02f, 1.50559973e-02f, -6.51369318e-02f, -6.20556548e-02f, -7.96242580e-02f, -4.89430241e-02f, -1.32671535e-01f, -7.99377710e-02f, 2.14741565e-02f, -8.19062665e-02f,
  8.17108005e-02f, 1.52543169e-02f, -6.52804524e-02f, -5.23309782e-03f, -5.56718633e-02f, 9.43539366e-02f, 3.47881317e-02f, 1.47080747e-03f, 4.74400707e-02f, -8.42715949e-02f,
  -5.05261160e-02f, -2.60201171e-02f, 3.02542280e-03f, -5.37278410e-03f, -1.87891871e-02f, -3.13411281e-02f, -5.30566387e-02f, -1.79239400e-02f, -1.93596794e-03f, 7.72577673e-02f,
  4.46457900e-02f, -2.04765145e-02f, -7.23952577e-02f, -4.87692654e-02f, 5.70810623e-02f, 2.62804236e-03f, 4.95577417e-02f, -6.91708177e-02f, -5.50090782e-02f, -1.06461748e-01f,
  1.64486006e-01f, -9.23114344e-02f, -6.94811866e-02f, 2.40295194e-02f, -9.75140408e-02f, -6.07894994e-02f, 2.12934949e-02f, -6.28282316e-03f, -9.23862383e-02f, 5.93013503e-02f,
  7.72841973e-03f, 5.37670627e-02f, -5.12801856e-02f, 3.99594158e-02f, -4.69507761e-02f, 2.69446634e-02f, 7.13351890e-02f, -7.81050101e-02f, -8.20052437e-03f, -1.27152041e-01f,
  -2.13315636e-02f, -1.28739243e-02f, 3.74857858e-02f, -4.93318625e-02f, -1.33601785e-01f, 1.25117442e-02f, -9.14651603e-02f, -4.68550883e-02f, -9.34602991e-02f, 4.58529368e-02f,
  5.98042645e-02f, 8.25792551e-02f, -5.78777194e-02f, -3.20094787e-02f, -4.03421745e-02f, -2.57551558e-02f, 2.75453459e-02f, 4.99257781e-02f, 9.81660709e-02f, -4.87318970e-02f,
  -5.75500652e-02f, -4.75225262e-02f, 1.05689883e-01f, -1.31761869e-02f, 9.22044273e-03f, 2.76645403e-02f, -3.69522795e-02f, 6.87566176e-02f, 9.74958017e-02f, 6.92281201e-02f,
  1.34759620e-02f, -1.44957993e-02f, 8.03997293e-02f, 8.39480013e-02f, -6.31460249e-02f, -8.04276168e-02f, 8.47288594e-03f, 2.45374329e-02f, 8.02153349e-02f, -5.22307754e-02f,
  -7.59091601e-02f, 6.97643757e-02f, 2.90639065e-02f, -4.64598835e-02f, -3.20188468e-03f, -6.60842732e-02f, -5.94528392e-02f, 1.03179840e-02f, 1.84260833e-03f, 2.00740825e-02f,
  -1.73137467e-02f, -3.71098965e-02f, 3.16390321e-02f, 6.75469935e-02f, 7.60005563e-02f, 8.42321217e-02f, 1.72606017e-02f, 4.10350487e-02f, 1.41967321e-02f, -7.33096525e-02f,
  -5.10223880e-02f, -4.24203947e-02f, -3.60892829e-03f, 2.30762959e-02f, 2.81947404e-02f, -4.21617851e-02f, -3.37965018e-03f, -3.77472043e-02f, -3.68226767e-02f, -5.38505465e-02f,
  -3.84266712e-02f, 6.06644787e-02f, -1.27911260e-02f, 9.57849398e-02f, -7.32061118e-02f, -5.51103689e-02f, 7.60106444e-02f, 8.59242752e-02f, 8.08309019e-02f, 5.35830669e-02f,
  4.53020856e-02f, 1.16324671e-01f, 1.12586327e-01f, 9.23798680e-02f, -1.30329411e-02f, -8.38393793e-02f, -3.65921631e-02f, 2.24943180e-02f, 4.96346615e-02f, -2.96853371e-02f,
  -1.15278931e-02f, 6.39771819e-02f, 4.72045019e-02f, 5.28112240e-02f, -4.95635830e-02f, -4.61159721e-02f, 1.52382031e-02f, -6.17708713e-02f, 8.15235525e-02f, 7.22138211e-02f,
  -4.48527962e-01f, 7.03445226e-02f, -1.78713337e-01f, -4.26684134e-03f, 1.58988565e-01f, 7.64511004e-02f, 1.89824477e-01f, 1.10567823e-01f, -1.88730638e-02f, 1.05214633e-01f,
  -3.70776430e-02f, -2.48271786e-02f, 2.47031059e-02f, 1.02337666e-01f, 1.21300220e-01f, 1.31183103e-01f, 2.15605602e-01f, -7.97593072e-02f, -6.85392618e-02f, -8.70456025e-02f,
  6.90516755e-02f, -8.40185881e-02f, -2.11853698e-01f, -1.34769663e-01f, 3.77681106e-02f, 2.77604666e-02f, -7.56066814e-02f, 6.29753922e-04f, 2.43950803e-02f, 1.00578628e-01f,
  -8.40139315e-02f, -6.37788773e-02f, 5.80128990e-02f, -2.66522542e-02f, -5.12878858e-02f, -7.23941401e-02f, 4.42987261e-03f, -1.46237001e-01f, -8.30939114e-02f, -7.57452548e-02f,
  -2.16447953e-02f, 4.97284271e-02f, 7.37943649e-02f, -6.07213471e-03f, -4.20734808e-02f, -1.35975853e-01f, 6.01790985e-03f, -8.75220895e-02f, 4.60677184e-02f, -4.01398391e-02f,
  5.22142313e-02f, -7.91188031e-02f, -1.04081362e-01f, -6.91036601e-03f, 8.57949257e-02f, 3.68743613e-02f, 2.98601612e-02f, -9.02875960e-02f, -1.15809299e-01f, -6.73732534e-02f,
  5.76088438e-03f, 9.25605670e-02f, -5.93924932e-02f, -7.63288364e-02f, 8.55732188e-02f, 3.61404717e-02f, 3.05103380e-02f, -7.40266731e-03f, 5.88332340e-02f, -2.40751430e-02f,
  6.69090971e-02f, 6.73253229e-03f, -7.80403987e-02f, -1.02690384e-01f, -9.30419471e-03f, -1.30750276e-02f, -4.11935057e-03f, -3.86500396e-02f, -2.26786248e-02f, 2.91624200e-02f,
  4.43407483e-02f, -1.01802070e-02f, -7.58186877e-02f, 2.35152114e-02f, -4.16103043e-02f, -3.39049567e-03f, 1.52219590e-02f, -4.34590504e-02f, -1.57712977e-02f, 2.36166157e-02f,
  2.78650895e-02f, 1.17913954e-01f, 2.52596512e-02f, 9.54774320e-02f, -6.90994859e-02f, -5.81827089e-02f, -1.17462613e-01f, 4.19507995e-02f, 9.11340467e-04f, 1.00610254e-03f,
  6.13318048e-02f, -4.32406664e-02f, 4.71690334e-02f, 4.94003221e-02f, 2.39961855e-02f, -1.03407381e-02f, -3.59731577e-02f, 6.49599805e-02f, 6.10558987e-02f, -6.46003569e-03f,
  9.13510695e-02f, -7.50948712e-02f, -1.18548721e-01f, -3.55465002e-02f, 5.74097708e-02f, -9.98788178e-02f, -4.53399569e-02f, -6.49962649e-02f, 3.97787318e-02f, -9.66528356e-02f,
  -1.71450600e-01f, -5.48912510e-02f, -5.03423624e-02f, -6.80836365e-02f, 3.55281085e-02f, -6.47873059e-02f, -6.25656080e-03f, 9.27309413e-03f, 7.86679015e-02f, -1.71788663e-01f,
  -9.37544331e-02f, -6.55632243e-02f, -1.27077907e-01f, -5.08204139e-05f, -2.20431075e-01f, -1.72009155e-01f, -1.57316491e-01f, -2.56996453e-01f, -1.22249380e-01f, 9.41983014e-02f,
  -9.23945084e-02f, -1.76666323e-02f, -1.45970032e-01f, -6.22098101e-03f, 1.19429871e-01f, -1.83157325e-02f, 1.65076591e-02f, 1.48151033e-02f, 1.66242383e-02f, -2.35162992e-02f,
  -2.15356991e-01f, 1.08518213e-01f, 4.76444773e-02f, -2.11840775e-02f, -8.33176896e-02f, 3.84671465e-02f, -3.83710042e-02f, 5.65680787e-02f, 1.04140051e-01f, -4.58617955e-02f,
  -6.43328279e-02f, 7.97132254e-02f, 6.37467019e-03f, 1.20335314e-02f, 3.08608357e-02f, 3.20769250e-02f, 1.30856540e-02f, 7.45685101e-02f, -3.36469598e-02f, 7.80926421e-02f,
  -5.40764779e-02f, 2.76557822e-02f, -3.44560221e-02f, 1.18244588e-01f, 2.48943307e-02f, 2.95217484e-02f, 1.18483335e-01f, 1.77813321e-01f, 1.71085685e-01f, 1.81828793e-02f,
  7.60758854e-03f, -2.18878500e-03f, -5.73216528e-02f, 1.13874510e-01f, 3.65202464e-02f, -8.05674195e-02f, 7.46919140e-02f, -9.23995599e-02f, -4.62302305e-02f, 4.18346375e-02f,
  1.21973539e-02f, 3.07220072e-02f, 2.34209076e-02f, -4.62378338e-02f, -1.36264950e-01f, 4.59230617e-02f, -4.03110981e-02f, -1.09207794e-01f, -2.78591160e-02f, 3.01840641e-02f,
  -5.16375974e-02f, -7.69926533e-02f, 1.96328964e-02f, 7.05876648e-02f, -2.70595271e-02f, 7.63885602e-02f, -7.52627701e-02f, -3.65766622e-02f, -7.70316496e-02f, 4.25465591e-03f,
  -6.06509931e-02f, -4.41608243e-02f, -2.34026313e-02f, 8.55339244e-02f, -5.50834909e-02f, 6.50387183e-02f, -5.18841892e-02f, 6.38738871e-02f, 3.34171280e-02f, 6.01035953e-02f,
  -4.47427388e-03f, 7.18639493e-02f, -4.22546417e-02f, 1.32185081e-02f, 1.27821183e-03f, -1.55750737e-02f, 1.19529486e-01f, -3.83555256e-02f, -5.32872379e-02f, 3.68626183e-03f,
  -2.80026644e-02f, -1.20109089e-01f, -5.92742525e-02f, 1.03672696e-02f, 9.59011093e-02f, -1.19587025e-02f, 1.18952310e-02f, 2.73210593e-02f, -4.14176472e-02f, 9.57325567e-03f,
  -2.66201515e-02f, -9.12526157e-03f, 2.11090036e-02f, 1.21309869e-01f, -4.29963693e-02f, -1.03125751e-01f, -1.14476681e-01f, 1.99938901e-02f, -4.35871705e-02f, 1.07865810e-01f,
  1.82113778e-02f, 7.51155764e-02f, 4.29281034e-02f, 9.41089243e-02f, 4.78221476e-02f, -6.96370378e-02f, -1.00482576e-01f, -2.34011952e-02f, -7.87607357e-02f, 3.00072040e-02f,
  -6.48325980e-02f, 1.62257701e-02f, -1.98731273e-02f, 4.18305248e-02f, -3.63926180e-02f, 8.80594030e-02f, 7.68110678e-02f, -5.37461787e-02f, 9.66177583e-02f, 5.94297275e-02f,
  -6.42591938e-02f, -3.95651199e-02f, 5.62676750e-02f, 3.43268029e-02f, 2.59579252e-02f, -6.00744449e-02f, -8.57936293e-02f, 7.93848485e-02f, -4.82546762e-02f, -2.04653665e-02f,
  -1.67272519e-02f, 4.23994958e-02f, -2.55431631e-03f, -6.76107407e-02f, 1.60887148e-02f, -5.64426892e-02f, 4.43260111e-02f, 1.24388356e-02f, 3.55577506e-02f, -3.89663465e-02f,
  7.52536505e-02f, -4.37560007e-02f, 1.20493378e-02f, -4.35368903e-02f, 2.23381650e-02f, -1.62323993e-02f, 9.75715742e-02f, 2.85287332e-02f, 6.99378774e-02f, 1.40779838e-01f,
  7.32098818e-02f, 5.06874323e-02f, 8.95053148e-02f, 1.75003428e-02f, 7.28864893e-02f, 7.24577308e-02f, -3.91686112e-02f, -5.00644818e-02f, -1.93989929e-02f, 6.91201016e-02f,
  -5.25139049e-02f, 9.03599113e-02f, -3.68766189e-02f, 5.15873805e-02f, 1.02019235e-01f, -9.46733728e-03f, 9.55232680e-02f, 4.88797948e-02f, 9.95468497e-02f, 2.95521393e-02f,
  3.27804014e-02f, -1.17632337e-02f, 4.26550545e-02f, 2.00950596e-02f, 6.45369515e-02f, 3.90404761e-02f, -5.09224162e-02f, -4.51594740e-02f, 2.14011241e-02f, 8.59404653e-02f,
  5.99234402e-02f, -4.93018441e-02f, 1.62297506e-02f, 2.02810820e-02f, 4.92487699e-02f, -5.88557422e-02f, -1.77589618e-02f, 3.74442972e-02f, -2.32750573e-03f, 1.75387487e-02f,
  -4.88529317e-02f, 4.17452380e-02f, 3.03913448e-02f, -4.06407341e-02f, -2.79291562e-04f, 9.73514915e-02f, -2.39471421e-02f, 8.59043449e-02f, 6.48222342e-02f, 4.44423482e-02f,
  -3.84420156e-02f, 4.71653081e-02f, -3.63217411e-03f, 5.97451534e-03f, 1.84496660e-02f, -6.81573674e-02f, 2.44525578e-02f, 2.34174039e-02f, -2.69219205e-02f, 2.79580187e-02f,
  2.04242811e-01f, 1.91093951e-01f, 8.91561806e-02f, -3.81390564e-02f, -1.34102359e-01f, -2.30477806e-02f, 2.84641478e-02f, 4.58089635e-02f, -3.64930443e-02f, -5.54308183e-02f,
  -7.39558935e-02f, -8.02527145e-02f, 4.07981798e-02f, -2.09985841e-02f, 6.56218082e-02f, -5.98626852e-04f, 5.44153787e-02f, 1.63755879e-01f, -2.87244059e-02f, 3.62530164e-02f,
  -1.78295597e-02f, 1.31577209e-01f, 5.53060435e-02f, 1.04514338e-01f, 1.07770614e-01f, 4.41788463e-03f, 8.14049095e-02f, 4.48429771e-02f, -2.52453722e-02f, 8.04192796e-02f,
  1.65033713e-02f, 4.85247038e-02f, -6.09191544e-02f, -9.10251215e-02f, 1.10335454e-01f, 3.71055081e-02f, 7.99484178e-02f, 2.29067192e-03f, 2.95392368e-02f, 8.03809464e-02f,
  2.05988134e-03f, -2.59914100e-02f, -6.53030574e-02f, 1.18695706e-01f, -1.87161081e-02f, -3.07501815e-02f, 8.64711553e-02f, 1.05719052e-01f, 6.92227334e-02f, -4.05955687e-02f,
  6.96185529e-02f, -3.76186892e-02f, 1.05913840e-01f, 4.37858105e-02f, -2.09958721e-02f, 3.37110576e-03f, -7.50695765e-02f, 2.80683711e-02f, 4.45668548e-02f, 3.77277806e-02f,
  -2.26856470e-02f, -1.01293229e-01f, 3.28472396e-03f, 3.78252640e-02f, -4.59084809e-02f, -5.46446303e-03f, 4.69486639e-02f, -8.23974982e-03f, 2.29643639e-02f, -1.79966427e-02f,
  2.22262170e-04f, -5.32111377e-02f, -7.38402456e-02f, 5.96975759e-02f, -1.85563397e-02f, 9.29273218e-02f, 8.34410936e-02f, -1.38138896e-02f, 6.53933287e-02f, 5.16517460e-02f,
  -3.94961685e-02f, -8.23062062e-02f, 3.16239037e-02f, 8.99540037e-02f, 1.02411084e-01f, -3.21518891e-02f, -2.56093703e-02f, 3.46992421e-03f, 6.47196174e-02f, -3.37747373e-02f,
  -5.19625656e-02f, -2.98152845e-02f, -1.42669408e-02f, -4.16945107e-03f, 3.85622680e-02f, 7.56796077e-02f, -9.04047769e-03f, 2.02558786e-02f, -4.15920578e-02f, 4.35183980e-02f,
  -7.84958079e-02f, -5.98840751e-02f, -6.65461347e-02f, -3.75579856e-02f, -3.18081044e-02f, -2.48180106e-02f, -4.45770659e-02f, 7.83928409e-02f, -5.53197190e-02f, 2.08932944e-02f,
  7.14632571e-02f, -2.79734302e-02f, -2.23284643e-02f, -1.13262542e-01f, 1.20460440e-03f, -7.96296597e-02f, -8.17818940e-02f, -3.04040103e-03f, -9.73178595e-02f, -3.27768438e-02f,
  -7.85691142e-02f, -7.79152811e-02f, 7.10964575e-03f, 1.00848310e-01f, 7.15634525e-02f, 1.00269439e-02f, -8.59143808e-02f, -3.26564647e-02f, -3.97192091e-02f, -1.38289034e-02f,
  4.22868691e-03f, 9.26130116e-02f, -4.82554659e-02f, -6.00845665e-02f, -4.48988676e-02f, -9.54518393e-02f, -2.09349282e-02f, -7.59259239e-02f, -4.09660451e-02f, 2.32797731e-02f,
  -8.52434337e-02f, -5.93415760e-02f, -6.11408502e-02f, 9.73239820e-03f, -3.66785340e-02f, 6.33476377e-02f, -9.70909074e-02f, -1.03744969e-01f, -1.38025759e-02f, -6.58594072e-02f,
  1.64341889e-02f, -4.12802286e-02f, 3.71960141e-02f, 4.20601778e-02f, 2.05057617e-02f, -8.62808153e-02f, 7.14193359e-02f, -6.97882026e-02f, -2.91247927e-02f, -1.09850802e-01f,
  -9.47465152e-02f, -5.86863719e-02f, -2.67644208e-02f, -7.36542568e-02f, -9.34086367e-02f, 2.28012186e-02f, -2.22768039e-02f, 2.69458964e-02f, -7.80797154e-02f, -7.01568872e-02f,
  2.69941986e-02f, 5.92769571e-02f, -4.90477048e-02f, 1.03225866e-02f, -6.01055510e-02f, -6.04661591e-02f, 4.68926914e-02f, -1.87431723e-02f, 1.40537331e-02f, -9.38712284e-02f,
  -5.61893508e-02f, -9.64179263e-02f, -6.24442101e-02f, -5.29004820e-02f, 5.90620004e-02f, 1.01980381e-03f, 1.50631787e-02f, -6.61597028e-02f, -5.48149869e-02f, -3.28561701e-02f,
  -9.31871682e-02f, -8.66324082e-02f, -1.08171506e-02f, 5.43545373e-02f, -3.09058335e-02f, -3.06790206e-03f, 8.29735845e-02f, 1.34196533e-02f, -5.87078184e-02f, -3.20005678e-02f,
  -9.94788185e-02f, 6.70162812e-02f, -1.10998847e-01f, -5.17880693e-02f, -5.72061650e-02f, 2.65479311e-02f, 5.34032248e-02f, 6.04283251e-02f, -2.05306825e-03f, -5.80648147e-02f,
  -8.96225944e-02f, -8.74932110e-02f, -6.00814298e-02f, -5.41667826e-02f, -7.16099441e-02f, 3.91765274e-02f, 7.43343607e-02f, 1.93153806e-02f, -1.34472698e-02f, -3.70328799e-02f,
  5.40205836e-02f, -6.73484011e-03f, 7.40225539e-02f, -6.51452392e-02f, -4.37882692e-02f, 4.09402959e-02f, -1.14410058e-01f, 2.03630626e-02f, 2.29454096e-02f, 6.00857399e-02f,
  -1.04808770e-01f, 4.67661135e-02f, -8.11455771e-02f, 1.52347898e-02f, -8.15532357e-02f, -5.64027056e-02f, 3.19703072e-02f, 2.61592064e-02f, -7.95537829e-02f, 4.84655127e-02f,
  -5.04904101e-03f, 1.47501156e-02f, -8.92436504e-02f, 5.83448727e-03f, -5.63677736e-02f, 2.54094191e-02f, -4.03398164e-02f, -3.17243375e-02f, 1.03892036e-01f, 5.53538464e-02f,
  1.13824315e-01f, 1.44183367e-01f, -5.14794998e-02f, -4.40273881e-02f, -9.13081318e-02f, -3.08180731e-02f, -3.06777228e-02f, -2.87028379e-03f, -9.24267471e-02f, -8.25779662e-02f,
  -1.06512278e-01f, -5.23703359e-02f, -2.86525898e-02f, -4.72560301e-02f, 1.98545065e-02f, -1.42769432e-02f, -9.18703675e-02f, -6.63483962e-02f, -1.04712352e-01f, -3.23813297e-02f,
  -1.03618309e-01f, 4.02525440e-02f, -3.60638686e-02f, 4.99168597e-02f, 4.35198471e-02f, 4.77665253e-02f, 8.81335437e-02f, 9.50655043e-02f, 5.69275813e-03f, -5.83681511e-03f,
  2.48309169e-02f, -2.73973681e-02f, 1.14878193e-01f, 8.42786487e-03f, 2.02975683e-02f, 8.18305165e-02f, 5.59185557e-02f, 2.98316684e-02f, 1.46847579e-03f, 7.05533326e-02f,
  -6.81451857e-02f, 1.55582586e-02f, 2.43666321e-02f, 2.55208127e-02f, -5.85393235e-02f, -9.33773518e-02f, -2.71295533e-02f, -2.01572590e-02f, -1.09527849e-01f, 4.47010137e-02f,
  6.01999164e-02f, 1.36021962e-02f, 4.41753715e-02f, 1.06419750e-01f, 1.53053980e-02f, 1.00727022e-01f, 3.31022404e-02f, 8.30502659e-02f, -2.02037022e-02f, 8.97382945e-02f,
  5.24341054e-02f, 5.86824603e-02f, -5.34091182e-02f, -7.38080665e-02f, 7.20994398e-02f, -2.38799416e-02f, -5.45395985e-02f, -8.26963186e-02f, 4.01434861e-02f, 4.55061719e-02f,
  1.94210317e-02f, 5.28737530e-02f, -3.10116727e-02f, -5.04295528e-02f, -7.17597231e-02f, 2.90682763e-02f, -1.45248845e-02f, -4.95555550e-02f, 9.03906580e-03f, -2.94073429e-02f,
  7.69125372e-02f, -3.55252549e-02f, -6.92075565e-02f, 1.40829068e-02f, 3.74863558e-02f, 1.09908164e-01f, -3.11434586e-02f, -9.41356178e-03f, -2.06404761e-03f, 7.32711330e-02f,
  4.96844202e-02f, -7.93984085e-02f, -3.02057918e-02f, 7.68678263e-02f, 1.23207763e-01f, 9.21762809e-02f, 9.34807137e-02f, 5.65714091e-02f, -9.90423486e-02f, 6.47740886e-02f,
  7.60723557e-03f, 4.25756723e-02f, 6.69706846e-03f, -8.61763358e-02f, -2.10274104e-02f, 5.02785034e-02f, 4.81705219e-02f, -1.02552541e-01f, 5.26302345e-02f, 5.53969704e-02f,
  -3.54270414e-02f, 1.49090141e-01f, -3.66728543e-03f, -3.27295549e-02f, 1.62947737e-02f, 3.51020917e-02f, -2.73331273e-02f, -3.07080559e-02f, -4.73240390e-02f, 4.67518382e-02f,
  4.90022898e-02f, 7.27191716e-02f, -2.28200648e-02f, -3.96782085e-02f, -4.64453995e-02f, 2.60306541e-02f, 6.62207156e-02f, 2.61636879e-02f, -1.34908587e-01f, -1.73273645e-02f,
  -3.60125639e-02f, 2.85907742e-03f, -9.81919393e-02f, -8.51653740e-02f, -9.47222766e-03f, 1.31621920e-02f, 8.57975259e-02f, -5.77038750e-02f, 7.97663555e-02f, 1.16769359e-01f,
  -1.01156635e-02f, 4.16901000e-02f, -4.25978489e-02f, 2.92219073e-02f, 4.45703901e-02f, -5.10087721e-02f, 1.98308676e-02f, 4.90013994e-02f, -2.72953529e-02f, 7.23507851e-02f,
  -3.40236016e-02f, -1.65421311e-02f, 7.72107467e-02f, 3.52159739e-02f, -1.84548590e-02f, -2.73034479e-02f, -9.51030776e-02f, -4.15821411e-02f, 1.55484281e-03f, 5.29658236e-02f,
  9.24320444e-02f, 4.18136269e-02f, 3.54446331e-03f, 2.51887590e-02f, -4.63080779e-02f, 4.39758077e-02f, -9.74256694e-02f, -8.66135061e-02f, -9.27413255e-02f, -1.37973111e-02f,
  -1.56197548e-01f, -8.87249932e-02f, 2.31174547e-02f, -1.10557608e-01f, -7.85950720e-02f, 3.94802876e-02f, -8.50647409e-03f, -1.03798565e-02f, -1.15770631e-01f, 5.45285409e-03f,
  -3.38382460e-02f, -1.63346715e-02f, -3.29028256e-02f, -1.73805188e-02f, -5.54996543e-02f, -9.23389848e-03f, -4.49281972e-04f, -8.30527768e-03f, -6.10841699e-02f, -6.76853880e-02f,
  -3.52907693e-03f, -9.34742764e-03f, -7.25788176e-02f, 8.98419768e-02f, 2.54800562e-02f, -1.23420931e-01f, -3.46541740e-02f, -8.92923623e-02f, -5.83506236e-03f, 1.55530342e-05f,
  -2.90466752e-03f, -3.02913766e-02f, 1.11156575e-01f, 7.43340030e-02f, 4.19621691e-02f, -7.93768838e-02f, 5.28820604e-02f, 9.99838933e-02f, 5.38346618e-02f, 5.39573766e-02f,
  1.07001439e-01f, 5.90101704e-02f, -7.01758340e-02f, -2.14817952e-02f, -6.77348971e-02f, -6.41561449e-02f, -6.16845712e-02f, 1.30991526e-02f, -2.22307220e-02f, -5.36779538e-02f,
  -4.84597273e-02f, -9.91311818e-02f, 2.44295541e-02f, -5.67196570e-02f, -5.21795005e-02f, -3.83933894e-02f, -4.75644432e-02f, 4.21145000e-02f, -1.16638027e-01f, -6.30183741e-02f,
  2.69884109e-01f, 3.71789448e-02f, -7.55235255e-02f, -6.52388902e-03f, -9.23414901e-02f, 4.92194407e-02f, -2.05759052e-03f, -1.16871130e-02f, -6.00444824e-02f, -1.19661568e-02f,
  -5.38979955e-02f, 3.12734693e-02f, -1.73041523e-02f, -7.16750175e-02f, 4.61725257e-02f, 9.62253585e-02f, 4.70713489e-02f, -5.97670535e-03f, -4.65224078e-03f, -1.99475009e-02f,
  -9.27354321e-02f, 4.97892015e-02f, 2.54046600e-02f, -3.51084508e-02f, 8.17512423e-02f, -4.84322347e-02f, 6.65594339e-02f, -6.29020631e-02f, -8.38508382e-02f, -1.99936237e-02f,
  -6.84286132e-02f, -9.57318989e-04f, 1.01789191e-01f, -8.00034497e-03f, -8.43394771e-02f, 3.62508148e-02f, -5.74928038e-02f, 6.58865599e-03f, 1.26831783e-02f, -2.36906130e-02f,
  2.22622231e-02f, 1.94824394e-02f, -5.68161681e-02f, 2.76573207e-02f, 8.71828422e-02f, -5.91494609e-03f, 2.60024313e-02f, -6.63935244e-02f, 1.58830211e-02f, 1.62029099e-02f,
  -1.05514809e-01f, -2.97981780e-02f, 1.34473564e-02f, 4.18757461e-02f, 6.53641149e-02f, -6.35405956e-03f, 4.88274358e-02f, 5.30218557e-02f, -1.97525080e-02f, 2.87057199e-02f,
  -7.03822300e-02f, 3.35863605e-02f, -1.05948456e-01f, -1.11455955e-01f, 8.14442858e-02f, -1.00882344e-01f, 2.37587448e-02f, 4.79214266e-02f, -3.52738574e-02f, 3.47939357e-02f,
  2.93255839e-02f, -2.63487268e-02f, 6.02158867e-02f, -1.78299900e-02f, -4.70964909e-02f, -5.72835878e-02f, 4.24249806e-02f, 3.87774706e-02f, -2.62424313e-02f, -9.13141072e-02f,
  -1.01951649e-02f, -8.81453976e-02f, -3.21624279e-02f, -5.29443957e-02f, 5.73245361e-02f, -5.74054159e-02f, -3.55508029e-02f, -3.12419571e-02f, -3.87114286e-03f, 7.00603724e-02f,
  4.19209376e-02f, -1.05212383e-01f, -5.65207051e-03f, 4.50500883e-02f, -5.13658747e-02f, 5.42850792e-02f, 1.38177653e-03f, 9.21305716e-02f, -5.09265624e-02f, 9.87292752e-02f,
  -2.20127050e-02f, 1.69960354e-02f, -5.23862205e-02f, -1.01130176e-02f, 3.99964452e-02f, 5.84178865e-02f, -8.07770416e-02f, -1.10337241e-02f, -5.75753348e-03f, -2.38502361e-02f,
  9.58455652e-02f, 8.64405930e-02f, 4.80481870e-02f, -1.46529507e-02f, 8.12789425e-02f, -6.83446452e-02f, 8.67231656e-03f, -4.47830707e-02f, 6.11325614e-02f, -2.62223440e-03f,
  1.40088946e-01f, 2.19000597e-03f, 3.24257351e-02f, 9.93616786e-03f, 1.71311826e-01f, 1.49523854e-01f, 1.44342303e-01f, 1.57687604e-01f, 1.18600667e-01f, -3.78154509e-04f,
  -1.04315504e-01f, -8.43595937e-02f, -8.95884708e-02f, 1.18681761e-02f, -1.45327719e-02f, -1.94496792e-02f, 1.30919203e-01f, 1.06453717e-01f, 6.86727315e-02f, 6.45524263e-02f,
  7.34740421e-02f, -1.41639682e-02f, 1.12559488e-02f, 9.86673534e-02f, 1.16808861e-01f, 1.14385942e-02f, -5.41118532e-02f, -3.78679708e-02f, -4.47795354e-02f, 5.25073297e-02f,
  -7.66216889e-02f, -8.01186264e-02f, -1.22221317e-02f, 5.99075295e-02f, 4.94726598e-02f, 4.41476181e-02f, -6.20188229e-02f, 5.28188189e-03f, -4.63391701e-03f, 9.35334861e-02f,
  -4.07329760e-02f, -1.40918698e-02f, 7.39431530e-02f, 1.94173260e-03f, -2.90942006e-02f, 6.15920126e-02f, 2.08542682e-02f, 3.60006765e-02f, -5.60442768e-02f, -1.46435769e-02f,
  -3.68226469e-02f, -7.38864541e-02f, 9.30725131e-03f, 1.19103856e-01f, 4.58947457e-02f, 8.43493044e-02f, -9.06116664e-02f, -7.25497007e-02f, 3.66037115e-02f, 6.58564493e-02f,
  9.59026720e-03f, 9.51782316e-02f, -4.31109071e-02f, 3.77765559e-02f, -7.50787035e-02f, 5.16494028e-02f, 1.04673199e-01f, 1.89390220e-02f, 5.84246442e-02f, -9.48877912e-03f,
  -7.27695152e-02f, -9.69972163e-02f, -7.98643157e-02f, -1.73986536e-02f, 3.51094529e-02f, -1.76424086e-02f, 2.99133118e-02f, 4.99198725e-03f, -7.75264651e-02f, 2.56831385e-02f,
  -5.48969023e-02f, -4.21541966e-02f, 9.52278525e-02f, -9.46201663e-03f, -1.06296703e-01f, -3.89118455e-02f, 5.32833934e-02f, 1.34254647e-02f, 7.52765359e-03f, 8.43089297e-02f,
  -1.84069350e-02f, -1.40017286e-01f, 6.65637385e-03f, -7.13548884e-02f, 1.04008652e-02f, -5.38461842e-02f, 6.65562823e-02f, -7.39600062e-02f, -5.28913103e-02f, -5.83741851e-02f,
  3.77942622e-02f, 8.21352750e-02f, -7.56475776e-02f, 7.32759107e-03f, 8.65152106e-02f, 9.81930494e-02f, 3.01915109e-02f, 6.75244704e-02f, 2.60491017e-02f, -2.09237542e-02f,
  -6.86364621e-02f, 1.12930596e-01f, 8.42117742e-02f, -5.69089502e-03f, 7.28087574e-02f, 1.37677044e-01f, 1.01575732e-01f, 1.27914876e-01f, -4.64365892e-02f, 1.39944181e-02f,
  -1.92182921e-02f, 3.03163230e-02f, -8.97053406e-02f, -3.57705611e-03f, 7.32333735e-02f, 2.63170823e-02f, 5.48697263e-02f, 4.43957932e-02f, -7.37117901e-02f, -5.40648624e-02f,
  -6.68801293e-02f, -3.09593379e-02f, -1.39944106e-01f, -9.43458304e-02f, -1.09483637e-01f, -1.34648874e-01f, -2.05932409e-01f, -1.05935939e-01f, -9.87589136e-02f, -1.60772558e-02f,
  -8.44768807e-02f, -2.91150026e-02f, -8.57635960e-02f, -1.62133481e-02f, 8.45296755e-02f, 4.29078788e-02f, 1.96555723e-02f, -4.97572757e-02f, 2.47588456e-02f, -1.16461255e-01f,
  -1.02534056e-01f, 7.07102120e-02f, -7.07849562e-02f, 2.35891119e-02f, -1.28386840e-02f, 6.79600090e-02f, 9.88387913e-02f, -3.85463946e-02f, -6.04344681e-02f, -8.82537439e-02f,
  -4.97072339e-02f, -5.48196435e-02f, 2.97078583e-02f, -5.88938631e-02f, -9.25881043e-02f, -6.70364425e-02f, 1.85423894e-04f, -1.31819040e-01f, -1.02876209e-01f, -2.88708713e-02f,
  4.17566039e-02f, -9.19090770e-03f, 4.89626527e-02f, -8.40337723e-02f, -2.59233210e-02f, 2.96568274e-02f, -4.43248190e-02f, -3.03603634e-02f, -3.63055281e-02f, 4.05007601e-03f,
  -2.95810327e-02f, 5.95723428e-02f, -4.86800075e-02f, -1.01991326e-01f, -5.21074161e-02f, 7.32396767e-02f, 6.02365248e-02f, 6.22833781e-02f, 6.39661476e-02f, -3.15050557e-02f,
  -5.05137034e-02f, -2.76814066e-02f, -2.89352378e-03f, -9.54127610e-02f, 7.56393671e-02f, 2.63817646e-02f, 6.78044260e-02f, 1.83444843e-02f, 3.02016977e-02f, -5.59610352e-02f,
  2.85820141e-02f, -3.96809261e-03f, 2.05954183e-02f, 7.96625689e-02f, -7.49411285e-02f, 8.35902840e-02f, -8.38004798e-02f, -1.26968436e-02f, -9.43073034e-02f, 6.58860803e-02f,
  -4.46774391e-03f, 1.13337962e-02f, -5.25660850e-02f, 6.71322122e-02f, -5.49362414e-02f, 5.41575486e-03f, -4.59718257e-02f, 7.74054974e-02f, 1.68693755e-02f, -6.19750172e-02f,
  -7.46670589e-02f, -6.78093657e-02f, 3.31718810e-02f, 1.94264967e-02f, -4.35681492e-02f, -3.54289673e-02f, -5.18486947e-02f, -1.03902705e-01f, 6.01907223e-02f, -5.45637868e-02f,
  -5.75900637e-02f, 7.14704171e-02f, 4.66176216e-03f, -8.69145989e-02f, 6.16247021e-02f, -1.03446595e-01f, 1.07522691e-02f, 7.77367204e-02f, 7.62333069e-03f, -1.01488650e-01f,
  -1.53863087e-01f, 1.02231400e-02f, -6.57087713e-02f, -3.18678394e-02f, 1.17218338e-01f, -3.19628604e-02f, 1.33981034e-01f, -3.74494633e-03f, -6.31652474e-02f, -7.94216841e-02f,
  -5.99341728e-02f, 3.60057279e-02f, 9.90605131e-02f, -7.72628607e-03f, -6.79874867e-02f, 7.44958073e-02f, 4.55799066e-02f, 6.34263828e-02f, 4.17723693e-02f, 2.74617169e-02f,
  7.51893297e-02f, -1.90106798e-02f, -6.30823746e-02f, -3.51229981e-02f, 8.22370052e-02f, -2.66051684e-02f, 8.95195827e-02f, -4.80308235e-02f, 1.01448335e-01f, 4.33507860e-02f,
  2.52865464e-03f, 3.27811912e-02f, -6.77222535e-02f, 2.82769538e-02f, 7.83957094e-02f, -4.19267453e-02f, 2.10202225e-02f, 4.32420745e-02f, -6.12598322e-02f, 5.69170713e-02f,
  -2.37232260e-02f, 2.99586710e-02f, 1.66844949e-02f, 1.35563668e-02f, -7.43750855e-02f, -2.58975904e-02f, 2.85574030e-02f, 6.43392950e-02f, -3.86848338e-02f, 3.21302190e-02f,
  5.77416569e-02f, -1.63606927e-02f, 1.05905406e-01f, 5.65348864e-02f, -2.22007232e-03f, 1.04569837e-01f, 6.41386136e-02f, -1.96314882e-02f, 1.51002863e-02f, -6.95474148e-02f,
  8.77008438e-02f, 1.69437807e-02f, -3.78163066e-03f, 2.60743853e-02f, -2.68625561e-02f, 5.38726687e-04f, -7.98993185e-02f, -3.02386358e-02f, -7.07130553e-03f, -8.83386936e-03f,
  -1.51493177e-02f, 1.99741423e-02f, -1.11206688e-01f, 4.56839241e-02f, -2.24665925e-03f, 1.85930636e-03f, 3.72599401e-02f, -2.70295125e-02f, 1.71473958e-02f, 4.81584445e-02f,
  -2.78578363e-02f, 2.68689431e-02f, -8.14448074e-02f, -2.84161791e-03f, -1.27845211e-02f, 2.55651288e-02f, 3.57321873e-02f, -2.89421342e-02f, 4.30040294e-03f, 9.70225409e-03f,
  -3.29655483e-02f, -2.04830710e-02f, -4.43551540e-02f, 3.34733874e-02f, -7.64670148e-02f, -2.49918047e-02f, -3.50340642e-02f, -7.24670291e-03f, 3.24611627e-02f, -2.16252171e-02f,
  -5.64409606e-02f, 6.06916510e-02f, -9.17753801e-02f, 2.69695334e-02f, 6.72553852e-02f, -8.69847164e-02f, 3.13649885e-02f, 6.86540976e-02f, 8.74007717e-02f, 3.51544954e-02f,
  -8.43473338e-03f, 6.07794672e-02f, 4.13277633e-02f, -8.15679207e-02f, 4.73612500e-03f, -6.38941675e-02f, -5.78393266e-02f, -5.14071397e-02f, -4.05051410e-02f, -7.52335191e-02f,
  -8.97427350e-02f, 1.49390787e-01f, -3.94597650e-02f, 1.53268380e-02f, -6.79681152e-02f, 5.85877849e-03f, 1.47886947e-01f, 8.46088752e-02f, -1.16531312e-01f, -9.05595534e-03f,
  9.69168618e-02f, 2.03991104e-02f, -5.06771803e-02f, 6.57827258e-02f, -5.82396351e-02f, 1.14419989e-01f, -4.29189317e-02f, -1.87006276e-02f, -1.06025621e-01f, -8.49061236e-02f,
  -4.93761078e-02f, -6.80217370e-02f, -5.73643716e-04f, -8.67624059e-02f, 2.54279543e-02f, -3.90274334e-03f, -4.42506634e-02f, -9.11915004e-02f, -4.78185862e-02f, 1.15350433e-01f,
  2.78312583e-02f, -2.15272196e-02f, -1.08658142e-01f, -5.51983006e-02f, -9.12317038e-02f, 2.45168880e-02f, -1.98808946e-02f, -1.12705842e-01f, -3.65487188e-02f, -4.01770100e-02f,
  -8.24027583e-02f, -2.29208451e-02f, -5.99533767e-02f, -4.27943021e-02f, 3.88117135e-02f, 2.99384706e-02f, 4.32484224e-02f, 5.55710196e-02f, -4.64754999e-02f, 7.10472688e-02f,
  3.76294777e-02f, 5.09003662e-02f, 1.51717858e-02f, 2.29750238e-02f, 8.72658268e-02f, -8.21918398e-02f, 4.79157791e-02f, -4.85651605e-02f, 5.89486063e-02f, -9.78134423e-02f,
  2.61915121e-02f, 9.59770530e-02f, 8.13885406e-02f, -8.29975232e-02f, -4.53491136e-02f, -2.48731282e-02f, 6.87526241e-02f, -2.34576389e-02f, 8.52830261e-02f, -4.52611968e-02f,
  -1.94690824e-02f, -1.59465615e-02f, -5.78417070e-02f, 8.57322589e-02f, 1.42907593e-02f, -9.24101844e-02f, -6.26201779e-02f, 1.01457432e-01f, 9.46734287e-03f, 6.67942613e-02f,
  -5.67478314e-02f, 2.42303219e-02f, 8.04863945e-02f, -2.40767263e-02f, 4.71488871e-02f, 4.33243476e-02f, 8.68456289e-02f, 4.71616425e-02f, -4.90176305e-02f, -5.30770347e-02f,
  -2.68712901e-02f, 8.82153772e-03f, 6.83007482e-03f, 2.03185398e-02f, 2.36084070e-02f, -8.53896216e-02f, 5.73535971e-02f, -8.49829987e-02f, -3.43626216e-02f, -2.75721848e-02f,
  -8.07205513e-02f, -3.61886062e-02f, 1.76029336e-02f, -6.86884746e-02f, 5.50748073e-02f, -1.96093181e-03f, -3.91233042e-02f, 7.65930787e-02f, -8.64957273e-02f, 7.33487010e-02f,
  -3.57267335e-02f, -1.02759441e-02f, -1.00913048e-01f, 6.37087002e-02f, 3.96599546e-02f, -5.40076010e-02f, 1.72874369e-02f, -1.27018228e-01f, 1.12528959e-02f, -9.04120877e-02f,
  1.31193683e-01f, 3.74990664e-02f, -9.42700822e-03f, -3.52734253e-02f, 7.52779394e-02f, 8.89422446e-02f, 1.26995355e-01f, -1.71492137e-02f, 4.27706242e-02f, 1.54843926e-02f,
  -4.09866236e-02f, -6.79364651e-02f, -1.43737644e-01f, -7.45477006e-02f, 5.83176911e-02f, 7.77184889e-02f, 6.15075193e-02f, -7.68126920e-02f, -4.88917753e-02f, 5.51275983e-02f,
  -3.46395075e-02f, 7.71520957e-02f, -9.78391171e-02f, 5.09149693e-02f, -2.90079834e-03f, -4.12947908e-02f, 5.13249300e-02f, -1.82061326e-02f, -5.79774939e-02f, 4.30924296e-02f,
  -1.87377296e-02f, 5.19826375e-02f, -1.25208190e-02f, -5.03650233e-02f, -1.95357949e-02f, 2.17000302e-02f, 5.31084873e-02f, -5.67906536e-03f, -8.23474377e-02f, -3.25742550e-02f,
  9.90100279e-02f, -5.88811524e-02f, 6.31808639e-02f, 2.81230416e-02f, 1.08558824e-02f, -3.30247916e-02f, 4.85104024e-02f, 6.77202046e-02f, -3.27986069e-02f, 1.95164885e-02f,
  1.07221268e-02f, 2.84942873e-02f, 4.88366745e-02f, -3.81840989e-02f, 5.85191436e-02f, 2.54284479e-02f, 9.03822184e-02f, 9.16197374e-02f, -5.10070436e-02f, -5.75236827e-02f,
  9.94493216e-02f, -4.60941680e-02f, 5.04313335e-02f, -1.88287273e-02f, -4.41197939e-02f, -1.25114219e-02f, -5.69772869e-02f, -6.39151409e-02f, 9.81278867e-02f, 5.51733887e-04f,
  -4.09861319e-02f, 6.63381815e-02f, 9.09734741e-02f, -4.59589362e-02f, -1.64216626e-02f, 8.04493725e-02f, 1.68149415e-02f, -7.77011588e-02f, 2.83922292e-02f, 1.15611851e-02f,
  -3.53352986e-02f, -2.19386686e-02f, -2.24000905e-02f, 3.73844669e-04f, 3.87751274e-02f, 4.57655964e-03f, 8.49321950e-04f, -4.50460725e-02f, 2.41567902e-02f, -4.39005457e-02f,
  3.93222831e-02f, 1.12948209e-01f, 2.57513556e-03f, -3.84301804e-02f, 4.22143154e-02f, -4.72681858e-02f, 8.04531425e-02f, -4.39548381e-02f, 2.18318962e-02f, -5.35894595e-02f,
  -1.24924844e-02f, -3.20355259e-02f, -2.83583570e-02f, 8.19805488e-02f, 8.27194303e-02f, 1.69910360e-02f, -2.74240933e-02f, -2.72648670e-02f, 9.15112346e-02f, 3.09801307e-02f,
  4.51840498e-02f, 7.99471419e-03f, 1.07897334e-02f, 1.37929376e-02f, 6.81609660e-02f, -2.27046665e-02f, 2.82728672e-02f, -4.69428971e-02f, 1.08031280e-01f, 2.79730689e-02f,
  -1.48100138e-01f, 1.40184006e-02f, -1.99318454e-01f, -1.50617898e-01f, -9.96283218e-02f, -8.37120041e-02f, 2.35264655e-02f, -6.81166351e-02f, -3.79283130e-02f, -1.67114019e-01f,
  -8.51905420e-02f, 1.85807906e-02f, -9.60801542e-02f, 1.68184179e-03f, -8.14098492e-02f, -8.99075642e-02f, -1.08396091e-01f, -4.58235778e-02f, 8.92433450e-02f, 9.20094773e-02f,
  3.29318345e-02f, -1.17055103e-01f, -1.35261165e-02f, -7.24608377e-02f, -1.26817480e-01f, -9.08614621e-02f, -7.56061226e-02f, -8.22639242e-02f, 1.63258668e-02f, -1.10625058e-01f,
  -8.71534869e-02f, -4.04192284e-02f, 3.40289250e-02f, -6.41715154e-02f, -9.60207805e-02f, 8.45127106e-02f, -5.46389371e-02f, 5.74939027e-02f, 1.20960221e-01f, 2.91318689e-02f,
  -5.26348688e-03f, 1.14315962e-02f, 4.87824567e-02f, 7.26535171e-02f, -2.57539693e-02f, -2.04436909e-02f, -5.04143834e-02f, 1.06726158e-02f, 4.42572944e-02f, -3.12891565e-02f,
  -5.54707833e-02f, -5.84490933e-02f, -3.80393304e-02f, 9.81179997e-03f, 6.42454922e-02f, -1.55753177e-02f, 5.56607358e-02f, -2.75169127e-02f, 6.02012835e-02f, -7.99452811e-02f,
  2.47361548e-02f, 1.04028516e-01f, 4.51504029e-02f, 2.08374374e-02f, 2.91383676e-02f, 3.71787623e-02f, 8.19913968e-02f, -8.24819431e-02f, 8.01948532e-02f, 7.04063028e-02f,
  -3.18916887e-02f, -1.23030566e-01f, -5.37121221e-02f, -1.46063454e-02f, -7.31275976e-02f, -6.28981814e-02f, -1.88685972e-02f, 2.24994794e-02f, 4.36906293e-02f, -4.04815003e-02f,
  5.20257019e-02f, -1.89223532e-02f, 1.02554895e-01f, 4.50685620e-02f, 6.23047240e-02f, -6.25764355e-02f, -7.74777457e-02f, 5.66097721e-02f, -3.48843522e-02f, -3.63004059e-02f,
  -1.37154534e-02f, -5.73040172e-02f, 3.10760736e-02f, 8.19503814e-02f, 1.10407211e-02f, -7.81263113e-02f, -9.48397368e-02f, 2.63034049e-02f, 9.15226415e-02f, -8.18963349e-02f,
  4.17417400e-02f, 1.20591288e-02f, -5.58388680e-02f, -4.49766293e-02f, 9.06257853e-02f, 4.70860824e-02f, -7.86690116e-02f, -7.36423060e-02f, 9.49733406e-02f, -4.35902998e-02f,
  -6.56080022e-02f, -6.12247810e-02f, -4.07270938e-02f, -3.93217951e-02f, -9.85541660e-03f, -1.69120114e-02f, 1.05546609e-01f, -5.49858063e-02f, 7.20420033e-02f, -4.77118380e-02f,
  -2.30291318e-02f, 5.53570986e-02f, -7.34881544e-03f, 5.96719496e-02f, 7.52925277e-02f, 1.06053829e-01f, 1.40359476e-01f, 4.95469905e-02f, 8.21089819e-02f, 3.58008370e-02f,
  3.85247543e-02f, 1.42897218e-01f, 8.67874920e-02f, 1.28655052e-02f, 1.23813294e-01f, 4.78452295e-02f, 8.67449343e-02f, -3.08062956e-02f, 1.09481454e-01f, 3.68019864e-02f,
  1.02464795e-01f, 5.49416952e-02f, 1.50966840e-02f, 6.92729279e-02f, -4.09278199e-02f, 1.27359405e-01f, -1.85717288e-02f, 8.70332867e-02f, 1.67506766e-02f, -1.37298051e-02f,
  -2.34048087e-02f, -7.36274272e-02f, 5.41375503e-02f, 5.04953302e-02f, 4.58272509e-02f, -6.11632317e-02f, 3.72145176e-02f, 1.16915945e-02f, 1.83813144e-02f, 2.23608296e-02f,
  -4.35006097e-02f, 1.36169437e-02f, 3.85550335e-02f, -2.39529256e-02f, -9.75661278e-02f, 6.29281402e-02f, -3.89470831e-02f, 5.49330600e-02f, 5.37793674e-02f, 2.42641065e-02f,
  1.10717997e-01f, 7.21472725e-02f, 5.16837370e-03f, -4.88713384e-02f, 3.57506890e-03f, 9.58437547e-02f, -6.48443997e-02f, 4.02320027e-02f, 1.92182921e-02f, 7.07116798e-02f,
  -5.02628386e-02f, -4.92409319e-02f, 3.87318358e-02f, 7.99823552e-02f, 3.19650932e-03f, 1.19118970e-02f, 8.38376507e-02f, 5.15734702e-02f, 5.97872250e-02f, 3.25638726e-02f,
  1.70366187e-02f, 7.81135783e-02f, -6.90810829e-02f, -1.06515707e-02f, 2.92503368e-02f, -5.67557439e-02f, -5.77580556e-02f, 1.52018098e-02f, 3.09525547e-03f, -3.09864134e-02f,
  -3.76495831e-02f, -5.61979264e-02f, 8.45215991e-02f, -2.98438827e-03f, -5.10763377e-02f, 8.81311744e-02f, 2.31315996e-02f, 6.12354800e-02f, -5.08623235e-02f, 7.81382993e-02f,
  2.62777153e-02f, -1.36383306e-02f, 1.25364829e-02f, -1.26740464e-03f, -5.37408441e-02f, -6.41175127e-03f, 6.49651513e-02f, 3.66175771e-02f, -5.87359890e-02f, 8.47856477e-02f,
  3.27217877e-02f, -7.26275444e-02f, -9.08415951e-03f, 2.81041791e-03f, 6.73460662e-02f, 3.24568972e-02f, 7.93903843e-02f, 3.40709575e-02f, -5.56242950e-02f, -9.50840116e-03f,
  -4.00416926e-02f, 3.33759449e-02f, 3.99873778e-02f, -5.44023775e-02f, 1.15634538e-01f, 3.48341092e-02f, -2.82819960e-02f, -6.31875023e-02f, 7.32213855e-02f, -2.12758146e-02f,
  1.38082683e-01f, -9.72621143e-03f, -8.29452872e-02f, 2.32394487e-02f, 7.77519718e-02f, 8.33307952e-02f, 2.12209541e-02f, -4.87999842e-02f, -6.62598200e-03f, 8.15819651e-02f,
  -2.60827318e-02f, 3.90134118e-02f, -6.78693131e-02f, -6.41657040e-03f, 3.60762514e-02f, -4.42363322e-02f, -4.05598469e-02f, -3.71351093e-02f, 3.04727368e-02f, -1.45903397e-02f,
  -1.11530267e-01f, -5.31156026e-02f, -4.62556481e-02f, 5.22028189e-03f, 3.21180671e-02f, -9.44928266e-03f, -2.93079037e-02f, 4.47058445e-03f, -3.81571986e-03f, 1.52442793e-04f,
  -1.44549096e-02f, -5.88044804e-03f, 9.21948552e-02f, -4.12255153e-02f, -1.26581520e-01f, -1.56147564e-02f, -9.35749337e-02f, -9.73166302e-02f, -3.83945666e-02f, -2.12497916e-02f,
  1.84371006e-02f, 2.32556034e-02f, 4.78030145e-02f, -8.77872631e-02f, 9.03555378e-02f, -4.47629206e-02f, -9.42826122e-02f, -3.01056039e-02f, -5.12020625e-02f, -1.16499709e-02f,
  -7.93003216e-02f, 4.89612669e-02f, -3.65577564e-02f, 7.42037520e-02f, 8.66118819e-02f, 1.54703790e-02f, -6.64995015e-02f, -9.95854512e-02f, 5.83106792e-03f, -3.86934280e-02f,
  -8.23128819e-02f, 2.44545955e-02f, 5.96878417e-02f, 3.29286195e-02f, -3.62118743e-02f, -2.45130504e-03f, 3.98925319e-02f, 7.31174573e-02f, 1.01093464e-01f, 7.80061781e-02f,
  5.22383638e-02f, 2.82702129e-02f, 6.47641420e-02f, 4.20652032e-02f, 6.23294860e-02f, 4.04360704e-02f, 7.91472867e-02f, -9.61379334e-02f, 1.00023210e-01f, 1.35588916e-02f,
  1.99749172e-02f, 5.65663651e-02f, -4.89971489e-02f, 7.27636293e-02f, -4.83528636e-02f, -1.85421780e-02f, 4.09448035e-02f, -6.37354404e-02f, 2.76900269e-02f, 1.02202177e-01f,
  -2.75616776e-02f, -1.83906015e-02f, -3.38695124e-02f, 4.16877680e-02f, 8.24895594e-03f, -7.59822503e-02f, 2.50932965e-02f, -8.96432325e-02f, -1.11625887e-01f, 2.94170063e-02f,
  -2.06661336e-02f, 2.30277590e-02f, -4.71913256e-02f, 8.67507234e-02f, 2.10352428e-02f, 1.04851402e-01f, 3.86273973e-02f, -5.01046283e-03f, 3.33973765e-02f, 5.07275872e-02f,
  1.61705706e-02f, -3.48900892e-02f, 2.00982876e-02f, 8.08694065e-02f, -5.91376051e-02f, 1.32090628e-01f, 7.49047250e-02f, 7.71273822e-02f, 4.25525308e-02f, -4.77647549e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  8.10407698e-02f, -3.91028374e-02f, 2.10630540e-02f, 9.37186927e-02f, 9.46334079e-02f, 1.27097592e-04f, -6.13796972e-02f, 4.50646058e-02f, 2.69994475e-02f, -1.75454337e-02f,
  -2.23126244e-02f, -8.37699920e-02f, 8.76000896e-02f, 1.23282239e-01f, 8.63461643e-02f, 5.71865356e-03f, -7.18829557e-02f, 1.00629278e-01f, 1.60753950e-02f, 3.96347903e-02f,
  7.71952644e-02f, 4.06169072e-02f, 4.79954891e-02f, -4.75478126e-03f, 6.97404100e-03f, 8.05314407e-02f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -1.63393855e-01f, -1.40718684e-01f, 4.68688086e-02f, 2.54485399e-01f, 5.44111505e-02f, -5.39599508e-02f, -1.55501783e-01f, 1.17623955e-01f, -2.75950506e-02f, -1.13352522e-01f,
  7.73339421e-02f, 9.80234444e-02f, -6.31574914e-02f, -1.88308239e-01f, -1.19224032e-02f, -1.03664935e-01f, -1.01018022e-03f, -6.28793612e-03f, 1.41337305e-01f, 1.68897316e-01f,
  -7.71064237e-02f, -7.80168176e-02f, 1.93974510e-01f, -9.96828228e-02f, -1.25156716e-01f, 1.12721078e-01f, -1.62727475e-01f, 1.91108674e-01f, -6.17429055e-02f, -2.08157614e-01f,
  1.05585806e-01f, -7.91739523e-02f, 7.04083368e-02f, -1.35593219e-02f, -1.18129261e-01f, -2.96579152e-01f, 5.15223071e-02f, 2.30551988e-01f, 6.45592734e-02f, -8.25465694e-02f,
  3.23788226e-02f, -4.51108627e-02f, -8.12190473e-02f, 5.95968142e-02f, -4.26060660e-03f, -4.46964018e-02f, -6.69886470e-02f, -8.79499465e-02f, 1.80272106e-02f, 3.30872051e-02f,
  4.84869927e-02f, 1.58836320e-01f, -1.85324959e-02f, 5.18453633e-03f, 1.03793852e-01f, 7.69207347e-03f, -8.35375711e-02f, -1.10576279e-01f, 7.77486265e-02f, -9.46815759e-02f,
  -7.32249692e-02f, -1.37539893e-01f, 9.87426490e-02f, -5.65466657e-02f, -5.44837043e-02f, -3.30915563e-02f, -1.01101160e-01f, 8.56958926e-02f, -8.59854519e-02f, -2.86060069e-02f,
  -2.01828014e-02f, 4.99706194e-02f, -5.71522899e-02f, 1.09951250e-01f, -8.10136423e-02f, -8.39815661e-02f, -1.11731909e-01f, -3.21793603e-03f, -5.60641335e-03f, -1.03905700e-01f,
  -1.38683081e-01f, -5.06168045e-02f, -4.88020256e-02f, -9.07640718e-03f, 4.81881648e-02f, -8.29449296e-02f, 1.37130842e-01f, -4.79968004e-02f, 1.11954279e-01f, 3.32734287e-02f,
  1.48319319e-01f, -5.48767000e-02f, 2.78942287e-01f, 3.55467528e-01f, -4.50592972e-02f, -9.30710435e-02f, -1.76099360e-01f, 1.61500558e-01f, -9.64665040e-02f, 2.40609378e-01f,
  -9.47068911e-03f, -5.69679141e-02f, -4.69921082e-02f, -5.57720624e-02f, 3.12021337e-02f, 1.82207879e-02f, 7.25844577e-02f, 1.49736300e-01f, 4.02151085e-02f, -1.28796950e-01f,
  -5.93216233e-02f, 9.04212147e-02f, 3.32466364e-02f, 1.31051928e-01f, 4.57220972e-02f, -1.97834641e-01f, 7.52754975e-03f, 9.02203843e-02f, -1.65739153e-02f, -1.12017184e-01f,
  -1.09525159e-01f, 6.38644993e-02f, -1.90379117e-02f, -6.90546334e-02f, -2.39328928e-02f, 1.36372879e-01f, -9.24726948e-03f, 3.89296412e-02f, 1.04396544e-01f, 4.64630499e-02f,
  3.18706296e-02f, -2.42652640e-01f, 3.99727002e-02f, -2.30427757e-02f, -7.99756497e-02f, 2.70350557e-02f, 3.23781371e-02f, 4.96547185e-02f, -1.11847878e-01f, 7.95022473e-02f,
  5.51018603e-02f, 1.14227071e-01f, 3.18249092e-02f, 8.02825317e-02f, -1.09523788e-01f, -1.12955682e-01f, 7.04049021e-02f, 1.70251176e-01f, -6.50994992e-03f, 4.18473147e-02f,
  -3.27385054e-03f, 2.26755008e-01f, -2.01570969e-02f, -4.48227525e-02f, 8.59863535e-02f, 1.04188874e-01f, -3.26821245e-02f, 2.06101760e-01f, -7.72857592e-02f, -1.78022236e-01f,
  -7.67254010e-02f, -8.70903730e-02f, -2.74261348e-02f, 3.23990285e-02f, -3.87739539e-02f, -1.15055032e-02f, 5.33320904e-02f, 6.03599474e-02f, 9.47099179e-02f, -7.73830041e-02f,
  -3.65814529e-02f, -1.46985054e-01f, -2.02679969e-02f, -5.25751337e-02f, -2.88211945e-02f, 5.00862785e-02f, -1.60684511e-01f, -2.53954288e-02f, 7.09228143e-02f, -1.46651687e-02f,
  -6.91776574e-02f, 2.32353117e-02f, -1.24130249e-01f, 7.62559325e-02f, 1.39198244e-01f, -1.88617501e-02f, -4.38767001e-02f, 5.58225550e-02f, -9.80820358e-02f, -1.90912094e-02f,
  2.04721317e-02f, 1.31121814e-01f, 1.74104109e-01f, -6.23399466e-02f, 4.89355177e-02f, -3.37861292e-02f, 1.46268666e-01f, -3.04867467e-03f, 1.33906215e-01f, 1.90521911e-01f,
  9.01241899e-02f, 1.57012507e-01f, -1.10285304e-01f, -6.26487136e-02f, -5.92908449e-03f, 2.40466129e-02f, 2.77583562e-02f, -1.26091361e-01f, 9.83274579e-02f, 1.76356230e-02f,
  -4.60028835e-02f, -1.78483240e-02f, 1.78198069e-01f, 1.31425649e-01f, -3.73463295e-02f, 2.66695283e-02f, 5.82913794e-02f, -3.51649448e-02f, 9.53621417e-02f, 4.72428231e-03f,
  2.85693526e-01f, 2.18063980e-01f, -1.44502461e-01f, 2.38556936e-02f, 1.59858853e-01f, 2.67114360e-02f, -4.21441346e-02f, 1.52846754e-01f, -6.45598173e-02f, -8.67346972e-02f,
  1.76397219e-01f, -9.52853411e-02f, -1.85235202e-01f, -4.56265323e-02f, 1.38092473e-01f, -5.11449538e-02f, 9.88151804e-02f, 1.55838877e-01f, 2.60576513e-02f, -1.74607988e-02f,
  3.01303174e-02f, 1.51302770e-01f, -3.78998555e-02f, 6.20159023e-02f, 1.23746559e-01f, 8.72553438e-02f, -1.51555985e-01f, -1.36337683e-01f, 8.92170332e-03f, 7.70688578e-02f,
  -9.22154821e-03f, 3.57932299e-02f, 8.96385014e-02f, 1.13553204e-01f, 3.36497538e-02f, 6.27648011e-02f, -1.30143603e-02f, -8.23348612e-02f, -1.54466918e-02f, 4.29066233e-02f,
  1.41668573e-01f, 8.69267434e-02f, -8.06957483e-02f, 1.27702281e-01f, 6.02648892e-02f, -8.42860788e-02f, 2.92998049e-02f, -1.13536585e-02f, 6.06446352e-04f, 1.05959885e-01f,
  -6.61278814e-02f, 9.30425376e-02f, 2.45975284e-03f, 7.66944885e-02f, 4.14316431e-02f, 1.16755329e-01f, -5.19484207e-02f, 1.00007653e-01f, 6.95001557e-02f, 2.40724515e-02f,
  -8.03331882e-02f, -3.54911648e-02f, 1.76279709e-01f, 1.33450374e-01f, 3.97587866e-02f, 2.34118536e-01f, -1.18635289e-01f, 5.91473002e-03f, 1.89556610e-02f, 1.70810118e-01f,
  3.58653367e-02f, 7.58258253e-02f, -1.53416470e-01f, 1.67537242e-01f, -2.89714988e-03f, -7.52827376e-02f, -2.06891656e-01f, 1.29232138e-01f, -9.58838835e-02f, 5.34831360e-02f,
  1.34902686e-01f, -2.76836623e-02f, -3.71136218e-02f, 2.49692388e-02f, -1.43740386e-01f, 1.68338388e-01f, -1.02835469e-01f, -1.45085668e-03f, -5.38826436e-02f, 4.07244312e-03f,
  -1.10580102e-01f, 1.78960641e-03f, 1.58646889e-02f, 6.04625531e-02f, -1.05972625e-01f, -1.58685759e-01f, -1.02107964e-01f, 3.69556658e-02f, -1.24638274e-01f, -1.28031522e-02f,
  -1.20617606e-01f, -8.28851834e-02f, -2.64280401e-02f, 1.81534767e-01f, -7.27858543e-02f, -1.48697183e-01f, -5.83872497e-02f, 6.51552975e-02f, -1.63752601e-01f, 1.03772935e-02f,
  -3.63497213e-02f, 5.56817502e-02f, 2.73466464e-02f, -2.11714968e-01f, -1.70445576e-01f, -1.28549740e-01f, -5.07001914e-02f, 2.58242767e-02f, 7.87208900e-02f, -9.24973488e-02f,
  -1.41333997e-01f, -3.95878628e-02f, -5.56428768e-02f, -1.54002830e-01f, 7.51625448e-02f, 1.35831153e-02f, -4.02294956e-02f, 3.55296992e-02f, -5.17647155e-02f, -1.41928583e-01f,
  5.63053712e-02f, 1.61028847e-01f, -1.19035669e-01f, 5.78272976e-02f, 5.73817194e-02f, -5.80956191e-02f, -2.12904308e-02f, 6.51327223e-02f, 6.44422397e-02f, 9.97795537e-02f,
  1.45176619e-01f, -4.41122502e-02f, -1.52516887e-01f, -1.55103626e-02f, 1.41898453e-01f, -1.26132190e-01f, 9.00612846e-02f, -9.54328030e-02f, 6.95476383e-02f, 8.00416917e-02f,
  1.20701998e-01f, 1.26959886e-02f, 7.93212205e-02f, 9.88762081e-02f, -7.92479515e-02f, 8.89864638e-02f, 5.94839826e-02f, -5.66005670e-02f, 6.42226785e-02f, 1.87757798e-02f,
  -4.41916399e-02f, -7.78999850e-02f, 1.65137264e-03f, -7.63972998e-02f, -8.93732160e-02f, -7.13137314e-02f, -1.00306630e-01f, 3.81644070e-02f, -8.84578750e-02f, -7.29777291e-02f,
  4.39023226e-02f, 7.95050189e-02f, -9.48276836e-04f, -8.14519078e-02f, 5.30205779e-02f, 6.90962374e-03f, 7.78464526e-02f, 5.11329388e-03f, -9.21079740e-02f, -1.14415705e-01f,
  3.28267515e-02f, 9.85734910e-02f, -3.64850834e-02f, -1.88452765e-01f, 1.53785683e-02f, 1.54774517e-01f, -1.91723630e-02f, -1.84718430e-01f, 9.02425349e-02f, 1.21460095e-01f,
  -2.56603956e-01f, -1.46853298e-01f, 1.17571376e-01f, -3.24141346e-02f, 1.47065461e-01f, -2.46590818e-03f, 1.20052293e-01f, -4.27723862e-02f, -5.73255308e-03f, 8.71510580e-02f,
  -6.89419881e-02f, -1.91882506e-01f, -1.66040454e-02f, -9.52015966e-02f, -3.03713251e-02f, -2.42493534e-03f, -3.51203345e-02f, 3.97585146e-02f, -8.39437693e-02f, 3.40804905e-02f,
  -1.39238998e-01f, 4.06581257e-03f, 1.89261734e-01f, 1.29183382e-01f, -5.55520691e-02f, -1.49998650e-01f, -5.79100512e-02f, 5.02300449e-02f, 8.13400894e-02f, -1.02164805e-01f,
  -9.88301858e-02f, 5.58080040e-02f, 1.27272218e-01f, 8.88681337e-02f, -6.31388724e-02f, -7.53276646e-02f, 1.23360772e-02f, -1.16848581e-01f, -7.55555853e-02f, 8.31059888e-02f,
  3.05539463e-02f, 1.97385386e-01f, -9.48587134e-02f, -1.14043906e-01f, -6.65409938e-02f, 3.02487552e-01f, -6.67667761e-02f, -1.69266462e-02f, 7.61739612e-02f, 9.14566591e-03f,
  -4.62523550e-02f, 4.61862907e-02f, -2.00758591e-01f, -1.88964128e-01f, -2.68279836e-02f, -7.58664832e-02f, 4.20966037e-02f, -1.35385394e-01f, 2.12343574e-01f, 1.35553479e-01f,
  1.09843269e-01f, 2.84458678e-02f, 2.39681989e-01f, -3.79551500e-02f, -7.74658099e-02f, -1.35699093e-01f, 3.27684045e-01f, 1.20762363e-01f, 3.91098000e-02f, 1.17681362e-01f,
  -1.53092504e-01f, -8.21030140e-02f, -1.11227199e-01f, -2.36314926e-02f, -1.96157962e-01f, -1.82420984e-01f, 1.33626059e-01f, -1.02696568e-01f, 4.98604812e-02f, 9.40741301e-02f,
  -1.35266453e-01f, 3.04600567e-01f, 1.36472687e-01f, -1.28580481e-01f, 2.90582255e-02f, -1.30519077e-01f, -9.19622406e-02f, 2.64140338e-01f, -4.63498868e-02f, -1.28052831e-01f,
  5.74953854e-03f, 1.89546030e-02f, -1.25788674e-01f, -1.07674301e-01f, -1.11194521e-01f, 1.64190754e-01f, 1.33921616e-02f, 1.21858776e-01f, -1.21946216e-01f, 9.38846394e-02f,
  -9.59471315e-02f, -3.15942317e-02f, 1.05732322e-01f, 9.56300348e-02f, 5.66232502e-02f, -1.96960479e-01f, 2.32413426e-01f, 4.17799465e-02f, -2.93460041e-02f, -4.95248921e-02f,
  8.74629170e-02f, 1.33770227e-01f, -1.00382157e-01f, -6.42600283e-02f, 3.27407084e-02f, 2.04698667e-01f, 2.29802117e-01f, 2.08194837e-01f, -3.94692719e-02f, -5.42333126e-02f,
  -1.22462600e-01f, 2.26538791e-03f, 5.77948289e-03f, -1.53507426e-01f, 1.28028795e-01f, 2.55002141e-01f, -6.01661950e-02f, -5.88431172e-02f, 2.16037065e-01f, 9.16794091e-02f,
  -3.45834019e-03f, 1.86488017e-01f, -1.93229973e-01f, -1.48796067e-01f, -5.98599501e-02f, -7.11238012e-02f, -1.23895146e-01f, 1.63139373e-01f, 1.10438742e-01f, -4.54481840e-02f,
  -2.60559805e-02f, 6.83371499e-02f, 1.18345834e-01f, -3.66847664e-02f, 2.50500776e-02f, -1.55075476e-01f, -7.45920911e-02f, 2.42071059e-02f, -7.44240284e-02f, 9.28197578e-02f,
  4.03109789e-02f, -2.33077183e-01f, -1.17480252e-02f, 1.42537206e-01f, -3.14743966e-02f, -1.44437879e-01f, -1.32758245e-01f, 1.32326707e-01f, 5.50571680e-02f, -2.06281215e-01f,
  2.93171685e-02f, 1.47098348e-01f, 1.02557018e-01f, 1.37112872e-03f, 7.33199390e-03f, -5.90994675e-03f, 5.58501668e-03f, 2.58460492e-02f, -3.64221409e-02f, -5.45831732e-02f,
  1.50815874e-01f, -4.95706946e-02f, 9.17536318e-02f, 1.80535957e-01f, -4.00211141e-02f, 5.23536168e-02f, 2.83129159e-02f, 7.42030963e-02f, 1.18987402e-02f, 8.58352557e-02f,
  9.87707451e-03f, 3.46452743e-02f, -3.09009664e-02f, 9.75634102e-05f, 7.72070438e-02f, -1.17565237e-03f, 8.28934684e-02f, 9.01434757e-03f, 5.23990430e-02f, 1.49733037e-01f,
  -4.48533781e-02f, -8.71868804e-02f, -9.89130288e-02f, 9.53438729e-02f, 2.04663292e-01f, 1.63763493e-01f, -1.72721401e-01f, 3.25162821e-02f, -1.71984322e-02f, 6.01124093e-02f,
  -4.54131961e-02f, -4.38978299e-02f, -9.20835659e-02f, -1.64789736e-01f, 5.87117411e-02f, -1.38140144e-02f, -1.86598286e-01f, 1.10640675e-01f, 1.11430675e-01f, 1.39915407e-01f,
  -3.99770029e-02f, 1.43582895e-01f, -1.15884654e-02f, -6.20059185e-02f, 1.12152882e-02f, -1.24583229e-01f, -9.70379114e-02f, 9.10641626e-02f, -4.80482392e-02f, -5.50611615e-02f,
  5.74836396e-02f, 7.93364197e-02f, -3.04374415e-02f, -6.72948062e-02f, 7.32260421e-02f, 3.11279260e-02f, -3.35538993e-03f, 1.83793321e-01f, -1.26837164e-01f, 3.69911194e-02f,
  6.83145076e-02f, -2.51085851e-02f, 9.10635665e-02f, 4.10198897e-01f, -2.00282604e-01f, -1.32145971e-01f, -4.69910130e-02f, 2.56438941e-01f, 5.57361953e-02f, -1.64759085e-01f,
  2.51547396e-02f, 1.45326614e-01f, 8.61887336e-02f, -1.75803304e-01f, -1.69496283e-01f, -1.77430719e-01f, 4.21608649e-02f, 8.46567079e-02f, 1.61737800e-01f, -2.18750089e-01f,
  -8.18777084e-02f, 1.56927362e-01f, -7.09322989e-02f, -2.72447973e-01f, 1.51135251e-01f, -2.31703036e-02f, -7.46217594e-02f, -7.96509609e-02f, 1.10865623e-01f, -1.11393951e-01f,
  1.26961052e-01f, 9.61707719e-03f, 8.71741250e-02f, 5.05213514e-02f, -1.79480374e-01f, -9.90862325e-02f, -1.23401098e-01f, -1.45852908e-01f, 4.22970913e-02f, -7.34372139e-02f,
  -7.77135640e-02f, -1.03407599e-01f, -5.55651188e-02f, 1.65798247e-01f, 2.13587359e-01f, -7.18124360e-02f, -6.17846884e-02f, -1.43796265e-01f, 7.88866635e-03f, 1.20142020e-01f,
  1.24258399e-01f, -9.23474506e-02f, 8.95666629e-02f, 1.98476650e-02f, 6.11731634e-02f, 4.13514813e-03f, -1.04967162e-01f, 1.87232614e-01f, 1.28071219e-01f, -5.49641550e-02f,
  -9.00904164e-02f, 1.32637367e-01f, 1.55736312e-01f, -9.60201472e-02f, -1.47180766e-01f, 7.57088065e-02f, 5.17092757e-02f, -9.92530491e-03f, -9.71069187e-02f, 8.76027271e-02f,
  3.63758840e-02f, -5.92577234e-02f, 9.46660861e-02f, -1.46495357e-01f, -3.08516668e-03f, 9.02911052e-02f, -3.87913734e-02f, -8.32067505e-02f, -6.18303828e-02f, 9.90186259e-03f,
  -5.86310886e-02f, 1.23043127e-01f, -1.11285999e-01f, 1.99708734e-02f, -1.93288729e-01f, -1.98525228e-02f, -4.10743570e-03f, -4.31237221e-02f, -1.34279773e-01f, 9.62811336e-02f,
  -1.60103634e-01f, -1.26665542e-02f, -1.71941310e-01f, -2.42631122e-01f, -2.39802338e-02f, -4.49995957e-02f, 2.02363171e-03f, -5.47974482e-02f, 1.12303957e-01f, -1.18568145e-01f,
  6.79426789e-02f, -8.21427256e-02f, -1.58868268e-01f, -4.52764295e-02f, 1.14106737e-01f, -1.12547569e-01f, 7.62444281e-04f, -5.99474050e-02f, -7.04244652e-04f, 5.72794080e-02f,
  2.22752821e-02f, 7.02750087e-02f, 1.50520593e-01f, 4.53838222e-02f, -1.61413476e-02f, -1.52324594e-03f, 9.66657996e-02f, -3.70859094e-02f, 1.47069663e-01f, 3.76820490e-02f,
  -4.04264331e-02f, -4.05702628e-02f, 4.52581383e-02f, 1.10064976e-01f, 4.73490134e-02f, -8.30916688e-02f, -3.72794755e-02f, -6.62658550e-03f, 1.22577816e-01f, 8.12147856e-02f,
  -1.14653394e-01f, 1.27163097e-01f, 6.69949502e-02f, -5.51597774e-02f, -1.71242461e-01f, 3.05082291e-01f, 8.90439898e-02f, -3.48284766e-02f, 1.07625000e-01f, -1.06512150e-02f,
  9.75398198e-02f, 2.00106180e-03f, -8.90099723e-03f, -7.36494586e-02f, 8.43676850e-02f, 2.51653176e-02f, 1.89084962e-01f, 2.27041632e-01f, 8.23176745e-03f, 1.51568681e-01f,
  1.96276635e-01f, -1.32550253e-02f, 1.38466030e-01f, 1.39032826e-01f, -6.55174777e-02f, 8.19155108e-03f, 1.03139076e-02f, 1.21992499e-01f, 2.04788730e-01f, -8.67720507e-03f,
  -6.50119856e-02f, 8.12223107e-02f, -1.70510530e-01f, -1.03199221e-01f, -1.25133306e-01f, 3.26456241e-02f, 2.78982501e-02f, 1.38596758e-01f, -1.08557560e-01f, -1.14608772e-01f,
  -2.34828535e-02f, 9.88579243e-02f, -5.39294258e-02f, -1.09171584e-01f, -5.09240329e-02f, -1.04959600e-01f, -6.74286634e-02f, 7.87376165e-02f, -4.98674053e-04f, 8.53066072e-02f,
  6.20950386e-02f, 4.74282093e-02f, -1.07533716e-01f, 3.59665975e-03f, -7.71970376e-02f, 3.24219912e-02f, -1.00782454e-01f, -1.50173977e-01f, -7.70145878e-02f, 5.69885895e-02f,
  1.45952389e-01f, 9.48696062e-02f, -1.01427495e-01f, 1.02345429e-01f, -1.20310307e-01f, -1.33176684e-01f, 1.38933524e-01f, 6.37256494e-03f, 4.34895866e-02f, -8.88785645e-02f,
  -9.89741385e-02f, 8.72878544e-03f, 5.01024164e-03f, -1.05907902e-01f, -4.51791994e-02f, -7.82835204e-03f, 5.32544367e-02f, 9.77332983e-03f, 9.23385024e-02f, -1.37624681e-01f,
  3.42165045e-02f, -1.17330581e-01f, 7.84648806e-02f, -5.52720092e-02f, 3.54576483e-02f, 1.67755425e-01f, 1.42516986e-01f, -7.57784545e-02f, 2.25783270e-02f, 8.30685645e-02f,
  1.51788294e-01f, 5.92855290e-02f, -1.22558795e-01f, -7.65151978e-02f, 1.35375828e-01f, -6.55156896e-02f, 1.11639708e-01f, 3.00284121e-02f, 3.00364513e-02f, -1.09296635e-01f,
  7.71929622e-02f, -1.57785639e-01f, -1.45497933e-01f, 1.31266579e-01f, -2.24841852e-02f, 4.36754748e-02f, -4.64867242e-02f, 5.35510518e-02f, -1.24056146e-01f, 2.53280215e-02f,
  1.24181114e-01f, -8.72115418e-03f, 6.24636561e-02f, -1.34223759e-01f, -1.05834410e-01f, 7.27990270e-02f, -1.52637824e-01f, 1.68476384e-02f, 7.93943703e-02f, 5.67914583e-02f,
  1.99632924e-02f, 1.23091498e-02f, -3.95957492e-02f, -2.53106020e-02f, -1.36632696e-01f, 7.17226118e-02f, -6.56614602e-02f, -5.40006496e-02f, -5.19238599e-02f, -3.09587549e-02f,
  -3.68350595e-02f, 1.16763085e-01f, 7.80029967e-02f, 1.52691916e-01f, -7.13358000e-02f, 9.10411647e-04f, 1.34757310e-01f, -9.18854177e-02f, 5.53585999e-02f, 4.60542552e-02f,
  -3.63980159e-02f, -5.77947646e-02f, -2.53327657e-02f, 7.58061707e-02f, 2.08254103e-02f, 7.51977339e-02f, 4.31134962e-02f, -7.17030615e-02f, 1.82858899e-01f, -1.18002594e-01f,
  1.77357674e-01f, 9.30703580e-02f, 6.35132864e-02f, -8.74058381e-02f, 1.11488262e-02f, 7.00940490e-02f, -6.41749874e-02f, -1.10418975e-01f, -5.68894744e-02f, 1.79546803e-01f,
  -1.08347103e-01f, 7.30312392e-02f, 2.63004359e-02f, -8.62096027e-02f, -6.10082895e-02f, -5.89227304e-02f, 3.89825590e-02f, 6.04052953e-02f, -3.64369117e-02f, 1.30649716e-01f,
  1.26343280e-01f, -9.46137775e-03f, -2.43771784e-02f, -1.37736544e-01f, 8.93271491e-02f, 6.93735927e-02f, 7.64308870e-02f, -6.65701851e-02f, 2.42190175e-02f, 9.61300209e-02f,
  2.65862122e-02f, 4.45722900e-02f, -2.66213920e-02f, 1.05534531e-01f, 4.44684029e-02f, 6.08338453e-02f, 3.81632447e-02f, 1.05851278e-01f, -9.89571512e-02f, 7.87672549e-02f,
  -6.28605410e-02f, 3.46539542e-03f, -1.05629660e-01f, 2.60120362e-01f, 8.96309987e-02f, -6.54708073e-02f, -1.98623016e-02f, 2.44273141e-01f, -7.11356625e-02f, -8.70060548e-02f,
  -3.00727654e-02f, 1.64273664e-01f, -1.18745835e-02f, -2.43891217e-02f, 2.29723323e-02f, 8.64775330e-02f, -1.45198284e-02f, 3.62945837e-03f, 1.80866659e-01f, 1.50177494e-01f,
  -1.18797347e-01f, -2.94705611e-02f, 2.44129375e-01f, -1.24321327e-01f, 6.11898750e-02f, 6.72401637e-02f, -6.14582337e-02f, 1.31689623e-01f, -1.06149510e-01f, -1.49033040e-01f,
  2.35568687e-01f, 2.48623304e-02f, 1.44093437e-02f, 1.58630431e-01f, -1.79017633e-01f, -1.33790120e-01f, -6.12950958e-02f, 2.49778613e-01f, -8.90294963e-04f, 1.42906830e-01f,
  -3.09432112e-02f, -1.12310544e-01f, -7.51821101e-02f, -1.59012914e-01f, 1.71115905e-01f, 1.80895198e-02f, 8.81598517e-02f, 4.82074842e-02f, -2.73338079e-01f, -3.75987627e-02f,
  1.58035889e-01f, 8.16016123e-02f, 6.18681870e-02f, 1.75710335e-01f, -9.61800665e-02f, 8.56656134e-02f, -7.91033134e-02f, -1.00989841e-01f, -8.20667446e-02f, -3.25535354e-03f,
  7.54731707e-03f, -1.26377568e-01f, -1.03313647e-01f, -5.53141795e-02f, -4.49782498e-02f, -1.58878341e-01f, -6.17674366e-03f, 1.25614420e-01f, -9.76998582e-02f, 9.05957744e-02f,
  3.06805223e-02f, -2.28867292e-01f, 9.15291384e-02f, 2.66964864e-02f, -1.15863234e-01f, 1.42418489e-01f, 1.06570825e-01f, -1.15134560e-01f, 1.72778621e-01f, 1.48618385e-01f,
  -3.45555022e-02f, 2.74361819e-02f, 4.80377786e-02f, 1.09799981e-01f, -2.63605565e-01f, -8.07051510e-02f, -1.93813220e-01f, 1.22710042e-01f, -2.17665017e-01f, 2.21252032e-02f,
  -6.16951846e-02f, -2.33627437e-03f, -3.53939325e-01f, -2.83639967e-01f, 1.02176495e-01f, -5.63124791e-02f, -3.63873802e-02f, -1.39820063e-02f, 2.13289753e-01f, -1.85904011e-01f,
  1.45243406e-01f, 1.93742260e-01f, -7.97809809e-02f, 2.69203018e-02f, -2.14877296e-02f, -7.02046007e-02f, -1.47811487e-01f, -1.24847054e-01f, 8.37926846e-03f, -1.97392851e-02f,
  -4.01756959e-03f, 1.29534677e-01f, 6.79753944e-02f, -1.09145679e-01f, 4.79123481e-02f, 1.29835591e-01f, 6.24909662e-02f, 1.22771904e-01f, -1.73766352e-02f, 7.75757357e-02f,
  1.53925776e-01f, 1.12462185e-01f, 1.08767942e-01f, 1.23546749e-01f, 6.74548000e-02f, -1.54722124e-01f, 4.93489066e-03f, 5.60277067e-02f, 1.42399473e-02f, 1.41648978e-01f,
  6.54191822e-02f, 8.99195075e-02f, -9.81187895e-02f, 2.67174244e-02f, -5.64154610e-02f, -1.09957635e-01f, 3.64565179e-02f, 3.38358358e-02f, 1.74414981e-02f, 2.00139225e-01f,
  -3.48922759e-02f, -1.55061006e-03f, 9.53751728e-02f, -1.48224263e-02f, -3.34972627e-02f, -1.48227932e-02f, 1.57576829e-01f, -2.53871083e-01f, 3.01188603e-03f, 3.09949797e-02f,
  -4.53579277e-02f, -3.04351240e-01f, -5.02635203e-02f, 1.41026964e-02f, -2.34069839e-01f, -1.52253538e-01f, 1.38734549e-01f, -2.01370269e-01f, 1.60790220e-01f, 1.94563702e-01f,
  1.82845354e-01f, 3.84129584e-02f, -7.03245550e-02f, -4.26417552e-02f, 7.41842240e-02f, -1.60168841e-01f, -9.57911089e-02f, -6.07137159e-02f, 1.11827843e-01f, 2.06480157e-02f,
  -2.05950625e-02f, 6.92204908e-02f, 1.30237892e-01f, -1.43821657e-01f, 5.06465370e-03f, -1.39592692e-01f, 2.48280436e-01f, 1.57015454e-02f, -1.03737056e-01f, -1.05974980e-01f,
  1.28910407e-01f, -4.55478206e-02f, 1.25196889e-01f, -1.44547135e-01f, -1.78748369e-02f, 6.17117211e-02f, -2.07155972e-04f, 7.45505169e-02f, 3.90652046e-02f, -4.34800126e-02f,
  6.00151829e-02f, -3.83433923e-02f, -1.20127983e-01f, -1.14399515e-01f, -7.44227991e-02f, 5.33388630e-02f, -1.07513517e-01f, 1.84667073e-02f, 3.60062867e-02f, 6.43289164e-02f,
  4.77970093e-02f, -1.06951818e-01f, -1.85106304e-02f, -1.79986432e-02f, 6.79985955e-02f, 8.70997459e-02f, -1.21138617e-01f, -8.82146209e-02f, 3.35669145e-02f, -9.86485779e-02f,
  -8.33320618e-02f, -1.63183138e-02f, 7.44549260e-02f, 7.67707750e-02f, 1.89061403e-01f, 5.32497726e-02f, 9.12540704e-02f, -1.11178145e-01f, 8.46112967e-02f, -6.85957149e-02f,
  1.14563368e-01f, 1.87175944e-02f, -2.60373242e-02f, -1.68341950e-01f, 1.30495295e-01f, -7.10101128e-02f, 7.19525293e-03f, 2.40125284e-02f, -1.37780219e-01f, 1.47450596e-01f,
  8.92062206e-03f, -2.24244967e-02f, -1.50120016e-02f, 5.96735775e-02f, 1.57384709e-01f, 7.92161077e-02f, 2.26056557e-02f, 1.51853159e-01f, 7.00734034e-02f, -1.45733701e-02f,
  1.96416080e-02f, -3.92661290e-03f, 5.96512444e-02f, -4.63059656e-02f, -4.30216976e-02f, 8.53649080e-02f, -6.62775114e-02f, 4.37656231e-02f, -4.40328233e-02f, 7.67912343e-02f,
  -1.39714509e-01f, -6.36615679e-02f, -3.11040320e-02f, 1.20336726e-01f, 1.19846486e-01f, 1.18154369e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -3.47481072e-02f, 2.70616990e-02f, -9.94677022e-02f, 1.54004628e-02f, -1.23321481e-01f, -4.71616872e-02f, 9.82324630e-02f, -1.12428255e-01f, -6.13173284e-02f, 7.74826482e-02f,
  -2.06362419e-02f, 4.69662342e-03f, -6.95693269e-02f, -4.21380699e-02f, -1.16446942e-01f, -1.37411067e-02f, 4.98266928e-02f, -6.23843782e-02f, -5.64869903e-02f, -5.38527668e-02f,
  8.98998007e-02f, 1.75312702e-02f, -8.67672116e-02f, -1.17532234e-03f, 6.20999783e-02f, 1.36196136e-01f, -2.89027370e-03f, -2.15026289e-02f, 6.08030297e-02f, -3.60271595e-02f,
  -7.85229430e-02f, 5.41209877e-02f, 4.16765288e-02f, 1.66433435e-02f, 8.20839554e-02f, -8.62780027e-03f, 6.13080151e-02f, -2.82743517e-02f, -5.51308021e-02f, 4.83542420e-02f,
  -1.82730984e-02f, -3.13037075e-02f, 2.18939744e-02f, 7.49280602e-02f, 1.02991253e-01f, -1.23118488e-02f, 1.13727920e-01f, -1.43733919e-02f, -3.19625102e-02f, -4.91104312e-02f,
  -6.60639778e-02f, 1.14702635e-01f, -4.22065407e-02f, -7.94117600e-02f, -4.11469452e-02f, -6.68008029e-02f, -1.17002107e-01f, 6.40217587e-02f, 6.06972165e-02f, 5.64541891e-02f,
  1.26752466e-01f, -1.98203996e-02f, -1.82606578e-02f, 3.25823724e-02f, -6.51796833e-02f, 5.74261099e-02f, -2.13430449e-02f, 2.58520041e-02f, -2.35988386e-02f, 1.40693828e-01f,
  6.81102574e-02f, -5.12152836e-02f, 4.10968252e-02f, 1.15921602e-01f, 3.09953671e-02f, 1.23712942e-01f, 7.68513232e-02f, -8.56387466e-02f, 1.24338761e-01f, -9.30140689e-02f,
  1.18423499e-01f, 5.61548918e-02f, 1.03001542e-01f, 5.13994321e-02f, 3.21652442e-02f, -7.71999508e-02f, 1.37881964e-01f, -3.05217337e-02f, 5.57197295e-02f, 7.32732639e-02f,
  9.34242532e-02f, -2.63614804e-02f, -2.89410874e-02f, 9.62641910e-02f, 1.04723396e-02f, 3.11013050e-02f, -7.87440017e-02f, 2.27919919e-03f, -3.00809462e-02f, 3.50952893e-02f,
  1.03657179e-01f, 1.57053053e-01f, -4.12569828e-02f, -1.01820715e-02f, -4.50572418e-03f, 6.85379356e-02f, 6.54913485e-02f, 5.20865284e-02f, -2.79748905e-02f, 8.65473822e-02f,
  -4.47317064e-02f, -6.71110749e-02f, -4.98779491e-02f, 1.06802933e-01f, 5.94607182e-02f, 4.50911885e-03f, 1.26597313e-02f, 1.04298502e-01f, -2.73964740e-02f, 8.66314098e-02f,
  -9.42270681e-02f, 7.05172569e-02f, 2.54786271e-03f, -1.03707975e-02f, -6.66612014e-02f, -1.10061347e-01f, -5.22990152e-02f, 1.08801767e-01f, -3.14637609e-02f, 9.56191942e-02f,
  -1.06880799e-01f, 6.51722445e-08f, 1.65240075e-02f, -8.21615383e-02f, -1.00076579e-01f, -3.37792039e-02f, 5.86997643e-02f, 4.30016555e-02f, -4.96103801e-02f, 8.32115412e-02f,
  -4.65853810e-02f, 2.58642975e-02f, 3.24368216e-02f, 8.98812190e-02f, 9.11703426e-03f, 1.35267124e-01f, 9.01951790e-02f, -7.90506825e-02f, -2.76883896e-02f, -4.55030687e-02f,
  7.44163170e-02f, 1.04752472e-02f, -1.55828997e-01f, 2.82910839e-02f, 9.95438546e-02f, 3.36695388e-02f, -6.44679591e-02f, -1.47074834e-01f, -8.63877386e-02f, 6.81298599e-02f,
  -1.15786672e-01f, 1.01614669e-01f, -3.89550813e-02f, -1.06859684e-01f, 1.30018336e-03f, -1.72431096e-02f, -4.41636965e-02f, 3.86318229e-02f, -2.97436696e-02f, 4.53214440e-03f,
  -8.38726386e-02f, 5.11022285e-02f, -1.50637375e-02f, -4.04573083e-02f, 6.22064061e-02f, -1.14494719e-01f, -3.54474708e-02f, -6.34114370e-02f, 1.33825213e-01f, -2.99189868e-03f,
  -5.13049662e-02f, 2.84803361e-02f, 8.50999653e-02f, -3.66260596e-02f, -1.24208942e-01f, -2.82934457e-02f, -4.33354042e-02f, -4.24184240e-02f, 1.14677943e-01f, 8.37169513e-02f,
  -1.11665890e-01f, -8.37848932e-02f, 2.82133520e-02f, 1.10825887e-02f, 4.12454829e-02f, -3.83939482e-02f, -8.66319314e-02f, 6.65042847e-02f, 3.34146135e-02f, -3.33698578e-02f,
  -9.38702896e-02f, 7.29765370e-02f, 2.09976006e-02f, 1.32932350e-01f, 2.06500329e-02f, 1.03881516e-01f, 4.37594280e-02f, -9.25321784e-03f, 1.28322067e-02f, -9.37516615e-03f,
  -1.14388289e-02f, -7.59123862e-02f, -1.59733653e-01f, -1.20682120e-02f, -1.38667766e-02f, -1.09973162e-01f, -1.36660546e-01f, -6.30824491e-02f, 8.68491735e-03f, -1.10993348e-01f,
  -3.95268649e-02f, -5.36431968e-02f, 1.21385090e-01f, -7.64028542e-03f, 9.83686894e-02f, -9.95719954e-02f, -5.48236929e-02f, -4.55746725e-02f, -1.62705574e-02f, 3.09116747e-02f,
  7.92135373e-02f, -8.14269334e-02f, 8.59436765e-02f, 2.63291039e-02f, -1.08514905e-01f, -1.21612929e-01f, 8.67354032e-03f, -6.38084039e-02f, -9.43607241e-02f, 6.68339506e-02f,
  1.47047251e-01f, 2.97774957e-03f, -7.50845820e-02f, -1.18726835e-01f, 7.47210905e-02f, 3.97125334e-02f, 7.08754808e-02f, -2.72006672e-02f, 5.02155274e-02f, 9.98885371e-03f,
  -9.75222215e-02f, 1.02812052e-01f, 1.13823228e-01f, 6.36162385e-02f, -8.16745982e-02f, -1.78783443e-02f, 1.52856596e-02f, 1.48409963e-01f, -4.45194989e-02f, 6.90241084e-02f,
  -1.45143211e-01f, 1.45731345e-01f, -5.66267185e-02f, 2.26466283e-01f, 1.25501856e-01f, -1.05469872e-03f, 4.83683273e-02f, -8.35182518e-02f, 1.06644057e-01f, 1.54046446e-01f,
  -4.27352525e-02f, -9.11074355e-02f, -2.54983436e-02f, -4.31412533e-02f, -3.67439464e-02f, -1.38152167e-01f, 1.70355320e-01f, 2.85667554e-03f, 1.40427381e-01f, -1.86916247e-01f,
  2.16328856e-02f, 7.22849220e-02f, -3.39123309e-02f, -2.03815307e-02f, 1.48485407e-01f, 2.69388836e-02f, 6.90528527e-02f, 6.56505674e-02f, -9.29228440e-02f, 1.64095804e-01f,
  -5.01328260e-02f, 3.06502497e-03f, -1.93673208e-01f, 9.51262265e-02f, 7.04374090e-02f, -7.63773248e-02f, 1.20222885e-02f, 1.19545065e-01f, 7.93225318e-02f, 1.50494829e-01f,
  1.49901003e-01f, -8.25556144e-02f, -5.80886155e-02f, 1.22299865e-01f, 8.94279927e-02f, 1.71567693e-01f, 4.67680842e-02f, -2.70012543e-02f, 1.58624724e-01f, -2.59535499e-02f,
  -1.37890801e-01f, 5.56858256e-03f, -9.72215757e-02f, 1.16328813e-01f, 5.89780603e-03f, -9.41301063e-02f, 2.58605238e-02f, 1.51288092e-01f, 1.01584360e-01f, 1.18990093e-01f,
  1.40338495e-01f, 3.53867561e-02f, 2.76125241e-02f, -2.80807838e-02f, -4.60480787e-02f, 1.13873802e-01f, -3.71036120e-02f, -2.80672573e-02f, -4.70264107e-02f, -4.01000306e-03f,
  -1.35387648e-02f, -2.08851937e-02f, 1.42703846e-01f, -1.34193450e-01f, -9.20527428e-02f, -6.87327087e-02f, 9.95716546e-03f, 1.36435270e-01f, 8.46799985e-02f, -1.04368508e-01f,
  8.87594279e-03f, 1.03152722e-01f, -1.17707372e-01f, -2.63163149e-02f, 1.10486545e-01f, -2.36843899e-02f, -1.04421601e-01f, -1.68289188e-02f, 2.84083616e-02f, 8.45595971e-02f,
  1.09234173e-02f, -4.21660542e-02f, 1.15873039e-01f, 6.53679296e-02f, 1.17730699e-01f, 9.89023712e-04f, -9.27054416e-03f, -1.79611519e-01f, 1.29170775e-01f, -3.80167440e-02f,
  1.37184143e-01f, 8.80444646e-02f, 2.62265950e-02f, 4.20278050e-02f, -8.42498243e-02f, -6.76322952e-02f, -1.41091272e-01f, 2.38716919e-02f, 7.65238926e-02f, 4.67235893e-02f,
  -4.73629497e-02f, -1.33389801e-01f, 5.96269146e-02f, 7.04384297e-02f, 1.08205944e-01f, -9.25565884e-02f, -1.09651096e-01f, 1.25171468e-01f, 3.66184376e-02f, 1.18272506e-01f,
  2.84214187e-02f, -6.41771108e-02f, 1.19270727e-01f, 1.25015840e-01f, 8.69334713e-02f, -9.06133950e-02f, 6.26325533e-02f, -9.57046449e-02f, -4.65990715e-02f, -3.94684039e-02f,
  -2.33139973e-02f, 1.21812947e-01f, 8.19057971e-02f, 1.18719541e-01f, -1.37630263e-02f, 4.80724275e-02f, -6.12901039e-02f, -7.25876018e-02f, 4.40321490e-03f, 7.82996118e-02f,
  -3.23151238e-02f, -6.81131333e-03f, -1.05447024e-01f, -1.13540418e-01f, 1.58551022e-01f, 6.85583279e-02f, -6.26200736e-02f, 8.58345181e-02f, 1.21302336e-01f, 3.51334997e-02f,
  8.04257765e-02f, -2.33170111e-02f, 1.28657490e-01f, 4.63562794e-02f, -1.94354355e-02f, 8.69004130e-02f, -8.97520930e-02f, -1.05059922e-01f, 9.63258743e-02f, 4.93118726e-02f,
  -1.03049234e-01f, -1.14966370e-01f, 4.57411185e-02f, -9.00162160e-02f, 8.12436789e-02f, -3.61867249e-02f, 1.26510665e-01f, 9.18020010e-02f, -9.27666947e-02f, -5.59065118e-02f,
  2.19424646e-02f, 5.13195880e-02f, -5.02494387e-02f, 1.06220081e-01f, 9.39982906e-02f, 1.16352946e-01f, 7.32754692e-02f, -3.43501493e-02f, -5.12960069e-02f, -4.06388752e-02f,
  8.97944048e-02f, -4.98383716e-02f, 1.06257543e-01f, -1.16612345e-01f, -6.85046837e-02f, 1.02745086e-01f, -8.94836485e-02f, -1.23244803e-02f, -2.50619575e-02f, 2.71069594e-02f,
  1.71809629e-01f, 1.72820717e-01f, 1.47719577e-01f, 1.42474711e-01f, -9.20007452e-02f, -2.93814926e-03f, 1.60062686e-01f, 9.04802606e-02f, -1.75510086e-02f, 1.65567994e-01f,
  1.48623258e-01f, -7.89211094e-02f, 1.51063338e-01f, 5.77941053e-02f, -6.25158697e-02f, -4.63095903e-02f, 3.29719670e-02f, 2.19040304e-01f, -1.28252640e-01f, -1.19357251e-01f,
  3.34033780e-02f, -1.41152337e-01f, 1.73427968e-03f, 1.35190949e-01f, -7.08394917e-03f, 2.01186150e-01f, -6.75878301e-02f, -1.78449735e-01f, 3.61472890e-02f, -1.38006851e-01f,
  -1.04910187e-01f, -2.80083120e-02f, -1.68399513e-02f, -1.89016253e-01f, 1.10826129e-02f, 1.73614278e-01f, 1.61572192e-02f, 1.58730268e-01f, -1.68203365e-03f, 9.19821709e-02f,
  7.29487091e-02f, -1.78147569e-01f, 1.27743483e-01f, 7.59240016e-02f, 1.36452541e-01f, -8.26456845e-02f, -1.87514678e-01f, 1.37808934e-01f, -4.77208756e-02f, 1.64620280e-01f,
  4.14027423e-02f, -1.95131097e-02f, 9.59167629e-02f, 8.02218989e-02f, 7.88247585e-02f, 3.22336480e-02f, -3.64309624e-02f, -1.26939252e-01f, -2.16914266e-02f, -7.72023723e-02f,
  -2.30699852e-02f, 5.18456139e-02f, 1.19258985e-01f, 3.13702449e-02f, 1.40198976e-01f, 2.27206141e-01f, -2.39416063e-02f, 7.57739916e-02f, -7.02507347e-02f, 1.16731981e-02f,
  1.00774191e-01f, -2.86734197e-02f, -2.10907795e-02f, -3.99743393e-02f, 9.51379016e-02f, 7.55814239e-02f, -3.68077010e-02f, 4.02753241e-02f, 1.61168817e-03f, 1.23305619e-01f,
  6.45422563e-02f, 2.37985514e-02f, -6.06218204e-02f, 1.04695097e-01f, -4.74312231e-02f, -2.09049910e-01f, 4.15027287e-04f, 1.86891958e-01f, 8.09816867e-02f, 7.99385309e-02f,
  -1.62760705e-01f, 3.34440731e-02f, 2.15054572e-01f, 1.35632483e-02f, -1.14624731e-01f, 1.86197937e-01f, 1.65447265e-01f, 3.46013382e-02f, 5.69852106e-02f, 1.39568120e-01f,
  -7.61864856e-02f, 3.73121239e-02f, 7.92102665e-02f, -4.69244793e-02f, 4.77502458e-02f, 3.04382220e-02f, 2.22771287e-01f, -1.11758649e-01f, 1.83249399e-01f, -1.30037621e-01f,
  -1.19255260e-02f, 9.25835893e-02f, -3.70414965e-02f, -1.31246805e-01f, 1.24033131e-01f, 5.00653014e-02f, -1.46024916e-02f, -9.80686471e-02f, 4.29721986e-04f, 9.45106521e-03f,
  -1.05326548e-01f, 1.02734365e-01f, 1.49495052e-02f, 1.60995442e-02f, 6.99029043e-02f, -5.38074784e-02f, 1.60080671e-01f, 8.56122673e-02f, -6.52541518e-02f, -9.68277082e-02f,
  -7.12099373e-02f, 1.63224444e-01f, 1.97460383e-01f, -2.63807714e-01f, 1.74046010e-01f, -5.30017726e-02f, 1.49739936e-01f, 6.78060204e-02f, 1.48938701e-01f, -4.18584272e-02f,
  7.92463198e-02f, -3.72046232e-02f, 1.04513615e-01f, -3.40451226e-02f, 6.59419373e-02f, -1.99072495e-01f, -1.12058975e-01f, 3.59930657e-02f, -3.17248851e-01f, -1.95018258e-02f,
  -4.06653136e-02f, -5.26782274e-02f, -8.75622220e-03f, -9.82327461e-02f, -1.88174590e-01f, -2.24748570e-02f, -1.87729716e-01f, 8.70281905e-02f, -5.24846911e-02f, -5.63619025e-02f,
  1.96867034e-01f, 1.08931474e-01f, 1.49001062e-01f, -4.75309491e-02f, 1.49811596e-01f, 2.32991353e-02f, 1.95722222e-01f, -8.27443302e-02f, -9.56901908e-02f, 1.94193777e-02f,
  -5.53314611e-02f, 1.03402644e-01f, -8.36834684e-02f, 1.42024770e-01f, 2.26202741e-01f, -4.76511493e-02f, -8.49192590e-02f, -1.27848983e-01f, 7.08917202e-03f, -1.55658439e-01f,
  5.25636859e-02f, 3.00900149e-03f, -1.37336319e-02f, -9.93427411e-02f, 2.76962668e-02f, 2.09019557e-01f, 1.99837595e-01f, -1.42996470e-02f, 9.76888388e-02f, 1.00359328e-01f,
  1.97293162e-02f, 1.26813203e-01f, 1.27631038e-01f, 6.79380372e-02f, 2.47809244e-03f, -3.52557227e-02f, 1.17808469e-01f, -1.12589747e-01f, 1.90393925e-01f, 7.54965022e-02f,
  8.90711620e-02f, 2.15209112e-01f, 8.32558051e-02f, 2.17405465e-02f, 2.09274918e-01f, 1.86711505e-01f, 1.90769374e-01f, 5.40764555e-02f, -6.74031824e-02f, 5.07653579e-02f,
  -1.81687564e-01f, -4.62316275e-02f, 1.27839250e-02f, -1.76122978e-01f, -1.81545511e-01f, 1.57494500e-01f, -1.71200544e-01f, 2.43210495e-02f, -2.30049163e-01f, -2.57702410e-01f,
  1.27804115e-01f, 8.00135080e-03f, 1.71455480e-02f, -8.23912397e-02f, 2.13293627e-01f, -1.90408558e-01f, -6.80457754e-03f, -2.71049589e-02f, -8.05725306e-02f, -7.99710974e-02f,
  8.71833786e-02f, -1.07699588e-01f, -5.33672497e-02f, -9.28595588e-02f, 2.89315153e-02f, 7.39252716e-02f, 7.22919479e-02f, 9.78311896e-02f, 2.27403075e-01f, 1.51524749e-02f,
  2.14482769e-02f, 7.56442621e-02f, -5.98976240e-02f, -3.29413153e-02f, 1.20391697e-01f, 3.51432972e-02f, 7.96879455e-03f, 9.80370343e-02f, -4.62398678e-02f, 1.33417606e-01f,
  -3.93737331e-02f, -4.99416068e-02f, 1.01849109e-01f, -7.91653171e-02f, 5.36598861e-02f, -5.38594723e-02f, -1.18990464e-03f, 1.38989821e-01f, 1.21721514e-02f, 1.51597057e-02f,
  9.40683186e-02f, 1.12576336e-01f, -1.07408948e-02f, -4.17632274e-02f, 8.33197907e-02f, 9.87856314e-02f, 5.76972961e-02f, 1.40360408e-02f, 1.37369737e-01f, 4.95032668e-02f,
  1.28399894e-01f, 1.38550982e-01f, 1.08246058e-02f, -4.84061241e-02f, -1.58764347e-01f, -6.72855005e-02f, -8.11112970e-02f, -1.50105476e-01f, 6.36300398e-03f, 1.64557956e-02f,
  -1.27304703e-01f, 2.91193579e-03f, -1.19357638e-01f, -1.62985310e-01f, 1.39613107e-01f, 4.38077003e-02f, 1.00997267e-02f, -5.21848127e-02f, 4.39802408e-02f, -1.15917251e-02f,
  -7.37574324e-02f, -9.23939571e-02f, -1.35546932e-02f, -5.84176257e-02f, 7.17403218e-02f, -6.44974932e-02f, 1.08257979e-01f, -5.13871908e-02f, 7.25359023e-02f, 1.25050664e-01f,
  -8.02299380e-03f, -7.19406232e-02f, 1.02511592e-01f, 5.16304821e-02f, 2.01178528e-02f, 5.29719666e-02f, 2.22310871e-02f, 4.62081134e-02f, -8.49140808e-02f, -1.13867857e-01f,
  -1.24651179e-01f, -8.49892497e-02f, 1.46855220e-01f, 1.91004295e-02f, -4.08495255e-02f, 8.69645774e-02f, -8.20377469e-02f, 7.60385245e-02f, -8.38030130e-02f, -1.09684378e-01f,
  -3.04654967e-02f, -1.24717683e-01f, 5.34201711e-02f, 2.77414136e-02f, -9.66770872e-02f, 7.17705563e-02f, -1.10416807e-01f, 4.82781231e-02f, 1.26044750e-01f, 7.20735490e-02f,
  -2.84309406e-02f, -1.03110157e-01f, 1.24138378e-01f, -3.57828289e-02f, 1.31960854e-01f, 1.41113088e-03f, -1.14709519e-01f, 7.78186470e-02f, -8.17939043e-02f, 3.25787291e-02f,
  -5.25230952e-02f, 9.09346417e-02f, -3.97439860e-02f, 1.97586156e-02f, -1.21422589e-01f, -5.34057207e-02f, -9.98582989e-02f, 1.21670179e-02f, -6.68330491e-02f, -7.73273734e-03f,
  8.30659792e-02f, -1.01182662e-01f, 5.67345740e-03f, -1.54856127e-02f, -5.99309504e-02f, -2.47026235e-02f, -8.67992193e-02f, 1.10409446e-01f, -9.12961960e-02f, 5.26014753e-02f,
  3.18024382e-02f, -2.99303345e-02f, -1.05041839e-01f, -2.23172512e-02f, 3.31272348e-03f, -1.19610436e-01f, 4.47957106e-02f, -6.84643090e-02f, -5.32403663e-02f, -7.77795017e-02f,
  1.20917030e-01f, -6.91545382e-02f, -4.36047763e-02f, -7.78231695e-02f, -4.58130091e-02f, 1.98247842e-02f, 8.17050971e-03f, 1.07131757e-01f, 1.98961832e-02f, 2.83624120e-02f,
  3.60654704e-02f, 6.35078922e-02f, 3.35873254e-02f, 3.02343424e-02f, 7.00068921e-02f, -4.07784656e-02f, 3.78740169e-02f, 6.90887421e-02f, 1.36673868e-01f, -1.72813311e-01f,
  4.28765044e-02f, -3.17957811e-02f, -5.65381199e-02f, 2.01223329e-01f, 1.33402571e-01f, 1.21002056e-01f, -6.91664545e-03f, 8.12015533e-02f, 1.75811097e-01f, 1.21208407e-01f,
  1.82610694e-02f, 5.23642898e-02f, -1.42893316e-02f, -5.00882193e-02f, -1.75239041e-01f, 2.97784489e-02f, -1.78802431e-01f, -3.71908434e-02f, 3.04346252e-02f, 1.00556150e-01f,
  -1.17354274e-01f, -1.93795219e-01f, 1.18212983e-01f, 7.07348660e-02f, 1.40027702e-02f, -7.79594705e-02f, 6.91667795e-02f, -8.80505666e-02f, 9.29513052e-02f, 1.10374711e-01f,
  -3.66782770e-02f, -2.53749229e-02f, 2.23705754e-01f, -4.41722944e-02f, -1.15041107e-01f, 5.93176000e-02f, -3.03224251e-02f, -4.65984270e-02f, -7.48426318e-02f, -1.06774017e-01f,
  1.57043576e-01f, -1.20923132e-01f, -8.33112821e-02f, 1.45119250e-01f, 1.83185749e-02f, 9.54249315e-03f, -2.75087003e-02f, 2.60564759e-02f, 2.47408934e-02f, 6.45157918e-02f,
  1.22756876e-01f, 1.11050092e-01f, -3.64943035e-02f, 4.58716489e-02f, 1.45607993e-01f, -9.51846093e-02f, 1.28699079e-01f, 8.54796618e-02f, -2.30126176e-02f, 1.80718279e-03f,
  6.61907643e-02f, -8.04314986e-02f, 1.30216494e-01f, -5.92281157e-03f, -3.11275572e-02f, 8.76268744e-02f, -6.37137815e-02f, -3.25729996e-02f, 1.33909002e-01f, -7.58180395e-02f,
  -8.21688399e-02f, 6.39056712e-02f, -7.64470696e-02f, 4.90341038e-02f, -6.52877837e-02f, -1.65497623e-02f, -3.07340454e-02f, -1.42821381e-02f, -5.23036346e-03f, 7.44102672e-02f,
  1.38594970e-01f, -7.63272643e-02f, -6.61539212e-02f, 1.38971835e-01f, -1.97700765e-02f, 1.05477035e-01f, 7.09937066e-02f, -1.54671948e-02f, 1.33948028e-01f, 6.29193187e-02f,
  -1.63338275e-03f, 1.25408813e-01f, -1.25638321e-01f, -9.36753377e-02f, 1.67980552e-01f, -2.01121904e-02f, 2.89461929e-02f, 6.31694272e-02f, -2.70698275e-02f, -9.96965915e-02f,
  1.08349381e-03f, -8.81914224e-04f, 3.58821675e-02f, 8.53330195e-02f, -1.18284360e-01f, 3.46207358e-02f, 3.34710553e-02f, -1.28948450e-01f, 1.35687158e-01f, -5.73911406e-02f,
  -1.37794867e-01f, -7.07446933e-02f, 1.44462511e-01f, 1.14429541e-01f, 5.86433448e-02f, 6.43436238e-02f, -9.12018716e-02f, 1.21414267e-01f, 1.59651428e-01f, 1.05593111e-02f,
  1.94757640e-01f, -1.90059897e-02f, 6.83879554e-02f, -1.60989597e-01f, 1.35818198e-01f, -8.48077890e-03f, 4.03373428e-02f, 7.64438766e-04f, -2.51590591e-02f, 1.16085283e-01f,
  6.42766580e-02f, 8.06995630e-02f, 1.35157527e-02f, 1.10718593e-01f, 2.24870294e-01f, 1.76879019e-01f, 1.91069186e-01f, 9.92479101e-02f, 1.65638421e-02f, 2.43447900e-01f,
  -2.08560809e-01f, -1.22789711e-01f, -1.13494888e-01f, 1.82298169e-01f, -1.40229926e-01f, -1.44510955e-01f, 2.03716367e-01f, 1.72758907e-01f, -1.77346841e-01f, 1.16193987e-01f,
  -1.83124498e-01f, 3.56915556e-02f, -2.52178293e-02f, 3.83800454e-02f, 9.01279375e-02f, -3.03536579e-02f, 9.86887291e-02f, -7.27951946e-03f, -2.26469208e-02f, -3.88269611e-02f,
  -4.19239849e-02f, 1.55201375e-01f, -1.79384854e-02f, -1.35705531e-01f, -2.06446778e-02f, 4.58044596e-02f, -6.42523170e-02f, 3.93248983e-02f, -1.23141453e-01f, 3.67770381e-02f,
  -6.77114427e-02f, -3.99396792e-02f, 4.12922129e-02f, 4.93334532e-02f, 4.62170281e-02f, 1.36402115e-01f, 2.01825708e-01f, 1.19319364e-01f, -3.38571407e-02f, 1.26538023e-01f,
  1.59686521e-01f, 2.19006967e-02f, -1.37938391e-02f, 1.60772443e-01f, 2.00111464e-01f, 1.50448248e-01f, 7.99462646e-02f, -1.63105369e-01f, -1.28666521e-03f, 9.86104365e-03f,
  1.29789487e-01f, -1.58545226e-01f, 1.89704940e-01f, 6.66332915e-02f, 1.71394937e-03f, -3.70314009e-02f, 3.63066867e-02f, 4.13146690e-02f, 6.07129112e-02f, 1.36221200e-01f,
  1.76624462e-01f, -7.39312405e-03f, 4.06892337e-02f, -1.66109219e-01f, 2.63847075e-02f, -1.66641369e-01f, -1.35769844e-01f, -7.31874630e-02f, -1.67786881e-01f, -9.31888968e-02f,
  1.23269156e-01f, 9.48492512e-02f, 1.18484767e-02f, 8.83315280e-02f, -2.24767178e-01f, 4.80620600e-02f, 1.99880481e-01f, -3.73973958e-02f, -5.43612707e-03f, 1.64579883e-01f,
  6.61200806e-02f, -1.75204873e-01f, 2.51305550e-01f, 8.77602175e-02f, 1.79523125e-01f, 1.68885902e-01f, 3.98232788e-02f, 5.44121787e-02f, -3.23681422e-02f, 1.77452773e-01f,
  -7.74678066e-02f, -6.03515245e-02f, -4.64755371e-02f, -1.46246880e-01f, 8.31748918e-03f, -1.16874829e-01f, 1.16573833e-01f, -1.53953254e-01f, 1.41185494e-02f, 1.13468327e-01f,
  1.99755326e-01f, -8.02735761e-02f, -1.06288604e-01f, -5.90207018e-02f, 8.13794956e-02f, -2.34207269e-02f, 1.86144695e-01f, 1.44382164e-01f, 3.37065533e-02f, 6.18925244e-02f,
  9.79563221e-03f, 1.14844643e-01f, -1.00023992e-01f, 9.86784846e-02f, -9.21803042e-02f, -1.16120592e-01f, -1.94186233e-02f, 1.32736444e-01f, -6.09463975e-02f, 1.90898664e-02f,
  2.52476912e-02f, -3.97772603e-02f, 2.49358080e-02f, 9.62985903e-02f, -2.73518562e-02f, 3.45140807e-02f, -6.47838935e-02f, 9.38031599e-02f, 4.52933833e-02f, 5.56826293e-02f,
  6.94122761e-02f, 3.77842598e-02f, -1.27876118e-01f, -7.22165331e-02f, -7.44098425e-02f, -7.43767992e-02f, -1.45957982e-02f, -1.77167077e-02f, -6.62476420e-02f, -1.05686665e-01f,
  -1.76117998e-02f, -1.02128007e-01f, -8.84877592e-02f, -1.19044863e-01f, 3.57226767e-02f, 1.12436891e-01f, 3.45704183e-02f, 1.26013160e-01f, 6.05930984e-02f, -4.13975045e-02f,
  1.21064872e-01f, 9.92889106e-02f, 1.00742944e-01f, 1.30685374e-01f, -3.82107049e-02f, 1.07901148e-01f, -1.10199489e-01f, -2.52591036e-02f, 6.91527426e-02f, 1.97254661e-02f,
  4.55558673e-02f, -1.64361559e-02f, 5.16199023e-02f, 1.47579268e-01f, -4.36451212e-02f, -1.13723643e-01f, -8.71780589e-02f, -2.40936894e-02f, 1.31104171e-01f, -1.65627189e-02f,
  4.43563275e-02f, 6.44422024e-02f, -3.51479240e-02f, 3.94614898e-02f, 7.78690651e-02f, 9.62611735e-02f, -7.91694149e-02f, -2.96095647e-02f, 7.55541250e-02f, 7.11013004e-02f,
  2.72829784e-03f, -7.80731663e-02f, -1.06799521e-01f, -8.75257608e-03f, -4.38316613e-02f, -3.75876091e-02f, -1.00240931e-01f, 3.78452353e-02f, -7.41337463e-02f, -7.43894726e-02f,
  -3.19060422e-02f, -3.61439139e-02f, 8.53640065e-02f, -1.09342761e-01f, 4.89292033e-02f, -2.65073292e-02f, 9.47950557e-02f, -1.11950524e-01f, -1.24851532e-01f, -8.91370252e-02f,
  5.65747079e-03f, 1.09435320e-01f, 7.60636351e-04f, 1.86853390e-03f, -2.07621455e-02f, -5.76663651e-02f, 3.63282114e-02f, 1.17124952e-01f, 1.69619778e-03f, 6.88445801e-03f,
  -1.03492089e-01f, -1.95909142e-02f, -6.50920719e-02f, 3.13557289e-03f, 6.73757270e-02f, 6.93824142e-02f, 1.04445353e-01f, -1.18184023e-01f, -4.30267453e-02f, -3.13211069e-03f,
  4.37900573e-02f, -4.61619087e-02f, 1.36431642e-02f, 1.11142911e-01f, 3.44400317e-03f, -7.22751692e-02f, 7.22169951e-02f, 8.81406292e-02f, -5.95483556e-02f, 7.05011263e-02f,
  -2.76486930e-02f, 1.00164577e-01f, 2.65999530e-02f, 2.73290835e-02f, -1.03050858e-01f, -2.91550402e-02f, 8.78120735e-02f, 1.47045001e-01f, 1.33855104e-01f, -2.32997835e-02f,
  1.45477504e-01f, 3.93430665e-02f, -1.09434454e-02f, -3.54200229e-02f, -4.80529666e-02f, 2.97342334e-02f, -5.67764379e-02f, 4.91315722e-02f, 3.89657728e-02f, 6.78596944e-02f,
  9.30249095e-02f, 1.19964421e-01f, 5.11915721e-02f, 1.24668710e-01f, -7.28021748e-03f, -8.26139599e-02f, 2.77961195e-02f, -4.75189686e-02f, 5.52086607e-02f, 1.56667918e-01f,
  -4.99876253e-02f, 4.04026322e-02f, 1.21687323e-01f, 1.04885048e-03f, -9.06063691e-02f, 1.00619674e-01f, -9.28862169e-02f, -1.64044365e-01f, 5.27736992e-02f, -6.72983453e-02f,
  -2.87397746e-02f, -3.41532901e-02f, -7.04507232e-02f, -7.06675351e-02f, 1.61401585e-01f, -1.20775029e-01f, 1.34059608e-01f, 1.76371038e-01f, -7.68639147e-02f, 7.33964443e-02f,
  -1.38265550e-01f, 1.76647067e-01f, -1.97411291e-02f, -1.14605725e-02f, -5.06548695e-02f, -7.32300580e-02f, -3.69685926e-02f, 1.07612684e-02f, 1.11173734e-01f, -6.22555353e-02f,
  -9.02814567e-02f, 6.29869103e-02f, 8.30999389e-02f, -6.75928360e-03f, -9.90547463e-02f, -9.20622572e-02f, 1.68394521e-02f, 1.93660632e-02f, 2.56991684e-02f, 3.27363461e-02f,
  1.39681548e-01f, 1.02425292e-01f, -1.20161464e-02f, -1.30900875e-01f, -1.59340687e-02f, -1.90282858e-03f, -2.68762652e-02f, -1.12723149e-01f, 3.58206443e-02f, 9.09721106e-02f,
  -9.43269953e-02f, -8.73852819e-02f, 3.96004990e-02f, 2.51827706e-02f, -9.58507508e-02f, -4.58449032e-03f, -3.47347073e-02f, -7.39584342e-02f, -8.63318220e-02f, 4.60156724e-02f,
  -8.03268179e-02f, 7.01011941e-02f, -7.80799836e-02f, -4.09155264e-02f, -4.35552970e-02f, -3.58472764e-02f, 1.25103772e-01f, 1.04878128e-01f, 2.68314835e-02f, 2.78740134e-02f,
  -4.80515361e-02f, 1.00729600e-01f, 2.59728655e-02f, 1.78347584e-02f, 9.93214250e-02f, 4.84434068e-02f, -9.64797214e-02f, -1.14624508e-01f, 2.02822044e-01f, 8.61896798e-02f,
  -1.34419724e-02f, 1.55456007e-01f, 7.50966044e-03f, -8.32219720e-02f, 1.19683251e-01f, 6.94278255e-02f, 9.49835498e-03f, 1.44628704e-01f, 2.88294256e-02f, 4.64272499e-02f,
  -1.34136900e-01f, -1.14749163e-01f, 1.20348878e-01f, -5.95042184e-02f, 7.04784393e-02f, 1.25046358e-01f, 2.26175115e-02f, 1.12293564e-01f, 7.21652284e-02f, 1.06202215e-02f,
  -8.31915736e-02f, 1.83660083e-03f, 6.27895221e-02f, 2.14346219e-03f, -1.98255349e-02f, 4.55985731e-03f, 8.62101316e-02f, -2.87589487e-02f, -1.06857933e-01f, -3.69662605e-02f,
  -6.90792575e-02f, -6.92343488e-02f, 2.40281485e-02f, 1.52518246e-02f, 1.23386249e-01f, 1.00945406e-01f, -6.41110241e-02f, -8.90703201e-02f, 9.18825939e-02f, 3.97791341e-02f,
  -3.58985178e-02f, -5.36963064e-03f, 1.97674893e-02f, -6.44906163e-02f, 2.82828361e-02f, 8.52801725e-02f, -1.02463052e-01f, -1.27620593e-01f, -2.41108425e-03f, 1.14787564e-01f,
  2.39404777e-04f, -5.65222949e-02f, -1.53344721e-02f, -9.75915045e-02f, 1.19190462e-01f, 9.40014496e-02f, -2.49112304e-02f, -7.57933185e-02f, -1.64550859e-02f, 1.06310219e-01f,
  2.50258464e-02f, -1.45793214e-01f, -7.20560998e-02f, -2.65647545e-02f, 1.35073036e-01f, -4.57055010e-02f, -1.03865869e-01f, 1.32356629e-01f, -3.43360640e-02f, -6.64007515e-02f,
  6.71256408e-02f, -9.24123079e-03f, 1.60651490e-01f, 7.42482468e-02f, -2.02208590e-02f, 9.39638540e-03f, 9.20024216e-02f, -7.57192597e-02f, 5.57067106e-03f, -3.09798829e-02f,
  -3.29554523e-03f, -1.00910194e-01f, 5.17094210e-02f, 6.60196170e-02f, -9.03476328e-02f, 1.24896355e-01f, 1.09519720e-01f, -1.17195927e-01f, -5.19070737e-02f, -6.46622032e-02f,
  -9.14065242e-02f, -6.46218434e-02f, 3.50383036e-02f, -9.61447805e-02f, -5.09429388e-02f, -2.49945968e-02f, -1.02892831e-01f, 1.02381475e-01f, -1.30746551e-02f, 1.06731839e-01f,
  -9.89591032e-02f, 1.03135243e-01f, 8.86820704e-02f, 1.97828817e-03f, -4.45785560e-02f, -7.27026304e-03f, -9.21794400e-02f, -1.37453177e-03f, 5.44469655e-02f, 7.23812953e-02f,
  1.26186430e-01f, 7.98331052e-02f, -2.66283285e-02f, -3.39736305e-02f, -9.65113044e-02f, -7.88836256e-02f, 8.52117613e-02f, 4.11215797e-02f, 1.36842653e-01f, 5.22901826e-02f,
  9.40156810e-04f, 5.45533933e-02f, 6.05613291e-02f, -2.46098032e-03f, -4.21276838e-02f, 9.21707526e-02f, 7.86121748e-03f, -8.34698090e-04f, -1.17814504e-01f, 7.73349032e-02f,
  4.16738279e-02f, -8.36806223e-02f, 1.24482125e-01f, 5.87321930e-02f, 6.33674767e-03f, 1.56653136e-01f, -4.90261987e-02f, 1.63832441e-01f, -6.92527816e-02f, -8.88684466e-02f,
  1.29646763e-01f, 1.05403088e-01f, 1.39675420e-02f, 8.24797675e-02f, 6.64821863e-02f, -6.05618469e-02f, 3.56153212e-02f, -1.24531817e-02f, -7.37326667e-02f, 2.50223093e-02f,
  8.86727870e-02f, -3.22403982e-02f, 1.54478788e-01f, 1.87679172e-01f, 1.70344085e-01f, 1.50455147e-01f, 1.43368423e-01f, 1.16824113e-01f, 1.84853017e-01f, 1.40238479e-01f,
  2.28654936e-01f, 1.79983959e-01f, 1.43855795e-01f, -7.18672052e-02f, 6.85997903e-02f, 5.80910333e-02f, 1.33997306e-01f, 1.57091871e-01f, 6.26700521e-02f, 8.02487135e-02f,
  1.64465338e-01f, 1.86870337e-01f, 1.69422090e-01f, -4.43589278e-02f, 1.29722372e-01f, 6.49289936e-02f, 1.79966733e-01f, 4.46890295e-02f, 6.73511252e-02f, 1.00912437e-01f,
  1.98892862e-01f, 1.92454979e-01f, 1.10332869e-01f, -5.58038726e-02f, -1.88188016e-01f, 1.02100611e-01f, -1.53638259e-01f, -6.12716265e-02f, -1.89986438e-01f, -3.07082776e-02f,
  -1.90926797e-03f, -2.70743817e-02f, -8.75730515e-02f, 2.39351559e-02f, 1.40844181e-01f, -7.72907436e-02f, 1.00114115e-01f, -2.83856839e-02f, 1.59049958e-01f, 2.33773924e-02f,
  -1.59331754e-01f, 1.15821019e-01f, 1.25526473e-01f, -5.03107384e-02f, 4.24397849e-02f, 7.69563019e-02f, -1.44522786e-01f, 1.28384262e-01f, -1.05005741e-01f, 2.99396440e-02f,
  -1.38015077e-01f, 5.53064756e-02f, 5.68973310e-02f, 1.03102021e-01f, 6.48377556e-03f, 9.15269852e-02f, 1.43900961e-01f, 1.45638466e-01f, 1.61971554e-01f, 1.34629652e-01f,
  1.02601713e-02f, 1.78577304e-01f, -7.76041970e-02f, 5.47627918e-02f, 1.75026506e-01f, 4.29484062e-02f, 9.41266045e-02f, -6.48862589e-03f, 1.19615838e-01f, 1.43563092e-01f,
  1.00126326e-01f, -3.75351794e-02f, -7.02753365e-02f, 9.78090838e-02f, -9.25398618e-03f, 2.51774341e-01f, -3.67953219e-02f, -3.61677632e-02f, 2.80753762e-01f, -9.81792286e-02f,
  1.63994387e-01f, -7.00884685e-02f, 1.20306805e-01f, 1.54454753e-01f, -6.16976172e-02f, 2.26080954e-01f, 1.67728346e-02f, 2.92057861e-02f, -2.48251542e-01f, 2.46068597e-01f,
  1.54649317e-01f, -5.49771897e-02f, 2.53465101e-02f, 1.97388440e-01f, 1.58591181e-01f, -6.96959645e-02f, -8.32253024e-02f, -4.07334380e-02f, 1.26865819e-01f, 6.36901334e-03f,
  1.67798568e-02f, -1.64538801e-01f, 9.18804184e-02f, -5.87578490e-03f, -2.15165000e-02f, 9.21852589e-02f, 5.15298657e-02f, -7.62038454e-02f, 4.74164523e-02f, 1.82716131e-01f,
  2.90684979e-02f, -1.82404239e-02f, 5.10733239e-02f, 1.33047804e-01f, -1.57524958e-01f, -7.05113485e-02f, 4.68524843e-02f, 4.33472134e-02f, 7.43210465e-02f, 4.49532531e-02f,
  -4.27449541e-03f, 9.54276994e-02f, 2.51172911e-02f, -6.51869178e-02f, 3.31608504e-02f, 1.19882502e-01f, -1.23845883e-01f, 1.55075818e-01f, 6.30372316e-02f, -1.49837419e-01f,
  3.48416865e-02f, -1.32556371e-02f, -5.82233369e-02f, 9.19704810e-02f, 8.52963477e-02f, -9.76838470e-02f, 1.33986041e-01f, -8.25791806e-02f, -6.15906529e-02f, -1.51548386e-01f,
  1.38711527e-01f, 1.23680316e-01f, 1.18162468e-01f, -2.42452309e-01f, 1.45598456e-01f, 1.72845230e-01f, -4.14744345e-03f, -4.43941094e-02f, 9.72243845e-02f, 1.14379391e-01f,
  7.24427253e-02f, -7.99844339e-02f, -1.14905596e-01f, 1.64641216e-01f, 1.54220179e-01f, 1.33910944e-04f, 7.73474574e-02f, 3.52155492e-02f, 2.45442875e-02f, 7.83913732e-02f,
  3.16650560e-03f, -1.66118797e-02f, 2.14544404e-02f, -2.74637863e-02f, 1.36102736e-01f, -4.30326676e-03f, 1.21751934e-01f, 1.88134462e-02f, 3.00424062e-02f, 5.26163764e-02f,
  1.26853660e-01f, -5.58911785e-02f, 7.26056471e-02f, 1.24369256e-01f, -1.01108417e-01f, 3.12988833e-02f, 7.45073780e-02f, 8.94681457e-03f, 3.33486646e-02f, -9.57464352e-02f,
  4.25964482e-02f, 7.52452686e-02f, 3.15293251e-03f, -4.92923334e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  9.30719152e-02f, 9.65640135e-03f, -6.55229986e-02f, -1.07566126e-01f, 1.64530277e-02f, 1.13119222e-01f, -6.09656721e-02f, 1.20721593e-01f, -3.63262706e-02f, 5.83226851e-04f,
  5.52286357e-02f, 3.37604247e-02f, -1.32715879e-02f, 1.64106920e-01f, -1.02413066e-01f, 1.20387338e-01f, -3.01046558e-02f, 3.60549428e-02f, -1.13601543e-01f, 3.25329080e-02f,
  7.34006912e-02f, 1.46757990e-01f, 1.46779744e-02f, 2.33687460e-01f, 1.93688378e-01f, 1.44857600e-01f
};

// L2_fan_Wp (Shape: 19 x 64)
const int L2_fan_Wp_rows = 19;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  1.50098965e-01f, 7.55899623e-02f, 1.60669044e-01f, 1.97477371e-01f, 1.08748876e-01f, 9.03709233e-02f, 1.96017921e-01f, -2.70439461e-02f, 6.99066296e-02f, 1.53567076e-01f,
  1.01484977e-01f, 5.28676771e-02f, -4.47347797e-02f, -6.72405064e-02f, 3.44518870e-02f, 1.61858737e-01f, 1.37908801e-01f, 4.26681861e-02f, 7.94172008e-03f, 1.34646401e-01f,
  1.02055058e-01f, -2.37436309e-01f, 7.27921212e-03f, -1.45994887e-01f, -4.03922461e-02f, 1.77704021e-01f, 2.29036570e-01f, -2.06158802e-01f, -7.59469569e-02f, 2.13607699e-01f,
  3.85699235e-02f, 1.03858992e-01f, -1.02540180e-01f, 2.76233815e-02f, -3.60522568e-02f, -7.97922313e-02f, 1.87575057e-01f, -6.17797934e-02f, 6.87693283e-02f, -1.06142871e-01f,
  -3.93575691e-02f, 9.70492978e-03f, 1.85152099e-01f, 1.08224973e-01f, 1.83318760e-02f, -1.02817044e-01f, 1.45463780e-01f, 7.67969266e-02f, 3.32620256e-02f, 3.80353779e-02f,
  3.18672769e-02f, -1.09850122e-02f, -1.25918806e-01f, -1.85933217e-01f, -2.23697707e-01f, -6.50303885e-02f, -5.04707508e-02f, -9.12057459e-02f, 1.40701104e-02f, 5.63239455e-02f,
  6.53440207e-02f, 4.54772599e-02f, -8.42239112e-02f, 4.95443568e-02f, -1.36979595e-01f, -7.43478984e-02f, -1.24498047e-01f, -4.20694463e-02f, 7.55665451e-02f, -1.12487644e-01f,
  5.88092655e-02f, 8.08623359e-02f, -5.83976209e-02f, -1.22188784e-01f, 1.37129063e-02f, 7.66116455e-02f, 1.31575555e-01f, 6.65717050e-02f, 7.44348839e-02f, -7.62707070e-02f,
  5.90760820e-02f, -8.75495374e-02f, -5.67035452e-02f, -1.24187529e-01f, -1.46745399e-01f, -9.76437777e-02f, -1.42561138e-01f, -7.72947222e-02f, -1.72278985e-01f, 2.24882979e-02f,
  -1.44571543e-01f, 1.01174682e-01f, 2.23032888e-02f, -2.23591402e-01f, 1.12587124e-01f, -1.41595960e-01f, -6.99386150e-02f, -7.26140141e-02f, -4.17803153e-02f, 1.18669637e-01f,
  -9.21102986e-02f, 5.58140315e-02f, 1.19016610e-01f, 3.63143645e-02f, 1.25162721e-01f, 5.59278624e-03f, -1.50026217e-01f, -1.07354589e-01f, -3.21351588e-02f, -1.11912219e-02f,
  -4.89619449e-02f, 8.24346244e-02f, 1.37726381e-01f, 8.06453601e-02f, -1.89408250e-02f, 6.21478669e-02f, -1.80938048e-03f, 1.18400387e-01f, -3.33791524e-02f, -8.84643495e-02f,
  7.73108304e-02f, -4.96677905e-02f, -1.73634868e-02f, -4.08836827e-02f, -6.97863549e-02f, -8.10687840e-02f, -6.81873038e-02f, -1.74944609e-01f, -1.07579067e-01f, -1.40027747e-01f,
  9.05230790e-02f, 1.47866204e-01f, -6.28540814e-02f, 8.93642902e-02f, -3.62848341e-02f, -1.35498226e-01f, 9.99957789e-03f, 2.48255744e-03f, -2.94303102e-03f, -4.53680977e-02f,
  8.41872096e-02f, -6.36290163e-02f, 8.68330374e-02f, -3.91508006e-02f, 4.56702486e-02f, 1.40830979e-01f, 1.02228761e-01f, 2.43771732e-01f, -6.66197538e-02f, -1.92297576e-03f,
  -8.08153898e-02f, -1.10651322e-01f, 1.80208981e-01f, 2.13249266e-01f, 3.77392285e-02f, -2.15267628e-01f, -1.24819912e-01f, 2.47084916e-01f, 1.62792295e-01f, 7.13685006e-02f,
  -3.25895078e-03f, 4.53333296e-02f, -5.13654202e-03f, 9.18409824e-02f, 2.01538339e-01f, 1.06743440e-01f, -2.21788604e-02f, 4.04593423e-02f, -1.21657029e-01f, 1.09511480e-01f,
  3.91424485e-02f, 6.46403879e-02f, -6.49523586e-02f, 1.05708763e-01f, 1.66286081e-01f, -1.23893782e-01f, 6.64913133e-02f, -6.92606438e-03f, -4.19347137e-02f, 1.18568167e-01f,
  -1.29625395e-01f, -1.49033025e-01f, -1.97448477e-01f, 8.88243318e-02f, -6.05672263e-02f, -7.92699680e-02f, -1.13003500e-01f, 1.10688694e-01f, -4.68887500e-02f, -1.27687350e-01f,
  1.77517515e-02f, 6.44678995e-02f, -1.47658810e-01f, 3.17341276e-02f, -4.08258066e-02f, 1.20053582e-01f, 4.86952402e-02f, -4.87713590e-02f, -6.64386572e-03f, -1.16567917e-01f,
  -1.13285050e-01f, -6.79687038e-02f, -1.70373786e-02f, -6.76529482e-02f, 9.08877626e-02f, -1.47954211e-01f, -1.20383687e-02f, -6.66847527e-02f, -2.63616778e-02f, 6.81020245e-02f,
  3.54031920e-02f, 1.17043361e-01f, -2.50379115e-01f, -6.97517619e-02f, -2.62252539e-01f, -1.71802416e-01f, -3.73919308e-02f, 8.91934335e-02f, -1.78341895e-01f, 3.43538187e-02f,
  -7.36173242e-02f, -1.09131575e-01f, 2.09953651e-01f, -3.77323246e-03f, 8.53128091e-04f, -7.65195340e-02f, -5.94043881e-02f, 2.98136979e-01f, 6.58852309e-02f, -1.60749272e-01f,
  3.98227796e-02f, -1.12609141e-01f, 7.08524212e-02f, 1.24218583e-01f, -2.13025838e-01f, 1.04311496e-01f, -7.57112056e-02f, -1.07502185e-01f, -1.45841524e-01f, 1.69256926e-01f,
  2.35626310e-01f, 8.23376179e-02f, -8.11954364e-02f, 2.35972434e-01f, 1.31118363e-02f, 3.36058810e-02f, -1.08535655e-01f, 8.84479731e-02f, 1.07159793e-01f, -6.54057488e-02f,
  -1.30138353e-01f, 1.30651817e-01f, -1.36464030e-01f, -2.49629349e-01f, -2.35224009e-01f, -5.08098118e-03f, -4.63417172e-02f, 4.80375141e-02f, -4.32186797e-02f, 6.60582781e-02f,
  -1.21532440e-01f, 6.48832917e-02f, 2.12380290e-03f, 9.70200747e-02f, -3.93272862e-02f, -4.02963609e-02f, -6.38126433e-02f, -1.46307439e-01f, 4.16728631e-02f, 6.50276989e-02f,
  2.79490203e-02f, 6.31034300e-02f, -1.18773272e-02f, -1.20237686e-01f, -1.33037820e-01f, -1.53180555e-01f, -2.36034900e-01f, -8.43435526e-02f, -1.24739364e-01f, -2.38400757e-01f,
  4.65342216e-02f, 3.84955145e-02f, -2.93811888e-01f, 1.79163396e-01f, 1.37476576e-02f, -1.33933604e-01f, 8.76281410e-02f, -3.41479957e-01f, 1.74023747e-01f, -1.24560982e-01f,
  -2.13784635e-01f, 1.91301897e-01f, -4.53172028e-02f, -1.74414262e-01f, 8.92335176e-02f, -9.59146470e-02f, -5.77524118e-02f, 5.06612100e-02f, -1.75919324e-01f, 4.05040458e-02f,
  1.61268767e-02f, 6.08068928e-02f, -1.04844701e-02f, 2.35343874e-01f, 7.09066987e-02f, 1.12004735e-01f, 6.51093423e-02f, 1.05918922e-01f, -1.07656240e-01f, -8.77354003e-04f,
  1.77422643e-01f, -7.28593543e-02f, -7.59586617e-02f, 4.78202030e-02f, 1.21202126e-01f, -5.13963401e-02f, 3.62083763e-02f, -1.73851520e-01f, -4.49700132e-02f, -8.70413333e-02f,
  1.34577602e-01f, 3.66400145e-02f, 7.57818222e-02f, -1.30772889e-01f, 1.13821253e-01f, -5.72913364e-02f, 1.35566875e-01f, 1.00901999e-01f, -5.55575751e-02f, -4.00354490e-02f,
  9.38813016e-02f, -9.13374573e-02f, 1.11755952e-01f, 8.97406712e-02f, 1.33639738e-01f, -2.06683017e-02f, -8.46954510e-02f, -6.62134066e-02f, 9.75373685e-02f, 4.70627286e-02f,
  -2.05859736e-01f, 1.10919312e-01f, 2.60940064e-02f, -2.17056185e-01f, 1.13704987e-03f, -3.66138220e-02f, -1.85394645e-01f, 2.02135563e-01f, 1.43461049e-01f, -8.05837214e-02f,
  1.08909592e-01f, -1.20093204e-01f, 3.77586670e-02f, -8.63625184e-02f, -2.36292467e-01f, -8.55556726e-02f, 7.37262815e-02f, -3.84678543e-02f, 2.96687242e-02f, -1.27312347e-01f,
  -9.50229317e-02f, -8.44181702e-02f, -1.28143579e-01f, 1.54077888e-01f, 6.70430809e-02f, -1.85306594e-01f, -4.87954505e-02f, 2.45459005e-01f, -3.50367352e-02f, 1.28956303e-01f,
  1.32730007e-01f, 5.34640774e-02f, 1.24596827e-01f, -4.60030474e-02f, 2.91146785e-01f, -6.94704577e-02f, 7.92659372e-02f, 1.80758402e-01f, -5.19603305e-02f, 1.13418899e-01f,
  -1.29472077e-01f, -1.01561747e-01f, -2.15674356e-01f, -2.10971594e-01f, 4.58948128e-02f, 3.29081342e-02f, -7.79551417e-02f, 2.19432697e-01f, -4.37600678e-03f, 3.73704098e-02f,
  -3.77983488e-02f, 1.44734010e-01f, -1.88071746e-02f, -5.54357432e-02f, 1.09408252e-01f, 1.27085477e-01f, 1.11620761e-01f, 1.44639574e-02f, 1.00020334e-01f, -1.87104344e-01f,
  1.67669803e-02f, -1.07478006e-02f, 1.78475112e-01f, 2.45711699e-01f, -2.41775036e-01f, -8.09435397e-02f, -2.34679312e-01f, -1.04354516e-01f, 6.72914609e-02f, -6.28746450e-02f,
  -2.41335213e-01f, -1.13845766e-01f, -2.36132577e-01f, -1.87600516e-02f, 4.38215882e-02f, -1.08811453e-01f, -1.56503707e-01f, -3.47295031e-02f, 1.22992083e-01f, 3.43791097e-01f,
  -1.08744651e-02f, -4.73026633e-02f, -4.50965911e-02f, -5.97965866e-02f, 4.87128757e-02f, -5.31397089e-02f, -1.88226312e-01f, -4.16086055e-02f, -3.77805494e-02f, 1.17042333e-01f,
  -1.36901075e-02f, -6.10188916e-02f, 2.12505773e-01f, -2.41988190e-02f, 3.30169126e-02f, 7.90880919e-02f, -1.19070552e-01f, 5.33338869e-03f, -1.87392712e-01f, -3.71547043e-02f,
  1.04309258e-03f, -4.59884964e-02f, -1.87441334e-01f, 4.85651754e-02f, -9.83424932e-02f, -3.53334583e-02f, 1.11470155e-01f, 1.24481851e-02f, 8.37490782e-02f, -1.20720260e-01f,
  -1.56902060e-01f, 2.92798579e-02f, -1.45876026e-02f, -1.23216681e-01f, -2.50180159e-02f, -5.42932339e-02f, 3.17262933e-02f, 8.73355269e-02f, 4.30631898e-02f, -1.44806936e-01f,
  5.35864756e-02f, 4.55843247e-02f, -8.69438052e-02f, -1.30703762e-01f, 3.65749933e-02f, -2.13595107e-01f, -1.08320698e-01f, -3.10724750e-02f, -1.19477203e-02f, -1.89517606e-02f,
  1.30204186e-02f, -4.18737121e-02f, -1.09982297e-01f, -7.43835643e-02f, -3.04649979e-01f, 1.77166775e-01f, -1.40711099e-01f, -2.07412392e-01f, 1.78408384e-01f, -2.60933936e-01f,
  -1.18343746e-02f, 1.42178254e-03f, -1.55802384e-01f, 2.94118553e-01f, -1.17670491e-01f, 1.88276246e-02f, -8.23645517e-02f, -3.34921433e-03f, 1.45019423e-02f, 6.63961619e-02f,
  -2.02265128e-01f, -1.66668575e-02f, -7.74207935e-02f, 9.95166600e-02f, 6.92265704e-02f, 2.74669707e-01f, 1.88290417e-01f, -8.22340325e-02f, 1.06815450e-01f, 1.83721200e-01f,
  1.15497977e-01f, 1.73416927e-01f, 2.32090190e-01f, 3.79782580e-02f, -8.08590651e-02f, -7.02112273e-04f, 1.19736575e-01f, -8.10259283e-02f, -9.28078741e-02f, -1.52638495e-01f,
  1.86579060e-02f, -2.04878032e-01f, 6.59880694e-03f, -1.02399938e-01f, -1.08728945e-01f, 1.62272036e-01f, -6.56164363e-02f, 1.34932950e-01f, -6.50780424e-02f, 9.90696922e-02f,
  -2.15530358e-02f, 1.08232170e-01f, 3.88830295e-03f, -7.80202374e-02f, 1.62755191e-01f, 6.15837416e-05f, 1.60515070e-01f, -1.12810075e-01f, 6.83586150e-02f, -9.73300189e-02f,
  6.38536178e-03f, 2.19827265e-01f, -3.36075872e-01f, -8.01420882e-02f, -7.67841339e-02f, -1.07374094e-01f, 6.18441254e-02f, 8.44508186e-02f, -1.52640477e-01f, 2.32049543e-02f,
  -1.26028344e-01f, -3.10653169e-02f, 1.81552637e-02f, -1.02837503e-01f, 1.49060180e-02f, -2.13815004e-01f, 5.00591174e-02f, 3.50954741e-01f, 1.04894169e-01f, -2.71680132e-02f,
  1.13975406e-01f, 4.05403450e-02f, 5.35100922e-02f, 1.31045073e-01f, -1.55333236e-01f, 1.07087418e-01f, 2.75983009e-02f, -6.30492643e-02f, 5.61289899e-02f, 2.18140572e-01f,
  2.20745236e-01f, 1.67148203e-01f, -3.37347053e-02f, 3.30590494e-02f, 1.30165787e-02f, 2.43986845e-02f, 1.87510714e-01f, 8.94064084e-02f, 2.07029991e-02f, 1.13262743e-01f,
  6.78715482e-02f, -4.89030443e-02f, -1.66569993e-01f, -1.98558360e-01f, -1.68732867e-01f, -1.40316114e-01f, 6.84983507e-02f, -5.35666682e-02f, 6.58147186e-02f, -8.51088241e-02f,
  -3.85969728e-02f, 7.07413703e-02f, -1.58461839e-01f, 2.57883221e-02f, -8.55450556e-02f, -1.42917857e-01f, 4.78799548e-03f, -5.18839480e-03f, 2.77425181e-02f, 1.03038125e-01f,
  8.72613192e-02f, -1.82914771e-02f, -1.18963405e-01f, -1.95266679e-01f, -4.22579162e-02f, -1.55494794e-01f, 2.15355288e-02f, -7.11137941e-03f, -1.34678915e-01f, -1.60487354e-01f,
  -4.62088920e-02f, -1.87325832e-02f, -2.35076860e-01f, 2.14820191e-01f, 1.08917177e-01f, -1.55145824e-01f, 8.22353363e-02f, -2.77298570e-01f, 1.20593905e-01f, 2.44065113e-02f,
  -3.07198763e-01f, 1.47946909e-01f, 1.28976926e-01f, -1.16154388e-01f, 1.16042189e-01f, -8.15073848e-02f, -2.55672745e-02f, 1.02004424e-01f, 5.48264664e-03f, 6.78574592e-02f,
  -7.69604519e-02f, -1.73636496e-01f, -8.06223527e-02f, 7.50927553e-02f, 4.15851399e-02f, -3.07542514e-02f, -4.64744829e-02f, -1.32299904e-02f, -1.13170221e-01f, 1.66182280e-01f,
  9.32102650e-02f, -6.07982129e-02f, -2.90166605e-02f, 4.44206409e-02f, 1.28228739e-01f, -6.74970001e-02f, 1.03165694e-01f, -2.37936780e-01f, -2.06136867e-01f, -1.14744147e-02f,
  6.56809434e-02f, -7.81946555e-02f, -8.87334198e-02f, -3.69694605e-02f, 4.00997512e-02f, 1.53293803e-01f, 1.00953139e-01f, 6.75646514e-02f, 4.80795018e-02f, -4.49764840e-02f,
  -5.41077890e-02f, 1.50794983e-01f, -3.59255709e-02f, -1.24649473e-01f, 8.34648311e-02f, -1.07106686e-01f, 7.83242881e-02f, 1.63777709e-01f, 1.59766555e-01f, 1.95437074e-01f,
  -1.40373439e-01f, -6.80807829e-02f, 4.42322083e-02f, 5.11749908e-02f, 1.66183472e-01f, -2.04212368e-02f, 1.31716356e-01f, -2.68243432e-01f, 4.01269905e-02f, 2.26566672e-01f,
  1.20718852e-01f, 1.30176261e-01f, -1.50990874e-01f, 9.87900868e-02f, 2.35697955e-01f, -1.10396616e-01f, 1.06477857e-01f, -3.54532637e-02f, -1.08753825e-02f, 1.07213631e-01f,
  1.25549987e-01f, -1.12681441e-01f, -2.37710960e-02f, -1.04375117e-01f, -1.08730190e-01f, 1.45033181e-01f, -5.49849309e-02f, -1.94943964e-01f, 2.97364648e-02f, 1.00769594e-01f,
  -7.81951398e-02f, 1.01746358e-01f, 6.93501607e-02f, -7.14418143e-02f, -5.99502847e-02f, -6.30696937e-02f, 6.11124048e-03f, -8.60774368e-02f, -1.80727288e-01f, 1.04419753e-01f,
  1.03315096e-02f, -7.40997866e-02f, 6.40040860e-02f, 1.22877017e-01f, 6.79781437e-02f, -2.31013559e-02f, -7.34530911e-02f, 1.25784844e-01f, -6.99913576e-02f, 4.50572334e-02f,
  8.76959935e-02f, 1.35446191e-01f, 5.84081039e-02f, 6.94100931e-02f, -9.16803181e-02f, 3.50974463e-02f, -6.02928512e-02f, -1.44989416e-01f, 7.88433701e-02f, 1.64427999e-02f,
  6.68677464e-02f, 4.97290380e-02f, -3.82623374e-02f, 1.67919040e-01f, -1.56192124e-01f, -4.15276363e-03f, 2.09693667e-02f, 7.55022317e-02f, 2.24847764e-01f, -2.03775498e-03f,
  -7.41860271e-02f, -1.49902344e-01f, -2.04563558e-01f, 3.15257162e-03f, 1.77158304e-02f, 1.06719300e-01f, 1.94792897e-02f, -4.44428734e-02f, 1.74638465e-01f, 1.01875938e-01f,
  1.09105192e-01f, -1.28581263e-02f, 5.41456304e-02f, -1.20347805e-01f, 9.39024389e-02f, 1.02537356e-01f, 9.20575932e-02f, -1.23261276e-03f, -1.51552618e-01f, 9.52524766e-02f,
  6.60855174e-02f, -7.32058436e-02f, 1.59815937e-01f, 3.84702384e-02f, -1.16789080e-02f, 5.00783361e-02f, -1.16682842e-01f, 6.86130524e-02f, -1.65942162e-01f, -2.89188549e-02f,
  -8.67191255e-02f, -9.60942879e-02f, 3.78222652e-02f, 1.11665010e-01f, 6.73543960e-02f, -2.05024555e-01f, 1.15406811e-01f, -1.01188822e-02f, -7.35923648e-02f, -9.92504358e-02f,
  -9.20898393e-02f, 4.20857035e-02f, -9.92769599e-02f, 7.85363615e-02f, 4.41000302e-04f, -1.38554618e-01f, 2.99501307e-02f, 1.45679489e-01f, -1.17707392e-02f, -5.55835478e-02f,
  -9.35899764e-02f, 6.11365139e-02f, 5.04118502e-02f, 5.94261140e-02f, -1.56032247e-02f, -9.50902626e-02f, -1.03149898e-01f, -2.60335188e-02f, -5.65466136e-02f, 1.39433488e-01f,
  6.47908002e-02f, -9.87650603e-02f, -2.16362178e-01f, -9.83165652e-02f, 3.28421555e-02f, 2.04434276e-01f, 1.78351983e-01f, -2.49918237e-01f, 2.80748028e-02f, 8.61912686e-03f,
  6.22056499e-02f, -5.22519983e-02f, -1.95383593e-01f, -2.46385075e-02f, -5.92066534e-02f, -4.28007636e-03f, 8.25658515e-02f, 4.95824739e-02f, -1.09935805e-01f, 1.13528222e-02f,
  5.32919578e-02f, 9.85721350e-02f, -6.80266321e-02f, -1.54299244e-01f, -2.92056445e-02f, -8.99138376e-02f, 5.02220206e-02f, -1.23580076e-01f, 1.13505796e-01f, -6.33853376e-02f,
  1.28000572e-01f, 1.61120206e-01f, 8.63171592e-02f, 1.06971815e-01f, -1.18692867e-01f, 1.44496813e-01f, 1.48069218e-01f, 7.01290220e-02f, 1.24510318e-01f, 9.09111202e-02f,
  -5.99050038e-02f, -9.20286849e-02f, 4.35884260e-02f, 1.32476345e-01f, 1.29594132e-01f, -8.09495598e-02f, 4.07921933e-02f, 3.80088985e-02f, 4.42660078e-02f, -5.47510274e-02f,
  1.32635593e-01f, -5.97207956e-02f, -1.09817438e-01f, 7.61412457e-03f, -4.12397869e-02f, -3.63857560e-02f, -7.95013234e-02f, -1.52869567e-01f, -1.26198895e-04f, 7.56862164e-02f,
  2.24299114e-02f, 1.66424401e-02f, -5.81859909e-02f, -1.87812746e-01f, -6.77247792e-02f, -1.68310348e-02f, 1.87453493e-01f, 1.70988634e-01f, 1.26225099e-01f, -2.98557729e-01f,
  -1.85434595e-01f, 1.89854309e-01f, 1.18968897e-01f, 5.21786921e-02f, -1.24454573e-01f, -5.24709225e-02f, -1.08302794e-02f, 1.19295321e-01f, 3.63231935e-02f, -7.46356472e-02f,
  7.67927393e-02f, -6.12369739e-02f, 8.25308338e-02f, 3.45705599e-02f, 1.63035557e-01f, 1.38727307e-01f, 1.50436303e-02f, -1.11672571e-02f, 1.13001190e-01f, -4.03081849e-02f,
  -8.41662940e-03f, 4.01029177e-02f, -1.21853026e-02f, -2.71507017e-02f, 2.28253454e-02f, -1.40574481e-02f, -6.98522851e-02f, 4.27448750e-02f, 1.33552607e-02f, -1.05688833e-01f,
  1.40659377e-01f, 8.16114396e-02f, -3.80921699e-02f, -1.34133324e-01f, 1.78832129e-01f, 1.45629346e-01f, -1.79324411e-02f, -4.82404837e-04f, -2.18732152e-02f, 6.26474842e-02f,
  9.96371135e-02f, 2.77498122e-02f, 9.96076465e-02f, -1.12336002e-01f, -4.55006063e-02f, 7.68977478e-02f, -4.81412411e-02f, 1.15916781e-01f, -1.25670522e-01f, 4.96445969e-02f,
  -4.27997150e-02f, -1.48054436e-01f, -6.86459169e-02f, -5.49999392e-03f, 1.18366256e-01f, 2.50348747e-01f, -1.09003209e-01f, -4.23837900e-02f, -7.51035586e-02f, 1.54043764e-01f,
  2.13610619e-01f, -5.63538074e-02f, 1.14359058e-01f, -1.26334265e-01f, -8.54732394e-02f, 2.50811279e-01f, 4.22807001e-02f, 1.66650146e-01f, -1.73903167e-01f, -8.41655582e-02f,
  6.32610917e-02f, 9.38860178e-02f, 1.22872531e-01f, -1.06949024e-02f, 7.20654875e-02f, 4.04993556e-02f, -1.28158405e-02f, -3.48341279e-02f, 9.75021347e-02f, 2.73414068e-02f,
  -5.11394702e-02f, 1.84593722e-01f, 1.31554678e-01f, -1.62861735e-01f, -1.23884946e-01f, -4.38468568e-02f, 7.68507421e-02f, 9.57611576e-02f, -3.59202623e-02f, -1.69342592e-01f,
  -2.38516673e-01f, -2.61118729e-02f, -7.64031187e-02f, -7.22747147e-02f, -3.02269235e-02f, -1.17087826e-01f, 7.30302185e-02f, 1.23215124e-01f, 4.00596373e-02f, 3.22164856e-02f,
  4.68010940e-02f, -1.10959709e-01f, 7.88570344e-02f, -7.54387379e-02f, -8.17446560e-02f, 1.19684458e-01f, -9.38561782e-02f, -1.56035557e-01f, -1.09014899e-01f, -2.00965330e-02f,
  -1.15831211e-01f, 7.47572631e-03f, -1.12436913e-01f, -3.99274155e-02f, -2.62915157e-03f, -2.50794869e-02f, -5.24561070e-02f, 1.07947126e-01f, -7.30285347e-02f, -6.40351325e-02f,
  6.90781921e-02f, 3.21378885e-03f, -9.63553712e-02f, -1.25167385e-01f, 6.99979886e-02f, 1.65927112e-02f, 1.40081421e-01f, -2.98362877e-02f, -4.83412221e-02f, 2.00726427e-02f,
  -1.21081658e-01f, 9.58926789e-03f, 7.74492174e-02f, 1.11152194e-01f, -1.66580260e-01f, 5.19758947e-02f, 8.95064399e-02f, -1.21518016e-01f, 1.31932974e-01f, 8.22523609e-02f,
  -1.00560658e-01f, -1.04475699e-01f, -6.37720749e-02f, 1.29349291e-01f, -2.87985876e-02f, 1.59263108e-02f, 1.08302668e-01f, 8.50894377e-02f, -2.62728520e-02f, 6.70313165e-02f,
  -3.77114415e-02f, -8.06942210e-02f, -4.24083360e-02f, -4.19434160e-02f, -3.81075926e-02f, -1.30050853e-01f, 1.23307347e-01f, 2.42711324e-02f, 4.37311791e-02f, 1.21747836e-01f,
  2.25797743e-02f, -5.99359348e-02f, 9.30881575e-02f, -1.88370682e-02f, 9.82700437e-02f, -7.84469545e-02f, 2.39321999e-02f, -7.01720491e-02f, 6.75102919e-02f, -7.57110640e-02f,
  -6.04931898e-02f, 4.12284993e-02f, 1.02883376e-01f, 7.25669563e-02f, 7.42781684e-02f, -3.99523266e-02f, 1.03143133e-01f, 4.35640439e-02f, 2.20431946e-02f, 6.11591488e-02f,
  -4.26148660e-02f, -4.56947722e-02f, -3.98420207e-02f, -1.61767360e-02f, -1.97820246e-01f, -4.37484384e-02f, -1.65582374e-01f, -1.78224683e-01f, 6.26131892e-03f, 9.32455435e-02f,
  -1.93085462e-01f, 8.57711285e-02f, 2.00882629e-02f, -1.54453903e-01f, -4.44054492e-02f, -2.50145018e-01f, -7.55501986e-02f, -1.60587057e-01f, -1.34729803e-01f, 1.28886223e-01f,
  -9.38418731e-02f, -5.35245202e-02f, 5.12404218e-02f, 8.95886347e-02f, -7.67933624e-03f, -7.67890289e-02f, -1.09608032e-01f, -7.67496973e-02f, 1.40303338e-03f, -7.46913254e-02f,
  -1.30927116e-01f, 2.07802102e-01f, 7.83900321e-02f, 1.24000125e-02f, 1.39097020e-01f, 2.18614340e-01f, -2.96605621e-02f, -2.67928988e-02f, 1.33761421e-01f, 4.40607034e-02f,
  4.10778960e-03f, 1.39755502e-01f, 5.07251243e-04f, 1.23697504e-01f, 1.05727218e-01f, -1.54623359e-01f, -2.16881588e-01f, -9.81957465e-02f, -1.92120552e-01f, -3.65964621e-02f,
  1.26579870e-02f, 4.32217633e-03f, 6.41251132e-02f, -1.48694247e-01f, -1.21253118e-01f, -7.20714033e-02f, 3.53279412e-02f, -8.93241316e-02f, 1.29241064e-01f, -3.96204889e-02f,
  -5.74356467e-02f, -1.35852516e-01f, 3.02186459e-02f, -1.22902930e-01f, -5.99577650e-02f, 8.47328603e-02f, -1.52914912e-01f, -6.42556325e-02f, -1.71003610e-01f, 4.60325293e-02f,
  -8.32117200e-02f, 1.86966091e-01f, -3.63278501e-02f, -1.71842039e-01f, -1.44116312e-01f, 2.54028022e-01f, 1.51256830e-01f, -1.48048475e-01f, -1.06365994e-01f, 4.43785749e-02f,
  6.79665431e-02f, -5.20277843e-02f, 2.19571050e-02f, 1.57558516e-01f, -7.52996355e-02f, -5.39364927e-02f, -9.92500633e-02f, -6.13913611e-02f, 1.14012532e-01f, 5.37102371e-02f,
  -1.58501253e-01f, -1.68760985e-01f, -1.00214392e-01f, 1.09021947e-01f, -1.62584603e-01f, -1.04750842e-01f, -1.64729103e-01f, -1.35620818e-01f, -5.82609400e-02f, -9.83157307e-02f,
  2.42962483e-02f, 1.51371345e-01f, -8.22481140e-02f, 8.71060938e-02f, -4.69400454e-03f, 9.43938196e-02f, -7.48711675e-02f, 5.72266988e-03f, 1.15607984e-01f, -7.94909149e-02f,
  -1.18946485e-01f, -4.27244138e-03f, -1.29587576e-01f, -3.12713385e-02f, -4.18552309e-02f, -1.08016133e-01f, -4.74391282e-02f, -1.44843802e-01f, -1.36718184e-01f, -9.23082083e-02f,
  3.98505554e-02f, 5.20266518e-02f, 1.19733550e-01f, 2.97834557e-02f, 1.54610112e-01f, 3.04730199e-02f, -1.03662618e-01f, -6.11596294e-02f, 1.10129137e-02f, -9.39817801e-02f,
  -6.15505576e-02f, -9.57408026e-02f, -2.06873164e-01f, 7.13175461e-02f, 6.49625510e-02f, -5.56453504e-02f, 4.63903649e-03f, -1.61543563e-01f, -1.21119738e-01f, 2.00162549e-02f,
  3.13032675e-03f, -7.71677494e-02f, 4.79204729e-02f, -2.62251347e-01f, 1.50396705e-01f, 7.74578284e-03f, -1.34613782e-01f, 2.35804871e-01f, -6.12110347e-02f, -2.87509952e-02f,
  -1.16279207e-01f, -1.12846084e-01f, -1.89113477e-03f, 7.71185383e-02f, -8.90796706e-02f, 9.83355790e-02f, -1.31962121e-01f, 3.98041420e-02f, -1.63324416e-01f, 2.47530073e-01f,
  1.02331229e-01f, 6.24200888e-02f, 1.98851712e-02f, 1.98472381e-01f, -3.67074981e-02f, 1.70491174e-01f, 1.63533539e-01f, 1.00975081e-01f, -2.94582620e-02f, 5.61298840e-02f,
  -1.23350453e-02f, 9.30100232e-02f, -1.23826526e-01f, -1.96985871e-01f, -1.30306855e-01f, -1.85831398e-01f
};

// L2_fan_Wp_bar (Shape: 26 x 64)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  6.27164170e-02f, -5.00677638e-02f, 9.01451260e-02f, 1.76424861e-01f, 1.14191286e-01f, 1.69032037e-01f, 2.13668682e-02f, -1.09797113e-01f, 9.65689048e-02f, 8.36857930e-02f,
  1.03532158e-01f, 4.72978055e-02f, 1.60470426e-01f, 1.62547350e-01f, 1.34596881e-02f, 8.93153399e-02f, 1.17613852e-01f, -7.71681443e-02f, -3.55150066e-02f, 1.63263738e-01f,
  -1.63470641e-01f, -8.16922411e-02f, 5.43163754e-02f, -2.09711403e-01f, -7.49590248e-02f, -4.37009633e-02f, -1.21978186e-01f, -1.50753660e-02f, -1.35418430e-01f, -1.46747455e-01f,
  2.12559387e-01f, -1.29521981e-01f, -9.01649669e-02f, -3.50489654e-02f, -6.42589256e-02f, 8.46701413e-02f, 1.17658518e-01f, -7.26760626e-02f, 1.06133729e-01f, -1.11207120e-01f,
  -1.02994233e-01f, 7.07452074e-02f, -6.66434243e-02f, 1.98339727e-02f, -6.79889023e-02f, 1.36792600e-01f, -2.84940992e-02f, 1.06753901e-01f, 2.55128473e-01f, 1.13712966e-01f,
  1.24165453e-01f, 3.82637121e-02f, -1.15074195e-01f, 8.02554339e-02f, 9.69464481e-02f, -3.50314169e-03f, -8.57090577e-02f, 6.94534406e-02f, 1.25767961e-01f, 8.12787935e-03f,
  5.78392446e-02f, -3.21622193e-02f, -1.01277664e-01f, 8.12842473e-02f, -3.05415150e-02f, 2.55774800e-02f, 1.12601452e-01f, -1.49848508e-02f, -2.67785881e-02f, -4.96175140e-02f,
  2.97943167e-02f, -4.18521045e-03f, -5.09016067e-02f, -5.07045984e-02f, -9.33795348e-02f, 3.11426111e-02f, 6.83518574e-02f, 4.75577042e-02f, 9.11183562e-03f, 1.30318031e-01f,
  3.92169654e-02f, -7.11028129e-02f, 7.46423826e-02f, 2.79718582e-02f, 1.05656952e-01f, -1.11778285e-02f, -6.87795877e-02f, 1.20268039e-01f, -1.30596280e-01f, 6.15140796e-02f,
  -1.43757880e-01f, 5.04303798e-02f, -9.31160077e-02f, -1.02785803e-01f, 2.62824148e-02f, -1.31779030e-01f, 1.00080758e-01f, 6.98903725e-02f, 2.81279273e-02f, -2.61651445e-02f,
  3.35997938e-05f, -6.93146586e-02f, -5.40230237e-02f, 4.94955145e-02f, -5.48466854e-02f, 3.09891663e-02f, 2.67916862e-02f, -4.86525632e-02f, 8.98969173e-03f, 8.84112194e-02f,
  -4.03829217e-02f, 7.96687827e-02f, -8.99464414e-02f, -1.09914131e-01f, -9.34644490e-02f, 4.04587090e-02f, 5.77205680e-02f, -7.36879706e-02f, -5.95824979e-02f, 6.71463041e-03f,
  -1.07155414e-02f, 1.09976642e-01f, -3.76119427e-02f, -2.74409018e-02f, 2.99006477e-02f, 8.24211091e-02f, -7.90296197e-02f, -2.81699952e-02f, 1.48579746e-01f, 7.26833940e-02f,
  5.54263256e-02f, -1.26704365e-01f, -3.75638939e-02f, 1.63824186e-02f, 1.11236252e-01f, 1.69692874e-01f, -6.40668124e-02f, 1.36254951e-01f, 1.30818650e-01f, -2.28897892e-02f,
  7.90299028e-02f, -7.13796318e-02f, -5.34511581e-02f, 8.97973485e-04f, -6.34363070e-02f, -6.05388172e-02f, -5.56817986e-02f, -1.56787068e-01f, 9.72872451e-02f, 1.09817937e-01f,
  8.71711969e-02f, 8.92608091e-02f, -1.81813136e-01f, -1.58745050e-01f, -8.28228965e-02f, 7.35739917e-02f, 8.51155221e-02f, -7.23451609e-03f, -6.86551556e-02f, 6.32060170e-02f,
  1.65483624e-01f, 1.39338925e-01f, -7.65850767e-02f, -1.03338443e-01f, -3.67002711e-02f, 7.79649317e-02f, -8.84592067e-03f, 3.63446511e-02f, 9.88587141e-02f, 1.04560867e-01f,
  3.13346572e-02f, -1.83613207e-02f, 1.07231140e-01f, 2.48384085e-02f, -5.74664362e-02f, -1.34691760e-01f, -1.28603026e-01f, -6.60484135e-02f, -5.33955097e-02f, 4.72717471e-02f,
  1.17773034e-01f, 7.07908347e-02f, 6.48053363e-02f, 3.62367369e-03f, 6.91316500e-02f, -8.45228974e-03f, 7.69783780e-02f, -1.27657518e-01f, -1.14906885e-01f, 2.86419522e-02f,
  2.13908046e-01f, -4.30328920e-02f, -1.09784611e-01f, 1.03361737e-02f, -2.82950848e-02f, -1.13150164e-01f, -6.09149551e-03f, -4.58331779e-03f, -6.79482743e-02f, 4.12983671e-02f,
  -1.04011297e-02f, 3.26335765e-02f, 4.67399284e-02f, -1.61083378e-02f, -9.11346152e-02f, 4.17676270e-02f, -1.12681285e-01f, -2.11457685e-02f, -9.62221473e-02f, -7.69614056e-02f,
  -7.73720741e-02f, 9.14722681e-03f, -7.00637922e-02f, 2.40483489e-02f, 8.01460370e-02f, 1.57858431e-02f, 7.29049742e-02f, 7.58923665e-02f, -1.35149822e-01f, 3.32705565e-02f,
  8.60061496e-02f, -4.64313515e-02f, 3.27021219e-02f, -1.07850440e-01f, -8.75522662e-03f, 2.47357152e-02f, 8.96932855e-02f, 4.83033620e-02f, -2.09327061e-02f, 8.86605829e-02f,
  6.21083425e-03f, -6.67246431e-02f, -3.12116668e-02f, 9.47964564e-02f, -6.48872554e-02f, 5.63591979e-02f, 6.29566833e-02f, 1.20985068e-01f, -5.42506389e-03f, 8.00446272e-02f,
  -2.20588129e-02f, -3.49878483e-02f, -3.63478996e-02f, 1.64778344e-02f, 1.10191613e-01f, 5.29007614e-02f, 6.78743646e-02f, 1.33309677e-01f, 5.40522719e-03f, 7.71493465e-02f,
  4.49073873e-02f, -2.03267094e-02f, 1.02822520e-01f, 5.80651872e-02f, 5.52773252e-02f, 7.57911131e-02f, 6.71913922e-02f, 5.48437871e-02f, -1.03431672e-01f, -7.54447579e-02f,
  4.28262725e-02f, -7.03965798e-02f, 9.62405652e-03f, -1.13328986e-01f, -9.58587751e-02f, 1.20825179e-01f, 4.70313653e-02f, -7.29577020e-02f, 4.90020066e-02f, 2.48345863e-02f,
  -9.76446271e-03f, -5.88708483e-02f, -4.22590449e-02f, -7.95977041e-02f, -4.19212058e-02f, 5.08425012e-02f, 1.28398135e-01f, -9.50753465e-02f, -6.72664419e-02f, -5.05545959e-02f,
  -1.37376219e-01f, -1.33741930e-01f, -8.86390805e-02f, 7.84734115e-02f, 4.32094522e-02f, -5.08324318e-02f, -6.67815879e-02f, 4.48992825e-04f, 3.11596543e-02f, -8.66231546e-02f,
  4.23459113e-02f, -6.82001784e-02f, -8.60416144e-02f, 6.61747307e-02f, -1.15109473e-01f, 3.51123661e-02f, -9.29374546e-02f, -4.31133546e-02f, -8.16274583e-02f, -2.15656087e-02f,
  -6.28537172e-03f, -6.26322925e-02f, -1.19589895e-01f, -2.35055406e-02f, -6.44843876e-02f, 5.79645075e-02f, -2.42980365e-02f, 2.88980342e-02f, 5.19527197e-02f, 8.49186033e-02f,
  2.68701464e-02f, 8.70046914e-02f, -1.14454351e-01f, 1.22414395e-01f, -5.63420244e-02f, -1.15242442e-02f, 1.89759452e-02f, -4.08694670e-02f, 3.54545712e-02f, -1.05757974e-01f,
  5.60628735e-02f, 6.86415732e-02f, 7.73468316e-02f, -8.01267568e-03f, -1.21717617e-01f, 7.63703138e-02f, 2.94297542e-02f, -9.49028358e-02f, -9.05672088e-02f, 2.23369114e-02f,
  2.27623768e-02f, 3.65946032e-02f, -3.01630329e-02f, -5.79983220e-02f, -8.54190663e-02f, -7.82810375e-02f, -1.41020089e-01f, 4.57661897e-02f, -4.57436070e-02f, 1.03719598e-02f,
  3.86378542e-02f, -5.27231842e-02f, 3.87912318e-02f, -1.53908040e-02f, -4.54087518e-02f, 9.76182334e-03f, 1.17293773e-02f, 1.11416280e-01f, -7.41635412e-02f, 6.11636192e-02f,
  3.13709006e-02f, -1.47215024e-01f, -7.92906061e-03f, 2.14864537e-02f, -3.55011784e-02f, 4.68169935e-02f, -9.96085852e-02f, -3.14852633e-02f, 3.58780734e-02f, -1.22406341e-01f,
  2.67662518e-02f, -9.35325176e-02f, 5.15016541e-02f, -7.09423050e-02f, -3.41501310e-02f, -4.45137024e-02f, -9.61517543e-02f, 1.37136385e-01f, 1.30387366e-01f, -8.89970586e-02f,
  1.13332622e-01f, 8.41391832e-02f, 4.72617224e-02f, -8.45514163e-02f, 7.53589422e-02f, -5.77175841e-02f, 7.21891671e-02f, 2.78582275e-02f, 1.43852383e-01f, 6.99572116e-02f,
  -5.40071055e-02f, 5.96101433e-02f, 4.51362506e-03f, 1.09985936e-02f, 8.27593356e-02f, 1.39404625e-01f, 7.41900429e-02f, 1.21227734e-01f, 1.77232716e-02f, 2.15530232e-01f,
  1.08318292e-01f, -6.79228529e-02f, 9.58897844e-02f, 1.84412882e-01f, 7.20584840e-02f, 9.34579670e-02f, -5.28836064e-03f, 5.54008409e-02f, 1.14855528e-01f, 1.54229328e-01f,
  -1.83289237e-02f, -3.86685431e-02f, 4.29338962e-02f, -5.51602319e-02f, 6.64240345e-02f, -2.50022262e-01f, -1.38107017e-01f, -9.63545591e-02f, -1.38346404e-02f, 1.80726275e-01f,
  -8.53612423e-02f, -2.28385657e-01f, -1.06730305e-01f, 2.26251945e-01f, 1.45083249e-01f, -2.74511408e-02f, -1.64047524e-01f, 4.14171033e-02f, 3.32199782e-02f, 1.21895857e-01f,
  3.26148540e-01f, -6.18635155e-02f, -2.94541791e-02f, 3.16818692e-02f, -6.94523677e-02f, 7.00554699e-02f, 1.98715031e-01f, 2.25520749e-02f, -1.02988295e-01f, 2.48450078e-02f,
  1.14505544e-01f, 2.54898727e-01f, 2.52537668e-01f, 1.70281649e-01f, -6.54681101e-02f, 1.31636262e-01f, -1.04411252e-01f, -8.77184868e-02f, 4.80949841e-02f, -1.21899679e-01f,
  5.32383993e-02f, -8.54234118e-03f, -1.40475109e-02f, 6.33319616e-02f, 7.00150579e-02f, -3.81892212e-02f, -1.53562697e-02f, 1.36028454e-01f, 1.31805977e-02f, 1.69464260e-01f,
  -1.75533071e-02f, -6.12160563e-02f, 9.73951295e-02f, 1.89702094e-01f, 1.63062230e-01f, 8.69592726e-02f, 1.38447985e-01f, 1.67721108e-01f, -4.29415181e-02f, 1.23930559e-01f,
  1.09830335e-01f, 1.33112311e-01f, 1.12495176e-01f, 1.47967888e-02f, 3.01627479e-02f, -5.81046939e-02f, 1.20453171e-01f, -4.99589555e-03f, 3.89039586e-03f, -1.07071862e-01f,
  1.23082332e-01f, 7.61099756e-02f, 1.62184447e-01f, 7.23911077e-02f, 3.07426870e-01f, -1.96606353e-01f, 9.28147957e-02f, 2.16471761e-01f, -9.79742315e-03f, 7.49983490e-02f,
  -5.00791415e-04f, 1.88064039e-01f, -6.79769292e-02f, -2.06782043e-01f, 1.44798204e-01f, -4.50793989e-02f, 9.62354317e-02f, -3.71788852e-02f, -9.03465152e-02f, 9.08360183e-02f,
  -1.95701458e-02f, 4.94371653e-02f, 8.70549828e-02f, -1.47478297e-01f, 8.88739750e-02f, -6.78253267e-03f, 1.10247314e-01f, 1.40272215e-01f, 1.09692767e-01f, 9.36753675e-02f,
  9.18231979e-02f, -1.73738882e-01f, -1.44600384e-02f, -5.91121055e-02f, 8.89945030e-03f, -1.17033601e-01f, -1.50467260e-02f, 1.49748906e-01f, -1.35371372e-01f, 1.80598587e-01f,
  8.91636536e-02f, -7.74660008e-03f, 3.55193280e-02f, 1.04378484e-01f, 1.69165358e-01f, 2.61474222e-01f, 1.33407027e-01f, 2.19332248e-01f, 1.51890868e-04f, 1.27486482e-01f,
  9.65012610e-02f, 1.41673908e-01f, 1.27737507e-01f, 3.95533331e-02f, -2.23113503e-02f, -6.54803123e-03f, -1.05626890e-02f, -1.95760913e-02f, 3.73643972e-02f, 2.04895124e-01f,
  8.51506442e-02f, 2.22621292e-01f, 7.78408274e-02f, -8.11489299e-02f, -1.29268155e-01f, -1.98686682e-02f, 1.72386020e-01f, -1.04876436e-01f, 7.47438073e-02f, -1.43592417e-01f,
  1.54417986e-02f, 1.71763584e-01f, 6.20817617e-02f, 3.17551583e-01f, -2.22738847e-01f, 1.27775833e-01f, 3.31342101e-01f, 2.93076366e-01f, -1.30585626e-01f, -9.04844478e-02f,
  -7.94904903e-02f, 1.37280717e-01f, 1.57376155e-01f, 4.36374396e-02f, -5.91554120e-02f, -7.04672709e-02f, -8.32315683e-02f, 2.77159065e-01f, 1.85599700e-01f, -1.85864091e-01f,
  1.96036011e-01f, -8.51660501e-03f, -3.69077316e-03f, -4.62248595e-03f, -5.80951534e-02f, 1.55689478e-01f, -7.36265630e-02f, 1.68498736e-02f, -1.21632926e-01f, -2.25719018e-03f,
  -1.08129427e-01f, -1.09472148e-01f, 4.11297046e-02f, 8.21053088e-02f, 2.37529173e-01f, -9.16521624e-02f, -9.49184820e-02f, -9.98360142e-02f, -2.62888502e-02f, 8.82112831e-02f,
  3.69082950e-02f, -4.38434891e-02f, 4.04887311e-02f, 8.85384679e-02f, 7.71829765e-03f, 9.33815390e-02f, -7.04898778e-03f, 6.83042407e-02f, -1.09732591e-01f, -8.91484097e-02f,
  6.55619800e-02f, -1.32625878e-01f, -6.47770762e-02f, 9.39090550e-02f, -5.70099317e-02f, 5.32625169e-02f, 7.72562772e-02f, 1.83541961e-02f, -8.70574340e-02f, -8.71475339e-02f,
  6.44165874e-02f, 4.01842147e-02f, 2.24640965e-02f, 1.34541288e-01f, 6.86229616e-02f, -2.03304701e-02f, -9.24346671e-02f, -8.73562917e-02f, 6.75432160e-02f, -1.22385003e-01f,
  1.14313692e-01f, -4.30860035e-02f, -1.27685070e-01f, -3.84341460e-03f, 5.18608615e-02f, -8.38714689e-02f, -1.15298375e-01f, 6.83062971e-02f, 6.67797476e-02f, 1.56206777e-02f,
  -7.18507543e-02f, 5.73149361e-02f, -3.79791968e-02f, 4.50153127e-02f, 1.10825486e-01f, -5.68413325e-02f, 4.18210812e-02f, 1.94895286e-02f, -1.91580958e-03f, -8.86227340e-02f,
  -8.20646957e-02f, -8.46143737e-02f, -7.50057846e-02f, -3.99078988e-02f, 5.76783232e-02f, 4.40881178e-02f, 1.53853949e-02f, 1.20858625e-01f, -1.23463236e-01f, -8.73191804e-02f,
  6.43811822e-02f, -9.30087790e-02f, -3.41737494e-02f, 6.19990043e-02f, -1.30196325e-02f, 1.10353582e-01f, 8.42234120e-03f, -5.19760028e-02f, -2.70388648e-02f, 4.42642644e-02f,
  8.35494488e-04f, -1.54285356e-02f, 1.02309197e-01f, -5.66705875e-02f, 1.08023651e-01f, -3.68203335e-02f, -4.55465913e-03f, 7.86007792e-02f, -2.72183400e-02f, 6.76778629e-02f,
  1.03513233e-01f, -3.68644819e-02f, -1.38254871e-03f, -6.22593835e-02f, 1.42450169e-01f, -5.97882085e-02f, 6.11421466e-02f, 3.10241897e-02f, 1.03380024e-01f, -7.15645924e-02f,
  -2.79103946e-02f, -9.64366719e-02f, -1.23493828e-01f, 1.31685687e-02f, -1.03151806e-01f, 6.01116568e-02f, 2.13140231e-02f, 1.18049160e-01f, -2.69921478e-02f, -9.50482935e-02f,
  4.89687547e-02f, 1.90269221e-02f, -1.11865006e-01f, -1.07299037e-01f, -1.08945012e-01f, 1.25509769e-01f, 8.24658722e-02f, 5.43512851e-02f, 2.29581911e-02f, 1.24816701e-01f,
  -1.52122881e-02f, -5.16800918e-02f, -3.78802279e-03f, -8.12687352e-02f, -8.74885321e-02f, 1.07378468e-01f, 1.08025763e-02f, -4.28031683e-02f, 3.07338815e-02f, 8.97640362e-02f,
  -1.12727955e-01f, 9.03000012e-02f, -7.72181749e-02f, 9.46908370e-02f, 8.49424824e-02f, 7.19808415e-02f, 1.01900697e-01f, -9.77829024e-02f, 4.11083642e-03f, -1.12236224e-01f,
  3.55851613e-02f, -6.62571341e-02f, 4.94793281e-02f, 1.21590104e-02f, 6.24291636e-02f, 3.95543315e-02f, -3.08698881e-02f, -1.00387238e-01f, -9.06849802e-02f, 3.22398701e-04f,
  -9.61311311e-02f, 1.09058678e-01f, -3.87667082e-02f, 3.46587412e-02f, 1.36166066e-01f, 4.32203002e-02f, 1.34843737e-01f, 1.05719253e-01f, -8.46040621e-02f, -4.77537103e-02f,
  -1.03489317e-01f, -7.52732977e-02f, 6.71919016e-03f, 1.25390068e-01f, 5.34237698e-02f, 5.18836826e-02f, 1.04682498e-01f, -6.07892014e-02f, -9.81995687e-02f, -7.98596963e-02f,
  -1.30043358e-01f, 6.26503080e-02f, 5.58402911e-02f, -1.12092257e-01f, -9.37135816e-02f, 6.68371245e-02f, 1.37488768e-01f, -1.16149083e-01f, -7.08900800e-04f, 1.12565830e-01f,
  6.91646012e-03f, -2.39684079e-02f, 1.03978924e-01f, 1.14826106e-01f, 2.64831819e-02f, -6.39880374e-02f, 8.63656476e-02f, 1.03867769e-01f, -6.98147640e-02f, 2.57494729e-02f,
  -6.42693369e-03f, 9.18187723e-02f, 3.66848335e-02f, -9.23989117e-02f, 2.51638591e-02f, -8.22480097e-02f, 8.36255848e-02f, 2.80594584e-02f, -5.65324649e-02f, 1.84534818e-01f,
  -4.03190330e-02f, 6.05850816e-02f, 1.48710739e-02f, -8.26866105e-02f, -1.09306648e-01f, 1.22731715e-01f, 3.73835713e-02f, 7.01385811e-02f, 1.68482527e-01f, 7.93087017e-03f,
  -3.25498171e-02f, 1.48429424e-01f, -3.80721577e-02f, -2.59376559e-02f, 1.76052615e-01f, -8.89376774e-02f, 4.88251261e-02f, -1.92431897e-01f, 2.46667285e-02f, 1.37783453e-01f,
  8.34007040e-02f, 9.40045342e-02f, -8.43124464e-02f, -1.55111924e-01f, -4.68198620e-02f, 1.54043004e-01f, 5.48460446e-02f, -1.78173870e-01f, 4.28471044e-02f, 2.57669576e-02f,
  -3.00445911e-02f, 3.27385999e-02f, 1.02565572e-01f, -4.42147180e-02f, -8.08810592e-02f, 6.88476712e-02f, 4.91767749e-02f, 1.35242879e-01f, -8.45636874e-02f, 1.10258507e-02f,
  -1.14826433e-01f, -8.33311770e-03f, -6.57448620e-02f, -1.93242393e-02f, 1.16352066e-01f, -1.25268728e-01f, -5.46095483e-02f, -1.47078514e-01f, 3.13030109e-02f, -4.88538817e-02f,
  7.57002309e-02f, 2.15186507e-01f, 6.62668496e-02f, -2.20155139e-02f, -1.26073167e-01f, 5.98189719e-02f, -3.59732844e-02f, -1.02168851e-01f, 1.05745800e-01f, 2.43598253e-01f,
  2.76613444e-01f, 8.64207000e-02f, -8.42457339e-02f, -1.15707248e-01f, -6.44113421e-02f, 6.99741766e-02f, -4.37316857e-02f, 1.00226671e-01f, -1.42371422e-02f, -3.38321412e-03f,
  -2.09042449e-02f, 8.90261028e-03f, -6.29091188e-02f, -4.87503931e-02f, -2.72716153e-02f, 8.43462422e-02f, 1.01424135e-01f, -6.69604912e-02f, -9.71072912e-02f, -5.37536778e-02f,
  6.22492023e-02f, -8.17041751e-03f, 6.85151070e-02f, -6.18538633e-02f, 1.72337238e-02f, 1.27365544e-01f, 5.48012629e-02f, -6.38836771e-02f, -4.93734106e-02f, -8.72855261e-02f,
  -7.14244619e-02f, -8.96343216e-03f, 8.72976035e-02f, -9.61124003e-02f, -1.38639659e-01f, -7.89067596e-02f, 3.63213755e-02f, 1.13602839e-01f, -3.57658640e-02f, -2.93293893e-02f,
  1.05696596e-01f, 8.64606872e-02f, 4.91240644e-04f, -2.13612486e-02f, -1.01871386e-01f, -3.09875328e-02f, 9.15020034e-02f, 7.84103274e-02f, 6.98994100e-02f, -5.35934307e-02f,
  5.53310439e-02f, 1.27642639e-02f, 6.26784116e-02f, -8.23648050e-02f, 6.23878390e-02f, -1.84394990e-03f, -9.95023400e-02f, -1.21196643e-01f, -1.18308008e-01f, -1.61645021e-02f,
  -5.99321909e-02f, -8.78229213e-04f, 5.25058247e-04f, 1.17004506e-01f, -9.70658138e-02f, -8.54902491e-02f, 3.99537794e-02f, -4.47991863e-02f, 1.27566189e-01f, -4.66050915e-02f,
  -5.34625873e-02f, -2.69444659e-02f, 1.22057520e-01f, 1.16094299e-01f, 1.66160744e-02f, -8.87965038e-02f, 8.67282413e-03f, -5.06505780e-02f, 6.37648627e-02f, 7.69895390e-02f,
  -8.83506536e-02f, 4.87406850e-02f, 1.90230478e-02f, -8.64953101e-02f, 8.68249461e-02f, -6.86840788e-02f, -1.65942371e-01f, 7.74739385e-02f, -1.32844537e-01f, 2.89934725e-02f,
  -5.87133644e-03f, 4.77893353e-02f, -1.77216008e-01f, 1.01885073e-01f, 6.77441061e-02f, 1.55956973e-03f, 9.77352783e-02f, -9.42651927e-02f, -1.12733975e-01f, 4.72294725e-02f,
  -9.76563767e-02f, 1.24639116e-01f, 8.75085220e-02f, -1.23706218e-02f, 1.11028604e-01f, 1.20480500e-01f, 8.66787508e-02f, 6.71080826e-03f, -1.06202848e-01f, 3.67797688e-02f,
  9.75968912e-02f, 1.00424975e-01f, 1.08317532e-01f, -1.02400050e-01f, 4.55553271e-03f, 8.46082158e-03f, 1.09008916e-01f, 1.49663657e-01f, -1.11201011e-01f, 5.92977777e-02f,
  -1.59120816e-03f, -1.07234433e-01f, -1.14565879e-01f, -5.91172576e-02f, -1.24813825e-01f, -5.37501536e-02f, -2.24469379e-02f, 1.47790816e-02f, 6.61289245e-02f, 8.32706392e-02f,
  2.14603283e-02f, -2.82568503e-02f, 1.43124294e-02f, 9.04728249e-02f, 1.05964370e-01f, 5.60956076e-02f, -5.15745878e-02f, 6.53344905e-04f, -2.69377250e-02f, 1.32328600e-01f,
  1.42252073e-01f, 1.12968221e-01f, 1.60129696e-01f, 6.68580458e-02f, 8.26944262e-02f, 3.53515856e-02f, 3.14772837e-02f, 2.11088985e-01f, 4.87836376e-02f, 2.13950977e-01f,
  -2.50225306e-01f, 1.35546669e-01f, -2.12041344e-02f, -2.79797683e-03f, -8.59396681e-02f, -2.84349710e-01f, -2.63815641e-01f, -8.90331436e-03f, -4.63766195e-02f, -9.17720273e-02f,
  1.14256106e-01f, 4.26507071e-02f, -2.01654434e-01f, -1.51957005e-01f, 1.35086671e-01f, 2.37879813e-01f, -7.66492635e-02f, -1.46795616e-01f, 6.39117062e-02f, 7.34605119e-02f,
  1.30901232e-01f, 3.25056836e-02f, -1.99406475e-01f, -1.48461699e-01f, -7.01365899e-03f, 2.72973537e-01f, 9.93020535e-02f, 1.51288267e-02f, 2.33362511e-01f, 1.29991442e-01f,
  -6.32922575e-02f, 1.84862643e-01f, -4.21859063e-02f, 2.37885639e-01f, 1.14154316e-01f, 1.46179527e-01f, -1.08650476e-01f, -5.10345660e-02f, -1.26832247e-01f, -6.03625402e-02f,
  -1.17181875e-01f, 1.18295088e-01f, 1.27171993e-01f, 5.21005839e-02f, 1.26111791e-01f, 5.89170977e-02f, 2.63227671e-02f, -2.62542255e-03f, 1.61731571e-01f, -2.26134714e-02f,
  2.32080799e-02f, 1.00917757e-01f, -3.64181064e-02f, -1.77991055e-02f, 4.82197851e-02f, 1.83907017e-01f, 2.20868692e-01f, 2.66229659e-02f, 1.57553211e-01f, 2.95854390e-01f,
  1.72033384e-02f, 2.58488487e-02f, 9.25609767e-02f, -2.32558087e-01f, 1.09334208e-01f, 4.05013785e-02f, 2.41568580e-01f, 4.65051271e-02f, -2.06054896e-01f, -7.01942071e-02f,
  1.04524776e-01f, 1.89391583e-01f, 2.08327219e-01f, -6.96679801e-02f, -2.50427574e-01f, -4.48609181e-02f, -1.48787722e-02f, 1.87160280e-02f, -1.06173389e-01f, -2.32807919e-01f,
  -1.28580257e-01f, -2.13353131e-02f, -1.11744314e-01f, 2.74534840e-02f, -1.09835915e-01f, -8.68990645e-02f, 1.05555765e-01f, 1.03425585e-01f, 6.24464042e-02f, -1.16369821e-01f,
  -1.62637278e-01f, -5.17863557e-02f, -1.37606233e-01f, 1.88898314e-02f, -9.13140029e-02f, -6.93366453e-02f, 1.09791599e-01f, 3.64925563e-02f, 2.74092764e-01f, 7.33355880e-02f,
  -1.07620358e-01f, 2.12812260e-01f, -9.74764749e-02f, -1.09923273e-01f, -7.78940246e-02f, 3.18150640e-01f, 8.28654170e-02f, 6.83155283e-02f, 6.61044717e-02f, 1.18382871e-01f,
  -3.36690284e-02f, -5.32992408e-02f, 1.55227557e-01f, 1.20535582e-01f, 1.06973909e-01f, -2.45967004e-02f, -9.71016809e-02f, 4.59895357e-02f, 3.14516127e-02f, 3.74057740e-02f,
  1.31771669e-01f, 3.57958488e-02f, -9.39383209e-02f, 8.24132785e-02f, 1.00573435e-01f, -5.56390882e-02f, -2.39022747e-02f, -2.70661227e-02f, 7.14411885e-02f, -1.19086243e-01f,
  1.13774147e-02f, -4.00697738e-02f, -5.01507893e-02f, 1.56388551e-01f, 1.75374746e-01f, -5.88553697e-02f, -7.62912929e-02f, 1.51425540e-01f, -8.28724802e-02f, 1.67993635e-01f,
  -1.15089692e-01f, -3.81765775e-02f, 1.30702361e-01f, 1.47939594e-02f, 9.99353305e-02f, 5.94876520e-02f, 6.48393854e-02f, -7.90847242e-02f, -8.04044530e-02f, -1.18942834e-01f,
  1.53123245e-01f, 1.68119758e-01f, 1.10119119e-01f, 3.92923728e-02f, 1.45095095e-01f, 8.77702832e-02f, -9.79967713e-02f, 1.43098742e-01f, 6.18140586e-02f, -9.37849209e-02f,
  2.17736494e-02f, 1.38428053e-02f, 1.36622533e-01f, 1.57329962e-01f, 6.41846135e-02f, 1.03778891e-01f, 1.33508801e-01f, 4.49749529e-02f, 5.53351007e-02f, 1.73069239e-01f,
  -6.04291894e-02f, 1.34581789e-01f, -5.82099110e-02f, -7.44939744e-02f, 1.23880371e-01f, 8.70745033e-02f, -4.01566476e-02f, 1.18355289e-01f, 1.01660676e-01f, 6.25094026e-02f,
  8.94452538e-03f, 8.68725702e-02f, 7.42753223e-02f, 1.33113474e-01f, 6.22743517e-02f, -5.49409576e-02f, 7.49822939e-03f, 5.85395172e-02f, -4.44154628e-02f, 1.87590584e-01f,
  7.85242096e-02f, 1.70892477e-01f, -1.87218159e-01f, 1.26769945e-01f, -1.24381371e-01f, 7.23064470e-04f, 1.13330046e-02f, -1.62585303e-01f, -2.81135857e-01f, 1.15655579e-01f,
  -1.35480106e-01f, 7.21350238e-02f, 1.50021374e-01f, -1.08609319e-01f, -7.55063444e-03f, -7.51232207e-02f, 2.11235672e-01f, 2.43730411e-01f, -7.55085200e-02f, 3.59434113e-02f,
  3.72699238e-02f, 6.20955825e-02f, 1.26422599e-01f, 7.22801611e-02f, -1.85486078e-02f, 2.75776405e-02f, -1.11713111e-01f, 1.13751329e-01f, 1.55924186e-01f, -2.81738602e-02f,
  2.06748962e-01f, 1.23238072e-01f, -8.22546519e-03f, 2.11051539e-01f, -7.93260187e-02f, 1.53036758e-01f, -8.26250762e-03f, 8.13824311e-02f, 7.58208707e-02f, 3.51291560e-02f,
  -3.33384499e-02f, -1.18125215e-01f, 9.10927132e-02f, 1.12076119e-01f, 1.35438547e-01f, -1.10202573e-01f, 5.46885952e-02f, 1.04809530e-01f, 1.44416019e-01f, 1.67548619e-02f,
  6.89597502e-02f, -5.19427955e-02f, 1.21321812e-01f, -8.79769027e-02f, -5.04206587e-03f, -3.58134545e-02f, -4.72862693e-03f, -1.06750019e-01f, 3.04428432e-02f, -1.23822829e-02f,
  9.86767933e-03f, 2.23520100e-01f, 1.26655802e-01f, 8.99163336e-02f, 1.47464588e-01f, -1.67022824e-01f, -4.44823578e-02f, 1.39650017e-01f, 5.27675683e-03f, 5.54457046e-02f,
  -1.85367733e-01f, 7.29413182e-02f, 7.92560428e-02f, 1.71244279e-01f, -2.40858719e-02f, -1.90188214e-01f, -1.18827447e-02f, -9.21838805e-02f, 4.42035645e-02f, 2.04807241e-02f,
  -1.00781679e-01f, -1.67474255e-01f, -2.40782909e-02f, 1.18950129e-01f, -2.17450820e-02f, 2.18561515e-02f, 1.09134316e-01f, 1.26289323e-01f, 2.95589585e-02f, -1.17992923e-01f,
  3.11167352e-02f, 4.59745573e-03f, -5.65626705e-03f, -8.49079862e-02f, 6.84684664e-02f, -1.25973165e-01f, 1.25173226e-01f, -3.84448539e-03f, 5.24391644e-02f, 3.40259587e-03f,
  1.64833486e-01f, -1.07709445e-01f, 3.93103808e-02f, 8.17034487e-03f, -9.35813338e-02f, 2.14531235e-02f, -8.72820169e-02f, 6.40087649e-02f, 1.15914613e-01f, -6.22102916e-02f,
  1.43806994e-01f, -4.52292338e-02f, -2.30163243e-02f, 1.05089664e-01f, -3.24074477e-02f, 1.55143723e-01f, -2.55718222e-03f, 9.19335112e-02f, 5.77020310e-02f, 1.85723335e-01f,
  1.82401776e-01f, 1.31716698e-01f, 1.50511026e-01f, 9.90153011e-03f, 1.33799940e-01f, -1.08282514e-01f, 1.99141383e-01f, 1.63202867e-01f, 1.59536470e-02f, 2.85422653e-02f,
  -2.15077743e-01f, 1.34085223e-01f, -6.99675009e-02f, -3.84574868e-02f, -5.82365459e-03f, -1.25318557e-01f, -2.25110278e-01f, 1.67044342e-01f, 3.69379856e-02f, -3.83362137e-02f,
  9.52630788e-02f, 2.08955985e-02f, -4.44858931e-02f, -1.47133633e-01f, -1.81101065e-03f, 1.70295209e-01f, -1.77861661e-01f, -4.97093052e-02f, -3.64066362e-02f, -7.10123032e-02f,
  -1.27723496e-02f, 7.94543400e-02f, 3.53074186e-02f, -1.29814819e-01f, -1.07688226e-01f, 1.86574325e-01f, -5.59190214e-02f, 9.36994180e-02f, -1.02267256e-02f, 5.65542392e-02f,
  8.62772763e-02f, 9.90597680e-02f, -1.30472630e-01f, 1.69402465e-01f, 1.55693918e-01f, -9.07226801e-02f, 8.80194735e-03f, 6.09803200e-02f, -6.81242049e-02f, 3.27939391e-02f,
  -4.09221603e-03f, 1.43890694e-01f, -3.05216052e-02f, -1.45520689e-02f, -3.44348885e-02f, 1.57941788e-01f, 1.27976269e-01f, 9.61728990e-02f, -6.88211322e-02f, 6.96734786e-02f,
  3.21378671e-02f, 1.65628448e-01f, -8.41394812e-02f, 6.75850660e-02f, 1.14815407e-01f, -1.62639730e-02f, 1.24833301e-01f, -4.09628637e-02f, 4.53037992e-02f, 8.94532129e-02f,
  1.20766371e-01f, -4.27016206e-02f, -7.39397556e-02f, 1.21809077e-02f, 1.07211128e-01f, 1.70672923e-01f, -1.02740061e-02f, 1.77303657e-01f, -1.59589425e-01f, -2.19941258e-01f,
  -2.91635487e-02f, 1.42853200e-01f, -6.36051074e-02f, -1.83529049e-01f, -2.08879381e-01f, 1.09042890e-01f, 8.61921683e-02f, -2.60371193e-02f, -1.65588260e-02f, -1.10842645e-01f,
  -2.66427964e-01f, 8.77186581e-02f, -2.44384748e-03f, 3.16451564e-02f, -1.26599044e-01f, -5.27656637e-02f, 1.18269876e-01f, -1.23002581e-01f, 1.08433135e-01f, -4.85376315e-03f,
  2.13222224e-02f, -1.46884277e-01f, -2.69579124e-02f, -1.33107737e-01f, -2.65849773e-02f, 1.63508020e-02f, 1.44885078e-01f, 2.02307910e-01f, 8.11146852e-03f, -2.37156488e-02f,
  -6.06541969e-02f, 9.93026942e-02f, -2.51453761e-02f, -8.55892822e-02f, 6.57343790e-02f, 1.91689670e-01f, 2.83049852e-01f, 1.52572408e-01f, -1.09480411e-01f, -3.21998373e-02f,
  -1.14234060e-01f, -1.12442605e-01f, 3.95436622e-02f, 1.09609202e-01f, 1.24034710e-01f, -1.07675873e-01f, -1.07482329e-01f, -6.65509030e-02f, -1.02396108e-01f, -2.95442361e-02f,
  2.51093265e-02f, 4.23467234e-02f, -1.94698926e-02f, 8.65487009e-02f, 1.20980693e-02f, -4.15350422e-02f, 1.05897747e-01f, 4.06424552e-02f, 1.13947704e-01f, -2.72394754e-02f,
  -9.38984752e-02f, -2.43081674e-02f, -2.58552805e-02f, -4.79631796e-02f, 7.42766336e-02f, -9.96561907e-03f, 1.19675681e-01f, -7.00035691e-02f, 6.13423064e-02f, -1.03678992e-02f,
  1.48271415e-02f, -1.17232300e-01f, -8.44736844e-02f, -1.30288586e-01f, 6.57613426e-02f, -1.10079750e-01f, 1.08282693e-01f, 8.95335749e-02f, -5.73389651e-03f, -6.84570847e-03f,
  -3.48533690e-02f, -3.44962031e-02f, 9.63588953e-02f, -2.35676710e-02f, -9.20787603e-02f, 9.95356962e-02f, -5.56936562e-02f, -9.63062868e-02f, 9.60782692e-02f, 6.59263656e-02f,
  -9.27343220e-02f, -1.47098564e-02f, 4.56238724e-02f, 7.65671656e-02f, -5.67267742e-03f, 5.55088110e-02f, 1.70339774e-02f, 7.91108012e-02f, -1.30576768e-03f, 8.71534944e-02f,
  4.39496972e-02f, -9.13663730e-02f, 1.10636629e-01f, 7.02100396e-02f, 8.21993649e-02f, 1.33045271e-01f, -7.00642318e-02f, 1.66586861e-01f, 1.25180185e-01f, 9.16702077e-02f,
  -2.51332652e-02f, 8.76553431e-02f, 1.13900870e-01f, 1.55203432e-01f, 1.10213310e-01f, 7.93276262e-03f, -5.25071397e-02f, 1.42079383e-01f, 1.77876353e-01f, 3.64294797e-02f,
  3.48167047e-02f, -7.89963678e-02f, 2.64158100e-02f, 1.41771525e-01f, 1.20888166e-01f, 2.25743324e-01f, -1.47778466e-02f, -2.86368728e-01f, -2.05239683e-01f, 4.30578068e-02f,
  -1.68701019e-02f, -2.97637552e-01f, -1.21506043e-01f, 4.49821129e-02f, -2.41317432e-02f, -1.05288416e-01f, 1.07569536e-02f, 2.00223997e-01f, -4.88593541e-02f, -1.07442714e-01f,
  -9.43744332e-02f, 1.12079084e-01f, -5.30265495e-02f, -1.08671010e-01f, -7.93728456e-02f, -1.87510952e-01f, -8.32925364e-02f, 1.07820757e-01f, -1.36254236e-01f, -7.24720210e-02f,
  -8.16736594e-02f, 4.32638749e-02f, 1.14651673e-01f, 1.45627961e-01f, -1.32456943e-01f, 2.81666696e-01f, -5.01261465e-02f, 1.22390212e-02f, -4.53323424e-02f, 1.01442873e-01f,
  6.78976774e-02f, -1.25071481e-01f, -3.21741812e-02f, -5.56616858e-02f, -5.08928783e-02f, -8.92017633e-02f, -7.51934275e-02f, 6.97215796e-02f, -3.60982232e-02f, -4.47879620e-02f,
  1.15563227e-02f, 4.30162698e-02f, 7.34061748e-02f, 2.65682880e-02f, 8.01193491e-02f, 1.67039968e-02f, -1.10330909e-01f, -1.40032815e-02f, 1.07485555e-01f, 2.17703599e-02f,
  -9.65177491e-02f, -7.72136375e-02f, -5.92329837e-02f, 3.30698900e-02f, -5.07039092e-02f, -1.26216605e-01f, 2.56443527e-02f, -9.63139981e-02f, 7.40022818e-03f, 9.99097675e-02f,
  4.17561196e-02f, 4.66319770e-02f, -4.81098033e-02f, 2.24842895e-02f, -6.84424713e-02f, -4.94931638e-02f, 5.13316542e-02f, 1.22724012e-01f, 7.16235070e-03f, -2.09917929e-02f,
  5.79494871e-02f, -1.54832061e-02f, -2.36135516e-02f, 9.39297155e-02f, -8.17847922e-02f, -1.09942537e-02f, -8.94708410e-02f, -2.51599010e-02f, -4.89516370e-02f, -1.00731216e-01f,
  -3.16176303e-02f, -1.03608645e-01f, 4.67942730e-02f, 1.65051892e-02f, -2.60590408e-02f, -3.79566923e-02f, -7.78248683e-02f, -6.59790188e-02f, -8.85894597e-02f, 3.14415954e-02f,
  1.94205008e-02f, -1.37720639e-02f, -3.26605290e-02f, 4.74423766e-02f, -2.25895760e-03f, -8.06692541e-02f, 8.47977474e-02f, -4.39427271e-02f, -3.93504202e-02f, 3.04901469e-02f,
  1.82307750e-01f, 2.38925521e-03f, 1.20718345e-01f, 1.57791078e-01f, 6.56962842e-02f, 5.25358506e-02f, 1.41524136e-01f, 1.17636345e-01f, 7.77317658e-02f, 8.85015354e-02f,
  -3.31661925e-02f, -9.50478315e-02f, 4.76183295e-02f, 9.93743762e-02f, 3.97898108e-02f, 1.79660916e-01f, 1.33431524e-01f, -9.01515037e-02f, 9.95066240e-02f, 8.87366310e-02f,
  1.49692535e-01f, 1.76453307e-01f, -6.46969527e-02f, 2.60010939e-02f, 3.89801711e-02f, 1.86413676e-02f, 1.94116130e-01f, 2.20117830e-02f, -5.80531582e-02f, -3.38964090e-02f,
  -1.39591441e-01f, 1.33906275e-01f, 7.02857673e-02f, -4.67231572e-02f, 9.80683789e-02f, -7.95571785e-03f, -6.34681731e-02f, -7.52370134e-02f, -1.16263956e-01f, -4.98532169e-02f,
  -5.61788380e-02f, -4.84675309e-03f, 9.15866867e-02f, 7.33911544e-02f, -6.38149232e-02f, 6.94774091e-02f, -7.24500716e-02f, -1.54945016e-01f, -1.67392641e-01f, -4.47352640e-02f,
  2.09570006e-02f, -2.33234055e-02f, -1.05399162e-01f, 4.11704853e-02f, -5.22250833e-04f, 6.47497028e-02f, 5.21185063e-02f, 1.12248540e-01f, 4.35302667e-02f, -2.13884339e-02f,
  -9.36611667e-02f, 2.42171988e-01f, 1.95248365e-01f, -2.05901898e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  1.55561194e-01f, -1.00056257e-03f, 1.44242302e-01f, 8.00491590e-03f, 2.72564366e-02f, -1.71344564e-03f, 1.22762114e-01f, 3.17126922e-02f, 1.95345327e-01f, -1.28481627e-01f,
  4.70827147e-02f, -1.01062231e-01f, 3.25323045e-02f, -1.05090767e-01f, -9.44140255e-02f, 9.43600088e-02f, 2.16526151e-01f, 1.49859255e-02f, 1.53048217e-01f, 8.71885866e-02f,
  -4.51648831e-02f, -5.88493310e-02f, -5.18049933e-02f, 8.37531611e-02f, 4.95124198e-02f, 7.58268088e-02f
};

// L3_fan_Wp (Shape: 19 x 64)
const int L3_fan_Wp_rows = 19;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  1.44338802e-01f, 2.82641035e-03f, 3.48277739e-03f, -1.53263569e-01f, -7.72481086e-03f, -1.30869150e-01f, -8.58575404e-02f, 1.47354584e-02f, -1.67020246e-01f, 7.35114813e-02f,
  6.20213263e-02f, 3.58156487e-02f, -7.01474678e-03f, -5.53195029e-02f, -2.49992847e-03f, 7.66790658e-02f, -1.63550049e-01f, -6.26109317e-02f, 1.11465910e-02f, -7.34833851e-02f,
  -1.62203889e-02f, 2.36892258e-03f, 1.64917916e-01f, 1.80885687e-01f, -7.29067698e-02f, 1.39323846e-01f, 5.44076487e-02f, 1.12538606e-01f, 2.28408929e-02f, -9.80246440e-02f,
  3.16534862e-02f, 2.31615566e-02f, 1.44563273e-01f, -1.26845911e-01f, -9.35751721e-02f, 4.48046699e-02f, -5.67616820e-02f, 1.01584606e-01f, 5.77306040e-02f, -6.36374354e-02f,
  1.08230971e-01f, -1.28943816e-01f, -2.73825265e-02f, -6.26196060e-03f, 1.35272339e-01f, 5.77791734e-03f, 4.84839231e-02f, -6.75621554e-02f, 4.63304892e-02f, 1.52885728e-02f,
  -6.04282180e-03f, 1.22811325e-01f, -3.26674208e-02f, 1.59705561e-02f, -2.40355104e-01f, -1.22595586e-01f, 1.59533724e-01f, -1.19838212e-02f, -3.00618913e-02f, 9.92579460e-02f,
  -5.07882191e-03f, 2.14469451e-02f, -1.16938896e-01f, -1.89594422e-02f, -1.07486201e-02f, 3.04744206e-02f, -3.71151790e-02f, 1.55521825e-01f, 3.21155578e-01f, 1.78045213e-01f,
  -4.46253344e-02f, 2.21189186e-01f, 2.37102240e-01f, 1.47050560e-01f, -1.45385981e-01f, 9.02106464e-02f, 8.88614077e-03f, -8.90436247e-02f, -7.49461586e-03f, -6.32821620e-02f,
  2.02809840e-01f, 1.54272199e-01f, 1.42223209e-01f, 2.33654326e-04f, 8.84832144e-02f, -1.03262424e-01f, -1.49749279e-01f, 6.48454726e-02f, 1.10607244e-01f, 1.54611319e-01f,
  1.71347082e-01f, 1.61835223e-01f, -1.41936108e-01f, 1.06345691e-01f, -1.02040060e-01f, 5.05407006e-02f, -1.72196910e-01f, -2.69129984e-02f, -4.01529074e-02f, 2.22277015e-01f,
  1.48084849e-01f, 1.60757974e-01f, 3.70124504e-02f, 1.43598653e-02f, -6.41417578e-02f, -1.23127125e-01f, 5.83049133e-02f, -5.74587807e-02f, -1.13124743e-01f, -7.03635626e-03f,
  1.13788031e-01f, 6.30473718e-02f, 3.50118950e-02f, 3.08608264e-02f, -3.50032188e-03f, -4.36442904e-02f, -1.25095099e-02f, 1.10442482e-01f, -1.14224881e-01f, 3.22636925e-02f,
  -2.68267654e-02f, 7.92811513e-02f, 1.03445895e-01f, -5.16652204e-02f, 9.26412642e-02f, 2.86369249e-02f, 2.44938433e-02f, 9.82398391e-02f, 1.66769132e-01f, -6.52883425e-02f,
  -4.93909232e-02f, -4.95922007e-02f, -2.70598680e-02f, 1.33366033e-01f, 1.43857449e-01f, 8.09495300e-02f, -1.30704969e-01f, 6.96517602e-02f, 2.10484844e-02f, -4.75563295e-02f,
  1.67294331e-02f, 5.82903251e-02f, 1.11479893e-01f, -1.24842249e-01f, 1.72850788e-01f, 9.55981910e-02f, 1.56140104e-02f, -6.86572716e-02f, 2.30223574e-02f, -3.49179864e-01f,
  -1.61819175e-01f, -1.31339386e-01f, -3.83947566e-02f, -1.13753378e-01f, -1.57776952e-01f, -1.98068693e-01f, 3.10329814e-03f, -1.97917894e-01f, -1.35171384e-01f, 1.84192449e-01f,
  -2.06688151e-01f, -1.02841675e-01f, 4.95505743e-02f, -1.13814346e-01f, 9.12978277e-02f, 2.43662819e-02f, -1.91989645e-01f, 7.89350644e-02f, 1.88762531e-01f, -5.66323474e-02f,
  -6.63240906e-03f, 4.82622236e-02f, -2.50318587e-01f, -9.71896648e-02f, 2.33900938e-02f, 3.85819538e-03f, 9.40240622e-02f, -6.45390004e-02f, 2.29934499e-01f, -1.13715399e-02f,
  6.81769848e-02f, -1.43068179e-01f, 1.46952704e-01f, -1.01037450e-01f, -3.49925719e-02f, 1.78968266e-01f, -1.23926830e-02f, 2.64084101e-01f, 7.16061145e-03f, 9.86341015e-02f,
  8.81709754e-02f, 4.93432581e-02f, -1.64628893e-01f, 1.01714388e-01f, 1.10911138e-01f, 2.32491121e-01f, 2.11855993e-01f, 1.37039140e-01f, 1.95285250e-02f, 9.37606581e-03f,
  2.35596150e-01f, 4.55476530e-02f, -1.58157304e-01f, -4.35356684e-02f, -2.00166646e-02f, -6.94606528e-02f, -8.80725980e-02f, -2.11983621e-02f, 6.34395927e-02f, -1.20953351e-01f,
  1.71411678e-01f, 3.08922306e-02f, -1.62020653e-01f, 2.18184248e-01f, -1.73675492e-01f, -3.02867681e-01f, -3.95206362e-02f, 2.49035522e-01f, -8.33871886e-02f, -4.95742932e-02f,
  -2.85258263e-01f, 2.17019722e-01f, 2.22180247e-01f, -2.01080203e-01f, 7.53194839e-02f, 3.13225567e-01f, 3.49795781e-02f, -1.31667912e-01f, 1.68563332e-02f, -2.92534381e-01f,
  -1.06733084e-01f, -4.40518372e-02f, -1.67898029e-01f, -4.09884006e-02f, 4.64603910e-03f, -1.05910145e-01f, 7.72658065e-02f, -1.34145077e-02f, 1.27964050e-01f, 7.16123432e-02f,
  3.00105661e-02f, -4.13614847e-02f, -6.13924488e-02f, 1.28108919e-01f, -2.86546834e-02f, 4.95856069e-02f, -1.97188407e-01f, -6.70289695e-02f, 1.13532200e-01f, -1.37597948e-01f,
  6.28506541e-02f, -1.22950397e-01f, -1.23424217e-01f, -1.19895048e-01f, -4.94439043e-02f, 1.37623489e-01f, 1.10867999e-01f, 5.57634346e-02f, 8.85165483e-02f, 1.14211552e-01f,
  -1.40850812e-01f, 7.05861151e-02f, 3.19527984e-02f, -1.31520569e-01f, 4.37926874e-02f, 1.44455165e-01f, 1.53931946e-01f, 2.34365711e-04f, 1.34411812e-01f, 4.18107845e-02f,
  1.96878433e-01f, 1.58634856e-01f, -1.60935130e-02f, 6.38685897e-02f, 4.81193662e-02f, 1.25083665e-03f, 8.63040332e-03f, -9.36612785e-02f, 2.86589980e-01f, 3.01682085e-01f,
  2.95307368e-01f, -1.54725552e-01f, 1.71874419e-01f, 1.33292407e-01f, 5.98394349e-02f, -3.57166119e-02f, -2.17247531e-01f, 1.86384261e-01f, -1.44381478e-01f, -1.12206280e-01f,
  8.17672163e-03f, 2.26757348e-01f, 7.75530934e-02f, 2.21345693e-01f, 1.98388591e-01f, 1.07326105e-01f, -1.07345499e-01f, 2.87027545e-02f, -3.89817990e-02f, 6.78337291e-02f,
  1.61043048e-01f, 1.02722645e-02f, -2.93357790e-01f, -9.02475640e-02f, 6.34451807e-02f, -8.69151875e-02f, -2.45609879e-02f, -8.58975202e-02f, -3.65319028e-02f, -3.72421555e-02f,
  1.98997453e-01f, 7.88334906e-02f, -2.23055128e-02f, 1.57738775e-01f, 1.83081821e-01f, -6.78528175e-02f, -1.14550767e-02f, -1.06753059e-01f, -9.97353122e-02f, -1.11743994e-01f,
  -1.42999649e-01f, -4.55537103e-02f, -1.63014680e-02f, -9.40225720e-02f, -2.51762927e-01f, -1.09539881e-01f, -1.44561738e-01f, -1.64012879e-01f, -5.28323278e-03f, -2.12913960e-01f,
  -1.64328218e-01f, 2.48052739e-02f, 6.87830821e-02f, 5.58809265e-02f, -2.56170798e-02f, 7.08851889e-02f, -2.32886210e-01f, -1.72318652e-01f, -2.07245320e-01f, 1.33035675e-01f,
  5.72309382e-02f, 1.41857371e-01f, 5.17184846e-02f, 3.37938033e-02f, 4.18533459e-02f, 1.07369735e-03f, 4.86271940e-02f, -2.69060601e-02f, 1.27763107e-01f, 7.51213729e-02f,
  8.63751490e-03f, -1.16801985e-01f, 9.85614732e-02f, 8.37687701e-02f, 1.43105775e-01f, 3.08105256e-02f, -1.19228199e-01f, 5.23646735e-02f, -2.76960321e-02f, -1.26567081e-01f,
  -1.31964207e-01f, -6.17557503e-02f, -1.51763871e-01f, 9.19513404e-02f, 2.08845213e-01f, -1.13293836e-02f, -5.99650666e-02f, 4.18576598e-02f, -1.20329142e-01f, 1.05101429e-01f,
  -9.45964605e-02f, -5.13253771e-02f, 2.80258879e-02f, 1.34593993e-01f, -1.77465290e-01f, -1.36094699e-02f, -6.26835600e-02f, 7.23972470e-02f, -1.40481517e-01f, -2.69099642e-02f,
  7.49518499e-02f, 1.56169506e-02f, 5.72564825e-02f, -9.83076245e-02f, 1.35035636e-02f, -5.82294688e-02f, -1.40481427e-01f, -5.57309240e-02f, -1.11423090e-01f, -1.66192740e-01f,
  -2.10198641e-01f, -3.25061195e-02f, -9.77790430e-02f, -2.57702675e-02f, -2.18966845e-02f, -1.37788579e-01f, -1.78681225e-01f, 3.13774757e-02f, -1.02523819e-01f, -8.66753310e-02f,
  -7.57826194e-02f, 3.21398079e-02f, -8.71729776e-02f, 1.64757416e-01f, -1.20062925e-01f, 3.42162848e-01f, 1.66334435e-01f, 7.49909654e-02f, -2.00217769e-01f, 7.22422525e-02f,
  6.23041159e-03f, -5.61070889e-02f, 2.25129705e-02f, 2.70322740e-01f, 1.35549307e-01f, -2.52337217e-01f, 3.13245833e-01f, 1.98498145e-01f, 3.45563293e-02f, -4.43754569e-02f,
  -1.84104085e-01f, -8.25892016e-03f, 7.23464414e-03f, -1.85333155e-02f, -1.37816742e-01f, 4.78446074e-02f, -7.60169998e-02f, -4.15261127e-02f, 8.84126648e-02f, 1.15427777e-01f,
  2.03388691e-01f, -1.02994822e-01f, 2.31672060e-02f, 2.93222610e-02f, -2.85723172e-02f, 5.42322770e-02f, 8.25387239e-02f, -6.74423277e-02f, -1.40129656e-01f, 1.51216567e-01f,
  1.45329699e-01f, -3.78195904e-02f, -7.93516561e-02f, -7.89116174e-02f, 3.12893353e-02f, -2.06022948e-01f, -9.41123143e-02f, -2.56152600e-02f, -2.14776531e-01f, 3.49200302e-04f,
  -1.19893372e-01f, -8.19803867e-03f, -9.88907441e-02f, -1.35846779e-01f, -9.20131896e-03f, -1.27818689e-01f, -7.09650367e-02f, 6.47343323e-02f, 3.59417461e-02f, -3.57536785e-02f,
  -6.74079359e-03f, -7.21235871e-02f, -9.80433971e-02f, 4.38047983e-02f, 1.34982780e-01f, -1.06165364e-01f, -3.78136896e-02f, -2.52520759e-03f, -6.61779791e-02f, -1.60947174e-01f,
  -2.06038326e-01f, -3.46847661e-02f, -2.37784237e-01f, -1.14758775e-01f, -2.36048311e-01f, 2.54696812e-02f, -1.65899768e-01f, -6.49175495e-02f, -1.52170062e-01f, -2.34682951e-02f,
  4.01773490e-02f, -2.19881348e-02f, 5.21785542e-02f, -2.74306059e-01f, -2.16841772e-01f, -1.47563353e-01f, 1.04366029e-02f, 4.98011597e-02f, 8.87677446e-02f, -8.95577818e-02f,
  1.02587625e-01f, 6.82897493e-02f, 1.68420166e-01f, 2.60073692e-01f, 1.11291967e-01f, -1.00844726e-01f, -1.00746572e-01f, 3.33349854e-02f, 6.07540719e-02f, -2.11295187e-02f,
  -1.41318023e-01f, -2.41542250e-01f, 1.64560109e-01f, 6.04855362e-04f, -1.89187214e-01f, -1.09414674e-01f, -1.03965662e-01f, 8.36691484e-02f, -3.91618311e-02f, -2.03382969e-01f,
  1.36112999e-02f, -5.12243062e-02f, -3.60052548e-02f, -8.08684230e-02f, 2.17926472e-01f, 1.53688326e-01f, 3.77918072e-02f, 1.41256616e-01f, 2.10424233e-02f, 7.58457035e-02f,
  2.04918291e-02f, 7.72427693e-02f, -1.69655774e-02f, 6.36462495e-03f, -9.99436900e-03f, 8.37070867e-02f, 2.13787362e-01f, -5.83136603e-02f, 1.86539948e-01f, 5.59087917e-02f,
  1.36371091e-01f, 4.25916910e-02f, -7.16983005e-02f, 4.38213311e-02f, -1.08220339e-01f, -1.90136194e-01f, -5.50705977e-02f, -1.68193430e-01f, -2.78674930e-01f, -4.82658781e-02f,
  -2.61089712e-01f, 2.61118531e-01f, -9.35038775e-02f, -9.60858911e-02f, 3.69958691e-02f, 1.96854219e-01f, 5.46058640e-02f, -1.32838115e-01f, -4.95877750e-02f, -2.59324342e-01f,
  4.35650200e-02f, -7.01772273e-02f, -8.46938938e-02f, -9.14383605e-02f, 5.20140640e-02f, 8.44778772e-03f, 6.10194653e-02f, 2.74683565e-01f, 1.24852359e-01f, 2.07761843e-02f,
  -1.87481754e-02f, -8.51209089e-02f, -2.09194899e-01f, -1.35136753e-01f, -9.51766670e-02f, -1.64516568e-01f, -7.37010092e-02f, 1.05336187e-02f, -1.73084542e-01f, -6.85264096e-02f,
  -1.39444724e-01f, -2.30927065e-01f, 1.10169619e-01f, -3.96826910e-03f, 1.24739790e-02f, -7.14945644e-02f, -1.61072031e-01f, 9.80387777e-02f, 8.04395005e-02f, 8.69253725e-02f,
  -7.83534348e-02f, -7.67487660e-02f, -1.02905340e-01f, -2.56521050e-02f, -1.40105531e-01f, 5.76422503e-03f, 2.73316242e-02f, -1.53142074e-02f, 7.71980882e-02f, -7.05393776e-02f,
  1.00974597e-01f, 1.00366928e-01f, -7.46255890e-02f, -1.99556991e-01f, 9.01255906e-02f, 2.02940881e-01f, -3.37138362e-02f, 1.07006565e-01f, 1.14506982e-01f, 4.37796563e-02f,
  -1.55240566e-01f, -1.60710767e-01f, -2.17714742e-01f, -1.39454216e-01f, -5.60758449e-02f, 1.70998722e-01f, -1.77929513e-02f, -1.48635760e-01f, 1.25904962e-01f, 1.09392684e-02f,
  7.40887374e-02f, -7.18221068e-02f, -1.76851839e-01f, -2.25237951e-01f, 8.40255525e-03f, 5.62881259e-03f, 5.11012152e-02f, 1.00723952e-01f, 8.19733292e-02f, 7.17503726e-02f,
  1.72507450e-01f, 1.14578173e-01f, -8.14492106e-02f, -7.62221068e-02f, 9.51566361e-03f, -5.46166748e-02f, -4.72890958e-03f, -3.52624282e-02f, -8.87639597e-02f, -8.24772492e-02f,
  1.61042750e-01f, 1.65176407e-01f, -1.29598022e-01f, -2.47254185e-02f, -1.80551007e-01f, -1.54746592e-01f, -6.00161254e-02f, -2.67288148e-01f, -1.16515353e-01f, -1.81283280e-02f,
  1.47126704e-01f, 5.29565327e-02f, 6.02899790e-02f, 9.86530334e-02f, 9.43977237e-02f, 5.84716722e-02f, 5.01677468e-02f, 2.23566920e-01f, 2.11680114e-01f, 1.62954569e-01f,
  -4.96737137e-02f, 1.82053953e-01f, 2.46699876e-03f, 5.42123355e-02f, 7.01670721e-03f, -1.67593464e-01f, -4.20740694e-02f, 2.24223837e-01f, 1.29447877e-01f, -2.10865811e-01f,
  6.62537292e-02f, -4.66905348e-02f, 1.56897709e-01f, 1.23216957e-01f, 7.62288719e-02f, 1.11553945e-01f, 1.32727012e-01f, 8.07278529e-02f, 7.72715807e-02f, -1.68178990e-01f,
  6.68822378e-02f, 8.20886493e-02f, -2.67446309e-01f, -7.53574222e-02f, -9.52849463e-02f, 2.02514961e-01f, 1.22552589e-01f, 1.57879055e-01f, -1.81163591e-03f, 1.26300290e-01f,
  -3.05738281e-02f, -5.93899600e-02f, 3.32141481e-02f, -5.13746105e-02f, -1.99250743e-01f, -1.37702718e-01f, -1.78000201e-02f, -5.89165092e-02f, -6.75374418e-02f, 6.14841245e-02f,
  1.05078198e-01f, 1.14362679e-01f, 5.54939508e-02f, 2.00648561e-01f, 2.27632374e-02f, -2.08333552e-01f, 5.86870797e-02f, 1.95090845e-02f, 1.88380972e-01f, 1.61285728e-01f,
  -1.15111358e-01f, 2.06514344e-01f, 1.23789804e-02f, -1.38805851e-01f, -1.29400045e-01f, -1.17203854e-01f, -2.27993727e-01f, -1.60237283e-01f, -9.40386429e-02f, -5.51462509e-02f,
  -4.38622723e-04f, -1.04684763e-01f, -1.63921550e-01f, -9.10163447e-02f, 3.90142798e-02f, -7.63514116e-02f, 3.91370943e-03f, 2.18395982e-02f, -1.50115833e-01f, 1.26026869e-01f,
  -3.05950511e-02f, -2.16231614e-01f, -1.07629403e-01f, -1.61395539e-02f, -1.17328823e-01f, -1.35894820e-01f, -2.58886423e-02f, -4.75636795e-02f, -1.89003348e-01f, -2.48602286e-01f,
  -2.47480478e-02f, -1.90791190e-01f, 9.04520415e-03f, -5.33959866e-02f, -1.00245871e-01f, 3.40594612e-02f, 2.52594464e-02f, 9.98767540e-02f, 5.56744449e-02f, -1.24739684e-01f,
  -1.10121571e-01f, -2.63602346e-01f, -1.13005117e-01f, 6.52073398e-02f, 9.73647684e-02f, -1.32697569e-02f, 6.09661825e-02f, 1.42725423e-01f, 2.94303317e-02f, -1.72338355e-02f,
  -7.32311979e-02f, -1.10049412e-01f, 6.37293532e-02f, -3.69660258e-02f, 1.57342568e-01f, 3.91129367e-02f, -5.34408502e-02f, -2.52026200e-01f, 3.35267698e-03f, 1.42598048e-01f,
  -9.70448032e-02f, 3.58297676e-02f, -3.59436013e-02f, 1.80377543e-01f, -7.20420778e-02f, -2.16120750e-01f, -7.10720345e-02f, 1.11659564e-01f, -5.50207533e-02f, 1.46289751e-01f,
  1.55044705e-01f, 8.28869864e-02f, -1.96973793e-02f, 1.16652258e-01f, -1.00668736e-01f, 1.14327639e-01f, -9.00004059e-02f, 9.10181925e-03f, -1.63756385e-01f, 8.96507204e-02f,
  2.40619630e-02f, 4.36035283e-02f, 1.21316433e-01f, -7.86768422e-02f, -9.81822424e-03f, -8.50806311e-02f, -1.21917361e-02f, 1.87591478e-01f, -1.59680963e-01f, 2.35307634e-01f,
  1.45541355e-02f, -4.20509391e-02f, -8.58484581e-02f, 1.59293026e-01f, -1.66485578e-01f, 5.64998575e-02f, -2.00076867e-02f, 1.37578011e-01f, 1.98021650e-01f, -1.88256606e-01f,
  2.57552862e-01f, 1.35922775e-01f, -9.28974450e-02f, -9.79470015e-02f, 8.69029947e-03f, -1.96677148e-02f, 2.16056868e-01f, 4.81385067e-02f, -9.97714326e-02f, -8.61087888e-02f,
  -8.82625654e-02f, -5.19884676e-02f, 1.17881358e-01f, 1.70708865e-01f, 2.00295731e-01f, 1.81163382e-02f, 4.14996929e-02f, 3.26375999e-02f, -1.54413402e-01f, 1.16331168e-01f,
  -3.33876982e-02f, -3.45432721e-02f, -1.03900500e-01f, 1.77093163e-01f, -2.73517123e-03f, 2.42197905e-02f, 1.01505741e-01f, -6.90483004e-02f, 8.76887441e-02f, -4.87352945e-02f,
  6.55667856e-03f, -3.51015888e-02f, 1.04251787e-01f, 1.52298391e-01f, -1.32395983e-01f, 8.33800435e-02f, -6.83819549e-03f, 1.08937770e-01f, 2.20327005e-01f, 8.53510648e-02f,
  -5.01312176e-03f, 3.13396454e-02f, 1.21983416e-01f, -5.48953824e-02f, 1.46871686e-01f, 6.10933416e-02f, 4.81562950e-02f, 2.73535326e-02f, 5.87696321e-02f, 1.22720018e-01f,
  8.57745707e-02f, -2.35279515e-01f, -1.84088144e-02f, -2.81110048e-01f, -1.56010866e-01f, 1.58171237e-01f, -1.61153413e-02f, -9.62412953e-02f, 1.73826978e-01f, -3.41648646e-02f,
  1.07549831e-01f, -1.95383549e-01f, -2.19356027e-02f, 1.77873615e-02f, 1.04780111e-03f, -2.19729006e-01f, 8.72709379e-02f, -6.71431944e-02f, 1.26851320e-01f, 1.87135696e-01f,
  -1.86495134e-03f, 1.30260050e-01f, 1.71065137e-01f, 4.91535515e-02f, 1.20676778e-01f, -1.10426517e-02f, 5.32834325e-03f, -1.10401630e-01f, -2.01445833e-01f, 4.68653813e-02f,
  2.08453350e-02f, 4.62607294e-02f, 1.39501423e-01f, -7.12282211e-02f, 1.60829909e-02f, -2.34313868e-02f, 1.59206137e-01f, -9.37018245e-02f, -5.58627397e-02f, 5.57997823e-02f,
  -5.75812384e-02f, 1.62542518e-02f, 4.97520342e-03f, 1.96941897e-01f, -8.47304799e-03f, -9.82437432e-02f, 1.27885550e-01f, -1.41299620e-01f, 4.76620682e-02f, -2.10394129e-01f,
  -2.37377733e-01f, -7.69276023e-02f, 1.15897685e-01f, -2.23365813e-01f, -1.77002490e-01f, 1.07221052e-01f, 7.53115267e-02f, 2.05721304e-01f, -6.50167689e-02f, 1.44561097e-01f,
  -2.13944186e-02f, -4.59010489e-02f, -7.63808116e-02f, 1.48868747e-02f, -3.08725834e-02f, -5.67956679e-02f, 4.92232628e-02f, -1.68661430e-01f, -8.27882364e-02f, 1.85296357e-01f,
  2.17246279e-01f, -2.65621781e-01f, -1.01245746e-01f, -9.54979807e-02f, 7.18365759e-02f, -2.45424628e-01f, -1.18393764e-01f, 1.35654077e-01f, -4.99909185e-02f, -1.81949109e-01f,
  -7.59536922e-02f, 2.36960016e-02f, -8.99905711e-03f, 1.01319410e-01f, 9.26862005e-03f, 3.16660590e-02f, 1.27207279e-01f, -5.41678601e-05f, 6.42238408e-02f, -1.38386805e-02f,
  5.39956279e-02f, -2.16960646e-02f, -2.44965419e-01f, 1.14762045e-01f, -3.34568471e-02f, 1.26578197e-01f, -5.89114465e-02f, -1.12347372e-01f, -1.03026226e-01f, -1.30392136e-02f,
  2.64374942e-01f, 4.09551617e-03f, -1.86681002e-02f, 1.86664805e-01f, 2.84859426e-02f, 1.16567835e-01f, 5.23882881e-02f, -3.52342799e-02f, -8.32117200e-02f, 1.20735101e-01f,
  7.04743490e-02f, 2.19374225e-01f, -4.39583231e-03f, 1.43655211e-01f, 2.91326940e-01f, 2.46165961e-01f, 1.63154036e-01f, 1.99209020e-01f, 2.12800860e-01f, 1.42602578e-01f,
  1.08663134e-01f, -2.34072823e-02f, -3.19060683e-02f, 6.90935403e-02f, 2.22301215e-01f, -4.22199853e-02f, 2.06332892e-01f, -6.17823303e-02f, 1.46149233e-01f, 5.97494729e-02f,
  -4.91893142e-02f, -1.01459801e-01f, -2.87370712e-01f, -2.35011488e-01f, -9.75304991e-02f, -1.34655148e-01f, -1.92176983e-01f, -1.93251908e-01f, -2.28213504e-01f, -2.89905462e-02f,
  -9.94672105e-02f, -1.12884633e-01f, 1.21419154e-01f, 1.95351634e-02f, -4.04080525e-02f, -1.83268309e-01f, -1.43043056e-01f, -1.45029902e-01f, -4.40770425e-02f, 3.03984862e-02f,
  9.30191502e-02f, -1.31363586e-01f, 7.67482957e-03f, -1.22988485e-01f, 1.52809042e-02f, 1.79215640e-01f, 1.40778556e-01f, -9.35009569e-02f, 8.47936869e-02f, 3.62025872e-02f,
  -1.97485778e-02f, 4.68175262e-02f, 2.61897463e-02f, -1.80573314e-01f, 1.92389295e-01f, 1.74693018e-01f, -1.47989467e-01f, 6.72350228e-02f, -4.04073037e-02f, -7.93688074e-02f,
  -8.31829533e-02f, -2.11766381e-02f, -7.19793700e-03f, 1.92281455e-01f, -7.92596606e-04f, 1.57490429e-02f, 1.08289197e-02f, 3.09642814e-02f, 1.17841065e-02f, 8.01409408e-02f,
  8.06965977e-02f, 2.82545947e-02f, 1.24852106e-01f, -8.11302215e-02f, 1.81530178e-01f, 1.26134425e-01f, 1.63935632e-01f, 1.28220655e-02f, -6.03245385e-02f, -1.13594189e-01f,
  -1.11938212e-02f, 1.44677684e-01f, 4.46753623e-03f, -5.09992428e-03f, 6.81844354e-03f, -3.66440624e-01f, -4.61806469e-02f, 1.32348891e-02f, 2.42200363e-02f, -1.98432188e-02f,
  4.17579487e-02f, -9.94369667e-03f, 3.34145762e-02f, -2.89726436e-01f, -1.24454312e-01f, 2.53751516e-01f, -2.69299060e-01f, -1.66488305e-01f, -5.37252687e-02f, 3.16191912e-02f,
  6.47052797e-03f, 9.12208930e-02f, -8.33115950e-02f, 6.04970716e-02f, 9.22862440e-02f, -8.29268172e-02f, 7.82821849e-02f, -5.04289903e-02f, -3.25386912e-01f, -5.86927719e-02f,
  4.60818149e-02f, -6.39915690e-02f, -1.17835455e-01f, -3.19780521e-02f, 2.02016324e-01f, -9.16428193e-02f, -4.16827798e-02f, -8.36371705e-02f, 1.07161880e-01f, -4.66629937e-02f,
  4.52752896e-02f, 1.04399428e-01f, 6.44441918e-02f, 1.01926714e-01f, 3.49024385e-02f, 1.79674655e-01f, 4.28497279e-03f, 6.82255030e-02f, 8.95354226e-02f, 8.01291168e-02f,
  1.23051591e-01f, -7.46655092e-02f, 3.15199792e-02f, -1.46816317e-02f, -5.12283817e-02f, 1.25837296e-01f, 1.36151224e-01f, -2.45493352e-02f, -1.37505503e-02f, -7.30343089e-02f,
  -6.75448328e-02f, 8.76766890e-02f, 1.02639891e-01f, -1.15761876e-01f, -1.54457927e-01f, 2.53829290e-04f, 1.45869842e-02f, 1.34824812e-02f, 2.79325008e-01f, -3.98688614e-02f,
  2.03548327e-01f, 2.30372384e-01f, 2.04759523e-01f, 2.48410314e-01f, 1.09886020e-01f, 1.66186899e-01f, 1.00766860e-01f, -1.69990182e-01f, -7.74774104e-02f, 3.07381246e-02f,
  -1.65412426e-01f, 2.15744656e-02f, -5.73264696e-02f, 3.04611027e-01f, 1.07237667e-01f, 1.69965610e-01f, 1.28238499e-01f, 1.52456164e-01f, 6.41456246e-02f, -8.41473192e-02f,
  -8.45120400e-02f, 8.85357894e-03f, -1.61866263e-01f, -4.27092575e-02f, -3.50539871e-02f, 3.25242020e-02f, -1.11099064e-01f, -6.58189580e-02f, 1.05260983e-01f, -9.94202681e-03f,
  1.34942859e-01f, 8.27356949e-02f, -8.95482749e-02f, -2.42613897e-01f, 1.40431553e-01f, 2.18684096e-02f, 2.55376071e-01f, 8.23777765e-02f, 8.17651078e-02f, 1.68370202e-01f,
  -8.21505785e-02f, -1.90925598e-01f, 5.29818702e-03f, -8.45910534e-02f, 1.95547149e-01f, 9.75417569e-02f, 1.74383268e-01f, 1.97711289e-01f, -6.27996325e-02f, 3.77629548e-02f,
  1.66469768e-01f, -8.11670274e-02f, -7.06774890e-02f, -8.15106034e-02f, 3.95108424e-02f, 1.02959618e-01f, -5.08903973e-02f, 3.90824936e-02f, 1.49044067e-01f, 1.03682756e-01f,
  1.87257469e-01f, 1.28879815e-01f, -6.52796356e-03f, 1.08317798e-02f, -1.95954546e-01f, -1.65663660e-01f, -1.28235221e-01f, 3.67335230e-02f, -1.76857069e-01f, 1.54111385e-02f,
  -2.24795297e-01f, 5.00311591e-02f, 1.44254891e-02f, -9.21974033e-02f, 1.12708159e-01f, 1.08107127e-01f, -1.54864103e-01f, -1.44533560e-01f, 7.71778375e-02f, -3.99909774e-03f,
  -9.87788290e-02f, -4.37046587e-03f, -1.88820109e-01f, -1.48462370e-01f, 1.99611690e-02f, -4.74514216e-02f, -1.04683563e-01f, -4.01853323e-02f, 2.45095700e-01f, 8.26042518e-02f,
  -2.93251909e-02f, -2.66103204e-02f, -9.99527946e-02f, 2.95393891e-03f, 7.87687674e-03f, 2.01182097e-01f, -9.78286937e-02f, -5.26793152e-02f, 1.58952042e-01f, -1.47260785e-01f,
  6.68433234e-02f, -1.55117050e-01f, -8.53488371e-02f, -5.37582263e-02f, -8.80922005e-02f, -8.55181832e-03f
};

// L3_fan_Wp_bar (Shape: 26 x 64)
const int L3_fan_Wp_bar_rows = 26;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  7.38957450e-02f, 1.24311090e-01f, 3.31280343e-02f, 6.53263703e-02f, 3.02806534e-02f, -7.44971633e-02f, -5.36442250e-02f, -2.30778381e-03f, -1.25734612e-01f, 1.68553621e-01f,
  1.09325655e-01f, -7.44147748e-02f, 1.28518552e-01f, 5.75751066e-02f, -6.89411024e-03f, 6.25986829e-02f, -3.83029990e-02f, -3.51438299e-04f, -1.24523588e-01f, 1.27754703e-01f,
  1.75554559e-01f, 1.09475061e-01f, 4.30160314e-01f, 3.37448388e-01f, 2.58426011e-01f, 1.45864204e-01f, 3.04512233e-01f, 1.54775605e-01f, 2.12886631e-01f, -8.40245187e-02f,
  9.23070461e-02f, 6.79258108e-02f, 6.52671233e-03f, 1.89766362e-02f, -4.33790609e-02f, 3.45319122e-01f, -1.21443063e-01f, 1.53028905e-01f, 3.86929810e-01f, -1.49777783e-02f,
  1.76828317e-02f, 2.33144425e-02f, 1.58504732e-02f, 7.07907975e-02f, 2.68482417e-01f, -1.71257451e-01f, 1.17998347e-01f, -8.33696797e-02f, 2.91485488e-02f, -1.14127062e-01f,
  -4.19693850e-02f, -1.12776995e-01f, 1.84368581e-01f, 2.46578932e-01f, -2.94369787e-01f, -2.12179914e-01f, 3.50307524e-01f, -1.16818227e-01f, 2.15042874e-01f, -2.71325260e-01f,
  2.58466993e-02f, 3.45256329e-02f, -1.34579331e-01f, -1.77640080e-01f, -3.34445387e-02f, 1.11305125e-01f, 1.03920080e-01f, -1.21368319e-01f, -8.57833400e-02f, 8.10431167e-02f,
  -1.18903406e-01f, -8.76091197e-02f, -7.21440464e-02f, 5.02443314e-02f, -1.15413025e-01f, -1.43460408e-01f, -1.00665882e-01f, 8.50748122e-02f, -8.48672390e-02f, -7.57565605e-04f,
  -3.82523164e-02f, 1.16799764e-01f, 1.79641806e-02f, 1.55793503e-01f, -1.33988559e-01f, 1.05892241e-01f, 8.85837823e-02f, -3.82312573e-02f, -1.09015018e-01f, 5.54963239e-02f,
  5.26101701e-02f, -1.96505394e-02f, 5.15420036e-03f, -5.03339060e-02f, 1.28660887e-01f, -1.78206071e-01f, 1.51330724e-01f, 1.56951055e-01f, -3.04547120e-02f, -2.82781180e-02f,
  -5.23986444e-02f, -1.60282310e-02f, -4.15063463e-02f, -9.98787135e-02f, -7.01813847e-02f, -5.54539077e-02f, 1.09297439e-01f, -2.79159341e-02f, 1.39365286e-01f, -9.84116346e-02f,
  2.61942238e-01f, -4.37679626e-02f, 1.20763533e-01f, 7.17053488e-02f, -1.02972008e-01f, 4.15575542e-02f, 5.24582528e-03f, 3.53253521e-02f, -9.38358977e-02f, 1.40020445e-01f,
  6.56752214e-02f, 7.85115734e-02f, 2.72948723e-02f, 3.98564860e-02f, -3.27947475e-02f, -1.66898891e-02f, -1.17123716e-01f, 8.68533924e-02f, 1.40336275e-01f, -1.21725693e-01f,
  -8.59924406e-02f, -1.57973990e-01f, 1.12771699e-02f, -1.13687970e-01f, -1.29582614e-01f, -1.08895088e-02f, -3.91589813e-02f, 6.50895908e-02f, -1.48290485e-01f, -3.99166830e-02f,
  8.46577138e-02f, -8.46902058e-02f, 8.99100378e-02f, 1.39025539e-01f, -4.41386886e-02f, 5.91139756e-02f, -5.50649799e-02f, 7.30753765e-02f, -1.09507419e-01f, -4.95662428e-02f,
  1.07978113e-01f, 6.42436976e-03f, -1.09520905e-01f, 1.16179459e-01f, 2.80352067e-02f, -9.35337506e-03f, -3.13152336e-02f, -6.60113245e-02f, 9.14203525e-02f, 8.44052527e-03f,
  8.76744539e-02f, 1.92662120e-01f, -2.01868676e-02f, -1.53276008e-02f, 5.03482595e-02f, -1.11743554e-01f, -2.56738765e-03f, 3.18051130e-02f, 1.27909303e-01f, 9.90841314e-02f,
  -1.22907743e-01f, -7.68336430e-02f, -6.88273162e-02f, 8.03211182e-02f, 3.41494411e-01f, -2.84088496e-02f, -1.80281722e-03f, 5.26767671e-02f, 1.33451983e-01f, 9.29804868e-04f,
  -9.89290997e-02f, 1.77838191e-01f, -1.44684047e-01f, 5.40205427e-02f, 1.52673900e-01f, -1.43381327e-01f, 1.28870025e-01f, 1.23664990e-01f, -4.44658659e-02f, -2.57430295e-03f,
  3.23114470e-02f, 1.63848996e-02f, -4.59120087e-02f, -5.92426509e-02f, 1.75565541e-01f, -2.31344923e-01f, -1.74763948e-01f, 1.19766429e-01f, 2.13747527e-02f, -5.69067337e-02f,
  -1.75728276e-01f, -7.29754418e-02f, 1.20373800e-01f, 1.79997876e-01f, 9.03377458e-02f, 9.11689699e-02f, -6.09573349e-03f, 1.06540017e-01f, -6.74172714e-02f, 6.71044067e-02f,
  -1.02832258e-01f, 1.78183138e-01f, -9.11171585e-02f, -2.02966407e-02f, -4.01618853e-02f, -9.89977494e-02f, -3.23927887e-02f, -1.63309112e-01f, -1.53138386e-02f, -2.55370468e-01f,
  -1.12870485e-01f, 7.52898008e-02f, -1.49745107e-01f, -2.66165659e-02f, -6.11087680e-02f, 1.13059558e-01f, -5.10702617e-02f, -1.97522864e-01f, -2.32943129e-02f, -9.03105959e-02f,
  -2.01453924e-01f, 5.51133342e-02f, 1.02346381e-02f, -1.39897987e-01f, -9.91292670e-02f, -1.31008849e-01f, -6.68072626e-02f, 1.69721365e-01f, 1.69491246e-01f, -1.26694441e-01f,
  2.66883504e-02f, 5.74013703e-02f, 1.58419415e-01f, -1.01356998e-01f, -1.20586507e-01f, -2.03071743e-01f, 2.18117535e-01f, 2.35821586e-02f, -8.94077420e-02f, 1.60897791e-01f,
  -1.91990823e-01f, 1.84111655e-01f, -3.16309631e-02f, -4.34957631e-02f, 8.98552388e-02f, 9.30864662e-02f, 8.57211575e-02f, -3.70588973e-02f, -4.38581072e-02f, -3.94801274e-02f,
  -2.04085261e-02f, 9.42013115e-02f, -7.81175494e-02f, -1.79976821e-02f, 5.38058989e-02f, -9.10291001e-02f, 8.94771814e-02f, 1.72619186e-02f, -6.63314238e-02f, -1.03213646e-01f,
  -1.30786493e-01f, -5.17216772e-02f, -9.67349857e-02f, -9.41210762e-02f, 9.95754004e-02f, -1.08355053e-01f, 6.16068728e-02f, -3.52878235e-02f, -7.55811483e-02f, 2.79178191e-03f,
  7.08132982e-02f, -3.93147394e-02f, -6.53515533e-02f, 9.88503247e-02f, -3.32010798e-02f, -3.58471833e-02f, -1.47354584e-02f, -1.30244792e-02f, -1.57692973e-02f, 5.55250328e-03f,
  4.98488126e-03f, -1.30184209e-02f, 8.47029611e-02f, -1.03767261e-01f, -2.03688350e-02f, 9.48568657e-02f, -8.75524580e-02f, 5.94753921e-02f, 4.82035875e-02f, 2.73673441e-02f,
  -1.61111988e-02f, 7.90387467e-02f, 9.07065570e-02f, 7.49927163e-02f, 4.51636827e-03f, 5.33703193e-02f, -5.25242276e-02f, 1.15207963e-01f, -4.24221382e-02f, -1.02706537e-01f,
  -1.12727366e-01f, -3.20600756e-02f, 5.63744530e-02f, -1.54789342e-02f, -1.19049184e-01f, -9.06344801e-02f, 1.03923731e-01f, 3.25414799e-02f, -5.21680675e-02f, -9.44720954e-02f,
  -6.04314543e-02f, 8.79413914e-03f, -1.82494093e-02f, 5.46329394e-02f, 7.85450190e-02f, 1.13326564e-01f, 5.07257022e-02f, 3.95918451e-02f, 6.03317469e-02f, -7.27766603e-02f,
  -1.03307940e-01f, -2.74555795e-02f, -5.97757585e-02f, 1.86298061e-02f, -3.76466773e-02f, -4.89354767e-02f, 1.30520418e-01f, 1.13107964e-01f, 6.05150498e-02f, 4.83695902e-02f,
  9.33359936e-02f, -7.26702884e-02f, -7.23016933e-02f, 8.68846774e-02f, 2.54314765e-02f, -1.08270042e-01f, -1.62356019e-01f, 4.82530482e-02f, -1.76977992e-01f, 2.04947218e-02f,
  6.59064725e-02f, -1.03595287e-01f, 7.63076469e-02f, 9.28729698e-02f, -1.44979477e-01f, -1.10427253e-01f, -7.84136802e-02f, -9.07977670e-02f, 2.10762266e-02f, 4.91186082e-02f,
  7.08455443e-02f, -8.15920085e-02f, 1.07342139e-01f, -6.89051151e-02f, -4.95302938e-02f, -4.18734103e-02f, -8.17989111e-02f, -1.47364167e-02f, 6.57613575e-02f, -1.73550751e-02f,
  -2.51649581e-02f, 5.89680523e-02f, -8.30018595e-02f, 3.27946059e-02f, 1.64733842e-01f, 1.35323480e-01f, 8.41816589e-02f, 1.32188529e-01f, 8.48989636e-02f, -6.86228722e-02f,
  -3.54612619e-02f, -4.53453325e-02f, -1.10455431e-01f, 2.37924438e-02f, 9.87793952e-02f, 1.85685962e-01f, 8.14087689e-02f, 1.10828869e-01f, 1.87280819e-01f, 3.40904575e-03f,
  -4.39210311e-02f, 2.18660668e-01f, 1.98773071e-01f, -7.89993182e-02f, -1.11825965e-01f, -6.16411977e-02f, -4.87953313e-02f, -8.66034776e-02f, 1.47826495e-02f, -1.32891163e-01f,
  1.26799598e-01f, 1.24946408e-01f, 1.01573497e-01f, 1.54578775e-01f, -2.27952227e-02f, 1.81161672e-01f, -1.36741117e-01f, -3.26679386e-02f, -1.76406249e-01f, 1.64635390e-01f,
  -1.55678928e-01f, 6.56191111e-02f, -1.60832673e-01f, 2.33434942e-02f, 2.11590677e-01f, -2.94771697e-02f, 1.89036325e-01f, 1.80456966e-01f, -1.47586584e-01f, -1.10429019e-01f,
  -8.21341425e-02f, -1.38318375e-01f, -1.80596188e-02f, -4.10117060e-02f, 1.95388217e-02f, 8.99516493e-02f, -9.78744552e-02f, -1.01769850e-01f, 1.77439749e-01f, -6.33595064e-02f,
  3.00747901e-01f, 7.62544051e-02f, 1.63165033e-02f, -1.34423664e-02f, -2.34324951e-02f, -6.84106871e-02f, 1.10948846e-01f, 2.95385361e-01f, -1.37033448e-01f, 3.24126123e-03f,
  4.94625308e-02f, -1.25642046e-01f, 1.60663620e-01f, -4.67245653e-02f, -3.27891745e-02f, 1.58695906e-01f, -2.12788954e-02f, -1.33307772e-02f, 1.02271914e-01f, 1.08018881e-02f,
  1.24899611e-01f, -9.52095017e-02f, 5.93998011e-05f, 4.67263572e-02f, 4.13470268e-02f, 6.70261011e-02f, -2.97313165e-02f, -3.35268378e-02f, 4.53373082e-02f, -7.64407143e-02f,
  6.71913894e-03f, 1.12534240e-01f, 9.51221585e-02f, 9.10829345e-04f, 7.35163763e-02f, -1.79634541e-02f, -2.53420579e-03f, -9.54529550e-03f, 2.19778176e-02f, -1.29181728e-01f,
  -1.08417504e-01f, 1.31292254e-01f, 1.39050916e-01f, -1.15767241e-01f, -1.25228167e-02f, -3.60566494e-03f, -9.93873104e-02f, -5.88878058e-03f, -2.37781107e-02f, 7.10183829e-02f,
  -6.81518465e-02f, 6.06273599e-02f, 8.05074051e-02f, -9.51958373e-02f, 4.37255651e-02f, -6.82078376e-02f, 3.49256881e-02f, -1.73723197e-03f, -3.65017056e-02f, -1.17908418e-01f,
  -4.40527722e-02f, 7.02097863e-02f, -7.80594200e-02f, 1.05665676e-01f, 1.42206457e-02f, 2.06596944e-02f, -2.24720500e-03f, 7.92769075e-04f, -9.41853747e-02f, 1.17398001e-01f,
  -8.68735537e-02f, 1.06917403e-03f, 4.48730662e-02f, -7.01127723e-02f, -2.21266132e-02f, 4.29062359e-02f, -3.00221723e-02f, -9.40440297e-02f, 4.12617177e-02f, -7.01529160e-02f,
  5.72329834e-02f, 5.01484871e-02f, -4.40844744e-02f, -5.09343557e-02f, 1.59823317e-02f, 3.90959159e-02f, 1.28368020e-01f, 3.14567909e-02f, 8.41238499e-02f, 7.21365884e-02f,
  3.72518636e-02f, -5.12734205e-02f, 2.75470745e-02f, 8.88417587e-02f, 1.18101925e-01f, 1.66328534e-01f, 4.43976149e-02f, 8.22936222e-02f, -8.19029287e-02f, 1.28141671e-01f,
  1.43336788e-01f, -1.83598343e-02f, 9.69410539e-02f, -5.08928709e-02f, 2.11446267e-03f, 1.76200628e-01f, 1.19308047e-01f, 6.44314662e-02f, 1.23336568e-01f, 1.07893825e-01f,
  7.97890052e-02f, 7.27181882e-02f, 1.18852906e-01f, -6.77927807e-02f, -1.06226420e-02f, -5.76475263e-02f, 7.53220618e-02f, -2.65808292e-02f, 3.76079045e-02f, 2.09023044e-01f,
  6.78897575e-02f, 1.07334629e-01f, -6.25359118e-02f, -1.21291406e-01f, -7.30015710e-02f, -6.85262606e-02f, 5.50736114e-02f, -1.56088755e-01f, 4.93658222e-02f, -6.60262257e-02f,
  -2.17656381e-02f, -1.27598569e-01f, 1.35296792e-01f, -3.87032554e-02f, -4.90367301e-02f, 1.09952554e-01f, 6.96262866e-02f, -1.16119660e-01f, 9.44639966e-02f, 1.41536430e-01f,
  9.87717211e-02f, -2.21915748e-02f, -7.32752010e-02f, 2.20505521e-01f, 5.55872060e-02f, -1.36037748e-02f, 9.28786695e-02f, -1.04536280e-01f, -6.24770075e-02f, -2.14247271e-01f,
  -4.39808071e-02f, -6.78823292e-02f, 2.83922851e-02f, -5.31627983e-02f, -1.62406534e-01f, -1.63992897e-01f, -1.18072987e-01f, 4.25185636e-02f, 6.93503171e-02f, -9.13056917e-03f,
  -1.23310052e-01f, 1.27767965e-01f, -1.92932934e-01f, -9.09501389e-02f, 1.64692458e-02f, 5.29108569e-02f, 3.24434564e-02f, -4.27789614e-02f, 1.15571477e-01f, 2.54788958e-02f,
  -1.35139033e-01f, 1.27947003e-01f, 6.40799850e-02f, -1.56817257e-01f, 1.29597038e-01f, -9.30466689e-03f, 1.45529345e-01f, 7.36110806e-02f, 1.32073730e-01f, 7.46773481e-02f,
  9.31657627e-02f, -1.22080706e-01f, -1.82272002e-01f, -3.51278484e-02f, 1.44302443e-01f, -6.13704277e-03f, -4.92147952e-02f, 2.12228551e-04f, -6.46108836e-02f, 1.54850543e-01f,
  -1.06274365e-02f, -2.61415448e-02f, 2.77119070e-01f, -3.98966670e-02f, 8.72718990e-02f, -7.93851539e-02f, 1.88360453e-01f, -4.07014638e-02f, -2.39516851e-02f, 1.54698208e-01f,
  3.01877763e-02f, 4.40091593e-03f, 1.27042249e-01f, -7.00819045e-02f, 1.08310595e-01f, -3.46986484e-03f, 9.95702296e-02f, -1.08138271e-01f, 3.97512875e-02f, 1.17179871e-01f,
  1.46700114e-01f, -2.67915223e-02f, 4.11433354e-02f, 5.82001396e-02f, -5.78609183e-02f, 6.05158247e-02f, 2.98373085e-02f, -7.50272125e-02f, 1.25851616e-01f, -1.44422710e-01f,
  -1.18403591e-01f, 1.28863767e-01f, 1.23313852e-01f, 9.03461650e-02f, 6.77406862e-02f, 8.82544816e-02f, 1.43075526e-01f, 8.43900163e-03f, 3.90214361e-02f, 1.23760529e-01f,
  2.84690149e-02f, -1.44038275e-01f, -1.47042021e-01f, 4.02699597e-02f, 9.19745583e-03f, 1.55270249e-01f, -1.57321175e-03f, 3.16270925e-02f, 1.01729788e-01f, 1.07693985e-01f,
  -2.73652840e-02f, -1.68557152e-01f, -1.67736430e-02f, -9.37217730e-04f, -7.47967139e-02f, -6.07058741e-02f, 3.26848067e-02f, -4.99731535e-03f, 2.40202639e-02f, -5.44977337e-02f,
  -1.67094786e-02f, 5.32520283e-03f, -1.13767676e-01f, 1.79965068e-02f, -1.20480984e-01f, 1.35142903e-03f, 2.43278578e-01f, 3.05712260e-02f, -5.20018749e-02f, -8.54621604e-02f,
  1.21329650e-01f, 9.22285989e-02f, 3.52730900e-02f, 7.87741989e-02f, -2.15799082e-02f, 3.34355682e-02f, 2.03589201e-01f, -3.59815843e-02f, 1.69168357e-02f, 5.84397875e-02f,
  -1.06185898e-01f, 2.43042558e-01f, 3.62016223e-02f, -3.37112397e-02f, -1.55876815e-01f, 9.28423330e-02f, 1.14150405e-01f, 9.16193007e-04f, 3.73590877e-03f, -4.30408232e-02f,
  6.56762943e-02f, 7.06395193e-04f, -3.51054519e-02f, 1.18857414e-01f, -7.78830424e-02f, 7.78143331e-02f, 1.19566560e-01f, -8.11105669e-02f, -4.67659719e-03f, -6.19030818e-02f,
  -1.41411439e-01f, -1.12736560e-02f, -1.19845308e-01f, 5.28267445e-03f, -1.22832946e-01f, -5.46011813e-02f, -1.80161949e-02f, -1.08963229e-01f, -1.20741926e-01f, -7.03063309e-02f,
  -3.75859290e-02f, 7.69308880e-02f, -9.07204896e-02f, 8.59258920e-02f, -1.00337997e-01f, 3.58806811e-02f, 1.38767421e-01f, 4.28681634e-02f, 4.30863127e-02f, 9.18728635e-02f,
  -1.85937546e-02f, 4.53462563e-02f, -1.02879032e-01f, -1.06022291e-01f, 1.15419701e-01f, -1.04322275e-02f, 4.98468019e-02f, -1.92159787e-02f, 5.36308959e-02f, 1.66666508e-01f,
  5.63921370e-02f, -1.17276207e-01f, -6.00164421e-02f, -7.40171522e-02f, -2.50547901e-02f, 7.40565360e-02f, 4.65603778e-03f, -1.23435862e-01f, -6.49496019e-02f, -5.15092574e-02f,
  -1.35228792e-02f, 4.05403227e-02f, 6.05076663e-02f, -1.31432042e-01f, 7.94318467e-02f, -8.56316611e-02f, -3.55897173e-02f, -9.62198302e-02f, 2.52725352e-02f, 1.10577881e-01f,
  -9.43681300e-02f, 2.56612501e-03f, -1.18425719e-01f, 1.41984848e-02f, 1.30647928e-01f, 7.03461170e-02f, 7.36913979e-02f, -9.06783640e-02f, 8.64876062e-03f, -1.22262314e-02f,
  -7.59404600e-02f, -8.25721398e-02f, 9.06671137e-02f, 1.06751382e-01f, -4.00197804e-02f, 1.20195396e-01f, 2.39587873e-02f, -1.18342303e-01f, 1.43228307e-01f, -1.45944566e-01f,
  -3.71108428e-02f, -2.92595513e-02f, 1.39103040e-01f, -1.25882521e-01f, 7.59852529e-02f, -1.02845259e-01f, -3.67412567e-02f, 5.03742089e-03f, 6.98220655e-02f, -5.16871326e-02f,
  -7.69210830e-02f, -1.55253991e-01f, -1.36202618e-01f, 2.70648524e-02f, -4.77778055e-02f, 6.65084273e-02f, 3.12233157e-02f, -8.53190422e-02f, 5.10955192e-02f, 9.17873904e-02f,
  4.53315638e-02f, 1.16475612e-01f, 6.58636466e-02f, -6.80248067e-02f, 1.29478890e-03f, -1.85605772e-02f, -1.88319664e-02f, -1.20876677e-01f, -4.71213870e-02f, 3.93258221e-02f,
  -6.26272559e-02f, 1.30803317e-01f, -4.07735370e-02f, -5.47884814e-02f, 5.33048175e-02f, 8.17403495e-02f, 1.37574011e-02f, -6.02856092e-02f, -5.33177741e-02f, 9.49490145e-02f,
  -1.09694362e-01f, 1.24111257e-01f, -1.74905788e-02f, 6.50373846e-02f, 2.44008619e-02f, 4.34562713e-02f, 1.92153037e-01f, -1.03257038e-03f, 1.01346619e-01f, 1.91995367e-01f,
  1.76371038e-01f, 7.28061795e-02f, 1.71200544e-01f, 1.12679102e-01f, 4.06423695e-02f, 5.45563139e-02f, 9.29046646e-02f, 3.59396525e-02f, 3.32054570e-02f, 3.18314089e-03f,
  1.16615482e-01f, -1.03912659e-01f, 1.73371091e-01f, -9.75542143e-02f, 1.45413235e-01f, 1.10075966e-01f, 4.80876826e-02f, 7.20652640e-02f, 1.70099705e-01f, 2.03446541e-02f,
  3.02857086e-02f, 4.16301712e-02f, -4.82562780e-02f, -8.29668343e-02f, -1.54521391e-01f, 4.85438667e-02f, 2.12076250e-02f, 1.00571439e-01f, 2.51814052e-02f, 1.51096329e-01f,
  1.33247219e-03f, 8.35504904e-02f, -3.57230157e-02f, 1.33074448e-01f, -4.78688143e-02f, -1.25447437e-02f, -1.15631826e-01f, -1.78660780e-01f, 7.14725628e-02f, -4.35978174e-02f,
  1.14924312e-01f, -3.71148475e-02f, 6.11967109e-02f, -1.09595381e-01f, -7.54343122e-02f, 1.58907667e-01f, 7.96979964e-02f, 1.46586271e-02f, 9.61533003e-03f, -1.76975857e-02f,
  7.42386431e-02f, 1.87000901e-01f, -1.14744902e-02f, 1.09663002e-01f, 1.07969224e-01f, 3.45783122e-02f, -9.84127223e-02f, -1.14175797e-01f, 2.04488728e-02f, 7.50850961e-02f,
  -1.22666813e-01f, 5.61854653e-02f, 4.63669337e-02f, 9.94152352e-02f, -1.06405959e-01f, 1.19710386e-01f, -4.37548347e-02f, -2.94227600e-02f, 1.13509394e-01f, -1.04964964e-01f,
  -2.91764047e-02f, -1.00569136e-01f, -1.11154601e-01f, -4.46951613e-02f, -4.65266928e-02f, -4.89616767e-02f, -5.45046031e-02f, -7.95542896e-02f, 3.56040560e-02f, 7.21759126e-02f,
  9.56206620e-02f, -1.60299223e-02f, -1.12467602e-01f, 1.08677775e-01f, 5.63897789e-02f, 2.35113278e-02f, 1.19992606e-02f, -9.60767567e-02f, 4.45188470e-02f, -1.26576498e-01f,
  1.12108551e-01f, 6.17851764e-02f, 7.51302242e-02f, -7.72086158e-02f, -6.60997108e-02f, -1.16349319e-02f, -4.88608070e-02f, -1.17244057e-01f, -2.53598038e-02f, 3.24331783e-03f,
  -5.93447164e-02f, -5.77344969e-02f, 7.79956132e-02f, -2.11845599e-02f, 3.75109427e-02f, -9.99517553e-03f, 9.88884345e-02f, -6.57886593e-03f, 5.80420569e-02f, -1.35190219e-01f,
  1.28303334e-01f, 3.79680879e-02f, 4.63854484e-02f, 1.45360660e-02f, 2.47127973e-02f, -6.66713342e-02f, 3.68503407e-02f, -5.50441816e-02f, -3.64333838e-02f, -5.07844873e-02f,
  -1.29180908e-01f, 1.22250147e-01f, 1.15279905e-01f, 8.48531201e-02f, 7.14197308e-02f, 9.08421427e-02f, 1.28801644e-01f, 7.70845078e-03f, 2.38719463e-01f, 1.19906344e-01f,
  9.38902497e-02f, 4.45135273e-02f, 8.08217227e-02f, 1.83062963e-02f, 7.47471079e-02f, 1.32014707e-01f, 1.05130322e-01f, -1.19199604e-01f, 1.41611412e-01f, 2.39807516e-01f,
  -1.55349917e-04f, 1.74008414e-01f, -1.62108585e-01f, -1.35461241e-01f, 4.61466052e-02f, 2.23553434e-01f, -2.24286690e-01f, -6.40826225e-02f, -1.93198815e-01f, 2.25826595e-02f,
  4.72500734e-02f, -2.50157416e-01f, 2.06994519e-01f, 2.30950713e-01f, 6.67621940e-02f, 2.39066314e-02f, -4.50183339e-02f, -1.55557394e-01f, 1.33277893e-01f, -9.95562226e-02f,
  -1.17980979e-01f, 2.30483972e-02f, -6.33920953e-02f, -1.18448436e-01f, 2.15532690e-01f, 1.01793051e-01f, 2.79241860e-01f, -3.80877629e-02f, 5.15407734e-02f, -5.58783934e-02f,
  7.26472363e-02f, 5.32136261e-02f, -8.70970637e-02f, 3.01112887e-03f, -1.16455510e-01f, 8.83793756e-02f, -4.07157466e-02f, -3.86857390e-02f, 8.79030973e-02f, -1.30989745e-01f,
  -9.36649814e-02f, -2.74793170e-02f, 1.11445665e-01f, -4.19282950e-02f, -1.14793666e-01f, 3.93277407e-02f, 2.16006320e-02f, 8.79620388e-02f, 1.17246747e-01f, 1.03890076e-01f,
  -4.77155261e-02f, 3.79581749e-02f, 2.38090940e-02f, -4.27718759e-02f, 4.86753657e-02f, 4.64049503e-02f, 9.24457610e-02f, 1.62800804e-01f, 1.25374720e-01f, 6.61045089e-02f,
  -1.48349563e-02f, -1.17361352e-01f, 4.41366173e-02f, -1.50166510e-03f, 8.37419108e-02f, -5.68478592e-02f, -7.46533796e-02f, -1.14384852e-01f, 1.08494326e-01f, -6.16876222e-03f,
  -8.41662213e-02f, 6.01236820e-02f, -1.31695881e-01f, 1.11611001e-01f, 3.16294134e-02f, 1.01123422e-01f, -9.75465849e-02f, 8.13605860e-02f, -6.52912036e-02f, -7.64440447e-02f,
  5.88035583e-02f, -2.34200098e-02f, 9.49052870e-02f, -5.31872101e-02f, -1.21958874e-01f, -1.42338648e-01f, -9.17963088e-02f, -8.18319172e-02f, 1.26986876e-01f, 1.95981175e-01f,
  -1.11667393e-02f, 5.76137230e-02f, 3.43673788e-02f, 1.11882156e-02f, -4.50052619e-02f, -1.03823908e-01f, -3.07767210e-03f, -3.53132151e-02f, -3.45932841e-02f, 2.62358561e-02f,
  -1.22994529e-02f, 1.14221990e-01f, -5.04944883e-02f, 2.66471002e-02f, -2.69800574e-02f, -1.27022102e-01f, 5.98436706e-02f, 1.39122140e-02f, 1.38700038e-01f, -4.17029522e-02f,
  3.13816369e-02f, -1.53330648e-02f, -4.51335609e-02f, -2.97260303e-02f, -7.48472214e-02f, 6.40187413e-02f, 7.42398351e-02f, 1.26836270e-01f, -7.14144483e-02f, -1.91880614e-02f,
  1.02391556e-01f, 1.58534180e-02f, 7.72065716e-03f, -9.68372971e-02f, -1.29604027e-01f, -4.31680977e-02f, 9.26107541e-02f, -5.27571701e-02f, 4.88335602e-02f, 4.77387309e-02f,
  -8.11407343e-02f, 1.78013623e-01f, -7.81748742e-02f, 9.74461213e-02f, -2.73447409e-02f, 3.02008986e-02f, 1.47199720e-01f, -6.16982691e-02f, -1.34642482e-01f, 4.93207276e-02f,
  -1.57191008e-01f, -2.42086779e-02f, 5.64227700e-02f, 1.57779023e-01f, 1.01179309e-01f, 8.55856761e-02f, -3.66616994e-02f, -5.64683713e-02f, 6.03643991e-02f, -6.70753559e-03f,
  -8.43304172e-02f, 9.46665257e-02f, -7.25181103e-02f, -1.29722089e-01f, 7.74511918e-02f, -9.80305746e-02f, 9.63348225e-02f, -1.96200497e-02f, 1.18704133e-01f, 7.30384961e-02f,
  1.30014911e-01f, 1.63602680e-01f, 1.56562150e-01f, 1.56201003e-03f, 6.92157215e-03f, 8.38835835e-02f, 1.86775282e-01f, 1.59386963e-01f, -5.39522506e-02f, 8.55477825e-02f,
  -8.14664885e-02f, 2.96425191e-03f, 2.87938379e-02f, 1.86258405e-01f, -2.02944677e-04f, 8.74991119e-02f, 1.79343924e-01f, 1.78792432e-01f, 2.75337011e-01f, 2.17257068e-01f,
  1.52742984e-02f, 5.93370013e-02f, 1.15617365e-01f, 2.04099968e-01f, 1.64311603e-02f, -3.64452116e-02f, 8.51373672e-02f, 6.06072843e-02f, 2.07827181e-01f, 9.38623622e-02f,
  1.45852312e-01f, -1.19331062e-01f, -1.04945369e-01f, -2.92606354e-01f, -3.05585265e-01f, -2.20589146e-01f, -1.58264097e-02f, -1.69976458e-01f, -1.21962260e-02f, -8.56900290e-02f,
  -4.26196456e-02f, -2.95490026e-01f, -4.09679860e-02f, 2.45009840e-01f, -1.70223966e-01f, -1.43719286e-01f, -2.25067377e-01f, 3.11382134e-02f, -1.20825455e-01f, -1.14766672e-01f,
  -4.78574559e-02f, -1.05106365e-02f, 2.55419344e-01f, 3.06639355e-02f, 4.16406021e-02f, 1.32973185e-02f, -2.90664524e-01f, -1.47184417e-01f, 1.03550792e-01f, 8.67382735e-02f,
  -1.15135625e-01f, 1.12774074e-01f, 2.67198384e-01f, -9.16189328e-02f, -3.66367064e-02f, 2.17810214e-01f, 4.05302674e-01f, 9.25545755e-04f, 3.36391442e-02f, 2.15200651e-02f,
  1.24835908e-01f, 3.47800940e-01f, 1.15255892e-01f, 2.03786567e-01f, 5.55894487e-02f, 2.69823581e-01f, 1.75615430e-01f, 7.02651888e-02f, -8.83415341e-02f, 7.63663203e-02f,
  1.96866274e-01f, -6.63028425e-03f, 1.18374927e-02f, 1.66542828e-01f, 2.87659001e-02f, 6.36360422e-02f, 8.78435671e-02f, 5.06475680e-02f, 1.14573039e-01f, 8.47240165e-02f,
  -1.68187357e-02f, 9.55892056e-02f, -8.79404917e-02f, 1.07561693e-01f, 1.18532643e-01f, -8.76487121e-02f, -6.13303259e-02f, 2.19650790e-02f, 2.05027476e-01f, -5.68038272e-03f,
  -2.33409498e-02f, 1.46863624e-01f, 1.38609961e-01f, 1.87284186e-01f, -1.67435914e-01f, 1.65206462e-01f, -1.14744361e-02f, 2.84095909e-02f, 8.99339095e-02f, 3.94154564e-02f,
  -4.32772748e-02f, -1.99636165e-02f, -2.41067465e-02f, 1.61443964e-01f, 8.73147026e-02f, -4.23758924e-02f, -1.29238755e-01f, 6.41610473e-02f, 9.30806622e-02f, 6.17436646e-03f,
  -8.39369223e-02f, -1.91251546e-01f, 2.26873577e-01f, -9.78261679e-02f, 1.07052036e-01f, -3.92107517e-02f, -8.25927854e-02f, 1.05580732e-01f, -8.86083618e-02f, 1.72386244e-01f,
  -1.63835868e-01f, -6.30220845e-02f, 2.65517354e-01f, -6.88019767e-02f, -2.63171233e-02f, 1.19556144e-01f, 4.33742143e-02f, -2.95033827e-02f, -7.05321133e-02f, -3.60323116e-02f,
  1.23290896e-01f, 7.89003745e-02f, 2.63466567e-01f, -3.06606814e-02f, -3.80819552e-02f, 1.86853930e-01f, 1.62345067e-01f, 1.30957589e-01f, 2.47003332e-01f, 7.25673810e-02f,
  1.30762473e-01f, 1.49939433e-01f, -1.94904823e-02f, 1.18763864e-01f, 1.97090268e-01f, 5.45733459e-02f, 1.41605228e-01f, -1.13419965e-01f, -2.01227013e-02f, 1.88564867e-01f,
  -2.19651699e-01f, -1.09875882e-02f, -2.02860713e-01f, -2.75117666e-01f, -2.18969375e-01f, -6.83621839e-02f, -2.85766870e-01f, -2.28516892e-01f, -2.44526193e-01f, 9.45330039e-02f,
  -8.00025761e-02f, -5.40109864e-03f, 1.44506410e-01f, 1.16518743e-01f, -1.14280246e-01f, -5.53183705e-02f, -2.00372264e-01f, -2.73839176e-01f, -1.22028235e-02f, -1.25060175e-02f,
  -2.27386821e-02f, 3.86803374e-02f, -8.43201429e-02f, -1.35688901e-01f, 1.95119705e-04f, 2.23471820e-01f, 2.14206070e-01f, -1.29228517e-01f, -1.19702488e-01f, -1.45714208e-01f,
  7.89857954e-02f, -1.21419862e-01f, 8.47408455e-03f, -1.26551315e-01f, 4.32800539e-02f, -2.62366771e-03f, -8.78085718e-02f, -3.03383190e-02f, 1.08768128e-01f, -9.45590064e-03f,
  8.88660084e-03f, 9.42278653e-03f, -8.52960497e-02f, 2.24453971e-01f, -2.35234872e-02f, 2.97866855e-02f, -9.13214833e-02f, 1.04599714e-01f, -1.12905763e-02f, 8.05560201e-02f,
  1.62119702e-01f, -2.39572600e-02f, -1.91811903e-03f, 1.23213477e-01f, 1.03815712e-01f, -9.94828567e-02f, 7.96788782e-02f, 4.83326800e-02f, 1.01041734e-01f, -4.72183377e-02f,
  1.57827929e-01f, -1.15430571e-01f, -3.79349738e-02f, 1.59197390e-01f, -2.05192016e-03f, -8.80801231e-02f, -5.28307445e-02f, -5.70669994e-02f, 7.29788095e-03f, -7.75838941e-02f,
  -1.07090339e-01f, -1.37661055e-01f, -1.19144760e-01f, 8.20934922e-02f, 1.20212369e-01f, -1.10973902e-01f, -3.32022049e-02f, 9.66377407e-02f, 8.13804641e-02f, -2.00442001e-02f,
  -1.58852592e-01f, -8.57678205e-02f, -8.42349976e-02f, -1.17031168e-02f, -1.16728261e-01f, 2.86252163e-02f, -9.27415565e-02f, -1.19964071e-01f, 8.05985928e-02f, 5.54324239e-02f,
  1.46073878e-01f, -9.69814584e-02f, 3.68994065e-02f, -4.69019189e-02f, -7.62209818e-02f, 6.17998326e-03f, 4.46732081e-02f, 4.79194224e-02f, 2.28061080e-02f, 5.76486737e-02f,
  1.46414097e-02f, -4.08834107e-02f, -6.59922734e-02f, -1.24660410e-01f, -1.01732522e-01f, -2.42352467e-02f, 8.33948776e-02f, -1.38949240e-02f, 1.05716474e-01f, -2.89208833e-02f,
  -7.29173049e-02f, 1.31522432e-01f, 5.11867069e-02f, 9.12466124e-02f, -3.01480736e-03f, 1.83304682e-01f, 5.80226816e-02f, 1.29967973e-01f, 7.57982135e-02f, 1.02428369e-01f,
  -6.13255017e-02f, 1.67704269e-01f, 1.15237750e-01f, -1.14522897e-01f, 1.45099252e-01f, -2.98078675e-02f, 1.13901801e-01f, 4.16271128e-02f, 5.24070561e-02f, 7.16164559e-02f,
  -1.56544343e-01f, -3.64037231e-02f, -3.10281385e-02f, 1.85451463e-01f, 7.83974901e-02f, -5.47042824e-02f, -1.02980904e-01f, 1.58784196e-01f, 2.44306296e-01f, -6.79097772e-02f,
  1.75980300e-01f, 6.72639012e-02f, -4.70459787e-03f, -6.24905340e-02f, -4.49269712e-02f, 3.36903310e-03f, 6.93851635e-02f, 4.77503762e-02f, -2.83263717e-02f, -1.19426519e-01f,
  -1.47637604e-02f, -1.10814139e-01f, 9.18076485e-02f, 1.21482342e-01f, 2.92495817e-01f, 9.19718966e-02f, 9.80613157e-02f, -1.54759670e-02f, 6.43630624e-02f, 4.39909138e-02f,
  2.44031474e-02f, 2.16014206e-01f, -7.65356943e-02f, -1.58026684e-02f, 1.86461031e-01f, -1.06360957e-01f, 1.18365893e-02f, -1.27637282e-01f, -1.43829122e-01f, 1.32900223e-01f,
  -8.78544673e-02f, -6.07905053e-02f, -1.69983700e-01f, -1.06404135e-02f, 2.18019485e-02f, -9.57637131e-02f, 9.54441279e-02f, 6.85327575e-02f, 1.72983140e-01f, 6.93422332e-02f,
  -1.41546741e-01f, 3.03361025e-02f, 4.67425846e-02f, -4.09190822e-03f, 1.73737505e-03f, 1.40124217e-01f, 9.51665491e-02f, 1.34407282e-01f, 1.40080556e-01f, -7.26578906e-02f,
  -2.58176737e-02f, 1.09049492e-01f, -3.50271575e-02f, 1.09918617e-01f, 7.33233839e-02f, -3.65821570e-02f, 8.73648673e-02f, -7.72357658e-02f, -1.08082011e-01f, -1.31462082e-01f,
  -5.91917224e-02f, 5.35814501e-02f, 1.13748506e-01f, 1.14715351e-02f, 1.18850730e-01f, 5.32377735e-02f, 2.90580504e-02f, -1.30824521e-01f, -1.98448095e-02f, -1.78358424e-02f,
  9.17771086e-02f, -8.99913311e-02f, 5.90332076e-02f, -5.10317609e-02f, -1.09352753e-01f, -6.41662106e-02f, 1.23038098e-01f, 1.98216319e-01f, -5.79592846e-02f, 4.87955697e-02f,
  8.36660266e-02f, -3.52354087e-02f, -1.95555855e-02f, -9.54245105e-02f, 6.99237511e-02f, -1.89559624e-01f, 1.14683874e-01f, 6.54529035e-02f, -7.45381564e-02f, 1.13293760e-01f,
  -1.31075084e-01f, -1.27087176e-01f, 2.13235375e-02f, -5.32179028e-02f, 8.51997286e-02f, 1.05211674e-03f, 5.35551235e-02f, 1.19735919e-01f, -4.39501479e-02f, -2.49318443e-02f,
  3.90114402e-03f, 1.07296474e-01f, -9.90950316e-02f, 5.26166856e-02f, 6.12734258e-02f, -8.41684565e-02f, -6.10837489e-02f, 7.54314587e-02f, -8.36266652e-02f, -1.36347655e-02f,
  -1.09037593e-01f, 1.04090400e-01f, -5.01263775e-02f, 5.21122105e-02f, 3.24869119e-02f, -6.22448735e-02f, 1.81186646e-02f, 4.28025164e-02f, 5.82913160e-02f, 6.82735369e-02f,
  -1.67237911e-02f, -9.57645550e-02f, 2.63839290e-02f, -2.71004196e-02f, 4.16564159e-02f, 5.50732464e-02f, -2.97410730e-02f, -3.79935466e-02f, -1.17041983e-01f, 6.26198724e-02f,
  -4.58823740e-02f, 1.31152689e-01f, 7.35635236e-02f, -1.01336680e-01f, 3.89315039e-02f, 3.61890420e-02f, 2.39514993e-04f, 1.18493475e-01f, 1.27751976e-01f, -2.26982180e-02f,
  1.21849105e-02f, -9.74837691e-02f, -8.36944580e-02f, 5.37775829e-02f, -3.87589522e-02f, 1.08134478e-01f, -6.72744634e-03f, -1.78091526e-02f, -1.03812262e-01f, -2.66134571e-02f,
  8.13090578e-02f, 1.06940255e-01f, -1.52752083e-02f, 2.03903802e-02f, 1.44255683e-01f, -3.40279303e-02f, -1.03535786e-01f, -1.11207455e-01f, -5.14796637e-02f, -2.10972261e-02f,
  2.79676933e-02f, 4.32253145e-02f, 6.49540946e-02f, -1.43984422e-01f, -1.23702727e-01f, 6.48806542e-02f, -1.59180127e-02f, -1.23201266e-01f, -1.58785030e-01f, 3.22889350e-02f,
  -3.82360667e-02f, -4.16037766e-03f, -8.09916109e-02f, -1.29281580e-01f, -1.11429505e-01f, -5.13844788e-02f, -1.20170586e-01f, -4.36700657e-02f, -1.49318948e-01f, 3.75934020e-02f,
  -2.17385124e-02f, -2.53028832e-02f, -9.04026553e-02f, 3.38068791e-02f, 9.40248743e-02f, 8.72157067e-02f, -8.15273970e-02f, -7.38595799e-02f, -2.63192020e-02f, 6.66561574e-02f,
  9.18864235e-02f, 3.54461819e-02f, 4.47277725e-02f, 9.41439345e-02f, 7.90940076e-02f, -9.81687233e-02f, -4.49505597e-02f, -7.06413537e-02f, -1.25175208e-01f, 2.77364850e-02f,
  -1.08205654e-01f, 5.44572715e-03f, 7.86932185e-03f, -4.44233231e-03f, 1.22040279e-01f, 3.18656638e-02f, 1.50896739e-02f, -1.18270025e-01f, 6.13864101e-02f, 1.17921740e-01f,
  -4.36382415e-03f, -9.28206816e-02f, 7.89872035e-02f, -7.95181692e-02f, -9.32094753e-02f, 6.16899133e-02f, 5.00481240e-02f, 9.02362447e-03f, 6.39407784e-02f, -8.34286883e-02f,
  -8.96934047e-02f, -7.58801773e-02f, 1.67293083e-02f, -9.11416039e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 26)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 26;
const float L3_fan_Bp_bar_data[] = {
  1.16691388e-01f, 2.85927448e-02f, -1.00548223e-01f, 2.07808957e-01f, -8.48662853e-02f, 1.31084695e-01f, -4.18409891e-02f, -2.04867441e-02f, 1.47455826e-01f, 1.98100917e-02f,
  1.24211632e-01f, 1.06620312e-01f, -5.85352667e-02f, -2.19889004e-02f, -8.89894292e-02f, -6.97000045e-03f, -6.61115125e-02f, 3.29902992e-02f, 8.56788829e-02f, 5.11785224e-02f,
  -2.55859699e-02f, -6.58536404e-02f, 7.46782199e-02f, 1.54966772e-01f, 3.29790823e-02f, -3.37713324e-02f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  1.59773350e-01f, -3.17336679e-01f, 2.07953393e-01f, 3.69816422e-01f, 1.81067839e-01f, 1.26916245e-01f, -2.17132136e-01f, -1.27356857e-01f, 2.46011615e-02f, -3.43235344e-01f,
  -3.78146946e-01f, -1.64677918e-01f, 7.13498443e-02f, 7.85287172e-02f, 1.11974694e-01f, -8.69571194e-02f, 8.61178190e-02f, -3.57299238e-01f, 1.36051878e-01f, 6.19273148e-02f,
  -4.46545392e-01f, -1.53264925e-01f, 2.44767740e-02f, -1.53763101e-01f, 3.15915704e-01f, 3.37178379e-01f, 2.13830307e-01f, 9.15331021e-02f, 3.31032127e-01f, -3.34051758e-01f,
  4.85015422e-01f, 2.45937243e-01f, -2.31805295e-01f, 1.89173579e-01f, 4.17843908e-01f, -2.91586429e-01f, -3.45414072e-01f, -1.40820518e-01f, -3.14112455e-01f, 9.41643044e-02f,
  1.84357584e-01f, 4.84132349e-01f, 1.47736110e-02f, 7.18982294e-02f, -2.86674678e-01f, -1.47417178e-02f, -6.71362430e-02f, 2.55516350e-01f, -6.39544800e-02f, 1.69430986e-01f,
  -1.74606755e-01f, -8.94695297e-02f, -2.75175609e-02f, -2.09392924e-02f, -6.62190020e-02f, 3.97642478e-02f, -2.10402951e-01f, -1.42746374e-01f, 4.35425565e-02f, -4.69353423e-02f,
  -1.63328767e-01f, 2.45731339e-01f, -8.38172063e-02f, 2.07764819e-01f, 2.17288479e-01f, 2.28332490e-01f, 2.42982894e-01f, -9.34967026e-02f, -3.13485810e-03f, -1.75049588e-01f,
  -3.49854410e-01f, 2.56220371e-01f, 2.03964129e-01f, 4.18792069e-01f, 2.55773932e-01f, 3.44966143e-01f, 1.88237473e-01f, -1.85621962e-01f, -2.71049827e-01f, -1.95587277e-01f,
  -1.57624483e-01f, 3.74608219e-01f, 2.80484706e-01f, -5.77379763e-02f, -1.76735684e-01f, 5.58134057e-02f, -5.54956198e-01f, 1.10103026e-01f, -6.11513592e-02f, -4.07013267e-01f,
  3.48400384e-01f, -4.07915831e-01f, -7.55543560e-02f, 4.19798374e-01f, 2.43601173e-01f, -3.62731189e-01f, 3.64708036e-01f, 3.72121483e-01f, -3.42556909e-02f, 1.29918203e-01f,
  1.67486481e-02f, -1.62951589e-01f, 7.26360232e-02f, -1.29229009e-01f, -1.26364127e-01f, 2.12453693e-01f, -2.50896048e-02f, 1.68399606e-02f, -1.92418382e-01f, 1.04718268e-01f,
  -1.24779135e-01f, 1.14045061e-01f, -1.93957716e-01f, -9.16576460e-02f, 1.60792410e-01f, -3.52553092e-03f, 7.69253075e-02f, -3.45953643e-01f, -1.58359539e-02f, 9.79561880e-02f,
  6.07572794e-01f, -5.87570742e-02f, -5.49362674e-02f, -1.63137764e-01f, -3.16315860e-01f, 4.01909053e-02f, 1.67312607e-01f, 6.15486503e-02f, 9.38821137e-02f, -1.10788882e-01f,
  5.80213487e-01f, -7.17321485e-02f, 4.61723596e-01f, -5.00413291e-02f, 3.85871619e-01f, 2.58934736e-01f, 1.73017859e-01f, 3.06037188e-01f, 2.85622418e-01f, -1.98352367e-01f,
  3.80548425e-02f, 3.06642026e-01f, 1.56220540e-01f, -2.75998354e-01f, 3.78809452e-01f, 5.11176229e-01f, -2.76098609e-01f, -1.44129485e-01f, 1.70464486e-01f, -2.86505800e-02f,
  4.60379630e-01f, 7.72451758e-02f, -2.85968065e-01f, -1.49852186e-01f, -2.10308567e-01f, 3.48975033e-01f, -1.42447695e-01f, 4.13739353e-01f, -3.23632419e-01f, 1.90934211e-01f,
  -6.04703985e-02f, -2.57253170e-01f, 1.70091435e-01f, 1.47014812e-01f, 2.91002333e-01f, 1.23048678e-01f, -3.22100967e-01f, -1.48692116e-01f, -1.82730287e-01f, -1.87074810e-01f,
  -9.12208855e-02f, 2.34595805e-01f, 3.20962042e-01f, 6.61786869e-02f, 5.59047051e-02f, -1.64644808e-01f, 2.27343395e-01f, -2.20776610e-02f, 7.50283971e-02f, -4.45060153e-03f,
  -8.89492184e-02f, 2.30438024e-01f, 9.59149674e-02f, -2.56444123e-02f, 1.77689359e-01f, -1.27686992e-01f, 2.59615451e-01f, 2.55534034e-02f, 2.16870978e-01f, -8.59391689e-02f,
  1.46559440e-02f, 5.08389845e-02f, 1.82078835e-02f, 2.54029632e-01f, 1.50522226e-02f, -2.22452030e-01f, 3.50978434e-01f, 2.42220894e-01f, 2.13093802e-01f, -1.80851985e-02f,
  -4.39254701e-01f, -2.62618572e-01f, 1.41398087e-02f, 2.92931795e-01f, -2.77347714e-01f, 2.00030982e-01f, 8.06810409e-02f, -3.56135666e-01f, -6.56797960e-02f, -8.22487175e-02f,
  1.73564628e-01f, -2.21230060e-01f, -4.30758251e-03f, -1.26245961e-01f, 3.52923363e-01f, -2.82259017e-01f, -1.45758182e-01f, 4.13286537e-01f, 2.12754950e-01f, -4.40444238e-02f,
  3.19420308e-01f, -3.81729990e-01f, -6.55702204e-02f, 1.69705437e-03f, -2.23962098e-01f, -1.64884403e-01f, -2.46688589e-01f, -3.49747688e-01f, -7.73290321e-02f, 1.99179381e-01f,
  -2.64468342e-01f, -6.15364946e-02f, -2.67077714e-01f, 4.10734229e-02f, -9.28918347e-02f, 9.48721543e-02f, -4.06380780e-02f, 1.38753951e-01f, -7.36145303e-02f, -2.72086233e-01f,
  -1.60296768e-01f, 1.53976664e-01f, -1.55366182e-01f, 4.00271043e-02f, 4.65668067e-02f, 4.75428522e-01f, 1.81846246e-01f, -7.08597451e-02f, -2.99457580e-01f, -1.69106856e-01f,
  3.24965656e-01f, 1.61502615e-01f, 8.84815007e-02f, 3.93312275e-01f, -1.01348840e-01f, -1.32276388e-02f, -1.06911816e-01f, 1.19488835e-01f, 1.33540090e-02f, -4.02531177e-01f,
  -5.34466624e-01f, 7.50954226e-02f, -3.73307645e-01f, 1.95098296e-01f, 9.65271071e-02f, -5.35096833e-03f, -2.84841210e-02f, 2.77699262e-01f, -6.50100037e-02f, -2.41242498e-01f,
  -7.40524903e-02f, -3.11858594e-01f, -2.55322200e-03f, -2.71494500e-04f, -1.40460595e-01f, -3.13553885e-02f, -2.31782272e-01f, -8.89608711e-02f, 1.44378946e-03f, -1.15656815e-01f,
  2.00698912e-01f, 2.38493457e-01f, 2.59913683e-01f, 1.93357795e-01f, 2.87316561e-01f, -4.63680267e-01f, 1.12901911e-01f, -1.57730922e-01f, -1.34050056e-01f, -3.15606654e-01f,
  2.43295610e-01f, -1.75261095e-01f, -3.00322264e-01f, 1.17720410e-01f, -2.61004597e-01f, 2.81000972e-01f, 2.26774231e-01f, -2.67127287e-02f, 8.04760605e-02f, 4.97961119e-02f,
  3.73808444e-01f, -4.68539931e-02f, -2.25862026e-01f, 2.48910993e-01f, 9.71592143e-02f, 1.22141372e-02f, -1.68765206e-02f, -7.12893829e-02f, -9.56484005e-02f, 2.97013938e-01f,
  -1.99011177e-01f, 7.14712888e-02f, -1.19415671e-01f, -1.01208478e-01f, 1.56734645e-01f, 4.60365489e-02f, 1.08572803e-01f, -1.17556304e-01f, 7.55587220e-02f, 4.51228842e-02f,
  3.23440358e-02f, 3.98861356e-02f, -2.91020066e-01f, 5.17626405e-01f, -5.98903298e-02f, -2.19494864e-01f, -1.08817600e-01f, 1.28668025e-01f, 1.51368693e-01f, -1.63800985e-01f,
  -6.37511760e-02f, 3.60597253e-01f, 3.39688569e-01f, -2.33177794e-03f, 4.37155724e-01f, -1.99978188e-01f, -1.07423171e-01f, 2.73845404e-01f, 6.12860732e-02f, 1.11027874e-01f,
  7.18077868e-02f, 4.64611471e-01f, 1.34140104e-01f, -1.64424151e-01f, -6.79980144e-02f, -1.90612391e-01f, -1.86310709e-02f, -1.96049035e-01f, -2.60594696e-01f, 4.79321666e-02f,
  -2.58018851e-01f, -8.37679021e-03f, 3.22650790e-01f, -5.65665998e-02f, 9.69297290e-02f, 7.25728795e-02f, 1.28799349e-01f, 2.71732479e-01f, -3.88283640e-01f, -7.88128823e-02f,
  2.13802576e-01f, -2.26032492e-02f, -3.25051025e-02f, -1.42913714e-01f, 1.33666486e-01f, -3.52925062e-02f, 1.32095665e-01f, 1.45712972e-01f, 2.27443755e-01f, -1.40343443e-01f,
  1.02030188e-01f, 2.15301216e-01f, -6.02886342e-02f, -1.38234452e-03f, -1.48111954e-01f, 8.78861845e-02f, 2.93433428e-01f, 6.89927787e-02f, 2.12027848e-01f, -5.48231862e-02f,
  2.49288172e-01f, -7.34738633e-02f, -8.06104839e-02f, 4.23717238e-02f, 1.05248960e-02f, -3.85564506e-01f, 6.68284893e-02f, 4.31757540e-01f, 4.75332327e-02f, -1.17475286e-01f,
  2.63735205e-01f, -4.11339849e-01f, 1.04947709e-01f, -1.85733184e-01f, -3.35510790e-01f, -8.12399760e-02f, -2.17084400e-02f, 2.24110112e-01f, 1.84204787e-01f, 5.17292678e-01f,
  3.38385314e-01f, -2.14919403e-01f, -1.69323683e-01f, 2.38670707e-02f, 3.00253946e-02f, -3.56106311e-01f, 3.38738471e-01f, 4.59325552e-01f, -2.68582374e-01f, -6.72901794e-02f,
  1.56103417e-01f, -1.84775963e-01f, -3.08693260e-01f, -1.02091990e-01f, 2.75832713e-01f, 1.73151031e-01f, -5.72430454e-02f, -3.63017976e-01f, -2.00141355e-01f, 1.12613246e-01f,
  1.14754848e-01f, 1.28295034e-01f, 2.55291492e-01f, -1.26016634e-02f, 1.88275039e-01f, -1.62852526e-01f, 1.13932662e-01f, -5.17954752e-02f, 6.21714815e-02f, 6.87090158e-02f,
  1.39064223e-01f, 3.60005647e-02f, -3.78312767e-02f, 1.40430881e-02f, -1.41854435e-02f, 2.87027597e-01f, -2.36507542e-02f, -1.21207416e-01f, -6.82217767e-03f, 1.10763930e-01f,
  -5.25536351e-02f, 4.09127533e-01f, -2.99072921e-01f, -2.03458339e-01f, 9.62455943e-02f, -9.75295529e-02f, 8.65086317e-02f, 3.95192355e-02f, -2.38617435e-01f, 2.44538605e-01f,
  -4.23194498e-01f, 2.93896403e-02f, -4.07421499e-01f, 1.38801321e-01f, 2.55499214e-01f, -2.18952820e-01f, -8.03103149e-02f, 9.84406397e-02f, 2.72858143e-01f, -1.55806050e-01f,
  2.20713355e-02f, 1.70401528e-01f, 3.59231383e-02f, -5.77050820e-02f, 1.49920478e-01f, -1.58241510e-01f, 3.00821606e-02f, 1.48114368e-01f, -2.13028073e-01f, -2.12211803e-01f,
  -3.39717835e-01f, 1.60039172e-01f, 4.29260910e-01f, 3.28387350e-01f, -2.29563594e-01f, -2.91771501e-01f, 2.11388469e-02f, 2.96939194e-01f, -1.99353397e-01f, 2.11191952e-01f,
  -1.36205822e-01f, 1.50250092e-01f, -4.94020969e-01f, -2.77288705e-01f, 2.98616379e-01f, -4.23880637e-01f, 6.47916734e-01f, 5.06705344e-02f, -3.92997265e-02f, -1.51114032e-01f,
  -1.18348673e-01f, -2.15232819e-01f, -9.47795287e-02f, 7.46378079e-02f, 5.81924841e-02f, 2.56580919e-01f, -2.03841910e-01f, 6.07327446e-02f, 6.32316768e-02f, -1.11155495e-01f,
  7.30954707e-02f, 5.44820167e-02f, 5.56628294e-02f, -1.15893530e-02f, -5.69849193e-01f, -4.55659628e-02f, -3.30662996e-01f, -1.56725526e-01f, 7.12770387e-04f, 9.87330526e-02f,
  1.05888441e-01f, -1.53854834e-02f, -7.18636140e-02f, -2.41024017e-01f, -3.30932200e-01f, -2.16324374e-01f, -3.42652172e-01f, -1.65577769e-01f, -3.28040510e-01f, 1.38279662e-01f,
  -2.74696916e-01f, -4.05733287e-01f, -2.52665728e-01f, 1.81204408e-01f, -2.61718005e-01f, -5.03316939e-01f, -7.19647557e-02f, 5.27424276e-01f, -3.84122550e-01f, -5.69847738e-03f,
  4.22166623e-02f, -5.58542237e-02f, 1.57632511e-02f, 3.65117431e-01f, -2.93756872e-01f, 2.19414204e-01f, -3.42206657e-02f, 7.26524070e-02f, -1.58394165e-02f, 3.28544043e-02f,
  -3.10750633e-01f, -4.50568534e-02f, -2.79875338e-01f, -2.54280210e-01f, -3.92653793e-02f, 6.68345094e-02f, 2.27430359e-01f, 4.59331162e-02f, 2.67030001e-01f, -1.81845546e-01f,
  -1.09963521e-01f, -9.31510031e-02f, -5.76967150e-02f, -1.23692304e-01f, 4.63484675e-02f, 7.91995823e-02f, -1.49994358e-01f, 1.11405425e-01f, 1.24388844e-01f, -8.97934213e-02f,
  -8.65309462e-02f, -3.43963727e-02f, 1.41063765e-01f, 2.04917848e-01f, -4.13625799e-02f, -2.51362294e-01f, -1.30882666e-01f, 2.21490890e-01f, 4.72547263e-01f, -8.19339901e-02f,
  -4.22148407e-01f, -1.93263024e-01f, -1.72924146e-01f, -1.56116774e-02f, 1.78865455e-02f, 8.72741803e-05f, 5.02083562e-02f, -2.02635229e-01f, -3.07003736e-01f, -2.81804681e-01f,
  3.45001340e-01f, 1.06856368e-01f, -9.44381729e-02f, -4.13274989e-02f, 1.59645289e-01f, 2.03455895e-01f, 2.15429902e-01f, -2.62351662e-01f, -1.79641053e-01f, 3.97271439e-02f,
  -4.03453231e-01f, 2.87237078e-01f, -3.48015726e-02f, 2.44219750e-01f, -2.74148267e-02f, 1.27357930e-01f, 1.65553525e-01f, -3.23978662e-01f, 3.49819958e-01f, 7.65136406e-02f,
  8.90280306e-03f, 4.77738172e-01f, -3.45057547e-01f, 1.08588152e-01f, -6.90635294e-02f, 3.57804626e-01f, -9.78218019e-02f, -2.39824057e-02f, -2.15833127e-01f, -1.55244127e-01f,
  2.99492538e-01f, -3.40381533e-01f, 3.33428860e-01f, 1.25678003e-01f, 3.21331531e-01f, 2.24165082e-01f, 6.07694611e-02f, -1.05332002e-01f, 1.27560245e-02f, 4.67143990e-02f,
  2.72162437e-01f, -1.45269603e-01f, -1.67430655e-04f, -5.93978018e-02f, -5.59700318e-02f, -8.09529126e-02f, -1.37391640e-02f, -6.74628690e-02f, -1.07178949e-02f, 1.93276539e-01f,
  2.27230079e-02f, -3.70536149e-02f, -3.62957329e-01f, 3.84241283e-01f, -2.86982477e-01f, -2.60594487e-02f, 1.89115971e-01f, 1.03994822e-02f, 5.40547855e-02f, 2.81948596e-03f,
  -1.54364362e-01f, 1.84327081e-01f, -3.50427508e-01f, 2.33071640e-01f, 3.19855213e-01f, 1.19677395e-01f, 3.04326087e-01f, -9.54496711e-02f, 1.00010954e-01f, 9.93859619e-02f,
  1.92687169e-01f, 1.25428542e-01f, 2.22278595e-01f, 3.01275760e-01f, -8.82538557e-02f, -3.24929804e-01f, -1.21092573e-01f, -1.46446116e-02f, -2.07421351e-02f, -9.11961645e-02f,
  -2.40354985e-01f, 5.40143311e-01f, 1.41910259e-02f, -6.32992238e-02f, -1.91151842e-01f, -4.83232170e-01f, 2.01518998e-01f, 3.67524296e-01f, 2.88059562e-01f, -5.01437604e-01f,
  3.43561709e-01f, 2.30251532e-02f, -8.47640559e-02f, 2.46468499e-01f, 4.36924063e-02f, 3.98452669e-01f, -3.74079734e-01f, 6.88434988e-02f, -1.59579173e-01f, 1.96620226e-02f,
  -1.13179468e-01f, 4.75152314e-01f, -7.30378926e-02f, 8.80623981e-02f, -2.63806552e-01f, 1.41370729e-01f, -1.43921375e-01f, 3.67573127e-02f, -6.00173771e-02f, -3.15680355e-02f,
  -4.29130625e-03f, -2.66030550e-01f, 9.00891572e-02f, -7.35987350e-02f, 1.65530860e-01f, -2.12197065e-01f, 2.38887578e-01f, -8.32445398e-02f, 4.06971991e-01f, -2.02568397e-02f,
  -2.49523759e-01f, 1.22325040e-01f, -7.61648715e-02f, -1.33535177e-01f, 4.87944633e-02f, 5.09729311e-02f, 4.50277299e-01f, -8.51852819e-02f, -2.77667195e-01f, 1.42063797e-01f,
  -2.69466877e-01f, -3.83274198e-01f, -2.07398340e-01f, -2.90019870e-01f, -3.37449878e-01f, -3.43640774e-01f, 2.08921507e-01f, -8.30973014e-02f, -2.47713365e-02f, 7.97871798e-02f,
  -1.43561512e-01f, -2.15937331e-01f, -7.66745862e-03f, 1.85031652e-01f, 2.15971306e-01f, 1.63972750e-01f, -3.00648808e-01f, -1.56771630e-01f, -2.76278444e-02f, -4.30028588e-01f,
  -2.15216622e-01f, -1.00315072e-01f, -2.91750312e-01f, -8.48103315e-03f, 3.25659178e-02f, -1.94366619e-01f, 3.39606136e-01f, 1.63762793e-01f, -3.60550970e-01f, 4.76292163e-01f,
  -3.52937984e-03f, -1.01344451e-01f, 5.58279276e-01f, -1.99883774e-01f, -7.43274242e-02f, -6.71553761e-02f, -1.02465814e-02f, -8.31952766e-02f, -2.39772111e-01f, 9.55628231e-02f,
  2.60074466e-01f, -7.21239522e-02f, 1.45764723e-01f, 5.75129762e-02f, 1.28196001e-01f, 2.26182774e-01f, -3.75219695e-02f, -1.98766276e-01f, -6.37038946e-02f, 2.37135366e-01f,
  -2.01034009e-01f, 1.16761671e-02f, -1.36046529e-01f, -4.57409248e-02f, -1.03145324e-01f, -1.68923840e-01f, -5.23310266e-02f, -6.46071658e-02f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  2.41145547e-02f, 1.13469306e-02f, 7.27771893e-02f, 1.08432546e-01f, -1.35096349e-02f, -1.02340225e-02f, -8.06082636e-02f, 5.61434701e-02f, -1.15761459e-01f, 4.91808765e-02f,
  5.52481115e-02f, 8.38673860e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    