/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.81625295e-02f, -3.84528607e-01f, 5.52012473e-02f, 1.53429866e-01f, 1.78670019e-01f, 2.11292595e-01f, 1.51671141e-01f, 1.42273426e-01f, 1.31668627e-01f, -1.53259605e-01f,
  1.37213320e-01f, -2.63060600e-01f, -1.62466168e-01f, 1.41156688e-01f, -8.27095995e-04f, -5.79763809e-03f, 4.45004217e-02f, 8.56480300e-02f, 1.09763509e-02f, 3.35973799e-02f,
  7.34639987e-02f, -8.26388597e-02f, -5.24518341e-02f, -2.04020724e-01f, 3.21547836e-02f, -8.05435777e-02f, -7.81090409e-02f, -1.55392602e-01f, -1.30809527e-02f, -1.32013522e-02f,
  -3.09367590e-02f, -9.78442878e-02f, -7.01474622e-02f, 9.16681159e-03f, -4.85704616e-02f, -6.64454550e-02f, -2.68046148e-02f, 3.39013524e-02f, -8.38919729e-02f, 5.74910901e-02f,
  -8.84684175e-02f, -5.12923822e-02f, 7.28261471e-02f, 1.55450935e-02f, -2.01467201e-02f, -8.69303849e-03f, 5.83738200e-02f, 4.15384211e-02f, -4.42043096e-02f, -1.23327086e-02f,
  -6.44913614e-02f, 8.02463368e-02f, -5.88310510e-03f, -2.63913646e-02f, 6.99063484e-03f, 3.74579243e-02f, -3.73104848e-02f, 4.03971486e-02f, 2.81666126e-03f, -6.77433284e-03f,
  3.05523127e-02f, 3.43110673e-02f, -1.09089985e-01f, -3.13518904e-02f, 3.81331258e-02f, 6.16184697e-02f, 1.45171713e-02f, -7.42823863e-03f, -1.18477168e-02f, 2.59882696e-02f,
  -2.12693047e-02f, 2.92256586e-02f, 8.21813941e-02f, 1.77103672e-02f, -7.15972260e-02f, -3.48269306e-02f, -1.29772410e-01f, 1.03595190e-01f, 2.11583152e-02f, 4.91186008e-02f,
  -1.16236294e-02f, -1.91047955e-02f, 4.34486344e-02f, -1.13879994e-01f, -1.11630835e-01f, -3.34377922e-02f, 2.40280870e-02f, 1.73132822e-01f, 5.18127643e-02f, 9.64543074e-02f,
  -2.47787431e-01f, -3.12564492e-01f, -6.41094521e-02f, -2.73899939e-02f, -6.28091916e-02f, -7.84568675e-03f, -6.19501173e-02f, 1.27498612e-01f, -1.46742702e-01f, 3.32642086e-02f,
  -1.20197490e-01f, -2.76334416e-02f, -3.09368316e-02f, -1.36945574e-02f, 7.17179850e-02f, -1.33958846e-01f, -1.05919600e-01f, 4.64339890e-02f, -1.18677258e-01f, 4.66953404e-03f,
  -1.14466831e-01f, 1.63093247e-02f, 3.05964723e-02f, -2.65065581e-02f, -5.97407632e-02f, 6.37645945e-02f, -1.04005009e-01f, 1.29274026e-01f, 5.76455668e-02f, -3.18235718e-02f,
  6.87374547e-02f, 3.66780400e-01f, 2.38716826e-01f, 3.97252664e-02f, 2.33548015e-01f, 2.72569805e-02f, -2.09124703e-02f, 3.02597851e-01f, 3.19832981e-01f, -2.06211105e-01f,
  -2.09359929e-01f, -7.51595125e-02f, -6.68394752e-03f, -8.79985839e-02f, -1.32593781e-01f, 1.09375834e-01f, -5.41165471e-02f, -4.71340232e-02f, 2.49882191e-01f, 2.17229725e-04f,
  1.24093905e-01f, -1.55773953e-01f, -5.93756177e-02f, 7.55041689e-02f, -1.66202337e-02f, 4.47183028e-02f, -3.32607448e-01f, 8.10733065e-02f, -1.62427291e-01f, 2.29584575e-02f,
  1.33005029e-03f, 1.59779787e-01f, 1.87749676e-02f, 7.50828609e-02f, 1.04113437e-01f, -7.26624578e-02f, -5.56893088e-02f, -1.01740144e-01f, 1.13761565e-02f, -4.25137803e-02f,
  -8.79999399e-02f, -6.54854774e-02f, 1.06590409e-02f, 3.30164433e-02f, 1.21864952e-01f, 3.07567175e-02f, 3.11361756e-02f, 8.37120712e-02f, 1.11235930e-02f, 9.35976207e-02f,
  6.07248535e-03f, 6.36206567e-02f, 9.43998918e-02f, -5.93832752e-04f, -5.01441769e-02f, 6.49136454e-02f, 4.03450988e-02f, -3.75595428e-02f, 2.51490828e-02f, 2.98023652e-02f,
  -2.67361216e-02f, 5.24798222e-02f, 2.88617657e-03f, 5.76602202e-03f, 4.71898653e-02f, -6.24248711e-03f, -1.65760592e-02f, -1.33985840e-02f, 2.92824656e-02f, -8.23475346e-02f,
  -7.82871991e-02f, 3.05965380e-03f, 6.62413538e-02f, -5.17425574e-02f, -5.11324778e-02f, -3.80212441e-02f, -3.20785195e-02f, 1.01653645e-02f, -9.49667767e-04f, -1.03613161e-01f,
  -3.31091508e-02f, -5.82711287e-02f, -4.64669839e-02f, -3.49233449e-02f, 5.85533269e-02f, -1.00414239e-01f, 2.45372020e-02f, 1.55952414e-02f, 1.42446235e-02f, -6.68311939e-02f,
  6.45404235e-02f, 2.49314517e-01f, 7.67635256e-02f, -4.03406695e-02f, -4.72955257e-02f, -3.22178118e-02f, 2.31631827e-02f, 4.65055415e-03f, 2.31172666e-02f, 2.71435026e-02f,
  -2.97758747e-02f, 3.84223764e-03f, -2.04985123e-02f, -3.31992693e-02f, -7.49509111e-02f, -1.01130493e-01f, 1.47837419e-02f, 3.18816751e-02f, -4.10250574e-02f, 1.23989035e-03f,
  -2.92627681e-02f, -4.86424975e-02f, -4.15186621e-02f, -3.84629816e-02f, -5.45018241e-02f, -1.23418480e-01f, 5.29834852e-02f, 4.43394389e-03f, -1.92324575e-02f, 1.86341051e-02f,
  -2.94805825e-01f, -2.47856572e-01f, 4.17977273e-02f, -2.91275561e-01f, 1.06077373e-01f, 2.33741790e-01f, -6.23463988e-02f, -1.05083048e-01f, -3.27501863e-01f, -2.83200532e-01f,
  -3.29200812e-02f, -1.28414854e-01f, -6.15058132e-02f, -1.08491279e-01f, 1.57787472e-01f, 3.57819311e-02f, -5.11259437e-02f, -1.16516151e-01f, -4.18790244e-02f, -7.22177178e-02f,
  8.65069125e-03f, 3.89148816e-02f, 1.92141294e-01f, 2.08266433e-02f, 1.79550126e-02f, -1.27865210e-01f, -1.63112693e-02f, 6.92384988e-02f, 7.23767951e-02f, 1.11835487e-01f,
  -5.18561192e-02f, -2.06125483e-01f, -1.03207361e-02f, 5.46692573e-02f, 4.92904037e-02f, 1.09479964e-01f, 1.05413973e-01f, 3.53765450e-02f, -1.15978671e-03f, -5.43107614e-02f,
  1.20592928e-02f, 5.15107028e-02f, 1.08000226e-02f, 1.49114383e-03f, 1.49027696e-02f, -1.69187635e-02f, 2.23846585e-02f, -1.97984427e-02f, 3.81099656e-02f, -1.67846698e-02f,
  -9.21396762e-02f, 5.09412885e-02f, 1.05776107e-02f, -1.46218147e-02f, 3.68334316e-02f, -6.58585057e-02f, -5.22766914e-03f, 4.66100425e-02f, -2.35899109e-02f, -9.76276398e-02f,
  -2.93685608e-02f, -3.53367217e-02f, 2.79270392e-02f, 2.57497709e-02f, 1.54760259e-03f, 5.21977525e-03f, 4.82641421e-02f, 1.21962085e-01f, 3.51063907e-02f, 1.76085904e-02f,
  -4.24101613e-02f, -5.15354127e-02f, -5.02412245e-02f, -7.09902681e-03f, 2.72541866e-02f, -2.55404115e-02f, 2.45190728e-02f, -3.24051678e-02f, -3.10201407e-03f, -3.46092251e-03f,
  1.49725536e-02f, -1.94348600e-02f, 5.09934127e-03f, 8.38977396e-02f, -4.70831022e-02f, 1.08118020e-02f, -2.88801193e-02f, -2.86998856e-03f, -6.99834079e-02f, 1.31381035e-01f,
  -7.27149323e-02f, -2.00529397e-01f, -8.47790763e-02f, 2.93543339e-02f, -3.53502519e-02f, 6.46879449e-02f, 1.30488202e-02f, 7.02099036e-03f, -3.24176475e-02f, -3.90205085e-02f,
  6.25159144e-02f, 9.51409489e-02f, -1.02388501e-01f, 6.84547126e-02f, 3.44935060e-02f, -8.88996795e-02f, 2.72813141e-02f, 1.08592339e-01f, 4.78654765e-02f, 3.74260768e-02f,
  -4.59282100e-03f, -3.61089185e-02f, 3.97808626e-02f, -4.04410511e-02f, 1.51633635e-01f, 1.36488816e-02f, -5.75179607e-02f, -7.57368132e-02f, 5.61957508e-02f, -4.50213440e-02f,
  3.36991608e-01f, 3.52595858e-02f, -9.40868333e-02f, 2.23292232e-01f, 1.61222816e-01f, 1.02440760e-01f, 2.42345221e-02f, 7.77968168e-02f, 9.72825363e-02f, -2.88317204e-02f,
  1.06001645e-01f, -8.53824466e-02f, -1.06336802e-01f, 5.28304093e-03f, 1.55414745e-01f, 5.04214205e-02f, 1.59351036e-01f, -1.91409979e-02f, 4.15777974e-02f, 9.12091881e-02f,
  5.46022505e-02f, 1.06572650e-01f, -6.67419285e-02f, 1.34303831e-02f, 5.20213507e-03f, 4.30700667e-02f, -3.24063152e-02f, -3.17597575e-02f, 3.83374877e-02f, 1.34363528e-02f,
  7.35879838e-02f, -8.42327178e-02f, -1.18654862e-01f, -8.69052559e-02f, 5.80003336e-02f, -1.31410167e-01f, -1.14935739e-02f, -4.21933606e-02f, 8.35774094e-02f, 1.07742600e-01f,
  -6.97491914e-02f, -6.29734695e-02f, 7.84643344e-04f, -6.20702207e-02f, -4.86727953e-02f, -6.02772422e-02f, -8.63886848e-02f, -1.03558093e-01f, -5.87138757e-02f, -1.52949497e-01f,
  -9.11879018e-02f, -2.58668009e-02f, -6.68229386e-02f, -4.25324701e-02f, -1.17027849e-01f, -1.78694800e-02f, -1.01179937e-02f, -8.03800449e-02f, 3.47799100e-02f, 5.43751605e-02f,
  -6.71189353e-02f, 1.44188721e-02f, -1.14562832e-01f, -3.02391183e-02f, 6.41670376e-02f, -3.94500904e-02f, -1.36750024e-02f, -2.76960578e-04f, -1.00342762e-02f, -3.75263728e-02f,
  1.09173417e-01f, -3.72180864e-02f, 3.47711891e-02f, -9.26746577e-02f, -1.34198293e-01f, 8.43782425e-02f, -3.31065468e-02f, -2.25490369e-02f, 3.98762375e-02f, -3.12631093e-02f,
  -9.20423567e-02f, 3.36377248e-02f, 4.67031784e-02f, -2.15109321e-04f, 9.76336002e-02f, -1.09457240e-01f, -1.11849345e-01f, 6.36380687e-02f, 8.10934007e-02f, 4.21976224e-02f,
  1.17469870e-01f, 1.33173823e-01f, 6.69863215e-03f, 5.55104911e-02f, 1.21935941e-01f, 1.85066126e-02f, 6.44887686e-02f, -1.81649700e-02f, 4.96514142e-02f, 1.01086013e-01f,
  -1.16130330e-01f, -7.29055852e-02f, 4.74884249e-02f, 5.11312895e-02f, 3.01502794e-02f, 1.28018484e-01f, 2.74752490e-02f, 7.07188025e-02f, -4.95393574e-03f, 1.26868099e-01f,
  -8.79786238e-02f, -1.48588838e-02f, -1.32769659e-01f, -6.46162704e-02f, -4.02772725e-02f, 6.69307560e-02f, 1.79082006e-01f, 2.06669644e-02f, -4.27979305e-02f, -1.48668364e-01f,
  1.67432889e-01f, -1.80903822e-01f, -9.35287476e-02f, 1.87006161e-01f, -5.79649247e-02f, 2.26250857e-01f, 3.96030366e-01f, 8.05802550e-03f, 3.85068774e-01f, 2.26999670e-02f,
  -6.61291778e-02f, 1.68871626e-01f, 2.36988394e-03f, 1.22680739e-01f, 2.10628822e-01f, 3.15484777e-02f, 8.55231285e-02f, 1.44509196e-01f, 7.37994835e-02f, -2.18635172e-01f,
  -1.76638749e-03f, -1.31782264e-01f, -1.64237455e-01f, -2.02957824e-01f, -1.69385448e-02f, -1.66563720e-01f, -2.64971554e-01f, -1.45288585e-02f, -2.69420980e-03f, 4.24181968e-02f,
  1.12420067e-01f, 1.36459351e-01f, 7.28376582e-02f, 1.00029990e-01f, -6.48211688e-02f, 4.83819284e-02f, -5.53413816e-02f, -1.14782583e-02f, -2.34392025e-02f, -8.40867218e-03f,
  1.28580211e-02f, 6.25317078e-03f, 2.43824348e-02f, 8.86722282e-02f, -5.39313145e-02f, 3.31890434e-02f, 1.19507946e-02f, 1.73455905e-02f, -1.90848280e-02f, 4.55897208e-03f,
  3.02077103e-02f, -8.71797837e-03f, -1.05132669e-01f, 4.38627340e-02f, -4.88407426e-02f, -1.56288520e-02f, -4.74232249e-02f, 3.21481265e-02f, 1.02372207e-02f, 1.35908008e-01f,
  -2.78535094e-02f, 3.13244760e-02f, -5.45554943e-02f, 1.66186541e-02f, -1.52500458e-02f, -3.99834812e-02f, -1.52082872e-02f, -5.03521562e-02f, 6.89375550e-02f, 2.86124349e-02f,
  7.69006386e-02f, 1.29534807e-02f, -5.42019121e-02f, -1.08595882e-02f, 3.61999460e-02f, 4.52770218e-02f, -1.03382304e-01f, 2.87580583e-02f, 1.10303842e-01f, -1.62119861e-03f,
  3.58303189e-02f, -2.38979291e-02f, 1.22751862e-01f, -6.42245933e-02f, -8.03348608e-03f, 7.44315237e-02f, -5.72366640e-02f, 3.03430259e-02f, -6.49253130e-02f, -5.47317155e-02f,
  -8.81749019e-02f, -1.20570652e-01f, 5.06476499e-02f, 8.48644674e-02f, -1.72992609e-02f, 2.24183127e-03f, 5.91901504e-02f, 2.91018318e-02f, -6.65388182e-02f, 6.20545149e-02f,
  -9.63734165e-02f, -3.93615291e-02f, -1.54348165e-01f, -1.10814627e-02f, -1.63929667e-02f, -1.00752488e-02f, -6.43327385e-02f, 8.85305461e-03f, -4.74032424e-02f, 6.53288001e-03f,
  -9.51066092e-02f, -6.43226411e-03f, -1.15538882e-02f, 7.03989565e-02f, -1.21215023e-01f, 5.56149846e-03f, -7.60326013e-02f, -3.81016582e-02f, -9.82987359e-02f, -4.70127128e-02f,
  -3.61495405e-01f, 3.70495543e-02f, -1.35266548e-02f, -3.16237599e-01f, 6.42286241e-02f, -1.43357381e-01f, -2.46031016e-01f, 1.18642645e-02f, -1.75304532e-01f, 9.63623077e-02f,
  -7.08053261e-02f, 1.89527217e-02f, -1.49298996e-01f, -2.32951548e-02f, -3.13775271e-01f, -2.13336557e-01f, -2.45268390e-01f, -4.90732528e-02f, -1.29554704e-01f, -3.45128663e-02f,
  -7.81525895e-02f, -1.28247663e-01f, -1.10395215e-01f, 1.03148729e-01f, 7.59650543e-02f, 5.79124913e-02f, -1.82300992e-02f, 9.13916677e-02f, 1.15063518e-01f, 6.04842417e-02f,
  6.42017499e-02f, -1.06757596e-01f, -3.78962047e-02f, 5.19195274e-02f, -6.69748113e-02f, 5.95982447e-02f, 1.18732050e-01f, 4.10951786e-02f, 1.70860589e-02f, 1.07343902e-03f,
  1.58755407e-02f, 1.08191734e-02f, -5.49893156e-02f, -4.97126281e-02f, 4.52109016e-02f, 2.71305740e-02f, -2.58261170e-02f, 1.17095448e-01f, -2.36641597e-02f, -4.86411229e-02f,
  -4.43699136e-02f, 4.82001156e-02f, 4.04417589e-02f, 1.79951112e-05f, -3.25188972e-02f, 5.76054603e-02f, 3.26350913e-03f, 1.24445811e-01f, -8.84631798e-02f, 4.71697785e-02f,
  -6.03054762e-02f, -5.08180214e-03f, 6.31135851e-02f, 2.39101052e-02f, -6.13587946e-02f, 9.91638750e-03f, 3.47085521e-02f, 1.70709305e-02f, -1.34053007e-02f, -9.18689091e-03f,
  2.59009935e-03f, 1.69476848e-02f, 6.26373515e-02f, 1.01396171e-02f, -3.58764455e-03f, -8.95246863e-02f, -7.87543058e-02f, 4.10074294e-02f, -1.31318048e-01f, -2.47025695e-02f,
  1.16965905e-01f, 2.63880789e-02f, 6.13973290e-02f, 2.33692694e-02f, 9.80552509e-02f, -3.14503387e-02f, -2.67017819e-02f, 1.29881999e-04f, 1.14819236e-01f, 3.86530757e-02f,
  -6.01584688e-02f, -1.41879335e-01f, -1.22716622e-02f, 1.14367083e-01f, -9.48792323e-03f, -1.56455245e-02f, -1.09987799e-02f, 2.28888448e-02f, -2.70844325e-02f, -8.75971988e-02f,
  1.41277537e-02f, 7.07817590e-03f, -1.31229814e-02f, 3.42636812e-03f, 1.56442821e-02f, -4.89412341e-03f, 4.81186714e-03f, 1.09843407e-02f, -3.07874121e-02f, 1.69276148e-02f,
  4.97098975e-02f, 9.19057336e-03f, 1.50874397e-02f, -7.03487769e-02f, 1.42201722e-01f, -8.79293960e-03f, -3.07419542e-02f, -3.94761935e-02f, 8.01822171e-02f, 1.86108276e-02f,
  -5.04266500e-01f, 2.17950791e-02f, -6.48882091e-02f, -3.07811886e-01f, -1.10512733e-01f, -1.22890741e-01f, -2.87214249e-01f, 1.67203978e-01f, -1.19419955e-01f, 5.83483614e-02f,
  5.07239550e-02f, -1.67451739e-01f, 1.15273654e-01f, -1.18249379e-01f, -1.42890975e-01f, 1.59599528e-01f, -9.71689746e-02f, -4.60282825e-02f, -2.44802400e-03f, -2.26365849e-02f,
  3.16738933e-02f, -4.42900620e-02f, 4.86098640e-02f, 2.20590785e-01f, -2.50785381e-01f, 4.23708512e-03f, 7.15167746e-02f, -8.10854584e-02f, -7.60364458e-02f, -7.88319930e-02f,
  -1.19711839e-01f, -1.01005267e-02f, 5.82492873e-02f, 2.12167930e-02f, -1.00270836e-02f, -8.97065643e-03f, -2.60653086e-02f, -4.04635482e-02f, -6.62635406e-03f, 4.11322303e-02f,
  -5.76918162e-02f, -5.60474256e-03f, -3.31447460e-02f, 9.96007174e-02f, -8.40527788e-02f, -7.04264119e-02f, -2.64257062e-02f, -5.24659865e-02f, -1.19060867e-01f, -7.55656958e-02f,
  -8.16013962e-02f, -2.12524994e-03f, -7.58127794e-02f, 4.69908044e-02f, -9.44877863e-02f, 2.25513093e-02f, 2.95649469e-02f, -2.15570405e-02f, -7.21934736e-02f, -7.58190081e-02f,
  1.27410041e-02f, -2.76972596e-02f, 2.31745224e-02f, 7.03802556e-02f, 1.00285402e-02f, 1.10599644e-01f, 8.88872985e-03f, 6.65175319e-02f, -7.98756257e-02f, -5.82741722e-02f,
  -4.71940916e-03f, 6.76330626e-02f, -5.05006388e-02f, -2.09097434e-02f, -3.48476209e-02f, 6.50714487e-02f, -3.86522640e-03f, 4.99391519e-02f, -8.37662145e-02f, 3.28962412e-03f,
  -3.89810279e-02f, -1.99945830e-02f, 4.50416990e-02f, -1.23516209e-02f, 1.55315120e-02f, 5.03238058e-03f, -1.71674963e-03f, 2.33575311e-02f, 4.18268852e-02f, -4.93826345e-02f,
  1.15890838e-02f, -1.17461095e-02f, -5.20025603e-02f, 3.67798395e-02f, 7.58544430e-02f, -8.13065004e-03f, 5.73410541e-02f, -9.85086635e-02f, -4.91110198e-02f, -1.27702928e-03f,
  -3.94454934e-02f, 2.37551611e-02f, -5.48958443e-02f, -4.86328639e-02f, 1.82606175e-03f, 8.14243499e-03f, -1.72619186e-02f, 1.79072004e-02f, 2.24883873e-02f, 4.11166176e-02f,
  -1.22503927e-02f, -7.58310109e-02f, -3.04079168e-02f, -7.12011158e-02f, 5.13278581e-02f, -5.31236157e-02f, -2.86112516e-03f, -3.86669785e-02f, 3.79830860e-02f, -8.49800929e-02f,
  2.49810696e-01f, 1.00925699e-01f, 1.56452700e-01f, -1.40563488e-01f, -6.74283728e-02f, 2.35091865e-01f, 2.70553857e-01f, -1.42830178e-01f, 1.26468852e-01f, -2.51559079e-01f,
  -1.28281608e-01f, 1.12876229e-01f, 2.20840394e-01f, -1.08982235e-01f, 2.90124744e-01f, 1.12298071e-01f, 1.25397086e-01f, -4.56258096e-02f, 1.09097451e-01f, -4.17409167e-02f,
  -6.77377582e-02f, -2.27021620e-01f, 5.06731272e-02f, -1.83713630e-01f, -1.41884163e-01f, -7.79517516e-02f, -9.67900828e-02f, -2.19493844e-02f, -2.42709816e-01f, 1.79672018e-02f,
  1.79254860e-01f, 1.76258720e-02f, 7.90051091e-03f, 3.35836150e-02f, 1.04188941e-01f, -6.26854878e-03f, 3.67981605e-02f, 1.67946350e-02f, 1.82020754e-01f, -3.96554172e-02f,
  7.75545985e-02f, -7.97791928e-02f, -5.10770865e-02f, -1.06108196e-01f, -2.32242160e-02f, 7.36599416e-03f, -1.90440398e-02f, 4.64293361e-02f, -1.11102253e-01f, 1.32683739e-02f,
  4.83051240e-02f, 5.11081470e-03f, 4.39134240e-02f, -2.17609871e-02f, -3.86515707e-02f, -5.47675900e-02f, -8.80073681e-02f, -1.96523666e-02f, 5.16128242e-02f, 8.12157741e-05f,
  -1.57988623e-01f, 1.81751847e-01f, 8.61414298e-02f, 9.83775109e-02f, 1.06042340e-01f, -2.62150280e-02f, 5.02580255e-02f, 3.33041139e-03f, 1.05034187e-01f, -6.38934299e-02f,
  6.59642443e-02f, -3.60317938e-02f, -6.74583986e-02f, 5.46220411e-03f, -1.19661185e-04f, 1.62311550e-02f, 8.60034227e-02f, -7.14958310e-02f, -1.07045081e-02f, 7.84399919e-03f,
  -1.78589094e-02f, 1.11798150e-02f, -6.37136325e-02f, -1.98809449e-02f, 5.22643439e-02f, 2.15555243e-02f, -1.59080803e-01f, -3.20856050e-02f, 2.23791376e-02f, -2.80860588e-02f,
  6.60281107e-02f, -1.01744615e-01f, 6.04027733e-02f, -9.02515575e-02f, 1.32309590e-02f, 1.82462018e-02f, 9.00551081e-02f, -3.49475257e-02f, 1.61513180e-01f, 1.64231360e-02f,
  -8.47491247e-05f, -5.25967628e-02f, 5.40928263e-03f, -3.20163602e-03f, 2.37179343e-02f, -3.48323919e-02f, 4.11050655e-02f, 1.12982012e-01f, -3.53865735e-02f, -7.44705647e-02f,
  -4.36555780e-02f, 6.49804473e-02f, 6.79413378e-02f, -2.94249188e-02f, -1.19985111e-01f, -4.10355963e-02f, 2.96356995e-02f, -6.04422763e-02f, -9.13134888e-02f, 5.78940585e-02f,
  -1.89028382e-01f, 2.22124860e-01f, -3.65708284e-02f, -2.44983852e-01f, -1.60344057e-02f, -1.50400847e-01f, -3.07296634e-01f, -7.34804198e-02f, -5.78782558e-02f, 1.04784012e-01f,
  -1.66392282e-01f, 1.89683497e-01f, 2.99751349e-02f, -1.03975683e-01f, -1.92262560e-01f, -7.41616299e-04f, -6.82298541e-02f, 3.17120217e-02f, 1.01023622e-01f, 6.73165694e-02f,
  9.88726839e-02f, -1.24665238e-01f, -3.06981523e-02f, 1.75681353e-01f, -7.13928342e-02f, 2.17208117e-02f, -9.31884795e-02f, 1.08844049e-01f, 1.84517398e-01f, -4.45062742e-02f,
  -5.55475391e-02f, -1.27757818e-01f, 4.59134988e-02f, 6.04309281e-03f, -6.15225285e-02f, -4.41588275e-02f, 4.49655727e-02f, 2.40605827e-02f, -1.34043157e-01f, 8.11641663e-02f,
  2.98301429e-02f, 1.28272712e-01f, -1.89401731e-02f, 3.23619135e-02f, -7.80818909e-02f, 4.57716174e-02f, -1.81287508e-02f, 1.03394784e-01f, 1.58551056e-02f, 1.29344493e-01f,
  3.59289274e-02f, 6.94739074e-02f, -5.28597496e-02f, -2.92546228e-02f, -5.98964691e-02f, -4.41911593e-02f, 3.13286893e-02f, 6.78924993e-02f, 5.71180321e-02f, 2.52270121e-02f,
  -1.18563116e-01f, 2.01312415e-02f, 5.65554574e-02f, 2.16441583e-02f, 8.82400647e-02f, 9.03476030e-02f, 1.47190198e-01f, -1.95902418e-02f, 4.77872901e-02f, -2.78719701e-04f,
  -5.10182697e-03f, 2.42676176e-02f, -4.40904722e-02f, -9.71636362e-03f, -7.21983165e-02f, -4.84850109e-02f, -1.51641741e-02f, 1.77220907e-02f, -5.31008840e-02f, 1.84254348e-03f,
  -3.76866269e-03f, 2.71633025e-02f, 1.87750980e-02f, -1.58696994e-02f, -3.55567262e-02f, -1.88643504e-02f, 1.65865198e-01f, 1.03212453e-01f, -7.35341758e-02f, -1.28495306e-01f,
  -7.37501755e-02f, -1.51130900e-01f, -1.36198476e-02f, 1.13340586e-01f, 2.26125531e-02f, -1.19898589e-02f, -1.78722907e-02f, 7.70469829e-02f, -3.47039849e-02f, 1.89159457e-02f,
  3.68473679e-02f, 4.64831246e-03f, -5.56813553e-03f, 1.00920945e-01f, 2.81418283e-02f, 1.00903381e-02f, -1.16599254e-01f, -6.31531514e-03f, -8.44189227e-02f, 5.91494367e-02f,
  3.81254070e-02f, -7.45790452e-02f, -4.72550280e-02f, -9.33523029e-02f, -5.86465970e-02f, -5.13053723e-02f, -6.70520589e-02f, 4.63484786e-02f, -3.20484452e-02f, 7.67953023e-02f,
  -8.64940137e-03f, 5.76744080e-02f, 2.22409546e-01f, -2.79752277e-02f, -6.77142665e-02f, -1.58922493e-01f, 4.71039712e-02f, 1.55097559e-01f, 4.01918776e-02f, -5.23546822e-02f,
  1.13441065e-01f, 1.94609731e-01f, 6.15611523e-02f, -1.49453832e-02f, -1.81437686e-01f, -1.18891664e-01f, -2.00130716e-01f, 1.35025531e-01f, -3.99210025e-03f, -1.04995966e-01f,
  6.18010275e-02f, -1.68950751e-01f, 3.27383094e-02f, -4.04389091e-02f, 6.68532923e-02f, 1.07520230e-01f, -1.57150164e-01f, 2.64653079e-02f, -3.32210176e-02f, -3.60385552e-02f,
  -9.09044892e-02f, 1.83354020e-01f, 1.01785824e-01f, 7.69829527e-02f, -3.43982987e-02f, 1.71562228e-02f, 1.16202403e-02f, -8.82735942e-03f, -3.61380726e-02f, 1.30074602e-02f,
  -1.48048613e-03f, -5.63946292e-02f, 4.87835221e-02f, 9.17511061e-02f, 4.72731106e-02f, 1.98368710e-02f, 3.77625823e-02f, -1.52738150e-02f, 4.54053581e-02f, 6.22660033e-02f,
  6.18778206e-02f, 4.98087611e-03f, 7.03359544e-02f, 7.91060627e-02f, 4.67490926e-02f, 6.67094141e-02f, -7.42353499e-02f, -1.92815550e-02f, -4.53139171e-02f, -7.72518814e-02f,
  1.79146811e-01f, 3.59886661e-02f, 1.13152035e-01f, 4.73046750e-02f, -3.04219518e-02f, -4.08019051e-02f, -1.37428388e-01f, -7.38292262e-02f, -1.34372219e-01f, -6.60415441e-02f,
  -2.42001787e-02f, 1.16631880e-01f, 1.65212490e-02f, 1.77810248e-02f, -6.39510825e-02f, 2.39812657e-02f, 6.57787398e-02f, -2.39284318e-02f, 8.62132758e-03f, 4.44283932e-02f,
  -1.95241794e-02f, -2.34725066e-02f, 3.34362052e-02f, -1.93211734e-02f, -4.75341417e-02f, -3.62783819e-02f, -1.46379713e-02f, -1.34012341e-01f, 1.02038234e-01f, -5.19573353e-02f,
  -2.88999766e-01f, -1.15504630e-01f, 4.89363410e-02f, -7.99734592e-02f, -3.70280445e-02f, 1.10459905e-02f, 1.12065226e-02f, -2.99539585e-02f, -2.07196429e-01f, 3.69829088e-02f,
  -2.19763014e-02f, -2.64368150e-02f, -1.96029589e-01f, -4.88783680e-02f, 4.47400510e-02f, -5.72933368e-02f, -1.44266859e-01f, -1.11747928e-01f, -6.01351187e-02f, 3.12524885e-02f,
  -1.55291921e-02f, -3.61512345e-03f, 1.21275611e-01f, 2.45538317e-02f, -4.01117548e-04f, -1.50878336e-02f, -1.05595030e-02f, 2.23091263e-02f, 3.72239649e-02f, -1.24987394e-01f,
  -1.10351250e-01f, 1.65095255e-01f, -2.44803131e-01f, 7.64249936e-02f, 3.59143945e-03f, -1.58055395e-01f, -3.07320673e-02f, 4.93865907e-02f, 8.97078812e-02f, 2.54144669e-01f,
  2.15950191e-01f, 2.09863763e-02f, 3.76605019e-02f, -8.11920986e-02f, -1.84663117e-01f, -1.35614246e-01f, -1.40925974e-01f, -9.05355513e-02f, -5.37924394e-02f, 1.45270422e-01f,
  -6.80289939e-02f, 1.16604067e-01f, -3.20767730e-01f, 6.59535453e-02f, -4.06175144e-02f, 1.14590339e-02f, 1.28906608e-01f, 1.75278056e-02f, -4.81085069e-02f, -4.15356643e-02f,
  -1.01703115e-01f, 9.33080241e-02f, -7.66147021e-03f, 1.54384710e-02f, -4.59893867e-02f, -3.30341533e-02f, -5.36755621e-02f, 2.80918237e-02f, -1.01809751e-03f, -1.99872609e-02f,
  -9.80404988e-02f, -9.89003554e-02f, -9.25423577e-02f, -1.55831818e-02f, -6.19015023e-02f, -3.75750214e-02f, -4.40338887e-02f, -6.78330287e-02f, -5.67709133e-02f, -9.43182334e-02f,
  -9.60868001e-02f, -5.46981469e-02f, -1.16190121e-01f, -3.93484868e-02f, -1.09990001e-01f, 2.63545401e-02f, -4.11111824e-02f, -2.52774265e-02f, 7.19169504e-04f, -4.86693643e-02f,
  -2.35412526e-03f, -2.98662055e-02f, -1.27655047e-03f, 9.30769462e-03f, 1.32083505e-01f, -7.12265726e-03f, 2.50055417e-02f, -4.74445075e-02f, -2.67695207e-02f, 4.66420427e-02f,
  5.30334972e-02f, 3.10273897e-02f, -4.13484452e-03f, -6.75589442e-02f, 4.98404726e-03f, 1.11387238e-01f, -3.83976772e-02f, 5.42744100e-02f, -8.57640952e-02f, -5.24724759e-02f,
  7.90912360e-02f, 2.04451568e-03f, 1.75087657e-02f, -6.09479062e-02f, 7.37746581e-02f, 8.28020126e-02f, -6.78882841e-03f, 3.41922566e-02f, 7.85564166e-03f, -8.05874243e-02f,
  1.84244469e-01f, 2.67265916e-01f, 7.39348680e-03f, 4.17640284e-02f, 2.26583797e-02f, -6.46648481e-02f, -3.83396856e-02f, -9.32440758e-02f, 3.33324894e-02f, 2.78546587e-02f,
  -4.80447523e-02f, -1.56015530e-02f, -6.68547973e-02f, -5.65712266e-02f, 2.78330222e-02f, 8.13101069e-04f, 8.38366821e-02f, -4.17896993e-02f, 2.66480260e-02f, 1.16267623e-02f,
  5.37751131e-02f, 4.37012687e-02f, -9.28838551e-02f, -5.66571136e-04f, -4.87683341e-02f, 3.96851562e-02f, 8.19464028e-02f, 4.63311709e-02f, -4.39537177e-03f, -3.94864865e-02f,
  -1.31794780e-01f, 5.55778742e-02f, 2.37670273e-01f, -1.97328210e-01f, 2.02989712e-01f, 1.01362178e-02f, -8.72281939e-02f, 7.89875537e-02f, -1.43706938e-02f, -2.63783783e-01f,
  -2.15915173e-01f, 1.19229592e-01f, -1.99145824e-01f, -1.75710142e-01f, 1.13458216e-01f, -1.15184702e-01f, -1.99345782e-01f, -1.26045600e-01f, 1.42728770e-02f, -1.15703471e-01f,
  -4.01086658e-02f, -1.29321679e-01f, 5.55604510e-02f, 1.40778283e-02f, 8.80185813e-02f, 1.01643890e-01f, -1.12139970e-01f, 1.70802265e-01f, -5.02802543e-02f, 2.02716231e-01f,
  6.92144856e-02f, 1.24811176e-02f, 9.37173963e-02f, 7.37817287e-02f, -5.11635058e-02f, -1.28261503e-02f, 8.46070796e-03f, -1.10913219e-03f, 6.20075166e-02f, -5.10487743e-02f,
  -4.29519676e-02f, 4.22244780e-02f, -8.17813799e-02f, 4.89351265e-02f, -3.05306306e-03f, 7.46966824e-02f, 5.16244024e-02f, -3.26070450e-02f, -4.40176874e-02f, -4.26020920e-02f,
  5.01631051e-02f, 4.21848968e-02f, -4.64161113e-03f, -1.28861487e-01f, -3.98988230e-03f, -2.23699398e-02f, 3.04957759e-02f, 9.97032132e-03f, -6.77686855e-02f, 2.38985773e-02f,
  -3.03923395e-02f, -6.40671998e-02f, -3.98243964e-02f, 5.71102509e-03f, 1.66106969e-02f, -3.60183008e-02f, -5.39114960e-02f, -6.77269027e-02f, 1.74144302e-02f, -8.63236710e-02f,
  -6.61557987e-02f, 8.80057737e-02f, 3.05656698e-02f, -5.24098016e-02f, -7.53910467e-02f, -6.92731291e-02f, -5.21713570e-02f, 3.50044779e-02f, 2.23263080e-04f, 5.47705255e-02f,
  -8.41373280e-02f, 1.30677817e-03f, 1.52755929e-02f, -4.94281538e-02f, 8.00805464e-02f, -1.04047455e-01f, -4.29259278e-02f, -7.02915564e-02f, -1.13934213e-02f, -1.60846990e-02f,
  -9.26431343e-02f, -8.13077018e-02f, 4.34062630e-02f, 7.27772191e-02f, 2.89314501e-02f, 2.84507219e-02f, 1.77442301e-02f, -2.07683593e-02f, 4.60483134e-03f, -4.73600812e-02f,
  -1.10619828e-01f, -4.91723828e-02f, -5.71072334e-03f, -4.60749120e-02f, 3.96889728e-03f, 8.59614238e-02f, -4.30644862e-02f, -3.45026180e-02f, 2.59833951e-02f, 3.98098864e-02f,
  -1.26815870e-01f, -1.25573231e-02f, -3.17495912e-02f, -1.07406907e-01f, -5.66938445e-02f, -1.46504333e-02f, 1.27976209e-01f, 8.07380080e-02f, -1.14956666e-02f, 7.48677924e-02f,
  4.09222215e-01f, 5.63642047e-02f, -7.26642534e-02f, 1.94065660e-01f, 4.65699136e-02f, -2.01650947e-01f, 2.79432479e-02f, 9.20506492e-02f, 4.34120409e-02f, 1.79004427e-02f,
  5.33451103e-02f, -6.16465695e-02f, -1.23746460e-02f, -9.54573378e-02f, -1.42255843e-01f, -6.81488663e-02f, 9.45448503e-03f, 7.92875588e-02f, -3.97772454e-02f, 1.22844756e-01f,
  4.86249290e-02f, -3.47051136e-02f, -1.12349913e-01f, 7.98747987e-02f, 7.35431612e-02f, 4.28395197e-02f, 9.73464251e-02f, 4.50389981e-02f, 6.41562194e-02f, -1.35930464e-01f,
  1.09114893e-01f, 8.78283307e-02f, -5.89262582e-02f, -5.75209260e-02f, -1.12500386e-02f, 2.14937143e-02f, -1.10924849e-02f, -1.75688013e-01f, -1.77783798e-02f, -2.14630850e-02f,
  -2.70418320e-02f, 9.26694721e-02f, -1.19182756e-02f, -9.11692157e-02f, -2.06976607e-02f, -5.19610830e-02f, -5.40226027e-02f, -6.02657497e-02f, 1.71943512e-02f, -3.90398577e-02f,
  4.32885848e-02f, -2.41345633e-02f, 8.54690522e-02f, -4.90992852e-02f, -3.28239910e-02f, 1.27358092e-02f, -9.84630454e-03f, -1.46352733e-02f, 4.14554290e-02f, -5.62648848e-02f,
  7.85214454e-03f, 9.87874269e-02f, -2.24621035e-02f, 3.54085267e-02f, 4.20188867e-02f, 7.87979737e-02f, -2.24166214e-02f, 1.17479824e-02f, -2.06350461e-02f, -3.31839616e-03f,
  5.48631437e-02f, 4.00849171e-02f, -9.36547760e-03f, -1.96311343e-02f, 4.51532453e-02f, 9.39478725e-02f, 6.24360591e-02f, -2.69824406e-03f, -6.51525520e-03f, 6.15844838e-05f,
  -1.26306955e-02f, -3.19586284e-02f, 7.73158520e-02f, -5.43375267e-03f, -7.30983764e-02f, -6.73018619e-02f, 1.31253704e-01f, -3.84998843e-02f, -1.09168729e-02f, 1.33274989e-02f,
  1.35642678e-01f, 2.40379229e-01f, -5.72821610e-02f, 9.55853984e-02f, -7.26957023e-02f, -4.92897816e-02f, -2.11733468e-02f, -6.95584863e-02f, -1.13352902e-01f, 1.12532387e-02f,
  -1.27001284e-02f, 2.24326011e-02f, 6.34163693e-02f, -1.52095780e-02f, -1.18526714e-02f, -3.95968296e-02f, 9.89082642e-03f, 6.72517419e-02f, 2.91088242e-02f, 7.78741837e-02f,
  1.05369397e-01f, 5.84733561e-02f, -4.29089600e-03f, 1.08823314e-01f, -9.91193298e-03f, 1.83396768e-02f, 3.07529382e-02f, 1.78532433e-02f, -5.91679327e-02f, 1.81211289e-02f,
  6.78003132e-02f, 3.75151299e-02f, 3.55605222e-02f, -7.38178659e-03f, -4.07450683e-02f, -1.93280309e-01f, -1.71070561e-01f, 2.67696232e-01f, 9.66347307e-02f, -1.93516985e-02f,
  -1.87691629e-01f, -5.13222739e-02f, 1.80680498e-01f, -2.43007690e-01f, 1.25544053e-02f, 7.64672309e-02f, -1.48744673e-01f, -1.49978533e-01f, 3.84356156e-02f, -5.21465577e-03f,
  7.04850554e-02f, -1.14380658e-01f, -1.58728942e-01f, 9.14677158e-02f, -9.96153429e-02f, 6.67849183e-02f, -1.20458782e-01f, 1.40861049e-01f, -1.92297306e-02f, -5.07862978e-02f,
  -3.79616246e-02f, 7.05201775e-02f, 8.23307317e-03f, 8.86576921e-02f, 1.84531249e-02f, -1.13262556e-01f, -3.95506695e-02f, -4.13534120e-02f, -6.78807544e-03f, -2.02889405e-02f,
  -2.75532696e-02f, 1.34304687e-01f, -3.01790293e-02f, -1.72885172e-02f, -1.65054891e-02f, -4.57469337e-02f, -1.07875150e-02f, -1.26482233e-01f, -7.12967536e-04f, 3.85797471e-02f,
  -9.42960903e-02f, -1.01115517e-01f, -5.91439847e-03f, -3.91398929e-02f, -9.29312333e-02f, -9.19924453e-02f, -7.04019293e-02f, -6.27244860e-02f, -4.06140089e-02f, -7.80023113e-02f,
  9.42199156e-02f, 2.46337373e-02f, -2.69721299e-02f, 5.66962995e-02f, -4.29540500e-02f, -3.40146758e-02f, -1.33104082e-02f, -8.15745294e-02f, 2.30002943e-02f, -1.12772539e-01f,
  -5.68650216e-02f, -8.46550986e-03f, 6.48660511e-02f, -8.66630375e-02f, -1.14178061e-01f, -3.94263193e-02f, -3.88585739e-02f, 7.90736231e-04f, -8.83063748e-02f, 3.98854241e-02f,
  4.61685918e-02f, 3.70018817e-02f, -8.03227499e-02f, 2.45973822e-02f, 2.65854970e-02f, 7.22678006e-02f, 5.17635010e-02f, 1.69494655e-02f, 2.85755452e-02f, -1.63159259e-02f,
  1.25863031e-01f, 1.37069061e-01f, 6.94872513e-02f, 5.61437942e-02f, -3.87596041e-02f, -6.54524416e-02f, 1.52320871e-02f, -1.09040020e-02f, 1.32898852e-01f, 9.85417962e-02f,
  -1.90232694e-02f, -5.22032008e-02f, -3.36340815e-02f, 3.94408144e-02f, 2.46752277e-02f, -7.89859667e-02f, 1.72675774e-02f, 8.79259501e-03f, 1.76709816e-02f, 1.54926535e-02f,
  -8.73627216e-02f, 3.75654101e-02f, -1.02124885e-01f, -9.47455037e-03f, -1.00214064e-01f, -9.64981094e-02f, 6.99830130e-02f, -1.17972679e-02f, -6.30254224e-02f, 2.24578660e-02f,
  1.18956059e-01f, -1.53199866e-01f, 2.44375952e-02f, 2.07129627e-01f, 2.56888539e-01f, 2.03535199e-01f, 8.72952938e-02f, 1.29886284e-01f, 3.39593068e-02f, -1.89809039e-01f,
  1.38812691e-01f, -1.91250667e-02f, 3.65349017e-02f, 5.50836027e-02f, 2.64875025e-01f, -2.95232236e-02f, 1.53464913e-01f, 6.17504232e-02f, -3.37828845e-02f, 1.07920974e-01f,
  9.21095908e-02f, 1.92553967e-01f, 1.30014271e-01f, 9.92136449e-02f, 1.20547697e-01f, -5.78533076e-02f, 5.33950366e-02f, 6.95876256e-02f, -2.40161698e-02f, 4.78330478e-02f,
  -2.49508601e-02f, -1.43335879e-01f, -8.84906277e-02f, -2.98723821e-02f, 5.93686588e-02f, -6.60067648e-02f, -4.70340624e-02f, 4.71533947e-02f, -1.63441279e-03f, 7.72755221e-03f,
  8.32476839e-02f, 9.13276300e-02f, 1.21955443e-02f, 5.77499121e-02f, 1.88339204e-02f, 8.50035325e-02f, 4.34938744e-02f, 8.04418046e-03f, 6.85832277e-02f, 3.99358645e-02f,
  2.66107991e-02f, 8.50362517e-03f, -5.23374043e-02f, 1.49439760e-02f, 4.81636748e-02f, -1.34973638e-02f, 4.90826815e-02f, 1.62241925e-02f, 5.21521419e-02f, 9.40039114e-04f,
  -1.26310680e-02f, 7.00287297e-02f, -5.92297390e-02f, -5.26320897e-02f, 5.32149747e-02f, -6.57030987e-03f, 7.48744756e-02f, 8.42411667e-02f, 2.54742000e-02f, 5.84092885e-02f,
  4.86076288e-02f, 4.70763035e-02f, 7.83326849e-03f, 5.79681881e-02f, 7.59897307e-02f, -3.58670615e-02f, 5.61364330e-02f, 6.12001913e-03f, -1.04480814e-02f, 1.86422206e-02f,
  1.21483756e-02f, 6.11448698e-02f, -9.88434851e-02f, 3.94812152e-02f, -2.23502927e-02f, 7.55420774e-02f, -4.26436886e-02f, 2.76169572e-02f, 4.81018946e-02f, 9.11886767e-02f,
  8.22086036e-02f, 5.57268262e-02f, -7.03494251e-02f, -7.19638541e-02f, -5.64810745e-02f, 8.50991607e-02f, 4.93170656e-02f, 1.38312221e-01f, -3.92851643e-02f, 1.59788042e-01f,
  5.37689440e-02f, -2.71671806e-02f, -4.77236025e-02f, 4.23917174e-03f, -1.47673199e-02f, -1.16032735e-03f, 8.51534754e-02f, -6.69365302e-02f, -4.03234102e-02f, -3.81298270e-03f,
  4.71984930e-02f, 4.85558324e-02f, 7.61953357e-04f, 5.73071130e-02f, 7.89709464e-02f, 4.92459461e-02f, -1.03886612e-03f, -4.98013422e-02f, 7.20751658e-02f, 2.79690120e-02f,
  -1.38804987e-01f, -2.49027535e-01f, -1.96250349e-01f, 9.48236436e-02f, 1.34049669e-01f, -7.67580420e-02f, -7.94471875e-02f, 9.03990716e-02f, -1.28797397e-01f, 4.99004386e-02f,
  1.95347399e-01f, -1.30029768e-01f, -3.09648495e-02f, 6.92987591e-02f, 1.05039738e-01f, -1.21450514e-01f, 8.20752531e-02f, 5.87886535e-02f, -1.43323600e-01f, 1.35892972e-01f,
  1.37303680e-01f, 2.63749272e-01f, 9.18493122e-02f, 8.05683434e-02f, -4.07791551e-04f, 9.96283814e-02f, 3.38563710e-01f, -2.85505652e-02f, 1.81048155e-01f, -5.84811531e-02f,
  -1.00470424e-01f, -1.26845643e-01f, 9.22807306e-02f, -9.98123735e-02f, -9.47832968e-03f, 6.71342015e-02f, 7.15402095e-03f, -1.17248110e-02f, -7.80590326e-02f, -3.32317650e-02f,
  -3.84818055e-02f, 5.85463224e-03f, -5.52158579e-02f, -1.56509895e-02f, -9.07596946e-02f, 3.96527629e-03f, -5.60558066e-02f, -2.60799676e-02f, -3.08332108e-02f, -9.98547077e-02f,
  -6.91970363e-02f, -7.32293576e-02f, -2.93339742e-03f, -3.03927553e-03f, 9.11071599e-02f, 4.12466973e-02f, -2.49317717e-02f, 9.16437581e-02f, -1.47219852e-01f, 7.63083771e-02f,
  -1.30233034e-01f, 3.47193964e-02f, -2.86244750e-02f, -5.47414869e-02f, 4.78227362e-02f, -5.78630250e-03f, -2.50407606e-02f, 9.08235610e-02f, -8.78219213e-03f, 2.19718907e-02f,
  7.63366837e-03f, 2.27589980e-02f, -6.61118180e-02f, 3.68917966e-03f, 9.69756246e-02f, -6.74672946e-02f, 6.75329764e-04f, 6.69393167e-02f, 3.36796604e-02f, -6.98934600e-04f,
  3.09467241e-02f, 1.48718404e-02f, 3.78531450e-03f, -3.04372702e-02f, -2.15716995e-02f, 4.19402495e-02f, 1.83363687e-02f, -3.69071402e-02f, 2.07216218e-02f, 4.63412777e-02f,
  -2.44283210e-02f, 9.44082439e-02f, 7.59583414e-02f, -3.55655476e-02f, 3.13702151e-02f, 4.37360294e-02f, -3.53954136e-02f, 2.78772060e-02f, -1.07185997e-01f, -9.00987089e-02f,
  7.50666782e-02f, 4.93961535e-02f, -3.30344401e-02f, -5.99140115e-02f, -2.02593412e-02f, 7.68938139e-02f, 7.14798719e-02f, 1.95921026e-02f, 4.30678204e-03f, 3.10291108e-02f,
  1.07173145e-01f, 2.88041751e-03f, -5.93776107e-02f, 2.29735058e-02f, 9.65896696e-02f, 5.52997217e-02f, -2.94244215e-02f, -3.89255397e-02f, 1.34373894e-02f, -1.52065102e-02f,
  -5.37380576e-01f, 3.11307281e-01f, -1.28968909e-01f, -1.72037631e-02f, -1.47826597e-01f, 1.47978738e-01f, -1.38691375e-02f, 1.28641948e-01f, 1.08495884e-01f, 2.89993525e-01f,
  1.54654160e-01f, -1.33520057e-02f, 7.81614035e-02f, 1.40040785e-01f, -2.98367918e-01f, 9.45066512e-02f, 2.45677009e-02f, 9.68610495e-02f, 2.00715847e-02f, -1.23842992e-02f,
  8.55873153e-02f, 8.68142992e-02f, -4.62010130e-02f, 5.71100600e-02f, 7.27317110e-03f, -7.26995021e-02f, -2.36107558e-02f, -1.45984516e-01f, -9.48308129e-03f, -3.25275548e-02f,
  3.49151492e-02f, 4.61810641e-02f, -7.37802982e-02f, -4.95568700e-02f, -1.14697620e-01f, -5.94604351e-02f, -1.72741637e-02f, 1.89620641e-03f, -9.27019790e-02f, -2.72334870e-02f,
  -4.84326072e-02f, 3.30739468e-02f, 3.37975658e-02f, -1.08184651e-01f, -3.32864281e-03f, -2.05434859e-02f, -2.52474030e-03f, 7.16391876e-02f, -1.79211721e-02f, -1.61866844e-02f,
  -6.17691176e-03f, -4.60239761e-02f, 1.17750512e-02f, 9.39759389e-02f, 6.21166602e-02f, -3.63692455e-02f, 7.04601780e-02f, -3.27144098e-03f, 5.73608540e-02f, 4.52196635e-02f,
  -5.57220131e-02f, -2.99998131e-02f, -2.19011270e-02f, 4.95339883e-03f, 7.26878736e-03f, 6.83889762e-02f, 4.27948646e-02f, 8.47258419e-02f, -8.77779648e-02f, -3.78321521e-02f,
  6.97707385e-02f, 2.16844678e-02f, -2.68791290e-03f, 8.75943452e-02f, 6.27364144e-02f, 5.05265556e-02f, -2.47554705e-02f, 4.86583933e-02f, -1.08412020e-02f, 1.47567224e-02f,
  1.06339432e-01f, 2.79361028e-02f, 3.15247588e-02f, -7.93068111e-03f, -4.17290553e-02f, -1.41109980e-03f, 1.15223870e-01f, -4.64532850e-03f, 1.64610203e-02f, -3.00574210e-02f,
  1.70685634e-01f, 2.46647835e-01f, 4.21241149e-02f, -2.12491155e-02f, 2.30811480e-02f, -2.38340255e-02f, 3.24671380e-02f, -2.13120412e-02f, 1.02824885e-02f, 2.55772043e-02f,
  5.54583780e-03f, -7.30127618e-02f, -2.89677028e-02f, 1.41162509e-02f, 4.90856403e-03f, 9.69722942e-02f, 1.91356018e-02f, 1.51815731e-02f, 1.87900998e-02f, -1.89737603e-03f,
  3.36484122e-03f, 5.84641919e-02f, -6.55516633e-04f, 3.62506807e-02f, 1.27439082e-01f, -3.33480239e-02f, -9.38664749e-03f, 1.60859805e-02f, 8.97866394e-03f, 3.33889537e-02f,
  -3.12047899e-01f, 8.99100304e-02f, -4.65654694e-02f, -1.26517460e-01f, -5.22931106e-03f, -2.79247254e-01f, -3.67764533e-01f, 7.84637108e-02f, -2.35183686e-01f, 1.39560536e-01f,
  7.64122531e-02f, 7.09386095e-02f, -4.94150408e-02f, -6.13738736e-03f, -2.20561743e-01f, -1.70151100e-01f, -1.53660625e-01f, -6.12685792e-02f, -7.09063485e-02f, 8.81207660e-02f,
  -7.31108291e-03f, 1.20084621e-01f, 9.74776074e-02f, 1.46846130e-01f, 9.83732939e-03f, 7.05420077e-02f, 1.96155697e-01f, 1.05935782e-01f, 1.62768975e-01f, 1.30120188e-01f,
  -1.15832746e-01f, -3.79512794e-02f, 3.92587855e-02f, -8.49641412e-02f, -1.87117066e-02f, 6.20954037e-02f, 8.19887221e-02f, 7.12851584e-02f, -9.38914493e-02f, -3.24216038e-02f,
  -3.64031568e-02f, -8.18161592e-02f, -2.40901541e-02f, 6.45795539e-02f, -2.48933863e-03f, 5.62448567e-03f, -7.00000152e-02f, -2.19786889e-03f, 3.54565866e-02f, -9.22472998e-02f,
  -4.76172157e-02f, -2.22928897e-02f, -3.26087996e-02f, -1.13167637e-03f, -1.12113645e-02f, -6.54752925e-02f, -4.19054404e-02f, 2.96890270e-02f, -5.37940748e-02f, 4.91128936e-02f,
  3.87583449e-02f, -5.19850664e-02f, -2.19133776e-02f, -2.18367875e-02f, -2.03883760e-02f, -4.58800830e-02f, 2.50605936e-03f, 1.28830254e-01f, 1.71437059e-02f, 2.84051113e-02f,
  -4.40567769e-02f, 5.20177223e-02f, 5.44055402e-02f, 1.04197524e-02f, -3.76957282e-02f, -5.76522909e-02f, 6.24795184e-02f, 4.70454469e-02f, -7.85153061e-02f, 1.50946965e-02f,
  2.44657882e-02f, -8.43901709e-02f, -4.52074297e-02f, 3.34914699e-02f, 5.63391745e-02f, 6.03100918e-02f, 1.55889140e-02f, 1.04568936e-01f, -2.00684415e-03f, -1.89201627e-03f,
  1.12673253e-01f, 9.18347314e-02f, -6.76671490e-02f, 7.87054822e-02f, -3.75587940e-02f, 5.15329875e-02f, 1.37307681e-03f, 3.21735367e-02f, 8.18133578e-02f, 1.22134788e-02f,
  7.65034277e-03f, -3.77056189e-02f, -1.76131185e-02f, 1.19492551e-02f, -4.72355671e-02f, 1.36382980e-02f, 2.34135669e-02f, -4.27333638e-02f, 1.17629133e-01f, 3.88599075e-02f,
  9.40687358e-02f, -5.03665395e-02f, -1.84390843e-02f, -1.95611082e-03f, -1.82343572e-02f, -4.45527621e-02f, 4.64789085e-02f, 1.23306587e-02f, 1.09547116e-01f, -1.05585745e-02f,
  1.96980104e-01f, 1.59217432e-01f, 1.42755315e-01f, 1.45812064e-01f, -4.52959910e-03f, -3.04067045e-01f, -2.20050029e-02f, -4.09173407e-02f, 2.59234905e-01f, 6.41756598e-03f,
  -1.23081952e-01f, 3.00558388e-01f, -8.40444863e-02f, -6.73794672e-02f, -6.31454289e-02f, -4.93504815e-02f, -7.28050172e-02f, 1.15415193e-02f, 4.02964950e-02f, 3.52165774e-02f,
  -6.45535514e-02f, -2.28015333e-01f, -1.35385513e-01f, -8.09581652e-02f, -6.99537620e-02f, 1.06617570e-01f, -1.84132427e-01f, -1.02830762e-02f, -3.07831541e-02f, 8.51619150e-03f,
  -6.16761409e-02f, 1.48753747e-01f, -7.60321990e-02f, 4.49934714e-02f, -7.58189484e-02f, -1.26287371e-01f, -4.14743163e-02f, 3.66574973e-02f, -1.30440909e-02f, -2.32782159e-02f,
  -9.10317153e-03f, 5.94133623e-02f, 1.53776109e-02f, -5.06361993e-03f, 2.88691185e-02f, 2.08739899e-02f, -4.39873617e-03f, -7.59726614e-02f, -6.82751788e-03f, 3.68567440e-03f,
  6.20014146e-02f, -5.32386824e-02f, 9.23978984e-02f, 7.85400271e-02f, 4.69517037e-02f, 7.30010942e-02f, -3.59381037e-03f, 6.65226579e-03f, 1.64561992e-04f, 3.73717286e-02f,
  6.62766621e-02f, -1.16872519e-01f, 3.91135551e-02f, 7.37374797e-02f, 1.24950483e-02f, 6.52434479e-04f, -4.60534170e-02f, 5.60495630e-02f, 1.61600709e-01f, 4.19376306e-02f,
  1.35067366e-02f, 2.48957146e-02f, 3.41149443e-03f, -1.80172455e-02f, -1.31667340e-02f, 1.22928977e-01f, 3.09386384e-02f, 1.09306378e-02f, 5.10706380e-02f, 3.57849784e-02f,
  -1.40184928e-02f, -2.49631633e-03f, 3.25181857e-02f, -1.11869036e-03f, -1.08410139e-02f, 8.55525024e-04f, 7.13914214e-03f, -1.37147624e-02f, 6.42636642e-02f, -6.43296316e-02f,
  4.75306697e-02f, 1.24721639e-01f, 4.42214869e-03f, 1.23680877e-02f, -1.86835025e-02f, -3.66750285e-02f, 2.55717561e-02f, 4.35669534e-02f, 9.13580507e-02f, 1.57561358e-02f,
  -6.59315363e-02f, -4.33980711e-02f, 5.01776859e-02f, 5.24368957e-02f, 5.55740856e-02f, 1.72432996e-02f, 1.57197062e-02f, 6.52609440e-03f, -8.88754055e-03f, 4.55138972e-03f,
  -3.33715081e-02f, 1.52642494e-02f, 5.42039461e-02f, -4.17055599e-02f, -1.18347153e-01f, 7.66426027e-02f, 7.92719275e-02f, -4.18083519e-02f, -3.89868878e-02f, -8.48664902e-03f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.08256602e-01f, -4.01125848e-02f, -2.93335825e-01f, -8.17870907e-03f, 1.91096902e-01f, 2.42290005e-01f, 1.32835237e-02f, 5.27761355e-02f, -2.22668238e-02f, 3.10776867e-02f,
  1.83173180e-01f, -8.32994431e-02f, -1.56008065e-01f, 2.46309295e-01f, 1.68631583e-01f, -1.68446973e-01f, 1.92670450e-01f, 1.38028398e-01f, -1.05913594e-01f, 1.47722021e-01f,
  5.39274840e-03f, 2.66801864e-01f, -1.42145455e-01f, 6.51434138e-02f, 2.19485655e-01f, -2.72630006e-01f, 5.56297712e-02f, -2.15395570e-01f, 3.33864167e-02f, 1.55687898e-01f,
  1.06997825e-02f, -3.46918777e-02f, -1.64944157e-02f, 1.61791947e-02f, -9.70585737e-03f, 2.98122596e-02f, 5.72885666e-03f, -1.44131780e-02f, -1.00668944e-01f, -1.18841100e-02f,
  -2.99893897e-02f, 3.03319879e-02f, -6.71020970e-02f, 7.35207200e-02f, 4.14191820e-02f, 7.45892450e-02f, -8.20388943e-02f, 3.24638747e-03f, -9.23448503e-02f, 6.65562153e-02f,
  -8.99374038e-02f, -1.06581725e-01f, 7.36371242e-03f, -8.90339762e-02f, -9.64382198e-03f, -5.55424727e-02f, -7.91712925e-02f, -4.41704430e-02f, -5.22969197e-03f, 7.55326971e-02f,
  -5.27506582e-02f, 1.10024204e-02f, -2.28901692e-02f, 8.76315776e-03f, 1.64922029e-02f, -3.98631282e-02f, 7.55170509e-02f, -2.89402599e-03f, -2.03113109e-02f, 1.05630592e-01f,
  1.50900176e-02f, -4.84634303e-02f, 7.27257133e-02f, 7.48351961e-03f, 6.08697832e-02f, -4.96829227e-02f, 1.99216548e-02f, 6.51520789e-02f, 8.17588996e-03f, -1.21115044e-01f,
  2.18591727e-02f, 1.60214510e-02f, -3.61665152e-02f, 1.92043409e-02f, 1.91299599e-02f, -1.69395395e-02f, 1.65926978e-01f, 5.68807833e-02f, -9.94415358e-02f, 7.34324902e-02f,
  7.91244879e-02f, -1.47595741e-02f, -2.08462849e-02f, 4.46705818e-02f, -5.25572933e-02f, 1.08782433e-01f, 7.82768726e-02f, -6.72036083e-03f, 1.96823720e-02f, 9.38482583e-02f,
  4.33195792e-02f, -1.18398130e-01f, 3.07894275e-02f, 5.00736423e-02f, 5.96987382e-02f, 9.53832045e-02f, 2.55898461e-02f, -1.04739182e-01f, 9.27584432e-03f, -2.61795912e-02f,
  -5.75390793e-02f, -7.79322460e-02f, -3.93642765e-03f, -2.63973214e-02f, -7.00152433e-03f, -6.28375039e-02f, -9.16095674e-02f, 2.02367045e-02f, 1.37581483e-01f, -5.59502393e-02f,
  -2.37133354e-01f, -1.88375842e-02f, -2.07307249e-01f, -1.50563046e-01f, -8.40464234e-03f, -2.61127353e-01f, -1.26003072e-01f, 2.01358236e-02f, 4.17023338e-02f, 1.41625181e-01f,
  5.27839316e-03f, 8.29749331e-02f, 1.05708420e-01f, -2.58440882e-01f, -2.24916488e-01f, -2.35877410e-02f, -3.94872457e-01f, -9.69572738e-02f, 1.27663678e-02f, -1.37092933e-01f,
  -9.57788825e-02f, -7.19362572e-02f, -1.43487990e-01f, 1.78388115e-02f, -1.43675625e-01f, 6.54600561e-02f, 1.01438805e-01f, 8.56013000e-02f, -8.26225206e-02f, 2.96166409e-02f,
  6.09545736e-03f, 7.98480585e-02f, 7.79477600e-03f, -2.56868574e-04f, -1.01852886e-01f, 3.57668055e-03f, -5.28693497e-02f, 6.32026186e-03f, 1.16805367e-01f, 3.91953737e-02f,
  -4.07646894e-02f, -1.00782186e-01f, -9.30290855e-03f, 1.05871715e-01f, 7.95825198e-02f, 2.87363604e-02f, -9.18060169e-03f, -3.65097262e-02f, 4.17232327e-02f, -8.78427327e-02f,
  -8.48057270e-02f, -3.69309559e-02f, -9.81266126e-02f, -2.74946783e-02f, -3.95630673e-02f, 5.24645261e-02f, -6.95864707e-02f, 2.07217922e-03f, -1.60066374e-02f, -3.74169350e-02f,
  -4.48005274e-02f, -5.32831810e-02f, -9.80960727e-02f, 7.87616521e-02f, 4.31220233e-02f, -6.60283267e-02f, -3.56598310e-02f, 3.77491117e-02f, -9.37737823e-02f, 4.02837954e-02f,
  2.23553330e-02f, 2.33456865e-02f, 9.18368325e-02f, -1.83080323e-02f, -1.14658186e-02f, 3.27759758e-02f, 8.70723557e-03f, -5.50177321e-02f, -7.40278885e-02f, -2.70940159e-02f,
  9.92023572e-02f, 1.06274961e-02f, 7.77894408e-02f, -5.40692210e-02f, -2.47089155e-02f, 5.78618161e-02f, 7.87944496e-02f, -5.24011254e-02f, 1.07260324e-01f, 4.68680598e-02f,
  -4.40185182e-02f, 3.76494764e-03f, 6.53961003e-02f, 9.38956439e-02f, -3.70415673e-02f, 3.04490775e-02f, -7.11965412e-02f, -1.39666870e-01f, -7.19401008e-03f, 3.43345217e-02f,
  5.79779735e-03f, -1.24029713e-02f, -7.35652447e-02f, -3.60049009e-02f, -1.05662821e-02f, 3.02162822e-02f, 6.45905808e-02f, -1.31384656e-02f, 2.72229854e-02f, 1.07821748e-01f,
  -9.58609655e-02f, 1.58875436e-02f, 1.81414038e-02f, 1.00072742e-01f, 3.96041125e-02f, 1.16482958e-01f, 5.86452894e-02f, 3.54747362e-02f, -8.84821173e-03f, -4.29779477e-02f,
  -1.63586736e-02f, -2.98661254e-02f, -1.48703456e-01f, -2.82334238e-01f, -1.93670645e-01f, -1.01466827e-01f, -1.87682122e-01f, -1.40100464e-01f, -1.17652759e-01f, 7.07746809e-03f,
  -1.61826894e-01f, 1.66059844e-03f, 2.30755538e-01f, -1.63744926e-01f, 2.52191633e-01f, 2.90993899e-01f, -6.28938228e-02f, 6.01002015e-02f, -1.48444936e-01f, -7.42975324e-02f,
  -5.15621416e-02f, -7.13575408e-02f, 2.07627460e-01f, -3.13817300e-02f, -2.50422359e-01f, -1.35433719e-01f, -1.39672682e-01f, -6.40891716e-02f, -2.92938471e-01f, -2.00529382e-01f,
  -3.35763628e-03f, 3.80474119e-03f, -1.55629329e-02f, 1.25670865e-01f, -6.37354553e-02f, 1.14221480e-02f, -9.52403322e-02f, -5.95736550e-03f, -3.92346792e-02f, 3.83760897e-03f,
  -3.13908197e-02f, 8.28332230e-02f, 3.61246779e-03f, -8.21510181e-02f, -2.68676355e-02f, -2.68799383e-02f, 1.26499878e-02f, -6.00716174e-02f, -1.81189235e-02f, 1.03959993e-01f,
  1.07542343e-01f, 5.34497947e-02f, -2.67916378e-02f, 2.67376634e-03f, -9.05778073e-03f, -6.07730299e-02f, 9.89210680e-02f, -6.93393871e-02f, 2.68842150e-02f, -4.68784645e-02f,
  -6.45957440e-02f, 7.17090368e-02f, 5.81675395e-02f, -7.08523914e-02f, 5.01497537e-02f, 8.56259167e-02f, 5.68658672e-02f, 4.27412391e-02f, -4.87585701e-02f, 3.88426706e-02f,
  3.23483199e-02f, 7.84212351e-02f, 1.61827520e-01f, 2.78096590e-02f, -8.95365551e-02f, -6.03062697e-02f, -5.64058684e-03f, -2.12910641e-02f, -9.19681042e-02f, -4.59144115e-02f,
  6.42499849e-02f, 1.36271808e-02f, 1.34232461e-01f, 4.28286977e-02f, -3.43494192e-02f, 8.50600675e-02f, -1.06419818e-02f, 6.28951285e-03f, -1.60800163e-02f, -3.95872444e-02f,
  -1.07471690e-01f, -1.00985698e-01f, -2.87333578e-02f, 3.55187580e-02f, 4.33805995e-02f, -6.56802719e-03f, -4.14302200e-02f, -4.29400131e-02f, -1.30196422e-01f, -1.77441798e-02f,
  -6.85297325e-02f, -2.47157104e-02f, -7.55881369e-02f, -1.52994931e-01f, -5.33131836e-03f, -7.41929421e-03f, 8.59212205e-02f, -1.32722519e-02f, -8.66874158e-02f, -8.54218304e-02f,
  7.12255910e-02f, 5.01433052e-02f, 8.88048410e-02f, 5.53654842e-02f, -2.40274947e-02f, 5.18352818e-03f, 5.62888607e-02f, -4.24333774e-02f, -2.92994399e-02f, -2.17670873e-02f,
  2.18021527e-01f, -2.02264816e-01f, 1.63187400e-01f, 3.16425711e-01f, 1.25155658e-01f, -6.39941394e-02f, -1.56567037e-01f, -2.96866633e-02f, -1.18760742e-01f, -2.14865789e-01f,
  4.94303973e-03f, 2.46174783e-01f, -3.20477486e-01f, 6.51544333e-02f, -2.24697798e-01f, -2.56348640e-01f, 3.72503921e-02f, 7.06525519e-02f, -1.67647470e-02f, -6.52287249e-03f,
  1.03672795e-01f, -1.90572038e-01f, -2.35932916e-02f, -1.16742283e-01f, 1.36904702e-01f, 9.47829559e-02f, -1.07686007e-02f, -4.37789075e-02f, 2.32499331e-01f, 4.15466614e-02f,
  9.28896293e-03f, -1.71700984e-01f, 4.45879251e-02f, -3.34284380e-02f, -1.28173947e-01f, 9.87320170e-02f, 1.23887919e-01f, -3.66503410e-02f, 9.28087533e-02f, 1.76089387e-02f,
  -1.03713628e-02f, 1.99000359e-01f, -1.36188522e-03f, 4.18366566e-02f, 3.45275067e-02f, 1.85186774e-01f, 7.90291205e-02f, 4.51066829e-02f, 5.75336404e-02f, -6.25941157e-02f,
  -6.60499930e-02f, 1.78300232e-01f, 1.54395029e-01f, 2.38070101e-01f, 3.00672352e-02f, -2.56884433e-02f, 2.01063659e-02f, -6.76418692e-02f, 2.60847658e-02f, 7.80409425e-02f,
  -1.58710763e-01f, -1.09835692e-01f, -1.10563142e-02f, 1.22447692e-01f, -2.35581845e-02f, -3.48486453e-02f, 3.43429409e-02f, 6.20892942e-02f, 7.72771686e-02f, -1.02243014e-02f,
  1.55331651e-02f, -1.24529704e-01f, 2.60993447e-02f, 1.20478228e-01f, 5.47954440e-03f, 4.39480357e-02f, 1.08108275e-01f, 1.10399030e-01f, 2.26418432e-02f, 2.54193991e-02f,
  -1.47463400e-02f, 4.23997715e-02f, -1.03106886e-01f, 1.58062458e-01f, 1.37163520e-01f, -1.40548676e-01f, 4.36127447e-02f, 1.26222804e-01f, 3.12362332e-02f, -2.75178626e-02f,
  -1.93077788e-01f, -4.42879468e-01f, -6.86933175e-02f, 8.19945782e-02f, 4.44957837e-02f, -3.27120759e-02f, 4.95126769e-02f, 2.82929875e-02f, -1.08756028e-01f, -7.66711906e-02f,
  5.87660819e-02f, 1.32673383e-01f, -1.95321981e-02f, 1.43479511e-01f, -1.33305117e-01f, -5.39922900e-02f, -1.15695298e-02f, -1.33041129e-01f, 7.67038763e-02f, -5.19314297e-02f,
  4.22542030e-03f, -3.26112285e-02f, 1.88793167e-02f, 2.58923769e-02f, 3.41596901e-02f, 7.04544829e-04f, 1.02771081e-01f, 1.46349985e-02f, 3.93927954e-02f, -4.87688892e-02f,
  1.88161999e-01f, 2.90024653e-02f, -3.27491045e-01f, -3.77640724e-02f, -1.48919687e-01f, 2.65250742e-01f, 1.15609154e-01f, 3.18378024e-02f, 1.71792172e-02f, 2.59215087e-01f,
  3.33966166e-01f, 8.32740143e-02f, 2.03471869e-01f, 3.39593917e-01f, 1.66751295e-01f, 1.67156592e-01f, 2.72258013e-01f, 1.25956118e-01f, -5.79681434e-02f, 1.95357218e-01f,
  -8.14819057e-03f, 3.45717430e-01f, 6.04312830e-02f, 3.13544087e-02f, 2.71952227e-02f, -2.41757512e-01f, 2.75379643e-02f, -1.33349881e-01f, 9.90457982e-02f, -4.08706479e-02f,
  1.99499335e-02f, 4.56758253e-02f, -3.67619023e-02f, -9.48551670e-02f, -1.96001469e-03f, -8.68548006e-02f, -1.07152060e-01f, -3.88141088e-02f, -2.89311055e-02f, 5.29697277e-02f,
  5.15831113e-02f, -3.56890634e-02f, 1.67778842e-02f, -6.94481982e-03f, -2.86719985e-02f, -8.97760317e-02f, -4.37911190e-02f, -4.97797430e-02f, 7.24907070e-02f, 6.12089708e-02f,
  -3.55509743e-02f, -4.74041365e-02f, 3.43735367e-02f, -1.27888352e-01f, 2.77602463e-03f, 3.73424329e-02f, 1.89768542e-02f, 3.33812763e-03f, -1.23534212e-02f, -2.90028248e-02f,
  -1.75621361e-02f, 2.81516835e-02f, -3.16356309e-03f, -1.19014326e-02f, -5.99993728e-02f, -2.10381187e-02f, 1.08910725e-01f, -2.06184462e-02f, 2.26490796e-02f, 1.51120156e-01f,
  -4.34984192e-02f, -8.70363135e-03f, 2.21927352e-02f, 2.04148702e-02f, 4.04476859e-02f, 1.21587135e-01f, 1.77986715e-02f, 5.21168225e-02f, -3.09577715e-02f, 3.53469849e-02f,
  1.14207696e-02f, 9.33836680e-03f, -4.93780412e-02f, 1.32494944e-03f, -2.41891621e-03f, -6.08233102e-02f, 6.39228821e-02f, 3.11614908e-02f, -6.65172413e-02f, 2.79733986e-02f,
  6.92709312e-02f, 9.84462947e-02f, 1.45882005e-02f, -5.93201630e-02f, -4.33055311e-02f, 2.57765111e-02f, 9.28908512e-02f, 7.29667619e-02f, -9.89263505e-02f, 7.16699511e-02f,
  -3.32901697e-03f, 4.04017570e-04f, 1.36160431e-02f, 2.15025060e-02f, -8.16810410e-03f, 6.88895062e-02f, 1.02666974e-01f, -5.57259694e-02f, -4.62736562e-02f, 4.90018837e-02f,
  4.57024686e-02f, -9.55699012e-02f, 5.88948242e-02f, -1.58531785e-01f, -3.09951641e-02f, 4.91008088e-02f, -9.80074331e-02f, -3.63089927e-02f, 7.55134970e-02f, 6.48881216e-03f,
  -7.47030258e-01f, 4.70912047e-02f, 1.18121430e-01f, -7.74735957e-02f, -1.02487579e-01f, 2.49350816e-01f, 2.59710938e-01f, 1.28821298e-01f, 1.12385117e-01f, 1.90527946e-01f,
  1.47771418e-01f, -2.07247213e-02f, 1.67826280e-01f, 1.67489365e-01f, 1.47375837e-01f, 1.92389324e-01f, 3.31575051e-02f, 5.61608262e-02f, -3.68420500e-03f, -2.25718051e-01f,
  -1.20707065e-01f, 3.82905565e-02f, 3.22997153e-01f, -9.39035192e-02f, -1.00393035e-01f, -7.78792873e-02f, 4.69860397e-02f, 1.14067458e-02f, 7.41870478e-02f, 7.21357614e-02f,
  -1.10311769e-01f, -8.06877539e-02f, -4.94826846e-02f, 1.03996724e-01f, 7.17604533e-02f, -8.57593268e-02f, 6.22530617e-02f, 9.43817012e-03f, -7.37978667e-02f, -4.56895493e-02f,
  -9.28951576e-02f, -1.35847718e-01f, -5.67518063e-02f, 7.49367699e-02f, -1.79702193e-02f, 1.03470281e-01f, -4.07895520e-02f, 4.39744024e-03f, 7.23031461e-02f, -6.39973283e-02f,
  9.49157476e-02f, -1.17884418e-02f, 8.39992538e-02f, 5.60277887e-02f, 1.92967758e-01f, 6.17445409e-02f, 6.90743849e-02f, -3.46985273e-02f, 8.59044492e-02f, 3.99502069e-02f,
  6.78386614e-02f, 2.55355593e-02f, 7.43655860e-03f, 8.13497454e-02f, 4.80402680e-03f, 4.95546646e-02f, -7.23758014e-03f, -5.83054265e-04f, 5.60746826e-02f, 2.37686392e-02f,
  5.95160089e-02f, 5.75664565e-02f, -2.78362893e-02f, -2.01057270e-03f, 6.00008480e-02f, -4.57374789e-02f, -7.25492612e-02f, 4.39724810e-02f, 3.66375260e-02f, 3.48938033e-02f,
  -7.09084794e-02f, -3.29417586e-02f, 1.21390641e-01f, 1.00183589e-02f, 1.70154292e-02f, 7.39564821e-02f, 1.00318575e-02f, 3.09312083e-02f, -6.81508109e-02f, 3.12613836e-03f,
  -1.16183400e-01f, 4.58928347e-02f, 1.01900911e-02f, 2.12010834e-02f, -4.00322825e-02f, -8.96027405e-03f, -4.61615995e-02f, -2.93796360e-02f, 2.14276314e-02f, -6.69815242e-02f,
  -8.22880566e-02f, 3.41982692e-02f, -1.27125800e-01f, -2.41151005e-02f, 7.14377686e-02f, 8.91371295e-02f, -5.85821783e-03f, -5.91154024e-02f, 1.88226029e-02f, -4.05770093e-02f,
  3.37882154e-02f, -1.29020214e-01f, 5.33699170e-02f, 9.00422409e-02f, 1.06627077e-01f, 1.59882177e-02f, -1.07167885e-01f, -6.55045956e-02f, -2.29645092e-02f, 1.11749312e-02f,
  3.68355215e-01f, 1.76242515e-01f, 2.97305465e-01f, 3.84302765e-01f, -2.73497850e-02f, -4.59533930e-01f, -1.51500508e-01f, 1.94147229e-01f, 5.27958460e-02f, -2.36895055e-01f,
  4.98394715e-03f, 8.36576670e-02f, -6.97009563e-02f, 1.24720648e-01f, 7.24811628e-02f, -1.11199163e-01f, 1.26738518e-01f, -1.18043676e-01f, 1.83655560e-01f, 9.01737437e-02f,
  1.76799193e-01f, -8.69652480e-02f, 3.11391473e-01f, 1.18545257e-01f, 2.42262021e-01f, 2.43607640e-01f, 2.36376315e-01f, 2.25402862e-02f, 1.55604957e-02f, -1.27787247e-01f,
  -1.57429636e-01f, 9.96399857e-03f, 8.00520852e-02f, -5.80339432e-02f, -4.92206123e-03f, -5.10964952e-02f, -1.69003561e-01f, -3.87848355e-02f, -8.57479051e-02f, -7.95747861e-02f,
  -7.32033104e-02f, -1.03450991e-01f, -2.69981846e-02f, -7.55425990e-02f, -2.48985309e-02f, 8.68379250e-02f, 1.65773928e-02f, 2.54199859e-02f, 3.19981575e-02f, 3.03268004e-02f,
  1.49907112e-01f, -2.83227731e-02f, 1.02126844e-01f, 6.54840022e-02f, 1.72788762e-02f, 6.72169076e-03f, -8.11543167e-02f, 1.00646177e-02f, 4.88544023e-03f, 5.26673868e-02f,
  -4.42435918e-03f, -3.43422480e-02f, 7.05362633e-02f, 5.70347235e-02f, 1.47539685e-02f, -5.43585122e-02f, -5.81955761e-02f, -4.93393950e-02f, -4.38298583e-02f, 9.14536789e-02f,
  1.33368000e-01f, 8.03663656e-02f, 6.01113923e-02f, 2.61976756e-03f, 1.49095403e-02f, 9.48387682e-02f, 3.26512456e-02f, -5.32454066e-02f, 8.96024033e-02f, 8.13650787e-02f,
  7.94902220e-02f, -1.21756189e-01f, 1.40681252e-01f, 1.49891258e-03f, 1.30118635e-02f, -6.96432143e-02f, -8.66148844e-02f, -5.58957234e-02f, 7.14816619e-03f, 7.35398978e-02f,
  -8.43853056e-02f, -8.36343784e-03f, -4.71348763e-02f, -1.60637677e-01f, -1.09984897e-01f, -2.56705377e-02f, -9.79220122e-02f, 8.85069147e-02f, -6.40239567e-02f, -4.20948025e-03f,
  -7.18633458e-02f, -1.52802300e-02f, -1.71104491e-01f, -2.04819385e-02f, -7.60055259e-02f, 3.83586413e-03f, -2.28772331e-02f, 1.55427363e-02f, 1.16292341e-02f, 9.27816983e-03f,
  4.06538323e-02f, -1.66703597e-01f, 2.53041252e-03f, 6.66525885e-02f, -7.20837414e-02f, 1.20512843e-02f, -4.67984676e-02f, 7.67959058e-02f, 1.01190694e-02f, 4.00929451e-02f,
  1.71654254e-01f, -1.34853274e-01f, 3.24240565e-01f, -4.71046269e-02f, -1.01652294e-01f, 9.84348729e-02f, 2.21479490e-01f, -1.64353848e-01f, -3.94788831e-02f, -1.17356248e-01f,
  -1.32201299e-01f, 2.28685826e-01f, 3.47656190e-01f, -1.40398979e-01f, 3.88338506e-01f, 1.99287012e-01f, -1.95242673e-01f, 5.67813814e-02f, -2.50494890e-02f, 1.29201645e-02f,
  -1.06147781e-01f, -3.71466696e-01f, -5.41722849e-02f, -3.52280915e-01f, -1.96174964e-01f, -1.42208695e-01f, -1.37833580e-01f, 1.01005033e-01f, -1.84671476e-01f, 1.00368969e-01f,
  -2.31630236e-01f, -1.64508417e-01f, -1.72555998e-01f, -5.25861382e-02f, -1.61961749e-01f, -1.18013872e-02f, 1.23021141e-01f, 9.57555249e-02f, -1.30998164e-01f, 6.31815121e-02f,
  1.66293770e-01f, 2.51822975e-02f, -1.19240850e-01f, 3.94841330e-03f, -1.38816074e-01f, -1.21081419e-01f, -9.02000517e-02f, -8.02230313e-02f, -7.22596571e-02f, 1.28763467e-01f,
  6.44721836e-02f, 1.04771502e-01f, -1.23905398e-01f, 9.88569707e-02f, -2.62824837e-02f, -1.40800908e-01f, 8.00801367e-02f, 2.00065687e-01f, 3.23208049e-02f, -2.21334584e-02f,
  -1.69361874e-01f, 6.60402328e-02f, -7.52690136e-02f, -7.59461746e-02f, 4.64931950e-02f, -1.28009282e-02f, 6.94571063e-03f, 4.54000682e-02f, 4.16399390e-02f, 2.65305936e-02f,
  6.89123124e-02f, 4.75362241e-02f, 6.06870502e-02f, 1.53327780e-02f, -8.57831389e-02f, -4.93683480e-02f, 9.91631672e-02f, 3.84122692e-02f, -7.96232224e-02f, -8.32426473e-02f,
  -6.79413155e-02f, 1.35281980e-01f, -7.69195706e-02f, 3.16012949e-02f, 1.48941586e-02f, 8.14142525e-02f, -7.28695560e-03f, 6.12947978e-02f, -2.90487185e-02f, 1.01117052e-01f,
  -2.80872703e-01f, -1.25349462e-01f, -7.61899054e-02f, 2.85172425e-02f, 1.61625992e-03f, -1.59881525e-02f, 6.80933669e-02f, 9.64911841e-03f, -1.09970383e-02f, 8.34231377e-02f,
  2.38483530e-02f, 1.10441729e-01f, -2.20474321e-03f, 6.28986806e-02f, 9.66331288e-02f, -4.69316170e-02f, 6.26410320e-02f, -3.66035961e-02f, -3.81056331e-02f, 2.52713077e-02f,
  2.43641268e-02f, 9.28187445e-02f, 4.74145822e-02f, -1.31674111e-01f, -4.33044136e-02f, -3.94563414e-02f, -7.31882639e-03f, 1.49981203e-02f, -6.07097186e-02f, -1.45293968e-02f,
  3.85118872e-01f, 1.46465600e-01f, 3.37899894e-01f, 3.36630642e-01f, 8.54011346e-03f, -3.03010434e-01f, -1.69650406e-01f, 1.39610767e-01f, 3.23884904e-01f, -1.66349590e-01f,
  -5.57868518e-02f, 1.76808760e-01f, -2.20838934e-02f, 5.47954366e-02f, 1.74123883e-01f, -2.83800177e-02f, 2.20699519e-01f, 3.24906185e-02f, 6.50084317e-02f, 1.75608575e-01f,
  1.98012233e-01f, 4.20402698e-02f, 1.99293897e-01f, 1.55552715e-01f, -2.52602417e-02f, 5.34067191e-02f, -3.34659256e-02f, -9.17636305e-02f, 2.16958374e-02f, -1.70225486e-01f,
  -7.94223472e-02f, 3.26304249e-02f, -5.02865165e-02f, -1.41612038e-01f, 3.26886363e-02f, -9.01881531e-02f, -8.85827020e-02f, -9.80701819e-02f, 3.72482613e-02f, -6.50607124e-02f,
  -2.68100351e-02f, -5.06554060e-02f, 1.04972464e-03f, -7.21251778e-03f, -9.66361165e-03f, 1.17390133e-01f, 2.82941833e-02f, 3.30576040e-02f, -5.38815595e-02f, -2.82812174e-02f,
  1.83074594e-01f, -4.75911833e-02f, 9.30604339e-02f, -3.43257003e-02f, 1.06239736e-01f, 3.87737304e-02f, 2.11634208e-02f, -3.01590394e-02f, -1.25299208e-02f, 7.78852850e-02f,
  -4.14758176e-02f, 3.84904705e-02f, 1.45726639e-03f, -1.26407430e-01f, 4.60051000e-02f, 7.03502446e-03f, -7.33457552e-03f, 1.22802118e-02f, 1.18017616e-02f, -9.32425559e-02f,
  -3.40970978e-02f, -9.04857218e-02f, 2.05135229e-03f, -4.27327827e-02f, 2.47767102e-02f, -4.10239846e-02f, -1.67742614e-02f, -1.01683401e-01f, 1.04934564e-02f, 9.97648314e-02f,
  -1.54093402e-02f, 1.59207899e-02f, -5.00106402e-02f, -4.22987454e-02f, -4.97511327e-02f, -4.67131026e-02f, 1.20582115e-02f, 3.86174172e-02f, -1.37654506e-02f, 7.29798824e-02f,
  4.55388874e-02f, 1.97472274e-01f, 6.04532808e-02f, -8.69558156e-02f, 3.45269740e-02f, -6.39889091e-02f, 1.96692273e-01f, -8.62783194e-03f, 1.03423402e-01f, -1.11767724e-02f,
  5.78711033e-02f, 1.29320321e-03f, -6.04151599e-02f, -6.18816633e-03f, -3.03999837e-02f, 8.00015628e-02f, 3.19947745e-03f, 1.04146423e-02f, 6.81511685e-02f, 4.44618380e-03f,
  -5.74740628e-03f, 4.11848612e-02f, 1.11565888e-01f, -2.17694603e-02f, 1.41946031e-02f, -4.65863124e-02f, 2.78249048e-02f, 6.59180284e-02f, -3.58759910e-02f, 7.38289282e-02f,
  1.75899398e-02f, -1.51631042e-01f, -2.51410395e-01f, -8.22849274e-02f, 2.67238123e-03f, 1.23933546e-01f, -9.72904041e-02f, 1.22330878e-02f, -3.63163590e-01f, 1.09714992e-01f,
  1.55737132e-01f, -2.06350178e-01f, -6.22407487e-03f, 3.73121761e-02f, -2.04057153e-02f, -9.90607403e-03f, 1.26616240e-01f, 6.87643662e-02f, -3.67565230e-02f, 2.00865775e-01f,
  4.04054932e-02f, 3.29702228e-01f, -2.81092301e-02f, 2.20034644e-01f, 8.59701484e-02f, 1.27554417e-01f, 1.53848425e-01f, -6.03385307e-02f, 2.25185975e-01f, -7.99657404e-02f,
  3.83631103e-02f, 5.08296639e-02f, -1.18575349e-01f, -1.53659031e-01f, 1.60016343e-01f, 1.83910847e-01f, 8.71010348e-02f, -8.76259711e-03f, -3.50127369e-02f, -5.60057871e-02f,
  1.25355721e-02f, 5.37395701e-02f, -1.78360380e-02f, -2.59111337e-02f, -7.68493041e-02f, -1.18379861e-01f, -1.61539569e-01f, -2.12431736e-02f, -1.23499662e-01f, -3.08529567e-03f,
  -5.67447841e-02f, 4.66809608e-02f, -4.68394868e-02f, 4.62355576e-02f, -6.97337165e-02f, -5.55036664e-02f, -8.51710234e-03f, 9.71117914e-02f, 9.17700306e-03f, 5.38670979e-02f,
  3.19841728e-02f, 2.23983657e-02f, 1.02372497e-01f, -9.76681933e-02f, 9.86536685e-03f, -3.84367369e-02f, -3.90825048e-03f, 6.35962784e-02f, -1.45893529e-01f, 5.12037426e-02f,
  -3.70116644e-02f, -3.16382130e-03f, -2.86590979e-02f, 1.05434686e-01f, 7.48660415e-02f, 3.04265805e-02f, -2.51644831e-02f, -4.25970219e-02f, -6.34423718e-02f, 4.37357314e-02f,
  -3.64148468e-02f, 4.99352301e-03f, 1.86712889e-03f, 1.02517940e-01f, 2.86583032e-04f, -8.57008994e-03f, 2.37978641e-02f, 6.14304170e-02f, -3.58473533e-03f, 1.11056585e-02f,
  1.47599978e-02f, 1.27311185e-01f, -5.22603188e-03f, -9.62831527e-02f, 1.20208235e-02f, 1.10167801e-01f, -6.09432720e-02f, 3.86467539e-02f, 3.54805700e-02f, -1.49911195e-02f,
  2.15447351e-01f, -7.14450888e-03f, 8.25890824e-02f, -4.34459485e-02f, -9.69593152e-02f, 5.17262034e-02f, 2.85200719e-02f, -9.34637189e-02f, -7.53674954e-02f, 1.42158736e-02f,
  9.28301811e-02f, 5.11482544e-02f, -1.08910255e-01f, 4.13556620e-02f, 1.38109699e-02f, 7.77538493e-02f, 6.75773025e-02f, 4.89787906e-02f, 4.81769219e-02f, -7.72031546e-02f,
  -1.70453057e-01f, 4.26646590e-01f, 2.62984000e-02f, 1.28912985e-01f, 8.90886262e-02f, 1.57413691e-01f, 1.10272229e-01f, 8.21280479e-02f, 2.61887848e-01f, 2.75305100e-02f,
  -1.00494660e-01f, 9.71893966e-02f, 7.65365511e-02f, 1.03145521e-02f, 1.16383903e-01f, 3.79458889e-02f, 2.64070809e-01f, 9.21074748e-02f, 9.22920853e-02f, 4.03293408e-02f,
  1.08577251e-01f, -6.14596764e-04f, -2.23908186e-01f, -1.81729689e-01f, -8.52339268e-02f, -1.63878962e-01f, -1.14580505e-01f, -2.92203408e-02f, -1.32603526e-01f, 7.02820495e-02f,
  -5.94741898e-03f, 2.91085038e-02f, -1.21643126e-01f, -1.71444714e-02f, -1.46029621e-01f, -7.31292889e-02f, -1.48909599e-01f, 3.19692716e-02f, -1.21890195e-01f, 5.97632676e-02f,
  7.82073364e-02f, -1.39259622e-02f, 4.72189747e-02f, 1.64785853e-03f, 4.03544214e-03f, -8.18892103e-03f, 5.22899628e-02f, -1.28528789e-01f, 7.01095238e-02f, -3.10137905e-02f,
  -1.12987898e-01f, -7.71909729e-02f, 1.10834837e-02f, 8.86151195e-02f, -3.57340798e-02f, 9.31361839e-02f, 3.63696441e-02f, 5.77909462e-02f, 1.22050963e-01f, 2.67522056e-02f,
  1.15473971e-01f, 7.47057572e-02f, -1.66471414e-02f, -1.44061998e-01f, 5.51310368e-02f, -4.84184287e-02f, 7.19962791e-02f, -7.30694234e-02f, 1.03709847e-02f, -8.02730694e-02f,
  -1.32074505e-01f, -3.21787894e-02f, 7.04957172e-02f, -4.62868474e-02f, 1.00416273e-01f, -8.33722278e-02f, 3.69075760e-02f, 1.93184484e-02f, 9.42418054e-02f, -9.49568897e-02f,
  5.59570007e-02f, 8.32219515e-03f, -6.86668679e-02f, -1.88367569e-03f, -9.15148333e-02f, -1.96069591e-02f, 3.51188146e-02f, -1.09373793e-01f, -7.99101964e-02f, 9.12798792e-02f,
  2.90499926e-01f, 4.95526582e-01f, 1.00322768e-01f, -3.33718024e-02f, 7.39760639e-04f, -8.21533427e-02f, 4.28591482e-02f, 4.38154861e-02f, 1.75442323e-01f, 3.64891514e-02f,
  -4.43294272e-03f, 2.10881289e-02f, 6.47960678e-02f, -9.16307420e-02f, 8.94424468e-02f, 5.75564578e-02f, 9.56688970e-02f, -5.24233319e-02f, 1.91386983e-01f, 5.64106703e-02f,
  -3.25998925e-02f, 8.08171779e-02f, -2.27052160e-02f, 1.11159764e-01f, 5.78196868e-02f, -8.23909268e-02f, 6.28313050e-02f, -4.97516058e-03f, -1.83470140e-03f, 1.84839264e-01f,
  7.08305240e-02f, -1.68522775e-01f, 3.05551607e-02f, 3.56036518e-03f, 2.36980811e-01f, -9.89896283e-02f, -3.57908979e-02f, 4.35087755e-02f, 3.55172157e-02f, -3.83850753e-01f,
  -6.75588846e-02f, -4.41066287e-02f, -7.84585848e-02f, -1.44870862e-01f, 1.91061586e-01f, 1.31212994e-01f, -7.13470951e-02f, -1.21082500e-01f, 1.53082445e-01f, -7.49889836e-02f,
  1.92310944e-01f, -1.83793362e-02f, 6.88269138e-02f, 1.49908885e-02f, -5.18515855e-02f, -1.63187623e-01f, 1.86780952e-02f, 1.99272446e-02f, -1.89362481e-01f, 1.46492366e-02f,
  -1.26134679e-01f, -6.59537092e-02f, -2.19859183e-02f, -1.04151569e-01f, -3.85063738e-02f, -8.37299302e-02f, -1.34792909e-01f, -5.36392480e-02f, -1.65383760e-02f, -9.69900861e-02f,
  -1.41027838e-01f, -9.53782424e-02f, -2.83852220e-02f, -1.01023400e-02f, -1.66134499e-02f, -7.18852356e-02f, 8.73087198e-02f, -8.72035846e-02f, -4.64615114e-02f, 1.00448534e-01f,
  1.72431648e-01f, -1.07703030e-01f, -3.25680943e-03f, -4.64043915e-02f, 3.95777784e-02f, 1.53990043e-02f, 6.90331161e-02f, -1.74498893e-02f, 1.03962325e-01f, 1.29817519e-02f,
  1.06643789e-01f, 1.77413434e-01f, 8.72242004e-02f, -1.84393693e-02f, 9.22029614e-02f, 5.68670081e-03f, -9.84860957e-02f, -9.54976492e-03f, -5.18098846e-02f, -8.96656066e-02f,
  -4.41671386e-02f, -3.89333777e-02f, 1.05910935e-01f, -4.74249199e-02f, -5.64335212e-02f, 6.62162304e-02f, -5.33232093e-02f, -5.84024824e-02f, 1.20382924e-02f, 1.12555407e-01f,
  6.60216361e-02f, 4.90013100e-02f, -4.67822552e-02f, -6.41965540e-03f, -1.83789775e-01f, 6.75327284e-03f, -3.31118070e-02f, -2.46893033e-01f, 5.57233728e-02f, 7.02618361e-02f,
  -2.81451583e-01f, -3.04900289e-01f, 1.20517975e-02f, -2.35723540e-01f, -1.28708780e-01f, -1.11414567e-01f, -2.53669489e-02f, 1.40920933e-02f, -9.23708230e-02f, 6.67497218e-02f,
  -3.46004516e-02f, -1.78277865e-01f, -4.34192941e-02f, -2.45214514e-02f, 4.92147096e-02f, -1.76076870e-02f, -1.27702802e-01f, -1.07950732e-01f, -5.82279898e-02f, 1.48006212e-02f,
  -1.18325926e-01f, -6.59580380e-02f, 5.71502335e-02f, 3.56779508e-02f, 3.13102384e-03f, 1.98077057e-02f, 1.24008156e-01f, 4.78303917e-02f, -3.74862663e-02f, 1.00594193e-01f,
  -4.55840766e-01f, 2.34165788e-01f, -1.95448950e-01f, -4.95875999e-02f, -2.03149140e-01f, 2.55867749e-01f, 1.82800144e-01f, -1.19584009e-01f, -1.78387046e-01f, 2.18063056e-01f,
  1.74081415e-01f, -2.67671198e-01f, 9.19407904e-02f, 1.77266181e-01f, -1.08316921e-01f, 3.19465846e-01f, 2.23778591e-01f, 1.21208854e-01f, -6.77842065e-04f, -5.02231717e-03f,
  -8.74733999e-02f, 2.37515613e-01f, 1.41595781e-01f, 9.22896639e-02f, 8.24636035e-03f, -1.27314419e-01f, -6.88863024e-02f, -1.26306757e-01f, 4.30901302e-03f, -1.88484311e-01f,
  6.40324205e-02f, -9.24270675e-02f, -3.69213000e-02f, -2.75944341e-02f, -5.05060703e-02f, -2.06055474e-02f, -1.68405809e-02f, -6.71094432e-02f, -1.18382990e-01f, -5.43822013e-02f,
  -5.09061757e-03f, 3.24494927e-03f, -3.90738323e-02f, -8.52248147e-02f, -8.59896168e-02f, -1.95369646e-02f, 5.41548207e-02f, -9.74601228e-03f, 1.21378228e-01f, 8.38669166e-02f,
  -1.50068216e-02f, 1.69574916e-02f, -2.05442347e-02f, 6.23966791e-02f, -5.76726235e-02f, 1.15189388e-01f, 3.94537561e-02f, -5.22395894e-02f, -2.37446390e-02f, -7.97905028e-02f,
  -7.75305107e-02f, 4.07398492e-02f, 1.15643017e-01f, -5.63343316e-02f, -2.58682203e-02f, 5.94006255e-02f, 3.15905139e-02f, 7.04313815e-02f, -8.83223638e-02f, 1.20165817e-01f,
  -3.22938524e-02f, 7.95165226e-02f, 2.71575972e-02f, 2.16235984e-02f, 1.77879352e-02f, -1.12655144e-02f, -3.92336957e-02f, -2.47646905e-02f, 3.46987583e-02f, 2.55235061e-02f,
  1.33253159e-02f, -1.47023290e-01f, -1.77766643e-02f, 7.62261301e-02f, 7.74467066e-02f, -5.81905432e-02f, -1.45217553e-01f, 1.57688279e-02f, 1.16168343e-01f, -3.51542383e-02f,
  1.22346073e-01f, -7.27165937e-02f, -7.15193450e-02f, 1.25928614e-02f, 2.72534862e-02f, 1.07559357e-02f, 2.16222331e-02f, -3.07675153e-02f, 3.09612006e-02f, -4.42978293e-02f,
  -2.48288661e-02f, -3.00411303e-02f, 5.03248535e-02f, -2.69226171e-02f, -6.65054470e-02f, 6.95542758e-03f, 1.49467975e-01f, -1.25659667e-02f, 2.93140346e-03f, -2.07812618e-02f,
  4.87569114e-03f, 8.35156292e-02f, -1.98510848e-02f, 1.16187958e-02f, 1.76247023e-02f, 5.21722101e-02f, -1.39868990e-01f, 1.77255254e-02f, -8.00212100e-03f, -2.08109748e-02f,
  1.44975692e-01f, -2.56295055e-01f, -1.69947937e-01f, -2.87555188e-01f, -4.58796732e-02f, -1.67335514e-02f, -2.09952444e-01f, -2.67247856e-01f, -2.90017158e-01f, -3.87354419e-02f,
  1.13189025e-02f, -1.19987495e-01f, -1.57336872e-02f, -2.16392308e-01f, -1.23041674e-01f, 3.67153250e-02f, -1.28867120e-01f, -7.54417628e-02f, -1.26010582e-01f, 1.47951441e-02f,
  -3.75785753e-02f, -7.73957893e-02f, -8.30425248e-02f, 4.93895598e-02f, -6.57110214e-02f, -2.95911264e-02f, 1.00886196e-01f, -2.90392637e-02f, -1.89524889e-02f, -1.13486692e-01f,
  2.27388758e-02f, 5.94858937e-02f, -3.75919603e-02f, -6.68657273e-02f, 8.12493544e-03f, 6.25770763e-02f, 9.28989947e-02f, -2.01203134e-02f, -3.23821343e-02f, -7.49016181e-02f,
  4.84530106e-02f, 5.97820021e-02f, -1.18531451e-01f, 2.17944141e-02f, -5.61016463e-02f, -4.46725637e-02f, -7.38290027e-02f, 2.45732022e-03f, -4.37361263e-02f, 1.19980790e-01f,
  -6.59155622e-02f, -3.49736633e-03f, -7.95978382e-02f, -4.58090752e-02f, -1.45251468e-01f, -5.00567891e-02f, 7.22751096e-02f, 8.05105120e-02f, 1.02337571e-02f, -6.47002012e-02f,
  1.06094360e-01f, 1.10086173e-01f, 2.50168126e-02f, 2.20572166e-02f, -5.53722121e-02f, 3.82263400e-02f, 6.96094558e-02f, 7.41930455e-02f, -6.37292862e-02f, 1.37427021e-02f,
  -2.76263375e-02f, -1.23880915e-01f, 4.51808535e-02f, 8.49351659e-02f, -8.34736042e-03f, 1.27766535e-01f, 9.21706557e-02f, -5.67783639e-02f, -7.09673017e-02f, -9.57589373e-02f,
  1.06802709e-01f, -3.64496112e-02f, -1.82544142e-02f, 9.37003791e-02f, 1.21328048e-01f, -1.00428477e-01f, -8.29002187e-02f, 9.98449177e-02f, 5.36972135e-02f, -2.51431279e-02f,
  -4.01293673e-02f, 1.88262910e-02f, -9.57474038e-02f, -8.58300328e-02f, -4.57062665e-03f, 1.15348613e-02f, -1.36970617e-02f, -1.53518662e-01f, -4.79697175e-02f, -4.42932248e-02f,
  1.81241557e-01f, -3.73370461e-02f, 5.39091900e-02f, -5.99574931e-02f, -1.28392980e-01f, -1.42139178e-02f, 2.30399668e-02f, 5.17092720e-02f, -1.90383177e-02f, 9.96579751e-02f,
  -1.30927209e-02f, 4.19882052e-02f, -9.55786556e-02f, -7.15418532e-02f, -8.84548277e-02f, 2.03045905e-02f, 3.96602601e-02f, 7.07800910e-02f, 6.28922284e-02f, -5.59076034e-02f,
  -3.26684266e-01f, 2.09370274e-02f, -2.83604354e-01f, -2.67537571e-02f, -2.88599938e-01f, -2.09922060e-01f, -1.00025341e-01f, -2.62949858e-02f, 1.34627640e-01f, 2.13646650e-01f,
  1.00854248e-01f, 3.56192887e-02f, 2.53953755e-01f, -5.86851325e-04f, -5.53314313e-02f, 2.08349153e-01f, -2.19182760e-01f, -7.94263557e-03f, 2.76000127e-02f, -1.03807263e-01f,
  -1.17305197e-01f, 1.63167134e-01f, -5.42036854e-02f, 3.17216143e-02f, -2.77421743e-01f, -6.62505478e-02f, -5.69001213e-02f, -1.09206624e-01f, -2.13707358e-01f, -9.01301205e-02f,
  -1.88071698e-01f, 3.11629176e-02f, -5.03923446e-02f, -1.84993558e-02f, -2.27244318e-01f, -1.30413780e-02f, -6.14077635e-02f, 3.70893106e-02f, 2.86426619e-02f, -5.28550036e-02f,
  -7.70912645e-03f, -5.79649955e-02f, 4.19706218e-02f, 8.74050036e-02f, -6.27814680e-02f, -4.27563526e-02f, -1.00575306e-01f, -1.13043077e-01f, -6.09256851e-04f, -6.84842691e-02f,
  -1.41637832e-01f, -1.69338763e-01f, -1.19571157e-01f, -6.80508167e-02f, -1.05051354e-01f, -2.24661361e-02f, -4.95883562e-02f, -4.80956286e-02f, -1.83424160e-01f, -1.72141746e-01f,
  -1.10683974e-03f, 1.02652065e-01f, 2.83379182e-02f, 9.55633353e-03f, -4.90490310e-02f, -1.02540158e-01f, -9.57581401e-03f, 1.03432732e-02f, -4.14709561e-02f, -1.36580849e-02f,
  4.29754853e-02f, -1.39256855e-02f, -2.72584036e-02f, -3.88471633e-02f, -7.36064315e-02f, -6.28072694e-02f, 4.71791551e-02f, -5.42541184e-02f, -4.42911424e-02f, -2.17502322e-02f,
  6.42625615e-02f, 5.68871328e-04f, -8.67162272e-03f, 7.28696934e-04f, -6.14115186e-02f, 3.41336355e-02f, -1.12728057e-02f, -1.54017732e-01f, -2.82678474e-03f, -4.08719592e-02f,
  -2.40596578e-01f, -2.18789861e-01f, 1.21035524e-01f, -9.49942097e-02f, 1.45117147e-02f, -1.03256822e-01f, 6.23126328e-02f, -1.26648322e-01f, 1.16675170e-02f, -6.47814618e-03f,
  -5.17058484e-02f, -1.95874590e-02f, -8.11709985e-02f, 7.70979971e-02f, 6.02300912e-02f, -9.36364755e-02f, 5.91040775e-02f, 3.16762663e-02f, -8.20970014e-02f, -6.61379658e-03f,
  -4.12669964e-02f, -1.31208953e-02f, 2.20950283e-02f, 3.91653404e-02f, -4.31126282e-02f, -3.60410102e-02f, -6.52779639e-02f, -3.07346378e-02f, -1.73118070e-01f, -2.02916507e-02f,
  1.05168015e-01f, -2.77324647e-01f, -2.24127956e-02f, -2.46179536e-01f, -4.23673727e-02f, -1.29358515e-01f, -8.92228261e-02f, -3.91055167e-01f, -2.35881895e-01f, -3.28078985e-01f,
  -1.67835206e-02f, 2.01421931e-01f, 1.14266790e-01f, -1.96332514e-01f, 4.27256435e-01f, 2.09053248e-01f, -1.58995435e-01f, 9.70965326e-02f, 2.27757730e-02f, -7.00851753e-02f,
  1.90723706e-02f, -1.12303555e-01f, 2.04424694e-01f, -2.21638784e-01f, -1.18750863e-01f, -9.42266434e-02f, 4.44699042e-02f, 1.94251955e-01f, -2.12467298e-01f, 1.31012142e-01f,
  3.01437397e-02f, -9.04225037e-02f, 3.25630344e-02f, -1.37016801e-02f, -5.65313697e-02f, 2.47907871e-03f, 8.86713862e-02f, 1.31051555e-01f, -1.15386276e-04f, -3.74275930e-02f,
  1.36776613e-02f, 2.04306897e-02f, -8.76234099e-02f, 1.29574403e-01f, -1.09720983e-01f, -1.20847993e-01f, -7.41954297e-02f, -5.22212647e-02f, -6.50417432e-02f, 2.26067682e-03f,
  2.37900969e-02f, 2.89541460e-03f, -1.01954393e-01f, -6.08372018e-02f, -5.70365563e-02f, -1.08850114e-01f, 5.77335767e-02f, 8.84466171e-02f, 3.35758268e-05f, -6.58098385e-02f,
  5.25173321e-02f, 8.38273168e-02f, -4.18708846e-02f, -2.85350736e-02f, 1.87899284e-02f, -1.00253195e-01f, -3.52489762e-02f, -4.86191781e-03f, -3.09369527e-02f, -5.33397347e-02f,
  2.68646255e-02f, 4.55846414e-02f, -3.03816423e-02f, -8.27453136e-02f, -2.50567514e-02f, 5.40080070e-02f, 1.18795559e-01f, -7.17251422e-03f, -1.15789443e-01f, -8.28910097e-02f,
  1.69148333e-02f, 6.12578727e-02f, -2.57822685e-02f, -1.70801226e-02f, 1.96030531e-02f, 2.19266880e-02f, -6.02457263e-02f, -4.54048924e-02f, 5.76471090e-02f, 2.16474999e-02f,
  -6.94362493e-03f, -9.66190323e-02f, -5.69795333e-02f, -2.62719188e-02f, 7.06886500e-02f, 4.74302582e-02f, 1.19573832e-03f, -7.64155015e-02f, -2.84196399e-02f, -6.99613243e-03f,
  -9.18903798e-02f, -3.47198695e-02f, -4.67076972e-02f, 4.21553478e-02f, 4.07062238e-03f, -1.01730809e-01f, 9.59969908e-02f, -2.93083657e-02f, -8.23926479e-02f, -2.41179559e-02f,
  -3.23580690e-02f, 3.71785164e-02f, 7.76631758e-02f, -4.31954674e-02f, -1.27145872e-01f, -2.87258439e-02f, 1.51816839e-02f, 1.19622862e-02f, 1.97147932e-02f, -8.33311677e-02f,
  2.97423840e-01f, -3.59763712e-01f, -2.12289423e-01f, 3.79001349e-02f, -4.93106283e-02f, -3.41893017e-01f, -4.90614384e-01f, 1.09638125e-02f, -2.20698994e-02f, -2.16478258e-01f,
  -6.86229765e-02f, -1.28459176e-02f, -2.22586408e-01f, 3.68010104e-02f, 3.77663642e-01f, -2.95843929e-02f, 1.85733646e-01f, -6.21449910e-02f, 1.64756447e-01f, 4.60811600e-04f,
  2.44786173e-01f, 2.60090768e-01f, 2.32174024e-01f, 2.35490069e-01f, -1.25272451e-02f, 2.15307415e-01f, 3.35668594e-01f, -5.01267612e-02f, 1.63984314e-01f, 1.51228428e-01f,
  -4.83308397e-02f, 7.04749813e-03f, -7.59410560e-02f, 2.88594756e-02f, -6.39779493e-02f, -1.39770508e-01f, 4.15795930e-02f, 4.32588793e-02f, 5.04915789e-02f, -1.48452483e-02f,
  -8.19387659e-02f, 1.64920375e-01f, -2.02879831e-02f, 1.44495681e-01f, 2.33348515e-02f, 9.44668800e-02f, 3.20800617e-02f, -7.85549544e-03f, 6.10633940e-03f, 8.73090178e-02f,
  -4.69294265e-02f, -1.58746378e-03f, 2.54082382e-02f, 3.46379019e-02f, 5.06198173e-03f, 4.28950340e-02f, 2.37932731e-03f, -1.13865852e-01f, -4.85222600e-02f, 5.60693368e-02f,
  -4.62400466e-02f, -1.45778889e-02f, -2.90630199e-02f, 4.00997475e-02f, -1.94885526e-02f, 1.43029233e-02f, 1.30184308e-01f, -3.01010944e-02f, 7.10981339e-02f, 9.26842447e-03f,
  -2.60729939e-02f, 3.00747529e-02f, 4.74023297e-02f, -2.78707016e-02f, 7.85183068e-03f, -5.55071421e-03f, 1.49109010e-02f, -4.24201228e-03f, -5.81216849e-02f, -1.26866400e-01f,
  -2.22453140e-02f, 9.71723124e-02f, -1.03564695e-01f, 3.81102450e-02f, -3.70644528e-04f, -4.03592698e-02f, 7.95187950e-02f, 4.15798230e-03f, -3.33336294e-02f, -5.31406701e-02f,
  -8.69827718e-02f, -7.75234327e-02f, -7.24548027e-02f, -3.39034176e-03f, -6.23019561e-02f, -8.40088427e-02f, -9.29917581e-03f, 3.97169357e-03f, 5.78782000e-02f, 6.61182031e-02f,
  -1.25175379e-02f, 1.45068588e-02f, -8.35390911e-02f, 5.08615561e-02f, -2.91396640e-02f, 1.62319764e-02f, -4.16289084e-02f, 1.87158436e-02f, -6.38722628e-02f, 4.16033119e-02f,
  -1.52011998e-02f, -1.74250603e-01f, 1.90876669e-03f, -9.45262909e-02f, -6.91840649e-02f, 3.21337953e-02f, 8.95626657e-03f, 7.27929920e-02f, 1.20344751e-01f, 4.04300867e-03f,
  3.73324573e-01f, -2.47409008e-02f, 1.16388857e-01f, 2.79956937e-01f, 2.87661046e-01f, 1.66082352e-01f, 3.52542728e-01f, 1.48080632e-01f, 5.62638402e-01f, -1.47060543e-01f,
  -5.67436777e-02f, -1.53507531e-01f, -9.32469815e-02f, -7.77665749e-02f, 1.01689845e-01f, 9.76809021e-03f, 3.80547829e-02f, 2.12602764e-02f, 9.22075883e-02f, 1.93188097e-02f,
  2.32033715e-01f, -5.21741584e-02f, -2.40069002e-01f, -2.40856618e-01f, -1.05832644e-01f, -9.03449506e-02f, -4.22081649e-01f, -1.61168482e-02f, -2.80152291e-01f, -2.26732716e-03f,
  9.89122614e-02f, 8.55010152e-02f, 3.13723758e-02f, 3.86923342e-03f, 5.04342727e-02f, -4.55589369e-02f, -3.33718620e-02f, -5.16667254e-02f, 1.03133224e-01f, 3.64945345e-02f,
  5.81030995e-02f, 5.84483556e-02f, 6.78690374e-02f, -2.62225159e-02f, 1.93720341e-01f, -3.73672731e-02f, 2.05364004e-02f, -2.10074317e-02f, -6.12399764e-02f, -3.42914984e-02f,
  1.92794241e-02f, 3.16294357e-02f, 6.00197949e-02f, -8.95634145e-02f, 4.95442795e-03f, 4.04680148e-02f, 4.30194773e-02f, -1.13230430e-01f, -6.68242052e-02f, 3.25449742e-02f,
  1.77050177e-02f, 1.66388731e-02f, -7.38818347e-02f, -1.47747219e-01f, -1.24476971e-02f, 8.30228478e-02f, 3.69543433e-02f, -1.41471261e-02f, 9.35952291e-02f, -1.46799264e-02f,
  -2.54525878e-02f, -4.31706943e-02f, 9.84894205e-03f, 7.21830651e-02f, 5.76619357e-02f, 4.62392569e-02f, -4.31690104e-02f, -5.68768792e-02f, 8.06368738e-02f, 2.24451572e-02f,
  3.06892376e-02f, 5.14439717e-02f, -9.48996767e-02f, -2.90276632e-02f, -1.43279685e-02f, 3.17297354e-02f, -1.11541711e-02f, -1.12469450e-01f, 3.03657260e-03f, -7.03267381e-02f,
  -1.15317050e-02f, 3.05625191e-03f, -6.21464141e-02f, -4.40720506e-02f, -8.50888863e-02f, -5.13835736e-02f, 7.64009282e-02f, -4.18867953e-02f, 4.63684350e-02f, 3.03220563e-02f,
  -9.13387630e-03f, 6.82553323e-03f, 7.50026777e-02f, -3.23921517e-02f, 4.31343392e-02f, 2.33759657e-02f, -3.71735133e-02f, 3.53156030e-02f, 8.15576613e-02f, -9.89875942e-02f,
  -7.16785267e-02f, -3.09509109e-03f, -1.95831191e-02f, 1.00584857e-01f, 5.59879169e-02f, -5.24637997e-02f, 8.06230493e-03f, -7.29451701e-02f, -6.30510598e-02f, 8.80654249e-03f,
  1.39619946e-01f, 8.78098793e-03f, -2.79842257e-01f, 4.33592312e-02f, -1.20620839e-01f, 2.76142061e-01f, 1.52815700e-01f, -3.21875177e-02f, -1.02017857e-01f, 2.22896695e-01f,
  2.65286505e-01f, -1.01711579e-01f, 2.93056760e-02f, 3.21215987e-01f, 1.21127248e-01f, 7.61335045e-02f, 2.54285216e-01f, 2.19996393e-01f, -1.40809581e-01f, 1.18863463e-01f,
  1.96925690e-03f, 3.72430354e-01f, 3.39212939e-02f, 2.34912448e-02f, 7.86210969e-02f, -2.50626087e-01f, 6.49729297e-02f, -2.36353189e-01f, 4.45793644e-02f, -3.90877239e-02f,
  1.09127462e-01f, -2.53388453e-02f, -6.96614459e-02f, 4.86368723e-02f, -3.24536934e-02f, -2.64044646e-02f, 2.03334969e-02f, 3.86851728e-02f, -1.17264286e-01f, 3.24640051e-02f,
  5.62559888e-02f, -3.60096171e-02f, 2.06253934e-03f, -1.08183408e-02f, -2.68457155e-03f, -3.97350118e-02f, -3.65127064e-03f, -3.23172882e-02f, -6.59593148e-03f, -2.24394016e-02f,
  -6.55870363e-02f, 1.16935289e-02f, 8.26888776e-04f, -5.57663012e-03f, -6.35527968e-02f, 2.36061998e-02f, -1.23952255e-02f, -6.37979358e-02f, -5.57761341e-02f, 1.32779479e-02f,
  6.34907633e-02f, 2.91948603e-03f, 2.67202575e-02f, 8.14277530e-02f, 5.76012116e-03f, 5.53015321e-02f, 1.04453474e-01f, 6.71931058e-02f, 2.47556940e-02f, 2.54875347e-02f,
  -1.11334890e-01f, -1.82621963e-02f, 2.67146509e-02f, 2.90539884e-03f, 2.65626591e-02f, 2.96288636e-02f, -3.33299004e-02f, -2.04158109e-03f, -2.19952762e-02f, -9.02538523e-02f,
  4.67126034e-02f, -8.51906687e-02f, -4.62101959e-02f, 5.00500426e-02f, 3.76040153e-02f, -9.85177793e-03f, 3.18133384e-02f, 3.39274816e-02f, -5.54082952e-02f, -4.37259860e-02f,
  2.56481767e-02f, -4.50983495e-02f, 5.98394461e-02f, 3.05288527e-02f, -8.74465182e-02f, 5.44467345e-02f, -1.98094342e-02f, 1.64302613e-03f, -4.67662252e-02f, -2.58679572e-03f,
  8.12529866e-03f, 5.31646125e-02f, -4.52952906e-02f, -4.89388518e-02f, -1.05901115e-01f, 1.77141447e-02f, 1.02768295e-01f, -8.94866362e-02f, -1.13997355e-01f, -6.71747550e-02f,
  4.01740707e-02f, 2.24256497e-02f, -1.02428652e-01f, -2.20515914e-02f, 1.00337766e-01f, 5.58367260e-02f, -3.83759961e-02f, -4.84890565e-02f, 6.26432300e-02f, 3.23062874e-02f,
  -7.35935047e-02f, -1.66948006e-01f, -2.42741078e-01f, -7.19975680e-02f, -6.47117272e-02f, -2.97976732e-01f, -2.21059352e-01f, -1.70607999e-01f, 2.25439053e-02f, 6.67584762e-02f,
  -8.72751102e-02f, 2.47931868e-01f, 1.22080622e-02f, -7.42603913e-02f, 6.92858733e-03f, 1.79339811e-01f, -2.89252788e-01f, -2.68366467e-02f, 3.79349366e-02f, -1.83645487e-01f,
  -1.20846860e-01f, -4.31748442e-02f, -7.69181922e-02f, -1.77633032e-01f, -2.78025776e-01f, -1.52208492e-01f, 1.24552742e-01f, 1.09195383e-02f, -3.92903313e-02f, -1.06336307e-02f,
  -1.46914512e-01f, 5.05316779e-02f, -3.68975103e-02f, 2.01028027e-02f, -2.15604156e-01f, 8.80398825e-02f, 1.94176771e-02f, 1.88274980e-01f, 1.29289418e-01f, 7.15755299e-02f,
  7.68987909e-02f, -6.47204444e-02f, -3.53479497e-02f, 6.61455914e-02f, 1.46056293e-02f, 2.55493186e-02f, -3.64524908e-02f, -1.50391757e-01f, 9.25568566e-02f, 1.17480438e-02f,
  -4.48639877e-02f, 9.51396078e-02f, -7.43960291e-02f, 2.80269347e-02f, 1.37787275e-02f, 1.65549032e-02f, 1.17417043e-02f, -4.95406128e-02f, -6.22862503e-02f, -5.68810944e-03f,
  -1.15863673e-01f, 8.09579268e-02f, 4.54292111e-02f, -2.35644374e-02f, 3.46392281e-02f, -9.67175588e-02f, 2.62972079e-02f, 4.66345400e-02f, 3.21512148e-02f, 6.53401017e-02f,
  4.37055342e-02f, 3.44434530e-02f, 4.38793115e-02f, 2.17063515e-03f, 4.08577397e-02f, 2.58992868e-03f, -5.13683371e-02f, -2.46327650e-02f, -1.97118148e-01f, -1.70368835e-01f,
  1.54177457e-01f, 1.96072217e-02f, -3.75239961e-02f, -6.27792105e-02f, -1.00307025e-01f, 3.06759099e-03f, -3.48086730e-02f, -1.28149927e-01f, 1.01847954e-01f, -7.53023699e-02f,
  -7.17964321e-02f, -2.15059239e-02f, 4.67379317e-02f, 2.83900537e-02f, -2.71446556e-02f, -8.48664790e-02f, 1.89780630e-02f, -2.52537634e-02f, 3.96734774e-02f, 6.67523593e-02f,
  -3.46078649e-02f, -4.18264456e-02f, -6.28810525e-02f, 7.49915838e-02f, -1.80095788e-02f, 4.98824306e-02f, 3.27836946e-02f, -3.50294150e-02f, 2.41775271e-02f, 1.58992726e-02f,
  1.77477784e-02f, -2.09658290e-03f, 4.37167399e-02f, 8.43679607e-02f, 6.27773255e-02f, 1.18212402e-01f, -4.13982496e-02f, -3.09516210e-02f, 1.93144511e-02f, 1.07091069e-02f,
  -6.94618896e-02f, -1.08038321e-01f, -3.14976841e-01f, -1.77228332e-01f, -1.40067106e-02f, -2.61276215e-01f, -2.38198385e-01f, -4.16534990e-02f, 1.26484903e-02f, 5.68772294e-02f,
  8.88732844e-04f, -1.04583472e-01f, 2.12402210e-01f, -4.02003050e-01f, -1.87406823e-01f, 5.22325113e-02f, -4.20443356e-01f, -1.97766095e-01f, 2.71734595e-02f, -2.69213766e-01f,
  8.40401649e-03f, -8.09745491e-02f, -3.30442041e-01f, 4.36083376e-02f, -1.99479043e-01f, 9.68326535e-03f, 9.83320698e-02f, 1.01337940e-01f, -1.29644066e-01f, 3.67943794e-02f,
  -9.78127569e-02f, 1.23099856e-01f, -1.18210100e-01f, -4.06372063e-02f, -2.65363958e-02f, -1.14309348e-01f, -5.17183170e-02f, 4.90348749e-02f, 7.48149231e-02f, 8.75613987e-02f,
  8.69369693e-03f, 1.20611247e-02f, 1.49630690e-02f, 4.01392356e-02f, -1.64572895e-02f, -1.80872232e-02f, 5.77890649e-02f, 2.40244921e-02f, -4.07315642e-02f, -5.56262173e-02f,
  -1.05040349e-01f, -7.68342242e-02f, -7.79614002e-02f, 4.85545844e-02f, 2.35783458e-02f, -1.23092989e-02f, -5.40280491e-02f, -6.22756928e-02f, -1.60789099e-02f, -3.47480737e-02f,
  8.17464888e-02f, -7.28504965e-04f, -8.39929376e-03f, -3.29556614e-02f, 9.27583650e-02f, 7.52603449e-03f, 8.51085410e-02f, -2.46296152e-02f, -5.48250740e-03f, -1.63699966e-02f,
  1.43685918e-02f, 7.16283321e-02f, 1.03423692e-01f, 3.26761454e-02f, -3.30370814e-02f, -7.02544227e-02f, 5.15770353e-02f, 2.67407391e-02f, -8.36411084e-04f, 6.10328540e-02f,
  8.44921246e-02f, 1.98174152e-03f, -5.70646441e-03f, 1.53465131e-02f, -3.11330557e-02f, 1.77102890e-02f, 1.18237831e-01f, -8.77747983e-02f, -2.34401263e-02f, 1.57140978e-02f,
  -9.10774097e-02f, -3.13434862e-02f, -3.01145669e-02f, 9.65417624e-02f, -5.27023384e-03f, -1.30771875e-01f, 1.66552968e-03f, 1.67293753e-02f, -1.39323184e-02f, 3.78108583e-02f,
  -6.89340234e-02f, -3.81476842e-02f, 3.55032347e-02f, 2.94410791e-02f, 7.95409828e-02f, 1.18219173e-02f, -6.18350953e-02f, 9.62597653e-02f, -5.83652705e-02f, 1.15486220e-01f,
  -6.81827664e-02f, -8.56276602e-03f, 5.22012375e-02f, 6.21227967e-03f, 8.81681144e-02f, 4.90251631e-02f, -3.84693593e-02f, -6.67504519e-02f, 7.90028572e-02f, -4.94516268e-03f,
  -7.94828176e-01f, 3.37434232e-01f, -3.92315462e-02f, -1.11966185e-01f, -5.86640798e-02f, -4.06641746e-04f, -3.60669345e-02f, 7.16704875e-02f, -6.63677305e-02f, 1.71124205e-01f,
  4.52169217e-02f, -1.22944355e-01f, 1.25099242e-01f, 1.31898537e-01f, -2.20424995e-01f, 1.59918785e-01f, -8.00307468e-02f, -8.86254385e-02f, 9.11436900e-02f, 4.52714674e-02f,
  -7.60708470e-04f, 2.23337352e-01f, 5.65883145e-03f, 2.55709112e-01f, -4.41529453e-02f, -5.30163012e-02f, -1.17966674e-01f, 1.57196686e-01f, -8.91322643e-02f, 1.11944415e-02f,
  -3.40942562e-01f, -1.54520765e-01f, -2.88194597e-01f, -1.96894154e-01f, -1.79044262e-01f, -4.20117490e-02f, -9.42605957e-02f, -7.10514432e-04f, -6.29789680e-02f, -3.59882638e-02f,
  -5.80306444e-03f, 2.26369291e-03f, -4.37946357e-02f, 8.99785981e-02f, -4.08376195e-02f, -8.59166980e-02f, 2.49427259e-02f, 5.48919924e-02f, -3.41922604e-02f, 7.28667378e-02f,
  6.76341429e-02f, -6.37678877e-02f, -5.36099523e-02f, 4.68408829e-03f, -5.04402667e-02f, -8.67575500e-03f, -3.90151516e-02f, -3.39942947e-02f, -1.63249746e-01f, -4.75356095e-02f,
  8.53268653e-02f, -2.09863093e-02f, -6.66531250e-02f, 7.33756423e-02f, 1.13843292e-01f, 7.12175593e-02f, 1.33796399e-02f, -3.36792842e-02f, -3.17037553e-02f, 2.30874047e-02f,
  -1.28864553e-02f, -2.27322336e-02f, -2.35279612e-02f, 5.51474392e-02f, 1.87763777e-02f, 5.73527243e-04f, 1.75021011e-02f, -4.13888246e-02f, -6.87146932e-02f, -1.16957389e-01f,
  -4.54488806e-02f, 7.95216635e-02f, -3.56376208e-02f, -4.07864973e-02f, -1.77082997e-02f, 4.88259830e-02f, 1.00512818e-01f, -6.75997213e-02f, -4.68953177e-02f, -5.50753698e-02f,
  -4.41096365e-01f, -4.43412840e-01f, -6.90042600e-02f, -1.22725487e-01f, -6.79119751e-02f, -1.34232119e-01f, 2.06127558e-02f, -1.97464470e-02f, -8.31894949e-02f, 2.78576780e-02f,
  1.61324404e-02f, 4.76582767e-03f, -4.91754040e-02f, 1.14993379e-02f, 3.87711115e-02f, 3.60187478e-02f, 8.13691132e-03f, -2.61381678e-02f, -8.62458199e-02f, -6.64400831e-02f,
  -2.87156925e-02f, -4.38840389e-02f, 7.45695680e-02f, -2.99119689e-02f, 4.84737791e-02f, -5.23510426e-02f, -1.49155557e-01f, -5.31497747e-02f, -1.99761242e-02f, 2.83876492e-04f,
  -3.30259919e-01f, 1.78700257e-02f, -7.04752579e-02f, -2.64227957e-01f, 1.31403595e-01f, 1.70629919e-01f, -7.39572495e-02f, 5.34776114e-02f, -2.15809736e-02f, 2.22331598e-01f,
  1.25915557e-01f, -1.32381603e-01f, -5.65445796e-02f, -2.81071544e-01f, -3.54864419e-01f, -2.60453820e-01f, -1.79710865e-01f, -4.84627374e-02f, -1.41624987e-01f, 4.66191769e-02f,
  -1.10810950e-01f, -2.00301766e-01f, -3.29033017e-01f, -2.23180912e-02f, 3.40944715e-02f, 8.72213170e-02f, 1.02325097e-01f, 3.31884474e-02f, 7.98662305e-02f, -3.33765224e-02f,
  -6.77844184e-03f, -5.52033149e-02f, -1.13223577e-02f, 1.29118972e-02f, 1.38159454e-01f, 1.05007701e-01f, 1.29390389e-01f, -2.06165556e-02f, -3.45537029e-02f, 6.39819950e-02f,
  9.55227092e-02f, -1.23296387e-01f, 1.15624873e-03f, -1.97697692e-02f, 2.34692991e-02f, 2.80525681e-04f, -2.38268897e-02f, 8.19324255e-02f, -1.14796646e-01f, -1.58768281e-01f,
  -5.65880351e-02f, 4.23955023e-02f, 2.75437925e-02f, -3.30515206e-02f, -5.55537492e-02f, 5.11590252e-03f, -7.63927121e-03f, 4.39788699e-02f, 4.38766815e-02f, -4.10234816e-02f,
  1.54289696e-02f, 3.29552740e-02f, -1.09393016e-01f, -1.68687515e-02f, 3.26724611e-02f, -4.52047549e-02f, -1.90469194e-02f, -5.36248498e-02f, -1.32286236e-01f, 5.75514883e-03f,
  -2.96366271e-02f, -3.40004601e-02f, -2.04536747e-02f, 3.15378867e-02f, -8.20738748e-02f, 1.37774376e-02f, -3.49244513e-02f, 5.89979254e-02f, -7.19060749e-02f, -2.70243753e-02f,
  -2.63386453e-03f, 6.08095676e-02f, -1.92932282e-02f, 1.25531703e-01f, -4.01467867e-02f, -1.07945323e-01f, -2.34967819e-03f, -2.40969807e-02f, 1.17048338e-01f, 1.86942909e-02f,
  1.10950045e-01f, 1.80345729e-01f, -3.95394601e-02f, -1.01006152e-02f, 3.91019024e-02f, 6.82455450e-02f, 3.15744691e-02f, -4.07956354e-02f, 4.40801820e-03f, 1.25924617e-01f,
  1.25852510e-01f, -6.80276752e-02f, 1.27600163e-01f, -8.29670727e-02f, -7.86014274e-02f, 9.04703885e-02f, -1.73176546e-02f, -5.64355887e-02f, 1.18616402e-01f, 3.59328017e-02f,
  5.67458682e-02f, 2.35445350e-02f, -4.44205739e-02f, 2.26793066e-02f, 1.07831359e-01f, 7.91933089e-02f, 1.27005398e-01f, 4.64703329e-02f, 6.82386458e-02f, -1.71013884e-02f,
  2.41496801e-01f, -2.54285365e-01f, -2.81809092e-01f, -5.62379360e-02f, 3.52932006e-01f, 1.61724418e-01f, -1.10233530e-01f, 1.77418858e-01f, -2.85508454e-01f, -1.52258590e-01f,
  1.36515394e-01f, -1.23240314e-01f, -3.08670253e-01f, 1.08392812e-01f, 2.67384142e-01f, -3.31730992e-01f, 2.25829571e-01f, 1.72275007e-02f, -1.12396903e-01f, -1.82807557e-02f,
  5.96882105e-02f, 4.52518970e-01f, -2.71521006e-02f, 2.36861631e-01f, 1.26612186e-01f, 2.21646819e-02f, 1.93059579e-01f, -1.53170660e-01f, 1.99884146e-01f, 1.89898193e-01f,
  6.42133579e-02f, -1.20832816e-01f, -1.87477693e-02f, -7.96224475e-02f, -7.90612251e-02f, -1.14744939e-02f, -5.41960783e-02f, 3.72798778e-02f, 9.52763781e-02f, -3.76818702e-02f,
  -7.22162426e-03f, 9.00512487e-02f, 1.40031785e-01f, -2.21998692e-02f, 6.29857332e-02f, 1.42252212e-02f, -1.03388973e-01f, -1.94213036e-02f, -3.07586510e-02f, -4.15646769e-02f,
  -8.79362002e-02f, 2.90361568e-02f, -2.43962184e-02f, 5.13903536e-02f, -2.75587328e-02f, -3.63927819e-02f, -8.92655179e-03f, -8.94462224e-03f, 8.48256573e-02f, -3.61170806e-02f,
  8.45815465e-02f, -4.02560681e-02f, 3.00111398e-02f, 2.47415118e-02f, -3.94834094e-02f, 4.28634062e-02f, 8.30824897e-02f, 5.82595952e-02f, -1.56963319e-02f, -4.35739234e-02f,
  1.73511598e-02f, 4.51377034e-02f, -1.11220159e-01f, -4.46596555e-03f, 7.71288499e-02f, -4.27912362e-02f, -5.41776232e-02f, -2.12901309e-02f, -1.19677015e-01f, -9.66813473e-04f,
  -1.19292447e-02f, 9.62255001e-02f, 1.46035757e-02f, -1.63936540e-02f, 7.04294220e-02f, 8.57591555e-02f, 5.24332747e-03f, -6.81901872e-02f, 5.78562059e-02f, 3.15814354e-02f,
  1.13215661e-02f, -3.50329988e-02f, -1.15641981e-01f, 1.13857649e-01f, -3.33561860e-02f, 1.88888479e-02f, -7.30056723e-04f, 7.06737190e-02f, -6.57284353e-03f, -2.92259026e-02f,
  8.89816359e-02f, 7.04314336e-02f, 3.76572646e-02f, 7.38534629e-02f, 1.23122811e-01f, -3.24228965e-02f, 7.91669562e-02f, -8.09357688e-02f, 1.11933738e-01f, 7.38497227e-02f,
  -3.78959067e-02f, 6.79396614e-02f, 3.02865393e-02f, 1.25098631e-01f, 8.03828686e-02f, -1.20173516e-02f, 6.80217426e-03f, -4.93618138e-02f, 5.02704792e-02f, -7.33911991e-02f,
  -2.01059014e-01f, 1.37315514e-02f, -1.71614692e-01f, 3.05311121e-02f, -1.99300990e-01f, 2.37839788e-01f, 2.20497683e-01f, -9.33065191e-02f, -7.62721896e-02f, 1.42862365e-01f,
  2.67363012e-01f, 2.93803420e-02f, -2.24962868e-02f, 3.12238336e-01f, 2.03417018e-01f, 1.37412459e-01f, 2.38841280e-01f, 1.49359718e-01f, -1.07979268e-01f, -5.73607758e-02f,
  -6.32886514e-02f, 1.92839503e-01f, 1.13364913e-01f, -1.18702270e-01f, 4.54488248e-02f, -1.65076226e-01f, -2.91226190e-02f, -1.20385952e-01f, 9.80901942e-02f, 8.19294527e-02f,
  -3.93116251e-02f, -1.38824925e-01f, -1.55640412e-02f, -8.02415311e-02f, -1.60287529e-01f, -7.67119899e-02f, -2.42131986e-02f, 1.60541255e-02f, 1.73960254e-02f, -1.85662322e-02f,
  7.32038096e-02f, -4.44694683e-02f, 3.78070995e-02f, 4.25257608e-02f, 3.54367010e-02f, 7.79188145e-03f, 3.71251553e-02f, 4.70261425e-02f, 7.33969659e-02f, 1.94243696e-02f,
  -3.53129767e-02f, 7.04414248e-02f, 5.03926352e-02f, -4.47681323e-02f, -1.51762674e-02f, 5.65092713e-02f, 2.72042695e-02f, 3.70625639e-03f, -3.35153155e-02f, 3.58307473e-02f,
  -3.80310304e-02f, 3.32277804e-03f, -8.51054937e-02f, -3.24629433e-02f, -1.63020715e-02f, 4.55509871e-02f, 1.34441838e-01f, 9.02265310e-02f, 7.38076717e-02f, 1.26008734e-01f,
  4.18760441e-02f, 8.62684334e-04f, 5.45406975e-02f, 7.55198225e-02f, -5.94923981e-02f, 8.09207652e-03f, -8.72200355e-03f, -3.57710905e-02f, 2.96722353e-02f, 9.94863585e-02f,
  6.52358234e-02f, 2.49374080e-02f, -7.07367659e-02f, 1.08240480e-02f, -4.81178612e-02f, -2.64830310e-02f, -1.57308742e-01f, 3.13472785e-02f, 1.21992551e-01f, 1.38786826e-02f,
  -9.85487178e-02f, -1.88732743e-01f, 5.78719890e-03f, -1.91519111e-02f, -8.69502779e-03f, -8.86741877e-02f, -3.09415236e-02f, -3.23355421e-02f, -8.14341977e-02f, -6.77833855e-02f,
  -7.18311071e-02f, 4.88094846e-03f, -4.46007438e-02f, 3.16886939e-02f, 5.66034531e-03f, -5.20682596e-02f, 7.40219802e-02f, 5.62673947e-03f, 1.62354395e-01f, 3.81393060e-02f,
  8.09653429e-04f, -6.86806664e-02f, -4.20878604e-02f, -5.69473505e-02f, 4.70408378e-03f, 1.65895522e-01f, -1.06424987e-01f, -9.66128185e-02f, -2.32806541e-02f, -3.19562881e-04f,
  3.81898820e-01f, 1.45711184e-01f, 1.78153947e-01f, 2.67063409e-01f, -2.17527181e-01f, -2.73521483e-01f, -1.14688218e-01f, -1.78993434e-01f, 2.93550104e-01f, -1.72553249e-02f,
  -1.83387429e-01f, 4.07303929e-01f, -1.53747916e-01f, 3.70079130e-02f, -2.15088233e-01f, -2.24389687e-01f, -9.92867202e-02f, 7.11088032e-02f, -5.88292070e-02f, 5.77880293e-02f,
  8.02394561e-03f, -3.10765624e-01f, -1.26273558e-01f, -2.32997090e-01f, 1.06971532e-01f, 1.79807410e-01f, -1.43760204e-01f, -1.84750557e-01f, 5.33537716e-02f, -1.99394584e-01f,
  -2.26690490e-02f, 7.44393766e-02f, 1.09994806e-01f, 7.07600713e-02f, 4.67535891e-02f, -9.81759187e-03f, -5.93519211e-03f, -8.42358842e-02f, -2.92943306e-02f, 6.73157126e-02f,
  1.47095278e-01f, -5.09233251e-02f, -3.14326137e-02f, -4.93216850e-02f, 6.05111457e-02f, 5.68603689e-04f, 1.98164076e-01f, 1.38415813e-01f, 3.47032808e-02f, 1.09913051e-01f,
  1.08934447e-01f, 1.97999030e-01f, 1.10515252e-01f, 8.55263025e-02f, 1.19695581e-01f, 6.30314797e-02f, 7.55673228e-03f, 2.59266533e-02f, 5.20959161e-02f, 3.94232236e-02f,
  3.79272588e-02f, -1.06106468e-01f, -9.53348428e-02f, -2.21868306e-02f, -9.05412734e-02f, 6.99175335e-03f, -7.78349722e-03f, -2.06997292e-03f, 6.26907423e-02f, -9.23478976e-02f,
  -2.04618648e-03f, 4.03807908e-02f, -8.45006332e-02f, 8.21976289e-02f, -1.02074789e-02f, 1.04838379e-01f, -6.82228850e-03f, 2.91463155e-02f, 1.31261453e-01f, 8.02211091e-02f,
  -3.67084518e-02f, -2.89573241e-02f, 5.25323637e-02f, 3.38629112e-02f, -1.23211637e-01f, 1.23974793e-02f, 9.19954702e-02f, 1.41071618e-01f, -2.26018322e-03f, -7.81635568e-02f,
  -6.22877814e-02f, -2.18791496e-02f, 8.47830623e-02f, 1.15625858e-01f, -1.03159705e-02f, 2.91365641e-03f, -7.15447515e-02f, 9.73371938e-02f, -6.59017935e-02f, -8.52309689e-02f,
  -2.80874111e-02f, 3.15053090e-02f, 5.90670668e-03f, 2.62170099e-02f, 6.90209344e-02f, 4.32645828e-02f, -3.22076119e-02f, 3.97625789e-02f, 7.22871535e-03f, 8.79702493e-05f,
  -2.40907483e-02f, -4.39545549e-02f, 6.81746304e-02f, 4.58084904e-02f, 7.26145506e-02f, 8.98426622e-02f, -1.23637551e-02f, -9.81023884e-04f, 5.98027138e-03f, 1.05387596e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  -1.80340721e-03f, 1.05942659e-01f, 8.11704174e-02f, 1.99739248e-01f, 8.02908912e-02f, 1.14001386e-01f, 1.18051060e-01f, 2.69427210e-01f, 2.33760491e-01f, 1.53786749e-01f,
  1.66020662e-01f, 1.97958916e-01f, 1.30244270e-01f, 6.83946162e-02f, 4.18388145e-03f, 1.45223141e-01f, 2.27982581e-01f, 2.42539927e-01f, 8.36865753e-02f, 4.22544703e-02f,
  8.82519782e-02f, 8.33730698e-02f, 2.21988752e-01f, 2.32274562e-01f, 1.27408609e-01f, 2.29916051e-01f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  2.31405217e-02f, 2.66890395e-02f, 3.37606296e-02f, -1.30588010e-01f, 1.52407959e-02f, 1.53868401e-03f, -8.77192467e-02f, 5.07674031e-02f, -8.74291267e-03f, 3.33675183e-02f,
  -4.04719561e-02f, -8.90469700e-02f, -1.08886324e-01f, 8.42687674e-03f, -7.73276314e-02f, 8.99393559e-02f, -1.00982942e-01f, 4.13877005e-03f, -3.43775414e-02f, 5.92361465e-02f,
  -2.93075502e-01f, 9.85873789e-02f, -4.67564501e-02f, -5.42541556e-02f, 1.01131149e-01f, 1.05513064e-02f, -1.20683134e-01f, -1.67354316e-01f, -1.48816198e-01f, 1.03819385e-01f,
  -5.69838248e-02f, 3.90593037e-02f, -1.41823053e-01f, -1.27516225e-01f, 1.33919314e-01f, 1.20381974e-01f, -6.52020378e-03f, -4.71899621e-02f, 1.75410062e-01f, 5.29648503e-03f,
  -4.46424223e-02f, -3.20270024e-02f, 1.18941538e-01f, -8.93162750e-03f, -3.02533001e-01f, -2.78826565e-01f, -2.84185231e-01f, 1.14970952e-01f, -1.24391466e-01f, -2.17900157e-01f,
  7.46651590e-02f, 5.95573261e-02f, 9.78713948e-03f, -2.33418345e-01f, -6.23884350e-02f, -2.43731737e-01f, 1.67113975e-01f, -1.06945084e-02f, -1.31615158e-02f, -6.23647124e-02f,
  5.52999973e-02f, 1.69916987e-01f, 1.98791713e-01f, -1.79931268e-01f, -4.79087830e-02f, 1.40723959e-01f, 1.04280077e-01f, 2.04746649e-02f, -9.58155617e-02f, -3.57604846e-02f,
  6.73503354e-02f, 1.29497368e-02f, 7.44952857e-02f, 6.02430329e-02f, 1.57498792e-01f, 8.76782238e-02f, -1.70612615e-02f, -4.04931046e-02f, -4.02373932e-02f, -4.68302146e-02f,
  6.32083416e-02f, -5.97886629e-02f, 1.02125317e-01f, 7.50529859e-03f, -9.33653712e-02f, -5.14226686e-03f, 2.27231905e-01f, -5.56804128e-02f, -1.44718245e-01f, -1.03737265e-01f,
  2.18400024e-02f, -1.22454993e-01f, -1.06664240e-01f, 4.44281660e-02f, -1.03079356e-01f, 6.53340369e-02f, 3.62066478e-02f, 1.05175965e-01f, -1.84366293e-02f, -1.00276344e-01f,
  -6.69327527e-02f, 5.36329998e-03f, 1.82493888e-02f, -4.83371168e-02f, 1.13481656e-01f, -1.23512439e-01f, 7.51470849e-02f, -6.67767823e-02f, 1.71004236e-01f, 1.40581548e-01f,
  1.01516068e-01f, 2.00935826e-03f, 3.83692384e-02f, 1.74799748e-02f, -5.78247048e-02f, 7.31697679e-02f, 3.29926349e-02f, 1.28516808e-01f, 2.20499560e-01f, 1.19088173e-01f,
  -3.66376415e-02f, 1.19211070e-01f, 4.82780002e-02f, -2.71607608e-01f, -1.22929566e-01f, 1.30824819e-01f, -5.16470447e-02f, -6.00861534e-02f, 1.43947052e-02f, 9.08902511e-02f,
  -3.00680269e-02f, -4.91986871e-02f, 6.17608204e-02f, 3.30758542e-02f, 1.02191512e-02f, 8.84099379e-02f, 2.28081481e-03f, -3.22860926e-02f, -6.04851954e-02f, 8.94168392e-02f,
  5.34131415e-02f, 1.10268526e-01f, 6.93920106e-02f, -6.05489500e-02f, 6.96663335e-02f, 3.71826887e-02f, 2.16097180e-02f, -1.21609718e-01f, 2.43687242e-01f, 3.11892629e-02f,
  -1.50693610e-01f, -1.38832510e-01f, 2.03687131e-01f, 2.59325374e-02f, -5.05888350e-02f, 2.02591956e-01f, 7.86767900e-03f, 1.08480655e-01f, 1.17321029e-01f, 6.19829819e-02f,
  3.30133140e-02f, -3.24374624e-02f, -9.33449045e-02f, 1.67183075e-02f, 1.14588164e-01f, 2.56415885e-02f, 6.73590088e-03f, 7.17655942e-02f, -1.21711440e-01f, 9.18358788e-02f,
  -1.98833674e-01f, -1.39837220e-01f, -1.11376226e-01f, -3.85274477e-02f, -9.50445831e-02f, 5.78106642e-02f, -3.76890339e-02f, -8.70987400e-02f, -3.10583916e-02f, 5.34220152e-02f,
  -2.31219783e-01f, -7.58820325e-02f, -3.19931090e-01f, -7.77585208e-02f, -1.73451960e-01f, -1.68967247e-02f, -4.07301411e-02f, -3.76036838e-02f, 2.03415468e-01f, -5.04804365e-02f,
  -2.03295633e-01f, 1.17791288e-01f, -1.74103811e-01f, -1.35165555e-02f, 8.19011927e-02f, 5.95271997e-02f, -8.59416351e-02f, 9.86088905e-03f, -5.42793199e-02f, -8.63640979e-02f,
  1.35369590e-02f, 6.30987436e-02f, 2.71703582e-02f, -2.06321031e-02f, -1.49638534e-01f, -9.16130990e-02f, -6.86214119e-02f, -3.17050517e-02f, 6.78652003e-02f, -5.83853461e-02f,
  1.26578156e-02f, -4.47740108e-02f, 1.10907234e-01f, -1.13824517e-01f, 2.38102168e-01f, -6.37836680e-02f, -9.32185873e-02f, -1.05455987e-01f, -4.53045033e-02f, -8.79012942e-02f,
  -1.50503293e-01f, 4.71517779e-02f, -8.75263363e-02f, -4.18651290e-02f, 6.55801594e-02f, 1.07368015e-01f, 6.82540834e-02f, -7.04883188e-02f, -7.85787776e-02f, -9.20237675e-02f,
  1.39084995e-01f, -1.17549360e-01f, -9.17761028e-02f, 4.68961895e-02f, 8.75811428e-02f, -6.06280193e-02f, 1.31604671e-01f, -2.51040429e-01f, 1.16172574e-01f, 4.40262519e-02f,
  8.53149816e-02f, 1.97201166e-02f, -4.55794856e-02f, -9.57404599e-02f, -6.30690977e-02f, -1.75990462e-01f, 2.77073622e-01f, 2.32837304e-01f, 9.06391367e-02f, -1.81725755e-01f,
  -6.38192669e-02f, -1.45452261e-01f, -3.74764390e-02f, 2.23516017e-01f, -3.87536502e-03f, -1.98327795e-01f, 8.92141685e-02f, -2.84739956e-03f, -1.29651502e-01f, -3.45850433e-03f,
  -1.21268205e-01f, -1.13780491e-01f, -1.26796111e-01f, -7.97870234e-02f, -1.14965804e-01f, -1.02903955e-01f, -6.20204546e-02f, -2.19016820e-02f, 9.06930829e-04f, -5.54661117e-02f,
  -6.95480853e-02f, -1.32121921e-01f, 8.56746957e-02f, -1.07482426e-01f, -9.66773853e-02f, -8.60475525e-02f, -1.85263187e-01f, 3.08173504e-02f, -1.08779810e-01f, -7.80793130e-02f,
  1.15617357e-01f, 8.90655629e-03f, -9.90855619e-02f, 1.96972772e-01f, 8.93758610e-02f, 1.06991708e-01f, 2.63336748e-02f, -1.83785986e-02f, -1.74253732e-02f, -5.67068830e-02f,
  5.15994318e-02f, 2.39973068e-02f, 9.70747247e-02f, 8.09495226e-02f, -1.00753359e-01f, 7.66781345e-02f, 8.13405439e-02f, -9.35090780e-02f, -2.41733771e-02f, -3.40392962e-02f,
  1.39609814e-01f, 1.66158844e-02f, 1.35532156e-01f, 7.98098668e-02f, 4.85900268e-02f, 2.92613022e-02f, -5.86751103e-02f, -1.38361175e-02f, 1.31121427e-01f, 1.45637706e-01f,
  1.32963896e-01f, -2.48850748e-01f, -5.95107041e-02f, 9.33308005e-02f, 1.89246669e-01f, -1.09829707e-02f, 9.16619599e-03f, -7.24103600e-02f, -1.17809884e-01f, -6.92194514e-03f,
  -1.78144023e-01f, 9.88774598e-02f, 8.80617127e-02f, 1.47345513e-01f, -6.49040639e-02f, -1.64710600e-02f, 4.48300084e-03f, 5.93210645e-02f, -4.73960564e-02f, 4.01007123e-02f,
  1.22329362e-01f, 2.06030399e-01f, 2.81215925e-03f, 1.18909925e-01f, -8.49695131e-02f, 2.85300892e-02f, 1.19380817e-01f, 5.60739376e-02f, 5.21310829e-02f, 4.08117436e-02f,
  -1.28904849e-01f, 1.35961160e-01f, -5.33521287e-02f, -9.46308225e-02f, 5.08144423e-02f, -1.72752157e-01f, -1.42483078e-02f, 4.46955115e-02f, 1.48717631e-02f, -3.29410695e-02f,
  -1.02057317e-02f, 8.52617472e-02f, -9.63916816e-03f, 5.70894144e-02f, 7.41229653e-02f, -3.21963489e-01f, 1.63072033e-03f, -2.69908900e-03f, 1.00011699e-01f, 5.24577200e-02f,
  -9.73247923e-03f, 2.32306466e-01f, -3.51382978e-02f, -1.84903517e-01f, 2.70758212e-01f, 1.52546316e-01f, 3.12782042e-02f, -8.74878466e-02f, -2.19602585e-01f, 1.04913287e-01f,
  -1.99949354e-01f, 1.01668619e-01f, -1.14285164e-01f, 2.96039015e-01f, 1.23738796e-01f, 5.60699264e-03f, -8.42232928e-02f, 7.52237439e-02f, -1.52833499e-02f, -2.49637768e-01f,
  -5.67595884e-02f, 1.22507825e-01f, 3.77931469e-03f, 1.41525552e-01f, -1.55455982e-02f, 7.04248175e-02f, -2.88275443e-03f, -1.02723286e-01f, -1.98742375e-03f, -2.19933093e-02f,
  2.15770919e-02f, 5.03169298e-02f, 8.96624848e-03f, -2.85700075e-02f, 3.92182209e-02f, -8.59120414e-02f, -6.69279844e-02f, -7.66640604e-02f, 4.20187861e-02f, -4.40988652e-02f,
  -1.49202332e-01f, -2.76863743e-02f, 9.34878662e-02f, 1.41521856e-01f, -1.76967993e-01f, 3.55041064e-02f, -3.20524792e-03f, -8.58891904e-02f, 1.03915192e-01f, -8.93263444e-02f,
  -6.88252524e-02f, -1.36256292e-01f, -1.47828842e-02f, 8.67629126e-02f, -1.70964170e-02f, 7.03890696e-02f, -4.96831238e-02f, -9.20906886e-02f, 4.09676582e-02f, -4.27962616e-02f,
  4.33858688e-04f, -1.29790694e-01f, 1.75386950e-01f, -5.32835163e-03f, -4.70270067e-02f, 2.88175605e-03f, 1.02813728e-01f, 1.38701513e-01f, -2.57723391e-01f, -1.80454463e-01f,
  -2.80066788e-01f, 2.05358773e-01f, -1.56915814e-01f, -1.35824457e-01f, 1.47347301e-01f, 1.76395267e-01f, -4.82740104e-02f, 4.72501181e-02f, -9.88884270e-02f, -2.41913140e-01f,
  1.96554840e-01f, -1.18427075e-01f, 7.20383413e-03f, -1.46029636e-01f, 5.95862679e-02f, 2.02150568e-01f, 1.55635744e-01f, -1.27738684e-01f, -4.56430502e-02f, 7.91435465e-02f,
  4.61627990e-02f, 1.24564208e-02f, 3.12259216e-02f, -5.86426258e-02f, -8.34517032e-02f, -1.80207714e-01f, -7.54076615e-02f, 1.70133188e-02f, -2.01741122e-02f, 1.01440042e-01f,
  2.60371584e-02f, 8.62177610e-02f, -1.78669542e-02f, -6.82290867e-02f, 4.17135954e-02f, -7.66751543e-02f, -3.60078514e-02f, 1.59880310e-01f, -2.12373197e-01f, 2.39002138e-01f,
  3.11965998e-02f, 1.50736317e-01f, 1.70021541e-02f, -2.58617342e-01f, 4.74719740e-02f, -1.89458326e-01f, 1.33292913e-01f, -1.08381122e-01f, 1.78170633e-02f, 8.04764498e-03f,
  -1.53228104e-01f, 1.37786999e-01f, 1.42236575e-01f, -3.62421602e-01f, -3.78405745e-03f, 2.11299397e-02f, -3.48374061e-03f, 1.00202663e-02f, -1.65455997e-01f, 2.71174252e-01f,
  -1.30305052e-01f, -2.04420626e-01f, 1.69146731e-01f, 1.90862760e-01f, -5.52468747e-03f, -7.74269328e-02f, -3.25558215e-01f, 1.07211724e-01f, -2.52680153e-01f, -3.75321158e-03f,
  -4.51279618e-02f, 7.81812519e-02f, 3.45843248e-02f, 1.15020268e-01f, -5.69371954e-02f, 4.21967171e-02f, -1.81500405e-01f, -1.96061239e-01f, -2.64933139e-01f, 1.43958300e-01f,
  -7.58829666e-03f, 6.19610352e-03f, 2.99721677e-02f, -5.37401885e-02f, -3.97790782e-03f, -3.35104577e-02f, -6.48041368e-02f, -2.97109894e-02f, -1.63509250e-01f, -6.42154291e-02f,
  -4.32768883e-03f, -4.84051406e-02f, 8.14824700e-02f, -2.79683508e-02f, 4.77972105e-02f, -3.86297964e-02f, -1.47701427e-01f, 4.94321296e-03f, -1.81983694e-01f, -7.62033239e-02f,
  -4.42222320e-02f, 2.20343918e-01f, -3.10954899e-01f, 4.33592126e-02f, 2.71016974e-02f, 1.74185604e-01f, -3.35207023e-02f, -6.13853522e-02f, 1.06144123e-01f, -3.10917012e-02f,
  9.71650630e-02f, -1.27077103e-01f, 4.60630236e-03f, -4.84445691e-02f, -1.53062463e-01f, -1.24039143e-01f, -3.76994871e-02f, -1.10572323e-01f, -6.30794391e-02f, 1.43955536e-02f,
  -4.15829755e-02f, -1.03719115e-01f, 1.91285044e-01f, 1.11673281e-01f, 1.13269994e-02f, 7.74292350e-02f, -1.12900389e-02f, 1.33126795e-01f, -1.91249959e-02f, -1.03429936e-01f,
  -1.83467418e-01f, -2.88078450e-02f, -1.35682449e-02f, 5.09144962e-02f, 6.14325069e-02f, 2.70829976e-01f, 1.99739501e-01f, -3.09049599e-02f, -1.79308746e-02f, 4.96026427e-02f,
  -7.57938325e-02f, -7.29402453e-02f, -2.63811827e-01f, 8.58290717e-02f, 1.60358116e-01f, 1.20461442e-01f, -4.46210392e-02f, -4.81217504e-02f, 4.59109582e-02f, 3.36803384e-02f,
  -2.73022130e-02f, -4.42362763e-03f, -3.51337865e-02f, 8.37939307e-02f, 8.18714947e-02f, -5.68247773e-03f, 3.46487425e-02f, -4.57601016e-03f, -4.88840938e-02f, 7.66706690e-02f,
  2.58184280e-02f, 1.87280588e-02f, 3.92976180e-02f, -7.44770467e-02f, -4.06623483e-02f, -2.40126073e-01f, 1.75878882e-01f, -1.92559540e-01f, 2.14508697e-01f, -5.53788096e-02f,
  -2.30093375e-01f, 3.81056592e-02f, 6.53758571e-02f, -9.62851942e-02f, -1.05749048e-01f, 6.91334829e-02f, -1.38897523e-01f, 9.75975096e-02f, 4.50562313e-02f, 1.30767912e-01f,
  3.13095190e-02f, 6.33678660e-02f, -9.81997475e-02f, 6.29737088e-03f, 3.92071158e-02f, -1.48908064e-01f, -1.02517456e-01f, -1.52836189e-01f, 2.81408012e-01f, -1.64529942e-02f,
  2.03128606e-01f, -9.06670764e-02f, 1.50042608e-01f, 6.60100952e-02f, 2.22831875e-01f, -1.06423862e-01f, 7.52690732e-02f, -1.02143243e-01f, 4.13431525e-02f, -1.44839033e-01f,
  -1.02207936e-01f, 1.75000638e-01f, 4.12650816e-02f, -2.49648448e-02f, -1.97254896e-01f, -6.69706613e-02f, -4.49398719e-02f, -4.41241823e-02f, 5.63338287e-02f, -4.60672416e-02f,
  1.24396598e-02f, -9.37681943e-02f, -1.49003994e-02f, -4.17312942e-02f, 5.50939031e-02f, -1.49290100e-01f, -4.59740199e-02f, 3.63311805e-02f, 1.65343750e-03f, 7.63475746e-02f,
  -1.00217819e-01f, -1.61499053e-01f, 3.69576104e-02f, -4.61141653e-02f, 8.36461186e-02f, 1.10319287e-01f, -6.68833926e-02f, -7.00646564e-02f, -1.14665017e-01f, 8.64145532e-03f,
  -8.94068480e-02f, -1.90197360e-02f, -1.61063045e-01f, -5.91560602e-02f, 1.12330019e-01f, 4.11960669e-02f, -1.80769145e-01f, -9.92921814e-02f, 3.74253355e-02f, 1.91610441e-01f,
  -6.64386898e-02f, 5.40068336e-02f, -4.42843027e-02f, -9.64567885e-02f, 1.22212991e-01f, 1.78633392e-01f, 1.52270168e-01f, -8.10267925e-02f, -5.17743565e-02f, 1.53421700e-01f,
  -1.10279806e-01f, -9.16342437e-02f, 1.13434559e-02f, 5.82650192e-02f, -2.06117094e-01f, -2.94715166e-01f, -2.35141233e-01f, 5.46655022e-02f, 3.51553373e-02f, -8.57460797e-02f,
  1.46429166e-01f, -1.17904204e-03f, 7.63048902e-02f, -3.35580796e-01f, -3.29669714e-01f, -3.75165194e-02f, 7.55278468e-02f, 7.02888519e-02f, 1.18256710e-01f, 1.48865029e-01f,
  2.45560229e-01f, -1.50401786e-01f, 1.52223622e-02f, -1.42816007e-01f, -1.75406247e-01f, 6.69130608e-02f, -6.66558370e-02f, -2.16544215e-02f, 3.59352268e-02f, 2.96075176e-02f,
  -5.68513572e-02f, -1.34924471e-01f, -7.47711733e-02f, -7.20161051e-02f, 8.94659758e-02f, 1.01620488e-01f, -4.23705541e-02f, 3.05381324e-02f, -7.75163426e-05f, 2.94896085e-02f,
  -4.24992405e-02f, -8.00165609e-02f, -2.39938701e-04f, -9.64011252e-03f, -1.76380575e-01f, 1.01085171e-01f, -2.73253005e-02f, 2.69487761e-02f, 9.39321741e-02f, -3.13694440e-02f,
  -1.10045239e-01f, 7.56286979e-02f, 6.81047663e-02f, 5.08851819e-02f, 7.37466440e-02f, 4.09327298e-02f, -1.61539521e-02f, -8.50476399e-02f, -2.03513540e-02f, -1.90204289e-02f,
  8.29348341e-02f, 6.83397874e-02f, -7.88521841e-02f, 1.03298258e-02f, 3.40234637e-02f, 1.24554552e-01f, -1.06058799e-01f, -2.32155733e-02f, 1.63029656e-01f, 1.01160817e-01f,
  4.25463244e-02f, 5.08653373e-02f, -2.27561250e-01f, 1.35195494e-01f, -1.24090962e-01f, 1.77972957e-01f, -1.45672513e-02f, 2.37794876e-01f, 2.56670922e-01f, -8.57008845e-02f,
  -4.18073870e-03f, 5.43106012e-02f, 1.59662277e-01f, 5.18119186e-02f, -1.21047862e-01f, 2.90992763e-02f, -6.81994036e-02f, 2.47268870e-01f, -1.65285379e-01f, -2.01499742e-02f,
  5.51276989e-02f, -1.78459957e-02f, -7.12839663e-02f, -1.31721245e-02f, -5.64591624e-02f, -1.16678052e-01f, 2.29019951e-02f, 3.49349082e-02f, -4.92870517e-04f, -7.90095180e-02f,
  -6.79609776e-02f, -4.20075990e-02f, -8.25250074e-02f, -4.36348952e-02f, -1.74370900e-01f, -8.29231367e-02f, 4.02930230e-02f, 2.91153878e-01f, -1.98516324e-01f, 6.46066293e-02f,
  1.49204180e-01f, 1.93869919e-01f, -1.42027438e-01f, -2.08060667e-01f, 8.47226307e-02f, -2.08549753e-01f, 1.03873506e-01f, -1.95170417e-01f, -8.53986740e-02f, -2.52188426e-02f,
  -1.12303130e-01f, 7.82555863e-02f, -2.11653523e-02f, -1.52590305e-01f, -1.61598057e-01f, -7.06361532e-02f, 7.94207454e-02f, -7.59769827e-02f, -4.85745743e-02f, 1.56815331e-02f,
  8.97543207e-02f, 3.73415872e-02f, 9.59295547e-04f, 1.24669708e-01f, -1.38826236e-01f, -1.17036775e-01f, -2.19213814e-01f, 4.87450361e-02f, -2.35271323e-02f, -3.96097600e-02f,
  -5.76747907e-03f, -3.27894054e-02f, 9.87375677e-02f, 1.62749037e-01f, 1.15403831e-01f, -6.66698143e-02f, -1.21593975e-01f, -8.18565413e-02f, -2.52949595e-01f, 1.78855360e-01f,
  1.24894351e-01f, -1.65056184e-01f, -9.89848524e-02f, 2.66760290e-02f, 6.24051988e-02f, 4.42299061e-02f, -1.32418334e-01f, -7.00981319e-02f, 1.15066335e-01f, 3.51630687e-03f,
  5.52145466e-02f, 1.92846432e-02f, 5.80965765e-02f, 8.85856524e-02f, -1.11696847e-01f, 7.61402175e-02f, -9.70679820e-02f, -1.70391113e-01f, 1.82617903e-02f, 3.15400474e-02f,
  1.86600760e-02f, -4.18551899e-02f, -1.35709450e-01f, 3.75268119e-03f, 9.58470702e-02f, -1.90467358e-01f, 4.44269478e-02f, -9.17946473e-02f, -1.19194379e-02f, -7.48816207e-02f,
  -1.70939043e-01f, 1.53134987e-01f, -5.91907687e-02f, 1.53585076e-01f, -3.54839414e-02f, 4.70786095e-02f, 1.11836709e-01f, 5.92805725e-03f, 1.19008213e-01f, -3.28448340e-02f,
  2.19749093e-01f, -6.01828657e-02f, -1.55677363e-01f, -1.65420517e-01f, 1.47943735e-01f, 3.80375446e-03f, 1.30308181e-01f, -2.68252730e-01f, 8.35541636e-02f, 9.63414907e-02f,
  -5.65937683e-02f, -9.89280343e-02f, -1.58682466e-01f, 5.33330441e-02f, -2.12742805e-01f, 8.26347247e-02f, 1.36815399e-01f, -1.54681310e-01f, -1.32448808e-03f, -1.63105533e-01f,
  -2.23029684e-02f, -2.43342787e-01f, -8.29951912e-02f, 2.16564640e-01f, -9.47302952e-02f, -1.38923988e-01f, 2.30900243e-01f, 4.64393981e-02f, -1.44206330e-01f, -4.69178855e-02f,
  5.61144054e-02f, 3.48159857e-02f, -2.65856944e-02f, 2.87247282e-02f, -5.86191146e-03f, 6.29424024e-03f, -8.72811452e-02f, 3.12843844e-02f, 7.63528049e-02f, -4.10805009e-02f,
  -1.74154211e-02f, -2.58480962e-02f, -5.98011073e-03f, 1.24888316e-01f, -2.03067604e-02f, 2.04712793e-01f, -9.20560136e-02f, 2.21824393e-01f, -2.23479956e-01f, 1.27300635e-01f,
  7.14461505e-02f, 1.25745788e-01f, 1.22719876e-01f, 1.44699663e-01f, 2.98855416e-02f, -9.95698571e-02f, 1.01927496e-01f, -2.31655940e-01f, -2.09220443e-02f, -1.11477666e-01f,
  1.28871379e-02f, 6.62218407e-02f, -6.73391670e-02f, -2.52304729e-02f, -4.80453596e-02f, 1.12138972e-01f, 2.85917491e-01f, -4.82076444e-02f, -8.10630545e-02f, 1.57206863e-01f,
  -2.12912023e-01f, 1.68498039e-01f, -1.03068709e-01f, 2.02968791e-02f, -1.17111810e-01f, 7.15913773e-02f, 2.37210132e-02f, 3.86992358e-02f, 1.72800928e-01f, 9.23255086e-02f,
  1.16372667e-01f, -2.14631066e-01f, 5.14555955e-03f, 8.32214877e-02f, 7.40173161e-02f, 2.30027258e-01f, 5.44246435e-02f, 7.11819977e-02f, 2.15465240e-02f, -1.69536859e-01f,
  -2.51330435e-01f, 1.02524236e-01f, 1.52691722e-01f, 4.12951373e-02f, -1.47755921e-01f, 3.60784978e-02f, 5.59087917e-02f, -6.07951507e-02f, 7.90953636e-02f, 7.69459531e-02f,
  -6.12367205e-02f, 8.09792131e-02f, -4.29675616e-02f, 6.15620092e-02f, -6.74462393e-02f, -8.86846408e-02f, 1.62245203e-02f, -4.71117869e-02f, 2.10430026e-02f, 9.67316329e-02f,
  -9.43064541e-02f, 3.11826337e-02f, 4.49526049e-02f, -5.21733649e-02f, -6.26200289e-02f, -5.27695194e-02f, -7.98966810e-02f, -2.28003025e-01f, -4.93976735e-02f, -2.20574941e-02f,
  -1.22992866e-01f, 7.39952847e-02f, 5.83883487e-02f, 1.57421634e-01f, 1.14970848e-01f, -7.97081515e-02f, 6.11122921e-02f, -1.04937963e-01f, 1.73832446e-01f, 1.23254501e-03f,
  -8.86259526e-02f, -2.26292796e-02f, 5.58479428e-02f, -2.06733514e-02f, 2.13741973e-01f, -1.03930220e-01f, 9.42918584e-02f, -4.69520912e-02f, -2.18024626e-01f, 9.84635130e-02f,
  -6.87692165e-02f, -9.66548771e-02f, -2.23188385e-01f, -5.29319793e-03f, 1.05158791e-01f, 1.28283396e-01f, 5.35249934e-02f, -1.92095056e-01f, -1.41495854e-01f, -1.48715496e-01f,
  -6.52981699e-02f, 1.46257252e-01f, 3.81843857e-02f, -1.71425506e-01f, 1.69065297e-01f, 3.56601644e-03f, 8.81557539e-02f, 3.64807458e-03f, 7.71662816e-02f, 3.16419493e-04f,
  5.84400073e-02f, 3.05735040e-02f, 4.25784253e-02f, -7.18370080e-02f, -4.23761457e-02f, -1.20515656e-02f, 6.49150759e-02f, 5.82558569e-03f, 7.88481832e-02f, -4.75367196e-02f,
  -2.80712768e-02f, 1.56878218e-01f, -4.16693203e-02f, 2.28882432e-01f, -2.16976508e-01f, 1.45192429e-01f, -1.75438330e-01f, 3.54843051e-03f, 1.50230289e-01f, -3.13867852e-02f,
  1.15702376e-02f, 2.54197773e-02f, 2.13161316e-02f, 5.24748489e-03f, 8.53341445e-02f, -5.31339906e-02f, -9.49514210e-02f, -1.32889273e-02f, 1.00831531e-01f, 6.01510592e-02f,
  -5.28254993e-02f, -9.62202251e-02f, 4.00351215e-04f, -2.26181671e-02f, -6.73345327e-02f, 1.21801093e-01f, -1.03062287e-01f, 1.05932206e-01f, -2.71664798e-01f, 7.45124929e-03f,
  -2.42160067e-01f, 9.37552005e-02f, -4.95286360e-02f, -5.59592545e-02f, 1.19415887e-01f, 1.42301489e-02f, -9.28316116e-02f, -5.29946573e-02f, -4.99464422e-02f, -1.91385165e-01f,
  1.83630101e-02f, -8.53324160e-02f, -5.49191423e-02f, -3.28117236e-02f, 1.41362818e-02f, 8.82122517e-02f, 1.12438351e-01f, -1.00464113e-01f, -1.63845971e-01f, 8.82602576e-03f,
  -5.26281558e-02f, 2.43935958e-02f, 1.38758076e-02f, -9.14188996e-02f, -1.68045424e-02f, -1.29689172e-01f, -3.04217748e-02f, -3.48863900e-02f, 1.08701838e-02f, 3.41519527e-02f,
  -4.63384539e-02f, -8.34365189e-02f, -8.43282714e-02f, -3.85704488e-02f, -7.36219622e-03f, -6.31601140e-02f, 1.71027724e-02f, 2.98525482e-01f, -1.40497580e-01f, 2.06314698e-01f,
  7.22761676e-02f, 5.47920205e-02f, -8.05327073e-02f, -1.41194388e-01f, 1.47467762e-01f, -1.53905958e-01f, -1.87193919e-02f, -1.06912330e-01f, 6.17294759e-02f, -1.10867098e-01f,
  4.17514965e-02f, 5.23647107e-02f, 1.26601979e-02f, -2.99753428e-01f, -1.43480182e-01f, -1.73472777e-01f, 3.18582915e-02f, 3.32890190e-02f, 8.07274878e-02f, 3.60340327e-02f,
  -8.68355483e-02f, -8.15411098e-03f, -3.55506353e-02f, 1.47025317e-01f, -8.89156684e-02f, -2.61868183e-02f, -1.81706056e-01f, 2.04126969e-01f, -1.62807539e-01f, 8.12927485e-02f,
  -1.05499774e-01f, 1.47364795e-01f, 1.81604505e-01f, 2.07391113e-01f, -1.05200037e-01f, -2.91730673e-03f, -2.96272570e-03f, -1.06392168e-01f, -3.41003016e-02f, 1.90143093e-01f,
  -3.47606391e-02f, -2.22992867e-01f, -1.37609199e-01f, 1.49464071e-01f, -2.57089920e-02f, 6.36489093e-02f, 2.19088774e-02f, 1.17442459e-01f, 1.75605323e-02f, -3.62789817e-02f,
  6.43582344e-02f, 1.38119265e-01f, 5.79229370e-03f, 1.17122501e-01f, 8.25247094e-02f, 1.33328155e-01f, -6.02005050e-02f, -8.65831971e-02f, 6.23571239e-02f, -9.48318839e-02f,
  1.15609549e-01f, -3.68699916e-02f, -1.55174062e-01f, 1.64169833e-01f, -6.61008656e-02f, -3.32857519e-02f, 6.68272078e-02f, -7.80273452e-02f, -9.49173421e-02f, -4.45996746e-02f,
  4.95745465e-02f, -5.44926934e-02f, 1.88339520e-02f, 1.49895931e-02f, -2.88065039e-02f, 2.03618258e-02f, 1.81119084e-01f, -1.72276661e-01f, 1.37005851e-01f, -2.21869294e-02f,
  -1.46169057e-02f, 1.20797761e-01f, -8.45221952e-02f, 2.29814574e-01f, -1.25288442e-01f, -1.57405853e-01f, 2.00128347e-01f, 1.30772024e-01f, 1.49106130e-01f, -1.12657122e-01f,
  -1.68433622e-01f, 2.31438145e-01f, -2.27704301e-01f, -1.53519779e-01f, 1.24771707e-02f, 2.34083533e-02f, 2.00519964e-01f, -1.91437248e-02f, -1.80134311e-01f, 1.20287985e-01f,
  6.54437467e-02f, -1.74928635e-01f, -1.58114776e-01f, 7.77419358e-02f, -1.71962991e-01f, -1.91044249e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -4.31329794e-02f, 1.70702651e-01f, 1.16384476e-01f, 1.39420897e-01f, 6.64428622e-02f, -2.35289894e-03f, 3.74415144e-02f, 7.13829622e-02f, 7.88621306e-02f, 1.82476848e-01f,
  5.04541695e-02f, 1.35779813e-01f, -2.21216772e-02f, 8.41249600e-02f, 8.09626281e-02f, 1.70193482e-04f, 5.66132963e-02f, 4.02809381e-02f, 1.63462117e-01f, 4.81176339e-02f,
  -1.44900307e-01f, 1.37182340e-01f, 8.26887339e-02f, -1.44982755e-01f, 6.60921410e-02f, -7.28585795e-02f, -1.82638451e-01f, -1.50808394e-01f, -6.32224977e-02f, 8.79216269e-02f,
  -3.21989693e-02f, 1.42139480e-01f, -7.37804966e-03f, 4.31644022e-02f, 1.54427037e-01f, -1.72095090e-01f, 9.03144032e-02f, -1.33279607e-01f, 1.66943282e-01f, 1.82295796e-02f,
  -1.39014095e-01f, 2.50149846e-01f, -5.22540845e-02f, -2.13095412e-01f, 5.89001402e-02f, -2.19719425e-01f, 4.78751101e-02f, 6.82012886e-02f, -4.37928252e-02f, 6.36309385e-02f,
  -1.42130256e-01f, 3.87044512e-02f, -1.08434513e-01f, -1.25807792e-01f, 2.52868861e-01f, 1.25480622e-01f, 8.62710029e-02f, -6.11679330e-02f, 1.10911593e-01f, -2.44539320e-01f,
  4.41837460e-02f, 3.82357687e-01f, -1.07052727e-02f, -9.10578966e-02f, 6.46210536e-02f, -1.34889884e-02f, -5.27443588e-02f, 1.86012480e-02f, 3.56233167e-03f, -1.11272439e-01f,
  -1.51146159e-01f, -9.79636908e-02f, -1.24929301e-01f, 6.44207448e-02f, -1.94692183e-02f, 5.69129083e-03f, 1.72854096e-01f, 1.83112733e-02f, -2.70718616e-02f, 1.30419195e-01f,
  6.45364746e-02f, -1.30406156e-01f, -2.59233359e-02f, -1.94662422e-01f, -8.78321007e-02f, -1.09176017e-01f, 2.70578563e-02f, 1.55214861e-01f, -6.62855357e-02f, -4.14367877e-02f,
  -6.97218999e-02f, -1.91230625e-02f, 7.47966245e-02f, 1.59655780e-01f, -1.77533358e-01f, 6.11674935e-02f, 9.38149244e-02f, -1.01431943e-01f, 1.93289407e-02f, 4.68469113e-02f,
  1.08638987e-01f, 3.54451127e-02f, -7.89666474e-02f, 3.01483870e-01f, 1.55000523e-01f, -1.21089995e-01f, 2.44693518e-01f, -1.15096711e-01f, -7.13748857e-02f, 7.55107477e-02f,
  -4.54088440e-03f, -3.66217606e-02f, 1.16039783e-01f, 2.80013643e-02f, 1.06217392e-01f, 6.74304441e-02f, 4.24593717e-01f, 1.05717070e-01f, 2.47583196e-01f, -5.65045215e-02f,
  7.36405253e-02f, 3.24551076e-01f, 3.72795880e-01f, 1.96210623e-01f, -1.06680989e-02f, -9.35572833e-02f, 1.94822275e-03f, 1.13558158e-01f, 1.17223449e-01f, 2.19064027e-01f,
  3.32154967e-02f, 1.08678833e-01f, 2.88725138e-01f, 1.83949262e-01f, 1.18130222e-01f, 1.43060938e-01f, 2.18987465e-02f, -3.54973190e-02f, 1.31390572e-01f, 2.38384694e-01f,
  1.14331514e-01f, 1.98986143e-01f, 2.10181270e-02f, 1.09339975e-01f, 7.44215399e-02f, 1.61325604e-01f, 1.43435627e-01f, 5.51098548e-02f, -1.00953840e-01f, 3.86064611e-02f,
  -1.02832623e-01f, 1.01171449e-01f, 1.78620726e-01f, -2.25052595e-01f, 9.08695534e-02f, 1.21026769e-01f, 2.06762359e-01f, -9.31841061e-02f, 1.27537653e-01f, 5.42465039e-02f,
  -1.71199366e-01f, -3.21373716e-02f, -1.04417048e-01f, -1.90602362e-01f, -1.66111495e-02f, 6.72244355e-02f, 1.93280801e-02f, -8.20216089e-02f, -1.15666427e-01f, 3.73245806e-01f,
  -3.06767374e-01f, -1.42326638e-01f, 2.88413577e-02f, 1.38472959e-01f, -6.76956922e-02f, -6.42614886e-02f, -1.99941620e-01f, 5.05907349e-02f, -1.66083053e-01f, -4.05015610e-02f,
  -1.79600477e-01f, 3.52826416e-02f, -2.19668478e-01f, 1.17160551e-01f, -5.11832237e-02f, -6.94761723e-02f, -2.49936417e-01f, -1.20805137e-01f, 2.09946841e-01f, 1.54270217e-01f,
  -2.46536527e-02f, 3.57508659e-01f, 1.85156167e-01f, 4.88479063e-02f, -2.98497640e-02f, 6.90566674e-02f, 1.71752706e-01f, 1.61416337e-01f, 1.40145332e-01f, 1.25465661e-01f,
  8.75444263e-02f, 4.40167300e-02f, 6.43389151e-02f, -1.03487246e-01f, -3.92755307e-02f, 2.13792160e-01f, 1.37124360e-01f, 1.66995972e-01f, -7.16718286e-02f, 1.51400149e-01f,
  1.11592583e-01f, 4.37126458e-01f, -1.77463800e-01f, 2.01174319e-01f, -1.99086130e-01f, 8.79393369e-02f, 3.42146419e-02f, -5.13532141e-04f, 2.07354635e-01f, -5.56099452e-02f,
  -7.43884221e-02f, -2.16006964e-01f, 1.79152817e-01f, -2.61099100e-01f, -1.52425274e-01f, 1.03200458e-01f, -6.59748865e-03f, -5.25490381e-02f, -1.01032577e-01f, -2.65382022e-01f,
  3.79374586e-02f, -1.03367388e-01f, 1.90423593e-01f, 7.04600066e-02f, 9.59476680e-02f, 3.71473134e-01f, -1.82813480e-01f, 1.75279111e-01f, -1.35183051e-01f, 1.63867146e-01f,
  -7.55116567e-02f, 1.23885773e-01f, 3.00958782e-01f, 8.03266913e-02f, -1.38105810e-01f, 2.10471094e-01f, 5.20769879e-02f, -1.43806353e-01f, 8.81250352e-02f, -9.58633795e-02f,
  -2.54068643e-01f, 2.42197961e-01f, -2.61379629e-02f, 1.53966427e-01f, 2.03229889e-01f, -2.94367939e-01f, 6.44800253e-03f, 8.36498439e-02f, 1.14406340e-01f, 3.15974802e-02f,
  -7.44580030e-02f, 7.46833906e-02f, 4.36273143e-02f, 1.38065070e-01f, 1.05046026e-01f, 1.41815975e-01f, 1.58032462e-01f, 1.53257027e-02f, -5.02982289e-02f, 8.12281519e-02f,
  1.12963445e-01f, 1.12648129e-01f, 1.01199821e-02f, 7.38507211e-02f, 1.17804080e-01f, -1.67465538e-01f, 1.90883592e-01f, -2.47693926e-01f, 2.47276753e-01f, -8.50568116e-02f,
  -1.74529672e-01f, -4.31499444e-02f, 3.88078461e-03f, -9.03753266e-02f, -2.81179965e-01f, 9.12821293e-02f, -3.86811234e-02f, 1.17556684e-01f, 8.21175128e-02f, 1.49877384e-01f,
  -1.15055211e-01f, 2.55274892e-01f, -1.53149381e-01f, -2.46076044e-02f, 8.33543912e-02f, -1.45551085e-01f, 6.84383437e-02f, -2.47820124e-01f, 1.66427746e-01f, 1.16169862e-01f,
  9.41502377e-02f, -1.90132320e-01f, 2.22039178e-01f, 1.48510337e-01f, 3.61182868e-01f, -1.63347960e-01f, 1.40713319e-01f, -1.22201294e-02f, 5.99451438e-02f, -1.11561984e-01f,
  5.76177277e-02f, 9.17345583e-02f, 1.61110148e-01f, -1.11548588e-01f, -3.74565385e-02f, -5.59264421e-02f, 7.27664530e-02f, 6.31689653e-02f, 1.22859910e-01f, -4.69667427e-02f,
  -9.00887176e-02f, 1.03736684e-01f, 1.48576096e-01f, 1.53107300e-01f, 2.15709910e-01f, 9.62042585e-02f, -2.92792247e-04f, -1.19823823e-02f, -3.48831862e-02f, 1.68784633e-01f,
  7.38134161e-02f, 1.20552503e-01f, 2.59233177e-01f, 1.53209955e-01f, 1.50380626e-01f, 2.36923590e-01f, 1.60297528e-02f, 7.09293708e-02f, 1.15001529e-01f, 5.47016263e-02f,
  1.64799809e-01f, -9.18803215e-02f, 7.57115334e-02f, 2.89628983e-01f, -2.24050552e-01f, -3.08291584e-01f, 1.99305177e-01f, -1.57831863e-01f, 1.90009505e-01f, -1.13587528e-01f,
  -1.03702947e-01f, 1.22092508e-01f, 3.27814259e-02f, 6.27263486e-02f, -7.80348927e-02f, -2.57419378e-01f, -2.24721223e-01f, 1.78332612e-01f, -1.24893561e-01f, 4.93372651e-03f,
  8.20952505e-02f, 1.44891784e-01f, -5.60055785e-02f, -2.15989456e-01f, 1.00849949e-01f, 3.13326955e-01f, 1.61548570e-01f, -3.57983738e-01f, -4.48567718e-02f, 1.04946122e-01f,
  -2.00396314e-01f, -1.89685941e-01f, 6.12301566e-02f, 7.68989325e-02f, -1.37836769e-01f, 4.60750103e-01f, -4.66016904e-02f, 1.17965989e-01f, -1.30008042e-01f, -2.30767503e-01f,
  -1.73045784e-01f, -1.56547427e-01f, 1.40448166e-02f, 3.57798189e-01f, 2.26316318e-01f, 1.95743591e-01f, 1.16267279e-01f, 1.65352449e-01f, -7.54634663e-02f, -1.89434364e-02f,
  6.66462630e-02f, 1.75226748e-01f, 8.88299420e-02f, 1.74057320e-01f, -7.20399767e-02f, 1.40217647e-01f, 1.00946762e-01f, 1.01983607e-01f, 1.77694082e-01f, 3.13912798e-03f,
  2.52637297e-01f, -7.82403648e-02f, 4.37944196e-02f, -3.01404148e-01f, -6.02011010e-02f, -7.09561482e-02f, -1.19086817e-01f, -2.54586995e-01f, 2.60409236e-01f, 2.08747104e-01f,
  -2.97520459e-01f, 7.35481456e-02f, 6.82574734e-02f, 2.70989597e-01f, -1.62397455e-02f, 2.00422138e-01f, 1.47255346e-01f, -1.18219920e-01f, 2.12276384e-01f, 6.90257326e-02f,
  3.29381108e-01f, 7.10692704e-02f, -1.23042151e-01f, 3.12306285e-01f, -1.03266403e-01f, 7.24664778e-02f, -6.90953434e-02f, -1.97744414e-01f, 7.41339326e-02f, -1.36065751e-01f,
  1.86533287e-01f, 1.30825683e-01f, 9.21544731e-02f, -5.63843697e-02f, -9.21603739e-02f, 1.75286643e-02f, 1.48406163e-01f, -1.01763688e-01f, 7.95872957e-02f, -3.00459951e-01f,
  -1.73003137e-01f, 1.96068436e-01f, 4.17509854e-01f, 1.16818905e-01f, 3.34925950e-01f, -7.07888603e-02f, -2.77422100e-01f, 3.88490222e-02f, 5.69300875e-02f, 1.84220195e-01f,
  5.50233200e-02f, 1.78488687e-01f, 7.15954527e-02f, 8.67703557e-02f, 1.85333475e-01f, 2.85735875e-01f, 1.29684463e-01f, 7.47221559e-02f, 1.44872129e-01f, 2.16210589e-01f,
  1.28410131e-01f, 2.07783744e-01f, 1.72183767e-01f, -4.32888605e-02f, 2.24648744e-01f, 6.13372549e-02f, 6.52882904e-02f, -1.93029776e-01f, 2.21043020e-01f, 4.95734774e-02f,
  -9.02744010e-02f, -1.35046661e-01f, 2.65901268e-01f, -7.50302374e-02f, -1.94548786e-01f, 2.84539461e-01f, 7.37411156e-02f, 3.08900699e-02f, 6.41286820e-02f, 8.56727287e-02f,
  -1.12926751e-01f, -6.13543093e-02f, -5.29960282e-02f, -3.80849279e-02f, 1.74870551e-01f, 1.23317413e-01f, -3.14510763e-02f, -1.05352774e-01f, -1.16271429e-01f, 2.75235385e-01f,
  -1.55969083e-01f, -7.93957561e-02f, 2.44878575e-01f, -1.20675243e-01f, 2.04795823e-01f, 2.60746703e-02f, 9.10139643e-03f, -4.64939401e-02f, -1.08558781e-01f, -9.16015729e-02f,
  -1.97124451e-01f, -1.69382483e-01f, -1.63685568e-02f, 5.72210029e-02f, -1.16360061e-01f, -4.47482467e-02f, -3.67832296e-02f, 2.64074560e-02f, 1.16042010e-01f, 9.74444523e-02f,
  -3.40395123e-02f, 4.23784792e-01f, 1.94321916e-01f, 1.02156304e-01f, 1.11133285e-01f, 5.94313703e-02f, 3.48971747e-02f, 8.78614038e-02f, 8.86961520e-02f, 7.79292732e-02f,
  1.41083449e-01f, 1.25331104e-01f, 1.77927122e-01f, 1.25964999e-01f, 4.34119776e-02f, 9.84682366e-02f, 1.36033475e-01f, 2.07990725e-02f, 2.22605299e-02f, 1.21578410e-01f,
  1.20023355e-01f, -1.25269026e-01f, -2.09813401e-01f, -7.93369561e-02f, 1.22243993e-01f, -1.08454563e-01f, -5.48629314e-02f, -1.45030335e-01f, 3.84054333e-02f, -1.04814254e-01f,
  -3.07647228e-01f, 8.60268250e-02f, -1.39017209e-01f, 1.62113041e-01f, -2.91176960e-02f, 3.92029574e-03f, 2.62506008e-02f, 1.81527615e-01f, -9.95711386e-02f, -5.57349324e-02f,
  1.77075356e-01f, -9.44356099e-02f, 6.01217523e-02f, -9.57527235e-02f, 1.66878060e-01f, 1.06004022e-01f, -1.11172400e-01f, -1.85279101e-01f, 4.12909724e-02f, 1.18255220e-01f,
  1.64693400e-01f, -2.86679626e-01f, 7.47455955e-02f, 8.33096355e-02f, -1.97494794e-02f, 5.04650846e-02f, 9.60530043e-02f, -4.00278606e-02f, 9.98981595e-02f, -7.69599974e-02f,
  -4.26888540e-02f, -1.29875407e-01f, 3.02424617e-02f, 1.94676831e-01f, 1.67133793e-01f, -1.11518942e-01f, -1.03313047e-02f, 8.80183503e-02f, 2.18496442e-01f, 1.47212923e-01f,
  6.78204373e-02f, 7.99485520e-02f, -5.00704860e-03f, 8.40549767e-02f, 1.81960873e-02f, 1.12321943e-01f, 1.90754980e-01f, 1.75399348e-01f, 1.50423288e-01f, -3.92549373e-02f,
  5.28402776e-02f, 3.66779491e-02f, 1.11587971e-01f, 3.89855765e-02f, 1.10966340e-01f, -2.44480968e-01f, 1.26813710e-01f, -1.65561035e-01f, 1.90492243e-01f, 7.55640864e-02f,
  -1.80677295e-01f, -1.72487617e-01f, 9.32288915e-02f, -6.14673123e-02f, -5.63993379e-02f, 6.82634339e-02f, -1.98774070e-01f, 1.87463403e-01f, -3.24101113e-02f, 4.28603590e-02f,
  -1.20533489e-01f, -1.46252573e-01f, -1.40033677e-01f, 2.16638729e-01f, 1.46656796e-01f, 1.71593763e-02f, 1.34555131e-01f, 3.96566056e-02f, 1.32873967e-01f, -2.75864035e-01f,
  2.82819927e-01f, 5.64538538e-02f, 2.04542309e-01f, -1.05736896e-01f, 1.88495994e-01f, 4.47035693e-02f, -1.10801809e-01f, 3.58407460e-02f, 4.39037122e-02f, -6.88739819e-04f,
  9.99845043e-02f, 3.08407277e-01f, 8.21904540e-02f, 2.01290950e-01f, 1.11837536e-01f, -2.02888548e-01f, 2.51417719e-02f, 4.33699973e-02f, -3.40520008e-03f, 3.82470369e-01f,
  1.40397310e-01f, 1.34370133e-01f, 5.26347049e-02f, 9.82732028e-02f, 9.04025584e-02f, 7.58609921e-02f, -1.62162278e-02f, 9.22707990e-02f, -1.64177660e-02f, -2.31605619e-02f,
  9.94628817e-02f, 2.09977895e-01f, 1.45678118e-01f, 1.37402564e-01f, 1.28924191e-01f, 8.58148262e-02f, 2.04841271e-01f, 4.80931923e-02f, 1.46535367e-01f, -6.66970611e-02f,
  2.38306776e-01f, 3.74304615e-02f, -5.98534904e-02f, 1.10591076e-01f, 3.50766741e-02f, 1.24128446e-01f, 4.55744984e-03f, 2.55078942e-01f, 5.35642095e-02f, -2.09635757e-02f,
  1.56150118e-01f, -1.28212929e-01f, 8.86305571e-02f, 1.15041726e-03f, -8.46548378e-02f, -6.87912256e-02f, 7.93693736e-02f, 6.91961497e-02f, -1.28840789e-01f, 1.13213785e-01f,
  1.57475039e-01f, 6.60298988e-02f, -1.33087307e-01f, 3.34587172e-02f, 4.26302999e-02f, 2.68009573e-01f, 1.06469549e-01f, -9.13453624e-02f, 1.75742328e-01f, 2.21661523e-01f,
  -8.96036625e-02f, 9.44618210e-02f, 1.20656425e-02f, 1.61345407e-01f, 5.04332595e-02f, 2.32225433e-01f, -2.01416135e-01f, 8.47614408e-02f, 1.39595315e-01f, 2.40561739e-01f,
  2.01127172e-01f, -1.04177296e-01f, -1.12173475e-01f, 6.88323006e-02f, 1.23349898e-01f, 1.58664197e-01f, 2.78278459e-02f, 8.36218521e-02f, 1.00420855e-01f, 1.12656303e-01f,
  -4.08979170e-02f, 7.54333735e-02f, 5.82604185e-02f, 7.72398431e-03f, 1.11210056e-01f, 8.21537003e-02f, 5.31103760e-02f, 6.65892672e-04f, 3.24503519e-02f, -4.49035689e-02f,
  2.20863104e-01f, 5.45756146e-02f, 7.81092718e-02f, -1.70094162e-01f, -4.61172834e-02f, -2.51830593e-02f, -4.78924513e-02f, 7.35279769e-02f, 2.98969094e-02f, -7.37829208e-02f,
  1.82314999e-02f, 2.73559541e-01f, 1.07711449e-01f, 1.69900358e-02f, -1.11350063e-02f, 8.09150264e-02f, -2.27637179e-02f, -1.37995318e-01f, -1.15551114e-01f, -1.01445071e-01f,
  7.31203258e-02f, 2.34231085e-01f, -3.65728326e-02f, 1.21068306e-01f, 7.25971684e-02f, 1.97501883e-01f, -3.82520333e-02f, -1.75699651e-01f, 1.25889570e-01f, 2.06030294e-01f,
  -1.42230121e-02f, -3.86126488e-02f, 2.00039316e-02f, 2.00437084e-02f, -1.18955724e-01f, 1.41332686e-01f, 5.55211827e-02f, 8.35521594e-02f, 3.35505717e-02f, -7.14581981e-02f,
  -1.04731649e-01f, 2.34404102e-01f, 8.03687051e-02f, -1.64302409e-01f, 1.52676165e-01f, -1.74074486e-01f, -3.45908441e-02f, 3.87211740e-01f, 1.47498712e-01f, 6.36763647e-02f,
  -5.77666238e-02f, 1.49121270e-01f, 1.44368699e-02f, 9.54654515e-02f, 7.33291451e-03f, 1.12223439e-01f, 6.17945977e-02f, 6.69280887e-02f, 2.20176037e-02f, 6.77901581e-02f,
  4.46270332e-02f, -3.44682597e-02f, 6.34814799e-02f, -4.19498496e-02f, 1.68523535e-01f, 6.46870509e-02f, 1.21227033e-01f, 3.55118252e-02f, 7.57423863e-02f, 9.76344943e-02f,
  -1.63103938e-01f, -1.03043824e-01f, 1.98816121e-01f, 2.80453235e-01f, -5.43693937e-02f, 2.64688998e-01f, 1.10216752e-01f, -5.11702709e-02f, 2.25795835e-01f, -2.55513728e-01f,
  1.01641312e-01f, -5.73019758e-02f, -1.08136050e-02f, 2.47423742e-02f, 1.75481856e-01f, -8.95298645e-03f, -1.36359036e-01f, 2.20182404e-01f, 2.17142060e-01f, 7.00007901e-02f,
  -1.29687741e-01f, 1.60933360e-01f, -8.03858340e-02f, 9.83282104e-02f, -8.61219876e-03f, 8.36250931e-03f, 2.49229576e-02f, 2.18816996e-01f, 5.49478382e-02f, 1.98866010e-01f,
  6.03064857e-02f, 5.71520515e-02f, 2.34794423e-01f, -6.78856373e-02f, -1.80388302e-01f, 1.43885806e-01f, 3.08978468e-01f, 2.15414107e-01f, 1.91162214e-01f, 8.22566915e-03f,
  -6.72117993e-02f, 5.72691746e-02f, 7.79974610e-02f, 3.54131870e-02f, -2.14135703e-02f, 1.83049813e-01f, 2.19410345e-01f, 2.51698524e-01f, 1.66280698e-02f, 5.41897342e-02f,
  2.25961450e-02f, -1.11393165e-02f, 8.15423131e-02f, 1.57924026e-01f, 1.39550969e-01f, 1.18451849e-01f, 1.97774649e-01f, 1.97956800e-01f, 1.02118216e-01f, 1.42364487e-01f,
  1.05434425e-01f, 2.88413186e-02f, 4.76670980e-01f, 2.69638915e-02f, -9.82106477e-02f, 1.10465005e-01f, 4.22508083e-02f, 2.13153601e-01f, 5.57535663e-02f, 2.39087209e-01f,
  2.01555878e-01f, -8.40379521e-02f, 2.28605345e-01f, -2.17002258e-01f, 1.52844697e-01f, -3.64530832e-02f, -1.31728947e-01f, 1.13501728e-01f, -2.17030589e-02f, 1.28404841e-01f,
  -2.26697430e-01f, 3.42596322e-02f, 1.29947096e-01f, 9.67873111e-02f, -8.64624903e-02f, 2.12485760e-01f, 1.54885978e-01f, 7.13133737e-02f, 1.65682212e-01f, -1.24038689e-01f,
  2.27979004e-01f, 2.00146601e-01f, 1.37198061e-01f, -6.30360320e-02f, 1.31822065e-01f, -8.51334706e-02f, -2.15944294e-02f, 1.44817486e-01f, -1.80956766e-01f, 8.81229807e-03f,
  6.53477907e-02f, 4.16258931e-01f, 1.00693349e-02f, -1.94002032e-01f, 6.58795424e-03f, 2.88680166e-01f, -1.23122126e-01f, 1.64540574e-01f, 2.52886474e-01f, 6.15534894e-02f,
  -1.24205723e-01f, 7.69857839e-02f, 7.65227899e-02f, 1.25631347e-01f, 1.04538828e-01f, 7.57116824e-02f, 8.36506933e-02f, 1.41514212e-01f, 2.18292512e-02f, 2.28374172e-02f,
  8.52632150e-02f, -2.20949557e-02f, 1.21638484e-01f, -5.80350161e-02f, 6.27245232e-02f, -3.54409486e-01f, 6.79305345e-02f, -2.37635389e-01f, 2.79412329e-01f, -1.30877063e-01f,
  -2.35166743e-01f, -7.15743601e-02f, -3.58597934e-02f, -3.79191712e-02f, -1.79484457e-01f, 1.21357419e-01f, -1.90103874e-01f, 2.02950835e-01f, 3.64117548e-02f, 1.11522004e-01f,
  6.23922609e-03f, 1.98050931e-01f, 1.35944681e-02f, 9.58034694e-02f, 5.73151335e-02f, -9.75572765e-02f, -6.70039132e-02f, -2.00455561e-01f, 2.33173087e-01f, -4.69663646e-03f,
  2.85685569e-01f, -7.95059875e-02f, 2.35236228e-01f, 1.07905760e-01f, 2.55781710e-01f, -1.67480096e-01f, 4.81959879e-02f, 1.00077942e-01f, -3.55498902e-02f, 6.50825202e-02f,
  6.70239031e-02f, 1.26937836e-01f, 1.09866187e-01f, -4.24634777e-02f, -7.16602011e-03f, -1.63420424e-01f, -2.38767713e-02f, -4.65440899e-02f, 3.75693478e-02f, 1.87607914e-01f,
  -8.74833539e-02f, 1.23759106e-01f, 2.29465023e-01f, 9.05613527e-02f, 3.27524878e-02f, 5.65727353e-02f, 9.29482654e-02f, 1.63862184e-01f, 1.09607093e-01f, 5.31381741e-02f,
  1.47489414e-01f, 1.08589672e-01f, 5.19861877e-02f, 1.30542159e-01f, 1.46000564e-01f, -5.80334142e-02f, 2.41620883e-01f, 4.67444062e-02f, 6.63396865e-02f, -2.54796714e-01f,
  7.07110167e-02f, -5.03240898e-02f, 1.43888459e-01f, -2.15368494e-01f, 7.17669055e-02f, -4.84329648e-02f, -1.25227019e-01f, -1.24570178e-02f, -7.94192255e-02f, 2.74208398e-03f,
  -3.33472416e-02f, 1.28339812e-01f, -2.60934848e-02f, 1.97997224e-02f, 8.29548389e-02f, 5.22683421e-03f, 1.13512404e-01f, 8.66115913e-02f, 1.33812577e-01f, -9.72746909e-02f,
  -1.70353338e-01f, 1.96574777e-01f, 4.18782718e-02f, -1.85320139e-01f, 2.88402706e-01f, -1.66141257e-01f, 2.63763607e-01f, 5.74906729e-02f, 1.16630360e-01f, -3.31410840e-02f,
  -1.29692212e-01f, -8.68579000e-02f, -1.59192875e-01f, -9.47770327e-02f, 1.01661287e-01f, 8.38237852e-02f, 1.35931345e-02f, -1.00430317e-01f, -6.76839277e-02f, -2.22561300e-01f,
  1.11634061e-01f, 1.57304093e-01f, 2.04155520e-02f, 2.69032508e-01f, 1.14763968e-01f, 9.23654586e-02f, 1.83340341e-01f, 8.20547063e-03f, 4.62064482e-02f, 1.98244676e-02f,
  5.32046929e-02f, 2.07076699e-01f, 8.42713043e-02f, 1.43150091e-01f, 1.29052803e-01f, 9.20282230e-02f, 3.55471447e-02f, 4.27426286e-02f, 1.12017348e-01f, 6.13191761e-02f,
  1.30058661e-01f, 1.28197474e-02f, 1.11459501e-01f, -8.68947208e-02f, -1.43654495e-01f, 3.41046136e-03f, 4.52900752e-02f, -2.96325237e-01f, 2.05157906e-01f, 1.26726791e-01f,
  -1.83568850e-01f, -9.73260961e-03f, -2.42724448e-01f, 1.98037177e-01f, -1.01963378e-01f, 1.78452358e-01f, 5.00585288e-02f, 3.90869826e-02f, 1.03346869e-01f, 1.95703506e-01f,
  1.63309664e-01f, -1.95327774e-01f, 1.61182687e-01f, 6.05272204e-02f, -1.64832901e-02f, -1.09856157e-02f, 1.48908779e-01f, 4.58370894e-02f, -1.37534380e-01f, -3.56680006e-01f,
  9.64388438e-03f, 2.94350117e-01f, 7.21092802e-03f, -2.05100536e-01f, 1.84701011e-01f, 2.46638060e-01f, -9.58505571e-02f, -5.94270900e-02f, 9.70272124e-02f, -2.95138448e-01f,
  1.10368006e-01f, -4.68714461e-02f, 1.09079383e-01f, -7.21305385e-02f, 2.54406929e-01f, 2.80008197e-01f, 8.06424320e-02f, -1.71332970e-01f, 1.75945565e-01f, 9.83540155e-03f,
  9.82088074e-02f, 7.87570775e-02f, 1.77590057e-01f, 1.43387109e-01f, 1.31591484e-01f, 9.89364386e-02f, 1.63765445e-01f, -8.92397016e-04f, 1.60299227e-01f, 1.72194466e-01f,
  9.17347446e-02f, 5.33755310e-02f, 1.14636466e-01f, 9.81207788e-02f, 8.31854790e-02f, 2.43750826e-01f, 1.58406198e-01f, 3.75245601e-01f, -2.43002120e-02f, 2.32530460e-01f,
  1.76854618e-03f, 1.90231726e-02f, -3.94947128e-03f, 7.80554265e-02f, 2.74517000e-01f, 1.16077056e-02f, -1.53542474e-01f, -1.83793306e-01f, 2.24998206e-01f, -2.69077808e-01f,
  1.05993524e-01f, 1.27010822e-01f, -1.35085434e-01f, -1.23080902e-01f, -2.17002332e-01f, -1.19020186e-01f, 5.45254350e-02f, -6.67592213e-02f, 2.13825077e-01f, -6.40994385e-02f,
  -5.52996956e-02f, 3.24532479e-01f, -1.21042736e-01f, 3.28699440e-01f, -8.12093392e-02f, 1.18107110e-01f, 3.27993296e-02f, 2.15035349e-01f, 2.29791608e-02f, 2.11529359e-01f,
  -7.47267380e-02f, 3.31300020e-01f, 2.79140413e-01f, 1.14126176e-01f, -1.12667114e-01f, -3.25357392e-02f, 1.40228271e-01f, 1.75728239e-02f, 4.75540385e-02f, 2.14861393e-01f,
  1.29058519e-02f, -2.88498104e-01f, 1.26250818e-01f, 8.44611526e-02f, 9.47658494e-02f, 2.35401820e-02f, 7.37748146e-02f, 1.39098123e-01f, 1.03186304e-02f, 7.10588172e-02f,
  4.97290082e-02f, 1.29677176e-01f, 1.08029731e-01f, 1.13868795e-01f, 1.87140435e-01f, 1.47141472e-01f, 5.29737622e-02f, 1.50203258e-01f, -2.17572264e-02f, 1.90992728e-01f,
  1.26013815e-01f, 1.61242247e-01f, -3.54591608e-01f, 4.58520502e-02f, 5.35008237e-02f, 1.66961566e-01f, -1.45626262e-01f, -2.42858604e-01f, 2.84597665e-01f, -2.51896471e-01f,
  -1.90902576e-01f, -4.61407267e-02f, 4.33479324e-02f, 1.25225680e-02f, -9.91352797e-02f, 3.04603651e-02f, 3.21888290e-02f, -5.48798069e-02f, -2.78530687e-01f, -1.18906192e-01f,
  5.75010851e-02f, -6.88440576e-02f, 1.26529351e-01f, -9.69410092e-02f, 1.48896366e-01f, 2.29089901e-01f, -2.28934899e-01f, 2.49163210e-01f, -1.05080068e-01f, 4.98636113e-03f,
  7.10812956e-02f, -4.18196097e-02f, 1.62312999e-01f, -2.18134802e-02f, 8.12145248e-02f, 2.27730215e-01f, 6.70225173e-02f, -1.13116100e-01f, 1.67760015e-01f, 6.48811609e-02f,
  -3.12068444e-02f, -3.59930173e-02f, -2.11688846e-01f, 3.20184588e-01f, 2.47103631e-01f, -2.35660464e-01f, -5.47318086e-02f, 1.51302248e-01f, 2.00242698e-01f, 1.24414213e-01f,
  5.88605553e-02f, 1.19089641e-01f, 6.10372424e-02f, 9.05546173e-02f, 1.51722044e-01f, 1.03817344e-01f, 2.15869322e-01f, 1.32435277e-01f, 1.24574825e-01f, 3.73073593e-02f,
  5.25322035e-02f, 1.59137949e-01f, 3.23682018e-02f, 8.27238411e-02f, 1.65063322e-01f, 5.73343895e-02f, 9.04174894e-02f, -3.83333787e-02f, 1.72817007e-01f, 1.05345182e-01f,
  -1.26186639e-01f, -1.49631768e-01f, 2.05696344e-01f, -7.27470666e-02f, -1.24272734e-01f, -5.22420369e-02f, -6.00592792e-02f, 1.77450236e-02f, -5.56519441e-02f, 1.08999975e-01f,
  -1.15871757e-01f, -5.34712039e-02f, -1.90136746e-01f, 7.00985491e-02f, 1.27447248e-01f, -7.73786679e-02f, 1.25096262e-01f, 2.34393310e-02f, 1.02398604e-01f, -6.10209107e-02f,
  -1.02283403e-01f, 2.14296043e-01f, -1.58896167e-02f, 3.29553895e-02f, 4.48593684e-02f, 4.14928049e-02f, -2.78439242e-02f, -3.86134312e-02f, -3.80006284e-02f, 6.21719100e-02f,
  3.59112471e-02f, 2.97547817e-01f, 6.20290004e-02f, 5.62397502e-02f, -9.05149728e-02f, -1.06930345e-01f, 4.41676565e-03f, 7.35744759e-02f, 8.47034231e-02f, -2.75772624e-02f,
  -2.12619767e-01f, 1.33047998e-01f, 1.20469362e-01f, 1.64278984e-01f, -3.77430394e-02f, 6.18333602e-03f, 1.28982842e-01f, 3.51570174e-03f, 4.67520393e-02f, 3.93762104e-02f,
  1.42564014e-01f, 1.02019280e-01f, 2.15831287e-02f, 1.00325495e-01f, 1.01983562e-01f, 9.04113799e-02f, 8.15668479e-02f, 5.81731368e-03f, 1.05491690e-01f, -1.19989187e-01f,
  1.89366251e-01f, -1.40604705e-01f, 3.37527424e-01f, 6.52376190e-02f, -2.33581215e-01f, -2.03898475e-01f, -8.07263143e-03f, -2.46024519e-01f, -1.36155307e-01f, 1.18907932e-02f,
  -1.28766969e-01f, 1.46671444e-01f, 8.99641514e-02f, 1.25139028e-01f, -9.05274786e-03f, -1.27799258e-01f, -7.92810991e-02f, -3.68234664e-02f, 1.93480551e-01f, -6.06697202e-02f,
  -1.20783849e-02f, -4.57000956e-02f, 1.65162504e-01f, -2.06828251e-01f, 1.44663498e-01f, -4.53114584e-02f, 1.37159914e-01f, -7.41388202e-02f, 7.85384551e-02f, 9.36266333e-02f,
  -1.26424879e-01f, 1.42050870e-02f, -5.72800543e-03f, -7.09784627e-02f, 6.72931075e-02f, 3.55328083e-01f, 1.20099343e-01f, -9.16897058e-02f, -3.45074348e-02f, -1.64088100e-01f,
  -8.03777352e-02f, 1.59148082e-01f, -2.98951697e-02f, 4.70765568e-02f, -2.13589147e-02f, 1.83954701e-01f, 7.53637329e-02f, 1.61697879e-01f, -1.64626874e-02f, 2.11257897e-02f,
  7.67616630e-02f, 1.33058399e-01f, 8.59528556e-02f, 1.21451437e-01f, 1.69849917e-01f, 1.81411907e-01f, -4.20395061e-02f, 9.23862308e-03f, -6.86129332e-02f, -6.42502606e-02f,
  9.60141793e-02f, 1.04283102e-01f, 2.32783273e-01f, -4.07716818e-02f, -2.86807656e-01f, 1.12297572e-01f, 1.04574151e-01f, -1.37865439e-01f, -1.79494414e-02f, -9.78707001e-02f,
  -6.99707493e-02f, -6.85493499e-02f, -2.22780734e-01f, 7.57311210e-02f, -3.84084992e-02f, 1.54857114e-01f, -8.80532246e-03f, 1.12584338e-01f, 1.27820358e-01f, -1.73074469e-01f,
  8.79458785e-02f, -9.93200764e-02f, 2.38202304e-01f, 7.14290738e-02f, 7.24978670e-02f, 4.51521054e-02f, 6.51730895e-02f, -5.28382249e-02f, 1.60700336e-01f, -1.39436856e-01f,
  3.47537212e-02f, 1.16996221e-01f, 2.10652370e-02f, 4.92092855e-02f, -1.98551223e-01f, 2.57158160e-01f, -1.37646139e-01f, 2.03922346e-01f, 3.03879142e-01f, -2.11360920e-02f,
  8.49323943e-02f, 6.96523041e-02f, 2.02574775e-01f, -3.01312983e-01f, -9.06489715e-02f, 3.74691784e-01f, 1.68309305e-02f, -1.38998076e-01f, 2.15668187e-01f, 2.68856548e-02f,
  1.85122579e-01f, -6.15837201e-02f, -7.03463738e-04f, -1.71254128e-02f, -3.17734070e-02f, 1.45329565e-01f, 3.07250582e-02f, 1.67073995e-01f, 1.15456350e-01f, -5.06566428e-02f,
  3.29563431e-02f, 6.85528144e-02f, 6.87918589e-02f, 2.34060094e-01f, -4.47776988e-02f, 1.32056788e-01f, -1.95736601e-03f, -6.70649037e-02f, -1.59124821e-01f, -2.90400207e-01f,
  8.93856958e-02f, 1.84757560e-02f, -1.28243849e-01f, -7.73429424e-02f, 1.16615318e-01f, -3.01313370e-01f, -1.50469884e-01f, 2.10272804e-01f, -1.92947716e-01f, 5.73583059e-02f,
  -3.28816436e-02f, -1.23406522e-01f, 3.64016145e-02f, 4.01927233e-01f, -1.59305856e-01f, -8.92396122e-02f, 1.13460645e-01f, 3.75996195e-02f, 1.44593596e-01f, -2.32511550e-01f,
  2.65973389e-01f, 2.18841895e-01f, -2.96772897e-01f, -2.25571126e-01f, -1.62789211e-01f, 1.72721252e-01f, 2.08336622e-01f, -3.58527064e-01f, 3.18195492e-01f, 1.64749891e-01f,
  1.74008355e-01f, -1.36655390e-01f, -1.01344317e-01f, -1.01351723e-01f, 2.88575739e-01f, 1.38681093e-02f, -3.83716114e-02f, 8.71682093e-02f, 1.57423667e-03f, -1.40351415e-01f,
  2.20248938e-01f, -5.40933870e-02f, -7.14783520e-02f, 1.25195906e-01f, 1.45499066e-01f, 1.39619604e-01f, -2.59294435e-02f, 5.46843894e-02f, 8.32066908e-02f, 7.69424066e-02f,
  2.24066779e-01f, 1.91842496e-01f, 1.65570136e-02f, 7.42252693e-02f, 6.15825243e-02f, 9.82027426e-02f, 1.41531192e-02f, -1.63069218e-01f, 1.28425688e-01f, -8.34826007e-02f,
  1.09953977e-01f, 9.82049038e-04f, -1.39487416e-01f, 1.22100554e-01f, 7.64698908e-02f, -2.64145166e-01f, 2.37592142e-02f, -7.58266868e-03f, -2.06076175e-01f, -1.00820631e-01f,
  1.16763972e-02f, 2.99297441e-02f, -6.64625242e-02f, 1.29306093e-01f, -3.06649879e-02f, 1.62955046e-01f, 1.81139097e-01f, -1.92928314e-01f, 1.68923199e-01f, -1.08055741e-01f,
  1.35727346e-01f, 1.14717335e-02f, -2.31444970e-01f, 1.71972305e-01f, 2.94913314e-02f, -1.50285855e-01f, 2.08009213e-01f, -2.44087130e-01f, 2.51409650e-01f, 1.57512128e-01f,
  -7.04897707e-03f, 7.07182959e-02f, -1.02698170e-01f, -9.98139456e-02f, -1.95519716e-01f, -9.74922180e-02f, 3.25340807e-01f, -1.71522442e-02f, 8.81862268e-02f, -1.26771539e-01f,
  5.39041683e-02f, -2.43729040e-01f, 4.01842780e-02f, 3.21336061e-01f, -7.05948891e-03f, -1.23439513e-01f, 3.15868467e-01f, 2.15313658e-02f, 1.18324690e-01f, 6.95160683e-03f,
  1.28464177e-01f, 1.18340380e-01f, 7.84766302e-02f, 7.27930367e-02f, 1.50748655e-01f, 1.28405258e-01f, 1.89065054e-01f, -2.60808319e-02f, 8.48001540e-02f, 1.92626297e-01f,
  1.94984227e-01f, 2.15099528e-01f, -4.71387729e-02f, 8.61258060e-02f, 6.02088533e-02f, 1.07972831e-01f, -6.54801785e-04f, -6.33538067e-02f, 9.00414214e-02f, 1.54603899e-01f,
  -4.38205749e-02f, -6.13955148e-02f, 2.26530045e-01f, -1.41967297e-01f, -1.59841388e-01f, -5.84433973e-02f, -7.57976994e-02f, -6.10938556e-02f, -7.91871920e-02f, 7.44031444e-02f,
  -1.42268017e-01f, 2.56388307e-01f, -2.52316713e-01f, 3.09922080e-02f, -8.10013637e-02f, -7.52190053e-02f, 9.56673399e-02f, -2.22749025e-01f, 1.26764745e-01f, 2.50977993e-01f,
  -2.37361968e-01f, 2.52480477e-01f, -6.35283962e-02f, 2.86980718e-02f, 2.53679603e-01f, -2.00084031e-01f, 2.45899037e-01f, -6.35974631e-02f, 3.91151709e-03f, -3.15185376e-02f,
  -3.16809565e-01f, 1.02002293e-01f, 8.13805908e-02f, -9.02740583e-02f, -1.77746251e-01f, 1.22059859e-01f, 1.16251409e-01f, -1.33239916e-02f, 1.57726601e-01f, -1.51641756e-01f,
  -4.83767949e-02f, 8.33991542e-02f, 1.87175885e-01f, 1.42695233e-01f, 7.49301240e-02f, 6.31541535e-02f, 5.77925481e-02f, -3.32671814e-02f, 1.17054902e-01f, 1.08668864e-01f,
  5.80138080e-02f, 1.36584967e-01f, 1.07887030e-01f, 2.97487583e-02f, 1.20507389e-01f, 1.10756308e-01f, 3.66665684e-02f, -4.15693484e-02f, 5.25585599e-02f, -5.76109067e-02f,
  4.38945964e-02f, -2.66870018e-02f, 1.64672151e-01f, 1.46225348e-01f, -1.35756761e-01f, -2.09848970e-01f, 5.40120117e-02f, -2.24705890e-01f, 7.91888125e-03f, -5.67753874e-02f,
  -1.14054896e-01f, 4.94869761e-02f, -7.54373670e-02f, 1.17550500e-01f, 8.58725682e-02f, -1.36404350e-01f, -6.79877549e-02f, 4.45079654e-02f, 1.12925492e-01f, -5.31579815e-02f,
  -6.38068318e-02f, 1.14063948e-01f, 9.01530385e-02f, -1.65624142e-01f, 1.75632626e-01f, 1.99800804e-01f, 1.52852207e-01f, -1.43053368e-01f, 2.25831605e-02f, 1.29125684e-01f,
  -1.23286434e-01f, -1.91502795e-01f, 2.25653667e-02f, 1.49360299e-02f, 7.06375912e-02f, 3.23760957e-01f, 1.03736423e-01f, 1.92678906e-02f, -8.16826075e-02f, -1.92460626e-01f,
  -4.68570739e-02f, 1.25115246e-01f, 1.05429299e-01f, 8.75096843e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  2.52427049e-02f, -1.03702042e-02f, 9.31024477e-02f, 6.17661737e-02f, 8.50920975e-02f, 1.35436445e-01f, 5.18170558e-02f, 1.50448143e-01f, -2.60079768e-03f, 8.18423256e-02f,
  1.83688045e-01f, 6.54422045e-02f, 7.94663578e-02f, 1.23241074e-01f, 1.10762939e-01f, 5.23696840e-02f, 1.59229606e-01f, 1.81884363e-01f, 1.15674458e-01f, 4.32997830e-02f,
  1.30408600e-01f, 1.68719381e-01f, 7.09224343e-02f, 3.34921405e-02f, 4.34967577e-02f, 9.98443738e-02f
};

// L2_fan_Wp (Shape: 19 x 64)
const int L2_fan_Wp_rows = 19;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  7.00995922e-02f, 3.97089832e-02f, 5.68880960e-02f, 6.96787313e-02f, 2.04415515e-01f, -1.66262835e-02f, 6.60051703e-02f, 3.13484184e-02f, 1.16201654e-01f, 1.18127108e-01f,
  5.36544323e-02f, 1.03880027e-02f, -3.10859866e-02f, -8.16238578e-03f, 5.11424150e-03f, 4.86783832e-02f, 4.68639135e-02f, 3.50277498e-02f, 1.01006124e-02f, -8.64203945e-02f,
  2.74948031e-02f, -6.92041591e-02f, -1.45095494e-02f, -2.61807665e-02f, 1.51647523e-01f, -1.67982858e-02f, 2.68864706e-02f, 5.87889180e-02f, 6.35981113e-02f, -9.73262414e-02f,
  1.16555355e-01f, -1.13243394e-01f, 1.00194663e-01f, -3.71950865e-02f, -3.44681218e-02f, -4.89422195e-02f, -5.43164201e-02f, -6.68091141e-03f, 1.80500865e-01f, 1.73946723e-01f,
  1.99684221e-02f, 4.30001020e-02f, 4.71666493e-02f, -4.12620381e-02f, 1.76861256e-01f, 1.54710293e-01f, 1.27900422e-01f, 1.63267702e-01f, 4.59044129e-02f, 2.08306640e-01f,
  1.40787885e-01f, -1.18372235e-02f, 2.00378120e-01f, 2.15656489e-01f, 1.54682100e-01f, -8.98265913e-02f, -7.75661319e-02f, 8.64290446e-02f, 7.14559481e-02f, 1.66989326e-01f,
  1.11255525e-02f, 2.01093435e-01f, -1.77459076e-01f, 2.62217466e-02f, -1.56425416e-01f, -1.94942951e-02f, 6.03390411e-02f, -8.53672847e-02f, -5.05148768e-02f, -4.16728333e-02f,
  -5.05685732e-02f, -4.29940447e-02f, 2.10442971e-02f, 7.05457032e-02f, 1.88236814e-02f, 4.12658155e-02f, -4.55830507e-02f, 6.92858268e-03f, -9.29127783e-02f, -7.98485354e-02f,
  -3.46257761e-02f, 9.45659131e-02f, -9.78743359e-02f, 3.99137512e-02f, 5.03653921e-02f, -7.87829831e-02f, 6.56547919e-02f, -1.91900171e-02f, 1.31636839e-02f, 2.32301485e-02f,
  5.93975186e-02f, 6.66062459e-02f, -3.03930342e-02f, -8.19399953e-02f, 1.94618106e-02f, 6.19938150e-02f, 1.09626628e-01f, 7.12502934e-03f, 1.55192211e-01f, -3.49775739e-02f,
  1.61071748e-01f, 8.73480961e-02f, 5.28387949e-02f, -1.54328495e-01f, -1.47253245e-01f, -5.66223590e-03f, -6.03665272e-03f, -5.77601679e-02f, -1.30745307e-01f, -3.38757373e-02f,
  -6.14192896e-02f, -2.58047935e-02f, 4.09535744e-04f, -4.08399850e-02f, 7.53382221e-02f, -3.63170095e-02f, 5.90895303e-03f, 6.33977875e-02f, 2.47402098e-02f, 1.72038272e-01f,
  -8.56416449e-02f, 5.76029494e-02f, 3.00418008e-02f, 1.79978624e-01f, -2.17993692e-01f, 2.37499475e-01f, -1.13819353e-01f, 2.55894233e-02f, 3.14535126e-02f, -9.22961161e-03f,
  3.60431825e-03f, 3.93752754e-02f, -6.87493831e-02f, 6.97642267e-02f, -8.28789473e-02f, 1.11577161e-01f, -9.68353078e-02f, -1.41913220e-01f, 5.58192395e-02f, -1.54867202e-01f,
  4.49155867e-02f, 1.37493862e-02f, 4.99559119e-02f, 6.90324083e-02f, 7.03113666e-03f, 3.66941132e-02f, -6.88666776e-02f, 7.24259838e-02f, 9.88916308e-03f, -2.48032669e-03f,
  7.81583786e-03f, 3.62957492e-02f, -1.46340564e-01f, 2.77324189e-02f, -6.68714419e-02f, -8.09834823e-02f, -2.84003280e-02f, 1.08012848e-01f, -8.63865688e-02f, -9.65872139e-04f,
  -1.09363813e-02f, 2.15192065e-02f, -5.87497577e-02f, -4.83538508e-02f, -5.70703186e-02f, -1.08989134e-01f, -9.93343070e-02f, 1.55304030e-01f, -1.26282975e-01f, -1.14259303e-01f,
  1.32983685e-01f, -6.64895549e-02f, -2.19215304e-02f, -9.62169617e-02f, 1.28183588e-01f, 2.84529142e-02f, -2.44748257e-02f, 7.18645379e-02f, -2.93268338e-02f, -1.92568824e-02f,
  -7.50402268e-03f, -1.12672187e-01f, 2.88379043e-02f, 4.07961048e-02f, 1.17082015e-01f, 6.03365190e-02f, -5.74387982e-02f, -8.45918134e-02f, 1.91837117e-01f, -1.30871370e-01f,
  3.11146025e-02f, -6.27476424e-02f, 1.42046213e-01f, 3.79553474e-02f, 1.05962679e-02f, 1.25854880e-01f, 4.96285073e-02f, 3.56613807e-02f, 4.63483185e-02f, 2.21524481e-02f,
  2.74096429e-02f, 1.10705145e-01f, 7.01691583e-02f, 3.90983447e-02f, 4.26965654e-02f, 8.09286311e-02f, 1.71304904e-02f, 1.77242644e-02f, -1.43511882e-02f, 2.18834411e-02f,
  8.15828517e-02f, -1.63623631e-01f, 4.99748811e-03f, 6.13298528e-02f, -5.41749485e-02f, -1.23538874e-01f, 5.87318763e-02f, 8.98705702e-03f, 7.92294070e-02f, 1.26706004e-01f,
  -1.30059689e-01f, -1.90685406e-01f, 9.52699259e-02f, -1.03252783e-01f, 3.27884080e-03f, -3.19377594e-02f, 4.91123423e-02f, 5.18000498e-02f, 7.87900239e-02f, 1.17672488e-01f,
  2.27835234e-02f, -1.16075404e-01f, 2.42812812e-01f, 5.60718179e-02f, -1.53611928e-01f, 6.47478253e-02f, -5.46827503e-02f, 1.37942702e-01f, -3.62656601e-02f, 2.09052600e-02f,
  1.82757780e-01f, 1.77837595e-01f, 1.29867256e-01f, 2.60168221e-02f, -8.32343027e-02f, 1.45176100e-02f, -6.76124841e-02f, 1.75511390e-01f, -2.98897233e-02f, -1.62677176e-03f,
  8.77374038e-03f, 5.25366180e-02f, -1.77967906e-01f, 3.17420661e-02f, -7.03983456e-02f, 9.63226929e-02f, -2.72943210e-02f, -1.35379853e-02f, 3.93366218e-02f, -1.08500654e-02f,
  -5.25092222e-02f, 1.03825005e-02f, -3.22304890e-02f, -1.03428937e-01f, -3.98772918e-02f, -1.90387499e-02f, 5.14701148e-03f, -2.61935070e-02f, 7.66092762e-02f, 1.00066721e-01f,
  -4.90682647e-02f, 3.90886664e-02f, 1.09215162e-03f, -1.24829561e-02f, 7.22007975e-02f, -8.69220346e-02f, 2.27912366e-02f, -9.66048613e-02f, 3.62792388e-02f, -5.88756986e-03f,
  5.95634170e-02f, 3.36234123e-02f, 1.07982665e-01f, 9.35075805e-02f, -5.07619884e-03f, -1.51254699e-01f, 4.83366810e-02f, 8.13837424e-02f, -5.05585922e-03f, 9.25184414e-02f,
  1.39524728e-01f, 1.77589785e-02f, 1.45014793e-01f, -1.88643467e-02f, 1.84984077e-02f, -7.44061247e-02f, 9.05071869e-02f, 1.28624350e-01f, -1.91986766e-02f, 1.48219854e-01f,
  -2.87899107e-01f, -8.93909186e-02f, -4.31377962e-02f, 5.80656193e-02f, 1.52998427e-02f, 1.20416060e-02f, 3.35834436e-02f, 4.46729884e-02f, -1.30718052e-01f, -5.96435107e-02f,
  -1.14193968e-01f, 2.61604398e-01f, 8.08092877e-02f, 1.71589211e-01f, 9.54106227e-02f, 4.90711220e-02f, -1.19313024e-01f, -7.17480779e-02f, 6.14284771e-03f, 2.12329756e-02f,
  3.35707515e-03f, -1.33620232e-01f, 1.07387356e-01f, 9.50933620e-02f, -7.99688175e-02f, 4.74375971e-02f, 3.79613526e-02f, 9.08404589e-02f, 6.74161613e-02f, -8.82634893e-03f,
  -3.89631428e-02f, -1.23174198e-01f, 3.11416574e-02f, -2.22484451e-02f, -8.96281898e-02f, -4.51833867e-02f, 6.11359328e-02f, 2.83043981e-02f, 8.01077764e-03f, -1.16824336e-01f,
  7.88450688e-02f, -1.25292033e-01f, 9.46860686e-02f, 1.26129150e-01f, -4.49274778e-02f, -1.12895571e-01f, -6.13182597e-02f, -3.21378559e-02f, 1.36489838e-01f, -9.27299634e-02f,
  -2.47244947e-02f, 4.94595505e-02f, -1.62080079e-02f, -1.34158149e-01f, 3.05664353e-02f, -1.69309184e-01f, -5.98201752e-02f, -3.06838676e-02f, -2.43964028e-02f, 1.58089668e-01f,
  -2.06557825e-01f, -1.13963202e-01f, 7.11272061e-02f, 1.04563281e-01f, 9.31496080e-03f, -4.26889881e-02f, -4.71843518e-02f, 6.67904764e-02f, 3.57010216e-02f, -5.39990440e-02f,
  -5.67889363e-02f, 9.62555185e-02f, 1.56468704e-01f, 9.21380986e-03f, -1.60812154e-01f, -3.19525450e-02f, -1.80974286e-02f, 1.78610962e-02f, 1.52376041e-01f, 5.57829514e-02f,
  1.17752254e-01f, -5.63032068e-02f, -1.83612369e-02f, 9.32186395e-02f, -1.82312638e-01f, -1.45333186e-01f, 1.94591079e-02f, -7.01001137e-02f, -2.98603512e-02f, -5.13623469e-02f,
  -8.46017897e-02f, -6.00149855e-03f, -2.31171376e-04f, -2.28069834e-02f, -4.13176864e-02f, -1.15233865e-02f, -7.96404630e-02f, -1.38956815e-01f, -1.15784556e-01f, -4.25631143e-02f,
  -7.08482862e-02f, 4.73154038e-02f, -1.55258864e-01f, 1.95523426e-01f, 4.24159691e-02f, -1.29911736e-01f, 1.21573202e-01f, 6.52173981e-02f, 1.35292914e-02f, 1.35898992e-01f,
  2.25327667e-02f, 5.68170324e-02f, 7.35798851e-03f, 1.48354128e-01f, 4.60735038e-02f, 1.16236918e-01f, 1.46244228e-01f, -8.33309591e-02f, 1.59718737e-01f, -2.77179349e-02f,
  1.12137944e-01f, -3.92807387e-02f, 4.01380286e-02f, 7.24385232e-02f, -1.61905527e-01f, 3.05305999e-02f, -4.00965044e-04f, -3.85829993e-02f, 7.04819337e-02f, 1.63170025e-02f,
  3.49094011e-02f, -5.51591814e-02f, -9.20890272e-02f, -1.24944977e-01f, -4.58725840e-02f, -8.30045342e-02f, 7.16698840e-02f, 1.34941777e-02f, 9.30447802e-02f, -1.62078500e-01f,
  4.69109602e-02f, -1.72517716e-03f, 4.80313413e-02f, 1.19467743e-01f, 1.88479751e-01f, 3.36899497e-02f, -9.40592811e-02f, -1.93119999e-02f, -3.13164108e-02f, -7.70635605e-02f,
  3.00844992e-03f, -4.66044955e-02f, 1.55911341e-01f, 3.89469378e-02f, 4.91438471e-02f, 5.90612367e-02f, 9.09513831e-02f, -1.59001108e-02f, -1.64615847e-02f, 2.25721858e-02f,
  -1.74959265e-02f, 5.89281172e-02f, -1.30994339e-02f, -3.59589141e-03f, -4.80405875e-02f, -3.25752422e-02f, -5.19168153e-02f, -2.25357205e-01f, 1.68249328e-02f, 5.76950982e-02f,
  -5.05736619e-02f, 8.70586187e-02f, 5.24567775e-02f, -1.05465442e-01f, 3.70719330e-03f, 2.44533401e-02f, -8.41655806e-02f, -9.45065096e-02f, 1.30563527e-01f, -1.51161477e-01f,
  -1.17781930e-01f, -6.07258752e-02f, -5.96014336e-02f, -1.19601592e-01f, 5.20564169e-02f, 1.26217157e-01f, -3.98187935e-02f, 8.67790193e-04f, 4.70275432e-02f, 3.43116093e-03f,
  -1.50643304e-01f, 1.01083070e-01f, 1.66881680e-01f, 3.80083323e-02f, -9.27218571e-02f, 5.65506937e-03f, 1.59521759e-01f, 1.08613446e-01f, 1.26765475e-01f, 1.35818481e-01f,
  -1.78503506e-02f, -6.13831989e-02f, 5.26883872e-03f, -4.43503521e-02f, -1.31869540e-01f, -1.24203555e-01f, 4.17553894e-02f, 2.93744281e-02f, -1.02057509e-01f, 1.05562834e-02f,
  -3.88428159e-02f, -4.26414236e-02f, -1.29647881e-01f, -2.33159564e-03f, -5.39204217e-02f, -8.07776973e-02f, -4.60614115e-02f, -8.47565159e-02f, -4.05618139e-02f, -7.32943937e-02f,
  3.52335274e-02f, -2.17456948e-02f, 5.39304949e-02f, -7.88986310e-02f, 2.29664668e-02f, -4.84094694e-02f, 1.15794227e-01f, 2.41900403e-02f, 6.67714998e-02f, -2.22671009e-03f,
  6.38244599e-02f, 2.03372553e-01f, 4.35454063e-02f, -4.58110310e-02f, -1.52422845e-01f, 1.60551704e-02f, 4.63074148e-02f, 1.43855229e-01f, 1.06378615e-01f, 2.42305592e-01f,
  -1.22851312e-01f, -4.24754387e-03f, 4.36560959e-02f, 3.21387239e-02f, 6.93175495e-02f, 1.73366759e-02f, -4.71123904e-02f, 1.17549673e-01f, -7.69109502e-02f, -6.24079816e-02f,
  -8.33443254e-02f, -4.23517078e-02f, 1.70402631e-01f, 7.06961006e-02f, -1.59131214e-01f, -3.66319679e-02f, -2.22638696e-01f, -3.06918230e-02f, 1.60350382e-01f, 2.24434882e-02f,
  -1.30705044e-01f, 2.23752797e-01f, 5.97497337e-02f, -8.16714838e-02f, -2.67967116e-02f, 1.33310454e-02f, 1.08457714e-01f, 5.57493754e-02f, 1.84784025e-01f, 9.80138257e-02f,
  -1.05343170e-01f, 1.45412341e-01f, 5.31098098e-02f, -1.07327983e-01f, -5.22111282e-02f, -1.05825830e-02f, 1.13484524e-01f, -1.10371344e-01f, -7.68701509e-02f, -1.72512904e-02f,
  -2.26616133e-02f, -1.71092793e-01f, 1.92850847e-02f, -2.01508868e-02f, -1.62853654e-02f, -1.70331597e-01f, -5.78220747e-02f, -1.04867525e-01f, -3.21764499e-02f, -1.25830784e-01f,
  -8.80710706e-02f, -1.72145054e-01f, -5.05511388e-02f, -2.28380337e-02f, -1.04371451e-01f, -1.09030597e-01f, 1.35978283e-02f, -9.19159651e-02f, -1.30552500e-02f, 1.64634541e-01f,
  -1.95718892e-02f, -1.55397132e-01f, 7.22813532e-02f, 4.85792616e-03f, 5.17009608e-02f, -9.35286954e-02f, 9.46850479e-02f, 1.39122037e-02f, -1.40358523e-01f, -9.97016430e-02f,
  -4.02258374e-02f, -1.53659791e-01f, -9.36336145e-02f, 1.06440946e-01f, -6.06465638e-02f, 2.13865489e-01f, -3.37542072e-02f, -2.12467611e-01f, -9.17284191e-02f, 1.29485279e-01f,
  2.02209800e-01f, -5.87221906e-02f, -3.86652425e-02f, 9.18774158e-02f, 2.76282560e-02f, -6.76715225e-02f, -2.89667840e-03f, 6.89374879e-02f, 7.52830058e-02f, 8.64358619e-02f,
  -1.02960072e-01f, -1.94869399e-01f, -2.15891395e-02f, -7.91770592e-02f, 2.14253906e-02f, -7.34214187e-02f, -6.95156381e-02f, -1.40116056e-02f, -6.63824528e-02f, 8.10199305e-02f,
  -5.27168959e-02f, -4.96892743e-02f, -6.68442398e-02f, -8.85485262e-02f, -1.74667031e-01f, -9.40048248e-02f, -6.85210824e-02f, -7.39797130e-02f, -1.56270295e-01f, -8.10951218e-02f,
  -8.94737691e-02f, -1.06581695e-01f, 4.72504273e-02f, 6.69013560e-02f, 4.43836786e-02f, -1.05711343e-02f, 3.19448747e-02f, -7.74640739e-02f, 1.13286162e-02f, 8.45663846e-02f,
  9.38623622e-02f, 6.80810399e-03f, -2.78325267e-02f, -9.59524065e-02f, 9.10386816e-03f, -1.42563591e-02f, 5.70397414e-02f, 3.27544771e-02f, 1.21600114e-01f, 4.35620919e-02f,
  -1.45656288e-01f, 1.06822196e-02f, 5.72293550e-02f, 2.44158413e-02f, -6.60684928e-02f, 8.02045614e-02f, -4.97527383e-02f, -1.98582392e-02f, -7.52679184e-02f, 3.14696319e-02f,
  4.37022857e-02f, 7.54780397e-02f, 1.39371585e-02f, 1.47894308e-01f, -1.33980870e-01f, -1.18066587e-01f, 1.41923264e-01f, -3.43097299e-02f, -1.26767561e-01f, -8.57159942e-02f,
  -1.62060782e-01f, -1.76403999e-01f, -2.01056376e-02f, 1.24425152e-02f, -1.42153740e-01f, 4.79574911e-02f, 1.55145824e-01f, 4.40132879e-02f, -1.90701764e-02f, 1.69731956e-02f,
  1.69987381e-01f, -7.88409114e-02f, 1.88698560e-01f, 3.38377915e-02f, 1.19363260e-03f, 4.85332012e-02f, -9.46627855e-02f, -6.20239787e-02f, -9.05967355e-02f, 6.50699530e-03f,
  -7.83230215e-02f, -7.31157884e-02f, -2.71302797e-02f, -4.79074046e-02f, -3.26167908e-03f, -3.41124181e-03f, 3.05651445e-02f, 6.04021810e-02f, 5.13606817e-02f, -3.12124193e-02f,
  3.52247199e-03f, 3.77619490e-02f, 4.39965799e-02f, -2.53359112e-03f, 1.01277865e-01f, -9.37249139e-02f, -3.35889831e-02f, -6.71559349e-02f, 6.28507733e-02f, 2.15224940e-02f,
  6.37528747e-02f, 1.56230494e-01f, 1.64455492e-02f, -1.21008664e-01f, -5.28957509e-02f, 1.02082379e-01f, 1.94135369e-04f, 5.22186458e-02f, 1.71481594e-02f, 1.29709512e-01f,
  5.97836487e-02f, 6.80549024e-03f, 1.10979497e-01f, -6.12602979e-02f, 1.72354206e-01f, 1.28636479e-01f, -1.24784289e-02f, 1.33705303e-01f, -8.49558711e-02f, 7.88415745e-02f,
  9.81606618e-02f, 1.12861127e-01f, -8.72037262e-02f, 6.83555156e-02f, -3.07283625e-02f, -1.25010133e-01f, -2.84395311e-02f, 5.29247373e-02f, -8.67320821e-02f, 9.64828581e-02f,
  2.34791934e-01f, 1.86903417e-01f, 5.84708303e-02f, 3.54423863e-03f, 6.91273138e-02f, 1.74444169e-02f, 1.98990852e-01f, 1.54602230e-01f, -2.99883038e-02f, -5.69570530e-03f,
  -1.41623542e-01f, -7.23468559e-03f, 2.17901450e-02f, -5.53925149e-02f, 2.44977907e-03f, 2.97296513e-02f, 2.55999970e-03f, -1.03294007e-01f, -3.95907164e-02f, 4.41418588e-02f,
  -4.05974835e-02f, 1.28480513e-02f, 4.00694124e-02f, -1.09745704e-01f, -7.53770722e-03f, -1.39530776e-02f, 6.83477893e-03f, 2.50217207e-02f, 4.53548022e-02f, -2.32205726e-03f,
  -1.08872071e-01f, 1.15723602e-01f, 3.08256913e-02f, -5.83684444e-02f, 2.66259480e-02f, 4.41512018e-02f, 4.73854728e-02f, -2.14803964e-02f, 1.85272917e-01f, -1.40665114e-01f,
  8.42838213e-02f, 8.25989526e-03f, -5.09690903e-02f, 3.03732883e-02f, -1.73976228e-01f, 1.41667262e-01f, -5.61355650e-02f, 3.17518562e-02f, 5.31971790e-02f, -6.53436631e-02f,
  -2.70373616e-02f, -1.00603752e-01f, 2.15494066e-01f, 1.74526215e-01f, 7.48681352e-02f, 7.63905942e-02f, -3.90744470e-02f, 2.25887075e-01f, 3.87146585e-02f, -7.93328583e-02f,
  6.62010536e-02f, 1.30110338e-01f, 1.17795192e-01f, -4.86420244e-02f, 7.76848232e-04f, -7.96267688e-02f, -1.03818186e-01f, 5.61444424e-02f, 5.67713529e-02f, 4.84473966e-02f,
  -1.48819551e-01f, -2.69601624e-02f, 1.38029590e-01f, 1.59237646e-02f, 3.37255932e-02f, 9.70608070e-02f, 5.80371134e-02f, 8.88848975e-02f, 9.79282558e-02f, 1.79604411e-01f,
  1.82027351e-02f, 8.73987600e-02f, 1.98048856e-02f, -1.35045247e-02f, -4.12318483e-02f, 1.56871639e-02f, 8.05216283e-02f, 7.57894143e-02f, -3.31829558e-03f, 3.83237377e-02f,
  7.27807954e-02f, -3.81817184e-02f, -3.54109262e-03f, 4.86071855e-02f, -3.76338400e-02f, 4.54521040e-03f, 7.78621659e-02f, -1.00732213e-02f, -1.65264711e-01f, -1.49516063e-02f,
  -1.52039319e-01f, -4.73511741e-02f, 1.79414198e-01f, -1.26783356e-01f, 8.82510617e-02f, 1.10566363e-01f, -1.10872826e-02f, -3.21279503e-02f, -4.44868244e-02f, -4.30876650e-02f,
  7.50402138e-02f, 9.71312821e-02f, -4.90930378e-02f, 1.56801846e-02f, -1.14212230e-01f, -1.03312947e-01f, 8.24692547e-02f, 7.26274997e-02f, -1.09516492e-03f, -5.57146780e-02f,
  1.55920550e-01f, 8.32763314e-02f, 1.75426438e-01f, 1.10128969e-01f, -5.79348020e-03f, -4.20949869e-02f, 1.03283882e-01f, 2.40247976e-03f, -4.00445759e-02f, -2.74702795e-02f,
  -5.61263077e-02f, 1.49260312e-01f, -1.09377742e-01f, 9.78296325e-02f, -1.61692247e-01f, -1.62994608e-01f, -3.51274051e-02f, 1.64515711e-02f, 5.38774878e-02f, 2.92162132e-02f,
  3.04253884e-02f, 5.59751270e-03f, 8.11497793e-02f, -3.29238996e-02f, 1.91547964e-02f, -1.95560697e-03f, -1.98740400e-02f, 1.04924768e-01f, -7.74974003e-02f, -3.78173031e-02f,
  2.40860265e-02f, -4.97797132e-02f, -5.72486557e-02f, 2.84835249e-02f, -3.60658132e-02f, -1.10084862e-01f, 6.01417273e-02f, -5.34895286e-02f, 1.64865311e-02f, 4.87463288e-02f,
  1.77674860e-01f, 4.25428711e-02f, 1.77762181e-01f, 1.38953269e-01f, -5.26115671e-02f, -2.08607480e-01f, 1.57418057e-01f, 1.70748278e-01f, 6.70571402e-02f, -5.11678346e-02f,
  1.34195656e-01f, -2.20682956e-02f, 1.55747950e-01f, 1.32677585e-01f, -1.41943451e-02f, -5.23546860e-02f, 1.20739222e-01f, -6.61448464e-02f, -5.10164973e-05f, 1.50133893e-01f,
  -1.55496344e-01f, 1.78562719e-02f, -3.95721272e-02f, 5.88136688e-02f, -8.75862688e-03f, -7.36539066e-03f, -6.94242418e-02f, -1.17180683e-01f, -4.51278277e-02f, 1.93217527e-02f,
  -4.87375855e-02f, -1.92838535e-02f, -2.89854761e-02f, -4.93854210e-02f, 6.91970810e-02f, 9.27448124e-02f, -1.17234036e-01f, 9.91449952e-02f, -1.83047563e-01f, 6.67135343e-02f,
  -3.69875096e-02f, -8.14585686e-02f, 3.39402258e-02f, 9.12979022e-02f, -2.93712188e-02f, 4.85654362e-02f, -9.43925306e-02f, 1.87933460e-01f, 3.08029093e-02f, 3.55195627e-02f,
  8.46430585e-02f, -4.62739654e-02f, 2.03794569e-01f, -1.85474843e-01f, 1.24900658e-02f, 9.06712264e-02f, 1.01559557e-01f, 6.14357404e-02f, 1.76639166e-02f, -1.38547599e-01f,
  -8.13820586e-02f, -4.69955169e-02f, 6.43556491e-02f, -7.79091790e-02f, -9.49135274e-02f, -5.29726148e-02f, -2.43819132e-01f, -7.84640238e-02f, 1.22778334e-01f, -5.21749631e-02f,
  -4.18233089e-02f, -1.40579492e-01f, 7.39033893e-02f, -5.41712381e-02f, -5.07391319e-02f, -1.73383802e-01f, -5.81653677e-02f, -2.24182919e-01f, -2.07292616e-01f, -6.50177225e-02f,
  -1.79152191e-01f, 7.47350976e-02f, 1.78923458e-01f, -1.02269322e-01f, -1.55033752e-01f, -5.82652763e-02f, 7.38930628e-02f, -4.70819958e-02f, -5.82916476e-02f, -2.80345269e-02f,
  -6.34167194e-02f, 1.05559386e-01f, 2.16680959e-01f, 3.72243375e-02f, -1.23764433e-01f, 1.28782347e-01f, -2.12770458e-02f, -8.96890759e-02f, -3.88086103e-02f, 3.88951302e-02f,
  7.87368268e-02f, -9.09952000e-02f, 1.41474739e-01f, -9.68040526e-02f, -2.46248255e-03f, -1.77021567e-02f, -8.49098340e-02f, -1.09143876e-01f, -2.67648716e-02f, -3.22357379e-02f,
  -1.06796660e-01f, -9.58171785e-02f, -5.24660200e-02f, -8.67798254e-02f, 3.17498446e-02f, -1.95545908e-02f, -1.18917018e-01f, 3.80712748e-02f, -6.27993643e-02f, -1.06677040e-01f,
  -1.97997428e-02f, -1.33980233e-02f, -3.67830582e-02f, 1.70866862e-01f, 8.36484134e-02f, 2.35473234e-02f, 8.51249918e-02f, 2.03196481e-02f, 1.63018629e-01f, 4.86522876e-02f,
  7.60592669e-02f, 9.72226188e-02f, -4.90963906e-02f, 4.40880135e-02f, 3.62166055e-02f, 8.44677165e-02f, 1.10725984e-01f, -7.46932477e-02f, 1.01233639e-01f, 8.70360211e-02f,
  5.44792563e-02f, 1.04495518e-01f, 1.48589000e-01f, -1.72545433e-01f, 3.55424508e-02f, -1.06713632e-02f, -1.04503594e-02f, -5.63335419e-02f, -2.89405324e-02f, -4.04593945e-02f,
  1.12293705e-01f, 2.94397399e-02f, -1.08188666e-01f, 9.50182439e-04f, 3.74608077e-02f, -2.38080189e-01f, 5.44151179e-02f, 1.23120174e-02f, 9.78360623e-02f, -3.99282053e-02f,
  -8.32282975e-02f, 8.29269364e-02f, -2.81965919e-02f, 1.63892910e-01f, -4.57713641e-02f, 1.54501215e-01f, -7.96793625e-02f, 1.48374178e-02f, -5.57128116e-02f, 1.53065741e-01f,
  1.82853192e-02f, 8.66341740e-02f, 3.26836593e-02f, 1.66297093e-01f, -3.94736230e-03f, 1.08074799e-01f, 1.69558585e-01f, 8.79668593e-02f, 1.87654961e-02f, 6.20384887e-02f,
  7.69762173e-02f, 1.63891148e-02f, 4.14565057e-02f, -1.46205518e-02f, -1.75075270e-02f, 1.83595881e-01f, 1.35993809e-01f, -6.24745600e-02f, -6.52609840e-02f, 1.08586073e-01f,
  1.68711722e-01f, -1.49637848e-01f, 4.38618995e-02f, 3.20528895e-02f, -3.03655695e-02f, -9.67438295e-02f, 4.52699140e-02f, -8.28710049e-02f, -8.94498229e-02f, 2.69276965e-02f,
  1.61232904e-01f, -7.57855400e-02f, 1.13425009e-01f, 7.86201358e-02f, 9.72499773e-02f, -7.40508437e-02f, 1.57456473e-01f, -1.72608197e-01f, 5.15535362e-02f, 7.72084594e-02f,
  8.24320242e-02f, -1.04853362e-01f, -1.53456241e-01f, 1.86295107e-01f, 6.62163794e-02f, -5.90235628e-02f, 6.51706159e-02f, -1.34805262e-01f, 1.02708731e-02f, 4.80008638e-03f,
  2.06451099e-02f, 1.93273351e-01f, 8.54973793e-02f, 2.57495884e-02f, -1.18303426e-01f, 1.16175219e-01f, 1.44770637e-01f, 4.23941240e-02f, -9.13514197e-02f, 8.36905986e-02f,
  -6.30996227e-02f, 7.30309263e-02f, 1.33751836e-02f, -1.19382180e-02f, 2.74313670e-02f, -5.27237589e-03f, -1.34690717e-01f, -1.26096189e-01f, 3.03919311e-03f, -4.00121771e-02f,
  -7.83511624e-03f, -7.23777562e-02f, -4.14512074e-03f, -1.17376171e-01f, 7.21827894e-02f, -7.56319799e-03f, -4.27197702e-02f, 3.59245054e-02f, -5.14963865e-02f, -6.40205368e-02f,
  2.21678540e-02f, -1.17174819e-01f, -6.56128004e-02f, -1.15887836e-01f, 5.19336946e-03f, -1.73980079e-04f, -9.95649919e-02f, -4.04493585e-02f, 2.33150590e-02f, 1.60424218e-01f,
  1.30622499e-02f, 4.51386906e-02f, -1.68122239e-02f, 5.04265837e-02f, -1.12848528e-01f, -3.94679680e-02f, -1.97928902e-02f, -8.32146183e-02f, 6.00279011e-02f, -6.30972236e-02f,
  -8.74615088e-02f, 1.22326411e-01f, -5.27059310e-04f, 4.87269238e-02f, 9.44599416e-03f, 7.46436119e-02f, -1.45396456e-01f, -8.14072043e-02f, -5.18807471e-02f, 7.06390366e-02f,
  -4.08504680e-02f, 9.62811708e-02f, 8.62735659e-02f, 1.01963110e-01f, -2.33869664e-02f, -5.80403358e-02f, -1.37568906e-01f, 6.33485690e-02f, -2.28891578e-02f, -1.51792099e-03f,
  1.20715778e-02f, -6.29066005e-02f, 9.37257856e-02f, -9.50161219e-02f, -3.54899205e-02f, 1.29555380e-02f
};

// L2_fan_Wp_bar (Shape: 26 x 64)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -2.79898029e-02f, 7.05944598e-02f, -1.10685445e-01f, -3.71075980e-02f, 5.44679239e-02f, -5.94703667e-02f, 5.83833046e-02f, -7.58222118e-02f, -9.09132212e-02f, 7.26665705e-02f,
  7.69212469e-03f, 8.90747383e-02f, -1.25346243e-01f, 7.60064349e-02f, 9.55277234e-02f, 4.75884378e-02f, 1.80938374e-02f, -2.83906367e-02f, 1.20787300e-01f, 1.73809290e-01f,
  1.43110678e-01f, 1.04006439e-01f, 3.32839601e-02f, -8.27450529e-02f, 2.56270677e-01f, 1.87747061e-01f, 1.80289403e-01f, -1.82353575e-02f, -3.52329575e-02f, 8.06219131e-02f,
  1.35640623e-02f, 1.91491649e-01f, 1.20369613e-01f, -1.47852182e-01f, 1.15791917e-01f, 9.41745713e-02f, 9.99495089e-02f, 1.17931053e-01f, 3.55782092e-01f, -3.31359990e-02f,
  2.97232538e-01f, 3.31152952e-03f, 8.82650390e-02f, 1.18740864e-01f, 1.13573037e-01f, 1.81643173e-01f, 1.68068007e-01f, 2.27632448e-01f, -4.69155312e-02f, 1.23958305e-01f,
  -1.63323522e-01f, -1.97539017e-01f, 1.56115890e-01f, 1.67839348e-01f, 1.51435271e-01f, -4.41704765e-02f, 2.09905937e-01f, 1.62417054e-01f, 3.05461913e-01f, 2.23308817e-01f,
  9.96886641e-02f, 2.38737151e-01f, 5.03770486e-02f, 2.77599722e-01f, 2.16692612e-02f, 4.51407172e-02f, 1.81083262e-01f, -1.90720763e-02f, 1.08829170e-01f, 7.66822025e-02f,
  -1.46998428e-02f, 7.02998787e-02f, 1.24363877e-01f, 1.22791141e-01f, 7.28172585e-02f, 4.56418581e-02f, 8.28816518e-02f, -9.54494476e-02f, -4.60899025e-02f, 3.91836977e-03f,
  1.18132979e-01f, -1.45707233e-02f, 8.41434449e-02f, -2.00966582e-01f, -2.43408576e-01f, 1.32186264e-01f, -2.01281041e-01f, -3.24385837e-02f, -1.23925418e-01f, -9.82488096e-02f,
  -1.54205814e-01f, 3.03768869e-02f, -1.52765036e-01f, -5.36845252e-02f, 1.62322417e-01f, -1.99907690e-01f, -1.34516820e-01f, 6.93765059e-02f, -1.52209193e-01f, -1.07279588e-02f,
  -1.94609314e-01f, -4.20736410e-02f, -1.57029867e-01f, 1.53615966e-01f, 1.39931813e-01f, 2.90492307e-02f, -1.27331212e-01f, -7.30322599e-02f, 1.19395427e-01f, 3.33045304e-01f,
  -2.61019826e-01f, 3.57023440e-02f, 1.90393656e-01f, 1.95098773e-01f, 3.05932939e-01f, 4.22438920e-01f, -1.31328434e-01f, -3.07393689e-02f, -6.88935220e-02f, 4.60325293e-02f,
  -2.66612053e-01f, -1.19494118e-01f, -1.78719044e-01f, -1.64643049e-01f, -1.81197569e-01f, -1.37441024e-01f, -1.67639241e-01f, -1.84518158e-01f, -3.55626307e-02f, -3.57482396e-02f,
  4.35867272e-02f, 1.64512582e-02f, -5.20303845e-02f, -1.01371445e-01f, 4.84315157e-02f, 1.97648481e-02f, -6.13921136e-02f, -5.26615679e-02f, -1.17468229e-02f, -6.98249564e-02f,
  1.27051711e-01f, 5.57841696e-02f, -6.64270595e-02f, 1.68520436e-02f, 5.35032572e-03f, -3.64013650e-02f, -4.94533218e-02f, -1.09195687e-01f, 1.61017656e-01f, -8.04151446e-02f,
  -8.73925313e-02f, 2.13755593e-02f, -3.74818668e-02f, -1.13989733e-01f, 1.93612561e-01f, 1.69003963e-01f, 1.48931062e-02f, -1.14594445e-01f, 1.11453549e-03f, -1.75134931e-03f,
  -9.62943062e-02f, 1.68135285e-01f, -9.88185629e-02f, 1.11047551e-02f, 6.91185147e-02f, 1.33549392e-01f, -9.80750322e-02f, 8.40941146e-02f, 5.03860712e-02f, 2.46322677e-01f,
  -1.37747988e-01f, 2.43388578e-01f, -1.50742725e-01f, -2.08405599e-01f, 5.98898232e-02f, 9.33948066e-03f, 1.33267477e-01f, 1.77804396e-01f, 1.68519393e-01f, 7.18261003e-02f,
  -1.27243727e-01f, -1.65352046e-01f, -2.66537398e-01f, 2.85488665e-01f, 2.84426451e-01f, 1.65278852e-01f, -6.63693547e-02f, 1.54250227e-02f, -4.78295647e-02f, -6.31871894e-02f,
  1.20254017e-01f, 1.32637560e-01f, 1.30589247e-01f, 6.96715936e-02f, 1.33572787e-01f, 8.50510001e-02f, 1.12775177e-01f, 2.27465760e-02f, -2.46787649e-02f, 7.00281709e-02f,
  7.44151324e-02f, 1.01301521e-01f, 1.53808966e-01f, 7.34819099e-02f, 9.31822360e-02f, -8.00266191e-02f, 3.99554670e-02f, 4.96078394e-02f, 1.25942096e-01f, -4.04191902e-03f,
  1.14216402e-01f, 1.18115291e-01f, -8.80366564e-02f, -2.45295446e-02f, -1.43413708e-01f, -2.29559630e-01f, -2.08200544e-01f, 1.39934607e-02f, -1.54782474e-01f, 2.99326405e-02f,
  -8.89461022e-03f, 2.86619291e-02f, -4.88497093e-02f, -8.09404999e-02f, -1.75124720e-01f, 2.46455356e-01f, -1.18310757e-01f, 9.52501968e-02f, -1.81740910e-01f, -2.21440151e-01f,
  -2.29045659e-01f, -1.13863433e-02f, 1.12072110e-01f, 4.44238514e-01f, 1.36716187e-01f, -3.49943497e-04f, -8.94627348e-02f, -7.89178628e-03f, 1.68000892e-01f, -2.25743070e-01f,
  8.68237689e-02f, -7.70816356e-02f, 8.04629698e-02f, 1.12898439e-01f, 2.82076411e-02f, -1.87559992e-01f, 1.15761206e-01f, 1.41428173e-01f, 3.55859309e-01f, 3.76033969e-02f,
  -9.09159034e-02f, -8.31891820e-02f, 3.19131464e-01f, -2.14863226e-01f, 2.19472945e-01f, 3.97077836e-02f, 2.52274759e-02f, 1.86243169e-02f, 1.77077964e-01f, 2.19548177e-02f,
  -6.81006117e-03f, 3.08269206e-02f, 1.64327547e-01f, -7.89960250e-02f, 1.17505044e-01f, 1.17751680e-01f, 9.63135157e-03f, 1.19962417e-01f, -2.63126455e-02f, 1.51942804e-01f,
  -4.47274260e-02f, 7.42535368e-02f, 9.69808176e-02f, 6.43915832e-02f, 1.34903505e-01f, -1.48464456e-01f, 9.18124095e-02f, 6.04683384e-02f, -1.24925800e-01f, -1.18822068e-01f,
  2.01817676e-01f, -3.69885303e-02f, 2.49799922e-01f, 1.40189126e-01f, -1.87282965e-01f, -2.54730105e-01f, 1.04529016e-01f, 1.53799832e-01f, -1.49623886e-01f, 8.13888758e-02f,
  1.15408234e-01f, 5.14356866e-02f, 2.37711996e-01f, 1.53562412e-01f, 1.14822470e-01f, -1.66304901e-01f, 3.89759004e-01f, 2.41679043e-01f, -1.23958044e-01f, 2.31610507e-01f,
  -2.63095170e-01f, 2.22091805e-02f, -1.23594254e-02f, 7.63951093e-02f, 1.52744606e-01f, 4.40219119e-02f, -2.08663456e-02f, 5.72023839e-02f, -2.78755873e-01f, -5.50333112e-02f,
  -2.19110101e-01f, 3.37962687e-01f, 2.76335567e-01f, 2.70645350e-01f, 9.29068923e-02f, 1.03208251e-01f, -3.43468666e-01f, 8.48247949e-03f, 1.08142003e-01f, 1.68280020e-01f,
  -3.86764109e-02f, -1.17425285e-01f, -5.08613251e-02f, 8.72555934e-03f, -5.06045371e-02f, 4.58740741e-02f, -5.09459190e-02f, 2.24398732e-01f, 2.58961376e-02f, -1.98125601e-01f,
  -1.07164122e-03f, -2.53291756e-01f, 7.13284612e-02f, -8.57524425e-02f, -1.12518832e-01f, -2.68553402e-02f, -2.98502985e-02f, 9.80789438e-02f, 3.20762210e-02f, -2.19077785e-02f,
  2.15381563e-01f, -1.11001045e-01f, 1.52016267e-01f, 2.15864226e-01f, 6.71162084e-02f, -2.50951871e-02f, -1.01863034e-01f, 3.14852335e-02f, 1.83767423e-01f, -2.09260449e-01f,
  -5.94075359e-02f, -4.10349295e-02f, 2.13568911e-01f, -1.80993855e-01f, -1.50839966e-02f, -1.38773382e-01f, -1.15535028e-01f, 5.30444039e-03f, 5.78355938e-02f, 1.62261203e-01f,
  -1.64307311e-01f, -2.67386734e-01f, 1.87784940e-01f, -2.58710030e-02f, -1.87562536e-02f, 6.93092793e-02f, 1.01994067e-01f, 3.49819034e-01f, 1.01033226e-01f, 2.42530286e-01f,
  5.73695861e-02f, -6.49590641e-02f, 2.54411429e-01f, 2.31123850e-01f, 8.12994689e-02f, -1.35989478e-02f, 7.34083280e-02f, 3.35597061e-02f, 1.31478503e-01f, 2.89806962e-01f,
  2.15139128e-02f, 1.34390995e-01f, 3.03141866e-02f, 1.25667319e-01f, 4.57021184e-02f, -9.02085751e-02f, 3.18675041e-02f, -2.48399787e-02f, 4.95043769e-02f, 6.01445735e-02f,
  2.71374136e-02f, 1.07789807e-01f, 4.95790429e-02f, -4.54564393e-03f, -1.02689900e-01f, -1.10511705e-01f, -8.14516991e-02f, -3.33186090e-02f, -9.69335735e-02f, -1.30788893e-01f,
  -3.17660868e-02f, 1.38653129e-01f, 1.28127914e-03f, -8.23507365e-03f, 4.84882891e-02f, -1.01756439e-01f, 8.56138840e-02f, 2.03051418e-01f, 1.45645933e-02f, 1.69369783e-02f,
  -9.45323780e-02f, -5.93540072e-02f, 2.99265441e-02f, -9.19872150e-02f, 1.43993497e-01f, -1.25495031e-01f, 2.21848443e-01f, 2.43186280e-02f, 5.07554002e-02f, -5.96426167e-02f,
  -7.04176128e-02f, 6.47524968e-02f, 1.66152000e-01f, 2.99042821e-01f, -3.10408652e-01f, -8.14095363e-02f, 7.68791884e-02f, -2.96544999e-01f, 3.62370104e-01f, 1.22347130e-02f,
  2.24094093e-01f, 3.31098363e-02f, 7.75942579e-02f, 1.00086890e-01f, 2.02661872e-01f, 5.48592433e-02f, 2.12888032e-01f, 9.24566537e-02f, 3.34440708e-01f, 1.07972994e-01f,
  1.31919697e-01f, -6.28861552e-03f, 5.58833890e-02f, 3.33453566e-01f, 1.67411845e-02f, 2.27815643e-01f, -1.65903941e-01f, -8.52513611e-02f, -7.42713958e-02f, -6.21521734e-02f,
  1.15380652e-01f, 6.45622686e-02f, 5.19428104e-02f, 4.90073562e-02f, 9.87536972e-04f, 1.32345587e-01f, 9.68691111e-02f, 3.17318439e-02f, -3.32101285e-02f, -6.46698698e-02f,
  -1.74616592e-03f, -3.58293131e-02f, -6.59210831e-02f, -4.83734831e-02f, -6.98217377e-02f, 7.79545084e-02f, 3.14189084e-02f, -1.06479064e-01f, 1.46323949e-01f, -6.30376115e-02f,
  2.53169507e-01f, 1.02795988e-01f, 1.02818675e-01f, -5.40854894e-02f, -1.30010307e-01f, -1.35455206e-01f, 9.90512744e-02f, -1.28662810e-01f, -2.18579010e-03f, 2.11653803e-02f,
  1.14243403e-01f, -2.07023337e-01f, 1.69860929e-01f, -1.47331849e-01f, 3.33633982e-02f, 1.04836978e-01f, 2.15938494e-01f, 1.38548627e-01f, -2.26588085e-01f, -2.43595824e-01f,
  2.11335450e-01f, -1.39892027e-02f, 3.08152139e-01f, 9.36913267e-02f, 1.18708387e-01f, 1.74047083e-01f, 8.00233260e-02f, -7.35849189e-03f, 2.39289686e-01f, 4.86125983e-02f,
  1.85383067e-01f, 1.71610817e-01f, 2.43172556e-01f, 9.57020372e-02f, -1.52722105e-01f, -2.92823389e-02f, 2.67310739e-01f, 1.66780502e-01f, -5.47738336e-02f, 3.64509374e-01f,
  -1.79489344e-01f, 1.53710201e-01f, -3.01725958e-02f, 6.16370104e-02f, 1.61445141e-01f, 1.55347064e-01f, -9.85555425e-02f, 1.70855075e-01f, -8.55140667e-03f, 1.71278194e-01f,
  8.88070464e-02f, 9.73346308e-02f, 1.40749648e-01f, -5.17523140e-02f, 1.67752653e-01f, 1.23916501e-02f, 6.85913414e-02f, 2.41254047e-01f, 1.85586095e-01f, 2.31867790e-01f,
  1.69953778e-01f, -1.67359099e-01f, 1.07158676e-01f, -1.97403118e-01f, 1.45526811e-01f, -1.41182050e-01f, -1.77154377e-01f, -4.70926985e-02f, -2.82086164e-01f, -1.65622666e-01f,
  2.36208066e-01f, -1.86997116e-01f, -2.63542503e-01f, 1.34073213e-01f, 7.76319159e-03f, -2.24102847e-02f, 3.99481542e-02f, -1.25718355e-01f, 4.27025259e-02f, -3.07463378e-01f,
  -1.57901719e-01f, -6.36999030e-03f, -1.60077080e-01f, 1.59909710e-01f, 3.14065844e-01f, 1.82101518e-01f, -3.48481566e-01f, -1.62127882e-01f, 9.12701339e-02f, 1.89786404e-01f,
  6.03543259e-02f, -1.86059669e-01f, -1.44481864e-02f, 1.24674536e-01f, 1.21659309e-01f, -1.06438689e-01f, -1.28387334e-02f, 2.88962841e-01f, 1.22950755e-01f, 2.93560684e-01f,
  2.99787343e-01f, -2.17310395e-02f, 2.68745124e-01f, -2.19573736e-01f, 4.04023200e-01f, 4.29279692e-02f, 4.98023219e-02f, -1.38324825e-02f, 1.13622129e-01f, 7.87912756e-02f,
  -4.06735986e-02f, 8.00368041e-02f, -9.87308286e-03f, 1.11053847e-01f, 5.37947789e-02f, -3.79355326e-02f, 6.83977604e-02f, -1.71419829e-02f, 1.83393255e-01f, -1.46154329e-01f,
  -6.22390248e-02f, 5.80729581e-02f, 1.08150601e-01f, 1.34409428e-01f, 2.54004132e-02f, -9.43189114e-02f, 4.19851718e-03f, -9.33294594e-02f, -1.22775093e-01f, 2.41572759e-03f,
  -2.54302114e-01f, -1.48381919e-01f, -2.22751841e-01f, -3.19834836e-02f, 1.21390214e-02f, -1.48736201e-02f, -8.38074237e-02f, -1.13969006e-01f, -1.98684886e-01f, 2.64986157e-01f,
  -2.05029368e-01f, -8.85483548e-02f, -1.13957956e-01f, -1.72905922e-01f, -1.74695954e-01f, 4.26183552e-01f, -2.84791380e-01f, 2.54054993e-01f, 2.54621565e-01f, -5.83276376e-02f,
  7.87147135e-02f, -2.95472175e-01f, 1.60547256e-01f, -3.73454131e-02f, 2.38371789e-01f, 8.38714093e-02f, 3.12358886e-01f, 2.97620833e-01f, 2.54723579e-02f, -1.94361001e-01f,
  5.75181209e-02f, 3.48557889e-01f, 3.30327541e-01f, 4.18120101e-02f, -5.74277565e-02f, -6.36021569e-02f, 2.76566893e-01f, -2.05220923e-01f, 3.73886138e-01f, 1.72465947e-02f,
  3.48783052e-03f, 7.16233179e-02f, -1.06114466e-02f, 1.95736121e-02f, -1.45181585e-02f, -2.87188310e-02f, 2.34152228e-02f, 5.80213666e-02f, 4.54596654e-02f, 1.36381632e-05f,
  9.08977725e-03f, 4.40975167e-02f, -6.69418201e-02f, 5.94144091e-02f, 6.98551163e-02f, 7.24634761e-03f, -3.21144126e-02f, -9.02408035e-04f, 5.32388911e-02f, -3.52899916e-02f,
  1.64228246e-01f, 5.53861000e-02f, 7.39082918e-02f, -2.93709105e-03f, 2.70630240e-01f, -7.88759962e-02f, 1.77026019e-01f, 4.18980308e-02f, 5.36427163e-02f, -1.81719452e-01f,
  6.01165257e-02f, 3.02544031e-02f, 1.36509791e-01f, -2.20041811e-01f, 1.33343220e-01f, 1.11357402e-02f, 3.53811458e-02f, 2.31299892e-01f, 3.55891943e-01f, -6.16502725e-02f,
  2.86649764e-01f, -2.26988479e-01f, 1.65359259e-01f, 3.87883633e-01f, 1.60271078e-01f, 2.82893687e-01f, 1.90762579e-01f, 3.22222650e-01f, 7.38556078e-03f, 1.41245112e-01f,
  -1.48478627e-01f, -1.15052722e-01f, 1.56708047e-01f, 3.95964086e-01f, 8.96024108e-02f, -1.53990844e-02f, 9.06084403e-02f, 1.84471935e-01f, 2.40777329e-01f, 2.63283968e-01f,
  -1.76326275e-01f, 3.60890508e-01f, -3.15660760e-02f, 2.53535897e-01f, -2.79873051e-02f, 6.91344738e-02f, -2.62763537e-02f, 1.76649243e-02f, -2.53354125e-02f, -4.47144061e-02f,
  5.53436689e-02f, 2.91730296e-02f, 5.69252521e-02f, -4.68951315e-02f, -5.62000461e-02f, -5.06465361e-02f, 7.76579306e-02f, 4.41502035e-02f, -3.96104297e-03f, 6.88855648e-02f,
  5.40083945e-02f, 2.26232186e-02f, 4.06100042e-02f, -2.36783847e-01f, 7.38666356e-02f, 2.75123492e-02f, -7.19600618e-02f, -5.15316129e-02f, 1.39047086e-01f, -2.07663640e-01f,
  1.34246662e-01f, 1.67912707e-01f, 1.06509306e-01f, -2.24400312e-01f, 5.45705967e-02f, 1.43874297e-02f, -1.63246036e-01f, -1.72591791e-01f, -7.48366490e-02f, -1.30254105e-01f,
  -9.40298811e-02f, 8.24233741e-02f, -1.02488436e-01f, 1.09252408e-01f, 2.26601318e-01f, -1.81937814e-01f, -3.50959748e-02f, 5.08460045e-01f, -7.44760260e-02f, 2.21622482e-01f,
  -1.01447165e-01f, 3.27795237e-01f, 1.68807194e-01f, 2.63449788e-01f, -1.30855203e-01f, 8.89794230e-02f, 1.48555264e-01f, 1.57591119e-01f, -2.50669777e-01f, -1.06701605e-01f,
  2.26774830e-02f, 9.51640904e-02f, 1.48630857e-01f, -1.25913367e-01f, -2.20400188e-02f, -1.83899298e-01f, 1.32921740e-01f, 2.31384456e-01f, -3.56478058e-03f, -1.14008285e-01f,
  1.14110842e-01f, -6.12849779e-02f, -8.59309211e-02f, 7.80630624e-03f, 3.21042761e-02f, 4.94303741e-02f, 4.07744050e-02f, 7.42528308e-03f, -2.78250240e-02f, -4.45486903e-02f,
  5.50184436e-02f, 1.99385779e-03f, 5.25441505e-02f, 2.59882596e-04f, 8.37002993e-02f, 5.87888733e-02f, 2.52414588e-02f, -9.34479013e-02f, 1.54891104e-01f, -1.13881290e-01f,
  1.87550947e-01f, -5.49241155e-02f, 1.76151857e-01f, 3.65002044e-02f, 9.75119770e-02f, 4.01837416e-02f, 8.39610100e-02f, -2.39373818e-01f, -2.88485177e-02f, 2.17319652e-01f,
  1.66135535e-01f, -6.85865283e-02f, 2.06427976e-01f, -1.19212680e-01f, 1.47968665e-01f, -5.03835864e-02f, 1.70713067e-01f, -3.38070765e-02f, -6.06733523e-02f, 1.05534233e-02f,
  1.29348591e-01f, 1.53344199e-01f, -2.91659325e-01f, -1.36325464e-01f, 1.66441008e-01f, 1.57154188e-01f, -2.84191612e-02f, -1.77781880e-01f, -2.47403130e-01f, -1.53968781e-01f,
  1.30267084e-01f, 8.12712237e-02f, 1.99084524e-02f, 1.62477776e-01f, 2.22199023e-01f, 2.51870483e-01f, 3.75094444e-01f, 2.38138556e-01f, -8.54947641e-02f, 1.18969440e-01f,
  1.18285701e-01f, 2.62019008e-01f, 4.27084789e-02f, -7.86188431e-03f, -1.27525702e-01f, 3.82621139e-02f, -1.11928931e-03f, -4.82709426e-03f, -4.12440561e-02f, 9.55385864e-02f,
  -7.23907724e-03f, -6.34238347e-02f, 7.64072463e-02f, -9.88199413e-02f, -5.38165905e-02f, -1.99830160e-02f, 1.65676206e-01f, 8.63222852e-02f, -4.99622300e-02f, 6.01447225e-02f,
  3.54803912e-02f, 2.73348570e-01f, 2.53001489e-02f, 2.69652344e-02f, 1.05892815e-01f, -7.30391219e-02f, -2.07687244e-02f, 1.45956740e-01f, -1.24504484e-01f, -9.20663252e-02f,
  1.59506753e-01f, 1.79338351e-01f, -1.81140408e-01f, -2.16803304e-03f, 2.41525888e-01f, -9.48488116e-02f, 3.18497274e-04f, 6.74651936e-02f, -1.83600307e-01f, -8.66251439e-02f,
  7.14914352e-02f, 1.76347252e-02f, -6.06150739e-02f, -2.52010804e-02f, 3.30609739e-01f, -2.56166756e-01f, 1.12689331e-01f, -1.20455157e-02f, 3.74310136e-01f, 7.85658732e-02f,
  -8.30982774e-02f, -7.48493597e-02f, -6.10602796e-02f, -2.65118510e-01f, 3.12646151e-01f, 2.00239137e-01f, 2.98969984e-01f, 6.77086413e-02f, 1.22036606e-01f, 1.32886738e-01f,
  9.53008756e-02f, 2.40875438e-01f, 2.93622941e-01f, 1.34662971e-01f, 2.26543516e-01f, 5.86164482e-02f, -4.62058512e-03f, 7.49725178e-02f, 7.14912340e-02f, 1.02663860e-01f,
  1.72955468e-01f, 1.37303531e-01f, 1.10432751e-01f, 7.17747211e-02f, -5.47034964e-02f, -5.16072148e-03f, -2.89335218e-03f, 4.14520577e-02f, -1.98818352e-02f, 1.92048419e-02f,
  1.48547599e-02f, 6.02384619e-02f, 6.06869422e-02f, 1.95000563e-02f, 1.43511519e-01f, -6.52806535e-02f, -3.54369218e-03f, 1.90663785e-01f, -2.21261963e-01f, 6.42081797e-02f,
  1.30708441e-01f, 4.77950759e-02f, -8.24577808e-02f, 1.24508198e-02f, -2.65468925e-01f, -4.00203653e-02f, 1.54057354e-01f, -1.43219143e-01f, -7.88011402e-02f, 1.93074033e-01f,
  -7.18277022e-02f, 1.36019364e-01f, 6.87663630e-02f, 1.37301341e-01f, 2.63231248e-02f, -4.34398800e-02f, 7.57054314e-02f, 1.06874347e-01f, -3.21335703e-01f, 7.20452657e-03f,
  3.05458456e-01f, -1.19940762e-03f, -1.91936880e-01f, -7.00414777e-02f, 4.05445069e-01f, 2.50824988e-01f, 3.43690455e-01f, 9.58133787e-02f, -2.59424359e-01f, -1.88207313e-01f,
  8.73434618e-02f, 3.82503062e-01f, -3.30877751e-02f, -3.82680520e-02f, -1.54933020e-01f, 2.52315432e-01f, -2.13580608e-01f, -8.37050602e-02f, -1.04837440e-01f, -2.14131981e-01f,
  -7.81042352e-02f, 7.71665052e-02f, 1.12847790e-01f, 1.37682199e-01f, -7.81055447e-03f, 6.42120838e-02f, -2.83485912e-02f, 1.15033202e-01f, 2.55272239e-01f, 2.71911714e-02f,
  9.84640121e-02f, -1.28127018e-03f, 2.30889469e-01f, 2.34748498e-02f, -3.78744118e-02f, 9.28126741e-03f, 5.57736307e-02f, 2.01843724e-01f, 8.97380710e-02f, -3.42133284e-01f,
  3.85815799e-02f, -4.62850034e-02f, 2.32940409e-02f, 3.05261537e-02f, -1.06292211e-01f, -3.54606599e-01f, -1.39700338e-01f, -1.93359535e-02f, 2.39849478e-01f, -3.12995046e-01f,
  -1.03423826e-01f, -1.78342074e-01f, -2.36890182e-01f, -1.94193497e-01f, -1.50754318e-01f, -1.75770104e-01f, -1.81369141e-01f, -6.35681674e-02f, -3.54646472e-03f, 1.01400547e-01f,
  1.36509791e-01f, -2.36608699e-01f, 1.62579224e-01f, 2.62688041e-01f, 6.83341548e-02f, 1.79391086e-01f, -5.36386706e-02f, 3.07921946e-01f, 2.21214622e-01f, 2.05262303e-01f,
  1.56034902e-01f, 3.78969342e-01f, 1.80484399e-01f, 2.35229105e-01f, -2.84817576e-01f, -7.99081326e-02f, -2.16527060e-01f, 1.42422035e-01f, 8.27057287e-02f, -1.52128324e-01f,
  -1.31495833e-01f, -5.94776645e-02f, -5.60399368e-02f, 1.71687856e-01f, 4.84933294e-02f, 6.08207211e-02f, 1.33232921e-01f, 1.70275867e-02f, 2.45850254e-02f, 1.16530210e-01f,
  3.81038198e-03f, 7.49850795e-02f, 2.03320891e-01f, 2.54234485e-02f, 1.30410329e-01f, 7.74149075e-02f, 1.55950963e-01f, -5.16439229e-03f, -2.69354396e-02f, -3.28745842e-02f,
  5.11353090e-02f, 2.03743771e-01f, 3.12803537e-02f, -1.85140386e-01f, 9.30027515e-02f, 4.81367186e-02f, 3.78414690e-02f, -7.69530684e-02f, 6.65724352e-02f, -1.56423435e-01f,
  -9.63340402e-02f, 7.72720426e-02f, 3.13646570e-02f, -3.51204365e-01f, -1.60672497e-02f, -6.19080290e-02f, 1.17155597e-01f, -6.78776726e-02f, -4.75510815e-03f, -5.43683320e-02f,
  -7.00181872e-02f, -6.51361346e-02f, 1.05165824e-01f, -1.98455721e-01f, 1.96614504e-01f, -4.83144224e-02f, 8.50392729e-02f, 9.11556780e-02f, -1.73011318e-01f, 2.55083710e-01f,
  1.36032358e-01f, 2.37935022e-01f, 1.30287394e-01f, 1.12410977e-01f, 3.19907926e-02f, 1.89365387e-01f, 1.35415256e-01f, 2.74697840e-01f, -8.53931680e-02f, 2.00663686e-01f,
  1.62930880e-02f, 1.44289672e-01f, 1.63765743e-01f, 2.20395550e-01f, -2.08707199e-01f, 2.51824498e-01f, -5.77549823e-03f, 2.94690039e-02f, 1.87260821e-01f, 2.58862466e-01f,
  -1.58295669e-02f, 8.38041827e-02f, 1.96458817e-01f, 5.61504886e-02f, 1.55023709e-01f, -1.57587696e-02f, 1.10444739e-01f, 1.10117793e-01f, 1.45904317e-01f, 1.29406244e-01f,
  2.00825132e-04f, -9.81575251e-03f, 1.90008894e-01f, 1.96169853e-01f, 1.32893205e-01f, -6.06753677e-03f, 1.29613027e-01f, 1.16853274e-01f, -2.82491982e-01f, 3.33374113e-01f,
  -2.99730569e-01f, -1.88865721e-01f, -8.28840435e-02f, -4.55969535e-02f, -9.70748514e-02f, -2.11301222e-01f, -1.26254678e-01f, 3.40480685e-01f, -4.06920686e-02f, -1.99238658e-01f,
  -2.98904300e-01f, 8.91533867e-02f, -2.62059718e-01f, 1.64535061e-01f, -3.39094371e-01f, -1.77839480e-03f, -3.47179808e-02f, -9.33487434e-03f, 2.94660151e-01f, 9.26259756e-02f,
  -4.29092459e-02f, -5.44260330e-02f, 3.73636097e-01f, 4.11683202e-01f, 5.23000471e-02f, -9.80852917e-02f, 9.94599164e-02f, 8.51333365e-02f, 1.53641760e-01f, 3.73364419e-01f,
  -1.01225831e-01f, 9.89022478e-02f, 2.87633806e-01f, -1.31632701e-01f, -1.00049578e-01f, -1.02904417e-01f, -2.10969597e-01f, -3.16191107e-01f, 1.80391937e-01f, -1.19636983e-01f,
  2.18218535e-01f, -1.08301461e-01f, 2.11247969e-02f, 9.52701792e-02f, -5.82628697e-02f, 1.04271218e-01f, -3.49404034e-03f, 5.34920059e-02f, -5.77302352e-02f, 5.76145463e-02f,
  -7.49213770e-02f, 2.31937058e-02f, 6.46070093e-02f, 9.65412110e-02f, 2.83255894e-02f, 2.15321388e-02f, 2.78714355e-02f, 1.42318711e-01f, 9.36486870e-02f, -7.14797080e-02f,
  5.84979840e-02f, 2.91261196e-01f, -4.00025249e-02f, -3.38827521e-02f, -3.46194245e-02f, -1.02839299e-01f, -1.28798425e-01f, 2.40344718e-01f, -1.63410753e-01f, -1.64850503e-02f,
  -1.68433860e-01f, 2.60410279e-01f, -1.14149712e-01f, -3.09708733e-02f, -5.25047723e-03f, 2.69257754e-01f, -6.76058680e-02f, 1.89719677e-01f, 6.09609764e-03f, -1.45003006e-01f,
  1.30572602e-01f, 1.22016601e-01f, 4.33686487e-02f, 3.56369257e-01f, 1.45386653e-02f, -2.21564531e-01f, 1.34251848e-01f, -6.09364137e-02f, 2.27086097e-01f, -9.13879275e-02f,
  2.78276205e-02f, -5.96337691e-02f, 1.74494073e-01f, -5.17989136e-02f, -2.40742475e-01f, -4.35564928e-02f, 2.04970792e-01f, 2.32421517e-01f, 3.22016329e-01f, 8.04299638e-02f,
  -4.48597930e-02f, 1.25944421e-01f, 3.03298056e-01f, -5.49484231e-02f, 2.59629309e-01f, 1.23338457e-02f, -8.63337424e-03f, -3.15422937e-02f, 1.23517051e-01f, -2.03044564e-02f,
  -3.66889089e-02f, -2.25149672e-02f, 1.10679686e-01f, -4.40858863e-02f, 5.31535596e-02f, -6.57819435e-02f, -6.95797727e-02f, -9.93471313e-03f, -1.93608960e-03f, 2.98327673e-03f,
  -5.11850342e-02f, -4.95764539e-02f, 7.53365010e-02f, -4.76059057e-02f, -1.43525517e-02f, -1.74209401e-01f, 5.59742935e-03f, -1.32263973e-01f, -8.89528319e-02f, 1.05890356e-01f,
  -9.07955170e-02f, -2.28200033e-01f, 3.84709388e-02f, 1.25957951e-01f, -4.92078252e-02f, 1.15035605e-02f, 3.64379287e-02f, 8.68284330e-03f, -2.44887874e-01f, 1.21714748e-01f,
  -1.53176963e-01f, -8.04407150e-02f, -3.32778879e-02f, 6.62223250e-02f, -1.27562106e-01f, 4.38576669e-01f, -7.98673648e-03f, 3.87366340e-02f, -5.69646843e-02f, 4.13407326e-01f,
  7.52759427e-02f, -1.00155525e-01f, -1.22408710e-01f, 2.48613939e-01f, 2.89815187e-01f, 1.10897571e-01f, 2.55476922e-01f, 2.32185215e-01f, -1.29406303e-01f, -1.91201046e-01f,
  -1.91577315e-01f, 8.85752141e-02f, 1.44956142e-01f, 1.26667127e-01f, -3.89897171e-03f, -2.12349519e-01f, 1.42205790e-01f, -2.41033912e-01f, 1.51073650e-01f, 2.07450688e-01f,
  6.56505376e-02f, 1.70928240e-01f, 5.22518940e-02f, 7.36417100e-02f, 8.96308571e-02f, 5.85861765e-02f, 9.93577838e-02f, -3.95138860e-02f, 1.34259313e-01f, 1.55348077e-01f,
  9.75494459e-02f, 1.12591632e-01f, 1.11623362e-01f, 6.75014481e-02f, 4.62237708e-02f, 1.26336142e-01f, 2.26206314e-02f, 4.38763350e-02f, 1.03713289e-01f, -5.48183061e-02f,
  -1.99513026e-02f, -7.44313607e-03f, -1.28849030e-01f, -2.39304736e-01f, 1.60313770e-02f, -9.89617873e-03f, 1.48568571e-01f, 1.11019067e-01f, -1.88044533e-02f, -1.30699262e-01f,
  1.94085147e-02f, 1.08407415e-01f, -1.05918132e-01f, 1.11150809e-01f, -1.48011679e-02f, 6.83455542e-02f, 8.01894218e-02f, -1.13468379e-01f, -1.38119996e-01f, -2.73047477e-01f,
  3.11501026e-01f, 3.96622986e-01f, 4.78236098e-03f, 2.92403311e-01f, -2.89416671e-01f, 1.69371381e-01f, 9.61577222e-02f, 1.70104410e-02f, 3.46013866e-02f, 5.40050454e-02f,
  -1.85741678e-01f, 1.71339452e-01f, -3.19946706e-02f, -3.29714306e-02f, -2.01340064e-01f, 1.76590741e-01f, 1.95613354e-01f, 2.27706462e-01f, 9.25736204e-02f, -9.15808156e-02f,
  8.82130116e-02f, -7.74939805e-02f, 2.80532807e-01f, 8.60834271e-02f, 2.89473068e-02f, -2.50528776e-03f, 1.99632552e-02f, 2.01390125e-02f, 3.24828960e-02f, 2.22087167e-02f,
  -1.20293528e-01f, -8.78779441e-02f, -9.10872370e-02f, 4.31969836e-02f, -1.06336931e-02f, -4.60950695e-02f, 3.58616821e-02f, 6.82021081e-02f, 6.54459819e-02f, -7.43435994e-02f,
  4.22635488e-03f, 3.09905596e-02f, -1.09759875e-01f, 2.36891389e-01f, 7.60653317e-02f, -8.97502303e-02f, -7.06101805e-02f, -9.86001119e-02f, 6.04181215e-02f, 2.52752721e-01f,
  -1.89212020e-02f, 1.41900107e-01f, -2.27508813e-01f, 7.40211308e-02f, 3.03570963e-02f, 5.28123006e-02f, 1.25008866e-01f, 2.46934548e-01f, -8.87069677e-04f, 1.95684880e-01f,
  7.13013932e-02f, -4.57045063e-02f, 1.85966864e-01f, -2.83096451e-02f, 7.48931915e-02f, 3.40651959e-01f, -2.92648524e-02f, -2.32502162e-01f, -7.39814416e-02f, -6.75577000e-02f,
  9.35329795e-02f, -8.71592909e-02f, -3.94785665e-02f, 3.98222506e-02f, 1.52957201e-01f, -1.76287055e-01f, -2.32737139e-01f, -3.11063603e-02f, 1.98155686e-01f, 3.42035711e-01f,
  3.27374309e-01f, -2.94699371e-02f, -1.35669187e-01f, 2.50306726e-01f, 1.12258457e-01f, 4.24738899e-02f, 8.53082240e-02f, -2.63931081e-02f, -2.67992169e-02f, 1.60043716e-01f,
  3.10921799e-02f, 1.92553252e-01f, 6.39197230e-02f, 1.13092326e-01f, -1.47644198e-02f, 1.88753441e-01f, 4.26956750e-02f, 1.45564646e-01f, 1.52755186e-01f, 1.37581989e-01f,
  3.77489328e-02f, -5.86020350e-02f, 2.87845302e-02f, 1.24755308e-01f, 9.30169970e-02f, 1.94334820e-01f, 2.98316441e-02f, 1.43781960e-01f, -2.32777558e-02f, 1.03714697e-01f,
  7.02132704e-03f, -1.18629947e-01f, -1.26193210e-01f, 1.26855135e-01f, -3.26479316e-01f, -2.55650431e-01f, 8.64577740e-02f, 1.23063706e-01f, -2.28011504e-01f, -2.48002410e-01f,
  1.35296419e-01f, 8.64515733e-03f, -5.09566888e-02f, 6.71277270e-02f, -1.70781121e-01f, -1.31101578e-01f, 1.87001843e-03f, -2.05027029e-01f, -1.10049278e-01f, 1.87253848e-01f,
  3.39076668e-01f, -3.11640888e-01f, 1.16230242e-01f, 1.68320864e-01f, 2.44811833e-01f, -1.19650245e-01f, 1.78721938e-02f, -1.25426933e-01f, 9.79109257e-02f, 1.00675136e-01f,
  2.39106551e-01f, 1.92657977e-01f, 3.46263200e-01f, 2.50845671e-01f, 9.11861211e-02f, 7.72400387e-03f, -1.07073888e-01f, 5.67509532e-02f, 2.56966621e-01f, 1.12797678e-01f,
  1.53271973e-01f, -9.34489146e-02f, -4.89295311e-02f, 5.41803911e-02f, 2.68174231e-01f, -9.40714590e-03f, 4.76162415e-04f, -7.95392394e-02f, 9.34126973e-02f, -2.48708025e-01f,
  1.68828517e-01f, 1.78406209e-01f, 4.32531815e-04f, 2.76704609e-01f, 1.62395108e-02f, -2.43063662e-02f, -3.56712006e-02f, -2.03766406e-01f, -2.52891202e-02f, 2.65338961e-02f,
  -1.13365225e-01f, -1.62375808e-01f, 3.57961357e-02f, -8.23793039e-02f, 1.40102990e-02f, -1.25101611e-01f, 1.01803191e-01f, -6.84818402e-02f, 3.00363034e-01f, 1.91906273e-01f,
  -2.33787015e-01f, -1.62462652e-01f, 1.68511152e-01f, 1.31877407e-01f, -6.09480590e-02f, 1.65082157e-01f, 1.76315665e-01f, 8.46274644e-02f, 3.19459051e-01f, 2.85996348e-01f,
  2.45803893e-01f, -2.61524200e-01f, 1.68832898e-01f, 3.70478630e-01f, -1.22523971e-01f, 1.65861830e-01f, -1.59528404e-01f, 1.31938994e-01f, -1.03435673e-01f, -1.86824679e-01f,
  2.13244617e-01f, -1.39136121e-01f, 1.32376879e-01f, 2.14427933e-01f, -3.41393292e-01f, 7.49519616e-02f, -1.23072661e-01f, 2.63730854e-01f, 1.33912459e-01f, 6.92400523e-03f,
  -4.75530252e-02f, 1.66042104e-01f, -4.93547082e-01f, 3.59251529e-01f, -1.07341208e-01f, 2.06350207e-01f, 6.28447579e-03f, 1.65638506e-01f, 1.72734484e-02f, 1.98612511e-01f,
  1.22955553e-01f, 2.45950341e-01f, 4.30628136e-02f, 2.39550263e-01f, 1.66496262e-01f, 2.73555703e-02f, 1.56904742e-01f, 6.11267937e-03f, 1.19223677e-01f, -4.80824187e-02f,
  5.27290702e-02f, 1.75180122e-01f, 1.20384075e-01f, 2.23305345e-01f, 2.18207404e-01f, -6.77445978e-02f, -1.19389206e-01f, 2.29078054e-01f, -1.08323358e-01f, -1.78217962e-01f,
  -1.73013732e-01f, -1.02727212e-01f, -3.93156230e-01f, -2.68697500e-01f, 5.85882440e-02f, -4.79783677e-02f, -2.30260521e-01f, -2.89506763e-01f, -1.57019123e-01f, 6.23471923e-02f,
  -2.37073392e-01f, 1.66184977e-02f, -2.51415402e-01f, -2.53216118e-01f, -1.22546874e-01f, -1.98105872e-01f, 1.25752419e-01f, 1.18890367e-01f, 2.58442283e-01f, -1.09863311e-01f,
  5.68215176e-02f, 2.48704627e-01f, 1.49196297e-01f, -7.12831840e-02f, 1.80344716e-01f, 1.77925825e-02f, 1.50700241e-01f, 2.94701546e-01f, 6.99939206e-02f, 1.32436022e-01f,
  1.69330776e-01f, -1.55565096e-02f, -1.98648870e-02f, 5.81081994e-02f, -1.42369583e-01f, -1.68403611e-01f, 1.70940131e-01f, -1.45730659e-01f, 2.76595116e-01f, -1.47327960e-01f,
  3.44469137e-02f, 1.40692368e-01f, 1.18297674e-01f, 6.61638305e-02f, 1.09038413e-01f, 1.11478537e-01f, 1.36197358e-01f, 6.72251433e-02f, 1.06629625e-01f, 2.66657714e-02f,
  9.24388990e-02f, 1.49355888e-01f, -6.68519661e-02f, 6.36579981e-03f, -3.97469662e-02f, 7.71389529e-02f, 1.13213763e-01f, 1.32454872e-01f, 1.51454732e-01f, -2.09073201e-01f,
  2.46628001e-02f, 1.53674290e-01f, -7.23188519e-02f, 5.32127656e-02f, 8.44557062e-02f, -2.35663652e-01f, -2.55293343e-02f, -3.88079993e-02f, -2.49740183e-02f, -2.55915113e-02f,
  8.14135149e-02f, -1.78914934e-01f, -1.15638725e-01f, -1.33605823e-01f, -5.72234206e-02f, -7.31393620e-02f, -1.26390368e-01f, 1.78935900e-01f, 6.16248474e-02f, 4.82250191e-03f,
  2.46218950e-01f, -1.54672757e-01f, 6.30172621e-03f, 2.45694399e-01f, 3.73584181e-01f, 3.46431166e-01f, -1.29271239e-01f, 1.79685235e-01f, 3.09778541e-01f, 2.55902261e-01f,
  2.00970516e-01f, 2.32276335e-01f, 6.24699034e-02f, 1.97983608e-01f, 9.49894711e-02f, 5.70023395e-02f, -2.48530611e-01f, -4.49823439e-02f, 1.14855595e-01f, -1.16592636e-02f,
  -2.17441618e-01f, 1.07246265e-01f, -6.27158433e-02f, 1.40051231e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  2.64925044e-02f, 7.49513581e-02f, -1.46348216e-02f, 2.63090264e-02f, 9.71687660e-02f, 5.28715970e-03f, 8.10284019e-02f, 4.22555506e-02f, 1.10835448e-01f, 9.32172760e-02f,
  2.11366937e-02f, 1.91091821e-02f, 5.23082130e-02f, 2.71538533e-02f, 5.23027815e-02f, 5.18891029e-02f, 1.21184252e-01f, 5.41808046e-02f, 8.48975107e-02f, 1.28794998e-01f,
  3.04661449e-02f, -4.15372327e-02f, 4.18940966e-04f, 4.47325828e-03f, 6.66253716e-02f, 1.24570675e-01f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  -7.47751966e-02f, -1.28962755e-01f, -9.46867540e-02f, -9.41262320e-02f, 1.59943894e-01f, 3.51682007e-02f, 3.27973403e-02f, -1.58025324e-01f, 5.98756596e-02f, -4.63172942e-02f,
  2.19139680e-02f, -3.65173630e-02f, 1.24048270e-01f, 1.80413071e-02f, -1.21387534e-01f, 4.72886525e-02f, 4.63665351e-02f, 1.53661475e-01f, 1.14555307e-01f, -1.16665035e-01f,
  3.37661318e-02f, 1.39716104e-01f, -2.87034690e-01f, -4.24927846e-02f, -4.28765975e-02f, 2.45796815e-01f, -2.16031164e-01f, 9.79251191e-02f, -1.01774417e-01f, 1.55910343e-01f,
  9.85361934e-02f, -4.80899215e-02f, -2.20065936e-01f, 5.10824062e-02f, 1.91144034e-01f, -1.95300996e-01f, -1.64917573e-01f, 6.83071315e-02f, -1.13486513e-01f, -3.06254894e-01f,
  5.18520512e-02f, 3.33417267e-01f, -3.70743483e-01f, -2.99098819e-01f, -1.06430903e-01f, -2.89699793e-01f, 9.53373089e-02f, 1.95888802e-01f, -4.37926978e-01f, -2.88884819e-01f,
  -1.76070452e-01f, 1.54962271e-01f, -4.42843527e-01f, -4.28096145e-01f, -4.15926456e-01f, 1.30052030e-01f, 2.83473700e-01f, 1.45786745e-03f, 7.05009997e-02f, 1.27063334e-01f,
  2.18132004e-01f, -3.26027334e-01f, 2.50398219e-02f, -4.90360320e-01f, 5.37041016e-02f, 1.59631088e-01f, -7.10488437e-03f, -1.33137256e-01f, -6.16327040e-02f, 6.07025959e-02f,
  -6.47363290e-02f, -9.04060230e-02f, -1.35677114e-01f, -1.69352293e-01f, 5.58941066e-03f, -5.96342348e-02f, 1.33635411e-02f, 5.52066900e-02f, 2.13581443e-01f, 5.62060326e-02f,
  1.32456183e-01f, -1.74004897e-01f, -3.03047542e-02f, -1.82515346e-02f, 1.15916044e-01f, 2.40698829e-01f, -7.51219764e-02f, 1.24756284e-01f, 1.13960057e-01f, 9.39963907e-02f,
  7.69375861e-02f, -3.35314162e-02f, -1.61083952e-01f, 7.67501965e-02f, 5.20325750e-02f, -6.19338360e-03f, -3.13954800e-02f, 8.52406956e-03f, 3.00853133e-01f, 1.45802706e-01f,
  5.62000200e-02f, 8.32079328e-04f, 1.56607360e-01f, -3.44911292e-02f, -1.81197181e-01f, 7.66118541e-02f, -2.01617777e-01f, 2.44260654e-01f, 1.50018141e-01f, 8.03416409e-03f,
  2.32622176e-01f, 1.62469931e-02f, -3.63968462e-02f, -2.89866090e-01f, 2.02758610e-01f, 2.71288007e-01f, -5.42355850e-02f, -2.90723443e-01f, 6.98538050e-02f, -4.07197922e-01f,
  1.80999011e-01f, -3.75918716e-01f, -4.28087376e-02f, 1.22314624e-01f, 1.30311593e-01f, -4.11761552e-01f, 1.79730577e-03f, -4.40023631e-01f, 6.17425144e-02f, -2.61218667e-01f,
  8.47376417e-03f, -1.08088739e-03f, 1.21847205e-02f, -1.73516870e-01f, 1.39099881e-01f, -5.51133603e-02f, -1.17359459e-01f, -1.39380559e-01f, 2.93872226e-02f, -1.31597400e-01f,
  1.07918538e-01f, -1.39517099e-01f, -1.18878037e-01f, -2.13430941e-01f, -2.09243536e-01f, -1.59034237e-01f, -1.33298531e-01f, -1.77076742e-01f, 3.55025046e-02f, -2.66959459e-01f,
  1.22827545e-01f, 5.72861917e-02f, -1.76737592e-01f, 1.09525159e-01f, -1.89207539e-01f, 1.56671122e-01f, -1.35028407e-01f, -3.00015905e-03f, -1.96913667e-02f, 2.16570884e-01f,
  2.58475505e-02f, 1.19411848e-01f, -2.41283119e-01f, 2.41153855e-02f, -1.13393888e-01f, -1.31219640e-01f, 2.32301623e-01f, -1.28657781e-02f, -7.28980452e-02f, -2.65289515e-01f,
  1.00266978e-01f, 1.52813169e-04f, 7.12188110e-02f, -1.15595656e-02f, -3.33321422e-01f, -6.08734667e-01f, 1.93999380e-01f, -3.84884387e-01f, 8.59900340e-02f, 1.07837290e-01f,
  -1.29097208e-01f, -4.60101426e-01f, 1.58897266e-01f, -1.94722787e-01f, 1.16034441e-01f, -3.91331643e-01f, -3.10184564e-02f, 2.83522815e-01f, -6.47548288e-02f, 4.15055513e-01f,
  -5.52244604e-01f, -2.23568842e-01f, 6.59747943e-02f, -2.07138032e-01f, 3.34908400e-04f, 2.19809562e-01f, -5.72837517e-02f, 9.42186713e-02f, 9.07549784e-02f, -7.57882074e-02f,
  4.64777136e-03f, 6.66612759e-02f, -4.94189709e-02f, -5.53975217e-02f, 1.01068355e-01f, -2.16118023e-01f, -3.31188627e-02f, 4.29203920e-02f, -1.28326118e-01f, 8.71639624e-02f,
  1.94303602e-01f, 2.27624327e-01f, -1.88917741e-01f, 5.71296550e-02f, 8.93585831e-02f, -2.68894225e-01f, 1.79219767e-01f, -4.09727357e-02f, 1.56872988e-01f, -2.91515082e-01f,
  3.14429283e-01f, -3.65059525e-02f, -3.31790268e-01f, 1.97838739e-01f, 8.94814953e-02f, -1.34656385e-01f, -2.31567949e-01f, -2.71045983e-01f, -3.51956189e-01f, -5.64930215e-02f,
  -3.01325649e-01f, 3.52519661e-01f, -4.09122378e-01f, 1.10249437e-01f, -4.57118243e-01f, -3.56450647e-01f, 1.77252993e-01f, 1.13464184e-02f, -5.54778278e-01f, 2.39097059e-01f,
  -4.74391460e-01f, -3.36198360e-01f, -1.16896816e-01f, -3.99779797e-01f, 1.68957800e-01f, -4.58445288e-02f, -4.08484548e-01f, 2.38195509e-01f, 5.66112250e-02f, 2.82564342e-01f,
  -6.12778842e-01f, -2.46881098e-01f, -1.02703586e-01f, -3.90060365e-01f, 5.36802337e-02f, 6.41927496e-02f, 9.60576981e-02f, 1.62924632e-01f, 2.45987382e-02f, -1.30445257e-01f,
  3.54052857e-02f, -3.31165977e-02f, -8.17797109e-02f, 1.75639182e-01f, 1.67259812e-01f, -5.39227687e-02f, 9.16424394e-02f, 2.94446230e-01f, 2.27847490e-02f, 3.55777354e-03f,
  4.47730646e-02f, 6.04560934e-02f, -6.09136857e-02f, -5.26843965e-02f, 6.84717819e-02f, -2.92486817e-01f, 1.42229140e-01f, -1.10804131e-02f, 2.83126503e-01f, 3.37129503e-01f,
  -9.75855216e-02f, -1.40172035e-01f, 1.52451053e-01f, -1.69523042e-02f, -1.60251901e-01f, -3.82552594e-01f, 2.63760298e-01f, -1.55943528e-01f, 1.84003532e-01f, -7.49427229e-02f,
  3.69533360e-01f, -4.15669382e-02f, 2.17749596e-01f, -7.88585842e-02f, -4.26093817e-01f, 2.42306679e-01f, 1.06214592e-02f, 2.42003262e-01f, 4.50569168e-02f, -3.53539944e-01f,
  -1.52671203e-01f, -1.90521181e-01f, 8.00276026e-02f, 7.79713467e-02f, -4.00217831e-01f, -2.67868727e-01f, -2.29731396e-01f, -3.26506585e-01f, 2.16491818e-01f, 5.43387979e-02f,
  1.71356693e-01f, 6.75228983e-02f, 2.97614955e-04f, -1.21958539e-01f, 1.60498410e-01f, 3.11720874e-02f, 1.83043778e-01f, 2.42086411e-01f, 2.87061304e-01f, -2.45169420e-02f,
  -1.26019120e-01f, -1.10648602e-01f, -6.71916232e-02f, 1.49588197e-01f, 1.72136873e-02f, -8.85825232e-02f, -9.69394892e-02f, 1.55317515e-01f, 8.71523246e-02f, 1.75951213e-01f,
  2.60875747e-02f, -2.28416145e-01f, 6.45274669e-02f, 3.54485959e-02f, 7.67346546e-02f, 2.35542506e-02f, -1.62652433e-01f, -2.19764840e-02f, 1.11463070e-02f, -8.32656547e-02f,
  -1.75111353e-01f, 3.03981751e-01f, -2.17270181e-01f, 1.26857787e-01f, 1.32143319e-01f, -2.90128022e-01f, -2.63179868e-01f, -1.33598402e-01f, 1.45932749e-01f, 1.85489774e-01f,
  -3.37883197e-02f, -1.29701182e-01f, -1.70004904e-01f, -2.27034077e-01f, 1.96839809e-01f, -2.36366004e-01f, -8.94984826e-02f, -1.08910259e-03f, -1.28983140e-01f, -3.92696410e-01f,
  5.57983033e-02f, 4.74435054e-02f, -1.19983084e-01f, 1.35749504e-01f, -1.27414033e-01f, -7.16556758e-02f, 2.42665634e-01f, 1.96395859e-01f, 8.17402732e-03f, 1.44980818e-01f,
  3.11608892e-02f, 2.07752511e-02f, -4.31971252e-01f, 2.68702686e-01f, 1.34921700e-01f, -8.16673860e-02f, -5.06797098e-02f, 1.79237068e-01f, 1.92404203e-02f, -2.57879049e-01f,
  -1.14955558e-02f, -2.86625773e-01f, 1.77068353e-01f, -6.39902130e-02f, 3.44229229e-02f, 3.76697108e-02f, 4.33475897e-02f, 1.15619868e-01f, -1.81916416e-01f, 1.11687548e-01f,
  1.43659592e-01f, 5.31723723e-02f, 9.65991840e-02f, 9.64942947e-02f, 1.38938576e-01f, -5.76087609e-02f, 7.98309296e-02f, -1.67542771e-01f, -1.49224952e-01f, -3.53634008e-03f,
  1.67187482e-01f, -1.95740044e-01f, 1.20866261e-01f, -1.24844007e-01f, 2.90394217e-01f, -1.72603667e-01f, 8.61718208e-02f, 2.21605860e-02f, 9.84461531e-02f, -6.99078143e-02f,
  2.06056964e-02f, -1.83926061e-01f, 1.19450986e-01f, -8.68400931e-02f, 4.82344963e-02f, -2.42594644e-01f, -1.11519374e-01f, 1.04819998e-01f, -1.92215472e-01f, -1.29114976e-02f,
  7.42300823e-02f, -7.68127441e-02f, 1.99883550e-01f, -3.13002825e-01f, -3.75877656e-02f, -4.71587658e-01f, 1.44638166e-01f, -2.86864173e-02f, -2.67388552e-01f, 1.41880289e-01f,
  1.31732225e-01f, -4.34894830e-01f, 2.06245825e-01f, 1.23866193e-01f, 1.64618507e-01f, -2.44216174e-01f, -2.81719744e-01f, 1.64460361e-01f, 1.01274714e-01f, -5.29501438e-01f,
  -3.28633755e-01f, 3.92488912e-02f, 4.00291234e-02f, -3.21683615e-01f, -4.00388092e-01f, 2.22058296e-01f, -4.71107066e-01f, 4.90811765e-02f, -4.98475209e-02f, 1.18522584e-01f,
  6.42627776e-02f, -2.05614895e-01f, -1.99422598e-01f, -5.34328111e-02f, 3.37378085e-02f, -8.51675645e-02f, -4.18596668e-03f, -1.29635870e-01f, 1.04982637e-01f, 9.80177969e-02f,
  -2.78582536e-02f, 2.39075739e-02f, 1.02040671e-01f, -2.71725934e-02f, 1.15575723e-01f, -8.32847357e-02f, -1.04499124e-01f, 1.72549516e-01f, 1.66742012e-01f, 7.62706399e-02f,
  -1.70811359e-02f, 1.57598794e-01f, -9.97510366e-03f, -7.57180676e-02f, 6.91251382e-02f, 2.08178833e-01f, 1.05829440e-01f, -7.15264902e-02f, 1.12267956e-01f, 1.07986748e-03f,
  1.58542454e-01f, -6.73217252e-02f, -7.94131085e-02f, -5.25275022e-02f, -1.81518272e-01f, 1.72544256e-01f, -2.25687265e-01f, 6.55433908e-02f, 2.78148204e-01f, -2.17622861e-01f,
  -6.69383481e-02f, 2.93771207e-01f, 1.82436943e-01f, 1.45942628e-01f, -1.58011928e-01f, 2.04655632e-01f, -1.08759627e-01f, -3.00746094e-02f, -2.18670204e-01f, -1.39058739e-01f,
  2.27358282e-01f, 1.29076391e-01f, 3.13039385e-02f, -4.35648441e-01f, 2.66868658e-02f, 2.90053189e-01f, -3.27121615e-01f, 1.53149545e-01f, -3.12288225e-01f, 2.04634555e-02f,
  -2.32278958e-01f, 1.62836220e-02f, 1.11195687e-02f, -1.49698243e-01f, 2.24222206e-02f, 6.49069473e-02f, -3.45467636e-03f, -1.02990933e-01f, -6.90709129e-02f, 2.70242300e-02f,
  4.84018680e-03f, -3.66536924e-03f, -1.43742085e-01f, 2.04214618e-01f, -2.02723965e-01f, -1.32202897e-02f, 3.43119688e-02f, 2.05094188e-01f, -5.83808012e-02f, -2.25119852e-02f,
  -6.16822913e-02f, 2.62992948e-01f, 1.33716688e-01f, -1.23592407e-01f, -1.71146750e-01f, -2.82714218e-01f, 2.84068704e-01f, 1.95203975e-01f, 1.10208660e-01f, -1.84777319e-01f,
  2.16792837e-01f, -2.00827003e-01f, 5.69707118e-02f, 2.10284933e-01f, -1.80466607e-01f, 1.95358902e-01f, 5.83012812e-02f, 3.19345109e-02f, 1.59218103e-01f, -1.26181766e-01f,
  7.59875998e-02f, -1.43247068e-01f, -3.61818761e-01f, -4.94796008e-01f, -4.76586640e-01f, 2.97949791e-01f, 3.40277731e-01f, 3.10714573e-01f, -1.91249490e-01f, -1.35016888e-01f,
  2.16572046e-01f, -4.68547791e-02f, 1.79456137e-02f, 1.34990185e-01f, -1.85474664e-01f, 1.06916018e-01f, 1.71178848e-01f, -3.94405335e-01f, -4.76492643e-01f, -2.13861436e-01f,
  -4.62334305e-01f, -3.69280368e-01f, 1.25837296e-01f, -7.06745461e-02f, -2.06820339e-01f, 9.05543044e-02f, 1.33163622e-02f, 3.79249044e-02f, 1.04896232e-01f, -1.84105352e-01f,
  -8.60072449e-02f, -9.10434872e-02f, 9.56316479e-03f, 6.54165596e-02f, -8.96493345e-02f, 1.22862391e-01f, -6.05752841e-02f, -4.66441251e-02f, 1.62007206e-03f, 1.91729456e-01f,
  5.23462594e-02f, 9.95489433e-02f, 1.06176682e-01f, 2.59561747e-01f, -5.43421647e-03f, -5.88350557e-02f, 3.91647071e-02f, -1.68215439e-01f, 1.99568078e-01f, -1.62427519e-02f,
  -5.85683845e-02f, -1.57082662e-01f, -2.81181131e-02f, 2.02267364e-01f, -1.24755196e-01f, 2.63886064e-01f, -1.05857342e-01f, -2.01900348e-01f, -2.96193302e-01f, 2.52753526e-01f,
  -2.11869523e-01f, -7.63874203e-02f, -1.00723349e-01f, -6.93191513e-02f, 1.00160114e-01f, -3.64309907e-01f, 2.83229828e-01f, 1.99619427e-01f, 2.96935558e-01f, -3.12453091e-01f,
  -4.50164318e-01f, -5.51440358e-01f, -6.28461018e-02f, -4.36801054e-02f, -2.76542939e-02f, 7.01218694e-02f, 8.93507153e-02f, -2.25831270e-01f, 2.01270744e-01f, -3.38666797e-01f,
  -4.99560721e-02f, -1.60856962e-01f, 1.13420859e-02f, 1.42918095e-01f, 2.68872052e-01f, 9.11683962e-02f, -4.25030529e-01f, 2.03629509e-01f, -3.15368652e-01f, -1.38187692e-01f,
  -2.97238063e-02f, -2.27592178e-02f, 1.50025651e-01f, 1.19320914e-01f, -1.92929544e-02f, -1.22763641e-01f, -5.61860874e-02f, 9.71682593e-02f, 1.25229433e-01f, 1.07856438e-01f,
  -7.45368050e-03f, 1.92059413e-01f, -1.36931136e-01f, 1.87151685e-01f, 8.38647634e-02f, -9.00532380e-02f, 9.69283134e-02f, 1.30080767e-02f, -1.29164532e-01f, -1.16687501e-02f,
  -3.47782113e-02f, -4.26936783e-02f, 2.90863533e-02f, -2.69332618e-01f, -1.96119100e-01f, 9.41402316e-02f, 1.60727113e-01f, -4.34679501e-02f, -1.80025890e-01f, -1.65546104e-01f,
  -8.27274192e-03f, 1.80333674e-01f, 1.66197255e-01f, -2.62290269e-01f, -1.99362844e-01f, 2.60081589e-01f, 9.91622582e-02f, -5.85690327e-02f, 2.90879190e-01f, -1.16332904e-01f,
  -4.07952815e-01f, -1.01290680e-01f, -3.14251661e-01f, -8.30074996e-02f, 1.07069209e-01f, 1.01058580e-01f, -3.91915023e-01f, -2.67769486e-01f, 8.07420164e-02f, -2.38074213e-01f,
  -4.28050131e-01f, 2.34991714e-01f, 2.44089022e-01f, -2.00573877e-01f, -1.09191507e-01f, 3.10398936e-01f, 2.13216618e-01f, -3.93712133e-01f, -3.01445842e-01f, -1.34829236e-02f,
  3.25028092e-01f, -3.78740728e-01f, 1.65105700e-01f, 1.55284539e-01f, 8.56252760e-03f, -6.60582706e-02f, -5.28413616e-02f, -1.10755593e-01f, 1.63549036e-01f, -5.64498194e-02f,
  -1.20548375e-01f, -4.37759273e-02f, -9.17301252e-02f, -2.37673111e-02f, -5.80852479e-02f, -8.53418186e-02f, -1.07514448e-01f, 1.34314656e-01f, 1.80845261e-01f, -6.82856701e-03f,
  -6.01531975e-02f, 8.34084749e-02f, 3.19517292e-02f, 2.60348797e-01f, -1.12784907e-01f, -1.60911784e-01f, 3.77937630e-02f, 5.65732718e-02f, -1.22595206e-01f, -1.85072020e-01f,
  8.22052658e-02f, 1.77247852e-01f, 1.64100289e-01f, -4.26710993e-02f, 1.54028416e-01f, 2.10031494e-01f, 1.54682308e-01f, 1.38267070e-01f, -2.21154526e-01f, 3.57503518e-02f,
  3.59275751e-02f, -3.01112402e-02f, 4.19090986e-02f, 2.81448990e-01f, -2.35488430e-01f, -1.00069650e-01f, -3.23806480e-02f, 7.77799822e-03f, -2.66953290e-01f, -2.15272069e-01f,
  -4.62064922e-01f, -4.20023531e-01f, 1.40376762e-01f, 3.08198959e-01f, -2.74213582e-01f, -2.01459676e-01f, -1.30589589e-01f, 2.79511601e-01f, 2.23825797e-01f, 2.43500680e-01f,
  -3.84310246e-01f, -3.02266125e-02f, 1.01284847e-01f, -2.21393511e-01f, -2.66133398e-01f, -1.19256191e-01f, 6.32338300e-02f, 1.21139757e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  4.53026555e-02f, -3.25564668e-02f, 8.11842829e-03f, 5.92992418e-02f, 9.11578909e-02f, 4.46521193e-02f, -5.91549687e-02f, 1.23846047e-02f, -4.60998677e-02f, -9.74826366e-02f,
  -5.17741777e-02f, -7.96871111e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    