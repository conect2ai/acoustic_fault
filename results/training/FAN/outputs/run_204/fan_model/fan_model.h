/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  5.97919822e-01f, 5.37302438e-03f, -1.00042991e-01f, 2.74411738e-01f, 1.68178692e-01f, -1.03321433e-01f, -1.39316261e-01f, 1.55895486e-01f, 1.68947905e-01f, 2.25576237e-02f,
  -9.49243978e-02f, 2.08967570e-02f, -2.49419972e-01f, 4.86719124e-02f, -1.11947827e-01f, -2.82177538e-01f, 1.59266815e-01f, 8.11847374e-02f, -2.33045742e-02f, 1.78410292e-01f,
  -1.59246661e-02f, 9.75716338e-02f, -1.32809982e-01f, 1.80789828e-02f, 1.58339605e-01f, -5.96213080e-02f, 5.48071153e-02f, -1.70608193e-01f, -4.96351742e-04f, -8.03422183e-02f,
  -8.97201523e-02f, -8.71621296e-02f, 1.09970853e-01f, -6.25201687e-03f, 3.03319916e-02f, 4.07811888e-02f, 4.94505726e-02f, -1.14568263e-01f, -3.63085605e-02f, -1.91919710e-02f,
  4.90293279e-02f, 2.31915116e-02f, 7.07727391e-03f, 4.13180739e-02f, 1.51586011e-01f, -2.13149209e-02f, 2.65641697e-03f, 4.90832776e-02f, -2.17535477e-02f, 8.10076017e-03f,
  1.63726155e-02f, 7.31910840e-02f, 1.08123906e-01f, 3.03564519e-02f, -2.01494573e-03f, 1.50631890e-02f, -1.92812402e-02f, -4.68249582e-02f, 2.38519218e-02f, 3.01871747e-02f,
  2.13351045e-02f, -9.47473198e-03f, -1.50574744e-02f, 8.28603953e-02f, -1.48153109e-02f, 4.91869356e-03f, 2.42644325e-02f, -4.89091799e-02f, 1.20725930e-02f, 4.75885021e-03f,
  1.53852133e-02f, 6.22320315e-03f, 1.41437883e-02f, -1.58092119e-02f, 7.25004673e-02f, 1.27407862e-02f, 2.74725724e-02f, -5.29216975e-02f, 6.24324977e-02f, -3.84310447e-02f,
  -2.60933302e-02f, 7.80996401e-03f, -5.18770851e-02f, -3.82091664e-02f, -5.61858974e-02f, 1.59471352e-02f, 9.41594783e-03f, -1.18285641e-02f, -3.32923196e-02f, 2.72257458e-02f,
  2.31080242e-02f, -8.28293338e-02f, -1.49857834e-01f, 3.38080968e-03f, -6.56286851e-02f, 2.32102238e-02f, 2.38225646e-02f, -3.47523652e-02f, -9.47767198e-02f, -2.88760047e-02f,
  2.88412794e-02f, 1.95791535e-02f, 8.04150850e-03f, 3.92524302e-02f, 6.24681590e-03f, -4.34179753e-02f, -9.48801339e-02f, 1.32163614e-02f, 6.81081712e-02f, 7.89735541e-02f,
  3.26287523e-02f, -1.70379002e-02f, 1.46764927e-02f, 1.00387767e-01f, -3.30904871e-02f, -3.40462849e-02f, 4.05347422e-02f, 2.16916222e-02f, -1.25671504e-02f, -5.12145879e-03f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.92457891e-01f, 4.28022534e-01f, -3.37946743e-01f, 1.49488866e-01f, -1.68177009e-01f, 4.02311951e-01f, 4.35760319e-01f, -9.26083922e-02f, 2.16555610e-01f, 5.62628806e-01f,
  2.92970181e-01f, -5.95880952e-03f, 1.65877104e-01f, 6.36044502e-01f, -8.30848888e-02f, 3.80661458e-01f, 5.16206145e-01f, 4.18704003e-01f, -1.91323236e-02f, 2.17031687e-02f,
  -6.37715459e-02f, 3.88564348e-01f, -8.35180059e-02f, -5.46107516e-02f, -6.55614138e-02f, -3.18761706e-01f, -1.72133297e-02f, -2.95327663e-01f, 7.04750866e-02f, 7.56776333e-02f,
  -1.49384867e-02f, -1.29563302e-01f, -1.23602889e-01f, -1.74108684e-01f, -8.88633057e-02f, -1.27012715e-01f, -6.20728694e-02f, -1.15454510e-01f, -1.29886210e-01f, -2.30493061e-02f,
  4.86725383e-02f, -9.57968235e-02f, 4.98834699e-02f, 2.45445892e-02f, -3.68720815e-02f, -7.79180229e-02f, 1.72270183e-02f, -1.29204039e-02f, -3.03029567e-02f, -6.82266280e-02f,
  -2.89601944e-02f, 4.31783460e-02f, 5.24118580e-02f, 8.48865062e-02f, -1.01298980e-01f, 9.37063694e-02f, 1.31003425e-01f, 5.38737467e-03f, 8.53762925e-02f, 4.28960025e-02f,
  -2.46047834e-03f, -6.58710748e-02f, 5.50538637e-02f, -6.13203309e-02f, 9.55459569e-03f, -9.36498791e-02f, 6.34266287e-02f, -4.53338027e-02f, -6.95801750e-02f, 9.53201577e-02f,
  1.31207453e-02f, 2.43584719e-02f, -6.62129223e-02f, 4.83907759e-02f, 1.28122196e-01f, 3.03037371e-02f, -4.52337377e-02f, -3.20768394e-02f, 4.86718267e-02f, -2.85959989e-02f,
  3.67116742e-02f, 6.36174530e-02f, -3.96389607e-03f, -3.99601385e-02f, -1.94732528e-02f, -4.59320247e-02f, 4.36469205e-02f, 4.39079329e-02f, -7.02661201e-02f, -3.19435447e-02f,
  1.17752269e-01f, 6.32635131e-02f, 3.36943218e-03f, 6.33190153e-03f, 2.45218351e-02f, 4.22759987e-02f, 5.12851104e-02f, -9.20128822e-03f, 1.06573485e-01f, -4.51403409e-02f,
  4.34620827e-02f, 6.15940578e-02f, -1.05492167e-01f, -1.98336057e-02f, 8.35279971e-02f, 9.42520648e-02f, -2.78446963e-03f, 7.56941736e-02f, 3.65475640e-02f, -6.92017749e-02f,
  -2.03391048e-03f, 2.87189800e-02f, -2.26528998e-02f, 4.33079171e-04f, 1.77761186e-02f, 7.78173581e-02f, -8.13496187e-02f, -5.70811797e-04f, -1.02991514e-01f, 9.29377452e-02f,
  1.92722484e-01f, -3.42283219e-01f, -3.20548117e-01f, 4.55426574e-01f, 2.96179175e-01f, -1.21977024e-01f, -3.52457881e-01f, 3.77685875e-01f, -1.04983434e-01f, -2.47882128e-01f,
  2.67038792e-01f, -2.18614385e-01f, -4.90750462e-01f, 2.91597754e-01f, 3.99965674e-01f, -4.36768353e-01f, 3.57970178e-01f, 7.62111396e-02f, -1.64717987e-01f, 2.15738624e-01f,
  3.51282835e-01f, 5.55350363e-01f, 1.02683350e-01f, 3.58949989e-01f, 1.57381669e-01f, 2.17653602e-01f, 3.82935554e-01f, -1.72796473e-01f, 4.70900983e-01f, 1.97010458e-01f,
  -1.52838573e-01f, 1.58362631e-02f, -4.87028509e-02f, -1.24592200e-01f, 9.63330343e-02f, -3.12759168e-02f, -1.16838478e-01f, -2.69595999e-02f, -5.40324254e-04f, -9.11684183e-05f,
  -1.22414187e-01f, 4.82379198e-02f, 9.80040058e-02f, 3.19481976e-02f, 5.62441908e-02f, 4.72688638e-02f, -4.20129411e-02f, -1.15664758e-01f, -6.80791959e-02f, -3.74803841e-02f,
  -9.67619494e-02f, 3.55707342e-03f, -3.22794057e-02f, -7.62160942e-02f, -1.15210107e-02f, 6.84888363e-02f, -6.38752133e-02f, -5.42047024e-02f, -2.56742630e-02f, 9.55055133e-02f,
  1.21848933e-01f, -7.77115747e-02f, -5.42411506e-02f, -8.60016868e-02f, 6.15993291e-02f, -5.11764176e-02f, 3.99419293e-02f, 1.13765346e-02f, -2.59663556e-02f, 3.42194438e-02f,
  4.18385398e-03f, 8.59176144e-02f, 2.85608713e-02f, -2.71979044e-03f, 1.11676967e-02f, 1.27008150e-03f, -3.22557464e-02f, 9.04782563e-02f, -5.21923229e-02f, 3.83283831e-02f,
  -1.02129184e-01f, 9.32013988e-02f, 2.29306668e-02f, 3.30344066e-02f, 4.02634107e-02f, 6.21593790e-04f, 1.09792545e-01f, -4.51613776e-03f, -1.36464551e-01f, -1.03688342e-02f,
  1.16068654e-01f, 2.98240006e-01f, -3.84090506e-02f, 5.78838699e-02f, 2.25804877e-02f, 8.29603970e-02f, -2.36142222e-02f, 3.67533788e-02f, 3.91899869e-02f, 4.50954698e-02f,
  1.12775691e-01f, 3.14324796e-02f, 1.48138416e-03f, 3.56824659e-02f, 2.05727406e-02f, 3.66023108e-02f, 6.38967529e-02f, 4.80651669e-02f, 9.35476199e-02f, 1.15233608e-01f,
  1.14301071e-02f, -2.02263501e-02f, -3.33772115e-02f, -1.12356627e-02f, 5.43104149e-02f, -4.07651030e-02f, 4.44667749e-02f, -2.18539983e-02f, 3.85925211e-02f, -6.26446754e-02f,
  -1.83179289e-01f, -1.98127553e-01f, -4.73071560e-02f, -1.17333040e-01f, 8.38316232e-02f, 6.02068976e-02f, 1.55305728e-01f, -1.45048425e-01f, -3.30360889e-01f, 1.28998794e-02f,
  2.85652187e-02f, -6.33672252e-02f, 2.56064273e-02f, -3.06895912e-01f, -3.33025455e-01f, -3.50617707e-01f, -1.80820942e-01f, 1.80517398e-02f, -1.63229495e-01f, 1.12598248e-01f,
  -1.37723610e-01f, -1.29660457e-01f, -1.25652120e-01f, -1.95068140e-02f, 4.54756953e-02f, 2.39949644e-01f, 2.84771323e-01f, 2.36496106e-01f, 8.74613449e-02f, 8.25865008e-03f,
  -1.27999067e-01f, -8.41883421e-02f, -4.73429561e-02f, -1.15688175e-01f, 6.87901005e-02f, 1.29235730e-01f, 4.38411348e-02f, 3.77719514e-02f, 5.30645549e-02f, -2.83652972e-02f,
  7.16983452e-02f, 2.32958309e-02f, -2.40959059e-02f, -3.23553644e-02f, -3.50619741e-02f, -5.57349101e-02f, 4.67519416e-03f, 1.11162877e-02f, -9.94090289e-02f, -5.71061298e-02f,
  -4.27962057e-02f, 3.95852327e-02f, 4.91635427e-02f, 5.79530410e-02f, -5.67407627e-03f, -1.85430814e-02f, 4.62871902e-02f, 1.35812059e-01f, -3.41824703e-02f, -2.56156698e-02f,
  2.70921215e-02f, 5.75704761e-02f, -5.15438691e-02f, -1.76890999e-01f, -4.37244400e-02f, -5.14954552e-02f, -1.95633415e-02f, -3.21453996e-02f, 7.56036118e-02f, -1.61593966e-02f,
  6.38124347e-02f, -1.27901947e-02f, -5.34071028e-02f, 9.05663222e-02f, 1.00400746e-02f, 8.34952574e-03f, -2.81006820e-03f, 5.36026172e-02f, 4.71290722e-02f, 1.55070117e-02f,
  -3.52838784e-02f, 5.58580868e-02f, 4.69202027e-02f, 7.83093944e-02f, -1.10560492e-01f, 9.09419730e-02f, -2.63720173e-02f, -4.09098715e-02f, 5.68109564e-02f, 1.13461472e-01f,
  6.14634976e-02f, 9.81919020e-02f, 2.02577617e-02f, 4.24033105e-02f, 2.85600610e-02f, 9.09587089e-03f, -1.33998469e-01f, -2.44392157e-02f, 5.66219911e-02f, -7.99689814e-02f,
  1.44803688e-01f, 8.84551778e-02f, 1.15594864e-01f, -1.93869118e-02f, -7.16515537e-03f, 2.04202421e-02f, 8.92674252e-02f, 8.35429728e-02f, 1.11782387e-01f, 1.97112821e-02f,
  8.73502567e-02f, 1.19941577e-01f, -3.78210656e-02f, 6.06787540e-02f, 8.93368721e-02f, 1.83870569e-01f, 7.60963485e-02f, 5.21125905e-02f, 2.79675089e-02f, 2.29104701e-02f,
  4.45657820e-02f, 5.20076454e-01f, 5.26134670e-01f, 4.84378189e-01f, -1.79453462e-01f, -5.54530621e-01f, -1.48881450e-01f, -1.55878728e-02f, 1.93311244e-01f, -9.61998384e-03f,
  -1.02388814e-01f, 3.37950468e-01f, -1.02690220e-01f, 2.55113482e-01f, -2.42502570e-01f, -1.13720046e-02f, -8.73533785e-02f, 1.50667131e-02f, 6.44437373e-02f, 1.60729602e-01f,
  4.66413423e-02f, 8.54658149e-03f, 1.90723941e-01f, -3.61861810e-02f, 9.37983394e-02f, 2.49705061e-01f, -3.29552055e-03f, -1.94518864e-02f, 1.85296014e-01f, -2.97570676e-02f,
  -1.63522109e-01f, 1.66718110e-01f, 1.05199322e-01f, -2.40438362e-03f, -5.17070033e-02f, -5.71318567e-02f, 6.24810457e-02f, -5.27164303e-02f, 3.57187241e-02f, -7.10215494e-02f,
  -5.11768758e-02f, -7.55783692e-02f, 1.32942842e-02f, 2.87047494e-02f, 5.51280789e-02f, 2.01022197e-02f, 1.06097199e-01f, 3.72095741e-02f, 9.68684405e-02f, -1.58412494e-02f,
  1.00524917e-01f, 8.87938738e-02f, 3.03862672e-02f, 4.90906723e-02f, 1.60469711e-02f, 2.07264330e-02f, -1.99397318e-02f, 8.84110406e-02f, 2.18836907e-02f, 3.11955418e-02f,
  -2.32254062e-02f, -3.01183145e-02f, 5.85469119e-02f, 2.00137105e-02f, 6.26165560e-03f, 4.45533358e-02f, 5.47980703e-02f, 3.89483869e-02f, 4.88416441e-02f, 7.04685925e-03f,
  -9.37059671e-02f, 7.50949234e-02f, -3.09714507e-02f, 2.83300076e-02f, 1.81110762e-02f, 6.56094924e-02f, -9.80604324e-04f, -4.89048772e-02f, -3.09406836e-02f, 5.00927307e-02f,
  4.12193686e-03f, 9.88770276e-03f, 4.93943468e-02f, -3.08099426e-02f, -5.21826223e-02f, -1.52401412e-02f, 3.36832218e-02f, 3.56761329e-02f, -3.74916531e-02f, -4.30744402e-02f,
  2.24951487e-02f, 2.79536396e-01f, -7.70954601e-03f, -7.64341131e-02f, 1.49082681e-02f, -5.30980751e-02f, -2.36472506e-02f, -1.13482140e-02f, 1.14388734e-01f, -4.38201092e-02f,
  1.22869788e-02f, -6.57830536e-02f, -4.93026823e-02f, 3.11538242e-02f, -8.83052573e-02f, -8.79012328e-03f, 6.68986291e-02f, 2.52184998e-02f, -2.82429922e-02f, 6.28642514e-02f,
  9.18337107e-02f, -1.02364212e-01f, -7.44021311e-02f, -4.54922989e-02f, -3.56316604e-02f, -5.94110647e-03f, 1.82526242e-02f, 1.17648683e-01f, -1.30587339e-03f, 5.28222211e-02f,
  4.21529621e-01f, -7.07519174e-01f, 1.53308913e-01f, 3.01394880e-01f, 4.34028804e-01f, 1.24478094e-01f, 5.24922192e-01f, -3.22798699e-01f, -3.24121267e-02f, -4.98414934e-01f,
  -3.20240706e-02f, -4.64193523e-03f, -1.78505808e-01f, -8.46149102e-02f, 4.72822905e-01f, -1.43914163e-01f, -1.04697205e-01f, 3.53577873e-03f, -1.02687597e-01f, -4.39791270e-02f,
  1.39071897e-01f, 3.21240798e-02f, 1.42992228e-01f, -3.10736328e-01f, 1.47371963e-01f, -9.72904861e-02f, 1.52126309e-02f, 4.02503647e-02f, 5.75715303e-03f, 2.18217179e-01f,
  -1.51283126e-02f, -1.70118004e-01f, 1.59629826e-02f, -1.56135142e-01f, -1.18407585e-01f, -5.39836511e-02f, 1.19657703e-02f, 1.58594638e-01f, 9.06100199e-02f, 1.28047997e-02f,
  3.97001073e-04f, 7.37546682e-02f, 5.59130721e-02f, 1.19325899e-01f, -1.69156957e-02f, -9.73897427e-03f, 1.04823053e-01f, -8.19216222e-02f, -3.84592600e-02f, 9.06633586e-03f,
  -4.31276821e-02f, -2.56818812e-02f, 6.90596877e-03f, -5.60336858e-02f, -2.00634338e-02f, 4.02956903e-02f, 2.68191043e-02f, 8.40574428e-02f, 2.36993544e-02f, -2.58848630e-02f,
  -5.97403273e-02f, -2.05932204e-02f, 4.05546166e-02f, 9.90321278e-04f, 2.05263793e-02f, 1.10907897e-01f, 2.53686383e-02f, -2.55016107e-02f, -3.74197736e-02f, -3.36411297e-02f,
  6.64829314e-02f, 3.19949873e-02f, -1.20517006e-02f, 5.06084561e-02f, 2.77736690e-02f, 3.51999216e-02f, 7.82709196e-02f, -2.13678498e-02f, -9.29426104e-02f, 5.19855064e-04f,
  1.67564563e-02f, 5.54230362e-02f, -7.25705177e-02f, -2.54414771e-02f, 8.89769231e-04f, 5.71451820e-02f, -4.08837311e-02f, -3.06196837e-03f, -2.22239587e-02f, 7.99777918e-03f,
  -4.24016476e-01f, -5.45145333e-01f, -9.20614302e-02f, -7.99631327e-02f, -9.76981148e-02f, -9.45468843e-02f, 2.24792715e-02f, -6.93100020e-02f, -1.89762771e-01f, -3.72831672e-02f,
  -2.43212674e-02f, 3.88413891e-02f, -9.52430218e-02f, 7.05862045e-02f, -7.49444123e-03f, -1.58596579e-02f, -5.68664409e-02f, -1.12352416e-01f, -7.79613405e-02f, -1.55035466e-01f,
  -4.41880077e-02f, 2.85925735e-02f, 1.56262051e-02f, 2.50565670e-02f, -9.00103599e-02f, 2.99486723e-02f, 2.29957514e-02f, 2.33452171e-02f, -7.97517374e-02f, -3.66008282e-02f,
  2.75663257e-01f, -1.99924022e-01f, -8.19843933e-02f, -2.66445190e-01f, -2.96837203e-02f, 7.34523311e-02f, 3.24328467e-02f, -2.51444012e-01f, -5.20705581e-01f, -2.12024331e-01f,
  -8.44836682e-02f, 5.32498062e-02f, 1.62519321e-01f, 5.03749028e-03f, 2.54823208e-01f, 1.99926779e-01f, -4.49391864e-02f, 2.07744911e-02f, -5.77442683e-02f, 2.26796027e-02f,
  4.46205363e-02f, -1.14025595e-03f, 1.82889268e-01f, 8.34703296e-02f, -2.44134124e-02f, -9.63834748e-02f, -5.79166226e-03f, 1.65695801e-01f, -5.93004078e-02f, 6.89807534e-02f,
  -3.64566222e-02f, -6.14689256e-04f, 2.90123355e-02f, 3.68315913e-02f, 1.14606291e-01f, 8.70227367e-02f, 9.84424055e-02f, 1.40149295e-01f, -9.60751697e-02f, 1.09713944e-02f,
  9.81744081e-02f, 4.51248400e-02f, -6.18982688e-02f, 6.24313802e-02f, -1.54392058e-02f, -1.18224896e-01f, 2.63278037e-02f, -4.22675386e-02f, -1.19230226e-01f, 1.91624627e-01f,
  -4.34071831e-02f, 5.75120747e-03f, -8.15134943e-02f, -5.32983840e-02f, -9.22177136e-02f, -3.88537273e-02f, 7.98677355e-02f, 4.72993366e-02f, -1.44290224e-01f, -9.65640917e-02f,
  9.71560255e-02f, 4.77851816e-02f, 5.35115339e-02f, 4.84285764e-02f, 6.06048107e-02f, -4.54089232e-02f, 6.35233074e-02f, 6.18077181e-02f, 1.04895448e-02f, 1.80413164e-02f,
  -4.13823463e-02f, -8.82205963e-02f, 5.01746945e-02f, -3.89687344e-02f, 3.24112028e-02f, -1.09321633e-02f, 5.55174500e-02f, 3.85518111e-02f, -1.01602986e-01f, 1.64521150e-02f,
  -2.00140923e-02f, 2.45354492e-02f, 9.75980423e-03f, -1.04720339e-01f, -2.41283514e-02f, -6.88575953e-02f, -8.43858719e-03f, -2.21895054e-03f, 3.48921008e-02f, 5.80111519e-02f,
  -1.25417829e-01f, -1.20693550e-01f, -1.01020694e-01f, -4.81098108e-02f, -5.31352707e-04f, 5.31668626e-02f, 4.48515490e-02f, -8.69616419e-02f, 7.78985992e-02f, -4.43688072e-02f,
  8.11018571e-02f, 2.87503675e-02f, -5.55359535e-02f, -3.88699993e-02f, -9.87854749e-02f, -3.64032425e-02f, 2.94047389e-02f, -1.01753101e-01f, -4.10578586e-03f, -4.80472334e-02f,
  -1.10452492e-02f, 7.70428255e-02f, 7.30905682e-02f, -1.43212518e-02f, -1.18325800e-01f, -2.15648804e-02f, 2.89624743e-02f, -1.99570390e-03f, 6.17891811e-02f, -4.26038057e-02f,
  -9.35409125e-03f, -1.51262665e-02f, -3.62400174e-01f, -2.27196559e-01f, -2.86292940e-01f, -5.45849860e-01f, -3.72974783e-01f, -2.31209114e-01f, 2.27938220e-01f, 1.05019823e-01f,
  -1.09865978e-01f, 2.29554027e-01f, 3.03223997e-01f, -2.53841102e-01f, 2.70055123e-02f, 2.86019325e-01f, -3.82031113e-01f, -7.26891235e-02f, 7.24758953e-02f, -2.66123295e-01f,
  -1.29483372e-01f, -1.85255513e-01f, -2.64744133e-01f, -1.83357045e-01f, -3.91170084e-01f, -1.00083344e-01f, 3.55150737e-02f, -1.14816964e-01f, -2.82137364e-01f, -6.10600263e-02f,
  -1.44514620e-01f, 2.40840793e-01f, -4.00218740e-02f, 5.41882729e-03f, -1.43285990e-01f, -6.20849878e-02f, -1.57953471e-01f, 6.57288209e-02f, -7.16216769e-03f, 2.06908956e-02f,
  3.42159644e-02f, 1.09475449e-01f, 4.45571616e-02f, 1.13630548e-01f, -5.51077984e-02f, -3.22034769e-02f, -1.23411454e-02f, -1.21320263e-01f, 5.57764806e-02f, -3.29013541e-02f,
  -1.09862924e-01f, -7.74459764e-02f, -1.76790774e-01f, 6.03565313e-02f, -3.55367772e-02f, -6.69500008e-02f, -2.07432378e-02f, -3.38391587e-02f, -9.39943716e-02f, -1.89106865e-03f,
  1.15860533e-02f, 8.24988186e-02f, -5.66689968e-02f, -1.04856174e-02f, -3.34469713e-02f, -3.58001739e-02f, -1.25901606e-02f, 8.49254131e-02f, -2.53476817e-02f, 4.36750939e-03f,
  1.48722576e-02f, 6.84921294e-02f, -1.55340899e-02f, -6.90780580e-02f, -6.27374202e-02f, 3.82729732e-02f, 9.75028984e-03f, 7.34502003e-02f, -1.12711176e-01f, -4.81164716e-02f,
  2.45189201e-02f, 1.54606560e-02f, 1.48443040e-02f, -3.67743894e-02f, -7.02498481e-02f, 5.11019304e-02f, 1.44733554e-02f, -3.82910222e-02f, 8.00296664e-02f, -5.10423928e-02f,
  -1.55979395e-01f, -3.58318202e-02f, 3.63365188e-02f, 6.07911646e-02f, -2.86195800e-03f, -6.31747320e-02f, -2.95957923e-02f, -5.07442094e-02f, 3.89667898e-02f, -8.07407275e-02f,
  -6.18685596e-02f, 6.89973459e-02f, -9.01012421e-02f, 4.70519811e-03f, -1.33155538e-02f, -6.88692927e-02f, -1.87028684e-02f, 7.49230459e-02f, -1.47825643e-01f, -3.89913395e-02f,
  -2.41052974e-02f, 4.26558703e-02f, 6.57062829e-02f, 3.32579128e-02f, 5.99663295e-02f, -3.12251076e-02f, -2.35123001e-02f, 9.35386643e-02f, -3.96353863e-02f, 5.78488857e-02f,
  -4.09797221e-01f, -3.89594994e-02f, 1.05330110e-01f, -4.16342705e-01f, 1.11455075e-01f, 3.08792219e-02f, -3.12555015e-01f, 1.98926423e-02f, -2.50380486e-01f, -2.06509516e-01f,
  -1.84220493e-01f, -1.16308860e-01f, 1.26794130e-01f, -3.47732157e-01f, 1.33156195e-01f, 1.66333318e-01f, -2.86953658e-01f, -1.31771386e-01f, 2.99421493e-02f, -1.79622293e-01f,
  -6.81009702e-03f, -3.18133801e-01f, 2.21501775e-02f, -8.35814420e-03f, -2.12607861e-01f, -1.11312091e-01f, -7.02384412e-02f, 1.03302985e-01f, -1.58698052e-01f, 4.03880738e-02f,
  -1.50858626e-01f, -3.30866098e-01f, 6.80048093e-02f, 1.39378794e-02f, -1.05568372e-01f, -5.41478805e-02f, -3.06998063e-02f, 8.24691951e-02f, -1.33688441e-02f, 2.39476617e-02f,
  -2.99356924e-03f, -1.10986996e-02f, -1.39502794e-01f, -1.56050790e-02f, 5.95415868e-02f, 1.05997073e-02f, 4.80485484e-02f, 4.39879857e-02f, -3.44786197e-02f, 7.16267824e-02f,
  6.22724295e-02f, 8.42313468e-02f, 5.02092764e-02f, 6.61798939e-02f, 8.69760588e-02f, 7.84798525e-03f, 1.26203327e-02f, 1.20858856e-01f, 4.17182548e-03f, -3.53437252e-02f,
  -9.18655768e-02f, -5.42387217e-02f, 1.43215870e-02f, -1.78112891e-02f, -5.74497692e-02f, -4.98877056e-02f, 1.63367875e-02f, -4.22241241e-02f, -1.24320965e-02f, -1.22932522e-02f,
  -7.43160024e-02f, -8.00094455e-02f, -5.37484139e-02f, -2.43891422e-02f, -7.83320442e-02f, -1.10102154e-01f, -1.19439438e-02f, -9.09738466e-02f, 4.95932549e-02f, -2.11603083e-02f,
  -1.62169114e-02f, 5.28250970e-02f, -5.51663525e-02f, 1.97559204e-02f, -5.82770482e-02f, 2.64454931e-02f, 5.03347740e-02f, 5.41199408e-02f, -1.74930673e-02f, 4.81705070e-02f,
  -2.63614370e-03f, -2.43737832e-01f, -9.98191014e-02f, -2.26328876e-02f, 5.19346260e-02f, 7.29851751e-03f, 9.73611255e-04f, 2.60070842e-02f, 6.92885742e-03f, 1.83789045e-04f,
  6.40639290e-03f, -6.78191856e-02f, 5.63939922e-02f, -9.56639822e-04f, 4.57009897e-02f, 3.90397869e-02f, -5.57743721e-02f, 7.07387328e-02f, 1.41950091e-02f, 5.98692745e-02f,
  5.15265353e-02f, -4.64275442e-02f, 3.36701572e-02f, -7.76799396e-02f, -1.00744531e-01f, -1.24879852e-01f, -2.04975922e-02f, 5.03063165e-02f, 9.34146866e-02f, 5.79880178e-02f,
  1.75585687e-01f, 3.37838411e-01f, 2.15779066e-01f, 3.08051914e-01f, -2.16763452e-01f, -1.08580060e-01f, 1.11591928e-01f, 5.49800182e-03f, 2.56763846e-01f, 2.15556994e-01f,
  -2.42240041e-01f, 4.81401026e-01f, -1.15491964e-01f, 3.90554257e-02f, -3.67445856e-01f, -3.00673902e-01f, 5.82293095e-03f, 1.38439655e-01f, 1.54118380e-02f, 1.17983416e-01f,
  -3.80124198e-03f, -2.32479990e-01f, -1.53892964e-01f, -5.85679524e-02f, 1.48852661e-01f, 2.74060130e-01f, -2.53948152e-01f, -4.73535992e-02f, 3.56260389e-02f, -8.31398070e-02f,
  5.99826574e-02f, -1.50472000e-02f, 9.31697264e-02f, -4.45212834e-02f, 1.24391234e-02f, 7.57637173e-02f, -9.81585011e-02f, -9.94101688e-02f, -9.75705236e-02f, 7.70917535e-03f,
  1.65126801e-01f, 3.37932035e-02f, 4.31211926e-02f, -2.59788684e-03f, 8.60071406e-02f, 7.38710463e-02f, 9.34164971e-03f, -4.33544219e-02f, 1.19574234e-01f, 4.05462123e-02f,
  9.80472490e-02f, 8.59274343e-02f, 4.79307920e-02f, -4.82873060e-02f, -5.23886532e-02f, 4.24325131e-02f, 4.83246185e-02f, -1.04596332e-01f, 3.75723243e-02f, -1.03030894e-02f,
  -1.15541257e-01f, -1.64036509e-02f, -5.31482361e-02f, -1.18422676e-02f, -5.08178920e-02f, -7.76821095e-03f, 1.75158251e-02f, -8.50656778e-02f, -1.67239811e-02f, -2.84707211e-02f,
  1.83637049e-02f, 3.08707766e-02f, 1.43938400e-02f, -2.73490231e-02f, 2.40097288e-02f, 4.05268818e-02f, 1.26492763e-02f, -1.72666356e-03f, 7.03016222e-02f, -2.22638156e-02f,
  -3.80366854e-02f, -7.48983920e-02f, 9.63165835e-02f, -1.08627183e-02f, -4.46099937e-02f, -4.57478166e-02f, 6.77230135e-02f, 1.15521550e-01f, -1.08285174e-01f, 9.70299356e-04f,
  -9.92841572e-02f, 4.47748287e-04f, 1.10602863e-01f, 8.82293433e-02f, 2.52496302e-02f, -4.05735746e-02f, -1.02112889e-01f, 1.41208857e-01f, -1.04930840e-01f, 8.40069652e-02f,
  6.60033673e-02f, 3.16616967e-02f, -3.03084366e-02f, -7.68588483e-02f, -1.34442281e-02f, 5.78132980e-02f, 1.48103386e-02f, -5.01367413e-02f, -5.37419058e-02f, -5.85124157e-02f,
  -2.33519562e-02f, 3.51237766e-02f, 9.23859775e-02f, -1.69571117e-02f, -7.03289406e-03f, 1.02085406e-02f, 3.52258049e-02f, 1.28088482e-02f, -2.48670951e-02f, -5.79991452e-02f,
  -5.17897546e-01f, 2.34112293e-01f, 4.51688975e-01f, -1.63705990e-01f, -4.19011116e-02f, 3.20096016e-01f, 3.36452007e-01f, 1.88853480e-02f, -4.35482375e-02f, -2.91014202e-02f,
  -4.63997433e-03f, 3.84599864e-02f, 3.05201024e-01f, 4.94073965e-02f, 1.64213717e-01f, 1.77181348e-01f, 9.09009874e-02f, 1.22300074e-01f, 7.21423030e-02f, -1.78648923e-02f,
  -1.78419501e-01f, -1.58074707e-01f, 2.26616338e-01f, -1.68233942e-02f, -9.95245799e-02f, -8.15259442e-02f, -1.75950766e-01f, 1.49060383e-01f, -5.32737039e-02f, 1.56325638e-01f,
  -9.44263861e-02f, -2.20667616e-01f, -2.14109585e-01f, -1.71017717e-03f, -3.20066214e-02f, -3.21158171e-02f, 1.56394914e-01f, 2.58462653e-02f, -4.78650630e-02f, 7.29145994e-03f,
  -1.28515055e-02f, 1.43314540e-01f, -4.66370396e-02f, -4.06341180e-02f, 1.71969458e-02f, -7.15380982e-02f, 1.33713866e-02f, -1.94726151e-03f, 2.20725704e-02f, 9.45929587e-02f,
  1.37826666e-01f, 9.21618119e-02f, -7.69364834e-02f, 6.58343881e-02f, 3.58667923e-03f, -3.90525125e-02f, -3.67084742e-02f, 5.86774498e-02f, -1.63614210e-02f, -3.67937163e-02f,
  2.81336978e-02f, 7.83804506e-02f, -6.40197992e-02f, -1.74426138e-02f, 3.95222055e-03f, 1.23589942e-02f, -2.50665452e-02f, -6.68269545e-02f, -4.16360721e-02f, -1.95155255e-02f,
  -7.71350190e-02f, 1.43329240e-02f, 4.38442305e-02f, 1.49161285e-02f, 2.94082891e-02f, 1.14672109e-02f, -1.45249879e-02f, -2.50947215e-02f, 8.24723393e-02f, -4.21185121e-02f,
  -5.14217392e-02f, -7.07250163e-02f, 8.19432288e-02f, 2.30928827e-02f, 6.69264942e-02f, -4.85199364e-03f, -6.14140071e-02f, 2.71169096e-02f, -1.67923160e-02f, -4.44853269e-02f,
  -2.06564218e-01f, -1.48163378e-01f, -8.26198757e-02f, -1.00902274e-01f, 2.63808686e-02f, -8.38043764e-02f, -5.46796210e-02f, -8.39805752e-02f, -8.98702294e-02f, -5.29642478e-02f,
  -4.79467772e-02f, -3.79234217e-02f, -1.50514524e-02f, 1.04477108e-01f, 4.33472618e-02f, -5.23944944e-02f, -9.84272882e-02f, -9.12073180e-02f, -7.89346471e-02f, -3.59555036e-02f,
  -6.17704466e-02f, -6.38778061e-02f, 9.43771675e-02f, -7.37715960e-02f, -2.81846169e-02f, 4.62333150e-02f, -6.30138069e-02f, -8.49058107e-03f, 3.35499905e-02f, 4.80304435e-02f,
  -6.35384500e-01f, 3.93842489e-01f, -1.85383052e-01f, -3.91743958e-01f, 1.95841745e-01f, -2.47174233e-01f, -1.82939976e-01f, 1.15263090e-01f, -5.48195206e-02f, 1.88177615e-01f,
  9.24650803e-02f, -9.85430777e-02f, 3.12039882e-01f, -1.43774852e-01f, -7.46662080e-01f, -1.27918750e-01f, -3.67057294e-01f, -1.47945896e-01f, 3.89448479e-02f, -4.26148559e-04f,
  -2.09133282e-01f, 7.52491578e-02f, -1.14601433e-01f, 4.46477205e-01f, -1.22393049e-01f, 2.90612951e-02f, 2.25983653e-02f, 3.73165488e-01f, -1.13556489e-01f, -4.36232463e-02f,
  -1.99776635e-01f, 5.71552590e-02f, -1.05066895e-01f, -9.97343510e-02f, -8.40350986e-02f, -1.40372127e-01f, -3.75705883e-02f, -1.49166277e-02f, -2.96361744e-03f, 2.04974110e-03f,
  -3.88864763e-02f, 2.55915821e-02f, -8.47237483e-02f, 1.32742211e-01f, -1.81205440e-02f, -5.30220242e-03f, -7.74602219e-03f, -3.97331752e-02f, -1.41555560e-03f, -1.76644307e-02f,
  9.64948349e-03f, -1.72116179e-02f, 1.97635368e-02f, -7.16428906e-02f, -1.55542657e-01f, 1.03565389e-02f, -8.22749287e-02f, -4.95737381e-02f, -5.79427890e-02f, -6.86887056e-02f,
  5.36966324e-02f, -4.85416278e-02f, 2.60973573e-02f, 1.42757306e-02f, 2.90745758e-02f, 5.44584431e-02f, 1.81570090e-02f, 3.45417485e-03f, 3.38014588e-02f, 4.60028574e-02f,
  -5.16011789e-02f, 7.44153373e-03f, 4.56022993e-02f, -8.68477896e-02f, -2.30887756e-02f, -7.97941163e-02f, 3.18013169e-02f, 3.21768150e-02f, -5.76336309e-03f, 2.87388754e-03f,
  8.78475010e-02f, -6.80920333e-02f, 6.01374842e-02f, -1.58339366e-02f, 8.51433724e-04f, 6.83062226e-02f, -4.53454852e-02f, 1.46979876e-02f, -3.89541015e-02f, -4.62841056e-02f,
  -1.20831177e-01f, 3.50243896e-02f, 3.21291923e-03f, 1.11534353e-02f, 1.05388360e-02f, -4.10133973e-02f, -3.68681997e-02f, -1.31003380e-01f, -1.18639596e-01f, -4.78729196e-02f,
  -5.32201752e-02f, -7.89217129e-02f, -6.58573732e-02f, -2.61456892e-02f, 8.38507563e-02f, -1.14374598e-02f, -1.96448341e-02f, -4.78223227e-02f, -3.43626142e-02f, 9.78284981e-04f,
  3.07052471e-02f, 4.62784879e-02f, -4.42704894e-02f, 4.47217226e-02f, -4.71381620e-02f, -1.47944493e-02f, -3.26895379e-02f, -3.13186496e-02f, -5.77844083e-02f, -4.47048433e-02f,
  2.43313029e-01f, 1.70683593e-01f, -1.70329213e-01f, 4.64211218e-02f, -1.57753587e-01f, 9.86075252e-02f, -1.10286530e-02f, -4.42929827e-02f, -1.28075838e-01f, 6.67507648e-02f,
  2.10857064e-01f, -4.68885228e-02f, 5.96834272e-02f, 3.16994607e-01f, -1.26984552e-01f, 9.87561867e-02f, 1.99585676e-01f, 2.19098642e-01f, -5.25202006e-02f, 1.31992744e-02f,
  3.37480269e-02f, 2.44544178e-01f, -2.25837491e-02f, -7.32486472e-02f, 1.29232362e-01f, -7.24357143e-02f, 3.62105072e-02f, -7.13195279e-02f, 1.39841586e-01f, -3.44907083e-02f,
  1.70184448e-01f, 7.26184249e-02f, 4.57618870e-02f, -2.67437771e-02f, -1.41371144e-02f, 7.71389902e-02f, -6.63513541e-02f, -8.44819620e-02f, 7.99285248e-03f, 8.53983313e-02f,
  2.51107924e-02f, 3.49428616e-02f, 3.66817713e-02f, -5.63313067e-02f, -7.84244388e-02f, 1.16558410e-02f, -1.15567716e-02f, -1.52495888e-03f, 2.01031435e-02f, 5.73231205e-02f,
  6.94893375e-02f, 1.15367532e-01f, 2.72772042e-03f, -5.52558936e-02f, 2.45734248e-02f, -2.89692683e-03f, -9.82469022e-02f, -5.04324473e-02f, -2.48727761e-02f, -4.96660359e-02f,
  -5.47868200e-02f, 5.98324873e-02f, 7.08816797e-02f, 9.92806479e-02f, 5.57543822e-02f, 5.91889955e-02f, -3.40937376e-02f, -2.62105167e-02f, -1.33862328e-02f, -3.08188493e-03f,
  1.92405321e-02f, -3.00566386e-02f, 9.67918038e-02f, 3.83023098e-02f, 4.94555719e-02f, -2.56250682e-03f, 1.23620415e-02f, 4.63050567e-02f, 1.07846566e-01f, -9.27421544e-03f,
  -9.10044741e-03f, -2.92750448e-02f, -3.86173129e-02f, 3.80785353e-02f, -2.61700731e-02f, 5.02281683e-03f, 5.02444431e-02f, 8.75961706e-02f, -1.03853447e-02f, 8.21931753e-03f,
  -9.42840427e-02f, -4.20083255e-02f, -4.39591594e-02f, -3.41406912e-02f, -1.17727712e-01f, 8.47299397e-03f, -1.17168371e-02f, 5.14240935e-02f, 9.32889804e-03f, 4.73467261e-02f,
  -5.14792129e-02f, -5.71807139e-02f, 1.06875133e-02f, 8.28685462e-02f, -1.00449167e-01f, 1.43532678e-02f, 2.31614094e-02f, -3.25664580e-02f, -4.86804694e-02f, -3.03848535e-02f,
  -3.67797501e-02f, 5.20869950e-03f, -1.33827887e-02f, 3.30652595e-02f, -3.91063727e-02f, -1.54421143e-02f, -7.11580068e-02f, -8.18348080e-02f, 6.15560189e-02f, 2.91752443e-02f,
  2.25850776e-01f, 4.31735367e-02f, 3.89263719e-01f, 3.31522167e-01f, 1.83104932e-01f, 3.39120150e-01f, 4.91556764e-01f, 2.78883368e-01f, 7.05172002e-01f, -3.66884977e-01f,
  -3.14294010e-01f, 1.91065878e-01f, -1.68627687e-02f, -1.20500699e-01f, 1.60735548e-01f, 4.83291633e-02f, 1.70974955e-01f, 4.54296730e-02f, 3.75603259e-01f, 1.04366370e-01f,
  1.46649972e-01f, -8.54859352e-02f, -1.06563456e-01f, -3.13404351e-01f, -8.58044252e-02f, -5.47795035e-02f, -4.53459948e-01f, 4.29450013e-02f, -4.33617413e-01f, -4.83239740e-02f,
  1.63425989e-02f, 1.56546533e-01f, -1.57784689e-02f, 2.63233837e-02f, -5.81620634e-02f, -3.72142978e-02f, 1.33396374e-04f, 3.05502750e-02f, 8.08675364e-02f, 5.74851558e-02f,
  -1.66500136e-02f, -8.15382078e-02f, 1.43912286e-02f, 2.08947062e-02f, 1.35209903e-01f, -6.42808601e-02f, 3.81770283e-02f, 2.94404533e-02f, 3.00222114e-02f, 4.36897203e-02f,
  -8.92515108e-03f, 9.97162703e-03f, 4.53897044e-02f, 4.02281731e-02f, 2.16887295e-02f, 4.32839803e-02f, 7.70806000e-02f, 3.80306095e-02f, -6.83301091e-02f, 9.98605415e-02f,
  1.02816552e-01f, 7.85559192e-02f, -2.99886651e-02f, -2.75811721e-02f, 1.70350429e-02f, -1.29570335e-01f, -2.02372409e-02f, -7.36737847e-02f, 8.80834013e-02f, -4.92060483e-02f,
  -2.50779670e-02f, 9.83650098e-04f, 9.47736055e-02f, 2.62678917e-02f, 2.10697483e-03f, 1.27740148e-02f, -1.68738943e-02f, 7.26911146e-03f, 4.20964845e-02f, -4.16349573e-03f,
  1.87332612e-02f, 6.80627972e-02f, -1.36001885e-01f, -1.17947616e-01f, -9.07874946e-03f, 1.14252344e-02f, -7.62536470e-03f, 8.90095234e-02f, 4.64720326e-03f, -4.92559522e-02f,
  9.78137776e-02f, 1.21923879e-01f, -4.22637798e-02f, 5.64026311e-02f, 5.12596779e-02f, -8.70627984e-02f, 3.90927866e-02f, -1.49782253e-02f, 1.75943896e-01f, 7.16448203e-02f,
  1.67392474e-02f, 2.01310981e-02f, -2.56222058e-02f, -2.43289340e-02f, 5.33915199e-02f, 1.47127975e-02f, 7.34746177e-03f, 2.33308654e-02f, -1.38751063e-02f, -1.81918480e-02f,
  -7.79364109e-02f, 1.25500694e-01f, -3.37389484e-02f, -7.82505274e-02f, -5.46945706e-02f, -8.61662850e-02f, -1.29239000e-02f, -2.60229968e-02f, -4.73263152e-02f, -8.75038281e-03f,
  1.20048791e-01f, -1.44546449e-01f, 1.06192194e-01f, 3.00702512e-01f, -3.07215704e-03f, -2.14156121e-01f, -6.70296624e-02f, -2.36947387e-01f, -2.16075972e-01f, -1.68267518e-01f,
  8.64451081e-02f, 1.90610483e-01f, 6.88696131e-02f, -1.09216675e-01f, 8.99023786e-02f, -1.61692604e-01f, -1.29168853e-02f, 4.69558500e-02f, 6.42501574e-04f, 1.44747794e-01f,
  8.62525776e-02f, -1.87828898e-01f, 1.84940606e-01f, -1.50620444e-02f, 7.02107251e-02f, 1.91258177e-01f, 3.00259888e-01f, 1.03189923e-01f, 2.23155111e-01f, 1.11103706e-01f,
  -3.83349769e-02f, 1.01867365e-02f, 6.01063147e-02f, -1.58911664e-02f, -1.26238912e-02f, 8.74358043e-02f, 1.85120448e-01f, 8.20601732e-02f, 2.57253535e-02f, -5.80119677e-02f,
  8.96823630e-02f, 1.44924941e-02f, -1.12785406e-01f, -7.92113040e-03f, -1.23711988e-01f, 3.36073227e-02f, -9.54318419e-02f, 5.88391759e-02f, 5.84773645e-02f, 4.04799506e-02f,
  -9.12446994e-03f, 1.43657653e-02f, 6.45372272e-02f, 2.03240830e-02f, 9.23515633e-02f, -4.08239961e-02f, 4.12277952e-02f, 1.10136546e-01f, -4.75524440e-02f, -4.67787609e-02f,
  7.09953159e-02f, -4.13447358e-02f, -6.52085096e-02f, -2.01452029e-04f, -6.17319113e-03f, -7.37164021e-02f, -1.05766639e-01f, 3.38909924e-02f, -2.76412200e-02f, -3.85114551e-02f,
  -2.87678558e-02f, 9.23237950e-02f, -2.02438831e-02f, -3.87454107e-02f, 8.50830227e-02f, -2.97353454e-02f, 2.26241238e-02f, 1.30447119e-01f, 4.27248925e-02f, 3.66017316e-03f,
  -3.77632082e-02f, -8.35809577e-03f, -5.97613677e-02f, 3.57815810e-02f, 8.84865131e-03f, 4.70525660e-02f, -7.54713491e-02f, 6.90714130e-03f, 4.81374897e-02f, -4.30204682e-02f,
  -7.19146132e-02f, -6.60459092e-03f, 6.92673922e-02f, -5.02941664e-03f, -4.65952940e-02f, 2.05146838e-02f, 5.28217526e-04f, -2.85781007e-02f, 8.81416164e-03f, 1.06221223e-02f,
  4.13965583e-02f, 4.20402102e-02f, -1.03400506e-01f, 4.08324599e-02f, 6.78576007e-02f, -1.14856668e-01f, 2.25363132e-02f, 3.58501039e-02f, 4.40016538e-02f, 2.97106300e-02f,
  3.65822129e-02f, -1.97450095e-03f, 6.93147108e-02f, -4.92798574e-02f, 5.11579122e-03f, 6.54566884e-02f, 4.17900793e-02f, -1.00475270e-02f, 8.89625400e-02f, 5.06870449e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  3.82799655e-01f, 5.05414844e-01f, 8.85026157e-02f, 2.85540640e-01f, 3.92221630e-01f, 1.17059715e-01f, 2.04657286e-01f, 3.61579806e-01f, 4.65680629e-01f, 4.19349849e-01f,
  5.73517203e-01f, 6.43458366e-02f, 5.88817656e-01f, 2.09444523e-01f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -3.20271760e-01f, 5.38006604e-01f, 3.22218895e-01f, 3.31166714e-01f, -2.82952070e-01f, 2.49873355e-01f, -2.92487383e-01f, 8.45925286e-02f, -3.61394674e-01f, -1.84177652e-01f,
  -1.78923622e-01f, -2.56431587e-02f, -1.75440237e-02f, 2.62532711e-01f, -2.25827858e-01f, 8.12969953e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  8.76033753e-02f, 3.45751196e-02f, -1.21000618e-01f, 1.05633572e-01f, -1.30750507e-01f, 1.02817547e+00f, -3.04456830e-01f, -4.57769781e-01f, 7.54675388e-01f, -1.30475923e-01f,
  8.02813828e-01f, -8.09339341e-03f, 4.62494791e-01f, -8.51792395e-02f, 6.77116394e-01f, 1.79089963e-01f, 1.48041144e-01f, 2.05924455e-02f, 1.75928563e-01f, 1.47733462e+00f,
  2.22177103e-01f, -3.08782924e-02f, -3.88779700e-01f, 2.33385339e-01f, 6.03394747e-01f, 5.35900652e-01f, -3.24352264e-01f, -3.00654054e-01f, 6.47084534e-01f, -7.68103004e-02f,
  -3.67480397e-01f, 3.79079223e-01f, 5.97229227e-02f, -3.57374661e-02f, 1.15707982e+00f, -2.43599322e-02f, -2.68737525e-01f, -5.17555047e-03f, -2.95810461e-01f, 4.78554636e-01f,
  6.09370947e-01f, 3.06379385e-02f, 7.48225152e-02f, 7.52129182e-02f, -3.80859196e-01f, 5.13564825e-01f, -1.43667251e-01f, -1.48210749e-01f, 2.22265631e-01f, 4.25778836e-01f,
  7.72273317e-02f, 6.81056082e-01f, -3.16203922e-01f, -3.70410174e-01f, 6.63728237e-01f, -3.18338841e-01f, -2.14578316e-01f, -2.62652546e-01f, -7.56287873e-02f, -2.10707068e-01f,
  -2.07485124e-01f, 2.61049688e-01f, 6.16416872e-01f, -2.91751891e-01f, 5.97724676e-01f, 1.37035415e-01f, -7.10711107e-02f, -4.91037499e-03f, 3.64885032e-01f, 4.29339886e-01f,
  -3.38486612e-01f, -3.99413049e-01f, -2.08493829e-01f, -3.61487456e-02f, 7.40817308e-01f, 6.27949461e-02f, 1.01862156e+00f, 9.44892541e-02f, -1.74037486e-01f, -1.55438362e-02f,
  -3.26036736e-02f, 1.07253000e-01f, -3.56496990e-01f, -3.60510722e-02f, -1.64165631e-01f, 1.09766394e-01f, 7.26510286e-01f, -1.79813549e-01f, 6.01146281e-01f, 5.98469019e-01f,
  -1.15017071e-01f, 4.03272331e-01f, 1.10759377e-01f, 4.69638593e-02f, 8.11852049e-03f, 2.13835031e-01f, 3.40323895e-01f, -1.11886561e+00f, 9.54629600e-01f, -1.02990307e-01f,
  -4.15143520e-01f, -1.00130670e-01f, -2.94718236e-01f, 1.39142677e-01f, 1.91136494e-01f, 5.28972268e-01f, -8.65174755e-02f, 8.60423505e-01f, 6.90763652e-01f, 5.91710806e-02f,
  2.50995874e-01f, -3.80511999e-01f, 3.61289680e-01f, -2.64418721e-01f, -1.33756399e-01f, -1.78562820e-01f, -1.40826136e-01f, -2.11073253e-02f, 8.11857581e-01f, 5.87910712e-01f,
  1.28751593e-02f, 9.92751420e-02f, 2.97947586e-01f, 6.56790376e-01f, -2.71286726e-01f, -2.91023590e-02f, 8.30960929e-01f, 2.89049566e-01f, 1.07355334e-01f, 3.64460617e-01f,
  2.41830066e-01f, 7.42224753e-01f, -3.90040688e-02f, 2.33356848e-01f, 8.26516986e-01f, -1.44238919e-01f, -2.21270565e-02f, -3.33664030e-01f, 8.97684693e-02f, 4.59819399e-02f,
  -3.34243327e-01f, 2.20583454e-02f, 6.36386931e-01f, 3.10783803e-01f, -2.28961453e-01f, -8.31251591e-02f, -6.55554757e-02f, 4.48333859e-01f, 8.24994966e-02f, 5.20116031e-01f,
  3.20350453e-02f, -1.11414246e-01f, -1.22422040e-01f, 1.13088060e-02f, -3.36386561e-02f, -1.57509431e-01f, -2.07660824e-01f, 1.03405133e-01f, -1.79089122e-02f, 2.87217170e-01f,
  5.75064480e-01f, 2.39514768e-01f, -1.93631202e-01f, 2.98561335e-01f, 8.09159756e-01f, -2.65538633e-01f, 5.14526904e-01f, -1.41445830e-01f, -3.52620572e-01f, -4.13924493e-02f,
  -5.28324917e-02f, 5.42415902e-02f, -7.35616609e-02f, -1.53040931e-01f, -6.12926558e-02f, 3.77904058e-01f, -1.47856906e-01f, -2.09360644e-01f, 1.20558426e-01f, -6.14946857e-02f,
  -2.38116890e-01f, -1.03224665e-01f, -2.16870189e-01f, -1.92236215e-01f, 4.14470024e-02f, 4.47016545e-02f, 8.72407630e-02f, 5.49477292e-03f, -5.55204228e-02f, 3.07727195e-02f,
  -1.99198201e-01f, -1.28811836e-01f, 5.35773411e-02f, -3.97790633e-02f, 5.23561954e-01f, 1.37591064e-01f, -2.27219939e-01f, -1.35439308e-02f, -2.33642116e-01f, -4.35627159e-03f,
  2.63001472e-01f, -2.70182520e-01f, -2.14608103e-01f, 1.08296685e-01f, 2.32432082e-01f, 2.75778323e-01f, -2.84311354e-01f, -1.60431787e-02f, 3.43480319e-01f, 5.46162546e-01f,
  6.36634052e-01f, -3.83816324e-02f, -1.96144417e-01f, -3.68994437e-02f, 3.67126018e-02f, -2.08178684e-01f, 2.01566011e-01f, -5.49535096e-01f, 4.30452496e-01f, -8.54601860e-02f,
  -3.59744012e-01f, 3.30079526e-01f, 7.06171751e-01f, -7.92028531e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  4.45880473e-01f, 2.79628217e-01f, 3.88213426e-01f, -6.05162494e-02f, 2.68608958e-01f, 1.55305922e-01f, 4.84446734e-01f, 3.23975086e-01f, -2.98389550e-02f, -2.22088903e-01f,
  6.73474967e-01f, -2.25825548e-01f, -4.09836993e-02f, 1.27136454e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  7.18725473e-02f, 5.87083876e-01f, -2.76273966e-01f, -5.69836617e-01f, 7.88121998e-01f, -3.88131142e-01f, 2.17655778e-01f, -2.61021674e-01f, 7.83448517e-01f, -6.07413530e-01f,
  -3.00678730e-01f, -2.32578203e-01f, -1.67692944e-01f, 2.05805048e-01f, 5.68486392e-01f, 2.38375098e-01f, -1.92956015e-01f, 1.28638792e+00f, -6.39742792e-01f, 5.89803040e-01f,
  7.41150796e-01f, 2.85509080e-01f, -8.34770054e-02f, -3.18625242e-01f, -1.82047948e-01f, 2.21407749e-02f, 1.90593064e-01f, -1.68936715e-01f, -1.26331434e-01f, -9.60696638e-02f,
  3.46038967e-01f, 4.57937241e-01f, -3.22187752e-01f, 8.80548656e-01f, -6.75091386e-01f, 5.29453099e-01f, -5.54683268e-01f, 7.07260847e-01f, -5.21096289e-01f, 9.65257362e-02f,
  -4.93030190e-01f, -3.03009480e-01f, 7.44446397e-01f, 2.83157676e-01f, 2.96059430e-01f, 1.14897795e-01f, -1.42650098e-01f, -1.03960924e-01f, -1.77334860e-01f, -6.93151891e-01f,
  6.10134542e-01f, 3.27832997e-01f, -5.49842715e-01f, 3.30963582e-02f, 8.43190253e-01f, -1.24830931e-01f, 4.57508504e-01f, -6.92124724e-01f, -4.96528774e-01f, 1.27068944e-02f,
  -7.35903144e-01f, -1.58021599e-02f, 2.09883496e-01f, -2.88008064e-01f, 3.16254407e-01f, -9.14560676e-01f, -2.99863666e-01f, -2.48017743e-01f, -2.68997014e-01f, -3.14731777e-01f,
  9.24513265e-02f, -2.96140313e-02f, 1.21299827e+00f, 4.50639457e-01f, -5.19103825e-01f, 6.12266250e-02f, -1.36233792e-01f, -3.85716595e-02f, -2.58627951e-01f, -5.45091212e-01f,
  5.50787270e-01f, -4.01067674e-01f, 5.66625297e-01f, -6.04849994e-01f, 2.56534576e-01f, 9.49845687e-02f, -8.38459134e-02f, -7.05146968e-01f, 4.41575438e-01f, 1.12506859e-01f,
  2.66381502e-01f, -9.91435200e-02f, -1.69396907e-01f, 1.13499714e-02f, -1.86469570e-01f, 7.31826484e-01f, 4.58916843e-01f, -4.40857291e-01f, -1.11763380e-01f, -5.82037032e-01f,
  -4.91489053e-01f, 9.20788348e-01f, -1.40037060e-01f, 4.88296431e-03f, -8.24184120e-01f, 1.08720034e-01f, 6.95342898e-01f, -1.70102552e-01f, 2.75524557e-01f, 4.00828868e-02f,
  1.18474485e-02f, 7.37899184e-01f, -5.22682667e-01f, -2.93730527e-01f, 3.81578296e-01f, 5.99106431e-01f, 3.37756068e-01f, -1.70119375e-01f, -3.81882787e-01f, 7.34646142e-01f,
  5.00407405e-02f, -1.97119907e-01f, -4.50709522e-01f, 2.37884924e-01f, -3.81411612e-01f, 6.39017373e-02f, 5.39736226e-02f, -2.04359531e-01f, -7.09446788e-01f, 6.25183344e-01f,
  6.14822686e-01f, 8.10044169e-01f, -4.14030701e-01f, -2.46314228e-01f, 1.14156596e-01f, -2.71601856e-01f, -5.21325469e-01f, -4.20159221e-01f, 3.58974338e-01f, 6.63372219e-01f,
  -1.14930101e-01f, -1.16166789e-02f, 6.24895096e-02f, -2.93824017e-01f, -4.04640406e-01f, -6.10865772e-01f, -7.84205675e-01f, -4.35752630e-01f, -1.15004674e-01f, -9.71698537e-02f,
  -1.23358689e-01f, 3.29445124e-01f, -2.81703472e-01f, 1.00102484e+00f, 3.76225263e-01f, 4.40915376e-02f, 4.96516645e-01f, 8.25353432e-04f, 1.11380361e-01f, -3.15309197e-01f,
  5.55084884e-01f, -3.43472064e-01f, -5.44287115e-02f, 7.55091131e-01f, -4.71268117e-01f, -3.72994602e-01f, 8.49814415e-01f, -3.48519385e-01f, -3.47360164e-01f, -5.45815587e-01f,
  -4.21153247e-01f, -1.77147314e-01f, 9.54567075e-01f, 4.86162640e-02f, -2.87600875e-01f, -3.09827775e-01f, 3.54283124e-01f, -2.62382746e-01f, 8.88813972e-01f, -7.48807132e-01f,
  -2.26553157e-01f, -3.73001814e-01f, 9.16328192e-01f, 1.02604859e-01f, -7.22267389e-01f, 1.37553945e-01f, 8.08921009e-02f, 1.87366650e-01f, -2.08903030e-02f, 1.16358124e-01f,
  -3.32611740e-01f, 3.52812171e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -3.21392149e-01f, 2.75171041e-01f, -2.27723002e-01f, -4.51617837e-01f, 5.93062580e-01f, 9.89782810e-02f, 3.55525762e-02f, -4.80641127e-01f, -9.98913795e-02f, -3.40795591e-02f,
  2.97737837e-01f, 2.11792752e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    