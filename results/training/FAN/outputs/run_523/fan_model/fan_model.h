/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.85158744e-01f, 1.52689591e-02f, 4.69488390e-02f, 5.34204356e-02f, -8.72210264e-02f, 2.61930913e-01f, 2.01842338e-01f, -2.68438626e-02f, 7.51116201e-02f, 5.12069184e-03f,
  2.01486245e-01f, 5.99920787e-02f, 1.49119154e-01f, 2.17843980e-01f, 2.66429126e-01f, 2.42484793e-01f, 2.71577656e-01f, 1.15345277e-01f, -8.51426832e-03f, -6.30903291e-04f,
  3.83128785e-02f, 9.20067877e-02f, 8.71028304e-02f, -1.61426127e-01f, -6.92687333e-02f, -1.37582272e-01f, -6.40869960e-02f, -1.34242386e-01f, 5.29505424e-02f, -7.75765330e-02f,
  1.06655508e-01f, -4.92516570e-02f, 8.65580365e-02f, -2.41324976e-02f, 1.28837703e-02f, 1.88488215e-02f, -1.04449115e-04f, -3.35806943e-02f, -9.66382213e-03f, -4.96814437e-02f,
  -6.91844895e-02f, -3.70626375e-02f, -3.60798202e-02f, 2.36657280e-02f, 3.70304771e-02f, -4.85611297e-02f, -4.36546095e-02f, -2.62275487e-02f, 5.33667020e-02f, 6.23652823e-02f,
  1.80224180e-02f, 3.88572970e-03f, 9.26268324e-02f, -1.85537047e-03f, 4.92980937e-03f, 4.63192426e-02f, 4.59289365e-02f, -4.82033379e-02f, -2.65660584e-02f, 2.55453982e-03f,
  -3.23613845e-02f, -6.39341176e-02f, -1.65136978e-02f, -2.26644264e-03f, 3.39178182e-03f, -2.93099321e-02f, 6.71931729e-03f, -6.80826977e-02f, -2.59760655e-02f, -3.64773721e-02f,
  -6.94736047e-03f, -6.20216830e-03f, 2.88409321e-03f, 8.86826217e-03f, 8.39226395e-02f, -1.73537359e-02f, -4.03250121e-02f, -6.63597211e-02f, 1.86743494e-02f, 6.82631731e-02f,
  -4.63353656e-02f, -8.12295228e-02f, -8.36817920e-02f, 6.90727457e-02f, 3.41396667e-02f, -5.28723486e-02f, 1.24369347e-02f, 2.95681525e-02f, -5.29169329e-02f, 7.47721568e-02f,
  6.57258332e-02f, -6.37757704e-02f, -6.90223277e-03f, -3.28771882e-02f, -6.48432076e-02f, 1.82261094e-02f, 8.43943562e-03f, -4.39745337e-02f, 3.18202563e-02f, 1.69370435e-02f,
  -4.13905308e-02f, -2.76398715e-02f, -4.53660972e-02f, 2.81227264e-03f, -4.14390787e-02f, 3.01177707e-02f, -7.50867948e-02f, -9.55872163e-02f, -4.25033160e-02f, -4.30550314e-02f,
  6.72953390e-03f, -6.05488978e-02f, -8.94908234e-03f, 1.96426995e-02f, -8.04821774e-02f, -1.07936308e-01f, -2.50248294e-02f, -9.27585270e-03f, 2.77034938e-02f, -4.80896942e-02f,
  2.87709147e-01f, -7.89060965e-02f, 1.49968520e-01f, 1.54240102e-01f, -4.12769206e-02f, -3.46508145e-01f, -3.27559650e-01f, 4.90383245e-02f, -4.86268140e-02f, -2.85553783e-01f,
  -1.72595993e-01f, -7.59304240e-02f, -3.19910139e-01f, -8.13542604e-02f, 3.65782529e-02f, -2.45508462e-01f, 4.86440957e-02f, -1.19655602e-01f, 3.55178304e-02f, 1.77228393e-03f,
  1.62050754e-01f, -4.06535864e-02f, 1.08482294e-01f, 2.19989911e-01f, 8.27618018e-02f, 2.63687909e-01f, 1.90231036e-02f, 1.69810373e-02f, 6.06926791e-02f, -2.92592831e-02f,
  4.83117849e-02f, 5.23046255e-02f, 4.64934185e-02f, 2.82957946e-04f, 4.51971069e-02f, 3.76348495e-02f, -2.60281656e-02f, -6.90458342e-02f, -2.72182133e-02f, -7.34856538e-03f,
  -3.18652205e-02f, 6.61679581e-02f, 5.96167222e-02f, 5.93894348e-03f, 3.97176407e-02f, 2.75365282e-02f, 1.30370595e-02f, -3.74517776e-02f, -6.75503165e-02f, 3.41610648e-02f,
  -5.17957062e-02f, 5.64790750e-03f, -1.74291097e-02f, -3.55106429e-03f, 1.70731544e-02f, -2.11975258e-02f, -6.05155062e-03f, 2.83139385e-02f, 6.55561034e-03f, -1.24484897e-02f,
  2.19796542e-02f, 1.23589532e-02f, 7.02561438e-02f, -4.23895977e-02f, 1.19675240e-02f, 5.67540340e-02f, 2.55577802e-03f, -1.58715453e-02f, 6.99832141e-02f, -4.32828022e-03f,
  2.01920886e-03f, 1.94714051e-02f, 3.93253379e-02f, -1.98120493e-02f, -2.58634686e-02f, 1.66698284e-02f, 2.70222593e-02f, -3.23710255e-02f, -3.66139086e-03f, -2.97178421e-02f,
  -4.42991927e-02f, 3.90516520e-02f, -2.90673729e-02f, 1.76410880e-02f, -2.68642996e-02f, 1.40678575e-02f, 3.23869064e-02f, 8.25942028e-03f, 6.52861446e-02f, 1.58076901e-02f,
  -9.09601375e-02f, -8.46073627e-02f, -5.41469827e-02f, -4.83819880e-02f, 1.02245240e-02f, -3.97800608e-03f, 8.77853110e-03f, 1.06125645e-01f, 3.82321626e-02f, -1.60581376e-02f,
  3.53021398e-02f, -7.75085092e-02f, 6.75473269e-03f, -2.82222182e-02f, -1.74509343e-02f, 3.41700241e-02f, -7.80490935e-02f, -1.34392856e-02f, 1.81250889e-02f, -4.62878542e-03f,
  3.24940272e-02f, -6.61099330e-02f, -4.69514541e-03f, 2.82438640e-02f, -2.40656491e-02f, -7.18577057e-02f, -2.84195249e-03f, 8.31075199e-03f, 2.14529242e-02f, -6.75996020e-02f,
  3.28472942e-01f, -1.45360053e-01f, 5.77700585e-02f, -8.93402472e-02f, 6.53857589e-02f, -1.14534339e-02f, 3.82531583e-02f, -9.66503769e-02f, 2.28981704e-01f, -1.71140254e-01f,
  2.60691182e-03f, 1.51992962e-02f, 5.32415211e-02f, -2.00239614e-01f, 3.08606595e-01f, 1.76158965e-01f, -1.25906663e-02f, 6.90267757e-02f, 7.10552558e-02f, -6.70092031e-02f,
  -3.62768257e-03f, -1.34538785e-01f, -6.95587248e-02f, -1.97777182e-01f, -6.31505921e-02f, -9.65337902e-02f, -1.57726645e-01f, -1.04223251e-01f, -1.46308422e-01f, 8.42024386e-03f,
  4.00522053e-02f, 5.17083406e-02f, -7.25508928e-02f, 4.60301302e-02f, 3.32258642e-02f, 9.56274010e-03f, 6.86055347e-02f, 3.30070108e-02f, 3.83971119e-03f, 1.89309125e-03f,
  8.19653869e-02f, 7.11179972e-02f, 2.82267593e-02f, 4.34055403e-02f, -2.99701728e-02f, 9.02218372e-02f, 1.94364577e-04f, 5.20006940e-02f, 2.59993486e-02f, 6.50699586e-02f,
  -3.04453112e-02f, 2.07676347e-02f, 1.61402095e-02f, 2.45989654e-02f, 8.96920450e-03f, -1.49764344e-02f, -3.56841311e-02f, 1.98320094e-02f, -5.50906174e-02f, 2.86132861e-02f,
  3.73283178e-02f, -2.39963434e-03f, -7.78553560e-02f, -1.83893144e-02f, -4.55994792e-02f, -1.19586429e-02f, -3.54894847e-02f, 2.10071802e-02f, -1.13937603e-02f, -1.94584038e-02f,
  1.72437802e-02f, -7.12937117e-02f, 8.47647153e-03f, -1.89073272e-02f, -6.46617031e-03f, 5.12999892e-02f, -2.01447625e-02f, -3.81370708e-02f, 1.89342629e-02f, 3.83496583e-02f,
  2.16030050e-02f, -1.82771950e-03f, -6.11497760e-02f, -4.16513607e-02f, -2.17747875e-02f, 6.37967605e-04f, 1.57930441e-02f, 6.36072680e-02f, -3.51902954e-02f, -2.50639990e-02f,
  -2.03588489e-03f, -6.69082478e-02f, -4.88574915e-02f, 5.43500409e-02f, 4.81705088e-03f, -4.45183143e-02f, 9.47160460e-03f, 7.73863643e-02f, -5.51788360e-02f, -4.04776372e-02f,
  -1.70432739e-02f, -5.07860407e-02f, -2.31580902e-03f, -2.15511043e-02f, -3.60327885e-02f, -1.89979561e-02f, 1.56215299e-02f, 5.92152216e-02f, -5.58391698e-02f, -6.70608832e-03f,
  -1.03879869e-02f, -4.01295610e-02f, -5.56595959e-02f, -2.99751144e-02f, 7.43314205e-03f, 7.13530602e-03f, 2.02622265e-02f, 3.54490355e-02f, 3.71681787e-02f, 6.25065565e-02f,
  3.83392796e-02f, 8.09431225e-02f, 6.58190548e-02f, 1.43317565e-01f, 1.99155062e-02f, 9.31234285e-02f, 1.74530268e-01f, 1.63326755e-01f, 1.82587802e-01f, 6.37348071e-02f,
  1.39028013e-01f, 8.00680593e-02f, -7.38295447e-03f, 1.70031756e-01f, 7.93175697e-02f, 1.47445351e-01f, 2.01697230e-01f, 2.47045942e-02f, 9.16262418e-02f, 1.13136314e-01f,
  8.37487727e-02f, 1.09385110e-01f, 1.65940717e-01f, 6.82584345e-02f, -6.35668859e-02f, -4.14650068e-02f, -3.12277451e-02f, -3.27167474e-02f, 4.52548563e-02f, -1.25451665e-02f,
  1.22115016e-02f, -3.59917134e-02f, -1.25058100e-01f, 2.27146596e-03f, -1.22996271e-01f, -1.46250263e-01f, -6.69330582e-02f, -4.13981937e-02f, 6.14812151e-02f, 3.75171900e-02f,
  -6.29109517e-02f, -4.90289330e-02f, 3.02749849e-03f, -2.25522765e-03f, -6.66296557e-02f, 5.91410026e-02f, 5.20378314e-02f, 9.16692913e-02f, 3.50871906e-02f, -2.82659568e-03f,
  -1.69841759e-02f, 5.50315641e-02f, 1.20192971e-02f, 2.54318584e-02f, -3.14399116e-02f, 1.45262126e-02f, 1.07770145e-01f, 2.20492133e-03f, 4.52352315e-02f, 4.59109545e-02f,
  -1.18044587e-02f, -4.95411567e-02f, -5.40733859e-02f, -5.87287508e-02f, 6.47942796e-02f, -6.17134944e-02f, 9.86488387e-02f, -3.26808095e-02f, -4.87761013e-03f, -2.07585916e-02f,
  3.47980624e-03f, -1.09253274e-02f, -5.25085852e-02f, 2.80822609e-02f, -9.46956500e-02f, 1.76530201e-02f, -1.16547316e-01f, -4.17357050e-02f, 4.10410613e-02f, -9.32716858e-03f,
  7.02309832e-02f, -8.03762954e-03f, 1.88324433e-02f, -4.99550551e-02f, -7.58938715e-02f, 8.60047862e-02f, 5.09069487e-02f, -3.49660739e-02f, -2.60037575e-02f, -4.45005335e-02f,
  -1.17684565e-02f, -8.09895247e-03f, -6.26174510e-02f, -4.49791364e-02f, -8.56760070e-02f, -9.83684286e-02f, -5.95116429e-02f, 1.16046868e-01f, -5.13778515e-02f, -3.39366980e-02f,
  -7.41621107e-02f, -3.91080491e-02f, 1.88560225e-02f, 3.57127413e-02f, 6.83107972e-02f, -3.05088293e-02f, 5.69872893e-02f, 3.14033069e-02f, 5.67902923e-02f, -3.42049375e-02f,
  1.63691118e-02f, 3.04209199e-02f, -6.41375184e-02f, 2.03734450e-02f, 5.78228645e-02f, 3.79893333e-02f, -5.47655635e-02f, 1.20049017e-02f, 3.77880372e-02f, -4.69916277e-02f,
  3.88041615e-01f, -2.82288864e-02f, -6.38310611e-02f, 1.92136735e-01f, 1.08255625e-01f, 8.48700926e-02f, 8.99937451e-02f, 3.98440659e-02f, 2.31471211e-01f, -2.81356256e-02f,
  -8.67520347e-02f, 7.37845898e-02f, -4.66455072e-02f, -3.60528729e-03f, 2.06066817e-01f, -6.89203367e-02f, 1.07022166e-01f, -3.42089161e-02f, 5.52148856e-02f, 5.95334247e-02f,
  8.32208991e-02f, 4.36526164e-02f, -1.41196236e-01f, -8.41056705e-02f, 6.85671624e-03f, -1.07867315e-01f, -4.88690995e-02f, -1.42557427e-01f, -1.01618003e-02f, -1.06692286e-02f,
  1.51039800e-02f, -1.24077126e-02f, 2.59980708e-02f, 1.70667861e-02f, 6.96713701e-02f, -4.59370427e-02f, 8.09481088e-03f, -7.62956440e-02f, 8.72696862e-02f, 1.37653891e-02f,
  4.41791415e-02f, -7.23243086e-03f, 8.53508413e-02f, 1.19501203e-02f, 3.18022259e-02f, -3.94517146e-02f, -2.31154282e-02f, -3.10769584e-02f, -4.07282449e-02f, -5.02045639e-02f,
  1.89623926e-02f, -4.28350121e-02f, -5.06834835e-02f, -5.20984605e-02f, 3.48795466e-02f, 6.48467466e-02f, -1.41631002e-02f, -8.60449150e-02f, -2.17946339e-02f, 3.42610814e-02f,
  6.37486055e-02f, 1.50581263e-02f, 2.20027342e-02f, 6.05825074e-02f, -3.29618752e-02f, -4.44515459e-02f, -4.94259708e-02f, -2.80688028e-03f, -3.17176655e-02f, 3.42306569e-02f,
  3.44345085e-02f, 4.41453569e-02f, 7.15551972e-02f, 4.68616672e-02f, -1.58670060e-02f, -6.91576600e-02f, 1.22676026e-02f, 4.04049009e-02f, -1.65128447e-02f, -5.73828146e-02f,
  2.51124091e-02f, 2.83012558e-02f, -1.11090221e-01f, -2.59992145e-02f, -1.12331901e-02f, -3.97136249e-03f, -1.78755485e-02f, -2.97586638e-02f, 5.08341156e-02f, -5.19444682e-02f,
  -2.32176669e-02f, 1.00235805e-01f, -4.14604228e-03f, 1.09973399e-03f, -2.89963651e-02f, 2.78826859e-02f, -3.22730541e-02f, -1.02624400e-02f, 5.58772571e-02f, 1.73723437e-02f,
  3.09232157e-02f, 9.76840500e-03f, -3.87751609e-02f, -3.93749168e-03f, 1.55555205e-02f, 4.98249428e-03f, 6.18132465e-02f, 1.76071394e-02f, 1.83449425e-02f, -1.09145939e-02f,
  -2.13906262e-02f, 8.67957249e-02f, 4.34961878e-02f, 8.00420251e-03f, 4.97545153e-02f, 4.59162258e-02f, -1.35361087e-02f, -1.66079402e-02f, -3.02942898e-02f, -2.24066116e-02f,
  2.91349351e-01f, 1.69944569e-01f, -1.49630141e-02f, 1.60563067e-01f, 5.96279465e-02f, 8.81916732e-02f, -7.76955951e-03f, 1.02024972e-02f, 5.61359301e-02f, 7.65814409e-02f,
  4.59203124e-03f, -1.01328734e-02f, -3.67556065e-02f, 7.44663477e-02f, -8.53063241e-02f, -1.16284490e-01f, -3.23077329e-02f, 4.55713607e-02f, -2.68372167e-02f, 1.66213766e-01f,
  -1.83048695e-02f, -7.27400929e-02f, -1.54737607e-02f, 8.73738062e-03f, 1.83338463e-01f, 1.21090293e-01f, -3.93915847e-02f, 1.35913277e-02f, 1.55387729e-01f, -1.08700059e-01f,
  1.05980910e-01f, -1.28356844e-01f, 3.97563241e-02f, -2.01888056e-03f, -3.59103084e-02f, 5.01952246e-02f, 8.56413990e-02f, 3.92745361e-02f, -1.61553156e-02f, -9.88219678e-03f,
  -1.04791357e-03f, -3.11326683e-02f, -2.40928289e-02f, -2.62427367e-02f, -1.35896467e-02f, 1.96109489e-02f, 7.78288096e-02f, 8.07832703e-02f, -5.90693355e-02f, 3.39328195e-03f,
  5.08386679e-02f, 4.74308282e-02f, 7.04949200e-02f, -1.38010690e-02f, 8.95711705e-02f, 1.31016374e-02f, -2.97259428e-02f, 2.65803281e-02f, 4.36536483e-02f, -2.74453051e-02f,
  3.32609341e-02f, -5.57618774e-02f, 2.48789545e-02f, 7.33790994e-02f, 7.32069388e-02f, -1.48243280e-02f, -4.60896492e-02f, 3.47304679e-02f, 3.46666947e-02f, -3.86472344e-02f,
  7.90496841e-02f, -6.08228855e-02f, -6.73719542e-03f, 9.48082358e-02f, 3.45115215e-02f, 7.30236666e-03f, 8.65922868e-03f, -9.65084601e-03f, 8.64325166e-02f, -1.93131566e-02f,
  -1.22658670e-01f, 2.19407491e-02f, 6.22368306e-02f, 7.12113455e-02f, -5.92046231e-02f, -3.82081121e-02f, 3.38214971e-02f, -1.74283162e-02f, -2.95446999e-02f, -4.43094522e-02f,
  1.80155039e-02f, -9.98355895e-02f, 1.30427340e-02f, 6.02303073e-02f, -5.53138964e-02f, 8.32689777e-02f, -1.13053717e-01f, -7.70212011e-03f, -7.16812164e-02f, 1.31482622e-02f,
  1.22497313e-01f, 1.16280047e-02f, 3.30265015e-02f, -3.58340777e-02f, -6.38409555e-02f, -5.98623790e-02f, 1.29949590e-02f, -4.83019128e-02f, 4.67028394e-02f, -5.44830859e-02f,
  8.32150355e-02f, -5.57146482e-02f, -5.75988106e-02f, 2.55402941e-02f, 1.31564140e-02f, -3.41060907e-02f, -4.07533087e-02f, 1.12158693e-02f, -4.76448461e-02f, -1.20994877e-02f,
  -1.64241530e-02f, -6.66915923e-02f, -2.81009704e-01f, -7.01759532e-02f, 5.23549020e-02f, 2.16675714e-01f, 1.31828085e-01f, -2.20181808e-01f, -2.08431959e-01f, 9.58413705e-02f,
  9.71605852e-02f, -1.37793407e-01f, -2.86939405e-02f, 2.73490459e-01f, 2.14323103e-02f, -1.25929192e-02f, 1.46169260e-01f, 1.03645466e-01f, -1.97417468e-01f, -9.06373933e-02f,
  -1.00266598e-01f, 3.10482919e-01f, -1.16189402e-02f, 1.19064949e-01f, 1.15109899e-03f, -1.71245679e-01f, 1.48563907e-01f, -4.50671986e-02f, 2.50977725e-01f, 1.02895446e-01f,
  -2.71157343e-02f, -1.61737815e-01f, 4.34406810e-02f, 2.20032427e-02f, -7.55865127e-03f, 6.89151809e-02f, 3.71381044e-02f, -5.13852166e-04f, -8.31108466e-02f, -7.77006000e-02f,
  1.71909016e-02f, 2.69612074e-02f, 7.80047253e-02f, 3.73938791e-02f, -5.05025359e-03f, -1.20700439e-02f, -2.51664110e-02f, -2.87537966e-02f, 9.68051795e-03f, -2.06546020e-02f,
  -7.49523863e-02f, -2.19676667e-03f, -4.85386997e-02f, -5.14312945e-02f, -2.08691508e-02f, 8.99325777e-03f, 2.52650939e-02f, -6.69143582e-03f, -5.31770289e-02f, -2.75456570e-02f,
  -1.70044415e-02f, 1.14515284e-02f, -2.18075365e-02f, 3.19698490e-02f, -6.57340586e-02f, 3.40148062e-02f, 5.89793250e-02f, 3.96665819e-02f, -3.75375599e-02f, 1.95754804e-02f,
  -4.67073917e-02f, 2.98683718e-02f, -8.44001696e-02f, 7.29054287e-02f, 5.54759875e-02f, -6.05388964e-03f, -3.18442620e-02f, -2.32914425e-02f, -6.72684088e-02f, -3.78273576e-02f,
  -2.57015750e-02f, -3.60739194e-02f, 1.29280221e-02f, 8.07983205e-02f, -3.60656232e-02f, -4.86425348e-02f, 2.96869688e-02f, 1.25914831e-02f, 6.39967695e-02f, 4.70651276e-02f,
  4.84229587e-02f, -1.34351358e-01f, -5.56918122e-02f, 3.32992449e-02f, -5.31168771e-04f, 5.62518314e-02f, -1.72442440e-02f, -7.19203055e-02f, -3.28465141e-02f, -6.54251128e-02f,
  1.46064246e-02f, 5.10982163e-02f, 1.87436920e-02f, 1.33965947e-02f, -2.33466309e-02f, 6.03562556e-02f, 5.00262156e-02f, -2.63247918e-02f, 1.55003350e-02f, 6.36783838e-02f,
  1.26708046e-01f, 9.68346186e-03f, -7.88692385e-02f, -1.55402748e-02f, 1.08250074e-01f, 2.50781723e-03f, 2.60223392e-02f, -2.64511351e-02f, 7.71996379e-02f, 2.25754678e-02f,
  1.56536832e-01f, 9.07339528e-02f, -1.89509153e-01f, -3.81935015e-02f, 7.38747120e-02f, 8.18630159e-02f, -7.45770186e-02f, 1.30896062e-01f, 8.35503340e-02f, 7.53610581e-03f,
  1.33228183e-01f, -9.74040926e-02f, -1.28665239e-01f, 1.52811140e-01f, -9.16134641e-02f, -1.47210509e-01f, 1.35014355e-01f, -8.93392116e-02f, -4.88244779e-02f, -3.27527970e-02f,
  -4.99264225e-02f, 1.57794714e-01f, -6.67440742e-02f, 9.07549784e-02f, 7.75619224e-02f, -8.76866654e-02f, 6.60677031e-02f, -1.01255007e-01f, 1.48058385e-01f, -7.46454895e-02f,
  1.18073441e-01f, 1.28848571e-02f, 6.46228567e-02f, -5.60209807e-03f, 1.67502329e-01f, -9.06268880e-03f, -3.12227663e-02f, 2.55682133e-02f, 2.73274686e-02f, 5.63915931e-02f,
  1.37828654e-02f, -5.29690161e-02f, -8.57865717e-03f, -6.77996799e-02f, -4.74504381e-02f, -4.01641801e-02f, -1.68341361e-02f, -1.55900372e-02f, -4.83300649e-02f, -4.72319350e-02f,
  -1.06355362e-01f, 1.04080373e-02f, 3.96650583e-02f, -3.52045782e-02f, -9.38316062e-02f, 3.21147256e-02f, -9.28324386e-02f, -6.41762046e-03f, 9.60163921e-02f, 6.81544915e-02f,
  -3.36814187e-02f, -5.88544235e-02f, -2.16882676e-02f, 4.90219751e-03f, 2.01929584e-02f, 2.89972518e-02f, -2.14260276e-02f, 6.59432635e-02f, -9.83030796e-02f, -3.10575720e-02f,
  1.16601638e-01f, -4.73919809e-02f, -1.65103134e-02f, -5.74043244e-02f, 4.19773199e-02f, 1.10860197e-02f, -2.23197192e-02f, 6.42906204e-02f, 6.04934432e-02f, 2.14793980e-02f,
  -5.09928390e-02f, 1.55769298e-02f, -4.27484028e-02f, 2.06438475e-03f, 2.97664907e-02f, -2.63130330e-02f, -1.08349428e-01f, -8.20421427e-02f, 4.68713641e-02f, 5.54386452e-02f,
  7.94054344e-02f, -5.46598509e-02f, 9.35470015e-02f, 1.21312156e-01f, 1.71853490e-02f, 5.46651939e-03f, 2.02360917e-02f, 5.09237610e-02f, 3.51634286e-02f, 3.65290307e-02f,
  -1.67810153e-02f, -4.09546457e-02f, 1.03603527e-02f, -5.23159988e-02f, 2.41628215e-02f, 1.39669487e-02f, 8.06846395e-02f, 2.44037602e-02f, 1.67165786e-01f, 4.55592535e-02f,
  3.00054234e-02f, 9.56955329e-02f, -7.51757696e-02f, 3.65240388e-02f, 2.41709016e-02f, -1.21637166e-01f, 7.09289089e-02f, 4.19306010e-02f, 7.92667642e-02f, 6.96567670e-02f,
  -7.54543543e-02f, 1.96685255e-01f, 6.02938831e-02f, 1.00987546e-01f, -8.02528411e-02f, -2.97161251e-01f, -3.02389711e-01f, 4.24942672e-02f, 5.89677170e-02f, 1.59223024e-02f,
  -1.19092561e-01f, 2.53077656e-01f, -1.05493762e-01f, -1.46461859e-01f, -1.81312114e-01f, -2.10675612e-01f, -6.69489577e-02f, -1.92243478e-03f, -4.67183255e-02f, -9.15740523e-03f,
  6.28607124e-02f, -1.08775541e-01f, -1.30771426e-02f, 4.33177799e-02f, -3.30846161e-02f, 1.15996130e-01f, 1.54947504e-01f, 4.70367186e-02f, 1.27669603e-01f, -4.41385806e-02f,
  2.89129578e-02f, -1.39853498e-02f, 1.04728796e-01f, 8.18970241e-03f, 3.74375246e-02f, 7.76323378e-02f, 6.98957816e-02f, -1.16271943e-01f, -2.72115669e-03f, -2.33755913e-02f,
  3.29127461e-02f, -9.69530549e-03f, 6.73337653e-02f, -1.21447228e-01f, 2.26319842e-02f, -3.45506109e-02f, 7.37787709e-02f, 3.98398228e-02f, -5.17752729e-02f, 2.14483757e-02f,
  2.63412353e-02f, 6.18954189e-02f, 9.12579242e-03f, 6.42319769e-02f, 4.98813391e-02f, -4.15328075e-04f, 2.86131608e-03f, -7.78570026e-03f, 4.48493138e-02f, 1.93451550e-02f,
  3.61328945e-03f, -3.39940302e-02f, -2.64210775e-02f, 1.23410821e-01f, -8.96009728e-02f, 6.99640438e-02f, -3.68176661e-02f, 7.87874218e-03f, 1.34031381e-02f, -3.87287959e-02f,
  7.22275972e-02f, -1.30350748e-02f, 1.19216656e-02f, 1.98276844e-02f, -6.88256398e-02f, 4.86295186e-02f, -1.74283870e-02f, -6.79115504e-02f, -8.23265165e-02f, -2.49051154e-02f,
  8.82155299e-02f, -7.24827871e-02f, 1.54940020e-02f, 1.32538388e-02f, -3.51491570e-02f, 2.84254588e-02f, -3.46511602e-02f, -5.45197912e-02f, 7.28954226e-02f, 6.82163313e-02f,
  5.44704571e-02f, 5.92169948e-02f, 3.86444367e-02f, -6.86467439e-02f, 7.47289062e-02f, 1.53101450e-02f, -1.84111521e-02f, 1.78779778e-03f, 4.83222976e-02f, -1.23394892e-01f,
  4.70660701e-02f, -1.12683354e-02f, -5.09180389e-02f, -3.77153419e-02f, 9.55175534e-02f, -2.03828439e-02f, 3.37119736e-02f, -7.31592474e-04f, 3.94065939e-02f, 4.31000665e-02f,
  -1.17625634e-03f, 5.92652895e-03f, 4.03706394e-02f, 4.95168194e-02f, 2.45985738e-03f, 3.88361774e-02f, 3.23153473e-02f, 6.67643547e-02f, -2.73694526e-02f, 8.04239605e-03f,
  -1.53652549e-01f, 1.11648753e-01f, 4.36781049e-02f, 1.99381813e-01f, -1.02092259e-01f, -2.25909829e-01f, -1.46984205e-01f, 1.79164279e-02f, -1.53469548e-01f, 1.10555310e-02f,
  5.85334785e-02f, -9.01287124e-02f, -7.12248161e-02f, 2.44216278e-01f, -1.98741078e-01f, 3.66420969e-02f, 1.46391809e-01f, 4.94461507e-02f, 2.78300755e-02f, 8.49129446e-03f,
  -4.90471087e-02f, 2.12465525e-01f, 8.96567628e-02f, -1.42773511e-02f, 6.56027198e-02f, 8.47127661e-02f, 9.87929329e-02f, -7.29189515e-02f, 1.46517217e-01f, -6.04101531e-02f,
  -1.19635865e-01f, 1.13040067e-01f, 6.12510787e-03f, -4.72692847e-02f, -6.51864037e-02f, -6.57170340e-02f, 1.81735735e-02f, -1.29830748e-01f, -8.04043636e-02f, -2.57957424e-03f,
  -7.14538037e-04f, 1.23692560e-03f, 2.39476133e-02f, 6.15931340e-02f, -4.64956835e-02f, -6.90403581e-02f, -6.88962191e-02f, 1.92052983e-02f, -4.83488850e-02f, 2.28136573e-02f,
  8.54195002e-03f, -5.83923869e-02f, 9.27147549e-03f, 6.31699860e-02f, 2.04684492e-02f, -3.87235172e-02f, -5.41495625e-03f, -4.20683209e-04f, -4.42627110e-02f, -4.54904959e-02f,
  2.61944700e-02f, -4.25225683e-02f, 5.64520396e-02f, -4.64270338e-02f, -2.05910858e-02f, 7.66005069e-02f, 5.03980219e-02f, -3.02238241e-02f, 5.61021417e-02f, 6.16757870e-02f,
  -2.44494225e-03f, -3.59264985e-02f, -1.25446776e-02f, -2.13653203e-02f, 5.58414645e-02f, 2.68805400e-02f, -6.29980713e-02f, 8.59296396e-02f, 7.59002985e-03f, 1.75933968e-02f,
  -5.22632971e-02f, 1.07319951e-02f, -5.95492087e-02f, -3.98287401e-02f, -8.23715702e-02f, 3.82034704e-02f, -6.00614026e-03f, 4.28262400e-03f, -3.67034636e-02f, 1.45576540e-02f,
  -3.16918828e-02f, 7.01662675e-02f, -3.81386951e-02f, -1.67097859e-02f, 6.23996966e-02f, -5.21637090e-02f, -1.20092700e-04f, 3.17243375e-02f, -6.35853410e-02f, -7.89796486e-02f,
  -3.95547226e-02f, 1.37146916e-02f, -3.71162854e-02f, -1.49498815e-02f, -1.88737251e-02f, 1.22927092e-01f, -6.37247935e-02f, -1.65279713e-02f, 6.21447600e-02f, -3.15288939e-02f,
  -2.24555153e-02f, -6.81274384e-02f, -4.11474146e-02f, -3.60917337e-02f, 6.58356259e-03f, -1.46410167e-02f, -9.43094492e-03f, 5.06966822e-02f, 4.90000919e-02f, 7.66448155e-02f,
  2.27046967e-01f, -3.59439731e-01f, -1.97357655e-01f, 1.79378819e-02f, 3.11731428e-01f, 2.41236761e-01f, 2.69244481e-02f, 1.07660539e-01f, -6.86854571e-02f, -1.76815599e-01f,
  9.77983847e-02f, -2.56689370e-01f, -2.15500265e-01f, 2.82527283e-02f, 4.77213450e-02f, -1.12176567e-01f, 8.81358143e-03f, -2.87199412e-02f, -2.59780809e-02f, -5.12646977e-03f,
  1.02889828e-01f, 2.06324011e-01f, -6.24986105e-02f, -6.80409651e-03f, 1.75370760e-02f, -1.25676736e-01f, 2.99732573e-02f, -3.19205970e-02f, 3.75484349e-03f, 9.22361910e-02f,
  -8.79354496e-03f, -8.29219669e-02f, -8.19916502e-02f, -5.56306355e-02f, 2.07237843e-02f, 4.10830006e-02f, -3.34824622e-02f, -8.14965591e-02f, 3.20373848e-02f, -1.00757582e-02f,
  -9.73234177e-02f, -4.38386165e-02f, 5.35814129e-02f, -1.42771685e-02f, 7.52831548e-02f, -6.29834877e-03f, 3.74600738e-02f, 8.73040501e-03f, 3.71612497e-02f, -2.51989532e-03f,
  3.28066535e-02f, -5.51065281e-02f, 4.72764634e-02f, -8.64871144e-02f, -1.67022608e-02f, -2.79516615e-02f, -2.50360444e-02f, -7.12221935e-02f, 4.92877215e-02f, 3.00222472e-03f,
  -5.68267629e-02f, -3.84294912e-02f, -6.48721028e-03f, -3.51388305e-02f, 6.06043898e-02f, 9.03728046e-03f, 5.81234433e-02f, 1.97003968e-02f, 7.90174678e-03f, 3.52721848e-02f,
  3.94043773e-02f, 1.32316034e-02f, 7.98445866e-02f, 5.55240922e-02f, -6.13942519e-02f, 2.11357400e-02f, -1.34676946e-02f, -6.93905503e-02f, -4.92676757e-02f, 4.45388593e-02f,
  -4.61597741e-03f, 5.25512770e-02f, 1.76798534e-02f, 3.03924643e-02f, -5.45246005e-02f, -1.90589558e-02f, 3.97277623e-02f, -3.38037275e-02f, 4.73468415e-02f, 7.45129259e-03f,
  9.43501890e-02f, -1.51042134e-01f, -7.08380044e-02f, -2.33015642e-02f, -3.20097432e-02f, -1.59889255e-02f, 2.59674597e-03f, 4.84173261e-02f, -8.16693180e-04f, 6.84410334e-02f,
  1.16063962e-02f, 4.53641377e-02f, 3.94756086e-02f, 3.67013812e-02f, -1.45395966e-02f, -4.21384312e-02f, -5.55092283e-02f, -1.49058169e-02f, 1.43696573e-02f, 3.31660397e-02f,
  5.53580932e-02f, 6.35803342e-02f, -1.64597072e-02f, 1.08202331e-01f, 1.05836103e-02f, 8.55069049e-03f, -3.95544879e-02f, -4.77975905e-02f, 1.25797512e-02f, -5.62624820e-02f,
  3.06422651e-01f, 8.55379775e-02f, -4.68869833e-03f, 1.00598983e-01f, 1.27144411e-01f, 3.87509577e-02f, -5.49838729e-02f, 5.88101968e-02f, 7.61882812e-02f, -1.02584727e-01f,
  -4.24386971e-02f, 6.83323070e-02f, -2.02056527e-01f, 1.55756343e-03f, 5.98452650e-02f, -1.27225205e-01f, 9.58984122e-02f, 3.05321515e-02f, 1.53805036e-02f, 5.29740192e-02f,
  7.64699727e-02f, -4.65937257e-02f, -6.97970614e-02f, -5.30392230e-02f, 1.16216473e-01f, 6.52773082e-02f, -9.54552069e-02f, -9.71655175e-02f, -6.41247183e-02f, 3.69746611e-02f,
  1.40905336e-01f, 1.77460890e-02f, -7.32510956e-03f, -6.05551265e-02f, 6.26757508e-03f, -1.14449784e-02f, -3.35568152e-02f, -9.73646045e-02f, 8.13988782e-03f, -2.81967199e-03f,
  -2.41480558e-03f, 3.10210604e-02f, 2.45920569e-02f, 5.30972071e-02f, 8.99176002e-02f, -2.92537287e-02f, -3.33258696e-02f, 4.03379835e-02f, 9.08174831e-03f, 3.63053903e-02f,
  -9.51847509e-02f, 2.04095859e-02f, 9.26869921e-03f, 5.70318848e-02f, -3.25928107e-02f, -3.38128544e-02f, -1.87202953e-02f, -1.33458590e-02f, 6.55373558e-02f, 3.61612961e-02f,
  -1.03120558e-01f, -3.78486747e-03f, -5.54626957e-02f, 3.81115079e-02f, -1.58980079e-02f, 4.34901565e-02f, -8.77872854e-03f, -6.83929818e-03f, 6.39800802e-02f, -1.10557480e-02f,
  3.29700559e-02f, 4.91640419e-02f, -5.24167195e-02f, -3.59021244e-03f, 1.13407210e-01f, -1.38584785e-02f, -3.91198322e-02f, 6.56347051e-02f, 4.61445004e-03f, -2.97802743e-02f,
  2.46906970e-02f, 5.43922782e-02f, -2.00811541e-03f, -2.80477870e-02f, 1.16191916e-02f, -5.84334247e-02f, 2.80408841e-02f, 2.90350318e-02f, -3.59803028e-02f, 2.62186769e-03f,
  2.15444878e-01f, 2.35679254e-01f, 2.26352680e-02f, 8.05804133e-02f, -2.97493897e-02f, 7.12983729e-03f, -3.60306492e-03f, -3.93821709e-02f, -4.12108889e-03f, 1.29284970e-02f,
  -3.98168527e-02f, 6.95627406e-02f, 2.71203369e-02f, 1.19366786e-02f, 7.79356584e-02f, 1.00774623e-01f, -3.06708850e-02f, 1.59953516e-02f, -1.66753083e-02f, -9.96379554e-03f,
  -3.61061543e-02f, -6.54051034e-03f, -4.88056093e-02f, -3.60532477e-02f, -4.18895148e-02f, 2.73320600e-02f, 8.68412256e-02f, 2.18610056e-02f, 1.05290441e-02f, 2.45911758e-02f,
  -3.22374046e-01f, 5.67599535e-02f, -1.28938302e-01f, -4.84293103e-02f, 1.61374081e-02f, -1.16982110e-01f, -4.89464849e-02f, -9.36211902e-04f, -9.54348147e-02f, 2.21413881e-01f,
  1.61202297e-01f, -1.53824002e-01f, -1.24542629e-02f, 1.52035326e-01f, -1.84393495e-01f, 1.08895861e-01f, 8.62910971e-02f, -2.50793025e-02f, 3.13877277e-02f, 2.58792434e-02f,
  1.74345803e-02f, 6.56419173e-02f, -3.66821932e-03f, 1.46653771e-01f, 4.33047675e-02f, 4.35469560e-02f, 3.16733345e-02f, -1.30816489e-01f, 9.64476690e-02f, 1.13653101e-03f,
  -7.03413319e-03f, 7.67512098e-02f, -2.29152571e-02f, 8.52439255e-02f, -2.17205975e-02f, -5.26669659e-02f, -1.08092069e-03f, -5.88764288e-02f, 2.86999457e-02f, 3.57502811e-02f,
  -9.31365695e-03f, 6.85873791e-04f, 6.42423145e-03f, 2.71357559e-02f, 1.00251865e-02f, 4.00877297e-02f, -8.99796095e-03f, -4.73760553e-02f, 4.25430760e-02f, 2.15702876e-02f,
  -2.04376876e-02f, 4.58529554e-02f, -3.67765240e-02f, 1.05401091e-01f, 5.76019771e-02f, -1.70384441e-02f, 7.20698610e-02f, -7.50091746e-02f, 6.05263934e-02f, -4.96123172e-02f,
  -3.88734154e-02f, -1.80628765e-02f, -3.07627879e-02f, 8.45212117e-02f, -4.23385538e-02f, -1.83574092e-02f, -2.44440362e-02f, -3.33631085e-03f, -7.39048347e-02f, 3.11091151e-02f,
  1.48826158e-02f, -6.90663531e-02f, -4.10698205e-02f, 1.18096128e-01f, 3.75310034e-02f, 8.90267491e-02f, 2.71601486e-03f, 5.19578755e-02f, -3.13225272e-03f, -3.33985388e-02f,
  3.04075032e-02f, -1.71291716e-02f, 7.06624165e-02f, -1.98488720e-02f, -1.17625697e-02f, 6.70522917e-03f, 3.80327068e-02f, 3.10358200e-02f, -7.82860518e-02f, -8.43624771e-02f,
  4.39487249e-02f, 7.23124892e-02f, 9.70681086e-02f, 4.67840843e-02f, 8.59295204e-03f, -2.29726937e-02f, -1.07201366e-02f, 9.60482731e-02f, -1.29116634e-02f, -3.21019581e-03f,
  -4.50022407e-02f, 1.95808783e-02f, -7.31212273e-02f, -1.71752591e-02f, 4.11758758e-02f, 2.99892686e-02f, 4.57395427e-02f, 7.57698268e-02f, -5.77756986e-02f, 3.77560072e-02f,
  1.03923336e-01f, 1.74262803e-02f, -2.22247234e-03f, 1.23697333e-02f, 6.79270774e-02f, 6.20320924e-02f, -7.67543614e-02f, 3.95867266e-02f, -1.07496809e-02f, 1.00720255e-02f,
  8.72017667e-02f, -4.57887575e-02f, 4.91724461e-02f, -1.10904984e-01f, 1.38887405e-01f, -2.57211357e-01f, -2.68180549e-01f, -5.44158295e-02f, 3.17682438e-02f, -1.27749249e-01f,
  -7.95275271e-02f, 1.38580464e-02f, -8.22790042e-02f, -2.02110529e-01f, -2.94627041e-01f, -1.71386629e-01f, -2.07676426e-01f, 1.49099417e-02f, -1.03389565e-02f, 4.12283503e-02f,
  -4.18444537e-02f, -8.84337574e-02f, -2.27320001e-01f, -1.50745194e-02f, -7.48652369e-02f, 1.14050306e-01f, -9.27702244e-03f, -2.29938347e-02f, -9.49488878e-02f, -1.10514984e-01f,
  -1.06133848e-01f, 1.23679720e-01f, 9.96023566e-02f, -1.41911325e-03f, -8.54363590e-02f, 5.63049987e-02f, 7.20961094e-02f, -1.37685081e-02f, 6.16465434e-02f, -9.20464247e-02f,
  1.81980487e-02f, -9.33283046e-02f, -2.61864178e-02f, 4.03466411e-02f, 2.35101264e-02f, 2.04138272e-02f, -2.25471705e-02f, -3.55355106e-02f, 6.36382252e-02f, 4.24287356e-02f,
  3.84651311e-03f, -8.09280798e-02f, 4.09110077e-02f, -2.21963692e-02f, 1.30180242e-02f, 4.54964451e-02f, -3.48230079e-02f, -6.69003651e-02f, 2.18834952e-02f, 4.03587073e-02f,
  -1.97540093e-02f, -1.23280190e-01f, 5.29192463e-02f, -2.65768133e-02f, -4.64936309e-02f, -9.62860882e-03f, -3.73360924e-02f, -1.55060031e-02f, 1.06167160e-02f, -6.23361692e-02f,
  -3.14544961e-02f, 8.31403360e-02f, 4.00205851e-02f, 8.96945223e-02f, 1.34265097e-02f, 1.81115475e-02f, 6.43291995e-02f, -1.47434510e-02f, 3.15111801e-02f, 1.64967626e-02f,
  2.48809904e-02f, -6.88760355e-02f, -5.51679209e-02f, -3.59584624e-03f, -1.11322202e-01f, -3.26946713e-02f, -3.22127081e-02f, -6.13030745e-03f, -8.62171222e-03f, -1.03753760e-01f,
  -4.69091833e-02f, 4.71955445e-03f, 1.27518596e-02f, -8.64128303e-03f, -8.29134788e-03f, -7.12623075e-02f, -5.99497855e-02f, -5.32931536e-02f, -9.91721526e-02f, 3.79858017e-02f,
  -6.37671351e-02f, 3.46447155e-02f, -6.59715608e-02f, -9.19432193e-02f, 6.52016606e-03f, 5.42503335e-02f, -1.75411105e-02f, 1.70251336e-02f, -4.24792729e-02f, -4.79574734e-03f,
  -1.50275696e-02f, 4.20134217e-02f, 1.21501246e-02f, -6.34132996e-02f, 6.01912197e-03f, 6.96976902e-03f, 1.97879430e-02f, -4.10524756e-03f, -8.09352770e-02f, -9.05570611e-02f,
  -2.86183685e-01f, 2.68442094e-01f, 3.92141901e-02f, -3.95348333e-02f, -1.80873051e-02f, -6.71270043e-02f, -1.26983508e-01f, 1.44422188e-01f, 1.35146528e-02f, 1.48851126e-01f,
  -7.82684088e-02f, 3.63033377e-02f, 2.77727656e-02f, 2.36922577e-02f, -1.03649989e-01f, -1.14148028e-01f, 4.11142521e-02f, -2.05514263e-02f, 4.42676768e-02f, 1.16120778e-01f,
  -2.46812161e-02f, -7.22820908e-02f, 3.26638781e-02f, 5.48844635e-02f, -5.81089929e-02f, 1.93719342e-02f, -9.13634598e-02f, 4.74013165e-02f, 1.15945950e-01f, -8.60919058e-02f,
  -6.79668188e-02f, 1.12116493e-01f, -4.68604863e-02f, -2.27027647e-02f, 7.81719610e-02f, 1.21431351e-02f, 7.01985881e-02f, -5.19839264e-02f, -1.53556513e-02f, -7.75508722e-03f,
  -2.01418847e-02f, 4.88659330e-02f, -3.22153568e-02f, -7.54995365e-03f, 1.26306657e-02f, 5.80869652e-02f, 1.93208978e-02f, 5.39908856e-02f, 1.19973443e-01f, -8.28263350e-03f,
  1.28588518e-02f, -5.65884188e-02f, 1.40163759e-02f, -3.87699828e-02f, 3.15046683e-02f, -1.66889466e-02f, 4.40668911e-02f, -3.14262416e-03f, -8.58697146e-02f, 4.41830866e-02f,
  -7.12157413e-02f, -8.73292461e-02f, -1.14095211e-02f, -3.96950208e-02f, 2.14783382e-02f, -5.28042950e-02f, -3.50729376e-02f, 5.94684435e-03f, 6.56861141e-02f, -4.08835113e-02f,
  4.39513773e-02f, 3.72709967e-02f, 7.79765367e-04f, 5.95911406e-03f, -6.31359071e-02f, -3.31574380e-02f, -2.20369436e-02f, -3.01036648e-02f, 3.45722586e-03f, -2.95044817e-02f,
  -1.50669385e-02f, -5.69485826e-03f, 6.86814934e-02f, -4.18218002e-02f, -2.24550167e-05f, -3.99274789e-02f, -7.81388581e-03f, 2.69559193e-02f, -3.61926705e-02f, -4.87717204e-02f,
  8.28491375e-02f, 1.24493957e-01f, 3.14027183e-02f, 3.84405814e-02f, 6.64374456e-02f, -1.99030768e-02f, 1.13703562e-02f, 5.24687953e-02f, 7.00907484e-02f, 6.42072037e-02f,
  -3.93767655e-02f, -1.69924293e-02f, 6.31363764e-02f, 4.86703217e-02f, -1.59072541e-02f, 4.96067517e-02f, -6.96465522e-02f, -5.89520223e-02f, -1.72741450e-02f, 7.89003298e-02f,
  -4.85120639e-02f, 3.32528241e-02f, -7.89936334e-02f, 1.37240533e-02f, 6.01179153e-02f, 2.21182220e-02f, -1.13300169e-02f, 4.62718345e-02f, -2.43542977e-02f, -2.88634896e-02f,
  1.65918946e-01f, 4.80253585e-02f, -1.20605072e-02f, 1.10639036e-01f, -1.34670705e-01f, -1.75541744e-01f, -1.11951694e-01f, -9.62364953e-03f, 5.52527755e-02f, 1.69198792e-02f,
  4.65045981e-02f, 5.27818985e-02f, -1.38351575e-01f, 2.44155347e-01f, 5.20085543e-02f, 2.86555178e-02f, 2.30272904e-01f, 1.00345716e-01f, -9.39445198e-03f, 1.77771300e-02f,
  9.81138796e-02f, 2.79711653e-02f, 8.25446006e-03f, 1.03730876e-02f, -8.33952576e-02f, 1.80977751e-02f, 9.61157959e-03f, -1.86174944e-01f, 7.57516921e-02f, 1.40177878e-02f,
  3.66365165e-02f, 4.76775505e-02f, -1.98489334e-02f, 8.84147547e-03f, 4.16620001e-02f, 6.25463873e-02f, -3.26480642e-02f, -7.52349943e-02f, -7.05199540e-02f, -5.69523908e-02f,
  3.83883864e-02f, 7.53941759e-02f, 1.93025246e-02f, -4.61824536e-02f, -4.51448932e-02f, 5.96848354e-02f, -3.16563323e-02f, 6.33305833e-02f, -4.21769097e-02f, 8.24774727e-02f,
  -5.00308797e-02f, -8.68178718e-03f, 3.96427028e-02f, -3.15116718e-02f, 6.63157478e-02f, 5.10629117e-02f, -2.87691783e-02f, 4.75269854e-02f, -2.82457527e-02f, 1.89245364e-03f,
  2.70035788e-02f, 3.22291330e-02f, -2.86715701e-02f, -1.56560279e-02f, 8.77218228e-03f, -1.77168450e-03f, -3.47635671e-02f, 3.81135792e-02f, 1.69689246e-02f, 4.03492106e-03f,
  -8.99008755e-03f, 6.62601963e-02f, 1.06121711e-01f, 6.27813637e-02f, 7.88163990e-02f, -2.74317991e-02f, -9.57395695e-03f, 6.12131692e-03f, 4.55544852e-02f, 5.91060631e-02f,
  -3.05247083e-02f, 6.44340813e-02f, -7.01465756e-02f, 3.89927141e-02f, 1.56881213e-02f, -8.58081952e-02f, 7.62408301e-02f, 7.52272755e-02f, -3.87533493e-02f, 1.01039978e-03f,
  -3.86122279e-02f, 3.41176428e-02f, -3.91737446e-02f, -3.24770920e-02f, -7.23055899e-02f, -5.70716634e-02f, -4.71178666e-02f, -5.74962795e-03f, -1.49128046e-02f, -1.13774436e-02f,
  9.76963192e-02f, -1.20486068e-02f, 8.64412412e-02f, 2.50599124e-02f, -4.55848314e-02f, -7.67883137e-02f, -1.31564476e-02f, 4.55095619e-02f, 6.82414025e-02f, 1.73217561e-02f,
  5.41963440e-04f, -8.63627642e-02f, 1.74452215e-02f, -9.79221910e-02f, -6.01957850e-02f, 3.81215140e-02f, -3.12978365e-02f, -9.88620818e-02f, 6.36788458e-02f, 7.57058710e-02f,
  6.39218884e-03f, 1.98851600e-01f, 1.35091260e-01f, -1.52727529e-01f, 4.66009863e-02f, 2.66148955e-01f, 2.16377318e-01f, -6.69039041e-02f, 7.23729581e-02f, -1.30861709e-02f,
  -2.37974524e-01f, 1.46175593e-01f, -1.36515526e-02f, -1.99710324e-01f, -1.36525750e-01f, -6.49489090e-02f, -1.47474036e-01f, -3.33161838e-02f, 4.36476916e-02f, -9.74085853e-02f,
  -1.09850727e-01f, -2.26906925e-01f, 1.87544767e-02f, -1.04227193e-01f, 1.58024266e-01f, -1.46074053e-02f, -2.43078709e-01f, 8.58945772e-02f, -8.08036849e-02f, 5.62452152e-02f,
  -3.09546143e-02f, -6.60176277e-02f, 1.20810218e-01f, 4.20596916e-03f, 1.65523738e-02f, 1.02995954e-01f, 1.22679800e-01f, 2.06203219e-02f, -6.92602023e-02f, -2.53143744e-03f,
  5.85557744e-02f, 5.03412355e-03f, -1.56988390e-02f, -9.12410468e-02f, 1.16680115e-01f, -4.02563922e-02f, -2.74578724e-02f, 1.27595915e-02f, 5.55261374e-02f, 2.69089900e-02f,
  3.00868265e-02f, 3.04925274e-02f, 5.85206002e-02f, -1.01982765e-02f, -4.23827469e-02f, -3.81983444e-02f, 3.97184603e-02f, -4.01066951e-02f, -5.08048898e-03f, 1.30638167e-01f,
  2.36838348e-02f, -2.59789303e-02f, 2.94217654e-02f, -8.80755633e-02f, -1.36185326e-02f, 3.88579927e-02f, 7.27915019e-02f, -1.04353033e-01f, 7.18159005e-02f, -2.83113923e-02f,
  2.73773130e-02f, 5.71534783e-03f, 1.20805029e-03f, 6.57682726e-03f, 1.07956575e-02f, 8.13412592e-02f, -2.45926995e-02f, -5.25443554e-02f, 1.22383162e-02f, -8.67351517e-02f,
  7.40557089e-02f, 5.10981306e-02f, 5.22145852e-02f, -8.18693603e-04f, 7.16518145e-04f, -1.07184932e-01f, -2.33572186e-03f, 7.71193728e-02f, 4.21481915e-02f, 6.32738322e-02f,
  -9.15464200e-03f, -1.10852934e-01f, -5.06117269e-02f, -1.34681901e-02f, -2.97111534e-02f, 8.22466053e-03f, 1.59229692e-02f, -5.96307665e-02f, 3.17908898e-02f, 5.41162677e-02f,
  -7.68284053e-02f, -7.59964138e-02f, 1.11584246e-01f, 3.42892781e-02f, -2.39631794e-02f, -5.95337385e-03f, 2.45240168e-03f, -1.40111633e-02f, 2.35621780e-02f, -3.81800346e-02f,
  6.17381232e-03f, 5.25532141e-02f, -1.87768526e-02f, -3.75890061e-02f, -1.35050967e-01f, 7.04664141e-02f, 4.72921841e-02f, 6.03840798e-02f, 4.74441350e-02f, -3.20964083e-02f,
  1.90419748e-01f, -1.17007583e-01f, 3.66294831e-01f, -2.10239679e-01f, 1.99249700e-01f, 1.93346530e-01f, 1.54220685e-02f, 1.01215495e-02f, -3.15659046e-02f, -1.88128486e-01f,
  -1.07343674e-01f, 1.38528883e-01f, 1.81480497e-02f, -2.94967920e-01f, 9.53796282e-02f, -1.32031646e-02f, -1.16830371e-01f, -1.10117614e-01f, 3.05188727e-02f, 6.98983297e-02f,
  5.91300316e-02f, -1.66864812e-01f, 7.32374415e-02f, -5.04797958e-02f, 1.03889599e-01f, 9.43146721e-02f, -2.19695598e-01f, 1.30054981e-01f, -1.30433545e-01f, -3.62996780e-03f,
  -9.04525518e-02f, -1.05247699e-01f, -2.74106557e-03f, 3.93871628e-02f, 7.39284009e-02f, -6.32903948e-02f, -5.55103384e-02f, 3.78404409e-02f, -1.84713807e-02f, 2.91179102e-02f,
  1.00261951e-02f, 3.45664397e-02f, -7.66715705e-02f, 6.38915272e-03f, -6.12978972e-02f, 7.47142434e-02f, 7.33262226e-02f, -1.77200548e-02f, 6.27089143e-02f, 1.06370769e-01f,
  1.00211918e-01f, -4.85519096e-02f, -1.46316073e-03f, -8.67331401e-02f, 5.01785837e-02f, -4.05653752e-02f, 2.94374917e-02f, 3.79395969e-02f, -1.89778972e-02f, -2.81239897e-02f,
  -3.64366286e-02f, 3.84198949e-02f, -5.08439494e-03f, 2.26054341e-03f, -2.96449065e-02f, -1.48005784e-02f, -4.10618111e-02f, 2.47863270e-02f, 8.82851928e-02f, -4.30013202e-02f,
  -1.77694745e-02f, -6.69618994e-02f, -6.35569990e-02f, 3.49892415e-02f, 5.82433157e-02f, -1.06679060e-01f, 4.14719153e-03f, 1.27638201e-03f, 1.07694566e-02f, -3.45072746e-02f,
  -7.49272779e-02f, -4.63891169e-03f, 9.94894803e-02f, -2.08454710e-02f, -2.94304471e-02f, 6.49844855e-02f, 1.99047080e-03f, -5.14512658e-02f, -1.79542303e-02f, 3.89939919e-02f,
  -1.57113411e-02f, -1.20579883e-01f, 4.32261676e-02f, -1.29995001e-02f, -5.62046207e-02f, -8.27490911e-03f, -3.66487727e-02f, 6.08539283e-02f, 4.72295433e-02f, -1.95929110e-02f,
  -3.52119543e-02f, -2.45652231e-03f, 5.60223795e-02f, 3.75810862e-02f, 7.19985664e-02f, -7.05832690e-02f, -3.82207036e-02f, 3.64940800e-02f, 4.55925008e-03f, -3.31079774e-02f,
  5.65872602e-02f, 2.11451780e-02f, 5.61019070e-02f, 5.55134052e-03f, 6.81615099e-02f, -2.18416639e-02f, -1.70394648e-02f, 2.66574156e-02f, 1.02106959e-01f, 5.38513996e-02f,
  3.55309516e-01f, -1.40686393e-01f, 1.87335059e-01f, 3.09356123e-01f, -1.10742878e-02f, -2.68933207e-01f, 7.78193921e-02f, -6.19380884e-02f, -1.38710454e-01f, -2.00443402e-01f,
  2.32269000e-02f, 1.83826163e-01f, 8.73525590e-02f, 3.15557383e-02f, 1.34198651e-01f, -1.48009464e-01f, 8.09291005e-03f, -2.90421192e-02f, 4.94542234e-02f, -4.86194268e-02f,
  4.03428525e-02f, -1.69587985e-01f, 2.52274603e-01f, -1.57477081e-01f, 8.01096484e-02f, 5.97073846e-02f, 8.78765583e-02f, -3.67643172e-03f, 6.10491224e-02f, -3.25278193e-02f,
  -3.93815748e-02f, -1.49923656e-03f, 8.79824683e-02f, -2.53751618e-03f, -8.02752003e-03f, 9.83063038e-03f, 1.41466164e-03f, 6.93420470e-02f, -1.27874808e-02f, 3.40493508e-02f,
  -6.91325730e-03f, -2.08215751e-02f, -1.20760221e-02f, -7.05969706e-02f, -1.03053145e-01f, 5.06099425e-02f, 5.15023433e-02f, -2.07468588e-02f, 7.64813274e-02f, 5.24813421e-02f,
  3.15815546e-02f, 1.39133269e-02f, -4.49768119e-02f, -3.26181054e-02f, 8.41431245e-02f, 5.29790930e-02f, 4.91888486e-02f, 8.77876356e-02f, -2.18976103e-02f, -4.27610837e-02f,
  -7.00099692e-02f, 2.19293460e-02f, -4.96154204e-02f, -1.11809734e-03f, -5.00470772e-02f, 8.78238492e-03f, -6.70844391e-02f, -3.69952666e-03f, -6.70244247e-02f, 3.96457762e-02f,
  5.38434535e-02f, -7.23573437e-04f, -4.80115833e-03f, -3.14895399e-02f, -3.61862220e-02f, 6.32095262e-02f, 3.51757370e-02f, 1.99280456e-02f, 1.89649276e-02f, 6.74031824e-02f,
  7.39987642e-02f, -6.15556687e-02f, 2.59522349e-02f, 2.48408373e-02f, -3.27150002e-02f, 3.43824960e-02f, -1.67476594e-01f, 3.82169522e-02f, 1.78777985e-03f, -8.15528259e-03f,
  -2.72488087e-01f, -1.93787768e-01f, 1.95308961e-02f, -3.83461751e-02f, 4.03098948e-02f, -5.63586652e-02f, -1.75298937e-02f, -4.43956219e-02f, -4.53686714e-02f, -1.55206602e-02f,
  -1.84841957e-02f, 1.77602246e-02f, -1.32713884e-01f, 7.50304013e-02f, -2.08916725e-03f, -9.83062461e-02f, -5.12423925e-02f, 5.82115985e-02f, 1.75460312e-03f, -5.01897968e-02f,
  -3.73775773e-02f, 1.07989326e-04f, -2.25454587e-02f, -3.18392552e-02f, -9.32980850e-02f, 2.35179495e-02f, -7.87847713e-02f, 3.09463162e-02f, -6.99196830e-02f, -1.90742183e-04f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.00087845e-01f, -1.79133892e-01f, -4.54773903e-02f, 2.13172406e-01f, 8.94801989e-02f, -4.13548462e-02f, 2.29406822e-02f, 5.76791354e-02f, 6.26513511e-02f, -3.43176611e-02f,
  5.34277260e-02f, -9.34021026e-02f, -8.33501369e-02f, 1.57749742e-01f, 5.15916720e-02f, -1.47289500e-01f, 5.59936054e-02f, 6.07045405e-02f, -3.05361822e-02f, -1.97663084e-02f,
  1.16848923e-01f, 1.89365685e-01f, 1.19264491e-01f, 8.81411135e-02f, 1.01816319e-02f, 1.25890747e-01f, 1.41095579e-01f, 8.16044435e-02f, 1.94642156e-01f, -2.12170761e-02f,
  -1.69975366e-02f, -7.71387294e-02f, 3.42929177e-02f, -3.03732418e-02f, 2.15909677e-03f, -4.35387231e-02f, 2.28756815e-02f, 4.57030088e-02f, 4.85024415e-02f, -2.89104264e-02f,
  4.60055135e-02f, 9.59432218e-03f, 1.01043575e-01f, 4.62449417e-02f, -3.74953002e-02f, 7.30740502e-02f, 9.60955992e-02f, -2.33853180e-02f, 4.16795835e-02f, -1.30907133e-01f,
  2.28256509e-02f, 2.04562768e-02f, 4.39792275e-02f, -3.16412263e-02f, -5.84921092e-02f, -7.38394335e-02f, -2.70752283e-03f, 1.74499545e-02f, 8.40536281e-02f, -8.90032724e-02f,
  -4.75529283e-02f, -9.55563188e-02f, -3.55213098e-02f, -2.47417316e-02f, 6.52878731e-02f, 7.45223835e-02f, -8.23513791e-02f, 5.86353168e-02f, -8.35885182e-02f, -3.82492915e-02f,
  5.98959811e-02f, 4.01822887e-02f, 3.57416347e-02f, -8.47554505e-02f, 2.65172776e-03f, 3.07704266e-02f, 3.50004733e-02f, 4.91901883e-04f, 9.97477304e-03f, 1.32565135e-02f,
  -1.18457982e-02f, -2.75529642e-03f, 8.56432840e-02f, -3.08667757e-02f, 7.73307830e-02f, 1.81472376e-02f, 1.30105823e-01f, 4.96664923e-03f, -5.04577048e-02f, -9.45974514e-03f,
  -3.18998955e-02f, -5.80131598e-02f, 3.05697694e-02f, -2.21903399e-02f, -6.40637875e-02f, 6.19727597e-02f, -4.66520973e-02f, -3.22706508e-03f, -6.11467436e-02f, -4.68609342e-03f,
  -2.83269193e-02f, 6.61028400e-02f, -2.83491593e-02f, 9.17982608e-02f, -6.33541942e-02f, 6.70894757e-02f, -1.23521651e-03f, -1.02934487e-01f, 1.62176073e-01f, 9.65364650e-02f,
  -3.32368575e-02f, 3.42834718e-03f, 3.34629864e-02f, 2.28091776e-02f, 1.17630012e-01f, -5.98762557e-02f, 1.24767408e-01f, -8.43625441e-02f, 2.84554902e-02f, 9.84842610e-03f,
  -6.07713833e-02f, 3.60030048e-02f, -1.37186795e-01f, -3.30755189e-02f, -2.65065785e-02f, -8.44199881e-02f, -9.84672233e-02f, -1.91620924e-02f, -3.45853455e-02f, 1.41131908e-01f,
  -3.08799315e-02f, 1.45722389e-01f, -1.95518598e-01f, -1.69411138e-01f, -3.93055528e-01f, -2.95946181e-01f, -1.36532083e-01f, -1.61865316e-02f, -1.15576990e-01f, 2.83378419e-02f,
  -4.85432297e-02f, -2.67021596e-01f, -1.99843168e-01f, -6.53329417e-02f, 1.48802117e-01f, 2.32108727e-01f, 9.46040750e-02f, -4.91159298e-02f, 1.18177608e-01f, -8.40856135e-02f,
  1.09154098e-01f, -3.06345094e-02f, 7.97695965e-02f, 4.54252731e-04f, 8.19615722e-02f, 2.21380275e-02f, 8.95801652e-03f, -3.64858545e-02f, 5.31968996e-02f, -1.37218209e-02f,
  1.27443209e-01f, 5.05422093e-02f, -5.43671288e-02f, -3.34561355e-02f, 1.87665466e-02f, 9.38364305e-03f, -1.31217754e-02f, 5.51940016e-02f, -6.49861321e-02f, -7.59764016e-02f,
  -8.67170095e-02f, 6.35854974e-02f, 3.04838810e-02f, -2.07541371e-03f, -2.72074118e-02f, -1.60218927e-03f, 3.94297391e-02f, 1.35805216e-02f, 3.80513333e-02f, 7.08127022e-02f,
  -5.47409691e-02f, 2.35583149e-02f, -5.93266152e-02f, 1.89594682e-02f, -6.79108500e-03f, 1.56735443e-02f, -4.24065739e-02f, 3.23685259e-02f, -1.86225288e-02f, 6.96033612e-02f,
  -2.95988750e-02f, 7.90532455e-02f, -5.10760164e-03f, -3.57882604e-02f, 2.25223489e-02f, 2.40183640e-02f, 5.42820198e-03f, -1.68551691e-02f, -5.92767671e-02f, 4.67908457e-02f,
  4.53800745e-02f, -6.79937750e-02f, -2.97370143e-02f, 5.18704168e-02f, -3.81717779e-04f, -8.39766208e-03f, -2.14974396e-02f, 8.09045136e-02f, -5.41280061e-02f, -5.45424782e-03f,
  -4.30078879e-02f, -1.98089760e-02f, -7.37658143e-02f, 8.60763788e-02f, -3.42206322e-02f, 5.77526391e-02f, -5.81587926e-02f, -7.35784546e-02f, 6.36207033e-03f, -7.44067132e-02f,
  4.73063774e-02f, -1.25677083e-02f, 7.72471204e-02f, 7.89446682e-02f, -7.66866431e-02f, 4.23222296e-02f, 7.07623065e-02f, 9.08672288e-02f, 7.21316934e-02f, 9.42337736e-02f,
  1.32840782e-01f, 1.01146571e-01f, -1.43914167e-02f, 6.32906780e-02f, 2.18947362e-02f, 3.17406766e-02f, 8.25340897e-02f, -1.94569137e-02f, -1.44882379e-02f, 7.05053136e-02f,
  -3.52057293e-02f, 2.62027025e-01f, -7.46658072e-02f, 1.65973470e-01f, -2.09537774e-01f, 1.81836814e-01f, 1.90073386e-01f, -6.79898560e-02f, 1.05868705e-01f, 2.43492723e-01f,
  5.90450168e-02f, 3.04716323e-02f, 1.42185047e-01f, 2.28533730e-01f, 9.56651643e-02f, 2.03953460e-01f, 2.56751180e-01f, 2.43858725e-01f, -9.39465091e-02f, 1.68305770e-01f,
  -1.18215367e-01f, 2.32647106e-01f, -3.35342996e-02f, -5.59396446e-02f, -8.10886100e-02f, -9.87544283e-02f, -1.09280452e-01f, -1.56696409e-01f, -4.67496924e-02f, -1.09357148e-01f,
  1.38725564e-01f, -4.93150651e-02f, 1.46118691e-02f, 3.65869291e-02f, 4.74013016e-02f, -3.26489434e-02f, -6.80585206e-02f, -4.97681228e-03f, -1.11365005e-01f, -3.25059742e-02f,
  -1.43547542e-02f, -3.69923189e-02f, 1.06796116e-01f, -9.25516635e-02f, 2.90104356e-02f, -9.75290984e-02f, 9.41780116e-03f, -5.81091195e-02f, 5.92720648e-03f, -5.94272465e-02f,
  -6.98086172e-02f, 7.63732195e-02f, -5.37082739e-02f, -7.08741881e-03f, -7.88441375e-02f, 4.89659496e-02f, -4.26399224e-02f, -2.59960890e-02f, 3.24751884e-02f, -6.59453124e-02f,
  -2.39427984e-02f, 6.98328018e-02f, 6.76004216e-02f, 3.40062156e-02f, 6.61842199e-03f, -4.80581298e-02f, 4.23006266e-02f, -8.58591944e-02f, -1.23581598e-02f, -1.26138586e-03f,
  -6.30796794e-03f, 2.22471934e-02f, 3.98349836e-02f, 2.35452957e-04f, 5.46171749e-03f, -2.03814488e-02f, -4.58038859e-02f, 1.63881592e-02f, -1.34571455e-02f, 1.65698323e-02f,
  -2.91387402e-02f, 2.14578658e-02f, 1.73542500e-02f, 5.96376918e-02f, 4.09850851e-03f, 3.77691351e-04f, 4.71239798e-02f, -4.32471372e-02f, 1.31143676e-02f, -1.31850140e-02f,
  1.05582498e-01f, 2.41504163e-01f, -4.43010516e-02f, -5.41774668e-02f, 5.73382154e-02f, 9.15733874e-02f, 2.89061125e-02f, -4.65463549e-02f, 3.89666073e-02f, 7.91996941e-02f,
  3.83724757e-02f, -2.44934708e-02f, -4.11240570e-02f, -7.35111833e-02f, -4.44684736e-02f, 1.46919802e-01f, 5.16717769e-02f, -3.39481495e-02f, 2.00000014e-02f, -2.36477740e-02f,
  4.09933254e-02f, 3.78777646e-02f, 2.97110323e-02f, -2.65300889e-02f, -1.17727974e-02f, -2.63618138e-02f, 1.32956784e-02f, 3.36110815e-02f, -8.18990842e-02f, 6.57834634e-02f,
  1.54974476e-01f, -1.45898759e-01f, -1.87069014e-01f, 1.13265060e-01f, 4.42905799e-02f, 1.16471730e-01f, -1.66020021e-01f, 6.76541999e-02f, 1.00793771e-01f, -1.14936776e-01f,
  3.83460522e-02f, -7.59390742e-02f, -2.65623212e-01f, 1.93408281e-02f, -4.09687823e-03f, -1.83117107e-01f, 8.38769674e-02f, 9.28757563e-02f, -1.66539047e-02f, 5.07059209e-02f,
  1.07985837e-02f, 9.77132171e-02f, -9.91716236e-02f, 1.11907378e-01f, 6.17195331e-02f, -7.56732747e-03f, 1.69774797e-02f, -1.84651598e-01f, 1.46258354e-01f, 1.02875888e-01f,
  7.67903402e-02f, -7.19252303e-02f, -3.38051207e-02f, 7.68919811e-02f, -5.22067435e-02f, 1.00235574e-01f, 2.41677053e-02f, 5.41229621e-02f, 8.89168009e-02f, -4.51410189e-03f,
  -9.32499096e-02f, 2.83291545e-02f, 9.56473425e-02f, -3.26337703e-02f, 3.29303811e-03f, 8.24158639e-02f, 4.64903228e-02f, 1.83402281e-02f, -6.66630566e-02f, 1.00944210e-02f,
  -1.34054750e-01f, 7.35835508e-02f, 1.07055970e-01f, 4.28050272e-02f, -1.13505153e-02f, -7.48961195e-02f, -4.01951484e-02f, -1.40880808e-01f, 1.63119305e-02f, -2.68653519e-02f,
  2.97637340e-02f, -1.02976866e-01f, 1.29946498e-02f, 8.01520348e-02f, 1.45710995e-02f, -1.55510660e-02f, 7.33858868e-02f, -1.11133782e-02f, -2.14788374e-02f, 6.43248335e-02f,
  -1.65800340e-02f, -3.87569424e-03f, 9.90327746e-02f, 3.77481058e-02f, -5.23191877e-02f, 8.68788268e-03f, 1.33972848e-03f, 4.84529510e-02f, -6.04819655e-02f, -1.65637042e-02f,
  -3.65366824e-02f, 3.34764495e-02f, 5.78106977e-02f, -3.64049226e-02f, 6.81079626e-02f, -5.20769879e-03f, -1.21466536e-02f, 3.98350358e-02f, -1.11606397e-01f, 1.00694045e-01f,
  -4.78299484e-02f, -2.12380916e-01f, -6.68151528e-02f, 5.66586554e-02f, -6.71377555e-02f, 1.87514797e-02f, -3.44295357e-03f, 5.96438535e-02f, -1.39527386e-02f, 6.91182688e-02f,
  -2.74825515e-03f, 1.30356206e-02f, 6.40042275e-02f, 1.63000703e-01f, -2.90499721e-02f, 9.79495198e-02f, -7.34018311e-02f, 4.47935192e-03f, 1.57736801e-02f, -6.84002740e-03f,
  1.51128136e-03f, -3.77685279e-02f, 9.95943025e-02f, -7.11401030e-02f, -5.39647937e-02f, -5.67022413e-02f, 1.35153802e-02f, -8.67970660e-03f, 1.24253489e-01f, -3.96031737e-02f,
  -2.99512465e-02f, -1.87757257e-02f, -1.04196370e-01f, -2.12365150e-01f, 9.00479779e-03f, -2.60038704e-01f, -2.04509392e-01f, 6.89319223e-02f, 1.63316131e-01f, 8.85901228e-02f,
  -1.25982696e-02f, 4.61333990e-02f, 3.56927654e-03f, -7.12305084e-02f, -1.07375033e-01f, -8.15518275e-02f, -3.05726707e-01f, -1.96543023e-01f, -1.98468789e-02f, -1.85230896e-01f,
  -9.04548168e-02f, -1.38401523e-01f, -1.48500517e-01f, -3.35088335e-02f, -1.16690576e-01f, 8.52962118e-03f, 2.29821764e-02f, 8.23446363e-02f, -9.71234590e-02f, -3.64408898e-03f,
  -1.60611987e-01f, -5.05791642e-02f, -2.87432671e-02f, 7.81346634e-02f, -1.20297857e-01f, -7.60603845e-02f, 8.38606153e-03f, 5.36976792e-02f, 5.02080992e-02f, 2.88462645e-04f,
  1.20002525e-02f, 2.68707573e-02f, -3.45769376e-02f, 5.38970307e-02f, -4.19691503e-02f, 5.75058497e-02f, 5.36452048e-02f, -7.08947405e-02f, 5.67660555e-02f, 5.95056117e-02f,
  -1.20545022e-01f, -4.33025043e-03f, 1.67855211e-02f, 4.95356284e-02f, -1.81186646e-02f, 2.52932534e-02f, -5.85240200e-02f, -4.65389621e-03f, -8.23241398e-02f, -4.86418568e-02f,
  1.60082486e-02f, 4.80552390e-03f, -3.54726873e-02f, 1.06284916e-01f, -6.49255365e-02f, 2.96100602e-03f, -7.85184801e-02f, 7.95073062e-02f, 4.68299128e-02f, 1.75177939e-02f,
  6.10268526e-02f, -4.49858457e-02f, 8.53480995e-02f, -1.02838449e-01f, -5.58295799e-03f, -1.99908931e-02f, -5.38487323e-02f, 5.47273643e-02f, -1.03716411e-01f, -4.79765013e-02f,
  4.02540676e-02f, 5.67784011e-02f, 2.19648536e-02f, -3.35166976e-02f, 4.72744927e-02f, 5.65551817e-02f, 2.38592476e-02f, -1.34590315e-02f, -5.65252453e-02f, 3.09344642e-02f,
  -2.35393554e-01f, -1.33193389e-01f, 1.36509975e-02f, 1.09220393e-01f, -3.65097523e-02f, 1.56410057e-02f, -1.70586426e-02f, 2.56238300e-02f, 4.72699897e-03f, 7.31137116e-03f,
  8.17722604e-02f, -4.60848724e-03f, 3.36569734e-02f, -4.26000804e-02f, 1.37070855e-02f, -4.59530503e-02f, 6.52122218e-03f, 6.61421865e-02f, -3.10786739e-02f, 1.68605335e-02f,
  1.34628983e-02f, 5.47347255e-02f, 2.92913094e-02f, -2.13300008e-02f, -2.76603494e-02f, 1.51982214e-02f, -2.17921939e-02f, -5.15718479e-04f, 1.18531659e-02f, -2.85001937e-02f,
  1.19384430e-01f, -1.67619944e-01f, 7.58376196e-02f, 1.95448007e-02f, 2.17088252e-01f, 5.97746170e-04f, 2.08305687e-01f, -7.90978819e-02f, -2.43694335e-02f, -1.80506766e-01f,
  -6.03012256e-02f, 3.90019454e-02f, -1.71288382e-03f, 9.81258601e-02f, 1.40602425e-01f, -1.01710603e-01f, 5.28502651e-02f, 7.43212178e-02f, 3.67705785e-02f, -1.47832092e-02f,
  -5.55528663e-02f, 1.01046219e-01f, 3.77657935e-02f, 1.42566152e-02f, 7.91392699e-02f, -1.25443071e-01f, -1.26183312e-02f, 9.90327075e-02f, -1.79350171e-02f, 7.06179291e-02f,
  5.32656983e-02f, -4.30731401e-02f, 6.95249811e-02f, 2.78927153e-03f, -6.74526170e-02f, -2.99463570e-02f, 1.35157187e-03f, 1.05873473e-01f, 2.65245214e-02f, -6.58259392e-02f,
  -2.30747368e-02f, 4.07966822e-02f, -2.18561497e-02f, -2.94359773e-03f, 4.42570634e-02f, -7.20023885e-02f, -3.09690065e-03f, -9.63233337e-02f, -1.01059474e-01f, 2.55063269e-02f,
  -2.93202568e-02f, -9.52122435e-02f, 5.60228527e-02f, 3.50161754e-02f, 3.98894809e-02f, -1.09327026e-01f, 3.76234278e-02f, 1.03085294e-01f, -3.44880335e-02f, -7.35270604e-03f,
  1.70772597e-02f, 9.33939368e-02f, 7.76773393e-02f, -6.14959113e-02f, 1.02191120e-01f, -8.02582800e-02f, 7.31260777e-02f, -4.82223704e-02f, 7.80858845e-02f, -4.58666831e-02f,
  1.15758270e-01f, 2.06640903e-02f, 1.20887361e-01f, 4.14136872e-02f, -2.04247776e-02f, 1.90322623e-02f, 7.24858493e-02f, 4.69570830e-02f, 1.60613917e-02f, -6.95781484e-02f,
  -9.13930982e-02f, 6.95232674e-02f, 1.07333317e-01f, -7.18853921e-02f, -6.64381981e-02f, 1.11725055e-01f, -5.33057423e-03f, -1.06806651e-01f, -1.02545777e-02f, -3.26311439e-02f,
  -4.68562217e-03f, 7.39210770e-02f, 4.28232774e-02f, 7.63474107e-02f, -4.74260822e-02f, 1.56143378e-03f, 2.74455585e-02f, -6.25728304e-03f, -6.55893013e-02f, -1.99801102e-03f,
  -7.50533119e-02f, -2.48730537e-02f, -8.21184143e-02f, 1.31438226e-01f, -9.05042738e-02f, 2.28836667e-02f, 5.03675407e-03f, 8.80391244e-03f, -7.02753589e-02f, -2.99827512e-02f,
  -3.39646302e-02f, 8.67675990e-02f, 6.80995360e-02f, -5.40705724e-03f, -7.69430995e-02f, -6.74940273e-02f, -1.47061534e-02f, 2.17204491e-04f, -1.12777695e-01f, -7.38234743e-02f,
  4.31558415e-02f, -5.19100092e-02f, -2.17884988e-01f, -2.42101233e-02f, 3.35130538e-03f, -3.37263495e-01f, -1.52976453e-01f, -6.64904341e-02f, 1.13303371e-01f, 1.89422239e-02f,
  -1.49528801e-01f, 1.76779002e-01f, 9.93710086e-02f, -1.46620139e-01f, -1.42480150e-01f, -4.16871980e-02f, -2.03150168e-01f, -6.47192970e-02f, 8.01295936e-02f, -1.46585509e-01f,
  7.73095759e-03f, -1.96959034e-01f, -1.03751294e-01f, -2.24084407e-02f, -1.69282809e-01f, -3.75604220e-02f, 6.99583068e-02f, 1.31828189e-02f, -5.86064979e-02f, 6.29349723e-02f,
  -2.41297670e-02f, 1.46746367e-01f, 2.20651031e-02f, 2.47150511e-02f, -8.39358270e-02f, 1.50136985e-02f, -1.64608702e-01f, -5.29046282e-02f, -4.30338737e-03f, -7.59990737e-02f,
  1.56077007e-02f, 6.25111237e-02f, 2.87749479e-03f, 8.88440013e-03f, -4.14813831e-02f, -1.28026900e-03f, 1.09219134e-01f, 2.76323431e-03f, -5.72340155e-04f, -9.26634520e-02f,
  2.41985265e-02f, -2.96094380e-02f, -1.32049453e-02f, -3.70335430e-02f, -1.58377308e-02f, -2.24473095e-03f, -6.26546890e-02f, -1.39667364e-02f, -2.80019697e-02f, -2.49223690e-02f,
  -3.03762052e-02f, -3.64965536e-02f, 2.28468794e-02f, 1.00108117e-01f, -1.05490824e-02f, 6.75710812e-02f, -8.32523480e-02f, 1.07330762e-01f, -7.75508434e-02f, 3.57326609e-03f,
  3.76571272e-03f, -1.64033081e-02f, 1.49426991e-02f, -1.23271160e-01f, -3.33507210e-02f, 3.36519666e-02f, -5.89195713e-02f, 6.09874092e-02f, -1.68932732e-02f, -5.98314591e-02f,
  -5.49608085e-04f, -1.41226258e-02f, 1.07791554e-02f, -4.41643000e-02f, -1.29938377e-02f, -7.02323625e-03f, 6.05934523e-02f, -1.43002300e-02f, 7.92521462e-02f, -7.52757192e-02f,
  6.26785085e-02f, 1.05805555e-02f, 3.92610431e-02f, -3.81303532e-03f, 2.93519609e-02f, 4.31162975e-04f, -5.82380220e-02f, -1.28531111e-02f, -6.49643689e-02f, 7.83397257e-02f,
  5.47039974e-03f, -1.40531815e-03f, 4.35443856e-02f, -2.25084322e-03f, 5.13711944e-02f, -1.05326600e-01f, 7.37132654e-02f, 1.00750864e-01f, 3.93960029e-02f, -1.53765995e-02f,
  -9.32291057e-03f, 3.34703363e-03f, 3.62710282e-02f, 7.34237134e-02f, 4.98992577e-02f, 3.10295299e-02f, -4.39773425e-02f, 3.48481834e-02f, 7.83169270e-02f, 3.18718217e-02f,
  -1.89947695e-01f, 1.10715345e-01f, -2.39352174e-02f, -1.85237199e-01f, 4.07003937e-03f, -1.89307332e-01f, -2.18789861e-01f, 3.13998871e-02f, -1.28125831e-01f, -4.62948792e-02f,
  -6.26136214e-02f, -1.05069630e-01f, -8.52377266e-02f, -1.66850716e-01f, -2.30983853e-01f, -1.91738516e-01f, -2.52459943e-01f, -5.76833412e-02f, 1.78303551e-02f, -7.54933208e-02f,
  -3.53934765e-02f, -1.60447553e-01f, -1.82726845e-01f, 3.86952683e-02f, 5.16072102e-02f, 2.38326769e-02f, 4.83334549e-02f, -9.43911895e-02f, -1.30376190e-01f, -7.35491961e-02f,
  2.89125182e-02f, -6.42924011e-02f, 4.04164828e-02f, -1.30279223e-04f, -1.84598584e-02f, 2.02999245e-02f, -1.65223554e-02f, 5.68714961e-02f, -6.54295534e-02f, -8.04524571e-02f,
  -2.95371413e-02f, -6.89392909e-02f, 2.92641707e-02f, -4.95618135e-02f, -6.61990745e-03f, 8.64875168e-02f, 7.31702745e-02f, -2.52061782e-05f, 7.77337253e-02f, 8.10954198e-02f,
  -7.79509097e-02f, 7.96287134e-03f, 2.10332386e-02f, -1.12924084e-01f, -9.11927596e-02f, 2.41170656e-02f, -1.51162734e-02f, 5.66435717e-02f, -2.76847612e-02f, -2.50276155e-03f,
  4.91322577e-03f, -4.77248840e-02f, -1.07549198e-01f, -2.00318992e-02f, -5.30106202e-03f, -4.01105955e-02f, 3.92814763e-02f, -6.53583035e-02f, -3.83947790e-02f, -4.02593352e-02f,
  -4.38062325e-02f, -3.03353034e-02f, -4.89343926e-02f, -1.01917371e-01f, 6.41085282e-02f, 2.88455263e-02f, -9.69056934e-02f, -3.11933216e-02f, 6.86350763e-02f, -8.02332163e-02f,
  -4.53044698e-02f, -8.08554068e-02f, -2.21630596e-02f, -4.63401992e-03f, 6.72207773e-02f, -1.72342937e-02f, 9.54320282e-03f, -8.32156464e-02f, -5.51796854e-02f, 6.01577247e-03f,
  2.64716651e-02f, 3.24698724e-02f, 4.69596907e-02f, -8.39223340e-02f, -2.12130062e-02f, 4.73679081e-02f, -1.02963768e-01f, -2.27000285e-02f, -8.02711211e-03f, -2.58335397e-02f,
  6.27670437e-02f, -2.94664428e-02f, -1.77878626e-02f, 2.87801679e-03f, 3.88930403e-02f, 4.86820228e-02f, -8.86158198e-02f, 6.06660210e-02f, -4.03710902e-02f, -1.61291808e-02f,
  9.62780416e-02f, 4.73789163e-02f, 6.75594583e-02f, -7.93265458e-03f, -5.22585064e-02f, 2.80298349e-02f, -1.27729801e-02f, 8.63798545e-04f, -8.73136967e-02f, 4.13603596e-02f,
  2.87709385e-01f, -2.90024370e-01f, -8.94350260e-02f, 2.09296551e-02f, 1.97933629e-01f, 1.38427436e-01f, 1.62736773e-01f, -1.06093213e-01f, -1.29606083e-01f, -1.85401306e-01f,
  6.24661781e-02f, 5.75169250e-02f, -1.12593308e-01f, 2.59168670e-02f, 1.81483164e-01f, -1.03749342e-01f, -2.59691896e-03f, 6.29122481e-02f, -8.44783336e-02f, -7.26062432e-02f,
  4.77591306e-02f, 1.40874520e-01f, -1.59243066e-02f, -1.33784041e-02f, 5.41548729e-02f, -8.57678205e-02f, 9.99030564e-03f, -4.73027024e-03f, 9.90533680e-02f, 6.88782558e-02f,
  5.29176481e-02f, 7.54046738e-02f, -1.81813221e-02f, -8.59841779e-02f, 2.61728670e-02f, -1.07539967e-02f, 7.32634366e-02f, 1.14163505e-02f, -1.18957963e-02f, -4.14480045e-02f,
  -4.29877043e-02f, -6.98511256e-03f, -7.20665157e-02f, 3.40094566e-02f, 8.15345570e-02f, -4.47533317e-02f, -1.23990001e-02f, 1.52285257e-02f, -7.37764984e-02f, -2.92064007e-02f,
  -3.61889265e-02f, -2.94839544e-03f, -5.81595488e-02f, -5.31499907e-02f, 3.70769911e-02f, 4.35243249e-02f, -7.36155435e-02f, 2.69047171e-02f, -1.04961641e-01f, -4.88523319e-02f,
  -6.82754219e-02f, -6.44222349e-02f, 6.33148253e-02f, 6.11761212e-02f, -5.66371344e-02f, 5.61043173e-02f, 1.04440115e-02f, -1.03200926e-02f, 2.39092484e-02f, -2.53261570e-02f,
  5.56269921e-02f, -1.74289234e-02f, -1.09398074e-01f, 5.01782149e-02f, 1.59951746e-02f, -6.79416256e-03f, -9.40485857e-03f, 4.27484773e-02f, 1.97110586e-02f, -2.95158345e-02f,
  -3.51268649e-02f, 4.88344207e-02f, -6.42177761e-02f, -8.68047923e-02f, -4.34950143e-02f, 3.61158997e-02f, 1.02801129e-01f, 2.61514448e-03f, 6.04619719e-02f, -6.52873842e-03f,
  -9.61432606e-02f, -1.11134417e-01f, -5.13550155e-02f, 2.07815785e-02f, -1.38999661e-02f, -2.05748100e-02f, 8.71130750e-02f, -1.86581556e-02f, -7.70653039e-02f, 3.86403352e-02f,
  6.20011464e-02f, 1.32633746e-02f, 3.03653665e-02f, -1.66530591e-02f, 1.28914183e-03f, 4.53056879e-02f, -7.96881095e-02f, -8.24386701e-02f, -1.11211777e-01f, -5.53534664e-02f,
  -4.99597527e-02f, 5.21546416e-02f, -1.68125015e-02f, 1.58997136e-03f, 2.08587460e-02f, -5.53685762e-02f, 1.27304008e-03f, -3.68886851e-02f, -3.07120271e-02f, -7.50340968e-02f,
  9.20697972e-02f, -2.52330929e-01f, -2.19156891e-01f, -2.09934369e-01f, -1.65264159e-01f, -2.59963244e-01f, -1.08795673e-01f, -2.07778797e-01f, -1.24254815e-01f, -8.82401094e-02f,
  -4.65846062e-02f, 9.95649695e-02f, 2.14113787e-01f, -9.31873545e-02f, 2.73537755e-01f, 1.76195785e-01f, -1.96732193e-01f, -9.77773145e-02f, -1.68184280e-01f, -2.11147100e-01f,
  -8.47335607e-02f, -1.21523917e-01f, 1.09265417e-01f, -2.64988482e-01f, -1.43805683e-01f, -1.33410037e-01f, 8.19018036e-02f, -1.30913630e-01f, -1.59061879e-01f, -8.30765963e-02f,
  -4.54916060e-02f, -6.90510217e-03f, -8.51346031e-02f, -4.05163616e-02f, 2.05584858e-02f, -8.00935831e-03f, 4.93834876e-02f, 3.59146222e-02f, 1.96474865e-02f, 5.92087656e-02f,
  4.43662293e-02f, -5.85219935e-02f, 5.33863576e-03f, 5.95191531e-02f, -3.01787853e-02f, -1.47325531e-01f, 1.28620607e-03f, 1.86940841e-02f, -1.05241038e-01f, -8.64316225e-02f,
  -3.52630615e-02f, -7.67026916e-02f, -4.66197133e-02f, 9.21720341e-02f, 7.71651119e-02f, 6.29863795e-03f, -2.24085841e-02f, 1.63911059e-01f, -1.42701967e-02f, -9.84529480e-02f,
  -8.45949650e-02f, -1.87933780e-02f, 8.35447200e-03f, -3.87018360e-02f, -1.73773319e-02f, -1.22860059e-01f, -3.02535621e-03f, 6.84496313e-02f, -5.77661907e-03f, -2.41845436e-02f,
  1.36189247e-02f, 6.41718647e-03f, 4.04118299e-02f, 6.68983012e-02f, -9.49716642e-02f, 3.06386873e-02f, 1.12650685e-01f, -2.27851719e-02f, 4.57636407e-03f, -1.36403805e-02f,
  3.15031558e-02f, -2.51445789e-02f, 3.13399360e-02f, -2.96293106e-02f, -1.89207937e-03f, 1.01262331e-01f, -4.24881838e-02f, -6.95346892e-02f, -1.64541509e-02f, 1.16776526e-01f,
  -4.87808287e-02f, -1.63552672e-01f, 5.70606589e-02f, -3.61563899e-02f, 1.76109318e-02f, -4.56358027e-03f, 1.42219374e-02f, -6.61867037e-02f, -7.50231594e-02f, -5.48786484e-02f,
  -6.58750832e-02f, -1.99947949e-03f, 1.92181184e-03f, -1.99145395e-02f, -2.81740893e-02f, -7.02231452e-02f, -9.51788276e-02f, -5.28174192e-02f, -1.22989714e-02f, -1.22574970e-01f,
  3.64432670e-02f, 4.30498272e-02f, 2.62630712e-02f, 2.81802267e-02f, -3.16209681e-02f, -2.17374116e-02f, -1.99937099e-03f, -5.45047820e-02f, -5.05719185e-02f, -8.98050964e-02f,
  -3.43039297e-02f, -1.20911255e-01f, -3.80737744e-02f, -4.15460542e-02f, 3.94687057e-02f, -2.44704157e-01f, -9.72941667e-02f, -3.91128585e-02f, -8.08865055e-02f, -1.07291937e-01f,
  -5.63640632e-02f, 1.68649122e-01f, 1.70065332e-02f, -1.36670187e-01f, 1.57686934e-01f, 1.88520238e-01f, -9.27220583e-02f, -9.71820429e-02f, -8.38502310e-03f, -5.52085862e-02f,
  7.81819299e-02f, -1.35827005e-01f, 8.15383866e-02f, -1.56505123e-01f, -1.01618119e-01f, -1.61580052e-02f, 1.41430208e-02f, -7.32427696e-03f, -9.13628936e-02f, 6.22504242e-02f,
  -1.10908806e-01f, -8.58019590e-02f, -8.99691582e-02f, -1.99382100e-02f, -1.12808555e-01f, 9.02112573e-02f, -2.61238348e-02f, 8.71090293e-02f, -3.19350138e-02f, -3.65216029e-03f,
  -3.22114713e-02f, 2.82736868e-02f, -7.77997151e-02f, 4.32950445e-03f, -2.95810718e-02f, 1.14658624e-02f, -6.89229881e-03f, -2.46045887e-02f, -8.43483023e-03f, 8.70477483e-02f,
  -6.12459965e-02f, -5.99994771e-02f, -1.33162722e-01f, 1.47800315e-02f, 7.31121153e-02f, -7.04479516e-02f, -1.60151776e-02f, -5.83837070e-02f, 8.05033520e-02f, 2.22813245e-02f,
  8.36080387e-02f, 1.29243553e-01f, -5.61521947e-02f, -3.72198201e-03f, -7.29428455e-02f, -1.67457480e-02f, 4.20146883e-02f, 9.58990529e-02f, -1.67411752e-02f, -1.04612440e-01f,
  4.73419055e-02f, 6.45446181e-02f, -6.71928823e-02f, -3.28080095e-02f, -2.59760139e-03f, -2.05354858e-02f, 2.43708305e-03f, -5.46466410e-02f, -2.43998622e-03f, 4.30215001e-02f,
  -4.66672741e-02f, -1.30419489e-02f, -1.34871639e-02f, 3.45027400e-03f, -7.45113716e-02f, -1.22208893e-01f, 3.73880821e-03f, -3.21941376e-02f, 2.05323892e-03f, -1.12853488e-02f,
  -7.73826102e-03f, -8.21034387e-02f, -9.77038220e-02f, -1.15169808e-01f, -5.96777685e-02f, -3.91674824e-02f, 5.67108206e-02f, 6.55445084e-02f, 1.81672182e-02f, 2.68877055e-02f,
  -6.08713701e-02f, -1.05091175e-02f, 2.45766062e-02f, 4.18033153e-02f, -8.60300064e-02f, -1.67844370e-02f, 4.06946875e-02f, 3.44852582e-02f, -3.88239063e-02f, 8.62267986e-02f,
  -4.38829958e-02f, 6.19449876e-02f, -8.19466859e-02f, -5.89411706e-02f, 1.29267484e-01f, -9.96175483e-02f, 1.03495695e-01f, 4.57343385e-02f, 1.44469440e-01f, 5.19178212e-02f,
  2.09263146e-01f, 1.84906080e-01f, 9.57751647e-02f, -4.97366600e-02f, -7.43820705e-03f, 2.69380242e-01f, 1.27226651e-01f, -7.01418072e-02f, -4.17602714e-03f, 1.46368057e-01f,
  3.13512720e-02f, 1.60840049e-01f, 4.40726578e-02f, 1.77053213e-01f, -1.26647800e-02f, 5.89020103e-02f, 1.71892300e-01f, 7.02612624e-02f, -1.00053865e-02f, -5.93604185e-02f,
  -1.71711743e-01f, -9.12303850e-02f, -4.99554463e-02f, -6.82244748e-02f, 3.82269919e-02f, 5.37997298e-02f, -1.89505175e-01f, 3.61285657e-02f, -8.60683024e-02f, 7.53474981e-02f,
  1.07339032e-01f, -3.71621363e-02f, 6.40460430e-03f, 5.34888282e-02f, 3.38040777e-02f, -1.20557779e-02f, 5.03993705e-02f, 9.29489452e-03f, -8.34565014e-02f, -1.62984207e-02f,
  5.72021678e-02f, 1.83947962e-02f, 7.02227205e-02f, -9.74375904e-02f, -8.60420894e-03f, -7.60200433e-03f, 3.33404727e-02f, -5.97294569e-02f, -1.77790355e-02f, 1.08060241e-01f,
  -1.71836726e-02f, -4.92548607e-02f, 9.51726269e-03f, 1.33079747e-02f, 6.79169968e-02f, -7.36224502e-02f, 1.48268566e-01f, -6.23106621e-02f, -1.12297118e-03f, 1.49245476e-02f,
  5.92789575e-02f, 4.55788411e-02f, 7.09868148e-02f, 8.15192703e-03f, 1.44471284e-02f, -1.61626399e-01f, -6.06681705e-02f, 9.21030939e-02f, -1.47319790e-02f, 1.17570665e-02f,
  3.66341248e-02f, -3.92406993e-02f, -3.26701067e-02f, -5.48645519e-02f, -5.01640886e-02f, 4.71378081e-02f, -4.81756032e-02f, -1.96013898e-02f, -1.88567806e-02f, -1.82717107e-02f,
  -2.27078963e-02f, -8.53364319e-02f, 5.98638970e-03f, 3.82420495e-02f, -5.78193879e-03f, -4.77610230e-02f, -1.06923049e-02f, -1.63750350e-02f, 5.01980484e-02f, 6.08796105e-02f,
  -4.57348712e-02f, 1.40264228e-01f, 8.99132118e-02f, 5.01665547e-02f, 1.55803980e-02f, 7.87327811e-02f, 1.11859888e-02f, 1.04805792e-03f, -5.03990501e-02f, -4.31624763e-02f,
  2.71018427e-02f, 1.44071430e-01f, 9.94092552e-04f, -3.68262012e-03f, -8.93766433e-02f, 1.32342339e-01f, -2.93003507e-02f, -1.07856020e-02f, -3.93408351e-02f, -6.99759647e-02f,
  -1.07576825e-01f, 3.53774577e-02f, -2.61772200e-02f, -1.05953805e-01f, 7.69437030e-02f, -1.35755226e-01f, -9.12378356e-02f, 7.16594234e-02f, -2.85414532e-02f, -9.77376103e-02f,
  -1.90553889e-01f, -7.79988766e-02f, -1.87803328e-01f, -2.81953305e-01f, 7.32957348e-02f, -6.83889315e-02f, -6.67817071e-02f, 1.73233733e-01f, -8.67449641e-02f, 1.36534885e-01f,
  1.68463439e-01f, -1.25615165e-01f, 1.12068765e-01f, -1.66821256e-01f, -2.57430524e-01f, -1.73446953e-01f, -1.43583521e-01f, 4.29838151e-02f, -1.09891798e-02f, 4.90589216e-02f,
  -1.25538126e-01f, -1.82898734e-02f, -2.08630487e-01f, 1.15458749e-01f, 6.43400997e-02f, 9.76699740e-02f, 5.92169724e-02f, 5.87174743e-02f, 1.09228477e-01f, 9.25471634e-02f,
  3.18287238e-02f, 7.39539713e-02f, 1.45164520e-01f, -5.99699989e-02f, 5.77527061e-02f, 8.37005973e-02f, 1.45894829e-02f, 3.92913409e-02f, -6.96191043e-02f, -6.50239661e-02f,
  7.06221685e-02f, 1.79039969e-04f, 5.57100177e-02f, -6.94508702e-02f, -8.75302181e-02f, -3.67413759e-02f, -2.55682431e-02f, -3.63788530e-02f, -9.94571298e-02f, -6.54914305e-02f,
  -5.22605516e-02f, -5.84119931e-02f, -7.03014880e-02f, -1.50448205e-02f, -7.61975124e-02f, 5.01491176e-03f, -1.27229109e-01f, 1.77175384e-02f, -1.74075663e-02f, -2.64170412e-02f,
  6.74175397e-02f, -2.38425173e-02f, 6.53866380e-02f, -7.72579685e-02f, -1.63669344e-02f, 4.50055003e-02f, -9.79470834e-02f, 5.17161861e-02f, -1.34473026e-01f, 4.02348787e-02f,
  8.93255174e-02f, -2.89490242e-02f, 6.73760846e-02f, -8.20065215e-02f, -7.09578395e-02f, -3.16163078e-02f, -8.56395587e-02f, 9.90498718e-03f, -1.04101606e-01f, -7.90339801e-03f,
  1.38690621e-01f, -6.77706078e-02f, 2.18637474e-02f, -5.93467541e-02f, -1.11971069e-02f, -5.37752621e-02f, 1.45167783e-02f, -5.24254031e-02f, -1.09865824e-02f, 3.27613018e-02f,
  9.65198949e-02f, 1.09861739e-01f, 8.94866437e-02f, 1.37953544e-02f, 1.73943304e-02f, 7.36796558e-02f, -1.17301652e-02f, 5.83052188e-02f, -2.93512307e-02f, 9.39044729e-02f,
  5.92986196e-02f, -5.56206815e-02f, -2.65423935e-02f, -1.09419143e-02f, -3.81920747e-02f, 2.66759414e-02f, -1.72629338e-02f, -3.36540528e-02f, -1.18069828e-01f, 1.10580642e-02f,
  -5.11708856e-02f, 8.62794928e-03f, -4.39362898e-02f, 3.83927636e-02f, 2.19976436e-02f, -9.07824468e-03f, 5.89731969e-02f, -7.08492473e-02f, 6.09591119e-02f, -3.14414278e-02f,
  -5.68111241e-01f, 3.26242864e-01f, -1.76371820e-02f, -5.28719909e-02f, 1.66936770e-01f, 8.13530385e-02f, -2.72207540e-02f, 7.36615434e-02f, -2.02116761e-02f, -2.50720959e-02f,
  -4.32317741e-02f, -6.31216839e-02f, 9.86916721e-02f, 2.08679847e-02f, -1.81017503e-01f, 1.18970037e-01f, 2.77905492e-04f, -4.01062928e-02f, -4.30479050e-02f, 4.49203961e-02f,
  -7.92877600e-02f, 2.40091924e-02f, -5.19257970e-02f, 2.09077954e-01f, -7.81397521e-02f, -3.02805044e-02f, -2.50008106e-01f, 1.24867009e-02f, -5.30684367e-02f, 3.68002243e-02f,
  -9.61762518e-02f, -1.76702663e-01f, -1.53335586e-01f, -1.36562884e-01f, -1.76369533e-01f, -6.55156473e-05f, -5.84988296e-02f, -3.37287337e-02f, -7.62670338e-02f, 2.75321193e-02f,
  -4.96911220e-02f, 3.01516820e-02f, 2.45712716e-02f, 2.37613544e-02f, 7.10403034e-03f, -7.77636915e-02f, 3.91680896e-02f, 5.49754612e-02f, -4.43270616e-03f, 9.73342583e-02f,
  2.83793285e-02f, -9.15208890e-04f, -3.59815508e-02f, -6.07284233e-02f, -3.12648937e-02f, -9.15153418e-03f, -2.90454663e-02f, -3.38587239e-02f, -1.28370762e-01f, -3.61141711e-02f,
  -6.18332289e-02f, -4.61779535e-03f, 1.96908358e-02f, 5.53774312e-02f, 2.58613657e-02f, -4.46392410e-02f, -1.27015095e-02f, 3.98130268e-02f, 1.08597847e-02f, -4.49442975e-02f,
  -2.22890917e-02f, 6.46970351e-04f, 7.70152453e-03f, 5.13481013e-02f, 5.57290651e-02f, 6.95128809e-04f, 4.31949235e-02f, -4.47696187e-02f, 5.43117970e-02f, 2.60710693e-03f,
  -4.76815514e-02f, 1.07761277e-02f, 5.96155180e-03f, 3.62999290e-02f, -2.62428205e-02f, -2.60169320e-02f, -3.66774900e-03f, 5.55289350e-02f, 2.09783614e-02f, -8.00363198e-02f,
  -1.93803325e-01f, -2.98426241e-01f, -3.09835151e-02f, -3.11873574e-02f, -7.18701929e-02f, -1.67494472e-02f, -3.21745276e-02f, -6.31631687e-02f, -1.11401025e-02f, -4.61046472e-02f,
  -2.37610321e-02f, -1.84451714e-02f, -9.19054523e-02f, 5.39145283e-02f, -4.18798253e-02f, -1.77491363e-02f, -2.49279868e-02f, -4.96354997e-02f, -8.59433860e-02f, -1.22530557e-01f,
  -7.72221610e-02f, 1.49072837e-02f, 5.94761979e-04f, -3.37730302e-03f, -4.29640524e-03f, -1.07562982e-01f, -5.93067557e-02f, -5.48415780e-02f, 1.62154958e-02f, -1.61077008e-02f,
  1.32962316e-01f, 1.02306694e-01f, 2.27435097e-01f, 3.93936336e-01f, -7.47169331e-02f, -1.33023858e-01f, 7.04856124e-03f, 1.40327558e-01f, 2.63315529e-01f, -5.45297265e-02f,
  6.22118451e-02f, 4.66443822e-02f, -8.49588737e-02f, 1.46007344e-01f, 9.64941382e-02f, -4.88966703e-03f, 1.88971628e-02f, 7.07987770e-02f, 1.81726627e-02f, 7.58005679e-02f,
  6.36893660e-02f, 5.93926683e-02f, 3.66995297e-02f, 5.90396579e-03f, 5.49023151e-02f, 1.29875496e-01f, 7.40502551e-02f, -8.71754736e-02f, -7.96967223e-02f, -1.34766743e-01f,
  8.99351910e-02f, 1.56535581e-01f, -5.11696711e-02f, -9.93155539e-02f, 6.77396506e-02f, -1.28104940e-01f, -2.52336189e-02f, -3.37107405e-02f, -1.04241312e-01f, 4.57652174e-02f,
  -3.16954441e-02f, 1.12589514e-02f, -8.26466177e-03f, -5.10277785e-02f, -5.54382987e-02f, 4.00302187e-02f, 7.49116391e-02f, -5.48031926e-02f, 3.87899689e-02f, 1.93353612e-02f,
  9.64032672e-03f, -3.21600884e-02f, -4.58578132e-02f, -7.26139471e-02f, 9.21852887e-02f, 7.72737861e-02f, 3.28085870e-02f, -1.55072100e-02f, 9.80529040e-02f, 6.54525608e-02f,
  -1.28195107e-01f, -5.93421236e-02f, 4.66210507e-02f, -4.16927971e-02f, -5.92650697e-02f, 3.51987127e-03f, -5.10504432e-02f, -1.27941314e-02f, -3.83971520e-02f, 5.37836850e-02f,
  5.42063937e-02f, -1.19510544e-02f, 8.07774290e-02f, 8.28029495e-03f, 2.40973737e-02f, -3.79595682e-02f, 3.38847563e-02f, 3.61648127e-02f, 9.38470289e-02f, 1.38717532e-01f,
  4.26529907e-02f, -4.66324687e-02f, -1.03289606e-02f, 5.91962365e-03f, -1.06788762e-01f, 2.33295094e-02f, -6.70811813e-03f, -1.63643658e-02f, -5.82926013e-02f, 5.51028959e-02f,
  7.11717308e-02f, 1.61226407e-01f, -7.69734234e-02f, -6.83171153e-02f, 6.76887780e-02f, 1.54663669e-02f, 6.16033562e-02f, 6.54271096e-02f, 1.03086725e-01f, 1.50328095e-03f,
  -3.66113111e-02f, -7.86633939e-02f, -3.21144201e-02f, 1.13650772e-03f, 4.26692292e-02f, 1.50141725e-02f, 2.13897675e-02f, -1.67031977e-02f, -6.31126091e-02f, 1.05407290e-01f,
  -1.85038596e-02f, 6.31856695e-02f, 1.52649991e-02f, 7.71862864e-02f, -1.03380368e-03f, -4.09434065e-02f, 6.65458292e-02f, -4.36374173e-02f, -4.51431796e-02f, -4.23639268e-02f,
  1.31507859e-01f, -1.00701280e-01f, -1.88353419e-01f, 1.16663761e-01f, 5.84516600e-02f, -6.33475371e-03f, -2.26749077e-01f, -3.49365994e-02f, -2.09218085e-01f, -5.54311536e-02f,
  -4.56220210e-02f, 4.90843318e-02f, -2.05037326e-01f, 2.34300464e-01f, 1.21386707e-01f, -1.30583018e-01f, 1.38054252e-01f, 9.24404114e-02f, -1.09844863e-01f, 9.88769680e-02f,
  -3.55975665e-02f, 2.59367019e-01f, -2.40617786e-02f, 2.17950016e-01f, 4.91859391e-02f, 3.04712486e-02f, 1.78700849e-01f, -3.67676318e-02f, 1.95454791e-01f, 1.27871811e-01f,
  1.13139398e-01f, -3.37287737e-03f, -1.94691345e-02f, -6.66809082e-02f, -1.80031378e-02f, 1.09607494e-02f, 1.55332601e-02f, 4.98881526e-02f, 1.10820576e-03f, -1.04759999e-01f,
  2.17377078e-02f, -5.97199332e-03f, 8.18390101e-02f, 7.55932853e-02f, 5.19353673e-02f, 3.98866227e-03f, -4.47857492e-02f, -3.99611099e-03f, -1.16591156e-01f, 4.49264459e-02f,
  -6.01854548e-02f, -9.57266428e-03f, -4.45234701e-02f, 7.18788505e-02f, 4.57918905e-02f, -5.56927063e-02f, -4.75232899e-02f, -5.62740117e-02f, -7.10719526e-02f, 3.98764126e-02f,
  8.30338821e-02f, -2.29040254e-02f, -9.80561674e-02f, 5.52918166e-02f, 1.88858919e-02f, -5.75681925e-02f, 3.88999023e-02f, -4.43289019e-02f, -8.16032887e-02f, 5.88652492e-02f,
  -2.48945435e-04f, -9.43362713e-03f, -4.32061553e-02f, -2.23388020e-02f, -3.62784229e-02f, 2.71160379e-02f, -3.16463225e-02f, -3.22564915e-02f, 1.89616960e-02f, -4.25331071e-02f,
  -4.75760400e-02f, -8.13708752e-02f, -2.07379535e-02f, -3.71431224e-02f, 4.54546437e-02f, -5.76608963e-02f, 1.02811977e-01f, -3.70346615e-03f, 1.34791527e-03f, -1.00956015e-01f,
  6.34521842e-02f, 9.05559957e-02f, -3.77793647e-02f, 1.05827503e-01f, -1.09418267e-02f, 2.93569136e-02f, 8.88703093e-02f, 4.22093607e-02f, -2.86132749e-02f, -6.27825269e-04f,
  2.37849820e-02f, -1.86068416e-02f, -4.59379740e-02f, -3.65368538e-02f, 4.08088230e-02f, 8.77177692e-04f, -6.77373558e-02f, 2.47570798e-02f, 1.67884061e-03f, 7.75656775e-02f,
  6.13611937e-02f, -1.40259922e-01f, 8.77806544e-02f, -6.54405653e-02f, -1.95547137e-02f, 1.13651445e-02f, -5.55348024e-02f, 7.31626749e-02f, -1.50665101e-02f, -3.21622528e-02f,
  1.94102794e-01f, -6.63269833e-02f, -1.98416337e-01f, -8.97480082e-03f, -1.23790719e-01f, -7.22774714e-02f, -8.18746909e-02f, 8.18869397e-02f, -1.67645082e-01f, 2.48291157e-02f,
  8.89016688e-02f, -7.53499866e-02f, -1.53352141e-01f, 2.25709006e-01f, 1.70138821e-01f, -1.42202228e-01f, 1.19743079e-01f, -1.14407782e-02f, -1.12460880e-02f, 1.20953433e-01f,
  8.21052790e-02f, 1.67215735e-01f, 6.34895936e-02f, 2.40037814e-01f, 1.55561492e-01f, 5.26266880e-02f, 1.95836782e-01f, -1.23636693e-01f, 2.42856413e-01f, 1.42481834e-01f,
  1.46675752e-02f, 6.58897012e-02f, -2.39418279e-02f, -8.89360756e-02f, 7.18876673e-03f, 4.25841361e-02f, -1.02131844e-01f, -4.35496606e-02f, -6.68020323e-02f, -6.42316714e-02f,
  -1.06229559e-01f, 9.13159549e-02f, 2.60481760e-02f, -1.12887785e-01f, 2.11007465e-02f, 2.94689159e-03f, 1.86456870e-02f, -5.12297861e-02f, -3.66552062e-02f, -2.88734641e-02f,
  -6.64745048e-02f, -3.02399360e-02f, -2.05767006e-02f, 1.44414557e-02f, -5.48245087e-02f, -2.19708737e-02f, 8.52430053e-03f, 8.19426589e-03f, -5.34486286e-02f, 6.50164708e-02f,
  1.12289585e-01f, 1.50424074e-02f, 7.38900900e-02f, -4.26154733e-02f, -8.85995179e-02f, 4.17651311e-02f, 8.49976689e-02f, 3.09161860e-02f, -2.74035186e-02f, -3.37980613e-02f,
  1.18921354e-01f, -4.64322865e-02f, 1.54140806e-02f, -2.99168192e-02f, 1.62609108e-03f, 1.19120376e-02f, -1.78456698e-02f, 4.99408841e-02f, -6.00402020e-02f, -2.56725475e-02f,
  -3.03954463e-02f, -1.55963330e-02f, 7.26285800e-02f, -1.03608966e-02f, -4.74319421e-03f, 1.10915313e-02f, 6.70669153e-02f, -8.76062959e-02f, -1.07129529e-01f, 3.28185260e-02f,
  -1.86655447e-02f, 1.35645084e-02f, 5.04675359e-02f, -9.34696407e-04f, -4.15496863e-02f, 1.29004009e-02f, -4.52810973e-02f, 1.20432423e-02f, 1.12069979e-01f, 1.76872592e-02f,
  1.77993104e-02f, -8.36193338e-02f, -2.63658855e-02f, 1.11839715e-02f, 7.30857104e-02f, -5.50299995e-02f, 4.00960669e-02f, 1.15125868e-02f, 1.06477924e-01f, 7.25797564e-03f,
  -4.99373190e-02f, 4.44067605e-02f, 4.61513661e-02f, -1.11885287e-01f, 1.03108119e-02f, 5.43987527e-02f, -2.89903563e-02f, 6.27533719e-02f, 8.59381631e-02f, -8.19722190e-03f,
  -1.02600738e-01f, -6.45299554e-02f, -2.26646990e-01f, -1.04930200e-01f, -2.17174500e-01f, -2.55592436e-01f, -1.19531415e-01f, -2.76949763e-01f, 1.22078553e-01f, 6.51125237e-02f,
  -3.66924852e-02f, 5.06325513e-02f, 1.38245285e-01f, -1.25157222e-01f, 1.57341361e-01f, 1.84979439e-01f, -2.44251877e-01f, 1.77869387e-02f, 7.99866766e-02f, -2.18222722e-01f,
  -1.33022085e-01f, -8.69453847e-02f, -8.39171559e-02f, -1.40417963e-01f, -2.80475140e-01f, 3.70224589e-04f, -4.10725400e-02f, -8.28927904e-02f, -2.25286365e-01f, 5.78831807e-02f,
  -9.34898201e-03f, -1.95441656e-02f, -2.25115512e-02f, 6.58746362e-02f, 2.62180325e-02f, -4.04782332e-02f, -1.08995020e-01f, -3.88031490e-02f, 7.16752606e-03f, -4.42360416e-02f,
  1.74484961e-02f, 4.04193699e-02f, -4.37856689e-02f, 1.06164984e-01f, -1.33070052e-01f, -3.67109999e-02f, 1.23652339e-03f, -7.86364675e-02f, -8.47462937e-02f, 6.68139383e-02f,
  -3.84008959e-02f, 5.71211092e-02f, -3.54365632e-02f, -1.96552966e-02f, -4.59913425e-02f, -3.99080217e-02f, 9.10403952e-02f, 1.21434936e-02f, 4.12790775e-02f, -4.62267883e-02f,
  -2.03359742e-02f, 5.03559411e-02f, 4.97672819e-02f, 1.30475601e-02f, 7.17788935e-02f, 9.89004821e-02f, -2.55990885e-02f, -1.65984724e-02f, -5.41376648e-03f, -6.02429360e-02f,
  4.58788462e-02f, 4.29252349e-02f, -1.61526307e-01f, 3.75237092e-02f, -3.18891965e-02f, -2.31719390e-02f, -5.23032956e-02f, -3.89998183e-02f, 3.85498442e-02f, -8.94542336e-02f,
  7.30019882e-02f, -6.38154000e-02f, 9.78915691e-02f, 1.12389503e-02f, -5.64595051e-02f, -5.93360327e-02f, -4.38518599e-02f, 8.45091511e-03f, 3.29359546e-02f, -5.94191700e-02f,
  3.54908630e-02f, -1.17319031e-02f, -3.59143689e-02f, 1.10741615e-01f, -1.20133348e-02f, -4.08418626e-02f, 4.67573619e-03f, 1.10997804e-04f, -7.98738189e-03f, 3.92112434e-02f,
  -1.29645973e-01f, -4.51311208e-02f, -9.00834203e-02f, -6.81074783e-02f, 8.58114660e-02f, 3.32966857e-02f, 1.27351256e-02f, -1.42269991e-02f, 4.70330529e-02f, -1.15837334e-02f,
  -8.33108835e-03f, 9.20025408e-02f, 2.01671533e-02f, 1.55166714e-02f, -4.69586104e-02f, -3.92291741e-03f, -5.06990775e-02f, -3.85834388e-02f, -6.17986545e-02f, 1.06644936e-01f,
  2.64146000e-01f, -2.94125944e-01f, -1.15830253e-03f, 2.24709928e-01f, 1.00451276e-01f, 4.45003808e-03f, 1.51803240e-01f, 2.61228979e-02f, 1.21850364e-01f, -1.90968022e-01f,
  9.04389471e-02f, -1.28323600e-01f, -1.14034042e-01f, -8.02196935e-02f, 1.03200369e-01f, -1.21741742e-01f, 9.41364244e-02f, -6.59707487e-02f, -6.20607957e-02f, -3.91877331e-02f,
  2.19497681e-02f, 1.04684560e-02f, -9.09506381e-02f, -6.26005381e-02f, 1.38328850e-01f, 1.25131030e-02f, 1.90749299e-02f, 2.36711148e-02f, -4.82278466e-02f, 2.52159722e-02f,
  1.35537460e-01f, 5.11104651e-02f, 6.40897900e-02f, 4.92937118e-02f, -3.49765345e-02f, -8.42644572e-02f, -1.36415496e-01f, -4.37785387e-02f, 5.00699803e-02f, 6.86507160e-03f,
  -1.88676827e-02f, 2.56108632e-03f, -5.53025603e-02f, -8.07296298e-03f, 3.41124013e-02f, 9.21709016e-02f, 5.00631891e-03f, -1.49201592e-02f, 8.14440567e-03f, 1.30065037e-02f,
  -4.24848720e-02f, -9.05100629e-02f, -6.06946684e-02f, -1.05436146e-02f, -1.93165988e-02f, -1.09810736e-02f, 3.72012742e-02f, -6.02022558e-02f, -1.06592409e-01f, -5.68352267e-02f,
  -5.48681319e-02f, -7.22659081e-02f, 3.39594632e-02f, 2.20547672e-02f, 2.15447787e-03f, 2.38337629e-02f, 2.46086605e-02f, -1.15900122e-01f, 4.26895805e-02f, -2.24140529e-02f,
  -1.27349270e-03f, 4.31653075e-02f, 3.29942219e-02f, 6.29784986e-02f, -3.78214531e-02f, 7.59668648e-02f, -3.85560915e-02f, -1.09336302e-02f, -1.28238779e-02f, 1.65698472e-02f,
  4.31334451e-02f, -5.39475605e-02f, 1.89159829e-02f, 2.41200589e-02f, -4.77477312e-02f, 4.22845110e-02f, -1.47233102e-02f, 6.79557351e-03f, -7.37475231e-02f, 4.98799197e-02f,
  -1.23476088e-01f, -2.57468134e-01f, -3.64358909e-02f, -3.62387821e-02f, -7.94615671e-02f, -3.25405747e-02f, -7.01858401e-02f, 5.55139370e-02f, 1.92057565e-02f, -8.44847709e-02f,
  -4.13882062e-02f, -1.94824263e-02f, 1.95397269e-02f, -3.46086361e-02f, 4.62099388e-02f, 1.91293731e-02f, 3.83488871e-02f, -3.24723087e-02f, -7.20048025e-02f, -7.23363608e-02f,
  2.34346874e-02f, -1.21312812e-02f, 5.43670682e-03f, 5.73892221e-02f, 1.52100520e-02f, 4.03365530e-02f, -8.96754265e-02f, 8.50700140e-02f, -1.74415484e-02f, 3.92939113e-02f,
  2.53872097e-01f, -7.26485774e-02f, 8.78227130e-02f, 2.53518373e-01f, -6.86362535e-02f, -2.24990889e-01f, -1.73788369e-01f, 7.65614025e-03f, 4.40836661e-02f, -1.59137491e-02f,
  -7.43080229e-02f, -8.62486381e-03f, -1.22674815e-01f, 1.08898848e-01f, 1.37697324e-01f, -6.94186613e-02f, 1.22793004e-01f, -9.05943755e-03f, 1.41452104e-02f, 1.29394740e-01f,
  4.11930121e-02f, 7.90373236e-02f, 7.18521029e-02f, 7.92203769e-02f, 1.21768191e-01f, 1.64624110e-01f, 4.24563475e-02f, -7.52017200e-02f, 1.48354307e-01f, 9.11306888e-02f,
  -6.04115389e-02f, -1.87960025e-02f, -3.01426165e-02f, -6.97222212e-03f, 1.63726858e-03f, -9.27512720e-02f, 6.24714745e-03f, 6.21525124e-02f, 2.62345131e-02f, 1.14113405e-01f,
  -6.12660944e-02f, 6.02925476e-03f, 6.74480498e-02f, 5.84365427e-02f, 2.37409901e-02f, 5.45597263e-02f, 1.59907341e-02f, 6.41619861e-02f, -6.88014850e-02f, 5.28766848e-02f,
  -3.44229937e-02f, 3.67214382e-02f, -4.86308783e-02f, 5.90166124e-03f, 4.36679786e-03f, 1.13664456e-02f, 2.28170911e-03f, -5.61604798e-02f, -4.01112288e-02f, 1.53893784e-01f,
  -4.42183577e-02f, -1.78550482e-02f, -6.77287355e-02f, -8.05010321e-04f, -3.63824889e-02f, -5.00652902e-02f, 3.72016951e-02f, -9.29266587e-02f, 6.49184585e-02f, 2.55441889e-02f,
  5.67834340e-02f, 9.64239687e-02f, -4.25500125e-02f, -1.35242399e-02f, 1.02442525e-01f, -5.61455451e-02f, 1.10073918e-02f, 2.82512214e-02f, 2.82370970e-02f, -2.14513013e-04f,
  -1.67981423e-02f, 1.74044687e-02f, 3.04238591e-02f, 7.53589571e-02f, 6.70083463e-02f, 7.00632483e-02f, 1.34739149e-02f, 9.24290624e-04f, -9.54896864e-03f, -8.83676931e-02f,
  -1.06394999e-02f, -1.62989851e-02f, 4.52245474e-02f, 1.04938179e-01f, 7.99227878e-02f, 1.89285967e-02f, 8.10119733e-02f, 3.27039137e-02f, -2.18706988e-02f, -4.87779342e-02f,
  -3.01872008e-02f, 3.37337330e-02f, -4.50549014e-02f, 8.66903290e-02f, -5.38518317e-02f, -3.17093506e-02f, 1.57190338e-02f, -6.49007130e-03f, -2.95684263e-02f, -4.76887412e-02f,
  7.42501579e-03f, -5.56237362e-02f, -1.22744148e-03f, 5.81638478e-02f, 8.19809884e-02f, 4.45976201e-03f, 9.16252136e-02f, 5.59137901e-03f, -2.94862874e-02f, 8.17297250e-02f,
  -7.42170773e-03f, 2.08939333e-02f, 6.80887923e-02f, 1.59629419e-01f, 3.59123088e-02f, -2.81795502e-01f, -1.51074961e-01f, 9.85206291e-03f, 7.20870346e-02f, -4.28963639e-02f,
  -4.56903800e-02f, -7.73208085e-05f, -1.51051089e-01f, -1.61554269e-03f, -4.02036488e-01f, -1.52361363e-01f, -1.59095347e-01f, -1.23493470e-01f, -1.08933160e-02f, 7.90241882e-02f,
  -1.40919998e-01f, 9.25925747e-03f, -1.42721862e-01f, 3.20287086e-02f, 1.80932000e-01f, 1.06345423e-01f, 1.86433760e-03f, 6.85929656e-02f, -8.24880973e-02f, 7.58437216e-02f,
  8.54616836e-02f, 1.21811859e-01f, -4.41070199e-02f, -2.91883312e-02f, 6.44348040e-02f, -7.23138303e-02f, -8.14437121e-03f, 3.22500467e-02f, 4.16507758e-03f, 5.67952842e-02f,
  2.49743927e-02f, -1.60262883e-02f, -7.67276064e-02f, 1.32904463e-02f, 1.24936499e-01f, 6.49713501e-02f, 6.74171448e-02f, 1.44030154e-01f, 1.07221276e-01f, -9.08118486e-02f,
  5.85931540e-02f, -1.19601553e-02f, 5.84799759e-02f, -4.12475504e-02f, -2.17132121e-02f, 2.46424004e-02f, -2.21239664e-02f, -4.72058989e-02f, 6.40038252e-02f, -7.44888633e-02f,
  5.73233180e-02f, 1.30655151e-02f, 5.09249717e-02f, -4.69650701e-02f, 7.21944645e-02f, 2.49868724e-02f, 6.31117895e-02f, 4.73538190e-02f, -1.70415938e-02f, 9.58400406e-03f,
  3.48703302e-02f, 2.24812087e-02f, -5.68399876e-02f, 1.06471457e-01f, -5.29943332e-02f, 7.69908652e-02f, -7.00026751e-02f, -8.71536210e-02f, 9.88916904e-02f, 2.25489046e-02f,
  1.14068903e-01f, 8.92214254e-02f, 3.29603814e-02f, 3.61560546e-02f, -4.59429361e-02f, -3.19290236e-02f, 3.43250595e-02f, 6.74447715e-02f, 7.37340078e-02f, -1.20354677e-02f,
  -3.41054648e-02f, -3.00079603e-02f, -3.83035392e-02f, 9.82151404e-02f, -3.66515778e-02f, 2.17358745e-03f, -2.44257562e-02f, 2.89917085e-02f, 1.78002492e-02f, 3.52508156e-03f,
  -5.27628511e-02f, 8.33146572e-02f, -1.73709504e-02f, 6.15851283e-02f, -2.00862084e-02f, -1.15199769e-02f, -6.19050264e-02f, 1.59478784e-02f, 3.19011733e-02f, -3.95898707e-02f,
  1.38650239e-01f, 1.50760589e-02f, 6.33440614e-02f, -6.04748465e-02f, -1.44654764e-02f, -2.53190356e-03f, 1.08766509e-02f, 6.61161356e-03f, 7.40928799e-02f, -1.19983971e-01f,
  -8.08411315e-02f, 9.91620719e-02f, 1.30123988e-01f, 1.88638896e-01f, -1.02073252e-01f, -1.42735124e-01f, -2.35783651e-01f, -1.25773117e-01f, 1.30927414e-01f, -2.13512614e-01f,
  -7.24387094e-02f, 3.14560086e-02f, -9.71284881e-02f, -1.22322775e-02f, 7.92649239e-02f, 1.58624247e-01f, 3.42940576e-02f, -8.29164684e-02f, 1.86500937e-01f, 5.87838143e-02f,
  1.64439589e-01f, -4.21381965e-02f, 5.92772514e-02f, -7.84506649e-02f, -3.58181670e-02f, 7.19494224e-02f, 2.03150660e-01f, 1.57128591e-02f, 1.25490278e-01f, -6.72516003e-02f,
  2.47102305e-02f, 1.48179978e-01f, 1.11327209e-01f, 1.19067937e-01f, -1.02746924e-02f, -1.82142287e-01f, -1.56015456e-02f, -5.08520342e-02f, -2.87974849e-02f, -1.59198735e-02f,
  -3.20764743e-02f, -4.14255038e-02f, -4.75492887e-02f, -5.05686812e-02f, -1.20236225e-01f, -2.01780684e-02f, -5.27896499e-03f, -5.04545011e-02f, 1.46416590e-01f, 9.79495328e-03f,
  1.17839538e-01f, 5.70990071e-02f, -1.67683922e-02f, 7.91547596e-02f, 3.95419225e-02f, -9.36259404e-02f, -1.00729987e-01f, 5.98147102e-02f, 9.11634266e-02f, 6.05064631e-02f,
  -4.81208554e-03f, -2.25797202e-02f, -5.70292398e-02f, -8.68805405e-03f, 3.03112566e-02f, 9.24650505e-02f, -9.05082524e-02f, -2.64742579e-02f, -4.53951173e-02f, -7.62658045e-02f,
  1.45384844e-03f, -3.37578133e-02f, 3.74799520e-02f, -4.33581062e-02f, -4.91207745e-03f, -6.08050823e-03f, 1.41458698e-02f, 2.24489644e-02f, 5.07115424e-02f, -8.26992560e-03f,
  4.07871902e-02f, -8.32211748e-02f, 4.93412428e-02f, 7.42422640e-02f, 2.39836555e-02f, -3.21865082e-03f, 2.70363949e-02f, 5.43767326e-02f, 4.12733220e-02f, 2.20279880e-02f,
  6.99052215e-02f, 1.19495571e-01f, 1.17455043e-01f, 1.01294748e-01f, 2.63907108e-02f, -3.18960510e-02f, 3.28256786e-02f, 4.61991616e-02f, 9.40303802e-02f, -4.54757996e-02f,
  -3.74266729e-02f, -3.16576846e-02f, 1.31075099e-01f, 2.37664506e-02f, 4.60253656e-02f, 5.38049340e-02f, 1.17548853e-01f, 4.11705077e-02f, 2.76445504e-02f, 3.58822122e-02f,
  7.87684843e-02f, -1.08395815e-01f, -4.31845523e-02f, -6.43574893e-02f, -5.08807860e-02f, 5.33195026e-02f, 1.47220842e-03f, 2.41664983e-03f, 5.47276288e-02f, -7.04244450e-02f,
  1.99378908e-01f, -1.70050655e-04f, -2.04136029e-01f, -2.76640981e-01f, 2.78883409e-02f, 2.66984552e-01f, 1.28654569e-01f, -1.87842958e-02f, -2.93096960e-01f, 2.41861224e-01f,
  2.43850440e-01f, -1.73055112e-01f, 2.12252010e-02f, -4.49075773e-02f, -4.72072512e-02f, -5.15901446e-02f, 1.59915075e-01f, 8.77852067e-02f, -1.49909362e-01f, 5.42667359e-02f,
  -4.85111438e-02f, 1.86293185e-01f, -1.03002757e-01f, 1.19792126e-01f, 1.25417888e-01f, 5.36037460e-02f, 5.66861480e-02f, -1.03241488e-01f, 1.49246439e-01f, 3.33519466e-02f,
  1.50214091e-01f, 8.72870758e-02f, -9.01528522e-02f, 2.55417656e-02f, 1.10833205e-01f, 1.04249746e-01f, 5.50980791e-02f, -6.88453615e-02f, -1.11445785e-02f, -2.44854297e-02f,
  8.16872567e-02f, -1.25564426e-01f, -6.11382648e-02f, 1.43441642e-02f, -1.70409173e-01f, -9.27598625e-02f, -8.39447603e-02f, -1.29056782e-01f, -6.19090796e-02f, 9.46601182e-02f,
  -3.48529778e-02f, -1.62425891e-01f, -1.36774480e-01f, -9.43948701e-02f, 3.09861870e-03f, 9.76096559e-03f, 6.30256906e-03f, -9.77578089e-02f, -5.02831489e-03f, -3.18665290e-03f,
  -3.28946859e-02f, 4.04920951e-02f, -3.69890407e-02f, -1.07795134e-01f, -3.28361196e-03f, 3.02565899e-02f, 4.78706555e-03f, -1.88662075e-02f, -1.14890486e-02f, -8.95654261e-02f,
  3.36964987e-02f, 2.24131066e-02f, 9.18766484e-02f, -3.56707387e-02f, -6.15395792e-03f, -5.60068116e-02f, 8.78854617e-02f, -4.46427288e-03f, -9.12093818e-02f, 2.63777492e-03f,
  1.72056183e-02f, 3.75264026e-02f, 6.03374839e-02f, 5.59078008e-02f, 4.33666958e-03f, -5.76236881e-02f, -8.07841346e-02f, 6.78634122e-02f, 3.14569287e-02f, -6.71000453e-03f,
  9.38946903e-02f, 1.97456822e-01f, 4.28176438e-03f, -3.09896786e-02f, 2.11611073e-02f, 5.33929504e-02f, -2.96064131e-02f, 8.65467861e-02f, 4.45696805e-03f, 7.58642610e-03f,
  3.86872180e-02f, -4.03054729e-02f, 8.20948780e-02f, -5.82961105e-02f, -6.43807873e-02f, 7.82854557e-02f, 8.38503093e-02f, -7.83550888e-02f, 1.11064032e-01f, -2.37140767e-02f,
  6.89491257e-02f, 8.74005556e-02f, -3.38202342e-02f, 3.17926630e-02f, 5.83712012e-02f, 1.29467741e-01f, 2.93522738e-02f, -9.16110352e-02f, 3.56966667e-02f, -1.31865919e-01f,
  4.06969100e-01f, 1.37613729e-01f, 3.22285891e-01f, 2.05896109e-01f, 5.25167435e-02f, -6.92197084e-02f, 7.47786695e-03f, 3.86440307e-02f, 1.15264863e-01f, 2.62660850e-02f,
  -1.29154220e-01f, 1.69148982e-01f, -1.57988861e-01f, 1.58102944e-01f, -2.25073755e-01f, -1.35343388e-01f, -4.81745265e-02f, 8.84240121e-02f, 4.52413484e-02f, 7.22770318e-02f,
  3.13321203e-02f, -2.65213072e-01f, -4.98868674e-02f, -1.83711931e-01f, 1.25590146e-01f, 9.43044573e-02f, -2.87747949e-01f, -8.02747607e-02f, -7.92879611e-02f, -2.78475612e-01f,
  9.60875824e-02f, 6.72273280e-04f, 9.94253233e-02f, 3.76221538e-02f, 3.84853296e-02f, 4.36264463e-02f, -8.53017718e-02f, -7.53503218e-02f, 1.00365005e-01f, 5.56263514e-03f,
  8.74053128e-03f, 1.71177983e-02f, 7.05453306e-02f, -1.05984695e-02f, -3.00136637e-02f, 6.69117942e-02f, 2.09478840e-01f, 9.47834104e-02f, 2.13213209e-02f, 1.07896447e-01f,
  1.22482590e-01f, 1.81846991e-01f, 1.41795546e-01f, 3.99288833e-02f, 8.14131871e-02f, 4.77528721e-02f, -2.77925022e-02f, 1.68068334e-01f, 1.19912483e-01f, -1.41433515e-02f,
  9.21604969e-03f, -1.76058355e-04f, -4.11752351e-02f, 3.92093621e-02f, -3.54672074e-02f, -1.92966498e-02f, 2.88176294e-02f, -1.53518468e-01f, -5.60198538e-02f, -5.81151322e-02f,
  -6.92603737e-03f, -1.48019521e-02f, -8.93127918e-03f, 6.78419769e-02f, 7.27965087e-02f, 4.34516631e-02f, -7.39342794e-02f, 2.81495545e-02f, 7.42542222e-02f, -5.37513867e-02f,
  -8.73708054e-02f, -5.80106676e-02f, 3.39336880e-02f, -4.94601652e-02f, -2.93596257e-02f, 4.72128466e-02f, 6.16640672e-02f, -6.62224484e-05f, 8.56804550e-02f, -4.02460843e-02f,
  -1.20941661e-01f, -2.50664681e-01f, 8.17905590e-02f, -1.05820980e-03f, -5.42212054e-02f, -1.59164239e-03f, -7.16958195e-02f, 4.40617017e-02f, -1.06755495e-01f, 3.12833749e-02f,
  8.67402256e-02f, -4.87641245e-02f, -4.99562696e-02f, -2.90902629e-02f, 1.50252262e-03f, -1.91023320e-01f, -1.14322260e-01f, -7.97013268e-02f, 5.56849584e-04f, -3.27598266e-02f,
  2.75870599e-03f, -9.56610292e-02f, 8.06237012e-03f, 4.08708118e-02f, 1.73484441e-02f, 5.30121790e-04f, 7.16417953e-02f, 7.28374496e-02f, -1.23561800e-01f, 4.70256209e-02f,
  1.65732816e-01f, -9.76854041e-02f, -1.49998292e-01f, 2.05042288e-01f, 2.33248204e-01f, 1.93890691e-01f, 1.53884307e-01f, 2.23081291e-01f, 3.32142889e-01f, -5.43720871e-02f,
  -5.39163388e-02f, -3.63663658e-02f, -1.74065053e-01f, 5.72353881e-03f, 1.54737771e-01f, -1.45589635e-01f, 2.74504751e-01f, -5.54145351e-02f, 5.11573739e-02f, 7.01909363e-02f,
  1.10810786e-01f, 1.44947484e-01f, -1.47915557e-01f, -1.55552141e-02f, -1.21594444e-01f, -2.19184421e-02f, -5.80469444e-02f, -1.72225654e-01f, -1.34848669e-01f, 8.28924775e-03f,
  4.01776060e-02f, 5.26309125e-02f, -3.68086882e-02f, -2.54872683e-02f, -7.94533417e-02f, 5.55255599e-02f, -2.12726407e-02f, -1.07445329e-01f, 2.90280115e-03f, -1.91330165e-02f,
  -2.27311905e-02f, 4.59317602e-02f, 4.22364958e-02f, 7.25270286e-02f, 5.92390411e-02f, -2.46486384e-02f, -6.27771392e-02f, 2.78480332e-02f, 1.25639196e-02f, -7.45884627e-02f,
  2.84542143e-02f, -1.08163908e-01f, -1.58697134e-03f, 5.94351813e-02f, -4.91840132e-02f, 5.61689027e-02f, 3.52208875e-02f, -9.52274129e-02f, -5.68186268e-02f, 3.25443856e-02f,
  4.96596657e-02f, 6.59247711e-02f, -1.11367768e-02f, 1.89189166e-02f, 6.21320773e-03f, -6.33912580e-03f, 6.76820874e-02f, -5.01323259e-03f, 6.75342083e-02f, -5.43526374e-02f,
  -5.10759391e-02f, 2.20260723e-03f, 3.23595814e-02f, -3.19714323e-02f, 2.75507551e-02f, 8.68233442e-02f, 1.52401160e-02f, -1.34563118e-01f, 5.40331863e-02f, -7.98350293e-03f,
  7.78689282e-03f, -7.04814028e-03f, -5.24636321e-02f, -2.91998219e-02f, 4.77182083e-02f, -8.97181500e-03f, -5.74838184e-02f, -7.09280372e-02f, -4.65767272e-02f, 1.08338427e-02f,
  8.64002854e-03f, 1.46716163e-01f, 3.14555243e-02f, -4.10491377e-02f, -1.51148615e-02f, -3.20097022e-02f, 5.41206002e-02f, -3.90184931e-02f, -3.56363393e-02f, 5.93315996e-02f,
  8.96200910e-02f, -2.73067541e-02f, -3.19187827e-02f, -3.65117453e-02f, -2.33003218e-02f, 2.17363122e-03f, -8.09230730e-02f, 1.93259753e-02f, 5.38779702e-03f, -4.79630195e-02f,
  1.50828091e-02f, 9.70859155e-02f, -5.65750413e-02f, 1.10352105e-02f, 3.93042825e-02f, -1.15248255e-01f, -1.72816613e-03f, 9.76227317e-03f, -6.37531281e-02f, -2.82828808e-02f,
  2.02417582e-01f, -2.66827404e-01f, -2.55359441e-01f, -1.40209943e-01f, 2.29361784e-02f, 1.75707608e-01f, 8.29186216e-02f, -2.32307330e-01f, -3.39642465e-01f, -1.72820725e-02f,
  1.33675352e-01f, -8.40879455e-02f, 1.84567496e-02f, -2.05522582e-01f, -9.88883227e-02f, -1.69649616e-01f, -1.52257904e-02f, -3.44296433e-02f, -1.88679829e-01f, 1.54884681e-01f,
  -8.66033882e-02f, -2.91183703e-02f, -1.30922928e-01f, -1.96360908e-02f, -4.74111810e-02f, 3.64281870e-02f, 2.22030640e-01f, 1.47482052e-01f, 6.36744825e-03f, -4.87546958e-02f,
  1.04928546e-01f, -7.04745250e-03f, -4.64326441e-02f, -5.99791035e-02f, 1.05587371e-01f, 6.57058284e-02f, 1.48407444e-01f, 2.17847824e-02f, -1.19689610e-02f, -6.10044412e-02f,
  -3.76385339e-02f, -1.15382038e-01f, -1.08212814e-01f, -3.22313160e-02f, -2.59170700e-02f, -1.49118200e-01f, 8.83217994e-03f, -9.13934559e-02f, -8.73618945e-02f, -4.27232683e-02f,
  -6.52281716e-02f, -1.02256298e-01f, 1.46220597e-02f, 1.91230851e-03f, -1.57940704e-02f, -8.83962810e-02f, 8.64796266e-02f, 7.72876665e-02f, -3.01957205e-02f, -3.39327119e-02f,
  3.14646401e-02f, 7.74612427e-02f, 7.39097446e-02f, -1.47935882e-01f, 1.03938607e-02f, -3.27535309e-02f, -6.33005500e-02f, 2.02441718e-02f, 3.76812443e-02f, 1.41295400e-02f,
  -2.26729014e-03f, -2.62559503e-02f, -1.06306942e-02f, 6.46971092e-02f, 6.35755435e-02f, 1.16441473e-02f, -2.78273621e-03f, 6.67640120e-02f, 1.66861229e-02f, 9.36431997e-03f,
  1.92576591e-02f, -4.59947065e-02f, 3.66160949e-03f, 9.49437469e-02f, -3.83986458e-02f, 1.36943847e-01f, -1.46028981e-01f, 1.43935578e-02f, -7.12511614e-02f, 6.18707314e-02f,
  8.84131249e-03f, 1.17686041e-01f, -1.75057985e-02f, -5.78495264e-02f, 1.51373977e-02f, -4.49810661e-02f, -9.74949822e-02f, 4.73425761e-02f, -3.72095555e-02f, -2.58233957e-02f,
  7.79793710e-02f, 1.04439124e-01f, -2.37803515e-02f, -2.92402636e-02f, -6.97220564e-02f, 5.03692776e-02f, -2.13583224e-02f, 1.04974210e-01f, 4.12264019e-02f, 4.62754145e-02f,
  -2.99945511e-02f, 1.24864094e-01f, -3.35284621e-02f, -1.90420207e-02f, 2.26418376e-02f, 1.10812530e-01f, 7.91446865e-02f, 8.77257064e-03f, -4.67934720e-02f, -1.41733751e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  2.64401250e-02f, 1.13449469e-01f, 1.27718121e-01f, 1.50327990e-03f, -1.46886511e-02f, 1.76352635e-02f, 4.01969887e-02f, 1.04594722e-01f, 8.35191831e-02f, 1.16826430e-01f,
  -1.30043495e-02f, 1.54449955e-01f, 1.07567675e-01f, 5.94319962e-02f, 1.63043782e-01f, -7.87861496e-02f, -1.28278257e-02f, 4.29823250e-02f, 5.25461212e-02f, 1.32897124e-01f,
  1.89871728e-01f, 1.38703752e-02f, 1.70615703e-01f, 7.45971277e-02f, 1.49843335e-01f, 1.73705444e-01f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -6.41088486e-02f, -1.87086090e-01f, -1.11485645e-01f, -4.91000451e-02f, -1.13762645e-02f, -1.27331242e-01f, -5.96508533e-02f, -4.14116085e-02f, 4.58560362e-02f, 7.54820853e-02f,
  -1.37299478e-01f, 1.27350986e-01f, -5.07473350e-02f, -5.34378439e-02f, -1.02536418e-01f, 4.58522961e-02f, 1.19170398e-01f, 8.19719359e-02f, -1.11903466e-01f, 1.08300196e-02f,
  4.59524505e-02f, 1.72029942e-01f, 5.07148728e-02f, 2.44409263e-01f, 1.31388605e-01f, -6.36693537e-02f, 1.13590688e-01f, 2.78606676e-02f, -1.94089040e-01f, -1.18676171e-01f,
  1.24591984e-01f, -1.59621432e-01f, 1.22999296e-01f, -7.96266496e-02f, 9.96522829e-02f, 9.40899178e-02f, 1.22867741e-01f, 2.43392870e-01f, 1.31047010e-01f, 8.96119922e-02f,
  2.41928492e-02f, 2.00622529e-01f, -5.33986762e-02f, -6.03630915e-02f, 7.64644071e-02f, -1.29495740e-01f, 5.38988151e-02f, 2.77775843e-02f, 9.43257660e-02f, 3.92110050e-02f,
  -1.68039843e-01f, -2.68011659e-01f, -4.67753597e-02f, 1.65127680e-01f, -7.57247955e-02f, -2.07759626e-02f, 2.05276653e-01f, 1.29395932e-01f, 3.77211608e-02f, -7.61223957e-02f,
  -1.28035605e-01f, 9.85767618e-02f, 1.88473925e-01f, 3.27875167e-02f, 1.16451323e-01f, 1.76009193e-01f, 1.05311140e-01f, 1.07385134e-02f, 4.79151914e-03f, -9.15557072e-02f,
  1.07704766e-01f, -1.00490712e-01f, -7.41543025e-02f, 1.04609676e-01f, 4.48395964e-03f, 2.78924443e-02f, 5.75360171e-02f, 1.75484374e-01f, -4.95778695e-02f, 1.23095796e-01f,
  6.55960813e-02f, -7.80980811e-02f, -1.47659287e-01f, 2.09250182e-01f, 2.18406599e-02f, 2.69836277e-01f, -2.62910295e-02f, 1.74410462e-01f, 2.86425769e-01f, 2.73067364e-03f,
  2.53039282e-02f, -3.83646414e-02f, -1.03340790e-01f, 8.00509453e-02f, 1.89358935e-01f, -1.01856880e-01f, 1.18487887e-01f, -3.07613015e-02f, -6.91782609e-02f, 1.88382342e-01f,
  1.90178156e-01f, 7.20319971e-02f, -3.02432347e-02f, 1.73249379e-01f, 4.88137901e-02f, 1.61667258e-01f, -1.42942697e-01f, 2.59480178e-02f, -1.54805392e-01f, 1.08831674e-02f,
  9.71699357e-02f, -1.40318289e-01f, -1.21972270e-01f, 4.07854356e-02f, -4.62987237e-02f, -1.64804474e-01f, -1.21331729e-01f, -1.68246865e-01f, -1.39509082e-01f, -1.25530466e-01f,
  1.44641548e-01f, -7.31604770e-02f, -1.46266088e-01f, -1.43857405e-01f, 1.41290084e-01f, 2.98249245e-01f, 6.47174492e-02f, 1.28945351e-01f, -4.60655279e-02f, 5.57447225e-02f,
  1.01405695e-01f, 4.10115272e-02f, -5.04302531e-02f, 7.32765254e-03f, 5.28171472e-02f, -1.13741547e-01f, 5.16782403e-02f, 6.94018528e-02f, -7.72753283e-02f, 6.59029260e-02f,
  1.32544160e-01f, 3.73429880e-02f, 4.60364223e-02f, -2.40630675e-02f, 7.49202222e-02f, 1.60678402e-01f, -5.77787496e-02f, -8.80853534e-02f, 3.39300707e-02f, -3.64624001e-02f,
  5.22453599e-02f, 1.57220766e-01f, 1.19049206e-01f, -4.60137911e-02f, 2.59362131e-01f, 2.79826839e-02f, -1.70719400e-01f, 2.34829858e-01f, 2.77985692e-01f, 2.23327875e-02f,
  -5.02362847e-02f, 4.89813723e-02f, -1.54739339e-02f, 8.20702687e-02f, 9.66505110e-02f, 8.79355520e-03f, 2.86833346e-02f, -8.05045143e-02f, 6.26520589e-02f, 2.03070149e-01f,
  -1.30117640e-01f, -6.18413510e-03f, -1.16786718e-01f, -5.88190109e-02f, 1.71132252e-01f, -1.47639722e-01f, -1.41564801e-01f, 9.49272290e-02f, 1.49052963e-02f, -1.58334032e-01f,
  -1.52778119e-01f, 2.54464000e-02f, 7.83535838e-02f, -1.13366947e-01f, 4.14738990e-02f, 1.13268346e-01f, -6.66216612e-02f, -1.88476220e-01f, -3.56136896e-02f, 6.28713295e-02f,
  2.35729218e-01f, 9.54205245e-02f, 1.76071256e-01f, 3.64676416e-02f, -9.60415453e-02f, 1.12381846e-01f, 5.57625964e-02f, -1.04597434e-01f, 1.58888236e-01f, -7.36974031e-02f,
  -1.40365303e-01f, -6.45786449e-02f, 5.46627901e-02f, 4.62087989e-02f, 8.91664438e-03f, 5.67261577e-02f, 5.19843064e-02f, 4.77081947e-02f, 6.67486712e-02f, 1.47889942e-01f,
  -4.44652047e-03f, -3.76463905e-02f, 2.37242773e-01f, 1.16240405e-01f, 1.37354568e-01f, 1.74720168e-01f, -1.41044827e-02f, -9.67198163e-02f, -1.35650128e-01f, 2.43661195e-01f,
  -8.63450319e-02f, -1.07889988e-01f, 1.63495183e-01f, 2.99336314e-02f, 6.08168878e-02f, -7.86907822e-02f, 1.88607827e-01f, -1.96393028e-01f, -8.62786826e-03f, 2.65871376e-01f,
  1.18867315e-01f, 3.50586697e-03f, 1.09015338e-01f, -1.06659010e-01f, -1.28823444e-01f, 1.04534537e-01f, 5.86822331e-02f, -3.45324501e-02f, 1.23421237e-01f, -1.03575900e-01f,
  1.92040488e-01f, -8.27547535e-02f, 2.35120878e-02f, -2.91400611e-01f, 2.14464456e-01f, 2.31266156e-01f, 7.45413378e-02f, -2.12528687e-02f, 9.05305892e-02f, 3.86391431e-02f,
  -1.74221247e-02f, 1.77214921e-01f, 1.01581961e-01f, -9.68969315e-02f, 8.91590677e-03f, 1.09678343e-01f, 7.37655535e-02f, 1.83297768e-01f, -5.71560785e-02f, -5.66724539e-02f,
  -1.29828840e-01f, 3.87348384e-02f, 9.38303676e-03f, 1.06083587e-01f, -9.34481770e-02f, -6.36540502e-02f, -5.54190809e-03f, 8.50330889e-02f, -8.26005638e-03f, 3.99114974e-02f,
  -4.46890816e-02f, 7.55476281e-02f, -1.35064185e-01f, 1.55808821e-01f, 4.57250588e-02f, 1.35702088e-01f, 1.84891745e-01f, -5.65428846e-02f, 4.50144336e-03f, 1.36760473e-01f,
  7.58491531e-02f, -9.30028781e-02f, 8.21364745e-02f, 7.76823163e-02f, -5.13140038e-02f, 1.67615384e-01f, 2.32473791e-01f, -1.58755794e-01f, -1.63172379e-01f, 1.41289681e-01f,
  4.50614057e-02f, -1.98460612e-02f, 9.47801620e-02f, 1.71794847e-01f, 2.21038327e-01f, 9.34089124e-02f, -3.85998264e-02f, 1.17364591e-02f, -2.52780944e-01f, -6.73259236e-03f,
  -2.10477799e-01f, -1.15660325e-01f, 8.25004186e-03f, -1.46568671e-01f, -1.99951604e-01f, -1.31339533e-03f, 4.71993349e-02f, -1.11118980e-01f, 1.80653170e-01f, 1.14086822e-01f,
  2.89639562e-01f, -1.52016833e-01f, 1.60532072e-01f, 1.48574850e-02f, 3.91743407e-02f, 8.68000537e-02f, 1.33032024e-01f, 1.02253534e-01f, 1.38270214e-01f, 2.05505431e-01f,
  -3.33276275e-03f, -4.80888225e-02f, -3.06390803e-02f, 2.49814484e-02f, -8.32915213e-03f, 1.26344070e-01f, -1.17853932e-01f, -3.01288348e-02f, 1.20446637e-01f, 3.67500335e-02f,
  -6.94943964e-02f, -1.95750669e-02f, 6.50181919e-02f, 9.35694054e-02f, -9.50829685e-02f, 7.66300634e-02f, -1.53168008e-01f, 1.62814230e-01f, -6.29535243e-02f, 9.57536846e-02f,
  9.66646597e-02f, -6.10770285e-02f, 1.35363966e-01f, 8.81825909e-02f, 9.64335054e-02f, 3.23473737e-02f, 1.76569879e-01f, -6.77605346e-02f, 7.47226402e-02f, -8.12031031e-02f,
  1.41151160e-01f, -9.94949415e-02f, 4.62458804e-02f, 1.27934739e-01f, 4.72567454e-02f, -9.40850228e-02f, 1.00793734e-01f, 1.01881251e-01f, -1.67993233e-02f, 6.18944056e-02f,
  -3.26264761e-02f, -1.87419374e-02f, -9.28008705e-02f, 8.66646767e-02f, 2.84120832e-02f, -1.28061607e-01f, -3.78923826e-02f, -2.94322819e-01f, -2.12350413e-01f, 7.16436356e-02f,
  -1.40278369e-01f, -1.25878185e-01f, 1.27537832e-01f, 1.78084910e-01f, 1.44761324e-01f, -1.13491438e-01f, 1.51693135e-01f, 4.78636920e-02f, 3.46127562e-02f, -3.14180702e-02f,
  7.48722553e-02f, -8.15245230e-03f, 2.51372606e-01f, 3.22997198e-02f, -5.24894102e-04f, 3.23364846e-02f, -7.02548325e-02f, -7.28254840e-02f, 1.42997885e-02f, 8.17238539e-02f,
  -9.62675959e-02f, -1.08092502e-01f, -1.66167729e-02f, 1.20424621e-01f, -1.47851869e-01f, 3.48016955e-02f, -7.44548067e-02f, 8.50283355e-02f, -2.21289042e-03f, 6.05363771e-02f,
  -4.96625761e-03f, -9.83650312e-02f, -7.50568435e-02f, -1.93873083e-03f, 1.21548161e-01f, 2.35841766e-01f, -1.90898985e-01f, 1.60338953e-01f, 4.26618494e-02f, 7.27060288e-02f,
  -3.03756222e-02f, -1.34634957e-01f, -1.72648430e-01f, 1.15477808e-01f, -4.09350283e-02f, -1.37509167e-01f, 6.30235812e-03f, -9.89179760e-02f, 3.59938182e-02f, -3.30909714e-02f,
  1.28875881e-01f, 3.00397217e-01f, 1.52732700e-01f, 8.79539773e-02f, -1.01641573e-01f, 1.58790592e-03f, -2.17258632e-01f, 2.09507823e-01f, -9.84940398e-03f, 8.61865282e-02f,
  2.87510514e-01f, 9.26699117e-02f, 8.51335526e-02f, 8.63166228e-02f, -6.27107173e-02f, -2.80753136e-01f, -2.49503091e-01f, 9.11855325e-02f, -2.35451628e-02f, 4.56123352e-02f,
  1.15592465e-01f, -2.94721238e-02f, 9.32197087e-04f, -2.47167885e-01f, 1.39162108e-01f, -6.69164211e-02f, -1.25238691e-02f, 9.06835198e-02f, 2.55600251e-02f, 9.33274105e-02f,
  1.02142543e-01f, -1.86634064e-02f, -1.27071425e-01f, 3.41888964e-02f, 4.26012138e-03f, -1.00460559e-01f, 1.57547250e-01f, 1.08974233e-01f, 7.44587928e-02f, -4.25939150e-02f,
  -6.33828864e-02f, 1.23435698e-01f, -2.51180194e-02f, 1.00997962e-01f, -6.97946772e-02f, 5.89536801e-02f, 4.16280404e-02f, 2.04940736e-01f, -1.53845131e-01f, 7.30010197e-02f,
  2.32401013e-01f, 1.06552385e-01f, 9.77679063e-03f, 7.44068623e-02f, 6.79753572e-02f, -2.03221560e-01f, -9.93477702e-02f, 1.52382389e-01f, 2.09661454e-01f, -1.17513023e-01f,
  -1.40492707e-01f, -6.06473461e-02f, -8.64006230e-04f, 1.64465845e-01f, 3.77687514e-02f, -9.84572545e-02f, -1.00877449e-01f, -2.34214872e-01f, 7.92451352e-02f, 6.39041513e-02f,
  -7.84775689e-02f, 7.31616616e-02f, -1.08473212e-01f, -2.96330303e-02f, 1.21378459e-01f, -1.69184595e-01f, -1.67509541e-01f, 3.48874629e-02f, -1.80939063e-02f, 1.91659050e-03f,
  3.52562703e-02f, 9.37256813e-02f, 1.28206149e-01f, 4.39969674e-02f, 1.00491829e-01f, 8.86541605e-02f, -1.05995029e-01f, -5.80359735e-02f, 4.36681435e-02f, 1.32538050e-01f,
  2.04678774e-01f, -7.42426142e-02f, -4.63550463e-02f, 2.89430976e-01f, 3.98250557e-02f, 6.18864484e-02f, 9.39038470e-02f, -4.57888618e-02f, -8.14515632e-03f, -1.44770026e-01f,
  -9.22554657e-02f, 1.74277976e-01f, -6.56915009e-02f, 2.13370204e-01f, 2.86336634e-02f, -7.19446540e-02f, 6.11697994e-02f, -2.03396957e-02f, 1.26163825e-01f, 8.06586817e-02f,
  -2.62127835e-02f, -1.23975977e-01f, 5.46225766e-03f, 1.83859188e-02f, -2.31720954e-01f, -5.20865545e-02f, 7.85734877e-02f, 2.52253652e-01f, 7.88443312e-02f, 1.66821070e-02f,
  -3.50247957e-02f, 2.77841985e-01f, 3.85858491e-02f, -3.22356299e-02f, 5.73147945e-02f, -1.10033199e-01f, -2.86944602e-02f, -8.55973642e-03f, 2.00774670e-01f, 1.80012867e-01f,
  2.85996255e-02f, 1.88304305e-01f, -5.32710738e-02f, 4.55860049e-02f, 3.75195779e-02f, 6.31380221e-03f, -1.50329798e-01f, 6.03342354e-02f, 2.34614477e-01f, -1.61047533e-01f,
  1.11791819e-01f, -5.27424924e-02f, -5.21653425e-03f, -1.80472568e-01f, -1.95289284e-01f, -1.38646632e-01f, 9.21848938e-02f, -7.86083564e-02f, 1.05079256e-01f, -1.07585981e-01f,
  1.09963953e-01f, -2.44108319e-01f, -4.75536920e-02f, -2.90831625e-02f, -1.27011597e-01f, 1.58290103e-01f, -1.93131939e-01f, -2.22585127e-02f, 1.07139070e-02f, -9.27447677e-02f,
  9.48457345e-02f, 9.58340466e-02f, -3.12205702e-02f, -3.99578921e-02f, -5.92345297e-02f, -5.67039698e-02f, 1.30759671e-01f, -1.14348069e-01f, 5.63566536e-02f, -4.32235971e-02f,
  5.10515906e-02f, 2.31278390e-02f, -1.15261227e-01f, -1.00138165e-01f, 7.89479539e-03f, -1.76807344e-01f, -1.56331569e-01f, -3.23477089e-01f, 5.77019267e-02f, -2.93352187e-01f,
  1.72683463e-01f, 8.36880878e-02f, 5.49821071e-02f, -2.75618080e-02f, 2.63301134e-01f, 4.32781279e-02f, -2.08807178e-02f, 2.20528856e-01f, -8.53348300e-02f, 2.12158799e-01f,
  -1.13609523e-01f, 9.66152400e-02f, -2.48162597e-01f, -1.65023625e-01f, -1.30316958e-01f, 1.16342343e-01f, 6.97683692e-02f, -3.49317379e-02f, -3.66615020e-02f, -1.71399340e-01f,
  -3.25154737e-02f, 2.72597582e-03f, -1.19595975e-01f, -2.06135541e-01f, -1.12929143e-01f, 4.72671613e-02f, 9.93941873e-02f, 1.36642918e-01f, -4.49339077e-02f, -8.32705200e-02f,
  8.07396919e-02f, -2.11150542e-01f, -9.83624905e-02f, -1.51902497e-01f, -3.83272059e-02f, 5.00684930e-03f, 1.59999833e-01f, -3.97184901e-02f, -1.93414405e-01f, -7.22024888e-02f,
  -6.35167584e-02f, 1.17410459e-01f, 2.75934804e-02f, -9.99850258e-02f, -4.52344975e-04f, 3.22969742e-02f, 1.14085674e-01f, 9.71123800e-02f, -4.02132384e-02f, 9.52515900e-02f,
  1.64834753e-01f, -6.39555184e-03f, -8.24293122e-02f, 1.22062422e-01f, -4.91348691e-02f, 2.16820743e-02f, 1.03936844e-01f, 1.00500666e-01f, 6.25383034e-02f, -1.30732819e-01f,
  -9.35629755e-02f, 5.66852838e-02f, -1.73361152e-02f, -4.50894684e-02f, 1.13410175e-01f, -9.91469622e-02f, -7.15295747e-02f, -7.81544596e-02f, -1.22691020e-01f, 5.63650541e-02f,
  -7.61018991e-02f, -7.11550191e-02f, 1.73141852e-01f, -1.30198076e-01f, -1.28058106e-01f, 1.41787350e-01f, 2.74699152e-01f, -1.84686512e-01f, -1.52011111e-01f, 9.03835893e-02f,
  -2.00379387e-01f, 4.84709516e-02f, 3.14236045e-01f, 7.47300079e-03f, 7.56594986e-02f, 1.09283656e-01f, 8.37243162e-03f, 1.67905703e-01f, 1.48729905e-01f, 4.15743664e-02f,
  9.54178348e-02f, 6.44751936e-02f, 4.57312055e-02f, -1.92841873e-01f, -2.34330282e-01f, 1.03673495e-01f, 1.20337427e-01f, -1.77747160e-01f, -9.07130465e-02f, -1.05336957e-01f,
  8.70422572e-02f, 1.64828882e-01f, -1.18564852e-01f, 1.46155566e-01f, 2.76392233e-02f, -2.83907771e-01f, -5.08852638e-02f, -5.54665215e-02f, -5.67193553e-02f, 3.56371589e-02f,
  -8.98738280e-02f, 5.94686344e-02f, 2.08852384e-02f, -1.11854844e-01f, -1.74819797e-01f, 5.85699789e-02f, 4.70919833e-02f, 5.18090166e-02f, 5.95132969e-02f, 3.19507048e-02f,
  -1.46790043e-01f, 7.85338581e-02f, 7.29115754e-02f, 1.01057976e-01f, 9.01484564e-02f, 1.14326477e-02f, 2.41711006e-01f, 1.43722683e-01f, -7.08146766e-03f, 3.80438343e-02f,
  1.17269948e-01f, -2.22053844e-02f, 1.90845788e-01f, 2.70034168e-02f, 3.43998820e-02f, 7.92485625e-02f, -1.44957796e-01f, 2.13851966e-02f, 1.35269448e-01f, -1.35252386e-01f,
  -2.24232391e-01f, 1.47902921e-01f, 1.55743822e-01f, -1.69896305e-01f, 3.26637149e-01f, 1.50090754e-01f, -2.48113438e-01f, 1.91711225e-02f, -3.11488248e-02f, -1.85535610e-01f,
  5.32401167e-02f, -2.59987324e-01f, -2.81758104e-02f, 1.08372673e-01f, -1.59347653e-01f, -3.76140326e-02f, 2.17155457e-01f, 3.58669311e-02f, 7.48026744e-02f, -4.58076373e-02f,
  1.20120749e-01f, 4.33690250e-02f, -8.25418234e-02f, 1.07884400e-01f, -6.66026399e-02f, 1.53562069e-01f, 2.95034617e-01f, -6.42383918e-02f, -8.82536322e-02f, -1.52546898e-01f,
  -6.21219091e-02f, 3.99513356e-03f, 7.48813227e-02f, 1.10211149e-01f, -1.28234059e-01f, -1.23179026e-01f, 1.39932439e-01f, 2.52562072e-02f, 5.50694205e-02f, 1.83553379e-02f,
  -6.62826300e-02f, -2.01209299e-02f, 1.07608855e-01f, 1.48857310e-01f, 4.47725505e-02f, 9.50406343e-02f, 5.24735190e-02f, 9.78983566e-02f, -1.93676203e-01f, 2.02779323e-01f,
  4.25314531e-02f, 1.95323259e-01f, -4.04232703e-02f, -1.56032080e-02f, 1.00158095e-01f, -1.31077647e-01f, -1.79408625e-01f, 1.54782504e-01f, -1.05105065e-01f, -8.13561119e-03f,
  -1.66166544e-01f, -5.50848134e-02f, -1.77557811e-01f, -1.54995352e-01f, -5.34310788e-02f, -1.05049260e-01f, 1.23350948e-01f, -1.56078622e-01f, -6.93914946e-03f, 2.49035489e-02f,
  -9.83598828e-02f, 5.06232269e-02f, -1.21942215e-01f, -1.70209602e-01f, 1.78213999e-01f, 1.79716811e-01f, 5.89977875e-02f, -4.83764410e-02f, -7.66340941e-02f, -9.02429745e-02f,
  -7.34209865e-02f, 1.52872831e-01f, 9.69808027e-02f, 2.48653993e-01f, 1.90533370e-01f, 8.68195947e-03f, 3.76859903e-02f, -1.31228998e-01f, 1.51983008e-01f, -1.29656345e-01f,
  1.74487740e-01f, 1.55474782e-01f, -8.07151720e-02f, 1.29629971e-05f, -2.04743519e-01f, -1.32186756e-01f, 1.10232644e-02f, -9.08801705e-02f, 1.79501437e-02f, -1.22916326e-01f,
  4.91321385e-02f, -1.70649234e-02f, -2.24542290e-01f, 1.13872990e-01f, -1.45882323e-01f, 3.86717506e-02f, -2.48112250e-02f, -7.73456544e-02f, -1.44538268e-01f, 1.22845396e-01f,
  -3.73687781e-02f, -2.19327305e-02f, 3.02165329e-01f, 6.75652921e-02f, -2.30227739e-01f, 4.35865074e-02f, 5.77303283e-02f, -8.74238759e-02f, -3.30129042e-02f, 1.02231450e-01f,
  9.94946882e-02f, 3.81581485e-02f, -5.76599352e-02f, -1.41454414e-01f, 1.79270282e-01f, -2.95575768e-01f, 1.64393097e-01f, -1.08011924e-01f, 7.57039711e-02f, 3.67510885e-01f,
  1.15154684e-01f, 2.00777024e-01f, -2.49989539e-01f, 1.30445808e-01f, 9.35508981e-02f, -1.06385089e-01f, 1.85040280e-01f, -1.62033290e-02f, 1.91350281e-01f, 9.08210427e-02f,
  3.08748595e-02f, -4.36390713e-02f, -1.12807997e-01f, -2.09276393e-01f, -1.29468322e-01f, 1.05440982e-01f, 9.75054651e-02f, 1.04323052e-01f, 2.10970953e-01f, 1.61669537e-01f,
  2.00810120e-01f, -1.85554698e-02f, -1.64292485e-01f, 2.13037387e-01f, 6.56975880e-02f, 1.35310486e-01f, 1.02367885e-01f, -2.72676051e-02f, -7.87549168e-02f, 7.44658038e-02f,
  -5.10181002e-02f, -7.48772547e-02f, 1.04477927e-01f, 1.15564741e-01f, -4.76806797e-02f, 1.26363024e-01f, 5.12696505e-02f, -9.62413698e-02f, -8.55849534e-02f, -1.43338248e-01f,
  1.16203412e-01f, -1.95434205e-02f, -4.37738411e-02f, -1.07629023e-01f, 1.17803551e-01f, -6.84634894e-02f, 1.67481884e-01f, -1.92888841e-01f, -1.49149895e-01f, -1.96940586e-01f,
  3.66067067e-02f, -9.06955376e-02f, -2.24998742e-02f, 2.06992492e-01f, 7.20357224e-02f, -1.06511913e-01f, 4.63655517e-02f, 1.35932922e-01f, 1.40406564e-01f, 2.45310932e-01f,
  6.49736449e-02f, 6.94836080e-02f, -5.69503270e-02f, -2.73723342e-02f, -1.41159832e-01f, 4.79425378e-02f, -1.75678860e-02f, -7.99240693e-02f, 3.00496686e-02f, -2.10251048e-01f,
  9.98986736e-02f, 1.98360935e-01f, -2.46887490e-01f, -2.32229143e-01f, -1.97590068e-01f, -5.77835701e-02f, 2.27459922e-01f, 1.66514039e-01f, -4.22525294e-02f, -1.16493694e-01f,
  -2.92696189e-02f, -1.15592733e-01f, -1.68394506e-01f, -7.66537338e-02f, 1.62748247e-01f, 9.08748992e-03f, 7.33299926e-03f, 1.67332873e-01f, -7.60131776e-02f, 9.90136117e-02f,
  9.12154280e-03f, -7.34083429e-02f, -4.03088098e-03f, -2.48389114e-02f, -1.04669183e-01f, 9.46256965e-02f, 1.41933292e-01f, 1.47579387e-01f, 1.46518484e-01f, 1.73288152e-01f,
  -2.41402965e-02f, -4.80569638e-02f, 7.81894028e-02f, -3.79336178e-02f, -1.44527070e-02f, 4.92873900e-02f, -3.69851477e-02f, 1.04007646e-01f, 4.68286723e-02f, -6.44613653e-02f,
  9.02022794e-02f, -2.41483331e-01f, 2.88673341e-02f, 1.62633911e-01f, 1.55603588e-01f, -1.58866644e-01f, 1.70811474e-01f, 1.01072103e-01f, 6.98868260e-02f, 9.91977379e-02f,
  2.84976512e-01f, 2.13213041e-01f, 6.37117624e-02f, 2.13926300e-01f, 6.78981394e-02f, -1.70882773e-02f, -8.75347704e-02f, -2.43494287e-01f, -3.83621417e-02f, 2.30776340e-01f,
  1.25982657e-01f, 2.84756958e-01f, 6.45906925e-02f, -1.69058949e-01f, -1.25353457e-02f, -6.42525777e-02f, -8.28841329e-02f, -3.07939947e-01f, -2.26727158e-01f, -9.83760133e-03f,
  1.04008161e-01f, 1.96772054e-01f, 2.13089928e-01f, 6.22186698e-02f, 6.63959458e-02f, -7.68372938e-02f, 5.08250436e-04f, 1.56965449e-01f, 2.39052638e-01f, -2.41994634e-02f,
  1.35099784e-01f, 2.60855049e-01f, 3.61208528e-01f, -8.88408795e-02f, -7.42967278e-02f, -3.90962660e-02f, 8.58211666e-02f, 1.83638670e-02f, -1.21456854e-01f, 3.36137116e-02f,
  -1.23653688e-01f, -2.23489106e-02f, -9.44596827e-02f, 8.34891573e-02f, -7.61287510e-02f, 1.47357449e-01f, 7.03832554e-03f, 1.28259689e-01f, 6.20568581e-02f, -2.90777218e-02f,
  -1.06155008e-01f, 1.63467273e-01f, -6.77484795e-02f, -1.23820506e-01f, 1.68848857e-01f, -1.92766041e-01f, 4.78530116e-02f, 1.19283997e-01f, 1.74046054e-01f, -7.25771338e-02f,
  9.81782526e-02f, 1.59814149e-01f, 1.69593215e-01f, 8.16169232e-02f, 2.96119750e-01f, -6.66420022e-03f, 3.03536475e-01f, 9.51103419e-02f, 2.06769049e-01f, -1.90656468e-01f,
  -9.73487049e-02f, 1.74717531e-02f, 1.82081595e-01f, 2.71254718e-01f, -1.10967100e-01f, 5.54518253e-02f, -1.45260468e-01f, 7.78295193e-03f, 1.13535963e-01f, 4.44127731e-02f,
  2.41539590e-02f, -1.74388945e-01f, -1.27141699e-01f, -1.30401120e-01f, 9.99245793e-02f, -3.38242352e-01f, 1.83654562e-01f, -3.74318846e-02f, 1.92357793e-01f, -2.16422796e-01f,
  4.07717861e-02f, 7.75789246e-02f, 2.95195788e-01f, -1.64162919e-01f, 1.47164136e-01f, 1.81447640e-01f, 2.66178042e-01f, 3.52540910e-02f, -1.97958946e-01f, -1.85807005e-01f,
  1.09020527e-02f, -1.37513369e-01f, 1.80152863e-01f, 2.41277087e-02f, -1.91834256e-01f, 8.69383197e-03f, 3.53206135e-03f, 2.00679968e-03f, 9.69653502e-02f, 9.02251974e-02f,
  -5.21501340e-03f, -1.19140044e-01f, 3.72739695e-02f, -1.09269470e-01f, -8.57904330e-02f, 4.85495152e-03f, -4.05406542e-02f, -1.63515314e-01f, 5.03240712e-02f, -2.32816011e-01f,
  -1.60828590e-01f, -4.25114669e-02f, 9.27156731e-02f, 3.72380376e-01f, 2.37655222e-01f, 1.09322481e-01f, 7.52032176e-02f, 9.74101648e-02f, -1.63870230e-02f, 2.61036932e-01f,
  -9.57054868e-02f, 4.08241805e-03f, 1.08470663e-01f, -1.24480076e-01f, -1.80826619e-01f, -1.61093980e-01f, 1.49988636e-01f, 1.26389116e-01f, -7.32544437e-02f, 2.07241371e-01f,
  -1.27311215e-01f, -7.89681897e-02f, -1.78610951e-01f, 1.15479164e-01f, 8.92205387e-02f, -1.46964848e-01f, -1.84710667e-01f, -7.86777958e-02f, -4.65645484e-04f, -8.46934393e-02f,
  -2.21048653e-01f, 3.40610862e-01f, 1.93350255e-01f, -2.65107006e-01f, -2.15446010e-01f, 1.75287258e-02f, -3.44198868e-02f, -2.26550549e-01f, 3.86496857e-02f, -2.38827974e-01f,
  -1.02548875e-01f, 5.98925911e-02f, -9.05000567e-02f, 1.41006023e-01f, 3.28607671e-02f, 1.31160428e-03f, 1.19399659e-01f, -5.06074354e-02f, -8.92511234e-02f, -3.37018557e-02f,
  1.01948723e-01f, 3.31540108e-02f, -2.62856893e-02f, 9.38615128e-02f, -6.93076849e-02f, -1.84387073e-01f, -1.13346964e-01f, 7.31964335e-02f, 1.08483605e-01f, -1.34919390e-01f,
  -4.71414402e-02f, -2.02079922e-01f, -1.48334742e-01f, -1.05852276e-01f, -9.32066366e-02f, -2.56689161e-01f, -1.93878442e-01f, 4.99669798e-02f, -1.82103172e-01f, -1.56560034e-01f,
  -5.45885116e-02f, 1.88831925e-01f, -2.19543085e-01f, 2.28036627e-01f, 6.28931820e-02f, 1.47949522e-02f, -2.07743436e-01f, -1.23238638e-01f, -2.53396761e-02f, -2.66196933e-02f,
  -1.32092744e-01f, 8.70980024e-02f, -1.19624645e-01f, 7.42387027e-02f, -9.78897065e-02f, -1.15118146e-01f, 3.38769257e-02f, 1.15188554e-01f, -7.97146093e-03f, -8.65791067e-02f,
  1.88344605e-02f, -1.70561761e-01f, 2.26115435e-01f, 1.97764069e-01f, -1.56671673e-01f, -1.69210777e-01f, -8.15689266e-02f, 3.11817303e-02f, -1.60780936e-01f, -2.69433171e-01f,
  -1.49321984e-02f, -1.09163299e-01f, 1.19369268e-01f, -1.89958543e-01f, -4.45946306e-02f, 1.04308940e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  3.82642262e-02f, -3.67189683e-02f, 3.02884020e-02f, 1.48008570e-01f, 3.08491532e-02f, 3.02503891e-02f, 1.12760529e-01f, 9.40658972e-02f, 3.65984216e-02f, 3.43657238e-03f,
  2.45291412e-01f, 3.09800301e-02f, 1.39443085e-01f, 8.93227477e-03f, 1.06396660e-01f, 1.48486197e-01f, 2.12417729e-02f, 2.36175761e-01f, 3.49755920e-02f, -8.76836404e-02f,
  -4.22773068e-04f, -1.52885363e-01f, 1.85558900e-01f, -1.96328983e-01f, 1.61881134e-01f, -2.06771996e-02f, -5.96619844e-02f, 2.69680649e-01f, 6.37682751e-02f, -2.01283798e-01f,
  -3.22373286e-02f, 6.77667139e-03f, 1.61502928e-01f, 2.67396331e-01f, 4.48071398e-02f, 1.42557696e-01f, -6.45919703e-03f, -7.13935718e-02f, -1.59600332e-01f, 1.53876796e-01f,
  1.04725592e-01f, 1.06495023e-02f, 2.64947172e-02f, -8.53050426e-02f, -1.01795889e-01f, 2.26195738e-01f, -1.78389534e-01f, -1.42984048e-01f, -1.50455788e-01f, 2.15922773e-01f,
  2.86041409e-01f, 1.60614029e-01f, 1.97578996e-01f, 5.80700859e-02f, -4.78514396e-02f, -4.70161065e-02f, -1.85677096e-01f, 1.13813199e-01f, 1.68138519e-01f, 1.18001364e-01f,
  1.47552833e-01f, 1.27860174e-01f, -1.06582090e-01f, 1.89855531e-01f, -6.64691180e-02f, 2.49531627e-01f, 3.59497825e-03f, 9.18233469e-02f, -5.95341343e-03f, 7.98961446e-02f,
  1.15534939e-01f, 1.72645554e-01f, -2.21562590e-02f, -5.91974668e-02f, 1.14846833e-01f, -5.81923462e-02f, 4.69030663e-02f, -7.16709942e-02f, 9.09854099e-02f, -2.79999785e-02f,
  -1.41612710e-02f, 1.59604236e-01f, -1.30103761e-03f, -2.24575251e-01f, 9.80714187e-02f, 6.47934228e-02f, -1.81574851e-01f, -1.31187633e-01f, -1.77401081e-01f, -8.41536224e-02f,
  -1.39903516e-01f, -1.28787905e-01f, -3.10763512e-02f, 1.69269964e-01f, -2.15003356e-01f, -6.32689521e-02f, 1.02096004e-03f, -1.93193614e-01f, -5.89205995e-02f, -9.26530957e-02f,
  1.13438085e-01f, 5.94635010e-02f, -4.39586341e-02f, 2.31999010e-01f, -7.07582831e-02f, 1.16247334e-01f, 2.95417488e-01f, -5.07486425e-02f, 2.73301303e-01f, 2.60977089e-01f,
  8.69580060e-02f, 1.06695361e-01f, 1.08736843e-01f, 4.15064069e-03f, 1.20336123e-01f, 2.65462603e-02f, -1.22740045e-01f, -2.07241639e-01f, -2.42493480e-01f, 1.55008063e-01f,
  1.99080855e-01f, -3.73180248e-02f, 2.93530412e-02f, 8.35244805e-02f, 4.25518602e-02f, 1.98130161e-02f, -8.42981692e-03f, -4.54163551e-02f, 1.04703762e-01f, 1.66617006e-01f,
  4.32092361e-02f, 6.43220246e-02f, -2.08249241e-02f, 5.89377731e-02f, 1.29021689e-01f, -1.25589883e-02f, 3.43484357e-02f, 1.72873959e-01f, 1.94889098e-01f, 8.93106759e-02f,
  -1.56231886e-02f, 1.17120087e-01f, 9.04013366e-02f, 1.03571631e-01f, 1.32772282e-01f, 2.42412746e-01f, 1.42473370e-01f, 1.10652305e-01f, -5.48812700e-03f, 2.34520525e-01f,
  1.46350443e-01f, 1.23715900e-01f, 1.58649579e-01f, -1.92311779e-01f, -1.88915804e-02f, 3.65932733e-02f, -9.93627310e-02f, -5.64640649e-02f, 1.29988268e-01f, -2.63964653e-01f,
  -1.33088022e-01f, 8.60059634e-02f, -7.34605119e-02f, 2.69240230e-01f, 1.82605475e-01f, -2.19778180e-01f, -1.62980303e-01f, 5.14003821e-02f, 2.87997052e-02f, -5.75455949e-02f,
  -1.43004715e-01f, 1.23473637e-01f, -1.30680621e-01f, -9.08532366e-02f, 6.80019036e-02f, -9.75155272e-03f, 5.12269512e-02f, 2.13341713e-01f, -1.55668100e-02f, 5.42216487e-02f,
  2.33252287e-01f, -5.41767515e-02f, 4.81885709e-02f, 1.79750305e-02f, -1.16260774e-01f, -2.10455991e-03f, -1.35385469e-01f, -7.78340027e-02f, 1.77081972e-01f, 2.49428764e-01f,
  2.61420041e-01f, 5.44284508e-02f, 2.36347407e-01f, -6.70783892e-02f, 1.08554721e-01f, 1.28383636e-01f, 1.40922680e-01f, 1.54184490e-01f, -1.36420527e-03f, 1.27877891e-01f,
  1.42194152e-01f, 1.12060495e-01f, 9.09855440e-02f, 1.09217130e-01f, 1.86597481e-01f, 1.86809614e-01f, 1.68259755e-01f, 1.07285138e-02f, 7.93387145e-02f, 6.23102635e-02f,
  2.37521335e-01f, 2.21238270e-01f, -1.03258900e-01f, 1.45975202e-01f, 2.85173923e-01f, 1.83387339e-01f, 1.80609733e-01f, 2.92527918e-02f, -7.86103681e-03f, -2.09854290e-01f,
  -1.67753085e-01f, 1.36590615e-01f, 1.59251571e-01f, -2.70064361e-03f, -9.72909629e-02f, 1.90993920e-01f, -4.31298986e-02f, 9.61747468e-02f, -1.16893537e-01f, -1.50786534e-01f,
  -6.08279221e-02f, -4.19068485e-02f, 2.95120060e-01f, 2.48985872e-01f, 5.16069122e-02f, 3.62505764e-02f, -1.02867763e-02f, 2.81729586e-02f, -5.99694904e-03f, -1.38351507e-02f,
  -1.08376220e-01f, 1.80831388e-01f, 1.06496327e-01f, 2.54423827e-01f, 1.57987282e-01f, 2.15592012e-01f, 1.56902790e-01f, 5.21375276e-02f, 1.66651487e-01f, 1.51027748e-02f,
  2.09236965e-01f, 7.72612542e-02f, 7.06080869e-02f, 3.43132168e-01f, 2.43608728e-01f, 5.52751087e-02f, 9.74648818e-02f, 3.58258814e-01f, 2.48286322e-01f, 6.63517192e-02f,
  3.55477966e-02f, 6.72554672e-02f, 2.10721776e-01f, 1.13826126e-01f, -3.29835042e-02f, 1.61023773e-02f, 4.07868624e-02f, 2.39965573e-01f, 6.54148459e-02f, 1.19971626e-01f,
  6.32185861e-02f, 2.78552510e-02f, 6.02830835e-02f, 7.52783492e-02f, -7.26372972e-02f, -3.18101235e-03f, -1.39676388e-02f, -3.60362325e-03f, -1.66441109e-02f, -9.96512473e-02f,
  1.16406098e-01f, -8.24397579e-02f, 6.76024705e-02f, 5.39460592e-02f, -5.85028119e-02f, -1.03443734e-01f, -1.09093133e-02f, -1.60384834e-01f, -4.03690077e-02f, 2.40317076e-01f,
  -7.55821466e-02f, 1.64188951e-01f, 1.95940048e-01f, 5.30584045e-02f, -5.21678589e-02f, 2.57843226e-01f, -9.69728231e-02f, 5.97031154e-02f, 4.85515743e-02f, 1.51025951e-01f,
  3.07443738e-02f, 9.55377817e-02f, 1.55819105e-02f, -1.68551683e-01f, -7.46448487e-02f, 7.17329085e-02f, 4.10140231e-02f, 1.96763039e-01f, 1.71860754e-01f, -1.59125239e-01f,
  -1.85855255e-02f, 2.62082946e-02f, -5.87708727e-02f, 4.48847935e-02f, 1.84107963e-02f, 7.63058066e-02f, -3.26966643e-02f, 2.77454466e-01f, -8.66189748e-02f, 7.53698125e-02f,
  2.46941790e-01f, -3.06443055e-03f, -7.68872276e-02f, 1.09357864e-01f, 1.03031859e-01f, -1.16908759e-01f, 1.61463603e-01f, 1.02018997e-01f, 1.70312479e-01f, 3.52118276e-02f,
  1.63461357e-01f, 6.47569001e-02f, 4.22328226e-02f, 9.30129290e-02f, 1.83416083e-01f, -2.17389446e-02f, 2.65488625e-01f, 2.16571838e-01f, 3.04986201e-02f, 1.21706948e-01f,
  6.11648196e-03f, 2.47816458e-01f, -6.61345124e-02f, 2.39156887e-01f, -1.68181285e-01f, -4.16174471e-01f, -3.65145504e-02f, 6.99182525e-02f, -2.60334104e-01f, -2.73777712e-02f,
  1.16977096e-01f, -2.05752239e-01f, -6.11189567e-02f, 2.22113281e-02f, -1.45297483e-01f, 3.17405611e-02f, 2.00934291e-01f, -1.53361320e-01f, 3.33071128e-02f, 4.20095660e-02f,
  -8.68068933e-02f, -1.74191922e-01f, 1.00963816e-01f, 6.95407689e-02f, 2.86296517e-01f, 6.83909431e-02f, 5.26444912e-02f, 2.54809469e-01f, 5.56275435e-02f, 9.04212743e-02f,
  -3.65778524e-03f, 6.77712932e-02f, 1.52407825e-01f, -2.87666500e-01f, -1.88715562e-01f, 2.84910589e-01f, 9.64999348e-02f, 4.44553941e-02f, -3.95054743e-02f, 2.37959668e-01f,
  -4.45253178e-02f, 3.55711244e-02f, 3.30774397e-01f, -2.53487844e-02f, -1.12536572e-01f, 1.90612093e-01f, 6.55575544e-02f, 1.11395665e-01f, 5.64568043e-02f, -3.84098403e-02f,
  7.56452903e-02f, 3.90786417e-02f, -8.16909894e-02f, 2.51369625e-01f, -1.44668192e-01f, 1.07293814e-01f, 7.25877658e-02f, 3.81441787e-02f, 2.39065140e-02f, 2.21260995e-01f,
  1.67550147e-01f, 8.48600641e-03f, 2.33616419e-02f, -5.99860176e-02f, 7.93509260e-02f, 3.96732986e-02f, -2.22877085e-01f, -9.33732390e-02f, 1.64087877e-01f, 2.36090273e-02f,
  1.02515265e-01f, 7.82440230e-02f, -3.16869766e-02f, 2.75517076e-01f, 1.46432444e-01f, -1.05955459e-01f, 1.52208135e-01f, -2.21045464e-02f, -4.34486680e-02f, -3.20067368e-02f,
  1.69624954e-01f, 2.70660907e-01f, 1.54769033e-01f, 2.29783818e-01f, -1.28266752e-01f, 2.43437633e-01f, -1.36452049e-01f, -9.06310007e-02f, -2.17247121e-02f, 6.32871166e-02f,
  6.21285737e-02f, 2.07696166e-02f, -1.51955406e-03f, -5.75122721e-02f, -7.98975006e-02f, -1.44980773e-01f, -1.08212844e-01f, -8.18026215e-02f, 7.63305724e-02f, -2.11807817e-01f,
  1.68784901e-01f, -8.74229819e-02f, 8.27211440e-02f, -3.22377421e-02f, 4.73562703e-02f, 1.90366730e-01f, -1.66808814e-02f, 1.68096021e-01f, 2.11646020e-01f, -9.78374109e-03f,
  1.39060095e-01f, 2.25735009e-02f, -8.05138499e-02f, 1.90225676e-01f, -1.73609667e-02f, -2.33725719e-02f, 1.62946627e-01f, 7.31465444e-02f, 1.93397179e-01f, -1.70431912e-01f,
  1.31330965e-02f, 5.55021353e-02f, 1.87007710e-01f, 1.63144749e-02f, -1.89956781e-02f, -5.24963289e-02f, 2.03121319e-01f, 9.89897326e-02f, -2.18027934e-01f, -9.99192148e-02f,
  2.47521147e-01f, -2.19866320e-01f, -1.59584716e-01f, 8.89427289e-02f, -2.13824049e-01f, -2.29055770e-02f, 1.75152346e-01f, -1.28722712e-01f, -2.68974394e-01f, 2.02805251e-01f,
  -1.68366313e-01f, 7.50845075e-02f, -1.09871402e-01f, -5.11550158e-02f, -1.63740605e-01f, -1.04271695e-01f, 2.07794905e-02f, 6.26136810e-02f, 2.85243094e-01f, -1.73849031e-01f,
  1.50414750e-01f, -1.57469019e-01f, 1.83971450e-02f, 2.62004156e-02f, -1.93613455e-01f, 5.21157570e-02f, -6.93086237e-02f, 1.74160063e-01f, 1.72081422e-02f, 3.67082596e-01f,
  1.49865597e-01f, -8.42085481e-02f, -1.60201132e-01f, 1.99814796e-01f, -1.07165389e-01f, -8.06725174e-02f, 8.99193287e-02f, 3.88238467e-02f, 5.05698025e-02f, -1.90865740e-01f,
  1.35264397e-01f, -4.94099930e-02f, 2.77721994e-02f, 5.96475974e-03f, -1.39096648e-01f, 1.62445396e-01f, 1.20226800e-01f, 1.70833752e-01f, 1.52498379e-01f, 9.90960002e-02f,
  8.21268931e-02f, -6.64296821e-02f, 1.38170153e-01f, 1.12074003e-01f, 2.53021419e-01f, -1.39658488e-02f, 2.21908227e-01f, 1.43196106e-01f, -8.51945356e-02f, 1.04604043e-01f,
  2.50148803e-01f, -1.72429997e-02f, 1.78962931e-01f, -1.73630580e-01f, -4.60749352e-03f, 8.52042958e-02f, -9.54803973e-02f, -2.57120907e-01f, -1.25339450e-02f, 3.02941173e-01f,
  1.55142114e-01f, -2.84012854e-01f, -2.93479469e-02f, 2.87375264e-02f, 8.98514464e-02f, 4.48251553e-02f, 2.53723860e-01f, -6.93895966e-02f, -1.24390297e-01f, -1.13962911e-01f,
  3.03339157e-02f, 5.41695505e-02f, 2.62312770e-01f, 6.20804494e-03f, 2.38091741e-02f, 6.57360852e-02f, 3.41503650e-01f, 2.53239572e-01f, 4.26464640e-02f, 3.62953506e-02f,
  2.21342593e-01f, -1.13622723e-02f, -1.40512977e-02f, 2.05374971e-01f, 1.13257073e-01f, 2.62827486e-01f, 2.78589547e-01f, 3.00384820e-01f, -2.88051944e-02f, 2.65007019e-01f,
  1.23692997e-01f, 1.68632135e-01f, 1.77905466e-02f, 4.46527377e-02f, 5.58516160e-02f, -9.28203464e-02f, 1.64359599e-01f, 5.81336766e-02f, 4.43474650e-02f, 1.75043702e-01f,
  5.49533106e-02f, 2.04009768e-02f, 2.36268297e-01f, -5.51902875e-02f, 1.01408735e-01f, 1.41359055e-02f, 1.92384552e-02f, 1.22128479e-01f, -7.78803825e-02f, 1.69972971e-01f,
  -3.31228301e-02f, 1.38003379e-01f, 1.02549478e-01f, -2.92998981e-02f, -1.18694328e-01f, 2.80911718e-02f, -1.01120919e-01f, 2.58189201e-01f, 4.58585508e-02f, -7.21798316e-02f,
  1.39559610e-02f, -6.37401044e-02f, -8.56394693e-03f, -1.43244773e-01f, -1.71342582e-01f, -4.56437357e-02f, 2.97541805e-02f, -2.71056950e-01f, -5.57764322e-02f, -7.01560900e-02f,
  -9.90615115e-02f, 2.93844461e-01f, 3.26937824e-01f, 1.72139749e-01f, 3.46670896e-02f, -4.90633659e-02f, -6.33032918e-02f, 3.03411968e-02f, -4.09785770e-02f, 1.32099763e-01f,
  -1.38696745e-01f, -7.46960193e-02f, 1.11826926e-01f, 1.43122748e-01f, 9.26188305e-02f, 1.58571661e-01f, -1.57350302e-01f, -1.92802958e-02f, 1.11079752e-01f, -8.53465050e-02f,
  -1.86966032e-01f, -3.89734395e-02f, 1.40229270e-01f, 1.23094067e-01f, 7.27889389e-02f, -4.75881137e-02f, 1.27972648e-01f, 2.90967524e-01f, -4.32446785e-03f, 7.89981484e-02f,
  1.27113730e-01f, 7.01567605e-02f, 2.16029271e-01f, 1.35521397e-01f, 1.37846470e-01f, 1.54620856e-01f, 1.08185165e-01f, -1.24985222e-02f, 2.26143673e-01f, 1.24982662e-01f,
  1.40448362e-01f, 1.41869456e-01f, 5.69421463e-02f, 1.01981267e-01f, 1.17767356e-01f, 2.03693464e-01f, 2.40828276e-01f, -9.26502049e-02f, -3.08868997e-02f, 2.28854612e-01f,
  -1.44691914e-01f, 2.07750350e-01f, -4.08133045e-02f, 2.08888516e-01f, -3.17752287e-02f, 9.29390714e-02f, 1.13908015e-02f, -2.05619320e-01f, -2.03679040e-01f, 6.69370592e-02f,
  1.31675437e-01f, -9.16434005e-02f, -1.29804894e-01f, -1.97806761e-01f, -1.11704208e-02f, -3.03870793e-02f, -9.64096412e-02f, -1.00097395e-01f, 1.45846844e-01f, -1.17488921e-01f,
  2.32743710e-01f, 8.61928463e-02f, -1.94096416e-02f, 1.20349126e-02f, -4.18125838e-02f, -9.41803232e-02f, 1.78811640e-01f, 3.09500217e-01f, 2.35541668e-02f, 2.22806126e-01f,
  2.01311074e-02f, -4.76670563e-02f, -1.40769228e-01f, -5.65774441e-02f, 1.94189116e-01f, 2.14812741e-01f, 1.60309151e-01f, 6.12888187e-02f, -2.31898546e-01f, -1.32956654e-01f,
  1.53304920e-01f, -1.33010566e-01f, 3.48655358e-02f, 2.17978492e-01f, 5.27562341e-04f, 2.34593853e-01f, 1.46004826e-01f, 4.68660109e-02f, 1.67397842e-01f, 1.05665304e-01f,
  1.94661021e-01f, 1.14945650e-01f, 1.03826694e-01f, 8.29779208e-02f, 5.06360643e-02f, 1.24797143e-01f, 5.87584414e-02f, 3.67308334e-02f, -2.22046394e-02f, 1.62527133e-02f,
  1.91932082e-01f, -5.56346364e-02f, 4.91766855e-02f, -1.01945385e-01f, 2.76456494e-02f, 1.03762582e-01f, -6.47913739e-02f, -1.05628558e-01f, -8.21207017e-02f, -8.83235931e-02f,
  4.58421037e-02f, 2.03594635e-03f, -2.07373694e-01f, -6.16930611e-02f, -1.27301991e-01f, -8.69015530e-02f, -5.23924567e-02f, 4.22646366e-02f, -2.15226978e-01f, 1.91700347e-02f,
  1.57725483e-01f, -1.44601643e-01f, -6.78573474e-02f, 1.38885662e-01f, -1.71986386e-01f, -2.88631022e-02f, 2.14460358e-01f, 1.77622866e-02f, -1.92981735e-02f, 2.08261371e-01f,
  -9.91435051e-02f, 1.08900808e-01f, 8.54221806e-02f, 1.81615050e-03f, 1.88311949e-01f, 1.06213167e-01f, -9.69418266e-04f, -4.14847583e-02f, -1.69424117e-01f, -2.56311204e-02f,
  1.75213274e-02f, -1.59875542e-01f, 8.82011503e-02f, 7.36664161e-02f, -1.54287706e-03f, -1.11405604e-01f, 2.47193947e-02f, 6.89168349e-02f, 3.84876244e-02f, 2.51414031e-01f,
  5.08157946e-02f, -1.19395519e-03f, 1.61847360e-02f, -9.50704608e-03f, 1.94952235e-01f, -9.00083513e-04f, -3.64489965e-02f, 4.56990302e-02f, 2.13392824e-01f, -2.25403458e-02f,
  1.64432138e-01f, 1.44469887e-01f, 1.53230742e-01f, 3.02997455e-02f, 9.15848166e-02f, 5.03667891e-02f, -8.16282332e-02f, -1.20375454e-01f, -3.64781804e-02f, -1.09956659e-01f,
  -1.18755050e-01f, -2.45509729e-01f, -1.26618147e-01f, 2.31820028e-02f, 3.66134979e-02f, 1.28144681e-01f, 6.76219314e-02f, 2.54977550e-02f, -7.97197372e-02f, -1.09003400e-02f,
  1.73791572e-01f, 2.39732474e-01f, -1.98764458e-01f, 1.02442913e-01f, 2.42190242e-01f, -2.22371310e-01f, -1.97220817e-01f, 1.56444699e-01f, -2.32722908e-01f, 1.15293235e-01f,
  2.44721681e-01f, 7.64678568e-02f, 9.22456756e-02f, 2.35376880e-01f, 7.41258264e-02f, -7.60803446e-02f, 4.13060673e-02f, -1.46049157e-01f, 1.35213494e-01f, 1.10226385e-01f,
  -5.65296821e-02f, -1.45430893e-01f, -1.02063470e-01f, -1.52571246e-01f, -1.85061261e-01f, -2.20542237e-01f, 3.82588767e-02f, -2.43534744e-02f, 4.81895283e-02f, 1.72441795e-01f,
  -2.24439368e-01f, 1.39579967e-01f, -4.18306701e-02f, -7.98035115e-02f, 1.52842375e-02f, 1.12745069e-01f, 1.41557306e-01f, -7.78972358e-02f, -2.93740667e-02f, 1.25913650e-01f,
  -4.13135812e-02f, -2.99158543e-02f, 6.80127665e-02f, 1.28208652e-01f, -3.84529829e-02f, 9.47263837e-02f, 1.26388475e-01f, 8.63669589e-02f, -1.74680993e-01f, 1.22254066e-01f,
  9.47545469e-02f, -1.19179763e-01f, -5.02272956e-02f, -1.58030987e-01f, 3.28827314e-02f, -5.66418953e-02f, 5.70050776e-02f, -1.28373042e-01f, -1.61320493e-01f, 2.20881268e-01f,
  2.37128213e-01f, -2.77211457e-01f, -2.40115479e-01f, 1.20756559e-01f, -3.63481119e-02f, 1.78612605e-01f, 7.55952448e-02f, -3.35071795e-03f, -5.95698468e-02f, 3.91314849e-02f,
  1.33239239e-01f, 1.32156998e-01f, -3.35693248e-02f, 9.67134908e-02f, 1.95754394e-01f, -1.13411054e-01f, 1.38187379e-01f, 2.42772937e-01f, -8.10414106e-02f, 6.81617334e-02f,
  1.34160593e-01f, 3.53307240e-02f, 1.26780808e-01f, 1.37236580e-01f, 1.01113379e-01f, 1.40661791e-01f, -1.37820961e-02f, -1.18166702e-02f, 9.70016979e-03f, 1.12174861e-01f,
  9.73995328e-02f, 2.58109003e-01f, -2.37976089e-02f, 7.16710091e-02f, -1.74253538e-01f, 1.23894505e-01f, 1.96514979e-01f, 1.23047531e-01f, 2.18301848e-01f, 2.07189992e-01f,
  -1.03796292e-02f, 5.31006753e-02f, 2.18655854e-01f, 2.19855621e-01f, 6.66285083e-02f, 2.92830020e-02f, 3.71264629e-02f, 3.28947976e-02f, 2.09680706e-01f, 5.17816730e-02f,
  9.77348015e-02f, 9.28982273e-02f, 2.03979686e-01f, 2.18023449e-01f, 2.86556661e-01f, 1.38369694e-01f, 1.01990879e-01f, -5.94489984e-02f, 2.04775438e-01f, 1.48802027e-01f,
  1.40798748e-01f, -3.80196422e-02f, 8.52712318e-02f, -1.21843658e-01f, 8.21971372e-02f, -3.15599628e-02f, 1.71572715e-01f, 1.98016129e-02f, -7.99396709e-02f, 1.20403148e-01f,
  9.47861758e-04f, 1.39412180e-01f, 2.02575415e-01f, -2.14459151e-01f, 1.57979026e-01f, -1.37865013e-02f, -2.47698631e-02f, 1.47087961e-01f, 1.81029905e-02f, 1.62213042e-01f,
  -1.71728462e-01f, 8.29938948e-02f, 2.56973971e-02f, -1.56487972e-01f, 1.16393315e-02f, 1.51469946e-01f, 7.55296797e-02f, 1.99704468e-01f, 2.34724671e-01f, 6.11278825e-02f,
  1.30464405e-01f, -5.78768849e-02f, 1.80487588e-01f, 1.57262951e-01f, 1.18760273e-01f, 6.88007474e-02f, 7.83298314e-02f, 1.53780073e-01f, 2.98940033e-01f, 3.99145391e-03f,
  3.37089114e-02f, 7.00290874e-02f, 1.23767823e-01f, -8.47354755e-02f, 4.18365523e-02f, 1.47055045e-01f, 1.24900997e-01f, 1.11139104e-01f, -2.27439310e-02f, 1.03407189e-01f,
  1.98253036e-01f, 9.98753402e-03f, 6.18431009e-02f, -9.19865668e-02f, 1.92117587e-01f, 4.37646583e-02f, -4.77677677e-03f, 1.05203494e-01f, 1.50654823e-01f, -1.61807001e-01f,
  1.05805192e-02f, -5.98182566e-02f, -1.20855786e-01f, -2.47895509e-01f, -7.94139057e-02f, 2.45507713e-02f, -9.12052840e-02f, 4.56238873e-02f, -4.45946269e-02f, 4.74732481e-02f,
  -3.14050391e-02f, 1.75879389e-01f, 1.04182493e-02f, 2.75341198e-02f, -1.04442738e-01f, 1.28808349e-01f, -1.05850138e-01f, -1.82446092e-01f, -5.41836955e-02f, 2.21458897e-01f,
  1.72387846e-02f, -5.44198602e-02f, 1.61939323e-01f, -5.96613474e-02f, 1.63130566e-01f, 2.10137650e-01f, 4.37848940e-02f, -3.74968839e-03f, 3.91322002e-02f, 5.88703863e-02f,
  1.70769602e-01f, 2.16820583e-01f, -5.07378057e-02f, -1.30761847e-01f, -9.02773812e-02f, 6.39889389e-02f, -7.95436278e-02f, -1.27931058e-01f, 1.18214995e-01f, -2.51116343e-02f,
  1.39041677e-01f, 5.30931465e-02f, -1.44729748e-01f, 1.45512983e-01f, -1.17031477e-01f, -1.34025872e-01f, 9.41489115e-02f, -8.29924345e-02f, 1.97654635e-01f, 1.22578191e-02f,
  -8.00859854e-02f, 1.67091563e-01f, 1.96073517e-01f, 1.55435026e-01f, -1.84050705e-02f, 1.86644029e-02f, 5.63162602e-02f, 6.90876553e-03f, 4.24391441e-02f, 1.22792795e-02f,
  -7.07082078e-02f, 4.87543829e-02f, 1.80182740e-01f, -2.10698396e-02f, -2.24318966e-01f, -7.16271251e-02f, -3.58415535e-03f, -5.57025895e-02f, 2.17372421e-02f, 2.14505300e-01f,
  1.72221586e-02f, -1.67536616e-01f, 2.18190670e-01f, 2.75819302e-02f, -6.22777753e-02f, 2.60188073e-01f, -7.21374452e-02f, -8.60569924e-02f, 1.27132013e-01f, -1.56924859e-01f,
  -3.36934835e-01f, -3.01062286e-01f, 1.31779108e-02f, -3.85664380e-03f, 2.88983304e-02f, 2.09830459e-02f, 2.51672000e-01f, -1.65944219e-01f, 2.00600356e-01f, 1.08435594e-01f,
  -1.22376969e-02f, 1.11677773e-01f, 1.04324751e-01f, 1.52429752e-02f, 2.70268798e-01f, 1.42114580e-01f, -2.38190070e-01f, 9.77479517e-02f, 2.25467190e-01f, 7.07090348e-02f,
  -6.35523871e-02f, -2.86766682e-02f, 1.20236620e-01f, -1.27446104e-03f, 1.31311536e-01f, -2.05948845e-01f, 4.50378358e-02f, 1.22309826e-01f, -6.22527115e-02f, 1.71272621e-01f,
  3.53109650e-02f, -1.76820196e-02f, 1.98078260e-01f, 2.32112825e-01f, -1.08012883e-03f, 3.84500064e-02f, 2.13158224e-02f, 2.30532050e-01f, 5.03569953e-02f, 9.81323421e-02f,
  1.63430214e-01f, 4.57734540e-02f, 1.89750940e-01f, 1.15397871e-01f, 1.35350183e-01f, 1.62298530e-01f, -7.11123869e-02f, -1.61803037e-01f, -3.26184630e-02f, -2.04496980e-02f,
  -2.16148570e-01f, 4.45354246e-02f, 5.27506471e-02f, 2.40149051e-01f, 1.75486609e-01f, -1.69809550e-01f, -2.81517226e-02f, 2.93649882e-01f, 1.98118404e-01f, -1.37115449e-01f,
  1.03238583e-01f, -2.55469441e-01f, -1.04207039e-01f, -6.76306933e-02f, 1.58874929e-01f, -4.70847972e-02f, 5.71184941e-02f, 1.50525257e-01f, -2.04473630e-01f, 1.93260729e-01f,
  4.31355238e-02f, 5.42786568e-02f, 8.92153978e-02f, 1.48133799e-01f, 2.87732393e-01f, 1.00570701e-01f, 7.85542578e-02f, -1.41377643e-01f, 1.87824756e-01f, -2.05523476e-01f,
  -4.14686836e-02f, 1.48906767e-01f, 7.30138719e-02f, 8.64502341e-02f, 5.54442480e-02f, -3.01960129e-02f, -8.55203811e-03f, -1.18179269e-01f, 1.83801726e-01f, 7.10095838e-02f,
  -2.56979000e-02f, 3.10777396e-01f, 8.33216608e-02f, 3.71861070e-01f, 7.31789917e-02f, 1.15877828e-02f, 1.33716268e-02f, -2.58641224e-02f, 1.22367546e-01f, 5.98426573e-02f,
  -6.50694780e-03f, 1.81057796e-01f, 1.67546242e-01f, 5.94380461e-02f, 1.94377020e-01f, 1.08306214e-01f, 2.08674625e-01f, 2.16561168e-01f, 9.44050550e-02f, 2.05485612e-01f,
  2.94549763e-02f, -8.34361762e-02f, 1.11498907e-01f, 7.95389861e-02f, -1.00863338e-01f, -1.04080930e-01f, 2.37652604e-02f, -1.58170998e-01f, -2.07031056e-01f, -5.33213429e-02f,
  -1.74672052e-01f, 3.01061478e-02f, -5.12362793e-02f, -1.32978752e-01f, 8.70858580e-02f, 6.60906285e-02f, -7.44106025e-02f, 1.77590758e-01f, 2.99291611e-01f, 2.95675192e-02f,
  -8.80840719e-02f, 2.17682287e-01f, -1.05597571e-01f, -1.17936393e-03f, 8.55716169e-02f, 1.70565724e-01f, 1.17611647e-01f, 1.58651173e-01f, -6.50839135e-02f, 3.40070352e-02f,
  1.46723449e-01f, 8.42154101e-02f, -4.36461419e-02f, 1.86214298e-02f, -1.98313408e-02f, -1.89280614e-01f, -1.12494044e-01f, -5.87169528e-02f, -1.40342768e-02f, -1.34205505e-01f,
  -3.69596891e-02f, 1.33614227e-01f, -4.25617583e-03f, 2.38546297e-01f, -6.61869347e-02f, 1.27930328e-01f, 6.75954148e-02f, -1.30826002e-02f, -8.47736970e-02f, 1.66143224e-01f,
  5.90418186e-03f, -1.26413718e-01f, -5.26980944e-02f, 1.22213699e-01f, -9.20381993e-02f, 4.37238365e-02f, -1.45738736e-01f, 1.00389861e-01f, 7.17223156e-03f, 1.27131239e-01f,
  6.83240741e-02f, -3.89015935e-02f, -1.36782631e-01f, 7.80687407e-02f, 1.61474407e-01f, -1.86361134e-01f, 3.49735349e-01f, -7.16263726e-02f, 8.60355794e-02f, 1.46287709e-01f,
  8.11826438e-02f, -1.17573760e-01f, 5.22147529e-02f, 1.63382635e-01f, 1.89910397e-01f, 1.94816329e-02f, -5.00006555e-03f, -6.50918707e-02f, 2.75332391e-01f, 2.80484241e-02f,
  2.12185532e-01f, -5.23141101e-02f, -3.60065289e-02f, 2.98100382e-01f, 1.69294745e-01f, 1.09822355e-01f, -1.90561891e-01f, 2.10425556e-01f, -1.04933374e-01f, -4.67457362e-02f,
  4.07418683e-02f, -3.75516675e-02f, 1.30108163e-01f, -2.09151104e-01f, 1.04039893e-01f, 1.97760761e-03f, -1.24359921e-01f, -1.30527526e-01f, 2.13583440e-01f, 1.02032207e-01f,
  1.05677851e-01f, -6.51749745e-02f, 2.23473638e-01f, 2.07601637e-01f, 9.32348222e-02f, 1.34753093e-01f, -1.80780113e-01f, 3.43382269e-01f, 1.01384304e-01f, -1.68669805e-01f,
  -1.51337370e-01f, 2.81806681e-02f, -1.22010939e-01f, -1.40726060e-01f, -5.69570735e-02f, -1.52768930e-02f, 7.96542410e-03f, -2.44463477e-02f, -1.45530045e-01f, -1.46241888e-01f,
  -9.97097939e-02f, -1.11804150e-01f, 8.86259004e-02f, -8.25774018e-03f, -9.65324268e-02f, 1.64671075e-02f, 3.75174619e-02f, -1.43384680e-01f, 2.69247964e-02f, -3.69230062e-02f,
  -6.16404116e-02f, -7.54733309e-02f, 1.08149499e-01f, -5.29267192e-02f, -1.04537301e-01f, -4.52720448e-02f, -3.48228291e-02f, 3.36576328e-02f, -1.00106876e-02f, 5.10569699e-02f,
  -3.44900191e-02f, 9.31894258e-02f, 3.31312828e-02f, 6.73997849e-02f, 5.81377000e-02f, 2.00013928e-02f, 8.57276991e-02f, 8.85330513e-02f, -1.43409237e-01f, 5.49310707e-02f,
  -9.55610946e-02f, -7.97689036e-02f, -3.87407131e-02f, -1.42154649e-01f, 7.56269842e-02f, -1.15666151e-01f, -7.71022588e-02f, -1.69635173e-02f, -6.20156750e-02f, 7.67520890e-02f,
  -4.16290425e-02f, 6.94319606e-02f, -8.27532485e-02f, 3.30856517e-02f, 6.80022538e-02f, 5.09006856e-03f, -1.23831242e-01f, -4.61310707e-03f, -8.97468403e-02f, -5.23545556e-02f,
  -6.54102415e-02f, 1.21258952e-01f, -3.11426725e-02f, 5.95409721e-02f, 1.36093199e-01f, -2.16649294e-01f, 1.62337571e-01f, -7.70672262e-02f, 3.79756428e-02f, 2.13325750e-02f,
  -4.11366075e-02f, 1.06472157e-01f, 9.33704227e-02f, 2.96043158e-02f, 1.96477130e-01f, 1.69941559e-02f, 1.45451978e-01f, 2.78457589e-02f, 1.70978531e-01f, 4.75479253e-02f,
  -7.02787703e-03f, 3.08320094e-02f, 7.64044598e-02f, 1.97517172e-01f, -3.04903418e-01f, -1.07222772e-03f, 2.23476425e-01f, -1.01370417e-01f, 3.55976559e-02f, 2.05472298e-02f,
  2.29826495e-01f, -3.28496099e-02f, 2.59263348e-02f, -7.40012713e-03f, 2.43622407e-01f, 2.27025628e-01f, -1.51156515e-01f, 1.80634186e-01f, 1.30015239e-01f, 1.53384045e-01f,
  -1.43701732e-01f, -3.86358172e-01f, -8.70481357e-02f, -1.21480949e-01f, 3.73766571e-01f, -7.70809427e-02f, 1.91321652e-02f, -2.04358310e-01f, -4.98547964e-02f, -6.70633391e-02f,
  -5.10951430e-02f, 4.04190905e-02f, 1.71887632e-02f, 2.21151739e-01f, 8.70700702e-02f, 2.93206275e-01f, -1.01284664e-02f, 1.37984678e-01f, 2.42003836e-02f, -3.20534757e-03f,
  -2.03407213e-01f, -6.75148517e-02f, -1.53912574e-01f, 1.26835987e-01f, 2.97244519e-01f, -1.62891284e-01f, 3.99940573e-02f, -9.59953666e-03f, -1.27879724e-01f, -1.11496396e-01f,
  1.29819751e-01f, 1.68792810e-02f, 1.76497772e-02f, -3.32093262e-03f, 3.95677574e-02f, -1.22622162e-01f, 1.79624692e-01f, 1.81916937e-01f, 1.79725185e-01f, -4.25498001e-02f,
  3.14410627e-02f, -6.46345690e-03f, -4.46623750e-02f, -3.64193395e-02f, 1.10835470e-01f, 9.86555219e-03f, 2.89629158e-02f, 5.75759299e-02f, -3.13091248e-01f, -6.72497973e-02f,
  6.16731588e-03f, -1.02667376e-01f, 1.67930201e-01f, 4.23964858e-01f, 2.88790345e-01f, -2.96200484e-01f, 1.22146823e-01f, 2.29951054e-01f, 5.81657179e-02f, 1.85690045e-01f,
  -3.25066485e-02f, -2.42353454e-01f, 1.13503650e-01f, -1.35359928e-01f, -2.75715679e-01f, -1.11891396e-01f, -4.46597897e-02f, 7.93748125e-02f, 5.79908974e-02f, 3.96354273e-02f,
  -1.08303152e-01f, 1.21143669e-01f, -2.94523649e-02f, 1.37724578e-01f, 2.41090849e-01f, 1.17691733e-01f, -1.48293838e-01f, 1.50976628e-01f, 1.42049551e-01f, -9.54071581e-02f,
  -1.79626551e-02f, 2.04793036e-01f, 2.44170576e-01f, -9.69365835e-02f, -1.05891768e-02f, -3.12856473e-02f, -2.01549023e-01f, -1.61610216e-01f, 3.11222613e-01f, -1.57404989e-01f,
  -1.14101410e-01f, 2.91977793e-01f, 1.50835171e-01f, 2.22543836e-01f, 1.78035330e-02f, 6.51715100e-02f, 4.32562865e-02f, 8.67643803e-02f, 8.99329185e-02f, 1.48779318e-01f,
  5.93989007e-02f, 4.79560085e-02f, 7.74551332e-02f, -3.87805142e-02f, 5.70527799e-02f, -1.50072202e-02f, 1.35945722e-01f, 3.96115668e-02f, 2.15326741e-01f, 1.84234783e-01f,
  1.80589721e-01f, -3.21375355e-02f, -1.88143477e-01f, 1.28926009e-01f, -9.59577486e-02f, -4.70400304e-02f, -2.84282625e-01f, -5.80403544e-02f, -6.58449009e-02f, -5.23263104e-02f,
  2.74707265e-02f, -2.26661846e-01f, -3.26341367e-03f, 8.64407197e-02f, -1.17442571e-01f, 1.80884838e-01f, -1.89754218e-01f, 1.05168805e-01f, -1.21488787e-01f, -1.02396876e-01f,
  -1.65088385e-01f, -6.33856729e-02f, -1.54415788e-02f, -8.15214217e-03f, 2.33504772e-01f, -7.49729723e-02f, 2.18387455e-01f, 2.13463753e-01f, -1.22358374e-01f, 2.16046497e-01f,
  2.00756744e-01f, -7.09852353e-02f, -6.08775690e-02f, 2.57205874e-01f, -1.07427083e-01f, -1.23864569e-01f, -2.22644567e-01f, 2.17878684e-01f, 2.38916129e-02f, -5.51943146e-02f,
  -8.24825838e-02f, 1.06054798e-01f, -7.25591481e-02f, -1.10508725e-01f, -1.37169622e-02f, 4.36287709e-02f, -4.81186099e-02f, 1.28010392e-01f, -1.81578308e-01f, -4.01670337e-02f,
  3.68997245e-03f, 6.13578297e-02f, -8.15339461e-02f, 1.71469569e-01f, 1.04030482e-01f, -8.14528093e-02f, -8.33633468e-02f, 7.41929188e-02f, -1.87027808e-02f, 4.84408513e-02f,
  2.16572033e-03f, -7.75953708e-03f, -8.11752155e-02f, 1.38919294e-01f, 6.00876333e-03f, -9.94838253e-02f, 1.00192674e-01f, -9.22642462e-03f, -7.28253648e-02f, 1.27476767e-01f,
  -1.55046955e-01f, -2.50564784e-01f, -1.39966607e-01f, 1.01622291e-01f, 1.55635893e-01f, -1.56679288e-01f, -3.03850528e-02f, 3.61689217e-02f, 1.67005882e-01f, 1.50592555e-03f,
  1.55206352e-01f, -2.23456740e-01f, -4.67333384e-02f, -1.22484103e-01f, -3.07066496e-02f, -1.09831139e-01f, -1.61029324e-01f, -8.76682550e-02f, 2.92083442e-01f, -9.00712684e-02f,
  2.05329075e-01f, 2.64160950e-02f, -1.57568529e-01f, 1.78652465e-01f, 2.18895808e-01f, -1.94750234e-01f, 1.06186494e-01f, 1.43359601e-01f, 1.82135403e-01f, 1.05188200e-02f,
  4.28529158e-02f, 2.88682640e-01f, -1.97022520e-02f, 7.75706917e-02f, 1.77380458e-01f, 2.64889777e-01f, -1.56805709e-01f, -2.45892972e-01f, 1.09092511e-01f, -1.12245515e-01f,
  3.36359560e-01f, 2.34704345e-01f, 2.24346127e-02f, 1.41774133e-01f, -7.00208917e-02f, -6.58922121e-02f, 2.46230125e-01f, 1.47787750e-01f, -4.89799539e-03f, 3.35639007e-02f,
  -2.14573927e-02f, 8.11852142e-02f, 4.86189611e-02f, 8.24146718e-02f, 1.80222154e-01f, 1.58718422e-01f, 5.28178550e-02f, 1.65395156e-01f, -2.69845165e-02f, 2.24677712e-01f,
  1.01086088e-01f, 3.19633216e-01f, 3.27384248e-02f, 1.13460630e-01f, 7.94666633e-02f, -3.31083179e-01f, -2.22587571e-01f, -9.99062434e-02f, -1.23327412e-01f, -1.88218758e-01f,
  9.74860340e-02f, -2.01342911e-01f, -1.47110187e-02f, 5.92462011e-02f, -8.52124617e-02f, 2.55869806e-01f, 9.36813429e-02f, 6.80508167e-02f, 3.75455841e-02f, -9.64804292e-02f,
  2.19992921e-02f, -1.12236969e-01f, -1.80108380e-02f, 5.11856899e-02f, -4.36163731e-02f, -5.01715168e-02f, 8.74269288e-03f, 2.72939146e-01f, 1.63290367e-01f, 6.96863979e-02f,
  -1.07599273e-01f, 1.17451437e-02f, 1.20285489e-01f, -1.45103008e-01f, -9.46317762e-02f, 8.02614987e-02f, 1.17240883e-01f, 8.18538293e-02f, -1.15772277e-01f, 2.22674906e-01f,
  -1.02087319e-01f, 1.55328870e-01f, 3.91829871e-02f, -2.59095524e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  8.55763406e-02f, 1.63622826e-01f, 6.49146661e-02f, 1.22968443e-01f, 1.03009738e-01f, -5.23218215e-02f, 6.51573464e-02f, 7.85249248e-02f, 7.22380579e-02f, 1.52507022e-01f,
  1.70401651e-02f, -4.47345115e-02f, 3.91938686e-02f, 1.53188631e-01f, 1.67551428e-01f, 9.52851102e-02f, 3.30413543e-02f, 1.20805509e-01f, 1.77572668e-01f, -5.43338358e-02f,
  -3.85910384e-02f, 2.19612624e-02f, 1.73339844e-01f, 9.78856012e-02f, 9.70844775e-02f, 7.31673539e-02f
};

// L2_fan_Wp (Shape: 19 x 64)
const int L2_fan_Wp_rows = 19;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  1.27622813e-01f, 8.73380378e-02f, -1.14515215e-01f, 5.76085746e-02f, -8.70117024e-02f, -9.79269370e-02f, -3.83299030e-02f, -5.20807058e-02f, 1.13967821e-01f, -8.09087306e-02f,
  5.17495461e-02f, -9.39732231e-03f, 1.38586774e-01f, 4.81662042e-02f, -1.04042090e-01f, 2.71065044e-03f, -2.68837810e-02f, 1.43642992e-01f, 1.22515097e-01f, 9.27129947e-03f,
  -1.37152776e-01f, -1.25906959e-01f, 2.69589752e-01f, 1.82028249e-01f, 3.16338353e-02f, 2.20022112e-01f, 1.59949660e-01f, -3.50288232e-03f, -6.60742894e-02f, -1.80435646e-02f,
  1.53610244e-01f, 2.83230484e-01f, 9.35773849e-02f, -2.94336706e-01f, -3.09717774e-01f, -1.94373488e-01f, -1.87198579e-01f, -2.21746981e-01f, -1.75637066e-01f, -3.65875438e-02f,
  -1.03351260e-02f, -1.57879386e-02f, -1.89587757e-01f, 1.42296731e-01f, -4.40116189e-02f, -1.31297827e-01f, 1.24288909e-01f, 9.06913728e-02f, 1.14736840e-01f, -2.41072029e-02f,
  -1.19199581e-01f, -1.13674082e-01f, -2.38443092e-02f, -4.08302955e-02f, -1.28931114e-02f, 8.39353278e-02f, 4.69599366e-02f, -3.93019728e-02f, 2.39093564e-02f, -9.90522951e-02f,
  6.85116947e-02f, 1.38240248e-01f, 1.96741298e-02f, 3.40193436e-02f, -5.35100549e-02f, -8.18763152e-02f, -4.16961685e-02f, -7.60928467e-02f, 7.69382417e-02f, 6.77596852e-02f,
  1.07519984e-01f, -2.96013337e-02f, 2.88599525e-02f, 1.00139841e-01f, 5.82590327e-02f, -6.65372834e-02f, 1.62379488e-01f, -5.68586625e-02f, -4.78582568e-02f, -1.10642456e-01f,
  2.75398102e-02f, -1.21371850e-01f, -2.13311315e-01f, -1.56525061e-01f, -5.45670465e-02f, 1.35959208e-01f, -1.15736291e-01f, -3.90231982e-02f, -1.18055210e-01f, -1.11883864e-01f,
  -8.06856602e-02f, 9.53549296e-02f, -1.43010989e-01f, 7.85101578e-03f, -1.01140253e-01f, -1.81485862e-01f, -1.59134403e-01f, 2.20429286e-01f, 2.92906731e-01f, 5.88869564e-02f,
  1.30544854e-02f, 4.96522570e-03f, 1.90888092e-01f, -6.62743673e-02f, 1.37008026e-01f, -1.07536457e-01f, 1.46238551e-01f, 3.24553810e-02f, -5.21725304e-02f, -3.52383442e-02f,
  -1.07274599e-01f, -1.93613052e-01f, -2.46639580e-01f, 1.08677939e-01f, 1.96398467e-01f, 9.64977443e-02f, 1.33415088e-01f, -4.68613692e-02f, -1.79314777e-01f, -1.68603376e-01f,
  8.04298893e-02f, -5.16710579e-02f, -4.56854701e-02f, -1.38754204e-01f, -1.29236281e-01f, 4.51816469e-02f, 4.71618362e-02f, 5.52422740e-02f, 4.49870303e-02f, -5.68646342e-02f,
  1.34692015e-02f, 1.53954908e-01f, 5.42977899e-02f, -5.39133735e-02f, -7.34269992e-02f, -1.29362315e-01f, 6.22601137e-02f, -3.45994122e-02f, -9.06336457e-02f, -1.60662562e-03f,
  6.97286651e-02f, 1.51570603e-01f, -1.43152118e-01f, -4.97966222e-02f, 6.65658340e-02f, -1.45653710e-02f, 4.44775857e-02f, -2.64893085e-01f, 6.96460605e-02f, -1.28157839e-01f,
  -8.03432614e-03f, 9.40472819e-03f, -4.70582843e-02f, -1.01878695e-01f, -7.38937557e-02f, 1.24401212e-01f, 1.88371614e-01f, 1.94027141e-01f, -3.09297621e-01f, 1.08221099e-01f,
  -1.21606439e-01f, -7.47023299e-02f, -2.48819992e-01f, -2.43112221e-02f, 1.20365240e-01f, 1.28275856e-01f, -1.68678463e-02f, 1.03131451e-01f, 5.07898405e-02f, -3.57971862e-02f,
  -8.71738568e-02f, -5.96374050e-02f, -6.44640476e-02f, -1.34452954e-01f, -8.04896057e-02f, 1.29870608e-01f, 2.09968761e-01f, 2.08513781e-01f, 1.67551056e-01f, 2.20151916e-02f,
  -1.32449627e-01f, -9.86015704e-03f, 2.25135572e-02f, 2.21694633e-01f, -4.66319770e-02f, -2.92292923e-01f, -7.09020197e-02f, 1.65496066e-01f, 1.80916294e-01f, 1.59050245e-02f,
  1.58547252e-01f, -1.59259051e-01f, 1.24534644e-01f, -9.73918363e-02f, 1.81893870e-01f, 4.59040739e-02f, 1.48674712e-01f, -7.44088367e-02f, -5.30131720e-03f, 8.88101086e-02f,
  -9.51182246e-02f, 1.33911386e-01f, -3.47364619e-02f, 7.48864282e-03f, 1.75740436e-01f, 1.25349894e-01f, 8.23973343e-02f, -1.15335517e-01f, -1.72682349e-02f, 2.26126350e-02f,
  -1.04682155e-01f, -2.18605638e-01f, -5.61243370e-02f, -5.75554855e-02f, -9.19322222e-02f, -3.32370587e-02f, -5.42833172e-02f, -2.20627889e-01f, -1.04020881e-02f, -1.56592522e-02f,
  1.23456083e-01f, 1.26351818e-01f, -2.43327543e-01f, -2.62800664e-01f, -1.17310457e-01f, 3.12471122e-01f, -8.20156857e-02f, 1.75545380e-01f, -5.87684177e-02f, 1.50241017e-01f,
  1.86110079e-01f, -5.59845306e-02f, 4.53745723e-02f, -4.41549346e-02f, 1.98240101e-01f, -7.79224709e-02f, -4.07481268e-02f, -1.36854529e-01f, -6.30826056e-02f, 7.72759467e-02f,
  -5.92343956e-02f, -7.33746067e-02f, 2.36131728e-01f, 2.74772812e-02f, -5.58191538e-02f, 1.79795414e-01f, -1.69081800e-02f, -6.01995289e-02f, -4.01724037e-03f, 1.04246370e-01f,
  -3.16425376e-02f, -7.73765519e-03f, 1.14323059e-02f, 8.59279335e-02f, 2.41195709e-02f, -1.33409202e-02f, 1.43395916e-01f, 1.00351118e-01f, 1.61222532e-01f, -1.40487388e-01f,
  -6.18700422e-02f, -4.73878384e-02f, 5.79051040e-02f, 1.99650303e-01f, 6.08510897e-02f, -1.12341776e-01f, -8.07705671e-02f, 1.39715806e-01f, 4.40751202e-02f, -5.83283929e-03f,
  1.19776525e-01f, 1.64601609e-01f, 1.45671573e-02f, -8.04137141e-02f, 2.60942546e-03f, 2.70679630e-02f, 1.23970859e-01f, 8.06479529e-02f, 8.18683282e-02f, 1.63432330e-01f,
  1.12325475e-01f, -1.81722902e-02f, -3.38640949e-03f, -1.81107357e-01f, -2.47925118e-01f, -5.39575629e-02f, 3.39157810e-03f, -1.53897315e-01f, 8.28639939e-02f, 7.11531145e-04f,
  5.81207611e-02f, -6.47934899e-02f, -1.89309478e-01f, -1.80309236e-01f, -1.36484196e-02f, -1.47113055e-01f, 2.04582855e-01f, -1.33650184e-01f, 6.03084303e-02f, 4.41940650e-02f,
  7.87383020e-02f, -1.35042131e-01f, 1.89633697e-01f, 5.65737151e-02f, -5.63799031e-02f, -1.59607351e-01f, -1.61327779e-01f, -3.07262084e-03f, 1.18725345e-01f, -1.51344508e-01f,
  -1.68806747e-01f, -1.56049892e-01f, 6.27802089e-02f, 4.80740480e-02f, 6.85771033e-02f, 1.24642774e-02f, -1.91961139e-01f, -6.70471191e-02f, -1.47825330e-01f, 2.62338459e-01f,
  1.00767612e-01f, -3.69114615e-02f, 1.08704427e-02f, 1.04832441e-01f, 8.70784745e-02f, 1.28703400e-01f, -4.10946123e-02f, 1.07069612e-02f, 1.03863083e-01f, 1.13124713e-01f,
  1.87115952e-01f, 1.28027275e-01f, -3.33075412e-02f, 1.90322429e-01f, 1.20939322e-01f, -6.33334145e-02f, 3.48987319e-02f, 4.41137962e-02f, -1.17384441e-01f, 9.66102928e-02f,
  1.30129874e-01f, -1.25450402e-01f, -1.14392236e-01f, -1.43800795e-01f, -1.72215521e-01f, -7.10661337e-02f, -3.58592086e-02f, -1.20993361e-01f, -1.54115424e-01f, 8.45683143e-02f,
  -1.39843300e-01f, -1.87452003e-01f, -1.06471367e-01f, 1.27507716e-01f, -1.39792576e-01f, -8.25589597e-02f, -3.79989952e-01f, -4.70823981e-02f, 4.94289659e-02f, 8.02700818e-02f,
  3.87656912e-02f, 1.22317232e-01f, 4.37776558e-02f, 2.44928539e-01f, 6.80641085e-02f, 1.92629471e-01f, -7.13772625e-02f, -2.99112331e-02f, 4.66205850e-02f, 1.40090182e-01f,
  -4.32002433e-02f, -2.57504676e-02f, 1.06849171e-01f, -3.44191119e-02f, -3.24667543e-02f, -9.89834592e-02f, 1.80897832e-01f, 1.25353709e-01f, 1.28744021e-01f, -1.14865206e-01f,
  -4.14832262e-03f, 5.47629595e-02f, 2.20296476e-02f, 2.26140559e-01f, -2.52493862e-02f, 1.37842342e-01f, 3.44824120e-02f, 7.61482269e-02f, 1.13313630e-01f, 5.09427488e-02f,
  -1.62494518e-02f, -4.70444672e-02f, 9.18862298e-02f, 4.04256806e-02f, 5.54473363e-02f, 1.35257706e-01f, -5.44401780e-02f, -1.08480044e-01f, -2.66094543e-02f, -5.12944087e-02f,
  -1.00291409e-01f, -5.40434718e-02f, -3.10698152e-02f, 1.73100270e-02f, 1.05718181e-01f, -9.83330980e-02f, 4.82543111e-02f, 4.91308682e-02f, 2.64992807e-02f, -7.78684691e-02f,
  1.93056779e-03f, 1.25781611e-01f, -2.06401870e-02f, 1.53580867e-02f, -2.48946878e-03f, 1.78770851e-02f, -2.68036991e-01f, -1.41596660e-01f, -1.41657472e-01f, -2.41875872e-01f,
  -6.25806451e-02f, -9.74373370e-02f, -1.21906355e-01f, -1.66806296e-01f, 1.05274633e-01f, -6.39646053e-02f, -3.32340673e-02f, 1.16430810e-02f, -4.64318953e-02f, -1.01314068e-01f,
  -2.58370675e-02f, 1.61607802e-01f, 1.53126478e-01f, -9.40396711e-02f, 2.30278838e-02f, -1.59812853e-01f, -4.40953486e-02f, -1.44139647e-01f, -1.76154732e-04f, 7.72406980e-02f,
  -3.76537144e-02f, -1.34076476e-01f, -7.52586825e-03f, 1.45899698e-01f, 2.07609031e-02f, 1.23541199e-01f, -1.12269223e-01f, 5.91394082e-02f, -7.16631487e-02f, -9.95185878e-03f,
  1.16035968e-01f, -1.09274313e-01f, 2.03643013e-02f, -7.50348121e-02f, 3.59005891e-02f, 1.96718693e-01f, -1.17179930e-01f, 1.27003849e-01f, -5.05502485e-02f, 3.37033272e-02f,
  -2.61069019e-03f, 1.19787753e-01f, -1.27038052e-02f, 1.16854481e-01f, -8.22626613e-03f, 6.50923774e-02f, -1.39426500e-01f, -1.62882805e-01f, -1.41284272e-01f, -4.34639007e-02f,
  -1.74861491e-01f, -1.56707931e-02f, -8.79630074e-03f, -1.90103292e-01f, -5.91536947e-02f, -6.62568435e-02f, 1.32540196e-01f, 4.31947708e-02f, -6.34681731e-02f, -3.27449173e-01f,
  -6.62326440e-02f, 3.03449899e-01f, 1.69669494e-01f, 3.35016884e-02f, 6.68034032e-02f, 8.58471617e-02f, 2.22336799e-01f, -8.21480826e-02f, 1.04718693e-01f, -3.61445248e-02f,
  1.06636487e-01f, -1.67492315e-01f, 2.89088413e-02f, 8.62982422e-02f, 7.73792714e-02f, 2.46236641e-02f, -2.13725775e-01f, 2.77187694e-02f, 1.43036813e-01f, 1.77006453e-01f,
  -7.30530098e-02f, 1.07039720e-01f, -1.25999540e-01f, -5.53984493e-02f, 8.74114335e-02f, 4.20465022e-02f, 2.33051069e-02f, 6.61207438e-02f, -9.73951221e-02f, 2.11858260e-03f,
  -1.44161686e-01f, -1.15690529e-01f, 1.07182421e-01f, 3.92496586e-02f, -7.84098729e-02f, -1.93378806e-01f, -3.36137600e-02f, -6.09396957e-02f, 1.38707653e-01f, -1.17457800e-01f,
  -1.19068079e-01f, 1.55381665e-01f, -3.04960702e-02f, 8.26963708e-02f, 3.68558317e-02f, 5.95454685e-02f, 1.99996859e-01f, -6.33184100e-03f, -4.28662971e-02f, -1.29871190e-01f,
  8.30888003e-02f, 5.89088015e-02f, -1.29452422e-01f, 1.53590381e-01f, 7.17668384e-02f, 2.70143956e-01f, 2.00728342e-01f, -2.27371175e-02f, 1.80777565e-01f, -1.36679709e-01f,
  -9.34357345e-02f, -1.24334149e-01f, 3.07086349e-01f, 2.08802804e-01f, -1.06960334e-01f, -1.24555007e-01f, 2.71273673e-01f, 8.54162499e-02f, 1.17066130e-01f, -2.41481781e-01f,
  -5.60224988e-02f, -2.62138903e-01f, 1.27068579e-01f, -2.58786976e-02f, -4.34156740e-03f, 9.27533582e-03f, -1.28031433e-01f, 7.98203349e-02f, 2.14294456e-02f, -9.11289677e-02f,
  -3.19617568e-03f, -9.91203487e-02f, -2.29437426e-01f, -1.53621376e-01f, 1.93238080e-01f, -9.44767818e-02f, -1.19084895e-01f, -1.21819757e-01f, -7.12782741e-02f, 2.79374383e-02f,
  5.43926507e-02f, 7.41704777e-02f, -1.05026597e-02f, -2.17719954e-02f, -7.71347387e-03f, -1.53211638e-01f, 7.71486089e-02f, 1.02925859e-01f, -7.22786337e-02f, 2.15477636e-03f,
  -5.04990965e-02f, 4.65797856e-02f, 1.16320908e-01f, -4.27252427e-02f, -5.92645369e-02f, 4.34410162e-02f, -7.02370033e-02f, -6.82919344e-04f, 2.91518010e-02f, 6.89085051e-02f,
  1.18122801e-01f, 1.61952510e-01f, 1.33231148e-01f, 1.50507689e-01f, 2.07112054e-03f, 5.75875454e-02f, 5.13523668e-02f, 5.47272945e-03f, 1.17776819e-01f, 1.74463391e-01f,
  1.00708520e-02f, -1.20511115e-01f, 1.78979203e-01f, -9.76613909e-02f, -4.48453911e-02f, -1.42095044e-01f, 1.47608861e-01f, 1.84424758e-01f, -5.50886244e-02f, -4.45557684e-02f,
  2.11480126e-01f, 9.95187089e-02f, -6.80249110e-02f, -1.30658569e-02f, 6.44696429e-02f, -9.16659981e-02f, -4.18973947e-03f, 1.53728214e-03f, -1.22413188e-01f, -5.23785464e-02f,
  -1.09954774e-02f, 2.08293367e-02f, -7.25548714e-02f, -3.19769867e-02f, 1.73005417e-01f, -4.71265130e-02f, -2.75904462e-02f, 1.30987717e-02f, 6.25634193e-02f, -1.57448754e-01f,
  1.53029030e-02f, 3.29114869e-02f, -1.44317687e-01f, 4.12224047e-02f, -7.06053823e-02f, 1.83119550e-01f, 1.54159620e-01f, -1.05337374e-01f, -4.80351262e-02f, 1.19138472e-01f,
  9.73867998e-02f, 1.22326843e-01f, -2.13526841e-02f, 1.50377095e-01f, 8.89003947e-02f, -1.21421695e-01f, 8.43835399e-02f, 3.79691981e-02f, -2.93502305e-02f, -1.37136862e-01f,
  1.58492923e-02f, -7.92245287e-03f, -1.19402952e-01f, 1.39292508e-01f, -1.74281254e-01f, -5.86938597e-02f, 1.11890905e-01f, 6.47826307e-03f, 1.06560908e-01f, 2.14511186e-01f,
  2.95477539e-01f, 2.96941251e-01f, 2.20168054e-01f, 1.79107532e-01f, 2.22607225e-01f, 1.29479572e-01f, 5.94697073e-02f, 3.01073015e-01f, 9.43517759e-02f, -1.49484172e-01f,
  -3.49936597e-02f, 1.20306171e-01f, 2.69336700e-01f, -2.43709460e-02f, -7.07598031e-02f, 1.39002830e-01f, 1.91998884e-01f, -1.79858997e-01f, -1.58345044e-01f, 6.88149035e-02f,
  -1.68861039e-02f, -1.13892615e-01f, 8.21027383e-02f, -1.38824806e-01f, 3.02608699e-01f, -1.85702562e-01f, -1.42095029e-01f, 3.09080221e-02f, 5.25038950e-02f, 5.53883128e-02f,
  4.98438440e-02f, 1.17488559e-02f, -2.91435663e-02f, -2.59744120e-03f, 9.75116566e-02f, 2.82926679e-01f, 7.60324672e-02f, 2.99605541e-02f, 5.56730181e-02f, -1.14795841e-01f,
  1.81429371e-01f, -1.96243167e-01f, -1.93545930e-02f, -9.37613025e-02f, -1.16370477e-01f, 5.04683442e-02f, -3.72664304e-03f, -1.80634528e-01f, -1.68160975e-01f, -4.18607406e-02f,
  -4.57961820e-02f, 6.71603009e-02f, 6.57646582e-02f, 7.11180717e-02f, -2.30906680e-01f, -1.71576925e-02f, 4.74636815e-02f, -2.46072132e-02f, 1.05181441e-01f, 4.53730710e-02f,
  -2.56010573e-02f, -1.29911780e-01f, -3.06556560e-02f, 1.25964046e-01f, -1.24988399e-01f, -5.25145903e-02f, 8.76360014e-02f, 2.50518262e-01f, 1.83415204e-01f, -3.89047116e-02f,
  -1.19711183e-01f, 9.09201503e-02f, -1.44057810e-01f, -2.17678010e-01f, 2.15142980e-01f, 9.34321806e-03f, 1.79261655e-01f, -1.40273497e-02f, 2.52061784e-01f, 3.18035245e-01f,
  3.51471193e-02f, -1.00447834e-01f, -8.52050781e-02f, -7.37398863e-02f, -3.27726826e-02f, -4.79852073e-02f, 5.65893576e-02f, -6.45262003e-02f, 1.78423971e-01f, -1.88675076e-01f,
  2.66613197e-02f, -9.81669351e-02f, -1.21540748e-01f, -5.52005060e-02f, -8.72616023e-02f, 6.18789420e-02f, 2.55903639e-02f, -1.60653397e-01f, -1.70688704e-01f, 6.20077290e-02f,
  7.87426457e-02f, 3.41282576e-01f, 5.75998379e-03f, -7.03008324e-02f, -1.89487681e-01f, -1.29813299e-01f, 1.70309842e-02f, 8.69791582e-02f, 5.80062270e-02f, 8.51336718e-02f,
  -5.24812639e-02f, 4.25732248e-02f, 1.18977375e-01f, 1.38114050e-01f, -1.08592128e-02f, 1.55327946e-01f, -1.65797532e-01f, 3.95611636e-02f, 1.44929245e-01f, 1.42926946e-01f,
  1.20580591e-01f, 5.89132719e-02f, -1.00908406e-01f, 1.28943603e-02f, -8.84272382e-02f, -1.20253474e-01f, 6.61185160e-02f, 1.99327506e-02f, 1.48450717e-01f, 8.73007476e-02f,
  1.63668618e-01f, -3.23794819e-02f, 5.29112667e-03f, 2.73342103e-01f, -1.33574098e-01f, 1.16369233e-01f, -9.19564664e-02f, 2.08797097e-01f, -1.11550823e-01f, -3.05478033e-02f,
  2.09739238e-01f, 5.52305765e-02f, -9.97977406e-02f, 8.50228295e-02f, -5.59852198e-02f, 7.17797279e-02f, -3.68667729e-02f, 5.53851500e-02f, -1.06653348e-02f, -9.15741920e-02f,
  1.10698842e-01f, 6.36400059e-02f, 2.31619611e-01f, -1.00672901e-01f, -1.40267372e-01f, 1.06694840e-01f, 3.59011516e-02f, -1.07599730e-02f, 1.23613998e-01f, 4.72903028e-02f,
  -1.44851372e-01f, 8.48881751e-02f, -8.90196562e-02f, 2.02923849e-01f, 6.65626824e-02f, 6.95465058e-02f, -2.29472481e-02f, -2.30269298e-01f, -7.05081820e-02f, -1.73213735e-01f,
  -1.56711966e-01f, 1.80241406e-01f, -1.14310067e-03f, -1.76065803e-01f, -1.18627874e-02f, -1.34632453e-01f, -1.53607085e-01f, -1.97688714e-02f, -6.25044405e-02f, 1.79001391e-01f,
  1.31950915e-01f, 5.60200587e-02f, -1.64672136e-01f, -1.88094229e-01f, -6.63913339e-02f, 9.60218757e-02f, -1.75489008e-01f, 9.00490731e-02f, 1.35705367e-01f, -1.76541344e-05f,
  -4.09757607e-02f, 1.66153535e-01f, -1.49801984e-01f, -2.64056176e-01f, -1.25093102e-01f, 6.67606760e-03f, -1.89883430e-02f, 1.20229848e-01f, -1.94130436e-01f, 1.67875551e-02f,
  -1.11296803e-01f, -1.66073486e-01f, 2.04369843e-01f, -1.19355857e-01f, 2.51076967e-01f, 1.56578392e-01f, -1.15699100e-03f, -9.88248736e-04f, -3.66688427e-03f, -1.45227879e-01f,
  1.01422668e-01f, 2.49079410e-02f, -4.24251053e-03f, 4.71862182e-02f, 2.73415931e-02f, -1.71279594e-01f, 2.99692736e-03f, 1.09657824e-01f, 7.39443675e-02f, -6.38935938e-02f,
  -1.44311115e-01f, -7.85990655e-02f, -9.37222969e-03f, 2.25295052e-01f, -5.87790459e-02f, -7.70866349e-02f, 4.44204956e-02f, -6.45568594e-02f, -8.24915767e-02f, 3.16754162e-01f,
  2.88020652e-02f, -1.91290244e-01f, 1.50548555e-02f, -1.08793247e-02f, 2.55689740e-01f, 8.05824324e-02f, 2.94105615e-02f, 6.47943560e-03f, 2.23329682e-02f, 1.45104468e-01f,
  2.00398173e-02f, -1.35047913e-01f, 1.14295390e-02f, 1.09622054e-01f, 9.29121673e-02f, -7.34033734e-02f, 1.01989046e-01f, -2.28590816e-02f, -5.19814342e-02f, -5.66795059e-02f,
  -1.75542444e-01f, -1.89559236e-01f, -3.95604335e-02f, -6.74636588e-02f, -8.89116433e-03f, -1.12252412e-02f, 1.02113150e-01f, 1.74580403e-02f, -1.10274348e-02f, 1.05605405e-02f,
  -2.07991138e-01f, 3.21573801e-02f, -1.85215056e-01f, 1.74229562e-01f, -3.22185308e-02f, 1.30903617e-01f, -3.03420782e-01f, -1.50260136e-01f, 7.58615062e-02f, 8.21554214e-02f,
  -8.72677565e-02f, -1.16689183e-01f, -1.29606515e-01f, 2.70293325e-01f, -1.85841516e-01f, 1.48870245e-01f, -1.13767982e-01f, -2.45103356e-03f, 1.69043496e-01f, 1.07500434e-01f,
  4.11913134e-02f, -1.84554398e-01f, -5.73221557e-02f, 8.01796690e-02f, -7.06669390e-02f, 1.75878853e-01f, 2.51867324e-01f, -1.52564384e-02f, 5.86907566e-03f, 1.08770974e-01f,
  -1.05502471e-01f, 8.15460633e-04f, 2.04279199e-01f, -1.44958228e-01f, -8.19371864e-02f, -7.70535842e-02f, -1.24745265e-01f, 2.35699862e-01f, 1.68767765e-01f, 6.18425533e-02f,
  1.17754102e-01f, 7.06530781e-03f, -4.62129014e-03f, -1.80465411e-02f, -2.01842025e-01f, -1.58323437e-01f, 1.21216185e-01f, -8.76421407e-02f, 9.49278250e-02f, -6.99814335e-02f,
  9.60557833e-02f, -1.53634539e-02f, 3.63236181e-02f, -1.63284361e-01f, 3.84965949e-02f, -6.75984621e-02f, 7.78673813e-02f, -6.98256306e-03f, 4.65450101e-02f, 7.85232484e-02f,
  -2.43196800e-01f, -2.37767808e-02f, -8.35360028e-03f, 8.25778469e-02f, 1.58143088e-01f, 4.41388898e-02f, -4.43392619e-02f, -2.39661947e-01f, 9.33568776e-02f, -2.49121994e-01f,
  2.82229364e-01f, 2.06057131e-01f, -9.84312408e-03f, -1.86879128e-01f, 5.89532442e-02f, 1.44180121e-05f, 1.51554078e-01f, -1.50662258e-01f, -1.19108990e-01f, -1.32394135e-02f,
  -1.71708450e-01f, 1.44244462e-01f, -2.49745995e-01f, 9.29378793e-02f, -1.31112039e-01f, 5.95845990e-02f, 2.08338752e-01f, -1.05162999e-02f, -3.48049216e-02f, 9.58703179e-03f,
  -1.92479655e-01f, -6.13969304e-02f, -8.05659890e-02f, -1.08873300e-01f, 1.24938883e-01f, -2.82646380e-02f, -1.98847756e-01f, 1.36236176e-01f, 6.59131482e-02f, 1.86004817e-01f,
  2.86864042e-02f, 7.41171604e-03f, 1.61810610e-02f, 5.46255969e-02f, -4.12810706e-02f, -1.06961183e-01f, 1.25330240e-01f, 7.39650875e-02f, -1.03525423e-01f, 6.27653152e-02f,
  7.74793997e-02f, 1.62172183e-01f, -8.95134881e-02f, 1.56961195e-02f, 8.90899524e-02f, -1.51971513e-02f, 1.80992275e-01f, -4.28592861e-02f, -6.12173453e-02f, 6.45325258e-02f,
  1.14882559e-01f, 9.43781715e-03f, 9.65122506e-02f, -1.02296747e-01f, -2.21641585e-01f, -1.83218330e-01f, 1.86551753e-02f, -2.33944774e-01f, -6.32992908e-02f, -1.56463429e-01f,
  -9.15338621e-02f, -9.97943133e-02f, 1.24424091e-02f, -2.28766706e-02f, -9.41102654e-02f, 8.55306387e-02f, -6.04734086e-02f, 9.14102420e-02f, -4.81907167e-02f, -2.48224676e-01f,
  5.57591543e-02f, 1.44780383e-01f, -1.02042921e-01f, 8.45441744e-02f, -1.38627499e-01f, 3.42404209e-02f, -5.95141388e-02f, -4.39307727e-02f, -1.31379947e-01f, 2.15983257e-01f,
  -1.29230944e-02f, -1.13133965e-02f, -6.32437924e-03f, -5.39494306e-02f, 9.91374701e-02f, 2.43132357e-02f, -1.22640900e-01f, 1.20317072e-01f, 1.73761219e-01f, -1.15481719e-01f,
  3.51203070e-03f, 2.94110514e-02f, -8.99279192e-02f, 4.26990353e-02f, -4.80375392e-03f, 1.85878411e-01f, 1.04891069e-01f, -1.38034791e-01f, -1.94324687e-01f, 6.82256743e-02f,
  1.03603518e-02f, -1.02753541e-03f, 6.84895590e-02f, -5.49863018e-02f, -1.13613553e-01f, -4.29274850e-02f, 8.71800259e-02f, -8.61116126e-02f, -5.25101507e-03f, -7.51121789e-02f,
  3.08217984e-02f, 9.21179354e-02f, 6.12025596e-02f, -9.69445035e-02f, 9.87983942e-02f, 6.15787096e-02f, -8.63114670e-02f, -2.25152090e-01f, 9.26827546e-03f, -2.03142241e-02f,
  -2.02074632e-01f, -1.57265410e-01f, -2.01017335e-02f, -1.63480103e-01f, -3.47632878e-02f, 5.82619533e-02f, 2.12433115e-01f, 1.56574547e-01f, -1.61499307e-02f, -7.02223778e-02f,
  -2.87374169e-01f, 1.85323790e-01f, -1.66149169e-01f, -2.50914603e-01f, -7.66002834e-02f, 1.95944563e-01f, -1.35149537e-02f, -6.66079745e-02f, 6.15202338e-02f, 1.55876637e-01f,
  8.12707189e-03f, -1.42933756e-01f, 6.25676960e-02f, 1.52891308e-01f, -2.13411406e-01f, -1.20440356e-01f, -2.37075165e-02f, 1.05349310e-01f, 5.55635653e-02f, -1.36363760e-01f,
  -4.13222127e-02f, 6.69102557e-03f, 2.20860559e-02f, 1.65431798e-02f, -2.42515765e-02f, -2.97567099e-01f, 8.60121399e-02f, 1.88941583e-01f, -5.44057749e-02f, -4.19948734e-02f,
  8.78032148e-02f, -6.16717823e-02f, -7.52481744e-02f, 1.65270865e-01f, -8.29374418e-02f, 1.09551489e-01f, 3.22850305e-03f, 1.35934517e-01f, -8.45510289e-02f, 1.29552886e-01f,
  1.27129108e-01f, 3.74329649e-02f, 8.66530314e-02f, 1.94322139e-01f, 1.23127386e-01f, -5.78104928e-02f, -3.17562260e-02f, 1.65853441e-01f, 7.05341920e-02f, 8.19880422e-03f,
  5.78422807e-02f, 7.71986470e-02f, 3.41913253e-02f, 1.75835744e-01f, -1.39760464e-01f, 3.76484543e-02f, 1.88183476e-04f, -3.78826298e-02f, 2.45891601e-01f, -8.86151791e-02f,
  7.61863291e-02f, -3.05882655e-04f, -9.95071977e-03f, 1.91597953e-01f, -3.13035250e-01f, -1.93820193e-01f, 7.49238906e-03f, -2.51238912e-01f, -4.20883037e-02f, -4.41414528e-02f,
  -1.20480061e-01f, -4.05240729e-02f, 8.37429240e-02f, 1.85313508e-01f, -4.96966913e-02f, 8.29367116e-02f, -5.27976565e-02f, 1.52086928e-01f, -1.57850832e-01f, 1.26287639e-01f,
  1.49718955e-01f, -4.71443087e-02f, -9.47617143e-02f, -1.51607737e-01f, 1.28056824e-01f, -8.23735148e-02f, -1.31646693e-01f, -1.46161588e-02f, -4.25610691e-02f, -1.45055458e-01f,
  7.28323683e-02f, 6.12504743e-02f, -4.65437025e-02f, -1.21738493e-01f, -7.46865645e-02f, -7.54305646e-02f
};

// L2_fan_Wp_bar (Shape: 26 x 64)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  4.27167527e-02f, 3.87452468e-02f, 2.49017164e-01f, 2.31160581e-01f, 1.54655918e-01f, 2.50891954e-01f, 6.12659045e-02f, 1.32662147e-01f, 1.46245703e-01f, 9.54360515e-02f,
  1.67391255e-01f, 1.42732322e-01f, 7.08991438e-02f, 1.13773093e-01f, 1.45832658e-01f, 1.24716334e-01f, 1.30612195e-01f, 8.54748785e-02f, 1.58452727e-02f, 1.82892352e-01f,
  3.28985274e-01f, 2.92661011e-01f, 3.53990085e-02f, 3.35270822e-01f, 1.32801414e-01f, 6.05596751e-02f, 3.24894011e-01f, 4.66191955e-02f, -8.00294727e-02f, 1.75119713e-01f,
  5.47955856e-02f, 1.60464067e-02f, -2.14019775e-01f, -1.97217420e-01f, 1.14474691e-01f, -8.98433253e-02f, -2.32569665e-01f, -2.78476011e-02f, 1.74807072e-01f, 8.66922885e-02f,
  3.28354448e-01f, 2.25247383e-01f, 2.46245325e-01f, 7.39397928e-02f, 1.41748697e-01f, -2.99690273e-02f, 6.66540340e-02f, 3.51389229e-01f, 2.77556013e-02f, 6.44002631e-02f,
  5.53513169e-02f, -1.36529356e-01f, 3.04687142e-01f, 1.52460183e-03f, 1.13592856e-01f, 1.68485209e-01f, 1.46582708e-01f, 2.28380963e-01f, 1.24125490e-02f, 1.23320045e-02f,
  -3.45676318e-02f, 3.08683477e-02f, -2.58444548e-01f, 3.12310457e-01f, 1.50498465e-01f, 1.71847284e-01f, 6.52368516e-02f, 1.04068689e-01f, 1.15385309e-01f, -5.89277502e-03f,
  3.24019380e-02f, 9.39045399e-02f, 5.48914261e-02f, 3.80552411e-01f, 3.48115340e-02f, -2.82451045e-02f, 7.62214884e-02f, 7.80193433e-02f, 5.96414357e-02f, 2.17337042e-01f,
  1.16367199e-01f, 7.25908577e-02f, -8.83739591e-02f, -3.57519835e-01f, -9.94004458e-02f, -1.12610504e-01f, -3.06988567e-01f, -7.14582950e-02f, -8.87910873e-02f, -3.63554627e-01f,
  1.17640674e-01f, -1.27459615e-01f, 1.38820544e-01f, 2.21542314e-01f, -1.34831458e-01f, -8.86180103e-02f, -4.53910232e-01f, 3.26803148e-01f, 3.21135700e-01f, -1.08465046e-01f,
  -1.14621231e-02f, 2.26749718e-01f, 1.80980280e-01f, -5.08286729e-02f, 1.89615652e-01f, 1.01817265e-01f, 2.98810095e-01f, 1.97130367e-02f, -1.81829203e-02f, 2.29087248e-01f,
  6.76958263e-02f, 1.14776092e-02f, -5.17634228e-02f, 2.26894483e-01f, 2.95995057e-01f, -8.81517958e-03f, 1.67316705e-01f, 1.58922747e-01f, 1.64728999e-01f, 6.92186654e-02f,
  9.91526395e-02f, -1.09908484e-01f, 1.08646378e-01f, 2.37162083e-01f, 1.06852666e-01f, -3.02606411e-02f, -9.71192941e-02f, -1.31068751e-01f, 1.72891453e-01f, 1.00242570e-01f,
  1.13588616e-01f, 2.74085253e-01f, 1.36913240e-01f, 2.36448213e-01f, 1.12928778e-01f, 7.97102228e-02f, 1.15805864e-01f, 3.19786668e-02f, 1.13910940e-02f, 2.64445931e-01f,
  1.30502030e-01f, 6.79660439e-02f, 5.29634301e-03f, 1.36026502e-01f, 1.47843994e-02f, -3.75441648e-02f, -3.86997014e-02f, 1.48567557e-01f, 4.02215928e-01f, 2.48109594e-01f,
  3.36290002e-01f, 2.21937731e-01f, -4.30335756e-03f, 5.26248664e-02f, 1.70512483e-01f, 5.55487424e-02f, -1.56394631e-01f, 3.99260491e-01f, -2.06718206e-01f, 1.34804428e-01f,
  -6.39387071e-02f, -6.79909736e-02f, 2.09797919e-02f, 7.90145919e-02f, -1.79812506e-01f, -1.25569075e-01f, 3.57457511e-02f, 2.95447141e-01f, 4.30559784e-01f, 1.80515453e-01f,
  2.79056966e-01f, 4.36342806e-01f, 2.46391892e-01f, -1.11823544e-01f, -7.12779723e-03f, 4.11945462e-01f, 9.02733281e-02f, 3.12859923e-01f, 2.23840073e-01f, -1.13990270e-01f,
  1.55011132e-01f, 8.86116475e-02f, -1.14948161e-01f, 1.60819173e-01f, 4.18699443e-01f, -3.35620791e-02f, -4.43348214e-02f, -8.14466625e-02f, 3.94408079e-03f, 3.00881892e-01f,
  6.22212738e-02f, 3.74496639e-01f, 6.19730987e-02f, 1.70676976e-01f, 2.11582273e-01f, 1.60403237e-01f, 2.42963776e-01f, 2.04990715e-01f, -5.41979773e-03f, 2.42554709e-01f,
  -3.06194578e-03f, 2.53120393e-01f, 1.26337290e-01f, 6.29627779e-02f, 7.93348178e-02f, 1.70828044e-01f, -1.36124063e-02f, -2.35053301e-02f, 1.52518183e-01f, 7.04215765e-02f,
  1.39887780e-01f, -2.05448076e-01f, 1.67789713e-01f, -1.24337450e-01f, -3.76436934e-02f, -2.92467270e-02f, -2.02396289e-01f, 1.24317063e-02f, 1.22535296e-01f, 2.84843206e-01f,
  1.37128547e-01f, 1.87978670e-01f, -3.50477725e-01f, 2.46366747e-02f, -3.08151692e-01f, -2.80666072e-02f, -2.69028157e-01f, -2.53925353e-01f, -8.09476525e-02f, -1.22471070e-02f,
  6.76999167e-02f, -9.12983902e-03f, 8.80051777e-02f, -2.10725758e-02f, 3.09236169e-01f, -1.33843690e-01f, 5.23225404e-02f, 1.29710004e-01f, -9.92583409e-02f, 2.42730066e-01f,
  1.10566758e-01f, 1.57483816e-02f, 1.52311385e-01f, 2.45691258e-02f, 7.99020827e-02f, 1.84310582e-02f, -7.58572221e-02f, 1.37632266e-01f, 2.26932421e-01f, -2.43630528e-01f,
  -6.84899986e-02f, 1.15087433e-02f, 2.09526449e-01f, 1.31582156e-01f, -2.03765735e-01f, -1.43543119e-02f, -6.86549721e-03f, 9.34465379e-02f, 1.48564786e-01f, 2.50508133e-02f,
  6.73355982e-02f, 1.81513369e-01f, 1.22922793e-01f, -9.98539254e-02f, 4.34188060e-02f, 1.09512217e-01f, 1.16854928e-01f, 1.78421751e-01f, -3.48773599e-02f, -9.84041393e-02f,
  1.04108833e-01f, 7.02693760e-02f, 4.22730260e-02f, 4.12801243e-02f, 1.42885551e-01f, 1.14310883e-01f, 2.37250894e-01f, -5.78807630e-02f, 3.57891843e-02f, -5.50971404e-02f,
  -6.00389987e-02f, -1.56838614e-02f, 2.03155875e-01f, -1.79842010e-01f, -2.86592424e-01f, 2.22914353e-01f, -1.73174813e-01f, 8.79534930e-02f, -2.20877320e-01f, 4.82633263e-02f,
  -5.79963066e-02f, -1.07205436e-01f, -2.34482512e-01f, -9.90080908e-02f, 1.05523884e-01f, -1.09748788e-01f, 3.36292028e-01f, 1.73118934e-01f, 1.75887600e-01f, 2.28904977e-01f,
  1.72096379e-02f, 9.89794508e-02f, 1.66188591e-04f, 2.39305303e-01f, 1.45715386e-01f, 1.92742616e-01f, -3.87495868e-02f, -3.42760310e-02f, -2.55282652e-02f, -4.19141948e-02f,
  1.84498169e-02f, -4.28535789e-02f, 2.64480382e-01f, -9.47901327e-03f, 1.35773867e-01f, 2.61500120e-01f, -3.54617722e-02f, 2.56538749e-01f, 9.37938225e-03f, 3.05647910e-01f,
  1.67439114e-02f, 1.02414854e-01f, 1.18347868e-01f, 5.76508380e-02f, -2.28005517e-02f, 1.12377018e-01f, 1.72817603e-01f, -3.42782103e-02f, 3.96116935e-02f, 1.61577880e-01f,
  -2.48659048e-02f, -1.61034867e-01f, 6.64598420e-02f, 1.14668995e-01f, -2.72607021e-02f, 1.40907355e-02f, 3.18858549e-02f, 4.44190130e-02f, 1.15704395e-01f, 1.09469838e-01f,
  -8.69767740e-02f, 3.00619781e-01f, 1.00354470e-01f, 1.15200713e-01f, 3.61613959e-01f, -1.94514077e-02f, 1.39125407e-01f, -6.53927028e-03f, -1.91732705e-01f, -3.03300351e-01f,
  2.25595310e-01f, 1.58592120e-01f, 3.07284266e-01f, -2.18038131e-02f, 4.19521362e-01f, 2.05766097e-01f, 2.46426731e-01f, -2.81793088e-01f, 6.35769889e-02f, -1.56647906e-01f,
  -8.82994607e-02f, 2.01364413e-01f, 1.62488654e-01f, -3.28341722e-02f, 5.84637038e-02f, -1.57459125e-01f, 2.66323775e-01f, -7.81123340e-02f, 8.29691514e-02f, -8.63577127e-02f,
  -4.74554859e-02f, 6.04123585e-02f, 2.12843269e-01f, -2.23661974e-01f, -2.61522532e-02f, 1.77910566e-01f, -1.56257033e-01f, 3.13700408e-01f, -2.51646303e-02f, -1.19781628e-01f,
  -6.55823499e-02f, -1.32689655e-01f, 1.62450641e-01f, -1.01477958e-01f, 1.75368741e-01f, 1.27671584e-01f, 6.42521456e-02f, 1.87159162e-02f, 5.23798540e-02f, 4.12117057e-02f,
  -6.92497939e-02f, 4.66848016e-02f, -4.49897312e-02f, 2.01301202e-01f, 6.75328672e-02f, -1.58384312e-02f, 1.25581175e-01f, 1.42602324e-01f, 4.51817214e-02f, 4.55355793e-02f,
  -3.24382260e-03f, 1.46793857e-01f, 2.54090708e-02f, -2.68877447e-01f, -1.86535180e-01f, -6.03718124e-02f, -1.54787228e-01f, -1.36547059e-01f, -2.20844910e-01f, -9.30926204e-02f,
  -9.50419307e-02f, -2.72047639e-01f, 2.11575087e-02f, 3.54569070e-02f, -6.62481189e-02f, 1.06608480e-01f, -2.78734744e-01f, 3.93881369e-03f, -2.09048748e-01f, -1.44003421e-01f,
  -2.37289920e-01f, 1.52656555e-01f, 4.06399034e-02f, -8.42845812e-03f, 1.45034373e-01f, 2.18577739e-02f, 1.89834926e-02f, 2.69741118e-01f, -1.73501581e-01f, 1.18872516e-01f,
  2.18177810e-01f, 9.20276195e-02f, 2.23398015e-01f, 1.26707688e-01f, -3.76234911e-02f, 2.03485206e-01f, -9.22377110e-02f, 9.22784135e-02f, 8.75612199e-02f, 1.07640006e-01f,
  1.25996411e-01f, -2.92016834e-01f, -2.84414068e-02f, 9.24429074e-02f, 5.71881495e-02f, 1.72452211e-01f, 2.68217713e-01f, 1.41037792e-01f, -4.53986935e-02f, -1.02041036e-01f,
  1.07116848e-01f, 5.75449727e-02f, -8.56907200e-03f, 1.02530323e-01f, 1.39879733e-01f, 8.44191089e-02f, 1.28610134e-01f, 1.11558661e-01f, -1.04629107e-01f, 8.19919445e-03f,
  2.70039588e-01f, 5.11551946e-02f, 5.21820895e-02f, 8.44284371e-02f, 1.19858637e-01f, 1.49056554e-01f, 1.74275879e-02f, -3.65954697e-01f, -2.78245509e-01f, -1.94681942e-01f,
  -4.86532450e-02f, -1.68355450e-01f, -1.31290853e-01f, -2.82572955e-01f, -4.17101495e-02f, -1.79171428e-01f, 8.37718621e-02f, -1.53004140e-01f, -7.99447224e-02f, -2.34419033e-01f,
  -2.78329641e-01f, 1.74970746e-01f, 9.34285745e-02f, -5.74948220e-03f, -1.44018903e-01f, 1.06857903e-01f, 1.08580597e-01f, 8.02217945e-02f, -2.55719312e-02f, 9.20630172e-02f,
  5.25356121e-02f, -1.23781562e-01f, -1.30409420e-01f, 2.13404655e-01f, 1.02395609e-01f, -7.83438683e-02f, -7.46858194e-02f, 1.47060245e-01f, 1.78089842e-01f, 2.98483968e-01f,
  1.74596488e-01f, 1.84506640e-01f, 1.40919417e-01f, -1.50881916e-01f, 4.96679991e-02f, 7.08634406e-02f, 6.02598414e-02f, 1.75117716e-01f, 1.85044631e-02f, 2.04661712e-01f,
  2.05670267e-01f, 1.56300329e-02f, -9.82294828e-02f, 5.48392422e-02f, 1.35640562e-01f, 1.13538884e-01f, 2.43738130e-01f, 1.54378861e-02f, 1.35483295e-01f, 6.50231987e-02f,
  1.73346654e-01f, -8.90042516e-04f, 2.16792509e-01f, 3.01183343e-01f, 1.04091272e-01f, 6.96748123e-02f, 1.65720463e-01f, -3.22346427e-02f, 1.12752013e-01f, 1.19971804e-01f,
  1.17173567e-01f, 1.39792021e-02f, 1.96140051e-01f, -1.03796370e-01f, 6.89089149e-02f, -1.53945684e-01f, -1.16251461e-01f, -7.76017830e-02f, 1.84671715e-01f, -4.36734501e-03f,
  -1.19179189e-01f, 2.36602664e-01f, 3.50884465e-03f, 9.56184343e-02f, -1.12596206e-01f, -9.73071083e-02f, -2.79456943e-01f, -4.50797290e-01f, -3.50191802e-01f, -1.12460732e-01f,
  -1.23669263e-02f, 1.31183304e-02f, 1.50222182e-01f, 1.93236306e-01f, 1.65317863e-01f, 1.23630106e-01f, -1.71030268e-01f, 2.68802375e-01f, 3.34332623e-02f, 2.33868450e-01f,
  2.15783268e-01f, 4.77857888e-02f, -1.31268129e-01f, -2.45695971e-02f, 7.43537471e-02f, -4.92317639e-02f, -6.06501326e-02f, -9.12614390e-02f, 9.15804207e-02f, -8.57812352e-03f,
  -8.84116441e-02f, 1.46533877e-01f, -1.28951102e-01f, 4.41654027e-02f, -1.48136586e-01f, 3.97132188e-01f, -9.32577401e-02f, -1.51449099e-01f, 2.09776275e-02f, -1.59627646e-02f,
  -1.25670582e-01f, -7.53565654e-02f, -2.17832495e-02f, -1.72797680e-01f, 1.52464658e-01f, -1.41079217e-01f, -7.98307806e-02f, -9.78940651e-02f, -7.15168715e-02f, 2.21800804e-02f,
  -1.17010444e-01f, -1.19308472e-01f, 7.58988261e-02f, -1.38827087e-03f, 6.20433688e-03f, -2.17241094e-01f, -2.69046009e-01f, -2.98786134e-01f, -1.54797405e-01f, -3.65316093e-01f,
  -1.07288957e-01f, -2.01636672e-01f, -2.79936016e-01f, -2.43769959e-02f, 1.49055302e-01f, 1.85518339e-01f, -1.13098651e-01f, 5.69191063e-03f, 6.43950514e-03f, -6.26020832e-04f,
  1.52201473e-03f, -5.04865497e-02f, -6.61953837e-02f, 2.46436775e-01f, 6.14549816e-02f, 2.81359136e-01f, -5.68289049e-02f, 4.76974845e-02f, 2.39631883e-03f, 8.99669379e-02f,
  -6.06937371e-02f, 7.89330676e-02f, 1.03423752e-01f, -2.79856503e-01f, 1.23287905e-02f, 8.72753263e-02f, 9.03556868e-02f, 5.68052419e-02f, -9.01637152e-02f, 2.03873605e-01f,
  1.38371691e-01f, 1.44908652e-01f, -3.67500000e-02f, -1.68008566e-01f, 5.83725907e-02f, 6.95614284e-03f, 2.13229959e-03f, 2.49047309e-01f, 3.05050462e-01f, -6.88293204e-02f,
  1.57688901e-01f, 8.27460214e-02f, -3.33735272e-02f, -1.05029836e-01f, -8.29029537e-04f, -9.81293805e-03f, 6.50669411e-02f, 6.10145591e-02f, 1.43446594e-01f, 1.59845099e-01f,
  4.79348414e-02f, -9.47434679e-02f, 3.21082361e-02f, -2.41082124e-02f, 1.56090245e-01f, 4.91992459e-02f, 1.82891563e-01f, 1.43847957e-01f, -5.44923022e-02f, -2.57342041e-01f,
  -1.84218958e-01f, -9.46844146e-02f, -1.01757266e-01f, -1.80424690e-01f, 7.35981688e-02f, -2.70091861e-01f, -3.22893225e-02f, -2.72140861e-01f, 2.35655650e-01f, -2.36467034e-01f,
  2.88196117e-01f, 2.31502876e-01f, -1.07447274e-01f, 3.05747204e-02f, -1.13019934e-02f, -5.50023355e-02f, 2.56121997e-02f, -8.42549279e-02f, 1.01466544e-01f, -2.58632749e-02f,
  5.50455935e-02f, 1.73238292e-01f, 7.66049419e-03f, 4.20264713e-02f, -1.98789760e-01f, 3.49541903e-01f, 1.31976232e-01f, 2.11174376e-02f, 4.37349966e-03f, -8.07778984e-02f,
  -1.48343205e-01f, 1.11649195e-02f, 1.59312248e-01f, 6.45619491e-03f, 2.53513128e-01f, -1.47526175e-01f, -2.71044254e-01f, -2.82686241e-02f, 5.30404709e-02f, 1.97555080e-01f,
  2.33134210e-01f, 5.88491485e-02f, 1.45955727e-01f, -4.98664342e-02f, -3.29819955e-02f, 1.81005284e-01f, -4.88717742e-02f, 2.33268037e-01f, -8.45040232e-02f, 1.90308347e-01f,
  3.39243636e-02f, -6.71215057e-02f, 2.09229272e-02f, -8.59481171e-02f, 1.65320858e-01f, -1.50733173e-01f, -8.28534458e-03f, -9.98582169e-02f, -1.31750092e-01f, -1.99102804e-01f,
  -2.37149782e-02f, 2.66041398e-01f, 3.66407514e-01f, -1.39058694e-01f, -1.21276602e-01f, 2.03826427e-01f, 5.67988753e-02f, 1.20919123e-02f, 1.67129058e-02f, -1.96337312e-01f,
  1.07660934e-01f, 3.20468806e-02f, 5.08353651e-01f, -2.07010522e-01f, 4.66090329e-02f, 8.35796669e-02f, -3.08051258e-01f, 7.03523904e-02f, 2.15193871e-02f, 1.12982549e-01f,
  5.62882841e-01f, -2.90666092e-02f, -1.41250432e-01f, 1.69977434e-02f, 3.72040123e-02f, 1.47234350e-01f, 3.06431316e-02f, -2.35746905e-01f, 9.27448332e-01f, -5.59342168e-02f,
  3.58815305e-02f, -2.44627014e-01f, 9.47018713e-02f, -1.29535496e-01f, 1.92215502e-01f, -3.76076438e-02f, -5.37376180e-02f, 1.22752145e-01f, 1.15107618e-01f, 1.26860142e-01f,
  -9.96316597e-02f, -4.36708868e-01f, 1.79401010e-01f, 1.19678803e-01f, 2.15010747e-01f, -1.01705886e-01f, -3.59093636e-01f, -2.03586325e-01f, -4.20502387e-02f, 1.24086579e-02f,
  -9.90203917e-02f, -2.27877536e-04f, -7.82263950e-02f, 1.01786420e-01f, -2.52848007e-02f, 6.04346767e-02f, -6.65428024e-03f, -3.86594199e-02f, 7.47363940e-02f, -9.28892717e-02f,
  3.15929092e-02f, -1.15232272e-02f, 6.85170963e-02f, 1.07588947e-01f, 3.77532803e-02f, 5.56085370e-02f, 9.39468741e-02f, -1.96067587e-01f, -2.90957153e-01f, -2.78530121e-01f,
  -8.09851065e-02f, -3.09001625e-01f, -1.53933004e-01f, -1.75893337e-01f, -1.51270136e-01f, -5.78324534e-02f, -7.24623129e-02f, 1.92306623e-01f, -1.45760208e-01f, -1.19455084e-02f,
  -2.33000312e-02f, 1.49453888e-02f, -8.99331179e-04f, -2.44470403e-01f, -1.10325888e-01f, 1.72910199e-01f, -2.88401102e-03f, 2.24407688e-01f, -1.93202004e-01f, -7.15447366e-02f,
  -2.12745249e-01f, 1.64684057e-01f, -1.67284295e-01f, 2.75372952e-01f, 2.74476767e-01f, -2.67224103e-01f, 3.33208069e-02f, 6.83577731e-02f, 1.28276929e-01f, 1.41639858e-01f,
  -1.52882770e-01f, 1.94353476e-01f, 2.68562436e-01f, 1.28286242e-01f, -3.39206122e-02f, 4.49459553e-02f, -1.06121957e-01f, 1.42211020e-01f, -4.58916947e-02f, 2.88511544e-01f,
  2.10177138e-01f, 7.06962496e-02f, 2.35674441e-01f, 1.65626660e-01f, -8.19277484e-03f, 1.09496795e-01f, 6.22668192e-02f, -6.40833303e-02f, 1.42030045e-01f, 1.27750471e-01f,
  -8.26779604e-02f, 2.71279722e-01f, 6.47834241e-02f, 7.61024803e-02f, -1.09307617e-01f, 1.04312375e-01f, -2.88047027e-02f, -3.59951705e-02f, -1.01636685e-01f, 2.12506935e-01f,
  1.72917694e-01f, -4.26019542e-02f, -5.64626083e-02f, 2.60728244e-02f, 5.39739989e-03f, -6.40413072e-03f, 1.95946082e-01f, -1.17907137e-01f, 9.69873089e-03f, -5.07690646e-02f,
  1.14627622e-01f, -3.36043328e-01f, 4.55312096e-02f, -1.24831326e-01f, 3.52625400e-02f, 1.18841939e-01f, 1.46984115e-01f, 8.49236548e-02f, 3.56219202e-01f, -1.28120884e-01f,
  2.57460445e-01f, -1.51427895e-01f, 7.04445764e-02f, 2.29277000e-01f, 3.96647304e-02f, -2.58540750e-01f, 1.26875997e-01f, 1.24602415e-01f, 2.80266255e-01f, -8.06268081e-02f,
  1.85282618e-01f, -6.17183261e-02f, -7.32688829e-02f, 2.39555448e-01f, -2.43365075e-02f, 1.93184987e-01f, 2.32344463e-01f, 3.29061113e-02f, -1.54674932e-01f, -4.68237810e-02f,
  6.37050867e-02f, 2.74286360e-01f, 3.31401646e-01f, -3.94348726e-02f, -8.16568956e-02f, -1.43886702e-02f, 3.65495421e-02f, 4.93685082e-02f, 5.37193008e-02f, 6.49031177e-02f,
  1.80358052e-01f, 1.88702300e-01f, 1.23565057e-02f, 8.86014849e-02f, -6.03749715e-02f, 2.49517411e-01f, -6.11404106e-02f, -9.17378142e-02f, -3.70357074e-02f, 2.85368323e-01f,
  9.05927196e-02f, 5.83932213e-02f, -7.69738778e-02f, 1.77132800e-01f, -9.22429487e-02f, -2.06326827e-01f, -8.93578231e-02f, -7.93882906e-02f, -1.47145241e-02f, 1.02137245e-01f,
  -1.19448863e-01f, 1.15515590e-01f, -2.51963913e-01f, 2.25220397e-01f, 6.23803469e-04f, 1.92869455e-01f, -1.01764746e-01f, -3.86147708e-01f, 2.32176766e-01f, 4.22531307e-01f,
  3.32651794e-01f, 3.64779055e-01f, 2.07044050e-01f, 2.79372811e-01f, 3.21130514e-01f, 1.62279382e-01f, -8.93032104e-02f, 3.39452885e-02f, 1.32950172e-01f, 2.37296820e-02f,
  1.57866895e-01f, -8.81732702e-02f, 1.82865694e-01f, -1.02534287e-01f, -9.48750451e-02f, 1.03627391e-01f, 2.82903135e-01f, 1.82712629e-01f, 1.18854031e-01f, 2.68180251e-01f,
  8.65384340e-02f, 2.07984284e-01f, 2.47521609e-01f, 2.61375636e-01f, -9.79672652e-03f, 3.34095620e-02f, 3.21105383e-02f, 4.92190756e-02f, 1.65257603e-01f, -1.10739566e-01f,
  6.83778226e-02f, 1.90044597e-01f, 7.03559369e-02f, 1.67783380e-01f, 1.36724457e-01f, 1.53677136e-01f, 2.01060012e-01f, -1.19884603e-01f, 5.87718971e-02f, -6.89743385e-02f,
  1.49398655e-01f, 7.81029090e-02f, -1.33373052e-01f, -4.34766859e-02f, 2.75429171e-02f, 5.02200015e-02f, 3.91751081e-02f, -7.41952583e-02f, 2.74052024e-02f, 1.15045421e-01f,
  2.87044972e-01f, 3.01771313e-01f, 2.35958859e-01f, 2.88829833e-01f, 1.91821069e-01f, 5.39121404e-02f, 1.68326631e-01f, 2.55778849e-01f, -2.81233132e-01f, -1.96407475e-02f,
  -1.44324377e-02f, 1.87937275e-01f, -1.09395295e-01f, -3.45787495e-01f, 1.74210563e-01f, 2.81414062e-01f, 2.57075895e-02f, -2.10928693e-01f, -4.74410541e-02f, -6.85350224e-03f,
  1.61072686e-01f, 1.63379326e-01f, -2.88217980e-02f, 1.08340740e-01f, 1.35409892e-01f, -2.93829069e-02f, 1.33894295e-01f, 1.09222516e-01f, 2.45788008e-01f, 2.53253765e-02f,
  -6.44324254e-03f, -1.84338346e-01f, 2.24567473e-01f, 3.96465734e-02f, 1.12461604e-01f, 1.58110350e-01f, 4.16746968e-03f, 1.75518985e-03f, 2.77635101e-02f, 2.15291053e-01f,
  1.78714141e-01f, -5.73295727e-02f, -9.49174166e-02f, 4.27322052e-02f, -7.46674612e-02f, 1.00701734e-01f, -1.30922005e-01f, 3.92653495e-02f, 1.19357500e-02f, -1.53919617e-02f,
  7.37126991e-02f, -1.16732053e-01f, -6.13849685e-02f, -7.02804998e-02f, 5.87785132e-02f, 2.69581024e-02f, -8.07103366e-02f, 1.02582559e-01f, -1.15272552e-01f, 1.09788803e-02f,
  1.25720631e-02f, 1.79653754e-03f, -6.11907914e-02f, -8.57882109e-03f, -1.07963542e-02f, -1.00247070e-01f, 4.64043617e-02f, 1.06449656e-01f, -9.25595835e-02f, 4.87029739e-02f,
  9.47588906e-02f, -1.39968485e-01f, 3.68030146e-02f, 2.83089690e-02f, 1.79124121e-02f, -5.77264652e-02f, 7.70248473e-02f, -1.16068311e-01f, -8.83491114e-02f, 9.38404128e-02f,
  3.19753252e-02f, 7.13691637e-02f, -5.12058660e-02f, -1.12125970e-01f, 8.84221792e-02f, -2.78212614e-02f, 1.10472500e-01f, -4.89567220e-02f, -2.86725746e-03f, -7.13263452e-03f,
  -4.92060706e-02f, -2.21040007e-02f, -8.06537718e-02f, -1.26550809e-01f, -4.58697975e-03f, 1.11348607e-01f, -8.07512626e-02f, 8.22919048e-03f, -8.25605169e-02f, -1.69457290e-02f,
  -1.13722473e-01f, -6.46548942e-02f, 2.63700057e-02f, 1.09271824e-01f, -1.19983479e-01f, -6.39828742e-02f, -5.34579009e-02f, -7.60145262e-02f, 1.73031643e-01f, -8.31021070e-02f,
  6.63214996e-02f, -1.59344599e-01f, -2.20606253e-02f, -3.14437854e-03f, 1.31789997e-01f, 2.17928216e-02f, 4.64847758e-02f, -3.58987390e-03f, 6.89542368e-02f, -1.82583518e-02f,
  1.29759282e-01f, -5.36529645e-02f, 1.84886605e-01f, 2.01689392e-01f, 8.66059661e-02f, -9.31977257e-02f, 5.51043600e-02f, 1.15367338e-01f, -4.44158427e-02f, 1.34570569e-01f,
  -4.02137153e-02f, 6.26107305e-02f, 3.41836870e-01f, -1.59755796e-01f, 1.25880405e-01f, -3.38284314e-01f, -1.93564519e-01f, -1.57258257e-01f, 4.36029077e-01f, 1.64788663e-01f,
  -1.14210218e-01f, 7.63934627e-02f, 2.24400803e-01f, 2.58213937e-01f, -2.34012544e-01f, -1.22879811e-01f, 2.49677554e-01f, -1.56166792e-01f, 1.26901507e-01f, 2.35731736e-01f,
  7.93585405e-02f, 9.75095779e-02f, -1.24585055e-01f, 1.08231135e-01f, 3.28454107e-01f, -8.02121386e-02f, -2.49060001e-02f, -1.50669634e-01f, -1.89639285e-01f, 2.71355122e-01f,
  7.07271099e-02f, 3.78554426e-02f, -1.19269202e-02f, -1.59444913e-01f, -7.96357691e-02f, 3.45787436e-01f, -7.94658661e-02f, 1.24776766e-01f, -8.01053364e-03f, 6.54546469e-02f,
  4.44853157e-02f, 7.89664239e-02f, -7.09280698e-03f, 1.64183825e-01f, -4.04357202e-02f, 1.70868427e-01f, 1.44784600e-02f, 6.94785193e-02f, 3.12286541e-02f, -5.65622151e-02f,
  -6.35290518e-02f, 1.17945172e-01f, 7.04100206e-02f, 8.93076658e-02f, -8.06989819e-02f, 2.19820123e-02f, 1.23584300e-01f, -9.61637218e-03f, 8.21314156e-02f, -8.50705430e-02f,
  9.61710326e-03f, 6.74466565e-02f, 2.95341052e-02f, 1.62441984e-01f, -1.07003316e-01f, 1.00745922e-02f, -3.04385554e-02f, -5.20209000e-02f, 1.29341334e-01f, -2.15417489e-01f,
  -1.29546627e-01f, -7.75609761e-02f, 1.62935629e-01f, 2.09793597e-01f, -3.06449682e-01f, -2.62281030e-01f, 1.27137437e-01f, -4.66921292e-02f, -5.73246963e-02f, -2.94002295e-01f,
  1.08332992e-01f, -1.44504681e-01f, 2.11518154e-01f, 7.98235685e-02f, -1.76289409e-01f, -7.11496919e-02f, -1.61610708e-01f, 5.41463196e-02f, -1.07890353e-01f, -5.38907461e-02f,
  1.71404630e-01f, 2.28542592e-02f, -2.52903556e-04f, 2.01858860e-02f, 1.53892338e-01f, 1.92792453e-02f, 5.55464663e-02f, 1.16149336e-01f, -1.82498202e-01f, -2.70626217e-01f,
  -3.68895158e-02f, 3.00608069e-01f, 1.51300058e-01f, 1.49913549e-01f, -2.29915917e-01f, -3.10176099e-03f, -1.30232751e-01f, 5.23752682e-02f, 8.67025461e-03f, -8.28793552e-03f,
  -4.14819084e-03f, 8.22040290e-02f, 2.76693571e-02f, 9.37930867e-02f, -1.31347338e-02f, 2.64850259e-01f, -1.20621577e-01f, -8.06195810e-02f, 1.93721250e-01f, 2.31905371e-01f,
  1.09128177e-01f, 1.32726789e-01f, 4.07352224e-02f, 9.18218344e-02f, -9.88889206e-03f, -3.96973073e-01f, -9.43770334e-02f, -2.26908475e-02f, -1.07020877e-01f, -1.82884336e-01f,
  -2.94911992e-02f, -2.22918130e-02f, 3.77756022e-02f, 1.94637001e-01f, 2.65369058e-01f, 3.20548899e-02f, -1.61822498e-01f, 4.07145098e-02f, -2.98590779e-01f, 2.69682109e-01f,
  2.62823194e-01f, 1.41986474e-01f, 1.15813807e-01f, 3.28020155e-01f, 3.31149697e-02f, 4.03509885e-02f, -8.92709121e-02f, 2.22986136e-02f, -4.36678007e-02f, -1.52711794e-01f,
  -3.70150171e-02f, 2.52818733e-01f, -6.16601147e-02f, -1.89485446e-01f, 2.78183781e-02f, 1.12895541e-01f, 1.32452980e-01f, 1.02669567e-01f, 8.15401897e-02f, 2.23527998e-01f,
  1.16655856e-01f, 1.93119437e-01f, 1.20114461e-01f, -2.47620314e-01f, 2.53151357e-02f, 6.22929707e-02f, 2.01856509e-01f, 7.97933340e-02f, -3.77658792e-02f, -2.07012028e-01f,
  2.45156256e-03f, -1.46831293e-02f, -2.18114719e-01f, 5.81389628e-02f, -1.00957401e-01f, -1.74018908e-02f, 1.26713946e-01f, -1.25770494e-01f, 9.11437273e-02f, -1.98698826e-02f,
  7.77541697e-02f, 4.02767472e-02f, -1.68271884e-01f, -1.60419270e-01f, -1.54076308e-01f, 1.07213274e-01f, -8.13381374e-03f, -5.16563207e-02f, 5.63978627e-02f, 1.78893074e-01f,
  7.29729608e-02f, 1.57121956e-01f, 1.29708365e-01f, 6.37726113e-02f, 2.69283593e-01f, 2.29215115e-01f, 7.34969229e-02f, 2.02038899e-01f, -1.29150063e-01f, -1.72860071e-01f,
  1.02102004e-01f, 9.15820152e-02f, 2.45134875e-01f, -2.36945748e-01f, 2.37594739e-01f, 2.38147035e-01f, 3.54096651e-01f, -1.46848544e-01f, 5.37188724e-02f, -7.10505173e-02f,
  1.66885648e-02f, 1.63488492e-01f, -2.04436436e-01f, -1.18940338e-01f, 9.45997536e-02f, -1.46405742e-01f, -8.08666050e-02f, -4.46421988e-02f, 6.97647855e-02f, -1.32301226e-01f,
  -9.48657095e-02f, -1.05087250e-01f, 8.29148516e-02f, -4.88046743e-02f, 1.73942164e-01f, 1.50070652e-01f, -2.44485140e-01f, 2.55935956e-02f, 6.58542737e-02f, -6.17120005e-02f,
  2.14108422e-01f, -1.16415225e-01f, -8.75180960e-02f, -1.45418793e-01f, -1.48171540e-02f, -1.53680772e-01f, -1.40516967e-01f, -1.17080770e-01f, 2.98958384e-02f, -1.09065361e-01f,
  1.40108481e-01f, -1.14609532e-01f, 6.80353492e-02f, -2.09784098e-02f, -3.47574204e-02f, -6.26209974e-02f, 2.04672083e-01f, 6.47401288e-02f, 2.89220035e-01f, 3.70116457e-02f,
  1.64038941e-01f, 4.00960706e-02f, 2.97478698e-02f, -1.75961196e-01f, -4.54769969e-01f, -2.77381033e-01f, -1.78026468e-01f, -1.46684811e-01f, -3.46038304e-02f, -4.56778228e-01f,
  5.78679182e-02f, -3.12275589e-01f, -1.12555072e-01f, 3.78415845e-02f, 3.15319980e-03f, -7.34611824e-02f, -3.63034040e-01f, 1.74078569e-02f, 5.93362860e-02f, -1.99704692e-01f,
  -2.99348295e-01f, -4.06055637e-02f, 8.93500298e-02f, 1.56029090e-01f, -2.58173179e-02f, -2.12287940e-02f, -6.32019015e-03f, 1.40698358e-01f, -2.66077459e-01f, 2.18965188e-01f,
  2.74139553e-01f, -2.17201546e-01f, -3.34090628e-02f, 9.71803814e-02f, 7.95912743e-02f, 1.51545510e-01f, 1.51060015e-01f, 6.86583892e-02f, 1.33204907e-01f, -9.65201184e-02f,
  1.12461850e-01f, -6.19698539e-02f, 4.80441079e-02f, 2.67438352e-01f, -1.57676041e-01f, 2.74381906e-01f, 3.33188176e-01f, 1.64913133e-01f, 2.24294253e-02f, 1.79128796e-01f,
  4.22264868e-03f, 3.32137346e-02f, 3.23862359e-02f, 3.31963003e-02f, -1.55352773e-02f, -1.65474549e-01f, 1.24739110e-01f, 1.52404949e-01f, 2.71416567e-02f, 1.36127129e-01f,
  3.39324120e-04f, -6.85436800e-02f, 1.01841688e-01f, 6.23969994e-02f, 1.52556285e-01f, -2.86402158e-03f, 5.46672940e-02f, -9.79644209e-02f, -3.47131975e-02f, 1.79693580e-01f,
  -4.79305312e-02f, 1.07086040e-01f, 2.61780750e-02f, -9.21149775e-02f, 2.08290249e-01f, -2.31531933e-01f, -1.48921218e-02f, -2.18152225e-01f, 3.16399872e-01f, 2.06213340e-01f,
  -2.53047317e-01f, -1.91710651e-01f, 1.94560200e-01f, -1.30481338e-02f, 5.40860407e-02f, -1.04889207e-01f, 1.74943730e-02f, -2.84008235e-01f, -6.98381066e-02f, 1.04707330e-01f,
  -2.62403470e-02f, -1.01957478e-01f, -1.53251663e-01f, 1.42804861e-01f, 7.95838982e-02f, -1.29742324e-01f, 1.64933100e-01f, -1.58067793e-01f, -5.37205078e-02f, -1.91123895e-02f,
  2.94058565e-02f, 1.17934979e-02f, 1.45167902e-01f, -1.54753923e-02f, -1.73660547e-01f, -4.49068099e-02f, 2.90991757e-02f, 2.26202950e-01f, 2.10040629e-01f, -7.58164423e-03f,
  -1.44121066e-01f, -8.20781011e-03f, 1.55901611e-01f, 2.38048146e-03f, -1.68385863e-01f, -1.46398827e-01f, -2.50261456e-01f, -1.38991773e-01f, 2.01605588e-01f, -6.44219294e-02f,
  1.30607709e-01f, -4.28278819e-02f, 9.95516181e-02f, 9.37091280e-03f, 1.11351594e-01f, -1.26998872e-01f, 1.83044717e-01f, 4.00353223e-03f, 1.41317528e-02f, -1.18782632e-01f,
  -6.21446557e-02f, 3.01483095e-01f, -1.66176055e-02f, 1.66685790e-01f, 9.78599861e-02f, -1.49730081e-02f, 3.05104107e-01f, 2.54594372e-03f, 1.36063561e-01f, -2.39443362e-01f,
  -1.50285095e-01f, -1.79127902e-01f, 3.15384090e-01f, 2.25822590e-02f, 3.41431886e-01f, -9.76404399e-02f, 3.67929131e-01f, 3.46818358e-01f, -1.69323877e-01f, -3.02444547e-01f,
  -1.09576039e-01f, 1.40290335e-01f, 9.80263725e-02f, 1.56837210e-01f, -5.58671691e-02f, 2.43714571e-01f, 9.46105197e-02f, -8.64444673e-03f, 2.40575686e-01f, 1.03025489e-01f,
  -3.31162363e-02f, -1.20416075e-01f, -6.38795495e-02f, 1.75541446e-01f, 1.72782451e-01f, -1.58687495e-02f, -7.46306181e-02f, 2.48014946e-02f, 1.12146676e-01f, 4.37722445e-01f,
  -2.84277145e-02f, -7.92103354e-03f, -1.65719762e-01f, 1.78376228e-01f, 1.71334103e-01f, 1.02541365e-01f, 6.94672614e-02f, 5.02494089e-02f, 1.44464541e-02f, 1.68961212e-01f,
  4.80607338e-02f, 1.89916074e-01f, 5.11956103e-02f, -9.22948197e-02f, 5.43873832e-02f, 1.07189596e-01f, -3.33230831e-02f, 1.77417994e-01f, 1.61160573e-01f, -4.82605956e-02f,
  4.87768874e-02f, 1.46963611e-01f, -1.97677054e-02f, 1.81388631e-01f, 5.37832566e-02f, -3.19151610e-01f, 1.38029620e-01f, -2.05877377e-03f, -6.27789944e-02f, -4.59644422e-02f,
  -6.83526993e-02f, -2.47057766e-01f, 1.54007226e-01f, -2.66240716e-01f, -1.67431049e-02f, 1.71580240e-01f, -1.52768061e-01f, -5.62899485e-02f, -4.29316193e-01f, 1.40635408e-02f,
  6.80175126e-02f, -2.54423112e-01f, -3.51706982e-01f, 1.01618350e-01f, 9.43892896e-02f, -5.85483911e-04f, 2.18795955e-01f, 2.43367881e-01f, 3.92657444e-02f, 1.87383905e-01f,
  7.26545881e-03f, 3.32034677e-01f, 4.28348966e-02f, 7.27292001e-02f, 2.25277975e-01f, 1.66398391e-01f, 7.05977529e-02f, -8.29083920e-02f, 8.43210071e-02f, 2.12946907e-01f,
  8.45689103e-02f, 9.42493454e-02f, 1.12547189e-01f, -3.28719884e-01f, 3.03607602e-02f, 1.90186381e-01f, 2.10964471e-01f, 1.14558063e-01f, -2.12027691e-02f, 3.16695459e-02f,
  2.06273511e-01f, 1.15482263e-01f, -2.32341234e-02f, 9.70452279e-02f, -1.66786402e-01f, -9.24516097e-02f, 2.38407552e-01f, -8.37121233e-02f, -1.30659221e-02f, 8.72536562e-03f,
  -2.68416945e-03f, -5.33173196e-02f, -7.72760734e-02f, -6.23465404e-02f, -5.96982148e-03f, 1.67331830e-01f, -1.63034524e-03f, 1.93929416e-04f, 6.89801350e-02f, 1.90479010e-01f,
  1.17726773e-02f, 1.52114838e-01f, 1.73796520e-01f, 2.76825838e-02f, 2.13067323e-01f, 8.26420337e-02f, 6.62088320e-02f, 5.17268479e-02f, -3.16479392e-02f, 1.02971205e-02f,
  1.32894039e-01f, 4.53971028e-02f, 3.30450475e-01f, 1.46878064e-02f, 1.41821966e-01f, 3.97667348e-01f, 3.83494347e-01f, -7.97110647e-02f, -1.73778113e-04f, 5.33417240e-02f,
  3.42139117e-02f, 1.44320101e-01f, -1.39651084e-02f, -4.05084155e-02f, 2.93062091e-01f, -1.16760813e-01f, 2.30774686e-01f, 1.26993358e-01f, 1.20683320e-01f, -9.91271138e-02f,
  1.53891277e-02f, 1.49895567e-02f, 5.08490615e-02f, 1.84915110e-01f, 1.55955508e-01f, 2.86634296e-01f, -4.04632166e-02f, 2.26910099e-01f, 1.53033704e-01f, 1.28358543e-01f,
  2.85023183e-01f, -1.35629773e-01f, -2.69463491e-02f, -1.44267395e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  1.30387634e-01f, -3.22588123e-02f, 1.47109613e-01f, 1.70023873e-01f, 5.15834279e-02f, 9.21527520e-02f, -2.71935407e-02f, 1.97625801e-01f, 4.92415279e-02f, 1.62312582e-01f,
  2.71167718e-02f, 1.68071643e-01f, -4.27118242e-02f, 9.91902202e-02f, 1.21332370e-01f, 1.67679861e-01f, -6.76943734e-02f, 1.83318153e-01f, 1.58065692e-01f, 5.95009401e-02f,
  -1.64594017e-02f, 9.27101374e-02f, 1.26668349e-01f, -8.30453932e-02f, -3.24789360e-02f, 8.17807242e-02f
};

// L3_fan_Wp (Shape: 19 x 64)
const int L3_fan_Wp_rows = 19;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  7.93154910e-02f, -1.20643899e-01f, -6.94768224e-03f, 9.96886566e-02f, -1.28531709e-01f, 4.47661243e-02f, -3.18910331e-02f, 2.26811655e-02f, -9.49168652e-02f, 7.37847686e-02f,
  3.51980701e-02f, 2.36128177e-02f, 4.42680083e-02f, -3.25540602e-02f, -5.86018376e-02f, -6.74085245e-02f, 2.83264369e-02f, -1.86025091e-02f, 6.42597824e-02f, -1.21901095e-01f,
  1.46409169e-01f, -1.32577628e-01f, 1.67152882e-01f, 6.10901602e-03f, -6.96944147e-02f, -6.89895451e-02f, 1.15508497e-01f, -2.33496539e-02f, -1.11125603e-01f, 1.06923006e-01f,
  1.25824571e-01f, -1.09846771e-01f, 9.15662944e-02f, -5.88085838e-02f, -8.58698972e-03f, -5.94466040e-03f, -1.34162471e-01f, -2.29529053e-01f, -1.03337958e-01f, 1.01063922e-01f,
  -7.97305927e-02f, -1.11023135e-01f, -1.03600353e-01f, -1.56643298e-02f, -6.92876354e-02f, 7.05184415e-02f, -1.65412545e-01f, -3.69770005e-02f, 8.37479532e-02f, -7.34424070e-02f,
  1.04313716e-02f, 2.25006476e-01f, 2.05738917e-01f, 4.36694734e-02f, 2.81228125e-02f, 3.14230621e-02f, 7.10984021e-02f, -9.10406038e-02f, 5.60367294e-02f, -8.48682895e-02f,
  8.96182004e-03f, -6.52261451e-02f, 6.85571507e-02f, 1.08882122e-01f, 6.35828450e-02f, 1.01856500e-01f, -8.55702385e-02f, 5.41976355e-02f, 1.04264632e-01f, 2.88428012e-02f,
  -1.51071919e-03f, 4.86507341e-02f, 2.88922098e-02f, -4.88992259e-02f, 1.49911776e-01f, 3.60532440e-02f, -4.41659801e-02f, 5.56438677e-02f, -5.00818044e-02f, 1.36772975e-01f,
  1.40135601e-01f, 8.81231427e-02f, -3.90191823e-02f, 1.66445598e-01f, -6.27766037e-03f, -1.17717102e-01f, -5.49690239e-02f, 5.02416827e-02f, 1.19541295e-01f, -1.39418961e-02f,
  -1.16347171e-01f, 1.74636871e-01f, 1.54078126e-01f, 2.50751972e-01f, -5.50107611e-03f, 1.15634408e-02f, -1.14693046e-01f, -1.56313926e-01f, 1.58604965e-01f, 5.45576252e-02f,
  -2.05797836e-01f, -1.04694471e-01f, -7.09995553e-02f, 2.25775391e-02f, 6.22793809e-02f, -7.78234676e-02f, 8.86124372e-02f, 9.76895019e-02f, -8.78234059e-02f, -9.97006446e-02f,
  -1.15943380e-01f, -1.45239279e-01f, -5.72603289e-03f, 5.51695488e-02f, 2.96852831e-02f, 6.38838932e-02f, -1.36545906e-02f, 1.33858055e-01f, -9.16105881e-02f, 1.96223184e-01f,
  1.59123782e-02f, 2.68614478e-02f, 1.38479784e-01f, 7.56592676e-02f, 3.25562507e-02f, 1.64106831e-01f, -1.29608542e-01f, 1.70819297e-01f, 3.76748964e-02f, 4.53829579e-02f,
  3.74299102e-02f, 1.93628445e-01f, 4.88721430e-02f, 1.65998563e-01f, -8.72722343e-02f, -5.12917787e-02f, -4.72899750e-02f, -3.22478339e-02f, 5.39564416e-02f, -2.09080353e-02f,
  -5.30317873e-02f, -3.64826024e-02f, -3.11314054e-02f, 3.78956236e-02f, 2.13070333e-01f, -6.05105376e-03f, -1.08574890e-01f, 1.84337467e-01f, -1.17409915e-01f, 2.84984931e-02f,
  -2.86505241e-02f, -2.42890995e-02f, 5.00200130e-02f, 1.78634509e-01f, 8.88839066e-02f, 1.79546475e-01f, 5.47233373e-02f, -5.96317230e-03f, 6.18848577e-03f, 3.90316099e-02f,
  -2.14844406e-01f, -1.23610452e-01f, 1.52498364e-01f, 2.01002881e-02f, -1.99608028e-01f, 1.47152364e-01f, 5.67850508e-02f, -1.58393204e-01f, -4.64172028e-02f, 1.05969347e-01f,
  -1.03534348e-01f, 5.02102785e-02f, 1.09385222e-01f, -3.94532569e-02f, 3.28949168e-02f, -5.60169183e-02f, 6.46357983e-02f, 9.03951675e-02f, -1.32388100e-01f, 7.56934732e-02f,
  -2.45326813e-02f, 1.79172069e-01f, 8.47057104e-02f, 1.57106873e-02f, 1.39187634e-01f, -6.76995516e-02f, -1.82391062e-01f, 4.59209792e-02f, 1.29191592e-01f, -1.15573816e-01f,
  4.09830101e-02f, -1.00484349e-01f, 5.13326488e-02f, -8.15840252e-03f, 4.15174896e-03f, -8.34352151e-02f, -6.89507052e-02f, -3.79918218e-02f, -6.44619688e-02f, -8.73865560e-02f,
  3.09512857e-02f, -1.16032636e-04f, 1.21860765e-01f, -8.01664367e-02f, 1.00643925e-01f, -3.09949741e-02f, -1.14395753e-01f, 7.77953640e-02f, -1.41873240e-01f, 1.88096669e-02f,
  2.52403542e-02f, 8.49709511e-02f, 4.37607653e-02f, -6.00951165e-03f, 1.28936559e-01f, -1.70575887e-01f, -2.06086021e-02f, -7.95587897e-02f, 4.28145900e-02f, -9.76677705e-03f,
  -1.11091562e-01f, -1.22392736e-01f, 7.54709840e-02f, -7.97995627e-02f, 9.56576765e-02f, -1.31293505e-01f, -5.26614115e-02f, -1.18718497e-01f, -4.06154338e-03f, -1.37841254e-01f,
  -1.49505973e-01f, -4.38943878e-02f, -1.87481001e-01f, 5.27086630e-02f, -6.59351200e-02f, -5.02752475e-02f, 1.40860543e-01f, 7.09050708e-03f, -1.36266991e-01f, 5.43608665e-02f,
  1.73281699e-01f, -8.72166380e-02f, -1.53200282e-02f, 1.12557560e-01f, 1.06463112e-01f, 7.04604536e-02f, -1.21356815e-01f, 1.49810091e-01f, 3.59943733e-02f, 1.07277207e-01f,
  -5.29507771e-02f, -1.02541752e-01f, -2.43223775e-02f, -1.15756415e-01f, 8.27309042e-02f, 1.46067083e-01f, -4.67091687e-02f, -3.28446575e-03f, 1.20373487e-01f, 7.61649981e-02f,
  -1.28073245e-01f, 7.14664534e-02f, 6.65218234e-02f, -5.73153282e-03f, 1.08985700e-01f, 9.75939631e-02f, 7.62375146e-02f, 5.06512774e-03f, -4.81493734e-02f, -7.97422975e-03f,
  -1.14977680e-01f, -1.27956569e-01f, -1.24215990e-01f, -1.78544477e-01f, -8.93900692e-02f, 1.30809266e-02f, -6.58645630e-02f, -1.57176688e-01f, -4.21594083e-02f, 6.08532652e-02f,
  2.88268719e-02f, -8.20724815e-02f, 4.63348851e-02f, 8.31293538e-02f, -5.11049293e-02f, 3.25501636e-02f, 3.15697908e-01f, -8.66093710e-02f, 1.11305550e-01f, -1.16691865e-01f,
  2.63924509e-01f, -9.62473638e-03f, 4.89371344e-02f, -2.41061687e-01f, -1.13913894e-01f, -1.28421903e-01f, 2.03929655e-03f, 1.81925371e-02f, -1.15043126e-01f, 7.81257972e-02f,
  -5.12865931e-02f, 1.17194347e-01f, -1.02687612e-01f, 7.15606213e-02f, 1.14084646e-01f, -2.61721481e-02f, 1.53967559e-01f, -5.56470416e-02f, 9.51535925e-02f, -1.29819885e-01f,
  -8.74061361e-02f, 1.03678510e-01f, -1.77236557e-01f, -1.26289595e-02f, -1.75588783e-02f, -2.73196064e-02f, -1.52726695e-01f, 7.48640150e-02f, -7.10070208e-02f, 1.10484555e-01f,
  1.67136383e-03f, 6.30035922e-02f, -5.24792783e-02f, -9.18322355e-02f, 5.17653227e-02f, 1.29938081e-01f, 4.28246371e-02f, 3.18488549e-03f, 1.28280476e-01f, -2.86254790e-02f,
  8.02345723e-02f, 2.99199075e-02f, -5.68223484e-02f, -1.69346784e-03f, -8.43065903e-02f, -7.76217505e-02f, 1.27684385e-01f, -9.13339630e-02f, -7.69318715e-02f, 2.29036272e-01f,
  1.18849808e-02f, -1.02828518e-01f, -1.11184776e-01f, -8.12826958e-03f, -1.22168601e-01f, -5.30699790e-02f, -1.06272288e-01f, 1.40493602e-01f, 1.31124541e-01f, 1.61929771e-01f,
  5.72828837e-02f, -7.53679723e-02f, 5.92915826e-02f, -2.07102358e-01f, 2.14340210e-01f, -7.73675088e-03f, -8.42996091e-02f, -7.08043054e-02f, -1.26702592e-01f, -1.41892612e-01f,
  -2.39373036e-02f, -6.81137443e-02f, -6.52062520e-02f, 9.38069448e-02f, -1.04566693e-01f, -3.62268798e-02f, -4.95387055e-02f, 1.34092897e-01f, 3.71230468e-02f, -5.71942935e-03f,
  -5.72251715e-02f, 1.25595972e-01f, -6.09190539e-02f, -3.55210761e-03f, 3.99669446e-02f, 6.12376370e-02f, 3.30964029e-02f, 5.36634848e-02f, 1.83516651e-01f, -7.63552636e-02f,
  2.20954306e-02f, 2.05154896e-01f, -5.00085130e-02f, -4.86900052e-03f, 2.20052432e-02f, -1.41241416e-01f, -3.01038381e-02f, 7.59858415e-02f, -2.53420435e-02f, 7.71816149e-02f,
  -3.28827240e-02f, -8.35860297e-02f, 7.63534680e-02f, -8.00239891e-02f, -2.42082123e-02f, 4.47847061e-02f, -1.34676835e-02f, -1.78939663e-02f, -3.21774259e-02f, 8.89939070e-03f,
  1.27881706e-01f, 1.43961534e-02f, 8.82559717e-02f, -1.67934775e-01f, 1.71641838e-02f, -9.34057087e-02f, -1.36394659e-02f, -7.53948465e-02f, -3.03928182e-03f, -9.73891318e-02f,
  9.00654867e-02f, 7.38146827e-02f, 1.29502773e-01f, 2.35012308e-01f, 2.10042626e-01f, 1.24352224e-01f, 2.41253898e-01f, -1.83309987e-01f, 1.04347438e-01f, -1.56116575e-01f,
  -1.00759082e-01f, -1.19735107e-01f, 1.37591928e-01f, -2.76260655e-02f, -9.57581401e-02f, -1.33947253e-01f, -6.85823932e-02f, 7.63169155e-02f, -1.84443787e-01f, 1.50478808e-02f,
  1.87209807e-02f, 9.69322920e-02f, 7.45610744e-02f, -1.21788800e-01f, -1.31208405e-01f, 5.44402972e-02f, 1.79853216e-01f, 2.64616329e-02f, -6.91487640e-02f, 3.51987593e-02f,
  -3.38408910e-02f, 6.57214150e-02f, 1.10893495e-01f, -1.80484489e-01f, 5.05218059e-02f, -2.68641729e-02f, -9.05168056e-02f, 1.36943713e-01f, -3.72748412e-02f, 7.62068257e-02f,
  9.15227458e-02f, -9.78207588e-02f, -1.03632949e-01f, -1.24968573e-01f, -1.19741641e-01f, -4.64415736e-03f, -9.60777234e-03f, -3.29724588e-02f, 4.71964777e-02f, -8.08434114e-02f,
  3.53108831e-02f, -1.39970168e-01f, 8.59085694e-02f, -1.84176341e-01f, -6.23079464e-02f, -7.07319155e-02f, 9.74742044e-03f, -2.63301700e-01f, 6.47908915e-03f, -2.34466553e-01f,
  7.43456930e-02f, 2.40264744e-01f, 8.00496191e-02f, -1.62029400e-01f, 2.01146007e-01f, -1.34166107e-01f, -9.67541635e-02f, -7.33769983e-02f, 2.35188976e-01f, 1.48926452e-01f,
  2.53372401e-01f, 2.33898265e-03f, -2.33874414e-02f, 8.47132877e-02f, 1.25626564e-01f, -1.65726945e-01f, -7.32508115e-03f, -6.49895426e-03f, 4.01047133e-02f, 5.80987781e-02f,
  2.75370516e-02f, 5.30508347e-02f, 4.99368496e-02f, 1.93863079e-01f, -2.06472948e-01f, 5.17903492e-02f, -1.28395945e-01f, 1.28978724e-02f, 3.88813717e-03f, 4.94313911e-02f,
  2.76923273e-02f, -6.58465996e-02f, -1.03624202e-01f, -2.07504071e-02f, -1.75793618e-01f, 1.26392156e-01f, -1.88712105e-01f, -3.86491418e-02f, -1.28297389e-01f, 1.70976575e-02f,
  3.72063788e-03f, -4.74449582e-02f, 2.56116893e-02f, 1.43604025e-01f, 1.65207703e-02f, 1.44522525e-02f, 9.58769619e-02f, 5.03574014e-02f, 9.04151425e-02f, 1.22562408e-01f,
  5.56672178e-02f, 4.13526073e-02f, 5.33124916e-02f, 8.13123435e-02f, -3.85654829e-02f, 1.60785869e-01f, 8.14951509e-02f, 4.23975848e-02f, 1.41334131e-01f, 5.29762954e-02f,
  -7.43481740e-02f, 5.91843128e-02f, 9.79303792e-02f, -2.91768983e-02f, -9.59485173e-02f, -4.74411659e-02f, -1.49809688e-01f, 7.60443211e-02f, -6.17801920e-02f, 2.53567323e-02f,
  -4.77124229e-02f, 1.59337521e-01f, 7.28902221e-02f, -1.29288331e-01f, 3.03853210e-02f, -1.85914293e-01f, 7.88854361e-02f, -1.32779658e-01f, 1.27715934e-02f, 6.25462160e-02f,
  1.96449477e-02f, 3.86379324e-02f, 2.89328154e-02f, 5.66207767e-02f, 9.53724384e-02f, -1.40901105e-02f, -1.41687587e-01f, -1.61731675e-01f, 1.31835565e-01f, 4.43297774e-02f,
  -5.88080883e-02f, 6.57013804e-02f, -7.77057782e-02f, 1.86755091e-01f, -1.62880450e-01f, -3.24720591e-02f, 4.20862027e-02f, 1.10621586e-01f, 1.77769020e-01f, -1.49457231e-01f,
  1.85433552e-02f, -5.71518913e-02f, 1.56394154e-01f, 7.00933635e-02f, 4.99746483e-03f, 5.55704571e-02f, 5.45496419e-02f, -1.22055253e-02f, -4.95114783e-03f, -1.94278494e-01f,
  6.17998876e-02f, 1.42267704e-01f, 2.08055794e-01f, 9.57202315e-02f, -8.99658054e-02f, 5.40551879e-02f, 7.08603263e-02f, 2.09877808e-02f, 1.95852946e-02f, -6.74838899e-03f,
  4.16008681e-02f, -7.07108388e-03f, 1.17655233e-01f, -1.70745496e-02f, 1.55187294e-01f, -9.99019220e-02f, 1.77419350e-01f, -5.03918715e-02f, -8.65537394e-03f, -9.67440605e-02f,
  1.72165930e-02f, -2.32508034e-01f, 2.94853486e-02f, -1.16658762e-01f, 1.96895618e-02f, 2.67145008e-01f, 5.57848811e-02f, 5.61843067e-02f, -6.55155554e-02f, 4.65012491e-02f,
  -1.80939019e-01f, 9.05024558e-02f, 1.43318340e-01f, -1.17581308e-01f, 7.68254101e-02f, 9.34743956e-02f, 1.02148518e-01f, 3.25297490e-02f, -1.55664608e-01f, 2.46000901e-01f,
  -1.58700109e-01f, 1.25870004e-01f, -1.14971086e-01f, -1.35272592e-01f, -1.66448057e-01f, -2.21653562e-03f, -1.27992257e-02f, -2.80217435e-02f, 7.00434223e-02f, 1.45256892e-01f,
  -1.02260850e-01f, -4.61189747e-02f, -9.90552902e-02f, 1.16550401e-01f, 2.51988441e-01f, 4.08584112e-03f, -8.12744796e-02f, 5.79664968e-02f, 8.37022290e-02f, -2.21872218e-02f,
  8.51615444e-02f, 3.74845825e-02f, -2.75185928e-02f, -1.72361106e-01f, -2.95088980e-02f, -1.92458518e-02f, 1.21446587e-01f, -1.84259308e-03f, 3.55819729e-03f, 8.52691531e-02f,
  -5.75540699e-02f, 5.81733398e-02f, 2.03689188e-02f, 6.06271997e-02f, -4.88541611e-02f, -2.74526123e-02f, -9.60370079e-02f, 1.44577101e-01f, -2.26370692e-02f, -8.49842653e-02f,
  2.67724037e-01f, 1.43989995e-01f, -3.09756380e-02f, -1.51317731e-01f, -1.49535343e-01f, -1.03552565e-01f, 1.04462191e-01f, -9.71169993e-02f, -1.85607478e-01f, 1.90667510e-01f,
  -1.70531511e-01f, 3.86521742e-02f, 5.81638142e-02f, 1.89148158e-01f, -1.13231726e-01f, 1.68418258e-01f, 1.50479198e-01f, -3.78279537e-02f, 1.89301670e-02f, 2.11133733e-01f,
  -7.66369998e-02f, -7.04696104e-02f, 1.19828405e-02f, 5.26220985e-02f, -1.06701687e-01f, 7.85766840e-02f, -2.36208439e-01f, 9.38401148e-02f, -2.36320704e-01f, -2.40641590e-02f,
  -1.12436436e-01f, -8.61788914e-02f, 1.38793081e-01f, -4.14372236e-03f, -9.78028029e-02f, -3.16592231e-02f, 7.15914518e-02f, 1.25468805e-01f, 1.14561126e-01f, -3.53219844e-02f,
  1.32769272e-02f, -7.05684070e-03f, 9.37154070e-02f, 1.71629831e-01f, -9.23835486e-02f, 9.19707566e-02f, 1.51626199e-01f, 1.10760957e-01f, 1.45162821e-01f, 7.91955390e-04f,
  -5.52405231e-02f, 4.59773391e-02f, 1.53817609e-01f, 9.48623493e-02f, -1.01054803e-01f, 4.14690524e-02f, -4.42510806e-02f, 1.13325819e-01f, -5.46949822e-03f, 1.46366745e-01f,
  1.10918805e-01f, -1.27076656e-01f, 6.77182749e-02f, 1.91943556e-01f, -2.59950548e-01f, -4.92850766e-02f, -1.82251111e-02f, -3.70480642e-02f, -1.06678583e-01f, 1.03262797e-01f,
  -7.01016337e-02f, -1.20355420e-01f, 2.19711378e-01f, -1.79248542e-01f, 2.17765957e-01f, -6.94349334e-02f, 3.36912423e-02f, 5.28178997e-02f, 8.79023969e-03f, -1.20919377e-01f,
  -7.98802152e-02f, -1.03587165e-01f, -5.25491089e-02f, -7.74016231e-02f, 1.02510683e-01f, -1.17504753e-01f, 2.42993012e-02f, -3.16971578e-02f, -3.90258059e-02f, -7.67900646e-02f,
  1.65873114e-02f, 3.31121162e-02f, 8.73963581e-04f, -6.80827424e-02f, 3.14835683e-02f, -1.13587953e-01f, 1.39249377e-02f, 8.73549134e-02f, -7.44022196e-03f, 1.87529802e-01f,
  -7.63558224e-02f, -1.69785768e-01f, -5.35526797e-02f, 8.43355432e-02f, -5.75282201e-02f, 1.67120486e-01f, -1.10021621e-01f, -2.55929749e-03f, -7.44870752e-02f, 1.19792648e-01f,
  1.13412783e-01f, 9.20172483e-02f, 1.45481741e-02f, -1.54113740e-01f, -1.03496730e-01f, 2.58880034e-02f, 4.61358391e-02f, 1.07040126e-02f, 7.62676671e-02f, -4.18848433e-02f,
  -1.58606004e-02f, -6.09038919e-02f, -3.94026339e-02f, 8.11707005e-02f, -1.10647991e-01f, 8.68770778e-02f, -9.92012173e-02f, -3.46594006e-02f, 5.64557984e-02f, -2.40829866e-02f,
  7.37383589e-02f, 2.07150728e-01f, 8.16334635e-02f, -2.50543212e-03f, 1.64379388e-01f, 6.47018999e-02f, 7.74065182e-02f, -1.69762284e-01f, 1.11078680e-01f, -1.56218484e-01f,
  6.49021268e-02f, -1.88230678e-01f, -5.12716845e-02f, -9.73600149e-02f, -1.52629748e-01f, 1.08282059e-01f, -9.30007733e-03f, 4.05494981e-02f, -7.44030103e-02f, 1.44883484e-01f,
  8.60942453e-02f, 5.36444085e-03f, 3.64006795e-02f, 2.04400215e-02f, 4.39573042e-02f, -8.90101045e-02f, -3.38335149e-02f, 3.54830027e-02f, -9.76188555e-02f, 9.40748155e-02f,
  -1.48786753e-01f, -1.81384291e-02f, -5.67907803e-02f, 1.87843218e-01f, 1.21632434e-01f, -6.67977706e-02f, -2.02224910e-01f, -7.96927661e-02f, 8.50573033e-02f, 3.79558988e-02f,
  1.08397692e-01f, -1.87652320e-01f, 9.94361341e-02f, 1.28917471e-01f, -2.75276117e-02f, -6.56186789e-02f, 1.01972334e-01f, -4.75237407e-02f, -3.41078006e-02f, -8.26388504e-03f,
  3.85546163e-02f, 2.58514415e-02f, -9.53733921e-02f, -9.16708410e-02f, 1.07541174e-01f, 6.53379560e-02f, -6.10404909e-02f, 1.51169479e-01f, 8.02004933e-02f, -8.72850046e-03f,
  4.52037379e-02f, 1.51486114e-01f, -2.09941030e-01f, 6.51645213e-02f, -4.31301780e-02f, -2.25760549e-01f, 8.92615765e-02f, 8.48349705e-02f, -1.05320781e-01f, -7.68081769e-02f,
  -8.29382464e-02f, -1.91690251e-02f, -1.51039790e-02f, 5.42865023e-02f, -1.89520493e-01f, 1.09728552e-01f, -6.09381087e-02f, 1.79825332e-02f, 1.96990371e-02f, 1.44783512e-01f,
  3.30140404e-02f, -7.43992180e-02f, 2.73047108e-02f, 1.10696301e-01f, 5.63376509e-02f, -1.28951192e-01f, 5.54726943e-02f, -6.25927150e-02f, 1.14963874e-01f, -6.73434958e-02f,
  7.28304163e-02f, 2.19360236e-02f, 4.67400700e-02f, -3.81219536e-02f, -1.63914010e-01f, -5.84843494e-02f, 8.77994299e-02f, -1.40337318e-01f, 5.79320155e-02f, 1.77008227e-01f,
  4.88838442e-02f, -2.62772664e-02f, 8.21110755e-02f, 1.42942998e-03f, 2.17211202e-01f, 8.06711614e-02f, -6.05569743e-02f, 1.58454299e-01f, 1.06065527e-01f, -1.92391947e-02f,
  5.84106483e-02f, 4.45342474e-02f, 1.19571917e-01f, 1.62869673e-02f, -4.13255766e-02f, 1.39845982e-02f, 1.46900686e-02f, 4.48591746e-02f, -5.04848175e-02f, -1.03692621e-01f,
  7.19220042e-02f, -6.85585663e-02f, 1.09969437e-01f, -9.88310501e-02f, -4.14654240e-02f, 1.18451901e-01f, -5.68223000e-02f, 3.32233170e-03f, -5.89200892e-02f, 1.44713119e-01f,
  -2.54061222e-02f, 1.60214350e-01f, -1.11134030e-01f, -1.22285113e-02f, -4.51858081e-02f, -2.49301940e-01f, -2.10902508e-05f, -3.54134501e-03f, -2.50373930e-01f, 1.87393725e-01f,
  -1.10287361e-01f, 1.46865055e-01f, -6.23056516e-02f, 1.40980467e-01f, -7.34940618e-02f, -6.38160259e-02f, 1.08486705e-01f, -6.68716477e-03f, 1.81499973e-01f, -5.45506068e-02f,
  -6.21976331e-02f, 3.60192284e-02f, 1.20919436e-01f, 7.11484207e-03f, -1.37597606e-01f, 1.27470404e-01f, 1.07481182e-01f, -1.63009077e-01f, -1.87157094e-01f, 4.92800139e-02f,
  -1.08851932e-01f, 1.32383320e-05f, -2.33190991e-02f, -1.32502720e-01f, -2.07340166e-01f, 1.62076071e-01f, -7.10253045e-02f, 6.45490438e-02f, -4.80980240e-02f, -1.20640047e-01f,
  1.35084704e-01f, 7.93993250e-02f, 1.18522212e-01f, 5.59226237e-02f, 1.33510396e-01f, -7.07812831e-02f, 1.38951927e-01f, -3.46991606e-02f, -1.11196144e-03f, 3.73428874e-02f,
  -9.14621651e-02f, -1.09801674e-03f, -1.35152116e-01f, 1.56878248e-01f, 2.65390538e-02f, 3.56478803e-02f, -1.86421517e-02f, 1.33155763e-01f, -4.63770702e-02f, -1.17034897e-01f,
  4.42790315e-02f, 2.29024217e-01f, 1.00022487e-01f, -8.12660530e-02f, 1.95111260e-02f, 3.96157876e-02f, 5.61618358e-02f, -2.85807461e-01f, -8.12310725e-02f, -3.74622457e-02f,
  -1.77939415e-01f, 2.26665467e-01f, 6.49802610e-02f, 2.26815671e-01f, -2.32483760e-01f, 1.28353894e-01f, 4.03561853e-02f, 1.70717947e-02f, -5.69958873e-02f, 2.05183104e-01f,
  4.89707477e-02f, 1.67036444e-01f, 1.77270919e-01f, -7.69704729e-02f, 1.17406416e-04f, 3.07594426e-02f, 3.17845009e-02f, -1.35646522e-01f, -8.41737762e-02f, 1.09120570e-01f,
  -7.38596218e-03f, 3.89869581e-03f, 2.74468418e-02f, -1.40489653e-01f, 2.35975925e-02f, -3.72349210e-02f, -1.40959784e-01f, 6.12507835e-02f, -5.78741618e-02f, -7.43287802e-02f,
  -1.25690147e-01f, 4.76645790e-02f, -7.21102133e-02f, -1.77918553e-01f, 2.94386502e-02f, -6.57296255e-02f, 3.46706808e-02f, -1.47571981e-01f, -3.11053973e-02f, 7.39714950e-02f,
  -6.52270988e-02f, -1.24328829e-01f, 1.09931611e-01f, -1.94960222e-01f, -1.36066020e-01f, -7.65622640e-03f, 4.74689826e-02f, 4.46679303e-03f, 6.32432848e-02f, -4.05095965e-02f,
  5.28699011e-02f, -1.33972004e-01f, 4.54195254e-02f, 1.21698819e-01f, 1.54100582e-01f, -2.17920393e-02f, -1.80882126e-01f, 3.41830067e-02f, -1.27211899e-01f, 1.00598618e-01f,
  -1.81164928e-02f, 1.28000513e-01f, -3.98329422e-02f, -3.53334807e-02f, -4.24168147e-02f, -1.38248295e-01f, 2.83546839e-02f, -1.22350082e-01f, -1.59790833e-02f, -1.78028718e-01f,
  7.57390186e-02f, 8.62255692e-02f, 2.51551289e-02f, 1.11940335e-02f, -2.51486693e-02f, 5.65902963e-02f, -1.33101016e-01f, 1.09917052e-01f, -1.22530431e-01f, 2.37698555e-02f,
  -9.58580002e-02f, 3.88323553e-02f, 1.72369570e-01f, 8.05263370e-02f, -9.54430103e-02f, 5.00502698e-02f, 7.66180642e-03f, -7.10750073e-02f, -2.52435319e-02f, 9.83094051e-02f,
  2.12799367e-02f, 2.12933496e-02f, 1.93441227e-01f, 5.70445769e-02f, 1.78868726e-01f, -6.03504628e-02f, -1.10955842e-01f, -8.16191807e-02f, -1.07172374e-02f, -1.88168973e-01f,
  -1.07127622e-01f, 5.78335263e-02f, -1.22484304e-01f, 7.61064366e-02f, -5.79398163e-02f, 8.03387687e-02f, -1.75257936e-01f, 1.74669120e-02f, 1.36492625e-02f, -9.45946872e-02f,
  5.79527915e-02f, -9.65055376e-02f, -1.59692049e-01f, 5.51342629e-02f, 1.15111964e-02f, -2.40665432e-02f, -1.48746878e-01f, -3.63608077e-02f, -1.19593509e-01f, 6.72437996e-02f,
  7.29418322e-02f, -1.56252414e-01f, 2.95686517e-02f, 7.93826953e-02f, 1.09306715e-01f, -1.14161007e-01f, -3.38934138e-02f, -1.08946688e-01f, -1.10510085e-02f, -1.55037329e-01f,
  4.30990243e-03f, -1.58293828e-01f, 1.47170961e-01f, -8.90147611e-02f, -6.97766244e-02f, -1.90951213e-01f, -1.10057734e-01f, 9.87443924e-02f, -1.68713555e-01f, -9.15424228e-02f,
  -4.44015786e-02f, -6.13888502e-02f, -9.92826279e-03f, 5.23665398e-02f, -6.04859814e-02f, 2.69812923e-02f, -1.63171235e-02f, -9.89336297e-02f, 1.07490294e-01f, 9.11624059e-02f,
  2.02562183e-01f, -2.66599897e-02f, 4.70986813e-02f, 3.50820981e-02f, 3.46388039e-03f, 1.56357422e-01f, 6.93150461e-02f, -6.97620139e-02f, 5.38316257e-02f, 6.32150751e-03f,
  5.31551279e-02f, 7.75248036e-02f, 5.64960539e-02f, 1.12872999e-02f, 1.28342584e-01f, -4.51080911e-02f, 1.55549616e-01f, -8.17515403e-02f, -3.07299402e-02f, 3.09324432e-02f,
  1.02543578e-01f, -8.36321414e-02f, -4.71141450e-02f, 6.62546009e-02f, -4.69851457e-02f, 3.51475962e-02f, 2.64165998e-02f, -2.81352624e-02f, -5.51673733e-02f, -3.07424050e-02f,
  1.16874464e-01f, -3.81883420e-02f, -3.27426009e-02f, -7.43632689e-02f, 4.21525836e-02f, 4.16300260e-02f, -6.62767813e-02f, 1.49043500e-01f, -1.01557717e-01f, 1.84910446e-01f,
  -4.20743935e-02f, -1.32522536e-02f, -1.01681694e-01f, -1.65371206e-02f, 2.83642709e-02f, -2.75595183e-03f, -5.38511239e-02f, -2.00614110e-01f, -2.12156743e-01f, 3.51973809e-02f,
  -5.97831570e-02f, 6.71326295e-02f, -3.33491154e-02f, 1.61047235e-01f, -4.30456772e-02f, -2.64658239e-02f, -2.31548660e-02f, -5.49011193e-02f, 1.45833135e-01f, -9.13734883e-02f,
  1.59138203e-01f, 3.49464491e-02f, -9.22111198e-02f, 2.62200069e-02f, -1.50065452e-01f, 1.18632764e-01f, -4.31830846e-02f, 1.50397927e-01f, 1.03404619e-01f, -1.12269312e-01f,
  -7.70245120e-02f, -3.91034186e-02f, 1.98857233e-01f, -1.06776282e-02f, 9.05973986e-02f, -3.14452648e-02f
};

// L3_fan_Wp_bar (Shape: 26 x 64)
const int L3_fan_Wp_bar_rows = 26;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  1.12850808e-01f, 6.43547550e-02f, 1.32473543e-01f, -1.38735399e-01f, 5.23923598e-02f, 2.37489641e-01f, 2.59808928e-01f, 6.60815686e-02f, 4.03157389e-03f, 5.29265814e-02f,
  -1.39342204e-01f, 1.83714762e-01f, -9.89922136e-03f, 4.50904109e-02f, -7.45573863e-02f, 2.51958836e-02f, -1.60508752e-01f, -3.09123904e-01f, 1.62187636e-01f, 8.59354660e-02f,
  -1.15346022e-01f, -1.60071135e-01f, -1.04185864e-01f, -1.77768283e-02f, -1.45278931e-01f, -3.22400481e-02f, -5.23770936e-02f, 1.65042542e-02f, 1.12164602e-01f, 3.88364285e-01f,
  2.99203992e-01f, 1.61504373e-01f, 1.21898577e-01f, -2.35068172e-01f, 2.85154045e-01f, -1.52901247e-01f, -1.57903492e-01f, 1.32914158e-02f, 3.57190445e-02f, -2.54699271e-02f,
  4.35931534e-02f, 1.86405331e-03f, 2.11228058e-02f, 3.68376434e-01f, -1.49411336e-01f, -1.06119420e-02f, -1.39595613e-01f, -2.80583445e-02f, 8.60214829e-02f, 3.11324865e-01f,
  -7.75779188e-02f, 2.99126625e-01f, 2.65048563e-01f, 2.37186439e-02f, -2.06567794e-02f, 9.09206569e-02f, 4.98555414e-03f, 4.42041121e-02f, 2.22573057e-01f, -1.33864239e-01f,
  1.92997947e-01f, 3.33155841e-01f, -1.05143450e-01f, 2.92530239e-01f, -1.62843376e-01f, 1.90952495e-02f, -2.05218673e-01f, -6.98857307e-02f, -1.40183181e-01f, -6.94012037e-03f,
  -1.68390349e-01f, -1.98453724e-01f, -2.02484593e-01f, 7.22563788e-02f, 1.25706896e-01f, 5.33572212e-02f, -1.67379051e-01f, 3.40609923e-02f, 3.61818485e-02f, -1.92829117e-01f,
  5.97859547e-02f, 8.16094130e-02f, -1.46743923e-01f, -1.43274471e-01f, 3.53861563e-02f, 3.83094370e-01f, -1.86861023e-01f, -6.39209077e-02f, 1.95839927e-01f, -1.91887170e-02f,
  -5.06945001e-03f, -5.00959717e-02f, -2.17052743e-01f, 3.48187834e-01f, -3.05648744e-01f, 2.53517061e-01f, -1.80495664e-01f, 2.98243463e-01f, -2.77727425e-01f, -1.32710591e-01f,
  -2.60355681e-01f, -3.03947479e-01f, 5.79960644e-02f, -1.71723813e-02f, 3.54071856e-01f, 2.22546920e-01f, 3.70778106e-02f, -4.57581095e-02f, 1.18608780e-01f, -9.75678712e-02f,
  -1.33061826e-01f, 3.02158415e-01f, -7.82747418e-02f, 1.93923280e-01f, 9.81116295e-02f, 4.71855104e-02f, 3.07644933e-01f, 2.22922757e-01f, -2.75949156e-03f, -1.96994215e-01f,
  -8.00522491e-02f, 2.96175368e-02f, 1.16330810e-01f, -7.39150047e-02f, -6.03843927e-02f, -7.78556913e-02f, 1.64624900e-01f, 1.72971994e-01f, 1.17901288e-01f, 1.41021773e-01f,
  -5.21847084e-02f, 5.70109375e-02f, 1.23323500e-01f, -1.63437296e-02f, 1.25413179e-01f, 5.92977628e-02f, -2.77028810e-02f, 6.92863092e-02f, 1.81548670e-01f, 2.18286738e-01f,
  -1.60542563e-01f, 1.58209745e-02f, 1.41834468e-01f, -1.59398884e-01f, 2.95562804e-01f, 2.10236117e-01f, 1.12922996e-01f, -8.07415992e-02f, 2.50551611e-01f, 9.33410898e-02f,
  2.13423938e-01f, 1.39732093e-01f, 2.65407152e-02f, 2.63630282e-02f, 1.38855979e-01f, -3.71992856e-01f, -9.04269442e-02f, 4.50747639e-01f, -2.45720267e-01f, 2.53186136e-01f,
  -3.65548134e-01f, 3.39486122e-01f, -1.72444895e-01f, -1.88348696e-01f, -3.10426325e-01f, -1.31896853e-01f, 3.70117038e-01f, 6.48078769e-02f, 3.64478320e-01f, 2.32203454e-01f,
  2.54142880e-01f, -1.24274038e-01f, 9.19043943e-02f, -2.16363668e-01f, 2.71351337e-01f, -2.25154892e-01f, -1.74273521e-01f, 1.97610050e-03f, -2.10494488e-01f, 5.86343668e-02f,
  1.79555476e-01f, 3.11346024e-01f, 1.08187228e-01f, -1.56796440e-01f, 5.50465584e-02f, 5.49249239e-02f, -8.25477019e-02f, -2.49342024e-01f, 5.58176376e-02f, 7.47048259e-02f,
  9.45646167e-02f, 1.17641971e-01f, 3.26057198e-03f, 1.12950608e-01f, 1.43602774e-01f, 2.73535311e-01f, 7.49651119e-02f, -1.65357396e-01f, 1.01308502e-01f, -1.66940957e-03f,
  -8.53548199e-02f, -3.89964171e-02f, 1.25658184e-01f, -2.85112672e-02f, 1.52563214e-01f, 1.22881167e-01f, 2.44552821e-01f, 1.97992831e-01f, -5.96067831e-02f, 1.00191921e-01f,
  -8.38279948e-02f, 5.24796009e-01f, -3.15277070e-01f, 2.44775012e-01f, -1.66209295e-01f, -8.98745209e-02f, 6.71410039e-02f, 3.29195559e-01f, -4.65936124e-01f, 1.03027083e-01f,
  9.47853699e-02f, -9.62300748e-02f, -1.68923631e-01f, -8.42735171e-02f, -2.11135253e-01f, -8.54372829e-02f, 2.91322589e-01f, 1.62831508e-02f, -2.95478612e-01f, 1.47380605e-01f,
  -2.47421712e-02f, -1.20697267e-01f, 2.71435529e-01f, -1.68326735e-01f, 2.08827689e-01f, -1.79805130e-01f, 1.98300093e-01f, -2.15703741e-01f, 3.00105661e-01f, 1.74784407e-01f,
  4.16410007e-02f, 1.21871103e-02f, 2.77532816e-01f, -1.13709137e-01f, -3.00784379e-01f, 2.94290155e-01f, -8.98318142e-02f, 9.71938744e-02f, 1.05002441e-01f, -1.90605968e-01f,
  4.39211763e-02f, 2.40773842e-01f, 3.79900075e-02f, 1.86314166e-01f, 1.73628762e-01f, -2.88092787e-03f, -8.08814913e-02f, -6.12813830e-02f, 6.72062486e-02f, 1.76237039e-02f,
  -7.61223258e-03f, 1.00091808e-01f, 1.75454006e-01f, 1.91152811e-01f, 1.09439410e-01f, -4.11748551e-02f, -1.46678332e-02f, -9.38457921e-02f, 8.36108103e-02f, 5.45553677e-02f,
  5.20886704e-02f, 7.05147535e-02f, -1.47821745e-02f, -2.51345217e-01f, -1.94231756e-02f, 3.33840907e-01f, -2.25230038e-01f, -1.28756449e-01f, -2.03236118e-02f, -3.19332480e-02f,
  2.14769412e-02f, -1.49315417e-01f, -2.19758689e-01f, 4.90746677e-01f, 1.73325688e-01f, -5.90278149e-01f, 8.49183872e-02f, -8.67084935e-02f, 8.70262146e-01f, -5.93806207e-01f,
  9.34116304e-01f, -1.59620032e-01f, 3.17700565e-01f, -2.02979730e-03f, -1.59971535e-01f, -3.53592724e-01f, -1.08213224e-01f, 2.58531645e-02f, -1.66994911e-02f, -1.08375624e-01f,
  1.06088698e-01f, -4.96300459e-02f, 1.25964761e-01f, 3.75760019e-01f, 2.51380920e-01f, -9.46843065e-03f, 4.77650553e-01f, 5.63706718e-02f, -3.65492284e-01f, -6.35656044e-02f,
  2.19103545e-02f, 3.95749696e-02f, 1.07153818e-01f, -5.09209871e-01f, 1.11615717e-01f, 7.13916004e-01f, 3.22959483e-01f, 2.23309711e-01f, -1.49388965e-02f, 8.74319300e-02f,
  -3.65747549e-02f, 9.14315283e-02f, 9.88469124e-02f, -1.61652938e-02f, 8.91883075e-02f, 4.15215679e-02f, 1.27903730e-01f, 6.05311580e-02f, 9.27727520e-02f, -2.37932075e-02f,
  -9.75864083e-02f, 4.12675040e-03f, 2.68927425e-01f, -1.01563573e-01f, 7.53631443e-02f, 8.97277445e-02f, 3.80825773e-02f, 5.80657683e-02f, 2.12279577e-02f, 1.06299736e-01f,
  -4.70417812e-02f, -1.71167478e-01f, 1.03027113e-02f, 1.20178871e-01f, -3.38478759e-02f, 9.81515795e-02f, -6.03537932e-02f, 3.48824501e-01f, 1.62988044e-02f, -2.84464210e-01f,
  1.08632311e-01f, -1.79683402e-01f, -8.07382464e-02f, -2.28059247e-01f, 1.62461385e-01f, 6.27549887e-02f, 1.20600820e-01f, 1.98069453e-01f, 1.61330700e-02f, 2.05431789e-01f,
  -5.94608635e-02f, -2.95834932e-02f, -3.04724853e-02f, 1.85328186e-01f, 1.66991010e-01f, -7.36898705e-02f, -5.27878590e-02f, 9.76087302e-02f, 1.94773227e-01f, -2.80713558e-01f,
  -6.13645762e-02f, -8.11664909e-02f, -1.12658538e-01f, 1.07626542e-01f, 2.40017902e-02f, 2.06472188e-01f, 5.74854761e-02f, -1.12191448e-02f, -6.68013990e-02f, 2.44928077e-01f,
  1.61651865e-01f, 1.71304733e-01f, 1.11154564e-01f, 3.86038534e-02f, -8.22304487e-02f, -8.78439397e-02f, 4.27874140e-02f, -3.80917490e-02f, -7.53777474e-02f, -1.26166627e-01f,
  -7.59937912e-02f, 4.82748747e-02f, -8.49516615e-02f, 3.10657406e-03f, -7.14029968e-02f, 2.52126995e-02f, 8.09843838e-02f, 1.80566534e-02f, 4.94383350e-02f, -4.38060472e-03f,
  -2.82848161e-03f, 2.31903475e-02f, 4.62894514e-02f, -7.79014900e-02f, 1.34517059e-01f, 7.40139931e-02f, 1.20116495e-01f, 2.85032578e-02f, -1.16503507e-01f, 4.89235632e-02f,
  -2.57923640e-02f, 5.93555309e-02f, 1.09082878e-01f, 7.77007192e-02f, -2.47923750e-02f, 7.52466768e-02f, -6.71480894e-02f, 6.76263124e-02f, 1.04770713e-01f, -2.11031903e-02f,
  4.36849296e-02f, -7.71234781e-02f, -1.08401746e-01f, 3.10429800e-02f, 4.84197726e-03f, -1.25335053e-01f, 1.07367165e-01f, 7.64365345e-02f, -1.28203139e-01f, -1.18644118e-01f,
  -9.87709872e-03f, 1.03118151e-01f, -7.76890367e-02f, 1.75179355e-02f, -8.35597813e-02f, -1.22592658e-01f, -6.00706190e-02f, -6.46359986e-03f, -8.21519196e-02f, 1.72905345e-02f,
  8.62749144e-02f, 5.91098629e-02f, 9.00485963e-02f, -6.19093329e-02f, 5.35665778e-03f, -1.12424798e-01f, 9.25540403e-02f, 5.18150255e-03f, 1.67799756e-01f, 3.09624195e-01f,
  1.18317768e-01f, 2.13910937e-01f, 7.29476586e-02f, -2.73612976e-01f, 2.00718895e-01f, 5.03063202e-02f, 2.30276152e-01f, 2.14072019e-01f, 7.71445557e-02f, -1.19637735e-02f,
  1.79285094e-01f, -1.97373913e-03f, 1.93330362e-01f, 1.21170081e-01f, 1.37852713e-01f, 1.31249294e-01f, 4.88712043e-02f, 1.44838542e-01f, -3.67267802e-02f, -2.88551360e-01f,
  1.93171754e-01f, 3.59590441e-01f, -6.16173632e-02f, 1.63283944e-01f, 1.42824292e-01f, 6.52762642e-03f, 2.15207398e-01f, -2.34077349e-01f, 1.93244025e-01f, 6.75963759e-02f,
  -1.01462841e-01f, 4.99544442e-02f, -2.13667318e-01f, -1.75806135e-01f, -2.58236617e-01f, 1.63347036e-01f, 3.00067484e-01f, 1.02065153e-01f, 2.49584764e-01f, 1.31569967e-01f,
  1.39365315e-01f, 1.53915733e-01f, -4.80799861e-02f, 1.31128922e-01f, 4.41457242e-01f, -3.64413142e-01f, 2.76097916e-02f, -4.58006173e-01f, -1.56727329e-01f, -9.78753120e-02f,
  -1.26102656e-01f, 2.18006186e-02f, -6.33601546e-02f, 3.73194933e-01f, -5.15207723e-02f, -1.05857477e-01f, -2.80329555e-01f, 1.58444848e-02f, -3.92042696e-02f, 2.06693143e-01f,
  1.94432154e-01f, -2.39512295e-01f, 5.00008278e-02f, 6.72193542e-02f, 9.92687047e-02f, 1.35650650e-01f, 5.11188805e-02f, -3.19158770e-02f, -3.65495123e-02f, 1.99022532e-01f,
  1.40347332e-02f, -1.55562023e-02f, -1.71661954e-02f, -7.45632499e-02f, 7.40406737e-02f, 1.22477271e-01f, 1.29765511e-01f, 1.56994626e-01f, 1.28881499e-01f, -1.98166631e-02f,
  -3.07866354e-02f, 4.11079347e-01f, -3.75891596e-01f, 8.89313072e-02f, -1.96579933e-01f, -1.85406551e-01f, 1.99605804e-02f, 1.78130865e-01f, -3.66813749e-01f, 3.12302381e-01f,
  2.21608743e-01f, -1.19817585e-01f, -2.53147840e-01f, -1.97115719e-01f, -1.26482069e-01f, -1.58852309e-01f, 2.50968516e-01f, 9.47309583e-02f, -1.63411811e-01f, 1.78081170e-01f,
  -9.30087343e-02f, -1.62481830e-01f, 6.88188449e-02f, -1.09472282e-01f, 9.83366594e-02f, 1.94084376e-01f, 2.33887002e-01f, -1.07148297e-01f, 2.17006635e-02f, -6.47022799e-02f,
  2.02425033e-01f, 6.31498024e-02f, 1.57031238e-01f, 2.23627865e-01f, -2.84842998e-01f, 1.59028441e-01f, -1.62948482e-02f, 2.29226276e-01f, 2.77331799e-01f, -1.25124961e-01f,
  3.47728021e-02f, 5.71295582e-02f, 3.31736207e-01f, 2.32200876e-01f, 1.79196298e-01f, 1.08977042e-01f, -6.56244531e-02f, 5.54096047e-03f, 4.72239256e-02f, 9.21223462e-02f,
  -8.79162028e-02f, 1.29260570e-01f, -9.63053629e-02f, -3.61292697e-02f, 8.82528350e-02f, -7.66461790e-02f, 3.55330370e-02f, -1.08008817e-01f, 4.29066569e-02f, -9.44058374e-02f,
  3.12680043e-02f, -8.75278190e-02f, -4.43698615e-02f, 2.21689064e-02f, -3.36458795e-02f, -9.74245835e-03f, -6.16005622e-03f, -3.20697762e-02f, -1.19221888e-01f, -9.24071446e-02f,
  6.01314427e-03f, 1.72627363e-02f, -4.09237593e-02f, -4.06370349e-02f, -1.05037972e-01f, -7.99624100e-02f, 2.89616920e-02f, -8.51552412e-02f, -4.57117036e-02f, 9.02626440e-02f,
  -2.85763107e-02f, 6.23729192e-02f, -1.30467825e-02f, -3.40341479e-02f, -7.71537423e-02f, 6.53264225e-02f, -1.04854247e-02f, 4.75775357e-03f, 1.06741481e-01f, 1.08626083e-01f,
  -7.94748887e-02f, -3.72878760e-02f, -1.21028595e-01f, 7.81332925e-02f, 4.03746776e-02f, -1.03595778e-01f, -1.73644479e-02f, -5.04464768e-02f, -1.33979306e-01f, -1.05443642e-01f,
  -1.04641199e-01f, -1.03681318e-01f, 5.56130558e-02f, 5.80214076e-02f, -1.56302899e-02f, 9.62160751e-02f, -9.25028622e-02f, -8.06585103e-02f, -7.89120346e-02f, 6.85970783e-02f,
  1.10954888e-01f, -1.61815621e-02f, -3.78044456e-01f, -1.80629045e-01f, -1.16387002e-01f, 3.17713261e-01f, 9.99407619e-02f, 6.29844666e-02f, -2.53490746e-01f, 1.33832738e-01f,
  -5.80701157e-02f, -1.12049639e-01f, 3.09574809e-02f, -6.17324486e-02f, -3.40479240e-02f, -3.34766507e-01f, 4.60469007e-01f, 3.36821318e-01f, 3.48222405e-02f, 9.08851251e-02f,
  6.08749650e-02f, 2.16949940e-01f, -2.72952821e-02f, -3.84533972e-01f, 2.04188257e-01f, -1.48542568e-01f, -9.61724371e-02f, 9.09388363e-02f, -8.26950818e-02f, 4.64335144e-01f,
  -4.27849919e-01f, 2.34795615e-01f, -4.15311068e-01f, 1.64766535e-01f, 3.13039720e-02f, 1.07715413e-01f, -2.46131960e-02f, 4.82588867e-03f, 8.21444392e-02f, 1.12203218e-01f,
  5.17584803e-03f, -2.21124920e-03f, -2.02706441e-01f, 1.82578862e-01f, -1.15163341e-01f, -1.02031358e-01f, -3.72984707e-01f, -4.03384753e-02f, -9.20561105e-02f, 6.20515227e-01f,
  -8.88866186e-02f, 1.77011952e-01f, 1.64849743e-01f, 2.74858952e-01f, -9.64556187e-02f, -1.21465519e-01f, 1.16502114e-01f, 1.93113998e-01f, 1.02328651e-01f, -9.24223587e-02f,
  5.75127713e-02f, -1.73947126e-01f, 1.05266884e-01f, 2.38470897e-01f, 1.59750551e-01f, 5.92477284e-02f, 2.06215933e-01f, 1.71661794e-01f, -2.24220436e-02f, 3.37787002e-01f,
  1.42236650e-01f, 8.10030848e-03f, 1.94020107e-01f, -5.39137535e-02f, -5.61194643e-02f, 2.90449262e-02f, -1.23051964e-01f, 1.70446813e-01f, 1.17178842e-01f, -3.93005162e-02f,
  -8.22862238e-02f, 2.95016672e-02f, 5.20277955e-02f, 1.64940581e-01f, -1.99787170e-01f, 1.67519413e-02f, -5.72921596e-02f, -3.26842338e-01f, 1.60331894e-02f, 7.14163762e-03f,
  1.43809514e-02f, 1.84741184e-01f, 2.59354115e-01f, 1.83733910e-01f, 2.31750622e-01f, -1.02194168e-01f, -1.06459297e-01f, -3.22689682e-01f, 2.42196932e-01f, -6.71448708e-02f,
  1.02474824e-01f, 1.86268181e-01f, 4.06853333e-02f, 5.46642207e-02f, -9.33531150e-02f, -1.60620064e-01f, -7.84984902e-02f, 3.70106667e-01f, -2.12704673e-01f, 1.87493563e-01f,
  -1.44009292e-02f, -1.36958972e-01f, 3.44446003e-01f, 4.34287041e-01f, 6.43991400e-03f, 2.18716875e-01f, -7.56836459e-02f, 2.34349579e-01f, 2.70818323e-02f, 2.37240225e-01f,
  1.84173256e-01f, 1.12109616e-01f, 3.38238746e-01f, 2.26904824e-02f, 2.63936549e-01f, 2.20195483e-02f, -7.79690174e-03f, 3.09917122e-01f, -7.33969500e-03f, 2.06444249e-01f,
  1.39098123e-01f, -1.90391183e-01f, -4.48564291e-02f, -1.32082608e-02f, 1.96525112e-01f, 3.16886939e-02f, 2.11091608e-01f, 2.18084633e-01f, 6.81180358e-02f, -2.62685213e-02f,
  -3.90618667e-02f, -2.64126323e-02f, 2.27196142e-01f, 7.11583123e-02f, -7.70712346e-02f, -5.90406001e-01f, 6.54155836e-02f, -9.06784646e-03f, 9.25567560e-03f, -4.78635579e-01f,
  -4.61780615e-02f, 3.70322138e-01f, 8.72515887e-02f, -2.94873118e-01f, -1.61741912e-01f, 2.40252629e-01f, 9.31111351e-02f, 1.64078057e-01f, 6.29178822e-01f, 2.41112426e-01f,
  2.74638176e-01f, 5.72947748e-02f, 1.51372269e-01f, -6.32191002e-02f, 2.03574859e-02f, -1.87782407e-01f, 1.92631796e-01f, -1.84900314e-01f, 2.20136791e-01f, -2.11383224e-01f,
  -4.72149625e-02f, 3.92371655e-01f, -8.20827186e-02f, 7.07824752e-02f, 1.53165450e-02f, -4.76057082e-03f, -8.68309438e-02f, -3.85197580e-01f, 7.78227448e-02f, 1.67822577e-02f,
  1.74920633e-01f, 6.92015365e-02f, -2.78876573e-02f, 3.58521521e-01f, -9.08809677e-02f, -1.54900163e-01f, 2.10494667e-01f, 1.07142059e-02f, 5.45806065e-02f, 4.11562026e-01f,
  -2.02414870e-01f, 2.53736287e-01f, 1.00988388e-01f, -1.43485323e-01f, 8.34025294e-02f, -5.31850196e-02f, 1.49279773e-01f, 1.12651452e-01f, 9.88266096e-02f, 1.57358237e-02f,
  5.53791337e-02f, -2.94829547e-01f, 2.97728032e-02f, 6.09190427e-02f, 1.92700386e-01f, 2.54153106e-02f, 2.89163608e-02f, 9.07527357e-02f, 9.00085736e-03f, -5.57490028e-02f,
  -7.19796270e-02f, 2.51157880e-01f, -1.40227117e-02f, -2.66827587e-02f, -2.95674384e-01f, -2.23183557e-01f, -1.89152852e-01f, 2.23459154e-02f, -3.31369370e-01f, 3.48187208e-01f,
  5.38536981e-02f, 1.51917025e-01f, -1.18513793e-01f, -1.37910515e-01f, 1.21308193e-01f, -2.31900737e-01f, 2.51436830e-01f, -2.19758749e-01f, 3.14455256e-02f, -1.48184597e-01f,
  1.40102908e-01f, 1.96630098e-02f, -1.00899458e-01f, 6.56557232e-02f, 4.74119633e-02f, 1.20726533e-01f, -1.46955013e-01f, -1.46617711e-01f, -2.01607198e-01f, 6.18075319e-02f,
  1.43594120e-03f, 5.79641480e-03f, -1.12392223e-02f, 1.81311756e-01f, -6.91029876e-02f, 2.52734125e-01f, 2.05584243e-02f, -1.39696207e-02f, 1.93977728e-01f, -1.37820795e-01f,
  2.65731275e-01f, -2.11224765e-01f, 1.93456128e-01f, 6.41416833e-02f, -5.08043319e-02f, 3.00202698e-01f, -9.18007791e-02f, -1.01925634e-01f, -7.63521763e-03f, 1.56082422e-01f,
  1.15856230e-01f, 8.29483047e-02f, 8.19952264e-02f, 1.14305979e-02f, 2.99103260e-02f, 4.26164791e-02f, -2.95048896e-02f, -1.08225524e-01f, -1.76990535e-02f, 1.18181296e-01f,
  5.47270477e-02f, 1.12951495e-01f, -9.60636977e-03f, 2.32944399e-01f, 5.36827184e-02f, 5.33891395e-02f, -1.46184430e-01f, 4.08296973e-01f, 2.41828561e-02f, -3.53554696e-01f,
  1.31933466e-01f, 3.54312569e-01f, -6.44699112e-02f, -2.19449267e-01f, 2.30884943e-02f, 6.31362721e-02f, -2.70713061e-01f, 2.08221022e-02f, -4.79740977e-01f, 1.19182743e-01f,
  -1.57564908e-01f, 5.12294322e-02f, 1.66850120e-01f, 3.68192434e-01f, 1.18798435e-01f, 3.90401661e-01f, 1.05642259e-01f, 3.10902953e-01f, 7.95754120e-02f, -1.74656332e-01f,
  1.33332580e-01f, 2.45453581e-01f, 2.23958194e-01f, -8.49981084e-02f, 3.20185661e-01f, 5.87206662e-01f, -8.62191990e-02f, 2.55812496e-01f, -1.54633924e-01f, 8.89134184e-02f,
  1.09766781e-01f, -1.17787115e-01f, 3.17613989e-01f, 2.35478804e-01f, -5.47687076e-02f, -7.93155655e-02f, 2.61249870e-01f, -3.31965536e-01f, 2.98087984e-01f, -1.75538495e-01f,
  8.04980993e-02f, -3.34617496e-03f, -8.02259296e-02f, -6.10491931e-02f, 1.77103579e-02f, -4.05249894e-02f, 5.63742369e-02f, 8.56566876e-02f, 3.26427817e-03f, 4.50317562e-03f,
  1.75642967e-03f, -7.35379905e-02f, 1.98797584e-02f, -2.33046561e-02f, -6.76379651e-02f, 3.29396278e-02f, 1.36492848e-02f, 9.31873918e-03f, -2.47734189e-02f, 2.52028555e-02f,
  4.22672331e-02f, -1.05090007e-01f, -7.02593923e-02f, 1.64810121e-02f, -7.62785822e-02f, -4.51222509e-02f, -4.26096320e-02f, 4.34726775e-02f, 9.31597948e-02f, -4.01376188e-03f,
  1.15477890e-02f, 7.27523118e-02f, -8.30870718e-02f, 6.78900331e-02f, 7.96924084e-02f, 8.45581293e-04f, 3.01994383e-03f, -9.42172855e-02f, -2.55414546e-02f, 3.31706852e-02f,
  6.79403543e-04f, -4.08165604e-02f, -5.38653731e-02f, -1.85531378e-03f, -1.30162984e-02f, -7.05899745e-02f, -8.31937641e-02f, -1.73844546e-02f, -5.05261123e-02f, -9.53493863e-02f,
  7.54656047e-02f, -6.26282692e-02f, -9.45948958e-02f, 4.32109833e-02f, -6.01094067e-02f, 9.93994027e-02f, -1.69320405e-02f, 3.95583808e-02f, -8.11139047e-02f, 1.46829337e-02f,
  -1.91507787e-02f, -1.10108554e-01f, -1.65707320e-02f, -1.18221834e-01f, 1.23362318e-01f, 7.80519396e-02f, 1.08794875e-01f, -1.61180824e-01f, -1.62139595e-01f, -1.70785248e-01f,
  -6.41630555e-04f, 7.79120103e-02f, 2.54763141e-02f, 5.97273707e-02f, -3.42027023e-02f, -3.32788676e-02f, 1.54389367e-01f, 2.24518836e-01f, 5.96264005e-02f, -7.48659819e-02f,
  -2.88715869e-01f, 7.78641626e-02f, -1.46735050e-02f, -2.26291656e-01f, 7.16325939e-02f, 1.11616656e-01f, 9.97020900e-02f, -3.31859797e-01f, 1.36316136e-01f, -2.76430070e-01f,
  3.00588101e-01f, -3.27560931e-01f, -5.85436411e-02f, -2.08624274e-01f, -1.55598506e-01f, 1.92055672e-01f, -9.76677835e-02f, 1.06240571e-01f, -1.04798302e-01f, 2.55758464e-01f,
  3.18413347e-01f, 1.44522771e-01f, 9.77587998e-02f, 2.91140079e-01f, 1.38024122e-01f, 2.17983767e-01f, 4.79855239e-02f, -3.78301919e-01f, 1.50275439e-01f, 3.12698692e-01f,
  3.42143439e-02f, 4.20471698e-01f, 8.10393617e-02f, 2.88399495e-02f, 4.25610155e-01f, -9.87211838e-02f, 2.97293037e-01f, -1.59654945e-01f, -2.43519410e-03f, -9.70224068e-02f,
  -1.00766912e-01f, 4.14706260e-01f, -4.23997194e-02f, 3.36348087e-01f, 1.31799176e-03f, -2.28170440e-01f, 2.74673790e-01f, -5.71407154e-02f, 3.48451771e-02f, -6.07748479e-02f,
  2.25845113e-01f, 6.04750356e-03f, -8.21367949e-02f, 3.48070376e-02f, 2.21738800e-01f, -1.14250928e-01f, 1.24712184e-01f, -1.82967875e-02f, -2.00376824e-01f, -1.08023666e-01f,
  -6.17000982e-02f, 2.34578907e-01f, 2.25047648e-01f, 2.97748223e-02f, -2.91583776e-01f, -2.29867443e-01f, 1.67608857e-01f, -1.34402011e-02f, -3.56416494e-01f, -3.98382358e-02f,
  -2.06260651e-01f, -2.12868392e-01f, 1.11572906e-01f, -5.89245073e-02f, -2.58871108e-01f, -7.68572316e-02f, 2.26936847e-01f, 1.90792248e-01f, 9.70180258e-02f, 2.31108174e-01f,
  -3.51431929e-02f, -9.83514190e-02f, 2.41635591e-01f, -2.02077881e-01f, -3.85203585e-02f, 1.29897386e-01f, 1.96162745e-01f, -1.12902582e-01f, -2.85961796e-02f, 5.50327301e-02f,
  2.92437412e-02f, 1.17888018e-01f, -4.83404212e-02f, -1.20640665e-01f, 2.04759255e-01f, -1.07229210e-01f, 3.85023132e-02f, 2.03391835e-01f, -1.43407017e-01f, 7.13349581e-02f,
  -1.67257965e-01f, 2.06223220e-01f, 9.61036608e-02f, 1.68912858e-01f, 1.10940985e-01f, -9.52082202e-02f, 7.84659386e-02f, -1.59913003e-01f, 5.58006279e-02f, 1.49857163e-01f,
  2.00389381e-02f, 1.41704783e-01f, 2.42622066e-02f, 1.07432455e-01f, 4.34590951e-02f, 1.18140988e-01f, 2.56014705e-01f, -1.10673115e-01f, 2.08629087e-01f, 5.68884239e-02f,
  -9.50963572e-02f, 1.65752806e-02f, 7.06271082e-02f, 1.46904781e-01f, -1.01889938e-01f, 1.28923133e-01f, -9.68765989e-02f, -1.30910978e-01f, 2.92171359e-01f, 2.46393025e-01f,
  1.13770343e-01f, 1.80192012e-02f, 2.31605262e-01f, 1.91984802e-01f, 2.09310934e-01f, -1.37641385e-01f, -7.55438209e-02f, 8.86293277e-02f, 2.14598522e-01f, -4.26453024e-01f,
  3.38603444e-02f, 3.78001750e-01f, -2.48057544e-01f, 2.51443088e-01f, -3.43566746e-01f, 3.06945950e-01f, -3.10950398e-01f, -9.73733515e-02f, -3.76784839e-02f, 8.17063749e-02f,
  2.29802072e-01f, 4.06829193e-02f, 3.22613657e-01f, 2.97731578e-01f, 2.48474523e-01f, -6.20237030e-02f, 9.41159949e-02f, -1.58945441e-01f, 1.00738980e-01f, -3.29585284e-01f,
  -2.16203451e-01f, 5.37317283e-02f, -3.64755839e-02f, 1.10923894e-01f, 1.99224614e-02f, 1.09988421e-01f, 1.16075650e-01f, -9.96601582e-02f, 7.05406219e-02f, 1.01613604e-01f,
  3.70417908e-02f, -6.72616363e-02f, -3.39575857e-02f, -1.45798400e-01f, 1.40136048e-01f, 1.37232080e-01f, 9.24823657e-02f, 4.82745208e-02f, 1.08383700e-01f, -1.33411154e-01f,
  2.38986865e-01f, 8.55027139e-02f, 8.03891867e-02f, -1.28977299e-01f, 1.01523586e-01f, 4.73223478e-02f, -2.75035333e-02f, 3.32593136e-02f, 5.77789806e-02f, -7.38304779e-02f,
  -7.70735443e-02f, -8.79528299e-02f, 5.61994314e-03f, 2.53760088e-02f, 3.54182869e-02f, -6.59301877e-02f, 7.68544376e-02f, 1.95503548e-01f, -1.61009863e-01f, 3.11039258e-02f,
  -1.89515218e-01f, 2.59444743e-01f, -7.91402012e-02f, -1.30893126e-01f, -8.53249803e-02f, -8.54984522e-02f, -1.93412602e-01f, -1.98855907e-01f, -1.19688712e-01f, 5.84951565e-02f,
  -5.76805025e-02f, 1.44965565e-02f, 2.11066566e-03f, 2.21649021e-01f, 1.92805544e-01f, -3.52328196e-02f, 1.57106757e-01f, 2.77174890e-01f, 2.06857711e-01f, 1.22238770e-01f,
  2.31065582e-02f, -7.80615509e-02f, 1.17711924e-01f, -1.43166766e-01f, -2.28446350e-02f, -9.45732594e-02f, -9.76678953e-02f, 9.30959508e-02f, -5.56891188e-02f, 2.13848636e-01f,
  1.07910790e-01f, -9.34479907e-02f, 2.46588320e-01f, -9.15221795e-02f, 2.30923429e-01f, -2.10385136e-02f, 5.53158820e-02f, -1.48445755e-01f, 2.00829685e-01f, 2.93756127e-02f,
  -8.42717886e-02f, -3.94170433e-02f, 9.46172699e-02f, 6.32011816e-02f, 6.71633855e-02f, 6.50674701e-02f, 1.01172470e-01f, 9.70722064e-02f, -3.26752961e-02f, -5.05481847e-03f,
  -1.78621579e-02f, -1.01702735e-01f, 1.34357801e-02f, -4.21082824e-02f, -1.25065506e-01f, 2.33619958e-02f, -7.98422247e-02f, 6.81419522e-02f, -6.78092390e-02f, 1.19055234e-01f,
  8.19102898e-02f, -6.16569421e-04f, -1.11730590e-01f, 6.21423349e-02f, 4.23562489e-02f, 2.90413871e-02f, -1.18665481e-02f, -5.66084944e-02f, 4.93306071e-02f, -2.29397640e-02f,
  1.19688705e-01f, 2.80116359e-03f, 8.62290710e-02f, -1.16143627e-02f, 1.07322581e-01f, -9.65578854e-02f, 8.15130100e-02f, -5.18318377e-02f, -1.13740928e-01f, 8.35555643e-02f,
  -4.61611226e-02f, 9.41373333e-02f, -4.03219089e-02f, -7.58588016e-02f, 5.59929125e-02f, 3.78230377e-03f, 5.11176288e-02f, 7.55095184e-02f, -1.17699057e-01f, -3.62104550e-02f,
  -1.47046253e-01f, -1.12499380e-02f, 1.82563830e-02f, -7.66538233e-02f, 4.26850915e-02f, -2.90667582e-02f, 8.67999904e-03f, -8.60243216e-02f, 7.40340650e-02f, 1.00694969e-02f,
  3.95274013e-02f, -2.90388875e-02f, 2.06586923e-02f, -1.02878638e-01f, 2.67490417e-01f, 1.74157083e-01f, -3.96792665e-02f, 1.44604206e-01f, -1.59656763e-01f, 8.84498507e-02f,
  6.54233843e-02f, 1.73373014e-01f, 6.33963346e-02f, -5.73694445e-02f, 8.57527778e-02f, -4.75698262e-02f, 2.16429830e-01f, -1.16956513e-02f, -2.38904846e-03f, 1.40534043e-02f,
  -1.01760089e-01f, 1.66723266e-01f, -9.89480242e-02f, -2.87089739e-02f, 3.08573544e-01f, -1.46839395e-02f, 2.57665396e-01f, -2.03008711e-01f, -8.20010006e-02f, 1.49931312e-02f,
  3.09394062e-01f, 1.61388293e-01f, 8.46545324e-02f, -4.23379332e-01f, -2.15252772e-01f, -3.47791195e-01f, -6.08422644e-02f, -7.09853396e-02f, 1.11101776e-01f, 2.84658223e-01f,
  2.02073589e-01f, -7.78072253e-02f, 3.88679723e-03f, 3.63633126e-01f, 2.18423754e-02f, -4.02655639e-02f, 8.66417289e-02f, 3.13264169e-02f, 3.47144425e-01f, 5.11239946e-01f,
  1.84834152e-02f, 3.56577784e-01f, 3.60264599e-01f, 1.31998941e-01f, 3.67720455e-01f, 3.00447881e-01f, 1.52656287e-01f, -1.55786768e-01f, 9.57232788e-02f, 3.46418232e-01f,
  3.82615216e-02f, 3.86165202e-01f, 2.00650077e-02f, 5.40659070e-01f, 1.79516062e-01f, -1.19787171e-01f, 2.82439172e-01f, -8.05005878e-02f, 1.65540770e-01f, 1.87281623e-01f,
  9.71855298e-02f, 1.73987314e-01f, -1.68168060e-02f, -5.71059696e-02f, 4.33442816e-02f, -2.18301304e-02f, 5.09125926e-02f, -1.76220253e-01f, 1.35838211e-01f, 1.14758834e-01f,
  1.85168281e-01f, -5.34681231e-03f, 1.90821663e-01f, 3.45908590e-02f, -5.99880256e-02f, 8.56870562e-02f, -2.19440740e-02f, 1.52973384e-01f, -1.84145465e-01f, -1.88886166e-01f,
  -2.85311133e-01f, 7.40036443e-02f, 1.52437072e-02f, 8.48916844e-02f, -2.43368730e-01f, 4.02707666e-01f, 3.96123640e-02f, 6.23990633e-02f, 1.82350352e-01f, 3.99053879e-02f,
  -1.91931397e-01f, -5.60780279e-02f, -6.72821701e-02f, -3.45498957e-02f, -9.26850811e-02f, 1.70700476e-01f, 2.28296921e-01f, 2.44671050e-02f, 1.68469071e-01f, -1.96736604e-01f,
  1.49732441e-01f, 2.62868702e-01f, -1.62255004e-01f, -2.76406467e-01f, -5.62013201e-02f, -1.84144154e-01f, -3.01970188e-02f, -9.40527674e-03f, -1.87603682e-01f, -1.83800220e-01f,
  -4.76319417e-02f, 2.07668632e-01f, -9.22855437e-02f, 2.15645075e-01f, 2.45850578e-01f, -1.72686473e-01f, 9.14712846e-02f, -1.97071992e-02f, 6.50548413e-02f, 3.45295459e-01f,
  1.35939687e-01f, 2.15784237e-02f, 1.13494650e-01f, 2.77299434e-01f, -3.17823812e-02f, -1.28249049e-01f, -1.85799465e-01f, -1.94006011e-01f, -1.39648348e-01f, 9.42309946e-02f,
  -4.06456739e-02f, 2.55823620e-02f, 3.37536007e-01f, 1.53577894e-01f, 2.15922117e-01f, -1.75940380e-01f, 1.56424999e-01f, 1.61742270e-01f, 1.48315117e-01f, 1.78370625e-01f,
  -2.16522545e-01f, -1.93938762e-01f, 3.13694000e-01f, -2.32826427e-01f, 2.47403994e-01f, 3.07805240e-01f, 6.78089932e-02f, -3.12573522e-01f, 1.26168042e-01f, 1.47529885e-01f,
  -6.09346516e-02f, -4.25892979e-01f, -4.22718823e-02f, -7.40094483e-03f, 2.04637006e-01f, 1.42658725e-01f, -8.87167603e-02f, 2.03454956e-01f, -6.35054260e-02f, -3.82287174e-01f,
  -2.58288644e-02f, 1.95073962e-01f, 2.84578949e-01f, -1.42247200e-01f, 1.36307076e-01f, -1.90150160e-02f, 1.46362081e-01f, 1.48394197e-01f, -6.43187612e-02f, 1.88947320e-01f,
  -6.57336190e-02f, -3.58670920e-01f, 2.63765275e-01f, 7.17969909e-02f, 2.81407148e-01f, -9.79753286e-02f, -9.25627649e-02f, 2.08849892e-01f, -4.96120974e-02f, 9.57186148e-02f,
  -4.41796146e-02f, 3.71164888e-01f, -1.44639879e-01f, 3.11751872e-01f, 9.04726163e-02f, -6.99957758e-02f, 2.26906717e-01f, -3.64639349e-02f, 1.20233253e-01f, 5.01777157e-02f,
  1.81098431e-01f, -9.74337310e-02f, 1.23298489e-01f, 1.57220721e-01f, -1.07988067e-01f, -7.86657259e-02f, 1.98478743e-01f, 7.05045164e-02f, 2.41621897e-01f, -8.15900862e-02f,
  -6.13865815e-03f, 5.33048399e-02f, 4.81188409e-02f, -7.89411590e-02f, 2.84041688e-02f, -1.38922185e-01f, 2.12018669e-01f, -7.90546685e-02f, 3.58049631e-01f, 2.28414491e-01f,
  -2.48695999e-01f, -2.18203217e-01f, 3.65881711e-01f, -1.63101822e-01f, -1.51983202e-01f, -3.68471026e-01f, 1.16022013e-01f, -1.77445129e-01f, 2.75921106e-01f, -1.96114585e-01f,
  1.25335185e-02f, -9.21731889e-02f, -1.69760864e-02f, -2.77526945e-01f, 9.75909457e-03f, 1.66774005e-01f, -1.01536699e-01f, -1.47624299e-01f, 1.22977190e-01f, 9.75658186e-03f,
  2.50544161e-01f, 2.92556733e-01f, 1.67896852e-01f, 1.59649178e-01f, 1.44087702e-01f, -3.16649556e-01f, 1.78361908e-01f, 1.83932617e-01f, 2.10953996e-01f, -7.65675977e-02f,
  5.97206615e-02f, 2.71263272e-01f, 1.15003221e-01f, -1.30080611e-01f, -5.11561446e-02f, 4.53205943e-01f, 4.36550938e-02f, 2.02525675e-01f, 5.72531186e-02f, 5.09330817e-03f,
  -2.83993091e-02f, 9.50070396e-02f, -1.02514243e-02f, -1.08830323e-02f, -2.93843821e-03f, -3.82579979e-03f, 8.46872851e-02f, -1.04474656e-01f, -1.02622420e-01f, 1.49731087e-02f,
  3.43334079e-02f, -5.22613600e-02f, 1.06594287e-01f, -5.83216995e-02f, -9.64815468e-02f, -8.68004188e-02f, -3.07359155e-02f, -8.01008344e-02f, -9.75536928e-02f, 5.78351244e-02f,
  1.01086527e-01f, 1.01500312e-02f, -1.97354215e-03f, 1.27392379e-03f, 8.15576613e-02f, 2.38202382e-02f, 3.67539003e-02f, 8.10876638e-02f, 5.38589284e-02f, 3.66894156e-02f,
  3.56001891e-02f, 9.57087427e-02f, 1.21660084e-01f, -3.39491516e-02f, -9.16932300e-02f, -9.83595625e-02f, 8.86157900e-02f, 5.82422502e-02f, 7.75893079e-03f, -5.77605292e-02f,
  -4.95593809e-03f, 3.21696997e-02f, 7.69171026e-03f, -6.71220571e-02f, 5.92181049e-02f, -6.96971864e-02f, -7.46293068e-02f, -1.00723341e-01f, -1.01648331e-01f, -4.02740836e-02f,
  -1.11103654e-02f, -1.03507578e-01f, -1.22879535e-01f, -4.41761389e-02f, 8.83205235e-03f, -3.25129665e-02f, -2.59360597e-02f, 1.93510838e-02f, -6.37714416e-02f, 1.21188932e-03f,
  4.98357899e-02f, 2.85730213e-02f, -1.15062080e-01f, 5.66710159e-03f
};

// L3_fan_Bp_bar (Shape: 1 x 26)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 26;
const float L3_fan_Bp_bar_data[] = {
  3.51133905e-02f, 1.84915811e-01f, 2.45799366e-02f, 1.37021616e-01f, -2.79709753e-02f, 8.91537219e-02f, -8.29580575e-02f, 7.66284987e-02f, 9.57919136e-02f, -1.36976987e-01f,
  -7.17024431e-02f, 5.33720739e-02f, 1.27624914e-01f, -7.86655843e-02f, -5.31898551e-02f, -9.64846164e-02f, 1.59796938e-01f, 1.72506750e-01f, 2.52529257e-03f, -1.11229956e-01f,
  -1.05802879e-01f, 8.23690370e-02f, -6.18970431e-02f, 2.56921444e-02f, 7.39376023e-02f, -1.04949743e-01f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  2.16690958e-01f, 2.16008738e-01f, -9.20576602e-02f, -1.31816670e-01f, 7.84813538e-02f, 3.78612988e-03f, 1.06671751e-01f, 1.55419439e-01f, 4.28467244e-02f, 1.56683117e-01f,
  6.33300319e-02f, -9.22831520e-02f, -2.06552073e-01f, -1.67212084e-01f, -1.08502870e-02f, 2.44459942e-01f, 1.12638764e-01f, -5.56624532e-02f, -2.26000592e-01f, 1.06673963e-01f,
  1.66845500e-01f, 2.82411844e-01f, 2.62093842e-01f, -2.18069732e-01f, -1.25003934e-01f, -2.87701190e-01f, -1.51194409e-01f, 1.34958923e-01f, -2.75195569e-01f, -8.34075585e-02f,
  -3.13858807e-01f, 2.15206563e-01f, 3.33966687e-02f, -3.55885565e-01f, -4.75256853e-02f, 6.21330738e-02f, 2.54769981e-01f, 7.75102004e-02f, -1.12805746e-01f, -2.38153905e-01f,
  -1.89862624e-01f, 3.00073922e-02f, 4.89154547e-01f, 1.09484307e-02f, 6.27373904e-02f, -9.76120457e-02f, 9.48638916e-02f, -1.16601177e-01f, -2.17059031e-01f, 1.46661445e-01f,
  -5.31029284e-01f, -1.77009657e-01f, 2.28922635e-01f, -2.56704986e-02f, 1.40972093e-01f, 6.88184649e-02f, -7.53018409e-02f, -4.29894663e-02f, -3.60558392e-03f, 1.36095583e-01f,
  -2.70328134e-01f, -2.69425035e-01f, -1.41628087e-03f, 9.30967554e-02f, 1.57474250e-01f, -1.17393069e-01f, -4.75686230e-02f, 2.18371097e-02f, -1.77308053e-01f, 1.15710847e-01f,
  1.29729271e-01f, -5.06247804e-02f, -5.73001765e-02f, -6.68154806e-02f, 9.02315322e-03f, -8.17918628e-02f, 6.73080385e-02f, -7.88312256e-02f, -1.92166880e-01f, -1.32649779e-01f,
  -4.57875915e-02f, 1.44723043e-01f, -1.46952510e-01f, -1.90141555e-02f, -1.80138037e-01f, 5.04434258e-02f, 8.13304856e-02f, 3.86399776e-02f, 2.24209264e-01f, 3.40390235e-01f,
  1.63114026e-01f, -6.22482523e-02f, 1.45347476e-01f, 1.52695924e-01f, -2.59587348e-01f, 9.85628366e-02f, 1.34015456e-01f, -1.49380982e-01f, -1.80506349e-01f, 2.18463391e-01f,
  3.27929594e-02f, -1.24777772e-01f, 9.93645117e-02f, 1.25838891e-01f, 7.31007457e-02f, 7.28460401e-02f, -4.69412982e-01f, -1.49572389e-02f, -1.05573013e-01f, -2.55034626e-01f,
  1.27348095e-01f, -9.10492614e-02f, 2.12385178e-01f, 2.25659281e-01f, -4.22414720e-01f, 2.44787872e-01f, 1.54645979e-01f, 9.36363637e-03f, -3.01016569e-01f, 9.47093219e-03f,
  7.52440766e-02f, 1.35848001e-01f, -1.04551598e-01f, 1.66977812e-02f, 4.09882702e-02f, -3.86345297e-01f, -1.63963094e-01f, -9.87138972e-02f, 1.43465459e-01f, -8.53745639e-02f,
  9.69670042e-02f, -1.04751391e-03f, 1.76763788e-01f, -4.91529144e-02f, -1.64658353e-01f, -6.02871403e-02f, -1.77999794e-01f, -1.30807295e-01f, 3.69888470e-02f, -9.12881196e-02f,
  9.28029567e-02f, 1.87448099e-01f, -1.16458260e-01f, 3.21282842e-03f, -1.01388898e-02f, 2.04126000e-01f, -3.45208757e-02f, 1.75124511e-01f, 4.99232225e-02f, 1.07996136e-01f,
  -1.09917209e-01f, 1.72798172e-01f, 7.40193278e-02f, -3.62301804e-02f, -1.95739090e-01f, -6.26669032e-03f, -1.32902786e-01f, -8.05912092e-02f, 2.95831054e-01f, -2.22025380e-01f,
  -1.64529696e-01f, -2.09475935e-01f, 1.49597507e-02f, 2.67955750e-01f, -7.18593691e-03f, 1.26698583e-01f, 2.84909904e-01f, -2.20657408e-01f, -1.88919201e-01f, -1.50698230e-01f,
  5.98396361e-01f, 1.18366711e-01f, 8.32875259e-03f, -2.26058647e-01f, 1.01744369e-01f, -6.75493404e-02f, -1.05952257e-02f, 2.10074082e-01f, 2.33745694e-01f, 2.92072177e-01f,
  -1.55969799e-01f, 6.55916482e-02f, -3.25122148e-01f, 1.33905143e-01f, -1.71977848e-01f, 1.01764701e-01f, -5.49099892e-02f, -3.45158637e-01f, -1.67041179e-02f, -5.36953866e-01f,
  -7.94145241e-02f, -8.37481953e-03f, 9.98281538e-02f, -1.27013132e-01f, -2.44501367e-01f, -1.47137344e-01f, 1.48898557e-01f, -2.16319740e-01f, -7.67622516e-02f, -1.86225519e-01f,
  -1.73043847e-01f, 1.27160236e-01f, -1.70549288e-01f, -1.23022690e-01f, 1.24333948e-01f, 8.07432234e-02f, 5.70309814e-03f, 5.13461791e-02f, 8.72579291e-02f, -1.78267345e-01f,
  -4.33441577e-03f, 3.50274116e-01f, -2.83846676e-01f, -7.05676824e-02f, 1.75885007e-01f, 2.78220266e-01f, 7.56244436e-02f, -2.86485791e-01f, -5.41489199e-02f, 6.07458949e-02f,
  2.56872833e-01f, 2.19851121e-01f, -1.74369499e-01f, -2.03856871e-01f, 2.20326725e-02f, -2.99940556e-01f, 1.90394372e-01f, 3.79329026e-02f, 3.80962505e-03f, -2.41823271e-01f,
  -4.07844007e-01f, 1.30060494e-01f, -3.33548903e-01f, -2.00889155e-01f, -4.32553142e-02f, 2.49611419e-02f, 2.31355969e-02f, -3.50393683e-01f, -3.39987963e-01f, -4.95332405e-02f,
  -2.58131772e-01f, -4.37549442e-01f, -5.09839833e-01f, -3.12825255e-02f, 4.55521345e-02f, -1.78083479e-02f, 2.43798718e-01f, -8.38502795e-02f, -2.87651479e-01f, -1.04353264e-01f,
  -4.77298684e-02f, 2.55304843e-01f, -1.27012715e-01f, 8.01827312e-02f, 1.26473084e-01f, 7.76736066e-02f, 4.93542776e-02f, -1.62917245e-02f, 1.49424329e-01f, 1.24632441e-01f,
  -2.24706024e-01f, -2.42960453e-02f, -1.95479482e-01f, 2.56256551e-01f, 2.61885315e-01f, -1.70507163e-01f, 6.36545122e-02f, 6.27759546e-02f, 1.69469237e-01f, -8.68211985e-02f,
  1.65879130e-01f, -2.00008109e-01f, -4.32222709e-02f, 1.63609743e-01f, 2.14049995e-01f, -2.81109750e-01f, -1.52900800e-01f, -4.96156849e-02f, -1.11903466e-01f, -3.32895815e-02f,
  1.68210879e-01f, 8.26512873e-02f, 2.29824290e-01f, -4.95776907e-02f, 1.54498190e-01f, 4.07412559e-01f, -3.07097912e-01f, 2.45309323e-01f, -2.49377042e-02f, 2.50882924e-01f,
  -9.80784371e-02f, -1.12252953e-02f, -1.70338809e-01f, 1.60223156e-01f, -3.70254576e-01f, -1.25578389e-01f, 1.09414384e-01f, -1.11684263e-01f, -6.27105415e-01f, 4.35704105e-02f,
  9.38330293e-02f, 1.39138415e-01f, -8.77256244e-02f, -2.79085357e-02f, -1.07978590e-01f, -1.74149096e-01f, -5.34742057e-01f, -1.15869284e-01f, 1.52972668e-01f, 6.48592263e-02f,
  1.74108908e-01f, -2.84860969e-01f, 2.24118948e-01f, 1.31379500e-01f, 7.93794617e-02f, 1.46773010e-01f, -1.99047685e-01f, -5.42820655e-02f, 9.34503078e-02f, 1.97407249e-02f,
  3.85686493e-04f, -2.53384084e-01f, -2.06663653e-01f, 3.89390476e-02f, -7.39244297e-02f, 3.13908085e-02f, -3.78611833e-02f, -1.17157333e-01f, -1.20869800e-01f, 9.77224782e-02f,
  -1.58301786e-01f, 1.60378337e-01f, -2.04037026e-01f, 1.18084133e-01f, -7.38433935e-03f, 1.47073846e-02f, 2.03614444e-01f, -3.67023051e-02f, -1.22136369e-01f, -2.57431656e-01f,
  6.77123293e-02f, 1.70069158e-01f, -3.31032902e-01f, 1.17421761e-01f, -1.01924784e-01f, -1.71641216e-01f, -3.10661234e-02f, -2.05208644e-01f, -1.28025785e-01f, -3.87666048e-03f,
  9.43585187e-02f, -5.28526157e-02f, 8.23093802e-02f, 2.96327293e-01f, -1.20031819e-01f, -1.23447523e-01f, -2.34472692e-01f, -1.74912065e-01f, -2.17342898e-01f, -1.86635524e-01f,
  6.34862706e-02f, 1.44820049e-01f, 9.54791307e-02f, 2.20327929e-01f, -1.34938478e-01f, 1.49576887e-01f, 1.84335083e-01f, -1.27203301e-01f, -3.19222927e-01f, -8.95895660e-02f,
  -2.65713900e-01f, 1.43048577e-02f, 1.03459209e-01f, -1.41587257e-02f, -2.52396405e-01f, -3.70615534e-02f, -4.37669978e-02f, 1.20272279e-01f, 4.85514775e-02f, 7.35799372e-02f,
  2.06848487e-01f, -3.40677984e-02f, -1.47081697e-02f, -6.82731271e-02f, -2.16097623e-01f, -2.01934278e-01f, 2.33398899e-01f, -1.32364899e-01f, 1.59686714e-01f, 2.52855480e-01f,
  2.43388355e-01f, 3.30922306e-02f, -9.79381427e-02f, -1.90411374e-01f, 1.56690776e-01f, -1.11562952e-01f, 9.48287770e-02f, 8.39337707e-02f, 1.53103173e-01f, 1.33675516e-01f,
  1.77840263e-01f, -8.71390775e-02f, 3.62642184e-02f, -1.56310752e-01f, -1.30268773e-02f, 7.64007196e-02f, -1.58897176e-01f, -2.43365005e-01f, 4.27898429e-02f, 2.82337755e-01f,
  -1.19068287e-01f, 8.17371011e-02f, 6.33086190e-02f, -2.47890353e-01f, 4.81100008e-02f, 5.06618135e-02f, 1.46924719e-01f, 2.34201103e-01f, -2.95397401e-01f, -1.39529899e-01f,
  1.49387075e-02f, 1.97695881e-01f, 1.45810887e-01f, -7.72806723e-03f, 9.45852920e-02f, 1.57409385e-01f, -7.51112819e-01f, -3.46529740e-03f, -1.14474341e-01f, 1.38894603e-01f,
  4.02233489e-02f, -2.59441044e-02f, -6.60077333e-01f, 8.01346749e-02f, 2.84777045e-01f, -3.39068957e-02f, -9.45255905e-02f, -1.28488541e-02f, -2.22767651e-01f, 1.70556724e-01f,
  -8.90650451e-02f, -3.43361124e-02f, -7.14182630e-02f, -3.95342559e-01f, 2.74427831e-01f, -2.38185674e-01f, -4.00627851e-01f, -1.24124587e-01f, 1.98659915e-02f, 8.16409849e-03f,
  2.84681264e-02f, -8.30649510e-02f, -1.91388875e-02f, 1.42792583e-01f, -1.83429465e-01f, 1.48717061e-01f, 2.14239582e-02f, 8.61281753e-02f, 1.01833068e-01f, 8.06980059e-02f,
  7.18858391e-02f, 1.15595385e-01f, -1.78869203e-01f, 1.44512653e-01f, -2.31363043e-01f, 9.57617611e-02f, -6.34137914e-02f, -2.78450012e-01f, 2.05506936e-01f, -1.61365539e-01f,
  -4.12244722e-02f, 2.85039365e-01f, -1.70293331e-01f, -1.02797113e-01f, 1.57783926e-01f, -2.35999927e-01f, -1.98800758e-01f, -2.03090366e-02f, 2.91279584e-01f, -2.81139106e-01f,
  1.93625510e-01f, 1.82474181e-01f, 8.81465077e-02f, -1.87603310e-01f, 1.23836890e-01f, -1.11374184e-01f, -1.38791859e-01f, 4.83830012e-02f, -1.71476245e-01f, 3.79000425e-01f,
  5.28023422e-01f, -9.89329144e-02f, 9.41744167e-03f, -3.25273782e-01f, 1.41432181e-01f, -5.57328202e-02f, 5.67185320e-02f, -1.34485140e-01f, -1.08657010e-01f, 1.47094093e-02f,
  -2.42496923e-01f, 2.70969570e-02f, 4.41624261e-02f, -2.04536349e-01f, -9.51446891e-02f, -2.58922935e-01f, -6.32591918e-02f, 7.99031779e-02f, -1.86593473e-01f, 3.32130417e-02f,
  1.40990436e-01f, 9.51098353e-02f, 5.41609749e-02f, -1.29918441e-01f, 1.13922089e-01f, 4.68479730e-02f, 3.12648378e-02f, 1.20429076e-01f, -1.55014947e-01f, 1.37991920e-01f,
  2.01301828e-01f, 1.25045165e-01f, 8.39884672e-03f, 9.75953937e-02f, 1.42433360e-01f, 3.23725268e-02f, 1.70296114e-02f, -1.23962641e-01f, 7.12630004e-02f, 1.03513047e-01f,
  5.48962504e-02f, 2.04356819e-01f, -9.14667472e-02f, 2.56391197e-01f, 2.28421405e-01f, 2.81752437e-01f, 3.07527155e-01f, 2.47427195e-01f, 2.53986806e-01f, -3.67854536e-02f,
  2.10507438e-01f, -1.73424542e-01f, 2.33749464e-01f, 1.80947050e-01f, -2.04146713e-01f, -1.88000441e-01f, -1.83678940e-01f, 2.41467774e-01f, 1.40640944e-01f, 8.45183432e-02f,
  1.37281135e-01f, -2.74931282e-01f, -3.01245332e-01f, -2.95787424e-01f, 1.00366443e-01f, 4.80906926e-02f, -2.51502916e-02f, 1.45914584e-01f, -9.39880591e-03f, -5.90811223e-02f,
  -8.13298374e-02f, 2.08755121e-01f, 2.01286405e-01f, -1.10128827e-01f, -2.08021715e-01f, -8.24760199e-02f, -2.73138314e-01f, -3.01384807e-01f, -2.59414345e-01f, -2.02039376e-01f,
  -1.01067334e-01f, 2.49982879e-01f, -1.15560442e-01f, 7.52215162e-02f, 2.32839093e-01f, 5.48071302e-02f, -1.07360058e-01f, 2.23195970e-01f, -3.10328491e-02f, -1.39911205e-01f,
  -7.27088600e-02f, -7.83685818e-02f, -4.21905369e-02f, -7.01227337e-02f, -6.55211955e-02f, 1.90154552e-01f, -1.06614977e-01f, 1.92344919e-01f, 1.18548706e-01f, -2.46024936e-01f,
  -2.67768316e-02f, -3.24125192e-03f, 2.88779251e-02f, -2.18113765e-01f, -6.09515086e-02f, -9.13131908e-02f, 2.18869865e-01f, 2.33783349e-01f, -1.52811632e-01f, 7.08352327e-02f,
  1.02477735e-02f, -2.40295351e-01f, -1.87156841e-01f, 2.39194110e-01f, 9.03676003e-02f, -2.59206533e-01f, 2.69203514e-01f, 1.94553047e-01f, 9.85329449e-02f, 1.78458542e-01f,
  1.19960636e-01f, -2.13426366e-01f, -1.32014334e-01f, 2.05431625e-01f, -1.61386862e-01f, 2.69637138e-01f, 2.51905024e-01f, 1.54525727e-01f, -7.97086358e-02f, -2.14140177e-01f,
  -3.97087447e-02f, 9.77361798e-02f, 2.65578032e-02f, 7.64385834e-02f, -4.48544025e-02f, -3.62827152e-01f, -2.91039616e-01f, -1.90696239e-01f, 2.76503623e-01f, 1.12938687e-01f,
  -1.10677928e-01f, 3.63079421e-02f, 2.96109974e-01f, 2.22037345e-01f, -7.47624859e-02f, -4.05381083e-01f, -7.57044926e-02f, -3.64565343e-01f, -4.23246413e-01f, -1.02783971e-01f,
  -1.85583122e-02f, 1.55230671e-01f, 1.40418977e-01f, 5.55232093e-02f, 1.48037776e-01f, -2.11511418e-01f, 2.04743117e-01f, -4.64066640e-02f, 7.09260479e-02f, -2.47608796e-01f,
  -1.99818403e-01f, -1.75339654e-01f, 1.83716305e-02f, 1.05764560e-01f, -1.58906594e-01f, -9.51132104e-02f, -1.94602590e-02f, -7.93753117e-02f, 1.80272572e-02f, 2.94790685e-01f,
  8.76541808e-02f, -1.43858507e-01f, 9.29032490e-02f, -1.05084397e-01f, -7.65036866e-02f, 3.79439034e-02f, 1.56180292e-01f, -3.22657317e-01f, -1.60919800e-01f, -2.43595615e-02f,
  6.90313503e-02f, -3.23162794e-01f, 8.92858878e-02f, -4.29829657e-02f, 2.27737665e-01f, -1.04328066e-01f, 2.22256541e-01f, -2.12482601e-01f, -4.94989231e-02f, 2.39124894e-01f,
  2.21458063e-01f, -2.81644851e-01f, -7.45092258e-02f, -3.17848384e-01f, 6.11577593e-02f, -3.96435797e-01f, -1.50981978e-01f, -7.20150815e-03f, 4.79600936e-01f, -1.22717008e-01f,
  -4.52314824e-01f, -1.83823034e-01f, 1.03970051e-01f, -5.31325787e-02f, 1.23430662e-01f, -1.66618928e-01f, 1.80034652e-01f, -8.35009739e-02f, 3.31863873e-02f, 4.46762629e-02f,
  -1.74619257e-01f, -2.38365121e-02f, -2.00452134e-01f, -3.34613807e-02f, 2.11057708e-01f, -5.09236231e-02f, 1.49958013e-02f, 2.15662718e-02f, 2.32653752e-01f, 2.75237542e-02f,
  6.16760133e-03f, -3.16475630e-02f, 1.17357960e-02f, -7.47659877e-02f, 5.35928505e-03f, 8.92211124e-02f, 1.87278941e-01f, 2.27030531e-01f, 2.00304151e-01f, -4.79639135e-02f,
  1.41357437e-01f, 2.69972850e-02f, 2.10219026e-01f, 2.59121418e-01f, 1.96341172e-01f, -1.86162651e-01f, -1.88502148e-01f, 1.65766589e-02f, -2.16320381e-01f, 2.86830187e-01f,
  2.48267889e-01f, 6.49268851e-02f, 1.90362856e-02f, 2.35047311e-01f, 1.39137402e-01f, 9.49938372e-02f, -2.75547802e-01f, -5.80991209e-02f, 2.13113368e-01f, -2.18322396e-01f,
  -1.72776416e-01f, 1.13702111e-01f, 1.76487342e-01f, 1.49265125e-01f, 2.87003934e-01f, -3.78764570e-01f, -1.50234729e-01f, -3.30528677e-01f, -2.62307283e-02f, 5.36204986e-02f,
  -3.12327981e-01f, 1.40412375e-02f, -4.15918112e-01f, -2.16287315e-01f, 1.82641059e-01f, -2.92040378e-01f, -1.87350690e-01f, -9.10071433e-02f, -5.80603816e-02f, 4.66698548e-03f,
  2.20933095e-01f, -1.41637987e-02f, -1.30949512e-01f, -8.37938413e-02f, -4.31355983e-02f, 2.55308561e-02f, 2.42296100e-01f, 7.88393319e-02f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -8.85037333e-02f, -1.34896100e-01f, 5.08162528e-02f, 4.57924232e-02f, 2.88855880e-02f, -7.71394670e-02f, 2.90544834e-02f, 7.98762217e-02f, 1.41896889e-01f, 4.24320623e-02f,
  7.40209520e-02f, -7.27389827e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    