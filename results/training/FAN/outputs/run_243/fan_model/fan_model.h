/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.75896671e-02f, 1.60828128e-01f, 3.28833282e-01f, -1.64580122e-01f, -1.35305196e-01f, 1.55022830e-01f, 1.09778248e-01f, -7.98957609e-03f, -9.51110199e-02f, 6.43360838e-02f,
  -1.65120110e-01f, 2.89160550e-01f, 1.91705629e-01f, -2.91355610e-01f, 1.34364143e-02f, -1.18053377e-01f, -3.02973777e-01f, -1.15401849e-01f, -1.78531229e-01f, -1.16513595e-01f,
  -2.23242894e-01f, -4.72618729e-01f, -1.44762814e-01f, -2.80253708e-01f, -1.12513803e-01f, 4.39806767e-02f, -7.13732541e-02f, 1.03028655e-01f, 1.00007392e-02f, 1.24593586e-01f,
  -1.10035382e-01f, -2.98971049e-02f, 1.36454245e-02f, 9.33207273e-02f, 9.35253873e-03f, 1.19365148e-01f, 8.00528377e-02f, 3.21381204e-02f, 2.50633322e-02f, 3.72390635e-02f,
  1.01907611e-01f, -1.97057854e-02f, -1.98548064e-02f, 1.02408975e-02f, -4.08182293e-02f, 4.05385122e-02f, -4.50687036e-02f, -5.89153618e-02f, 4.75484319e-03f, -2.09612772e-03f,
  -4.49589603e-02f, -1.54339094e-02f, -5.24804555e-03f, -1.21867871e-02f, 4.54306230e-03f, -2.38606595e-02f, 8.48370567e-02f, 1.10808939e-01f, 5.21844514e-02f, 2.59920042e-02f,
  4.65628598e-03f, 4.04687086e-03f, 1.54140843e-02f, -6.45207241e-02f, 1.81010608e-02f, -1.86241604e-02f, -1.70654971e-02f, -3.69589888e-02f, -7.24618556e-03f, -1.97840948e-03f,
  -1.02880104e-02f, -3.94356623e-02f, -4.13581245e-02f, 2.61591710e-02f, -3.97909693e-02f, 1.42867453e-02f, -1.48600328e-03f, 2.55783666e-02f, -5.91725074e-02f, -5.09022102e-02f,
  -6.70909043e-03f, 3.10746743e-03f, 1.56864747e-02f, -3.58205177e-02f, 3.18546072e-02f, 2.06782948e-02f, -3.55882607e-02f, 3.93318795e-02f, 2.90790033e-02f, 1.15157943e-02f,
  -3.37094325e-03f, 6.59611523e-02f, 1.94741301e-02f, -9.07746255e-02f, -3.36891389e-03f, -3.51775922e-02f, -3.59295793e-02f, 3.31313200e-02f, 2.46307924e-02f, -3.97994444e-02f,
  -2.24403292e-02f, -6.93238713e-03f, 6.15145303e-02f, -4.53271978e-02f, -6.32127002e-03f, -6.10096119e-02f, 6.11191764e-02f, 3.58300097e-02f, 6.09406866e-02f, 1.09058106e-03f,
  -6.87097781e-04f, -1.78632624e-02f, 4.03415933e-02f, -9.08011571e-02f, -7.11677447e-02f, 3.41247804e-02f, -1.35197407e-02f, 4.19084867e-03f, -1.28716966e-02f, 4.13791388e-02f,
  -1.60731629e-01f, -1.76649317e-01f, -2.71345019e-01f, -1.15921475e-01f, -1.71074450e-01f, 3.45854431e-01f, 3.74098837e-01f, -2.75984317e-01f, -1.53872922e-01f, 2.49094620e-01f,
  1.39606625e-01f, -1.65392175e-01f, 2.17470042e-02f, 1.67266309e-01f, 1.16583087e-01f, 8.50373581e-02f, 2.62052447e-01f, 2.07900345e-01f, -1.88035369e-01f, -4.59631644e-02f,
  -7.60110542e-02f, 1.47460133e-01f, -1.30896777e-01f, -9.24724266e-02f, 1.81524996e-02f, -2.24390894e-01f, 4.96775918e-02f, -5.44387214e-02f, 8.80694836e-02f, 1.32287769e-02f,
  7.90145472e-02f, -9.53303799e-02f, -1.44787654e-01f, 1.40156755e-02f, 1.48556819e-02f, 7.10997283e-02f, 7.21498951e-02f, 3.43613923e-02f, -1.41022364e-02f, 5.30838966e-03f,
  4.38060686e-02f, 1.37688750e-02f, -5.06299660e-02f, 8.52028560e-03f, 2.50805262e-02f, -6.09048381e-02f, -9.47159603e-02f, 8.47001909e-04f, -1.02696232e-01f, -6.74158856e-02f,
  -3.83564755e-02f, 2.15529054e-02f, -1.51198134e-02f, 9.92889553e-02f, -5.92499860e-02f, -4.05436158e-02f, -2.70450395e-02f, 4.03341241e-02f, 3.86596359e-02f, -1.01150654e-01f,
  3.79416607e-02f, -3.61442193e-02f, -8.22315924e-03f, -3.67652401e-02f, 1.88375935e-02f, -6.36954978e-02f, 1.76054835e-02f, 6.96917772e-02f, -2.04614680e-02f, 4.03254963e-02f,
  2.42719892e-02f, -3.27303186e-02f, -3.74762155e-02f, 3.71007212e-02f, 2.82806866e-02f, -5.94154671e-02f, 7.49485986e-03f, 3.15676294e-02f, -7.61706987e-03f, -5.08022457e-02f,
  -2.32810881e-02f, 5.30427285e-02f, -6.78608567e-03f, 4.19636928e-02f, -2.20769155e-03f, 6.21183636e-03f, 4.22591828e-02f, -2.99568903e-02f, -2.22628601e-02f, 1.53213646e-02f,
  2.01123938e-01f, 6.68695047e-02f, -2.74809059e-02f, -5.94683401e-02f, 3.80694680e-02f, -3.22693139e-02f, -1.91601869e-02f, -7.45520070e-02f, 6.15106225e-02f, 1.10273287e-02f,
  4.02377173e-03f, 2.84294244e-02f, 9.60102491e-03f, 3.32971364e-02f, 2.01667175e-02f, -2.72609144e-02f, 5.99674545e-02f, 3.21852751e-02f, 6.52684197e-02f, 7.19719147e-03f,
  5.23816757e-02f, 4.39382903e-02f, 8.25846160e-04f, -4.44913283e-02f, 5.45325242e-02f, 4.80776057e-02f, -2.12784708e-02f, -6.50629103e-02f, 5.67898117e-02f, 6.90398738e-02f,
  -1.26314744e-01f, 1.79848641e-01f, -2.30227694e-01f, -1.43027425e-01f, 2.59233534e-01f, -1.50766596e-01f, -1.44937202e-01f, 2.52074778e-01f, -2.33119249e-01f, 2.45292678e-01f,
  1.53186098e-01f, -3.09831977e-01f, -6.61514373e-03f, 3.61886434e-02f, -3.99785966e-01f, -2.66390353e-01f, -6.71821758e-02f, -9.30275843e-02f, -8.53981301e-02f, 1.04466811e-01f,
  -3.42019871e-02f, 2.98213363e-01f, 2.03941520e-02f, 3.14433366e-01f, 2.38498405e-01f, 4.92922850e-02f, 2.70542711e-01f, -9.81682315e-02f, 1.60584077e-01f, -1.48586994e-02f,
  2.78349537e-02f, 1.05778269e-01f, 3.25540602e-02f, 2.32989248e-02f, 7.33123869e-02f, 1.18579352e-02f, -6.43382668e-02f, -1.01262316e-01f, -3.91953252e-02f, 6.71050744e-03f,
  -9.35588852e-02f, -1.21040279e-02f, -2.98769102e-02f, -9.98596195e-03f, 6.31555468e-02f, 1.01709506e-02f, -3.54441665e-02f, 7.38691911e-02f, -2.45900415e-02f, -2.34558694e-02f,
  -4.30963114e-02f, -5.47927953e-02f, -4.58290353e-02f, -2.65755281e-02f, -8.98731202e-02f, -2.60147452e-02f, -6.94733784e-02f, -6.86616972e-02f, -1.46955531e-03f, -3.67810838e-02f,
  -4.67295572e-02f, -1.26700616e-02f, -1.42410612e-02f, 2.12123003e-02f, -2.63821948e-02f, 8.69535282e-02f, -2.71632476e-03f, 1.48412511e-02f, -5.22482134e-02f, 1.45825688e-02f,
  1.71095561e-02f, 1.95107907e-02f, 5.70123550e-03f, 5.32489736e-03f, 2.90406533e-02f, -5.17898798e-03f, -5.19287810e-02f, 1.01027740e-02f, 1.07382275e-02f, 2.94868238e-02f,
  -1.33632142e-02f, 1.23990150e-02f, 6.91248253e-02f, 4.08452787e-02f, -7.51975225e-03f, -2.63721272e-02f, 7.55763892e-03f, -1.12541635e-02f, -5.73375495e-03f, -6.92971051e-03f,
  2.51712769e-01f, 5.86222149e-02f, 2.11516302e-02f, 5.41325472e-03f, 2.18899958e-02f, 6.23293929e-02f, 1.72421383e-03f, -3.72587442e-02f, 6.54593948e-03f, -7.35058123e-03f,
  4.60957065e-02f, 2.95192935e-02f, 1.62981115e-02f, -2.22085845e-02f, -4.35870811e-02f, 3.62191238e-02f, -2.04986967e-02f, -4.41504456e-03f, 6.06805086e-02f, 6.19433448e-02f,
  6.72221109e-02f, 1.42606962e-02f, -3.64197642e-02f, 2.52176225e-02f, 1.43352952e-02f, -5.44969551e-02f, -7.83678610e-03f, -1.22571168e-02f, -3.25810239e-02f, 1.13207512e-02f,
  -1.48784742e-02f, 1.36271805e-01f, -2.33637929e-01f, -2.96598971e-01f, 1.17551819e-04f, -7.40481392e-02f, -3.46379243e-02f, -1.25346899e-01f, -7.49775767e-02f, 9.73950252e-02f,
  1.16597168e-01f, 1.98838726e-01f, 1.57401145e-01f, 9.29310098e-02f, -1.15413181e-01f, 9.50374752e-02f, -1.25989527e-01f, 1.26859099e-01f, 2.95274127e-02f, -7.12030530e-02f,
  -2.08302438e-01f, 1.28384560e-01f, -1.90078825e-01f, -2.48392615e-02f, -1.17332295e-01f, -1.95207983e-01f, -7.12613687e-02f, 1.22165062e-01f, -6.07570894e-02f, 1.53956920e-01f,
  1.28447518e-01f, 9.18582678e-02f, -7.90358428e-03f, -3.42915170e-02f, -1.55698985e-01f, -3.28308903e-02f, -3.18587273e-02f, 2.20052060e-02f, 1.76182331e-03f, 5.30759851e-03f,
  5.61629646e-02f, -3.03857494e-02f, 4.18438837e-02f, -8.41403380e-03f, -7.38198403e-03f, 6.57832297e-03f, -3.37810405e-02f, -5.71341924e-02f, 7.71766976e-02f, -6.59119859e-02f,
  -7.52360607e-03f, 1.22013129e-03f, -1.37729988e-01f, 1.28924176e-02f, -2.23139916e-02f, 2.16355901e-02f, 1.93308026e-03f, 2.21387204e-02f, -8.64128992e-02f, -1.16432561e-02f,
  9.63828117e-02f, -7.68844858e-02f, -1.77813843e-02f, 6.27061352e-02f, -6.54955432e-02f, 1.16874687e-02f, 1.49878729e-02f, -1.88283790e-02f, 2.34485436e-02f, 7.29263797e-02f,
  -6.03213049e-02f, 1.67308208e-02f, 2.55430229e-02f, -6.81340173e-02f, 1.06069669e-02f, -2.03463789e-02f, 1.58897545e-02f, 3.60722840e-02f, -8.11264738e-02f, -8.97670984e-02f,
  -1.88724846e-02f, 2.02102810e-02f, 7.68927783e-02f, -3.37498598e-02f, 1.85681451e-02f, -1.12436842e-02f, -8.78049806e-02f, -3.63719128e-02f, -9.28377062e-02f, 4.30378653e-02f,
  6.18439503e-02f, -1.61636658e-02f, -4.25236113e-02f, 1.08150601e-01f, 8.33845735e-02f, 3.62639986e-02f, -4.10052724e-02f, -1.52254645e-02f, 1.69767868e-02f, 5.26133459e-03f,
  -1.17733814e-01f, -7.09039047e-02f, -4.98717166e-02f, 8.94720778e-02f, -9.01055615e-03f, -3.19224708e-02f, 2.28463784e-02f, -2.53196675e-02f, -5.06236777e-02f, -4.04152162e-02f,
  -1.58292577e-02f, -2.96789948e-02f, -4.02173176e-02f, -5.32298870e-02f, -5.85098565e-02f, -3.78902629e-02f, -3.92153859e-02f, -1.60971303e-02f, -3.00359912e-03f, 2.87215915e-02f,
  6.59971654e-01f, 9.34304595e-02f, 1.02601945e-01f, 3.64194453e-01f, 1.51932999e-01f, 1.52880535e-01f, 3.13236676e-02f, 1.74476132e-01f, 2.27182493e-01f, -1.92398459e-01f,
  -9.98935699e-02f, 1.23609200e-01f, -3.96862030e-01f, 2.10050672e-01f, 1.72178015e-01f, -3.05283993e-01f, 2.42796317e-01f, 3.67774516e-02f, -1.51505424e-02f, 1.87774479e-01f,
  1.18493088e-01f, 4.19150814e-02f, -3.74811105e-02f, -4.12070714e-02f, 2.70748407e-01f, 1.16201252e-01f, -1.68784812e-01f, -1.48715004e-01f, 1.18229866e-01f, 1.41276298e-02f,
  2.68590334e-03f, -2.86455732e-03f, 8.22089314e-02f, -2.71662343e-02f, 5.53314164e-02f, 1.26130674e-02f, -2.70566978e-02f, -8.61840844e-02f, 1.62788332e-02f, 9.64021310e-04f,
  -1.66304037e-02f, 6.91692531e-02f, 5.99275418e-02f, -4.18882072e-02f, 1.07252344e-01f, 9.83251780e-02f, 4.81207632e-02f, 7.81671107e-02f, 2.22886316e-02f, 2.90885326e-02f,
  2.94629689e-02f, 7.32968450e-02f, 6.53213635e-02f, -5.65749258e-02f, 5.48301302e-02f, 4.24757749e-02f, -1.74689479e-02f, -2.20369850e-03f, -7.19624944e-03f, 1.33988246e-01f,
  4.10298929e-02f, 4.35581710e-03f, -2.25459132e-02f, 2.29753368e-02f, 3.59016433e-02f, -1.53505905e-02f, -1.44415190e-02f, -6.86396882e-02f, 1.55278156e-02f, -2.37243678e-02f,
  1.35741588e-02f, 3.79657783e-02f, -3.28067178e-03f, 1.09103164e-02f, -1.26339700e-02f, 4.53301892e-02f, -6.60274476e-02f, -4.13328372e-02f, 8.83226618e-02f, 5.90168163e-02f,
  -4.16114815e-02f, 3.84592935e-02f, -3.63508984e-02f, -2.84581259e-02f, -1.33738033e-02f, -7.68294511e-03f, 2.29679104e-02f, 2.08087768e-02f, -3.65373380e-02f, -2.70790868e-02f,
  -1.91659946e-02f, -6.35927543e-02f, -2.79995077e-03f, -1.64828524e-02f, -5.80859073e-02f, 1.70202423e-02f, -1.23886783e-02f, 1.63991954e-02f, -2.35519335e-02f, -6.67995447e-03f,
  1.09091550e-02f, -2.45147869e-02f, -1.80206522e-02f, 3.91373644e-03f, 3.29646189e-03f, -3.32714133e-02f, -5.86359501e-02f, -1.21628940e-02f, 4.88540195e-02f, 2.68277414e-02f,
  -1.75263248e-02f, -5.53865219e-03f, -7.92128593e-03f, 5.26798293e-02f, -3.52398194e-02f, 2.88273152e-02f, 5.95195740e-02f, 2.06246860e-02f, -2.58532651e-02f, -3.51002552e-02f,
  -8.65297914e-02f, 3.11689854e-01f, -7.13893622e-02f, -2.93681026e-01f, 4.97733690e-02f, 8.07266682e-02f, 6.44615218e-02f, 1.26881018e-01f, 2.22717807e-01f, 1.93137810e-01f,
  8.97021443e-02f, -2.41048530e-01f, 2.18440458e-01f, 3.83961387e-02f, -4.47203040e-01f, 2.39339456e-01f, -1.91405171e-03f, 6.09838068e-02f, 2.08960041e-01f, 1.21525312e-02f,
  -9.59677473e-02f, -6.84785843e-02f, -1.42471224e-01f, 1.28955141e-01f, -3.27593274e-02f, 1.20433392e-02f, -3.51152062e-01f, 8.37689415e-02f, -2.58610964e-01f, -9.08187777e-02f,
  -1.62119828e-02f, 1.18284263e-01f, -2.58504227e-02f, 3.99473757e-02f, 8.10613409e-02f, 2.00244635e-02f, -6.94001764e-02f, -5.25002964e-02f, 1.22768180e-02f, 5.24819717e-02f,
  -4.66534421e-02f, -4.21933196e-02f, 5.74576333e-02f, -1.43004870e-02f, 4.67346832e-02f, 1.44259306e-03f, -4.43283878e-02f, 3.83887510e-03f, -4.45286855e-02f, -1.48078864e-02f,
  6.78668075e-05f, 1.89881884e-02f, -5.60309701e-02f, -4.47202437e-02f, -3.18249576e-02f, 7.27190971e-02f, 8.56410072e-04f, -5.49528971e-02f, -4.05048049e-04f, 1.38105750e-02f,
  5.48120849e-02f, 6.10180199e-02f, 4.73462269e-02f, 3.26176248e-02f, 4.16482287e-03f, 1.39519013e-02f, -4.86442819e-02f, 5.05850231e-03f, -1.52446041e-02f, 3.70650478e-02f,
  -5.10322228e-02f, -1.72612779e-02f, 2.07410287e-02f, -1.95709802e-02f, -2.61080801e-03f, -2.64316201e-02f, -2.02401336e-02f, 4.61353883e-02f, 1.44916335e-02f, -8.35910663e-02f,
  2.42168196e-02f, -1.32730193e-02f, -3.54772620e-02f, -3.59492190e-02f, 4.39795740e-02f, 1.44126257e-02f, 1.80180147e-02f, -6.40917895e-03f, 1.42342011e-02f, -3.86370532e-02f,
  3.68154496e-02f, 6.82860464e-02f, 1.05617322e-01f, -4.14693244e-02f, -1.88163179e-03f, -3.59114967e-02f, 3.80488113e-02f, 5.13156271e-03f, -2.47886665e-02f, 1.78283453e-02f,
  7.51727670e-02f, -1.51499175e-03f, -5.99471293e-02f, -2.68958770e-02f, -7.24212602e-02f, -5.11442535e-02f, -4.18256260e-02f, -3.50279734e-02f, -6.86298832e-02f, -2.73542237e-02f,
  -6.99931756e-02f, 3.96210887e-02f, 1.89027167e-04f, -8.50529782e-03f, -3.52848833e-03f, -1.58964582e-02f, -5.11368662e-02f, 9.28509515e-03f, -1.55486139e-02f, 2.23851465e-02f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.33309224e-01f, -1.47943735e-01f, -1.65076479e-01f, -3.62713367e-01f, 2.38890499e-01f, 1.42742231e-01f, -3.99280116e-02f, 1.41731054e-01f, -2.22709537e-01f, 1.74944967e-01f,
  1.06091335e-01f, -3.28471452e-01f, 1.65405478e-02f, -4.56854045e-01f, -2.89553881e-01f, -3.38491082e-01f, -2.04648986e-01f, -1.31314248e-01f, -1.75519302e-01f, 1.20807312e-01f,
  -3.72177996e-02f, -7.73733631e-02f, -1.13334134e-01f, 2.09912091e-01f, 3.21905501e-02f, 2.30540872e-01f, 3.08319151e-01f, 1.86046466e-01f, 1.31347090e-01f, -1.49111480e-01f,
  -1.27170414e-01f, -8.49541128e-02f, 4.79831137e-02f, -5.68345822e-02f, 1.79461360e-01f, 1.34034753e-01f, 2.73652393e-02f, -9.28204060e-02f, -8.72325711e-03f, -4.89529930e-02f,
  4.36915942e-02f, -9.46661364e-03f, -2.25742329e-02f, -9.60136764e-03f, 7.39800408e-02f, -3.23843993e-02f, -6.16673417e-02f, 7.18151405e-02f, 4.60708998e-02f, -2.44912449e-02f,
  -5.99182360e-02f, 4.21437658e-02f, -2.13023052e-02f, -1.65129127e-03f, 7.64279510e-04f, -1.82734244e-03f, 2.52211895e-02f, 4.62212898e-02f, -2.26559378e-02f, -6.57064561e-03f,
  2.90244905e-04f, 9.31705758e-02f, -3.77634019e-02f, -2.87548732e-02f, -6.43629357e-02f, -1.67052057e-02f, 1.48720248e-02f, 5.28544514e-03f, 4.32623550e-02f, 2.13582702e-02f,
  1.24177728e-02f, 7.86802080e-03f, -5.46465851e-02f, -1.02679636e-02f, -1.11465203e-02f, -1.98018905e-02f, -3.42319198e-02f, -1.40586989e-02f, -3.42346840e-02f, 1.73417423e-02f,
  1.05454316e-02f, 2.06351001e-02f, -4.59698290e-02f, 6.95500895e-03f, -3.29678953e-02f, -7.20229074e-02f, 5.09914272e-02f, -9.09007192e-02f, 4.47712392e-02f, 9.34260264e-02f,
  1.75682127e-01f, 2.30479255e-01f, -1.02576902e-02f, -3.04702744e-02f, -2.38103624e-02f, 6.17207773e-02f, -3.09795439e-02f, -5.48980273e-02f, 1.90280769e-02f, -2.33196989e-02f,
  1.29178792e-01f, 5.54273836e-02f, 1.11398086e-01f, -1.10237345e-01f, 1.04357139e-03f, 2.70502735e-02f, 1.14893019e-01f, -1.50901172e-02f, 7.25018010e-02f, 4.86904420e-02f,
  1.46275297e-01f, 2.96187233e-02f, -6.19837493e-02f, 7.60461167e-02f, 6.31558150e-02f, 7.03479648e-02f, 3.89895029e-02f, 2.37466320e-02f, -2.66946964e-02f, -5.03632687e-02f,
  3.38221788e-01f, -3.08329105e-01f, -4.98989254e-01f, 5.44706807e-02f, 3.85715783e-01f, 1.94412634e-01f, -2.53364861e-01f, 1.35714397e-01f, -3.29326123e-01f, -1.70129791e-01f,
  1.43807814e-01f, -2.99144499e-02f, -6.05468631e-01f, 3.89017731e-01f, 3.52256805e-01f, -3.84249300e-01f, 4.26657170e-01f, 1.77714482e-01f, -1.05993874e-01f, 2.23629922e-01f,
  1.78567499e-01f, 6.89969599e-01f, -6.62878230e-02f, 3.78731191e-01f, 2.68110126e-01f, 1.91183351e-02f, 2.99335033e-01f, -2.02218607e-01f, 4.22518373e-01f, 2.61654109e-01f,
  1.61568690e-02f, -3.28845941e-02f, -8.48130211e-02f, -5.53827621e-02f, 1.26324240e-02f, 5.70371673e-02f, -4.18102965e-02f, 6.07733168e-02f, -9.32400860e-03f, -8.33142325e-02f,
  -1.87138990e-02f, 6.82547688e-02f, 1.30166709e-01f, 2.11242996e-02f, 8.93374383e-02f, 9.12053883e-03f, -6.88351169e-02f, -1.17679551e-01f, -7.70346671e-02f, -1.76019780e-02f,
  -1.70423135e-01f, -1.87166352e-02f, -9.56815016e-03f, -1.05913438e-01f, -5.64642884e-02f, -2.08898503e-02f, -1.13153374e-02f, -3.01274247e-02f, 4.07662503e-02f, 5.51114604e-02f,
  1.61597803e-01f, -4.40809242e-02f, 6.74503669e-02f, 1.35201020e-02f, 3.84739637e-02f, 2.28583533e-02f, 1.10160559e-02f, 2.66407281e-02f, -6.72710389e-02f, 1.86517108e-02f,
  -6.45452961e-02f, 2.77883131e-02f, 4.35677543e-03f, -4.41000052e-03f, 6.37437850e-02f, -1.36586353e-02f, -4.97199316e-03f, 8.12143534e-02f, -1.15628242e-01f, -5.17038368e-02f,
  -3.74091491e-02f, 5.29287644e-02f, -2.29084361e-02f, -3.32227200e-02f, 6.49351776e-02f, -4.87903617e-02f, 7.79288039e-02f, 1.26536861e-02f, -6.48846552e-02f, 3.37824114e-02f,
  4.25052010e-02f, 9.02325138e-02f, -9.62141603e-02f, 1.76542755e-02f, -5.06329117e-03f, 1.44684687e-01f, -1.99030880e-02f, 5.10790423e-02f, 1.86442137e-02f, 3.21956985e-02f,
  7.14200214e-02f, -7.10334582e-03f, 3.27767655e-02f, 1.98216084e-02f, 2.39031631e-02f, 2.73262132e-02f, 5.38890250e-02f, 1.16968509e-02f, 3.39711420e-02f, 1.37006342e-01f,
  -1.86266284e-02f, -1.24296919e-02f, 1.60059854e-02f, 3.27015892e-02f, 4.66299765e-02f, -4.39624535e-03f, 1.09786075e-02f, -9.82307494e-02f, 1.03722095e-01f, -6.91007599e-02f,
  3.81817222e-02f, 3.67374659e-01f, -1.79004539e-02f, 3.62620279e-02f, -1.24649405e-01f, -5.07216215e-01f, -2.64957547e-01f, -5.53013235e-02f, 1.87711939e-01f, 2.38378897e-01f,
  -1.32015750e-01f, 3.66324931e-01f, 1.07072219e-02f, -1.84802741e-01f, -7.73811996e-01f, -2.28470683e-01f, -4.70300168e-01f, -6.39064386e-02f, -2.51387116e-02f, -9.49333981e-02f,
  -1.85335651e-01f, -2.34565035e-01f, -2.08675891e-01f, 1.22821378e-02f, 5.11186570e-02f, 1.74578354e-01f, -9.99921933e-02f, 5.36455475e-02f, -8.60650614e-02f, -6.90216720e-02f,
  -1.28313184e-01f, 2.22546056e-01f, 1.10818923e-01f, -1.32923666e-02f, -1.65617928e-01f, 2.84639038e-02f, 1.72416586e-02f, -7.15586543e-02f, -5.38824592e-03f, -2.92022782e-03f,
  8.84276927e-02f, 2.91740410e-02f, -1.60410255e-02f, 5.51644824e-02f, 1.53025791e-01f, 3.87131460e-02f, -1.11088445e-02f, 5.56056462e-02f, 1.32588118e-01f, 2.26651691e-02f,
  7.68702701e-02f, -1.11398185e-02f, -2.48159803e-02f, 7.31562600e-02f, -2.87533458e-02f, 2.59093624e-02f, -7.14206025e-02f, 3.07146981e-02f, -1.78741887e-02f, -5.17968610e-02f,
  4.24537659e-02f, -3.55951069e-03f, -3.45648564e-02f, 4.71396260e-02f, 2.38587498e-03f, 4.90061790e-02f, 2.13742745e-03f, -3.73435281e-02f, 6.81008324e-02f, -9.43994597e-02f,
  -6.17343187e-02f, 1.39663871e-02f, -1.73312705e-02f, -5.95341576e-03f, -1.81762967e-02f, 8.29318985e-02f, -4.55367658e-03f, 1.69756059e-02f, -5.33791073e-02f, -2.80261561e-02f,
  2.19763368e-02f, -9.64091644e-02f, 6.59471229e-02f, 3.94679718e-02f, -3.73176932e-02f, -2.54924539e-02f, 7.46848360e-02f, 8.31129998e-02f, 3.51984128e-02f, -4.58914153e-02f,
  -2.13526487e-01f, -2.06141636e-01f, -6.59099128e-03f, 1.01157159e-01f, 4.09946553e-02f, -7.68652111e-02f, -1.11151740e-01f, 4.33061719e-02f, -8.52859616e-02f, -1.14506952e-01f,
  6.12761732e-03f, 5.50999120e-02f, -4.40063700e-02f, -5.99968771e-04f, -5.65811619e-02f, -4.80926409e-02f, 4.01132144e-02f, -3.49188484e-02f, -9.21389535e-02f, -2.79850187e-03f,
  9.68195572e-02f, 4.22634222e-02f, -2.05408335e-02f, 1.82992592e-02f, 1.82269011e-02f, -6.20375052e-02f, 4.81560975e-02f, -1.04494602e-03f, 1.55921327e-02f, -1.29341688e-02f,
  3.85965444e-02f, -1.23100504e-01f, -1.61597744e-01f, -1.73421517e-01f, -3.24000455e-02f, -2.18199879e-01f, -3.35192353e-01f, -3.51561084e-02f, 2.25758180e-01f, -1.82297617e-01f,
  -2.00240731e-01f, 5.41229993e-02f, -7.56293535e-03f, -2.31399700e-01f, 1.64191455e-01f, 1.58491015e-01f, -2.43483201e-01f, -8.89800489e-02f, 8.98921024e-03f, -3.34008783e-01f,
  2.40600575e-02f, -2.87577450e-01f, -8.08878466e-02f, -2.79887795e-01f, -2.50345379e-01f, -1.61358446e-01f, 5.76230586e-02f, -2.40860209e-01f, -2.33930692e-01f, -8.86602029e-02f,
  -6.80912659e-02f, 6.98036561e-03f, -1.21359348e-01f, -1.27672683e-02f, -4.37935069e-02f, -4.18883115e-02f, -3.21530811e-02f, -7.59238228e-02f, 5.80481905e-03f, -5.74354315e-03f,
  3.17033343e-02f, 8.43404531e-02f, -3.85639183e-02f, 7.45147839e-02f, -9.43877250e-02f, 4.90278229e-02f, -2.19014403e-03f, 7.59000704e-03f, -4.70402800e-02f, 7.77238086e-02f,
  -1.19827040e-01f, -4.12745550e-02f, 4.73891050e-02f, 1.01064436e-01f, 5.14702592e-03f, -1.18181370e-01f, 9.14525762e-02f, 8.14123265e-03f, 7.31083751e-02f, 6.11578897e-02f,
  -1.10625900e-01f, 4.60792221e-02f, -5.06660417e-02f, -6.12170696e-02f, 3.20325047e-02f, -5.79647683e-02f, -4.28275391e-02f, 5.43516092e-02f, 4.82925214e-02f, 2.46104114e-02f,
  4.93345410e-02f, 5.52409068e-02f, -4.11492260e-03f, 5.77641353e-02f, -1.09375520e-02f, -2.30216719e-02f, -7.32343644e-02f, -1.44501338e-02f, 2.09234878e-02f, -2.67836060e-02f,
  4.93290871e-02f, -3.94743346e-02f, 1.22983363e-02f, 1.00279413e-02f, 1.57139555e-03f, 3.54539715e-02f, -4.99998890e-02f, 8.33524298e-03f, 6.23474047e-02f, -6.36379346e-02f,
  2.45448225e-03f, -6.46341592e-02f, -2.98949610e-03f, -7.17873424e-02f, -1.21884264e-01f, -9.90786180e-02f, -7.53780752e-02f, 2.42211241e-02f, 2.29592174e-02f, 8.97151046e-03f,
  -1.04186617e-01f, -2.69587580e-02f, -6.17162511e-02f, 1.86021184e-03f, -1.57677606e-02f, -7.39182308e-02f, -8.50070864e-02f, -1.04825594e-03f, -1.25233771e-03f, -1.18815703e-02f,
  -1.09598506e-02f, 2.44601443e-02f, -1.95084291e-03f, 2.79508494e-02f, 7.86254555e-03f, 3.01056784e-02f, -4.96828295e-02f, 1.28329834e-02f, 3.95059176e-02f, -1.88544393e-02f,
  -3.31312865e-01f, 3.06812614e-01f, -2.84618348e-01f, 1.12930156e-01f, -2.71329552e-01f, 2.89636254e-01f, 4.23491061e-01f, 3.50589119e-02f, 1.67929754e-01f, 5.78632355e-01f,
  3.71880800e-01f, -5.07750399e-02f, 2.12212875e-01f, 5.37193000e-01f, 7.48069212e-02f, 4.07498956e-01f, 6.10187292e-01f, 3.66755545e-01f, -3.27782780e-02f, 8.29891860e-02f,
  -1.55755610e-03f, 3.97300869e-01f, -3.76743078e-02f, -1.33417591e-01f, 5.33400290e-02f, -2.91996330e-01f, -5.81485108e-02f, -3.83855075e-01f, 1.01481453e-01f, -5.92417456e-02f,
  1.10182360e-01f, 9.90989655e-02f, -1.09415352e-01f, -1.05883442e-01f, -2.01560929e-02f, -3.30457278e-02f, -1.26612306e-01f, -1.67730302e-01f, -8.16786215e-02f, -7.11709335e-02f,
  2.02146955e-02f, -5.26150316e-02f, 4.90373671e-02f, -7.24309832e-02f, -7.78108612e-02f, -1.28957406e-01f, -4.27634455e-02f, -1.55403186e-02f, 1.37923309e-03f, -8.99724439e-02f,
  -5.06223030e-02f, -3.08416113e-02f, 7.05774724e-02f, 9.33294520e-02f, -5.63190430e-02f, 4.55373190e-02f, 1.20155729e-01f, -7.72151724e-02f, 2.59876214e-02f, 6.81960359e-02f,
  -6.84041530e-02f, 8.05668533e-02f, 5.04258424e-02f, -8.61840174e-02f, -1.72982477e-02f, -2.31560729e-02f, 1.83055364e-02f, -4.24038395e-02f, -8.53798538e-02f, 5.61012374e-03f,
  -4.70959991e-02f, -6.75978139e-02f, -1.14139263e-02f, 2.56757289e-02f, 5.54895326e-02f, 7.48504475e-02f, -1.20378323e-01f, -4.03820723e-02f, 7.26060569e-02f, -4.69357148e-02f,
  6.80624694e-02f, 5.94333522e-02f, -1.90072134e-02f, 2.60638837e-02f, -3.03404243e-03f, -5.40839359e-02f, 5.56521602e-02f, 3.13849710e-02f, 3.66326831e-02f, -5.56192808e-02f,
  2.12455288e-01f, 2.99086720e-01f, -1.43174278e-02f, 1.19045889e-02f, -2.01916955e-02f, 3.42020243e-02f, 7.38174543e-02f, 2.17986032e-02f, 2.80694533e-02f, 1.85676292e-02f,
  4.12586480e-02f, -1.58272889e-02f, -1.71848983e-02f, -9.89674926e-02f, -2.01470330e-02f, 1.36722505e-01f, 6.87384829e-02f, 1.41418146e-04f, 3.56449410e-02f, 3.33537027e-04f,
  -6.33083060e-02f, 4.93412130e-02f, -1.11397272e-02f, -5.38409837e-02f, 9.60548595e-02f, -2.78731366e-03f, -3.43649462e-02f, -4.80657965e-02f, -5.40456250e-02f, 4.88485359e-02f,
  1.10127732e-01f, -5.44108488e-02f, 9.91140530e-02f, 2.83492357e-01f, 4.10811827e-02f, -2.68161148e-01f, -2.58271247e-01f, -9.77618024e-02f, 1.12342194e-01f, -1.16082646e-01f,
  -1.47963688e-01f, 2.22104579e-01f, -4.86602485e-01f, 6.30585924e-02f, -1.80620030e-01f, -3.22854102e-01f, 6.54719621e-02f, 5.88129796e-02f, 6.96366727e-02f, 1.85497981e-02f,
  6.76122680e-02f, -1.07812434e-01f, -7.02932253e-02f, 9.96818952e-03f, 1.37734637e-01f, 3.51664990e-01f, 1.80224285e-01f, 6.67153671e-03f, 3.23630005e-01f, -1.56114930e-02f,
  7.84443505e-03f, -6.42293990e-02f, 4.68313843e-02f, 7.59035721e-02f, -1.24090044e-02f, 4.08470556e-02f, 3.35157104e-02f, -3.91655676e-02f, 8.00574347e-02f, -6.10949509e-02f,
  4.14402690e-03f, 5.63336536e-04f, 6.95382953e-02f, -6.67750090e-02f, 1.14465714e-01f, 8.84227157e-02f, 6.75470755e-02f, 5.45975231e-02f, -1.34784430e-02f, -1.02210820e-01f,
  4.86227795e-02f, 6.94530979e-02f, 1.27792895e-01f, 5.25838770e-02f, 6.41291514e-02f, 4.52493951e-02f, 2.19376869e-02f, 6.95799440e-02f, 1.03767969e-01f, 4.09235023e-02f,
  -1.91626959e-02f, -1.90940890e-02f, -9.94015932e-02f, 1.71034895e-02f, -8.58604684e-02f, 7.01493695e-02f, -1.56316012e-02f, 2.21924065e-03f, -6.19938746e-02f, -5.77378878e-03f,
  -3.53553407e-02f, 7.71842971e-02f, 3.76236476e-02f, 5.73532730e-02f, -1.94700453e-02f, -3.40756737e-02f, -2.30232161e-02f, 5.87983616e-02f, 1.21334471e-01f, -2.09439583e-02f,
  -7.46627077e-02f, 3.39663029e-02f, 2.28294134e-02f, -4.15834226e-02f, 1.72113664e-02f, -3.46990600e-02f, -5.92008175e-04f, -2.94164717e-02f, 4.27038856e-02f, 3.76841165e-02f,
  7.33110029e-03f, -5.34072816e-02f, 1.36384685e-02f, 5.18884957e-02f, 3.45943822e-03f, -4.53150123e-02f, -3.44546023e-03f, 3.38413753e-02f, -8.04533809e-02f, -5.93337603e-02f,
  9.87543464e-02f, 9.54799503e-02f, 6.39286786e-02f, -9.31186974e-03f, -5.17095402e-02f, -4.93033975e-02f, 3.17402482e-02f, 1.38761818e-01f, 1.34453401e-01f, 8.65432397e-02f,
  5.01121134e-02f, -9.52182561e-02f, -4.67624106e-02f, 3.11727691e-02f, -6.12845225e-03f, -3.98157202e-02f, 1.06174327e-01f, -2.32874732e-02f, 5.60665876e-02f, 7.32703954e-02f,
  4.78110835e-02f, 9.45952684e-02f, 8.54431093e-03f, 7.28833154e-02f, -8.14880356e-02f, -2.42206737e-01f, -4.14260514e-02f, 7.57427216e-02f, -1.62519310e-02f, -2.25006044e-02f,
  -4.03107377e-03f, 2.77784616e-02f, -2.42836624e-02f, -2.22403603e-03f, 1.38200000e-01f, -2.70964634e-02f, 1.20569997e-01f, -1.38945997e-01f, 2.04823595e-02f, 1.26923442e-01f,
  8.74484852e-02f, 1.73136815e-01f, 7.42176771e-02f, 1.48591474e-01f, 7.42670223e-02f, 1.11019306e-01f, 1.82837591e-01f, 8.60351622e-02f, 1.03645921e-01f, 1.04267053e-01f,
  -8.57295021e-02f, 1.19166851e-01f, -2.93195306e-04f, -1.12039372e-01f, -4.48890701e-02f, -4.83395755e-02f, -3.31658833e-02f, -1.75961237e-02f, -8.72779191e-02f, 9.30843689e-03f,
  -3.20020132e-02f, 6.11624457e-02f, -4.16352559e-04f, 2.81330142e-02f, 3.11970972e-02f, 1.09041981e-01f, 7.45466771e-03f, -4.30778861e-02f, -6.82517290e-02f, -6.67338595e-02f,
  -1.01713844e-01f, -1.08231278e-02f, 1.15407980e-03f, 7.54182041e-02f, 1.20739741e-02f, 5.35739064e-02f, 4.48825918e-02f, -9.98091605e-03f, -1.22957593e-02f, 1.65451271e-03f,
  1.26771033e-01f, -2.66064499e-02f, -1.19473774e-03f, -5.24149537e-02f, -8.39603133e-03f, -5.87404519e-02f, 8.69492721e-03f, -6.09808750e-02f, -5.46148494e-02f, 1.18182052e-03f,
  -5.10913357e-02f, 4.74701934e-02f, -3.32832858e-02f, -7.59683698e-02f, 1.27622893e-03f, 2.42575798e-02f, -1.08907618e-01f, -6.08110521e-03f, -3.51425223e-02f, -2.27454621e-02f,
  1.43062929e-02f, 2.49405801e-02f, -5.88687044e-03f, -3.07767149e-02f, 1.89525001e-02f, -9.85153392e-03f, 8.32050890e-02f, -2.85032368e-03f, 4.34854627e-02f, 4.43108007e-02f,
  8.79010484e-02f, 3.27591062e-01f, -3.18890996e-02f, -1.87963396e-02f, -9.92356986e-02f, -4.71959300e-02f, 6.16719052e-02f, -6.55708387e-02f, 1.97468102e-01f, 4.73029763e-02f,
  -6.68107020e-03f, -5.57784736e-02f, -5.27430661e-02f, -5.52487820e-02f, -1.97630543e-02f, -5.33982553e-03f, 9.99967530e-02f, -4.79853190e-02f, 7.18025863e-02f, 4.26339209e-02f,
  9.21072736e-02f, 3.44163403e-02f, -6.55309111e-02f, 2.22994946e-03f, 1.58575568e-02f, 4.62704375e-02f, 6.82916269e-02f, -1.84363760e-02f, -2.18512509e-02f, 1.92407444e-02f,
  -2.39487872e-01f, 8.56689736e-03f, -3.29968989e-01f, -2.38464788e-01f, 3.89957502e-02f, -1.40962467e-01f, -2.90365607e-01f, 1.80538150e-03f, -4.68371846e-02f, 1.53686181e-01f,
  7.56955370e-02f, -1.58952221e-01f, 3.74883227e-02f, -3.70448112e-01f, -4.48890239e-01f, -1.03557266e-01f, -3.99569631e-01f, -2.41734624e-01f, -8.54535699e-02f, -6.49526864e-02f,
  -1.56590581e-01f, -2.53379401e-02f, -3.34242821e-01f, 1.64859459e-01f, -6.50169775e-02f, 1.19219624e-01f, 1.61972612e-01f, 9.18257087e-02f, -9.19448286e-02f, -1.05979376e-01f,
  -1.51952982e-01f, -4.18730341e-02f, -8.06846619e-02f, -7.82857612e-02f, -4.82048951e-02f, -8.29944946e-03f, 1.54435625e-02f, 3.09775732e-02f, 2.38622166e-02f, -4.71759178e-02f,
  5.65272346e-02f, 1.05486633e-02f, -1.35472164e-01f, 2.83521204e-03f, 1.06183691e-02f, -4.98360489e-03f, 1.31091643e-02f, -2.53176633e-02f, -6.07015900e-02f, -9.14856941e-02f,
  -1.00248180e-01f, -9.08360183e-02f, 4.07961048e-02f, -8.14391226e-02f, 2.96837231e-03f, 5.60373329e-02f, -3.60885300e-02f, -4.40780371e-02f, 3.97430845e-02f, 2.08993182e-02f,
  7.50611648e-02f, 1.38685256e-02f, 1.17666628e-02f, -4.54274602e-02f, 2.07660720e-02f, -3.48156877e-02f, -2.38202214e-02f, 6.85345978e-02f, 2.27137804e-02f, 8.69694650e-02f,
  -5.32109775e-02f, 6.33303747e-02f, -2.51157619e-02f, 1.30833490e-02f, 2.98689771e-02f, 3.59853506e-02f, -9.03212093e-03f, 3.85353900e-02f, 2.45129783e-02f, 1.10828709e-02f,
  2.76626069e-02f, -1.20210713e-02f, -4.25921716e-02f, 7.80631695e-03f, -9.24436972e-02f, 7.83065241e-03f, 8.26552585e-02f, -4.61754911e-02f, -4.80257310e-02f, -1.83653608e-02f,
  6.04223758e-02f, 1.27064705e-01f, 2.35830769e-02f, -4.86752726e-02f, -1.51973190e-02f, 9.24990920e-04f, -1.85638070e-02f, -1.25572503e-01f, -4.38305140e-02f, -1.58576015e-02f,
  7.29806200e-02f, 2.80410331e-02f, 9.51811224e-02f, 3.07528842e-02f, -1.96974073e-03f, -4.69392873e-02f, 2.29631737e-02f, 3.97818238e-02f, -3.07092676e-04f, 1.80263445e-02f,
  3.94984521e-02f, 7.61715695e-02f, 3.81336473e-02f, 4.82691489e-02f, 3.85616347e-03f, 2.70079505e-02f, 2.60071456e-02f, 4.18325439e-02f, 5.10106571e-02f, 5.46529563e-03f,
  5.32655083e-02f, 4.70038861e-01f, 5.00950396e-01f, 2.84594834e-01f, -1.33212686e-01f, -1.21850431e-01f, -9.98821482e-02f, 2.51883507e-01f, 3.34859431e-01f, -5.44603774e-03f,
  -2.52363592e-01f, 2.33300582e-01f, 2.18156688e-02f, 1.13569953e-01f, 1.07396264e-02f, 2.55075991e-02f, 2.17191294e-01f, -2.77823918e-02f, 2.13861406e-01f, 1.93440825e-01f,
  1.60383537e-01f, -1.77122578e-01f, 1.32250637e-01f, -6.55838568e-03f, 9.82320532e-02f, 1.53738379e-01f, -1.43202618e-01f, -1.15483433e-01f, 8.93697317e-04f, 1.42027321e-03f,
  -2.01046914e-01f, 2.40757138e-01f, 1.22695707e-01f, 1.50086522e-01f, 9.47919562e-02f, -1.05917901e-01f, -7.94299468e-02f, -6.55644387e-02f, 4.27867919e-02f, -1.03167500e-02f,
  3.65493372e-02f, 5.75235579e-03f, 1.19359225e-01f, -2.98899296e-03f, 1.68234557e-02f, 5.60874417e-02f, 1.14700841e-02f, -2.44084862e-03f, 9.92167369e-02f, -6.08414179e-03f,
  1.34640813e-01f, 2.48097368e-02f, -6.36201724e-02f, 9.49777216e-02f, 5.13167381e-02f, -8.63243244e-04f, -2.04865672e-02f, 9.36688110e-02f, 6.46096319e-02f, 1.24867177e-02f,
  5.20327501e-02f, -3.55931632e-02f, -1.81088187e-02f, -7.05692098e-02f, 5.29264472e-02f, -2.12550368e-02f, -4.87378538e-02f, -5.91103397e-02f, 4.37238179e-02f, -1.10810846e-01f,
  -1.50286304e-02f, 4.06916179e-02f, 1.56238824e-02f, 1.94874983e-02f, -1.04415128e-02f, 5.05963620e-03f, -4.71560694e-02f, 2.13819444e-02f, 5.54796867e-02f, 1.26080336e-02f,
  6.39090836e-02f, 1.44909816e-02f, -1.85714066e-02f, -8.80440325e-02f, 1.79223213e-02f, -3.29100750e-02f, 4.85795587e-02f, 1.00473233e-01f, -1.10091612e-01f, -1.03220795e-04f,
  1.03064328e-01f, 4.14550334e-01f, 1.30863890e-01f, 4.52425778e-02f, 3.94853316e-02f, -4.78131175e-02f, 8.77580233e-03f, 8.44876692e-02f, 1.18472509e-01f, 1.03802398e-01f,
  -7.92208011e-05f, -7.26262107e-03f, -7.20326081e-02f, -1.56728476e-02f, -4.53856401e-03f, 1.76655594e-02f, 1.61778089e-02f, 1.10777199e-01f, -8.33038334e-03f, 6.65781647e-02f,
  1.91563237e-02f, -9.01694298e-02f, 2.13453490e-02f, -6.26137704e-02f, -1.73666719e-02f, -9.95534286e-02f, 1.31345596e-02f, -1.53172370e-02f, 4.92800847e-02f, 9.19411927e-02f,
  6.28347993e-02f, -6.30784571e-01f, 3.26014549e-01f, 6.73686117e-02f, 3.56943488e-01f, 2.00194374e-01f, 2.89361954e-01f, -1.55293986e-01f, -2.10703164e-01f, -6.36961877e-01f,
  -2.14073360e-02f, -1.74410701e-01f, -1.14425141e-02f, 1.45951388e-02f, 4.14932549e-01f, 7.20105097e-02f, -1.57263745e-02f, 3.74948117e-03f, 1.08650446e-01f, -1.59821622e-02f,
  1.52652055e-01f, -1.88425574e-02f, 3.50351870e-01f, -8.74581859e-02f, 1.25125140e-01f, -1.31285995e-01f, -1.09114818e-01f, 2.66632944e-01f, -1.57090276e-01f, 9.59999189e-02f,
  -8.49018171e-02f, -9.30933729e-02f, 1.05545864e-01f, 1.47925867e-02f, -6.60781190e-03f, 4.61668298e-02f, 6.60959780e-02f, 1.35620639e-01f, 3.60869467e-02f, -8.51857141e-02f,
  -5.28257228e-02f, 7.38703907e-02f, -1.28687629e-02f, 9.50221643e-02f, -1.94528457e-02f, -1.59772821e-02f, 2.13441998e-02f, 4.22220528e-02f, 3.01005002e-02f, 8.90649483e-02f,
  3.07744816e-02f, -3.79791223e-02f, 1.12996005e-01f, -4.88830172e-02f, 6.68161511e-02f, -2.08230484e-02f, 4.65801656e-02f, 4.49021347e-02f, -1.98931545e-02f, -5.37890941e-03f,
  3.47427391e-02f, 1.66378170e-03f, 4.03781934e-03f, -7.35252202e-02f, -2.33330727e-02f, -6.30541593e-02f, -7.34181255e-02f, -1.06328381e-02f, 8.20904505e-03f, -5.78540117e-02f,
  -6.19440712e-02f, -2.55474802e-02f, 1.87850790e-03f, 2.54946407e-02f, -4.17296551e-02f, -4.74053845e-02f, 7.27520585e-02f, -3.73269282e-02f, 4.77158017e-02f, -1.53949326e-02f,
  -6.04643188e-02f, 3.59215587e-02f, -2.87936367e-02f, 2.15952005e-02f, 2.73897629e-02f, -1.09280953e-02f, -1.04407847e-01f, 5.23823537e-02f, 5.15975915e-02f, 3.27296294e-02f,
  -2.73160726e-01f, -5.37484407e-01f, -5.71647994e-02f, -1.03021868e-01f, 1.53157366e-02f, -3.71970236e-02f, -1.86030958e-02f, -2.08845139e-02f, -4.75805998e-02f, 2.07267832e-02f,
  -1.73932184e-02f, -1.20098731e-02f, -1.09990925e-01f, 1.12528345e-02f, -2.80648451e-02f, -9.08677801e-02f, -7.92317167e-02f, -8.69289339e-02f, -4.08311039e-02f, -5.39335087e-02f,
  -5.29772975e-02f, -4.98510525e-02f, 5.37989996e-02f, 1.95753984e-02f, 2.82092281e-02f, -8.73412713e-02f, -3.13555673e-02f, -2.14237105e-02f, -6.42832741e-02f, -1.12802526e-02f,
  -1.50704741e-01f, -7.26370364e-02f, 5.80906682e-02f, 1.17400154e-01f, 4.41097081e-01f, 1.06464259e-01f, 8.88017416e-02f, 2.13127241e-01f, 4.02015448e-01f, -1.42813414e-01f,
  -6.27082991e-05f, -1.84262410e-01f, -1.41721740e-01f, 2.88821347e-02f, -1.33434400e-01f, -9.38213989e-03f, 7.86326230e-02f, -1.44930584e-02f, 1.59429103e-01f, -1.05794705e-01f,
  -7.21415952e-02f, 2.05449983e-02f, -1.69820741e-01f, -6.82443962e-04f, -4.18211445e-02f, -4.54712063e-02f, -9.42337215e-02f, 1.23021036e-01f, -8.26799795e-02f, 1.26367748e-01f,
  -1.94615815e-02f, 2.31555733e-03f, -6.74240962e-02f, -1.52072441e-02f, -1.12667933e-01f, -1.23459622e-01f, -9.02841613e-02f, 2.88187596e-03f, 5.57202380e-03f, 3.08359298e-03f,
  -1.16531342e-01f, -3.88710015e-02f, -3.76211405e-02f, 8.00779238e-02f, 5.62683959e-03f, 8.02890435e-02f, -2.79201418e-02f, -1.61221661e-02f, 1.33980336e-02f, -3.81224602e-02f,
  -2.31396630e-02f, -5.63610829e-02f, -6.64811656e-02f, -1.06041115e-02f, 5.66850603e-03f, 8.63253698e-02f, -4.38039824e-02f, -1.00546315e-01f, 2.72452869e-02f, 2.66506560e-02f,
  -4.27899994e-02f, 9.97832790e-02f, -4.08897586e-02f, -2.20256634e-02f, 1.24113320e-03f, 4.83649485e-02f, -7.83235431e-02f, 3.13730650e-02f, -5.59119172e-02f, 5.42211868e-02f,
  1.56240826e-02f, 7.12118894e-02f, 1.08480118e-01f, 8.12174678e-02f, 1.47919497e-02f, 4.37314808e-02f, -1.07511058e-01f, 6.90473169e-02f, 7.97019526e-03f, -3.06585860e-02f,
  3.92049830e-03f, 7.32480958e-02f, 8.54909886e-03f, 1.40337870e-02f, -1.23401107e-02f, -5.32989800e-02f, -4.20972258e-02f, -2.25299411e-02f, -7.92116001e-02f, 3.84580754e-02f,
  1.16349779e-01f, 1.39357030e-01f, 4.03719135e-02f, -6.04676642e-02f, 3.64338909e-03f, 4.78968248e-02f, 2.11949851e-02f, -1.08856019e-02f, -7.66505545e-04f, -1.20939221e-02f,
  -1.14738435e-01f, -4.44147959e-02f, 4.72197980e-02f, 4.30276766e-02f, -1.67071093e-02f, 9.06749070e-03f, -4.29987870e-02f, 2.35062856e-02f, -4.70644124e-02f, -1.06213599e-01f,
  -7.70704746e-02f, 2.02316232e-02f, -3.93286683e-02f, -6.43980727e-02f, -6.91247871e-03f, -4.47745901e-03f, -3.72905284e-03f, -3.40950377e-02f, -4.85640392e-02f, 8.78659263e-02f,
  7.12614134e-02f, 8.18834826e-03f, -2.90100068e-01f, -2.11626008e-01f, -2.45669857e-01f, 1.15432180e-01f, -1.37168020e-01f, -3.06599773e-02f, 2.90751792e-02f, -9.99681130e-02f,
  -3.46107513e-01f, 1.42639518e-01f, 6.74344376e-02f, -2.66739160e-01f, 3.10604483e-01f, 3.84333462e-01f, -4.22476977e-02f, -9.04385820e-02f, 8.73743370e-02f, -1.26276299e-01f,
  4.66745235e-02f, -1.79607809e-01f, -4.80797179e-02f, -2.43898287e-01f, -3.60866219e-01f, -3.18323910e-01f, -1.55175537e-01f, -2.76837528e-01f, -2.92076677e-01f, -1.49297878e-01f,
  2.12928765e-02f, -4.74245921e-02f, -6.50818050e-02f, 1.31732240e-01f, -4.48689349e-02f, -9.33581777e-03f, 8.87707155e-03f, -3.14870011e-03f, -1.01196073e-01f, -6.17665611e-03f,
  7.40494207e-02f, 7.76633099e-02f, -9.92941298e-03f, 4.96820323e-02f, 5.36134243e-02f, -9.48295295e-02f, -4.40718271e-02f, -1.66964661e-02f, -1.06990607e-02f, 1.10362276e-01f,
  -5.49876168e-02f, 3.40019576e-02f, -1.43223166e-01f, 5.82289062e-02f, -1.16429567e-01f, -2.48127617e-02f, 1.25301957e-01f, 5.94949387e-02f, -2.53147036e-02f, 1.89611893e-02f,
  1.35310531e-01f, 6.57491386e-02f, 7.73522481e-02f, 1.82551872e-02f, -3.35061178e-03f, -1.31438663e-02f, 1.38408542e-02f, 2.46108919e-02f, 5.28221130e-02f, -1.17913065e-02f,
  -9.55496654e-02f, -7.64689296e-02f, 4.21818905e-02f, 1.17403008e-02f, -1.69781130e-02f, 2.97722574e-02f, 9.54870041e-03f, -4.43089046e-02f, -1.90025382e-02f, -1.10381849e-01f,
  -6.86509088e-02f, 8.89656097e-02f, -6.94184676e-02f, -9.66497362e-02f, -9.84510686e-03f, 1.64585412e-02f, 1.68829933e-02f, 5.14585041e-02f, -1.10696383e-01f, 2.21655169e-03f,
  6.90891035e-03f, 6.83974549e-02f, 3.63412825e-03f, 6.63394034e-02f, 7.49419332e-02f, 2.72352882e-02f, 1.53260736e-03f, 1.07521936e-02f, 3.49150077e-02f, 1.04191788e-01f,
  -5.11890687e-02f, -9.82143357e-02f, 3.66009474e-02f, -7.43239149e-02f, 2.07159910e-02f, 2.48207040e-02f, -3.08527611e-02f, -3.80785018e-02f, 5.82621656e-02f, -2.43522357e-02f,
  -1.29736459e-03f, -1.13693997e-03f, 1.09226890e-01f, 3.33541725e-03f, -2.84380335e-02f, -1.34526774e-01f, 1.15139790e-01f, -1.60900373e-02f, -1.26676895e-02f, 1.56045239e-02f,
  -2.54255980e-02f, 1.37244448e-01f, -8.04742798e-02f, -2.09634472e-02f, -1.32215545e-01f, -1.12403654e-01f, -2.13884667e-01f, 3.34650837e-02f, -1.16395481e-01f, 9.07253027e-02f,
  8.12383592e-02f, -1.18810080e-01f, 5.60759865e-02f, -5.43454215e-02f, 5.64817898e-02f, 6.56035915e-02f, 7.75471330e-02f, 5.44126071e-02f, 3.49807814e-02f, 6.35275468e-02f,
  1.28324986e-01f, 1.21653415e-01f, 1.36625886e-01f, 2.42176920e-01f, 2.95904987e-02f, 4.92388532e-02f, 2.56240845e-01f, 9.50488523e-02f, 1.52606413e-01f, 3.49950194e-02f,
  2.93194745e-02f, 5.78159206e-02f, 2.27070991e-02f, -1.33375481e-01f, 1.13192774e-01f, -7.51430318e-02f, 1.31697757e-02f, -5.11172116e-02f, -1.34468423e-02f, 6.62890598e-02f,
  -2.84850840e-02f, -2.47736853e-02f, -8.61495957e-02f, -3.20487656e-02f, -1.12109557e-01f, 3.32623683e-02f, 3.49223875e-02f, -9.60691124e-02f, 2.81747081e-03f, 4.91708666e-02f,
  -8.65108371e-02f, -4.24369276e-02f, 5.91777004e-02f, -7.29932934e-02f, -7.86519721e-02f, -7.28317797e-02f, -2.68489169e-03f, 6.66323379e-02f, -1.85356569e-02f, 3.81761603e-02f,
  5.12929074e-02f, -9.80964601e-02f, 6.29414767e-02f, -1.96368862e-02f, 4.99240458e-02f, 9.03098285e-02f, 5.48647046e-02f, -1.39234331e-03f, -3.90151963e-02f, -1.15972143e-02f,
  -8.14630166e-02f, -8.31129178e-02f, 1.67166125e-02f, 5.54797277e-02f, -3.15520912e-02f, -9.38680544e-02f, 4.11800034e-02f, 5.53219765e-02f, 1.91025995e-02f, 4.24458347e-02f,
  2.49542911e-02f, -4.76202331e-02f, -5.20439968e-02f, 1.90361275e-03f, -1.06388748e-01f, 4.23848219e-02f, -9.81602911e-03f, -4.51324768e-02f, 7.83436671e-02f, 1.66887965e-03f,
  1.25933915e-01f, 3.02145123e-01f, 1.82641365e-04f, -9.61400792e-02f, 1.01629220e-01f, 4.40430455e-02f, 6.11811178e-03f, -1.10838739e-02f, -2.26498172e-02f, 8.49924758e-02f,
  -4.53002416e-02f, -4.49926592e-02f, 4.02007140e-02f, -6.42471388e-02f, 3.90709192e-02f, 2.45551839e-02f, 5.10184467e-02f, 6.24227263e-02f, -7.07522407e-02f, 4.56394861e-03f,
  4.25790921e-02f, 5.34451716e-02f, 5.40479347e-02f, 7.42046116e-03f, 2.25070100e-02f, 4.49413396e-02f, -3.52071263e-02f, -4.30801287e-02f, 6.73963055e-02f, 2.92769521e-02f,
  -9.24247131e-02f, 2.93903887e-01f, 7.81920254e-02f, 1.17617093e-01f, -6.92432448e-02f, -3.58845085e-01f, -2.74913549e-01f, 6.21167049e-02f, 1.17530659e-01f, 1.27382025e-01f,
  -4.10184152e-02f, 1.30562216e-01f, 6.90036863e-02f, -9.98199731e-02f, -3.58805031e-01f, -1.06487833e-01f, -2.89126813e-01f, -2.22821370e-01f, 3.08728535e-02f, 2.68175695e-02f,
  4.44275502e-04f, -2.72607263e-02f, 3.03059034e-02f, 1.38868362e-01f, 1.48481965e-01f, 1.45592675e-01f, 1.40572906e-01f, 1.67512000e-01f, 7.39969313e-02f, -6.91845790e-02f,
  -1.38796687e-01f, 1.36029616e-01f, -5.70804663e-02f, 4.49597053e-02f, -4.74218186e-03f, -5.01511060e-02f, -3.27574536e-02f, -2.32883263e-02f, -2.81754918e-02f, -7.85595179e-03f,
  3.15457210e-03f, 8.23221877e-02f, 9.20813903e-02f, 1.51044764e-02f, 6.13864362e-02f, 7.54389027e-03f, 2.43888237e-02f, -5.43269254e-02f, 1.93594191e-02f, 3.56612168e-02f,
  -5.01680523e-02f, -9.43482518e-02f, 1.67697966e-02f, -2.17456333e-02f, 2.75946259e-02f, -2.94384677e-02f, -5.53487390e-02f, -7.33788908e-02f, -6.49354905e-02f, -5.38820326e-02f,
  -6.70561008e-03f, -2.45604329e-02f, 3.39296013e-02f, 5.26880100e-03f, -2.33573746e-02f, 3.73891927e-02f, -7.61566265e-03f, 3.72591354e-02f, -1.57421473e-02f, -2.85013337e-02f,
  3.90284434e-02f, 3.58608179e-02f, 4.38717902e-02f, -5.96468225e-02f, 9.97104589e-03f, 5.09447902e-02f, -7.56395832e-02f, 2.35691667e-02f, -1.17973588e-01f, 2.69323890e-03f,
  6.11172840e-02f, -1.58668663e-02f, -3.52061316e-02f, -6.73808157e-03f, -3.18749622e-02f, 8.50683525e-02f, 1.52549865e-02f, -5.62069006e-02f, -7.49908295e-03f, 2.42657326e-02f,
  -4.50279899e-02f, 9.20275450e-02f, 6.47481307e-02f, -6.89661084e-03f, -1.30286142e-02f, -5.09557724e-02f, -5.22759035e-02f, 6.54827477e-03f, -1.46197388e-02f, 5.74735142e-02f,
  -6.70763701e-02f, -9.34971422e-02f, -1.03357747e-01f, 1.61066111e-02f, -4.47446778e-02f, 2.72418521e-02f, -3.24747600e-02f, -2.30773725e-02f, -4.56136949e-02f, 1.93554554e-02f,
  1.23266853e-01f, 5.27369604e-02f, -4.89112660e-02f, -6.32631630e-02f, -1.75555851e-02f, 1.54220476e-03f, 6.72097057e-02f, 9.56912860e-02f, 4.09130640e-02f, 3.68686728e-02f,
  -7.96720505e-01f, 8.97373438e-01f, 1.87343433e-01f, -2.48774916e-01f, 5.00849038e-02f, 2.27793813e-01f, -1.36091504e-02f, 2.70097226e-01f, -1.89489424e-02f, 2.59625673e-01f,
  -4.72118221e-02f, 3.66172194e-02f, 2.10242257e-01f, 1.72247306e-01f, -4.06952024e-01f, 2.55781382e-01f, 2.43374798e-02f, -1.04937613e-01f, 1.10446073e-01f, -1.13335870e-01f,
  -1.39654875e-01f, -1.63757876e-01f, 2.32313052e-01f, 2.00764164e-01f, -4.60246019e-02f, -7.12347254e-02f, -3.01469982e-01f, 9.48023349e-02f, -6.86287507e-02f, 6.39429614e-02f,
  -3.02691251e-01f, -3.63981217e-01f, -1.86462924e-01f, -1.35508683e-02f, -1.71546325e-01f, -1.53729171e-01f, -9.61613581e-02f, -5.08246645e-02f, -1.22355647e-01f, 3.97291631e-02f,
  -4.55344990e-02f, 5.06082028e-02f, -1.18734343e-02f, 9.17582400e-03f, 7.86146801e-03f, 8.52299556e-02f, 1.37071535e-01f, 2.76773926e-02f, 3.55404615e-02f, 1.56718671e-01f,
  1.41423792e-01f, 1.18867442e-01f, -1.05405655e-02f, 3.63015733e-03f, -1.34974271e-02f, 1.44042661e-02f, -1.51436506e-02f, -4.99358494e-03f, 1.39431618e-02f, 1.99679546e-02f,
  -5.39435167e-03f, -8.79355520e-02f, 1.83061846e-02f, -4.86661941e-02f, -4.47914936e-03f, 5.66735305e-03f, -4.24241722e-02f, -1.65830757e-02f, -1.18917078e-02f, -1.68638155e-02f,
  -6.43420294e-02f, -2.49749552e-02f, -9.39466879e-02f, -5.69712631e-02f, -3.26985605e-02f, -4.68940474e-02f, -8.09437037e-02f, -2.08849143e-02f, 1.45640252e-02f, 5.55051416e-02f,
  -4.29010130e-02f, 1.02991601e-02f, 5.71119152e-02f, -1.79727208e-02f, 5.23290969e-02f, 8.15822801e-04f, 8.82006658e-04f, 1.23917386e-01f, 2.81217862e-02f, -8.12149793e-02f,
  -3.70625049e-01f, -4.07891601e-01f, -4.60705310e-02f, -1.15908019e-01f, -6.52433978e-03f, -6.53121695e-02f, -3.47652584e-02f, -4.33863699e-02f, -1.93051733e-02f, -3.34378369e-02f,
  -8.17164332e-02f, -2.70414315e-02f, -1.00963920e-01f, 9.94766131e-03f, -5.30685019e-03f, -6.34298325e-02f, -1.40934944e-01f, -1.46393627e-01f, -9.34532508e-02f, -9.70884599e-03f,
  -6.95795864e-02f, -1.02787994e-01f, -3.86928804e-02f, -4.78081852e-02f, -7.76473284e-02f, -7.65268803e-02f, -8.45067948e-02f, 4.27019261e-02f, -6.98238462e-02f, 6.47237599e-02f,
  2.37230495e-01f, -3.85859638e-01f, 2.19093516e-01f, 2.94540495e-01f, 2.42955878e-01f, 1.19788565e-01f, 2.58503467e-01f, -2.26647891e-02f, 6.99612200e-02f, -4.35465902e-01f,
  -8.88723284e-02f, -9.05040801e-02f, -1.27640724e-01f, -4.72025573e-03f, 2.29958907e-01f, -4.49953750e-02f, -2.40978971e-02f, -9.13420767e-02f, 3.31505761e-02f, 7.19417213e-03f,
  6.73915148e-02f, -9.49546173e-02f, 1.78894535e-01f, -1.91931069e-01f, 1.28333166e-01f, -2.80477032e-02f, -1.32870659e-01f, -2.18996289e-03f, -1.58215836e-01f, 6.33781552e-02f,
  -3.11466716e-02f, 2.65106447e-02f, 9.75887030e-02f, -9.29701254e-02f, 1.19173909e-02f, -2.20073257e-02f, -3.51811200e-02f, 5.02852211e-03f, 1.25910401e-01f, -5.09262159e-02f,
  -1.80480815e-02f, -2.73198877e-02f, -2.13010255e-02f, 2.75801159e-02f, 9.89788249e-02f, 3.47583517e-02f, 3.91670614e-02f, 1.07559413e-01f, 1.79450903e-02f, 2.95985490e-02f,
  1.33177742e-01f, -7.30861723e-02f, 2.50699129e-02f, -7.19626918e-02f, -1.42209996e-02f, 7.32332766e-02f, 1.16478745e-02f, 4.90204012e-03f, 9.04543046e-03f, -3.97662679e-03f,
  1.51042244e-03f, 3.18496004e-02f, 4.61340249e-02f, 7.41816312e-02f, 9.82255954e-03f, 7.28559420e-02f, 5.06232865e-02f, -1.80225112e-02f, -4.69033532e-02f, -4.63986620e-02f,
  2.12495122e-03f, 7.60755967e-03f, -1.07594300e-02f, 4.03860137e-02f, 6.69326708e-02f, 6.33819848e-02f, 1.34477895e-02f, -4.79530282e-02f, 4.34413403e-02f, 5.70413992e-02f,
  8.66258293e-02f, 4.69453121e-03f, -3.95404212e-02f, 4.59175408e-02f, -8.59598815e-02f, 3.36552933e-02f, 1.05051529e-02f, -4.47791927e-02f, 2.31056055e-03f, 3.72852422e-02f,
  -2.72371292e-01f, -4.80180502e-01f, -1.14038408e-01f, -2.60476861e-02f, -1.31872594e-01f, -3.90146673e-02f, -9.25354511e-02f, -7.87841454e-02f, -6.84364140e-02f, 8.53035040e-03f,
  -8.24441612e-02f, 1.62565485e-02f, -1.04359478e-01f, -1.65585820e-02f, -9.48763192e-02f, -1.93876885e-02f, -4.21674438e-02f, -1.38434172e-01f, 1.82040618e-03f, 1.01516070e-02f,
  8.21294903e-04f, 1.65084898e-02f, 1.76828238e-03f, -6.48705214e-02f, 5.00297779e-03f, -5.07602096e-02f, -5.60214072e-02f, -3.06440461e-02f, -3.96894328e-02f, -7.67904371e-02f,
  6.26736358e-02f, 3.56321484e-01f, 4.48559284e-01f, 3.37598592e-01f, -2.41109222e-01f, -3.40408355e-01f, -1.57129943e-01f, 7.19655529e-02f, 4.18861508e-02f, 7.77674019e-02f,
  -5.27003445e-02f, 3.42991710e-01f, 4.33862442e-03f, 1.92206860e-01f, -1.40480995e-01f, -4.53806370e-02f, 1.12954356e-01f, 3.50407101e-02f, 4.46666107e-02f, 3.05694669e-01f,
  1.28412396e-01f, -3.22462358e-02f, 2.61541396e-01f, -7.71199074e-03f, 8.31232741e-02f, 3.01661998e-01f, 7.91717395e-02f, -5.00202961e-02f, 1.35525852e-01f, -1.31814152e-01f,
  1.54390968e-02f, 6.16590716e-02f, 1.03960805e-01f, -2.28631287e-03f, -1.03897438e-03f, 1.50423218e-02f, 6.70310203e-03f, -4.67902310e-02f, -3.09301503e-02f, 2.67283991e-02f,
  1.16740935e-01f, -4.54567783e-02f, -1.38703706e-02f, -3.75238596e-03f, 3.20122577e-02f, 2.33158804e-02f, 2.58713178e-02f, 1.03275619e-01f, 1.33906171e-01f, 9.80674326e-02f,
  1.34728983e-01f, 3.06521244e-02f, 3.19102556e-02f, 3.59241404e-02f, 8.74147341e-02f, 5.61938770e-02f, 1.86909586e-02f, 5.64260818e-02f, 8.00153017e-02f, 9.35628042e-02f,
  -1.72236040e-02f, -1.23691382e-02f, -3.70050594e-02f, -4.81809229e-02f, -3.42081711e-02f, -4.78387475e-02f, -6.02133013e-02f, 2.91240197e-02f, 1.00195408e-02f, 8.32241327e-02f,
  -4.53855097e-02f, 2.98847239e-02f, -4.34878729e-02f, 1.22770818e-03f, 2.51612831e-02f, -4.90002483e-02f, -1.65911985e-03f, -1.21885082e-02f, -1.38397301e-02f, -1.50985667e-03f,
  -6.87482283e-02f, -1.23319998e-02f, 3.19684446e-02f, 1.64071787e-02f, -8.09278488e-02f, -3.17098983e-02f, 5.45270666e-02f, -1.63129289e-02f, 5.21811433e-02f, 3.03378813e-02f,
  1.49009213e-01f, 3.52341592e-01f, 1.06389066e-02f, -1.21000089e-01f, 5.82724251e-03f, -4.34144475e-02f, -1.59813538e-02f, 1.01373838e-02f, 8.63713920e-02f, -5.53181916e-02f,
  -6.13449477e-02f, -9.41944076e-04f, 5.66080632e-03f, -1.21894209e-02f, -2.77371779e-02f, 9.63130668e-02f, 9.30916145e-02f, -1.29423402e-02f, 8.59617442e-03f, 1.14679322e-01f,
  1.39156627e-02f, 1.99618693e-02f, 4.16711718e-02f, -1.54116927e-02f, 4.06638049e-02f, 5.07537872e-02f, -5.73548935e-02f, 3.33248489e-02f, 1.55740594e-02f, 2.05525639e-03f,
  2.74613768e-01f, -3.86382639e-02f, -3.72164771e-02f, 4.07811761e-01f, 3.40944350e-01f, 8.35534856e-02f, 2.61606723e-01f, 2.69900054e-01f, 7.58411229e-01f, -1.30687788e-01f,
  -9.40048546e-02f, -9.85368267e-02f, -1.28857106e-01f, -4.93000541e-03f, -6.73574507e-02f, -3.11725028e-02f, 1.31495312e-01f, 8.89109150e-02f, 1.56438395e-01f, 9.56240222e-02f,
  1.89163700e-01f, 9.49254818e-03f, -2.83691764e-01f, -1.30308896e-01f, 1.73338726e-02f, -2.72275396e-02f, -2.90433228e-01f, -9.09630433e-02f, -2.40382418e-01f, -8.01034048e-02f,
  -6.13656119e-02f, 9.65441987e-02f, -1.46474764e-01f, -4.42769900e-02f, 3.55905332e-02f, 3.10060028e-02f, -1.19715050e-01f, -7.67325908e-02f, 5.55378534e-02f, 9.42189544e-02f,
  -7.92308748e-02f, -5.02352789e-03f, 4.18307409e-02f, -4.85254638e-02f, 1.45288616e-01f, -7.21071437e-02f, 2.26470008e-02f, 1.70229133e-02f, -1.43791530e-02f, -5.42085357e-02f,
  -3.11279632e-02f, -4.22735885e-03f, 7.03145750e-03f, 4.04801453e-03f, 2.29501165e-02f, 8.59997869e-02f, -4.53461073e-02f, -5.51115312e-02f, 1.38518587e-02f, 3.33292410e-02f,
  5.42941839e-02f, 1.01255924e-02f, -1.11942291e-02f, 5.74102029e-02f, -6.01840066e-03f, -3.02828047e-02f, -1.23190340e-02f, -9.98379216e-02f, 5.52227125e-02f, -7.13780746e-02f,
  6.52774721e-02f, 9.44669265e-03f, 8.67009349e-03f, -6.58339122e-03f, 9.78825465e-02f, 2.98351720e-02f, -1.40718156e-02f, 3.50622945e-02f, 4.01272364e-02f, 2.05711685e-02f,
  -5.09139076e-02f, 2.92354301e-02f, -9.86933801e-03f, 2.78168824e-02f, 1.30512146e-02f, -3.66709754e-02f, -3.21224406e-02f, 6.83732657e-03f, 6.10077940e-02f, -7.17756599e-02f,
  1.46900013e-01f, 2.46930301e-01f, -4.49102484e-02f, 1.45875392e-02f, -1.26436586e-02f, -4.45399098e-02f, 1.14547682e-03f, 2.09136587e-02f, 5.82544021e-02f, 2.01250147e-02f,
  -4.81962301e-02f, 8.56239051e-02f, 4.23403122e-02f, -2.78399400e-02f, -6.33741841e-02f, 5.95148318e-02f, -5.51556144e-03f, 6.85091764e-02f, 4.31373976e-02f, -6.81354478e-02f,
  -9.57384985e-03f, 4.30105701e-02f, 8.57894272e-02f, 6.19304590e-02f, -1.55032771e-02f, -4.44573462e-02f, 1.30410641e-01f, -3.42763960e-02f, -9.49382707e-02f, 2.08657049e-02f,
  2.00764626e-01f, -1.36278600e-01f, 1.32249609e-01f, 3.86436641e-01f, 1.46488681e-01f, 5.55205420e-02f, 2.18884841e-01f, -4.09588367e-02f, 3.32304060e-01f, -9.28247869e-02f,
  -9.13624838e-02f, 1.37627080e-01f, -5.82410060e-02f, -5.62621355e-02f, -6.37070686e-02f, -1.22015327e-01f, 5.36019802e-02f, 1.01362027e-01f, 2.00854376e-01f, 1.17805079e-01f,
  5.64062335e-02f, -9.62951928e-02f, -2.64621556e-01f, -2.36086696e-01f, 2.09026616e-02f, 1.64921671e-01f, -2.61123389e-01f, -6.18152954e-02f, -2.34934762e-02f, -4.73370031e-02f,
  7.76161030e-02f, 1.11184709e-01f, -8.69428664e-02f, -2.80207954e-02f, -8.65022689e-02f, 2.51181796e-03f, 7.77909905e-02f, 4.62976024e-02f, 7.68572688e-02f, 1.31127194e-01f,
  1.33412614e-01f, -2.96642873e-02f, -2.93763243e-02f, 7.52399191e-02f, 1.28996164e-01f, 2.53845323e-02f, -2.94380840e-02f, -1.96540635e-02f, 4.99121798e-03f, 3.84444520e-02f,
  -4.53291722e-02f, 3.33366804e-02f, -3.72167979e-03f, -2.46256255e-02f, -6.91733733e-02f, -1.15065407e-02f, 1.81115065e-02f, 1.62761826e-02f, 3.20646726e-02f, 2.17864886e-02f,
  -9.34063047e-02f, -1.15292314e-02f, -3.66188474e-02f, -8.77698436e-02f, -8.68263543e-02f, 4.33216728e-02f, 3.92136611e-02f, 2.24015210e-03f, 3.20124477e-02f, 2.59298855e-03f,
  -5.72806597e-02f, -2.77430005e-02f, -8.76646116e-03f, 4.32827957e-02f, 3.23348977e-02f, -2.24590860e-02f, -2.21591797e-02f, 6.84643537e-02f, 6.93410113e-02f, -5.83454669e-02f,
  5.32558896e-02f, 3.14961262e-02f, -5.78711219e-02f, -3.75747010e-02f, -5.15461676e-02f, -2.78035626e-02f, 2.77193226e-02f, 2.08527744e-02f, 6.38673753e-02f, 2.36186832e-02f,
  1.10083647e-01f, -7.76025355e-02f, -7.62329698e-02f, 6.17197640e-02f, 5.24959378e-02f, -5.70654981e-02f, 7.27630854e-02f, -3.12929861e-02f, 2.36428771e-02f, 3.03946137e-02f,
  1.31933307e-02f, 1.89907234e-02f, -4.88933697e-02f, -5.31405918e-02f, 4.36616689e-02f, -8.52911174e-02f, 9.48995501e-02f, -7.51237124e-02f, -4.50555682e-02f, -2.28765309e-02f,
  -7.53786266e-02f, 1.21534109e-01f, 4.95953858e-02f, 5.63678481e-02f, 2.98276544e-02f, 1.45874331e-02f, -6.22335263e-02f, -8.30625966e-02f, -3.99841815e-02f, -3.23505737e-02f,
  3.33044410e-01f, -1.42986938e-01f, -7.39573389e-02f, -5.44933509e-03f, -3.79645489e-02f, -1.22483820e-01f, -1.41443700e-01f, 4.01234254e-02f, 2.52875417e-01f, -1.24359265e-01f,
  6.33075535e-02f, -2.01769590e-01f, -6.93507269e-02f, -6.61134720e-02f, 7.18945637e-02f, 9.97789651e-02f, -1.45963728e-01f, -2.23980621e-01f, 1.08417191e-01f, -3.68245505e-02f,
  1.60319328e-01f, 2.76368335e-02f, 4.55206968e-02f, -1.09235398e-01f, -4.85830419e-02f, 1.35247678e-01f, 2.70294547e-02f, -1.63592491e-02f, -2.37053677e-01f, -9.94855836e-02f,
  7.07938597e-02f, 2.73372710e-01f, 1.13301381e-01f, -4.68088910e-02f, 3.35964225e-02f, -2.61311345e-02f, -9.49104056e-02f, 2.46141426e-05f, -1.64259858e-02f, 3.59627069e-03f,
  -8.94295145e-03f, -8.62495080e-02f, -4.14683111e-02f, 6.32950962e-02f, 9.20723379e-02f, 1.77247673e-02f, 8.71568397e-02f, -5.29672652e-02f, -8.42124149e-02f, 1.11704901e-01f,
  -4.07645740e-02f, -6.32122234e-02f, -3.33831795e-02f, -3.11229099e-02f, -4.74348385e-03f, 1.25799663e-02f, -6.53251633e-02f, -7.22985268e-02f, -1.98691841e-02f, 4.85843346e-02f,
  5.67618161e-02f, -1.27477631e-01f, 7.29402825e-02f, 1.36048421e-02f, 4.15039808e-02f, 8.42016935e-02f, -1.02248274e-01f, -4.17185649e-02f, -1.51440119e-02f, 2.22528782e-02f,
  -1.64232980e-02f, 1.33374296e-02f, -2.10417099e-02f, 3.58418263e-02f, 4.74174917e-02f, -5.43792434e-02f, -3.25152762e-02f, -7.37240445e-03f, 1.27751371e-02f, -1.99091434e-02f,
  -8.67676809e-02f, -8.40671808e-02f, 5.68199009e-02f, -9.80160460e-02f, 1.31669985e-02f, 6.54948922e-03f, -6.30450100e-02f, 1.46044083e-02f, 1.00776404e-01f, -6.42112419e-02f,
  -1.13912746e-01f, -2.37268656e-02f, 1.28023267e-01f, 1.64539460e-02f, -5.35882004e-02f, 1.63782656e-01f, -8.08132812e-03f, 3.95426489e-02f, 2.09876653e-02f, 6.60369769e-02f,
  1.16711727e-03f, -6.75983429e-02f, -3.84120047e-02f, -6.04467653e-02f, -9.74791348e-02f, 9.92197990e-02f, -9.81088653e-02f, -1.41246598e-02f, 3.57742310e-02f, -6.52528256e-02f,
  -4.75337654e-02f, -1.02824284e-04f, -4.86073084e-02f, -2.36402024e-02f, -9.91542190e-02f, -6.17723465e-02f, -5.88966645e-02f, -9.02524516e-02f, 5.06493896e-02f, 7.37386104e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  1.81587785e-01f, 3.03668529e-01f, 2.59790868e-01f, 4.29528281e-02f, 3.28711718e-01f, 3.39313120e-01f, 4.58945222e-02f, 1.54576480e-01f, 4.41886246e-01f, 4.08170074e-01f,
  2.88651913e-01f, 3.01383317e-01f, 9.49375927e-02f, 1.77875742e-01f, 4.27994013e-01f, 3.27425748e-01f, 1.67032778e-01f, 3.53669643e-01f, 2.14502499e-01f, 6.58699125e-02f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -9.62160453e-02f, -5.82953990e-01f, 3.06739569e-01f, -1.30796745e-01f, -1.47904366e-01f, -7.36062154e-02f, -5.19167721e-01f, 5.94651103e-01f, 2.10622270e-02f, 4.02148105e-02f,
  -5.44658661e-01f, 3.77745599e-01f, -9.26053971e-02f, -5.18807650e-01f, -1.55592084e-01f, -1.97472900e-01f, 1.12370741e+00f, -2.96526521e-01f, -2.40780726e-01f, -2.00873077e-01f,
  -2.99243569e-01f, -1.73421785e-01f, -2.46832356e-01f, -7.75993019e-02f, 1.73836753e-01f, -2.64914453e-01f, 5.99885941e-01f, -2.96311714e-02f, 3.51432487e-02f, -5.01866639e-01f,
  -1.82602108e-01f, -2.04307318e-01f, -6.53707087e-02f, -1.49194241e-01f, 5.29236197e-02f, -1.32544041e-01f, 2.76889443e-01f, 5.18204868e-01f, -3.10701311e-01f, 6.18462861e-01f,
  4.34621185e-01f, 3.37741911e-01f, 5.35684705e-01f, -1.80599615e-02f, -1.55263096e-01f, 9.76205349e-01f, -2.86879033e-01f, -9.90027860e-02f, 7.79507458e-01f, -4.35759515e-01f,
  7.87482634e-02f, -1.17854103e-01f, -1.74862459e-01f, -4.76938009e-01f, 1.67283833e-01f, 1.81201309e-01f, 1.38012841e-01f, -1.98442295e-01f, -3.82903785e-01f, -3.49803001e-01f,
  -2.19362989e-01f, 2.19850931e-02f, -1.82706520e-01f, 2.74027735e-01f, -2.87609339e-01f, 3.91666517e-02f, -9.91382077e-02f, -1.37172580e-01f, -2.68452972e-01f, -6.07841313e-01f,
  -3.72970045e-01f, 1.21047221e-01f, -1.79884173e-02f, -1.21378630e-01f, 2.91181624e-01f, -4.04546738e-01f, -1.15870506e-01f, 1.16950297e+00f, -1.55295491e-01f, -8.30776840e-02f,
  -3.60793918e-01f, 4.24039513e-01f, 4.42474186e-02f, -2.11921290e-01f, -2.42734388e-01f, 2.61337519e-01f, 8.80607516e-02f, -1.50949284e-01f, -1.31184071e-01f, -3.64423357e-02f,
  -3.23345482e-01f, 1.49359673e-01f, -3.90121460e-01f, -2.93290198e-01f, 7.43465964e-03f, -3.18528205e-01f, 1.15986936e-01f, -2.45019840e-03f, -4.19188589e-02f, -3.39821905e-01f,
  -4.01162803e-01f, -4.20430571e-01f, 1.40162274e-01f, -4.73012865e-01f, 4.80224490e-01f, 4.93880033e-01f, -4.90985215e-01f, 2.75161684e-01f, 1.33151919e-01f, -3.72633815e-01f,
  8.06930423e-01f, -1.62027135e-01f, -3.34516674e-01f, -3.61090690e-01f, 1.43280253e-01f, 4.94753480e-01f, -3.14154313e-03f, -1.24500506e-01f, 2.29497179e-01f, -3.51579845e-01f,
  6.95880279e-02f, 5.79364955e-01f, 5.48157990e-01f, -3.12448621e-01f, -2.55123079e-01f, -1.36124520e-02f, 8.60224385e-03f, 3.38718556e-02f, -3.24445069e-01f, 5.23761213e-01f,
  4.78045762e-01f, 2.12975685e-02f, 4.64809954e-01f, 1.14180610e-01f, -1.78781766e-02f, -4.29279000e-01f, -3.68135631e-01f, -1.71726748e-01f, -6.34658515e-01f, 7.61040866e-01f,
  2.67926633e-01f, -1.61643118e-01f, -3.81136596e-01f, 1.24012753e-02f, -4.54698116e-01f, -3.71214777e-01f, -2.94904038e-02f, -2.39556074e-01f, 1.90897733e-01f, 5.14700890e-01f,
  1.78803384e-01f, 2.11843222e-01f, 2.29699105e-01f, -2.65620857e-01f, 1.20967710e+00f, 2.08753332e-01f, -1.41969785e-01f, -2.93983698e-01f, -2.69401520e-01f, 1.50878251e-01f,
  4.20368075e-01f, 4.41201925e-01f, -1.07978575e-01f, 5.21235205e-02f, 2.13373452e-01f, -2.87218541e-01f, 2.58014441e-01f, 6.50098145e-01f, -8.22565973e-01f, -8.64240080e-02f,
  1.64104983e-01f, 3.92925233e-01f, -3.28417361e-01f, -4.25507396e-01f, -4.17873323e-01f, -9.16908160e-02f, 5.51252544e-01f, 1.13319844e-01f, 1.64322793e-01f, -2.23333493e-01f,
  6.27322197e-01f, -5.34576952e-01f, 4.73083138e-01f, 6.17747962e-01f, -8.64158720e-02f, -2.17508182e-01f, -7.34467730e-02f, -2.61737585e-01f, 1.18869923e-01f, 6.55027270e-01f,
  4.43028927e-01f, -1.97656766e-01f, 1.77927420e-01f, -3.68856378e-02f, -5.66244945e-02f, -3.70516419e-01f, -4.90169585e-01f, 1.80684760e-01f, -5.15807807e-01f, -5.03229022e-01f,
  -1.24282375e-01f, -3.17487389e-01f, 5.35657585e-01f, 1.14943884e-01f, 4.56430241e-02f, -2.26290107e-01f, -2.47198954e-01f, 1.77915711e-02f, -1.47408605e-01f, 9.83415097e-02f,
  4.50809747e-02f, -2.24449486e-01f, -7.87308291e-02f, 4.00596917e-01f, 3.86382371e-01f, -8.68020579e-02f, -2.48856694e-01f, -7.78817460e-02f, -3.21033627e-01f, 7.08718598e-01f,
  -2.17270240e-01f, 8.25332224e-01f, 5.75692713e-01f, 4.64827806e-01f, -2.83883899e-01f, -2.31183037e-01f, -1.40260577e-01f, -1.39621541e-01f, -3.52454394e-01f, -2.26832137e-01f,
  2.40217932e-02f, -1.82239503e-01f, -2.32064188e-01f, 1.75387025e-01f, -4.13995177e-01f, -3.20787758e-01f, -4.99483608e-02f, -1.83658123e-01f, 3.49257052e-01f, 9.07795727e-01f,
  -2.87328780e-01f, 2.23930463e-01f, 8.76584835e-03f, 2.97090858e-01f, -5.47236688e-02f, -2.59901583e-01f, -1.86695114e-01f, 7.01169312e-01f, 1.04134567e-01f, 4.83239405e-02f,
  -2.28175715e-01f, -7.28290156e-02f, -1.39418989e-01f, -2.24136963e-01f, -7.60917664e-02f, 1.57382682e-01f, -3.53614800e-02f, -1.60702556e-01f, -1.56354070e-01f, -1.16006695e-01f,
  2.59267725e-03f, -2.84813404e-01f, -6.35439679e-02f, -3.43108535e-01f, 1.76783934e-01f, -4.18952674e-01f, 2.60917068e-01f, -3.67065996e-01f, 3.67162167e-03f, 2.58303374e-01f,
  -4.03253406e-01f, -2.85147578e-01f, 1.51806148e-02f, 2.29545116e-01f, 5.88984787e-01f, -2.75834233e-01f, 7.09110856e-01f, -2.77955532e-01f, -3.24313015e-01f, -3.12224358e-01f,
  4.44096714e-01f, 3.58942419e-01f, -2.15270579e-01f, -1.52120963e-01f, 8.09838414e-01f, -1.56425655e-01f, -3.13034773e-01f, 1.03984974e-01f, 1.99253753e-01f, 2.87611842e-01f,
  -5.40636539e-01f, 4.34515923e-01f, 6.43592060e-01f, 3.21649201e-02f, 6.25449359e-01f, 2.80886382e-01f, -7.12832868e-01f, -3.77797522e-03f, -1.61796331e-01f, -4.13289487e-01f,
  -2.44165361e-01f, -3.33337367e-01f, -1.95401669e-01f, -1.90665387e-02f, -3.13934028e-01f, -1.76286429e-01f, -2.38983542e-01f, -2.91622967e-01f, -4.35526609e-01f, 9.84639287e-01f,
  -1.40146419e-01f, 2.13645220e-01f, -2.37703860e-01f, -2.47749239e-01f, -4.48424041e-01f, 6.11365855e-01f, -2.20167711e-01f, -3.70622486e-01f, 1.41577497e-01f, -2.14103952e-01f,
  2.29802743e-01f, 3.38490695e-01f, -2.68100470e-01f, 8.28507468e-02f, 1.45560995e-01f, 2.98107475e-01f, 3.82988513e-01f, 1.83029130e-01f, 6.28419220e-01f, -2.07236111e-01f,
  -3.91622096e-01f, 8.30888376e-02f, 1.09981084e+00f, 2.06342302e-02f, 5.48049286e-02f, -2.06553608e-01f, -1.60816491e-01f, 2.76748657e-01f, 8.05401802e-02f, 6.51066184e-01f,
  -3.67053837e-01f, -1.98168546e-01f, 9.23755951e-03f, -3.49188119e-01f, 2.48106703e-01f, 8.81544128e-02f, -6.17012262e-01f, -3.53214800e-01f, -1.34713799e-01f, 7.96399936e-02f,
  8.50856900e-02f, -3.35635513e-01f, -2.37152562e-01f, -1.40051648e-01f, 3.49910885e-01f, 1.92721084e-01f, -7.41088837e-02f, 1.83561333e-02f, 6.36387706e-01f, -3.61594170e-01f,
  -1.10546082e-01f, -1.89521618e-03f, 5.33540726e-01f, 3.03576365e-02f, -2.89215356e-01f, -3.69507819e-01f, 8.10946524e-01f, -2.17026502e-01f, -2.77437806e-01f, 5.52099884e-01f,
  -2.52278447e-01f, -2.90495068e-01f, 5.68466604e-01f, -2.50421733e-01f, -3.63390744e-01f, -2.92941719e-01f, -2.40300536e-01f, 3.02362740e-01f, 2.28655711e-01f, 1.64067581e-01f,
  5.27273178e-01f, -9.67731401e-02f, 3.24358374e-01f, -2.05691501e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  9.75024551e-02f, -9.26469713e-02f, -4.58205715e-02f, -2.19371587e-01f, 1.99739531e-01f, 1.86513886e-01f, -1.08263060e-01f, -2.17932612e-01f, -2.66466379e-01f, 2.97386497e-01f,
  1.89690977e-01f, 5.20665422e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    