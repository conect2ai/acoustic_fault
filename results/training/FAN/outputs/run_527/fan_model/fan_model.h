/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -7.31495544e-02f, 1.34887278e-01f, -7.01257437e-02f, -9.35278907e-02f, -2.28566229e-01f, 6.28656447e-02f, -2.79011372e-02f, -1.49497882e-01f, 1.61490869e-02f, 1.77301049e-01f,
  3.03367674e-02f, 9.00813267e-02f, 1.76424816e-01f, -2.14113761e-02f, 3.54577303e-02f, 1.71854779e-01f, -5.19619584e-02f, 3.32536618e-03f, -5.40224463e-02f, -1.09292850e-01f,
  -1.40056923e-01f, -2.42234319e-02f, -7.25521818e-02f, -1.33434221e-01f, -9.92425457e-02f, -4.08572629e-02f, 6.83484301e-02f, -1.50501654e-02f, -1.28084287e-01f, 6.81968257e-02f,
  5.61293289e-02f, 8.66203681e-02f, -4.87424284e-02f, 3.72406095e-02f, 4.18049544e-02f, -6.26950711e-02f, 2.24069897e-02f, -2.17579082e-02f, -2.15764102e-02f, 4.62789647e-02f,
  3.24118286e-02f, 4.57110535e-03f, 2.23712064e-03f, 5.55761382e-02f, 2.38178130e-02f, -7.36465454e-02f, -7.84130916e-02f, 2.19634757e-03f, -1.76789928e-02f, 1.84892174e-02f,
  -4.65002097e-02f, 8.12449865e-03f, -8.92284587e-02f, 5.51116131e-02f, -3.78319025e-02f, -2.83707101e-02f, 3.53033245e-02f, 2.12317258e-02f, -4.64894883e-02f, 4.78069149e-02f,
  1.20144302e-03f, -3.52419913e-02f, 1.95819396e-03f, -7.41270557e-02f, 2.24859752e-02f, -1.03895999e-01f, 2.85454057e-02f, 3.47793358e-03f, -1.50945662e-02f, -7.18809105e-03f,
  -5.04698865e-02f, -2.63438243e-02f, 1.00169569e-01f, -6.74602240e-02f, -7.59834424e-02f, 7.36280018e-03f, 6.09047078e-02f, 1.67730451e-02f, 2.28542034e-02f, -1.85844749e-02f,
  -1.07290484e-01f, -8.67708996e-02f, -4.74690571e-02f, -5.16930744e-02f, 6.30709082e-02f, 1.55714499e-02f, 4.24830467e-02f, -3.33550647e-02f, -3.87668377e-03f, 5.52564003e-02f,
  2.27168133e-03f, 6.10970296e-02f, 8.44363496e-03f, 4.82427031e-02f, 6.90677315e-02f, 8.62971991e-02f, 1.11076152e-02f, 2.19013374e-02f, 7.65141919e-02f, -1.23991992e-03f,
  -1.22620016e-02f, -6.38262718e-04f, 3.79395783e-02f, -7.21588656e-02f, -5.00920042e-02f, 2.26425496e-03f, 6.99870586e-02f, 1.09934136e-02f, 9.01293103e-03f, -6.42742030e-03f,
  4.65989821e-02f, 6.02708571e-02f, -3.65181789e-02f, 5.92008159e-02f, -7.17230365e-02f, 1.82054359e-02f, 3.98182087e-02f, 5.84034137e-02f, -2.88238702e-03f, -1.52220223e-02f,
  -5.51231354e-02f, 1.06711157e-01f, 4.90792505e-02f, 7.11710379e-02f, -1.19388536e-01f, 7.38337114e-02f, 4.41448390e-02f, 1.07331447e-01f, 7.12245405e-02f, 2.11721152e-01f,
  9.49305966e-02f, -7.37662092e-02f, 1.48695707e-02f, 1.39875188e-01f, -2.05355063e-01f, 4.79174033e-02f, 2.12676093e-01f, 1.70541719e-01f, 2.87732519e-02f, 1.09783672e-01f,
  2.17876921e-04f, 3.89672108e-02f, 2.30882689e-02f, 6.35244921e-02f, 5.20095639e-02f, 5.34045920e-02f, 1.05967987e-02f, -1.76604912e-01f, 2.50569899e-02f, -7.02411160e-02f,
  -4.51206639e-02f, 6.94135353e-02f, -9.77774398e-05f, -4.19826694e-02f, 7.76440725e-02f, 3.32951313e-03f, 3.49349752e-02f, -1.20237991e-01f, -7.05107078e-02f, -7.25923926e-02f,
  7.17537478e-02f, 1.15551539e-02f, 1.45857148e-02f, -1.31616173e-02f, 6.69907480e-02f, -1.48817280e-03f, -9.04043838e-02f, 3.20256501e-02f, 2.55886279e-02f, -2.27181464e-02f,
  -2.20463313e-02f, 3.58814150e-02f, 5.58335446e-02f, -2.12079473e-02f, -7.16203749e-02f, 3.29389684e-02f, 7.12063909e-02f, -9.65183135e-03f, 5.29633313e-02f, 5.28492453e-03f,
  3.72120179e-02f, 3.30551974e-02f, -3.79479565e-02f, -1.74080208e-02f, 5.88190109e-02f, -1.77899897e-02f, 8.59998763e-02f, -9.03659780e-03f, -5.31745069e-02f, 4.58562933e-03f,
  2.18748748e-02f, 1.79481022e-02f, -1.98654179e-02f, 8.70002583e-02f, -1.90297030e-02f, 4.21770401e-02f, -2.37887390e-02f, 5.98339317e-03f, 1.50749069e-02f, 8.81524384e-03f,
  2.18548346e-02f, 7.82768428e-03f, 6.96542040e-02f, 1.53073976e-02f, -6.10407616e-04f, -3.60592529e-02f, -4.22908664e-02f, 2.40228567e-02f, 3.68557200e-02f, -9.03580040e-02f,
  8.10693651e-02f, 1.41885877e-01f, 8.66110399e-02f, 3.48414667e-02f, 1.74458660e-02f, 2.66712755e-02f, -3.52602042e-02f, -8.71039461e-03f, -4.23297882e-02f, 1.37227429e-02f,
  2.08388525e-03f, 1.45660359e-02f, -2.26098746e-02f, -2.68486515e-02f, -1.20103378e-02f, 1.82705894e-02f, 5.10549024e-02f, -5.43021411e-02f, -4.95533831e-02f, 5.26572764e-03f,
  -8.56916979e-03f, 9.70407575e-03f, -4.70927693e-02f, 4.25087176e-02f, -2.43986640e-02f, -5.12791313e-02f, 2.79878639e-02f, -4.06517051e-02f, -2.64830478e-02f, 3.19815874e-02f,
  -1.74143732e-01f, 2.06564963e-02f, -7.85547271e-02f, -1.62082404e-01f, -1.25377044e-01f, -3.13403308e-01f, -3.14051747e-01f, -8.53631571e-02f, 7.69198164e-02f, 1.39926910e-01f,
  -9.49864462e-02f, -2.98184082e-02f, 1.16968587e-01f, -9.63269845e-02f, -2.24954084e-01f, 8.57641399e-02f, -1.28124535e-01f, -6.72661811e-02f, 7.70478770e-02f, -8.23019594e-02f,
  -3.75615954e-02f, -1.62754357e-01f, -7.01255426e-02f, 1.19641479e-02f, -8.37372988e-02f, 5.57352714e-02f, 5.87102138e-02f, -8.22059065e-02f, -1.04581550e-01f, -1.82724383e-03f,
  5.65735996e-02f, 4.70851623e-02f, -7.19879642e-02f, -2.99214106e-03f, -6.33283257e-02f, -7.58035630e-02f, -1.95794161e-02f, -4.73802239e-02f, 1.10437684e-02f, 5.57588749e-02f,
  -9.26752985e-02f, 3.71000320e-02f, 5.02540879e-02f, -4.14578207e-02f, 3.04511786e-02f, -8.02362785e-02f, -4.30411473e-02f, -4.66828309e-02f, 7.72516505e-05f, 7.01337159e-02f,
  3.19685116e-02f, 9.60534662e-02f, 4.33005439e-03f, 6.39377162e-02f, -4.13318223e-04f, -3.11879870e-02f, 4.30160761e-02f, 5.14065586e-02f, -7.19408318e-02f, -1.63149331e-02f,
  -8.76291096e-02f, -6.89672213e-03f, -4.79590222e-02f, 2.49201600e-02f, -2.84998789e-02f, 5.03696389e-02f, -4.15251106e-02f, -1.96522251e-02f, 3.46116610e-02f, -9.42037534e-03f,
  1.76619217e-02f, 2.43480690e-02f, 2.72529889e-02f, 5.69624677e-02f, -5.62655628e-02f, -1.15405917e-02f, -3.37746851e-02f, -3.69780436e-02f, 6.48115110e-03f, -5.68489395e-02f,
  3.75743420e-03f, -5.38960062e-02f, 3.80407466e-04f, -4.31196280e-02f, 6.97228163e-02f, -1.55040808e-02f, 5.56491427e-02f, 9.47958156e-02f, 6.45059273e-02f, -1.23095825e-01f,
  1.76013575e-03f, -6.86139334e-03f, 1.10930383e-01f, -2.19119377e-02f, -1.91586893e-02f, 1.36274770e-02f, -8.20203796e-02f, -6.81128576e-02f, 3.81866917e-02f, -1.01348404e-02f,
  -6.88054636e-02f, 2.82323863e-02f, -2.18826849e-02f, -2.12707277e-02f, -7.67370733e-03f, 3.35776359e-02f, 2.97172796e-02f, 6.61919713e-02f, -2.63888054e-02f, -5.53276576e-02f,
  4.11428325e-02f, 9.64452513e-03f, 4.06369194e-02f, -5.62401973e-02f, -5.55958301e-02f, 8.17105621e-02f, 6.91269292e-03f, -7.41481781e-02f, -5.92884943e-02f, 3.43572870e-02f,
  2.62119640e-02f, 1.55408129e-01f, -2.26091873e-02f, 1.35378361e-01f, 2.09094852e-01f, 1.21832646e-01f, 1.06723204e-01f, 1.15619607e-01f, 2.00538889e-01f, -5.10727914e-05f,
  3.86038348e-02f, -8.13537315e-02f, -2.07955584e-01f, 1.33680552e-02f, -3.89620326e-02f, -1.91236570e-01f, 1.34696573e-01f, -2.27143001e-02f, -1.32519770e-02f, 1.11170255e-01f,
  -1.45245707e-02f, -6.71489222e-04f, -3.90777476e-02f, 4.34226729e-02f, 5.57463989e-02f, 6.94249049e-02f, -3.76540124e-02f, -1.39275223e-01f, 6.42809495e-02f, 7.47508034e-02f,
  -3.37004736e-02f, -1.17739193e-01f, 1.08842400e-03f, -1.33591443e-01f, -3.61199044e-02f, -5.49021224e-03f, -1.01412311e-01f, -1.71673764e-02f, 5.97784929e-02f, 2.29136320e-03f,
  -1.72643457e-02f, -8.07613973e-03f, -8.52439273e-03f, -4.33018394e-02f, 5.44232838e-02f, 4.07429226e-02f, 1.01923756e-01f, -1.03898933e-02f, -4.60567251e-02f, -8.27267617e-02f,
  -2.08533209e-04f, -8.10814556e-03f, 3.44164260e-02f, -2.89976466e-02f, 1.79184615e-04f, 5.78959771e-02f, -3.14752571e-02f, -2.39254278e-03f, 3.26030143e-02f, 1.03718027e-01f,
  -1.30980492e-01f, 7.44130164e-02f, -5.88359982e-02f, -6.09773658e-02f, -4.08184268e-02f, 4.90632607e-03f, 4.49402705e-02f, -4.97334264e-02f, -6.11084886e-02f, -3.91441071e-03f,
  -6.38598353e-02f, 7.59689063e-02f, 1.15848649e-02f, 2.41096932e-02f, -1.08888578e-02f, -1.41069489e-02f, -3.39622796e-03f, -4.24983092e-02f, 9.32346508e-02f, 7.34178796e-02f,
  4.89970529e-03f, 2.66573597e-02f, -1.00665471e-04f, 2.34489571e-02f, 4.51758280e-02f, -7.93637650e-04f, -1.20814415e-02f, -4.44682827e-03f, 1.13862962e-01f, -3.05282399e-02f,
  7.99524859e-02f, 1.14533253e-01f, 1.54613168e-03f, -2.00417507e-02f, -9.62941572e-02f, 9.63637233e-02f, -7.80816749e-02f, 6.61917683e-03f, -5.06666489e-02f, 9.92737040e-02f,
  -3.32263187e-02f, 5.30842505e-02f, 1.37184918e-01f, 5.82509814e-03f, 3.89416330e-03f, 1.14239238e-01f, 1.14369644e-02f, 5.94716780e-02f, 1.36199549e-01f, 1.99054442e-02f,
  -1.11783901e-02f, 6.25132546e-02f, -1.48269922e-01f, 6.02674149e-02f, -2.67576668e-02f, -9.13943127e-02f, 8.45930576e-02f, -1.59878395e-02f, -4.54507470e-02f, 4.91018547e-03f,
  -1.52873412e-01f, -6.87358826e-02f, 2.84275383e-01f, -1.70785978e-01f, -2.10694313e-01f, -2.10939944e-01f, 1.61855012e-01f, -1.70965865e-01f, 1.29851386e-01f, -1.26033828e-01f,
  -4.77112718e-02f, 1.13750555e-01f, 1.07375875e-01f, 8.10284924e-04f, 9.27401334e-02f, -5.85642271e-03f, -2.73535158e-02f, 5.25599532e-02f, -3.54277045e-02f, -1.44939572e-01f,
  5.12722544e-02f, -1.02965392e-01f, 1.46477651e-02f, -1.79797620e-01f, -1.40944913e-01f, -2.16312613e-02f, -5.14943302e-02f, 8.16459209e-02f, -1.04474850e-01f, 1.03186676e-03f,
  -1.71146348e-01f, -1.26602575e-01f, -4.15671505e-02f, -8.85037333e-02f, -2.14140657e-02f, -1.70569979e-02f, -2.58198343e-02f, 1.22890480e-01f, 2.94351317e-02f, -1.69500969e-02f,
  -8.79961625e-02f, -1.37181138e-03f, -1.04465391e-02f, 3.17310169e-02f, -8.85589123e-02f, -1.75708793e-02f, 1.97747955e-04f, -8.46669171e-03f, -5.61122522e-02f, -5.96257523e-02f,
  2.94264685e-02f, -9.94215813e-03f, 4.48816009e-02f, -6.28951192e-02f, -5.25902212e-03f, 5.11003807e-02f, -1.72022963e-03f, 2.13841740e-02f, -1.33064896e-01f, -3.37670557e-02f,
  9.30331051e-02f, -5.12071997e-02f, -4.19099256e-02f, -4.19656150e-02f, -3.56293656e-02f, -7.93691501e-02f, -6.59626676e-03f, -1.77401938e-02f, 5.73866479e-02f, -1.10354595e-01f,
  -2.91804913e-02f, -2.83103883e-02f, -8.89572725e-02f, -4.61522117e-02f, 1.22115891e-02f, 3.20275873e-02f, -4.13091620e-03f, -4.27521989e-02f, 7.77378082e-02f, -8.96670371e-02f,
  -5.37985340e-02f, -5.73356152e-02f, 4.93096821e-02f, -4.60498743e-02f, 1.25538576e-02f, -1.14505729e-02f, 3.53708002e-03f, -1.24624573e-01f, 3.73129211e-02f, 3.19751576e-02f,
  -2.00081304e-01f, -1.37152717e-01f, -5.66965006e-02f, -3.36506292e-02f, -7.17320591e-02f, -5.29723475e-04f, -1.41831778e-03f, -9.20037106e-02f, -8.34748074e-02f, -2.75385529e-02f,
  -9.21384767e-02f, 1.60485469e-02f, 4.37528305e-02f, -8.30837861e-02f, 1.89679209e-02f, -6.92586228e-02f, 6.37118220e-02f, -4.70043533e-02f, -3.70640717e-02f, -2.53379606e-02f,
  -7.52974078e-02f, 6.68335110e-02f, 2.22261623e-02f, 3.87272127e-02f, -2.52334271e-02f, -5.11278287e-02f, -1.77723411e-02f, 1.00434721e-02f, -1.25259031e-02f, 1.12203002e-01f,
  -1.93834454e-01f, -2.63628125e-01f, -2.99195461e-02f, -1.37509659e-01f, 1.54326066e-01f, 1.75689518e-01f, 1.42866559e-02f, 2.77283210e-02f, -1.34755829e-02f, -1.31249845e-01f,
  4.63331863e-02f, -7.34683648e-02f, 3.01787499e-02f, 1.94901470e-02f, 1.61413178e-01f, 1.61051139e-01f, -3.24399062e-02f, -6.18721955e-02f, 6.17355704e-02f, -7.78673440e-02f,
  4.53229956e-02f, 7.41253421e-02f, -5.46595678e-02f, 5.88500649e-02f, -1.20917805e-01f, -7.19048129e-03f, -9.98655334e-02f, 1.02260187e-01f, -1.18448339e-01f, 1.49636924e-01f,
  -8.30596164e-02f, -1.28450587e-01f, -1.41995490e-01f, -6.26468584e-02f, -8.32889304e-02f, -5.51038980e-02f, -4.90656029e-03f, -7.97660183e-03f, -5.40081859e-02f, 2.01381408e-02f,
  -4.82315719e-02f, -1.29998913e-02f, 4.53568548e-02f, 2.14262237e-03f, -4.87066843e-02f, -1.19133517e-01f, 4.86576110e-02f, -2.76529975e-02f, -1.22049429e-01f, -1.05377873e-02f,
  -3.51543427e-02f, 1.33881113e-02f, -8.63827541e-02f, 2.03719214e-02f, -3.60841826e-02f, 5.38488291e-02f, 1.10666201e-01f, -2.40382608e-02f, -2.74791289e-02f, -4.20790240e-02f,
  -9.79085565e-02f, 6.63814554e-03f, -5.49058579e-02f, -9.35454965e-02f, 4.87599224e-02f, -2.74824835e-02f, 7.99397528e-02f, 3.76848094e-02f, 7.80772269e-02f, 1.32317608e-02f,
  4.26367372e-02f, 1.32764848e-02f, 1.45131093e-03f, 4.35951650e-02f, -6.56156465e-02f, -1.52852431e-01f, -2.24287231e-02f, 1.19380347e-01f, 3.54809351e-02f, -1.62225850e-02f,
  -4.59272414e-02f, 3.21613438e-02f, 5.44214062e-02f, 3.66810849e-03f, -2.79712733e-02f, 9.07600075e-02f, -2.65687727e-03f, -8.69349837e-02f, -3.20962034e-02f, -8.93442612e-03f,
  -6.82451725e-02f, -1.97271377e-01f, -5.67464270e-02f, -1.05002292e-01f, -2.78628413e-02f, -6.21626005e-02f, -5.17616142e-03f, 2.26077698e-02f, 1.41764269e-03f, 7.46501377e-03f,
  9.19753760e-02f, -9.59485676e-03f, -1.39336400e-02f, -1.67333223e-02f, 7.65670687e-02f, -2.91259051e-03f, -1.44487629e-02f, 5.37502905e-03f, -3.72445248e-02f, -8.45115073e-03f,
  5.93137518e-02f, -4.10005897e-02f, -3.75238024e-02f, -1.10219985e-01f, -5.86446971e-02f, -4.33945656e-02f, -4.06732671e-02f, 1.50746468e-03f, 1.15392275e-01f, 8.77610687e-03f,
  -4.01326209e-01f, 8.78055617e-02f, -8.43503177e-02f, -7.57314041e-02f, -7.64504960e-03f, -7.33755529e-02f, -2.18673527e-01f, 5.24306819e-02f, -1.84282660e-01f, 7.53202513e-02f,
  -7.04051694e-03f, -8.81817862e-02f, 1.28928244e-01f, -5.08244485e-02f, -1.65136084e-01f, 9.01255608e-02f, -9.45019498e-02f, 4.33911942e-03f, -5.13037816e-02f, 8.56415853e-02f,
  -7.01746866e-02f, -1.85457747e-02f, 9.21559855e-02f, 1.55603677e-01f, -3.64142917e-02f, -1.22383721e-01f, 1.31369874e-01f, 8.28368291e-02f, 4.52204607e-02f, -8.12278166e-02f,
  -8.09313506e-02f, -5.82313351e-02f, 4.14202809e-02f, -1.30171916e-02f, 7.42319971e-02f, -2.30919700e-02f, -8.64568874e-02f, -1.34076148e-01f, 2.31455453e-02f, -3.66235115e-02f,
  1.75447017e-03f, 5.22311255e-02f, -1.05884619e-01f, -4.21365909e-02f, 6.92775622e-02f, 3.67986858e-02f, 5.95771968e-02f, -7.23528266e-02f, -3.17998342e-02f, 7.52388760e-02f,
  4.50530536e-02f, -5.26675805e-02f, 6.92854673e-02f, -1.97021384e-02f, 6.58901185e-02f, 6.60107732e-02f, -7.52900839e-02f, 3.78987007e-02f, -5.71482293e-02f, -1.23433210e-01f,
  -2.79927403e-02f, 2.06683800e-02f, 7.32629150e-02f, 4.35742997e-02f, -9.63262806e-04f, 3.92965414e-02f, 1.51980631e-02f, 6.47528172e-02f, -5.40776104e-02f, 8.04809406e-02f,
  -2.02260744e-02f, 4.65070419e-02f, -4.57501523e-02f, -1.88568910e-03f, -1.75574422e-02f, 6.31043548e-03f, 2.21406613e-02f, 5.90359308e-02f, -4.75335903e-02f, 2.76346654e-02f,
  4.83441725e-03f, 2.24638619e-02f, -5.35268039e-02f, 8.60777870e-02f, -6.53032139e-02f, 5.00552729e-02f, 3.01139336e-02f, 7.74943531e-02f, -1.94667000e-02f, -1.09334867e-02f,
  -1.78051684e-02f, -7.18352497e-02f, -5.16698174e-02f, 1.28061289e-03f, -1.60229411e-02f, 5.51114343e-02f, -7.18848482e-02f, 1.15214333e-01f, 3.94655578e-02f, 3.00708897e-02f,
  3.84565592e-02f, -6.79146647e-02f, 2.00628070e-03f, 4.55119498e-02f, -3.54445130e-02f, -8.71170387e-02f, 5.24782725e-02f, 1.05545055e-02f, 2.50845607e-02f, 3.17178704e-02f,
  -1.50035899e-02f, -2.81591341e-02f, 2.15409119e-02f, -3.46033461e-02f, -2.82310303e-02f, -4.72340081e-03f, -1.25080422e-02f, -4.89490293e-02f, 2.35074330e-02f, -3.01471576e-02f,
  -1.97477996e-01f, 1.72747821e-01f, 1.82476997e-01f, -7.53100887e-02f, 2.00473323e-01f, -9.52935517e-02f, -1.52273461e-01f, 1.32994071e-01f, -1.60429850e-01f, -4.64071799e-03f,
  -1.36663884e-01f, -1.37954980e-01f, -2.71045975e-02f, -2.85079181e-01f, -2.73830116e-01f, -1.80559888e-01f, -2.82003731e-01f, -4.45962250e-02f, -1.45821571e-01f, 5.10220267e-02f,
  -1.87912330e-01f, -1.74830094e-01f, -8.93325284e-02f, -3.51286605e-02f, 4.53484319e-02f, 1.20731592e-01f, -5.44848572e-03f, 2.14489810e-02f, -4.41445485e-02f, -1.00062927e-03f,
  8.61391798e-03f, -7.29664043e-02f, 8.73364806e-02f, 5.34828752e-02f, 6.10381775e-02f, 2.25141961e-02f, 5.52934082e-03f, 5.08806743e-02f, 8.82410444e-03f, 1.00094318e-01f,
  4.30062972e-02f, 3.31398211e-02f, -7.54265860e-02f, -6.42472431e-02f, 6.16488494e-02f, 8.47863853e-02f, 4.34620716e-02f, 9.05713812e-02f, 8.31419975e-02f, -1.17729399e-02f,
  2.96180528e-02f, 8.15605745e-02f, 4.89539504e-02f, 1.91314816e-02f, -1.98837044e-03f, -5.40705398e-02f, 3.31451632e-02f, 1.34052364e-02f, 4.72323820e-02f, 1.52537581e-02f,
  3.08384635e-02f, 1.30522856e-02f, 9.80759412e-02f, -2.75924616e-02f, -3.44922319e-02f, 5.53435087e-03f, -4.04824056e-02f, -1.54398782e-02f, -5.58675006e-02f, -2.40521301e-02f,
  -4.44856659e-02f, -4.19530198e-02f, -2.23366637e-03f, -1.88499447e-02f, -3.69810499e-02f, -2.27228887e-02f, -4.22869669e-03f, 5.62022068e-02f, 4.35447022e-02f, -4.87257652e-02f,
  -2.94317212e-02f, 8.84738266e-02f, 2.11648159e-02f, 1.64863467e-03f, 6.74654096e-02f, -1.29349232e-02f, -3.83868255e-02f, 3.35034020e-02f, 3.17894742e-02f, 5.54205775e-02f,
  8.14085826e-02f, 9.55349505e-02f, 1.04138404e-02f, 5.94502166e-02f, 2.91344095e-02f, 5.80870211e-02f, -2.95703802e-02f, -5.48948422e-02f, 4.79530953e-02f, -6.48485590e-03f,
  1.27075806e-01f, 7.58019043e-03f, 1.26568466e-01f, -8.08505863e-02f, -7.87710547e-02f, -3.36794443e-02f, 3.73145565e-02f, 8.90568178e-03f, -6.95693567e-02f, 1.22095942e-02f,
  1.09218527e-02f, 2.49086544e-02f, -6.33831834e-03f, 3.44965495e-02f, 5.58346929e-03f, 6.18612468e-02f, 5.96154295e-02f, 3.61963138e-02f, 4.03198563e-02f, 3.56321335e-02f,
  -3.46720606e-01f, -5.35301790e-02f, -3.46144103e-03f, -9.56420079e-02f, -1.05894707e-01f, -2.05337573e-02f, 7.88749233e-02f, -2.03834578e-01f, -2.72308409e-01f, 1.15763202e-01f,
  -5.95057867e-02f, 3.64660807e-02f, 2.02228710e-01f, -1.27311036e-01f, -1.17564075e-01f, 1.42810836e-01f, -1.55699328e-01f, 7.99739442e-04f, -3.91414985e-02f, -1.08670503e-01f,
  -6.58339635e-02f, -1.55681625e-01f, 9.37511772e-02f, -1.81016698e-02f, -9.24901068e-02f, -1.20669574e-01f, -1.67119205e-02f, 1.12750404e-01f, 7.78996348e-02f, -1.53327631e-02f,
  -4.95222844e-02f, -1.22061512e-02f, 4.75558750e-02f, 1.07290879e-01f, 7.34957904e-02f, 2.36500222e-02f, 1.05981663e-01f, 6.36558682e-02f, -6.15685098e-02f, 9.11971275e-03f,
  2.59126071e-03f, -1.30129224e-02f, -1.35106305e-02f, 3.72177549e-02f, -1.40625641e-01f, -4.05337922e-02f, 1.48600666e-02f, -1.00695692e-01f, 2.76786424e-02f, 8.23911466e-03f,
  1.99238099e-02f, -4.66329902e-02f, 3.59290056e-02f, 2.55126562e-02f, -3.55769880e-02f, 3.90049489e-03f, -1.15122888e-02f, 7.95220304e-03f, 1.11965314e-02f, -8.06608275e-02f,
  -8.96118954e-02f, 3.83710451e-02f, -5.10339662e-02f, -4.11313064e-02f, -1.17025280e-03f, -3.41217481e-02f, -4.04745825e-02f, 4.86751227e-03f, -2.94131152e-02f, -6.91193948e-03f,
  3.00414115e-02f, -6.51784167e-02f, 6.06620833e-02f, -1.79123227e-02f, -5.50609492e-02f, 1.38609540e-02f, 7.30165690e-02f, -4.65025380e-02f, -6.96162973e-03f, -7.89337605e-02f,
  -4.11709398e-02f, -1.53419189e-02f, 4.02093902e-02f, 3.83108743e-02f, 2.67338585e-02f, 3.04958038e-02f, -8.78063515e-02f, 4.48212884e-02f, -4.01658677e-02f, -1.49868168e-02f,
  -2.63962839e-02f, 3.23541313e-02f, -3.97539092e-03f, 2.62230858e-02f, 1.53239602e-02f, -7.06757456e-02f, 2.90034823e-02f, -8.19608569e-02f, -5.30329049e-02f, -4.80717607e-02f,
  -4.98346239e-03f, 6.77959323e-02f, -7.53732473e-02f, -2.96371747e-02f, 7.07358122e-03f, 4.16547805e-02f, -1.85437594e-02f, -2.94577535e-02f, 7.39019597e-03f, -2.32976419e-03f,
  -2.43748743e-02f, 2.28068959e-02f, -1.38570722e-02f, 6.14298694e-02f, -6.73178807e-02f, -2.86683254e-02f, 4.50642873e-03f, 4.50567938e-02f, -4.71409298e-02f, -3.88331823e-02f,
  3.12742919e-01f, -4.73078042e-02f, 8.98157060e-02f, 9.87317339e-02f, -9.78914183e-03f, -2.09479600e-01f, 1.01905465e-01f, -5.61550222e-02f, 1.45876795e-01f, -9.86943021e-02f,
  3.47914845e-02f, 1.24400616e-01f, 7.17873126e-02f, -3.86544913e-02f, 2.31834888e-01f, 1.25578403e-01f, -7.51775652e-02f, 9.15329084e-02f, 7.26894736e-02f, 1.29753994e-02f,
  9.60406810e-02f, 4.92837764e-02f, 1.33370489e-01f, -1.14055738e-01f, -4.10147086e-02f, 8.36423784e-03f, -2.31252541e-03f, -1.43641988e-02f, -1.63783401e-01f, 1.05997965e-01f,
  -3.33743952e-02f, -6.52684271e-02f, 3.10827475e-02f, -2.94666663e-02f, 4.87501733e-02f, -4.69942503e-02f, -2.59721037e-02f, 1.69984289e-02f, 5.33079095e-02f, 1.40249217e-03f,
  8.60920548e-03f, -2.09367764e-03f, -8.51391777e-02f, 2.85387393e-02f, -4.08385172e-02f, 6.52786752e-04f, 8.98737237e-02f, -3.37877460e-02f, 3.40318084e-02f, 7.67610446e-02f,
  -8.25089775e-03f, -3.23438123e-02f, 4.49761488e-02f, -2.85512581e-02f, -1.59368254e-02f, -7.94147998e-02f, -3.32542844e-02f, 2.34512873e-02f, 1.89509820e-02f, -4.67529744e-02f,
  -2.33356003e-02f, -5.44173382e-02f, -1.43947760e-02f, 5.54336049e-03f, 6.68815151e-03f, -3.45148444e-02f, 1.73741579e-02f, -4.31964546e-03f, -8.96261248e-04f, -4.93231304e-02f,
  3.03299967e-02f, -3.84984650e-02f, 4.00781110e-02f, 2.76370514e-02f, 2.14442406e-02f, -1.82191841e-02f, 1.03204168e-01f, -2.86759045e-02f, -6.11821283e-03f, -9.95553099e-03f,
  -4.48237546e-02f, 4.21845801e-02f, -2.57241856e-02f, -5.24810366e-02f, -4.23254631e-02f, 5.49863093e-02f, -8.26433450e-02f, -1.09065045e-03f, 7.58782076e-03f, -6.22483483e-03f,
  -8.26926455e-02f, -1.20782286e-01f, 4.44820374e-02f, -3.51009034e-02f, 5.34626879e-02f, 8.36118758e-02f, 3.56065407e-02f, -9.06272698e-03f, -2.52861599e-03f, 5.97501658e-02f,
  -2.87660360e-02f, 2.33095679e-02f, -6.89117238e-02f, -6.63938327e-03f, -1.16021901e-01f, -7.29722679e-02f, -4.84662503e-02f, 3.52121033e-02f, 1.36846546e-02f, -3.74335237e-02f,
  7.17205182e-03f, 4.18499745e-02f, 1.28390789e-02f, 2.75033582e-02f, -7.15475753e-02f, -5.67188151e-02f, 2.75530703e-02f, -1.88295469e-02f, -5.36303259e-02f, -9.54853073e-02f,
  1.20066768e-02f, -1.12218834e-01f, 1.23105802e-01f, -5.34476973e-02f, 9.59107578e-02f, 2.61217505e-01f, 2.20590159e-01f, 2.83990391e-02f, 1.51473954e-01f, -3.32117192e-02f,
  4.24667522e-02f, -1.36350870e-01f, 1.14495404e-01f, -8.02494138e-02f, 1.76231116e-01f, 8.70670304e-02f, -9.71830450e-03f, -1.15635365e-01f, -2.72959210e-02f, 7.63764456e-02f,
  1.09130628e-01f, 2.43824348e-02f, -4.13056388e-02f, -1.55647183e-02f, -1.29088521e-01f, -1.34087980e-01f, -1.10014953e-01f, -5.96791208e-02f, -2.04564124e-01f, -9.42570530e-03f,
  1.10309370e-01f, 3.10897268e-03f, -6.77215606e-02f, -1.02050910e-02f, -1.91314854e-02f, -5.30467331e-02f, -4.35499214e-02f, -2.29991619e-02f, -4.45187204e-02f, -3.91751602e-02f,
  -6.02732301e-02f, 4.11922199e-04f, -5.79763390e-02f, -2.41275802e-02f, 1.57488771e-02f, 3.38581647e-03f, 6.96755797e-02f, -7.40410089e-02f, 4.04733792e-02f, -3.16167958e-02f,
  5.43110147e-02f, -1.91761088e-02f, 2.34060828e-02f, -9.75983962e-02f, 3.22097354e-02f, 1.16202543e-02f, 5.25633767e-02f, -1.22546656e-02f, 3.88512015e-02f, -2.12594867e-02f,
  5.97461909e-02f, 8.25739428e-02f, -2.12393459e-02f, -8.87199342e-02f, -5.11499532e-02f, -4.89215329e-02f, 2.62375772e-02f, 1.98290944e-02f, -6.78370055e-03f, -9.52223409e-03f,
  5.06704003e-02f, -6.80567399e-02f, 7.17366263e-02f, 8.76644552e-02f, -8.45614821e-02f, 5.59101403e-02f, -9.48086753e-02f, -3.88866253e-02f, -3.40182930e-02f, 3.02340426e-02f,
  6.20019995e-02f, 9.30501819e-02f, -2.23087631e-02f, 2.32705437e-02f, -1.98299550e-02f, 1.73321553e-02f, 2.68940907e-02f, -2.22940911e-02f, 2.67199054e-02f, 6.42886534e-02f,
  -9.83479470e-02f, 1.48280133e-02f, -5.62033756e-03f, 2.06236616e-02f, -5.49184568e-02f, -1.18110277e-01f, 4.63690162e-02f, 3.90236862e-02f, 5.74168228e-02f, 5.29352948e-03f,
  8.26087780e-03f, -8.87890980e-02f, 7.26634562e-02f, -2.58919802e-02f, -1.55468928e-02f, 3.48554887e-02f, -3.43195423e-02f, -4.52517234e-02f, -2.66673453e-02f, -3.00425068e-02f,
  -1.03926435e-01f, 1.04836104e-02f, -6.84503913e-02f, -7.88854994e-03f, -1.04023084e-01f, -1.17721729e-01f, -2.82805692e-02f, 7.28484690e-02f, -4.60043177e-03f, 5.61905205e-02f,
  -5.49272262e-02f, 1.11709133e-01f, 7.37745240e-02f, -1.27653480e-01f, 9.44024175e-02f, 8.71092379e-02f, -4.99763787e-02f, -8.49324688e-02f, 1.96976624e-02f, -1.85449660e-01f,
  -1.55741140e-01f, 1.03966333e-01f, 6.10950179e-02f, -8.89939964e-02f, 1.76786095e-01f, 1.05411142e-01f, -7.55461231e-02f, -1.53148934e-01f, 1.17759489e-01f, -1.44511297e-01f,
  6.40753750e-03f, -4.04224470e-02f, 1.26827359e-01f, 6.23274744e-02f, 4.39757109e-02f, -8.63907412e-02f, -3.34102027e-02f, -9.39891208e-04f, -6.07244782e-02f, 8.38479474e-02f,
  7.33528808e-02f, -9.52441692e-02f, -5.09242564e-02f, 1.75688285e-02f, -7.61788562e-02f, -2.37301122e-02f, -6.46661073e-02f, 7.93772042e-02f, -4.77492111e-03f, -7.47385621e-02f,
  5.72277866e-02f, -9.49583873e-02f, -6.62642047e-02f, 1.42958686e-02f, 3.07130124e-02f, -1.96017642e-02f, -4.98021357e-02f, 4.77067521e-03f, 1.03895575e-01f, 1.19800262e-01f,
  8.95047411e-02f, 2.52547320e-02f, -9.94295701e-02f, -7.69307464e-02f, -2.61545833e-02f, -3.59565839e-02f, -8.23696777e-02f, 6.06120564e-02f, -1.57186538e-02f, 1.11071179e-02f,
  4.68281060e-02f, -1.33942692e-02f, 4.25046775e-03f, -2.85985637e-02f, -2.66878074e-03f, -1.06650762e-01f, 4.42602783e-02f, -8.28255117e-02f, -3.28233987e-02f, -1.13855086e-01f,
  -6.77723810e-02f, -2.81702913e-03f, -9.33451578e-02f, -4.40690517e-02f, 1.05045205e-02f, -3.99036855e-02f, 7.42386281e-02f, -5.27807064e-02f, -7.91431293e-02f, 3.64674851e-02f,
  -1.43084880e-02f, -1.63639616e-02f, 6.59410506e-02f, -1.59990359e-02f, -6.25674501e-02f, -2.69099530e-02f, -5.99546172e-02f, 4.08259407e-02f, 1.22894354e-01f, -2.86931428e-03f,
  -5.01580648e-02f, -9.85292345e-02f, 3.98902968e-02f, -1.81445424e-02f, 4.05977219e-02f, 7.18085319e-02f, 6.85803667e-02f, -1.18794091e-01f, 5.27316518e-02f, 4.15131412e-02f,
  -1.28209610e-02f, -7.61695281e-02f, 9.45975073e-03f, 2.46034265e-02f, 6.85959235e-02f, -3.59143279e-02f, 8.26349761e-03f, 6.15361817e-02f, -5.03101498e-02f, -3.34733836e-02f,
  -2.15113219e-02f, -3.35693695e-02f, -5.61917722e-02f, -1.25653967e-01f, 2.22337674e-02f, 4.29969169e-02f, -1.72924474e-02f, 4.43068743e-02f, 2.12617684e-02f, 2.68756803e-02f,
  -2.28983238e-01f, 7.59002641e-02f, -7.99306631e-02f, 1.60226956e-01f, 8.85910764e-02f, 1.33087588e-02f, 7.46831000e-02f, 6.14118762e-02f, -1.83921736e-02f, 1.10430785e-01f,
  1.42107261e-02f, -1.76910385e-01f, -4.05117460e-02f, 2.50104845e-01f, 1.47336908e-02f, -1.60454735e-02f, 8.00312236e-02f, 2.35399860e-03f, -6.84533939e-02f, 1.06203951e-01f,
  -5.68572320e-02f, 1.47675693e-01f, -5.95151521e-02f, 4.52682935e-02f, 1.05768092e-01f, 2.94396840e-02f, -1.09518634e-03f, -1.06817782e-01f, 1.29212022e-01f, -2.48144697e-02f,
  -6.19285889e-02f, 1.51118124e-02f, -5.07689919e-03f, -8.98155496e-02f, 7.49161243e-02f, -7.55672678e-02f, -3.91081609e-02f, -1.64832361e-02f, -7.84482062e-02f, -3.21732555e-03f,
  -7.57223144e-02f, -2.02408172e-02f, -4.16203365e-02f, 3.09667718e-02f, 6.04385957e-02f, -1.02610931e-01f, -4.04557437e-02f, -5.45116328e-03f, 3.50657664e-02f, 1.73339695e-02f,
  -4.61800881e-02f, 5.37505299e-02f, 1.95339955e-02f, -4.11647409e-02f, -6.58482360e-03f, 2.38866024e-02f, 2.09732540e-02f, -9.15127024e-02f, -9.72782597e-02f, -5.24260066e-02f,
  -2.66373018e-03f, -1.03789918e-01f, -9.10088494e-02f, -7.96556566e-03f, 2.19839420e-02f, 7.86807679e-04f, 5.75192831e-03f, 3.51229459e-02f, -6.84508532e-02f, -4.81705600e-03f,
  -1.13449274e-02f, 1.95323881e-02f, -8.55784267e-02f, 3.67173329e-02f, 4.87171486e-02f, 2.42288951e-02f, -6.80745021e-02f, -6.30489225e-03f, -3.90081704e-02f, 7.95368627e-02f,
  5.76271042e-02f, -4.89299148e-02f, 2.85457838e-02f, -3.01014818e-02f, -6.99294880e-02f, 6.95621669e-02f, 3.07271071e-02f, 3.09548080e-02f, -3.05467155e-02f, -3.19926813e-02f,
  1.35319769e-01f, 9.58086476e-02f, 9.47781652e-03f, 3.04746386e-02f, -1.06346153e-01f, -5.13877161e-02f, -2.02540345e-02f, -1.10828087e-01f, 8.71691108e-03f, -3.91060486e-02f,
  3.30926962e-02f, 9.69832614e-02f, -6.74150065e-02f, -3.06145288e-02f, -2.45593619e-02f, 6.37708679e-02f, 4.95063476e-02f, -1.81657262e-02f, 3.27809379e-02f, 5.45927361e-02f,
  9.67788622e-02f, 9.26766396e-02f, 2.25370079e-02f, 5.77552691e-02f, -1.93216130e-02f, -4.93473746e-02f, 4.87886742e-02f, -3.73801170e-03f, -1.14559196e-01f, -3.23962942e-02f,
  3.88439089e-01f, -2.26246446e-01f, 1.10018872e-01f, -9.12493244e-02f, 7.85296559e-02f, -4.07861881e-02f, 2.21590772e-02f, -4.00395244e-02f, 1.63944066e-01f, -1.60888016e-01f,
  -3.78485955e-02f, 1.44511431e-01f, -8.32540914e-03f, -1.67273819e-01f, 1.38720870e-01f, -4.78080660e-02f, -8.79861116e-02f, -7.12791309e-02f, 3.49370353e-02f, -1.69963717e-01f,
  -4.58503887e-02f, -2.67088830e-01f, -4.09358069e-02f, -1.84444159e-01f, -1.59910433e-02f, 5.26379831e-02f, -1.68745548e-01f, 2.02107523e-02f, -9.17371660e-02f, -1.39408214e-02f,
  5.51038282e-03f, 8.87578279e-02f, 1.35320246e-01f, 6.88239411e-02f, -5.30318543e-02f, -4.43659723e-02f, 7.03690723e-02f, -4.98034060e-03f, -1.87881142e-02f, 4.02643606e-02f,
  -1.75042953e-02f, -1.60201285e-02f, 2.74018925e-02f, 2.18939111e-02f, 5.32876812e-02f, 2.26949118e-02f, 5.98615184e-02f, 4.11620513e-02f, 1.40250148e-02f, 3.02069224e-02f,
  2.63101105e-02f, 7.44761005e-02f, 2.88800038e-02f, 7.22084008e-03f, 9.13035348e-02f, 2.74105091e-02f, 3.74650583e-02f, -2.33185962e-02f, -1.55965043e-02f, -6.25384320e-03f,
  -9.17803869e-02f, -7.41602480e-02f, -8.20205882e-02f, -1.88673828e-02f, -2.82283910e-02f, 1.29253706e-02f, -2.53101606e-02f, -2.69671362e-02f, 3.80088091e-02f, -3.93928103e-02f,
  5.79894632e-02f, 4.99395914e-02f, -4.21382580e-03f, 5.64151779e-02f, -1.79285854e-02f, 1.72625668e-02f, -1.41721917e-02f, 3.81657295e-03f, 7.71060511e-02f, 1.96467377e-02f,
  -5.30853821e-03f, 3.31149288e-02f, -4.89889756e-02f, 3.31365224e-03f, 7.80225620e-02f, -3.16767662e-04f, 7.33161671e-03f, 6.04203828e-02f, -1.51587743e-02f, -7.49292672e-02f,
  -1.39609322e-01f, -2.20843837e-01f, 2.86015552e-02f, -3.69894621e-03f, 1.00226793e-02f, 4.34149317e-02f, -3.42492238e-02f, -1.89071875e-02f, -8.06910098e-02f, -6.18643574e-02f,
  5.12765683e-02f, 7.55675063e-02f, -8.89023170e-02f, -7.35193789e-02f, -1.42095680e-03f, 4.07196319e-04f, -3.93145271e-02f, -2.17886698e-02f, -2.49017123e-02f, 5.30930748e-03f,
  -7.73427710e-02f, 2.54688766e-02f, -1.61691904e-02f, -2.80006379e-02f, -8.64058584e-02f, 3.67327109e-02f, -3.32438610e-02f, -3.02246381e-02f, 6.09035511e-03f, -5.62328435e-02f,
  -1.94430187e-01f, -1.00142039e-01f, 1.50130436e-01f, -1.54517964e-01f, 1.66003436e-01f, 4.99798954e-02f, 1.19891822e-01f, -2.11227909e-02f, -6.52789697e-02f, -6.00252114e-02f,
  -1.72890723e-02f, -2.11442336e-01f, 7.85495788e-02f, -7.48461336e-02f, 1.37647226e-01f, 1.08916916e-01f, -7.95475915e-02f, -1.43030524e-01f, 8.43883380e-02f, -1.60287812e-01f,
  -1.42511232e-02f, 1.05558746e-01f, 8.39315951e-02f, 2.66237697e-03f, -3.48394886e-02f, -7.73291960e-02f, 1.06587429e-02f, 1.20091788e-01f, -1.02006428e-01f, 5.41087463e-02f,
  -4.80559170e-02f, -8.81016180e-02f, -5.05828001e-02f, -7.82010518e-03f, -3.98446172e-02f, 1.61728840e-02f, 4.35432270e-02f, 9.72264558e-02f, 1.45276329e-02f, 7.51633197e-04f,
  -6.72723353e-03f, 2.76684090e-02f, -1.84002481e-02f, 1.29084721e-01f, -1.75144598e-02f, 2.28606649e-02f, -5.85183203e-02f, -5.38029149e-02f, -4.83284034e-02f, 4.34212051e-02f,
  -6.47822693e-02f, -4.42619622e-03f, -6.71352148e-02f, -4.49549481e-02f, 1.03542812e-01f, -5.15675060e-02f, -3.58700082e-02f, -4.11707386e-02f, -8.22071135e-02f, -5.64581528e-03f,
  -3.51442397e-02f, 9.91115998e-03f, 3.25972885e-02f, -1.23132868e-02f, -8.72068256e-02f, -1.00201957e-01f, 6.61092484e-03f, 2.57680509e-02f, -7.33340085e-02f, 3.24400254e-02f,
  -9.75418277e-03f, -2.93260869e-02f, 3.68534066e-02f, -9.12446529e-03f, -3.22056115e-02f, -8.97302926e-02f, -4.93990779e-02f, 5.24234734e-02f, 1.21914633e-02f, 5.75826503e-02f,
  -3.99652272e-02f, -8.10326114e-02f, -4.22857739e-02f, 1.01481872e-02f, -1.32090272e-02f, 9.33358520e-02f, 3.62703167e-02f, 7.79848965e-03f, 6.42462298e-02f, 1.49261113e-03f,
  -5.38625047e-02f, -2.09748074e-01f, 8.88552293e-02f, -1.12259626e-01f, 1.24878334e-02f, -5.10759242e-02f, 1.55784306e-04f, 9.36834067e-02f, 2.94592436e-02f, -4.82575148e-02f,
  -8.13392922e-02f, 6.34521106e-03f, -2.82808989e-02f, 1.00956991e-01f, -2.11432483e-02f, -5.06484769e-02f, 1.29064592e-02f, -6.15308806e-02f, -4.34181429e-02f, 4.55875359e-02f,
  -1.44080415e-01f, -2.04193089e-02f, -2.85743717e-02f, -1.03926100e-01f, -9.67413634e-02f, -7.95021770e-05f, -7.18904510e-02f, -3.40691321e-02f, 2.19515879e-02f, -1.78930964e-02f,
  -7.09597766e-02f, -3.79210450e-02f, -3.06922317e-01f, -1.95794940e-01f, -2.27640986e-01f, 1.08089902e-01f, -9.79390442e-02f, -9.02131870e-02f, -3.10581535e-01f, 7.44664893e-02f,
  1.22061856e-02f, 1.18330106e-01f, -6.51607215e-02f, 1.78873893e-02f, 3.37042138e-02f, 1.48705952e-02f, 2.68435199e-02f, 6.20778017e-02f, -2.21276626e-01f, -7.23138526e-02f,
  -8.91477540e-02f, 1.54343471e-01f, 1.10587046e-01f, 4.65756245e-02f, 4.79289182e-02f, 5.10937860e-03f, 2.19371721e-01f, -1.16569862e-01f, 6.91814870e-02f, 2.61430684e-02f,
  -4.02921028e-02f, -1.65713266e-01f, -4.83039990e-02f, -4.54746932e-02f, -2.42056828e-02f, -3.57603356e-02f, 4.22212481e-02f, 6.81358129e-02f, -1.53368674e-02f, 6.60125399e-03f,
  -1.10476976e-02f, 3.75878848e-02f, 6.75789490e-02f, -2.65622372e-03f, -6.93427846e-02f, 2.47749854e-02f, -3.91588174e-02f, -5.18973283e-02f, -3.85656469e-02f, 9.06789023e-03f,
  5.91330528e-02f, 1.16746565e-02f, 6.64531393e-03f, -2.33030263e-02f, 1.90236345e-02f, 1.51789384e-02f, 9.65321139e-02f, 2.42384020e-02f, -6.65231869e-02f, 2.49412283e-02f,
  8.66466388e-02f, -2.09361553e-01f, 5.09984381e-02f, 1.28076663e-02f, -7.40249380e-02f, 5.99409193e-02f, 7.86074623e-02f, -3.72313745e-02f, 4.75393571e-02f, -7.89750218e-02f,
  -1.24745958e-01f, -7.97122940e-02f, -4.37930115e-02f, -8.69333651e-03f, -4.37803976e-02f, 4.98041585e-02f, 2.70897392e-02f, -5.95727190e-02f, 8.88556615e-02f, -7.06950435e-04f,
  1.05454251e-02f, 6.52615055e-02f, 3.34182347e-04f, 2.97793932e-03f, -2.82724742e-02f, -3.57453823e-02f, -2.61146985e-02f, -4.73470688e-02f, -2.23270934e-02f, -1.98975932e-02f,
  -2.19978895e-02f, -1.52892545e-01f, 6.81889728e-02f, 5.08475341e-02f, -3.46263349e-02f, 1.90520417e-02f, -7.95686543e-02f, 1.06295459e-02f, -1.07228048e-02f, 2.62300652e-02f,
  -2.14356426e-02f, -2.22643781e-02f, 7.02232644e-02f, 7.17360303e-02f, 3.47063094e-02f, 9.36633945e-02f, -1.35849621e-02f, -4.45082411e-02f, 3.33384201e-02f, -1.01705723e-01f,
  1.37288794e-01f, 1.11758872e-03f, 3.01475041e-02f, -7.69043062e-03f, -2.47560441e-03f, 6.45860285e-02f, 2.37248912e-02f, -4.97951992e-02f, 1.04842804e-01f, 7.16976151e-02f,
  -2.60966480e-01f, 9.21553373e-02f, -1.04805283e-01f, -1.70389891e-01f, -1.75197553e-02f, -2.44776085e-01f, -1.19719431e-01f, -3.82858864e-03f, -2.46288721e-02f, 1.19736515e-01f,
  9.61182415e-02f, -5.59559800e-02f, 5.19229248e-02f, 2.81527862e-02f, -1.47720307e-01f, -6.30792156e-02f, -1.42035475e-02f, -9.68199521e-02f, -5.13239130e-02f, 7.95221925e-02f,
  -2.00092401e-02f, 8.54458436e-02f, -1.09093845e-01f, 7.30313882e-02f, -1.77469980e-02f, 8.38328674e-02f, 1.36228502e-01f, 3.40635714e-04f, 5.45126125e-02f, 5.97315803e-02f,
  -8.14255103e-02f, 8.42057727e-03f, -4.53885160e-02f, 7.85463378e-02f, -6.88832775e-02f, -5.44604938e-03f, -9.00135860e-02f, 1.06681921e-02f, 3.81006685e-04f, 3.28907594e-02f,
  3.49739157e-02f, 1.46166021e-02f, 1.29928440e-02f, 1.82162449e-02f, 2.89830901e-02f, 2.63053868e-02f, 8.31028819e-02f, 2.94910558e-02f, -1.61187090e-02f, -1.13579430e-01f,
  -1.21986471e-01f, -3.33997235e-02f, 5.23179062e-02f, 5.75714670e-02f, -2.03393139e-02f, -5.56254573e-02f, -4.26153652e-02f, -8.13706517e-02f, 2.88219694e-02f, 5.47510423e-02f,
  6.55498654e-02f, 2.06485596e-02f, -1.11187674e-01f, -8.61003902e-03f, 7.50511745e-03f, -5.20637669e-02f, 1.07723549e-02f, 1.59431864e-02f, 1.75345782e-02f, 5.27350418e-02f,
  5.81002887e-03f, 3.56327109e-02f, -5.43243065e-02f, -2.39163768e-02f, 1.40893888e-02f, 3.31734344e-02f, -2.74183452e-02f, -1.42572336e-02f, -4.47424576e-02f, -3.29620540e-02f,
  2.96749454e-02f, 2.98922025e-02f, -8.59853346e-03f, -6.69407696e-02f, -3.51403398e-03f, 2.93511376e-02f, 9.48961601e-02f, -6.05863743e-02f, -6.51373994e-03f, -1.58653855e-02f,
  1.34602919e-01f, 2.12648273e-01f, 7.39267170e-02f, 4.83559221e-02f, 6.00463524e-03f, -1.93077531e-02f, 1.64731257e-02f, 2.89697014e-02f, 2.65920460e-02f, 5.75538166e-02f,
  5.95415011e-03f, -7.91936833e-03f, -6.90644560e-03f, -2.62573827e-02f, -1.78647619e-02f, -1.22808516e-02f, 2.07250770e-02f, 6.75536618e-02f, -2.73245256e-02f, 7.70509019e-02f,
  -3.77046922e-03f, 5.21660037e-02f, -7.66503364e-02f, 1.25910053e-02f, 7.88733587e-02f, -9.56252068e-02f, 2.03352813e-02f, -4.07620408e-02f, 1.67535283e-02f, 3.56671102e-02f,
  -2.55665272e-01f, 1.38412490e-01f, -2.39615604e-01f, 2.32388340e-02f, -4.02213633e-02f, 2.64900267e-01f, 2.53105432e-01f, 2.62449440e-02f, -1.69470173e-03f, 2.31012791e-01f,
  7.00519308e-02f, -2.15062462e-02f, 6.19116006e-03f, 2.28770822e-01f, 9.95449722e-02f, 1.06034309e-01f, 1.72079712e-01f, 8.03823769e-03f, -1.25679329e-01f, -6.34128675e-02f,
  -4.32022400e-02f, 1.66589871e-01f, -8.11791420e-03f, -1.20366849e-02f, -3.13415304e-02f, -1.29729003e-01f, -1.63905188e-01f, 6.69292780e-03f, 3.68087143e-02f, 2.82223746e-02f,
  1.34138227e-01f, -6.12217113e-02f, -5.48172407e-02f, -3.71783487e-02f, -7.11896196e-02f, 2.27390323e-02f, 2.00036244e-04f, 6.16686232e-02f, -1.26006110e-02f, 7.45599493e-02f,
  -1.00668566e-02f, 3.50703858e-02f, 4.96234708e-02f, 4.88080122e-02f, 1.80574879e-02f, 1.72265787e-02f, -2.66126879e-02f, 1.62622500e-02f, -5.25553562e-02f, -3.74791883e-02f,
  1.48847811e-02f, 3.47877778e-02f, -1.25060435e-02f, 9.59595218e-02f, -5.90742901e-02f, 7.71030411e-02f, 4.36206423e-02f, -8.11827020e-04f, 4.92497310e-02f, 4.36174162e-02f,
  -2.59433668e-02f, -4.25160863e-02f, -1.77500229e-02f, 2.99911853e-03f, -9.15613323e-02f, 1.65618435e-02f, 1.11424346e-02f, -1.03492290e-03f, 2.23808736e-02f, 2.37601064e-02f,
  6.55384958e-02f, -9.00281966e-02f, 1.49394036e-03f, -3.74988429e-02f, 1.18605075e-02f, 3.65695432e-02f, 1.44423749e-02f, 2.70302799e-02f, 1.68177970e-02f, 2.01554433e-03f,
  4.98172045e-02f, -1.72481425e-02f, 5.58326207e-03f, -1.10634100e-02f, 6.67875707e-02f, -4.32346277e-02f, 2.74625905e-02f, -4.23134938e-02f, -6.10196292e-02f, -2.94051878e-02f,
  6.91786483e-02f, 3.55283394e-02f, 2.02136692e-02f, -1.24379955e-02f, 3.26261669e-02f, 5.16373711e-03f, -1.32256728e-02f, 7.13174173e-04f, -1.93970073e-02f, 5.55722155e-02f,
  -1.32355345e-02f, 1.56374776e-03f, -3.42471898e-02f, -2.07293686e-02f, -2.74838265e-02f, 2.68164873e-02f, -2.37425268e-02f, 1.76406745e-02f, 6.50950745e-02f, -1.31700551e-02f,
  -6.55142590e-02f, -1.30989414e-03f, -6.74533471e-02f, -3.79209332e-02f, 9.54615138e-03f, 2.24188510e-02f, -2.48687211e-02f, 1.68147143e-02f, -9.17850249e-03f, -4.17962931e-02f,
  -1.35430068e-01f, 1.86307937e-01f, 2.55289674e-01f, -3.46459337e-02f, -1.50335237e-01f, -9.27130505e-02f, 1.21133924e-01f, -1.09865092e-01f, 2.21020222e-01f, -8.90196636e-02f,
  -1.71746939e-01f, 1.46603003e-01f, 1.12763382e-01f, -1.22689223e-02f, -7.41454884e-02f, 1.53966263e-01f, -8.57480243e-02f, 6.39177114e-02f, -9.86529747e-04f, -3.54037695e-02f,
  -1.19299240e-01f, -2.10156217e-01f, -9.46473479e-02f, -1.42425656e-01f, -3.07979435e-02f, -1.12257957e-01f, -2.25966483e-01f, -1.62575506e-02f, -6.91544712e-02f, -8.60060528e-02f,
  -1.02041773e-01f, -1.62009168e-02f, 1.29352361e-02f, 2.20842082e-02f, -7.72843137e-02f, -5.13075553e-02f, -2.34622741e-04f, 4.48780283e-02f, -3.51966172e-02f, 5.20267636e-02f,
  9.21552628e-02f, 3.17470990e-02f, -9.56397429e-02f, 5.51941767e-02f, -1.17649771e-02f, 6.69810921e-02f, 3.55213322e-02f, -3.10052373e-02f, 5.90624660e-02f, 1.64561216e-02f,
  4.05230336e-02f, -3.17572989e-03f, -9.26562622e-02f, 9.76392850e-02f, 6.96119070e-02f, 3.13763469e-02f, 1.95780583e-02f, 2.16729399e-02f, 3.07807955e-03f, -1.53501537e-02f,
  5.24451025e-02f, 4.49096449e-02f, -4.02203053e-02f, 4.45092581e-02f, -5.18000014e-02f, 5.39071970e-02f, 2.20192745e-02f, -2.57802512e-02f, -6.76856786e-02f, 3.11499322e-03f,
  -9.43002328e-02f, 8.73080734e-03f, -3.36356014e-02f, -2.41723321e-02f, 9.97629482e-03f, -2.23782174e-02f, -2.93679014e-02f, 3.01648141e-03f, 4.56748046e-02f, -9.64968726e-02f,
  9.15467441e-02f, -3.55743570e-03f, 2.46746074e-02f, 3.68424915e-02f, 1.11735370e-02f, 5.81016690e-02f, 9.37713459e-02f, -1.10724801e-03f, 4.21051234e-02f, -1.11127548e-01f,
  -8.19797739e-02f, -7.91939199e-02f, -2.86580604e-02f, -6.19508810e-02f, -2.95735542e-02f, 3.39601748e-02f, 2.60185003e-02f, -1.72028746e-02f, 5.50995544e-02f, 3.43275256e-02f,
  -3.21067721e-02f, -1.49029214e-02f, 4.66662180e-03f, 5.74387386e-02f, 5.23961969e-02f, -7.03815743e-02f, -4.84119132e-02f, -5.93955107e-02f, -1.33669868e-01f, -1.21985041e-01f,
  -8.42720494e-02f, 5.44913746e-02f, 6.92783892e-02f, -4.54952046e-02f, 6.55017747e-03f, 3.42949182e-02f, -9.29112732e-02f, 9.76849273e-02f, -6.19126186e-02f, -2.48177461e-02f,
  -4.98311631e-02f, -2.83094764e-01f, -1.76678225e-01f, -1.09439313e-01f, 2.42334139e-02f, 1.00653976e-01f, -7.72346649e-03f, -8.71006474e-02f, -5.44811599e-02f, -1.97351232e-01f,
  -6.38604164e-02f, -2.21337005e-01f, 4.93693948e-02f, -1.00767337e-01f, 1.38073400e-01f, 2.11840734e-01f, -3.49133858e-03f, -7.91169479e-02f, 1.09869100e-01f, 2.49359664e-02f,
  2.95986924e-02f, 7.53967464e-03f, 9.38121006e-02f, -2.02182997e-02f, 1.85403395e-02f, -1.76046282e-01f, -9.09568928e-03f, -6.86327601e-03f, 3.61432098e-02f, -9.02063213e-03f,
  3.10057122e-02f, -1.40321806e-01f, -5.62240556e-02f, -3.02702580e-02f, 2.45232843e-02f, 2.83293296e-02f, 6.35468168e-03f, -2.71923970e-02f, 1.71151187e-03f, -6.25420958e-02f,
  2.78723631e-02f, 2.79379310e-03f, -1.62295625e-02f, -3.97747476e-03f, 6.99062739e-03f, -1.08571656e-01f, -7.59175718e-02f, 5.00863194e-02f, -1.59773156e-02f, -8.05125982e-02f,
  -9.24181717e-04f, -2.50411760e-02f, -4.51035053e-02f, 6.06737286e-02f, -2.93580554e-02f, -1.52121475e-02f, 9.88215115e-03f, 1.38992695e-02f, 2.56958418e-02f, -3.80659029e-02f,
  -3.20438072e-02f, 4.03057262e-02f, 3.07750404e-02f, -2.96491086e-02f, -3.52630615e-02f, 6.50793612e-02f, -8.92813969e-03f, 8.77926052e-02f, -5.98669685e-02f, -3.10986582e-03f,
  5.25954999e-02f, -1.09005675e-01f, -1.39773684e-02f, -6.03935309e-02f, 3.27210650e-02f, -3.57501954e-02f, 9.01261419e-02f, -8.86373818e-02f, 4.08651903e-02f, 2.04896145e-02f,
  -5.74190356e-02f, 1.00699894e-01f, 1.89181902e-02f, -6.18900619e-02f, 8.93974379e-02f, 2.26627216e-02f, -6.40343428e-02f, -4.43170639e-03f, 2.34328303e-02f, -4.08071540e-02f,
  -6.26528729e-03f, -5.05509637e-02f, 4.30431515e-02f, -1.96155962e-02f, 2.25017546e-03f, -2.18501315e-02f, 6.95569441e-02f, -9.69281979e-03f, -1.27111590e-02f, 2.00271346e-02f,
  4.61292863e-02f, 1.15051921e-02f, 6.04611598e-02f, 1.03843607e-01f, 9.60153714e-02f, -2.59099361e-02f, 2.73517333e-02f, 3.14880721e-02f, -1.98629573e-02f, 1.78967323e-02f,
  -9.06355213e-03f, 6.86610416e-02f, -3.88922021e-02f, 1.22072235e-01f, 4.48908955e-02f, -4.84391563e-02f, -6.97115585e-02f, 1.17338812e-02f, 4.10332195e-02f, 9.28663611e-02f,
  -5.25713503e-01f, 5.45018800e-02f, -6.41640723e-02f, -1.85775846e-01f, -9.42251533e-02f, 2.59530455e-01f, 1.42850444e-01f, 2.36370303e-02f, 5.51882535e-02f, 4.12261821e-02f,
  3.69594134e-02f, -1.73660815e-02f, 7.60089383e-02f, 6.72138035e-02f, -1.19435810e-01f, 4.00041603e-02f, 1.33676082e-02f, 4.03627902e-02f, 4.71906411e-03f, -6.53823838e-02f,
  -6.68127090e-02f, 8.64594057e-03f, -5.08781224e-02f, 2.52865553e-02f, -2.35754289e-02f, -1.07355509e-02f, -1.18832458e-02f, -4.10868414e-03f, -5.86027913e-02f, 5.56507260e-02f,
  -9.62004289e-02f, 9.74167418e-03f, -1.86924208e-02f, -3.16295587e-02f, 5.80320060e-02f, 3.46809579e-03f, 2.65712081e-03f, -3.71335410e-02f, 2.63028778e-03f, -1.49377119e-02f,
  -5.72443521e-03f, -3.30356099e-02f, -6.85685053e-02f, -7.31417760e-02f, 1.13336872e-02f, -4.22318056e-02f, 6.37575835e-02f, 1.14111692e-01f, 5.57382256e-02f, -1.14896772e-02f,
  -3.99582908e-02f, 4.84480448e-02f, 7.67474575e-03f, 5.91102540e-02f, 3.60086896e-02f, -2.31064819e-02f, 5.13162576e-02f, -8.11794251e-02f, -4.07462604e-02f, -1.23415049e-02f,
  -2.40809843e-03f, -6.92631379e-02f, -6.60338625e-02f, 5.86612746e-02f, 4.20374833e-02f, 3.67781334e-02f, -5.22233034e-03f, -3.10289953e-02f, 2.18106643e-03f, -3.87323126e-02f,
  -2.87310891e-02f, 5.29775433e-02f, 1.28533021e-02f, 3.27514894e-02f, 5.99654112e-03f, -1.06537685e-01f, -7.69271106e-02f, 6.83125481e-03f, 3.76713532e-03f, 4.75232117e-02f,
  2.98399236e-02f, 6.37815967e-02f, -2.62905005e-02f, -3.67616862e-02f, 2.57499088e-02f, -3.69991884e-02f, 4.96031530e-02f, -1.76440757e-02f, 9.18158982e-03f, 6.87929839e-02f,
  4.46553640e-02f, 5.83191551e-02f, 1.82790365e-02f, 1.48002105e-02f, 7.29528666e-02f, -1.88304950e-02f, 1.55118201e-03f, 1.50981760e-02f, 7.34855086e-02f, -3.87986121e-03f,
  6.03278093e-02f, 2.54492625e-03f, -2.67645884e-02f, 3.04073393e-02f, 6.10432550e-02f, 4.71228845e-02f, 8.52487981e-02f, 2.44876556e-02f, -1.47982510e-02f, 4.76308465e-02f,
  -1.91325154e-02f, 2.09174890e-04f, 5.62564284e-02f, -2.69909017e-02f, 4.28164331e-03f, 2.20236205e-03f, -1.15623437e-02f, -8.38123038e-02f, 4.97613437e-02f, 2.01953705e-02f,
  2.61018515e-01f, -2.48433217e-01f, -1.73428699e-01f, -3.71047407e-02f, 2.14007534e-02f, -1.24230303e-01f, -7.11750835e-02f, -2.70041704e-01f, -1.86543390e-01f, -1.43060759e-01f,
  1.79913756e-03f, 1.90291047e-01f, -4.26023751e-02f, -1.08902529e-01f, 1.92075476e-01f, -1.30609512e-01f, -2.23933175e-01f, -2.34718509e-02f, -1.05598435e-01f, -6.23272322e-02f,
  -3.87575813e-02f, -4.41665528e-03f, -7.44630992e-02f, -2.18823195e-01f, -1.30006686e-01f, -1.24671627e-02f, 1.81115866e-01f, -7.53400475e-02f, 1.12263642e-01f, -2.32329518e-02f,
  -1.49626002e-01f, -7.02003986e-02f, 1.36544788e-02f, -5.31315878e-02f, -3.88618484e-02f, 3.56520265e-02f, -1.19259330e-02f, 4.48480472e-02f, -1.22727538e-02f, -3.66795845e-02f,
  6.65435046e-02f, 8.66972376e-03f, -4.47766669e-02f, 4.68182936e-02f, -9.63770300e-02f, -1.19344154e-02f, -8.64936188e-02f, -3.95425595e-02f, -8.31196159e-02f, 1.52288089e-02f,
  -1.26286864e-01f, 1.38524678e-02f, -2.31053475e-02f, 1.32776739e-03f, 3.65891419e-02f, -4.67444770e-02f, 2.81824768e-02f, 2.63098907e-03f, -7.87355155e-02f, -2.13861261e-02f,
  4.18162793e-02f, -2.85617914e-02f, -3.00750397e-02f, -5.78683661e-03f, -1.34549718e-02f, -9.41506401e-02f, 5.39088100e-02f, 5.57274222e-02f, -6.26462400e-02f, 4.21057045e-02f,
  5.66863380e-02f, 6.17703609e-02f, -5.97376302e-02f, 7.37412181e-03f, -4.89763282e-02f, 1.00690894e-01f, -1.01890173e-02f, -3.81151855e-04f, -7.92753324e-02f, 9.20084566e-02f,
  3.19629908e-02f, 1.18393302e-02f, -3.53562348e-02f, 3.36509272e-02f, -1.21841691e-01f, 3.41672823e-02f, 2.60092262e-02f, -6.56821653e-02f, 8.79621580e-02f, 1.02797285e-01f,
  -1.67716220e-02f, -1.42452806e-01f, -6.06881501e-03f, 9.76350438e-03f, 1.75370872e-02f, 8.59548301e-02f, -5.05103618e-02f, -5.68049550e-02f, 4.23325300e-02f, 1.85346417e-02f,
  -1.82352141e-02f, -2.21084226e-02f, 7.30326325e-02f, -5.10919988e-02f, 1.28661050e-02f, -6.73280582e-02f, 7.89779350e-02f, -4.71049398e-02f, 5.83365299e-02f, -6.61798045e-02f,
  6.32858253e-04f, -6.91105146e-03f, 4.25554849e-02f, -9.94801968e-02f, 4.08261195e-02f, 3.30509692e-02f, 2.08689533e-02f, -2.33856356e-03f, 3.81341130e-02f, -6.16061725e-02f,
  1.28375262e-01f, 7.13700131e-02f, 1.43329039e-01f, 1.29792675e-01f, 9.04805064e-02f, -1.08814389e-01f, -5.24513833e-02f, 1.67115211e-01f, 9.83375311e-02f, -1.29907519e-01f,
  -1.10479832e-01f, -8.24929848e-02f, -2.52662122e-01f, -2.67353915e-02f, -2.78327435e-01f, -1.20239131e-01f, 2.19171885e-02f, -9.83241722e-02f, 6.74352720e-02f, -3.02123893e-02f,
  1.32552043e-01f, 8.21857378e-02f, 6.90110773e-02f, 1.90549105e-01f, 1.72260776e-01f, 1.60779715e-01f, 4.86064814e-02f, 1.06888659e-01f, 8.99440646e-02f, -1.41608059e-01f,
  -8.78500193e-02f, -1.76051930e-02f, 7.75768533e-02f, -4.81479913e-02f, 3.82590219e-02f, 5.77542745e-02f, -1.65350437e-02f, -6.31036162e-02f, 4.39146236e-02f, -1.44913113e-02f,
  -4.44534607e-02f, -1.91157497e-02f, 5.19059822e-02f, 8.79809074e-03f, 9.71089397e-03f, 3.45153064e-02f, 4.49736230e-02f, 6.54805005e-02f, 3.17816809e-02f, 7.73900375e-02f,
  7.79766515e-02f, 8.95332098e-02f, 6.79275533e-03f, -6.94325045e-02f, 2.10854374e-02f, 5.10668159e-02f, 1.70335472e-02f, 3.60843493e-03f, -2.92265732e-02f, -1.31245404e-02f,
  2.62093488e-02f, 3.51748765e-02f, -7.28882384e-04f, 3.55638340e-02f, -2.98550222e-02f, 1.19311795e-01f, 1.81527454e-02f, -3.06826681e-02f, 3.74861099e-02f, -5.90875037e-02f,
  -5.54842986e-02f, -2.56324615e-02f, 2.79570627e-03f, -7.35794604e-02f, -4.83581387e-02f, 1.85166374e-02f, -3.99432071e-02f, -4.47009653e-02f, 5.93160316e-02f, -2.65154187e-02f,
  5.20980805e-02f, -9.18224230e-02f, 1.73653122e-02f, -1.35792028e-02f, -6.91954570e-04f, 5.96963568e-04f, 4.85211350e-02f, -2.89025940e-02f, 9.65677667e-03f, -2.84533557e-02f,
  -2.07000449e-01f, -1.05325565e-01f, -3.29837762e-02f, -1.14064908e-03f, -7.47576579e-02f, -1.00003339e-01f, 3.18204202e-02f, 2.26177946e-02f, -5.21320030e-02f, -1.08644376e-02f,
  -4.83513856e-03f, 1.75067466e-02f, -7.71617815e-02f, -7.71751488e-03f, -4.48835194e-02f, 9.64576006e-03f, -5.89117361e-03f, -6.27681240e-02f, 1.80971138e-02f, -4.11955938e-02f,
  -2.43909657e-02f, -1.13727944e-02f, -2.46425811e-02f, 7.35134333e-02f, -1.80607326e-02f, -3.73485275e-02f, 4.96891886e-02f, 1.44448457e-02f, 1.05739292e-03f, 5.71526922e-02f,
  -2.20828637e-01f, 2.59009600e-01f, 5.92000736e-03f, 2.56912231e-01f, -8.82772207e-02f, -7.65963122e-02f, -5.96980713e-02f, 1.07654206e-01f, -1.35788873e-01f, 1.59980625e-01f,
  -1.35631621e-01f, -6.13320731e-02f, -1.69017464e-01f, 1.11354217e-01f, -2.89195627e-01f, -1.10577814e-01f, -1.17957490e-02f, 3.09579968e-02f, 1.77683122e-02f, -6.73336908e-02f,
  8.59683454e-02f, 1.13825552e-01f, 2.01436039e-03f, 7.91548193e-02f, -3.33514921e-02f, 8.67327452e-02f, 1.00169098e-02f, -5.70020340e-02f, 1.42567217e-01f, 2.00036149e-02f,
  3.16381059e-03f, -6.48135599e-03f, 4.74279252e-04f, 2.50040903e-03f, -5.88326938e-02f, 1.71324443e-02f, 8.16091150e-02f, -4.54017818e-02f, 7.67699406e-02f, -1.98136251e-02f,
  -1.02155037e-01f, -5.25227860e-02f, 6.22463040e-03f, -6.32924736e-02f, -5.58570139e-02f, -3.60293761e-02f, 4.64187982e-03f, -4.51184921e-02f, 1.20707843e-02f, -8.77176374e-02f,
  -1.94199216e-02f, 6.96362602e-03f, 1.12038450e-02f, 2.15031747e-02f, 6.90999627e-03f, 2.69884765e-02f, 3.40597704e-02f, 5.14030941e-02f, -6.49772063e-02f, 8.51447880e-03f,
  -1.21387802e-01f, -5.19987307e-02f, 1.12992600e-02f, -8.24167505e-02f, -1.07424166e-02f, -8.69484767e-02f, -5.03296684e-03f, -4.19614427e-02f, -1.34746647e-02f, 3.62450406e-02f,
  7.12013021e-02f, -2.13120948e-03f, 6.66600317e-02f, 3.63446362e-02f, 6.05298392e-03f, 1.08798921e-01f, -1.10456310e-02f, 4.02674451e-02f, 4.45823893e-02f, 9.08243656e-03f,
  -4.06173840e-02f, 4.03453521e-02f, 3.39378752e-02f, -8.81131366e-03f, -4.18153517e-02f, -3.56945992e-02f, -1.63289942e-02f, -5.20386286e-02f, 8.32195505e-02f, -1.18253054e-02f,
  9.12996847e-03f, -1.74615346e-02f, 7.66514242e-02f, -5.79413176e-02f, 6.59507513e-02f, -2.69291680e-02f, -3.87021974e-02f, -3.30213867e-02f, -1.10368310e-02f, 8.43165070e-03f,
  1.57147776e-02f, 8.64606649e-02f, -1.36244325e-02f, 2.64412425e-02f, 1.59799363e-02f, -3.24533060e-02f, 2.84342617e-02f, -2.61064805e-02f, 1.97837148e-02f, 4.07850184e-03f,
  1.09867556e-02f, -5.02049513e-02f, -2.12564208e-02f, 4.52033579e-02f, -2.60140095e-02f, -5.45907654e-02f, -4.62444201e-02f, -4.15928178e-02f, 3.00471485e-02f, -7.38009140e-02f,
  3.50960016e-01f, -2.09848970e-01f, -2.20725715e-01f, -8.91557261e-02f, 8.86421278e-02f, -1.03891425e-01f, 8.79451819e-03f, -8.13132152e-02f, -2.80338794e-01f, -9.37122777e-02f,
  5.67651503e-02f, -9.01965052e-03f, 6.97112223e-03f, -1.06633469e-01f, 1.36833921e-01f, -4.34746817e-02f, -1.24160826e-01f, 2.29218472e-02f, -9.65107977e-02f, 6.36889637e-02f,
  -9.04748365e-02f, 1.04260407e-01f, -1.15789965e-01f, -3.60381007e-02f, 7.67375752e-02f, -6.48748726e-02f, 2.32350022e-01f, -9.25577059e-02f, 4.12654392e-02f, 1.06022000e-01f,
  1.06194437e-01f, -4.98986766e-02f, -6.20520338e-02f, -6.51976392e-02f, 6.24726564e-02f, 3.29146311e-02f, 8.34007338e-02f, -9.24880244e-03f, -4.02998962e-02f, 3.73385698e-02f,
  6.08444922e-02f, 5.54853901e-02f, -4.89959866e-02f, -1.14797115e-01f, -2.79227234e-02f, -1.35277957e-01f, 3.73738930e-02f, 3.66618633e-02f, -8.27802867e-02f, -6.15172461e-02f,
  -1.89129524e-02f, -1.80458762e-02f, -5.94037436e-02f, -2.91053802e-02f, -7.42539763e-03f, -5.04357815e-02f, -4.84971981e-03f, 9.70666260e-02f, 4.10362743e-02f, -9.37733240e-03f,
  -1.78600140e-02f, -6.61782324e-02f, -5.50340414e-02f, -9.94162075e-03f, -4.09376323e-02f, 7.46507719e-02f, 1.87951233e-02f, -1.95340365e-02f, 3.78846517e-03f, 4.85292040e-02f,
  5.49678877e-02f, 6.88394811e-03f, 5.33945486e-02f, -2.64576618e-02f, -3.26236822e-02f, -1.18843548e-03f, 4.64546382e-02f, 2.14377022e-03f, -1.75798114e-03f, 2.28751395e-02f,
  -1.40717160e-02f, -3.96264791e-02f, 3.00544836e-02f, -2.86910888e-02f, 5.78596964e-02f, -3.38323414e-03f, 3.75888348e-02f, -4.85755280e-02f, -1.20806508e-02f, 4.22601104e-02f,
  6.03632815e-02f, 2.15286762e-02f, 2.08836813e-02f, -5.18785678e-02f, -1.45996455e-02f, -6.54218346e-02f, -8.25311989e-02f, 2.25875247e-02f, -4.68968004e-02f, -2.24624295e-02f,
  -3.79935913e-02f, 4.89753373e-02f, 1.61200054e-02f, 6.52711391e-02f, 2.20690574e-02f, 3.34168551e-03f, -4.76500131e-02f, -1.23472037e-05f, 8.90381932e-02f, 2.72766538e-02f,
  3.72970738e-02f, 1.06462151e-01f, 8.97380337e-02f, 8.66040736e-02f, -1.71525776e-02f, 2.18844488e-02f, 5.40786274e-02f, -8.71771500e-02f, 2.82577965e-02f, -3.32428105e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.59801666e-02f, -1.69006083e-02f, -8.69410038e-02f, -1.45448834e-01f, -1.57447848e-02f, -1.73023671e-01f, -8.15075934e-02f, 3.51546854e-02f, -5.19810356e-02f, 1.11470073e-01f,
  2.41078287e-02f, -9.41851139e-02f, 2.50591803e-02f, -2.78459311e-01f, -3.85516942e-01f, -1.04385875e-01f, -1.96999013e-01f, -1.30089849e-01f, -1.18989736e-01f, 6.68156296e-02f,
  -1.06514640e-01f, -1.62464395e-01f, -3.20402652e-01f, 4.43850793e-02f, -1.79900061e-02f, 1.53953239e-01f, 1.69357136e-01f, 1.72787815e-01f, -9.47738290e-02f, -8.65944028e-02f,
  -9.04047936e-02f, 6.33779913e-02f, 3.61481495e-02f, -6.39386997e-02f, 5.00720693e-03f, 1.16066195e-01f, 4.07739282e-02f, -8.12366456e-02f, -7.69588128e-02f, -6.00775816e-02f,
  -3.53809111e-02f, -5.40602617e-02f, -2.47164667e-02f, -4.73950282e-02f, -1.58170389e-03f, -8.42448266e-04f, 2.27182321e-02f, -6.36649877e-02f, -5.37417755e-02f, -1.01176493e-01f,
  -1.15950219e-02f, -1.27311414e-02f, 2.48977449e-02f, -4.03662585e-02f, 6.80838674e-02f, 2.09816564e-02f, -7.41235092e-02f, -8.49438366e-03f, 1.15995534e-01f, -1.25586689e-01f,
  3.16336304e-02f, 1.05136909e-01f, 2.61748992e-02f, 4.80941422e-02f, -8.12309310e-02f, -5.84057830e-02f, 6.64700121e-02f, -5.38886115e-02f, -3.47246579e-03f, 3.62201314e-03f,
  7.98661113e-02f, -3.81633863e-02f, -3.62833287e-03f, 5.04057854e-02f, 8.86732191e-02f, 1.26055926e-01f, 1.47643406e-02f, -4.43904549e-02f, -1.12090722e-01f, -2.78518964e-02f,
  3.00827203e-03f, -1.24161150e-02f, -7.42174834e-02f, 1.24781944e-01f, -5.10872938e-02f, -3.12749334e-02f, -5.43887503e-02f, 7.12567195e-03f, 4.15783376e-02f, 4.09846529e-02f,
  8.04215968e-02f, 1.59643441e-01f, -5.75226955e-02f, -8.45609307e-02f, 6.48871958e-02f, -5.85566647e-02f, -1.83445625e-02f, -6.28387034e-02f, 7.88921211e-03f, 5.99515177e-02f,
  1.06276952e-01f, 7.37403259e-02f, 5.48846163e-02f, -2.65712198e-02f, -2.27961559e-02f, -4.72749025e-02f, 6.28896654e-02f, -1.47085721e-02f, 1.23917840e-01f, 6.15034774e-02f,
  1.55478373e-01f, -6.92623947e-03f, 3.50242713e-03f, -3.22983898e-02f, 5.21498807e-02f, 8.76993462e-02f, 9.10477247e-03f, -5.03752194e-02f, -1.10087516e-02f, -9.99834668e-03f,
  2.58903921e-01f, -2.18262732e-01f, -5.81715964e-02f, 1.05158642e-01f, 2.46386945e-01f, 9.96890739e-02f, 1.59341507e-02f, -2.14000721e-03f, -2.97426768e-02f, -1.52808070e-01f,
  -9.99673158e-02f, -2.02276975e-01f, -2.31782287e-01f, 3.08196303e-02f, 1.21599965e-01f, -2.33584076e-01f, 2.23025545e-01f, -3.75590026e-02f, -1.27138928e-01f, -2.06908107e-01f,
  -8.12123418e-02f, 1.43935546e-01f, -4.84388582e-02f, 1.69590130e-01f, 1.04027845e-01f, 3.24447230e-02f, 1.39822870e-01f, -4.62108776e-02f, 1.45171598e-01f, 2.34021805e-02f,
  9.34169367e-02f, -7.56111443e-02f, 3.61601897e-02f, -5.76845631e-02f, -1.33238593e-02f, 8.37729946e-02f, 5.48412045e-03f, 1.30810931e-01f, 3.53895202e-02f, -4.84098718e-02f,
  1.06902430e-02f, 9.54657793e-02f, 9.92194749e-03f, 1.93572622e-02f, 2.29116883e-02f, -2.04276312e-02f, -2.53400020e-02f, -8.36723372e-02f, 4.33687586e-03f, -1.42431527e-01f,
  -1.59722105e-01f, -1.42718051e-02f, -3.47350053e-02f, 1.04343139e-01f, -1.01304511e-02f, 5.95634170e-02f, -5.51941171e-02f, -9.31208879e-02f, -2.12574918e-02f, 6.72747642e-02f,
  -1.28463646e-02f, 7.57706687e-02f, -1.25337671e-02f, 5.35797365e-02f, 5.19198016e-04f, -1.71835795e-02f, 1.32616879e-02f, 6.25190213e-02f, 1.47203458e-02f, -7.31206536e-02f,
  -9.12003510e-04f, -1.38826657e-03f, 2.86205509e-03f, 2.36694161e-02f, 8.39812383e-02f, -2.19293442e-02f, -6.25835285e-02f, 3.89705691e-03f, -5.72063737e-02f, -7.36752376e-02f,
  7.06885532e-02f, -1.57105848e-02f, -9.83640403e-02f, 3.23744603e-02f, 4.35028970e-02f, -5.12732156e-02f, 5.63893728e-02f, -3.51215573e-03f, 2.00133957e-03f, 5.01440316e-02f,
  -8.92652273e-02f, -8.35463852e-02f, -8.36781561e-02f, 3.55575308e-02f, 1.11886370e-03f, 5.82256243e-02f, -2.41802502e-02f, 7.44798640e-03f, -1.85488209e-01f, 6.87010353e-03f,
  9.57640186e-02f, -2.16313154e-02f, -3.11240163e-02f, -9.78078507e-03f, 2.43904325e-03f, -1.48304060e-01f, 6.36659414e-02f, -3.40808509e-03f, -5.85903339e-02f, -2.00201552e-02f,
  5.94267845e-02f, -4.00419533e-02f, 1.56657631e-03f, 5.75223640e-02f, -6.71560410e-03f, 4.73484509e-02f, -2.70257946e-02f, -3.40152271e-02f, 4.64377441e-02f, -2.17537303e-02f,
  2.65527278e-01f, 1.97493564e-02f, -1.66226059e-01f, -3.60851996e-02f, 1.87842771e-02f, 1.69235364e-01f, 1.89031780e-01f, -2.67473310e-02f, 2.49389499e-01f, -9.35431048e-02f,
  4.93419096e-02f, 5.55020906e-02f, 6.17147870e-02f, 1.42461374e-01f, 8.59180093e-02f, 1.35097310e-01f, 2.04882175e-01f, 1.24111488e-01f, 9.10556018e-02f, 1.67937756e-01f,
  6.74823821e-02f, 1.91116817e-02f, -2.74859935e-01f, -2.18594223e-01f, -2.08497912e-01f, -2.17177451e-01f, -2.29649231e-01f, -1.30794525e-01f, -2.46160284e-01f, -3.86983007e-02f,
  7.28268847e-02f, 9.49464440e-02f, 5.49157038e-02f, 1.01218574e-01f, 2.96201929e-02f, -4.55580764e-02f, -1.18463643e-01f, -9.95848253e-02f, 6.45458549e-02f, 3.48572643e-03f,
  6.17514141e-02f, -7.74979293e-02f, 8.53403285e-02f, -5.37065975e-02f, 6.12628832e-02f, -2.12672818e-02f, 2.04041158e-03f, -1.35186780e-02f, -6.99148998e-02f, 3.16690989e-02f,
  8.75819381e-03f, 3.34106646e-02f, 7.68715143e-02f, -7.06062168e-02f, -3.19686942e-02f, 1.65569726e-02f, 3.08417063e-02f, -3.60306278e-02f, -5.57397418e-02f, 2.66845478e-03f,
  -1.04810158e-02f, -3.59459482e-02f, 4.87797940e-03f, 2.38609798e-02f, 2.11849324e-02f, -1.11484647e-01f, -2.23470647e-02f, 1.50530674e-02f, 4.62087579e-02f, 3.43505293e-02f,
  -6.20294129e-03f, 2.21388577e-03f, 3.40185389e-02f, 4.16560918e-02f, 3.53969657e-03f, 2.26433505e-03f, -2.75429506e-02f, 2.18496956e-02f, 7.38291070e-03f, -7.07850829e-02f,
  -1.16537370e-01f, 8.03279877e-02f, -8.90837461e-02f, -6.80951402e-02f, -1.15948291e-02f, -3.93969528e-02f, 3.75248631e-03f, -2.31697783e-02f, 2.48728245e-02f, -2.80260127e-02f,
  1.53617263e-01f, 1.42426386e-01f, 7.71455169e-02f, -1.99094438e-03f, -6.04112484e-02f, -1.35466410e-02f, 1.83098428e-02f, -2.26482376e-02f, 1.25467792e-01f, 6.42601848e-02f,
  9.20268800e-03f, -6.18712557e-03f, 5.24461642e-02f, -4.89621423e-02f, -3.04110143e-02f, 3.30986059e-03f, 6.90885037e-02f, -5.09111732e-02f, -2.01296620e-02f, -1.69250220e-02f,
  -7.09403083e-02f, 1.78622492e-02f, -3.35277966e-03f, -3.00114732e-02f, 1.62487105e-02f, -4.32888232e-03f, 5.39595746e-02f, -2.62909178e-02f, 2.07003895e-02f, 6.12951927e-02f,
  2.57077068e-01f, 1.78645700e-01f, 1.47540912e-01f, 1.13609895e-01f, -2.38310814e-01f, -1.66173086e-01f, -4.46537435e-02f, 1.03774652e-01f, 1.29314870e-01f, -3.11985053e-02f,
  -1.71554200e-02f, 7.30569661e-02f, 6.54164106e-02f, 2.46578325e-02f, 1.55501580e-02f, 4.85188030e-02f, 1.23852633e-01f, -4.68208939e-02f, 6.06690580e-03f, 7.80518204e-02f,
  2.03431159e-01f, 3.60984020e-02f, 1.79901183e-01f, 4.12503891e-02f, 3.29871066e-02f, 6.86007217e-02f, 2.81860922e-02f, -8.61598328e-02f, 1.47511244e-01f, -7.77831748e-02f,
  -2.66060568e-02f, 9.99500528e-02f, -9.44450125e-03f, -5.05953580e-02f, 6.99322000e-02f, -8.95726606e-02f, -7.41150528e-02f, -9.97691303e-02f, -7.80544952e-02f, 8.34024400e-02f,
  7.53691420e-02f, 5.78254089e-02f, -1.45203155e-02f, -9.51470574e-04f, -3.79941473e-03f, -3.05099948e-03f, 3.85143608e-02f, -5.06407395e-02f, 4.52985652e-02f, -9.48135182e-03f,
  -8.22002143e-02f, 5.86080626e-02f, -4.64527756e-02f, -1.61566660e-01f, 4.25479487e-02f, -4.84721139e-02f, -7.99472407e-02f, -3.40306759e-02f, -8.45442154e-03f, 2.17035972e-02f,
  1.35507077e-01f, -8.69321898e-02f, 1.80586185e-02f, -1.80614758e-02f, -4.93467301e-02f, -5.21324128e-02f, -4.61953618e-02f, -3.82751948e-03f, 1.84934307e-02f, -3.86890247e-02f,
  -1.56175531e-02f, -3.06932554e-02f, 1.34953726e-02f, 2.47850306e-02f, -3.09196729e-02f, -9.50777158e-02f, 8.10559781e-04f, -7.60485046e-03f, 1.06403474e-02f, 2.58005783e-03f,
  -4.55095172e-02f, 4.51755337e-02f, 8.92262608e-02f, 6.06636629e-02f, -1.04602158e-01f, -3.08460984e-02f, 1.35542572e-01f, 5.78273311e-02f, -1.81485936e-02f, 1.01614051e-01f,
  -1.72393546e-02f, 1.38461962e-01f, 6.80580810e-02f, -4.59291674e-02f, -3.67179848e-02f, -6.82601109e-02f, -1.19031779e-01f, 1.11876644e-01f, 4.23158593e-02f, 2.86997538e-02f,
  -1.54992016e-02f, -1.11255430e-01f, -6.24389723e-02f, 9.31097791e-02f, 7.87949115e-02f, 1.21274572e-02f, -3.65522057e-02f, -7.96191916e-02f, -9.12093595e-02f, 5.12746237e-02f,
  -4.80723456e-02f, -6.75534829e-03f, -9.67821479e-02f, -1.07395433e-01f, -4.33513522e-02f, -2.48332415e-02f, 1.03451302e-02f, 8.28722864e-02f, -9.17048287e-03f, -5.64774722e-02f,
  1.43056870e-01f, -1.07944816e-01f, -2.87661105e-01f, 1.20402947e-01f, -1.44443855e-01f, -2.96311881e-02f, 8.14720020e-02f, -2.01972947e-02f, -9.68548432e-02f, 9.69425291e-02f,
  1.84141651e-01f, -2.03400701e-02f, -1.50162121e-02f, 3.61605138e-01f, 1.73937708e-01f, 1.29775017e-01f, 1.54424235e-01f, 1.75112292e-01f, -5.16332537e-02f, 1.32386655e-01f,
  1.59496427e-01f, 3.22399706e-01f, 1.05130427e-01f, 1.56003147e-01f, 9.08906683e-02f, -1.59377784e-01f, 8.26052651e-02f, -1.47696480e-01f, 2.45998666e-01f, -7.19714351e-03f,
  2.52293386e-02f, -3.64461765e-02f, -1.49575034e-02f, 2.46197227e-02f, -6.17138259e-02f, -3.29313427e-02f, 8.27828795e-03f, 1.71745233e-02f, -1.09839134e-01f, 1.18377265e-02f,
  -1.21610515e-01f, -1.45743312e-02f, -1.12539036e-02f, 7.79643953e-02f, 8.71216506e-03f, -4.44888882e-02f, -1.85294077e-04f, 2.33845925e-03f, 3.31056193e-02f, -2.70546041e-02f,
  -2.46048477e-02f, 3.89530547e-02f, -2.44386122e-02f, 1.54260388e-02f, -6.60299696e-03f, 2.01079473e-02f, -2.17271410e-03f, -5.28897084e-02f, -1.07336007e-01f, -6.23883381e-02f,
  -9.33610648e-03f, 4.32197787e-02f, 9.49904546e-02f, -2.00342555e-02f, 1.10751484e-02f, 7.73920268e-02f, 8.25900361e-02f, -4.33536991e-02f, -1.16599955e-01f, 1.35375947e-01f,
  7.88137615e-02f, -1.59077742e-03f, 4.52237815e-04f, -4.50835377e-02f, 1.04280010e-01f, 2.41289800e-03f, -2.15112418e-02f, 6.37712106e-02f, 2.82571273e-05f, -5.87029159e-02f,
  -9.79204196e-03f, 6.27904236e-02f, -4.29923879e-03f, -1.93232819e-02f, 6.82439003e-03f, -3.57047580e-02f, 7.05476999e-02f, 6.58110902e-02f, 2.75192279e-02f, -7.84753263e-02f,
  8.12621862e-02f, 2.11029667e-02f, -1.02861069e-01f, 4.93212491e-02f, -8.79265219e-02f, 8.08484778e-02f, -7.61056095e-02f, -6.51523471e-02f, 2.51801917e-03f, -8.26903135e-02f,
  -9.34052616e-02f, 3.33409943e-02f, -2.13219947e-03f, 5.54485573e-03f, 6.58369809e-02f, 3.61421099e-03f, 5.65840043e-02f, -1.67878848e-02f, -6.76297918e-02f, 5.32016940e-02f,
  -7.59182423e-02f, -8.75675157e-02f, -6.38222098e-02f, -8.03692490e-02f, 4.67928387e-02f, 3.38459238e-02f, -9.10540521e-02f, -6.47738129e-02f, -2.40241159e-02f, 4.46908772e-02f,
  6.16284572e-02f, 1.14857114e-03f, -2.83245623e-01f, -1.06246062e-01f, -1.47334114e-01f, -2.73935109e-01f, -2.71729350e-01f, 3.29256826e-03f, 7.40410164e-02f, 4.33210954e-02f,
  1.62543267e-01f, 8.27917159e-02f, 1.22984044e-01f, -1.33455038e-01f, -9.32550877e-02f, 5.69445826e-02f, -1.74691811e-01f, -1.74000636e-01f, -4.39934917e-02f, -1.51887313e-01f,
  -7.22192600e-02f, -4.56407815e-02f, -1.87267035e-01f, 5.79112507e-02f, -1.55455798e-01f, -5.74162900e-02f, -5.31878322e-02f, -1.91633236e-02f, -1.36276260e-01f, -6.16121255e-02f,
  1.57931037e-02f, 6.01736382e-02f, 5.84682636e-02f, -3.96637134e-02f, -1.25801846e-01f, -1.07457832e-01f, -1.06371045e-01f, 2.80770436e-02f, -7.47177303e-02f, 3.97868194e-02f,
  7.26983026e-02f, 8.44295844e-02f, 1.01114791e-02f, -5.87542728e-02f, 4.56916913e-02f, -8.19589496e-02f, -1.54525228e-02f, 1.15554419e-03f, 4.17639222e-03f, 1.80216432e-02f,
  -1.31232351e-01f, 3.16810347e-02f, -1.63654879e-01f, 6.92076236e-02f, -7.55792335e-02f, -6.11635484e-02f, 5.76410927e-02f, 2.53588408e-02f, -6.54683867e-03f, -9.45768878e-03f,
  -3.42113487e-02f, -7.06000775e-02f, 2.76945047e-02f, -6.22247607e-02f, -4.70948964e-02f, -2.74640555e-03f, -2.25079004e-02f, -2.83744447e-02f, -1.38039514e-01f, -5.22409752e-02f,
  -7.67652094e-02f, -2.08968818e-02f, 8.91767368e-02f, -4.92618186e-03f, -9.33607575e-03f, -1.42226210e-02f, 5.48095768e-03f, 4.87618409e-02f, -1.13336734e-01f, -3.40434946e-02f,
  1.04371794e-01f, -4.29586470e-02f, 6.71040341e-02f, -5.92846461e-02f, -5.73223978e-02f, 2.29736380e-02f, -6.26279116e-02f, -1.46956267e-02f, 1.02087595e-01f, 2.26082443e-03f,
  6.52664676e-02f, 2.78997011e-02f, -3.12838703e-02f, 1.50497863e-02f, 7.45508149e-02f, -4.50787283e-02f, 3.93082388e-02f, -8.98392126e-02f, -5.73319420e-02f, 2.58215349e-02f,
  -8.07290077e-02f, -1.33310361e-02f, -1.28366560e-01f, 7.96191767e-03f, -7.30339810e-02f, -1.27277095e-02f, 6.44281954e-02f, 3.96862738e-02f, -9.46450010e-02f, -9.39513817e-02f,
  -1.12536037e-02f, -5.58949336e-02f, 4.57745837e-03f, -4.67157252e-02f, -5.47776669e-02f, 7.17394501e-02f, 1.68096796e-02f, -1.13029070e-01f, 4.12826566e-03f, 5.96484803e-02f,
  -2.71233678e-01f, 1.55233696e-01f, -3.00604641e-01f, -2.92908996e-01f, -8.33321884e-02f, -2.96523452e-01f, -2.15332106e-01f, -1.42387897e-01f, -9.07853842e-02f, -1.40592242e-02f,
  -1.05965681e-01f, -4.79834639e-02f, 7.42614344e-02f, 2.82496260e-03f, 4.17606086e-02f, 3.18157673e-01f, -1.55259475e-01f, -1.29366234e-01f, 7.09726363e-02f, -3.79796922e-02f,
  8.93858224e-02f, 4.36656326e-02f, 1.06235318e-01f, 2.34738700e-02f, -2.12519720e-01f, -2.17152108e-02f, -2.97455397e-02f, -3.93180884e-02f, -2.11741611e-01f, -4.31506373e-02f,
  -1.87177226e-01f, -3.12557608e-01f, -5.92843480e-02f, -1.42904684e-01f, -2.16895521e-01f, -6.69980943e-02f, -7.52735734e-02f, -4.07409742e-02f, 4.84811924e-02f, 1.38628241e-02f,
  -1.38839269e-02f, -7.08344206e-03f, -8.78333449e-02f, -3.93615710e-03f, -1.20695364e-02f, -9.51615572e-02f, 9.07288119e-02f, 1.77579243e-02f, -1.55807529e-02f, -4.56554517e-02f,
  -2.09186319e-02f, 6.93552149e-03f, -8.08900669e-02f, -1.24738263e-02f, -2.59451866e-02f, -5.20972311e-02f, 2.52744630e-02f, 5.53074479e-02f, -1.62941366e-02f, -4.70281541e-02f,
  1.15165571e-02f, -6.67109201e-03f, -6.70454726e-02f, 9.05224681e-02f, -2.50250716e-02f, 6.08858392e-02f, -8.85988250e-02f, 2.79043578e-02f, 8.47682208e-02f, 4.52365279e-02f,
  1.02104805e-02f, -4.55343239e-02f, -9.46310069e-03f, 8.64758343e-02f, 1.78535096e-02f, -1.19072646e-02f, -9.19337496e-02f, 1.55517440e-02f, 4.21228111e-02f, -4.27433429e-03f,
  4.95131426e-02f, -3.73984426e-02f, -2.65837424e-02f, 2.44052075e-02f, 2.14749649e-02f, -2.34631952e-02f, 3.65661643e-02f, -7.75027275e-03f, 8.63885321e-03f, -5.34367934e-02f,
  -1.14675730e-01f, -3.96162212e-01f, -4.49596234e-02f, -4.24921587e-02f, -9.60943289e-03f, 2.01451760e-02f, 3.85281853e-02f, 5.51361814e-02f, -1.20382831e-01f, -7.95525089e-02f,
  -5.34065142e-02f, 1.43296588e-02f, -2.32115388e-02f, 3.13121788e-02f, 7.76479840e-02f, 6.73605055e-02f, -7.08678141e-02f, -3.59942988e-02f, -4.07044441e-02f, 3.73586640e-02f,
  7.11525977e-03f, 3.86375785e-02f, 1.40338130e-02f, -4.22677286e-02f, 6.13762513e-02f, -6.17668815e-02f, -7.70269856e-02f, 5.36572263e-02f, -1.00704260e-01f, -3.34336683e-02f,
  -1.98740978e-02f, 1.77360401e-01f, -1.06906295e-01f, 7.85217658e-02f, -7.63632879e-02f, 5.27933054e-02f, 1.47287995e-01f, -5.39104007e-02f, -1.49969742e-01f, 2.42235750e-01f,
  3.71812172e-02f, -8.68660882e-02f, -2.88757458e-02f, 1.93822831e-01f, -1.82823256e-01f, -5.55755422e-02f, 3.02743942e-01f, 1.68116525e-01f, -3.68191414e-02f, -3.36609557e-02f,
  -1.13284841e-01f, 1.09618679e-01f, -2.00251132e-01f, -9.06763896e-02f, -5.41874766e-02f, -9.84170064e-02f, 6.93370849e-02f, -1.39083818e-01f, 1.90704286e-01f, 7.76638836e-03f,
  9.47620869e-02f, 5.54829873e-02f, 2.41208971e-02f, 9.64845344e-03f, -4.50643264e-02f, 2.65405625e-02f, 9.29982886e-02f, 1.49520859e-02f, -4.96966802e-02f, 2.78173648e-02f,
  1.18367903e-01f, -6.59825355e-02f, 1.81795843e-02f, -1.19518295e-01f, -1.24185488e-01f, -1.13751307e-01f, 2.25762441e-03f, -7.24989921e-02f, -4.80658226e-02f, 4.48503904e-02f,
  3.32580283e-02f, 5.92813715e-02f, -2.66895033e-02f, -5.50526232e-02f, -5.58314472e-02f, -6.74966499e-02f, -6.95827156e-02f, -6.45593330e-02f, 8.18219483e-02f, 2.28191866e-03f,
  1.15899391e-01f, -3.10150138e-03f, 1.15582012e-01f, 7.09205866e-02f, -7.30836689e-02f, 2.15904098e-02f, 1.27697142e-03f, 2.33835112e-02f, 6.04133820e-03f, -1.11033849e-01f,
  5.89215495e-02f, 2.90254895e-02f, -7.91465025e-03f, -8.25883180e-04f, 8.51880684e-02f, -2.14211345e-02f, -3.74458171e-02f, 3.21659744e-02f, 3.42056863e-02f, 4.70066257e-02f,
  -3.72583456e-02f, -2.59091929e-02f, -1.18552689e-02f, 1.32782131e-01f, 6.20981818e-03f, -8.77723098e-02f, 9.36052855e-03f, -4.25784662e-02f, -5.33398315e-02f, 9.60045755e-02f,
  3.70129757e-02f, 3.78132500e-02f, 1.97950155e-02f, -3.61602306e-02f, -4.62076180e-02f, 8.77129883e-02f, 3.99006680e-02f, 1.42542899e-01f, 5.84236979e-02f, -5.80278635e-02f,
  1.32626012e-01f, -9.23899040e-02f, 8.50292146e-02f, -7.40656480e-02f, -2.21850281e-03f, 2.20808312e-02f, -7.21497536e-02f, 4.35713166e-03f, 1.25858083e-03f, -3.76034565e-02f,
  -6.53271899e-02f, 1.30412318e-02f, 8.67838189e-02f, 3.46976779e-02f, 8.31654072e-02f, -3.44296428e-03f, -1.03602760e-01f, -1.68205313e-02f, 1.86498374e-01f, 8.49685259e-03f,
  2.82980859e-01f, 3.90644312e-01f, 1.87386543e-01f, 2.40951508e-01f, -1.68481901e-01f, -2.24406853e-01f, -1.02030240e-01f, 4.00324240e-02f, 2.21133810e-02f, 4.63339873e-02f,
  -1.08156696e-01f, 2.68117219e-01f, 8.16973019e-03f, 1.18821368e-01f, -7.27561638e-02f, -1.33750796e-01f, -1.01900306e-02f, -6.12424500e-02f, -6.01871684e-02f, 7.78971985e-02f,
  1.90409254e-02f, -8.31194818e-02f, 1.82008281e-01f, -3.27099115e-02f, 1.14210010e-01f, 1.13338724e-01f, 1.65487044e-02f, -5.37034124e-04f, 1.73679188e-01f, -2.75525972e-02f,
  -1.37801066e-01f, 7.44839236e-02f, 1.27751037e-01f, 3.99966948e-02f, 4.83280942e-02f, 5.85170090e-02f, 1.29324794e-01f, 4.39662673e-03f, -9.45207700e-02f, -2.32795030e-02f,
  1.05643086e-01f, 2.32523791e-02f, 7.69385993e-02f, -1.07475348e-01f, 1.49730034e-02f, -6.76423088e-02f, 1.02796415e-02f, 7.19070509e-02f, 1.09067082e-01f, 8.55833218e-02f,
  1.02900483e-01f, 9.86023620e-02f, 1.33746877e-01f, 8.20913464e-02f, 5.95943965e-02f, 6.37918562e-02f, 1.59194198e-04f, 7.38154911e-03f, -4.59375372e-03f, 4.98239547e-02f,
  1.29574046e-01f, -9.59690511e-02f, -7.41736740e-02f, -1.55910747e-02f, 4.54054587e-02f, -8.09801519e-02f, -6.39945790e-02f, -2.43202187e-02f, -8.49361122e-02f, -7.82719553e-02f,
  3.98759171e-02f, 5.13739772e-02f, 2.10108534e-02f, 6.18973095e-03f, -3.94834112e-03f, -1.87501870e-02f, 4.07203697e-02f, -2.62628272e-02f, 6.46405518e-02f, 5.31273312e-04f,
  -6.04390316e-02f, -6.44734427e-02f, -3.49722281e-02f, -7.82787427e-02f, -2.18843035e-02f, 8.48701969e-03f, -4.51519825e-02f, 3.48529406e-02f, 7.41428370e-03f, -1.08192004e-02f,
  -1.56790074e-02f, 1.82772905e-01f, -1.85596722e-03f, 1.50342630e-02f, -8.00467655e-02f, -7.86067769e-02f, -6.97024018e-02f, 9.76679847e-02f, 9.01215672e-02f, 3.52150090e-02f,
  4.18233648e-02f, -4.08710577e-02f, -2.07652468e-02f, 1.21037560e-02f, -1.51695521e-03f, 1.70279201e-02f, 9.72854123e-02f, 1.09406516e-01f, 6.19935840e-02f, 3.51335071e-02f,
  3.19303684e-02f, 4.49227635e-03f, 7.32828975e-02f, 9.73110199e-02f, -5.41935209e-03f, 5.71703538e-02f, -8.17276984e-02f, 7.85209704e-03f, -2.52756495e-02f, -4.53625135e-02f,
  3.61355231e-03f, -1.50548697e-01f, -2.61900008e-01f, -1.03479527e-01f, 1.48978531e-01f, -2.55650487e-02f, -1.41389579e-01f, 2.52850410e-02f, -1.74299583e-01f, 1.16368376e-01f,
  -2.07738038e-02f, -7.97617212e-02f, -1.00670204e-01f, -8.05448294e-02f, -3.62097695e-02f, -2.07689136e-01f, -4.89727668e-02f, -8.03995654e-02f, -1.19515643e-01f, 1.44647673e-01f,
  -2.09687948e-02f, 1.53337568e-01f, -9.16708410e-02f, 1.19409114e-01f, 8.01299363e-02f, 3.21489945e-02f, 2.15684727e-01f, 1.03094019e-01f, 1.63068891e-01f, 5.97284921e-03f,
  -4.24125697e-03f, -1.40822083e-02f, -7.59610459e-02f, -1.46568744e-02f, 8.60191733e-02f, 1.62740141e-01f, 5.95369823e-02f, 3.70512754e-02f, -3.93906832e-02f, -1.57250166e-02f,
  4.35536727e-03f, -1.94201693e-02f, -1.05397411e-01f, 8.52427334e-02f, -3.22392955e-02f, 6.34151278e-03f, -8.75825807e-02f, -5.01969121e-02f, 6.15260424e-03f, -8.95123556e-03f,
  -8.91454071e-02f, 2.81019285e-02f, -7.23351017e-02f, -1.03508219e-01f, -3.47231776e-02f, -4.18066382e-02f, -5.59914410e-02f, 1.17961429e-01f, -8.08869153e-02f, 2.91435272e-02f,
  6.00948110e-02f, -3.49785686e-02f, -9.99661833e-02f, -1.60380349e-01f, -4.09533158e-02f, 1.14055425e-02f, -9.37834159e-02f, 5.39011741e-03f, 1.46683501e-02f, -5.56475949e-03f,
  -4.26968150e-02f, -4.01122384e-02f, 3.36356536e-02f, 6.63662404e-02f, 2.26005889e-03f, -6.24446198e-02f, -2.98875514e-02f, 6.24300130e-02f, 5.59343137e-02f, -8.36179480e-02f,
  -4.87162359e-02f, -6.82419688e-02f, 8.35536867e-02f, -2.55198907e-02f, -5.05988784e-02f, 9.59119126e-02f, 6.63647577e-02f, 5.18822065e-03f, -1.36998417e-02f, -7.92744458e-02f,
  1.09379865e-01f, 1.08182997e-01f, -1.06290297e-03f, -1.10628456e-02f, -3.13150920e-02f, 7.01441765e-02f, 9.39011388e-03f, 3.49226557e-02f, 7.38558918e-02f, 5.41285127e-02f,
  1.14421859e-01f, -6.70058280e-02f, 6.07482195e-02f, -1.58643462e-02f, -7.27951303e-02f, 4.28116247e-02f, 6.55458570e-02f, 9.12087187e-02f, 5.85443825e-02f, 9.64403432e-03f,
  6.38190284e-02f, 8.54512751e-02f, -8.72563124e-02f, 2.34835502e-02f, -9.58755054e-03f, 1.25465617e-01f, -1.51216686e-02f, 1.69609949e-01f, -5.39200492e-02f, -9.39765573e-02f,
  1.38084531e-01f, -2.06260964e-01f, -1.27374619e-01f, 1.68535158e-01f, 4.72224802e-02f, -1.88781843e-01f, -2.27315292e-01f, 9.93809327e-02f, -1.69772193e-01f, -1.33578062e-01f,
  -3.19523811e-02f, -1.31735370e-01f, -1.50773838e-01f, 1.31746367e-01f, 2.06960216e-01f, -2.17669919e-01f, 6.72729537e-02f, -1.02499928e-02f, -8.87923986e-02f, -2.55737472e-02f,
  8.76264423e-02f, 1.40277207e-01f, 2.58906275e-01f, 2.40139693e-01f, 2.34397454e-03f, 8.85696486e-02f, 2.67758816e-01f, 1.83075089e-02f, 2.00238898e-01f, 1.71516061e-01f,
  -3.52619886e-02f, -1.10974066e-01f, 3.34742339e-03f, -1.00614671e-02f, -1.56455045e-03f, -4.81863208e-02f, 4.59729973e-03f, 2.92892214e-02f, 6.84610754e-02f, -1.12309847e-02f,
  -1.30329773e-01f, 1.41460188e-02f, -2.17284765e-02f, 1.11799859e-01f, 7.49694183e-02f, 3.75136472e-02f, -7.68780261e-02f, 1.95979644e-02f, -8.42666551e-02f, 1.54332519e-02f,
  -1.29785940e-01f, 4.84306626e-02f, 6.56149909e-03f, 7.44999871e-02f, 2.99935229e-04f, 1.79120935e-02f, -4.04144935e-02f, -1.19016906e-02f, 7.26434542e-03f, -5.49109392e-02f,
  -5.82293719e-02f, -1.71106607e-02f, -3.97104323e-02f, 4.01544496e-02f, 1.57284662e-02f, 5.01816459e-02f, 5.91790006e-02f, -9.10878275e-03f, -2.98940819e-02f, -2.29293481e-02f,
  3.91511172e-02f, 1.95648205e-02f, -7.72688817e-03f, 3.12504806e-02f, 3.71190384e-02f, -6.81680366e-02f, -7.30284899e-02f, -4.54706000e-03f, 3.75033170e-02f, 5.96722737e-02f,
  5.15268976e-03f, 7.97080845e-02f, -5.26462384e-02f, 7.18352273e-02f, 4.18304875e-02f, 5.95751926e-02f, 4.32543568e-02f, -7.68652707e-02f, 1.29703349e-02f, -6.28364161e-02f,
  5.93422651e-02f, -1.63625535e-02f, -2.24155746e-02f, 2.90359855e-02f, -7.88046569e-02f, -1.15581796e-01f, 1.58040933e-02f, -1.03143072e-02f, 1.02805413e-01f, 3.62475887e-02f,
  6.03235178e-02f, 6.30227253e-02f, 5.66582903e-02f, 1.71875842e-02f, 7.56311268e-02f, 2.59059854e-02f, -3.84198315e-02f, 3.23992968e-02f, 5.78300692e-02f, 1.08960345e-02f,
  -7.61628523e-03f, -4.12325226e-02f, 3.45392972e-02f, -4.16402332e-02f, 6.90999627e-02f, -1.09891318e-01f, -4.70396429e-02f, 1.17366515e-01f, 5.97669296e-02f, -1.01736240e-01f,
  -1.44305974e-01f, 1.38866246e-01f, -1.52003719e-02f, -1.54761031e-01f, 2.31385604e-02f, -2.95388877e-01f, -2.56550401e-01f, 5.04011400e-02f, 9.12902225e-03f, 1.22102149e-01f,
  -5.19324243e-02f, 2.67173171e-01f, -8.68425071e-02f, -1.20484918e-01f, -3.17879945e-01f, -2.57805496e-01f, -3.49338859e-01f, -9.03811380e-02f, 2.98592988e-02f, -1.26132682e-01f,
  -1.38174430e-01f, -1.40968606e-01f, -2.99542606e-01f, 6.26364350e-02f, -6.31495193e-02f, 1.14895858e-01f, -5.91473095e-02f, 5.74523695e-02f, -4.58594263e-02f, 7.16183484e-02f,
  -1.39305508e-02f, 1.83224052e-01f, 1.31136104e-01f, 3.43565531e-02f, -1.43281057e-01f, 3.87995616e-02f, -1.54939666e-02f, 4.42363843e-02f, -1.55736262e-03f, -6.84030727e-02f,
  9.90114659e-02f, -5.38561158e-02f, 3.59273590e-02f, 1.01572767e-01f, 5.49481586e-02f, 8.93259421e-02f, -1.14228083e-02f, 1.03258332e-02f, 8.36667269e-02f, -3.39274928e-02f,
  -3.02603040e-02f, -2.08765268e-02f, -1.06383428e-01f, -1.84732452e-02f, -5.34269921e-02f, -3.15560848e-02f, -2.34479066e-02f, -8.94844159e-03f, -3.52135375e-02f, -1.00479349e-02f,
  -3.62030789e-02f, -2.83920392e-02f, -3.85317095e-02f, -4.26991954e-02f, 3.12402137e-02f, 5.91286942e-02f, -2.87725907e-02f, 1.13225527e-01f, 2.08173003e-02f, -5.10763898e-02f,
  -1.16376579e-02f, -9.79613978e-03f, 4.02272046e-02f, -8.23765025e-02f, 4.29589348e-03f, -9.64724123e-02f, -3.04652303e-02f, 2.77047940e-02f, -9.29207653e-02f, 3.18025723e-02f,
  9.16199982e-02f, 7.92813152e-02f, 1.02080807e-01f, -1.28395543e-01f, -7.19978511e-02f, -3.86694297e-02f, 1.72683727e-02f, -4.18697149e-02f, -3.16337980e-02f, -9.76302251e-02f,
  -9.67714489e-02f, -4.11761999e-02f, 2.15305239e-02f, 6.91048205e-02f, -3.45822424e-02f, -7.61795938e-02f, -1.25027955e-01f, 2.88813915e-02f, -7.82624558e-02f, -3.91982310e-02f,
  1.92720070e-02f, -6.85780421e-02f, 8.67341757e-02f, -2.19168924e-02f, -1.41553888e-02f, 2.20276490e-02f, -1.00156598e-01f, 8.34955573e-02f, -3.25688347e-02f, 3.51320989e-02f,
  5.53639140e-03f, 8.42409581e-02f, -2.99958140e-02f, -3.42887593e-03f, -1.08056247e-01f, -6.28956556e-02f, 7.57973001e-04f, 8.43168348e-02f, 2.57343389e-02f, 3.18139642e-02f,
  4.45657521e-02f, 1.20887123e-01f, 1.94013223e-01f, 1.90138951e-01f, -1.90353736e-01f, -4.03652728e-01f, -1.88877970e-01f, 4.68385518e-02f, 4.64445585e-03f, -6.69328868e-02f,
  1.30064860e-01f, -3.16824540e-02f, 6.22924243e-04f, 1.17598101e-01f, 1.64391175e-01f, 4.88036908e-02f, 1.23928882e-01f, -1.13560036e-01f, 1.38654098e-01f, 1.49825186e-01f,
  1.88405424e-01f, 9.67283547e-02f, 2.49247238e-01f, 1.13223888e-01f, 7.22526619e-03f, 8.15894976e-02f, 1.96760997e-01f, 2.12953473e-03f, 1.44268602e-01f, -1.45051569e-01f,
  -1.33506536e-01f, 4.33463641e-02f, 2.28441022e-02f, -1.23095132e-01f, -3.54112461e-02f, -6.17868342e-02f, -1.56501110e-03f, -2.49240343e-02f, 2.69684698e-02f, -4.39259373e-02f,
  -1.42050132e-01f, 6.00001728e-03f, 2.56301798e-02f, 8.65872651e-02f, -1.02417395e-01f, 1.16448123e-02f, -3.67842242e-03f, -2.47402508e-02f, 1.01300073e-03f, 1.26528457e-01f,
  1.01595156e-01f, -2.31666025e-02f, 2.83237617e-03f, -1.91665385e-02f, 6.85584545e-02f, -4.16801348e-02f, 6.27632216e-02f, -4.41502929e-02f, -6.07344962e-04f, -2.35856809e-02f,
  -1.29845500e-01f, -2.74152439e-02f, 1.02531153e-03f, 1.13620266e-01f, -4.46006609e-03f, -2.52739545e-02f, -8.09003692e-03f, 3.31912413e-02f, 4.63798232e-02f, -1.10883862e-02f,
  6.36807159e-02f, -2.03189291e-02f, -6.31952211e-02f, -1.01285568e-02f, 2.67570410e-02f, -7.19477013e-02f, 4.79567284e-03f, 2.38510445e-02f, -2.04721894e-02f, 9.32526439e-02f,
  -5.34595326e-02f, -5.59704714e-02f, 8.60505924e-02f, -1.34145617e-01f, -7.68167153e-02f, 6.45019636e-02f, -2.06416519e-03f, -9.95055065e-02f, 5.64481830e-03f, 7.53309019e-03f,
  1.42713347e-02f, 1.43117756e-01f, 1.17300125e-02f, -2.57013571e-02f, -2.20059347e-03f, -5.65713570e-02f, 2.43489146e-02f, 7.98631739e-03f, 9.99319404e-02f, -3.28389229e-03f,
  -5.77151403e-02f, 6.28186539e-02f, -1.13191463e-01f, -5.44233341e-03f, 7.81083629e-02f, 8.44820142e-02f, -9.95302107e-03f, -1.49329193e-02f, -1.32695194e-02f, 1.83694605e-02f,
  5.10760881e-02f, -1.36844963e-01f, -6.40764609e-02f, -1.14777610e-01f, 5.38609810e-02f, -1.11058719e-01f, -4.14430723e-02f, -4.56416570e-02f, 4.97972034e-02f, 1.54783940e-02f,
  1.08826883e-01f, -3.86420101e-01f, -1.32854730e-01f, 1.38448268e-01f, 1.99788257e-01f, -8.20997171e-03f, -2.33949851e-02f, -2.07286403e-02f, 1.57277465e-01f, 1.64845213e-02f,
  1.18211865e-01f, -1.35404253e-02f, -1.37691900e-01f, 1.89282432e-01f, 2.09033340e-01f, -3.14713866e-02f, 2.33687401e-01f, 5.48128299e-02f, 1.14923501e-02f, -8.02507177e-02f,
  1.61958471e-01f, 8.91388431e-02f, 5.59096560e-02f, 9.94835198e-02f, -5.62120695e-03f, -1.36352450e-01f, 7.67979100e-02f, -8.29401091e-02f, 8.81495625e-02f, 8.96939710e-02f,
  -2.68392805e-02f, -5.40382266e-02f, -2.05933582e-03f, 5.68830334e-02f, -4.47886176e-02f, -1.21658266e-01f, -1.04433179e-01f, -6.24505617e-03f, 6.00690655e-02f, -1.80229452e-02f,
  -4.96174879e-02f, 7.71290362e-02f, 4.77965325e-02f, -2.39491947e-02f, -3.39468233e-02f, 7.42669106e-02f, 1.12199083e-01f, -1.06468974e-02f, 1.67808421e-02f, -8.35907012e-02f,
  1.42945033e-02f, -2.38419697e-02f, -2.11892501e-02f, -5.51799275e-02f, -4.21945564e-02f, 1.06303833e-01f, -6.77802861e-02f, -1.78820046e-03f, -6.83430284e-02f, 4.39656004e-02f,
  4.02423702e-02f, -9.21103358e-03f, -6.65685013e-02f, 9.27883014e-02f, 4.87115380e-04f, 3.77142988e-02f, -1.60540305e-02f, 5.70982276e-03f, -9.34640989e-02f, -5.67291304e-02f,
  2.51078736e-02f, -5.23102246e-02f, 4.18505073e-02f, -6.50294200e-02f, 1.32416608e-02f, 2.02299077e-02f, 4.53122333e-02f, 5.64042367e-02f, 7.73227913e-03f, -5.11566810e-02f,
  -2.32725069e-02f, 1.39589990e-02f, 8.74605477e-02f, 1.06399907e-02f, 1.63916778e-02f, -2.43756231e-02f, 2.83857975e-02f, 4.01207767e-02f, 4.94756773e-02f, -5.86993210e-02f,
  -1.91064924e-01f, -2.52142191e-01f, -4.59106639e-02f, 6.56849667e-02f, -9.09053488e-04f, -4.10968624e-02f, 6.77267462e-02f, -1.01349363e-02f, -5.10160364e-02f, -3.48706823e-03f,
  6.01177290e-02f, 7.15350150e-04f, -2.91059241e-02f, -3.55270021e-02f, -1.36704836e-02f, 1.84524432e-02f, 1.96037386e-02f, 4.43965336e-03f, 8.84914584e-03f, -4.83989157e-02f,
  -3.28210182e-02f, 5.43108620e-02f, 8.86057839e-02f, 2.44269911e-02f, 3.85536216e-02f, -2.07000636e-02f, 3.12497001e-02f, -5.32569401e-02f, -2.31029671e-02f, 2.51412671e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  9.17171612e-02f, 1.81326885e-02f, 1.27847120e-01f, -6.92743063e-02f, 6.64813146e-02f, -7.68314525e-02f, 5.95859103e-02f, 4.68878523e-02f, -2.87253372e-02f, 6.42168522e-02f,
  2.69339792e-02f, 9.65978503e-02f, -9.28462967e-02f, 2.02753946e-01f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -2.93956287e-02f, -3.50343548e-02f, 1.71286657e-01f, 1.12932943e-01f, 1.07665285e-01f, -1.12222120e-01f, -5.77009916e-02f, 1.90830126e-01f, 1.39429048e-01f, 1.60722241e-01f,
  -8.04428384e-03f, 7.25195035e-02f, -3.15871276e-02f, 2.37893648e-02f, -1.51901264e-02f, 2.25129277e-02f, 1.27687395e-01f, 2.52370350e-02f, 1.11591265e-01f, 4.82155271e-02f,
  -7.28598703e-03f, -1.39084935e-01f, 1.24464095e-01f, 1.44170582e-01f, -7.45120570e-02f, 3.38771543e-03f, 8.80805627e-02f, 4.50233975e-03f, 8.62835944e-02f, 1.88914895e-01f,
  2.59219520e-02f, 3.97024080e-02f, 2.08916288e-04f, 1.57179683e-02f, -6.03122003e-02f, 6.22180402e-02f, 6.58515766e-02f, 6.14047870e-02f, -6.58366233e-02f, 1.57379061e-02f,
  -1.79426938e-01f, 5.00531830e-02f, 8.41436908e-02f, 2.12702587e-01f, -7.59116486e-02f, 1.88723523e-02f, -1.90892488e-01f, 7.25509152e-02f, 2.08972871e-01f, -2.02466518e-01f,
  6.30325228e-02f, -2.34095529e-01f, 9.71638933e-02f, -6.25243783e-02f, -1.40436009e-01f, 1.58861317e-02f, 5.99902533e-02f, -9.84617993e-02f, -3.82730067e-02f, -1.39980298e-02f,
  -3.71416435e-02f, 1.67847708e-01f, -1.24673231e-03f, -3.62890474e-02f, 5.33396974e-02f, 1.16946548e-01f, -1.24545895e-01f, 1.31999210e-01f, 4.26717289e-02f, -1.60153404e-01f,
  -8.39371756e-02f, 2.66588628e-01f, -2.68760114e-03f, 4.73681912e-02f, 2.01762281e-02f, 2.35030856e-02f, 1.31020308e-01f, -7.07267001e-02f, 3.59726772e-02f, 1.23953275e-01f,
  -1.18763886e-01f, 1.53140679e-01f, 2.21682578e-01f, -5.21248281e-02f, 1.62958965e-01f, -1.08496726e-01f, -3.06648351e-02f, -3.24550420e-02f, 1.68939512e-02f, -1.13563515e-01f,
  -2.24780843e-01f, -1.03826653e-02f, -1.81899704e-02f, 1.24104165e-01f, 5.43527529e-02f, 3.18174362e-02f, 1.05834000e-01f, -3.72791439e-02f, 1.75819367e-01f, 1.25789374e-01f,
  5.56967631e-02f, -1.84875056e-01f, 2.95048714e-01f, 1.74990803e-01f, -2.28879794e-01f, -5.61910905e-02f, -8.90280455e-02f, 1.69992104e-01f, 3.25177722e-02f, -1.51372328e-01f,
  -5.32470755e-02f, 2.13627830e-01f, -2.14172512e-01f, -1.65129423e-01f, -8.30552801e-02f, -1.10865511e-01f, 1.41833546e-02f, 1.27792746e-01f, -2.51956910e-01f, 1.05066068e-01f,
  -4.74862494e-02f, -1.73238724e-01f, 4.35012169e-02f, -2.10127711e-01f, -4.88747880e-02f, 1.65996626e-01f, 3.21864374e-02f, -1.14031788e-02f, 1.99762404e-01f, -2.01416183e-02f,
  1.90568656e-01f, 5.21093197e-02f, 2.11077228e-01f, -5.75260483e-02f, -1.14698678e-01f, -5.10410331e-02f, -2.06520893e-02f, 1.94098622e-01f, -2.90162805e-02f, -1.58523563e-02f,
  1.54482454e-01f, 9.65858400e-02f, 1.09319307e-01f, -1.77281443e-02f, 1.26334548e-01f, 9.96118113e-02f, 9.19235572e-02f, 1.47198483e-01f, -7.95991197e-02f, 1.93323016e-01f,
  7.11873546e-03f, 1.55757248e-01f, 2.19323169e-02f, -7.76322111e-02f, 2.70849258e-01f, 3.41098532e-02f, 1.25163198e-01f, -2.14204401e-01f, -2.03083858e-01f, -6.67296574e-02f,
  4.66638729e-02f, -1.73472092e-01f, 2.31865477e-02f, 7.43776634e-02f, -7.00857937e-02f, 1.38017252e-01f, -2.49769330e-01f, -2.68868029e-01f, -1.31746083e-01f, 2.52626296e-02f,
  1.68044612e-01f, 3.53746861e-02f, -2.52109945e-01f, 7.14299902e-02f, -3.28984648e-01f, 1.38731524e-01f, 3.12557936e-01f, -2.75136501e-01f, 1.06488392e-01f, -1.23240829e-01f,
  3.00061554e-02f, 2.00719059e-01f, -5.99450357e-02f, 3.51949483e-02f, -6.60373643e-02f, 1.73462540e-01f, 3.62024382e-02f, 9.48802568e-03f, -3.21968272e-02f, 1.04898801e-02f,
  2.51810569e-02f, -1.18003286e-01f, -7.38541111e-02f, -3.11951600e-02f, -3.16647515e-02f, 1.32366223e-02f, -1.11224018e-01f, 2.13468134e-01f, -6.63735252e-03f, -8.51482600e-02f,
  2.50158738e-02f, 1.84287485e-02f, 4.75091599e-02f, 1.71985105e-01f, -4.36783358e-02f, 2.22509161e-01f, 1.80818319e-01f, 4.22714790e-03f, -6.87419251e-03f, 3.48864496e-02f,
  1.92217436e-02f, 1.39035076e-01f, 6.72607645e-02f, 8.83412808e-02f, -6.89861327e-02f, 9.67689827e-02f, 3.41625661e-02f, 1.45927304e-02f, -4.93501611e-02f, -1.27441928e-01f,
  -1.73733942e-02f, 1.17981965e-02f, 1.91625118e-01f, 1.00938138e-02f, -2.05221415e-01f, 1.38575509e-01f, -9.17723700e-02f, 1.24298640e-01f, -1.09412625e-01f, -1.04908414e-01f,
  -1.79873465e-03f, 1.13374174e-01f, 3.05337133e-03f, -9.20467302e-02f, 1.67821601e-01f, -9.87746492e-02f, 8.93566683e-02f, 1.31385520e-01f, 1.14739239e-01f, -2.73513824e-01f,
  -1.14951476e-01f, 2.58560896e-01f, 1.33206129e-01f, 1.16543598e-01f, 1.36846364e-01f, -2.83402562e-01f, 9.41101164e-02f, 1.14963658e-01f, 3.55086327e-02f, 7.08577409e-02f,
  -2.37259164e-01f, 1.34977428e-02f, -1.67261399e-02f, -7.04848468e-02f, -3.50870103e-01f, 2.54663080e-01f, -1.70067176e-02f, -8.66697133e-02f, -6.83469102e-02f, -5.75081967e-02f,
  2.52630077e-02f, -4.48970161e-02f, -8.50630254e-02f, 2.11212844e-01f, 7.79776871e-02f, -2.85048317e-02f, 9.04848129e-02f, -8.44339058e-02f, 4.73234914e-02f, 1.20702319e-01f,
  -9.96686071e-02f, -8.21134225e-02f, 1.15345135e-01f, 1.61934018e-01f, 1.28808334e-01f, -9.79296267e-02f, -7.44280145e-02f, -1.20168649e-01f, 7.39011094e-02f, 1.10962257e-01f,
  1.00033619e-01f, 9.68563706e-02f, -3.06352470e-02f, 8.29919353e-02f, 5.59942387e-02f, 2.13677734e-01f, 9.03712735e-02f, -4.93627861e-02f, 9.21941251e-02f, 1.83997691e-01f,
  1.16944574e-02f, 3.33833806e-02f, 1.00223899e-01f, -1.77275971e-01f, -2.50325371e-02f, 1.12835333e-01f, -9.99721661e-02f, -2.05302122e-03f, 2.17696335e-02f, 2.77736247e-01f,
  -1.14092350e-01f, 1.16100855e-01f, -3.90704609e-02f, -3.38869579e-02f, 3.25669572e-02f, -2.81484365e-01f, -1.02588855e-01f, -1.96679309e-01f, -6.37063682e-02f, -1.63983896e-01f,
  -1.69002712e-01f, 1.15778871e-01f, 3.29014093e-01f, -8.68567452e-03f, 8.67962465e-02f, -2.62787312e-01f, -5.17074242e-02f, 1.37528837e-01f, -8.22991580e-02f, -4.61046845e-02f,
  8.67534876e-02f, -1.04056997e-03f, 1.68989867e-01f, -9.34213400e-02f, -6.93472773e-02f, -7.04833493e-02f, 2.74367724e-02f, 1.54221654e-02f, -6.05894625e-03f, 8.17483217e-02f,
  3.41621302e-02f, 1.17089890e-01f, 6.01622686e-02f, 1.12390108e-01f, 2.49555148e-02f, -1.52624339e-01f, 2.31054574e-01f, -2.23489068e-02f, 1.82385817e-02f, 1.27399787e-01f,
  3.60663719e-02f, 1.19619109e-01f, -7.90779963e-02f, 1.14209257e-01f, -1.50786668e-01f, 1.22618996e-01f, 2.42205322e-01f, -9.21273306e-02f, 1.35745585e-01f, -2.38659829e-01f,
  1.13818392e-01f, -1.75893173e-01f, -8.93820822e-02f, -1.53510988e-01f, -8.15033540e-02f, 1.07946739e-01f, -1.51591465e-01f, 2.24894449e-01f, -2.60245651e-01f, -1.42753422e-01f,
  1.70289814e-01f, -2.25563557e-03f, 2.55488813e-01f, 2.37818062e-02f, -7.44675426e-03f, 1.55669928e-01f, -1.40386149e-01f, -4.94577587e-02f, 1.08304232e-01f, -7.73940906e-02f,
  -1.92329902e-02f, 6.00658432e-02f, 1.87140480e-01f, 7.21307322e-02f, 1.83578074e-01f, -6.89188913e-02f, -1.00220494e-01f, 2.07068533e-01f, -4.15116102e-02f, 5.41328378e-02f,
  -9.81548056e-02f, -2.92913616e-01f, -1.81583360e-01f, -1.13459356e-01f, -1.78790018e-02f, -1.75377913e-02f, 1.96796171e-02f, -3.30573991e-02f, -5.56125604e-02f, 4.00233194e-02f,
  5.84290549e-03f, -6.48020133e-02f, 1.74413204e-01f, 5.63437976e-02f, 1.24121130e-01f, -1.11364566e-01f, 5.72426990e-02f, 1.78230740e-02f, -2.53000297e-02f, 1.83703110e-01f,
  -3.03339604e-02f, 1.22666784e-01f, 1.59677759e-01f, -6.35671690e-02f, 2.36645918e-02f, 1.24445751e-01f, 2.99527287e-03f, 2.27480265e-03f, 3.41772921e-02f, -1.14745215e-01f,
  -9.68806446e-02f, 1.06667131e-01f, -1.52370453e-01f, 8.82127881e-02f, 1.98861938e-02f, 2.02435672e-01f, 2.17800885e-01f, 1.83841050e-01f, 2.41803546e-02f, -1.72622308e-01f,
  -9.29173082e-02f, 5.20462468e-02f, 1.69933997e-02f, 1.19941756e-01f, -1.69301815e-02f, 8.19614436e-03f, -1.19153261e-01f, -3.28717269e-02f, 3.20703685e-02f, 1.19537547e-01f,
  -1.34821102e-01f, 8.67737234e-02f, 7.53994063e-02f, -1.23593723e-02f, -8.86303186e-03f, -2.65819520e-01f, -3.04073781e-01f, 1.84719622e-01f, 8.19950700e-02f, -3.35715245e-03f,
  -3.67840379e-02f, -4.93665226e-02f, 7.37027451e-02f, -1.21807903e-01f, -4.08994518e-02f, 2.02597275e-01f, 2.76389509e-01f, -1.02838818e-02f, 1.88178271e-02f, -9.04286578e-02f,
  1.07400328e-01f, 3.14483307e-02f, -1.22189363e-02f, 1.76559892e-02f, -6.22795559e-02f, 1.26591831e-01f, 2.03135505e-01f, 1.53297424e-01f, -8.91610235e-02f, 8.80995765e-02f,
  6.46881806e-03f, 1.40895352e-01f, -6.26848862e-02f, 5.30345365e-02f, 1.78521037e-01f, -7.93376863e-02f, 8.69604293e-03f, -2.80983467e-02f, -7.82459378e-02f, -1.13196641e-01f,
  5.49450517e-02f, 3.01503595e-02f, -1.25600174e-01f, 2.36861244e-01f, 2.11182714e-01f, 1.16906865e-02f, 9.07248035e-02f, -6.80081397e-02f, -2.38654345e-01f, 3.33058871e-02f,
  -1.42033532e-01f, 1.55221626e-01f, -6.24357350e-02f, -1.15680136e-01f, 5.55735007e-02f, 7.80379251e-02f, -2.35507697e-01f, -1.30440757e-01f, -1.74937095e-03f, 1.47484224e-02f,
  1.97134778e-01f, 1.43388107e-01f, -1.42756239e-01f, 2.39504740e-01f, -8.50941911e-02f, -3.52982491e-01f, 8.55265632e-02f, -7.88794979e-02f, -1.30460352e-01f, -1.33965269e-01f,
  1.83374032e-01f, 1.34157687e-01f, 1.75771058e-01f, 1.56100929e-01f, 5.16744554e-02f, 3.16630185e-01f, 1.47840500e-01f, -1.32440463e-01f, -1.61258802e-01f, -2.36967648e-03f,
  7.11712465e-02f, -2.91000068e-01f, -5.72963394e-02f, -1.39666691e-01f, -1.10502847e-01f, -2.09762156e-01f, -2.27030605e-01f, 2.12833621e-02f, 1.08846806e-01f, -9.55522507e-02f,
  -7.71314055e-02f, -1.26679465e-02f, 1.08807851e-02f, -8.19704235e-02f, -1.20338418e-01f, -1.25298023e-01f, 2.52929889e-02f, -6.39386773e-02f, 1.15380391e-01f, -5.72875142e-02f,
  -1.82392187e-02f, -1.06456652e-01f, -1.11623965e-01f, 5.14941011e-03f, -1.03534997e-01f, -2.59435121e-02f, -3.14137079e-02f, 2.15723887e-01f, -2.15994306e-02f, -9.24518481e-02f,
  2.23134421e-02f, -5.25135808e-02f, -5.16786389e-02f, -6.49104863e-02f, -1.74581900e-01f, -2.17880365e-02f, 7.27873445e-02f, -3.94456163e-02f, 1.19829431e-01f, 1.15634724e-02f,
  -5.54337911e-02f, -3.33849974e-02f, 1.70913979e-01f, -1.15442760e-01f, 1.94462657e-01f, 8.92471820e-02f, -1.07745491e-01f, -2.61905417e-02f, 1.60167381e-01f, -1.22343734e-01f,
  -1.66297108e-01f, -4.08522524e-02f, -2.58671250e-02f, -3.04736327e-02f, 1.67437449e-01f, -9.03215706e-02f, 2.96323318e-02f, 2.00784579e-01f, 2.64281332e-01f, 1.58630461e-01f,
  -1.05546437e-01f, -1.02088772e-01f, 2.34580096e-02f, -1.01804249e-01f, -1.25382617e-01f, 2.03469872e-01f, -1.38014853e-01f, 8.02576467e-02f, 8.33062902e-02f, 6.76286733e-03f,
  1.27742901e-01f, -1.26088914e-02f, 2.19294261e-02f, 5.94484173e-02f, -5.94250113e-02f, 1.12965822e-01f, -1.61572605e-01f, 8.77485145e-03f, 9.32397395e-02f, 5.86338863e-02f,
  5.26702218e-02f, -3.75388972e-02f, 1.64576754e-01f, 6.62891716e-02f, 2.43634172e-02f, 2.16373540e-02f, -4.91712950e-02f, -1.46372557e-01f, -8.35056975e-03f, 7.10826591e-02f,
  1.45867234e-02f, -6.43397123e-02f, -1.41723543e-01f, -8.22864175e-02f, 3.30120288e-02f, 1.12653114e-02f, 2.47237850e-02f, -1.81084320e-01f, -3.53729352e-02f, -1.70843750e-01f,
  5.27954884e-02f, 1.21888459e-01f, 1.32322371e-01f, -1.81002691e-01f, 2.57144064e-01f, -2.04556771e-02f, -1.79364253e-02f, -1.89129576e-01f, -8.42439905e-02f, 3.54610682e-02f,
  1.54286683e-01f, -6.91500083e-02f, -1.61457248e-02f, 1.39722511e-01f, -1.40496260e-02f, -6.55554188e-03f, -2.06230253e-01f, 9.85241607e-02f, 1.15455493e-01f, -2.91865803e-02f,
  -3.65159847e-02f, -8.33724588e-02f, 1.08300157e-01f, -1.15272336e-01f, -1.04746796e-01f, -1.47342831e-01f, 5.06212711e-02f, -6.73081651e-02f, -6.45266175e-02f, 1.13053657e-01f,
  -4.57724780e-02f, 9.48027242e-03f, -1.48587421e-01f, -1.60351936e-02f, 6.32704645e-02f, 2.10371451e-03f, 5.20303100e-02f, 8.63476768e-02f, 6.37700036e-02f, -1.08661950e-01f,
  -3.70019302e-02f, -8.82872567e-02f, -1.55111048e-02f, 9.23304707e-02f, -1.04031220e-01f, 2.63959244e-02f, -9.07521248e-02f, 5.94802164e-02f, 2.18511606e-03f, -1.01279885e-01f,
  -2.03312170e-02f, -7.53426626e-02f, 1.06434219e-01f, -3.60368527e-02f, -6.30277321e-02f, -8.98330733e-02f, -1.18437693e-01f, 6.41653836e-02f, -6.02606777e-03f, 1.51517868e-01f,
  4.91174459e-02f, -7.72719160e-02f, 1.10416688e-01f, -4.05399501e-03f, 1.25391386e-03f, 1.60733610e-02f, 1.04327418e-01f, -1.78611413e-01f, 1.67268246e-01f, 1.35278255e-02f,
  4.25578021e-02f, 8.92773420e-02f, -1.45863459e-01f, -3.65307815e-02f, 8.40731934e-02f, -1.44006208e-01f, 2.02873036e-01f, -7.89314061e-02f, -1.28828689e-01f, 1.95944846e-01f,
  8.12867656e-02f, -8.49796012e-02f, -1.06433459e-01f, -1.66017175e-01f, -2.27665901e-03f, 1.40603095e-01f, 1.56045184e-01f, -2.25500464e-01f, -7.28199631e-02f, 9.81271267e-02f,
  -1.72863472e-02f, 2.20616072e-01f, -1.32180378e-02f, -1.73768178e-02f, 1.21867647e-02f, -6.77433535e-02f, 1.72194511e-01f, -7.89161846e-02f, 1.45389825e-01f, -1.53060049e-01f,
  6.75048009e-02f, 9.44994092e-02f, -1.37689546e-01f, 1.09685905e-01f, -4.04995382e-02f, -1.11219153e-01f, -7.25799277e-02f, -9.74253863e-02f, 8.46054778e-02f, -1.93656817e-01f,
  1.06857568e-01f, 1.57757908e-01f, 3.94108817e-02f, -4.57252637e-02f, 7.31707141e-02f, -4.69563864e-02f, 3.68406661e-02f, 1.13559425e-01f, -9.26269367e-02f, 8.38615447e-02f,
  -5.35745993e-02f, -1.24241352e-01f, 3.81447859e-02f, -6.95194975e-02f, -1.67987585e-01f, -1.86688647e-01f, -7.22843707e-02f, -2.21946344e-01f, 4.60136347e-02f, 1.89462796e-01f,
  1.16511144e-01f, -2.25892523e-03f, 2.90885448e-01f, -9.97093692e-02f, -1.78824723e-01f, -1.80848852e-01f, -7.49982819e-02f, 1.93040475e-01f, -2.11337224e-01f, -1.77910119e-01f,
  -1.46799058e-01f, 4.92835604e-02f, -2.25047697e-03f, -1.80986747e-01f, -3.48432884e-02f, -3.16382088e-02f, 1.46808237e-01f, 1.56206354e-01f, -1.73539072e-01f, -5.86575270e-02f,
  -2.23745391e-01f, -1.88815936e-01f, 2.19997570e-01f, -3.07068735e-01f, -2.35290721e-01f, -2.03273430e-01f, -1.14800230e-01f, -9.42325592e-02f, -5.88483084e-03f, 3.22037600e-02f,
  -2.27579474e-01f, 4.42838995e-03f, -1.43141933e-02f, 1.42812252e-01f, -2.41301581e-02f, 2.96233352e-02f, 3.94854834e-03f, -1.25567243e-01f, -5.01843654e-02f, 1.05185464e-01f,
  -1.28735378e-01f, -8.31166059e-02f, 3.07750907e-02f, -8.86153504e-02f, 1.27779678e-01f, -3.71095464e-02f, -4.42814380e-02f, 1.18155375e-01f, 9.20952931e-02f, -1.21479154e-01f,
  -1.98503565e-02f, 6.66019917e-02f, -7.55298883e-02f, 1.76081154e-02f, -1.07785404e-01f, -2.34850273e-01f, 1.46185746e-02f, 6.57201707e-02f, 4.45884764e-02f, -1.20342426e-01f,
  2.91052405e-02f, 7.34001249e-02f, -3.58727551e-03f, 4.58213128e-02f, 8.52957368e-02f, 5.67699457e-03f, 1.15967005e-01f, 1.99410170e-01f, 4.00990956e-02f, -7.71505479e-03f,
  1.20286308e-01f, -2.19043851e-01f, 1.19225152e-01f, 8.70613903e-02f, -1.80650745e-02f, -1.59180775e-01f, -2.29313150e-01f, 2.63729095e-01f, 7.87163433e-03f, 2.39493608e-01f,
  -2.50366107e-02f, -2.13388547e-01f, 1.21759899e-01f, 1.04146063e-01f, 1.41094849e-01f, -1.23805523e-01f, -1.57030672e-01f, 6.25583529e-02f, 1.18861079e-01f, -1.04087181e-01f,
  -1.58523172e-01f, 1.87905088e-01f, -1.22302584e-02f, 7.97628760e-02f, 3.50909531e-02f, -1.43650874e-01f, -1.57843500e-01f, -2.23774277e-02f, -8.27478170e-02f, -1.83521286e-02f,
  -3.47244516e-02f, 1.09462343e-01f, 6.89855963e-02f, 4.14307229e-02f, 6.09159432e-02f, 8.92726034e-02f, -1.62296131e-01f, 5.17276935e-02f, 1.93661191e-02f, -1.54276326e-01f,
  2.78103235e-03f, 4.55349274e-02f, -1.76361541e-03f, -7.59222033e-03f, 4.89121526e-02f, 2.94785239e-02f, -9.87853631e-02f, 2.08113492e-01f, 4.66400646e-02f, 2.16125567e-02f,
  -8.71670991e-02f, -6.59131929e-02f, 1.49269179e-01f, -6.48016036e-02f, -1.13984749e-01f, 2.15131387e-01f, -1.64103657e-02f, 1.42352581e-01f, 6.41025677e-02f, 2.09954157e-02f,
  -1.94020987e-01f, 3.47853750e-02f, -4.79693636e-02f, 1.16048649e-01f, 3.83626632e-02f, 1.24543803e-02f, -1.84320956e-02f, 1.37908384e-01f, -1.54837340e-01f, -2.49610022e-01f,
  -1.13376364e-01f, -1.30840912e-01f, -1.69030488e-01f, -1.58595219e-01f, -1.90152749e-02f, -6.00503013e-02f, 1.31361946e-01f, 1.73782259e-01f, 2.04706103e-01f, -2.13385001e-02f,
  -1.58650264e-01f, -4.12039421e-02f, -7.21255392e-02f, 2.40751002e-02f, -1.38920188e-01f, -1.16478384e-01f, 2.38010678e-02f, -6.09935373e-02f, -1.62269384e-01f, -4.63868771e-03f,
  3.00715752e-02f, 2.83196587e-02f, -1.02169864e-01f, 1.61193728e-01f, -9.89275128e-02f, 2.49632411e-02f, 8.30786601e-02f, -8.36027488e-02f, -2.29737395e-03f, 1.37626663e-01f,
  -9.69098210e-02f, 9.90704373e-02f, -1.29349619e-01f, 1.79867432e-01f, 1.60294831e-01f, -1.97968915e-01f, -6.69595879e-03f, -1.47903293e-01f, -1.40177235e-01f, -3.12722661e-02f,
  -4.71445657e-02f, -1.81047931e-01f, -4.37245443e-02f, 2.37322152e-02f, -1.03490502e-02f, 3.03685032e-02f, 1.08702943e-01f, 3.16815786e-02f, 2.13704199e-01f, 4.75960746e-02f,
  1.06975511e-01f, 4.00169194e-02f, 1.46281987e-01f, 4.62582000e-02f, 2.22929657e-01f, 2.06461802e-01f, 3.93661624e-03f, 9.90666449e-02f, -1.01345547e-01f, -8.98834318e-02f,
  7.26553127e-02f, 3.01157814e-02f, 1.24655835e-01f, 1.69369042e-01f, -1.30971611e-01f, -1.23756036e-01f, -4.83343238e-03f, 1.47412973e-03f, -3.69980223e-02f, -1.69347376e-01f,
  -1.50554821e-01f, -2.26752944e-02f, 1.90609649e-01f, -1.49466276e-01f, -7.16912597e-02f, -5.73128797e-02f, -9.16799828e-02f, 1.80655614e-01f, -5.98665550e-02f, -4.32273820e-02f,
  5.82984090e-02f, 6.78514689e-02f, 6.56852946e-02f, 9.35546979e-02f, 1.63286209e-01f, -1.62849396e-01f, 8.00086483e-02f, 1.75852418e-01f, 1.06963068e-01f, 4.92134597e-03f,
  -1.29435882e-01f, -4.27573267e-03f, 1.65393814e-01f, 1.33422986e-01f, -1.21170811e-01f, 3.24097164e-02f, 2.69577410e-02f, 2.23339781e-01f, -1.13459816e-02f, -4.51030359e-02f,
  4.03392054e-02f, 7.22241700e-02f, 4.70996648e-02f, 1.06345348e-01f, 1.22779302e-01f, -4.72727269e-02f, -4.60797064e-02f, -1.96302142e-02f, -4.78781275e-02f, -8.35448317e-03f,
  1.02295689e-01f, -2.00426400e-01f, -1.02730915e-01f, -1.39769047e-01f, 2.21233338e-01f, 6.30824566e-02f, 1.57520935e-01f, -1.19188547e-01f, 1.07774310e-01f, 2.86471210e-02f,
  1.04129883e-02f, -2.43279338e-01f, -1.05380736e-01f, 1.33167312e-01f, -1.46808168e-02f, -1.16698377e-01f, -1.06619120e-01f, 1.37645543e-01f, -8.83892477e-02f, 4.41773991e-05f,
  -2.34361842e-01f, 1.26776800e-01f, 1.59694403e-01f, 2.00472698e-01f, -2.06182793e-01f, -1.69880226e-01f, -2.12709844e-01f, -6.21235408e-02f, 2.56274909e-01f, -7.08077848e-02f,
  9.69518498e-02f, -2.07687214e-01f, 7.27289617e-02f, -1.17419511e-01f, 5.12010939e-02f, 3.81441899e-02f, -1.55013919e-01f, -1.34075522e-01f, -1.20181791e-01f, 4.51731086e-02f,
  8.33135098e-02f, -1.88303769e-01f, -5.20468205e-02f, -1.47269160e-01f, 7.40499273e-02f, 1.09457426e-01f, -1.58010408e-01f, 5.57902493e-02f, 4.53665741e-02f, -2.22756527e-02f,
  7.53417388e-02f, -2.01066449e-01f, -6.29650988e-03f, -3.87854949e-02f, 5.59295565e-02f, -1.79005917e-02f, 1.25707299e-01f, -8.17558840e-02f, -1.19935349e-01f, 4.76599634e-02f,
  -9.19514056e-03f, -1.25260398e-01f, -3.66803929e-02f, -3.81808504e-02f, 5.61800003e-02f, 4.98668812e-02f, -1.03935525e-01f, -3.98704931e-02f, -1.08015604e-01f, -5.99611066e-02f,
  -1.18900768e-01f, 1.54011875e-01f, -1.19556628e-01f, -1.51335329e-01f, 2.46398017e-01f, 1.10654809e-01f, 9.81665626e-02f, -2.16552958e-01f, 1.29844293e-01f, 1.04229875e-01f,
  3.12811173e-02f, -1.60377532e-01f, 1.01268172e-01f, 1.37660950e-01f, 1.04404375e-01f, 4.29257900e-02f, -6.05946258e-02f, -3.50252315e-02f, 2.00600773e-01f, -2.91674081e-02f,
  -3.42283994e-02f, 1.69106871e-01f, -1.78681329e-01f, 1.54056117e-01f, 2.27613941e-01f, -1.23959377e-01f, -1.11966468e-01f, 4.11432348e-02f, -3.72672193e-02f, 8.50346088e-02f,
  -1.10809058e-01f, -9.08177868e-02f, 7.66261853e-03f, -1.36333685e-02f, 7.78686330e-02f, 2.33313218e-02f, -1.23810314e-01f, 8.56951475e-02f, 6.11566305e-02f, 5.49356081e-02f,
  -1.28609061e-01f, 1.60587020e-02f, 6.53657317e-03f, -4.91716042e-02f, 5.50107174e-02f, -1.80658087e-01f, -1.68893725e-01f, -6.10392913e-02f, -1.34720132e-01f, 9.83110219e-02f,
  5.64606339e-02f, -1.21197134e-01f, 8.99216309e-02f, -3.03296149e-02f, -3.44819091e-02f, 7.46089313e-03f, 3.15823629e-02f, -9.05601755e-02f, -3.68264057e-02f, 1.04621693e-01f,
  -2.20540121e-01f, -1.85039356e-01f, 1.58300102e-01f, -6.01138994e-02f, -3.38061489e-02f, 1.50300860e-01f, -8.71799886e-02f, -3.70520651e-02f, -1.87949445e-02f, 1.09138563e-01f,
  -2.85751000e-02f, -1.50346205e-01f, -2.04247069e-02f, 1.17557216e-02f, -6.85343072e-02f, -4.92226519e-02f, 1.05993435e-01f, 1.24660708e-01f, -5.31439185e-02f, 1.24881856e-01f,
  2.59812009e-02f, 8.54838192e-02f, 2.39720806e-01f, -6.75578043e-02f, -8.82382020e-02f, -1.13007665e-01f, -1.82089023e-02f, 1.20759659e-01f, 1.76876724e-01f, -2.15493262e-01f,
  2.62961894e-01f, 1.98081508e-01f, -7.54054487e-02f, -5.84151410e-02f, 3.70424688e-02f, 4.14814390e-02f, -1.55807007e-02f, 3.06198075e-02f, 2.46389396e-02f, -1.03958830e-01f,
  -6.83845133e-02f, -1.89968169e-01f, 3.95125486e-02f, -2.79636811e-02f, -1.67848125e-01f, 8.80225450e-02f, -1.07261598e-01f, 4.73940261e-02f, -2.13130519e-01f, -1.07554789e-03f,
  -1.45344511e-01f, -7.98336044e-02f, -6.94082379e-02f, -5.19235805e-02f, 8.13198537e-02f, -5.60430437e-02f, -5.97947799e-02f, -7.33322725e-02f, -8.94796252e-02f, 5.56360707e-02f,
  2.20002653e-03f, -1.60665289e-01f, -1.67481065e-01f, 3.42254899e-02f, 9.66417119e-02f, 9.74374563e-02f, -1.93125531e-01f, -4.63402867e-02f, 5.68390042e-02f, -1.00521911e-02f,
  -6.01436645e-02f, -1.09950244e-01f, 9.76762101e-02f, 1.56480893e-01f, -1.42877832e-01f, -1.67622015e-01f, -1.66265592e-01f, -7.49507803e-04f, 1.82806611e-01f, 1.77734941e-01f,
  2.63129294e-01f, 1.10694058e-01f, 2.25099415e-01f, 2.29616519e-02f, -2.78289199e-01f, 4.18188013e-02f, -1.55284986e-01f, 1.10227363e-02f, -1.75159007e-01f, 1.22582078e-01f,
  1.91563889e-01f, 2.18366813e-02f, 1.49900019e-01f, 2.70048320e-01f, 1.03072166e-01f, -6.44934848e-02f, 7.69701079e-02f, -6.34352416e-02f, -1.59341663e-01f, -8.98937732e-02f,
  1.05509564e-01f, -1.15190949e-02f, 1.59143984e-01f, 1.31477296e-01f, 4.03427631e-02f, -1.30064655e-02f, -4.32658717e-02f, -5.38931340e-02f, 7.68898875e-02f, 7.40590505e-03f,
  1.70109961e-02f, 2.41440013e-01f, -5.97573742e-02f, 1.08918026e-01f, -6.67703971e-02f, -1.21922553e-01f, 1.12241127e-01f, -7.54670277e-02f, -2.04685200e-02f, 2.22231783e-02f,
  9.74030793e-02f, 6.27262369e-02f, -1.26353621e-01f, -5.11428751e-02f, 2.61866413e-02f, 2.13013459e-02f, -8.98757651e-02f, 1.24813296e-01f, 4.88504488e-03f, 7.06181899e-02f,
  5.74182300e-03f, -1.76605284e-01f, 1.72692597e-01f, -1.82087086e-02f, 1.10827595e-01f, -7.57205263e-02f, 1.60863772e-01f, -2.38340534e-02f, -1.78626940e-01f, 1.02045991e-01f,
  -1.42765358e-01f, -1.64006159e-01f, 2.58200407e-01f, -6.35936577e-03f, -5.23461923e-02f, 7.86850825e-02f, 1.35341242e-01f, -1.96676478e-01f, -7.45518729e-02f, -5.98208327e-03f,
  -4.40105237e-02f, 1.62984774e-01f, 1.58906549e-01f, 1.09398291e-01f, 2.34295771e-01f, 1.61429271e-02f, -1.03184894e-01f, 2.56973654e-01f, 6.96990192e-02f, -1.38907671e-01f,
  2.09891628e-02f, 8.88309106e-02f, 2.48000011e-01f, 4.07131203e-02f, 1.16060689e-01f, 8.67965072e-02f, -7.33152702e-02f, -1.23142667e-01f, -1.97038166e-02f, 4.14162129e-02f,
  8.05983767e-02f, 2.12838277e-02f, 2.69616414e-02f, -2.00708825e-02f, -6.15655594e-02f, -4.92897853e-02f, 1.08630151e-01f, -6.85898885e-02f, 6.15953282e-02f, 1.77219465e-01f,
  -1.11670300e-01f, -2.87067387e-02f, -6.63086697e-02f, 1.54903039e-01f, -1.24184832e-01f, -5.54794483e-02f, 1.71701163e-01f, -1.16597977e-03f, 8.69278312e-02f, 6.04617372e-02f,
  -8.30503926e-02f, 2.00349540e-01f, 1.26941770e-01f, -1.89077541e-01f, -5.36330678e-02f, 1.51821956e-01f, -7.27250278e-02f, 2.14666016e-02f, -2.25633442e-01f, -6.07566200e-02f,
  -1.53537288e-01f, -2.20056772e-02f, -1.37182577e-02f, -3.36779691e-02f, 4.41762283e-02f, -1.94064658e-02f, -1.42829686e-01f, 1.94967419e-01f, 2.30226479e-02f, -1.70454681e-01f,
  -4.35439348e-02f, -8.53580460e-02f, 6.57693595e-02f, 7.78069049e-02f, -1.03545235e-02f, -1.37233317e-01f, 3.42907086e-02f, -2.12459378e-02f, -1.47087798e-01f, 6.82721511e-02f,
  3.94835249e-02f, -1.32908061e-01f, 1.77885354e-01f, 2.00470071e-02f, -5.05580418e-02f, 7.66844749e-02f, -6.91431342e-03f, -9.54571366e-03f, -1.12712227e-01f, 9.52439904e-02f,
  4.52294573e-02f, 1.84535563e-01f, -3.49840559e-02f, 1.41151249e-01f, -4.57201228e-02f, -1.19348420e-04f, -3.02102622e-02f, 8.93651322e-02f, -5.78650124e-02f, -7.41579533e-02f,
  1.96782071e-02f, 5.93616776e-02f, 5.08558787e-02f, -1.10179365e-01f, -5.47639579e-02f, -1.33871689e-01f, -4.48865481e-02f, -1.00299539e-02f, -6.78989068e-02f, 1.84328668e-02f,
  4.02756892e-02f, 9.99143720e-02f, -1.69988975e-01f, 2.15649858e-01f, 1.12845205e-01f, 8.67482498e-02f, -6.09775446e-02f, 1.05440795e-01f, 7.45040774e-02f, 6.04430623e-02f,
  1.11043893e-01f, 1.29338533e-01f, -1.75066665e-01f, 1.84860051e-01f, 2.29423996e-02f, 6.27905689e-03f, 7.55072981e-02f, 2.36995727e-01f, -1.05450436e-01f, -6.59425631e-02f,
  -1.19151376e-01f, -6.92774951e-02f, 9.83558893e-02f, -1.90417901e-01f, 1.15069179e-02f, -2.50215560e-01f, -3.02934665e-02f, -1.02435417e-01f, -3.46355252e-02f, 4.99717109e-02f,
  3.86692077e-01f, 5.43674007e-02f, -3.17854546e-02f, -1.42390460e-01f, -1.54963151e-01f, 6.40293732e-02f, -5.03310822e-02f, 1.61121011e-01f, -1.43194133e-02f, -9.19608772e-02f,
  1.25023499e-01f, -3.54919434e-02f, -2.88082473e-02f, -1.16087243e-01f, 9.59596112e-02f, -9.43561569e-02f, 5.31890392e-02f, 6.85001612e-02f, -3.72640882e-03f, -5.23643121e-02f,
  6.39818190e-03f, 1.72811523e-01f, -6.73373714e-02f, 1.94955945e-01f, 1.94862619e-01f, 1.23104500e-02f, 6.79964870e-02f, 2.58655311e-03f, 1.04929075e-01f, -1.71374545e-01f,
  3.46184932e-02f, 1.23493457e-02f, 2.83758640e-02f, 1.26452416e-01f, -8.12737942e-02f, 9.98157486e-02f, -1.55406043e-01f, 1.88940868e-01f, 6.22684322e-02f, 2.03103557e-01f,
  1.47529110e-01f, 2.84298599e-01f, -2.35926107e-01f, 1.90643463e-02f, 1.79844528e-01f, -2.12951392e-01f, -2.58565750e-02f, -2.41418984e-02f, 1.94211170e-01f, -3.78992744e-02f,
  9.85052884e-02f, 2.13162780e-01f, -4.03579324e-02f, 2.04151303e-01f, -1.72939878e-02f, -2.25405946e-01f, 8.12856108e-02f, 8.77539590e-02f, 1.16641730e-01f, -3.48602831e-02f,
  -1.87179387e-01f, -8.52719396e-02f, -1.20514490e-01f, -3.96950589e-03f, 1.16076186e-01f, 1.70773000e-01f, 1.32729888e-01f, 4.89007384e-02f, -5.34035638e-02f, 1.48905605e-01f,
  -1.23924762e-01f, -1.84718043e-01f, -1.11730993e-01f, 7.62325749e-02f, -2.33351160e-02f, 7.69341141e-02f, 1.52504161e-01f, 7.33411871e-03f, 4.83951047e-02f, -4.49628942e-02f,
  9.50173140e-02f, -1.23588212e-01f, 1.06298566e-01f, 4.86406162e-02f, 1.22912072e-01f, 7.17029721e-02f, -9.54193622e-02f, 1.12835623e-01f, -1.61576807e-01f, 1.82955131e-01f,
  -8.54246169e-02f, 8.50510970e-02f, 1.30154118e-01f, 7.73463845e-02f, 8.75595137e-02f, 6.48143515e-02f, 1.47765025e-01f, -1.70817167e-01f, -2.10193694e-01f, 4.06111889e-02f,
  9.29180253e-03f, 4.39061783e-02f, 5.01139611e-02f, 3.11781913e-02f, 1.58289015e-01f, -1.41889572e-01f, -8.37792084e-02f, 6.70785084e-02f, 3.69194038e-02f, -1.64752603e-01f,
  6.86000362e-02f, -3.98183502e-02f, -1.09552495e-01f, -4.14161496e-02f, -2.16848314e-01f, -1.81990266e-01f, 9.82334167e-02f, -1.06657892e-01f, 9.71848816e-02f, 2.35805377e-01f,
  3.32627371e-02f, 9.19232666e-02f, 3.81760150e-02f, -4.33929637e-03f, -1.81246594e-01f, 6.60891384e-02f, -1.27181606e-02f, -3.26923132e-02f, 2.38101967e-02f, -2.00405553e-01f,
  1.34595901e-01f, 9.15930122e-02f, 1.28495112e-01f, 1.80177271e-01f, 2.06536323e-01f, 6.05097599e-02f, -2.06462741e-01f, -1.88594267e-01f, -2.04501078e-01f, -1.98430851e-01f,
  -2.20032319e-01f, -7.57708699e-02f, 4.56790999e-02f, -3.04746106e-02f, -6.48772418e-02f, 3.90990824e-02f, -2.63267662e-03f, -4.01298925e-02f, -1.94865033e-01f, -1.74573824e-01f,
  9.12186056e-02f, 3.82233299e-02f, 1.08001858e-01f, -2.26809561e-01f, -2.01556876e-01f, 4.19167336e-03f, 5.75750228e-03f, 6.17572591e-02f, -1.76168770e-01f, 1.43963834e-02f,
  -1.01480059e-01f, 1.21878311e-01f, -1.26009226e-01f, 1.09333396e-01f, -7.24621192e-02f, -1.51180312e-01f, 1.50358444e-02f, 5.88339530e-02f, -1.75919771e-01f, -3.17316949e-02f,
  1.03623252e-02f, -1.30313605e-01f, 6.23413408e-03f, -9.70299244e-02f, -8.69520940e-03f, 1.08945454e-02f, 1.92278340e-01f, 3.60623822e-02f, -1.05060861e-01f, -1.03595488e-01f,
  5.16499840e-02f, 2.40596551e-02f, 1.78169236e-01f, -1.55881777e-01f, -2.17908680e-01f, 1.47352278e-01f, 5.00051640e-02f, 6.07744344e-02f, 3.07127740e-02f, 2.35371664e-02f,
  8.98173004e-02f, 1.12806857e-01f, 2.16124773e-01f, -3.45964637e-03f, 2.08077300e-02f, 1.52033344e-01f, 1.77226156e-01f, -3.56414095e-02f, -1.45848347e-02f, 2.54790157e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -4.00410406e-02f, -3.06149852e-02f, 1.13389909e-01f, -9.95498709e-03f, 8.65674317e-02f, 1.79830521e-01f, -7.23775104e-02f, 1.50961056e-01f, 1.35324568e-01f, 4.61863764e-02f,
  1.78307444e-01f, 2.59817448e-02f, 1.74556538e-01f, 2.46195838e-01f, 6.72738999e-02f, 1.40885174e-01f, 4.40241136e-02f, 1.41485214e-01f, 7.87407234e-02f, 1.27666861e-01f,
  7.80376047e-02f, -4.77192774e-02f, 8.02773908e-02f, 8.92840400e-02f, 7.67398179e-02f, -4.42212299e-02f, -7.09851645e-03f, -4.62425053e-02f, -7.19963089e-02f, 7.93455616e-02f,
  1.32962555e-01f, 6.13044761e-02f, -1.35482982e-01f, 2.30158567e-01f, -1.60595387e-01f, 5.87531067e-02f, 1.86429709e-01f, 9.87550318e-02f, -9.36724842e-02f, 2.17703521e-01f,
  7.02491626e-02f, -7.96993226e-02f, 2.24297956e-01f, 1.80481151e-01f, -3.88114899e-02f, 9.24571380e-02f, -2.31603086e-01f, 6.24987781e-02f, -5.61243854e-02f, -2.24783882e-01f,
  -2.39253178e-01f, 3.95968109e-02f, 1.42111570e-01f, 1.82191096e-02f, -3.63158546e-02f, -1.16933897e-01f, 1.65736109e-01f, -9.53099728e-02f, -8.97770673e-02f, -1.80426627e-01f,
  -3.11197825e-02f, -1.56078905e-01f, -1.46384344e-01f, -2.38513332e-02f, 2.04306170e-01f, 8.07121098e-02f, -1.67382248e-02f, 2.53596723e-01f, -4.06877510e-02f, 3.38451900e-02f,
  -4.10195291e-02f, -2.68826094e-02f, -2.59046778e-02f, 8.47433135e-02f, 2.56632060e-01f, 1.38637856e-01f, 1.13824733e-01f, 1.45513356e-01f, 7.64105320e-02f, 1.77814960e-01f,
  7.64285624e-02f, 6.93886653e-02f, -4.41358387e-02f, 1.39717638e-01f, 1.09363779e-01f, 2.37496302e-01f, 1.25042811e-01f, 8.84957239e-03f, -2.07568705e-02f, -8.67238939e-02f,
  1.78580601e-02f, 1.90031067e-01f, 1.35229841e-01f, -4.59435694e-02f, 3.57149579e-02f, 2.04989746e-01f, 1.68010592e-01f, 2.18156055e-01f, -3.01379532e-01f, -6.00175560e-02f,
  -1.82044104e-01f, 1.96674168e-01f, -3.41011614e-01f, 3.77672575e-02f, 1.39408976e-01f, 1.92327768e-01f, 7.15198293e-02f, -2.55598694e-01f, 1.01080403e-01f, 1.70824006e-01f,
  -5.23539260e-02f, 1.69065997e-01f, 1.94682762e-01f, -4.20577712e-02f, 1.67542472e-01f, -5.75773232e-02f, -2.41281033e-01f, -6.49834499e-02f, 1.19898155e-01f, -9.22515318e-02f,
  4.39964281e-03f, 3.54608404e-03f, -9.88336354e-02f, 3.08759660e-01f, 2.01705843e-01f, 1.50257796e-01f, -3.31804156e-02f, 9.75087881e-02f, 9.60908830e-02f, 1.74912766e-01f,
  1.27585858e-01f, 2.07625423e-02f, 4.60761003e-02f, 7.40016326e-02f, 1.92082882e-01f, 1.22265138e-01f, 1.89532802e-01f, 1.10738419e-01f, 1.18078344e-01f, -1.00394813e-02f,
  2.22928464e-01f, 8.82245041e-03f, -6.23700991e-02f, 1.26145771e-02f, 3.43422033e-02f, 2.07293183e-01f, 2.44001850e-01f, 1.51356518e-01f, 1.48470804e-01f, 5.64753115e-02f,
  -4.60139476e-02f, 1.06242374e-01f, 2.05906071e-02f, -2.70677730e-02f, -2.35457242e-01f, -6.17877543e-02f, 8.19697753e-02f, 2.07902268e-01f, -2.12545935e-02f, -2.22917989e-01f,
  -4.94447872e-02f, -9.29378495e-02f, 6.40131384e-02f, 1.68903708e-01f, 1.44133657e-01f, -2.00494140e-01f, 3.38073730e-01f, 1.48026288e-01f, -1.12896055e-01f, -2.47433439e-01f,
  -4.66393605e-02f, 7.07987994e-02f, 1.86492577e-02f, -8.22731331e-02f, -2.85771172e-02f, 1.93413254e-02f, -2.70057291e-01f, 4.35375646e-02f, -2.06420228e-01f, -4.14758623e-02f,
  1.74616307e-01f, -1.09047957e-01f, -1.63627133e-01f, 1.01037301e-01f, 1.64819762e-01f, -2.45893970e-01f, 1.06687799e-01f, -1.72053963e-01f, -7.72811845e-02f, 4.04218137e-02f,
  -1.04900964e-01f, 3.38517390e-02f, 2.34154478e-01f, 1.50573879e-01f, 3.23719420e-02f, 2.58808494e-01f, 1.23854630e-01f, 9.58807673e-03f, 4.37914617e-02f, 5.99822104e-02f,
  1.26693591e-01f, 1.46064147e-01f, 1.84373418e-03f, 6.59653544e-02f, 6.56850412e-02f, 1.24991424e-01f, 1.90337509e-01f, 2.23278582e-01f, -9.20558795e-02f, -3.12587456e-03f,
  -4.20328975e-02f, 1.37557372e-01f, 9.80531052e-02f, 7.95194358e-02f, 1.28544018e-01f, 9.28397328e-02f, 1.98387101e-01f, -1.67072102e-01f, 6.04919456e-02f, 2.27829851e-02f,
  1.68528482e-01f, -1.17869265e-01f, -1.10888749e-01f, 1.69118091e-01f, 2.10004807e-01f, 5.70475496e-02f, -9.50370729e-02f, -1.49104163e-01f, -2.04848573e-01f, -8.57666880e-02f,
  -1.79403603e-01f, -7.35836430e-03f, 1.12095498e-01f, -3.52070034e-02f, -2.18248963e-01f, -6.53394833e-02f, 7.32512400e-02f, -1.09348044e-01f, 2.74411570e-02f, 2.91688621e-01f,
  6.73386157e-02f, 9.98851508e-02f, 2.10739881e-01f, 8.52073431e-02f, -7.95739740e-02f, 2.51163691e-01f, 3.19480104e-03f, -1.28089450e-02f, -1.64671138e-01f, 1.15914188e-01f,
  1.63328752e-01f, 1.91078663e-01f, 9.47932452e-02f, 3.94317620e-02f, 3.52575392e-01f, 1.61049500e-01f, 4.67311703e-02f, 1.65947363e-01f, 8.03923234e-02f, 1.09295703e-01f,
  4.62844372e-02f, 8.88636336e-02f, 2.24677082e-02f, 1.92866072e-01f, -5.13079427e-02f, 2.23026916e-01f, -1.38857123e-02f, 6.57985508e-02f, 3.00087444e-02f, -4.35277335e-02f,
  6.19943365e-02f, 1.00170456e-01f, 1.19065985e-01f, 2.35552818e-01f, -5.22224279e-03f, 2.09925890e-01f, 8.41681361e-02f, 4.02197540e-02f, 8.08156431e-02f, 1.11602522e-01f,
  1.75153479e-01f, -1.38214812e-01f, 7.47068375e-02f, 4.59911190e-02f, 8.11694413e-02f, 5.26625849e-03f, -1.41711473e-01f, -2.62676448e-01f, -1.48526862e-01f, -1.10635720e-01f,
  2.42754579e-01f, 6.03914186e-02f, -1.58912078e-01f, -1.05824247e-01f, 2.00025275e-01f, -8.76174197e-02f, -2.00574443e-01f, -1.75234601e-01f, 3.33790947e-03f, 3.24455537e-02f,
  -1.77408829e-01f, -2.69442558e-01f, -1.01103656e-01f, 9.63570476e-02f, 9.18434486e-02f, -4.93933484e-02f, -1.82261407e-01f, 1.15114279e-01f, 9.97440666e-02f, 7.42365047e-02f,
  4.66085151e-02f, -7.72399921e-03f, -2.38724396e-01f, -1.43358544e-01f, 2.88301498e-01f, -1.32754713e-01f, 2.09442884e-01f, -1.75401941e-01f, 1.15617357e-01f, 8.53977352e-02f,
  4.39230762e-02f, 3.39135490e-02f, 1.03804618e-01f, 3.59793976e-02f, 1.91027775e-01f, 8.17467943e-02f, 2.16186307e-02f, -3.49421762e-02f, 2.07976205e-03f, 1.01483040e-01f,
  2.65983671e-01f, -5.67817874e-02f, 2.26135060e-01f, 4.96497191e-02f, 1.84852660e-01f, 2.93470435e-02f, 1.10196874e-01f, 3.76252760e-03f, 2.32725471e-01f, 5.20297550e-02f,
  -5.00725955e-02f, 1.98131129e-01f, 2.36288816e-01f, 4.99407127e-02f, 7.85067901e-02f, -2.72582434e-02f, 2.34697625e-01f, -5.84813394e-02f, 9.00320560e-02f, -5.68750361e-03f,
  2.73510534e-02f, 2.96235591e-01f, 1.60007998e-01f, 2.43968725e-01f, -2.32697889e-01f, 8.13924596e-02f, 6.25875741e-02f, 1.45864770e-01f, -2.80638725e-01f, 2.51723856e-01f,
  -1.03276679e-02f, 9.36501250e-02f, 2.12065011e-01f, 1.33115664e-01f, -9.07519013e-02f, 4.00233060e-01f, -3.42240393e-01f, 1.64469611e-02f, 3.65724802e-01f, -3.85187656e-01f,
  -1.05274737e-01f, -2.83067226e-01f, -2.47940257e-01f, -1.01221517e-01f, 2.03108326e-01f, -4.50116657e-02f, 2.10248142e-01f, 1.01183929e-01f, -1.80445518e-02f, 2.15391722e-02f,
  -1.37390882e-01f, -5.25773242e-02f, 1.87613130e-01f, -6.89512771e-03f, 1.95046157e-01f, 1.01501472e-01f, 6.56105950e-02f, -2.78324485e-02f, -5.89830764e-02f, 3.95109802e-02f,
  -7.85862430e-05f, 1.73709944e-01f, -6.17520362e-02f, 1.58108830e-01f, 1.50383160e-01f, 1.19310953e-01f, 1.02313757e-02f, 1.72032252e-01f, 1.21003166e-01f, -1.07826993e-01f,
  2.00466573e-01f, -9.75945592e-02f, 1.66174278e-01f, 1.35526493e-01f, 5.58988377e-02f, 1.13807760e-01f, -6.44892920e-03f, 1.25896335e-01f, 8.16922113e-02f, 1.98074102e-01f,
  2.06527278e-01f, -9.35854111e-03f, 1.94836900e-01f, -1.58260256e-01f, -7.16486126e-02f, -3.30512300e-02f, -3.11980903e-01f, 5.54138385e-02f, -1.26380539e-02f, 2.43117765e-01f,
  1.15353301e-01f, 2.03755826e-01f, -1.53961957e-01f, -1.78426996e-01f, 3.06572858e-02f, -5.55160418e-02f, 2.72209018e-01f, 6.99258074e-02f, -6.37673885e-02f, 1.97285384e-01f,
  -1.62751377e-01f, -2.01263294e-01f, -6.99018165e-02f, -2.22695768e-01f, -1.05527349e-01f, -1.68542668e-01f, 2.75561482e-01f, 1.96120858e-01f, 1.52365327e-01f, -8.88244435e-02f,
  9.68060642e-02f, 9.10091698e-02f, 8.39202385e-03f, -1.17992565e-01f, 5.77888899e-02f, -4.06742126e-01f, 1.58455849e-01f, -8.83050787e-04f, -5.82196265e-02f, 1.56364009e-01f,
  9.74354967e-02f, -1.52947903e-02f, -2.79460587e-02f, -5.49650081e-02f, -8.95436630e-02f, 1.13453023e-01f, -5.62424585e-02f, -6.72306716e-02f, -6.55130446e-02f, 1.31567717e-01f,
  -1.19041707e-02f, 4.44071833e-03f, 1.26069158e-01f, -4.77684326e-02f, -2.16473565e-02f, 1.24814674e-01f, -1.06059447e-01f, -3.43224928e-02f, 7.97764584e-02f, 2.02663004e-01f,
  -1.59408793e-01f, -9.22592729e-03f, 4.05542478e-02f, -2.40266606e-01f, 3.40529345e-02f, -2.15228975e-01f, 1.43267617e-01f, 8.48190188e-02f, -5.00398614e-02f, -1.99480042e-01f,
  -5.93086183e-02f, -1.11798607e-01f, 2.25381032e-01f, -2.23202445e-02f, -7.89682940e-02f, 1.15050182e-01f, 9.23226699e-02f, 1.28022134e-01f, -3.68280448e-02f, -1.81113571e-01f,
  -2.38969743e-01f, -6.51514605e-02f, 8.36329907e-02f, -2.81622082e-01f, -8.73930678e-02f, 2.89575487e-01f, -3.60999047e-03f, 8.98030251e-02f, -1.28478110e-01f, 2.38074541e-01f,
  2.16831565e-01f, 1.35565773e-01f, 1.82489306e-01f, -1.23768143e-01f, -1.02265745e-01f, -2.60740757e-01f, 1.15987144e-01f, -4.43282351e-02f, 2.67447442e-01f, -2.57256061e-01f,
  2.28805602e-01f, 2.58486211e-01f, 2.25769117e-01f, 1.05022684e-01f, 2.26748034e-01f, 1.87919766e-01f, 1.83988780e-01f, -5.46641871e-02f, 1.47732154e-01f, -3.27563100e-02f,
  8.75385180e-02f, 1.42011389e-01f, 1.24247465e-02f, 1.61112875e-01f, -6.25347421e-02f, -8.56773555e-02f, 1.96819156e-02f, 9.10967886e-02f, -4.85521443e-02f, -7.56827146e-02f,
  6.60650330e-05f, 1.10511139e-01f, 2.43070554e-02f, 1.22466467e-01f, 1.76285774e-01f, 8.49590898e-02f, -7.28193996e-03f, -1.04816593e-01f, 1.00663044e-01f, -2.82316818e-03f,
  1.86278149e-01f, -8.60295743e-02f, -5.46040796e-02f, 8.48244131e-02f, 3.21552977e-02f, -1.76841512e-01f, -9.51534212e-02f, -1.81456864e-01f, -1.51082292e-01f, -3.00031248e-02f,
  -1.53589591e-01f, -2.43316948e-01f, -1.39709324e-01f, 4.59847860e-02f, -2.73478985e-01f, -4.71895337e-02f, -1.48305103e-01f, -1.74463764e-01f, 1.31336689e-01f, 1.07622311e-01f,
  -5.61077185e-02f, 1.65107742e-01f, 2.04949856e-01f, -8.87985975e-02f, -8.84135216e-02f, 1.19261257e-01f, 5.54159358e-02f, -8.09425563e-02f, -2.74716049e-01f, 4.12765406e-02f,
  2.55291224e-01f, 1.38592377e-01f, 1.29699528e-01f, -4.13462669e-02f, 2.35359475e-01f, -3.00759338e-02f, 2.12159261e-01f, 2.04930648e-01f, -2.86993328e-02f, 6.33315817e-02f,
  -1.77847873e-02f, 1.26884162e-01f, 2.41771266e-01f, 2.11479962e-01f, 9.09796581e-02f, 1.78282335e-02f, -4.68557514e-02f, 2.67141283e-01f, 1.62465110e-01f, 2.07992792e-01f,
  2.59579718e-01f, 1.08845212e-01f, 7.46238139e-03f, 1.15765765e-01f, 2.22046487e-02f, 2.29633242e-01f, 1.81819305e-01f, 1.00816071e-01f, 4.07736562e-02f, -1.52369617e-02f,
  8.58420655e-02f, -4.49970476e-02f, -1.50321335e-01f, -2.37510815e-01f, 3.85276228e-02f, -4.16628048e-02f, 6.25208914e-02f, -2.13993862e-01f, -1.99969560e-01f, -1.60964891e-01f,
  6.64313659e-02f, 5.10599464e-02f, -1.25667658e-02f, 5.65232374e-02f, -2.39571054e-02f, -1.19061902e-01f, -1.02685275e-03f, -1.10381059e-01f, 1.44892320e-01f, -2.53824979e-01f,
  2.26671640e-02f, 3.80143803e-03f, 1.64011881e-01f, -2.38778129e-01f, -2.46579826e-01f, 2.88114130e-01f, -3.48496921e-02f, 2.97928095e-01f, 9.95763764e-02f, 6.18294440e-02f,
  5.95790111e-02f, -1.15342468e-01f, -2.60236233e-01f, 7.98121542e-02f, 3.26537639e-02f, 1.00413725e-01f, 2.07412556e-01f, -1.07971668e-01f, -2.91359182e-02f, 1.19812526e-01f,
  1.01908983e-03f, 1.77891746e-01f, 1.63929656e-01f, -3.44663486e-02f, 3.88149954e-02f, 1.66617841e-01f, 1.10902868e-01f, 1.57161638e-01f, 1.01964504e-01f, -4.42294963e-02f,
  6.22502863e-02f, 1.56343892e-01f, 1.09153226e-01f, 1.66001350e-01f, 2.20693663e-01f, -1.84475128e-02f, -4.66664508e-02f, 1.85765754e-02f, -2.36896425e-02f, 1.84472993e-01f,
  -2.24844217e-02f, 1.98399603e-01f, 1.14515863e-01f, 7.33875558e-02f, 1.62220448e-01f, -6.99544474e-02f, 2.21439674e-02f, -1.81018606e-01f, 1.49857908e-01f, -1.57913327e-01f,
  -1.83911100e-01f, -6.61714822e-02f, -2.86300242e-01f, -1.59157842e-01f, 9.84996259e-02f, -9.93643305e-04f, -7.35218376e-02f, -5.72801642e-02f, -3.30391414e-02f, -2.00866789e-01f,
  -2.11679190e-03f, -3.30324247e-02f, -8.11124071e-02f, -2.12127104e-01f, 4.54798602e-02f, -1.83398008e-01f, 1.00063242e-03f, -1.73258916e-01f, -1.62768438e-01f, 1.36864230e-01f,
  1.29719183e-01f, 1.13607638e-01f, 8.86505768e-02f, 2.62491494e-01f, 2.01137856e-01f, -2.21232977e-02f, -3.04763585e-01f, 4.65283692e-02f, 3.49685811e-02f, 1.13449544e-01f,
  3.06284368e-01f, -2.19612926e-01f, 3.05817783e-01f, 8.09827149e-02f, 2.23320387e-02f, 1.26931840e-03f, 4.39135404e-03f, 8.50132182e-02f, -9.32393223e-02f, 2.48180032e-01f,
  1.85645208e-01f, 1.76173281e-02f, 9.99079421e-02f, -2.66771880e-03f, 1.38884380e-01f, 2.48281747e-01f, -4.80376817e-02f, -1.86457299e-02f, 1.37880176e-01f, 2.67772377e-01f,
  1.84553280e-01f, -4.77003455e-02f, 1.38011202e-01f, 1.85252130e-01f, 1.53000429e-01f, 6.39102887e-03f, 6.26086965e-02f, 1.11244708e-01f, 2.36098543e-01f, 1.75818607e-01f,
  -6.06234670e-02f, 1.51349664e-01f, -2.34085232e-01f, 1.24235265e-01f, 7.43354484e-02f, 2.57408142e-01f, -1.68198064e-01f, 1.37052566e-01f, -5.64285628e-02f, -1.58620924e-01f,
  -4.24628444e-02f, -2.52593849e-02f, -1.84449796e-02f, 3.22984457e-02f, 1.70878842e-02f, 1.79231584e-01f, -1.73048884e-01f, -2.31892705e-01f, 2.22110614e-01f, 2.06819251e-01f,
  -3.98593061e-02f, -2.22961783e-01f, -1.29408002e-01f, -5.48021961e-03f, 3.47845793e-01f, 1.02850385e-02f, 5.91958202e-02f, -1.56058282e-01f, 3.16667765e-01f, 2.72244871e-01f,
  2.65227109e-01f, 5.96001633e-02f, -1.72960222e-01f, 3.27584147e-01f, 1.38055533e-02f, 1.19013101e-01f, 8.62946361e-02f, 8.53865445e-02f, 1.33639678e-01f, 2.02152178e-01f,
  1.07126229e-01f, 1.70322374e-01f, 1.12903677e-01f, 1.79615647e-01f, 1.66394755e-01f, 1.84318885e-01f, 1.63019180e-01f, 1.16820842e-01f, 1.90502197e-01f, 6.55895174e-02f,
  2.07832053e-01f, 8.95382687e-02f, 3.56458835e-02f, 8.06502700e-02f, 1.10332854e-01f, -2.24387571e-02f, 4.34459448e-02f, -3.64561789e-02f, 4.91664000e-02f, 4.51909862e-02f,
  1.06288187e-01f, 5.53709045e-02f, 8.11130106e-02f, 2.99625639e-02f, 1.23609729e-01f, 1.64961368e-01f, -1.08981699e-01f, 2.13040680e-01f, 4.09941450e-02f, 8.23304877e-02f,
  3.05461790e-02f, 2.38549545e-01f, -1.05736129e-01f, 3.38353738e-02f, 2.89368890e-02f, 1.16638713e-01f, -2.69362211e-01f, -3.02451160e-02f, -8.57628603e-03f, 9.43901464e-02f,
  1.98491514e-01f, 2.00080663e-01f, 2.83786133e-02f, 2.25128427e-01f, -2.88574457e-01f, -2.19361871e-01f, 2.04677165e-01f, -3.91916096e-01f, 1.07099190e-01f, -1.72287151e-01f,
  7.17488527e-02f, -7.67115876e-02f, 2.38089144e-01f, 1.72929198e-01f, 1.35484412e-01f, 1.27512679e-01f, 3.79227549e-02f, 4.27909158e-02f, -2.19134986e-01f, 2.21105814e-01f,
  -1.70892403e-01f, 1.07996166e-01f, -5.41905612e-02f, 1.66869551e-01f, 3.65210995e-02f, 1.55592620e-01f, 1.83583766e-01f, 6.12070933e-02f, 2.79295743e-02f, 1.29277945e-01f,
  -8.22733715e-02f, 1.60398737e-01f, 1.45007625e-01f, 1.02228992e-01f, 3.06163933e-02f, 1.64701208e-01f, 1.59301180e-02f, -1.20485596e-01f, 1.01927891e-01f, 2.08693251e-01f,
  9.78529155e-02f, 1.47565901e-01f, 9.85097066e-02f, -3.02167814e-02f, 3.26164588e-02f, 1.15433142e-01f, 1.37994125e-01f, -1.82392851e-01f, -1.23032942e-01f, -2.71446198e-01f,
  1.22597881e-01f, 9.87148285e-02f, 3.37679908e-02f, -2.21630901e-01f, -2.34746844e-01f, -6.10944182e-02f, 4.64881286e-02f, 2.62594223e-01f, 9.47578531e-03f, -2.92194355e-02f,
  2.39968255e-01f, 2.45001122e-01f, -2.20427826e-01f, -2.42976069e-01f, 7.48825446e-02f, -2.05811653e-02f, 2.04524696e-01f, -4.55066524e-02f, 6.25337847e-03f, 6.90321401e-02f,
  -1.20854959e-01f, -2.14894190e-02f, -1.78263523e-02f, 1.54034212e-01f, 2.57512331e-01f, -1.19268537e-01f, 3.23588252e-02f, -2.75490046e-01f, -1.33713201e-01f, -2.39210904e-01f,
  -9.37155113e-02f, -1.79283217e-01f, 1.19627416e-01f, -2.08059549e-01f, -1.13404319e-01f, -1.04924571e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  2.34427318e-01f, 6.97592944e-02f, 1.11701973e-01f, -3.09404824e-02f, 1.52343348e-01f, 1.84807390e-01f, 1.31071895e-01f, 1.39071764e-02f, 2.83928234e-02f, 1.10087328e-01f,
  7.27657676e-02f, 2.40004733e-01f, 1.96131572e-01f, 1.39347881e-01f
};

// L2_fan_Wp (Shape: 25 x 64)
const int L2_fan_Wp_rows = 25;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -1.53344832e-02f, 5.48289195e-02f, 1.44183580e-02f, -1.45366281e-01f, 2.13075858e-02f, 1.16772227e-01f, 1.55495806e-02f, 2.41110712e-01f, -6.61383495e-02f, 1.11873113e-01f,
  2.12742165e-02f, 1.43020555e-01f, 4.77941222e-02f, 8.25881362e-02f, 3.36511210e-02f, 1.90519635e-02f, 9.61100087e-02f, -7.71971792e-02f, -7.56529570e-02f, 9.16127041e-02f,
  4.86887438e-04f, 9.24710259e-02f, 4.79122996e-03f, -8.04726109e-02f, 6.67878613e-02f, -2.95910053e-02f, 1.34372905e-01f, -3.30624171e-02f, -4.37870026e-02f, 1.19347183e-03f,
  -3.84650193e-02f, 3.39782797e-02f, -1.78499699e-01f, -1.38125524e-01f, 2.59259958e-02f, 2.01033622e-01f, -1.92676023e-01f, 2.41173118e-01f, -1.08357973e-01f, 1.83569059e-01f,
  4.47185077e-02f, 1.72404215e-01f, 8.25323723e-03f, 5.34802154e-02f, 8.76180381e-02f, -1.71170279e-01f, 5.60917556e-02f, 8.73109922e-02f, 1.88962236e-01f, 1.18162081e-01f,
  -1.19108912e-02f, 2.15426981e-01f, 1.73073225e-02f, -4.23319899e-02f, -1.63431391e-01f, -7.73282945e-02f, -1.34106368e-01f, -2.42062677e-02f, -4.01139408e-02f, 1.08653001e-01f,
  -5.04583959e-03f, 1.06062248e-01f, -2.39512715e-02f, -8.27376470e-02f, 4.35079308e-03f, -8.99819061e-02f, 1.70727819e-01f, 1.86989680e-01f, 4.74531278e-02f, -3.14613394e-02f,
  1.78049400e-01f, -1.06738761e-01f, 4.03785966e-02f, 8.84073786e-03f, 5.20497337e-02f, -1.35305608e-02f, 1.40494585e-01f, -3.63786146e-02f, 1.06742263e-01f, -6.34409636e-02f,
  1.34303030e-02f, 1.86627716e-01f, -1.86290070e-01f, 1.83864638e-01f, 1.73715338e-01f, -8.42121337e-03f, -1.64364621e-01f, -1.83802247e-02f, -1.72559377e-02f, 1.12342089e-02f,
  -1.10597350e-01f, 1.77067503e-01f, 1.55516848e-01f, 1.29311923e-02f, 3.41400087e-01f, -1.78855494e-01f, -1.89552948e-01f, 8.13188106e-02f, 5.32118231e-02f, -3.19244601e-02f,
  1.33814737e-01f, 1.23380773e-01f, 1.15555376e-01f, 1.45779550e-02f, 1.58616863e-02f, 1.44044748e-02f, 1.33519977e-01f, -1.13622472e-01f, -1.34115681e-01f, 1.96341038e-01f,
  9.25459415e-02f, -3.53955477e-02f, -8.98628235e-02f, -1.29386723e-01f, 1.70606777e-01f, -1.34092599e-01f, 3.57866026e-02f, -1.59340233e-01f, 8.16900730e-02f, 1.76785931e-01f,
  -4.45888415e-02f, 1.48246989e-01f, -1.40927643e-01f, -9.21345502e-02f, -4.35099863e-02f, -1.21097811e-01f, 4.80043739e-02f, 1.23211697e-01f, 3.73284072e-02f, -3.41271311e-02f,
  -1.70375064e-01f, -1.52129620e-01f, -7.10049570e-02f, -1.92350522e-01f, 1.53160458e-02f, -2.68398132e-02f, -1.00872681e-01f, 1.51950046e-01f, 3.31901275e-02f, 2.14352477e-02f,
  -3.02339904e-02f, -1.09433867e-01f, -6.59754276e-02f, -8.22802167e-03f, 3.73416319e-02f, -1.25820339e-01f, -3.83706912e-02f, -1.99942067e-01f, -1.44961014e-01f, -3.93157788e-02f,
  -2.98954882e-02f, 1.28725665e-02f, -1.52741954e-01f, -3.81176062e-02f, 9.23074931e-02f, 1.06584076e-02f, -1.77205503e-01f, 5.88578060e-02f, -1.15264170e-01f, -7.23123997e-02f,
  1.19273655e-01f, 2.50598907e-01f, 6.43999428e-02f, -9.31872651e-02f, 2.49438748e-01f, -2.38189787e-01f, -7.33266398e-02f, -2.04835832e-01f, 1.87393859e-01f, -1.17762409e-01f,
  7.95573667e-02f, 1.32344306e-01f, 7.89117813e-03f, -6.84227273e-02f, -1.25451013e-03f, -1.76762417e-01f, 8.00454337e-03f, 8.14895406e-02f, -1.60207957e-01f, -2.66241550e-01f,
  9.71782357e-02f, -1.22771733e-01f, 1.97243169e-01f, -1.38789535e-01f, 9.07203555e-03f, 9.01152343e-02f, 1.94277227e-01f, -1.38556538e-03f, 9.89987627e-02f, 2.09314730e-02f,
  -1.03831463e-01f, 8.26192051e-02f, 2.07466632e-03f, 2.05233231e-01f, -1.35426030e-01f, -4.48032320e-02f, 1.70870259e-01f, -5.99739291e-02f, 1.26246065e-01f, -3.79865728e-02f,
  1.94244739e-02f, -3.00921518e-02f, -1.34343818e-01f, 1.36199102e-01f, -3.31017189e-02f, -3.25657353e-02f, 7.08312988e-02f, 5.31306537e-03f, -1.39301829e-02f, 1.63954884e-01f,
  -1.20996302e-02f, -1.47718906e-01f, -7.94157982e-02f, 1.20319636e-03f, -3.92986946e-02f, 4.45962511e-03f, -1.54371709e-01f, 1.34361878e-01f, 2.55729020e-01f, -1.72887966e-01f,
  -1.30382374e-01f, 2.78504223e-01f, 2.38318611e-02f, 1.89265624e-01f, 9.19186473e-02f, 9.14710686e-02f, 9.17938873e-02f, 2.13731617e-01f, 1.37542814e-01f, -4.27004788e-03f,
  -1.00180618e-01f, 1.08295850e-01f, 8.19483697e-02f, -7.46087730e-02f, -5.51450141e-02f, -9.82544348e-02f, 2.24788785e-01f, -3.35360825e-01f, 2.35621870e-01f, 1.69093937e-01f,
  9.88600627e-02f, -9.60591584e-02f, -4.49755453e-02f, -2.12767452e-01f, 1.04662672e-01f, 1.57321815e-03f, 8.71469304e-02f, -1.46386012e-01f, -1.49533615e-01f, -5.93680888e-02f,
  -1.48746759e-01f, -5.20115532e-02f, -1.54786229e-01f, 1.27750710e-02f, 2.78961025e-02f, -4.45942469e-02f, 6.48555206e-03f, -1.40505342e-03f, -7.34571740e-02f, 1.09804899e-01f,
  1.04925506e-01f, 1.31023839e-01f, 4.40517887e-02f, 1.35004595e-01f, 1.48345068e-01f, 4.20015538e-03f, -9.33193322e-03f, 1.24005705e-01f, -5.53297326e-02f, 1.89676031e-01f,
  1.70979381e-01f, -2.45063063e-02f, 2.68889040e-01f, 1.48187876e-01f, 1.22656681e-01f, 1.10954836e-01f, 3.76571044e-02f, 3.61858383e-02f, 2.45138884e-01f, 5.52373603e-02f,
  1.41435429e-01f, 7.59471506e-02f, 2.89403528e-01f, -1.04136422e-01f, 1.10339662e-02f, 1.72361508e-01f, -1.35960460e-01f, 1.53035954e-01f, 1.42321542e-01f, 6.16228990e-02f,
  1.16868891e-01f, 2.63430178e-01f, -1.63144082e-01f, 2.17539027e-01f, 1.90846369e-01f, 2.22675279e-01f, 2.56352983e-02f, -1.20752595e-01f, -1.46333992e-01f, -2.06569195e-01f,
  1.03675313e-01f, -2.49471322e-01f, 1.62810713e-01f, 2.20353037e-01f, 1.15909345e-01f, 8.51056427e-02f, 5.77514917e-02f, -1.13064535e-01f, 1.50476113e-01f, -9.68417600e-02f,
  -1.25684544e-01f, -2.10712459e-02f, 4.30284970e-04f, -9.58164781e-02f, -6.77161058e-03f, -8.41131732e-02f, -7.90254697e-02f, 4.73261997e-02f, 1.04276687e-01f, 1.17991362e-02f,
  1.84234560e-01f, -1.05782494e-01f, -1.05339751e-01f, -8.43077675e-02f, -1.67410910e-01f, -1.31475940e-01f, -1.02619186e-01f, 6.61955476e-02f, -1.14107318e-01f, 1.88498981e-02f,
  -8.03734586e-02f, 9.86288413e-02f, -1.36265084e-01f, 2.65776031e-02f, -3.98464724e-02f, 5.04708886e-02f, -9.91716236e-02f, -3.62069085e-02f, 5.36952466e-02f, 8.65302831e-02f,
  -1.41507089e-01f, 1.98462456e-02f, -1.53550953e-01f, 3.13540511e-02f, -6.57067224e-02f, -3.44922347e-03f, 5.34197912e-02f, -4.05006818e-02f, 8.89489986e-03f, -1.27802521e-01f,
  -4.95789759e-02f, -1.08360119e-01f, -1.60365820e-01f, 2.19385952e-01f, -1.05256096e-01f, 7.48090893e-02f, 2.93614827e-02f, 2.47482300e-01f, -1.04435526e-01f, 9.71408710e-02f,
  -9.75559503e-02f, 5.34149259e-02f, 2.47906923e-01f, -1.92300230e-02f, -2.43729409e-02f, -1.63570434e-01f, -8.61075446e-02f, -2.59711742e-01f, 5.28107136e-02f, 1.05592340e-01f,
  -1.92465708e-02f, -1.40644565e-01f, 9.21674073e-02f, 2.96619087e-02f, 1.49917185e-01f, -2.61744887e-01f, -1.66924467e-04f, 2.02255741e-01f, 8.85955095e-02f, 2.35764861e-01f,
  4.57486399e-02f, 8.23678002e-02f, -1.76218539e-01f, -5.98484091e-02f, 6.72957748e-02f, -9.87824127e-02f, 6.33311719e-02f, 1.12697162e-01f, 6.89306706e-02f, -9.54228416e-02f,
  5.48580997e-02f, 2.67772973e-02f, 6.17903918e-02f, 7.29167908e-02f, -1.27091795e-01f, -2.14961357e-02f, -6.58754483e-02f, -6.93105981e-02f, 4.08211648e-02f, 1.77650332e-01f,
  -7.51641244e-02f, 6.96707666e-02f, -2.93840058e-02f, -1.05168056e-02f, 5.52854799e-02f, -8.55581611e-02f, 1.92456208e-02f, 5.51880375e-02f, 2.30708234e-02f, 8.55673328e-02f,
  1.53551668e-01f, 1.75863430e-02f, 5.85727219e-04f, 2.50151545e-01f, -7.22231045e-02f, 2.19014436e-01f, -7.42833167e-02f, 5.72813340e-02f, 1.41546041e-01f, 7.98285902e-02f,
  -8.63056034e-02f, 1.86234340e-02f, 2.20346674e-01f, 9.90293846e-02f, -1.83834150e-01f, -1.19688682e-01f, -9.62811615e-03f, -2.20614240e-01f, 1.00383572e-01f, -4.44218814e-02f,
  2.15005368e-01f, 2.43706889e-02f, -4.58389036e-02f, 2.17602909e-01f, 1.24749497e-01f, 3.40393931e-02f, -2.89430916e-02f, -2.84415716e-03f, -1.67286396e-01f, 7.81865418e-02f,
  -3.75426710e-02f, -1.88734695e-01f, -2.61195123e-01f, -2.65756935e-01f, -9.51014087e-02f, 5.51606640e-02f, 7.45063573e-02f, -1.47880673e-01f, 7.16526583e-02f, -9.89136398e-02f,
  4.49192300e-02f, -7.20854178e-02f, 6.02055937e-02f, -2.12842733e-01f, -7.02020749e-02f, -1.08702667e-01f, 6.51571825e-02f, 5.91477156e-02f, -1.78359106e-01f, 1.46123543e-01f,
  1.27383798e-01f, 1.10182621e-01f, -7.65682086e-02f, 7.62587925e-03f, 1.09414019e-01f, -5.03351539e-02f, 8.79611969e-02f, 4.72545326e-02f, -9.06180963e-02f, 1.13209367e-01f,
  1.12901807e-01f, 6.99858591e-02f, -4.25769053e-02f, -4.02865633e-02f, -1.19904585e-01f, -1.42210290e-01f, 2.29096770e-01f, -6.95329159e-02f, 1.68685466e-02f, -6.61231354e-02f,
  -9.19636935e-02f, 2.07801118e-01f, 1.91990674e-01f, 1.45665199e-01f, -5.78886606e-02f, 1.49698928e-01f, 1.96591541e-01f, -8.62592645e-03f, 1.22361980e-01f, 1.94212079e-01f,
  1.83761999e-01f, -2.00264245e-01f, -2.38841921e-02f, -2.01474428e-01f, 3.73515040e-02f, -1.16957419e-01f, -5.94591908e-02f, 2.04815537e-01f, 2.93584093e-02f, -1.79888234e-01f,
  1.65266797e-01f, -8.46831948e-02f, 7.01695532e-02f, -2.04518259e-01f, 1.98218018e-01f, 1.32283673e-01f, -1.77038833e-01f, 1.94762990e-01f, 2.05042794e-01f, 3.52951661e-02f,
  6.11324459e-02f, 4.10184301e-02f, -1.07251272e-01f, -5.34621254e-02f, -2.29161722e-03f, -1.03242926e-01f, -8.70215669e-02f, 5.61019443e-02f, -3.33750360e-02f, -3.57288942e-02f,
  4.74062152e-02f, -1.10485293e-01f, 1.34328052e-01f, -1.21100470e-02f, -1.21490598e-01f, -1.09019160e-01f, 4.79364507e-02f, -9.95839201e-03f, -1.70050442e-01f, 1.50181307e-03f,
  -1.51105389e-01f, 9.67493579e-02f, -8.42725784e-02f, 9.64461565e-02f, -3.41175571e-02f, -9.81249437e-02f, 1.73095495e-01f, -1.11980304e-01f, -7.51747787e-02f, 7.45357247e-03f,
  -1.70557454e-01f, -1.42600089e-01f, 2.08156481e-01f, -4.29979116e-02f, 1.12737983e-01f, -9.58776250e-02f, -7.49816895e-02f, -3.43977287e-02f, 2.31671587e-01f, -1.90356851e-01f,
  -8.92474577e-02f, -1.33785203e-01f, 2.32159793e-01f, 7.90654868e-03f, 1.69009879e-01f, 1.18174754e-01f, -7.37464577e-02f, -2.88522001e-02f, -5.54680303e-02f, -2.50973720e-02f,
  -1.06105536e-01f, -6.29585460e-02f, 1.27194092e-01f, -1.72702432e-01f, -6.03436828e-02f, -1.37260973e-01f, 2.37361699e-01f, -6.16111234e-02f, 1.75064892e-01f, 1.97159901e-01f,
  4.28891480e-02f, 7.82614201e-02f, 1.98606089e-01f, -1.32457331e-01f, 4.37538326e-02f, 1.05635874e-01f, 1.25766501e-01f, -6.05486855e-02f, -5.63791059e-02f, -7.57643655e-02f,
  -1.61384702e-01f, -2.91359425e-02f, 8.50492269e-02f, -5.57517074e-03f, -2.33964566e-02f, 1.94380611e-01f, -1.02170900e-01f, 1.94877118e-01f, 2.64651030e-02f, 4.68231477e-02f,
  -6.41975775e-02f, 1.01766303e-01f, 7.78249055e-02f, -3.99061665e-03f, 1.19471677e-01f, -8.97981822e-02f, 1.14309089e-02f, -4.49870974e-02f, 8.61083567e-02f, -1.61080405e-01f,
  8.79064128e-02f, -4.06233110e-02f, -2.36205861e-01f, -1.45367622e-01f, 2.92889494e-02f, -2.48368442e-01f, -2.48125553e-01f, 1.30137235e-01f, 1.00410387e-01f, 2.57660031e-01f,
  -1.73441201e-01f, 3.92072760e-02f, -3.36401731e-01f, 2.82727808e-01f, 1.10650748e-01f, -9.58711952e-02f, -1.16778843e-01f, 2.02507049e-01f, 2.91396320e-01f, -7.42511973e-02f,
  4.55748178e-02f, -2.59537641e-02f, 6.52437434e-02f, 9.71306339e-02f, 6.27752990e-02f, 2.49555752e-01f, -5.29907942e-02f, 2.55735904e-01f, -2.35170007e-01f, 6.50909021e-02f,
  -1.22125402e-01f, -4.90646902e-03f, -1.08438902e-01f, -3.86754572e-02f, -1.52414897e-03f, 1.19228572e-01f, 1.73762277e-01f, 2.84118444e-01f, 4.45611775e-02f, -1.11318100e-02f,
  2.15054862e-02f, 4.26530875e-02f, 1.41563714e-01f, 1.51546448e-01f, 7.77686462e-02f, -7.04169506e-03f, 1.97867766e-01f, -6.07079379e-02f, -6.00051768e-02f, 8.94728824e-02f,
  -1.84344739e-01f, -3.25588905e-03f, -6.49670810e-02f, -6.53786585e-03f, -5.21854497e-03f, 2.70885732e-02f, 4.46524769e-02f, -2.22241972e-02f, -2.87102461e-02f, -2.18347441e-02f,
  -4.27245395e-03f, -1.26281351e-01f, -1.70530215e-01f, 4.49610017e-02f, -1.25117078e-02f, 4.02432717e-02f, 1.56434879e-01f, -2.00573027e-01f, 1.61182523e-01f, -1.01045027e-01f,
  5.85187376e-02f, -6.49965405e-02f, -2.17985973e-01f, -1.06855864e-02f, 2.36426279e-01f, -2.71241367e-02f, -1.57509632e-02f, 3.25458556e-01f, 4.15420718e-02f, 9.85988081e-02f,
  6.94723800e-03f, 1.19203918e-01f, 1.45997599e-01f, -7.53927976e-03f, -2.60287106e-01f, 1.44208997e-01f, 3.79929133e-02f, -2.65005883e-02f, 8.88568386e-02f, 1.49100870e-01f,
  1.14327095e-01f, -1.66692987e-01f, 9.44477320e-02f, -1.29902065e-01f, 6.64378256e-02f, -6.67055473e-02f, -1.37895837e-01f, 1.60586283e-01f, -6.72150776e-02f, 1.36736616e-01f,
  -6.11181855e-02f, -1.15615942e-01f, -1.42162979e-01f, 2.25407511e-01f, 1.11315414e-01f, -8.44551846e-02f, 1.56708971e-01f, -1.27703786e-01f, -7.27807060e-02f, -6.00063242e-02f,
  -2.56378744e-02f, 6.59023449e-02f, -2.98829433e-02f, -3.91130038e-02f, -6.71735853e-02f, 1.00081518e-01f, 1.61738863e-04f, -1.08100526e-01f, 5.12928329e-02f, 1.43069297e-01f,
  -5.41670695e-02f, 1.02827653e-01f, 8.03973675e-02f, -6.09093122e-02f, -1.30157679e-01f, 1.08584829e-01f, 1.79052129e-01f, -1.30133837e-01f, -4.27050740e-02f, -1.17214166e-01f,
  -2.47781530e-01f, -2.03523844e-01f, 1.24027051e-01f, 1.60818733e-02f, -1.76744610e-01f, 3.34083959e-02f, -1.04059219e-01f, 2.04122901e-01f, 6.12226501e-02f, 1.17656693e-01f,
  -2.16864526e-01f, 1.03712641e-01f, 6.26205839e-03f, 8.96040648e-02f, -1.64231822e-01f, 1.60558820e-01f, 2.31803432e-01f, 6.48888061e-03f, -1.37727976e-01f, -1.34282142e-01f,
  3.61001715e-02f, 9.54752490e-02f, -4.79559898e-02f, 2.27698877e-01f, -1.29892498e-01f, 1.56804889e-01f, -1.22934297e-01f, 7.88439438e-02f, -5.57616986e-02f, 2.11439744e-01f,
  4.14823666e-02f, 1.25888720e-01f, -3.07231471e-02f, 7.37822130e-02f, -8.96228664e-03f, 2.16363758e-01f, 1.14315353e-01f, -1.80392653e-01f, -6.22788956e-03f, 6.55602589e-02f,
  1.62136704e-01f, 1.11776814e-01f, -1.08464986e-01f, -1.29657492e-01f, 1.53483257e-01f, -4.28224988e-02f, 1.06210589e-01f, -4.12027463e-02f, -5.24920458e-03f, 7.65666217e-02f,
  1.06198318e-01f, 3.66808614e-03f, 1.08428203e-01f, -6.30569411e-03f, -2.05085184e-02f, -4.25848030e-02f, -1.29151523e-01f, 6.85658231e-02f, 7.50217363e-02f, -5.56436963e-02f,
  1.02148972e-01f, 5.56673743e-02f, -5.78454733e-02f, -8.11936110e-02f, -8.89146924e-02f, 2.24569603e-03f, 2.11831048e-01f, -2.26068702e-02f, 5.92432991e-02f, -2.05530882e-01f,
  4.10071984e-02f, 2.81932980e-01f, 1.74282953e-01f, -1.47005394e-01f, -6.38122633e-02f, 1.97439238e-01f, 1.71261847e-01f, -1.29911110e-01f, -7.18858391e-02f, 2.15200454e-01f,
  1.27201155e-02f, -1.76540717e-01f, -2.57111043e-01f, 1.78555883e-02f, 6.14555702e-02f, -1.02135852e-01f, -1.56458884e-01f, 2.41654992e-01f, 1.01959147e-01f, -1.67745978e-01f,
  1.13675855e-01f, -3.01078763e-02f, 3.05508766e-02f, 7.05164596e-02f, 2.13538036e-01f, 1.20285023e-02f, -2.47151986e-01f, 1.63733006e-01f, -8.58661607e-02f, 1.38249733e-02f,
  6.77523687e-02f, 1.50770873e-01f, 1.75893471e-01f, 2.93096080e-02f, 1.06923483e-01f, 9.18941498e-02f, 2.83791348e-02f, -4.80152071e-02f, -2.33587753e-02f, 3.48888189e-02f,
  -1.84917673e-02f, -6.03751540e-02f, 1.86152402e-02f, 7.65647516e-02f, -1.67885661e-01f, -7.12127909e-02f, 7.48340711e-02f, -7.56747648e-02f, -7.18847662e-02f, -8.08583274e-02f,
  2.45940257e-02f, 7.95633867e-02f, -3.06796581e-02f, 7.51838312e-02f, -1.08422764e-01f, -1.10159427e-01f, -1.70301884e-01f, -9.20793563e-02f, 9.58508179e-02f, -1.51581317e-01f,
  1.25763178e-01f, 3.91846113e-02f, -1.39863938e-01f, -1.38753965e-01f, -1.90992162e-01f, 8.97655264e-02f, 1.92003682e-01f, 1.15627475e-01f, -1.99707747e-02f, 2.83075958e-01f,
  -7.10564926e-02f, 1.12010866e-01f, -3.89553718e-02f, 4.06037122e-02f, 1.23665564e-01f, -7.44472444e-02f, -7.21099526e-02f, -2.17087060e-01f, -3.10942493e-02f, -5.62791154e-02f,
  -2.12354846e-02f, 2.61819988e-01f, -1.16676250e-02f, 2.29381789e-02f, 7.76166916e-02f, -8.93379673e-02f, 3.25618461e-02f, -2.16169760e-01f, -1.78352192e-01f, 9.14297327e-02f,
  -1.81518301e-01f, -5.19520952e-04f, 8.59931707e-02f, 1.47548735e-01f, -1.27152264e-01f, 9.50653255e-02f, 7.17586502e-02f, -5.83214983e-02f, 5.03571033e-02f, -6.49586245e-02f,
  1.37668490e-01f, -4.42000851e-02f, 1.69089921e-02f, -4.52592187e-02f, 1.31240534e-02f, -3.95265669e-02f, -1.16457015e-01f, -1.30482942e-01f, 6.72304779e-02f, 1.14385329e-01f,
  4.92561087e-02f, 1.62348078e-04f, -1.34171680e-01f, 1.07351504e-01f, 7.00553134e-02f, 7.61825889e-02f, 2.18121964e-03f, -8.23426098e-02f, 1.61644056e-01f, -4.13230434e-02f,
  8.08895156e-02f, -1.13752864e-01f, -1.63209289e-01f, -3.86517979e-02f, 1.39602467e-01f, -1.13283005e-02f, -2.74734162e-02f, -1.08896270e-01f, 5.63645102e-02f, -5.10569029e-02f,
  -1.76103786e-01f, 1.21181281e-02f, -1.83138430e-01f, 1.21015012e-01f, 1.20507434e-01f, -1.51723310e-01f, -1.92435756e-01f, 1.57466814e-01f, -2.05357164e-01f, 1.19664140e-01f,
  -7.95028731e-03f, -1.84739642e-02f, -2.89240126e-02f, 1.15956187e-01f, -1.82539910e-01f, -1.11302838e-01f, -7.48319775e-02f, 1.05435960e-02f, -1.42178237e-01f, -1.70120578e-02f,
  -8.35902989e-02f, -3.40775610e-03f, -4.99507524e-02f, -1.96191788e-01f, -1.04168661e-01f, 6.32834062e-02f, -7.41708130e-02f, 1.19178459e-01f, 2.85485182e-02f, -1.06954113e-01f,
  -9.73094776e-02f, -5.93335256e-02f, 2.36719370e-01f, -4.78218794e-02f, -1.60495818e-01f, 6.04311824e-02f, -9.52165276e-02f, 1.67477414e-01f, 7.71219376e-03f, 2.76029371e-02f,
  -6.62025362e-02f, 4.52222675e-02f, 1.25562027e-01f, 9.72316414e-02f, 8.09080452e-02f, 7.73290619e-02f, -3.71849095e-03f, -9.88293663e-02f, -1.06496528e-01f, 1.93243772e-01f,
  8.82860944e-02f, -3.82915623e-02f, -5.66588715e-02f, -6.67015836e-02f, 9.24377963e-02f, -1.25424132e-01f, -4.44814265e-02f, -3.82891856e-02f, 5.63736521e-02f, -1.67862081e-03f,
  -6.27592430e-02f, 1.60316527e-01f, -2.62578636e-01f, -8.12251717e-02f, 8.24103951e-02f, 8.40395764e-02f, -3.95644635e-01f, 2.59506881e-01f, 2.31025834e-03f, 1.26629576e-01f,
  -2.17639655e-02f, 1.40458316e-01f, 1.24475285e-01f, -6.21238425e-02f, -1.56823844e-01f, 7.88554773e-02f, 1.82068720e-01f, 5.29111139e-02f, 9.79465917e-02f, 8.52312967e-02f,
  1.81985125e-01f, 2.23633930e-01f, -1.80688109e-02f, 2.77002770e-02f, -1.50974676e-01f, 2.32437894e-01f, -1.42775774e-01f, 3.58421355e-02f, -1.22601539e-01f, -1.52562037e-01f,
  -1.82712927e-01f, 1.02912828e-01f, -1.82114691e-02f, 5.50138317e-02f, 1.93485506e-02f, -1.24694362e-01f, 6.91452697e-02f, 2.94446573e-02f, -1.01611957e-01f, 8.04396346e-02f,
  -1.20359510e-01f, -1.48601368e-01f, -9.52469558e-03f, -1.35839537e-01f, 5.49688227e-02f, -2.53137648e-02f, -1.21338302e-02f, -1.54350892e-01f, 7.02877045e-02f, -7.45568797e-02f,
  4.45459075e-02f, -1.29400432e-01f, -7.84747675e-03f, 1.69654921e-01f, -8.92466605e-02f, -1.61433332e-02f, -1.26328215e-01f, -2.01665059e-01f, 1.67976879e-02f, -1.20646581e-02f,
  -1.08890355e-01f, 2.15955034e-01f, 3.43922116e-02f, -2.15155125e-01f, 2.32330695e-01f, -1.40638083e-01f, -1.08163439e-01f, 3.41261625e-02f, -1.62784100e-01f, -2.34422311e-01f,
  2.25200523e-02f, 3.55389938e-02f, 2.90835043e-03f, -2.33184233e-01f, -9.15237144e-02f, -5.04713058e-02f, 2.38005653e-01f, -3.10020261e-02f, -7.69909769e-02f, 2.47689903e-01f,
  5.37612438e-02f, -2.33678371e-01f, -9.52557996e-02f, -5.86503483e-02f, -6.10896572e-02f, -1.36588458e-02f, -1.66674525e-01f, 7.62397945e-02f, 1.25564665e-01f, 9.91182923e-02f,
  1.80219978e-01f, 1.90118939e-01f, 9.33455827e-04f, 6.55335486e-02f, 4.02784944e-02f, 4.16507907e-02f, -1.75876121e-04f, 9.99164432e-02f, 5.00999056e-02f, -6.69458434e-02f,
  -1.79996639e-01f, 3.28020044e-02f, 3.99077982e-02f, -1.76402450e-01f, 2.15880969e-03f, -5.25632873e-02f, -1.32622495e-01f, -8.52065086e-02f, -4.65432480e-02f, 4.65698875e-02f,
  -5.00756390e-02f, 4.60265577e-02f, -1.10497802e-01f, 1.17999636e-01f, 8.34487453e-02f, 1.48169503e-01f, 2.00802699e-01f, -1.04844779e-01f, 1.49716912e-02f, 9.18828547e-02f,
  1.39204666e-01f, 5.94227854e-03f, -1.59407288e-01f, -1.18322589e-01f, 6.62740171e-02f, -4.90334630e-02f, -1.43773686e-02f, 9.24395844e-02f, -1.79108396e-01f, -6.14293367e-02f,
  8.11851621e-02f, 1.87364206e-01f, 2.10882667e-02f, 1.08593784e-01f, 3.17284986e-02f, 4.00660653e-03f, -8.97231102e-02f, 1.20042816e-01f, -1.14998676e-01f, 3.13714705e-02f,
  -2.34661847e-01f, 4.42109853e-02f, 1.49405703e-01f, -1.10624440e-01f, 5.69795370e-02f, 4.77386303e-02f, 7.59209692e-02f, 2.38463670e-01f, 1.16699617e-02f, 2.26442516e-02f,
  3.19976099e-02f, -9.50154290e-02f, -7.09936917e-02f, -6.71628565e-02f, -1.56464964e-01f, -3.63057181e-02f, -3.52801532e-02f, -1.58106908e-01f, -1.25922725e-01f, 9.83171090e-02f,
  1.82354331e-01f, -2.02453345e-01f, -5.29281124e-02f, -1.09661318e-01f, 6.53308183e-02f, -1.55230062e-02f, -6.92910049e-03f, 1.99961156e-01f, -2.18643650e-01f, 1.39113054e-01f,
  -7.21117333e-02f, 2.28636507e-02f, 1.79844022e-01f, -1.78247929e-01f, -1.53081939e-02f, -1.34637048e-02f, -2.84641534e-02f, -1.67603537e-01f, -8.44881162e-02f, -1.30462855e-01f,
  -4.07109363e-03f, -1.72724463e-02f, -9.05783698e-02f, -6.93242550e-02f, -2.33046621e-01f, -6.39118105e-02f, 7.76689202e-02f, 1.25616178e-01f, 2.44693369e-01f, 1.55640841e-01f,
  -3.32294047e-01f, 7.80518875e-02f, -5.70341060e-03f, 1.69931099e-01f, 1.99370123e-02f, -1.41787142e-01f, 1.02770902e-01f, -1.94281176e-01f, 1.50239080e-01f, -9.30439755e-02f,
  -5.86062297e-03f, 9.91970897e-02f, -2.83656418e-02f, -2.29794860e-01f, 8.54654759e-02f, 1.29802465e-01f, -3.89756933e-02f, 1.28972515e-01f, -8.65628496e-02f, -3.12971734e-02f,
  5.60461283e-02f, -2.17796266e-01f, -1.59640133e-01f, -5.30809015e-02f, -1.25450939e-02f, 1.12886675e-01f, 1.52876198e-01f, 6.73367903e-02f, 9.87395942e-02f, 1.35065079e-01f,
  2.03709424e-01f, -1.34426579e-01f, -9.17061940e-02f, -2.63084441e-01f, -1.70339108e-01f, 9.10017490e-02f, 6.75203651e-02f, 8.14905167e-02f, 1.14288934e-01f, 5.42187206e-02f,
  -4.14891681e-03f, 2.01170668e-01f, -1.35215938e-01f, -5.49994074e-02f, 3.14632654e-02f, -6.84848875e-02f, 4.88356389e-02f, -8.12996086e-03f, 9.79439616e-02f, -9.11803916e-02f,
  -9.99448448e-02f, -1.91823728e-02f, 5.03344759e-02f, 7.00545087e-02f, 9.50174779e-02f, 8.47554281e-02f, -5.89526929e-02f, 2.22443528e-02f, -6.88679516e-02f, -5.80287091e-02f,
  -6.03324585e-02f, 2.11534902e-01f, -1.01400204e-01f, 2.78523177e-01f, -1.86241031e-01f, 3.81394736e-02f, 6.64699776e-03f, 1.82457238e-01f, 1.88030973e-01f, -1.06568672e-01f,
  -7.77501687e-02f, 6.97341487e-02f, 8.67705643e-02f, -2.64359027e-01f, -1.26731411e-01f, 1.46662593e-02f, 2.01490875e-02f, -1.58783808e-01f, -2.90915947e-02f, 1.10949874e-01f,
  4.56453785e-02f, 2.55035311e-01f, -5.89622073e-02f, 4.58359346e-02f, -7.77648911e-02f, -2.48452961e-01f, -2.88522076e-02f, 5.37395775e-02f, -9.73245725e-02f, -1.06501710e-02f,
  6.98858574e-02f, 3.34286034e-01f, -9.07667428e-02f, 1.45776235e-02f, 1.98856890e-02f, -1.46747902e-01f, -1.26965299e-01f, 8.24616328e-02f, 8.74471590e-02f, -3.00078280e-02f,
  1.35243004e-02f, -4.63568643e-02f, 1.12616077e-01f, 1.37357622e-01f, 1.28015161e-01f, 1.92703873e-01f, -2.18205750e-02f, 1.17320739e-01f, 1.70513034e-01f, -5.00079952e-02f,
  1.11823745e-01f, -1.85590237e-01f, 1.66187018e-01f, 1.09989315e-01f, 6.11197837e-02f, -8.40329602e-02f, 6.57996610e-02f, 1.37327462e-01f, -3.70737463e-02f, 1.56602442e-01f,
  -1.32619748e-02f, -9.62354764e-02f, -9.73090157e-02f, 1.14121474e-01f, 1.95777893e-01f, 2.83387620e-02f, 2.36444566e-02f, 6.09460846e-02f, 1.24437682e-01f, 1.88735351e-01f,
  1.99243098e-01f, 4.04655840e-03f, -2.20194608e-01f, 3.29532027e-02f, -9.09921378e-02f, -1.10815004e-01f, 1.50519818e-01f, 7.01838136e-02f, -8.44278187e-02f, 6.09029606e-02f,
  -1.24631092e-01f, -2.24050686e-01f, -6.89513087e-02f, -1.66934177e-01f, -2.21613526e-01f, 7.85515159e-02f, 1.01513319e-01f, 1.85938999e-02f, 1.08016506e-01f, 1.11277048e-02f,
  1.25682861e-01f, -4.58480045e-02f, 5.23651426e-04f, 2.54353415e-03f, -7.56737664e-02f, 1.59009948e-01f, -9.20729563e-02f, 1.41000792e-01f, -1.44983411e-01f, -3.37866060e-02f,
  -1.84680492e-01f, -1.20156005e-01f, 1.27857223e-01f, 1.48287639e-01f, -2.45324969e-01f, -1.59389079e-01f, 1.07278079e-01f, -3.48954536e-02f, -7.95737281e-02f, -3.70186120e-02f,
  -7.74122402e-02f, -6.29079267e-02f, -3.92141333e-03f, 1.35189164e-02f, 1.53822422e-01f, 1.32965222e-01f, 6.11868761e-02f, -1.00200646e-01f, -9.40115005e-02f, -8.29025581e-02f,
  -7.76968598e-02f, 8.47822800e-02f, -2.08767178e-03f, 7.51622170e-02f, -5.61277755e-02f, -5.75111695e-02f, 1.71860263e-01f, -1.01509253e-02f, -1.16433233e-01f, -1.48359552e-01f,
  -5.47483116e-02f, -3.19900587e-02f, 1.68646574e-02f, 1.72476858e-01f, 1.21148601e-01f, -7.70354196e-02f, 2.71657348e-01f, -1.36449054e-01f, 2.01160293e-02f, -1.23958036e-01f,
  -1.33526251e-01f, -4.16499749e-02f, 7.89854378e-02f, 5.41253798e-02f, 5.21087721e-02f, 1.81942865e-01f, -1.35937467e-01f, -9.46890712e-02f, -1.23144994e-02f, 9.06385183e-02f,
  -1.43588662e-01f, 1.95704907e-01f, -1.02820791e-01f, -1.33704051e-01f, 1.36257052e-01f, 1.49044976e-01f, -1.51922867e-01f, -1.63030460e-01f, -1.29622430e-01f, 2.23263562e-01f,
  4.15022708e-02f, -2.49002159e-01f, -8.34345445e-02f, 3.09026949e-02f, -2.25762188e-01f, -1.08469091e-01f, -1.42647233e-02f, -1.13794006e-01f, -6.09593280e-02f, 7.80140907e-02f,
  -7.30815455e-02f, -7.97626525e-02f, -1.00386003e-02f, -6.20197207e-02f, 4.05229405e-02f, 7.24344254e-02f, 1.47387326e-01f, 1.12614788e-01f, 3.52515392e-02f, 1.58678859e-01f,
  -7.67025799e-02f, 1.22388631e-01f, -4.87922877e-02f, 6.88020466e-03f, -6.48334622e-02f, 5.23002297e-02f, -5.81832863e-02f, -2.31495891e-02f, 6.07491843e-02f, -6.18021656e-03f,
  1.52381435e-01f, 4.83643115e-02f, -2.02922784e-02f, -2.04496067e-02f, 5.75651135e-03f, -9.18694511e-02f, -1.60993182e-03f, 2.22823694e-01f, -2.07163125e-01f, 1.33583158e-01f,
  1.35964766e-01f, 7.17436969e-02f, -1.52762935e-01f, 1.38033360e-01f, -1.60477921e-01f, -7.57259727e-02f, 2.10260600e-01f, 1.06031284e-01f, -5.18917330e-02f, -9.62905362e-02f,
  -1.48661479e-01f, -1.13009989e-01f, 3.90853770e-02f, -1.16998769e-01f, 1.67922348e-01f, 1.66439176e-01f, -6.09246083e-02f, 6.63507730e-02f, 8.94007683e-02f, -6.64563552e-02f,
  5.15344776e-02f, -1.15856305e-01f, -1.52484819e-01f, 1.99601606e-01f, 8.07136446e-02f, -8.43076780e-02f, -3.93047743e-03f, -6.03612140e-02f, -1.06483556e-01f, 2.81817690e-02f,
  1.48161739e-01f, -4.54979800e-02f, 6.36418164e-02f, 5.62399141e-02f, 1.45657295e-02f, -1.55994937e-01f, 4.37573008e-02f, 1.19846486e-01f, -6.71520755e-02f, 8.95689428e-02f,
  -4.17916700e-02f, -1.38296932e-01f, -5.57245910e-02f, 9.33788866e-02f, -6.39307201e-02f, -2.24298574e-02f, 5.08938320e-02f, -9.50950757e-03f, -8.51744190e-02f, -5.14239771e-03f,
  5.43798730e-02f, 3.66558917e-02f, -1.00384831e-01f, -5.63579835e-02f, 1.11384831e-01f, -5.50842471e-02f, 4.40882593e-02f, 7.88090453e-02f, -5.36971465e-02f, 3.11432015e-02f,
  -2.38766521e-01f, 1.18435979e-01f, -1.55401275e-01f, 1.65736318e-01f, 1.90907985e-01f, -9.07550752e-02f, -2.22930312e-02f, -1.70809962e-02f, -2.23228663e-01f, -1.16924182e-01f,
  1.39900610e-01f, 7.22966641e-02f, 1.75941307e-02f, 1.38586953e-01f, -9.04144570e-02f, 6.15275726e-02f, 6.20077550e-02f, 1.43144637e-01f, 4.81624864e-02f, 1.52660832e-01f,
  8.72866996e-03f, -9.60235968e-02f, -5.97738102e-02f, 4.56402861e-02f, -1.56553894e-01f, 1.55248597e-01f, -4.75778915e-02f, 2.72297323e-01f, -1.41485706e-01f, -3.25412527e-02f,
  8.86726826e-02f, -2.17998043e-01f, -1.61479801e-01f, 3.68649252e-02f, 1.61792114e-01f, -2.11932257e-01f, 4.28653657e-02f, -1.47792190e-01f, 1.17688924e-01f, 1.19217955e-01f,
  -4.95169172e-03f, 1.43591180e-01f, -8.97478536e-02f, 2.80645251e-01f, 2.62249485e-02f, -6.74993694e-02f, 8.60591829e-02f, 1.56467631e-01f, -4.54192609e-02f, 1.24928735e-01f,
  6.74258694e-02f, -1.14174113e-01f, 5.47330268e-02f, 8.36222842e-02f, -1.90479141e-02f, -3.73561792e-02f, 9.63943377e-02f, 1.13997802e-01f, 6.30097240e-02f, 1.61969826e-01f,
  5.17650768e-02f, 9.52071771e-02f, 2.50400186e-01f, -4.42742333e-02f, -8.09724908e-03f, -3.75132859e-02f, -1.79310024e-01f, 2.44723693e-01f, 9.19298753e-02f, -1.67160124e-01f,
  3.94916944e-02f, 1.12086266e-01f, -1.43053785e-01f, 1.75245345e-01f, 1.01962395e-01f, 2.78962523e-01f, -1.02553619e-02f, -8.94512162e-02f, -5.64862825e-02f, -1.71826124e-01f,
  1.41453743e-01f, -1.94354326e-01f, 1.84378415e-01f, 9.63341736e-04f, 6.51683658e-02f, -6.59189150e-02f, -5.74378781e-02f, -4.35543247e-02f, 1.56814081e-03f, 6.56644776e-02f,
  -1.32319078e-01f, 4.47450913e-02f, -2.02481970e-02f, -1.34484358e-02f, -1.00163162e-01f, -1.60815582e-01f, -1.52376682e-01f, 9.07357782e-03f, -4.42191307e-03f, 1.18344296e-02f
};

// L2_fan_Wp_bar (Shape: 14 x 64)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  9.98730883e-02f, 9.28112119e-03f, 1.46061242e-01f, -1.47382572e-01f, -3.82847227e-02f, -2.76701394e-02f, 1.09252080e-01f, 1.65300295e-01f, -1.84912945e-03f, 8.04929212e-02f,
  3.78311053e-02f, 5.56874014e-02f, -1.06243260e-01f, 7.57758133e-03f, -4.94289324e-02f, 6.78175241e-02f, 1.52378023e-01f, -3.72111090e-02f, 1.97783887e-01f, 1.78677782e-01f,
  3.06259431e-02f, -3.11094709e-02f, 7.89850205e-02f, 7.79078230e-02f, 8.09001848e-02f, -7.07351342e-02f, -2.34196812e-01f, -7.17067765e-03f, -1.33946957e-02f, -3.15441847e-01f,
  -9.97957364e-02f, -1.17996022e-01f, -1.82623491e-01f, -1.57939065e-02f, -9.15273950e-02f, 2.21437979e-02f, -2.16133460e-01f, 2.36274108e-01f, -2.28071302e-01f, -2.78639495e-01f,
  4.31254432e-02f, 1.69998169e-01f, 3.38005364e-01f, 1.10879309e-01f, 6.55436814e-02f, 3.31504494e-02f, -3.28535944e-01f, -1.73099458e-01f, 1.74660832e-01f, 4.78159860e-02f,
  -4.56477515e-02f, 1.88783854e-01f, -1.37941197e-01f, 1.75696671e-01f, 7.70208389e-02f, -1.67460993e-01f, 1.88641325e-02f, 1.60902530e-01f, 2.54234284e-01f, 3.56540322e-01f,
  2.50963777e-01f, 1.51431516e-01f, -3.06385309e-02f, -9.26527828e-02f, -8.27909857e-02f, 1.85822248e-01f, 1.31838873e-01f, 2.39682838e-01f, 2.44585335e-01f, 1.11285523e-01f,
  6.36848211e-02f, 1.10482186e-01f, 2.02407688e-01f, 2.03333244e-01f, 3.04139286e-01f, 2.68363710e-02f, 1.30294040e-01f, 2.76916444e-01f, 2.41790846e-01f, 2.05286443e-01f,
  1.25961471e-02f, 1.31423384e-01f, 2.56609708e-01f, 8.89049694e-02f, 1.11717574e-01f, 1.17647707e-01f, 1.63702309e-01f, 4.91849631e-02f, -7.25756865e-03f, 3.01849544e-01f,
  1.74872056e-01f, 2.42156252e-01f, -4.25107963e-02f, 3.12941551e-01f, 3.20228375e-02f, 3.47148806e-01f, 1.80172697e-01f, -9.94599536e-02f, -4.64733802e-02f, 6.81594200e-03f,
  -2.54516363e-01f, -3.03820401e-01f, 1.52761027e-01f, 3.69974449e-02f, -8.40405896e-02f, -1.69338789e-02f, -3.14787835e-01f, -1.95548288e-03f, 6.85533881e-02f, 1.48560330e-01f,
  2.27738291e-01f, 3.60084713e-01f, 1.17602840e-01f, -7.29411468e-02f, 2.79852122e-01f, 2.31641442e-01f, 8.07999149e-02f, 1.24624640e-01f, -1.15204968e-01f, 3.41877609e-01f,
  9.80686173e-02f, -1.73737764e-01f, 8.89446214e-02f, -2.58580983e-01f, -2.01414123e-01f, 1.31969571e-01f, 3.37430596e-01f, -1.37164637e-01f, 1.78448662e-01f, 1.75077349e-01f,
  1.04519986e-02f, -1.84950251e-02f, -4.01338972e-02f, 1.56544954e-01f, 3.56107131e-02f, 7.17709363e-02f, -5.75839207e-02f, 1.27110705e-01f, 1.76263139e-01f, 6.66743815e-02f,
  -1.39593497e-01f, -7.28594661e-02f, -3.24971303e-02f, 2.14566544e-01f, -5.54639921e-02f, -1.84216529e-01f, 1.63620904e-01f, 1.11704014e-01f, 1.27398252e-01f, 1.02563664e-01f,
  -7.55579025e-02f, -1.62345201e-01f, -3.55626643e-02f, 6.72682449e-02f, -2.01906562e-01f, 1.36365250e-01f, -1.15826860e-01f, -2.54079312e-01f, 1.37507930e-01f, 1.59182966e-01f,
  1.12742282e-01f, -1.61971942e-01f, -2.20872462e-01f, 1.43711045e-02f, -1.68814421e-01f, -1.62371352e-01f, -2.79564440e-01f, -1.04938656e-01f, 4.90979217e-02f, 1.75467089e-01f,
  9.52553451e-02f, 5.25729582e-02f, 5.86955398e-02f, 4.94037643e-02f, -3.36267680e-01f, 3.33259851e-02f, 2.18170345e-01f, -2.52785925e-02f, -7.65934885e-02f, 2.46611670e-01f,
  -2.17195049e-01f, 1.42998904e-01f, 9.25068706e-02f, 1.12839431e-01f, -2.00869609e-02f, 2.29005255e-02f, 3.32112163e-01f, 9.96368453e-02f, 1.90010384e-01f, -5.14006726e-02f,
  -1.42116159e-01f, -1.29078686e-01f, 4.76600826e-02f, 1.47006482e-01f, 4.01661545e-02f, 6.86471239e-02f, 2.25178041e-02f, 2.19276115e-01f, 9.58200246e-02f, 2.66588718e-01f,
  1.23283058e-01f, 2.65720159e-01f, 3.39658223e-02f, 2.61523664e-01f, -2.89498437e-02f, 2.25123614e-01f, 2.58413851e-01f, 1.00334801e-01f, 7.43384883e-02f, 1.17006317e-01f,
  5.82193621e-02f, 5.93637116e-02f, -4.94286651e-03f, 8.67646039e-02f, 2.89077818e-01f, 2.97812879e-01f, 1.25288248e-01f, 1.30393550e-01f, 4.06311184e-01f, -8.47652033e-02f,
  9.78714079e-02f, 2.96259671e-01f, -2.55484819e-01f, 1.93204284e-01f, 1.36115626e-01f, -1.25074998e-01f, 7.50427619e-02f, 2.36334577e-01f, -1.38916550e-02f, 1.74956858e-01f,
  2.54056215e-01f, 3.45938057e-01f, 2.22048033e-02f, -2.25399897e-01f, -2.89148390e-01f, -2.59704828e-01f, 2.43997917e-01f, -3.45104158e-01f, 1.58018067e-01f, 5.92457540e-02f,
  2.52897710e-01f, -6.33776262e-02f, 2.15594336e-01f, -3.60851586e-02f, 1.42427057e-01f, 4.88399854e-03f, 6.62715733e-02f, -3.39540816e-03f, -2.32890043e-02f, -1.89263359e-01f,
  -4.18498628e-02f, 1.11179397e-01f, -5.36210760e-02f, 2.83067018e-01f, 2.57666588e-01f, 1.68842718e-01f, 9.31557864e-02f, -9.13742557e-02f, 8.59544612e-03f, 1.26661614e-01f,
  6.16456196e-02f, -9.37606618e-02f, -2.12218612e-02f, 5.99852623e-03f, 4.65239696e-02f, 7.35581964e-02f, -5.08717559e-02f, 5.85029041e-03f, 1.85348064e-01f, 7.76228607e-02f,
  -2.00113077e-02f, 1.63170159e-01f, -1.42599363e-02f, -2.43202988e-02f, -4.63838018e-02f, 1.44376993e-01f, -8.28508567e-03f, -7.86685497e-02f, 1.44912198e-01f, 1.45252282e-02f,
  -5.05660065e-02f, -6.80334913e-03f, -3.95849764e-01f, 1.77570358e-01f, 2.34675989e-01f, -3.14428687e-01f, 4.46370356e-02f, -1.48837864e-02f, 1.61100030e-01f, 1.00000441e-01f,
  -2.49186948e-01f, -7.42455646e-02f, -1.99729428e-01f, 4.98007983e-02f, 1.06303006e-01f, -2.35888481e-01f, -2.46730000e-01f, 3.57448041e-01f, 2.41266236e-01f, -8.70459750e-02f,
  -1.92204386e-01f, 1.42833799e-01f, -3.12293887e-01f, -1.12437993e-01f, -1.94833800e-01f, 2.28364412e-02f, -4.51090410e-02f, 1.79199502e-01f, -2.95566827e-01f, 1.09164745e-01f,
  -9.57412794e-02f, 7.47450721e-03f, 1.44596666e-01f, -1.86981902e-01f, 1.74902275e-01f, 1.77377611e-01f, 2.14291155e-01f, 1.75259471e-01f, 7.00529665e-02f, -1.22350626e-01f,
  -6.62674680e-02f, 1.93497201e-03f, -2.59658955e-02f, 1.85346901e-01f, -8.58463570e-02f, -1.55622959e-01f, 1.50661319e-01f, -3.17843184e-02f, 2.67181337e-01f, 2.88855284e-01f,
  4.29111309e-02f, 2.43223399e-01f, 1.55243054e-01f, 8.87207016e-02f, 2.45557148e-02f, 5.01343720e-02f, 1.11048371e-01f, -6.92352513e-03f, 1.28385603e-01f, 1.51054218e-01f,
  9.71718431e-02f, 1.11164361e-01f, 3.29620957e-01f, 1.21156499e-01f, 1.06399454e-01f, -1.06550567e-01f, -2.23521709e-01f, 4.90729585e-02f, 3.63465965e-01f, 1.93019602e-02f,
  1.78300381e-01f, -2.39575177e-01f, 1.87367156e-01f, 1.37659118e-01f, 1.30165249e-01f, -1.93761393e-01f, -9.82635319e-02f, 2.37852633e-01f, 1.91352889e-01f, -3.25060971e-02f,
  -9.18567739e-03f, 7.88896531e-02f, 1.36053979e-01f, -2.54295021e-01f, -1.82872675e-02f, -1.25340402e-01f, 6.62066340e-02f, -1.58104569e-01f, -2.02277482e-01f, -1.28869042e-02f,
  2.73372263e-01f, -1.40525445e-01f, -1.49298087e-02f, -1.32749215e-01f, 1.27039822e-02f, 1.79911390e-01f, 1.63314044e-01f, -5.91590106e-02f, -5.90581670e-02f, 2.77980357e-01f,
  9.48140547e-02f, 8.49356875e-02f, 1.64052516e-01f, 1.89211816e-01f, 2.30823100e-01f, 9.17648226e-02f, 1.96194440e-01f, -7.73670748e-02f, 1.82243660e-01f, 4.00387913e-01f,
  2.41088793e-01f, 1.95992097e-01f, 4.73383665e-02f, 1.27888873e-01f, 3.65179807e-01f, 2.01607972e-01f, -1.25122750e-02f, -1.15229432e-02f, 2.28177905e-01f, -5.34761809e-02f,
  5.12387753e-02f, 1.22708201e-01f, 2.08776847e-01f, -2.87145674e-02f, 1.24053344e-01f, 2.45557413e-01f, -5.28393406e-03f, 1.88697472e-01f, 2.86572099e-01f, 5.19969165e-02f,
  1.12998128e-01f, 1.82105780e-01f, 7.30329156e-02f, 3.58660729e-03f, 1.90617025e-01f, 2.09597096e-01f, -7.43737891e-02f, -2.67007858e-01f, 2.11975858e-01f, 5.58145605e-02f,
  2.66564012e-01f, -1.86588094e-01f, -2.75464684e-01f, -5.90408631e-02f, 1.90308169e-01f, -1.48845151e-01f, -3.04758847e-01f, 5.91351427e-02f, 2.89689362e-01f, -1.17504954e-01f,
  -2.54783601e-01f, 2.62692012e-02f, 1.71232671e-01f, -3.90173376e-01f, 1.12431660e-01f, 1.38542778e-03f, 3.32737923e-01f, 3.35076749e-01f, 3.93374085e-01f, -6.49053976e-02f,
  -1.33769423e-01f, 1.39223620e-01f, 2.40249366e-01f, 3.42571110e-01f, 2.35370435e-02f, -1.75830757e-03f, 2.16653794e-02f, 1.92389071e-01f, 4.36355621e-02f, 1.47108719e-01f,
  -2.61075702e-02f, 2.88644135e-01f, 1.29189894e-01f, -1.62460394e-02f, 1.14527151e-01f, -2.05365255e-01f, 1.36518553e-01f, -2.27953605e-02f, 1.41670942e-01f, 1.36996070e-02f,
  3.21982980e-01f, 1.48486242e-01f, -6.04419457e-03f, 1.72250748e-01f, 2.13165313e-01f, 2.44215786e-01f, -7.13560805e-02f, 1.64781094e-01f, 1.89418629e-01f, 1.25164121e-01f,
  5.61826229e-02f, 1.24616340e-01f, -4.56595495e-02f, 6.29676059e-02f, 7.35241594e-03f, 2.81880409e-01f, 1.14476621e-01f, 2.47036457e-01f, 3.55813295e-01f, -1.70941249e-01f,
  2.99481302e-01f, -8.33275616e-02f, 2.04008371e-01f, -2.51135290e-01f, 3.74773413e-01f, -2.76911445e-03f, 3.01518381e-01f, -1.95924297e-01f, 2.27428153e-01f, -1.14637025e-01f,
  -5.72030880e-02f, -2.71628857e-01f, -1.49796978e-01f, 1.76158801e-01f, 1.51994258e-01f, -1.12290300e-01f, -3.57199371e-01f, -2.02695668e-01f, 3.30513567e-01f, -2.04352379e-01f,
  2.17256352e-01f, -1.76608518e-01f, 1.70456663e-01f, 1.90703884e-01f, 3.52724105e-01f, -5.69636859e-02f, -1.21681519e-01f, 6.33043200e-02f, 1.44621334e-03f, -4.88039888e-02f,
  1.80012748e-01f, 8.05636197e-02f, 1.92787517e-02f, -1.99008491e-02f, 1.15401082e-01f, 2.73029748e-02f, 8.13393369e-02f, -8.89304727e-02f, -5.25938570e-02f, 5.20758256e-02f,
  -6.12448342e-02f, 1.59938365e-01f, 4.08036709e-02f, -1.80346314e-02f, 2.76395261e-01f, 1.52080238e-01f, -5.66981211e-02f, 1.14286505e-01f, 1.39351875e-01f, 1.64162681e-01f,
  -2.68533584e-02f, 1.89147994e-01f, 2.15060681e-01f, -2.35696952e-03f, 1.47482693e-01f, -7.56181106e-02f, 1.25214532e-01f, 5.65058403e-02f, -3.54614556e-01f, 3.57549220e-01f,
  1.50568336e-01f, -1.49329081e-01f, 1.61440134e-01f, 4.94712964e-02f, 2.98509717e-01f, 1.16300255e-01f, -1.69526041e-01f, -3.27634841e-01f, -1.82541519e-01f, -2.47633144e-01f,
  6.44754916e-02f, -3.33377421e-01f, -1.58311695e-01f, 1.29761800e-01f, 1.96460664e-01f, -1.29098371e-01f, 1.74671374e-02f, 2.88977355e-01f, -3.06216218e-02f, 1.12836622e-01f,
  -7.78194666e-02f, -4.53251414e-02f, 8.80403221e-02f, 1.94365889e-01f, -1.04813874e-01f, 1.85772359e-01f, -7.79553410e-03f, 3.59050274e-01f, 2.25785151e-01f, -1.57907426e-01f,
  2.02381849e-01f, -4.17204574e-02f, 1.45493552e-01f, 1.81791261e-01f, 3.26373994e-01f, -3.18016969e-02f, -4.11936119e-02f, -5.02853049e-03f, -1.30006135e-01f, -1.57282054e-01f,
  -2.62024882e-03f, 2.03848392e-01f, -4.06068005e-03f, 6.85037598e-02f, -2.37547979e-01f, 8.26042518e-02f, 3.17947716e-02f, 9.93053988e-02f, -1.12959864e-02f, 1.28549963e-01f,
  -6.68459833e-02f, 6.10486269e-02f, 7.03145936e-02f, 9.18396935e-02f, 8.07515606e-02f, -5.56793250e-03f, 4.40035341e-03f, 9.63137895e-02f, -2.09836550e-02f, -5.36734834e-02f,
  -6.88072387e-03f, 4.65427339e-02f, 9.05697569e-02f, 9.84117985e-02f, -4.30669963e-01f, -8.19958746e-03f, -3.52903642e-02f, 2.23903224e-01f, 1.10111438e-01f, -1.82864740e-01f,
  -2.40125820e-01f, -5.43750189e-02f, 1.05958143e-02f, -4.24463511e-01f, -1.87085390e-01f, -2.56549437e-02f, 2.65728682e-03f, -1.05379604e-01f, -1.26972318e-01f, 1.80503696e-01f,
  2.77556002e-01f, 2.23325685e-01f, -1.04656748e-01f, 2.16439933e-01f, 1.92276612e-01f, -7.99252912e-02f, 1.08712935e-03f, 1.31822184e-01f, -1.52460352e-01f, 2.46177703e-01f,
  3.51395607e-02f, 1.27643257e-01f, -8.92642662e-02f, 2.44446378e-02f, 3.26890141e-01f, -4.76568751e-02f, 1.28269106e-01f, 2.32636750e-01f, 1.14711104e-02f, -1.41735911e-01f,
  7.12370053e-02f, 7.27873743e-02f, -2.68172044e-02f, 2.08208457e-01f, -2.27678791e-02f, -3.19386244e-01f, 1.78356990e-01f, 1.47630334e-01f, 2.10363477e-01f, 9.73968953e-02f,
  -5.41811325e-02f, 2.65898824e-01f, 2.01299638e-01f, 2.85190970e-01f, 8.97062123e-02f, 1.84463263e-01f, 4.67344560e-02f, 1.59129664e-01f, 9.01755244e-02f, 9.36943516e-02f,
  1.61307335e-01f, 3.50289699e-03f, 2.69194961e-01f, 2.62950957e-01f, -7.61733353e-02f, 1.63384110e-01f, -5.77277131e-02f, -1.41111076e-01f, 2.77592450e-01f, 1.66773275e-01f,
  -5.91293722e-02f, 5.51360287e-02f, 3.50449562e-01f, 2.55220443e-01f, 2.56615821e-02f, -3.13826241e-02f, -1.22982142e-02f, 2.91320264e-01f, 4.02781516e-01f, 1.89175215e-02f,
  -5.63971438e-02f, 6.72729239e-02f, 7.28491023e-02f, -2.61856586e-01f, 1.04171224e-01f, -8.33273977e-02f, 2.24411607e-01f, 8.12038854e-02f, -1.01948984e-01f, 1.42052710e-01f,
  1.81733519e-01f, -4.95789796e-02f, 1.30949125e-01f, -1.18288830e-01f, -1.22037470e-01f, 6.65542781e-02f, 2.46734038e-01f, -1.91536978e-01f, -4.95922118e-02f, 1.13849908e-01f,
  4.35213000e-02f, 3.59324992e-01f, 9.43653286e-02f, -2.12807804e-02f, 1.07081458e-01f, 2.74780571e-01f, 1.14653744e-01f, 1.75829306e-02f, 1.59750730e-01f, 1.98121279e-01f,
  4.99373488e-02f, 1.75281897e-01f, 9.97577831e-02f, 1.35219067e-01f, 2.02128828e-01f, 1.15335889e-01f, 9.91711020e-02f, 1.57843098e-01f, 2.81002432e-01f, -2.55161934e-02f,
  2.23665535e-01f, 6.85707182e-02f, -7.14846998e-02f, 8.29485804e-02f, 7.41694421e-02f, 2.40788609e-01f, -7.96902627e-02f, 4.63029519e-02f, 1.35882065e-01f, 9.27814245e-02f,
  2.65205830e-01f, 9.93442386e-02f, -1.73672423e-01f, -5.11403829e-02f, 1.91721916e-01f, -4.73880693e-02f, -6.11652583e-02f, -3.07633370e-01f, 1.12718567e-01f, -1.35405421e-01f,
  2.72301316e-01f, -1.77568793e-01f, -3.14896286e-01f, 1.37381144e-02f, 3.88834715e-01f, -4.06470656e-01f, 1.39594004e-01f, 4.85586673e-02f, -1.18453652e-01f, 5.45644276e-02f,
  6.95085386e-03f, -1.57207891e-01f, 2.54440725e-01f, -3.71680528e-01f, 1.21461391e-01f, -4.43690158e-02f, 3.88329655e-01f, 2.91074216e-01f, 4.49697167e-01f, -6.86350791e-03f,
  1.26695648e-01f, 3.70564848e-01f, 2.00880691e-01f, 2.05540866e-01f, 2.83431411e-01f, -8.06488842e-02f, 7.93200359e-02f, 4.04728591e-01f, 3.40299644e-02f, 1.44707367e-01f,
  -2.91275885e-02f, 8.75451490e-02f, 3.50387432e-02f, 4.30458076e-02f, 3.06283142e-02f, 6.49351701e-02f, 6.07824363e-02f, -9.26820412e-02f, 1.59667522e-01f, -8.60752240e-02f,
  1.11324348e-01f, 4.60148882e-03f, 1.83876678e-01f, 1.58199787e-01f, 5.36207147e-02f, -4.04197443e-03f, 3.88462469e-02f, 5.13111390e-02f, 1.11332923e-01f, 1.10903598e-01f,
  1.25123322e-01f, 6.04874827e-02f, 9.77612659e-02f, 1.54558629e-01f, -2.75792778e-01f, 1.63868472e-01f, 2.13185713e-01f, -4.41048071e-02f, -2.21324101e-01f, 1.06473073e-01f,
  -1.10190161e-01f, -3.90866429e-01f, -2.61604041e-01f, 2.33054817e-01f, -2.53289729e-01f, -4.27583270e-02f, 1.43908158e-01f, 7.22671747e-02f, -5.46557009e-01f, 1.58434808e-01f,
  -1.67438939e-01f, 2.31927425e-01f, 1.61758840e-01f, 1.21672042e-01f, -7.28370473e-02f, 2.82050520e-01f, 1.18790530e-02f, -2.14847535e-01f, 6.48815408e-02f, 5.34028530e-01f,
  -2.15281874e-01f, 1.26430303e-01f, -5.05376995e-01f, 2.03964770e-01f, -2.55836517e-01f, -3.93701375e-01f, -1.07664526e-01f, -9.58463624e-02f, -1.98377624e-01f, 2.83966660e-01f,
  1.81191847e-01f, -2.62980551e-01f, 1.68682531e-01f, -2.67877784e-02f, 1.03420734e-01f, -9.63485017e-02f, -7.61905760e-02f, -5.43778464e-02f, 1.47647753e-01f, 5.74042723e-02f,
  -7.36880675e-02f, 2.01245293e-01f, 7.72860274e-02f, 2.78285053e-02f, 1.48226276e-01f, 1.79741636e-01f, -7.71011710e-02f, 2.78361589e-01f, -5.33347651e-02f, -6.12901486e-02f,
  4.61932197e-02f, 1.15433447e-02f, 1.90165788e-01f, -1.91241782e-03f, 7.77069554e-02f, 3.41083184e-02f, 2.43370891e-01f, -1.12102799e-01f, -3.23009819e-01f, 4.99925353e-02f,
  -4.34701554e-02f, -3.54631364e-01f, -6.40998408e-02f, -1.13663256e-01f, 5.69979437e-02f, 1.05096921e-01f, -7.48582557e-03f, -6.14530109e-02f, -2.09757864e-01f, 2.36610249e-01f,
  -1.06665909e-01f, -1.59965575e-01f, -2.52959803e-02f, 3.46237034e-01f, 3.61373574e-01f, 4.08332758e-02f, 1.72245428e-02f, -5.15545383e-02f, -3.63132477e-01f, -2.04166666e-01f,
  1.25599951e-01f, 1.52157649e-01f, -1.62608117e-01f, 1.69362769e-01f, -1.84560984e-01f, 2.37971470e-01f, 1.17334127e-02f, 7.32823908e-02f, 1.78929776e-01f, 1.90998182e-01f,
  1.82171062e-01f, 2.77177602e-01f, 3.02064210e-01f, 1.18901096e-01f, -1.12192407e-01f, 1.43421307e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  1.88230097e-01f, 7.25913048e-02f, -6.08706400e-02f, 2.75776923e-01f, -5.02797589e-03f, 1.09600089e-01f, 2.54078239e-01f, 1.65385470e-01f, 4.23644520e-02f, 5.69805503e-03f,
  2.24837318e-01f, 1.32759914e-01f, 1.11768663e-01f, 8.35012719e-02f
};

// L3_fan_Wp (Shape: 25 x 64)
const int L3_fan_Wp_rows = 25;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  -4.62417491e-02f, 1.45801574e-01f, -2.19453555e-02f, -8.05230066e-02f, 1.87984496e-01f, 1.76329136e-01f, -4.64658625e-02f, 5.73691390e-02f, -6.09130226e-02f, -9.03009176e-02f,
  -1.13881342e-01f, -8.46556723e-02f, 3.73270549e-02f, -1.86989889e-01f, -6.99711964e-02f, -2.07096916e-02f, -3.97277214e-02f, -6.90706726e-03f, -2.07860753e-01f, -1.96042042e-02f,
  1.01085335e-01f, 1.54099688e-02f, 1.79387629e-01f, 1.08431496e-01f, 9.11123119e-03f, -9.63638127e-02f, -2.24981263e-01f, -1.34377065e-03f, -8.75757113e-02f, -1.33200660e-01f,
  1.09556787e-01f, -6.67652786e-02f, -5.21359127e-03f, 7.83052444e-02f, 2.10522562e-01f, -1.34519354e-01f, 1.47451818e-01f, -2.46140450e-01f, -4.74027917e-02f, 8.72379467e-02f,
  -1.82441875e-01f, 5.28124720e-02f, 1.44947514e-01f, 4.83242907e-02f, -1.82729922e-02f, -5.76155111e-02f, -3.00434884e-02f, -1.17739595e-01f, 1.63197011e-01f, 8.37645307e-02f,
  1.58205271e-01f, 1.07272878e-01f, -5.08316001e-03f, 1.08620249e-01f, 1.84547037e-01f, -7.51972124e-02f, -1.24373488e-01f, -1.94571793e-01f, 1.45746976e-01f, 1.78787842e-01f,
  1.23573370e-01f, -1.43106669e-01f, -1.22837909e-01f, -3.61663550e-02f, 1.25360742e-01f, -9.01816040e-02f, -1.39303729e-01f, -2.72619873e-02f, -4.01359313e-04f, -2.38735467e-01f,
  1.13399945e-01f, 1.77769795e-01f, 2.47553498e-01f, 1.35046363e-01f, -1.01033575e-03f, 5.81705850e-03f, -2.83136088e-02f, 8.15395862e-02f, 3.96742932e-02f, -7.11947158e-02f,
  2.82444563e-02f, 7.39239082e-02f, 1.49793193e-01f, -1.19820520e-01f, -1.50067493e-01f, 4.74936925e-02f, -1.73575401e-01f, -1.55301541e-01f, -1.34112686e-01f, -1.99495424e-02f,
  3.01229656e-01f, -2.27826573e-02f, -7.18500242e-02f, 9.81378034e-02f, 2.72401422e-02f, 1.12272859e-01f, 6.46058917e-02f, 7.94303790e-02f, -2.70842258e-02f, 2.56298304e-01f,
  7.67945219e-03f, 1.97912976e-01f, 1.96393766e-02f, -1.72605544e-01f, 2.71959513e-01f, 3.71970423e-02f, -1.94073126e-01f, 5.97238950e-02f, -3.52108758e-03f, 1.65951699e-01f,
  9.75697264e-02f, 1.25018712e-02f, -1.62027448e-01f, -1.02787726e-02f, -4.61272486e-02f, -1.76896639e-02f, -2.13018253e-01f, -9.59581956e-02f, 6.23775683e-02f, 5.97510822e-02f,
  -2.59239506e-02f, -3.66415828e-02f, 7.78707191e-02f, -2.01125190e-01f, 2.52664536e-02f, 1.49060950e-01f, -1.48482010e-01f, -3.35065499e-02f, 1.03427405e-02f, 5.87603115e-02f,
  9.32983384e-02f, 1.10086635e-01f, -3.84801775e-02f, -1.32365059e-02f, 1.47331089e-01f, 1.12336554e-01f, 5.75704016e-02f, 1.20314211e-01f, -2.43879762e-02f, -9.53816772e-02f,
  -9.06183794e-02f, 1.65879741e-01f, -7.87797123e-02f, 1.17054060e-01f, 1.56716302e-01f, 1.29139930e-01f, 9.62187275e-02f, 1.47885494e-02f, 4.46492545e-02f, 8.32686573e-03f,
  6.84359297e-02f, -4.93751727e-02f, 1.27731249e-01f, -1.00191675e-01f, 1.32980675e-01f, -6.96003288e-02f, -4.77518290e-02f, -8.28582793e-03f, -1.71389729e-01f, 3.21551934e-02f,
  1.02755658e-01f, -5.07191233e-02f, -1.87639609e-01f, 2.86477767e-02f, -2.01099679e-01f, 1.69991300e-01f, -5.08092865e-02f, -1.61787972e-01f, -2.02456951e-01f, -1.40748665e-01f,
  -1.80174604e-01f, 7.22132400e-02f, -3.71178845e-04f, 5.00937104e-02f, -5.06827421e-02f, 3.80809605e-02f, 8.18631575e-02f, 4.77525741e-02f, -1.99018270e-01f, -1.99667346e-02f,
  -1.10307835e-01f, -6.39117435e-02f, -1.23024344e-01f, 3.77286747e-02f, 2.35337615e-01f, 1.14177980e-01f, 6.23020828e-02f, -1.06659248e-01f, 1.70557275e-02f, 5.68759106e-02f,
  -5.37971742e-02f, -1.15307517e-01f, 9.50232372e-02f, -4.68442813e-02f, 1.18779920e-01f, 7.49196811e-03f, -1.10648885e-01f, 1.41438261e-01f, 3.30560245e-02f, 5.88539094e-02f,
  9.93458927e-02f, 3.44814546e-02f, 3.04601174e-02f, 1.29729196e-01f, 2.49710381e-01f, 1.33264765e-01f, -5.06082289e-02f, 1.78407833e-01f, 1.52247883e-02f, -1.24827353e-02f,
  3.26496810e-02f, -4.52418663e-02f, -1.54693291e-01f, -1.66980729e-01f, -3.17695248e-03f, 5.59186414e-02f, 9.61319804e-02f, 1.03677087e-01f, 1.63218096e-01f, -1.13202788e-01f,
  6.68754503e-02f, 2.69852020e-02f, 2.06321210e-01f, 1.14312761e-01f, 1.37291774e-01f, -2.02121645e-01f, 7.15835840e-02f, 1.36838078e-01f, 2.05559328e-01f, 1.81814939e-01f,
  1.99925855e-01f, -2.56375611e-01f, 3.06100756e-01f, -1.11210831e-01f, -1.51168173e-02f, 5.67668602e-02f, -2.40838215e-01f, 2.02948283e-02f, 7.02837929e-02f, -2.98960879e-02f,
  1.63268279e-02f, 2.78469235e-01f, -3.43324766e-02f, -3.92363109e-02f, -1.12025015e-01f, 8.38900581e-02f, -7.08715096e-02f, -1.49765387e-02f, -2.80482285e-02f, -3.75025086e-02f,
  -1.18829772e-01f, -1.68566078e-01f, 9.79380980e-02f, 8.79422724e-02f, -1.06069677e-01f, 2.37397790e-01f, 5.81154861e-02f, 1.55908018e-01f, -1.23359606e-01f, -2.28203796e-02f,
  -1.61281273e-01f, -4.30472083e-02f, -8.35490152e-02f, -7.35042915e-02f, -1.25689447e-01f, 9.78291631e-02f, 1.26114432e-02f, -9.29992944e-02f, 8.80743936e-02f, -3.03448755e-02f,
  5.35558201e-02f, 4.76821922e-02f, 1.04006022e-01f, -7.39890784e-02f, -4.18577492e-02f, -8.14184919e-02f, -1.11848772e-01f, 2.49330942e-02f, 1.39153123e-01f, 7.42871091e-02f,
  -3.26950140e-02f, 2.22224697e-01f, 4.01542708e-03f, -3.46685871e-02f, 6.39922097e-02f, 2.49440428e-02f, 1.01068072e-01f, -8.18597618e-03f, 1.04313027e-02f, -1.52094841e-01f,
  7.40392134e-02f, 2.68093377e-01f, -3.04067079e-02f, 2.07664073e-01f, 1.15156204e-01f, -6.41236603e-02f, 2.07881555e-01f, -7.12662339e-02f, -5.52475192e-02f, -3.68579887e-02f,
  -2.63688326e-01f, 6.91900030e-02f, -6.59156814e-02f, 5.83629571e-02f, -1.46153823e-01f, 8.28878805e-02f, -6.03745729e-02f, 5.86314350e-02f, -1.15390472e-01f, 2.20997021e-01f,
  -3.28394994e-02f, 1.36682138e-01f, -1.83986165e-02f, -1.62612975e-01f, -1.33611977e-01f, -1.19996238e-02f, 1.23198539e-01f, -1.61740720e-01f, 1.12028331e-01f, -9.42641217e-03f,
  1.51709337e-02f, -1.22605145e-01f, 9.13981646e-02f, -5.76643050e-02f, -1.15552038e-01f, -5.49903996e-02f, 4.06588204e-02f, 5.87900281e-02f, 7.35120568e-03f, 1.58305451e-01f,
  -6.51456192e-02f, -8.38782936e-02f, 7.45867640e-02f, -3.45868431e-02f, 5.95451042e-04f, -1.24994338e-01f, -5.41366190e-02f, -1.32991403e-01f, -3.49119082e-02f, -4.61652353e-02f,
  9.01944190e-03f, -6.82518110e-02f, -1.61899835e-01f, 5.02544455e-02f, -4.20990773e-02f, -3.30019109e-02f, 1.85505718e-01f, 2.82621048e-02f, 1.45471722e-01f, -1.48837864e-01f,
  1.22825429e-01f, 1.18234009e-01f, -5.68538047e-02f, -2.12874766e-02f, -1.07788607e-01f, 1.73964858e-01f, -1.81075320e-01f, 1.94250733e-01f, 8.81161448e-03f, -2.21711293e-01f,
  1.73561722e-01f, -5.59491776e-02f, -6.47393167e-02f, 1.03201024e-01f, -7.22502172e-02f, -8.23585391e-02f, 1.54128507e-01f, 1.15318276e-01f, 1.09429443e-02f, -1.07848711e-01f,
  4.54308651e-02f, -6.82480559e-02f, 1.16799437e-02f, 4.63266671e-02f, -1.25412822e-01f, -8.36564228e-02f, 1.23774685e-01f, 1.10139921e-01f, -1.54462740e-01f, -4.78864908e-02f,
  -2.06216499e-01f, -2.88984459e-03f, -1.25119418e-01f, -3.83101702e-02f, 4.00638469e-02f, 9.83042046e-02f, -1.65354069e-02f, 1.93239272e-01f, 4.78991605e-02f, 4.82485071e-03f,
  1.31837472e-01f, -2.07337141e-02f, 1.72696948e-01f, 2.36622453e-01f, 6.40591383e-02f, -4.86665033e-02f, -5.03292307e-02f, -2.75029372e-02f, 1.23458788e-01f, -1.49223814e-02f,
  -6.33345335e-04f, 1.72765851e-01f, 9.59083438e-02f, 6.97532073e-02f, 1.25874430e-01f, -7.96497166e-02f, 9.07154679e-02f, 3.41793038e-02f, 1.08885795e-01f, -1.61622986e-01f,
  1.47015944e-01f, 1.01280309e-01f, 1.76855192e-01f, 1.65043801e-01f, -9.54030454e-02f, -8.24072808e-02f, 3.25021178e-01f, 1.03025466e-01f, -1.58173576e-01f, 3.18158455e-02f,
  5.21070212e-02f, 2.51558006e-01f, 1.00384958e-01f, 7.07873628e-02f, -1.38579801e-01f, -1.18982745e-03f, 7.57183656e-02f, -6.99668005e-02f, -6.01995774e-02f, -2.43464783e-02f,
  -1.05546609e-01f, 1.15627408e-01f, -2.72206962e-01f, 3.69348912e-03f, -1.44844219e-01f, -5.41088954e-02f, -1.26459882e-01f, 4.36915867e-02f, 1.76954716e-02f, 2.11110879e-02f,
  -4.71283793e-02f, 2.17530280e-01f, -2.82129534e-02f, -9.55463871e-02f, 1.41542673e-01f, 4.67735045e-02f, -2.58167237e-02f, -1.87726691e-02f, -1.43907219e-01f, -5.03651798e-02f,
  7.69494995e-02f, -4.23058681e-03f, 1.30623549e-01f, 1.15292519e-01f, 7.25964904e-02f, 1.25259444e-01f, -2.05629528e-01f, -2.37547368e-01f, 1.82109736e-02f, -2.82058623e-02f,
  -6.97988868e-02f, -2.87407488e-02f, 5.08545786e-02f, -4.02281210e-02f, -4.98551615e-02f, 8.54770690e-02f, -1.63717002e-01f, 5.53756393e-02f, -2.44474597e-02f, 5.33458367e-02f,
  8.39194097e-03f, 9.40194295e-04f, 1.34302408e-01f, -1.44455343e-01f, -1.62851870e-01f, -3.81301753e-02f, -4.66331653e-02f, 3.49324644e-02f, -1.80212528e-01f, -1.67070612e-01f,
  -8.06996375e-02f, 4.08360884e-02f, -2.23968830e-02f, -1.32241592e-01f, -9.63607132e-02f, -1.80368721e-01f, -1.99836060e-01f, 9.98655185e-02f, -1.82492629e-01f, 1.80841088e-01f,
  1.68674346e-02f, 4.04350907e-02f, 7.41493553e-02f, -1.19957909e-01f, -3.67041789e-02f, -1.20986000e-01f, 3.24153043e-02f, -1.40678123e-01f, -1.31213069e-01f, -3.23854722e-02f,
  3.12412565e-04f, -1.85442075e-01f, 1.81751102e-01f, 1.09419348e-02f, 4.05811407e-02f, 1.20110154e-01f, 1.76508531e-01f, -4.73661907e-02f, -1.46201238e-01f, -9.47900116e-02f,
  1.54847741e-01f, -3.42453942e-02f, -1.22495696e-01f, -6.17350116e-02f, 8.00668448e-03f, -1.29525624e-02f, -3.43089402e-02f, -7.10286526e-03f, 5.00372052e-02f, 2.44372729e-02f,
  6.54346426e-04f, 8.39976128e-03f, 8.23069289e-02f, -1.06819980e-01f, -1.00832522e-01f, 2.32022014e-02f, 7.07849041e-02f, 5.81935719e-02f, -1.03331611e-01f, 1.28579795e-01f,
  -3.55459191e-02f, 6.81078136e-02f, -1.71769381e-01f, 2.28590053e-02f, 2.46365871e-02f, -7.09193349e-02f, 7.37285940e-03f, -1.03622094e-01f, 5.88882938e-02f, 2.42192633e-02f,
  -2.55666878e-02f, -7.29785189e-02f, 7.03154579e-02f, -6.48419186e-02f, 1.39252275e-01f, 4.43068594e-02f, 6.35721534e-02f, 4.01916280e-02f, 3.19547951e-02f, 1.22859560e-01f,
  -6.41481206e-02f, 9.73649323e-02f, -8.48564282e-02f, 2.02159926e-01f, -2.01151609e-01f, -1.18638329e-01f, -1.06002025e-01f, 1.48477599e-01f, 4.28393781e-02f, -4.67786007e-03f,
  -2.19580054e-01f, -2.26063520e-01f, 5.96414134e-02f, -1.12262145e-01f, -6.55617006e-03f, -1.13457404e-01f, 8.24937075e-02f, 1.61553949e-01f, -3.03398278e-02f, 9.24857259e-02f,
  6.28785491e-02f, -4.39894982e-02f, -1.21045606e-02f, -5.46322390e-02f, -1.18805774e-01f, 8.43050405e-02f, -8.09679478e-02f, -1.89648867e-01f, -1.52398661e-01f, 3.92660387e-02f,
  1.53647229e-01f, -8.14233050e-02f, -7.94210881e-02f, 1.52227208e-01f, 4.52462286e-02f, 2.51769070e-02f, -9.82993245e-02f, -3.18144448e-02f, -5.69484371e-04f, -5.73036075e-02f,
  -5.20391949e-02f, -7.16834888e-03f, -6.57200366e-02f, 7.83967078e-02f, -1.27432004e-01f, 1.45640776e-01f, 5.27805137e-03f, -5.17453142e-02f, 9.28405672e-02f, 7.53708333e-02f,
  1.69396922e-01f, -4.09327447e-02f, 8.24579075e-02f, 9.67181772e-02f, -9.42704827e-02f, 1.20440640e-01f, -2.17473075e-01f, 4.88160439e-02f, 8.08653701e-03f, -4.54569533e-02f,
  -1.72281206e-01f, -1.67609483e-01f, -1.35019258e-01f, -1.08284056e-01f, -2.04646468e-01f, 5.78935482e-02f, 9.11450572e-03f, -1.45202801e-02f, 8.96172673e-02f, 2.08304211e-01f,
  2.14942053e-01f, 9.44840983e-02f, 6.93112835e-02f, -1.05969407e-01f, 3.21032494e-01f, 7.92308897e-03f, -5.41670062e-02f, 1.38092279e-01f, 9.41270813e-02f, -1.62835985e-01f,
  3.39373648e-02f, -2.11237013e-01f, 1.42446503e-01f, 1.38862446e-01f, 9.85563993e-02f, -4.48444709e-02f, -9.32726040e-02f, 4.10267822e-02f, 7.61625096e-02f, -7.11242408e-02f,
  8.78441259e-02f, -3.59542109e-02f, -3.64907272e-02f, 1.65465385e-01f, -1.23773575e-01f, -4.07108888e-02f, -7.15935826e-02f, -1.79480031e-01f, 1.20062521e-02f, 9.57673565e-02f,
  7.74400681e-03f, -6.66853487e-02f, 1.00055121e-01f, 9.23258960e-02f, -7.52068982e-02f, -2.13875392e-04f, -1.67154968e-02f, -4.86419126e-02f, 9.25059393e-02f, -3.26926671e-02f,
  -7.83052146e-02f, -1.38160303e-01f, -1.56354859e-01f, -2.53074914e-01f, -1.43327117e-01f, 2.03627706e-01f, 1.73982501e-01f, -8.09707195e-02f, -1.26569211e-01f, 1.03454888e-01f,
  1.20509237e-01f, 1.20910391e-01f, 1.68541688e-02f, 2.73048971e-02f, -8.52611288e-03f, 1.14621140e-01f, 1.22147620e-01f, 1.20895244e-02f, 1.83994025e-01f, 1.89569611e-02f,
  2.03331202e-01f, -4.92969342e-02f, 1.03837721e-01f, -1.20696366e-01f, -2.12766334e-01f, 2.00411722e-01f, 8.84297714e-02f, 1.22194842e-01f, -2.35035922e-03f, 1.08124374e-03f,
  2.21562590e-02f, 2.96461154e-02f, 5.82856126e-03f, 1.45539388e-01f, -6.39047399e-02f, 1.56898815e-02f, 3.94243225e-02f, -1.62350625e-01f, -1.21236891e-01f, -1.87820092e-01f,
  -1.40090540e-01f, 1.29692480e-01f, 1.52049199e-01f, 3.42292296e-05f, 9.10647884e-02f, 5.63617945e-02f, -1.94086239e-01f, -3.23104411e-02f, -1.11793213e-01f, 1.28986850e-01f,
  2.76131965e-02f, -5.91532141e-02f, 7.43415430e-02f, -4.11867090e-02f, 8.00234973e-02f, 2.27057468e-02f, 1.55689299e-01f, 8.76969695e-02f, 2.31805518e-02f, 3.69464681e-02f,
  1.02784753e-01f, 6.89511299e-02f, 1.66488767e-01f, -1.08027257e-01f, 6.23149611e-02f, 1.43217012e-01f, 1.27934515e-01f, 1.81845799e-01f, -1.42304167e-01f, -6.07435629e-02f,
  1.48466960e-01f, -9.79409926e-03f, 8.60955715e-02f, -1.05793932e-02f, -1.81923330e-01f, 1.51853919e-01f, 9.12780538e-02f, -1.05987221e-01f, -5.42412773e-02f, 1.58278793e-01f,
  2.42400542e-03f, 1.14123963e-01f, -1.78827103e-02f, 3.02125998e-02f, 1.41352460e-01f, -7.41639286e-02f, -2.15056185e-02f, 2.80070063e-02f, -3.00476654e-03f, 1.26936987e-01f,
  -3.52488980e-02f, -2.44754279e-04f, 5.07640168e-02f, 2.06246644e-01f, -2.22297739e-02f, 1.14027031e-01f, -1.75381139e-01f, 2.09464118e-01f, -1.57095701e-01f, -1.08357653e-01f,
  -1.68002009e-01f, -1.00705922e-01f, 9.33322012e-02f, 2.66224090e-02f, 1.07942872e-01f, -4.09994759e-02f, 7.01539069e-02f, -9.53477472e-02f, 2.14645732e-02f, -2.35238057e-02f,
  8.76571238e-02f, -2.49158926e-02f, 6.79275542e-02f, -9.32598021e-03f, 1.25460863e-01f, -1.17329046e-01f, 8.79256204e-02f, -2.77294554e-02f, -9.51316673e-03f, -2.53937226e-02f,
  -1.55950829e-01f, 7.75247663e-02f, 7.03808516e-02f, 6.95445612e-02f, 1.27201363e-01f, 1.79891855e-01f, -1.23491444e-01f, -1.62098393e-01f, -6.13974072e-02f, -4.65296879e-02f,
  8.17878991e-02f, -8.98630992e-02f, 2.28649154e-01f, -1.20692514e-01f, -1.12819970e-01f, -1.60753399e-01f, 1.07088737e-01f, 1.62276015e-01f, 6.00871779e-02f, -1.92464128e-01f,
  1.36323854e-01f, 6.65528551e-02f, -1.16895944e-01f, 4.41746488e-02f, -5.76249585e-02f, -5.09804524e-02f, 1.93881556e-01f, 1.86914071e-01f, -2.30797321e-01f, 6.50790408e-02f,
  -1.20596765e-02f, 1.64829493e-02f, -5.68155609e-02f, 1.16822526e-01f, -1.48614004e-01f, -6.09196611e-02f, -1.70801669e-01f, -8.06148797e-02f, 5.84607534e-02f, -1.47724852e-01f,
  8.73947293e-02f, -2.95607354e-02f, 1.74848258e-01f, 1.66923299e-01f, 2.13291243e-01f, -1.07003711e-01f, -6.12910278e-02f, -2.14075580e-01f, 8.46004188e-02f, -5.71192764e-02f,
  6.57097846e-02f, 1.38643831e-01f, -4.93704304e-02f, 9.78471190e-02f, 1.29278421e-01f, -1.89799070e-02f, 6.41113743e-02f, 1.44748852e-01f, -1.01214461e-01f, -7.02847391e-02f,
  -5.12760133e-02f, 1.13763548e-02f, -2.01560542e-01f, -9.49317813e-02f, -7.05664530e-02f, 9.33210328e-02f, 7.27887126e-03f, 7.55306110e-02f, -3.27432416e-02f, -1.74155891e-01f,
  -3.41323875e-02f, -1.20855838e-01f, -1.24476850e-01f, -1.94803551e-01f, 8.91976152e-03f, 4.61978242e-02f, 3.91994826e-02f, -1.47148687e-02f, -2.24786289e-02f, 3.01691908e-02f,
  1.14862427e-01f, -1.39676929e-01f, 1.92320317e-01f, -1.14722382e-02f, -8.56706351e-02f, 1.79582268e-01f, -9.85340104e-02f, 1.22817665e-01f, -3.69522572e-02f, -2.13863954e-01f,
  1.54002696e-01f, -1.15626730e-01f, 6.27828464e-02f, -4.29937020e-02f, 1.08321846e-01f, 2.10902423e-01f, -2.31500193e-02f, -5.89830540e-02f, 4.47129942e-02f, -5.94067909e-02f,
  -3.50241773e-02f, -1.14449039e-01f, -4.77160625e-02f, -5.07446341e-02f, -8.19848327e-04f, -1.96064070e-01f, 1.57365203e-02f, -2.16637388e-01f, 5.40305562e-02f, -5.84633835e-03f,
  -1.10348731e-01f, -7.14197829e-02f, -1.66412026e-01f, 1.54986203e-01f, 4.72400263e-02f, 9.42140073e-02f, 1.72711104e-01f, 3.24951597e-02f, 4.47673500e-02f, 8.49563852e-02f,
  -1.06524803e-01f, 6.94234148e-02f, 6.43526763e-02f, 4.88346964e-02f, 2.52009034e-01f, 9.55434293e-02f, 7.59522244e-02f, -7.62711763e-02f, 6.18278161e-02f, 1.62748452e-02f,
  -1.54550508e-01f, -7.49195740e-02f, -2.70371381e-02f, -2.62649599e-02f, 9.64287668e-02f, -1.05371930e-01f, -8.38796496e-02f, 3.70518789e-02f, -9.46102217e-02f, 4.79247943e-02f,
  -4.02639806e-02f, -8.54890496e-02f, 1.77500620e-01f, 8.24941695e-02f, -4.44523133e-02f, 8.68296772e-02f, -1.77461561e-02f, 2.10029334e-01f, 7.99309164e-02f, 3.29557806e-02f,
  -1.17366724e-01f, 1.26123622e-01f, 4.17755842e-02f, 2.46487230e-01f, -3.36295217e-02f, -1.32930398e-01f, -5.53808995e-02f, 4.18849848e-02f, -1.97802901e-01f, -3.72743495e-02f,
  2.26266250e-01f, 1.37951925e-01f, 1.16306968e-01f, -1.63307264e-02f, -4.46347632e-02f, 8.07094276e-02f, -6.77494481e-02f, 2.98655704e-02f, -3.84943224e-02f, -3.32986675e-02f,
  -1.13602534e-01f, -3.83995771e-02f, 6.65962324e-02f, 1.08392112e-01f, -7.16909096e-02f, -3.01915556e-02f, -1.21016994e-01f, 1.76295623e-01f, -8.04699212e-02f, -8.96821171e-02f,
  -2.04625934e-01f, 1.06291689e-01f, 1.92189395e-01f, -1.76857375e-02f, 1.14376113e-01f, 1.33390620e-01f, 4.58254218e-02f, -1.58791125e-01f, 5.67773953e-02f, -8.93355012e-02f,
  5.24759479e-02f, -1.09520100e-01f, -1.69920921e-01f, -1.62000075e-01f, 9.47668552e-02f, -1.49862140e-01f, 3.12326532e-02f, -6.14439091e-03f, -4.25571688e-02f, 1.38683235e-02f,
  2.54153639e-01f, 5.99077418e-02f, 7.07907453e-02f, -3.62635180e-02f, 1.30148321e-01f, -3.37275257e-03f, -2.34440062e-02f, -6.54448792e-02f, 2.64910400e-01f, 5.82727306e-02f,
  -1.79117285e-02f, -1.17854953e-01f, 2.24352643e-01f, 1.93940699e-01f, 1.49931028e-01f, 8.83948505e-02f, 9.30080786e-02f, -5.41929193e-02f, 7.97461271e-02f, 2.21974961e-02f,
  -2.64252901e-01f, -8.30918103e-02f, 5.50464280e-02f, -1.62721232e-01f, -2.10841760e-01f, -1.32259503e-02f, -5.50735258e-02f, 5.42810746e-02f, -2.60160416e-01f, -8.51200968e-02f,
  -3.75260711e-02f, 3.30334567e-02f, -1.71554744e-01f, 2.75283195e-02f, 1.27104998e-01f, 2.15914339e-01f, -9.77539122e-02f, -5.80993332e-02f, -1.16588799e-02f, 2.65341941e-02f,
  1.63907811e-01f, -4.57316861e-02f, -5.91649376e-02f, -1.23147540e-01f, -1.60536200e-01f, -7.77297989e-02f, -9.46181938e-02f, -2.20775139e-02f, 1.82440966e-01f, 9.38408077e-02f,
  4.65905070e-02f, -9.40727443e-03f, -1.49769753e-01f, -2.74406731e-01f, -1.50401846e-01f, -1.77624643e-01f, -8.76322389e-02f, 2.32983381e-02f, 3.78686488e-02f, 1.96771827e-02f,
  -5.33555374e-02f, 2.69014146e-02f, -4.19629961e-02f, 4.63770702e-02f, 2.05985662e-02f, 3.50342430e-02f, -3.18055652e-04f, 8.49037096e-02f, 9.97001007e-02f, -8.37130249e-02f,
  -6.71806633e-02f, 6.20615892e-02f, -1.15498111e-01f, -9.60460901e-02f, 1.34388700e-01f, -2.52044380e-01f, -1.75849330e-02f, 3.81097421e-02f, 5.04749827e-02f, -1.69114500e-01f,
  1.14055604e-01f, -1.00926094e-01f, -1.45084679e-01f, 2.47273162e-01f, -1.96130872e-02f, 1.47234321e-01f, 6.54934943e-02f, 1.58003822e-01f, -3.72567065e-02f, -1.37400012e-02f,
  6.59985319e-02f, -5.89964613e-02f, 2.76737306e-02f, -8.56734216e-02f, 1.44068137e-01f, -7.93918297e-02f, 1.02402912e-02f, -1.78859323e-01f, 2.12917879e-01f, 4.25222181e-02f,
  -1.74787670e-01f, -5.17809168e-02f, 1.07864765e-02f, 1.04868822e-01f, 3.96885835e-02f, 5.32733044e-03f, 7.03877956e-02f, -4.09121476e-02f, -8.54995400e-02f, -7.01537132e-02f,
  -1.65537208e-01f, -1.08044539e-02f, -1.29346862e-01f, -4.00334559e-02f, 2.87067592e-02f, 8.94159004e-02f, -1.50414601e-01f, -1.43967886e-02f, -1.30144181e-04f, -1.02241710e-01f,
  1.33497640e-01f, 7.75732845e-02f, -1.15014054e-01f, -9.70072970e-02f, 5.72595559e-02f, -9.37414095e-02f, 7.36690834e-02f, 1.55895529e-02f, 1.12260066e-01f, -3.46197933e-02f,
  3.55760902e-02f, -6.59701824e-02f, -6.39979914e-02f, 1.51680075e-02f, 9.96953472e-02f, -1.34568483e-01f, 2.26704590e-03f, -1.34909721e-02f, -6.53873309e-02f, 1.50172353e-01f,
  2.15991028e-02f, -2.64246147e-02f, -1.08996987e-01f, 1.77442133e-01f, 1.51952192e-01f, 1.15025816e-02f, 1.13188542e-01f, 6.91543892e-02f, 1.97851464e-01f, -2.21933797e-03f,
  8.05135742e-02f, -2.68325824e-02f, -1.46438137e-01f, 2.45569404e-02f, 4.26495858e-02f, 1.06204793e-01f, 1.04026822e-03f, -8.69800989e-03f, -1.90880448e-02f, 4.43990678e-02f,
  -8.72396827e-02f, 6.43222556e-02f, -7.17495754e-02f, -6.11964501e-02f, -1.34509683e-01f, 1.34413645e-01f, -8.49408880e-02f, 9.04850215e-02f, 1.43535554e-01f, -9.93690714e-02f,
  2.21250877e-01f, -1.90378264e-01f, 7.41043389e-02f, -8.84481221e-02f, 1.86369240e-01f, 1.07677534e-01f, -1.76064074e-01f, 9.73474234e-02f, 1.54127613e-01f, -5.30750267e-02f,
  1.50067970e-01f, 2.15968579e-01f, -1.53095916e-01f, 3.27903107e-02f, -1.38126329e-01f, -1.53350607e-01f, 1.47915453e-01f, 5.33476397e-02f, -2.11509806e-03f, 7.94471893e-03f,
  -6.44622818e-02f, 2.25589871e-02f, -5.46681974e-03f, 1.25875529e-02f, 2.04433218e-01f, -1.03125185e-01f, 7.25326128e-04f, -5.32922335e-02f, 2.56736996e-04f, 1.53256774e-01f,
  8.17028284e-02f, 2.31138547e-03f, 1.30029351e-01f, -2.20686048e-01f, 1.02405041e-01f, 1.12395532e-01f, -1.36582732e-01f, -2.50852883e-01f, -2.01951534e-01f, -1.70160502e-01f,
  -1.28813565e-01f, -7.50909746e-02f, -2.76940167e-01f, 8.03268254e-02f, -1.46944895e-01f, 4.61542346e-02f, -2.14741491e-02f, -1.38705462e-01f, -1.74291909e-01f, -1.40408576e-01f,
  -2.19082013e-01f, -4.05730400e-03f, 1.00141406e-01f, -2.96650827e-02f, 8.57350603e-03f, 8.05812478e-02f, -5.27042784e-02f, -4.85464837e-03f, 7.31724733e-03f, -4.80559980e-03f,
  4.22577634e-02f, 7.27808177e-02f, -1.92798190e-02f, -9.32035595e-03f, -2.52906263e-01f, -9.31349099e-02f, 5.21376170e-02f, 3.14975786e-03f, 1.75585300e-01f, 1.84194267e-01f,
  6.16834797e-02f, 5.31135164e-02f, 1.11654535e-01f, 1.29618153e-01f, 5.76528199e-02f, 7.28493854e-02f, 9.69700441e-02f, 2.44034380e-02f, 9.88434628e-02f, 1.17327236e-01f,
  -4.13216315e-02f, -7.22393319e-02f, -7.63327703e-02f, 7.05201924e-02f, 4.05838154e-02f, -3.53009962e-02f, -1.48884105e-02f, 1.70486078e-01f, 1.07495323e-01f, -1.55919110e-02f,
  7.74937570e-02f, -5.79251088e-02f, -3.37672681e-02f, -7.83758014e-02f, -1.18920550e-01f, -1.18818671e-01f, 4.05583866e-02f, 6.54748529e-02f, 1.08862154e-01f, 1.32709488e-01f,
  -1.36433497e-01f, -3.72842140e-02f, -2.64382780e-01f, 1.22113572e-02f, -2.19414070e-01f, -1.29076123e-01f, -2.37205595e-01f, 1.75554529e-01f, -1.94986269e-01f, 5.92133477e-02f,
  4.23164107e-02f, -5.86202741e-02f, -1.34253860e-01f, -1.78085253e-01f, -1.18057407e-01f, -1.17355742e-01f, -5.11641651e-02f, -1.23969622e-01f, 5.86675331e-02f, 2.56999326e-03f,
  -6.75554872e-02f, 3.18145342e-02f, -4.83407229e-02f, 1.80494443e-01f, 6.89340383e-03f, 8.33069980e-02f, 9.70369279e-02f, 1.60149023e-01f, -4.77787293e-02f, 9.90589857e-02f,
  -3.57498452e-02f, -1.23017430e-01f, 4.39944267e-02f, -1.30050033e-01f, -4.20259349e-02f, -6.71069697e-03f, -1.88396081e-01f, 4.54757214e-02f, -1.36846960e-01f, -1.67229995e-01f,
  -6.56873733e-02f, -1.60654068e-01f, -1.47732884e-01f, -1.46330252e-01f, 5.98207489e-03f, -4.63503646e-03f, 3.64148542e-02f, -1.84033766e-01f, -7.54894540e-02f, -7.08532557e-02f,
  7.10269362e-02f, -2.29108840e-01f, -1.45989001e-01f, -1.65018979e-02f, -5.37827797e-03f, 6.73092529e-02f, -1.74886420e-01f, 1.75752267e-02f, -9.34132785e-02f, -6.06040731e-02f,
  3.08088586e-02f, -8.55068266e-02f, -5.40168770e-02f, 8.36076140e-02f, 3.32412054e-03f, 1.28182963e-01f, 8.11994076e-02f, -1.05033569e-01f, 7.99503028e-02f, 1.06954239e-01f,
  1.13991894e-01f, 1.99790806e-01f, 1.38896778e-01f, 5.69326468e-02f, 1.06191956e-01f, -2.56520957e-02f, 8.97301808e-02f, -1.47533745e-01f, 6.38908520e-02f, -1.75993159e-01f,
  -6.23024330e-02f, -2.13145062e-01f, 2.92694056e-03f, -1.31171301e-01f, 3.95642258e-02f, -1.33429229e-01f, -1.08391784e-01f, -1.50765002e-01f, 9.44336876e-02f, 5.84342033e-02f,
  -9.79300439e-02f, 8.39546993e-02f, 1.48117632e-01f, 1.24816701e-01f, 6.96910098e-02f, 6.36318699e-02f, -6.58828840e-02f, 1.23261571e-01f, -8.49531144e-02f, 8.08182172e-03f,
  -1.02675937e-01f, -4.48629558e-02f, -7.42131323e-02f, -9.51506197e-02f, 3.46736349e-02f, 1.91553682e-02f, 8.59087929e-02f, 1.18757248e-01f, 6.65458366e-02f, 8.06104019e-02f,
  -8.97405744e-02f, -1.56886399e-01f, 6.76993132e-02f, -9.68193859e-02f, 1.27159715e-01f, -5.84813356e-02f, -1.57805845e-01f, -1.54707253e-01f, -1.29180580e-01f, 2.06872478e-01f,
  1.02192156e-01f, 5.65479174e-02f, -8.83566365e-02f, 2.81976350e-02f, 2.32292682e-01f, 1.60217732e-01f, 7.62401596e-02f, -1.38182372e-01f, 8.38221386e-02f, 2.54921764e-01f,
  1.60129711e-01f, 2.07687970e-02f, 1.24082789e-01f, -2.02736199e-01f, 3.00588220e-01f, -7.78134465e-02f, 1.69263020e-01f, 1.74641367e-02f, -1.63544074e-01f, 1.66539885e-02f,
  -2.50189900e-02f, 1.09550186e-01f, 2.74576340e-02f, 1.41287535e-01f, 8.36435109e-02f, -6.02980852e-02f, -1.55088410e-01f, 2.52020299e-01f, -3.09122279e-02f, 4.26647775e-02f,
  -3.77697707e-03f, -8.47805217e-02f, -8.24856758e-02f, -8.29526762e-05f, -5.56908920e-02f, -9.30930898e-02f, 1.42315060e-01f, 2.66199652e-02f, -2.78604520e-03f, 6.33944869e-02f,
  1.10114805e-01f, 2.09794473e-02f, -1.26667917e-01f, 1.29501387e-01f, 1.78458989e-02f, -1.57638022e-03f, 1.04765408e-01f, 6.38549924e-02f, -1.78402558e-01f, 2.53984649e-02f,
  -1.62312225e-01f, 8.89197811e-02f, -1.38469413e-02f, 1.19576110e-02f, -7.71078542e-02f, 2.37254538e-02f, 5.16537875e-02f, -1.46702498e-01f, -1.38542876e-01f, -1.15813829e-01f,
  -3.70982885e-02f, -2.75957305e-02f, -1.04360573e-01f, 5.02194799e-02f, -1.41552106e-01f, 1.56595521e-02f, 1.04341544e-01f, -6.74075186e-02f, -1.08638264e-01f, -1.78931970e-02f,
  -1.08695179e-01f, -1.30227990e-02f, 1.35006040e-01f, -4.98228818e-02f, 6.20685779e-02f, -1.92525908e-01f, 1.28644317e-01f, -8.36546272e-02f, 5.51253520e-02f, 1.42220467e-01f,
  1.78235099e-02f, -1.49520785e-02f, -9.21828374e-02f, -3.73043604e-02f, -2.84868572e-02f, -7.57924616e-02f, 1.20511115e-01f, 1.52364805e-01f, 1.19242653e-01f, -1.38710007e-01f,
  5.53900115e-02f, 8.23455453e-02f, -1.31092638e-01f, -1.40958801e-01f, 9.90904197e-02f, -1.32329613e-01f, -2.79047024e-02f, 6.84898272e-02f, -1.27529010e-01f, 1.24700218e-01f,
  -1.49097204e-01f, -5.32490648e-02f, -1.11420147e-01f, 1.05651356e-02f, -8.95385444e-03f, -1.42576739e-01f, -3.99696035e-03f, 1.48429543e-01f, -1.35953352e-01f, -6.91884831e-02f,
  -6.26045167e-02f, -1.96209386e-01f, 7.09064528e-02f, 7.03318119e-02f, 6.26101494e-02f, 1.38937717e-03f, -2.72053014e-03f, 1.06687516e-01f, -6.15888499e-02f, -6.00825064e-02f,
  -4.25319113e-02f, -3.08695044e-02f, 9.28197950e-02f, 1.27603216e-02f, 1.69909112e-02f, 1.29295379e-01f, -4.84613180e-02f, 1.52350694e-01f, -2.05735907e-01f, 4.37268317e-02f,
  1.63202420e-01f, 4.99441884e-02f, 7.22505972e-02f, -3.62699516e-02f, -1.92037299e-01f, -2.78067514e-02f, 6.66184872e-02f, -1.90557510e-01f, 1.87020451e-01f, -2.59365827e-01f,
  7.82665610e-02f, 1.83864668e-01f, -2.59406585e-03f, -5.47261387e-02f, 1.65311366e-01f, 9.45911035e-02f, 2.29950361e-02f, -2.02157751e-01f, 8.70908871e-02f, -2.54520290e-02f,
  2.07192346e-01f, 1.72458827e-01f, 1.12628043e-01f, 8.49580467e-02f, 5.55112138e-02f, -3.99576314e-02f, 2.56750900e-02f, -3.71042490e-02f, 1.05448775e-01f, -2.01327279e-01f,
  1.05253393e-02f, 1.94698796e-01f, 1.59631353e-02f, -6.46827221e-02f, -1.00963235e-01f, 8.78943652e-02f, -6.74828142e-02f, 9.02655274e-02f, -1.99540272e-01f, -9.10196677e-02f,
  -1.00184858e-01f, 3.37605597e-03f, -1.41477706e-02f, 1.37543410e-01f, -6.54459819e-02f, -1.13398865e-01f, 7.22191930e-02f, -4.04945910e-02f, 1.35278031e-01f, 9.43255275e-02f,
  -6.11585751e-02f, -4.03851038e-03f, 1.49052620e-01f, -7.87987784e-02f, 2.47586016e-02f, 9.00838077e-02f, 8.69215354e-02f, -4.05510142e-02f, 8.01905543e-02f, 1.36764618e-02f,
  -1.69173572e-02f, 1.30878597e-01f, 7.63571933e-02f, -8.83507803e-02f, -5.86670041e-02f, -5.58628291e-02f, -1.03456443e-02f, 1.02763280e-01f, -7.06570670e-02f, -1.30935535e-01f,
  9.86138806e-02f, 1.55454159e-01f, 2.08248228e-01f, 1.04681857e-01f, 7.07642827e-03f, 6.85636103e-02f, 8.43136907e-02f, -2.85302009e-02f, -3.91378887e-02f, -2.21746508e-03f,
  9.47071984e-02f, -6.76244721e-02f, 2.20766254e-02f, 8.62077177e-02f, 1.97407782e-01f, 1.36493444e-01f, -2.40320843e-02f, 1.69010982e-01f, -1.19753189e-01f, -1.40354708e-02f,
  3.02659422e-02f, -6.02727793e-02f, -1.58393562e-01f, -7.72644207e-02f, 1.16660513e-01f, 1.34365216e-01f, 1.60348773e-01f, -6.00120462e-02f, 4.71432284e-02f, -1.75858755e-02f
};

// L3_fan_Wp_bar (Shape: 14 x 64)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  2.80878335e-01f, -8.36276636e-02f, 1.33653030e-01f, 1.69455066e-01f, 2.13443592e-01f, 2.02700004e-01f, 5.44600859e-02f, 1.50588274e-01f, -5.17466962e-02f, -1.08974045e-02f,
  5.36492318e-02f, 1.94195807e-02f, 1.95618302e-01f, 1.80623323e-01f, 2.48807333e-02f, -7.53361508e-02f, 1.93262137e-02f, -8.51564109e-02f, 1.77134529e-01f, 2.35167503e-01f,
  -9.00678262e-02f, -8.90170261e-02f, -1.63824722e-01f, 1.33191466e-01f, 1.66787311e-01f, -1.85513049e-01f, 1.63983911e-01f, 1.08791217e-01f, -9.59048867e-02f, 1.38541967e-01f,
  1.39662489e-01f, -1.84797958e-01f, 1.22623229e-02f, 2.22788215e-01f, -3.44880402e-01f, 2.78931912e-02f, -3.39731812e-01f, 2.31841523e-02f, -1.96216404e-01f, -2.58453459e-01f,
  -3.63221288e-01f, 2.62120515e-01f, -1.06054492e-01f, 3.33995104e-01f, 2.42031664e-01f, 6.03047647e-02f, 6.02665357e-04f, -2.65876353e-01f, -1.65880382e-01f, 2.53931414e-02f,
  2.42717639e-02f, 1.73601121e-01f, 6.15962110e-02f, 2.32436582e-02f, -7.44299516e-02f, -2.78256163e-02f, 4.13464546e-01f, 1.24046214e-01f, 6.76052868e-02f, 1.07612289e-01f,
  4.41137963e-04f, 4.49068427e-01f, -4.53911781e-01f, -2.13961098e-02f, 8.92874748e-02f, 2.66159251e-02f, 1.92076445e-01f, 6.75857067e-02f, 1.42528817e-01f, 1.62178412e-01f,
  5.36135212e-02f, -3.56708407e-01f, 7.82158747e-02f, -1.79429613e-02f, 7.93745220e-02f, 1.91964075e-01f, 1.41149303e-02f, 2.24115744e-01f, 1.29733488e-01f, 2.53174722e-01f,
  1.48196921e-01f, -1.66648090e-01f, 2.48272717e-02f, 2.01363862e-01f, 1.36259824e-01f, -5.63568920e-02f, 4.81750816e-02f, -3.60553771e-01f, 1.03760816e-01f, 2.37251399e-03f,
  2.59520143e-01f, -5.73733337e-02f, -1.75605163e-01f, 1.49085792e-02f, 2.16278046e-01f, -4.33091462e-01f, 2.30593458e-01f, 4.05859709e-01f, -1.68641090e-01f, 3.20214301e-01f,
  -2.77324796e-01f, 2.84205407e-01f, 2.59034991e-01f, -2.80276895e-01f, -2.72752404e-01f, 2.84811944e-01f, -1.07035369e-01f, -3.55721384e-01f, -4.80278313e-01f, 1.77229181e-01f,
  -2.76115388e-01f, -2.92543530e-01f, -4.95646268e-01f, -1.69757009e-01f, 3.42927486e-01f, -3.91090989e-01f, -1.19783901e-01f, 6.09348081e-02f, -3.76148825e-03f, 4.01282042e-01f,
  1.82339862e-01f, 3.25457662e-01f, 5.77223189e-02f, -5.62603593e-01f, -1.12103531e-02f, 2.93505162e-01f, -3.85198623e-01f, 2.50331283e-01f, -7.10408688e-02f, -2.36398757e-01f,
  2.16999501e-01f, -1.82031140e-01f, 5.65061010e-02f, -9.32917371e-02f, -3.56353611e-01f, 1.32883698e-01f, -1.24945134e-01f, -1.26336999e-02f, -2.69776613e-01f, -3.99115942e-02f,
  2.85961106e-02f, -3.72897461e-02f, -1.95838422e-01f, -5.43381413e-03f, -3.20566416e-01f, -4.10964757e-01f, 3.29954147e-01f, -3.09561286e-02f, -1.26589432e-01f, -5.76539636e-01f,
  -5.57554007e-01f, -1.99237034e-01f, -7.57088214e-02f, -2.87933182e-02f, -8.66607800e-02f, 1.28124207e-01f, -2.51279801e-01f, -6.25663102e-02f, 2.17039973e-01f, 1.62424624e-01f,
  7.02111721e-02f, 2.34836310e-01f, 1.88089028e-01f, 2.61413515e-01f, -1.18682690e-01f, 7.69310817e-03f, 1.14979424e-01f, -2.63399601e-01f, -9.61564779e-02f, 3.94754231e-01f,
  -6.78518116e-02f, 2.53607452e-01f, 1.67453438e-01f, -5.18957451e-02f, -4.95284162e-02f, -2.02132016e-01f, 9.14677233e-02f, -1.27029493e-01f, 2.66787559e-01f, -3.69028598e-01f,
  2.76235342e-01f, -3.51939052e-01f, -6.25117719e-02f, -1.43629417e-01f, 2.17363343e-01f, -2.02667154e-02f, -7.71765411e-02f, 1.39571950e-01f, -4.57557589e-01f, 4.00301188e-01f,
  -4.04113144e-01f, 1.67435333e-01f, 1.63903072e-01f, 1.91866949e-01f, -1.31814301e-01f, 2.36918300e-01f, 5.02487868e-02f, 8.94936025e-02f, 1.42551348e-01f, -1.26439139e-01f,
  1.53789505e-01f, 1.44953117e-01f, -2.50064164e-01f, 1.83639247e-02f, 8.58122632e-02f, 6.38426142e-03f, 8.80272780e-03f, -2.70371586e-02f, 2.60300517e-01f, 2.58250147e-01f,
  1.15317494e-01f, 1.08917011e-02f, 6.40428364e-02f, 6.31307065e-02f, 1.11777499e-01f, -5.30020669e-02f, 1.38586968e-01f, 3.77517402e-01f, -7.00861290e-02f, 4.20704521e-02f,
  1.31682783e-01f, 1.66294873e-01f, -1.02439716e-01f, -2.41269812e-01f, -3.64289284e-01f, -2.52815485e-01f, -5.60145117e-02f, -6.74135387e-02f, -1.49241149e-01f, -2.56704062e-01f,
  -2.33647376e-01f, 2.01429591e-01f, 5.39739057e-02f, -2.42420018e-01f, -1.56012490e-01f, -1.68502163e-02f, 3.47579010e-02f, 7.76955560e-02f, -1.32132232e-01f, -1.16560847e-01f,
  2.61890143e-01f, 3.04175049e-01f, -3.36869992e-02f, 2.58622378e-01f, 8.33574161e-02f, 1.73668295e-01f, 6.58314303e-02f, -1.86850205e-01f, 4.48094398e-01f, -5.93750030e-02f,
  -5.92681617e-02f, 1.96356937e-01f, -1.78894863e-01f, 3.76391448e-02f, 6.58779263e-01f, -1.20368332e-01f, 1.85342222e-01f, 1.69957072e-01f, -3.30223709e-01f, 2.33181894e-01f,
  3.53810303e-02f, -2.74354964e-01f, 1.83424860e-01f, 5.48148602e-02f, 2.20399708e-01f, 1.06913187e-01f, -1.18117511e-01f, 1.38974652e-01f, 1.64981738e-01f, 1.07726194e-01f,
  -2.89808996e-02f, 2.36746352e-02f, 2.82234818e-01f, 2.56487221e-01f, 2.60522440e-02f, -8.64919927e-03f, 1.17406718e-01f, 1.97708786e-01f, 1.36960790e-01f, 2.69372404e-01f,
  -6.43019602e-02f, 2.17603907e-01f, -2.26751104e-01f, -9.57693234e-02f, 5.62223867e-02f, 1.18727058e-01f, -3.74179512e-01f, 2.27435231e-01f, -4.08252448e-01f, -2.64155775e-01f,
  9.16678086e-02f, -4.47118878e-01f, -3.74508463e-03f, -3.27253461e-01f, -3.88340354e-01f, 1.28765255e-01f, 4.60095704e-02f, -4.05679308e-02f, 4.35576551e-02f, 1.16864093e-01f,
  4.29594249e-01f, 1.90054193e-01f, -1.09319966e-02f, 1.71712726e-01f, 4.77892369e-01f, 2.48832345e-01f, -9.85713452e-02f, 5.49284458e-01f, 9.83205289e-02f, 3.12425882e-01f,
  -1.15203327e-02f, -2.93832812e-02f, 2.35707715e-01f, -2.91372240e-02f, 3.20288658e-01f, 4.69339311e-01f, -8.97312835e-02f, 1.29108638e-01f, 5.89068353e-01f, -6.73787668e-02f,
  1.09876454e-01f, -7.94866681e-02f, 2.16812760e-01f, 3.87716919e-01f, -1.84506476e-01f, 3.01070124e-01f, 2.14677006e-01f, -6.73506856e-02f, -1.77647397e-02f, 3.95922035e-01f,
  4.50717732e-02f, 2.00524569e-01f, 1.82314545e-01f, 1.75536320e-01f, 1.62753299e-01f, 1.77635610e-01f, 2.71544307e-01f, 1.00203499e-01f, 9.28141847e-02f, 1.33017108e-01f,
  1.26070350e-01f, 1.57218669e-02f, 2.62414515e-01f, -1.50879063e-02f, 1.35694623e-01f, -4.47584614e-02f, 2.11144641e-01f, -1.67640805e-01f, -3.53694782e-02f, 7.15761036e-02f,
  -2.25005955e-01f, -1.49131510e-02f, 2.69245952e-01f, 1.81314826e-01f, -3.00546676e-01f, 3.11558664e-01f, -3.08182091e-01f, 3.01592052e-01f, 1.67085439e-01f, -3.03519756e-01f,
  -3.03754538e-01f, -1.74452692e-01f, -1.05859160e-01f, -3.16032767e-02f, -2.08126664e-01f, 1.23460926e-01f, -2.89411902e-01f, 7.72984177e-02f, -1.89445287e-01f, 2.47819081e-01f,
  -1.25133127e-01f, 1.12696469e-01f, -3.20230156e-01f, 4.79327559e-01f, -3.39837819e-01f, 5.31248860e-02f, 2.69288719e-01f, 3.50233018e-01f, -2.33822703e-01f, -2.41257817e-01f,
  1.27061307e-01f, 3.90545964e-01f, -3.33337247e-01f, -6.24675713e-02f, -8.13613907e-02f, 1.62518799e-01f, 2.06637397e-01f, -9.60106328e-02f, 1.73403546e-01f, 9.91847366e-02f,
  -4.85554412e-02f, 3.95861454e-02f, 2.09176227e-01f, -1.20475054e-01f, -9.82341841e-02f, 1.55117884e-01f, 4.61337203e-03f, -5.94854504e-02f, 2.16989845e-01f, 7.03169703e-02f,
  -2.40395181e-02f, -2.13169064e-02f, 9.26558301e-02f, 8.28183070e-03f, 2.53858984e-01f, -9.16936472e-02f, 9.50913504e-02f, 2.21073762e-01f, 7.28647113e-02f, 2.58095711e-01f,
  -1.76371872e-01f, 2.31714267e-02f, -7.83153325e-02f, -1.03829592e-01f, -6.63542934e-03f, -9.90595669e-02f, -2.37879768e-01f, 7.74889737e-02f, 2.29811653e-01f, -2.70903051e-01f,
  -7.57429302e-02f, -2.39952520e-01f, -1.27513781e-01f, -6.74069971e-02f, -1.03761263e-01f, 1.75977916e-01f, -2.36075833e-01f, -1.52800575e-01f, 1.14932291e-01f, -3.17517549e-01f,
  -1.24653302e-01f, -1.38402045e-01f, 9.12497267e-02f, -2.02162549e-01f, 4.59930927e-01f, -1.77845120e-01f, 3.57427299e-01f, -1.01064883e-01f, 9.31127071e-02f, -1.09404482e-01f,
  2.32488066e-01f, -2.45379254e-01f, 1.77212447e-01f, 2.49671623e-01f, -1.12826839e-01f, 2.39743739e-01f, -1.13550924e-01f, 3.96570534e-01f, 1.72665358e-01f, -1.99261889e-01f,
  1.30365059e-01f, -1.73013508e-02f, 3.44693422e-01f, -3.28550115e-02f, -5.92956990e-02f, 3.55497718e-01f, 2.92767614e-01f, 1.29232678e-04f, 1.61283761e-01f, -3.15387622e-02f,
  -1.52671024e-01f, -7.13426843e-02f, -3.42285074e-02f, -7.17969686e-02f, -5.25646023e-02f, 1.50053248e-01f, -2.73218691e-01f, 1.05149426e-01f, -5.82564957e-02f, 2.13261664e-01f,
  2.29969010e-01f, 4.42156345e-01f, 1.84093297e-01f, -4.94619548e-01f, 1.66235968e-01f, 2.71844883e-02f, -2.29684874e-01f, 7.50863776e-02f, -5.46242632e-02f, 2.14058831e-02f,
  8.52046460e-02f, -9.02881287e-03f, -8.77613425e-02f, -5.39483249e-01f, -9.75920632e-03f, 2.38630995e-02f, -3.04626107e-01f, 8.15087110e-02f, -2.47026205e-01f, 3.55002493e-01f,
  -2.15544835e-01f, 2.46016935e-01f, 4.26618636e-01f, -8.17190260e-02f, 2.35240549e-01f, 4.57894243e-02f, 1.58574566e-01f, -2.21278906e-01f, 2.06088554e-02f, 2.51115620e-01f,
  1.21833235e-01f, -4.18494642e-02f, 4.22383219e-01f, 2.28208154e-01f, -1.08521491e-01f, 4.75742131e-01f, 4.85181659e-01f, 1.15440831e-01f, 3.52640182e-01f, 2.30971985e-02f,
  -4.39977407e-01f, 2.13354662e-01f, 1.92577124e-01f, 1.48337573e-01f, 2.82226857e-02f, 2.26518780e-01f, -1.40181825e-01f, -4.16016318e-02f, 1.86847210e-01f, -8.73696432e-02f,
  1.81488961e-01f, 4.60633993e-01f, -4.69781645e-02f, 2.87410229e-01f, 1.10258415e-01f, 2.46279448e-01f, 6.81016147e-02f, -8.11607838e-02f, 2.79536486e-01f, 3.45024735e-01f,
  2.18788058e-01f, -1.08521074e-01f, -1.39869571e-01f, 2.31587082e-01f, 2.45395750e-01f, -5.63254841e-02f, 6.30280375e-02f, 1.80980012e-01f, 1.38141319e-01f, 2.73285490e-02f,
  9.25977230e-02f, 1.12035811e-01f, -1.65395677e-01f, 2.87635773e-02f, -3.54402453e-01f, -1.69531688e-01f, -1.99649647e-01f, 4.73611988e-02f, -4.58687246e-01f, -3.85075398e-02f,
  -1.99146047e-01f, -2.40213171e-01f, -1.47535637e-01f, -1.95370436e-01f, -1.72094151e-01f, 1.88648701e-01f, 2.63444871e-01f, 1.81242555e-01f, -1.48092866e-01f, 6.37759268e-02f,
  1.69173494e-01f, 3.88466984e-01f, -5.55319525e-02f, 1.84263498e-01f, 8.32632929e-02f, 3.33208710e-01f, -2.02123806e-01f, 2.74425326e-03f, 4.98213649e-01f, 1.25186713e-02f,
  -1.07987612e-01f, 1.70123577e-01f, 2.34334636e-02f, 3.94212425e-01f, -5.01301996e-02f, -1.59283474e-01f, 2.16149509e-01f, -1.35817736e-01f, 1.65203124e-01f, 3.22363265e-02f,
  4.18572098e-01f, 1.19513907e-01f, -1.12466030e-01f, 5.89242615e-02f, 4.58038263e-02f, -2.39308663e-02f, 2.50583347e-02f, -1.52061656e-01f, 1.15751922e-01f, -3.57629620e-02f,
  -1.31368771e-01f, 1.13457143e-01f, -3.72513793e-02f, -1.22981884e-01f, 7.21951127e-02f, 1.50576651e-01f, -2.87579522e-02f, -2.02454310e-02f, -6.81734085e-02f, 3.16923074e-02f,
  1.10359006e-01f, -8.35695788e-02f, -2.21143603e-01f, 1.83258280e-01f, -1.98856875e-01f, 8.85705501e-02f, 1.98573723e-01f, -2.03678712e-01f, -1.18266918e-01f, 9.11149848e-03f,
  -2.60100126e-01f, -2.17862293e-01f, -2.44056731e-01f, -2.42777750e-01f, -1.32826939e-01f, -7.56422663e-03f, -3.99539858e-01f, 3.64987135e-01f, -1.83958188e-01f, 3.79464030e-01f,
  2.49197319e-01f, 6.43073320e-02f, -1.17442697e-01f, -2.88328409e-01f, 3.19955796e-02f, -1.07209838e-03f, 1.77777827e-01f, -1.52761713e-01f, 2.97845453e-01f, -4.55309357e-03f,
  1.57214880e-01f, -3.00126448e-02f, 1.23847157e-01f, 3.59028652e-02f, 1.58074498e-01f, 2.12673515e-01f, -1.53841391e-01f, 1.94904432e-01f, 5.29585630e-02f, 1.45593762e-01f,
  -1.31312877e-01f, 1.55702680e-01f, -1.50327027e-01f, -3.67631793e-01f, 2.86194533e-02f, 2.68324316e-01f, -1.21462204e-01f, -5.39823100e-02f, -4.92923558e-02f, -2.78026104e-01f,
  -1.09333724e-01f, 7.62400683e-04f, 4.41930331e-02f, -7.48575777e-02f, 1.85786590e-01f, 2.13549793e-01f, -4.20341343e-02f, -1.37336729e-02f, -4.58310209e-02f, -5.03700264e-02f,
  6.79590330e-02f, 1.18373372e-01f, 2.31600419e-01f, 1.25809774e-01f, 9.36003402e-02f, 2.18361735e-01f, -1.39982209e-01f, -1.88352585e-01f, -1.12748384e-01f, -1.46555394e-01f,
  1.83597788e-01f, -2.66604513e-01f, -2.51090050e-01f, -2.17381448e-01f, 3.61049175e-01f, -1.48329595e-02f, 3.67768914e-01f, -4.56424505e-02f, -3.19678895e-02f, 2.91771472e-01f,
  1.30031049e-01f, 1.70677215e-01f, -2.09972724e-01f, -1.75483242e-01f, 1.00025371e-01f, -3.61064076e-01f, -2.23448753e-01f, -2.01990306e-01f, -7.59320427e-03f, -1.45816237e-01f,
  4.23548132e-01f, -1.89460397e-01f, 1.73276842e-01f, -2.06317842e-01f, 4.54552799e-01f, 6.32047141e-03f, 1.31624013e-01f, -2.18548849e-01f, 1.95364594e-01f, 1.90080479e-01f,
  5.05990982e-02f, -6.28602342e-04f, 1.24967992e-01f, 4.40007120e-01f, 2.49573663e-01f, 7.44088590e-02f, 4.23442751e-01f, -7.04850331e-02f, -1.74425140e-01f, 3.70286137e-01f,
  -1.45686999e-01f, -1.29228726e-01f, -2.02557802e-01f, -1.67284578e-01f, 2.81288587e-02f, -9.34930593e-02f, 7.64886662e-02f, 5.99883385e-02f, 2.60089606e-01f, 2.87250787e-01f,
  -2.93941140e-01f, -3.56993407e-01f, -2.09174857e-01f, 7.22424164e-02f, 8.29872787e-02f, -3.72641593e-01f, -7.26524815e-02f, 1.74151614e-01f, 2.27593482e-02f, 3.48025262e-01f,
  -3.50228995e-01f, 3.37000750e-02f, 3.61654431e-01f, -8.58157501e-02f, 4.28556621e-01f, 2.65058786e-01f, 2.79248923e-01f, 1.54229343e-01f, 2.93715060e-01f, 3.78670335e-01f,
  3.60223591e-01f, 1.76375598e-01f, 4.93726134e-01f, -2.74927706e-01f, 1.79606885e-01f, -2.12304980e-01f, 2.73460776e-01f, 1.14596322e-01f, -3.77788723e-01f, 1.52588971e-02f,
  -3.29022825e-01f, 1.89146504e-01f, -4.23968621e-02f, 2.60708094e-01f, 3.29859585e-01f, 3.48592969e-03f, 8.82541165e-02f, 2.42230237e-01f, -1.88755512e-01f, -8.38127062e-02f,
  2.85292506e-01f, -1.59313038e-01f, -2.80134171e-01f, 9.08861831e-02f, 2.32032314e-01f, 2.09418118e-01f, -1.33608446e-01f, 1.99383825e-01f, 5.92122301e-02f, 3.23989302e-01f,
  2.36041784e-01f, -6.29143044e-02f, -3.39808881e-01f, 2.03149334e-01f, 1.12238027e-01f, -2.43997350e-01f, 1.52562514e-01f, 6.30254224e-02f, 3.44276816e-01f, 1.99971914e-01f,
  7.91312754e-02f, 9.07195732e-02f, 2.84559220e-01f, -4.92802076e-02f, -6.74132910e-03f, 2.27741301e-01f, -7.55146593e-02f, 3.77739919e-03f, 1.84545144e-01f, 2.53466785e-01f,
  3.73887271e-01f, 2.59107947e-01f, 2.76826825e-02f, 1.80281982e-01f, 1.04421079e-01f, -1.74212366e-01f, 3.15939844e-01f, 3.78139578e-02f, -7.86997676e-02f, -1.99355721e-01f,
  2.59857357e-01f, 1.56222135e-01f, 4.95270900e-02f, -1.17334817e-02f, 1.46649778e-01f, 2.64310598e-01f, 7.51971081e-02f, -5.81533723e-02f, -2.65731722e-01f, -2.59398520e-01f,
  -5.88105526e-03f, -4.10161942e-01f, -3.33093524e-01f, -7.73948133e-02f, -2.51338303e-01f, 2.78670132e-01f, -3.43704104e-01f, 8.37312490e-02f, 1.05302118e-01f, 2.00994890e-02f,
  1.59794930e-02f, 3.10535222e-01f, 3.85987051e-02f, 2.83057451e-01f, 1.34072497e-01f, 1.98581621e-01f, -1.08651169e-01f, -1.12936117e-01f, 3.82092923e-01f, -5.37508028e-03f,
  -4.61673021e-01f, 6.25501499e-02f, 1.53788731e-01f, 1.03133522e-01f, -2.08332568e-01f, 1.28385320e-01f, -3.50447983e-01f, -3.54123831e-01f, 1.69123709e-01f, 1.95592456e-02f,
  2.27691293e-01f, 1.11407444e-01f, 3.27007174e-01f, 1.12037465e-01f, 6.39545545e-02f, 5.24795689e-02f, 3.47042263e-01f, 1.52259961e-01f, 9.22363475e-02f, 4.40893732e-02f,
  5.79731651e-02f, 1.16436323e-02f, 7.39877746e-02f, 2.06530407e-01f, -9.09528285e-02f, -6.65878356e-02f, -6.77777007e-02f, 3.41066003e-01f, 2.96786815e-01f, -3.55952531e-01f,
  -5.24912849e-02f, 6.59566596e-02f, -1.00640498e-01f, 2.45888546e-01f, 2.36502692e-01f, -3.22532542e-02f, 4.37676102e-01f, 1.41894877e-01f, 3.28767866e-01f, 4.19029504e-01f,
  2.85682874e-03f, -1.37993738e-01f, 5.35237074e-01f, 3.33959311e-02f, -8.73932689e-02f, -4.62450057e-01f, -9.99946222e-02f, 1.63359493e-01f, -9.02814642e-02f, 3.52355868e-01f,
  -2.16412440e-01f, 2.08974198e-01f, 1.51537791e-01f, 4.17400479e-01f, 1.96492169e-02f, 2.91799217e-01f, 1.82844520e-01f, 4.43775803e-01f, -8.65454301e-02f, 3.09972405e-01f,
  3.43807876e-01f, -2.75107503e-01f, 4.37211424e-01f, -7.09852725e-02f, 2.20771000e-01f, 2.33866647e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  2.10787952e-01f, 7.94452708e-03f, 1.25927344e-01f, -1.62767358e-02f, 9.77682844e-02f, 4.78079356e-02f, 9.65663884e-03f, 2.28333727e-01f, 1.63006678e-01f, 7.72572830e-02f,
  1.00922756e-01f, 1.48180202e-01f, 1.98477238e-01f, 2.94561923e-01f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  -5.10172136e-02f, 6.70185313e-02f, 2.48373121e-01f, 1.50969606e-02f, 1.83058888e-01f, -2.50458270e-01f, -7.02111199e-02f, -1.10296890e-01f, 4.76031266e-02f, -2.03636527e-01f,
  4.24625985e-02f, 1.97726130e-01f, 2.03297450e-03f, -1.17441803e-01f, 2.13213831e-01f, 7.53601342e-02f, 1.28630670e-02f, 1.45369664e-01f, -1.25091895e-03f, 2.00956747e-01f,
  -5.57390749e-02f, 4.57562208e-02f, -2.26433072e-02f, 1.11598834e-01f, -1.65632114e-01f, 2.27756217e-01f, 3.56090754e-01f, 1.40689328e-01f, -9.18766782e-02f, -1.01210006e-01f,
  1.98199123e-01f, 1.43271089e-01f, 2.95818478e-01f, 3.31750959e-01f, 2.38370150e-01f, -3.11056733e-01f, 1.25078142e-01f, 5.88294044e-02f, 1.71818793e-01f, -1.98340520e-01f,
  2.03685701e-01f, 1.93175897e-01f, 4.27022353e-02f, -2.98225254e-01f, 7.09334016e-02f, -1.15880527e-01f, -2.78049260e-01f, 5.23116030e-02f, -3.17206711e-01f, 2.44477749e-01f,
  -3.43292028e-01f, -2.37031713e-01f, -1.12706713e-01f, -1.15572795e-01f, 6.69552311e-02f, -3.19140673e-01f, -3.55757475e-01f, 3.99097294e-01f, -3.95932257e-01f, -2.12174639e-01f,
  -1.76038861e-01f, -2.67243892e-01f, -1.34415701e-01f, 2.51978040e-01f, -1.00884736e-01f, 5.63306436e-02f, 1.46500692e-01f, 1.56483099e-01f, 1.00861803e-01f, -2.77284920e-01f,
  1.65189832e-01f, 4.87858690e-02f, -1.88444749e-01f, -2.79107578e-02f, 3.51098739e-02f, -1.51414812e-01f, -2.24970818e-01f, -7.66282603e-02f, -1.45558879e-01f, 1.50705772e-02f,
  -1.51991457e-01f, -2.47637123e-01f, 9.17948931e-02f, -2.06983805e-01f, 1.99625492e-01f, 1.19299591e-01f, -1.18977480e-01f, 7.46017247e-02f, 2.43739471e-01f, 2.27511138e-01f,
  4.11473773e-02f, -2.33379632e-01f, -4.57145758e-02f, -3.50111239e-02f, 9.81915835e-03f, 2.11516067e-01f, 1.64701805e-01f, 7.97696337e-02f, -3.12365711e-01f, -1.90381721e-01f,
  -2.42164820e-01f, -4.72134277e-02f, -3.06477368e-01f, -2.42118090e-01f, 6.65705353e-02f, 2.30786383e-01f, -1.11596249e-01f, 1.04570366e-01f, 2.61089504e-02f, -1.77017614e-01f,
  -1.27127782e-01f, -2.94455022e-01f, 9.78838727e-02f, -2.47377791e-02f, -5.99384978e-02f, 2.06301883e-01f, -3.17881554e-01f, -1.26823366e-01f, -4.72250551e-01f, -3.90107721e-01f,
  9.86433700e-02f, 2.52160579e-01f, -5.10026217e-01f, 7.04244971e-02f, 2.29258731e-01f, -1.84165195e-01f, 1.98657572e-01f, 3.65499109e-02f, 1.75421402e-01f, 9.89657119e-02f,
  1.57048151e-01f, -3.50625962e-02f, -3.85576822e-02f, 2.76783645e-01f, -4.94928807e-02f, -1.28749803e-01f, -3.40915881e-02f, -4.12790589e-02f, -2.07402974e-01f, -1.59643143e-01f,
  -1.79478005e-01f, 4.15225700e-02f, 1.93516254e-01f, 1.53212667e-01f, 1.13807596e-01f, -1.52518138e-01f, 1.10225521e-01f, -2.05520708e-02f, 1.65833756e-01f, 3.00434474e-02f,
  -5.17682172e-04f, 1.91216655e-02f, -6.94320947e-02f, -3.36175293e-01f, 1.67694077e-01f, -1.92281201e-01f, -5.22176512e-02f, -1.30694225e-01f, 1.47612035e-01f, -2.49263927e-01f,
  -1.93433017e-01f, 2.27049857e-01f, -3.89867872e-01f, 3.46155018e-01f, 1.18044913e-02f, -8.59480575e-02f, 2.49012500e-01f, -1.22188635e-01f, -2.66969711e-01f, 6.06720634e-02f,
  8.71080086e-02f, -2.64279097e-01f, 8.00406784e-02f, 1.92225158e-01f, 3.50538582e-01f, 1.98826700e-01f, 2.09695682e-01f, -2.59034425e-01f, -1.23093249e-02f, 1.82338998e-01f,
  2.59606898e-01f, -2.32080832e-01f, -5.70462108e-01f, -3.02195609e-01f, 2.24776760e-01f, -3.25155705e-01f, -3.72783989e-01f, -4.62323129e-02f, 8.58290344e-02f, 2.79905200e-01f,
  -1.41808242e-01f, 5.55330627e-02f, -1.79534350e-02f, -1.70952484e-01f, 1.69874758e-01f, -1.43925592e-01f, 2.09792494e-03f, -3.19261760e-01f, 1.83889002e-01f, 6.65230453e-02f,
  -1.09742589e-01f, 1.17107831e-01f, -7.90402740e-02f, -1.05645835e-01f, -3.04644331e-02f, -2.38708019e-01f, -1.27047626e-02f, 1.62452459e-01f, 5.24211302e-02f, -1.30235285e-01f,
  -1.81808101e-03f, 1.69793125e-02f, -1.40921816e-01f, -1.58319265e-01f, 7.57149681e-02f, 9.64807123e-02f, -1.96920455e-01f, 3.59303027e-01f, -2.47731432e-01f, -1.55936658e-01f,
  -3.21205020e-01f, 2.65168548e-01f, 2.38093757e-03f, -3.26135010e-01f, -1.04324922e-01f, -1.84882641e-01f, 2.55552351e-01f, 3.16035628e-01f, 8.04586411e-02f, -3.98558319e-01f,
  -7.11027831e-02f, -3.35532695e-01f, -1.68565512e-01f, -2.92123437e-01f, 2.02154040e-01f, -1.59724846e-01f, -3.59035283e-01f, -2.28338882e-01f, 1.52334347e-01f, -1.83076218e-01f,
  2.33395636e-01f, 1.75940439e-01f, -5.15881181e-01f, -2.45948926e-01f, -4.12948057e-02f, 2.90426493e-01f, 2.73833811e-01f, -2.13807032e-01f, -3.62856060e-01f, -4.22131687e-01f,
  1.55317485e-01f, -3.04081351e-01f, -2.52782315e-01f, -3.68547171e-01f, -3.20801765e-01f, 9.54701602e-02f, -1.40254954e-02f, 1.37427950e-03f, -1.38187751e-01f, 2.08017930e-01f,
  1.81539714e-01f, 1.94802552e-01f, 6.34530336e-02f, -1.53233185e-01f, 1.49015531e-01f, 5.11688255e-02f, 2.30466515e-01f, -2.24431038e-01f, -8.63364618e-03f, -1.33646214e-02f,
  -1.34991735e-01f, 8.68253037e-02f, -2.16739461e-01f, 1.94204852e-01f, 1.70649737e-01f, 7.44321570e-02f, 2.62853839e-02f, 2.24437892e-01f, -3.05361697e-03f, 5.82168363e-02f,
  2.51939744e-02f, -4.44427490e-01f, 1.49873465e-01f, 2.70821691e-01f, 3.76078516e-01f, 3.35157216e-01f, -1.53211057e-01f, 4.06313688e-01f, -3.61067683e-01f, -3.99948865e-01f,
  2.10904688e-01f, 7.17549101e-02f, 1.68605387e-01f, -3.86567563e-01f, 2.94502433e-02f, 2.08037928e-01f, -2.86211908e-01f, 1.48241103e-01f, 2.73891479e-01f, -1.04460403e-01f,
  2.60340005e-01f, 3.29871446e-01f, -1.04294866e-02f, -3.18052590e-01f, -2.64435977e-01f, 3.09470087e-01f, -4.29942608e-02f, -3.72908890e-01f, -1.32504895e-01f, -9.68255848e-03f,
  8.72776285e-02f, 1.57570913e-01f, -3.48266095e-01f, 1.18651902e-02f, 2.43242532e-01f, -3.36081833e-01f, -2.91714907e-01f, -4.02429342e-01f, 6.07460253e-02f, 1.28903911e-01f,
  -1.96281634e-02f, 7.31988177e-02f, -1.08045615e-01f, 1.46327198e-01f, 7.19773322e-02f, -3.03824828e-03f, -1.99179769e-01f, 1.64143056e-01f, -2.18890402e-02f, 1.55573547e-01f,
  1.34540051e-01f, 1.95979506e-01f, 1.48281872e-01f, -9.40548405e-02f, 3.76377068e-02f, -1.40333921e-01f, -2.45266687e-02f, 1.27774030e-01f, 2.84196027e-02f, -7.26975277e-02f,
  -1.08533315e-01f, -1.99936718e-01f, -3.29386622e-01f, -2.83060879e-01f, 7.90388063e-02f, -3.09420556e-01f, 1.35199562e-01f, 5.92454672e-02f, -2.33287513e-01f, -1.94915295e-01f,
  -1.28166273e-01f, -1.77831724e-01f, 1.30518779e-01f, 3.39196056e-01f, 3.15648705e-01f, -4.18961763e-01f, -1.07617564e-01f, 2.56344169e-01f, -4.06169929e-02f, 2.50849664e-01f,
  2.40797430e-01f, -2.70102352e-01f, 7.15102581e-03f, 3.90657037e-01f, -1.85732290e-01f, 8.10657963e-02f, -3.03220391e-01f, -2.83217639e-01f, -6.66638538e-02f, -2.71045715e-01f,
  8.51817504e-02f, 2.01415837e-01f, -1.30174369e-01f, -3.07084709e-01f, -2.16772303e-01f, 2.29949310e-01f, -1.79877847e-01f, 1.33255124e-01f, -3.83645557e-02f, -3.35231237e-02f,
  -3.69667739e-01f, -7.02719152e-01f, 1.90998897e-01f, 3.25424597e-02f, -1.50767446e-01f, 7.64367506e-02f, -1.48603439e-01f, 5.80117814e-02f, -5.02626710e-02f, 9.62994993e-02f,
  3.67745385e-02f, 1.69497326e-01f, 1.51986465e-01f, 2.21778695e-02f, 1.06229102e-02f, -1.35638058e-01f, -1.01096250e-01f, -4.53055283e-04f, -1.77168876e-01f, 1.50955841e-02f,
  -4.35497425e-03f, 6.94252700e-02f, 1.22144222e-01f, -1.73337534e-01f, 2.77869970e-01f, 1.97932720e-01f, -7.83596988e-05f, -6.92939311e-02f, -1.63403690e-01f, -5.54976873e-02f,
  2.51574397e-01f, 6.27952814e-02f, 2.91148007e-01f, -2.57171273e-01f, 1.64434925e-01f, 1.52021825e-01f, -2.87918508e-01f, 1.12533376e-01f, 1.82407528e-01f, 2.68110752e-01f,
  -2.21341383e-02f, 1.03076667e-01f, 2.34735683e-01f, 1.28488600e-01f, -3.51581663e-01f, -1.99321702e-01f, -1.34818211e-01f, 2.35529765e-01f, -3.07140294e-02f, -1.72638610e-01f,
  -1.95322670e-02f, -2.48472784e-02f, -2.28690550e-01f, -1.81616634e-01f, 2.83753455e-01f, 2.40477234e-01f, 3.47106397e-01f, -7.63855800e-02f, -3.95055622e-01f, 1.37551144e-01f,
  -1.44118071e-01f, -1.78756475e-01f, -2.84898560e-02f, 3.00924689e-01f, -4.85253900e-01f, 4.98424992e-02f, -4.06372696e-01f, -3.52107018e-01f, -3.46270725e-02f, -1.38853624e-01f,
  1.96082160e-01f, -2.05644950e-01f, -1.57843336e-01f, 1.61224492e-02f, 1.52897045e-01f, -1.56251475e-01f, -1.92141607e-02f, 8.39141663e-03f, 1.25974327e-01f, -2.05129445e-01f,
  1.53036088e-01f, -2.36264300e-02f, -3.41959633e-02f, -3.01302746e-02f, -2.17301510e-02f, -7.86953196e-02f, 3.22272442e-02f, 1.73249602e-01f, -4.42035794e-02f, -1.52077809e-01f,
  1.58812776e-01f, -1.50228254e-02f, -1.41150057e-01f, 2.98820019e-01f, -2.45685488e-01f, -2.24719673e-01f, 2.51255929e-01f, 3.85854356e-02f, -1.03976876e-01f, 2.31654301e-01f,
  -2.56583661e-01f, -2.21547738e-01f, -3.12967062e-01f, 2.50788540e-01f, 1.82490066e-01f, -8.17290172e-02f, -1.33464023e-01f, -2.82642186e-01f, 1.39736697e-01f, -2.57513255e-01f,
  1.87781617e-01f, -2.10973904e-01f, -3.39805514e-01f, -2.45678589e-01f, 8.69095102e-02f, -6.37843013e-02f, 2.27512270e-01f, 3.47433746e-01f, -4.33430493e-01f, -2.62899637e-01f,
  -2.06923764e-02f, -3.04549307e-01f, -2.06640810e-01f, 1.53835818e-01f, -2.56925136e-01f, -2.36339256e-01f, -2.86983013e-01f, -2.71406025e-01f, -1.10294014e-01f, 6.04997993e-01f,
  3.06865185e-01f, 1.67900950e-01f, -1.17687091e-01f, -8.04237202e-02f, 1.12497926e-01f, -5.65797202e-02f, -5.22056594e-02f, 1.37624696e-01f, -1.93788499e-01f, 8.82467330e-02f,
  7.87132904e-02f, 2.06902083e-02f, -2.47382894e-02f, -6.49604723e-02f, 1.29100263e-01f, 6.30286932e-02f, 2.29690820e-02f, -1.94227606e-01f, 1.14062920e-01f, 2.90057762e-03f,
  -7.07674399e-02f, -1.34908542e-01f, 7.63745829e-02f, -2.65960582e-02f, -9.14111063e-02f, -5.37533760e-02f, -8.17032754e-02f, 2.52763987e-01f, -1.81800514e-01f, -1.36061177e-01f,
  -2.15843081e-01f, 1.20571062e-01f, -1.31326512e-01f, -1.34446332e-02f, 7.61603788e-02f, -1.40240118e-02f, 2.03395709e-01f, -4.65540588e-02f, 1.35332886e-02f, -1.28385425e-01f,
  1.88893840e-01f, 3.48156318e-02f, -3.32410936e-03f, 2.02219352e-01f, 1.25345930e-01f, 3.64805400e-01f, -6.10045507e-04f, 2.30482161e-01f, -1.92207128e-01f, 2.02987120e-01f,
  5.36196977e-02f, 2.21867636e-02f, 8.88222009e-02f, -2.47809708e-01f, 2.86064893e-01f, -2.27781042e-01f, -1.35562330e-01f, -2.95159131e-01f, 2.28616565e-01f, 2.31417999e-01f,
  -1.21131524e-01f, 1.88637823e-01f, 1.70662686e-01f, 6.30977079e-02f, -4.38826472e-01f, -5.20793378e-01f, -4.62864526e-02f, 5.28832600e-02f, -3.73929217e-02f, -9.34318304e-02f,
  1.46683790e-02f, 5.43308817e-02f, -1.02142833e-01f, -1.51210517e-01f, 1.05133332e-01f, -1.37342498e-01f, -1.33573458e-01f, 6.54917508e-02f, -1.26756594e-01f, 2.18607917e-01f,
  -6.63893521e-02f, 1.10982552e-01f, -1.29845724e-01f, 2.04174250e-01f, -1.12825885e-01f, -1.10673256e-01f, -1.05347276e-01f, 9.60135758e-02f, 1.78803265e-01f, -8.13192204e-02f,
  -1.57557614e-02f, -1.67688012e-01f, 2.22021967e-01f, 1.01842932e-01f, 4.30786759e-02f, 4.43993747e-01f, -2.15291400e-02f, 1.80075839e-02f, 5.16529083e-02f, 6.63682371e-02f,
  -3.72594625e-01f, 1.58216164e-01f, 5.49632832e-02f, 1.48601994e-01f, -1.20442845e-01f, 2.31028885e-01f, 1.87507182e-01f, 7.38337561e-02f, -1.44069314e-01f, 3.29359949e-01f,
  2.42123634e-01f, 8.66432190e-02f, 2.65704304e-01f, 2.39916906e-01f, -2.33454198e-01f, -2.62994736e-01f, -1.23417966e-01f, 2.45816097e-01f, -2.78973132e-01f, 9.30471793e-02f,
  -2.93442637e-01f, 2.56650120e-01f, -1.19616404e-01f, -6.65370047e-01f, 1.92975506e-01f, -2.66412377e-01f, -1.65238246e-01f, 7.16500580e-02f, 2.49904588e-01f, 3.95823605e-02f,
  -1.98683277e-01f, -7.99381882e-02f, 2.64064223e-02f, -1.24504015e-01f, 1.65486172e-01f, -2.34849930e-01f, -1.48330614e-01f, -1.38583183e-01f, 1.43761158e-01f, -1.74437806e-01f,
  1.65310547e-01f, 2.36384392e-01f, -7.08411038e-02f, -6.26030862e-02f, -1.55503780e-01f, -2.87516546e-02f, -6.70742467e-02f, 1.82584524e-01f, 1.76127497e-02f, 2.02853993e-01f,
  9.32294875e-02f, 1.68625712e-01f, 1.13893926e-01f, -1.21857859e-01f, -9.61503908e-02f, 1.31551981e-01f, 2.44937893e-02f, -3.35428081e-02f, -1.45607814e-01f, -2.41602391e-01f,
  1.26890510e-01f, -1.60427853e-01f, 3.17654759e-01f, -2.51936734e-01f, -5.64425671e-03f, -1.02835074e-01f, -9.58703607e-02f, 2.76509047e-01f, -6.48190156e-02f, -1.74674600e-01f,
  -2.54264742e-01f, 3.02684605e-01f, -2.15701625e-01f, -2.59462118e-01f, -1.29156679e-01f, 1.06987886e-01f, -1.98663831e-01f, 2.43016891e-02f, 4.26303484e-02f, 2.47973338e-01f,
  -2.89144427e-01f, -2.47483566e-01f, -1.76927969e-01f, 2.10858136e-01f, 1.33418456e-01f, -2.46611655e-01f, 1.74938753e-01f, -7.46691525e-02f, 4.94798739e-03f, 1.32857010e-01f,
  3.57189536e-01f, -5.37724257e-01f, -2.77997255e-01f, -2.09590554e-01f, 2.08883271e-01f, -1.10649675e-01f, -2.26243004e-01f, -4.97113764e-02f, -1.14825547e-01f, 9.76646394e-02f,
  2.10443333e-01f, -2.61575598e-02f, -1.47402778e-01f, -1.22135632e-01f, 1.01411372e-01f, 2.10254490e-01f, 1.11923240e-01f, 1.79976583e-01f, 8.20514336e-02f, 1.03639580e-01f,
  -1.22687347e-01f, -1.79576337e-01f, -1.01364553e-01f, 7.77005330e-02f, -1.20417774e-01f, 8.41045007e-03f, 8.53594840e-02f, -1.62512437e-02f, 8.11451077e-02f, 2.84893382e-02f,
  -1.43113166e-01f, 1.68640628e-01f, -1.96915999e-01f, -2.98786402e-01f, -8.43496099e-02f, 5.37421927e-02f, 2.58586667e-02f, -2.03281090e-01f, 6.17937297e-02f, -1.98036388e-01f,
  -1.03865385e-01f, 1.58188388e-01f, 8.02411512e-02f, 1.98972225e-01f, -8.98413435e-02f, -2.48646900e-01f, -2.61580855e-01f, 3.49329770e-01f, 7.69203082e-02f, -1.92889047e-03f,
  -2.70439506e-01f, 2.54362822e-01f, 3.35793406e-01f, -3.77989680e-01f, 1.12160720e-01f, -3.39309245e-01f, -1.95332363e-01f, 2.47616187e-01f, 1.93862617e-01f, 4.92642969e-02f,
  1.08074605e-01f, -3.18625495e-02f, 2.09872767e-01f, 9.36915725e-02f, -4.55960929e-01f, -3.31316628e-02f, -2.22286563e-02f, -5.43544948e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  4.92705666e-02f, -4.09357771e-02f, 6.25666901e-02f, 4.92202081e-02f, 9.26928893e-02f, 1.28644645e-01f, -1.11120269e-01f, 1.20376587e-01f, 3.00606973e-02f, 1.00947663e-01f,
  -2.28164606e-02f, -5.96498586e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    