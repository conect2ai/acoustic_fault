/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.19768658e-02f, -1.43770427e-02f, 1.86606795e-01f, 7.91998506e-02f, -1.07190283e-02f, -1.57989889e-01f, -1.73300222e-01f, 1.02781065e-01f, -1.00963034e-01f, -1.42637059e-01f,
  -1.80983976e-01f, -9.34252664e-02f, -1.30858511e-01f, -1.94274172e-01f, -1.80098161e-01f, -1.12093866e-01f, -1.85781002e-01f, -1.17800206e-01f, 2.60550100e-02f, -9.03209019e-03f,
  5.48616871e-02f, -3.12651657e-02f, 2.03860998e-01f, 1.16013877e-01f, 1.13247491e-01f, 2.11149618e-01f, 1.10225111e-01f, 1.75637096e-01f, 1.39194906e-01f, -3.34722437e-02f,
  -9.55721438e-02f, -1.36643246e-01f, -2.51071132e-03f, -1.69785079e-02f, 2.53109783e-02f, -3.42332534e-02f, -1.12516815e-02f, -1.83538590e-02f, -5.02371714e-02f, 3.75835262e-02f,
  1.30329281e-02f, 3.62893827e-02f, 5.12175895e-02f, -1.41459303e-02f, -5.70996143e-02f, 2.43503246e-02f, 2.03798208e-02f, 5.00796698e-02f, -4.43120021e-03f, 1.17488112e-02f,
  -5.72573282e-02f, 9.79219899e-02f, 5.71329929e-02f, 5.49792089e-02f, 6.53374568e-02f, 6.25558645e-02f, 7.04298317e-02f, 2.20193975e-02f, -1.90400630e-02f, 4.40583713e-02f,
  7.65441805e-02f, 7.25840777e-02f, 3.99505757e-02f, 9.71924805e-04f, -1.20939827e-02f, -3.44412378e-03f, -1.63454209e-02f, -9.42282751e-03f, 3.36392336e-02f, -6.69195130e-02f,
  3.18705328e-02f, 2.53755003e-02f, 5.91215678e-02f, 5.28603494e-02f, 1.30876340e-02f, 3.52155860e-03f, 3.69383879e-02f, 3.98816587e-03f, 2.20641624e-02f, -2.22767442e-02f,
  -5.06029464e-02f, 1.89360566e-02f, 4.05612141e-02f, 9.45629366e-03f, -3.45048904e-02f, 6.66925833e-02f, 3.07666101e-02f, 3.01209781e-02f, 3.75406109e-02f, 1.00431796e-02f,
  -1.12349451e-01f, -5.84987365e-02f, -2.51545664e-02f, 7.05600902e-02f, -9.47635770e-02f, -1.17221095e-01f, -4.19355594e-02f, 6.05347492e-02f, 1.38472561e-02f, 2.74555106e-02f,
  1.79454908e-02f, -2.44211741e-02f, 3.18748131e-02f, 7.75577351e-02f, 5.66241927e-02f, -5.29285818e-02f, 7.34085683e-03f, 1.25071835e-02f, -8.02761391e-02f, -1.35482466e-02f,
  6.98825493e-02f, 3.26014720e-02f, -2.58627590e-02f, 7.47915208e-02f, -3.79424877e-02f, -3.51658165e-02f, 6.94519356e-02f, 3.37801017e-02f, -5.18697361e-03f, -5.77805564e-02f,
  -1.68313477e-02f, -3.55908662e-01f, -3.04898411e-01f, 1.97239202e-02f, -2.55092662e-02f, 2.76026785e-01f, 2.05178246e-01f, -1.14428647e-01f, 1.59011379e-01f, -2.08389059e-01f,
  8.02033544e-02f, -8.96217376e-02f, -8.32708031e-02f, 1.28656983e-01f, 4.10630316e-01f, 1.47877499e-01f, 2.45242283e-01f, -8.84408411e-03f, 1.83245555e-01f, -5.87816238e-02f,
  1.48723453e-01f, 2.39056930e-01f, -7.64713287e-02f, -4.84504998e-02f, -1.04611799e-01f, -1.23870030e-01f, -1.72801688e-01f, -7.97848031e-02f, -3.67979705e-02f, 6.37512207e-02f,
  -1.92353223e-02f, -7.05141202e-02f, -1.15358703e-01f, -8.76071453e-02f, -9.95072126e-02f, -1.21448658e-01f, -1.01741344e-01f, -5.53590478e-03f, 2.65040677e-02f, -2.23633368e-02f,
  1.70379039e-02f, 9.05923918e-03f, 1.24397546e-01f, 7.00405836e-02f, 3.55371535e-02f, -1.04055647e-03f, 6.16097748e-02f, -5.38775437e-02f, -4.73334594e-03f, 5.59422188e-02f,
  2.70468798e-02f, 3.30337211e-02f, -2.96833627e-02f, 1.11997746e-01f, -3.49294581e-02f, 6.14080057e-02f, 2.96578575e-02f, -5.99988960e-02f, -4.18598913e-02f, 4.85094301e-02f,
  4.18252163e-02f, -2.21014172e-02f, -3.64926867e-02f, 5.00376290e-03f, -6.91531003e-02f, 7.25805387e-02f, 1.72756836e-02f, 9.97999590e-03f, -4.85932417e-02f, -4.19117650e-03f,
  -3.04496456e-02f, -1.11319602e-03f, 4.36797366e-02f, 1.41045200e-02f, 2.07734443e-02f, -9.58956894e-04f, -2.64093131e-02f, 7.45359063e-02f, 1.29980426e-02f, -7.28662079e-03f,
  6.03095740e-02f, 8.05210695e-02f, -6.28653467e-02f, -3.05751655e-02f, 2.24734247e-02f, -6.53601363e-02f, -5.45809884e-03f, -1.10520847e-01f, 1.07271469e-03f, -5.59357693e-03f,
  -1.00474671e-01f, -2.11989596e-01f, 4.59627733e-02f, 2.51161661e-02f, -1.43913068e-02f, -3.19075286e-02f, -7.54616736e-03f, -1.15457652e-02f, -1.10624559e-01f, 4.57559042e-02f,
  -7.14271795e-03f, -7.06628785e-02f, -2.83700395e-02f, 3.14532630e-02f, -3.51111375e-05f, 6.69227168e-03f, 3.10496483e-02f, -5.56183746e-03f, -1.55015271e-02f, -7.70981330e-03f,
  -1.24458492e-01f, 4.77070780e-03f, -3.56349684e-02f, -3.48417647e-02f, -1.85738169e-02f, -1.32561643e-02f, 3.22846137e-02f, -3.40511464e-02f, 9.55576077e-03f, 3.81635278e-02f,
  1.41297225e-02f, -2.87069064e-02f, -3.76387462e-02f, 9.24797729e-02f, -5.37263863e-02f, -1.36802197e-01f, -1.07796989e-01f, 2.62659322e-02f, -2.35070199e-01f, 1.12591041e-02f,
  1.16328150e-01f, -2.24157386e-02f, -8.11292883e-03f, 1.90963864e-01f, 1.58092752e-01f, -2.00661011e-02f, 1.11760847e-01f, 1.63335167e-02f, -5.55924736e-02f, -5.09449430e-02f,
  -5.50711118e-02f, 1.78191155e-01f, 1.22294024e-01f, 1.99285105e-01f, 9.90928337e-03f, 6.26028404e-02f, 1.39276922e-01f, -2.73417197e-02f, 2.16800630e-01f, 5.57772331e-02f,
  5.51482779e-04f, -2.46972986e-03f, -1.03661818e-02f, -8.20497144e-03f, -5.16193844e-02f, 1.49231059e-02f, 5.15911728e-02f, 3.95744853e-02f, 2.98843230e-03f, -2.71577518e-02f,
  9.27344523e-03f, 4.60740104e-02f, -2.68561523e-02f, -2.32479479e-02f, 1.56169655e-02f, 4.72721495e-02f, -7.77812600e-02f, -7.54452795e-02f, -1.05292000e-01f, -7.08879083e-02f,
  -1.23894354e-02f, -1.27042353e-01f, -1.11810721e-01f, 1.40397055e-02f, 3.82245705e-02f, -5.13866486e-04f, -3.01943757e-02f, 5.80702387e-02f, 1.42638106e-02f, 6.67794496e-02f,
  2.22136304e-02f, -4.17996310e-02f, -1.27102910e-02f, -4.80712354e-02f, 4.83361781e-02f, -7.59066865e-02f, -4.93395515e-02f, -4.94937859e-02f, -7.45644153e-04f, -4.94522862e-02f,
  6.31091520e-02f, 7.17043644e-03f, -9.21510980e-02f, -5.66318333e-02f, -2.23854813e-03f, -6.97573572e-02f, -9.77203948e-04f, -1.81306787e-02f, 1.77509487e-02f, 9.01664514e-03f,
  1.60561744e-02f, -5.06554954e-02f, 4.83687073e-02f, -5.40166609e-02f, 7.91757852e-02f, 1.36876199e-02f, 4.77373460e-03f, -4.90716584e-02f, 5.80879450e-02f, 2.46739015e-03f,
  -6.82850629e-02f, 1.38526014e-03f, 9.45288464e-02f, 4.53368686e-02f, 4.08799239e-02f, -7.77928010e-02f, 5.04810475e-02f, -2.64125951e-02f, 3.52763571e-02f, -4.76525305e-03f,
  3.52540612e-02f, -2.97128595e-02f, -7.16577470e-02f, -3.21534574e-02f, 4.29655947e-02f, 1.27601530e-02f, 6.19745702e-02f, 1.73571464e-02f, 1.01735279e-01f, 3.07482798e-02f,
  5.79449609e-02f, -9.19858068e-02f, 9.13596153e-02f, -3.49723771e-02f, 1.09420614e-02f, 4.50872406e-02f, -4.92258780e-02f, 8.08059145e-03f, 1.10763535e-02f, -3.75654101e-02f,
  2.93320239e-01f, -5.67962788e-02f, 4.55485433e-02f, 1.48799896e-01f, -1.45998076e-02f, -7.09777847e-02f, -1.85892414e-02f, -8.33106786e-02f, 7.23131672e-02f, 3.85081694e-02f,
  3.90505865e-02f, 5.62123358e-02f, -4.61206697e-02f, 1.39193311e-01f, 1.19872212e-01f, 1.70855876e-02f, 1.42880946e-01f, -4.62629236e-02f, 3.24891396e-02f, 6.93359226e-02f,
  1.00994371e-01f, -2.84938253e-02f, 1.45833030e-01f, 1.14949690e-02f, 2.02885401e-02f, -1.20284013e-01f, -9.02229920e-03f, -4.92513739e-02f, 4.71488349e-02f, 4.84346263e-02f,
  7.26074651e-02f, -1.98715832e-02f, 5.20181395e-02f, 4.17308882e-02f, -6.97007179e-02f, -5.27214669e-02f, -9.98549815e-03f, 2.01583672e-02f, -8.44893903e-02f, 1.53857078e-02f,
  1.72322821e-02f, -1.06910756e-02f, 2.46898588e-02f, 3.96210365e-02f, 7.12335482e-02f, 5.23625575e-02f, -1.64194889e-02f, -1.62259899e-02f, -5.77428285e-03f, -1.35936774e-03f,
  3.66017222e-02f, -2.35300120e-02f, 2.35363021e-02f, -8.05722177e-02f, -5.54327620e-03f, 8.77207369e-02f, 1.91451963e-02f, 4.55470793e-02f, -4.45556343e-02f, 4.74771336e-02f,
  4.25049162e-04f, -2.34538540e-02f, -3.08074784e-02f, -2.66369842e-02f, 4.34142277e-02f, -8.97062570e-02f, 6.13679131e-03f, -1.02287554e-03f, 3.87219302e-02f, 1.13140210e-03f,
  1.69391315e-02f, 6.68803975e-02f, 8.01627710e-02f, -4.10119072e-02f, -1.36202043e-02f, -4.49757848e-04f, 6.19637221e-02f, -7.04515353e-02f, 4.27590869e-03f, 2.60453708e-02f,
  2.22089682e-02f, 1.57189295e-02f, -3.52530926e-02f, 4.20438685e-02f, 9.96295139e-02f, -3.03245299e-02f, 1.65015683e-02f, 6.89230300e-03f, -2.71632597e-02f, -4.86277230e-02f,
  -1.35500178e-01f, -7.66909048e-02f, -4.82743494e-02f, 4.23633084e-02f, 3.35620530e-02f, 3.30071822e-02f, -2.85284258e-02f, -2.28693392e-02f, 5.11957929e-02f, 1.60151552e-02f,
  -1.09957837e-01f, -1.29769556e-02f, -9.29459259e-02f, -3.38834971e-02f, 2.70446204e-02f, 3.59574817e-02f, -4.24418449e-02f, -6.55652210e-02f, -1.03271771e-02f, 2.63032522e-02f,
  -6.22608103e-02f, -6.83895350e-02f, 7.63681531e-02f, -9.25937518e-02f, -7.88081363e-02f, -1.02744401e-01f, -8.17821696e-02f, 5.09889685e-02f, -9.86828562e-03f, -3.37073877e-02f,
  3.65323573e-01f, -3.85846645e-02f, 9.04547721e-02f, 2.21534178e-01f, -3.05190999e-02f, -1.14747301e-01f, -1.55029133e-01f, 1.59583315e-01f, 1.21966109e-01f, -1.03429876e-01f,
  1.94351673e-02f, 1.34336889e-01f, -9.08408612e-02f, 1.87498376e-01f, 1.24968871e-01f, -5.07641770e-02f, 1.59586892e-01f, 7.40067512e-02f, -6.40479699e-02f, 2.85059270e-02f,
  6.34452477e-02f, 1.16521691e-03f, 8.85433108e-02f, 3.97689342e-02f, 8.49566609e-02f, 6.14941046e-02f, -5.46661802e-02f, -1.53571710e-01f, 1.33982822e-01f, 4.14695218e-02f,
  4.30366769e-02f, 2.44223788e-01f, 4.58241515e-02f, -3.30715626e-02f, -2.95876414e-02f, 3.47103737e-02f, 1.39114028e-02f, -1.27565954e-02f, 1.92885883e-02f, -2.51463298e-02f,
  -6.01555035e-02f, -1.11007355e-02f, -3.97780649e-02f, -1.68762282e-02f, -5.26624545e-02f, -9.18688700e-02f, 2.90567130e-02f, 8.95584598e-02f, 7.87279829e-02f, -4.04396541e-02f,
  -7.77760297e-02f, -4.14423868e-02f, 1.07570430e-02f, -8.72781128e-03f, 1.36870652e-01f, 1.99948400e-02f, -4.27776389e-02f, -4.46253680e-02f, 5.46701886e-02f, -2.69255675e-02f,
  1.10219745e-02f, 5.30496389e-02f, 6.12395108e-02f, 7.78210233e-04f, 7.48471692e-02f, 2.56177299e-02f, 7.95042589e-02f, -5.58525175e-02f, 3.33003663e-02f, -8.47902894e-03f,
  1.98141560e-02f, 5.72620295e-02f, -1.25378165e-02f, 2.66170762e-02f, -2.74539385e-02f, 5.20886295e-02f, -3.99624370e-02f, -1.02745891e-02f, 3.42380535e-03f, 7.40924403e-02f,
  -4.51555327e-02f, -2.84529217e-02f, -8.98943003e-03f, -2.61939280e-02f, -1.50963350e-03f, 5.45560941e-03f, 3.96474972e-02f, 6.42629787e-02f, -5.37809171e-02f, 4.16233391e-02f,
  -8.06888714e-02f, 1.22616671e-01f, 2.81658266e-02f, -2.87186448e-02f, -2.23033465e-02f, -1.29993754e-02f, -1.22432252e-02f, 2.74480302e-02f, 1.60704758e-02f, -2.42074467e-02f,
  5.19324280e-02f, -4.10671197e-02f, 4.11006957e-02f, 4.51739542e-02f, 1.34029742e-02f, -2.18912736e-02f, 1.99321844e-03f, 4.52555530e-02f, 1.33050773e-02f, 1.21974826e-01f,
  1.48225576e-02f, -4.66204248e-02f, -2.06635240e-02f, 6.08273447e-02f, 8.02518707e-03f, 1.49942879e-02f, -2.14627683e-02f, -4.01998796e-02f, -4.63235565e-03f, -1.05753206e-02f,
  -3.93703163e-01f, 2.31380820e-01f, -1.14315771e-01f, -5.72542250e-02f, -9.82513726e-02f, -2.40435973e-02f, -1.88602153e-02f, 7.30097368e-02f, 1.10115029e-01f, 1.61289707e-01f,
  6.22455589e-02f, 1.14281261e-02f, 9.68122333e-02f, 8.97517875e-02f, -1.46509677e-01f, 7.40612075e-02f, 2.85131820e-02f, 9.71018448e-02f, 3.84499580e-02f, -7.02613741e-02f,
  -2.87709497e-02f, 1.07903242e-01f, -1.10410146e-01f, -1.76617969e-02f, -1.38363719e-01f, -5.53204827e-02f, -1.30839318e-01f, -2.25420326e-01f, -5.21002300e-02f, -3.88963930e-02f,
  -8.11446551e-03f, 8.86792690e-02f, -9.98462811e-02f, 6.02458231e-02f, 1.01666793e-03f, 4.34240997e-02f, -3.94369625e-02f, -1.46385342e-01f, -2.92583443e-02f, 1.43593093e-02f,
  9.36016161e-03f, -2.69745141e-02f, 8.33713487e-02f, -9.30392444e-02f, 1.47251682e-02f, -2.00883243e-02f, -1.92340724e-02f, -2.57754717e-02f, 1.40673164e-02f, 3.01420782e-02f,
  1.34026473e-02f, 2.72101723e-02f, 2.63113691e-03f, 7.94665888e-02f, -7.87834451e-02f, 3.01022734e-03f, 9.55378190e-02f, 6.43382687e-03f, 8.01930111e-03f, 4.32451209e-03f,
  3.72400843e-02f, 2.92937178e-02f, 7.61170983e-02f, -1.58662591e-02f, 2.92969998e-02f, 2.23778989e-02f, -2.64046416e-02f, 3.92167270e-03f, 1.13006057e-02f, -1.67945568e-02f,
  -1.15255555e-02f, -3.84439691e-03f, 8.38625804e-02f, 1.75122786e-02f, 1.87125392e-02f, -6.08341396e-03f, 2.34910782e-04f, 6.09042086e-02f, 3.10626049e-02f, -1.27078546e-02f,
  2.13928837e-02f, -1.30561134e-02f, 5.00163473e-02f, 2.58806329e-02f, 1.45773012e-02f, -4.44518775e-02f, 7.10733607e-02f, -6.25722855e-02f, 1.19209348e-03f, -6.89081773e-02f,
  1.55662253e-01f, 2.03136072e-01f, -1.62560586e-02f, 3.52373384e-02f, 2.65989546e-02f, 3.65179218e-02f, 7.39936903e-02f, 2.63743140e-02f, 1.03040323e-01f, -2.06325147e-02f,
  5.78347929e-02f, -2.18813866e-02f, -6.78643864e-03f, -2.95709241e-02f, -8.64864979e-03f, 7.67472163e-02f, 4.12456356e-02f, -1.89243983e-02f, 5.18139638e-03f, -1.22414231e-02f,
  -6.24952605e-03f, 1.51512166e-02f, -1.37016680e-02f, -8.72922167e-02f, 7.33223036e-02f, -2.57398728e-02f, -2.03354750e-02f, -2.70852745e-02f, 2.09380575e-02f, -2.40182877e-02f,
  -1.44193336e-01f, -7.43618906e-02f, -2.32348323e-01f, -9.90275946e-03f, -9.61862653e-02f, -3.21220085e-02f, -6.70237914e-02f, 4.64640483e-02f, 2.61619482e-02f, 6.98496401e-02f,
  1.67331845e-01f, -1.47871122e-01f, -2.52674352e-02f, 2.19125412e-02f, 3.63514386e-02f, 2.94035282e-02f, 8.35077912e-02f, -2.20052358e-02f, 2.38063112e-02f, 5.66673428e-02f,
  3.74438241e-02f, 1.13221608e-01f, 3.23267020e-02f, -4.55460399e-02f, -1.79900955e-02f, -8.60787034e-02f, 4.82407659e-02f, 3.98688056e-02f, -1.49863819e-02f, 4.53218482e-02f,
  -2.31145844e-02f, 2.62084678e-02f, -4.42502089e-03f, 8.04883689e-02f, -3.32011841e-02f, -7.85143673e-02f, 8.97293724e-03f, -4.90276963e-02f, -8.07777271e-02f, -5.56480139e-02f,
  -1.95125081e-02f, 5.92956603e-05f, 5.67664169e-02f, -1.55643681e-02f, -6.16299957e-02f, -2.99088191e-02f, 4.94704917e-02f, -6.54463693e-02f, 2.47490648e-02f, -9.24333930e-03f,
  -5.25877066e-02f, -8.32590461e-02f, -9.32912305e-02f, 2.47200653e-02f, -8.53283927e-02f, -1.16743464e-02f, -6.41221479e-02f, -9.59658548e-02f, 5.68120927e-02f, -3.49442288e-02f,
  5.35142496e-02f, 6.20547421e-02f, 6.96082637e-02f, 1.41101955e-02f, 1.18137203e-01f, -1.83714796e-02f, 8.15428793e-03f, -2.94022076e-02f, 1.08413287e-02f, -2.22091116e-02f,
  -3.90860587e-02f, -4.05701324e-02f, -4.98418696e-02f, -3.26805934e-03f, 6.62779659e-02f, 4.71630618e-02f, -4.49748933e-02f, -9.41913798e-02f, -2.58187745e-02f, -5.33723198e-02f,
  -4.22337912e-02f, 1.73624773e-02f, 2.64421739e-02f, 3.77556682e-02f, -2.37499382e-02f, -2.93604806e-02f, -8.96404237e-02f, -6.54401183e-02f, 5.55684566e-02f, -7.03363791e-02f,
  1.55420274e-01f, 7.36903027e-02f, 5.89929172e-04f, 3.30134965e-02f, -3.02401595e-02f, 7.60303810e-02f, -4.59958315e-02f, 8.23615044e-02f, 6.83270767e-02f, 1.01818062e-01f,
  -3.60106863e-02f, -3.23608331e-02f, -6.94754124e-02f, -6.07447214e-02f, 3.35785821e-02f, -3.74672227e-02f, 1.58743206e-02f, 1.37178436e-01f, 2.64081471e-02f, -1.96264796e-02f,
  4.81626540e-02f, -2.77655032e-02f, -1.57826263e-02f, -6.66724071e-02f, 3.19286771e-02f, 5.83918430e-02f, -5.04386891e-03f, -5.28092310e-02f, 1.67719219e-02f, 1.41292876e-02f,
  -1.88341811e-02f, -6.42656386e-02f, 9.00273398e-02f, -7.90227652e-02f, -5.47310449e-02f, 1.29165158e-01f, 6.16266988e-02f, 2.19652317e-02f, 1.26186269e-03f, -1.07299410e-01f,
  -1.14293844e-02f, -1.72509551e-01f, 1.13286860e-01f, -8.50419924e-02f, -1.26833785e-02f, 3.02150920e-02f, 8.19657743e-03f, 4.60470691e-02f, 2.33464083e-03f, -6.35036826e-02f,
  1.12733757e-02f, -5.14949858e-02f, -4.92679253e-02f, -7.04589859e-02f, -5.54822721e-02f, 2.09525004e-02f, -1.40742317e-01f, -7.18392082e-04f, -5.84929734e-02f, -5.18351011e-02f,
  5.65010719e-02f, -9.12789553e-02f, -1.88402962e-02f, -3.97831574e-02f, 2.40448187e-03f, -1.28952367e-02f, -4.53503337e-03f, 3.06717865e-02f, 2.40771715e-02f, -3.63836065e-02f,
  -1.24852315e-01f, 4.29707952e-02f, 2.25938484e-02f, 3.72074060e-02f, -5.17579839e-02f, -1.77322514e-02f, 2.47105937e-02f, 7.18114839e-04f, -3.50343920e-02f, -2.95953080e-02f,
  -6.62501436e-03f, 2.11928375e-02f, -8.54422003e-02f, 2.85483990e-02f, 2.45639160e-02f, -4.30283956e-02f, 1.07084103e-02f, -7.25435093e-02f, 3.30727845e-02f, -8.17285404e-02f,
  -3.68494876e-02f, -1.16989110e-02f, 1.96178369e-02f, -2.48684362e-02f, 3.51901427e-02f, -1.43097062e-02f, 9.17502865e-02f, 4.39602882e-03f, -5.76327778e-02f, -8.49663466e-02f,
  4.25121635e-02f, -5.51094748e-02f, -8.08696225e-02f, 3.32856178e-02f, -6.01729490e-02f, 3.97876017e-02f, 6.77179098e-02f, -2.72487290e-02f, 9.15444344e-02f, 4.75275367e-02f,
  -1.01301931e-01f, -4.93268743e-02f, 1.41217243e-02f, 5.20960204e-02f, 3.95191554e-03f, 7.04218354e-03f, -1.02389291e-01f, 4.88191564e-03f, 5.65024279e-02f, -2.14698315e-02f,
  -1.42562047e-01f, -5.73170111e-02f, 5.27636483e-02f, -3.12354378e-02f, 2.87071266e-03f, -4.74215634e-02f, 5.29346056e-03f, -5.15275002e-02f, 6.55604526e-02f, -4.25158180e-02f,
  -3.32859829e-02f, -5.66926859e-02f, -5.65001778e-02f, 7.39326887e-03f, 2.84166913e-02f, -6.70663640e-02f, -1.68535095e-02f, 4.93683666e-02f, 2.57631838e-02f, 4.47830604e-03f,
  -1.17929410e-02f, -6.49049431e-02f, -2.66491286e-02f, -2.01129969e-02f, 6.09932188e-03f, -1.05111878e-02f, 7.01074675e-02f, -3.62323411e-02f, -3.29827406e-02f, 2.86609400e-02f,
  3.17922115e-01f, -4.68794815e-02f, 3.00233811e-01f, 3.99864838e-02f, 6.12194128e-02f, 1.73961759e-01f, 1.28020972e-01f, 4.95097153e-02f, 1.73909813e-01f, -9.95331109e-02f,
  2.96433549e-02f, 1.32308781e-01f, -1.34937009e-02f, 6.87515289e-02f, 9.36815888e-02f, -5.42494617e-02f, 5.65736033e-02f, 1.22442499e-01f, -1.04972839e-01f, -5.61165847e-02f,
  -1.70698017e-02f, -1.02883346e-01f, 9.84738991e-02f, -9.78232697e-02f, 4.15802039e-02f, 6.28571957e-02f, -1.41925719e-02f, 1.70866717e-02f, 7.25582838e-02f, 3.23556624e-02f,
  5.91553934e-02f, 1.17901094e-01f, 1.94451138e-02f, 9.12395865e-02f, 1.54771522e-01f, 5.73468581e-02f, 2.01225094e-02f, 3.34515199e-02f, 6.98152706e-02f, 2.71981321e-02f,
  4.90339510e-02f, 3.45002078e-02f, -3.13457358e-03f, -6.64924383e-02f, 1.03786513e-02f, 3.38162407e-02f, 1.42885530e-02f, -1.63102765e-02f, 3.13770995e-02f, -1.24934828e-02f,
  -8.21086764e-02f, 2.16298494e-02f, 1.69580318e-02f, 2.93542799e-02f, -5.07183373e-02f, 1.76518913e-02f, 6.52390271e-02f, -1.21412834e-03f, -2.79789772e-02f, 3.60316299e-02f,
  2.32385453e-02f, 6.26176745e-02f, -3.35987844e-02f, 3.90351415e-02f, -4.84327553e-03f, 1.08919004e-02f, 9.78054944e-03f, -1.95173249e-02f, 1.87746771e-02f, -4.06267121e-02f,
  4.27256897e-02f, -2.61305906e-02f, -2.62511824e-03f, 1.39194028e-02f, -2.07581390e-02f, -2.46975552e-02f, -2.02278811e-02f, 2.17648316e-02f, -4.13286127e-02f, -1.11032957e-02f,
  4.73528430e-02f, 1.29270395e-02f, -8.89159590e-02f, -9.75262560e-03f, -3.53940297e-04f, -3.18136960e-02f, -3.38162333e-02f, -8.48782137e-02f, -2.09400114e-02f, -1.48659619e-02f,
  -1.06596225e-03f, 1.16941720e-01f, -2.49402616e-02f, 1.08576077e-03f, 2.33712960e-02f, -1.38530498e-02f, 4.15393122e-04f, -3.44977044e-02f, 5.54944575e-02f, 3.44407521e-02f,
  -9.29813017e-04f, -3.64594683e-02f, 3.56950890e-03f, -1.60893127e-02f, -6.02317862e-02f, -2.67363805e-02f, -2.99096387e-03f, 5.50914835e-03f, 5.72665557e-02f, 1.16352616e-02f,
  6.08398616e-02f, 3.98892723e-02f, -4.92659174e-02f, -7.23228976e-02f, 3.28098759e-02f, 2.42195278e-02f, 5.19048721e-02f, -3.00839776e-03f, -6.70004264e-02f, 3.89851071e-02f,
  -3.43769073e-01f, 2.11466178e-01f, -2.75935959e-02f, 2.51260847e-01f, 4.19303589e-02f, -1.65824704e-02f, -8.79235789e-02f, 1.62160009e-01f, 9.43825096e-02f, 1.49016172e-01f,
  1.38047040e-02f, -1.10802501e-02f, -1.22967139e-01f, 1.92921698e-01f, -3.28605235e-01f, -1.37298942e-01f, 5.81304990e-02f, 8.67775530e-02f, 2.78794263e-02f, 1.17009252e-01f,
  -7.69755542e-02f, 5.93114756e-02f, -6.19975328e-02f, 8.47695693e-02f, -7.64196273e-03f, 5.96275330e-02f, -6.70593381e-02f, 2.12252326e-02f, 9.36096609e-02f, 6.49071187e-02f,
  -1.51545018e-01f, 4.15117256e-02f, -3.67864557e-02f, -5.09161316e-02f, 2.58795563e-02f, 6.54175645e-03f, 1.86758135e-02f, -1.01423271e-01f, 6.55393675e-03f, 1.11475540e-02f,
  1.31754661e-02f, 6.21291287e-02f, -5.38332202e-02f, 1.83196459e-03f, 6.72667697e-02f, 4.45353761e-02f, 1.90444291e-02f, 6.97480217e-02f, 1.07789248e-01f, -9.30614322e-02f,
  1.97302941e-02f, 6.92218468e-02f, 2.57054698e-02f, -3.00437008e-04f, -3.74448672e-02f, 4.86311577e-02f, 5.35083562e-02f, 1.95419695e-02f, 1.50622493e-02f, 5.79409115e-02f,
  -3.01759541e-02f, -6.99232891e-02f, -3.23024802e-02f, 4.71778326e-02f, 3.53838392e-02f, 6.14495911e-02f, -1.12426106e-03f, -4.11985368e-02f, -2.76660867e-04f, 2.92575732e-02f,
  1.95032789e-03f, 1.78870428e-02f, 2.85134260e-02f, 3.80761251e-02f, 2.58505996e-02f, 9.81062949e-02f, 1.18800101e-03f, -2.30668001e-02f, -3.28432620e-02f, -3.51249054e-02f,
  -2.79387105e-02f, -2.29190383e-03f, 3.96775417e-02f, -7.11476356e-02f, 2.93468721e-02f, -7.20125958e-02f, -7.87867978e-02f, 6.66201264e-02f, -2.20617633e-02f, -7.59147406e-02f,
  8.06486160e-02f, 1.15050934e-01f, 1.07965946e-01f, 2.17460208e-02f, 1.56492535e-02f, -4.18344177e-02f, -7.71533772e-02f, 2.48218304e-03f, -1.17704058e-02f, -4.99754250e-02f,
  9.36772581e-03f, 7.49813719e-03f, 5.57615701e-03f, -2.89079994e-02f, -6.00257982e-03f, -2.23276368e-03f, -3.23068574e-02f, -2.54352335e-02f, -4.96535562e-03f, 9.05110613e-02f,
  8.39800835e-02f, -1.10021643e-01f, -2.29691435e-02f, 6.95729852e-02f, -1.39674153e-02f, 2.29110271e-02f, -3.20682898e-02f, 5.52098872e-03f, 4.08269092e-03f, -9.13838565e-04f,
  6.15123566e-03f, -4.97328117e-02f, -7.73777589e-02f, -1.81790311e-02f, 9.40179080e-02f, 1.67287767e-01f, 6.05036542e-02f, -3.05273402e-02f, 7.10030599e-03f, 9.93485823e-02f,
  5.20640193e-03f, -1.69625565e-01f, -5.79127222e-02f, 7.86569491e-02f, -1.33297637e-01f, -7.93363675e-02f, 2.48293933e-02f, 1.04502691e-02f, -5.85913025e-02f, -2.09481139e-02f,
  -1.67450104e-02f, 1.48444369e-01f, -1.79706234e-02f, 5.42210881e-03f, 2.80572213e-02f, -6.49159998e-02f, 1.92566484e-03f, -5.97253069e-02f, 8.29219818e-02f, -8.47434774e-02f,
  -4.47290242e-02f, -1.41163366e-02f, -4.89127450e-02f, -3.71714239e-04f, 7.33212903e-02f, 3.92877460e-02f, -1.38059082e-02f, -6.22721426e-02f, 1.98885389e-02f, 2.46617128e-03f,
  4.38986719e-02f, -3.50764580e-02f, 6.02008477e-02f, -1.11639835e-02f, -3.58051471e-02f, -9.35402811e-02f, -1.13711432e-02f, -7.37250000e-02f, 5.67696206e-02f, 5.50720915e-02f,
  -8.36601928e-02f, 2.84531079e-02f, 1.59259345e-02f, -4.24091406e-02f, -7.69388676e-02f, -4.32242313e-03f, 3.72959003e-02f, -7.63372630e-02f, -3.67341042e-02f, 3.96285951e-02f,
  4.54219580e-02f, 6.97527975e-02f, 1.72614362e-02f, -2.29706541e-02f, -5.21646254e-02f, -8.45815241e-03f, -2.46746745e-02f, 4.63182926e-02f, -2.43130755e-02f, 1.56296082e-02f,
  9.40054208e-02f, -1.81365144e-02f, 8.11630934e-02f, 8.65725577e-02f, 3.87766119e-03f, -4.86580729e-02f, 1.14689395e-02f, -1.33192511e-02f, 6.09112345e-02f, 5.92383295e-02f,
  4.24957052e-02f, 1.56122744e-02f, -5.72204776e-02f, 3.42053548e-02f, -9.92700607e-02f, -2.56218594e-02f, -3.64324525e-02f, -6.26528449e-03f, 4.90252255e-03f, 8.84732157e-02f,
  7.14733545e-03f, -9.48215742e-03f, 2.36264262e-02f, -4.41706851e-02f, -1.37040494e-02f, 3.59638408e-03f, 1.20140438e-03f, 2.76812408e-02f, -1.04373321e-01f, 3.79043333e-02f,
  8.31692070e-02f, 1.00791007e-01f, -6.54331073e-02f, -3.93856093e-02f, 5.90256080e-02f, 5.38662151e-02f, 3.95914987e-02f, 7.24570826e-03f, 2.30019186e-02f, 2.64021549e-02f,
  7.59607404e-02f, 1.88321713e-02f, -9.38360542e-02f, -1.95173770e-02f, 2.00706050e-02f, -1.94428291e-03f, -4.32442576e-02f, 9.52691771e-03f, 8.99094716e-03f, 1.28830746e-02f,
  -1.23390272e-01f, -1.20844297e-01f, -2.17770413e-01f, -9.29630548e-02f, 3.94697599e-02f, -1.94807798e-02f, -4.15910631e-02f, -7.55938469e-03f, -1.91126570e-01f, 5.90160936e-02f,
  -6.69178441e-02f, -1.72930866e-01f, -9.98114944e-02f, 6.59199618e-03f, -1.35887265e-01f, -1.49373636e-01f, -4.91835438e-02f, -8.75903443e-02f, -8.78266767e-02f, 8.19088295e-02f,
  7.24294484e-02f, 1.40288383e-01f, -3.57350823e-03f, 2.54790753e-01f, 7.36953542e-02f, -1.46931214e-02f, 1.88129991e-01f, 9.31986645e-02f, 8.62194076e-02f, 5.11494763e-02f,
  -1.14449048e-02f, -8.08537900e-02f, -2.43234355e-02f, 3.34506878e-03f, 3.45327370e-02f, 9.59821567e-02f, 3.01753208e-02f, -1.69195626e-02f, -9.49684158e-02f, 1.95626970e-02f,
  6.74069487e-03f, -3.92749161e-02f, 2.78330408e-02f, 6.88456297e-02f, 7.21844360e-02f, -3.77323031e-02f, -5.85371517e-02f, -2.95526516e-02f, -5.85249551e-02f, -1.02804333e-01f,
  -3.64669897e-02f, 3.28039899e-02f, 7.01703206e-02f, -7.48032928e-02f, -1.86075103e-02f, -4.88368347e-02f, 2.83539817e-02f, -4.61724848e-02f, -1.56710111e-02f, -6.95958138e-02f,
  -1.78195126e-02f, -2.53412053e-02f, 3.73645872e-02f, 1.28514236e-02f, -6.27100244e-02f, 2.73445696e-02f, -1.33727891e-02f, -3.21986750e-02f, -5.58050396e-03f, -5.22751063e-02f,
  -4.47681770e-02f, 3.96275427e-03f, -1.45995226e-02f, -2.86827199e-02f, -1.27850063e-02f, -8.81655980e-03f, 2.58511514e-03f, 3.31967659e-02f, -4.91587967e-02f, -3.27902175e-02f,
  4.30004559e-02f, -5.73183922e-03f, 3.15480307e-02f, 8.44421685e-02f, 2.56894119e-02f, -2.84044836e-02f, 5.31359166e-02f, -2.19466239e-02f, 3.87704782e-02f, 2.09416656e-04f,
  -2.89879516e-02f, 4.57705855e-02f, 9.19390749e-03f, -6.02600984e-02f, -7.40731135e-02f, 2.08476204e-02f, -7.83091784e-02f, -4.44796029e-03f, 2.47576907e-02f, -3.32660303e-02f,
  2.94579547e-02f, 3.84377576e-02f, 1.13639273e-01f, 2.16709916e-02f, -3.76044884e-02f, 1.01485224e-02f, 2.29804870e-02f, -5.36313951e-02f, 5.60906418e-02f, -1.15777226e-02f,
  -3.69376764e-02f, 5.10876067e-03f, -4.80253249e-02f, 2.21210234e-02f, 2.47361157e-02f, 4.59979028e-02f, 3.12885875e-03f, -6.93687471e-03f, 2.73449533e-02f, 1.38523383e-02f,
  2.04810157e-01f, -6.34418949e-02f, 5.40657081e-02f, -1.01260878e-01f, 7.01149739e-03f, 5.45719303e-02f, 7.60043645e-03f, -3.91234048e-02f, 8.32568854e-02f, 1.91743914e-02f,
  -9.44522768e-02f, 6.90634698e-02f, -1.07263187e-02f, -1.54186979e-01f, -1.42024577e-01f, -2.32469290e-02f, -1.27842054e-01f, -1.15359440e-01f, 3.71496901e-02f, -6.08896650e-02f,
  -3.65366936e-02f, -2.47247368e-01f, -6.75546750e-02f, -8.43639821e-02f, 5.29779643e-02f, -3.12185045e-02f, -6.76036552e-02f, 7.52831474e-02f, -1.99866533e-01f, 1.58439539e-02f,
  1.84735004e-02f, 8.91681835e-02f, 3.66656035e-02f, 4.76102270e-02f, -1.98372696e-02f, 4.65035290e-02f, 1.07159525e-01f, -2.63505615e-02f, -1.68375839e-02f, 5.21189012e-02f,
  6.15053363e-02f, -8.35642964e-02f, 1.62838679e-02f, -5.58746755e-02f, -2.01666169e-02f, 8.82321969e-02f, 3.52249518e-02f, 5.00269346e-02f, 1.90916099e-02f, 1.35555342e-02f,
  -6.94103539e-02f, 5.68070002e-02f, 1.44657549e-02f, -5.90682700e-02f, 4.84469673e-03f, -5.80377579e-02f, -5.21481633e-02f, 3.64768393e-02f, 2.32247133e-02f, -7.18818009e-02f,
  3.07279043e-02f, 3.45906354e-02f, -4.79713343e-02f, 2.47095134e-02f, 2.29830537e-02f, -4.07648124e-02f, -1.55619821e-02f, 1.79484002e-02f, -7.97148515e-03f, -4.89171036e-03f,
  1.50192175e-02f, 3.24321389e-02f, 3.73691469e-02f, -6.52766824e-02f, 1.94034446e-02f, 5.79046234e-02f, 1.47833293e-02f, -3.31240967e-02f, 3.68075930e-02f, -1.33190546e-02f,
  9.25127119e-02f, -2.29053069e-02f, -1.67054478e-02f, 5.02826758e-02f, -1.85238048e-02f, -5.78501485e-02f, 3.43959257e-02f, 1.31935533e-02f, 5.24132997e-02f, 4.55117486e-02f,
  -9.64832380e-02f, -1.30863234e-01f, 5.27952500e-02f, -1.67762972e-02f, -3.52506228e-02f, -5.85611314e-02f, 8.80088806e-02f, -6.33748472e-02f, -3.82373966e-02f, 1.28223747e-02f,
  2.48626620e-02f, 5.67019507e-02f, -1.49624292e-02f, -5.48051717e-03f, 7.95191433e-03f, -1.68108847e-02f, -2.17117239e-02f, -5.70257157e-02f, 3.15623656e-02f, 3.88060547e-02f,
  -1.96117572e-02f, -4.83495891e-02f, -8.91514402e-03f, -5.43616451e-02f, -2.65132897e-02f, 3.11999489e-02f, -2.74597611e-02f, -2.62391400e-02f, -8.22000671e-03f, -1.26906689e-02f,
  -1.46394596e-01f, 1.43644884e-01f, 1.68740049e-01f, 1.92876503e-01f, -9.46522430e-02f, 3.11299592e-01f, 4.25411850e-01f, 2.79056728e-02f, -8.92262906e-03f, 2.41284892e-01f,
  1.13566235e-01f, -1.07851408e-01f, 2.75874138e-02f, 2.64893025e-01f, -8.02102219e-03f, 4.75342609e-02f, 2.60186642e-01f, 5.87668605e-02f, -4.46201302e-02f, 5.76625615e-02f,
  -3.79699506e-02f, 1.28580943e-01f, 4.14143316e-02f, -1.07459150e-01f, 3.81532498e-02f, -1.57469604e-02f, 9.08247847e-03f, -5.80626652e-02f, 1.64447039e-01f, 6.72149882e-02f,
  6.93120137e-02f, -6.41648322e-02f, -1.14810310e-01f, -4.27588224e-02f, 3.47588677e-03f, 6.06719963e-02f, 5.05386256e-02f, -4.83600572e-02f, -6.62861690e-02f, 4.78986800e-02f,
  2.55356450e-02f, -4.62888591e-02f, 3.15958969e-02f, -8.35299194e-02f, -1.85386427e-02f, -5.66471145e-02f, -1.85346752e-02f, 2.34250147e-02f, -2.19030678e-02f, 1.91425662e-02f,
  -2.28625815e-02f, -8.56855139e-03f, 5.48646823e-02f, 3.20290290e-02f, 1.59321446e-02f, 2.85713486e-02f, 1.51546171e-03f, -9.83127207e-03f, 4.74509671e-02f, 2.50114352e-02f,
  1.11285793e-02f, 2.29180176e-02f, 9.14931484e-03f, 4.51125298e-03f, 3.09571307e-02f, -5.18382303e-02f, 6.26582652e-02f, -1.13307633e-01f, 5.00834249e-02f, -5.43100312e-02f,
  4.59701894e-03f, 2.06134864e-03f, -3.05615291e-02f, 6.90855533e-02f, 3.66725437e-02f, 5.23160696e-02f, -3.35848480e-02f, -9.08196889e-05f, 1.50728179e-02f, -7.46728759e-03f,
  2.79161781e-02f, -3.10880207e-02f, 1.36397341e-02f, 7.40604252e-02f, -1.70139465e-02f, -3.22017469e-04f, -1.12353894e-03f, -2.42751203e-02f, 6.08004294e-02f, 3.41148339e-02f,
  1.67065650e-01f, 1.45669639e-01f, -3.59071721e-03f, 3.88702215e-03f, -3.77786420e-02f, -5.75966798e-02f, -4.45302762e-03f, 1.97715499e-02f, 1.48886979e-01f, -2.82704644e-02f,
  1.07234947e-01f, -3.00258845e-02f, 2.82646390e-03f, 4.46851887e-02f, 5.04107252e-02f, 5.99872060e-02f, 4.58674468e-02f, 4.13524080e-03f, 5.91999441e-02f, 2.97796223e-02f,
  -9.94808879e-03f, -3.60874981e-02f, -6.50317073e-02f, 1.84892043e-02f, -6.24983013e-03f, 7.50506520e-02f, -2.29050871e-02f, -2.83071138e-02f, -4.62781340e-02f, 1.04845874e-02f,
  -1.07599035e-01f, 1.02953918e-01f, 1.47915289e-01f, -4.16172668e-02f, 9.32012051e-02f, -3.80721658e-01f, -3.67588639e-01f, 1.12072043e-01f, -6.72419220e-02f, -1.20265223e-01f,
  -1.36193201e-01f, 8.20318237e-02f, -3.91428769e-02f, -2.08430484e-01f, -1.96899712e-01f, -1.39003009e-01f, -2.93580949e-01f, -9.60969478e-02f, 8.02630931e-02f, 6.08884469e-02f,
  -3.41784060e-02f, -2.26091936e-01f, -2.35189777e-02f, -8.29241518e-03f, -3.77166606e-02f, 1.05946451e-01f, 1.64799467e-02f, 7.86244869e-02f, 5.72670288e-02f, -2.84132492e-02f,
  -8.44203904e-02f, 1.03109188e-01f, 3.88607234e-02f, 3.98538355e-03f, -6.74462467e-02f, -1.88437216e-02f, -2.28807256e-02f, 3.12688202e-02f, 1.36998976e-02f, -7.97630101e-03f,
  8.69981274e-02f, 9.03851353e-03f, -7.75301317e-03f, 9.03908350e-03f, -3.89899760e-02f, 3.53939161e-02f, 6.58751726e-02f, 2.79819015e-02f, 4.19584885e-02f, 3.88899930e-02f,
  -1.90834329e-02f, -1.60424504e-02f, 4.91199642e-02f, 1.00704962e-02f, 2.85710692e-02f, 1.46702090e-02f, -3.62351052e-02f, -4.28970112e-03f, 2.56467238e-02f, 2.91678384e-02f,
  -1.72471199e-02f, 5.84034286e-02f, -5.35625219e-03f, 5.92179522e-02f, -5.64049482e-02f, 4.43130359e-02f, -1.42303482e-02f, -6.18424499e-03f, 7.07105845e-02f, -3.69675010e-02f,
  -3.28726806e-02f, 1.25954105e-02f, 1.74107905e-02f, 3.22084874e-02f, -1.99896265e-02f, 6.10367991e-02f, -3.72004248e-02f, 6.55454323e-02f, -1.99485682e-02f, -2.49409266e-02f,
  7.39064813e-02f, 6.52607856e-03f, -1.67787317e-02f, -6.14780597e-02f, -1.40592945e-03f, 1.85807515e-02f, -9.49053466e-03f, -3.29176709e-03f, 7.54784271e-02f, -4.06549349e-02f,
  -7.75814652e-02f, 7.35224485e-02f, 1.31866215e-02f, -4.40389290e-02f, 4.26266752e-02f, -5.13182469e-02f, 8.85755196e-03f, 2.83479244e-02f, 3.30743752e-02f, 6.02634735e-02f,
  -2.60331598e-03f, -4.57846820e-02f, -6.15659449e-03f, -2.78977882e-02f, 9.94234979e-02f, -9.36013926e-03f, -2.26268638e-03f, 1.07180318e-02f, -1.30727002e-02f, 5.84524237e-02f,
  4.95147556e-02f, 8.94104131e-03f, -7.23364651e-02f, -7.03564286e-02f, -2.14098785e-02f, -5.13628609e-02f, 1.97259663e-03f, -6.50124550e-02f, -2.97283176e-02f, -2.60392912e-02f,
  -1.09796703e-01f, 1.03399031e-01f, 1.33357242e-01f, 6.89300150e-02f, -2.32149959e-01f, -9.95381176e-02f, 4.14734446e-02f, -6.89230114e-02f, 6.91442341e-02f, -4.13614064e-02f,
  5.26289754e-02f, 7.97843188e-02f, 1.33024737e-01f, 1.48144364e-01f, 1.58119217e-01f, 1.45784557e-01f, 2.77769174e-02f, -1.07130311e-01f, -8.26847926e-03f, 3.98345813e-02f,
  8.17396771e-03f, -2.79477183e-02f, 2.11915910e-01f, 5.88691160e-02f, -4.30199876e-02f, 2.85619758e-02f, 3.96969020e-02f, 6.98975613e-03f, 8.85073096e-03f, -4.34502214e-02f,
  5.05744182e-02f, 1.05389901e-01f, -2.88932230e-02f, -4.32351716e-02f, 4.67954166e-02f, -2.06401516e-02f, 2.64674611e-02f, 2.54578609e-02f, -2.40403526e-02f, -1.44083947e-02f,
  5.92930838e-02f, 5.81476316e-02f, 2.68116854e-02f, 8.28967541e-02f, 2.78839711e-02f, -3.52419913e-03f, 4.71623503e-02f, 1.62976794e-02f, 3.87545750e-02f, 2.90694255e-02f,
  -3.21139097e-02f, 1.84516683e-02f, 8.17322433e-02f, 4.49686684e-02f, -3.43382396e-02f, 6.12039156e-02f, 3.63153964e-02f, -2.93764453e-02f, -6.19763276e-03f, -5.23512699e-02f,
  -9.84334294e-03f, -3.46506052e-02f, 3.34530547e-02f, 1.84586346e-02f, -6.08134568e-02f, -2.42827013e-02f, -4.19771336e-02f, 6.66510388e-02f, -4.92293984e-02f, 6.94547296e-02f,
  -1.07477620e-01f, 1.75460596e-02f, -3.65836434e-02f, 7.25603849e-03f, 7.15927929e-02f, -7.14855827e-03f, -6.10585101e-02f, -1.35135911e-02f, -5.49510261e-03f, -9.12059098e-03f,
  3.13207507e-02f, -4.31726314e-02f, -2.26026634e-03f, -7.31450394e-02f, -3.88150550e-02f, -1.73295327e-02f, -3.47258411e-02f, 3.93786021e-02f, 1.01487115e-02f, -4.54618819e-02f,
  4.66244109e-02f, 1.31209701e-01f, 2.15033535e-03f, -1.17326435e-02f, -3.52870338e-02f, -4.22454625e-02f, 6.84214756e-02f, 1.91807169e-02f, 9.72461700e-02f, 5.29334173e-02f,
  -6.57499656e-02f, -1.65664237e-02f, 4.06311126e-03f, -2.56110933e-02f, -6.41440880e-03f, 3.51017043e-02f, 5.98656051e-02f, 6.73629437e-03f, -1.70619246e-02f, -6.77010193e-02f,
  8.33794624e-02f, 3.86503786e-02f, 1.80783644e-02f, 6.41752640e-03f, -1.44293427e-03f, -7.49838585e-03f, 2.69068088e-02f, -3.63082886e-02f, 4.45117690e-02f, 7.72366822e-02f,
  -3.50358814e-01f, -1.02250524e-01f, -3.63494232e-02f, -1.19292438e-01f, -6.19619526e-02f, -1.04023159e-01f, -1.92576572e-02f, -1.46271497e-01f, -9.64202210e-02f, -4.92537348e-03f,
  -2.50473078e-02f, 3.57495714e-03f, 2.05347613e-01f, -2.48503708e-03f, -1.10015750e-01f, 1.78166792e-01f, -1.51653498e-01f, -3.48804402e-03f, -7.90929496e-02f, -1.47954032e-01f,
  -1.07750826e-01f, -6.24838881e-02f, 1.28228664e-01f, 3.67872976e-02f, -3.87862474e-02f, -1.00726880e-01f, 1.78878438e-02f, 1.51200280e-01f, 1.80315319e-02f, 4.78312038e-02f,
  -1.64556801e-02f, 1.36000976e-01f, -2.38197669e-02f, 8.08444172e-02f, -7.48715699e-02f, -3.62602137e-02f, 7.52022192e-02f, -1.03031667e-02f, 1.02141779e-03f, -2.19533239e-02f,
  2.03874018e-02f, 4.20140363e-02f, -9.47023034e-02f, 1.65276472e-02f, -2.89998073e-02f, 5.98662570e-02f, 4.78796987e-03f, 2.46160813e-02f, 8.53776485e-02f, 4.14295904e-02f,
  -3.98333669e-02f, -2.47571468e-02f, -3.07502653e-02f, -2.68226024e-02f, 4.97571677e-02f, -1.18166972e-02f, -4.73024622e-02f, -6.11032173e-03f, -1.00098126e-01f, -6.79503307e-02f,
  -3.32641862e-02f, 3.98543440e-02f, 8.51849541e-02f, -8.47662315e-02f, 1.84399299e-02f, -6.80004358e-02f, 4.78063859e-02f, -1.37048895e-02f, -1.05416588e-02f, -6.52149320e-03f,
  -2.12830747e-03f, -2.21017748e-02f, -6.64684847e-02f, 9.90396366e-03f, -9.39064026e-02f, -5.53850606e-02f, 6.86391741e-02f, -9.08410996e-02f, 5.11948019e-03f, 1.48226751e-03f,
  -2.04702541e-02f, -8.45664144e-02f, -4.56523709e-02f, 2.95228101e-02f, 3.49604711e-02f, -1.05655938e-02f, -3.62350903e-02f, 5.82662113e-02f, -8.35353136e-03f, -1.41988574e-02f,
  -4.26309742e-02f, -1.21797711e-01f, 1.40527477e-02f, -6.89008534e-02f, 2.77309567e-02f, -6.75791816e-04f, -8.14730972e-02f, -4.81459945e-02f, 8.70560668e-03f, -3.42134759e-02f,
  -4.64693196e-02f, 7.32641481e-03f, -6.32922649e-02f, 3.50991078e-02f, -4.63552251e-02f, -8.18290636e-02f, -4.03268598e-02f, -4.65281270e-02f, 2.13570017e-02f, 6.66147023e-02f,
  1.65119506e-02f, 1.73639860e-02f, -1.89463068e-02f, -1.33369435e-02f, -6.14735670e-02f, 1.41738504e-02f, -8.49867389e-02f, -9.34908818e-03f, -7.73847802e-03f, 5.56939021e-02f,
  1.32929623e-01f, -2.53179431e-01f, 2.39607561e-02f, 4.99600098e-02f, 2.60300338e-01f, 2.64409017e-02f, 2.13258155e-02f, 5.23528382e-02f, 4.14537787e-02f, -1.94824904e-01f,
  -9.28573497e-03f, -1.43695474e-01f, -9.55530256e-02f, -3.85467112e-02f, 6.92816004e-02f, -1.01899445e-01f, 7.01980025e-04f, -6.16188459e-02f, 1.96933635e-02f, -2.65426002e-02f,
  1.72970202e-02f, 5.58822192e-02f, -2.81396322e-03f, -5.53463772e-02f, -2.37068068e-02f, 8.27045664e-02f, -5.11098951e-02f, 1.88341346e-02f, -2.12669224e-02f, 7.28766620e-02f,
  -4.62510437e-02f, -4.40142080e-02f, -2.38084663e-02f, -5.50574698e-02f, -3.51255424e-02f, -1.20454011e-02f, 4.84844558e-02f, -1.76812131e-02f, -7.30544468e-03f, -5.53169698e-02f,
  -6.18870705e-02f, 3.32079679e-02f, 2.03148667e-02f, 4.90037212e-03f, 8.54599103e-02f, 8.09652358e-02f, 2.21800189e-02f, -2.59868465e-02f, -3.78009025e-03f, -3.12978774e-02f,
  1.37136411e-03f, 4.18229550e-02f, 1.92699749e-02f, 2.87072820e-04f, -3.84148806e-02f, -6.92982972e-02f, -4.11872454e-02f, 8.84702057e-02f, 1.67056769e-02f, -5.02780043e-02f,
  -9.26321745e-02f, 6.31106943e-02f, 7.01328367e-02f, 5.23146205e-02f, 4.78105769e-02f, 6.17476217e-02f, -3.20746601e-02f, -8.17010105e-02f, 6.78998083e-02f, -6.81236982e-02f,
  -1.69969182e-02f, 7.55711040e-03f, 3.22289132e-02f, -1.39354607e-02f, -3.14297229e-02f, -4.09593396e-02f, 1.64988749e-02f, 6.44348562e-02f, -2.13258341e-03f, -2.17610318e-02f,
  -7.39976540e-02f, -3.40140536e-02f, 3.82378809e-02f, -1.37668140e-02f, -7.39269033e-02f, 8.92147943e-02f, -8.65762010e-02f, 5.32332398e-02f, -4.52965163e-02f, -7.78951421e-02f,
  2.00985391e-02f, -3.50400507e-02f, -7.75205716e-02f, -3.50203589e-02f, 6.89538941e-03f, -1.47704571e-01f, -1.86459199e-02f, 3.69151384e-02f, 6.09699413e-02f, 1.20744882e-02f,
  -4.16057557e-02f, 4.81448881e-02f, -1.03121012e-01f, 2.07599223e-04f, -8.42874199e-02f, 7.03835040e-02f, -5.31037599e-02f, -3.54104377e-02f, -4.45838608e-02f, -7.95796514e-02f,
  -4.49613482e-02f, -7.58624524e-02f, -5.74202538e-02f, 4.70624864e-02f, 2.79128421e-02f, 5.64322174e-02f, -5.17873615e-02f, 2.38152687e-02f, -4.93563823e-02f, -8.30542296e-02f,
  1.11604691e-01f, 4.73751966e-03f, 2.03264013e-01f, -1.20264754e-01f, -5.72716743e-02f, 4.14073654e-02f, 1.24263294e-01f, -6.81021344e-03f, 1.30707517e-01f, -6.85657039e-02f,
  -8.52642134e-02f, 1.57584965e-01f, 4.00866270e-02f, -1.92915678e-01f, -8.59222710e-02f, 3.16654844e-03f, -1.89176261e-01f, 4.11771052e-02f, 1.25099957e-01f, -4.88963202e-02f,
  2.55133044e-02f, -1.95019290e-01f, 7.33438954e-02f, -6.18973486e-02f, -1.46455066e-02f, 1.18082128e-01f, -1.89513162e-01f, 1.20756902e-01f, 4.05486040e-02f, -3.59103307e-02f,
  8.91070068e-02f, 1.52083784e-01f, 3.91240232e-02f, 2.68404912e-02f, 3.00318897e-02f, 2.70173722e-03f, 5.50607266e-03f, 4.12520431e-02f, -2.97848824e-02f, 7.32736439e-02f,
  1.10998563e-01f, -1.17598763e-02f, 2.02754550e-02f, 4.68505025e-02f, 2.49003079e-02f, -8.86575356e-02f, 7.00559691e-02f, 3.85428667e-02f, 4.00473811e-02f, -3.21652070e-02f,
  9.45323333e-02f, -4.66426983e-02f, -7.50751346e-02f, -5.20113185e-02f, -4.60734479e-02f, -3.69518884e-02f, 2.64979787e-02f, 8.04707408e-02f, 3.39473784e-02f, -4.95106308e-03f,
  -3.00349984e-02f, -2.00028624e-03f, -3.99625977e-04f, 4.08795197e-03f, 5.45219146e-02f, -2.38291570e-03f, -4.53059226e-02f, -8.53566825e-02f, 4.78911921e-02f, -4.53926697e-02f,
  4.55881888e-03f, -1.26514202e-02f, 2.29599439e-02f, -2.41596457e-02f, 7.90911634e-03f, -8.71183276e-02f, 4.16988693e-02f, -1.66605450e-02f, -3.99118550e-02f, 3.56571004e-02f,
  2.44066166e-03f, -9.36880149e-03f, 4.17956449e-02f, 4.32509743e-03f, 1.84884144e-03f, -1.33823417e-02f, -4.52482477e-02f, 4.96022701e-02f, -9.69712716e-03f, -4.14005704e-02f,
  -1.38061628e-01f, -1.16336919e-01f, 5.43355234e-02f, -2.11101603e-02f, -1.00079114e-02f, 2.06529777e-02f, -9.84418392e-02f, 1.98281817e-02f, 9.18739010e-03f, -8.06568377e-03f,
  -9.75491107e-02f, -1.00721538e-01f, -1.94535800e-03f, -7.47409388e-02f, -6.69283569e-02f, -1.34251202e-02f, 2.14381404e-02f, 5.04696593e-02f, -7.89714083e-02f, 9.53182019e-03f,
  5.85049875e-02f, -1.26729312e-03f, -5.62078878e-03f, 1.52835166e-02f, -4.87656891e-02f, 7.30519891e-02f, -7.19095543e-02f, -5.17629534e-02f, 3.79195251e-02f, 2.68183704e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -9.93933454e-02f, 6.94948956e-02f, 4.83869836e-02f, 2.88644638e-02f, -9.47101191e-02f, -2.25932747e-02f, -7.18272105e-02f, -1.06491849e-01f, -3.81009951e-02f, 9.10682231e-02f,
  3.92447002e-02f, 4.22688499e-02f, 6.94433972e-02f, -7.06518367e-02f, 3.15756202e-02f, 4.48856130e-02f, 1.91928409e-02f, -3.11708753e-03f, -9.65871289e-02f, -5.97445033e-02f,
  -8.90801847e-02f, -8.71035382e-02f, 2.83780042e-02f, -1.13579415e-01f, -2.82825064e-02f, -5.85251004e-02f, 8.42470617e-04f, -9.31628421e-02f, -8.85192528e-02f, 4.71446030e-02f,
  -9.02782902e-02f, 8.70757625e-02f, -2.59173978e-02f, 1.24857984e-02f, -1.98187213e-02f, 1.01638407e-01f, -1.54823372e-02f, -6.46168590e-02f, -4.97521013e-02f, 6.38277009e-02f,
  -8.31709132e-02f, -2.76110191e-02f, -5.77443242e-02f, -1.02524762e-03f, -6.20354414e-02f, 1.24682486e-02f, -4.23793262e-03f, -1.10433223e-02f, -5.51181547e-02f, -1.06465138e-01f,
  -4.90171611e-02f, 8.24858174e-02f, 8.29360634e-02f, -3.16220312e-03f, -1.41952969e-02f, 6.66443780e-02f, 2.83299573e-02f, -3.37594654e-03f, 6.37918338e-02f, 3.39821652e-02f,
  -2.27879435e-02f, -7.08319619e-02f, -3.12817059e-02f, -1.00097647e-02f, -2.38224044e-02f, 3.26388143e-02f, -1.56558212e-02f, -6.29579127e-02f, -3.40234861e-02f, -5.25366403e-02f,
  9.14438143e-02f, 6.96537122e-02f, -1.41496370e-02f, 7.69357160e-02f, 3.04807927e-02f, 6.19670749e-02f, -4.70175333e-02f, -2.44604349e-02f, 4.83176112e-03f, -2.95974705e-02f,
  -5.65833785e-02f, 5.61751127e-02f, 4.17399332e-02f, 3.33221001e-03f, -6.99158534e-02f, 6.25964180e-02f, 8.08031857e-02f, 8.47328901e-02f, -2.09151749e-02f, -8.42265785e-02f,
  3.86664495e-02f, 2.95078419e-02f, -5.89729697e-02f, -4.70208935e-02f, 8.16805735e-02f, -2.63119256e-03f, -2.36466397e-02f, 1.06694931e-02f, -1.40396394e-02f, -1.97506193e-02f,
  -2.58458741e-02f, 7.11029992e-02f, -7.69191384e-02f, -1.97008103e-02f, -2.32019294e-02f, 5.99151142e-02f, 1.74441915e-02f, -1.77414957e-02f, -4.33787666e-02f, -4.90641445e-02f,
  -9.65416208e-02f, -7.40442947e-02f, -1.61385182e-02f, -3.87861878e-02f, 4.90086451e-02f, -5.65589927e-02f, -2.25625411e-02f, -3.99801768e-02f, 8.46888274e-02f, 4.87497672e-02f,
  1.16826095e-01f, -4.25046720e-02f, 9.49313045e-02f, 1.00104354e-01f, 8.66899788e-02f, 8.18945765e-02f, 1.54222921e-01f, 1.01387367e-01f, -4.76498008e-02f, -1.45319596e-01f,
  4.07733433e-02f, -5.61216511e-02f, 1.22149877e-01f, -1.82627946e-01f, 4.04302776e-02f, -9.84820426e-02f, 3.82203306e-03f, -1.31387347e-02f, -6.01123553e-04f, 2.41748895e-02f,
  1.32699430e-01f, 9.84160677e-02f, 1.40592739e-01f, 2.77263857e-02f, 6.15744442e-02f, -2.85879262e-02f, -1.03174500e-01f, 5.83194269e-05f, -1.57789916e-01f, 5.09034377e-03f,
  -6.52091578e-02f, -9.41156968e-02f, 5.95405959e-02f, -5.84139675e-02f, -1.85042135e-02f, -2.86546405e-02f, 2.13894732e-02f, -1.67166570e-03f, 1.22451503e-02f, 2.61539612e-02f,
  -6.21091668e-03f, -3.44972834e-02f, -5.63963549e-03f, -3.07434276e-02f, 1.72020718e-02f, 4.60766330e-02f, 3.72195877e-02f, 4.04576175e-02f, -9.47471410e-02f, -2.70125009e-02f,
  9.08382982e-02f, -7.18458882e-03f, 5.38759260e-03f, -8.34028050e-02f, 6.21404592e-03f, -1.04003757e-01f, 3.91628360e-03f, 2.14356594e-02f, 5.48513159e-02f, -3.66928289e-03f,
  1.64688956e-02f, 9.76404995e-02f, -4.58238740e-03f, 4.51892912e-02f, 2.68632229e-02f, 1.48322945e-02f, 2.74177976e-02f, 3.56983319e-02f, 6.57485798e-02f, 6.68525090e-03f,
  6.76352233e-02f, 5.60428016e-02f, 1.16775237e-01f, 8.18072408e-02f, 8.11606180e-03f, 5.86353317e-02f, -7.71603212e-02f, -8.13528076e-02f, -6.15587682e-02f, -6.65388852e-02f,
  -6.95111528e-02f, -6.96638674e-02f, 4.01962698e-02f, -4.94027287e-02f, -4.92509827e-02f, 3.90013009e-02f, -9.06914771e-02f, -1.16861453e-02f, 4.89106402e-02f, 5.26334979e-02f,
  -1.25025958e-01f, -1.59593239e-01f, 6.93644732e-02f, 9.22160968e-02f, -1.00449167e-01f, -8.20416026e-03f, 2.97841579e-02f, -4.24707308e-02f, -9.16522890e-02f, 2.85137631e-02f,
  9.34511274e-02f, 2.31191777e-02f, 2.75080577e-02f, 1.16468882e-02f, 5.72623983e-02f, -5.27411103e-02f, -4.60817590e-02f, 3.27484943e-02f, -3.60816643e-02f, 1.10313110e-02f,
  2.92988475e-02f, 1.46455457e-02f, 3.44987251e-02f, -1.88428182e-02f, 3.63683179e-02f, 8.78343452e-03f, 4.77471482e-03f, -2.99358610e-02f, 1.74643751e-02f, 1.90124032e-03f,
  -1.38789192e-02f, 1.31516561e-01f, 1.15606740e-01f, 2.54894853e-01f, -1.24627843e-01f, -1.63844317e-01f, -2.94543784e-02f, 1.56678259e-02f, 5.74287213e-02f, -9.91420150e-02f,
  4.38164547e-02f, 1.66633531e-01f, 2.84679383e-02f, 1.11061409e-01f, 9.59621593e-02f, 1.54703986e-02f, 1.22841680e-02f, -1.44622680e-02f, 1.24414213e-01f, 1.64999172e-01f,
  4.58003916e-02f, -1.66728348e-02f, 1.59398228e-01f, -2.80681229e-03f, 5.61176017e-02f, 1.96189821e-01f, 1.40023679e-01f, -4.45770957e-02f, 1.41418189e-01f, -1.14965782e-01f,
  -1.06640443e-01f, 1.28701210e-01f, -4.24784832e-02f, 1.02520622e-02f, -6.27762899e-02f, -3.98819745e-02f, -6.82233125e-02f, -8.85544047e-02f, 4.48998902e-03f, 8.62107202e-02f,
  6.35580113e-03f, -3.12221907e-02f, 1.61058940e-02f, -4.51957807e-02f, 2.15976145e-02f, 6.54827133e-02f, 4.82075699e-02f, -6.58133253e-02f, 1.54943578e-02f, 8.68916512e-02f,
  8.79923776e-02f, -4.04257141e-02f, 5.28322384e-02f, -1.18942618e-01f, 3.04263495e-02f, -5.58659285e-02f, 2.33248640e-02f, 5.27753159e-02f, 2.58276183e-02f, 3.16202603e-02f,
  7.18693947e-03f, -5.43869250e-02f, -1.93279125e-02f, -1.73666775e-02f, 7.74147883e-02f, 2.74740905e-02f, 2.29227003e-02f, 5.49454428e-02f, 4.42631869e-03f, -5.84705658e-02f,
  -5.70462644e-02f, -6.57420382e-02f, 5.26077971e-02f, -7.31474534e-02f, -6.58731163e-02f, 2.68346211e-03f, -2.58148853e-02f, -1.40326824e-02f, 1.46648185e-02f, 3.22994553e-02f,
  -4.44905125e-02f, -4.15068753e-02f, 3.06958482e-02f, -2.66496500e-04f, -3.31153534e-02f, -4.41724609e-04f, -1.92421377e-02f, 6.41740113e-02f, -2.49986490e-03f, 2.67294887e-02f,
  -1.00414187e-01f, 5.77965416e-02f, 3.16757746e-02f, -5.44786826e-02f, 2.90188212e-02f, -3.66239361e-02f, 1.36488443e-02f, -7.02499896e-02f, 1.09340839e-01f, 2.94148345e-02f,
  -4.28866223e-02f, -9.78428721e-02f, -1.10070296e-01f, 1.87198017e-02f, -3.37043665e-02f, 4.24037464e-02f, 3.42074744e-02f, 2.17409097e-02f, 2.58020312e-02f, 8.99702907e-02f,
  1.40543319e-02f, 8.86282176e-02f, -4.12502512e-02f, -3.52098607e-02f, -6.08868450e-02f, -1.14727922e-01f, 3.26814391e-02f, 9.97352786e-03f, 1.01901494e-01f, 1.05202638e-01f,
  9.47799627e-03f, 9.84242335e-02f, -1.22571457e-02f, 9.95840132e-02f, -8.54665786e-02f, -9.93918255e-02f, -2.97545213e-02f, -9.63412449e-02f, -8.07552692e-03f, -4.94862441e-03f,
  -9.95507613e-02f, -5.25445445e-03f, 3.11440174e-02f, 5.91564737e-02f, -3.70156057e-02f, -6.59913644e-02f, 6.22663870e-02f, -6.19845837e-02f, 5.40013313e-02f, 1.48797929e-01f,
  1.18773356e-01f, 4.29911278e-02f, 5.47638498e-02f, 1.15491338e-01f, 3.50690223e-02f, 4.67011938e-03f, 2.13109761e-01f, 3.22772153e-02f, -1.79655030e-02f, -5.27612902e-02f,
  -1.15676127e-01f, 5.79620600e-02f, 1.69939324e-02f, -4.59704809e-02f, 5.74167147e-02f, 3.79120819e-02f, 2.82529891e-02f, 7.97869116e-02f, -2.79948283e-02f, 8.04684609e-02f,
  5.01713715e-02f, -3.52936611e-02f, -5.08202314e-02f, 9.42869205e-03f, 4.95283748e-04f, 7.94241056e-02f, -4.12872024e-02f, -3.30011323e-02f, -3.94949839e-02f, 1.90818030e-02f,
  -1.10440984e-01f, 8.73590559e-02f, 4.55113575e-02f, -5.58020435e-02f, -1.71932660e-03f, -4.02285941e-02f, -1.08010620e-01f, -4.87075895e-02f, 5.36934957e-02f, -4.65508290e-02f,
  -2.96300761e-02f, -6.89283460e-02f, -6.83934689e-02f, 2.29367297e-02f, -7.72275031e-02f, -2.79961638e-02f, -3.02238227e-03f, 1.19539984e-02f, -4.54357192e-02f, -5.63707240e-02f,
  6.32514060e-02f, 3.73686627e-02f, 1.12461755e-02f, 1.02850404e-02f, -2.24989671e-02f, -1.26956496e-02f, -5.46881966e-02f, 1.66696534e-02f, 5.67586347e-02f, -1.05701955e-02f,
  -6.83519021e-02f, 6.48331270e-02f, -5.98678850e-02f, 5.83593994e-02f, -3.99287045e-02f, -1.33626144e-02f, -3.67779434e-02f, -6.92208409e-02f, 2.90617347e-02f, -2.55781021e-02f,
  2.72891987e-02f, 2.06727311e-01f, -3.22278962e-02f, -5.88458702e-02f, 7.40721822e-03f, -2.98804566e-02f, 8.38958845e-03f, -1.45279774e-02f, -1.94099601e-02f, -6.28472343e-02f,
  5.03323227e-02f, -8.07702541e-02f, -3.76666822e-02f, 9.88953747e-03f, 8.17472264e-02f, 7.67047480e-02f, 2.64710020e-02f, -2.92119775e-02f, -4.89343889e-04f, 1.50290141e-02f,
  2.21031178e-02f, 6.42968193e-02f, 6.89007863e-02f, 4.54677269e-03f, 3.97105217e-02f, -2.04281835e-03f, 5.57286944e-03f, 3.80397625e-02f, -2.57645342e-02f, -7.89686069e-02f,
  8.04858208e-02f, -1.31462932e-01f, -1.90455448e-02f, 5.38953580e-02f, 8.85249078e-02f, -2.48731533e-03f, -6.06496632e-03f, -4.58431840e-02f, -1.25707671e-01f, -1.11990897e-02f,
  8.99857953e-02f, -1.61089674e-01f, -8.09705481e-02f, 3.31582390e-02f, -6.31980821e-02f, -2.74365712e-02f, -4.28941138e-02f, -9.03596729e-02f, -1.03422686e-01f, -5.38408309e-02f,
  9.47965086e-02f, -1.52396858e-02f, 4.22865711e-02f, 1.71273842e-01f, 5.77638447e-02f, 9.80424210e-02f, 1.47680432e-01f, 3.71910841e-03f, 4.69291881e-02f, 9.17700008e-02f,
  -7.81592540e-03f, -8.52500796e-02f, -5.87657057e-02f, 5.09054586e-02f, 4.57437746e-02f, 2.17330363e-02f, 1.00967996e-01f, -1.20176123e-02f, -5.97788803e-02f, -3.20520960e-02f,
  -6.63758218e-02f, -9.85150859e-02f, -6.36318186e-03f, 1.75955128e-02f, -2.35393699e-02f, 5.30224591e-02f, -8.86618439e-03f, -2.78589353e-02f, -5.32629294e-03f, -5.15233763e-02f,
  -4.51708250e-02f, -8.45337734e-02f, -5.31401522e-02f, -6.28319234e-02f, -2.04537734e-02f, -3.27436365e-02f, 4.07529213e-02f, -7.15915784e-02f, -5.43984808e-02f, -9.35448408e-02f,
  -4.87372316e-02f, -9.47004557e-03f, -7.20742494e-02f, -1.35357631e-02f, 6.88670799e-02f, -4.37585004e-02f, -2.22755540e-02f, -4.47376221e-02f, -1.78834680e-03f, 4.79689240e-02f,
  6.18148744e-02f, 7.72055704e-03f, -9.13865212e-03f, 2.60290336e-02f, -7.04423040e-02f, -5.87930810e-03f, -8.75158701e-03f, 8.38285461e-02f, 4.61119547e-04f, -2.15506330e-02f,
  5.00323027e-02f, -4.05061059e-02f, 1.23021938e-02f, -1.41657572e-02f, 3.95795293e-02f, -4.62336801e-02f, 6.35401830e-02f, 3.15917172e-02f, -6.28802925e-02f, 5.38555160e-02f,
  6.76551182e-03f, 1.30097503e-02f, -7.64827356e-02f, 1.76567622e-02f, -7.32657220e-03f, 1.05620585e-01f, -2.64991559e-02f, -1.64703038e-02f, 5.77867357e-03f, -3.06508504e-02f,
  4.22002673e-02f, 1.57544501e-02f, 7.53533021e-02f, 9.43246949e-03f, 1.93022825e-02f, -2.03782376e-02f, -8.86041746e-02f, 1.28928926e-02f, 9.94917471e-03f, 1.17553152e-01f,
  7.39404708e-02f, 9.05279294e-02f, 5.06620742e-02f, -6.39624521e-02f, -7.94726312e-02f, 6.79890364e-02f, 5.83626032e-02f, -4.23602983e-02f, 6.37383983e-02f, 7.05270767e-02f,
  6.71031475e-02f, -1.09368518e-01f, -2.06343830e-01f, -8.15415606e-02f, 1.23590361e-02f, -1.41924411e-01f, -2.67012537e-01f, -7.23257065e-02f, 7.87835196e-02f, 7.68209174e-02f,
  -1.02113627e-01f, -7.41373980e-04f, 1.26017913e-01f, -5.40797040e-03f, 4.71345410e-02f, 1.67161793e-01f, -2.19952703e-01f, -1.25519335e-01f, -7.94812962e-02f, -9.76415500e-02f,
  5.44871688e-02f, -2.12903731e-02f, -5.83209395e-02f, 1.99029744e-02f, -1.77107260e-01f, 4.94327880e-02f, 1.16242453e-01f, -1.44363180e-01f, -1.01613887e-01f, -8.54960009e-02f,
  1.40123377e-02f, 2.04909876e-01f, -1.55665707e-02f, -1.69656165e-02f, -2.09723203e-03f, 1.93654019e-02f, -6.85380250e-02f, 7.00221024e-03f, 1.76849775e-02f, -4.95391106e-03f,
  4.74958122e-02f, 5.59932068e-02f, -8.23967457e-02f, -2.44137924e-02f, -1.04068771e-01f, 1.49104716e-02f, -6.69000074e-02f, -1.17388752e-03f, -5.71547635e-02f, 7.28978030e-03f,
  -1.14551701e-01f, 4.11089137e-02f, -3.65349315e-02f, -2.78894957e-02f, -4.93894778e-02f, 5.68604916e-02f, -6.09564781e-02f, -3.71231809e-02f, -6.07566498e-02f, -7.13726133e-02f,
  2.37334892e-02f, 8.52894038e-02f, -6.59342762e-03f, 1.05267793e-01f, 3.55103761e-02f, 2.36823000e-02f, -8.05479959e-02f, -4.43619378e-02f, -2.95555349e-02f, 3.24844047e-02f,
  6.38322532e-02f, 5.17298356e-02f, 6.83717430e-02f, -4.92229722e-02f, -4.43637036e-02f, -6.43754262e-04f, -7.64206517e-03f, 8.32351670e-02f, -1.30307838e-01f, 5.16972095e-02f,
  8.10489878e-02f, 1.56441703e-02f, 4.40720432e-02f, -7.91230202e-02f, -5.04851080e-02f, 3.27854641e-02f, -8.88275206e-02f, 1.55122336e-02f, 2.89894920e-03f, 2.73141526e-02f,
  1.02880500e-01f, 5.75504778e-03f, 4.92814854e-02f, 5.10111004e-02f, 2.11671684e-02f, -4.58237901e-02f, 8.25169161e-02f, 1.58142895e-02f, -1.09290205e-01f, -9.84288827e-02f,
  -1.09094977e-01f, 6.67374134e-02f, -1.80087972e-03f, -5.36065595e-03f, -1.93126313e-02f, -6.37906268e-02f, -6.71501383e-02f, -5.78392707e-02f, -3.79317664e-02f, 4.53434773e-02f,
  -4.93901335e-02f, 2.76068561e-02f, -1.66397281e-02f, -5.87766804e-02f, -6.87557906e-02f, -3.59489881e-02f, 5.16448058e-02f, 9.34022963e-02f, -8.89139026e-02f, 9.36770737e-02f,
  -1.23467714e-01f, 9.18693542e-02f, -1.00609340e-01f, 8.43150616e-02f, -1.54031858e-01f, 1.06008779e-02f, 2.08534747e-02f, -5.20081781e-02f, -1.14257559e-02f, 1.92334130e-01f,
  1.65264662e-02f, 4.27580103e-02f, 9.77712497e-02f, 1.67798623e-01f, -5.81838600e-02f, 7.80763850e-02f, 8.50060135e-02f, 4.14215699e-02f, -8.91173035e-02f, -4.92863171e-02f,
  7.00457692e-02f, 1.01694584e-01f, 8.37688893e-02f, -1.30438516e-02f, -1.10042751e-01f, -6.79914728e-02f, 1.02424398e-01f, 4.13711742e-03f, -6.16807230e-02f, 3.16023565e-04f,
  -4.75430526e-02f, -5.04316613e-02f, -1.00476079e-01f, -7.20092803e-02f, -6.49556145e-02f, -9.77549553e-02f, -4.18592393e-02f, 5.42993024e-02f, 3.66062708e-02f, 4.83070910e-02f,
  3.95856872e-02f, -5.76422550e-02f, -8.33353847e-02f, -4.76416163e-02f, -9.32417288e-02f, 5.03753349e-02f, 5.66691123e-02f, 6.60753995e-02f, -1.36540225e-03f, -5.34478687e-02f,
  6.05141036e-02f, -8.19249917e-03f, 8.53216276e-02f, -3.97167131e-02f, 5.88729493e-02f, -3.96438092e-02f, 1.78735889e-02f, -1.87094361e-02f, -1.00862972e-01f, 2.88713817e-02f,
  2.06581187e-02f, -3.04567739e-02f, -5.02516469e-03f, -3.40126478e-03f, -2.19501462e-02f, -5.48130125e-02f, -6.58651143e-02f, -7.64881149e-02f, 6.97885230e-02f, -7.69812316e-02f,
  -8.08803439e-02f, -6.99893236e-02f, 2.35803574e-02f, -8.64408910e-02f, -7.87135363e-02f, -8.17411207e-03f, -2.70073991e-02f, 3.83122489e-02f, 3.67452158e-03f, 4.03365344e-02f,
  9.37673897e-02f, -6.19333237e-02f, 7.29324296e-02f, -6.06674738e-02f, -2.32999660e-02f, 5.04642799e-02f, -6.37220889e-02f, 1.37568405e-02f, 6.08361699e-02f, 7.97002912e-02f,
  -9.91090611e-02f, -9.67876613e-02f, -8.11068807e-03f, -6.58252165e-02f, -7.63269514e-02f, 2.68144682e-02f, 9.24145132e-02f, -1.17995106e-01f, 5.05481698e-02f, 5.15755937e-02f,
  -9.00330544e-02f, -3.27007286e-02f, 4.31586020e-02f, 5.35685346e-02f, 5.91399893e-02f, 5.62595017e-02f, -4.39097472e-02f, 1.02747325e-02f, 5.41204996e-02f, 3.07741184e-02f,
  -1.66211054e-02f, -8.86646137e-02f, 2.80770641e-02f, 5.11904284e-02f, 8.00153315e-02f, 2.59727414e-04f, -7.08458871e-02f, -9.77625325e-02f, 3.21192406e-02f, -4.97633778e-02f,
  -1.76151589e-01f, 1.02026192e-02f, -7.20003396e-02f, -1.41228316e-03f, -5.25205135e-02f, 2.63397451e-02f, 9.77668464e-02f, 4.14611362e-02f, 1.05963781e-01f, 2.49988511e-02f,
  7.51821771e-02f, 5.92644177e-02f, 1.65637843e-02f, 5.14444746e-02f, -8.17542374e-02f, 4.40989397e-02f, 2.73530111e-02f, 5.28977700e-02f, -2.48242170e-02f, -6.75968751e-02f,
  1.96149666e-02f, -6.91761300e-02f, -7.04489499e-02f, 3.75227444e-02f, -4.63146716e-02f, 9.35812574e-03f, 4.13510576e-02f, -6.41986588e-03f, 1.85926184e-02f, 9.20918956e-02f,
  -7.85755590e-02f, -7.12401420e-02f, -1.19128358e-02f, 6.27933741e-02f, 4.79766615e-02f, -5.23416474e-02f, -4.45685871e-02f, 5.74878678e-02f, -2.34713964e-03f, 1.65556390e-02f,
  -1.54837444e-02f, -7.02002319e-03f, 1.54609689e-02f, -6.51064748e-03f, 3.27591263e-02f, 6.14562584e-03f, -3.99499908e-02f, 2.05730218e-02f, -7.34118521e-02f, -1.17388114e-01f,
  2.51085125e-02f, -4.21713814e-02f, -3.49440216e-03f, -2.40973029e-02f, 5.77331148e-02f, 5.53542422e-03f, -1.87736843e-02f, 5.13015911e-02f, 5.72683588e-02f, -1.78196968e-03f,
  5.53656556e-02f, 4.31702547e-02f, 2.77064033e-02f, -1.65473986e-02f, -4.55094352e-02f, 3.40800663e-03f, 6.39704913e-02f, 5.90441562e-02f, 5.42146638e-02f, -5.30278943e-02f,
  8.78309011e-02f, 5.63769639e-02f, 2.50895489e-02f, -8.60592350e-02f, -4.09463085e-02f, 9.14084017e-02f, -5.87982722e-02f, -5.17373756e-02f, -3.88697796e-02f, -5.80579340e-02f,
  9.00128707e-02f, -3.51472832e-02f, -3.85601819e-02f, 5.33899069e-02f, 2.90944744e-02f, 2.38185935e-02f, 9.53668654e-02f, 7.00108998e-04f, -4.88039181e-02f, 4.53004278e-02f,
  1.01435483e-02f, 3.37397400e-03f, -5.87702841e-02f, 8.07086527e-02f, -1.87923145e-02f, -3.19175199e-02f, -7.28408573e-03f, 1.23002492e-02f, 7.85601512e-02f, 3.31744514e-02f,
  -8.25433210e-02f, -4.70742248e-02f, -6.48103133e-02f, -7.66811669e-02f, -8.53748620e-02f, 9.10315365e-02f, 1.21724056e-02f, 2.95501594e-02f, 7.46069476e-02f, 7.75811151e-02f,
  -3.13053722e-03f, 7.94880092e-02f, 5.16568571e-02f, -5.18014608e-03f, -3.02446838e-02f, -3.14529128e-02f, -1.63528528e-02f, -5.06419726e-02f, -2.18464062e-02f, 2.91180909e-02f,
  -1.05061896e-01f, -6.81095719e-02f, 9.80645418e-02f, -6.72869831e-02f, -3.10554150e-02f, -1.19472109e-01f, -1.87380202e-02f, -1.43324267e-02f, -1.75408907e-02f, 5.81272282e-02f,
  4.15098779e-02f, 4.41523977e-02f, -1.09101303e-01f, -3.29895131e-02f, 4.80462145e-03f, -6.45491332e-02f, -1.32735550e-01f, -3.57011855e-02f, -3.25614959e-02f, -1.53611407e-01f,
  2.83879936e-02f, -1.46197364e-01f, 2.12395028e-03f, -8.91482085e-02f, -8.10125768e-02f, -1.13412403e-02f, -3.23943570e-02f, 9.06542838e-02f, -1.82210794e-03f, 2.06934474e-02f,
  7.62169855e-03f, -9.45248678e-02f, -6.55364320e-02f, 2.30452064e-02f, 1.26530956e-02f, 2.67892405e-02f, -7.30725052e-03f, 1.13643490e-01f, -2.56302394e-02f, 4.48829569e-02f,
  1.07660592e-01f, -5.28848432e-02f, -4.42436002e-02f, -4.70843241e-02f, 8.57579783e-02f, -3.75186950e-02f, -5.75741082e-02f, -7.70033002e-02f, 6.86185658e-02f, 7.26799145e-02f,
  -6.90513384e-03f, -7.13521689e-02f, -8.07743054e-03f, 3.66264023e-02f, 6.08875677e-02f, -2.80601643e-02f, 5.00955917e-02f, 4.55889814e-02f, -4.70251553e-02f, 4.52252030e-02f,
  7.40079582e-02f, -4.57638167e-02f, -4.58457656e-02f, -5.51997162e-02f, 5.00892177e-02f, -1.93342790e-02f, 6.59336075e-02f, 7.46305846e-03f, 1.06987674e-02f, -8.30572993e-02f,
  -2.45227814e-02f, -5.35852350e-02f, -1.09392628e-01f, 6.55651558e-03f, -7.39187226e-02f, -7.24081993e-02f, -5.97920008e-02f, 5.00807911e-02f, 3.07908542e-02f, -6.54626712e-02f,
  6.20780960e-02f, 8.51696543e-03f, -4.44365703e-02f, 4.59440909e-02f, -9.84597728e-02f, -8.43940601e-02f, -3.19179185e-02f, -5.80854826e-02f, 7.99676403e-02f, 9.58800614e-02f,
  -1.27941757e-01f, -9.35242400e-02f, -9.13041923e-03f, -5.53647336e-03f, -5.47902994e-02f, 8.08297992e-02f, 5.54824583e-02f, -8.55005085e-02f, 2.97857728e-02f, 6.03396855e-02f,
  7.74021074e-02f, -5.89750223e-02f, 6.70198128e-02f, 8.63715075e-03f, -6.25234470e-02f, 8.60069096e-02f, -4.32816148e-02f, 1.55820651e-02f, -2.90265139e-02f, -1.01116989e-02f,
  3.94339040e-02f, -2.04962585e-02f, -3.94720249e-02f, -9.71033946e-02f, 1.94634423e-02f, -4.96179909e-02f, 7.73364119e-03f, 6.14346452e-02f, -3.11837420e-02f, 5.58055416e-02f,
  -1.01850308e-01f, 4.58422676e-02f, -7.16047082e-03f, 3.82442176e-02f, -1.23517541e-02f, -8.06027055e-02f, -2.30161678e-02f, -3.61391231e-02f, -8.97455588e-02f, -5.33216670e-02f,
  1.38728945e-02f, 8.17030296e-02f, -4.74326424e-02f, -1.36249885e-02f, -3.06850299e-02f, 2.70011555e-03f, -8.69289860e-02f, -9.91227701e-02f, -1.04017630e-02f, -1.62697993e-02f,
  -1.06530145e-01f, 8.88101161e-02f, -8.04917514e-02f, -5.80137111e-02f, 8.71317685e-02f, 2.47860309e-02f, -6.90022483e-02f, 2.08131056e-02f, -6.49105236e-02f, -3.58607769e-02f,
  -6.34291396e-02f, 3.08349226e-02f, -6.58645993e-03f, 2.02311538e-02f, 4.05178927e-02f, -8.10279176e-02f, 7.78202713e-02f, 3.08180461e-03f, -7.95699283e-02f, 4.09193970e-02f,
  1.77216586e-02f, -8.71761441e-02f, 5.37601747e-02f, -7.79272690e-02f, 5.02019487e-02f, 3.03956196e-02f, -8.86096582e-02f, 3.66266556e-02f, -8.69486332e-02f, 7.50123933e-02f,
  -1.57499928e-02f, 6.81878254e-02f, -8.22117478e-02f, 5.18532358e-02f, -4.91891429e-02f, 2.49947328e-02f, -8.71444121e-02f, -6.30440265e-02f, -7.03720376e-02f, -9.82126221e-03f,
  8.11575949e-02f, -2.58179307e-02f, -1.32647222e-02f, -3.61781679e-02f, 5.17507866e-02f, -1.03538390e-02f, 1.81400236e-02f, -7.81359002e-02f, -5.32973930e-02f, -8.86942223e-02f,
  5.50727919e-02f, -5.19212261e-02f, -2.16367170e-02f, -6.86003119e-02f, 4.18750905e-02f, 4.58736159e-02f, 7.68215358e-02f, -7.08755525e-03f, 6.81001171e-02f, 4.14543636e-02f,
  -5.10361046e-02f, -3.76608558e-02f, -3.61479931e-02f, 1.18166236e-02f, -3.69480699e-02f, 2.59436294e-02f, -9.53208935e-03f, 6.24574348e-02f, -5.53134605e-02f, 7.07122087e-02f,
  8.02132338e-02f, 6.19488508e-02f, 2.57721953e-02f, -1.00181848e-02f, 1.39469365e-02f, -4.67830896e-02f, 6.53125346e-02f, -5.11428975e-02f, 1.51287327e-02f, 8.23069829e-03f,
  2.73958445e-02f, 4.86103222e-02f, -8.04879069e-02f, 6.08322397e-02f, 1.67496055e-02f, -8.86983350e-02f, 7.49955699e-03f, 4.98898998e-02f, -2.34777071e-02f, -7.43348524e-02f,
  -2.95613557e-02f, -2.59855557e-02f, 1.66089050e-02f, -2.04466283e-02f, 5.45518883e-02f, -7.60719106e-02f, -8.61812532e-02f, 2.91271396e-02f, -2.29063258e-02f, 5.15509956e-02f,
  -1.00814309e-02f, 8.75363350e-02f, 7.37139210e-02f, 1.49848819e-01f, 1.61961634e-02f, 5.49265072e-02f, 1.03228070e-01f, 1.37382358e-01f, 2.12229714e-01f, 2.98581645e-02f,
  -6.71558902e-02f, 1.19966500e-01f, -4.73740026e-02f, -5.14794663e-02f, 3.69351022e-02f, 8.31714869e-02f, 1.28164589e-01f, 2.41439417e-02f, 1.43166363e-01f, 5.80650494e-02f,
  -5.04512247e-03f, -3.11035626e-02f, -1.14115968e-01f, -1.50411963e-01f, -5.87914474e-02f, -1.21582530e-01f, -9.76785719e-02f, -3.70377712e-02f, -8.26010481e-02f, 1.66693330e-02f,
  1.09949790e-01f, 9.77836326e-02f, -9.02443156e-02f, -1.69345420e-02f, 5.37065379e-02f, -1.04468957e-01f, -6.92484304e-02f, 3.90140228e-02f, 1.91724617e-02f, 8.19536224e-02f,
  8.90408158e-02f, -8.16649944e-02f, 2.07522064e-02f, -5.17250635e-02f, 6.07314855e-02f, -3.06589473e-02f, -7.40382299e-02f, -9.60680097e-02f, -4.90020066e-02f, -3.50148641e-02f,
  2.63218749e-02f, -7.19731748e-02f, 1.53851546e-02f, -4.40494493e-02f, -5.30592054e-02f, 1.13520892e-02f, 6.09586295e-03f, 4.47737575e-02f, -7.46895373e-02f, -4.44872677e-02f,
  -3.03421821e-02f, 3.52126434e-02f, -4.94653583e-02f, -1.75096374e-02f, -3.88285927e-02f, 5.85741922e-02f, 7.58474916e-02f, -7.74965510e-02f, 6.91168979e-02f, -1.36319809e-02f,
  -9.33773145e-02f, 2.47844514e-02f, 5.25616622e-03f, -3.50312442e-02f, 3.27371918e-02f, 1.87116656e-02f, 1.54602458e-03f, 3.90382409e-02f, 6.38195798e-02f, -1.99130457e-02f,
  7.19710067e-02f, -8.52539092e-02f, 4.87511419e-02f, 5.29431961e-02f, -2.73798173e-03f, -2.93456782e-02f, 5.58665842e-02f, 2.88961995e-02f, -5.05759753e-02f, 2.45027784e-02f,
  -4.60796542e-02f, 3.53833288e-02f, -9.72640049e-03f, -4.31989469e-02f, -8.69100913e-03f, -8.91978201e-03f, 6.90237507e-02f, -7.56967664e-02f, 7.54408985e-02f, -5.71899153e-02f,
  5.87506443e-02f, 5.78403473e-02f, 8.53228197e-02f, -5.57862297e-02f, -4.03242297e-02f, 1.23026893e-02f, -3.66899781e-02f, -1.03078131e-02f, 8.63621533e-02f, -8.16793814e-02f,
  -2.79034432e-02f, 9.75001454e-02f, 5.20260371e-02f, -1.02806427e-01f, 5.21048568e-02f, -2.75824368e-02f, 9.81648732e-03f, 7.43774027e-02f, -1.90089121e-02f, 6.74106404e-02f,
  -9.64141116e-02f, -8.51528570e-02f, -8.83296356e-02f, -3.35091911e-02f, -4.37513925e-02f, -1.09436281e-01f, -6.92993701e-02f, 9.92348418e-02f, -8.49048942e-02f, 1.29105613e-01f,
  3.03312931e-02f, -1.27136424e-01f, 1.02648564e-01f, 7.67322183e-02f, -6.45624921e-02f, -1.22730490e-02f, -8.23954865e-03f, 1.90416370e-02f, 5.08655095e-03f, 2.34851427e-03f,
  -6.86855167e-02f, 1.23662233e-01f, -1.93987060e-02f, 4.84173447e-02f, 9.04115140e-02f, -1.10630726e-03f, 6.60211965e-02f, 1.01585621e-02f, 1.28212556e-01f, -1.39768040e-02f,
  -6.14854880e-03f, -4.30114530e-02f, 6.93680868e-02f, 2.27712058e-02f, 5.73670343e-02f, -7.45453909e-02f, 7.53370672e-02f, 6.90829679e-02f, 1.74668264e-02f, 8.43028501e-02f,
  -4.77732718e-02f, -1.52572459e-02f, -7.55999088e-02f, -5.39739802e-02f, -1.05006965e-02f, -7.11335912e-02f, 4.34831269e-02f, 3.21098939e-02f, -7.68441409e-02f, -3.94187905e-02f,
  2.75958981e-02f, -1.12779588e-01f, -1.41885392e-02f, -6.03280030e-02f, -6.02123886e-02f, -2.27513444e-02f, -4.43280861e-02f, 4.19311635e-02f, 5.23572639e-02f, -7.32817575e-02f,
  5.51903956e-02f, 1.53589565e-02f, -7.65919015e-02f, 2.54443344e-02f, 2.66937632e-03f, -6.83817342e-02f, 4.62121926e-02f, 3.90878133e-02f, -7.97947273e-02f, 7.44547173e-02f,
  -1.07141966e-02f, 5.78357801e-02f, 6.49221539e-02f, 2.96009220e-02f, 4.82448228e-02f, -7.13198110e-02f, 9.57063884e-02f, -1.52588421e-02f, 7.94303417e-02f, 9.08058807e-02f,
  2.14287844e-02f, 9.65825021e-02f, -1.55106804e-03f, 9.55681223e-03f, -3.98390219e-02f, 8.76559913e-02f, 1.23828277e-02f, 8.60353634e-02f, -1.00967966e-01f, -8.67993608e-02f,
  4.70189080e-02f, 8.41557980e-02f, 2.67582713e-03f, -3.44527103e-02f, 2.41846349e-02f, 9.02897958e-03f, -5.19658364e-02f, -3.30391563e-02f, 3.10328286e-02f, 1.79096628e-02f,
  1.69988126e-02f, -5.97438887e-02f, 5.45537733e-02f, 4.92902137e-02f, -6.60270974e-02f, 7.05563203e-02f, 8.75307173e-02f, -4.93560694e-02f, -3.84745263e-02f, -3.45739760e-02f,
  2.20105648e-02f, -4.11057547e-02f, -8.50676298e-02f, -6.04195110e-02f, -7.94388503e-02f, 4.88174371e-02f, 5.31099699e-02f, -2.73331944e-02f, -4.47395071e-02f, 2.44212840e-02f,
  1.74330130e-01f, -1.89029664e-01f, 5.63512072e-02f, 1.43042952e-01f, 1.77919865e-01f, 4.97983657e-02f, 7.59357065e-02f, -3.72969918e-02f, -4.73925937e-03f, -3.50311473e-02f,
  4.64619920e-02f, -7.85259679e-02f, -3.19177583e-02f, 5.39074726e-02f, 6.35969862e-02f, -5.63886464e-02f, -5.98931871e-02f, -7.31420219e-02f, 2.38504242e-02f, 1.19390031e-02f,
  8.10081288e-02f, 4.70265485e-02f, -2.43761502e-02f, -3.24093588e-02f, 1.26080811e-01f, -8.58990103e-03f, 9.35296621e-03f, -6.61360472e-02f, 3.69017199e-02f, -8.00514296e-02f,
  5.68820722e-02f, 1.62501000e-02f, -4.14266586e-02f, -4.68878597e-02f, 5.11684269e-03f, 2.22137403e-02f, 6.20208979e-02f, -6.49800077e-02f, 1.39571782e-02f, 8.06935653e-02f,
  8.15189108e-02f, -9.77736246e-03f, 4.14243452e-02f, 4.95266654e-02f, 1.60383154e-02f, 7.19042942e-02f, -6.18057698e-03f, -7.07885658e-04f, -1.37892123e-02f, -5.21243066e-02f,
  -9.99473557e-02f, -6.99334443e-02f, 1.84976961e-02f, 3.39223887e-03f, 6.39577359e-02f, -4.41222526e-02f, -2.51552295e-02f, -6.29407093e-02f, 4.11965996e-02f, 3.74100730e-02f,
  6.57601878e-02f, -3.97110917e-02f, 5.31484149e-02f, -5.23408428e-02f, -4.41439897e-02f, 7.51834139e-02f, -3.07108499e-02f, 5.62347174e-02f, 6.73507899e-02f, 6.69906586e-02f,
  8.19547772e-02f, 8.62873495e-02f, -2.70172302e-02f, 2.96691898e-02f, -2.67590526e-02f, -2.48001162e-02f, 1.73559394e-02f, 1.55898742e-02f, 7.15816915e-02f, -7.00124279e-02f,
  -4.96094860e-02f, 5.47441505e-02f, -1.46467062e-02f, 1.96946859e-02f, -2.62598135e-02f, 7.31589049e-02f, 6.61128061e-03f, 5.58872847e-03f, 6.10989518e-02f, -7.46751577e-02f,
  4.95543741e-02f, -9.36855227e-02f, 5.79720661e-02f, 1.78600801e-03f, -8.73411447e-02f, 1.59521471e-03f, 6.67060241e-02f, -3.07241362e-02f, 2.53297295e-02f, 3.03919539e-02f,
  7.02050030e-02f, -5.93472905e-02f, 2.79684030e-02f, 3.44143957e-02f, 2.78436020e-02f, -5.34591600e-02f, -2.81876400e-02f, -3.15816049e-03f, 1.51152415e-02f, 3.64638828e-02f,
  -9.82521847e-02f, -4.64630574e-02f, 4.43224125e-02f, 7.32010975e-02f, -6.55389130e-02f, -6.42093197e-02f, 1.19166970e-02f, -9.22077447e-02f, -4.11962979e-02f, -1.65286772e-02f,
  -9.16538388e-03f, -8.74608085e-02f, 1.39201209e-01f, -5.58686368e-02f, 6.87164441e-02f, 6.77225143e-02f, 3.04308441e-02f, 4.26008888e-02f, 3.02821249e-02f, 2.20584404e-02f,
  -2.80364678e-04f, 3.86635885e-02f, 8.43558758e-02f, 3.42364199e-02f, 4.85426486e-02f, -1.34019153e-02f, -7.07926899e-02f, 3.49753872e-02f, 3.85620892e-02f, 1.26918480e-01f,
  5.37588634e-02f, -2.32825689e-02f, 6.87239170e-02f, 4.29676957e-02f, 1.40378773e-01f, -9.42651033e-02f, -9.90907997e-02f, 7.52484575e-02f, 4.91970852e-02f, 3.50210965e-02f,
  6.01841547e-02f, -6.90577030e-02f, -2.02394910e-02f, -1.60636287e-02f, -6.12284243e-02f, -3.95802036e-02f, 4.34947461e-02f, 4.56448533e-02f, -5.08256555e-02f, -7.01923892e-02f,
  7.34438226e-02f, -4.37259525e-02f, -5.74059077e-02f, 2.35653296e-02f, -5.83243789e-03f, -2.56757978e-02f, -5.63707240e-02f, -9.92340129e-03f, 1.18929707e-02f, 9.28360000e-02f,
  -5.56837469e-02f, -2.48224083e-02f, -1.63842901e-03f, 2.28670402e-03f, 7.21390024e-02f, -6.83074966e-02f, -5.34331612e-02f, 5.01495935e-02f, -1.32992759e-03f, -4.34939004e-02f,
  8.20348412e-02f, 1.28413811e-02f, 3.89587805e-02f, -7.92093724e-02f, -1.92520507e-02f, 2.21013334e-02f, 4.74956743e-02f, 4.17593941e-02f, -4.12290394e-02f, -2.75833216e-02f,
  -1.11225381e-01f, -3.03602163e-02f, 3.81485634e-02f, -6.71233833e-02f, -4.78736274e-02f, 4.49304543e-02f, 6.94204718e-02f, -3.56886648e-02f, -5.07484330e-03f, -4.41119485e-02f,
  1.48693370e-02f, 1.71345081e-02f, 5.80335921e-03f, -6.25979528e-02f, 7.98291489e-02f, -5.07568084e-02f, 7.69977421e-02f, 5.99626601e-02f, -2.46004052e-02f, -1.08800754e-02f,
  -1.03542238e-01f, -4.66786362e-02f, 8.39443281e-02f, -4.19532843e-02f, 9.32865217e-02f, -8.07646438e-02f, -4.05282341e-02f, 8.12768638e-02f, -2.19945349e-02f, 4.73080622e-03f,
  2.97963638e-02f, 4.61080670e-02f, -5.60934544e-02f, 4.89010252e-02f, 5.55851497e-02f, -1.64140482e-02f, 2.95674661e-03f, 4.70164008e-02f, -1.81325544e-02f, 7.77879506e-02f,
  3.78099233e-02f, 9.90452245e-04f, 1.19585209e-02f, -2.48811841e-02f, -3.76688465e-02f, -4.21843939e-02f, -3.58188269e-03f, 8.12887773e-02f, 1.03581194e-02f, -8.34791437e-02f,
  1.42059550e-01f, -2.21535116e-02f, -1.74687225e-02f, 1.02433525e-01f, 5.16827889e-02f, -1.22661583e-01f, 2.14482099e-02f, 4.39422801e-02f, 1.66127831e-01f, -1.18045516e-01f,
  -9.34894234e-02f, -3.47419865e-02f, -1.50551960e-01f, -1.36990771e-02f, 4.08206545e-02f, -2.56168358e-02f, -3.38328001e-03f, 3.41666378e-02f, 3.88152264e-02f, -1.57801490e-02f,
  1.59625724e-01f, -1.46116025e-03f, 4.93456647e-02f, -7.49628479e-03f, -4.11183387e-02f, 2.62002945e-02f, 4.78465483e-02f, -2.40694545e-02f, -6.60438463e-02f, 4.59854081e-02f,
  1.20180927e-03f, -1.80328893e-03f, -7.21844882e-02f, 7.57248467e-03f, 6.95182383e-02f, 2.72719581e-02f, 1.40430185e-03f, 3.66548933e-02f, -1.56920217e-02f, -7.93610066e-02f,
  -7.99918664e-04f, -7.01674148e-02f, -2.97591574e-02f, -3.39444876e-02f, 2.31172238e-02f, 6.53630346e-02f, -1.35557512e-02f, 1.06661737e-01f, 8.44313800e-02f, -7.57965744e-02f,
  2.20317673e-02f, -3.41789722e-02f, 9.10869762e-02f, -5.77800870e-02f, 3.39341834e-02f, 8.34435225e-02f, -7.58682415e-02f, 3.63175711e-03f, 1.88971683e-02f, -9.41806138e-02f,
  4.28696629e-03f, -3.03348415e-02f, 5.65052079e-03f, 3.49026360e-02f, 2.26577022e-03f, -5.85639179e-02f, -2.69780547e-04f, 4.59700730e-03f, -8.66695195e-02f, -1.36951804e-02f,
  -7.70566314e-02f, -4.15706709e-02f, -8.66249427e-02f, -7.13539571e-02f, -3.96448150e-02f, -3.87738049e-02f, -4.80842255e-02f, -1.70968883e-02f, 6.26592934e-02f, -2.07414106e-02f,
  5.51322550e-02f, 3.87802646e-02f, -1.46562513e-02f, 6.80395141e-02f, 1.94652174e-02f, 4.52725552e-02f, -9.07854438e-02f, 7.81711638e-02f, 2.48352438e-03f, -5.23149110e-02f,
  -9.14853737e-02f, -6.39597997e-02f, -6.17623404e-02f, 7.50063658e-02f, -2.48735100e-02f, 4.44519520e-02f, -5.22667095e-02f, 4.11117636e-02f, 8.47439766e-02f, -4.52525727e-02f,
  1.39642283e-02f, 5.83257526e-02f, 4.61074561e-02f, 2.69898437e-02f, 6.64092898e-02f, -4.07947935e-02f, 1.51408352e-02f, -4.21037599e-02f, -5.87434799e-04f, -6.63421601e-02f,
  -1.21508297e-02f, 3.06061935e-03f, 7.02999905e-02f, -2.30229422e-02f, -2.39436198e-02f, 2.98073459e-02f, 1.31434789e-02f, -6.61582500e-02f, -8.28075316e-03f, 6.69640675e-02f,
  -4.06832024e-02f, 1.02881946e-01f, 7.14309439e-02f, 3.66113032e-03f, 2.23528426e-02f, 6.65851161e-02f, 1.23267621e-02f, 6.22685030e-02f, -7.69045055e-02f, 2.81091873e-02f,
  -4.17343192e-02f, 1.28235668e-01f, -7.62733370e-02f, -8.23531300e-02f, -1.72685772e-01f, -1.54530227e-01f, -1.51487231e-01f, 1.53268306e-02f, 5.05465362e-03f, -8.79072621e-02f,
  -1.07938789e-01f, -4.02860455e-02f, 3.43819294e-04f, 4.41317745e-02f, 4.41328734e-02f, 3.95188220e-02f, -1.50486128e-03f, 6.48906231e-02f, -1.72218103e-02f, 3.38209644e-02f,
  3.34829763e-02f, -1.03866108e-01f, 1.09353952e-01f, 1.00641744e-02f, -1.21225389e-02f, 9.58004519e-02f, 3.79562415e-02f, -7.22790733e-02f, 7.09771505e-03f, 3.25160697e-02f,
  -8.30551460e-02f, 9.12662246e-04f, -5.65144196e-02f, -2.40941904e-02f, 1.01302236e-01f, 5.42025529e-02f, 9.16495770e-02f, 4.80324365e-02f, 7.14952797e-02f, -9.21534095e-03f,
  2.17472296e-02f, -4.62236181e-02f, 2.90882308e-03f, 4.15789001e-02f, 1.61404926e-02f, -6.82756305e-02f, 3.74003574e-02f, -6.90611452e-03f, 1.49891013e-02f, 2.27991026e-02f,
  1.87302344e-02f, -5.83784692e-02f, 2.47933473e-02f, -5.11619598e-02f, 7.68864006e-02f, -7.07833618e-02f, 1.48555273e-02f, -8.38309526e-02f, -5.68023324e-02f, -6.82511926e-02f,
  -2.42448635e-02f, 3.98419388e-02f, -1.51961138e-02f, 1.61351971e-02f, 1.05989099e-01f, 7.34350681e-02f, -2.72443965e-02f, -6.07864745e-03f, 2.49740276e-02f, -7.26175755e-02f,
  4.09998372e-02f, -9.70354602e-02f, -1.90453157e-02f, -4.71351333e-02f, 1.80148724e-02f, 3.57012562e-02f, -5.94150312e-02f, -7.74957659e-03f, -7.53691932e-03f, 3.04212770e-03f,
  3.13641392e-02f, -9.30694416e-02f, -5.84699512e-02f, 6.39957264e-02f, -1.03140250e-02f, -3.41981240e-02f, -5.41628636e-02f, -3.55570130e-02f, -1.71756595e-02f, 8.52792896e-03f,
  6.44057617e-02f, -8.77228901e-02f, -2.50330344e-02f, -6.20179400e-02f, 6.38275826e-03f, 5.44849038e-02f, 2.58224867e-02f, -8.01623538e-02f, 8.63164663e-02f, 1.73638891e-02f,
  2.24524047e-02f, -5.26682921e-02f, 7.30528831e-02f, -8.54208842e-02f, 3.95637974e-02f, 9.23364833e-02f, 5.42578567e-03f, -8.50233436e-02f, -7.90436566e-02f, -2.41591427e-02f,
  -5.24953455e-02f, -2.97276415e-02f, -1.37816265e-01f, -1.21789731e-01f, -1.55943543e-01f, -2.51234919e-01f, -2.45571092e-01f, -1.81373462e-01f, 4.90766093e-02f, 1.43432198e-02f,
  -6.14736564e-02f, -4.86912765e-02f, 1.15607180e-01f, -1.83772258e-02f, 4.48895171e-02f, 9.71765965e-02f, -8.43972266e-02f, -4.92731556e-02f, 7.98025876e-02f, -1.49978593e-01f,
  7.55014494e-02f, -6.00126646e-02f, 4.12271880e-02f, 8.01220629e-03f, -3.39483209e-02f, -2.80389898e-02f, 7.16265012e-03f, -8.75475928e-02f, -1.26491159e-01f, 2.16424707e-02f,
  -1.49951756e-01f, -1.49936810e-01f, -1.52388155e-01f, -6.37129471e-02f, -3.82239148e-02f, -2.79912930e-02f, -7.92725831e-02f, 6.36070743e-02f, -3.66926827e-02f, -8.92040357e-02f,
  2.05046106e-02f, -2.50209626e-02f, 2.17166208e-02f, -6.64025769e-02f, 1.04297642e-02f, -1.96030140e-02f, 3.26022394e-02f, -3.77847888e-02f, -1.75262596e-02f, -1.06012233e-01f,
  -1.09075472e-01f, -7.85206724e-03f, -1.07168719e-01f, -3.78173515e-02f, -5.36325946e-02f, 3.13333236e-03f, 2.75422521e-02f, -1.99142918e-02f, 4.48875222e-03f, -7.72951692e-02f,
  -6.45872876e-02f, 1.01187170e-01f, -1.05468199e-01f, 2.38265246e-02f, -4.19116989e-02f, 3.16248015e-02f, -2.88055521e-02f, -4.78982134e-03f, 3.61995772e-02f, -7.73911038e-03f,
  -3.85531336e-02f, 6.56516757e-03f, -1.18336594e-02f, 2.23891493e-02f, -3.86379100e-02f, 1.06214946e-02f, 6.27415404e-02f, -4.12002280e-02f, -2.17150934e-02f, -3.59271728e-02f,
  -2.50303987e-02f, 5.81283495e-02f, -4.89183702e-02f, 2.55197450e-03f, -1.22873731e-01f, 1.18519783e-01f, 2.10333243e-02f, -1.05656590e-02f, -7.72961751e-02f, -1.09293088e-02f,
  -1.50081664e-01f, -1.20658994e-01f, -1.08059466e-01f, -1.74915120e-02f, 9.02276561e-02f, -6.96101189e-02f, 4.89192046e-02f, -1.72207709e-02f, -1.83502231e-02f, 3.33874226e-02f,
  -2.47764084e-02f, -4.05849144e-02f, -5.91936484e-02f, 7.20201656e-02f, 5.19365259e-02f, -1.37677845e-02f, -5.50253280e-02f, 3.54757383e-02f, 4.99813892e-02f, 1.55367227e-02f,
  3.29073146e-02f, 5.25422730e-02f, 1.08937748e-01f, 3.56690437e-02f, 5.80123775e-02f, -5.73267192e-02f, 4.61675860e-02f, 8.05882141e-02f, -5.66086881e-02f, -5.88494875e-02f,
  3.63317691e-02f, 1.71297580e-01f, 1.94297627e-01f, 1.54651329e-01f, -1.01230048e-01f, -1.23183072e-01f, 2.02723574e-02f, -5.24559282e-02f, 5.60624525e-02f, -4.31154259e-02f,
  -5.07754050e-02f, 8.40345621e-02f, 3.48600112e-02f, -2.75955442e-02f, -5.56925312e-02f, -4.96039074e-03f, -1.04229845e-01f, -8.54266360e-02f, 2.03928426e-02f, -5.36448844e-02f,
  6.01653457e-02f, -4.73835096e-02f, 2.83231735e-02f, -7.08658099e-02f, 8.54689777e-02f, 1.36157244e-01f, -1.18763894e-01f, 3.60829346e-02f, -6.40378892e-02f, -3.80101567e-03f,
  -3.80490161e-02f, -3.47708911e-02f, 7.30428249e-02f, 6.24442250e-02f, -7.57136568e-02f, -1.12047233e-01f, -1.87049769e-02f, -9.09825191e-02f, -2.21458636e-02f, 2.60803346e-02f,
  9.09270197e-02f, -5.61608747e-02f, 1.04181228e-04f, -9.17039625e-03f, -5.11000194e-02f, 7.64019340e-02f, 7.27757514e-02f, 4.52737100e-02f, -1.67691484e-02f, -2.79564373e-02f,
  9.96785760e-02f, 7.63319880e-02f, -6.81348145e-02f, -1.74222868e-02f, -4.34131436e-02f, -7.10635260e-02f, 4.46881652e-02f, 6.88032582e-02f, 3.69174741e-02f, -7.30524361e-02f,
  1.35848358e-01f, -9.01173055e-02f, 3.00608925e-03f, -8.71350914e-02f, -6.62256703e-02f, -3.16895656e-02f, -4.90247495e-02f, 8.31091963e-03f, 2.45628729e-02f, 5.09791784e-02f,
  2.85644233e-02f, 3.31778117e-02f, 3.33255827e-02f, 1.72280632e-02f, 6.15123436e-02f, -5.01046740e-02f, 1.01554625e-01f, -2.78102029e-02f, -1.62840374e-02f, -6.75678439e-03f,
  -5.41550145e-02f, -6.64241388e-02f, 4.40677702e-02f, -4.14521396e-02f, -8.53510723e-02f, -5.87137230e-02f, -4.78995591e-02f, 1.43863875e-02f, -3.39480788e-02f, -1.00752629e-01f,
  4.27608304e-02f, 1.17010087e-01f, -7.06918463e-02f, 3.90471816e-02f, -5.82842641e-02f, 4.03376445e-02f, -1.56225152e-02f, 9.38338116e-02f, 5.51527813e-02f, 3.73003143e-03f,
  2.91996896e-02f, 3.21447626e-02f, -1.18075358e-02f, 6.06781058e-02f, 6.13107160e-02f, 1.19186360e-02f, -4.39537391e-02f, -1.48653388e-02f, 7.30720386e-02f, 4.60359752e-02f,
  2.45575537e-03f, -8.27730671e-02f, -6.76260367e-02f, 7.48943072e-03f, 8.41611177e-02f, 1.03871308e-01f, -3.94835472e-02f, 6.81351796e-02f, 6.80777654e-02f, 4.97876890e-02f,
  5.57930991e-02f, -7.05334172e-02f, 2.92034131e-02f, 3.53831053e-02f, -4.40969467e-02f, 3.03081404e-02f, -1.25561744e-01f, 1.28725804e-02f, 4.74831834e-02f, 6.22109845e-02f,
  1.00237273e-01f, 6.00439869e-02f, -1.54850073e-02f, -9.33067799e-02f, -8.02534372e-02f, 9.73102972e-02f, -5.08569330e-02f, 4.45001163e-02f, 8.60993862e-02f, -4.50095087e-02f,
  -7.19769374e-02f, 6.18601777e-02f, 6.16957769e-02f, 1.18807681e-01f, 2.29746420e-02f, 6.80892691e-02f, 5.49428724e-02f, 8.82498249e-02f, 1.01241820e-01f, -5.88113256e-02f,
  3.14552113e-02f, 1.14572765e-02f, 3.36902961e-03f, -7.24895345e-03f, 4.22824696e-02f, -5.21858782e-02f, -1.15548132e-03f, 5.06740138e-02f, -3.81058604e-02f, -4.32590628e-03f,
  -2.73528639e-02f, 4.24102321e-02f, 6.43844306e-02f, -5.32253087e-02f, 5.93732577e-03f, -7.19698891e-03f, -2.47587636e-02f, 1.07967518e-02f, -7.11612329e-02f, -2.20216789e-05f,
  -1.01084873e-01f, -6.39858246e-02f, 5.86947463e-02f, -8.65392461e-02f, 1.54871549e-02f, -2.17004046e-02f, -5.27930409e-02f, -8.79682302e-02f, 1.93886384e-02f, 8.19770992e-02f,
  -1.10857025e-01f, 8.88803303e-02f, 1.64163355e-02f, -2.68203188e-02f, 3.57501879e-02f, -7.07199574e-02f, -2.56709382e-02f, 8.26662481e-02f, -5.86490892e-02f, -4.46153134e-02f,
  1.00003988e-01f, -7.45538250e-02f, -2.83795632e-02f, 4.49157469e-02f, -6.80553094e-02f, -1.98706985e-03f, 6.64470717e-02f, 3.05838566e-02f, -3.69472019e-02f, -5.64185753e-02f,
  7.03008175e-02f, -5.20741045e-02f, -3.63703333e-02f, 3.08918897e-02f, 7.06951916e-02f, 9.00614932e-02f, 4.41017980e-03f, 2.70278193e-02f, -3.33455615e-02f, 6.34274036e-02f,
  -4.47993949e-02f, -2.87889838e-02f, -9.43099521e-03f, 1.41215054e-02f, -6.69618323e-02f, -2.79230382e-02f, -3.62350941e-02f, 1.96964499e-02f, 9.60931629e-02f, 5.06320558e-02f,
  -7.07973838e-02f, -7.92992935e-02f, -7.80591294e-02f, 2.17704326e-02f, -5.61689474e-02f, 5.55282347e-02f, 6.52531758e-02f, 2.09935252e-02f, -2.27397680e-02f, -5.80538735e-02f,
  7.50324577e-02f, -6.80024847e-02f, 6.24748915e-02f, -8.90338495e-02f, 7.17059597e-02f, -4.70594764e-02f, -8.62405151e-02f, 6.57297112e-03f, -4.36106436e-02f, -8.64370018e-02f,
  -1.06583074e-01f, 1.03570238e-01f, -6.67622462e-02f, -1.03030309e-01f, 7.86812678e-02f, 1.62817892e-02f, 2.78232954e-02f, 7.30566159e-02f, 1.24448852e-04f, -5.59555069e-02f,
  6.41029701e-02f, -1.46726087e-01f, 6.80764988e-02f, -1.55852541e-01f, -1.05351828e-01f, -6.60057692e-03f, -1.02972873e-01f, -5.10903448e-02f, -2.97979712e-02f, -9.12768021e-02f,
  3.49905565e-02f, -3.16238143e-02f, -4.63534035e-02f, 6.95358813e-02f, -3.54765542e-02f, -4.94098663e-02f, -1.02946863e-01f, -1.36847030e-02f, -5.14121726e-02f, 1.61148328e-02f,
  -8.76654163e-02f, -2.22618841e-02f, -2.54363678e-02f, -1.96156222e-02f, -7.81393796e-02f, -5.62797748e-02f, 6.24824725e-02f, 4.42247875e-02f, -9.18327421e-02f, 7.28099700e-03f,
  -7.88176581e-02f, 7.33794421e-02f, 4.24490646e-02f, 4.79370467e-02f, 1.68881100e-02f, 6.47444651e-02f, 4.30097952e-02f, -2.28926763e-02f, -4.32799989e-03f, 4.67149243e-02f,
  7.57493675e-02f, -5.66369705e-02f, -1.90648958e-02f, -6.55396357e-02f, -6.23778775e-02f, 2.35572420e-02f, -5.80282733e-02f, 1.13825044e-02f, -9.36830044e-02f, 3.07495743e-02f,
  6.99894130e-02f, -1.25842169e-02f, -8.27361345e-02f, 7.54473060e-02f, 1.03285447e-01f, 1.06970966e-01f, 6.22300319e-02f, 6.27010688e-02f, 2.33077686e-02f, 4.89372686e-02f,
  6.56574294e-02f, 6.07835762e-02f, -8.87835398e-02f, -6.81482032e-02f, -5.65356389e-02f, 4.77479920e-02f, 1.05759865e-02f, -7.62846991e-02f, 6.26325980e-02f, 3.61690558e-02f,
  -7.53790513e-02f, 3.24314088e-02f, -2.10598181e-03f, 6.33009225e-02f, 1.04073793e-01f, 6.27105013e-02f, 8.44668821e-02f, -7.15066567e-02f, -9.49645862e-02f, 5.94397122e-03f,
  2.08467618e-02f, 5.73965125e-02f, -3.06231454e-02f, -6.11677915e-02f, 7.72142597e-03f, 4.92093600e-02f, -3.95503454e-02f, -5.32792099e-02f, -2.25158539e-02f, 1.91631671e-02f,
  -2.33064890e-02f, 2.96692410e-03f, 5.45288494e-05f, 3.91715690e-02f, 5.96372411e-02f, 6.04470074e-02f, 3.72278318e-02f, -1.11980746e-02f, 5.79587370e-02f, -6.67662024e-02f,
  -2.35040393e-02f, 8.07828754e-02f, 8.21273327e-02f, -7.84740746e-02f, 5.68853654e-02f, -5.86598106e-02f, 5.64131513e-02f, 6.68330789e-02f, -6.39337748e-02f, 3.63315269e-02f,
  -7.43362680e-02f, 6.35367334e-02f, 6.03965372e-02f, 4.71219569e-02f, -2.66942047e-02f, -1.37895226e-01f, -6.51193932e-02f, 1.65788196e-02f, 3.51382270e-02f, -7.71799088e-02f,
  1.98735446e-02f, 1.10492274e-01f, -8.62693116e-02f, 1.33246526e-01f, 1.11763887e-01f, 3.01811080e-02f, 1.22776248e-01f, 9.67470109e-02f, -5.20221964e-02f, 1.00647584e-01f,
  1.30961552e-01f, -3.52315679e-02f, 7.66780833e-03f, -5.64501025e-02f, 2.11477503e-02f, 3.89209278e-02f, 6.86574727e-02f, 3.13503817e-02f, 6.15538247e-02f, -5.52762747e-02f,
  -5.82070388e-02f, 8.61476511e-02f, 4.10174998e-03f, 9.49385464e-02f, 1.67580321e-02f, 8.22017156e-03f, 9.66228992e-02f, 1.26511371e-02f, 3.35054100e-02f, 5.81995696e-02f,
  -5.05105332e-02f, 2.57287337e-03f, -1.38567174e-02f, 4.95082811e-02f, -7.37132132e-02f, -6.01628758e-02f, -1.84423674e-03f, 3.98688838e-02f, 4.70174327e-02f, 4.86491248e-02f,
  8.81428495e-02f, 6.54176176e-02f, -3.90508361e-02f, 2.30556447e-02f, 2.63248049e-02f, -3.55201848e-02f, 3.26378867e-02f, -1.49193518e-02f, -3.41774374e-02f, 3.15720104e-02f,
  -9.46378037e-02f, 4.62319748e-03f, 6.58527911e-02f, 6.26118779e-02f, -7.44093284e-02f, -2.09792033e-02f, -2.92700771e-02f, 6.05725683e-02f, -8.51510838e-02f, -1.30452598e-02f,
  3.21225338e-02f, -4.81349453e-02f, -1.88553780e-02f, -2.52759550e-02f, -2.23122109e-02f, 1.70171242e-02f, -7.95852095e-02f, 6.73164614e-03f, -3.48540246e-02f, 4.47552837e-02f,
  2.98567470e-02f, -5.51666692e-02f, -1.13724358e-02f, 2.43733972e-02f, 9.08039976e-03f, -3.82362455e-02f, -4.67026234e-02f, 4.87640612e-02f, -6.34080246e-02f, 6.40806742e-03f,
  -6.36597872e-02f, 2.67484859e-02f, -4.15674485e-02f, -4.66976762e-02f, 5.93302399e-02f, -7.15310648e-02f, -5.50129823e-02f, -8.04325566e-02f, -6.59530191e-03f, -7.92008117e-02f,
  -6.43753931e-02f, 3.14284489e-02f, 4.33608182e-02f, -3.14889033e-03f, 5.60731143e-02f, 3.34369093e-02f, -7.75329545e-02f, 4.83286828e-02f, 6.36335611e-02f, 8.99947062e-02f,
  -5.68098761e-02f, -4.15532663e-02f, -3.51465978e-02f, -2.59420946e-02f, -4.17866046e-03f, 6.22648746e-03f, 7.64520317e-02f, 8.20614919e-02f, 4.18909900e-02f, -3.31830718e-02f,
  -1.08345104e-02f, 7.89195076e-02f, -5.27219661e-02f, -7.01628774e-02f, 6.33118451e-02f, 3.46734598e-02f, 1.10900141e-02f, 4.68452834e-02f, -4.15831283e-02f, 1.10988423e-01f,
  4.29170132e-02f, 1.04471575e-02f, 3.83047797e-02f, -7.61692645e-03f, 2.23152656e-02f, -1.05452880e-01f, 4.94369213e-03f, 2.33145058e-02f, -6.54608011e-02f, -8.70884117e-03f,
  -3.78172509e-02f, 1.24236047e-01f, -8.13449249e-02f, 3.04346085e-02f, 7.88765773e-02f, 1.87297072e-02f, -4.00776751e-02f, -2.53376644e-02f, -1.30177932e-02f, 1.08402716e-02f,
  -3.56870517e-03f, -6.43007308e-02f, 1.08221462e-02f, 4.07477245e-02f, 2.42015887e-02f, -1.93362217e-02f, 5.29276095e-02f, -4.70019467e-02f, -2.50523072e-03f, 6.13566628e-03f,
  -3.68723720e-02f, 4.28218357e-02f, -4.44680545e-03f, 4.67321612e-02f, -5.88321732e-03f, -5.34839556e-02f, 6.48021698e-02f, 4.61223163e-02f, 5.28274861e-04f, -4.18369658e-02f,
  2.48229560e-02f, 9.69048664e-02f, -2.72516403e-02f, -1.96807440e-02f, 9.24570858e-03f, -1.13665650e-03f, 4.98975953e-03f, 7.13604614e-02f, 1.05479494e-01f, -2.32908279e-02f,
  2.36749332e-02f, -3.05529628e-02f, -1.05709150e-01f, -5.72036877e-02f, 3.90082598e-02f, -2.71240901e-02f, 4.40497659e-02f, -2.09538173e-02f, 1.70596801e-02f, -5.34768924e-02f,
  3.04144472e-02f, 2.58870292e-02f, -4.76709194e-02f, -4.32140678e-02f, 4.89380732e-02f, -2.31107455e-02f, 6.66494220e-02f, 6.96345568e-02f, 5.65628186e-02f, 2.03030352e-02f,
  -4.38887812e-02f, -7.71631375e-02f, 6.60954043e-02f, 4.02477868e-02f, 6.59428164e-02f, 4.91942205e-02f, -1.71179173e-03f, 8.24310035e-02f, 8.29893425e-02f, -5.18837906e-02f,
  -2.61417925e-02f, 6.05428815e-02f, -5.44346385e-02f, -1.43134966e-02f, -2.24686097e-02f, -4.87918481e-02f, 6.52923882e-02f, 3.09997071e-02f, -3.54976906e-03f, -7.56734982e-02f,
  7.69105926e-02f, -3.60059179e-03f, 9.93200541e-02f, -6.04287460e-02f, -8.62616077e-02f, -7.35320821e-02f, 5.25219440e-02f, 8.20997879e-02f, 8.40057358e-02f, 4.99049947e-02f,
  -1.81762502e-03f, -7.54999742e-03f, 6.77810907e-02f, -3.55131626e-02f, 8.79720151e-02f, 1.59528237e-02f, 5.45139350e-02f, 5.10291662e-03f, -6.49103969e-02f, 6.26757741e-02f,
  1.26828000e-01f, 1.02625024e-02f, -9.77618396e-02f, -1.70082618e-02f, 6.47421256e-02f, 3.04686371e-02f, 5.89703061e-02f, 6.30751327e-02f, -1.02477230e-01f, 2.50752326e-02f,
  5.12512773e-02f, 1.19368490e-02f, -7.17919171e-02f, -3.90260778e-02f, -2.89203087e-03f, -1.81936417e-02f, 9.14744884e-02f, -2.27851812e-02f, -1.26867354e-01f, 9.30112749e-02f,
  -5.19387946e-02f, 2.71980464e-02f, -1.96501445e-02f, 9.07963514e-02f, 1.21635776e-02f, -9.95426066e-03f, -3.74110118e-02f, 5.31283058e-02f, 7.06956312e-02f, -6.44336119e-02f,
  1.13473356e-01f, 5.59436195e-02f, -5.32301255e-02f, 4.07053828e-02f, -3.54236402e-02f, 1.28415614e-01f, -2.42519714e-02f, 8.98894668e-02f, -8.58928785e-02f, -5.27801998e-02f,
  7.75719956e-02f, -9.72339362e-02f, 7.45033622e-02f, -4.18213606e-02f, 5.74110411e-02f, 2.68194303e-02f, -1.47419600e-02f, -4.28234674e-02f, -8.72707143e-02f, -4.59817760e-02f,
  3.08185816e-02f, -3.24774943e-02f, 1.07924864e-02f, -8.79245400e-02f, 8.42592865e-03f, -1.37258749e-02f, 1.36049455e-02f, 5.68679869e-02f, 9.53845382e-02f, 6.21431097e-02f,
  7.62029514e-02f, 8.47387239e-02f, 2.93203574e-02f, -1.13703832e-02f, 2.82416120e-02f, 2.40302924e-02f, -3.53948795e-03f, 2.56999768e-02f, -1.84541438e-02f, 4.66410816e-02f,
  -4.75628152e-02f, -7.34455809e-02f, -5.47404997e-02f, 3.16332616e-02f, -8.37867707e-02f, -2.79617123e-02f, 7.77916834e-02f, -6.26843423e-02f, -8.72198343e-02f, 7.29515329e-02f,
  -3.07489783e-02f, 6.57990798e-02f, 7.43498355e-02f, 8.99130255e-02f, 2.36850735e-02f, 1.37342839e-02f, -7.19454736e-02f, 6.40139207e-02f, -8.99618119e-02f, 2.91919820e-02f,
  1.04144365e-01f, -3.40254046e-02f, 6.88866451e-02f, -3.86176147e-02f, -1.26763829e-03f, 8.32914561e-02f, 1.93737745e-02f, -4.92929444e-02f, 8.13085288e-02f, 5.06693609e-02f,
  5.37145697e-02f, 2.12822687e-02f, -5.50519153e-02f, -2.34849844e-02f, 2.86286939e-02f, 6.96993992e-02f, -5.87479360e-02f, 5.58548905e-02f, 3.03715225e-02f, 9.38382819e-02f,
  -2.85066031e-02f, 8.81318897e-02f, 5.26178144e-02f, 2.83185039e-02f, -5.60253821e-02f, 2.60841884e-02f, 3.22584845e-02f, 2.77539343e-03f, 8.17082301e-02f, -1.71757396e-02f,
  1.86338767e-01f, -4.46551293e-02f, -1.19780324e-01f, 9.63953882e-02f, 9.68509093e-02f, 1.50187910e-01f, 1.04998864e-01f, 3.12528014e-02f, 1.02490716e-01f, -9.62756574e-02f,
  8.95682573e-02f, -8.64334479e-02f, -8.61052796e-02f, 8.30187276e-02f, 1.05890550e-01f, 1.68160852e-02f, 1.17566288e-01f, 1.78775638e-02f, -5.56970350e-02f, -5.04485220e-02f,
  -6.49599433e-02f, 9.90902930e-02f, 2.94352192e-02f, 3.72490957e-02f, -4.59038615e-02f, -1.50971320e-02f, -1.72324665e-02f, -1.13287181e-01f, -2.86365971e-02f, 8.19223300e-02f,
  -2.43373532e-02f, -2.43743579e-03f, -3.86334285e-02f, -3.77795547e-02f, -1.37831084e-02f, 2.27607656e-02f, -4.21976559e-02f, -1.26854293e-02f, -8.89259726e-02f, -9.48595777e-02f,
  5.35734184e-02f, -3.89023474e-03f, -3.64787094e-02f, -8.59552529e-03f, -3.63136479e-03f, 6.38141576e-03f, 5.85253574e-02f, -4.10852470e-02f, 1.03977351e-02f, -1.86795369e-02f,
  -8.46119151e-02f, 7.75396125e-03f, 1.61460806e-02f, -2.74334215e-02f, 5.81005178e-02f, 2.93562785e-02f, 6.00045510e-02f, -8.08955058e-02f, -2.45007519e-02f, 6.73839375e-02f,
  -4.83628772e-02f, 6.43638009e-03f, 4.76945117e-02f, -3.46025564e-02f, -3.95663045e-02f, -5.01442403e-02f, -1.15898037e-02f, -6.77804947e-02f, -3.03757656e-02f, -2.21310440e-03f,
  -3.26567814e-02f, 1.52442455e-02f, 3.83732491e-03f, 1.13157490e-02f, 2.90220398e-02f, 3.25242728e-02f, 9.36640650e-02f, 1.61829982e-02f, -6.10154010e-02f, 2.21359264e-02f,
  -1.40451584e-02f, -5.48641197e-03f, -6.44920468e-02f, 1.24061778e-02f, -2.95166019e-02f, -3.41573246e-02f, 3.08536608e-02f, -3.70661579e-02f, 5.33475615e-02f, 7.77126523e-03f,
  5.36343977e-02f, 3.84429134e-02f, 7.36778975e-02f, -1.51853357e-02f, -2.27449276e-02f, 1.64477360e-02f, -2.73024198e-02f, -2.16831788e-02f, -7.07785338e-02f, 6.63998052e-02f,
  2.85339616e-02f, 1.74852405e-02f, -7.57985786e-02f, 4.85751368e-02f, -6.54243305e-02f, -7.94354156e-02f, -2.08040532e-02f, 5.95679767e-02f, 4.92490865e-02f, 1.26282230e-03f,
  -4.72697750e-04f, 1.56120760e-02f, -3.14302444e-02f, -4.42075729e-02f, 7.10908175e-02f, -3.75579931e-02f, -2.29749433e-03f, -4.45739925e-02f, -8.31855610e-02f, 6.56620115e-02f,
  -1.23183995e-01f, -2.73510255e-02f, 7.06570074e-02f, -1.28355503e-01f, 3.53811383e-02f, 1.36641525e-02f, -1.01246953e-01f, -2.72997357e-02f, 2.79991832e-02f, -8.92344490e-02f,
  4.08927761e-02f, 8.44952166e-02f, -5.77307679e-02f, -8.24073553e-02f, 5.68659268e-02f, 2.93746646e-02f, -1.49537712e-01f, -1.09398991e-01f, 1.12712868e-02f, 5.25657050e-02f,
  -6.01475909e-02f, 3.81696038e-02f, 2.13388936e-03f, 2.13382058e-02f, 7.94657413e-03f, 6.70012385e-02f, -5.24541689e-03f, 7.74280205e-02f, -6.88606203e-02f, 1.74582645e-03f,
  3.98403034e-02f, -2.11296398e-02f, -2.73851808e-02f, 7.44751096e-02f, 4.06587590e-03f, -3.27025279e-02f, 7.68708205e-03f, -2.99061574e-02f, -4.29115742e-02f, 5.80983981e-03f,
  -3.31458412e-02f, 9.14271846e-02f, 4.34652790e-02f, -8.37362632e-02f, -8.76192600e-02f, -2.90421080e-02f, -3.40689979e-02f, -1.64194182e-02f, -1.63365752e-02f, 6.98174089e-02f,
  -5.32586426e-02f, -6.97933957e-02f, -3.95587683e-02f, -3.81079987e-02f, 2.95943599e-02f, -8.20463821e-02f, 5.27638532e-02f, 3.46212685e-02f, -6.16086088e-03f, -4.76789437e-02f,
  -6.67953491e-03f, 7.86929652e-02f, -7.49279782e-02f, 1.50987820e-03f, -2.43015271e-02f, -4.56591509e-02f, -6.58972114e-02f, 6.59265146e-02f, 6.77234828e-02f, -4.45426926e-02f,
  -2.67676935e-02f, -8.56602862e-02f, 6.43764362e-02f, -3.75445262e-02f, -7.13095218e-02f, -5.56626618e-02f, 4.39346805e-02f, -1.88223850e-02f, 1.44963227e-02f, -4.30724882e-02f,
  -6.17345870e-02f, -2.95447949e-02f, -2.87556332e-02f, 2.13099103e-02f, 5.39980344e-02f, 7.62648135e-02f, -4.89318147e-02f, 2.10242555e-03f, -6.09442778e-02f, 5.76923378e-02f,
  -1.14102578e-02f, -6.87285438e-02f, -1.17055379e-01f, 1.56670064e-02f, -7.75291324e-02f, -3.99305262e-02f, 7.20038684e-03f, 1.57983173e-02f, -2.77826842e-02f, 2.47345306e-02f,
  6.67864755e-02f, 3.75429094e-02f, 1.16308779e-02f, -5.55586182e-02f, 6.13435805e-02f, -7.53013194e-02f, -8.13930482e-02f, -4.07459103e-02f, -7.24156797e-02f, 1.80115886e-02f,
  -5.84855266e-02f, -9.80794989e-03f, 1.67938787e-02f, -6.94358051e-02f, 3.81992795e-02f, 9.08893719e-02f, 8.17443058e-02f, -9.03618932e-02f, -4.72315215e-02f, -7.50058144e-02f,
  1.28289476e-01f, 2.96466686e-02f, 2.42151394e-01f, 9.47815180e-02f, -7.55557641e-02f, -1.10239044e-01f, -9.21662897e-03f, 4.23015328e-03f, 6.53433725e-02f, -4.38908860e-02f,
  -5.69120198e-02f, 2.12048680e-01f, -1.54566094e-01f, 9.24405828e-03f, -1.06175795e-01f, -1.21024728e-01f, -2.98300181e-02f, 7.46606067e-02f, 6.15420751e-02f, -7.74706248e-03f,
  -1.02727756e-01f, -1.46594450e-01f, 8.05172101e-02f, -2.16546636e-02f, 2.59088129e-02f, 2.40287296e-02f, -1.21702746e-01f, -6.54449537e-02f, 5.51965982e-02f, -7.30763227e-02f,
  -4.94832173e-02f, 5.98511696e-02f, 4.91024069e-02f, 6.14912659e-02f, -8.61960649e-02f, 9.87874717e-02f, -3.89121547e-02f, 3.49234790e-02f, 1.40727675e-02f, 1.19265169e-02f,
  4.08863872e-02f, 9.73506644e-02f, -2.61791553e-02f, -2.78819464e-02f, -3.15147899e-02f, 9.36423987e-02f, 1.10648550e-01f, -5.51507510e-02f, 8.49276111e-02f, 1.15816623e-01f,
  1.24215014e-01f, -2.46996377e-02f, 5.39544970e-02f, -5.50840758e-02f, 2.13258751e-02f, 1.34956697e-02f, 3.44340988e-02f, -6.16158471e-02f, 7.89398625e-02f, 1.01316825e-01f,
  6.77090585e-02f, -1.87817067e-02f, -2.68446133e-02f, -1.88458953e-02f, -7.38158524e-02f, -1.01854419e-03f, -9.85393748e-02f, -1.70828272e-02f, 4.10357788e-02f, -7.47336298e-02f,
  1.57246329e-02f, 6.56154752e-02f, -4.31767218e-02f, 3.54862139e-02f, 4.13617343e-02f, 6.88224733e-02f, 5.34887128e-02f, -2.59635914e-02f, 6.66813254e-02f, 5.66415079e-02f,
  6.83924928e-02f, 5.08355722e-02f, 1.48095433e-02f, 5.72458617e-02f, 7.04439357e-02f, 8.21094066e-02f, 6.20638989e-02f, 3.06988936e-02f, -3.97497602e-02f, 3.68448608e-02f,
  -5.19988388e-02f, -1.13414966e-01f, -2.70331856e-02f, -8.74724835e-02f, 4.98560518e-02f, 3.32915671e-02f, 2.01291200e-02f, 3.26986015e-02f, 5.32345511e-02f, -3.88611853e-02f,
  -4.86868508e-02f, -1.21714724e-02f, 7.27734640e-02f, 3.12635042e-02f, 5.39365448e-02f, -5.76215424e-02f, -3.55420299e-02f, -5.52730449e-02f, 6.56778589e-02f, 6.41956180e-02f,
  6.82558194e-02f, 6.14624880e-02f, -5.71512319e-02f, 1.37892338e-02f, 9.66100916e-02f, -5.20579107e-02f, 6.26034988e-03f, -5.29065207e-02f, 3.67249921e-02f, -2.82453429e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  -6.32332116e-02f, 2.29048543e-02f, -4.87030931e-02f, -8.17001890e-03f, 3.11045703e-02f, -5.32263108e-02f, 6.09188825e-02f, 7.50073045e-02f, 4.72994745e-02f, 6.14198036e-02f,
  7.69636557e-02f, -7.05959648e-03f, 1.23342969e-01f, -6.31666332e-02f, 9.69019234e-02f, 3.54483202e-02f, 4.83557954e-02f, 6.92385584e-02f, -3.30337547e-02f, 4.05884311e-02f,
  2.74526756e-02f, -8.02824423e-02f, 1.41970161e-02f, 1.16734296e-01f, -5.65869287e-02f, 8.13996606e-03f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -1.33743420e-01f, -1.03275798e-01f, -5.50984889e-02f, -8.14407915e-02f, 8.28081295e-02f, -4.55579385e-02f, 1.15049724e-02f, 6.64902478e-02f, 1.56941459e-01f, 2.28888616e-02f,
  -1.10691376e-01f, -7.42987692e-02f, 6.38536140e-02f, 2.66360283e-01f, 1.48571596e-01f, 1.16739690e-01f, -9.92631763e-02f, 9.83902365e-02f, 2.50720363e-02f, 9.66963693e-02f,
  -1.80090427e-01f, -6.82542175e-02f, -8.29784945e-03f, 1.86645046e-01f, -1.72689736e-01f, 2.55042724e-02f, -4.27365787e-02f, 9.93807912e-02f, 2.74721859e-03f, 9.37786177e-02f,
  -5.73085696e-02f, -4.66808751e-02f, -1.33184448e-01f, 2.97311228e-02f, -5.96029423e-02f, -9.86135229e-02f, 1.04556069e-01f, -1.77052785e-02f, 5.61925173e-02f, 1.75900422e-02f,
  6.32770509e-02f, 7.37427035e-03f, 1.44233987e-01f, -1.49001360e-01f, -7.58097991e-02f, 2.53865141e-02f, 8.98603052e-02f, -1.34152353e-01f, -3.07079218e-02f, -1.28339142e-01f,
  9.93288383e-02f, 1.95122771e-02f, 1.17398508e-01f, 7.06777945e-02f, -8.33207443e-02f, -1.53993228e-02f, -2.73721907e-02f, -8.27824771e-02f, -2.73635350e-02f, 1.28778487e-01f,
  -7.00848103e-02f, 7.23756850e-02f, -9.35635120e-02f, 9.84388068e-02f, 3.24408226e-02f, 1.52519837e-01f, 5.76716773e-02f, 3.77625674e-02f, -9.11386013e-02f, -1.60812557e-01f,
  7.32887834e-02f, 5.56762964e-02f, -1.84418708e-02f, -8.24395120e-02f, -9.44957659e-02f, -4.71223034e-02f, 3.80024388e-02f, 6.19979203e-02f, -4.83335592e-02f, 7.15967491e-02f,
  -2.55450085e-02f, -3.74426693e-02f, 4.95834909e-02f, -2.49259725e-01f, 2.11994469e-01f, 7.78674781e-02f, 7.04853609e-02f, -9.92053151e-02f, -1.54430568e-01f, 1.19861104e-01f,
  1.59052521e-01f, 1.12814046e-01f, -1.75602138e-01f, 1.27075925e-01f, 1.16246641e-02f, -1.04830712e-02f, 1.71660796e-01f, -3.23503286e-01f, 6.72577322e-02f, -1.14859223e-01f,
  1.32474467e-01f, 2.11701244e-02f, -3.90963890e-02f, 1.76305562e-01f, -1.51794985e-01f, -5.58271334e-02f, -9.34642628e-02f, 7.21650496e-02f, 4.97663431e-02f, 1.05286993e-01f,
  -1.19588189e-01f, -5.87256216e-02f, 4.25708815e-02f, -5.19325584e-02f, 1.61580458e-01f, 1.37757316e-01f, 1.10447682e-01f, -1.79402977e-02f, 7.06871180e-03f, -1.38562888e-01f,
  9.44891572e-03f, -1.47063658e-02f, -1.07054360e-01f, -7.42685199e-02f, -1.35800103e-02f, -2.78529860e-02f, -3.37105915e-02f, -5.46717532e-02f, -3.57386060e-02f, 1.01144761e-01f,
  2.20142379e-02f, -3.84911709e-02f, -2.78166942e-02f, 1.24616005e-01f, 1.01703472e-01f, -9.86159220e-02f, 1.18771501e-01f, 1.31434873e-01f, 2.32258957e-04f, 1.95688959e-02f,
  4.01336476e-02f, -2.56732590e-02f, -3.11881909e-03f, -6.33586869e-02f, -5.05607203e-02f, 1.53096557e-01f, 1.45161867e-01f, -7.54572302e-02f, -1.65845156e-01f, -5.19079529e-02f,
  -1.80284262e-01f, -1.51081666e-01f, 7.45914727e-02f, -1.08257517e-01f, -6.82194382e-02f, -1.74953237e-01f, 6.02309443e-02f, 1.39127329e-01f, 2.00002268e-01f, 1.12365343e-01f,
  -4.18787561e-02f, 3.49743105e-02f, -4.79569240e-03f, 1.08121447e-01f, -3.53067964e-02f, 5.11807352e-02f, 6.96866065e-02f, -2.46021841e-02f, -9.11429524e-02f, 2.81404052e-03f,
  -2.12885495e-02f, -2.48435251e-02f, 6.88612387e-02f, 1.92697383e-02f, 3.77957113e-02f, -6.17030412e-02f, -8.98684785e-02f, 1.55912295e-01f, 8.40054676e-02f, -4.61462997e-02f,
  4.07708138e-02f, 1.01524919e-01f, 1.24890596e-01f, -6.90169781e-02f, 9.59873796e-02f, 7.26067200e-02f, 5.05981259e-02f, 1.08552948e-02f, 2.31151637e-02f, -1.35415206e-02f,
  6.36731610e-02f, -1.29242882e-01f, 5.79174645e-02f, -1.84207000e-02f, -8.75534192e-02f, -3.98289487e-02f, 9.47056711e-02f, 1.68358032e-02f, -1.01312965e-01f, -5.23164459e-02f,
  1.11637907e-02f, 5.38372695e-02f, -1.11742541e-02f, -5.61586022e-02f, -8.55787843e-02f, 1.38721287e-01f, 1.27621189e-01f, -5.17993793e-02f, 1.37609482e-01f, -4.53421623e-02f,
  -5.91020212e-02f, 3.46962214e-02f, 1.00622717e-02f, -8.02571978e-03f, -4.68152948e-02f, 2.18070641e-01f, 2.35999729e-02f, -2.21310481e-02f, -2.71286368e-02f, 7.63015300e-02f,
  2.96332780e-02f, 1.47263080e-01f, -1.05763830e-01f, 7.01353401e-02f, -7.61643797e-02f, -1.76881626e-01f, -4.72677778e-03f, -2.41551176e-01f, 1.90160442e-02f, -1.53534740e-01f,
  7.34327212e-02f, -5.71234189e-02f, -5.34875207e-02f, 7.14355782e-02f, 1.86125133e-02f, -1.27258658e-01f, 5.58934510e-02f, 1.05614468e-01f, 7.80615732e-02f, -4.90626730e-02f,
  1.09024845e-01f, 5.38582616e-02f, 1.02969237e-01f, 4.07075509e-02f, 7.76010007e-02f, 3.62284333e-02f, -1.50717959e-01f, 3.61765847e-02f, 2.59767976e-02f, 4.44354042e-02f,
  1.21838123e-01f, 1.00227386e-01f, 8.05580169e-02f, -2.22115051e-02f, 8.12873244e-02f, -3.54830176e-02f, 8.14517587e-03f, -1.18562020e-01f, -1.34402558e-01f, -1.64467081e-01f,
  -1.91661552e-01f, 9.58747491e-02f, 9.71005261e-02f, 3.13460804e-03f, 1.87327549e-01f, 2.56441414e-01f, -5.27541488e-02f, -4.86477613e-02f, -1.17232524e-01f, 2.87865192e-01f,
  -9.44625139e-02f, 6.53179968e-03f, 1.23786338e-01f, -1.23044625e-02f, 6.65039523e-03f, 2.21549213e-01f, -1.86130315e-01f, -1.35251701e-01f, 7.08675086e-02f, 2.05731079e-01f,
  -1.00258589e-01f, -2.81190220e-02f, -3.35627049e-02f, 1.67481229e-01f, 2.45361775e-01f, 3.30534540e-02f, 1.56613684e-03f, 3.15747075e-02f, -9.07880068e-02f, 1.20020874e-01f,
  -8.33938867e-02f, -2.09009573e-01f, 5.94870448e-02f, -1.81862377e-02f, -1.08635157e-01f, -7.98850507e-02f, 1.84146106e-01f, 1.08836025e-01f, -1.85114723e-02f, -1.20297298e-01f,
  -1.43305451e-01f, 1.02538049e-01f, -5.91528490e-02f, 6.86284900e-02f, -4.38440777e-02f, 5.74734956e-02f, -6.12253696e-02f, -6.66125789e-02f, 1.30831569e-01f, 1.21871181e-01f,
  -2.22165406e-01f, 2.06531972e-01f, 6.28338084e-02f, -3.18006147e-03f, -3.23141329e-02f, 9.60142389e-02f, 9.84804854e-02f, 1.02113202e-01f, 8.34819004e-02f, 6.63939863e-02f,
  -4.99841161e-02f, -5.63747957e-02f, -1.03610717e-01f, -3.34958769e-02f, -1.01430342e-02f, 7.85108730e-02f, 1.25836851e-02f, 5.86133674e-02f, 9.22032595e-02f, 2.27459013e-01f,
  7.85670336e-03f, -9.26900432e-02f, -9.67817828e-02f, 1.73834130e-01f, 8.86462554e-02f, -3.05442382e-02f, 1.32103991e-02f, -9.54587460e-02f, 3.04794293e-02f, 1.44169435e-01f,
  -1.05899043e-01f, -1.29296109e-01f, -5.25267534e-02f, 6.30986616e-02f, 1.01607926e-02f, -2.80871093e-02f, -4.92975749e-02f, -3.40456516e-02f, 9.75756422e-02f, 1.66373566e-01f,
  1.78933144e-01f, -7.75025487e-02f, -9.70827565e-02f, -1.18959278e-01f, -2.24718094e-01f, -2.01084271e-01f, 9.56399068e-02f, -2.28137732e-01f, -4.12469916e-02f, 7.08612204e-02f,
  -8.83004740e-02f, 3.02888583e-02f, 1.45662352e-01f, -5.84234297e-03f, -9.31917205e-02f, 7.35431388e-02f, -1.75689369e-01f, -9.03726891e-02f, -1.37572303e-01f, 7.83818439e-02f,
  1.41779214e-01f, -1.37149066e-01f, 1.26770735e-01f, -8.80020037e-02f, -1.00888066e-01f, -1.22624226e-01f, 1.11012816e-01f, 3.78433652e-02f, -1.45410284e-01f, 5.56405932e-02f,
  1.22961693e-01f, -3.37216109e-02f, -6.06284365e-02f, -1.94401652e-01f, 2.56994795e-02f, 1.08086824e-01f, 5.54810390e-02f, -1.54122263e-02f, -4.05622236e-02f, -2.38372952e-01f,
  -5.87472040e-03f, 1.30906641e-01f, 2.54064053e-03f, -8.72702971e-02f, -5.25496006e-02f, -5.38713634e-02f, -8.87338296e-02f, -3.78458910e-02f, 2.51034945e-02f, -4.00437182e-03f,
  4.08464437e-03f, -7.34236985e-02f, 7.77038112e-02f, -1.52374238e-01f, 1.83331177e-01f, 2.70230826e-02f, 1.76436290e-01f, 5.91421276e-02f, -1.13344729e-01f, -4.60360423e-02f,
  -9.99608114e-02f, 1.95991695e-01f, -1.61041453e-01f, -1.08913437e-01f, -7.81574659e-03f, 2.34992011e-03f, -1.98457800e-02f, -3.18859458e-01f, 1.78725384e-02f, -5.30011170e-02f,
  -7.41768675e-03f, -1.54033294e-02f, 1.04102574e-01f, 1.13318063e-01f, -7.84501210e-02f, -4.70512062e-02f, -3.88072394e-02f, -8.93946290e-02f, 4.21975888e-02f, -6.52346462e-02f,
  -6.65757954e-02f, 6.71973219e-03f, 1.03448972e-01f, 2.34209057e-02f, 8.29536542e-02f, 6.26672804e-02f, 3.03027108e-02f, -1.69035405e-01f, 5.47150187e-02f, -1.12820402e-01f,
  8.04847106e-02f, -1.00618377e-02f, 9.37011652e-03f, -3.10437530e-02f, -5.86707108e-02f, 1.68938190e-01f, -1.04407020e-01f, 2.30969209e-02f, -6.07721135e-02f, 5.71209230e-02f,
  -3.12916450e-02f, -1.06009087e-02f, -7.54382927e-03f, 5.43867499e-02f, 1.24724731e-02f, -9.31627825e-02f, 5.26803546e-02f, 6.06400194e-03f, -1.30639508e-01f, 2.73633115e-02f,
  9.28218216e-02f, -8.40584859e-02f, 1.20948263e-01f, 1.38892187e-02f, 1.02301121e-01f, -3.82793210e-02f, 1.86768457e-01f, -3.65367010e-02f, 1.04514107e-01f, -1.08985052e-01f,
  -4.24333140e-02f, -2.38085166e-02f, -6.22586198e-02f, -1.56120151e-01f, 4.07299632e-03f, 1.75044179e-01f, -2.09635809e-01f, 1.95446070e-02f, -1.66871876e-01f, 1.96138725e-01f,
  1.10232592e-01f, 2.02099755e-02f, -6.73594475e-02f, 1.43127376e-02f, 1.11499839e-01f, 2.09461257e-01f, 4.12529558e-02f, 1.07845046e-01f, 4.10014689e-02f, 3.09409834e-02f,
  -1.20192170e-01f, 8.81024674e-02f, -3.56497504e-02f, -1.18352093e-01f, 4.83387848e-03f, -8.37785453e-02f, 1.75893694e-01f, -6.21381849e-02f, 7.07653314e-02f, 4.26208489e-02f,
  -6.61645159e-02f, 6.60057552e-03f, 6.19301461e-02f, -9.54441354e-02f, -1.16617136e-01f, -7.02349283e-03f, -8.40309188e-02f, -1.12848699e-01f, -8.81007463e-02f, -3.28106657e-02f,
  -4.84049171e-02f, 1.61784872e-01f, 2.17367068e-01f, 1.01442881e-01f, 5.72245307e-02f, -7.37417908e-03f, 1.73632473e-01f, 1.32644922e-01f, -2.84859166e-02f, 1.25733286e-01f,
  -3.39633077e-02f, -3.51510234e-02f, -8.65141675e-02f, 7.05400407e-02f, -5.46357557e-02f, 3.19015025e-03f, -1.38148457e-01f, 9.51624662e-02f, 3.83131206e-02f, 1.42056614e-01f,
  4.53463122e-02f, 2.46922802e-02f, 8.68588313e-02f, -1.45265058e-01f, -1.34092644e-01f, -2.49373540e-01f, 7.41366372e-02f, -1.55021265e-01f, 5.41258082e-02f, -1.13394678e-01f,
  -5.02707623e-02f, 1.64380893e-01f, 7.22807273e-02f, 3.84957716e-02f, -4.55573723e-02f, 3.40806842e-02f, -3.82095389e-02f, 1.79278404e-01f, 6.04900345e-03f, 5.88692427e-02f,
  6.54169247e-02f, 1.96163151e-02f, -2.21878663e-01f, -1.72843859e-01f, 5.75001054e-02f, 1.18973948e-01f, -1.05767034e-01f, 1.21459916e-01f, 1.38622135e-01f, 3.82686146e-02f,
  -1.19620971e-01f, 6.95319623e-02f, 1.90259237e-02f, 3.03534884e-03f, -6.41499609e-02f, 1.32955700e-01f, 5.99670410e-02f, -1.14039190e-01f, 6.33146614e-02f, 1.31770357e-01f,
  -1.04024976e-01f, 2.16491185e-02f, 4.67523001e-02f, -1.21222556e-01f, 1.47943109e-01f, 7.66952708e-02f, -8.02396759e-02f, -2.27892712e-01f, -9.33035389e-02f, -1.19158581e-01f,
  -1.52973503e-01f, 1.91735044e-01f, 5.95935956e-02f, -3.08894683e-02f, 2.84815487e-02f, 2.73123950e-01f, -6.16830140e-02f, -3.65246609e-02f, -5.75089119e-02f, 1.41822398e-01f,
  -6.41183108e-02f, 6.32173568e-02f, 3.09473239e-02f, -4.01126593e-02f, -3.91348079e-02f, 5.10358214e-02f, -9.33221281e-02f, -2.11144332e-02f, -5.83697930e-02f, 3.05650663e-02f,
  7.74255618e-02f, 1.10282160e-01f, 3.84106189e-02f, -9.69424918e-02f, 2.31069610e-01f, 1.42753884e-01f, 6.24878183e-02f, -6.58298040e-06f, -1.36598170e-01f, 1.06668606e-01f,
  -1.79788917e-01f, -3.47910374e-02f, -2.56391224e-02f, -1.41697332e-01f, -8.87988284e-02f, -9.82401744e-02f, 1.14662610e-01f, 1.20670781e-01f, 3.30796838e-02f, -1.27071172e-01f,
  1.68990847e-02f, -5.79185970e-02f, -1.02913976e-02f, -9.66357216e-02f, 4.80579622e-02f, 1.18883774e-01f, -5.29366871e-03f, -5.71666844e-03f, -1.04161166e-01f, 1.76227272e-01f,
  -1.38272732e-01f, -2.05788761e-02f, -5.59998266e-02f, 1.05624378e-01f, -7.67239779e-02f, 6.39854297e-02f, -1.38871521e-02f, 6.00519851e-02f, 4.99848393e-04f, 4.78016734e-02f,
  -1.92062855e-01f, 1.05734512e-01f, 6.97962493e-02f, 1.33391216e-01f, 1.25772059e-01f, -1.04237847e-01f, -6.28809771e-03f, 1.06899723e-01f, -4.44734544e-02f, 5.58079444e-02f,
  6.78291991e-02f, -7.86509812e-02f, 1.13774598e-01f, -1.29272252e-01f, 5.94143197e-03f, 5.35892742e-03f, -1.33795515e-01f, -1.84630200e-01f, -2.59885192e-02f, -2.29421228e-01f,
  2.73698896e-01f, 1.26989046e-03f, 1.72854692e-01f, -1.23088144e-01f, 1.64465517e-01f, -1.04916189e-02f, -4.32014130e-02f, 1.59563035e-01f, 2.43387986e-02f, 1.11263998e-01f,
  -1.42957836e-01f, -1.03558935e-01f, 2.00338870e-01f, -3.18711400e-01f, 1.40487149e-01f, -1.17376901e-01f, 1.91084780e-02f, 7.44517520e-02f, -3.41887586e-03f, 4.29316536e-02f,
  -9.81867462e-02f, -1.51668340e-01f, 7.98700452e-02f, -1.49079129e-01f, 1.78173818e-02f, 1.12516962e-01f, -5.15924133e-02f, -5.68811260e-02f, 9.82434750e-02f, 1.21633291e-01f,
  -6.53782338e-02f, 1.19934879e-01f, -1.46277264e-01f, -7.23882020e-02f, -1.37684613e-01f, -1.64893419e-01f, 6.59655035e-03f, -1.25864625e-01f, 2.77152583e-02f, 8.17179307e-02f,
  1.63146973e-01f, 1.83068261e-01f, -2.45664325e-02f, -1.03291124e-01f, -1.32925361e-01f, 3.83350775e-02f, 2.85483450e-02f, 3.40410545e-02f, -1.27629191e-01f, -1.40786022e-02f,
  -8.64613354e-02f, 9.27355066e-02f, 1.38123319e-01f, -2.10986137e-02f, -6.76584914e-02f, 5.74387144e-03f, -8.29591528e-02f, 2.44897455e-01f, 1.51727051e-01f, -7.12477714e-02f,
  1.48546010e-01f, -9.82678756e-02f, -2.70418059e-02f, 1.36577442e-01f, -1.68261826e-01f, 4.76888679e-02f, 1.08675152e-01f, 2.14715049e-01f, -9.09603164e-02f, 1.68273831e-03f,
  -1.25823244e-01f, 1.02161497e-01f, 1.39874481e-02f, -7.51562938e-02f, 2.36270819e-02f, 4.07192484e-02f, -4.08995077e-02f, 1.36450619e-01f, -1.27130702e-01f, -7.97244459e-02f,
  1.53869137e-01f, 5.58423288e-02f, -8.00406560e-02f, -6.19027345e-03f, 1.70459345e-01f, -1.23889735e-02f, 1.32746428e-01f, -1.40016213e-01f, -1.10507898e-01f, -6.41258135e-02f,
  -1.36321083e-01f, 1.06174067e-01f, 3.02089062e-02f, -5.79655096e-02f, -6.17033541e-02f, -1.09657012e-01f, 5.15747257e-02f, 4.12853137e-02f, -1.63417071e-01f, 1.79593116e-01f,
  8.23526829e-02f, -9.86664835e-03f, 5.75554408e-02f, 5.99166080e-02f, -9.28260088e-02f, -1.12041242e-01f, 1.60796437e-02f, 1.87688753e-01f, 2.11180493e-01f, -2.77546979e-02f,
  1.28972337e-01f, 1.63702834e-02f, -6.85082842e-03f, 1.59372948e-02f, -1.37175560e-01f, -8.29133838e-02f, -1.24513395e-01f, -1.22384271e-02f, 3.15861888e-02f, -4.70548980e-02f,
  1.59158260e-02f, 7.42817745e-02f, -1.12976909e-01f, 1.29849166e-01f, 3.35978158e-02f, 9.27838758e-02f, -1.90462060e-02f, 2.64704198e-01f, -1.06283076e-01f, 2.53760349e-03f,
  -1.35148624e-02f, -4.70277257e-02f, -1.90441877e-01f, -1.49635240e-01f, 2.39022920e-04f, -7.88224041e-02f, -1.65311024e-01f, -2.87961662e-02f, -3.11539955e-02f, 4.37288545e-02f,
  -1.78675011e-01f, 2.21482798e-01f, -2.20680073e-01f, 2.13252917e-01f, 1.39153942e-01f, 8.44924450e-02f, -1.24864960e-02f, 1.00455225e-01f, -1.69623986e-01f, -3.86763103e-02f,
  4.76674736e-02f, -8.28492865e-02f, -1.61444843e-01f, -1.00414447e-01f, 1.11748680e-01f, -1.79481227e-02f, -7.13724419e-02f, -1.31128833e-01f, -1.40262723e-01f, 7.32668191e-02f,
  7.19431192e-02f, 6.50750697e-02f, -5.47042787e-02f, 3.32108997e-02f, -7.18272775e-02f, 1.36130109e-01f, -4.23880443e-02f, 4.53924350e-02f, -5.35369515e-02f, 3.63129377e-02f,
  7.36264810e-02f, 8.03017244e-03f, -6.92255571e-02f, -4.59992625e-02f, -1.59418374e-01f, -2.33437493e-02f, 1.57476123e-02f, 5.22866510e-02f, -3.67822759e-02f, -8.69450867e-02f,
  1.35182753e-01f, 2.55733437e-04f, -5.18552698e-02f, -7.84491897e-02f, -2.21422035e-02f, 1.17536694e-01f, -1.13879927e-02f, -1.09167069e-01f, 8.41334686e-02f, -1.43625408e-01f,
  -1.17343232e-01f, 2.13733297e-02f, 1.24274120e-02f, 3.51720303e-02f, 1.21098988e-01f, 1.31970346e-01f, 9.48444456e-02f, 1.57805502e-01f, -4.77227159e-02f, 9.40901786e-02f,
  6.01314381e-02f, 2.34737843e-02f, -8.47941935e-02f, -2.85669584e-02f, -6.23588488e-02f, -3.13374363e-02f, -9.99848396e-02f, -1.69795126e-01f, 2.76267510e-02f, -1.24945275e-01f,
  -9.63892937e-02f, -1.44814178e-01f, -1.85265318e-02f, -4.48563695e-02f, -2.70160288e-02f, 6.40591756e-02f, -8.81873220e-02f, 7.82049149e-02f, -1.41794160e-01f, 8.58322456e-02f,
  8.03744793e-02f, 5.86011708e-02f, 6.41851500e-02f, 8.77904445e-02f, 2.45534378e-04f, -5.59033826e-03f, -6.58104420e-02f, 5.00669181e-02f, -1.67819299e-02f, -1.08377405e-01f,
  6.75330358e-03f, -2.71912515e-02f, -5.89435473e-02f, 1.22804880e-01f, 7.06789419e-02f, -9.46889147e-02f, 1.69455662e-01f, 5.48126362e-02f, 1.84985265e-01f, -6.25148267e-02f,
  1.60810977e-01f, -4.72521409e-02f, -8.70275423e-02f, 7.67663345e-02f, -9.99546126e-02f, -1.03805408e-01f, 5.37091307e-02f, 5.47691807e-02f, 1.46190412e-02f, -7.91262016e-02f,
  3.30729149e-02f, 1.08193636e-01f, -1.10489175e-01f, -4.31194082e-02f, 1.00506097e-01f, -1.21157706e-01f, 9.25628617e-02f, -1.18220367e-01f, -2.05628835e-02f, -2.41246089e-01f,
  2.18009911e-02f, -2.89273597e-02f, 9.28658620e-02f, -1.49143457e-01f, 3.29057798e-02f, 7.28330389e-02f, -6.21238686e-02f, 1.48337498e-01f, 6.32975847e-02f, 7.58296810e-03f,
  -2.87718251e-02f, 1.12598538e-01f, 4.68002222e-02f, 1.47230119e-01f, 1.12051636e-01f, -2.44878866e-02f, -1.72446892e-01f, 5.00178635e-02f, -1.26815382e-02f, -3.66358012e-02f,
  -1.20985202e-01f, 8.43684375e-02f, 9.95364785e-02f, 1.93386227e-02f, -1.64752100e-02f, -9.91874412e-02f, -1.27731562e-01f, 4.17403989e-02f, -1.12617880e-01f, -7.28896707e-02f,
  4.76316325e-02f, -6.06011562e-02f, -1.27754025e-02f, 9.16389897e-02f, -9.26288366e-02f, -1.88381560e-02f, 5.35534434e-02f, -1.08369768e-01f, 6.48301244e-02f, 7.91101810e-03f,
  -5.80425821e-02f, 6.24017231e-02f, -5.37151247e-02f, -9.68201309e-02f, 9.60272923e-02f, -2.67917793e-02f, 5.31632341e-02f, -9.52334609e-03f, 1.61470667e-01f, 6.71257973e-02f,
  1.21770509e-01f, -1.30222484e-01f, 6.23449720e-02f, 6.51493892e-02f, 8.94672945e-02f, 5.97783737e-02f, 2.03800648e-02f, -1.05909817e-01f, -9.47925320e-04f, 1.75561442e-03f,
  1.10223196e-01f, -9.49936882e-02f, 3.31879668e-02f, 7.24918917e-02f, -7.48138949e-02f, 1.15111195e-01f, 1.22607201e-02f, 1.13736831e-01f, -9.53333899e-02f, 1.12110876e-01f,
  -1.32391155e-01f, -1.27213702e-01f, 1.40805855e-01f, -1.51821554e-01f, -2.10340205e-03f, 1.58201382e-02f, -3.53629775e-02f, -1.81235313e-01f, -6.49624988e-02f, -4.38918732e-02f,
  8.89198296e-03f, 7.08288401e-02f, -2.84231771e-02f, -1.13984533e-01f, 4.78464402e-02f, -6.51722848e-02f, -3.33901048e-02f, -6.42996877e-02f, 4.16424051e-02f, -1.05201878e-01f,
  1.39889255e-01f, 3.70044149e-02f, -2.71092542e-02f, -1.09494388e-01f, -8.36869776e-02f, -1.37656331e-02f, -3.25726531e-02f, 6.49794564e-02f, 4.42985557e-02f, 1.18017510e-01f,
  5.84808178e-02f, 9.54118595e-02f, 2.08714698e-03f, 8.89092609e-02f, -1.17062278e-01f, 7.55226389e-02f, -2.77128741e-02f, 3.36405449e-02f, -1.31150052e-01f, 1.07952520e-01f,
  1.38058618e-01f, 1.12281591e-01f, -6.22326471e-02f, -2.56162696e-02f, 5.28287739e-02f, 6.94428906e-02f, 3.59112509e-02f, 9.04431567e-02f, -1.61350332e-02f, -1.60140432e-02f,
  4.57860865e-02f, 8.64212811e-02f, -7.58680888e-03f, 6.08525388e-02f, -1.75339326e-01f, 6.55581057e-02f, -6.13192655e-02f, 7.89283216e-02f, 1.83101431e-01f, -9.55340117e-02f,
  1.04870878e-01f, 4.64909747e-02f, -1.41969754e-03f, -1.68404803e-02f, 3.20801027e-02f, -8.82153064e-02f, 7.64952675e-02f, 5.13673574e-02f, 1.26171455e-01f, 3.27864811e-02f,
  6.89124465e-02f, 4.82198372e-02f, 1.02089113e-02f, -8.76967981e-02f, 1.40458792e-01f, -3.07980049e-02f, 6.55507445e-02f, -4.71739098e-02f, 1.40125975e-01f, 1.28978550e-01f,
  -1.41460020e-02f, 4.74269614e-02f, 1.00873522e-01f, 1.06550016e-01f, -8.62435997e-02f, 1.02177456e-01f, -1.19363070e-01f, 1.32873561e-02f, 1.60800591e-02f, -5.77048697e-02f,
  4.71809357e-02f, 2.09423024e-02f, 9.65330154e-02f, -2.06933171e-02f, -1.04215421e-01f, 8.03275630e-02f, -7.28185549e-02f, 3.71362306e-02f, -1.49861813e-01f, -1.52369842e-01f,
  -1.71110466e-01f, 3.32183242e-02f, -7.80983865e-02f, 5.05894721e-02f, 7.89465383e-02f, -1.26007214e-01f, 1.47814676e-01f, 8.72941762e-02f, -5.20303845e-02f, -6.05049767e-02f,
  4.17812541e-02f, 1.92248642e-01f, -3.45319021e-03f, -8.82486552e-02f, 2.74752197e-03f, 3.54247652e-02f, -1.60218194e-01f, 5.85421585e-02f, -2.34874740e-01f, 1.17205374e-01f,
  2.02732548e-01f, 1.12184294e-01f, -1.15979403e-01f, -9.43175182e-02f, 4.66727354e-02f, 6.07360527e-02f, 5.29897511e-02f, 6.16355464e-02f, 3.43272649e-02f, -1.62545055e-01f,
  -4.20366749e-02f, 1.97081435e-02f, 2.89441943e-02f, -1.82639942e-01f, 1.60846934e-01f, -6.35317042e-02f, 5.69739304e-02f, -1.18156813e-01f, 1.49850160e-01f, 1.28426641e-01f,
  -8.62976760e-02f, -1.40563771e-01f, -1.45038709e-01f, -1.18514173e-01f, -6.15634844e-02f, 2.69481223e-02f, 5.89834265e-02f, -1.13444068e-02f, -4.29486036e-02f, 6.91789910e-02f,
  1.41902491e-01f, -8.91001076e-02f, -5.25192842e-02f, 2.12418601e-01f, 9.72671732e-02f, -1.48694023e-01f, 1.15595207e-01f, -8.14852864e-02f, 8.35571960e-02f, -3.78490277e-02f,
  -1.22081064e-01f, 1.88804865e-01f, 9.44902673e-02f, 8.24364722e-02f, 1.03431687e-01f, 1.62853107e-01f, 2.12647885e-01f, -3.38424481e-02f, -5.46088517e-02f, 4.26545404e-02f,
  -1.10614836e-01f, -2.55609214e-01f, 1.72189139e-02f, 8.42068493e-02f, 6.40067533e-02f, -1.48182770e-03f, 1.68531194e-01f, 3.14006768e-02f, 1.36038400e-02f, -1.54726595e-01f,
  3.44393253e-02f, 5.37061458e-03f, 8.88170227e-02f, -3.12026173e-01f, 2.26660985e-02f, -5.63897155e-02f, -1.25356466e-01f, -2.58868426e-01f, 1.18485413e-01f, 4.81764637e-02f,
  -2.68238455e-01f, -7.04140738e-02f, -2.93425679e-01f, 2.67546535e-01f, 2.58047823e-02f, -6.03759773e-02f, 7.13339597e-02f, -5.25746755e-02f, 2.17734724e-02f, 3.15310836e-01f,
  9.25483406e-02f, 1.69185668e-01f, 5.43485321e-02f, -1.43999532e-01f, -1.81663111e-01f, 9.13512111e-02f, -1.50877804e-01f, 2.62602791e-02f, 1.41030967e-01f, -1.04000084e-01f,
  2.00010210e-01f, -1.87788397e-01f, 4.99114133e-02f, 1.09608084e-01f, 1.85414359e-01f, 1.09662756e-01f, 3.30930613e-02f, 1.01133965e-01f, -9.47370976e-02f, 7.69190192e-02f,
  -8.22639614e-02f, -5.01086041e-02f, -7.09256157e-02f, 4.15931195e-02f, -1.00198738e-01f, 2.27881908e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.41490251e-01f, 3.45901698e-02f, 1.25096902e-01f, 1.49601195e-02f, 7.03179240e-02f, 1.81931127e-02f, -6.00312389e-02f, 4.21632566e-02f, -7.79494718e-02f, -6.59735054e-02f,
  -6.23575225e-02f, 8.63547027e-02f, 4.81371135e-02f, -1.70742497e-02f, 6.99332580e-02f, 5.53872669e-03f, -4.89429682e-02f, 1.32061899e-01f, 1.29767105e-01f, -4.23830412e-02f,
  -6.13081008e-02f, 4.49510962e-02f, 5.91272116e-03f, 7.33847097e-02f, -8.65809396e-02f, -1.41134053e-01f, 1.60551257e-02f, -8.71404111e-02f, -5.24963737e-02f, -4.30357046e-02f,
  -4.12675440e-02f, -8.74722376e-02f, -5.49843907e-02f, -6.70643151e-03f, -8.65184218e-02f, 1.34281233e-01f, -1.12982310e-01f, 1.30095914e-01f, 5.68827018e-02f, -1.29953958e-02f,
  -4.92749177e-02f, 1.85334554e-03f, -7.72430375e-02f, 1.53997555e-01f, -3.19512077e-02f, 5.70236705e-02f, -6.04254156e-02f, 2.24330220e-02f, -6.72964603e-02f, 3.24725918e-02f,
  -2.91545205e-02f, -7.92089701e-02f, -6.01683892e-02f, 3.26437317e-02f, 1.22413009e-01f, -7.21997581e-03f, -2.42915899e-02f, 1.25102937e-01f, 9.59809646e-02f, -6.30526766e-02f,
  -6.59063682e-02f, 5.91171673e-03f, 7.36514479e-02f, -8.40869099e-02f, 1.03549026e-02f, 4.18151803e-02f, 1.10896736e-01f, 6.59565777e-02f, -1.24016339e-02f, 1.72074690e-01f,
  1.09509803e-01f, 1.28997015e-02f, 4.19777185e-02f, 5.10413870e-02f, 3.29233110e-02f, 9.65450704e-02f, 1.74562261e-01f, -6.66333064e-02f, 1.59915805e-01f, 6.96008950e-02f,
  1.31717116e-01f, 2.23260045e-01f, 1.85220987e-01f, 8.54415894e-02f, 1.94924980e-01f, 6.43405551e-03f, -6.88155591e-02f, -8.20596442e-02f, 5.61474040e-02f, -2.38435157e-02f,
  -3.92499007e-02f, -1.45197093e-01f, -7.36280829e-02f, -2.26550564e-01f, -1.08119898e-01f, -8.84678140e-02f, -8.89227018e-02f, 1.45967469e-01f, 1.72368377e-01f, 1.20342486e-01f,
  -9.52306688e-02f, 1.11061297e-01f, 9.77312326e-02f, 1.15736015e-01f, 4.12985645e-02f, 4.20080684e-02f, -7.60002956e-02f, 2.63924241e-01f, 8.77520964e-02f, 1.10201515e-01f,
  8.99217427e-02f, 5.06832488e-02f, -9.75668803e-02f, 4.61219102e-02f, -9.67428014e-02f, 6.57342970e-02f, 1.25298977e-01f, -1.27326369e-01f, 2.51011431e-01f, 7.80040249e-02f,
  -6.98404610e-02f, 1.20536074e-01f, 1.03100531e-01f, -1.23046048e-01f, -7.61795416e-02f, -8.93215984e-02f, 1.27467722e-01f, -5.30229956e-02f, 5.06888777e-02f, 9.45446268e-02f,
  1.09721899e-01f, 4.13712822e-02f, -1.05804078e-01f, -6.52210414e-02f, -7.50159547e-02f, 7.79347643e-02f, 8.00309330e-03f, -9.67247486e-02f, -4.05725352e-02f, 6.94225580e-02f,
  -2.80613806e-02f, 4.27549519e-02f, -7.58072957e-02f, 6.41494170e-02f, 8.49978104e-02f, 5.59271825e-03f, -3.20968078e-03f, 6.74610287e-02f, -3.69715989e-02f, 2.31316090e-02f,
  1.03687167e-01f, 4.02154997e-02f, -1.30306929e-01f, 4.24185134e-02f, 5.19897826e-02f, 2.10710820e-02f, 1.92896295e-02f, 6.99669048e-02f, 1.07050136e-01f, -1.14491314e-01f,
  -1.33614153e-01f, -3.31814401e-02f, -4.81939130e-02f, 5.70128970e-02f, -1.99434347e-02f, 9.19665247e-02f, 4.90421336e-03f, -6.24289736e-02f, -8.29888061e-02f, -4.76491153e-02f,
  3.30097452e-02f, -1.27228955e-02f, -8.07881877e-02f, 8.74908790e-02f, -3.44787538e-02f, 1.08837545e-01f, -6.34255856e-02f, 1.20581277e-02f, -4.81874868e-02f, -6.34694174e-02f,
  1.19033515e-01f, -1.46384295e-02f, 2.42666062e-02f, 9.16805118e-03f, -9.76077467e-02f, -7.61945471e-02f, -1.40078953e-02f, -6.50489852e-02f, -3.63660678e-02f, 7.42375255e-02f,
  8.15505907e-02f, 1.18729487e-01f, -7.99098164e-02f, 9.92658287e-02f, -1.02118112e-01f, 8.26870501e-02f, -1.12843346e-02f, -1.33777618e-01f, 2.46384293e-02f, 7.49445483e-02f,
  -3.75251509e-02f, -1.34025112e-01f, -1.25406319e-02f, 3.05334129e-03f, -8.41792673e-02f, -1.22857690e-02f, -3.85574885e-02f, 6.18125200e-02f, -7.18274713e-03f, 4.49553505e-03f,
  -2.74373144e-02f, -5.12527786e-02f, -6.81838319e-02f, 1.20204069e-01f, -2.43496504e-02f, 5.57259582e-02f, 1.43299535e-01f, 1.22270621e-01f, 7.21455142e-02f, -1.06345549e-01f,
  -1.09818846e-01f, -1.38013631e-01f, -7.58597702e-02f, 1.12520643e-01f, 1.22413374e-01f, -9.28853080e-02f, -6.97061867e-02f, -2.68834364e-02f, -1.20673902e-01f, -8.99396762e-02f,
  8.13340470e-02f, 1.13404989e-02f, 5.61767295e-02f, -1.53556550e-02f, 9.92781892e-02f, 1.34985344e-02f, 2.85051912e-02f, 6.56521786e-03f, 1.30687296e-01f, -1.07004434e-01f,
  2.27193697e-03f, -4.17009816e-02f, 3.26251350e-02f, 1.04345940e-01f, 9.84947905e-02f, 5.38334437e-02f, 7.74644911e-02f, -2.19313987e-02f, -9.10942852e-02f, -2.43178420e-02f,
  7.87495151e-02f, 2.68747602e-02f, -1.17736936e-01f, 1.04824461e-01f, 8.04968923e-02f, 2.43724938e-02f, -1.36260673e-01f, 6.72896802e-02f, 5.16125523e-02f, 4.70952354e-02f,
  5.31117879e-02f, -1.15409292e-01f, -4.12518717e-02f, 2.36042961e-02f, 5.73265553e-02f, -2.44536866e-02f, -2.59115137e-02f, -4.16675657e-02f, -1.20017678e-01f, -7.05077276e-02f,
  -4.94348407e-02f, -8.20141211e-02f, 2.71994751e-02f, -1.91218464e-03f, -1.25019804e-01f, 6.80826083e-02f, 2.75678351e-04f, 2.52613910e-02f, 1.90330017e-02f, -1.80015713e-02f,
  -2.46248599e-02f, 6.83522448e-02f, 7.77939111e-02f, -1.00703321e-01f, 6.18967861e-02f, 9.88373347e-03f, -1.07549183e-01f, 1.09521961e-02f, -3.30857672e-02f, -1.41532468e-02f,
  1.03458151e-01f, -9.98260826e-03f, 7.70377964e-02f, 4.21188362e-02f, 2.70183198e-02f, -5.54314516e-02f, 4.25899811e-02f, -7.43384138e-02f, 1.19041868e-01f, 3.53949331e-02f,
  3.63046378e-02f, 3.92090855e-03f, 2.06206683e-02f, 7.45298713e-02f, -1.22915812e-01f, -9.31540802e-02f, -7.90431127e-02f, 5.06533757e-02f, -4.63759489e-02f, 6.28114045e-02f,
  -5.24223708e-02f, -8.12992975e-02f, -9.25491378e-02f, 1.09005354e-01f, 1.99719667e-02f, -9.07293186e-02f, -1.09416723e-01f, -9.87940580e-02f, 1.14464298e-01f, -3.24698314e-02f,
  4.38860245e-02f, 2.87816138e-03f, 8.23671371e-02f, 4.13428955e-02f, 8.67423601e-03f, 1.39595151e-01f, 1.93083391e-01f, 2.09775060e-01f, 9.45696011e-02f, 2.94455588e-01f,
  1.84951365e-01f, -2.02647485e-02f, 1.26455292e-01f, 3.31433624e-01f, 1.24421664e-01f, 9.09273177e-02f, 2.04488605e-01f, 1.17564529e-01f, 1.02810040e-01f, 2.41574142e-02f,
  -9.30564031e-02f, 9.17359740e-02f, -3.28470469e-02f, 4.77555357e-02f, -1.83429345e-01f, 1.46292225e-01f, 1.53853735e-02f, 7.45096654e-02f, -9.72312130e-03f, 2.35191546e-02f,
  2.11689934e-01f, -2.84631718e-02f, 5.18237101e-03f, -4.78854179e-02f, -1.12456515e-01f, -1.01695076e-01f, 1.42771304e-01f, -1.58265531e-01f, -1.31755084e-01f, 1.08010203e-01f,
  4.52469029e-02f, 5.69873825e-02f, 2.28606582e-01f, -1.07787505e-01f, 7.47810751e-02f, -4.56413217e-02f, -4.36087325e-02f, 6.83769211e-02f, 1.17130112e-02f, 2.97445320e-02f,
  1.62176102e-01f, -1.17512450e-01f, 6.48794174e-02f, -1.28456548e-01f, -4.11755592e-02f, -1.10110650e-02f, -3.91660966e-02f, 5.22236452e-02f, -1.05032243e-01f, -2.03105845e-02f,
  5.46227172e-02f, 1.49180859e-01f, -4.82386090e-02f, -1.81168661e-01f, 3.16091068e-02f, 1.47266723e-02f, -2.38832645e-02f, -5.87953180e-02f, -1.67673901e-02f, -6.36327192e-02f,
  7.10892975e-02f, 1.34431630e-01f, -4.32570539e-02f, -5.50281256e-02f, 1.14334457e-01f, 8.20276588e-02f, -5.16283773e-02f, 4.18182611e-02f, 9.22133848e-02f, 6.23371592e-03f,
  7.04962239e-02f, 1.39792532e-01f, 3.31356190e-02f, 4.88104187e-02f, -6.35887906e-02f, 8.51757005e-02f, 1.22228503e-01f, 1.33024186e-01f, 1.25049397e-01f, -1.25126690e-02f,
  -8.42561051e-02f, -5.30641750e-02f, 5.40173985e-02f, -4.78024445e-02f, -1.04702011e-01f, -1.51053831e-01f, 2.41425005e-03f, 1.18702099e-01f, -1.83370039e-02f, -8.82703960e-02f,
  -5.72781824e-02f, -2.97794864e-02f, -3.37375253e-02f, 5.54899946e-02f, 1.74099416e-01f, 1.33929580e-01f, 1.02662653e-01f, 3.89230475e-02f, 1.57970022e-02f, -9.42653716e-02f,
  -1.66301634e-02f, -1.17485993e-01f, 8.49608332e-02f, -1.08963968e-02f, -4.64411154e-02f, 8.30938369e-02f, -6.36857152e-02f, 4.87515219e-02f, -2.83337402e-04f, -5.77920265e-02f,
  -5.45698069e-02f, 9.52526107e-02f, 5.37841618e-02f, 5.93042597e-02f, -2.97200475e-02f, -8.59141424e-02f, 6.14795908e-02f, 1.04773365e-01f, 1.53342560e-01f, 8.13705772e-02f,
  1.52614132e-01f, 1.15201876e-01f, -3.40371281e-02f, -6.58993050e-02f, 5.31624742e-02f, -1.86916329e-02f, -1.96884703e-02f, -9.05568525e-03f, 1.48493126e-01f, 1.15629725e-01f,
  -4.67716753e-02f, -1.27833620e-01f, -1.07422262e-01f, 2.36370079e-02f, -3.87627594e-02f, 7.55674019e-02f, -3.99062559e-02f, -3.11942995e-02f, -1.29217282e-01f, 1.09395288e-01f,
  -1.74053665e-02f, -4.49767197e-03f, -7.30601922e-02f, -4.14275080e-02f, 1.19193658e-01f, -7.12286383e-02f, -6.37582913e-02f, 2.93097999e-02f, 2.15395838e-02f, -3.97849157e-02f,
  6.36277497e-02f, 1.38520837e-01f, 7.69034997e-02f, 7.54953548e-02f, 6.51784688e-02f, -1.04042590e-01f, -7.21962526e-02f, 8.07924941e-02f, 1.07124165e-01f, -1.32071711e-02f,
  -1.69944242e-02f, 4.91362140e-02f, 5.32907024e-02f, 1.14766955e-01f, -7.39352480e-02f, -3.54973450e-02f, -1.04735442e-01f, 1.39697984e-01f, -4.66671847e-02f, -8.13489929e-02f,
  -1.61682535e-02f, -9.43083689e-02f, 1.13671556e-01f, -1.96433980e-02f, 7.05720261e-02f, 1.05241247e-01f, -2.00014096e-02f, -1.00407250e-01f, 7.89285675e-02f, 4.40142229e-02f,
  8.54520649e-02f, -2.31722705e-02f, 1.60051301e-01f, -3.58614959e-02f, -5.68892062e-02f, 1.59294426e-01f, 1.04046352e-01f, -7.01721981e-02f, -5.55442236e-02f, -4.41270396e-02f,
  1.46809101e-01f, -5.74897416e-02f, -8.14748034e-02f, -5.22015840e-02f, 2.74498183e-02f, 1.36996970e-01f, 1.74556255e-01f, 1.36452287e-01f, 2.00586743e-03f, 4.65677083e-02f,
  6.77077100e-02f, 1.13255888e-01f, 1.08719900e-01f, -9.72071365e-02f, 1.39166182e-02f, -4.16010581e-02f, -1.79431871e-01f, -1.09942742e-02f, 1.01991430e-01f, 5.55601940e-02f,
  -9.83734131e-02f, 2.19636392e-02f, -3.09324116e-02f, -2.31424309e-02f, -1.02960750e-01f, 1.23744093e-01f, 1.85949393e-02f, 1.46615818e-01f, 1.02792360e-01f, 2.30072271e-02f,
  7.18194991e-02f, 1.19076997e-01f, 1.60097051e-02f, -1.45487592e-01f, -1.08737595e-01f, 7.23218769e-02f, 7.64082838e-03f, -8.17591622e-02f, -5.70342578e-02f, 8.22440386e-02f,
  1.01088069e-01f, -1.30503729e-01f, 1.16617605e-01f, -5.10821566e-02f, -9.57502350e-02f, 4.56243344e-02f, 1.47055024e-02f, 5.52939577e-03f, 6.62772134e-02f, -9.69465300e-02f,
  1.57048665e-02f, -2.04449594e-02f, 1.40307527e-02f, 1.23966418e-01f, 4.76886444e-02f, -9.95705351e-02f, -7.40184262e-02f, -1.04201138e-01f, -1.00666367e-01f, -6.16346160e-03f,
  3.81474234e-02f, -9.69480500e-02f, -8.93067718e-02f, -9.78959277e-02f, -2.55159661e-02f, 6.17390685e-02f, -1.07904010e-01f, -3.62057723e-02f, 7.33315051e-02f, 6.33691847e-02f,
  -1.14558958e-01f, 2.12940965e-02f, -7.87354335e-02f, -2.40462273e-02f, -8.93437862e-02f, 1.04891974e-02f, -1.17577992e-01f, 4.71146740e-02f, -1.21380068e-01f, -1.34322912e-01f,
  -9.46043804e-02f, 1.04333930e-01f, 7.30802417e-02f, -1.22552022e-01f, -3.13658342e-02f, -1.17547594e-01f, -1.00189023e-01f, -7.90520906e-02f, 9.67322513e-02f, 1.03695661e-01f,
  -1.00873746e-01f, 1.13999382e-01f, -9.70118269e-02f, 1.28660321e-01f, 7.57629424e-02f, -1.12037823e-01f, 1.00377113e-01f, -3.16337100e-03f, -7.11437464e-02f, -5.71704097e-02f,
  2.89631505e-02f, -1.06373891e-01f, -3.59163284e-02f, -1.08549111e-01f, 2.30901819e-02f, -5.98975345e-02f, -8.42332616e-02f, -8.51851627e-02f, -2.47029308e-03f, 8.48476961e-02f,
  5.59641868e-02f, -1.17981238e-02f, -2.72203377e-03f, -6.21222295e-02f, -1.20285824e-01f, -2.35887859e-02f, 7.96186849e-02f, -9.87607986e-02f, -9.09295306e-02f, 9.80727598e-02f,
  3.20132300e-02f, -7.66183063e-02f, 4.23771404e-02f, 1.14332430e-01f, 5.18081784e-02f, 6.70681968e-02f, -3.64180654e-02f, 2.47130860e-02f, 4.82422151e-02f, 8.89527202e-02f,
  1.21528566e-01f, -6.62140772e-02f, 1.19208604e-01f, 1.56905621e-01f, -7.50906989e-02f, 9.25171450e-02f, -1.88380238e-02f, -5.37477769e-02f, 7.75443912e-02f, -4.03224975e-02f,
  -1.25566393e-01f, 3.45627964e-02f, -9.71711129e-02f, 3.84406932e-02f, 3.61659080e-02f, -5.97049408e-02f, -5.15986681e-02f, 1.01012982e-01f, 1.01499803e-01f, 2.07555387e-03f,
  -4.54813354e-02f, 1.28209576e-01f, -1.40282780e-01f, 3.42246052e-03f, -1.17394410e-01f, -7.94363022e-02f, -5.37727326e-02f, -7.49467388e-02f, -1.42399430e-01f, -2.34470181e-02f,
  8.03493038e-02f, 5.97624155e-03f, -8.97377555e-04f, -2.31667385e-02f, -1.31083608e-01f, -3.06157600e-02f, -9.08304900e-02f, 3.39495353e-02f, 3.18378545e-02f, -3.77988368e-02f,
  1.38724536e-01f, -1.22778244e-01f, 4.86974157e-02f, -4.56744581e-02f, -1.34711295e-01f, 2.91816685e-02f, 9.99709666e-02f, -7.53816217e-02f, 4.63073440e-02f, -3.92919183e-02f,
  1.37477264e-01f, 1.45359337e-02f, -1.34764081e-02f, -6.86619878e-02f, -1.23788811e-01f, -4.38667014e-02f, -8.37745592e-02f, -1.16741985e-01f, 1.16704412e-01f, -3.37109081e-02f,
  -8.24647993e-02f, 7.57233351e-02f, 1.15032174e-01f, 4.66862209e-02f, 9.03361365e-02f, 9.25467163e-02f, -7.37853209e-03f, 4.50963825e-02f, -7.80395567e-02f, -2.96613388e-03f,
  8.04561302e-02f, 1.98057555e-02f, -9.20223147e-02f, 9.45175514e-02f, 4.36261855e-02f, -6.40694797e-02f, 4.19164496e-03f, 6.73068240e-02f, -3.34009789e-02f, 4.18100469e-02f,
  -4.75187786e-02f, 1.51499480e-01f, 1.05746888e-01f, 6.64308369e-02f, -6.06085137e-02f, -1.21952355e-01f, 1.53322723e-02f, -1.67524025e-01f, -8.98548737e-02f, -7.29484484e-02f,
  -4.68429364e-02f, -1.69881821e-01f, -7.16119483e-02f, 1.71622653e-02f, 2.22787950e-02f, -4.85378467e-02f, 9.33081880e-02f, 1.06653403e-02f, -1.31757468e-01f, 8.94172341e-02f,
  6.40436113e-02f, -9.77957472e-02f, 7.58073339e-03f, 1.18161380e-01f, -2.18898430e-02f, -1.17045142e-01f, -2.94500254e-02f, -8.91714990e-02f, 7.22459778e-02f, -4.56829295e-02f,
  1.29989805e-02f, -6.61369041e-03f, 1.10531814e-01f, 7.35210925e-02f, 4.79376722e-05f, 1.51754990e-01f, -3.22773866e-02f, 8.78865868e-02f, -2.76831649e-02f, -5.21069989e-02f,
  -3.59346345e-02f, 4.68680337e-02f, -7.75380433e-02f, -9.28657204e-02f, -1.79415755e-02f, -4.55321930e-02f, -6.12543188e-02f, 9.02311727e-02f, 1.09613203e-01f, -2.87664291e-02f,
  1.38769507e-01f, 2.06280183e-02f, -6.36386275e-02f, 1.19756944e-01f, 6.12343438e-02f, 8.35947245e-02f, 8.92375186e-02f, -1.80607945e-01f, 1.65574506e-01f, 8.03239495e-02f,
  3.75594124e-02f, -1.03199750e-01f, 6.77860677e-02f, 5.83305284e-02f, 6.50404170e-02f, 1.28495529e-01f, -2.68078484e-02f, 7.93915391e-02f, -1.46964163e-01f, 9.77947339e-02f,
  3.58806215e-02f, -1.90092340e-01f, 8.19959193e-02f, -5.74361607e-02f, -4.92915623e-02f, -1.14544481e-01f, 9.05791670e-02f, -9.32416096e-02f, 1.09760582e-01f, 7.61177912e-02f,
  -7.15526417e-02f, -6.27924725e-02f, -4.31471691e-02f, -1.08052194e-01f, -2.40718313e-02f, 4.89854580e-03f, 5.46188429e-02f, -1.05756544e-01f, -6.56641424e-02f, -3.04184612e-02f,
  5.31805120e-02f, 1.37429601e-02f, -3.30889486e-02f, 4.56525311e-02f, -3.83632034e-02f, -4.70367782e-02f, 6.62856102e-02f, 2.31680330e-02f, -3.19899991e-02f, 1.33358151e-01f,
  1.01101272e-01f, -1.03563845e-01f, 9.04475451e-02f, -1.44708171e-01f, -1.00570790e-01f, 7.41564855e-02f, -1.02907255e-01f, 8.88699591e-02f, 9.00698528e-02f, 7.45603889e-02f,
  2.86051817e-02f, 1.34921953e-01f, -7.21444981e-03f, -2.89171729e-02f, 5.29754274e-02f, 2.40865320e-01f, 1.28795534e-01f, -3.99173833e-02f, 6.21603951e-02f, 1.34037971e-01f,
  1.03075877e-01f, 1.51211783e-01f, 4.77438159e-02f, 1.79761574e-01f, -1.53747909e-02f, 1.15764849e-01f, -1.81701556e-01f, 2.47868355e-02f, -4.85369228e-02f, -4.77697290e-02f,
  -1.07014097e-01f, 8.25124457e-02f, 1.66904554e-01f, -4.33909781e-02f, -1.16836436e-01f, -1.78885967e-01f, -5.20943925e-02f, -1.17853694e-01f, 3.63582112e-02f, -2.03845143e-01f,
  -1.19434699e-01f, -7.51209259e-02f, 1.24203630e-01f, -1.95860420e-03f, 1.08750410e-01f, 8.26241821e-02f, -6.95084706e-02f, 6.78307265e-02f, 3.43207307e-02f, 9.84400362e-02f,
  -1.25518307e-01f, 4.00544843e-03f, -1.29528074e-02f, 5.98334055e-03f, 1.15368687e-01f, 4.73172031e-02f, -9.29450151e-03f, -3.69942598e-02f, 8.91436785e-02f, -8.04186314e-02f,
  -2.35011871e-03f, -1.13043383e-01f, 5.85312173e-02f, 4.74562012e-02f, -4.71940786e-02f, -2.81115882e-02f, 5.07869981e-02f, 1.03059141e-02f, -7.00980797e-02f, 5.84288724e-02f,
  4.61183451e-02f, 1.46993631e-02f, 1.28464438e-02f, 1.73730344e-01f, -5.26741222e-02f, -5.23615628e-02f, 6.53673261e-02f, 1.06505521e-01f, 1.48038432e-01f, 1.27070621e-01f,
  5.78525513e-02f, 1.07638396e-01f, -1.71201453e-02f, 1.17635153e-01f, 1.23764656e-01f, -6.26909882e-02f, 1.33670703e-01f, -1.76906809e-01f, 7.81159475e-02f, 1.31348982e-01f,
  -1.04827471e-01f, -7.64561892e-02f, -3.91187482e-02f, 2.03251630e-01f, 4.95365867e-03f, 2.37381132e-03f, 1.99415106e-02f, -2.45383326e-02f, 6.32427558e-02f, -5.09282202e-02f,
  -9.25382897e-02f, 1.18288901e-02f, 1.83061063e-01f, 3.22371051e-02f, -1.28207430e-01f, 1.04716629e-01f, -3.50136571e-02f, -1.37041807e-01f, -1.16578512e-01f, 3.21107991e-02f,
  -2.50034388e-02f, -3.47735174e-02f, -4.76306528e-02f, -1.27519876e-01f, 1.66782647e-01f, -8.72410685e-02f, 1.38107613e-01f, -1.22445514e-02f, 1.08028643e-01f, -6.39049932e-02f,
  -8.69160295e-02f, -1.70671400e-02f, -4.55934927e-02f, 7.02599436e-02f, -7.82942623e-02f, -1.12427458e-01f, 6.68407679e-02f, 1.19520850e-01f, -7.12849796e-02f, -2.06010826e-02f,
  -5.00676744e-02f, 1.20802289e-02f, -1.45950159e-02f, 9.78991389e-02f, 4.49655056e-02f, 3.06342309e-03f, 1.12479076e-01f, -5.74442074e-02f, -5.44148870e-03f, -1.12079322e-01f,
  6.20962344e-02f, -3.95592302e-02f, -1.08203702e-01f, -6.22263104e-02f, -2.48989160e-03f, -7.36566484e-02f, -9.00639668e-02f, 5.13358675e-02f, -9.67850313e-02f, 5.09139076e-02f,
  -1.06109440e-01f, 3.60462815e-02f, 5.27540594e-02f, -2.47102994e-02f, -3.37698460e-02f, 5.68696335e-02f, 4.72187176e-02f, 7.62625337e-02f, -9.48298723e-02f, -8.91325176e-02f,
  8.23205113e-02f, 3.78038734e-02f, -1.09769449e-01f, 6.84677437e-02f, 7.21457452e-02f, 6.31004646e-02f, -1.02998137e-01f, -9.08382386e-02f, -9.64877978e-02f, -5.33102527e-02f,
  -3.47380005e-02f, -5.80517016e-03f, -2.99552418e-02f, -8.21677595e-02f, 1.28153255e-02f, 1.10915363e-01f, -1.79981533e-02f, -2.83362735e-02f, 1.12159736e-01f, 4.18844353e-03f,
  -6.08598627e-02f, 1.44329695e-02f, 1.14437938e-01f, 8.99263546e-02f, 1.13512501e-01f, -2.03516353e-02f, 1.18043803e-01f, 8.87427200e-03f, -1.22717410e-01f, -3.42554860e-02f,
  -1.49506768e-02f, 7.36701787e-02f, 1.19950756e-01f, -1.18825510e-01f, -1.33566512e-02f, 9.43595767e-02f, 9.73666012e-02f, -3.09814084e-02f, 1.85645353e-02f, -2.09603366e-02f,
  -1.13357648e-01f, -1.54813593e-02f, -4.73917350e-02f, 7.26160705e-02f, 1.21646658e-01f, 1.01021565e-02f, 7.81273097e-02f, 5.75080290e-02f, 8.37361664e-02f, -6.88771829e-02f,
  -9.76198614e-02f, -8.52537602e-02f, -1.07805483e-01f, -6.24403618e-02f, -2.28544418e-02f, 4.86284234e-02f, -8.10234919e-02f, -1.32309496e-02f, -1.16834953e-01f, -7.13739544e-02f,
  9.62060839e-02f, 1.09694980e-01f, -6.16144240e-02f, 6.28913343e-02f, 5.26164845e-02f, -2.57648509e-02f, -2.80522741e-02f, -1.20380111e-01f, 1.03524268e-01f, -1.52791739e-02f,
  -5.86962774e-02f, -9.63568613e-02f, -1.19374834e-01f, 1.41428396e-01f, -9.56198946e-02f, -1.05386294e-01f, 6.56298548e-02f, 9.30509064e-03f, -5.53642884e-02f, -8.88761953e-02f,
  1.20957883e-03f, -8.89684167e-03f, -2.68474724e-02f, -1.06209993e-01f, -5.13346456e-02f, 5.56497276e-02f, 8.76739770e-02f, 6.24862313e-02f, 5.44601902e-02f, 9.32726413e-02f,
  1.21634819e-01f, -4.16934006e-02f, 1.15561515e-01f, -3.52188610e-02f, -2.54575294e-02f, 2.20054630e-02f, 1.75166745e-02f, 6.95407018e-02f, -5.60875796e-02f, 6.67348853e-04f,
  -8.82848948e-02f, -1.01439189e-02f, -3.19800675e-02f, 6.76109269e-02f, 6.32174537e-02f, -7.72808641e-02f, -6.93912655e-02f, 6.75414726e-02f, 1.23044044e-01f, 2.98410244e-02f,
  1.06307469e-01f, 6.95817098e-02f, 5.67594506e-02f, -3.30230258e-02f, 7.08452091e-02f, 1.22779243e-01f, 8.50134268e-02f, -4.36667390e-02f, 1.54189274e-01f, 1.08744344e-02f,
  1.97063889e-02f, -1.29618332e-01f, -9.11162794e-02f, -9.37241167e-02f, -1.06902584e-01f, -5.77972978e-02f, -1.30000830e-01f, -1.05349809e-01f, -3.78036164e-02f, 1.23209991e-01f,
  -8.28355923e-02f, 8.16587508e-02f, 5.60858026e-02f, -1.03989318e-02f, -9.07204300e-02f, 1.47075444e-01f, 6.64998367e-02f, -4.00513485e-02f, -7.33852834e-02f, 8.71844515e-02f,
  -8.71751085e-02f, -3.55303995e-02f, -9.50307697e-02f, -5.68950176e-02f, 1.47076607e-01f, -9.23032984e-02f, -1.28786759e-02f, -3.70790809e-02f, -8.98343548e-02f, -3.54959294e-02f,
  1.20157357e-02f, -1.32976443e-01f, 1.15990788e-01f, -9.77332592e-02f, 4.65199724e-02f, 9.19190794e-03f, 8.33313912e-02f, 9.49453637e-02f, 7.24012870e-03f, -7.40880445e-02f,
  8.30743089e-02f, 3.35528217e-02f, 3.31771225e-02f, 4.23246361e-02f, 1.01841561e-01f, 2.13517368e-01f, 2.15305656e-01f, 8.88382420e-02f, 2.78144497e-02f, 2.44653732e-01f,
  1.28459990e-01f, 9.43101794e-02f, 1.58221290e-01f, 4.49919291e-02f, 1.29237667e-01f, 2.57245064e-01f, 2.76444972e-01f, 2.34937802e-01f, 1.57234743e-01f, -7.39289671e-02f,
  1.90191776e-01f, 5.40659428e-02f, 2.55486611e-02f, -5.05909622e-02f, 1.96910083e-01f, 8.80045444e-02f, -2.63972610e-01f, -1.09246567e-01f, 1.92735225e-01f, 2.26876885e-01f,
  -3.71466219e-01f, -8.89717415e-02f, -1.90976545e-01f, 1.88789770e-01f, -3.77746709e-02f, -1.65496811e-01f, 6.48333803e-02f, -1.34981319e-01f, 2.13694975e-01f, 2.26649374e-01f,
  4.32194211e-02f, 2.45730281e-01f, -1.03998128e-02f, -1.47572175e-01f, 4.70881984e-02f, -1.30667746e-01f, 3.89079819e-03f, -1.64143667e-01f, 6.77391589e-02f, -9.73891243e-02f,
  -5.79218045e-02f, -4.97328490e-02f, 1.11916795e-01f, 1.48815140e-01f, 4.52412851e-02f, 1.00965828e-01f, -1.07021958e-01f, 2.64393669e-02f, -1.02038428e-01f, 3.35545167e-02f,
  -1.06964752e-01f, -3.40950526e-02f, -6.11441731e-02f, 9.90665480e-02f, 1.44169971e-01f, 1.95164204e-01f, -1.06771745e-01f, -9.58806053e-02f, 1.38218582e-01f, 1.15051486e-01f,
  5.28673381e-02f, 1.13507330e-01f, 1.13753043e-01f, -1.02668405e-01f, 1.03748245e-02f, -6.68252539e-03f, 1.08337812e-01f, -1.01299264e-01f, -5.15634120e-02f, 3.63074034e-03f,
  -7.73090348e-02f, 3.71385552e-02f, -9.58894864e-02f, -9.85135324e-03f, -5.58496378e-02f, -4.81910892e-02f, -5.24784066e-02f, -3.56470495e-02f, -7.49431327e-02f, 3.79558690e-02f,
  1.27973696e-02f, -1.28663555e-01f, -1.07630961e-01f, 7.32573494e-02f, 4.84570414e-02f, 3.89054492e-02f, 2.44586635e-02f, 1.09879533e-02f, -1.07838362e-01f, -7.84796551e-02f,
  -6.57972246e-02f, -4.56632003e-02f, 1.03409864e-01f, -5.97933889e-04f, -4.00361717e-02f, -1.05027676e-01f, -1.18933283e-01f, -8.61988813e-02f, -8.76733661e-02f, -1.23335741e-01f,
  3.89247350e-02f, -7.86853135e-02f, 2.92686410e-02f, 8.84737745e-02f, 1.36036322e-01f, 7.27336705e-02f, -3.59421223e-02f, 1.28343254e-01f, 6.92656189e-02f, 1.21974126e-01f,
  -1.00137852e-02f, 4.30230424e-02f, 9.05719399e-02f, 9.20099095e-02f, -3.52614336e-02f, -2.69800564e-03f, 7.15540498e-02f, -1.16775297e-02f, 2.62233987e-02f, 3.42464410e-02f,
  -5.44369109e-02f, 1.83511972e-02f, 1.01783738e-01f, 3.52811404e-02f, 8.17056820e-02f, -7.62971342e-02f, 1.61089659e-01f, 1.06168531e-01f, -1.11590579e-01f, 1.04627319e-01f,
  1.33278653e-01f, -2.16243062e-02f, 1.03240706e-01f, -1.15434825e-02f, -1.08326115e-01f, 6.77171499e-02f, 7.31957257e-02f, 9.11245868e-02f, 4.69248332e-02f, -1.26036435e-01f,
  -6.86630979e-02f, -4.52971198e-02f, 1.21318661e-01f, -1.42609507e-01f, 1.13593839e-01f, 1.51564494e-01f, 1.61030777e-02f, 6.77101910e-02f, 1.42280236e-01f, 1.67654693e-01f,
  2.97663826e-02f, -9.16593522e-02f, 1.53473139e-01f, -1.55610979e-01f, -7.79373422e-02f, 3.31574008e-02f, -4.39931974e-02f, 4.81834188e-02f, 3.44680585e-02f, 1.19207683e-03f,
  -1.48136809e-01f, 1.41864493e-02f, -6.75356667e-03f, 4.53527905e-02f, 5.12750149e-02f, 3.58865038e-02f, -4.28435132e-02f, 4.96835448e-02f, 5.63426018e-02f, -3.66142578e-02f,
  -8.06669146e-02f, 8.60448256e-02f, -1.15121700e-01f, 8.49965960e-03f, 6.16597533e-02f, 5.79048023e-02f, 3.41636725e-02f, 9.77438092e-02f, -9.23537686e-02f, -3.77507624e-03f,
  9.48991328e-02f, 1.16148621e-01f, -1.28199622e-01f, -4.53277752e-02f, -6.93577752e-02f, -8.80609825e-02f, 8.34452957e-02f, 8.53670463e-02f, -5.95544539e-02f, -1.01981238e-01f,
  -1.01606563e-01f, -8.37890804e-02f, -8.49409774e-02f, 8.63067210e-02f, 8.49486217e-02f, -1.07711427e-01f, 4.50738110e-02f, 3.92284878e-02f, 8.54905248e-02f, -1.20458547e-02f,
  1.32122263e-01f, 1.14030682e-01f, -4.96538840e-02f, -5.31819053e-02f, -4.00071889e-02f, 7.89659098e-02f, 1.37951463e-01f, 4.18760329e-02f, 8.74232501e-02f, 3.25091891e-02f,
  -7.31194392e-04f, 6.53713122e-02f, -3.96152213e-02f, -1.63279437e-02f, -8.47199485e-02f, -6.18246906e-02f, 2.87137143e-02f, -1.54491842e-01f, 9.17386785e-02f, 1.34410694e-01f,
  6.06015883e-02f, 5.08521050e-02f, 3.88406031e-02f, 8.89406204e-02f, -5.88265434e-02f, 9.53981653e-03f, 2.98775565e-02f, 9.90450978e-02f, 1.03319034e-01f, -2.31784163e-03f,
  -7.68506378e-02f, -9.80157107e-02f, 7.14651868e-02f, 2.57395934e-02f, 6.45924956e-02f, -6.46374151e-02f, -1.30308822e-01f, -1.35387346e-01f, 7.05843791e-02f, -1.06739648e-01f,
  4.69261706e-02f, -3.55429873e-02f, -3.41827832e-02f, 9.34974775e-02f, -9.89525616e-02f, -9.61601958e-02f, 7.81588256e-02f, 5.99188246e-02f, 1.82467595e-01f, 7.15393573e-02f,
  2.22806931e-01f, 1.61267236e-01f, -5.96083552e-02f, 2.52725780e-01f, 1.88187078e-01f, 4.24074158e-02f, 1.36878431e-01f, 1.41244978e-01f, 1.10216744e-01f, 1.31707728e-01f,
  1.76811107e-02f, -1.25792697e-01f, 9.01095793e-02f, 2.15247035e-01f, 1.70971215e-01f, 1.37295723e-01f, 1.52352139e-01f, -1.29334003e-01f, -8.96212906e-02f, 8.86256061e-03f,
  -2.21679494e-01f, -7.20177889e-02f, 2.12417156e-01f, 7.98677653e-02f, -7.16667995e-02f, -2.14855209e-01f, 5.64185455e-02f, 6.25712285e-03f, 6.11607246e-02f, -5.39155491e-02f,
  1.35032415e-01f, 1.60158217e-01f, -2.10479386e-02f, 1.14496619e-01f, -9.07173827e-02f, 6.23175874e-03f, 1.23038016e-01f, -1.61265939e-01f, -9.22869146e-02f, -3.93905193e-02f,
  -4.08972660e-03f, 2.22521946e-01f, 5.69553785e-02f, 1.19793095e-01f, 1.02854017e-02f, 5.86785376e-02f, 1.29588977e-01f, 1.95175156e-01f, -1.11016773e-01f, 5.18497266e-02f,
  -5.56655377e-02f, -8.22530612e-02f, 9.66521725e-02f, 8.35506022e-02f, 1.07331708e-01f, 1.78913772e-01f, -7.50724077e-02f, -2.01754160e-02f, 9.14816931e-02f, 3.59920785e-02f,
  -5.16165234e-02f, 6.15360998e-02f, 2.45964937e-02f, 1.66527793e-01f, 2.85848957e-02f, 8.63493234e-02f, 1.09499946e-01f, -8.89492631e-02f, 1.82314336e-01f, 3.81927495e-03f,
  1.25141248e-01f, 1.64580077e-01f, 1.56159997e-01f, 1.13548063e-01f, -7.89396465e-02f, -1.44023955e-01f, -6.91215172e-02f, 1.20106250e-01f, 1.38471261e-01f, -5.13102897e-02f,
  1.16450913e-01f, -2.17067048e-01f, 8.09506625e-02f, 8.40334669e-02f, 3.24818604e-02f, 7.05120564e-02f, 1.43781856e-01f, 8.13876614e-02f, -1.42214164e-01f, -1.76948290e-02f,
  1.34747803e-01f, 1.09102733e-01f, -7.24884719e-02f, -1.50215164e-01f, 6.00915141e-02f, -1.74143583e-01f, 1.45934612e-01f, -1.07123978e-01f, -1.22107998e-01f, -1.47181809e-01f,
  1.30309433e-01f, 2.25194208e-02f, -9.12907571e-02f, -3.61809600e-03f, -7.07289502e-02f, 1.06417961e-01f, 2.27407608e-02f, 3.12271118e-02f, -1.30526215e-01f, 5.37438132e-02f,
  1.42885685e-01f, -4.87035513e-02f, 1.04110196e-01f, 2.27376465e-02f, -1.40958458e-01f, -9.41378325e-02f, 1.40490159e-02f, -5.21640107e-02f, 1.13518974e-02f, 5.92763089e-02f,
  -1.00682043e-01f, 1.27143383e-01f, 5.52561097e-02f, 1.32294536e-01f, 4.63431180e-02f, -1.58205360e-01f, 5.86790331e-02f, -1.56682881e-03f, -7.23741110e-03f, 1.88386608e-02f,
  -1.19428933e-01f, 1.06350191e-01f, 1.30037516e-01f, 1.06263176e-01f, -6.14766330e-02f, -1.29124511e-03f, -8.43562279e-03f, 1.26703948e-01f, -5.17429225e-02f, 7.10930815e-03f,
  5.78625090e-02f, 1.09815426e-01f, 1.35316625e-02f, 6.67384118e-02f, -1.09895609e-01f, 1.45361885e-01f, -1.19363256e-01f, 8.15231800e-02f, -6.07126616e-02f, 1.04747213e-01f,
  -9.35859755e-02f, 1.02149785e-01f, -1.16290733e-01f, -1.62930321e-02f, 1.61850885e-01f, -1.57196388e-01f, 9.44792852e-02f, 2.99760960e-02f, -1.48700818e-01f, 8.28016549e-02f,
  1.34739593e-01f, -4.52404981e-03f, -1.40451387e-01f, -1.01712748e-01f, -2.02618279e-02f, -4.35015559e-02f, 1.82572484e-01f, 2.64357477e-02f, -1.03974931e-01f, 4.63689640e-02f,
  -2.74633132e-02f, 1.25515923e-01f, -1.19728349e-01f, 8.41554403e-02f, 1.17898598e-01f, 1.04732409e-01f, 6.68676719e-02f, -8.64415020e-02f, 8.19623470e-03f, -1.42246559e-01f,
  9.13213044e-02f, -1.79524813e-02f, 6.86863661e-02f, -3.92462872e-02f, -2.25813743e-02f, -9.68676209e-02f, -7.40017444e-02f, -5.08188009e-02f, -1.01546161e-01f, -2.87139341e-02f,
  -1.29704580e-01f, 1.35526881e-01f, -1.28141314e-01f, 1.16613239e-01f, -2.57904157e-02f, 1.10547185e-01f, -3.67524400e-02f, 9.19071510e-02f, 6.26346096e-02f, 3.23988907e-02f,
  1.31860346e-01f, 6.21062070e-02f, -4.04068641e-03f, -7.76994973e-02f, 3.08378646e-03f, -1.96590424e-02f, 1.35393173e-01f, -7.87692983e-03f, 9.03402045e-02f, -1.09314173e-01f,
  -1.20645009e-01f, -8.35813731e-02f, 3.55581008e-03f, 1.12833470e-01f, -8.63858834e-02f, 7.35817254e-02f, 3.38047631e-02f, 1.68721303e-01f, 2.33512949e-02f, -4.26205434e-02f,
  -1.83034882e-01f, -2.16303635e-02f, -6.87111821e-03f, 1.33903906e-01f, -6.69464841e-02f, 4.04207446e-02f, -1.04415350e-01f, -6.17944859e-02f, 3.51174697e-02f, -1.37762977e-02f,
  1.13084994e-01f, 3.35937403e-02f, -3.39171216e-02f, -1.21409312e-01f, 2.07366142e-02f, 8.42106529e-03f, -1.03521451e-01f, 1.29417107e-01f, 1.09955303e-01f, 1.37464479e-02f,
  -8.35277587e-02f, 3.55013013e-02f, 1.35218963e-01f, -1.36825845e-01f, -1.32402088e-02f, 1.30745992e-01f, 5.94185777e-02f, 4.89029847e-02f, -3.93418595e-02f, 7.47352932e-03f,
  -9.80554894e-02f, 2.80566681e-02f, -1.07142590e-01f, 1.62227720e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  5.79157472e-02f, 2.25308254e-01f, -6.51503876e-02f, 8.25331882e-02f, -1.04096020e-02f, 1.73462078e-01f, 8.82130936e-02f, 1.51914805e-01f, 8.08918253e-02f, 6.27735630e-02f,
  2.32937708e-02f, -7.95195326e-02f, 9.43547264e-02f, 3.79305184e-02f, -1.19801015e-02f, -9.29594561e-02f, 9.52205136e-02f, 1.29540712e-01f, 2.01915011e-01f, -7.29751289e-02f,
  9.09825787e-02f, 5.99173196e-02f, 8.62867087e-02f, 1.71107382e-01f, 2.60209646e-02f, 1.25315994e-01f
};

// L2_fan_Wp (Shape: 19 x 64)
const int L2_fan_Wp_rows = 19;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  1.03184013e-02f, 9.79790837e-02f, 2.62749232e-02f, 4.97507825e-02f, -3.17510421e-04f, 6.63956702e-02f, 5.62380403e-02f, 5.25651537e-02f, 1.35246977e-01f, 2.35990789e-02f,
  1.41789064e-01f, 7.16324598e-02f, -7.41867498e-02f, 1.20997999e-03f, -4.13661823e-03f, -3.92498560e-02f, 1.12294778e-01f, -3.01228021e-03f, -3.90524641e-02f, -9.42207426e-02f,
  2.73101002e-01f, -8.86498615e-02f, -1.98937170e-02f, -2.47884970e-02f, 8.31534043e-02f, 2.96663553e-01f, -9.47971921e-03f, -1.26279145e-01f, -2.88071129e-02f, 2.24936649e-01f,
  -8.38980675e-02f, -2.51701295e-01f, -1.62811596e-02f, -8.05972144e-02f, 1.63288102e-01f, -7.75257777e-03f, 5.33808731e-02f, -7.62998313e-03f, -8.84538963e-02f, -1.12942629e-01f,
  -2.36809961e-02f, -7.52934292e-02f, 6.17098436e-02f, 1.67316779e-01f, -1.17001899e-01f, 6.88474812e-03f, 2.10525040e-02f, -1.23996846e-01f, -4.49181311e-02f, 1.13933384e-01f,
  -5.65729775e-02f, 1.25296459e-01f, -8.16026330e-02f, -8.45237076e-02f, -6.13123700e-02f, -1.51040569e-01f, 5.94548024e-02f, 2.85732001e-02f, 1.49946064e-01f, 1.71372935e-01f,
  -1.66489348e-01f, 1.73450455e-01f, 4.26583663e-02f, 5.56308851e-02f, -7.88299590e-02f, -5.09567671e-02f, 3.61374840e-02f, 6.93358481e-02f, -1.04086436e-01f, 3.57746035e-02f,
  -4.85381531e-03f, 2.31233370e-02f, 3.06546148e-02f, 1.08439215e-01f, -2.90771723e-02f, 5.59561066e-02f, 1.01391681e-01f, 1.31523097e-02f, -6.13210611e-02f, 5.81794567e-02f,
  -7.76908398e-02f, 8.35411698e-02f, 1.17597558e-01f, 7.34528601e-02f, -1.92510337e-01f, 2.44951602e-02f, -1.53898850e-01f, 1.35341868e-01f, -8.59692618e-02f, -1.88222140e-01f,
  4.17939052e-02f, 7.19281211e-02f, 1.50150239e-01f, -1.65490732e-01f, 2.85342075e-02f, -3.87371741e-02f, 1.99132003e-02f, -1.35624632e-01f, -7.10421950e-02f, -7.24296123e-02f,
  1.47988230e-01f, -1.99184462e-01f, 7.61755258e-02f, 8.55377093e-02f, 7.11082071e-02f, -4.32591885e-02f, -9.58345607e-02f, -8.29773396e-02f, -5.92990369e-02f, -5.22218980e-02f,
  -1.61772966e-02f, 7.37112248e-03f, -7.42209107e-02f, 9.51534584e-02f, -6.87218830e-02f, 1.11686736e-01f, -1.68905571e-01f, 1.27403691e-01f, -1.17064357e-01f, -6.96354136e-02f,
  -1.58112720e-01f, -6.36508912e-02f, 2.54637655e-02f, -1.24874702e-02f, 1.25850841e-01f, -1.33180514e-01f, 1.24843270e-02f, -7.32961297e-02f, 4.48702127e-02f, 6.49319366e-02f,
  -1.09137863e-01f, 4.29748297e-02f, 3.00106797e-02f, 7.52105517e-03f, 5.93002923e-02f, 4.85938191e-02f, -1.09332442e-01f, -1.98444635e-01f, 1.05745140e-02f, -4.17457633e-02f,
  -1.00676715e-01f, 5.77315874e-02f, 1.08775206e-01f, 9.77538005e-02f, -3.87394913e-02f, -1.31444499e-01f, -4.20669354e-02f, -1.86987668e-01f, 1.82200342e-01f, -1.17528856e-01f,
  -1.60882816e-01f, -3.52884680e-01f, -2.02780679e-01f, 2.67333537e-01f, 1.63677782e-01f, -2.94567626e-02f, -2.25790396e-01f, 6.16755933e-02f, -7.59210214e-02f, -1.88665520e-02f,
  -9.47787892e-04f, 1.48270288e-02f, -6.54969644e-03f, -1.51311189e-01f, -2.40262240e-01f, 6.03752695e-02f, -7.50490874e-02f, 1.09904878e-01f, -1.57714414e-03f, 1.36130646e-01f,
  5.33748567e-02f, -2.00596318e-01f, -8.90017301e-02f, 3.55056599e-02f, 8.62209648e-02f, -6.72325119e-02f, 2.16611940e-03f, -8.28974545e-02f, 1.15247265e-01f, -9.15532708e-02f,
  -9.22347307e-02f, -2.01928355e-02f, 1.26522154e-01f, 1.24000117e-01f, -5.97406030e-02f, -2.92226346e-03f, -8.96977261e-02f, 7.77502060e-02f, 2.63024382e-02f, 5.16074263e-02f,
  -2.38908753e-02f, 3.93665815e-03f, -4.87504601e-02f, 4.49597649e-02f, -4.27842773e-02f, 1.81746446e-02f, 1.36105996e-02f, -8.25887397e-02f, 1.91569906e-02f, -4.19058284e-04f,
  8.95076543e-02f, -8.14806297e-02f, 7.82960802e-02f, 1.56571586e-02f, -1.10330574e-01f, 1.01287558e-03f, 9.10999775e-02f, 1.33004254e-02f, -9.38989893e-02f, -1.08134968e-03f,
  1.15213856e-01f, -2.51009673e-01f, 2.07006201e-01f, 1.75731540e-01f, -9.47191566e-02f, -2.46221706e-01f, -2.39420936e-01f, 4.91263084e-02f, 1.71486750e-01f, 5.62706180e-02f,
  -1.74476624e-01f, 3.15815091e-01f, -2.91934788e-01f, -2.20695466e-01f, -1.00350231e-01f, 2.80863345e-01f, 9.85797793e-02f, -1.03587739e-01f, -2.75122881e-01f, 2.46478781e-01f,
  7.15046600e-02f, 1.13164425e-01f, -1.03509106e-01f, 7.01378376e-05f, 9.17147622e-02f, -3.28085981e-02f, -1.15414828e-01f, -1.21574573e-01f, -1.18885942e-01f, -1.30369756e-02f,
  -1.17112324e-01f, -9.05564055e-02f, 3.10304929e-02f, -2.10509837e-01f, 9.84778926e-02f, 5.47438636e-02f, -1.05378553e-01f, 5.91761023e-02f, 1.28417704e-02f, 5.78879975e-02f,
  1.40310019e-01f, 8.30666423e-02f, 1.87367722e-01f, 1.47051930e-01f, -1.04394294e-01f, -9.29127112e-02f, 1.43515572e-01f, 1.30245641e-01f, -5.02870744e-03f, 9.91463959e-02f,
  1.65156737e-01f, 7.58687928e-02f, 1.57818690e-01f, 9.45740268e-02f, 6.77040368e-02f, 1.57406971e-01f, 6.74207136e-02f, -2.47143116e-03f, 1.14410788e-01f, -1.20286178e-02f,
  5.04034348e-02f, 1.96306966e-02f, 1.48959532e-01f, 1.32486492e-01f, 4.33966219e-02f, 1.31425172e-01f, 4.51765135e-02f, 1.02399386e-01f, 3.32769826e-02f, 1.91862911e-01f,
  1.95951641e-01f, 4.62844372e-02f, -1.00424953e-01f, 1.45874321e-02f, 1.25243649e-01f, 4.86328825e-02f, 2.04662964e-01f, -1.56707570e-01f, 2.08636988e-02f, -1.00394189e-01f,
  -2.30229385e-02f, 1.33198649e-01f, 1.00500703e-01f, -1.26259133e-01f, 8.38471949e-03f, -1.63190871e-01f, -4.13324647e-02f, -2.84288861e-02f, -1.20910101e-01f, 5.84544428e-02f,
  1.18462786e-01f, 8.68794397e-02f, -9.02688429e-02f, -9.69777480e-02f, 1.30531624e-01f, 4.73054573e-02f, 8.14874098e-02f, -2.80842949e-02f, 4.10348736e-02f, 8.83582234e-02f,
  -4.78202589e-02f, -1.16508402e-01f, -6.39575243e-04f, -7.06388354e-02f, 9.82536897e-02f, -3.76520827e-02f, 6.78985044e-02f, 1.23958953e-01f, -8.02682117e-02f, 1.19285792e-01f,
  -1.30179012e-02f, 7.67486095e-02f, 1.62172988e-02f, -3.34764607e-02f, 1.28702760e-01f, -5.59138097e-02f, -4.72494252e-02f, -3.25910486e-02f, -1.32757813e-01f, 1.89341754e-02f,
  -1.19140968e-01f, -1.68064155e-03f, -1.15644865e-01f, 6.54822141e-02f, -6.77800030e-02f, 1.15831539e-01f, 8.93290341e-02f, 6.98694438e-02f, 7.90880620e-02f, -7.39482343e-02f,
  1.94741003e-02f, 2.17127651e-01f, -1.27604142e-01f, -6.38527051e-02f, 2.46511117e-01f, -2.11177170e-01f, -1.21462129e-01f, 1.73924580e-01f, 8.69974196e-02f, 9.88674685e-02f,
  -2.13736743e-01f, 6.85132146e-02f, -8.07982869e-03f, 3.51426229e-02f, -5.79509139e-02f, 5.93611263e-02f, -2.12061465e-01f, -3.16718787e-01f, -1.01461664e-01f, -1.61286622e-01f,
  -4.34324928e-02f, 2.35542245e-02f, 5.27615435e-02f, 3.77447493e-02f, 4.20898125e-02f, 1.00708410e-01f, -1.69258028e-01f, 6.25664070e-02f, -3.74998301e-02f, -1.15096956e-01f,
  -1.19868264e-01f, -1.36457058e-02f, -1.03340432e-01f, 1.04137054e-02f, -6.28903955e-02f, -4.88567799e-02f, -2.67788261e-01f, -7.54721016e-02f, 1.96781710e-01f, -2.53504850e-02f,
  6.32626936e-02f, 2.77381297e-02f, -1.42084628e-01f, -1.86143026e-01f, -1.19492911e-01f, -1.80708200e-01f, -1.77622646e-01f, -2.20278818e-02f, 9.69845131e-02f, -1.52041003e-01f,
  -1.28711984e-01f, -1.47009969e-01f, 6.18284009e-03f, 2.18030885e-02f, 1.40101209e-01f, -3.56994867e-02f, 1.01375140e-01f, -3.69569100e-02f, 4.53493223e-02f, -9.01404917e-02f,
  -1.32726416e-01f, 9.67100337e-02f, 4.11549769e-02f, 6.87655434e-02f, 1.21453151e-01f, -6.30970821e-02f, 8.61916866e-04f, -1.47880659e-01f, 2.27858536e-02f, 1.65054485e-01f,
  -3.93907912e-02f, 9.92845595e-02f, -4.39580344e-02f, 1.79882541e-01f, -3.89245078e-02f, -5.68345040e-02f, 1.96788795e-02f, 6.72573373e-02f, 1.26965679e-02f, -1.58108860e-01f,
  -2.76914258e-02f, 1.08046196e-01f, -2.12538820e-02f, -1.68930918e-01f, 4.83899638e-02f, 1.15746610e-01f, 1.04102291e-01f, 1.48027226e-01f, -9.41887498e-02f, -1.04552612e-01f,
  -1.85035523e-02f, -2.11836174e-02f, 8.84287152e-03f, 4.39151982e-03f, 8.24507549e-02f, 1.48154408e-01f, 8.81369114e-02f, -5.96331954e-02f, 1.35630459e-01f, -1.45934612e-01f,
  2.42921010e-01f, -2.63692103e-02f, 7.26154596e-02f, 8.20794515e-03f, -1.63971603e-01f, -1.43103525e-01f, -6.25779554e-02f, -1.65145069e-01f, 4.75775031e-03f, -8.73620510e-02f,
  -6.75521567e-02f, -4.23193797e-02f, -3.55263576e-02f, -9.15660188e-02f, -1.99462455e-02f, -3.70507836e-02f, -3.18025914e-03f, -4.95432541e-02f, 6.05990402e-02f, -1.05272658e-01f,
  -2.28126198e-02f, -4.63951789e-02f, -1.47069516e-02f, -1.06013771e-02f, -6.82667866e-02f, -1.27773896e-01f, -8.61489549e-02f, 6.95724264e-02f, -1.16985343e-01f, 3.96379121e-02f,
  -6.30646423e-02f, 2.26870760e-01f, 2.23759070e-01f, -1.67748958e-01f, -2.37671748e-01f, -1.47993594e-01f, 2.77072012e-01f, -1.29865959e-01f, 8.88322145e-02f, 2.79766843e-02f,
  -2.18642224e-02f, -9.58203003e-02f, 8.83271080e-03f, 1.22816779e-01f, 7.17598125e-02f, -4.19065714e-01f, -4.59809341e-02f, -2.48745941e-02f, 8.31500664e-02f, -7.62922764e-02f,
  -1.20160105e-02f, 2.80555576e-01f, 3.30848545e-02f, 1.56362027e-01f, -7.25581944e-02f, 5.77956513e-02f, -4.07626107e-02f, 1.08957306e-01f, -7.34767169e-02f, 1.00614488e-01f,
  3.93002480e-02f, -5.29944617e-03f, 6.12655692e-02f, -1.60983518e-01f, -1.70055121e-01f, -4.90385890e-02f, -7.81603158e-03f, 1.11617751e-01f, 3.83622050e-02f, 4.73815128e-02f,
  1.38499156e-01f, -1.45275503e-01f, 4.87819314e-02f, 2.82095913e-02f, 4.85682450e-02f, -3.93588208e-02f, -3.39083448e-02f, -1.17276110e-01f, 4.81105261e-02f, 3.95353399e-02f,
  -4.43908498e-02f, -3.88743766e-02f, 1.37608990e-01f, 5.56386225e-02f, 6.43306449e-02f, -9.74086896e-02f, 1.69700235e-01f, 1.06218658e-01f, 6.26331046e-02f, 1.22697100e-01f,
  1.17587611e-01f, -2.34645493e-02f, 3.14776972e-02f, 1.79955646e-01f, -9.65609476e-02f, 2.34270897e-02f, -1.62327394e-01f, -1.60212889e-01f, 1.33780703e-01f, 2.96351910e-01f,
  3.66114802e-03f, -2.40995228e-01f, -1.64783653e-03f, 3.53795230e-01f, -2.23756492e-01f, 1.20891534e-01f, -8.32528099e-02f, 7.40321307e-03f, -1.88689202e-01f, 1.97132707e-01f,
  8.12993944e-02f, -2.39448473e-02f, 2.42162161e-02f, 7.23987445e-02f, -2.55715773e-02f, -1.11550931e-02f, 5.95484227e-02f, -7.53869861e-02f, 1.60562709e-01f, 5.47118038e-02f,
  -8.71234946e-03f, 7.77393207e-03f, -1.89898551e-01f, -1.23361982e-01f, -9.45038199e-02f, 8.00567679e-03f, -9.74818990e-02f, 8.11627507e-02f, 1.38881877e-01f, 5.66143207e-02f,
  -1.03909530e-01f, -7.04844948e-03f, -5.99211641e-02f, -1.58101395e-01f, -1.04231626e-01f, -1.11803755e-01f, 5.46030961e-02f, 9.84114110e-02f, 1.08389981e-01f, 7.03759119e-02f,
  -1.53595349e-02f, 8.10663179e-02f, 8.66012797e-02f, 1.90127213e-02f, 1.97872758e-01f, 1.46526536e-02f, -3.72942872e-02f, 1.46116931e-02f, 1.24928966e-01f, 5.84998988e-02f,
  1.52355507e-01f, -7.59851485e-02f, -4.00750674e-02f, 1.64363474e-01f, 1.52987599e-01f, 1.29122138e-01f, 2.65032083e-01f, -1.20073296e-01f, 9.65551212e-02f, -4.52555791e-02f,
  1.53922468e-01f, 2.62481868e-01f, 1.50930867e-01f, 6.34864941e-02f, -1.18863665e-01f, 1.90603971e-01f, -1.69035062e-01f, -1.58678442e-01f, 3.49602895e-03f, 1.51202649e-01f,
  1.37703642e-01f, -1.89378355e-02f, -5.49751744e-02f, -7.23334821e-03f, -6.11700006e-02f, -1.08825617e-01f, 3.89018729e-02f, 2.31633689e-02f, -9.37544554e-02f, 8.58481675e-02f,
  -2.38097776e-02f, -1.04409486e-01f, 7.04266801e-02f, -2.81538982e-02f, 1.07136443e-01f, 9.18214172e-02f, 1.03514172e-01f, 7.64921978e-02f, 1.60046235e-01f, -1.90031026e-02f,
  -8.45494643e-02f, -4.17194925e-02f, 1.93756055e-02f, 5.84047362e-02f, 4.25552763e-02f, 4.32459600e-02f, -9.04356688e-02f, 1.53244555e-01f, -1.86378866e-01f, -7.73276165e-02f,
  5.72598092e-02f, -5.26772551e-02f, 7.62412101e-02f, -1.01105943e-01f, -9.80562642e-02f, 6.94826851e-03f, 1.20732643e-01f, 1.20219542e-02f, -3.28398906e-02f, -2.44818851e-02f,
  -6.94986284e-02f, 9.07791853e-02f, -7.06493706e-02f, 1.11243419e-01f, -1.16785960e-02f, 9.10655558e-02f, 1.07567228e-01f, -2.59739514e-02f, 7.04787448e-02f, -1.14444725e-01f,
  -3.73606347e-02f, 7.34600127e-02f, -3.50940600e-02f, -3.31509262e-02f, 8.93134624e-04f, 3.13446037e-02f, -6.91146553e-02f, -3.84089053e-02f, -6.36611730e-02f, 1.51851717e-02f,
  -1.23965524e-01f, -9.88693163e-02f, -1.08085707e-01f, 1.13946624e-01f, -3.76890674e-02f, 1.44397303e-01f, -6.23851866e-02f, -1.54761657e-01f, -1.92634184e-02f, 1.44445643e-01f,
  -9.99595076e-02f, -8.00828449e-03f, 1.15262337e-01f, -2.05537956e-02f, 5.92448004e-02f, 4.53658998e-02f, -1.10246018e-01f, -1.26146287e-01f, 6.95217550e-02f, 4.22113240e-02f,
  9.22215953e-02f, -1.14661887e-01f, -7.26444572e-02f, -5.82073107e-02f, -2.28642635e-02f, -2.05355249e-02f, -6.39838725e-02f, 6.18667752e-02f, 8.26783106e-02f, 1.04147971e-01f,
  -3.60785127e-02f, 1.93957657e-01f, -9.60580483e-02f, 6.56230226e-02f, -6.14640489e-02f, -4.42999452e-02f, 8.78671482e-02f, -4.25898144e-03f, 5.14402613e-02f, -3.25288214e-02f,
  3.03121749e-02f, -7.73789063e-02f, 3.77896130e-02f, -3.02249677e-02f, 1.03655733e-01f, 6.68787910e-03f, 5.66280894e-02f, 8.36026222e-02f, 6.30510300e-02f, 7.13991970e-02f,
  -6.64364621e-02f, 1.08975470e-01f, -1.96881294e-02f, 1.85154617e-01f, 5.71602471e-02f, 8.50484241e-03f, 1.55587494e-01f, 2.54596919e-01f, 1.46579653e-01f, -1.01422362e-01f,
  -9.53292754e-03f, -1.78481787e-01f, 1.69633761e-01f, 1.76256914e-02f, 1.35550171e-01f, -1.43039033e-01f, 8.38971436e-02f, -6.08997345e-02f, 9.66171920e-02f, 8.47868174e-02f,
  7.44370297e-02f, -1.74818709e-01f, -9.87153202e-02f, -8.89549777e-02f, -9.58823934e-02f, 1.93391498e-02f, -6.43379614e-02f, 2.59610787e-02f, 4.75796461e-02f, -1.44126087e-01f,
  9.08861607e-02f, 2.71616243e-02f, 1.09061152e-01f, 1.03538655e-01f, 1.05812782e-02f, 6.77649537e-03f, 9.86713171e-02f, -9.77984890e-02f, 2.82996166e-02f, 4.52410541e-02f,
  -7.69675300e-02f, 1.07889250e-01f, -7.77494758e-02f, -9.98669043e-02f, 6.23046719e-02f, -4.34685200e-02f, 3.10697649e-02f, -2.28282660e-02f, 1.84310991e-02f, 1.38981640e-01f,
  -2.60456018e-02f, -5.37528954e-02f, -2.96813007e-02f, -8.24753195e-03f, 1.54574543e-01f, 1.69951841e-02f, 7.56904259e-02f, 7.68721700e-02f, -1.60106197e-01f, -1.27802446e-01f,
  -6.38182387e-02f, -1.57827251e-02f, 4.52131964e-03f, -3.37749571e-02f, -1.11831635e-01f, 1.04074918e-01f, 9.64757800e-02f, -1.28838301e-01f, -1.12118371e-01f, 2.04109788e-01f,
  5.57374321e-02f, -1.61012664e-01f, -5.69087714e-02f, -1.48906440e-01f, 4.64918418e-03f, 5.80032542e-02f, 4.36711721e-02f, -6.75497949e-02f, -1.75951943e-01f, -2.00473532e-01f,
  -1.07285092e-02f, -1.27370343e-01f, -1.07571840e-01f, 4.37701494e-02f, -5.52751198e-02f, -2.14137018e-01f, -7.63838599e-03f, 6.96322247e-02f, -1.34098947e-01f, 7.47219995e-02f,
  -4.61635515e-02f, -1.47122025e-01f, 1.12675428e-01f, 6.05630055e-02f, -3.42800952e-02f, 1.32119969e-01f, -1.34108096e-01f, -1.39763102e-01f, 3.30420770e-02f, -1.14538796e-01f,
  -9.42130834e-02f, -4.22783941e-02f, -7.18436614e-02f, -4.09032544e-03f, -2.49464989e-01f, -7.38547295e-02f, 8.26698691e-02f, -2.19529327e-02f, 1.48438469e-01f, 1.26262739e-01f,
  1.33051857e-01f, -1.06671713e-02f, 2.26101838e-02f, -2.56287009e-02f, -4.39036451e-02f, 6.16103746e-02f, -8.47849175e-02f, -4.21725400e-02f, -6.82248026e-02f, 1.34287313e-01f,
  -3.80006358e-02f, -7.76061323e-03f, 1.30595610e-01f, -5.98726720e-02f, 6.00369833e-03f, -3.61102261e-02f, -5.93180917e-02f, -1.12823047e-01f, -5.81613667e-02f, 1.13268062e-01f,
  1.12620860e-01f, -1.84315871e-02f, 1.91381887e-01f, -1.27244011e-01f, 1.53606981e-01f, -1.56943068e-01f, 3.56954969e-02f, 2.65735358e-01f, -6.19761050e-02f, -5.46842702e-02f,
  -5.09963594e-02f, 4.13630828e-02f, -7.68218338e-02f, -5.87904602e-02f, 1.72948092e-02f, -1.15156189e-01f, 1.64048046e-01f, -9.36620310e-02f, -8.76074508e-02f, -1.06469899e-01f,
  2.40922477e-02f, -2.15130270e-01f, 8.55515450e-02f, -7.09636509e-02f, -7.33947158e-02f, 1.69528186e-01f, -9.01945755e-02f, 3.51946205e-02f, -1.22812264e-01f, -1.34074792e-01f,
  1.87130999e-02f, 1.50353223e-01f, 1.49781033e-01f, 1.38700962e-01f, -5.75263053e-03f, -3.68255191e-02f, 1.36983633e-01f, 5.63641861e-02f, 1.05317138e-01f, -3.64757776e-02f,
  8.50886852e-02f, -7.49315787e-03f, -1.64686404e-02f, 2.10153714e-01f, -5.05488254e-02f, -1.13394976e-01f, 8.64126235e-02f, 3.38911004e-02f, -2.39771120e-02f, 2.53744284e-03f,
  1.24790922e-01f, -5.04113175e-03f, 3.51035297e-02f, -2.05409732e-02f, 1.58459321e-01f, 9.84514505e-02f, 1.41692325e-01f, 8.55079517e-02f, -4.81586456e-02f, -4.57893312e-02f,
  1.47947684e-01f, -6.82970285e-02f, -1.40236085e-02f, 6.68528602e-02f, 1.05421588e-01f, 1.24709867e-01f, 1.69795722e-01f, -1.54299572e-01f, 1.01921275e-01f, 7.79564977e-02f,
  1.12211347e-01f, 2.03828841e-01f, 1.27248943e-01f, 2.16190852e-02f, -8.86255056e-02f, 4.63279560e-02f, 1.27021819e-01f, -3.40480395e-02f, -1.04870886e-01f, 1.71546012e-01f,
  -7.34309293e-03f, -1.10143542e-01f, 7.56785274e-02f, 2.15498045e-01f, -7.93647766e-02f, -2.09495798e-01f, -1.11187048e-01f, -8.32071677e-02f, -1.30756661e-01f, 7.00683519e-02f,
  5.79359159e-02f, -9.62956026e-02f, 3.13574187e-02f, 9.35917199e-02f, 7.51053765e-02f, 7.99877718e-02f, -6.29540682e-02f, -1.25614405e-01f, 1.68359771e-01f, -1.29663572e-01f,
  6.02162583e-03f, 6.78543150e-02f, 2.16540769e-01f, -6.22306392e-02f, 4.91498709e-02f, -9.97016132e-02f, -2.00190190e-02f, 7.54867792e-02f, -9.07184407e-02f, 6.23073615e-02f,
  -1.02711976e-01f, 2.34226566e-02f, 7.30112717e-02f, -1.19655512e-01f, -1.36381343e-01f, 1.15372978e-01f, 3.34811471e-02f, -9.92565528e-02f, -6.56975731e-02f, -3.15814689e-02f,
  7.69049525e-02f, 7.75341736e-03f, -1.60865039e-02f, 4.68485169e-02f, -3.40997204e-02f, 3.19648087e-02f, 1.91209950e-02f, -1.50045559e-01f, 5.14666289e-02f, -1.15346611e-02f,
  -5.22740781e-02f, 1.13654666e-01f, -1.45022914e-01f, -2.14136675e-01f, -2.21910164e-01f, 4.05700020e-02f, -1.24316476e-01f, 5.95114045e-02f, -5.91907836e-02f, 4.41609733e-02f,
  -7.50285164e-02f, -9.09004509e-02f, 2.45492049e-02f, 8.34990665e-02f, -8.77469108e-02f, 1.00883663e-01f, -1.06828347e-01f, -8.98909867e-02f, 7.12883547e-02f, 1.28538713e-01f,
  5.52900545e-02f, 6.24016114e-02f, 3.17485556e-02f, -1.90154299e-01f, -4.68824282e-02f, 4.64476924e-03f, -6.09517619e-02f, 9.03983042e-02f, -1.30968066e-02f, -2.32060701e-02f,
  -1.12103418e-01f, 2.12887302e-02f, -6.22693188e-02f, 7.26070255e-02f, 2.55279802e-03f, -3.45356241e-02f, -2.09813580e-01f, -9.05642984e-04f, 1.00216784e-01f, 8.44220072e-02f,
  2.07313433e-01f, 1.51088402e-01f, -1.51196420e-02f, -7.14076534e-02f, -2.55096313e-02f, -6.32326379e-02f, -9.07604247e-02f, 1.21661164e-02f, -1.26663670e-01f, 6.61588609e-02f,
  -1.62191298e-02f, -1.13590732e-02f, 2.30231695e-02f, -2.16783267e-02f, -1.24047562e-01f, -9.39587206e-02f, -1.00785136e-01f, -1.14664078e-01f, 1.34453863e-01f, -1.26374448e-02f,
  9.30109397e-02f, -6.00106604e-02f, 6.73580393e-02f, 4.72087879e-03f, -1.21089511e-01f, 8.21863767e-03f, 2.69284230e-02f, -4.48789448e-02f, -4.75425087e-02f, -1.72415867e-01f,
  3.64567712e-02f, 1.20455243e-01f, 5.88321313e-02f, 8.40733126e-02f, -5.46670966e-02f, 1.09366968e-01f, -1.57286227e-01f, 4.68475297e-02f, -1.16269790e-01f, 4.87639084e-02f,
  -1.73611626e-01f, -4.98922281e-02f, -1.56399589e-02f, 7.19273165e-02f, -4.52419929e-02f, -4.12310176e-02f, -8.48206580e-02f, -9.86195505e-02f, -1.29485160e-01f, 8.27632546e-02f,
  -2.66880356e-02f, -1.78021472e-02f, 5.90907000e-02f, -7.80519545e-02f, -2.50812992e-02f, -4.33891788e-02f, -1.20651051e-01f, 1.15346283e-01f, -9.63358581e-02f, -8.52636620e-02f,
  -1.48566365e-01f, 4.01000343e-02f, -3.91649529e-02f, 3.60947810e-02f, 1.87713504e-01f, 5.43415872e-03f, -1.22033281e-03f, -8.19189250e-02f, -2.57975105e-02f, -1.57232404e-01f,
  3.94878983e-02f, 3.48427147e-02f, 1.16245188e-01f, -7.92168081e-02f, -5.62486090e-02f, -1.05009422e-01f, 4.51543108e-02f, -1.48848534e-01f, 4.84649912e-02f, 1.25051185e-01f,
  2.37528104e-02f, -1.03919610e-01f, -8.90299827e-02f, -1.11880703e-02f, 7.08216801e-02f, 2.52673663e-02f, 5.01730591e-02f, 2.33314425e-01f, 1.09677091e-01f, -2.62016747e-02f,
  -4.92960215e-02f, 1.13385804e-01f, -6.14465140e-02f, 1.85684413e-01f, 7.04907402e-02f, 1.76952839e-01f, -5.19823730e-02f, 1.36289462e-01f, 5.38603030e-02f, 1.88358635e-01f,
  8.97302479e-02f, 1.36371832e-02f, 1.75877810e-02f, 5.83793931e-02f, 8.55530277e-02f, 1.43295690e-01f, -4.50473167e-02f, 9.54260118e-03f, 1.27908569e-02f, -1.46530926e-01f,
  -1.84396878e-02f, -3.09917200e-02f, -1.00482151e-01f, -8.13970342e-02f, 1.87861100e-02f, -3.25117186e-02f, 1.00468077e-01f, 3.43867876e-02f, -1.22698059e-03f, -6.05153898e-03f,
  8.62790719e-02f, -1.02519449e-02f, 5.37229236e-03f, -5.42533286e-02f, 3.07143092e-01f, 7.22872913e-02f, 5.12023382e-02f, -1.15909189e-01f, -2.08415374e-01f, -2.32914150e-01f,
  -1.59121543e-01f, -8.53704438e-02f, -6.84536099e-02f, 7.03896284e-02f, -2.49943938e-02f, -1.42686460e-02f, 6.37231916e-02f, 6.65076822e-02f, 4.91820462e-02f, 1.15956776e-01f,
  -9.96077955e-02f, 9.14493874e-02f, -8.02707970e-02f, -2.93068681e-02f, -4.27384153e-02f, -1.20189480e-01f, 1.40185654e-01f, 1.40902093e-02f, -7.76828751e-02f, 3.97647358e-02f,
  1.16358567e-02f, -2.37198517e-01f, 9.25208032e-02f, 1.74854755e-01f, -1.95423245e-01f, -2.43049249e-01f, -7.71773681e-02f, -1.07707262e-01f, -1.01006351e-01f, 2.88239747e-01f,
  -9.33106337e-03f, 1.18568659e-01f, -2.04747885e-01f, -6.15326278e-02f, -6.91499859e-02f, 2.16105908e-01f, -2.05084443e-01f, -7.62305707e-02f, -2.29301944e-01f, -1.00564823e-01f,
  5.49401008e-02f, -5.98648377e-03f, -9.89142507e-02f, 1.25401765e-01f, 8.22188929e-02f, -5.35303401e-03f, -5.51684722e-02f, 1.40430689e-01f, -1.60407051e-02f, -9.70434472e-02f,
  4.05214466e-02f, -1.55432746e-02f, -1.00716382e-01f, -1.75956469e-02f, -1.35519966e-01f, 1.01812854e-01f, -7.11541474e-02f, -5.36104254e-02f, -1.32954136e-01f, -8.31227824e-02f,
  3.64700481e-02f, -4.50812876e-02f, 2.13059351e-01f, 1.11044839e-01f, -2.15895660e-02f, -1.55779526e-01f
};

// L2_fan_Wp_bar (Shape: 26 x 64)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -8.57757926e-02f, -6.07523508e-02f, 2.09944067e-03f, -7.62615278e-02f, -8.80909432e-03f, 8.84845331e-02f, 1.34306908e-01f, -9.50825214e-02f, -9.02707409e-03f, 4.52066995e-02f,
  -3.48508991e-02f, 7.37472773e-02f, 4.14751470e-02f, 4.57938872e-02f, -3.19473222e-02f, 3.99879329e-02f, -3.80710000e-03f, 1.19215898e-01f, 8.64038616e-02f, 2.69471481e-02f,
  -1.07267126e-02f, 7.72258863e-02f, 3.45183164e-02f, 1.05239317e-01f, 4.09901179e-02f, 7.56762996e-02f, -7.54652321e-02f, -4.84409817e-02f, 1.09293282e-01f, 9.16182622e-02f,
  1.32392883e-01f, -2.90774778e-02f, -2.76551545e-02f, -1.72418058e-01f, 5.19443955e-03f, 2.68674362e-02f, 1.93268526e-02f, -1.33948475e-01f, -4.63003889e-02f, -6.22063205e-02f,
  9.31110978e-02f, 1.28138334e-01f, -8.66812915e-02f, -2.22558547e-02f, 1.12400390e-01f, -2.82470994e-02f, 6.44356292e-03f, 2.34435834e-02f, -3.46888527e-02f, 4.03125472e-02f,
  1.18528441e-01f, 1.75606981e-01f, -1.76892783e-02f, 1.09828949e-01f, -6.06534891e-02f, 2.89097987e-02f, 6.88341856e-02f, -9.07322466e-02f, 1.26012802e-01f, -3.98280192e-03f,
  1.57461204e-02f, 9.14164782e-02f, 5.00091584e-03f, 1.87001713e-02f, 1.05678596e-01f, 2.38788705e-02f, 4.86783572e-02f, 1.14138462e-01f, 1.69810653e-02f, -1.30107626e-04f,
  3.75168733e-02f, 1.72838256e-01f, 8.47291108e-03f, -2.38928553e-02f, 2.08797440e-01f, -2.85224374e-02f, 2.15991452e-01f, -2.56751105e-02f, 1.29932076e-01f, 1.81097716e-01f,
  -2.63118502e-02f, -7.37886652e-02f, -4.96306345e-02f, -3.91175598e-02f, 1.27561852e-01f, -7.86870494e-02f, -1.04191750e-01f, -1.18519023e-01f, -2.46833086e-01f, 1.45897210e-01f,
  1.90127343e-01f, 1.24402441e-01f, -2.46426940e-01f, -2.35041082e-02f, -5.33610629e-03f, 1.03768744e-02f, -1.39708012e-01f, 6.05765637e-03f, -7.00929388e-02f, 2.47137825e-04f,
  -7.38068223e-02f, 3.52964520e-01f, 1.22714698e-01f, 2.41018906e-01f, 6.40111864e-02f, -4.23920453e-02f, -1.19873784e-01f, -1.25573510e-02f, 9.39582735e-02f, 9.17103067e-02f,
  2.23746430e-02f, -6.29603863e-02f, -7.06486180e-02f, -1.31868914e-01f, -6.86794892e-02f, 6.94952831e-02f, 1.54106766e-01f, 6.99867755e-02f, 4.88371998e-02f, -1.99463144e-02f,
  3.98694336e-01f, 9.33780149e-03f, -1.61462247e-01f, -9.37939510e-02f, -4.25351113e-02f, -5.35129495e-02f, 1.33529259e-02f, 1.37158111e-01f, -1.01367114e-02f, 1.59163661e-02f,
  6.13261238e-02f, -6.41579926e-02f, -4.01235074e-02f, -5.92678599e-02f, 5.38970716e-02f, -1.15145430e-01f, 2.87494026e-02f, 1.72184277e-02f, 7.93780014e-02f, -6.65114596e-02f,
  -3.22636105e-02f, 1.72245894e-02f, -9.79036689e-02f, -8.49484876e-02f, -1.00846134e-01f, -6.04488663e-02f, -3.32801603e-02f, -1.15840226e-01f, 5.83294667e-02f, -1.00231014e-01f,
  2.08769664e-02f, -4.51371744e-02f, 8.80444050e-03f, 6.93131238e-02f, 8.57492238e-02f, -1.01370667e-03f, 8.27687606e-02f, -5.35226706e-03f, 3.36727430e-03f, 9.68818888e-02f,
  -4.93873619e-02f, 5.59954643e-02f, -2.38713659e-02f, -3.62760536e-02f, -6.33148924e-02f, 9.72921252e-02f, 9.69746783e-02f, 9.87216905e-02f, 2.78528314e-02f, 1.09443150e-01f,
  3.93983759e-02f, -6.23668497e-03f, 8.65990669e-02f, -9.63270739e-02f, -6.45336136e-02f, 1.09078206e-01f, -4.24713008e-02f, -6.75531803e-03f, 3.67412455e-02f, -8.57424513e-02f,
  8.83818343e-02f, -5.17848060e-02f, 3.49574983e-02f, 6.20076805e-02f, -9.81153250e-02f, -5.45720682e-02f, -2.88209841e-02f, 1.16067588e-01f, 3.23831923e-02f, -1.06484979e-01f,
  1.18083686e-01f, 6.01716898e-02f, 5.10001034e-02f, -1.37647271e-01f, -5.07258363e-02f, 3.37331034e-02f, 5.80058396e-02f, -3.19200195e-02f, -3.53327347e-03f, 1.36030436e-01f,
  1.22750781e-01f, -4.74153683e-02f, -6.03265874e-02f, -5.84633648e-02f, 8.82525519e-02f, -6.52987137e-02f, 1.28754854e-01f, 6.89480230e-02f, 8.76029953e-02f, 1.42928600e-01f,
  -9.47927088e-02f, -3.99510898e-02f, -2.11259350e-02f, 4.91758287e-02f, 1.17162883e-01f, 3.35472822e-02f, -6.45330921e-03f, 6.53656423e-02f, 1.65801361e-01f, -4.15610336e-02f,
  6.57464266e-02f, 1.24311052e-01f, 1.60620421e-01f, 5.31152822e-02f, -3.61710303e-02f, 6.59443624e-03f, 6.61343662e-03f, -9.21353996e-02f, 4.90235128e-02f, 1.58560738e-01f,
  -1.98918637e-02f, -4.48080972e-02f, 3.09135914e-02f, 1.03640415e-01f, -1.16899051e-01f, -2.60584969e-02f, -3.45179364e-02f, 2.54942067e-02f, -4.22331952e-02f, -9.39997211e-02f,
  3.84578779e-02f, -4.26025204e-02f, 5.01745269e-02f, 9.51159447e-02f, 1.03518739e-01f, 5.17273918e-02f, 1.62356552e-02f, -4.03521694e-02f, 2.42773786e-01f, 1.21742986e-01f,
  6.33697063e-02f, -3.95313688e-02f, -1.35654256e-01f, -1.01738259e-01f, -5.58955222e-02f, 2.06867028e-02f, 1.46966115e-01f, 8.03886950e-02f, 1.41403615e-01f, 1.26529187e-01f,
  -7.63905942e-02f, 6.62208572e-02f, -4.33665253e-02f, -7.45161548e-02f, 1.54325545e-01f, -2.08067745e-02f, -4.21989821e-02f, 9.34274271e-02f, -1.05915695e-01f, 1.15705729e-01f,
  -7.58745670e-02f, -4.97570634e-02f, -8.50196108e-02f, 3.43413986e-02f, -8.36548880e-02f, 4.60010692e-02f, 1.00224733e-01f, -8.03813152e-03f, -6.83572367e-02f, -1.16883358e-03f,
  -1.00336909e-01f, 1.15456782e-01f, -4.31849584e-02f, -8.16840976e-02f, -6.70821816e-02f, 1.38240948e-01f, 8.79659131e-02f, -2.81086713e-02f, -5.04214801e-02f, -9.45447162e-02f,
  1.08524196e-01f, -4.11380967e-03f, -8.77341926e-02f, -5.22768050e-02f, -2.96475384e-02f, -4.08943109e-02f, 5.73599115e-02f, 6.53007254e-02f, -2.79092621e-02f, 1.02580197e-01f,
  -9.34386551e-02f, -3.13580856e-02f, -4.24437858e-02f, -4.49579433e-02f, 1.41791955e-01f, -8.92505497e-02f, 1.38183143e-02f, 9.40185115e-02f, 1.14703141e-01f, 4.61007208e-02f,
  -2.18856595e-02f, -2.21562758e-02f, -1.11431792e-01f, 1.20136172e-01f, -3.12907733e-02f, -4.68834117e-02f, 1.24464110e-01f, -5.71109802e-02f, -4.70349863e-02f, -8.58899355e-02f,
  1.18942991e-01f, 9.80357379e-02f, 1.33723393e-01f, 4.67397943e-02f, 1.44366652e-01f, 8.87575075e-02f, 6.22260757e-02f, -2.63746902e-02f, 1.08267311e-02f, 9.30475071e-02f,
  1.50473425e-02f, 1.49046838e-01f, 7.48147368e-02f, -1.73936747e-02f, -8.46617222e-02f, 8.88025537e-02f, 1.09518908e-01f, -7.23159611e-02f, -2.58796616e-03f, 1.40869524e-02f,
  1.68259591e-01f, 4.93719503e-02f, 3.95024642e-02f, -1.30643070e-01f, -7.27890385e-03f, 2.09327072e-01f, -2.17045490e-02f, -5.30059729e-03f, -1.37079120e-01f, 1.75191060e-01f,
  -4.11672145e-02f, 3.13430801e-02f, -6.24015287e-04f, 2.32963599e-02f, 3.10158450e-02f, 8.50413516e-02f, 8.76295641e-02f, 5.99536709e-02f, 2.41454784e-02f, 7.45553970e-02f,
  8.44279379e-02f, 8.44523236e-02f, 6.57419860e-02f, 8.38428140e-02f, 1.07563853e-01f, 8.54382217e-02f, 8.32997411e-02f, -1.41039938e-01f, -1.24210037e-01f, -7.81738460e-02f,
  1.10770784e-01f, -8.60954672e-02f, 1.63466886e-01f, -2.85781343e-02f, -3.70384492e-02f, 4.68070805e-03f, 2.56590217e-01f, 1.36524774e-02f, -9.91546065e-02f, 1.28455907e-01f,
  2.89100856e-02f, -2.93124057e-02f, -6.43332303e-02f, -1.04666471e-01f, 2.65921801e-01f, 1.85700446e-01f, -7.43587241e-02f, 2.16896310e-01f, 2.77358592e-01f, -2.15784330e-02f,
  -6.13272237e-03f, 2.18411326e-01f, -7.16065019e-02f, 1.95750952e-01f, 5.78313470e-02f, 2.40185842e-01f, 1.84057683e-01f, 6.62624538e-02f, 3.46799940e-02f, 6.98183030e-02f,
  8.57745484e-02f, 9.94691402e-02f, 4.16513197e-02f, 6.82029948e-02f, -2.14959413e-01f, 2.16356844e-01f, -1.75289229e-01f, -8.91715139e-02f, 1.57299206e-01f, -2.75566339e-01f,
  -1.36281535e-01f, 3.37983757e-01f, 1.31015539e-01f, -2.12277785e-01f, -7.02705905e-02f, 1.98422134e-01f, -3.20487954e-02f, 1.99125648e-01f, -1.00854620e-01f, 9.31645483e-02f,
  -1.10699430e-01f, -1.58756942e-01f, 9.34975892e-02f, 2.10611582e-01f, -2.00808141e-02f, -1.15619674e-01f, -2.12885570e-02f, 1.66855067e-01f, 4.21872269e-03f, 7.96366036e-02f,
  1.11403435e-01f, 7.84084275e-02f, 1.15404174e-01f, -2.01284941e-02f, -7.10402653e-02f, -8.70784819e-02f, -1.26426446e-03f, 1.01241812e-01f, -1.12983860e-01f, -4.63992618e-02f,
  -3.71978059e-02f, 1.06600508e-01f, 4.15980555e-02f, -3.58633064e-02f, 2.57073611e-01f, 3.64963859e-02f, -1.09532028e-02f, -9.38041806e-02f, 1.08803086e-01f, -9.96863917e-02f,
  1.25766456e-01f, 1.15671776e-01f, 1.08008027e-01f, -1.81669127e-02f, -7.86936209e-02f, -7.72056058e-02f, 1.34261459e-01f, 3.65968086e-02f, -9.90541279e-02f, -5.15202759e-04f,
  -5.99806942e-02f, -8.58533233e-02f, 6.45128861e-02f, 1.03988342e-01f, -1.87331345e-02f, -6.09735735e-02f, 2.17454205e-03f, 5.58621846e-02f, -5.48042171e-02f, -8.80770572e-03f,
  -8.96168426e-02f, 1.95746161e-02f, -1.24447435e-01f, -1.69744268e-02f, -6.20051585e-02f, -2.31907722e-02f, 1.36763364e-01f, 2.57981140e-02f, 3.58857177e-02f, 6.74950033e-02f,
  -1.02122255e-01f, -3.49583961e-02f, -1.20970324e-01f, 1.41047880e-01f, 7.60661662e-02f, 4.75773066e-02f, -5.07879350e-03f, -1.02640234e-01f, 3.85295264e-02f, 2.73153428e-02f,
  4.45294790e-02f, -2.39794422e-02f, -1.38646662e-02f, -2.58161165e-02f, -7.89163858e-02f, -5.75753637e-02f, 2.80373413e-02f, 9.47686955e-02f, 3.90329845e-02f, -5.79021573e-02f,
  -3.74775305e-02f, 5.97301908e-02f, 7.72116408e-02f, -3.42434421e-02f, -6.67039528e-02f, 1.25507817e-01f, 1.07312247e-01f, 7.47144595e-02f, 4.40368848e-03f, 1.48655742e-01f,
  9.52570960e-02f, 4.07334492e-02f, 1.11304417e-01f, -8.93131793e-02f, -6.30029812e-02f, -3.68962740e-03f, -1.81486066e-02f, -9.20844674e-02f, -4.76156548e-03f, -4.11581211e-02f,
  1.03803590e-01f, -1.11996243e-02f, 2.27813562e-03f, -5.23020290e-02f, 9.28777456e-02f, 2.23390441e-02f, 3.51620540e-02f, 1.08356528e-01f, 1.34980986e-02f, -7.58333728e-02f,
  1.05107307e-01f, 1.11231141e-01f, -5.59509099e-02f, -1.44174457e-01f, -8.87530670e-02f, 7.73973316e-02f, 6.08332492e-02f, 1.04170747e-01f, -7.07271919e-02f, 8.01788941e-02f,
  -3.98510695e-02f, -1.24002516e-01f, 1.87804624e-01f, -8.65028873e-02f, -8.54630098e-02f, -1.28760457e-01f, 7.92361572e-02f, -1.08449362e-01f, 4.21473496e-02f, -5.77852828e-03f,
  -8.83280262e-02f, -6.01188019e-02f, -4.53380123e-02f, -1.30454555e-01f, -1.12657636e-01f, 5.37839234e-02f, -2.71954052e-02f, 2.40522716e-02f, -9.88268405e-02f, 9.95377302e-02f,
  8.69026035e-02f, 9.88040194e-02f, 2.58500949e-02f, 2.72550527e-03f, 1.15805767e-01f, 9.68217477e-02f, 5.62076904e-02f, -1.12191997e-01f, 1.50086164e-01f, 7.10104778e-02f,
  -5.36626838e-02f, -8.89329687e-02f, -3.54962237e-02f, 4.67572063e-02f, -8.69635940e-02f, 2.52292212e-02f, 7.10140914e-02f, -4.75989208e-02f, -5.76499999e-02f, 1.17016904e-01f,
  1.49342999e-01f, -1.12948857e-01f, -2.47611422e-02f, 1.84511289e-01f, 1.40032962e-01f, 1.84639558e-01f, 5.82119152e-02f, 8.55278969e-02f, 1.00964000e-02f, 1.27166450e-01f,
  1.32578135e-01f, 7.47873858e-02f, 1.18989833e-01f, 1.14632882e-01f, 5.02682664e-02f, 1.45741373e-01f, -1.23535044e-01f, -4.35735323e-02f, 1.12608910e-01f, 2.14034647e-01f,
  2.30314612e-01f, -1.04158275e-01f, -1.52996881e-02f, 4.27132770e-02f, 1.69320062e-01f, -1.38723686e-01f, 4.63022850e-02f, -5.00776153e-03f, 7.54339024e-02f, -1.66420832e-01f,
  1.11729845e-01f, -5.33363633e-02f, 1.21744141e-01f, -1.41660973e-01f, 9.46412832e-02f, -1.55868277e-01f, -2.77586542e-02f, -1.19048931e-01f, 5.47866058e-03f, 2.13860780e-01f,
  -1.01235896e-01f, 8.84489492e-02f, 1.51675725e-02f, -7.79078528e-02f, 1.76724926e-01f, -5.68216341e-03f, 5.55961542e-02f, 1.39494672e-01f, -7.41240457e-02f, -7.29714856e-02f,
  -2.08888799e-02f, 8.32780451e-02f, 3.52181233e-02f, 2.46136729e-02f, -9.25750956e-02f, -1.22972734e-01f, 1.20110154e-01f, 1.43688083e-01f, -1.32065779e-02f, -6.83416203e-02f,
  -5.62470071e-02f, 4.58012596e-02f, -1.07981823e-01f, 1.24667309e-01f, -4.64652032e-02f, -4.01223563e-02f, -4.99013700e-02f, 1.14980869e-01f, -5.48895560e-02f, -4.39360738e-02f,
  -5.56965619e-02f, -1.00344710e-01f, -5.11250719e-02f, 8.57908055e-02f, -9.38160121e-02f, 3.65068316e-02f, 7.70064220e-02f, 9.27766412e-02f, 9.65647623e-02f, 5.11158332e-02f,
  -1.47653177e-01f, -8.96792561e-02f, -6.75928965e-02f, -1.02074601e-01f, -4.80222665e-02f, -7.96886832e-02f, -1.46147981e-01f, 1.08570501e-01f, 1.34911433e-01f, -6.09178580e-02f,
  9.46834385e-02f, -9.12865326e-02f, 1.10036515e-01f, 3.18187065e-02f, -2.87263226e-02f, -1.34310871e-02f, -8.70311186e-02f, -1.04448758e-01f, -2.22556964e-02f, -3.07199545e-02f,
  -2.86371652e-02f, 1.00959882e-01f, -1.50955329e-02f, 3.22937034e-02f, -1.64430365e-02f, 7.70711079e-02f, 8.80713835e-02f, 1.87468939e-02f, 1.04384266e-01f, 4.74368744e-02f,
  -8.42036083e-02f, 1.20991975e-01f, -7.60182738e-02f, 8.76047462e-02f, 3.86546515e-02f, -4.11077812e-02f, -5.74455895e-02f, 2.16672961e-02f, 8.42317101e-03f, -4.77652401e-02f,
  1.11857474e-01f, 4.98366021e-02f, 9.09593701e-02f, 2.11643893e-02f, 1.09877005e-01f, 1.95733875e-01f, -3.62547599e-02f, 5.45878075e-02f, 7.65076503e-02f, 9.00495276e-02f,
  1.91695184e-01f, 1.32510319e-01f, -8.58084485e-02f, 8.37438405e-02f, 1.27022117e-01f, 9.52981785e-02f, 8.59767944e-02f, 7.39241317e-02f, 1.06485710e-01f, -2.96451133e-02f,
  -3.52415293e-02f, -7.43761100e-03f, 1.06858186e-01f, -5.97556345e-02f, -1.53293043e-01f, 1.26184657e-01f, -4.57699187e-02f, 1.55471966e-01f, 1.01919316e-01f, -2.07356274e-01f,
  -1.14891425e-01f, -1.32340357e-01f, 9.24136490e-02f, -2.62026966e-01f, 1.60768792e-01f, -8.58627111e-02f, -1.14878453e-01f, 1.41539704e-02f, -6.83643371e-02f, 4.88963611e-02f,
  -4.28616665e-02f, -1.54773798e-02f, -3.64356209e-03f, 2.27004901e-01f, -9.82163921e-02f, -1.38293326e-01f, -5.34685887e-02f, 2.07660228e-01f, 2.39587743e-02f, 2.21125092e-02f,
  -4.62151505e-02f, 3.00393533e-02f, 6.75091222e-02f, 1.74012240e-02f, -2.78924988e-03f, 1.34001911e-01f, -1.31234586e-01f, 1.14710685e-02f, 2.64324490e-02f, 1.51293010e-01f,
  -1.21451065e-01f, 1.11634523e-01f, -6.98088929e-02f, -5.09866187e-03f, 2.23106354e-01f, 3.64463776e-02f, 8.56318921e-02f, -3.17926034e-02f, 1.02551244e-01f, 5.98255321e-02f,
  1.46453187e-01f, -1.43815335e-02f, -3.30536962e-02f, -3.63407992e-02f, -7.15087950e-02f, -3.88308801e-02f, 4.16871905e-02f, 1.10933371e-01f, -7.97058269e-02f, 1.28352806e-01f,
  1.14210024e-02f, -6.73982129e-03f, 1.58425495e-02f, -5.38603775e-02f, 8.16570371e-02f, -3.15321535e-02f, -8.05172417e-03f, 1.52670160e-01f, 6.39198124e-02f, 1.84481852e-02f,
  1.22227162e-01f, 1.78531095e-01f, -3.19598429e-02f, 3.23927142e-02f, -7.70339295e-02f, -1.87386572e-01f, 5.60594676e-03f, 1.44156301e-02f, 1.35205224e-01f, 2.97962409e-02f,
  -4.45109755e-02f, -5.99109381e-02f, 5.73476218e-02f, 1.21502839e-01f, 1.95049673e-01f, -1.94489822e-01f, -1.02772795e-01f, -1.13919012e-01f, -1.10053075e-02f, -5.50013874e-03f,
  1.96587630e-02f, 2.46139526e-01f, 1.62432641e-01f, -8.68683532e-02f, -1.96022037e-02f, -1.24312006e-01f, -2.13583698e-03f, 2.27865409e-02f, -1.21416882e-01f, 1.75595641e-01f,
  -1.14672564e-01f, -8.32811370e-02f, 3.01684514e-02f, -1.29603446e-01f, 1.08732685e-01f, -4.68312204e-02f, -7.95464665e-02f, 2.68629808e-02f, 3.91920693e-02f, -1.00043394e-01f,
  4.23481837e-02f, -7.79773891e-02f, 6.18610391e-03f, -9.21735764e-02f, 4.10060249e-02f, 3.70527059e-02f, 6.02682009e-02f, -9.62187350e-02f, 1.12602517e-01f, 1.50894359e-01f,
  1.04015283e-01f, 1.74637839e-01f, 2.15310138e-02f, -3.43287848e-02f, 1.59701467e-01f, 1.62441447e-01f, 9.59754661e-02f, 1.54880792e-01f, 1.67900041e-01f, -8.38431623e-03f,
  -9.85061452e-02f, 1.81465045e-01f, 1.10448934e-01f, 5.32908849e-02f, 1.36612192e-01f, 2.44918838e-01f, 1.95356920e-01f, 2.11574584e-02f, -1.08576510e-02f, -2.42439449e-01f,
  7.06356615e-02f, -1.25521377e-01f, 1.49073690e-01f, -6.97325543e-02f, 1.55912697e-01f, -1.63172424e-01f, 1.88171789e-02f, 1.33963704e-01f, 2.16371372e-01f, -1.68902218e-01f,
  -1.13012813e-01f, 7.80334994e-02f, -1.14804402e-01f, -2.95118578e-02f, 5.12131155e-02f, 1.56348899e-01f, 9.95801687e-02f, -1.09030671e-01f, 9.67291147e-02f, -1.00730158e-01f,
  6.56352714e-02f, 4.74132225e-02f, -6.87588826e-02f, 1.42261013e-01f, 1.64680660e-01f, 1.10223545e-02f, -3.66980843e-02f, -7.73168355e-02f, 1.80310920e-01f, -8.43738988e-02f,
  9.09183323e-02f, 9.02793258e-02f, -7.60568678e-02f, 4.38253954e-02f, 1.29519388e-01f, 1.36220053e-01f, 1.09076791e-01f, -5.42058796e-02f, 2.64843069e-02f, 1.19570702e-01f,
  1.43178552e-01f, 6.73766015e-03f, 1.41008988e-01f, 6.66633025e-02f, -5.46341278e-02f, 1.27011567e-01f, -8.18000734e-02f, -7.13469908e-02f, -1.98928863e-02f, 1.53568015e-01f,
  -2.00801678e-02f, -2.94629503e-02f, -7.71591216e-02f, 1.55587390e-03f, 2.42772792e-02f, -3.97260487e-02f, 3.66377123e-02f, -5.81732690e-02f, 6.33497238e-02f, 1.41741529e-01f,
  6.81608915e-02f, -1.15986735e-01f, -7.32955337e-02f, -1.32080808e-01f, -8.62182751e-02f, 1.63580000e-01f, -2.99897455e-02f, -2.04411030e-01f, 8.78312737e-02f, 8.10779035e-02f,
  -1.76566988e-02f, -1.25482390e-02f, -1.06450818e-01f, -1.17499597e-01f, -8.28885660e-02f, 7.80354366e-02f, -1.16739109e-01f, 7.69894123e-02f, 1.47623308e-02f, 1.34824634e-01f,
  8.99831355e-02f, -1.10496372e-01f, -1.13277160e-01f, 7.91731328e-02f, 8.37264434e-02f, -4.90093566e-02f, 1.13721095e-01f, 2.17894334e-02f, 7.40231797e-02f, 3.26344813e-03f,
  -8.02081674e-02f, 8.26920345e-02f, 4.88351062e-02f, -7.17163607e-02f, 1.75119281e-01f, -6.44165725e-02f, 1.35590315e-01f, 2.22835332e-01f, 9.66396034e-02f, 9.50978026e-02f,
  1.06495567e-01f, 8.17243457e-02f, -4.41444516e-02f, -3.82398814e-02f, 5.63690998e-02f, 3.21830548e-02f, 1.12992339e-01f, -1.34681603e-02f, -2.97428202e-03f, 1.25254616e-01f,
  -9.33926031e-02f, 2.52228342e-02f, -5.06174043e-02f, -1.93024967e-02f, 2.19091531e-02f, 1.06495552e-01f, -6.32739589e-02f, 1.47127539e-01f, -5.41709214e-02f, -1.08983092e-01f,
  7.89486617e-02f, 1.20586522e-01f, -1.10366687e-01f, 3.51573005e-02f, 5.31966947e-02f, 5.39172962e-02f, 1.80586092e-02f, 5.61042465e-02f, -2.51181219e-02f, -5.77838123e-02f,
  -1.54846475e-01f, 1.29040226e-01f, 4.18304019e-02f, 5.34674972e-02f, -5.89993000e-02f, -4.01598029e-02f, -1.97176076e-02f, -6.23093434e-02f, 7.24098599e-03f, 1.33632272e-01f,
  7.83116445e-02f, -2.62285583e-02f, -7.08744898e-02f, 8.50535706e-02f, -3.98516506e-02f, 1.10242419e-01f, -3.48540694e-02f, 5.93713969e-02f, -1.38815530e-02f, -7.34494701e-02f,
  2.89066210e-02f, 1.12722114e-01f, 2.96982541e-03f, 8.02777782e-02f, 8.61168653e-02f, -2.82340683e-02f, -7.59114251e-02f, 1.18507616e-01f, -7.05045611e-02f, 5.45099229e-02f,
  1.72774658e-01f, 4.61286940e-02f, -2.65413802e-03f, -8.67768750e-02f, 9.68582835e-03f, -3.59497517e-02f, 4.45114225e-02f, 2.83656511e-02f, 1.17147458e-03f, 6.53676391e-02f,
  6.62933588e-02f, 6.00149333e-02f, 9.61042941e-02f, -1.72193274e-02f, 8.56399983e-02f, 3.62679623e-02f, 3.16684656e-02f, -9.82328057e-02f, -2.04844866e-02f, 1.03887260e-01f,
  5.81650017e-03f, 1.27548143e-01f, 1.02718577e-01f, -1.62121460e-01f, -2.50401888e-02f, 1.73521534e-01f, 5.37274107e-02f, -1.84483745e-03f, -1.15317784e-01f, -1.74577311e-01f,
  9.42300819e-03f, 5.16686700e-02f, 1.19707473e-01f, -2.90897805e-02f, -1.13403397e-02f, -2.69979872e-02f, -1.35939866e-01f, 1.30832568e-01f, 2.59761792e-02f, -9.53098666e-03f,
  -1.05462596e-01f, 1.10174768e-01f, 4.83906232e-02f, 9.64963064e-02f, 1.02615431e-01f, -6.10926263e-02f, -9.37730074e-02f, -1.19567297e-01f, -5.57823442e-02f, -3.90058896e-03f,
  6.52066916e-02f, 2.32222420e-03f, -3.69706638e-02f, -3.00402008e-02f, -9.74352211e-02f, 1.81432962e-02f, 4.46922071e-02f, -9.41680297e-02f, -2.00060569e-02f, 8.55868235e-02f,
  6.47652341e-05f, 4.78841551e-02f, 4.53188866e-02f, -6.14760742e-02f, 1.93402782e-01f, -1.06135443e-01f, 4.13043685e-02f, 7.99418092e-02f, 1.56801194e-01f, 4.62123640e-02f,
  1.05462439e-01f, 1.25576600e-01f, 7.02177510e-02f, 1.61059767e-01f, 6.96707070e-02f, 1.61278218e-01f, 2.34547257e-02f, 1.65669292e-01f, -1.22600712e-01f, -1.02489233e-01f,
  -4.46303971e-02f, 1.41307801e-01f, 1.22437857e-01f, -8.66255015e-02f, 4.53236066e-02f, -6.40648082e-02f, -7.61665478e-02f, -8.85761622e-03f, -5.92140406e-02f, -4.66619544e-02f,
  -6.64276630e-02f, -1.11484095e-01f, -1.96907103e-01f, -5.03476001e-02f, 4.85817455e-02f, -1.00881364e-02f, 5.38714416e-03f, 8.40423182e-02f, -1.13637142e-01f, -8.19736347e-02f,
  6.26157522e-02f, -1.17108881e-01f, -8.19008052e-02f, 1.33617878e-01f, -1.28106877e-01f, -1.63314313e-01f, 5.32005578e-02f, 9.44722593e-02f, 1.14854105e-01f, 4.18218672e-02f,
  -1.19657917e-02f, -7.90596828e-02f, 8.93334597e-02f, 6.69057742e-02f, -3.56458277e-02f, 4.90738116e-02f, 4.57340255e-02f, -1.70532688e-02f, 5.37465475e-02f, -8.44721645e-02f,
  -8.21536630e-02f, -1.22136243e-01f, -1.09716374e-02f, -8.39580297e-02f, -1.52254045e-01f, 1.75187495e-02f, 2.24017184e-02f, -9.03431699e-02f, 2.20481962e-01f, 7.53233880e-02f,
  1.80444896e-01f, 1.08325392e-01f, 7.62632713e-02f, -5.41073941e-02f, 1.27159894e-01f, 1.40203819e-01f, 1.23723589e-01f, -4.82500307e-02f, 2.46950379e-03f, -8.80245343e-02f,
  4.17287573e-02f, -6.10859646e-03f, 3.46368626e-02f, 1.05214059e-01f, 5.11917919e-02f, -1.90521348e-02f, -9.10201967e-02f, 3.61970291e-02f, 1.03029318e-01f, 1.22489557e-01f,
  -1.12582885e-01f, 1.16439760e-01f, 9.23225749e-03f, 7.62783438e-02f, -1.18787020e-01f, -1.10256426e-01f, -8.64746645e-02f, -8.80735442e-02f, 2.08108783e-01f, 3.75387818e-02f,
  -2.09715992e-01f, -7.43760765e-02f, 5.23889251e-02f, 8.08101743e-02f, -2.28731111e-02f, 1.40430391e-01f, -8.99047554e-02f, 3.92420739e-02f, -1.02039054e-01f, 2.90427387e-01f,
  1.42164543e-01f, 2.04637557e-01f, -3.87958027e-02f, -3.21991332e-02f, -7.66176311e-03f, 8.48469213e-02f, -1.24220429e-02f, 1.02108598e-01f, 1.38056874e-01f, -1.03214398e-01f,
  6.73888177e-02f, -1.53525487e-01f, -1.14498556e-01f, -1.06087532e-02f, 6.09167032e-02f, -1.73975453e-02f, 8.28709304e-02f, 1.78682163e-01f, 3.05116802e-01f, -6.01743497e-02f,
  -1.80842638e-01f, -9.62729901e-02f, 7.42835924e-03f, -5.25468448e-03f, -5.26280776e-02f, -8.85276124e-02f, -6.07023835e-02f, 5.56766652e-02f, 1.01617016e-01f, 2.84706187e-02f,
  1.49952173e-01f, 1.55553594e-01f, 1.11157559e-01f, 9.15743560e-02f, 1.34341745e-03f, 1.27139494e-01f, 3.27248834e-02f, -7.21984655e-02f, -1.39094805e-02f, -6.53720796e-02f,
  -8.85391161e-02f, 2.30254624e-02f, -5.31566329e-02f, 1.05532579e-01f, 4.03208286e-02f, 1.41004696e-01f, -1.23420268e-01f, 9.39819291e-02f, 1.07612446e-01f, 8.61478075e-02f,
  8.48510042e-02f, -1.29681349e-01f, 4.33854312e-02f, -8.37138072e-02f, 1.68052036e-02f, -5.76687567e-02f, 1.66145265e-01f, 7.60435686e-02f, 1.37283251e-01f, -8.41542929e-02f,
  6.74778149e-02f, 2.19970215e-02f, -3.52590829e-02f, -5.64893447e-02f, -3.72943580e-02f, -1.73298679e-02f, 1.96944773e-02f, -5.21795228e-02f, 5.27935214e-02f, 1.26519814e-01f,
  6.80103339e-03f, 5.13393134e-02f, -8.40829238e-02f, -3.71779948e-02f, -2.85030939e-02f, -6.74393326e-02f, 2.30234750e-02f, 5.64448014e-02f, 1.25316948e-01f, 2.72597298e-02f,
  -5.52963167e-02f, -6.73624277e-02f, -3.31598595e-02f, 6.30688563e-04f, 8.29713717e-02f, 3.06980554e-02f, 1.36398092e-01f, 6.18993379e-02f, 8.93008113e-02f, 1.53628483e-01f,
  4.59562242e-02f, -1.92348845e-02f, 1.08410884e-02f, -2.88856011e-02f, -6.17401116e-02f, 2.26589274e-02f, 1.15965262e-01f, -6.54245540e-03f, 9.85742509e-02f, -7.75028616e-02f,
  8.25727079e-03f, 1.04225911e-02f, -1.19491376e-01f, -1.01065785e-01f, -3.25522833e-02f, -1.11757569e-01f, 7.69146159e-02f, -1.07154354e-01f, -7.19376132e-02f, 7.99177140e-02f,
  1.07752308e-01f, -1.06696568e-01f, -1.45042082e-02f, 7.15858638e-02f, 8.74160677e-02f, 1.11950338e-01f, -2.01395713e-02f, -7.39469677e-02f, -6.45750985e-02f, 9.67197642e-02f,
  -1.45970166e-01f, 1.51854698e-02f, -1.18641302e-01f, 1.49992928e-01f, -1.12169273e-01f, 3.94122191e-02f, 2.61333138e-02f, -3.49910855e-02f, 9.22861472e-02f, -6.35995045e-02f,
  -1.44876685e-04f, 5.28480671e-02f, -1.05414875e-01f, -2.65576169e-02f, -6.95706010e-02f, -7.89618790e-02f, 8.39960352e-02f, -5.71815483e-02f, -1.32882074e-01f, -7.02355355e-02f,
  7.95720592e-02f, -9.61173177e-02f, 1.02975786e-01f, 5.49262315e-02f, -1.23597860e-01f, 7.39812627e-02f, 9.33041945e-02f, 8.43918994e-02f, 1.91723350e-02f, -6.58725202e-02f,
  8.73865932e-02f, -5.17162941e-02f, -7.08821639e-02f, -5.52135482e-02f, 4.91105802e-02f, 1.51480176e-02f, 1.69147655e-01f, 1.21113040e-01f, 6.02278151e-02f, 1.18863836e-01f,
  1.25112668e-01f, 2.24487871e-01f, 1.39663354e-01f, -8.25424716e-02f, 1.96043283e-01f, 5.99349886e-02f, 2.21677721e-02f, 1.70798644e-01f, 2.37883881e-01f, 9.11270231e-02f,
  2.31870607e-01f, 1.52962610e-01f, 9.75207463e-02f, -1.03777371e-01f, 1.76949188e-01f, 2.97804791e-02f, -1.10077418e-01f, -3.58950108e-01f, -2.96939850e-01f, 1.16864681e-01f,
  2.00306952e-01f, 1.86614186e-01f, -3.13879073e-01f, 1.44246608e-01f, -6.38439655e-02f, 5.80326356e-02f, -2.69687474e-01f, 1.51972696e-01f, 5.27548976e-02f, 1.52664676e-01f,
  -2.06292331e-01f, 3.13453943e-01f, 1.72768056e-01f, 2.94281423e-01f, -1.29502416e-02f, 1.48179367e-01f, -3.30455899e-02f, -6.35783449e-02f, -3.68331396e-03f, 1.66485161e-01f,
  1.03452384e-01f, -5.82903475e-02f, -1.51952252e-01f, -1.43260524e-01f, 1.43690005e-01f, -6.25012591e-02f, 9.99772176e-02f, 8.76813307e-02f, 2.70597581e-02f, 7.87504613e-02f,
  1.40251532e-01f, -1.13064945e-01f, 8.02301243e-02f, 8.06913748e-02f, 1.38361216e-01f, 5.58142923e-02f, -1.12020768e-01f, -1.09234288e-01f, -2.10245396e-03f, 7.18527436e-02f,
  1.45893544e-01f, 1.19390264e-01f, -2.34705415e-02f, -5.60995154e-02f, 8.21385533e-02f, -8.83993953e-02f, 1.29960939e-01f, -3.67446020e-02f, -9.96449366e-02f, -8.36595544e-04f,
  7.97087997e-02f, -4.36645886e-03f, -6.48228973e-02f, -9.01418254e-02f, 4.32929508e-02f, -9.34002101e-02f, 1.20735675e-01f, -7.82853365e-03f, 7.94306472e-02f, 9.13351402e-02f,
  5.89890741e-02f, 1.21710017e-01f, -2.66855825e-02f, -4.19023680e-03f, -3.38339657e-02f, 1.16676847e-02f, -2.06605084e-02f, 5.11202589e-02f, 1.02276035e-01f, -2.02875644e-01f,
  4.08830568e-02f, -1.41242191e-01f, 4.78814989e-02f, 4.78929430e-02f, 7.24028498e-02f, -3.66501557e-03f, 4.62779552e-02f, 9.61764604e-02f, 1.78440772e-02f, 1.04233034e-01f,
  -9.00267884e-02f, 1.40415743e-01f, 9.88262519e-03f, 1.17326133e-01f, -6.48726672e-02f, 1.74673926e-02f, -2.51193978e-02f, -1.77920070e-02f, 1.11691274e-01f, -4.69964407e-02f,
  -1.18031930e-02f, 2.84846518e-02f, -4.44115512e-02f, 1.82836014e-03f, -5.27517423e-02f, -7.06246421e-02f, 2.63852812e-02f, 4.36091051e-02f, 2.72957068e-02f, 8.81426483e-02f,
  -1.64356660e-02f, -2.54742317e-02f, -7.55279139e-02f, -2.24584211e-02f, -4.98318747e-02f, -2.64832787e-02f, 1.87700078e-01f, 1.60558987e-02f, 7.73421675e-02f, -5.22133671e-02f,
  9.70514491e-03f, 1.12874202e-01f, 1.52411759e-01f, -2.25897841e-02f, -3.70298587e-02f, 3.42912190e-02f, -1.48206260e-02f, 1.35234535e-01f, 1.80700570e-01f, 1.88475475e-01f,
  7.39950240e-02f, 1.48557007e-01f, 2.04236835e-01f, -3.22977938e-02f, 2.80150678e-02f, 1.16110146e-01f, 1.52971551e-01f, -3.13896537e-02f, 1.17047429e-01f, 1.14820495e-01f,
  6.60034940e-02f, 1.32807821e-01f, -2.38938901e-05f, 1.05584681e-01f, 1.02578156e-01f, 4.90918197e-02f, 1.66653037e-01f, -2.15363074e-02f, -1.09317474e-01f, 3.11877728e-02f,
  -2.01572664e-02f, -1.54097274e-01f, 4.00777273e-02f, -8.06316063e-02f, 9.05444548e-02f, 2.51269311e-01f, -1.00269578e-01f, -8.13820064e-02f, 1.23646207e-01f, -3.62969115e-02f,
  1.19264901e-01f, -7.71033345e-03f, -3.78777310e-02f, 1.46574751e-01f, 9.59582925e-02f, -2.90067885e-02f, 7.11056665e-02f, -1.07474081e-01f, 2.42608726e-01f, 1.08847059e-01f,
  9.73018035e-02f, 3.79899889e-02f, 5.21686599e-02f, -5.48473746e-02f, 1.57098733e-02f, -3.91059183e-02f, 1.08067989e-01f, -7.67352208e-02f, 5.83111905e-02f, -1.26807466e-01f,
  -1.42810876e-02f, -1.02090023e-01f, -6.83979392e-02f, 6.42148480e-02f, -8.31738021e-03f, -6.09324723e-02f, -8.96608680e-02f, -9.53722298e-02f, -9.44435317e-03f, 9.52945277e-02f,
  -1.15463911e-02f, 1.25948817e-03f, 4.81664427e-02f, -2.80971956e-02f, 8.94549116e-03f, -2.67004501e-02f, -6.31272271e-02f, -7.96409789e-03f, -4.48249234e-03f, -3.86844762e-02f,
  -1.22144058e-01f, -1.07477449e-01f, 2.98918653e-02f, -3.81385684e-02f, -5.83794080e-02f, 3.61960903e-02f, 1.25613511e-01f, 9.96800810e-02f, 1.18610308e-01f, 1.33409016e-02f,
  -7.40905926e-02f, -4.44811732e-02f, 3.34006548e-02f, 5.99348135e-02f, 1.23274820e-02f, -8.99073780e-02f, 6.78304359e-02f, 2.87812334e-02f, 2.07016766e-02f, -4.77864128e-03f,
  -3.22325267e-02f, 6.92555904e-02f, 7.62834912e-03f, -6.34761453e-02f, 1.60493534e-02f, 6.52754121e-03f, -5.35853468e-02f, 2.47030202e-02f, -8.12796280e-02f, 3.97540815e-02f,
  -9.46655273e-02f, -7.65459612e-03f, -4.82320525e-02f, -2.34513711e-02f, 6.62108660e-02f, 8.07598606e-02f, -1.39769852e-01f, 8.53487328e-02f, 1.31337177e-02f, 3.40151303e-02f,
  -1.71898529e-02f, -6.00032657e-02f, -4.76990268e-02f, -5.03142886e-02f, 1.42103955e-01f, 2.44092345e-02f, -3.84984538e-02f, 2.01303735e-02f, 1.46143347e-01f, 3.38810645e-02f,
  1.08801857e-01f, 4.17423137e-02f, 1.11661069e-01f, 2.34675780e-02f, 2.18696609e-01f, 4.88850400e-02f, 3.79034430e-02f, 7.49317631e-02f, 1.11122437e-01f, 1.05329804e-01f,
  1.35466577e-02f, 1.29840031e-01f, 1.31561652e-01f, 1.09690905e-01f, 1.50677145e-01f, -3.44131142e-02f, -5.03933430e-02f, 2.16870412e-01f, 8.11995268e-02f, 2.89453510e-02f,
  1.53481751e-03f, 1.95163369e-01f, 6.07077703e-02f, -3.67573611e-02f, 9.93455574e-03f, -1.02706462e-01f, -1.09770708e-01f, -8.18812549e-02f, -2.91362870e-02f, 3.68277170e-02f,
  1.15665883e-01f, -2.51110382e-02f, -5.04965633e-02f, 2.14505866e-01f, -4.80637439e-02f, -1.16886559e-03f, 1.27538472e-01f, 7.51218870e-02f, 1.08546698e-02f, -1.89391952e-02f,
  -9.67005864e-02f, 1.50435120e-01f, 5.67781925e-03f, -1.39126897e-01f, 1.17584489e-01f, 8.86074379e-02f, 6.41371384e-02f, -4.09664959e-02f, 1.69636384e-01f, -8.23944733e-02f,
  7.86914602e-02f, 1.27284450e-03f, -1.12578019e-01f, -1.16983503e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  -3.74074504e-02f, 9.74967107e-02f, -1.05665274e-01f, -1.66672189e-02f, 1.46032162e-02f, -2.98246183e-02f, 1.97051764e-01f, 1.25428900e-01f, 2.39794478e-02f, 9.78456661e-02f,
  1.20934844e-01f, 6.69207126e-02f, 1.25566535e-02f, -3.85663509e-02f, 1.32746637e-01f, 1.43804729e-01f, 2.14496208e-03f, 1.35104313e-01f, -1.08293826e-02f, 8.31408277e-02f,
  3.49744782e-02f, 2.51409840e-02f, -8.06460157e-02f, 1.55908570e-01f, -2.54222807e-02f, 9.66757610e-02f
};

// L3_fan_Wp (Shape: 19 x 64)
const int L3_fan_Wp_rows = 19;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  -9.38100070e-02f, 7.94021934e-02f, -7.38038868e-02f, 7.28528500e-02f, 1.58369299e-02f, 2.71231811e-02f, 3.94718200e-02f, 8.74844268e-02f, 4.48446199e-02f, 1.07057974e-01f,
  -1.12997331e-01f, 9.58160311e-02f, 1.71489596e-01f, 1.39677688e-01f, 1.78619146e-01f, -1.15547730e-02f, -4.36071912e-03f, 1.66811273e-02f, -8.11677277e-02f, 1.19011685e-01f,
  2.17603184e-02f, -1.90334007e-01f, -1.68755531e-01f, 9.82216075e-02f, 1.22250348e-01f, -1.62663117e-01f, 1.14982612e-01f, -7.15784580e-02f, -4.16742451e-02f, -5.51572889e-02f,
  1.13481022e-01f, 2.21794248e-01f, -1.25852332e-01f, -1.46060765e-01f, -8.14243481e-02f, 1.75031219e-02f, -1.39346883e-01f, 1.62914723e-01f, 7.89353810e-03f, -2.08322734e-01f,
  7.60169700e-02f, 1.97147597e-02f, 1.62818208e-02f, 1.00409408e-04f, 5.39519601e-02f, 1.49975643e-01f, 2.63453983e-02f, 1.85187504e-01f, 7.11474642e-02f, 1.45728573e-01f,
  6.77981749e-02f, -6.58278391e-02f, 1.67426616e-01f, 1.30055055e-01f, 1.12660795e-01f, 1.07410640e-01f, -2.37093017e-01f, -2.31779125e-02f, -8.32926407e-02f, -4.12845686e-02f,
  -3.34012732e-02f, 3.21716815e-02f, -1.19995445e-01f, 2.67052930e-02f, -1.85754627e-01f, -1.56562075e-01f, 4.25252877e-02f, -7.51003474e-02f, 3.79302204e-02f, -1.64518595e-01f,
  1.13451015e-02f, -1.41384199e-01f, -1.07096963e-01f, -7.60364234e-02f, -6.59694821e-02f, 6.95121987e-03f, -7.03772381e-02f, -2.97242347e-02f, -1.05153315e-01f, -1.54159114e-01f,
  -9.17530619e-03f, -1.09869100e-01f, 6.17124401e-02f, 2.17769042e-01f, -1.27304092e-01f, 1.63806245e-01f, -8.18236768e-02f, -6.05876967e-02f, -2.28528246e-01f, 9.23698843e-02f,
  -1.71574518e-01f, -1.12636283e-01f, -2.78425496e-02f, -2.09353790e-02f, -3.97078432e-02f, -2.03760907e-01f, 5.64779788e-02f, -3.36448029e-02f, -4.25814427e-02f, -6.73430413e-02f,
  8.04203004e-02f, -2.40283698e-01f, -9.88405868e-02f, 1.35173514e-01f, -4.58206311e-02f, 1.04157127e-01f, -3.79225314e-02f, 1.58768341e-01f, -2.82066762e-01f, -1.06988937e-01f,
  3.71169746e-02f, 1.69601366e-02f, -7.69313872e-02f, -8.73221457e-02f, 1.10949300e-01f, 1.52003020e-01f, 5.78188635e-02f, -5.27693778e-02f, -1.81432694e-01f, 3.56464386e-02f,
  1.28892750e-01f, 8.18491653e-02f, -5.00502698e-02f, 4.05336246e-02f, 4.46469449e-02f, 9.29941386e-02f, -4.83936481e-02f, 2.45038737e-02f, -1.58376470e-01f, 3.09105515e-02f,
  8.11700523e-02f, 8.83974973e-03f, 1.18824884e-01f, 1.92939062e-02f, 1.22143775e-01f, -2.35486571e-02f, 6.17227033e-02f, -2.65095353e-01f, -1.08959056e-01f, 1.07894704e-01f,
  -1.68205127e-01f, 1.07940190e-01f, 2.45643873e-02f, -9.10502002e-02f, -1.30668223e-01f, -7.05890637e-03f, 1.08518321e-02f, 2.74614245e-01f, -1.90301508e-01f, 1.27692550e-01f,
  2.78848857e-01f, 1.18039094e-01f, 8.19339827e-02f, 8.14916939e-02f, -2.14415073e-01f, -3.50440629e-02f, 2.65121490e-01f, 8.94423276e-02f, -4.00436064e-03f, -1.59145653e-01f,
  1.76771805e-01f, 2.43353546e-01f, -9.91793573e-02f, 1.50292004e-02f, 2.47298434e-01f, 8.53455067e-02f, 7.57828578e-02f, 1.83110639e-01f, -1.31720334e-01f, -5.69172837e-02f,
  -5.84483296e-02f, 1.15396209e-01f, -2.15693668e-01f, -3.45973670e-02f, 1.10176794e-01f, 4.81902948e-03f, -8.62180740e-02f, -1.10540532e-01f, 6.16006218e-02f, 1.99356563e-02f,
  3.45927887e-02f, 6.10888340e-02f, 4.65056933e-02f, -9.25660953e-02f, -4.37636860e-03f, -6.93137348e-02f, 6.40495569e-02f, 5.49542531e-02f, 3.62807214e-02f, 1.30683959e-01f,
  -1.03011958e-01f, -6.51246682e-02f, -2.09870059e-02f, 1.14806041e-01f, 7.56442770e-02f, -1.15287840e-01f, -2.87428856e-01f, 4.90130764e-03f, -9.13850516e-02f, -2.06660777e-02f,
  1.62412867e-01f, -6.18506186e-02f, -7.37620965e-02f, -1.11625485e-01f, 7.96129331e-02f, -1.02768876e-01f, -6.19743690e-02f, -2.42014267e-02f, 3.19190621e-02f, -5.00817299e-02f,
  5.83462678e-02f, 1.48656607e-01f, -1.47697642e-01f, -2.21832201e-01f, -2.90486217e-01f, 1.01057835e-01f, -2.18145009e-02f, 2.41977572e-02f, 1.67809308e-01f, -2.82453001e-01f,
  -6.75068498e-02f, 1.95070636e-02f, 2.35717654e-01f, -9.06602442e-02f, 4.73300517e-02f, 1.77112401e-01f, -1.54702455e-01f, 4.44073044e-02f, -1.28288954e-01f, 1.69892218e-02f,
  8.05686638e-02f, -2.22341985e-01f, -1.14401177e-01f, -6.56673610e-02f, 1.49795100e-01f, -1.01675399e-01f, -4.29931507e-02f, 5.22762910e-02f, 9.22646075e-02f, 1.53367385e-01f,
  -1.06752612e-01f, 3.54535840e-02f, 2.07760662e-01f, 1.85201585e-01f, 2.17674941e-01f, -4.50445991e-03f, -7.44319409e-02f, -1.25820145e-01f, -9.56562907e-02f, -3.28055918e-02f,
  6.95632771e-02f, -1.08315617e-01f, 1.40279099e-01f, -4.43463698e-02f, -8.45654756e-02f, 7.14176148e-02f, -1.37656465e-01f, -6.72089960e-03f, -3.96274738e-02f, 3.48148532e-02f,
  -1.08573541e-01f, 6.28098175e-02f, -1.60625540e-02f, 2.11863905e-01f, 1.62515268e-01f, -7.43444934e-02f, -4.08032574e-02f, 2.51156539e-02f, -9.78465304e-02f, -9.90670994e-02f,
  1.30499497e-01f, 4.14288044e-02f, -7.30351582e-02f, -8.84830654e-02f, -5.49018867e-02f, 1.01804033e-01f, 1.45388082e-01f, -2.07170442e-01f, -3.01598519e-01f, 1.89795554e-01f,
  2.15001211e-01f, -2.87353229e-02f, 1.82490394e-01f, -3.96025889e-02f, -1.42042525e-02f, 1.15256593e-01f, 2.03476503e-01f, -4.34430204e-02f, 3.07066869e-02f, 9.37453806e-02f,
  -1.18336201e-01f, -1.04137279e-01f, -2.12890714e-01f, -2.79004872e-02f, 9.93365571e-02f, -2.53354818e-01f, -6.63279444e-02f, 2.06263666e-03f, 6.73667043e-02f, -8.89920667e-02f,
  5.88152073e-02f, 4.39921431e-02f, -3.87444869e-02f, 1.14833295e-01f, 1.08181871e-01f, 5.31217307e-02f, 1.05336927e-01f, 1.95322424e-01f, 5.92335127e-02f, 1.28286630e-02f,
  3.21359038e-02f, 3.95919643e-02f, -2.17694864e-02f, 8.36112201e-02f, 4.42466773e-02f, -3.19365144e-01f, 1.26559898e-01f, 1.22386061e-01f, -9.27126929e-02f, 1.12336740e-01f,
  9.83521566e-02f, 4.55654636e-02f, -1.37124881e-01f, 2.34668970e-01f, -7.79777989e-02f, -9.51971635e-02f, -5.70787340e-02f, 1.61150277e-01f, -1.55257270e-01f, 1.41067699e-01f,
  1.48320608e-02f, -1.16444610e-01f, -4.22152765e-02f, 7.95752406e-02f, -2.03591976e-02f, -8.17010775e-02f, 1.89521089e-02f, 3.71692441e-02f, -4.05389927e-02f, -2.54088610e-01f,
  2.71760896e-02f, -1.54024929e-01f, -2.55319148e-01f, 8.59676078e-02f, 1.44587815e-01f, -4.94944490e-02f, 1.35365622e-02f, 2.26069748e-01f, -1.28253862e-01f, -1.90632567e-01f,
  -2.98700910e-02f, -5.86705878e-02f, -1.18419841e-01f, 4.08274643e-02f, 3.07304915e-02f, 1.43105626e-01f, 8.48704670e-03f, -9.19193253e-02f, -8.50550085e-02f, -9.81823076e-04f,
  -3.33391912e-02f, -3.77309509e-02f, -5.64622171e-02f, -1.94184095e-01f, 1.87662780e-01f, 8.11236277e-02f, 7.87734315e-02f, -4.08130400e-02f, 3.44632939e-02f, 1.18752509e-01f,
  4.84327525e-02f, -4.35800515e-02f, -1.47904847e-02f, -7.68828765e-02f, 4.03867364e-02f, -4.79219072e-02f, -1.24855451e-02f, 9.63987187e-02f, -4.51480895e-02f, -3.16521257e-01f,
  -1.11505687e-01f, 1.50757745e-01f, 8.90380517e-02f, 1.46643624e-01f, 2.35606954e-02f, 8.03540051e-02f, 1.11224353e-01f, 1.03892349e-01f, -4.71118428e-02f, -5.23920655e-02f,
  1.34245470e-01f, -3.17141339e-02f, -5.03176600e-02f, -1.55855209e-01f, 6.88456595e-02f, -4.31794338e-02f, 1.26650964e-04f, -3.58692207e-03f, -1.29192963e-01f, 8.43991786e-02f,
  1.18470788e-01f, 1.01179607e-01f, -4.36255187e-02f, 1.67568669e-01f, -1.66743711e-01f, 7.20314980e-02f, 3.18867862e-01f, 1.40491828e-01f, 2.32548676e-02f, 1.43146813e-01f,
  -2.76016742e-01f, 6.18431009e-02f, 2.08717197e-01f, 8.88617635e-02f, -1.89636543e-01f, 6.11608587e-02f, 1.36869133e-01f, 2.32109904e-01f, 9.81673971e-02f, -2.58973055e-02f,
  1.17608160e-01f, 1.55051962e-01f, -6.83572842e-03f, 1.82574093e-01f, -8.70272145e-02f, -4.63280082e-03f, 8.00252631e-02f, 8.88576731e-02f, -4.52878475e-02f, 5.62990382e-02f,
  6.53567761e-02f, 3.55217792e-02f, 8.31102058e-02f, -6.71680048e-02f, -3.32608745e-02f, -2.23754555e-01f, -7.83179775e-02f, -6.67750463e-02f, 6.02588318e-02f, 7.21484870e-02f,
  -8.64478853e-03f, 3.61935869e-02f, -7.86448717e-02f, 2.39825383e-01f, -1.04233734e-01f, 9.31233242e-02f, 1.68243926e-02f, 2.98795011e-02f, -5.15745357e-02f, -2.93489601e-02f,
  9.50935632e-02f, 5.11209248e-03f, 1.92150712e-01f, 2.45614462e-02f, -8.63237455e-02f, 1.43378943e-01f, -1.69556346e-02f, 1.04869738e-01f, 5.45000136e-02f, -4.88630645e-02f,
  4.18587066e-02f, -8.91558528e-02f, 6.94496632e-02f, -1.36855200e-01f, -3.81534547e-02f, 3.51412892e-02f, -1.97741628e-01f, -6.19479679e-02f, 2.27260520e-03f, 1.69700831e-01f,
  2.95820683e-01f, -1.13047041e-01f, -3.95176979e-03f, 2.89344997e-03f, -4.62459847e-02f, 1.32561401e-01f, -6.22746609e-02f, 1.22723855e-01f, -2.05831736e-01f, 1.91489488e-01f,
  -2.57544797e-02f, -1.37583226e-01f, 7.28627145e-02f, 1.54901206e-01f, -1.09288126e-01f, 1.60255522e-01f, -2.42772456e-02f, -6.85966611e-02f, 9.39215161e-03f, -1.22532077e-01f,
  -1.14409775e-01f, 2.44122185e-02f, -1.86560284e-02f, -1.20443791e-01f, -1.27472868e-02f, -1.64755598e-01f, -8.26579034e-02f, 6.81713894e-02f, -4.52203527e-02f, 1.69320796e-02f,
  -3.38096768e-02f, 2.27035098e-02f, 9.07130465e-02f, 9.77612585e-02f, 1.48125902e-01f, -3.09115108e-02f, 3.89972329e-02f, 1.75590500e-01f, -1.18390203e-01f, -1.39187217e-01f,
  -3.50535326e-02f, -1.98739283e-02f, -1.22128457e-01f, 3.76081355e-02f, -6.02392368e-02f, 1.89506918e-01f, -1.46240577e-01f, -6.19432367e-02f, 1.34985924e-01f, 2.20660567e-01f,
  6.20485954e-02f, 1.10130630e-01f, -3.30765434e-02f, 1.48811296e-01f, -5.26280329e-02f, -1.18072420e-01f, 1.26624554e-01f, 2.16743201e-02f, -1.72199570e-02f, -1.97697263e-02f,
  -1.86377808e-01f, 1.77986681e-01f, 8.14515054e-02f, -2.34421283e-01f, 1.64426938e-02f, 1.22479893e-01f, 3.11252117e-01f, 4.98302132e-02f, 2.12191805e-01f, -9.09649208e-02f,
  1.43176332e-01f, 1.16532378e-01f, 1.14636928e-01f, 1.71384826e-01f, 1.08308055e-01f, 1.21453017e-01f, 8.48219693e-02f, 1.05757244e-01f, -1.70109779e-01f, 2.60445684e-01f,
  8.87950808e-02f, -2.44964465e-01f, -3.09215635e-02f, -1.21686034e-01f, -7.24304095e-02f, 7.14667961e-02f, 1.25302270e-01f, -4.56585437e-02f, -1.06105097e-01f, -4.69406731e-02f,
  1.19898049e-02f, 1.04524970e-01f, 7.77516589e-02f, -4.51798812e-02f, 1.26327813e-01f, 9.71995741e-02f, -7.69405346e-03f, -1.25169888e-01f, -2.00977072e-01f, 3.65479738e-02f,
  -7.66408443e-02f, -1.53973311e-01f, 5.78287803e-02f, 1.79974273e-01f, -1.34403139e-01f, 3.73597257e-02f, -4.00261432e-02f, 4.11038883e-02f, 3.38966656e-03f, 2.34311417e-01f,
  1.67291060e-01f, -2.59026326e-02f, -2.18270011e-02f, -1.02834003e-02f, -1.72886968e-01f, -1.30243808e-01f, 2.81994920e-02f, -7.34173283e-02f, 5.10211773e-02f, 5.32232560e-02f,
  -1.17163248e-01f, -7.78559595e-03f, -7.57444724e-02f, 6.92484081e-02f, 4.15991955e-02f, -1.94130674e-01f, -1.93397850e-02f, 5.43894842e-02f, 1.60942763e-01f, -1.01255953e-01f,
  -7.07275942e-02f, 1.20706484e-01f, -6.93386123e-02f, 1.68568254e-01f, -7.76003301e-02f, 4.07861136e-02f, -6.01593144e-02f, -1.84310421e-01f, -1.03873737e-01f, 1.21688128e-01f,
  -7.31961895e-03f, 3.69853489e-02f, 2.14528874e-01f, 1.45215943e-01f, 3.34792472e-02f, 1.28403202e-01f, 1.32861063e-01f, 9.43191275e-02f, 3.50881070e-02f, -4.83097173e-02f,
  -2.24572793e-02f, 1.01862147e-01f, -3.29076946e-02f, -3.69432792e-02f, 4.97672148e-02f, -1.67807609e-01f, -7.55903721e-02f, -3.43701132e-02f, -6.43856525e-02f, -6.04448542e-02f,
  1.59315601e-01f, -5.84397689e-02f, 1.38194531e-01f, -8.86109024e-02f, 7.10559562e-02f, 2.35885382e-01f, -3.87752652e-02f, 9.85800251e-02f, 1.13142028e-01f, 2.44510267e-02f,
  2.08910815e-02f, 1.30015478e-01f, 2.43081860e-02f, -1.38674453e-01f, -7.93231875e-02f, -6.51585162e-02f, -1.57348484e-01f, 6.89247847e-02f, 1.30188286e-01f, 8.04905742e-02f,
  -3.79010700e-02f, -8.51819441e-02f, 3.58892828e-02f, 2.59091277e-02f, 1.79649964e-01f, 5.35028838e-02f, 8.43859613e-02f, 2.85667907e-02f, -1.47776216e-01f, 6.71382807e-03f,
  1.27925262e-01f, -4.47323285e-02f, -2.89924489e-03f, -6.76531792e-02f, 6.40094876e-02f, -2.28114426e-01f, 1.43964708e-01f, -1.62131011e-01f, -3.55087258e-02f, 5.06180618e-03f,
  1.08868182e-01f, 1.87131390e-01f, -1.72754988e-01f, -1.26035988e-01f, 1.04689591e-01f, 1.00485802e-01f, -1.97503939e-01f, 1.15196563e-01f, 4.47869524e-02f, -2.09390402e-01f,
  8.07318613e-02f, -1.20949663e-01f, 3.76915024e-03f, -4.31050966e-03f, -1.06924772e-02f, 3.80641334e-02f, 6.97285607e-02f, 4.21755277e-02f, -4.78328280e-02f, 8.86243656e-02f,
  8.79394114e-02f, 1.35407209e-01f, 9.71261561e-02f, -8.33632499e-02f, 1.17191575e-01f, 1.53534755e-01f, -2.17560932e-01f, -3.43272239e-02f, -2.68974286e-02f, 4.10931520e-02f,
  1.35822311e-01f, -6.28090575e-02f, 5.85238896e-02f, -3.33308466e-02f, 8.02129209e-02f, 2.33510230e-02f, -1.77518688e-02f, 6.35556430e-02f, 1.60233080e-02f, -3.74301597e-02f,
  -1.43691003e-01f, 1.30100504e-01f, 4.83990461e-02f, 1.45325199e-01f, 7.95243606e-02f, -6.79229051e-02f, 2.41484284e-01f, -8.26588273e-02f, 1.11079104e-01f, 5.08938581e-02f,
  1.50580078e-01f, 2.60787252e-02f, -1.02955690e-02f, -1.22231334e-01f, 1.42954588e-01f, -1.37718558e-01f, 1.02951400e-01f, 8.20300728e-02f, -2.06920840e-02f, -2.21485242e-01f,
  -4.82040271e-03f, -1.73186675e-01f, -1.81260183e-01f, 1.58674121e-01f, 1.78296138e-02f, 1.96407527e-01f, -2.45132327e-01f, -2.28931829e-02f, 8.20731670e-02f, 7.09186569e-02f,
  -1.94168329e-01f, -4.68387716e-02f, 1.24032848e-01f, -7.17412382e-02f, -9.12415907e-02f, -1.20815508e-01f, -6.81117922e-02f, -8.43861252e-02f, 1.01479836e-01f, 1.03925765e-01f,
  -1.09085388e-01f, 5.93940653e-02f, 1.20514810e-01f, 1.59405068e-01f, 9.63758826e-02f, -2.58264877e-02f, 8.04295111e-03f, -2.49759704e-02f, 1.26976445e-02f, 1.96389645e-01f,
  7.67597184e-02f, 3.27634215e-02f, 1.41047798e-02f, -1.60715133e-01f, 2.41545811e-02f, -1.15974478e-01f, 5.75478002e-02f, -1.26989931e-01f, -1.29420921e-01f, -9.10124108e-02f,
  -1.04577981e-01f, -5.54532111e-02f, -2.42434423e-02f, -1.54599458e-01f, 6.35210797e-02f, -1.46692574e-01f, -2.98407692e-02f, -2.85038985e-02f, -1.33986734e-02f, -5.46742603e-02f,
  -1.40965834e-01f, 4.63524833e-02f, -1.01931587e-01f, 2.11369973e-02f, -1.75620064e-01f, -9.74609926e-02f, 1.17575213e-01f, 1.19255066e-01f, -1.58571899e-01f, -4.45791753e-03f,
  -5.61595522e-02f, -9.21902061e-02f, -2.41898775e-01f, 1.84623405e-01f, -2.40334217e-02f, 4.59171552e-03f, 1.37315355e-02f, 7.26415366e-02f, 9.48271677e-02f, -1.45590752e-01f,
  1.11793831e-01f, 8.03475305e-02f, -4.18244675e-02f, -1.05982915e-01f, 5.95242642e-02f, -2.21845761e-01f, 5.14031015e-02f, 1.45479783e-01f, 8.38993862e-03f, -4.85944003e-02f,
  1.49580806e-01f, 1.26006708e-01f, -2.48004884e-01f, -1.10174716e-01f, 7.31207207e-02f, -1.08635589e-01f, -1.04373805e-01f, 2.41169352e-02f, -6.92152884e-04f, 1.96007967e-01f,
  3.01218815e-02f, -9.36648548e-02f, -1.22628339e-01f, -1.50192171e-01f, -4.24336717e-02f, 8.19327533e-02f, -6.88473061e-02f, 5.59315532e-02f, -7.47785419e-02f, 5.80718406e-02f,
  9.72606093e-02f, -1.10342212e-01f, -5.23965284e-02f, -1.40401691e-01f, 4.79003526e-02f, -1.66507512e-01f, 1.96502537e-01f, 2.70315502e-02f, -1.65540408e-02f, -1.34545401e-01f,
  4.92137820e-02f, 1.46167755e-01f, -6.37624087e-03f, -3.19235288e-02f, 1.51033364e-02f, -9.90695283e-02f, 1.01444609e-01f, -1.55076116e-01f, -4.90357168e-02f, -2.56164353e-02f,
  -1.53524652e-01f, 3.34077440e-02f, -1.31698418e-02f, 1.82359785e-01f, -3.42880003e-02f, -6.67950660e-02f, -8.27423632e-02f, -6.79702982e-02f, 4.59495485e-02f, 1.75446510e-01f,
  -1.22512192e-01f, 1.67041123e-02f, -1.24527581e-01f, 1.40794381e-01f, -5.56891263e-02f, 5.16632712e-03f, 2.06817627e-01f, 8.34182203e-02f, 1.42902536e-02f, 1.26087993e-01f,
  2.46172491e-02f, 1.80715501e-01f, -2.22491473e-02f, -7.66966566e-02f, 7.89042786e-02f, -7.28588030e-02f, -7.38904849e-02f, 7.72750303e-02f, -1.15333065e-01f, -1.99627891e-01f,
  -1.50054190e-02f, -1.01531461e-01f, -5.28497137e-02f, -1.04224697e-01f, 1.95768420e-02f, 1.19864330e-01f, 4.47926548e-04f, -3.77128758e-02f, -2.75039370e-03f, 1.56422388e-02f,
  1.12680130e-01f, 1.92592919e-01f, -1.05248146e-01f, -1.38867334e-01f, 8.21158066e-02f, -1.19766489e-01f, 6.38086870e-02f, -2.43444834e-02f, -8.39040875e-02f, -2.37765893e-01f,
  1.19491383e-01f, -6.04660511e-02f, -1.85748115e-01f, -7.09283054e-02f, -1.99215002e-02f, 1.63287953e-01f, -3.11277863e-02f, 4.87174615e-02f, 1.59523413e-01f, 7.05515370e-02f,
  1.81792259e-01f, 1.21168919e-01f, 1.26050785e-01f, 8.67756680e-02f, -1.40529037e-01f, 1.39958523e-02f, 1.97262764e-02f, 4.48864326e-02f, 1.65843349e-02f, 9.21448767e-02f,
  -2.92867590e-02f, -2.14561895e-01f, 1.14591599e-01f, -2.00385675e-01f, -1.96032152e-01f, 1.70774803e-01f, -9.93709043e-02f, 2.72983104e-01f, 3.15338410e-02f, -1.21289007e-01f,
  1.55446082e-01f, 6.76574335e-02f, -2.05317408e-01f, -2.87076961e-02f, -6.33997694e-02f, 5.70893362e-02f, 3.23982164e-02f, -1.50741175e-01f, 4.54077683e-02f, -9.33518410e-02f,
  -8.05703551e-02f, -8.00487399e-03f, 2.51141395e-02f, 9.82427690e-03f, 6.93275221e-03f, 1.87451497e-01f, 4.79229493e-04f, 1.85876936e-02f, 1.58349186e-01f, -2.06738478e-03f,
  5.21381684e-02f, 2.21094832e-01f, -1.52701274e-01f, -3.88484113e-02f, -2.76360102e-03f, 1.19119644e-01f, 1.25809327e-01f, -2.07065150e-01f, 9.43925232e-02f, -2.07048878e-01f,
  3.16067040e-02f, 6.41172677e-02f, 2.38907393e-02f, 1.21195130e-01f, 9.17314664e-02f, 6.60194904e-02f, -3.68457288e-02f, -3.48588526e-02f, 1.20221106e-02f, -7.83999860e-02f,
  9.71830823e-03f, -4.22974601e-02f, 5.68460822e-02f, -3.78444828e-02f, -8.22893456e-02f, 1.07757516e-01f, 2.79094279e-02f, 3.99973653e-02f, 7.06707686e-02f, -1.88762531e-01f,
  -5.22052050e-02f, 2.41591483e-02f, 4.15037155e-01f, -2.62394566e-02f, 1.57737449e-01f, -2.93202270e-02f, -1.89715415e-01f, 3.04204136e-01f, -1.19952755e-02f, -4.91389818e-02f,
  -7.93961361e-02f, 7.83500299e-02f, 4.07694876e-02f, 7.78881600e-03f, 1.17577046e-01f, 1.72776192e-01f, -8.74792710e-02f, 3.34764004e-01f, -1.09500907e-01f, 3.92356440e-02f,
  -1.03693165e-01f, 4.57235426e-02f, -5.99097610e-02f, 1.13426112e-01f, 6.21930882e-02f, 2.00895518e-02f, 8.04239213e-02f, -1.25170529e-01f, 2.54527144e-02f, -4.50598188e-02f,
  -1.82581022e-01f, -1.00517809e-01f, -7.83205181e-02f, 1.00641482e-01f, 1.80349082e-01f, -6.82013482e-02f, 7.65890852e-02f, -1.09573349e-01f, 9.51253250e-02f, 2.23011702e-01f,
  -9.28101987e-02f, 2.87696887e-02f, -5.38785644e-02f, 1.54030859e-01f, 6.68398961e-02f, -7.35153258e-03f, -5.33005930e-02f, -1.20849334e-01f, 1.49380729e-01f, 8.00797045e-02f,
  5.40602580e-02f, -1.26166880e-01f, -7.20522925e-02f, 7.62363598e-02f, 1.49180442e-02f, -4.12308574e-02f, -1.26090199e-01f, -7.18532130e-02f, 6.54309541e-02f, -5.32124452e-02f,
  3.58714946e-02f, 7.65410364e-02f, -1.59512162e-01f, -1.30919944e-02f, -1.62860826e-01f, 2.41176367e-01f, 2.93308228e-01f, -1.76483959e-01f, 5.96216321e-03f, 9.90625620e-02f,
  -1.27485305e-01f, 1.98440403e-01f, -2.09916523e-03f, -7.51492754e-02f, -2.36880213e-01f, -1.26008913e-01f, -1.11183725e-01f, 2.54961569e-02f, -6.05095830e-03f, 6.12744242e-02f,
  6.25447705e-02f, 8.17322545e-03f, -1.08449444e-01f, 1.99113443e-01f, -8.39336738e-02f, 8.76260921e-02f, -4.87951972e-02f, 1.69905484e-01f, -1.67142265e-02f, -1.61653548e-01f,
  -8.68142992e-02f, -2.69783169e-01f, -1.08475648e-01f, -6.29705861e-02f, -1.14070438e-01f, -5.46694873e-03f, -1.01006024e-01f, -3.16633433e-02f, 4.58250940e-02f, -2.17865258e-02f,
  2.19664440e-01f, -1.54670119e-01f, 6.71385750e-02f, 1.53267324e-01f, 3.61316986e-02f, 5.14080189e-02f, -7.43130744e-02f, 1.79702193e-02f, 7.17375986e-03f, -9.75758061e-02f,
  1.14389412e-01f, 1.45624939e-03f, -1.70143381e-01f, -1.74399354e-02f, 1.15220629e-01f, -1.50902132e-02f, -2.05987543e-02f, -3.22871767e-02f, -1.66884847e-02f, 5.48831634e-02f,
  1.36372656e-01f, 1.47803545e-01f, -3.67478505e-02f, 7.86459222e-02f, 8.79481286e-02f, 4.48839851e-02f, 2.41533704e-02f, 1.51815951e-01f, -6.05209311e-03f, 3.64339426e-02f,
  2.70131558e-01f, 8.93143378e-03f, 2.10077509e-01f, 9.54207480e-02f, -1.49021536e-01f, -1.43076017e-01f, -1.50743127e-02f, -9.40093771e-03f, -8.68151635e-02f, -1.21567547e-02f,
  8.27775747e-02f, -5.67775145e-02f, -9.21786353e-02f, -8.10912251e-02f, -7.87732154e-02f, 2.44528756e-01f, -4.24813516e-02f, -1.43537462e-01f, -1.38497502e-01f, 6.91301525e-02f,
  5.80822937e-02f, -1.31560136e-02f, 1.50923235e-02f, 1.28484190e-01f, -1.28401965e-01f, -1.09961137e-01f, -7.67136291e-02f, -1.48661509e-01f, -9.43851545e-02f, -5.25565781e-02f,
  1.95642143e-01f, -1.18517429e-01f, 1.13599755e-01f, 1.38164580e-01f, -1.74742490e-01f, 6.94054663e-02f, 5.60833327e-02f, 8.90229084e-03f, 2.47672517e-02f, 5.53296655e-02f,
  -2.04263404e-02f, 1.15119003e-01f, 9.73802730e-02f, 1.33445233e-01f, -4.78955880e-02f, 9.89194959e-04f, 1.40256882e-01f, -8.26838464e-02f, -1.09932937e-01f, -2.46789474e-02f,
  4.16879877e-02f, 2.19252631e-01f, 5.84404580e-02f, 2.02007480e-02f, 6.72634169e-02f, 7.94203505e-02f, 2.31122792e-01f, -3.36203277e-02f, -8.77560377e-02f, -4.40604473e-03f,
  -1.31459206e-01f, -2.43055761e-01f, 1.31328538e-01f, -3.33503112e-02f, -6.99146762e-02f, -3.45888250e-02f, 7.48305321e-02f, -4.66698520e-02f, 2.08288938e-01f, -3.30740889e-03f,
  -9.90144610e-02f, 6.96605295e-02f, -1.22028649e-01f, 2.70968378e-01f, -1.00079067e-01f, -3.14227581e-01f, 1.87630326e-01f, 6.69143423e-02f, -2.83378184e-01f, 1.70220062e-01f,
  8.09443444e-02f, -1.42535552e-01f, -8.32425728e-02f, -1.22414738e-01f, -3.52486148e-02f, -2.22840589e-02f, 3.03653796e-04f, 1.17333606e-01f, 5.18157147e-02f, 4.35824366e-03f,
  1.73983201e-01f, 2.23044962e-01f, 9.17028263e-02f, -2.09884644e-02f, -8.86082947e-02f, 3.51309665e-02f, 1.23147622e-01f, 6.10590503e-02f, 5.04449233e-02f, 4.94927093e-02f,
  7.64956400e-02f, 2.66418364e-02f, -3.04632802e-02f, -1.31139040e-01f, -7.90369138e-02f, 4.86250501e-03f
};

// L3_fan_Wp_bar (Shape: 26 x 64)
const int L3_fan_Wp_bar_rows = 26;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  -5.96457943e-02f, 1.71311632e-01f, 9.14743822e-03f, 7.82097876e-03f, -4.23925184e-02f, 6.44904524e-02f, 5.84469140e-02f, -6.77659735e-02f, 1.17003508e-01f, -8.52856860e-02f,
  1.43459082e-01f, 4.34480794e-02f, -8.36304277e-02f, -8.37589577e-02f, 1.39456123e-01f, 8.80463421e-02f, 1.14182234e-01f, -4.35981192e-02f, -5.69564812e-02f, 9.29232016e-02f,
  6.15411811e-02f, -1.72163218e-01f, -1.10507920e-01f, 5.42135164e-02f, -1.32900383e-03f, 4.03714888e-02f, 1.84730977e-01f, -2.22216129e-01f, -8.83645415e-02f, 5.21669462e-02f,
  1.28824428e-01f, 2.63506919e-02f, 4.17031422e-02f, -3.69161852e-02f, -2.28977893e-02f, -3.20967101e-02f, 1.20933568e-02f, -8.00838917e-02f, 7.56338015e-02f, -1.10390030e-01f,
  6.01348579e-02f, -8.90605003e-02f, -3.68188359e-02f, -6.80119172e-02f, -3.03895306e-02f, 1.19512893e-01f, -4.44417149e-02f, -2.76209842e-02f, 1.34977162e-01f, -5.27051948e-02f,
  -2.98250816e-03f, 1.75964415e-01f, -6.26951084e-02f, 7.99397826e-02f, -1.49303690e-01f, -7.86990598e-02f, -4.14371453e-02f, 5.24109192e-02f, -1.32672846e-01f, 3.44673321e-02f,
  6.12563901e-02f, 1.74042657e-01f, 1.14051066e-01f, 4.26489189e-02f, -6.41028956e-02f, 3.15232761e-02f, 1.05241217e-01f, 1.00369476e-01f, -1.16304375e-01f, 1.47158861e-01f,
  -1.00697009e-02f, 6.00658953e-02f, 1.78431049e-01f, -7.37238973e-02f, 4.29224446e-02f, 1.66372001e-01f, -8.22755694e-02f, -6.81557655e-02f, -2.97843311e-02f, 1.03854589e-01f,
  -4.80886688e-03f, -1.00238882e-01f, -6.14642613e-02f, 1.66548908e-01f, -1.21718533e-01f, 4.39061288e-04f, 1.45773897e-02f, 8.89963880e-02f, 1.12447083e-01f, -4.42921035e-02f,
  1.47445455e-01f, -1.91338137e-01f, 7.78993294e-02f, 1.03068382e-01f, 1.56472117e-01f, 1.66451037e-01f, 1.55557856e-01f, 8.06781650e-02f, 1.54697953e-03f, 1.37093375e-02f,
  -2.20156476e-01f, -2.01595463e-02f, 8.33937302e-02f, -1.38556078e-01f, -1.27378702e-01f, 3.79549414e-02f, 1.21786278e-02f, 2.24372372e-02f, 6.88826665e-02f, -1.28717124e-02f,
  -6.01677736e-03f, 9.19017121e-02f, 5.07155322e-02f, 1.69789001e-01f, -8.92342404e-02f, 9.15807784e-02f, 3.24079506e-02f, 1.46987690e-02f, -7.06976652e-02f, 1.74682349e-01f,
  -9.75959301e-02f, 1.89606124e-03f, 1.12287313e-01f, -8.07230547e-02f, -3.44310030e-02f, 6.79703131e-02f, -4.94729392e-02f, 4.83127385e-02f, 8.23017433e-02f, 5.01879565e-02f,
  -9.90236700e-02f, -1.37877554e-01f, -4.86942334e-03f, 1.84307531e-01f, -3.18031549e-03f, -1.62638515e-01f, 3.00863720e-02f, 2.04473436e-02f, 1.45101905e-01f, 4.39733863e-02f,
  6.64623976e-02f, 9.05921310e-03f, -4.03527208e-02f, 1.73117086e-01f, -6.06394596e-02f, 3.36730257e-02f, 1.25640169e-01f, -3.38391252e-02f, 1.41565889e-01f, 1.21923806e-02f,
  -1.65743843e-01f, -1.31496415e-02f, -1.95453316e-01f, -6.49460480e-02f, 1.44902468e-01f, -1.86247259e-01f, 3.49802189e-02f, -2.16727853e-02f, 1.49645463e-01f, 9.10679549e-02f,
  7.26467371e-02f, 1.49833476e-02f, -6.14862144e-02f, -1.53399453e-01f, -6.65523335e-02f, -1.32272854e-01f, 8.68507549e-02f, 7.42576942e-02f, -1.14565097e-01f, -1.27953261e-01f,
  -1.03879735e-01f, 1.30669355e-01f, 4.16309424e-02f, -9.36565921e-02f, -8.60827714e-02f, 3.36869843e-02f, 8.53102058e-02f, 1.89319566e-01f, 3.57240178e-02f, 1.15021236e-01f,
  1.83936879e-01f, -5.75119555e-02f, -1.05593525e-01f, 1.14571981e-01f, -1.40877105e-02f, 1.73046082e-01f, 1.08082026e-01f, -9.21337605e-02f, 1.09227046e-01f, -4.05372195e-02f,
  -9.75445509e-02f, -1.04659006e-01f, -8.77597854e-02f, 1.71998441e-01f, 1.52390108e-01f, -7.45829791e-02f, -1.50761530e-01f, -5.64604104e-02f, 1.49337545e-01f, 9.64288637e-02f,
  1.81259289e-02f, 2.97709461e-02f, -8.58761966e-02f, 1.56958103e-01f, 3.12409233e-02f, -1.44449284e-03f, -4.95112240e-02f, 2.88909301e-02f, -1.73694883e-02f, 4.91318256e-02f,
  -7.04708099e-02f, 1.80107340e-01f, -1.03205569e-01f, -7.15193227e-02f, 6.44425452e-02f, 9.28836241e-02f, 5.78216948e-02f, -7.75965601e-02f, 2.90019419e-02f, 7.74322217e-03f,
  -1.65435020e-02f, 7.73480013e-02f, 1.20609321e-01f, 9.61314365e-02f, 5.40131368e-02f, 1.50475696e-01f, 1.06728308e-01f, 3.06746047e-02f, -6.23189472e-02f, -1.50501579e-01f,
  -8.92170444e-02f, 1.19272843e-01f, 2.32276488e-02f, 9.06627327e-02f, -1.60306618e-02f, -6.63884431e-02f, -1.04294769e-01f, -3.50495316e-02f, 8.92888382e-02f, -7.88339153e-02f,
  -2.71929782e-02f, -6.13074079e-02f, 6.23339787e-02f, 9.35104862e-02f, 1.18877061e-01f, 4.83425185e-02f, -1.15938291e-01f, 8.50492269e-02f, -9.88562331e-02f, 1.29760783e-02f,
  5.68697862e-02f, -4.02131006e-02f, 2.02146303e-02f, -1.91796646e-02f, -6.49420470e-02f, 4.40740697e-02f, -5.45829795e-02f, -2.33586635e-02f, -4.49889228e-02f, 1.08893588e-01f,
  -9.45899114e-02f, -7.33142346e-02f, 5.46538457e-02f, 1.47410437e-01f, -6.99519664e-02f, 1.62151292e-01f, 5.78322597e-02f, 4.77603450e-02f, 7.44167864e-02f, -8.31935927e-02f,
  -2.98583563e-02f, 1.08363912e-01f, 1.22123063e-01f, 1.76035836e-01f, 3.58754396e-02f, -2.22129431e-02f, 2.29715133e-05f, -1.04361206e-01f, -2.00615093e-01f, -3.13730687e-02f,
  -6.77927285e-02f, -1.76516652e-01f, -4.61092815e-02f, 1.04897931e-01f, 4.39176522e-02f, 4.84746099e-02f, 1.30320191e-01f, 5.86165786e-02f, -1.47695631e-01f, 1.67351961e-01f,
  -1.29789963e-01f, 4.39076163e-02f, -8.97948295e-02f, 9.20985043e-02f, -3.83712091e-02f, 6.56515583e-02f, -2.26251110e-02f, -4.81455699e-02f, 5.09376712e-02f, -1.37728110e-01f,
  4.39345092e-02f, -3.54833342e-02f, 8.59233364e-02f, -1.61742158e-02f, -9.94549468e-02f, 7.21322447e-02f, 4.32540216e-02f, 3.25011015e-02f, 8.68042707e-02f, 1.07830040e-01f,
  5.27493395e-02f, -1.11448847e-01f, -3.19483839e-02f, 5.24582304e-02f, -1.10032804e-01f, -7.83494413e-02f, 4.96395156e-02f, -7.38757029e-02f, -3.15146074e-02f, 9.82705355e-02f,
  1.52300164e-01f, 6.58625737e-02f, 2.13642567e-01f, -2.21451342e-01f, 4.38691750e-02f, 7.22666979e-02f, 2.85072234e-02f, -1.24137513e-02f, 2.54205436e-01f, -1.24648713e-01f,
  9.24931765e-02f, 2.22660631e-01f, 1.37292296e-01f, 4.01772931e-03f, 1.75459504e-01f, 4.47795838e-02f, 1.85011610e-01f, -2.48971954e-02f, -1.29222587e-01f, 7.02188611e-02f,
  -1.39146999e-01f, 2.57776380e-01f, 2.77536005e-01f, 8.99026096e-02f, -1.54952049e-01f, -2.44349670e-02f, -3.15357685e-01f, 1.66532159e-01f, 2.38283843e-01f, 1.89106360e-01f,
  -2.16058627e-01f, 1.20804615e-01f, -4.05760296e-02f, -5.63270822e-02f, 1.67078599e-01f, -3.55708599e-02f, -1.79126747e-02f, 2.70183235e-01f, 1.20177921e-02f, 6.12455718e-02f,
  9.77277234e-02f, -2.61586867e-02f, 8.99598449e-02f, 7.02336710e-03f, 9.95505415e-03f, 8.52470398e-02f, -1.39766350e-01f, -2.09671959e-01f, -5.22726960e-02f, -2.42452100e-02f,
  -1.72585428e-01f, -2.30901971e-01f, 5.19200787e-02f, -4.60587591e-02f, 9.18876082e-02f, 1.37838125e-01f, 8.50709900e-02f, 4.26742211e-02f, 6.60527200e-02f, 4.98541594e-01f,
  -2.88378801e-02f, 1.00595271e-02f, -1.05040982e-01f, -2.57662665e-02f, 1.30604491e-01f, 5.19353524e-02f, -6.93151280e-02f, 1.39528170e-01f, -5.40694408e-02f, 6.36941269e-02f,
  -2.24719197e-02f, -6.94857836e-02f, 1.03297263e-01f, 5.18093072e-02f, 1.08749919e-01f, 1.69980675e-01f, 4.95767966e-02f, 1.46000236e-01f, 1.01523593e-01f, 6.59145191e-02f,
  1.56467438e-01f, 7.41674006e-02f, 1.43405646e-01f, 1.86138391e-01f, 9.45750531e-03f, -1.66665673e-01f, -3.03235710e-01f, 5.58110625e-02f, -2.27813914e-01f, 1.23626329e-01f,
  1.29820213e-01f, 5.91289327e-02f, 1.18133247e-01f, -7.38822445e-02f, 5.84568493e-02f, -2.85767138e-01f, 1.43139496e-01f, 1.39761850e-01f, -2.88773388e-01f, -3.67451608e-02f,
  2.77574241e-01f, -1.10633239e-01f, 1.38572648e-01f, 2.15260297e-01f, -1.31959677e-01f, 1.57071128e-02f, -4.08251584e-02f, 2.08754823e-01f, 1.36283979e-01f, -1.38068214e-01f,
  1.68941334e-01f, 2.80997664e-01f, 2.66140979e-03f, 2.79027857e-02f, 1.23890534e-01f, 1.82904750e-01f, -4.76281159e-02f, -5.76129034e-02f, -4.52775322e-02f, -2.32043266e-01f,
  2.01467559e-01f, -4.46865000e-02f, 5.67107573e-02f, 1.61760733e-01f, -1.24690287e-01f, 2.01770604e-01f, 2.52016094e-02f, 1.19581088e-01f, 1.71471909e-01f, 5.56361787e-02f,
  -4.10212129e-02f, 1.47774011e-01f, 5.74124940e-02f, -1.21563196e-01f, 1.62343718e-02f, 9.01001617e-02f, -1.16690919e-01f, 7.65549839e-02f, 3.15713435e-02f, -9.53260064e-02f,
  -5.34628145e-02f, 8.52881521e-02f, 1.28331095e-01f, 7.19668344e-02f, 8.93266127e-03f, 1.84194501e-02f, 4.75572143e-03f, -9.09401402e-02f, 1.09181017e-01f, 1.26299458e-02f,
  1.42968409e-02f, 1.10699341e-01f, -4.78032418e-02f, 9.12890583e-02f, 1.37212560e-01f, 8.06073025e-02f, 1.02736309e-01f, -1.99074280e-02f, 3.81782688e-02f, -7.51765119e-03f,
  1.24119623e-02f, 3.41368094e-02f, -5.29247858e-02f, -1.02662131e-01f, 6.62483349e-02f, -8.69728550e-02f, 5.12224548e-02f, 1.46213174e-01f, -1.65326614e-02f, -2.84227822e-02f,
  -1.25335172e-01f, -7.21755400e-02f, 2.43253574e-01f, 5.78281917e-02f, -7.66697899e-02f, 1.65522769e-01f, -8.88524130e-02f, -7.47984722e-02f, 8.35717022e-02f, -4.66564447e-02f,
  2.68326011e-02f, 1.15526831e-02f, 2.95151733e-02f, -1.64679624e-02f, -3.12724337e-02f, 3.13163102e-02f, 1.18993878e-01f, 2.82314867e-02f, -1.43731594e-01f, 1.63329989e-01f,
  1.75237528e-03f, 1.52524292e-01f, -8.61764252e-02f, -4.39743176e-02f, -4.49361876e-02f, -1.18944712e-01f, 1.70022532e-01f, 4.55833785e-02f, -4.68237186e-03f, -3.99937108e-02f,
  -3.76988389e-02f, 8.60176757e-02f, -2.90894359e-02f, -6.79978030e-03f, -6.64013848e-02f, 7.38322511e-02f, -5.31039014e-02f, 3.27981673e-02f, 1.35312080e-01f, -1.23245627e-01f,
  1.20377436e-01f, 1.46724954e-01f, 6.25095442e-02f, 1.55778140e-01f, 1.64657012e-01f, 5.15957922e-02f, 1.18135706e-01f, 1.24195546e-01f, 6.17248714e-02f, 1.52956694e-01f,
  3.33635658e-02f, 1.28100201e-01f, -8.55893940e-02f, 5.58756441e-02f, 1.37658507e-01f, -3.77058424e-02f, -9.36077461e-02f, 7.17209429e-02f, 4.06144932e-02f, 8.68227705e-03f,
  -2.28924491e-03f, 2.72575989e-02f, 5.45752831e-02f, 7.52357319e-02f, -1.36859752e-02f, -2.52297092e-02f, 2.84775980e-02f, 6.31299615e-02f, -9.93446708e-02f, -8.81314799e-02f,
  1.08201951e-01f, -1.15175769e-01f, 6.28378987e-02f, -7.13853911e-02f, 7.32925758e-02f, 1.15567356e-01f, 4.62227501e-02f, -4.53344081e-03f, 8.18004832e-02f, 1.60044935e-02f,
  -7.96695799e-02f, 2.40331620e-01f, -1.27824619e-02f, -2.39164289e-02f, -3.23460326e-02f, 5.68216071e-02f, -3.68201802e-03f, 1.11190431e-01f, 1.17857955e-01f, 9.89142507e-02f,
  -1.37112051e-01f, 5.35411313e-02f, 1.71488717e-01f, 1.62605017e-01f, 2.44635586e-02f, -1.82422012e-01f, 2.41867989e-01f, 5.96030205e-02f, -1.50458864e-03f, 8.86173025e-02f,
  -1.02865055e-01f, 2.53536850e-02f, 1.63058311e-01f, 9.37040672e-02f, 2.47625127e-01f, 2.79583961e-01f, -1.87489957e-01f, -2.23046273e-01f, -5.72993830e-02f, 5.86073324e-02f,
  -1.68145567e-01f, 4.70495895e-02f, -2.59029288e-02f, -4.94042970e-02f, 9.89997238e-02f, 8.39788280e-03f, 1.05238408e-01f, -2.48559996e-01f, 6.72220811e-02f, 1.55448049e-01f,
  -1.00117303e-01f, -2.36273184e-01f, 1.25077337e-01f, -6.12858832e-02f, 2.12726071e-02f, -1.90344304e-02f, 2.69208923e-02f, 1.63649961e-01f, 1.23763338e-01f, 1.57431573e-01f,
  -3.96793708e-02f, 4.45643216e-02f, 1.50707200e-01f, 2.00057268e-01f, -6.01710863e-02f, 1.05095856e-01f, 3.88757624e-02f, 2.70025998e-01f, 8.85735080e-02f, 4.60506268e-02f,
  -9.27867964e-02f, -1.18755013e-01f, 1.08706683e-01f, 1.37017399e-01f, -7.50125432e-03f, 1.36713326e-01f, 1.16813079e-01f, 2.78380781e-01f, 5.29566407e-02f, 1.84714362e-01f,
  -1.17646605e-01f, 1.17425911e-01f, 9.92395729e-02f, -5.77793159e-02f, 4.19967212e-02f, 5.34641705e-02f, 1.18180197e-02f, 3.47596593e-02f, -2.66298037e-02f, 6.73548356e-02f,
  2.88111549e-02f, -6.80610836e-02f, 2.81531792e-02f, -1.00019609e-03f, 1.46753881e-02f, -6.96268678e-02f, 1.44766062e-01f, 8.42065066e-02f, 2.53748745e-02f, 7.06524923e-02f,
  -3.76704335e-02f, 1.25742495e-01f, 1.35786623e-01f, -1.39479444e-03f, 1.99478790e-02f, -1.25209782e-02f, -4.30992842e-02f, -8.02218318e-02f, -3.21366936e-02f, -5.43757062e-03f,
  -6.68146461e-02f, 1.02633037e-01f, 1.19052157e-01f, 6.67491695e-05f, 3.63474004e-02f, -1.14285991e-01f, -1.61480695e-01f, -2.80244034e-02f, -9.71642416e-03f, 1.32518426e-01f,
  -1.18627042e-01f, -6.90335082e-03f, 1.02626095e-02f, 1.18999816e-01f, -8.30705464e-02f, -8.60254001e-03f, 1.17709808e-01f, 4.60365741e-03f, -4.67629209e-02f, -6.90835491e-02f,
  2.79248646e-03f, -6.43524751e-02f, 1.29293591e-01f, 1.10255145e-01f, -8.90169665e-02f, 1.13406941e-01f, 2.54902411e-02f, -8.05527419e-02f, -2.29067858e-02f, 1.23503044e-01f,
  1.11392729e-01f, 1.47876116e-02f, -8.43363181e-02f, -8.84427205e-02f, -9.61678997e-02f, -8.40840787e-02f, 5.49797080e-02f, 1.08391538e-01f, 5.17255925e-02f, 1.97132584e-02f,
  -2.73055844e-02f, -3.79103944e-02f, 1.01353206e-01f, 9.57850665e-02f, 6.72130287e-02f, -3.85649577e-02f, 4.97301668e-02f, -3.65581550e-02f, 4.24779356e-02f, 1.12315789e-01f,
  -4.22018580e-02f, -1.06773369e-01f, -9.69179347e-02f, -7.02566803e-02f, 4.08282541e-02f, 8.55078623e-02f, 4.90693856e-05f, -1.09136187e-01f, 1.38665304e-01f, 1.13805579e-02f,
  6.46102354e-02f, -1.26162440e-01f, -1.64801970e-01f, 1.16424248e-01f, -9.05359685e-02f, -3.31673063e-02f, -6.09398000e-02f, -3.93069386e-02f, -3.12906019e-02f, 1.14262827e-01f,
  -1.13522857e-01f, -1.44332722e-02f, -6.52294233e-02f, -1.06117964e-01f, 9.35579017e-02f, 6.08854592e-02f, 1.11469746e-01f, 8.99054408e-02f, -1.31970039e-02f, -6.49348050e-02f,
  6.38042465e-02f, 6.27424195e-02f, 7.61619955e-02f, 1.75510943e-01f, 3.34058814e-02f, -2.36847047e-02f, -4.15968113e-02f, 6.07805215e-02f, 1.22336730e-01f, 7.21292272e-02f,
  9.85143930e-02f, 4.65503372e-02f, -2.22556461e-02f, 9.84657854e-02f, -3.13914344e-02f, -1.63197234e-01f, -6.31488115e-02f, 7.03859627e-02f, 1.53467268e-01f, 6.46700189e-02f,
  -7.46794567e-02f, -9.23227370e-02f, 2.51055658e-02f, -4.90290076e-02f, 1.20926209e-01f, -6.78313198e-03f, -2.69842595e-02f, 1.37814477e-01f, -3.46007012e-02f, -1.00266084e-01f,
  1.24962620e-01f, 1.14633441e-01f, 1.46391645e-01f, 1.59074023e-01f, 1.29143491e-01f, 9.95482132e-02f, -1.24907028e-02f, 7.24406093e-02f, -1.41934678e-02f, -5.91775142e-02f,
  6.14392348e-02f, -9.02751237e-02f, -1.63054615e-01f, -1.63175955e-01f, -8.44104663e-02f, 5.28135262e-02f, 1.61604043e-02f, 4.90731336e-02f, 1.38570085e-01f, 6.55896887e-02f,
  -8.41754526e-02f, 3.61288860e-02f, -3.78830209e-02f, -5.79221733e-02f, -4.01076488e-02f, -9.68632922e-02f, 3.87377590e-02f, 8.96496028e-02f, 1.45008750e-02f, -9.34300646e-02f,
  -4.53506187e-02f, -8.64876881e-02f, 1.37383148e-01f, 7.39234090e-02f, 9.38922465e-02f, -4.19094451e-02f, 4.54101972e-02f, 2.15292666e-02f, 1.13516554e-01f, -2.28271959e-03f,
  6.85357628e-03f, -2.23295242e-02f, 5.04903235e-02f, 2.56420430e-02f, 6.70710951e-03f, -7.00864121e-02f, -5.62170558e-02f, 1.09119825e-01f, -4.74289358e-02f, -1.09572135e-01f,
  -1.07971273e-01f, -3.33352163e-02f, -1.20824449e-01f, 5.54955117e-02f, -7.61856064e-02f, 8.04440528e-02f, 2.11205892e-02f, -5.88314757e-02f, -8.48658234e-02f, -3.74636650e-02f,
  -8.60191882e-02f, 8.08118656e-03f, -7.69990534e-02f, 5.05443253e-02f, -2.29793116e-02f, 8.35759938e-02f, 5.32777682e-02f, -5.93817607e-02f, 3.73487622e-02f, 9.00901407e-02f,
  8.91250446e-02f, -5.76719716e-02f, -8.51090550e-02f, 2.09580585e-02f, -9.91812348e-02f, -8.34200978e-02f, 4.78175469e-02f, 1.37612879e-01f, -1.37590235e-02f, -5.43322451e-02f,
  1.10037446e-01f, 9.54447836e-02f, -6.16906732e-02f, -8.49126950e-02f, 1.02912329e-01f, -2.74603162e-02f, -1.31701916e-01f, -4.55853231e-02f, -2.50026416e-02f, -1.19848214e-01f,
  6.69582710e-02f, -7.37173855e-02f, -1.22625865e-01f, 1.10616416e-01f, -5.95002919e-02f, -3.08631584e-02f, -5.09333163e-02f, -4.20184545e-02f, -2.77809463e-02f, 8.81265551e-02f,
  -3.19768651e-03f, 1.03912711e-01f, 1.38115942e-01f, -5.35039976e-02f, -2.12863367e-02f, -1.15809150e-01f, -1.46153376e-01f, -4.12905067e-02f, -8.89797434e-02f, -1.09945454e-01f,
  -2.98171528e-02f, 2.99608521e-02f, -3.04790623e-02f, 7.39643052e-02f, -7.64912590e-02f, 6.24311827e-02f, 1.81767777e-01f, -2.97143799e-03f, 1.85319737e-01f, 2.19617292e-01f,
  1.32080480e-01f, -2.95352079e-02f, 1.19770057e-01f, 1.36027351e-01f, -6.79987809e-03f, 1.64159954e-01f, 1.09403141e-01f, 2.04764158e-01f, 8.25910494e-02f, -1.18257133e-02f,
  -3.58057581e-03f, 1.37294754e-01f, 1.51157230e-01f, 1.65515065e-01f, -4.82436791e-02f, -8.59770179e-02f, -1.08892836e-01f, -1.50506958e-01f, 4.46288958e-02f, 1.76909596e-01f,
  -1.38669550e-01f, -7.80598493e-03f, -1.93357110e-01f, 2.81635761e-01f, 4.49948618e-03f, -1.12510890e-01f, -8.35797116e-02f, -1.60329401e-01f, -1.55317098e-01f, 7.33399913e-02f,
  2.54452825e-02f, -4.94161136e-02f, 1.32062569e-01f, 1.45245910e-01f, -8.62044990e-02f, 6.65730089e-02f, -1.03161100e-03f, 9.95423868e-02f, -1.18706152e-01f, 7.18314126e-02f,
  2.12700814e-01f, 9.96713564e-02f, -2.95160636e-02f, -1.01775408e-01f, -8.22236252e-05f, 7.54485950e-02f, -1.84928611e-01f, 3.60373184e-02f, -2.10831296e-02f, 9.71763134e-02f,
  1.30745679e-01f, -8.87779705e-03f, 1.15263037e-01f, 1.27722427e-01f, 8.10644254e-02f, 1.11698307e-01f, 5.27557731e-02f, 2.22376194e-02f, 1.22553837e-02f, 1.46967113e-01f,
  -1.17473770e-02f, 8.76788944e-02f, 1.09691270e-01f, -4.67727184e-02f, -8.83210078e-02f, 4.93801571e-02f, 2.41590501e-03f, -3.66642922e-02f, 4.93922131e-03f, 4.71958220e-02f,
  -1.25057414e-01f, 1.17919169e-01f, 1.04839064e-01f, -9.09312908e-03f, 6.89969510e-02f, 1.18349105e-01f, 6.26044944e-02f, 4.83122841e-02f, 5.84575236e-02f, 1.41969636e-01f,
  9.28707272e-02f, -1.74609423e-02f, -6.93122372e-02f, -4.84086089e-02f, -7.39938812e-03f, -6.89380318e-02f, 3.72139141e-02f, 9.11687538e-02f, -6.67028874e-03f, 1.29899278e-01f,
  -9.71087888e-02f, 5.00369258e-02f, -1.12049608e-03f, -2.05581170e-02f, 5.35475872e-02f, 7.61199817e-02f, 6.88458532e-02f, -1.29226474e-02f, 5.59362024e-02f, 1.42622024e-01f,
  -2.60876250e-02f, -1.02309637e-01f, -9.25052464e-02f, 1.36827633e-01f, 9.56642702e-02f, 9.47515219e-02f, -9.84383896e-02f, -1.13207228e-01f, -1.03354238e-01f, 1.11458503e-01f,
  7.49274567e-02f, -5.77825196e-02f, -2.73354705e-02f, 5.35579911e-03f, 1.37841344e-01f, -2.23358385e-02f, 7.92018548e-02f, 9.36142355e-02f, -3.57270017e-02f, 4.99429032e-02f,
  1.41199753e-01f, -1.20619880e-02f, 5.68100959e-02f, -1.32826716e-01f, 6.10929504e-02f, 1.64776832e-01f, 2.91514069e-01f, 1.10701203e-01f, 1.48382500e-01f, 2.53873020e-01f,
  1.78814113e-01f, 7.36893639e-02f, -6.30070716e-02f, -2.26904023e-02f, -4.22536023e-02f, 1.85511276e-01f, 1.40474888e-03f, 1.36574671e-01f, 4.51180078e-02f, 1.69049218e-01f,
  2.21709982e-01f, -4.72804718e-03f, -1.96237992e-02f, 4.76946421e-02f, 4.38863188e-02f, 2.52316713e-01f, 3.48225534e-01f, -1.46777956e-02f, 3.04179490e-02f, -1.02813125e-01f,
  -3.72136422e-02f, 1.09145358e-01f, 9.06411409e-02f, 5.84274530e-02f, -4.78993431e-02f, 2.30675787e-01f, -2.72573414e-03f, 1.09166749e-01f, 2.51060426e-01f, -6.45241439e-02f,
  -1.88854739e-01f, 3.38326931e-01f, 5.29977642e-02f, 1.65855989e-01f, 3.05863284e-02f, -1.22643806e-01f, -4.55725975e-02f, 8.77585039e-02f, 2.41303295e-01f, -2.46518943e-02f,
  -1.59136027e-01f, -1.47879466e-01f, -2.68234722e-02f, 5.79814613e-02f, -1.67418614e-01f, -2.13955179e-01f, 6.24908395e-02f, 1.08231656e-01f, 1.82992872e-02f, 8.51313174e-02f,
  -3.01210750e-02f, -6.01588935e-02f, -8.02360922e-02f, 3.75280410e-01f, -1.22891068e-02f, -1.01752691e-01f, -1.32961079e-01f, -4.24051993e-02f, -6.72354829e-03f, 2.74763051e-02f,
  1.34350911e-01f, -1.19507641e-01f, 1.60759449e-01f, 1.02909401e-01f, 8.20506513e-02f, 1.68395776e-03f, -3.37556712e-02f, -3.47435884e-02f, 1.04651041e-01f, 2.49141101e-02f,
  2.64286578e-01f, 1.81683283e-02f, -1.23951929e-02f, 1.23931482e-01f, 2.09622189e-01f, 1.54328421e-01f, 1.74605653e-01f, 1.20866045e-01f, -7.67991915e-02f, 2.30876744e-01f,
  2.70501524e-01f, 5.36971055e-02f, -1.82496682e-01f, -1.15829088e-01f, -1.10347465e-01f, 8.45234096e-03f, 3.94145250e-02f, 1.21704847e-01f, -1.05352312e-01f, 8.77379775e-02f,
  -1.53397322e-01f, 1.71203524e-01f, 9.77206528e-02f, 4.70514856e-02f, -1.63445815e-01f, 1.67381123e-01f, -8.76933709e-02f, 2.34125316e-01f, -2.01736763e-02f, -1.47912294e-01f,
  7.94023946e-02f, 1.41403750e-01f, 1.93335682e-01f, -1.07409686e-01f, -1.05091289e-01f, -4.22667190e-02f, -7.82523602e-02f, -4.42727618e-02f, -9.42028835e-02f, -1.35089770e-01f,
  4.31732908e-02f, 8.88735428e-02f, 5.93263889e-03f, -4.73539010e-02f, 5.80827594e-02f, -4.67031077e-02f, -1.39876511e-02f, 2.12270305e-01f, -8.74800980e-02f, -1.29253283e-01f,
  -1.09513439e-01f, -6.68684989e-02f, 4.38718945e-02f, 7.85932243e-02f, 1.49199769e-01f, 1.84653878e-01f, -1.81439564e-01f, 1.33318424e-01f, 1.25218734e-01f, 2.59640992e-01f,
  -1.05851535e-02f, 3.91091481e-02f, 2.09478401e-02f, 1.56225175e-01f, 1.38261080e-01f, -2.97951549e-02f, 1.92600831e-01f, 1.69554815e-01f, -1.96231473e-02f, 1.63486987e-01f,
  4.92442064e-02f, 1.73840120e-01f, -6.28487021e-02f, -9.29478556e-02f, 2.95983236e-02f, 1.57727271e-01f, 1.67203963e-01f, 3.47118005e-02f, 5.96762709e-02f, -2.06458375e-01f,
  -1.25209866e-02f, -3.36842388e-02f, -4.09331769e-02f, 1.17590874e-01f, 1.80704355e-01f, 8.50646347e-02f, 1.09140188e-01f, 5.01665892e-03f, -8.70330557e-02f, 1.83073953e-01f,
  1.53343856e-01f, -4.02449183e-02f, -1.02980174e-01f, -9.25853103e-02f, -1.79667526e-03f, 7.95326307e-02f, 2.05850452e-01f, 4.59249206e-02f, -9.24106464e-02f, 1.01682462e-01f,
  6.04586564e-02f, -4.73743342e-02f, 1.07347384e-01f, 1.04614265e-01f, 1.82182044e-01f, 7.84318745e-02f, -8.32770467e-02f, 2.52809282e-02f, -1.56972647e-01f, 1.24835268e-01f,
  -1.08612716e-01f, -1.31409720e-01f, 5.01317382e-02f, -7.82748461e-02f, 1.08651176e-01f, 2.43462771e-02f, -2.11170726e-02f, 1.73063353e-01f, 1.05068468e-01f, 1.07427001e-01f,
  -1.18035264e-01f, 1.08631045e-01f, -6.15620948e-02f, 1.23667926e-01f, 1.92607582e-01f, 1.78557590e-01f, 1.95374727e-01f, -2.14267448e-02f, 1.72102451e-01f, 1.42956734e-01f,
  8.66570473e-02f, 9.60709751e-02f, -3.32775041e-02f, 1.59788638e-01f, 1.68617934e-01f, 3.12752947e-02f, 7.39789456e-02f, -2.83957839e-01f, -1.51621833e-01f, 1.37613192e-01f,
  3.16762514e-02f, -1.64384633e-01f, 2.06509545e-01f, -7.02929273e-02f, 9.58383530e-02f, 5.63593879e-02f, 2.81716492e-02f, 1.05427571e-01f, 7.63704255e-02f, -6.22575637e-04f,
  -1.13456354e-01f, -2.34780777e-02f, -1.94261000e-01f, -8.24676380e-02f, 3.91234010e-02f, -8.98656920e-02f, -2.47195251e-02f, -2.87787933e-02f, 1.39378935e-01f, 2.90157869e-02f,
  9.23074037e-02f, 7.45680034e-02f, 2.93675065e-02f, 1.40151203e-01f, -6.78692386e-02f, 1.27016708e-01f, 1.47839293e-01f, 2.05490977e-01f, 2.65345238e-02f, -1.02430321e-01f,
  -6.02036491e-02f, 5.58302626e-02f, -1.43194601e-01f, 1.82151169e-01f, -1.17397927e-01f, -1.31233111e-01f, 1.00527644e-01f, -5.25311902e-02f, -1.29954904e-01f, 7.84362480e-02f,
  3.34763154e-02f, 4.63971868e-02f, 3.61090596e-03f, 2.92958505e-02f, 1.37669370e-02f, 1.49310827e-01f, 4.94373813e-02f, 4.73636165e-02f, 5.20152710e-02f, 1.28432035e-01f,
  2.96720378e-02f, -1.38088828e-02f, -8.07145908e-02f, 1.13594368e-01f, 6.95298761e-02f, 3.13280784e-02f, 1.44545272e-01f, 9.82960984e-02f, 1.69577040e-02f, 1.10731116e-02f,
  4.00418118e-02f, -1.97582878e-03f, 1.77918926e-01f, 5.73819391e-02f, 1.24273382e-01f, 8.68164599e-02f, 3.29397060e-03f, 1.89922884e-01f, 1.30235925e-01f, 1.10969745e-01f,
  6.42137751e-02f, 2.20870256e-01f, -8.35463479e-02f, -7.91260451e-02f, -1.43853948e-02f, 1.05246782e-01f, -8.69201124e-02f, 2.62023062e-01f, -1.23475976e-01f, -1.62761763e-01f,
  -1.22878395e-01f, -1.31675154e-01f, -8.94490406e-02f, 2.04087943e-02f, 2.59824336e-01f, -1.42182514e-01f, 2.20124349e-02f, 1.68258905e-01f, 2.16350611e-02f, 4.02286872e-02f,
  -1.40056238e-01f, -6.33763224e-02f, 4.50719111e-02f, -4.13331687e-02f, 6.90058097e-02f, -3.73236798e-02f, -1.15062289e-01f, -1.13543138e-01f, 2.72051487e-02f, 1.66399509e-01f,
  -4.05719168e-02f, 6.45052940e-02f, -9.40570384e-02f, 1.04772963e-01f, 1.37699604e-01f, 1.05650492e-01f, 1.82257280e-01f, 2.22362995e-01f, 1.94637338e-03f, 1.19790807e-01f,
  -2.33409256e-02f, 1.62217438e-01f, -5.23362216e-03f, 5.63438758e-02f, 7.65734613e-02f, -5.97310811e-02f, 2.09331587e-01f, -7.58068487e-02f, -3.35887820e-02f, 1.95888162e-01f,
  1.59165949e-01f, 5.99910617e-02f, 1.54873222e-01f, -1.21913247e-01f, 1.32182971e-01f, -5.08747399e-02f, 2.91426275e-02f, 1.23764172e-01f, 1.95551828e-01f, -2.01749310e-01f,
  1.11141121e-02f, 2.65876073e-02f, -1.27510920e-01f, 1.09062009e-01f, -2.52180640e-02f, 1.13185972e-01f, -3.85785773e-02f, -3.81791685e-03f, 8.71868879e-02f, -3.74731421e-02f,
  -4.60492112e-02f, -4.65834746e-04f, -9.52204093e-02f, -9.77994725e-02f, -1.09247409e-01f, -9.27617773e-02f, -1.01107374e-01f, -1.51677415e-01f, 3.21140945e-01f, 6.44370243e-02f,
  -1.11436933e-01f, 1.88950030e-03f, 6.52764440e-02f, 2.14663237e-01f, -8.84553120e-02f, 2.46238224e-02f, -1.16570060e-04f, -1.82790477e-02f, -2.05653403e-02f, 6.66860566e-02f,
  7.36928433e-02f, 1.11847460e-01f, 4.80120536e-03f, -1.02641426e-01f, 1.39353285e-02f, 1.99251492e-02f, -1.30275130e-01f, 9.00590047e-02f, 5.55770285e-02f, 1.33263795e-02f,
  1.69977680e-01f, 1.39880866e-01f, -1.70760110e-01f, 3.39692682e-02f, 1.21969491e-01f, 1.94264293e-01f, 2.44876549e-01f, -2.14024857e-01f, 7.80428573e-02f, 3.79751958e-02f,
  2.89907195e-02f, 2.11577415e-02f, 4.25997074e-04f, -5.75488023e-02f, 1.20644279e-01f, 1.66223839e-01f, 1.05597183e-01f, 2.76123047e-01f, -1.59748733e-01f, -3.36327925e-02f,
  1.39738783e-01f, 1.64660633e-01f, 1.69439808e-01f, -9.93132144e-02f, 3.80895734e-02f, -1.87156424e-01f, 1.82191461e-01f, 1.65357232e-01f, -3.31746973e-03f, 1.37228265e-01f,
  1.80858791e-01f, 6.05028868e-02f, -5.57507724e-02f, -1.30576253e-01f, 1.08545497e-02f, 1.94596365e-01f, -3.08305509e-02f, -4.57748622e-02f, -5.80765679e-02f, -2.92166416e-02f,
  1.90116819e-02f, 3.40446271e-03f, 1.22901820e-01f, -1.30135929e-02f, -1.00958697e-01f, 1.66949138e-01f, 1.30313978e-01f, -8.72569010e-02f, -2.60450207e-02f, 6.84584454e-02f,
  2.66485903e-02f, 1.17892154e-01f, -8.53503644e-02f, 1.03503633e-02f, -1.15879856e-01f, 4.49616835e-02f, -1.06671751e-02f, 1.54172435e-01f, -3.59644927e-02f, 5.10546453e-02f,
  1.47998221e-02f, 1.52960435e-01f, 1.33832172e-01f, 7.48989657e-02f, -1.14880607e-01f, -6.03242852e-02f, 6.12369850e-02f, -3.59510407e-02f, 1.34982556e-01f, -8.36730096e-03f,
  8.65645409e-02f, -1.03538118e-01f, 8.97969827e-02f, 1.00991547e-01f, 8.45756847e-03f, -6.57456517e-02f, -1.03445880e-01f, -4.72596753e-03f, -4.41030674e-02f, -3.38145308e-02f,
  3.65484655e-02f, -4.98379022e-02f, -1.57032982e-01f, -9.83885378e-02f, -1.93977281e-02f, -9.14468095e-02f, -8.04888532e-02f, 3.29851583e-02f, 5.69313131e-02f, 4.16829921e-02f,
  4.72110063e-02f, 9.74627659e-02f, 3.70192006e-02f, 6.84285089e-02f, 8.48308355e-02f, 4.58564609e-03f, -3.99233140e-02f, -1.67442858e-02f, -5.23847751e-02f, 1.02811269e-01f,
  -5.36120720e-02f, -3.63477729e-02f, 1.02412730e-01f, 2.06536260e-02f, -6.24322742e-02f, 6.80581629e-02f, 1.19438976e-01f, -1.04329534e-01f, -5.49871437e-02f, 5.22450358e-02f,
  -6.22455887e-02f, 3.95699739e-02f, -1.35968868e-02f, 4.11609896e-02f, 1.32538686e-02f, -1.57487895e-02f, -7.97819048e-02f, -6.63985685e-02f, -5.92632778e-02f, -9.79187414e-02f,
  -3.41608785e-02f, 1.53450429e-01f, 1.68247204e-02f, 8.58078972e-02f, -6.79285973e-02f, 1.58238024e-01f, -2.81045260e-03f, 1.70694754e-01f, 3.07167415e-02f, 9.82616395e-02f,
  1.44551873e-01f, 1.36367187e-01f, -1.00970916e-01f, 2.07989573e-01f, 1.00433014e-01f, 2.21469358e-01f, -9.43355262e-02f, 7.65709579e-03f, -2.74020936e-02f, 1.20708294e-01f,
  1.87388524e-01f, -2.20611244e-02f, 1.78557273e-03f, 2.49769352e-02f, -1.67886481e-01f, -2.10716754e-01f, -2.32899468e-02f, -4.41918336e-02f, 1.62468284e-01f, -8.68542939e-02f,
  2.17763588e-01f, -4.03806791e-02f, 3.70839909e-02f, 2.82636937e-02f, -1.21584110e-01f, 9.73631293e-02f, -1.75423294e-01f, 1.84392497e-01f, -1.16094798e-02f, -1.96943477e-01f,
  1.20806687e-01f, 1.12054728e-01f, -4.36810553e-02f, 3.27361196e-01f, 1.75358318e-02f, 1.15048610e-01f, -7.52470866e-02f, -1.12763688e-01f, 8.06683451e-02f, -8.24333876e-02f,
  3.21842432e-01f, 2.39194036e-02f, -8.17976668e-02f, -1.83847025e-02f, 4.93902061e-03f, 1.22792892e-01f, -4.62057348e-03f, -1.93633646e-01f, 7.99461454e-02f, 4.95444350e-02f,
  5.74882701e-02f, 1.69648752e-01f, 1.53571755e-01f, -1.39844313e-01f, 9.41905007e-02f, 1.18550330e-01f, 6.99688569e-02f, 1.14331404e-02f, 1.09652594e-01f, 1.28098041e-01f,
  2.68760473e-01f, 1.62703782e-01f, -8.65453780e-02f, 3.36783767e-01f, -2.39641853e-02f, 1.24194093e-01f, -7.13817552e-02f, 1.62572294e-01f, -7.15268403e-02f, 3.94031107e-01f,
  2.23214805e-01f, 2.66702566e-02f, 9.33320299e-02f, 2.11195052e-01f, 2.87275583e-01f, 1.45687297e-01f, 2.10288569e-01f, 1.27710402e-01f, 1.85551688e-01f, -2.82626659e-01f,
  1.97057456e-01f, -2.01220244e-01f, -1.85711384e-01f, -4.61579449e-02f, 1.73293874e-01f, -1.39935240e-01f, 2.45732650e-01f, 2.90285915e-01f, -1.51631922e-01f, 7.82273188e-02f,
  1.26502262e-02f, 1.07812732e-02f, -3.42862874e-01f, -7.26560578e-02f, -4.85336892e-02f, 1.24222383e-01f, -2.88886465e-02f, 4.21105102e-02f, -1.02864377e-01f, 5.98944873e-02f,
  6.83806762e-02f, -4.99704517e-02f, 4.17982228e-02f, -1.56880438e-01f, 4.40904856e-01f, -7.24230660e-03f, 2.87036151e-02f, 1.40507981e-01f, -3.27913985e-02f, 3.14563900e-01f,
  -1.24934837e-02f, -9.26507041e-02f, -3.47360857e-02f, 9.93539691e-02f, 5.47910146e-02f, -7.59446621e-02f, 9.31731313e-02f, 1.41298845e-01f, -1.70210585e-01f, 3.27688712e-03f,
  -1.14001475e-01f, -1.03412889e-01f, -8.25079009e-02f, 1.82212070e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 26)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 26;
const float L3_fan_Bp_bar_data[] = {
  -1.53388195e-02f, 1.13136038e-01f, 1.40883952e-01f, -3.08026057e-02f, 2.56612431e-02f, 2.15920940e-01f, 1.73203647e-01f, 5.56658842e-02f, 8.33306611e-02f, 1.85592175e-01f,
  1.32941186e-01f, -4.47708890e-02f, 9.36274081e-02f, -4.60594967e-02f, 5.00886813e-02f, 4.74731885e-02f, 1.09904774e-01f, 1.73256531e-01f, 1.35524422e-01f, 4.85637672e-02f,
  5.38740214e-03f, 3.71376909e-02f, -4.03414816e-02f, 8.13490450e-02f, 1.05924092e-01f, 6.65453002e-02f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  -9.24734920e-02f, 2.08179966e-01f, 3.57985087e-02f, 2.46659860e-01f, 3.09020579e-01f, -1.05478972e-01f, -1.57174960e-01f, -7.86678642e-02f, 9.71458387e-03f, 1.42208442e-01f,
  5.62334992e-03f, 8.52965340e-02f, -1.22473098e-01f, 5.05197421e-02f, -1.84568822e-01f, 1.09936118e-01f, 2.29660586e-01f, -1.10702068e-01f, 1.15031146e-01f, 1.17499821e-01f,
  -1.91541374e-01f, 2.97656864e-01f, -1.39046609e-01f, -3.57079171e-02f, -2.38863274e-01f, 2.99952954e-01f, 5.00999570e-01f, 2.50217289e-01f, -3.06085140e-01f, 2.20315889e-01f,
  -5.26583977e-02f, -1.13100514e-01f, 2.87373960e-01f, 4.05477673e-01f, 3.44720483e-01f, 1.13866679e-01f, 1.32337704e-01f, 3.38077486e-01f, -2.34355833e-02f, 1.18138678e-01f,
  -1.67812988e-01f, 1.84470475e-01f, -1.49619654e-01f, 5.02884626e-01f, -4.13216054e-01f, -1.40831918e-01f, 1.41323626e-01f, -3.61106366e-01f, 1.99834064e-01f, 1.03492364e-01f,
  -6.97015598e-02f, 6.20824061e-02f, -1.51821807e-01f, 1.16186567e-01f, 4.47015643e-01f, 2.83167977e-02f, 1.68953881e-01f, -1.17257893e-01f, 2.49891892e-01f, -1.01084322e-01f,
  2.02274159e-01f, 2.41850168e-02f, 2.45875806e-01f, -4.28112745e-01f, -7.57698789e-02f, 2.52953857e-01f, 9.96939838e-02f, 7.79277533e-02f, -2.33776588e-02f, 1.58092100e-02f,
  -3.04030795e-02f, 2.27193266e-01f, -1.37105808e-01f, 1.38243824e-01f, 1.94523349e-01f, 2.87858844e-01f, 1.22934759e-01f, -1.66980833e-01f, 2.40535066e-01f, 1.80638567e-01f,
  7.75900856e-02f, -1.24541201e-01f, 1.62343040e-01f, 9.16859508e-02f, -1.65811211e-01f, 1.91892400e-01f, 3.65565270e-01f, 3.72999638e-01f, -2.70948917e-01f, 3.67273629e-01f,
  -2.53418505e-01f, 4.40056503e-01f, -3.16383988e-02f, 4.60247546e-02f, 1.49374232e-01f, -1.69447467e-01f, -2.39212096e-01f, -3.52846049e-02f, 8.20158869e-02f, -3.39031309e-01f,
  3.24326366e-01f, -1.82773322e-01f, -4.87142205e-02f, 3.61868262e-01f, -5.41945584e-02f, 8.66914243e-02f, 3.20180580e-02f, -1.90921426e-01f, -1.93218797e-01f, -1.85717016e-01f,
  -6.17495552e-02f, 2.30620921e-01f, 1.18295394e-01f, 1.21385604e-01f, -1.30725056e-01f, -8.66970643e-02f, -1.05084822e-01f, -1.19656399e-01f, 8.86687040e-02f, -3.24786641e-02f,
  5.36670983e-01f, 1.94780976e-01f, 6.05922490e-02f, 1.47132128e-01f, 3.75870138e-01f, -1.28928900e-01f, -5.94999455e-02f, -1.05919257e-01f, 1.03177883e-01f, 1.97724491e-01f,
  1.08242922e-01f, -2.20307395e-01f, -2.03131393e-01f, 2.39419844e-02f, 3.91398877e-01f, -2.94633716e-01f, 9.89559852e-03f, 1.64302494e-02f, 1.00813247e-01f, 2.89356560e-01f,
  -1.42294411e-02f, -1.37072206e-01f, -2.98399609e-02f, -2.13054195e-01f, 6.38573691e-02f, -1.05189001e-02f, 1.15297198e-01f, 5.76665998e-02f, 2.43177325e-01f, 1.25866711e-01f,
  1.45037740e-01f, 1.28175452e-01f, 1.89453643e-02f, -2.92155687e-02f, -3.75442415e-01f, 3.77250701e-01f, -1.82631463e-01f, -6.42177239e-02f, -3.75768989e-01f, 2.03352004e-01f,
  -2.57646274e-02f, -2.39558756e-01f, -5.10299027e-01f, -2.80901045e-01f, -2.39805460e-01f, -2.45033771e-01f, 2.79475421e-01f, 3.96139920e-02f, 8.93694013e-02f, 1.33798286e-01f,
  5.05297892e-02f, -2.50505477e-01f, 3.18549544e-01f, 5.79640381e-02f, 7.93357566e-03f, 3.47180486e-01f, 4.88996804e-02f, -2.03795210e-02f, -1.28169611e-01f, 1.98669419e-01f,
  -3.76333416e-01f, -1.17407471e-01f, -2.82558590e-01f, -3.40268612e-01f, 1.93535253e-01f, 2.32555509e-01f, -7.99276903e-02f, -2.56448239e-01f, 3.03873643e-02f, -4.00850773e-02f,
  -1.93541706e-01f, -3.05275470e-01f, -1.66905209e-01f, -3.40663910e-01f, -1.36339471e-01f, 2.63726339e-03f, 1.59312844e-01f, -5.19494973e-02f, 2.96843022e-01f, -1.26170948e-01f,
  -6.19023629e-02f, 9.46068987e-02f, -7.48945400e-02f, -3.50414932e-01f, -3.65457147e-01f, 1.08638406e-01f, -2.34056711e-01f, -1.07938491e-01f, 2.52099991e-01f, -1.19879292e-02f,
  -4.08041626e-01f, 2.27850452e-01f, -8.26629549e-02f, -2.73682356e-01f, -2.34496832e-01f, 5.16911373e-02f, 3.83297473e-01f, -4.26464789e-02f, 4.90114212e-01f, 1.71649829e-01f,
  7.99607635e-02f, 8.10661260e-03f, 2.09701389e-01f, -1.96754765e-02f, 1.46967262e-01f, 4.84929653e-03f, 3.12775373e-01f, -6.01107925e-02f, 3.22661065e-02f, 1.83030874e-01f,
  5.29201292e-02f, -2.59197727e-02f, -2.01777682e-01f, -1.06692955e-01f, 6.27290606e-02f, -1.31970152e-01f, -4.56428677e-01f, -1.06024388e-02f, 2.81987488e-02f, -3.50375772e-01f,
  -1.98512316e-01f, 2.23625600e-01f, -1.57454669e-01f, 6.54700585e-03f, 2.04106465e-01f, -3.31620499e-02f, 1.73514202e-01f, -7.30884895e-02f, 5.57177812e-02f, -3.03412694e-02f,
  1.52673379e-01f, 3.64652723e-01f, -1.37230039e-01f, -1.17258333e-01f, 4.08965886e-01f, 4.45608824e-01f, 1.68557361e-01f, 1.96356460e-01f, 2.09455624e-01f, -9.14797559e-02f,
  2.30127405e-02f, 2.75388807e-01f, -1.33926392e-01f, 6.04006089e-02f, 1.29011184e-01f, -6.21811077e-02f, 2.75006928e-02f, 1.53380692e-01f, 2.59289220e-02f, 1.43210679e-01f,
  4.01062965e-01f, -1.93133891e-01f, -2.18394846e-01f, 4.55040112e-02f, 3.66732866e-01f, 1.25046389e-03f, -1.93156168e-01f, 2.02920988e-01f, -3.91350180e-01f, -3.93065095e-01f,
  -2.25780103e-02f, 8.20802674e-02f, 4.24167782e-01f, -7.92988092e-02f, 9.50465128e-02f, -2.81009406e-01f, 2.97276769e-02f, -1.29667133e-01f, -6.57816380e-02f, -1.17008112e-01f,
  1.20956890e-01f, 3.85323405e-01f, 5.12339324e-02f, 1.24968454e-01f, -1.95701733e-01f, -2.26180419e-01f, -4.63910913e-03f, -3.61944847e-02f, 6.84597576e-03f, 3.12754735e-02f,
  7.79201537e-02f, 8.50190967e-02f, -8.21676664e-03f, -5.00725657e-02f, -6.11104444e-02f, -1.12875216e-01f, 8.02837461e-02f, -7.03863055e-02f, 3.38253051e-01f, 8.18862692e-02f,
  3.46468598e-01f, 2.70601153e-01f, 6.28039390e-02f, -1.89557493e-01f, 1.84526876e-01f, 1.34429708e-01f, -6.93900660e-02f, 2.28818394e-02f, 1.19494200e-01f, 1.16339087e-01f,
  2.38551408e-01f, 3.46605062e-01f, -2.10297227e-01f, 2.12555066e-01f, 2.01056898e-01f, -2.42139503e-01f, -2.40817070e-01f, 1.64017856e-01f, 2.98600703e-01f, 2.31281117e-01f,
  3.86518806e-01f, 2.33288452e-01f, 2.65457779e-01f, 7.34770373e-02f, 4.83989894e-01f, 1.69136867e-01f, 1.45795256e-01f, -7.02967644e-02f, -1.22378655e-02f, -1.15659714e-01f,
  4.96593446e-01f, 3.89381915e-01f, 3.03949006e-02f, -3.78992766e-01f, -1.17057249e-01f, 2.18215808e-01f, -7.82784969e-02f, -3.05725545e-01f, 2.10981950e-01f, -3.43061000e-01f,
  -3.22788477e-01f, 1.83422595e-01f, -9.14555192e-02f, 1.35654777e-01f, 1.71282962e-01f, 1.01332083e-01f, 3.47120464e-01f, -4.48441774e-01f, -1.56473011e-01f, -1.07786618e-01f,
  1.53029054e-01f, 1.06107835e-02f, -1.15307517e-01f, 4.75785762e-01f, -1.37350395e-01f, -2.17337757e-01f, 1.63007434e-02f, 2.41299152e-01f, 8.46439749e-02f, -1.70018047e-01f,
  1.15404606e-01f, -1.43520772e-01f, 1.00447973e-02f, -1.12142228e-02f, 1.72432125e-01f, 3.43319565e-01f, -7.20001534e-02f, -4.79635037e-02f, 1.64164603e-02f, -1.89702496e-01f,
  2.03577995e-01f, 5.88298403e-02f, -2.61323512e-01f, -5.48250675e-01f, 8.24454129e-02f, -3.45456421e-01f, -2.61684984e-01f, 3.40820193e-01f, 3.15143585e-01f, 1.78431466e-01f,
  -9.65860859e-02f, 1.39072519e-02f, 1.69299260e-01f, 9.38430149e-03f, -2.23722994e-01f, -2.25395143e-01f, -2.88282558e-02f, -3.67790572e-02f, -3.42767060e-01f, 3.09838802e-01f,
  2.29689598e-01f, 5.04088439e-02f, -2.01223046e-01f, -2.52986193e-01f, 1.33249998e-01f, 1.52534977e-01f, 1.76838711e-01f, 4.34093811e-02f, -5.30748740e-02f, 3.26096028e-01f,
  -2.62484640e-01f, -2.85852939e-01f, 2.95713246e-01f, -3.42239559e-01f, -4.12252933e-01f, 2.93434203e-01f, -1.90706834e-01f, -2.96867371e-01f, -1.39623582e-01f, 2.62238801e-01f,
  2.68666334e-02f, -3.36441934e-01f, 1.90805737e-02f, 2.14541145e-02f, -1.24117441e-01f, 1.35438666e-01f, -1.93589151e-01f, -2.77905822e-01f, 3.14188212e-01f, -4.46822755e-02f,
  -6.94220364e-02f, 4.24645901e-01f, 3.93864289e-02f, -9.41921696e-02f, -1.60142183e-01f, 6.66371286e-02f, 8.97163153e-02f, -2.11189985e-01f, -3.05318922e-01f, -3.43118668e-01f,
  -1.42113939e-01f, -2.22187415e-01f, -3.44202965e-02f, -1.48057595e-01f, 1.09401874e-01f, 4.72854562e-02f, -2.25984007e-01f, -2.44425952e-01f, 9.38799307e-02f, 5.62311411e-02f,
  4.69166413e-02f, -4.91565168e-01f, -2.92916447e-01f, 8.56143981e-02f, 7.66725764e-02f, -4.93057787e-01f, -2.34633461e-01f, -7.87213817e-02f, 1.26670539e-01f, -2.71706693e-02f,
  -1.43375501e-01f, -1.93728626e-01f, -2.28409797e-01f, -1.45371944e-01f, -2.46503413e-01f, 4.87883203e-02f, -2.23813340e-01f, -1.53215721e-01f, -2.12062001e-01f, -2.88829476e-01f,
  8.13681167e-03f, -1.41993001e-01f, -4.64410335e-02f, 4.81383167e-02f, 2.85268188e-01f, -5.11053205e-01f, 6.85643554e-02f, -1.15974275e-02f, 1.75644711e-01f, -2.64813066e-01f,
  3.32424194e-01f, 2.31156677e-01f, 4.85135876e-02f, 1.17476881e-01f, -2.50875980e-01f, 3.37659448e-01f, -1.37884945e-01f, -7.11901560e-02f, 7.84714520e-03f, -1.04093358e-01f,
  -1.23972476e-01f, 2.65719265e-01f, -3.92680109e-01f, -1.15574993e-01f, 5.40892221e-02f, -3.90270263e-01f, 1.71622232e-01f, 1.57820016e-01f, 1.76231235e-01f, -8.50812495e-02f,
  -8.02020282e-02f, -4.73574400e-02f, 3.73426259e-01f, 3.44399422e-01f, -2.20953241e-01f, -3.00935507e-01f, 1.25140190e-01f, -3.23240161e-02f, -3.37194085e-01f, -6.54767379e-02f,
  3.10636610e-01f, 8.72837752e-02f, -1.18808471e-01f, 9.11728200e-03f, -6.80853352e-02f, -1.71150848e-01f, -2.06645519e-01f, 1.26828611e-01f, -1.06440902e-01f, 3.59740146e-02f,
  1.70817003e-01f, -2.77995080e-01f, -1.47209600e-01f, -3.33978415e-01f, 1.50228485e-01f, 3.08356360e-02f, -3.68507326e-01f, -3.09602708e-01f, -1.36923879e-01f, 1.08798727e-01f,
  -1.31793082e-01f, 2.11290345e-01f, -1.05579682e-01f, -3.81049454e-01f, 3.69225740e-01f, 2.26563379e-01f, -3.51338228e-03f, -5.96900225e-01f, -3.05870563e-01f, 3.68905701e-02f,
  -2.60184199e-01f, 3.37460339e-01f, 2.76247889e-01f, -9.53827798e-02f, -8.96797478e-02f, 3.36762518e-01f, -5.23267090e-01f, -9.41147506e-02f, -1.50487572e-01f, 2.95771956e-01f,
  1.70163244e-01f, 1.11479849e-01f, 4.59087133e-01f, 1.30715105e-03f, -9.19149164e-03f, -3.02193165e-01f, 6.31853268e-02f, -1.12325631e-01f, -1.23869479e-01f, 2.02092435e-02f,
  2.12720167e-02f, 1.12531938e-01f, 1.37019292e-01f, -5.47630489e-02f, -3.48229855e-01f, 7.44967088e-02f, -3.52595478e-01f, -9.74358469e-02f, 8.83362889e-02f, 3.64795208e-01f,
  -2.62936801e-01f, 1.26107171e-01f, -1.50671914e-01f, -1.41569510e-01f, -1.95571244e-01f, 2.53878832e-01f, -2.11385593e-01f, -1.73606142e-01f, -2.85345227e-01f, -2.39383951e-01f,
  -3.99347752e-01f, -2.79951334e-01f, -2.63311774e-01f, 8.70137140e-02f, -4.35629427e-01f, -1.88629746e-01f, -2.28015512e-01f, -2.79399753e-01f, -2.80755647e-02f, 2.30520710e-01f,
  5.03490269e-02f, -1.04098909e-01f, -3.15853059e-01f, -3.47916521e-02f, -1.88709930e-01f, -2.49992967e-01f, 3.22497666e-01f, 3.95374522e-02f, -3.55151385e-01f, -3.42667758e-01f,
  -1.98697165e-01f, 9.00239497e-03f, 9.95140746e-02f, -3.04139644e-01f, 2.70484179e-01f, -2.35251129e-01f, -2.21495017e-01f, 4.36340988e-01f, 1.63142532e-01f, -3.54066223e-01f,
  8.50952417e-02f, 1.32045731e-01f, 7.28601124e-03f, -3.15815836e-01f, -1.50900349e-01f, -2.42574453e-01f, -9.75059494e-02f, -1.92370236e-01f, -1.03774711e-01f, 3.51246089e-01f,
  2.61413842e-01f, 8.97410810e-02f, 2.97842860e-01f, 8.18811134e-02f, 9.38598067e-02f, -7.88177084e-03f, -1.60973117e-01f, -5.62160388e-02f, 9.77343395e-02f, -2.46200301e-02f,
  1.12273045e-01f, 1.05031371e-01f, -2.08258674e-01f, -2.68808365e-01f, -5.72478846e-02f, -2.89421499e-01f, -1.06165551e-01f, 2.73931585e-03f, -1.69584587e-01f, -2.63009936e-01f,
  -1.16871886e-01f, -5.01619935e-01f, 3.15286741e-02f, 2.30444849e-01f, -3.41407061e-01f, -2.06680313e-01f, 1.11595497e-01f, -3.34374718e-02f, -1.33433267e-01f, 6.12284839e-02f,
  9.59037989e-02f, 4.83938828e-02f, -3.86546046e-01f, -1.56099603e-01f, 2.23907158e-01f, 3.19149792e-01f, -9.97935236e-02f, 7.80978054e-02f, 3.51774506e-03f, -8.83586518e-03f,
  -3.28177452e-01f, -3.25000465e-01f, 3.73235226e-01f, 2.00851902e-01f, 2.07414702e-01f, -1.75637856e-01f, -1.44120023e-01f, 3.49228829e-01f, -2.32082427e-01f, 1.65406913e-01f,
  1.00133255e-01f, -2.31504381e-01f, -7.91088417e-02f, -4.62976396e-02f, 4.86585535e-02f, -8.43455419e-02f, -2.14224849e-02f, 3.72075796e-01f, -8.10351148e-02f, -6.03619637e-03f,
  -1.07884467e-01f, -1.05110377e-01f, 1.53324306e-01f, -3.55196744e-01f, 1.41588494e-01f, 1.91243663e-01f, 2.74324864e-02f, -7.44001940e-02f, -1.80292249e-01f, -6.92330720e-03f,
  -1.91707909e-02f, -4.91001680e-02f, -9.08164158e-02f, -1.34638458e-01f, -2.66397834e-01f, -2.21354276e-01f, 6.54578805e-02f, 2.13511735e-01f, 3.13104391e-01f, 1.96519330e-01f,
  1.11821577e-01f, 6.83025420e-02f, 2.45986730e-02f, 5.84966600e-01f, 2.64819026e-01f, 1.37417182e-01f, 2.42882088e-01f, 4.41438526e-01f, 2.29404658e-01f, 1.07581988e-02f,
  3.99270236e-01f, 9.31696519e-02f, 1.66836470e-01f, 1.37371808e-01f, 2.14897528e-01f, 2.34439194e-01f, 1.54692084e-01f, 1.65922314e-01f, 2.30549246e-01f, 3.58304322e-01f,
  2.75989652e-01f, 4.00069058e-02f, 3.88698965e-01f, 4.18691151e-02f, -2.51605660e-01f, -2.74804711e-01f, -1.44964028e-02f, 3.98138426e-02f, 3.49092185e-01f, 1.25342831e-01f,
  -2.21645162e-01f, -3.73430490e-01f, 9.12395865e-02f, 4.00829921e-03f, 3.10753405e-01f, -2.36566335e-01f, -2.58879930e-01f, -5.14364354e-02f, -1.31660432e-01f, -1.03881270e-01f,
  -2.31366917e-01f, 7.56435143e-03f, -1.80475563e-01f, -2.47257397e-01f, -4.80823480e-02f, 3.33521664e-02f, 2.49436900e-01f, -1.41394839e-01f, 2.48343021e-01f, 8.07283372e-02f,
  -1.00368708e-01f, 1.07614517e-01f, -7.14076161e-02f, 1.90432500e-02f, 1.69703603e-01f, -1.17922179e-01f, 2.85053462e-01f, 1.10650389e-02f, -2.85292983e-01f, -1.20946616e-01f,
  -1.30209833e-01f, 1.46003604e-01f, -2.10828081e-01f, 5.62869348e-02f, -2.18972132e-01f, -1.38682857e-01f, -2.32649326e-01f, 3.45993578e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -1.06085256e-01f, 1.12145342e-01f, -3.86808328e-02f, 4.47044298e-02f, 1.09308017e-02f, -2.51604617e-02f, 4.72384412e-03f, -2.16008034e-02f, -7.86775723e-02f, -5.97171672e-02f,
  -2.13234350e-01f, 1.21133246e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    