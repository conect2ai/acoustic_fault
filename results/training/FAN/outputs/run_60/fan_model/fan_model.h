/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  7.95973763e-02f, 7.58456951e-03f, -2.61161104e-03f, 4.43808772e-02f, 2.22318202e-01f, -1.87661335e-01f, -3.01601559e-01f, 2.09266856e-01f, -9.14356858e-02f, -2.12332889e-01f,
  4.61574607e-02f, -1.75369799e-01f, -1.01646461e-01f, -1.12373948e-01f, -8.23571905e-02f, -2.21444786e-01f, -1.26835942e-01f, -5.47973951e-03f, 6.04366139e-02f, 1.02203459e-01f,
  9.18736868e-03f, 1.27484426e-01f, 4.88124043e-02f, 1.43127009e-01f, -4.18330766e-02f, 5.09365164e-02f, 1.44791797e-01f, -1.30461618e-01f, 5.22783259e-03f, -6.87912554e-02f,
  2.26507466e-02f, 3.74410488e-02f, -1.93494353e-02f, -2.92169321e-02f, 7.25631639e-02f, -2.53419932e-02f, 3.10749765e-02f, -3.90697503e-03f, -3.37064900e-02f, 3.81890908e-02f,
  4.49266806e-02f, 1.95716500e-01f, -2.19766572e-02f, -1.79274246e-01f, -5.95849045e-02f, -4.07635868e-02f, 3.97948176e-02f, -3.12942974e-02f, 1.50548950e-01f, 7.25436881e-02f,
  -1.39959097e-01f, -1.09623812e-01f, -1.47939712e-01f, -2.42394768e-02f, 8.67603049e-02f, 8.93301796e-03f, -1.16744481e-01f, -7.50982761e-02f, 5.74383251e-02f, 8.97797570e-02f,
  -4.43237536e-02f, 3.52876522e-02f, 7.16990158e-02f, 8.21639076e-02f, 8.04668199e-03f, 1.30008206e-01f, -4.13472503e-02f, 1.15661524e-01f, -8.51684660e-02f, 7.44626150e-02f,
  1.36920139e-02f, 5.44799529e-02f, 3.15407626e-02f, -1.48616033e-02f, 2.61169150e-02f, 7.74290937e-04f, -4.84631769e-02f, 2.41130926e-02f, 6.34984821e-02f, 9.56124684e-04f,
  7.06140772e-02f, -3.64693925e-02f, -8.87165368e-02f, -5.62760718e-02f, 2.27481220e-02f, -1.71444595e-01f, 4.25782613e-02f, 1.60912517e-03f, 1.68193821e-02f, 1.02899119e-01f,
  1.24670379e-01f, 4.96729128e-02f, -1.12801287e-02f, 1.12279914e-01f, 6.77487701e-02f, -6.45085648e-02f, -4.51444350e-02f, 7.10069686e-02f, -1.99751668e-02f, 4.84181568e-02f,
  9.20190662e-02f, -2.00616308e-02f, 3.05515304e-02f, -1.21245883e-01f, -7.78069794e-02f, -6.84391484e-02f, 4.46283296e-02f, -5.03605455e-02f, 3.25899757e-02f, 1.29103497e-01f,
  1.26504794e-01f, 1.50296027e-02f, 3.63198258e-02f, 1.33932069e-01f, 2.06624921e-02f, 7.32594430e-02f, -5.75794578e-02f, -2.14006361e-02f, 5.09136133e-02f, 9.40307043e-03f,
  5.02736807e-01f, -9.88176744e-03f, -1.27711043e-01f, 6.31573349e-02f, 1.15134783e-01f, 2.09930420e-01f, 9.74470302e-02f, 4.71014641e-02f, 2.18446374e-01f, -6.66391850e-02f,
  -8.84376690e-02f, -1.50531693e-03f, -1.42595998e-03f, -3.67711596e-02f, 3.82050157e-01f, -1.91341922e-01f, 1.15032345e-01f, 5.29604815e-02f, -5.60277663e-02f, 2.20648721e-01f,
  5.78749552e-02f, 1.49940372e-01f, -8.29579756e-02f, 9.12121311e-03f, 8.98581669e-02f, -1.07745796e-01f, 2.31875498e-02f, -5.33758029e-02f, 7.05913082e-02f, -3.25338915e-02f,
  8.06084424e-02f, -3.56636420e-02f, -7.09314868e-02f, -8.59718490e-03f, -2.12868378e-02f, -1.54469520e-01f, -2.83818301e-02f, -1.30242169e-01f, -1.65495172e-01f, 6.03882000e-02f,
  -1.80712212e-02f, 1.09110121e-02f, 1.82714406e-02f, 3.42950001e-02f, 3.34573723e-02f, 1.02165481e-03f, -1.17947869e-01f, 1.45493336e-02f, -3.19113433e-02f, -2.61971243e-02f,
  9.72112790e-02f, 3.68500734e-03f, -1.53084183e-02f, -6.91842735e-02f, -6.19743429e-02f, -2.25236416e-02f, -9.21170935e-02f, 4.33943942e-02f, 3.62073444e-02f, 1.23988814e-03f,
  -9.26074162e-02f, -5.84032908e-02f, -4.70635435e-03f, 9.52150300e-02f, 4.63654548e-02f, -3.82078737e-02f, 3.52254808e-02f, -1.02265432e-01f, -1.55704170e-02f, 4.19478789e-02f,
  5.37575558e-02f, 6.61129653e-02f, -1.14102894e-02f, 3.61138843e-02f, -3.44395675e-02f, 6.76065385e-02f, -6.61628842e-02f, -2.38445500e-04f, 5.14977938e-03f, -5.78620024e-02f,
  -2.80409921e-02f, 4.97529618e-02f, 1.52338045e-02f, -6.40358105e-02f, 1.36152171e-02f, 5.10690361e-02f, -9.92547870e-02f, -5.55923544e-02f, 2.32729185e-02f, 3.50478701e-02f,
  2.95344561e-01f, 1.38930351e-01f, -1.96897499e-02f, -4.05493891e-04f, -2.26833764e-03f, 1.49957687e-02f, -5.46602011e-02f, -4.43118550e-02f, -4.29352894e-02f, 4.05665860e-02f,
  -1.32891163e-02f, -2.00179890e-02f, 2.06609797e-02f, -3.56524438e-02f, -2.42795050e-02f, -1.04568377e-02f, -9.42531079e-02f, -3.90299335e-02f, 4.55457047e-02f, -7.95121193e-02f,
  -1.77662671e-02f, 3.90640125e-02f, -7.89053217e-02f, 1.78028166e-03f, -9.55162048e-02f, -2.33640373e-02f, 5.29529005e-02f, -6.14053272e-02f, 9.36626941e-02f, -1.01218648e-01f,
  3.55907083e-01f, -2.12759405e-01f, -6.37347028e-02f, 2.29644328e-01f, -4.08749050e-03f, 1.99387059e-01f, 2.76200235e-01f, -5.47969490e-02f, 2.92161535e-02f, -7.62014417e-03f,
  5.38382456e-02f, -5.67790754e-02f, -2.14532673e-01f, 2.80747592e-01f, 1.97956622e-01f, -3.48514229e-01f, 2.81231761e-01f, 1.97295636e-01f, -2.04557762e-03f, 1.04766749e-01f,
  -8.56670924e-03f, 1.49274856e-01f, -2.88118348e-02f, -1.18934475e-02f, 8.58037472e-02f, -5.78297451e-02f, -1.15377873e-01f, -5.95720075e-02f, 5.15647419e-02f, 1.46466382e-02f,
  1.84376240e-02f, -2.36918638e-03f, -2.56127659e-02f, 8.53966828e-03f, 5.28162569e-02f, 1.28763951e-02f, 1.66902281e-02f, 9.50142927e-03f, -1.77572574e-02f, -1.70010340e-03f,
  -4.97372262e-02f, 4.34409678e-02f, -1.45097887e-02f, -7.92652741e-02f, 1.06439136e-01f, -2.51376200e-02f, -3.63163687e-02f, 4.60792482e-02f, 4.95474339e-02f, -1.57391019e-02f,
  2.40350012e-02f, -4.74892259e-02f, 1.57755777e-01f, -9.58872437e-02f, -1.78863592e-02f, 7.20688030e-02f, -6.06689900e-02f, -5.59081137e-02f, -2.47853361e-02f, -4.20805775e-02f,
  4.75452803e-02f, -8.47845301e-02f, 9.05371383e-02f, -3.94215547e-02f, 5.37559204e-03f, 3.09250653e-02f, 5.85761108e-02f, -2.46464889e-02f, 1.07613772e-01f, -2.29001809e-02f,
  1.23542594e-02f, 6.12356216e-02f, 8.16960558e-02f, 5.97378574e-02f, 6.12367801e-02f, -1.08076613e-02f, 7.06203654e-03f, -2.70569362e-02f, 4.39499505e-02f, 1.09786205e-02f,
  -4.80845943e-02f, 1.09327041e-01f, -7.68841803e-02f, -1.04884570e-02f, -4.21037935e-02f, 5.27004674e-02f, -1.46837793e-02f, -4.04485594e-03f, -4.44883890e-02f, 6.31106645e-02f,
  9.00615007e-02f, -6.61661029e-02f, -3.00137699e-02f, -1.22940997e-02f, 3.46619316e-04f, 5.76825440e-02f, -4.91013611e-03f, -2.57525742e-02f, -4.06132527e-02f, -1.06044384e-02f,
  5.10153510e-02f, 5.24486229e-03f, -5.80889697e-04f, 8.47104415e-02f, -4.99434024e-02f, -1.74925737e-02f, -1.35438284e-02f, -1.36520699e-01f, 7.30494922e-03f, -8.33475590e-02f,
  1.25994319e-02f, 3.71989608e-02f, 4.47405390e-02f, 2.88886856e-02f, 3.28958593e-02f, -3.01348083e-02f, 5.87669946e-03f, -4.05673273e-02f, -1.21012982e-02f, -9.99243334e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.64848679e-01f, -2.10341558e-01f, -6.33329302e-02f, -1.41526520e-01f, -3.11966632e-02f, -1.12226009e-01f, 1.42525956e-01f, -3.63781959e-01f, -1.16499774e-01f, -2.81927973e-01f,
  -1.42168447e-01f, 2.20614985e-01f, 3.56890172e-01f, -3.75612885e-01f, 5.89510024e-01f, 2.44696200e-01f, -2.37450466e-01f, -3.46096489e-03f, -5.81596047e-02f, -1.33197188e-01f,
  -3.93181294e-02f, -2.31898695e-01f, -5.59126399e-02f, -3.89326155e-01f, -2.71489441e-01f, -2.26374716e-01f, 1.66353762e-01f, 2.07967103e-01f, -2.29475334e-01f, 4.70100902e-02f,
  2.44634096e-02f, -1.49945272e-02f, -7.92148635e-02f, -1.33178219e-01f, -4.59747352e-02f, -4.76329587e-02f, 3.96459624e-02f, 1.75280482e-01f, 7.16551840e-02f, 6.97654858e-02f,
  1.26483917e-01f, 6.63953796e-02f, -1.83400527e-01f, 1.52448520e-01f, -3.93208079e-02f, -1.23118572e-01f, -8.80338550e-02f, 3.69506292e-02f, -4.92264889e-02f, 4.52307872e-02f,
  -6.06252775e-02f, 2.08445787e-02f, -6.89263865e-02f, 3.45344953e-02f, -1.47993863e-02f, 7.47950142e-03f, -2.51662405e-03f, 1.71025485e-01f, -7.95127172e-03f, -2.23919619e-02f,
  -6.14620894e-02f, 7.20304251e-02f, -1.14868887e-01f, -7.77224451e-02f, 8.86270031e-02f, -7.39397928e-02f, -2.84490846e-02f, 1.66113339e-02f, -4.87103723e-02f, -1.22051602e-02f,
  -7.32987374e-02f, -6.85755908e-02f, -5.22784591e-02f, -7.81761855e-02f, -5.45654539e-03f, 9.35922004e-03f, 1.55522972e-01f, -9.98300910e-02f, 1.69117618e-02f, -2.53546722e-02f,
  -5.23731858e-03f, -2.78451871e-02f, 8.23882297e-02f, -4.31422815e-02f, -5.15380129e-02f, 5.80157861e-02f, -1.44174516e-01f, 1.96637176e-02f, -1.41844243e-01f, 1.42176300e-01f,
  -5.39184883e-02f, -1.85069725e-01f, -2.84022242e-02f, -1.51946336e-01f, 3.77333313e-02f, -3.03578414e-02f, -1.04180492e-01f, -1.29348770e-01f, -1.84901953e-02f, -3.30623798e-02f,
  9.16205626e-03f, 2.34408062e-02f, -1.06677413e-01f, 9.45986882e-02f, 8.82298797e-02f, -9.87683460e-02f, 7.81360492e-02f, 3.03405710e-02f, -2.75633531e-03f, -4.78019118e-02f,
  1.34491976e-02f, 5.41928299e-02f, 8.72635990e-02f, -9.75622684e-02f, -1.75675198e-01f, 9.48863029e-02f, -3.21926624e-02f, 8.49056244e-03f, 1.60697028e-01f, -7.40441605e-02f,
  -4.76902157e-01f, 1.85074270e-01f, -4.64668989e-01f, 5.60780354e-02f, -2.57928371e-01f, 3.18880439e-01f, 3.46834511e-01f, 5.28628342e-02f, -3.22160535e-02f, 5.00853479e-01f,
  3.39589655e-01f, -1.83967948e-01f, 2.76983351e-01f, 4.27345484e-01f, -1.46224678e-01f, 2.88111299e-01f, 3.96421134e-01f, 2.38900721e-01f, -7.22096041e-02f, -3.60482857e-02f,
  -9.09814090e-02f, 3.45735103e-01f, 1.55699119e-01f, -5.82005605e-02f, 5.16673028e-02f, -2.48616263e-01f, 6.60163909e-02f, -3.78840983e-01f, 1.24758899e-01f, -2.92320438e-02f,
  1.27065703e-01f, -4.18967530e-02f, -9.86780748e-02f, -9.51306894e-02f, -9.09461528e-02f, 2.73889452e-02f, -5.36690392e-02f, -6.72531649e-02f, -9.20857117e-02f, -8.15594420e-02f,
  -1.82060376e-01f, -6.78564534e-02f, -7.94332400e-02f, -8.55284184e-02f, -1.94691554e-01f, -7.11873397e-02f, 5.62098771e-02f, 8.06412920e-02f, 1.09244734e-01f, -1.33651530e-03f,
  -1.91968179e-03f, -5.60914502e-02f, -2.92798057e-02f, 4.47742604e-02f, -6.22561723e-02f, -4.37000161e-03f, 3.55069228e-02f, -9.64250639e-02f, 2.75255051e-02f, -1.42977014e-03f,
  -2.53324360e-02f, -1.40427714e-02f, -8.48333538e-02f, 7.45116919e-02f, -1.45110577e-01f, 1.79516628e-01f, 1.54867880e-02f, 6.19700588e-02f, -1.27337560e-01f, 8.53681043e-02f,
  3.58443297e-02f, -3.85462015e-04f, -5.42606711e-02f, 7.41266310e-02f, 1.59395710e-02f, 1.60704315e-01f, 2.65729241e-02f, 7.46333897e-02f, 8.59218743e-03f, 7.68083930e-02f,
  7.55660087e-02f, -8.91227275e-02f, -5.00860717e-03f, 9.37559977e-02f, 6.63574710e-02f, -1.26460403e-01f, 1.04806051e-01f, 1.02426633e-01f, 9.30696279e-02f, -3.62330042e-02f,
  2.50007927e-01f, -1.56674124e-02f, -1.92009173e-02f, 4.41385917e-02f, 3.11157443e-02f, -1.12122230e-01f, 1.39622670e-03f, -2.37980224e-02f, 3.67179550e-02f, -6.27035201e-02f,
  -1.67604573e-02f, -9.11362618e-02f, -4.71601486e-02f, 3.28796394e-02f, -9.70616564e-02f, 1.09147318e-01f, 7.18873814e-02f, -1.13733867e-02f, 9.50607955e-02f, 1.32443950e-01f,
  8.50924328e-02f, -9.41059366e-02f, -1.24566466e-01f, 6.60172570e-03f, -1.23150097e-02f, 5.81124276e-02f, -1.47934388e-02f, -7.84092695e-02f, -1.60385087e-01f, -5.14160236e-03f,
  -1.30877495e-02f, 4.26030725e-01f, -1.09482870e-01f, 2.05029458e-01f, 3.95511776e-01f, 6.04245424e-01f, 4.24199373e-01f, 4.09407645e-01f, 5.22521138e-01f, 6.85558543e-02f,
  1.00985818e-01f, 9.06961188e-02f, -3.79145965e-02f, 2.57114917e-01f, 9.34901461e-02f, 3.14093903e-02f, 3.39321047e-01f, 3.20292503e-01f, 1.63333461e-01f, 6.00643307e-02f,
  5.01258820e-02f, 1.68027714e-01f, -1.96802080e-01f, -1.72361821e-01f, -7.67489001e-02f, -1.83602422e-01f, -3.13060284e-01f, -1.77842811e-01f, -8.63315240e-02f, 1.25682503e-01f,
  1.66827627e-02f, -9.42186452e-03f, -4.13723923e-02f, -7.23910779e-02f, 3.21089290e-02f, -5.43449484e-02f, -1.10214166e-02f, 4.70166467e-02f, -1.34964839e-01f, 2.85648331e-02f,
  7.98718408e-02f, -1.26660079e-01f, 1.17709160e-01f, 7.38320639e-03f, 1.28802270e-01f, -4.55448069e-02f, -7.62831718e-02f, 1.06874160e-01f, 1.22106872e-01f, -2.01324280e-02f,
  6.99515715e-02f, -3.18105407e-02f, 3.67086716e-02f, 8.28326717e-02f, -3.04362960e-02f, 1.08772963e-01f, -8.45126510e-02f, 1.44065589e-01f, -9.74518210e-02f, 1.53630465e-01f,
  -2.70242281e-02f, 3.08812652e-02f, 2.29023043e-02f, -1.68294702e-02f, -1.01246797e-02f, -1.12558320e-01f, -2.64554459e-04f, -3.54982689e-02f, 3.27882394e-02f, 2.30373628e-03f,
  9.85979214e-02f, 9.01417620e-03f, 1.00747369e-01f, -5.74791953e-02f, 1.23810284e-01f, -2.18478739e-02f, 2.05961540e-02f, 4.78462465e-02f, 1.57805935e-01f, 4.63396758e-02f,
  -2.43109418e-03f, -1.19763510e-02f, -2.35759895e-02f, -5.91563284e-02f, -2.56190486e-02f, 6.11062087e-02f, -2.03046147e-02f, -7.56134316e-02f, -6.51002279e-04f, 6.17873669e-02f,
  2.85457730e-01f, 2.50404060e-01f, -5.26188649e-02f, 1.85720716e-02f, -7.16669811e-03f, 3.86042967e-02f, -9.72740054e-02f, -3.36633204e-03f, 7.10395724e-02f, -7.10804909e-02f,
  3.70783955e-02f, -5.84983043e-02f, 6.68963883e-03f, -3.18250582e-02f, -1.27879411e-01f, 1.00607380e-01f, -1.01880990e-02f, 5.64941615e-02f, 1.70920312e-01f, -6.49107769e-02f,
  -8.94727558e-02f, 7.44085908e-02f, -6.36066049e-02f, 7.13038370e-02f, 6.49827719e-02f, -1.42906895e-02f, 3.85025516e-02f, -6.87578991e-02f, -4.20075729e-02f, 8.14021453e-02f,
  5.51793464e-02f, -5.16824543e-01f, -4.89184320e-01f, -1.90517008e-01f, 2.88233012e-01f, 2.81766683e-01f, -1.59840509e-02f, -5.61963916e-02f, -3.99646163e-01f, 2.36632135e-02f,
  1.39447942e-01f, -1.40457556e-01f, -3.92567664e-01f, -7.74520487e-02f, 1.61491901e-01f, -3.09778810e-01f, 1.74762636e-01f, 1.30839497e-01f, -1.72625944e-01f, 7.31782615e-02f,
  -6.32035434e-02f, 9.27004367e-02f, -1.56120270e-01f, 2.56569922e-01f, 1.23428524e-01f, 5.25248460e-02f, 2.74018228e-01f, 2.16510613e-02f, 2.66572624e-01f, 2.00857610e-01f,
  -4.39996226e-03f, -1.86551139e-01f, -8.78877193e-02f, -4.34238985e-02f, -2.29078215e-02f, 1.42827988e-01f, 1.06800400e-01f, 1.03873461e-01f, -2.60883830e-02f, -1.20450102e-01f,
  5.26737198e-02f, 7.58623183e-02f, -4.97722924e-02f, 2.76318248e-02f, -5.93561260e-03f, -2.01432109e-02f, -1.93040535e-01f, -1.59115344e-01f, -2.05534488e-01f, -1.23919033e-01f,
  -7.56880566e-02f, -1.90352686e-02f, 6.42875805e-02f, -5.85814081e-02f, -7.04075620e-02f, -8.02967697e-02f, -1.17002605e-02f, 6.43226430e-02f, -7.21832216e-02f, 9.92910936e-02f,
  5.25908284e-02f, 8.95189494e-02f, 2.55771056e-02f, -1.10590346e-01f, -2.96696611e-02f, -8.31891820e-02f, -3.82063054e-02f, -1.57613717e-02f, 4.76570353e-02f, -5.08811846e-02f,
  -7.84263760e-02f, -3.30594964e-02f, 5.71409538e-02f, 1.03511937e-01f, 1.24299563e-01f, -4.30895612e-02f, 5.58809265e-02f, 1.16098531e-01f, 2.00464763e-02f, -1.06288455e-01f,
  -5.90604842e-02f, 1.04097180e-01f, 5.42294346e-02f, 6.90706670e-02f, -1.40189528e-01f, 6.52054995e-02f, 1.56958774e-01f, -9.63595584e-02f, 4.28070165e-02f, 1.10806309e-01f,
  7.31684268e-02f, 1.21461943e-01f, -9.24763307e-02f, -5.21283189e-04f, -1.54369175e-01f, 4.76419143e-02f, -1.15136683e-01f, -1.50752496e-02f, 1.25120878e-01f, -7.69193470e-02f,
  2.03875259e-01f, 4.42901589e-02f, 6.61956966e-02f, 4.21051942e-02f, -1.23576727e-02f, 1.49685144e-02f, 3.92686427e-02f, 9.06948224e-02f, -1.18971497e-01f, -8.70216824e-03f,
  1.61882982e-01f, 1.70151934e-01f, -1.51457889e-02f, 2.98388605e-03f, -2.90819909e-02f, 6.10989258e-02f, 5.03377765e-02f, 2.13586949e-02f, -6.72058612e-02f, 9.68513452e-03f,
  3.58029783e-01f, -1.25427052e-01f, -2.81994734e-02f, 4.75069098e-02f, 1.40656620e-01f, 1.68594927e-01f, 1.11432180e-01f, -1.12688698e-01f, 3.56522262e-01f, -8.13541189e-02f,
  1.80521943e-02f, -1.50420442e-01f, -1.02135576e-01f, 1.05174571e-01f, 1.77469462e-01f, -3.79214659e-02f, 2.34838858e-01f, 1.36383176e-01f, 1.04925238e-01f, 1.11580640e-01f,
  1.88913018e-01f, 2.33021448e-03f, -2.92419523e-01f, -1.08456001e-01f, -3.98495942e-02f, -8.37363899e-02f, -1.82949200e-01f, -4.89540026e-03f, -2.20654055e-01f, 5.51671907e-02f,
  2.24390663e-02f, 1.10638507e-01f, -9.83154550e-02f, 2.40231045e-02f, 9.47683007e-02f, 4.78004366e-02f, -9.96147916e-02f, -1.44856442e-02f, -7.08313519e-03f, 7.55081400e-02f,
  -1.23903751e-01f, 6.91360086e-02f, 4.59261984e-02f, -1.55476769e-02f, -2.68748798e-03f, 2.11103037e-02f, -2.86520440e-02f, 2.78892405e-02f, -2.26560593e-01f, 6.44113403e-03f,
  1.17598824e-01f, 3.63981873e-02f, 1.57734618e-01f, 1.55877438e-03f, 9.59298611e-02f, 1.22498818e-01f, -3.34950686e-02f, -9.46865454e-02f, 5.04268184e-02f, 3.39311454e-03f,
  -4.38688975e-03f, 1.00497760e-01f, 1.23161651e-01f, 1.61792859e-02f, 1.68718413e-01f, 1.84164550e-02f, 1.00184314e-01f, 3.32947411e-02f, 2.84698457e-01f, 4.68262611e-03f,
  4.60462905e-02f, 9.01932716e-02f, 1.10351101e-01f, 3.63690890e-02f, 8.46950151e-03f, 5.61857633e-02f, -5.22031076e-02f, -5.18808775e-02f, 1.50470912e-01f, -7.99714774e-02f,
  5.46849445e-02f, 1.85180649e-01f, -5.68455048e-02f, -2.14462191e-01f, 9.75464731e-02f, 7.11528882e-02f, 4.00159545e-02f, -5.07962666e-02f, 3.18401493e-02f, -3.49331386e-02f,
  -6.95844814e-02f, 4.70163748e-02f, -5.27887940e-02f, -5.69391660e-02f, 1.18453596e-02f, 1.62691638e-01f, 6.83212057e-02f, 6.65631667e-02f, -6.36032075e-02f, 1.43721446e-01f,
  -1.11560345e-01f, 4.40317951e-02f, 3.30605842e-02f, 9.79080424e-03f, -9.57858488e-02f, 5.07061705e-02f, 3.39988992e-02f, 1.54150436e-02f, -2.36772522e-01f, -1.85507163e-01f,
  8.61434713e-02f, 1.86343387e-01f, 1.33599073e-01f, 8.80360976e-03f, -1.01020291e-01f, -1.66363284e-01f, 4.73765731e-02f, -8.62478912e-02f, 6.34667203e-02f, -2.93703992e-02f,
  -8.45986009e-01f, 1.95656165e-01f, 4.02752221e-01f, -3.56307477e-01f, -8.56661871e-02f, 4.20322508e-01f, 2.67173737e-01f, -3.31321880e-02f, -1.91165045e-01f, 2.26873737e-02f,
  -2.38012686e-01f, -2.65914500e-01f, 8.35745931e-02f, -8.59304443e-02f, 2.79883832e-01f, 3.03616345e-01f, 9.36205611e-02f, -6.13363832e-02f, 4.03533056e-02f, -1.74723193e-01f,
  6.17524274e-02f, -2.06862003e-01f, 2.59201020e-01f, -1.13068323e-03f, -1.26687214e-01f, -2.13418037e-01f, -1.78036079e-01f, 3.08440849e-02f, -1.00207902e-01f, -4.29280847e-02f,
  -2.88768560e-01f, -4.10883456e-01f, -3.36212337e-01f, -1.44049153e-02f, -4.46744859e-02f, -4.56373543e-02f, 7.03935996e-02f, -4.45037186e-02f, -1.14551023e-01f, -2.82331351e-02f,
  -1.62252709e-01f, 1.07251808e-01f, -1.05805278e-01f, 4.47317921e-02f, -3.38899577e-03f, -3.53319570e-02f, 8.07461515e-02f, 2.96048801e-02f, -9.27557051e-02f, 9.16091055e-02f,
  8.30519795e-02f, 1.03268735e-01f, -6.42864108e-02f, 4.62204926e-02f, 1.34802992e-02f, -1.30099682e-02f, 1.18443869e-01f, 9.86793265e-03f, 8.55722204e-02f, 1.96712255e-03f,
  1.22315474e-01f, -4.70950976e-02f, -9.67303440e-02f, -7.21184164e-02f, 1.01990268e-01f, -6.99676946e-02f, -9.34168622e-02f, -6.78231567e-02f, -2.07528919e-02f, 1.95341650e-02f,
  -2.77016331e-02f, -4.27153297e-02f, -1.02932177e-01f, 9.54444893e-03f, 2.56420244e-02f, -2.23507676e-02f, 2.59889737e-02f, -8.49040151e-02f, -2.49292217e-02f, -1.03284316e-02f,
  -7.54039660e-02f, 7.81235024e-02f, 4.60967571e-02f, 1.72267202e-02f, 8.83945525e-02f, 2.24655867e-03f, -3.50723192e-02f, 1.37010127e-01f, -1.42039299e-01f, 2.25152373e-02f,
  -3.39254379e-01f, -2.51238167e-01f, -2.00450733e-01f, -7.72563145e-02f, -9.73025337e-02f, 4.41158637e-02f, 3.98149900e-02f, -1.35443266e-02f, 1.42778158e-02f, 1.12989955e-02f,
  -5.40502220e-02f, -3.14532183e-02f, -9.61790159e-02f, -4.69289273e-02f, 1.59033105e-01f, 6.30910248e-02f, -7.65341818e-02f, -4.04010564e-02f, -1.28676310e-01f, -5.29885218e-02f,
  -4.59821671e-02f, -8.58073495e-03f, 4.23139744e-02f, -5.57177775e-02f, 5.02454303e-03f, -1.11943819e-01f, -5.75167276e-02f, 8.90828855e-03f, -2.64334679e-02f, 1.32647023e-01f,
  1.43647537e-01f, -9.82471034e-02f, -3.25945556e-01f, -2.54347414e-01f, -4.39080745e-01f, -2.61267275e-01f, -1.38049290e-01f, -1.83396995e-01f, 2.09059007e-02f, 2.19096050e-01f,
  -1.85536742e-01f, 8.48455429e-02f, 4.24314618e-01f, -1.79955482e-01f, 4.08769660e-02f, 5.55739224e-01f, 2.93682013e-02f, 1.49698019e-01f, -1.65432785e-02f, -1.59376994e-01f,
  -3.24575938e-02f, 6.91971881e-03f, 1.52648361e-02f, -2.04964906e-01f, -4.44154531e-01f, -2.04482689e-01f, 1.64556690e-02f, -2.18994111e-01f, -2.99178958e-01f, -1.38418525e-01f,
  -4.58738543e-02f, 1.20229922e-01f, -1.45685151e-01f, 7.16156363e-02f, -9.71163996e-03f, 5.99128902e-02f, -3.31492536e-02f, 1.08662307e-01f, 3.82483974e-02f, 4.31203246e-02f,
  9.98964831e-02f, 8.07203427e-02f, 4.26141731e-02f, -4.39745784e-02f, -1.04072452e-01f, -3.30929295e-03f, 1.26488477e-01f, -8.17338675e-02f, 2.52665058e-02f, 2.85862722e-02f,
  -8.72824341e-02f, 1.88627597e-02f, -1.21243834e-01f, 1.76860541e-01f, 8.96846782e-03f, 2.46942379e-02f, 9.92961451e-02f, -8.72419104e-02f, -1.12526312e-01f, -5.55343702e-02f,
  7.23641291e-02f, 7.49642104e-02f, -5.33520989e-03f, -1.05928786e-01f, 1.00497000e-01f, 9.25058592e-03f, -5.39928079e-02f, 7.98962787e-02f, -2.62176692e-02f, 5.49906790e-02f,
  -3.29762250e-02f, -7.83968270e-02f, -3.71985574e-04f, -3.37635819e-03f, 4.98655401e-02f, 1.06385745e-01f, -1.22942636e-02f, -9.79779940e-03f, -2.68982463e-02f, -4.46211100e-02f,
  7.10948631e-02f, -1.27279782e-03f, -3.59547362e-02f, 9.80948731e-02f, -9.27808061e-02f, 3.72605282e-03f, 4.63472530e-02f, -4.90770973e-02f, 7.96850547e-02f, -4.30405848e-02f,
  5.01959734e-02f, 4.78584506e-02f, -1.39110815e-02f, 3.31156179e-02f, -3.30497064e-02f, -1.38047546e-01f, -7.06662610e-02f, 2.44219601e-02f, 7.06390291e-02f, -1.30092725e-01f,
  7.34554231e-02f, 1.39262274e-01f, -4.14182954e-02f, -4.12279703e-02f, 8.18855911e-02f, -1.13954730e-02f, 1.43022925e-01f, 3.11529059e-02f, -6.65062945e-03f, 7.18521327e-02f,
  7.47916326e-02f, 6.95079118e-02f, 1.73310861e-01f, 8.64707455e-02f, 1.23742960e-01f, 5.58382608e-02f, 1.44390427e-02f, -1.64144207e-02f, -1.14119202e-01f, -4.14010882e-02f,
  -4.58347976e-01f, 1.31739870e-01f, -2.37174947e-02f, -5.08968413e-01f, 2.16676250e-01f, 1.62394598e-01f, -2.27991119e-01f, 2.59873867e-01f, -2.37541154e-01f, 1.48845196e-01f,
  1.29985213e-01f, -2.60575563e-01f, 8.64593014e-02f, -4.65486199e-01f, -3.80637228e-01f, -2.23515570e-01f, -4.39581931e-01f, -2.72951096e-01f, -1.48161724e-01f, -5.91316931e-02f,
  -1.72650054e-01f, -2.59591699e-01f, -2.08455071e-01f, 7.29535222e-02f, -1.54770410e-03f, 7.96813611e-03f, 1.82080552e-01f, 1.23379797e-01f, -4.33511101e-02f, -1.12705320e-01f,
  -2.16646027e-02f, -1.39011221e-03f, 4.89226803e-02f, -5.88282347e-02f, 1.15905054e-01f, -1.21402815e-02f, -2.98724342e-02f, -8.17255229e-02f, 5.66800963e-03f, -1.26192391e-01f,
  -1.01002373e-01f, -1.05164841e-01f, -8.53840932e-02f, 1.23721984e-04f, 2.78293863e-02f, 7.61152059e-02f, 5.85699603e-02f, 1.67675480e-01f, -5.50854299e-03f, -9.73461345e-02f,
  -5.96663654e-02f, 7.28095397e-02f, -5.68723641e-02f, -7.06518739e-02f, -2.70021148e-02f, 6.53042123e-02f, -5.17846495e-02f, 3.32496576e-02f, 8.72680079e-03f, -6.30056709e-02f,
  -7.22630098e-02f, -4.86478508e-02f, -7.66133964e-02f, -1.88745689e-02f, 4.60024811e-02f, -4.50950898e-02f, -3.27410512e-02f, -1.18631842e-02f, -1.17340900e-01f, 1.37290552e-01f,
  -1.30881341e-02f, -9.27523598e-02f, -3.81202251e-02f, 3.56412977e-02f, -1.02442510e-01f, -1.04075983e-01f, 7.68876970e-02f, 1.04842680e-02f, -5.32848835e-02f, 7.44609609e-02f,
  8.25473964e-02f, -1.01313792e-01f, -3.51283280e-03f, -5.41311279e-02f, -5.32430038e-02f, 2.51824278e-02f, 1.36577114e-01f, 3.17037292e-02f, 4.78431433e-02f, -4.58147414e-02f,
  1.49242520e-01f, 1.84596375e-01f, 1.78527483e-03f, 3.41307446e-02f, -4.01954055e-02f, -1.90780926e-02f, -1.35702148e-01f, -6.20375536e-02f, 2.83191968e-02f, -2.96270940e-02f,
  1.72119979e-02f, 5.25669232e-02f, 1.52180538e-01f, -6.32831976e-02f, 2.36861743e-02f, 5.96295521e-02f, -7.23143741e-02f, 1.09064370e-01f, 7.39890188e-02f, 2.14028180e-01f,
  1.02655411e-01f, 6.15409203e-03f, -2.33311355e-01f, -6.53921962e-02f, -2.20011007e-02f, 1.22775964e-01f, 1.51801616e-01f, 1.96379200e-02f, -3.83289233e-02f, -1.03540281e-02f,
  1.16383895e-01f, -4.60766733e-01f, -1.92432582e-01f, 4.08968389e-01f, 2.97148824e-01f, 7.14887083e-02f, -2.34140992e-01f, 2.70267069e-01f, -1.22842686e-02f, -2.88449138e-01f,
  -4.98007424e-02f, -8.85894299e-02f, -5.26097238e-01f, 3.63262326e-01f, 3.93516123e-01f, -3.85660946e-01f, 3.47723007e-01f, 1.67534322e-01f, -7.00217336e-02f, -1.68860666e-02f,
  1.95920512e-01f, 4.06035632e-01f, 1.24396361e-01f, 2.47314557e-01f, 1.51137546e-01f, 7.67892972e-02f, 1.67850628e-01f, -1.72446981e-01f, 3.64098459e-01f, 1.82552144e-01f,
  1.07519906e-02f, -1.35958955e-01f, 4.17216383e-02f, 7.34264106e-02f, -8.78562257e-02f, -4.38552350e-02f, -4.77376170e-02f, 1.02579542e-01f, 6.58933446e-02f, -9.99980606e-03f,
  -4.64573130e-02f, 1.62885696e-01f, 1.84405565e-01f, 6.76364303e-02f, 9.34642330e-02f, 6.64543286e-02f, -7.29552358e-02f, -5.51710837e-02f, 9.66861695e-02f, -2.82239541e-02f,
  -1.27574638e-01f, 2.24093683e-02f, -7.26807788e-02f, 7.65126124e-02f, -6.00912236e-02f, 7.94330984e-02f, -1.65836960e-02f, -6.10486269e-02f, -3.42966989e-02f, 3.94284353e-02f,
  -1.02913558e-01f, -1.04201555e-01f, -4.40144502e-02f, 1.09393217e-01f, -9.60230678e-02f, -6.16907654e-03f, 2.11927239e-02f, -1.36393243e-02f, -4.86520790e-02f, -1.72330383e-02f,
  8.44590887e-02f, 7.21470043e-02f, 8.49949419e-02f, 3.66145670e-02f, 4.11259383e-03f, 9.46554691e-02f, -2.49364879e-02f, 3.59266554e-03f, 6.27574027e-02f, 3.88133787e-02f,
  8.57197121e-03f, 3.61188687e-02f, 2.54928805e-02f, 8.00314099e-02f, 4.95268926e-02f, 2.87571922e-02f, -6.63545430e-02f, -3.55299450e-02f, -2.62127053e-02f, 9.58510637e-02f,
  -9.82160717e-02f, -2.54985243e-01f, -4.17531878e-02f, 1.33130252e-01f, -7.30034485e-02f, 1.29417375e-01f, -5.71296662e-02f, 4.09375206e-02f, -5.67080379e-02f, -9.93185267e-02f,
  6.43304139e-02f, 3.83010730e-02f, -6.67381741e-04f, 5.46950512e-02f, 2.92371102e-02f, -5.76763451e-02f, -1.36786595e-01f, -7.29475915e-03f, 9.28784534e-02f, -1.25936484e-02f,
  -7.20458403e-02f, -1.58028275e-01f, 7.27664009e-02f, 7.61154220e-02f, -9.13761258e-02f, -3.52005437e-02f, -7.30801821e-02f, 3.78257111e-02f, 5.73585965e-02f, -9.25565064e-02f,
  -2.61928998e-02f, 3.08838580e-02f, -4.89749946e-02f, 2.35649422e-01f, -4.24548127e-02f, -1.89204905e-02f, -2.17984244e-01f, 2.02084497e-01f, -1.01280719e-01f, -5.16285822e-02f,
  2.02993348e-01f, -1.71431806e-02f, -1.88894346e-01f, 3.55958998e-01f, 2.70389795e-01f, -2.59213001e-01f, 2.83904612e-01f, 6.54781535e-02f, -6.64841235e-02f, 2.44808808e-01f,
  1.76078618e-01f, 3.68594885e-01f, 2.66156137e-01f, 2.55909204e-01f, 3.21078836e-03f, 1.17520183e-01f, 3.21091354e-01f, -1.12172738e-01f, 4.20881122e-01f, 6.33474439e-02f,
  -4.83429246e-03f, 1.02481119e-01f, -3.61512341e-02f, -9.18778703e-02f, 1.19099356e-01f, 7.28294179e-02f, -8.48346576e-02f, 4.72518913e-02f, 5.05601615e-02f, 8.82442370e-02f,
  -2.18350347e-02f, -2.27934169e-03f, 1.26868904e-01f, 5.18126674e-02f, -2.79404763e-02f, -1.17098376e-01f, 8.27412400e-03f, 1.05165079e-01f, 7.25473911e-02f, 8.82336125e-02f,
  -6.74811825e-02f, -1.06916867e-01f, 7.36145005e-02f, 8.96515101e-02f, 5.32787144e-02f, 7.83319920e-02f, -7.74855688e-02f, 1.24736242e-02f, 1.13968149e-01f, 9.39866379e-02f,
  1.29779093e-02f, -8.15254003e-02f, 7.96220545e-03f, -1.99301983e-03f, 6.26799837e-02f, -3.25233154e-02f, 1.32130444e-01f, 1.41187176e-01f, 4.26154584e-02f, 9.89509150e-02f,
  3.19211669e-02f, 1.03582600e-02f, 1.75299440e-02f, 7.11277649e-02f, -2.29833983e-02f, -5.60058020e-02f, -7.30846599e-02f, 6.24702796e-02f, 1.77985251e-01f, 4.81022298e-02f,
  -8.25140700e-02f, -7.81920329e-02f, 2.63904743e-02f, -2.31285449e-02f, -4.92830165e-02f, -2.76992060e-02f, -1.11677945e-02f, -5.74129149e-02f, 2.51662941e-03f, 2.90635787e-02f,
  1.60250440e-01f, 1.67608127e-01f, 4.83278371e-02f, -1.00405820e-01f, 2.61728037e-02f, 1.11566670e-01f, -8.94583762e-02f, 8.16397816e-02f, 1.40135020e-01f, 5.16427904e-02f,
  1.53770745e-01f, -3.05251572e-02f, -1.67486575e-02f, 9.26085189e-02f, 1.51845604e-01f, -7.50112683e-02f, -1.00483581e-01f, 1.31512098e-02f, 1.66385442e-01f, 1.15736745e-01f,
  -1.79140810e-02f, -4.66168150e-02f, 7.51236677e-02f, -6.19834140e-02f, 8.59769657e-02f, 3.70520391e-02f, -8.79168569e-04f, 7.90564716e-03f, 1.39427200e-01f, 3.01633049e-02f,
  -6.58109248e-01f, 4.29442704e-01f, 4.09381576e-02f, -4.81596917e-01f, 4.12894011e-01f, 1.24333359e-01f, -1.32518098e-01f, 2.25880980e-01f, 7.97553733e-02f, 6.04424886e-02f,
  1.03932068e-01f, -2.27051508e-02f, 3.42959970e-01f, -1.62581101e-01f, -2.52509385e-01f, 4.00642641e-02f, -3.39611232e-01f, -2.09382415e-01f, 1.41466320e-01f, 1.94302492e-03f,
  -8.57961476e-02f, -6.92685843e-02f, -2.18273416e-01f, 4.14269596e-01f, -2.66497023e-02f, -7.65284970e-02f, -3.27819705e-01f, 2.77054518e-01f, -2.75290132e-01f, 1.35895610e-01f,
  -1.26965463e-01f, -1.38102636e-01f, -5.56037985e-02f, -1.33342206e-01f, -7.51523599e-02f, -2.12637447e-02f, -1.98992491e-01f, 1.67453606e-02f, 1.09393470e-01f, 2.73725949e-02f,
  -2.42171939e-02f, 1.31815135e-01f, -1.23191334e-01f, 6.98632002e-02f, 5.36104552e-02f, 6.88519478e-02f, -4.31694314e-02f, -6.44924566e-02f, 2.58585978e-02f, 3.01348101e-02f,
  1.39366239e-01f, 1.04844859e-02f, -9.39945579e-02f, -8.52782726e-02f, -2.75453683e-02f, -7.43237510e-02f, -3.56884277e-03f, -8.90010595e-02f, -1.00248478e-01f, 2.63678674e-02f,
  5.83864003e-02f, 6.80335686e-02f, -1.58505291e-02f, -5.88319190e-02f, 1.57771543e-01f, 4.90932651e-02f, 9.50781107e-02f, -7.03119338e-02f, -4.92383465e-02f, -3.02096698e-02f,
  -9.28456932e-02f, -2.32866290e-03f, 2.75948402e-02f, -2.06504948e-02f, -3.72749940e-02f, -3.63059267e-02f, -9.74572077e-02f, -4.70671840e-02f, -1.16222754e-01f, -6.52717277e-02f,
  -2.18555387e-02f, -7.44738132e-02f, 6.66602179e-02f, -4.91881091e-03f, 2.45816857e-02f, -2.99507589e-03f, 3.56401056e-02f, -5.86804859e-02f, -1.28198601e-02f, -8.14475045e-02f,
  -3.61343890e-01f, -2.87952602e-01f, 2.13717446e-02f, -3.45380008e-02f, -3.46800387e-02f, -4.78221066e-02f, -8.83843750e-02f, 8.34964775e-03f, 4.39591520e-03f, -8.13208520e-03f,
  -8.80094171e-02f, -3.37621011e-02f, -1.26803488e-01f, -7.73981540e-03f, -2.20252182e-02f, -1.81639194e-01f, -1.28318995e-01f, -8.33109617e-02f, -1.44101307e-01f, 5.56865260e-02f,
  -2.53054872e-02f, 2.51139887e-02f, 1.41947856e-02f, -1.54703362e-02f, 5.11300890e-03f, -5.29235043e-03f, -2.84296758e-02f, 1.41361896e-02f, -6.65535331e-02f, 9.79680046e-02f,
  -4.91300672e-02f, 4.12778735e-01f, -2.54956305e-01f, 1.86583012e-01f, -1.66059688e-01f, 5.69187462e-01f, 5.68850994e-01f, 5.97862620e-03f, 1.55241415e-01f, 3.89928818e-01f,
  4.76888567e-02f, 1.74268216e-01f, 2.39195913e-01f, 3.94807577e-01f, 1.85121968e-01f, 2.88914233e-01f, 3.24331611e-01f, 3.28272372e-01f, -4.91639823e-02f, 1.58076748e-01f,
  -3.71481478e-02f, 3.22510272e-01f, -1.29074082e-01f, -1.02996146e-02f, -1.05114035e-01f, -2.03886896e-01f, -1.74765110e-01f, -1.51558593e-01f, -2.90051810e-02f, 3.19789015e-02f,
  5.56469709e-02f, -4.02500331e-02f, -2.04686616e-02f, 5.91412373e-02f, -7.75270537e-02f, -3.98449600e-02f, 2.16665454e-02f, 4.50345576e-02f, -7.69937783e-02f, 2.62245368e-02f,
  4.50520366e-02f, 9.57001969e-02f, 8.64614174e-02f, 4.26355749e-02f, -3.82822901e-02f, 1.36122573e-02f, -9.66153108e-03f, -1.98574901e-01f, 3.57254385e-03f, -4.50937450e-02f,
  1.08907530e-02f, 1.90090891e-02f, 2.94973776e-02f, -1.28801614e-02f, -2.40233373e-02f, 1.26386747e-01f, 2.17393160e-01f, -1.12393275e-01f, 6.85183182e-02f, 1.29775971e-01f,
  -6.70526922e-02f, 1.18367784e-01f, 7.62395337e-02f, -3.08416523e-02f, -2.69555300e-03f, 1.61577817e-02f, -1.32982899e-02f, 1.38575975e-02f, 3.05588860e-02f, 7.09129497e-02f,
  -6.27162913e-03f, -1.15596512e-02f, 4.59147543e-02f, 8.35821405e-02f, 9.27699506e-02f, 1.73000130e-03f, -1.06260531e-01f, -7.05552921e-02f, -8.59866887e-02f, -1.00931846e-01f,
  -2.54868008e-02f, 1.35221228e-01f, -9.68939438e-02f, -1.60715625e-01f, 1.60069569e-04f, -1.24975462e-02f, 6.66912720e-02f, -1.30387068e-01f, -7.22599998e-02f, 4.76322062e-02f,
  1.31358892e-01f, 2.82963783e-01f, -4.33716588e-02f, -1.48101104e-03f, -3.80756222e-02f, 2.94361338e-02f, 9.78726000e-02f, 9.96797308e-02f, 7.39221275e-02f, 6.50327280e-02f,
  -1.49554918e-02f, 8.27019140e-02f, -2.09573153e-02f, -2.37002037e-02f, -6.34237230e-02f, 8.77839923e-02f, 7.74396881e-02f, -5.43467626e-02f, -4.45289165e-02f, -1.26810431e-01f,
  6.99526668e-02f, 9.26315039e-02f, 5.54882027e-02f, 6.21275380e-02f, 1.11012094e-01f, -7.05370530e-02f, 1.00058146e-01f, -1.47999093e-01f, -5.60966246e-02f, 5.53777702e-02f,
  1.17117487e-01f, 3.10251892e-01f, 4.18625847e-02f, -1.40930369e-01f, -3.81246597e-01f, -2.04739332e-01f, -2.99219072e-01f, -3.37340385e-02f, 1.71792969e-01f, 1.76151171e-01f,
  -3.55187744e-01f, 4.75899488e-01f, 1.01857409e-01f, -2.68490851e-01f, -1.83492079e-01f, -2.17994605e-03f, -2.20344573e-01f, -4.93656956e-02f, -2.18056783e-01f, -1.76945299e-01f,
  -1.14624977e-01f, -5.04886568e-01f, -6.57503158e-02f, -4.25442755e-01f, -2.69572467e-01f, 9.95912775e-02f, -2.66692996e-01f, -2.60745376e-01f, -3.52547765e-02f, -9.43266079e-02f,
  -4.97673713e-02f, 3.33480351e-02f, 8.52374658e-02f, 1.88230544e-01f, 3.61780934e-02f, 1.57630313e-02f, 5.04049771e-02f, -1.98544990e-02f, -2.74700355e-02f, 1.00067779e-01f,
  1.72530726e-01f, 1.12017423e-01f, 6.17807880e-02f, -9.03152376e-02f, 2.29868758e-02f, 2.46327557e-02f, 1.62171990e-01f, 1.24405213e-01f, 9.14478526e-02f, 5.19354418e-02f,
  -5.11599053e-03f, 1.40030727e-01f, 5.57140782e-02f, 3.02325994e-01f, 1.17312998e-01f, -7.63014937e-03f, 1.55373335e-01f, 1.10562906e-01f, 1.65855274e-01f, -1.90227553e-02f,
  -1.46000218e-02f, -4.79725003e-02f, -1.16414011e-01f, -1.73697874e-01f, -1.64852545e-01f, -1.24648876e-01f, -3.67165431e-02f, -1.85377579e-02f, -1.66856926e-02f, -9.38651711e-03f,
  -6.15170486e-02f, -2.37198919e-02f, -9.17686969e-02f, -2.15675794e-02f, -6.58579096e-02f, 2.86118109e-02f, -1.13467038e-01f, 1.30229294e-01f, 1.05135374e-01f, -3.63567397e-02f,
  -1.07272714e-01f, -9.32558030e-02f, -2.06033997e-02f, -3.38785239e-02f, -1.39558658e-01f, -4.40017842e-02f, 1.04724213e-01f, 8.38316455e-02f, -1.83989189e-03f, -8.57281983e-02f,
  4.57893796e-02f, -6.75339550e-02f, -6.53416151e-03f, 1.34674966e-01f, -1.46293538e-02f, -7.09473938e-02f, -1.14580311e-01f, 2.22718105e-01f, -8.41193646e-02f, -8.34655762e-02f,
  1.33418471e-01f, 6.13931492e-02f, 1.36731282e-01f, -1.41679905e-02f, 6.73815683e-02f, -1.84081327e-02f, -3.29880863e-02f, 4.37937155e-02f, -4.67152428e-03f, 7.23871887e-02f,
  1.46286532e-01f, -6.29097894e-02f, 1.21196039e-01f, 5.67791350e-02f, 1.27853125e-01f, 1.31582916e-01f, 8.72859210e-02f, 8.29578489e-02f, -1.30704949e-02f, 3.89426611e-02f,
  -4.18905675e-01f, 5.47992289e-01f, 1.46439701e-01f, 4.13730919e-01f, -1.39072344e-01f, -5.84499300e-01f, -1.07518928e-02f, 9.82684493e-02f, 2.07429290e-01f, 3.31068546e-01f,
  1.83922902e-01f, 2.73160517e-01f, 9.70341265e-02f, 2.46424720e-01f, -4.56090719e-01f, 4.74143177e-02f, -9.78202298e-02f, -4.26636264e-02f, -1.40451387e-01f, 1.22745186e-01f,
  -1.14735633e-01f, 1.24981761e-01f, 1.14661284e-01f, -8.47259289e-05f, 6.92500845e-02f, 3.44344154e-02f, 2.00996548e-01f, 2.33121458e-02f, 6.63461462e-02f, -2.91936751e-02f,
  5.17385080e-02f, 2.24707901e-01f, 5.44050783e-02f, -1.15564540e-02f, -6.59357980e-02f, -1.00628391e-01f, 3.17581184e-02f, -1.09268792e-01f, 2.44376492e-02f, 9.82397981e-03f,
  3.29270922e-02f, 5.30184656e-02f, -6.35223091e-02f, -4.17872705e-02f, -3.51046845e-02f, 8.58742818e-02f, 1.04525171e-01f, -2.46320404e-02f, 1.44452661e-01f, -1.89414937e-02f,
  3.25406902e-02f, 1.00227937e-01f, -7.38440230e-02f, 8.63192976e-02f, -3.30693945e-02f, 2.63632964e-02f, -9.90084931e-02f, 6.22836361e-03f, -1.99508481e-02f, -6.19863160e-02f,
  -1.97273150e-01f, 1.53194472e-01f, 8.03938136e-03f, 1.51143014e-01f, 4.82223071e-02f, -2.67150998e-02f, -3.20098512e-02f, -7.35826343e-02f, -2.18715146e-01f, -1.40269706e-02f,
  7.47075155e-02f, 5.84117845e-02f, -3.62817347e-02f, -7.97817633e-02f, -5.55767454e-02f, 5.46461605e-02f, -2.87300963e-02f, 2.54515139e-03f, -1.00776486e-01f, 3.41950506e-02f,
  9.90391523e-02f, -7.84503073e-02f, 9.86927003e-02f, -6.53254837e-02f, 3.06421667e-02f, 6.50563538e-02f, 1.59603432e-01f, 9.53281969e-02f, 3.61128524e-02f, -8.46259594e-02f,
  1.48842791e-02f, 1.15302555e-01f, 4.59799320e-02f, -8.40598121e-02f, 3.93453464e-02f, -1.45734385e-01f, 1.24857044e-02f, -1.16372786e-01f, -6.84712976e-02f, -1.03406787e-01f,
  4.56097201e-02f, 1.80813633e-02f, -8.63664672e-02f, -6.67124242e-02f, -2.18393765e-02f, 7.95147642e-02f, 1.94338456e-01f, 5.49100153e-02f, 7.48334778e-03f, -7.02435598e-02f,
  1.34683207e-01f, -7.89989308e-02f, -9.07301754e-02f, -1.25410959e-01f, -1.56463549e-01f, 1.14023775e-01f, 1.00736655e-02f, 4.03158367e-02f, -1.21673040e-01f, 4.88987789e-02f,
  3.86973172e-01f, -1.72846213e-01f, 4.60074306e-01f, 3.09050649e-01f, 1.91586867e-01f, 2.37444282e-01f, 4.41222668e-01f, -7.77419249e-04f, 1.13828801e-01f, -1.95418015e-01f,
  -1.58449903e-01f, 3.31317693e-01f, 1.60890386e-01f, -5.02574556e-02f, 1.55661404e-01f, -2.06354812e-01f, 1.10138766e-02f, -3.02657625e-03f, -5.25073670e-02f, 1.44398823e-01f,
  5.55894747e-02f, -3.30791891e-01f, 1.18564159e-01f, -2.64219314e-01f, 2.84848690e-01f, 4.14311402e-02f, -2.59079576e-01f, 1.81849346e-01f, -1.85729370e-01f, 4.60306369e-02f,
  -2.92418413e-02f, -2.78169885e-02f, 7.37944320e-02f, -8.47443640e-02f, 9.37150605e-03f, 4.20506112e-02f, -1.62572265e-02f, 1.57265916e-01f, 7.83767775e-02f, 4.24173735e-02f,
  4.79116552e-02f, 8.61810371e-02f, -3.54688093e-02f, 9.70470533e-03f, -4.85853618e-03f, 2.92179622e-02f, 1.09614491e-01f, 3.11198831e-02f, 1.05456524e-01f, 1.20162569e-01f,
  5.40509559e-02f, 7.19930977e-02f, -4.80225794e-02f, -1.04414606e-02f, 5.28085083e-02f, -2.74576377e-02f, 6.93347380e-02f, 2.01718420e-01f, 6.93029612e-02f, 4.02445272e-02f,
  -6.20360561e-02f, 8.29010382e-02f, -5.40730637e-03f, -1.03964452e-02f, 7.10537583e-02f, -5.18335924e-02f, -7.81231560e-03f, -6.95013106e-02f, -3.91315930e-02f, 4.39431937e-03f,
  2.74871420e-02f, 4.85446714e-02f, 3.85507233e-02f, 7.41437376e-02f, -6.60696477e-02f, 5.09008914e-02f, -1.23964045e-02f, -6.47812560e-02f, -1.16917500e-02f, 1.24378093e-02f,
  6.73477119e-03f, -7.83079341e-02f, 1.68220267e-01f, 1.13774799e-01f, -8.07790377e-04f, 8.44517201e-02f, -5.59152924e-02f, 1.32376745e-01f, -5.32019734e-02f, -3.36538292e-02f,
  -2.84914643e-01f, -3.86730045e-01f, -1.19321272e-01f, -1.39700860e-01f, -1.35440141e-01f, -4.16009501e-02f, -7.57236183e-02f, 1.00086898e-01f, -6.40147179e-02f, -7.39095174e-03f,
  -2.47699150e-04f, 1.23335078e-01f, 1.76972374e-02f, 1.63195014e-03f, -6.72999769e-02f, 3.89169343e-02f, 3.57849672e-02f, -9.23404843e-02f, -1.15409326e-02f, -7.02540502e-02f,
  4.81542908e-02f, -3.81592624e-02f, -1.83649119e-02f, -6.47036582e-02f, -1.99384894e-02f, 4.52538915e-02f, -1.11217995e-03f, 2.14791950e-03f, 3.06419525e-02f, 5.06581040e-03f,
  7.30396882e-02f, -7.36055672e-02f, -4.40541118e-01f, -3.52833301e-01f, 8.66057053e-02f, 1.21182300e-01f, -1.27062857e-01f, -5.56819700e-03f, -2.69114226e-01f, 2.74219960e-01f,
  9.08170342e-02f, -2.63050109e-01f, -4.11228240e-02f, -1.03992343e-01f, -1.59675002e-01f, -1.79083809e-01f, -7.08734319e-02f, -6.27121776e-02f, -6.04908615e-02f, 6.57792315e-02f,
  -1.19540118e-01f, 2.05365568e-01f, -3.49361449e-01f, 2.96401411e-01f, 2.27067485e-01f, 6.76423311e-02f, 2.14155301e-01f, 9.97336209e-02f, 9.48511586e-02f, 2.98186820e-02f,
  -1.75107699e-02f, -2.35092957e-02f, -5.48882559e-02f, -1.56585783e-01f, 6.16222695e-02f, 1.59850255e-01f, 9.70798451e-03f, -9.94913206e-02f, -1.09708004e-01f, -1.06841847e-01f,
  -2.02020686e-02f, -3.88248675e-02f, -1.00691512e-01f, -2.62758546e-02f, 3.74355428e-02f, 4.02853228e-02f, -8.89485776e-02f, -6.49558455e-02f, -1.42214596e-01f, -3.05241141e-02f,
  -7.42644221e-02f, -1.02789812e-01f, 5.45204468e-02f, -1.42647445e-01f, -8.70337784e-02f, -3.75314034e-03f, 1.21537950e-02f, -7.41691366e-02f, 2.20116135e-02f, -1.48282768e-02f,
  1.38213918e-01f, 1.24323197e-01f, 1.65704116e-01f, -7.07099773e-03f, 3.62611264e-02f, 1.16649553e-01f, 7.41292313e-02f, -5.78717291e-02f, 3.67731303e-02f, 4.21710797e-02f,
  -5.19716628e-02f, -3.85978259e-02f, 1.14390388e-01f, 4.59950268e-02f, -1.50619447e-02f, -5.84705137e-02f, 2.69995164e-02f, 7.06998408e-02f, -1.15793921e-01f, -1.80828005e-01f,
  -2.53843237e-02f, 1.30303711e-01f, 5.41035719e-02f, -1.62273608e-02f, -4.25416753e-02f, 5.23105562e-02f, 1.45047624e-02f, -4.36094552e-02f, 4.88250777e-02f, 4.18174267e-02f,
  -3.99512239e-02f, 1.64119229e-01f, -1.29414976e-01f, -1.56740949e-01f, -5.53200878e-02f, 1.52055308e-01f, -5.59202097e-02f, -6.46082833e-02f, -3.96580547e-02f, -1.97505467e-02f,
  -3.26399505e-02f, 1.09676858e-02f, 2.24144742e-01f, 3.98348691e-03f, -6.30303025e-02f, -1.34568056e-03f, 1.19794585e-01f, 3.09646353e-02f, -3.70942838e-02f, -1.81690268e-02f,
  9.00053382e-02f, 1.20268241e-01f, -3.05981422e-03f, 2.73445044e-02f, -5.11833094e-02f, 4.85754535e-02f, 1.25763312e-01f, -7.21541494e-02f, 1.84769146e-02f, -1.91310182e-01f,
  1.95527017e-01f, -1.06946148e-01f, 1.14840910e-01f, 3.30490619e-01f, 3.08204651e-01f, 3.49219777e-02f, 2.09195286e-01f, 1.74914137e-01f, 5.51627874e-01f, -2.79634088e-01f,
  -5.80893904e-02f, -2.53583759e-01f, -2.05451205e-01f, -8.86100903e-02f, 9.86829549e-02f, 3.66123542e-02f, 1.40764341e-01f, -1.60781965e-01f, 1.61276072e-01f, -1.44936040e-01f,
  1.49538428e-01f, -3.10144544e-01f, -1.53760284e-01f, -2.59781450e-01f, -2.99369497e-03f, 1.55124767e-02f, -2.28815287e-01f, 1.39482925e-02f, -3.17927390e-01f, -7.69335255e-02f,
  1.61249846e-01f, 2.12825134e-01f, 4.45984378e-02f, -7.31487647e-02f, 1.70013905e-01f, -1.56758860e-01f, -1.92936689e-01f, -8.35576653e-02f, 1.89879924e-01f, 7.15993494e-02f,
  -1.48193076e-01f, -2.30167419e-01f, 1.13177627e-01f, 4.27359156e-02f, 2.53491610e-01f, -9.12132710e-02f, 1.19398057e-01f, 9.66135561e-02f, -4.32288907e-02f, -1.28755122e-01f,
  -3.21501903e-02f, 8.75442252e-02f, 1.44539282e-01f, -3.64550613e-02f, -8.38419702e-03f, 2.54544199e-01f, -2.67960466e-02f, -3.01790237e-02f, -4.07193229e-02f, 8.42281580e-02f,
  -5.24138920e-02f, 9.58622545e-02f, -1.74246654e-02f, -6.26879930e-02f, 8.42722040e-03f, 4.17815521e-02f, -4.45536710e-02f, -7.42448419e-02f, 4.18858752e-02f, 2.66276058e-02f,
  1.27488852e-03f, -5.01459949e-02f, -3.15286368e-02f, 2.45111678e-02f, 9.89086851e-02f, -2.26550456e-02f, -1.02262877e-01f, -9.85562652e-02f, 8.42538700e-02f, 9.09700617e-02f,
  -1.06282555e-01f, -6.22512363e-02f, 2.80194860e-02f, -1.02904744e-01f, 8.34335312e-02f, 9.35840309e-02f, -1.12500906e-01f, -2.01530084e-02f, 1.25197172e-01f, -5.09342067e-02f,
  1.30780742e-01f, -4.53239754e-02f, 1.31488755e-01f, -1.19422320e-02f, -1.40807005e-02f, -1.21870451e-01f, 8.97314772e-02f, -5.72572416e-03f, 8.34888592e-02f, -2.55312361e-02f,
  -1.14736073e-01f, -5.22336215e-02f, -3.71669978e-02f, -3.24541181e-02f, 2.12876853e-02f, 3.66569832e-02f, -6.83448464e-02f, 5.82621321e-02f, -9.83494520e-03f, -1.16675414e-01f,
  -1.64823726e-01f, 8.94763991e-02f, 5.62288091e-02f, 9.18584876e-03f, -4.46692258e-02f, 5.87996319e-02f, 2.40926538e-02f, 1.52699864e-02f, -4.66550775e-02f, 9.28456709e-02f,
  2.43162617e-01f, 5.56239821e-02f, -3.09374835e-02f, 1.86759055e-01f, -1.92597479e-01f, -1.76537216e-01f, -1.43589512e-01f, 1.10512972e-01f, -2.04212472e-01f, 1.25128180e-01f,
  2.18357846e-01f, -1.59959808e-01f, 1.56279266e-01f, 3.67172658e-01f, 2.19181910e-01f, 4.42392975e-02f, 2.09576562e-01f, -8.75525270e-03f, -1.42725214e-01f, 2.31073767e-01f,
  1.18064515e-01f, 2.56440222e-01f, 1.97307020e-01f, 1.73562050e-01f, 1.56486452e-01f, 9.11567062e-02f, 1.80311158e-01f, -6.25393614e-02f, 1.09856300e-01f, -2.25307909e-03f,
  -6.11973926e-02f, 1.30350947e-01f, 9.83842090e-03f, -1.44749910e-01f, 1.31066237e-02f, 9.35940519e-02f, -9.58276838e-02f, -4.79162857e-02f, -7.34484866e-02f, -7.41672888e-02f,
  -6.83726743e-02f, 2.53280457e-02f, 2.82904916e-02f, -1.14599140e-02f, -1.44905560e-02f, -2.41349060e-02f, -1.54600486e-01f, -1.49623394e-01f, -9.25285816e-02f, 8.30189511e-02f,
  -2.80859228e-02f, -4.73610424e-02f, 2.88599450e-02f, -1.13071941e-01f, 1.39521016e-02f, -7.04468740e-03f, -3.39229628e-02f, -5.09569794e-03f, -4.03427519e-02f, -6.50273040e-02f,
  1.89280853e-01f, -2.58795470e-02f, 1.46083578e-01f, -7.86429271e-02f, -2.78338920e-02f, 2.88078859e-02f, -4.32138890e-02f, -6.49184659e-02f, 5.83908297e-02f, 1.62503980e-02f,
  -3.26270312e-02f, 5.32557331e-02f, -2.53254566e-02f, 3.41991484e-02f, 9.47624594e-02f, -7.19688162e-02f, -7.74662420e-02f, 1.53055936e-02f, 2.64027305e-02f, -1.78624652e-02f,
  -1.31088886e-02f, 1.16434678e-01f, 1.05430260e-02f, -2.94313096e-02f, -3.98170166e-02f, 3.09521593e-02f, 1.09962616e-02f, -6.40959144e-02f, -1.51409656e-01f, -2.03633886e-02f,
  -4.93547097e-02f, 2.17404038e-01f, 1.21117122e-02f, -1.15536138e-01f, -1.00498609e-01f, 5.79396226e-02f, -5.57702631e-02f, -4.35655788e-02f, 6.31213114e-02f, 3.74455787e-02f,
  9.27647874e-02f, -9.22056064e-02f, -2.28276048e-02f, 7.29451422e-03f, -1.53588638e-01f, -9.98021197e-03f, 9.20169055e-02f, -1.68844193e-01f, 2.99237985e-02f, -7.75088221e-02f,
  4.16798033e-02f, -1.02754392e-01f, 1.96262132e-02f, -1.00022458e-01f, -7.36544803e-02f, -5.58936372e-02f, -7.06345811e-02f, -8.36479664e-02f, 1.29505873e-01f, -9.64973643e-02f,
  -1.47078514e-01f, -2.00541526e-01f, 1.74548417e-01f, -1.48330152e-01f, -6.01334237e-02f, 2.02386454e-01f, 3.17715317e-01f, -5.98479211e-02f, -2.28384688e-01f, -2.06371695e-01f,
  7.55416090e-03f, 1.93992287e-01f, 1.40712544e-01f, -6.39206469e-02f, 5.00031352e-01f, 1.31564021e-01f, -3.31091285e-02f, 6.01641275e-02f, -1.78007543e-01f, -1.29290223e-01f,
  -4.02404368e-02f, -3.63238081e-02f, 1.67213112e-01f, -2.50147998e-01f, -1.26041114e-01f, -1.32744431e-01f, 7.37028546e-04f, 1.46945372e-01f, -6.26283064e-02f, 1.27735510e-01f,
  -1.72670826e-01f, -2.23897591e-01f, -4.31618281e-03f, -4.36416641e-02f, -1.04963481e-01f, 6.92349393e-03f, 8.83127451e-02f, 2.51791298e-01f, 1.32260710e-01f, -5.65467924e-02f,
  -7.88425002e-03f, -3.96717750e-02f, -2.00135410e-02f, 2.73454599e-02f, -1.79135904e-01f, -2.52250172e-02f, -1.02294385e-01f, -2.06816364e-02f, 6.59003928e-02f, -1.63377803e-02f,
  2.01039277e-02f, 2.77445130e-02f, -1.91026945e-02f, 2.70686001e-02f, 1.01140223e-01f, 2.27409936e-02f, -9.45393592e-02f, -4.25411351e-02f, 8.68047327e-02f, 7.84553811e-02f,
  9.49571803e-02f, -4.69780825e-02f, -3.16804312e-02f, -1.54591992e-01f, 1.68836385e-01f, 4.82876226e-03f, 4.71345931e-02f, 1.32611811e-01f, 1.52705103e-01f, 3.68815549e-02f,
  -1.04370572e-01f, -8.61212015e-02f, -6.71749339e-02f, -6.58954829e-02f, -1.17725562e-02f, -3.36563513e-02f, 9.79087874e-02f, 4.83410321e-02f, -1.21541843e-01f, 6.93880301e-03f,
  4.97171618e-02f, 1.13571785e-01f, 4.47213277e-02f, -4.69769863e-03f, 7.97205977e-03f, 8.37755874e-02f, 7.28548020e-02f, -1.18360557e-01f, -5.29562458e-02f, 2.05251873e-01f,
  -2.67051786e-01f, -2.18123943e-01f, 1.27297230e-02f, 1.02888066e-02f, -4.04903367e-02f, -3.97306122e-02f, -4.39671613e-02f, 7.28798378e-03f, 6.49626274e-03f, -6.48864284e-02f,
  -8.28663483e-02f, -3.15893218e-02f, -6.60749152e-04f, 2.16558557e-02f, 1.22024687e-02f, -3.12101245e-02f, -3.33502665e-02f, -2.17936188e-02f, 1.10049248e-01f, 7.61491028e-05f,
  -6.73477873e-02f, -5.95656224e-02f, 9.60799977e-02f, -4.53428440e-02f, -1.11184001e-01f, 1.35198295e-01f, -1.25312150e-01f, -5.74102215e-02f, -6.65657967e-02f, 1.26596093e-01f,
  -7.12378681e-01f, -2.63861746e-01f, 1.25912458e-01f, -2.94745803e-01f, 6.03552312e-02f, 2.42254794e-01f, 2.52580941e-01f, -1.41035438e-01f, -2.25351200e-01f, 1.29017711e-01f,
  1.91018909e-01f, -2.37130225e-01f, 2.01502249e-01f, 3.44681293e-02f, 1.02500185e-01f, 2.18674570e-01f, 9.01851580e-02f, 1.37501284e-01f, -6.96802512e-02f, -2.67061889e-01f,
  -5.19758537e-02f, 2.92645507e-02f, 2.30952799e-01f, -9.83733907e-02f, -4.57321554e-02f, -1.33932203e-01f, 1.97909832e-01f, 1.28432666e-03f, 1.19217381e-01f, 6.15558326e-02f,
  1.07327230e-01f, -2.04136521e-01f, 3.26440297e-02f, -1.18120909e-02f, 1.50878549e-01f, 7.82456025e-02f, 5.90661205e-02f, 3.62483114e-02f, -6.90714968e-03f, 4.44157012e-02f,
  3.10305785e-02f, -5.97447641e-02f, -1.14646673e-01f, 2.89314445e-02f, -5.32517061e-02f, -4.22329307e-02f, 2.01464631e-03f, 5.81541397e-02f, -3.07640359e-02f, 4.46630605e-02f,
  -2.42945962e-02f, 5.96938170e-02f, -7.03331083e-02f, 1.25661075e-01f, -1.86224598e-02f, -1.00630850e-01f, 1.45418823e-01f, 5.09974062e-02f, 1.27328411e-01f, -4.18358557e-02f,
  -9.21155587e-02f, 2.42409334e-02f, 1.47223577e-01f, 6.45296574e-02f, -4.22609635e-02f, 1.26620173e-01f, 1.18040748e-01f, 6.27145246e-02f, -2.97788233e-01f, -8.90950486e-02f,
  -6.64000511e-02f, 7.15977326e-02f, -5.84976785e-02f, -8.48135278e-02f, 5.26889861e-02f, 1.75503027e-02f, 1.27158925e-01f, -7.11259991e-02f, -7.67392144e-02f, 6.84757531e-02f,
  -2.82649547e-02f, -3.98510247e-02f, 9.97499451e-02f, 7.33304918e-02f, -1.12198535e-02f, -1.03475802e-01f, 7.35533750e-03f, 8.39903802e-02f, 4.55795415e-02f, 4.47065607e-02f,
  -3.54197063e-02f, -1.69217303e-01f, 1.69798490e-02f, 1.59586743e-02f, 1.39483795e-01f, -1.10000193e-01f, -1.01049714e-01f, -9.56360474e-02f, -3.14281369e-03f, -1.63004939e-02f,
  8.46114233e-02f, 6.36988580e-02f, -1.02622971e-01f, -3.06844208e-02f, -2.31206464e-03f, 6.57755136e-02f, -4.58693765e-02f, 1.66737847e-02f, -4.51271720e-02f, 5.29927909e-02f,
  1.87970605e-02f, 1.25371544e-02f, -1.32254645e-01f, 1.87210999e-02f, 6.08082563e-02f, 8.43486562e-03f, -4.08097496e-03f, -1.10756658e-01f, 8.04459155e-02f, -7.79459700e-02f,
  3.30387563e-01f, -4.21254069e-01f, 6.30737841e-02f, 1.55996233e-01f, 2.20948175e-01f, -2.71715820e-01f, -7.46979192e-02f, -3.19563970e-02f, 3.42579991e-01f, -2.91229486e-01f,
  -2.03240886e-02f, -1.26942221e-04f, -1.23444743e-01f, -1.72475129e-01f, 3.07254523e-01f, 1.17154367e-01f, -5.36859781e-02f, -1.65072128e-01f, 1.23096667e-01f, -8.77117738e-02f,
  6.88586459e-02f, -1.43302917e-01f, -6.65102974e-02f, -2.59869725e-01f, -1.61057740e-01f, 2.26933509e-02f, 9.49831232e-02f, -1.01776183e-01f, -2.36387491e-01f, 5.59697449e-02f,
  -1.79219976e-01f, -2.92622857e-02f, -1.41739920e-01f, -1.84031278e-01f, -1.17180087e-01f, -1.07982494e-02f, 5.54167181e-02f, -4.64408249e-02f, -7.58188888e-02f, 9.42845792e-02f,
  2.24804468e-02f, -6.72971904e-02f, -1.11065293e-02f, 5.41918278e-02f, -2.37699673e-02f, 7.08845034e-02f, 9.65252221e-02f, -2.34587174e-02f, 1.09495847e-02f, 1.02949977e-01f,
  7.14131966e-02f, -2.08239667e-02f, -6.32182583e-02f, -1.86083280e-02f, 7.21701011e-02f, -9.25138220e-03f, 1.10369679e-02f, 3.76834944e-02f, -1.04462214e-01f, 1.66442677e-01f,
  -3.64986658e-02f, 7.42324293e-02f, 3.83425620e-03f, -1.81380641e-02f, -7.22211078e-02f, 1.05864227e-01f, 1.45935014e-01f, 4.71599353e-03f, -1.61918312e-01f, -3.18495296e-02f,
  -1.66600812e-02f, -1.31315112e-01f, 1.29741341e-01f, 4.37907912e-02f, -3.55744995e-02f, 9.95672718e-02f, -6.76690564e-02f, 8.82720128e-02f, 2.73260544e-03f, 3.12644690e-02f,
  8.00339058e-02f, 3.38646285e-02f, -6.23087920e-02f, 2.36647688e-02f, 1.06303580e-01f, 5.92343397e-02f, -3.45269442e-02f, 4.20134291e-02f, 7.22773075e-02f, -5.83287962e-02f,
  -3.98773253e-01f, -4.46132004e-01f, -1.15580857e-01f, -8.83907229e-02f, -1.27931505e-01f, -5.54330163e-02f, 1.30157366e-01f, 1.61776766e-01f, -2.95477569e-01f, 4.34004478e-02f,
  2.79391408e-02f, -6.41519800e-02f, -6.93958327e-02f, 8.91072378e-02f, -1.98615059e-01f, 6.49309307e-02f, -8.85125697e-02f, -1.24522187e-01f, 5.54441959e-02f, 2.06728298e-02f,
  -1.30765796e-01f, -3.08495760e-02f, -7.02876598e-02f, -2.48591844e-02f, -6.16383972e-03f, 7.96998590e-02f, 5.48703298e-02f, 1.47734374e-01f, -2.14910670e-03f, -5.79350255e-02f,
  1.78535953e-01f, 1.18898958e-01f, 7.00696260e-02f, 8.48011672e-02f, -2.06842259e-01f, -1.76579639e-01f, -3.01874518e-01f, 7.28410780e-02f, -4.22848433e-01f, -1.75758481e-01f,
  2.37835813e-02f, -2.60215759e-01f, 9.08412635e-02f, 9.89948437e-02f, 1.47539675e-01f, 7.20428452e-02f, 1.25381693e-01f, -6.64986745e-02f, 2.00432912e-01f, 2.55928367e-01f,
  2.56282300e-01f, 2.26403862e-01f, 3.30102533e-01f, 4.22620952e-01f, 3.17459494e-01f, 1.62977785e-01f, 1.56882703e-01f, 1.29952952e-01f, 7.28153735e-02f, -7.89731219e-02f,
  -2.18976643e-02f, 1.08579263e-01f, 6.78111538e-02f, -6.12947494e-02f, 1.87323868e-01f, 2.07871012e-02f, 4.90171313e-02f, -5.49115129e-02f, -1.27091482e-01f, -1.04663685e-01f,
  -4.66114134e-02f, 2.68252939e-02f, -6.39752224e-02f, -9.90294814e-02f, -1.22444384e-01f, -1.02661371e-01f, -1.03412218e-01f, -1.56845421e-01f, -1.22087240e-01f, 1.62207738e-01f,
  5.16832247e-02f, 2.26664171e-03f, -1.34376213e-01f, -4.70399782e-02f, -9.01863724e-02f, -7.94385225e-02f, -1.40186355e-01f, 1.30790295e-02f, -7.63694942e-03f, -7.57040232e-02f,
  1.87890679e-01f, -1.43218674e-02f, 4.03257385e-02f, -8.71735364e-02f, -5.03323041e-02f, -3.15475054e-02f, -1.61524951e-01f, -5.95045164e-02f, -3.53401713e-02f, 3.29450564e-03f,
  -9.93778259e-02f, -2.49976926e-02f, -5.50045595e-02f, 1.41551709e-02f, 2.80822068e-02f, -2.68855821e-02f, -6.02860376e-02f, 1.89062357e-02f, -7.22880512e-02f, 9.29123163e-02f,
  -2.18592752e-02f, -1.34535935e-02f, -1.88271448e-01f, 2.71083433e-02f, -8.73021036e-02f, -1.00023128e-01f, -3.82091030e-02f, -5.77356853e-02f, 7.51462802e-02f, 2.40702946e-02f,
  3.30278985e-02f, 2.74158746e-01f, 4.40095691e-03f, -4.64237444e-02f, 1.35455513e-02f, 1.09770462e-01f, 1.06701054e-01f, 2.58554262e-03f, 4.52267714e-02f, 1.15203522e-01f,
  1.26547575e-01f, -6.24988563e-02f, -1.39571741e-01f, -1.55376926e-01f, -9.81806740e-02f, 4.06535016e-03f, 6.56657517e-02f, -1.79768637e-01f, -9.54887643e-02f, 1.23813182e-01f,
  -3.74984443e-02f, -6.80408478e-02f, -1.76276073e-01f, -2.97529958e-02f, -1.13488913e-01f, -5.40206730e-02f, -3.29478644e-02f, 1.80055741e-02f, 2.54297890e-02f, 1.98043212e-02f,
  1.57187302e-02f, 4.02932912e-01f, 3.27783883e-01f, 3.91265482e-01f, -3.06981593e-01f, 3.49907428e-02f, 7.80345052e-02f, 8.75861272e-02f, 4.17901605e-01f, 9.03137475e-02f,
  -4.25859272e-01f, 4.96105760e-01f, -1.28366187e-01f, 3.88436988e-02f, -3.70075321e-03f, 3.33613269e-02f, 6.47500390e-04f, 1.09603070e-01f, 2.00711116e-01f, 2.69920498e-01f,
  -3.68059091e-02f, -3.16108912e-01f, -5.54814339e-02f, 3.83197851e-02f, -1.42014295e-01f, 2.09946632e-01f, -2.75219589e-01f, 8.49947035e-02f, -9.44524780e-02f, -4.29663993e-02f,
  -2.18958467e-01f, 2.34044269e-01f, -8.16924497e-02f, 1.74497709e-01f, -3.64751630e-02f, -6.66077062e-03f, 8.11753348e-02f, -4.26741689e-02f, -7.73512423e-02f, 2.10035294e-02f,
  -3.20048747e-03f, -2.67028771e-02f, -5.64870164e-02f, 4.24082158e-03f, 1.10490888e-01f, -4.08364600e-03f, 5.78685850e-02f, -9.07217488e-02f, 8.81260484e-02f, -1.58975959e-01f,
  9.41621780e-04f, -1.90010667e-01f, -1.55334771e-01f, 7.25799473e-03f, -4.46835272e-02f, 7.22167268e-02f, 9.89845619e-02f, 9.58338287e-03f, -2.18747370e-02f, 1.35382056e-01f,
  1.26025802e-03f, -3.70852812e-03f, 3.24219912e-02f, -6.80506453e-02f, 1.00092858e-01f, -5.10875210e-02f, 1.55399486e-01f, -2.00890169e-01f, 2.83998437e-02f, -7.45268911e-02f,
  -7.35115483e-02f, -3.31982933e-02f, -8.00789371e-02f, 1.99187058e-03f, 1.71685591e-02f, 1.33093432e-01f, 5.53931668e-03f, -1.26560703e-01f, 9.34370887e-03f, -2.83069015e-02f,
  1.60737276e-01f, 4.06025350e-02f, -3.04227117e-02f, -1.72631368e-01f, 7.86361024e-02f, 8.11209250e-03f, -6.70171529e-02f, 8.35647732e-02f, 6.11236645e-03f, -6.11414649e-02f,
  1.26585469e-01f, 4.96804446e-01f, -5.22625744e-02f, 4.28116275e-03f, 1.43920124e-01f, -3.22064348e-02f, 7.90719613e-02f, -6.34793714e-02f, 1.31880999e-01f, 8.30936953e-02f,
  -4.06083018e-02f, -1.54980272e-01f, -8.19684416e-02f, -4.89393361e-02f, 1.41799852e-01f, 4.22889134e-03f, 9.57417265e-02f, 1.49316028e-01f, 4.45331559e-02f, 1.43211996e-02f,
  1.28810080e-02f, 2.01105922e-02f, 4.59420420e-02f, -9.59511399e-02f, -1.65811852e-01f, -9.32077467e-02f, 1.96652743e-03f, 1.58934265e-01f, -5.37983887e-02f, 8.61337036e-02f,
  2.02048331e-01f, 3.02910596e-01f, 2.52784282e-01f, 3.79053056e-01f, -3.75944562e-02f, -1.29685134e-01f, -1.11966789e-01f, 1.31888345e-01f, -1.56679794e-01f, 8.56175795e-02f,
  -1.30913705e-01f, 3.28125358e-01f, -3.94542217e-01f, 2.58001804e-01f, -1.42333388e-01f, -3.48040849e-01f, 8.48895088e-02f, 4.26705442e-02f, -1.40508682e-01f, 2.14241683e-01f,
  7.91978091e-02f, 1.47766173e-02f, 8.18564668e-02f, -2.75362115e-02f, 1.34642750e-01f, 2.83987492e-01f, 1.25310972e-01f, -7.74810165e-02f, 3.74094337e-01f, -1.18331753e-01f,
  -9.71628651e-02f, -9.61315166e-03f, 1.37925714e-01f, -3.78077142e-02f, 4.80604097e-02f, -1.46120824e-02f, 1.73818432e-02f, -1.09615400e-01f, -9.85649675e-02f, 1.83842145e-02f,
  1.29992574e-01f, 8.03680718e-02f, 1.17589563e-01f, -5.41282967e-02f, 7.24246949e-02f, 4.32977937e-02f, 2.87756864e-02f, 8.22753534e-02f, 5.08491807e-02f, 1.64041296e-01f,
  1.42412275e-01f, 3.49772424e-02f, 3.46789435e-02f, 6.28158152e-02f, 3.82509716e-02f, 6.12314343e-02f, 1.14669176e-02f, 1.33133411e-01f, 8.67266357e-02f, 2.08990678e-01f,
  1.05018227e-03f, -2.91606188e-02f, 1.42370639e-02f, 5.35120890e-02f, 1.10574298e-01f, -2.21092235e-02f, -1.30330905e-01f, -6.21470138e-02f, 9.47243869e-02f, -2.81547233e-02f,
  -6.84524700e-02f, 1.59709435e-02f, -7.33003989e-02f, 3.43833715e-02f, 3.35649848e-02f, 5.72293140e-02f, -9.54496637e-02f, -2.33283397e-02f, 7.86225647e-02f, 4.58777137e-02f,
  -2.03590035e-01f, -7.24484324e-02f, 7.43572935e-02f, -6.80309534e-02f, -6.11924082e-02f, 9.69923437e-02f, -1.67295247e-01f, 4.37503122e-02f, -2.49677338e-03f, -6.06979989e-02f,
  -6.54446036e-02f, 8.67125839e-02f, 3.32579315e-02f, -1.52990237e-01f, -4.16458845e-02f, 6.25814572e-02f, -1.29176795e-01f, 5.29260710e-02f, -1.17399674e-02f, -9.91029292e-03f,
  9.55428630e-02f, -1.45576866e-02f, -6.19170675e-03f, 3.60777974e-02f, -5.26059978e-02f, -2.30662972e-02f, 4.34676297e-02f, -4.98930104e-02f, 8.91063362e-02f, 3.14584486e-02f,
  3.17317210e-02f, -5.75497076e-02f, 8.34774226e-02f, 1.45655749e-02f, -4.51822989e-02f, -1.04861986e-02f, 1.78547427e-02f, 3.48941796e-02f, 7.19570369e-02f, -2.43846932e-03f,
  -9.68046021e-03f, -9.92689133e-02f, -3.62090379e-01f, -1.16547264e-01f, 1.33654609e-01f, -4.50522244e-01f, -1.18624456e-01f, 3.08582615e-02f, 1.44039571e-01f, 1.50459290e-01f,
  1.39892220e-01f, -1.37740046e-01f, 2.69791216e-01f, -4.46394712e-01f, -3.54419380e-01f, 6.08492782e-03f, -5.66019356e-01f, -2.62340605e-01f, 1.28219709e-01f, -3.04133922e-01f,
  6.63086474e-02f, 1.05855063e-01f, -1.75092205e-01f, 3.40244055e-01f, -4.71239164e-02f, 1.35498747e-01f, 1.22007668e-01f, 2.21874639e-01f, -2.62879431e-01f, 1.80488899e-02f,
  -2.00724155e-01f, 9.16577503e-02f, -7.21600726e-02f, -2.77962498e-02f, -2.02221125e-01f, 7.46639371e-02f, -1.16387382e-01f, 7.17914030e-02f, -7.43268877e-02f, 4.18220162e-02f,
  1.62944850e-02f, 5.76815307e-02f, 1.07244374e-02f, 2.03959063e-01f, 1.62797004e-01f, 7.10376725e-02f, -4.23282161e-02f, -1.40250981e-01f, 3.39644738e-02f, -8.25125948e-02f,
  -1.58358887e-01f, -4.49943654e-02f, -1.08855106e-01f, 5.75553477e-02f, -1.31628469e-01f, -3.52658890e-02f, -1.31159231e-01f, -3.58439647e-02f, -6.25275448e-02f, -1.19938709e-01f,
  1.46070737e-02f, -1.81426611e-02f, -6.16844893e-02f, 6.23997822e-02f, 2.95840334e-02f, -8.92923772e-03f, 8.35658684e-02f, 3.69386300e-02f, 2.60316003e-02f, -4.88786623e-02f,
  1.95625089e-02f, -7.78313819e-03f, 1.54492371e-02f, -3.38494852e-02f, -4.20379313e-03f, 2.35060789e-02f, -5.18088043e-02f, 5.66144139e-02f, 4.22603302e-02f, -4.48703393e-02f,
  1.37152687e-01f, -2.31624007e-01f, 1.23087421e-01f, 1.29316941e-01f, -5.87429032e-02f, 7.51661062e-02f, -2.99510583e-02f, 1.01966336e-02f, 5.76820672e-02f, 2.77903341e-02f,
  -2.99358517e-01f, -1.93358675e-01f, -2.92210449e-02f, 5.54326773e-02f, -1.44107386e-01f, 1.02139197e-01f, -1.73985645e-01f, 4.14023735e-02f, -2.89630331e-02f, 1.79549694e-01f,
  -4.34854031e-02f, 5.64174429e-02f, -1.26701072e-01f, 8.99207070e-02f, -4.36940007e-02f, 5.08167669e-02f, -1.39782757e-01f, 1.21079825e-01f, -9.22520459e-02f, -5.53098358e-02f,
  3.35465334e-02f, 7.20845237e-02f, -2.88497470e-02f, 7.62107223e-02f, 1.11956432e-01f, -5.88087179e-02f, 1.35875503e-02f, 8.79085958e-02f, 6.93416521e-02f, -6.94341660e-02f,
  4.93613863e-03f, 4.34256256e-01f, 3.12643647e-02f, -4.91276458e-02f, 4.67237197e-02f, -1.86892033e-01f, -1.02957971e-01f, -5.58207445e-02f, -5.15615903e-02f, 3.50835055e-01f,
  -9.34360027e-02f, 2.42288888e-01f, -8.49943683e-02f, -2.24421218e-01f, -5.27817309e-01f, -3.77058238e-01f, -1.89116880e-01f, 3.23872976e-02f, -8.86689723e-02f, 1.22459717e-01f,
  -6.33574277e-02f, -2.41731450e-01f, -1.48095340e-01f, 2.69219596e-02f, 2.25701287e-01f, 1.64376706e-01f, 3.33544351e-02f, 1.63071722e-01f, 2.51264334e-01f, -6.15283884e-02f,
  -8.84839892e-02f, -1.14155039e-01f, 1.32796869e-01f, -5.46448641e-02f, -2.70545762e-02f, 6.45447001e-02f, 6.06857538e-02f, -1.27269045e-01f, -1.03837512e-01f, 4.97336537e-02f,
  1.67167857e-01f, -6.76953793e-02f, -5.34601025e-02f, -1.22114560e-02f, 1.11038312e-01f, 1.07534446e-01f, 7.36179948e-02f, 5.78549132e-02f, 5.32740075e-03f, -4.35601175e-02f,
  -2.71191746e-02f, 2.89394222e-02f, 1.09070003e-01f, -5.46313636e-02f, -9.76539403e-02f, 6.86518997e-02f, 8.20688680e-02f, 1.20750897e-01f, 8.08085725e-02f, 1.15747713e-01f,
  -3.74113508e-02f, 1.04714975e-01f, -1.76159833e-02f, 9.65555012e-02f, -4.68950123e-02f, 3.19123524e-03f, 9.14091766e-02f, 3.46120112e-02f, 6.10399842e-02f, 1.15587927e-01f,
  1.21840827e-01f, 1.25597388e-01f, 1.55542940e-02f, 2.34372821e-02f, 1.49531901e-01f, 1.51588852e-02f, 1.33194461e-01f, -2.30761270e-05f, 1.98486075e-02f, 5.11738770e-02f,
  -4.10610288e-02f, -1.20007638e-02f, 9.36857387e-02f, 1.18534170e-01f, -6.59234375e-02f, 4.90810536e-03f, 4.79337014e-02f, 7.78460801e-02f, 1.36771398e-02f, -2.22789496e-02f,
  -2.10138387e-03f, -2.16162428e-02f, 1.58144534e-02f, 4.83087227e-02f, 2.29535159e-02f, 1.57748666e-02f, -2.02016890e-01f, -3.06184981e-02f, -1.02247745e-01f, -2.01949552e-02f,
  5.20838536e-02f, 1.90705806e-01f, 1.03815541e-01f, -1.71689853e-01f, 1.35149667e-02f, -4.83534224e-02f, 1.02896299e-02f, 4.14451286e-02f, -3.44003513e-02f, -1.36725614e-02f,
  5.65967485e-02f, 1.00012057e-01f, 5.66695221e-02f, -1.07046001e-01f, 4.32075225e-02f, 6.02912679e-02f, 1.43020423e-02f, -4.45680171e-02f, 7.79179782e-02f, -4.10296842e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  2.46045947e-01f, 1.81447774e-01f, 1.84367746e-01f, 2.81207621e-01f, 2.87643492e-01f, 2.51278937e-01f, 2.34793708e-01f, 3.82830054e-01f, 2.39234537e-01f, 3.19847584e-01f,
  1.60735622e-01f, 3.25685948e-01f, 3.54255289e-01f, 3.67336720e-01f, 5.10220766e-01f, 2.96103418e-01f, 1.74787790e-01f, 8.00059438e-02f, 2.57596016e-01f, 3.50380749e-01f,
  2.35711813e-01f, 1.51555374e-01f, 5.91173232e-01f, 3.84366333e-01f, 3.29174191e-01f, 2.61651725e-01f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  1.03111058e-01f, 7.74401948e-02f, -1.39951810e-01f, 9.93519500e-02f, -2.52774984e-01f, -3.61772329e-01f, -1.71759516e-01f, -2.51426905e-01f, -2.34882087e-01f, -2.10494474e-01f,
  -7.47185946e-02f, 1.41736060e-01f, -1.93823650e-01f, 3.03093582e-01f, 3.73601518e-03f, 1.54313603e-02f, 2.76774704e-01f, -3.03403229e-01f, -1.18549205e-01f, 1.85239479e-01f,
  -1.19928308e-01f, -2.13742465e-01f, 1.37499481e-01f, -5.12343124e-02f, -1.17423296e-01f, -1.70152970e-02f, 2.17215970e-01f, 4.78093280e-03f, 1.15750425e-01f, 3.64350267e-02f,
  3.11067402e-01f, -1.10844746e-02f, 1.57337263e-01f, 3.21492329e-02f, -1.93873253e-02f, -1.24116033e-01f, -2.39249229e-01f, -1.51405111e-01f, 2.96710730e-02f, -1.24329381e-01f,
  -2.28549108e-01f, -2.71389693e-01f, -6.96211529e-04f, 2.29770109e-01f, -7.63764828e-02f, -3.03337686e-02f, -7.54805580e-02f, -1.96335733e-01f, 2.33089313e-01f, -1.77507833e-01f,
  1.06869198e-01f, 2.66337395e-01f, 1.43290713e-01f, -2.87257403e-01f, -4.64717932e-02f, -1.97491542e-01f, 6.41966164e-02f, 8.43838751e-02f, 2.14602083e-01f, -7.09526613e-02f,
  1.12708673e-01f, 3.30700539e-02f, -7.65846670e-02f, 5.77100478e-02f, -1.08379446e-01f, -1.86171472e-01f, 5.45063280e-02f, -2.40081474e-02f, 5.52140065e-02f, 2.92821616e-01f,
  3.03611338e-01f, 2.95863271e-01f, -7.53619522e-02f, 1.23850912e-01f, -2.15293616e-01f, -2.40975502e-03f, 4.39795703e-02f, -2.49351636e-01f, -2.01035142e-01f, 5.57468086e-02f,
  -4.11533087e-01f, 1.45384014e-01f, 2.35234424e-02f, 3.01108509e-01f, 1.60011306e-01f, -3.47577296e-02f, -2.40528211e-01f, 1.77548900e-01f, 1.83470100e-01f, 2.12291211e-01f,
  -1.40099049e-01f, -1.10674882e-02f, -8.61155763e-02f, 2.49019369e-01f, -2.88385659e-01f, 2.17537120e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.25141978e-01f, 3.05281617e-02f, 3.26488227e-01f, 2.27420494e-01f, -1.37640044e-01f, 6.09636493e-02f, -1.61792874e-01f, 6.05630398e-01f, 1.30802453e-01f, 1.13607228e-01f,
  -3.33036296e-02f, 3.70488316e-01f, -6.86854497e-02f, 5.52582383e-01f, -2.30138421e-01f, 1.08762756e-01f, 2.64549792e-01f, 6.49900585e-02f, -2.92100579e-01f, 2.38887489e-01f,
  -1.80216134e-01f, 4.66872603e-01f, -1.94216549e-01f, 1.46004811e-01f, -1.03990890e-01f, 4.87517804e-01f, -3.21930498e-01f, 3.36439759e-01f, -4.12749469e-01f, -1.08962618e-01f,
  3.02238077e-01f, 7.15112761e-02f, 1.23567050e-02f, 1.90792263e-01f, 1.51446089e-01f, 1.67536333e-01f, 8.19297433e-02f, 1.24328166e-01f, -1.67754248e-01f, -1.86151490e-02f,
  -4.15535681e-02f, 4.15930152e-01f, -1.36944398e-01f, -2.37624854e-01f, -2.25729421e-01f, 2.74031401e-01f, 8.23511183e-02f, 3.10175300e-01f, -4.18754309e-01f, -1.05758749e-01f,
  3.28818619e-01f, 6.18432090e-02f, 1.50057584e-01f, 1.63721144e-01f, -2.07557708e-01f, 2.13488676e-02f, -9.70049277e-02f, -4.52107824e-02f, -1.37510151e-01f, -2.12697666e-02f,
  1.82044581e-01f, 4.42113996e-01f, -1.66071817e-01f, 4.69076097e-01f, -1.27609283e-01f, 2.43602157e-01f, 3.57333608e-02f, -2.12072015e-01f, -3.83272022e-01f, -1.33344278e-01f,
  4.62116271e-01f, 2.61653662e-01f, -3.59253079e-01f, 1.35188758e-01f, -1.20641299e-01f, 5.20917416e-01f, 4.01594311e-01f, 4.27123643e-02f, 1.94259241e-01f, -9.53326933e-03f,
  1.17999189e-01f, 6.77685291e-02f, 1.62759602e-01f, 1.07548796e-01f, -8.94571394e-02f, -1.22309916e-01f, -1.12401411e-01f, -3.36428136e-02f, 3.41293007e-01f, 3.69771302e-01f,
  2.21532106e-01f, 1.04113733e-02f, -9.56829935e-02f, -1.79492339e-01f, 2.40852367e-02f, -2.53603548e-01f, -6.79866076e-02f, -2.52858885e-02f, 2.20881984e-01f, -1.58424661e-01f,
  5.70372008e-02f, 2.37316251e-01f, 4.47606623e-01f, 4.73154843e-01f, 4.87450045e-03f, 3.83015156e-01f, -1.38317496e-01f, 2.46601343e-01f, 1.80239782e-01f, -3.42677772e-01f,
  3.53161514e-01f, 5.28167546e-01f, -2.61486232e-01f, 3.49856168e-01f, -1.82282239e-01f, 2.76371032e-01f, 1.30214483e-01f, -7.79964104e-02f, -3.55391502e-01f, 2.23012269e-01f,
  3.99861157e-01f, 3.74707997e-01f, -2.11121559e-01f, 1.90512612e-01f, 3.00017819e-02f, 1.37035817e-01f, -2.59471565e-01f, -1.03086546e-01f, 2.21275046e-01f, 2.82215744e-01f,
  3.91967416e-01f, -4.47008491e-01f, -4.05793875e-01f, -3.42133045e-01f, -2.32809052e-01f, -7.88033456e-02f, -6.30032504e-03f, -2.01865405e-01f, -1.03201024e-01f, 5.94568014e-01f,
  3.96097004e-02f, -1.46056384e-01f, -2.29528233e-01f, 5.74553385e-02f, 2.38486618e-01f, -2.58897641e-03f, 5.16473770e-01f, 2.98127770e-01f, 3.63812894e-01f, -3.80226731e-01f,
  9.30948555e-02f, -7.30840489e-03f, 1.20960146e-01f, 2.20057279e-01f, -1.76615611e-01f, 1.56191841e-01f, 7.00537324e-01f, 3.76936227e-01f, -5.61795712e-01f, 9.45870206e-02f,
  2.41335005e-01f, 3.87620240e-01f, 4.78332564e-02f, 2.89324313e-01f, 4.55960445e-02f, -1.14756055e-01f, 2.37904504e-01f, -2.75782675e-01f, -2.48082682e-01f, 3.86365563e-01f,
  2.24251360e-01f, 3.30340862e-01f, -5.29641621e-02f, 2.16214687e-01f, 5.73926926e-01f, 4.36118722e-01f, -1.47111356e-01f, -3.62516254e-01f, 2.91288793e-01f, -3.01536709e-01f,
  5.41474044e-01f, -3.59555036e-02f, 4.35858428e-01f, 6.37606718e-04f, 3.87469560e-01f, 6.30607605e-02f, 5.42470276e-01f, 2.89548308e-01f, -9.63326171e-02f, 2.45375291e-01f,
  -1.97854951e-01f, 3.53486314e-02f, -9.71614476e-03f, 1.81608871e-02f, -6.58280477e-02f, -1.30331486e-01f, 2.20903099e-01f, 1.34800375e-01f, -4.68071140e-02f, 4.47680920e-01f,
  4.44037020e-01f, -1.84587628e-01f, 1.49326921e-01f, -5.30440733e-02f, 4.77381349e-01f, -2.98357606e-01f, -2.01908171e-01f, 7.58624747e-02f, -2.14591861e-01f, 3.86672884e-01f,
  4.30863708e-01f, 2.14949980e-01f, -8.40650797e-02f, -1.53521925e-01f, 8.03298056e-02f, 1.44059375e-01f, -2.45055482e-01f, -3.04818768e-02f, 2.57121205e-01f, 2.44971618e-01f,
  2.23636732e-01f, 3.39324832e-01f, 1.34632379e-01f, 3.12245358e-02f, 2.19069198e-01f, 2.94515621e-02f, -2.48151138e-01f, 2.50929952e-01f, -1.24797225e-01f, 4.35859673e-02f,
  -2.53182143e-01f, -4.52488095e-01f, -1.42886117e-01f, -3.18151444e-01f, 1.52448326e-01f, -5.40878832e-01f, -3.18831712e-01f, 5.00042699e-02f, 6.29943728e-01f, 2.55926192e-01f,
  1.99446172e-01f, -2.29705736e-01f, -3.67106907e-02f, 3.54436994e-01f, 2.89024174e-01f, -2.99921364e-01f, 4.24243391e-01f, 1.07967861e-01f, -2.44247049e-01f, -3.54526490e-01f,
  2.42889240e-01f, -1.32376641e-01f, 4.08651769e-01f, 4.22958404e-01f, 4.68056113e-01f, 3.75668496e-01f, -1.36528969e-01f, 4.06127870e-01f, 2.12429717e-01f, -4.63040993e-02f,
  -3.56424242e-01f, 2.40308680e-02f, 2.13124618e-01f, 3.36985707e-01f, -3.00300717e-01f, 5.78344584e-01f, -1.43147826e-01f, 3.35557491e-01f, 7.44376853e-02f, 2.82852471e-01f,
  3.45828146e-01f, 1.44763306e-01f, -3.93787324e-01f, -1.06187738e-01f, 1.94959536e-01f, 1.04078673e-01f, 9.53368396e-02f, 2.41960526e-01f, -2.06901744e-01f, -2.17677608e-01f,
  4.23858017e-01f, 5.35454929e-01f, 4.37335111e-02f, -2.18979850e-01f, -2.58922637e-01f, 2.89082766e-01f, -4.80679780e-01f, 2.51490146e-01f, 1.79654315e-01f, -1.74710844e-02f,
  3.22387755e-01f, 3.46620120e-02f, 7.07775533e-01f, 4.82771665e-01f, 4.98134792e-01f, 5.03138565e-02f, 3.10278684e-01f, 1.06755227e-01f, 3.29251528e-01f, -2.06418425e-01f,
  -4.99383472e-02f, -4.76062030e-01f, -2.11820036e-01f, -1.64877735e-02f, -3.48562419e-01f, 2.65486389e-01f, -3.48465443e-01f, -2.88625777e-01f, 6.83701515e-01f, 4.26948369e-02f,
  3.77546996e-01f, 2.54357189e-01f, 3.48467112e-01f, -1.26497403e-01f, 1.64647341e-01f, -1.56598762e-02f, -1.22164205e-01f, -2.63049137e-02f, 5.92893139e-02f, -4.75638099e-02f,
  2.18518823e-01f, 5.32583296e-02f, 1.27263263e-01f, 1.09246716e-01f, -2.32316926e-01f, -1.96840957e-01f, -3.20139676e-01f, -1.54306695e-01f, -1.89045936e-01f, -2.21945748e-01f,
  -2.12574333e-01f, 2.17594683e-01f, -4.84229803e-01f, 2.83402175e-01f, 2.04820395e-01f, 5.90475881e-03f, 4.37195152e-01f, -3.22692186e-01f, 1.58988729e-01f, 4.16770518e-01f,
  3.96794766e-01f, -2.14261249e-01f, 7.33501464e-02f, 6.04333989e-02f, -1.16069868e-01f, -8.70060921e-03f, 1.48816174e-02f, 2.29164824e-01f, 2.95710564e-01f, 3.56215477e-01f,
  6.98103532e-02f, 4.71558869e-01f, 1.32554933e-01f, 2.70170689e-01f, 1.04182407e-01f, -3.29144560e-02f, 2.32125565e-01f, 1.96164474e-01f, -6.64532036e-02f, -2.61467308e-01f,
  4.79272157e-01f, -5.53757995e-02f, 3.25903356e-01f, -1.81972906e-01f, 3.63673985e-01f, -2.12560028e-01f, 5.31768143e-01f, 1.49530455e-01f, -3.86693329e-02f, 2.52427280e-01f,
  3.98434341e-01f, -3.31702113e-01f, 9.13766846e-02f, -3.06510150e-01f, 4.74324852e-01f, -2.05023453e-01f, -1.17406875e-01f, -4.81101573e-01f, 3.90676856e-01f, -1.64138317e-01f,
  3.72472852e-01f, 2.68961012e-01f, 2.02785984e-01f, 6.60833344e-02f, 1.53687432e-01f, 1.23534232e-01f, 2.60521621e-01f, -4.52687383e-01f, -4.72601533e-01f, -4.32039797e-01f,
  -2.12023750e-01f, 1.29563779e-01f, 1.85675487e-01f, -3.89978290e-01f, -1.72788516e-01f, 4.90481257e-01f, 3.69274408e-01f, 1.45266056e-01f, -2.51667112e-01f, -2.82185495e-01f,
  6.61033154e-01f, 3.17491919e-01f, 3.68061602e-01f, 4.22370434e-01f, -1.59023151e-01f, -2.50791997e-01f, 1.84622556e-01f, -8.90125632e-02f, -3.36439423e-02f, 2.23101482e-01f,
  -8.19523484e-02f, 1.52095437e-01f, 5.92509806e-01f, -1.27006888e-01f, 1.64431974e-01f, -1.45725220e-01f, 2.03406543e-01f, 2.57950366e-01f, 1.38930768e-01f, -3.30039740e-01f,
  -1.39158726e-01f, -1.83461517e-01f, 3.42715144e-01f, -7.45310187e-02f, -6.36762157e-02f, -2.48055205e-01f, 1.62791133e-01f, 3.32782000e-01f, 3.83203536e-01f, 1.38717517e-01f,
  -9.61742252e-02f, -1.95619941e-01f, 3.58512878e-01f, 1.62638307e-01f, 3.10048878e-01f, 1.52388960e-01f, 1.91246644e-01f, -3.68535593e-02f, 4.41579014e-01f, -1.13581747e-01f,
  1.81116641e-01f, 1.13615558e-01f, 4.13293898e-01f, -1.07163854e-01f, 3.20445389e-01f, -1.27798960e-01f, 2.75049120e-01f, -1.54018819e-01f, 8.98595229e-02f, -3.86098778e-04f,
  2.26118729e-01f, -2.89106339e-01f, 2.16906056e-01f, 2.51334995e-01f, -5.16308025e-02f, 5.13732970e-01f, 3.95328224e-01f, -7.79217780e-02f, 3.98436673e-02f, 1.82553530e-01f,
  2.19950691e-01f, -1.73663482e-01f, -3.03852558e-01f, -8.62104222e-02f, 8.19813311e-02f, 6.35154366e-01f, 9.77974609e-02f, 4.18251663e-01f, 1.27070889e-01f, 5.10853715e-02f,
  -6.00230098e-02f, 8.20474401e-02f, 3.25195752e-02f, 4.43703635e-03f, -4.46085125e-01f, -8.25788379e-02f, 3.57463300e-01f, 2.30521008e-01f, 6.47629350e-02f, 1.38721883e-01f,
  1.98418051e-01f, 3.33484977e-01f, 3.54260981e-01f, -1.20377779e-01f, -1.71812832e-01f, -2.90150315e-01f, -2.90684313e-01f, 3.26361746e-01f, 2.84648210e-01f, 1.65897399e-01f,
  6.52265027e-02f, 4.43866879e-01f, -3.55103239e-02f, 4.39296573e-01f, -4.14801240e-01f, 1.22121729e-01f, 3.47848743e-01f, 3.52855951e-01f, 1.67693302e-01f, 3.32323045e-01f,
  1.23480437e-02f, 1.15149446e-01f, -9.81796756e-02f, 3.04718971e-01f, -1.73786152e-02f, 2.56870806e-01f, -3.74908715e-01f, 4.00917590e-01f, 6.01012707e-01f, 6.70829341e-02f,
  -7.66995475e-02f, 1.41143858e-01f, 2.41313070e-01f, 2.54898041e-01f, 2.46926814e-01f, -3.03527415e-01f, -1.33606404e-01f, -2.23437130e-01f, 3.99328887e-01f, -3.44900101e-01f,
  1.61469460e-01f, -3.43606621e-01f, 3.54929194e-02f, 2.40792811e-01f, 2.57496029e-01f, 1.07194975e-01f, -3.36856619e-02f, -2.72108644e-01f, 4.52514768e-01f, 2.82072332e-02f,
  3.94256979e-01f, 8.47717002e-02f, 5.91118932e-01f, -9.09129679e-02f, 3.76681626e-01f, -2.94496864e-01f, 2.96803921e-01f, -6.05765097e-02f, 4.72922832e-01f, -1.96611241e-01f,
  4.93900329e-01f, 6.21694922e-02f, 1.61879748e-01f, 2.17897296e-01f, 3.53307366e-01f, -1.17791615e-01f, 7.71244019e-02f, 2.31639788e-01f, 4.00352478e-01f, 2.46614307e-01f,
  -3.76405492e-02f, -4.62563783e-02f, 2.60102808e-01f, 5.00691473e-01f, 2.04462484e-01f, -3.32078785e-01f, -1.72623992e-02f, 2.84499198e-01f, 4.19271678e-01f, 2.19225541e-01f,
  1.09674983e-01f, 3.49484295e-01f, 8.46162513e-02f, -2.30426379e-02f, -2.52110332e-01f, 3.18235040e-01f, -2.72520810e-01f, 2.77479682e-02f, -7.51036704e-02f, -1.19607821e-01f,
  -2.79402316e-01f, -1.27440602e-01f, 8.99768993e-02f, 2.99390584e-01f, 5.13290048e-01f, 5.41749179e-01f, -4.09265310e-02f, -8.25379267e-02f, 1.28427669e-01f, -1.09662540e-01f,
  3.13811362e-01f, 3.33811939e-01f, -1.08705148e-01f, 3.52575779e-01f, 3.62426937e-01f, -1.15329266e-01f, 2.48251468e-01f, 2.10314002e-02f, 3.13596368e-01f, -3.62171173e-01f,
  -3.17614824e-01f, 9.91287678e-02f, -2.44636372e-01f, 5.13344705e-01f, -1.77904978e-01f, 2.05777273e-01f, -1.02349602e-01f, 7.80982152e-02f, 3.83942015e-02f, 3.29873621e-01f,
  -5.63830249e-02f, 3.38719450e-02f, -2.58916557e-01f, 3.03868532e-01f, 9.06237140e-02f, 4.39719260e-02f, 4.74556535e-02f, -2.52142102e-01f, -4.05307822e-02f, -4.41266736e-03f,
  1.43972829e-01f, 1.88345592e-02f, -5.35766721e-01f, -3.69225770e-01f, -2.78961569e-01f, 3.35838318e-01f, -3.59241217e-02f, -1.55485913e-01f, -1.18595228e-01f, 5.17618477e-01f,
  -9.07338113e-02f, 2.26618722e-01f, 3.15924674e-01f, 2.70012021e-01f, 4.22699153e-01f, -1.43661365e-01f, -1.52998924e-01f, 4.38817441e-01f, -1.80667013e-01f, 4.62871641e-02f,
  7.46518299e-02f, 4.78109539e-01f, 1.74864512e-02f, 4.80237633e-01f, -1.30620986e-01f, 6.77727044e-01f, 1.12337999e-01f, -7.86125101e-03f, -2.45877299e-02f, -3.23804140e-01f,
  1.94003224e-01f, 3.20902050e-01f, 3.34643841e-01f, 1.21167056e-01f, 2.88296729e-01f, 2.29069546e-01f, 3.83056879e-01f, 6.91461787e-02f, 8.65455717e-02f, 9.95476767e-02f,
  4.09231782e-01f, 2.78440267e-01f, -1.30758941e-01f, 2.79231519e-01f, 2.39764348e-01f, -3.86484154e-02f, -1.87193975e-01f, 1.05152190e-01f, -2.14720517e-01f, -4.47607517e-01f,
  4.06944305e-01f, 1.76744029e-01f, 3.69794548e-01f, -1.74246252e-01f, 2.46621013e-01f, 1.90861166e-01f, 4.27530199e-01f, 2.34898254e-01f, -3.01911533e-01f, -1.96043983e-01f,
  1.68851428e-02f, -1.81741670e-01f, 2.84923643e-01f, 2.44784430e-02f, -1.13819249e-01f, 3.63264650e-01f, -2.28780910e-01f, -3.54387224e-01f, 4.65871602e-01f, -2.43683189e-01f,
  -1.87746435e-01f, 2.17649471e-02f, 4.94238846e-02f, -7.68446177e-02f, 3.15385163e-01f, 4.36314881e-01f, -2.90994793e-01f, -1.92870334e-01f, 3.15930337e-01f, -4.61617976e-01f,
  3.02796990e-01f, 3.13267261e-01f, -3.60364467e-01f, 4.20964360e-01f, -1.54842317e-01f, -1.76061746e-02f, -1.63379893e-01f, -2.94578001e-02f, 3.22503924e-01f, -7.87510499e-02f,
  1.41622514e-01f, -4.28644642e-02f, 5.97658515e-01f, 4.18828249e-01f, 4.20269042e-01f, 1.22838780e-01f, 4.49880004e-01f, 6.23992682e-02f, 3.54984015e-01f, 1.03961743e-01f,
  3.28961045e-01f, 7.94905052e-02f, 2.94663727e-01f, 1.40409589e-01f, 2.04246789e-01f, 4.21821833e-01f, -1.86748743e-01f, 1.55649737e-01f, -2.08841249e-01f, -8.50599110e-02f,
  1.17793009e-02f, 2.30675578e-01f, -5.23845032e-02f, -3.98600936e-01f, 3.08522344e-01f, 2.64332891e-01f, -9.95636657e-02f, 3.58672813e-02f, 3.54431093e-01f, 2.39989653e-01f,
  8.84048119e-02f, 2.73940593e-01f, -2.41070747e-01f, -8.80889222e-02f, -2.13469923e-01f, -1.56836778e-01f, 1.43297166e-01f, -1.04271330e-01f, 1.01686676e-03f, 8.12004283e-02f,
  5.27672768e-01f, 2.48774782e-01f, -1.12523451e-01f, 1.34003744e-01f, 4.10442173e-01f, 1.72306418e-01f, 1.75272673e-01f, -1.25801384e-01f, 2.20708176e-01f, -3.30901533e-01f,
  3.65754485e-01f, 4.47286546e-01f, -1.50074363e-01f, 4.19347018e-01f, -3.59776169e-02f, -1.40326098e-02f, -1.26359358e-01f, -2.94962209e-02f, -5.57207949e-02f, 3.04176480e-01f,
  1.46217555e-01f, -1.40593529e-01f, -7.25957528e-02f, 2.47273430e-01f, 1.62655845e-01f, 2.14404494e-01f, 1.05583951e-01f, -2.72912830e-01f, 3.61668974e-01f, 9.23362896e-02f,
  2.01886505e-01f, 1.46905333e-01f, 2.62569100e-01f, -7.33930394e-02f, -1.64230272e-01f, -1.81259379e-01f, 3.87665421e-01f, 1.65004045e-01f, 6.30309805e-02f, 1.28712216e-02f,
  -1.50163367e-01f, 2.16443047e-01f, 1.52695537e-01f, 3.27388316e-01f, 3.18759888e-01f, 4.81730103e-02f, 2.49990746e-01f, -5.75389564e-02f, 1.25359580e-01f, 1.41590267e-01f,
  9.05554220e-02f, 2.13340953e-01f, -1.52822584e-03f, -1.75872251e-01f, -1.55312404e-01f, 3.05121034e-01f, 5.36220789e-01f, 2.85353631e-01f, -6.63824975e-02f, 1.77899420e-01f,
  1.38399333e-01f, -1.95132971e-01f, 6.39122799e-02f, 1.30634904e-01f, 4.32177424e-01f, 2.85543531e-01f, -1.71258561e-02f, 4.55281377e-01f, 5.15703321e-01f, 4.89474386e-02f,
  3.09315681e-01f, -1.32431194e-01f, 1.60380304e-01f, -4.51430857e-01f, 3.16532761e-01f, 4.41330522e-01f, -2.05512479e-01f, 3.40831310e-01f, -1.28710672e-01f, 7.51235709e-02f,
  -1.39690563e-01f, -5.26069887e-02f, -6.88657165e-03f, 3.58165205e-01f, -5.20945378e-02f, -1.08601041e-01f, -1.37521699e-01f, 2.12918580e-01f, 3.93690541e-03f, 1.43277943e-01f,
  1.30490914e-01f, -1.61520377e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  2.92344421e-01f, -8.24500713e-03f, 1.05521321e-01f, 1.00907637e-02f, 3.15298587e-01f, 2.79579252e-01f, 1.67219397e-02f, 1.34398982e-01f, 2.59875029e-01f, 2.91972518e-01f,
  1.69073403e-01f, 1.27580240e-01f, 1.66581184e-01f, 1.42164126e-01f, 3.17838192e-01f, 2.19913647e-01f, 2.24059746e-01f, 1.58649117e-01f, 1.50574654e-01f, 1.57217428e-01f,
  2.99750239e-01f, 7.23913833e-02f, 2.06062153e-01f, 5.36816521e-03f, 1.94435179e-01f, 1.31428555e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -2.77995411e-02f, -3.33400182e-02f, -1.87955782e-01f, -3.00979763e-01f, 2.44940375e-03f, 4.36448485e-01f, 4.82574075e-01f, -2.57134348e-01f, 4.00609076e-01f, 3.71161759e-01f,
  3.08942683e-02f, -7.56947637e-01f, 3.02744448e-01f, -2.11690217e-01f, 4.46874201e-01f, -4.02503639e-01f, -3.98825049e-01f, -6.82935774e-01f, 3.07598323e-01f, -1.41332448e-01f,
  4.16158825e-01f, 2.48803496e-01f, -6.47269249e-01f, -4.71331358e-01f, 3.54144067e-01f, 3.44771773e-01f, 4.35813144e-03f, -2.94651061e-01f, -7.35478103e-02f, -2.24571347e-01f,
  -5.79351902e-01f, -1.01684649e-02f, -2.92954445e-01f, -4.29892898e-01f, -1.78850088e-02f, -7.61924759e-02f, -2.01378003e-01f, 3.38616431e-01f, 3.11745197e-01f, -8.55001435e-02f,
  -3.11441034e-01f, 2.84603566e-01f, -8.67380381e-01f, -3.09828937e-01f, 2.85986990e-01f, -7.27032065e-01f, -3.79840583e-01f, 3.74875426e-01f, -4.27149624e-01f, -4.11672853e-02f,
  -6.10459149e-01f, -5.60928464e-01f, 2.56843030e-01f, -7.63317049e-02f, -5.96856475e-01f, 3.20042163e-01f, 3.93324584e-01f, -1.82201803e-01f, 8.86074081e-02f, 4.06552330e-02f,
  3.60110462e-01f, 4.04733419e-01f, 1.27731875e-01f, 4.73786831e-01f, 8.15972835e-02f, -3.06235492e-01f, 1.80301368e-01f, -3.15928400e-01f, -2.25897193e-01f, -1.15687422e-01f,
  -3.82521600e-01f, 8.61212164e-02f, 1.87191904e-01f, 3.44033450e-01f, -4.77540225e-01f, 4.19589937e-01f, -3.22216541e-01f, 2.07790598e-01f, 4.87843066e-01f, -3.54155421e-01f,
  -2.92067081e-01f, 3.14811766e-01f, -1.69052064e-01f, -4.72216010e-01f, -5.15175104e-01f, -7.13745952e-01f, -5.94543576e-01f, 3.87472898e-01f, -3.44209790e-01f, -1.11132286e-01f,
  1.37657166e-01f, -4.13669258e-01f, -2.13305369e-01f, 2.83347189e-01f, 5.07717207e-02f, 1.41759366e-01f, -1.31550580e-01f, 1.56258449e-01f, -1.92998230e-01f, -8.14891979e-02f,
  3.18369478e-01f, -1.46135852e-01f, 3.71031046e-01f, -4.62060601e-01f, -1.90758869e-01f, -3.74448448e-01f, -2.84851402e-01f, -7.36777604e-01f, -4.25997257e-01f, 3.42038393e-01f,
  -5.58241725e-01f, -8.41749683e-02f, 3.65053773e-01f, -3.83584470e-01f, 4.52642173e-01f, 1.12393722e-01f, 3.99558712e-03f, 2.75449067e-01f, 2.65829563e-01f, 2.46460691e-01f,
  -1.58257514e-01f, 3.45240831e-01f, -5.80333114e-01f, 4.52324659e-01f, -6.10973775e-01f, -1.45522803e-01f, 1.85413405e-01f, -1.78907260e-01f, 1.00394584e-01f, -8.77301171e-02f,
  3.51117477e-02f, 6.11470699e-01f, 2.94380873e-01f, -6.12800419e-01f, 2.08914548e-01f, -3.75000656e-01f, 1.04771398e-01f, -3.33887577e-01f, 4.90766019e-01f, 3.27939659e-01f,
  -3.89270604e-01f, -4.22762454e-01f, 4.26671356e-02f, -5.77539086e-01f, 1.99890584e-01f, -3.71542692e-01f, 3.15694869e-01f, 2.33411659e-02f, -2.83269674e-01f, 2.68711448e-01f,
  1.73181906e-01f, -7.55520165e-01f, -4.04741883e-01f, 5.21153271e-01f, 2.90641695e-01f, -3.37419480e-01f, 4.02536869e-01f, -5.34776270e-01f, 1.74343199e-01f, -5.55633068e-01f,
  7.19029680e-02f, 3.64908099e-01f, 2.32019275e-01f, -4.28358138e-01f, -2.72770137e-01f, -1.66340142e-01f, -5.67836165e-01f, -1.93773761e-01f, 2.20644679e-02f, -9.96018574e-02f,
  3.47007930e-01f, -5.45385897e-01f, 2.50710309e-01f, -3.54890764e-01f, -4.75225180e-01f, -1.03991935e-02f, -5.85005045e-01f, 3.34022731e-01f, 4.30738270e-01f, 2.18546405e-01f,
  5.18681824e-01f, 3.00932318e-01f, 1.87298805e-01f, -3.47369816e-03f, 2.10147604e-01f, -6.11703396e-01f, -7.84050375e-02f, -6.72349691e-01f, 5.78749813e-02f, 7.11584911e-02f,
  1.69936568e-01f, -1.31333908e-02f, 1.56550661e-01f, 3.06815714e-01f, 1.21208662e-02f, 1.17958076e-01f, -1.49418518e-01f, -5.37026465e-01f, -3.61979268e-02f, -2.80856043e-01f,
  -5.37888944e-01f, -8.78686547e-01f, -4.75650370e-01f, 3.70029896e-01f, 7.89375454e-02f, 6.58942640e-01f, -6.97991788e-01f, 3.88556302e-01f, 6.80570677e-02f, 5.17783105e-01f,
  -4.89105314e-01f, 1.18692420e-01f, -2.37080365e-01f, -6.96070731e-01f, 1.25400811e-01f, -3.41190487e-01f, 3.54600400e-02f, -2.57407814e-01f, 4.51088905e-01f, -4.28666204e-01f,
  -5.80809265e-02f, -9.56605151e-02f, -8.76296386e-02f, -1.16397357e-02f, -1.09359749e-01f, -2.89247348e-03f, -1.01740904e-01f, 2.17113476e-02f, 1.36445716e-01f, -1.52628705e-01f,
  -3.09767187e-01f, -1.66294858e-01f, 4.15452957e-01f, -2.89919049e-01f, -1.85658693e-01f, 1.70969635e-01f, 3.48964393e-01f, -1.13345653e-01f, 2.02832334e-02f, -4.94102716e-01f,
  -4.35812294e-01f, 3.15683842e-01f, 1.41273856e-01f, 3.92646313e-01f, -4.67128903e-01f, -2.63000458e-01f, 3.93370241e-01f, -2.17759773e-01f, -1.77667603e-01f, -4.29377079e-01f,
  -3.47148888e-02f, 5.98707557e-01f, -2.42469504e-01f, -1.44869983e-01f, -2.66696602e-01f, -2.15448663e-01f, -1.01872809e-01f, 1.20181151e-01f, -1.81138560e-01f, 4.54571009e-01f,
  -8.96763355e-02f, 9.27420110e-02f, -2.28851646e-01f, 1.42231986e-01f, -1.21376701e-01f, 2.71243989e-01f, 1.45849198e-01f, 1.64714500e-01f, 2.44920656e-01f, 3.66909772e-01f,
  -3.04814994e-01f, -4.51501608e-01f, 3.02829593e-01f, -1.73628911e-01f, -1.15670651e-01f, -2.77928025e-01f, -2.04142421e-01f, 2.21591935e-01f, -5.47354341e-01f, -1.28502458e-01f,
  1.58634320e-01f, 5.13172686e-01f, -5.30382574e-01f, -2.61719793e-01f, -4.10492450e-01f, 3.03870797e-01f, 3.10822040e-01f, 2.04868376e-01f, 2.74703465e-02f, -5.92505150e-02f,
  -1.17667533e-01f, -2.43646905e-01f, 1.09697521e-01f, 5.17981589e-01f, -4.43972260e-01f, -2.01644570e-01f, 3.52088690e-01f, 4.57958370e-01f, -4.85516712e-02f, 3.09758842e-01f,
  -5.19156933e-01f, -5.85979283e-01f, 3.70991528e-01f, 4.87383127e-01f, -4.11388367e-01f, -4.60357010e-01f, -6.23189092e-01f, 2.15064973e-01f, -1.92300484e-01f, -2.59971201e-01f,
  3.09975415e-01f, -3.68337035e-01f, -2.54662186e-01f, -5.68805933e-01f, 3.42974424e-01f, -4.01064426e-01f, 4.11161244e-01f, -3.52325082e-01f, -4.93847579e-01f, -4.72741663e-01f,
  2.17517480e-01f, 2.01454684e-02f, 1.15622163e-01f, 2.69471645e-01f, -3.94425452e-01f, -7.83319101e-02f, 4.40923929e-01f, 4.91186261e-01f, -3.30698013e-01f, -4.35143381e-01f,
  -4.79370892e-01f, 2.23964065e-01f, -2.58755863e-01f, -1.90630406e-01f, 4.96998787e-01f, -3.85025173e-01f, 1.12392075e-01f, -4.94926840e-01f, -5.73720992e-01f, -4.38622802e-01f,
  -3.19507629e-01f, 3.93087834e-01f, -2.42746204e-01f, 4.66037422e-01f, -3.76642048e-01f, -4.64276373e-01f, 1.01028912e-01f, 3.56682777e-01f, 1.30278677e-01f, -3.90997112e-01f,
  2.58501321e-01f, -4.85590309e-01f, 1.96425453e-01f, -5.78303114e-02f, 2.85582766e-02f, 1.95476357e-02f, 4.30279493e-01f, 4.42387789e-01f, -6.41069114e-01f, 3.49182814e-01f,
  -4.88781035e-01f, -1.54040128e-01f, 5.26973426e-01f, 4.27739024e-02f, 2.21997991e-01f, 3.70708168e-01f, 2.47267768e-01f, -1.83275476e-01f, 3.90530378e-01f, 1.85760066e-01f,
  -1.30264061e-02f, -2.60140747e-01f, 2.93852001e-01f, -4.04593013e-02f, 2.79739648e-01f, 6.38406258e-03f, -4.72006112e-01f, -6.27017558e-01f, -4.39180046e-01f, -1.90821245e-01f,
  -3.56997877e-01f, -4.20009136e-01f, 1.83953598e-01f, -3.72496367e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.54298425e-01f, -5.39746173e-02f, -2.27928832e-02f, -1.54283315e-01f, -3.21486406e-02f, -9.32309926e-02f, -4.94713783e-02f, -1.44448444e-01f, -1.53237760e-01f, 4.76432294e-02f,
  -8.01995322e-02f, -1.29994333e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    