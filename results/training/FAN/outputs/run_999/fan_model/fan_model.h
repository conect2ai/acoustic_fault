/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.52596051e-01f, -2.36011073e-01f, 5.84527731e-01f, -1.57777220e-01f, -1.91114038e-01f, -1.52852029e-01f, -1.75225437e-01f, 4.33672853e-02f, 2.61714011e-02f, 2.26484668e-02f,
  -2.23861068e-01f, -2.78797716e-01f, -2.28107199e-01f, -1.08632594e-01f, -5.45894988e-02f, -6.59030974e-02f, 4.65145446e-02f, 3.50003123e-01f, 2.63937473e-01f, -1.63539410e-01f,
  -3.08360130e-01f, 8.03204328e-02f, 3.62298489e-01f, 5.78493029e-02f, 6.13644719e-02f, -1.46445006e-01f, 2.16669589e-01f, 1.08265929e-01f, -1.98049426e-01f, 3.43258619e-01f,
  1.81824312e-01f, 1.40180096e-01f, 1.11085974e-01f, -1.82385463e-02f, 9.67868716e-02f, 1.43225998e-01f, 2.08149403e-02f, 1.50961399e-01f, -5.47183268e-02f, 1.30602241e-01f,
  4.41070981e-02f, -1.06295962e-02f, -5.39220171e-03f, 2.47277878e-02f, 1.20803803e-01f, 8.83153528e-02f, 5.51123805e-02f, 9.13503617e-02f, 6.14716150e-02f, -1.29762255e-02f,
  -2.03175232e-01f, -5.48487641e-02f, 1.15434505e-01f, -8.27621445e-02f, -7.42258504e-02f, 3.19017619e-02f, -2.82005854e-02f, 1.38811216e-01f, 2.30352543e-02f, 1.50786936e-01f,
  -5.24130724e-02f, 8.41394812e-03f, -2.82996967e-02f, -5.19802682e-02f, -4.53834161e-02f, -3.76741998e-02f, 7.49557558e-03f, -2.86542252e-02f, -4.37384425e-03f, -1.10837016e-02f,
  -1.01949766e-01f, 3.20415460e-02f, -5.11365421e-02f, -6.98796064e-02f, -1.14773914e-01f, -8.82903673e-03f, 2.16847495e-03f, -1.81944538e-02f, -1.25529822e-02f, 1.48159219e-02f,
  -8.05861130e-02f, 5.53658232e-02f, 2.48279190e-03f, -2.57953908e-02f, -9.33468044e-02f, -9.04043838e-02f, -9.68564209e-03f, -1.03026321e-02f, -5.49320690e-02f, 1.93002913e-02f,
  -1.53959170e-01f, -8.87332931e-02f, 5.46520622e-03f, 1.85400452e-02f, 8.07123333e-02f, -1.00906909e-01f, -8.72253031e-02f, -3.95186916e-02f, 5.36075532e-02f, -5.86603470e-02f,
  6.85756933e-03f, 5.68992905e-02f, 2.38775238e-02f, 7.32792094e-02f, 6.04718141e-02f, -5.14892749e-02f, -6.54083341e-02f, -2.15572603e-02f, 1.44068301e-02f, 7.30004087e-02f,
  -4.09662277e-02f, 9.51828843e-04f, -6.34227926e-03f, -6.67854166e-03f, -2.94668302e-02f, -2.68610753e-02f, 4.39532176e-02f, -5.38489483e-02f, 7.75899142e-02f, -1.31334662e-02f,
  -2.11784437e-01f, 1.12057827e-01f, -2.76070684e-01f, 1.17037624e-01f, 1.41047537e-01f, 4.49685194e-02f, -2.08417386e-01f, -5.73579818e-02f, 3.74880470e-02f, -1.58161193e-01f,
  -4.22728397e-02f, 2.14286759e-01f, 1.50930911e-01f, 3.32397103e-01f, 2.02059567e-01f, -1.08579203e-01f, -4.39742580e-02f, 1.41719401e-01f, 1.35912880e-01f, 2.16671109e-01f,
  2.13205740e-01f, -1.88025102e-01f, -4.39746939e-02f, 9.19147804e-02f, -1.11399904e-01f, 1.61492422e-01f, -2.12208822e-01f, -1.17544748e-01f, 6.27676025e-02f, -9.10464674e-04f,
  -1.37628630e-01f, -3.10303085e-02f, 1.80492714e-01f, 2.38396645e-01f, 8.24563578e-02f, 5.86176068e-02f, 9.30760652e-02f, 5.93370982e-02f, 1.10923991e-01f, 4.14320640e-02f,
  1.02954708e-01f, 1.16360679e-01f, 1.13123305e-01f, -3.08381207e-02f, 1.04525506e-01f, 9.35539696e-03f, -4.32523520e-04f, 1.19925044e-01f, 8.66644010e-02f, 8.50153193e-02f,
  1.29097119e-01f, 7.54285902e-02f, 2.53002439e-02f, 1.73496589e-01f, 8.08340535e-02f, 1.48409486e-01f, 1.08555838e-01f, 1.39058411e-01f, 1.36611313e-01f, 1.97596289e-02f,
  1.43075526e-01f, 1.55223359e-03f, -2.85708234e-02f, -9.89760384e-02f, -7.51448646e-02f, -2.05035862e-02f, -3.06128897e-02f, -1.37044145e-02f, 4.47545499e-02f, -1.68450460e-01f,
  8.38014204e-03f, -1.30014131e-02f, 6.07009465e-03f, -4.45836075e-02f, 2.68069860e-02f, 1.80157311e-02f, 4.58312519e-02f, -8.39097425e-02f, 7.30754286e-02f, -1.76938064e-02f,
  -3.84953432e-02f, -8.23279098e-03f, -1.31710768e-01f, -4.71135452e-02f, 4.10409458e-02f, -3.91584188e-02f, -3.93207259e-02f, 7.17966035e-02f, -4.36381064e-02f, 5.93621135e-02f,
  -9.24878269e-02f, 4.78722870e-01f, -1.71509221e-01f, 9.33230296e-02f, 6.89285845e-02f, 6.89044371e-02f, 2.40555275e-02f, 1.48880184e-01f, 6.92580938e-02f, 3.71749699e-02f,
  1.08620122e-01f, 4.66621295e-02f, -2.22994052e-02f, 7.55213201e-02f, 1.42581791e-01f, 1.18173517e-01f, -1.79283582e-02f, 7.11860806e-02f, 1.81315288e-01f, -2.55774930e-02f,
  -1.14707102e-03f, -8.87820199e-02f, -4.30113673e-02f, -1.35208592e-02f, 3.84316891e-02f, 6.61322251e-02f, -5.60066812e-02f, -9.25940573e-02f, 2.90849013e-03f, -2.56993741e-01f,
  3.43113959e-01f, -5.22051156e-01f, 2.40947735e-02f, 1.13542520e-01f, -1.37271076e-01f, 1.16261929e-01f, -1.94804803e-01f, 5.39592765e-02f, 7.96535984e-02f, -3.27789038e-01f,
  -1.34924456e-01f, 2.72947308e-02f, -6.00164197e-02f, -5.36974892e-02f, 2.06651986e-01f, -1.61789432e-01f, -2.81178914e-02f, 2.17522249e-01f, 4.33934987e-01f, 1.51663557e-01f,
  -2.01073483e-01f, -1.26397356e-01f, 2.08722278e-01f, 2.02783301e-01f, -4.72807251e-02f, 2.30538417e-02f, -2.73181379e-01f, -7.19997510e-02f, -1.03174441e-01f, -3.25084835e-01f,
  -6.11930713e-03f, -3.10584810e-02f, -6.77077472e-02f, -6.78284913e-02f, -7.19331279e-02f, 7.15518817e-02f, -3.00433151e-02f, -1.71404015e-02f, -1.41803399e-01f, -6.75197169e-02f,
  -1.61781788e-01f, -3.41205969e-02f, -2.06127558e-02f, -1.62788421e-01f, 4.23979247e-03f, -1.51889622e-02f, -1.25885541e-02f, 6.91642612e-02f, -5.13696857e-03f, -2.67571653e-03f,
  -9.12219137e-02f, -4.36746553e-02f, -6.91466108e-02f, -6.10079952e-02f, -1.70193575e-02f, -1.43650426e-02f, -5.29817156e-02f, -7.35828429e-02f, -8.13499540e-02f, -1.51517481e-01f,
  1.17723783e-02f, 4.73419167e-02f, 9.89642069e-02f, 7.20935762e-02f, 4.86356057e-02f, -1.27495080e-02f, 6.35563284e-02f, -6.63260743e-02f, 5.32761142e-02f, 1.18274111e-02f,
  7.79758841e-02f, 1.60103734e-03f, 2.05667242e-02f, -1.35118123e-02f, -1.47403292e-02f, -3.10982205e-02f, 6.28865138e-02f, -2.42054812e-03f, 1.70400075e-03f, -2.18543690e-02f,
  -4.64637280e-02f, -3.08243074e-02f, -6.22042790e-02f, 6.60820231e-02f, 4.07667123e-02f, 4.48870957e-02f, 6.30419180e-02f, -2.29793414e-02f, 1.96890328e-02f, -7.31711909e-02f,
  -1.99678928e-01f, 1.59066767e-01f, -5.95440194e-02f, -9.39971432e-02f, -1.17661834e-01f, -1.06108889e-01f, 3.59526672e-03f, -3.75611633e-02f, -9.40893888e-02f, -7.95964077e-02f,
  -1.41974157e-02f, 6.31441027e-02f, -5.23059554e-02f, -8.51206109e-02f, -3.06001939e-02f, 2.69153677e-02f, -1.13778777e-01f, -6.53870404e-02f, -7.90095031e-02f, -5.72615936e-02f,
  -1.30896587e-02f, -1.00690469e-01f, -2.32012812e-02f, -1.41583964e-01f, -1.61047757e-01f, -4.95703928e-02f, -2.96048541e-02f, -6.79745153e-03f, 7.98484981e-02f, -1.09591857e-01f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -9.22542140e-02f, 8.99865180e-02f, -5.65688945e-02f, 3.22637439e-01f, 1.98871389e-01f, 1.50611401e-01f, 1.06843457e-01f, 3.61148082e-02f, 7.31041655e-02f, 1.28486365e-01f,
  -5.80111891e-03f, 9.65087339e-02f, 6.26550689e-02f, 3.03364664e-01f, 2.30994627e-01f, 3.25630367e-01f, 4.53403682e-01f, 2.11422548e-01f, 2.97957249e-02f, 1.64039299e-01f,
  2.58387119e-01f, -1.62138417e-02f, -1.48243695e-01f, 4.59717140e-02f, 3.35005552e-01f, 6.62418455e-02f, -5.58967404e-02f, 7.36508965e-02f, 6.39505833e-02f, 5.82951128e-01f,
  -1.33676203e-02f, 9.65184420e-02f, 2.11239234e-01f, -9.36366618e-02f, 1.80432200e-02f, -9.60225314e-02f, -1.11893415e-01f, -1.45090759e-01f, -3.95779591e-03f, -4.32506874e-02f,
  -1.33202702e-01f, -1.25058725e-01f, -1.46667799e-02f, -1.06566669e-02f, -5.25336489e-02f, -2.03507751e-01f, 8.60516801e-02f, 6.08039871e-02f, -8.06231037e-05f, -6.98553631e-03f,
  2.59567797e-01f, -1.37130134e-02f, -3.01136255e-01f, -9.17738378e-02f, 1.54468939e-02f, 1.91930547e-01f, 1.32031098e-01f, 1.29228488e-01f, -1.72439262e-01f, 1.88111484e-01f,
  -4.41421755e-02f, 6.71414435e-02f, 4.64018025e-02f, 1.38940245e-01f, 1.09669156e-01f, 4.22526710e-02f, 1.38006359e-01f, 8.88165832e-02f, 9.44637135e-02f, -1.81989655e-01f,
  1.04076639e-01f, 6.83008432e-02f, 4.46255505e-03f, -9.86053497e-02f, 1.78214461e-01f, -9.18866694e-02f, 3.93807180e-02f, -6.99763000e-02f, -4.65440862e-02f, -1.71180397e-01f,
  -8.89050141e-02f, -4.89193294e-03f, 4.27796952e-02f, 1.90583766e-01f, 2.86351293e-02f, 1.38731331e-01f, 3.32329795e-02f, -1.22523248e-01f, -7.91944750e-03f, -2.82361638e-03f,
  -4.74382848e-01f, 2.18395349e-02f, 2.50401258e-01f, -2.16179937e-02f, 5.39347641e-02f, -1.32433385e-01f, 1.29360482e-01f, -6.02473207e-02f, -1.27916075e-02f, 8.85025486e-02f,
  -1.48742661e-01f, 2.62770876e-02f, -1.20460056e-01f, 5.49611375e-02f, -1.12626955e-01f, -2.63077050e-01f, 5.20607037e-03f, -1.18026361e-02f, 3.12777306e-03f, -6.63717389e-02f,
  -1.22069463e-01f, -2.90493131e-01f, -4.80245620e-01f, -7.27041587e-02f, -1.25124931e-01f, -1.54815659e-01f, -8.28738734e-02f, -2.69908667e-01f, -3.72451127e-01f, -2.85831362e-01f,
  2.97420651e-01f, 8.56254458e-01f, -1.06369495e-01f, 3.38141210e-02f, 4.31877613e-01f, 1.65638700e-01f, 5.14177024e-01f, -2.12382868e-01f, -3.26566845e-01f, 2.56356716e-01f,
  3.34850580e-01f, -1.37572870e-01f, -4.68227148e-01f, -2.49053299e-01f, -1.66198924e-01f, 9.57577154e-02f, 2.16755912e-01f, -6.55045509e-02f, -3.77681971e-01f, 8.85512829e-02f,
  3.59277517e-01f, 3.39655541e-02f, -1.86778277e-01f, -2.08538115e-01f, 3.24683070e-01f, -2.15241775e-01f, -2.08724171e-01f, 3.88378859e-01f, 4.17566657e-01f, 5.99618256e-01f,
  3.73311609e-01f, 5.48158884e-01f, -4.87468600e-01f, 9.56612751e-02f, 1.29795328e-01f, -1.20062128e-01f, 9.64945531e-04f, -4.08451110e-02f, 8.87890980e-02f, -1.38895333e-01f,
  1.59637213e-01f, 1.78828806e-01f, 2.00488284e-01f, 2.13705413e-02f, 3.21546607e-02f, 9.79894120e-03f, -1.45364657e-01f, -1.25146970e-01f, -4.11601573e-01f, 7.14759529e-02f,
  4.06635851e-01f, 5.19278586e-01f, 2.51708508e-01f, -1.00495458e-01f, -1.74495995e-01f, -8.14560279e-02f, 9.49031562e-02f, 1.04748346e-01f, -1.83539942e-01f, 5.02159968e-02f,
  -6.45898655e-02f, 9.05456170e-02f, 1.15854725e-01f, 5.13036773e-02f, -8.53595734e-02f, -1.16287388e-01f, 9.63131934e-02f, 6.30445480e-02f, -1.32888809e-01f, -3.55432965e-02f,
  -7.78148100e-02f, -2.56908610e-02f, -1.80974871e-01f, -4.62234169e-02f, -9.49177071e-02f, 9.71760377e-02f, -5.64095415e-02f, 9.05204937e-02f, 2.19556261e-02f, 2.25791205e-02f,
  7.29487883e-03f, -1.28155574e-01f, 3.98792438e-02f, -4.57725562e-02f, 1.15015425e-01f, 5.47491089e-02f, 2.80839187e-04f, -3.54345888e-02f, -8.93496126e-02f, 1.69214159e-02f,
  -5.78962028e-01f, -3.66018116e-01f, -1.86734915e-01f, -3.85812707e-02f, 1.59089237e-01f, -8.52776840e-02f, 6.58290163e-02f, 1.10103235e-01f, 2.20818371e-01f, -1.92887001e-02f,
  1.39641240e-01f, -2.37423271e-01f, 7.36229494e-02f, -1.06433243e-01f, -2.26704285e-01f, -4.33963276e-02f, 1.89626902e-01f, -1.21003360e-01f, -1.41319782e-01f, 2.83917878e-02f,
  -1.82174757e-01f, -4.01756942e-01f, -3.25085759e-01f, -3.26728761e-01f, -2.41553962e-01f, -3.85096639e-01f, -1.19186468e-01f, -1.52831316e-01f, -3.11998785e-01f, -3.32543939e-01f,
  4.63965582e-03f, -1.48652750e-03f, -1.10140085e-01f, 4.05222595e-01f, 3.85129660e-01f, 4.30015326e-02f, -5.73174655e-01f, -1.54037088e-01f, 4.56029952e-01f, -1.11723244e-01f,
  4.81196791e-01f, 3.83181602e-01f, 6.50349259e-02f, -2.28545949e-01f, -5.34099281e-01f, -4.18822706e-01f, -5.17978668e-01f, -3.20439160e-01f, 2.07320191e-02f, 1.64979547e-01f,
  3.30577195e-01f, 3.12701941e-01f, 3.72710079e-02f, -4.10278924e-02f, 5.26276231e-02f, 1.46793678e-01f, 3.41905537e-03f, 7.25991949e-02f, 2.02377476e-02f, -8.05971205e-01f,
  9.06007811e-02f, 7.46818855e-02f, 1.19296953e-01f, 1.90802053e-01f, 1.93361014e-01f, -1.85877576e-01f, 7.33969640e-03f, -1.67519808e-01f, -7.96716511e-02f, 8.94560739e-02f,
  2.71122009e-01f, 1.36924163e-01f, -1.58343725e-02f, 8.42939839e-02f, -7.54096825e-03f, 1.02170967e-01f, -1.80331945e-01f, -3.10278118e-01f, -2.35025033e-01f, -1.07148789e-01f,
  -1.28869966e-01f, 9.65525210e-02f, -2.82863617e-01f, -1.73349589e-01f, -3.87537956e-01f, 1.73003075e-03f, -1.83104455e-01f, -3.61965835e-01f, -1.74602821e-01f, -4.14015740e-01f,
  4.54346137e-03f, 6.17705695e-02f, 9.61477775e-03f, 8.85193143e-03f, -3.38019170e-02f, 8.97247866e-02f, -2.21284945e-02f, 9.80656147e-02f, 8.68882835e-02f, -2.37470672e-01f,
  -6.49630204e-02f, 9.22398940e-02f, -8.38613510e-02f, -1.38463518e-02f, -1.61214899e-02f, 3.95340438e-04f, 2.54803877e-02f, -1.06718071e-01f, -1.43318847e-01f, 1.30238216e-02f,
  -5.36846146e-02f, 4.76846192e-03f, 1.68262675e-01f, -3.46631259e-02f, 9.74304695e-03f, -1.29260883e-01f, 2.65237466e-02f, -2.05682945e-02f, 6.55656606e-02f, 1.03810176e-01f,
  1.34121940e-01f, 1.54659778e-01f, 1.20170573e-02f, -1.00844160e-01f, 6.35795966e-02f, 8.26941431e-02f, -2.43673604e-02f, -3.02629173e-02f, 1.36286110e-01f, -1.14324346e-01f,
  -4.68269251e-02f, -1.55369967e-01f, 9.67056602e-02f, -1.35017663e-01f, -5.12516275e-02f, -1.33395046e-01f, -5.39706163e-02f, -6.00346997e-02f, -1.34343386e-01f, 1.97000250e-01f,
  -8.30455795e-02f, -1.84945926e-01f, -7.76727274e-02f, -3.09636861e-01f, 3.50799635e-02f, -1.48791997e-02f, -8.73669833e-02f, 5.19432761e-02f, -1.74181968e-01f, -3.92338753e-01f,
  -1.20670211e+00f, -1.96238592e-01f, -9.01931599e-02f, -6.13284528e-01f, -6.97221681e-02f, -1.92875117e-01f, -1.74308419e-01f, -1.01613253e-01f, -1.19920813e-01f, -9.31814387e-02f,
  -8.37825239e-02f, -1.51950613e-01f, -1.16060995e-01f, 1.62046850e-02f, -2.32898399e-01f, -9.46393162e-02f, -2.46431381e-01f, -3.07314873e-01f, -1.51157334e-01f, 1.40868455e-01f,
  1.19454660e-01f, -2.30909020e-01f, -3.16454709e-01f, 1.43755488e-02f, 2.60889590e-01f, -2.24665105e-02f, 3.36171128e-02f, 1.82504609e-01f, 4.21015143e-01f, 6.14243187e-02f,
  1.75497960e-03f, -1.20261446e-01f, -5.17995507e-02f, -1.82838231e-01f, -2.36557033e-02f, 4.26976522e-03f, -6.88856244e-02f, 2.30393894e-02f, 6.60064584e-03f, 5.06808572e-02f,
  2.97478703e-03f, 1.10561110e-01f, -2.68630143e-02f, 2.50919517e-02f, -6.54512197e-02f, 1.11285120e-01f, 3.10423393e-02f, 5.71784899e-02f, 1.53459862e-01f, 9.62191895e-02f,
  2.71698475e-01f, 1.20657913e-01f, 9.10634771e-02f, 1.23907439e-01f, 2.03887165e-01f, 1.18208304e-01f, 3.24997753e-02f, 2.37705573e-01f, 9.91091356e-02f, 3.18789743e-02f,
  -1.00855678e-02f, 3.92359495e-02f, 8.32346380e-02f, 8.15188885e-02f, -7.13238865e-02f, -5.96361384e-02f, 1.73891080e-03f, 1.67973228e-02f, -1.11899357e-02f, 3.41101065e-02f,
  -7.86526352e-02f, -3.37621495e-02f, -1.30144106e-02f, 3.42870653e-02f, 6.39724657e-02f, 5.99898286e-02f, 4.70410334e-03f, 1.27391880e-02f, 7.40450248e-02f, -1.01301000e-01f,
  3.14831454e-03f, 5.66327944e-02f, -6.07494712e-02f, -5.02899401e-02f, 8.14528689e-02f, -4.91675176e-02f, 3.89180444e-02f, 5.71590438e-02f, 1.84034165e-02f, 4.17724364e-02f,
  -3.80797356e-01f, -1.02358967e-01f, -1.28092870e-01f, -4.12526019e-02f, -1.86476454e-01f, 1.78159237e-01f, -7.27802292e-02f, -4.39341627e-02f, -1.11365870e-01f, 1.18568111e-02f,
  5.85027114e-02f, 2.14520786e-02f, 2.54893750e-02f, 6.71158582e-02f, -4.74870615e-02f, 6.97616264e-02f, 7.20907301e-02f, -3.46025676e-02f, -5.36206253e-02f, 1.08729407e-01f,
  2.74310298e-02f, -5.97190578e-03f, -7.38095418e-02f, -2.32667103e-02f, 3.15111615e-02f, -1.28937894e-02f, -3.66364121e-02f, -3.94128700e-04f, -2.09991504e-02f, -1.16034083e-01f,
  6.83105588e-01f, -3.89204532e-01f, -5.92856705e-01f, -2.81131953e-01f, -3.76003921e-01f, 3.53727825e-02f, -4.46794450e-01f, 9.70808193e-02f, 1.23205066e-01f, -4.65510011e-01f,
  -2.64305081e-02f, 3.13558608e-01f, 4.49176431e-02f, 1.02216437e-01f, 3.78439844e-01f, -6.02757215e-01f, -5.48409402e-01f, -1.08657964e-01f, 3.79285872e-01f, 1.78898811e-01f,
  -1.84736088e-01f, -3.36523682e-01f, 1.62039295e-01f, -9.24735740e-02f, -5.85096955e-01f, -2.45450675e-01f, -7.08516896e-01f, -2.58902371e-01f, -1.19923495e-01f, -8.14508677e-01f,
  -2.63899326e-01f, -5.70374988e-02f, 8.22600629e-03f, 1.96735516e-01f, -2.03764260e-01f, 1.25615790e-01f, -2.18584314e-02f, -1.57271400e-01f, -1.61878858e-02f, -7.61994123e-02f,
  -1.77898750e-01f, 1.97067663e-01f, 3.47673781e-02f, -3.88465077e-02f, 4.33533173e-03f, -4.72642966e-02f, -2.93037910e-02f, -3.53756808e-02f, -1.87262765e-03f, -6.77291229e-02f,
  -8.25647265e-02f, -3.37489299e-03f, -5.10309301e-02f, -4.45049629e-02f, 2.14750752e-01f, 3.30334902e-02f, -5.08984327e-02f, -1.00346200e-01f, 7.31975138e-02f, -4.60580111e-01f,
  -2.01009735e-02f, -7.28447270e-03f, -4.32080813e-02f, 2.38000834e-03f, -3.97349009e-03f, -3.29790451e-02f, 9.40883458e-02f, -1.78135149e-02f, 3.80481477e-03f, -8.84327516e-02f,
  -1.20138498e-02f, 6.57870481e-03f, 2.61230655e-02f, -4.11918275e-02f, -1.08908072e-01f, 3.32237072e-02f, 4.99222949e-02f, -1.15563069e-02f, 9.94208083e-02f, 1.06841864e-04f,
  4.53241915e-02f, -1.05549907e-02f, -8.08780454e-03f, 3.57221998e-02f, -1.65376291e-02f, 2.66698413e-02f, 5.00399321e-02f, 1.17181785e-01f, -1.31081073e-02f, 2.62642652e-02f,
  -1.21137530e-01f, 9.37603340e-02f, -9.86511037e-02f, -3.57275493e-02f, -2.05610216e-01f, -1.41701540e-02f, -5.60825206e-02f, -8.96705911e-02f, 2.14264449e-02f, -7.42633939e-02f,
  1.33300228e-02f, 7.40369856e-02f, -3.69384997e-02f, -1.94243863e-02f, -7.87062645e-02f, -6.19764701e-02f, -7.84744099e-02f, 3.09096817e-02f, 1.18942134e-01f, 2.91998517e-02f,
  -8.06184560e-02f, 5.37827983e-02f, 1.99783340e-01f, 8.02056417e-02f, -5.99882752e-02f, 1.35986775e-01f, -1.08157016e-01f, -1.49374172e-01f, 2.14205712e-01f, -2.04745397e-01f,
  -1.25389576e+00f, -4.97730672e-02f, 2.42463290e-03f, -4.42443043e-01f, 1.63686782e-01f, 1.70815557e-01f, 4.75835323e-01f, 2.00121492e-01f, -1.06901720e-01f, 5.39676100e-02f,
  1.11436680e-01f, -8.19678456e-02f, -3.32443975e-02f, 2.05555111e-01f, 1.17296934e-01f, 3.97014529e-01f, 1.91229686e-01f, -6.12653755e-02f, -2.60189734e-02f, 7.86847770e-02f,
  1.46223120e-02f, -4.84826118e-01f, -7.44808197e-01f, -1.46199062e-01f, -1.93238735e-01f, -1.80945069e-01f, 1.36226341e-01f, -2.94030249e-01f, 2.28105143e-01f, -6.17074557e-02f,
  -3.19157131e-02f, -8.44126940e-02f, 1.36718497e-01f, -1.82997987e-01f, 3.04806866e-02f, -1.18725514e-02f, 6.59299493e-02f, -5.51789775e-02f, 1.54155018e-02f, -1.20025307e-01f,
  6.35672221e-03f, 2.03932617e-02f, -1.05713546e-01f, 6.34915903e-02f, -6.77564964e-02f, -1.44769639e-01f, -1.50713464e-03f, 1.47613928e-01f, 9.77357849e-02f, 8.52962956e-02f,
  1.77031890e-01f, -1.71735033e-01f, -9.93868560e-02f, 5.30181490e-02f, 9.88943782e-03f, -4.79532704e-02f, -1.00992456e-01f, -2.67512709e-01f, -2.64414325e-02f, -2.71264941e-01f,
  -6.31048381e-02f, 2.09570974e-02f, 1.66918077e-02f, -4.55923416e-02f, -7.59932399e-02f, 1.28775716e-01f, 9.83613431e-02f, -9.29412022e-02f, -3.84181142e-02f, -5.39648011e-02f,
  -2.56318022e-02f, 9.86029655e-02f, -1.25974298e-01f, -4.81917672e-02f, 2.82600895e-02f, -1.23227183e-02f, -1.20675899e-01f, 5.20478189e-02f, -3.63169499e-02f, -8.40952899e-03f,
  -5.77827543e-02f, 4.15161066e-02f, 1.61315855e-02f, -5.75643852e-02f, -8.39416683e-03f, -2.96380967e-02f, -3.14954063e-03f, -5.69445714e-02f, 3.16649675e-03f, 5.33707514e-02f,
  -2.61451185e-01f, 9.90796089e-02f, -5.68128303e-02f, 1.62022710e-01f, 1.02763437e-01f, -6.08363114e-02f, -1.29606828e-01f, -7.49496743e-02f, -5.93066588e-02f, -6.92915693e-02f,
  -7.72014782e-02f, -7.06647113e-02f, -5.89903295e-02f, -2.05995347e-02f, 8.21426809e-02f, 5.17971329e-02f, -3.99690904e-02f, -1.84100479e-01f, 1.48369238e-01f, -7.31849074e-02f,
  -2.02732041e-01f, -3.67884710e-02f, -2.97710896e-01f, 1.46426991e-01f, 7.31631694e-03f, -8.01818669e-02f, 9.88923311e-02f, -6.34428486e-02f, 2.22153351e-01f, -1.00288980e-01f,
  8.07200551e-01f, 5.06822467e-02f, 7.05534995e-01f, 5.87428987e-01f, 4.91105497e-01f, 7.42758512e-01f, 7.57383168e-01f, 3.96821707e-01f, 1.97080593e-03f, 7.76291341e-02f,
  9.69385132e-02f, -7.92160183e-02f, -8.73121396e-02f, -6.03662878e-02f, 2.02374965e-01f, 2.86520004e-01f, 2.07626149e-01f, 1.34033903e-01f, 1.54294819e-01f, 2.66014814e-01f,
  -2.13261306e-01f, -3.50499228e-02f, 3.76779176e-02f, -1.20770687e-03f, 2.35464759e-02f, -1.34843752e-01f, 4.03436795e-02f, 1.48689345e-01f, -8.08055401e-02f, -2.67826080e-01f,
  2.03353509e-01f, 4.28227186e-01f, 4.95017916e-02f, -9.68793407e-02f, 1.50920115e-02f, 3.19457077e-03f, 9.21941772e-02f, -1.78054214e-01f, 4.26350720e-02f, -4.17982005e-02f,
  -1.61609203e-02f, -1.55130476e-01f, 4.28182855e-02f, -1.44667462e-01f, 4.49743010e-02f, -4.86293659e-02f, -6.34691864e-02f, 5.08898571e-02f, 1.70343950e-01f, -5.02371602e-02f,
  -8.36848319e-02f, 8.44582096e-02f, 1.74319446e-01f, 1.40888780e-01f, 1.67831063e-01f, 2.33338065e-02f, 6.54165819e-02f, 4.06641141e-02f, 1.98125586e-01f, -5.59905693e-02f,
  9.40817446e-02f, 8.30685422e-02f, 4.92813587e-02f, 3.49942520e-02f, -1.11180194e-01f, -7.18341209e-03f, 3.18780541e-03f, -5.38679808e-02f, -2.68457215e-02f, -5.72150834e-02f,
  1.52277928e-02f, 7.10597709e-02f, 6.88820034e-02f, 9.03788581e-02f, -7.94490054e-03f, -4.83743381e-03f, -2.81398799e-02f, -6.77227974e-02f, -7.81190544e-02f, 2.73687486e-02f,
  -9.44837928e-02f, -1.29372785e-02f, -1.17279567e-01f, -6.45255148e-02f, 1.39034381e-02f, 2.08170749e-02f, -4.59873453e-02f, -5.55859730e-02f, 3.45309116e-02f, 5.74644245e-02f,
  -2.73170590e-01f, 1.04301073e-01f, -1.47176802e-01f, -1.17951438e-01f, 6.12342767e-02f, -2.29247585e-01f, 3.19407955e-02f, -1.07815214e-01f, -1.47226278e-03f, 1.24730226e-02f,
  7.70101696e-02f, -1.11453578e-01f, -7.63084292e-02f, -9.58110318e-02f, 6.76449714e-03f, -1.44198332e-02f, -5.25985193e-03f, -1.47045194e-03f, 3.58854942e-02f, -7.31012300e-02f,
  -1.91065177e-01f, 9.27689448e-02f, 9.39188376e-02f, 6.99333400e-02f, 1.44037092e-02f, 3.12167946e-02f, -6.83607310e-02f, -5.93175814e-02f, 2.26728953e-02f, -1.30641311e-01f,
  -6.50562227e-01f, 3.41564834e-01f, 5.20280302e-01f, -5.74005544e-01f, 9.77650657e-02f, 2.55357981e-01f, 6.13994360e-01f, 1.77376673e-01f, -3.02176982e-01f, 2.20037833e-01f,
  1.44788638e-01f, -2.00722054e-01f, 2.87557952e-03f, 5.63745536e-02f, 5.76699479e-03f, 2.77966052e-01f, 3.10034249e-02f, -2.09880471e-01f, -2.37893999e-01f, -9.88514125e-02f,
  -4.80679162e-02f, -2.53476620e-01f, -4.58267659e-01f, -2.96901464e-01f, -1.32641181e-01f, -2.92131424e-01f, 2.87373573e-01f, -8.17983374e-02f, 1.36266826e-02f, -2.15539977e-01f,
  1.72594473e-01f, 2.65756160e-01f, 2.27498021e-02f, -2.99632460e-01f, 5.00335060e-02f, -1.38241068e-01f, 3.42542939e-02f, 1.68823171e-02f, -4.77138311e-02f, -9.98951048e-02f,
  1.05931861e-02f, 9.75486562e-02f, -1.03937559e-01f, 8.09002444e-02f, -1.32087637e-02f, 1.85849089e-02f, -1.23109005e-01f, 1.36436820e-01f, 8.88119936e-02f, 1.74058720e-01f,
  7.11822659e-02f, 1.01397231e-01f, 2.69962311e-01f, 8.89257714e-02f, 5.57040758e-02f, -3.46102715e-02f, 1.80304661e-01f, -1.18129840e-02f, -2.00575870e-02f, -1.08283341e-01f,
  -9.25832018e-02f, -3.06297466e-03f, -4.75214869e-02f, 4.90481034e-02f, 1.16391584e-01f, 3.74208800e-02f, 6.07923232e-02f, 4.72650453e-02f, 1.24763027e-01f, 6.76316023e-02f,
  6.21282496e-02f, 6.63485974e-02f, 8.05905163e-02f, 6.30877689e-02f, -4.38686013e-02f, 9.60210804e-03f, 8.94125551e-02f, -8.43324512e-02f, 2.77377646e-02f, -9.10452977e-02f,
  -1.06540816e-02f, 7.54269436e-02f, 8.25803634e-03f, -5.00295870e-02f, 1.28664240e-01f, 2.08129790e-02f, -6.00278303e-02f, 1.04147010e-01f, -3.70472968e-02f, 9.33195057e-04f,
  5.97538240e-02f, 3.66597958e-02f, -2.86631044e-02f, -1.47588283e-01f, -5.37244491e-02f, -8.33208337e-02f, -3.73899899e-02f, 5.56397426e-04f, 1.51108846e-01f, 1.52913153e-01f,
  2.53360029e-02f, 1.67150330e-02f, 9.38942060e-02f, -6.72111288e-02f, -1.47648767e-01f, -3.97888198e-02f, -4.17391807e-02f, -4.67633866e-02f, -3.83262746e-02f, -2.13825740e-02f,
  -1.23347603e-01f, -1.08339228e-01f, -7.45702460e-02f, -5.64876236e-02f, 2.19286419e-02f, -6.39305115e-02f, 1.56994373e-01f, 5.13278246e-02f, 6.97319582e-02f, 2.53126882e-02f,
  -3.53094488e-01f, 1.07614569e-01f, -6.45701230e-01f, 1.44218519e-01f, -3.48310024e-01f, -1.07443474e-01f, -3.39039654e-01f, 3.11409086e-01f, 4.76727515e-01f, 8.46753940e-02f,
  9.98526514e-02f, 8.11001360e-02f, -3.00080836e-01f, -1.02758043e-01f, -2.07231656e-01f, -5.00602841e-01f, -5.95885754e-01f, -5.87374270e-01f, -4.81508851e-01f, 6.45778179e-02f,
  -2.20516279e-01f, -3.61930043e-01f, -1.38702244e-01f, 2.29665246e-02f, 1.83982700e-01f, 9.99186933e-02f, -7.60919452e-02f, -4.10940498e-02f, 8.06742832e-02f, -2.68072784e-01f,
  -5.96695542e-01f, 6.88841119e-02f, 1.03418276e-01f, -1.56417172e-02f, -9.24797952e-02f, -1.41282445e-02f, -7.70600364e-02f, 9.32113826e-02f, 1.19632237e-01f, 1.17597014e-01f,
  5.73923346e-03f, -3.94504964e-02f, -5.95000423e-02f, -1.67805364e-03f, -2.25984361e-02f, 8.49240646e-02f, 2.00059295e-01f, 1.61892157e-02f, -9.80571955e-02f, 9.73635316e-02f,
  -2.10557114e-02f, -5.03710210e-02f, 8.80782213e-03f, 1.69973001e-01f, 1.53426290e-01f, -1.69853210e-01f, 1.10244706e-01f, 1.63976625e-01f, 1.48887873e-01f, 3.37897897e-01f,
  -6.00175261e-02f, -1.17551573e-01f, -3.69595513e-02f, 4.46057208e-02f, 9.31287780e-02f, -2.68904231e-02f, -4.27702330e-02f, -1.19982539e-02f, 4.88553643e-02f, 5.46018314e-03f,
  1.12717293e-01f, -6.87270090e-02f, -2.40875352e-02f, -1.23153791e-01f, -3.93384956e-02f, -7.87936673e-02f, -2.32830849e-02f, 3.93165043e-03f, 1.23432480e-01f, 6.18140511e-02f,
  6.35968298e-02f, -3.21750231e-02f, -1.08642451e-01f, 3.41923758e-02f, -1.05109634e-02f, 3.02067380e-02f, -7.15142414e-02f, -7.36715831e-03f, 4.11513001e-02f, 1.39077064e-02f,
  1.29571676e-01f, -1.64959848e-01f, -4.09422554e-02f, 1.20525397e-01f, 7.52993599e-02f, 8.26283321e-02f, -5.54251149e-02f, 1.49429202e-01f, -1.03985723e-02f, 1.32776722e-01f,
  2.31745411e-02f, -4.54573445e-02f, -3.77643444e-02f, -2.29459535e-03f, -5.69237918e-02f, 2.67915148e-02f, 1.97075129e-01f, -6.92973062e-02f, -6.60115406e-02f, 7.97630399e-02f,
  3.64198326e-03f, 3.66742983e-02f, 2.56781448e-02f, 3.58616337e-02f, -9.33368728e-02f, -2.99306214e-01f, -8.88749287e-02f, 4.74938415e-02f, -1.79255307e-01f, 1.91549495e-01f,
  -5.03282607e-01f, 6.64340258e-01f, -1.84303731e-01f, -3.41655195e-01f, -2.72530824e-01f, -3.74251842e-01f, 2.32875064e-01f, 1.04090951e-01f, -2.38374650e-01f, 2.76000381e-01f,
  2.33878449e-01f, -2.44014949e-01f, 1.08652830e-01f, 1.27511486e-01f, -1.25381932e-01f, 2.74186701e-01f, -1.08771555e-01f, -4.20400262e-01f, -6.56458259e-01f, -2.76967794e-01f,
  -8.32128301e-02f, -3.41934144e-01f, -4.89621669e-01f, -2.56330878e-01f, 7.58801177e-02f, -2.78225571e-01f, 8.11133534e-02f, -2.71843880e-01f, -8.43879580e-02f, 1.11471610e-02f,
  -6.90596029e-02f, -2.37845302e-01f, -3.15231979e-02f, -1.70989484e-02f, -4.24800999e-02f, 5.54835089e-02f, -4.15530093e-02f, 8.09701718e-03f, 8.25771969e-03f, -1.49587607e-02f,
  -1.11423068e-01f, 4.38672081e-02f, -1.64804772e-01f, 3.04512791e-02f, -9.62885022e-02f, 2.25475486e-02f, 7.55955875e-02f, 2.12518554e-02f, 2.60734949e-02f, 2.67361730e-01f,
  5.46421111e-02f, -2.97475513e-02f, 2.02840008e-02f, 2.01155394e-02f, 7.92439654e-02f, -1.48701280e-01f, 1.08634084e-01f, -4.70778719e-02f, -1.01066455e-01f, 2.11243629e-01f,
  -2.12377682e-02f, 1.11926772e-01f, -3.34050618e-02f, -7.02491701e-02f, 6.28182516e-02f, -7.34474361e-02f, -2.30923463e-02f, -6.62026256e-02f, 3.38138305e-02f, -7.10111931e-02f,
  6.52573854e-02f, 1.51357916e-03f, 7.48936459e-02f, 4.46195900e-03f, -9.12693981e-03f, 5.02229249e-03f, -9.53482091e-02f, 6.90443665e-02f, 4.13572639e-02f, -1.41633973e-02f,
  -8.73557776e-02f, -4.32500504e-02f, 3.64737548e-02f, 6.08939026e-03f, -1.16413407e-01f, -9.73474234e-02f, -1.13260802e-02f, 1.07351644e-02f, 4.98472229e-02f, -4.63247746e-02f,
  1.24365531e-01f, -1.56903520e-01f, 5.32456078e-02f, 2.65303869e-02f, -3.26461229e-03f, 1.01717822e-01f, -8.33063647e-02f, 1.96538703e-03f, -9.62934569e-02f, -1.46423439e-02f,
  -1.18745551e-01f, -2.55461643e-03f, 1.01993382e-01f, 1.19832113e-01f, -1.04534581e-01f, -1.58236474e-01f, 1.40734660e-02f, 7.38971820e-03f, 4.48374003e-02f, 1.16647989e-01f,
  9.66731608e-02f, 3.88770662e-02f, 1.38610214e-01f, 2.65497658e-02f, -7.31112808e-02f, -1.26999334e-01f, -6.24524578e-02f, 1.24206757e-02f, -5.09493910e-02f, 4.65760082e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  6.21522307e-01f, 7.64256418e-01f, 5.31670332e-01f, -8.94193500e-02f, 9.52580497e-02f, -8.36903509e-03f, 5.18799126e-01f, 3.92073542e-01f, 1.95313528e-01f, 5.97797394e-01f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -1.12495311e-01f, -1.35332271e-01f, -5.21280393e-02f, -7.00705588e-01f, 1.61489263e-01f, -1.20610386e-01f, 2.90410846e-01f, 1.14647653e-02f, -3.56411546e-01f, 7.41460547e-02f,
  -1.70913368e-01f, 5.49281657e-01f, -1.60950363e-01f, 9.95932240e-03f, -1.56087324e-01f, 5.68662584e-02f, 3.44597995e-02f, 5.16227819e-02f, 5.49041070e-02f, -1.54640839e-01f,
  -1.26421183e-01f, -1.11563891e-01f, -2.73928903e-02f, 7.72793125e-03f, -4.61855501e-01f, -1.74315318e-01f, 1.75738990e-01f, -1.82551704e-02f, 3.58488917e-01f, -4.45914678e-02f,
  -4.39581841e-01f, -1.47376344e-01f, -1.78009063e-01f, 1.40658533e-02f, 9.76276621e-02f, 1.64794847e-01f, -2.68817157e-01f, 5.57675809e-02f, 1.72385760e-02f, -2.24753648e-01f,
  6.58630431e-02f, -4.98327851e-01f, 4.13398951e-01f, 3.60909313e-01f, 2.97987521e-01f, 3.78216982e-01f, -2.30650194e-02f, 1.94012634e-02f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  6.19980514e-01f, 1.28112689e-01f, 3.02132934e-01f, -1.22402415e-01f, 2.01343112e-02f, -2.18472511e-01f, -1.45285413e-01f, 7.60126591e-01f, 8.99875611e-02f, 2.54869282e-01f,
  -4.17412370e-01f, 2.87106812e-01f, -1.44114599e-01f, 4.26448733e-01f, -2.67531686e-02f, 2.64593363e-01f, 5.10720253e-01f, 4.89021540e-01f, 4.82205063e-01f, 9.32774603e-01f,
  -1.73845232e-01f, 8.05761367e-02f, 2.79231429e-01f, 9.12139952e-01f, 6.25827834e-02f, -1.48224354e-01f, 9.06210616e-02f, -4.87986386e-01f, -4.09437157e-02f, 2.82567561e-01f,
  -6.33803666e-01f, -1.19224656e+00f, 2.54513323e-02f, 3.49790424e-01f, 6.80867015e-05f, -6.75080001e-01f, 5.50878584e-01f, 3.61391693e-01f, 3.75593960e-01f, -1.58747867e-01f,
  3.33993077e-01f, 2.92231113e-01f, 5.98582089e-01f, 3.85728180e-01f, -7.38472492e-02f, -1.49550065e-01f, 4.16955948e-01f, -3.97885978e-01f, 6.34994924e-01f, 5.23574173e-01f,
  6.84818506e-01f, -2.35602677e-01f, -6.46472573e-01f, -3.70899104e-02f, -1.31056771e-01f, -1.97934762e-01f, 5.07315874e-01f, -3.53123218e-01f, -5.86723648e-02f, 1.62628107e-02f,
  -1.10974751e-01f, -2.84466922e-01f, 5.11754036e-01f, 6.55513287e-01f, 1.18436113e-01f, 1.84223533e-01f, 1.59327969e-01f, -8.83376375e-02f, -1.16657101e-01f, -2.45700497e-02f,
  -5.56980968e-01f, 2.35676631e-01f, -4.54766303e-02f, -3.69362980e-02f, -1.67083189e-01f, 4.58329260e-01f, 1.32631436e-01f, 5.59016049e-01f, -1.63419470e-01f, 5.96310019e-01f,
  4.74292338e-02f, 2.60993272e-01f, 5.16172424e-02f, -1.31528333e-01f, -3.01371682e-02f, -1.97222784e-01f, -7.71584213e-02f, 6.80636048e-01f, 3.51037472e-01f, 4.08770323e-01f,
  2.47596987e-02f, 8.59537244e-01f, -1.65118903e-01f, 5.71295023e-01f, 3.23439389e-02f, 2.78764516e-01f, 2.75143683e-01f, 1.71094194e-01f, 2.03143403e-01f, -4.10781682e-01f,
  1.14171274e-01f, 1.50534645e-01f, 2.08319779e-02f, 2.11179897e-01f, -3.93514186e-01f, -8.93972591e-02f, 4.89357620e-01f, -5.66582084e-01f, 5.17338932e-01f, -4.27686647e-02f,
  9.82446894e-02f, 3.66170779e-02f, 6.80424809e-01f, 6.12744868e-01f, 7.38367975e-01f, 1.10851951e-01f, 3.18379104e-01f, 3.60343039e-01f, 1.00192571e+00f, 4.37351257e-01f,
  5.04343092e-01f, 2.42496356e-01f, 5.85308194e-01f, 2.03188404e-01f, -1.76396355e-01f, 4.75019962e-02f, 4.25073318e-02f, 4.59766299e-01f, 2.76214719e-01f, 3.34379598e-02f,
  -1.45631656e-01f, -7.88865089e-01f, 8.81553367e-02f, -2.84469277e-01f, 9.02587250e-02f, 3.38133782e-01f, 8.16189945e-01f, 8.07007626e-02f, -9.50062275e-02f, 4.12167937e-01f,
  1.26158297e-01f, 1.18426956e-01f, 3.96465272e-01f, 5.59006333e-01f, -7.73484349e-01f, 3.40540856e-01f, -1.37505889e-01f, -1.46284893e-01f, -3.58953506e-01f, -7.94944763e-01f,
  3.46778691e-01f, 2.12991506e-01f, -4.61397022e-01f, -4.05476391e-01f, -4.52895641e-01f, 8.12996507e-01f, -2.46301726e-01f, -4.31991339e-01f, -6.18859172e-01f, -4.91330981e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  2.64277607e-01f, 3.02576452e-01f, -2.62453794e-01f, 4.55135405e-01f, 2.33057827e-01f, 2.49407664e-01f, 2.29102537e-01f, 8.25390935e-01f, -1.67047590e-01f, 3.11493337e-01f
};

// L2_fan_Wp (Shape: 3 x 16)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -3.50604832e-01f, 2.76576169e-02f, -1.70562714e-01f, -4.05087531e-01f, 2.29806215e-01f, 6.08975649e-01f, 2.76020970e-02f, 1.72208264e-01f, -1.66088253e-01f, -9.57491025e-02f,
  3.30467336e-02f, -7.83589557e-02f, 4.11863774e-01f, -1.64093390e-01f, -1.30235448e-01f, 4.97537166e-01f, -6.69240296e-01f, 7.40291625e-02f, -5.05274892e-01f, 5.87351382e-01f,
  4.70497727e-01f, -3.48003060e-01f, -7.34411925e-02f, -3.60638529e-01f, 2.76676416e-01f, -1.12970181e-01f, 3.88599522e-02f, -6.84098005e-02f, 3.11864346e-01f, 7.18266144e-02f,
  1.27861649e-01f, 2.71879137e-02f, -8.73275101e-03f, -1.33251026e-01f, 2.21403819e-02f, -1.38213396e-01f, -5.56789756e-01f, -4.74771261e-01f, 1.14678867e-01f, -3.52576226e-01f,
  1.91929433e-02f, -1.27670458e-02f, 3.70946154e-02f, 6.34005144e-02f, -3.12320501e-01f, 3.99204530e-02f, 1.27117887e-01f, -1.91898227e-01f
};

// L2_fan_Wp_bar (Shape: 10 x 16)
const int L2_fan_Wp_bar_rows = 10;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  3.51818025e-01f, 2.81357974e-01f, -9.81502142e-03f, -5.50759614e-01f, 6.35997832e-01f, 5.21711648e-01f, 1.53460130e-01f, 6.12902045e-01f, -6.84939623e-01f, -1.75348222e-01f,
  -1.14624441e-01f, 2.44004458e-01f, -2.75155097e-01f, 2.31668964e-01f, -6.28733218e-01f, -5.05495025e-03f, -1.36601821e-01f, 3.12863410e-01f, -1.15536258e-01f, 3.07306796e-01f,
  4.58944142e-01f, -3.21569830e-01f, -2.02340737e-01f, 2.39255667e-01f, 6.50352299e-01f, -3.87567908e-01f, -3.57682973e-01f, 2.87670791e-01f, 3.34087402e-01f, 3.25027019e-01f,
  3.00149858e-01f, 1.09745145e+00f, 2.55404003e-02f, 1.30945817e-01f, 2.10824192e-01f, 1.32512963e+00f, -6.79942191e-01f, -1.90332770e-01f, 3.32268983e-01f, -6.77858740e-02f,
  -2.31242761e-01f, 3.83481592e-01f, 4.61221546e-01f, 4.53136474e-01f, -5.24343431e-01f, 2.62805939e-01f, 3.78907830e-01f, -2.04699799e-01f, 1.81824192e-01f, -4.70847189e-01f,
  8.97338167e-02f, -1.66122168e-02f, 1.27382949e-01f, 7.10585266e-02f, 5.41341007e-01f, 1.67389959e-01f, 4.25158858e-01f, 8.16718996e-01f, -5.88333271e-02f, 6.29721165e-01f,
  4.15234834e-01f, 7.03549206e-01f, 6.50967240e-01f, 1.93654541e-02f, 2.67761983e-02f, 6.02234781e-01f, 5.68280697e-01f, 9.44645762e-01f, -3.25042605e-01f, -2.73410171e-01f,
  -2.39292756e-02f, 4.55658995e-02f, 2.19577089e-01f, -3.28978419e-01f, 4.04137112e-02f, 1.67267352e-01f, -3.31152111e-01f, 5.55689216e-01f, -2.75554329e-01f, 8.61510217e-01f,
  -1.40096366e-01f, -8.59915674e-01f, -6.83066696e-02f, -5.05424440e-01f, 4.30405349e-01f, -3.50751430e-01f, -1.64226070e-01f, -7.06874251e-01f, 6.91083848e-01f, 3.82768571e-01f,
  -1.77940637e-01f, 1.94577277e-01f, 6.06304482e-02f, 1.91342250e-01f, 2.95696080e-01f, 3.59594524e-01f, -3.44881624e-01f, 1.34448335e-01f, -3.89501661e-01f, -1.80241659e-01f,
  6.60699248e-01f, 4.84135211e-01f, 1.08139420e+00f, 3.37703615e-01f, -5.09157181e-01f, -3.87237877e-01f, 4.27638859e-01f, 6.26718223e-01f, 8.93201604e-02f, 5.92255257e-02f,
  2.05767900e-01f, -1.37059942e-01f, 5.22288084e-02f, 6.43692970e-01f, -2.18564216e-02f, -1.00932789e+00f, -4.70044732e-01f, -3.21444184e-01f, -2.89499134e-01f, 8.05072665e-01f,
  1.93372279e-01f, -2.56716251e-01f, -6.59226716e-01f, -1.70917064e-01f, 1.10904843e-01f, 6.65091634e-01f, -2.74144024e-01f, 7.32800186e-01f, 6.14228368e-01f, 4.21425164e-01f,
  2.62467831e-01f, -4.52383459e-01f, -1.82028368e-01f, 5.14936864e-01f, 7.55637228e-01f, 6.92143798e-01f, -6.51845515e-01f, 1.87262535e-01f, 3.44455659e-01f, 8.10172111e-02f,
  -3.31664801e-01f, 2.76443988e-01f, 6.27074018e-02f, -6.04902744e-01f, 4.66748506e-01f, 6.23515189e-01f, 1.79850563e-01f, -8.93412113e-01f, -5.83597302e-01f, 6.62487626e-01f,
  -6.85628593e-01f, 1.01427384e-01f, -8.86290744e-02f, 7.00700343e-01f, -2.75640786e-01f, -3.09816629e-01f, 3.32458287e-01f, 4.04291421e-01f, 6.56758994e-02f, -7.03924835e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 10)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 10;
const float L2_fan_Bp_bar_data[] = {
  1.43534482e-01f, -4.05481867e-02f, -3.62741225e-03f, 5.58968298e-02f, 6.13219067e-02f, 5.58939204e-02f, -2.16811195e-01f, 4.52001423e-01f, 3.48678499e-01f, 5.53991139e-01f
};

// L3_fan_Wp (Shape: 3 x 16)
const int L3_fan_Wp_rows = 3;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  2.56226927e-01f, -1.91123635e-01f, 4.38716412e-02f, 3.38837713e-01f, 3.11121391e-03f, -7.40042865e-01f, 2.07794428e-01f, 4.30234428e-03f, -1.74205199e-01f, -4.42168899e-02f,
  3.97683650e-01f, 1.30889952e-01f, -1.99927554e-01f, 7.59217888e-02f, -1.92218885e-01f, 2.34308511e-01f, 5.27963089e-03f, -4.88104045e-01f, -2.80899256e-01f, 3.83983195e-01f,
  -4.86860603e-01f, -1.16956718e-01f, 4.12712961e-01f, 2.18455076e-01f, -2.32050478e-01f, -7.38759786e-02f, -4.72334260e-03f, 2.86808729e-01f, 2.44718388e-01f, -1.58322662e-01f,
  -2.71227024e-02f, -2.36678451e-01f, -2.74000973e-01f, -6.08476102e-01f, 1.62924469e-01f, -1.85446814e-01f, 4.16022748e-01f, 5.39052002e-02f, -5.00958040e-02f, 5.84553145e-02f,
  9.24655944e-02f, 1.64235145e-01f, 2.14340508e-01f, -1.64466321e-01f, 5.73147722e-02f, 1.99522465e-01f, -7.90644139e-02f, -3.87777954e-01f
};

// L3_fan_Wp_bar (Shape: 10 x 16)
const int L3_fan_Wp_bar_rows = 10;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  -1.19881868e-01f, -1.47037148e-01f, -1.01142392e-01f, 1.40194833e-01f, 1.64091364e-01f, -1.44603595e-01f, -8.31855655e-01f, 6.09167218e-01f, 8.51922855e-02f, 4.84311670e-01f,
  -6.58663735e-02f, 9.01095688e-01f, -5.50140142e-01f, 5.37561700e-02f, -5.89937866e-01f, 2.22491235e-01f, -3.88094634e-01f, 7.79912233e-01f, -1.80315375e-01f, -2.67611384e-01f,
  -1.44533023e-01f, 5.36277831e-01f, -3.21256697e-01f, -3.20089966e-01f, 6.19934201e-01f, 3.34662199e-01f, -6.22725368e-01f, -2.61535376e-01f, 6.81004524e-01f, -2.04132512e-01f,
  6.54247940e-01f, -6.55350164e-02f, 4.40965980e-01f, 6.13023400e-01f, 2.54832767e-02f, 6.13979623e-02f, 3.83851200e-01f, -3.16707969e-01f, -2.92622626e-01f, 2.93464631e-01f,
  -5.92048705e-01f, 2.10912272e-01f, -2.13656753e-01f, -4.04928833e-01f, 2.33457088e-01f, 8.70749891e-01f, 3.73909563e-01f, 5.24310231e-01f, 1.37561411e-01f, -3.72430384e-01f,
  -9.94949639e-01f, 6.39665604e-01f, -8.31965446e-01f, -4.45779562e-01f, 8.87586951e-01f, -8.37961286e-02f, -5.27760506e-01f, -1.21081315e-01f, -5.66476405e-01f, -1.46628782e-01f,
  5.93546450e-01f, 7.57700726e-02f, 4.34708804e-01f, -2.18595847e-01f, 3.49342108e-01f, -7.75832176e-01f, 9.95302320e-01f, -1.90154299e-01f, -5.45074463e-01f, 1.01350278e-01f,
  1.61462441e-01f, 1.33458242e-01f, 4.36140448e-01f, -2.24872440e-01f, 1.23746037e+00f, -3.65756780e-01f, 1.36281652e-02f, 2.67655194e-01f, 3.28787923e-01f, -5.00825286e-01f,
  -4.17384058e-01f, -1.49919137e-01f, 3.37858200e-01f, 3.76451127e-02f, 4.11198139e-01f, 2.33995274e-01f, 7.50521198e-02f, 2.27340713e-01f, 5.27575493e-01f, 1.85254395e-01f,
  5.97887337e-01f, 3.51099163e-01f, 2.86616921e-01f, 2.72907346e-01f, 1.12338424e-01f, -9.49758291e-01f, 3.97683412e-01f, 1.80220604e-02f, 3.76827478e-01f, 4.64697748e-01f,
  -2.30300143e-01f, -4.08043534e-01f, 9.21794236e-01f, 2.95401871e-01f, -5.63708723e-01f, 8.19593444e-02f, -2.61718839e-01f, 2.21896872e-01f, 1.37443766e-01f, 7.81771123e-01f,
  4.22644466e-01f, 5.74661434e-01f, 5.36642373e-01f, 3.99009407e-01f, 9.67000723e-01f, -8.53310466e-01f, -5.48143744e-01f, -3.01355600e-01f, 3.29424977e-01f, -5.24410665e-01f,
  4.61247474e-01f, 2.39375215e-02f, 2.21978202e-01f, -4.56380814e-01f, -7.47378826e-01f, 2.22115755e-01f, 6.26497030e-01f, 7.81970799e-01f, -4.26912755e-01f, 7.04975307e-01f,
  1.19381815e-01f, -9.35629725e-01f, -1.29568309e-01f, 6.39231503e-01f, -1.76687643e-01f, -2.40632206e-01f, 1.90839037e-01f, 4.62526798e-01f, -5.12273312e-01f, 4.34568226e-01f,
  -3.62162918e-01f, 7.31545240e-02f, 4.34010416e-01f, 1.74309611e-01f, 8.17798316e-01f, 5.37138432e-02f, -4.84724998e-01f, 7.36474752e-01f, 5.87671816e-01f, -4.38635379e-01f,
  -5.23276590e-02f, 5.78968465e-01f, -1.82945043e-01f, 2.68569738e-01f, 6.16442859e-01f, -1.91505566e-01f, 2.29003593e-01f, 1.70581322e-02f, 9.47900768e-03f, -3.83910656e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 10)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 10;
const float L3_fan_Bp_bar_data[] = {
  1.23549655e-01f, 5.57829477e-02f, 3.75297099e-01f, -1.25923768e-01f, 3.12796026e-01f, 4.25866321e-02f, 1.50394574e-01f, 4.18615043e-01f, 2.25440204e-01f, -2.22524673e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  2.88877767e-02f, -2.02547595e-01f, -2.80462235e-01f, 8.20410550e-01f, 3.67139310e-01f, 1.89258441e-01f, 6.05776608e-01f, -7.02873826e-01f, -5.15103757e-01f, -1.86175436e-01f,
  -5.37166774e-01f, 1.73604801e-01f, -1.10334799e-01f, -4.82794583e-01f, 1.74255088e-01f, -1.31226815e-02f, -7.16127813e-01f, 2.47199148e-01f, 4.07096416e-01f, -2.57467568e-01f,
  -4.00061458e-01f, 1.41304657e-01f, 1.31857604e-01f, -9.44237292e-01f, 4.04528499e-01f, -3.62434179e-01f, -6.60466969e-01f, -5.01794100e-01f, 4.53864604e-01f, -1.49788275e-01f,
  -2.39069313e-01f, 2.05979571e-01f, -1.67712316e-01f, 5.38580358e-01f, 6.70862854e-01f, 2.31645748e-01f, -5.03563762e-01f, 5.72799563e-01f, -1.94021165e-01f, -9.87555027e-01f,
  1.26058102e-01f, -6.10463619e-01f, 7.77368426e-01f, -5.27512431e-01f, 3.29528987e-01f, 4.90088880e-01f, -2.70464271e-01f, -8.50327790e-01f, 9.39815342e-02f, -5.33031523e-02f,
  5.91864824e-01f, -3.55800897e-01f, 3.82058531e-01f, -1.05042231e+00f, 1.93148494e-01f, 3.24084580e-01f, -9.45244074e-01f, -6.34893358e-01f, 3.02224040e-01f, 2.41391048e-01f,
  -1.41226947e+00f, -8.08727980e-01f, -6.01186454e-02f, 3.76279175e-01f, -5.89532793e-01f, 4.48669285e-01f, -3.02900642e-01f, -8.12068224e-01f, -4.96530056e-01f, 4.76163298e-01f,
  1.46485552e-01f, 4.05187219e-01f, -2.73203999e-01f, -2.97370017e-01f, -7.74068594e-01f, 5.67353331e-02f, -3.76961321e-01f, -6.69842541e-01f, 5.16609788e-01f, -3.02992433e-01f,
  7.68623531e-01f, -2.08435342e-01f, 1.08486526e-01f, 2.15749830e-01f, 3.32579575e-02f, 5.67930117e-02f, 1.45857081e-01f, 1.82226136e-01f, 8.34831521e-02f, -3.39355797e-01f,
  -8.06611001e-01f, -4.88892168e-01f, -3.01001251e-01f, 5.92362404e-01f, 2.26498142e-01f, -5.38174450e-01f, 3.77850562e-01f, -4.56110328e-01f, -9.27815661e-02f, 8.49372029e-01f,
  1.98171794e-01f, 7.59188756e-02f, -1.13029458e-01f, -1.04616594e+00f, -3.95574421e-02f, 4.86437201e-01f, 3.88452291e-01f, -1.44520476e-01f, 4.41420734e-01f, 2.76422296e-02f,
  -7.63205171e-01f, -3.91928256e-02f, 7.15244785e-02f, 3.08280379e-01f, 2.21314147e-01f, 2.45105430e-01f, 4.83956248e-01f, -3.63937356e-02f, 1.69403389e-01f, -1.08021215e-01f,
  1.76561475e-01f, -4.70258385e-01f, 2.11554855e-01f, 1.31255254e-01f, -3.10781032e-01f, -8.14122736e-01f, -3.19523156e-01f, 4.73888129e-01f, 2.63174951e-01f, 1.89280182e-01f,
  1.70085058e-01f, 2.27708265e-01f, 8.23116243e-01f, -9.73130465e-01f, -5.51078200e-01f, -5.56341782e-02f, 1.03899308e-01f, 8.11995029e-01f, -9.36607957e-01f, -1.16052568e+00f,
  3.54107410e-01f, 1.52214676e-01f, -3.06263357e-01f, -3.48852009e-01f, 2.58413762e-01f, 6.19085729e-01f, -6.55428469e-01f, -2.95802932e-02f, 7.70927891e-02f, -8.29234600e-01f,
  -6.62633181e-01f, 4.34916429e-02f, 1.55511394e-01f, -5.42528331e-01f, 4.01454210e-01f, 4.77482714e-02f, 1.67244691e-02f, 3.34861875e-01f, -2.21537471e-01f, -1.19035996e-01f,
  -4.47889537e-01f, -7.47550905e-01f, -4.52680022e-01f, 9.86147448e-02f, -4.27691251e-01f, 2.25434333e-01f, -9.61474717e-01f, 5.05432308e-01f, -8.98474872e-01f, -5.92607200e-01f,
  4.50681776e-01f, 1.52587891e-01f, -1.04897225e+00f, 3.93965930e-01f, 6.93330094e-02f, -6.58777952e-01f, -6.04236007e-01f, -6.44816995e-01f, -3.93290907e-01f, -1.23975897e+00f,
  7.58821964e-02f, 3.12261790e-01f, -9.85476136e-01f, 6.23896897e-01f, 8.03013220e-02f, 3.43627632e-01f, -2.75702089e-01f, -2.77638465e-01f, 1.25128865e-01f, -4.93003160e-01f,
  -4.24077600e-01f, -1.41985625e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -3.81097496e-01f, -2.52394378e-01f, 3.40681404e-01f, -2.08501786e-01f, -6.93074018e-02f, -6.23954721e-02f, 2.36797556e-01f, 8.26144069e-02f, 2.12997943e-02f, -1.37170151e-01f,
  1.95415154e-01f, -4.47695225e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    