/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.95319489e-01f, 3.00967097e-01f, -5.14197983e-02f, 1.98353454e-01f, -1.35386422e-01f, -6.25982508e-02f, 5.89627598e-04f, 1.09421611e-02f, 2.27406830e-01f, 1.41151831e-01f,
  -8.18048790e-02f, 1.09747022e-01f, 1.55288773e-02f, 3.96920703e-02f, 1.54606760e-01f, 5.10273986e-02f, 1.60129324e-01f, 1.12775050e-01f, 2.99512427e-02f, 1.00381047e-01f,
  -2.93249227e-02f, 1.19110562e-01f, 3.68317105e-02f, -2.08128896e-02f, -7.38603473e-02f, -1.11597277e-01f, -4.72210022e-03f, -9.61258933e-02f, -1.23144992e-01f, -1.55526146e-01f,
  1.16886117e-01f, 1.71450362e-01f, 9.19576269e-03f, 3.09166778e-02f, 2.46928707e-02f, 3.16120218e-03f, -4.96923327e-02f, -6.96228370e-02f, -7.69730806e-02f, -1.50520027e-01f,
  -2.85471641e-02f, -7.79470080e-04f, 1.54046109e-02f, -1.16239905e-01f, 1.68128777e-02f, -5.91635145e-02f, -7.71219209e-02f, -2.72045191e-02f, -1.38224978e-02f, -5.03995605e-02f,
  2.29684431e-02f, -6.88549653e-02f, 8.90081525e-02f, -4.85274345e-02f, 1.17137134e-02f, 8.16360116e-02f, -1.62232306e-03f, -1.02979057e-01f, -7.87570998e-02f, 2.06851605e-02f,
  7.37677217e-02f, 2.29849909e-02f, -5.90577573e-02f, 1.47848791e-02f, 3.06656398e-03f, -2.29970068e-02f, -2.63045803e-02f, -1.93719380e-02f, 1.75974183e-02f, -2.85428818e-02f,
  2.66030319e-02f, 5.55687137e-02f, 6.79333508e-02f, -3.73150297e-02f, 8.44720379e-02f, 4.05471511e-02f, -8.47947318e-03f, -3.54925394e-02f, 7.39140660e-02f, 1.78337712e-02f,
  2.92200651e-02f, 9.07941312e-02f, 3.57993096e-02f, 3.75280865e-02f, -4.48752427e-03f, 9.54625662e-03f, -3.26948427e-02f, -6.22462928e-02f, -6.49635196e-02f, -4.12811618e-03f,
  1.44795492e-01f, 3.32463145e-01f, 4.33337167e-02f, 3.10854968e-02f, -4.79212478e-02f, -6.41063824e-02f, -1.44781219e-02f, -9.80917085e-03f, 1.43520489e-01f, 7.73408785e-02f,
  -1.45698667e-01f, -3.13960947e-02f, 1.19919024e-01f, 1.60273369e-02f, 4.15233597e-02f, 4.72056605e-02f, 5.18261045e-02f, 6.31811470e-02f, 9.73772537e-03f, 3.24414745e-02f,
  1.78685281e-02f, 7.09185377e-02f, -6.09254837e-02f, 4.70129959e-02f, 1.09760957e-02f, -5.59466034e-02f, -5.63996751e-03f, -2.93184295e-02f, -6.55196309e-02f, 6.89156875e-02f,
  -8.12877640e-02f, 2.72218257e-01f, -1.61209807e-01f, 1.06313460e-01f, -2.12288901e-01f, 2.69592982e-02f, -7.14641586e-02f, 1.78698316e-01f, -4.28097099e-02f, 3.98097485e-01f,
  1.85724303e-01f, -5.19956872e-02f, -7.95215368e-03f, 1.94557056e-01f, -3.91392171e-01f, -5.86242415e-03f, 7.42473826e-02f, 6.51277453e-02f, -6.12004027e-02f, 1.28994077e-01f,
  -4.25621532e-02f, 1.25471801e-01f, -1.33832440e-01f, 1.59142092e-01f, -2.42360886e-02f, 4.63593006e-02f, -4.70628776e-02f, -1.07918650e-01f, 1.67916805e-01f, -4.12362665e-02f,
  2.62360759e-02f, 1.43060222e-01f, -4.96918559e-02f, -4.99528646e-03f, -1.11237112e-02f, -8.88830796e-02f, -6.89095333e-02f, -1.08715773e-01f, -2.65618693e-02f, 4.66398001e-02f,
  -8.54066946e-03f, 3.05526387e-02f, 5.97428940e-02f, -4.35329117e-02f, 3.82006867e-03f, 8.56736004e-02f, 2.46717688e-03f, 1.24856480e-03f, -3.18664452e-03f, -4.56068898e-03f,
  1.04916999e-02f, -4.25476246e-02f, 6.07806779e-02f, 9.07258466e-02f, -2.68573705e-02f, 3.61304097e-02f, -5.73568940e-02f, -1.31510189e-02f, 3.01476344e-02f, 7.73679912e-02f,
  6.48960657e-03f, -2.36550858e-03f, 9.24551301e-03f, 6.06609099e-02f, 1.23668626e-01f, 5.63845783e-02f, 1.80771388e-02f, 8.66346154e-03f, 5.58885075e-02f, 1.80478562e-02f,
  5.25571108e-02f, 3.87697071e-02f, 2.70363204e-02f, 2.92822514e-02f, 4.78601642e-03f, 7.72122517e-02f, 9.52338520e-03f, 3.65164913e-02f, 1.62371993e-02f, -1.13357892e-02f,
  -1.82752013e-02f, -2.46642232e-02f, 4.68426794e-02f, -4.25984375e-02f, -7.90232327e-03f, -2.87952777e-02f, 3.74793299e-02f, 7.52003044e-02f, -5.02243591e-03f, -3.61131653e-02f,
  5.37290201e-02f, 1.43689409e-01f, 3.92234065e-02f, 5.74622825e-02f, 4.99140397e-02f, 7.11002797e-02f, 1.95025709e-02f, 1.15918480e-01f, 5.36973067e-02f, 1.94391850e-02f,
  3.45206410e-02f, 4.70290184e-02f, -3.35582234e-02f, -4.15109238e-03f, 6.33077929e-03f, 1.33029632e-02f, -2.98708081e-02f, 2.28670202e-02f, 6.49796873e-02f, -1.64391100e-02f,
  -1.34615451e-02f, 3.17385644e-02f, 4.01951261e-02f, 4.45881896e-02f, 5.36335111e-02f, 9.46361721e-02f, -5.23744747e-02f, -5.27035166e-03f, -3.21072228e-02f, -6.59635116e-04f,
  1.21833114e-02f, -1.48528159e-01f, -1.40552282e-01f, -1.57046288e-01f, 4.25152406e-02f, -2.07926080e-01f, -2.44040668e-01f, 1.19807377e-01f, 4.70745414e-02f, 3.81814353e-02f,
  -1.00519985e-01f, -1.98344812e-01f, -7.82731771e-02f, -1.78134799e-01f, -2.16560572e-01f, -1.48463473e-01f, -7.74483830e-02f, -1.54025495e-01f, -7.58605357e-03f, -6.59539327e-02f,
  6.95874691e-02f, 1.91923678e-02f, -9.41917300e-02f, 1.66336790e-01f, -9.22556669e-02f, 1.34278014e-01f, 4.35894281e-02f, 1.16349077e-02f, 2.50392854e-02f, -1.18898101e-01f,
  -1.37748033e-01f, -5.58893681e-02f, 4.25460339e-02f, -2.89259702e-02f, 3.10854428e-02f, -2.38788947e-02f, -4.10834700e-02f, -7.24015981e-02f, 6.01687655e-02f, -1.08391773e-02f,
  -9.12568122e-02f, -8.45989063e-02f, 3.62014771e-02f, 5.98714277e-02f, 1.11213319e-01f, -7.88157526e-03f, 2.98028085e-02f, -3.58067267e-02f, 4.52045575e-02f, -2.69931764e-03f,
  -6.89714924e-02f, -1.22024482e-02f, -5.40902875e-02f, -1.19070984e-01f, 3.66304368e-02f, -6.45854473e-02f, 4.23181579e-02f, -8.18724185e-02f, -5.28080016e-02f, -2.18020342e-02f,
  -7.14897811e-02f, 1.52777378e-02f, 9.48731322e-03f, 5.14880419e-02f, -1.01464495e-01f, -1.00455917e-02f, -3.59922573e-02f, -2.80536171e-02f, 5.26366867e-02f, -9.36930776e-02f,
  3.98695283e-02f, 8.77375063e-03f, 7.44172558e-02f, 9.06287953e-02f, 6.57146666e-05f, 1.53415129e-02f, 6.88426662e-03f, 4.06392626e-02f, 5.81194609e-02f, -1.55282742e-03f,
  6.47865161e-02f, 4.74101976e-02f, -4.35338821e-03f, 2.73865033e-02f, -1.17305871e-02f, 1.16323691e-03f, 4.34280224e-02f, -3.56342867e-02f, -1.72211602e-02f, 1.79606937e-02f,
  1.84398890e-03f, 8.93285051e-02f, 4.32712771e-02f, 1.06289005e-02f, -3.76260281e-02f, 3.03309411e-02f, -2.58632880e-02f, 2.28598248e-03f, 1.21951669e-01f, 2.63178181e-02f,
  5.15986606e-02f, 6.46234229e-02f, -3.70734814e-03f, -4.67109047e-02f, -5.23104146e-02f, 2.59814039e-02f, -1.46012232e-02f, 2.60300059e-02f, -5.01568317e-02f, 2.79719848e-02f,
  -3.44980881e-02f, -6.46932274e-02f, -2.73350184e-03f, -2.96016186e-02f, -2.39768829e-02f, -5.15883677e-02f, -4.74895462e-02f, 3.75868566e-02f, 2.83886120e-02f, 3.85518037e-02f,
  2.48418376e-01f, -7.48026446e-02f, -1.16050683e-01f, -7.17111304e-02f, 5.17888851e-02f, -4.02053565e-01f, -2.27346063e-01f, 1.41939431e-01f, 7.59922564e-02f, -1.05418842e-02f,
  3.59391384e-02f, -1.07420422e-02f, -1.33292750e-01f, -1.29151180e-01f, -2.52991110e-01f, -2.77229786e-01f, -3.16535160e-02f, -1.20257109e-01f, 2.69739088e-02f, 5.14722392e-02f,
  7.53097087e-02f, -5.41556254e-02f, -1.66643575e-01f, 7.74431080e-02f, -2.05476880e-02f, 1.90112516e-01f, -3.22648580e-03f, -2.60750875e-02f, -1.21264569e-02f, -1.09205775e-01f,
  8.49113166e-02f, 1.81552082e-01f, 9.23579633e-02f, 7.00218156e-02f, 1.66800134e-02f, 4.83451374e-02f, -8.34730715e-02f, -9.34466273e-02f, 2.95944326e-02f, 1.57786496e-02f,
  -5.64882345e-02f, 2.25400906e-02f, 9.79300812e-02f, -2.52545569e-02f, -1.08799264e-02f, 4.02976722e-02f, 7.51221851e-02f, 1.55952573e-03f, -2.99622118e-02f, 1.20533593e-02f,
  3.64571549e-02f, 7.16651930e-03f, -5.16187586e-02f, -1.04027376e-01f, -5.49743744e-03f, 1.23467781e-02f, -2.74525099e-02f, -8.21523815e-02f, 2.14293581e-02f, 2.10325290e-02f,
  -5.58820069e-02f, -3.82990018e-02f, -2.09131949e-02f, 3.32126170e-02f, -3.50044668e-02f, 6.59755915e-02f, -4.33971956e-02f, 2.65499838e-02f, 4.32548411e-02f, 5.01118712e-02f,
  -5.62392734e-03f, -1.31683815e-02f, 4.18204963e-02f, -7.11905882e-02f, 5.14697656e-02f, 3.67401689e-02f, -5.25915325e-02f, 6.96536750e-02f, -1.99870802e-02f, 4.90314662e-02f,
  2.61752717e-02f, 1.32277142e-02f, -3.84913795e-02f, 3.71770188e-02f, 2.33259518e-02f, -2.96578668e-02f, 5.44070266e-02f, -1.37110958e-02f, -1.47546288e-02f, -2.65942607e-02f,
  -9.09801647e-02f, 4.00774442e-02f, 7.37245083e-02f, 1.67061687e-02f, -2.23711934e-02f, -2.20124573e-02f, 4.83621024e-02f, 5.96784577e-02f, -4.58906330e-02f, -2.14010216e-02f,
  -1.25022326e-02f, 1.09930895e-02f, -9.72828642e-03f, -2.42969114e-02f, -1.86938662e-02f, 6.79119006e-02f, -8.58942792e-03f, 2.68859826e-02f, 7.75501803e-02f, 7.03069568e-02f,
  6.47605062e-02f, 2.37178002e-02f, -3.20689715e-02f, 6.24162406e-02f, -3.01964208e-02f, 5.05196415e-02f, 5.36782034e-02f, 1.69809423e-02f, -4.59875949e-02f, 1.01873074e-02f,
  -5.17180748e-02f, 3.20242494e-01f, 1.19108975e-01f, 1.19717591e-01f, -1.67318480e-03f, 3.14048082e-01f, 1.29744157e-01f, 6.82716537e-03f, 9.00134295e-02f, 2.01329902e-01f,
  3.38565409e-02f, 1.78904325e-01f, -3.08324117e-02f, 1.39214486e-01f, -6.51267618e-02f, -5.16127609e-02f, 1.27043471e-01f, -1.84773048e-03f, 4.11775894e-02f, -3.17065604e-03f,
  -1.87775567e-02f, 6.78089559e-02f, -1.69841796e-02f, 9.37955827e-02f, 1.79175436e-01f, 1.61725581e-01f, -1.35915786e-01f, 1.16638370e-01f, 5.86668737e-02f, 5.78988306e-02f,
  -8.69695395e-02f, -1.19158193e-01f, 3.60691408e-03f, -7.78296031e-03f, -8.44657421e-02f, -4.86835092e-02f, -5.51998727e-02f, -4.80103074e-04f, 2.82673575e-02f, -1.88214350e-02f,
  6.46251440e-02f, 1.80676617e-02f, 5.46836667e-02f, 1.12690991e-02f, 8.50289539e-02f, -1.48950592e-02f, 7.19720647e-02f, 9.53280032e-02f, 3.47757898e-02f, 2.77482625e-02f,
  7.72257447e-02f, 1.06821381e-01f, 7.13974163e-02f, 4.89980206e-02f, 1.46009435e-03f, 3.49253640e-02f, -2.01107282e-02f, 3.41660380e-02f, 8.96778256e-02f, -1.71877909e-02f,
  2.52829790e-02f, -9.04330984e-02f, 5.78539744e-02f, 4.37157648e-03f, 1.70365982e-02f, -5.11454605e-02f, 1.46337366e-02f, -2.76925359e-02f, 3.53202671e-02f, -1.37959253e-02f,
  5.76826930e-02f, 2.39336900e-02f, -6.26264662e-02f, 6.45682141e-02f, -3.53246480e-02f, -1.22125205e-02f, -4.34769578e-02f, 4.19639125e-02f, -1.61814690e-03f, 2.13145185e-02f,
  1.20682064e-02f, 4.77979220e-02f, 1.58115830e-02f, 3.34666818e-02f, 3.13839801e-02f, 3.36999446e-02f, 1.64462067e-02f, 8.64561200e-02f, -5.95972240e-02f, 1.19637176e-02f,
  -2.95464471e-02f, -1.08906619e-01f, -1.08961482e-02f, -5.09109758e-02f, -5.08926548e-02f, 1.95050631e-02f, 4.37105959e-03f, 4.12992276e-02f, -5.01841456e-02f, -5.54442964e-02f,
  -9.67088863e-02f, -5.34797460e-02f, -6.86815828e-02f, -1.20474109e-02f, 2.59757563e-02f, 1.69462431e-02f, -9.32377577e-03f, 2.07996201e-02f, -1.11927395e-03f, 8.76854360e-02f,
  1.58454645e-02f, -4.80415188e-02f, -3.47284488e-02f, -1.73920095e-02f, 4.46354114e-02f, 3.80189717e-02f, -1.48754921e-02f, 4.19686697e-02f, -6.31233677e-02f, 3.01580448e-02f,
  3.04868907e-01f, -8.25607926e-02f, -2.19758675e-01f, 1.17864363e-01f, 9.51643288e-02f, 1.89684331e-01f, -1.87059976e-02f, 1.87573224e-01f, 3.53831574e-02f, 4.05703112e-02f,
  1.39603570e-01f, -2.73284167e-01f, -3.22253138e-01f, 2.12804422e-01f, 1.26231134e-01f, -1.32774517e-01f, 2.10314140e-01f, -2.96681188e-02f, -3.63201499e-02f, 7.30511174e-02f,
  -9.94730741e-03f, 2.27055073e-01f, -1.40304178e-01f, 6.61042631e-02f, 7.27078989e-02f, -4.23543714e-03f, 1.59464002e-01f, -2.38483608e-01f, 1.66790500e-01f, 4.72184978e-02f,
  6.45764321e-02f, -2.94431709e-02f, -1.29609294e-02f, -2.62302887e-02f, 9.43179354e-02f, -1.64556652e-02f, -3.78517929e-04f, -1.30653769e-01f, -6.73084185e-02f, -2.07574684e-02f,
  -4.32715826e-02f, -2.54567061e-02f, -3.14730033e-03f, -3.81079689e-02f, 1.37474630e-02f, 3.67861539e-02f, -1.77869536e-02f, 4.94840182e-02f, 2.91981902e-02f, -1.00875445e-01f,
  -3.61703560e-02f, -6.20567165e-02f, -4.39795628e-02f, -4.99985218e-02f, -9.89429280e-02f, 7.62732029e-02f, 2.08364753e-03f, -9.10841152e-02f, 3.07680313e-02f, 5.71694709e-02f,
  1.13153234e-02f, -9.76688191e-02f, -2.53253244e-02f, 1.57913733e-02f, 2.88183684e-03f, 8.37644860e-02f, -2.78129745e-02f, 4.36929874e-02f, 6.72520101e-02f, 1.73807738e-03f,
  -3.50546278e-02f, -1.29374163e-02f, 3.99306640e-02f, -6.53028786e-02f, 3.19128670e-02f, 2.33857501e-02f, -1.65590420e-02f, 1.47715583e-02f, 4.87112217e-02f, 2.04177981e-04f,
  7.43563008e-03f, -2.42622849e-03f, -3.84396538e-02f, -4.45426367e-02f, -4.07947898e-02f, -2.90214587e-02f, -1.93372481e-02f, 4.62774336e-02f, -1.43728433e-02f, 5.69468066e-02f,
  3.26182097e-02f, 1.24913462e-01f, 2.11334229e-02f, 3.20209004e-02f, -3.63645107e-02f, 8.59912187e-02f, -6.02072179e-02f, -2.60333382e-02f, 3.85276899e-02f, -3.54909562e-02f,
  5.16222194e-02f, -5.92790060e-02f, 5.58694527e-02f, -7.20689865e-03f, 4.29527648e-02f, 4.74257134e-02f, -4.60972637e-02f, 1.50331957e-02f, 5.22066578e-02f, 5.29251471e-02f,
  -1.06622517e-01f, -2.63514500e-02f, 1.49366101e-02f, 5.56709357e-02f, 6.32657632e-02f, -3.85708399e-02f, 1.97677836e-02f, 2.77209654e-02f, 7.22504854e-02f, -9.88120884e-02f,
  -1.18839256e-01f, 6.85135946e-02f, -2.28399903e-01f, -1.03018761e-01f, 8.37847218e-02f, -3.52019705e-02f, -3.02073479e-01f, 6.20140880e-02f, -2.33545825e-01f, 1.66667551e-01f,
  2.51823634e-01f, -1.74660549e-01f, 1.00541219e-01f, 1.37172669e-01f, -8.44691321e-02f, -6.14326000e-02f, -3.83493258e-03f, 6.16736934e-02f, -1.29565120e-01f, 2.06426270e-02f,
  -1.19552746e-01f, 1.60152346e-01f, -9.11957026e-02f, 1.42953947e-01f, 5.53602539e-02f, -2.95763891e-02f, 1.57964513e-01f, 6.01532403e-03f, 1.68067336e-01f, 3.75992097e-02f,
  5.65734766e-02f, 7.96805918e-02f, -1.13768928e-01f, -1.48736104e-01f, 9.43065062e-02f, 2.91949343e-02f, -9.91963968e-02f, -8.11056718e-02f, -1.09575409e-02f, -4.51035053e-02f,
  -2.35718451e-02f, 3.23311426e-02f, 9.95135214e-03f, -8.91128555e-03f, -4.72825021e-02f, -1.25132293e-01f, -5.59932590e-02f, -6.49639368e-02f, -1.20114461e-01f, 4.96459864e-02f,
  -1.01089098e-01f, -1.38306664e-02f, 7.97991902e-02f, -5.47519661e-02f, -1.86093934e-02f, -7.88168982e-02f, -1.82709545e-02f, -1.15065180e-01f, -8.90517980e-02f, -9.48153064e-02f,
  -8.82624239e-02f, -4.14466560e-02f, -3.38335382e-03f, 1.27902851e-01f, -5.28731197e-02f, 1.03516795e-01f, -4.47976738e-02f, 6.07508048e-02f, -7.23174587e-02f, 9.92006809e-02f,
  1.09814256e-01f, 3.95207256e-02f, -9.92609281e-03f, -2.30021663e-02f, -2.44456008e-02f, 4.93992530e-02f, -6.16502203e-02f, 1.02735810e-01f, -4.76937369e-02f, -4.46905335e-03f,
  -2.76425090e-02f, 1.64319742e-02f, 2.26032492e-02f, 1.22582400e-02f, -6.86640888e-02f, -1.08083393e-02f, 2.32052933e-02f, 1.63613365e-03f, -4.77121724e-03f, -4.91131376e-03f,
  2.51831263e-01f, 7.60461092e-02f, -6.58646598e-03f, -5.66003583e-02f, 2.34916322e-02f, 3.29931118e-02f, -4.49235253e-02f, 1.01949334e-01f, -8.82683843e-02f, -8.04808959e-02f,
  -7.81950057e-02f, 7.16080740e-02f, 8.83941725e-02f, 3.65835354e-02f, -3.34028713e-03f, -3.54076037e-03f, -3.58317979e-03f, -1.09024474e-03f, 3.18373851e-02f, 4.87928726e-02f,
  7.03607947e-02f, 3.20801586e-02f, -9.86167938e-02f, 8.31682533e-02f, 7.16096982e-02f, 3.01264003e-02f, -9.68336910e-02f, -3.52933183e-02f, 1.26441464e-01f, -7.70323873e-02f,
  7.75925294e-02f, 2.72551123e-02f, -4.25312042e-01f, -1.43792545e-02f, -9.40621421e-02f, 8.02635103e-02f, 3.55695002e-02f, 4.37200516e-02f, 4.72469665e-02f, 1.82037741e-01f,
  -6.25190958e-02f, 1.64951198e-03f, 6.56245127e-02f, 4.88681458e-02f, 9.34261754e-02f, 1.35350928e-01f, 1.75185964e-01f, -3.46023776e-02f, -1.13616221e-01f, 2.04873923e-02f,
  -1.10287615e-03f, 1.48666382e-01f, -4.58869152e-02f, -5.23172431e-02f, -6.41781315e-02f, -6.71352968e-02f, 3.79301645e-02f, -2.10941106e-01f, 2.62240805e-02f, -6.25768453e-02f,
  1.77389458e-01f, -7.17501119e-02f, -2.46524252e-02f, 3.99913304e-02f, 1.25101656e-02f, 2.30897237e-02f, -6.56459183e-02f, -1.12329423e-01f, -6.24844246e-03f, 6.75917566e-02f,
  2.29205079e-02f, -6.84112161e-02f, 8.76591951e-02f, 1.79431716e-03f, 6.86170682e-02f, -8.29160362e-02f, -1.33782672e-02f, 3.85552160e-02f, -2.38866918e-02f, -1.55287907e-02f,
  -7.55131766e-02f, 5.55325300e-03f, -4.90813553e-02f, 1.02522923e-02f, -3.70324999e-02f, -3.84862423e-02f, 1.40772245e-04f, -2.48775061e-04f, 4.84732836e-02f, 4.95603792e-02f,
  -1.67320490e-01f, 4.35392512e-03f, -1.04915546e-02f, -4.32587713e-02f, 1.55875022e-02f, -2.85088401e-02f, 9.32236016e-02f, 1.58460229e-04f, -5.35246916e-02f, -1.44030061e-02f,
  -2.46310700e-02f, -3.56114879e-02f, -4.01308946e-02f, -1.49148917e-02f, -5.02907485e-02f, 2.88621429e-02f, -5.14007732e-02f, 5.53760789e-02f, -2.95634978e-02f, -2.78286114e-02f,
  1.44965611e-02f, 1.93325970e-02f, -8.67953822e-02f, -4.84902002e-02f, -1.82421003e-02f, -1.93850100e-02f, 2.76413038e-02f, -6.16067611e-02f, 3.08302436e-02f, 4.16064188e-02f,
  2.87890255e-01f, 9.03545879e-03f, -3.89917642e-02f, 2.55486593e-02f, -6.92272186e-03f, 2.49503441e-02f, -3.89323495e-02f, 5.69396727e-02f, 2.06910446e-02f, 1.32146329e-01f,
  1.11080721e-01f, 5.23615368e-02f, -7.27373292e-04f, -2.33531091e-02f, -4.11109626e-02f, 2.01805364e-02f, 3.56632993e-02f, 2.55430359e-02f, 1.05872490e-01f, -2.68966146e-02f,
  1.07480854e-01f, -5.99464728e-03f, -4.99141589e-03f, 1.25891222e-02f, -5.23468666e-02f, 2.96238866e-02f, 4.85528149e-02f, -1.04521036e-01f, -2.39431318e-02f, 3.73153500e-02f,
  -3.84428382e-01f, 1.23641983e-01f, -3.02462786e-01f, -1.38766706e-01f, -2.90223528e-02f, 4.78154141e-03f, -2.35094994e-01f, 7.65381195e-03f, -2.96254337e-01f, 1.15042694e-01f,
  -2.06746277e-03f, -2.02557236e-01f, -1.96987078e-01f, 2.69864738e-01f, -1.31602794e-01f, -1.46294773e-01f, 2.11862773e-01f, -5.34205139e-03f, -5.62814847e-02f, 3.34900171e-02f,
  -6.46235934e-03f, 1.08230144e-01f, -6.10954463e-02f, 1.92657590e-01f, -1.91543400e-01f, 4.82842214e-02f, 1.51919052e-01f, -2.75340211e-02f, 3.38045865e-01f, 1.04236625e-01f,
  9.69262347e-02f, -1.84714988e-01f, -9.68063308e-04f, -1.50957098e-02f, -7.08740726e-02f, 1.94796249e-02f, 7.18599781e-02f, 6.21525198e-02f, -3.13616954e-02f, 1.09645255e-01f,
  -8.72460008e-02f, -3.27171460e-02f, -4.40014852e-03f, -2.55918968e-02f, 3.22724436e-03f, 6.92736506e-02f, 3.34635302e-02f, 2.84728059e-03f, -2.93513807e-03f, -8.45635384e-02f,
  -7.80246705e-02f, 2.77100597e-02f, -1.00820407e-01f, 4.93461192e-02f, -5.98429982e-03f, 1.80465132e-02f, -1.04333498e-02f, 4.05768817e-03f, 9.40820947e-02f, -2.99136881e-02f,
  -6.88187331e-02f, -7.51978811e-03f, -2.74587460e-02f, -7.31160790e-02f, 4.68233302e-02f, -1.04667090e-01f, 2.24980153e-02f, 1.59741408e-04f, -4.56940383e-02f, 1.46649210e-02f,
  -6.58165216e-02f, -6.88085845e-03f, -4.87820916e-02f, -1.57933775e-02f, -3.00979093e-02f, -1.33858575e-02f, 2.13113427e-02f, -3.03604640e-02f, -3.85296196e-02f, -5.60879102e-03f,
  -5.55281155e-02f, 7.71960057e-03f, 4.42308709e-02f, -4.00682613e-02f, 2.14973167e-02f, -1.95326880e-02f, 5.26751280e-02f, -2.70718634e-02f, 1.00789210e-02f, 2.22994592e-02f,
  -5.39869852e-02f, 2.75114775e-02f, 7.80072622e-03f, 5.33007877e-03f, -4.99558188e-02f, 5.81883825e-02f, -7.77877215e-03f, 6.74806610e-02f, 9.90988035e-03f, -9.70814824e-02f,
  -3.56436870e-03f, 2.95973439e-02f, -8.09448597e-04f, -2.24300157e-02f, 1.83422081e-02f, -1.05042145e-01f, -1.75646022e-02f, 5.83379492e-02f, -2.65707099e-03f, 4.70162071e-02f,
  6.96187690e-02f, -9.27416459e-02f, 4.67353873e-02f, -4.26448584e-02f, 4.81697880e-02f, -1.07088611e-01f, 1.35243195e-03f, 1.83363166e-02f, 2.91283559e-02f, 2.21124813e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.86190003e-01f, 5.29483080e-01f, 1.59029007e-01f, -9.56256688e-02f, -9.36606061e-03f, -1.74396113e-01f, -1.45583570e-01f, -4.18897631e-04f, 5.27057610e-02f, -3.93294282e-02f,
  -3.97258073e-01f, 2.50534117e-01f, -7.42284656e-02f, -1.13991268e-01f, -4.91539598e-01f, -5.88851515e-03f, -1.95103332e-01f, -5.08144610e-02f, 1.68607324e-01f, -9.38559789e-03f,
  -5.29775098e-02f, -1.90314069e-01f, 1.44617036e-02f, 1.82352558e-01f, 1.26940414e-01f, 2.55156886e-02f, -2.12689206e-01f, 2.20188107e-02f, -5.26955314e-02f, -7.55507872e-02f,
  2.25896649e-02f, -1.46772331e-02f, -1.45493038e-02f, -1.83851353e-03f, -1.16549112e-01f, -1.57385767e-01f, -6.95399418e-02f, -1.40224531e-01f, -8.62590969e-02f, 2.61266548e-02f,
  8.49103406e-02f, -6.38477057e-02f, -5.97866923e-02f, 2.97856666e-02f, 2.87235118e-02f, -2.32156739e-02f, -2.98733683e-03f, 7.51458704e-02f, 8.84600505e-02f, 5.87929264e-02f,
  1.10074982e-01f, 2.31228378e-02f, -6.23133406e-02f, 2.21607015e-02f, -3.06233615e-02f, 2.28048693e-02f, -7.22397417e-02f, 2.28326190e-02f, -5.59018031e-02f, 6.63376995e-04f,
  1.44454852e-01f, -8.58903453e-02f, -1.47527196e-02f, -5.76062389e-02f, -1.23581663e-02f, -7.41333095e-03f, 3.41716483e-02f, -3.41581739e-02f, 3.27626639e-03f, -7.85795078e-02f,
  -7.25104213e-02f, 3.09168901e-02f, -6.42717928e-02f, 2.61332560e-02f, -3.62288244e-02f, 2.28357706e-02f, -2.09912676e-02f, 1.15663856e-02f, -4.30007689e-02f, -3.63254244e-03f,
  -3.23485024e-02f, -5.17135747e-02f, 3.23690735e-02f, -6.03398010e-02f, -7.50955893e-03f, 2.69172024e-02f, -1.23957150e-01f, 7.23440871e-02f, 3.46013047e-02f, -3.32544670e-02f,
  -2.35036016e-01f, -2.21607417e-01f, -1.24001518e-01f, 2.17247456e-02f, 2.66390014e-03f, 4.59535159e-02f, -6.37057498e-02f, -4.86207791e-02f, 1.06415721e-02f, 4.74822149e-02f,
  -7.42738098e-02f, -9.41973999e-02f, 4.55457193e-04f, -3.98631543e-02f, -9.72225983e-03f, -1.80253554e-02f, -7.07856715e-02f, -9.76632442e-03f, -1.40068531e-01f, 2.88959444e-02f,
  9.03066471e-02f, 2.32393779e-02f, 2.88136136e-02f, 6.55933283e-04f, -3.12130470e-02f, -2.00704932e-01f, 1.49941696e-02f, 9.47359670e-03f, -7.14596584e-02f, 1.16059473e-02f,
  -5.10464907e-01f, 4.15720373e-01f, -2.29704872e-01f, -1.15261316e-01f, -6.41293153e-02f, 3.71316940e-01f, 2.94367313e-01f, -1.00762844e-02f, 4.31801677e-02f, 3.43912959e-01f,
  1.18573569e-01f, -1.55652627e-01f, 2.30079591e-01f, 1.92039520e-01f, -2.22748414e-01f, 4.01657909e-01f, 2.69818932e-01f, 2.84930855e-01f, 6.77919835e-02f, -1.16834402e-01f,
  -1.16525598e-01f, 2.20082968e-01f, 3.69158573e-02f, 5.31241298e-02f, -2.13617846e-01f, -3.04296166e-01f, -1.75348315e-02f, -9.97991189e-02f, -1.60409838e-01f, 3.18956487e-02f,
  1.17805384e-01f, -1.03529148e-01f, -6.16931580e-02f, -6.31574728e-03f, 4.15498111e-03f, 8.02007131e-03f, -4.86010406e-03f, -3.77547294e-02f, -9.32988599e-02f, -9.20282770e-03f,
  -1.65676288e-02f, 3.14513710e-03f, 6.15465119e-02f, 2.48717424e-02f, -1.49887279e-01f, 3.53946835e-02f, 1.37073342e-02f, -3.36913802e-02f, 6.00508675e-02f, -3.15144621e-02f,
  -3.01316082e-02f, 8.01079720e-03f, -3.25776599e-02f, 1.37874382e-02f, -4.78374660e-02f, -3.26200202e-02f, 8.32104608e-02f, -1.07872859e-02f, 5.60216233e-03f, 3.85363251e-02f,
  -7.34167099e-02f, 1.03456061e-02f, 4.35549691e-02f, 2.50187255e-02f, 3.26545240e-04f, -2.28939038e-02f, 2.63743941e-02f, 3.72718461e-02f, -2.22580004e-02f, 2.14826148e-02f,
  6.29185885e-02f, -1.00086771e-01f, -4.38265279e-02f, 1.60303228e-02f, 1.29392177e-01f, 1.97850894e-02f, 3.94161604e-02f, 4.35724147e-02f, 1.84223857e-02f, 3.23559865e-02f,
  9.31913182e-02f, -1.26747608e-01f, 2.17391457e-02f, 8.82338807e-02f, 2.08132132e-03f, -1.73025597e-02f, -7.70279090e-04f, -8.89851339e-03f, 1.11121558e-01f, -5.77230938e-02f,
  1.21685199e-01f, -1.75628930e-01f, 7.72166923e-02f, 1.19414933e-01f, 3.47879305e-02f, -9.54409838e-02f, -2.30594091e-02f, -1.05653092e-01f, -3.96795087e-02f, -5.74777201e-02f,
  -2.49425136e-03f, 1.26935542e-02f, -2.12088991e-02f, -2.77989563e-02f, 1.38992034e-02f, 1.07187785e-01f, 5.64022698e-02f, 1.73471831e-02f, 8.46508332e-03f, 5.82755096e-02f,
  -6.27115592e-02f, 3.11472416e-02f, -5.54802381e-02f, 2.26440579e-02f, -1.58805810e-02f, 5.79158356e-03f, -1.20538019e-01f, -3.93524915e-02f, -1.04812212e-01f, 9.48652104e-02f,
  -2.47958601e-02f, 7.48571660e-03f, -4.09087576e-02f, -2.48495936e-02f, 1.15892850e-01f, -1.58029884e-01f, -2.11642776e-02f, 3.70365717e-02f, -1.91546664e-01f, 3.26343402e-02f,
  9.57724154e-02f, 6.94590658e-02f, 2.51990855e-02f, -1.59419268e-01f, -4.76901978e-02f, -2.49013275e-01f, -4.11711335e-02f, -6.24231715e-03f, -1.72878623e-01f, 2.66074538e-01f,
  -9.84981656e-03f, 1.01246685e-01f, 1.04722241e-02f, 1.64403141e-01f, -4.37278813e-03f, 4.76260707e-02f, 3.26165527e-01f, 7.92643279e-02f, 5.70169464e-02f, -5.98535500e-02f,
  -5.24729192e-02f, 2.44249478e-02f, -1.08481057e-01f, -8.57836083e-02f, 1.70819387e-01f, 1.77340299e-01f, 2.17880029e-02f, -1.99246779e-01f, -6.01486340e-02f, -1.19886417e-02f,
  -7.82125443e-03f, -8.34813714e-02f, 2.07375325e-02f, -3.62441577e-02f, 1.95110012e-02f, -1.46874376e-02f, -6.38945475e-02f, -5.67893386e-02f, 6.99039176e-02f, -1.12594990e-02f,
  -6.65156245e-02f, -6.52213639e-04f, -6.36965334e-02f, -1.25833657e-02f, 3.24234134e-03f, 2.27733552e-02f, -5.09049073e-02f, 1.50996715e-01f, -5.20653166e-02f, 8.76204763e-03f,
  1.28183216e-01f, 1.03573985e-01f, 8.40564072e-03f, -9.93344113e-02f, 1.28063159e-02f, -1.26169063e-02f, -7.06419051e-02f, -2.77160965e-02f, -7.10814819e-02f, -3.57633159e-02f,
  -2.76045762e-02f, -5.71518168e-02f, -9.54504963e-03f, 2.68998146e-02f, 1.28017038e-01f, -3.08491234e-02f, -4.59408797e-02f, 6.76287478e-03f, 1.31159768e-01f, -8.65508690e-02f,
  -1.27493396e-01f, 8.94173235e-03f, 2.33758576e-02f, -6.66303262e-02f, -1.38059974e-01f, 7.78916851e-02f, 1.53726324e-01f, -7.41094947e-02f, -2.03940701e-02f, -1.18773547e-03f,
  1.22788511e-01f, 1.56995103e-01f, -3.11819855e-02f, -2.31213961e-02f, 4.04160134e-02f, -5.39954118e-02f, -4.32864428e-02f, 2.21472308e-02f, -1.48675898e-02f, 2.70909611e-02f,
  1.26384079e-01f, -3.42609994e-02f, 2.91841440e-02f, 1.60147175e-02f, -9.00551826e-02f, 7.88250491e-02f, 2.43964139e-02f, -4.49825972e-02f, 1.74285471e-02f, 1.46094739e-01f,
  1.34118229e-01f, 3.16130556e-02f, -4.75233868e-02f, 1.38911651e-02f, 8.32142606e-02f, -8.63920897e-03f, -7.42933378e-02f, 5.95369264e-02f, -3.10083814e-02f, -7.04158023e-02f,
  1.67760104e-01f, 3.59577447e-01f, 2.77592629e-01f, 1.37568951e-01f, -2.20856089e-02f, -1.27206385e-01f, -1.97937146e-01f, 4.08057570e-02f, 7.82070234e-02f, 1.25672042e-01f,
  -2.09634885e-01f, 4.20943826e-01f, -1.65657848e-01f, 5.98631203e-02f, -3.24494004e-01f, -2.47257829e-01f, -1.75871938e-01f, 9.22482982e-02f, -1.66486457e-01f, 2.77739596e-02f,
  -1.61073104e-01f, -3.15821946e-01f, -1.18472418e-02f, -1.71782985e-01f, 1.92425251e-01f, 2.47067228e-01f, -8.02571252e-02f, -1.18476361e-01f, 3.16469312e-01f, 5.03788330e-02f,
  5.42926304e-02f, 1.56735063e-01f, 1.69092923e-01f, 1.33352667e-01f, 6.80453405e-02f, -2.95774713e-02f, 1.52959689e-01f, 2.70105917e-02f, 4.65137651e-03f, 3.90381701e-02f,
  9.75120664e-02f, -7.51260221e-02f, 8.18445832e-02f, -3.63839231e-02f, 1.17545404e-01f, 1.08065061e-01f, 1.21721797e-01f, 6.72204942e-02f, 1.05591938e-01f, 1.01953916e-01f,
  5.32214157e-02f, 1.25593945e-01f, -9.42890272e-02f, 4.18916754e-02f, 4.93039563e-02f, -9.75258052e-02f, 9.11235064e-02f, 5.86062483e-02f, 1.51266277e-01f, -6.62363181e-03f,
  -4.02385406e-02f, -7.30615631e-02f, -1.67741086e-02f, 5.82300015e-02f, -3.99097949e-02f, 1.88271627e-02f, 3.04587204e-02f, -8.79593790e-02f, 3.20174582e-02f, -4.50746827e-02f,
  -2.98880562e-02f, -2.74390262e-02f, -2.64020711e-02f, -1.20519646e-01f, -2.37156786e-02f, 2.75841355e-02f, -2.42121741e-02f, 1.18667132e-03f, -2.67355200e-02f, -2.78238803e-02f,
  5.99520691e-02f, -5.88635094e-02f, -2.79793981e-02f, 6.99486211e-03f, -8.57402980e-02f, -3.17026116e-02f, 9.96065792e-04f, 1.53470959e-03f, 3.33250947e-02f, -9.44126397e-02f,
  -7.99413472e-02f, -1.00482605e-01f, -2.29199361e-02f, 3.11013740e-02f, 1.03504106e-01f, 4.91438285e-02f, -7.13326335e-02f, -1.02679450e-02f, 8.00212696e-02f, -1.42354285e-02f,
  4.22503166e-02f, 5.56577072e-02f, -8.63350704e-02f, -2.20727902e-02f, -9.96841118e-02f, -6.83649257e-02f, -5.50936311e-02f, 5.00978455e-02f, -8.55082050e-02f, -2.42993813e-02f,
  4.27331729e-03f, 4.11949717e-02f, -9.24061760e-02f, -4.52148207e-02f, 1.06779858e-02f, 4.65863422e-02f, 3.27965580e-02f, 4.65374859e-03f, -6.48786779e-04f, 1.17942030e-02f,
  -1.39051884e-01f, -6.19949177e-02f, -2.73488343e-01f, -3.20645601e-01f, -1.73673164e-02f, -2.56416321e-01f, -3.22553933e-01f, -9.78133753e-02f, 6.28812760e-02f, 2.47085005e-01f,
  -4.14040051e-02f, -1.59116816e-02f, 7.74669796e-02f, -3.14218789e-01f, -2.17244670e-01f, -6.04842789e-02f, -3.58749002e-01f, -1.85704634e-01f, 1.07520156e-01f, -2.44711682e-01f,
  -1.06364936e-01f, -2.18837216e-01f, -2.53232419e-01f, 4.20225523e-02f, -2.67202705e-01f, 7.19432831e-02f, 3.23796183e-01f, 1.07199229e-01f, -2.22958565e-01f, 5.72562311e-03f,
  -1.38660267e-01f, 6.00326853e-03f, -1.75019093e-02f, 4.03734855e-02f, -2.72385869e-02f, -5.12863137e-02f, 4.27021384e-02f, -4.69930209e-02f, -7.34618574e-04f, -8.80198032e-02f,
  -6.67869486e-03f, 9.54979584e-02f, -8.44259337e-02f, 1.29158432e-02f, -7.47745857e-02f, 1.96895972e-02f, -2.75812633e-02f, 3.68564837e-02f, -8.10972676e-02f, -1.43356532e-01f,
  -1.83526263e-01f, -4.11316939e-02f, -1.17087755e-02f, 1.76224690e-02f, -1.07308067e-01f, 2.09044199e-02f, -4.68955114e-02f, -2.54324749e-02f, 1.96591448e-02f, 4.25944515e-02f,
  -2.58921105e-02f, 1.79656502e-02f, 2.97237635e-02f, 1.57075636e-02f, 2.09222585e-02f, 4.43459786e-02f, -2.26036403e-02f, 2.98005082e-02f, 2.81742569e-02f, 3.60195618e-03f,
  6.93375990e-02f, 5.22806905e-02f, -6.26968453e-03f, -8.74408856e-02f, -9.50212404e-02f, 5.27071506e-02f, 8.35785419e-02f, 1.18137999e-02f, -5.42637408e-02f, 1.61670579e-03f,
  -9.73291870e-04f, 2.12366530e-03f, 6.32604957e-02f, 1.43259559e-02f, -4.72120382e-02f, 2.37426646e-02f, 5.34100197e-02f, 3.53109129e-02f, -2.29813512e-02f, -4.85573076e-02f,
  1.13426866e-02f, 9.69335660e-02f, 8.10992569e-02f, 3.79285812e-02f, 1.94371003e-03f, 5.35110198e-02f, -4.17169183e-02f, -8.79181176e-02f, -2.18525119e-02f, 5.75931370e-02f,
  -1.31308734e-02f, -4.44503129e-02f, 7.13720918e-02f, -5.04743261e-03f, 5.71693368e-02f, 5.56134470e-02f, 2.98632178e-02f, 1.11575238e-01f, 1.63447969e-02f, 6.32210970e-02f,
  5.17190509e-02f, 7.67842308e-02f, 4.76332121e-02f, 2.21327320e-02f, -5.40833883e-02f, 7.01065511e-02f, 3.18429433e-02f, 2.77778623e-03f, 1.25552826e-02f, 5.11453822e-02f,
  7.16632381e-02f, 1.45795867e-01f, 2.82401413e-01f, 4.85564440e-01f, -2.99534353e-04f, -2.46233240e-01f, -2.01250583e-01f, 2.47484475e-01f, 1.46260753e-01f, -7.60672316e-02f,
  3.69176921e-03f, -6.97747320e-02f, -5.75204492e-02f, 1.36987254e-01f, 2.29667559e-01f, -7.39742653e-04f, 1.32442236e-01f, -7.12418854e-02f, 1.36208534e-01f, 9.16402563e-02f,
  1.64638594e-01f, 1.26544550e-01f, 1.62556142e-01f, 1.04531139e-01f, 1.15298651e-01f, 2.17166916e-01f, 2.76727140e-01f, 1.97200645e-02f, 1.47947535e-01f, -2.29567736e-02f,
  -4.19418961e-02f, -1.33662345e-03f, -6.33803830e-02f, -2.25606244e-02f, 8.00227597e-02f, -9.00560096e-02f, -2.78318673e-03f, -1.42823815e-01f, -1.64515413e-02f, -9.66541748e-03f,
  -6.65379912e-02f, 1.71355698e-02f, 8.98535177e-03f, 1.98020600e-02f, 1.55411253e-04f, 4.36868444e-02f, -3.24344868e-03f, 1.56998504e-02f, -4.69124690e-02f, -4.61568236e-02f,
  1.18641108e-02f, -4.59147319e-02f, -1.14416517e-02f, 1.37315840e-02f, 4.88390252e-02f, 1.63659547e-02f, 2.10361872e-02f, -3.73509191e-02f, 8.26369151e-02f, 5.23884185e-02f,
  -4.52505350e-02f, 4.36544903e-02f, -2.77078804e-02f, 1.97019987e-02f, 9.29290354e-02f, 3.23381424e-02f, 5.53736575e-02f, -2.07022801e-02f, 1.52516635e-02f, -6.42869323e-02f,
  1.20595209e-01f, 1.65985271e-01f, 3.05314399e-02f, -7.37165138e-02f, 9.58573893e-02f, -7.25868419e-02f, -2.00090241e-02f, -2.98425872e-02f, 6.13682754e-02f, 4.16828096e-02f,
  1.08210824e-01f, 1.01196598e-02f, 7.60732219e-02f, 1.12239886e-02f, 2.79598478e-02f, 9.32552665e-03f, 9.33488682e-02f, 8.83143321e-02f, 2.53052320e-02f, 6.87530711e-02f,
  1.82175990e-02f, 2.17826992e-01f, 9.47435200e-02f, -8.97049829e-02f, 7.44582061e-03f, -4.81101871e-02f, 3.14526297e-02f, 1.03422709e-01f, 1.18438751e-02f, 1.56583954e-02f,
  -7.49014840e-02f, -4.43871692e-03f, -1.10629639e-02f, -8.19897354e-02f, 7.51780868e-02f, -8.36710539e-03f, 3.20531167e-02f, 1.00461252e-01f, 1.29122525e-01f, 3.90843712e-02f,
  5.32585345e-02f, -2.23362967e-02f, -5.99566326e-02f, -1.05400933e-02f, -3.85393910e-02f, -1.08693749e-01f, -2.51098461e-02f, -3.70840430e-02f, 4.05497961e-02f, -3.00010517e-02f,
  2.63790011e-01f, 7.94037208e-02f, -2.73668617e-01f, -2.43577734e-02f, -1.81459576e-01f, -1.29932866e-01f, -7.47689530e-02f, -6.20588986e-03f, -1.81333259e-01f, 1.51555628e-01f,
  1.32746071e-01f, -9.96173266e-03f, 1.56944036e-01f, 2.32066676e-01f, 8.98710936e-02f, 3.57418060e-02f, 2.05117509e-01f, 3.99375968e-02f, 1.06811738e-02f, 2.27918923e-01f,
  1.00748420e-01f, 3.53577822e-01f, 1.06785119e-01f, 1.83925569e-01f, 1.53211191e-01f, 1.50948092e-02f, 1.15152135e-01f, -6.59706828e-04f, 1.43888265e-01f, 1.01310633e-01f,
  4.12043184e-02f, 1.00136414e-01f, 4.40714099e-02f, 1.01682030e-01f, 9.02773887e-02f, 2.15586811e-01f, 5.72020411e-02f, -1.93442143e-02f, -5.80591410e-02f, 2.20827665e-02f,
  6.77623972e-02f, -5.82806617e-02f, 7.09033906e-02f, -1.30966166e-03f, -7.54208341e-02f, -1.42835245e-01f, -4.48424630e-02f, -1.24622039e-01f, -1.09622046e-01f, 9.69895348e-02f,
  -2.99462657e-02f, -2.54887212e-02f, -1.74762964e-01f, -3.81672494e-02f, -5.49373813e-02f, 2.03456506e-02f, -7.71491900e-02f, -3.58574353e-02f, -7.46329576e-02f, -4.62489575e-02f,
  8.95461440e-02f, -3.80149111e-02f, 4.14487571e-02f, 3.99271585e-02f, 7.89694786e-02f, 1.35482438e-02f, -1.09609477e-02f, -3.97318695e-03f, -9.19580162e-02f, 7.91677013e-02f,
  -2.13651154e-02f, -6.54327050e-02f, 4.12817635e-02f, 5.13399020e-02f, -4.88070473e-02f, -1.24732545e-02f, 3.12104598e-02f, -2.77629271e-02f, -7.64996707e-02f, 3.90677527e-02f,
  3.24145635e-03f, 3.53211537e-02f, 8.92029107e-02f, 1.59385130e-01f, -4.33429778e-02f, -8.34046006e-02f, 6.30507395e-02f, 2.82729100e-02f, -1.41228959e-01f, -7.45651051e-02f,
  1.84748203e-01f, 1.43014282e-01f, 4.24739271e-02f, -2.99420021e-02f, 2.72445660e-02f, 3.78288589e-02f, 8.33894759e-02f, 1.00438103e-01f, 8.81043822e-02f, 2.34850962e-02f,
  2.63777431e-02f, -5.86923398e-02f, 3.52182873e-02f, -3.42025682e-02f, -2.24566236e-02f, 9.25961062e-02f, 1.36172287e-02f, 6.19588085e-02f, -5.43362685e-02f, 3.49266687e-03f,
  6.12902008e-02f, 8.67778584e-02f, -2.35904586e-02f, -1.08904347e-01f, -9.30025280e-02f, 1.90113171e-03f, 3.76884006e-02f, -1.55241862e-01f, -6.79313317e-02f, 5.99278845e-02f,
  2.96775490e-01f, 1.81180120e-01f, 6.15170635e-02f, 2.77477622e-01f, 2.76883662e-01f, 2.87488014e-01f, 3.57125252e-01f, 1.86458126e-01f, 5.38091481e-01f, -4.86828350e-02f,
  -7.89295211e-02f, 5.58829270e-02f, -4.00082506e-02f, -2.41151806e-02f, 1.34039268e-01f, -1.31683163e-02f, 2.32917815e-01f, 8.66323560e-02f, 2.82932758e-01f, 4.64894138e-02f,
  7.31249452e-02f, 6.57907426e-02f, -3.17661732e-01f, -1.29439533e-01f, -4.99144644e-02f, -6.88253194e-02f, -3.37528586e-01f, -4.07387465e-02f, -1.48310602e-01f, 2.04539504e-02f,
  1.49724809e-02f, 5.38552701e-02f, 1.57481190e-04f, -2.91777253e-02f, 9.12950374e-03f, -2.18722671e-02f, -6.82164133e-02f, 1.89131387e-02f, 4.06401046e-02f, 9.50635150e-02f,
  6.10201769e-02f, 2.35017650e-02f, -1.43248262e-02f, 2.98463833e-02f, 8.38495269e-02f, -1.99360568e-02f, 3.24248187e-02f, -7.75260404e-02f, -1.51285098e-03f, 1.66290551e-02f,
  -9.79140997e-02f, -1.81263983e-02f, -6.83943704e-02f, 6.41867891e-03f, 4.35708836e-02f, -2.36222222e-02f, 4.23791222e-02f, -2.75223553e-02f, 7.85683244e-02f, 1.87836111e-01f,
  -4.88336058e-03f, 7.81044737e-02f, -2.47958228e-02f, -3.41261476e-02f, -1.11734588e-03f, -1.11696377e-01f, 1.45812761e-02f, -7.78515860e-02f, 4.49831374e-02f, -3.35070933e-03f,
  -3.34346830e-03f, 3.52261262e-03f, -5.62598146e-02f, 9.64362621e-02f, 3.93638760e-02f, 3.64279607e-03f, 4.32517231e-02f, 2.12875847e-02f, -3.64004336e-02f, -4.73799407e-02f,
  9.71688796e-03f, 2.45301705e-02f, -9.71233379e-03f, -1.27818352e-02f, -6.19734749e-02f, 6.44730479e-02f, 1.75606683e-02f, 4.23420519e-02f, 2.35485360e-02f, -2.55530197e-02f,
  2.45173857e-01f, 3.08689475e-01f, 2.34953854e-02f, -2.68271398e-02f, -2.01804917e-02f, -8.75915140e-02f, 8.55303034e-02f, 5.09716459e-02f, 2.93225646e-02f, 3.32588255e-02f,
  1.78106166e-02f, -6.22159895e-03f, -4.00030836e-02f, -7.92859346e-02f, -1.10069141e-01f, 9.62396897e-03f, -4.29395624e-02f, 5.43005876e-02f, -4.02776431e-03f, 1.29477531e-02f,
  -3.07985619e-02f, 1.06357060e-01f, 3.75308919e-05f, -8.68418589e-02f, -3.33270170e-02f, -9.30666625e-02f, 2.93717962e-02f, 4.79908884e-02f, -2.38916595e-02f, -7.93684926e-03f,
  -1.09684892e-01f, 2.05823183e-01f, 5.34273721e-02f, 4.21947509e-01f, -2.67370760e-01f, -1.37454465e-01f, -3.23594846e-02f, 7.52475625e-03f, -1.69324819e-02f, 2.12687120e-01f,
  1.13797374e-01f, 8.47746711e-03f, 1.11779250e-01f, 2.57834971e-01f, -1.22080827e-02f, 2.21640334e-01f, 1.37005955e-01f, 2.26282626e-02f, 5.50345555e-02f, 1.55975014e-01f,
  1.50451392e-01f, 1.44717678e-01f, 2.60685742e-01f, 1.10978477e-01f, 1.41651451e-03f, 9.48394015e-02f, 1.83849066e-01f, -7.22818077e-02f, 2.33665302e-01f, 1.28357457e-02f,
  -9.72485868e-05f, 6.27737343e-02f, -9.53545272e-02f, -6.05965480e-02f, 6.16880767e-02f, -4.17835228e-02f, -7.22314417e-02f, 3.58030722e-02f, -2.21571233e-02f, 4.54436615e-02f,
  -8.91180411e-02f, -3.16512138e-02f, -5.19278347e-02f, 6.53331950e-02f, -8.32385197e-02f, 1.39949434e-02f, -5.82727492e-02f, 5.00420816e-02f, 1.09932823e-02f, -1.05091125e-01f,
  3.15057412e-02f, 9.55438465e-02f, 3.42947207e-02f, 3.07506081e-02f, 4.71511157e-03f, -4.12455797e-02f, 1.06866695e-01f, -4.32283543e-02f, 8.25161301e-03f, -3.70232537e-02f,
  5.44347893e-03f, 5.48570529e-02f, -2.15412118e-02f, 9.02827177e-03f, -1.19578494e-02f, -1.53682726e-02f, 4.01796401e-02f, -1.34837721e-02f, -1.44964587e-02f, 6.67421147e-02f,
  3.12602632e-02f, -2.11085230e-02f, 4.40955535e-02f, 8.98488909e-02f, -7.37625174e-03f, 4.49774154e-02f, -4.63143848e-02f, -1.33784034e-03f, 1.14646062e-01f, -3.36086228e-02f,
  -6.99551171e-03f, -1.68024972e-02f, 2.69100629e-02f, -8.36527161e-03f, 7.44152954e-03f, 1.87847670e-02f, 1.03849523e-01f, 6.42330870e-02f, 6.23858571e-02f, -3.02010356e-03f,
  3.11498512e-02f, 2.58383930e-01f, 1.42468020e-01f, -1.01303458e-01f, -5.14941998e-02f, -1.42516857e-02f, 3.94806229e-02f, -2.10577007e-02f, 8.40555280e-02f, 5.26778437e-02f,
  9.59125999e-03f, -4.76134419e-02f, -5.94042540e-02f, -2.81431098e-02f, -1.87951904e-02f, 3.45241427e-02f, 2.76836026e-02f, -3.37503548e-03f, 3.50358076e-02f, 7.03696609e-02f,
  4.34482377e-03f, -2.43582465e-02f, 6.79195821e-02f, 2.43335241e-03f, -7.49144983e-03f, 3.93837504e-02f, -4.89413589e-02f, 7.28101283e-03f, -1.03392303e-02f, 4.31046747e-02f,
  3.42241168e-01f, -4.57808316e-01f, -1.41737953e-01f, 2.79926598e-01f, 3.16919088e-01f, -7.73930782e-03f, -1.77416995e-01f, 8.88853744e-02f, 2.54490852e-01f, -2.62175053e-01f,
  7.08562732e-02f, -1.00883961e-01f, -3.25167447e-01f, 2.03610227e-01f, 1.96010351e-01f, -2.14468837e-01f, 2.00391173e-01f, 1.79538280e-01f, 1.53828219e-01f, 8.14282000e-02f,
  2.46482611e-01f, 2.46961340e-01f, -1.85943972e-02f, 4.00722213e-02f, 1.29032448e-01f, -3.67719121e-02f, -9.64419916e-02f, -1.80038080e-01f, 8.29836540e-03f, 7.45541975e-02f,
  1.30180821e-01f, 2.02282175e-01f, -2.51128301e-02f, 4.00951281e-02f, -6.28247187e-02f, -1.48244366e-01f, -1.09862007e-01f, -8.08842108e-02f, 1.55584374e-03f, -3.36245596e-02f,
  -3.81444767e-02f, 3.75829525e-02f, 2.98684705e-02f, 6.19087927e-02f, 6.84839711e-02f, 6.73220232e-02f, 7.77985603e-02f, 3.45160067e-02f, 6.08457625e-02f, 1.99624673e-02f,
  -2.22074669e-02f, 1.02451228e-01f, 1.33377671e-01f, 4.16449197e-02f, 7.96117485e-02f, 4.08029631e-02f, -3.19809355e-02f, -6.71835393e-02f, -4.30595987e-02f, 3.85973677e-02f,
  -6.94551319e-03f, -1.82265753e-03f, 4.67267521e-02f, 2.75485069e-02f, 2.71405783e-02f, -3.22615504e-02f, 2.73432247e-02f, -4.94412892e-02f, -5.37310950e-02f, -9.62254964e-03f,
  2.57934723e-02f, 1.27719308e-03f, 9.20685157e-02f, 4.24573235e-02f, 1.87294111e-02f, 1.90687664e-02f, 4.04248089e-02f, -2.14270148e-02f, 3.01663065e-03f, 4.15170193e-02f,
  -4.22113761e-02f, 5.94228506e-02f, -1.90347508e-02f, 9.18280892e-03f, -7.41577372e-02f, 3.20260115e-02f, 2.16392800e-02f, 8.37487280e-02f, 4.16146219e-02f, -7.72926062e-02f,
  -2.54504085e-02f, -3.34321082e-01f, -1.15632549e-01f, 3.53751630e-02f, -7.77147114e-02f, 1.25662787e-02f, -1.21230679e-02f, 1.98382121e-02f, -2.33729966e-02f, 3.41674648e-02f,
  3.67193446e-02f, -4.55823131e-02f, -7.66565651e-02f, 5.64073063e-02f, -1.76807027e-02f, -1.41626885e-02f, -8.46693143e-02f, 5.92995659e-02f, -1.06672987e-01f, -4.98889647e-02f,
  6.19409643e-02f, 3.14476974e-02f, -9.25604329e-02f, 1.12289183e-01f, -4.07936983e-02f, -5.13061620e-02f, 3.14269885e-02f, 8.78393948e-02f, -8.58815387e-02f, -3.77277378e-03f,
  -1.02592200e-01f, -2.63162646e-02f, -2.15274915e-01f, -1.04729027e-01f, 1.09007962e-01f, -4.88994569e-02f, 8.18320923e-03f, 5.99422082e-02f, -2.74344891e-01f, 1.99470982e-01f,
  -1.61738996e-03f, -5.83422817e-02f, -1.64593264e-01f, -1.65026605e-01f, -1.97872177e-01f, -2.96684921e-01f, -2.79833134e-02f, 2.38572676e-02f, -9.91274491e-02f, 1.58848763e-01f,
  -7.55410790e-02f, 1.63508609e-01f, -5.97692244e-02f, 1.46023154e-01f, 1.08744599e-01f, 3.96946855e-02f, 3.65591913e-01f, 7.01074153e-02f, 2.73211360e-01f, 8.62796679e-02f,
  -2.55717826e-03f, -7.63186738e-02f, -3.95230576e-03f, -1.28272567e-02f, 6.18313327e-02f, 7.13185444e-02f, 7.12112561e-02f, 5.94534613e-02f, 3.91674452e-02f, -4.00806963e-02f,
  3.45237926e-02f, 2.06558127e-02f, -4.63902839e-02f, -6.91060796e-02f, -2.65359115e-02f, -5.53917028e-02f, -2.78350040e-02f, -6.59439415e-02f, -1.25181779e-01f, -5.41680753e-02f,
  4.88791689e-02f, 4.64230813e-02f, -2.83403118e-04f, -1.41044054e-03f, -3.65886949e-02f, 4.23018001e-02f, -8.26780405e-03f, 8.22696388e-02f, -1.73977315e-02f, -1.44819384e-02f,
  1.38386250e-01f, 9.90655366e-03f, -5.94214071e-03f, -5.88546060e-02f, -5.71219064e-02f, -8.75943899e-02f, -5.68664819e-02f, 1.70412157e-02f, -7.27763250e-02f, -5.60087860e-02f,
  1.28810957e-01f, -2.61368025e-02f, -8.10003057e-02f, 7.69622028e-02f, -4.59532924e-02f, -4.09433991e-02f, 6.23841472e-02f, 4.39584777e-02f, -6.16158452e-03f, 1.48934918e-02f,
  -1.58581361e-02f, 1.50071178e-02f, 6.71648756e-02f, 9.83812809e-02f, -5.92920668e-02f, 6.58789799e-02f, 4.42754403e-02f, -6.85349554e-02f, -8.80326517e-03f, -4.55172397e-02f,
  4.06817645e-02f, 7.05515742e-02f, -5.77455424e-02f, 9.15312767e-03f, -7.53488094e-02f, -1.31756604e-01f, -9.64755416e-02f, 6.41442910e-02f, 9.53558460e-02f, 9.08324197e-02f,
  1.88066512e-01f, 4.67217714e-02f, 2.18677800e-02f, -5.75843118e-02f, 5.22839278e-02f, 6.79125339e-02f, -8.88497531e-02f, -2.62588058e-02f, 4.68445718e-02f, 3.17958109e-02f,
  2.67419331e-02f, 1.56681195e-01f, -1.48832332e-02f, -2.02612355e-02f, -1.44023839e-02f, 1.03477992e-01f, 1.50342658e-01f, 1.83365447e-03f, 3.16728503e-02f, -6.91772774e-02f,
  1.36478558e-01f, -1.93092242e-01f, -1.54475138e-01f, 8.51405561e-02f, -5.91192767e-03f, -2.78782576e-01f, -4.00583774e-01f, -6.62558600e-02f, -1.68265358e-01f, -1.52146488e-01f,
  -6.85275048e-02f, 2.18471140e-01f, -3.27532142e-01f, 1.59940973e-01f, 1.93879604e-01f, -2.26328373e-01f, 2.52358288e-01f, 1.57448709e-01f, -1.27685042e-02f, 2.13668756e-02f,
  1.24528937e-01f, 3.09826404e-01f, 2.13682055e-01f, 2.59431124e-01f, 4.92870174e-02f, 7.83269256e-02f, 1.70941249e-01f, -1.37231261e-01f, 2.63594627e-01f, 1.88268498e-01f,
  -2.14592684e-02f, 1.93960648e-02f, -5.43774664e-02f, 4.03964072e-02f, -2.36751251e-02f, -1.04636870e-01f, 4.45911884e-02f, 2.62464900e-02f, 5.36272600e-02f, -8.15932453e-02f,
  -6.04754575e-02f, 1.17278717e-01f, 1.70461923e-01f, 6.44326285e-02f, -4.58258055e-02f, 1.85180064e-02f, 9.21503603e-02f, -5.66116422e-02f, -5.49155325e-02f, 4.44481596e-02f,
  -6.87166676e-02f, -3.14489976e-02f, -1.15141362e-01f, 4.93909679e-02f, -1.39617631e-02f, -2.97273602e-03f, 2.63929684e-02f, 6.60963776e-03f, -1.54711464e-02f, 1.45776376e-01f,
  -7.90778399e-02f, -6.15371065e-03f, -6.42239675e-02f, 2.90002651e-03f, -5.17789721e-02f, 4.65458371e-02f, 3.30629684e-02f, -5.27403429e-02f, 2.91041099e-02f, -5.80055602e-02f,
  5.73299117e-02f, 3.56681980e-02f, -8.51062499e-03f, 5.82765751e-02f, 1.51757700e-02f, -4.18253802e-02f, -2.48712581e-02f, -4.11017202e-02f, -2.72272024e-02f, 4.87230346e-02f,
  -2.43020225e-02f, 6.56569423e-03f, -8.43374655e-02f, -1.25322221e-02f, 1.69262096e-01f, -7.95867741e-02f, -3.31693962e-02f, -1.54861197e-01f, -3.86622436e-02f, -6.13551065e-02f,
  -1.76917925e-01f, -8.98648351e-02f, 2.68230494e-02f, 1.17121384e-01f, 7.15771243e-02f, 3.93020362e-02f, 4.76802140e-02f, 8.79026353e-02f, 3.26417871e-02f, -2.82604787e-02f,
  3.37057151e-02f, -1.77714005e-01f, 7.25589460e-03f, 2.28948426e-02f, 9.89484340e-02f, -1.34102970e-01f, 7.16845915e-02f, 2.28937361e-02f, 3.98610011e-02f, 1.05613329e-01f,
  -1.14244848e-01f, -2.26773083e-01f, 8.36994573e-02f, -5.12172356e-02f, 3.60855348e-02f, -4.82832119e-02f, -5.66269048e-02f, 2.25103460e-02f, -1.44643933e-02f, 7.18755126e-02f,
  -4.26179796e-01f, 9.86514166e-02f, -7.19625503e-02f, -4.62217778e-01f, -1.66807771e-01f, -3.03919077e-01f, -3.72305751e-01f, -6.42509386e-02f, -4.47853543e-02f, 8.90692249e-02f,
  -7.63055980e-02f, 6.89880401e-02f, 3.38252097e-01f, -1.76853895e-01f, 4.16945033e-02f, 1.98115841e-01f, -1.82213381e-01f, -6.04944080e-02f, 9.13883299e-02f, -1.67704135e-01f,
  -6.74608350e-02f, -1.25847697e-01f, 1.14642307e-02f, 1.20678484e-01f, -1.81561917e-01f, -1.80739701e-01f, -1.57750636e-01f, -2.12366432e-02f, -1.23998441e-01f, 2.74936799e-02f,
  -4.21707541e-01f, -2.02102348e-01f, -2.22608164e-01f, -1.59023359e-01f, -2.23939210e-01f, 3.07992790e-02f, -1.56389296e-01f, 3.33938971e-02f, -9.60444584e-02f, -6.50318339e-02f,
  4.05517295e-02f, 1.65297203e-02f, -1.77977793e-02f, 7.43017793e-02f, -1.05856583e-01f, -3.00769918e-02f, -2.77738553e-02f, -2.34078825e-03f, 1.30731883e-02f, 6.12564795e-02f,
  1.39705241e-01f, -7.38617256e-02f, -1.57305896e-01f, 6.67401925e-02f, -5.24483621e-02f, -5.03864661e-02f, -6.58740327e-02f, 5.97277619e-02f, -9.17515680e-02f, 7.26819690e-03f,
  6.66035786e-02f, 7.50351176e-02f, -8.38042498e-02f, 9.56735685e-02f, 3.82816419e-02f, 4.37595248e-02f, -1.88564621e-02f, 1.25925452e-01f, -4.41573113e-02f, -6.41662395e-04f,
  -8.22980553e-02f, -8.76913518e-02f, -7.49789476e-02f, 5.83380228e-03f, -1.97310951e-02f, -2.66718324e-02f, -4.95229475e-02f, -2.63612401e-02f, 7.27568567e-02f, -7.65255317e-02f,
  4.79616225e-02f, 2.60725338e-02f, 1.01624168e-01f, -6.27439767e-02f, -1.21327164e-02f, 1.27656996e-01f, 4.57679667e-02f, 5.03031798e-02f, 4.99018654e-02f, -4.53269109e-02f,
  -5.04593015e-01f, -2.67302215e-01f, -2.40261089e-02f, -1.84079055e-02f, 3.92498076e-02f, -4.86843698e-02f, 1.04109515e-02f, 5.30602485e-02f, -2.40606517e-02f, -1.01623954e-02f,
  -1.03347182e-01f, -9.56702307e-02f, -2.10928470e-02f, -3.13390139e-03f, 9.81920958e-02f, -3.47268842e-02f, -6.27594069e-02f, -7.54258186e-02f, -1.04505002e-01f, 1.88373402e-02f,
  -7.55254030e-02f, 9.60411429e-02f, 5.73649444e-02f, 2.44290531e-02f, -2.95691825e-02f, -1.09032005e-01f, 2.05031950e-02f, -1.29736131e-02f, -2.96159107e-02f, 2.98200101e-02f,
  -7.11491480e-02f, -6.00637421e-02f, -1.84189320e-01f, -5.14812842e-02f, 1.42061144e-01f, -1.99853163e-02f, -7.75027573e-02f, -1.55094452e-02f, -8.72061178e-02f, -3.12420372e-02f,
  1.06395632e-02f, -1.29109502e-01f, -5.59429117e-02f, -8.94243568e-02f, -1.56282052e-01f, -3.13926429e-01f, 6.02495708e-02f, -9.85672623e-02f, -1.23658486e-01f, 5.89361452e-02f,
  -8.28892365e-02f, 9.59018394e-02f, -1.35841712e-01f, 2.51095034e-02f, 1.33390203e-01f, 1.83330774e-01f, 1.11337647e-01f, 1.00453556e-01f, 1.67174041e-01f, -3.58921513e-02f,
  -4.96744029e-02f, -1.49072051e-01f, -1.04170404e-01f, 4.26400490e-02f, 1.46095799e-02f, 1.96583956e-01f, 4.87104841e-02f, 4.14176844e-02f, -9.72492695e-02f, -1.41652584e-01f,
  1.68608651e-02f, 4.74236533e-02f, -5.22944257e-02f, 7.76681900e-02f, 2.86478810e-02f, -1.09587228e-02f, 1.06130354e-03f, -5.51474988e-02f, -1.69340391e-02f, -1.66923717e-01f,
  6.27729371e-02f, 2.01748707e-03f, 9.47204232e-02f, 1.04268409e-01f, 2.98708063e-02f, -1.18293062e-01f, 7.37565532e-02f, -2.84233625e-04f, 8.62320140e-02f, -6.05913587e-02f,
  1.17654288e-02f, -6.07729703e-02f, -9.08187330e-02f, 2.14306545e-02f, -1.14450119e-02f, -1.08476505e-02f, 1.66464821e-02f, 5.94919994e-02f, 6.08122395e-03f, 3.23036760e-02f,
  5.92460334e-02f, 3.09582073e-02f, -1.10398732e-01f, 6.67764470e-02f, -4.67165485e-02f, 4.61641625e-02f, 3.06240171e-02f, -4.98115923e-03f, -5.88325877e-03f, 2.23083440e-02f,
  -9.90975741e-03f, 8.96004587e-03f, -5.70555218e-02f, 6.45457655e-02f, 5.19002043e-02f, -4.93415222e-02f, -4.88021187e-02f, 4.28282656e-02f, 2.76094954e-02f, 1.07433543e-01f,
  -3.31647806e-02f, 1.52867332e-01f, 1.02584235e-01f, -5.06685190e-02f, -6.73314929e-02f, 1.30129680e-01f, -2.58938726e-02f, -2.12424118e-02f, 6.63600769e-03f, -4.59684208e-02f,
  1.17893718e-01f, 8.89545828e-02f, 1.11228731e-02f, 8.06811005e-02f, -5.31785097e-03f, -1.19453678e-02f, 1.79115329e-02f, 1.44793123e-01f, 1.57142296e-01f, -3.03265642e-05f,
  1.10075280e-01f, 5.08529693e-03f, -1.95448380e-02f, 1.48918629e-01f, 3.70258577e-02f, 7.31358230e-02f, 6.23757951e-02f, -1.14761153e-02f, 6.66685477e-02f, 2.69667599e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  1.22661389e-01f, 2.82187045e-01f, 4.90782270e-03f, -8.90711918e-02f, 4.34536487e-02f, 1.33484811e-01f, 4.37392667e-02f, 5.77192679e-02f, 2.73868516e-02f, 2.50856042e-01f,
  1.16136782e-01f, 4.53436114e-02f, 1.79559305e-01f, 3.80291119e-02f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  7.86591470e-02f, -1.58870474e-01f, -1.69787377e-01f, -1.50635377e-01f, 1.05625942e-01f, -1.13910049e-01f, 6.85829893e-02f, 8.22363794e-02f, -6.14162534e-03f, 1.03545167e-01f,
  2.27966875e-01f, 1.85900182e-01f, 1.05574653e-01f, -1.44494265e-01f, 2.45323986e-01f, 3.14240456e-01f, 9.38030630e-02f, 1.65215433e-01f, -1.46669447e-01f, 3.10233355e-01f,
  2.48252928e-01f, -3.40317637e-01f, 1.48542017e-01f, -1.23566727e-03f, 1.03136174e-01f, -1.61941990e-01f, 2.55100936e-01f, -8.45147222e-02f, 6.00769632e-02f, -1.54460415e-01f,
  3.37754972e-02f, 2.59550046e-02f, 3.13834213e-02f, -5.14783300e-02f, -1.08797066e-01f, -1.90833092e-01f, 1.11919761e-01f, 6.36165068e-02f, 2.90078241e-02f, 3.60830203e-02f,
  -2.46455073e-01f, -2.12480158e-01f, 5.04354201e-02f, 1.30407020e-01f, -3.11892759e-02f, -1.73528388e-01f, 2.45296240e-01f, 1.95335150e-01f, 1.88664958e-01f, 3.50831538e-01f,
  -4.53309834e-01f, 3.54563035e-02f, -2.50815693e-02f, -4.54906464e-01f, 1.87594384e-01f, 2.14499712e-01f, -2.60702252e-01f, -1.77751243e-01f, 1.29577458e-01f, 9.00666118e-02f,
  -2.93702446e-02f, 1.76767066e-01f, -1.04483040e-02f, 1.91603288e-01f, -3.47842723e-02f, 5.26753440e-02f, -1.58057019e-01f, -4.30654176e-03f, -1.81727380e-01f, -3.05818975e-01f,
  3.77227254e-02f, -2.35425934e-01f, -2.83558518e-01f, 3.00735123e-02f, -6.74388111e-02f, -5.40045984e-02f, 1.63813502e-01f, 2.99032964e-02f, 1.60890639e-01f, 1.93394735e-01f,
  1.56227082e-01f, -8.30678940e-02f, -1.73104003e-01f, -1.17832042e-01f, 2.32803196e-01f, -1.74545780e-01f, 1.96615115e-01f, -2.75837570e-01f, -4.00173441e-02f, -5.31084538e-02f,
  -2.92881787e-01f, 2.77575999e-01f, 2.20667064e-01f, 1.79791614e-01f, 6.72051683e-02f, 1.51528448e-01f, 9.16578844e-02f, -8.71795416e-02f, 1.97656512e-01f, -2.32913226e-01f,
  -2.60497421e-01f, 2.48976901e-01f, 1.88671499e-02f, -8.92205164e-02f, -1.11805059e-01f, 2.56354891e-04f, 1.53486581e-05f, -1.12294711e-01f, -2.31275707e-01f, 9.27099735e-02f,
  -1.27451122e-01f, -1.21027909e-01f, -5.85345402e-02f, 3.45823228e-01f, 8.23160354e-03f, 1.18763268e-01f, -2.47552976e-01f, 3.62191796e-01f, -3.43608081e-01f, -2.54897296e-01f,
  -1.81512564e-01f, -2.02128172e-01f, 2.79382840e-02f, -1.11782223e-01f, -2.12534606e-01f, 8.14456865e-03f, 1.89580359e-02f, -1.95701048e-01f, 1.62028849e-01f, -1.88769266e-01f,
  -1.53415464e-02f, -8.71897787e-02f, 3.22568156e-02f, -1.40828505e-01f, -9.37079564e-02f, -2.01317206e-01f, 2.53327847e-01f, 1.36882439e-01f, -1.67847350e-02f, -3.41872394e-01f,
  -2.83979297e-01f, 1.56630114e-01f, 1.46805704e-01f, 8.91714171e-02f, 1.31866068e-01f, -1.92928821e-01f, -2.89547771e-01f, 2.87934601e-01f, 1.45034179e-01f, -2.18421459e-01f,
  -3.31376314e-01f, -2.01896355e-01f, 1.77207664e-01f, 3.07589537e-03f, 7.99931586e-02f, -3.51939872e-02f, -1.54209808e-01f, -2.35699460e-01f, -1.68881789e-01f, -2.75482804e-01f,
  -5.94843552e-02f, -2.33648136e-01f, 1.21081710e-01f, -2.09548593e-01f, -2.09026765e-02f, 1.60655975e-01f, 1.36696205e-01f, -2.19959393e-02f, 1.00072987e-01f, -2.60456562e-01f,
  -1.04336597e-01f, -3.29323262e-02f, -4.48213145e-02f, -6.62137941e-02f, -2.56734252e-01f, -1.07325785e-01f, -1.04536660e-01f, 9.78947878e-02f, 8.91796201e-02f, 1.14814095e-01f,
  -2.36458361e-01f, 8.47407728e-02f, 1.42431974e-01f, -5.30248173e-02f, 4.83084433e-02f, -2.39472896e-01f, 2.55646616e-01f, -8.32535252e-02f, -2.40769032e-02f, -2.36182079e-01f,
  1.81443989e-01f, -1.17337167e-01f, 2.57828273e-02f, 2.89547861e-01f, 1.31890982e-01f, 1.82667319e-02f, -2.44164709e-02f, -2.14094743e-01f, 9.06156152e-02f, -2.34091878e-02f,
  8.35216716e-02f, -9.40929353e-02f, 3.26229662e-01f, -9.45007242e-03f, 1.45828515e-01f, 6.92097992e-02f, 1.90164596e-02f, 1.67783752e-01f, -1.09445296e-01f, 3.11770856e-01f,
  3.26521814e-01f, 1.45346463e-01f, 1.87654406e-01f, 3.33896458e-01f, -1.86177492e-01f, 1.10734195e-01f, 1.15259990e-01f, -3.23725015e-01f, 6.89720660e-02f, 5.13405306e-03f,
  1.91393510e-01f, 1.48721099e-01f, -1.99882850e-01f, 1.96944356e-01f, -3.67672183e-02f, -2.96189517e-01f, -5.94751798e-02f, -1.17779545e-01f, -2.28622362e-01f, -2.22646549e-01f,
  -1.86730772e-01f, -1.56942412e-01f, 9.74387228e-02f, 1.61424112e-02f, -3.35475691e-02f, -3.57189439e-02f, -2.74264067e-01f, 2.13046581e-01f, 1.72726661e-01f, 1.31199643e-01f,
  2.53562063e-01f, -7.37237781e-02f, -3.14748704e-01f, 6.98448271e-02f, -1.08521260e-01f, -1.87060669e-01f, 4.52766903e-02f, -5.57097234e-02f, 2.01510891e-01f, 1.30009800e-01f,
  -1.58534363e-01f, -9.22329724e-02f, -1.92723319e-01f, -1.84159130e-01f, 2.56992519e-01f, -6.24336787e-02f, -2.43395399e-02f, -1.83177799e-01f, 6.10179715e-02f, -2.92177647e-02f,
  -9.10339355e-02f, 6.76750541e-02f, 1.08284742e-01f, 1.74263954e-01f, -2.81895604e-02f, -2.45036930e-01f, -2.52521932e-01f, 4.17362787e-02f, -2.03997474e-02f, -2.13459224e-01f,
  -5.34850135e-02f, -7.96937197e-03f, -1.61082387e-01f, -5.95945418e-02f, -4.80483249e-02f, -1.90651238e-01f, -3.54207121e-02f, 2.23365966e-02f, 2.75764048e-01f, -1.43128008e-01f,
  4.19965480e-04f, -5.02268709e-02f, -3.15814428e-02f, 2.65028626e-01f, -1.54170439e-01f, 4.18287456e-01f, 2.61498421e-01f, -1.39566556e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  2.85756558e-01f, 4.34505701e-01f, 2.24629030e-01f, 3.62052411e-01f, 1.49270371e-01f, 6.78617209e-02f, 1.65729210e-01f, 3.36779028e-01f, 3.96318465e-01f, -5.20353496e-01f,
  4.12238687e-01f, 4.24394667e-01f, 1.35152712e-01f, -1.44139081e-01f, -2.40397796e-01f, 1.55662090e-01f, -3.57682675e-01f, 3.99202079e-01f, 4.64288384e-01f, 4.70647067e-01f,
  1.95185676e-01f, 2.37584546e-01f, 2.26867706e-01f, -8.68034810e-02f, 1.23646230e-01f, -3.22300762e-01f, -8.42113644e-02f, -5.69565631e-02f, 8.03967044e-02f, -1.61464974e-01f,
  2.43743032e-01f, 1.38180479e-01f, 1.67017058e-02f, 4.29544419e-01f, 1.84438199e-01f, 3.15235555e-01f, 6.90833703e-02f, -9.42551717e-02f, 1.14975728e-01f, 3.84959206e-02f,
  4.70856614e-02f, 1.91363350e-01f, 1.00263186e-01f, 2.00365111e-01f, 2.34586760e-01f, -1.15453787e-01f, 3.82429898e-01f, 3.51751387e-01f, 1.99296653e-01f, 1.98937148e-01f,
  -1.08143575e-01f, -3.08096051e-01f, 1.38982713e-01f, -2.68246621e-01f, -4.69856896e-02f, 2.04226017e-01f, 1.32994100e-01f, 5.14286160e-02f, 2.11237922e-01f, 3.81298721e-01f,
  2.25687221e-01f, 1.69846669e-01f, -4.48386937e-01f, 3.67035300e-01f, -1.76219821e-01f, 2.03302294e-01f, 1.96374446e-01f, 1.23144858e-01f, 2.85500228e-01f, 7.57404417e-02f,
  3.55694117e-03f, -8.65013152e-02f, 1.15063742e-01f, 5.20766973e-01f, 1.70661673e-01f, -2.04100400e-01f, 5.02531044e-02f, 3.02879274e-01f, 2.72171974e-01f, -1.33200616e-01f,
  2.59351254e-01f, -3.10545266e-01f, -2.40202457e-01f, 2.67620116e-01f, 1.88050315e-01f, -2.58149624e-01f, -1.34019598e-01f, 4.42675948e-01f, 6.89190626e-02f, 4.95363086e-01f,
  3.09521049e-01f, -1.15423150e-01f, -1.12207994e-01f, 1.52598664e-01f, -9.23380721e-03f, 2.22962916e-01f, 1.20891221e-01f, 3.96016955e-01f, 3.45870778e-02f, 1.19335689e-01f,
  5.44341989e-02f, -7.68216252e-02f, 1.20133437e-01f, 1.43024802e-01f, 7.63831884e-02f, -5.80885040e-04f, 3.73349100e-01f, 5.74055649e-02f, 1.21023573e-01f, 1.94416329e-01f,
  2.10768208e-01f, 3.03236514e-01f, 1.94084808e-01f, 5.42640865e-01f, -1.74374938e-01f, 1.48199022e-01f, 1.41019896e-01f, -1.75512061e-01f, -1.32712230e-01f, 2.35023603e-01f,
  1.56726256e-01f, -2.85652339e-01f, 2.25703910e-01f, 1.80491712e-02f, 2.52961665e-01f, 4.39749241e-01f, -2.11182386e-01f, 8.94859359e-02f, 1.29788741e-01f, 7.80890808e-02f,
  -1.84622663e-03f, -2.26449296e-02f, -1.87924549e-01f, -3.05807590e-02f, 1.39778018e-01f, -1.31611764e-01f, 3.69274110e-01f, 4.30371612e-01f, 2.23330110e-01f, -3.79258543e-01f,
  -3.94597530e-01f, 5.18761694e-01f, 1.23491004e-01f, 2.66552478e-01f, 5.43088377e-01f, 1.53434634e-01f, -1.18161365e-01f, 5.21362126e-01f, -5.33928834e-02f, -3.07143480e-01f,
  1.36176974e-01f, -1.99379668e-01f, 3.11756760e-01f, 2.31467858e-01f, 1.78731382e-01f, -2.18059812e-02f, 1.52346203e-02f, -7.41310418e-02f, 1.71238426e-02f, -1.55118257e-01f,
  2.98171565e-02f, 1.82463706e-01f, 2.71675050e-01f, 4.33474667e-02f, 1.53459758e-01f, -5.60183451e-02f, 1.01462960e-01f, 2.18108699e-01f, 3.50862324e-01f, 3.92705560e-01f,
  3.25674653e-01f, -2.97520638e-01f, -4.80203688e-01f, 3.87843400e-01f, 1.45289540e-01f, 1.77346736e-01f, 3.45260799e-01f, 3.50414246e-01f, -1.95679814e-01f, 2.60447174e-01f,
  2.75932346e-02f, -8.95273909e-02f, -2.03630537e-01f, 1.22172676e-01f, 3.46552074e-01f, 2.06819683e-01f, 3.56264293e-01f, -1.54077962e-01f, 6.46914467e-02f, 5.24277687e-02f,
  1.80536777e-01f, -1.29567832e-01f, 4.94908355e-02f, 1.49551257e-01f, -7.83328116e-02f, 1.65756285e-01f, 3.94155122e-02f, 2.46023554e-02f, 1.41011283e-01f, 7.11154938e-02f,
  -6.55176044e-02f, -2.22956166e-01f, 5.49019217e-01f, 3.15439433e-01f, 4.09102201e-01f, -1.46019176e-01f, -1.60398707e-01f, 3.07748169e-01f, -6.74107969e-02f, 9.88525003e-02f,
  2.05364972e-01f, 6.43057898e-02f, 3.16702664e-01f, 1.68507710e-01f, 4.56898153e-01f, -3.94687206e-01f, -1.90265745e-01f, -2.55703628e-01f, -2.54499465e-02f, -4.59556103e-01f,
  2.77989864e-01f, -5.24667978e-01f, 1.86573956e-02f, 4.32619125e-01f, 1.34177983e-01f, 3.95577848e-01f, 2.44676337e-01f, 5.08694232e-01f, 3.93619508e-01f, 2.21804291e-01f,
  -1.17502372e-04f, 3.01890969e-01f, -1.26353875e-01f, 3.30516815e-01f, 1.77079007e-01f, 8.83131623e-02f, 4.13203776e-01f, 1.67522997e-01f, 3.22344720e-01f, 7.16946367e-03f,
  5.19590490e-02f, -2.64830709e-01f, -4.30946350e-02f, -3.91591042e-01f, 1.86876357e-01f, -2.18917117e-01f, 2.67592119e-03f, 4.57242966e-01f, 9.50515121e-02f, 4.41541702e-01f,
  2.90424198e-01f, 4.65900689e-01f, 2.26395667e-01f, 2.49495566e-01f, -5.12690663e-01f, 3.33130240e-01f, 1.55626722e-02f, 3.55976075e-02f, 2.81416148e-01f, 3.59170020e-01f,
  1.33310482e-01f, -6.15129732e-02f, 2.76185155e-01f, 4.77382354e-02f, 5.94671071e-02f, -1.52759790e-01f, -2.78322995e-01f, 2.58851498e-01f, -4.68459763e-02f, -8.44865441e-02f,
  1.16041834e-02f, -1.75324544e-01f, -1.40126094e-01f, -1.34057239e-01f, 2.55452305e-01f, 2.46171013e-01f, -2.87899911e-01f, -4.20963466e-02f, 4.29063827e-01f, -3.69304419e-02f,
  1.43232405e-01f, 2.69461513e-01f, -3.57356220e-01f, 4.28827971e-01f, -9.34774354e-02f, 1.64803788e-01f, 3.99038613e-01f, -1.09446615e-01f, 1.85508266e-01f, 1.34707436e-01f,
  9.87313315e-02f, 1.54902548e-01f, 3.84098768e-01f, -2.15974405e-01f, -1.11976303e-01f, 6.58221245e-02f, -2.83845812e-01f, -2.86424071e-01f, -3.72271746e-01f, 3.11934529e-03f,
  5.42787984e-02f, 2.34803438e-01f, 4.07759994e-01f, -1.72887340e-01f, -2.26618782e-01f, -8.48865360e-02f, -3.66183281e-01f, -2.42217124e-01f, -2.91264564e-01f, -2.40775764e-01f,
  -4.18410331e-01f, 5.95817007e-02f, -3.30229193e-01f, 1.34131625e-01f, -5.05201876e-01f, 5.44419587e-01f, 1.69678524e-01f, 3.17019463e-01f, -4.06328321e-01f, 1.57865256e-01f,
  9.31081176e-02f, 2.52994537e-01f, 5.25128394e-02f, 3.36269103e-02f, -3.74944001e-01f, -1.14481859e-01f, -4.82218154e-03f, 3.19002062e-01f, 7.27237985e-02f, -6.93322122e-02f,
  5.09381332e-02f, 2.29987025e-01f, 4.01019901e-01f, -3.77180517e-01f, 4.25832644e-02f, 2.15674788e-01f, 1.43903300e-01f, 7.62156323e-02f, 1.36196762e-01f, -1.33513063e-01f,
  -9.76461172e-02f, -2.08483353e-01f, 5.37015319e-01f, -2.66084760e-01f, -6.48073852e-02f, -1.02671102e-01f, -1.84542820e-01f, 2.96991765e-01f, 1.65350586e-01f, 2.42643163e-01f,
  3.10085267e-01f, -1.10463142e-01f, 1.32389188e-01f, -1.08845502e-01f, -2.07428746e-02f, 1.48685247e-01f, -7.23805800e-02f, -8.09514672e-02f, 1.14557900e-01f, 2.51070321e-01f,
  1.28056526e-01f, -2.21502438e-01f, -9.91581380e-02f, 3.08910668e-01f, 1.43167719e-01f, 4.14713733e-02f, -7.62005970e-02f, 1.91543266e-01f, -2.26536542e-02f, -1.77631635e-04f,
  1.73001960e-01f, -3.31069529e-02f, 1.88139141e-01f, -3.11463922e-01f, 3.95775646e-01f, -7.64513388e-02f, -1.39917865e-01f, 2.06979901e-01f, -2.26516619e-01f, 5.17219067e-01f,
  1.49157912e-01f, -1.68539491e-02f, 3.90936852e-01f, 8.85033831e-02f, 9.96511206e-02f, 3.33619475e-01f, -2.31932150e-04f, 1.68918565e-01f, -7.28177950e-02f, -3.52769792e-01f,
  -8.78266469e-02f, -1.81742251e-01f, 6.62135109e-02f, 6.18767217e-02f, 2.40384877e-01f, -2.41517082e-01f, -1.23227648e-02f, 1.56189814e-01f, 4.40924466e-01f, 2.64746279e-01f,
  3.41770589e-01f, 3.81644994e-01f, -1.46545678e-01f, 1.64334308e-02f, 5.76758422e-02f, -2.66871274e-01f, 9.95901972e-02f, -2.59826094e-01f, 8.74784440e-02f, 1.61591023e-01f,
  -2.14776158e-01f, 5.35793781e-01f, 2.68530458e-01f, 4.07591075e-01f, -4.63919044e-01f, 1.49819642e-01f, 8.68141726e-02f, 1.86857790e-01f, -7.56762549e-02f, 8.02911371e-02f,
  6.20646439e-02f, 4.27033938e-02f, -8.21058732e-03f, 1.18778571e-01f, 1.78753600e-01f, 1.49096429e-01f, 7.58666843e-02f, 1.33118123e-01f, 1.48816645e-01f, -2.15534255e-01f,
  1.89049631e-01f, 2.63572544e-01f, 8.44496042e-02f, 1.60490394e-01f, -2.43657932e-01f, -3.44032645e-01f, 3.37059349e-01f, -1.25977382e-01f, 1.44560069e-01f, 3.37372363e-01f,
  2.48353690e-01f, 2.06666544e-01f, 3.07361484e-01f, 1.05796963e-01f, 4.92775679e-01f, 8.88295993e-02f, -6.77849650e-01f, 1.97422802e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  3.29640985e-01f, 1.42907053e-01f, 1.50234595e-01f, 1.99920740e-02f, 5.98786548e-02f, 1.10964045e-01f, 2.86675878e-02f, 1.06746871e-02f, 4.68299896e-01f, -2.59556212e-02f,
  3.79273593e-02f, 2.50535399e-01f, -1.57945212e-02f, 4.16531600e-02f
};

// L2_fan_Wp (Shape: 9 x 32)
const int L2_fan_Wp_rows = 9;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  5.72079904e-02f, 3.64521295e-01f, 3.27296853e-01f, 2.88567036e-01f, -1.54621778e-02f, 6.53710589e-02f, 6.86932802e-02f, 2.82892406e-01f, 1.77154109e-01f, 7.33543038e-02f,
  -1.96607530e-01f, 8.18989128e-02f, -5.05529523e-01f, 3.26198250e-01f, -1.56226726e-02f, -3.53271842e-01f, 2.86882281e-01f, 6.78941980e-02f, -2.13487878e-01f, -8.80130827e-02f,
  -8.51561129e-02f, -2.47205690e-01f, 2.70614270e-02f, -6.08407892e-02f, 5.93834408e-02f, 1.75769821e-01f, 6.31019706e-03f, -3.09425056e-01f, 2.13441849e-01f, 1.37806267e-01f,
  1.75657630e-01f, 9.09651294e-02f, 3.94316345e-01f, 2.50162929e-01f, 1.18668072e-01f, 2.06632376e-01f, 1.33538797e-01f, 5.29081523e-02f, 4.05025072e-02f, 3.40647012e-01f,
  -5.38891070e-02f, -2.21749067e-01f, -7.78258294e-02f, -1.29178166e-01f, -3.18122357e-01f, -5.33371940e-02f, 1.75063893e-01f, -3.96072358e-01f, -1.08227111e-01f, 1.61597088e-01f,
  -1.09836772e-01f, -1.88366279e-01f, 1.25248984e-01f, -3.47015619e-01f, -1.18570857e-01f, -1.87900841e-01f, -1.75527528e-01f, -7.16061592e-02f, 3.53839308e-01f, -1.48246646e-01f,
  1.05935827e-01f, 1.72966644e-01f, -1.46091968e-01f, -1.15080722e-01f, -8.73753708e-03f, -2.85530448e-01f, 1.58662051e-01f, 1.37283057e-01f, 1.55280903e-02f, 2.04181105e-01f,
  -1.76939353e-01f, 5.05170561e-02f, -8.84191319e-02f, -3.17572325e-01f, -1.19828202e-01f, -8.16453341e-03f, -1.29737090e-02f, -3.82901341e-01f, 1.35404453e-01f, 1.76490128e-01f,
  -1.76447332e-01f, 2.52869755e-01f, 2.61577815e-01f, 1.67771697e-01f, -5.80010116e-02f, -2.27441028e-01f, -3.59930426e-01f, -2.19199479e-01f, 1.50044933e-01f, 1.22421853e-01f,
  2.54367322e-01f, 1.63699225e-01f, 3.53245854e-01f, 6.00177534e-02f, 7.30390474e-02f, 8.48280825e-03f, 1.15688361e-01f, 7.61398077e-02f, 1.92523181e-01f, -2.05330774e-01f,
  -2.51074433e-01f, -2.65497535e-01f, -2.74511594e-02f, -9.04004127e-02f, -2.41715267e-01f, 2.77012110e-01f, 1.47249684e-01f, 3.15922737e-01f, -3.13828230e-01f, 1.94073185e-01f,
  -4.13491666e-01f, 4.51773740e-02f, 1.90749690e-02f, 1.76563516e-01f, -8.61931443e-02f, 2.57179767e-01f, -1.11180618e-01f, 1.81197405e-01f, -8.64610001e-02f, -1.57146946e-01f,
  1.75676301e-01f, 8.52550194e-02f, 4.47106697e-02f, 2.82762527e-01f, 1.92989975e-01f, 2.03686669e-01f, 2.87872225e-01f, 1.21574596e-01f, 2.13211432e-01f, 1.49904862e-01f,
  1.23767652e-01f, 4.25231643e-02f, 3.52456033e-01f, 3.44411135e-01f, 1.89362571e-01f, 2.19603732e-01f, 3.62610251e-01f, -3.93930614e-01f, -2.47746836e-02f, -1.74658999e-01f,
  3.50003392e-01f, 1.25739366e-01f, 4.14442599e-01f, -4.41190571e-01f, -9.38167125e-02f, 2.28723854e-01f, 6.80012256e-02f, -7.32000545e-02f, 3.33390772e-01f, -2.37610832e-01f,
  -8.20583850e-02f, -6.14270754e-02f, -1.30407304e-01f, 1.56693995e-01f, 1.16054490e-02f, 1.59063369e-01f, -1.94059998e-01f, -2.31831893e-01f, -2.56752253e-01f, -7.45875090e-02f,
  -1.96859241e-01f, -3.05308312e-01f, -2.35489100e-01f, -2.09956974e-01f, -1.82708472e-01f, -2.92580929e-02f, -8.62888470e-02f, -2.55587876e-01f, -1.09212689e-01f, 1.93987284e-02f,
  1.63885877e-01f, 2.01311976e-01f, 2.09511653e-01f, -1.89849585e-01f, 7.49495327e-02f, 2.70113766e-01f, -1.29309565e-01f, -9.00958776e-02f, 3.12856436e-02f, 1.28490746e-01f,
  -1.14444382e-01f, 2.21074134e-01f, 1.65344432e-01f, 7.28355870e-02f, 2.88309962e-01f, -2.28539314e-02f, -2.57527512e-02f, 7.50126094e-02f, -5.65239526e-02f, -1.27968058e-01f,
  -4.13640440e-02f, 8.57997239e-02f, -1.69777662e-01f, -7.92056322e-02f, -2.33494446e-01f, 3.72579694e-02f, 1.00088231e-01f, 7.49365240e-02f, 6.96294233e-02f, 3.55200619e-02f,
  2.41228580e-01f, 1.74398199e-01f, -7.25474879e-02f, -3.46465230e-01f, 3.77278715e-01f, -3.14280123e-01f, 2.90627211e-01f, 1.41457066e-01f, -1.37688935e-01f, -2.38038413e-03f,
  2.72721857e-01f, -1.53939724e-01f, 1.93746775e-01f, -8.09430107e-02f, -3.76382507e-02f, 2.12095067e-01f, 1.34542629e-01f, 4.75077778e-02f, -9.95349586e-02f, -2.83273131e-01f,
  -7.55285025e-02f, -5.90609163e-02f, -4.45921302e-01f, 2.20211804e-01f, 2.07456589e-01f, 6.35905340e-02f, 1.63110867e-01f, 2.45318189e-01f, 6.82347193e-02f, 1.29488498e-01f,
  -6.35822862e-02f, 1.80893049e-01f, -3.07963997e-01f, -1.30382270e-01f, -4.19320539e-03f, 1.14724450e-01f, -3.24660093e-01f, 3.21055651e-01f, -2.47376949e-01f, -3.63854229e-01f,
  1.91674888e-01f, -1.88174278e-01f, -3.08716983e-01f, 2.04872847e-01f, 8.87481198e-02f, -5.09326570e-02f, 6.76073208e-02f, -1.50498927e-01f, -2.31002212e-01f, 3.97531949e-02f,
  2.15940714e-01f, 3.62429410e-01f, 1.85928315e-01f, 5.10032289e-02f, 2.61692166e-01f, -1.68051451e-01f, -3.06145400e-01f, -2.68319935e-01f, -1.04864351e-01f, -1.23390354e-01f,
  -1.86478961e-02f, -1.20116748e-01f, -2.54001975e-01f, -2.17997253e-01f, 1.35158122e-01f, -1.45247832e-01f, 1.45434305e-01f, 2.24101856e-01f, -6.75459281e-02f, -3.71773690e-01f,
  -2.84697682e-01f, 4.14139241e-01f, -1.92442924e-01f, 1.41555220e-01f, 1.75157748e-02f, 4.50617857e-02f, -4.97107469e-02f, 1.16478674e-01f, -3.73284906e-01f, -2.83463240e-01f,
  1.25309139e-01f, 3.85267437e-01f, -1.09020568e-01f, 3.04524839e-01f, 8.09809342e-02f, -1.16863266e-01f, -1.77893505e-01f, 8.01488087e-02f
};

// L2_fan_Wp_bar (Shape: 14 x 32)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  2.79811889e-01f, -4.50912975e-02f, 2.50964999e-01f, 2.41825461e-01f, -3.35005403e-01f, 1.77699611e-01f, -7.21771047e-02f, 1.37305468e-01f, -6.02250636e-01f, 1.05711661e-01f,
  4.58656475e-02f, 5.51005602e-01f, -1.86708078e-01f, -2.97969226e-02f, -2.03088805e-01f, 2.50463039e-01f, 2.87717640e-01f, -2.81310063e-02f, 4.02966794e-03f, 1.38702437e-01f,
  -6.03612475e-02f, 3.17696512e-01f, 3.54626715e-01f, 1.03767835e-01f, 1.70094341e-01f, -1.48676053e-01f, 1.73961028e-01f, 3.37979674e-01f, 7.31934428e-01f, 2.96441108e-01f,
  7.33027101e-01f, 1.84817150e-01f, 4.33013499e-01f, 6.90412700e-01f, 4.21154290e-01f, 5.02128482e-01f, 3.54805410e-01f, 2.80921757e-01f, 3.51860464e-01f, 6.61091745e-01f,
  1.98013663e-01f, -4.72003706e-02f, -2.76676029e-01f, -3.08784753e-01f, -1.08647957e-01f, 2.95221984e-01f, 3.72652560e-01f, -4.24501508e-01f, -1.93792418e-01f, 4.78604376e-01f,
  5.27127564e-01f, 4.09592092e-02f, 3.20074677e-01f, -7.46012852e-02f, 3.22678804e-01f, 3.24442029e-01f, -4.50189859e-01f, -6.23649992e-02f, 5.95991313e-01f, 2.60397494e-01f,
  1.54554039e-01f, 6.17312074e-01f, 2.06840634e-01f, 1.04541071e-01f, 2.68516183e-01f, -1.07735716e-01f, -5.48109375e-02f, 2.15706885e-01f, 5.41450307e-02f, 2.07045078e-01f,
  7.25387260e-02f, 1.61727473e-01f, 1.10131718e-01f, 6.72517866e-02f, 1.64461911e-01f, -4.55927193e-01f, 9.72985476e-02f, 1.28267854e-01f, -1.15225203e-01f, -2.10586973e-02f,
  -4.93679382e-02f, -2.42678583e-01f, 3.75536382e-02f, 2.34327212e-01f, 3.39441687e-01f, 4.11967635e-01f, 6.11873925e-01f, 5.34440279e-01f, -5.55699289e-01f, 3.88339698e-01f,
  3.93935740e-01f, 1.54590502e-01f, -3.65949780e-01f, -1.12673797e-01f, 1.76462874e-01f, 5.82867675e-02f, 9.31770951e-02f, 2.29732037e-01f, 3.96106616e-02f, 4.06387031e-01f,
  2.50678629e-01f, 2.94847161e-01f, 4.39576417e-01f, 3.31078023e-01f, 3.83526742e-01f, -1.47050545e-01f, -3.73801142e-01f, -4.73556161e-01f, 6.17881656e-01f, -1.84887767e-01f,
  5.93552351e-01f, 2.79340774e-01f, -3.36789191e-01f, 3.25731605e-01f, 3.37796539e-01f, -4.26093966e-01f, -4.32018667e-01f, 1.77404005e-02f, 1.10409692e-01f, 2.83583224e-01f,
  1.00901380e-01f, -3.24067652e-01f, 1.86117753e-01f, -4.35061187e-01f, -1.51089683e-01f, -1.08328156e-01f, -3.76108497e-01f, -4.37472135e-01f, 1.28638685e-01f, -2.54947320e-02f,
  9.25187171e-02f, -2.44649872e-01f, -6.02197424e-02f, 7.11593851e-02f, 1.24350809e-01f, -6.87657893e-02f, 9.00948197e-02f, 3.34364057e-01f, 2.78925300e-01f, -2.21762046e-01f,
  -2.76971251e-01f, -3.37251395e-01f, 2.29944438e-02f, 4.65910673e-01f, -1.69161171e-01f, 1.15984559e-01f, 3.06210995e-01f, 1.80067182e-01f, 1.64109599e-02f, 8.06731731e-02f,
  -4.02324110e-01f, -1.57321870e-01f, 4.67249185e-01f, 2.56803870e-01f, -1.99106991e-01f, -6.13439322e-01f, -6.02995530e-02f, -1.25132158e-01f, -2.67528266e-01f, 3.95219445e-01f,
  1.18603788e-01f, 1.69563621e-01f, 1.25539911e-04f, 2.81443506e-01f, 3.10724258e-01f, 3.26258421e-01f, 1.66940168e-01f, 1.95840359e-01f, 1.01115167e-01f, 3.16940427e-01f,
  -2.95049697e-01f, -8.32095891e-02f, 1.38734102e-01f, 5.26452601e-01f, -1.34964362e-02f, 5.55618443e-02f, 3.96429271e-01f, -4.93965328e-01f, 1.11798435e-01f, 1.08936884e-01f,
  4.70533997e-01f, 1.49484217e-01f, 6.79366291e-01f, 5.99914432e-01f, -1.60604864e-01f, 1.16220640e-03f, 7.25005120e-02f, -4.67021078e-01f, -4.67935950e-01f, -3.07975411e-01f,
  -7.07284436e-02f, 1.40262261e-01f, -3.35141979e-02f, -2.92619169e-01f, 1.10906269e-02f, 2.60682732e-01f, -8.76121689e-03f, 3.53258342e-01f, 1.29639998e-01f, 2.29301769e-02f,
  3.92571568e-01f, 5.75994551e-02f, -1.57376364e-01f, -3.84878278e-01f, 5.01773715e-01f, -5.65389693e-01f, 2.97941923e-01f, 6.81582749e-01f, -4.17436868e-01f, 2.17528790e-01f,
  5.23813963e-01f, -8.13236684e-02f, -4.25190002e-01f, 1.97791308e-01f, -1.13124728e-01f, -3.76971886e-02f, 4.98886645e-01f, -1.63586482e-01f, 3.53097647e-01f, -5.42052507e-01f,
  -1.02125809e-01f, 1.74027681e-01f, -3.13508421e-01f, 1.38717264e-01f, 1.38325840e-01f, 1.61165148e-02f, -6.12099655e-03f, -8.38846490e-02f, 2.28211120e-01f, 1.24364994e-01f,
  9.83382240e-02f, 2.23060295e-01f, 4.09700692e-01f, 1.53864503e-01f, 1.74347594e-01f, -3.90324026e-01f, -5.77660382e-01f, -1.49213240e-01f, -2.92753577e-01f, 3.24116528e-01f,
  -2.30882823e-01f, 7.70825297e-02f, 2.94377774e-01f, 4.41495240e-01f, 4.89296436e-01f, 2.15217978e-01f, -2.39450276e-01f, 9.84409899e-02f, 3.45472574e-01f, 6.64922297e-01f,
  -6.38546795e-02f, 1.99644361e-02f, -1.52962372e-01f, 2.17441767e-01f, -7.52884671e-02f, 2.98342347e-01f, -4.98941764e-02f, 4.10071872e-02f, 2.60014474e-01f, 1.43129647e-01f,
  -1.30897969e-01f, -4.25553275e-03f, 3.67837578e-01f, 1.34988338e-01f, 1.16936781e-01f, 6.77024946e-02f, -8.20326582e-02f, 1.14537209e-01f, -3.25880319e-01f, -4.76681352e-01f,
  2.56284773e-01f, 2.08931372e-01f, -3.17410409e-01f, 1.32087111e-01f, 4.65159327e-01f, -1.28997400e-01f, -1.60209060e-01f, 9.89878848e-02f, -1.70035020e-01f, -2.92628467e-01f,
  3.88584018e-01f, 5.65314591e-02f, 4.12871122e-01f, -3.70121002e-01f, 4.51245904e-01f, 3.46606225e-01f, -1.38812885e-01f, -7.49175847e-02f, 1.71748057e-01f, -1.25111207e-01f,
  2.54902899e-01f, 1.24332771e-01f, -1.81370288e-01f, -9.79689509e-02f, 2.86985368e-01f, 6.60364404e-02f, 1.33509785e-01f, 2.19915062e-01f, 1.69134274e-01f, 4.00186807e-01f,
  -4.19590145e-01f, -3.94670635e-01f, -2.62908131e-01f, 2.75837332e-01f, -2.72809505e-01f, 1.10523224e-01f, 2.91676879e-01f, 1.87937155e-01f, -2.61817247e-01f, 1.56129971e-01f,
  -3.36668611e-01f, -4.09680456e-01f, 6.14109755e-01f, 1.50100097e-01f, 4.08033937e-01f, 4.34149146e-01f, 4.66552645e-01f, 5.01974583e-01f, 3.48986000e-01f, -1.83079809e-01f,
  4.48229998e-01f, 3.26761007e-01f, 2.26458982e-01f, 2.15693772e-01f, 2.28584081e-01f, 2.35494286e-01f, 1.43289968e-01f, 4.15932268e-01f, 3.98138851e-01f, -2.78259069e-01f,
  -4.44326758e-01f, -3.02341491e-01f, -2.68797636e-01f, 3.71319354e-01f, -3.45639318e-01f, -1.14858709e-01f, 2.83523798e-01f, -5.10649495e-02f, -1.77209213e-01f, 3.57985407e-01f,
  2.82776773e-01f, -9.12369788e-02f, 3.54036152e-01f, 1.67066142e-01f, -4.94651735e-01f, 3.92597228e-01f, 4.59575444e-01f, 1.73029989e-01f, -1.35115400e-01f, 9.97620970e-02f,
  2.96836376e-01f, 1.59574151e-01f, 4.93648529e-01f, 6.38395190e-01f, 5.53632259e-01f, 3.00429702e-01f, 3.72618616e-01f, 2.17767432e-01f, 4.80227023e-01f, 6.65408432e-01f,
  3.52202326e-01f, -2.68941760e-01f, -2.10303083e-01f, -2.08848611e-01f, -4.53042895e-01f, 9.51233014e-05f, 1.83505878e-01f, -7.01334119e-01f, -3.35866958e-01f, 3.95381242e-01f,
  2.53475189e-01f, 1.11056708e-01f, -6.76445216e-02f, -3.93340021e-01f, -1.88347831e-01f, -2.73944497e-01f, 1.92214116e-01f, 8.73765945e-02f, 3.58591378e-01f, 3.96255314e-01f,
  2.43632615e-01f, 5.34521222e-01f, -2.42009178e-01f, 6.36865273e-02f, 1.45300612e-01f, 3.03479135e-02f, 3.54969352e-01f, -8.44497606e-02f, 7.60213584e-02f, 1.57873735e-01f,
  -1.60026893e-01f, -6.93503842e-02f, 2.02143624e-01f, 2.58235514e-01f, 2.70116270e-01f, 2.05663100e-01f, -4.47840571e-01f, -1.18242748e-01f, -6.33738160e-01f, 4.16718006e-01f,
  -2.67923594e-01f, -1.10576358e-02f, 9.74554643e-02f, 5.30309558e-01f, 8.83466303e-02f, 4.87571031e-01f, -1.58835053e-01f, 1.35343857e-02f, 3.20079356e-01f, 5.70546269e-01f,
  5.31588588e-03f, 2.89982080e-01f, 1.12176500e-01f, 3.14950228e-01f, 4.46750909e-01f, 3.29520643e-01f, -2.27646559e-01f, -1.55063465e-01f, 3.23831029e-02f, -1.58922672e-01f,
  -9.55825076e-02f, 1.63082033e-01f, 1.33799091e-02f, -4.22885306e-02f, 1.79798007e-01f, 4.37780857e-01f, 3.91555339e-01f, 4.19317186e-02f, -5.57060763e-02f, -1.16906658e-01f,
  -4.08216193e-02f, 3.16395760e-01f, -2.17863873e-01f, 1.94270834e-02f, 3.92373711e-01f, 3.01390797e-01f, 1.51090056e-01f, 2.99573213e-01f, 3.32498431e-01f, 3.79928350e-01f,
  1.69139981e-01f, 7.09825233e-02f, -1.88979954e-01f, -2.61389762e-01f, 1.76215861e-02f, -1.71921253e-01f, 1.92239568e-01f, 3.10819447e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  -2.82509271e-02f, 4.32948738e-01f, 2.56897248e-02f, 4.99395639e-01f, 2.95426007e-02f, 1.15813680e-01f, 1.90759450e-01f, 2.40630716e-01f, 4.96892072e-02f, 7.46783912e-02f,
  1.29531369e-01f, 2.22756296e-01f, 9.55621675e-02f, -1.74795128e-02f
};

// L3_fan_Wp (Shape: 9 x 32)
const int L3_fan_Wp_rows = 9;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  1.33884937e-01f, 1.78135201e-01f, 1.42764956e-01f, -6.27655238e-02f, -1.22175559e-01f, 6.76423460e-02f, 1.18968695e-01f, 1.56540275e-01f, 2.10237399e-01f, 2.18852654e-01f,
  3.28679353e-01f, 1.79365396e-01f, -1.80535942e-01f, 2.44730532e-01f, -1.11458957e-01f, 1.07156277e-01f, -1.21262528e-01f, 1.26429632e-01f, -2.00718641e-01f, 1.52166501e-01f,
  9.26001742e-02f, 1.90011606e-01f, 1.47805605e-02f, -2.37443924e-01f, 7.17607886e-02f, 1.55897781e-01f, -1.13923542e-01f, -1.10565521e-01f, 1.37811229e-02f, 1.81138784e-01f,
  -3.52482274e-02f, -2.00617030e-01f, 2.83567663e-02f, -2.92855382e-01f, 3.28236371e-02f, -8.29967782e-02f, 7.61633739e-02f, -5.48259960e-03f, 2.11481601e-01f, -1.89424008e-01f,
  -9.29385051e-02f, 5.03712567e-03f, -3.71123910e-01f, 2.87962351e-02f, 7.52803981e-02f, -2.44471431e-01f, -3.11021041e-02f, -1.32483751e-01f, 9.22261924e-02f, 1.43786982e-01f,
  1.36932060e-01f, 1.65330376e-02f, 5.85580133e-02f, -1.20574288e-01f, 1.59776472e-02f, -1.01579286e-01f, -1.69555880e-02f, -5.32783382e-02f, -9.93999541e-02f, -1.83058783e-01f,
  -3.62313516e-03f, -2.21710116e-01f, 2.01532483e-01f, 6.53098375e-02f, -2.43701804e-02f, 1.01109169e-01f, 8.17340463e-02f, -1.03983350e-01f, -3.81780677e-02f, 1.96666270e-02f,
  6.26097396e-02f, -1.48557186e-01f, 4.79582464e-03f, 1.78708866e-01f, -2.85237461e-01f, -3.76293570e-01f, 4.73295748e-02f, -1.57800063e-01f, 1.41134039e-01f, 5.75597547e-02f,
  2.43783459e-01f, 5.11461571e-02f, -9.57865641e-02f, -1.18037902e-01f, -1.44417984e-02f, -2.95012504e-01f, 1.82995737e-01f, 2.37467021e-01f, -1.31594330e-01f, 2.15238780e-01f,
  -8.80646482e-02f, 6.46972135e-02f, 1.20455384e-01f, -1.53410926e-01f, -7.35085756e-02f, 5.11099435e-02f, -1.51565090e-01f, -9.34909731e-02f, 4.76275235e-02f, 9.48908404e-02f,
  -8.80005807e-02f, 5.72827421e-02f, -1.42661765e-01f, -1.22158915e-01f, -1.98846981e-02f, -6.24443255e-02f, -2.02108249e-01f, 5.40668610e-03f, 4.18108255e-01f, -1.26312390e-01f,
  -4.77394648e-02f, -2.24791497e-01f, 1.95825592e-01f, 3.90622556e-01f, 9.81997177e-02f, -9.33785364e-02f, 2.21544243e-02f, -3.09054732e-01f, 1.58707723e-01f, -1.39415309e-01f,
  -1.34625152e-01f, 1.25536755e-01f, 8.43548551e-02f, 2.35021412e-01f, -3.77457514e-02f, 4.73999456e-02f, -5.02252616e-02f, 1.60977557e-01f, -1.51288703e-01f, -1.39578342e-01f,
  4.11867723e-03f, 6.26435783e-03f, 5.92877064e-03f, -2.92446584e-01f, -4.41925898e-02f, -9.82737318e-02f, -2.26975139e-02f, 1.32359639e-01f, 5.67949787e-02f, -3.85170132e-01f,
  -1.15826420e-01f, 6.70500025e-02f, -1.51542649e-01f, 1.40273375e-02f, 1.73215866e-01f, -4.46834803e-01f, 3.59249674e-02f, -1.55844400e-02f, 5.85560687e-02f, 5.28141037e-02f,
  1.59066483e-01f, 2.31087565e-01f, -1.06718354e-01f, -1.21699490e-01f, -1.88547805e-01f, -1.93236530e-01f, 1.07124165e-01f, 1.48395166e-01f, -6.41579777e-02f, -6.24194182e-02f,
  -2.17635557e-01f, 2.42666993e-02f, -1.95226446e-01f, 1.30315036e-01f, 1.86731160e-01f, 8.15536641e-03f, 6.91777766e-02f, -1.63871974e-01f, 8.44472870e-02f, 2.27670163e-01f,
  -2.02503845e-01f, 9.62514617e-03f, 3.63914847e-01f, -3.44333053e-02f, -2.92958748e-02f, -3.06721926e-01f, -3.32604423e-02f, 1.19534269e-01f, 2.19102249e-01f, -3.16715091e-02f,
  -2.62256086e-01f, -2.16600940e-01f, 6.47376254e-02f, -3.17864493e-02f, -3.43006581e-01f, -8.29486996e-02f, 1.48115799e-01f, 6.11936338e-02f, -2.07347199e-02f, 8.75266418e-02f,
  1.37926847e-01f, 2.57579476e-01f, 6.52067512e-02f, -8.20312873e-02f, -2.00219706e-01f, 9.69364643e-02f, 1.08515121e-01f, 9.02204886e-02f, -1.42892346e-01f, 4.79888869e-03f,
  -2.36485630e-01f, 5.68629690e-02f, -1.92746043e-01f, -1.40155345e-01f, 1.29536882e-01f, -6.49539456e-02f, 1.57779440e-01f, -2.36343324e-01f, 1.88980758e-01f, 1.48289323e-01f,
  1.88701004e-01f, -6.13774508e-02f, 4.62376773e-02f, -1.94344401e-01f, 1.29238784e-01f, -1.06914833e-01f, -2.78655827e-01f, -8.42162594e-02f, 1.89026013e-01f, 2.81967491e-01f,
  -1.30230606e-01f, -1.02811880e-01f, 1.93359132e-03f, 7.15402290e-02f, -1.40758127e-01f, 1.59338385e-01f, -2.37559706e-01f, -1.81652173e-01f, 8.43981132e-02f, 2.09570587e-01f,
  -1.91907987e-01f, 1.61704883e-01f, -1.22466803e-01f, -1.93947062e-01f, 5.35635948e-02f, 1.47721991e-01f, 3.93302530e-01f, 9.67684761e-02f, 2.13503227e-01f, -4.18974124e-02f,
  -2.41591278e-02f, 4.46832061e-01f, 6.49996176e-02f, -1.37943998e-01f, 1.48351118e-02f, -1.77177265e-01f, 1.05447538e-01f, -1.98132545e-01f, 2.02396646e-01f, -2.77947821e-02f,
  1.01157203e-01f, 1.02798752e-01f, -3.25823613e-02f, 6.62329122e-02f, 4.52931970e-02f, 1.25901505e-01f, 1.44581124e-01f, 6.73562810e-02f, -2.19097570e-01f, -2.35808820e-01f,
  1.97087124e-01f, 9.24148262e-02f, -8.84327851e-03f, 6.08994924e-02f, -1.42721891e-01f, -1.08215325e-01f, -2.55727142e-01f, -2.33763799e-01f, 2.58431166e-01f, -2.44946033e-01f,
  2.10461751e-01f, -8.39693192e-03f, -2.67900050e-01f, 2.76851863e-01f, -1.93769131e-02f, -8.99917558e-02f, 9.00991037e-02f, -1.69956267e-01f, 1.78576447e-02f, 7.17025697e-02f,
  -1.28325615e-02f, 8.58428404e-02f, -9.72293839e-02f, -5.08393534e-02f, -9.09971148e-02f, -2.15897053e-01f, 2.40555056e-03f, 1.59367725e-01f
};

// L3_fan_Wp_bar (Shape: 14 x 32)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  1.49028659e-01f, 1.48533359e-01f, -1.40633155e-02f, -7.74159506e-02f, -6.58665076e-02f, 4.80577536e-02f, -5.75963706e-02f, 8.17167852e-03f, -8.49779248e-02f, -2.18889698e-01f,
  -3.68808717e-01f, -3.10149729e-01f, -2.09701285e-01f, 1.42154414e-02f, -4.61709313e-02f, -6.89756498e-02f, 2.09207088e-01f, -5.16264029e-02f, 5.44660032e-01f, 2.77395338e-01f,
  4.72032815e-01f, -1.90461546e-01f, -8.06272924e-02f, 4.51316029e-01f, -6.27292573e-01f, 3.27593923e-01f, -4.39965159e-01f, -1.74092632e-02f, 1.22182131e-01f, -4.08163637e-01f,
  2.31680810e-01f, 4.02023159e-02f, 2.30786741e-01f, 2.96240687e-01f, -7.82331303e-02f, -3.03805023e-01f, -2.13452756e-01f, -2.30379865e-01f, -4.44698870e-01f, -2.95338511e-01f,
  -2.46551111e-01f, -2.16142327e-01f, 3.67432386e-01f, 2.80453295e-01f, 1.39467448e-01f, 1.55164972e-01f, 2.63975468e-02f, 1.50366640e-03f, -9.23549831e-02f, 7.68064618e-01f,
  -4.35341597e-01f, 9.17781238e-03f, 9.20188427e-03f, -3.62884879e-01f, 2.92185009e-01f, -1.32825509e-01f, -2.50459254e-01f, 4.52471495e-01f, 1.14003167e-01f, 2.75660038e-01f,
  6.92454427e-02f, 3.66294563e-01f, 3.02881241e-01f, 7.52708316e-02f, -3.97357613e-01f, -2.36088142e-01f, 2.93174654e-01f, 1.60791993e-01f, -5.58455102e-02f, 8.21912363e-02f,
  5.79258204e-01f, 9.29562896e-02f, 2.72644281e-01f, 4.87725496e-01f, 2.39780217e-01f, -6.90219477e-02f, 1.34295911e-01f, -2.22874030e-01f, -4.85507786e-01f, -4.81909335e-01f,
  9.01086628e-01f, -3.86896402e-01f, 5.71093023e-01f, 2.61565238e-01f, -4.04580720e-02f, -3.97375286e-01f, -5.44848561e-01f, 1.73404574e-01f, -3.42593729e-01f, -3.86508331e-02f,
  -3.06815840e-02f, 3.71631794e-02f, 5.31805396e-01f, 2.29359210e-01f, 1.48691878e-01f, -2.62461692e-01f, -6.46106387e-03f, -1.60354659e-01f, 2.59002745e-01f, 3.34990233e-01f,
  4.69963029e-02f, 1.59077924e-02f, 2.00779468e-01f, 2.29345202e-01f, 2.64440835e-01f, 3.01787496e-01f, 4.65629518e-01f, 1.64904937e-01f, 1.04899816e-01f, -1.12748303e-01f,
  -3.13065469e-01f, 1.71753824e-01f, -9.77679938e-02f, -3.48226279e-01f, 9.45301801e-02f, 2.49318317e-01f, -3.75873893e-01f, 5.58573484e-01f, 1.13583975e-01f, -1.67851418e-01f,
  5.26468039e-01f, -3.35576124e-02f, 4.40188110e-01f, 2.38658324e-01f, -2.48680398e-01f, 5.10201633e-01f, -1.23464502e-01f, -1.74753472e-01f, -1.17757268e-01f, 1.82942376e-01f,
  -1.68580964e-01f, 2.32774280e-02f, 2.53753334e-01f, 1.42805323e-01f, 5.86221255e-02f, -1.56080022e-01f, -1.18425637e-01f, -1.65770799e-01f, -5.15377559e-02f, 3.21973920e-01f,
  4.91403013e-01f, 5.25576482e-03f, 3.46621126e-01f, -3.08521628e-01f, 2.61628684e-02f, 8.38194728e-01f, 2.82778919e-01f, -3.80205847e-02f, 6.69472665e-02f, -5.83823144e-01f,
  4.67779130e-01f, -2.99113482e-01f, 9.52050090e-02f, 5.04829228e-01f, 1.48320854e-01f, 5.54606974e-01f, 1.86119258e-01f, 2.67171621e-01f, 6.92498088e-01f, 1.76633537e-01f,
  3.23561579e-01f, 2.13774279e-01f, -4.14574295e-02f, 7.95051232e-02f, 3.76650810e-01f, 2.77906775e-01f, 4.41868491e-02f, 2.31850386e-01f, 1.02315545e-01f, -3.00939262e-01f,
  2.28396609e-01f, 4.36279416e-01f, 3.60582955e-02f, 1.82515591e-01f, 2.05979034e-01f, 5.41866481e-01f, -5.87822020e-01f, 1.62691444e-01f, 6.46718368e-02f, 1.18608750e-01f,
  -2.96968997e-01f, 3.78564745e-01f, 3.83682519e-01f, -2.42362827e-01f, 8.73725653e-01f, 3.91318321e-01f, 5.18828452e-01f, 4.13302571e-01f, -3.25101376e-01f, 5.92868365e-02f,
  1.89375192e-01f, 3.81056428e-01f, 8.14290717e-03f, 2.43716054e-02f, 5.09928912e-04f, 2.54209310e-01f, 3.29039574e-01f, -1.75009847e-01f, 9.74267870e-02f, 6.97210282e-02f,
  1.34763822e-01f, 3.27765226e-01f, -1.79536521e-01f, -2.42910579e-01f, 7.03181744e-01f, -3.06611151e-01f, 2.30181441e-02f, -8.91798884e-02f, -9.82474014e-02f, 2.35355943e-01f,
  -1.20948367e-02f, 4.11830433e-02f, 1.07837841e-01f, -1.99961483e-01f, 4.83386397e-01f, -8.87053907e-02f, 9.36003923e-02f, 4.83751714e-01f, 1.66539818e-01f, 2.63707429e-01f,
  -7.37052113e-02f, -6.23985492e-02f, 5.45620024e-01f, 3.56496155e-01f, 2.27277562e-01f, 3.83448675e-02f, 4.30967093e-01f, 4.04612757e-02f, -5.80043316e-01f, -2.58397311e-01f,
  2.64504313e-01f, -3.15585025e-02f, 2.77612090e-01f, 5.94878078e-01f, 5.98144829e-01f, 1.78846762e-01f, -4.17868972e-01f, 3.11892509e-01f, -4.46591973e-01f, 1.58195421e-01f,
  4.74569559e-01f, -3.58945638e-01f, -6.54267788e-01f, 3.50859940e-01f, 5.59317432e-02f, 7.07318187e-02f, -3.69109631e-01f, 3.87942828e-02f, -3.76790613e-01f, 2.42182106e-01f,
  -2.90721953e-01f, -1.58295766e-01f, 3.00091684e-01f, 6.17931843e-01f, -1.66962802e-01f, -3.92227739e-01f, 1.00810483e-01f, -1.76378619e-02f, -4.00460400e-02f, 3.07257861e-01f,
  2.52937358e-02f, 1.63428068e-01f, 2.84348428e-01f, 2.01303050e-01f, 3.39421153e-01f, 3.02370995e-01f, 4.80663896e-01f, 4.31350559e-01f, -1.27156124e-01f, 1.99145406e-01f,
  -2.75854260e-01f, 1.07068643e-01f, -3.96405786e-01f, -3.88032526e-01f, -1.80808023e-01f, 3.88292909e-01f, -1.25563353e-01f, 6.00613177e-01f, -1.04068279e-01f, -5.53183556e-01f,
  5.12357652e-01f, -1.19033940e-01f, 5.31822860e-01f, 2.57770181e-01f, -4.33758199e-02f, 5.21875560e-01f, -2.19531849e-01f, -4.50509906e-01f, 3.08387667e-01f, 2.81733364e-01f,
  -5.59965014e-01f, -1.26861095e-01f, 3.93531680e-01f, 5.88780165e-01f, -5.85859120e-01f, 1.99795559e-01f, -1.11230485e-01f, -1.00049043e+00f, -5.16205430e-01f, 9.48849395e-02f,
  -5.61220944e-01f, 5.44884026e-01f, 2.66777903e-01f, 3.26910734e-01f, -4.29842383e-01f, 3.60736638e-01f, -1.16500638e-01f, 1.76004395e-01f, 5.56381166e-01f, 4.67321008e-01f,
  -2.33157910e-02f, 3.90400112e-01f, 6.55881107e-01f, 1.30425468e-01f, -3.37410229e-03f, -1.44691020e-01f, 1.85743347e-01f, -3.58719409e-01f, 9.63374749e-02f, 3.21607292e-01f,
  3.60919148e-01f, -2.93152004e-01f, 3.67948622e-01f, -4.03127680e-03f, -1.82065174e-01f, 1.35259867e-01f, 1.48038298e-01f, 4.83059525e-01f, -1.19649448e-01f, 3.08733433e-01f,
  2.33595699e-01f, -2.73689628e-01f, -2.59142190e-01f, 2.92277068e-01f, -3.05845827e-01f, 2.79925227e-01f, 1.68462977e-01f, -5.70966303e-01f, -3.64334017e-01f, 7.17108846e-01f,
  3.56208473e-01f, 3.44850272e-01f, 1.22696478e-02f, 6.65950775e-01f, -1.01609983e-01f, 2.49389797e-01f, -2.00179145e-01f, -6.06622934e-01f, 4.09250736e-01f, 2.31819302e-01f,
  -2.46477723e-01f, 2.05274940e-01f, -3.00403327e-01f, -1.23796090e-01f, -5.83404660e-01f, -1.02253579e-01f, 3.14279050e-01f, 7.11921975e-02f, -2.49559581e-01f, -3.82877260e-01f,
  6.79100975e-02f, 1.65510625e-01f, -2.03447744e-01f, -9.71694142e-02f, 3.27008128e-01f, -3.21266115e-01f, -2.73818504e-02f, -5.42124867e-01f, 3.61207724e-01f, -3.25971991e-01f,
  8.30044866e-01f, 3.27903479e-01f, 1.10660456e-01f, -2.35949337e-01f, -4.26290244e-01f, -4.15790938e-02f, -1.11349016e-01f, -1.43460393e-01f, 2.82306969e-01f, 6.38292670e-01f,
  1.10731736e-01f, 1.76033348e-01f, 2.51688331e-01f, 1.53386444e-01f, -1.36837885e-01f, -1.87739372e-01f, 3.88968408e-01f, 3.35529983e-01f, -9.13188383e-02f, -2.04273701e-01f,
  3.07095498e-01f, 2.24557281e-01f, 1.39528781e-03f, 5.54351628e-01f, 5.91617823e-01f, 3.12292367e-01f, 5.79825379e-02f, 1.37697354e-01f, -4.24210638e-01f, 1.64250612e-01f,
  3.04181695e-01f, -5.32481968e-01f, -1.24431826e-01f, 4.21812981e-01f, 1.62984729e-01f, 1.48446187e-01f, -3.89786698e-02f, -1.05934039e-01f, -2.27206703e-02f, 1.42069189e-02f,
  3.18589836e-01f, 4.53922339e-02f, 1.99826270e-01f, 6.01983964e-01f, -2.48343959e-01f, -5.39230049e-01f, 3.32131386e-02f, 2.44932547e-01f, 2.09877506e-01f, -4.14745100e-02f,
  4.65278737e-02f, 1.43688008e-01f, 9.53192562e-02f, -2.14330286e-01f, 2.16420852e-02f, 1.79487661e-01f, 6.85257167e-02f, -5.21709323e-01f, -1.10873282e-01f, 2.01567113e-01f,
  7.49066621e-02f, 2.03540608e-01f, 2.51108170e-01f, 1.43464044e-01f, -6.08584546e-02f, 8.90257061e-02f, 3.86296332e-01f, -3.35017741e-01f, 1.04998983e-01f, 1.29441917e-01f,
  -5.61054766e-01f, 3.80096078e-01f, -1.39548168e-01f, -2.96136498e-01f, 5.30864835e-01f, -1.99244604e-01f, 1.38639092e-01f, 6.14988692e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  1.18751861e-01f, -1.67522192e-01f, 2.36268803e-01f, 3.41714770e-01f, 1.91412151e-01f, 2.26672083e-01f, -8.62930864e-02f, 4.07300800e-01f, 4.94962335e-02f, 4.58432764e-01f,
  1.77229524e-01f, 1.24570705e-01f, 2.26966202e-01f, 1.83371857e-01f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -7.45162135e-03f, 2.55719185e-01f, 1.76369920e-01f, -1.62797496e-01f, 5.99560365e-02f, -9.64387879e-02f, 1.95395306e-01f, 8.16573426e-02f, -1.26394272e-01f, -8.92584622e-02f,
  -1.14502236e-02f, 2.52244711e-01f, -2.87006617e-01f, 3.98167163e-01f, -2.43190795e-01f, -9.68627483e-02f, -2.10237056e-01f, 3.80222589e-01f, 1.46205813e-01f, -1.82962269e-01f,
  -5.87293029e-01f, -1.71730101e-01f, -6.10337794e-01f, -2.53977567e-01f, -2.90949941e-01f, -4.03047562e-01f, -4.43668753e-01f, 5.00311136e-01f, 4.12008345e-01f, -2.02363674e-02f,
  -6.47133529e-01f, 3.58866043e-02f, -1.17661888e-02f, -1.67219952e-01f, -2.58296520e-01f, 2.20446914e-01f, 5.35211992e-03f, 2.84942776e-01f, 2.71456808e-01f, -9.49738324e-02f,
  3.15871462e-02f, -3.43187928e-01f, 2.35360339e-01f, 7.83763677e-02f, 7.72233605e-02f, 2.98840046e-01f, 4.18047160e-02f, -4.51760218e-02f, -2.35328361e-01f, 3.76002133e-01f,
  1.64819583e-01f, -5.32779098e-01f, 4.10331607e-01f, -1.35643512e-01f, -1.09928437e-01f, -6.53314769e-01f, 2.33328223e-01f, -4.82587278e-01f, -7.50506744e-02f, -2.14445814e-02f,
  1.56885922e-01f, 2.51073688e-01f, -4.41392630e-01f, 2.47022644e-01f, 2.65525724e-03f, 7.60069564e-02f, 2.01664507e-01f, -2.93322235e-01f, -1.74734876e-01f, 1.64930508e-01f,
  -2.32745081e-01f, -4.50670905e-02f, 2.09917098e-01f, -8.73348676e-04f, 1.78107917e-01f, 1.17258959e-01f, 1.82331607e-01f, -3.84312242e-01f, 1.42120570e-01f, 2.31314898e-01f,
  3.43382448e-01f, -8.66975822e-03f, 2.32278600e-01f, 1.97930112e-01f, -5.20129874e-02f, -4.95512545e-01f, 1.81953400e-01f, -2.11929187e-01f, -1.98733602e-02f, -2.77380645e-01f,
  -3.95837486e-01f, 5.32966256e-02f, -5.36001682e-01f, 5.07613897e-01f, -2.39685208e-01f, -8.31733197e-02f, 2.97181122e-02f, -1.96263149e-01f, -3.40232700e-01f, 7.52222240e-02f,
  -1.63256288e-01f, 2.68272221e-01f, 3.66443515e-01f, -2.53004164e-01f, -2.81013668e-01f, 3.09493244e-01f, 2.19532222e-01f, -1.49862409e-01f, 4.17094976e-01f, -5.16836857e-03f,
  2.63198018e-01f, 3.00488144e-01f, 2.99223494e-02f, -2.16464505e-01f, -5.57888970e-02f, 4.40294825e-04f, -5.85474312e-01f, 3.13874185e-01f, -5.15017696e-02f, 2.26914570e-01f,
  1.99440271e-01f, -5.88942707e-01f, 3.52586567e-01f, -4.83279258e-01f, -4.54178602e-01f, -1.06160656e-01f, 1.94801211e-01f, -1.17491789e-01f, -2.53077094e-02f, -2.83924729e-01f,
  4.90455367e-02f, -1.63707584e-01f, 3.88275594e-01f, 6.34268448e-02f, -2.99551785e-01f, 4.68239516e-01f, -1.73865378e-01f, -1.96985509e-02f, 9.24502462e-02f, 2.72206143e-02f,
  -1.06785215e-01f, -1.59522831e-01f, 1.47404611e-01f, -3.69373001e-02f, -3.40418130e-01f, 1.59167703e-02f, -2.85556614e-01f, -4.54148985e-02f, -6.06747568e-01f, 2.49777928e-01f,
  -4.72487748e-01f, 1.81654215e-01f, -3.32814783e-01f, -1.16239756e-01f, 3.84378284e-01f, 1.12777203e-01f, 2.34562173e-01f, -3.33603024e-01f, 1.93113461e-01f, -1.06419496e-01f,
  -5.48392534e-02f, 1.29641697e-01f, 2.10933581e-01f, 9.22575369e-02f, -2.09552824e-01f, -1.18524373e-01f, -1.78290814e-01f, -2.63729692e-01f, 4.99155298e-02f, 4.05766934e-01f,
  -2.36954346e-01f, 5.09076834e-01f, -2.99920708e-01f, 1.63872525e-01f, -2.87397295e-01f, -7.91040212e-02f, -1.65995285e-01f, -4.10828292e-01f, 1.34608999e-01f, 1.34309649e-01f,
  2.29342654e-01f, -3.51920158e-01f, -3.79164875e-01f, -3.55282098e-01f, -2.94017136e-01f, 3.70068192e-01f, -5.29499173e-01f, -8.47776383e-02f, 2.46697545e-01f, -2.67879963e-01f,
  1.75612196e-01f, 4.15316939e-01f, -2.75749356e-01f, 1.10040553e-01f, 2.62187958e-01f, -1.18770577e-01f, 2.43237883e-01f, 1.70578331e-01f, 8.33788961e-02f, 3.35602731e-01f,
  -2.05662221e-01f, -1.30179524e-02f, -1.94082722e-01f, -9.38691199e-02f, 4.26798254e-01f, -5.19730002e-02f, 3.71600240e-01f, 8.24811589e-03f, -5.87917715e-02f, -2.10849971e-01f,
  -2.82446116e-01f, 4.95817631e-01f, 2.32726768e-01f, -1.30018324e-01f, 2.65392393e-01f, -3.11576545e-01f, 2.99413060e-03f, 1.34130046e-01f, 2.57083923e-02f, -4.74491835e-01f,
  -1.08045414e-02f, 4.23416942e-02f, 1.72227427e-01f, 4.11203429e-02f, 3.45708221e-01f, -1.36498764e-01f, -1.77878246e-01f, -8.51726457e-02f, 6.64906204e-02f, -2.67428041e-01f,
  -3.75273339e-02f, -5.54440245e-02f, -1.44417286e-01f, -1.98912278e-01f, -1.57793760e-01f, -1.44328564e-01f, 2.74991006e-01f, -2.20425561e-01f, 2.17663795e-01f, 3.19644183e-01f,
  2.30055436e-01f, -8.96003097e-02f, -3.41085643e-01f, -5.69804013e-01f, 6.76849484e-01f, 1.87164962e-01f, -1.57653466e-02f, -5.91760576e-02f, -1.59620732e-01f, -4.81130540e-01f,
  4.74889874e-02f, -4.84173924e-01f, -2.91438878e-01f, 4.45791423e-01f, 2.18531311e-01f, -4.28105652e-01f, -2.83753090e-02f, -1.75688881e-02f, -2.41648927e-01f, -2.43326321e-01f,
  9.22759697e-02f, -4.13534120e-02f, 2.08390340e-01f, 7.19574541e-02f, -2.98881978e-01f, -1.00758627e-01f, 1.08490855e-01f, 1.14668384e-01f, 3.41770887e-01f, -1.07523330e-01f,
  -9.72176418e-02f, 1.48610398e-01f, 2.47316301e-01f, 1.31271675e-01f, 4.41528484e-02f, 2.71170527e-01f, -5.34371734e-01f, -6.03115931e-02f, 1.60153776e-01f, -1.29522473e-01f,
  3.27593327e-01f, -4.73415345e-01f, -3.61158937e-01f, 1.24914758e-01f, 1.25156060e-01f, -4.18120503e-01f, -4.33790833e-02f, 2.09582165e-01f, -2.86274552e-01f, 1.53783467e-02f,
  -3.57080624e-02f, -2.96128709e-02f, -3.62696052e-02f, 1.78189993e-01f, -2.69798040e-01f, -1.45311043e-01f, -2.17570603e-01f, 9.51340273e-02f, -9.04568583e-02f, -3.44605327e-01f,
  -3.59700382e-01f, 5.25573194e-01f, -2.94420779e-01f, -1.61169782e-01f, -3.71988416e-01f, 1.92438383e-02f, -4.83887494e-01f, -2.33587891e-01f, 2.19218805e-01f, 2.05336481e-01f,
  -4.08825189e-01f, -2.96336412e-01f, -3.41312706e-01f, 3.99926931e-01f, 1.96852148e-01f, -8.19626272e-01f, 3.01575333e-01f, -3.47724676e-01f, 3.80016416e-01f, -2.40691200e-01f,
  1.99663892e-01f, 1.25677958e-01f, 2.38487497e-01f, -2.16255069e-01f, -2.07036600e-01f, -3.43646288e-01f, -4.21794504e-02f, -2.03367859e-01f, 5.67710102e-02f, -2.46013403e-02f,
  -1.63238831e-02f, 4.84202392e-02f, 4.76307934e-03f, 1.39441788e-01f, 2.54448593e-01f, 3.43577296e-01f, -1.87194757e-02f, 3.41019630e-02f, -2.28463203e-01f, 3.56089562e-01f,
  -5.21944702e-01f, -1.86411198e-02f, 3.15971971e-01f, 3.09952676e-01f, 2.88410336e-01f, -1.10585697e-01f, -3.00070226e-01f, -3.77228111e-01f, -3.95354003e-01f, -3.07639353e-02f,
  -4.47555661e-01f, -6.29301488e-01f, 2.68867999e-01f, 5.78248762e-02f, 4.53010276e-02f, 3.64004433e-01f, -8.44078884e-02f, 5.06076477e-02f, 1.60355645e-04f, 1.19105771e-01f,
  4.07129228e-01f, 3.78089875e-01f, -4.59537923e-01f, -4.41065639e-01f, -4.83503431e-01f, -4.79698300e-01f, -3.80756468e-01f, -2.93215126e-01f, 3.33635479e-01f, -2.95123905e-01f,
  -3.97247583e-01f, -4.17005979e-02f, -2.70869911e-01f, 1.29351586e-01f, 4.90843244e-02f, 3.84411842e-01f, -2.49843001e-01f, -2.25391626e-01f, 2.14590847e-01f, 6.74591899e-01f,
  -6.99757993e-01f, -8.33933294e-01f, -3.94527704e-01f, -2.57113606e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  1.27361029e-01f, -9.06744972e-02f, 1.13938838e-01f, -4.67770658e-02f, 4.02509794e-02f, -7.28853121e-02f, 1.05447128e-01f, -1.58697978e-01f, -1.05475031e-01f, -6.70413747e-02f,
  -1.61374472e-02f, 1.30321026e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    