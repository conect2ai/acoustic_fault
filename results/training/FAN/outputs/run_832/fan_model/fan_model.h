/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.58347797e-03f, -4.26512547e-02f, -8.69663283e-02f, -1.89538002e-01f, -2.64467835e-01f, -2.94195823e-02f, 3.79829779e-02f, 1.83867455e-01f, 1.33619741e-01f, -4.93755825e-02f,
  -1.14160344e-01f, -1.71605483e-04f, -4.36624363e-02f, 3.13665532e-02f, 3.74275632e-02f, -6.68198019e-02f, -1.16079673e-01f, -6.34355992e-02f, 9.34531242e-02f, 1.00393988e-01f,
  -1.12868212e-02f, -1.47702277e-01f, -1.80827696e-02f, -6.71742707e-02f, -9.27459002e-02f, -2.91206203e-02f, -1.29516810e-01f, -1.26252040e-01f, -9.55370963e-02f, -3.12879205e-01f,
  -1.33896440e-01f, -9.19013843e-02f, 4.79785278e-02f, -9.58612654e-03f, -1.43508032e-01f, 6.72116056e-02f, 4.84510921e-02f, 6.12371303e-02f, 9.14293379e-02f, -1.70178115e-02f,
  -1.07667498e-01f, 3.10268905e-03f, -6.10915497e-02f, -5.66078909e-03f, -5.17451353e-02f, 8.70190486e-02f, 1.96472509e-03f, 5.75539060e-02f, -4.18397933e-02f, 2.38314066e-02f,
  -9.12390575e-02f, -2.87319510e-03f, 5.40011078e-02f, 1.00814059e-01f, 3.27971093e-02f, -1.14915870e-01f, 3.93572263e-02f, 1.05048493e-02f, -1.60145137e-04f, 1.15891390e-01f,
  1.21285312e-01f, -2.28525512e-02f, 4.81675286e-03f, 2.71539558e-02f, 4.35022153e-02f, 2.37334128e-02f, -2.07578130e-02f, -3.17544565e-02f, -1.14331711e-02f, 3.83593328e-02f,
  7.66201178e-04f, -9.91447195e-02f, -7.36984517e-03f, 4.24327962e-02f, -1.05281994e-01f, -2.55156178e-02f, -3.14094722e-02f, 4.72026728e-02f, 4.97311167e-03f, 1.02543943e-02f,
  6.01261295e-02f, -1.09761015e-01f, -1.65282842e-02f, 2.45810533e-03f, -3.48159969e-02f, -4.88925800e-02f, -4.42789830e-02f, 1.22217461e-01f, -4.48209606e-02f, -1.08083449e-01f,
  6.80414438e-02f, -1.80588756e-02f, -1.30139381e-01f, 9.46746580e-03f, -7.15771392e-02f, -5.94724193e-02f, -1.09103754e-01f, 4.59578000e-02f, -1.09048061e-01f, 2.49725971e-02f,
  -2.47740392e-02f, 1.25143006e-01f, -7.56001845e-02f, -2.08356753e-02f, 5.55760227e-02f, -3.70510179e-03f, 4.98621128e-02f, -1.82967871e-01f, 8.32083542e-03f, -3.25388052e-02f,
  4.73512486e-02f, 4.74884920e-02f, 5.92090376e-02f, 1.35985374e-01f, 4.68028672e-02f, -2.05526166e-02f, 1.14324749e-01f, 1.14068374e-01f, 6.17651902e-02f, 3.43800157e-01f,
  3.42342496e-01f, -3.19285512e-01f, 2.50271171e-01f, -1.20395839e-01f, -6.34109378e-02f, 1.50512025e-01f, 1.03356898e-01f, 1.57525077e-01f, -8.66370574e-02f, -9.18397158e-02f,
  -1.09339707e-01f, -6.98850816e-03f, -6.03712127e-02f, 4.07734923e-02f, 2.98065573e-01f, 3.65608595e-02f, 3.29214931e-02f, 2.18356207e-01f, 3.83292586e-01f, 1.96825057e-01f,
  -1.52817085e-01f, 5.34004811e-03f, 1.07956931e-01f, 1.15713693e-01f, -3.01309228e-01f, -5.26811928e-02f, -1.19339593e-01f, -4.08535115e-02f, -1.08016089e-01f, -3.03561181e-01f,
  1.76505037e-02f, -6.27097301e-03f, 1.75040185e-01f, -1.31700877e-02f, -1.37808591e-01f, 5.62717244e-02f, 7.10895583e-02f, 2.56600548e-02f, 1.00559238e-02f, 3.62907499e-02f,
  -5.93102276e-02f, -2.80835032e-02f, 6.58415109e-02f, -1.27831161e-01f, -7.10263625e-02f, -2.35638581e-02f, 7.15954527e-02f, 1.95169389e-01f, 1.32028371e-01f, -3.64111476e-02f,
  -5.62293082e-02f, -3.94060800e-04f, 1.21635176e-01f, -5.32871261e-02f, 1.67641938e-01f, 3.41088884e-02f, -1.23921424e-01f, -2.09351666e-02f, 9.96456742e-02f, -2.16436550e-01f,
  -6.56864978e-03f, 5.06601073e-02f, -6.82698414e-02f, -9.65090375e-03f, -1.18521098e-02f, 2.03979071e-02f, -3.02323550e-02f, -4.91196588e-02f, -4.18978892e-02f, -4.74345386e-02f,
  2.82803122e-02f, -1.19938944e-02f, -2.11593881e-02f, 3.01210885e-03f, -5.22920899e-02f, 5.62492646e-02f, -1.79625675e-02f, -1.95133574e-02f, -2.30136458e-02f, -1.24043729e-02f,
  -8.51382129e-03f, 6.24891445e-02f, -6.49494082e-02f, -2.65983120e-02f, 2.09961738e-02f, 4.53058444e-02f, 5.40214926e-02f, -1.30940499e-02f, 3.59922349e-02f, 7.07171019e-03f,
  -8.51411745e-02f, 2.11632907e-01f, -2.16323603e-02f, 1.28351614e-01f, -2.93954127e-02f, -2.06976850e-03f, -7.44689032e-02f, 2.97722016e-02f, -4.03268412e-02f, 4.24215309e-02f,
  5.78783080e-02f, 8.89530256e-02f, -2.89590899e-02f, 2.23104954e-02f, 4.10750732e-02f, 2.81256158e-02f, -1.43241346e-01f, -1.47601720e-02f, 5.41193224e-02f, -4.87647168e-02f,
  -5.94293978e-03f, 3.18484716e-02f, 9.00069773e-02f, 7.37983063e-02f, 7.78218359e-02f, 1.81087598e-01f, 2.23338809e-02f, -1.97739415e-02f, 2.73166448e-01f, -9.56119075e-02f,
  2.60897070e-01f, -3.78548414e-01f, -6.62310570e-02f, -3.76845598e-02f, 6.22163415e-02f, 1.43390581e-01f, -1.92594558e-01f, -1.37110939e-02f, 7.23164901e-02f, -1.64434522e-01f,
  1.03119858e-01f, 2.40715936e-01f, 7.64578730e-02f, 1.53924480e-01f, 9.30652544e-02f, -1.91012189e-01f, -8.91612172e-02f, 2.64068749e-02f, 3.19817454e-01f, 1.61688611e-01f,
  4.37211208e-02f, -6.08417206e-02f, 4.58240230e-03f, -5.72712384e-02f, -1.38906837e-01f, 1.64962545e-01f, -8.03389400e-02f, -1.13000818e-01f, -1.09878313e-02f, -2.68041670e-01f,
  1.03333525e-01f, -6.82973191e-02f, 7.67635703e-02f, 1.55175542e-02f, 3.45027749e-03f, 2.59438501e-04f, 4.08204682e-02f, -5.89647368e-02f, 3.38587761e-02f, -4.91039306e-02f,
  -9.18587968e-02f, -2.12709736e-02f, 2.06930172e-02f, -7.69751295e-02f, -3.55870351e-02f, 2.15598214e-02f, -1.25777856e-01f, -1.04368828e-01f, -2.06889156e-02f, -3.73975895e-02f,
  -9.92448553e-02f, 1.01382248e-01f, 4.15729471e-02f, 3.23699154e-02f, 1.46374302e-02f, 1.18157096e-01f, 3.10985558e-02f, 1.06279455e-01f, 1.62322789e-01f, -7.95361921e-02f,
  -5.34585826e-02f, 5.00732809e-02f, 5.22700138e-02f, 8.44822545e-03f, -2.98498850e-02f, -5.70351258e-02f, 5.51621988e-02f, 6.94313878e-03f, -8.22911225e-03f, -3.74933518e-02f,
  2.20323056e-02f, -4.08618413e-02f, 9.00939852e-03f, -7.83381052e-03f, 3.32720540e-02f, -4.66124788e-02f, 6.24048039e-02f, -3.09224427e-02f, 7.59996325e-02f, 1.74821988e-02f,
  6.61717132e-02f, 3.02691013e-02f, -3.28876800e-03f, -4.73495275e-02f, 3.89923342e-02f, 2.76429877e-02f, -5.09739388e-03f, 4.25924659e-02f, -1.63699798e-02f, -3.07207089e-02f,
  -1.34745836e-01f, 1.41206354e-01f, 8.37001763e-03f, -1.40925925e-02f, 3.00649554e-02f, -1.33270435e-02f, -3.60340029e-02f, 5.91055378e-02f, 8.51548184e-03f, 2.94594123e-04f,
  6.52532429e-02f, 3.70102078e-02f, -1.61128879e-01f, -2.06181016e-02f, 1.93749554e-02f, 3.50357369e-02f, -9.77113396e-02f, 8.34196247e-03f, 9.40654650e-02f, 8.15041643e-03f,
  -1.20698102e-01f, -9.54894256e-03f, 1.79937646e-01f, 1.29658440e-02f, -3.79888229e-02f, 1.83079645e-01f, 2.63936650e-02f, 2.71595214e-02f, 1.51050791e-01f, -1.60623670e-01f,
  -5.49389794e-02f, 1.90273926e-01f, -6.10797852e-02f, -6.52980059e-02f, 3.37055288e-02f, -2.60490980e-02f, -8.78966898e-02f, -1.78210855e-01f, -6.41646683e-02f, -5.45982122e-02f,
  5.47124632e-02f, -1.07512452e-01f, -7.32939094e-02f, -1.08533554e-01f, -8.91001150e-02f, 1.02071501e-01f, 1.59612849e-01f, 3.40225957e-02f, -2.18827978e-01f, -4.98773530e-02f,
  -5.03506884e-03f, -4.88574095e-02f, -9.60441008e-02f, -5.29790968e-02f, 4.56984192e-02f, 4.28015403e-02f, 1.42949089e-01f, 9.25144181e-03f, 1.02298744e-01f, 3.94608676e-01f,
  2.74546146e-02f, 1.52201667e-01f, -8.93645734e-02f, 2.45114174e-02f, 8.31342861e-03f, -5.93376160e-02f, 1.07260216e-02f, 1.00471586e-01f, 8.98744687e-02f, 9.57905874e-03f,
  5.83814196e-02f, 2.42742393e-02f, 1.91532835e-01f, 2.72463728e-02f, 3.17742256e-03f, -3.93680297e-02f, -9.94539447e-03f, -1.01779073e-01f, -2.90886723e-02f, -5.35896942e-02f,
  9.40806940e-02f, 1.49367154e-01f, 7.14657083e-02f, -2.81595683e-04f, 2.80301180e-02f, 2.14512479e-02f, 2.76496820e-02f, 1.12268813e-01f, 2.10334454e-02f, 1.32054344e-01f,
  -1.87120382e-02f, 3.07627041e-02f, 2.15580054e-02f, 5.23510091e-02f, 8.63262080e-03f, 1.48547282e-02f, 9.03233811e-02f, -7.14404583e-02f, 1.17238332e-02f, 3.78635973e-02f,
  -3.38557400e-02f, -7.89785981e-02f, 1.32819703e-02f, -3.25293839e-02f, -3.06582525e-02f, 4.21110913e-02f, 4.15375941e-02f, 4.73737605e-02f, -8.50191433e-03f, 7.44516104e-02f,
  -2.65892968e-02f, 2.84046438e-02f, 4.06045504e-02f, -5.47641031e-02f, 4.80766110e-02f, 5.33580706e-02f, 1.75991934e-03f, 5.81705011e-02f, -9.58082154e-02f, -7.05670342e-02f,
  -3.40992689e-01f, 9.35405791e-02f, 9.11964756e-03f, -5.01697231e-03f, 3.94538939e-02f, 5.22723719e-02f, -2.78723128e-02f, -1.88680980e-02f, 3.42769697e-02f, -6.16748221e-02f,
  -1.58934463e-02f, -4.93641645e-02f, -3.75820436e-02f, 2.46741362e-02f, -1.32041415e-02f, -7.85173383e-03f, -1.05038220e-02f, -1.58711579e-02f, -7.06718639e-02f, -8.88975933e-02f,
  -6.17699474e-02f, -1.07417822e-01f, -2.00619623e-01f, -1.27456740e-01f, 2.36883834e-02f, -2.29023024e-03f, -1.26398101e-01f, -1.42051101e-01f, -2.03395382e-01f, -2.87257612e-01f,
  -2.28364944e-01f, -1.83415410e-04f, 2.10041925e-02f, -7.06855357e-02f, -3.37177664e-02f, 6.37216419e-02f, 5.88449501e-02f, -3.14718746e-02f, -6.50805980e-02f, -8.89859274e-02f,
  -1.46949604e-01f, -1.51891395e-01f, -2.30804220e-01f, -1.33164212e-01f, -4.57156710e-02f, 8.88303593e-02f, 1.46891013e-01f, 8.52326602e-02f, -1.68536622e-02f, 1.42907547e-02f,
  1.36537567e-01f, 1.50064051e-01f, 3.18620764e-02f, 3.46739255e-02f, 1.84498921e-01f, 1.07876010e-01f, 3.28453369e-02f, 6.14857674e-02f, 1.52016565e-01f, 3.57703567e-01f,
  5.68625182e-02f, -1.35941073e-01f, -1.98951773e-02f, -7.40800658e-03f, -8.51575583e-02f, 4.75932397e-02f, 1.31926136e-02f, -1.20613538e-02f, -1.23835094e-02f, -1.32720834e-02f,
  1.55728972e-02f, -5.66168863e-04f, -4.75182086e-02f, 3.26568522e-02f, 7.82818794e-02f, 6.49459958e-02f, -3.78494076e-02f, 7.82150403e-02f, -7.87036344e-02f, 6.52285442e-02f,
  -2.76591815e-02f, 3.12958285e-02f, -1.78340990e-02f, -6.97526634e-02f, -1.99317709e-02f, -2.25811750e-02f, 1.20294742e-01f, 1.47281185e-01f, 7.26501048e-02f, 2.24728882e-01f,
  3.70945223e-02f, 2.93133128e-02f, -2.68735196e-02f, 6.65264651e-02f, -7.61815719e-03f, -5.05188815e-02f, 4.17742319e-02f, -4.71422449e-02f, 6.31840825e-02f, 5.08056991e-02f,
  -6.05940409e-02f, 4.41419743e-02f, 3.94903570e-02f, -6.84377924e-02f, -3.18675861e-02f, 4.17763628e-02f, 7.26385042e-02f, -1.37710469e-02f, -6.10009395e-02f, -1.36287659e-02f,
  -8.49033240e-03f, -9.20940773e-04f, 1.25136261e-03f, 5.50662018e-02f, -1.17097935e-02f, 3.12463343e-02f, 8.49550590e-02f, -8.86324886e-03f, -5.62981032e-02f, -4.90750335e-02f,
  -8.54556412e-02f, -2.96032578e-01f, 6.42702207e-02f, 1.98896751e-02f, 3.69615741e-02f, 2.46815830e-02f, -4.40964103e-02f, -1.27350641e-02f, -1.08291134e-01f, 8.99118185e-02f,
  -5.86915500e-02f, -8.70269351e-03f, -4.16074246e-02f, 1.04720540e-01f, 6.17511664e-03f, -7.97454342e-02f, -2.05687657e-02f, 7.69024529e-03f, 1.75235905e-02f, 6.54872730e-02f,
  5.25937043e-02f, 6.99513918e-03f, -7.69424960e-02f, -5.62626123e-02f, 5.73511496e-02f, -1.23119503e-01f, -4.46309848e-03f, 1.44825339e-01f, -2.95328032e-02f, 1.96705297e-01f,
  3.87706220e-01f, 5.54105192e-02f, 6.62713647e-02f, 2.23428398e-01f, 2.84743048e-02f, -1.07482085e-02f, 2.31064886e-01f, 2.27077994e-02f, 8.65082741e-02f, 5.84153794e-02f,
  -1.76749140e-01f, -2.65754879e-01f, -1.31178007e-01f, 2.92096511e-02f, 2.15793416e-01f, 2.35094890e-01f, 3.37140679e-01f, 2.05369547e-01f, 2.00434551e-01f, 1.02246128e-01f,
  -8.13449547e-03f, 5.69338836e-02f, 1.04208380e-01f, 1.01651080e-01f, -9.24547110e-03f, -1.87471598e-01f, 6.01016963e-03f, 5.05354851e-02f, -9.81826857e-02f, 1.28786892e-01f,
  -3.52700502e-02f, 8.73347074e-02f, 8.72266814e-02f, 4.81415763e-02f, -7.40926862e-02f, -7.69848377e-02f, -6.98096771e-03f, 7.89904874e-03f, -1.37854204e-01f, -3.51732746e-02f,
  -8.23496208e-02f, -1.23228624e-01f, 4.91603203e-02f, -8.96644518e-02f, 8.78609344e-02f, 4.80831303e-02f, 1.93644082e-03f, 8.78498629e-02f, 9.83569473e-02f, -4.91099758e-03f,
  -6.43963143e-02f, -5.06044924e-02f, 2.73356605e-02f, 3.89521359e-03f, 1.12391919e-01f, -2.95359548e-03f, -4.00960632e-02f, 2.36702282e-02f, -3.44064283e-05f, 6.55305535e-02f,
  -3.22648436e-02f, -3.03261820e-03f, 2.56321989e-02f, 6.91765966e-03f, -7.03603867e-03f, -8.29005390e-02f, 3.20489965e-02f, 1.27814775e-02f, 1.73653401e-02f, -5.27855493e-02f,
  -7.87269510e-03f, -2.03246381e-02f, 7.63972029e-02f, 7.40402862e-02f, 3.04080024e-02f, -1.68793555e-02f, -1.96875585e-03f, 7.76653811e-02f, -1.69159416e-02f, -3.49761290e-03f,
  1.91112738e-02f, -3.47533473e-03f, 1.13697536e-02f, -7.00738234e-03f, -8.75849277e-03f, 2.03638226e-02f, 1.26992548e-02f, -1.05649091e-01f, -8.97991583e-02f, 1.66759044e-02f,
  -1.71585694e-01f, -3.45805995e-02f, -1.51206390e-03f, 8.34540725e-02f, -1.73610505e-02f, -2.66678259e-02f, -3.01076174e-02f, 7.78037906e-02f, 1.00535844e-02f, -3.84433828e-02f,
  3.02173700e-02f, 1.35065645e-01f, 6.07626559e-03f, -9.51855183e-02f, -3.52620371e-02f, -3.17993127e-02f, -2.71228645e-02f, 3.77137028e-02f, -1.58524439e-02f, -2.29548942e-02f,
  -1.95434019e-02f, 4.72964533e-02f, 2.06331182e-02f, 2.12490279e-02f, -1.12327887e-03f, 7.79531747e-02f, -3.63370478e-02f, 1.90203711e-02f, -1.80851035e-02f, -3.77133116e-02f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.22645491e-01f, 3.62605691e-01f, 1.00584880e-01f, 6.71730191e-02f, 1.70081809e-01f, 1.82412550e-01f, 4.59972143e-01f, 1.75893217e-01f, -6.22768365e-02f, 1.36248812e-01f,
  9.02286097e-02f, -4.44749035e-02f, 8.20996985e-03f, 3.02124098e-02f, 1.93989109e-02f, 8.37239325e-02f, 1.19834788e-01f, -9.90554318e-02f, -7.93987513e-02f, -7.29906783e-02f,
  9.16903540e-02f, -8.17955732e-02f, -6.89794645e-02f, -1.27293706e-01f, 5.39057143e-02f, -1.98288634e-02f, 9.49935541e-02f, 9.19177234e-02f, 1.03417806e-01f, -6.42275140e-02f,
  -2.03895062e-01f, 1.13284901e-01f, -1.49418384e-01f, -9.24133286e-02f, -7.50538195e-03f, -6.29895702e-02f, -2.15383787e-02f, -6.80861697e-02f, 1.33681437e-03f, -1.06412359e-01f,
  8.66127014e-02f, -7.44031593e-02f, 4.51127589e-02f, -3.02552828e-03f, -1.82644110e-02f, -1.11430913e-01f, -7.57167339e-02f, 2.16849912e-02f, -5.54980375e-02f, 2.88123954e-02f,
  1.62969321e-01f, 7.63535276e-02f, 1.07980095e-01f, 1.00061424e-01f, 9.65134352e-02f, -2.25415044e-02f, 1.30137667e-01f, -1.17445560e-02f, 8.74687135e-02f, -9.70802605e-02f,
  -1.49282783e-01f, 7.25660175e-02f, 8.86624306e-02f, 2.83181984e-02f, -4.69122194e-02f, -2.26729903e-02f, -4.43645082e-02f, -6.48963004e-02f, 1.82396304e-02f, -3.85044739e-02f,
  1.37887718e-02f, 6.09690556e-03f, 6.90451171e-03f, -1.21875778e-01f, -5.85800782e-02f, 6.99305162e-02f, -8.38868096e-02f, -4.67605144e-02f, -5.08581959e-02f, -4.94602658e-02f,
  3.53354700e-02f, 6.72153831e-02f, -9.35353222e-04f, 2.29273774e-02f, -6.46223724e-02f, -1.06305979e-01f, -3.65555957e-02f, -1.11729633e-02f, -6.42585102e-03f, -2.95582525e-02f,
  -3.86227444e-02f, -1.09088300e-02f, -8.62183496e-02f, -3.35496515e-02f, 4.36010920e-02f, -3.13002728e-02f, -4.91540618e-02f, -1.75803900e-02f, -6.81055360e-04f, 1.39319329e-02f,
  3.87629345e-02f, -5.77462688e-02f, 1.08733796e-01f, -9.03851986e-02f, -8.92749876e-02f, 1.74852330e-02f, -5.71397990e-02f, -3.68983187e-02f, -5.99787645e-02f, 7.01407567e-02f,
  7.64494315e-02f, -6.56382665e-02f, -1.86662063e-01f, 5.66716306e-03f, 8.76535103e-02f, -1.24493852e-01f, 6.61710696e-03f, -9.19111669e-02f, 3.49487998e-02f, -1.86948493e-01f,
  3.81862283e-01f, -4.20301497e-01f, -3.34167242e-01f, 4.93765734e-02f, -2.08247811e-01f, -2.55953521e-01f, -4.45735544e-01f, -2.71575581e-02f, 1.43001914e-01f, -2.54523933e-01f,
  -1.51074663e-01f, 1.15433984e-01f, 1.68292984e-01f, 5.41161597e-02f, 3.86986360e-02f, -3.44539702e-01f, -3.17267567e-01f, 5.04261926e-02f, 3.37274075e-01f, 1.17966183e-01f,
  -6.07074313e-02f, 2.57910695e-02f, 2.81729817e-01f, 2.00855032e-01f, -2.30865702e-01f, 4.94254827e-02f, -1.63959429e-01f, -1.55068859e-01f, -2.22398326e-01f, -2.88722515e-01f,
  -4.67226028e-01f, -9.54608545e-02f, 4.87778783e-02f, 1.12226360e-01f, -5.66145740e-02f, -6.85445890e-02f, -1.27436757e-01f, 3.88447493e-02f, -2.05996968e-02f, -9.15971864e-03f,
  2.31094528e-02f, 7.32524367e-03f, 6.31452054e-02f, 4.41012084e-02f, 4.83597396e-03f, -4.12865132e-02f, 1.87778268e-02f, 3.66185717e-02f, 6.13809563e-02f, -2.07050458e-01f,
  -2.05091670e-01f, -1.04342222e-01f, -6.03637211e-02f, -3.04284636e-02f, 1.35400854e-02f, 1.28318459e-01f, -9.65468511e-02f, -9.68442764e-03f, 7.64798895e-02f, -1.81410357e-01f,
  -1.19114667e-01f, -1.37738958e-01f, -6.99214935e-02f, 2.82441787e-02f, 4.36368734e-02f, -1.40337152e-02f, 4.17326763e-02f, 6.21431600e-03f, 7.94872716e-02f, 2.51723398e-02f,
  -3.44037786e-02f, -2.31916439e-02f, -3.54343876e-02f, 4.51105274e-02f, -2.97515336e-02f, -3.59092578e-02f, 3.07112727e-02f, 2.00315900e-02f, -6.70284173e-03f, 4.69289422e-02f,
  -5.41428514e-02f, -7.06542330e-03f, -7.59998411e-02f, 7.96312243e-02f, -2.47698333e-02f, -8.97105858e-02f, 6.88802674e-02f, 6.50378913e-02f, 5.22205941e-02f, -2.87403967e-02f,
  2.36916438e-01f, 2.76789051e-02f, -6.32266402e-02f, 8.99252295e-03f, 9.47684515e-03f, -3.20436840e-04f, -8.55320990e-02f, 2.37785541e-02f, 9.06224474e-02f, -4.81931008e-02f,
  -8.74847397e-02f, 1.95612106e-02f, 4.75700498e-02f, -6.65604398e-02f, 1.85043402e-02f, -1.80117395e-02f, -4.51823063e-02f, 6.06539138e-02f, 1.79133529e-03f, -6.56342432e-02f,
  -1.96881942e-03f, 7.82525539e-02f, 1.90497190e-01f, -5.01655638e-02f, 2.14260584e-03f, 1.20105855e-01f, -4.50296700e-02f, -3.98204755e-03f, 1.86763495e-01f, 4.16157115e-03f,
  4.56237942e-02f, -1.55279651e-01f, -2.37518966e-01f, -4.71135980e-04f, -6.51551113e-02f, -1.09238081e-01f, -1.21726669e-01f, 4.66720499e-02f, 7.64556527e-02f, -1.06996544e-01f,
  -8.56669173e-02f, 3.90997343e-02f, 6.33327439e-02f, 1.88828390e-02f, -8.16249102e-02f, -2.06791177e-01f, -2.41435140e-01f, -4.42074006e-03f, 1.54928327e-01f, 3.76406349e-02f,
  7.93017074e-02f, 1.46817297e-01f, 6.78988993e-02f, 3.17691527e-02f, 7.05132447e-03f, 3.88644375e-02f, -4.99759875e-02f, 4.62285653e-02f, 4.04039137e-02f, -2.13144422e-01f,
  -2.45145395e-01f, -5.20288683e-02f, -5.75666800e-02f, 1.07626945e-01f, 2.51879990e-02f, 3.47031541e-02f, 6.17370941e-03f, 1.85943134e-02f, 3.96798663e-02f, -1.16677321e-01f,
  6.18508346e-02f, 1.06550232e-01f, 8.06705579e-02f, -3.68596651e-02f, -3.63667011e-02f, 2.44264882e-02f, 4.72222501e-03f, -7.15309232e-02f, 2.67480388e-02f, 5.20161986e-02f,
  6.07048757e-02f, 3.97038907e-02f, -1.17060117e-01f, 7.92244896e-02f, -8.51261467e-02f, 7.33467415e-02f, 5.62615544e-02f, 1.48695149e-02f, -3.52393351e-02f, -1.19367801e-01f,
  -3.62742110e-03f, 2.24318309e-03f, 2.08453424e-02f, 9.43352748e-03f, 6.18351065e-03f, -5.88700660e-02f, -1.16577861e-03f, 4.35665809e-02f, 7.95481205e-02f, 3.43549326e-02f,
  -6.26122626e-03f, -8.82105231e-02f, 5.68875596e-02f, 2.24727788e-03f, 3.34678730e-03f, 3.62215601e-02f, -6.54186541e-03f, -2.74894293e-02f, 6.25275820e-02f, -2.15918794e-02f,
  5.06210700e-02f, 1.12236266e-04f, 3.59825119e-02f, -1.03167063e-02f, -2.24250872e-02f, 2.11137049e-02f, -3.73327695e-02f, -4.30365168e-02f, -1.31645827e-02f, -8.73677507e-02f,
  -2.13810080e-03f, 2.13226769e-02f, -8.70929807e-02f, 1.92055646e-02f, -7.33993948e-02f, -1.45486603e-02f, -8.55807140e-02f, -7.08658397e-02f, -5.20590357e-02f, 5.78220226e-02f,
  1.52868889e-02f, -6.30353689e-02f, -9.18393768e-03f, 1.70157067e-02f, -1.90395266e-02f, 5.17680496e-02f, 6.78225532e-02f, -3.67682800e-02f, -7.81443622e-03f, 4.52429466e-02f,
  -9.37280804e-02f, -9.01395679e-02f, -9.51813310e-02f, 3.19333524e-02f, 3.43563296e-02f, 5.48624285e-02f, -1.82934888e-02f, -1.01651676e-01f, -9.66992006e-02f, -9.24277455e-02f,
  -3.56551483e-02f, -1.66925356e-01f, 2.87250519e-01f, -7.17508942e-02f, 2.12892249e-01f, 3.83019686e-01f, 2.86316901e-01f, -4.08700332e-02f, 8.60203709e-03f, -8.25576112e-02f,
  -1.06600612e-01f, -1.82966247e-01f, -2.52521485e-01f, -1.94138110e-01f, -1.02699459e-01f, 1.16226256e-01f, 1.35729477e-01f, -1.27136176e-02f, 1.03376448e-01f, 4.31968365e-04f,
  -1.10956945e-01f, -1.11807458e-01f, -3.36108990e-02f, -3.73350345e-02f, -1.98704004e-02f, -1.34966746e-01f, -2.70825974e-03f, -1.74183100e-02f, 7.33884657e-03f, -6.93351850e-02f,
  -9.26700607e-03f, 4.23372798e-02f, -5.99978492e-02f, -1.87607091e-02f, -2.75696777e-02f, -9.23041180e-02f, 1.94955077e-02f, -1.30591556e-01f, -5.61429840e-03f, 2.16093622e-02f,
  6.44845665e-02f, -1.00808382e-01f, -4.19833772e-02f, -1.09649509e-01f, -4.88575846e-02f, -1.39141325e-02f, -5.77025861e-02f, -3.09639201e-02f, -2.43213847e-02f, -8.77848864e-02f,
  -1.47685215e-01f, 1.41760036e-01f, 1.77101389e-01f, 6.31078407e-02f, -5.33071198e-02f, 9.00627002e-02f, 8.69195759e-02f, -7.03551024e-02f, 3.14766765e-02f, -5.77083342e-02f,
  1.06327254e-02f, -3.93138006e-02f, 3.25770490e-02f, -1.61650330e-02f, -5.50056174e-02f, -4.53592539e-02f, 5.07219844e-02f, -7.12895840e-02f, -3.99682112e-03f, -6.05364051e-03f,
  -2.07636803e-02f, 1.32077839e-02f, -8.27408880e-02f, -5.68003356e-02f, -8.10986608e-02f, 3.51048149e-02f, 9.73271113e-03f, -2.74311733e-02f, 2.93841790e-02f, 7.40700075e-03f,
  2.70472467e-02f, -9.12827346e-03f, 2.75898017e-02f, 1.35951526e-02f, -2.94351741e-03f, -5.12416288e-02f, -3.40683274e-02f, -6.15715384e-02f, -3.99463437e-02f, 4.40949202e-02f,
  -2.85037398e-01f, 1.64745644e-01f, 5.51175438e-02f, -8.31129402e-02f, 3.62921879e-02f, -2.86315307e-02f, -1.85191613e-02f, -3.55017197e-04f, 8.72095209e-03f, 4.91267517e-02f,
  -2.19731554e-02f, 2.49968353e-03f, -5.90964817e-02f, 1.74224582e-02f, 4.65250835e-02f, 9.11708176e-02f, -6.28896132e-02f, -9.34807882e-02f, 2.49618012e-02f, 3.30533534e-02f,
  -8.81965682e-02f, 9.02329311e-02f, -5.57495840e-03f, 3.99318039e-02f, -2.93575283e-02f, 1.47650585e-01f, 6.99084625e-02f, -2.03559618e-03f, 9.64245573e-02f, -7.03705326e-02f,
  1.43190891e-01f, 1.90983545e-02f, -2.55189925e-01f, -4.39081416e-02f, -1.03679970e-01f, 5.59764914e-03f, 8.77752304e-02f, 4.00310867e-02f, 6.57024533e-02f, -1.19059794e-01f,
  -6.97003454e-02f, 5.03373630e-02f, 4.64858189e-02f, -7.03575164e-02f, -4.95144725e-02f, -1.06472023e-01f, -5.61880171e-02f, -5.45500219e-02f, 5.92219308e-02f, 7.06790164e-02f,
  -6.63499385e-02f, -4.50706258e-02f, -4.48211506e-02f, -1.36962637e-01f, -9.69377607e-02f, -7.41432235e-02f, -2.13021547e-01f, -1.71199322e-01f, -7.69620314e-02f, -1.05665587e-01f,
  -2.53156513e-01f, -4.30594459e-02f, 7.19365031e-02f, 2.75306627e-02f, -1.60392728e-02f, 1.04420573e-01f, 4.41418961e-02f, -8.74778405e-02f, 9.36038941e-02f, 2.70920657e-02f,
  -2.72913137e-03f, 3.35435793e-02f, -6.38950616e-02f, -3.84028666e-02f, 1.46560194e-02f, 4.10517678e-02f, -6.71147406e-02f, -1.23460954e-02f, 2.64240149e-02f, 3.04227695e-02f,
  1.20711699e-02f, -1.22620799e-02f, 8.84864405e-02f, 1.02826744e-01f, -2.53262650e-02f, -7.03351852e-03f, -8.30206871e-02f, 2.16393005e-02f, 5.64505830e-02f, 8.74380916e-02f,
  1.23693928e-01f, 6.51667546e-03f, -7.10983500e-02f, 4.54138331e-02f, 2.95357946e-02f, 1.38149969e-02f, -5.79383411e-02f, 5.38740633e-03f, 6.00751638e-02f, -6.25220910e-02f,
  4.60855775e-02f, -5.31745851e-02f, 5.09358793e-02f, -9.78303924e-02f, -6.65905178e-02f, 3.01390681e-02f, -5.92600964e-02f, -1.08138174e-02f, 3.27219293e-02f, 8.54980759e-03f,
  7.23367035e-02f, -1.29163995e-01f, 2.85357740e-02f, 3.84843126e-02f, -8.58613029e-02f, -5.67349466e-03f, -1.11390553e-01f, -4.51061130e-02f, 2.29428690e-02f, -4.68751341e-02f,
  -9.55896825e-02f, 1.67460646e-02f, 5.62574603e-02f, -3.29272151e-02f, -5.28115779e-02f, 6.03134446e-02f, 4.72077243e-02f, -1.41400531e-01f, -4.33855057e-02f, -1.20171264e-01f,
  1.96821038e-02f, -9.56916362e-02f, 6.12474047e-04f, -2.90116598e-03f, 4.37083021e-02f, 9.41701606e-02f, 5.12878411e-03f, 4.85510528e-02f, -2.02647503e-02f, -2.70193424e-02f,
  1.34944990e-01f, 1.96859881e-01f, 7.00560883e-02f, 9.71871912e-02f, 7.62723461e-02f, 5.11782803e-02f, -1.73068810e-02f, 9.47808623e-02f, 3.77825927e-03f, 1.28752783e-01f,
  -6.74763173e-02f, -3.16034816e-02f, -3.33084911e-01f, -1.35532707e-01f, -9.27395374e-02f, -1.18132226e-01f, -2.37769157e-01f, 2.32713781e-02f, 5.06576411e-02f, -2.34674126e-01f,
  -1.34457335e-01f, -5.49629778e-02f, -1.11982085e-01f, -1.84587806e-01f, -1.01770893e-01f, -2.55272686e-01f, -2.30620891e-01f, -3.19326043e-01f, -2.72145182e-01f, -1.41932189e-01f,
  -2.64539808e-01f, -2.59874552e-01f, -2.66418725e-01f, -1.05557807e-01f, 4.54754084e-02f, -1.00063927e-01f, -8.52839649e-02f, -2.01867118e-01f, -1.29055336e-01f, -7.63148218e-02f,
  -1.26089081e-01f, 4.53440472e-02f, -5.22967763e-02f, -5.74053451e-02f, -9.53588486e-02f, -5.66575713e-02f, -5.65405637e-02f, -1.88762695e-02f, -5.50175607e-02f, -1.21493503e-01f,
  4.93746735e-02f, -4.64217328e-02f, 4.14783619e-02f, -8.21877867e-02f, -1.24511048e-02f, -2.76580378e-02f, -2.41312701e-02f, -4.96834442e-02f, -7.66095445e-02f, 8.02500099e-02f,
  -9.78790969e-02f, -1.40178641e-02f, 2.58813370e-02f, 1.01231836e-01f, 4.56152111e-02f, 1.49127888e-02f, 6.77325800e-02f, 1.51580065e-01f, -2.73188464e-02f, 4.64036427e-02f,
  -8.73446390e-02f, 1.86008196e-02f, 7.30367824e-02f, 1.33485189e-02f, 5.27228229e-02f, 3.21494266e-02f, -2.85254531e-02f, -1.02234490e-01f, 1.73223279e-02f, -7.59287179e-02f,
  2.74679270e-02f, 5.13505423e-03f, 4.94566709e-02f, -5.35254106e-02f, -5.78332879e-02f, 4.48696315e-02f, 4.55412306e-02f, 1.43756522e-02f, 2.62855459e-02f, 1.10587262e-01f,
  -5.37763815e-03f, 1.06729597e-01f, -6.15920697e-04f, 5.79766072e-02f, 2.63114907e-02f, -6.35770485e-02f, -5.35037331e-02f, 1.54291280e-02f, 8.44225511e-02f, -1.94816943e-02f,
  8.25441182e-02f, -1.15223609e-01f, -6.12548590e-02f, -3.40350680e-02f, -2.63471361e-02f, 5.71731701e-02f, 3.98382694e-02f, 3.06147076e-02f, 5.47236251e-03f, -3.08726057e-02f,
  -3.95003557e-02f, -1.28304008e-02f, -1.06815949e-01f, 5.17125428e-03f, -6.12191930e-02f, -2.60499269e-02f, 2.64160447e-02f, -1.32554751e-02f, -6.29622415e-02f, 4.46268544e-03f,
  -6.95567727e-02f, -4.13950123e-02f, -8.22456628e-02f, 6.45027980e-02f, 3.17691118e-02f, -1.01007514e-01f, 4.41445410e-02f, 8.59161317e-02f, -2.78500617e-02f, -6.67004585e-02f,
  4.12776396e-02f, 5.63459434e-02f, 7.62800202e-02f, -2.59584002e-02f, -1.56183109e-01f, -4.82373349e-02f, -7.79842958e-03f, 4.09969856e-04f, -5.02831861e-02f, 5.76345548e-02f,
  6.16141260e-02f, 3.45506542e-03f, 2.64297798e-02f, -8.35719109e-02f, -7.21545070e-02f, 2.31700316e-02f, -9.87876020e-03f, -3.02214995e-02f, -2.06742078e-01f, -9.14635956e-02f,
  -3.52033749e-02f, -5.26941493e-02f, -2.42165644e-02f, -4.35893871e-02f, 5.48243821e-02f, -5.09224534e-02f, 8.37322548e-02f, -8.67517292e-02f, -1.50889635e-01f, -2.39122510e-02f,
  -6.30278466e-03f, -1.60753295e-01f, -3.24969739e-02f, -1.13638438e-01f, 3.52442526e-04f, 5.68024032e-02f, -9.55783874e-02f, 6.18631244e-02f, -1.82170654e-04f, -2.80165821e-02f,
  -9.06011760e-02f, -9.63216722e-02f, -1.80750256e-04f, 2.55498830e-02f, 4.32333350e-02f, -7.83479437e-02f, -3.53836976e-02f, 9.39791650e-03f, -3.72073986e-02f, -1.43993367e-03f,
  -1.21878736e-01f, -1.78496077e-04f, -6.87187985e-02f, -1.74527690e-02f, -6.69734254e-02f, -1.77051872e-02f, -5.12582473e-02f, -1.09210677e-01f, -1.30851880e-01f, 1.71543527e-02f,
  2.22620964e-02f, -8.87409151e-02f, -1.63356550e-02f, 4.64875065e-02f, -6.91378117e-02f, 3.92336994e-02f, 1.56581253e-02f, -3.70506644e-02f, 5.30801266e-02f, -2.07704604e-02f,
  -6.77580535e-02f, 8.61230716e-02f, -8.77084851e-04f, 1.07053287e-01f, 6.39969558e-02f, -7.94393346e-02f, -2.28138175e-02f, 5.46440631e-02f, 2.96872724e-02f, -4.37331124e-04f,
  3.02024893e-02f, -6.28101006e-02f, 8.97889659e-02f, -1.23183681e-02f, 2.55437493e-02f, -3.97655033e-02f, 5.08426800e-02f, -9.16749611e-02f, -2.00832561e-02f, 5.15410528e-02f,
  1.50369018e-01f, -1.08398035e-01f, -9.49914940e-03f, 3.16521637e-02f, -5.52503653e-02f, 1.04024097e-01f, -9.72210094e-02f, 4.12734859e-02f, -5.84117929e-03f, -9.02034193e-02f,
  -2.71156579e-02f, -6.50552213e-02f, -2.99680158e-02f, -7.40579888e-02f, -1.60113350e-02f, -7.21697370e-03f, 8.22087899e-02f, -1.45092458e-02f, -1.06253669e-01f, 1.40926037e-02f,
  1.50735959e-01f, 8.12592879e-02f, -1.86689962e-02f, 7.72471204e-02f, -7.49101192e-02f, 1.80105064e-02f, 6.71652555e-02f, -2.25300379e-02f, 2.97416393e-02f, 2.55532295e-01f,
  5.32171488e-01f, 6.17088489e-02f, 3.33493382e-01f, 1.41175240e-01f, 2.21101180e-01f, 4.08925176e-01f, 4.52588081e-01f, 1.58280000e-01f, 8.15434679e-02f, 6.55525401e-02f,
  1.52093530e-01f, -9.87512693e-02f, -4.48505618e-02f, -5.60558252e-02f, 1.41112655e-01f, 1.18883491e-01f, -5.98886088e-02f, 6.59154803e-02f, 7.50411972e-02f, 4.08646986e-02f,
  -8.79288837e-02f, -5.05735725e-03f, 9.74960905e-03f, 6.55322969e-02f, 4.35789451e-02f, -6.90724626e-02f, 6.26045987e-02f, 4.40111235e-02f, -2.11407561e-02f, -2.34155819e-01f,
  -3.31264697e-02f, 2.90285140e-01f, -2.39133202e-02f, -1.22437663e-01f, 3.08695231e-02f, -3.44251618e-02f, 8.44378117e-03f, -7.75926486e-02f, -3.47584896e-02f, -9.57236737e-02f,
  -6.35025874e-02f, -7.02959746e-02f, -3.44057567e-02f, -5.12523316e-02f, 1.03942722e-01f, 3.77038941e-02f, -1.01077832e-01f, 5.31387739e-02f, -1.04382653e-02f, -4.64117527e-02f,
  -1.38827145e-01f, 2.57339645e-02f, 6.68511987e-02f, 6.10466227e-02f, 5.99902496e-02f, -4.81650606e-02f, 1.15632765e-01f, -3.21960002e-02f, -1.39373215e-02f, 5.64718619e-03f,
  -9.16342426e-04f, 3.41319628e-02f, -5.68218203e-03f, 3.98571901e-02f, 2.62990762e-02f, 4.06758636e-02f, 4.85063158e-02f, -1.30597288e-02f, 4.37999144e-02f, 2.08807793e-02f,
  -3.84753430e-03f, 9.94128361e-02f, 4.20083851e-02f, 9.80231613e-02f, -2.35604891e-03f, -2.69658081e-02f, 9.18581616e-03f, 3.49770077e-02f, -3.89217883e-02f, -6.42879158e-02f,
  -1.68637969e-02f, 1.58627182e-02f, -1.41902305e-02f, -2.59051193e-02f, 7.44780526e-02f, 1.16554029e-01f, -9.92092211e-03f, -5.45064844e-02f, 2.75720544e-02f, -7.42034763e-02f,
  -2.45843515e-01f, 1.64431214e-01f, -1.10123813e-01f, -1.35448113e-01f, 4.27250639e-02f, -4.71657962e-02f, 1.96966361e-02f, -1.35091588e-01f, -9.82431322e-02f, -2.56036036e-02f,
  1.53083475e-02f, -6.50038272e-02f, -1.44474185e-03f, 8.57528485e-03f, 1.08775921e-01f, 4.47146483e-02f, -8.68580211e-03f, -2.21003648e-02f, -2.80950591e-02f, -2.63987575e-02f,
  -1.12706363e-01f, 7.89039209e-02f, 9.73894745e-02f, 1.24174412e-02f, 2.78479047e-02f, 2.94431131e-02f, -7.79319555e-02f, 7.15144947e-02f, 4.33217250e-02f, 2.94298008e-02f,
  -1.42278969e-01f, -1.74470946e-01f, 2.94492189e-02f, -7.42934793e-02f, 4.15530056e-03f, -1.12125739e-01f, -1.65763333e-01f, 3.08518130e-02f, -1.05925806e-01f, -1.28882095e-01f,
  -4.07284945e-02f, -7.77394027e-02f, -4.93792556e-02f, 8.26041028e-02f, -1.11890640e-02f, 3.94228883e-02f, 1.10156886e-01f, 1.84077144e-01f, 3.90757248e-02f, -2.72243023e-02f,
  -2.20052581e-02f, -6.66334108e-02f, 1.74752191e-01f, 1.18187264e-01f, -2.39938702e-02f, 3.33463475e-02f, 1.06280781e-01f, -1.57767197e-03f, -9.94235724e-02f, 1.57054063e-04f,
  -1.33565709e-01f, -7.72795677e-02f, 5.18875532e-02f, -5.89104481e-02f, -5.89900911e-02f, -4.17753905e-02f, -1.59243997e-02f, 8.74157250e-02f, -4.17241454e-02f, -3.58589478e-02f,
  -7.04453215e-02f, -1.95208173e-02f, -7.33659565e-02f, -2.26493794e-02f, -2.48405505e-02f, 3.16934101e-02f, 2.99660973e-02f, 8.99515897e-02f, 1.24575742e-01f, -5.85312508e-02f,
  -8.55938867e-02f, -5.04598059e-02f, -3.98442522e-02f, -6.25079451e-03f, 5.50087169e-02f, 1.01021156e-02f, 1.91856772e-02f, 9.36151966e-02f, 1.20833866e-01f, -5.51166274e-02f,
  -2.39740275e-02f, 2.66467799e-02f, -1.88058652e-02f, 7.35109532e-03f, 2.51043197e-02f, -4.87965196e-02f, 1.71163175e-02f, -8.84674396e-03f, 5.90345412e-02f, -6.46303743e-02f,
  9.79526639e-02f, 3.35164778e-02f, 4.82531078e-02f, 4.27550115e-02f, -2.04851143e-02f, -6.44221082e-02f, -5.02963969e-03f, -5.77742653e-03f, 1.88021585e-02f, -3.27055417e-02f,
  7.33528957e-02f, -7.30932578e-02f, -2.88437605e-02f, 3.71869728e-02f, -5.91315441e-02f, 6.32049069e-02f, 3.47292833e-02f, -4.99242730e-03f, 4.39557359e-02f, -7.55432323e-02f,
  -1.31062150e-01f, 2.35515460e-01f, -7.77087808e-02f, 3.83884907e-02f, -2.48657651e-02f, 8.05840269e-02f, 2.12481134e-02f, 3.56446505e-02f, 1.13862741e-03f, -8.29704180e-02f,
  -1.99499819e-02f, -5.69460876e-02f, -2.67926287e-02f, -6.92676082e-02f, 4.56680767e-02f, -4.01043370e-02f, 3.09879389e-02f, 3.60856056e-02f, 5.08861355e-02f, 3.77873220e-02f,
  -2.25994941e-02f, -6.00678883e-02f, -7.17193037e-02f, -1.85128450e-02f, -6.47015451e-03f, 5.10218814e-02f, -3.80323566e-02f, 1.22586833e-02f, 3.50823291e-02f, -2.38443073e-02f,
  4.30647373e-01f, 3.72129023e-01f, 2.43461385e-01f, 2.69815437e-02f, -7.16068670e-02f, -2.81364098e-02f, -2.32202578e-02f, 1.32331820e-02f, -1.66959211e-01f, 3.10298102e-03f,
  -5.11808023e-02f, -2.88533211e-01f, -2.23585039e-01f, -5.89084439e-02f, 3.01913731e-02f, 9.31374505e-02f, 1.08669050e-01f, 4.69109602e-02f, -1.18458629e-01f, -1.47528976e-01f,
  -3.82254981e-02f, 1.50880050e-02f, 1.72987297e-01f, 6.72418550e-02f, 1.18631773e-01f, -1.89870000e-01f, 1.48410490e-02f, 2.73708310e-02f, 8.75308141e-02f, 8.32634047e-02f,
  -2.17188839e-02f, 2.16230944e-01f, -2.04436094e-01f, -7.38113448e-02f, -6.00843281e-02f, 6.53007105e-02f, 3.22047062e-02f, 1.08315915e-01f, -6.44391924e-02f, -8.39156955e-02f,
  -6.93029612e-02f, 1.30120749e-02f, -8.33620802e-02f, -1.12070693e-02f, -3.49693559e-02f, -4.77887923e-03f, 1.10242553e-01f, 1.15571931e-01f, -7.72733539e-02f, 4.21759486e-02f,
  -1.46099240e-01f, 3.54305543e-02f, 8.65773205e-03f, -1.02784391e-02f, -1.82242610e-03f, -1.05936259e-01f, 7.41556427e-03f, 7.31357262e-02f, 4.25200425e-02f, 1.29899442e-01f,
  -1.81288615e-01f, -6.72395155e-02f, -4.01049331e-02f, -8.34412128e-02f, -3.17251906e-02f, -1.22498088e-01f, -2.98456755e-02f, 2.51620486e-02f, 9.80724022e-03f, 6.29302412e-02f,
  -8.08187351e-02f, 1.99835543e-02f, -1.08473428e-01f, 6.69634528e-03f, -6.84117340e-03f, 1.43039869e-02f, -1.28887454e-02f, 2.98601426e-02f, 7.13451281e-02f, 3.50493677e-02f,
  -4.52034958e-02f, 3.84859927e-02f, -2.63840333e-02f, 3.40059511e-02f, -4.92989123e-02f, -5.47105633e-02f, -9.39399153e-02f, -3.79113518e-02f, 5.20012788e-02f, 8.02450627e-02f,
  -3.00161511e-01f, -2.02449679e-01f, -1.53967708e-01f, -5.28190695e-02f, 9.37535390e-02f, -2.95025203e-02f, -9.73992888e-03f, 1.41466549e-02f, 3.88171934e-02f, 6.92355111e-02f,
  -6.34647161e-02f, -1.18272670e-03f, 9.76956543e-03f, 5.09820282e-02f, -1.54009864e-01f, -5.01913726e-02f, -7.74906799e-02f, -2.65099271e-03f, -6.96278960e-02f, -6.51540905e-02f,
  -1.13114091e-02f, -2.18295772e-02f, -1.86326832e-01f, -1.14660010e-01f, -1.25670329e-01f, -1.73114181e-01f, -3.73287126e-02f, -8.25043768e-02f, -3.00074704e-02f, -1.13713205e-01f,
  1.75643072e-01f, -8.52772668e-02f, 5.85801117e-02f, 9.68066510e-03f, 8.57121572e-02f, 2.30158046e-01f, 3.51329029e-01f, 6.98443800e-02f, -8.55264906e-03f, -3.51544358e-02f,
  -2.06472024e-01f, -2.56499559e-01f, -1.69796929e-01f, -1.87390596e-01f, -7.33251423e-02f, 1.71610788e-01f, 9.89232138e-02f, 1.31524140e-02f, 1.31630287e-01f, -8.18632660e-04f,
  5.86102903e-02f, 1.22135065e-01f, 1.65975709e-02f, 3.76666710e-02f, -9.82404649e-02f, -1.20086744e-01f, -4.10213098e-02f, -5.28766215e-02f, -1.69960007e-01f, -1.38061345e-01f,
  9.42810699e-02f, -2.40770057e-01f, -2.86346003e-02f, -2.29675472e-01f, -1.27222613e-02f, -2.11451519e-02f, 6.25674352e-02f, -1.38513252e-01f, -1.25790730e-01f, 3.70734818e-02f,
  -5.20162731e-02f, -1.00453511e-01f, -7.03661293e-02f, -7.57793337e-02f, 2.11818647e-02f, -1.02293147e-02f, -5.22008864e-03f, -9.44292471e-02f, -1.16939321e-01f, -1.11748263e-01f,
  -2.41041720e-01f, -3.88711574e-03f, 1.28716588e-01f, -3.36028077e-03f, -2.02522978e-01f, -1.65860340e-01f, 2.53359675e-02f, -1.49128556e-01f, -9.78035331e-02f, 1.24551505e-01f,
  1.10759800e-04f, -7.43521750e-02f, 5.55295683e-02f, 6.06443966e-03f, 5.68621270e-02f, -3.36727090e-02f, -4.20266725e-02f, -1.32905990e-02f, 2.06363015e-02f, 1.28136337e-01f,
  -1.31091282e-01f, 4.49613407e-02f, 1.48160243e-02f, -4.61228564e-02f, 1.90508068e-02f, -5.28364927e-02f, 5.53311221e-02f, 2.70524230e-02f, 1.25320200e-02f, 4.20640744e-02f,
  4.40534800e-02f, -3.87495160e-02f, 6.94583580e-02f, -6.18742704e-02f, -1.97545774e-02f, -4.93063852e-02f, -1.98545307e-02f, -2.04272103e-02f, -7.52353370e-02f, 5.90356290e-02f,
  1.98908627e-01f, -2.67978162e-01f, 7.98324496e-02f, -6.96156025e-02f, 7.00103864e-02f, -9.08367485e-02f, -6.48649260e-02f, -7.09610581e-02f, -6.91443235e-02f, -5.16151860e-02f,
  -1.07356876e-01f, -3.85619253e-02f, 1.28274383e-02f, -1.68147217e-02f, 1.05825663e-01f, 7.31405690e-02f, 1.10344976e-01f, 6.26383498e-02f, -7.45232701e-02f, 9.22746211e-02f,
  -1.39706209e-02f, 1.86397985e-01f, 2.07878798e-01f, 1.02626927e-01f, 8.47493857e-02f, 3.18914950e-02f, 1.59954831e-01f, 1.16791204e-01f, 1.28855944e-01f, 3.82176399e-01f,
  -8.62683713e-01f, 3.25693041e-01f, -9.35146734e-02f, -3.62291485e-01f, 2.42840782e-01f, 3.63734454e-01f, 6.40459716e-01f, 2.06127554e-01f, -1.42136902e-01f, 1.62554190e-01f,
  9.98536646e-02f, -1.47413835e-01f, 2.32819803e-02f, 5.34593351e-02f, 1.47685617e-01f, 3.32749993e-01f, 2.08535925e-01f, -5.20165376e-02f, -2.77683467e-01f, -1.28093556e-01f,
  1.31090686e-01f, -9.15790051e-02f, -4.10078019e-01f, -9.48890448e-02f, -1.21971004e-01f, -9.65631679e-02f, -8.32680538e-02f, -2.46574394e-02f, 8.11717063e-02f, 8.23481679e-02f,
  -1.97332174e-01f, -1.82072952e-01f, -3.30660604e-02f, -1.00836642e-01f, -2.94128675e-02f, -1.17516175e-01f, 8.96545686e-03f, -1.31520778e-01f, -8.86040628e-02f, 4.50946279e-02f,
  -3.15126926e-02f, -8.47593602e-03f, -2.76960656e-02f, 5.61718037e-03f, -3.64067852e-02f, 1.46192797e-02f, 6.62212074e-02f, -8.69746134e-02f, 6.44867569e-02f, 5.39759407e-03f,
  2.93713152e-01f, 1.56652287e-01f, 6.15825839e-02f, 1.20723933e-01f, 1.01440735e-01f, -5.37724234e-03f, 8.37715343e-02f, -6.83981404e-02f, -8.72603059e-03f, -1.57698557e-01f,
  2.56789988e-03f, -2.25773994e-02f, -1.21735157e-02f, 1.61569528e-02f, 2.16366630e-02f, 2.97387820e-02f, -2.45506447e-02f, 7.10492134e-02f, -1.56307183e-02f, -8.39928985e-02f,
  1.28195398e-02f, 2.75754295e-02f, 2.48180795e-02f, -4.34514359e-02f, -3.73422056e-02f, 4.13770974e-02f, 7.19084069e-02f, 6.38772771e-02f, 7.51446337e-02f, 1.59863811e-02f,
  3.54587957e-02f, -1.39686922e-02f, -1.67564657e-02f, 7.55106956e-02f, 8.12332630e-02f, 2.20193807e-02f, -3.74969803e-02f, 1.85343418e-02f, -4.35197540e-02f, -5.46143092e-02f,
  -2.75895476e-01f, 1.91257298e-01f, -1.15599111e-01f, -4.90907542e-02f, -1.61055289e-02f, -6.42314628e-02f, -7.27536455e-02f, -2.61371732e-02f, 2.33563054e-02f, 6.72754738e-03f,
  -5.06018801e-03f, -1.31028101e-01f, -1.97963435e-02f, 3.96767427e-04f, -7.68324435e-02f, -6.43571690e-02f, 3.45195979e-02f, -2.39977017e-02f, 3.88820358e-02f, 5.31880483e-02f,
  2.78067272e-02f, -2.55017565e-03f, -1.39098331e-01f, 8.51319283e-02f, 4.51500714e-02f, -1.22140512e-01f, -7.57143348e-02f, -6.33742586e-02f, 4.28062379e-02f, -1.48151323e-01f,
  -4.82054114e-01f, -6.79641962e-02f, 2.87923008e-01f, -2.28091016e-01f, -1.27801120e-01f, 3.07737198e-02f, 1.94816645e-02f, -8.11526477e-02f, -1.13104716e-01f, -1.49848491e-01f,
  -1.27242148e-01f, -1.49059286e-02f, 5.03845289e-02f, -6.53598607e-02f, -4.48787556e-04f, 4.10650559e-02f, -8.15011212e-04f, 7.67346025e-02f, 8.04104730e-02f, -5.22061437e-02f,
  -4.67938855e-02f, -2.27648199e-01f, -1.49906009e-01f, -1.15627274e-01f, -1.16472200e-01f, 3.87455113e-02f, -5.98551109e-02f, -1.02441721e-01f, 1.60124041e-02f, -2.06873547e-02f,
  4.18709487e-01f, -2.01680452e-01f, 6.27713576e-02f, -1.82427928e-01f, 1.89852733e-02f, -1.21664964e-01f, -2.08067205e-02f, -2.62862779e-02f, -8.09438154e-02f, -4.43095230e-02f,
  -6.28709197e-02f, -8.14267993e-02f, 5.21406271e-02f, -2.73311399e-02f, -9.43263397e-02f, -3.63888405e-02f, -1.36832803e-01f, 3.33005853e-04f, 3.32825333e-02f, -1.82684250e-02f,
  -5.16259782e-02f, 2.91326344e-02f, 1.44396937e-02f, 2.59907153e-02f, 3.79663669e-02f, 7.94312805e-02f, 1.05012797e-01f, 9.45366696e-02f, -7.25207757e-03f, 6.00233637e-02f,
  -7.36413896e-02f, 7.89216459e-02f, -2.54963599e-02f, 2.57574208e-02f, -5.61717562e-02f, 6.92933798e-02f, 2.48850379e-02f, -1.47097080e-03f, 6.06877059e-02f, -2.07149889e-02f,
  -3.00610848e-02f, 3.43764685e-02f, 2.58333422e-02f, 3.89572373e-03f, 5.87508716e-02f, -1.10253813e-02f, -1.18878083e-02f, -6.31724969e-02f, 5.23654781e-02f, -8.60862657e-02f,
  -5.39292991e-02f, -7.54789338e-02f, -7.88724348e-02f, 1.46176107e-02f, -3.61776128e-02f, -5.26261814e-02f, -2.90247239e-02f, 6.13563322e-02f, 8.62716045e-03f, -1.20349536e-02f,
  8.95334259e-02f, 6.68668002e-02f, -4.98215780e-02f, -1.67330019e-02f, -3.46257575e-02f, 4.15295595e-03f, -3.93761545e-02f, 1.22464327e-02f, -9.95920151e-02f, -4.19334099e-02f,
  3.04644387e-02f, -5.65600619e-02f, 3.45250685e-03f, -3.35040763e-02f, 7.07511455e-02f, -4.21273597e-02f, -1.45731941e-01f, -2.21120790e-02f, 7.84242675e-02f, -4.23621610e-02f,
  -1.52119294e-01f, 2.68425234e-02f, 1.29652962e-01f, 2.03087091e-01f, 1.04528278e-01f, 8.90884027e-02f, 2.68243492e-01f, 1.14769518e-01f, 1.27524137e-01f, 8.63581616e-03f,
  -4.33235109e-01f, -1.63508549e-01f, -1.73548982e-01f, -3.06349546e-01f, -2.87866276e-02f, 2.22090811e-01f, 2.24263072e-01f, 6.59877583e-02f, -1.04758412e-01f, -6.05264530e-02f,
  1.17890984e-02f, -1.08013257e-01f, -9.47095156e-02f, -1.21869422e-01f, -1.02799132e-01f, -7.88176209e-02f, -2.32094601e-01f, -2.09918857e-01f, -8.94357450e-03f, 2.46223450e-01f,
  1.24644630e-01f, -1.06592230e-01f, -2.39202276e-01f, -6.69315830e-02f, -8.23012069e-02f, -5.17481603e-02f, -2.84327239e-01f, -1.98317960e-01f, -8.74986574e-02f, -3.15961182e-01f,
  -2.00607911e-01f, 4.72147353e-02f, 1.47233635e-01f, 1.39891054e-03f, -5.00397459e-02f, 1.41370008e-02f, 6.91454159e-03f, -4.50533330e-02f, -2.49222741e-02f, -5.90310246e-03f,
  1.12309586e-02f, 8.19645226e-02f, -1.09288447e-01f, 1.41922146e-01f, 3.63798738e-02f, 9.59072635e-02f, 2.73328144e-02f, -8.66223946e-02f, -4.29879315e-02f, 1.38381258e-01f,
  4.47234325e-02f, -1.23120740e-01f, -1.32363752e-01f, -3.14814523e-02f, 9.80712771e-02f, -1.00154676e-01f, -2.63329167e-02f, 1.17727660e-01f, -1.07694611e-01f, -2.32105270e-01f,
  3.37123126e-02f, -7.65276849e-02f, 8.94124657e-02f, -3.30588035e-02f, -7.06427246e-02f, -3.09545062e-02f, -1.41855953e-02f, -3.32193752e-03f, 9.03744623e-02f, -1.12562776e-01f,
  -5.95854335e-02f, -1.04495380e-02f, -5.71642295e-02f, -4.61126193e-02f, 3.21508534e-02f, -2.07605697e-02f, -2.34344117e-02f, -1.94470100e-02f, -8.15593358e-03f, -8.20074081e-02f,
  -7.15967873e-03f, 1.08000338e-02f, -3.40508483e-02f, 2.15716939e-02f, -2.43595019e-02f, -1.20409921e-01f, 1.37947217e-01f, 6.71596965e-03f, -4.02391553e-02f, 1.47542804e-02f,
  -1.74605757e-01f, 1.36165008e-01f, -1.11565240e-01f, -7.70062348e-03f, 1.31573658e-02f, 1.25064244e-02f, -1.47768468e-01f, 7.21291006e-02f, -2.34019514e-02f, 2.64421534e-02f,
  1.39070347e-01f, 2.58612935e-03f, -5.84836043e-02f, 1.06379047e-01f, 5.10194674e-02f, 7.19242990e-02f, -1.05369315e-01f, -9.20192599e-02f, 8.52090493e-03f, 2.84697451e-02f,
  -9.34593156e-02f, -1.17012769e-01f, -3.02309364e-01f, -1.72289699e-01f, -1.05837196e-01f, -1.84671983e-01f, -1.29529014e-01f, 6.92112604e-03f, -1.49291873e-01f, -3.17074567e-01f,
  -2.76052445e-01f, 1.05606906e-01f, 1.43447682e-01f, -1.31834343e-01f, -8.36504474e-02f, 1.45792998e-02f, 9.88214314e-02f, 5.00638150e-02f, -4.92612347e-02f, -5.84750697e-02f,
  9.13872421e-02f, -3.24717797e-02f, 6.57681674e-02f, -5.71116917e-02f, -2.42400616e-02f, 1.77241229e-02f, 2.47525051e-03f, 4.56809998e-02f, -3.56403366e-02f, 7.75644034e-02f,
  -1.50375506e-02f, 4.23128009e-02f, -1.52531266e-01f, 7.09811272e-03f, -2.21848693e-02f, -2.74977926e-02f, 1.60304420e-02f, 2.73731966e-02f, -1.81620698e-02f, -6.77567273e-02f,
  3.53577942e-01f, 7.63390288e-02f, 7.89044052e-03f, -1.20927259e-01f, 8.01934451e-02f, -9.18970183e-02f, 4.91142534e-02f, -4.28515039e-02f, -7.93540105e-02f, 8.59210193e-02f,
  1.08797804e-01f, 8.77860188e-02f, 4.46550176e-03f, -2.56930515e-02f, 6.60370812e-02f, 5.40656643e-03f, 1.59580987e-02f, -4.34613377e-02f, 8.95735323e-02f, 6.37514368e-02f,
  5.75289764e-02f, 8.74196514e-02f, 9.21015963e-02f, -3.87767255e-02f, -6.61023334e-02f, -2.54824050e-02f, 3.99206243e-02f, 1.77722070e-02f, 5.08916900e-02f, -3.08935028e-02f,
  -3.27313840e-02f, -6.04309291e-02f, 4.49269712e-02f, -6.14241548e-02f, 5.54314293e-02f, -6.83798548e-03f, 3.24998684e-02f, 1.14998452e-01f, -1.13871790e-01f, -6.97451755e-02f,
  -2.75783194e-03f, -6.77676797e-02f, 4.92810197e-02f, 3.68482359e-02f, -5.30137047e-02f, -6.65474869e-03f, 2.45053601e-02f, -8.17585643e-03f, 1.42424684e-02f, 1.37548707e-02f,
  -9.02279019e-02f, 2.63423957e-02f, -5.82386628e-02f, 6.80820122e-02f, 2.08506957e-02f, -1.78095456e-02f, 8.55246410e-02f, -2.32328400e-02f, 4.91260663e-02f, -7.04898834e-02f,
  1.75580129e-01f, 1.82029009e-02f, -1.05235735e-02f, -4.90540564e-02f, 1.16583593e-02f, 1.89598501e-02f, -5.99859166e-04f, -4.96375635e-02f, -3.04350555e-02f, 7.16409683e-02f,
  6.24340177e-02f, 8.15705433e-02f, 1.08631082e-01f, 2.86536291e-02f, 2.96028890e-02f, -9.04444605e-03f, -1.88136790e-02f, -3.74992676e-02f, -5.44795906e-03f, 1.40371546e-01f,
  -1.93949118e-02f, 8.48946124e-02f, 1.40368402e-01f, 9.05500818e-03f, 1.50861619e-02f, 1.66411679e-02f, 1.69526443e-01f, 2.28091683e-02f, 1.08601041e-01f, -2.20737085e-02f,
  3.44844535e-02f, -1.63014710e-01f, 1.98078558e-01f, 4.11069617e-02f, 4.74487841e-02f, -7.17556328e-02f, -1.78478703e-01f, -1.22786328e-01f, -8.95925984e-02f, -6.31344989e-02f,
  -1.63887009e-01f, -1.10226758e-01f, -4.46905643e-02f, -5.53849377e-02f, -3.04613821e-02f, 2.90907663e-03f, 2.04524741e-01f, 1.53958812e-01f, 1.97997123e-01f, 6.29335120e-02f,
  2.60512717e-02f, 4.72163036e-02f, 2.57240742e-01f, 1.40859976e-01f, -3.89417782e-02f, -1.42367044e-03f, 1.39129564e-01f, 1.44314080e-01f, -5.59064671e-02f, 7.72337168e-02f,
  -7.55216405e-02f, -1.77522182e-01f, 9.09052044e-02f, -4.41547707e-02f, 2.44896230e-03f, -3.98658626e-02f, -8.79504606e-02f, -3.59962247e-02f, -2.31531961e-03f, 7.77255371e-02f,
  -6.34890199e-02f, -2.35137232e-02f, -1.21752575e-01f, 7.67956823e-02f, -4.97234762e-02f, 1.06298756e-02f, -2.61685662e-02f, 3.55225466e-02f, 2.41345838e-02f, 2.49089096e-02f,
  -7.42131397e-02f, -1.82106951e-03f, 9.75786056e-03f, 4.22983058e-02f, -7.20591769e-02f, 3.96375395e-02f, -8.93266127e-03f, -9.93942618e-02f, 2.75421739e-02f, -3.94094847e-02f,
  -4.19348143e-02f, -7.39070401e-03f, -3.57450619e-02f, -7.58554935e-02f, 7.66922906e-02f, 8.21188092e-02f, -2.14365814e-02f, -4.26495448e-02f, -5.65338768e-02f, -3.20930295e-02f,
  3.48370448e-02f, 7.58159906e-02f, 4.41602543e-02f, 5.61310463e-02f, -5.75886071e-02f, 5.31013170e-03f, -3.41461636e-02f, -4.66092750e-02f, 6.63259774e-02f, -1.06479237e-02f,
  4.63159047e-02f, -5.92504209e-03f, 6.79446161e-02f, 4.36155349e-02f, 6.86399871e-04f, 1.37644010e-02f, 2.64369473e-02f, 2.46537402e-02f, -2.27575544e-02f, -2.65661106e-02f,
  -7.55742192e-02f, 6.16421923e-02f, 8.35847780e-02f, -7.73796737e-02f, 1.54133122e-02f, 2.62038759e-03f, -7.09261969e-02f, 7.30056036e-03f, -4.26165834e-02f, 1.04292845e-02f,
  2.59267110e-02f, -5.83836529e-03f, -1.34328574e-01f, 3.87496203e-02f, 5.74556626e-02f, -3.48299183e-02f, -6.92735147e-03f, 5.33185957e-04f, -4.48317416e-02f, -5.77388629e-02f,
  -2.23847907e-02f, 4.48001586e-02f, -1.41533716e-02f, -8.46932232e-02f, -7.15352446e-02f, -1.18799604e-01f, 5.06821088e-02f, 3.31287310e-02f, 1.98484045e-02f, 2.10311692e-02f,
  -2.86136359e-01f, 1.57409385e-02f, 5.48572317e-02f, 6.98679220e-03f, 1.37319103e-01f, -6.27639815e-02f, -2.58703411e-01f, -1.46231458e-01f, -1.65769339e-01f, -3.91764343e-02f,
  9.05559137e-02f, 8.85029808e-02f, -1.09484702e-01f, -1.84331566e-01f, -2.23259836e-01f, -2.45970443e-01f, -6.26484677e-02f, -9.30447057e-02f, -1.53219610e-01f, -1.25537127e-01f,
  -7.51267094e-03f, -1.48058742e-01f, -1.88237458e-01f, -5.80869131e-02f, 1.26433045e-01f, 1.79422140e-01f, 1.47646284e-02f, 1.10159263e-01f, 1.06536441e-01f, 2.41772085e-01f,
  2.37068266e-01f, -7.35282339e-03f, -3.47206444e-02f, -1.81014650e-02f, 8.15194473e-02f, -3.22957821e-02f, -2.61550061e-02f, -4.60013114e-02f, -4.65785386e-03f, 1.43705904e-02f,
  1.35310262e-01f, 3.47776487e-02f, 1.06720692e-02f, -7.37681612e-02f, -1.08715378e-01f, -1.17708065e-01f, -1.78791746e-01f, -1.41590655e-01f, -1.01959296e-01f, -1.33972301e-03f,
  -6.09773258e-03f, -5.81269637e-02f, -4.66435328e-02f, -7.52116293e-02f, -4.97256815e-02f, -3.39473747e-02f, -8.06273893e-03f, -3.02292518e-02f, 7.97893554e-02f, -9.83746070e-03f,
  4.26240731e-03f, 3.11053675e-02f, -8.36789310e-02f, 1.72054197e-03f, -2.86939964e-02f, 5.83836585e-02f, 3.20875868e-02f, 1.30714960e-02f, -2.91750543e-02f, -2.91192401e-02f,
  4.46716230e-03f, 5.39761335e-02f, -4.64842580e-02f, 7.89749548e-02f, -7.82035198e-03f, 4.64430489e-02f, -4.39472236e-02f, -5.37214473e-05f, -7.36400932e-02f, 6.50987308e-03f,
  7.97758531e-03f, -2.85333414e-02f, 1.25125162e-02f, 3.89179885e-02f, -8.70686397e-02f, -7.52636492e-02f, 1.84803095e-03f, 3.86759676e-02f, -7.68440813e-02f, -7.85494819e-02f,
  1.74255501e-02f, -8.81467313e-02f, 3.97590548e-02f, -1.78239048e-01f, 1.22616999e-01f, -3.38503197e-02f, 1.07650764e-01f, -1.15535557e-02f, 9.56896245e-02f, -5.26393764e-02f,
  -8.20330009e-02f, -5.85142784e-02f, -3.51696555e-03f, -3.83829921e-02f, -5.88165224e-02f, -1.11174114e-01f, -7.56389648e-02f, 8.54953192e-03f, -2.11923337e-03f, -1.37614403e-02f,
  -1.70496151e-01f, -1.31059796e-01f, -1.37894958e-01f, -7.08903894e-02f, -5.29218139e-03f, 2.39947513e-02f, 1.00538144e-02f, -4.25117798e-02f, -5.64985536e-02f, -5.66536821e-02f,
  -7.54711688e-01f, -1.68176293e-01f, 1.71203047e-01f, -2.45009571e-01f, -1.03396274e-01f, 5.90016507e-02f, -9.86570567e-02f, -1.69087231e-01f, -1.71320483e-01f, -1.00884542e-01f,
  -2.44979784e-01f, -9.02642086e-02f, 2.17929520e-02f, 1.12126954e-01f, 1.52547896e-01f, 1.10786604e-02f, 2.67539203e-01f, 1.74869522e-01f, 1.69101030e-01f, -8.78358781e-02f,
  6.21597171e-02f, 5.65675795e-02f, 5.28573282e-02f, 4.42366488e-02f, -2.11386174e-01f, -3.22982855e-02f, 3.96838076e-02f, 1.59297958e-02f, 1.49082765e-02f, 7.69495592e-03f,
  -1.45563424e-01f, -2.95820713e-01f, 1.00926086e-01f, -5.92350189e-05f, 4.12386730e-02f, -1.16575599e-01f, -6.57248423e-02f, 3.26141939e-02f, -2.61735241e-03f, -9.99974012e-02f,
  7.17994198e-03f, -3.19382697e-02f, -9.25248340e-02f, 5.29972953e-04f, -1.17387347e-01f, 5.60195884e-03f, 9.37513858e-02f, 1.42857745e-01f, 1.08805649e-01f, -6.77876025e-02f,
  2.32001711e-02f, -4.44496758e-02f, -3.10683548e-02f, 1.16421282e-01f, -1.92857161e-02f, 8.91822577e-02f, -9.22752731e-03f, -8.33964050e-02f, 6.64836308e-03f, -2.53391594e-01f,
  6.90765604e-02f, -9.45844408e-03f, 3.49072292e-02f, -1.17869312e-02f, -4.53896262e-02f, -8.81657973e-02f, 3.38249244e-02f, -4.94903699e-02f, 2.93537043e-02f, 3.20492387e-02f,
  2.04920974e-02f, 3.94312404e-02f, 2.61092652e-02f, -8.02288279e-02f, 6.18942548e-03f, 2.35594977e-02f, -4.92294915e-02f, 4.42699865e-02f, 2.31189709e-02f, 7.19359070e-02f,
  -5.90948276e-02f, 7.66849071e-02f, 2.56579258e-02f, -7.13927485e-03f, 9.23001766e-02f, 3.34517024e-02f, 8.94464832e-03f, -7.49088302e-02f, -6.98220134e-02f, -1.69695299e-02f,
  -2.10608438e-01f, 4.74900723e-01f, -2.28019595e-01f, -1.15051411e-01f, -1.33179678e-02f, 1.17068745e-01f, -1.03214033e-01f, 5.51344045e-02f, -4.62084264e-02f, -6.88957572e-02f,
  -7.55299032e-02f, -4.60347272e-02f, -4.77442145e-03f, 6.33381531e-02f, 2.38477271e-02f, -2.38317437e-02f, -7.55123571e-02f, 5.10387085e-02f, 2.40591671e-02f, -6.57884106e-02f,
  5.29624447e-02f, -1.41397759e-01f, -1.80150926e-01f, -1.26574442e-01f, -4.23233435e-02f, -8.33000764e-02f, -7.73000792e-02f, -1.21857598e-01f, -2.56767720e-02f, -2.27890536e-01f,
  1.20496880e-02f, -5.79603761e-02f, -5.72721772e-02f, 2.01430410e-01f, 3.17829065e-02f, -2.35329062e-01f, -2.33596787e-01f, -1.40089378e-01f, 1.46192864e-01f, 1.46651283e-01f,
  8.35252777e-02f, 2.20148370e-01f, 2.48307526e-01f, 2.45027050e-01f, 8.82920027e-02f, -7.16923028e-02f, 1.69055805e-01f, 1.43890753e-01f, 3.65915522e-02f, 1.71648294e-01f,
  3.07243496e-01f, 1.59627169e-01f, 1.46590754e-01f, 2.03994259e-01f, 1.55998275e-01f, 2.21978873e-01f, 4.84589040e-02f, 1.21649094e-01f, 1.69731528e-01f, 3.52920413e-01f,
  1.10052176e-01f, -1.51869789e-01f, 1.47883192e-01f, 1.38320237e-01f, 6.57586679e-02f, -5.96967451e-02f, 5.06267063e-02f, -5.73177300e-02f, -7.78478011e-02f, -6.96697012e-02f,
  3.68282422e-02f, 3.18545289e-02f, 1.89517327e-02f, -6.09309934e-02f, -8.98968130e-02f, -1.51547715e-02f, -5.74263372e-02f, 3.33605260e-02f, -3.02435830e-02f, -7.89775401e-02f,
  3.72538120e-02f, -7.13418424e-02f, -1.69248194e-01f, -1.77031502e-01f, 3.98317585e-03f, 2.45607048e-02f, -5.30655682e-02f, -1.97552959e-03f, -1.57254040e-01f, 1.14488816e-02f,
  3.54129188e-02f, -2.30044629e-02f, -2.07345597e-02f, 2.94461343e-02f, -7.64867384e-03f, 4.82680090e-02f, 1.01024602e-02f, 1.39707569e-02f, 7.69700250e-03f, -5.58072180e-02f,
  -5.36919609e-02f, -3.45495879e-03f, -1.89762264e-02f, -4.25601425e-03f, 1.02412753e-01f, -8.49859044e-02f, -3.09687145e-02f, 5.33217415e-02f, -3.19813080e-02f, -5.53817712e-02f,
  4.84407507e-02f, -2.83922963e-02f, 6.45888038e-03f, 2.11359933e-02f, 2.41498966e-02f, -3.73297296e-02f, 2.94311941e-02f, -1.02652282e-01f, 3.10398731e-02f, -8.51142853e-02f,
  -3.91064100e-02f, -1.39594346e-01f, 1.07281908e-01f, -1.20553914e-02f, -1.23656671e-02f, 1.48355076e-02f, 6.01719283e-02f, -3.71541791e-02f, -5.37422486e-02f, 5.57309366e-04f,
  -6.17695898e-02f, 7.67157301e-02f, -9.35612768e-02f, -3.93173378e-03f, -5.52484021e-02f, 2.79372965e-04f, -1.99836772e-02f, 3.47550847e-02f, -5.94966905e-03f, 2.28841268e-02f,
  5.20451041e-03f, -4.85871211e-02f, -3.06308493e-02f, -1.77025348e-01f, 1.03966724e-02f, 8.65230039e-02f, -1.72412097e-01f, -3.93927209e-02f, -1.34642154e-01f, -2.38571286e-01f,
  -3.20890069e-01f, -1.54840514e-01f, -1.74032003e-01f, -6.97422698e-02f, 1.76303804e-01f, 3.84927280e-02f, 7.32787177e-02f, -5.63780554e-02f, 4.89719920e-02f, -6.91119656e-02f,
  4.96505797e-02f, 1.67351723e-01f, -2.79107615e-02f, 7.68559426e-02f, -9.24025923e-02f, -2.79337075e-02f, -4.70243618e-02f, -5.21401688e-02f, 1.19532414e-01f, 1.12211362e-01f,
  2.13339090e-01f, -1.43463928e-02f, 2.54763514e-02f, 1.04968682e-01f, 4.60035019e-02f, 8.01415071e-02f, -4.43168990e-02f, -4.77973446e-02f, 3.95358279e-02f, -5.39406426e-02f,
  -1.12831153e-01f, -2.07861647e-01f, 8.31649378e-02f, 7.08329752e-02f, 9.22636688e-02f, -1.33700848e-01f, -2.59792972e-02f, -8.90301690e-02f, -4.25859317e-02f, 7.58547755e-03f,
  -1.44359628e-02f, 5.65361939e-02f, -2.05422882e-02f, 4.47794832e-02f, -8.13366845e-02f, 1.73609406e-02f, -1.00825213e-01f, -2.80282293e-02f, -7.79123604e-02f, -1.17574260e-01f,
  1.13219075e-01f, 8.44483823e-03f, -5.46046793e-02f, -3.50838862e-02f, -1.65525883e-01f, -2.95711160e-02f, -1.44605815e-01f, -1.21442638e-01f, -1.72456488e-01f, -2.39008278e-01f,
  -3.44885737e-02f, -3.40540148e-02f, 2.02076323e-02f, -5.45359179e-02f, -3.23438086e-02f, -2.85299663e-02f, 3.19322906e-02f, 2.50538979e-02f, -2.36533079e-02f, 3.53906932e-03f,
  -6.43967534e-04f, 5.75068295e-02f, 9.27317422e-03f, -1.12875411e-02f, -1.14169605e-02f, 9.00629312e-02f, 8.95600095e-02f, -2.36611255e-02f, 4.06490006e-02f, -2.91686263e-02f,
  -4.77844812e-02f, 1.59395933e-02f, -8.31657648e-02f, 3.37068625e-02f, -3.72233801e-02f, -1.11996746e-02f, -5.43938279e-02f, -4.43337522e-02f, -1.36133535e-02f, 3.73147540e-02f,
  -7.72012994e-02f, 1.58114433e-02f, -8.66028666e-02f, 9.09237599e-04f, 3.43834050e-02f, -6.78241998e-02f, 1.03778735e-01f, 5.49426489e-02f, 3.05082817e-02f, -5.07520773e-02f,
  2.03195065e-02f, -1.11022927e-01f, -1.24558564e-02f, 1.20117217e-02f, 6.64999411e-02f, -7.85394907e-02f, -6.62021786e-02f, -3.65339965e-02f, -1.07167177e-01f, -5.51940575e-02f,
  -3.79754528e-02f, -5.90749346e-02f, -1.90494820e-01f, -1.39320716e-01f, 3.42629664e-03f, -4.27955575e-03f, -1.63680002e-01f, -5.14280275e-02f, -1.57838926e-01f, -2.54737556e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  1.39020935e-01f, 3.74095470e-01f, 1.01630889e-01f, 2.41211683e-01f, 1.11976653e-01f, 2.52150863e-01f, 6.47640899e-02f, 3.13543648e-01f, 5.54675460e-02f, 4.02087301e-01f,
  4.02737379e-01f, 2.03336850e-01f, 2.60136604e-01f, 7.41021484e-02f, -4.48067747e-02f, 2.36266375e-01f, 2.95700639e-01f, 1.97133452e-01f, 3.71142328e-01f, 1.46931037e-01f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  9.29768756e-02f, -6.87897727e-02f, -1.22162558e-01f, 1.66145414e-02f, 2.88685225e-02f, -3.15646023e-01f, -1.20357379e-01f, 4.78260368e-01f, 4.04525787e-01f, 1.07196216e-02f,
  -1.34934029e-02f, 1.28287688e-01f, 1.37408093e-01f, 1.12366520e-01f, 1.75524175e-01f, 2.76127249e-01f, -6.39082491e-02f, 1.36470392e-01f, -2.81681597e-01f, 4.51237172e-01f,
  -2.77976334e-01f, -8.74499157e-02f, 1.34423479e-01f, -8.54473859e-02f, 1.66823491e-01f, 2.01809034e-01f, 2.74569631e-01f, -1.20951772e-01f, 9.88076627e-02f, -2.99648613e-01f,
  -3.65702897e-01f, 9.78106633e-02f, 1.11456849e-01f, 1.21800102e-01f, 1.37172684e-01f, 1.80179700e-01f, 1.07499048e-01f, 3.09398502e-01f, 1.96168572e-01f, 4.27476168e-01f,
  1.32274285e-01f, -2.14009926e-01f, -1.77561820e-01f, 6.08345568e-02f, -1.92811310e-01f, 5.11597335e-01f, 2.15920150e-01f, -1.36316102e-03f, 3.94356921e-02f, 2.47870192e-01f,
  5.49513996e-02f, -2.41838340e-02f, 2.03488201e-01f, 9.94424373e-02f, 1.01661056e-01f, -4.72161591e-01f, -2.08163485e-01f, -7.27869049e-02f, -2.98306257e-01f, 2.26817027e-01f,
  -1.53369039e-01f, -3.92696857e-02f, -3.38905305e-02f, -3.82143930e-02f, 1.45473987e-01f, 1.85207576e-01f, 1.38896123e-01f, -1.98362142e-01f, 7.06881508e-02f, -1.66940793e-01f,
  1.19778484e-01f, -1.41534016e-01f, -3.30081940e-01f, -1.36604205e-01f, 2.19474643e-01f, 1.23949163e-01f, 2.05978170e-01f, -3.24337453e-01f, -4.26556170e-02f, 1.25419334e-01f,
  9.30717029e-03f, 1.91112645e-02f, 2.23668188e-01f, 4.32428151e-01f, -4.87304963e-02f, 3.30758035e-01f, 3.69413942e-01f, -1.47438064e-01f, 1.06757879e-01f, -2.70686805e-01f,
  2.23939925e-01f, -1.13448597e-01f, -1.34947985e-01f, -4.43420500e-01f, -2.48385116e-01f, -2.64166623e-01f, -1.35443330e-01f, -8.95252451e-02f, -1.79360151e-01f, -7.02927485e-02f,
  5.22955460e-03f, -4.94949333e-02f, 7.74512663e-02f, 5.28074801e-02f, 3.54478806e-01f, -3.83003354e-01f, -5.09250537e-03f, -4.26995516e-01f, 9.70104709e-02f, -3.23849767e-02f,
  1.31459430e-01f, -1.12155639e-01f, -1.18864313e-01f, 2.61735708e-01f, -1.79993019e-01f, -9.49304253e-02f, -5.51578104e-02f, -2.77807057e-01f, -2.91142642e-01f, 3.67959291e-01f,
  2.89555997e-01f, 2.94813901e-01f, 2.88443565e-01f, -2.64416069e-01f, 1.96993962e-01f, -8.18773210e-02f, 1.54017955e-01f, 2.62318313e-01f, 2.80023385e-02f, 1.49157092e-01f,
  1.34940073e-01f, -1.62360162e-01f, 1.08828105e-01f, -1.44862667e-01f, -4.20541108e-01f, -1.47369266e-01f, -4.51950818e-01f, 3.20421010e-01f, 1.21106140e-01f, 3.87564689e-01f,
  2.06294164e-01f, -3.44057262e-01f, -1.92694902e-01f, 5.48133403e-02f, -2.42499530e-01f, 6.40495121e-03f, -5.40926261e-03f, 1.45064071e-01f, -1.54895425e-01f, 2.60494947e-01f,
  1.23239331e-01f, 1.39806449e-01f, -1.75888330e-01f, -1.78123236e-01f, 1.72777455e-02f, 8.12430754e-02f, -6.17006852e-04f, -2.34437436e-01f, 5.94537035e-02f, -4.82298695e-02f,
  -1.57812357e-01f, 4.91580702e-02f, 1.84464887e-01f, -3.45316418e-02f, 1.46299213e-01f, 3.72271895e-01f, 1.57126352e-01f, -4.75508459e-02f, 3.32142532e-01f, -3.66186082e-01f,
  -8.92458186e-02f, -2.72396624e-01f, -1.34228498e-01f, 3.42356771e-01f, 1.75824702e-01f, -3.93031053e-02f, 3.17164600e-01f, 2.17385203e-01f, 8.07693601e-02f, 2.26689354e-02f,
  -5.43809496e-02f, -1.95332810e-01f, 4.00317758e-02f, -3.59597921e-01f, -6.05931133e-02f, 5.31755239e-02f, -2.21692964e-01f, 1.12707838e-02f, 1.15849964e-01f, -3.82761478e-01f,
  1.83345396e-02f, 3.77679467e-02f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  3.79763567e-03f, 9.52737704e-02f, 1.87671021e-01f, -6.47970960e-02f, 2.74804711e-01f, 2.84050047e-01f, 8.74079578e-03f, -3.04534547e-02f, 3.37234437e-02f, 1.77718252e-01f,
  1.77375242e-01f, 5.09210043e-02f, 3.16912949e-01f, -3.04640591e-01f, -3.06316223e-02f, 4.87241298e-01f, -1.59219094e-02f, 5.29820519e-03f, 1.50665760e-01f, -9.80367437e-02f,
  1.27601981e-01f, 3.67001444e-02f, 3.51679504e-01f, 7.99124658e-01f, 2.19535962e-01f, 2.06018627e-01f, -3.85962278e-02f, 1.64950341e-01f, 2.15737969e-01f, 4.69237119e-01f,
  -1.19111352e-01f, 3.28436106e-01f, -1.65935114e-01f, 4.89286095e-01f, 5.06739914e-01f, -2.28797365e-02f, 4.54421103e-01f, 4.07781869e-01f, 2.88878940e-02f, -2.54880548e-01f,
  -1.32692948e-01f, -8.10276270e-02f, 3.45045894e-01f, -2.16161653e-01f, -2.49966055e-01f, 1.79506615e-01f, 2.00201541e-01f, -2.93286860e-01f, -4.62235846e-02f, -7.18884543e-02f,
  5.95337935e-02f, -2.62467116e-01f, -1.29245639e-01f, -1.38722537e-02f, 4.20356572e-01f, -5.06073713e-01f, -1.77057385e-01f, 7.71282986e-02f, -2.96208169e-02f, 3.06436509e-01f,
  1.34776846e-01f, 1.15402304e-01f, 3.27689439e-01f, 2.33123854e-01f, 2.06741005e-01f, 1.77255750e-01f, -5.37903607e-02f, 1.86640754e-01f, 3.63829546e-02f, -1.05824977e-01f,
  5.48154525e-02f, -1.34034187e-01f, 1.00080699e-01f, 1.47712931e-01f, 1.22151360e-01f, -1.13928266e-01f, 1.18818916e-02f, -1.82364225e-01f, -9.90485251e-02f, -9.20468718e-02f,
  -1.40837401e-01f, 8.49296153e-02f, -4.70594876e-02f, -1.15194455e-01f, -7.92466700e-02f, -7.56211132e-02f, -3.05565353e-03f, -4.89716418e-02f, 3.53540719e-01f, 2.43242040e-01f,
  1.75053813e-02f, 8.68445113e-02f, 3.75664175e-01f, 9.07363892e-02f, -6.18020147e-02f, 1.28638998e-01f, 8.41625333e-02f, 6.21279739e-02f, 3.60771179e-01f, 7.47938827e-02f,
  1.99127913e-01f, 1.38647616e-01f, 3.20068389e-01f, -5.35903394e-01f, -2.87994057e-01f, -9.78648812e-02f, -1.59560457e-01f, -4.20403570e-01f, 3.13366681e-01f, 9.05501619e-02f,
  -1.52655780e-01f, -1.48246557e-01f, -1.85222514e-02f, 5.16248345e-01f, 3.22968155e-01f, 1.66620910e-01f, -1.73132211e-01f, 9.34620351e-02f, 4.17810306e-02f, -5.49602248e-02f,
  2.36740083e-01f, 2.88108557e-01f, 7.88379088e-02f, -2.09353223e-01f, 5.31096339e-01f, -3.13377619e-01f, 2.06245622e-03f, 4.43440191e-02f, 1.46544755e-01f, 4.00659055e-01f,
  1.09414712e-01f, 2.23297715e-01f, 1.57255549e-02f, -1.17168747e-01f, -5.72911859e-01f, -1.99034840e-01f, -2.03366965e-01f, 6.41630650e-01f, 2.98165292e-01f, 6.20147169e-01f,
  2.48985246e-01f, 2.40613103e-01f, 2.12343395e-01f, -2.56637245e-01f, -1.30419880e-01f, -3.22451144e-01f, 6.25016838e-02f, -3.84256631e-01f, 3.09405088e-01f, 3.49770308e-01f,
  -8.07286277e-02f, 9.19449329e-02f, -2.84330342e-02f, -1.41470283e-01f, 1.80763096e-01f, 3.29793364e-01f, 3.00990622e-02f, 4.58103925e-01f, 6.09684944e-01f, 6.45180121e-02f,
  7.29929060e-02f, -1.64062724e-01f, 1.73935786e-01f, 2.20111474e-01f, 3.55535783e-02f, 2.87515894e-02f, -9.12460163e-02f, -2.50416487e-01f, 1.34952322e-01f, -1.63375475e-02f,
  -4.06568766e-01f, -1.06564671e-01f, 2.71444440e-01f, 4.25124913e-01f, 1.29262701e-01f, 1.38846382e-01f, -9.37869921e-02f, 3.85942817e-01f, 8.95186886e-03f, 1.42727450e-01f,
  -9.11802649e-02f, 2.17119545e-01f, -2.06379607e-01f, -1.37194186e-01f, -1.52466998e-01f, -1.81908727e-01f, -7.11910427e-02f, -1.37067735e-01f, 2.66979903e-01f, -2.41392523e-01f,
  1.01011835e-01f, 2.61162035e-02f, -5.94740212e-02f, -2.70031542e-02f, -1.98820457e-01f, 1.12324633e-01f, -1.36212245e-01f, 4.79032658e-02f, 1.33877143e-01f, 4.28846806e-01f,
  2.41937563e-01f, -2.33852983e-01f, -1.06717348e-01f, 2.18442783e-01f, -1.24839939e-01f, 1.23093873e-01f, -1.26727656e-01f, 2.49949753e-01f, 1.91789463e-01f, -3.56012508e-02f,
  5.03163338e-02f, 4.57942970e-02f, 6.11733459e-02f, 7.51350913e-03f, 1.58012047e-01f, -5.56570590e-02f, 4.87912335e-02f, -8.92642662e-02f, 2.52939127e-02f, 1.62215307e-01f,
  4.31543514e-02f, -1.16323166e-01f, -4.24249806e-02f, 1.33980498e-01f, -1.46903381e-01f, 3.55604976e-01f, 2.23311558e-01f, -9.09242593e-03f, 1.84761986e-01f, -2.55310386e-01f,
  3.58876973e-01f, -1.74544364e-01f, 1.33513168e-01f, -2.74166703e-01f, 1.28857885e-02f, -1.53935403e-01f, -3.19759250e-02f, 2.06651408e-02f, 5.47284372e-02f, 1.91071033e-01f,
  2.06919074e-01f, 1.48876319e-02f, -1.31557018e-01f, 8.77335016e-03f, -1.83553603e-02f, -3.28485578e-01f, 3.30224514e-01f, 1.86474979e-01f, 3.00100625e-01f, 4.75002795e-01f,
  -1.10971443e-02f, 1.41419202e-01f, -1.99019924e-01f, -6.95386110e-03f, 6.90201670e-02f, 1.85920388e-01f, -1.47243604e-01f, -1.37724072e-01f, 3.03594954e-02f, -9.72521976e-02f,
  3.31520359e-03f, 3.52420732e-02f, -2.41095304e-01f, 5.64403459e-03f, -1.87231869e-01f, 1.45596238e-02f, 1.36334985e-01f, -8.85275304e-02f, 3.47347051e-01f, 1.20626166e-01f,
  1.84803411e-01f, 2.34034374e-01f, -1.52243435e-01f, -2.08168346e-02f, -1.28386289e-01f, 2.07791522e-01f, -1.89548247e-02f, 6.81207776e-02f, 1.72073528e-01f, -1.04370834e-02f,
  2.76856944e-02f, 5.19269258e-02f, 1.77538753e-01f, 5.75809069e-02f, 2.24621799e-02f, -1.67951226e-01f, 7.75605515e-02f, 2.42259577e-01f, 1.88392326e-01f, 2.25510791e-01f,
  1.91620082e-01f, -4.29323725e-02f, 1.48952782e-01f, 2.96788990e-01f, -1.66365221e-01f, -4.85057026e-01f, -7.15380982e-02f, 5.03156841e-01f, 2.07563013e-01f, 5.67473322e-02f,
  -5.66461310e-02f, -3.87692481e-01f, -1.85910881e-01f, -6.42433167e-02f, 7.82641545e-02f, 1.70638207e-02f, -8.98407102e-02f, -1.78682402e-01f, -2.49540195e-01f, 4.16141778e-01f,
  -1.41053110e-01f, 3.96445841e-01f, 1.39768282e-02f, 2.42407665e-01f, -2.88735218e-02f, -7.07915723e-02f, 1.77277565e-01f, -4.93267849e-02f, 3.02564234e-01f, -4.26950157e-02f,
  1.34145275e-01f, -1.15754761e-01f, -4.31069620e-02f, -5.96865490e-02f, 8.62893742e-03f, 8.51965398e-02f, 8.70404467e-02f, -7.15331063e-02f, 1.11028396e-01f, 1.80390760e-01f,
  1.79789439e-02f, -1.89933583e-01f, -1.67119697e-01f, 2.75026798e-01f, 2.00054064e-01f, -8.84821489e-02f, -2.82354653e-02f, 2.96131102e-03f, -5.18324086e-03f, -1.57601401e-01f,
  1.93537042e-01f, 1.52614847e-01f, -1.25349328e-01f, -4.96247783e-02f, 1.10017601e-02f, 3.10971022e-01f, -9.69774053e-02f, 1.75804645e-02f, 6.52934015e-02f, 1.06899194e-01f,
  -3.11710574e-02f, 1.45519063e-01f, -1.83748707e-01f, 1.86196372e-01f, 2.22470224e-01f, 1.81707323e-01f, 2.59096414e-01f, 4.57459278e-02f, 2.26676762e-01f, 2.49213710e-01f,
  1.79933473e-01f, -2.39100367e-01f, -2.64603078e-01f, 1.10716134e-01f, 2.10486382e-01f, 5.49439430e-01f, 1.33730888e-01f, -3.53302918e-02f, 3.53169769e-01f, 2.36664906e-01f,
  -1.91384945e-02f, 4.25598592e-01f, -2.02614479e-02f, -7.35439286e-02f, 2.69355059e-01f, 4.34537716e-02f, -4.36648011e-01f, 3.12213957e-01f, -2.49614149e-01f, 1.59957521e-02f,
  -2.80614495e-01f, -4.03605819e-01f, 6.92598149e-03f, 1.45471111e-01f, 3.26670676e-01f, 1.93365246e-01f, 6.33077845e-02f, 8.94839615e-02f, 9.41336248e-03f, -1.59858186e-02f,
  2.04143584e-01f, -1.43329903e-01f, 1.97757050e-01f, -2.80279487e-01f, -2.86290944e-01f, -5.38191259e-01f, -1.16257764e-01f, 2.94089884e-01f, 3.11611086e-01f, -1.02032162e-01f,
  1.60048530e-01f, 5.58712959e-01f, -2.23613493e-02f, 1.12061284e-01f, -2.50518303e-02f, -3.12146664e-01f, 2.17422619e-02f, -7.45915547e-02f, 2.70757049e-01f, 3.70471716e-01f,
  6.40444905e-02f, 1.63021922e-01f, 4.02165174e-01f, 2.82623649e-01f, 2.61422098e-01f, 4.12627012e-01f, -2.18080461e-01f, 2.48103425e-01f, -5.24958782e-03f, 3.68497632e-02f,
  -7.20889941e-02f, 2.58892655e-01f, 1.75192691e-02f, -6.69410545e-03f, 1.75153881e-01f, -3.57679576e-01f, -3.40940773e-01f, 3.99722718e-03f, 1.30610019e-01f, 5.25538564e-01f,
  2.49208555e-01f, -3.00816953e-01f, 3.14970016e-01f, 1.57135755e-01f, 9.55273882e-02f, 3.48293446e-02f, -1.26431003e-01f, -2.47552022e-01f, -6.64885491e-02f, -1.44945621e-01f,
  -2.36729592e-01f, -1.81184113e-02f, -8.50745812e-02f, -2.16387242e-01f, -1.65556654e-01f, -1.00461900e-01f, 3.22938353e-01f, -4.42435592e-02f, 3.42108786e-01f, 5.50933599e-01f,
  4.37837869e-01f, 4.51159596e-01f, 4.50110048e-01f, 2.40845710e-01f, 2.42083535e-01f, 7.24499106e-01f, 9.24071148e-02f, -5.35872936e-01f, 9.88739729e-02f, 2.06481203e-01f,
  -1.86114700e-03f, 3.98501694e-01f, -1.51499435e-01f, 3.73959988e-01f, -1.39296159e-01f, -2.21066132e-01f, 2.65987217e-01f, 3.89261603e-01f, 1.56510770e-01f, 3.65809709e-01f,
  8.45234036e-01f, -2.69053221e-01f, 4.52300489e-01f, -3.80232811e-01f, -6.69633318e-03f, 2.69115895e-01f, -1.09517276e-01f, 2.21182927e-01f, -2.99332172e-01f, -3.17304075e-01f,
  -1.00189149e-01f, 3.66142154e-01f, 2.86237132e-02f, 2.92016268e-01f, 1.84780419e-01f, 2.10410152e-02f, -5.87807633e-02f, 2.57454187e-01f, -1.80730730e-01f, 3.58639807e-01f,
  -3.09618294e-01f, -9.42314044e-02f, 4.99864936e-01f, 2.63671160e-01f, 1.24742590e-01f, 1.71168372e-01f, 8.13597739e-02f, 3.01581383e-01f, -1.63785651e-01f, 1.33671448e-01f,
  1.97654784e-01f, 1.34214088e-01f, -1.99188367e-01f, 9.20592308e-01f, -4.75877114e-02f, 6.28293514e-01f, -1.91954508e-01f, -2.10614130e-01f, -1.20781258e-01f, 6.83324933e-01f,
  -3.46049845e-01f, 1.36635095e-01f, 1.38731763e-01f, -4.66941297e-02f, -5.27838022e-02f, 9.07313451e-02f, -1.58669561e-01f, -7.90157542e-02f, 9.52840671e-02f, 5.92264593e-01f,
  2.59342760e-01f, -3.20785344e-02f, -1.64551642e-02f, 6.16289005e-02f, 3.95097695e-02f, 4.57372159e-01f, -9.28789228e-02f, 2.43685335e-01f, 1.73999891e-01f, 3.48391831e-02f,
  -2.07264736e-01f, 5.90407848e-01f, 2.79236790e-02f, 1.24880567e-01f, 1.00544423e-01f, -1.12599276e-01f, -1.10030308e-01f, -2.01770112e-01f, -1.24815032e-01f, 1.65150493e-01f,
  -4.46039811e-02f, -2.62012601e-01f, 2.25687787e-01f, -1.19343169e-01f, 2.21898317e-01f, 2.42768183e-01f, 3.92019600e-01f, 1.82542473e-01f, 1.99973911e-01f, 1.19523458e-01f,
  -5.49951419e-02f, -1.20754026e-01f, -1.08263634e-01f, 1.95597544e-01f, -1.03633828e-01f, 2.17129022e-01f, 1.12872034e-01f, -1.13427654e-01f, 1.05885431e-01f, -1.21598497e-01f,
  8.24126378e-02f, 1.90199409e-02f, 2.68957093e-02f, 9.22830105e-02f, -1.49130568e-01f, 5.79122663e-01f, 1.13988936e-01f, -1.48957357e-01f, -2.31142953e-01f, 1.05323851e-01f,
  5.89088984e-02f, -1.15507655e-01f, 1.16595313e-01f, 5.49035976e-05f, -2.74123192e-01f, -2.29788497e-01f, 2.24998072e-01f, -1.24213904e-01f, 5.29635549e-02f, 2.25053310e-01f,
  1.76287457e-01f, -2.08558012e-02f, -1.50158210e-02f, 3.34353447e-02f, 1.62519857e-01f, 1.30147219e-01f, 2.49037877e-01f, 2.30581701e-01f, -1.26902282e-01f, 2.03754425e-01f,
  -1.63326278e-01f, 7.91823864e-02f, 2.17618734e-01f, -1.77827105e-01f, -1.07718423e-01f, -7.22684190e-02f, -4.98089008e-03f, -5.07382583e-03f, 8.55399519e-02f, -3.87370169e-01f,
  1.10386938e-01f, -1.60968781e-01f, -7.61514977e-02f, 2.23323759e-02f, 8.05685669e-02f, 4.07272950e-02f, 1.77153870e-01f, 3.11313197e-02f, -1.16487056e-01f, -6.93113506e-02f,
  1.45912379e-01f, -1.42680705e-01f, -1.63187459e-01f, 1.74940601e-02f, -3.27610485e-02f, 3.70018557e-02f, -1.23274215e-01f, 2.29364894e-02f, -1.68933302e-01f, 4.35328744e-02f,
  2.33164892e-01f, 9.02567059e-02f, 2.54698005e-02f, -1.27046600e-01f, 3.96099687e-02f, 1.87924400e-01f, 1.47006109e-01f, 1.82160363e-01f, -1.32360339e-01f, -1.14060238e-01f,
  1.22414283e-01f, 8.81830752e-02f, 2.90506836e-02f, -1.60650671e-01f, -1.14964649e-01f, 7.99290389e-02f, -9.30725187e-02f, -7.87780583e-02f, 1.89283326e-01f, 9.78143290e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  4.23048437e-02f, 2.86448002e-01f, 2.78350890e-01f, 1.69487551e-01f, 3.29217792e-01f, 6.03184802e-03f, 6.66550994e-02f, 4.12318558e-02f, 1.20324768e-01f, 3.22324812e-01f,
  -1.14904111e-02f, 1.71089649e-01f, 3.67645890e-01f, 3.46580446e-01f, 3.36687624e-01f, 3.88799347e-02f, 3.38224202e-01f, 3.22530508e-01f, 1.87044561e-01f, -1.17451526e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -4.86889124e-01f, -3.16090167e-01f, -5.08171082e-01f, -2.87535191e-01f, -2.20186129e-01f, -2.28433907e-01f, 9.54684317e-02f, 2.19814286e-01f, 8.75759870e-03f, -2.16343179e-01f,
  -1.47634193e-01f, -5.36728427e-02f, -3.71405602e-01f, 2.31463224e-01f, -6.28349558e-02f, -2.14812509e-03f, -9.58066061e-02f, -7.28043467e-02f, -1.85706154e-01f, 5.77437222e-01f,
  -3.23272273e-02f, -4.86156642e-01f, 2.30090499e-01f, 7.13513792e-01f, 4.34501171e-01f, 2.70579606e-01f, -6.44396365e-01f, 2.97625452e-01f, -1.26337647e-01f, -1.00948162e-01f,
  -1.64179504e-01f, -1.14904583e-01f, -1.45600755e-02f, -2.80633837e-01f, 3.31457198e-01f, 2.79210180e-01f, -1.99401870e-01f, 6.96156360e-03f, 5.78961253e-01f, -1.30139992e-01f,
  -3.31753910e-01f, 3.82621646e-01f, 2.37401724e-02f, 1.85498565e-01f, -7.35652566e-01f, -4.31968629e-01f, -3.25688571e-01f, -2.44708136e-01f, -4.19350505e-01f, 3.13768446e-01f,
  3.20729375e-01f, -9.30907950e-02f, -1.74333110e-01f, -2.29735881e-01f, -5.64559828e-04f, 4.62094367e-01f, 3.79469067e-01f, 7.06323266e-01f, 3.51884991e-01f, -2.22028822e-01f,
  8.12482417e-01f, -3.46288383e-01f, 7.77579919e-02f, 1.00753978e-01f, -1.86681554e-01f, -3.32549334e-01f, -2.64965594e-01f, -2.94007417e-02f, 4.66000319e-01f, 3.83706540e-01f,
  -3.80365074e-01f, 3.33995134e-01f, -7.31552064e-01f, -2.07713425e-01f, -5.18458307e-01f, -1.63179174e-01f, 1.30151227e-01f, 3.71220440e-01f, 4.20388877e-02f, -5.48499405e-01f,
  5.07968366e-01f, -2.70784497e-01f, 9.32035409e-03f, -1.36986494e-01f, -2.52700180e-01f, -3.94124091e-01f, 4.35979627e-02f, -3.08381885e-01f, 2.59104818e-01f, 3.94340884e-03f,
  4.53746498e-01f, 3.69936407e-01f, -1.58929542e-01f, 5.91178872e-02f, 1.04563393e-01f, -4.25312035e-02f, 5.88580333e-02f, 2.25470781e-01f, -1.57825783e-01f, -1.25156209e-01f,
  -3.50619666e-02f, 4.24764007e-01f, 3.20988800e-03f, -3.48318189e-01f, -3.26151311e-01f, 2.06175516e-03f, -2.80420303e-01f, -3.73855117e-03f, 6.94785535e-01f, -5.77245474e-01f,
  1.44616097e-01f, -5.43680489e-02f, -5.13538063e-01f, -4.20870334e-01f, 1.56030521e-01f, 3.76944631e-01f, -2.23215327e-01f, 3.67428631e-01f, -7.28900582e-02f, -2.24660411e-01f,
  1.70525506e-01f, -3.18638772e-01f, -3.97523880e-01f, 7.20231414e-01f, -9.43234786e-02f, -8.46496671e-02f, -7.13134333e-02f, -6.40192404e-02f, 1.50867403e-01f, 2.52243698e-01f,
  2.49326289e-01f, -2.06993535e-01f, 1.85190335e-01f, 1.86844230e-01f, -1.41468393e-02f, 3.57716709e-01f, -3.14286500e-01f, 5.44673324e-01f, -5.27527392e-01f, 5.65078259e-01f,
  -1.51637122e-01f, -3.12850177e-01f, 2.80093372e-01f, 7.87706494e-01f, -3.20614755e-01f, 3.89886230e-01f, -2.22623229e-01f, -2.39650011e-01f, 2.85832006e-02f, -4.76644039e-02f,
  1.32055491e-01f, -1.61563605e-01f, 4.79172677e-01f, -3.08606684e-01f, -6.52822912e-01f, -3.01591642e-02f, -4.92944978e-02f, 2.66252697e-01f, 4.93403561e-02f, -5.99390119e-02f,
  3.93054038e-01f, -3.78837824e-01f, 5.10634303e-01f, 4.26188171e-01f, 4.49921966e-01f, -2.87980616e-01f, -3.64247054e-01f, 6.05858147e-01f, 4.38168436e-01f, -3.03237200e-01f,
  -4.17636245e-01f, 3.90382171e-01f, -1.74465120e-01f, 6.28112018e-01f, -3.85354698e-01f, 3.96112561e-01f, -4.31456327e-01f, 4.04454470e-02f, -1.70551643e-01f, 1.84899241e-01f,
  -1.60284668e-01f, -7.72005096e-02f, -2.77176440e-01f, 6.36784792e-01f, 1.60882473e-02f, 5.32160103e-01f, 2.85607517e-01f, -2.48875454e-01f, -9.15275738e-02f, 3.44580114e-01f,
  -1.48926049e-01f, 1.28780141e-01f, 3.40072423e-01f, 1.38501137e-01f, 3.36847067e-01f, -2.37279177e-01f, -2.67279953e-01f, 1.33108005e-01f, -2.40794182e-01f, 3.32449935e-02f,
  6.01525366e-01f, -5.43794215e-01f, 3.63676459e-01f, -5.56759238e-01f, -3.98321241e-01f, 2.60842844e-05f, -5.06577156e-02f, -3.87248874e-01f, 9.44740653e-01f, -2.93543488e-01f,
  -1.63025707e-01f, -1.90730929e-01f, -1.62604764e-01f, 4.57878590e-01f, -2.15872467e-01f, -2.97157496e-01f, -7.76682377e-01f, -7.83407986e-02f, 2.13305280e-01f, -3.96243364e-01f,
  2.59906262e-01f, 4.16702360e-01f, 3.23263496e-01f, -2.00621694e-01f, 2.54151188e-02f, -6.35177255e-01f, -9.25512388e-02f, 2.61364225e-02f, -3.40602279e-01f, -5.84451497e-01f,
  -2.67326534e-01f, -5.04231155e-01f, -6.74316287e-02f, 1.23005398e-01f, 1.74929112e-01f, -3.14272225e-01f, 5.15114784e-01f, -3.79360914e-01f, -3.95737588e-02f, -2.05613986e-01f,
  7.46462047e-01f, -1.60391778e-01f, 1.08030021e-01f, -3.98810860e-03f, 2.95442998e-01f, 2.24701837e-01f, -3.28197926e-02f, -1.09572984e-01f, -2.30857193e-01f, 4.71209884e-02f,
  -6.20730639e-01f, 5.72177470e-01f, 4.14918363e-02f, -4.59721357e-01f, -3.43175918e-01f, 1.90221712e-01f, -4.25126284e-01f, -1.23535208e-01f, -1.50433645e-01f, 1.25494391e-01f,
  2.01187387e-01f, -7.98667315e-03f, 2.28091851e-01f, 3.82065117e-01f, 2.93007195e-01f, -4.45155442e-01f, 2.87131201e-02f, 6.92371875e-02f, 2.54779279e-01f, 8.82128906e-03f,
  -1.66953817e-01f, -5.36183178e-01f, -3.71460408e-01f, -2.08148122e-01f, 4.36548978e-01f, 3.38677093e-02f, 8.31382498e-02f, -4.49510038e-01f, -1.41526729e-01f, 1.48405686e-01f,
  -3.70910585e-01f, -4.64416891e-01f, 1.02814412e+00f, -5.64064622e-01f, 5.06472468e-01f, -7.68289044e-02f, 3.33412558e-01f, -1.44298270e-01f, 2.92419940e-01f, 2.20921934e-01f,
  4.64969546e-01f, 4.45819825e-01f, 4.34857368e-01f, 5.10806680e-01f, -3.57899010e-01f, -1.49674580e-01f, -5.09611607e-01f, -4.52750474e-02f, 4.29450959e-01f, 2.15373158e-01f,
  6.70653582e-02f, 6.47947311e-01f, 6.32555112e-02f, 4.39416878e-02f, 4.02944416e-01f, 3.19808781e-01f, 7.45007768e-02f, -3.62695366e-01f, 6.20422214e-02f, 6.44546032e-01f,
  3.40883061e-02f, -3.79408151e-01f, 7.20816031e-02f, 1.31275550e-01f, -7.98691809e-01f, -3.99319232e-01f, -2.41198972e-01f, 3.05603240e-02f, 1.99830025e-01f, -4.28249054e-02f,
  3.50052826e-02f, 5.29723585e-01f, 1.21947020e-01f, -1.79036662e-01f, 2.76602179e-01f, 3.70275639e-02f, 7.77892321e-02f, 4.68920954e-02f, 4.97361064e-01f, 4.11930919e-01f,
  -4.97934550e-01f, 3.21343213e-01f, -5.41405426e-03f, 3.92996103e-01f, 3.30963373e-01f, 4.53930050e-01f, -3.49372447e-01f, -3.61691505e-01f, -2.14810655e-01f, 4.13844019e-01f,
  -1.08346194e-01f, -2.33072981e-01f, -3.20782155e-01f, -4.73312974e-01f, 3.19018722e-01f, -1.56701222e-01f, 6.61271691e-01f, -8.16204250e-01f, -4.27197456e-01f, -1.06180862e-01f,
  -5.16449399e-02f, -6.70865551e-02f, -1.90074816e-01f, 2.02965051e-01f, -3.70771468e-01f, -4.53314856e-02f, -3.66268158e-01f, 1.12509727e-02f, 4.81052667e-01f, -1.39806405e-01f,
  5.20740926e-01f, -3.21192205e-01f, 4.42411751e-01f, -3.69704187e-01f, 1.86078578e-01f, -4.69221711e-01f, -2.22371981e-01f, -8.77865851e-02f, -2.13338565e-02f, 2.41641521e-01f,
  -1.86346963e-01f, -3.47076386e-01f, 2.47226030e-01f, 7.33468356e-03f, -1.48247898e-01f, 1.44326597e-01f, -5.50327778e-01f, -2.13879406e-01f, 5.12770951e-01f, 6.43919349e-01f,
  1.78893939e-01f, 5.17623067e-01f, -2.99631566e-01f, -1.34144560e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.09989785e-01f, 2.40347460e-01f, 7.38001764e-02f, -1.72499016e-01f, 2.25190088e-01f, -1.02452710e-01f, -7.96217546e-02f, -5.46062216e-02f, -2.39807323e-01f, -5.32586314e-02f,
  -5.10121584e-02f, -1.73979178e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    