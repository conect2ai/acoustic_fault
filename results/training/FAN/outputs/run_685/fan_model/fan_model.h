/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.60429680e-01f, -2.50390828e-01f, -2.58667350e-01f, -3.68181057e-02f, 5.87292165e-02f, 1.19750194e-01f, 7.49049112e-02f, -4.82510217e-03f, -5.67697585e-02f, -7.21509382e-03f,
  5.25278412e-02f, -3.37154493e-02f, -8.78583733e-03f, 5.94209172e-02f, 4.45693452e-03f, -9.70038250e-02f, -1.64623737e-01f, -9.18023139e-02f, 8.09988230e-02f, 1.30288884e-01f,
  -9.11248196e-03f, -2.39267573e-02f, -2.35529244e-02f, -2.83487216e-02f, -6.68069869e-02f, -7.56179169e-02f, -1.05971992e-01f, -5.50923198e-02f, -1.23634286e-01f, -3.15863401e-01f,
  -1.23369321e-01f, 6.46392480e-02f, 8.00179765e-02f, 7.37988800e-02f, 1.27850510e-02f, 5.72231188e-02f, -4.44540707e-03f, -9.66504775e-03f, 3.63205187e-02f, -3.87860578e-03f,
  5.03448099e-02f, -2.47316528e-02f, 4.87567522e-02f, 5.43119051e-02f, -2.14034896e-02f, 4.51028980e-02f, 1.76200792e-02f, -4.44360189e-02f, -3.07622030e-02f, 1.01180291e-02f,
  -8.22275504e-02f, -7.89366383e-03f, 3.81109342e-02f, 8.31847824e-03f, 7.10649118e-02f, 7.97189213e-03f, 4.42491993e-02f, 7.13347718e-02f, 3.09359320e-02f, -8.05471931e-03f,
  9.54197794e-02f, -3.64760086e-02f, -1.18183561e-01f, -8.05406496e-02f, -4.25087847e-02f, -1.08500615e-01f, -1.11970678e-01f, 3.31785972e-03f, 1.97796971e-02f, -9.48953703e-02f,
  2.62065809e-02f, 2.99457982e-02f, -9.01551545e-02f, -2.35909466e-02f, -9.25853252e-02f, -1.49700716e-01f, -6.30652755e-02f, -1.07776731e-01f, -1.06029086e-01f, -1.24745004e-01f,
  5.47638768e-03f, -1.17200695e-01f, -7.02893734e-02f, -1.46861777e-01f, -7.38341734e-02f, -9.75892171e-02f, -1.42416507e-01f, 2.58406624e-02f, -4.58381586e-02f, -3.91766205e-02f,
  1.15723021e-01f, 1.91397905e-01f, 5.08159585e-02f, 5.44841327e-02f, 2.13893261e-02f, 1.12456225e-01f, 1.08431436e-01f, -1.70263723e-02f, 9.00595710e-02f, 5.26831150e-02f,
  5.16002811e-02f, 1.11334883e-01f, -1.34112118e-02f, 3.96532677e-02f, 8.55162591e-02f, 6.27710447e-02f, 9.18577686e-02f, 8.78911689e-02f, 2.33480781e-02f, 3.03916857e-02f,
  2.63253283e-02f, 1.93676025e-01f, 2.35135213e-01f, 2.82104705e-02f, 1.24066845e-01f, 1.69029757e-01f, 1.66000083e-01f, 1.33005291e-01f, 2.81749308e-01f, 1.04919598e-01f,
  5.56324869e-02f, -8.16473216e-02f, -1.66806802e-01f, 1.08338244e-01f, -5.34663796e-02f, -1.74023688e-01f, -2.29115739e-01f, -7.16650710e-02f, -6.25434890e-02f, -7.81924948e-02f,
  -2.02599112e-02f, -3.75580564e-02f, 1.34885348e-02f, -1.18901879e-02f, -2.58113056e-01f, -3.29429895e-01f, -2.08377585e-01f, -2.11022630e-01f, -7.33035654e-02f, -5.21073584e-03f,
  -1.37731358e-01f, 1.00221159e-02f, 1.77388955e-02f, -1.05481083e-02f, 3.90500985e-02f, -7.74824619e-02f, 4.95912954e-02f, 4.77539338e-02f, 1.05228741e-02f, -1.24446020e-01f,
  -6.43262938e-02f, -1.73791219e-02f, -3.75332721e-02f, -8.08864459e-02f, -3.11819762e-02f, -1.45508543e-01f, -5.95432855e-02f, -4.93250862e-02f, -1.05546694e-02f, -5.17118908e-02f,
  -6.20952845e-02f, 3.98742408e-02f, -5.65641187e-03f, -4.86911200e-02f, -1.20531537e-01f, -1.02163859e-01f, -1.13748044e-01f, -6.56505898e-02f, -6.96681291e-02f, -1.36299819e-01f,
  -3.89997922e-02f, -6.29626215e-02f, -9.79813859e-02f, -6.66710585e-02f, -1.48154289e-01f, -6.58509806e-02f, -2.39628181e-02f, -5.92047423e-02f, -7.26249963e-02f, -5.45603521e-02f,
  1.48367807e-02f, 3.68279661e-03f, 7.34257847e-02f, 5.14423754e-03f, 1.16617214e-02f, 8.02324712e-03f, 3.06885447e-02f, -1.23486053e-02f, 4.40332331e-02f, -3.46183851e-02f,
  3.87271158e-02f, 6.87552318e-02f, -4.35528979e-02f, 5.76553307e-02f, -1.92083679e-02f, -7.23827258e-03f, 4.68799584e-02f, 1.29811866e-02f, 9.77597479e-03f, -3.30490544e-02f,
  1.81243028e-02f, -6.44627772e-03f, -3.12745534e-02f, -1.36828031e-02f, 6.07473217e-02f, -1.29720103e-03f, 6.43926188e-02f, 8.99102464e-02f, -5.01241833e-02f, 6.98410049e-02f,
  4.87127192e-02f, -5.35415970e-02f, -1.62789240e-01f, -8.45900699e-02f, -8.94444212e-02f, -7.22057186e-03f, 9.02958866e-03f, -6.59398139e-02f, 6.89329021e-03f, -2.40666084e-02f,
  -6.66742632e-03f, -1.23584054e-01f, -1.20552495e-01f, -8.77653286e-02f, -1.15977086e-01f, -1.36167422e-01f, -6.97780773e-02f, -6.66167662e-02f, -3.10044847e-02f, -6.26034886e-02f,
  -1.28040418e-01f, -1.73161745e-01f, -1.39113247e-01f, -1.17485501e-01f, -1.15732953e-01f, -8.95431861e-02f, -1.80849716e-01f, -1.66831002e-01f, -1.67549118e-01f, -1.90522105e-01f,
  1.85391158e-01f, -9.74669773e-03f, -1.64752267e-02f, -1.75197035e-01f, -1.53371692e-01f, -3.01578436e-02f, 1.08757019e-01f, -7.16915075e-03f, -3.97496149e-02f, -3.30306329e-02f,
  -1.67874709e-01f, -2.13740200e-01f, -7.49471486e-02f, -3.25253420e-02f, 3.94183435e-02f, 6.88957842e-03f, -4.04121056e-02f, -8.34248960e-02f, -1.11065330e-02f, -1.49640078e-02f,
  -5.85320070e-02f, -7.57562518e-02f, -7.73488805e-02f, -1.49947181e-02f, -2.26998970e-01f, -2.13175297e-01f, -2.21849501e-01f, -1.10600501e-01f, 8.99446104e-03f, -7.25855231e-02f,
  -1.59307629e-01f, 2.46284574e-01f, 4.26278710e-02f, 1.21802965e-03f, -1.06051221e-01f, -7.08584040e-02f, 7.84667805e-02f, -7.80747607e-02f, -1.20479524e-01f, -8.09122995e-02f,
  -7.32173100e-02f, -9.08037946e-02f, -8.90584514e-02f, -4.58932519e-02f, 2.56203096e-02f, 2.28585154e-02f, 2.40022019e-02f, 7.99929798e-02f, 7.32973916e-03f, 5.40560521e-02f,
  -2.68019680e-02f, 3.05071287e-03f, 3.46253514e-02f, -8.56618807e-02f, 1.20474368e-01f, -1.96207911e-02f, 7.18230531e-02f, 4.39867564e-02f, 1.00945234e-01f, 4.59275581e-03f,
  1.14666469e-01f, -1.26716644e-01f, -2.82179774e-03f, -5.60845770e-02f, -4.29807156e-02f, 3.35932225e-02f, 1.78977661e-02f, -1.14427255e-02f, -8.43796954e-02f, -1.10050194e-01f,
  3.32797319e-02f, 2.94820648e-02f, -4.35214266e-02f, 5.30181341e-02f, -1.24868467e-01f, 1.81613527e-02f, 9.45640542e-03f, -3.79699171e-02f, 3.61485332e-02f, 3.22249271e-02f,
  1.99494250e-02f, -3.94182950e-02f, -5.97357191e-02f, 5.20213461e-03f, 6.15835600e-02f, -4.12989408e-02f, -8.25378820e-02f, -1.17240869e-01f, -7.81522021e-02f, 4.24803561e-03f,
  -2.98925102e-01f, 6.10098988e-03f, -8.50612819e-02f, 3.37732844e-02f, -6.81434497e-02f, -3.12768407e-02f, -1.44307882e-01f, -4.84287329e-02f, -1.00974545e-01f, -3.30844149e-02f,
  7.36447377e-03f, -8.58331379e-03f, -5.98461293e-02f, -2.70351712e-02f, -1.24383315e-01f, -3.57455947e-02f, -1.23895958e-01f, -3.76762077e-02f, -8.74646530e-02f, -4.09870036e-02f,
  -1.08669586e-01f, -4.80790213e-02f, -1.27721280e-01f, -1.36995211e-01f, -7.40937218e-02f, -8.08426961e-02f, -3.45126167e-02f, -3.01138051e-02f, -4.12441976e-02f, -1.39833376e-01f,
  2.80282497e-01f, 1.61498532e-01f, -2.84910232e-01f, 2.20501021e-01f, -5.09245023e-02f, -9.35450047e-02f, -5.59172891e-02f, 4.38762680e-02f, 1.41618580e-01f, 3.21703292e-02f,
  1.62351251e-01f, 2.19634414e-01f, 1.24459565e-01f, 1.97905768e-03f, -1.84401795e-01f, -1.14785418e-01f, -1.89773425e-01f, -2.39958718e-01f, -2.43754312e-01f, -1.40376046e-01f,
  1.20248646e-01f, 2.64564948e-03f, 1.07761368e-01f, 1.11663930e-01f, 1.99088842e-01f, 9.20754224e-02f, 1.52664915e-01f, 1.15959927e-01f, 3.94086242e-02f, 1.50777355e-01f,
  -1.66475594e-01f, 2.71783829e-01f, -5.10350391e-02f, 1.84007406e-01f, 8.02615136e-02f, 1.70418337e-01f, 6.68534935e-02f, 2.41149422e-02f, 1.78412855e-01f, 6.76953346e-02f,
  8.43633562e-02f, 5.98467290e-02f, 1.60177454e-01f, 1.29222915e-01f, 3.64127271e-02f, 5.06216064e-02f, 1.20200939e-01f, 6.60585687e-02f, 4.23522554e-02f, 1.22245140e-01f,
  1.70940027e-01f, 4.83070128e-03f, -4.94037494e-02f, 1.08830914e-01f, 1.31250530e-01f, 7.34711811e-02f, 1.15490973e-01f, 1.88740417e-01f, 1.45014107e-01f, 7.35371038e-02f,
  7.39826411e-02f, 6.13434426e-02f, -8.95834789e-02f, -1.15983682e-02f, -7.05240890e-02f, -2.40717176e-02f, -3.15225124e-02f, 2.65725015e-04f, 1.31043792e-02f, -5.24393655e-02f,
  -4.33653630e-02f, -8.75385478e-02f, -5.82400709e-02f, -8.17716941e-02f, -6.26891032e-02f, -1.24856770e-01f, -8.90511945e-02f, -9.74539444e-02f, -8.48068222e-02f, -6.93359077e-02f,
  -1.15418665e-01f, -9.59627107e-02f, 7.24510895e-03f, -1.21760547e-01f, -1.13157153e-01f, -8.21542740e-02f, -8.19524452e-02f, 4.43216749e-02f, -2.54016686e-02f, -1.99569645e-03f,
  6.17635474e-02f, -8.62289779e-03f, 7.83875808e-02f, 1.01397447e-01f, 1.18806183e-01f, 7.67576098e-02f, 9.87281874e-02f, 6.07219152e-02f, 1.43864200e-01f, 1.69707444e-02f,
  1.00831628e-01f, 1.72214434e-01f, 9.24539641e-02f, 1.23666070e-01f, 9.07890275e-02f, 1.59389358e-02f, 1.15437128e-01f, 7.02358857e-02f, 3.71776596e-02f, 1.79338679e-01f,
  8.05958733e-02f, -6.08615987e-02f, -6.93050548e-02f, -5.33393696e-02f, 2.65023038e-02f, 3.29203792e-02f, 1.09123569e-02f, 1.05784312e-01f, 3.34887430e-02f, 5.97838722e-02f,
  9.72695500e-02f, 1.82841092e-01f, -3.25268328e-01f, 1.01223737e-01f, 1.25053763e-01f, 9.81358588e-02f, 1.65607959e-01f, 1.51876673e-01f, 5.42790107e-02f, 4.66263108e-02f,
  7.97876790e-02f, -1.47440180e-01f, -1.57234401e-01f, -1.87347308e-01f, -2.35276237e-01f, -2.33144984e-02f, -7.97184929e-02f, -2.87334710e-01f, -2.64705092e-01f, 8.56604602e-04f,
  2.27867346e-02f, -2.09005829e-02f, -3.11097987e-02f, -6.82182163e-02f, -5.22155501e-02f, -5.43846600e-02f, -6.29024133e-02f, 2.86686234e-02f, -4.55330908e-02f, -1.96224183e-01f,
  -1.16441540e-01f, 1.48014545e-01f, -8.32047462e-02f, 1.61929596e-02f, -8.63833949e-02f, -1.27060354e-01f, -6.73556849e-02f, -3.95788178e-02f, -8.04932937e-02f, -3.37009132e-02f,
  6.43293411e-02f, -1.67247187e-02f, -7.68261105e-02f, -5.46499267e-02f, 9.69806835e-02f, -2.98047792e-02f, 1.80832706e-02f, -6.66172132e-02f, -1.93517860e-02f, 4.96212244e-02f,
  -3.87575217e-02f, 9.17613804e-02f, -1.59607455e-02f, -5.46808727e-02f, -3.94920669e-02f, -1.17386624e-01f, -1.05648361e-01f, 3.03608403e-02f, -9.68718007e-02f, -4.24793921e-02f,
  -1.28746303e-02f, -5.28491177e-02f, -6.67580962e-03f, -8.64351448e-03f, 8.94441232e-02f, -4.71597351e-02f, 6.76560327e-02f, -2.55363565e-02f, 9.14175585e-02f, 2.61686966e-02f,
  3.58609408e-02f, 9.86246839e-02f, 2.46402360e-02f, 5.48465289e-02f, 5.56820408e-02f, 1.11906724e-02f, -1.35270609e-02f, 8.18526447e-02f, -3.60966921e-02f, 1.61424465e-02f,
  2.69097071e-02f, 3.22405659e-02f, 4.04713303e-02f, 3.77932265e-02f, 1.49612324e-02f, 1.88319087e-02f, 5.08384593e-02f, 5.60263768e-02f, 8.77089351e-02f, 6.86664283e-02f,
  6.43926933e-02f, -4.75525111e-02f, 1.39597664e-02f, -4.28235009e-02f, 4.08630595e-02f, -9.19928309e-03f, -2.53880359e-02f, -1.44579604e-01f, 9.53305792e-03f, -1.04621567e-01f,
  -3.62315997e-02f, -8.10924917e-02f, 2.74612638e-03f, -8.23653415e-02f, -3.98605689e-02f, -1.28605291e-02f, -2.93090325e-02f, -1.66409761e-01f, -8.91888589e-02f, -6.41237572e-02f,
  -6.55569183e-03f, 3.88223790e-02f, -1.76734626e-01f, -1.51193133e-02f, -2.82606930e-02f, -8.18210542e-02f, -4.85683084e-02f, -1.71388164e-02f, -8.68106931e-02f, 5.49929729e-03f,
  3.90959159e-02f, 1.58515379e-01f, -7.81965479e-02f, 2.11630493e-01f, 2.16979548e-01f, 4.66734469e-02f, 2.27872789e-01f, 1.30539522e-01f, 5.96199045e-03f, 2.30074435e-01f,
  4.83909622e-02f, -1.66902497e-01f, -5.63805997e-02f, -1.65714383e-01f, -1.75377086e-01f, 2.02897027e-01f, 2.22777858e-01f, -1.08091027e-01f, -2.13344589e-01f, -6.50451928e-02f,
  7.56271034e-02f, -1.25949671e-02f, -6.84951171e-02f, 7.81781599e-03f, 1.67051017e-01f, 6.51084036e-02f, 8.32730830e-02f, 6.41516075e-02f, 5.84645532e-02f, 1.74571574e-01f,
  1.95329338e-02f, 2.79747285e-02f, 1.11003462e-02f, 1.41772078e-02f, 1.97415445e-02f, -2.61035357e-02f, 9.34577286e-02f, -1.09502831e-02f, 3.28701474e-02f, 5.81541620e-02f,
  7.23131672e-02f, 7.42890779e-03f, 6.58827499e-02f, -2.67435685e-02f, 2.23210175e-02f, 2.34711152e-02f, -3.85493822e-02f, -9.03187394e-02f, -3.71685997e-03f, 4.28912453e-02f,
  6.44895360e-02f, 1.37881145e-01f, -1.52509967e-02f, -5.46428524e-02f, 1.23659419e-02f, -4.12425250e-02f, -1.65889058e-02f, -4.67383973e-02f, 3.27163152e-02f, 3.71838883e-02f,
  8.10960382e-02f, -7.02591389e-02f, -1.12822494e-02f, 2.39818972e-02f, 1.54278405e-05f, -5.76676168e-02f, -1.89097710e-02f, -3.33852023e-02f, -3.57647464e-02f, 2.20485497e-02f,
  -5.31252287e-02f, -4.31514047e-02f, -4.49681692e-02f, -2.63298806e-02f, -1.70886535e-02f, 6.90455809e-02f, 1.50103848e-02f, 2.14448273e-02f, 2.27143839e-02f, 3.80501561e-02f,
  -7.50562623e-02f, -4.23189811e-02f, 7.45778307e-02f, -8.09117779e-02f, -3.72746252e-02f, 5.07232621e-02f, 5.39672375e-02f, -8.78868327e-02f, 9.30593684e-02f, 5.33544719e-02f,
  1.32649109e-01f, -1.37060225e-01f, 8.08693171e-02f, -4.49281782e-02f, 8.60561710e-03f, -2.94649955e-02f, 6.59751818e-02f, -5.90507612e-02f, -4.03547063e-02f, 2.50022002e-02f,
  -1.03401607e-02f, 1.04956999e-02f, 3.35550718e-02f, 4.20720205e-02f, 4.93003614e-02f, -1.56652201e-02f, 6.44303560e-02f, 7.68344477e-02f, -6.63270280e-02f, 1.73914991e-02f,
  3.79870161e-02f, 2.77562104e-02f, 1.19551100e-01f, 9.95668024e-02f, -1.61714829e-03f, 3.05759273e-02f, 8.92071724e-02f, 8.66843155e-04f, 8.37403312e-02f, 1.86572358e-01f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.43326446e-01f, 3.56076300e-01f, 2.99490869e-01f, -2.39556972e-02f, 1.90737993e-01f, 2.45128870e-01f, 3.76124144e-01f, 5.45322802e-03f, -8.19396749e-02f, 6.99703693e-02f,
  6.98020682e-02f, -2.59189606e-01f, -2.20637858e-01f, -1.22877926e-01f, -9.01428834e-02f, 7.97860771e-02f, 1.48024529e-01f, -2.32880265e-01f, -4.25121427e-01f, -2.75889456e-01f,
  -2.62590468e-01f, -2.11569086e-01f, -1.14215359e-01f, -2.23516241e-01f, 2.35486832e-02f, -2.79182285e-01f, 1.81743860e-01f, 1.29190043e-01f, 6.35753572e-02f, -1.41135812e-01f,
  1.06349163e-01f, 3.22233260e-01f, -3.37125957e-01f, -2.42098838e-01f, 5.68141453e-02f, -7.57700279e-02f, 6.20451123e-02f, 4.61364053e-02f, 2.16519963e-02f, 3.31093334e-02f,
  1.26310870e-01f, 1.03228047e-01f, 1.58369288e-01f, -4.36551981e-02f, 1.13504469e-01f, 2.31460147e-02f, -1.31850066e-02f, 1.63394548e-02f, 3.90413031e-02f, 5.72997630e-02f,
  7.45618641e-02f, 5.95231466e-02f, 9.48856100e-02f, 9.61846113e-02f, 1.18718423e-01f, -8.20085183e-02f, 1.36583358e-01f, -1.29586741e-01f, 1.29632959e-02f, -1.98281571e-01f,
  -6.20050281e-02f, 1.88486315e-02f, -6.62546158e-02f, -2.06635240e-02f, -1.89592615e-02f, 3.54512371e-02f, -8.04289524e-03f, 8.98505673e-02f, -1.82504579e-02f, 5.42752072e-02f,
  4.54154983e-02f, 1.07839428e-01f, 1.28580779e-01f, 1.90732136e-01f, -9.21435580e-02f, 6.66507035e-02f, 8.84501338e-02f, -3.53040011e-03f, 8.27303603e-02f, 7.69400746e-02f,
  -5.04735857e-02f, 1.58344015e-01f, 1.58138422e-03f, 7.98663795e-02f, 1.32914543e-01f, 4.31348234e-02f, -5.54812897e-04f, 7.31298700e-02f, 4.64286879e-02f, 1.49360582e-01f,
  -1.45010218e-01f, 7.04170391e-02f, -3.98245007e-02f, -1.06138326e-01f, 1.61215350e-01f, 4.55936566e-02f, -1.64206198e-03f, -3.45779699e-03f, 1.28171429e-01f, -7.58092403e-02f,
  7.84359947e-02f, 3.86884958e-02f, 1.61066189e-01f, 4.66001332e-02f, -1.49072528e-01f, -7.60008320e-02f, -1.19889155e-01f, -8.54702592e-02f, -1.11009739e-01f, 6.76718950e-02f,
  3.40575017e-02f, -1.14157617e-01f, -1.08174361e-01f, -8.79534334e-02f, -4.85940874e-02f, -1.96873114e-01f, 2.31355429e-02f, -1.18120998e-01f, -1.31533608e-01f, -9.66915563e-02f,
  1.31470054e-01f, -1.96417332e-01f, -3.50784771e-02f, 2.30810106e-01f, 1.30901888e-01f, -3.41863222e-02f, -2.34585017e-01f, 1.49042252e-03f, 1.10031404e-02f, 5.95079735e-02f,
  1.04605213e-01f, 2.98653990e-01f, 2.52436489e-01f, 1.07383393e-01f, 9.02239978e-02f, -1.15768397e-02f, 5.24673760e-02f, -6.95329579e-03f, -2.49582175e-02f, -1.65036723e-01f,
  -3.05632036e-02f, -7.52564520e-02f, 1.78776011e-02f, -4.74870875e-02f, -1.38733044e-01f, 2.11558923e-01f, -1.39172241e-01f, -1.46777108e-01f, -6.18938450e-03f, 4.34124246e-02f,
  -1.45960480e-01f, -6.09630793e-02f, 1.00174844e-01f, 8.32803175e-03f, -2.97449646e-03f, -2.44405456e-02f, -3.03141773e-03f, -9.28944722e-02f, -9.04133692e-02f, -5.70956059e-02f,
  -1.20139629e-01f, -1.37026563e-01f, 9.25195813e-02f, -7.79363215e-02f, -7.60315359e-02f, -1.18296444e-01f, -2.80490462e-02f, -1.31742924e-01f, -2.76442245e-02f, -2.03162909e-01f,
  -4.10968475e-02f, -1.22297518e-01f, -1.29950598e-01f, -9.41400677e-02f, -1.63675532e-01f, 5.82149019e-03f, -1.09159112e-01f, -1.46010667e-01f, -1.51500598e-01f, -1.64450184e-01f,
  -1.71118483e-01f, -3.31708968e-01f, -1.62567034e-01f, 1.59505196e-02f, 1.14245139e-01f, -4.91639189e-02f, 6.96580335e-02f, -1.18112184e-01f, -8.76304284e-02f, -1.21469863e-01f,
  5.74989766e-02f, 6.60891086e-02f, -8.29810500e-02f, -3.72327194e-02f, -2.06124745e-02f, -1.16123356e-01f, -2.06423953e-01f, -9.26622823e-02f, -8.29918608e-02f, 4.45282497e-02f,
  9.21897441e-02f, -1.06813587e-01f, -1.60961911e-01f, -1.89513788e-01f, -2.81184912e-02f, -1.39721766e-01f, -8.57877135e-02f, -1.11127324e-01f, -1.94884330e-01f, -1.47428274e-01f,
  4.16261256e-02f, 3.49805176e-01f, 1.42897233e-01f, 9.15833041e-02f, -7.18082488e-02f, 2.22919043e-02f, 1.69858545e-01f, 1.72180057e-01f, 9.80889723e-02f, -1.74038615e-02f,
  -3.26077454e-02f, -5.85088283e-02f, 9.95813310e-02f, 5.71111254e-02f, -4.71892767e-02f, -3.48023511e-02f, 6.39988333e-02f, 1.35126531e-01f, 3.99373993e-02f, -1.73900947e-01f,
  -8.84500742e-02f, -5.10344617e-02f, 1.33265644e-01f, 1.08769216e-01f, -9.97247640e-03f, 1.86503738e-01f, 4.88506518e-02f, 2.64078155e-02f, 8.72368589e-02f, -1.29137903e-01f,
  -3.88576269e-01f, 9.53386351e-03f, 9.38832611e-02f, -1.40499830e-01f, -7.45642334e-02f, -2.18843028e-01f, -1.99303001e-01f, -1.82479203e-01f, -1.55723527e-01f, -5.15593104e-02f,
  2.22116429e-02f, 1.81734383e-01f, 1.94975436e-01f, 1.87616721e-01f, 5.00812829e-02f, 3.23673300e-02f, -2.16109473e-02f, 1.15855128e-01f, 7.08381683e-02f, 6.15442730e-02f,
  1.83720335e-01f, 2.42814869e-01f, 3.17347944e-02f, 3.42091285e-02f, 4.45160037e-03f, 2.03699201e-01f, 1.83853641e-01f, 1.57375988e-02f, 8.13132375e-02f, 6.73190737e-03f,
  3.23437005e-01f, -1.83431640e-01f, -2.34652516e-02f, -9.85913426e-02f, -1.38345197e-01f, -1.38145894e-01f, 2.40244884e-02f, -1.44217178e-01f, -6.05800785e-02f, -6.49241731e-02f,
  -7.87778497e-02f, -1.44136906e-01f, 1.62588172e-02f, 3.19092646e-02f, 7.09071606e-02f, 1.12126563e-02f, -2.75033116e-02f, -1.84345722e-01f, -6.79298118e-02f, -7.72370249e-02f,
  6.16665222e-02f, -1.23733029e-01f, -4.30546366e-02f, -9.69468057e-02f, -1.10556833e-01f, -5.79858348e-02f, 7.39466101e-02f, -1.28986195e-01f, -7.46167079e-02f, -1.44549897e-02f,
  -5.23679927e-02f, 9.26801488e-02f, -5.89554152e-03f, 2.50086710e-02f, 1.34119228e-01f, -2.92249024e-03f, 1.20059103e-01f, 3.54609564e-02f, 4.36260961e-02f, 1.42909586e-01f,
  4.29516882e-02f, 1.11067630e-01f, 1.98271666e-02f, -2.83168592e-02f, 1.27925500e-02f, -1.42012224e-01f, -6.31448999e-02f, 1.35253608e-01f, 2.60247458e-02f, -7.57624134e-02f,
  -4.58247773e-02f, -4.28296737e-02f, -4.54152077e-02f, -2.39040684e-02f, -9.77246910e-02f, -9.38923731e-02f, 3.67239527e-02f, 1.20399401e-01f, 4.68230471e-02f, -7.48357475e-02f,
  4.41614598e-01f, -1.38616800e-01f, 1.47207811e-01f, -7.85765424e-02f, 1.99087895e-02f, -6.82963803e-02f, 7.41489828e-02f, -1.15952477e-01f, -8.54555741e-02f, -3.31313610e-02f,
  -5.11730369e-03f, -4.71366942e-03f, 1.04031891e-01f, -3.84790674e-02f, 4.01387550e-02f, 6.16686158e-02f, 8.39017481e-02f, 9.61900949e-02f, -7.92502053e-03f, -8.56719911e-02f,
  9.17444099e-03f, 1.54478545e-03f, 8.99806172e-02f, 1.18835188e-01f, -5.55639751e-02f, 1.36942357e-01f, 1.61015064e-01f, 3.44212651e-02f, 1.17084399e-01f, 8.88731703e-02f,
  2.13518173e-01f, -4.48933601e-01f, -3.55181664e-01f, -1.81101620e-01f, -3.23604465e-01f, -1.70697019e-01f, -1.50374547e-01f, -1.79121882e-01f, -8.74203295e-02f, -2.96432942e-01f,
  6.72105886e-03f, 1.82026416e-01f, 1.10820360e-01f, 4.35686596e-02f, 1.35221481e-01f, -2.81323224e-01f, -3.37075949e-01f, 5.37213124e-02f, 2.30921417e-01f, 5.85888326e-02f,
  2.65329741e-02f, -5.86904846e-02f, 9.59564894e-02f, -2.40445975e-02f, -3.05955023e-01f, -8.05472657e-02f, -2.35957667e-01f, -2.15304300e-01f, -1.88218534e-01f, -2.75130928e-01f,
  -1.45893544e-02f, 1.51985750e-01f, 1.29740298e-01f, 1.76169217e-01f, -4.80422005e-02f, 5.46156168e-02f, 6.34804592e-02f, -1.30181625e-01f, -4.17220928e-02f, 1.30500644e-03f,
  2.31411587e-02f, -9.96804051e-03f, 7.95993507e-02f, -3.21178585e-02f, 2.96225995e-02f, 1.49614736e-01f, 5.73385991e-02f, 9.96605530e-02f, -8.60166401e-02f, -1.71339363e-02f,
  -5.52453138e-02f, 3.14339772e-02f, 9.60672423e-02f, 1.89550206e-01f, 2.14594677e-01f, 2.13312760e-01f, 4.95627560e-02f, 1.80358931e-01f, 1.97747186e-01f, -5.83813973e-02f,
  -1.46509521e-02f, -3.64510380e-02f, 1.06915191e-01f, 9.22791213e-02f, 8.74953717e-02f, -7.48704933e-03f, -2.49815322e-02f, -1.10254949e-02f, 8.40000063e-02f, 9.97484103e-02f,
  -6.09368309e-02f, -4.23405645e-03f, 4.28703018e-02f, 4.54431809e-02f, 2.68147886e-02f, -1.10590458e-01f, 3.38932164e-02f, -4.69401367e-02f, 7.62010813e-02f, 4.82808501e-02f,
  1.04175389e-01f, 3.38014923e-02f, -4.67572324e-02f, 9.12049785e-02f, -6.99189082e-02f, 4.25628424e-02f, 6.54936358e-02f, 2.27905754e-02f, 6.78389147e-02f, -9.90368575e-02f,
  -3.28654945e-02f, 2.88275450e-01f, 9.93787218e-03f, 1.09369069e-01f, -1.73548702e-02f, -1.38378754e-01f, 2.02140417e-02f, -2.80435849e-02f, -1.58194080e-01f, -9.24321339e-02f,
  1.78514223e-03f, 1.33194953e-01f, 4.78517339e-02f, -2.83568911e-02f, 9.20068249e-02f, 2.79119741e-02f, 1.50129637e-02f, -8.18277597e-02f, 5.74627072e-02f, -9.27152857e-02f,
  -7.36652017e-02f, -5.51562570e-03f, 1.84085146e-01f, 8.00118130e-03f, 1.32847326e-02f, 1.90422252e-01f, 6.16949387e-02f, 1.05621286e-01f, 3.78006287e-02f, -6.11795075e-02f,
  3.80432457e-02f, 3.65110010e-01f, 1.65296614e-01f, -7.74850184e-03f, 2.15973690e-01f, 1.16874121e-01f, 3.87526184e-01f, 2.04823971e-01f, -2.04413924e-02f, 7.86194876e-02f,
  3.68973427e-02f, -3.37194741e-01f, -2.23301128e-01f, -1.68348834e-01f, -4.47404347e-02f, 2.56029487e-01f, 1.74147949e-01f, -8.93483534e-02f, -2.96401948e-01f, -2.14413017e-01f,
  -8.99528787e-02f, 1.19820414e-02f, -1.03795849e-01f, -1.16108274e-02f, 5.19986451e-02f, -1.51346564e-01f, 1.73674732e-01f, 2.27584392e-01f, 1.59108922e-01f, 6.22074828e-02f,
  -3.05732280e-01f, 3.25152844e-01f, -3.33723873e-01f, -1.60921782e-01f, -4.09164391e-02f, -1.57603458e-01f, -1.97079942e-01f, -1.01573937e-01f, -1.07789546e-01f, -2.21687499e-02f,
  -1.46198973e-01f, -1.61864132e-01f, -9.05680284e-02f, -2.25445941e-01f, -1.54521048e-01f, -3.55299897e-02f, -3.63693126e-02f, -1.14083216e-01f, -2.40859911e-01f, -1.96325913e-01f,
  -1.15986004e-01f, 1.15859471e-01f, 1.47573411e-01f, 2.31895894e-01f, 4.67961393e-02f, -2.76200026e-01f, 2.05587804e-01f, 1.62270516e-02f, 8.04147273e-02f, 1.10878013e-01f,
  2.62869205e-02f, 2.08264813e-02f, 1.73627585e-01f, 1.41214609e-01f, -5.32187968e-02f, -1.42672490e-02f, 3.10224667e-02f, -8.76777023e-02f, -5.73043041e-02f, 5.71080223e-02f,
  -8.62281919e-02f, -5.08106053e-02f, -4.32896316e-02f, 3.28758210e-02f, -1.36475369e-01f, 6.76998943e-02f, -2.56835744e-02f, 4.79785725e-02f, 1.58667862e-02f, 5.90317883e-02f,
  2.37907778e-04f, -5.26181385e-02f, -2.23882007e-03f, 2.65966775e-03f, 2.64231637e-02f, 4.28804336e-03f, -1.74205959e-01f, -1.37577383e-02f, 3.77092808e-02f, 6.09821379e-02f,
  -2.56204635e-01f, -3.64034623e-02f, -2.46471748e-01f, -6.29617125e-02f, 6.76604956e-02f, -1.36037633e-01f, 7.29167759e-02f, 1.05873592e-01f, -8.13819394e-02f, -2.78635304e-02f,
  -1.14841044e-01f, -6.04065284e-02f, -5.82246520e-02f, -1.39389336e-01f, -1.62025481e-01f, -1.13081085e-02f, -6.92380741e-02f, -2.59119198e-02f, -8.42053667e-02f, -1.59949422e-01f,
  1.52282426e-02f, 2.20793456e-01f, 4.58016731e-02f, 8.67624357e-02f, 2.62980945e-02f, -2.20644236e-01f, -2.74547115e-02f, -5.37738577e-02f, 9.39350426e-02f, 2.19468310e-01f,
  -3.48578125e-01f, 4.42812413e-01f, 2.21404046e-01f, -4.07205224e-01f, 1.80931494e-01f, 3.88444394e-01f, 5.64650834e-01f, 6.30380064e-02f, -1.48985431e-01f, 1.40341446e-01f,
  1.66968271e-01f, -2.26010993e-01f, -9.03498456e-02f, -8.41197520e-02f, 4.65288125e-02f, 3.76876473e-01f, 1.23821415e-01f, -1.60291150e-01f, -2.53479838e-01f, -2.10845936e-02f,
  -6.06170595e-02f, -9.01925117e-02f, -2.38782808e-01f, -1.92624211e-01f, -1.51284412e-01f, -2.21293047e-01f, 4.33456823e-02f, 1.03172496e-01f, 2.38199264e-01f, -2.20837787e-01f,
  -9.73169059e-02f, 1.27158295e-02f, -4.58537630e-04f, -1.61004066e-01f, -1.96964759e-03f, -1.13545358e-01f, 5.41638210e-03f, -1.83022320e-01f, -6.33772165e-02f, -1.22551873e-01f,
  -8.41987208e-02f, 3.09739113e-02f, -1.65476042e-04f, 4.86094877e-02f, 7.73890987e-02f, -4.84931171e-02f, -7.44439512e-02f, -1.03423223e-01f, 4.86802980e-02f, 1.39404610e-01f,
  1.22534759e-01f, 3.00467778e-02f, 1.28544375e-01f, 6.81492761e-02f, -8.80105980e-03f, -6.28025830e-02f, 1.82456478e-01f, -4.00517806e-02f, 2.84151314e-03f, -1.78444102e-01f,
  7.93301594e-03f, -3.83958337e-03f, 6.48037270e-02f, 1.61879119e-02f, 9.51852649e-02f, 2.10538507e-02f, -5.17491922e-02f, 3.08560263e-02f, 5.18400483e-02f, 4.81205247e-02f,
  7.55217820e-02f, 4.00364920e-02f, -4.04664828e-03f, 3.45966592e-02f, -8.21165442e-02f, 5.32124937e-02f, 1.10714316e-01f, 1.06297927e-02f, 9.89141464e-02f, 1.24589175e-01f,
  1.17362197e-02f, 9.23156962e-02f, -9.73176211e-02f, -5.61430342e-02f, 8.21033791e-02f, -4.88432348e-02f, 1.05679771e-02f, -7.43136136e-03f, -7.09466860e-02f, 8.34019929e-02f,
  -7.23778233e-02f, 3.58203769e-01f, -1.72221586e-01f, 5.38210385e-02f, 4.84921932e-02f, 3.38921472e-02f, -5.58270477e-02f, 2.98763029e-02f, -3.35209817e-02f, -6.94126859e-02f,
  1.20509557e-01f, -1.62690192e-01f, 1.82770625e-01f, 2.65974570e-02f, 1.31185539e-02f, -5.83734363e-02f, 1.18903607e-01f, -4.05934639e-03f, 7.15815425e-02f, 3.33896861e-03f,
  -6.01508506e-02f, -1.74844880e-02f, -1.87140793e-01f, -1.27697855e-01f, -1.81203142e-01f, -2.12361246e-01f, -3.77412997e-02f, -4.84318882e-02f, 1.30940974e-01f, -8.79301801e-02f,
  -5.77566251e-02f, -4.65012163e-01f, -3.74193698e-01f, -3.20103616e-02f, -2.08516773e-02f, 1.79249331e-01f, 1.32103488e-01f, 1.62336648e-01f, 9.90056843e-02f, -2.20776945e-01f,
  -1.86478406e-01f, 1.25696659e-02f, -9.35868099e-02f, -4.14023288e-02f, 2.82039549e-02f, -2.80074924e-01f, -3.28783661e-01f, -3.58537771e-02f, 4.04772460e-01f, 5.18505633e-01f,
  2.88885176e-01f, 1.66860461e-01f, 5.35147525e-02f, 6.82999864e-02f, -9.72432084e-03f, 7.62355402e-02f, -2.15948701e-01f, -6.46848008e-02f, -7.06387311e-02f, -3.15502733e-01f,
  9.29171592e-02f, -1.26659438e-01f, -2.91168429e-02f, -8.48989412e-02f, -3.02696917e-02f, -1.04462422e-01f, 1.31280441e-02f, -8.12369660e-02f, -3.27009261e-02f, -6.20994642e-02f,
  -1.21198751e-01f, -4.38216142e-02f, 5.04895821e-02f, -2.80416124e-02f, 1.97255909e-01f, 7.52538517e-02f, -1.61282986e-03f, -1.37282044e-01f, -4.28437144e-02f, 9.65522788e-03f,
  -1.02952152e-01f, -1.18835442e-01f, -5.25179580e-02f, -6.53785542e-02f, 6.56182393e-02f, -3.49166356e-02f, 3.13181709e-03f, -1.75141927e-03f, -2.49070954e-02f, -1.84682637e-01f,
  8.39224234e-02f, -2.38666981e-02f, 5.03752716e-02f, 1.30929798e-01f, 2.61626486e-02f, -1.11657763e-02f, -7.71793425e-02f, 3.42177562e-02f, 1.07537016e-01f, 1.04342498e-01f,
  3.10587753e-02f, -3.96366827e-02f, 4.83823046e-02f, -5.13992980e-02f, -8.88416916e-02f, -5.52790686e-02f, -1.49057079e-02f, -7.00817853e-02f, 5.95545061e-02f, 2.17920053e-03f,
  5.08577265e-02f, 5.05749881e-02f, 5.49189467e-03f, 7.46788234e-02f, -1.00139052e-01f, -1.19272903e-01f, -1.83980186e-02f, 3.61008346e-02f, 1.04094245e-01f, -2.95927115e-02f,
  2.30052754e-01f, -3.55091512e-01f, -7.16130733e-02f, -2.32527684e-02f, -9.43594798e-02f, -7.22948536e-02f, -1.25813767e-01f, -3.69476806e-03f, -5.62154390e-02f, 1.36198297e-01f,
  1.29967123e-01f, 7.87586570e-02f, -4.84558120e-02f, 1.49483951e-02f, 2.71232367e-01f, 4.77831326e-02f, -1.39891520e-01f, -9.28389356e-02f, 4.11796197e-02f, 1.59516051e-01f,
  -1.64940238e-01f, -5.33140451e-02f, 1.20791838e-01f, -3.92675027e-02f, 2.55837645e-02f, 1.49990946e-01f, 1.23624608e-01f, 1.26360431e-01f, 1.07198551e-01f, 1.03278846e-01f,
  7.07871979e-04f, -3.77613276e-01f, 9.29096639e-02f, 1.59085784e-02f, 8.80330205e-02f, 3.02912563e-01f, 1.92727819e-01f, 1.28856325e-03f, -6.43269122e-02f, -2.56045721e-02f,
  -1.15568474e-01f, 8.01509842e-02f, 1.17194586e-01f, 1.52675398e-02f, 7.70589933e-02f, 1.47646308e-01f, 8.25080872e-02f, 2.59319365e-01f, 4.14316326e-01f, 7.38131180e-02f,
  -3.00021879e-02f, -1.41514838e-01f, -1.34113044e-01f, -2.99441516e-02f, -1.87364727e-01f, 1.23355100e-02f, -1.45977773e-02f, -6.60883710e-02f, -1.31749570e-01f, -1.48727745e-01f,
  1.45935133e-01f, -1.15548566e-01f, 3.16627622e-02f, -1.74580902e-01f, -1.79480776e-01f, -3.84802595e-02f, -3.97462025e-03f, -1.75810143e-01f, -1.12449735e-01f, -1.32195711e-01f,
  1.40729100e-02f, -1.28828093e-01f, -1.16811348e-02f, -8.98985192e-02f, -1.51404724e-01f, -9.53811407e-02f, -4.48823869e-02f, -3.90512384e-02f, -1.93422958e-02f, -6.62659705e-02f,
  -7.65947923e-02f, 1.30982660e-02f, 1.00722909e-01f, 1.04796097e-01f, -8.31592306e-02f, 2.35838313e-02f, -1.49506405e-01f, -1.30908802e-01f, -2.27625165e-02f, -1.65332660e-01f,
  -1.58371851e-02f, 2.52079144e-02f, 7.22137094e-02f, 7.12382549e-04f, 1.50887489e-01f, 4.04210091e-02f, 1.57284439e-01f, 5.83651885e-02f, 1.90644953e-02f, -1.55415945e-03f,
  -5.33141382e-02f, 7.01588988e-02f, 1.41690001e-01f, -2.35761851e-02f, -6.13152869e-02f, 3.67044769e-02f, 1.43657520e-01f, -7.17051253e-02f, -8.66103619e-02f, -5.42514436e-02f,
  1.57034434e-02f, -5.22959530e-02f, -7.99268633e-02f, 3.43747362e-02f, -5.12900241e-02f, 4.96759564e-02f, -1.14331944e-02f, -1.23187508e-02f, 5.15620112e-02f, -2.34626047e-02f,
  1.25602767e-01f, 1.61096483e-01f, 1.52764335e-01f, -3.13467160e-02f, 1.79039147e-02f, -1.25810742e-01f, 2.55377833e-02f, -6.27223775e-02f, 5.63729331e-02f, 5.63969798e-02f,
  -1.20203691e-02f, -1.97272673e-02f, -4.89409715e-02f, 2.05370318e-02f, 1.49910748e-01f, 9.38228145e-02f, -6.41282722e-02f, 1.70519918e-01f, 2.20387280e-02f, -1.28270775e-01f,
  -1.53366223e-01f, 1.19352683e-01f, 2.13115796e-01f, 2.44406566e-01f, 1.48594886e-01f, 3.06337684e-01f, 1.67139083e-01f, 1.66410916e-02f, 2.15788379e-01f, 5.49130142e-02f,
  6.63034320e-01f, -3.86043906e-01f, 2.15074822e-01f, 2.97339857e-01f, 4.50400710e-02f, 5.40520065e-02f, -1.29940063e-01f, -4.04216163e-02f, 1.22244716e-01f, -4.70677093e-02f,
  -8.63050669e-02f, -8.51029977e-02f, 2.00303663e-02f, 2.28209198e-02f, -4.75888737e-02f, 1.99963506e-02f, 1.12726353e-01f, 2.49027193e-01f, 2.58011729e-01f, 5.81840836e-02f,
  -1.70941144e-01f, -1.49949240e-02f, 2.51462013e-01f, 1.17999695e-01f, -1.59971774e-01f, 6.14363380e-05f, -7.22951144e-02f, -5.57131879e-02f, -1.06891908e-01f, -6.29679784e-02f,
  -1.38416544e-01f, 7.57004600e-03f, 9.13981572e-02f, -1.12010106e-01f, -1.95188746e-01f, -9.13825035e-02f, -5.06480746e-02f, -1.28970489e-01f, -4.95564081e-02f, -1.56434886e-02f,
  -4.21143621e-02f, -2.93419347e-03f, -7.82856438e-03f, -1.31980836e-01f, -1.35494918e-01f, -1.01406403e-01f, -5.73574267e-02f, 5.33432662e-02f, -5.14362082e-02f, -4.20462079e-02f,
  -8.70389938e-02f, -1.29766064e-02f, 1.13374226e-01f, 3.24594229e-02f, -5.47812171e-02f, 2.10514013e-02f, -1.54512808e-01f, -7.85623193e-02f, 5.08296601e-02f, 6.60015568e-02f,
  1.03556804e-01f, 5.87381842e-03f, 1.47158327e-02f, 8.98697302e-02f, 1.20470803e-02f, 9.39818472e-02f, 5.94444536e-02f, -5.34547828e-02f, 8.15033689e-02f, 7.10151568e-02f,
  1.11115817e-02f, 1.41780615e-01f, 6.18112274e-02f, 3.37020382e-02f, 8.31840932e-02f, 1.01790294e-01f, -7.01903701e-02f, -1.91901959e-02f, -5.45308851e-02f, 8.68543014e-02f,
  2.52988748e-02f, -4.16866988e-02f, -6.95234910e-02f, -1.11039929e-01f, -6.95059747e-02f, 3.93543430e-02f, 5.35469428e-02f, -4.19241898e-02f, -2.60720984e-03f, 1.75040271e-02f,
  -3.40807498e-01f, 1.19011261e-01f, 6.24196744e-03f, -4.84893881e-02f, -7.80971572e-02f, -8.74370486e-02f, 4.44268622e-02f, -1.38972685e-01f, -1.33021295e-01f, -3.74249704e-02f,
  -3.98514383e-02f, -3.32218595e-02f, -4.72455435e-02f, -5.42806946e-02f, 5.43537363e-02f, 8.65478143e-02f, -1.46216452e-01f, -7.75949843e-03f, -9.20553971e-03f, -1.13577254e-01f,
  -6.06652573e-02f, 1.42921522e-01f, 1.07966498e-01f, 1.40850022e-01f, -4.46564890e-02f, 1.19722053e-01f, 4.80893999e-02f, 8.44579265e-02f, 3.14872675e-02f, 2.57540941e-02f,
  1.28376365e-01f, 1.46745564e-02f, 2.39378452e-01f, 7.28126243e-02f, -1.49907395e-01f, -2.30903491e-01f, -3.70176762e-01f, -2.85252213e-01f, -4.56222892e-03f, 9.90753695e-02f,
  -8.22658278e-03f, -4.77103144e-02f, 7.27616325e-02f, 1.64360204e-03f, -2.63941050e-01f, -3.74764614e-02f, -5.57591505e-02f, -1.86885782e-02f, -1.53528661e-01f, -2.99203366e-01f,
  -4.42765392e-02f, -7.85773620e-03f, 1.33575261e-01f, -7.49517530e-02f, 2.59117544e-01f, 1.42586872e-01f, 2.23285466e-01f, 2.54185647e-01f, 1.96237922e-01f, 3.80869865e-01f,
  3.89784873e-01f, 7.19488934e-02f, -9.16795209e-02f, 4.01490703e-02f, 7.92792737e-02f, -3.26376818e-02f, -1.02669597e-01f, 1.13015085e-01f, -8.77508745e-02f, -6.01986004e-03f,
  7.76613578e-02f, 1.12087728e-04f, -2.30012164e-02f, -1.56272426e-01f, -1.29784346e-01f, -2.68144101e-01f, -2.56210845e-02f, -1.79966778e-01f, -5.11400439e-02f, -5.38276993e-02f,
  -1.04464546e-01f, -2.24145111e-02f, -6.14319183e-02f, -2.19982430e-01f, -2.75047384e-02f, 2.85871383e-02f, 1.90999079e-02f, 4.78769541e-02f, -1.44524023e-01f, 2.57453173e-01f,
  2.66089197e-02f, -7.49024702e-03f, 3.55196297e-02f, 1.69259612e-04f, -1.11515611e-01f, 3.65104489e-02f, 2.44210195e-02f, -6.33448735e-02f, 1.64544675e-02f, -6.59355074e-02f,
  -3.84911932e-02f, -4.27404419e-03f, 2.29165014e-02f, -7.24434480e-02f, 4.58670445e-02f, 9.15946215e-02f, -4.74546477e-02f, -4.59524896e-03f, 2.97688730e-02f, 1.13738365e-01f,
  -4.61233594e-03f, -2.70287842e-02f, 8.92112926e-02f, -1.43686339e-01f, -2.34150086e-02f, 1.51851876e-02f, 6.13309368e-02f, 1.25910025e-02f, -8.05214420e-03f, 4.86134104e-02f,
  1.20065948e-02f, -1.66620687e-01f, 1.89315125e-01f, -4.35095541e-02f, 1.12710059e-01f, -5.78633137e-02f, 6.69126585e-02f, -3.85876670e-02f, 3.92064229e-02f, -1.41363919e-01f,
  -2.52434701e-01f, -6.29939064e-02f, 1.04856774e-01f, 2.98842769e-02f, -1.43751830e-01f, -1.21746555e-01f, -1.02344535e-01f, -8.19176435e-02f, -8.98284912e-02f, -1.38523966e-01f,
  -1.04698807e-01f, -2.03455627e-01f, -1.04656577e-01f, -1.00936241e-01f, 3.76276230e-03f, -1.58940673e-01f, 1.47567526e-01f, -1.68495942e-02f, -2.19052806e-01f, -1.88011199e-01f,
  3.68845284e-01f, 1.57507688e-01f, 1.25619337e-01f, -6.07811920e-02f, 2.00517893e-01f, 1.26859039e-01f, 1.20474420e-01f, -5.40314242e-02f, -1.77592769e-01f, 1.47149727e-01f,
  3.52519721e-01f, 6.65497184e-02f, -1.45182401e-01f, -1.45566359e-01f, -7.23698586e-02f, -1.10446200e-01f, -2.80480117e-01f, -1.95317030e-01f, 1.16123306e-02f, 2.24431440e-01f,
  8.49878043e-02f, 2.00111806e-01f, 2.42941767e-01f, -1.52966073e-02f, 6.62967786e-02f, -1.30638465e-01f, -6.21304996e-02f, 1.90749645e-01f, 1.66881204e-01f, -8.00586343e-02f,
  1.64424703e-01f, 2.59351641e-01f, -1.63769886e-01f, 1.01296291e-01f, 2.08454669e-01f, -2.08639465e-02f, -2.55339164e-02f, -1.26304049e-02f, -3.69247161e-02f, -1.16229743e-01f,
  1.91230223e-01f, 5.34390695e-02f, 1.30183205e-01f, 3.75088118e-02f, 9.96190608e-02f, 5.69422953e-02f, -7.81982169e-02f, -1.58686534e-01f, -1.31919265e-01f, 7.54740387e-02f,
  3.95552963e-02f, 3.07119191e-01f, 2.20014691e-01f, -1.02779754e-01f, -1.21901460e-01f, -7.63712898e-02f, -3.32303457e-02f, 1.31205525e-02f, -6.77834526e-02f, -7.14709312e-02f,
  -5.66398464e-02f, 6.01368882e-02f, 1.17808141e-01f, -1.02837525e-01f, -3.41685712e-02f, -2.21955013e-02f, -5.41792661e-02f, 5.54580279e-02f, -2.41621993e-02f, 2.85365768e-02f,
  -2.52015796e-02f, -1.20910205e-01f, -7.96228871e-02f, -1.52588651e-01f, -1.43657058e-01f, 3.85667458e-02f, -2.16622762e-02f, -9.48394015e-02f, 2.94457581e-02f, -2.95675248e-02f,
  4.52227928e-02f, -8.13233852e-02f, -6.12910651e-02f, -3.85457017e-02f, -3.86924632e-02f, -1.60131723e-01f, -1.41498789e-01f, 4.38407101e-02f, -8.37220699e-02f, 6.32500499e-02f,
  -1.11079030e-01f, -1.67184137e-02f, -1.59249172e-01f, -5.52755743e-02f, 4.08621617e-02f, -4.61344607e-02f, -1.98761467e-02f, -1.26154423e-01f, 8.54854658e-02f, -3.02371476e-02f,
  1.75282031e-01f, -1.62818864e-01f, -5.11841476e-02f, -1.01748127e-02f, -8.38589147e-02f, 4.67608832e-02f, -2.10018829e-02f, -6.98564202e-02f, -1.69957012e-01f, 6.43519238e-02f,
  -7.94116110e-02f, -4.28060442e-02f, 7.42482534e-03f, -2.52896279e-01f, -2.57102996e-01f, -1.67767599e-01f, -2.15177119e-01f, -6.35490194e-02f, -1.27237692e-01f, -2.10663855e-01f,
  -2.08133414e-01f, -1.36453256e-01f, -1.48518935e-01f, -1.34857625e-01f, 9.25164595e-02f, 1.37330651e-01f, -8.73129070e-02f, 1.32622734e-01f, 1.67276010e-01f, -1.95203591e-02f,
  6.03715368e-02f, 9.98377651e-02f, -1.79269761e-01f, -3.47527079e-02f, -1.88649237e-01f, -2.53131062e-01f, -2.61712104e-01f, -2.94831634e-01f, -4.27221470e-02f, 1.23340741e-01f,
  4.79214936e-02f, -1.09202251e-01f, -2.04967514e-01f, -7.88768008e-02f, -8.15516561e-02f, -1.14770353e-01f, -1.64550945e-01f, -2.11586282e-01f, -1.94173440e-01f, -3.11200112e-01f,
  -1.19373754e-01f, 8.76170322e-02f, 6.63474053e-02f, -7.70625770e-02f, -6.66238293e-02f, -7.13266339e-03f, -6.20550103e-02f, -1.12963933e-03f, -8.57890956e-03f, -6.97101578e-02f,
  4.62626964e-02f, 1.95910498e-01f, -6.88530877e-02f, 4.69218194e-02f, 1.11519760e-02f, 5.99040315e-02f, 1.59224793e-02f, -6.62357509e-02f, -9.59873423e-02f, 1.33730903e-01f,
  7.02141523e-02f, 1.61163248e-02f, -1.18258975e-01f, -4.07930836e-02f, 2.80282199e-02f, -1.59676865e-01f, 2.16025803e-02f, 7.05730766e-02f, -7.84499273e-02f, -2.69618094e-01f,
  5.03126346e-02f, 8.23815092e-02f, 1.56306237e-01f, 1.25479579e-01f, -2.27915501e-04f, 3.75235081e-02f, -7.78908506e-02f, -1.01662233e-01f, -2.15560012e-02f, -7.46494234e-02f,
  8.57282579e-02f, 6.21432215e-02f, -1.46054476e-02f, -1.55878469e-01f, -1.90256089e-01f, -5.22846282e-02f, -4.46229987e-02f, -1.99605823e-01f, -1.01910859e-01f, -9.63902324e-02f,
  -1.10004516e-02f, -8.00299086e-03f, -4.29222696e-02f, -7.55403340e-02f, 4.13242839e-02f, -6.64763898e-02f, 9.20313895e-02f, 1.87792718e-01f, 2.25568451e-02f, 5.58082201e-03f,
  -1.21296100e-01f, -1.11082934e-01f, -1.58273548e-01f, -2.78730560e-02f, -1.15132883e-01f, -3.34827974e-02f, -6.34896234e-02f, 2.84774303e-02f, -3.86874005e-02f, 5.53706326e-02f,
  1.15194090e-01f, -1.03296116e-01f, -1.48679078e-01f, -4.47065532e-02f, 6.74704388e-02f, 4.75064516e-02f, -1.10576503e-01f, -1.07444659e-01f, 2.86677014e-02f, -4.80640642e-02f,
  -6.87370971e-02f, -2.31453791e-01f, -2.38225505e-01f, -2.05981046e-01f, -1.81410108e-02f, -2.19059706e-01f, -2.37895966e-01f, -1.80588260e-01f, -2.33921498e-01f, -3.64089280e-01f,
  2.49948874e-01f, -1.64042525e-02f, 4.82440442e-02f, 6.96520060e-02f, 1.65400475e-01f, 1.18005022e-01f, 1.62384957e-01f, 1.66622549e-02f, 5.30247428e-02f, 6.37042820e-02f,
  1.89484894e-01f, 1.74033061e-01f, 1.04488999e-01f, 7.72204921e-02f, 8.65695626e-02f, -3.86376604e-02f, 2.78216731e-02f, 5.42086177e-02f, 7.73832500e-02f, 1.33064523e-01f,
  1.26393631e-01f, 9.39009711e-03f, 9.04877577e-03f, 4.02241275e-02f, 5.71312271e-02f, 1.01855136e-01f, 8.60617235e-02f, -4.85451333e-02f, 8.34551901e-02f, 3.35183367e-02f,
  -5.67024462e-02f, 1.29742771e-01f, 1.98196024e-02f, 5.88289835e-02f, -5.70265353e-02f, -2.57044397e-02f, 1.91596127e-03f, -6.87790141e-02f, -1.04248516e-01f, -1.97268259e-02f,
  -3.37723158e-02f, -2.12127082e-02f, 3.97846699e-02f, -3.27183865e-02f, -3.80790681e-02f, -3.15120816e-02f, 3.83745544e-02f, 8.94431472e-02f, 8.54405463e-02f, -4.05122451e-02f,
  4.46371883e-02f, 9.63001773e-02f, 3.60253900e-02f, -1.74753480e-02f, 1.07040517e-01f, 1.21967969e-02f, 5.68889156e-02f, 8.09425768e-03f, -1.46639058e-02f, -8.22144598e-02f,
  1.42037839e-01f, 1.89479992e-01f, 1.97640210e-01f, 6.33611232e-02f, 1.16026171e-01f, -1.21821212e-02f, -4.25678603e-02f, -5.02993651e-02f, 9.41775888e-02f, 1.23670297e-02f,
  7.00870156e-02f, 7.43487105e-02f, 1.17666749e-02f, -2.94650649e-03f, 8.90634488e-03f, 6.37232661e-02f, -6.52734563e-02f, 8.67539346e-02f, 3.02092615e-03f, -1.53708074e-03f,
  1.18438236e-01f, -2.69767139e-02f, 8.26076865e-02f, 1.77559480e-02f, 1.08670317e-01f, 2.88819242e-02f, 5.82611142e-03f, 9.21260044e-02f, 8.55096504e-02f, -1.27304811e-02f,
  -1.98915422e-01f, 1.07251793e-01f, -1.36639727e-02f, -1.00746201e-02f, -2.18145754e-02f, -5.90399615e-02f, 4.43843603e-02f, -9.39244628e-02f, -1.95152745e-01f, -1.57564387e-01f,
  -3.57688591e-02f, -4.44732085e-02f, -1.67489816e-02f, -6.62714541e-02f, -7.30457455e-02f, -9.48764160e-02f, -6.08963892e-02f, -4.10649404e-02f, -1.00554846e-01f, -1.13300808e-01f,
  -4.51785587e-02f, -8.56094584e-02f, 1.44967921e-02f, 1.40167819e-03f, 3.16218697e-02f, 2.97451504e-02f, 2.56402828e-02f, -1.10743307e-01f, 6.64640218e-02f, -4.00880910e-02f,
  2.71552444e-01f, 2.46366322e-01f, 2.66762257e-01f, 1.88949406e-01f, 6.78345710e-02f, 2.40085665e-02f, 1.66198522e-01f, 1.13138676e-01f, -7.27148205e-02f, 3.41339186e-02f,
  4.17967886e-03f, -1.40029103e-01f, 5.97865880e-02f, 6.13334887e-02f, 1.52081341e-01f, 1.33623913e-01f, 4.25813422e-02f, 1.95823878e-01f, 1.66106187e-02f, 5.90177029e-02f,
  2.51334254e-03f, 3.72260548e-02f, 5.38237207e-02f, 4.30158116e-02f, 1.72816902e-01f, 9.11894515e-02f, 7.18546705e-03f, 3.83484140e-02f, 3.13785970e-02f, 1.46449283e-01f,
  4.73181419e-02f, -2.21484173e-02f, -7.58880302e-02f, -1.32293850e-01f, -1.16341129e-01f, -5.20019699e-03f, -3.32613215e-02f, -1.83750585e-01f, -1.15500651e-01f, -1.29769608e-01f,
  -1.10379584e-01f, -5.77910207e-02f, 5.80520742e-03f, 9.54807911e-04f, -1.05240144e-01f, -1.16987020e-01f, -1.77280363e-02f, -2.06517875e-02f, 7.39813745e-02f, -4.38944548e-02f,
  -9.55182388e-02f, -3.36864293e-02f, 1.41336080e-02f, -9.48639959e-02f, 8.80076140e-02f, -1.43579334e-01f, -1.12614021e-01f, -5.27639203e-02f, -4.95575741e-02f, -2.09442130e-03f,
  -1.75870568e-01f, 3.01359110e-02f, 6.27307445e-02f, -9.04689580e-02f, -4.64644330e-03f, -1.22471571e-01f, -5.65157719e-02f, -3.43180932e-02f, -7.18923658e-02f, -1.20586835e-01f,
  -1.35185301e-01f, 5.73960692e-03f, 1.66142844e-02f, -5.09730205e-02f, -5.72382361e-02f, -9.61021855e-02f, 1.37624545e-02f, 1.04592666e-02f, -1.72689959e-01f, -9.31420624e-02f,
  2.79077906e-02f, 4.55090664e-02f, -1.49881929e-01f, -4.21479717e-02f, -1.44899979e-01f, -1.08896449e-01f, -1.32596239e-01f, -2.26077408e-01f, -1.65564731e-01f, -1.23343647e-01f,
  -1.23273455e-01f, -1.27355233e-01f, 3.59202437e-02f, 2.07140632e-02f, 6.95761368e-02f, -1.04576297e-01f, 1.47884116e-01f, -5.07782251e-02f, -2.21506450e-02f, 6.73040673e-02f,
  5.69413230e-02f, -4.38467935e-02f, 1.11343730e-02f, 4.29390837e-03f, -1.08814068e-01f, -1.83458135e-01f, -1.40538126e-01f, -6.41236678e-02f, 4.87483712e-03f, -4.40466143e-02f,
  -2.64353957e-03f, -1.06243245e-01f, -6.26309961e-02f, -6.89175725e-02f, -1.37199042e-03f, -1.25047028e-01f, -1.20504104e-01f, -1.03353113e-01f, -1.33309454e-01f, -1.50034666e-01f,
  -2.70412236e-01f, -2.52251387e-01f, -2.76935518e-01f, -2.46068731e-01f, -9.22401398e-02f, -5.85397258e-02f, -1.44732744e-01f, 7.39526749e-02f, -1.93094704e-02f, -1.75957769e-01f,
  -1.06500655e-01f, -8.98738503e-02f, -1.93659902e-01f, -1.63107768e-01f, -1.52648926e-01f, -3.35541397e-01f, -3.20399076e-01f, -2.63650000e-01f, 1.73033271e-02f, 1.00765400e-01f,
  -5.47452532e-02f, -4.17516530e-02f, 2.35567484e-02f, -6.10336140e-02f, -6.80515170e-02f, -1.38823455e-02f, -1.59266606e-01f, -7.81119540e-02f, -1.18464977e-01f, -3.18728596e-01f,
  -2.52903074e-01f, -8.58653486e-02f, -8.82925559e-03f, -1.52941793e-01f, -9.68421400e-02f, 5.54328561e-02f, -7.73713738e-02f, -4.15417999e-02f, 7.81550035e-02f, -6.57868907e-02f,
  -5.12416810e-02f, 6.32890174e-03f, -6.29464164e-02f, -3.80436219e-02f, -3.87693979e-02f, 8.06419104e-02f, -4.82445955e-02f, -7.22900853e-02f, -1.63042203e-01f, 1.01874610e-02f,
  -1.66068226e-01f, -7.54158422e-02f, -6.85773268e-02f, 6.95097595e-02f, 5.95546141e-02f, 2.28087530e-02f, -1.12732863e-02f, 3.62200327e-02f, -6.92760646e-02f, -2.29338512e-01f,
  1.73924193e-02f, 1.96790113e-03f, -6.35453239e-02f, 7.22222356e-03f, 4.45283838e-02f, 5.01026995e-02f, -5.07680178e-02f, -1.29370600e-01f, 5.15799187e-02f, -1.39101490e-01f,
  -4.26719971e-02f, 6.86104894e-02f, 4.94513065e-02f, -3.14816497e-02f, -4.20717634e-02f, -2.48582494e-02f, -9.96121168e-02f, -1.17343515e-02f, 5.83608001e-02f, -3.15686502e-02f,
  -1.55665651e-01f, -5.87001331e-02f, -2.03785785e-02f, 2.82096080e-02f, -9.31871906e-02f, -6.59350380e-02f, 7.58909732e-02f, -2.28115041e-02f, -1.30347893e-01f, 2.48837378e-02f,
  -1.23967424e-01f, -4.87116426e-02f, -2.06669286e-01f, -2.46474463e-02f, -5.89301176e-02f, -5.73465340e-02f, -1.77823961e-01f, 6.07409179e-02f, -1.09364614e-01f, 4.53510843e-02f,
  -4.28712219e-02f, -7.89083913e-02f, -1.15557037e-01f, 1.42477620e-02f, -2.81826742e-02f, 7.92815313e-02f, -1.28535047e-01f, -1.14998601e-01f, -5.70346266e-02f, 1.18178263e-01f,
  -1.72958210e-01f, -1.32487670e-01f, -1.71741828e-01f, -1.88915402e-01f, -4.72654104e-02f, -1.04967587e-01f, 1.46323163e-02f, -3.51855382e-02f, -1.30866632e-01f, -2.58576155e-01f,
  6.31730020e-01f, 2.25361045e-02f, 1.13690108e-01f, 2.78097153e-01f, 1.57843158e-01f, 1.89580187e-01f, 1.33698374e-01f, 1.76251188e-01f, 7.39089027e-02f, 1.72150120e-01f,
  2.00680315e-01f, 1.79007709e-01f, 1.66790754e-01f, -3.82994227e-02f, 1.19234854e-02f, -7.03435950e-03f, -1.14504568e-01f, -2.60197576e-02f, 2.14030027e-01f, 6.07878417e-02f,
  -2.03478765e-02f, 5.53521067e-02f, 1.51557222e-01f, 1.22683588e-02f, -1.20475531e-01f, -7.91492760e-02f, -1.17207363e-01f, -4.09810506e-02f, -9.95268822e-02f, -2.61679173e-01f,
  -3.49493057e-01f, 4.54284847e-02f, 1.13243118e-01f, -1.12155586e-01f, -6.34126039e-03f, 1.43546723e-02f, 9.65268388e-02f, -6.70748530e-03f, -2.06260104e-02f, -9.38323066e-02f,
  -3.81368473e-02f, -3.08608692e-02f, -7.51354396e-02f, -8.53540599e-02f, -9.31124687e-02f, 6.00192770e-02f, -9.60623547e-02f, -1.14214793e-03f, -1.08093023e-01f, -1.59026265e-01f,
  3.01746614e-02f, 9.07239690e-02f, -1.84026416e-02f, 3.67484167e-02f, -8.05404130e-03f, 1.02237128e-01f, -1.05627008e-01f, 5.66403903e-02f, 3.02544534e-02f, 9.65884924e-02f,
  1.25914037e-01f, 2.18261406e-02f, 7.66154453e-02f, 9.05576944e-02f, 1.21660046e-02f, -1.96364652e-02f, -5.36902249e-02f, 8.21353588e-03f, 4.82106805e-02f, 4.63359281e-02f,
  -7.89971873e-02f, -6.72170296e-02f, -2.77492460e-02f, 5.81005216e-02f, 4.40154001e-02f, -4.75052856e-02f, -1.13793388e-01f, -8.91937315e-02f, -1.13925263e-01f, -1.85351133e-01f,
  5.30064702e-02f, -1.27368897e-01f, -8.41991883e-03f, -1.04777403e-01f, 6.76548341e-04f, -5.25118895e-02f, -6.79562688e-02f, -1.21425763e-01f, 3.11674532e-02f, 6.73618168e-02f,
  -3.06060523e-01f, 1.19328529e-01f, 8.38780105e-02f, -1.03731327e-01f, -1.21609725e-01f, -6.85511157e-02f, 8.63794312e-02f, -1.34328917e-01f, -2.61777490e-01f, -1.05742000e-01f,
  -4.16548625e-02f, 2.55364683e-02f, -9.44167525e-02f, 4.47587855e-02f, 1.40401334e-01f, -3.28437239e-02f, -6.11155853e-02f, 3.28738950e-02f, -8.54755342e-02f, -6.76322505e-02f,
  -7.63434768e-02f, 1.63707331e-01f, 1.27963379e-01f, 6.27120882e-02f, 1.27034038e-01f, 5.61676100e-02f, 1.94819048e-02f, 9.90764797e-03f, 4.73890789e-02f, 2.16682300e-01f,
  -5.11240721e-01f, 1.06548175e-01f, 3.52139883e-02f, -1.80468604e-01f, 1.13792241e-01f, 2.84511000e-01f, 4.84892935e-01f, 1.43646196e-01f, -6.55083656e-02f, 2.96474677e-02f,
  9.23230778e-03f, -2.22590402e-01f, -6.43817037e-02f, 7.86731318e-02f, 1.23563915e-01f, 2.88416326e-01f, 2.53216088e-01f, 4.23297808e-02f, -9.17731375e-02f, 9.36972350e-02f,
  1.81750432e-01f, -2.15321824e-01f, -3.26544255e-01f, -1.17990203e-01f, 2.06228290e-02f, -8.31505135e-02f, -7.57478327e-02f, -1.59359306e-01f, 2.10261196e-01f, 9.43400413e-02f,
  -2.45410383e-01f, -2.84257054e-01f, 7.42597431e-02f, -1.80441096e-01f, -1.03094362e-01f, -6.36427253e-02f, 1.46182925e-01f, -1.09539144e-01f, 1.11906886e-01f, -2.19490770e-02f,
  -1.22871725e-02f, 1.16675287e-01f, -7.45721161e-02f, -7.24722221e-02f, -2.27885824e-02f, -5.31499088e-02f, -4.92133237e-02f, -1.13866068e-01f, -1.10620655e-01f, 3.75601240e-02f,
  1.64690405e-01f, -1.12181984e-01f, -1.63696513e-01f, -3.70288715e-02f, -1.05445581e-02f, -2.37822697e-01f, -8.00241306e-02f, -7.34412447e-02f, -1.42106250e-01f, -2.02808455e-01f,
  -7.03601539e-02f, -1.02073267e-01f, 9.31373388e-02f, 8.44755098e-02f, -7.47595960e-03f, 8.05432573e-02f, -9.82696656e-03f, 1.24599487e-01f, 2.46609300e-02f, -1.28023503e-02f,
  -6.40626922e-02f, -1.63947660e-02f, -9.60670710e-02f, 1.31936288e-02f, -6.86882483e-03f, -1.00087814e-01f, 8.62787589e-02f, -1.43070770e-02f, -5.56934997e-02f, 3.16731744e-02f,
  -7.49663934e-02f, 1.20161809e-01f, -1.12939812e-01f, -3.17169428e-02f, 2.68220548e-02f, -7.67251477e-02f, -7.18450965e-03f, -1.44960433e-02f, -8.48078057e-02f, -2.88892351e-03f,
  -2.66850352e-01f, 1.41666532e-01f, -1.17280651e-02f, -3.83887291e-02f, -4.17907676e-03f, -9.39841494e-02f, -3.94672416e-02f, 1.81493461e-02f, 3.19797383e-03f, -5.31587712e-02f,
  1.05674956e-02f, 5.56676369e-03f, -5.13745248e-02f, 9.66610163e-02f, 3.35161164e-02f, -1.84332207e-02f, -1.42717976e-02f, 6.69021457e-02f, -8.58219340e-02f, -2.44918223e-02f,
  8.83603990e-02f, 1.14734970e-01f, -1.97241947e-01f, 9.34827700e-03f, -2.37956624e-02f, -1.73778489e-01f, -7.23636150e-02f, -3.02770622e-02f, -5.94905466e-02f, 3.58497910e-02f,
  -4.00760204e-01f, 1.81327164e-01f, -4.47095148e-02f, -1.13179401e-01f, 6.66458756e-02f, 7.71206394e-02f, 4.13328916e-01f, 3.08082178e-02f, 2.41395086e-02f, 1.57066807e-01f,
  -6.70997649e-02f, -3.43752176e-01f, -2.51541197e-01f, -1.45754749e-02f, 8.08967501e-02f, 4.32352275e-01f, 3.58458608e-01f, -1.53301612e-01f, -3.37424427e-01f, -7.88439363e-02f,
  1.14563040e-01f, -6.97958916e-02f, -1.62629724e-01f, -1.56352013e-01f, -3.41263637e-02f, -1.03543298e-02f, 5.86886099e-03f, -3.08066979e-02f, -2.30937675e-02f, 6.47791708e-03f,
  -3.01842652e-02f, -2.79770494e-01f, 1.32295704e-02f, -5.21839410e-02f, -1.03153460e-01f, -1.53381556e-01f, 2.12389044e-02f, -1.53656930e-01f, -2.05743909e-01f, 3.40234744e-03f,
  -4.91550490e-02f, -1.41756564e-01f, -9.71823260e-02f, -4.77181636e-02f, -1.04042262e-01f, -1.30007014e-01f, 1.49974274e-03f, -6.31704926e-02f, -9.68189165e-03f, -4.69027348e-02f,
  8.02838206e-02f, -2.35210601e-02f, -1.81859851e-01f, 1.96270971e-03f, -1.21249184e-01f, -8.86710659e-02f, 1.68429315e-02f, -1.92974031e-01f, -3.99600156e-02f, 8.92442167e-02f,
  5.00774160e-02f, -1.40635427e-02f, 3.81855890e-02f, 4.44314294e-02f, 6.71335459e-02f, 1.39393166e-01f, -6.86569288e-02f, -5.35183810e-02f, -9.83927026e-03f, -7.37948790e-02f,
  -5.32251149e-02f, 9.58960280e-02f, -8.25614408e-02f, 9.34463833e-03f, -6.00519553e-02f, -4.90353592e-02f, -1.52567262e-02f, 1.46040633e-01f, 4.58305143e-03f, -5.21037392e-02f,
  -3.53558548e-02f, 2.96860114e-02f, -1.78559944e-02f, -2.80210730e-02f, 6.16943203e-02f, -6.02677139e-03f, 6.71576187e-02f, -1.22374907e-01f, -8.21578354e-02f, -3.50292623e-02f,
  1.57361925e-01f, -7.42005631e-02f, 2.31651738e-01f, -1.41620310e-02f, -6.64534494e-02f, -1.59442099e-03f, -1.32982239e-01f, 1.40896719e-03f, -2.10740380e-02f, -4.46728505e-02f,
  -1.93842798e-01f, -1.18191607e-01f, 1.29815191e-02f, -3.79804000e-02f, -1.34335300e-02f, -1.25295203e-02f, 1.23052686e-01f, -7.62268603e-02f, 5.17317578e-02f, 1.98370833e-02f,
  1.70473948e-01f, 1.43132836e-01f, 1.47883192e-01f, 1.72228858e-01f, 6.95819333e-02f, 1.42645806e-01f, 8.67595524e-02f, -1.10236974e-02f, 6.78388029e-02f, 3.54229003e-01f,
  2.82788694e-01f, -1.77564546e-01f, 4.87858444e-01f, -1.09302558e-01f, -3.77863735e-01f, -2.65000969e-01f, -2.59029150e-01f, -5.44614084e-02f, -1.87107682e-01f, -2.66684353e-01f,
  -3.12470019e-01f, -1.83571845e-01f, 5.64613286e-03f, 1.01184495e-01f, 3.07986528e-01f, 9.66504775e-03f, 1.85130298e-01f, 4.88772422e-01f, 3.42191368e-01f, -6.85599109e-04f,
  -2.17425406e-01f, 1.53906181e-01f, 4.15639311e-01f, 2.59089649e-01f, -1.68684408e-01f, -5.89945540e-03f, 4.45416793e-02f, 3.77768315e-02f, -1.31437272e-01f, 1.14298955e-01f,
  4.67420975e-03f, 1.24925077e-01f, 7.24213850e-03f, -9.33976471e-02f, -1.45523608e-01f, 7.33826980e-02f, -3.66299301e-02f, 1.56723559e-01f, 2.89162416e-02f, 1.27809897e-01f,
  -2.90435880e-01f, -6.46852255e-02f, -2.11906463e-01f, -1.33932814e-01f, -1.00187980e-01f, 7.39393011e-02f, 2.08823875e-01f, 2.64058501e-01f, 2.53284067e-01f, -6.67743087e-02f,
  -4.00309354e-01f, -1.83595657e-01f, 1.23013437e-01f, -4.12314199e-02f, 1.67540029e-01f, 2.21697420e-01f, 9.19198394e-02f, 1.00659080e-01f, 8.60074982e-02f, 1.06962070e-01f,
  -6.02636822e-02f, -6.05301000e-02f, -4.39423248e-02f, 2.14372389e-02f, -5.69427535e-02f, -7.77031109e-02f, 3.15145329e-02f, -7.87777305e-02f, 3.43990512e-02f, 5.89809790e-02f,
  3.61579061e-02f, -1.45385293e-02f, 7.88376704e-02f, -6.25020191e-02f, -6.97908998e-02f, -7.86394775e-02f, -6.82630166e-02f, 4.48315702e-02f, -3.82904522e-02f, -2.09717662e-03f,
  -2.47373804e-03f, 4.25172225e-02f, 3.88771482e-03f, 8.37859884e-02f, 7.62966229e-04f, 1.19570129e-01f, -8.34770780e-03f, -7.50485109e-03f, -5.18514737e-02f, -1.04200877e-02f,
  -1.52279884e-01f, 1.50856808e-01f, -4.85359058e-02f, 6.01921566e-02f, -1.66976541e-01f, -3.27234566e-02f, -6.87500760e-02f, -5.27749136e-02f, -4.56580669e-02f, 4.82279286e-02f,
  -1.18577443e-01f, -5.10027260e-02f, 7.38885021e-04f, 3.08295731e-02f, -9.43973586e-02f, -1.73377797e-01f, -1.21998392e-01f, -3.98423113e-02f, -1.72843412e-02f, -6.22802228e-02f,
  -7.22068623e-02f, -5.30380271e-02f, -8.76884758e-02f, -1.03213213e-01f, -2.02578068e-01f, -1.15436547e-01f, -5.37239723e-02f, -9.83539745e-02f, -4.28892337e-02f, -1.91127911e-01f,
  -6.37772262e-01f, -3.44123602e-01f, 3.14432174e-01f, -4.79371339e-01f, -1.86272472e-01f, -1.10012598e-01f, -3.86101007e-01f, -3.01009476e-01f, -1.09532356e-01f, -3.46953243e-01f,
  -1.14663966e-01f, -9.86793041e-02f, 6.57991394e-02f, 2.39459127e-02f, -1.79448411e-01f, -2.37878829e-01f, 2.52286140e-02f, 3.17918090e-03f, 1.09172322e-01f, -2.53984541e-01f,
  -2.63246417e-01f, -2.51544148e-01f, 1.70273371e-02f, 3.50412093e-02f, -1.84574813e-01f, -8.28586295e-02f, 1.28453046e-01f, -1.00464843e-01f, -1.26590002e-02f, -2.04674184e-01f,
  -1.96751699e-01f, -9.35842618e-02f, 3.19833755e-02f, -5.29999919e-02f, -4.26210240e-02f, -1.33977085e-02f, -1.08288318e-01f, -3.53238918e-02f, 6.85825869e-02f, -2.65762452e-02f,
  7.23607615e-02f, -8.93021077e-02f, -2.56799385e-02f, -9.91110429e-02f, -2.64989167e-01f, -1.22060560e-01f, 1.47238374e-01f, -1.54206790e-02f, 1.65690720e-01f, 9.78988037e-02f,
  8.72009844e-02f, 1.34057377e-03f, 1.50741309e-01f, 1.78812861e-01f, 1.40850663e-01f, 1.16252571e-01f, 1.72460973e-01f, 1.49838075e-01f, 3.07038337e-01f, -8.60501826e-02f,
  -9.30409804e-02f, 8.46721523e-04f, 8.41248110e-02f, -6.82955533e-02f, -6.52851239e-02f, -1.44401728e-03f, -3.08042038e-02f, -1.19863942e-01f, 3.00887041e-02f, -3.61617953e-02f,
  1.64237525e-02f, -3.26096378e-02f, -9.25118625e-02f, -1.22100361e-01f, 1.78772565e-02f, 6.63704947e-02f, 1.53230987e-02f, 5.79806939e-02f, 2.39078384e-02f, 5.15682176e-02f,
  7.78250471e-02f, 9.29988623e-02f, 6.45671561e-02f, -1.11657735e-02f, 8.56406391e-02f, -1.13195330e-02f, 6.12112395e-02f, -2.65215933e-02f, -1.96946301e-02f, 6.32223040e-02f,
  -2.51620710e-01f, 3.55663478e-01f, -3.23240995e-01f, 5.27096726e-02f, -2.20871530e-02f, 1.69399396e-01f, 4.34122086e-02f, 1.27178580e-01f, -1.00351118e-01f, -1.36850372e-01f,
  2.34935917e-02f, -1.17106266e-01f, 1.55536188e-02f, 3.53570506e-02f, -1.37316540e-01f, 4.57133465e-02f, -4.69316058e-02f, 7.11834952e-02f, 1.17862195e-01f, 6.86489791e-02f,
  1.61168858e-01f, 1.75039470e-02f, -1.56997234e-01f, 1.29203215e-01f, 5.87754734e-02f, 6.14801347e-02f, -3.85964736e-02f, 2.14855168e-02f, 5.15649840e-02f, -3.99531215e-01f,
  5.57789028e-01f, 2.85853967e-02f, -6.11057997e-01f, 8.71168077e-02f, -2.29267836e-01f, -2.86028594e-01f, -8.58888924e-02f, -4.67080884e-02f, 5.46745993e-02f, -9.84939262e-02f,
  -1.30258381e-01f, 1.06226116e-01f, -3.18469442e-02f, -2.75807772e-02f, 6.26449138e-02f, -2.07595348e-01f, -3.35437536e-01f, -5.97254261e-02f, 6.98748901e-02f, 1.62017625e-02f,
  1.22298934e-01f, 5.58009557e-02f, 2.14990720e-01f, -2.52264384e-02f, -1.31964013e-01f, -1.01381987e-01f, -3.41952026e-01f, -2.29781061e-01f, -1.86391473e-01f, -2.37665132e-01f,
  -4.09946710e-01f, -1.33705750e-01f, -8.24796855e-02f, 1.26000598e-01f, -9.71331224e-02f, 1.11290552e-01f, 3.65853086e-02f, 4.29563560e-02f, 1.35579482e-01f, -8.81185308e-02f,
  -1.75112337e-02f, 1.00284126e-02f, 2.21348945e-02f, -4.42067534e-02f, -4.48563583e-02f, -4.71736267e-02f, -8.59069750e-02f, -3.33363041e-02f, 7.46756345e-02f, -8.57499912e-02f,
  -6.77310526e-02f, -4.88244183e-02f, -9.30873901e-02f, 4.96849343e-02f, -1.51110679e-01f, -3.20168398e-02f, -4.44494560e-02f, -1.28123676e-02f, -2.04035982e-01f, -8.83498043e-03f,
  1.80743393e-02f, -1.30050471e-02f, 9.41297784e-02f, 1.73882619e-02f, 1.21430479e-01f, 8.03711712e-02f, 6.60314932e-02f, 1.40586808e-01f, 4.59683649e-02f, 7.99790025e-02f,
  1.23211397e-02f, 4.71662404e-03f, 3.27214040e-02f, 7.26129115e-02f, -5.25498204e-02f, 1.11581162e-01f, -2.12494433e-02f, 3.65612730e-02f, 9.44876373e-02f, 1.21946193e-01f,
  6.18237723e-03f, 5.90296797e-02f, 4.42346632e-02f, 1.12890884e-01f, -3.22058350e-02f, -3.47293913e-02f, -7.38651529e-02f, 8.81929696e-03f, 3.06136943e-02f, 6.03546202e-02f,
  1.49507701e-01f, -2.32711673e-01f, 6.22420087e-02f, 1.15725450e-01f, 2.11091508e-04f, -1.11264996e-01f, -4.10384573e-02f, 8.49452168e-02f, -6.87327189e-03f, -2.31269691e-02f,
  -1.50730312e-01f, -3.83443199e-03f, -7.68060759e-02f, -4.46203630e-03f, 2.55882051e-02f, -3.35189924e-02f, 9.72064435e-02f, 8.01464245e-02f, 1.09950826e-01f, -4.55294140e-02f,
  1.24368697e-01f, 1.55126244e-01f, 1.30368695e-01f, 9.23083201e-02f, 1.39097162e-02f, 6.72338903e-02f, -1.28509700e-01f, 5.64923286e-02f, 7.65819401e-02f, 2.36624002e-01f,
  -4.54363734e-01f, 6.87949955e-02f, -2.24772170e-01f, 1.26532137e-01f, 7.89694563e-02f, 1.22603878e-01f, 4.57511693e-02f, 9.09094065e-02f, 8.51713717e-02f, 1.60274073e-01f,
  1.27474099e-01f, 2.25751549e-01f, 1.61525786e-01f, 1.46021411e-01f, 1.33254593e-02f, 1.38131723e-01f, 2.41149366e-01f, -1.68216556e-01f, -9.91499200e-02f, 8.99156481e-02f,
  2.42656305e-01f, 1.31776735e-01f, -6.13658540e-02f, -6.91563915e-03f, 7.81928301e-02f, 2.15838835e-01f, 1.65841192e-01f, 9.70194265e-02f, 8.83097127e-02f, 1.91431880e-01f,
  -2.47168511e-01f, -2.15069741e-01f, 6.95740953e-02f, -1.04159676e-02f, -1.13003545e-01f, -1.32403791e-01f, -1.57790840e-01f, -3.87759730e-02f, 2.57635787e-02f, 2.46589966e-02f,
  -4.40225676e-02f, -1.32299960e-01f, -2.42102630e-02f, -5.23841754e-02f, -6.97979005e-03f, -6.05827309e-02f, 4.24122736e-02f, 8.79788920e-02f, 7.65418038e-02f, 2.61447784e-02f,
  2.56127715e-02f, 5.48859760e-02f, 9.23068523e-02f, 4.86247316e-02f, -7.76707828e-02f, 6.85848668e-02f, 1.15481243e-02f, 7.25206826e-03f, -1.30070105e-01f, 8.50337744e-02f,
  9.55449417e-02f, -1.37618901e-02f, -7.40134865e-02f, -3.47280391e-02f, 1.79185905e-02f, 5.50848581e-02f, 6.35620579e-02f, 1.32753357e-01f, -8.55930746e-02f, 6.20499812e-02f,
  4.58217785e-02f, 4.15779576e-02f, -3.77585702e-02f, -1.25355586e-01f, -8.92894343e-02f, -1.64248818e-03f, 6.21279934e-03f, -7.86742568e-02f, -1.37304336e-01f, -1.86463341e-03f,
  -7.06769004e-02f, -1.67032983e-02f, -1.53663680e-01f, -1.01818971e-01f, 5.90896560e-03f, -8.77837315e-02f, -2.56956872e-02f, 1.17839221e-03f, 3.91085213e-03f, -8.85149837e-03f,
  3.27363014e-01f, -1.80438325e-01f, 3.29851694e-02f, 2.59939004e-02f, -6.27628192e-02f, -7.05310553e-02f, -5.63611649e-02f, 7.25271460e-03f, -7.76934996e-02f, -2.06830949e-02f,
  -1.06305815e-01f, -5.48606291e-02f, -1.43299391e-02f, -2.20376495e-02f, -9.27426890e-02f, 8.62431340e-03f, 9.13711861e-02f, 8.80315751e-02f, 7.23426715e-02f, 6.24853335e-02f,
  1.02504678e-01f, 1.44103402e-02f, 1.02795474e-01f, 9.10048485e-02f, 1.05568565e-01f, 6.51092455e-02f, -2.89845802e-02f, 6.07668683e-02f, -1.17562190e-01f, 1.11598959e-02f,
  3.77884835e-01f, 1.36939615e-01f, -2.61512339e-01f, 1.60804227e-01f, -1.01863131e-01f, -1.83274597e-01f, 4.73098792e-02f, 3.08558289e-02f, 1.96498856e-01f, 1.07648835e-01f,
  -1.57182500e-01f, -3.00984889e-01f, -1.26225814e-01f, -1.18008651e-01f, -8.81531239e-02f, 1.13363624e-01f, 1.71840757e-01f, -1.57937497e-01f, -2.32330814e-01f, -1.33296043e-01f,
  1.24468906e-02f, 2.48745963e-01f, 1.83924273e-01f, -1.17792645e-02f, 7.75868744e-02f, 1.33929411e-02f, -1.10247545e-02f, -3.83930691e-02f, -2.95645446e-02f, -6.28849417e-02f,
  -8.16214159e-02f, -1.75279185e-01f, -1.04896769e-01f, -1.07396916e-01f, -3.12774852e-02f, 7.72295147e-02f, 1.65324304e-02f, -9.95204002e-02f, -1.94869265e-01f, -3.07628214e-02f,
  -2.35704765e-01f, -1.94902286e-01f, -2.47107565e-01f, -4.23473977e-02f, -1.47273270e-02f, -1.36115506e-01f, 6.94896281e-02f, -1.23966508e-01f, -2.27656737e-02f, -1.26440302e-01f,
  -2.04038322e-01f, -1.80837065e-01f, -1.19273208e-01f, -1.52710155e-01f, -1.23773016e-01f, -2.22309008e-01f, -2.77461499e-01f, -2.36687765e-01f, -1.82483017e-01f, 2.29246110e-01f,
  2.08634455e-02f, 1.04482353e-01f, 1.62782986e-02f, 6.56887889e-02f, 1.09101079e-01f, -9.19632986e-02f, -6.48227558e-02f, -2.81311572e-02f, 2.67712120e-03f, -1.77892135e-03f,
  -1.81645647e-01f, -3.10607012e-02f, -9.28965211e-02f, -4.69278656e-02f, -1.94834117e-02f, 4.66666706e-02f, -5.96764386e-02f, 6.55118302e-02f, -5.60336150e-02f, 6.05200008e-02f,
  8.48348737e-02f, 4.20907419e-03f, 9.82606318e-03f, 2.36378498e-02f, 2.47945096e-02f, -7.96908066e-02f, 6.59950227e-02f, -4.86513227e-02f, 4.20279205e-02f, -1.62960179e-02f,
  3.34186435e-01f, -1.53394684e-01f, 2.22895026e-01f, -9.07860976e-03f, 5.88185042e-02f, -1.41260773e-01f, 6.93687797e-02f, 2.10850183e-02f, -1.34848043e-01f, -9.47420970e-02f,
  -1.57310426e-01f, -1.33046731e-01f, -1.45361066e-01f, -4.68317904e-02f, -9.55269206e-03f, -4.94815968e-02f, 1.08990900e-01f, 1.69803239e-02f, 8.93609673e-02f, 2.28262302e-02f,
  -2.73747668e-02f, 1.23592786e-01f, 2.70517051e-01f, 1.33386314e-01f, 8.52356255e-02f, 1.00209780e-01f, 1.03707425e-01f, 1.06560431e-01f, 8.92634168e-02f, 5.03749728e-01f,
  2.98679322e-01f, 1.71096787e-01f, -4.32027638e-01f, -9.08218473e-02f, -9.25975591e-02f, 1.24142960e-01f, 3.41196209e-01f, 2.55346477e-01f, 5.60657792e-02f, 6.13890998e-02f,
  2.31112748e-01f, 9.78452861e-02f, -6.42214864e-02f, 4.42869216e-02f, 5.40800542e-02f, -1.31598860e-01f, -1.26088843e-01f, -7.48521611e-02f, -7.59940818e-02f, 1.93597883e-01f,
  3.77246737e-02f, 5.58067970e-02f, 1.49854392e-01f, -4.34969589e-02f, -2.38000631e-01f, -2.45968133e-01f, -1.32544234e-01f, -9.01706815e-02f, -1.53528020e-01f, -4.57592070e-01f,
  -1.23955786e-01f, 7.18122572e-02f, -6.05192222e-03f, -6.78608343e-02f, -8.60070437e-02f, 9.61616561e-02f, 4.71478142e-02f, 8.44095647e-03f, 1.62020326e-01f, -2.61074747e-03f,
  -8.31538588e-02f, 8.17338452e-02f, -9.38163884e-03f, -4.66354154e-02f, -3.44811045e-02f, 5.83565272e-02f, 1.07870223e-02f, 3.46955843e-02f, 1.67481713e-02f, 8.35026894e-03f,
  -6.28261175e-03f, 2.19711401e-02f, -6.29071146e-02f, -2.61703623e-03f, -3.47697735e-02f, -8.28274041e-02f, -7.01371580e-02f, -1.10868722e-01f, -3.79491672e-02f, -1.94967031e-01f,
  2.07345471e-01f, -3.60055715e-02f, -3.61250117e-02f, -2.65511195e-03f, 9.79171619e-02f, 8.00008979e-03f, -8.12092423e-02f, -8.07795823e-02f, -1.18160844e-01f, -3.88927534e-02f,
  -6.08343519e-02f, 1.00907177e-01f, 1.07907191e-01f, 6.20736741e-02f, 6.70057198e-04f, 1.78086050e-02f, -1.13876380e-01f, 1.08390218e-02f, -8.28852057e-02f, -4.02924828e-02f,
  1.92031227e-02f, -1.01001926e-01f, -5.34269661e-02f, -3.12077906e-02f, -3.78440022e-02f, 2.60953456e-02f, -5.21987788e-02f, 9.70810652e-02f, 4.68714349e-02f, 8.33118185e-02f,
  4.48690541e-02f, 2.07783923e-01f, -1.97078899e-01f, -6.86252937e-02f, -3.14893484e-01f, -1.07260115e-01f, -1.20286427e-01f, -4.72764857e-02f, -3.24326828e-02f, -2.38206964e-02f,
  -1.20201195e-02f, 5.35678156e-02f, -1.79353021e-02f, 1.92985032e-03f, 6.65994734e-02f, 5.94310202e-02f, 5.98461404e-02f, -4.83092777e-02f, 2.25072261e-02f, -2.01003015e-01f,
  -4.63289991e-02f, 1.02453567e-01f, -7.50364363e-02f, -1.48460791e-01f, -6.79823905e-02f, -6.53492147e-03f, -1.05834313e-01f, -3.67161050e-03f, -5.84636293e-02f, 1.45623043e-01f,
  1.20638860e-02f, 9.04084593e-02f, 1.63866907e-01f, 9.18470398e-02f, 1.84353545e-01f, 2.10629344e-01f, 3.21357489e-01f, 1.08289130e-01f, -5.67976944e-02f, 2.66735908e-02f,
  -1.87707558e-01f, -2.77001292e-01f, -2.16301158e-01f, -1.34784728e-01f, -2.09560290e-01f, 6.82837740e-02f, 6.25400022e-02f, -5.34811281e-02f, -9.64589864e-02f, 3.67547758e-02f,
  -8.06852058e-02f, 4.51608710e-02f, -9.66673717e-02f, -4.73354235e-02f, -1.02580175e-01f, -6.42639101e-02f, 1.24914058e-01f, 3.81765552e-02f, -3.83807160e-02f, 1.51086098e-03f,
  -4.11042534e-02f, 3.00447773e-02f, -5.92302196e-02f, -2.17024162e-01f, -8.66583213e-02f, 5.09331487e-02f, 7.60555789e-02f, 3.75132114e-02f, 6.86545968e-02f, 1.04451142e-01f,
  -6.55541420e-02f, 2.92933322e-02f, 1.36261294e-02f, -7.27896392e-03f, 1.68064207e-01f, 1.03794962e-01f, -5.77356778e-02f, 6.43080613e-03f, 8.07095319e-03f, -1.09936982e-01f,
  -1.25636868e-02f, 9.74184498e-02f, 9.91543233e-02f, 1.80701483e-02f, -1.24382637e-01f, -2.44872458e-02f, -2.29066052e-03f, -1.35987952e-01f, -8.83936137e-02f, -5.45465574e-03f,
  -2.04387203e-01f, -1.29425526e-02f, -1.58598870e-01f, -3.46335792e-03f, 1.73316095e-02f, 6.49359003e-02f, 1.66845948e-01f, 1.18649073e-01f, 4.43443283e-02f, 1.24411173e-01f,
  1.26700833e-01f, 9.84350443e-02f, 2.05095261e-01f, 6.20075092e-02f, 8.24110806e-02f, 4.50826436e-02f, 7.13450313e-02f, -4.67341095e-02f, 1.18296608e-01f, 5.09410948e-02f,
  4.39592823e-02f, 2.61975639e-02f, 5.65497503e-02f, 1.66705891e-01f, 1.09161235e-01f, -7.15518370e-02f, 8.78978819e-02f, 8.53095502e-02f, -1.17102554e-02f, 3.18980999e-02f,
  2.09574644e-02f, 2.33698077e-02f, -9.45550427e-02f, -1.74250916e-01f, 6.07086122e-02f, 5.62638417e-02f, 7.74346963e-02f, -2.09082384e-02f, 2.30518039e-02f, 1.84251443e-01f,
  3.87509130e-02f, 7.71544948e-02f, 1.20397449e-01f, 2.34207474e-02f, 2.03865811e-01f, 1.71345100e-02f, 1.86595637e-02f, 3.77461985e-02f, -4.63041440e-02f, -3.82897966e-02f,
  7.72136226e-02f, 1.50452852e-01f, 9.75281745e-03f, 8.25096294e-02f, -2.04829425e-02f, 4.08474579e-02f, -9.14239697e-03f, 2.92657018e-02f, 6.69769794e-02f, 2.46982232e-01f,
  2.04298422e-01f, -3.56959254e-01f, 2.28274107e-01f, 1.90817326e-01f, 1.43334016e-01f, 2.65677214e-01f, 4.72287871e-02f, 1.29969493e-01f, 1.31012648e-01f, 3.46810818e-02f,
  5.26054576e-02f, -9.66105703e-03f, -2.40108315e-02f, 6.04850277e-02f, 7.20734075e-02f, 2.94621326e-02f, 7.62255713e-02f, 1.12037160e-01f, 1.77335024e-01f, 1.00857660e-01f,
  -1.48941919e-01f, -1.71948895e-01f, -7.41481259e-02f, 6.02921878e-04f, -3.99968587e-02f, -6.57025725e-02f, -6.21803803e-04f, 7.24196360e-02f, 7.16131367e-03f, -1.27321199e-01f,
  7.68461749e-02f, 1.76581796e-02f, 1.02378674e-01f, 3.47234681e-02f, 2.21380349e-02f, -6.24062819e-03f, 3.89198437e-02f, -1.20316274e-01f, 2.96676606e-02f, -6.45985901e-02f,
  8.04684535e-02f, -8.71017501e-02f, -4.74100150e-02f, 1.48569439e-02f, 2.08171667e-03f, 8.16728994e-02f, 2.36304440e-02f, -5.27962781e-02f, -2.63737533e-02f, -5.71650565e-02f,
  -1.52572066e-01f, 1.52258664e-01f, 2.14156836e-01f, 1.88547641e-01f, 1.37455061e-01f, 1.83509842e-01f, -1.29576130e-02f, -4.00276259e-02f, 1.58082023e-01f, -1.14501202e-02f,
  1.53888687e-01f, -5.42777628e-02f, 3.20936441e-02f, -1.55390222e-02f, 3.95189337e-02f, 1.77086487e-01f, 6.37680218e-02f, 1.00677468e-01f, 7.53643140e-02f, -1.87829696e-02f,
  2.24716011e-02f, 1.46574602e-01f, -2.12235935e-02f, -2.88318116e-02f, 4.94740962e-04f, -1.50023565e-01f, -4.75364700e-02f, -4.74015325e-02f, 7.55687356e-02f, -9.57575813e-02f,
  3.28704715e-02f, 4.79111820e-02f, -7.44928420e-02f, -4.34693061e-02f, -1.98197756e-02f, 1.85351998e-01f, -5.24758268e-03f, 8.20590649e-03f, 1.50121804e-02f, -9.52642858e-02f,
  -2.08213463e-01f, 2.14073390e-01f, -1.26796700e-02f, -1.90513581e-01f, -2.98357029e-02f, -1.06717065e-01f, -9.32116956e-02f, -3.73643078e-02f, -6.02765828e-02f, -6.08000048e-02f,
  -8.12030286e-02f, -8.99491236e-02f, -2.05727816e-02f, -1.18794844e-01f, 1.51676033e-02f, 2.89480854e-02f, -1.74425587e-01f, -6.81697764e-03f, 1.99295357e-02f, -9.99660417e-02f,
  -1.48887530e-01f, 1.50376469e-01f, 7.71870837e-02f, 1.79582700e-01f, 1.03323296e-01f, 1.60572678e-01f, 1.15855783e-01f, 1.10961720e-01f, 7.14669451e-02f, 3.02760433e-02f,
  -2.69195199e-01f, 9.57027227e-02f, -1.18342385e-01f, 1.38593584e-01f, -1.18156895e-02f, 9.12697390e-02f, 1.18549608e-01f, 8.09401944e-02f, 9.24507156e-02f, -1.99503880e-02f,
  -1.09008215e-01f, 1.09476624e-02f, 8.65681693e-02f, 1.33865446e-01f, 7.34005645e-02f, 6.55685812e-02f, 2.39355907e-01f, 1.12339064e-01f, -1.00641601e-01f, -9.51965433e-03f,
  1.02036849e-01f, -2.37671775e-03f, -1.01572119e-01f, 1.02945283e-01f, 7.93780535e-02f, 9.19214934e-02f, -1.34690655e-02f, -2.23806407e-02f, 2.83719096e-02f, 3.72470915e-01f,
  -2.58618265e-01f, -2.24722743e-01f, 1.71646606e-02f, -1.69807091e-01f, -1.25412837e-01f, -1.19498476e-01f, 6.00810675e-03f, -8.85540247e-02f, 6.38350323e-02f, 4.98755947e-02f,
  7.34273866e-02f, 3.53406444e-02f, 1.60455972e-01f, -5.38141169e-02f, -5.05964383e-02f, -1.34255499e-01f, 3.48885469e-02f, 6.14525042e-02f, -1.67717524e-02f, -1.23812757e-01f,
  2.02460542e-01f, -3.08327936e-02f, -2.11892918e-01f, -1.15287401e-01f, 4.08164710e-02f, -1.15988500e-01f, -5.35998717e-02f, -8.44016671e-02f, -2.37404913e-01f, -1.40567720e-02f,
  -3.27890813e-02f, -1.08882658e-01f, 6.34180829e-02f, 7.21609816e-02f, 7.36872703e-02f, 7.41645647e-03f, 1.46449789e-01f, 1.20457716e-01f, 6.13647513e-02f, -2.54952759e-02f,
  3.31541449e-02f, -8.78636092e-02f, -9.89709795e-02f, -8.81733000e-03f, 1.42200187e-01f, 2.10610647e-02f, 4.38497066e-02f, -8.98637697e-02f, -1.17595755e-01f, -3.47906612e-02f,
  1.01974450e-01f, 2.68703736e-02f, -1.08417504e-01f, 1.68131247e-01f, 1.34615814e-02f, -7.42740780e-02f, -1.19520470e-01f, -3.01271416e-02f, -1.26537896e-04f, -1.59910008e-01f,
  -7.41491243e-02f, -2.69340485e-01f, -1.01809978e-01f, 1.34158609e-02f, -4.56959493e-02f, -1.04562551e-01f, 1.10702068e-02f, -4.48017009e-02f, -8.55940282e-02f, -1.09193787e-01f,
  -2.02679977e-01f, 3.70686054e-02f, 1.21134873e-02f, -2.24185977e-02f, -9.96890143e-02f, -6.90199435e-02f, 1.28225237e-02f, 2.85874028e-02f, 7.13784248e-02f, -5.96749261e-02f,
  1.66717693e-01f, -1.14874586e-01f, -1.43977478e-01f, -8.11462849e-02f, 6.67076558e-02f, -9.49440300e-02f, -1.34899735e-01f, -1.26932368e-01f, -2.51466691e-01f, -1.60014510e-01f,
  -4.74748760e-01f, 3.07331085e-01f, -8.52736980e-02f, -3.07229161e-01f, -2.58211434e-01f, -1.93836138e-01f, 1.38917252e-01f, -3.53114568e-02f, -1.24626286e-01f, 2.66092628e-01f,
  1.14182182e-01f, -1.13648266e-01f, 3.55349630e-02f, 1.22587113e-02f, -3.41686718e-02f, 4.28263173e-02f, -1.16393611e-01f, -3.44077229e-01f, -4.54339653e-01f, -1.62994355e-01f,
  -1.94599122e-01f, -3.80065024e-01f, -4.40535694e-01f, -2.50308514e-01f, -1.23194873e-03f, -1.71421707e-01f, -4.06221636e-02f, -2.95049846e-01f, -2.13239744e-01f, -1.00113101e-01f,
  8.34766328e-02f, -2.62463123e-01f, 4.39477414e-02f, -5.60927112e-03f, 1.15303420e-01f, 6.29802346e-02f, -7.07003027e-02f, -2.51958836e-02f, 7.30816498e-02f, 1.61048576e-01f,
  -1.80169835e-03f, 7.65706748e-02f, 6.77196495e-03f, -2.38211080e-02f, -9.58445668e-02f, -3.60251926e-02f, 5.77103868e-02f, -9.54357535e-02f, 7.76062831e-02f, 8.65528658e-02f,
  4.52420898e-02f, -1.94710903e-02f, 1.25604406e-01f, 1.83314055e-01f, 5.99737726e-02f, -7.55404904e-02f, 8.80708173e-02f, 7.56226927e-02f, 4.57997210e-02f, 1.44774735e-01f,
  9.18873176e-02f, 5.00246994e-02f, 4.08141986e-02f, -7.29453808e-04f, 1.07224189e-01f, 1.08022489e-01f, 2.46779751e-02f, 1.49592102e-01f, 7.94019029e-02f, 1.83358923e-01f,
  1.78282529e-01f, -1.36301378e-02f, 2.76963525e-02f, 2.11677179e-02f, 2.02682000e-02f, -6.90662116e-02f, -2.00837292e-02f, 7.14524537e-02f, 2.46914066e-02f, -9.41653103e-02f,
  -8.63263980e-02f, -7.74381980e-02f, -6.16157539e-02f, -2.20718775e-02f, 3.85755263e-02f, -8.83389711e-02f, 1.97374877e-02f, 1.64279398e-02f, -4.23212722e-02f, -5.24938554e-02f,
  1.91186830e-01f, -2.17267200e-01f, 9.54273269e-02f, -9.59671661e-03f, -5.41014550e-03f, -5.90141816e-03f, -8.32111537e-02f, -1.43212691e-01f, -1.06171101e-01f, -4.42083292e-02f,
  -2.89447736e-02f, -6.23000525e-02f, 1.87946428e-02f, 1.43030033e-01f, -6.60926327e-02f, 2.06534509e-02f, -1.72506720e-02f, 5.25392629e-02f, -2.53745299e-02f, 5.81115782e-02f,
  1.28741071e-01f, -2.17845608e-02f, 1.60357624e-01f, 9.79538485e-02f, 9.63665545e-02f, -2.97410972e-02f, 1.95393488e-01f, 1.00533776e-01f, 3.12960707e-02f, 1.63185224e-01f,
  3.50766890e-02f, -3.51498276e-01f, 1.31928846e-01f, 2.62149006e-01f, 2.00387031e-01f, 1.38488546e-01f, -5.23006395e-02f, 4.58392203e-02f, 9.50156525e-02f, -6.19315580e-02f,
  -9.25768632e-03f, 1.07854322e-01f, -4.50075865e-02f, 8.02123845e-02f, -5.48968874e-02f, 6.33011088e-02f, 1.53739646e-01f, 1.52127221e-01f, 1.30355835e-01f, 2.65985653e-02f,
  2.01066695e-02f, -1.00433007e-01f, -2.00982019e-03f, -6.53479770e-02f, 2.50041317e-02f, 1.15895770e-01f, 2.26297434e-02f, 7.15383589e-02f, -3.71171460e-02f, 1.60560608e-01f,
  -8.55723098e-02f, -1.59906089e-01f, 4.76131588e-02f, 4.69093993e-02f, -7.57090747e-02f, -1.10797539e-01f, 6.45130947e-02f, -1.04822680e-01f, -1.08041819e-02f, -7.96002895e-02f,
  -4.54438739e-02f, -4.79770117e-02f, -6.76047727e-02f, -9.26156044e-02f, -1.43495919e-02f, -1.11209013e-01f, -1.41719118e-01f, -1.19180806e-01f, -1.94293391e-02f, -8.45247135e-02f,
  -1.17550818e-02f, 8.42579454e-02f, 1.23541420e-02f, -1.56843383e-02f, -1.19794365e-02f, 7.28164762e-02f, -4.43026833e-02f, -1.44708127e-01f, -7.65264705e-02f, -5.09334989e-02f,
  -1.00733250e-01f, 4.98443767e-02f, 7.78618455e-02f, -4.37358059e-02f, -3.86839211e-02f, 1.26242548e-01f, 4.18830775e-02f, 4.09176685e-02f, 7.50303119e-02f, -2.23032702e-02f,
  -3.03719360e-02f, 8.39487091e-02f, 5.58532216e-03f, 9.37628299e-02f, 1.16788998e-01f, 8.73607323e-02f, 1.37598187e-01f, -9.62935612e-02f, 1.22297540e-01f, 6.26255795e-02f,
  1.91571712e-02f, 4.75510843e-02f, -5.09470887e-02f, -9.60056707e-02f, -3.94933820e-02f, 1.00571260e-01f, 9.12691057e-02f, -8.19212198e-02f, 2.69132629e-02f, -4.57858779e-02f,
  -1.17263898e-01f, 1.47349954e-01f, 2.14408889e-01f, 3.54173034e-02f, 1.35256216e-01f, -1.04544297e-01f, 1.68514669e-01f, 5.60262613e-02f, 8.38034153e-02f, 1.08597130e-01f,
  -9.13607553e-02f, -5.06096892e-02f, -8.53097141e-02f, -4.47248966e-02f, 5.89003339e-02f, 7.15885907e-02f, 3.44397426e-02f, 9.25156623e-02f, -3.90849374e-02f, -3.35611366e-02f,
  -1.07136756e-01f, 1.01003900e-01f, 1.82898208e-01f, 9.97529179e-02f, 8.78663063e-02f, 2.14481145e-01f, 7.97437876e-02f, -7.76139740e-03f, 8.56046041e-04f, 7.40519390e-02f,
  -2.05390170e-01f, -1.51618958e-01f, -2.67933547e-01f, -8.95643532e-02f, -9.37648565e-02f, -1.26887977e-01f, -2.55640030e-01f, -1.06336482e-01f, -4.26055901e-02f, -1.38502657e-01f,
  3.34284715e-02f, -6.90184981e-02f, -1.82462886e-01f, -1.86134756e-01f, -3.93193305e-01f, -3.92061025e-01f, -2.60434538e-01f, -3.64038587e-01f, -3.75116408e-01f, -1.39561400e-01f,
  -2.98171222e-01f, -3.77550185e-01f, -3.27978075e-01f, -2.45328948e-01f, -6.03490993e-02f, -1.15917563e-01f, -2.67995685e-01f, -3.31038356e-01f, -2.95570135e-01f, -1.61565259e-01f,
  -6.78781047e-02f, 1.56604126e-01f, 9.08965021e-02f, 1.22028857e-01f, 5.14599308e-02f, 6.58500269e-02f, 5.47701269e-02f, 9.71734151e-02f, 1.63412079e-01f, 1.43408582e-01f,
  -4.39690240e-03f, 3.31668630e-02f, 7.23345280e-02f, 2.70441212e-02f, 8.48374516e-02f, 1.04066163e-01f, 1.51238263e-01f, 9.56326574e-02f, 3.01002944e-03f, 1.67616010e-01f,
  6.28854260e-02f, 3.37092020e-02f, 7.20487558e-04f, 1.20124519e-01f, 1.11644121e-03f, 3.61109301e-02f, 8.95652846e-02f, 1.88189015e-01f, 7.94207454e-02f, 1.78850722e-02f,
  -1.56035379e-01f, -1.73510388e-02f, 4.06815521e-02f, -6.70447247e-03f, 3.95275950e-02f, 5.78369275e-02f, 2.07389295e-02f, -7.20046088e-02f, -6.97289929e-02f, -3.16936038e-02f,
  1.52586743e-01f, 1.13834478e-01f, -1.17236553e-02f, -1.17831491e-02f, -1.38543090e-02f, 4.99376468e-02f, 3.09075955e-02f, 8.64675269e-02f, 5.75478412e-02f, 1.08324647e-01f,
  1.16688654e-01f, 6.90510422e-02f, 4.18240912e-02f, 2.02598386e-02f, -9.95050929e-03f, 3.00579667e-02f, -3.91503498e-02f, -3.17179039e-02f, 1.24153215e-02f, -4.56463322e-02f,
  9.96160135e-02f, -1.35478944e-01f, 1.06683150e-01f, 2.32874081e-02f, -4.47582267e-02f, 9.94870216e-02f, 2.95977830e-03f, 1.11332588e-01f, 4.51692976e-02f, 6.41995817e-02f,
  -7.17242062e-03f, -5.53611256e-02f, 7.28934407e-02f, 1.13420516e-01f, -3.08676320e-03f, 1.75897758e-02f, 1.48091793e-01f, 4.39998023e-02f, 8.13130885e-02f, 1.03191122e-01f,
  1.23714313e-01f, 5.28674759e-02f, 5.21660894e-02f, 3.26083191e-02f, -1.89454537e-02f, -1.00529917e-01f, 4.91141118e-02f, 6.20715469e-02f, -1.20695986e-01f, -1.55520335e-01f,
  3.40519249e-01f, -7.17734620e-02f, 1.73268929e-01f, 9.58274454e-02f, 6.89515993e-02f, -1.29892454e-01f, -1.27524480e-01f, -1.07278086e-01f, 9.14223585e-03f, 8.57630819e-02f,
  8.22220072e-02f, 4.71931286e-02f, 1.96289927e-01f, 1.25467658e-01f, 1.49356395e-01f, -3.45212668e-02f, 1.00601979e-01f, 2.36133546e-01f, 2.92867292e-02f, 5.91920763e-02f,
  9.70428735e-02f, 1.18617296e-01f, 1.54936120e-01f, 1.44810393e-01f, 1.03089534e-01f, 1.63760692e-01f, 1.06033310e-01f, 4.65647392e-02f, 2.96649914e-02f, 2.02101335e-01f,
  -8.17771815e-03f, 1.01384833e-01f, -9.54011679e-02f, 2.12534070e-02f, 9.47059318e-02f, 1.93929989e-02f, 1.53341284e-02f, -8.83312821e-02f, -5.44448011e-02f, -9.17441249e-02f,
  2.56751180e-02f, 6.87867461e-04f, -3.14886980e-02f, 4.32195663e-02f, -3.76655534e-02f, -9.29120034e-02f, 9.71140787e-02f, 8.13862309e-02f, -8.48553423e-03f, -8.11254382e-02f,
  1.09749123e-01f, -7.02785552e-02f, -1.47879586e-01f, 5.78164356e-03f, 6.65506674e-03f, 7.42971078e-02f, -6.39666393e-02f, -4.20797877e-02f, 1.78163536e-02f, -4.06844951e-02f,
  2.10238770e-01f, 7.64275342e-02f, 5.93394786e-02f, 2.02129737e-01f, 2.47941494e-01f, 1.14462405e-01f, 3.22571676e-03f, 1.02760658e-01f, 5.26879393e-02f, 9.14607272e-02f,
  -4.85561267e-02f, 8.06615725e-02f, -6.18650205e-02f, 1.21937869e-02f, 4.94627561e-03f, 1.01743601e-01f, -5.87765984e-02f, -6.09384216e-02f, -7.58748269e-03f, -1.06874943e-01f,
  -1.57975350e-02f, 8.55591428e-03f, 3.49564962e-02f, -4.40215208e-02f, -3.45493481e-02f, 1.18334293e-01f, 1.00951888e-01f, 4.09021080e-02f, 1.34452090e-01f, 1.80325639e-02f,
  -2.98287749e-01f, -6.98204041e-02f, 3.11402176e-02f, -1.11337416e-01f, 3.22711766e-02f, -3.53880599e-03f, -3.23543660e-02f, -2.35625226e-02f, -7.87394680e-03f, -1.03885323e-01f,
  -1.21779338e-01f, 1.94779001e-02f, 5.32824136e-02f, -9.47361141e-02f, -1.47097155e-01f, -1.31507754e-01f, -3.00398115e-02f, -6.02840562e-04f, -2.92519592e-02f, -1.06219999e-01f,
  -1.60272211e-01f, -2.65629709e-01f, -2.79962271e-01f, -8.24998766e-02f, -1.32592231e-01f, -1.03539146e-01f, -1.32369846e-01f, -4.65355851e-02f, -9.86970216e-02f, -2.08791673e-01f,
  -2.26216510e-01f, -1.22936226e-01f, -3.52009475e-01f, -2.66757369e-01f, -4.40120548e-02f, 7.44681358e-02f, 8.94331932e-02f, 7.36756772e-02f, -5.96237667e-02f, -1.43070906e-01f,
  1.12498123e-02f, 1.55798614e-01f, 3.76956090e-02f, 1.03221998e-01f, 2.59352416e-01f, 1.03466781e-02f, 9.33818221e-02f, 4.68229912e-02f, 1.37824431e-01f, 6.19904809e-02f,
  1.24756254e-01f, -1.08747818e-01f, 4.30489033e-02f, 8.78856257e-02f, -2.21452504e-01f, -1.20484596e-02f, -1.23916663e-01f, -1.05145194e-01f, 2.09721439e-02f, -1.43208191e-01f,
  -2.48253599e-01f, -2.38740757e-01f, 5.20363078e-02f, 1.23359874e-01f, -1.67856783e-01f, 1.26499727e-01f, 5.22309467e-02f, -1.78535208e-01f, 2.72340234e-02f, -1.27947018e-01f,
  -1.16448887e-01f, 9.17372629e-02f, -1.18106537e-01f, -7.24957213e-02f, -1.32312968e-01f, -1.03033952e-01f, -2.89295744e-02f, -9.05264765e-02f, -3.21237519e-02f, -1.28132850e-01f,
  5.14680967e-02f, -1.67542189e-01f, -2.33613193e-01f, 2.04354748e-02f, -3.55086066e-02f, 1.02133462e-02f, -1.41745389e-01f, -1.89688638e-01f, -3.68192978e-02f, -2.75852591e-01f,
  -8.10982734e-02f, -3.95521000e-02f, -3.67155373e-02f, -4.69926409e-02f, 8.10262710e-02f, -7.69511983e-02f, 2.99984794e-02f, 2.68368181e-02f, -6.00898117e-02f, -1.62847131e-01f,
  1.79890152e-02f, 2.24424712e-02f, 2.78723333e-02f, -8.48019645e-02f, 5.62593760e-03f, -3.26504447e-02f, -2.13378742e-02f, 1.36320491e-03f, -8.44205618e-02f, 5.32462820e-02f,
  -8.25900934e-04f, -8.23715294e-04f, -3.77093926e-02f, 1.33779153e-01f, 1.19944245e-01f, 4.11404893e-02f, -5.63896485e-02f, -5.73155619e-02f, 6.09688200e-02f, 7.85716996e-03f,
  -4.72132452e-02f, 2.16676697e-01f, -9.31969509e-02f, 1.22546770e-01f, -4.80375253e-02f, -1.62757598e-02f, 5.94367757e-02f, 1.57601178e-01f, 1.31626755e-01f, -4.36896384e-02f,
  -1.08646490e-01f, -3.26149724e-02f, -5.99774681e-02f, 2.93865260e-02f, 1.28359884e-01f, 6.17203303e-02f, 1.74678579e-01f, 1.00163698e-01f, 1.04922466e-01f, -1.36364639e-01f,
  -2.23757401e-02f, -7.30087422e-03f, 3.76676545e-02f, 3.49384211e-02f, 6.28897548e-03f, 1.06147215e-01f, -9.80083868e-02f, -8.27663615e-02f, 1.68655232e-01f, -6.46212250e-02f,
  -2.33262137e-01f, -5.38661480e-01f, 3.12915057e-01f, -9.66932178e-02f, 3.22570115e-01f, 3.77880067e-01f, 3.02684307e-01f, 7.69746974e-02f, -1.13092177e-01f, -2.82559684e-03f,
  -4.02389050e-01f, -3.60458821e-01f, -3.65635395e-01f, -1.50263041e-01f, -1.26938805e-01f, 2.53998131e-01f, 2.30615616e-01f, 2.90272892e-01f, 3.64293218e-01f, 1.60905778e-01f,
  -5.91541342e-02f, -1.59380212e-02f, -1.54257163e-01f, -4.31100130e-02f, -1.01543568e-01f, -1.26790464e-01f, -1.17260357e-02f, -4.19232296e-03f, -8.08180124e-02f, -1.31518468e-01f,
  1.42020226e-01f, -3.16766232e-01f, 3.08990106e-02f, -1.44505724e-01f, -1.95424389e-02f, -3.75187807e-02f, -6.05416074e-02f, -9.68786627e-02f, -8.49392712e-02f, 7.19742253e-02f,
  7.58725731e-03f, -7.25108609e-02f, 5.83714014e-03f, 8.79896805e-03f, 7.40956590e-02f, 6.02426268e-02f, -9.57129374e-02f, -1.96091041e-01f, -1.47202194e-01f, -3.84633429e-02f,
  -1.82042271e-01f, -9.03304070e-02f, 2.43215915e-02f, 3.61910723e-02f, -1.13280624e-01f, 5.98916858e-02f, -5.15727734e-04f, 1.78365837e-04f, -1.03098355e-01f, -1.95857454e-02f,
  1.23398207e-01f, -7.92249665e-03f, -5.12568392e-02f, -1.94393843e-02f, -5.62441461e-02f, -8.31007119e-03f, 5.56481183e-02f, -4.31872485e-03f, -1.54306348e-02f, -3.70928869e-02f,
  -3.24963182e-02f, -5.02516441e-02f, -5.45677654e-02f, -1.56727098e-02f, -9.11591202e-02f, -9.22862291e-02f, -4.67483327e-02f, -4.66280468e-02f, -1.21042162e-01f, -2.77464949e-02f,
  -1.42186821e-01f, -1.85156073e-02f, 6.76834509e-02f, 3.56405079e-02f, -1.32820919e-01f, 5.36110718e-03f, -9.38489810e-02f, -4.33527827e-02f, -4.20176424e-02f, -2.82879081e-02f,
  -2.50892013e-01f, -1.93751425e-01f, 4.58529107e-02f, -5.38096018e-02f, -6.08990341e-02f, -2.14508027e-02f, -1.52588427e-01f, 6.23845458e-02f, -3.94942351e-02f, 8.46547335e-02f,
  2.64768563e-02f, 4.87866532e-03f, -7.25148171e-02f, -1.58045534e-02f, 1.96395427e-01f, 1.59587875e-01f, -5.98993413e-02f, -1.01213157e-02f, -1.44234924e-02f, 4.90428917e-02f,
  -4.98467758e-02f, 1.46366492e-01f, 1.23111159e-01f, 1.36693016e-01f, 4.31419834e-02f, 1.22982427e-01f, 1.71410769e-01f, 2.16868222e-01f, 2.08226562e-01f, 2.42302179e-01f,
  -2.23373711e-01f, -1.60048038e-01f, 1.25339687e-01f, 3.79053466e-02f, 1.02258146e-01f, -1.68005288e-01f, -3.73487473e-01f, -2.74313360e-01f, 2.39333813e-03f, -6.00016750e-02f,
  2.15271190e-01f, 2.47360542e-01f, 7.58749694e-02f, -1.04050308e-01f, -4.60976094e-01f, -3.72651696e-01f, -2.36804545e-01f, -2.58074880e-01f, -3.48758817e-01f, -2.19373494e-01f,
  1.43533852e-02f, -1.13457881e-01f, -1.74669147e-01f, -1.27245590e-01f, 1.57220230e-01f, 1.79689169e-01f, 1.65766716e-01f, 1.25495225e-01f, 1.99822113e-02f, 9.49013606e-02f,
  6.12550676e-02f, -3.95008028e-02f, -6.94540218e-02f, 5.99334436e-03f, 1.73609108e-01f, -1.51231855e-01f, -1.03000533e-02f, 3.61879691e-02f, -8.35394301e-03f, -5.30231837e-03f,
  1.74986109e-01f, -3.44259180e-02f, 6.13040105e-02f, 4.25262786e-02f, -1.62773386e-01f, -1.74577996e-01f, -1.59936816e-01f, -2.64280885e-01f, -1.77082241e-01f, 1.21568181e-02f,
  1.17508009e-01f, 1.37588590e-01f, -1.73674539e-01f, -2.22159520e-01f, -1.12989381e-01f, 6.37017190e-02f, -8.75993520e-02f, -8.68713930e-02f, -2.01000899e-01f, -1.27678290e-01f,
  4.36272360e-02f, 1.43846884e-01f, 4.32911962e-02f, -3.74334753e-02f, 7.36537203e-02f, 4.28934507e-02f, 1.01905510e-01f, -1.06742950e-02f, 1.12195037e-01f, -5.69171607e-02f,
  2.25532036e-02f, 1.50573789e-03f, 2.90291682e-02f, -1.14081532e-01f, 4.46216986e-02f, -3.09717506e-02f, -9.17346179e-02f, -1.16474934e-01f, -1.61051854e-01f, 6.57927766e-02f,
  5.30675463e-02f, -5.07531799e-02f, 1.99450567e-01f, -9.05062929e-02f, 4.49732579e-02f, -3.96262184e-02f, 1.40338272e-01f, -7.61359632e-02f, -1.99120063e-02f, -4.56972644e-02f,
  -3.71697769e-02f, -7.35959038e-02f, 5.76632470e-02f, -1.79777175e-01f, 7.89954737e-02f, 7.76081830e-02f, 1.82247788e-01f, -4.45817895e-02f, 9.47760418e-02f, -3.65035906e-02f,
  -1.17366895e-01f, -6.81313127e-02f, 2.58698333e-02f, -5.69803547e-03f, -1.38996452e-01f, 3.01083401e-02f, -1.55210853e-01f, -1.53406467e-02f, -9.09748450e-02f, 1.09914266e-01f,
  -9.17213857e-02f, -1.80893943e-01f, -2.86999166e-01f, -2.36275107e-01f, -7.65383318e-02f, -1.09143741e-01f, -1.45022869e-01f, -6.92088008e-02f, -2.36225337e-01f, -4.11106557e-01f,
  -4.89153355e-01f, -2.21623123e-01f, -9.70555767e-02f, -5.32572687e-01f, -2.40365505e-01f, -1.41360655e-01f, -1.17253490e-01f, -1.39451817e-01f, -3.83846939e-01f, -2.49189273e-01f,
  -7.23510757e-02f, 1.43285692e-01f, 7.81142414e-02f, 1.96423493e-02f, 1.17113397e-01f, -1.46099806e-01f, -3.07049155e-01f, -8.22917596e-02f, 1.88057408e-01f, 3.12506817e-02f,
  -1.50675178e-01f, -1.79173455e-01f, -1.46389768e-01f, -4.50886879e-03f, -2.19619304e-01f, -1.78664941e-02f, -9.49511677e-02f, -1.20074242e-01f, -2.07951311e-02f, -2.42868245e-01f,
  2.28520602e-01f, -2.55393088e-01f, -3.82163152e-02f, -7.56605789e-02f, -4.30588014e-02f, -5.50402440e-02f, -2.98156459e-02f, -1.35836795e-01f, -4.95956279e-02f, -1.61476344e-01f,
  -7.52340034e-02f, -9.14167762e-02f, -4.25372683e-02f, 1.00911491e-01f, -1.11802518e-01f, -1.28583118e-01f, -9.29175541e-02f, -1.36515841e-01f, -1.62523255e-01f, 3.00798193e-02f,
  -1.75904930e-01f, -1.24086648e-01f, 1.11763924e-01f, -2.19925065e-02f, 4.68375795e-02f, -3.40097584e-02f, 6.04568720e-02f, 1.61124393e-02f, -1.17148459e-02f, -2.09611773e-01f,
  1.03426911e-03f, 3.57422903e-02f, 9.85775143e-03f, -2.76514031e-02f, -3.59559022e-02f, 1.64318345e-02f, 5.94114996e-02f, 2.71184724e-02f, -9.90196876e-03f, 1.24815322e-01f,
  -3.13360915e-02f, 6.43790653e-03f, 1.00754760e-01f, 3.86203751e-02f, 3.29450555e-02f, -6.91720620e-02f, -5.21861203e-02f, -8.89040604e-02f, 2.37633847e-02f, 5.54673746e-02f,
  7.11895823e-02f, -2.73271967e-02f, -7.47926980e-02f, 1.06734701e-01f, -9.56835318e-03f, -3.31696868e-02f, -1.11258984e-01f, 4.10086587e-02f, -3.63912508e-02f, -1.06565572e-01f,
  1.82177454e-01f, -5.11015579e-02f, -6.39846250e-02f, 1.05925547e-02f, -1.24388346e-02f, -3.09161991e-02f, -5.59667386e-02f, 5.47370985e-02f, 7.65064955e-02f, 4.35863025e-02f,
  3.51638719e-02f, 3.15375626e-02f, 2.76873950e-02f, 1.10079259e-01f, -3.19501273e-02f, -1.24392603e-02f, -3.34576853e-02f, -4.35911641e-02f, 8.47830847e-02f, 7.45207146e-02f,
  -3.03707216e-02f, -7.49827176e-02f, 1.68217495e-01f, 1.43150568e-01f, 4.07443009e-02f, 1.29765853e-01f, 1.37463734e-01f, 1.50814503e-01f, 3.40043940e-02f, -2.69235633e-02f,
  -2.87950456e-01f, -1.63912892e-01f, 1.31244153e-01f, -3.25906634e-01f, -2.04043940e-01f, -2.51106061e-02f, -2.98936591e-02f, -2.69856602e-01f, -3.03175181e-01f, 7.52488244e-03f,
  1.09344363e-01f, 2.79268742e-01f, 2.97084242e-01f, 1.09561756e-01f, 1.83589265e-01f, -1.57324467e-02f, -3.26032117e-02f, 1.19020738e-01f, 1.16646461e-01f, -6.17466904e-02f,
  -1.27030268e-01f, -2.21390411e-01f, -2.41567791e-01f, -2.91752279e-01f, -2.95514494e-01f, -7.73914754e-02f, -1.13351829e-01f, -2.81338215e-01f, -1.01608880e-01f, -1.77124172e-01f,
  3.02739978e-01f, -2.86547959e-01f, -4.74359095e-02f, -1.52937338e-01f, -7.84769654e-02f, -8.24174192e-03f, 7.56660104e-02f, -7.40799159e-02f, -1.05461746e-01f, -7.13849962e-02f,
  -4.67786677e-02f, -6.09888472e-02f, 6.11022115e-03f, 3.81420031e-02f, -1.33540317e-01f, -3.46068367e-02f, -1.18358761e-01f, -8.97602141e-02f, -8.10486823e-02f, 8.48926082e-02f,
  4.22100313e-02f, 2.50691120e-02f, -1.85135398e-02f, -4.30224612e-02f, 7.75095308e-03f, 3.39700133e-02f, -1.13188736e-02f, -9.09660012e-02f, -1.77481882e-02f, -1.41493291e-01f,
  -3.45105790e-02f, -2.64878385e-02f, -4.02676649e-02f, -2.23716628e-02f, -2.22962946e-02f, -6.48709983e-02f, 3.20677436e-03f, 1.17129385e-01f, 2.70992261e-03f, -2.71793623e-02f,
  -9.63135362e-02f, -1.83311515e-02f, -1.78990457e-02f, -5.98924607e-02f, 2.52960678e-02f, 5.61342277e-02f, 3.79192121e-02f, -4.01745290e-02f, -2.70538870e-02f, -1.21631913e-01f,
  -7.45041817e-02f, -7.53005594e-02f, -4.57304195e-02f, 1.17620081e-02f, -1.59414988e-02f, -4.80842451e-03f, 7.88982809e-02f, 2.53597014e-02f, 5.23944013e-02f, -3.23073864e-02f,
  2.03990027e-01f, 9.95297581e-02f, 1.29476815e-01f, -5.45791052e-02f, -1.30052879e-01f, -2.37793531e-02f, 9.79910512e-03f, -5.77459857e-02f, -5.78182228e-02f, 7.26182386e-02f,
  -8.20261315e-02f, 5.61528578e-02f, 4.05249931e-02f, -1.99240204e-02f, -3.81099619e-02f, 3.04827653e-02f, -4.23456430e-02f, 1.04074590e-01f, 2.98492908e-02f, 1.84630118e-02f,
  -1.32911608e-01f, 2.72950474e-02f, 2.27780879e-01f, 3.64784561e-02f, -4.03350480e-02f, 1.21610597e-01f, 9.88007262e-02f, 5.27846105e-02f, 1.96262777e-01f, 1.45295158e-01f,
  6.30414009e-01f, 1.96178555e-02f, -6.78472161e-01f, 1.68895781e-01f, -1.79609314e-01f, -2.00175107e-01f, -2.87856370e-01f, -3.13356593e-02f, 2.07531452e-01f, 2.91703381e-02f,
  -1.85958982e-01f, 5.99794947e-02f, -9.97326747e-02f, -1.78421006e-01f, -2.27124602e-01f, -2.78371274e-01f, -2.49652520e-01f, -2.79705048e-01f, -2.22224832e-01f, -5.88083416e-02f,
  2.23615736e-01f, 2.52195567e-01f, 1.24594592e-01f, 9.93980691e-02f, 8.62146635e-03f, -3.52334529e-02f, -3.08869362e-01f, -6.05876483e-02f, -1.23809688e-01f, -1.56180665e-01f,
  -4.45526361e-01f, -1.59780160e-01f, -2.26019159e-01f, 9.68019813e-02f, -2.98471004e-02f, 4.84893136e-02f, 3.02415527e-02f, -1.04454597e-02f, 6.98527321e-02f, -8.87561366e-02f,
  -1.58526868e-01f, -4.10762383e-03f, -3.33211124e-02f, -1.89722553e-02f, 3.49472463e-02f, 2.63199285e-02f, 6.18614480e-02f, -5.29547594e-02f, -5.72951101e-02f, -1.07686132e-01f,
  3.41979377e-02f, -2.20764801e-01f, -2.08933696e-01f, -1.08965218e-01f, -2.03876019e-01f, -2.12825820e-01f, -2.24645361e-01f, -1.49635687e-01f, -2.53046960e-01f, 1.97568417e-01f,
  2.51398329e-02f, -8.96107480e-02f, -6.05532527e-03f, 5.92906922e-02f, 1.41804576e-01f, -2.85042133e-02f, 4.93416116e-02f, 6.74017146e-02f, 2.07162369e-02f, 7.27044269e-02f,
  4.32294607e-02f, -3.44766490e-02f, 6.72365446e-03f, -1.47634149e-02f, -6.83743730e-02f, -1.16921134e-01f, 8.22296888e-02f, -4.23394851e-02f, 3.65870148e-02f, -3.02028470e-02f,
  -7.20538374e-04f, -1.72057256e-01f, -2.45687850e-02f, 4.54680808e-02f, -9.17109847e-02f, 2.29418259e-02f, -1.87873654e-02f, 8.62240791e-02f, -3.70766222e-02f, -4.51980196e-02f,
  1.98858827e-01f, -1.30149186e-01f, 4.48743366e-02f, -2.74948459e-02f, -6.99121971e-03f, -2.54257191e-02f, -3.72653715e-02f, 1.03665866e-01f, 9.50914994e-02f, 8.75414014e-02f,
  -4.14293930e-02f, 4.56495583e-02f, -5.36665879e-02f, 7.63532966e-02f, -1.12308590e-02f, -4.03053798e-02f, 1.79046169e-01f, -3.69676575e-02f, -4.93662953e-02f, 1.89211920e-01f,
  1.94516867e-01f, -1.10809261e-03f, 2.22070575e-01f, 1.87499374e-02f, 1.02556318e-01f, 1.26260132e-01f, -8.97531211e-02f, -1.67263765e-02f, -8.59015249e-03f, 3.41160208e-01f,
  4.14316535e-01f, -3.04125428e-01f, -2.34000966e-01f, -1.37114927e-01f, -1.09660879e-01f, -6.42271787e-02f, -5.31875305e-02f, -7.51426294e-02f, -1.42504320e-01f, -1.50034159e-01f,
  8.72760825e-03f, 3.66186589e-01f, 1.49965122e-01f, 2.03355953e-01f, 2.23051205e-01f, -2.26853043e-01f, -2.35895663e-01f, 7.77578205e-02f, 3.15654844e-01f, -7.63477106e-03f,
  1.12404497e-02f, -1.30839348e-01f, 8.10609758e-02f, -9.29620638e-02f, -2.57108182e-01f, -3.81210111e-02f, -4.45431501e-01f, -2.46735856e-01f, -2.08145395e-01f, -3.53178412e-01f,
  1.47017792e-01f, 2.32803263e-02f, 1.51318368e-02f, 9.01375152e-03f, -1.73823789e-01f, -2.55733691e-02f, -2.01971047e-02f, -1.19054787e-01f, -2.00051460e-02f, -9.54506472e-02f,
  -5.83688319e-02f, -1.23048909e-02f, -1.66852456e-02f, -1.48253841e-02f, -4.23270417e-03f, 2.38109678e-02f, -1.59506500e-01f, 3.83397490e-02f, -8.38790089e-02f, -1.46503538e-01f,
  -6.58622012e-02f, 4.18423451e-02f, 7.38850087e-02f, -4.72731628e-02f, -3.14828306e-02f, 4.88734432e-02f, -1.53971121e-01f, -7.92684779e-02f, 5.65215480e-03f, -1.69197574e-01f,
  5.16165048e-02f, 3.86952120e-03f, -4.86110710e-02f, -1.02523513e-01f, -2.63779983e-03f, 7.39517994e-03f, 4.30905670e-02f, 2.16129757e-02f, 5.77980056e-02f, 8.63814901e-04f,
  -7.28619099e-02f, -6.82689026e-02f, 6.21202476e-02f, -6.58215731e-02f, 3.91830765e-02f, -5.81674762e-02f, 4.83929031e-02f, 5.45778237e-02f, 3.79451402e-02f, 4.37450334e-02f,
  3.96675281e-02f, -2.97307782e-02f, 1.56615451e-02f, 2.90542748e-02f, -6.23307340e-02f, 2.08045244e-02f, 3.16977501e-03f, -2.43150536e-02f, 1.18611366e-01f, -1.33783231e-02f,
  1.53006881e-01f, 2.10645478e-02f, 3.37205976e-02f, 2.22296864e-02f, -9.45047438e-02f, -8.60169828e-02f, -5.49709536e-02f, 9.69626456e-02f, -7.33267292e-02f, -1.10363953e-01f,
  1.71063188e-02f, 8.74308497e-02f, -2.93954574e-02f, -1.29665449e-01f, -3.16119157e-02f, 3.25459726e-02f, -9.61367507e-03f, 1.26311973e-01f, 1.00035481e-01f, -1.11947298e-01f,
  -2.50346232e-02f, 7.51927197e-02f, 2.56963372e-01f, 4.05560471e-02f, 1.97603945e-02f, 1.88611582e-01f, 2.51334975e-03f, 8.11053216e-02f, 1.53681040e-01f, 7.76304677e-02f,
  -4.36329871e-01f, 3.66778225e-01f, -1.17088504e-01f, -4.13308799e-01f, -1.33338809e-01f, 2.05878258e-01f, 3.47500682e-01f, 5.69641627e-02f, -2.43780389e-02f, 2.22283691e-01f,
  1.52359486e-01f, -1.70665190e-01f, -3.23050097e-02f, 2.14763712e-02f, 6.44020364e-02f, 3.10428649e-01f, -1.21131092e-02f, -2.48518974e-01f, -2.55464315e-01f, 1.41009204e-02f,
  3.17992046e-02f, -1.94209829e-01f, -3.02891433e-01f, -1.59088835e-01f, -1.10967383e-01f, -1.51093751e-01f, -1.44434363e-01f, -1.70340046e-01f, 8.15444812e-03f, -8.69747996e-02f,
  -5.60827218e-02f, -1.79747328e-01f, -1.38457417e-01f, -2.33682208e-02f, -1.19588800e-01f, -1.19771332e-01f, 9.43457894e-03f, -2.00351685e-01f, -7.71225318e-02f, 2.75375247e-02f,
  -1.20376468e-01f, -8.51542428e-02f, -1.21558607e-01f, -6.59565181e-02f, -2.11737603e-01f, -1.37913525e-01f, -2.88251583e-02f, -8.69044736e-02f, -6.19736277e-02f, 1.47663325e-01f,
  1.00760676e-01f, -6.42202199e-02f, -7.43800178e-02f, 6.51311576e-02f, 8.59406739e-02f, -6.79161474e-02f, -2.36311257e-02f, -1.76096670e-02f, -9.63290185e-02f, -7.18804076e-02f,
  7.77762011e-02f, 3.63692679e-02f, -1.22716062e-01f, -1.36439517e-01f, 6.71276748e-02f, -2.56525036e-02f, -5.56838475e-02f, 1.13494456e-01f, 1.28172291e-02f, 3.66348214e-02f,
  3.68721522e-02f, -8.00313242e-03f, -1.00162979e-02f, -6.24749735e-02f, 2.59552374e-02f, -7.22063333e-02f, 8.75355527e-02f, -1.40715921e-02f, -8.07254855e-03f, -2.07956787e-02f,
  -5.36290146e-02f, 4.05085534e-02f, -4.05409709e-02f, -5.61547726e-02f, 1.00687936e-01f, -2.12538708e-02f, 4.61346209e-02f, 4.15401198e-02f, 2.31748745e-02f, -3.14091682e-03f,
  -2.51925945e-01f, 3.34809311e-02f, -2.28789411e-02f, -2.98659764e-02f, -1.13199331e-01f, -3.75762433e-02f, -6.27406826e-03f, 3.08557842e-02f, -1.51428998e-01f, -8.36587232e-03f,
  8.67671371e-02f, -3.70755009e-02f, -4.66940105e-02f, -6.70158118e-02f, -1.31033570e-01f, -4.00937744e-04f, 1.15261607e-01f, -5.16188256e-02f, 1.87407881e-02f, 4.97233719e-02f,
  1.46140262e-01f, 1.48321077e-01f, 4.22789194e-02f, -2.80415025e-02f, 5.55489734e-02f, -8.49390700e-02f, 6.79223165e-02f, -1.27039449e-02f, 6.50533512e-02f, 2.36548945e-01f,
  -3.28295261e-01f, -2.35047668e-01f, 2.82747559e-02f, 3.08984071e-01f, 3.65934908e-01f, 6.20827749e-02f, 4.12721047e-03f, -6.15989752e-02f, 1.02360487e-01f, 1.11028083e-01f,
  1.58013180e-01f, 1.72323719e-01f, 2.20196426e-01f, 1.77487656e-01f, -1.70687530e-02f, 1.15867183e-01f, 6.26385063e-02f, 8.50057304e-02f, 2.55234931e-02f, 8.69997740e-02f,
  2.09286854e-01f, -6.67767301e-02f, -6.18310608e-02f, -6.58704862e-02f, 1.59526125e-01f, 2.41648227e-01f, 6.00808188e-02f, 5.99236786e-02f, 8.13173428e-02f, 1.34061456e-01f,
  6.68413267e-02f, -2.22724929e-01f, 2.14980051e-01f, -6.36616303e-03f, 3.50916944e-02f, -1.94911927e-01f, -9.39180627e-02f, -3.58179994e-02f, -4.63057645e-02f, -1.18097395e-01f,
  -3.55974212e-02f, -1.01663783e-01f, 6.71708137e-02f, 1.17118061e-02f, -2.10756138e-01f, -5.72784990e-02f, -1.66911960e-01f, -1.36987031e-01f, 2.28667315e-02f, -5.52585721e-02f,
  9.48135853e-02f, 8.97115171e-02f, -2.30795089e-02f, -8.54636133e-02f, -1.21668186e-02f, 6.93955719e-02f, -1.95530474e-01f, -1.08527608e-01f, -1.93034351e-01f, -2.52255708e-01f,
  -2.88232230e-02f, -9.69559103e-02f, -1.74244959e-02f, -1.06754296e-01f, 4.66047265e-02f, -9.26790107e-03f, 5.43371513e-02f, 3.75375599e-02f, 1.29593490e-02f, -4.94793840e-02f,
  1.15837798e-01f, 5.19188382e-02f, 1.09409643e-02f, -5.89058138e-02f, 9.03246626e-02f, -6.74449801e-02f, -2.34588366e-02f, 2.74050602e-04f, -1.96854621e-02f, -6.15972430e-02f,
  1.22361956e-02f, 7.70946220e-02f, -5.79807796e-02f, -1.92259345e-02f, 6.09409288e-02f, -2.13249102e-02f, 4.46227714e-02f, -3.45459627e-03f, -7.16259629e-02f, -4.69567291e-02f,
  3.40654105e-02f, 1.22602589e-01f, 1.90324336e-01f, 3.41707431e-02f, 1.48297371e-02f, -6.48974925e-02f, 1.05181836e-01f, 8.44100639e-02f, 8.04353133e-03f, 7.49159604e-02f,
  -8.50562751e-02f, -9.29718092e-02f, 3.20587046e-02f, 6.49750419e-03f, -2.37369090e-02f, -5.38806058e-02f, -8.42052251e-02f, 1.66576952e-01f, 8.15295577e-02f, 3.03927879e-03f,
  1.26015395e-01f, -1.60747543e-02f, 6.04351610e-02f, 2.12163478e-02f, -2.23302469e-02f, 1.07199162e-01f, -7.48375878e-02f, 4.13237177e-02f, -7.24269375e-02f, -1.91584215e-01f,
  4.66128513e-02f, 1.77542806e-01f, -1.20443523e-01f, 2.02576831e-01f, 8.23526271e-03f, -3.24657410e-01f, -2.81778127e-01f, -1.26193166e-01f, 1.84032440e-01f, 7.78819844e-02f,
  1.36028752e-01f, 5.29064611e-02f, 1.60117239e-01f, -1.40678763e-01f, -4.87161338e-01f, -1.99464917e-01f, -2.07559600e-01f, -2.24775359e-01f, -3.26377273e-01f, -2.67837226e-01f,
  -1.31871030e-01f, -5.68990484e-02f, -1.74713820e-01f, -1.19660003e-02f, 2.01035336e-01f, 1.49816662e-01f, 2.46607020e-01f, 7.60743618e-02f, -1.82114065e-01f, 2.49424130e-01f,
  1.82369426e-01f, -6.98693246e-02f, -5.92609346e-02f, -1.90991372e-01f, 6.23532273e-02f, 8.41672998e-03f, -6.01837821e-02f, 4.68550250e-02f, -1.98783223e-02f, -3.67766507e-02f,
  -4.27438393e-02f, -1.48674995e-01f, -7.28697628e-02f, 4.36504371e-02f, -1.48949638e-01f, -1.19769387e-01f, -1.98669825e-02f, -1.30677015e-01f, -9.97402295e-02f, 6.34438768e-02f,
  -5.47919888e-03f, 1.43760862e-02f, -2.61237472e-02f, -7.99951255e-02f, -6.80828318e-02f, -5.17629534e-02f, 6.47855997e-02f, 3.15115042e-02f, -2.33340755e-01f, 3.36314023e-01f,
  -4.05731201e-02f, -2.46482231e-02f, -8.60181898e-02f, 4.27684300e-02f, 4.79519628e-02f, 1.11789275e-02f, 5.28040603e-02f, 7.68232420e-02f, -3.91461961e-02f, 6.92749470e-02f,
  -6.56365454e-02f, -5.99936508e-02f, 1.47162499e-02f, 6.67071529e-03f, -3.56596150e-02f, -4.79395501e-02f, 4.40449081e-02f, -2.02306155e-02f, -1.11319080e-01f, 9.18440893e-02f,
  -2.07207799e-02f, 5.25145195e-02f, 6.76327571e-02f, 1.52861541e-02f, 2.53649820e-02f, 7.90548399e-02f, -3.03017423e-02f, -6.00548461e-02f, 8.49560741e-03f, -8.18653777e-02f,
  2.07468972e-01f, -2.07296580e-01f, 1.96600467e-01f, -1.27091810e-01f, -9.04566944e-02f, 6.36582449e-02f, 6.95670694e-02f, 2.46321186e-02f, -6.04431098e-03f, 3.84720452e-02f,
  -1.24567240e-01f, 3.34865153e-02f, 1.04925998e-01f, 4.27801767e-03f, -5.44797368e-02f, 3.81868519e-02f, -5.56342900e-02f, -4.06869985e-02f, -1.95053041e-01f, 2.90850345e-02f,
  1.00323789e-01f, -7.41342083e-02f, -9.16075259e-02f, 2.86664497e-02f, 2.69146245e-02f, -6.91853613e-02f, 1.55787095e-01f, 8.70677307e-02f, -2.18285218e-01f, 2.58223295e-01f,
  -4.70314652e-01f, -1.38767257e-01f, 1.41169606e-02f, 2.09823042e-01f, 2.69233465e-01f, 2.27324754e-01f, 1.62775174e-01f, 1.32816136e-01f, 2.65117347e-01f, 1.62503213e-01f,
  1.78090632e-01f, 3.02503109e-01f, 3.30897629e-01f, 2.16898039e-01f, 1.11544169e-01f, 2.36350670e-01f, 2.95782685e-01f, 1.22463144e-01f, 5.33964634e-02f, 1.18218008e-02f,
  2.52368510e-01f, 6.60285130e-02f, 3.36683430e-02f, 1.12269267e-01f, 1.61327422e-01f, 2.68129885e-01f, 2.00737372e-01f, 4.85219583e-02f, 2.04641581e-01f, 1.82927787e-01f,
  9.76974666e-02f, -1.44724980e-01f, 1.67452261e-01f, 5.52324690e-02f, -1.26511129e-02f, -8.54788348e-02f, 4.67364825e-02f, -6.05502985e-02f, 2.38601002e-03f, 6.83538318e-02f,
  2.77642836e-03f, -1.09105565e-01f, 2.37764022e-03f, 5.49537577e-02f, -1.86047908e-02f, -5.52628599e-02f, -7.35783428e-02f, 1.04254872e-01f, 7.98177645e-02f, 3.89473070e-03f,
  6.37492537e-02f, -2.81134062e-02f, 3.00006773e-02f, 7.86722749e-02f, 7.85729066e-02f, 3.82621586e-02f, 6.77573867e-03f, -8.47381353e-02f, 8.26625526e-02f, -6.46319017e-02f,
  1.70229599e-01f, -2.00854540e-02f, 1.43655434e-01f, 9.33169201e-02f, -5.15900999e-02f, 5.95378689e-02f, 1.18126823e-02f, 8.67725983e-02f, 1.35929108e-01f, -2.81285886e-02f,
  1.50365829e-01f, 1.56044498e-01f, 5.91255911e-02f, 8.63185748e-02f, 1.43410534e-01f, 2.12565660e-02f, 3.14364843e-02f, 3.98840010e-02f, 9.57166627e-02f, 1.05001479e-01f,
  8.80097374e-02f, -9.09877867e-02f, -1.23497064e-03f, -4.33883481e-02f, -2.90954057e-02f, 6.63817599e-02f, 5.68801863e-03f, 1.21169373e-01f, 1.89135168e-02f, -7.13397563e-02f,
  3.64884794e-01f, 3.24636728e-01f, -3.74499783e-02f, -9.58724767e-02f, -1.32310599e-01f, -1.10308252e-01f, 4.87844981e-02f, -5.54883629e-02f, -4.03948203e-02f, -9.52979028e-02f,
  -5.53003997e-02f, -1.65914789e-01f, -1.11743614e-01f, -9.05840620e-02f, -1.46237925e-01f, -4.78049144e-02f, -1.12404497e-02f, -6.24986626e-02f, 1.08687520e-01f, -6.29326608e-03f,
  2.71059368e-02f, -1.91170536e-02f, 2.94732787e-02f, 8.73058215e-02f, 4.98108529e-02f, 8.52269903e-02f, -6.56803921e-02f, -1.09663315e-01f, -1.04152504e-02f, -6.36040494e-02f,
  6.55978084e-01f, 2.75291592e-01f, 3.49631310e-01f, 1.47796825e-01f, 6.83884323e-02f, 1.65139958e-01f, 2.07714796e-01f, 1.72497928e-01f, 2.57345755e-02f, 1.15102574e-01f,
  1.53483495e-01f, 1.10889994e-01f, 3.85465436e-02f, -1.51409609e-02f, 1.56484678e-01f, 8.45554247e-02f, 6.76990449e-02f, 1.94979459e-01f, 1.66408002e-01f, 1.32212311e-01f,
  5.80468364e-02f, 1.90954342e-01f, 2.87294000e-01f, 1.28796428e-01f, 1.07050538e-02f, -1.04320720e-02f, 4.62809345e-03f, 1.62862718e-01f, 1.13898344e-01f, 9.84518453e-02f,
  3.07170033e-01f, 3.79589230e-01f, -1.77709833e-01f, -1.39976844e-01f, -6.03649653e-02f, -1.52473280e-03f, -1.97692085e-02f, -7.72121623e-02f, -4.90275100e-02f, -3.51442285e-02f,
  -9.36248899e-02f, 1.58692412e-02f, -1.36119397e-02f, -1.15387522e-01f, -2.85956915e-02f, -5.87910526e-02f, 1.20256245e-02f, -9.32100322e-03f, -1.18350416e-01f, -3.24649736e-02f,
  -2.11940199e-01f, -5.48332557e-02f, -4.00738865e-02f, -5.75944856e-02f, -4.68657799e-02f, 1.56687982e-02f, 6.92968220e-02f, 1.32567924e-03f, 7.93697536e-02f, 7.62449056e-02f,
  -1.41574368e-01f, 7.17034638e-02f, 6.56766668e-02f, 9.58772898e-02f, 2.05348939e-01f, 1.36667669e-01f, -5.06896786e-02f, -5.15479967e-03f, -2.82857083e-02f, 4.52614874e-02f,
  -2.87148822e-02f, 1.12442739e-01f, 4.84226309e-02f, -7.92562217e-03f, -7.17525482e-02f, 1.55564677e-02f, 3.05464561e-03f, -5.66233881e-02f, -5.17776273e-02f, -3.28087769e-02f,
  1.99059639e-02f, 8.05794448e-02f, 1.07907400e-01f, -3.14993560e-02f, 8.58343542e-02f, -3.41878794e-02f, 5.86810745e-02f, 2.22390983e-02f, -3.38408612e-02f, 2.97129136e-02f,
  -3.12919289e-01f, -6.95265979e-02f, 4.49680723e-03f, -7.99995884e-02f, -5.36185317e-02f, -7.55006894e-02f, -4.91979420e-02f, -1.09483395e-02f, -4.75416258e-02f, -6.99795336e-02f,
  -5.89535981e-02f, 6.80498034e-02f, -2.89328676e-03f, -6.60120547e-02f, 3.33787724e-02f, -2.35688258e-02f, -5.54359145e-03f, -5.21424636e-02f, -9.79396328e-02f, -6.83508292e-02f,
  -1.24413192e-01f, -8.79940093e-02f, 7.69872358e-03f, -5.70597351e-02f, -1.86175499e-02f, -5.56467399e-02f, 2.03568712e-02f, 2.90648080e-02f, -6.42032251e-02f, 1.14893029e-03f,
  1.24040723e-01f, 1.01695262e-01f, -1.68166250e-01f, 1.01621963e-01f, -1.44281000e-01f, -1.75074577e-01f, -2.50611424e-01f, 1.19458809e-01f, 1.48502037e-01f, -8.91128182e-02f,
  -2.10500993e-02f, 2.62268156e-01f, 1.57045469e-01f, 5.91001846e-03f, -9.26484838e-02f, -1.86253056e-01f, -2.79426277e-01f, -1.57241762e-01f, -1.19116686e-01f, -6.69001490e-02f,
  -1.62355423e-01f, -1.16205201e-01f, -7.02764988e-02f, -7.83712417e-02f, 8.42859522e-02f, -7.71205127e-02f, -1.74239591e-01f, -1.62781715e-01f, -2.35488176e-01f, -2.57080466e-01f,
  -4.21354659e-02f, 2.45086364e-02f, -6.46033883e-02f, -1.47382051e-01f, -1.23811498e-01f, 3.16621736e-02f, -2.08007693e-02f, 1.96527280e-02f, -4.81241979e-02f, -8.11037049e-03f,
  -7.79626369e-02f, -7.60030746e-02f, -6.91616312e-02f, -3.61778550e-02f, -9.35938656e-02f, -1.81949008e-02f, -8.66391324e-03f, -1.34868743e-02f, -1.09712616e-01f, -1.19843505e-01f,
  -7.25773051e-02f, -1.55268043e-01f, 6.09849915e-02f, 1.87534411e-02f, -1.21958675e-02f, -3.13823298e-02f, 3.23242769e-02f, -1.29798139e-02f, -1.74558178e-01f, 6.98403865e-02f,
  9.22437534e-02f, 1.55566126e-01f, -6.66287020e-02f, 5.72658218e-02f, 1.27623752e-02f, -5.85406236e-02f, -3.01967338e-02f, 6.57467637e-03f, -1.35080114e-01f, 1.02238230e-01f,
  3.01847365e-02f, -3.20106037e-02f, 7.28099719e-02f, -5.06150834e-02f, -1.19157180e-01f, -4.40786704e-02f, -4.35776971e-02f, -5.51191270e-02f, -1.39174253e-01f, -1.07464910e-01f,
  -9.25133079e-02f, -5.60152344e-02f, -1.97949428e-02f, -1.38880923e-01f, -7.81206861e-02f, -3.86161916e-02f, -4.49593104e-02f, 6.09556176e-02f, 5.11879437e-02f, 2.57585035e-03f,
  2.09281877e-01f, -1.87141493e-01f, -3.81487887e-03f, 3.23675387e-02f, -9.66362190e-03f, 6.17819764e-02f, 7.49539062e-02f, -9.71002951e-02f, 4.73770797e-02f, 9.18191150e-02f,
  -1.39039055e-01f, 1.07847631e-01f, -3.10039204e-02f, -2.37671915e-03f, -5.69579192e-02f, -4.48378846e-02f, -8.83934200e-02f, -4.27915081e-02f, -8.13655183e-02f, -2.16471571e-02f,
  -3.81160900e-02f, 8.73065181e-03f, 1.97920963e-01f, 6.01537414e-02f, 6.10671081e-02f, -7.98381213e-03f, 1.16076112e-01f, -1.56515911e-02f, -9.42527223e-03f, 8.27693045e-02f,
  5.16755879e-01f, 4.76645291e-01f, 2.34426439e-01f, 1.60071909e-01f, -1.62309900e-01f, -1.45600542e-01f, 2.75146142e-02f, 1.03514209e-01f, 1.58735029e-02f, 7.00624511e-02f,
  1.73357487e-01f, 4.05807868e-02f, 4.21456657e-02f, 1.37068331e-01f, 9.85693559e-02f, 1.01481490e-01f, -7.44955316e-02f, 1.16886102e-01f, 1.31579548e-01f, 9.21826363e-02f,
  2.49724146e-02f, 1.59399405e-01f, 2.96296805e-01f, 1.09119423e-01f, 2.17682585e-01f, -1.17938079e-01f, 2.30668820e-02f, -1.57575253e-02f, 1.26631171e-01f, 2.41007686e-01f,
  3.38256508e-01f, 3.20892692e-01f, -3.19806822e-02f, -6.58753421e-03f, 7.92443305e-02f, 2.14234605e-01f, 6.38873205e-02f, 1.49240401e-02f, 7.79297128e-02f, -7.45610818e-02f,
  2.75747068e-02f, 1.34153605e-01f, 1.93959493e-02f, 5.02551033e-04f, -7.71514028e-02f, -3.51202525e-02f, 9.46680605e-02f, -4.63219211e-02f, 1.54711185e-02f, 1.09057538e-01f,
  -1.03471717e-02f, 4.94752750e-02f, -3.76659259e-02f, -9.81351733e-02f, -1.41227901e-01f, -1.56999916e-01f, 5.23904748e-02f, 1.04612604e-01f, -1.49001461e-02f, -4.43619266e-02f,
  -7.37195313e-02f, 2.30473615e-02f, -5.26349135e-02f, -1.91609934e-01f, -1.41648948e-01f, -1.70657963e-01f, -9.96239483e-02f, -9.92163941e-02f, -1.91320911e-01f, -5.48883453e-02f,
  -1.52314276e-01f, -1.50243849e-01f, -7.51368329e-02f, -3.57134417e-02f, 1.02348790e-01f, 9.48606580e-02f, -3.91130336e-03f, 7.57486001e-02f, -1.71840176e-01f, -2.49750540e-03f,
  -6.99628815e-02f, 1.83221314e-03f, 1.68139823e-02f, -1.99800953e-02f, 1.57533982e-03f, -6.53361380e-02f, 2.89382432e-02f, -3.36925872e-02f, 4.39352393e-02f, -5.00740819e-02f,
  -5.49031645e-02f, -2.64722526e-01f, 3.68982204e-03f, 1.29471585e-01f, 2.32094582e-02f, 2.95019094e-02f, 9.33175348e-03f, 6.28969297e-02f, 9.80846062e-02f, 2.50830501e-02f,
  -4.33807028e-03f, 9.46184993e-02f, -4.64214152e-03f, -2.16518696e-02f, -9.50376615e-02f, -2.17453483e-02f, 5.50206788e-02f, 7.45832175e-02f, -3.91404219e-02f, 8.78633335e-02f,
  7.85307065e-02f, -3.12283374e-02f, -9.75982621e-02f, -1.34413972e-01f, -6.04250655e-02f, -1.62531324e-02f, -1.26467705e-01f, -3.87087539e-02f, -9.51692984e-02f, -1.63141079e-02f,
  4.45391059e-01f, 5.93470484e-02f, 2.65865147e-01f, 1.14756294e-01f, -2.68952996e-02f, -2.35990882e-01f, -1.89218089e-01f, -1.66834280e-01f, -7.80833811e-02f, 6.70856684e-02f,
  -1.94937401e-02f, -1.35646882e-02f, 1.25692207e-02f, -9.00337026e-02f, -5.87572232e-02f, -1.17133101e-02f, 1.65307254e-01f, 2.15567842e-01f, 1.00567095e-01f, 1.77008137e-01f,
  1.32506028e-01f, 6.85078502e-02f, 2.35243812e-01f, 6.58697188e-02f, 2.37267986e-01f, 8.27337131e-02f, 1.01944596e-01f, 1.55747414e-01f, 1.13332681e-01f, 2.12430671e-01f,
  2.66596735e-01f, 1.35165825e-01f, -8.39180797e-02f, -1.63153019e-02f, 3.67895961e-02f, 5.99170551e-02f, -4.63864803e-02f, 5.05188815e-02f, -1.34760544e-01f, -2.17346456e-02f,
  4.88528386e-02f, 5.91064990e-02f, -2.78780516e-02f, 1.17624201e-01f, 5.45490906e-02f, 6.74133189e-03f, 9.65949595e-02f, 1.33826345e-01f, -4.53254469e-02f, 5.09323180e-02f,
  1.02015495e-01f, 1.47952214e-01f, 5.82409129e-02f, -1.04849219e-01f, -2.30188984e-02f, 3.00181601e-02f, 3.27000162e-03f, 9.95672774e-03f, -2.61299293e-02f, 2.28699744e-01f,
  6.31230185e-03f, -2.51093302e-02f, 9.69023779e-02f, 1.31977722e-01f, 6.76542372e-02f, -1.50267202e-02f, 8.49037096e-02f, 6.39635473e-02f, 9.28198621e-02f, 2.17574149e-01f,
  7.86133334e-02f, -6.66934717e-03f, 1.31410494e-01f, 1.13832459e-01f, -8.69795773e-03f, 1.17903590e-01f, 1.72221452e-01f, 1.36055589e-01f, 6.39774948e-02f, -2.95838639e-02f,
  8.91375691e-02f, 5.59598170e-02f, 7.03177750e-02f, 6.19480386e-02f, 1.29680604e-01f, 1.39780357e-01f, 1.95539758e-01f, 2.61650719e-02f, 1.94860937e-03f, 1.20700628e-01f,
  -4.32846636e-01f, -2.10095018e-01f, 1.22480579e-01f, 8.45882222e-02f, 1.74550887e-03f, 6.82418942e-02f, 2.41027791e-02f, -1.30752362e-02f, -1.04223900e-01f, -6.21632254e-03f,
  -7.06755649e-03f, 2.76274700e-02f, -6.07798919e-02f, -7.30367303e-02f, 5.64424880e-02f, 1.94892078e-03f, 1.26657024e-01f, 5.82253970e-02f, -1.24764651e-01f, -7.23383054e-02f,
  -9.04922374e-03f, -1.32406503e-01f, -6.03542551e-02f, -2.08540246e-01f, -7.23334178e-02f, -1.13373384e-01f, -1.22470438e-01f, -9.87129193e-03f, -1.13484316e-01f, -1.50893986e-01f,
  -4.80907232e-01f, -3.16503346e-01f, -2.42933072e-03f, -3.75021607e-01f, -1.06333345e-02f, 1.83390319e-01f, 5.82726188e-02f, -7.34999478e-02f, -1.61915585e-01f, -2.27316350e-01f,
  7.64122978e-02f, 1.00438349e-01f, 4.72464822e-02f, 1.37907758e-01f, 1.50124550e-01f, -1.42174261e-02f, 1.48484968e-02f, 1.00715257e-01f, 3.47078830e-01f, 1.84181079e-01f,
  7.89011344e-02f, -5.19818068e-02f, 4.65449654e-02f, 1.08714752e-01f, -2.38574430e-01f, -3.35711725e-02f, -1.86255142e-01f, -8.86107385e-02f, -5.38677685e-02f, -3.10921520e-01f,
  -2.58790284e-01f, -2.25500330e-01f, 2.56111801e-01f, 1.39091924e-01f, 1.16793416e-01f, -1.83561459e-01f, -5.79800047e-02f, -4.14741971e-02f, -2.61557344e-02f, -6.99199811e-02f,
  -1.30344927e-01f, 1.47996396e-01f, -4.89443801e-02f, 1.56515557e-02f, -2.14065164e-02f, -3.26077528e-02f, 1.13812312e-01f, 9.67107043e-02f, -2.67508328e-02f, -6.93959966e-02f,
  4.69805002e-02f, -5.72081506e-02f, -1.74941808e-01f, 2.85088066e-02f, -9.55525190e-02f, -5.39986044e-02f, -1.25563502e-01f, -1.14729978e-01f, -1.27486974e-01f, -4.30357635e-01f,
  1.31072953e-01f, 5.32059856e-02f, 2.52827760e-02f, 6.87160566e-02f, -3.46529707e-02f, 1.44339381e-02f, -2.12223101e-02f, 1.15451008e-01f, 7.17037916e-02f, 1.17961308e-02f,
  -1.45063521e-02f, 1.12631969e-01f, -2.05645571e-03f, -1.27893671e-01f, -9.71166492e-02f, 3.90058458e-02f, -3.80799137e-02f, -2.20044944e-02f, -1.34673649e-02f, -6.27692603e-03f,
  -2.30358504e-02f, -2.63130851e-02f, 6.12680130e-02f, 3.03830635e-02f, 4.35653403e-02f, -7.88649922e-05f, -1.19618170e-01f, 4.30312455e-02f, -2.63230572e-03f, -1.18266292e-01f,
  -2.53682286e-01f, 1.87011182e-01f, -3.47711504e-01f, 5.02714403e-02f, -7.73189263e-03f, 3.93202454e-02f, -5.20030335e-02f, 1.64694190e-01f, -6.58598691e-02f, -7.99955577e-02f,
  7.88777098e-02f, -9.99606997e-02f, -1.75271273e-01f, 4.22420315e-02f, 1.21650755e-01f, -1.14050582e-01f, -4.35236543e-02f, -2.89218575e-02f, 4.83705625e-02f, -1.43506378e-01f,
  5.86396828e-02f, -1.40558898e-01f, -2.80966729e-01f, -1.16817832e-01f, -2.67167777e-01f, -1.79200903e-01f, -8.12586769e-02f, -1.31595880e-01f, -1.56345233e-01f, -4.74666297e-01f,
  4.00829494e-01f, 2.19632298e-01f, -2.05130931e-02f, 1.26919910e-01f, -3.39256048e-01f, -2.18584135e-01f, -2.85639614e-01f, -8.67057294e-02f, 1.85330033e-01f, 1.67063728e-01f,
  -8.98006484e-02f, -2.63535604e-02f, -3.59615982e-02f, 6.47794604e-02f, 7.46552786e-03f, 1.74401075e-01f, 2.07113773e-01f, 1.70893386e-01f, -1.22877330e-01f, -1.98692933e-01f,
  -9.39581767e-02f, -1.12354448e-02f, 1.52154654e-01f, 8.32195301e-03f, 2.34841764e-01f, 2.51591951e-02f, 9.15966630e-02f, 6.35689944e-02f, -5.95478341e-02f, 3.93318743e-01f,
  1.39229283e-01f, 3.52298655e-02f, -3.37867767e-01f, -9.54043120e-02f, -1.11512728e-01f, 2.35010475e-01f, 7.54257664e-02f, 9.29149985e-02f, -3.20132822e-02f, 2.34719545e-01f,
  6.26569092e-02f, 2.07931660e-02f, -1.01753836e-02f, 8.03859606e-02f, 1.67185571e-02f, 9.98753356e-04f, -5.28652035e-03f, 1.35125384e-01f, 8.28105211e-02f, -2.23536268e-02f,
  -1.27626117e-02f, -1.06204346e-01f, -1.79760054e-01f, -2.87625134e-01f, 5.71045885e-03f, -8.22287425e-02f, -4.72396947e-02f, -1.44671323e-02f, -2.33671274e-02f, 3.83571267e-01f,
  -4.83683385e-02f, 4.49128933e-02f, 1.22797407e-01f, 1.42525822e-01f, 7.93128461e-02f, 5.06659597e-02f, 4.76662666e-02f, -4.23316807e-02f, 1.11067824e-01f, 7.28809536e-02f,
  8.58751610e-02f, 3.28503847e-02f, -5.40909451e-03f, -7.96409994e-02f, -3.54197174e-02f, 6.10281713e-02f, -3.59652936e-02f, 1.77827701e-02f, -9.53934714e-02f, 9.77519825e-02f,
  -6.08123355e-02f, 1.46207111e-02f, 1.56487301e-02f, 9.59611088e-02f, -5.44228330e-02f, -5.31688631e-02f, 4.05883044e-02f, -6.48183972e-02f, -1.18779995e-01f, 9.93762314e-02f,
  -2.56197993e-02f, -4.38819438e-01f, 6.94828182e-02f, 1.05056472e-01f, -2.61577144e-02f, -1.58694848e-01f, -1.46628106e-02f, -3.82553674e-02f, 3.11143085e-05f, 1.01804890e-01f,
  -8.63573551e-02f, -2.13121846e-02f, 9.64160115e-02f, 4.94846590e-02f, 5.44878133e-02f, -5.36662564e-02f, -9.17922705e-02f, -1.04550138e-01f, -1.51293099e-01f, -6.23296686e-02f,
  -2.62314752e-02f, -1.53726816e-01f, -3.21052432e-01f, -1.54640883e-01f, -1.45351365e-02f, -3.59899908e-01f, -1.64229333e-01f, -1.67350590e-01f, -3.20309907e-01f, -6.58416450e-02f,
  1.59156606e-01f, 3.05702567e-01f, 1.53768407e-02f, 1.33528158e-01f, 2.35510945e-01f, 2.25141495e-01f, 3.05058151e-01f, 2.22084031e-01f, 7.96946883e-02f, 7.47337192e-02f,
  2.79264063e-01f, 1.59115627e-01f, 7.62516335e-02f, 5.91309480e-02f, 3.93981747e-02f, 5.28003462e-02f, 4.74305823e-02f, -9.49704349e-02f, 1.90337654e-02f, 1.67308554e-01f,
  2.71048516e-01f, 2.18340963e-01f, 1.65202767e-01f, 1.00023217e-01f, 6.55012429e-02f, 1.26017183e-01f, 2.16874316e-01f, 2.40989238e-01f, 2.09272638e-01f, 1.37551958e-02f,
  -1.69402793e-01f, 1.73682928e-01f, -3.03450793e-01f, -1.10093713e-01f, -2.32008658e-02f, -1.42603442e-01f, -7.49809220e-02f, -8.52686018e-02f, 4.62851599e-02f, -3.61922681e-02f,
  -7.51354173e-02f, 5.25791422e-02f, 5.16810305e-02f, 5.26507869e-02f, 6.58869967e-02f, -6.82836547e-02f, -1.09633572e-01f, -2.51799170e-02f, -6.84762374e-02f, -1.14209717e-02f,
  1.16505340e-01f, 2.43006162e-02f, -1.75344627e-02f, 3.29645793e-03f, 3.11225578e-02f, -4.11918424e-02f, 8.92823711e-02f, 2.03294531e-02f, -5.67726158e-02f, -1.56089425e-01f,
  -7.52157718e-02f, -3.33871208e-02f, -5.11550866e-02f, -3.16177085e-02f, 8.87128264e-02f, 5.00019826e-02f, -9.50132161e-02f, 1.73498541e-02f, -2.56064516e-02f, -3.34170945e-02f,
  -7.63831064e-02f, -1.19272821e-01f, -1.80216581e-01f, 5.44037335e-02f, 7.79194236e-02f, 3.28132138e-02f, -4.32621986e-02f, -1.42989933e-01f, -4.79087047e-02f, 7.89029226e-02f,
  6.61878567e-03f, -1.47733524e-01f, 4.86439764e-02f, -8.65255594e-02f, -5.84275089e-02f, -5.11234626e-02f, -6.51649460e-02f, 2.77497550e-03f, 4.79005985e-02f, 1.74780264e-01f,
  5.04888371e-02f, 2.27196246e-01f, -1.90454155e-01f, -1.38567969e-01f, -3.69802266e-02f, -3.16002518e-02f, 2.16072053e-02f, -1.25606477e-01f, 1.19721936e-02f, -1.98567309e-03f,
  6.09006844e-02f, -1.49960890e-01f, -2.81847380e-02f, -7.27140764e-03f, -3.38660404e-02f, -1.06868148e-01f, 1.77404284e-02f, -1.44330993e-01f, 4.90154978e-03f, -5.57410531e-02f,
  -9.89939496e-02f, -1.67151943e-01f, -2.33448192e-01f, -1.18086427e-01f, -1.62427396e-01f, -1.12554200e-01f, -7.04740360e-02f, -2.20599517e-01f, -1.72288731e-01f, -1.27542958e-01f,
  6.78845584e-01f, -2.54186839e-01f, -1.93060681e-01f, 2.74483204e-01f, -1.65737510e-01f, -1.27692237e-01f, -1.38575315e-01f, 7.85136148e-02f, 1.40328452e-01f, -1.41417250e-01f,
  -1.44748449e-01f, 2.08084472e-02f, 1.30789980e-01f, 4.52428386e-02f, 1.55011281e-01f, -5.50294220e-02f, -8.60546157e-02f, 1.03399247e-01f, 2.32772261e-01f, 3.51940952e-02f,
  -7.63024986e-02f, -3.67136300e-02f, 1.89398170e-01f, -1.22731356e-02f, -2.09310442e-01f, 1.97912715e-02f, -2.93784857e-01f, -1.13416925e-01f, -2.43078128e-01f, -2.92411804e-01f,
  -2.09792122e-01f, -1.30721673e-01f, -3.51998053e-04f, -3.07115493e-03f, -1.75102949e-02f, 7.00391531e-02f, -1.04833553e-02f, 6.59065694e-02f, 2.32497733e-02f, 2.43933275e-02f,
  -9.17593613e-02f, -2.57120728e-02f, -3.33118066e-02f, 2.91034114e-02f, -1.05855875e-01f, -7.47603476e-02f, 2.74092667e-02f, 3.36311832e-02f, 8.83147493e-02f, -6.90049678e-02f,
  -6.25943393e-02f, -3.77157889e-02f, -3.60385817e-03f, -6.83002844e-02f, 5.91939986e-02f, -1.74104869e-02f, -2.13331908e-01f, -1.01334237e-01f, 6.07405901e-02f, 2.23497376e-02f,
  5.70980236e-02f, 1.20049402e-01f, 1.66567508e-02f, -3.37591879e-02f, 2.02093981e-02f, 1.60970427e-02f, -2.25251988e-02f, -1.96903907e-02f, -8.29564109e-02f, 3.87198888e-02f,
  2.55372059e-02f, -5.30428812e-03f, -8.49165991e-02f, 1.30286030e-02f, -1.51600717e-02f, 3.09596714e-02f, 4.91463840e-02f, 1.11488262e-02f, -9.24879714e-05f, 1.16870098e-01f,
  8.82659331e-02f, -3.12451404e-02f, -6.33650497e-02f, 4.51970808e-02f, -5.41578382e-02f, -1.37254596e-02f, -4.15282249e-02f, 3.31418887e-02f, 3.60178202e-02f, 1.37639448e-01f,
  1.90631866e-01f, 4.99880277e-02f, 2.52793115e-02f, -9.84875835e-04f, 1.45015046e-02f, 4.97436486e-02f, -5.58844283e-02f, 2.39953827e-02f, -1.13564059e-01f, -7.07487091e-02f,
  -1.08343765e-01f, 1.39262781e-01f, -6.60377815e-02f, -7.00504482e-02f, 3.29645164e-02f, 3.34699079e-03f, 1.84385125e-02f, 1.14058934e-01f, 5.53426445e-02f, 5.57199270e-02f,
  1.81514733e-02f, 1.10891022e-01f, 2.65488952e-01f, 1.59661099e-01f, -1.80828315e-03f, 9.42918733e-02f, -7.77321383e-02f, 2.09589265e-02f, 6.56890571e-02f, 2.58109152e-01f,
  -3.87570113e-01f, -1.41156897e-01f, -1.32277980e-01f, 2.42453039e-01f, 2.43116662e-01f, -1.40723348e-01f, -4.68061239e-01f, -4.04435366e-01f, -4.57008602e-03f, -6.23765513e-02f,
  1.38430536e-01f, 3.46480131e-01f, 1.45230189e-01f, 3.42068709e-02f, -1.36788860e-01f, -1.27263904e-01f, 6.94794506e-02f, 1.03379123e-01f, -3.86474468e-02f, -5.42489067e-03f,
  1.58938155e-01f, 2.40322083e-01f, 6.88204169e-02f, 9.94057059e-02f, 2.65212655e-01f, 3.19100231e-01f, 5.03536873e-02f, 1.99232161e-01f, 1.20818406e-01f, 1.03264682e-01f,
  -3.02695841e-01f, -2.64512420e-01f, -5.54148592e-02f, 2.34691501e-01f, 7.38140345e-02f, -2.51451284e-01f, -1.85077965e-01f, -8.63047019e-02f, -9.55600515e-02f, -1.66001678e-01f,
  2.50715464e-01f, 2.46851575e-02f, 1.62032545e-01f, 6.44215345e-02f, 6.04902506e-02f, -1.45242333e-01f, -1.63988307e-01f, -2.31784776e-01f, -2.67764807e-01f, -2.38771051e-01f,
  2.49461114e-01f, 1.79544851e-01f, -1.83207959e-01f, -2.31065542e-01f, -3.86471987e-01f, 6.75224513e-02f, -2.14560479e-01f, -2.05282167e-01f, -3.41651469e-01f, -2.77468055e-01f,
  -2.81005111e-02f, -1.43174140e-03f, 3.12297288e-02f, -9.29291919e-02f, -2.87288688e-02f, -1.08545488e-02f, 1.04675265e-02f, -4.40960899e-02f, 5.99896722e-02f, -8.70307386e-02f,
  -5.26577868e-02f, -4.41304371e-02f, -7.55379796e-02f, -2.40037329e-02f, 1.90303668e-01f, -5.73786609e-02f, -2.69840918e-02f, -4.06490732e-03f, 1.66872114e-01f, -2.77664065e-02f,
  5.04058823e-02f, -3.38849463e-02f, 6.76426515e-02f, -4.50879335e-02f, 1.15279472e-02f, -6.44032583e-02f, -1.37289772e-02f, -4.96985801e-02f, -4.45684977e-02f, 2.98427907e-03f,
  3.76010314e-02f, 1.92313239e-01f, -1.96724504e-01f, -2.04638302e-01f, -2.99688764e-02f, 6.36914372e-02f, -7.47747496e-02f, -1.07327685e-01f, -5.20976111e-02f, -1.31152689e-01f,
  -4.51049097e-02f, -1.57062814e-01f, 9.41879973e-02f, -3.69157568e-02f, -1.11303218e-02f, 1.01239011e-01f, 1.90296009e-01f, 4.53430042e-02f, 1.56444851e-02f, -2.69662663e-02f,
  1.18442075e-02f, -3.95587534e-02f, -1.27059773e-01f, -1.67016953e-01f, -8.74024779e-02f, 4.72153835e-02f, -1.50440827e-01f, -1.76076815e-01f, -2.94428587e-01f, -2.73380756e-01f,
  -5.34040868e-01f, 1.14543915e-01f, 1.52583346e-01f, -1.30340621e-01f, 4.28130925e-02f, -9.24507976e-02f, 1.69513121e-01f, -5.93712814e-02f, -3.27574685e-02f, 2.31799766e-01f,
  -7.95616861e-03f, -2.83208162e-01f, -1.50349006e-01f, -1.82514802e-01f, -2.60579288e-01f, 2.01947600e-01f, -3.84116583e-02f, -2.08413959e-01f, -5.57560384e-01f, -3.82908940e-01f,
  -2.83068776e-01f, -2.41532564e-01f, -3.79416108e-01f, -6.44265488e-02f, 1.48291916e-01f, -1.10378869e-01f, 1.38141200e-01f, -6.29119501e-02f, -7.99353886e-03f, 3.91619131e-02f,
  2.88386911e-01f, -1.08719558e-01f, -6.08081222e-02f, -1.48325637e-01f, 1.64908051e-01f, 6.62276000e-02f, -2.60646362e-02f, 5.55219734e-03f, -5.51960021e-02f, 1.39407381e-01f,
  -1.42758369e-01f, -1.11377522e-01f, 3.77713442e-02f, 3.55033912e-02f, -1.29259378e-01f, -8.52205977e-02f, 4.30727610e-03f, -9.77819562e-02f, 3.01044360e-02f, 3.57698053e-02f,
  5.65149300e-02f, -1.91965997e-01f, -5.15219867e-02f, 1.07589386e-01f, -8.75739157e-02f, -1.51410550e-01f, 1.21570379e-01f, 3.12368274e-02f, 5.86274341e-02f, 2.63350070e-01f,
  9.68387723e-02f, 1.62661612e-01f, -2.60993838e-02f, -6.36643544e-02f, 2.23796852e-02f, -4.18366566e-02f, 2.89851874e-02f, 4.30529099e-03f, 4.62401658e-02f, -1.68121466e-03f,
  1.40392512e-01f, 2.22890154e-02f, 5.67338020e-02f, 6.39891624e-02f, 2.92085321e-03f, 5.78116579e-03f, -4.47640605e-02f, 4.92072552e-02f, 1.98968616e-03f, -2.83517465e-02f,
  -4.11842465e-02f, 2.24706829e-02f, 8.66973680e-03f, 3.40335742e-02f, -2.44287010e-02f, 4.05783094e-02f, -1.04039852e-02f, -9.37327594e-02f, -6.73178360e-02f, -5.69125563e-02f,
  1.74795151e-01f, -1.08011179e-01f, 6.93482384e-02f, -2.24144608e-02f, 1.49255916e-02f, 3.67098860e-02f, 8.77596214e-02f, 5.77637143e-02f, -8.27059820e-02f, -4.74144891e-02f,
  -1.31987631e-01f, -4.84899506e-02f, -1.39738172e-02f, 7.80122578e-02f, -4.99532036e-02f, -1.26822352e-01f, -7.82932900e-03f, -8.11876357e-03f, 3.61455418e-02f, 1.77819908e-01f,
  4.83178049e-02f, -4.53682691e-02f, 6.67498857e-02f, 6.65393472e-02f, 9.31494087e-02f, -5.23755662e-02f, 9.83885825e-02f, 1.03481829e-01f, -4.48976755e-02f, 3.03085893e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  3.00302356e-01f, 1.44211590e-01f, 2.50533760e-01f, -5.46127968e-02f, 4.12887275e-01f, 2.84456760e-01f, 2.35068992e-01f, 4.41540599e-01f, 3.73367012e-01f, 3.34043860e-01f,
  2.76081055e-01f, -5.31772263e-02f, -2.21827254e-02f, 2.49375984e-01f, 2.05916062e-01f, 1.85930640e-01f, 1.16675913e-01f, 5.29887378e-01f, 2.44160801e-01f, 4.86331999e-01f,
  1.32446975e-01f, 1.82200283e-01f, 2.17596710e-01f, 3.51697952e-01f, 1.70865059e-01f, 7.50400946e-02f, -9.98436706e-04f, 3.93450797e-01f, 9.77027342e-02f, 1.32744864e-01f,
  3.00671130e-01f, 3.31593245e-01f, 3.95192981e-01f, 1.75583988e-01f, 2.71864563e-01f, 3.14837575e-01f, 2.65349537e-01f, 1.93526328e-01f, 2.12861836e-01f, 1.71465710e-01f,
  1.73862755e-01f, 1.07377835e-01f, 2.93755293e-01f, 2.49589369e-01f, 6.30750135e-02f, 1.54620871e-01f, 2.08758384e-01f, 3.39002639e-01f, 3.31572175e-01f, 4.08264488e-01f,
  2.25679547e-01f, 2.22125158e-01f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -6.01177923e-02f, 4.41485606e-02f, 7.36410543e-02f, -6.73056990e-02f, -2.51827333e-02f, -8.54654014e-02f, -1.35035843e-01f, 8.38892609e-02f, -1.21957585e-01f, -4.30805348e-02f,
  -7.43553862e-02f, -2.26995219e-02f, 4.90784273e-02f, 1.83194891e-01f, 1.72210019e-02f, -1.99075773e-01f, -6.90022111e-02f, 8.25353637e-02f, -1.57391969e-02f, -9.88230705e-02f,
  -1.07127808e-01f, 1.43529937e-01f, -1.72537655e-01f, 5.74466847e-02f, 1.48596633e-02f, -1.31653652e-01f, 7.72273261e-03f, -1.18367523e-01f, 6.22982010e-02f, 3.09086412e-01f,
  4.86330921e-03f, 2.34076306e-01f, -1.65221319e-01f, -1.66364033e-02f, -9.77321789e-02f, -1.00270882e-01f, -8.21840912e-02f, -1.43024087e-01f, 1.60443097e-01f, -1.31836161e-02f,
  -7.51940459e-02f, 3.83817516e-02f, -2.85711065e-02f, 1.08686022e-01f, 1.69847488e-01f, 1.62566513e-01f, -1.37947232e-01f, -1.72874361e-01f, -1.22693785e-01f, -1.51370212e-01f,
  1.36968091e-01f, 8.99904072e-02f, -1.53335761e-02f, 6.08821809e-02f, -2.10716590e-01f, -2.76315063e-01f, -1.32389560e-01f, 1.17406346e-01f, 2.67185986e-01f, -1.02973670e-01f,
  -3.03581189e-02f, -9.38153565e-02f, 2.41899803e-01f, 2.95827478e-01f, 2.93948688e-02f, 5.24391271e-02f, 3.34148258e-02f, -5.07806093e-02f, 1.01141326e-01f, -5.44883385e-02f,
  -1.47167034e-02f, -5.67644984e-02f, -1.52301893e-01f, -4.64575328e-02f, -8.39592516e-02f, 2.30895922e-01f, -8.04914162e-02f, 2.29687840e-01f, 8.44052806e-02f, -1.50897205e-01f,
  -7.24652559e-02f, -1.90600067e-01f, 1.25140101e-01f, 7.27357492e-02f, 8.77454802e-02f, -1.76808052e-02f, -2.95725048e-01f, -1.58219591e-01f, -8.98238942e-02f, -7.51381144e-02f,
  -1.55303791e-01f, 1.22879446e-01f, 8.83635879e-02f, 6.06356226e-02f, 2.24270970e-01f, -1.70140862e-01f, 2.82073438e-01f, -1.10987434e-02f, 1.83440283e-01f, -7.50835910e-02f,
  -2.80804187e-02f, 8.37787315e-02f, 1.99076593e-01f, -6.38748109e-02f, -2.28849296e-02f, -1.41677380e-01f, 1.40970377e-02f, 3.32022496e-02f, 2.89174199e-01f, -5.98888770e-02f,
  7.26929978e-02f, 9.27483812e-02f, 1.62070990e-01f, 1.24793440e-01f, -6.27028793e-02f, 2.21246891e-02f, -3.51342969e-02f, 4.23121750e-02f, -5.62777147e-02f, 6.12583291e-03f,
  1.08629264e-01f, -3.08448169e-02f, -2.35769093e-01f, 5.21510765e-02f, -5.25208563e-02f, 2.71394521e-01f, 4.30407040e-02f, -8.91061686e-03f, -5.46583720e-02f, 2.52689403e-02f,
  1.45653442e-01f, -1.21730655e-01f, 1.10263182e-02f, -6.37269393e-02f, -6.36771396e-02f, -2.82982504e-03f, 2.88897846e-02f, 7.52956793e-02f, 4.80642729e-03f, 2.08655685e-01f,
  4.97193933e-02f, -1.47235423e-01f, -3.57322209e-02f, -1.93155810e-01f, 1.30634144e-01f, -1.69155627e-01f, -1.32807180e-01f, -9.87764820e-02f, -3.97176761e-03f, 2.66602099e-01f,
  -1.54724762e-01f, -1.68601960e-01f, 7.19484761e-02f, 9.18684751e-02f, -7.78553039e-02f, 2.11841837e-02f, 5.26301488e-02f, 2.70457089e-01f, 1.95469335e-03f, 6.44637570e-02f,
  -9.22877491e-02f, 1.41655385e-01f, 7.09122941e-02f, -3.09073001e-01f, 8.02538022e-02f, 1.13609731e-01f, -1.06088482e-01f, -6.96710423e-02f, 6.04493879e-02f, -3.03835124e-01f,
  -3.68774384e-02f, -2.04337433e-01f, 2.24787757e-01f, 3.35577019e-02f, 8.39222670e-02f, 4.98246290e-02f, 1.44354776e-02f, -1.66982159e-01f, -9.53795463e-02f, -1.18930615e-01f,
  7.88124502e-02f, -6.84385970e-02f, -1.41098425e-01f, -2.06983551e-01f, 5.38181737e-02f, 2.11235672e-01f, -2.43135095e-01f, 1.21255703e-01f, -1.30858332e-01f, -2.21694082e-01f,
  -9.39168260e-02f, 2.05530867e-01f, -7.18860775e-02f, 7.15847360e-03f, 6.50968328e-02f, 1.21337950e-01f, 9.25462469e-02f, 4.36722599e-02f, -2.09945992e-01f, 2.43950356e-02f,
  3.70859876e-02f, -1.51636779e-01f, -2.35674337e-01f, 7.36698806e-02f, 2.10987374e-01f, -4.31152098e-02f, 2.05915198e-02f, -4.14344519e-02f, 2.40027770e-01f, 1.93588540e-01f,
  -2.14103997e-01f, 1.82370320e-01f, 1.53406844e-01f, 2.82563746e-01f, 2.43708193e-01f, -1.86201468e-01f, -4.74668182e-02f, 1.12542454e-02f, -1.86582461e-01f, -7.01041743e-02f,
  1.25050759e-02f, 1.76391438e-01f, 3.51479985e-02f, -1.57457039e-01f, -7.59025216e-02f, -4.12437506e-02f, 1.06548741e-01f, -4.05151360e-02f, 1.06513545e-01f, 1.16168842e-01f,
  -3.98387313e-02f, 6.48423135e-02f, -1.56601563e-01f, 2.91746762e-02f, -8.23915154e-02f, -6.91477805e-02f, 2.29437754e-01f, 1.72247700e-02f, 8.94934013e-02f, 1.49223641e-01f,
  -2.23503411e-01f, -4.82085496e-02f, 8.23089574e-03f, -3.80832478e-02f, 2.65140031e-02f, -2.84849763e-01f, 1.59821257e-01f, -1.09323941e-01f, 7.80089945e-02f, 1.95889488e-01f,
  -2.53970139e-02f, 1.71129718e-01f, -2.56178193e-02f, -4.52940501e-02f, -1.85800582e-01f, 1.78845763e-01f, -2.06956454e-02f, 3.72364260e-02f, -1.06427275e-01f, 5.88184856e-02f,
  8.77273306e-02f, -8.64920393e-03f, 3.66918892e-02f, -1.47979900e-01f, -6.07861727e-02f, -1.85679898e-01f, 6.26997352e-02f, 6.01431690e-02f, 2.82565802e-01f, 2.26544395e-01f,
  9.97880846e-02f, 2.85282861e-02f, 2.09179014e-01f, 2.55897611e-01f, -2.95846969e-01f, 1.29667863e-01f, -1.76478311e-01f, 7.06932740e-03f, 4.80038300e-02f, -1.31497726e-01f,
  2.56825425e-02f, 1.30315065e-01f, -1.18053354e-01f, -6.35954812e-02f, 6.61502630e-02f, 5.01157679e-02f, 2.60996781e-02f, 2.10894316e-01f, -2.55537212e-01f, -3.44835897e-03f,
  -4.62168865e-02f, -2.87860841e-01f, -8.68290886e-02f, 7.83304498e-02f, 6.74979612e-02f, 4.13241722e-02f, 2.41024308e-02f, -2.91446950e-02f, -1.75232626e-02f, 1.06965847e-01f,
  -1.00898683e-01f, 3.77901737e-03f, 1.33900400e-02f, 2.15744540e-01f, -3.09919357e-01f, 3.99965718e-02f, -4.31290194e-02f, -1.19747641e-02f, 3.16703953e-02f, 1.34800285e-01f,
  4.83193770e-02f, 6.09664358e-02f, -7.50073269e-02f, -6.25660270e-02f, 4.82144244e-02f, -7.79346153e-02f, 8.00860673e-02f, -1.30994782e-01f, -9.14327949e-02f, 7.79584199e-02f,
  -8.54400024e-02f, 8.27486217e-02f, -5.12640551e-02f, 4.88174595e-02f, -1.34066954e-01f, -1.61390156e-01f, -9.03443769e-02f, 2.29265001e-02f, 1.67047493e-02f, -1.85173824e-01f,
  -1.56247273e-01f, -1.37551337e-01f, -8.86388272e-02f, -1.05386395e-02f, -5.27338870e-03f, 2.61590686e-02f, -7.29000522e-03f, 2.70696692e-02f, 1.99911773e-01f, -3.42831598e-03f,
  -5.34017347e-02f, -1.79968700e-02f, -9.12399590e-02f, 1.22982949e-01f, -1.94785073e-02f, -3.41000990e-03f, 1.00331917e-01f, -6.22233376e-02f, 1.48896471e-01f, 1.88277751e-01f,
  3.65916163e-01f, 2.42790550e-01f, -2.82547235e-01f, -8.98604654e-03f, -1.70010537e-01f, -7.23920241e-02f, -9.32250638e-03f, -1.76658869e-01f, 8.13357830e-02f, 9.19854119e-02f,
  -1.43945292e-01f, -1.33771792e-01f, 1.11879438e-01f, 9.40153468e-03f, 2.91044235e-01f, -1.00042306e-01f, 3.08739375e-02f, -1.47927077e-02f, -2.87383378e-01f, -1.69673428e-01f,
  6.98750541e-02f, -1.95426568e-02f, -2.11265124e-02f, -1.11929059e-01f, -3.90111953e-02f, -4.72522639e-02f, -7.51607418e-02f, 1.29089311e-01f, 1.83709979e-01f, 1.51432708e-01f,
  -1.73462480e-01f, -8.39913338e-02f, -1.93850726e-01f, 1.01270750e-01f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.17179252e-01f, 1.75448269e-01f, -4.65263836e-02f, 5.44568300e-02f, 2.88628950e-03f, 1.37988374e-01f, 5.73562384e-02f, 1.02926381e-01f, 8.01320970e-02f, 7.86340982e-02f,
  1.60349812e-02f, -7.82018825e-02f, -2.89901555e-01f, 1.00346068e-02f, 2.39717543e-01f, 3.17038983e-01f, -3.18059891e-01f, -5.61375991e-02f, 1.95582718e-01f, 5.41208349e-02f,
  -6.39938265e-02f, -2.37292290e-01f, -7.92479366e-02f, -1.22883525e-02f, 1.05120346e-01f, -1.07851280e-02f, 1.81455195e-01f, 1.93632707e-01f, -3.00485454e-02f, -3.53711173e-02f,
  -8.84465501e-02f, 6.71823323e-02f, 3.54344279e-01f, 1.40075590e-02f, 3.96271013e-02f, 4.06953126e-01f, -6.60580322e-02f, -3.29045132e-02f, -7.13832378e-02f, 7.49775618e-02f,
  -9.21133384e-02f, 2.47915477e-01f, -2.27246992e-02f, 1.78185895e-01f, -3.18177730e-01f, -4.60161455e-02f, 1.95167363e-01f, 8.00524503e-02f, 3.46963406e-01f, 2.57957578e-01f,
  1.25699192e-01f, 9.87557024e-02f, -4.36419323e-02f, 1.12662509e-01f, 8.93918872e-02f, 6.65722638e-02f, -1.24315202e-01f, -6.82040974e-02f, 5.28174452e-02f, -1.61352918e-01f,
  1.24617323e-01f, 1.74702004e-01f, -4.94403206e-02f, -1.41330287e-01f, 1.75696909e-01f, 2.06692368e-01f, 8.44538361e-02f, 1.62068412e-01f, 8.46155509e-02f, 1.30915031e-01f,
  -1.20273232e-01f, 2.42046252e-01f, -1.28264382e-01f, 2.38170713e-01f, 2.25263804e-01f, 1.40014321e-01f, 2.47289270e-01f, 2.28609830e-01f, -3.35260555e-02f, -2.87747413e-01f,
  3.52559835e-01f, 9.47481394e-02f, -2.33142272e-01f, -3.51192772e-01f, -1.74069658e-01f, 2.28649750e-01f, 2.73641109e-01f, -3.75485420e-02f, -9.73921046e-02f, -1.70694724e-01f,
  -7.41689885e-03f, 2.44934876e-02f, -1.28009781e-01f, 3.04528534e-01f, -2.49514922e-01f, -1.18308812e-01f, 1.29743824e-02f, 1.95223093e-02f, 1.73028067e-01f, 2.95779228e-01f,
  2.72081465e-01f, -1.74529210e-01f, -1.63614601e-02f, 9.46037322e-02f, -4.71757241e-02f, 2.65269786e-01f, 5.16993850e-02f, 5.08751236e-02f, -2.28557274e-01f, 2.95883864e-01f,
  -1.74577370e-01f, -1.80145070e-01f, 3.76792729e-01f, -1.73827305e-01f, 5.34625240e-02f, 3.98192666e-02f, 2.96209931e-01f, 2.88193170e-02f, -1.93753734e-01f, -3.64365652e-02f,
  -1.05407037e-01f, 6.78281486e-02f, -8.89401603e-03f, 1.01541668e-01f, 2.17191726e-01f, 1.01227142e-01f, 2.90458441e-01f, 3.00901145e-01f, 7.62969032e-02f, -3.19871418e-02f,
  -4.36396599e-02f, -1.84502676e-02f, 5.06449081e-02f, 1.97239548e-01f, 6.90757409e-02f, 1.32355928e-01f, -7.87235796e-02f, 1.50311917e-01f, 3.87857147e-02f, 1.35470629e-01f,
  3.31230283e-01f, -1.17679670e-01f, 2.43744478e-01f, -8.55235383e-02f, 3.14992189e-01f, 9.36607271e-02f, 7.75318742e-02f, -3.30370337e-01f, -3.21494907e-01f, 1.64611667e-01f,
  3.09940726e-01f, 1.57582104e-01f, 1.99030057e-01f, 7.52837062e-02f, 2.42661446e-01f, 2.13038344e-02f, -2.92604834e-01f, 3.77473161e-02f, -4.56033587e-01f, -2.18917653e-02f,
  1.69757918e-01f, 5.26816174e-02f, 1.93816543e-01f, 2.65959591e-01f, 1.45732954e-01f, -1.08927593e-01f, -1.12406343e-01f, 3.22604507e-01f, -2.22794175e-01f, 3.76256615e-01f,
  -2.11405624e-02f, 1.80619489e-02f, -1.39946938e-01f, 1.59411907e-01f, 6.37417138e-02f, -1.59947202e-01f, 2.97549784e-01f, -1.16732217e-01f, 1.90996185e-01f, -4.87221368e-02f,
  3.62625092e-01f, -3.11252605e-02f, 1.43630743e-01f, 1.99620977e-01f, -1.15930647e-01f, 5.86695084e-03f, -3.61628681e-02f, -2.15134434e-02f, 2.36945063e-01f, -1.89908698e-01f,
  1.25282124e-01f, 2.89714485e-01f, 2.28614450e-01f, 1.06580794e-01f, 7.15473443e-02f, 1.14376120e-01f, 3.31666060e-02f, 2.69957315e-02f, 1.00827642e-01f, -6.99544465e-03f,
  4.29667048e-02f, -5.43091400e-03f, 1.18956767e-01f, 1.93145350e-01f, 2.96693683e-01f, -1.56238943e-01f, 1.19328819e-01f, -1.07428223e-01f, 2.96229750e-01f, 1.56047255e-01f,
  9.68579203e-02f, 1.90390460e-02f, -4.68150564e-02f, 9.02199373e-02f, 9.01811272e-02f, 1.49714604e-01f, -7.18819946e-02f, 1.18381288e-02f, 3.69187929e-02f, 1.92605108e-01f,
  -9.43474174e-02f, -9.00603607e-02f, -7.53480494e-02f, -1.81955501e-01f, 1.87985841e-02f, 6.07274994e-02f, 1.86557591e-01f, 8.13641623e-02f, 2.10477144e-01f, 8.83169398e-02f,
  -1.14572570e-01f, 2.17699841e-01f, -7.00685233e-02f, 6.50457740e-02f, 1.03522331e-01f, -1.01507030e-01f, 3.03410083e-01f, -4.84450795e-02f, -9.65321139e-02f, 4.31271410e-03f,
  6.01193048e-02f, -5.92406392e-02f, -1.21527109e-02f, -2.01355532e-01f, 1.85305327e-01f, -1.50887161e-01f, 1.53495833e-01f, 8.99161696e-02f, 2.39697229e-02f, 1.54718667e-01f,
  -2.09720790e-01f, 1.13846511e-01f, 9.03337672e-02f, -3.68223079e-02f, -1.14248142e-01f, 1.77476909e-02f, -2.48835958e-03f, 3.17176953e-02f, -6.65310696e-02f, -3.94720621e-02f,
  1.28362447e-01f, -1.12201590e-02f, 1.13474734e-01f, -6.22795410e-02f, -1.03906682e-03f, 2.88027879e-02f, 6.70867693e-03f, 8.66569728e-02f, -3.63676101e-01f, 1.37926593e-01f,
  -7.91973770e-02f, -9.67297424e-03f, 7.91385695e-02f, -7.01644123e-02f, 3.78326997e-02f, 2.83321708e-01f, 3.77910852e-01f, -2.78092384e-01f, -1.86552510e-01f, -9.88661647e-02f,
  6.84895441e-02f, 3.56797278e-02f, -1.44796669e-01f, 2.11585671e-01f, 2.37835556e-01f, 1.17212802e-01f, 8.36930275e-02f, 2.27435648e-01f, 1.09276079e-01f, 1.63285851e-01f,
  1.78526029e-01f, -7.67257810e-02f, 1.40714452e-01f, 1.05908856e-01f, 1.06876761e-01f, -1.60497606e-01f, 2.30530411e-01f, -1.57085657e-01f, 4.72458601e-02f, 1.33929580e-01f,
  8.18708315e-02f, -2.70833038e-02f, -8.83063376e-02f, -4.18770500e-02f, 1.11925520e-01f, 2.40832552e-01f, -1.92645818e-01f, 1.02046728e-01f, -2.39122123e-01f, 4.29315299e-01f,
  -1.22184731e-01f, 7.54461065e-02f, -1.15340889e-01f, -1.85672734e-02f, 5.38193733e-02f, -1.66014031e-01f, 7.64698088e-02f, 3.22357476e-01f, 1.26835674e-01f, -1.02884144e-01f,
  8.55855867e-02f, 8.01721588e-02f, 1.51371136e-01f, -4.91677690e-03f, 1.50115594e-01f, 6.45022765e-02f, 8.65643546e-02f, -1.74906716e-01f, -5.37504144e-02f, -1.92448705e-01f,
  -2.81533320e-03f, 3.02104533e-01f, 3.30461144e-01f, 8.66227746e-02f, 5.03170900e-02f, -1.23061009e-01f, 3.41205537e-01f, 4.25173670e-01f, 7.21862689e-02f, 2.68113375e-01f,
  1.58516228e-01f, -9.88751091e-03f, 1.96059525e-01f, -8.26845691e-02f, -7.01618865e-02f, -7.81960562e-02f, -6.22208677e-02f, 1.38053015e-01f, 2.31772482e-01f, 3.29698116e-01f,
  -2.00663004e-02f, 1.28149197e-01f, -1.77722499e-01f, -1.43802226e-01f, 1.19769767e-01f, 4.33929488e-02f, 1.04163744e-01f, 3.63260061e-02f, -1.91963091e-01f, 2.47141838e-01f,
  -6.02524802e-02f, -4.62007970e-02f, 1.31677613e-02f, -9.09350514e-02f, 5.18043518e-01f, 9.98448879e-02f, 1.84047878e-01f, 2.43125692e-01f, -2.60715157e-01f, -1.08739436e-01f,
  1.06796041e-01f, -4.38918509e-02f, 4.27922942e-02f, -2.03445837e-01f, 1.74290717e-01f, -1.71395153e-01f, -1.95499659e-01f, -1.20281093e-01f, -6.38651401e-02f, -1.68073401e-01f,
  3.08977421e-02f, -8.62604529e-02f, -1.70554712e-01f, 2.45204598e-01f, 1.12894289e-01f, 9.19552445e-02f, 8.91784355e-02f, 9.35938507e-02f, 1.20938411e-02f, 2.25854889e-01f,
  -1.73807621e-01f, 1.19686453e-02f, 1.75238132e-01f, 5.12570068e-02f, -4.08876836e-02f, -1.38261495e-02f, 2.37684831e-01f, -6.82142330e-03f, -2.01594263e-01f, -1.32303879e-01f,
  3.86565566e-01f, 1.32796660e-01f, -4.86942947e-01f, -1.98999673e-01f, 5.37573453e-03f, 5.08716941e-01f, 1.20247506e-01f, 8.36738124e-02f, -1.44886002e-01f, 8.35584551e-02f,
  2.71062944e-02f, -1.89795345e-01f, -4.07546386e-03f, 1.03199877e-01f, 4.70977038e-01f, 1.92812264e-01f, -3.38047862e-01f, 8.84604678e-02f, -1.16124824e-01f, -1.31442964e-01f,
  1.82312071e-01f, -1.95378065e-01f, 9.31073353e-02f, 1.19162731e-01f, 2.89469808e-02f, 6.23862408e-02f, -6.05278537e-02f, -4.68552746e-02f, -2.83317506e-01f, 2.19232932e-01f,
  -1.05827078e-01f, -8.57672319e-02f, -7.96017051e-02f, -8.47126991e-02f, 1.13321275e-01f, 8.88730735e-02f, 2.40062952e-01f, 1.17846534e-01f, -3.41073126e-02f, -6.49513304e-02f,
  1.50387064e-01f, 2.18198568e-01f, -1.55605562e-02f, 4.05908167e-01f, -1.08030846e-03f, -1.46309063e-01f, -3.89161631e-02f, 2.28035435e-01f, 4.19623964e-02f, 2.16610488e-02f,
  -5.46110049e-02f, -3.15499008e-02f, -2.19020005e-02f, -1.23177029e-01f, 2.55988121e-01f, -1.08525626e-01f, 3.19988839e-02f, -6.60213782e-03f, 1.89190749e-02f, -1.95859805e-01f,
  -2.19784170e-01f, -2.79947966e-01f, -6.21570051e-02f, 4.77616079e-02f, 1.26965949e-02f, 2.69896239e-01f, 3.72549087e-01f, 1.69438735e-01f, 4.20725010e-02f, -3.96720618e-01f,
  9.80143026e-02f, 2.16697007e-01f, -6.35382533e-02f, -9.01066065e-02f, 1.74086273e-01f, 2.19852179e-02f, 3.53808373e-01f, -2.86309980e-02f, -1.04216017e-01f, 5.37245572e-02f,
  9.19055268e-02f, -6.15797862e-02f, -1.99459732e-01f, 6.97960258e-02f, -4.73130457e-02f, 4.25471365e-02f, -4.68909461e-03f, 1.90477055e-02f, 5.38327768e-02f, 2.71356907e-02f,
  -1.30345017e-01f, 2.13205040e-01f, 3.97393703e-01f, 1.00537445e-02f, 6.22816682e-02f, -2.29600128e-02f, 1.14978654e-02f, 3.01164612e-02f, 1.77395344e-01f, -1.41491845e-01f,
  -1.81147456e-01f, -9.93856192e-02f, 9.92204472e-02f, 6.98970817e-03f, -2.24591076e-01f, -1.09937321e-02f, 2.01478899e-01f, -2.81872034e-01f, -6.65784851e-02f, -1.69994067e-02f,
  1.74425531e-03f, -2.27942150e-02f, -5.23125194e-02f, 6.47124574e-02f, 1.19979501e-01f, 6.86649755e-02f, 1.38425484e-01f, 1.48900256e-01f, -1.60775781e-01f, 2.34961808e-02f,
  7.06569254e-02f, 6.79084286e-02f, -2.59256102e-02f, 1.41679659e-01f, 8.78833532e-02f, 3.41509938e-01f, 1.24464147e-01f, -6.14892989e-02f, 9.15010944e-02f, -1.38153553e-01f,
  -6.72785118e-02f, 2.42063981e-02f, -1.81719940e-02f, 2.48429760e-01f, 8.63135234e-02f, -3.23587544e-02f, -2.76920740e-02f, 1.25818446e-01f, -1.32812813e-01f, -1.29179552e-01f,
  1.22905105e-01f, 6.50603250e-02f, -7.62583613e-02f, -2.40916550e-01f, 1.84830725e-01f, 9.53555331e-02f, -9.67427865e-02f, -4.16693985e-02f, -1.72404811e-01f, -2.51726002e-01f,
  2.55243450e-01f, -1.69238061e-01f, 8.97866488e-02f, 7.48647600e-02f, 1.59433484e-01f, -8.62255469e-02f, -1.87509000e-01f, 8.67350996e-02f, -1.83103889e-01f, -1.06627464e-01f,
  1.40824527e-01f, -3.15589570e-02f, -5.13044931e-02f, 2.49427825e-01f, 1.32838741e-01f, -5.21604717e-02f, 1.47499755e-01f, -7.49735087e-02f, 7.50893876e-02f, 1.39458790e-01f,
  -5.81109971e-02f, 2.33350605e-01f, 1.91469580e-01f, -3.31611894e-02f, 2.41899356e-01f, -1.04077727e-01f, -1.98772606e-02f, 2.01463580e-01f, 1.79128498e-02f, 5.74502051e-02f,
  8.34494829e-02f, 8.85177255e-02f, 1.23976938e-01f, -9.71912593e-02f, -1.06717246e-02f, -6.54455125e-02f, -1.16104446e-01f, 2.41933689e-02f, -2.40110427e-01f, 6.68078512e-02f,
  1.16089426e-01f, 1.14207059e-01f, -1.78043157e-01f, 2.53907531e-01f, 3.68517935e-01f, 2.60359168e-01f, 1.61714867e-01f, -2.98950166e-01f, -1.11636162e-01f, 1.27126962e-01f,
  -2.46877205e-02f, -7.08708074e-03f, 6.12886325e-02f, -6.18544780e-03f, 3.91956598e-01f, 2.29407176e-01f, 1.10156097e-01f, 2.30150111e-02f, 7.29564056e-02f, -2.84578968e-02f,
  1.93966813e-02f, 1.38860881e-01f, 3.87278460e-02f, -4.89893071e-02f, 1.33062974e-01f, 1.33989990e-01f, 3.84904183e-02f, -1.67715907e-01f, -9.59028229e-02f, 2.78178304e-01f,
  2.96513557e-01f, -6.19600676e-02f, 7.80149773e-02f, 2.43528709e-01f, 6.99397847e-02f, 2.14429989e-01f, 2.88892537e-01f, 2.13645458e-01f, -2.16849804e-01f, 6.68696761e-02f,
  9.38071534e-02f, -2.71768868e-03f, -2.42157489e-01f, -1.67604327e-01f, 2.40173593e-01f, -1.80479065e-01f, -6.64922297e-02f, 1.81308851e-01f, 5.24511226e-02f, -1.36073474e-02f,
  1.31268585e-02f, 1.24059327e-01f, 7.82768130e-02f, 1.75581828e-01f, 7.96703324e-02f, 1.72296941e-01f, 3.56879793e-02f, 1.20635465e-01f, -4.62974720e-02f, 1.20753020e-01f,
  2.10067168e-01f, 1.88503221e-01f, 3.24056923e-01f, 1.63943440e-01f, 1.64848636e-03f, -2.17149183e-01f, 4.25253063e-01f, 4.21355337e-01f, -2.58042425e-01f, -3.11392635e-01f,
  -1.98914319e-01f, 1.10388055e-01f, 3.40743005e-01f, 9.05744880e-02f, 8.14532712e-02f, -1.19232394e-01f, 1.13514073e-01f, 7.27750957e-02f, 3.13834637e-01f, 4.51612353e-01f,
  -3.61708224e-01f, -4.46888283e-02f, 1.88309088e-01f, 5.19619249e-02f, 2.75736809e-01f, 2.75349528e-01f, 2.80844033e-01f, -2.40631580e-01f, 6.63340688e-02f, 1.20936275e-01f,
  1.76288597e-02f, 8.40370059e-02f, 2.94733532e-02f, 1.47380203e-01f, -9.76804271e-02f, 1.85389504e-01f, -4.58928049e-02f, -1.53188393e-01f, 2.24292591e-01f, -2.61943132e-01f,
  3.00012141e-01f, 6.32649958e-02f, 6.33842349e-02f, 2.45870347e-03f, -1.75530285e-01f, -6.51659817e-02f, -1.42476276e-01f, -1.24874994e-01f, 4.91690040e-02f, -9.05079395e-02f,
  2.71246970e-01f, -1.37990415e-01f, 3.87104839e-01f, 1.60574615e-01f, -1.14012644e-01f, 7.48763606e-02f, 1.25346795e-01f, 1.03015512e-01f, -1.70128699e-02f, -4.64024767e-02f,
  2.16759726e-01f, 7.24967802e-03f, 1.55448273e-01f, 5.02234548e-02f, 3.93860005e-02f, 1.57635182e-01f, 1.45937353e-01f, -1.11342005e-01f, -1.73959553e-01f, 1.42744452e-01f,
  2.57448535e-02f, 2.12940738e-01f, 2.50354201e-01f, -4.95753847e-02f, 8.60360935e-02f, -1.65315747e-01f, 2.68745363e-01f, 1.69059187e-01f, 8.21670666e-02f, 2.97556609e-01f,
  1.40313193e-01f, 7.46535361e-02f, 2.04912350e-01f, 5.42044789e-02f, -1.57353520e-01f, -2.84853783e-02f, 3.41762379e-02f, -5.52729936e-03f, -9.58753526e-02f, 1.14153475e-01f,
  1.79179367e-02f, -1.87059250e-02f, -2.49804705e-02f, 6.99559152e-02f, -3.98668135e-03f, 1.41034782e-01f, 2.63257235e-01f, 1.37397140e-01f, -1.15753837e-01f, -1.43116787e-01f,
  -9.55497473e-03f, 1.12366281e-01f, 1.13015868e-01f, 1.81645662e-01f, -9.80306324e-03f, -1.19688153e-01f, -2.01337382e-01f, -2.41970912e-01f, 2.69168019e-01f, -5.12620993e-02f,
  -3.78975905e-02f, 1.79738179e-01f, 3.62679996e-02f, 1.35598943e-01f, 3.46702129e-01f, -2.16505621e-02f, -9.28662643e-02f, -1.61008313e-01f, 8.14062580e-02f, 5.65017201e-02f,
  1.14279091e-01f, -1.15078755e-01f, 1.56993456e-02f, 2.06533715e-01f, 1.25281185e-01f, 1.65701464e-01f, -6.87776953e-02f, 1.21676184e-01f, 2.60690868e-01f, 1.56697631e-01f,
  -1.96429715e-02f, 1.06959976e-01f, 4.64231372e-02f, -4.40588631e-02f, -1.83380887e-01f, -3.06948781e-01f, 1.69014856e-01f, 6.54187426e-02f, -2.01801695e-02f, 9.06499624e-02f,
  2.78007269e-01f, 2.55160213e-01f, 1.47900045e-01f, -4.31239940e-02f, 1.69323504e-01f, 4.69641387e-02f, -1.92247242e-01f, -3.24181169e-02f, -2.78893709e-01f, -2.75417566e-01f,
  3.14487904e-01f, -6.45246683e-03f, 1.65053844e-01f, 2.06259117e-01f, 1.78080976e-01f, -1.67691335e-01f, 2.56116781e-02f, -1.41809836e-01f, 2.28454754e-01f, 1.25966907e-01f,
  -1.99007057e-02f, -2.71890201e-02f, 1.48480386e-01f, 2.25811869e-01f, -1.36190072e-01f, -1.97806016e-01f, 4.01940674e-01f, -7.61933625e-02f, -9.36244503e-02f, 1.64343357e-01f,
  1.45586357e-01f, -6.14684969e-02f, -1.23053074e-01f, 1.29165947e-01f, -1.50776654e-01f, 1.15044869e-01f, 8.31457749e-02f, -6.10349216e-02f, 3.80244665e-02f, -4.53521349e-02f,
  3.24607790e-01f, -9.28680748e-02f, -8.28107148e-02f, -2.95837168e-02f, 1.00252116e-02f, 8.54070485e-02f, 1.01559237e-01f, 1.34170145e-01f, 7.76307061e-02f, -1.58746958e-01f,
  6.67469725e-02f, -8.24765265e-02f, 4.75176573e-02f, 2.41206642e-02f, -6.32938221e-02f, 1.72611536e-03f, -5.91137707e-02f, -6.99191615e-02f, 1.83433220e-01f, 1.19736783e-01f,
  -1.17238320e-01f, 7.30434135e-02f, 1.40468910e-01f, -1.12565435e-01f, -1.13165893e-01f, -1.94445714e-01f, 1.03655435e-01f, 1.34546623e-01f, -2.02744398e-02f, 1.20624099e-02f,
  1.23617180e-01f, 3.39274794e-01f, -1.24854811e-01f, -5.07964492e-02f, 2.39883095e-01f, 2.05252215e-01f, 2.85560489e-01f, 1.33336484e-01f, -5.70899509e-02f, 7.76047185e-02f,
  1.64661258e-01f, -1.30536426e-02f, 5.01202345e-02f, -1.54191151e-01f, -9.71666304e-04f, 1.31103858e-01f, 3.46837603e-02f, -2.58909106e-01f, -2.50996202e-02f, -1.06207475e-01f,
  2.26842597e-01f, 1.40286759e-01f, 1.83555976e-01f, 1.54105416e-02f, -7.33816251e-02f, 6.66559413e-02f, 6.01676740e-02f, 2.09768470e-02f, 7.58387707e-03f, -2.72072591e-02f,
  -1.53285220e-01f, 4.33860160e-02f, 2.71540016e-01f, 2.64174759e-01f, -6.16224334e-02f, -3.43609937e-02f, 3.76308784e-02f, 8.23627114e-02f, 1.53840140e-01f, -2.07762215e-02f,
  1.50666147e-01f, 1.52826667e-01f, -1.14699461e-01f, 7.35415472e-03f, 2.06932873e-02f, -8.05338770e-02f, -6.92153871e-02f, -2.55998820e-01f, -6.69542328e-02f, -3.59298021e-01f,
  9.26947892e-02f, 9.49536338e-02f, -1.56547487e-01f, -9.82764661e-02f, 1.92617297e-01f, 4.93758870e-03f, 3.83450021e-03f, 3.07898551e-01f, 2.37924352e-01f, 3.52061659e-01f,
  -6.50190115e-02f, -1.83790922e-02f, 2.62130469e-01f, -1.84067130e-01f, -6.11889660e-02f, -9.99208689e-02f, 2.91967869e-01f, 2.64439970e-01f, -2.79328257e-01f, -1.80150107e-01f,
  -1.61799744e-01f, 6.81434991e-03f, -1.06357493e-01f, 1.37675675e-02f, -1.08766034e-01f, 4.07076254e-02f, 5.41578457e-02f, 2.51078457e-01f, 1.89301878e-01f, -6.16261698e-02f,
  -2.21487895e-01f, 2.88205206e-01f, 1.17787614e-01f, 8.75717923e-02f, -8.91418904e-02f, -8.42889324e-02f, 1.88559055e-01f, -4.31644991e-02f, 6.30211085e-02f, 2.26325379e-03f,
  4.67713512e-02f, 8.27663764e-02f, 6.52191639e-02f, 1.38533771e-01f, 3.02710027e-01f, 7.34049156e-02f, 2.61274204e-02f, -8.51925611e-02f, 1.55976459e-01f, 1.06782444e-01f,
  1.33171035e-02f, 1.17810637e-01f, 1.02894828e-01f, -6.41814396e-02f, -5.42615727e-03f, -1.69499740e-02f, 1.00931183e-01f, 1.50049448e-01f, -7.43592381e-02f, 1.24761602e-02f,
  -9.10491943e-02f, -1.75306365e-01f, -2.44629547e-01f, 1.46557078e-01f, 1.59387872e-01f, 3.22739273e-01f, -3.88805121e-01f, -3.13756853e-01f, 1.72626048e-01f, 2.30183285e-02f,
  1.68068141e-01f, 1.81735426e-01f, 9.82811376e-02f, 1.76269993e-01f, 1.47795632e-01f, -4.48537990e-02f, 1.70713797e-01f, 2.84703355e-02f, -2.86426246e-01f, -4.01331484e-01f,
  2.98583418e-01f, 2.45242864e-01f, 1.76264465e-01f, -1.53133526e-01f, -7.29276985e-02f, -7.76071101e-02f, -8.56299698e-02f, 1.07205316e-01f, -4.12048772e-02f, -1.74528867e-01f,
  1.43654943e-02f, 2.51061559e-01f, 2.83454210e-01f, 1.60308108e-02f, -2.22919390e-01f, 1.69044122e-01f, 1.83092937e-01f, -6.04150780e-02f, 1.48402497e-01f, 2.76679754e-01f,
  -2.87231982e-01f, 1.23211771e-01f, 9.46142003e-02f, -1.25907604e-02f, 1.57963023e-01f, 9.04742852e-02f, -6.23298751e-04f, 2.12124482e-01f, 2.03506261e-01f, 5.63577004e-02f,
  -5.16967215e-02f, 2.26190999e-01f, 2.22723693e-01f, -3.79743785e-01f, 5.55733666e-02f, 1.28151909e-01f, 1.35481209e-01f, 1.16702154e-01f, 3.21482755e-02f, -1.05362184e-01f,
  4.55183461e-02f, 5.90873212e-02f, 1.84454411e-01f, 8.95938426e-02f, 1.39426626e-02f, -8.33883360e-02f, 2.83041656e-01f, 2.41269935e-02f, -1.83961064e-01f, -2.33378820e-02f,
  4.55788314e-01f, 5.15217483e-01f, -8.08878466e-02f, -4.63418588e-02f, -1.42646000e-01f, -1.47124648e-01f, 2.59326827e-02f, 3.52617115e-01f, 1.26218632e-01f, 1.42891079e-01f,
  2.41359368e-01f, -1.16551504e-01f, 2.90287673e-01f, 1.21817589e-01f, 2.81882167e-01f, 3.68179440e-01f, -3.32610667e-01f, 4.54306789e-02f, -3.07552338e-01f, 1.81163266e-01f,
  5.26820906e-02f, 6.39260858e-02f, 5.33294491e-02f, 6.08520806e-02f, -7.59489685e-02f, 1.48544945e-02f, 1.41625419e-01f, 2.03151613e-01f, -1.12216488e-01f, 1.19346395e-01f,
  1.99257672e-01f, -3.41258086e-02f, -2.57312298e-01f, -1.92851037e-01f, 2.51707792e-01f, -6.05170429e-02f, -2.34015882e-01f, 3.12815458e-02f, -9.26767197e-03f, -8.63004401e-02f,
  -2.17807263e-01f, -9.64077488e-02f, 4.76706207e-01f, -1.61834359e-01f, 2.93641165e-02f, -1.70795813e-01f, 2.05132768e-01f, 1.59263313e-01f, -3.05617787e-02f, 1.40559196e-01f,
  1.33542344e-01f, 1.05472580e-01f, 9.86232758e-02f, -7.76804909e-02f, 8.69885385e-02f, -7.01536760e-02f, 3.18732113e-02f, -5.88391945e-02f, -1.33723885e-01f, -2.88051575e-01f,
  -1.10499963e-01f, 2.24828750e-01f, -8.73762071e-02f, 1.63344845e-01f, -2.25636274e-01f, 1.15824811e-01f, -4.47446778e-02f, 2.83139557e-01f, 1.92177102e-01f, -1.92382574e-01f,
  3.59608181e-04f, 3.56014408e-02f, 1.23371147e-01f, 6.35350645e-02f, 6.02573194e-02f, 1.31482720e-01f, 3.47300798e-01f, -3.11983116e-02f, 2.96698153e-01f, 2.97504336e-01f,
  1.65414941e-02f, -6.82369322e-02f, -1.69803202e-01f, -7.26619959e-02f, 8.99883360e-02f, 8.49339366e-02f, 6.89739808e-02f, -3.34068537e-02f, 9.66138020e-02f, -8.14618170e-02f,
  1.70000315e-01f, 2.32141480e-01f, 1.57023668e-01f, -3.11867092e-02f, 2.13939160e-01f, 1.98066533e-01f, -1.02897607e-01f, 1.56890914e-01f, 1.94721833e-01f, 7.97208101e-02f,
  -2.41181567e-01f, 9.29133222e-02f, 6.07883707e-02f, -1.04228057e-01f, -1.54556125e-01f, 6.76874863e-03f, 2.66269654e-01f, -2.21933022e-01f, -8.60201791e-02f, 6.60032704e-02f,
  -1.52048841e-01f, -1.09958515e-01f, 6.20247126e-02f, 1.01581208e-01f, -7.20516145e-02f, 1.06667832e-01f, -8.54599383e-03f, 5.86995333e-02f, -1.65571243e-01f, -5.05048484e-02f,
  2.59820491e-01f, -1.49998879e-02f, 1.31653205e-01f, 7.67227337e-02f, 4.14461046e-01f, -1.27756968e-01f, -9.60347801e-02f, -2.43486151e-01f, 3.62526774e-01f, 3.65657330e-01f,
  -3.79675001e-01f, -1.50997592e-02f, -5.69781289e-02f, -1.44109353e-01f, 4.26645353e-02f, 5.04752621e-02f, 2.60191970e-02f, 9.68653783e-02f, 1.22996278e-01f, 4.08543386e-02f,
  3.71615827e-01f, 3.34638745e-01f, -7.38862529e-02f, 3.54973882e-01f, -4.28990602e-01f, 1.05910979e-01f, -1.72776818e-01f, -1.36218444e-01f, 7.24258497e-02f, 9.41747613e-03f,
  7.79943094e-02f, 1.70966119e-01f, -8.70273262e-02f, -5.37332930e-02f, 1.09475069e-02f, 2.05936953e-01f, -2.13405535e-01f, 7.29639381e-02f, 2.37721652e-01f, 1.48414150e-01f,
  -3.06132495e-01f, -1.09904632e-01f, 3.04272443e-01f, -1.90213062e-02f, -8.40560645e-02f, 2.17023924e-01f, -2.12601200e-02f, -1.13028683e-01f, 2.61033829e-02f, -7.88449645e-02f,
  1.40192360e-01f, 7.49971196e-02f, 2.51364917e-01f, -2.96784818e-01f, -1.87234387e-01f, 3.56764019e-01f, -3.61598283e-02f, 8.65272991e-03f, -8.07772018e-03f, -1.28378898e-01f,
  9.35827047e-02f, -3.38871814e-02f, -7.80677348e-02f, 4.34374698e-02f, -1.00091085e-01f, -1.04048908e-01f, -2.88883477e-01f, -1.77415296e-01f, -5.47508299e-02f, 1.93055287e-01f,
  2.66093671e-01f, 1.92228220e-02f, -2.58043677e-01f, -6.90135956e-02f, -1.11057766e-01f, 1.57485694e-01f, 2.84321792e-02f, 1.19779110e-01f, -2.45360304e-02f, 7.34026060e-02f,
  1.03686519e-01f, 5.37111014e-02f, 1.58560947e-01f, 1.30669475e-01f, 8.07207078e-02f, -2.85547674e-01f, -1.96597800e-01f, 2.67614812e-01f, -1.16157681e-02f, 1.16256386e-01f,
  -1.17195539e-01f, -1.90451324e-01f, -1.99327379e-01f, -6.84997649e-04f, 3.46736647e-02f, 3.88239957e-02f, 2.22565129e-01f, -5.50655201e-02f, 8.06944668e-02f, -5.81060164e-03f,
  -9.91246626e-02f, 3.71809632e-01f, 1.36134133e-01f, 2.18131617e-01f, -1.08478926e-01f, 2.15670824e-01f, -9.18994937e-03f, 2.20927298e-01f, 2.06543982e-01f, 1.23959661e-01f,
  -6.09863028e-02f, 3.00493151e-01f, -1.24251522e-01f, 1.14235438e-01f, -1.09142717e-02f, -1.08667992e-01f, 1.16217941e-01f, -3.54596153e-02f, 1.99950531e-01f, 1.02980277e-02f,
  2.49624670e-01f, 1.59294441e-01f, 1.07631296e-01f, 2.30378080e-02f, 1.47718593e-01f, 1.07027367e-01f, -1.33321330e-01f, 6.91183209e-02f, 1.30296364e-01f, 5.13678044e-02f,
  -1.08556613e-01f, -2.15499118e-01f, 1.26373200e-02f, 4.60080475e-01f, 1.28235862e-01f, -3.30525860e-02f, -1.20877109e-01f, -4.19178873e-01f, -4.83592540e-01f, 1.16775900e-01f,
  2.90151387e-01f, 4.62495774e-01f, 4.84859049e-02f, -1.60233989e-01f, -1.09260371e-02f, 2.22495031e-02f, 1.42902061e-01f, 2.79602408e-02f, -3.22626173e-01f, -1.77959979e-01f,
  3.60919505e-01f, 3.51249456e-01f, 8.48904252e-02f, -1.31895527e-01f, 1.40537098e-01f, -1.87584043e-01f, -1.67924717e-01f, -1.51601836e-01f, -3.05687319e-02f, -1.09633729e-02f,
  1.52922750e-01f, 4.47966754e-02f, 2.41612300e-01f, -1.21692689e-02f, -2.31944218e-01f, 1.29465237e-01f, 4.32566255e-02f, 1.94568604e-01f, 7.42753670e-02f, 2.26074666e-01f,
  -2.15808406e-01f, 5.41967386e-03f, 1.66377142e-01f, 3.07551306e-02f, 2.72278994e-01f, 1.92026839e-01f, 1.38203084e-01f, 3.70654285e-01f, -1.14256911e-01f, 3.62570316e-01f,
  6.92579001e-02f, 2.82190740e-01f, -8.62844959e-02f, -4.82868366e-02f, -2.95009613e-02f, 1.95513994e-01f, 1.58346742e-01f, 7.06896633e-02f, 9.66959596e-02f, -3.12345196e-02f,
  1.73173055e-01f, -1.70108527e-01f, 1.08468607e-01f, -1.16312519e-01f, -7.54697695e-02f, -2.42903471e-01f, 1.00597627e-01f, 2.37946168e-01f, -1.31207198e-01f, 2.75492728e-01f,
  -2.80648861e-02f, 2.94827610e-01f, 8.46902803e-02f, 2.57182658e-01f, 3.59088302e-01f, -1.30882442e-01f, 6.26639873e-02f, -1.98793456e-01f, 1.21608332e-01f, 1.63180530e-01f,
  1.10385135e-01f, 1.23710476e-01f, 1.51860654e-01f, 4.21957262e-02f, 4.52535003e-01f, 3.56202394e-01f, -3.90468538e-02f, -1.54930055e-01f, -4.47968096e-02f, 1.01818599e-01f,
  7.04020858e-02f, 1.11908361e-01f, -9.36341211e-02f, 3.72757157e-03f, 4.92447875e-02f, -1.30177766e-01f, 2.38370206e-02f, 2.60446340e-01f, 3.51501137e-01f, -2.14217603e-01f,
  1.49442449e-01f, 3.70882824e-02f, -7.97745772e-03f, 2.35020772e-01f, -4.69295159e-02f, 8.85614287e-03f, -3.91022474e-01f, 1.07327230e-01f, 1.67782396e-01f, -7.29118437e-02f,
  -1.21396758e-01f, 8.93317834e-02f, 2.13366345e-01f, -5.50729185e-02f, 1.12746112e-01f, 3.20843428e-01f, -1.73942298e-01f, -1.65747359e-01f, -2.97326762e-02f, 1.03042312e-01f,
  1.90155640e-01f, 5.53638376e-02f, 1.80599451e-01f, 1.39753103e-01f, -1.96421415e-01f, -8.58727321e-02f, 3.89408879e-02f, -9.08448845e-02f, -6.92102090e-02f, 1.59899488e-01f,
  1.03144191e-01f, -4.22444530e-02f, 2.66995668e-01f, -7.22330660e-02f, 4.67382938e-01f, 6.32444117e-03f, 2.44565457e-02f, 7.59720653e-02f, 4.98564132e-02f, 2.46914759e-01f,
  -3.14197749e-01f, 1.08590405e-02f, -6.92736730e-02f, 7.98424557e-02f, -1.97484031e-01f, -8.81444812e-02f, 2.10001484e-01f, 4.57235932e-01f, 3.70723307e-01f, 1.86362956e-02f,
  -2.56797642e-01f, 1.29601344e-01f, 4.03237522e-01f, -4.64792214e-02f, 2.34538630e-01f, -3.12673271e-01f, 2.64892101e-01f, 2.56930381e-01f, -8.40360969e-02f, -3.60065396e-03f,
  1.43141523e-01f, -8.51990208e-02f, 3.54489952e-01f, 5.32280933e-03f, 6.38973713e-02f, 1.54571250e-01f, -1.37768567e-01f, -2.19342574e-01f, 2.99012721e-01f, -1.15025684e-01f,
  2.41930827e-01f, -1.47656024e-01f, 3.28113185e-03f, 7.00895786e-02f, 6.12550713e-02f, 6.97183087e-02f, -1.74709573e-01f, 3.80409598e-01f, 3.32455449e-02f, 2.99243312e-02f,
  -1.24126948e-01f, 3.32139045e-01f, 2.35196445e-02f, -7.51332268e-02f, -7.27927685e-02f, -2.59203166e-01f, -3.48395519e-02f, 1.26218140e-01f, -8.83624982e-03f, 2.48528704e-01f,
  1.29180729e-01f, 1.46846935e-01f, 2.07843482e-02f, 1.52441248e-01f, -8.95575359e-02f, 7.35920519e-02f, -8.83670077e-02f, 1.72935173e-01f, -1.03681698e-01f, -2.96664208e-01f,
  3.90350595e-02f, 3.55018862e-02f, -1.02920868e-02f, 1.87361315e-02f, -1.30943820e-01f, 2.48711407e-01f, 1.26959085e-02f, -1.68740954e-02f, 2.65979290e-01f, 1.66935980e-01f,
  -4.35183011e-02f, -2.07029849e-01f, -3.73227149e-01f, 6.68522343e-02f, 6.44355714e-02f, 3.32264870e-01f, -4.06425036e-02f, -8.83138087e-03f, -2.28663281e-01f, 1.59163490e-01f,
  1.18904926e-01f, -9.44633558e-02f, 2.05858275e-01f, 2.67222255e-01f, 1.44962057e-01f, 4.54651080e-02f, -4.56105977e-01f, 3.70270729e-01f, 6.71022087e-02f, -1.90455645e-01f,
  3.09461564e-01f, 1.46850064e-01f, -1.80061519e-01f, 1.72162458e-01f, 3.47066045e-01f, 3.11248362e-01f, 4.12988104e-02f, 1.00369900e-01f, 2.29243860e-02f, 5.21649644e-02f,
  1.14512891e-01f, 5.59042320e-02f, 1.27899081e-01f, 2.38387026e-02f, 3.34819674e-01f, -3.91369909e-02f, 8.59227255e-02f, -2.01378949e-02f, -7.20537007e-02f, -5.68288751e-02f,
  7.34629780e-02f, 1.65109649e-01f, -3.63211855e-02f, -2.36742161e-02f, -3.03625733e-01f, -5.19676246e-02f, 1.58748422e-02f, 7.03631490e-02f, 3.89941502e-03f, 3.08608621e-01f,
  1.44847035e-01f, -2.46027857e-02f, 3.05437725e-02f, -2.44906276e-01f, 1.90092474e-01f, 2.12669313e-01f, 3.53237204e-02f, 2.18129143e-01f, -8.94535556e-02f, 1.72024444e-01f,
  -2.77701896e-02f, -2.11713016e-02f, 1.56218112e-01f, -8.05295929e-02f, 2.54340526e-02f, -6.47876188e-02f, -5.13403304e-02f, 7.19510317e-02f, -1.37422904e-01f, -1.02885939e-01f,
  1.46947503e-01f, -1.95003673e-01f, 1.49023682e-01f, 2.43164804e-02f, -4.34329845e-02f, 5.53268865e-02f, 1.59567446e-01f, 2.05197319e-01f, -1.10254705e-01f, -1.04811855e-01f,
  3.89074981e-01f, 2.03299060e-01f, 1.38740852e-01f, 5.75861894e-02f, -6.21044934e-02f, -5.09631187e-02f, -1.62176400e-01f, 1.69571340e-01f, 2.33545080e-01f, -4.10042256e-02f,
  -3.28650847e-02f, 6.13076389e-02f, -1.87534228e-01f, 1.17702745e-01f, -1.06187582e-01f, -7.62630394e-03f, 6.61288993e-03f, -5.96498605e-03f, 2.91577250e-01f, 1.67017639e-01f,
  1.99224398e-01f, 8.15458670e-02f, 5.27251698e-02f, 2.27449521e-01f, 1.02139585e-01f, 5.11932932e-02f, -4.68159504e-02f, 1.07339516e-01f, 9.62644219e-02f, 9.28326920e-02f,
  5.83098568e-02f, -1.08187631e-01f, 3.54687989e-01f, -1.18293874e-01f, 5.03799357e-02f, -2.32875019e-01f, 2.36759767e-01f, 3.88425658e-03f, -5.86360767e-02f, -2.23035723e-01f,
  -2.52834782e-02f, 4.01514202e-01f, 2.29711339e-01f, 2.37424403e-01f, -7.82427937e-02f, 1.16746172e-01f, 2.14363053e-01f, -4.11447100e-02f, -1.12826154e-01f, -2.61299342e-01f,
  3.31608444e-01f, 3.06667775e-01f, -2.44901672e-01f, -7.35463127e-02f, -1.86593205e-01f, -1.31063713e-02f, 1.08423978e-01f, -1.69125021e-01f, -7.01992065e-02f, 5.65392934e-02f,
  -1.24360844e-01f, 1.00934021e-01f, 1.77532788e-02f, -2.06243470e-01f, -1.97856337e-01f, 5.18727712e-02f, 1.26532158e-02f, -1.71021119e-01f, -1.36015981e-01f, -2.14665115e-01f,
  9.29011554e-02f, -1.86474040e-01f, 1.25161782e-01f, 3.57357785e-02f, 2.59811968e-01f, 1.37631908e-01f, 1.73305199e-01f, 2.81900495e-01f, 1.35824054e-01f, 3.18007499e-01f,
  2.31410842e-02f, -5.49865849e-02f, 1.16735920e-02f, 2.21004441e-01f, 7.81505033e-02f, 6.68395311e-02f, 1.13546923e-01f, 9.11039189e-02f, 1.64951339e-01f, 2.19972417e-01f,
  5.02722338e-02f, 5.87290153e-02f, -9.00735334e-02f, -1.06655568e-01f, 6.83620125e-02f, 7.22125694e-02f, 2.70662278e-01f, -5.05848154e-02f, 2.74699569e-01f, -1.01174079e-01f,
  2.87528455e-01f, 6.91457689e-02f, 2.39627630e-01f, 1.27409890e-01f, 1.12337455e-01f, 2.34611884e-01f, 1.69239685e-01f, -7.49341324e-02f, -1.40312105e-01f, 6.24645166e-02f,
  -1.19369783e-01f, -1.82179570e-01f, -3.76005583e-02f, 1.51534960e-01f, 4.00676429e-01f, -1.92588478e-01f, -4.51485477e-02f, 3.13543379e-02f, 3.71885180e-01f, -6.90761283e-02f,
  3.29567313e-01f, -1.92193449e-01f, -6.14663810e-02f, 6.48302138e-02f, 1.26222312e-01f, -8.16974640e-02f, 9.69049633e-02f, -1.27490446e-01f, 5.11139572e-01f, 5.44039868e-02f,
  -6.46852851e-02f, -3.13887782e-02f, 1.04932994e-01f, -1.01621330e-01f, -1.53516680e-01f, -1.82547852e-01f, 2.52019197e-01f, -5.38744368e-02f, 1.19718239e-01f, -5.01770787e-02f,
  -1.45891055e-01f, 2.92926848e-01f, 1.03928121e-02f, 1.25432938e-01f, -5.87517358e-02f, 7.32897744e-02f, 1.94601163e-01f, 4.76267152e-02f, -5.91334142e-02f, -8.40042233e-02f,
  1.73770618e-02f, 3.46129611e-02f, 3.46746109e-02f, 9.40394327e-02f, -3.10444236e-02f, 3.29254791e-02f, -3.34727131e-02f, 1.43030614e-01f, -1.37640983e-01f, 3.33949290e-02f,
  2.42913082e-01f, -1.08662121e-01f, -9.07331612e-03f, 4.48101088e-02f, 2.59238154e-01f, 2.12708011e-01f, -4.72076684e-02f, -9.07366946e-02f, -6.36933371e-03f, 1.21882841e-01f,
  -3.42236273e-02f, 1.98152229e-01f, 9.82760638e-02f, -9.24108326e-02f, 1.69373989e-01f, -4.27564420e-02f, 1.44943684e-01f, 3.63306887e-02f, -2.05225259e-01f, 4.15921748e-01f,
  -8.33155811e-02f, 1.07108742e-01f, -2.11421680e-02f, 1.10018246e-01f, -7.45923072e-02f, 7.54950941e-02f, -1.40319675e-01f, 3.22441459e-01f, -3.17885093e-02f, 3.77647102e-01f,
  -1.48463339e-01f, 2.00923547e-01f, -1.44859806e-01f, 8.88300613e-02f, 2.28356093e-01f, 1.31170660e-01f, 1.91909261e-02f, -2.86525898e-02f, 3.44772965e-01f, 3.60027403e-02f,
  1.13014713e-01f, -2.61545092e-01f, 2.86183553e-03f, 2.54691631e-01f, -9.50788707e-02f, -1.48627192e-01f, 1.30495027e-01f, -1.27323959e-02f, -1.49301738e-01f, -9.30553004e-02f,
  -1.81716025e-01f, 2.65121311e-01f, 8.80130157e-02f, -8.41705129e-02f, 1.59289185e-02f, 4.45482433e-02f, 1.89613372e-01f, 2.23756880e-02f, 1.37408748e-01f, -1.10169798e-01f,
  8.89108889e-03f, -6.33688048e-02f, 1.75149157e-03f, 7.53858462e-02f, 3.17388117e-01f, 1.00088745e-01f, -6.60043433e-02f, 2.71921039e-01f, 1.59323812e-01f, 2.21886430e-02f,
  2.65990466e-01f, 1.66874558e-01f, 1.36114910e-01f, 5.82013875e-02f, 2.26780683e-01f, 2.51719356e-01f, 1.21724434e-01f, -6.62383288e-02f, 2.79145658e-01f, -9.78377182e-03f,
  -1.99659355e-02f, -2.21025646e-01f, 1.40234023e-01f, 3.78263801e-01f, -1.17480576e-01f, -1.73599094e-01f, 2.02645436e-02f, -4.25900845e-03f, 3.60838026e-01f, 1.54462814e-01f,
  -1.24734715e-01f, -3.54027718e-01f, 1.89012781e-01f, 5.49037904e-02f, 1.55234963e-01f, -1.54157624e-01f, 4.04012889e-01f, 4.04058963e-01f, -2.28182122e-01f, -2.59906538e-02f,
  4.06448380e-04f, 8.08209851e-02f, -3.63899916e-01f, 9.64556485e-02f, 1.04610182e-01f, -3.94919738e-02f, -2.58803666e-02f, 2.08591111e-02f, -1.26460716e-01f, 1.73899963e-01f,
  2.41550148e-01f, -2.76846290e-01f, -6.91945106e-02f, 1.84300363e-01f, 2.85912633e-01f, -1.16556562e-01f, 1.11235663e-01f, 2.33583841e-02f, 1.54489964e-01f, 1.36741951e-01f,
  1.34554178e-01f, 2.04521678e-02f, 2.96735913e-01f, 1.60228871e-02f, 8.70052949e-02f, -1.21271066e-01f, 1.67720560e-02f, 7.80817792e-02f, -8.98338556e-02f, 7.54105374e-02f,
  8.73261392e-02f, -2.94116624e-02f, -1.29290223e-01f, -1.86910313e-02f, 2.36613572e-01f, 1.83970824e-01f, 3.39853078e-01f, -2.42788076e-01f, 4.89267297e-02f, -4.96789292e-02f,
  1.31407589e-01f, 1.13141015e-02f, -2.12712828e-02f, 3.64529759e-01f, -8.52409005e-02f, -1.90973468e-02f, -6.16884865e-02f, -2.22862214e-01f, 2.49017909e-01f, -6.06147572e-02f,
  3.54050696e-01f, 2.82420516e-01f, 5.49654216e-02f, -1.44053511e-02f, -1.57911882e-01f, -1.71201788e-02f, 2.46852282e-02f, -3.31475250e-02f, -1.25495255e-01f, 2.03081533e-01f,
  1.71427816e-01f, -2.69099772e-01f, 9.09556150e-02f, 9.39731076e-02f, 2.49499768e-01f, 1.47115991e-01f, 8.90708715e-02f, 9.00268480e-02f, -1.27108069e-02f, -2.43505090e-02f,
  1.64876238e-01f, 1.40120909e-01f, -1.75194547e-01f, -2.54143737e-02f, -1.57566547e-01f, -1.53873578e-01f, 2.55100369e-01f, 3.34931940e-01f, -1.91623271e-01f, -4.92642410e-02f,
  1.26792550e-01f, 9.18127522e-02f, 6.87935427e-02f, 1.21975794e-01f, -5.90550974e-02f, 9.64879319e-02f, 3.72006223e-02f, -1.09907769e-01f, -9.98636857e-02f, -1.80729300e-01f,
  1.75156832e-01f, 4.99439016e-02f, 2.42609173e-01f, 4.39364696e-03f, 2.97308028e-01f, 2.87452340e-02f, 2.18392119e-01f, 3.34655106e-01f, 1.43406749e-01f, 2.91281678e-02f,
  -4.07290012e-02f, -2.47977152e-01f, 1.45414203e-01f, -2.88344473e-01f, -6.36019781e-02f, 4.06588204e-02f, -2.55453527e-01f, -7.35108256e-02f, 1.00150906e-01f, 3.09690237e-01f,
  -2.43592158e-01f, -2.03988031e-01f, 2.10836858e-01f, 2.52506621e-02f, 2.72034407e-01f, 1.47952542e-01f, 8.13803747e-02f, 1.16418369e-01f, 7.91661441e-02f, 2.79700130e-01f,
  -6.96838871e-02f, -1.19847870e-02f, -9.33621228e-02f, 8.67614523e-02f, 1.62557736e-01f, -2.17498913e-01f, -3.45468591e-03f, 6.45190477e-02f, 8.76979381e-02f, 1.01054430e-01f,
  7.11426511e-02f, 1.30584881e-01f, 1.29066659e-02f, 2.31038958e-01f, -7.03785494e-02f, 4.16915119e-02f, -2.32822187e-02f, -2.17977762e-01f, -9.53783542e-02f, -1.96170092e-01f,
  2.62891829e-01f, 7.11033419e-02f, 4.49567735e-02f, 1.50451988e-01f, 6.54018372e-02f, 1.04573779e-01f, -8.57620314e-02f, -2.96170898e-02f, 5.73247261e-02f, 6.52101710e-02f,
  1.17054537e-01f, -1.23479229e-03f, -1.11458667e-01f, -2.20056683e-01f, -2.23680183e-01f, -3.43836769e-02f, -1.71712592e-01f, 1.41145244e-01f, 2.54427314e-01f, 2.91205466e-01f,
  -3.88800204e-01f, -1.80551618e-01f, 3.44943017e-01f, 7.76649341e-02f, -1.14992678e-01f, 5.88836297e-02f, -2.49814056e-02f, -1.23208098e-01f, 3.10773291e-02f, 2.59300624e-03f,
  3.19250189e-02f, 1.01935506e-01f, -1.87318131e-01f, -1.46427736e-01f, -4.84385937e-02f, -9.98904333e-02f, 5.16678020e-02f, 5.87687418e-02f, -4.91129905e-02f, 8.59793946e-02f,
  -7.31036514e-02f, -1.41901195e-01f, -1.09314911e-01f, 1.52891994e-01f, 1.70089398e-02f, 5.21569736e-02f, 1.35911167e-01f, 1.65064663e-01f, -2.36929759e-01f, -9.32448357e-02f,
  2.09015653e-01f, 2.76712716e-01f, 7.12115243e-02f, 2.88945794e-01f, 5.35413763e-03f, 5.36596254e-02f, 9.33363140e-02f, 9.50867087e-02f, 7.39519671e-02f, 2.23973170e-01f,
  -9.52132419e-02f, 3.49866487e-02f, 2.13067047e-02f, -1.52177110e-01f, 1.22844107e-01f, -3.97117846e-02f, 2.15167478e-01f, -3.97441071e-03f, 1.93255380e-01f, 6.13433234e-02f,
  9.26896110e-02f, -5.45707084e-02f, 1.03029244e-01f, 2.26192057e-01f, -4.78598811e-02f, 1.68166950e-01f, -2.39105523e-01f, -3.85155082e-02f, -7.75246322e-02f, 6.06167875e-02f,
  1.46172881e-01f, 3.20096731e-01f, 3.83980602e-01f, -2.83342996e-03f, -2.29597509e-01f, -3.65932137e-02f, -2.36085758e-01f, 8.17974582e-02f, -2.56357282e-01f, 2.24783584e-01f,
  1.74170271e-01f, -1.01100303e-01f, 9.21995789e-02f, -1.85191393e-01f, -2.66292002e-02f, -2.74302764e-03f, -2.46289462e-01f, -1.19207844e-01f, -3.26078445e-01f, 5.84482960e-02f,
  -2.55421549e-03f, -1.62577175e-03f, -7.12269470e-02f, 7.35938177e-02f, -1.41278580e-01f, -4.98329177e-02f, -5.88436499e-02f, 2.32713729e-01f, 2.02444047e-02f, 1.20557167e-01f,
  1.02046365e-02f, -3.94603312e-02f, -5.18908948e-02f, 3.33563179e-01f, 6.30203411e-02f, 2.00301334e-01f, 2.19879523e-01f, -7.49452114e-02f, 1.01178000e-02f, 1.17392957e-01f,
  2.89872974e-01f, 1.39299035e-01f, -1.54165016e-03f, 1.71835676e-01f, -1.34869739e-01f, -2.92491987e-02f, -1.35169342e-01f, -8.38959217e-02f, 1.57014549e-01f, -1.02522925e-01f,
  2.97172636e-01f, 2.59803772e-01f, 1.29688978e-01f, 1.33781239e-01f, 1.14215754e-01f, 1.29582405e-01f, 5.98714016e-02f, 9.03000310e-02f, -1.53087571e-01f, 1.00715691e-02f,
  -1.63957313e-01f, -2.15434060e-01f, -1.01448372e-01f, -2.19181374e-01f, -1.71528067e-02f, 2.42753237e-01f, 2.73681253e-01f, -4.81557734e-02f, -2.09569037e-01f, -2.94713467e-01f,
  -7.86632374e-02f, 1.41899493e-02f, 1.33421957e-01f, 3.25058073e-01f, 3.66531044e-01f, -1.26291677e-01f, 1.24425991e-02f, 4.00699116e-02f, -1.23137072e-01f, -6.50608987e-02f,
  -2.74365366e-01f, -2.96783805e-01f, 3.06382298e-01f, -2.71193162e-02f, 2.75698174e-02f, -5.25431037e-02f, -3.84490527e-02f, -1.25726257e-02f, -8.72669891e-02f, -1.77500933e-01f,
  -1.14989191e-01f, -2.79949695e-01f, -3.95012647e-02f, -1.19362533e-01f, 1.31303579e-01f, -2.67639216e-02f, -7.77087435e-02f, 1.78153977e-01f, -1.80332020e-01f, -1.05193488e-01f,
  1.58367127e-01f, -5.42237833e-02f, -6.44602925e-02f, 6.16715737e-02f, 5.32267103e-03f, -2.10313901e-01f, 8.47116262e-02f, -6.02783374e-02f, 2.08067581e-01f, 3.48680407e-01f,
  7.02822730e-02f, 2.60309458e-01f, 1.41601279e-01f, 5.50928041e-02f, 2.95481265e-01f, -2.10114628e-01f, -3.53885330e-02f, 1.71477258e-01f, 8.53912830e-02f, 6.63933903e-02f,
  1.26029253e-01f, 1.43441055e-02f, 1.03633076e-01f, 3.25497054e-02f, 1.48184076e-01f, 1.08340487e-01f, -1.61521345e-01f, -1.62284479e-01f, -1.01781152e-02f, -4.84425537e-02f,
  -1.00946397e-01f, 4.79840547e-01f, -1.64413482e-01f, 1.51122242e-01f, 7.15949759e-02f, 1.25620842e-01f, 2.63077915e-01f, -3.36366832e-01f, 1.69521850e-02f, 1.69324726e-01f,
  1.44047663e-01f, 6.12460310e-03f, 2.33333230e-01f, 1.22160785e-01f, 2.44740888e-01f, -6.85045421e-02f, 2.32903972e-01f, 4.37446266e-01f, -5.31704463e-02f, -7.79233277e-02f,
  -2.40930602e-01f, 8.40677321e-02f, -1.73677161e-01f, 2.02302113e-02f, 9.19129234e-03f, -1.33397177e-01f, 1.74839184e-01f, 5.03011718e-02f, 6.93806708e-02f, 3.01123649e-01f,
  -9.81994905e-03f, 1.86457075e-02f, 8.66582692e-02f, -3.43280728e-03f, -1.31748363e-01f, 1.89711183e-01f, 1.25640361e-02f, 8.36918727e-02f, -2.93255001e-01f, 8.91966149e-02f,
  1.55284882e-01f, 1.87831651e-02f, -1.06395362e-02f, 6.43206164e-02f, 4.46318179e-01f, -2.48219818e-01f, -3.54359746e-02f, 8.48879591e-02f, -1.12282515e-01f, -1.81996733e-01f,
  1.15648374e-01f, 1.52407899e-01f, 1.99820966e-01f, 6.53712973e-02f, 6.64704144e-02f, 5.50835356e-02f, -1.23125026e-02f, 3.50897163e-02f, 3.85547802e-03f, 6.44549131e-02f,
  1.39984071e-01f, -1.42688006e-01f, -1.26737922e-01f, -2.30845548e-02f, -5.84385730e-02f, 2.04425231e-01f, -1.08301817e-02f, -1.40967146e-01f, 6.22998960e-02f, -1.32458210e-01f,
  -9.41896904e-03f, 1.21944003e-01f, 1.61467791e-01f, 2.00557813e-01f, 6.70484360e-03f, -2.43111715e-01f, 2.90687382e-01f, -2.35691920e-01f, -5.16042449e-02f, -4.57367264e-02f,
  1.39547167e-02f, 3.19263712e-02f, 5.92397759e-03f, -1.24278016e-01f, 4.81448881e-02f, 1.19316757e-01f, 1.31282419e-01f, 9.12939012e-02f, 3.71859409e-02f, 6.26453236e-02f,
  9.00602937e-02f, 1.91393301e-01f, 5.61370328e-02f, 1.55869097e-01f, 1.34548154e-02f, 2.44253755e-01f, -8.34858492e-02f, -2.92866796e-01f, 2.36298949e-01f, -2.04622298e-01f,
  6.50664642e-02f, 8.72189552e-02f, 2.37432152e-01f, -2.51322668e-02f, -1.88995838e-01f, 1.22000657e-01f, -3.31895389e-02f, -1.15663834e-01f, 3.30044746e-01f, 2.94540217e-03f,
  -1.18827086e-03f, -2.43631415e-02f, 4.29647833e-01f, -4.14157100e-03f, 2.38557845e-01f, 2.05388337e-01f, 1.32018328e-01f, -4.90921177e-03f, 2.34679207e-02f, 4.28091697e-02f,
  1.72244489e-01f, -2.81044114e-02f, -1.30864397e-01f, -1.00349464e-01f, -1.81085651e-03f, -9.19634849e-03f, 2.12570816e-01f, -8.85341838e-02f, 1.31369546e-01f, 2.14520097e-01f,
  1.66447788e-01f, 3.00995916e-01f, 3.19649637e-01f, 1.53898582e-01f, 1.35755036e-02f, -2.02536672e-01f, 1.87819570e-01f, -1.83979958e-01f, 4.51563671e-03f, -1.27445394e-03f,
  4.45587598e-02f, 1.40975341e-01f, -7.48525858e-02f, 1.16911279e-02f, 8.87713954e-02f, 1.76319167e-01f, -1.99298054e-01f, -2.02676848e-01f, 1.32233992e-01f, 1.61719665e-01f,
  2.45914459e-01f, 6.04874752e-02f, -2.47610942e-01f, 1.99715178e-02f, -3.27654295e-02f, -5.13046756e-02f, -3.43875475e-02f, -6.31441996e-02f, 4.04529154e-01f, -9.08702686e-02f,
  1.43805772e-01f, 6.80679232e-02f, -8.60422924e-02f, 6.07609823e-02f, -1.57679066e-01f, -1.31130338e-01f, -1.00123622e-01f, 2.35506706e-02f, 1.44839957e-01f, -2.42754482e-02f,
  1.31242089e-02f, -4.09493707e-02f, 1.75583810e-01f, -2.10874632e-01f, 1.22460470e-01f, 7.44363368e-02f, 1.00394048e-01f, 1.85577199e-02f, 1.54801041e-01f, 7.72655681e-02f,
  1.21744731e-02f, 2.49395017e-02f, 3.09633426e-02f, 4.52381186e-02f, 1.43320739e-01f, 9.90971457e-03f, -7.79129863e-02f, -9.89739895e-02f, -6.90275729e-02f, 1.19719267e-01f,
  -1.94606170e-01f, -1.29427597e-01f, 3.12925547e-01f, -7.42964000e-02f, -3.78332101e-02f, 1.31476119e-01f, 3.94392490e-01f, 7.38324299e-02f, -1.40174448e-01f, -5.09561151e-02f,
  -1.15318373e-01f, 2.84198876e-02f, -1.09608527e-02f, -3.05201486e-02f, 1.15997285e-01f, 1.15674185e-02f, 1.93755403e-01f, 1.54161766e-01f, -1.90661520e-01f, -1.59075692e-01f,
  5.10416739e-02f, 1.87030341e-02f, 1.46157295e-01f, 1.56305190e-02f, 4.82925996e-02f, -1.96202964e-01f, -1.40522292e-03f, 1.46798208e-01f, 1.03513645e-02f, 7.42717534e-02f,
  -8.40689987e-04f, 7.38270432e-02f, 1.40939176e-01f, 9.43915993e-02f, 1.62450835e-01f, 1.70368388e-01f, 9.92178991e-02f, 6.55745938e-02f, 2.21941262e-01f, -2.12451592e-02f,
  8.02166685e-02f, -5.24150720e-03f, -1.58259198e-02f, 6.31487891e-02f, -5.73076159e-02f, -1.31525204e-01f, 6.80545345e-02f, -6.83390424e-02f, 6.42130226e-02f, 4.56046360e-03f,
  2.15723962e-02f, 1.53604746e-01f, 1.47815943e-01f, 9.47278216e-02f, 2.60271784e-02f, 2.01143622e-02f, 1.05245218e-01f, 8.82461593e-02f, 2.16923624e-01f, -2.75509451e-02f,
  -1.23185724e-01f, 5.01116253e-02f, 7.90324807e-02f, 8.85524508e-03f, -1.81715220e-01f, 1.63280755e-01f, 1.59876242e-01f, -1.82602014e-02f, -3.50498289e-01f, -1.68728128e-01f,
  1.87710255e-01f, -2.16326932e-03f, 1.44947931e-01f, -1.13184385e-01f, -1.54442593e-01f, 1.23510323e-02f, 1.88775539e-01f, 4.74979617e-02f, 5.10985665e-02f, 2.82208800e-01f,
  -8.78063813e-02f, -2.55829673e-02f, -1.36091411e-01f, -1.90437108e-01f, 7.38671944e-02f, -5.69207594e-02f, 2.29461864e-01f, 1.92356601e-01f, 1.55930787e-01f, -2.10433081e-02f,
  -4.91259024e-02f, 1.79889679e-01f, 5.52694835e-02f, -1.21679291e-01f, -4.22095470e-02f, 2.31254727e-01f, 2.71004327e-02f, -2.19719350e-01f, 1.24676451e-01f, 1.27460822e-01f,
  2.23543912e-01f, 2.13590980e-01f, 1.67993665e-01f, 2.91072000e-02f, 8.99485573e-02f, 9.49420184e-02f, 1.90042421e-01f, 9.33746025e-02f, -1.28550619e-01f, -2.70539289e-03f,
  -2.65941292e-01f, 3.01493257e-02f, 2.03999594e-01f, 2.62140781e-01f, -2.04979837e-01f, -9.13901068e-03f, 1.31677076e-01f, 1.89626172e-01f, 3.09611745e-02f, 1.40125468e-01f,
  1.69091865e-01f, 2.23780572e-02f, 8.40426385e-02f, -1.02602914e-02f, 1.40028819e-01f, -9.58417207e-02f, 1.46285852e-03f, -6.32658452e-02f, 8.23883191e-02f, 5.35253398e-02f,
  5.17093427e-02f, 2.37690270e-01f, -9.30006206e-02f, 1.07509838e-02f, 1.25874475e-01f, 2.65533566e-01f, 1.60037950e-01f, 1.42765269e-01f, 2.55881131e-01f, -3.87026109e-02f,
  1.57968208e-01f, 2.19530836e-01f, -7.84691144e-03f, 2.13894755e-01f, -2.59788066e-01f, -1.73288152e-01f, 2.68851101e-01f, -1.52978852e-01f, 1.05613515e-01f, 4.98111621e-02f,
  1.22515216e-01f, -2.82589607e-02f, 1.82729825e-01f, -1.12464085e-01f, -1.22584641e-01f, 6.78083971e-02f, 5.16128652e-02f, -3.63476239e-02f, 2.04114974e-01f, -1.09591380e-01f,
  2.08718643e-01f, -2.20592737e-01f, 2.70120591e-01f, 5.31144887e-02f, 5.88382035e-02f, 1.85090408e-01f, -1.35129005e-01f, -1.48349926e-01f, -9.52494070e-02f, -1.69849306e-01f,
  3.64303678e-01f, 1.04783855e-01f, 8.49132314e-02f, 3.22088718e-01f, -2.99788028e-01f, 5.73830530e-02f, 5.61917648e-02f, 6.57157823e-02f, -2.21932486e-01f, -2.21395373e-01f,
  1.65421695e-01f, 2.44470224e-01f, 1.58130005e-01f, 1.88193008e-01f, -1.17019583e-02f, 5.18666469e-02f, 1.18454270e-01f, 1.92446500e-01f, 5.25353663e-02f, 2.22163856e-01f,
  -1.15323871e-01f, 1.74186062e-02f, -2.60880202e-01f, 1.21340632e-01f, -1.96668193e-01f, 2.50013936e-02f, -2.16245815e-01f, -2.90759355e-01f, -1.66164592e-01f, -1.83907300e-01f,
  1.77206129e-01f, 2.28505805e-01f, -1.88707665e-01f, 4.25308757e-03f, -2.75239139e-03f, -5.96070252e-02f, 9.37354490e-02f, 2.96481729e-01f, -2.28000566e-01f, 1.36948735e-01f,
  4.23818886e-01f, 5.83624654e-02f, 2.65420765e-01f, 4.81712967e-02f, 3.33883256e-01f, 1.84880182e-01f, -1.12010092e-01f, 9.52237248e-02f, -8.29586834e-02f, 2.34913364e-01f,
  -4.86275330e-02f, 1.34502411e-01f, 1.77799523e-01f, 1.60186976e-01f, 5.78676797e-02f, -1.91596583e-01f, -5.92491180e-02f, -1.58841297e-01f, 3.50575775e-01f, -3.45496237e-02f,
  7.17878640e-02f, -8.92588943e-02f, -4.26237918e-02f, -2.44634494e-01f, 5.04042655e-02f, 2.96930615e-02f, 2.86436737e-01f, 6.56669214e-02f, 9.43088681e-02f, 3.12180012e-01f,
  -1.23984098e-01f, 2.30742782e-01f, 3.06294300e-02f, 3.09660845e-02f, 3.97633500e-02f, 4.15593311e-02f, 9.33060497e-02f, 5.28053381e-02f, 6.34572953e-02f, 1.58330098e-01f,
  -1.43221587e-01f, -4.92898300e-02f, -3.22517991e-01f, -1.87584132e-01f, -1.63525626e-01f, -8.94393846e-02f, -9.35509130e-02f, 1.90006584e-01f, 2.10922733e-01f, -2.31128950e-02f,
  -1.07158110e-01f, -3.08994316e-02f, -1.38045281e-01f, 2.80230880e-01f, 1.21898331e-01f, 3.21192354e-01f, -1.16757251e-01f, -2.74173524e-02f, 3.58053781e-02f, 1.02003142e-01f,
  -1.60152093e-01f, -1.42302215e-01f, 2.66113311e-01f, 2.42773294e-01f, 1.61326349e-01f, 1.03512660e-01f, -2.16877148e-01f, 1.15824468e-01f, -6.90663904e-02f, -3.41560572e-01f,
  5.31241111e-02f, 9.77430418e-02f, 2.86011428e-01f, -1.02227613e-01f, 2.36710384e-01f, -1.14166558e-01f, 5.55718243e-02f, 1.36012569e-01f, 1.34170756e-01f, 1.90572858e-01f,
  1.26745671e-01f, 2.30103925e-01f, -1.65134788e-01f, 1.03123924e-02f, -6.39978498e-02f, 3.30519766e-01f, 2.11689770e-01f, 3.71565938e-01f, -2.11344972e-01f, 5.32792471e-02f,
  -1.88963547e-01f, 8.62040222e-02f, 1.77743524e-01f, 6.38627335e-02f, -1.54763788e-01f, 1.00450225e-01f, 2.73968995e-01f, 7.88588822e-02f, 3.91766764e-02f, -9.11918357e-02f,
  -8.45077857e-02f, -5.63797317e-02f, 1.76092625e-01f, -4.89239395e-02f, -6.16659736e-03f, -1.99456558e-01f, -5.06397374e-02f, -9.44125280e-02f, -1.26659162e-02f, 1.84452668e-01f,
  9.19312611e-02f, 1.03331044e-01f, 1.70451626e-01f, -1.43322349e-01f, 4.28111970e-01f, 1.75217867e-01f, 3.76310587e-01f, 2.61271656e-01f, 7.17151985e-02f, -8.46088212e-03f,
  2.56893128e-01f, -4.40122411e-02f, -8.66060629e-02f, 1.73280686e-01f, -9.05173570e-02f, -1.87808380e-01f, 2.83767432e-01f, 2.05985874e-01f, 9.70065817e-02f, -7.88610056e-02f,
  -1.81834146e-01f, -3.95991541e-02f, 1.17843665e-01f, -1.79213405e-01f, 1.49257779e-01f, -3.41333300e-02f, 9.94770527e-02f, 9.99684036e-02f, -3.28292139e-02f, -9.72583294e-02f,
  -7.76582286e-02f, -9.59866047e-02f, 3.70388448e-01f, -8.93666744e-02f, 3.92828882e-02f, 1.99474260e-01f, -2.04577178e-01f, 9.95492637e-02f, -1.05782479e-01f, 5.69624938e-02f,
  -1.55855482e-02f, -1.71294689e-01f, 9.37711447e-02f, -1.61134526e-01f, -1.38081193e-01f, 9.06755179e-02f, -1.32182151e-01f, 2.16492683e-01f, 8.26898664e-02f, 1.65779293e-02f,
  -2.29697227e-02f, 1.79814339e-01f, 7.53603950e-02f, 3.39389481e-02f, -8.74853879e-02f, 1.84925646e-02f, 5.05793877e-02f, 1.45704508e-01f, 1.19361714e-01f, 8.52179527e-02f,
  1.05350152e-01f, 1.10939428e-01f, 9.96713992e-03f, -3.35688293e-02f, -2.41524786e-01f, 1.48110300e-01f, -5.45716379e-03f, 3.13851148e-01f, -4.80619133e-01f, -4.61284727e-01f,
  2.07996383e-01f, 8.43729004e-02f, 4.88123186e-02f, -4.47555333e-02f, 4.08246331e-02f, 1.17614260e-02f, 1.27060249e-01f, 1.09540954e-01f, 5.43136038e-02f, 4.45233025e-02f,
  -1.52630880e-01f, -1.56290561e-01f, -1.93172302e-02f, -1.59305438e-01f, 3.41881156e-01f, 1.19720489e-01f, 1.67289034e-01f, 1.56105489e-01f, -1.93059295e-01f, -3.42486314e-02f,
  -3.61806639e-02f, -3.07417661e-02f, 6.49402477e-03f, 2.40544565e-02f, 2.85481691e-01f, 8.02401602e-02f, -1.86149999e-01f, -4.43321541e-02f, 1.44716963e-01f, -2.76683626e-04f,
  4.64755177e-01f, 2.03669533e-01f, -1.16693508e-02f, 3.90126929e-02f, 4.99905013e-02f, -3.04552883e-01f, 1.33871675e-01f, 1.64256841e-01f, 1.10951073e-01f, 1.88839450e-01f,
  -1.26990080e-02f, 3.16910803e-01f, 8.00867975e-02f, 2.67985165e-01f, 2.09907144e-02f, -1.42428249e-01f, -4.48237509e-02f, 1.25352427e-01f, 2.14801118e-01f, -8.89078528e-03f,
  6.46544248e-03f, 9.39602554e-02f, 7.09020644e-02f, -4.01697382e-02f, -9.20326263e-02f, -1.37904370e-02f, -4.54677828e-02f, -1.86550960e-01f, -3.20621908e-01f, 1.82286546e-01f,
  2.51049697e-01f, 1.45358175e-01f, -2.69435585e-01f, -1.34140149e-01f, 3.16163540e-01f, 1.79270610e-01f, 1.05324484e-01f, -2.06096500e-01f, -2.09258080e-01f, -6.64418936e-02f,
  1.00560421e-02f, 8.14162195e-02f, -3.08058970e-03f, 1.14908516e-01f, 3.53901810e-03f, 5.65529540e-02f, 2.14387193e-01f, -9.32652503e-02f, 4.03513253e-01f, 1.47375897e-01f,
  2.47100025e-01f, 1.43720552e-01f, -7.51811340e-02f, -7.22678006e-02f, 2.35468209e-01f, 3.51671278e-02f, 5.09277545e-02f, -1.02403730e-01f, 2.01026276e-01f, 1.17539555e-01f,
  -2.02248469e-01f, -2.37447232e-01f, 1.45299599e-01f, 1.78275064e-01f, 3.37556452e-01f, 2.48770326e-01f, -2.76030693e-02f, 2.69146472e-01f, -6.92674965e-02f, 1.65941611e-01f,
  1.19913027e-01f, 3.59715372e-02f, -1.83085173e-01f, -4.88519445e-02f, 7.32492954e-02f, 1.41246557e-01f, 2.39887774e-01f, 2.95682311e-01f, 6.06294982e-02f, -1.67467698e-01f,
  1.80467322e-01f, 5.98375127e-02f, -1.08518619e-02f, 7.64105171e-02f, 1.27931252e-01f, 2.41418257e-01f, 3.32273655e-02f, -4.78156880e-02f, -3.80861163e-02f, 3.97408381e-02f,
  3.30342017e-02f, 2.43909106e-01f, 3.92176121e-01f, 1.81333683e-02f, -6.46323478e-03f, -4.10228223e-01f, 2.61846960e-01f, 2.70207912e-01f, -1.03899702e-01f, 9.83977243e-02f,
  -2.32273457e-03f, 1.20502509e-01f, 7.50130489e-02f, 1.02609113e-01f, -1.98313072e-02f, -4.12190221e-02f, 9.39114094e-02f, 1.78060144e-01f, 8.88235942e-02f, 2.73373246e-01f,
  -3.87315989e-01f, -5.21580279e-02f, -6.87739551e-02f, 2.58087277e-01f, 2.20543712e-01f, 1.65367290e-01f, 3.06531757e-01f, -6.65288717e-02f, -6.16629841e-03f, 6.99687973e-02f,
  -5.17187789e-02f, -2.10957691e-01f, -7.42550045e-02f, -8.06085765e-02f, 1.78214386e-01f, 5.02344444e-02f, -1.85018107e-02f, 4.24111970e-02f, 1.55643016e-01f, -1.08638871e-03f,
  1.00681007e-01f, 3.16285156e-02f, 2.42726952e-01f, 2.21546903e-01f, 7.16940537e-02f, 7.29839131e-02f, 1.51471660e-01f, 2.86798645e-02f, -1.36914343e-01f, 5.51996678e-02f,
  8.70716795e-02f, 1.00798845e-01f, 8.54401141e-02f, 2.21430168e-01f, 2.18318645e-02f, 1.14379890e-01f, -1.07599497e-01f, 3.66965272e-02f, 5.63333854e-02f, 1.22642048e-01f,
  -5.10587208e-02f, 1.48077635e-03f, 2.35562608e-01f, 1.15622237e-01f, 7.64280334e-02f, 2.66301602e-01f, 4.13872004e-01f, 1.91781640e-01f, -9.44498479e-02f, -2.01547354e-01f,
  1.97273135e-01f, 9.91651192e-02f, 5.10341413e-02f, 9.96919870e-02f, 6.26443177e-02f, 9.79840010e-02f, 1.00345522e-01f, 1.19267046e-01f, 1.73657268e-01f, 3.78501952e-01f,
  -5.10552302e-02f, 1.47848397e-01f, -2.63030343e-02f, 1.13510797e-02f, 1.97580177e-02f, -1.92717016e-01f, 8.48352984e-02f, 1.35851979e-01f, 1.46109518e-02f, 2.32060954e-01f,
  -2.67250575e-02f, -1.11827180e-02f, 2.40566701e-01f, -5.98720647e-02f, -7.90658295e-02f, -1.96903273e-02f, 1.59482092e-01f, -1.19069353e-01f, -1.90390795e-01f, 7.10566789e-02f,
  -1.75862223e-01f, -5.99791221e-02f, 1.25771940e-01f, -1.67433526e-02f, 1.28914267e-01f, 7.77939484e-02f, 1.77927002e-01f, 1.03326574e-01f, 3.09025228e-01f, 2.10098907e-01f,
  8.94615501e-02f, 3.16711754e-01f, -2.15879396e-01f, 2.82291740e-01f, 3.10286164e-01f, 1.58614591e-01f, -5.35165183e-02f, 5.29656522e-02f, 1.75719976e-01f, 1.15176119e-01f,
  6.76065460e-02f, 2.10681066e-01f, 3.05276271e-02f, -1.88079663e-02f, 9.34311002e-02f, -2.45694648e-02f, 7.55311847e-02f, -6.83610588e-02f, -1.34887844e-01f, -3.33146304e-01f,
  1.65019315e-02f, -1.24816321e-01f, 1.59946352e-01f, 2.83309609e-01f, 1.04376771e-01f, 5.02988696e-01f, -1.92164797e-02f, 1.13753164e-02f, 4.41963188e-02f, -1.72259152e-01f,
  1.58454463e-01f, -2.69785542e-02f, -6.22989498e-02f, 1.20708540e-01f, 1.24833010e-01f, 7.43096694e-02f, 2.00593248e-01f, 1.69632912e-01f, 2.29734957e-01f, 3.66808027e-01f,
  -1.23449109e-01f, -1.49547040e-01f, -2.11626902e-01f, 1.93785042e-01f, -2.84911022e-02f, 7.60239437e-02f, -9.46066156e-02f, 2.23217197e-02f, -1.48674130e-01f, 1.33728147e-01f,
  8.26410484e-03f, 2.68525869e-01f, -1.70402855e-01f, 5.90217896e-02f, 1.76752269e-01f, 3.72528940e-01f, -2.75520653e-01f, 1.35583892e-01f, 1.78411797e-01f, -1.58171207e-02f,
  -2.17899874e-01f, 1.21613026e-01f, 4.62870821e-02f, -7.32812956e-02f, 4.66205627e-02f, -1.69106871e-01f, 3.07326406e-01f, -1.77122921e-01f, 2.42167383e-01f, -1.66067496e-01f,
  -1.23226106e-01f, 2.19357405e-02f, -2.37319414e-02f, 2.99839042e-02f, 1.64017335e-01f, 2.40689665e-01f, -7.55216107e-02f, 1.76137760e-01f, -1.41599640e-01f, -1.12974890e-01f,
  -2.04326361e-01f, -2.12682351e-01f, -1.33761428e-02f, -1.62197743e-02f, -5.42250462e-02f, 1.00670513e-02f, 2.25036055e-01f, -7.37213865e-02f, 2.76239216e-01f, 3.71754557e-01f,
  -2.56602541e-02f, 1.01284057e-01f, -2.76163250e-01f, 2.21216176e-02f, -1.63702726e-01f, 7.36611411e-02f, 4.76963446e-02f, -3.11004445e-02f, 7.16997907e-02f, -1.47297785e-01f,
  4.23934579e-01f, 4.71489787e-01f, -7.63182938e-02f, -4.11042273e-02f, -7.57961944e-02f, 3.17181259e-01f, 1.69603974e-01f, -1.17951576e-02f, 4.34623174e-02f, -1.71329647e-01f,
  2.94104666e-01f, 2.50225514e-01f, -4.29394282e-02f, 1.50066167e-01f, 7.39528164e-02f, 1.27318934e-01f, 6.58066049e-02f, 3.42877030e-01f, -1.17305387e-02f, 3.98965105e-02f,
  -7.02862907e-03f, -2.61848688e-01f, 2.31519952e-01f, 1.13340989e-01f, 2.58298457e-01f, 1.65800735e-01f, -2.67159581e-01f, 9.46944207e-03f, -7.46697783e-02f, -1.89785019e-01f,
  4.03655618e-01f, 2.13874504e-02f, 1.27145991e-01f, -1.15067042e-01f, 4.87248123e-01f, 4.08492506e-01f, 9.48927253e-02f, -2.41492782e-02f, -1.51884079e-01f, 2.12712642e-02f,
  -3.45796496e-02f, -4.12298087e-03f, -6.05998039e-02f, 7.22870678e-02f, -3.77595909e-02f, 1.69550255e-01f, -1.14346957e-02f, -8.65261480e-02f, 1.10662512e-01f, 6.74815848e-02f,
  1.48416042e-01f, 1.57825738e-01f, 1.10764422e-01f, 1.88205764e-02f, -1.50257275e-01f, 2.44573541e-02f, -1.27888322e-01f, 1.70469463e-01f, -6.87338710e-02f, 3.27285454e-02f,
  7.92261139e-02f, -7.18097240e-02f, 2.05717102e-01f, 2.27402113e-02f, -7.57075772e-02f, -5.60705699e-02f, -2.05709994e-01f, 2.79829860e-01f, 1.82679236e-01f, 1.36214256e-01f,
  6.22292496e-02f, 1.37313113e-01f, 3.85284461e-02f, -8.07640105e-02f, 3.18896696e-02f, 2.93898731e-01f, -1.15619913e-01f, 3.45529795e-01f, -1.32731140e-01f, 1.49265394e-01f,
  -2.99292386e-01f, 7.89442733e-02f, 2.35948473e-01f, 1.78387374e-01f, 1.02577895e-01f, 1.06379256e-01f, 1.26246229e-01f, 3.06101106e-02f, 2.07561344e-01f, -1.12782873e-01f,
  -1.12809330e-01f, 3.61993283e-01f, -1.50307745e-01f, -1.72768772e-01f, -1.25556216e-01f, -1.12907775e-01f, -2.92511471e-02f, 1.67295501e-01f, -1.96814835e-01f, 2.23682061e-01f,
  6.40266910e-02f, 1.96274370e-02f, -2.29460932e-02f, -3.42972018e-02f, 5.14689088e-02f, 7.84489363e-02f, -4.88870256e-02f, 4.20789309e-02f, -2.29817480e-01f, -7.68758357e-02f,
  -6.14654906e-02f, 1.08697295e-01f, -1.84907749e-01f, 7.74582699e-02f, 1.88187584e-01f, -8.33106562e-02f, -4.79638539e-02f, -1.38052151e-01f, 6.04487918e-02f, 1.89984456e-01f,
  1.99112892e-01f, 2.88407933e-02f, -1.58166766e-01f, -5.33978827e-02f, 4.42302898e-02f, 6.69398382e-02f, -3.04529667e-02f, 9.27397534e-02f, 1.50051713e-01f, 1.08248681e-01f,
  -1.58143744e-01f, -1.00639582e-01f, 1.78278703e-02f, 3.14743906e-01f, 2.04969674e-01f, -1.52162351e-02f, 1.37639627e-01f, 2.35965066e-02f, 1.16884828e-01f, 1.07634552e-02f,
  2.35142291e-01f, -6.68924600e-02f, -7.30596557e-02f, 1.18737139e-01f, 2.67897010e-01f, 1.94439799e-01f, 1.79880232e-01f, 9.23802331e-02f, 1.34137645e-01f, 1.86225995e-01f,
  -5.13353869e-02f, 2.42758349e-01f, 2.03292325e-01f, 3.62972587e-01f, -5.49069867e-02f, 2.37291351e-01f, -1.65946677e-01f, 3.90701601e-03f, -1.69011116e-01f, -1.50457153e-03f,
  -8.37573111e-02f, 2.40313202e-01f, 1.36212960e-01f, 2.35714331e-01f, -2.32208520e-03f, 4.70820703e-02f, 6.56730905e-02f, 2.22901218e-02f, -9.74371843e-03f, -3.70239792e-03f,
  -5.87394647e-02f, 5.12502193e-02f, -3.53162400e-02f, -2.83326264e-02f, 1.73456073e-02f, 6.97710514e-02f, 5.05328402e-02f, 5.80816753e-02f, 1.47777587e-01f, -1.56367138e-01f,
  -6.39693365e-02f, -1.07480958e-01f, 1.18675150e-01f, -8.90430808e-02f, -2.66464613e-02f, 8.48685130e-02f, 5.61822392e-02f, -2.92702159e-03f, 5.52831925e-02f, -2.68105343e-02f,
  -5.61545156e-02f, -1.21616557e-01f, -2.93313842e-02f, 1.34110093e-01f, -9.86265466e-02f, -1.22712836e-01f, 1.47050291e-01f, -9.61908400e-02f, 2.26056412e-01f, 1.12439789e-01f,
  1.54346049e-01f, -1.34562060e-01f, -1.39745860e-03f, -1.45401016e-01f, 4.77482099e-03f, 7.17588812e-02f, 8.26202258e-02f, 3.82484533e-02f, -6.03938615e-03f, -2.81135626e-02f,
  -5.03838174e-02f, -4.82628345e-02f, 2.36232296e-01f, -1.78206041e-02f, -5.41642122e-02f, 7.19238967e-02f, 9.27964374e-02f, 8.08162093e-02f, 3.76963578e-02f, -6.77873986e-03f,
  -9.09236893e-02f, 6.60605654e-02f, -1.83223441e-01f, 7.47305974e-02f, 5.42270094e-02f, 5.18261306e-02f, 1.17969289e-01f, -8.32527578e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  7.01744184e-02f, 5.17749898e-02f, 1.34236723e-01f, 1.00460954e-01f, -3.19819339e-02f, 7.90518597e-02f, 1.39474034e-01f, -1.47725865e-02f, 3.50416638e-02f, 9.63944718e-02f,
  1.72800198e-01f, 9.83073786e-02f, 2.39369757e-02f, 1.53566614e-01f, 1.23854458e-01f, 1.61939710e-01f, 9.53446180e-02f, -1.70554798e-02f, 9.28861722e-02f, 5.20645231e-02f,
  1.46403894e-01f, 1.98494673e-01f, 1.73146710e-01f, -8.76188949e-02f, 1.53529882e-01f, 1.45092651e-01f, 1.71859443e-01f, -7.53475772e-03f, 2.18448579e-01f, 1.24111027e-01f,
  1.35832921e-01f, -4.11666781e-02f, 1.36103213e-01f, 2.48889253e-01f, -4.92114238e-02f, 1.37431443e-01f, 8.38188156e-02f, -7.48954937e-02f, 2.98004802e-02f, 6.38850406e-02f,
  1.59162000e-01f, 2.05739379e-01f, 1.04178749e-02f, 5.99351041e-02f, 6.32292405e-02f, -1.60160977e-02f, 1.31503493e-01f, 1.50188729e-01f, 2.29980230e-01f, 1.52386010e-01f,
  -8.86274443e-04f, -4.17730995e-02f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  2.35788360e-01f, 9.21236649e-02f, 1.94121927e-01f, -5.01123250e-01f, -3.32012400e-02f, -3.64702828e-02f, 1.12921394e-01f, -3.38016212e-01f, 6.75234124e-02f, -2.88579613e-01f,
  -3.27560842e-01f, 3.21608365e-01f, 2.09958762e-01f, -2.38284826e-01f, 9.91218090e-02f, -1.37481373e-02f, -4.13831353e-01f, -4.49551642e-01f, -4.85028327e-01f, 3.85297894e-01f,
  -1.92460164e-01f, 8.12565088e-02f, -1.43394604e-01f, 1.75721437e-01f, 2.17431128e-01f, -2.61835486e-01f, 1.93011895e-01f, 2.23998889e-01f, 8.28345045e-02f, -8.98939446e-02f,
  -2.81053275e-01f, -2.12968383e-02f, -4.02083635e-01f, -1.95593491e-01f, -5.48937619e-01f, 2.15986580e-01f, -5.75452177e-05f, -2.25720406e-02f, -2.31902122e-01f, 1.02779157e-01f,
  1.28846674e-04f, -1.13205034e-02f, -1.67722747e-01f, 7.93266371e-02f, -1.36945903e-01f, -1.85117021e-01f, 2.46999279e-01f, 2.29530245e-01f, -6.46155924e-02f, 8.79928768e-02f,
  4.95813042e-02f, -8.96027908e-02f, -7.18922075e-03f, -3.52396250e-01f, -1.37568504e-01f, 2.40342692e-01f, 4.55301218e-02f, -2.75829464e-01f, -3.92813981e-01f, 3.44761014e-02f,
  -7.40115941e-02f, 4.01583128e-02f, -1.03546180e-01f, -1.13568850e-01f, -3.60370696e-01f, 1.59333516e-02f, -2.06507549e-01f, 2.58143485e-01f, 4.66114990e-02f, -2.96054393e-01f,
  -2.13872492e-01f, 4.56789225e-01f, 2.46649399e-01f, -1.24376394e-01f, 8.64597186e-02f, -2.56804228e-01f, 1.64250851e-01f, -5.77481329e-01f, -3.48960131e-01f, -1.27961576e-01f,
  1.14115052e-01f, -3.90779257e-01f, -4.37426627e-01f, -1.67078584e-01f, -1.02494890e-02f, 1.36387855e-01f, -5.14323711e-01f, 7.41709098e-02f, -1.39099419e-01f, 9.85240042e-02f,
  -1.78611562e-01f, 2.29717165e-01f, -2.72537857e-01f, 2.29797855e-01f, -7.52293393e-02f, 1.55005589e-01f, 1.86261147e-01f, 1.79542094e-01f, -6.63444698e-01f, 4.55472022e-02f,
  -8.38841498e-02f, -2.86597431e-01f, -4.82380569e-01f, -1.41643630e-02f, -6.42122477e-02f, 2.07087398e-01f, -1.87171325e-02f, 1.87995985e-01f, -7.89970439e-03f, -1.64185300e-01f,
  2.30176657e-01f, -2.19947219e-01f, -5.96086979e-02f, -1.04041778e-01f, 2.31787696e-01f, 1.75242782e-01f, 5.69225438e-02f, -4.06733993e-03f, -3.27239037e-01f, 1.94169879e-01f,
  2.96850026e-01f, -9.50338244e-02f, 1.29772916e-01f, 4.66015488e-02f, -5.27509272e-01f, 2.15832055e-01f, 7.53336772e-02f, -7.75029734e-02f, -1.62867472e-01f, 1.80482596e-01f,
  8.83371904e-02f, 2.13822424e-01f, 1.13871530e-01f, -6.90627396e-02f, 3.43138009e-01f, 3.43336873e-02f, -2.42399648e-01f, -9.02482346e-02f, 5.15436046e-02f, 2.45008215e-01f,
  -6.11685179e-02f, -5.54073714e-02f, -5.58677852e-01f, -2.41015360e-01f, -2.34307256e-02f, -2.19594315e-01f, 4.32281941e-02f, -3.27129066e-01f, -1.93920106e-01f, 2.27376446e-02f,
  -9.71796736e-02f, -2.68744081e-01f, -1.66889921e-01f, -3.44548106e-01f, 2.54778296e-01f, 3.09867024e-01f, 3.54091495e-01f, 2.26758689e-01f, -1.97086379e-01f, -2.12630257e-02f,
  1.93691730e-01f, 2.07112029e-01f, -4.64563519e-02f, -1.88102826e-01f, 4.84586544e-02f, 4.93463427e-02f, 1.74152821e-01f, -5.31952381e-01f, 1.98602915e-01f, -2.25121394e-01f,
  1.34067731e-02f, -1.07186124e-01f, -1.70363113e-02f, 1.82933629e-01f, 2.75960237e-01f, 2.37805292e-01f, 2.42688566e-01f, -2.65046746e-01f, -2.50038803e-01f, -6.94099218e-02f,
  2.30751768e-01f, 1.98663875e-01f, -2.94430971e-01f, -1.35186881e-01f, 1.09272875e-01f, -6.21484339e-01f, -4.56292063e-01f, 3.39833558e-01f, 8.58565345e-02f, -5.69457769e-01f,
  -1.23596668e-01f, -2.73096472e-01f, -2.60850668e-01f, 9.01440233e-02f, -1.26795247e-01f, 2.87881251e-02f, -1.08545922e-01f, -1.62442073e-01f, 2.78999686e-01f, -9.27781090e-02f,
  1.16581552e-01f, 1.40273437e-01f, 2.19301894e-01f, 2.61327535e-01f, -7.71388188e-02f, -8.44418705e-02f, -6.99305981e-02f, -9.70948786e-02f, -2.35707507e-01f, 2.85430014e-01f,
  9.07012671e-02f, 2.95164734e-01f, -3.68555099e-01f, 2.78388530e-01f, 2.29209334e-01f, 1.14274725e-01f, -2.66364127e-01f, -5.46624362e-02f, 1.34594455e-01f, -5.96170723e-01f,
  3.18225205e-01f, 2.88427174e-01f, 4.06617761e-01f, -1.48805663e-01f, -6.80526316e-01f, 3.72278271e-03f, 1.39105111e-01f, -3.12406480e-01f, -1.16919488e-01f, -3.52032552e-03f,
  -3.92552525e-01f, 2.27921411e-01f, -3.40661436e-01f, -1.53452620e-01f, -7.76694193e-02f, -2.42789909e-01f, -1.17575482e-01f, -8.42774510e-02f, 2.28090435e-01f, -4.80622686e-02f,
  -5.62690645e-02f, 5.83270304e-02f, -8.42381716e-02f, -3.24415416e-01f, -1.94438204e-01f, -9.63224173e-02f, -3.85089815e-02f, -4.94712204e-01f, -4.08385038e-01f, 1.08013608e-01f,
  -4.29598808e-01f, 3.51102322e-01f, 1.38227984e-01f, -1.38649605e-02f, -1.70674577e-01f, -9.44491774e-02f, 1.99760377e-01f, -3.22140232e-02f, -3.61352056e-01f, 2.51698166e-01f,
  -1.76095292e-02f, 3.64274591e-01f, 3.85354489e-01f, -5.39731026e-01f, 7.10094199e-02f, -2.44289115e-01f, 7.26240799e-02f, 1.26132727e-01f, -8.23910534e-02f, 2.04521164e-01f,
  2.30790809e-01f, 5.44222556e-02f, 1.62812963e-01f, -1.55815542e-01f, 3.06519747e-01f, -3.35064113e-01f, -2.40969613e-01f, -3.35013926e-01f, 9.44764391e-02f, -2.05368325e-01f,
  1.17566288e-02f, -7.60516226e-02f, 1.38846800e-01f, -6.86893016e-02f, 2.97060926e-02f, -3.66070122e-01f, 9.63549763e-02f, 6.35157973e-02f, 3.76668684e-02f, -3.78928900e-01f,
  1.08833574e-01f, 2.24360883e-01f, 1.86412588e-01f, 1.98225439e-01f, -1.90124795e-01f, 1.87484413e-01f, -6.10687919e-02f, -2.54871964e-01f, -1.32600069e-01f, -1.37898654e-01f,
  1.37195319e-01f, -5.01233220e-01f, -8.13909322e-02f, 1.19643711e-01f, -1.41419604e-01f, -6.71817884e-02f, -6.10846281e-02f, -3.20417076e-01f, 1.08516486e-02f, -2.45725252e-02f,
  -2.53823966e-01f, -3.36569041e-01f, -3.88584137e-01f, 1.95536464e-01f, 4.34284993e-02f, -1.24342762e-01f, -6.84205303e-03f, 1.81217730e-01f, 6.27103895e-02f, -1.63153574e-01f,
  1.73981134e-02f, 2.57528782e-01f, -2.81936973e-01f, 3.42627279e-02f, 3.50650959e-02f, -2.15946674e-01f, -1.61732092e-01f, 2.37128437e-01f, -3.27337772e-01f, 1.78831760e-02f,
  -3.66852164e-01f, -1.83145583e-01f, 1.69923767e-01f, 3.82853627e-01f, 2.28821024e-01f, 1.71696246e-01f, -5.86278886e-02f, -8.69759321e-02f, -4.40920442e-01f, -3.79886568e-01f,
  -7.56778345e-02f, 1.18184397e-02f, 3.46694022e-01f, -8.91007558e-02f, 2.13478655e-01f, 1.93945244e-01f, -3.00731272e-01f, -2.27317229e-01f, -3.88121068e-01f, -3.94747347e-01f,
  -2.94918388e-01f, -3.40477169e-01f, -2.02117726e-01f, -2.48479992e-01f, 9.85421836e-02f, -5.67805953e-02f, 8.30944534e-03f, -2.80130982e-01f, 1.01992935e-01f, 1.72670151e-03f,
  -3.87162656e-01f, 2.00980753e-01f, 2.00862035e-01f, -1.03107952e-02f, 1.04831748e-01f, -1.42556266e-03f, -3.61706644e-01f, 1.80651285e-02f, 2.54438445e-03f, 4.35490608e-02f,
  2.44323492e-01f, -5.73602552e-03f, 2.90209383e-01f, -2.84734666e-01f, -2.41378576e-01f, 1.28752843e-01f, 1.53548643e-01f, 2.64017075e-01f, -2.21793689e-02f, -2.20599085e-01f,
  8.63109902e-02f, 1.04051635e-01f, 7.49654770e-02f, 2.25589782e-01f, 1.25148743e-01f, 1.34639546e-01f, 2.39077941e-01f, -8.35984796e-02f, 2.12975919e-01f, 1.40373439e-01f,
  -4.49753523e-01f, 1.37056395e-01f, 2.97536939e-01f, 3.28526273e-02f, -2.79517956e-02f, 2.01316386e-01f, -2.11963549e-01f, -1.49751678e-01f, -2.59969890e-01f, -4.60430002e-03f,
  -2.66514301e-01f, -4.64332938e-01f, 2.91989177e-01f, -3.08111100e-03f, 1.97274104e-01f, -1.56124741e-01f, -3.08979034e-01f, 1.17129855e-01f, -4.13132489e-01f, -1.08855590e-02f,
  8.73724818e-02f, -1.48508148e-02f, -3.52030098e-01f, -1.66180283e-01f, -1.06555752e-01f, -5.01635253e-01f, 3.28766078e-01f, -7.97747672e-02f, 4.95762587e-01f, -2.82186270e-01f,
  -4.20119643e-01f, 2.51319826e-01f, 2.26182461e-01f, -1.37266085e-01f, -3.97411346e-01f, -2.44072050e-01f, -2.81680644e-01f, -3.59076142e-01f, -5.15991688e-01f, 2.11520672e-01f,
  -2.60970384e-01f, -4.54532951e-01f, -3.99149001e-01f, -9.47576985e-02f, -3.92024629e-02f, 2.87589639e-01f, 2.75040001e-01f, -8.09655413e-02f, 1.34492621e-01f, 2.26556972e-01f,
  1.54587673e-02f, -1.22284763e-01f, 2.43581548e-01f, -4.21059132e-01f, -4.43548471e-01f, -1.36917785e-01f, -3.59156549e-01f, 3.24590765e-02f, -2.23095831e-03f, -5.68317883e-02f,
  -1.13371480e-03f, 1.06754743e-01f, -1.51556164e-01f, -7.19751185e-03f, 1.26556098e-01f, 2.46450171e-01f, 2.51041532e-01f, -1.06634088e-01f, 7.44510591e-02f, -8.72545317e-02f,
  -1.77927703e-01f, 3.09611037e-02f, -1.83823600e-01f, -2.97538698e-01f, 1.58249706e-01f, -3.82186264e-01f, -2.96447407e-02f, -3.00117563e-02f, 1.24257706e-01f, 6.12808280e-02f,
  2.69075692e-01f, 1.43193733e-02f, -1.86684340e-01f, 1.69601172e-01f, -3.53248447e-01f, -2.64167607e-01f, 2.67380655e-01f, -1.88336931e-02f, 2.34147608e-01f, 7.86835626e-02f,
  -3.01657110e-01f, -1.11379854e-01f, 1.20780237e-01f, 1.13751084e-01f, -1.40218809e-01f, -3.44505727e-01f, -2.14369908e-01f, -3.29850793e-01f, -2.75706828e-01f, -3.79282296e-01f,
  2.40190744e-01f, -3.63687098e-01f, -5.49958684e-02f, -4.18736607e-01f, 3.81514505e-02f, -1.28656283e-01f, -2.50743330e-01f, -6.01944961e-02f, -2.41453171e-01f, -4.53508914e-01f,
  -3.05655599e-01f, 2.57481664e-01f, 1.59420297e-01f, -2.45250747e-01f, 1.89232409e-01f, 4.79584225e-02f, 7.94159994e-02f, 2.57405471e-02f, 4.51554269e-01f, -2.38491222e-01f,
  1.52697757e-01f, -8.80005583e-02f, 1.72883660e-01f, -2.56422311e-01f, 2.29345649e-01f, -2.10172370e-01f, 1.48596545e-03f, 2.47463971e-01f, -2.24613681e-01f, -3.36128287e-02f,
  2.17635423e-01f, 2.78584093e-01f, 1.36457488e-01f, -1.23116277e-01f, -4.95599329e-01f, -3.12538594e-01f, -5.27616382e-01f, 4.46353778e-02f, 2.24187970e-01f, 3.43517482e-01f,
  -7.53997117e-02f, 1.96008787e-01f, -1.64246574e-01f, 2.09058806e-01f, -8.98211077e-02f, -9.25770476e-02f, 1.17613465e-01f, -4.17148694e-02f, -2.45638326e-01f, -1.79601505e-01f,
  -2.71882862e-01f, 1.32650912e-01f, -1.54338315e-01f, -1.05531797e-01f, -1.09227248e-01f, 2.21454203e-01f, 5.82888164e-02f, -2.53402323e-01f, 3.21338564e-01f, -1.53867543e-01f,
  3.03159773e-01f, -3.65949690e-01f, 3.45713377e-01f, 1.75356314e-01f, 1.60898454e-02f, -2.09813386e-01f, -3.74422908e-01f, -2.52630830e-01f, -4.23483405e-04f, -1.55125856e-01f,
  2.00791493e-01f, 1.55254407e-02f, 7.12551177e-02f, 7.88455233e-02f, -2.85724521e-01f, 1.43313229e-01f, 3.18635464e-01f, -2.94095278e-01f, -9.99369696e-02f, 1.10866442e-01f,
  -9.24952030e-02f, -4.38254327e-01f, -3.27372700e-01f, -3.93259108e-01f, 1.81052268e-01f, 1.05565200e-02f, 3.09008509e-01f, -7.92651027e-02f, 2.16709133e-02f, 4.47057895e-02f,
  -7.43014514e-02f, 1.64534703e-01f, 1.76786244e-01f, -1.80859789e-01f, -8.37650448e-02f, 1.83164746e-01f, -3.29539739e-02f, -5.39726019e-01f, -3.94791901e-01f, 2.93665141e-01f,
  1.16544753e-01f, -1.56201079e-01f, -1.76993474e-01f, -2.72931337e-01f, 1.07956149e-01f, -2.14638337e-01f, 2.40800589e-01f, -4.55644459e-01f, 2.32767671e-01f, -4.71581891e-03f,
  5.29550612e-01f, -2.44410008e-01f, 1.44745812e-01f, 2.21926078e-01f, -3.80613923e-01f, -8.73511285e-02f, -3.17135781e-01f, 2.54671961e-01f, 1.91898286e-01f, -3.72193009e-01f,
  -2.87786901e-01f, 1.54702634e-01f, 1.63551360e-01f, 8.25176854e-03f, 1.01804502e-01f, -3.81767184e-01f, 1.48719206e-01f, -4.86681521e-01f, -1.59825757e-01f, 7.68738519e-03f,
  4.28272933e-01f, 2.27834761e-01f, -2.36903280e-01f, 5.38133867e-02f, -3.93000245e-01f, -3.64641130e-01f, -2.66090512e-01f, -8.48596245e-02f, -1.56042963e-01f, 1.32297561e-01f,
  -1.37931600e-01f, 8.53853226e-02f, -1.38581529e-01f, -3.91935594e-02f, 2.05749143e-02f, -5.57983398e-01f, -6.24251133e-03f, -3.79538268e-01f, -8.53293538e-02f, 8.06279629e-02f,
  1.13834001e-01f, 2.23574378e-02f, 2.08118200e-01f, -1.25538155e-01f, -1.85009062e-01f, 7.40200654e-02f, -6.61183847e-03f, 2.59203970e-01f, -5.31595349e-02f, 7.44047910e-02f,
  1.23515256e-01f, 2.90284187e-01f, 7.40461498e-02f, -3.99326116e-01f, 3.44550349e-02f, 4.08744067e-02f, -3.54837805e-01f, 1.56264365e-01f, -3.14333439e-01f, -2.12091982e-01f,
  -2.02221319e-01f, 1.24539353e-01f, -2.48618901e-01f, -2.33782932e-01f, -4.05821443e-01f, -2.84973472e-01f, 6.80498371e-04f, -2.36232385e-01f, -3.15789908e-01f, -8.46110955e-02f,
  1.25082294e-02f, 2.98094809e-01f, -2.11332068e-01f, -2.95735449e-01f, 4.00744766e-01f, -3.50144863e-01f, 1.61696985e-01f, -1.69776618e-01f, 1.04716808e-01f, -1.90164242e-02f,
  -6.56306684e-01f, -3.50296721e-02f, 2.31694937e-01f, 3.71439368e-01f, 3.21732908e-01f, -1.27652183e-01f, -3.01732421e-01f, -3.95215213e-01f, 1.34085983e-01f, 2.81746179e-01f,
  1.75408050e-01f, 1.06509864e-01f, -5.34164667e-01f, 2.35276103e-01f, 2.76008129e-01f, -2.67298639e-01f, 9.06281918e-02f, 1.96379200e-02f, -2.67197847e-01f, 1.60114616e-01f,
  1.78959310e-01f, 1.17692687e-01f, 1.21869251e-01f, -1.12480000e-01f, -6.10167794e-02f, 1.53041184e-01f, 9.01960209e-02f, -1.18911654e-01f, -1.66560188e-01f, -5.04005589e-02f,
  -2.58100718e-01f, -2.95618266e-01f, -1.21774770e-01f, 6.35773242e-02f, 2.38076329e-01f, -2.34860882e-01f, -2.28819698e-01f, 7.68337473e-02f, 2.05878168e-01f, 2.06192166e-01f,
  -2.32922226e-01f, 2.40751609e-01f, -2.48187501e-02f, -1.25284091e-01f, -4.18149158e-02f, -3.44201446e-01f, 1.59675390e-01f, 2.88108945e-01f, -9.43115056e-02f, -9.62900463e-03f,
  -1.17652327e-01f, -2.29419559e-01f, 2.86697984e-01f, -1.07221842e-01f, 2.59783417e-01f, -3.51990342e-01f, -1.70338377e-01f, 8.01490694e-02f, -3.10105592e-01f, -3.54104966e-01f,
  -3.11494321e-01f, 1.87058076e-01f, 1.78986564e-01f, -1.87052235e-01f, 2.09660441e-01f, -1.62807070e-02f, 2.40944907e-01f, -9.95265916e-02f, -9.27083418e-02f, -2.40299776e-02f,
  6.40148520e-02f, -1.65243149e-01f, 3.16307068e-01f, -1.78916499e-01f, -1.71574220e-01f, 2.39976078e-01f, -4.42099988e-01f, -3.80611151e-01f, 1.28051713e-01f, -2.05482110e-01f,
  -2.78990120e-01f, 1.29001692e-01f, 1.97675809e-01f, 2.50630945e-01f, -3.16022009e-01f, -1.46264032e-01f, -3.64463061e-01f, -6.77375421e-02f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -8.39727521e-02f, -1.24148391e-01f, 6.31510392e-02f, -1.37017384e-01f, 2.99776327e-02f, 4.67921011e-02f, 1.14655867e-01f, -4.39162925e-02f, -1.46637224e-02f, 2.20155474e-02f,
  -3.14701833e-02f, 5.03584519e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    