/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.13707644e-02f, -8.05911049e-02f, 4.87638444e-01f, 8.78098160e-02f, -2.10584160e-02f, 2.67206222e-01f, 4.11854424e-02f, -6.75697029e-02f, 2.30096743e-01f, -2.03270465e-01f,
  -3.76624882e-01f, 2.61797786e-01f, -2.68699285e-02f, -3.68854821e-01f, -4.64900315e-01f, 7.85541534e-03f, 2.73791775e-02f, 1.62310436e-01f, 1.55566961e-01f, 2.40613699e-01f,
  1.09793521e-01f, -6.07446790e-01f, -8.75095427e-02f, -1.50856212e-01f, 1.07160345e-01f, 2.48338148e-01f, -1.45487010e-01f, 4.63423245e-02f, -1.82472587e-01f, -2.73734629e-01f,
  2.85921036e-03f, -1.35390103e-01f, 2.39328220e-02f, 1.89506207e-02f, 9.32366475e-02f, 6.30846545e-02f, 1.24803573e-01f, 3.78165990e-02f, -2.53607195e-05f, -5.07060066e-02f,
  1.19822174e-01f, -1.54215217e-01f, -1.05984742e-03f, 1.96328275e-02f, -4.48121540e-02f, 7.45038167e-02f, -8.78510401e-02f, 2.30263341e-02f, -1.40424138e-02f, 5.84508777e-02f,
  2.38634497e-02f, 8.54272172e-02f, -7.95938745e-02f, 2.52750088e-02f, 7.67173916e-02f, -8.39277804e-02f, 6.09809719e-03f, 1.00085266e-01f, 6.01115776e-03f, -1.71372090e-02f,
  -6.06037155e-02f, -7.30607435e-02f, -1.07832864e-01f, -1.03995688e-01f, 3.07058673e-02f, 3.36809866e-02f, -3.78208458e-02f, 4.90081348e-02f, 7.44757950e-02f, 7.84048662e-02f,
  6.73021227e-02f, 2.42237672e-02f, -8.85893628e-02f, 1.25446692e-01f, -1.17098525e-01f, -2.36266777e-02f, 2.25041639e-02f, 4.42324020e-02f, 1.49955954e-02f, 1.73898578e-01f,
  -4.73976657e-02f, 5.66900522e-02f, -1.41650885e-01f, 1.32731289e-01f, -6.89426363e-02f, -4.99865003e-02f, -7.50680268e-02f, -3.00520360e-02f, 1.21844605e-01f, 1.76412806e-01f,
  5.89402504e-02f, 6.64931664e-04f, 2.18493901e-02f, 3.50789800e-02f, 5.29989526e-02f, -1.04117677e-01f, -8.69631991e-02f, 2.70679407e-03f, 4.22484465e-02f, 5.54011650e-02f,
  1.81617048e-02f, 4.29607555e-02f, 7.40216970e-02f, -5.33055440e-02f, 2.97275260e-02f, -5.45716621e-02f, 3.41981165e-02f, 9.34569985e-02f, -2.37353183e-02f, -8.62464085e-02f,
  6.19308129e-02f, -1.78813543e-02f, 1.31502867e-01f, -2.97236536e-02f, 6.18086122e-02f, -4.60896827e-03f, 1.61898747e-01f, 4.45765369e-02f, 1.71390027e-02f, -3.38277631e-02f,
  -8.27484548e-01f, 4.19626683e-02f, 6.22461475e-02f, -3.75726014e-01f, -1.75772384e-01f, -4.06746060e-01f, -1.98213663e-02f, -1.40982613e-01f, -2.98010796e-01f, 2.51469135e-01f,
  2.92271189e-02f, -2.05258746e-02f, 1.92834079e-01f, -1.83002084e-01f, -6.06896341e-01f, 1.10640250e-01f, -3.82184565e-01f, 1.20659145e-02f, -1.01789027e-01f, -1.59437358e-01f,
  -1.61598176e-01f, -3.25451344e-01f, 1.11237831e-01f, -9.16473046e-02f, -1.16008997e-01f, 9.61751491e-02f, -1.06284440e-01f, 2.28619888e-01f, 1.71394506e-03f, -1.54000763e-02f,
  5.50249368e-02f, 2.22988546e-01f, 2.60073617e-02f, -2.17122231e-02f, -7.52584636e-02f, 6.57016411e-03f, -3.20563056e-02f, 1.41420320e-01f, 2.46629976e-02f, 4.00715582e-02f,
  -8.36022384e-03f, -6.86155707e-02f, 1.02185532e-02f, 3.12773027e-02f, -1.14931054e-01f, -9.61149931e-02f, -8.02427307e-02f, 7.59596974e-02f, 6.90649599e-02f, 2.94603985e-02f,
  4.98071611e-02f, 4.61539738e-02f, -1.54193625e-01f, 3.10075637e-02f, -1.47891659e-02f, -6.26821890e-02f, 2.28587463e-02f, 1.45691866e-02f, -1.66419614e-02f, -7.20813200e-02f,
  -3.21077071e-02f, -4.11568284e-02f, 1.69049669e-02f, 2.57481318e-02f, 5.60046220e-03f, 6.76196767e-03f, -7.60081187e-02f, 4.22292501e-02f, -2.64465599e-03f, -7.67564699e-02f,
  -2.76768450e-02f, -1.77378710e-02f, -3.15127559e-02f, -3.18737514e-02f, -2.76254746e-03f, 7.79316947e-02f, -4.22181711e-02f, 5.74611463e-02f, -2.59349067e-02f, 3.96616682e-02f,
  1.16797782e-01f, -9.19965878e-02f, 4.40995581e-02f, 4.87101786e-02f, 1.91888548e-02f, -1.16118407e-02f, -7.11870342e-02f, -6.09262735e-02f, 2.78555788e-02f, -4.51467596e-02f,
  -5.25794961e-02f, -1.38593674e-01f, 5.14041334e-02f, -1.76982637e-02f, 8.93897340e-02f, -6.11616708e-02f, -2.53051370e-02f, -9.09445211e-02f, -5.91607727e-02f, -1.41744632e-02f,
  -2.76441239e-02f, -5.59856705e-02f, -1.74086615e-02f, -1.87176410e-02f, 3.12358718e-02f, 5.28531745e-02f, 5.06491475e-02f, 3.39909829e-02f, -4.62795086e-02f, -2.01993063e-02f,
  9.76832956e-03f, -5.45573421e-02f, 2.56924648e-02f, 2.90619186e-03f, -7.99832493e-02f, 3.53145003e-02f, -8.29570889e-02f, 3.62141468e-02f, 1.75435655e-02f, 3.24757844e-02f,
  -2.69771814e-01f, 2.40236521e-01f, 4.74143267e-01f, -1.39383292e-02f, -1.24668732e-01f, -4.43667978e-01f, -8.59695300e-02f, 3.37061891e-03f, 7.11878240e-02f, -3.91473025e-02f,
  -1.99758485e-01f, 2.69459635e-01f, 5.73914424e-02f, -1.77171230e-01f, -1.43277600e-01f, 5.71761876e-02f, -3.70346546e-01f, 5.08960932e-02f, 1.32272750e-01f, 1.46104962e-01f,
  -3.60642411e-02f, -2.18796924e-01f, 3.05041601e-03f, 5.14292605e-02f, 3.49209160e-02f, 3.00033748e-01f, -2.90253043e-01f, 3.23348969e-01f, -2.21411392e-01f, -8.76777619e-03f,
  2.51235534e-02f, 1.92456588e-01f, 9.52433869e-02f, 1.13680400e-01f, -1.36192366e-01f, -4.60171625e-02f, -8.42365697e-02f, 1.98658794e-01f, 3.97718176e-02f, 6.65179044e-02f,
  9.59064253e-03f, -4.09367122e-02f, 8.51294100e-02f, 2.70473566e-02f, 4.45622988e-02f, 1.17820598e-01f, 5.70546500e-02f, -7.88274854e-02f, 1.92654803e-02f, 8.46820846e-02f,
  1.19006261e-02f, 9.40333456e-02f, 3.03446199e-03f, -5.50133847e-02f, 6.93944395e-02f, 1.50165141e-01f, 1.14293629e-02f, 2.27033272e-02f, -3.80258472e-03f, -2.50328481e-02f,
  -1.49335772e-01f, 1.90740880e-02f, 1.16796166e-01f, 8.70351493e-02f, 3.45224142e-02f, 9.54199210e-02f, -7.53648696e-04f, 4.26087938e-02f, -6.74118474e-03f, 7.61915976e-03f,
  -6.84214309e-02f, 7.31527507e-02f, -6.95450157e-02f, 3.83181721e-02f, 9.02136031e-04f, 3.96304158e-03f, 1.12955339e-01f, -1.47539235e-04f, 3.58369909e-02f, 1.47334635e-02f,
  1.29753038e-01f, 2.01037824e-02f, 5.87301180e-02f, -5.87197393e-02f, 6.10373989e-02f, 1.20125055e-01f, 5.25040664e-02f, 2.72429176e-02f, 2.34256946e-02f, -6.15276173e-02f,
  -2.05247745e-01f, -1.80913091e-01f, 1.03976578e-01f, -9.15620178e-02f, 6.73632398e-02f, -1.32182479e-01f, 8.58302042e-02f, -5.49178906e-02f, -5.52360900e-02f, -5.95285669e-02f,
  -1.90763306e-02f, 6.05164915e-02f, -5.36994189e-02f, -4.49321419e-02f, 4.56081517e-02f, -9.19852331e-02f, -1.21533953e-01f, 1.92571320e-02f, -3.18246037e-02f, -5.85237928e-02f,
  1.86030623e-02f, -2.19679717e-02f, 8.17560181e-02f, 6.35023117e-02f, -1.26216769e-01f, -1.25051945e-01f, -5.74828796e-02f, 6.11607172e-02f, -1.04939595e-01f, 7.20275044e-02f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  7.41327181e-02f, -4.86951731e-02f, 7.03213453e-01f, -6.25044107e-01f, 1.98776182e-02f, 2.41333663e-01f, 1.39516225e-04f, -1.86152965e-01f, -1.18310595e+00f, -5.62565267e-01f,
  -2.21882737e-03f, -3.71139258e-01f, 3.28787029e-01f, -5.07566452e-01f, 1.07204151e+00f, -9.38132927e-02f, -4.03259601e-03f, 8.22684243e-02f, 2.12873876e-01f, 5.23555756e-01f,
  4.73463595e-01f, 5.86426910e-03f, 7.12573767e-01f, 3.38085532e-01f, 2.75979221e-01f, 3.30630839e-01f, 6.04314089e-01f, 5.58667481e-01f, 1.36877388e-01f, 2.02406257e-01f,
  -2.48012573e-01f, -2.00239092e-01f, 2.87944004e-02f, -1.04993626e-01f, 2.68192261e-01f, 5.60303181e-02f, 2.16416582e-01f, 2.13994458e-01f, -9.70041975e-02f, -4.55314443e-02f,
  2.12162826e-02f, -5.50380535e-02f, -1.58227846e-01f, -2.22175103e-02f, -1.26283124e-01f, -2.11191282e-01f, 3.84703688e-02f, -2.17785299e-01f, -1.66088104e-01f, 1.53883040e-01f,
  5.93316182e-02f, -7.37995133e-02f, -3.53875384e-02f, -1.27710924e-01f, 2.52019148e-02f, -1.98169261e-01f, 3.68627831e-02f, 2.96040565e-01f, -1.66810557e-01f, -8.06433633e-02f,
  1.27579927e-01f, 1.13446238e-02f, 1.14049837e-01f, 3.19819562e-02f, -9.71111208e-02f, -2.11655553e-02f, 4.23257202e-02f, -5.19054905e-02f, -5.20444335e-03f, 2.16202270e-02f,
  -2.91789949e-01f, 1.17684588e-01f, -3.80978957e-02f, -2.53679901e-01f, 1.64679751e-01f, -9.85377356e-02f, 3.28000307e-01f, 8.44550207e-02f, -1.16838656e-01f, 8.63475055e-02f,
  -3.17589611e-01f, 1.38366250e-02f, 2.67264928e-04f, -7.37120537e-03f, -1.40507743e-01f, -3.03140543e-02f, -1.62016124e-01f, 1.38572603e-01f, 9.07929242e-02f, 2.55965769e-01f,
  7.57156983e-02f, 3.79260600e-01f, -2.29987744e-02f, -1.21833749e-01f, -2.46760510e-02f, 1.09443635e-01f, -1.33706793e-01f, -4.70055267e-03f, 1.02065109e-01f, -6.69645052e-03f,
  1.05722554e-01f, 1.74823165e-01f, 9.57991369e-03f, -2.69619189e-02f, 7.16093406e-02f, 1.08199582e-01f, -1.10914402e-01f, -2.20865741e-01f, 2.77977018e-03f, 1.38004869e-01f,
  -1.23361878e-01f, 5.76864704e-02f, -8.14410374e-02f, -1.46835353e-02f, -1.94421202e-01f, -1.36758359e-02f, 1.23184495e-01f, -1.70613170e-01f, 2.61368155e-01f, -1.39250398e-01f,
  4.22063082e-01f, -1.08075738e+00f, 5.28572977e-01f, 3.14923793e-01f, 6.32730842e-01f, 6.34490371e-01f, 1.08084798e+00f, -4.96587425e-01f, -3.37028176e-01f, -8.78982425e-01f,
  -3.82590324e-01f, 4.24764842e-01f, -3.06626439e-01f, -1.94333687e-01f, 1.41195953e+00f, -1.60119116e-01f, 2.76715696e-01f, 1.79873616e-01f, -2.06867591e-01f, 1.12161353e-01f,
  2.30659470e-02f, -2.88430210e-02f, 3.37631315e-01f, -4.68044341e-01f, -5.52178062e-02f, -3.14816795e-02f, 5.10493927e-02f, 4.05065566e-01f, 1.50112852e-01f, 5.40815413e-01f,
  -2.87114233e-01f, -4.15425211e-01f, -2.53497779e-01f, -4.43762280e-02f, -1.60370007e-01f, 1.52306601e-01f, 2.46090993e-01f, 4.14200425e-01f, 2.95990974e-01f, -4.54322025e-02f,
  1.12775385e-01f, 1.26218975e-01f, -3.24728042e-02f, 1.61214754e-01f, -4.27907407e-02f, -3.72123681e-02f, 5.73962517e-02f, -1.85161680e-01f, -1.49034142e-01f, -8.46038461e-02f,
  -1.27119601e-01f, -1.67396694e-01f, -1.30368918e-01f, 1.27457846e-02f, 4.10826877e-02f, -1.53525528e-02f, 2.29968488e-01f, 3.23471814e-01f, -1.51104689e-01f, 1.58740714e-01f,
  1.65119469e-01f, 2.32162938e-01f, -5.70792891e-02f, -4.34379429e-02f, 7.45168626e-02f, -1.80717275e-01f, 5.51367924e-02f, -9.00965091e-03f, 9.35886800e-02f, -3.48223746e-02f,
  1.38421163e-01f, -7.34882131e-02f, 3.01153865e-02f, 8.69897678e-02f, 2.91994046e-02f, -1.80752829e-01f, 2.53412813e-01f, -4.93660532e-02f, -8.29660892e-02f, -1.67703882e-01f,
  1.00020923e-01f, 7.56512061e-02f, -4.65840548e-02f, -1.18132599e-01f, 7.24043995e-02f, 1.11632727e-01f, -1.67987064e-01f, -1.39003128e-01f, -3.24211344e-02f, 1.02159016e-01f,
  -7.73487270e-01f, -3.92531574e-01f, -1.30927578e-01f, -1.14587389e-01f, 8.77364874e-02f, -1.98055983e-01f, 9.33409929e-02f, 2.89214049e-02f, 1.11622691e-01f, 1.55620556e-02f,
  -2.73531735e-01f, -7.31208688e-03f, -6.08313903e-02f, 1.20169729e-01f, 1.50434285e-01f, -3.01121145e-01f, 1.21740647e-01f, -6.12013265e-02f, 1.43318996e-01f, -1.45373091e-01f,
  -1.02441035e-01f, 2.97589391e-01f, 1.70559883e-01f, -7.04669729e-02f, -1.98268238e-02f, 1.50058210e-01f, 5.03666252e-02f, -1.28161222e-01f, 8.66927058e-02f, -2.95590609e-02f,
  -2.71965802e-01f, 2.47937247e-01f, -3.78260553e-01f, -4.65523124e-01f, -3.42651039e-01f, -8.91726255e-01f, -7.56506324e-01f, -2.86204666e-01f, 4.86771286e-01f, -2.12744310e-01f,
  -4.03630435e-01f, 1.03248239e+00f, 5.60033679e-01f, -7.86465406e-01f, 2.34014899e-01f, 4.44861650e-01f, -9.75932300e-01f, -3.54181021e-01f, 1.89452052e-01f, -7.31433034e-01f,
  -3.32421184e-01f, -7.90267110e-01f, -2.42783979e-01f, -3.70740265e-01f, -8.23299289e-01f, -2.08728731e-01f, -3.14203560e-01f, -1.87075332e-01f, -9.47756648e-01f, -1.02073558e-01f,
  -2.60045975e-01f, -1.19455913e-02f, -1.18269034e-01f, 8.18801206e-03f, -4.43150699e-01f, -1.02734677e-01f, 2.93288892e-03f, 5.18097132e-02f, 5.54876402e-02f, 1.61953401e-02f,
  1.88523680e-01f, 1.76728234e-01f, -2.38083690e-01f, 3.79141033e-01f, -2.17248853e-02f, -1.11636594e-01f, -1.68372691e-01f, -1.07817903e-01f, 2.40385473e-01f, 2.17224196e-01f,
  8.36582929e-02f, -2.00941667e-01f, -3.74172419e-01f, -1.88708138e-02f, 9.05265138e-02f, -1.97589591e-01f, 6.50014207e-02f, 1.40464842e-01f, -1.22383714e-01f, 2.51945164e-02f,
  2.90567484e-02f, -8.30612052e-03f, -5.36589958e-02f, -1.70196667e-01f, -1.08657211e-01f, -4.20929790e-02f, 1.53051496e-01f, -9.99404564e-02f, 1.04695089e-01f, -1.76252693e-01f,
  1.64585710e-01f, 1.90409601e-01f, 1.39644057e-01f, -1.09351702e-01f, -1.94765285e-01f, 1.05002321e-01f, 9.25864875e-02f, -6.40864894e-02f, 9.39859673e-02f, -2.69446313e-01f,
  8.23672339e-02f, -1.74195796e-01f, 5.50035238e-02f, -2.25407943e-01f, -7.20157921e-02f, 1.37304708e-01f, 4.34878580e-02f, 1.64857566e-01f, -5.70296720e-02f, 2.10254896e-03f,
  -3.40641081e-01f, -4.27133769e-01f, -8.05481002e-02f, 1.73733115e-01f, -1.82343066e-01f, -2.22707972e-01f, -7.25010037e-02f, -9.25794989e-02f, -4.53526109e-01f, -3.01547617e-01f,
  -4.63366419e-01f, 6.61840895e-03f, -2.93273956e-01f, 7.23307282e-02f, 2.26343572e-01f, 1.64224014e-01f, -2.01597273e-01f, 1.09211259e-01f, -1.92481264e-01f, -2.73223221e-01f,
  6.80197589e-03f, 2.64635593e-01f, 3.71386975e-01f, -9.08545498e-03f, 1.17002331e-01f, -5.53864427e-02f, 2.33733460e-01f, -8.63711443e-03f, -2.01886326e-01f, -6.20148657e-03f,
  4.52464044e-01f, 7.47637630e-01f, -3.81246299e-01f, -2.20905527e-01f, 1.37896806e-01f, 7.98295736e-01f, 3.85861576e-01f, -3.65394130e-02f, -2.89498210e-01f, 7.96741247e-01f,
  -6.11072294e-02f, 7.55791903e-01f, -2.76697546e-01f, 2.93682724e-01f, -7.48382747e-01f, -3.89366388e-01f, 3.24534625e-01f, 5.21418691e-01f, -1.95581749e-01f, 4.84248102e-01f,
  -3.53033215e-01f, 3.68214279e-01f, -8.07928920e-01f, 1.57384425e-01f, 6.23330235e-01f, 1.66317567e-01f, -1.51049554e-01f, -2.96063107e-02f, 2.92564362e-01f, 3.23789455e-02f,
  -7.21559227e-02f, -3.87480818e-02f, -8.52954239e-02f, 4.05400898e-03f, 3.84910777e-02f, 9.27778035e-02f, 1.78979278e-01f, -1.77677691e-01f, -2.68505812e-01f, 2.27003638e-02f,
  1.63193852e-01f, -1.28935734e-02f, -4.41083834e-02f, -6.51354790e-02f, 2.65342623e-01f, 2.23067086e-02f, -5.43113425e-02f, 1.18831679e-01f, 1.03099402e-02f, 8.10815543e-02f,
  -2.64430810e-02f, 6.59377268e-03f, 5.92267737e-02f, 7.84853324e-02f, -1.03761263e-01f, -7.49942437e-02f, 6.58339411e-02f, 6.18760362e-02f, 2.37341911e-01f, 1.04742818e-01f,
  1.83194742e-01f, 2.61129916e-01f, 1.13948382e-01f, -1.18377535e-02f, 9.17297527e-02f, -2.31421039e-01f, 7.39978254e-02f, -3.31043117e-02f, -4.90967855e-02f, 1.34866282e-01f,
  5.75432144e-02f, 2.08694506e-02f, 1.82636902e-02f, 9.38380882e-02f, 1.56496137e-01f, -5.43469302e-02f, 3.26859243e-02f, 6.55180812e-02f, -6.59775212e-02f, -1.81462556e-01f,
  -6.40674904e-02f, 4.52773198e-02f, 1.43955424e-01f, -7.20148310e-02f, 6.49140775e-02f, -1.26547903e-01f, 1.89099506e-01f, -5.20026758e-02f, 3.01811341e-02f, -2.78159268e-02f,
  1.36719882e-01f, 4.75172251e-01f, -1.13050170e-01f, 5.54057024e-02f, 5.55055924e-02f, 2.94441015e-01f, 1.50344167e-02f, 1.58550456e-01f, 3.31167914e-02f, 1.08385950e-01f,
  8.54524150e-02f, -1.85249257e-03f, 2.41211012e-01f, 4.62913280e-03f, -9.24462974e-02f, 6.18509017e-02f, 1.31426558e-01f, -3.15012299e-02f, 7.02762082e-02f, 3.91569622e-02f,
  2.21470445e-01f, 1.16523705e-01f, 7.86421001e-02f, -1.14103138e-01f, 1.39754370e-01f, 1.70198679e-01f, 1.43329427e-01f, -9.19258520e-02f, -1.61302872e-02f, -1.10035405e-01f,
  1.18724597e+00f, -6.46131516e-01f, -1.42490268e-01f, 5.72590530e-01f, 9.76819038e-01f, 2.77529925e-01f, 5.73039770e-01f, 1.45408005e-01f, 6.01300895e-01f, -7.46230662e-01f,
  2.36417115e-01f, -1.66241247e-02f, -5.51073015e-01f, 4.73219931e-01f, 5.46871960e-01f, -6.07598126e-01f, 2.99801677e-01f, 3.82255524e-01f, 1.88026309e-01f, 2.63160318e-01f,
  5.75771630e-01f, 4.18434799e-01f, -9.80264470e-02f, -3.59484702e-01f, 7.35777259e-01f, -2.39339039e-01f, -5.18234193e-01f, -4.85381842e-01f, -2.39368424e-01f, 1.25895619e-01f,
  2.23455369e-01f, 2.50154465e-01f, 2.63121754e-01f, -2.01509193e-01f, 7.11393654e-02f, 9.45277736e-02f, -1.78188592e-01f, -8.85821879e-02f, 1.60108894e-01f, 8.78602937e-02f,
  -7.13764653e-02f, -4.43918891e-02f, 2.40785196e-01f, -8.79481062e-02f, 2.37444997e-01f, 2.04246357e-01f, 1.27710372e-01f, -2.01744633e-03f, -1.42573953e-01f, 1.46848112e-01f,
  2.15478614e-01f, -9.86285880e-02f, 1.95935249e-01f, -2.26632938e-01f, -8.13167393e-02f, -1.10082850e-02f, -1.79054171e-01f, -1.10079512e-01f, 6.85088784e-02f, 1.20455869e-01f,
  5.48795015e-02f, -1.03793956e-01f, 4.02685739e-02f, 1.38370618e-01f, 6.51147682e-03f, 4.13197242e-02f, 5.80576248e-02f, -9.77720916e-02f, -4.61114869e-02f, -7.39850700e-02f,
  -4.86913435e-02f, 2.24595428e-01f, 2.68935971e-02f, 1.33701146e-01f, 1.58884689e-01f, 1.50445521e-01f, 1.05804861e-01f, -1.32283513e-02f, 6.13137931e-02f, 5.78576513e-02f,
  9.74621903e-03f, -6.92719594e-03f, -2.44267017e-01f, -6.64646551e-02f, 6.15034327e-02f, -1.39901815e-02f, -4.64794338e-02f, -4.75225933e-02f, 1.92573238e-02f, 1.03673466e-01f,
  -2.04100043e-01f, -6.48693204e-01f, -9.12974924e-02f, -9.92279351e-02f, -1.95529565e-01f, 9.50713232e-02f, 6.73638061e-02f, 3.31435412e-01f, -2.75992423e-01f, -3.18791047e-02f,
  -2.70460490e-02f, 7.77339190e-02f, -1.15814365e-01f, 1.48884714e-01f, -1.03459351e-01f, 1.30368754e-01f, -3.16142827e-01f, -5.92601374e-02f, -1.11089922e-01f, -1.03299551e-01f,
  -1.73614249e-01f, 1.83462352e-03f, 1.26810325e-02f, 1.22426294e-01f, 2.48848018e-03f, -2.87140995e-01f, -2.67382637e-02f, -1.70123637e-01f, -1.94643408e-01f, -2.82266229e-01f,
  -6.97642863e-01f, -1.57646835e-01f, -8.59583318e-01f, -2.52359182e-01f, 8.40560436e-01f, -6.50606453e-01f, -4.63755190e-01f, 4.25355822e-01f, -1.61235482e-01f, 3.87019634e-01f,
  3.00791055e-01f, -2.61434466e-01f, -1.00608818e-01f, -2.86533982e-01f, -1.07057858e+00f, -9.70852077e-01f, -4.50266331e-01f, -3.77815962e-01f, -4.99930307e-02f, 2.16118455e-01f,
  -2.23129541e-01f, 7.05731034e-01f, -5.14511466e-01f, 1.05855167e+00f, 3.82450193e-01f, 2.95767784e-01f, 9.13120627e-01f, 6.27975345e-01f, 4.06749070e-01f, 1.65439755e-01f,
  -3.79910469e-01f, -7.73924515e-02f, -5.54011911e-02f, 1.63550396e-02f, -1.85445413e-01f, -2.03514267e-02f, -7.82067925e-02f, -4.01045047e-02f, -1.44886196e-01f, -6.27992749e-02f,
  -2.02120412e-02f, 6.44153059e-02f, 8.13795850e-02f, 1.54453829e-01f, 5.99847063e-02f, 3.74328829e-02f, -2.32298777e-01f, -2.24853173e-01f, -1.30631164e-01f, -3.09506297e-01f,
  -4.43663687e-01f, -8.94538388e-02f, -7.62445480e-02f, -8.21336284e-02f, 2.60524731e-02f, -7.83100631e-03f, -2.44693369e-01f, -8.70968252e-02f, -1.36952400e-01f, -4.30113263e-02f,
  9.63032618e-02f, 2.26389840e-01f, 1.99261811e-02f, -1.01445824e-01f, -5.00523038e-02f, 8.10125396e-02f, -1.35263965e-01f, 6.40356615e-02f, -5.00616282e-02f, -6.60388693e-02f,
  1.04679309e-01f, 1.18756201e-03f, 1.03859730e-01f, 1.63610894e-02f, 6.38751686e-02f, 1.49228081e-01f, -1.41136080e-01f, 1.39049590e-01f, -7.29244798e-02f, -2.23333210e-01f,
  2.83814669e-01f, -1.02479056e-01f, -6.62721973e-03f, 9.90889072e-02f, -1.84397891e-01f, 1.07920781e-01f, 2.13984922e-01f, -1.68540776e-01f, 2.68132892e-02f, -5.15298657e-02f,
  -7.27719292e-02f, 3.19589138e-01f, 4.05510962e-02f, 8.41110870e-02f, -1.11600399e-01f, 5.69983684e-02f, -1.91825256e-01f, -1.02484329e-02f, -9.36155915e-02f, 2.07487091e-01f,
  1.18217036e-01f, 4.43653092e-02f, 2.33490821e-02f, 1.31175546e-02f, 3.49773727e-02f, 1.84560314e-01f, 1.90080300e-01f, 1.24362215e-01f, 3.02531123e-01f, -9.08246171e-03f,
  3.97909403e-01f, 1.38621777e-01f, 3.45763601e-02f, 1.77860260e-01f, 1.25664651e-01f, 4.21559392e-03f, 5.79835996e-02f, 2.17982172e-03f, 3.98044894e-03f, 3.98094878e-02f,
  7.84253716e-01f, 8.88486564e-01f, 8.40981245e-01f, 1.14577401e+00f, -6.22923851e-01f, -4.68449891e-01f, 3.44814621e-02f, 4.54873830e-01f, 8.40349257e-01f, -2.92046905e-01f,
  -6.05614603e-01f, 8.83895338e-01f, -3.25921178e-01f, 1.76227450e-01f, -6.64904565e-02f, -3.21606576e-01f, 5.14578223e-01f, 1.98308583e-02f, 2.79937178e-01f, 5.00921905e-01f,
  3.19497198e-01f, -6.04962587e-01f, 1.21232390e-01f, -2.84534961e-01f, 8.77547252e-04f, 6.35235012e-01f, -4.35428292e-01f, -1.31779268e-01f, -7.97510296e-02f, -3.43235910e-01f,
  -3.48564655e-01f, 3.00542891e-01f, 5.45996614e-02f, 8.03638101e-02f, -8.66851434e-02f, -1.10305011e-01f, 1.05354197e-01f, -1.45331100e-01f, -4.78975475e-02f, 1.44817337e-01f,
  5.12239225e-02f, -3.84305194e-02f, 4.75716218e-02f, -1.33274257e-01f, 1.48523167e-01f, 7.96301439e-02f, 7.84348324e-02f, -3.67637426e-02f, 1.02884524e-01f, 4.35935892e-02f,
  -1.47154983e-02f, 2.42530238e-02f, 3.91710028e-02f, 2.22723752e-01f, 2.21230611e-01f, 1.83301732e-01f, 1.63202770e-02f, -5.87993152e-02f, 1.47497311e-01f, 1.93280086e-01f,
  2.42549442e-02f, -3.04937176e-02f, -7.64524788e-02f, -2.14733601e-01f, -1.44925565e-01f, -1.68673664e-01f, 5.39119076e-03f, -1.08690947e-01f, 1.48291141e-01f, -4.82865945e-02f,
  -2.04970837e-02f, 5.16138524e-02f, -3.05644907e-02f, -6.84890971e-02f, 7.20811039e-02f, 5.32582924e-02f, -2.66257972e-02f, -1.31653443e-01f, 1.19751334e-01f, -8.37423354e-02f,
  -7.40993991e-02f, -1.59582257e-01f, -7.71721750e-02f, -1.56330779e-01f, -1.10394470e-01f, -9.32609886e-02f, -3.44211459e-02f, 8.19787011e-02f, -1.58017114e-01f, -1.52428508e-01f,
  1.70780078e-01f, 5.30764937e-01f, 1.19605809e-01f, -3.11156176e-02f, 5.16621582e-02f, -1.11521117e-01f, 5.72001785e-02f, 2.07562774e-01f, 3.00042152e-01f, -5.00272401e-02f,
  -1.33492975e-02f, 7.52858073e-03f, 1.65908262e-02f, -7.80413449e-02f, -3.96630354e-03f, 7.85109699e-02f, 4.40225750e-02f, 1.24437183e-01f, 4.95573618e-02f, 3.78034525e-02f,
  -3.08198854e-02f, -9.13905650e-02f, 8.46915394e-02f, -3.47383060e-02f, -7.26527646e-02f, -1.07076645e-01f, 1.35193259e-01f, 9.96096954e-02f, -9.03442129e-02f, 8.84212404e-02f,
  -1.89645040e+00f, 1.12950253e+00f, 5.23122102e-02f, -1.37536302e-01f, -8.49480927e-02f, 1.10037780e+00f, 5.22281170e-01f, 4.88152891e-01f, 5.54404795e-01f, 6.16659701e-01f,
  2.94785261e-01f, -1.31446928e-01f, 6.52744710e-01f, 5.81386387e-01f, -2.78448761e-02f, 8.26696694e-01f, 2.76240975e-01f, 2.24321604e-01f, 5.13851106e-01f, -9.62253362e-02f,
  -2.01339170e-01f, 2.87058860e-01f, -2.89910525e-01f, 3.23184907e-01f, -1.26831725e-01f, -4.08972383e-01f, -5.82207918e-01f, 1.22485675e-01f, -4.07838881e-01f, 4.69598323e-02f,
  -2.97431588e-01f, -2.46346146e-01f, -2.07895488e-01f, -8.01907033e-02f, -2.05196053e-01f, -1.47837013e-01f, -2.80720860e-01f, 1.26007468e-01f, -7.91371241e-02f, 2.04816461e-01f,
  -8.73717666e-02f, 1.33362338e-01f, 1.01252936e-01f, 5.52028678e-02f, 1.98115245e-01f, -1.61158498e-02f, 8.47829804e-02f, -6.87539279e-02f, 1.70580328e-01f, -2.79610418e-02f,
  3.85781452e-02f, -9.16962884e-03f, -1.21157177e-01f, 4.26129773e-02f, -1.91587284e-01f, 1.80652991e-01f, 9.46052298e-02f, -2.14103952e-01f, -1.00019991e-01f, 9.87146795e-03f,
  9.75535717e-03f, 1.00740746e-01f, 8.22417215e-02f, -1.88179344e-01f, 7.97509551e-02f, -2.59136647e-01f, -4.41156998e-02f, -8.30221400e-02f, -1.13264337e-01f, -1.50492817e-01f,
  -1.37531742e-01f, -1.14415579e-01f, -1.07050305e-02f, -1.34286925e-01f, -1.27176801e-02f, -6.87503368e-02f, -8.98583233e-02f, -1.65300407e-02f, -7.56662413e-02f, -8.61755684e-02f,
  5.69200777e-02f, 5.50457761e-02f, -4.78914864e-02f, -7.69898817e-02f, 9.61617604e-02f, 7.77036846e-02f, 2.92088520e-02f, 4.22808044e-02f, 1.54114604e-01f, -8.58758688e-02f,
  2.83035278e-01f, -4.65582348e-02f, 9.65728983e-02f, 8.21962021e-04f, 3.21935527e-02f, 1.77767083e-01f, 1.72721431e-01f, -1.33030221e-01f, 1.38251543e-01f, 8.06424543e-02f,
  1.03133952e-03f, -1.73912302e-01f, -1.88147038e-01f, 5.40111624e-02f, -7.53134489e-02f, 2.54634529e-01f, -1.41966730e-01f, -8.81269723e-02f, -1.22919969e-01f, -1.37174517e-01f,
  -4.07962203e-01f, -6.76277792e-04f, -3.58062498e-02f, -2.06160564e-02f, -1.00095764e-01f, -3.05508822e-01f, -3.29595767e-02f, -2.49339137e-02f, -1.60425723e-01f, -9.71783474e-02f,
  -9.41368639e-01f, 4.16104287e-01f, -3.32474947e-01f, 1.04804599e+00f, -4.79595065e-01f, -5.45581818e-01f, -2.57377237e-01f, -3.38342115e-02f, -4.16050851e-01f, 4.45680678e-01f,
  2.13202685e-01f, 9.14732300e-05f, -4.60233808e-01f, 1.32219946e+00f, -1.24853767e-01f, 1.33360013e-01f, 1.04135895e+00f, 9.26404953e-01f, -5.96592315e-02f, 1.62583351e-01f,
  3.57269704e-01f, 1.03197932e+00f, 7.96100318e-01f, 2.18600690e-01f, 1.61883041e-01f, 1.07877158e-01f, 5.08002579e-01f, -3.07569951e-01f, 1.00861835e+00f, 9.76123735e-02f,
  3.30658495e-01f, -1.16827570e-01f, -6.13053404e-02f, -3.33930179e-02f, -2.42650643e-01f, -2.57103727e-03f, 1.32538766e-01f, 1.05077013e-01f, -9.97335762e-02f, 8.75606760e-02f,
  -1.83589846e-01f, 9.85412672e-02f, 1.33239493e-01f, -1.21776745e-01f, -6.45173192e-02f, 2.74217799e-02f, -1.25899911e-01f, -1.03048727e-01f, 3.47414240e-02f, -1.13835216e-01f,
  -2.37206981e-01f, 2.09364384e-01f, 7.56675526e-02f, 1.92163020e-01f, -1.93349510e-01f, -2.76779413e-01f, 3.63545455e-02f, -9.33587924e-02f, 6.88646063e-02f, -8.61373097e-02f,
  -8.79748091e-02f, -1.12842761e-01f, -7.53660649e-02f, 2.13472784e-01f, -1.75398335e-01f, 3.60791385e-02f, 1.13170408e-01f, 1.48529038e-01f, -1.81440920e-01f, 1.22211613e-01f,
  -3.18015479e-02f, 8.73575136e-02f, 2.44807005e-02f, -1.36780724e-01f, 1.31404579e-01f, 2.66166851e-02f, -3.03922396e-04f, -5.10794111e-02f, -9.66668054e-02f, 1.09561466e-01f,
  7.09527731e-02f, -1.39245242e-01f, -1.65613107e-02f, 1.23083949e-01f, 2.78314739e-01f, -1.82101116e-01f, 1.29073709e-01f, -1.01426199e-01f, 4.49475013e-02f, -9.20366962e-03f,
  2.03724727e-01f, -3.34888160e-01f, -2.05953062e-01f, 3.19056250e-02f, 2.54371881e-01f, 1.34647293e-02f, -2.30283719e-02f, 1.38079494e-01f, 5.34374155e-02f, -2.56770253e-01f,
  1.62613876e-02f, 2.77726650e-02f, -6.74321428e-02f, -3.45694460e-03f, 1.20137386e-01f, 5.79755120e-02f, 6.80383444e-02f, 1.62912235e-01f, -2.43337601e-02f, 2.56158769e-01f,
  -2.75757499e-02f, -1.65064216e-01f, 9.75993723e-02f, -1.31059885e-01f, 6.71604201e-02f, 5.23273423e-02f, -2.58964002e-01f, -9.32223052e-02f, -8.74570906e-02f, 1.76098049e-01f,
  -7.76965261e-01f, 3.04589063e-01f, 4.74409044e-01f, -3.99730921e-01f, 4.77245241e-01f, 6.17841840e-01f, -6.10246301e-01f, 5.85151553e-01f, -8.91038552e-02f, -2.13130876e-01f,
  -4.66964126e-01f, -5.31172991e-01f, -3.74261051e-01f, -4.48929131e-01f, -7.26352990e-01f, -5.34126222e-01f, -2.81426519e-01f, -6.92448735e-01f, -4.94157001e-02f, -8.89163986e-02f,
  -1.84834599e-01f, -4.09674376e-01f, 1.70279667e-01f, 6.62547290e-01f, 5.87529361e-01f, 4.02487457e-01f, -1.46737218e-01f, 3.09660614e-01f, 2.72712022e-01f, 1.71251982e-01f,
  -2.73592696e-02f, -2.46135995e-01f, 2.07802244e-02f, 2.26951301e-01f, 7.13933334e-02f, 1.15390763e-01f, 1.82165559e-02f, -8.63699466e-02f, 5.10470346e-02f, -2.50861584e-03f,
  -1.46823540e-01f, 1.12901278e-01f, -7.41971880e-02f, 1.43483728e-01f, 2.03269020e-01f, 1.79847285e-01f, 2.25044459e-01f, 2.59210467e-01f, 1.71898901e-01f, 1.34623498e-01f,
  1.35117128e-01f, 1.62964359e-01f, -4.72823717e-02f, -1.27292216e-01f, 1.19407102e-02f, 9.95881036e-02f, 1.86171234e-01f, 5.98118566e-02f, 1.29361689e-01f, 9.38039422e-02f,
  1.39146015e-01f, -2.94285230e-02f, -1.17239878e-01f, 1.97811332e-02f, -2.49066222e-02f, 4.98300977e-02f, -9.84585807e-02f, -1.22281455e-01f, -6.21082559e-02f, -1.34503737e-03f,
  1.85232982e-02f, 3.28643583e-02f, -4.45956737e-02f, 1.15270369e-01f, -1.31664082e-01f, 6.56433171e-04f, -5.12929671e-02f, 4.06029150e-02f, -3.31506543e-02f, 5.62154921e-03f,
  -1.80482209e-01f, -9.69850272e-02f, 2.31137499e-03f, -4.52336520e-02f, -4.41811010e-02f, -7.62454942e-02f, 6.47975132e-02f, 1.94367409e-01f, -1.53648913e-01f, -5.98424785e-02f,
  -8.89808834e-01f, -6.56324267e-01f, -1.77786887e-01f, -8.93277153e-02f, -1.01658836e-01f, 1.08905979e-01f, -6.86861575e-02f, 1.43773705e-01f, -1.94053888e-01f, -9.79343895e-04f,
  2.00023055e-01f, -2.01188605e-02f, 2.07906608e-02f, -1.11370131e-01f, -1.46068856e-01f, -1.21705839e-03f, -2.29859546e-01f, -1.52329534e-01f, -1.85133368e-01f, 7.32857808e-02f,
  -7.60509595e-02f, -4.14831489e-02f, 9.00033861e-02f, 1.57118648e-01f, 8.89773741e-02f, 3.46386395e-02f, -3.54669206e-02f, 2.36559510e-02f, 1.13880495e-02f, -5.80945350e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  8.85466278e-01f, 7.54302621e-01f, 8.46200347e-01f, 1.36593986e+00f, 1.08340931e+00f, 1.16665363e+00f, 1.11329687e+00f, 1.40061903e+00f, 9.37423289e-01f, 1.62453580e+00f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  5.87640405e-01f, 7.13449657e-01f, -3.34300175e-02f, -6.32571042e-01f, 1.34298074e+00f, -1.08781874e+00f, -1.16193557e+00f, -1.00581741e+00f, -6.16748452e-01f, -1.38446949e-02f,
  -2.09371591e+00f, -1.11916518e+00f, -1.20093739e+00f, 9.69780087e-01f, 1.10648775e+00f, -8.94926727e-01f, -1.07602108e+00f, -7.52173185e-01f, -1.65974617e+00f, -1.15501547e+00f,
  -1.56240082e+00f, -7.87426233e-01f, 5.13190567e-01f, -9.39431727e-01f, -8.81440401e-01f, 1.21227074e+00f, 4.96393502e-01f, -4.26719159e-01f, -1.34417868e+00f, 6.32589310e-02f,
  9.31511447e-02f, -1.26557386e+00f, 8.78873616e-02f, -1.34431672e+00f, -8.12789619e-01f, -6.67559981e-01f, -2.45632827e-01f, -4.02914405e-01f, -4.61100072e-01f, 6.34298146e-01f,
  -1.30767989e+00f, -9.75944698e-01f, 1.17751852e-01f, 3.72853130e-01f, -1.09949529e+00f, -1.52639925e+00f, 9.09370601e-01f, 1.59769893e-01f, -1.49435475e-01f, -1.48667192e+00f,
  -8.62510026e-01f, -6.18605852e-01f, -4.18665528e-01f, 1.27737558e+00f, -1.12232518e+00f, -7.74256289e-01f, 9.17335078e-02f, -1.75164461e-01f, -9.95392680e-01f, 9.42202091e-01f,
  -2.61751294e-01f, 2.56580472e-01f, -1.01489472e+00f, 6.34133741e-02f, 7.20150709e-01f, 1.29859850e-01f, -1.11682117e-01f, 6.07744873e-01f, 1.24443662e+00f, 1.02187490e+00f,
  9.34700608e-01f, -6.27059221e-01f, -2.46214643e-01f, -8.97441387e-01f, -8.22143555e-01f, -1.62811470e+00f, -6.77853942e-01f, 8.24807048e-01f, -3.91712785e-01f, 1.16593623e+00f,
  5.31496048e-01f, 3.11219156e-01f, 1.09058797e+00f, 1.30036473e+00f, -1.51680350e+00f, -8.95542502e-01f, -8.58291209e-01f, 6.68404475e-02f, -1.89096063e-01f, 4.76096928e-01f,
  -7.17377424e-01f, -1.15552855e+00f, 9.25142705e-01f, 8.65653694e-01f, -8.61695111e-01f, -1.70739996e+00f, -7.76145309e-02f, -1.17961121e+00f, 2.53073186e-01f, 9.56876278e-01f,
  -8.28180671e-01f, -1.56604216e-01f, -1.36939681e+00f, 1.92034036e-01f, -9.40517545e-01f, -1.60347629e+00f, 1.30687106e+00f, -1.37009621e-01f, 3.63488346e-01f, -7.99773157e-01f,
  -1.37481165e+00f, 5.33364713e-01f, -5.94834164e-02f, 5.38823545e-01f, 1.11297572e+00f, -1.08044958e+00f, 6.46307170e-01f, 4.87100869e-01f, 1.26648635e-01f, -8.26157331e-01f,
  1.12285721e+00f, -6.20703995e-01f, 9.51987058e-02f, -8.35020781e-01f, -5.96953630e-01f, -1.17157412e+00f, -8.65900517e-02f, -4.29117084e-01f, -1.27053350e-01f, -3.99021089e-01f,
  -1.26581183e-02f, -3.57380450e-01f, -5.74347138e-01f, 1.37899101e-01f, 6.03089392e-01f, -7.10238218e-01f, -9.59388852e-01f, -6.21133327e-01f, -1.11323273e+00f, 3.76413018e-01f,
  9.96237338e-01f, -1.16265333e+00f, 6.30445182e-01f, -8.99638772e-01f, 2.96774030e-01f, 8.15133214e-01f, 2.39020586e-01f, 1.08329582e+00f, -3.34352255e-01f, 4.73806739e-01f,
  5.31721652e-01f, 1.33487773e+00f, 2.06928983e-01f, -6.49064422e-01f, 1.29506335e-01f, -1.20337129e+00f, -1.27839804e+00f, -7.96534181e-01f, -1.21565771e+00f, -1.03933167e+00f,
  2.72491779e-02f, 6.34177089e-01f, 5.30865014e-01f, 1.14364219e+00f, 9.52446461e-01f, -1.35970175e+00f, 2.79330999e-01f, -9.87857521e-01f, -1.10179996e+00f, 7.64655292e-01f,
  -1.25617576e+00f, 1.02179170e+00f, -1.06231070e+00f, -1.49219251e+00f, -9.36092377e-01f, 4.30008501e-01f, -6.45896614e-01f, 5.26274085e-01f, -1.05752563e+00f, 9.49249327e-01f,
  1.24507678e+00f, 1.05211031e+00f, -1.06578243e+00f, -9.49748635e-01f, 6.83837105e-03f, 6.60982430e-01f, 6.05619512e-02f, -9.79810297e-01f, 1.01071393e+00f, -1.24725664e+00f,
  -1.40402719e-01f, 5.70444107e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  3.78916740e-01f, 9.70281020e-04f, -5.71703136e-01f, -2.32802540e-01f, -4.70894687e-02f, 3.51346880e-02f, -1.40128657e-01f, 5.84361672e-01f, -5.92312455e-01f, -2.17697248e-01f,
  -3.64672422e-01f, -4.85455900e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    