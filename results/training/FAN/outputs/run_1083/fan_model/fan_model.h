/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.07329142e-01f, 3.13027471e-01f, -1.07916426e-02f, -1.79584920e-01f, -6.51011392e-02f, -1.14958398e-01f, 3.30318362e-02f, 5.61560085e-03f, -1.07052743e-01f, 9.49583128e-02f,
  -1.05922110e-02f, -4.75926735e-02f, 2.08916310e-02f, -9.56870541e-02f, -3.88078876e-02f, 9.92747396e-02f, 1.10483967e-01f, -1.31968662e-01f, -3.29806775e-01f, -1.26354322e-01f,
  4.94451933e-02f, -9.04298797e-02f, -8.78690183e-02f, -8.08014050e-02f, 1.80143923e-01f, -1.95424389e-02f, 2.11531818e-01f, 1.89244747e-01f, 1.88699976e-01f, 2.79519290e-01f,
  8.52286592e-02f, 2.57058837e-03f, -1.08011544e-01f, -5.26471660e-02f, 8.77477229e-02f, -5.67560196e-02f, -2.59974599e-02f, 3.48546617e-02f, 5.82297631e-02f, -7.30375946e-03f,
  5.93497343e-02f, 2.09622309e-02f, 3.72326933e-02f, 1.35165781e-01f, -3.33233103e-02f, 2.50385050e-02f, 6.12469502e-02f, -6.85917437e-02f, 2.07506027e-02f, -4.24497121e-04f,
  2.61671934e-02f, 7.47937188e-02f, 1.20161019e-01f, 1.37742922e-01f, -2.51715630e-02f, 5.96246272e-02f, 1.05721377e-01f, 1.39560610e-01f, 6.44474030e-02f, 1.48748294e-01f,
  -1.19414115e-02f, -5.17569343e-03f, 1.41031360e-02f, -9.78721213e-03f, 1.78622734e-02f, 4.24223281e-02f, -4.18849848e-02f, 1.35584055e-02f, 1.78453643e-02f, -1.52722578e-02f,
  3.58304493e-02f, 5.19959023e-03f, 1.69261824e-02f, -1.39068440e-02f, 2.92434655e-02f, -5.12060970e-02f, 8.39063339e-03f, -1.27486344e-02f, 5.73056452e-02f, 3.61040346e-02f,
  -4.53202762e-02f, 6.17602235e-03f, 3.60367931e-02f, 1.41689330e-02f, 2.09040698e-02f, 4.33029793e-02f, -3.29207885e-03f, -6.67073578e-02f, -5.81701612e-03f, -9.30372477e-02f,
  1.27530992e-02f, -5.97382560e-02f, -3.25962827e-02f, 1.21969776e-02f, 4.09796508e-03f, -2.39600893e-02f, 1.48475904e-03f, -4.50106636e-02f, -5.89338988e-02f, -3.91609082e-03f,
  -5.52321151e-02f, -1.33816991e-02f, 2.65094377e-02f, 8.15335214e-02f, 2.80879550e-02f, 5.66769168e-02f, 1.19078070e-01f, -4.45265435e-02f, 5.45075424e-02f, 1.13578826e-01f,
  7.56136551e-02f, -4.71946150e-02f, -4.32086848e-02f, 1.13115020e-01f, 6.71076402e-02f, -1.37190402e-01f, 5.30299582e-02f, 5.91654740e-02f, -1.92652613e-01f, 4.38618101e-02f,
  -1.58112362e-01f, -1.91093355e-01f, -1.56340271e-01f, 1.21645875e-01f, 1.93532422e-01f, 2.07473159e-01f, 5.32187894e-02f, 1.73820600e-01f, 1.51507154e-01f, -1.09236397e-01f,
  -1.12779409e-01f, -7.56400963e-03f, -3.84830385e-02f, 4.01580408e-02f, 1.33835852e-01f, 5.29652908e-02f, -6.39213920e-02f, 5.88027351e-02f, 2.75128186e-01f, 1.33747473e-01f,
  1.99366093e-01f, 5.47940470e-02f, 3.29035036e-02f, 2.36226488e-02f, 5.40814269e-03f, 2.37803124e-02f, -1.22593537e-01f, -1.65450826e-01f, -1.30355814e-02f, -1.83616191e-01f,
  -2.62990057e-01f, -8.02579746e-02f, 1.02795407e-01f, 6.80192858e-02f, -6.57275766e-02f, 1.77259874e-02f, -4.99117337e-02f, 4.31300439e-02f, 1.13209337e-01f, -4.96775210e-02f,
  -4.91622016e-02f, -3.52300853e-02f, 4.99133244e-02f, 9.61837918e-02f, 7.14288354e-02f, 5.70240505e-02f, -1.09963883e-02f, -9.13210772e-03f, 1.21450849e-01f, 4.26485529e-03f,
  1.13954656e-02f, 6.19007908e-02f, 5.19739427e-02f, 1.28641471e-01f, 1.27074225e-02f, 6.99409544e-02f, -2.22559758e-02f, 3.07706911e-02f, 1.25901371e-01f, -1.30923226e-01f,
  -7.26929575e-04f, -3.49390246e-02f, -3.41150016e-02f, -7.78001128e-03f, -2.18772404e-02f, -8.14255700e-03f, 7.10592326e-03f, -1.65577516e-01f, 5.92384748e-02f, -7.95512572e-02f,
  -4.50430177e-02f, -5.04222661e-02f, -1.37517676e-02f, -5.56880794e-02f, -7.22576380e-02f, -1.08215868e-01f, 2.98004728e-02f, -1.16575792e-01f, -1.68410758e-03f, -1.12090655e-01f,
  -2.08794940e-02f, 2.61361264e-02f, -9.71806869e-02f, 4.12656404e-02f, -1.00441806e-01f, -3.80772725e-02f, -9.04860348e-03f, -8.50293145e-04f, -7.07999468e-02f, -3.43740284e-02f,
  1.70082510e-01f, 7.59057850e-02f, -3.50515097e-02f, -2.02975310e-02f, 8.72218795e-03f, 7.72521049e-02f, -6.87952638e-02f, -3.56054194e-02f, -1.85032142e-04f, 8.47836584e-03f,
  -8.41666420e-04f, 3.55906747e-02f, 9.26164463e-02f, 1.31342839e-02f, 7.81420842e-02f, 8.02600756e-03f, -4.33558971e-02f, 7.05514699e-02f, 1.03801951e-01f, 9.91694629e-02f,
  8.79984796e-02f, 7.32428953e-02f, 1.25153229e-01f, 1.19831510e-01f, 4.85597253e-02f, 6.88155890e-02f, 7.57047832e-02f, 1.03618512e-02f, 1.20415725e-01f, 9.22057480e-02f,
  1.41604930e-01f, -8.51622745e-02f, -1.07050896e-01f, 1.71919391e-01f, -2.05781702e-02f, -1.66817114e-01f, -3.19917798e-01f, -7.36758113e-02f, 1.72405124e-01f, 2.98308972e-02f,
  3.95418815e-02f, 1.60368726e-01f, 8.48183706e-02f, 2.19313443e-01f, -4.39097472e-02f, -1.69550210e-01f, -8.02214742e-02f, 7.44831264e-02f, 8.16395506e-02f, 1.42293662e-01f,
  1.34264186e-01f, 2.01353326e-01f, 2.56216884e-01f, 1.75109953e-01f, 7.15265109e-04f, 1.57399073e-01f, 7.32924975e-03f, -4.37312871e-02f, -1.28481999e-01f, 8.34707357e-03f,
  -1.30699262e-01f, 4.86066798e-03f, 1.04174539e-01f, 9.95123610e-02f, 4.87427898e-02f, 1.03926450e-01f, 9.32379514e-02f, 1.26051530e-01f, 1.08004503e-01f, 8.76669288e-02f,
  1.18099242e-01f, 1.55465692e-01f, 6.30862489e-02f, 1.30444705e-01f, 7.69428164e-02f, 1.23293027e-01f, 1.65693343e-01f, 6.92957342e-02f, 1.12091057e-01f, 6.07249178e-02f,
  8.18919539e-02f, -1.42490342e-02f, -3.53959724e-02f, 3.96861322e-02f, 7.08874241e-02f, 6.10097349e-02f, -4.18008938e-02f, -2.99410857e-02f, -8.17465112e-02f, -3.97094451e-02f,
  1.45589292e-01f, 3.10790781e-02f, -1.96820125e-02f, 1.24866366e-02f, -5.42431325e-03f, -5.63092753e-02f, 2.39430089e-02f, 6.90186513e-04f, -6.08835407e-02f, -7.60048702e-02f,
  2.29660179e-02f, -2.64373012e-02f, -9.08681378e-03f, -2.74693947e-02f, 1.07405618e-01f, -4.70275851e-03f, 4.62416038e-02f, 1.41559942e-02f, 1.44925611e-02f, -1.82962976e-02f,
  5.47758862e-02f, 1.07884491e-02f, 2.13950570e-03f, -1.68495532e-02f, -1.74660381e-04f, -7.93305598e-03f, -1.11749740e-02f, -6.00872859e-02f, 5.87790310e-02f, -8.56419280e-02f,
  1.65699869e-01f, -2.94220112e-02f, 2.75898743e-02f, 7.53262732e-03f, 1.11505374e-01f, 3.97290997e-02f, 1.33975819e-01f, 7.83159882e-02f, 2.41620895e-02f, 5.39944097e-02f,
  7.65684992e-02f, 8.18160325e-02f, 1.40318228e-02f, 9.60269645e-02f, 1.21924222e-01f, -2.41576787e-03f, 9.11080688e-02f, 1.59036778e-02f, 2.20820848e-02f, 7.14662373e-02f,
  1.31884709e-01f, 4.59350646e-02f, -3.52334641e-02f, 2.42814030e-02f, 1.19838584e-02f, -2.55532060e-02f, -3.54746357e-02f, -1.11239199e-02f, -1.41904065e-02f, -7.72586763e-02f,
  -1.37479522e-03f, -1.85964838e-01f, 1.36262653e-02f, -7.39224255e-02f, 1.92282230e-01f, 2.58128852e-01f, 2.74932653e-01f, 1.33582219e-01f, 1.30350934e-03f, -1.14430189e-01f,
  -5.21201342e-02f, 1.08149759e-01f, -9.76824481e-03f, -3.97818759e-02f, 6.38726540e-03f, -1.66914046e-01f, -1.60209775e-01f, 3.77734564e-02f, 2.46701628e-01f, 1.83546886e-01f,
  -3.96330208e-02f, -5.07743247e-02f, -3.87903093e-03f, 4.01280634e-03f, 3.20161134e-02f, 1.42624274e-01f, 4.64207791e-02f, -5.51292039e-02f, 1.13467507e-01f, -2.25584939e-01f,
  1.99740976e-01f, 8.86462722e-03f, 1.70635194e-01f, 3.65705928e-03f, 1.06581628e-01f, 8.34722742e-02f, -1.23398635e-03f, -3.01095452e-02f, 1.87728286e-03f, 5.61925909e-03f,
  -4.90770750e-02f, -7.37252459e-02f, 9.69065800e-02f, 1.35736354e-02f, 6.79122955e-02f, 9.43934098e-02f, 1.55758916e-03f, -4.05383445e-02f, -7.47405551e-03f, 8.01670831e-03f,
  -5.78187332e-02f, 7.95542225e-02f, 1.14893712e-01f, 9.89899505e-03f, 5.94974943e-02f, -4.73742224e-02f, 5.79942651e-02f, 9.33839679e-02f, 9.19840336e-02f, -1.01118229e-01f,
  -1.22751787e-01f, -8.78177807e-02f, 1.51788266e-02f, -5.02087921e-02f, -8.64659548e-02f, 3.68939675e-02f, -8.63416344e-02f, 1.93753168e-02f, -1.52378157e-02f, 2.66555529e-02f,
  -4.56461832e-02f, -3.98159958e-02f, 4.35567787e-03f, -7.50879645e-02f, 7.16536865e-03f, 2.67997906e-02f, 2.19046697e-02f, -1.02186404e-01f, 3.28786788e-03f, 3.61600555e-02f,
  -2.45398842e-02f, -2.51835808e-02f, 7.45231062e-02f, -7.34540969e-02f, -7.10208565e-02f, -1.84386987e-02f, 4.64872681e-02f, -4.85533252e-02f, 1.85624715e-02f, 4.89189476e-03f,
  6.32074773e-02f, 1.47304907e-01f, -3.20774224e-03f, 1.03405170e-01f, 9.03719813e-02f, 9.64963138e-02f, 9.48791280e-02f, 4.54194769e-02f, 1.00007523e-02f, 4.59794439e-02f,
  1.45116016e-01f, 4.07046191e-02f, 3.04084234e-02f, -7.03313248e-03f, 1.79535113e-02f, 5.14202267e-02f, -5.12723103e-02f, -5.22512291e-03f, 9.89445224e-02f, -3.02057657e-02f,
  3.20007578e-02f, 1.50874272e-01f, 1.13411181e-01f, 5.09298928e-02f, 1.65617138e-01f, 2.38914192e-01f, 1.83136314e-01f, 1.61972016e-01f, 1.08277068e-01f, 5.69241680e-02f,
  -5.49193844e-02f, 1.71121404e-01f, 3.36130172e-01f, -8.24514870e-03f, 7.63583779e-02f, -1.71082877e-02f, 1.32173911e-01f, -1.45462841e-01f, -1.24641888e-01f, 5.75701892e-02f,
  4.52166749e-03f, -2.12403238e-01f, -1.53341174e-01f, -1.48851946e-01f, -3.73509303e-02f, 2.09351331e-01f, 2.49887526e-01f, 5.34383506e-02f, -1.49453610e-01f, -2.14324594e-01f,
  -9.12509635e-02f, -3.86977643e-02f, -3.13986540e-02f, -1.81140020e-01f, 4.84008603e-02f, -9.87436846e-02f, 1.29590198e-01f, -2.14161631e-03f, -3.66702564e-02f, 2.35263199e-01f,
  1.65620789e-01f, 3.17759037e-01f, 2.48580724e-02f, -3.16962823e-02f, 2.32801889e-03f, -2.42344458e-02f, 2.06514262e-02f, 6.87378570e-02f, -5.48814870e-02f, -2.08517220e-02f,
  1.39241084e-01f, -7.54880756e-02f, -4.58542928e-02f, -1.74823105e-02f, 4.07777764e-02f, 1.34042855e-02f, 4.72495854e-02f, 8.98061991e-02f, 3.26500349e-02f, -4.97680996e-03f,
  -3.18586035e-03f, 6.84909075e-02f, 1.24519907e-01f, -7.14427084e-02f, 8.34336355e-02f, -5.82257994e-02f, 7.53972903e-02f, 6.03291430e-02f, -4.30783667e-02f, -5.85159026e-02f,
  -7.37464353e-02f, 4.14630547e-02f, 1.92273350e-03f, 4.21460457e-02f, -5.62837310e-02f, -8.68232921e-02f, 1.08065702e-01f, 2.57397462e-02f, -9.71530378e-02f, 2.23453324e-02f,
  -6.13424554e-02f, -7.89652839e-02f, 2.41113286e-02f, -3.62125561e-02f, -4.23475467e-02f, 7.18213171e-02f, -2.06327625e-02f, -3.99853215e-02f, -3.82325752e-03f, -9.96352956e-02f,
  -1.14131548e-01f, 4.53967378e-02f, 2.55329497e-02f, 2.52411179e-02f, 3.25915553e-02f, 1.42509583e-02f, 3.32150608e-02f, 2.28415034e-03f, 3.64138521e-02f, -2.93122381e-02f,
  -2.61612028e-01f, 1.32605195e-01f, 5.35466634e-02f, -6.67210808e-03f, 1.26398563e-01f, 1.55830299e-02f, 9.62172449e-02f, 3.80438194e-02f, -1.09166233e-02f, 2.55950331e-03f,
  -9.37264692e-03f, 1.04524277e-01f, 8.73902291e-02f, 1.12297395e-02f, -5.09601552e-03f, -2.27966569e-02f, -7.70865008e-02f, 3.04241534e-02f, 3.08243390e-02f, 5.66291250e-02f,
  5.86552657e-02f, -6.28307387e-02f, -2.67617721e-02f, 1.20935678e-01f, 1.40505191e-02f, -1.39101362e-02f, 2.67145876e-02f, -3.37079316e-02f, 7.76226074e-02f, -8.23290721e-02f,
  -5.71250916e-01f, -2.12313235e-01f, -2.16478392e-01f, -2.28142917e-01f, -7.06722662e-02f, -5.74029200e-02f, -1.10496543e-01f, -1.04751386e-01f, 7.58077856e-03f, -6.85394853e-02f,
  -8.83390903e-02f, -1.16316438e-01f, -3.78716737e-03f, -2.19046418e-02f, -2.27417499e-01f, -1.40148401e-01f, -2.27148645e-02f, -2.34731078e-01f, -8.63836259e-02f, -4.92403731e-02f,
  1.06950551e-02f, -4.14222665e-02f, -2.24625006e-01f, 1.67149827e-02f, -5.57382442e-02f, -1.06892832e-01f, -1.43549398e-01f, -1.25607058e-01f, -1.17092997e-01f, -7.14516640e-02f,
  -1.13745056e-01f, -2.86109447e-01f, -4.79209572e-02f, -2.68383436e-02f, -2.35963222e-02f, -3.32059129e-03f, -8.80133137e-02f, -2.99993921e-02f, -1.26974374e-01f, 1.43535649e-02f,
  1.46204913e-02f, 2.54993998e-02f, -4.78741787e-02f, 1.54198911e-02f, -1.39201000e-01f, -5.46303876e-02f, -4.54204120e-02f, -9.85353217e-02f, -8.87361616e-02f, -1.09914176e-01f,
  -5.12867980e-02f, -1.70589145e-02f, -1.36801481e-01f, -7.66823888e-02f, -1.37647269e-02f, -7.89539963e-02f, -1.33950233e-01f, -6.55123815e-02f, -1.80634022e-01f, -2.06721470e-01f,
  1.40027320e-02f, 3.15662683e-03f, 1.82221725e-03f, -1.31259328e-02f, 8.90459213e-03f, 1.85051560e-02f, -2.01565642e-02f, -1.33639621e-02f, -4.32920530e-02f, 3.85981873e-02f,
  2.36903764e-02f, 3.93534405e-03f, 5.19880690e-02f, -9.19510350e-02f, -7.36774355e-02f, -4.77961823e-02f, -5.93287759e-02f, 7.17120096e-02f, -1.94449555e-02f, 4.44246344e-02f,
  -7.65086189e-02f, -3.82464007e-02f, 7.72982463e-02f, 9.30167437e-02f, -8.70314334e-03f, -2.01000436e-03f, -2.61361375e-02f, 4.79338653e-02f, -5.69949076e-02f, 5.61069697e-02f,
  -8.77511427e-02f, -4.34544273e-02f, -6.82067499e-02f, -1.01285703e-01f, -1.21114694e-01f, 8.88210684e-02f, -4.97708656e-02f, -2.47523747e-02f, 1.44930109e-02f, -1.42984957e-01f,
  -1.31835967e-01f, -9.43710282e-02f, -1.06865816e-01f, 2.57022027e-02f, -1.62597969e-02f, -9.39164609e-02f, -2.79385038e-02f, -1.66460380e-01f, -3.33292149e-02f, -2.15466041e-02f,
  4.06020507e-02f, -2.75145974e-02f, -1.96089298e-01f, -1.93590820e-01f, -9.71499383e-02f, -1.27919376e-01f, -1.11430183e-01f, -3.43971774e-02f, -1.68533325e-01f, -2.21318260e-01f,
  3.66026759e-01f, -3.62451464e-01f, -9.29369330e-02f, 1.64656546e-02f, -1.21173702e-01f, -6.72919825e-02f, -1.49504736e-01f, -2.91689709e-02f, 5.41256890e-02f, -1.67548537e-01f,
  -1.08119719e-01f, -6.31105602e-02f, 4.67941500e-02f, -6.73685269e-03f, 9.66336280e-02f, -4.01364267e-02f, 1.41152728e-03f, 1.48550302e-01f, 1.35295644e-01f, 1.19952910e-01f,
  -1.04323573e-01f, -2.71434872e-03f, 2.30940014e-01f, 5.62977381e-02f, -1.33543313e-01f, -2.06574090e-02f, -1.02816224e-01f, 2.85705626e-02f, -9.14837644e-02f, -2.41013736e-01f,
  7.76495337e-02f, -3.39420214e-02f, 3.53845693e-02f, -7.24869743e-02f, -1.07411578e-01f, -5.83611242e-02f, -2.88189054e-02f, 8.60745553e-03f, -5.96511923e-03f, -1.01563156e-01f,
  -4.65587638e-02f, -3.99499312e-02f, -1.19527943e-01f, -1.50424987e-01f, -1.81497522e-02f, -4.06062044e-02f, -4.11918648e-02f, -1.63647078e-03f, -2.18058713e-02f, 2.96790618e-02f,
  -7.22027719e-02f, 3.46840173e-02f, 8.65591690e-02f, -1.52273446e-01f, 4.63366248e-02f, 4.18456942e-02f, -1.16464317e-01f, -2.84673162e-02f, -4.17897366e-02f, -9.43424925e-02f,
  -1.70813780e-02f, -5.14721237e-02f, -5.61749078e-02f, 3.28479595e-02f, -7.44253993e-02f, 1.50151476e-02f, 2.11287122e-02f, -5.85987903e-02f, 5.39490096e-02f, -3.64203416e-02f,
  1.21819384e-01f, 6.06031194e-02f, 4.04798239e-03f, 4.97643724e-02f, 3.61135639e-02f, -3.60449357e-03f, 4.11270224e-02f, -5.92245422e-02f, 5.35013340e-02f, -1.96829848e-02f,
  4.20247428e-02f, 2.26772949e-02f, -6.29571304e-02f, 2.15287600e-02f, 5.62965982e-02f, 8.59132856e-02f, 8.77150446e-02f, 2.73579191e-02f, 6.51714429e-02f, 6.64535761e-02f,
  1.12140685e-01f, 7.65341073e-02f, -4.46890853e-02f, -7.87336901e-02f, -4.02300525e-03f, -4.90714796e-02f, -1.30839227e-02f, -7.65817687e-02f, -2.76697446e-02f, 4.99708764e-02f,
  -5.62371965e-03f, 1.00595281e-01f, -5.71901351e-02f, 1.05681072e-03f, -4.53293771e-02f, -4.74106986e-03f, -1.22626387e-01f, -9.12093222e-02f, -1.72451269e-02f, 1.27504608e-02f,
  2.12154388e-02f, 3.78473848e-03f, 1.32544979e-01f, 3.20062749e-02f, -4.79705818e-02f, 9.97627452e-02f, -8.49043280e-02f, -6.18436299e-02f, 1.30321443e-01f, -4.86754626e-02f,
  -3.42317104e-01f, -1.48833185e-01f, -5.00474423e-02f, -4.52655703e-02f, -2.53215758e-03f, -5.92228025e-02f, -1.23078972e-01f, -1.06883794e-02f, -9.65750590e-03f, -8.79994109e-02f,
  5.15479222e-02f, 1.61631539e-01f, 8.82073492e-02f, 1.43943325e-01f, 5.19655682e-02f, -4.21672575e-02f, -9.09089670e-02f, -9.23904218e-03f, 5.27093634e-02f, -5.88756800e-03f,
  5.85352518e-02f, -1.07877478e-01f, -1.34899691e-01f, -6.89714998e-02f, -1.39362827e-01f, 1.08671658e-01f, -1.74112953e-02f, -8.75397325e-02f, 3.30281071e-03f, -1.64965704e-01f,
  -1.47506878e-01f, -2.07116127e-01f, 1.07456833e-01f, 8.15825835e-02f, -2.19077524e-02f, -6.15334883e-02f, -1.70492381e-02f, -1.20835215e-01f, -4.22733650e-03f, -1.31186694e-01f,
  -3.38653438e-02f, -9.39470083e-02f, -5.50368242e-02f, -3.82004827e-02f, -1.40587792e-01f, -5.13970256e-02f, -8.45161155e-02f, 2.35894192e-02f, -9.71193891e-03f, -7.49395713e-02f,
  1.27352895e-02f, -5.40949143e-02f, -1.11845277e-01f, 3.74022461e-02f, -1.56058054e-02f, -6.09225768e-04f, -3.50160003e-02f, -9.70777571e-02f, -1.47746922e-02f, -2.09908396e-01f,
  -9.53073427e-02f, -8.95344466e-02f, 3.92417237e-02f, -8.95425770e-03f, 3.36548388e-02f, 4.21170257e-02f, -1.79757215e-02f, -2.64503807e-02f, 6.30404130e-02f, 3.55640240e-02f,
  9.18433517e-02f, 1.57875419e-02f, 1.26291677e-01f, -4.19309847e-02f, 3.30051072e-02f, -5.06690554e-02f, 5.10318279e-02f, 4.00111079e-02f, 2.09812541e-02f, 1.56743042e-02f,
  1.00287311e-01f, 3.15005817e-02f, -5.97369671e-03f, 2.06955578e-02f, 9.40691531e-02f, -4.77395803e-02f, 2.11329702e-02f, 8.02810043e-02f, -4.32017632e-02f, -4.54989187e-02f,
  -1.44240633e-01f, 2.53970712e-01f, -7.03756809e-02f, -6.31463379e-02f, 1.79213863e-02f, -5.19626364e-02f, -1.12263106e-01f, -3.38370577e-02f, 8.93302727e-03f, -1.57714471e-01f,
  -6.83711097e-02f, -3.33334543e-02f, 1.65502001e-02f, -2.32016575e-03f, -2.86476817e-02f, -4.51616943e-02f, -4.38079573e-02f, -5.93990758e-02f, 1.35480566e-02f, -1.32056087e-01f,
  -3.36342566e-02f, -7.18551129e-02f, -1.09838702e-01f, -7.08275437e-02f, -3.96953560e-02f, 8.68201777e-02f, -2.88622379e-02f, -1.46690562e-01f, 2.65888665e-02f, -2.08560914e-01f,
  -4.64638025e-01f, -3.74308556e-01f, 4.28084703e-03f, -1.66262075e-01f, -7.12905428e-04f, 7.02942759e-02f, 7.91156068e-02f, -1.36622503e-01f, -1.59113333e-01f, -1.60728738e-01f,
  -2.11247459e-01f, -2.15848744e-01f, -1.70485437e-01f, -4.55642939e-02f, -1.32992879e-01f, 6.48957118e-02f, 1.44020185e-01f, 8.30676705e-02f, 1.29886985e-01f, -9.44848657e-02f,
  -2.85411831e-02f, -1.50061369e-01f, -2.07490429e-01f, -1.87916115e-01f, -5.34804501e-02f, 1.70977190e-02f, -7.18709081e-02f, -1.86996281e-01f, 1.21322088e-02f, -2.41261587e-01f,
  -3.00916899e-02f, -3.80635530e-01f, 4.96697277e-02f, -5.88563234e-02f, -8.04402158e-02f, -1.48051798e-01f, -8.38914793e-03f, -2.08571002e-01f, -1.69596985e-01f, -1.80152640e-01f,
  -1.17735803e-01f, -2.02592820e-01f, 4.13992023e-03f, -7.05765933e-02f, -1.21815577e-01f, -1.25246942e-01f, -1.88786700e-01f, -2.97389507e-01f, -1.80710047e-01f, -2.07564980e-01f,
  -4.26780134e-02f, -1.11437857e-01f, -1.80534467e-01f, -8.66946876e-02f, -3.55082378e-02f, -3.78066637e-02f, -1.86923817e-01f, -2.36515805e-01f, -1.75687745e-01f, -2.59621918e-01f,
  1.01208165e-02f, -3.50935571e-02f, 3.61805595e-02f, -2.52686162e-03f, -7.82760326e-03f, 4.42954041e-02f, 6.49399310e-02f, 6.99192137e-02f, 4.82152291e-02f, -1.32030416e-02f,
  4.90061790e-02f, 8.70091245e-02f, 1.97624825e-02f, -1.77815892e-02f, 8.96546617e-02f, -2.06805710e-02f, 7.88498223e-02f, -6.54865578e-02f, 2.97713690e-02f, 5.86742498e-02f,
  1.68384926e-03f, 1.53617645e-02f, 1.46240015e-02f, 2.10371222e-02f, 6.88774586e-02f, 2.61393399e-03f, 7.87873790e-02f, 1.28476769e-02f, -1.45093827e-02f, -9.14209336e-02f,
  -1.33481175e-01f, -6.03883862e-02f, -6.71793073e-02f, -1.53321102e-01f, -1.41390651e-01f, -9.42137763e-02f, -1.46658987e-01f, -1.38720527e-01f, -6.50577545e-02f, -1.27923176e-01f,
  -1.85499176e-01f, -1.60772085e-01f, -3.43669467e-02f, -1.74720094e-01f, -2.73443498e-02f, -1.23951770e-01f, -1.25511065e-01f, -5.11831082e-02f, -7.64324963e-02f, -1.63178101e-01f,
  -1.37988448e-01f, -1.23170637e-01f, -5.32588437e-02f, -1.20114900e-01f, -1.16165765e-01f, 3.26965936e-02f, 2.18903869e-02f, 2.17451919e-02f, 1.74828321e-02f, -1.32106319e-01f,
  -2.89629459e-01f, -1.21434838e-01f, -1.80776510e-02f, -6.10593520e-02f, -9.74260122e-02f, -1.43536031e-01f, -3.45829368e-01f, -5.70718795e-02f, -1.10740662e-01f, -3.17052752e-02f,
  2.56007761e-02f, 1.80015579e-01f, 1.32991403e-01f, 5.26782908e-02f, -9.50204656e-02f, -2.97393233e-01f, -2.61647522e-01f, -5.66976927e-02f, -1.13264501e-01f, 3.91611755e-02f,
  -1.06470697e-01f, -1.60176665e-01f, -1.75389238e-02f, -8.38339999e-02f, -1.28065377e-01f, 1.13071688e-02f, 6.50802255e-02f, -3.74409370e-02f, 2.24501099e-02f, -7.34233335e-02f,
  1.46772489e-01f, 3.96194682e-02f, -9.72936526e-02f, -6.25921786e-02f, 8.32271352e-02f, -1.37019768e-01f, -3.78044061e-02f, -3.79481092e-02f, -1.40046775e-01f, -4.95550409e-02f,
  -5.62435798e-02f, -4.69187759e-02f, -6.14649951e-02f, 8.27896036e-03f, -1.28278688e-01f, -1.47608563e-01f, -7.38374218e-02f, -9.01872590e-02f, -1.03651509e-01f, -1.29785212e-02f,
  -2.64614733e-04f, -6.56016916e-02f, -3.67385894e-02f, -8.95691663e-02f, -6.73184171e-02f, -3.30962315e-02f, 1.34261362e-02f, -5.47864996e-02f, 8.77946168e-02f, -1.03907473e-01f,
  -1.34685010e-01f, 9.56535637e-02f, -3.35770636e-03f, -3.42050716e-02f, -3.78618985e-02f, 7.26055950e-02f, 2.71559898e-02f, 1.06230043e-01f, 6.67687654e-02f, 3.26544531e-02f,
  -3.61943878e-02f, 3.09223542e-03f, 1.09345086e-01f, -2.79927310e-02f, 1.56461671e-01f, 1.78082734e-02f, -1.70485117e-02f, 1.33359119e-01f, 6.39624079e-04f, -6.32957555e-03f,
  -2.13872362e-03f, 4.49240915e-02f, 8.74570757e-02f, -1.77655537e-02f, -2.63240542e-02f, 9.12848115e-02f, 2.04986762e-02f, 1.25637770e-01f, 5.15106916e-02f, -7.35538676e-02f,
  7.29176775e-02f, 1.40237764e-01f, -4.39817719e-02f, -4.01180089e-02f, -2.76419539e-02f, 6.62019774e-02f, -1.45669151e-02f, -6.58270866e-02f, 2.77637225e-02f, -2.74422206e-02f,
  5.58562623e-03f, 2.06815731e-02f, 1.67923979e-02f, -1.15322158e-01f, -8.57189819e-02f, -1.99013334e-02f, 3.68122244e-03f, -5.94769754e-02f, 8.99439678e-03f, 4.38748822e-02f,
  -7.95433894e-02f, -2.79113883e-03f, -7.47672224e-04f, 1.76918712e-02f, -8.40820093e-03f, -3.50799300e-02f, -5.91856521e-03f, -2.31919289e-02f, 5.16022444e-02f, -1.45440578e-01f,
  1.41851693e-01f, 2.31931563e-02f, -5.23665221e-03f, -2.61239279e-02f, -1.62185822e-03f, 7.92921185e-02f, -9.24466774e-02f, 6.92934245e-02f, -1.27520878e-02f, -4.19711694e-02f,
  1.81713607e-02f, 2.30892956e-01f, 1.92639560e-01f, 2.13610843e-01f, 1.63535506e-01f, -8.71997923e-02f, -2.23415550e-02f, 1.14603586e-01f, 1.68020472e-01f, 1.28023624e-01f,
  -5.51388487e-02f, -3.42114493e-02f, 6.63268790e-02f, 1.77343950e-01f, -2.78841585e-01f, -1.24792524e-01f, -7.31549785e-02f, -1.63385093e-01f, 1.13267335e-03f, -3.53435069e-01f,
  -5.76734059e-02f, 5.78685328e-02f, 4.01533172e-02f, 1.67771727e-01f, 9.72932018e-03f, 1.08063377e-01f, 4.74633835e-02f, 7.81711116e-02f, 1.58982560e-01f, 1.21948369e-01f,
  6.92701265e-02f, 1.45341307e-01f, 1.31567910e-01f, 1.50199875e-01f, 5.16550541e-02f, 8.56955722e-02f, 1.74002320e-01f, 6.35998696e-02f, 1.96093202e-01f, 9.35011804e-02f,
  3.57358158e-02f, 1.61505956e-02f, 2.49549411e-02f, 1.77993849e-01f, 9.46287513e-02f, 1.58342510e-01f, 9.86892506e-02f, 1.09828681e-01f, 7.91592076e-02f, -3.95327471e-02f,
  -2.90781609e-03f, -4.13865745e-02f, -1.14449132e-02f, -6.23139143e-02f, 4.39635059e-03f, -5.79707362e-02f, -1.04204506e-01f, -8.78234580e-02f, -1.25510152e-02f, -1.37702689e-01f,
  -4.22313139e-02f, -4.44587953e-02f, -2.05798615e-02f, -3.19457427e-02f, -3.45173739e-02f, -7.51741081e-02f, -1.20103225e-01f, 5.04090190e-02f, -9.40066576e-02f, 3.21110301e-02f,
  -9.08627957e-02f, -7.69328186e-03f, -7.16376305e-02f, -8.44984874e-02f, 1.73829403e-02f, 3.41265239e-02f, -7.12874457e-02f, -4.51633073e-02f, -3.50344516e-02f, -1.35721132e-01f,
  -6.65372908e-02f, 3.18613052e-01f, -1.22876139e-02f, 1.09288096e-01f, 9.47403535e-02f, 7.06302598e-02f, 1.02194563e-01f, 9.74103212e-02f, 2.84088473e-03f, -8.73316452e-03f,
  7.59189576e-02f, 5.19951321e-02f, -3.69638531e-03f, 4.46230024e-02f, 6.98952153e-02f, -2.91719306e-02f, 8.06173682e-02f, -1.07148979e-02f, 1.55350044e-01f, 8.24575871e-02f,
  1.86523085e-03f, 4.00104048e-03f, 1.12244871e-03f, -3.82468626e-02f, -8.79301690e-03f, 2.20076311e-02f, -5.23747541e-02f, -1.11461587e-01f, 5.62327020e-02f, -1.50462896e-01f,
  1.34964159e-03f, -3.08310185e-02f, -1.29686281e-01f, 1.33269995e-01f, -3.41187641e-02f, -1.29350275e-01f, -1.27501801e-01f, -4.53052148e-02f, -1.55369071e-02f, -6.60257414e-02f,
  -1.09681323e-01f, -1.90157052e-02f, -1.59951091e-01f, -1.22278467e-01f, -7.64014348e-02f, 9.50254574e-02f, 1.75648004e-01f, 1.15089968e-01f, 9.11635682e-02f, 4.26719859e-02f,
  1.76829040e-01f, 8.57750401e-02f, 1.46893278e-01f, 1.70834556e-01f, 2.72206724e-01f, 2.14491785e-01f, 1.59604460e-01f, 2.82646984e-01f, 1.39906004e-01f, 5.30242026e-01f,
  -3.59553434e-02f, -1.47252873e-01f, -6.40663356e-02f, 3.59189771e-02f, -1.07975192e-01f, 2.07475461e-02f, 4.59126793e-02f, 3.74830961e-02f, -6.68241009e-02f, 3.04068234e-02f,
  -6.46140873e-02f, -7.04837441e-02f, 8.54556076e-03f, -6.38248026e-02f, -8.57895687e-02f, -1.09359501e-02f, 1.77672729e-02f, 1.01380825e-01f, -1.87558737e-02f, -1.00711413e-01f,
  6.94230795e-02f, 1.69958353e-01f, -1.80661567e-02f, 4.64612097e-02f, -6.67420253e-02f, 1.03328124e-01f, -2.33413987e-02f, 1.70742750e-01f, 1.03043653e-01f, 3.12393010e-01f,
  -1.25991786e-02f, -1.07634902e-01f, -3.20528098e-03f, -1.89616885e-02f, 2.16997676e-02f, -3.23542506e-02f, -3.28940414e-02f, 6.30609691e-02f, -1.21632796e-02f, -6.85371757e-02f,
  -6.31122515e-02f, -5.80039918e-02f, -7.39918575e-02f, 1.79712102e-02f, 6.44888310e-03f, -3.10013779e-02f, -4.44241799e-02f, 3.41660343e-02f, -1.21218085e-01f, 2.28577908e-02f,
  -6.91568777e-02f, 3.59497629e-02f, -6.68037459e-02f, -3.19705531e-02f, -8.11455399e-02f, 6.05307333e-02f, -3.85421291e-02f, -1.54697532e-02f, -1.50663644e-01f, -7.71826208e-02f,
  -1.59414515e-01f, -1.03893004e-01f, 4.99015823e-02f, 7.75031894e-02f, 5.48048541e-02f, 5.25987882e-04f, 5.78134917e-02f, -2.94096558e-03f, 2.61545517e-02f, -2.40822714e-02f,
  -7.53151551e-02f, -1.42310951e-02f, -7.10153207e-02f, 1.74917951e-02f, -1.76641308e-02f, -1.52481319e-02f, -7.08309263e-02f, 1.91134668e-03f, 1.28371477e-01f, 1.03804477e-01f,
  5.06773144e-02f, 9.19399261e-02f, -1.22661171e-02f, 7.80513287e-02f, 1.34637818e-01f, 1.80568807e-02f, 1.50885424e-02f, 2.15575006e-03f, 3.97980819e-03f, 1.65235952e-01f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.46055144e-01f, -1.12364717e-01f, 1.73812568e-01f, 6.23458661e-02f, 2.39299476e-01f, 3.93953919e-01f, 3.68342549e-01f, -8.23888332e-02f, -7.90025592e-02f, -2.58820746e-02f,
  -9.23041776e-02f, -3.85163605e-01f, -3.48111093e-01f, -3.36250395e-01f, -2.26204358e-02f, 1.78148866e-01f, 6.85793981e-02f, 9.79218706e-02f, 7.87901059e-02f, 7.53617194e-03f,
  -1.33139819e-01f, 1.02877870e-01f, 6.81381747e-02f, -1.18570114e-02f, -9.18204263e-02f, -1.12748481e-01f, -2.02238164e-03f, 1.08584665e-01f, 1.44831643e-01f, -1.84647694e-01f,
  -1.46210387e-01f, 5.73819391e-02f, -7.99032003e-02f, -9.04292054e-03f, 5.74913844e-02f, -1.11476295e-01f, -1.10667311e-01f, -1.51952818e-01f, -5.87194934e-02f, -1.05097458e-01f,
  4.20811325e-02f, -8.89360681e-02f, 7.83508196e-02f, -3.09304297e-02f, 1.12209637e-02f, 1.19392583e-02f, 2.58580465e-02f, -1.13282166e-01f, -1.84660017e-01f, -1.49809003e-01f,
  -1.66106761e-01f, 1.79397732e-01f, 1.77896872e-01f, 1.35246459e-02f, -6.41528890e-02f, 1.24084719e-01f, 2.86359321e-02f, -4.64418009e-02f, -6.06348291e-02f, -9.14385617e-02f,
  -7.13037923e-02f, 1.23720609e-01f, -2.52586659e-02f, -2.82766521e-02f, 1.04138874e-01f, -5.93274040e-03f, -3.53099145e-02f, -1.04298312e-02f, 8.71618092e-03f, 6.54805154e-02f,
  -1.75963677e-02f, 2.49508414e-02f, -5.33763692e-02f, -6.39848188e-02f, -5.94701394e-02f, -1.13862954e-01f, -1.04615770e-01f, -9.03114602e-02f, 2.32947860e-02f, 2.47767102e-02f,
  -5.88590978e-03f, -4.43651862e-02f, 9.82147902e-02f, -8.72593075e-02f, -1.59087256e-01f, -1.61029063e-02f, -1.36698350e-01f, -1.61034107e-01f, -2.14918833e-02f, 8.11045766e-02f,
  -3.14738244e-01f, 2.57293701e-01f, -4.58676219e-02f, -9.62308496e-02f, 9.28283557e-02f, -9.37837362e-02f, -8.55884552e-02f, -4.95863631e-02f, 1.36595473e-01f, -7.86022097e-02f,
  8.11591372e-02f, -5.12835570e-02f, -7.38276467e-02f, -1.22824594e-01f, -1.66251115e-03f, 5.08901924e-02f, -9.01631862e-02f, 6.39884025e-02f, -9.22094956e-02f, 5.03064729e-02f,
  -1.12899542e-01f, 9.68564451e-02f, 1.45555213e-01f, -3.10830865e-02f, -6.22833371e-02f, 1.74367934e-01f, 1.25100389e-02f, 3.40740718e-02f, 1.38169542e-01f, -5.77123277e-02f,
  4.72250938e-01f, 1.24491692e-01f, 9.18990001e-02f, 6.31701350e-02f, -3.17929387e-01f, -2.56570488e-01f, -4.01784807e-01f, -2.19805971e-01f, 1.59410417e-01f, -1.54587952e-02f,
  -1.19825810e-01f, -1.07545378e-02f, 1.27308771e-01f, 1.34615600e-03f, -1.21154338e-01f, 2.41053272e-02f, 4.51302566e-02f, 2.57264152e-02f, -2.24488169e-01f, -2.63107240e-01f,
  7.76004791e-03f, 1.12175800e-01f, 1.06317021e-01f, 2.18812283e-02f, 7.69196078e-02f, -1.67708114e-01f, 9.67041850e-02f, 2.87881377e-03f, -5.27747273e-02f, 3.73415023e-01f,
  1.93252519e-01f, 8.79063085e-02f, -1.92792818e-01f, -4.45641056e-02f, 1.20019816e-01f, 2.46030569e-01f, 1.47160403e-02f, 1.64284229e-01f, -2.52826698e-02f, 1.46718308e-01f,
  1.18302591e-01f, -5.87358437e-02f, 3.95123549e-02f, -2.96797827e-02f, 4.73496951e-02f, -1.00213431e-01f, 1.04326628e-01f, 9.60973427e-02f, 1.28146112e-01f, 1.43348083e-01f,
  -3.71577144e-02f, -1.34733804e-02f, -9.00132954e-02f, -5.27584665e-02f, -1.25388857e-02f, -5.05647361e-02f, -2.06756726e-01f, -1.14570014e-01f, -1.89924553e-01f, 1.85856089e-01f,
  -1.76716760e-01f, -4.42071669e-02f, 6.38483241e-02f, 2.75881682e-02f, -9.50323194e-02f, 2.78421817e-03f, -8.90356302e-03f, -2.45749969e-02f, -1.58613414e-01f, -8.34086165e-03f,
  -9.14981961e-02f, 8.33939761e-04f, 1.80296469e-02f, 3.96428211e-03f, -6.85285553e-02f, 5.69151202e-03f, 1.55368494e-02f, -4.81991703e-03f, 4.71361959e-03f, 3.88751812e-02f,
  -7.55332187e-02f, -2.51005143e-02f, -2.90136016e-03f, 4.33356017e-02f, -4.71715117e-03f, 7.30237514e-02f, -3.28612551e-02f, -7.67731965e-02f, -9.37452167e-02f, 4.28865030e-02f,
  -1.22839296e-02f, -2.02866361e-01f, 2.33603239e-01f, -6.37546033e-02f, -7.25486875e-02f, 3.78146917e-02f, 1.32132024e-01f, -7.61024579e-02f, -6.34151027e-02f, -1.21835947e-01f,
  -8.05698261e-02f, 8.72824118e-02f, 7.61198252e-02f, 1.55520989e-02f, 2.05837581e-02f, -1.22766174e-01f, -8.14574119e-03f, -1.44955188e-01f, -1.00030012e-01f, 6.32314086e-02f,
  2.29500495e-02f, -1.92439452e-01f, -1.42051652e-01f, -1.30128905e-01f, -5.50762042e-02f, -1.57745540e-01f, -1.31975472e-01f, -1.25588179e-01f, -2.63189852e-01f, -8.00384581e-02f,
  2.69164145e-01f, 3.27907175e-01f, 1.23804860e-01f, 3.49823721e-02f, -6.59411699e-02f, 3.23324800e-02f, 3.02440554e-01f, 1.33353427e-01f, -6.45456091e-02f, 7.49978945e-02f,
  8.87634307e-02f, -2.03240827e-01f, -5.19803762e-02f, -1.15620665e-01f, 8.76585990e-02f, 7.02633336e-02f, -8.92604366e-02f, 7.35762343e-02f, -5.75126745e-02f, -2.53519677e-02f,
  -5.09841405e-02f, 2.43098363e-02f, 1.71095580e-01f, 4.01118658e-02f, 1.67768091e-01f, -1.50600344e-01f, 3.24456207e-03f, 1.88094735e-01f, 1.09389149e-01f, 1.26769349e-01f,
  -7.71667883e-02f, 3.15185636e-01f, -3.01738888e-01f, -8.14124569e-02f, -2.41096560e-02f, -1.43666953e-01f, -1.56496167e-02f, -6.81580752e-02f, -7.99101219e-02f, -4.54842262e-02f,
  -1.49063058e-02f, 3.19759883e-02f, 6.85574636e-02f, 5.87362722e-02f, -4.17265072e-02f, -8.54611620e-02f, -1.10342860e-01f, 1.17549561e-01f, -1.97297558e-02f, 5.07909097e-02f,
  -9.90267545e-02f, 6.28589317e-02f, 2.52624899e-01f, -5.97953126e-02f, 9.93094221e-02f, -1.17104083e-01f, 6.33022264e-02f, 1.15253039e-01f, 3.10689099e-02f, 5.48801869e-02f,
  -6.32464886e-02f, -6.68058032e-03f, -3.49934387e-04f, 1.06589859e-02f, 3.64969857e-02f, -7.67810130e-03f, -2.70778276e-02f, 5.35214581e-02f, 8.09680894e-02f, 8.40093940e-02f,
  -1.17177077e-01f, -1.42692327e-01f, -8.45577642e-02f, -7.29718208e-02f, -1.18169300e-01f, 1.75563875e-03f, -2.28135586e-02f, 8.78701881e-02f, 8.00300948e-03f, -6.00407757e-02f,
  3.80235240e-02f, 1.65097192e-02f, -1.57070950e-01f, -4.65962663e-02f, -8.48079100e-02f, 6.47376403e-02f, -1.04615465e-01f, -7.14821443e-02f, -9.20249447e-02f, 3.02216131e-02f,
  -3.56383592e-01f, -1.04852259e-01f, -2.48775199e-01f, 8.17924552e-03f, 8.25153440e-02f, -7.51352832e-02f, -6.57387748e-02f, -6.01214319e-02f, 1.19379275e-02f, 3.49960402e-02f,
  1.34782687e-01f, 7.00843409e-02f, -6.95825694e-03f, -2.71519031e-02f, -1.76608652e-01f, -3.93363424e-02f, 4.12943028e-02f, -1.19290173e-01f, 1.19647104e-03f, 8.19737241e-02f,
  1.35406842e-02f, -9.23978314e-02f, -7.79963136e-02f, -2.68642697e-02f, -9.17361006e-02f, -2.57666171e-01f, -5.48379030e-03f, -7.23856613e-02f, -1.40459031e-01f, -1.40529379e-01f,
  -7.87461922e-02f, 2.32752599e-02f, 6.01674654e-02f, 7.02378303e-02f, -1.90973207e-02f, -1.15572765e-01f, -1.53617814e-01f, -4.95665409e-02f, -1.29072592e-01f, -1.02126792e-01f,
  -1.70886934e-01f, -1.37760386e-01f, 3.85453179e-02f, 1.85376003e-01f, 1.12387411e-01f, 1.78782046e-01f, 3.51945609e-01f, 2.66503125e-01f, 1.72691196e-01f, 8.81721557e-04f,
  1.30558759e-01f, 4.42363918e-02f, 6.66619167e-02f, 2.06040010e-01f, 1.50976166e-01f, 1.23547390e-01f, 2.88357548e-02f, 2.08294183e-01f, 1.15150124e-01f, 3.02461833e-01f,
  -1.68656394e-01f, -1.97509620e-02f, 1.98269524e-02f, 5.75655550e-02f, 7.59729370e-02f, -9.07965600e-02f, -8.97018705e-03f, -5.33592179e-02f, -1.34392127e-01f, -1.27077147e-01f,
  -6.93505025e-03f, 2.89719533e-02f, 9.97051746e-02f, 7.37689957e-02f, -1.24722496e-02f, 5.51081523e-02f, 1.23829164e-01f, 6.51372895e-02f, 5.39830700e-02f, -7.04925926e-03f,
  8.15376341e-02f, -4.14432175e-02f, -1.49589360e-01f, -7.28246346e-02f, 1.24090016e-01f, 5.97862005e-02f, -6.72001541e-02f, 1.63785685e-02f, -2.68006288e-02f, -5.50488010e-02f,
  3.05532739e-02f, 1.99213512e-02f, 4.38653827e-02f, 6.14419095e-02f, -7.13786483e-02f, -2.66388897e-02f, 2.28997208e-02f, 1.22664392e-01f, 2.08991528e-01f, 1.81147560e-01f,
  2.13615328e-01f, 1.05330953e-02f, 4.87065651e-02f, 1.00970827e-01f, -1.55208278e-02f, 1.26126125e-01f, 1.61120519e-01f, -2.30849721e-02f, 2.10207868e-02f, -2.68866271e-02f,
  3.69997844e-02f, 4.39126901e-02f, -3.09619913e-03f, 2.77935654e-01f, -3.60641778e-02f, 8.35503787e-02f, 5.91489188e-02f, 1.19175911e-01f, 7.08399639e-02f, 1.09672852e-01f,
  -1.49485245e-01f, 1.02607124e-01f, 5.04572019e-02f, 1.51687637e-01f, 1.76608507e-02f, 1.20196275e-01f, 4.48420011e-02f, 4.07590382e-02f, 6.65635467e-02f, -9.44606885e-02f,
  -1.87791586e-02f, 5.90309091e-02f, 7.02699274e-02f, 9.96521637e-02f, 7.22312033e-02f, -7.51633048e-02f, 4.64771315e-02f, 2.39242911e-02f, 7.01058507e-02f, 4.43457346e-03f,
  -3.12780924e-02f, -1.92991138e-01f, -1.22900687e-01f, -8.21711123e-02f, 3.59833874e-02f, -1.29995614e-01f, -7.15660080e-02f, -6.30581081e-02f, -1.61177784e-01f, -9.40941051e-02f,
  -2.19435215e-01f, -2.21063972e-01f, 4.48564366e-02f, 1.35972828e-01f, 9.26703364e-02f, 1.17800169e-01f, -6.69277683e-02f, 7.61308670e-02f, 1.90117776e-01f, 1.09399125e-01f,
  7.05847749e-03f, 1.98138595e-01f, 2.73905754e-01f, 1.09100454e-01f, 1.69379830e-01f, 1.63386554e-01f, 2.59616882e-01f, 1.50784761e-01f, 2.16856837e-01f, 1.80307180e-01f,
  1.36676341e-01f, -2.34906022e-02f, 8.91939625e-02f, 1.89633727e-01f, 7.37241358e-02f, 2.30294287e-01f, 9.79520828e-02f, 8.86127800e-02f, 5.80172054e-02f, 1.29979879e-01f,
  7.09351078e-02f, -3.02827865e-01f, 7.03782365e-02f, -5.71610071e-02f, -2.12720260e-01f, -1.93785116e-01f, -4.84624095e-02f, -1.27281949e-01f, -1.00456029e-01f, -7.83380307e-03f,
  -3.45013402e-02f, -1.35033771e-01f, -2.33604163e-02f, -8.51754844e-02f, -9.78210345e-02f, -2.19399616e-01f, -1.77318990e-01f, 1.10702299e-01f, 1.05882674e-01f, -6.63348585e-02f,
  -8.57611466e-03f, -6.96990713e-02f, 4.51151505e-02f, 1.19090363e-01f, 1.45826012e-01f, 5.45986220e-02f, -4.75485176e-02f, -1.04150325e-01f, -1.12922136e-02f, -7.05983192e-02f,
  1.96457699e-01f, 1.48320243e-01f, 5.23726121e-02f, 1.58464700e-01f, 9.45805199e-03f, -4.02267948e-02f, -6.40529543e-02f, 4.72816192e-02f, 1.74092039e-01f, -6.64559528e-02f,
  -2.76277162e-04f, 1.41304106e-01f, 1.63375735e-01f, -4.54555675e-02f, 1.21557772e-01f, 6.71177208e-02f, -1.09521016e-01f, 5.89346886e-02f, 3.12832072e-02f, -1.01359943e-02f,
  -3.89886126e-02f, -3.96748856e-02f, -1.00497469e-01f, -7.93946385e-02f, 2.76131704e-02f, -7.61354947e-03f, 3.69425677e-02f, -4.54422534e-02f, -1.09142937e-01f, -1.15885004e-01f,
  2.26138845e-01f, 2.51250178e-01f, 1.24100938e-01f, -1.60503369e-02f, -7.09221214e-02f, -1.73934177e-01f, 8.41842741e-02f, -9.06074718e-02f, -1.49614498e-01f, 9.34194326e-02f,
  -1.54608563e-01f, -1.91771537e-02f, -8.77628103e-02f, -2.45823357e-02f, -6.58583939e-02f, -5.66163883e-02f, -6.18257113e-02f, 1.01294570e-01f, 1.96462929e-01f, -2.89285410e-04f,
  7.90594146e-02f, 3.36067788e-02f, 1.62029803e-01f, 2.29689538e-01f, 1.62936166e-01f, 1.53429314e-01f, -3.52091193e-02f, -1.15297036e-02f, -2.61153970e-02f, -7.62752891e-02f,
  1.20478161e-02f, -2.14279979e-01f, -1.67972788e-01f, 1.12235405e-01f, -2.05824792e-01f, -2.72430301e-01f, -2.51551718e-01f, -1.09193385e-01f, 1.24395480e-02f, -3.18396270e-01f,
  4.62061875e-02f, 2.69348204e-01f, 1.07585445e-01f, 7.78511614e-02f, 2.60998785e-01f, -2.61948466e-01f, -3.30194265e-01f, -4.06284519e-02f, 2.32179388e-01f, 1.29488096e-01f,
  -3.54696214e-02f, -1.14046806e-03f, 1.85690537e-01f, 6.07574619e-02f, -8.02084059e-02f, 1.28832683e-01f, -1.58722073e-01f, -1.64716408e-01f, -4.42457162e-02f, -3.29514503e-01f,
  1.71646774e-02f, -1.32905543e-01f, -8.39090720e-02f, 1.78548209e-02f, -1.56323537e-01f, -2.70689260e-02f, 5.88174686e-02f, -4.33483459e-02f, -4.81363311e-02f, -1.63686976e-01f,
  -5.20022288e-02f, -9.60418675e-03f, 1.76072508e-01f, 1.16858989e-01f, 1.01110481e-01f, -1.48483005e-03f, -1.40950575e-01f, -5.84296770e-02f, 3.67816016e-02f, -5.27290534e-03f,
  -3.70719247e-02f, -1.02660798e-01f, 1.08822845e-01f, -8.38279203e-02f, 3.96825857e-02f, 4.98780496e-02f, -7.42888404e-03f, -3.34042273e-02f, -1.10700406e-01f, -1.26611203e-01f,
  3.68691832e-02f, 5.07590510e-02f, -2.57117655e-02f, -5.37049118e-03f, -1.64825786e-02f, -4.82354462e-02f, 4.77826893e-02f, 7.22526461e-02f, 3.60516049e-02f, 4.79964726e-02f,
  -4.62457128e-02f, -2.94459760e-02f, -3.66994143e-02f, -4.83504087e-02f, 1.85527802e-02f, -5.75321987e-02f, 9.58061020e-04f, 9.95954219e-03f, -8.84019583e-02f, -6.42516315e-02f,
  -9.45193693e-03f, -5.76416813e-02f, -3.92513946e-02f, 9.18517783e-02f, -8.52226838e-02f, 7.78098926e-02f, -3.43414433e-02f, 4.00550365e-02f, 7.64845237e-02f, -5.18358685e-02f,
  4.06887323e-01f, -9.55188200e-02f, 5.39756007e-02f, 2.57313289e-02f, -9.44809243e-02f, -8.69676564e-03f, -5.14843091e-02f, -7.35975280e-02f, -3.88898291e-02f, -3.51693481e-02f,
  -4.74555278e-03f, 1.08160630e-01f, -4.19585407e-02f, -2.17224956e-02f, 5.81619367e-02f, -7.54692480e-02f, -1.54881682e-02f, 1.50888627e-02f, -2.75465157e-02f, -9.93065089e-02f,
  -3.89144421e-02f, -2.13934365e-03f, 1.34599477e-01f, 8.37321207e-02f, 1.27859354e-01f, 1.33190677e-01f, 1.05047002e-01f, 7.01661110e-02f, 1.26292735e-01f, -2.98656896e-02f,
  3.15675944e-01f, -6.56546354e-02f, 1.31898403e-01f, 1.55625001e-01f, -3.91409039e-01f, -3.45983922e-01f, -4.68779325e-01f, -1.71137035e-01f, -5.23207746e-02f, -7.09687024e-02f,
  -1.73463643e-01f, -9.60955117e-03f, 8.88852701e-02f, 6.68885335e-02f, -3.04181613e-02f, -3.89482155e-02f, 7.63455927e-02f, 1.70509055e-01f, -7.49172736e-03f, -6.98638111e-02f,
  -5.99461719e-02f, 1.62787557e-01f, 3.74511957e-01f, 1.47086933e-01f, 1.38383493e-01f, 1.39373960e-02f, 5.94153702e-02f, 1.20405167e-01f, 6.47142455e-02f, 3.46882582e-01f,
  1.48505136e-01f, 4.58242744e-02f, 6.39621392e-02f, 1.02145202e-01f, 3.21415775e-02f, 3.33819278e-02f, 3.96853909e-02f, 2.11951479e-01f, -6.43247515e-02f, 5.07036410e-02f,
  -4.06152457e-02f, -3.61300856e-02f, 4.99633548e-04f, -4.52822121e-03f, -4.62782681e-02f, -1.39254957e-01f, 3.96794565e-02f, 1.89010859e-01f, 9.80302915e-02f, -2.53649689e-02f,
  -1.60114273e-01f, -2.21049383e-01f, -8.39467719e-02f, -1.84971243e-01f, 3.09368521e-02f, -9.54387262e-02f, -1.59466386e-01f, -1.26934245e-01f, -1.09057114e-01f, 1.83659971e-01f,
  -8.63877758e-02f, -3.67967412e-02f, -4.46220264e-02f, 2.37678438e-02f, -1.24979271e-02f, -7.84271732e-02f, 5.47550945e-03f, -9.95438173e-02f, -7.65684620e-02f, -8.57974589e-02f,
  2.82954350e-02f, 9.66121405e-02f, 1.02281673e-02f, -7.97375664e-02f, -5.45299761e-02f, -2.66129393e-02f, -1.33418754e-01f, 5.81312738e-02f, -4.55731340e-03f, -6.21821694e-02f,
  -2.71784645e-02f, -1.53063044e-01f, 2.50921417e-02f, 6.10522181e-02f, 1.06830820e-02f, 3.31474394e-02f, 9.85216424e-02f, 1.60928619e-06f, 1.71368420e-01f, 4.56719138e-02f,
  2.74045486e-02f, -8.63667428e-02f, -4.80158664e-02f, 1.28671750e-02f, 2.85148751e-02f, -2.15873569e-02f, -1.05872706e-01f, -3.07940822e-02f, -5.72366677e-02f, -1.55562282e-01f,
  -1.59195736e-01f, -7.69391060e-02f, -3.20419036e-02f, -6.02421127e-02f, -4.59961668e-02f, -1.04480185e-01f, -3.29844877e-02f, -1.09154031e-01f, 8.15289281e-03f, -7.13164657e-02f,
  -1.16393693e-01f, -2.17302769e-01f, -2.02176377e-01f, -5.17662731e-04f, -1.88236833e-01f, -1.68265805e-01f, -6.28512129e-02f, -2.45423526e-01f, -2.80168831e-01f, -1.75082401e-04f,
  6.01400971e-01f, -1.66596156e-02f, -1.30931199e-01f, -1.22769335e-02f, -5.77641837e-02f, 2.61581149e-02f, 2.00017944e-01f, 4.27212529e-02f, -1.43999994e-01f, 4.93867956e-02f,
  3.28322530e-01f, 1.71646506e-01f, 9.89226401e-02f, 5.79272620e-02f, 2.32125714e-01f, -3.09014380e-01f, -3.45058203e-01f, -7.37179741e-02f, 1.70675486e-01f, 1.39337942e-01f,
  -3.10579855e-02f, -2.86826268e-02f, 7.35078752e-02f, -7.15752877e-03f, -3.62502038e-01f, -1.49989009e-01f, -1.99046314e-01f, -2.11551655e-02f, -1.76596537e-01f, -3.98065865e-01f,
  -5.86322024e-02f, 3.15746218e-01f, -3.49753499e-02f, 1.68283284e-02f, -1.40892684e-01f, -4.94613647e-02f, 3.22868638e-02f, -1.83194131e-01f, -1.31814107e-02f, -1.11681052e-01f,
  1.33348349e-02f, -8.28802735e-02f, 7.66612962e-02f, -1.00376688e-01f, -2.19322857e-03f, -7.66383717e-03f, -5.71839884e-02f, 6.27915412e-02f, -5.17600141e-02f, 2.67965384e-02f,
  -3.79944891e-02f, 1.89350039e-01f, 1.26039833e-01f, -4.16956581e-02f, -2.76057329e-03f, 1.12221405e-01f, 1.20059632e-01f, -1.07167602e-01f, -5.88144325e-02f, -2.42866382e-01f,
  -3.26521024e-02f, -2.04314124e-02f, 1.96869057e-02f, -5.58280153e-03f, 1.13839246e-01f, -3.78393494e-02f, -5.26044481e-02f, 6.85689598e-02f, -2.66335551e-02f, -9.24611241e-02f,
  6.04201593e-02f, -1.96751449e-02f, 6.71510100e-02f, -8.71145874e-02f, -1.31355375e-02f, -9.43383127e-02f, -2.85008852e-03f, 1.49708602e-03f, 3.67389321e-02f, 6.69693425e-02f,
  1.08245045e-01f, 3.44455242e-02f, -1.19724050e-02f, -5.88644296e-02f, -1.98136289e-02f, -5.95001504e-02f, -2.29892991e-02f, -8.20107013e-02f, -1.91394210e-01f, -6.09154664e-02f,
  -6.62846938e-02f, 2.50188440e-01f, 1.06736058e-02f, 5.95976599e-02f, 2.46008541e-02f, -1.11208633e-01f, 1.39416948e-01f, 9.41992830e-03f, 4.32536453e-02f, -6.84464350e-03f,
  1.40143307e-02f, -3.48634496e-02f, 9.68260393e-02f, 4.52782959e-02f, -1.84290111e-02f, 1.09782979e-01f, 2.27727811e-03f, 1.43065125e-01f, 2.59303749e-02f, -6.75034225e-02f,
  -1.81822255e-01f, -7.20249712e-02f, 1.04606017e-01f, -1.81944907e-01f, -7.56208450e-02f, -2.79829334e-02f, -3.63379829e-02f, -1.09605588e-01f, 9.46949720e-02f, -2.57350177e-01f,
  -4.37663823e-01f, 1.42872021e-01f, -6.61704391e-02f, -1.42536372e-01f, 2.57991940e-01f, 3.30869049e-01f, 3.36391956e-01f, -7.27608847e-03f, -1.13324307e-01f, 1.46984652e-01f,
  6.34818822e-02f, -4.17483076e-02f, 2.87133045e-02f, -3.55015099e-02f, 5.45118675e-02f, 1.13453925e-01f, 1.82540342e-01f, -1.95872292e-01f, -2.00930774e-01f, 1.50908500e-01f,
  1.59167022e-01f, -9.61773172e-02f, -2.69892097e-01f, -6.22959062e-02f, -8.10069367e-02f, -8.68711844e-02f, -5.04257418e-02f, -1.40376091e-02f, 1.33121237e-01f, 4.92551513e-02f,
  -1.67529717e-01f, -1.56882957e-01f, 9.49310213e-02f, -5.47327176e-02f, 2.55436245e-02f, -3.27145904e-01f, -2.44988576e-02f, -2.70337999e-01f, 3.46816033e-02f, -1.96947932e-01f,
  -1.09702544e-02f, -6.78814426e-02f, 1.17968600e-02f, 5.53807355e-02f, -5.49920537e-02f, 1.15237720e-02f, -6.14462197e-02f, -1.88209955e-02f, -2.58404195e-01f, -2.83456203e-02f,
  2.39698470e-01f, 1.22724175e-01f, -2.94342134e-02f, 4.11781259e-02f, 1.99844781e-02f, -2.01573640e-01f, -1.00597590e-01f, -2.16782019e-01f, -1.01267003e-01f, -2.98709750e-01f,
  9.52531099e-02f, 1.33269161e-01f, 5.89706115e-02f, 6.27494603e-02f, 7.17399467e-04f, -3.10461428e-02f, 1.03828087e-01f, 8.74690041e-02f, 1.38328150e-01f, 1.22463135e-02f,
  -2.18609720e-02f, 1.63638238e-02f, 3.74654948e-04f, -8.26968327e-02f, -6.27780631e-02f, -1.17493635e-02f, -6.51902929e-02f, -8.38841945e-02f, -1.25774398e-01f, 4.70691547e-02f,
  -7.95010924e-02f, -4.95500639e-02f, 2.72059068e-03f, -7.53973126e-02f, 3.19716744e-02f, -1.25901233e-02f, 4.14992496e-02f, 6.93353564e-02f, -6.70549870e-02f, 8.13950002e-02f,
  -2.37204939e-01f, 6.48996606e-02f, -1.17728926e-01f, 5.74021637e-02f, -1.08572254e-02f, -1.89165864e-02f, -8.02450106e-02f, -1.58509880e-01f, 5.91172688e-02f, -9.02825594e-02f,
  -7.47061148e-02f, -9.57783163e-02f, -9.01885480e-02f, 7.01573119e-02f, 8.15759227e-03f, -7.14552030e-02f, 1.68346867e-01f, -1.23233851e-02f, 6.36431873e-02f, -2.06163209e-02f,
  -8.86177272e-02f, -8.09271336e-02f, -1.73668370e-01f, -7.60419592e-02f, -6.09534886e-03f, -2.61632472e-01f, -9.33592469e-02f, -9.87426117e-02f, -1.93989456e-01f, -2.76596725e-01f,
  4.33636159e-01f, -2.18528822e-01f, -5.15957654e-01f, 1.11645013e-01f, -2.27306243e-02f, -7.82827809e-02f, -6.83793426e-02f, 5.74440397e-02f, 1.13258354e-01f, -1.23382315e-01f,
  -2.33669698e-01f, 1.47254365e-02f, -8.95961747e-02f, -8.43678787e-02f, 1.27438491e-03f, -2.84010559e-01f, -2.96324223e-01f, -5.31587563e-02f, 2.13217407e-01f, 8.82561654e-02f,
  1.11357551e-02f, 5.59127331e-02f, 1.96995944e-01f, 1.90879479e-02f, -2.25334466e-02f, -5.85812256e-02f, -2.16756582e-01f, -8.63629207e-02f, -1.72541693e-01f, -3.63652468e-01f,
  -3.94907564e-01f, -2.46239886e-01f, 1.84333593e-01f, 1.48455918e-01f, -6.26215413e-02f, 7.46871680e-02f, -4.61012833e-02f, 5.95007278e-02f, 1.09547846e-01f, -2.81920247e-02f,
  1.13357725e-02f, 7.52697587e-02f, -1.83709711e-02f, -7.80609017e-03f, 1.54310046e-02f, -1.01206213e-01f, 3.01058069e-02f, 2.28587873e-02f, -1.66084673e-02f, -4.51750532e-02f,
  -1.53708518e-01f, 5.34098819e-02f, 8.18201378e-02f, 5.65392291e-03f, -9.14250910e-02f, -4.20866944e-02f, -1.10641427e-01f, -8.65446627e-02f, -1.51613327e-02f, -3.62938680e-02f,
  -1.13368571e-01f, 2.13424563e-02f, 3.81253920e-02f, 1.21621661e-01f, 2.26973921e-01f, 1.46430045e-01f, 9.38237160e-02f, 4.19812985e-02f, -1.88148320e-02f, 7.00083002e-02f,
  -4.91727479e-02f, 3.09089236e-02f, 3.03965416e-02f, -2.33792188e-03f, -1.21305026e-01f, 4.86183465e-02f, -8.71225086e-04f, -1.02231745e-02f, -2.62649935e-02f, 1.72017515e-01f,
  -1.30462146e-03f, -6.43054470e-02f, -1.15969107e-02f, 1.38197560e-02f, -1.08728692e-01f, -1.08430199e-01f, -1.53638944e-02f, -8.29674210e-03f, -5.21396175e-02f, -1.23213649e-01f,
  1.72795713e-01f, -1.47531405e-01f, 1.02536865e-01f, -1.85727365e-02f, -7.17370361e-02f, -2.91697755e-02f, -1.49665743e-01f, -9.52757150e-02f, 8.69709440e-03f, -7.64840096e-02f,
  -1.09886765e-01f, -1.51915371e-03f, -1.42911971e-01f, -8.03782642e-02f, 1.28064975e-01f, -7.05606909e-03f, 3.26124541e-02f, 7.89793506e-02f, 9.38021094e-02f, -3.88609134e-02f,
  -5.96969686e-02f, 7.08624870e-02f, 2.03360245e-01f, 1.16794690e-01f, 1.43233582e-01f, 1.39245808e-01f, 2.74008252e-02f, 3.78333777e-02f, 1.35131553e-01f, 1.49461091e-01f,
  -4.90512431e-01f, -2.72784010e-03f, -2.70090312e-01f, -1.52272701e-01f, 2.86170244e-01f, 2.28509471e-01f, 3.50947976e-01f, 8.04321766e-02f, 2.36303788e-02f, 6.63182586e-02f,
  2.18583003e-01f, 1.81698054e-02f, 1.55119151e-02f, 3.94608751e-02f, -3.89755145e-02f, 8.63440409e-02f, -3.14591378e-02f, -1.48257166e-01f, -1.20534278e-01f, 1.98806226e-01f,
  2.60520935e-01f, -8.83683190e-02f, -1.70587882e-01f, -1.02318987e-01f, -6.01119585e-02f, 4.68439870e-02f, 1.67873676e-03f, -6.61833957e-02f, 1.85434371e-01f, -1.18455015e-01f,
  -2.00953901e-01f, -2.85605133e-01f, 7.03563839e-02f, -2.10373402e-02f, -7.81081989e-02f, -1.21796392e-01f, 5.41423149e-02f, -3.67700718e-02f, -5.85564077e-02f, -5.35487272e-02f,
  -6.66992515e-02f, -5.95454946e-02f, 1.58938721e-01f, 9.81308892e-02f, -5.56480326e-03f, -5.71483225e-02f, 2.07740976e-03f, -1.81329757e-01f, -1.43214613e-01f, 3.40367742e-02f,
  2.58170694e-01f, 2.16810137e-01f, -1.77011669e-01f, -1.81693863e-02f, -8.91284049e-02f, -1.79083906e-02f, -4.11299691e-02f, -1.20712453e-02f, -6.99056387e-02f, -2.21422270e-01f,
  -1.34951686e-02f, 3.02040274e-03f, -1.59501389e-01f, -1.62846833e-01f, -7.39647150e-02f, -8.21101889e-02f, -2.69916113e-02f, 6.39044940e-02f, 2.60422919e-02f, -7.10238442e-02f,
  -9.51777212e-03f, 8.93088710e-03f, 3.11370995e-02f, -4.65164222e-02f, 7.33887330e-02f, -6.31381124e-02f, 8.39618444e-02f, -1.42879467e-02f, 2.25494839e-02f, 4.03838083e-02f,
  -8.47604424e-02f, -7.26889297e-02f, -7.11987913e-02f, -1.38353288e-01f, -7.02453181e-02f, -1.42401427e-01f, -9.07573923e-02f, -3.92324552e-02f, -5.72530143e-02f, -1.07808420e-02f,
  -1.87071949e-01f, 7.94259757e-02f, -1.16125479e-01f, -1.02021061e-02f, -3.23607065e-02f, -2.19913647e-02f, 8.51344615e-02f, -3.44959237e-02f, 2.25261692e-02f, 1.78591460e-02f,
  -6.40007704e-02f, -8.18995386e-02f, -4.85526510e-02f, 3.06510497e-02f, 8.95036533e-02f, 2.91769635e-02f, 4.43026394e-04f, -2.89636459e-02f, -1.79037586e-01f, 5.38302138e-02f,
  3.49248736e-03f, -1.64932162e-02f, -1.37854591e-01f, -2.12992817e-01f, -2.08113119e-02f, -1.01383388e-01f, -1.53583571e-01f, -1.78348154e-01f, -1.46243468e-01f, -1.41115099e-01f,
  4.43080366e-02f, 8.37194696e-02f, 2.47817099e-01f, 1.72605559e-01f, 1.61256090e-01f, 1.61994159e-01f, 1.77524194e-01f, 6.49139956e-02f, 1.81605190e-01f, 2.02122822e-01f,
  1.36972681e-01f, 1.25223279e-01f, -5.89933107e-03f, 1.05914570e-01f, 1.80999422e-03f, 3.98275591e-02f, -4.82701100e-02f, 1.05150625e-01f, 1.08405380e-02f, 4.45203930e-02f,
  9.08369720e-02f, -4.27080393e-02f, 4.40013297e-02f, 5.27006686e-02f, -5.13288863e-02f, -7.73758292e-02f, 3.08779050e-02f, -1.50002132e-03f, -1.31980432e-02f, -7.82128945e-02f,
  3.47644269e-01f, 1.00368090e-01f, 1.16146076e-02f, 5.03828339e-02f, 2.88037155e-02f, 1.02005079e-01f, 1.17993630e-01f, 1.19663872e-01f, 5.65657802e-02f, 1.40019506e-01f,
  1.09769829e-01f, -6.12114333e-02f, -8.36508870e-02f, -4.27018143e-02f, 9.42780524e-02f, 8.27918574e-02f, -9.28086322e-03f, 2.81533971e-02f, 7.99767673e-02f, 1.14079669e-01f,
  4.84141670e-02f, -1.88880432e-02f, 8.53432417e-02f, 1.53213609e-02f, -1.12573365e-02f, -4.46076579e-02f, 2.49779765e-02f, -1.34247625e-02f, 1.00500500e-02f, 3.26146297e-02f,
  3.41470689e-02f, -2.69214045e-02f, 5.63500375e-02f, 2.01656390e-02f, 1.88816395e-02f, 1.15398727e-01f, 7.51603511e-04f, -8.11485201e-02f, 1.04381219e-01f, -1.10590085e-01f,
  3.16748209e-02f, 6.71466962e-02f, 1.52856842e-01f, 7.16039836e-02f, 1.18346207e-01f, -2.06248602e-03f, -8.90626237e-02f, -2.13382542e-02f, -1.68453977e-02f, -1.12468816e-01f,
  -7.39276931e-02f, -3.93824689e-02f, -8.46113935e-02f, -6.23035915e-02f, 6.12762161e-02f, 2.77720876e-02f, -3.20512429e-02f, 1.70754455e-02f, -1.02341808e-01f, -1.36409312e-01f,
  4.70077217e-01f, 1.35244250e-01f, -1.93849765e-02f, -1.07562512e-01f, -1.70007106e-02f, -6.48494661e-02f, 1.73422933e-01f, 3.25836465e-02f, 8.30339193e-02f, 1.37742385e-01f,
  1.18415924e-02f, -1.80045646e-02f, -1.35566428e-01f, -5.90739888e-04f, 7.21456185e-02f, -1.46248611e-03f, 1.15446612e-01f, 1.02528043e-01f, 1.68556929e-01f, 1.59231573e-01f,
  -1.99059141e-03f, 2.04720929e-01f, 2.09693626e-01f, 5.41079380e-02f, -4.51661795e-02f, -3.20971012e-02f, 1.21387735e-01f, 2.96569988e-02f, 8.39484707e-02f, 1.25544621e-02f,
  -3.63825589e-01f, -2.90169924e-01f, 2.13912632e-02f, 9.10642967e-02f, -2.10554129e-03f, -2.59244233e-01f, -4.68946248e-01f, -2.84489185e-01f, -9.44646299e-02f, -2.53840387e-01f,
  -2.20218942e-01f, 5.61755672e-02f, 9.55666378e-02f, 1.43453106e-01f, 6.73955604e-02f, 2.65966915e-02f, 3.43230397e-01f, 3.57381612e-01f, 2.25388765e-01f, 5.34435362e-02f,
  1.75144136e-01f, 1.46802336e-01f, 2.13590190e-01f, 1.19677909e-01f, 8.28716904e-02f, 1.14535913e-01f, 1.72943935e-01f, 6.68689087e-02f, 1.74330816e-01f, 3.14447433e-01f,
  -2.22126748e-02f, -2.16702297e-01f, 1.32352367e-01f, 6.30679727e-02f, 5.08838333e-02f, -2.28151958e-02f, 3.98941413e-02f, -3.66248339e-02f, 2.00669132e-02f, 9.18506384e-02f,
  7.03859553e-02f, 1.68033142e-03f, 1.33366347e-03f, -7.08713830e-02f, 5.83455786e-02f, -1.78357363e-02f, -1.53293461e-02f, -2.58711968e-02f, 2.04537455e-02f, -1.58883065e-01f,
  1.15336046e-01f, 3.63427065e-02f, -1.23451672e-01f, -1.30663529e-01f, -1.68649822e-01f, -3.95585703e-05f, -2.07383543e-01f, -4.28973325e-02f, -2.05572337e-01f, -2.32326880e-01f,
  1.41592361e-02f, -1.36739179e-01f, -5.51588535e-02f, 2.61412207e-02f, 1.23582140e-01f, 6.71740696e-02f, 2.05749609e-02f, 6.22691214e-02f, 1.20247059e-01f, 2.62566172e-02f,
  -3.63811180e-02f, -3.35851759e-02f, -1.06900193e-01f, -1.11542039e-01f, -7.13670254e-02f, -3.00243646e-02f, 8.18078220e-02f, 4.54856493e-02f, -7.62952343e-02f, -1.32216318e-02f,
  1.07845634e-01f, -2.15381682e-02f, -1.30241467e-02f, -1.75051857e-02f, -1.14232168e-01f, -9.84520316e-02f, 3.85501049e-02f, -6.70369416e-02f, 1.44406538e-02f, 2.54221889e-03f,
  -1.83495969e-01f, 1.95467442e-01f, -8.25167298e-02f, -3.39692878e-03f, 2.90627405e-03f, -2.38629617e-02f, 7.79061466e-02f, 4.77863774e-02f, 4.10905667e-02f, -1.55462474e-01f,
  -1.14475459e-01f, -5.53088263e-02f, 3.77310552e-02f, -1.24458097e-01f, 7.99605995e-02f, -5.86695001e-02f, 9.60408431e-03f, -3.13216113e-02f, -7.16519356e-02f, -2.24887490e-01f,
  1.67223308e-02f, -1.40366718e-01f, -1.83552131e-01f, -1.58938438e-01f, -8.74747187e-02f, -3.38548534e-02f, -1.06905699e-01f, -6.79650307e-02f, -1.20447509e-01f, -3.17657202e-01f,
  6.02670491e-01f, 2.32180402e-01f, 2.70495445e-01f, 1.62217766e-01f, 7.89085627e-02f, 1.32270068e-01f, 1.51569694e-01f, 8.16982016e-02f, 3.13703194e-02f, 3.38968635e-02f,
  1.60915017e-01f, 6.15103915e-02f, 2.93640904e-02f, -2.90035121e-02f, -2.39671711e-02f, -9.18963626e-02f, -1.21053211e-01f, 4.08416577e-02f, 1.93827599e-01f, -1.97141152e-02f,
  -1.58057764e-01f, -6.48269011e-03f, 1.76890984e-01f, -5.92910163e-02f, -5.73326983e-02f, -6.07757755e-02f, 2.16505975e-02f, -8.21672082e-02f, -7.38050565e-02f, -9.63604003e-02f,
  -2.42305230e-02f, 2.68389434e-01f, -8.37990120e-02f, 2.07693242e-02f, 1.08416891e-02f, -2.21657827e-02f, 3.38532701e-02f, 2.80816089e-02f, 1.04836738e-02f, -6.19863719e-02f,
  -9.23432037e-02f, 6.95776418e-02f, 4.43319418e-02f, -2.94341817e-02f, 1.08698800e-01f, -3.73057164e-02f, 2.86718041e-05f, 7.02466816e-02f, 1.12811014e-01f, 3.81395742e-02f,
  3.76004167e-02f, 1.34017915e-01f, 1.61930442e-01f, -3.20448400e-03f, 1.29946828e-01f, 9.43593979e-02f, 2.71772183e-02f, -3.34683917e-02f, 1.36978418e-01f, 1.45853326e-01f,
  1.70431226e-01f, 2.03662947e-01f, 1.12518735e-01f, 1.31691813e-01f, -1.31631903e-02f, 9.52601805e-02f, -7.33044138e-03f, -1.50845125e-01f, 1.24465153e-01f, -8.30480903e-02f,
  -1.47448123e-01f, 1.24776497e-01f, 1.09511726e-01f, 2.30717543e-03f, 8.56853351e-02f, 1.13031738e-01f, -5.27905971e-02f, -1.77099463e-02f, 1.81200400e-01f, -1.60375647e-02f,
  1.19899191e-01f, -3.41263860e-02f, -1.17935799e-02f, -6.16255477e-02f, -7.95672163e-02f, 7.41958842e-02f, 6.74685091e-02f, -3.73313129e-02f, 6.25805631e-02f, 4.63229790e-03f,
  -2.25748703e-01f, 2.40110084e-01f, -9.89931598e-02f, -5.05128019e-02f, -4.25008051e-02f, -2.01182272e-02f, -4.74942848e-02f, -1.93646587e-02f, -1.10095039e-01f, -1.32665977e-01f,
  -1.18397161e-01f, 5.28646517e-04f, 3.48744206e-02f, -4.87171812e-03f, -4.43623476e-02f, -1.72172058e-02f, 6.61634952e-02f, -3.37096490e-02f, -5.95434718e-02f, -1.68524474e-01f,
  1.99746760e-03f, -2.04688665e-02f, -1.65248048e-02f, 5.26871271e-02f, -2.37921849e-02f, 6.98021650e-02f, -4.29245122e-02f, -1.11416548e-01f, -6.36007860e-02f, -7.53234997e-02f,
  8.81068129e-03f, -2.07153291e-01f, -2.98941374e-01f, -7.42188096e-02f, -1.86518237e-01f, -1.01084501e-01f, -1.18168168e-01f, 7.71302953e-02f, -1.12008899e-02f, -1.64418712e-01f,
  -1.34913445e-01f, 1.06898613e-01f, -1.01269424e-01f, -5.04024364e-02f, 9.78708342e-02f, -2.43763149e-01f, -2.66371131e-01f, -2.57982146e-02f, 1.80561796e-01f, 1.14001282e-01f,
  3.70987342e-03f, -2.59878039e-02f, 1.82559386e-01f, 1.87083378e-01f, -6.88089803e-02f, -7.49546941e-03f, -1.39303327e-01f, 2.77340934e-02f, 2.52134725e-02f, -2.46617809e-01f,
  -1.37054071e-01f, -2.26222519e-02f, 7.53186503e-03f, 8.66887271e-02f, -2.06791148e-01f, 5.62342741e-02f, -4.63298336e-02f, 1.35943647e-02f, 1.63051225e-02f, -1.68937162e-01f,
  9.48589947e-03f, 3.55664603e-02f, -7.90322199e-02f, 5.23457527e-02f, 9.61401835e-02f, 2.37157308e-02f, -1.15485333e-01f, 7.25878924e-02f, -9.21124071e-02f, -8.53700712e-02f,
  -7.72454515e-02f, -8.34467113e-02f, 7.21851960e-02f, 5.77116981e-02f, -3.74848619e-02f, 9.06546880e-03f, 4.11930010e-02f, 5.33674844e-02f, 5.32196462e-02f, 6.04447275e-02f,
  2.94258483e-02f, 2.85211280e-02f, 6.87042773e-02f, 5.94004989e-02f, 1.10782221e-01f, -7.37027526e-02f, -7.90668651e-03f, -6.21187268e-03f, 1.18213847e-01f, 1.06634177e-01f,
  -9.51004401e-02f, -1.13915145e-01f, 6.10018596e-02f, -1.45627812e-01f, -2.00967472e-02f, -1.45329475e-01f, 6.80691078e-02f, -9.03630704e-02f, 4.12971526e-02f, -5.98454289e-02f,
  -4.82117720e-02f, -4.88854982e-02f, 8.08054209e-02f, 8.37146789e-02f, -9.69365016e-02f, 5.64988889e-03f, 6.48710877e-03f, 4.20613512e-02f, 9.72903147e-03f, -2.98912562e-02f,
  2.51325279e-01f, -1.15275688e-01f, -1.59113742e-02f, 3.30736823e-02f, -4.16087313e-03f, -1.09956570e-01f, -1.31650478e-01f, -1.29673686e-02f, -1.13249989e-03f, -9.11615938e-02f,
  4.11683740e-03f, 3.42111215e-02f, -1.81344803e-02f, -6.25002682e-02f, 1.20732032e-01f, -2.64298096e-02f, -1.03797801e-01f, 8.75961967e-03f, 6.07095808e-02f, -4.94813174e-02f,
  -9.31911096e-02f, -1.27342939e-02f, 3.60154472e-02f, 7.41459951e-02f, 8.78484622e-02f, 6.07145578e-02f, 1.05037101e-01f, 2.49287114e-03f, 1.36543840e-01f, 1.02957755e-01f,
  -1.93127796e-01f, -1.07546046e-01f, -1.04954310e-01f, -1.98660254e-01f, -2.27118395e-02f, 1.13340743e-01f, -2.45544389e-02f, 1.04803495e-01f, 2.83727068e-02f, -1.91544652e-01f,
  -6.42997697e-02f, -1.79677494e-02f, -1.21095352e-01f, 2.03045290e-02f, 1.02916420e-01f, -1.60223961e-01f, -1.14158757e-01f, 3.14934403e-02f, 2.37278029e-01f, 9.88144726e-02f,
  5.40304407e-02f, 6.66432306e-02f, 1.24733336e-01f, 2.32768040e-02f, -2.89478958e-01f, -1.29725039e-01f, -2.21551165e-01f, -2.11148143e-01f, -1.56325474e-01f, -4.22646612e-01f,
  -1.65953010e-01f, -3.79610211e-02f, 3.84738371e-02f, -1.85135473e-02f, -8.77190530e-02f, 2.86110677e-02f, -6.60901964e-02f, -2.85906103e-02f, 7.64687806e-02f, 3.34847681e-02f,
  -1.62934735e-01f, -3.91060449e-02f, -1.42279744e-01f, 1.80944607e-01f, 6.58043846e-02f, 5.21637779e-03f, 5.25323972e-02f, 1.61354840e-01f, -3.49279097e-03f, 4.85145301e-02f,
  -1.07917845e-01f, -1.21681079e-01f, -2.21133232e-01f, -7.30431378e-02f, -1.47325844e-01f, -3.05822995e-02f, -1.30712375e-01f, -1.71024144e-01f, -1.76250171e-02f, -2.44999111e-01f,
  1.23504914e-01f, 1.16600208e-01f, 1.01658762e-01f, 1.07560486e-01f, 1.56372599e-02f, -8.69683828e-03f, -5.55229858e-02f, -5.41707966e-03f, 7.25799706e-03f, 5.62899746e-02f,
  3.53556015e-02f, 7.59985000e-02f, 1.32483132e-02f, -2.19569236e-01f, -8.98016468e-02f, 7.30906799e-02f, 3.12903486e-02f, 1.93008911e-02f, -1.16479084e-01f, -3.80584924e-03f,
  -3.11814528e-02f, -4.03391570e-02f, 3.94526646e-02f, 1.24491327e-01f, 5.30290753e-02f, 4.09980752e-02f, -4.63536941e-02f, 3.48145030e-02f, 1.02016144e-01f, 1.24817990e-01f,
  -9.92543325e-02f, 4.00346816e-02f, 3.86306457e-02f, -1.39458971e-02f, 1.70702279e-01f, 2.55948938e-02f, -1.62236299e-02f, 2.58678585e-01f, 3.54882032e-02f, 5.26642650e-02f,
  4.94208857e-02f, -2.47928239e-02f, -1.87193856e-01f, 9.37603880e-03f, 9.41090286e-02f, -1.13866232e-01f, -6.40560091e-02f, 3.81554738e-02f, 3.10305087e-03f, 7.06247578e-04f,
  -3.88419293e-02f, -8.63601044e-02f, -1.75884068e-01f, -8.53618458e-02f, -7.82863423e-02f, -2.17159972e-01f, -1.59372285e-01f, -1.75888509e-01f, -1.10628299e-01f, -1.15592539e-01f,
  1.35268897e-01f, -1.71260208e-01f, -2.50125349e-01f, 7.75697306e-02f, -2.69366980e-01f, -3.09922755e-01f, -2.59080261e-01f, 5.48185259e-02f, 2.08771080e-01f, -2.70175844e-01f,
  -1.43420264e-01f, 1.88208312e-01f, -3.57812680e-02f, -7.59637058e-02f, 2.03382857e-02f, -3.41551721e-01f, -2.99864769e-01f, -1.68054253e-01f, 5.89389279e-02f, 3.49991247e-02f,
  -4.10998985e-02f, 1.02433395e-02f, 1.66492254e-01f, 1.89980090e-01f, 7.56582543e-02f, 1.32991642e-01f, -1.05463512e-01f, -5.78484386e-02f, -6.97324127e-02f, -1.52985841e-01f,
  -3.30910057e-01f, 8.52028280e-02f, -1.01041548e-01f, 9.92630944e-02f, -8.19072351e-02f, 4.39860784e-02f, 6.27288371e-02f, 5.87772951e-02f, 4.09699790e-02f, -6.17358312e-02f,
  -1.48695603e-03f, -7.22783282e-02f, 1.63451768e-02f, 4.80436832e-02f, -3.58525440e-02f, -3.81530374e-02f, 5.36383837e-02f, 6.16710074e-03f, -5.57946973e-02f, -1.15450680e-01f,
  -1.23052359e-01f, -4.48925458e-02f, -9.73552912e-02f, -1.61433257e-02f, -1.07539691e-01f, -2.86985226e-02f, 3.99030261e-02f, 1.07336119e-01f, 6.23316430e-02f, -4.73991111e-02f,
  -1.09091721e-01f, -1.25993297e-01f, -9.73252356e-02f, -2.12289393e-02f, 7.09191635e-02f, 2.26490311e-02f, -3.33982077e-03f, -1.08652478e-02f, 6.56868471e-03f, -1.97850866e-04f,
  2.40381733e-02f, -5.98619245e-02f, 7.96518347e-04f, 1.35628115e-02f, 6.55553024e-03f, 8.25860277e-02f, 6.84961630e-03f, -6.01400398e-02f, 6.42926618e-02f, 8.21545371e-04f,
  4.77711260e-02f, -9.46506392e-03f, 5.92239462e-02f, 1.18010111e-01f, -7.86369666e-02f, -4.20304798e-02f, -4.86058183e-02f, 1.63370706e-02f, 1.10710256e-01f, 5.23002632e-02f,
  9.10532773e-02f, -1.14998400e-01f, -6.91606104e-02f, 3.26433405e-02f, -1.78571034e-03f, -1.56365391e-02f, 1.86707806e-02f, 8.07978064e-02f, 5.07152081e-02f, -3.04277837e-02f,
  -2.16005761e-02f, 3.91859487e-02f, -1.07571356e-01f, -1.33564528e-02f, -5.95102347e-02f, 1.38367983e-02f, 8.46769568e-03f, -3.57856974e-02f, -5.58758266e-02f, 1.56673957e-02f,
  3.92524386e-03f, -2.94385776e-02f, 8.60767141e-02f, -7.16650784e-02f, -5.73180057e-03f, 1.30037025e-01f, -7.65128359e-02f, -2.39174739e-02f, -4.72418107e-02f, 7.34488890e-02f,
  5.25889218e-01f, -3.00658911e-01f, 3.42629142e-02f, 1.83086559e-01f, -7.88133666e-02f, -1.50597738e-02f, -5.31386994e-02f, 3.44824269e-02f, 1.68621734e-01f, -8.72720182e-02f,
  -6.03340566e-02f, 4.97973897e-02f, 1.81867741e-02f, 5.84830865e-02f, 2.96649020e-02f, 8.66626296e-03f, 1.51450057e-02f, 1.82207227e-01f, 2.67388940e-01f, 5.55902570e-02f,
  1.48077020e-02f, 1.10500129e-02f, 2.52261281e-01f, 9.93548781e-02f, -1.03807084e-01f, 6.14384795e-03f, -4.25541997e-02f, -2.09732533e-01f, -2.33689025e-01f, -2.50335097e-01f,
  -3.05539042e-01f, -1.56913385e-01f, 2.16402989e-02f, -2.09702272e-02f, -1.74537212e-01f, 5.20591661e-02f, -3.62452911e-03f, -8.11525658e-02f, 4.38975245e-02f, -6.85052574e-02f,
  -8.05684105e-02f, -6.37034029e-02f, 4.12116613e-04f, -6.22416176e-02f, -4.12302800e-02f, 4.85505871e-02f, -1.03596941e-01f, -9.34748873e-02f, -1.24474049e-01f, -5.81528693e-02f,
  -7.23255724e-02f, -3.79379615e-02f, -9.06671658e-02f, 3.73626756e-03f, 8.65391418e-02f, 4.13117558e-02f, -1.38424292e-01f, -2.50953510e-02f, -9.62249786e-02f, 1.47586122e-01f,
  4.43676412e-02f, -3.88060436e-02f, -5.47738001e-02f, 1.29521430e-01f, 1.25111178e-01f, 5.82252182e-02f, 1.06303118e-01f, 7.93139115e-02f, 1.93333372e-01f, 4.96516190e-02f,
  -5.81244193e-02f, 4.58159186e-02f, -4.48633954e-02f, 9.18280712e-05f, -1.14225112e-01f, -7.92274997e-02f, -7.58249909e-02f, 2.65559088e-02f, -1.10067002e-01f, -1.12857372e-01f,
  -7.66902836e-03f, -7.60937203e-03f, -8.68829414e-02f, -1.21002376e-01f, -2.68084437e-01f, 3.55350897e-02f, 5.22298478e-02f, -3.78136002e-02f, 6.40632138e-02f, 6.09582104e-02f,
  -1.23108603e-01f, 2.07410194e-03f, 1.73257351e-01f, -1.33914828e-01f, -7.81804249e-02f, 7.91610312e-03f, -1.19660713e-03f, 3.71226557e-02f, -1.67291507e-01f, -3.59155796e-02f,
  -8.26332644e-02f, 1.57924801e-01f, -5.93739329e-03f, 2.37121303e-02f, 2.60111272e-01f, 2.20400572e-01f, -5.47061488e-02f, 8.49134699e-02f, -7.91326314e-02f, -6.79295957e-02f,
  2.70640887e-02f, 1.89027622e-01f, 1.16728041e-02f, 1.22188449e-01f, 9.50715765e-02f, 1.07956447e-01f, 1.12460084e-01f, -2.02822927e-02f, 1.58238918e-01f, 3.64574105e-01f,
  -8.70378196e-01f, -1.93080232e-01f, 5.58984429e-02f, -6.25057638e-01f, -2.44163677e-01f, -4.69028950e-02f, 2.16283455e-01f, -5.82409315e-02f, -3.99578720e-01f, -1.41869085e-02f,
  -3.71261016e-02f, -9.10548028e-04f, -4.93587777e-02f, 1.42303586e-01f, 5.31006902e-02f, 1.55786842e-01f, -1.40664652e-01f, -1.67467326e-01f, 9.42668244e-02f, 6.72968701e-02f,
  2.28564478e-02f, -3.20441753e-01f, -4.30213660e-01f, -1.96447194e-01f, -2.54601210e-01f, -1.89339742e-01f, -1.34875149e-01f, -7.78916255e-02f, 8.44844133e-02f, -2.55132258e-01f,
  5.48745871e-01f, -2.32118994e-01f, 4.28770818e-02f, -3.12261999e-01f, -8.97045955e-02f, -9.17114243e-02f, 2.93291942e-03f, -5.94866872e-02f, -1.41116366e-01f, -1.17326312e-01f,
  -1.52383372e-01f, 3.49812359e-02f, 5.57177775e-02f, 1.62324533e-02f, -1.17341973e-01f, 8.18408839e-03f, 7.50336796e-02f, -1.72737017e-01f, 6.73714187e-03f, 2.54528016e-01f,
  5.63908592e-02f, -8.18745568e-02f, 7.74596408e-02f, 6.78861365e-02f, 6.08306080e-02f, -4.33285162e-03f, 2.06203014e-01f, 1.38926953e-01f, 9.05195624e-02f, -6.46554604e-02f,
  -2.40191203e-02f, 4.17709723e-02f, 2.89033186e-02f, 4.46442002e-03f, 7.05615580e-02f, 2.80641415e-03f, -1.08026983e-02f, -1.32601783e-02f, -9.63430256e-02f, -2.30981223e-02f,
  2.88349818e-02f, -3.15843523e-02f, -2.83867330e-03f, -5.37527427e-02f, -6.25485778e-02f, -1.84417013e-02f, -7.26760784e-03f, -4.94301021e-02f, -6.66545928e-02f, -6.44328892e-02f,
  -6.73245117e-02f, 2.53833346e-02f, -1.17588624e-01f, 7.44792745e-02f, -3.34584676e-02f, 2.06585880e-02f, -1.37794018e-02f, 5.07187471e-02f, -4.05833125e-02f, -6.54078946e-02f,
  1.70311779e-01f, 2.57141944e-02f, 1.78112462e-02f, -8.02032650e-02f, -5.17510511e-02f, -8.28796402e-02f, -4.84552011e-02f, -1.61844995e-02f, -7.33100176e-02f, 1.02739789e-01f,
  -2.02810159e-03f, -1.08079500e-02f, 4.12658267e-02f, 2.17749868e-02f, -2.84090582e-02f, -2.56556086e-02f, -1.73565336e-02f, -7.73711577e-02f, 4.85135838e-02f, 3.40052247e-02f,
  6.44616783e-02f, 4.25440967e-02f, 1.58462554e-01f, 1.68881938e-01f, 4.45944443e-02f, 1.49974838e-01f, 2.40671411e-01f, 7.84400627e-02f, 2.34241799e-01f, 6.02974817e-02f,
  3.71862262e-01f, -4.23171744e-02f, -6.26875982e-02f, 2.63322949e-01f, -4.69029918e-02f, 8.61550197e-02f, 1.47776529e-01f, 8.46258253e-02f, 1.49357021e-01f, 1.59160852e-01f,
  -2.16967896e-01f, -3.76465231e-01f, -3.32595229e-01f, -3.38058293e-01f, -1.11661173e-01f, 1.90273732e-01f, 4.40541506e-02f, -9.14947242e-02f, -9.76485834e-02f, 7.95241073e-02f,
  1.52797634e-02f, 2.76117235e-01f, 2.40064010e-01f, 5.80752455e-03f, 4.76108491e-02f, -1.51470110e-01f, 7.92801231e-02f, -5.90990623e-03f, -1.23410344e-01f, -1.70088068e-01f,
  -2.12209985e-01f, -1.43608749e-01f, -2.76998710e-02f, -1.02009527e-01f, -1.67014897e-01f, 8.60089585e-02f, -3.00802402e-02f, -9.45115685e-02f, -1.44129679e-01f, -3.48738469e-02f,
  -2.45593607e-01f, -7.25568980e-02f, -4.09224391e-01f, -1.11057341e-01f, 1.07260063e-01f, -7.14717358e-02f, 1.36113703e-01f, -9.43936706e-02f, -6.55112639e-02f, -9.72528160e-02f,
  -1.57118559e-01f, -9.75426435e-02f, -1.47839069e-01f, -5.43329380e-02f, -2.49234319e-01f, -1.48109466e-01f, -8.71958062e-02f, -1.55806884e-01f, -1.88787833e-01f, 9.75188538e-02f,
  5.90224452e-02f, -1.12899244e-02f, -7.94698149e-02f, 2.19511669e-02f, 8.25768337e-02f, -8.47449675e-02f, -8.67884532e-02f, 1.68006979e-02f, -1.82432740e-03f, 1.76202357e-01f,
  -1.52328223e-01f, 1.47624044e-02f, -1.61399003e-02f, 2.06825044e-02f, 2.27089152e-02f, 7.02449903e-02f, 8.99440423e-02f, 1.05903484e-01f, 3.54309827e-02f, 3.38729508e-02f,
  5.01304939e-02f, 5.65815046e-02f, -8.22597891e-02f, -5.27459159e-02f, 9.68049746e-03f, 8.96798912e-03f, 1.12013862e-01f, -7.71927088e-02f, 5.57326078e-02f, -2.75755916e-02f,
  2.38339558e-01f, -7.54911155e-02f, 7.64624327e-02f, -3.20246667e-02f, -1.46334488e-02f, 5.94891384e-02f, -1.10025287e-01f, -1.95677176e-01f, -1.41342655e-01f, 2.86138598e-02f,
  -1.59466103e-01f, -1.55297607e-01f, -1.57542422e-01f, 1.82046313e-02f, 1.66252688e-01f, -3.99814695e-02f, 1.03476383e-01f, 4.26619463e-02f, 1.25412166e-01f, 7.82934502e-02f,
  9.59848240e-02f, 1.81224048e-01f, 9.65581909e-02f, -1.95373818e-02f, -2.46821716e-02f, 1.82121933e-01f, 7.99224526e-02f, 3.58727947e-02f, 6.68549612e-02f, 4.50256377e-01f,
  -2.92590559e-01f, -1.01719685e-01f, -1.83119193e-01f, -1.90713838e-01f, 2.50216797e-02f, 4.98483144e-02f, -5.96897528e-02f, 1.25810087e-01f, -1.30764926e-02f, -1.50031149e-01f,
  -2.78740078e-02f, -1.59974307e-01f, -5.36975786e-02f, -1.61624447e-01f, -2.12088764e-01f, -2.81885922e-01f, -1.82350472e-01f, -4.10257757e-01f, -2.60442406e-01f, -1.23026773e-01f,
  -2.11791679e-01f, -3.87568235e-01f, -3.67790401e-01f, -1.74868599e-01f, -1.21742375e-01f, -1.89614266e-01f, -2.79480070e-01f, -7.87959471e-02f, 5.68899512e-02f, -1.51699692e-01f,
  -2.80736595e-01f, 2.27243245e-01f, -1.42652728e-02f, -3.04857995e-02f, -6.07562028e-02f, 4.78112549e-02f, -8.21362212e-02f, 6.00924045e-02f, 1.02779485e-01f, 1.13422535e-01f,
  1.10396659e-02f, 1.63088255e-02f, -6.32252023e-02f, -5.34589067e-02f, 5.27573414e-02f, 2.01757532e-03f, 2.59514302e-02f, 1.31950513e-01f, 1.65867835e-01f, 1.61027193e-01f,
  1.48098290e-01f, 1.60140023e-01f, 1.77738875e-01f, 2.08950713e-01f, 2.24040642e-01f, 5.65231480e-02f, 1.43093541e-01f, 3.06132555e-01f, 1.86322629e-01f, 4.55088578e-02f,
  -5.79342954e-02f, -1.94203407e-02f, 5.70848994e-02f, 3.83891165e-02f, 5.09020053e-02f, 1.08357100e-02f, -7.83484802e-02f, -1.89185664e-02f, -4.48335567e-03f, -2.94077657e-02f,
  -4.41496149e-02f, 1.07634380e-01f, -3.49497944e-02f, -1.09889731e-01f, -1.85935706e-01f, 3.64970639e-02f, -6.18503653e-02f, 1.76776536e-02f, -7.34581705e-03f, 1.23035520e-01f,
  2.02018768e-01f, 1.08568430e-01f, -5.95990941e-02f, -8.79258215e-02f, -1.08681002e-03f, -7.77958855e-02f, 3.37880217e-02f, 8.05426612e-02f, 3.58470008e-02f, -3.69777880e-03f,
  -3.26664805e-01f, -1.18764944e-01f, -6.82346001e-02f, 1.07858628e-01f, -4.73709106e-02f, 5.47332019e-02f, -3.77684049e-02f, -1.16006412e-01f, -9.24291275e-03f, 1.51646221e-02f,
  2.37343907e-02f, -2.43008539e-01f, -1.85778990e-01f, 3.21887732e-02f, -1.60005212e-01f, 3.28581184e-02f, 1.25269562e-01f, -2.75121257e-02f, 2.16240678e-02f, 1.99079514e-02f,
  4.07557860e-02f, 9.81964753e-04f, -5.30813560e-02f, 6.35318682e-02f, 1.36705637e-01f, -4.03192937e-02f, -1.17675342e-01f, 3.94355282e-02f, -3.58189382e-02f, -1.84868902e-01f,
  4.90698069e-01f, 3.48524690e-01f, 1.74607396e-01f, 3.58332018e-03f, -7.00815469e-02f, -1.52350683e-02f, 9.66859758e-02f, 7.05093369e-02f, -4.38043922e-02f, 1.32415161e-01f,
  -2.93850563e-02f, -2.92086527e-02f, -1.30779520e-01f, 8.74009281e-02f, 9.22583491e-02f, 1.05083950e-01f, 1.83401272e-01f, 2.90698498e-01f, 2.03620642e-01f, 4.26680259e-02f,
  -2.58514797e-03f, 2.10491091e-01f, 3.22433352e-01f, 2.27068648e-01f, 7.79882148e-02f, 3.70120667e-02f, 3.07191461e-02f, 1.14174172e-01f, 1.24002866e-01f, 3.06439430e-01f,
  -1.36023924e-01f, 2.73530424e-01f, -8.53868574e-02f, -2.77095009e-02f, -6.11448614e-03f, 7.23471940e-02f, -6.31538853e-02f, 9.62909609e-02f, 2.04738528e-02f, -1.45283654e-01f,
  3.83218974e-02f, 3.78781487e-03f, -9.35348868e-03f, -1.04766093e-01f, -3.49365361e-02f, -9.38146859e-02f, 6.50269613e-02f, 1.79021377e-02f, -3.40047516e-02f, -5.34081794e-02f,
  6.95262896e-03f, -1.04270481e-01f, -4.97898571e-02f, -1.24772213e-01f, -1.68646704e-02f, -1.46537021e-01f, -2.98125446e-02f, 8.61638635e-02f, -1.22047305e-01f, -1.68416444e-02f,
  -5.71468771e-02f, 3.10750566e-02f, -1.05796335e-02f, -5.70988208e-02f, -3.43676843e-02f, -8.27731490e-02f, -1.37318462e-01f, -1.48489907e-01f, 7.50189051e-02f, -1.52565828e-02f,
  -1.43033385e-01f, -3.64731997e-02f, -1.14798114e-01f, -1.33456469e-01f, 4.79086116e-02f, 1.87226795e-02f, 6.47979276e-03f, -7.43490160e-02f, -1.44475803e-01f, 3.72343212e-02f,
  -6.67305812e-02f, 3.14853936e-02f, -4.59832996e-02f, -4.63974103e-02f, -3.09429206e-02f, -1.15225136e-01f, -1.33656785e-01f, -1.42632350e-02f, 6.94094226e-03f, 7.47562274e-02f,
  -4.00124550e-01f, -1.09614529e-01f, 2.81772185e-02f, 2.48336136e-01f, 6.90330118e-02f, 1.59248888e-01f, 1.32882789e-01f, 2.13524774e-02f, -2.96212491e-02f, 4.03473452e-02f,
  -4.04760279e-02f, -1.54988386e-03f, -6.22270769e-03f, 2.14384720e-02f, -9.81297567e-02f, -3.51749659e-02f, -1.57828741e-02f, 5.56119531e-02f, 1.08892787e-02f, -2.89113615e-02f,
  -3.27108651e-02f, -3.60532576e-04f, -9.48262736e-02f, -1.13995500e-01f, -1.22980997e-01f, -1.56471163e-01f, -1.88112125e-01f, 5.58886817e-03f, -5.55236898e-02f, -1.90635666e-01f,
  2.16377661e-01f, 2.87154973e-01f, 1.26649618e-01f, 7.42853945e-03f, 1.93969265e-01f, 1.41701177e-01f, 2.83523768e-01f, 9.15618911e-02f, -1.25574276e-01f, 9.21534821e-02f,
  1.98483407e-01f, -1.05379105e-01f, -1.77734330e-01f, -2.07520455e-01f, 1.15322620e-01f, 5.70455827e-02f, -2.05914482e-01f, -9.19270441e-02f, -5.88316582e-02f, 5.73214367e-02f,
  -1.67152673e-01f, -5.96703216e-02f, 2.28382926e-02f, -8.11809674e-02f, 1.32997753e-02f, -1.98038459e-01f, 3.27189490e-02f, 5.27999923e-02f, 6.65346906e-02f, -2.89137304e-01f,
  1.57780886e-01f, 3.41854274e-01f, -1.96975157e-01f, -2.07094047e-02f, 7.46656060e-02f, -2.00804234e-01f, -6.44783750e-02f, -7.43837431e-02f, -1.02004282e-01f, -1.49600759e-01f,
  2.40455717e-02f, -2.75727175e-03f, 8.35866928e-02f, 8.78185704e-02f, 2.16915868e-02f, 7.41019547e-02f, 1.48986327e-02f, -7.70988762e-02f, -6.87146187e-02f, 5.08851260e-02f,
  -1.68192804e-01f, 1.02593541e-01f, 2.31732368e-01f, -7.92593285e-02f, -8.79852772e-02f, -1.86352074e-01f, 9.57140625e-02f, -8.54349732e-02f, 4.76950221e-02f, -9.20750275e-02f,
  -7.58050680e-02f, 1.92827138e-03f, 1.27502561e-01f, 1.53067801e-02f, -7.22422227e-02f, -1.46655872e-01f, -1.27390418e-02f, 1.00700118e-01f, -1.69726294e-02f, -4.34389012e-03f,
  -4.50673625e-02f, 1.02192335e-01f, -6.71977848e-02f, 3.18576545e-02f, -2.08256207e-02f, -6.77936012e-03f, -5.33824833e-03f, 3.59070152e-02f, 6.60790950e-02f, -1.27444267e-02f,
  4.96446118e-02f, 3.99385616e-02f, 5.66152893e-02f, 7.94761404e-02f, -2.09312681e-02f, -1.43562127e-02f, -6.50808513e-02f, -2.40157433e-02f, -1.05531834e-01f, -8.72978196e-02f,
  -1.11904740e-02f, 2.85026312e-01f, -1.91649109e-01f, -1.87247619e-01f, 1.96044490e-01f, 2.45266370e-02f, 5.75968698e-02f, 5.90278208e-02f, -3.80356722e-02f, -6.55153170e-02f,
  1.61196783e-01f, 4.25576605e-02f, 8.71215463e-02f, 2.27632634e-02f, -1.33290261e-01f, -1.09775603e-01f, 1.88280977e-02f, 2.91350391e-02f, 2.86445231e-03f, -5.66833429e-02f,
  -1.24608971e-01f, -2.57268492e-02f, 1.79765690e-02f, -3.48252989e-02f, -1.58152446e-01f, -1.95706218e-01f, 1.93530731e-02f, -1.71429999e-02f, 1.20751664e-01f, -2.11070344e-01f,
  4.34928149e-01f, 7.23976418e-02f, 1.16307452e-01f, 1.91864610e-01f, 2.21693322e-01f, 2.87040323e-02f, 1.20607801e-01f, 5.62865101e-02f, 7.26486519e-02f, 1.63274795e-01f,
  1.74495205e-01f, 8.79473239e-02f, 2.85661239e-02f, -3.64710651e-02f, -1.99498818e-03f, 6.07467666e-02f, 1.29344851e-01f, 1.28229350e-01f, 9.02478918e-02f, 1.57068610e-01f,
  9.23562795e-02f, 1.70848921e-01f, 1.32556617e-01f, 1.13368936e-01f, 9.32766497e-02f, 1.02448918e-01f, 9.19699818e-02f, 2.16518901e-02f, 6.74779713e-02f, 2.83371471e-02f,
  4.61118072e-02f, 2.53725052e-01f, -5.99255450e-02f, 9.27102640e-02f, 3.15830112e-02f, -7.93298706e-02f, -9.73785743e-02f, -1.46718085e-01f, -1.44119918e-01f, -6.80177584e-02f,
  -4.66991216e-02f, 4.47936589e-03f, 4.65736948e-02f, -3.88433821e-02f, -5.58367856e-02f, -2.25412380e-02f, 3.66257876e-02f, -8.82391930e-02f, -1.08181305e-01f, 9.63345636e-03f,
  -7.74068907e-02f, 1.02553971e-03f, 4.49959077e-02f, -2.95128785e-02f, 8.80729705e-02f, 6.95336163e-02f, 9.54685081e-03f, 4.63962257e-02f, 5.76834753e-03f, 3.54205468e-03f,
  -2.27076150e-02f, 1.09345265e-01f, 1.51113689e-01f, 1.18966691e-01f, 1.23232119e-01f, 3.06196623e-02f, 7.77077228e-02f, 4.61226329e-02f, 1.61936626e-01f, -3.98988277e-02f,
  -3.52622420e-02f, -5.93381748e-02f, -1.09136529e-01f, -4.05386090e-02f, 3.82907502e-02f, -7.07848072e-02f, -1.76326349e-01f, -7.81175047e-02f, -5.23088872e-02f, -5.49801141e-02f,
  5.55271842e-02f, -1.02103660e-02f, 7.76629448e-02f, -5.28030321e-02f, -3.26263569e-02f, -5.55960350e-02f, 3.11489441e-02f, -6.33040965e-02f, -5.04127378e-03f, 9.18328464e-02f,
  -2.87804395e-01f, 6.83609620e-02f, 9.94063243e-02f, -1.20260164e-01f, 7.34472200e-02f, -1.37887120e-01f, 9.97110233e-02f, -1.42697647e-01f, -2.21404657e-02f, 1.59265064e-02f,
  -7.76181817e-02f, 2.80421935e-02f, -5.36742695e-02f, -1.15466930e-01f, -1.09665394e-01f, -9.65009183e-02f, -8.48225877e-02f, -6.89798743e-02f, -3.81853990e-02f, -1.79124340e-01f,
  -1.64226502e-01f, -1.31217629e-01f, -1.48653179e-01f, -1.58736736e-01f, -9.66124535e-02f, 2.68667880e-02f, -7.60884583e-02f, -1.37389094e-01f, -9.46010128e-02f, -1.26720548e-01f,
  -2.96244323e-01f, -2.75862366e-02f, 1.96348280e-01f, -3.79730240e-02f, 1.80555373e-01f, 3.53849009e-02f, -3.07920933e-01f, -1.73571125e-01f, 4.84758709e-03f, -1.29801512e-01f,
  2.32574672e-01f, 1.25031278e-01f, 1.38506308e-01f, 5.20718023e-02f, -3.93150538e-01f, -1.61856174e-01f, -7.64238238e-02f, -1.08369499e-01f, -9.66911986e-02f, -6.70782998e-02f,
  7.31428191e-02f, -3.16190906e-02f, -7.68072233e-02f, -1.11757196e-01f, -3.62954438e-02f, -1.76146708e-03f, -3.61932293e-02f, -1.49790898e-01f, -1.11847468e-01f, -9.53517333e-02f,
  5.87542839e-02f, 3.64476652e-03f, 9.81330648e-02f, -5.25563806e-02f, 1.61544695e-01f, -1.31771326e-01f, -9.53397155e-02f, 1.10363014e-01f, 1.36126339e-01f, 1.21130664e-02f,
  1.05486736e-01f, -2.89460439e-02f, 1.34975389e-01f, 1.23891579e-02f, -5.18079251e-02f, -8.57247114e-02f, -3.89664620e-02f, -3.83957960e-02f, -1.42954618e-01f, -4.09702621e-02f,
  -1.07036881e-01f, -4.88973521e-02f, -2.83292811e-02f, -2.92993158e-01f, -3.61350439e-02f, -1.16548926e-01f, -1.21423535e-01f, -1.26416549e-01f, -1.42788723e-01f, -3.66503090e-01f,
  -1.10959440e-01f, 1.16299264e-01f, 5.87807819e-02f, -3.63870040e-02f, -3.40191908e-02f, -3.65288891e-02f, 2.65618786e-02f, -1.07599139e-01f, -8.30159057e-03f, -1.64428368e-01f,
  1.29103333e-01f, 7.26958215e-02f, 6.68267161e-03f, 4.84655937e-03f, -1.18566968e-01f, 4.90044709e-03f, -1.90309789e-02f, -1.48351222e-01f, -8.29326957e-02f, -7.50632733e-02f,
  6.55077258e-03f, 1.11335024e-01f, 1.05177179e-01f, -5.16238883e-02f, -5.06652705e-02f, -9.35582519e-02f, 6.18844293e-03f, 7.56199285e-03f, -1.58877193e-03f, -9.66589302e-02f,
  -4.73019518e-02f, 4.54026051e-02f, 3.25031728e-02f, -2.78578349e-03f, 3.86573859e-02f, 6.96491301e-02f, -1.57430600e-02f, 3.80379185e-02f, 9.33356285e-02f, 5.85209765e-03f,
  3.33724804e-02f, -1.14394918e-01f, -3.38784307e-02f, 1.27146905e-02f, -4.70947735e-02f, -5.17813005e-02f, -2.43548170e-01f, -1.26054063e-02f, -1.06180899e-01f, 7.95421097e-03f,
  -1.59960806e-01f, -2.30131418e-01f, -1.93318322e-01f, -2.87083119e-01f, -1.14351049e-01f, -1.80190444e-01f, -3.83701846e-02f, -4.59941141e-02f, -1.78919435e-01f, -3.97590876e-01f,
  8.31566527e-02f, 1.57871880e-02f, -2.60818064e-01f, 1.04482351e-04f, -2.60760635e-01f, -1.35064662e-01f, 8.47382098e-03f, -1.83307111e-01f, -4.16215770e-02f, 1.07110456e-01f,
  -4.05985638e-02f, 1.92100480e-02f, 1.90348759e-01f, -1.52505681e-01f, -9.74187702e-02f, -2.93697743e-03f, -1.98576704e-01f, -1.11704700e-01f, -1.81735411e-01f, -1.32415369e-01f,
  2.69580185e-02f, 2.03549236e-01f, 2.53360942e-02f, 2.92967129e-02f, 1.82873487e-01f, 1.14122324e-01f, 1.65126592e-01f, -5.72707392e-02f, -7.32379109e-02f, 1.49152055e-02f,
  3.84510905e-01f, -2.20660761e-01f, -7.78160244e-02f, -2.01981872e-01f, -7.19357580e-02f, -3.36961411e-02f, 8.95783082e-02f, -1.18975945e-01f, -1.62412137e-01f, -6.62232339e-02f,
  -2.51569301e-01f, -1.27435878e-01f, -5.30740395e-02f, -8.94676894e-02f, 1.15478434e-01f, -1.65952761e-02f, 4.92951386e-02f, -3.19320187e-02f, -5.88514619e-02f, -1.18498392e-01f,
  -2.93311272e-02f, -9.87899154e-02f, -7.68230259e-02f, -8.32402729e-04f, -1.07788421e-01f, -4.62984852e-02f, -7.78220594e-02f, -6.67690113e-02f, -2.24480346e-01f, 2.16995150e-01f,
  4.30763476e-02f, 4.78703454e-02f, -1.50091955e-02f, 9.23486054e-02f, 4.68606651e-02f, -2.45477669e-02f, 4.99630980e-02f, -2.00075544e-02f, 1.08851574e-01f, -6.07819408e-02f,
  -2.07501594e-02f, -4.69313785e-02f, -4.85694148e-02f, -7.34863281e-02f, -2.31694020e-02f, -9.77760553e-03f, -4.65632714e-02f, 1.93567455e-01f, 4.97179218e-02f, -2.24042777e-02f,
  -4.85405289e-02f, 6.75716102e-02f, 6.28656102e-03f, 1.22847714e-01f, -9.62352976e-02f, -5.69002032e-02f, -2.25799927e-03f, -1.13884620e-01f, -7.75194690e-02f, -9.32697654e-02f,
  3.87026697e-01f, -2.79088706e-01f, 2.07298428e-01f, 2.44981702e-02f, -1.57922745e-01f, -1.02624573e-01f, 5.16363904e-02f, -9.74438787e-02f, 6.55625854e-03f, -5.85936867e-02f,
  -2.56638616e-01f, -4.51656431e-02f, 1.37751803e-01f, -3.26416790e-02f, 4.50306311e-02f, 8.73076450e-03f, 5.04113771e-02f, -5.98710903e-04f, 2.35950835e-02f, 9.77519974e-02f,
  2.88965274e-02f, 3.83652896e-02f, 1.57831669e-01f, 1.29470989e-01f, 2.62252297e-02f, 6.24560304e-02f, 1.87007546e-01f, 1.33943353e-02f, -1.43547757e-02f, 3.87788385e-01f,
  -1.50948808e-01f, -1.40035495e-01f, -3.34760010e-01f, -2.13604838e-01f, -3.39082628e-01f, -1.79460004e-01f, -3.55074644e-01f, -1.36409864e-01f, -7.51090497e-02f, -1.65737584e-01f,
  -1.19554996e-01f, -1.28693329e-02f, -1.02815680e-01f, 5.14987251e-03f, -1.22130625e-01f, -3.23339224e-01f, -2.87033916e-01f, -1.81398213e-01f, -7.84717277e-02f, 3.71328034e-02f,
  -9.87064689e-02f, -7.51092881e-02f, 5.25423847e-02f, 5.77780604e-02f, -9.51626822e-02f, -8.55160505e-02f, -2.46008098e-01f, -8.12007338e-02f, -1.87774241e-01f, -1.88285679e-01f,
  -2.01606929e-01f, 5.13104312e-02f, 1.88285321e-01f, 1.78765848e-01f, 8.44907165e-02f, 7.95823410e-02f, -1.47449207e-02f, -6.82423711e-02f, -4.97215353e-02f, 2.43438073e-02f,
  -2.80587785e-02f, -1.29474672e-02f, -1.22119044e-03f, 2.50230134e-02f, 2.14426219e-02f, 1.93374753e-02f, 1.28976002e-01f, 1.28676534e-01f, 9.05092061e-02f, 1.08705379e-01f,
  1.17044434e-01f, 9.13262591e-02f, 1.11974329e-01f, 1.03338547e-01f, 8.97070244e-02f, 9.92924348e-02f, 1.12600684e-01f, 1.41033188e-01f, 1.81580216e-01f, -3.04048811e-03f,
  -1.88727513e-01f, -7.85363317e-02f, 1.93116609e-02f, -1.55922882e-02f, 1.17032655e-01f, 3.67760360e-02f, -3.23990062e-02f, -2.60689557e-02f, 1.38706630e-02f, 2.25032028e-02f,
  -5.85685484e-02f, -7.50144385e-03f, 2.09750105e-02f, 2.96463501e-02f, 2.73381770e-02f, -3.30306999e-02f, -4.71983440e-02f, -6.41271332e-03f, 1.19734265e-01f, 4.86000851e-02f,
  1.39621943e-01f, 1.16040699e-01f, 6.86166668e-03f, 5.53041846e-02f, 2.23468747e-02f, -7.16148689e-03f, -7.21455961e-02f, 2.36600768e-02f, -7.38592818e-02f, -3.52709629e-02f,
  4.46738712e-02f, 1.10870458e-01f, -8.47223699e-02f, 1.37996852e-01f, -6.46248162e-02f, 1.12154953e-01f, 3.37377749e-02f, 7.83011243e-02f, -2.55896412e-02f, -1.17743552e-01f,
  3.96278538e-02f, -3.82910296e-02f, -9.70038921e-02f, 2.97223199e-02f, -3.93274240e-03f, 9.66343432e-05f, 1.54103920e-01f, -1.69396512e-02f, 7.33191296e-02f, 7.77890012e-02f,
  5.21609709e-02f, 1.34868473e-01f, 6.55475855e-02f, 6.61946982e-02f, 6.76063001e-02f, 1.25773565e-03f, -7.18175024e-02f, -3.69246234e-03f, -5.28034987e-03f, -4.55571078e-02f,
  -2.99188584e-01f, 1.74731016e-01f, 1.76941887e-01f, -1.57871783e-01f, 1.47107348e-01f, 2.72557467e-01f, 4.21590775e-01f, 6.41200319e-02f, -1.30678162e-01f, 7.66213611e-02f,
  -1.53419813e-02f, -1.15225673e-01f, -1.45907104e-01f, 3.30126211e-02f, 1.09990604e-01f, 2.49478504e-01f, 9.02696848e-02f, 3.60549390e-02f, -1.85459405e-01f, -4.18791547e-02f,
  9.51748993e-03f, -1.29454389e-01f, -1.44049332e-01f, -8.90465602e-02f, -7.32508451e-02f, -1.05143569e-01f, 3.45582478e-02f, 6.22944208e-03f, 9.27474871e-02f, 1.44834772e-01f,
  -2.58128256e-01f, -1.89492449e-01f, 3.52956131e-02f, -1.75996780e-01f, -3.72615643e-02f, -1.43337071e-01f, 2.49027852e-02f, 6.52623698e-02f, 1.18991643e-01f, 3.79171185e-02f,
  -1.32085472e-01f, 2.46201493e-02f, -1.92457158e-02f, -5.45248985e-02f, -3.71620320e-02f, -1.03003092e-01f, -9.02815908e-02f, -1.05678864e-01f, -2.02787787e-01f, -2.71013975e-02f,
  1.58542588e-01f, -7.79011995e-02f, -8.40674266e-02f, 4.40354546e-04f, 1.19222766e-02f, -1.98005885e-01f, -2.17852164e-02f, -5.71354106e-02f, 1.45800104e-02f, -1.53788373e-01f,
  -8.07435364e-02f, 6.19676858e-02f, -3.37055847e-02f, 4.22788272e-03f, -6.59007803e-02f, 8.66841748e-02f, 6.59781843e-02f, 3.36708911e-02f, -2.18397100e-02f, -1.00850128e-02f,
  6.39183745e-02f, -4.79407012e-02f, -4.70378622e-02f, 1.12975959e-03f, 5.99845499e-02f, -3.18928622e-02f, 9.10116956e-02f, -2.92746369e-02f, 6.17248453e-02f, 3.50776762e-02f,
  -1.15516327e-01f, -2.30357386e-02f, 4.93551418e-02f, -9.01674926e-02f, 1.14094011e-01f, 9.48066264e-02f, 9.19306204e-02f, -8.60546082e-02f, -2.06709988e-02f, -3.90300080e-02f,
  -1.15995504e-01f, 5.76898158e-02f, -7.39748850e-02f, -1.09109189e-02f, -4.17792760e-02f, -1.22399349e-02f, -6.05087765e-02f, -1.41821802e-01f, 8.11508894e-02f, -8.24538246e-02f,
  -3.84577997e-02f, -1.78489611e-01f, -8.26562941e-02f, -5.60115241e-02f, -1.45327032e-01f, -3.31167616e-02f, 5.31232469e-02f, 8.09443742e-02f, 4.35634255e-02f, -9.38532725e-02f,
  1.06620314e-02f, -4.29059565e-02f, -1.73530981e-01f, -9.03991088e-02f, -1.12654567e-01f, -1.82756603e-01f, -1.69176176e-01f, -1.01280339e-01f, -1.02830090e-01f, -3.52087580e-02f,
  -3.35898578e-01f, -1.87654659e-01f, 2.22057685e-01f, -3.42385978e-01f, -2.64972657e-01f, -2.43838325e-01f, -3.37215245e-01f, -1.60796002e-01f, -1.36048421e-02f, -4.49554861e-01f,
  -2.41454095e-01f, -2.10173558e-02f, 9.20761675e-02f, 2.02807769e-01f, -3.38429399e-02f, -3.74505222e-01f, -5.47617711e-02f, 1.89506397e-01f, 1.52889729e-01f, -8.58853981e-02f,
  -3.01329732e-01f, -2.29355674e-02f, 3.53380352e-01f, 2.00540900e-01f, -1.09556466e-01f, 1.50743619e-01f, 2.33144119e-01f, 1.63658366e-01f, 1.47499263e-01f, -2.04244778e-01f,
  -2.49970868e-01f, -1.44831613e-01f, 7.65874982e-02f, -1.82604231e-02f, -1.06486186e-01f, -1.30097449e-01f, -1.33050144e-01f, 1.17061839e-01f, 5.28144240e-02f, 3.25148460e-04f,
  -1.27858385e-01f, -7.99640864e-02f, -1.10487148e-01f, 8.81687403e-02f, -3.49294171e-02f, -1.88766792e-01f, 5.05131818e-02f, 6.38295859e-02f, 1.24840759e-01f, -1.52557969e-01f,
  -1.81697160e-01f, -1.17779493e-01f, 3.73865769e-04f, 2.09736958e-01f, -9.51315183e-03f, -6.87748790e-02f, 1.74089726e-02f, 7.88749903e-02f, 2.64063388e-01f, 3.51282842e-02f,
  -7.87457451e-02f, 9.58752166e-03f, -1.15948943e-02f, 1.26285540e-05f, -1.14993751e-01f, 3.55073204e-03f, 5.28592467e-02f, -9.40386280e-02f, 5.97304814e-02f, 3.08454549e-03f,
  9.95839238e-02f, -5.26902191e-02f, 2.37678853e-03f, 8.30040351e-02f, 6.08754046e-02f, 1.01116665e-01f, 6.71416596e-02f, 9.80409160e-02f, -7.87518099e-02f, 4.15289551e-02f,
  -3.00573334e-02f, 1.59130730e-02f, 6.56535337e-03f, 1.81716830e-02f, -1.01659246e-01f, -3.14357691e-03f, 1.43800238e-02f, -6.87861517e-02f, -6.19162917e-02f, 3.53121292e-03f,
  2.57314891e-02f, 3.08566630e-01f, -2.03255534e-01f, -3.06054391e-02f, -1.45008311e-01f, 1.15475886e-01f, -8.16622283e-03f, -4.84786648e-03f, -6.43370301e-02f, -1.44931838e-01f,
  -1.49461240e-01f, -1.69009119e-01f, -8.65861773e-02f, 9.14325267e-02f, -8.12750682e-02f, 3.85675812e-04f, -2.23235235e-01f, 3.28276120e-02f, 1.04273863e-01f, -7.62381703e-02f,
  -7.95860291e-02f, -1.71899021e-01f, -2.04204261e-01f, 7.47349784e-02f, -5.60766645e-02f, -1.37073681e-01f, 3.27249281e-02f, 8.18613693e-02f, 5.09292632e-02f, -8.66245776e-02f,
  -3.71901572e-01f, -1.42168343e-01f, 6.83215484e-02f, 2.65852332e-01f, 1.57281861e-01f, -1.08962007e-01f, -1.51725337e-01f, -4.03397344e-02f, 1.76986665e-01f, 1.47204101e-01f,
  8.57345983e-02f, 2.29163885e-01f, 2.12009609e-01f, 1.86863109e-01f, 1.08821578e-01f, 2.45232545e-02f, 2.60817558e-01f, 1.55185014e-01f, -9.61583667e-03f, -7.19895586e-02f,
  1.62713140e-01f, 3.11048869e-02f, 9.29915607e-02f, 5.62836304e-02f, 1.02771543e-01f, 2.50741184e-01f, 1.04297228e-01f, 1.68087915e-01f, 1.83918521e-01f, 2.27266312e-01f,
  3.51277411e-01f, 6.66208973e-04f, 1.43795997e-01f, 1.13147117e-01f, -4.13134247e-02f, -2.54194081e-01f, -2.06686314e-02f, -7.49182627e-02f, -2.62604710e-02f, -3.51111814e-02f,
  -5.27794994e-02f, -7.91348144e-02f, 2.96075549e-02f, -1.19360171e-01f, -1.63234845e-01f, -1.57303125e-01f, -8.41373056e-02f, 1.03704043e-01f, 7.68649131e-02f, -6.62407205e-02f,
  7.45833293e-02f, -1.18801687e-02f, 9.02109593e-02f, 9.02961195e-02f, -2.51259818e-03f, 1.34182930e-01f, 6.63787425e-02f, 5.25976382e-02f, -6.90610185e-02f, -1.34590670e-01f,
  7.08447769e-02f, -8.83746073e-02f, 6.47630692e-02f, 3.41209397e-02f, 8.10904056e-02f, -9.80855227e-02f, -1.32317439e-01f, -5.48979677e-02f, -5.01178578e-03f, -1.72457889e-01f,
  -8.69591236e-02f, 9.25062448e-02f, 1.37884051e-01f, -5.46271019e-02f, 6.70155697e-03f, -7.94390310e-03f, -7.53900558e-02f, 3.41675133e-02f, -5.00494093e-02f, 6.74555227e-02f,
  -3.27883214e-02f, -6.88372925e-02f, -6.06814064e-02f, -1.47782378e-02f, -5.89499660e-02f, 1.07665554e-01f, -6.02692664e-02f, 3.82784405e-03f, 2.91820988e-02f, 1.34103578e-02f,
  3.72147530e-01f, 3.09313059e-01f, -4.15203162e-02f, 9.53577459e-02f, -4.86093313e-02f, -1.14558309e-01f, 1.05112940e-02f, -3.73877101e-02f, -1.04726376e-02f, -4.12541442e-02f,
  -1.17477603e-01f, -1.09347500e-01f, -4.14901637e-02f, -5.48445173e-02f, -1.96364671e-01f, -1.82814509e-01f, 1.13625992e-02f, 9.90282595e-02f, 1.66234940e-01f, -3.61169502e-02f,
  3.59466225e-02f, -8.22988003e-02f, 4.82427329e-02f, -1.02511548e-01f, 1.14566265e-02f, 5.24862446e-02f, 6.97102165e-03f, -1.04875371e-01f, -1.27373546e-01f, -1.41530886e-01f,
  1.66973889e-01f, -1.68185428e-01f, -3.83339316e-01f, 8.65674242e-02f, -9.55653936e-02f, -1.17122538e-01f, -2.37309679e-01f, 2.12924510e-01f, 2.19135404e-01f, -5.73875941e-02f,
  5.72584309e-02f, 2.57946908e-01f, 6.11720793e-02f, 1.09685883e-01f, 9.85055640e-02f, -1.44298106e-01f, -3.10107350e-01f, -1.41671047e-01f, 8.33635628e-02f, 8.77086297e-02f,
  1.28689095e-01f, 2.07333758e-01f, 1.43123522e-01f, 8.39195997e-02f, -1.29547521e-01f, 1.09979836e-03f, -1.99751392e-01f, -1.34915635e-01f, -6.97888806e-02f, -4.02015507e-01f,
  -2.31316745e-01f, -6.95959991e-03f, -9.16942954e-02f, 3.69671509e-02f, -1.16742447e-01f, 1.30678102e-01f, 3.08901276e-02f, 9.05748457e-02f, 2.71647852e-02f, -1.95141528e-02f,
  7.70221930e-03f, 1.09273963e-01f, 9.87336934e-02f, 7.56811723e-02f, 4.75458317e-02f, -4.92353402e-02f, 1.39728459e-02f, 3.46245840e-02f, -1.15682833e-01f, -5.37187792e-02f,
  -9.54296589e-02f, -5.77667244e-02f, -6.05102852e-02f, -9.89180803e-02f, 8.49556830e-03f, -3.76832187e-02f, -2.39900034e-02f, -3.40800243e-03f, -3.98771558e-03f, -8.48063082e-02f,
  -9.92497988e-03f, -2.26778351e-03f, -1.06518671e-01f, -7.45955035e-02f, 8.39638859e-02f, -9.57657993e-02f, -7.47119784e-02f, -5.44023067e-02f, -8.36051181e-02f, 1.17353171e-01f,
  -6.52158633e-02f, 2.47654021e-02f, 5.76705951e-03f, -3.51827941e-03f, -9.16747823e-02f, 1.32219587e-02f, 1.18107880e-02f, -1.22388422e-01f, 2.22753305e-02f, -1.79718458e-03f,
  -1.22975782e-02f, -1.23786651e-01f, 4.24375609e-02f, -1.45407056e-03f, -9.25880224e-02f, 2.88588926e-02f, 1.10757753e-01f, 1.55115396e-01f, 7.53043070e-02f, 1.70459315e-01f,
  1.35039866e-01f, -3.01374849e-02f, -6.13846406e-02f, -5.86085906e-03f, -7.45852590e-02f, -1.01176538e-01f, -1.12891287e-01f, -9.71189216e-02f, -3.39511828e-03f, -3.34980302e-02f,
  -3.29417214e-02f, 3.96801829e-02f, 2.51145381e-02f, -1.20917499e-01f, -1.40369087e-02f, -2.79379319e-02f, -8.82280469e-02f, -8.49220753e-02f, -1.88243594e-02f, 6.45478815e-02f,
  -1.54486284e-01f, -3.53596769e-02f, 1.50146578e-02f, -5.14701977e-02f, -4.57694456e-02f, 6.31336346e-02f, -7.29763731e-02f, 4.31092344e-02f, 1.02523854e-02f, -1.60413887e-02f,
  -5.31379759e-01f, 8.24303739e-03f, 1.27038315e-01f, -3.30323249e-01f, 1.04782499e-01f, 1.55343205e-01f, 9.33897421e-02f, 2.63520721e-02f, -1.44593909e-01f, -9.30007845e-02f,
  -7.37455785e-02f, -2.15744823e-02f, 9.53398719e-02f, 1.70433342e-01f, 2.42570117e-02f, 3.14831659e-02f, 2.64116019e-01f, 1.40344203e-01f, -2.62557399e-02f, -4.82839718e-02f,
  1.13753550e-01f, -1.37049243e-01f, -1.51934087e-01f, 9.92083829e-03f, 5.68313822e-02f, 2.30942909e-02f, 9.88607481e-02f, 2.28987280e-02f, 1.15642712e-01f, 1.53120309e-01f,
  -2.32895032e-01f, -3.41099560e-01f, 1.76179454e-01f, -1.36076078e-01f, -4.45257649e-02f, -1.57152172e-02f, -4.43195924e-02f, -5.31847328e-02f, 9.93727520e-02f, -2.37768628e-02f,
  -8.84976685e-02f, -5.17581217e-02f, 2.31891349e-02f, 9.46691185e-02f, -8.81875679e-02f, -9.47170481e-02f, 4.86451462e-02f, 7.89909065e-02f, -1.18527465e-01f, -4.88969460e-02f,
  9.37486738e-02f, -3.26954238e-02f, -1.56954378e-01f, 6.33160844e-02f, 4.00900021e-02f, -6.36051819e-02f, -2.80619133e-02f, -3.70878205e-02f, -7.03708902e-02f, -1.72994584e-01f,
  1.27859250e-01f, -6.43050671e-02f, 7.61182159e-02f, 3.30888666e-02f, -6.27807481e-03f, -5.58928810e-02f, 1.30019680e-01f, 8.74415971e-03f, 5.45097366e-02f, -1.40597925e-01f,
  -1.03742955e-02f, -4.56523150e-02f, 6.02847412e-02f, 1.01160314e-02f, -4.57365438e-02f, 4.64103892e-02f, 5.58617041e-02f, 1.51465714e-01f, 4.87737358e-02f, 7.58585483e-02f,
  -2.52516717e-02f, 1.40946656e-02f, 2.80246162e-03f, 1.02274172e-01f, 8.98790509e-02f, 4.96586114e-02f, -5.58429398e-02f, -7.42966458e-02f, -1.70456871e-01f, -1.76157996e-01f,
  -2.59097844e-01f, 1.79268107e-01f, 1.19004808e-02f, -6.06825911e-02f, -5.70405982e-02f, 8.44851956e-02f, -1.21220574e-01f, -2.20090840e-02f, -5.43053746e-02f, -1.99011162e-01f,
  -7.61707351e-02f, -5.20260222e-02f, -6.97016791e-02f, 1.86177064e-02f, -2.38742866e-03f, -7.42889866e-02f, 6.48902683e-03f, 1.15607180e-01f, 3.71679068e-02f, -6.59222454e-02f,
  8.10998678e-02f, -3.41376364e-02f, -2.33521894e-01f, -1.08549416e-01f, -1.07904516e-01f, -8.82575214e-02f, -8.21871758e-02f, -1.61234699e-02f, -8.63159224e-02f, -1.57059282e-01f,
  -1.95112452e-01f, -3.19235682e-01f, -9.28416774e-02f, -4.20496255e-01f, -2.27085531e-01f, -1.90238431e-01f, -2.11045995e-01f, -9.39479768e-02f, -1.33046523e-01f, -2.47544572e-01f,
  -6.08486384e-02f, 2.03128979e-01f, 1.26622632e-01f, 2.78532326e-01f, 2.66555727e-01f, -2.54824877e-01f, -2.35020131e-01f, 1.98825315e-01f, 3.79522443e-01f, 3.27798247e-01f,
  4.56429049e-02f, -6.57865182e-02f, 1.31775394e-01f, 8.62659141e-02f, -3.22858959e-01f, 3.43511738e-02f, -2.32301548e-01f, -1.72300905e-01f, -1.17916517e-01f, -3.82084697e-01f,
  7.48194456e-02f, -1.97868988e-01f, 1.48604229e-01f, 3.20431702e-02f, -1.61876306e-01f, 1.02864414e-01f, -5.39572723e-03f, -1.05808772e-01f, -2.60582864e-02f, -1.00768425e-01f,
  -1.60230175e-02f, 1.05918758e-01f, -3.57118528e-03f, -6.57462552e-02f, -2.12439403e-01f, 3.19113731e-02f, -8.77642110e-02f, -1.10473521e-02f, 8.54884014e-02f, -1.78568270e-02f,
  8.64063203e-03f, 1.82583940e-03f, 9.73802209e-02f, -2.45348960e-02f, 4.56941947e-02f, 1.32076293e-02f, 4.25412804e-02f, -3.71495150e-02f, 7.15576112e-02f, -3.54676962e-01f,
  -8.92350301e-02f, -9.42302719e-02f, 1.29941609e-02f, 8.75584558e-02f, -1.28405327e-02f, -1.35222107e-01f, 8.28582719e-02f, -2.33701374e-02f, 5.68707054e-03f, -4.50936593e-02f,
  -4.65993993e-02f, -2.05620192e-02f, 4.08848673e-02f, -4.36256193e-02f, 6.01036847e-02f, -7.66308606e-02f, -5.37720174e-02f, -1.08333100e-02f, 5.93234668e-04f, -5.48716970e-02f,
  7.58547634e-02f, 4.34780028e-03f, -3.21262516e-02f, 2.99595110e-02f, -4.46892269e-02f, 4.84195165e-02f, 1.35229891e-02f, 8.54309723e-02f, -2.13336684e-02f, 5.19562513e-02f,
  8.90932232e-02f, 1.12035654e-01f, -1.44506499e-01f, 3.89016196e-02f, -5.13403341e-02f, -2.75599901e-02f, -1.32650927e-01f, -2.90335957e-02f, -2.09038854e-02f, 3.82284261e-02f,
  3.95073406e-02f, 5.89168109e-02f, -8.78192633e-02f, -2.13016402e-02f, 6.64211363e-02f, 9.27231461e-02f, 5.15063480e-02f, 6.55461103e-02f, 8.97878855e-02f, -5.52779958e-02f,
  5.63527681e-02f, -3.95249052e-04f, 1.23004973e-01f, 4.07343172e-02f, -7.66664147e-02f, 1.59769773e-01f, -1.11524379e-02f, -1.49850175e-01f, 5.58988079e-02f, -1.83086589e-01f,
  3.38074237e-01f, 1.09149851e-02f, -3.64647985e-01f, 3.19630861e-01f, -1.31072206e-02f, -1.38562948e-01f, -1.87485501e-01f, -3.78969125e-03f, 2.86264628e-01f, 1.57559767e-01f,
  7.62196071e-03f, -2.10321583e-02f, -1.16742097e-01f, -1.72474653e-01f, -4.25434083e-01f, -3.18701535e-01f, -3.53452027e-01f, -4.97908503e-01f, -4.74894971e-01f, -2.10360736e-01f,
  -1.13001438e-02f, 1.75309870e-02f, -5.48253208e-02f, -1.31025702e-01f, 9.92670655e-02f, 2.00389307e-02f, 4.19486798e-02f, 6.15744591e-02f, -1.92955390e-01f, 7.83996843e-03f,
  -2.59263366e-01f, 4.16489728e-02f, -2.97546715e-01f, -7.80829340e-02f, -1.39182299e-01f, -3.51249538e-02f, -1.03651658e-01f, -1.92513794e-01f, 5.50373048e-02f, -1.22864947e-01f,
  1.32759959e-02f, -3.85867171e-02f, -7.20340982e-02f, -2.95346584e-02f, -1.27842408e-02f, -9.40709338e-02f, 5.86918183e-02f, -1.55715764e-01f, -3.81475911e-02f, -1.88353077e-01f,
  1.06478728e-01f, -1.02417627e-02f, -2.05453604e-01f, 1.27656445e-01f, -7.39343017e-02f, -1.32539868e-01f, -5.57637364e-02f, 4.41829376e-02f, -1.19952910e-01f, 2.32903108e-01f,
  4.18123007e-02f, 1.47705004e-02f, 4.77708168e-02f, 7.06057772e-02f, 1.51702717e-01f, 3.91335301e-02f, -9.36320573e-02f, 4.73171696e-02f, -7.68358707e-02f, 5.58575280e-02f,
  4.59873937e-02f, -1.51731884e-02f, -8.34700465e-02f, 1.59767494e-02f, -3.96677591e-02f, -6.59577176e-02f, -8.55289847e-02f, -9.80580300e-02f, -4.55767065e-02f, -2.65077967e-02f,
  -6.48271069e-02f, -4.86226864e-02f, -5.49733154e-02f, 2.00862456e-02f, -9.39666182e-02f, -4.14400287e-02f, -7.07906783e-02f, -5.94120957e-02f, 4.98638526e-02f, -7.36154541e-02f,
  1.96517304e-01f, -9.00734961e-02f, -1.19006202e-01f, -1.57616585e-01f, -5.23549356e-02f, -5.89883467e-03f, -2.81352270e-02f, -1.11938164e-01f, 4.37237732e-02f, -1.00251906e-01f,
  -1.90546423e-01f, 6.19261013e-03f, 1.39630884e-01f, -6.83510676e-02f, -1.60190817e-02f, -1.35967983e-02f, -3.11122518e-02f, -9.87033453e-03f, -9.29714441e-02f, 4.40658592e-02f,
  1.51745617e-01f, -6.70200866e-03f, -1.68312329e-03f, 7.36130774e-02f, 6.69493824e-02f, -1.64268106e-01f, 4.83201537e-03f, 2.37799878e-03f, -1.15789346e-01f, 2.42350996e-01f,
  6.79183185e-01f, -1.28648430e-01f, 2.61333972e-01f, 2.14898795e-01f, 8.91620889e-02f, 1.36745527e-01f, 2.39250571e-01f, 5.48072457e-02f, 3.85112725e-02f, 5.98704554e-02f,
  1.34462388e-02f, -5.69314696e-02f, -1.18829077e-02f, -2.72329375e-02f, 1.07682772e-01f, 8.94952938e-02f, 3.08842901e-02f, 1.43565908e-01f, 2.83475935e-01f, 1.63885459e-01f,
  -1.63813829e-01f, 9.81221795e-02f, 1.35491267e-01f, 1.46589831e-01f, -1.28735274e-01f, 2.98440214e-02f, 5.08294255e-02f, -1.28617957e-01f, -1.26113340e-01f, -2.24249735e-01f,
  -1.06520377e-01f, 1.91274419e-01f, -1.11630012e-03f, -1.41694769e-01f, 5.74050099e-03f, 1.10599630e-01f, 1.18476644e-01f, -2.43380070e-02f, -5.72284460e-02f, -1.24917133e-02f,
  -1.56473979e-01f, -4.23025973e-02f, -7.81640187e-02f, 5.01385927e-02f, 1.17885368e-03f, 3.08551919e-02f, -3.00472490e-02f, 8.31966624e-02f, 5.74409869e-03f, -2.39649583e-02f,
  -1.71182901e-01f, 9.35752913e-02f, -2.68799327e-02f, 6.51439652e-02f, 7.40512311e-02f, -3.83253247e-02f, 2.13729106e-02f, 1.05354235e-01f, 1.35092482e-01f, 1.26927897e-01f,
  6.44520670e-02f, -7.23722740e-04f, 6.66779131e-02f, -5.33363149e-02f, 4.30869032e-03f, -7.20130727e-02f, 3.58060747e-02f, 2.88746729e-02f, 8.25503767e-02f, -1.44631285e-02f,
  -5.48102036e-02f, 1.83198950e-03f, 1.15204826e-01f, 1.05050476e-02f, 1.03177857e-02f, 9.01785214e-04f, -9.21811734e-04f, -5.45275435e-02f, -6.86452016e-02f, -3.23386975e-02f,
  -5.36251180e-02f, 2.50050407e-02f, 7.03716977e-03f, -2.73721330e-02f, -7.03218058e-02f, 1.22297993e-02f, -1.40924696e-02f, -4.66787256e-02f, 2.45882496e-02f, -7.92711005e-02f,
  -3.50644320e-01f, -6.47258982e-02f, -5.25775691e-03f, -1.33329898e-01f, 5.47537245e-02f, -1.53271019e-01f, -4.02297117e-02f, -8.46142787e-03f, -1.07606746e-01f, -8.54634345e-02f,
  -7.80842677e-02f, 1.13769174e-02f, -9.00799781e-02f, 3.60950865e-02f, 1.92951575e-01f, 2.90389210e-02f, -2.06918065e-02f, 5.41647151e-02f, 1.57514180e-03f, -5.49225435e-02f,
  -1.32013857e-01f, 5.48488125e-02f, 8.44503641e-02f, 1.01871639e-01f, 1.00832902e-01f, -2.46349745e-03f, -2.69130785e-02f, 4.72176187e-02f, -2.77980277e-03f, 8.61046240e-02f,
  1.33248419e-01f, -1.42939435e-02f, 1.97819322e-02f, 8.55350718e-02f, -1.60189167e-01f, -2.19703421e-01f, -3.89200747e-01f, -4.21882302e-01f, -1.79866090e-01f, 6.21866547e-02f,
  1.34089030e-02f, 2.02570334e-02f, 9.59476158e-02f, -2.33995412e-02f, -1.78569064e-01f, -1.53612614e-01f, 5.24160676e-02f, 9.68568698e-02f, -4.13777567e-02f, -8.85994360e-03f,
  8.36050063e-02f, 1.54408619e-01f, 1.20524988e-01f, 3.33517715e-02f, 9.32735205e-02f, 7.01239556e-02f, 1.72963679e-01f, 2.34182119e-01f, 1.75653964e-01f, 4.44767416e-01f,
  2.47371331e-01f, 1.33780405e-01f, -1.20048653e-02f, 1.94994882e-01f, 1.79439038e-01f, -1.39333187e-02f, -5.23930006e-02f, 6.12885170e-02f, -4.53779195e-03f, -6.36763498e-03f,
  1.37507498e-01f, 1.40866548e-01f, -2.30286475e-02f, 3.78827453e-02f, 1.39334366e-01f, 8.49861745e-03f, -8.62260535e-02f, -3.44827920e-02f, -2.13192310e-02f, -1.12044439e-01f,
  8.96118879e-02f, 2.54718363e-02f, -7.45358318e-02f, -1.79140940e-01f, -8.04926530e-02f, 1.03289858e-01f, -1.17832124e-01f, 1.36019243e-02f, 3.37099098e-02f, -1.19311623e-02f,
  -9.94638354e-02f, 9.96746346e-02f, 7.58310035e-02f, 9.52371135e-02f, 3.15008312e-02f, -1.24193383e-02f, 1.12305634e-01f, 4.72621061e-02f, 3.87708545e-02f, -8.78185704e-02f,
  -7.44433030e-02f, -4.05071639e-02f, 1.60383843e-02f, 1.32058701e-02f, 1.06764078e-01f, 1.26686484e-01f, 1.32907376e-01f, -6.55954843e-03f, -6.14785869e-03f, 4.76084128e-02f,
  -2.71577910e-02f, -2.77832244e-02f, 7.55531266e-02f, -5.16134575e-02f, 3.62732410e-02f, 7.27235079e-02f, 9.52788889e-02f, 2.58402284e-02f, 8.96858573e-02f, 1.39167681e-01f,
  4.87011559e-02f, -8.62981845e-03f, 9.07849744e-02f, 4.98728901e-02f, 9.81658176e-02f, -1.23746566e-01f, 9.20882672e-02f, 1.88320428e-02f, 5.63668087e-02f, -6.92378581e-02f,
  1.94089673e-02f, -5.47968186e-02f, -2.47475021e-02f, -7.82821402e-02f, -8.79901648e-02f, 5.84022608e-04f, 6.84617162e-02f, -2.76506823e-02f, -1.51275799e-01f, 1.12629086e-02f,
  -1.16150111e-01f, -2.96431482e-01f, -3.00694317e-01f, -2.91715950e-01f, -5.74236661e-02f, -6.14776351e-02f, -7.62573704e-02f, 2.91318521e-02f, -1.99455932e-01f, -1.09464481e-01f,
  4.11174864e-01f, -1.50265515e-01f, 1.43566951e-02f, 2.55521894e-01f, 1.51737109e-01f, -2.19314080e-02f, -6.09848239e-02f, -3.69810201e-02f, 1.87131777e-01f, 1.41920045e-01f,
  1.82621852e-01f, 3.13885033e-01f, 2.78539866e-01f, 2.63529062e-01f, 1.16647080e-01f, -1.24175893e-02f, -7.81270191e-02f, 1.16537407e-01f, 1.55933559e-01f, 1.09546095e-01f,
  1.03672840e-01f, 1.33830741e-01f, 1.00925669e-01f, 1.22794822e-01f, -2.22333912e-02f, 1.20267831e-01f, 1.08077802e-01f, -9.54951644e-02f, 7.72028044e-03f, -1.42966136e-01f,
  -3.91181298e-02f, 8.08758885e-02f, 1.20417170e-01f, 6.97764382e-02f, -9.15135741e-02f, 1.19531676e-02f, 1.56622976e-02f, -1.70336947e-01f, -5.77660128e-02f, -8.40330571e-02f,
  -9.16172117e-02f, -1.03789285e-01f, 1.59587860e-02f, -2.98574809e-02f, -8.86459202e-02f, -1.19863264e-02f, 7.26090837e-03f, -3.93256508e-02f, 3.35586397e-03f, 3.12016122e-02f,
  -5.61556295e-02f, -2.77900174e-02f, -1.23042881e-01f, 7.74665028e-02f, 6.89841360e-02f, 1.12228550e-01f, 3.65388766e-02f, -2.12303200e-03f, 8.97466019e-02f, 3.72176878e-02f,
  2.00878397e-01f, -4.22866307e-02f, -6.11379789e-03f, 1.91834643e-02f, 7.98977613e-02f, 7.40064457e-02f, -1.51216269e-01f, 3.47799547e-02f, 4.30475287e-02f, -1.09875455e-01f,
  4.08285595e-02f, -3.61929089e-02f, -5.02196653e-03f, 9.18106991e-04f, 5.06148376e-02f, -7.67120197e-02f, -5.40588349e-02f, -6.81941807e-02f, 4.61042672e-03f, 3.10046673e-02f,
  -6.19015470e-02f, -1.31479025e-01f, -1.80633254e-02f, -1.18766882e-01f, 5.77422157e-02f, 1.55792207e-01f, 3.57151367e-02f, 7.01103806e-02f, 4.68336679e-02f, -8.63613188e-02f,
  -3.40222508e-01f, 2.81854779e-01f, 9.03955400e-02f, -7.07813948e-02f, -9.56423655e-02f, -1.61290094e-02f, 6.46028891e-02f, -6.23467900e-02f, -2.42626444e-01f, -1.23542689e-01f,
  -3.93521450e-02f, -1.03522137e-01f, 9.30329785e-03f, -1.62163511e-01f, -6.26490563e-02f, -1.34510115e-01f, -7.20010977e-03f, -2.87019648e-02f, 4.66748253e-02f, -1.88087761e-01f,
  6.95821922e-03f, -1.24714658e-01f, 3.29667726e-03f, 1.68358050e-02f, -8.97399150e-03f, 6.80008233e-02f, -8.66374075e-02f, -2.39154935e-04f, -5.11412583e-02f, -6.58639893e-02f,
  -2.59402126e-01f, -2.78842449e-01f, 4.58453819e-02f, 1.07363034e-02f, 7.84794986e-02f, -1.83370173e-01f, -3.37777168e-01f, -3.44884574e-01f, 4.14815545e-02f, 1.80581771e-02f,
  6.87231123e-02f, 1.13405958e-01f, 6.18740804e-02f, -2.16207746e-02f, -3.99375737e-01f, -3.41348886e-01f, -1.07639655e-01f, -2.36878157e-01f, -6.99078068e-02f, -3.76470610e-02f,
  3.29710320e-02f, 5.68022542e-02f, 7.82545097e-03f, -2.53621433e-02f, 2.36132592e-01f, 2.52563059e-01f, 1.98525101e-01f, 2.45845556e-01f, 4.11201306e-02f, 1.19870469e-01f,
  5.92548735e-02f, 8.67609233e-02f, 6.34780303e-02f, -1.33146510e-01f, 1.20603114e-01f, -6.82872310e-02f, -6.83642924e-02f, -6.05706908e-02f, -3.42649594e-02f, -1.75563265e-02f,
  1.98751807e-01f, -5.29445261e-02f, 1.09012753e-01f, 1.24030085e-02f, -1.68429613e-01f, -1.24347337e-01f, -1.89825565e-01f, -2.06646606e-01f, -1.70982346e-01f, -7.18989819e-02f,
  -4.28208522e-03f, 4.25255299e-02f, -3.97245884e-02f, -1.06410787e-01f, -2.68706512e-02f, 7.56982267e-02f, -3.49162100e-03f, 8.58567953e-02f, 5.15354332e-03f, -1.84326340e-02f,
  2.04942022e-02f, -6.53089583e-02f, 2.00334396e-02f, 3.22639197e-02f, -8.11566412e-02f, 1.49398178e-01f, 1.44972345e-02f, 1.15513280e-01f, -4.49641794e-02f, -9.25861448e-02f,
  -8.44894275e-02f, -1.29135407e-03f, -2.32489989e-03f, -3.60243469e-02f, 2.20173374e-02f, 1.25167206e-01f, -6.77710623e-02f, -5.34532107e-02f, -1.06112808e-01f, 2.55178977e-02f,
  1.29068717e-02f, 7.46494951e-03f, 6.31038919e-02f, -6.17748313e-02f, 3.93463415e-04f, 9.58555564e-02f, 5.21065630e-02f, -2.20484398e-02f, -1.67989478e-01f, 1.09131530e-01f,
  3.27159539e-02f, 1.39245749e-01f, -1.72656700e-02f, 2.23319628e-03f, 3.89191620e-02f, 1.03955008e-02f, 2.27172613e-01f, 2.15524733e-02f, 6.32899776e-02f, -1.64505213e-01f,
  1.97766647e-02f, 4.19052839e-02f, -7.06967991e-03f, 1.36179477e-02f, -1.44466788e-01f, -5.96262366e-02f, -1.98133737e-01f, -5.53042740e-02f, -1.37053162e-01f, 5.49909137e-02f,
  -1.71736419e-01f, -9.23027322e-02f, -2.46350527e-01f, -1.89776242e-01f, -7.80040622e-02f, -1.65760264e-01f, -1.88447684e-02f, 1.44202918e-01f, -9.86403599e-02f, -3.18063587e-01f,
  1.72345936e-01f, -2.12758437e-01f, -4.07083958e-01f, 3.78166139e-01f, -4.27465588e-02f, -2.58873791e-01f, -3.36888045e-01f, 3.19843069e-02f, 2.44948521e-01f, -1.10747486e-01f,
  1.08996416e-02f, 1.00142397e-01f, -4.73066531e-02f, -9.84929651e-02f, -3.27387214e-01f, -3.56145859e-01f, -2.06924826e-01f, -2.68993974e-01f, -9.00985375e-02f, -1.34072397e-02f,
  1.96316481e-01f, 2.77579278e-02f, 6.44468442e-02f, 4.89103273e-02f, 1.63911343e-01f, 4.57461774e-02f, -1.54127315e-01f, 1.00399084e-01f, -1.96336925e-01f, -1.10118732e-01f,
  -1.70762837e-01f, -3.71579081e-02f, -2.07417041e-01f, 5.98043017e-02f, 8.90624225e-02f, -6.30400702e-02f, 7.98173025e-02f, -4.88176532e-02f, 5.74689284e-02f, 7.29033574e-02f,
  1.37483358e-01f, 1.63422346e-01f, 6.79505840e-02f, 6.65233359e-02f, 4.28611040e-02f, 1.47088396e-03f, -6.88378587e-02f, -1.49445385e-01f, -1.90427318e-01f, -1.20728835e-02f,
  1.18983157e-01f, 7.94104189e-02f, -1.07257254e-01f, -9.31832269e-02f, -1.37260333e-01f, -1.21783882e-01f, -9.47512016e-02f, -6.41327575e-02f, -4.17021841e-01f, -9.94182006e-02f,
  -1.33579308e-02f, -7.19209611e-02f, 9.13895369e-02f, -8.72793943e-02f, 3.28366905e-02f, 8.90056137e-03f, -1.06006516e-02f, 5.90203702e-02f, 1.61311686e-01f, 5.43006994e-02f,
  3.86949349e-03f, -1.19497791e-01f, -1.02828085e-01f, -2.47340538e-02f, 1.09803565e-02f, 5.52185997e-02f, 7.04407319e-02f, -4.73812819e-02f, 5.44750616e-02f, 9.71323699e-02f,
  -2.18866672e-02f, -5.70257977e-02f, 1.27566770e-01f, 4.58789878e-02f, -1.25025257e-01f, -1.24571525e-01f, 6.05166703e-02f, 1.97897553e-02f, 7.05085024e-02f, 1.47810970e-02f,
  1.74920574e-01f, -3.51801693e-01f, 1.19061820e-01f, 5.45021519e-02f, -6.89395741e-02f, 9.94281173e-02f, 1.15758494e-01f, 1.55764341e-01f, 1.27657905e-01f, 4.69054691e-02f,
  1.01392353e-02f, 8.44741464e-02f, 2.46743914e-02f, 7.79366046e-02f, 9.41994637e-02f, 1.46207782e-02f, 6.77645812e-03f, -5.12636937e-02f, -9.62281078e-02f, 2.53439873e-01f,
  1.57185778e-01f, -1.49807936e-04f, -1.33377060e-01f, -1.43177852e-01f, 5.74066155e-02f, -3.31913754e-02f, 2.54578590e-02f, 3.84862386e-02f, -3.18547219e-01f, -3.46190184e-02f,
  -2.69179821e-01f, -7.65700936e-02f, 1.91904511e-02f, -2.73466468e-01f, 2.92309821e-02f, 1.07395440e-01f, 1.16857596e-01f, 8.09639171e-02f, -8.77431184e-02f, -1.76066056e-01f,
  2.09525004e-01f, -5.60308993e-02f, -1.27975404e-01f, -8.36953372e-02f, -8.70386288e-02f, -2.49881238e-01f, -2.30681583e-01f, -1.12725765e-01f, 1.78296834e-01f, 2.84718573e-01f,
  1.72178522e-01f, 2.65059415e-02f, -1.33161747e-03f, 7.40338862e-02f, -2.54697919e-01f, -6.68395534e-02f, -1.89917371e-01f, -1.51363879e-01f, 2.67160125e-02f, -3.84351104e-01f,
  -1.67708963e-01f, 6.63966760e-02f, 6.37744963e-02f, -3.14232074e-02f, 4.42430675e-02f, 4.60811593e-02f, -4.16132323e-02f, 3.56061831e-02f, 8.83971453e-02f, -3.39337364e-02f,
  3.51088792e-02f, 8.57080445e-02f, -2.00466335e-01f, 6.49408773e-02f, 6.55075237e-02f, 5.86101487e-02f, 1.92957520e-02f, 1.38369322e-01f, 1.42569570e-02f, 1.45525334e-03f,
  -9.49783400e-02f, 3.77370566e-02f, -6.94159120e-02f, -3.91343459e-02f, 7.96299577e-02f, -2.95309327e-03f, 1.33605406e-01f, 2.20529400e-02f, 1.54727370e-01f, -1.41099289e-01f,
  2.73639206e-02f, 1.43191114e-03f, 9.21958089e-02f, -3.30716837e-04f, 1.66346803e-02f, 8.70325267e-02f, -8.62420201e-02f, 3.24736498e-02f, 1.09986112e-01f, -3.19741741e-02f,
  6.82208464e-02f, 8.16800743e-02f, 9.61633846e-02f, -2.30278075e-01f, 1.36061674e-02f, 2.38390900e-02f, -2.29820088e-02f, -6.94980174e-02f, 3.57941911e-02f, -6.33401647e-02f,
  -1.91891938e-02f, 1.03592118e-02f, 3.67941670e-02f, -1.91578865e-02f, -3.92061360e-02f, -1.43823419e-02f, 5.64715527e-02f, 1.33535326e-01f, 2.80007925e-02f, 8.69200677e-02f,
  -2.45388284e-01f, 1.22061126e-01f, -1.99724913e-01f, -1.30666634e-02f, -1.24444239e-01f, 1.89026929e-02f, -1.14481583e-01f, -6.20485134e-02f, -1.73916504e-01f, 2.12532990e-02f,
  2.27394655e-01f, 2.24735197e-02f, -9.27043334e-02f, 5.55661656e-02f, 9.46907178e-02f, 6.18810654e-02f, 1.15319137e-02f, -1.24332299e-02f, -2.28992873e-03f, 1.84368819e-01f,
  7.98134655e-02f, -4.32039574e-02f, -2.00222686e-01f, -2.20543906e-01f, -1.91693511e-02f, -5.69151901e-02f, -5.17619140e-02f, -1.06352612e-01f, -1.28968135e-01f, -2.86381900e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  2.72032291e-01f, 2.33064696e-01f, 5.20798489e-02f, 7.88266212e-02f, 2.14175165e-01f, 3.39857899e-02f, 2.47132197e-01f, 2.70715863e-01f, 1.81183144e-01f, 2.51767784e-01f,
  1.38881087e-01f, -2.00961754e-01f, 5.06291464e-02f, 2.11502075e-01f, 8.79907981e-02f, -2.29468010e-03f, 9.69483480e-02f, 4.28676307e-01f, 3.02747607e-01f, 1.30445465e-01f,
  4.98975329e-02f, 9.89111587e-02f, 9.45065692e-02f, 2.98556030e-01f, 6.18719272e-02f, 2.27640063e-01f, -6.54213503e-02f, 7.44295791e-02f, 1.77073836e-01f, 2.52161056e-01f,
  -6.86154282e-03f, 1.73990458e-01f, 1.97564960e-01f, 2.27659747e-01f, 1.64123133e-01f, 6.74043745e-02f, 1.93692669e-01f, -8.96121562e-03f, 6.55595213e-02f, 1.33558288e-01f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  2.11594418e-01f, -1.05619721e-01f, -9.66192186e-02f, -3.00175305e-02f, 1.10308698e-03f, 8.72998312e-02f, 2.78468635e-02f, -1.31138146e-01f, 1.71926375e-02f, 8.58871788e-02f,
  2.18925402e-02f, 1.22280121e-01f, -4.90506254e-02f, 4.63447906e-02f, -1.78306438e-02f, -3.64442542e-02f, 2.43839487e-01f, -7.11021945e-02f, 1.08919613e-01f, -1.06752496e-02f,
  -1.10048980e-01f, -3.16224620e-02f, -1.04268648e-01f, 1.52103826e-01f, 1.17048500e-02f, 1.90112934e-01f, 1.52298901e-02f, 1.20864801e-01f, -4.68608700e-02f, -1.72063172e-01f,
  2.74552077e-01f, -1.75994873e-01f, -9.62537900e-02f, 4.59856652e-02f, -1.85950756e-01f, -3.54220830e-02f, 1.54959962e-01f, 7.71180838e-02f, -5.75043373e-02f, -2.15059724e-02f,
  -1.61962330e-01f, 3.59333605e-02f, -2.32396182e-02f, 2.42509007e-01f, 5.58192134e-02f, -2.49280520e-02f, -1.08488455e-01f, 2.13933401e-02f, 5.03153428e-02f, 1.67873073e-02f,
  2.83141527e-03f, 2.83359587e-02f, 1.02321781e-01f, -1.79708749e-02f, -7.52693340e-02f, 2.23725121e-02f, -2.40759909e-01f, -2.99774092e-02f, 7.37644210e-02f, 4.79548126e-02f,
  -3.24174464e-02f, -1.12051800e-01f, 3.01888697e-02f, -9.73634943e-02f, 4.24465723e-02f, -1.59259558e-01f, -1.10627554e-01f, -1.71906486e-01f, 1.44994676e-01f, -2.08398644e-02f,
  2.35933885e-02f, 1.29696384e-01f, 5.43494746e-02f, 8.22877288e-02f, 6.99502826e-02f, 1.25889536e-02f, 2.44311899e-01f, -2.58433223e-02f, -2.59639412e-01f, -1.14919513e-01f,
  6.84359893e-02f, 6.44941349e-03f, -2.10197359e-01f, -7.05150738e-02f, 5.69633618e-02f, -1.19839519e-01f, -1.60538867e-01f, 1.66460961e-01f, 1.37630641e-01f, 3.74311805e-02f,
  9.08862650e-02f, 6.24276064e-02f, 7.66476393e-02f, -1.05957069e-01f, 6.84331264e-03f, -1.23268090e-01f, 1.65291905e-01f, -1.76773921e-01f, -3.38856503e-02f, 1.47956058e-01f,
  -1.20763086e-01f, -1.41833071e-03f, -3.45255286e-02f, -2.51643769e-02f, -5.74327670e-02f, 5.72077371e-02f, -6.23665862e-02f, 1.06458023e-01f, -3.34970504e-02f, 7.96218067e-02f,
  1.16045997e-01f, -6.60132840e-02f, 3.75914760e-02f, 4.58292738e-02f, -1.04287714e-01f, 7.89163336e-02f, -1.96921512e-01f, 9.44031402e-03f, -2.61951029e-01f, -9.30618718e-02f,
  -3.57814908e-01f, 1.13194235e-01f, 8.95815119e-02f, 3.45110074e-02f, -1.25581026e-01f, 1.92554414e-01f, 2.42013186e-02f, -2.56601393e-01f, -8.58081505e-02f, 2.22287904e-02f,
  9.10258666e-02f, 6.56239092e-02f, -5.51781468e-02f, 1.92624342e-03f, 8.89164396e-03f, 9.43929479e-02f, 2.59131864e-02f, -7.37887388e-03f, -1.40839757e-03f, 8.35008770e-02f,
  -1.67325765e-01f, 4.22313176e-02f, -3.80857661e-02f, 9.10442993e-02f, 1.07909674e-02f, -1.61235337e-04f, -5.65140061e-02f, 2.13913713e-03f, -7.19280094e-02f, 3.15186717e-02f,
  -9.20524076e-02f, -7.56494179e-02f, 8.63300413e-02f, -5.96060269e-02f, -1.04226783e-01f, -2.03097820e-01f, -4.93098944e-02f, 1.83123678e-01f, 5.34459464e-02f, 5.36757521e-02f,
  -3.78291346e-02f, 1.88033089e-01f, -4.59095053e-02f, 2.14167997e-01f, -3.48433018e-01f, -4.45963815e-03f, 1.69803202e-01f, -9.19224769e-02f, 9.00571048e-02f, 7.06951832e-03f,
  -4.18564230e-02f, 3.06410134e-01f, -9.25798342e-02f, -5.26706642e-03f, 8.64709094e-02f, -2.35357080e-02f, -3.42675522e-02f, 4.25923914e-02f, -5.71215041e-02f, -3.94075876e-03f,
  -8.39658901e-02f, -1.29046395e-01f, 8.83596614e-02f, -2.57866859e-01f, 8.17811489e-02f, 2.36417711e-01f, 1.22659035e-01f, -1.85551748e-01f, -3.80763635e-02f, -1.22879846e-02f,
  1.73240751e-01f, -1.26741290e-01f, 1.24885425e-01f, -1.37183115e-01f, 1.95382863e-01f, 1.06553592e-01f, 3.52866426e-02f, 1.23438358e-01f, 3.90040949e-02f, 4.25335951e-02f,
  3.97872999e-02f, 6.14481978e-02f, 4.57567684e-02f, 1.00272112e-02f, 3.48175347e-01f, -2.18832895e-01f, -1.97258905e-01f, -1.26432538e-01f, 1.84320167e-01f, 8.12691357e-03f,
  -3.43967639e-02f, 1.83684677e-01f, -2.00909842e-02f, -5.10319732e-02f, 1.57683305e-02f, -1.40168160e-01f, 4.39376347e-02f, 1.61834031e-01f, 1.24921188e-01f, 2.26519294e-02f,
  4.81708819e-04f, -1.64244309e-01f, 9.11958441e-02f, -1.44346640e-01f, 2.71058995e-02f, -2.26112753e-01f, 4.25920375e-02f, -4.55127005e-03f, 1.69643626e-01f, -4.63235788e-02f,
  -2.07454845e-01f, -3.37299742e-02f, -1.96933806e-01f, -1.66503176e-01f, 4.10464443e-02f, -4.79048193e-02f, -2.95467675e-03f, 6.07507974e-02f, -2.29509380e-02f, 1.79171935e-01f,
  1.38859162e-02f, -6.20714426e-02f, -1.10943466e-01f, 1.85315698e-01f, 2.32936472e-01f, 3.33470330e-02f, -5.58176264e-02f, 1.71331912e-01f, -4.28603701e-02f, 1.18445978e-01f,
  6.60100728e-02f, 6.32144809e-02f, 3.82671990e-02f, 1.96877256e-01f, -1.10402234e-01f, -1.49750069e-01f, -1.81367353e-01f, 2.09519267e-02f, -5.64519875e-02f, 1.23764604e-01f,
  -2.31073827e-01f, -6.21292964e-02f, -9.07391980e-02f, -1.89538553e-01f, 1.27134711e-01f, -1.93869695e-02f, -6.47235066e-02f, -5.85753433e-02f, 1.28897250e-01f, -4.75056060e-02f,
  5.30524878e-03f, 9.00974311e-03f, 7.45026022e-02f, -3.92682105e-02f, -1.83012024e-01f, -3.98039371e-02f, 5.76497801e-03f, 8.03675726e-02f, -6.54725581e-02f, 5.01236804e-02f,
  -1.09409563e-01f, -1.60880297e-01f, 1.04788661e-01f, -5.54722734e-02f, -1.78466626e-02f, -5.40323220e-02f, -1.60157189e-01f, 2.06790745e-01f, 3.82025898e-01f, -1.64773673e-01f,
  2.37876847e-01f, 3.70841995e-02f, -1.15388028e-01f, 3.99957187e-02f, 8.40372965e-02f, 2.58263331e-02f, -1.30834937e-01f, -4.25150990e-01f, 1.36139736e-01f, -1.77771345e-01f,
  1.50935903e-01f, 1.13276191e-01f, 8.17485675e-02f, 9.68825594e-02f, 1.45233735e-01f, 1.14599638e-01f, -7.75398361e-03f, -5.09546548e-02f, -3.92898083e-01f, 1.26269117e-01f,
  -3.10805943e-02f, 1.71194989e-02f, 5.94215468e-02f, 2.63510227e-01f, -7.27756545e-02f, 1.65018305e-01f, -4.73924242e-02f, 1.26599506e-01f, 1.21721558e-01f, 1.78836882e-01f,
  8.34713280e-02f, -8.09404328e-02f, 2.25993656e-02f, -2.61207998e-01f, 1.06996566e-01f, 3.51444110e-02f, 3.81559394e-02f, -9.04546976e-02f, -1.09793283e-01f, -8.37842748e-02f,
  1.36448890e-01f, 2.20594015e-02f, 2.35238984e-01f, -5.89883551e-02f, -7.33381137e-02f, -1.44095466e-01f, 5.91223910e-02f, -8.02661851e-03f, -2.07621828e-02f, -6.05632775e-02f,
  9.03349891e-02f, -5.77831343e-02f, -1.55838102e-01f, 1.17364332e-01f, -5.32431751e-02f, 2.12718815e-01f, -1.91161875e-02f, 3.78314629e-02f, 1.53549984e-01f, -7.49880001e-02f,
  -1.55717796e-02f, -2.74174631e-01f, -2.45119166e-02f, -1.01563260e-01f, -1.11161575e-01f, 5.47890812e-02f, -1.31976336e-01f, -7.17692003e-02f, -2.91923359e-02f, -2.08225563e-01f,
  9.25096869e-03f, 9.14087743e-02f, 1.59567863e-01f, 5.61266206e-02f, 8.43095928e-02f, 1.06718056e-01f, -7.94189870e-02f, 6.81840107e-02f, -1.16523243e-01f, 5.53835481e-02f,
  -2.02264026e-01f, 2.23453447e-01f, -9.73175541e-02f, -8.77575725e-02f, -1.50405481e-01f, 2.19774917e-02f, -2.37546548e-01f, -6.83457404e-02f, 1.43302783e-01f, 2.94982543e-04f,
  -9.64723304e-02f, -1.37689993e-01f, -3.53941917e-02f, -1.62289962e-01f, 6.50004596e-02f, 2.29265541e-02f, 5.63077722e-03f, 3.59082520e-02f, -9.01051536e-02f, 3.23455036e-02f,
  2.84370352e-02f, 7.83806220e-02f, 9.50425714e-02f, 6.75120279e-02f, 1.19049989e-01f, 1.24168873e-01f, -1.76995561e-01f, -1.31607533e-01f, 8.82817358e-02f, -7.30407238e-02f,
  1.37873739e-03f, -1.07418559e-01f, 1.93241000e-01f, 2.82193217e-02f, -1.52003109e-01f, -1.86679065e-02f, 1.38702512e-01f, -2.01376244e-01f, 9.17842761e-02f, 1.67823046e-01f,
  1.18235953e-01f, -1.83006451e-02f, -1.19709872e-01f, 2.18819186e-01f, 8.26685578e-02f, 3.27364773e-01f, -1.51725605e-01f, 2.16953546e-01f, -1.84528157e-01f, 5.28827980e-02f,
  -2.79171884e-01f, 2.31823519e-01f, 3.99949849e-02f, -1.36316195e-01f, 1.06854476e-01f, -1.47314668e-01f, -1.27444848e-01f, -1.59182638e-01f, 1.08359326e-02f, -1.02127844e-03f,
  2.98689216e-01f, 1.22675344e-01f, -2.75850315e-02f, -6.20057769e-02f, -3.78642580e-03f, -1.98220894e-01f, -1.48691744e-01f, -2.81642750e-02f, 1.06324807e-01f, -2.19556704e-01f,
  -1.22593984e-01f, 1.86283067e-01f, 1.78446546e-01f, -1.13026664e-01f, -7.85989687e-02f, -2.08181843e-01f, 2.12061089e-02f, -1.71427727e-01f, -1.00584656e-01f, 9.35891494e-02f,
  -7.78002143e-02f, 1.00990847e-01f, -5.33700138e-02f, -7.47129619e-02f, 3.10718697e-02f, 5.16531505e-02f, 3.60863172e-02f, 3.35810520e-02f, -9.40502286e-02f, 1.16516359e-01f,
  -7.49489889e-02f, 5.11595383e-02f, 3.59350033e-02f, 1.42088518e-01f, -1.11651607e-01f, -7.22438693e-02f, 4.62127887e-02f, 2.84295585e-02f, 1.31219238e-01f, -6.88334554e-02f,
  -2.71349829e-02f, -4.38219793e-02f, 9.23060700e-02f, -2.05039039e-01f, -1.68581560e-01f, -1.72985584e-01f, 7.31834248e-02f, 2.01277047e-01f, -1.53278992e-01f, 3.87171097e-02f,
  1.80424412e-03f, 1.06612071e-01f, 1.74170166e-01f, 1.94151640e-01f, -1.75453886e-01f, -1.55748412e-01f, 1.06019743e-01f, 4.50183600e-02f, -1.77356172e-02f, 1.09466966e-02f,
  -5.38064688e-02f, 1.06069207e-01f, -1.33981347e-01f, -1.55452177e-01f, 5.91517054e-02f, -4.62273834e-04f, -1.28470242e-01f, 9.65005159e-02f, 4.45107594e-02f, -7.64369220e-02f,
  -2.86164768e-02f, -3.82570596e-03f, 1.58971071e-01f, -2.59953052e-01f, 1.33033186e-01f, -4.61316817e-02f, 1.04011215e-01f, -2.57842124e-01f, -5.00878766e-02f, 3.55374403e-02f,
  -3.48238694e-03f, 7.50329569e-02f, -1.58263072e-01f, 9.18181911e-02f, 4.78917174e-02f, 2.05286816e-01f, 1.28608942e-01f, 1.04751684e-01f, -9.50784758e-02f, -5.35484329e-02f,
  -5.91889992e-02f, -1.66210253e-02f, 1.20982647e-01f, -9.38155800e-02f, -1.45777851e-01f, 1.40809417e-01f, 2.84301229e-02f, 1.39455840e-01f, -3.55326235e-02f, -2.39970610e-02f,
  9.09344479e-02f, 2.07177503e-03f, 2.76411194e-02f, 4.93523329e-02f, 1.73676237e-01f, -1.74612284e-01f, -1.19676307e-01f, -1.03652604e-01f, -1.48458913e-01f, -9.17152464e-02f,
  1.31341830e-01f, 1.91725999e-01f, -1.33512765e-01f, 2.04070464e-01f, 1.20256297e-01f, -1.09125592e-01f, 8.40138346e-02f, -1.41743049e-01f, 7.13450834e-02f, -1.45683587e-01f,
  1.00125775e-01f, 1.49305671e-01f, 4.80703376e-02f, -5.92485107e-02f, 1.68401137e-01f, -3.20884854e-01f, 6.71577305e-02f, -5.52230850e-02f, 2.64674588e-03f, 7.92952925e-02f,
  -7.18000985e-04f, -1.54787019e-01f, 5.47625162e-02f, -6.58161705e-03f, 4.41045582e-01f, 7.04879314e-02f, 3.72549566e-03f, 6.40824065e-02f, 2.79403657e-01f, -2.21458718e-01f,
  -1.15023769e-01f, -9.39023308e-03f, 5.86646572e-02f, -4.02512737e-02f, -8.94555226e-02f, 8.58270004e-02f, 6.35765074e-03f, 8.36269185e-02f, -6.39510229e-02f, -3.98962498e-02f,
  1.53079957e-01f, -2.70186067e-02f, 1.67290196e-01f, -7.01485276e-02f, 7.36895204e-02f, 5.94332069e-02f, 1.18892193e-02f, 2.18192693e-02f, 1.68393571e-02f, -3.03931665e-02f,
  2.13964190e-02f, -2.10695624e-01f, -4.40198667e-02f, 6.38180748e-02f, -1.30879939e-01f, -1.07931845e-01f, 5.77716418e-02f, -1.19195946e-01f, -7.25527108e-03f, 5.58878034e-02f,
  -7.08612129e-02f, 1.53750330e-01f, 5.49993664e-02f, 3.51850837e-02f, 2.26940230e-01f, -1.60086006e-01f, 2.17031427e-02f, -1.52219579e-01f, 5.30868322e-02f, -1.96951941e-01f,
  -8.04931000e-02f, -2.65220879e-03f, 2.13313311e-01f, 6.00302080e-03f, -8.50458816e-02f, -1.40949450e-02f, -1.75974637e-01f, 1.08995296e-01f, -2.47240271e-02f, 4.73551303e-02f,
  2.25113649e-02f, 1.39128506e-01f, 9.02150124e-02f, 1.00205265e-01f, 1.59177974e-01f, -5.47432043e-02f, -3.10230302e-03f, 9.16922167e-02f, -2.06833884e-01f, 1.38216928e-01f,
  -1.41289502e-01f, -4.40738201e-02f, -1.71457723e-01f, 4.22910899e-02f, 1.80157527e-01f, 1.27994910e-01f, 8.97834525e-02f, -5.90133145e-02f, -1.32526651e-01f, -6.46148920e-02f,
  -7.58187771e-02f, -5.65655082e-02f, -3.47066149e-02f, 1.87173218e-03f, -1.16796002e-01f, -5.54002821e-02f, 6.89857230e-02f, -1.10149451e-01f, -3.04644499e-02f, 7.83546269e-02f,
  2.60719052e-03f, -1.90400146e-02f, 4.93203551e-02f, 3.41362357e-02f, 1.49308935e-01f, 5.57037741e-02f, 4.62159626e-02f, -1.49047002e-02f, -1.32853329e-01f, 1.65636577e-02f,
  -8.77768323e-02f, 1.57655105e-01f, 4.91822660e-02f, -1.74765438e-02f, -9.15362760e-02f, -1.02029011e-01f, -5.21804132e-02f, 3.75613160e-02f, -1.05448574e-01f, 3.20516378e-02f,
  1.82322845e-01f, 9.64668207e-03f, 4.92242761e-02f, -1.42067239e-01f, 8.05295333e-02f, -1.98300257e-01f, 1.40270129e-01f, -8.17356110e-02f, -1.83393657e-02f, -1.36085510e-01f,
  1.11540556e-01f, -6.56802068e-03f, -9.19347182e-02f, 3.28183100e-02f, 1.24972232e-01f, -3.59336361e-02f, -2.84372363e-02f, -2.53303740e-02f, 1.48968741e-01f, 1.63284894e-02f,
  1.23843193e-01f, -8.13774914e-02f, 1.27575502e-01f, -1.66574031e-01f, 1.43240333e-01f, 5.39178625e-02f, 1.49784893e-01f, -8.88426527e-02f, -1.91662639e-01f, 6.08776510e-03f,
  -8.86695087e-02f, 7.28043541e-02f, 1.69134274e-01f, 1.81431510e-02f, 3.30846533e-02f, -1.37579992e-01f, -2.42231712e-02f, 6.17893711e-02f, -4.17615883e-02f, -9.19755399e-02f,
  -1.80299044e-01f, 8.29830617e-02f, -8.10659900e-02f, -3.64552513e-02f, -1.84645161e-01f, 6.71436787e-02f, -6.17158227e-02f, 1.26942337e-01f, 2.12819092e-02f, 6.03299122e-03f,
  -8.08868557e-02f, 2.98594888e-02f, 6.72293231e-02f, 1.36095315e-01f, 5.86874690e-03f, 1.13425016e-01f, 3.61587144e-02f, 1.71785846e-01f, -9.51036364e-02f, -2.22859845e-01f,
  -2.50024378e-01f, 6.39380366e-02f, 1.27449572e-01f, -2.39824131e-02f, -5.14089093e-02f, -1.56808421e-01f, 2.65490294e-01f, -6.99706003e-02f, 2.05313087e-01f, 3.52521166e-02f,
  2.71654695e-01f, 1.20507360e-01f, 4.21543568e-02f, 1.52092546e-01f, 3.47475037e-02f, -1.31728292e-01f, -1.05583884e-01f, -8.82110521e-02f, 1.44339129e-01f, -2.50367731e-01f,
  -9.15392563e-02f, -1.68412000e-01f, 1.53084308e-01f, -2.37803310e-01f, 1.43424287e-01f, 6.78953156e-02f, 1.67740643e-01f, 4.19219472e-02f, 8.36916864e-02f, 2.03325525e-01f,
  7.63758691e-03f, -1.16512030e-01f, -1.23447642e-01f, 2.67887469e-02f, 7.51609430e-02f, 4.06320132e-02f, -9.68257561e-02f, 1.89717323e-01f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -4.53334749e-02f, 8.70896801e-02f, -1.65655985e-02f, 8.24911967e-02f, 2.19167754e-01f, 5.28618470e-02f, 5.17281182e-02f, -9.37277898e-02f, 1.90879837e-01f, 9.40033942e-02f,
  1.69243291e-01f, 1.09862406e-02f, -6.82904497e-02f, 1.74528539e-01f, 1.46503076e-01f, -6.43609911e-02f, -2.64650173e-02f, 1.61032170e-01f, -7.44456723e-02f, 1.57969147e-01f,
  -4.53344434e-02f, 1.31797306e-02f, 1.60226211e-01f, 1.91592559e-01f, -1.80761721e-02f, -2.36496210e-01f, -1.74580768e-01f, 1.71883464e-01f, 1.36718556e-01f, 8.70331451e-02f,
  4.64717448e-02f, 4.96458262e-02f, 3.01134318e-01f, 2.96494178e-03f, 2.14853048e-01f, -2.45110005e-01f, 3.13250452e-01f, -2.67309844e-01f, 7.58517534e-02f, 2.06521586e-01f,
  7.19893584e-03f, -8.41299966e-02f, 1.78900018e-01f, -1.82678521e-01f, 1.74938798e-01f, 5.43922670e-02f, -1.84778795e-01f, -7.47410879e-02f, 1.73175380e-01f, -2.47369468e-01f,
  1.38023794e-01f, 2.50833482e-01f, 6.86277002e-02f, 3.93990166e-02f, 7.21118078e-02f, 4.00273055e-01f, 2.50036180e-01f, -7.00745285e-02f, -1.42504694e-02f, -6.56813458e-02f,
  6.30410854e-03f, 1.37281016e-01f, 7.46550187e-02f, 3.54092240e-01f, -7.31574744e-03f, 2.37584949e-01f, 1.48663118e-01f, 8.87239426e-02f, 1.04744032e-01f, 2.85599772e-02f,
  1.01566926e-01f, 1.34183958e-01f, 7.13963583e-02f, 1.18645117e-01f, 6.98402002e-02f, 1.49941176e-01f, -2.90950298e-01f, -1.10049322e-02f, -1.01443112e-01f, 5.94988093e-03f,
  -2.01207444e-01f, 4.50969078e-02f, 2.22901404e-01f, 1.24225177e-01f, 6.02147840e-02f, 2.40177177e-02f, 1.92019448e-01f, -1.32071480e-01f, -5.80306947e-02f, 6.51096106e-02f,
  -2.00045675e-01f, -1.80432558e-01f, 9.20563415e-02f, 1.60598606e-01f, 7.97024816e-02f, 2.85021007e-01f, -1.44708633e-01f, 3.71971764e-02f, -3.58623043e-02f, -1.48316883e-02f,
  2.92658880e-02f, 4.51457389e-02f, 5.44211529e-02f, 2.65572190e-01f, 1.88350886e-01f, 2.34901965e-01f, -8.47282335e-02f, -2.70690590e-01f, 2.63497293e-01f, -1.65083990e-01f,
  -7.14064017e-02f, -3.13767046e-02f, 9.21786726e-02f, -1.62459612e-01f, 2.78773129e-01f, -1.30242825e-01f, 2.03886569e-01f, 5.79315536e-02f, 4.77926806e-02f, 1.06695756e-01f,
  2.69699663e-01f, -5.82638308e-02f, 2.77654640e-02f, -2.60413706e-01f, 2.28123024e-01f, -7.49086067e-02f, 1.69140294e-01f, 2.43460029e-01f, 1.82865858e-01f, 1.08837776e-01f,
  8.34120885e-02f, 1.13762710e-02f, 1.39375101e-03f, 1.11148931e-01f, 1.95270777e-01f, -5.40913418e-02f, 2.36445647e-02f, 1.37701377e-01f, 2.23230898e-01f, 1.90573052e-01f,
  -7.19471648e-02f, 1.38704136e-01f, -1.62163738e-03f, 1.17348596e-01f, -2.62513965e-01f, 5.81443356e-03f, 1.89172272e-02f, -2.10626662e-01f, 7.13403970e-02f, -7.52446502e-02f,
  -2.18568251e-01f, 6.08112756e-03f, -1.00313738e-01f, 5.78030013e-02f, -2.23204657e-01f, -2.66809583e-01f, 1.25827240e-02f, 2.10889384e-01f, 5.35126626e-02f, -3.98725010e-02f,
  4.65939343e-02f, 2.97835737e-01f, 1.43540666e-01f, -1.03912480e-01f, -2.10801780e-01f, -1.31005168e-01f, 1.24727942e-01f, 5.24178632e-02f, 1.39945984e-01f, 9.54887494e-02f,
  -1.36904776e-01f, 4.01516885e-01f, 7.92070553e-02f, -1.67385966e-01f, -5.92228211e-02f, 5.29828444e-02f, 6.02680668e-02f, 2.38763273e-01f, -1.55451238e-01f, -2.16693446e-01f,
  -2.22762078e-01f, -1.03849150e-01f, 3.33997548e-01f, -1.86293110e-01f, -5.51490001e-02f, 2.53539562e-01f, 1.08077265e-01f, 1.00610014e-02f, 1.34078652e-01f, 1.80093385e-02f,
  3.85699153e-01f, 3.36414054e-02f, -1.10816181e-01f, 2.78099060e-01f, -2.52118465e-02f, -5.47688939e-02f, 1.01161622e-01f, 7.23860636e-02f, 4.11376320e-02f, -8.68325215e-03f,
  1.13127351e-01f, 1.24094207e-02f, -2.71449294e-02f, -8.34975615e-02f, -3.08972150e-01f, -6.62227869e-02f, -8.07467848e-02f, 1.08388342e-01f, -4.64343354e-02f, -1.25189573e-01f,
  3.63820076e-01f, -1.60589680e-01f, -1.96997389e-01f, 9.38885659e-02f, 4.94610257e-02f, 3.14801373e-03f, 7.69407526e-02f, 1.70662686e-01f, 4.57682833e-02f, 8.65618289e-02f,
  9.15289745e-02f, 2.13216081e-01f, 2.92841524e-01f, 3.17012280e-01f, -3.94379109e-01f, 1.29783213e-01f, -5.65953016e-01f, -1.24804333e-01f, -1.16391718e-01f, 2.33610958e-01f,
  9.62792709e-02f, -1.04191683e-01f, 2.46281922e-01f, 1.41688660e-01f, -1.60909668e-01f, -4.36237305e-01f, -8.91941264e-02f, 4.94362675e-02f, -1.70423791e-01f, 1.08938940e-01f,
  -1.06743008e-01f, -1.21473454e-01f, 1.93695594e-02f, -2.12039679e-01f, 4.15994048e-01f, 8.17313716e-02f, 1.45759117e-02f, -1.16766497e-01f, 3.52227122e-01f, -3.23906809e-01f,
  1.84488967e-01f, -1.38999820e-01f, 1.60379693e-01f, -8.20382535e-02f, -1.32500514e-01f, 5.43210357e-02f, 1.58274114e-01f, 1.53101087e-01f, 1.74546182e-01f, 1.08374596e-01f,
  1.54386133e-01f, 2.44210437e-01f, 1.45605892e-01f, 2.71259099e-02f, 1.29565552e-01f, 3.07658035e-02f, 3.25938128e-03f, -2.75444109e-02f, -1.44438803e-01f, 1.45574167e-01f,
  -9.21846852e-02f, 5.98403700e-02f, -1.06594764e-01f, 1.37854889e-01f, 2.95387488e-02f, -7.03290403e-02f, 1.61255375e-01f, -2.29151994e-01f, -1.53481081e-01f, -6.89736530e-02f,
  3.13868672e-01f, -4.90187854e-02f, -1.89723894e-01f, 6.12155255e-03f, -1.14510499e-01f, 5.21526411e-02f, 8.95320922e-02f, -3.20509493e-01f, -2.44494185e-01f, 3.77710372e-01f,
  -3.73212546e-02f, 1.11751184e-01f, -8.13002214e-02f, -1.10024847e-01f, 1.29075617e-01f, 9.47589800e-02f, 9.15213525e-02f, 4.35412467e-01f, 5.84157482e-02f, 4.98653114e-01f,
  -1.99998379e-01f, -7.32906610e-02f, -1.08386718e-01f, -1.96219996e-01f, -2.56726146e-01f, 3.30930114e-01f, -4.92436625e-02f, -5.92339039e-03f, -2.08725139e-01f, -2.99161196e-01f,
  -5.86556969e-04f, -2.60675531e-02f, 1.46506708e-02f, 9.36825126e-02f, 5.42122358e-03f, -2.35212207e-01f, -9.95240286e-02f, -2.41469756e-01f, 1.78670257e-01f, -1.78321823e-01f,
  1.79564551e-01f, 2.62441784e-01f, 1.70231968e-01f, 1.85046151e-01f, 1.99259102e-01f, 2.43450627e-01f, -5.30656762e-02f, 1.45212710e-01f, 1.43323272e-01f, -6.56204745e-02f,
  6.95448518e-02f, 2.29144588e-01f, 2.21964896e-01f, 2.56928653e-01f, -2.39142746e-01f, 3.12378462e-02f, 4.49415371e-02f, 1.87943891e-01f, -1.54255003e-01f, 7.33586103e-02f,
  1.56669363e-01f, 1.86299123e-02f, -1.13465272e-01f, 7.38374665e-02f, 1.01085193e-01f, -3.38027805e-01f, -8.81447196e-02f, 1.39919162e-01f, 2.33433880e-02f, -4.08383422e-02f,
  -2.21486285e-01f, 6.33211136e-02f, 2.14671373e-01f, -4.46709013e-03f, 2.92557836e-01f, -2.62162447e-01f, 4.99036424e-02f, -2.32625514e-01f, 6.08633831e-02f, 1.71163753e-02f,
  -2.65257150e-01f, -2.31228955e-02f, 3.28452170e-01f, -1.18295841e-01f, 6.74173841e-03f, -6.70077512e-03f, 5.00340685e-02f, -1.88970834e-03f, 6.89311177e-02f, 1.15037367e-01f,
  1.07847087e-01f, 3.63004178e-01f, -5.68353422e-02f, 1.40035804e-02f, -2.09258601e-01f, 2.96368331e-01f, 2.10894048e-01f, -4.44430888e-01f, -1.75349824e-02f, -1.58698559e-01f,
  7.06714243e-02f, -1.73663437e-01f, -2.77075112e-01f, 1.26553968e-01f, 1.73893586e-01f, 2.37095103e-01f, 1.79169342e-01f, 1.46723958e-02f, -5.44349775e-02f, 2.17462391e-01f,
  -7.20134974e-02f, 4.06798311e-02f, 1.04966454e-01f, 2.02506483e-01f, 1.59045011e-01f, 1.23457588e-01f, 1.28633127e-01f, 7.69611374e-02f, -1.76047683e-01f, 1.29687145e-01f,
  4.34200987e-02f, 5.36870621e-02f, -8.27280153e-03f, 1.38083294e-01f, 9.40035060e-02f, -1.13527700e-01f, 2.15165868e-01f, -1.54962674e-01f, 2.42068231e-01f, -2.79209107e-01f,
  5.36659658e-02f, 8.30658525e-02f, 3.13276917e-01f, 4.06899601e-02f, -2.47774333e-01f, 1.64012194e-01f, 1.61430806e-01f, 1.19115256e-01f, 8.38315040e-02f, -6.23126477e-02f,
  -1.90363824e-01f, -3.08302436e-02f, 1.18595418e-02f, 1.33726284e-01f, -1.35104079e-02f, 2.19743252e-01f, 3.78915876e-01f, 9.24603194e-02f, -2.50012055e-02f, 5.51582798e-02f,
  3.12171075e-02f, 1.14436239e-01f, -9.35683101e-02f, 6.06804937e-02f, -8.36698040e-02f, 2.49904215e-01f, 2.37593520e-02f, 1.12324812e-01f, -6.32319823e-02f, 1.76916867e-01f,
  3.72328192e-01f, -8.21234137e-02f, 1.71864722e-02f, -1.85792789e-01f, 1.94653049e-01f, -2.46782228e-01f, -1.82808891e-01f, 4.14695553e-02f, 1.61643520e-01f, 3.11805960e-03f,
  8.03459212e-02f, 5.29598212e-03f, 3.56086120e-02f, 6.04905486e-02f, -7.33030662e-02f, 5.68403453e-02f, -1.02167599e-01f, -5.74702062e-02f, -5.33426479e-02f, 2.96770446e-02f,
  -4.99630794e-02f, -1.64524000e-02f, -1.67290971e-01f, -5.30558005e-02f, 1.86613262e-01f, -1.35893613e-01f, 2.25854367e-01f, -1.89895496e-01f, -1.82640344e-01f, -3.49583924e-01f,
  -8.97624157e-03f, 1.85057476e-01f, 5.67473657e-03f, 1.18960992e-01f, -3.78874317e-03f, -7.17122778e-02f, -5.01439571e-02f, 1.82793349e-01f, 2.41103023e-01f, -3.15950572e-01f,
  -2.08765462e-01f, 2.66471744e-01f, -4.29941267e-02f, -4.46478501e-02f, 2.34523956e-02f, -1.85327888e-01f, 4.09970805e-03f, 2.07967684e-01f, 7.62639716e-02f, 1.51963696e-01f,
  -4.58352529e-02f, 5.98469675e-01f, 5.47404513e-02f, 1.75588593e-01f, -3.42156678e-01f, 1.06267311e-01f, -3.94224137e-01f, 1.85124874e-01f, -3.51553597e-02f, -1.59200691e-02f,
  -2.87177376e-02f, -1.51230276e-01f, 2.24854231e-01f, -3.87669168e-02f, -1.06532358e-01f, -9.61353332e-02f, 1.58453286e-01f, -1.61308870e-01f, 5.29204085e-02f, -2.58029252e-01f,
  -1.45538077e-02f, -2.66457289e-01f, 2.59999633e-01f, 7.07504973e-02f, 8.63772556e-02f, -8.42297683e-04f, 2.09640220e-01f, 1.55048683e-01f, 1.25571251e-01f, 6.93571642e-02f,
  6.99085370e-02f, 1.26775548e-01f, 1.77973330e-01f, 1.32211089e-01f, 1.64079353e-01f, 2.05412153e-02f, 8.54449421e-02f, -1.72907248e-01f, 3.46222132e-01f, 4.81199473e-02f,
  1.48823741e-03f, 4.46535647e-02f, -8.30853079e-03f, -7.58412434e-03f, -1.86646543e-02f, 1.39272273e-01f, 3.48963857e-01f, 8.33531544e-02f, 1.68937132e-01f, 2.36908808e-01f,
  -1.61526650e-01f, -1.56480417e-01f, 1.46765381e-01f, 2.17638865e-01f, 2.90083081e-01f, -2.76726007e-01f, -2.22354811e-02f, -1.59487829e-01f, 1.99019164e-01f, 1.86137185e-01f,
  -2.19116852e-01f, -1.11658787e-02f, -1.24349691e-01f, -3.40106457e-01f, 6.56084493e-02f, -2.37174451e-01f, 1.79016083e-01f, 1.83011666e-02f, 2.50609607e-01f, 6.75784275e-02f,
  1.41775116e-01f, -5.23597933e-02f, 3.40274721e-02f, 1.12149574e-01f, 8.85002464e-02f, 1.18018538e-01f, -1.24928281e-01f, 1.23688765e-01f, -8.37888271e-02f, 2.58724913e-02f,
  -1.85435712e-01f, 2.32413977e-01f, -1.97199911e-01f, 2.17454836e-01f, -3.99702303e-02f, -6.72301501e-02f, -2.08344441e-02f, 2.02730104e-01f, 8.14410523e-02f, 5.33126257e-02f,
  2.44575813e-01f, 2.16655344e-01f, -1.11196870e-02f, 1.32535934e-01f, 3.16745304e-02f, 3.95447873e-02f, -5.22815064e-02f, 1.20867975e-01f, 5.05653359e-02f, 4.26804721e-02f,
  1.07624948e-01f, -5.90013452e-02f, -7.31778592e-02f, 7.35844448e-02f, 8.46856087e-02f, -1.67495131e-01f, 1.88732501e-02f, 1.18915640e-01f, 2.46310547e-01f, -2.29367971e-01f,
  5.35068475e-03f, 2.75507867e-01f, 4.85673137e-02f, 1.29961744e-01f, 4.97578718e-02f, 4.80295494e-02f, 1.21487647e-01f, 2.34030467e-02f, -3.09209853e-01f, 1.78807005e-01f,
  -1.19589336e-01f, -1.35870427e-01f, -4.23257872e-02f, 1.12383202e-01f, 4.73077297e-02f, 2.32106596e-01f, 2.08848819e-01f, 1.30979985e-01f, -2.16654718e-01f, 7.78309479e-02f,
  2.35366374e-01f, 2.29749799e-01f, -1.90931588e-01f, 1.97137609e-01f, -2.95214318e-02f, 4.99835387e-02f, 1.53688356e-01f, -1.49843395e-01f, 3.94390851e-01f, -7.88683891e-02f,
  1.83879867e-01f, 3.75436153e-03f, 1.22643463e-01f, 1.53468192e-01f, 4.32744026e-02f, -2.05176145e-01f, 2.28655353e-01f, -2.19892547e-01f, -6.08001091e-02f, -1.33126512e-01f,
  7.44528323e-02f, -1.19837239e-01f, 1.40880216e-02f, 1.41860982e-02f, 1.82394221e-01f, -4.85767052e-03f, 5.94263300e-02f, 1.66261196e-01f, 6.94329105e-03f, -2.55379200e-01f,
  1.16986036e-01f, 1.45929888e-01f, -1.39752984e-01f, 1.28824294e-01f, -2.57249046e-02f, 3.58578086e-01f, 1.27699301e-01f, 1.08527467e-01f, -1.09208100e-01f, -4.34067920e-02f,
  1.03318453e-01f, 3.49863507e-02f, -3.71167123e-01f, -1.68767512e-01f, 1.07546933e-01f, -2.74870217e-01f, -2.17312142e-01f, 1.84372112e-01f, 2.60155320e-01f, 2.66581267e-01f,
  -1.35052264e-01f, -5.36155999e-01f, 6.95130751e-02f, 1.75416142e-01f, 5.90844154e-02f, -2.70622782e-02f, 1.04159549e-01f, 7.14509690e-04f, 1.18975364e-01f, -2.39581659e-01f,
  -3.81820768e-01f, 1.26442745e-01f, 4.48578298e-01f, 1.40491426e-01f, -2.15634376e-01f, -1.85425788e-01f, -9.07880068e-02f, -1.94282588e-02f, 6.65363893e-02f, 3.21244180e-01f,
  -2.21979231e-01f, 1.71837807e-01f, -2.23461896e-01f, 1.99001759e-01f, -2.36456975e-01f, 7.66055286e-02f, 2.80052066e-01f, -5.60486436e-01f, 8.43763575e-02f, -2.60995448e-01f,
  -1.72736347e-01f, -3.15023452e-01f, -1.93318859e-01f, -3.52786124e-01f, 1.36761472e-01f, -2.56769508e-02f, 1.07775412e-01f, 2.17193171e-01f, 2.85045981e-01f, 1.82951942e-01f,
  1.64088249e-01f, -4.47232202e-02f, 3.84538695e-02f, -1.03372864e-01f, 8.65675211e-02f, 4.39396873e-03f, 1.99852005e-01f, -1.70843601e-01f, -1.31137475e-01f, -1.82891861e-01f,
  -1.56217134e-02f, -6.88061491e-02f, -8.45964774e-02f, -8.27895536e-04f, 5.89319132e-02f, 1.87421933e-01f, -1.28936142e-01f, -7.83821940e-02f, -1.78968191e-01f, 2.39441529e-01f,
  -1.55733153e-01f, 7.73290265e-03f, -1.25310078e-01f, 1.77221581e-01f, 2.80129224e-01f, -4.39286143e-01f, -2.99655795e-01f, -2.96089768e-01f, -2.32331842e-01f, 1.25865519e-01f,
  3.52859259e-01f, -1.37723938e-01f, 1.36093237e-02f, -6.87999949e-02f, -2.36225933e-01f, -3.43196839e-03f, 3.39443386e-01f, -1.46300837e-01f, -3.32713157e-01f, 1.32641256e-01f,
  -3.07940375e-02f, -2.12278888e-01f, 1.07017733e-01f, 1.44159049e-01f, 4.30816039e-02f, -5.20612784e-02f, 3.43101740e-01f, 1.83258727e-01f, -1.68836340e-01f, -1.28480373e-02f,
  9.73862484e-02f, -1.33485198e-01f, -1.96372956e-01f, 6.23032451e-02f, -1.40449122e-01f, 5.61440736e-02f, -1.92685425e-01f, 3.97013454e-03f, 3.11170761e-02f, -8.52246583e-02f,
  1.67071909e-01f, -6.86428742e-03f, 1.89938664e-01f, 2.40374152e-02f, -8.47146139e-02f, -6.79005682e-02f, 5.56427687e-02f, 1.03259711e-02f, 9.31636803e-03f, -5.90741774e-03f,
  -9.73699167e-02f, 2.36075565e-01f, -8.26598406e-02f, -2.44019721e-02f, 7.84875229e-02f, -4.98439111e-02f, -1.49683088e-01f, 8.13019834e-03f, -1.45612694e-02f, -3.44697647e-02f,
  7.74341598e-02f, 3.31823304e-02f, -8.46126750e-02f, -2.40276098e-01f, 4.08771001e-02f, 8.19068104e-02f, 1.94445923e-01f, -2.49092713e-01f, -2.37833977e-01f, -7.62596950e-02f,
  4.05215919e-01f, -2.12296844e-01f, 2.73161769e-01f, 1.08733498e-01f, -3.98928709e-02f, -9.69500542e-02f, 1.30668610e-01f, 1.54847339e-01f, -3.37810934e-01f, -2.65115410e-01f,
  2.60984212e-01f, 1.68687761e-01f, 8.76382366e-02f, -1.68913811e-01f, -1.63189262e-01f, -1.15843594e-01f, 5.21510877e-02f, -1.88418522e-01f, -7.78891444e-02f, 3.38983715e-01f,
  -2.12575972e-01f, 2.15036809e-01f, -1.83344632e-01f, 2.96442032e-01f, 3.18539105e-02f, -3.83406915e-02f, -1.49206012e-01f, -2.80519575e-01f, -8.67227092e-02f, -3.29655968e-02f,
  -2.42442459e-01f, -5.01693180e-03f, 6.23781867e-02f, 7.57865831e-02f, 2.94674411e-02f, 3.26965868e-01f, 1.87455133e-01f, 5.48912771e-02f, 3.51247311e-01f, 1.67634293e-01f,
  1.53325260e-01f, 2.34477550e-01f, 1.52466804e-01f, 2.58023113e-01f, 3.39942724e-01f, 1.22297205e-01f, -2.17976466e-01f, -6.03670776e-02f, -2.01411352e-01f, 1.05719566e-01f,
  -2.92890579e-01f, -1.28963888e-01f, -1.47863045e-01f, 7.00376779e-02f, -4.37222570e-02f, -1.62901908e-01f, -1.87055364e-01f, 2.12439165e-01f, 8.30050260e-02f, -2.29867890e-01f,
  -6.15155548e-02f, 1.61770463e-01f, -5.73321581e-02f, 1.25246450e-01f, 1.93610489e-01f, 5.21919690e-02f, -1.00193289e-03f, -5.27918190e-02f, -2.37332836e-01f, -1.09013408e-01f,
  7.20089078e-02f, 2.08848581e-01f, 6.83020195e-03f, -1.81732625e-01f, 4.85085666e-01f, 3.09535652e-01f, 1.26660600e-01f, -9.58682746e-02f, -1.28110312e-02f, 1.42353699e-01f,
  1.14661604e-01f, 3.54812235e-01f, 9.99595225e-02f, 1.67251721e-01f, 1.18692860e-01f, -1.76382214e-01f, 1.40067905e-01f, 6.86388835e-02f, 5.97597323e-02f, 3.06614369e-01f,
  -4.38656002e-01f, 8.77685845e-02f, 1.73199568e-02f, 9.49998647e-02f, 2.22339153e-01f, 1.46413952e-01f, 2.46736616e-01f, 2.23396122e-01f, 9.49850902e-02f, 6.33085817e-02f,
  5.87402172e-02f, -1.81499273e-02f, 7.06481040e-02f, 8.65881592e-02f, 1.03851400e-01f, 3.22038531e-01f, 2.13189021e-01f, 4.71485406e-02f, -3.75867225e-02f, -1.04202777e-01f,
  -2.11557616e-02f, -1.90523744e-01f, -1.20416932e-01f, -6.62598461e-02f, 9.09837037e-02f, -1.17488213e-01f, -1.31612420e-01f, -1.94917038e-01f, 7.90157020e-02f, 2.29069799e-01f,
  2.40152791e-01f, 3.38062756e-02f, 2.75128126e-01f, 3.19974832e-02f, -2.10410371e-01f, -1.86088495e-02f, 1.26015112e-01f, 1.02355838e-01f, -8.25644210e-02f, 3.33836645e-01f,
  1.28671750e-01f, -6.11047074e-02f, 1.48782432e-01f, 1.32938921e-01f, -8.47373754e-02f, -9.37734917e-02f, -7.82531947e-02f, -5.98059297e-02f, -2.60042667e-01f, 3.16907644e-01f,
  2.00242493e-02f, 3.27222019e-01f, -2.25154851e-02f, 7.38437176e-02f, -3.11522812e-01f, 2.01555073e-01f, 1.10074483e-01f, -1.96755573e-01f, -4.67662275e-01f, 7.99197927e-02f,
  4.41788100e-02f, -2.60255575e-01f, -3.81930470e-01f, 1.17061861e-01f, -4.31704856e-02f, 3.15488726e-01f, -2.29770541e-02f, -2.43450664e-02f, 2.49755800e-01f, -7.34923556e-02f,
  2.25443467e-01f, -1.35490954e-01f, 5.97162768e-02f, 1.62699819e-01f, 3.60344686e-02f, 6.34386465e-02f, 8.73540863e-02f, 4.27629873e-02f, 5.52481003e-02f, 1.87976316e-01f,
  2.46699899e-01f, 7.66532496e-02f, -1.11620761e-01f, 9.62665752e-02f, -1.85882840e-02f, -1.62297815e-01f, 2.00334750e-02f, -1.14424407e-01f, 2.15235306e-03f, -1.18376315e-01f,
  -1.59736536e-02f, -2.23533466e-01f, -3.16779613e-02f, 2.14669108e-01f, 3.13295871e-01f, 1.65666983e-01f, 4.57307734e-02f, 2.50981026e-03f, 1.45679742e-01f, -1.20249920e-01f,
  1.23048693e-01f, -1.24596089e-01f, 2.87444383e-01f, 1.36244282e-01f, -3.04497331e-02f, 3.28752622e-02f, 1.02109574e-01f, -2.34308690e-01f, 1.11452676e-01f, -2.24450633e-01f,
  -4.09503840e-02f, -5.10626137e-02f, -1.46394983e-01f, 3.29214901e-01f, -1.82043657e-01f, 1.34645760e-01f, 4.53282380e-03f, 9.14069638e-02f, -2.10138261e-01f, 1.78696990e-01f,
  -4.82145026e-02f, -4.50650752e-02f, -4.10559058e-01f, 9.37479213e-02f, 2.43495107e-02f, 1.13606542e-01f, -2.67082483e-01f, 1.04484186e-01f, -1.27335951e-01f, 1.74953550e-01f,
  -1.45798594e-01f, -3.23371775e-03f, 1.29988402e-01f, 1.08113070e-03f, -7.50366673e-02f, 5.82599863e-02f, -2.21011713e-02f, -2.19702914e-01f, 4.59331498e-02f, -1.07588388e-01f,
  1.97591782e-02f, -1.00454926e-01f, -3.60875353e-02f, 3.56765673e-03f, -1.47788674e-01f, 8.99231359e-02f, 2.16763280e-02f, 5.31924888e-02f, -1.69954881e-01f, -2.53096893e-02f,
  -4.76185232e-02f, -3.59146297e-02f, -6.00170046e-02f, 3.21363844e-02f, -5.03738113e-02f, 1.38213813e-01f, -5.51219136e-02f, 8.93047601e-02f, -4.22082096e-01f, 4.23635542e-02f,
  7.81900585e-02f, -1.79281980e-01f, 3.17545742e-01f, -1.16284922e-01f, 1.09902151e-01f, 3.91021371e-02f, 6.13192879e-02f, -2.13821530e-01f, -1.63844913e-01f, 7.54057318e-02f,
  -7.84021989e-02f, -1.25733912e-01f, -2.62091696e-01f, -7.31324628e-02f, 3.15580368e-02f, 3.71465236e-02f, -2.45480374e-01f, -2.40984425e-01f, 1.06366873e-01f, 1.64445952e-01f,
  8.51433445e-03f, 1.41702473e-01f, -5.20105474e-02f, -2.92569865e-02f, -7.05583096e-02f, 1.29328489e-01f, -6.73526227e-02f, 2.60820508e-01f, -4.84469011e-02f, 2.16510087e-01f,
  -1.37376413e-01f, 6.38751090e-02f, -1.61648858e-02f, 1.31031841e-01f, 6.16086014e-02f, -4.85106222e-02f, 1.80856675e-01f, -4.49423976e-02f, 6.29570335e-02f, 1.33588105e-01f,
  1.24700129e-01f, 1.60154194e-01f, 1.08465202e-01f, -2.11389586e-02f, -8.18136111e-02f, -7.04348832e-02f, 1.42178893e-01f, -1.34600088e-01f, 1.50280083e-02f, 1.70639362e-02f,
  -3.00878324e-02f, -1.12852879e-01f, 1.75149947e-01f, 1.04739867e-01f, -5.35094664e-02f, -9.11500752e-02f, -6.32814392e-02f, -5.98154254e-02f, 1.24445781e-02f, -1.18910305e-01f,
  -1.41739976e-02f, -1.79354101e-02f, -1.14145689e-01f, 2.14506447e-01f, 5.85918687e-02f, -2.92199850e-01f, -2.45397478e-01f, 1.69630900e-01f, 3.44109125e-02f, 1.06218472e-01f,
  4.82017882e-02f, 2.23922580e-01f, 2.30659842e-01f, 8.07707012e-02f, -2.90884048e-01f, 4.97607999e-02f, 1.18650690e-01f, 1.02893874e-01f, 1.36884555e-01f, 1.02356169e-02f,
  -1.35470912e-01f, -1.37622461e-01f, 1.40920445e-01f, -2.08641693e-01f, 5.03557175e-02f, -2.31615417e-02f, 1.96224198e-01f, 1.28764510e-01f, 2.60903478e-01f, 4.69014458e-02f,
  1.45305112e-01f, -2.23998562e-01f, 4.07865107e-01f, -1.24307573e-01f, 3.28561924e-02f, 2.96397567e-01f, 7.76687823e-03f, 1.28186643e-02f, 1.25483781e-01f, 9.52645689e-02f,
  3.03741157e-01f, 1.12161078e-01f, 2.69462377e-01f, 2.43770972e-01f, 2.01864243e-01f, 1.71328887e-01f, -3.78435217e-02f, -5.72044142e-02f, 3.12789798e-01f, 1.84470028e-01f,
  6.25381395e-02f, 6.63769469e-02f, 4.89453450e-02f, 1.87855870e-01f, 1.78536713e-01f, -1.26596242e-01f, 1.05394825e-01f, -3.27332258e-01f, -2.30280701e-02f, -3.10813129e-01f,
  1.03257254e-01f, -1.68575309e-02f, -2.73474187e-01f, -2.03791752e-01f, 9.53499079e-02f, 9.25411750e-03f, 4.73913476e-02f, 2.51598746e-01f, 2.25186393e-01f, 6.14465885e-02f,
  -2.58112371e-01f, -2.19400108e-01f, 2.48411074e-01f, 6.40309900e-02f, -2.69950122e-01f, -8.26472510e-03f, -3.16927195e-01f, -1.20799959e-01f, 5.79543076e-02f, 1.21309549e-01f,
  -2.66460069e-02f, 5.87075800e-02f, -7.86419660e-02f, -1.71652690e-01f, -1.56643480e-01f, 2.01505274e-01f, 1.04871234e-02f, 5.80247156e-02f, 1.42322451e-01f, -8.04084912e-02f,
  -2.04198286e-01f, 1.85557052e-01f, 9.09585804e-02f, -6.56823767e-03f, -2.19870824e-02f, 1.64107548e-03f, -3.30416672e-02f, -9.16374177e-02f, -2.14352697e-01f, 2.49108672e-01f,
  -6.38826713e-02f, 2.26263553e-01f, -8.25254396e-02f, 1.28095776e-01f, -1.35351364e-02f, 4.68064323e-02f, -1.79087132e-01f, -4.13720757e-02f, -1.19374469e-01f, -1.77277457e-02f,
  -8.25227797e-02f, 1.43224550e-02f, -5.20777255e-02f, 5.84274046e-02f, 1.77652270e-01f, 6.19585514e-02f, -8.55390280e-02f, -2.94793755e-01f, -4.79965061e-02f, -3.34570743e-02f,
  -1.74631596e-01f, 4.27632749e-01f, -2.17337087e-01f, -5.26955575e-02f, -9.33669060e-02f, -9.92672592e-02f, -4.55851816e-02f, 1.93040520e-01f, 1.12802476e-01f, 1.47872791e-02f,
  -2.18026176e-01f, -3.01191777e-01f, -6.55488968e-02f, -1.83249891e-01f, -8.28943476e-02f, 1.95974141e-01f, -1.54426411e-01f, 1.96324944e-01f, 2.01255128e-01f, 4.62574661e-02f,
  1.50695801e-01f, -1.34400293e-01f, -2.86017030e-01f, -6.56465301e-04f, 1.68344289e-01f, 9.64029953e-02f, 1.66627124e-01f, 1.22692272e-01f, 3.09511393e-01f, -2.48311505e-01f,
  6.10025488e-02f, -6.63806051e-02f, 8.90212506e-03f, -2.86883354e-01f, 1.62953377e-01f, 8.08355585e-02f, -2.10741665e-02f, 1.38986260e-01f, 2.77124077e-01f, -3.46594065e-01f,
  1.61643669e-01f, 1.99171022e-01f, 1.92279294e-01f, 5.44203706e-02f, -1.05118454e-01f, 4.12038788e-02f, -9.31227431e-02f, 2.25878596e-01f, 5.43294623e-02f, 3.57904017e-01f,
  2.57441252e-01f, 1.34948164e-01f, 1.97759509e-01f, -1.59280077e-01f, -1.31545784e-02f, 2.62121946e-01f, 3.09954017e-01f, -1.05089340e-02f, -6.52941409e-03f, 8.79634246e-02f,
  7.30175078e-02f, 9.46092308e-02f, -1.00295283e-01f, -9.57654193e-02f, -1.33911148e-01f, 1.33116007e-01f, 2.99833685e-01f, -1.04808412e-01f, 3.27608049e-01f, -1.98250577e-01f,
  -1.80566639e-01f, -9.41832960e-02f, -1.02970079e-01f, -2.21423820e-01f, 3.00998390e-01f, 1.40737921e-01f, 1.62322566e-01f, -5.33808209e-02f, -1.02988347e-01f, 2.49089837e-01f,
  2.50717521e-01f, 1.97679833e-01f, -1.02948211e-01f, 1.54336691e-01f, -3.09466630e-01f, -1.72816679e-01f, -1.68501958e-01f, 4.46790736e-03f, 1.74051732e-01f, -6.57291487e-02f,
  -1.24263607e-01f, -1.23739421e-01f, 2.45516822e-01f, 1.44795343e-01f, -1.17445759e-01f, 2.23394409e-01f, 2.60163575e-01f, 1.39040053e-01f, -2.59755522e-01f, 1.31136566e-01f,
  -2.16333312e-03f, 1.03334419e-01f, 1.02524877e-01f, -1.62463933e-01f, -2.54467651e-02f, -1.99193001e-01f, 2.95074075e-01f, -3.39416504e-01f, 1.49475738e-01f, -4.23585512e-02f,
  -1.65551782e-01f, -3.54809850e-01f, -2.67497897e-01f, -1.73619792e-01f, 2.31373385e-01f, 5.56860492e-02f, 7.13561699e-02f, 1.07045479e-01f, 5.25349937e-02f, 1.34065360e-01f,
  1.77000284e-01f, 7.14298487e-02f, 3.62303928e-02f, 1.85225129e-01f, 6.75252825e-02f, 1.76822096e-01f, 6.37440011e-02f, -1.79991320e-01f, -1.10129289e-01f, -1.83676690e-01f,
  -6.98927417e-02f, -1.27579749e-01f, -1.04590788e-01f, -1.20445400e-01f, 4.14146148e-02f, 1.39159922e-04f, 4.33269665e-02f, 7.85740316e-02f, -9.18121636e-02f, 1.45267859e-01f,
  2.33747140e-01f, 2.15956569e-01f, -3.61642659e-01f, 3.17514315e-02f, 2.43043736e-01f, -1.47918268e-04f, -1.93627730e-01f, 7.69669637e-02f, -1.94701567e-01f, 8.58023688e-02f,
  5.77210896e-02f, 6.45396337e-02f, -1.02973275e-01f, -2.07569644e-01f, -1.45256728e-01f, -2.59045869e-01f, 2.61512212e-02f, 2.37616133e-02f, -2.80328035e-01f, 1.81689143e-01f,
  1.04211882e-01f, 1.73336834e-01f, 1.07006982e-01f, 2.49026008e-02f, 5.14832959e-02f, -1.76500425e-01f, -1.84670046e-01f, 1.18823558e-01f, 3.62244435e-02f, -2.45452046e-01f,
  3.62384394e-02f, -9.68590286e-03f, -6.74127862e-02f, 2.61319429e-01f, 8.96975324e-02f, 1.76110908e-01f, 1.24040931e-01f, -3.85180898e-02f, 4.45299782e-02f, 2.87454519e-02f,
  2.12003857e-01f, -5.34971827e-04f, 3.60934377e-01f, 1.40503943e-01f, 8.83754045e-02f, 1.53230056e-01f, 1.18384570e-01f, 5.08949496e-02f, 8.68192762e-02f, 9.00613144e-03f,
  8.24831724e-02f, -5.61708808e-02f, -1.10890396e-01f, -1.80930510e-01f, 1.30528912e-01f, -1.22916095e-01f, -1.77742124e-01f, -2.25665122e-01f, -1.31506830e-01f, 8.67084041e-02f,
  -1.39970988e-01f, 4.48845960e-02f, -2.46741906e-01f, 2.68344820e-01f, -9.23365261e-03f, -6.27593370e-03f, -4.41492163e-02f, -1.40385062e-01f, 2.07940280e-01f, -1.77900586e-02f,
  -2.28842735e-01f, -1.83910578e-02f, -1.17457174e-01f, 1.61076523e-02f, 1.27839763e-02f, -1.52054476e-02f, -1.83468655e-01f, -7.00890869e-02f, 7.85108581e-02f, -8.11672136e-02f,
  -8.30630597e-04f, -2.90621161e-01f, 7.91403651e-02f, 1.85274646e-01f, 1.25047714e-02f, 1.43738061e-01f, 2.06969664e-01f, -1.07630407e-02f, 7.11993501e-02f, 1.85628720e-02f,
  6.91463724e-02f, 2.65589803e-01f, 1.22136451e-01f, -1.08985104e-01f, -2.13155150e-01f, 2.44097546e-01f, 3.45389508e-02f, 2.35607103e-01f, 2.65778244e-01f, 9.07796323e-02f,
  7.71830827e-02f, -2.02870384e-01f, 1.91194527e-02f, 1.43186480e-01f, 7.17246979e-02f, 1.35498196e-01f, 1.97196007e-02f, -1.37562891e-02f, 1.16736531e-01f, 1.03147171e-01f,
  1.69743136e-01f, -4.05168720e-02f, 6.49852231e-02f, 1.13108106e-01f, -5.75226732e-02f, 5.09187356e-02f, 1.12768508e-01f, -1.39839560e-01f, 5.37200943e-02f, 7.71982968e-02f,
  -1.08495228e-01f, -4.82887141e-02f, 6.22834861e-02f, -1.25278130e-01f, 2.16056302e-01f, 3.76352407e-02f, -1.12496652e-01f, -1.66408215e-02f, -1.77753359e-01f, -2.67011732e-01f,
  4.68859375e-02f, 9.08181816e-02f, 5.99476136e-02f, 1.70346022e-01f, -1.11086234e-01f, 6.58975169e-02f, 6.93731755e-02f, 1.69337213e-01f, 7.26520258e-04f, 8.28324854e-02f,
  1.98167607e-01f, 2.87331790e-01f, 9.48353931e-02f, 3.98198739e-02f, -7.25361183e-02f, 1.15375981e-01f, 1.98511019e-01f, -1.63697347e-01f, -3.23908515e-02f, -7.04128370e-02f,
  2.52334233e-02f, -7.85782039e-02f, 3.78631949e-02f, -9.49472375e-03f, 2.49375001e-01f, 8.94086957e-02f, 1.74548313e-01f, 2.20885858e-01f, 1.01850115e-01f, 2.70901322e-01f,
  3.50447968e-02f, -5.28160520e-02f, 2.56079435e-01f, 1.72057420e-01f, 2.17990950e-01f, 1.42671421e-01f, 8.01483318e-02f, 1.34611771e-01f, 1.46565408e-01f, 1.37538061e-01f,
  -1.14102848e-02f, 6.23283200e-02f, 1.84664190e-01f, 9.61234048e-02f, 8.50569904e-02f, 2.09329590e-01f, 8.45315605e-02f, 1.26123607e-01f, 1.49750173e-01f, -8.98490921e-02f,
  1.39547423e-01f, -6.38311282e-02f, -2.49939501e-01f, 1.21249869e-01f, -7.60244429e-02f, 3.82687338e-02f, 6.04007579e-02f, 1.17457069e-01f, -9.73460153e-02f, -2.70572044e-02f,
  -4.70288426e-01f, 6.26701713e-02f, -7.64973611e-02f, 1.46114558e-01f, -3.39540057e-02f, 1.65583223e-01f, 1.79574609e-01f, -2.13585868e-01f, -1.65067185e-02f, 6.12049364e-02f,
  -6.31086081e-02f, -1.43558681e-01f, 2.80464977e-01f, -9.10219923e-02f, 2.18844339e-01f, 1.39688715e-01f, 2.69562751e-01f, 1.72318310e-01f, -1.67331211e-02f, 2.96651646e-02f,
  -1.71987608e-01f, -7.16254041e-02f, -2.35080838e-01f, 2.39394575e-01f, 1.19408034e-01f, 2.39113584e-01f, -5.82537204e-02f, -2.08587721e-01f, -1.13923132e-01f, 2.69085258e-01f,
  2.32669279e-01f, -6.50875503e-03f, -9.69626456e-02f, 3.29032481e-01f, -1.56639725e-01f, 1.26864135e-01f, 2.29263470e-01f, 2.62560308e-01f, 4.20080811e-01f, 5.17082661e-02f,
  7.29942396e-02f, -4.61245105e-02f, 7.63056129e-02f, 1.35908797e-01f, 1.09262303e-01f, 1.22762971e-01f, -4.82341349e-02f, -4.17150557e-03f, 9.37834755e-02f, 8.07257071e-02f,
  1.23737328e-01f, 2.83888690e-02f, 1.79230869e-01f, -1.73958633e-02f, -2.51154125e-01f, -1.84859931e-01f, 1.80621892e-01f, 3.69428694e-02f, -3.33265454e-01f, 1.27757285e-02f,
  4.59292345e-02f, 4.72987704e-02f, -6.59294799e-02f, -1.70360774e-01f, 2.71537721e-01f, -1.11329123e-01f, 2.49455228e-01f, 3.01804692e-02f, -2.52422005e-01f, -1.13154441e-01f,
  -2.62969702e-01f, 2.49503881e-01f, 2.39029393e-01f, -4.16346908e-01f, 2.40443036e-01f, -8.92565995e-02f, -1.64778411e-01f, 1.67308286e-01f, 4.73079309e-02f, 7.01213852e-02f,
  -1.80402637e-01f, -5.02703786e-01f, 1.63203731e-01f, -9.80805680e-02f, 2.80665606e-01f, 1.97092388e-02f, 3.85189652e-01f, 9.20655653e-02f, 2.13381216e-01f, -1.11700110e-01f,
  1.19630493e-01f, 1.61485091e-01f, -9.50991958e-02f, 1.24089997e-02f, -4.49855737e-02f, 6.65622950e-02f, -3.24515030e-02f, 5.88422734e-03f, -2.08399985e-02f, -1.41648985e-02f,
  -1.46589249e-01f, -1.73454434e-02f, -1.27379224e-01f, 2.28462234e-01f, 1.40049428e-01f, 1.73849136e-01f, 1.20528601e-02f, 1.86874837e-01f, 1.29558951e-01f, 2.52341367e-02f,
  1.16165601e-01f, 1.71593085e-01f, 1.14545859e-01f, 1.11240007e-01f, 9.95893702e-02f, 8.40935111e-02f, 5.06438613e-02f, 9.93114412e-02f, 1.47215113e-01f, -8.74652341e-02f,
  -1.56815097e-01f, 2.02357005e-02f, -2.16965109e-01f, -4.77737300e-02f, -1.09146126e-01f, 5.58764152e-02f, 1.28496304e-01f, -3.84758711e-02f, -6.60207570e-02f, -2.66715810e-02f,
  -2.03070655e-01f, -1.04921676e-01f, 2.38822624e-02f, 4.89883684e-02f, 1.30359888e-01f, 1.37955561e-01f, -9.81044918e-02f, 8.15318450e-02f, 1.53056920e-01f, -6.90669939e-02f,
  -2.55480986e-02f, -1.46705955e-01f, 1.40991971e-01f, 2.79284686e-01f, 1.36001602e-01f, 1.29220665e-01f, 1.21650659e-01f, -2.35441606e-02f, 1.07853197e-01f, -2.02949151e-01f,
  -1.21854454e-01f, 4.47888337e-02f, 2.03270480e-01f, 8.04826990e-02f, 1.24076046e-01f, -3.86945531e-02f, 3.11731845e-01f, 5.37804738e-02f, 3.04841220e-01f, 1.16280146e-01f,
  -1.03069944e-02f, 2.60030270e-01f, -4.36786115e-01f, 1.07525989e-01f, -2.64979005e-02f, 1.28374204e-01f, 1.92887068e-01f, 2.09262118e-01f, 2.08907977e-01f, -8.73350427e-02f,
  1.81719467e-01f, 1.73404053e-01f, 3.14416409e-01f, 6.06986545e-02f, 3.33164334e-01f, 4.65735942e-02f, 6.08114414e-02f, 2.07877100e-01f, -2.83552296e-02f, 1.90297335e-01f,
  1.30825356e-01f, -2.19891831e-01f, 2.76575834e-02f, -1.35991797e-01f, 1.15631834e-01f, -2.12908462e-02f, 5.55556715e-02f, -1.59625143e-01f, 9.96434912e-02f, 4.84633297e-02f,
  -1.11815237e-01f, 1.53226286e-01f, -1.24821760e-01f, 3.22799772e-01f, -1.67210370e-01f, 6.77362904e-02f, 7.18178451e-02f, -1.00739136e-01f, 3.51801276e-01f, -3.06140214e-01f,
  -2.62027532e-01f, -4.61705215e-02f, -8.78259540e-02f, -1.57321766e-01f, 2.16601789e-01f, 5.54381385e-02f, -4.08223011e-02f, -1.76798124e-02f, 1.06792130e-01f, 1.10983536e-01f,
  -9.03326496e-02f, 3.57088149e-01f, -3.14985663e-02f, 5.79158626e-02f, -3.48356575e-01f, 4.70478423e-02f, 1.83208268e-02f, 3.65666837e-01f, -1.89342275e-01f, -1.19161129e-01f,
  9.07157585e-02f, 1.44178912e-01f, -8.96063820e-02f, -9.89090502e-02f, -2.42872871e-02f, 3.56727183e-01f, -2.07949042e-01f, 3.76734138e-01f, 4.70857061e-02f, 2.31199354e-01f,
  1.20088093e-01f, -1.24710470e-01f, 1.39677614e-01f, 8.46249759e-02f, 1.50758000e-02f, 2.06771612e-01f, 1.78264350e-01f, 1.69791579e-02f, 1.81483194e-01f, 1.17961936e-01f,
  1.86688796e-01f, 2.65019834e-01f, 1.81003079e-01f, 1.69447213e-01f, -4.63938229e-02f, 6.09881943e-03f, 6.54852092e-02f, -1.04880199e-01f, -4.77761663e-02f, -1.06601238e-01f,
  7.05623850e-02f, 1.58089936e-01f, -9.59631279e-02f, 8.03487375e-02f, 7.22945333e-02f, 2.38617463e-03f, -9.38187316e-02f, 6.28741682e-02f, -9.63417068e-02f, 2.92728133e-02f,
  1.13349343e-02f, 5.75616164e-03f, 1.88595593e-01f, -2.44698465e-01f, -2.61351198e-01f, 2.41434146e-02f, -2.28782758e-01f, -3.01776621e-02f, 2.81140774e-01f, -3.66961099e-02f,
  -3.99086922e-02f, 1.20633068e-02f, -2.05260906e-02f, 1.32901326e-01f, -5.71027212e-02f, 4.49649058e-02f, -6.04123585e-02f, -2.44636610e-02f, -2.48234749e-01f, 8.14939961e-02f,
  1.51464611e-01f, 7.16362968e-02f, 7.59370551e-02f, -1.08291067e-01f, 1.07784651e-01f, 1.92048207e-01f, -1.05680063e-01f, -1.99988514e-01f, -1.52417287e-01f, 2.51251996e-01f,
  -2.20434546e-01f, 2.44718805e-01f, 2.43320465e-01f, 1.60875805e-02f, 8.46003070e-02f, 1.46768698e-02f, 1.16368875e-01f, 1.43752337e-01f, 1.95417270e-01f, 3.14840488e-02f,
  4.35073674e-02f, 1.65935576e-01f, -1.15186628e-02f, 1.70011818e-01f, -1.02289625e-01f, 8.52833167e-02f, 1.37795955e-01f, 1.81068525e-01f, -1.90944076e-01f, 1.33836254e-01f,
  -9.01855305e-02f, 1.18759528e-01f, -8.11208338e-02f, -1.71788167e-02f, 1.12043448e-01f, 7.62941167e-02f, 8.70453659e-03f, -1.19907461e-01f, 1.31221905e-01f, 2.98392884e-02f,
  8.29590559e-02f, -2.72990093e-02f, 2.27299362e-01f, 3.60139459e-02f, 1.05534382e-01f, 1.90806091e-01f, -6.67646006e-02f, 3.04181516e-01f, 1.01489171e-01f, 2.68196732e-01f,
  7.84805417e-02f, 2.11518854e-02f, -8.97890255e-02f, 1.07479244e-01f, 2.02152267e-01f, 2.02898961e-02f, 2.50923634e-01f, 1.55278176e-01f, -2.46859878e-01f, -1.33152917e-01f,
  -2.80817728e-02f, 5.73924705e-02f, -8.02317541e-03f, 2.23534003e-01f, -1.37719959e-01f, -1.29980594e-01f, 1.19569875e-01f, -5.66556072e-03f, -4.08014804e-02f, 3.89895029e-02f,
  1.98175564e-01f, -2.31514089e-02f, 2.07294852e-01f, 1.14824548e-01f, 6.98620752e-02f, -1.65727977e-02f, 1.29472479e-01f, -2.25701168e-01f, 1.13427289e-01f, 4.48811762e-02f,
  -4.22242880e-02f, 2.77446896e-01f, 1.40876159e-01f, 5.00725172e-02f, -9.24880803e-02f, 2.41497114e-01f, -4.00443710e-02f, 1.38951335e-02f, 1.05109820e-02f, 1.16567023e-01f,
  9.85187292e-02f, 1.56227022e-01f, -1.01490520e-01f, 1.29109591e-01f, 1.05505720e-01f, 2.51674205e-01f, -3.44040126e-01f, -3.29800770e-02f, 1.72725611e-03f, -2.86416225e-02f,
  -9.44197699e-02f, 2.08835050e-01f, 1.75408855e-01f, -2.13667125e-01f, -1.10337667e-01f, -1.45192653e-01f, -7.79707879e-02f, -3.06361541e-02f, 1.15678407e-01f, 2.40559220e-01f,
  -5.17982095e-02f, 2.21555695e-01f, -2.66299218e-01f, 2.60301322e-01f, 3.23822675e-03f, -1.35130733e-01f, 5.81658110e-02f, 1.27165392e-01f, 1.55781150e-01f, 4.39362973e-02f,
  3.14877778e-01f, 8.45346898e-02f, -8.66295025e-02f, -1.60969466e-01f, -8.37284401e-02f, 7.52772763e-02f, 2.21066084e-02f, 6.13362342e-02f, -8.96545313e-03f, 2.28710622e-01f,
  -3.28642987e-02f, -2.33493418e-01f, 1.39045209e-01f, 9.36139822e-02f, 8.43473151e-02f, -4.22739536e-02f, 2.91519731e-01f, -7.82163590e-02f, 1.69781670e-02f, -1.94896460e-01f,
  1.30986780e-01f, -1.84877813e-01f, 3.55060324e-02f, -7.80634508e-02f, 1.93372741e-01f, 1.79845199e-01f, 1.87826872e-01f, -6.36478513e-02f, -1.04167059e-01f, 1.95707530e-01f,
  1.08552545e-01f, 2.75797695e-01f, 4.86920625e-02f, 1.28748687e-02f, 1.17224373e-01f, 1.84777707e-01f, 5.31576015e-02f, 3.67227420e-02f, -1.93826064e-01f, 6.75387755e-02f,
  -3.81591693e-02f, -1.07938603e-01f, 1.35897204e-01f, -1.14084877e-01f, -1.86885949e-02f, -4.64040264e-02f, -2.27189392e-01f, -2.64014304e-01f, 2.08354801e-01f, -8.37263390e-02f,
  2.76437253e-01f, 1.50249809e-01f, -5.07650785e-02f, 1.39824390e-01f, 5.33465762e-03f, 2.28519887e-01f, -1.75179869e-01f, 1.43983200e-01f, -4.42724712e-02f, -9.94095132e-02f,
  -3.56199592e-01f, 1.47133619e-01f, -7.18489587e-02f, -6.70462325e-02f, 6.85244426e-02f, 5.52765839e-02f, 1.55186132e-01f, 3.38569134e-01f, -1.71841785e-01f, 2.52867639e-01f,
  2.15991095e-01f, 1.34109914e-01f, -2.53913820e-01f, 3.07441264e-01f, -1.40771374e-01f, -1.41509473e-01f, -7.93387368e-02f, -3.60577591e-02f, 1.97977230e-01f, -2.06524625e-01f,
  5.53921424e-02f, -1.64960623e-02f, 9.75438952e-02f, -5.25534526e-02f, 1.72436535e-01f, -2.08982140e-01f, -1.55651167e-01f, -1.38928071e-01f, 5.50642535e-02f, 2.92782962e-01f,
  -8.60188808e-03f, 1.93094552e-01f, -8.07443187e-02f, 1.60255775e-01f, 2.40830909e-02f, 7.73382485e-02f, 1.76407963e-01f, 2.25951657e-01f, -3.68939945e-03f, 1.49753854e-01f,
  -2.61104614e-01f, -7.48402923e-02f, 1.81206718e-01f, -1.03194239e-02f, -7.56862238e-02f, 1.51743919e-01f, 3.28052826e-02f, 2.25277007e-01f, 3.74268405e-02f, -7.45110959e-02f,
  3.08045417e-01f, -7.25963637e-02f, -2.38592535e-01f, -7.65522793e-02f, -1.30369946e-01f, -9.04384628e-02f, -4.91820611e-02f, 8.35150406e-02f, 9.50658787e-03f, 2.01745734e-01f,
  -2.06407742e-03f, 3.03952485e-01f, 1.55151874e-01f, -4.90223290e-03f, 2.04722270e-01f, 4.82173562e-02f, 1.14149176e-01f, 3.00561279e-01f, 1.59465998e-01f, 9.08579901e-02f,
  -2.43818596e-01f, 1.92508753e-02f, 1.92940459e-01f, -2.14908898e-01f, -2.70522274e-02f, 1.58695996e-01f, -1.81600124e-01f, 4.63483259e-02f, 3.70478570e-01f, -1.52506679e-02f,
  8.34183916e-02f, 4.74645346e-02f, 3.05670470e-01f, 2.01603815e-01f, 1.54167414e-01f, 1.05877198e-01f, 5.83619699e-02f, -1.76564362e-02f, 2.57056475e-01f, -9.74011198e-02f,
  7.68382698e-02f, 1.08399518e-01f, 1.04944758e-01f, 4.51441109e-02f, 1.47872806e-01f, 5.09743877e-02f, 1.74988002e-01f, 7.23901242e-02f, 1.59344062e-01f, -6.66163936e-02f,
  1.59797966e-01f, 1.96764581e-02f, 2.47465279e-02f, 6.09963872e-02f, 7.87026063e-02f, -4.58473526e-02f, 9.55636427e-02f, -1.81573123e-01f, -1.78513154e-01f, -3.30558196e-02f,
  -3.18462849e-01f, -1.52918696e-01f, 3.60432006e-02f, 1.87572151e-01f, -1.42327964e-01f, -1.10766165e-01f, -1.90668583e-01f, 7.84004629e-02f, -5.08565120e-02f, -1.57504469e-01f,
  -2.30470583e-01f, -4.11600582e-02f, -3.81684117e-02f, -1.88058108e-01f, -3.26903015e-02f, -1.73139311e-02f, -4.86330390e-02f, 8.75846371e-02f, -8.12518410e-03f, -1.38216645e-01f,
  7.32700378e-02f, 6.74975365e-02f, -3.85837955e-03f, -3.05979759e-01f, 1.61565185e-01f, 1.88715801e-01f, 2.87402838e-01f, -3.01288009e-01f, 1.36498297e-02f, 3.72176133e-02f,
  3.45293611e-01f, 3.44082445e-01f, 1.63838983e-01f, -1.10364124e-01f, -7.21204728e-02f, 5.37141562e-02f, 1.47552505e-01f, -8.71916413e-02f, -8.12302530e-02f, 4.49382603e-01f,
  -2.66210735e-01f, 2.36167088e-01f, -6.11874685e-02f, 4.03876752e-01f, 2.13762254e-01f, 5.30080423e-02f, 2.49009177e-01f, -8.28040242e-02f, 2.65223294e-01f, -4.11784416e-03f,
  3.82479966e-01f, 4.76869643e-02f, 2.48720534e-02f, 2.82381475e-02f, -6.85296580e-03f, -2.54768990e-02f, -6.54828921e-02f, 2.60148421e-02f, 1.45156458e-01f, 3.81197855e-02f,
  1.45179451e-01f, -2.30475873e-01f, 3.92375886e-02f, 2.30326146e-01f, -1.19645089e-01f, 8.45161155e-02f, 1.16710760e-01f, -2.12263744e-02f, -2.01983228e-01f, 3.33046347e-01f,
  -1.18890144e-01f, 3.22435945e-01f, -8.96263719e-02f, 1.27558991e-01f, 3.15221003e-03f, -1.41333759e-01f, 2.65189826e-01f, -1.79882750e-01f, 2.37605706e-01f, -2.44169950e-01f,
  2.17840582e-01f, -2.91272789e-01f, 3.33859235e-01f, -2.01855257e-01f, -1.59402207e-01f, 8.85286368e-03f, -5.95257282e-02f, -1.34744763e-01f, -9.19971094e-02f, -4.19279486e-01f,
  1.64398655e-01f, 8.79637599e-02f, -2.88730055e-01f, 1.10542834e-01f, 1.79715738e-01f, 5.27621657e-02f, -8.62951353e-02f, 9.69738439e-02f, 1.34975659e-02f, 1.25073597e-01f,
  -1.89991325e-01f, 2.47394577e-01f, -6.57158867e-02f, 1.20803759e-01f, -1.47066876e-01f, 1.15589052e-01f, -3.48808058e-02f, 9.66234356e-02f, 1.56560019e-01f, -1.46355852e-01f,
  1.70757562e-01f, 1.73460424e-01f, 1.77072838e-01f, 9.96468589e-02f, 2.22083777e-01f, 6.95997104e-02f, 2.99964994e-01f, 1.01642907e-01f, 2.16206044e-01f, 1.34232759e-01f,
  9.53402445e-02f, 2.42402017e-01f, -3.41746509e-01f, 2.57336646e-01f, -1.68626085e-01f, 1.93570137e-01f, -2.07768828e-01f, -1.69827133e-01f, 5.18992580e-02f, -6.99555203e-02f,
  7.38708675e-02f, -4.98272255e-02f, -1.26964644e-01f, 7.34316260e-02f, 3.41504663e-01f, -2.52728254e-01f, -2.54834831e-01f, -9.56964195e-02f, 7.23742023e-02f, 1.52748033e-01f,
  -3.80732827e-02f, -6.45323992e-02f, 1.05869003e-01f, 2.83412099e-01f, -2.24866625e-02f, -9.35234800e-02f, 8.15072283e-02f, -4.91651818e-02f, 1.47700623e-01f, -9.18042734e-02f,
  1.59927338e-01f, 2.07876191e-01f, 1.61958948e-01f, 4.35968965e-01f, -4.39411588e-02f, 8.13986466e-04f, -9.65973511e-02f, 6.54991642e-02f, -2.82146007e-01f, 2.00546682e-01f,
  -1.76026538e-01f, -2.35552080e-02f, -2.66982824e-01f, -4.39154282e-02f, 3.77425365e-02f, -1.86451226e-01f, 7.49468058e-02f, 4.96544018e-02f, -4.50195372e-02f, -2.80701488e-01f,
  -2.11273544e-02f, -2.58927554e-01f, 1.20910749e-01f, -2.78315455e-01f, 4.99931797e-02f, 6.80544525e-02f, 9.93386507e-02f, 5.68345189e-02f, -2.15710187e-03f, 5.57095222e-02f,
  1.48598358e-01f, -2.90788850e-03f, 1.34437904e-01f, 4.50637937e-02f, 5.87523635e-03f, 5.83662279e-02f, -1.87228322e-02f, 1.10200793e-01f, -1.79344177e-01f, 1.90402672e-01f,
  2.15481550e-01f, -1.64879054e-01f, 1.54485479e-01f, 3.45410183e-02f, -3.43240052e-02f, 7.05466643e-02f, -6.43213242e-02f, -3.02939266e-01f, 3.53960246e-01f, -2.99979568e-01f,
  1.16505951e-01f, -4.57976237e-02f, 8.44659060e-02f, 1.07268780e-01f, -4.60908711e-01f, 3.86967123e-01f, 2.53642499e-01f, -1.22981325e-01f, 8.55534598e-02f, 1.15829734e-02f,
  -2.50553250e-01f, 3.29418659e-01f, 1.46352425e-01f, -4.89760712e-02f, -1.75173983e-01f, -1.71122253e-01f, 2.24653602e-01f, -2.81717658e-01f, 1.65506527e-01f, 4.52848747e-02f,
  3.72643471e-01f, 1.28018320e-01f, 1.92833215e-01f, -2.14774624e-01f, -1.75868705e-01f, 1.08376354e-01f, -3.19897719e-02f, 1.56828567e-01f, -2.82787383e-01f, 6.71434868e-03f,
  1.95974991e-01f, -2.81271994e-01f, -1.98281333e-02f, -1.88739896e-01f, 5.14384136e-02f, -1.86037011e-02f, -2.13813424e-01f, 1.74640268e-01f, 7.78054819e-02f, 5.80259366e-03f,
  1.03565082e-01f, -6.57735625e-03f, 2.85785049e-01f, -4.56243902e-02f, 6.45771176e-02f, 7.07189813e-02f, 4.47972864e-02f, 4.88465242e-02f, -7.94242099e-02f, -5.11178188e-02f,
  8.19387734e-02f, -5.36488518e-02f, 1.93546787e-02f, -2.28422925e-01f, 2.17175856e-02f, -1.12191945e-01f, 3.09000481e-02f, -2.57652223e-01f, -1.77850381e-01f, 2.90485304e-02f,
  8.34119767e-02f, 7.04497322e-02f, -3.70893866e-01f, 2.92194068e-01f, 1.62734866e-01f, 7.01540411e-02f, 1.63506735e-02f, 5.80127239e-02f, 3.15580666e-01f, -1.48415333e-02f,
  -5.72819054e-01f, -4.27719533e-01f, -4.69231069e-01f, 1.31196603e-01f, 2.00470462e-02f, 1.51045248e-02f, -1.14291638e-01f, -8.06258768e-02f, -7.25271180e-02f, -1.51722543e-02f,
  -1.33368492e-01f, -7.51956403e-02f, -2.14494988e-01f, 2.10599542e-01f, -2.28730440e-01f, -3.89045179e-02f, -1.65348172e-01f, -5.98803572e-02f, 1.59326196e-01f, -1.05825275e-01f,
  2.54883051e-01f, -3.92634049e-02f, -1.97122782e-01f, 1.58803407e-02f, -8.99386331e-02f, -2.91789532e-01f, 2.60940306e-02f, -7.31472820e-02f, -3.36059257e-02f, -2.60503024e-01f,
  -4.02860433e-01f, -1.92846462e-01f, 2.34902054e-01f, -4.20800149e-02f, 2.00528037e-02f, 4.09568660e-02f, 4.69908975e-02f, -4.38695103e-02f, -2.09978186e-02f, 5.66068366e-02f,
  -1.23249263e-01f, -1.58424079e-01f, -8.19963496e-03f, -7.09512308e-02f, 2.34178185e-01f, 1.23044632e-01f, -9.07504261e-02f, -2.98366576e-01f, 2.63380557e-01f, 2.91790790e-03f,
  1.36576337e-03f, 3.55187245e-02f, -4.73622866e-02f, -1.95267096e-01f, -4.16601896e-01f, 2.86644429e-01f, -3.62590909e-01f, 2.11980805e-01f, 1.64780527e-01f, 9.29046944e-02f,
  1.08256288e-01f, -2.13311881e-01f, 1.55830175e-01f, -2.48625562e-01f, 1.26316085e-01f, -5.15128136e-01f, 7.01937899e-02f, -6.28172383e-02f, 2.63881683e-02f, -1.26671746e-01f,
  -2.99781263e-01f, -2.16084465e-01f, -4.40616794e-02f, 1.14430912e-01f, -1.30259633e-01f, 5.23210550e-03f, -4.24299538e-01f, 5.20155542e-02f, -3.14267844e-01f, 1.93887413e-01f,
  -3.36123079e-01f, 1.37547061e-01f, -2.43193686e-01f, 2.88682222e-01f, -2.16168687e-01f, 6.77521750e-02f, -3.82157952e-01f, 3.25987250e-01f, -3.95032912e-01f, -2.92259812e-01f,
  -1.17334634e-01f, -2.79944520e-02f, -1.63072031e-02f, -1.58290595e-01f, -2.65627861e-01f, -3.21059406e-01f, 2.29258835e-02f, 2.10974023e-01f, 1.66943058e-01f, 8.25358480e-02f,
  3.03704202e-01f, 2.60451511e-02f, -6.13050200e-02f, 1.04689568e-01f, -2.22874675e-02f, 5.01817353e-02f, 1.30092397e-01f, 1.11975223e-01f, -1.05207212e-01f, -2.02002693e-02f,
  2.71102548e-01f, -4.34520235e-03f, -1.08175976e-02f, 7.22121149e-02f, 6.34401590e-02f, 1.04112029e-01f, 5.90049699e-02f, 1.15413576e-01f, 2.39426315e-01f, 1.05662830e-01f,
  -2.22394422e-01f, -2.68840808e-02f, -1.04208753e-01f, 1.06974386e-01f, 1.81806624e-01f, 1.83293626e-01f, 2.45428141e-02f, 1.86570749e-01f, -5.26701920e-02f, 1.20638005e-01f,
  -2.01147571e-01f, -1.15790561e-01f, 2.32165977e-01f, -2.12915614e-03f, 1.19562596e-01f, -1.07703179e-01f, 2.10651830e-01f, 9.42916125e-02f, -9.92233306e-02f, -3.28706861e-01f,
  -1.57618895e-01f, -7.91586190e-02f, -2.05739409e-01f, 1.19285233e-01f, 4.20165211e-02f, -2.13018134e-01f, 5.57021461e-02f, 5.96983694e-02f, 4.23276067e-01f, 3.55148539e-02f,
  -1.34478316e-01f, 3.27113777e-01f, 2.14978635e-01f, -3.49161357e-01f, 6.59692883e-02f, -7.33649824e-03f, 2.63390601e-01f, -1.58874378e-01f, -2.14289919e-01f, -5.03754206e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  4.03446965e-02f, 2.07711428e-01f, 5.54021634e-02f, -4.69999127e-02f, 1.05794042e-01f, 1.09500840e-01f, 5.31686135e-02f, 2.15785563e-01f, 6.23171292e-02f, 1.47143230e-01f,
  1.11470707e-01f, 2.25454569e-01f, -5.07190041e-02f, 2.14315504e-01f, 1.82815000e-01f, 6.86605647e-02f, -9.18344930e-02f, 1.53873013e-02f, 7.33431503e-02f, 6.57083690e-02f,
  2.40022376e-01f, 2.63586611e-01f, 2.94010550e-01f, -1.33710966e-01f, 1.70384094e-01f, 8.32523182e-02f, 1.51394278e-01f, 2.49213547e-01f, -1.31647987e-02f, 5.57817635e-04f,
  -8.95494316e-03f, 2.13860691e-01f, -7.23495856e-02f, 1.05671003e-01f, 1.85267493e-01f, 1.31703243e-01f, 3.01789716e-02f, -3.31254974e-02f, 4.11908329e-02f, 1.24826349e-01f
};

// L2_fan_Wp (Shape: 12 x 64)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  3.24817181e-01f, -8.37348867e-03f, -4.15182531e-01f, 2.78354615e-01f, 1.68663263e-01f, 8.30257162e-02f, 1.45638380e-02f, -2.29365245e-01f, 1.10173248e-01f, 1.71198174e-01f,
  -4.17799540e-02f, 1.61767155e-01f, 2.55600195e-02f, 2.46460736e-03f, 3.96654829e-02f, -2.26324499e-01f, 8.95898715e-02f, 1.37698188e-01f, 2.14973956e-01f, 1.72638372e-01f,
  -3.07173461e-01f, -1.21930160e-01f, -1.08811855e-01f, 1.32789105e-01f, -1.53777644e-01f, 1.22175865e-01f, 1.37395278e-01f, 4.10125889e-02f, -3.55359502e-02f, -1.79723114e-01f,
  1.76535949e-01f, 1.16200708e-02f, -1.56500459e-01f, -8.91221389e-02f, 7.72226974e-02f, -2.19648212e-01f, -3.09097022e-01f, -1.09267496e-01f, 2.00247452e-01f, 9.60412025e-02f,
  -8.03624839e-02f, 3.97198694e-03f, -1.02599166e-01f, -1.34678930e-01f, -1.98058531e-01f, 8.35313573e-02f, 1.62799060e-01f, -4.86647002e-02f, 4.40216437e-02f, -2.72798032e-01f,
  2.94516701e-02f, 8.92799795e-02f, 4.19988148e-02f, 1.76051457e-03f, -8.07599947e-02f, 1.55383527e-01f, -1.37412827e-02f, 1.41754627e-01f, 6.82607144e-02f, 9.17426571e-02f,
  -8.30391888e-03f, -2.84857482e-01f, -7.77963847e-02f, -2.87251435e-02f, -2.49064282e-01f, 5.46414107e-02f, 1.12215012e-01f, -2.35090286e-01f, -4.17865515e-02f, -1.32575244e-01f,
  -1.27634659e-01f, 1.86454728e-01f, -1.21836618e-01f, 1.05817374e-02f, -8.96984041e-02f, -1.55970618e-01f, 1.95320651e-01f, 1.54984938e-02f, -1.90533116e-01f, 1.12800896e-01f,
  -9.52059552e-02f, -9.16428491e-02f, 1.22622941e-02f, -3.50668460e-01f, 1.16570346e-01f, 7.53525272e-02f, 1.76138625e-01f, 9.64499637e-02f, 1.31381169e-01f, -2.53929999e-02f,
  -1.71227813e-01f, 1.23311713e-01f, -1.16235860e-01f, 1.22100092e-01f, 6.24141805e-02f, -6.09297827e-02f, 9.48351920e-02f, -1.89224612e-02f, -6.43619103e-03f, 7.10399002e-02f,
  2.08546400e-01f, -1.30889818e-01f, 9.44852754e-02f, -2.49092616e-02f, 2.05365375e-01f, -1.08088300e-01f, 1.26290798e-01f, 9.96894315e-02f, 1.57457158e-01f, 1.58172715e-02f,
  3.04221455e-02f, 1.45439170e-02f, 8.35561659e-03f, -2.54170336e-02f, -1.95674226e-01f, -1.56192660e-01f, -8.74356031e-02f, -3.06098294e-02f, -6.89438879e-02f, -6.05245680e-02f,
  8.73664841e-02f, -2.76559200e-02f, -9.95422229e-02f, -1.86274365e-01f, 1.26619577e-01f, 2.42079690e-01f, -8.70262738e-03f, 1.08892068e-01f, -5.70735568e-03f, -1.65964782e-01f,
  -1.69133216e-01f, -1.51195034e-01f, 6.39103800e-02f, 1.92243066e-02f, -1.48822367e-01f, -1.19093610e-02f, -1.59467444e-01f, -7.45983720e-02f, -1.95548296e-01f, 7.05993408e-03f,
  -9.98183787e-02f, -3.09971254e-02f, -2.99866945e-01f, -8.73523951e-02f, 3.42351361e-03f, -9.01881978e-02f, 5.26264645e-02f, -2.28395090e-02f, 4.25058566e-02f, 1.82053611e-01f,
  2.46565878e-01f, -1.95747852e-01f, -1.78147629e-02f, 6.68778643e-02f, -8.27034786e-02f, 2.49326423e-01f, 1.39557160e-02f, 2.24993140e-01f, 7.11577088e-02f, -2.83164948e-01f,
  -5.07799089e-02f, -6.44434318e-02f, 9.49886665e-02f, 3.33656929e-02f, 1.78021297e-01f, -9.77704972e-02f, -1.68062359e-01f, 4.26186547e-02f, -2.34089009e-02f, 5.11918440e-02f,
  1.53421406e-02f, 1.14769721e-02f, 1.88255236e-01f, 1.71995144e-02f, -2.93658059e-02f, 3.40539813e-02f, -1.28701136e-01f, 1.13706782e-01f, -1.25484720e-01f, -1.20442040e-01f,
  6.62421659e-02f, 1.47350222e-01f, 1.70189768e-01f, 9.84147564e-02f, 6.91011697e-02f, -1.19781725e-01f, -1.95587263e-01f, -7.08733872e-02f, 2.22741127e-01f, -2.50174478e-02f,
  -2.66013723e-02f, 1.20866997e-02f, -1.35781631e-01f, -2.39403352e-01f, 6.72763633e-03f, 1.99584752e-01f, -4.47685719e-02f, 4.17923778e-02f, -6.84411600e-02f, -1.00383237e-01f,
  -1.05385236e-01f, -7.62885436e-02f, 1.63018659e-01f, 7.97695853e-03f, -1.53739184e-01f, -9.05012712e-03f, -2.77046654e-02f, 1.66702271e-01f, 1.09993674e-01f, -6.23123907e-02f,
  3.47800791e-01f, -5.95508441e-02f, -2.77991354e-01f, 3.34704608e-01f, -4.87400815e-02f, -8.94087479e-02f, -1.70787260e-01f, -3.22928876e-02f, -2.89749578e-02f, 1.74731016e-02f,
  -6.14122935e-02f, -8.47433358e-02f, -2.01241404e-01f, -2.89508402e-02f, 1.40459105e-01f, -4.62549031e-02f, -5.29970713e-02f, 6.84781149e-02f, 6.07568473e-02f, -1.46080673e-01f,
  1.41220644e-01f, 6.39540479e-02f, -6.97752759e-02f, 1.55475065e-01f, 1.52661931e-02f, 3.71708870e-02f, 1.31867304e-01f, 2.24888667e-01f, 1.91628203e-01f, -1.14155605e-01f,
  -1.60490021e-01f, 6.43427297e-02f, -1.87251553e-01f, -7.25650182e-03f, 1.75576098e-02f, 2.65096244e-03f, -2.39500068e-02f, -5.49626090e-02f, 1.28526166e-02f, -5.20763658e-02f,
  1.38972685e-01f, -2.06078708e-01f, 1.05015740e-01f, 1.41980993e-02f, 1.89928293e-01f, 7.16859624e-02f, 3.46396118e-01f, 1.41952217e-01f, 4.47181202e-02f, 2.26735279e-01f,
  -3.21180299e-02f, -2.12701350e-01f, -5.19799776e-02f, 1.95945110e-02f, -5.55386813e-03f, -1.14594780e-01f, 1.87926754e-01f, 1.57645524e-01f, -3.89623381e-02f, -4.05831575e-01f,
  7.97340123e-04f, -2.61797272e-02f, -2.45217919e-01f, -1.61193341e-01f, -1.08945528e-02f, 4.97155674e-02f, 3.60661358e-01f, -3.02887142e-01f, -5.47538288e-02f, 1.91478208e-01f,
  1.29417153e-02f, 1.25199407e-01f, -1.04794092e-01f, 2.29776964e-01f, -9.10461619e-02f, 8.67319256e-02f, 5.04791401e-02f, -1.15547255e-01f, 7.42668211e-02f, 1.07652076e-01f,
  1.16913438e-01f, 1.79710537e-01f, -3.23430806e-01f, -3.05086141e-03f, -1.94288701e-01f, -2.26883411e-01f, -1.90942124e-01f, -2.58470327e-03f, -2.00021774e-01f, -1.22766383e-01f,
  -7.26308003e-02f, 1.11586809e-01f, 4.11880910e-02f, -1.63885668e-01f, -4.85867262e-02f, -1.53913841e-01f, 1.53145147e-03f, 8.14073160e-02f, 1.12301387e-01f, 1.47063090e-02f,
  9.60941166e-02f, 5.57038113e-02f, -1.25171259e-01f, -8.03395957e-02f, -9.18616951e-02f, 8.11568275e-02f, 1.62248671e-01f, -4.99335416e-02f, -1.95357993e-01f, 1.81357563e-01f,
  -1.14481725e-01f, 3.15083340e-02f, -1.58777818e-01f, -6.13097511e-02f, -1.44469172e-01f, 1.05796747e-01f, 2.38895446e-01f, -8.21691826e-02f, 1.41398609e-01f, 3.31361033e-02f,
  -2.17606783e-01f, 3.63796502e-02f, 1.81909323e-01f, 3.57491434e-01f, 7.06181750e-02f, -1.60397649e-01f, 2.73840815e-01f, -4.10212353e-02f, -1.63260937e-01f, -1.06770083e-01f,
  -1.31936565e-01f, 8.17582309e-02f, 1.32155001e-01f, 1.52370289e-01f, 4.65325154e-02f, 2.64640860e-02f, 1.82724074e-02f, -6.31320551e-02f, -4.77548689e-02f, -1.31258056e-01f,
  -1.34595320e-01f, -1.05968289e-01f, 7.36441836e-02f, -1.34529039e-01f, 9.53582600e-02f, -1.72312275e-01f, 4.40196916e-02f, -1.42825335e-01f, -7.98817053e-02f, 9.33297798e-02f,
  -9.57031548e-02f, 1.02724820e-01f, -5.61125129e-02f, -7.46678114e-02f, -9.40940380e-02f, 2.59775575e-02f, 4.92453575e-02f, 1.68430284e-01f, 9.93168801e-02f, -1.32372186e-01f,
  4.30094898e-02f, -8.40899069e-03f, 5.12070321e-02f, 1.24942034e-01f, 2.04870384e-02f, -1.73364580e-01f, 8.73206109e-02f, 2.62784045e-02f, 6.37143925e-02f, -1.59798563e-02f,
  -2.62610149e-02f, 2.43145432e-02f, -3.87523621e-02f, 3.53305005e-02f, -4.18311320e-02f, 1.18897848e-01f, 2.18961582e-01f, -1.55147798e-02f, 1.68915778e-01f, 7.23849237e-02f,
  1.36154741e-01f, 2.11071864e-01f, 9.94255319e-02f, 4.90622930e-02f, 7.47800693e-02f, 1.55020013e-01f, -9.67338905e-02f, -6.86997846e-02f, 2.83856958e-01f, 5.98493330e-02f,
  1.35454655e-01f, -2.28548585e-03f, 1.43700361e-01f, 3.17354083e-01f, -5.81893779e-04f, -5.06924018e-02f, -1.57983556e-01f, 3.29933478e-03f, -7.59963170e-02f, -2.73203813e-02f,
  1.27702862e-01f, -2.31666699e-01f, -2.14167014e-02f, 9.58000198e-02f, -1.92838311e-01f, -1.79951966e-01f, -1.16401292e-01f, -2.73805000e-02f, 7.91571811e-02f, 6.49164096e-02f,
  -1.39468580e-01f, 2.07166836e-01f, -1.00263216e-01f, -4.63411175e-02f, 2.58126911e-02f, 7.96590820e-02f, 4.12320457e-02f, 9.35368463e-02f, -1.93957850e-01f, -7.97417760e-02f,
  -4.08411697e-02f, 2.20428277e-02f, 2.54968792e-01f, 1.72140461e-03f, 8.06558430e-02f, -2.37930436e-02f, -4.58452851e-03f, -1.40246704e-01f, -4.94679250e-02f, 3.99835553e-04f,
  -5.15275113e-02f, 1.12335473e-01f, 8.01410247e-03f, -1.42163336e-01f, -1.58622056e-01f, -4.24688645e-02f, -1.34371921e-01f, -1.34847730e-01f, 1.47651918e-02f, -4.15977575e-02f,
  -1.51703745e-01f, 8.83674249e-02f, -3.53341587e-02f, 2.28346094e-01f, 3.90928611e-02f, -1.45418569e-01f, -1.04107618e-01f, 1.59071058e-01f, 2.75731653e-01f, -3.40115689e-02f,
  8.93804152e-03f, 1.62125304e-02f, -1.90304071e-01f, 9.04823989e-02f, 2.96439171e-01f, -1.44412590e-03f, 1.63399875e-01f, -2.25406289e-01f, -2.31464148e-01f, 1.83110654e-01f,
  6.11230657e-02f, 8.18715096e-02f, -6.04541637e-02f, -4.69690003e-02f, -1.17048472e-01f, -2.37599388e-01f, -9.86561477e-02f, -4.72354852e-02f, -1.74299330e-02f, -8.46617818e-02f,
  3.34642157e-02f, 1.05518857e-02f, -2.22579896e-01f, 2.32192189e-01f, 1.20445579e-01f, -6.53408989e-02f, -5.16364770e-03f, 1.25974461e-01f, 7.55015463e-02f, 4.25681239e-03f,
  1.07292579e-02f, -9.32316259e-02f, -2.98837125e-01f, 6.98968098e-02f, 8.42670202e-02f, 3.81713100e-02f, 1.16702363e-01f, 4.34284173e-02f, -6.37975801e-03f, 6.27703443e-02f,
  -1.61359385e-02f, -6.82456791e-03f, -1.99259371e-01f, -2.34171748e-01f, -2.51934957e-02f, 1.43947095e-01f, 1.18626840e-01f, 1.36020053e-02f, -2.24075884e-01f, 1.43447474e-01f,
  2.16267496e-01f, -1.99774317e-02f, -2.42592841e-01f, 1.17204398e-01f, -2.72259917e-02f, 1.12659253e-01f, -2.13957414e-01f, -1.62021846e-01f, 1.17572270e-01f, 2.05547623e-02f,
  2.41642177e-01f, 2.08890289e-01f, -1.35819055e-02f, -1.32786661e-01f, 1.05825379e-01f, -2.58623790e-02f, 3.90775166e-02f, 2.49644592e-01f, -3.24004889e-01f, -6.68763369e-02f,
  -1.80303738e-01f, 1.16672352e-01f, -1.92438200e-01f, 1.34433266e-02f, -3.98966623e-03f, -1.20932525e-02f, -1.07247382e-01f, -1.73439428e-01f, 1.32314891e-01f, -6.97888583e-02f,
  2.43040562e-01f, -1.74493507e-01f, -1.04496807e-01f, 1.32330582e-01f, -7.07271174e-02f, 1.43354014e-02f, -4.21955362e-02f, 2.17659250e-01f, 1.22163884e-01f, -1.91571668e-01f,
  2.88711786e-02f, -2.47958079e-02f, 1.05730958e-01f, -1.17227636e-01f, -3.29086669e-02f, -1.28284991e-01f, 5.26081882e-02f, 7.37740025e-02f, -6.09863810e-02f, 1.10974103e-01f,
  1.21381938e-01f, -2.23001823e-01f, -7.25979358e-02f, 2.76882559e-01f, 6.00088313e-02f, 9.26721841e-02f, -9.59896967e-02f, -1.41573653e-01f, -1.11908339e-01f, -1.17464200e-01f,
  -3.14930305e-02f, 1.46506384e-01f, -1.86292499e-01f, 1.06164247e-01f, -2.71318946e-02f, 7.51866177e-02f, -5.51618356e-03f, 1.20996218e-03f, 3.65752936e-03f, 4.37993295e-02f,
  5.35957105e-02f, -8.00483301e-02f, 2.19241217e-01f, -2.70633191e-01f, -2.05482580e-02f, 7.33978897e-02f, -2.42584310e-02f, 1.60306804e-02f, 5.63528500e-02f, 5.73408119e-02f,
  -2.32260108e-01f, 1.21959947e-01f, 1.92864344e-03f, -4.73116245e-03f, 5.08348038e-03f, -7.94184133e-02f, -1.66386142e-01f, 9.30724218e-02f, 2.09503129e-01f, -1.27035100e-02f,
  -3.01632937e-02f, -1.16458992e-02f, -2.21756890e-01f, 1.08679317e-01f, -6.92935139e-02f, -7.58936033e-02f, -4.70983312e-02f, -9.98467579e-02f, 1.08580612e-01f, 5.66615313e-02f,
  5.77223264e-02f, 2.65178770e-01f, -1.97789654e-01f, 2.29929276e-02f, 2.84144729e-02f, -1.03818048e-02f, 6.29821494e-02f, -1.73332125e-01f, 2.05870748e-01f, 5.96043020e-02f,
  1.37246758e-01f, 1.50428265e-02f, -2.16646828e-02f, -3.05720908e-03f, -9.91473123e-02f, -4.12615053e-02f, 9.95697081e-02f, 1.80378094e-01f, -4.36474159e-02f, -8.20627511e-02f,
  -1.87839136e-01f, -1.22888863e-01f, -1.34732515e-01f, -1.08274957e-02f, 1.37225032e-01f, -1.45152137e-01f, -1.37933316e-02f, 3.67721170e-02f, -8.30677673e-02f, 3.17735858e-02f,
  1.22948729e-01f, 8.31447262e-03f, 3.04113384e-02f, 9.30676833e-02f, 6.62042126e-02f, -2.36177698e-01f, 2.06043229e-01f, 1.29476562e-01f, 9.36562493e-02f, -2.93815196e-01f,
  -1.94179609e-01f, 2.33152032e-01f, -3.41970287e-02f, -2.61015184e-02f, 1.86341833e-02f, -1.37468889e-01f, -2.21148297e-01f, 1.12919584e-01f, -1.68122485e-01f, 3.44566524e-01f,
  1.85540274e-01f, -1.44948110e-01f, -1.07484788e-01f, 2.41142049e-01f, 1.68819442e-01f, 1.08244672e-01f, 4.30452041e-02f, 2.69002050e-01f, 2.90606474e-03f, -5.40891998e-02f,
  -3.07387020e-03f, 1.56774465e-02f, -2.81679392e-01f, 7.26426020e-03f, 1.34380236e-01f, -2.70672470e-01f, -3.21303718e-02f, 7.24398047e-02f, -1.61233693e-01f, -9.78255123e-02f,
  1.76551729e-01f, -6.78058267e-02f, -3.22738379e-01f, 3.55001204e-02f, -1.05682842e-01f, -2.04793558e-01f, -3.39584462e-02f, 1.15184695e-01f, -5.29839136e-02f, -2.34969314e-02f,
  9.67592672e-02f, -1.75372809e-01f, 4.89744581e-02f, 1.46560669e-01f, 2.70985272e-02f, -1.19309001e-01f, -5.72174750e-02f, -3.23971845e-02f, -1.00021116e-01f, 7.81754181e-02f,
  8.15709531e-02f, -1.07765026e-01f, 2.04420853e-02f, 1.37863666e-01f, 7.41112381e-02f, -1.52480067e-03f, -7.79209891e-03f, -9.57944617e-02f, -9.56241041e-02f, 4.30551022e-02f,
  1.10027343e-01f, -4.97383811e-02f, 8.08868632e-02f, 2.16733590e-01f, -2.12016493e-01f, 1.67793423e-01f, -3.20627987e-02f, 1.14340045e-01f, -1.34349883e-01f, 5.49276434e-02f,
  -8.82650018e-02f, -2.27080993e-02f, -4.28775325e-02f, -2.30990574e-02f, -1.79451287e-01f, -1.62236504e-02f, -1.63229257e-02f, 6.35373173e-03f, 3.83546054e-02f, -1.58812806e-01f,
  -1.26152650e-01f, -1.01662427e-01f, 2.35621288e-01f, 2.17903182e-01f, -1.02442905e-01f, 7.73142874e-02f, 2.14282319e-01f, -1.02479167e-01f, 1.41538620e-01f, 1.15598083e-01f,
  6.42653033e-02f, 6.72457069e-02f, -5.94222918e-02f, 6.73108026e-02f, -1.60648406e-01f, -1.20401263e-01f, -9.68280211e-02f, -2.68682335e-02f, 1.96428671e-01f, 1.93726435e-01f,
  3.41416989e-03f, -1.80334270e-01f, 4.45278455e-03f, -1.65746972e-01f, -1.26873463e-01f, 1.09251283e-01f, 4.01500389e-02f, -1.30859941e-01f, -1.22446291e-01f, -2.19944008e-02f,
  -2.93922587e-03f, 2.65153944e-02f, 1.01920091e-01f, 3.62400599e-02f, -2.49204449e-02f, -7.50139952e-02f, 1.54895321e-01f, 9.16183889e-02f
};

// L2_fan_Wp_bar (Shape: 40 x 64)
const int L2_fan_Wp_bar_rows = 40;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  6.36479035e-02f, 9.10049975e-02f, 1.29660711e-01f, 2.00250000e-01f, 5.30574378e-03f, 2.38647431e-01f, 4.70135303e-04f, 1.55866235e-01f, 7.03767762e-02f, 5.84340952e-02f,
  5.88132963e-02f, 8.96783695e-02f, 5.33391796e-02f, 7.70361349e-02f, 4.25140083e-01f, -1.99920926e-02f, -1.59319162e-01f, 5.70174714e-04f, 3.22471082e-01f, 1.98015094e-01f,
  -2.33725950e-01f, -6.00833260e-02f, -3.40041101e-01f, -3.38153809e-01f, -7.73733333e-02f, 3.77847552e-02f, 2.34321699e-01f, -2.03000009e-03f, 2.17154652e-01f, 2.11675674e-01f,
  1.64120778e-01f, 4.11103874e-01f, -9.87781361e-02f, 2.16813698e-01f, 2.78259665e-01f, -6.00988232e-02f, -2.19514102e-01f, 6.12008832e-02f, 7.89949298e-02f, 1.22265056e-01f,
  -1.94485754e-01f, -3.67587917e-02f, 1.93280548e-01f, -1.19097397e-01f, 3.17427576e-01f, 1.79490715e-01f, -2.58209053e-02f, -1.46527514e-02f, 3.38060805e-03f, -2.17376485e-01f,
  -9.99767482e-02f, -1.37844812e-02f, 1.79960262e-02f, 1.83758289e-01f, 1.06328905e-01f, 2.07851574e-01f, 6.76101744e-02f, -1.40275717e-01f, -2.09864900e-01f, 3.31909627e-01f,
  -2.77469624e-02f, -6.90057725e-02f, -1.00635663e-01f, -1.38842657e-01f, 1.91480115e-01f, 5.95176145e-02f, -1.20023496e-01f, 4.33171205e-02f, 1.20020635e-01f, -6.68836618e-03f,
  1.56312287e-01f, -5.28355911e-02f, 3.01850736e-01f, 1.48835137e-01f, -1.92061201e-01f, 2.71475494e-01f, 5.79590835e-02f, 2.28323061e-02f, 2.81556666e-01f, -2.34029502e-01f,
  -5.66545948e-02f, 5.35133407e-02f, 8.57639164e-02f, 2.12571502e-01f, -1.32814735e-01f, -1.21823743e-01f, 2.86901802e-01f, 1.63462892e-01f, 5.95466010e-02f, 1.07853480e-01f,
  2.67355144e-01f, 7.06205741e-02f, 2.52671003e-01f, -2.83495963e-01f, 1.07558556e-01f, 1.14548691e-01f, -2.38479897e-01f, -5.47192506e-02f, 1.62383571e-01f, -5.88251501e-02f,
  -2.39235312e-01f, 9.41150934e-02f, 6.03506640e-02f, 1.06949126e-02f, 1.73778504e-01f, 1.33154437e-01f, -6.78979680e-02f, -2.37310189e-03f, -3.16025823e-01f, 5.94190061e-02f,
  1.33593515e-01f, 2.90005594e-01f, 2.31890410e-01f, -3.12288254e-01f, 1.38832182e-02f, 7.92979151e-02f, 1.22461252e-01f, 2.49856398e-01f, 1.42227873e-01f, -1.27325291e-02f,
  2.01421946e-01f, 1.99319258e-01f, 8.97049755e-02f, 1.70735061e-01f, -2.16328241e-02f, -5.84584251e-02f, -1.16372965e-01f, 1.46948285e-02f, 1.75198376e-01f, -8.15126523e-02f,
  -1.37257099e-01f, 1.92190453e-01f, 2.27582499e-01f, 1.16052724e-01f, 2.40271211e-01f, -6.74716160e-02f, 8.09739828e-02f, 1.21884763e-01f, 2.72778392e-01f, 7.11880326e-02f,
  -1.98600665e-02f, -1.44810989e-01f, -3.90594959e-01f, 5.81244193e-02f, 5.45276068e-02f, -3.16496566e-02f, -3.43424410e-01f, -1.48184001e-01f, -1.36114612e-01f, 1.34801582e-01f,
  -2.84036752e-02f, 3.25677902e-01f, 1.53331876e-01f, -5.33231487e-03f, -2.03242172e-02f, -3.02993327e-01f, -1.34955749e-01f, 4.27708954e-01f, 2.72887528e-01f, -2.44704890e-04f,
  1.35988504e-01f, -1.90755501e-01f, 2.34001294e-01f, 8.81881565e-02f, 4.23855126e-01f, 2.18636855e-01f, 6.51160553e-02f, 2.03942880e-01f, 5.36959730e-02f, -1.75774112e-01f,
  -6.12578243e-02f, 1.52055800e-01f, -3.44705999e-01f, 2.88495049e-03f, -6.54879138e-02f, 1.76534504e-02f, 1.88572496e-01f, 2.73760021e-01f, 1.08335279e-01f, -2.01739557e-02f,
  1.17199332e-01f, -6.64154021e-03f, -6.67873099e-02f, -1.18704468e-01f, 2.83300746e-02f, -1.09887859e-02f, 2.71197677e-01f, 2.81611383e-01f, 3.71907018e-02f, -2.16924980e-01f,
  1.56573132e-01f, 1.25999644e-01f, 9.07333642e-02f, 9.61449593e-02f, 1.63074970e-01f, 2.04971105e-01f, 2.59182274e-01f, 1.81990683e-01f, 2.45371222e-01f, -1.32058486e-01f,
  2.70355582e-01f, 1.73225533e-02f, -1.91306353e-01f, 6.66835606e-02f, -1.09819532e-03f, 4.32840228e-01f, 1.67911708e-01f, -1.81144383e-02f, 3.44530582e-01f, 1.34908274e-01f,
  2.30659932e-01f, 1.75038621e-01f, -3.08429331e-01f, 2.03255802e-01f, -3.17584842e-01f, -2.28494346e-01f, -1.56413436e-01f, -2.74120439e-02f, 2.38653481e-01f, -3.24542969e-01f,
  1.82072371e-01f, 2.35001266e-01f, -8.92349556e-02f, 1.84967622e-01f, 4.18012552e-02f, -1.98316962e-01f, 3.10909778e-01f, 8.75707790e-02f, 2.80535787e-01f, 7.40941837e-02f,
  3.26564044e-01f, 1.62588790e-01f, 2.13209298e-02f, 2.32099816e-02f, 1.42914280e-01f, -1.96513124e-02f, 1.58108830e-01f, 2.51495063e-01f, -2.19528750e-02f, -2.23886743e-01f,
  1.21075533e-01f, -1.05327778e-01f, -4.75227907e-02f, 2.29976773e-01f, -6.99828416e-02f, 1.57114118e-02f, -6.67347386e-02f, 6.34627417e-02f, -9.45690125e-02f, 2.06838086e-01f,
  3.38590205e-01f, 2.62400061e-01f, -6.60313219e-02f, -1.65456459e-01f, 3.25390309e-01f, -1.05092689e-01f, 3.28123242e-01f, -8.18723366e-02f, -8.47932138e-03f, 1.68879077e-01f,
  -3.17393579e-02f, 2.86533851e-02f, -4.51170802e-02f, 1.45807669e-01f, 4.68281694e-02f, 1.13499537e-01f, 2.18241349e-01f, 1.10966884e-01f, -1.99400589e-01f, -1.35078892e-01f,
  -3.04827858e-02f, 2.86373407e-01f, -1.65180370e-01f, 2.71839071e-02f, 8.22949409e-02f, -1.15732990e-01f, 4.41123098e-01f, -2.41109952e-01f, 1.60953254e-01f, 4.39029545e-01f,
  1.36966899e-01f, 9.54767615e-02f, -9.30537730e-02f, 1.52859151e-01f, -1.90371335e-01f, 5.05299717e-02f, 2.19612166e-01f, -1.70411512e-01f, 1.13769002e-01f, 1.59710452e-01f,
  -2.62323052e-01f, 1.49070382e-01f, 1.21986531e-01f, 5.21188080e-02f, -1.90327913e-01f, -2.81111926e-01f, -3.28789391e-02f, -4.45315503e-02f, 2.08234927e-03f, 1.05001427e-01f,
  1.10935912e-01f, -1.56073377e-01f, 8.77729133e-02f, 1.53204083e-01f, -1.22275732e-01f, 2.11769566e-01f, 1.87651664e-01f, -1.11327976e-01f, -4.15922403e-02f, 2.06810869e-02f,
  -2.36010775e-02f, 1.46906570e-01f, -1.00897618e-01f, 8.03071856e-02f, 1.76981866e-01f, -7.81084672e-02f, 2.58289069e-01f, -1.32793844e-01f, -4.73491997e-02f, 1.15964510e-01f,
  8.48851278e-02f, -1.78559721e-02f, 1.41513953e-02f, 1.82397038e-01f, 4.05940190e-02f, 2.32584700e-01f, -2.05855548e-01f, 9.71861333e-02f, 4.60915491e-02f, 3.48241031e-02f,
  2.80411303e-01f, -1.62934333e-01f, -5.50533123e-02f, -2.13844895e-01f, 2.84777254e-01f, 4.41049822e-02f, 6.50400808e-03f, -1.64224803e-01f, 1.87133610e-01f, 1.11533366e-01f,
  2.48732381e-02f, 4.74885218e-02f, -6.75257966e-02f, -3.33569646e-01f, -1.83639318e-01f, -8.19581226e-02f, 1.28716156e-01f, -1.05376698e-01f, -5.60301580e-02f, 1.51780158e-01f,
  1.84406027e-01f, -1.45954126e-02f, 1.77287996e-01f, -3.17822248e-02f, 4.94488608e-03f, 2.53907949e-01f, -4.06261772e-01f, 2.28898644e-01f, 1.94139451e-01f, 1.40024364e-01f,
  4.18797247e-02f, 7.81079847e-03f, 2.37952188e-01f, -2.07690120e-01f, 3.77217799e-01f, 1.69694677e-01f, -6.86053038e-02f, 2.25523170e-02f, 9.31551829e-02f, 2.32012905e-02f,
  -6.47376329e-02f, 1.18417516e-01f, -8.59139208e-03f, 4.97396663e-02f, 1.76166713e-01f, 2.83019066e-01f, -5.67849986e-02f, -1.07143402e-01f, -2.25386992e-01f, 5.41209579e-02f,
  8.93217251e-02f, -1.28592536e-01f, -2.88861841e-01f, -1.31637052e-01f, 2.25635394e-01f, 4.49807703e-01f, -2.15067491e-01f, 1.64576888e-01f, 5.71385734e-02f, 2.92145640e-01f,
  3.61029118e-01f, -9.41521898e-02f, 3.35901141e-01f, 2.93438226e-01f, -5.17287292e-02f, 1.55358389e-01f, -6.84095314e-03f, 2.28859961e-01f, 2.15152144e-01f, 8.35855454e-02f,
  3.02144408e-01f, -2.01066788e-02f, 2.94675767e-01f, 2.57288188e-01f, -5.51348925e-01f, 1.45096153e-01f, -3.16655636e-01f, -4.92071882e-02f, 3.73737444e-03f, -8.50293636e-02f,
  1.41630962e-01f, -1.88179016e-01f, 1.36253744e-01f, -1.63000315e-01f, -1.14756167e-01f, 1.26675680e-01f, 1.53604895e-01f, 7.99180008e-03f, -1.63152412e-01f, -1.85188204e-01f,
  6.91093579e-02f, 1.32087201e-01f, 2.87817270e-01f, 2.28294894e-01f, -1.49825320e-01f, 6.27332702e-02f, 1.00079164e-01f, -2.69376963e-01f, -9.81260762e-02f, -8.56738305e-04f,
  8.83402899e-02f, -5.66001935e-03f, -8.30209628e-02f, 1.02380283e-01f, -6.22778870e-02f, 2.25411221e-01f, 7.58582205e-02f, 3.25191617e-02f, -1.10872038e-01f, 2.21487328e-01f,
  -1.65917687e-02f, 2.25256279e-01f, 2.01087728e-01f, 2.14524716e-01f, -7.88922012e-02f, -3.41858894e-01f, 1.89957228e-02f, -2.26578951e-01f, -9.07291546e-02f, 3.48838449e-01f,
  1.15959533e-01f, 8.99378881e-02f, 6.21109605e-02f, -1.65405795e-02f, 2.26634622e-01f, -6.86249742e-03f, 1.39112264e-01f, -6.32527247e-02f, -2.73450792e-01f, 6.78675100e-02f,
  1.25084072e-01f, -8.36267322e-03f, 3.19444031e-01f, -2.20961437e-01f, -1.44658387e-01f, 2.96586573e-01f, 2.58031525e-02f, 3.11260313e-01f, -1.19180717e-01f, -2.00804785e-01f,
  -1.93333000e-01f, -1.42596975e-01f, -7.29036331e-02f, 4.93441746e-02f, 3.18592221e-01f, 1.60072267e-01f, 1.37704268e-01f, -2.80184895e-01f, 1.20106630e-01f, 2.44355828e-01f,
  -3.25908154e-01f, 2.16315463e-01f, 4.31128949e-01f, 1.91273212e-01f, -1.02244332e-01f, 1.04925469e-01f, -8.32544342e-02f, 1.24747463e-01f, 1.83455616e-01f, 1.30963340e-01f,
  -8.48099962e-03f, 3.35845239e-02f, -5.24617732e-03f, -8.89199972e-02f, 1.51209936e-01f, 1.02843076e-01f, 8.18689987e-02f, -2.87560880e-01f, 1.00425795e-01f, 3.90323967e-01f,
  9.56113264e-02f, -3.26907374e-02f, -4.97416854e-02f, 1.06309116e-01f, 5.45588927e-03f, 1.74163789e-01f, 2.40284242e-02f, 1.02102078e-01f, -1.78133130e-01f, 1.97992459e-01f,
  2.93126494e-01f, -3.57351406e-03f, -4.82271723e-02f, -4.07373935e-01f, 1.73301511e-02f, -2.93710344e-02f, 1.01804748e-01f, -1.16452537e-01f, -1.11217126e-01f, 2.65450776e-01f,
  -2.18741044e-01f, -3.11037093e-01f, 2.81840593e-01f, -2.61363927e-02f, -1.44507587e-01f, -1.91128150e-01f, 9.03949291e-02f, -2.31899992e-01f, 6.82729706e-02f, 4.44998033e-02f,
  -1.95297580e-02f, 3.72337133e-01f, 2.76208729e-01f, -1.90828711e-01f, 1.52670175e-01f, 3.34743708e-01f, 2.37555280e-01f, 2.58052737e-01f, 1.14317119e-01f, 1.81998566e-01f,
  -6.76170290e-02f, 1.66633531e-01f, 1.84340015e-01f, -2.53621578e-01f, -2.33380899e-01f, 2.04895705e-01f, 1.07630156e-01f, -2.51139868e-02f, 2.44982138e-01f, 2.87493140e-01f,
  -1.46497488e-01f, -2.07319111e-01f, 1.37355983e-01f, 2.01867908e-01f, -3.39553863e-01f, 3.67623776e-01f, -2.65984759e-02f, -1.13970384e-01f, 8.06656554e-02f, 5.27299233e-02f,
  1.48212284e-01f, 7.53552243e-02f, 1.76463217e-01f, -3.00700456e-01f, -9.02192220e-02f, 2.49097049e-02f, 2.23260060e-01f, 6.59412891e-02f, 1.68716371e-01f, 1.05029270e-01f,
  -1.71486914e-01f, 4.11856845e-02f, 2.31278956e-01f, 4.80956361e-02f, 1.03886232e-01f, -3.24972421e-02f, -7.30090216e-02f, -8.64464939e-02f, 7.73786530e-02f, 1.02176405e-01f,
  -3.21293622e-02f, 1.41050383e-01f, 6.95583150e-02f, 1.45612806e-02f, -8.46718401e-02f, -1.15471721e-01f, 4.11440670e-01f, 4.84083146e-02f, 1.04452930e-01f, -2.53798872e-01f,
  -1.52615430e-02f, -2.58000314e-01f, -4.09999222e-01f, 3.91720384e-01f, -1.01703987e-03f, 3.24985147e-01f, 1.95392564e-01f, -5.36021478e-02f, -9.06003080e-03f, 8.49946588e-02f,
  -8.18092600e-02f, 1.63209453e-01f, 4.94363718e-02f, 1.66214019e-01f, 4.04297560e-01f, 2.49788657e-01f, 5.84825687e-02f, 2.55619019e-01f, -2.46296138e-01f, 1.62918106e-01f,
  1.75629929e-01f, 2.03575924e-01f, -3.72224003e-01f, 8.30703080e-02f, -5.61182685e-02f, 8.56710523e-02f, -1.80081934e-01f, 2.48964299e-02f, 8.23595673e-02f, -7.37441806e-05f,
  3.50714952e-01f, 1.26596615e-01f, -5.98117933e-02f, 2.38890038e-03f, 2.69834340e-01f, -3.88282686e-01f, -8.99235532e-03f, 1.00689821e-01f, 2.34497800e-01f, -4.29066978e-02f,
  2.20857695e-01f, 2.12078363e-01f, 1.81398526e-01f, -2.75331974e-01f, -1.81545898e-01f, 3.18522096e-01f, -1.80420130e-01f, 1.08939826e-01f, 8.83466676e-02f, 1.80270627e-01f,
  2.42527276e-01f, -3.69506270e-01f, -1.33713588e-01f, 1.80308446e-01f, 1.05046220e-02f, 1.48039788e-01f, -1.36263639e-01f, 6.52783662e-02f, 5.64739518e-02f, -2.34727830e-01f,
  9.77536663e-03f, -4.76703793e-02f, 1.13024004e-01f, 1.73945665e-01f, 1.34302542e-01f, 6.57327399e-02f, 3.29524904e-01f, 3.16605777e-01f, 3.33580881e-01f, 1.16840363e-01f,
  -2.31664017e-01f, 2.36744791e-01f, -2.55298972e-01f, -2.16765448e-01f, -1.39794171e-01f, 7.13388622e-02f, -4.32915241e-02f, 3.57258134e-02f, -2.99679101e-01f, 3.52471992e-02f,
  6.30421191e-02f, -1.49874493e-01f, 2.57559478e-01f, -6.53046370e-02f, 6.82414696e-03f, 4.39471416e-02f, -1.49488449e-01f, -1.01483129e-02f, 8.77815485e-02f, 1.40007868e-01f,
  7.49677196e-02f, -1.73574775e-01f, 3.17425430e-01f, -2.10924655e-01f, 2.38405779e-01f, 2.17455685e-01f, 5.96335679e-02f, -7.45110260e-03f, 9.67883542e-02f, 4.14490819e-01f,
  -6.96306080e-02f, -3.46670263e-02f, 2.35042851e-02f, 1.07234247e-01f, -1.28693478e-02f, 1.20289914e-01f, -8.31674561e-02f, 5.06023280e-02f, 2.75959447e-03f, -1.63831055e-01f,
  2.92363971e-01f, -3.88845317e-02f, 1.65207461e-01f, 1.55942962e-01f, 3.38311255e-01f, 2.33382002e-01f, -8.79647508e-02f, 1.97837263e-01f, 1.69384345e-01f, 3.11864942e-01f,
  1.43325347e-02f, 8.14338624e-02f, 1.64217249e-01f, 4.94195879e-01f, 2.10582927e-01f, 6.17532320e-02f, 1.62696853e-01f, -2.66377568e-01f, 3.09857470e-03f, 6.35818690e-02f,
  4.13574070e-01f, -2.32919320e-01f, -6.74159499e-03f, -2.63255686e-01f, -1.51303962e-01f, 2.03154713e-01f, -1.00791309e-04f, 1.40100837e-01f, 1.56647146e-01f, -3.68847139e-02f,
  -4.56496850e-02f, -3.57070833e-01f, 1.18809476e-01f, 3.54783297e-01f, 1.75613821e-01f, -7.75280669e-02f, 3.27596188e-01f, 7.80384317e-02f, -3.59960675e-01f, -2.56841987e-01f,
  1.85946941e-01f, 1.67713791e-01f, 2.35669851e-01f, 1.54887080e-01f, -1.56473219e-01f, -3.10116392e-02f, 1.24278024e-01f, -1.62508488e-01f, -1.99611023e-01f, 9.51824933e-02f,
  -2.39664000e-02f, 4.52913344e-02f, -7.61759654e-02f, 2.71503478e-01f, -5.02239913e-02f, 7.64246807e-02f, 1.48325739e-02f, -8.23323280e-02f, -2.42984787e-01f, 8.54247510e-02f,
  1.88854083e-01f, 3.35015021e-02f, 1.65996358e-01f, 1.51304081e-01f, 1.13257013e-01f, -3.90091836e-01f, -1.00594662e-01f, -7.24942461e-02f, 1.21667981e-02f, 7.17113614e-02f,
  5.16388714e-02f, 1.20704837e-01f, 3.79905328e-02f, 7.37424791e-02f, -4.86074015e-03f, 1.19104564e-01f, 4.33122069e-02f, 2.76202429e-02f, 8.15398395e-02f, 1.79859668e-01f,
  8.84707570e-02f, -4.56102043e-02f, 3.75915825e-01f, -6.17405847e-02f, -1.92305557e-02f, 1.05017357e-01f, 9.25881639e-02f, 3.45610559e-01f, 3.25572863e-02f, 8.75899568e-02f,
  -1.89475223e-01f, -3.70540500e-01f, -1.18246987e-01f, -1.10048741e-01f, -5.36918826e-02f, 8.92958641e-02f, -8.42341483e-02f, 2.36906469e-01f, 1.18987009e-01f, -1.21008717e-01f,
  1.80988405e-02f, 1.04017615e-01f, 4.16170567e-01f, 1.94086991e-02f, -1.89376935e-01f, 3.69197056e-02f, -8.37710425e-02f, 7.70296669e-03f, -1.73110321e-01f, 4.59533073e-02f,
  -8.03598091e-02f, 1.89105526e-01f, 3.59245509e-01f, 2.11852014e-01f, -2.53339969e-02f, -2.22740412e-01f, -3.34399305e-02f, 3.89626585e-02f, -1.67513371e-01f, 1.63370706e-02f,
  -8.45204145e-02f, -1.56853313e-03f, 1.15211837e-01f, 1.09171398e-01f, -1.86627790e-01f, 5.52030616e-02f, -1.67667985e-01f, 6.01634271e-02f, 3.84037763e-01f, -3.77737135e-02f,
  -1.92872390e-01f, 9.98803377e-02f, 3.75913754e-02f, 8.65524784e-02f, 2.49133021e-01f, 1.51477143e-01f, 1.91454202e-01f, -1.27822638e-01f, 1.57928579e-02f, 3.79161835e-01f,
  1.90533757e-01f, -1.39292926e-01f, 1.42386379e-02f, -6.79745153e-02f, 6.17052354e-02f, -7.48122633e-02f, 2.80324101e-01f, -2.12523207e-01f, -2.87637282e-02f, -2.56350953e-02f,
  -1.42422035e-01f, 5.22281043e-02f, 5.43252975e-02f, -2.46699095e-01f, -2.55122501e-02f, -4.02897634e-02f, -1.14146128e-01f, -3.12582403e-02f, 1.41347706e-01f, -1.18393786e-01f,
  2.73783449e-02f, -2.07926854e-01f, 1.15107941e-02f, 2.94349849e-01f, -3.40328813e-01f, 1.52339503e-01f, 3.79655808e-01f, -1.40623958e-03f, -2.10640773e-01f, 5.37090115e-02f,
  -2.18958646e-01f, -1.41985267e-01f, 1.06354602e-01f, 1.71790883e-01f, -1.63725056e-02f, 1.63286000e-01f, 2.77637802e-02f, -2.02323701e-02f, 1.63221091e-01f, 2.17984587e-01f,
  1.15165606e-01f, -1.04811164e-02f, 9.13342834e-03f, 1.61985338e-01f, 9.87598374e-02f, 3.26056443e-02f, 2.14941531e-01f, 1.88323289e-01f, 1.40748948e-01f, 2.01869488e-01f,
  -2.53343999e-01f, 1.80856034e-01f, -1.93727180e-01f, -4.30362150e-02f, 6.36029020e-02f, -3.37907746e-02f, 2.11113185e-01f, 8.94703940e-02f, -6.39166497e-03f, 2.01531500e-01f,
  6.72571138e-02f, 4.25874963e-02f, -2.16412991e-01f, 3.32205504e-01f, 1.65012687e-01f, -2.13033006e-01f, 8.42122957e-02f, 8.06048885e-02f, -1.54272532e-02f, 7.28021637e-02f,
  5.03347337e-01f, 7.85731599e-02f, -1.50597945e-01f, 5.42699695e-02f, 1.02877662e-01f, 2.31550604e-01f, 1.67037979e-01f, -8.77073184e-02f, -2.03326911e-01f, -2.19525322e-01f,
  -6.33589476e-02f, -5.27938716e-02f, 1.49472475e-01f, 2.24680752e-02f, 2.02012599e-01f, 2.47618496e-01f, 2.83140481e-01f, 7.15702865e-03f, 7.01490417e-02f, 7.15271011e-02f,
  3.04027438e-01f, -9.46212932e-02f, 9.51507874e-03f, 2.81187855e-02f, 2.01343633e-02f, 3.60210799e-02f, -2.06043813e-02f, -2.45882515e-02f, -3.73541814e-04f, -1.22319326e-01f,
  3.63884896e-01f, -6.62779808e-02f, -4.00888585e-02f, 4.93226349e-02f, -1.83475167e-01f, 3.07620198e-01f, 2.21786443e-02f, -4.57882173e-02f, 4.78521027e-02f, 1.58991158e-01f,
  8.05865042e-03f, 2.46737748e-01f, -1.04625799e-01f, -7.52903000e-02f, -2.09239826e-01f, 3.35641176e-01f, 3.37162852e-01f, -4.40841950e-02f, -5.35574816e-02f, 1.74468532e-02f,
  1.36214852e-01f, -1.15483575e-01f, -2.50952638e-04f, 3.68280075e-02f, 1.74371749e-02f, 6.61615729e-02f, 7.10379630e-02f, 1.16031408e-01f, -4.50065956e-02f, -1.91785082e-01f,
  2.23336235e-01f, 1.37253210e-01f, 6.21504709e-02f, 9.45562348e-02f, 3.67034405e-01f, -3.96275036e-02f, -4.83678579e-01f, 4.64765355e-02f, 5.37041247e-01f, 1.17552586e-01f,
  -2.09436849e-01f, 1.15765460e-01f, -3.84690821e-01f, -9.03067440e-02f, -2.74804890e-01f, 1.68955430e-01f, 7.84879848e-02f, 1.24220826e-01f, 2.33610496e-01f, -2.73288608e-01f,
  1.42310947e-01f, 4.01368409e-01f, -1.33359656e-01f, 2.95614481e-01f, -2.16653764e-01f, -4.67325747e-02f, -1.89803660e-01f, 1.23183560e-02f, 2.25340515e-01f, -5.19278720e-02f,
  4.87822704e-02f, -4.04386967e-02f, 1.63161829e-01f, -1.04111172e-01f, 4.55712050e-01f, -9.15918276e-02f, 9.13587436e-02f, 3.62893124e-03f, -1.47300959e-01f, -1.80716887e-01f,
  5.65793887e-02f, 5.76027520e-02f, -8.52305442e-02f, 1.60266697e-01f, -3.12742852e-02f, 3.24723929e-01f, 1.35561064e-01f, -2.66660988e-01f, -1.06776878e-01f, 2.85903484e-01f,
  -9.99697074e-02f, -1.64107177e-02f, 3.91103141e-02f, -6.08447306e-02f, 1.75378487e-01f, -1.80952791e-02f, 3.97592522e-02f, 2.68442571e-01f, 2.12718565e-02f, 1.10205904e-01f,
  8.09020698e-02f, -3.43540795e-02f, 1.31601572e-01f, 1.12594806e-01f, 1.66838422e-01f, 3.13700855e-01f, -9.27907303e-02f, -3.14340651e-01f, 6.22439124e-02f, 1.58374444e-01f,
  2.31961552e-02f, -1.84288576e-01f, 2.24761322e-01f, 6.25571683e-02f, 2.67623663e-01f, -6.87613860e-02f, 3.65512580e-01f, 2.25469738e-01f, -1.91241000e-02f, 2.54370779e-01f,
  5.67405224e-02f, -4.15976159e-02f, -1.17327673e-02f, -3.31457227e-01f, -1.19424440e-01f, -3.22277397e-01f, -1.42422654e-02f, 2.48060167e-01f, -3.72395277e-01f, 9.96424630e-03f,
  -3.65870506e-01f, 1.22432455e-01f, -2.71891542e-02f, -1.61131486e-01f, 4.15351912e-02f, 2.82324851e-01f, 1.02081992e-01f, -2.80141622e-01f, -2.29619712e-01f, 1.42270640e-01f,
  1.61910281e-01f, 6.15069345e-02f, 3.08768183e-01f, -2.08831266e-01f, 2.10954055e-01f, 2.57462621e-01f, 3.24912369e-01f, 9.41328630e-02f, 1.35901898e-01f, 1.00447983e-01f,
  2.31606424e-01f, 1.98113933e-01f, 4.18414548e-02f, 3.49762687e-03f, -9.23472364e-03f, -1.52750820e-01f, 1.03233280e-02f, 2.07339510e-01f, 5.52502871e-02f, -1.72483306e-02f,
  2.20426813e-01f, -4.35357690e-02f, -1.13080345e-01f, 2.45435163e-01f, 2.21426979e-01f, 1.60778731e-01f, 2.91595962e-02f, 8.99557397e-02f, 9.97107476e-02f, 1.52625233e-01f,
  1.13452978e-01f, 1.48847774e-01f, 8.64707530e-02f, 9.37472060e-02f, 4.04397212e-02f, 2.16438621e-01f, -1.68937385e-01f, 1.68067858e-01f, 1.19343601e-01f, 2.13257670e-01f,
  6.98236376e-02f, -3.03572565e-01f, -6.43990263e-02f, -1.33884788e-01f, 1.00841075e-01f, -1.61045507e-01f, 1.09830268e-01f, 4.83547091e-01f, 2.85362184e-01f, 9.50403288e-02f,
  1.84516460e-02f, -1.96650222e-01f, 5.44749260e-01f, 2.96912074e-01f, 2.29185358e-01f, 2.34889343e-01f, 3.71259414e-02f, 6.69261441e-02f, -2.41302460e-01f, -7.72220269e-02f,
  -1.70073986e-01f, 2.62843221e-01f, 4.54757065e-01f, 1.19153060e-01f, -3.83386277e-02f, -2.85114318e-01f, -1.60730422e-01f, 1.85391024e-01f, -1.77176759e-01f, -1.18309334e-01f,
  -1.12033755e-01f, -1.47244349e-01f, -3.03564351e-02f, 2.44829491e-01f, -3.75672162e-01f, 1.49669871e-01f, -5.07814400e-02f, 2.44073391e-01f, 2.90295005e-01f, -2.23152801e-01f,
  -1.84072256e-01f, -4.30331863e-02f, -1.08680129e-01f, 4.31421131e-01f, 2.77460843e-01f, 1.38329668e-02f, 6.49306476e-02f, 2.11304724e-02f, 1.90868542e-01f, 4.76433933e-02f,
  2.15369314e-01f, 1.77906007e-01f, -1.46974877e-01f, 9.53907520e-02f, 1.30685996e-02f, 4.16794986e-01f, 2.14595795e-01f, 9.73493531e-02f, -5.87683953e-02f, 1.01736017e-01f,
  1.62605122e-01f, -2.27474138e-01f, -1.68223828e-01f, -6.72002435e-02f, -4.85019594e-01f, -4.57426906e-01f, 3.69103812e-02f, -1.78600773e-01f, 4.10799915e-03f, 1.86574519e-01f,
  -4.06704005e-03f, -3.41729313e-01f, -9.38267931e-02f, 1.64252415e-01f, 2.34742671e-01f, 2.06102744e-01f, -6.72298670e-02f, -4.59947288e-02f, 4.65391837e-02f, -1.47072598e-01f,
  1.02312222e-01f, 1.31494999e-01f, -8.39740485e-02f, -5.70615977e-02f, 1.39139026e-01f, -2.39199445e-01f, 4.11572456e-01f, 2.37761036e-01f, 1.40933573e-01f, -3.81682254e-02f,
  -1.82219476e-01f, -2.11206917e-02f, -2.75310576e-01f, 5.94691336e-02f, -5.78540228e-02f, 3.33598182e-02f, -1.84309512e-01f, 1.92283213e-01f, -1.57184198e-01f, -2.54024506e-01f,
  1.47454366e-01f, 2.39380181e-01f, 2.23823581e-02f, 2.44388163e-01f, 1.95588619e-02f, -1.28335640e-01f, 6.61892444e-02f, -3.51457447e-02f, -1.26104176e-01f, 7.80406669e-02f,
  1.92255557e-01f, 1.85599718e-02f, 6.63496181e-02f, -1.89988166e-01f, -1.98727667e-01f, 3.49397920e-02f, 6.05053939e-02f, 4.14658226e-02f, -5.08725010e-02f, 1.14604332e-01f,
  -3.47543687e-01f, 9.09318179e-02f, 3.95085633e-01f, 1.62031259e-02f, 3.83682877e-01f, -2.55834550e-01f, -2.51500368e-01f, 3.68275136e-01f, 2.49948315e-02f, -1.05973430e-01f,
  -1.07197165e-02f, 3.04229911e-02f, -4.50896136e-02f, 2.07656436e-02f, -1.38720259e-01f, -1.90485969e-01f, -3.26714158e-01f, -2.47464344e-01f, 3.08275223e-01f, -4.51450516e-03f,
  -3.92137855e-01f, 1.24473169e-01f, -3.14848721e-01f, -2.32995600e-01f, 2.62929022e-01f, 9.04847682e-02f, 9.98804253e-03f, -1.22912722e-02f, 2.66345739e-01f, -6.66121840e-01f,
  1.16205707e-01f, 3.80599052e-01f, 1.21074706e-01f, 1.65188871e-02f, 6.60047755e-02f, -2.02516302e-01f, -1.68104723e-01f, 2.04820678e-01f, 2.11576357e-01f, 3.28006186e-02f,
  -1.65528581e-01f, -1.67642444e-01f, 1.06408380e-01f, 4.92187403e-02f, 2.56268024e-01f, -1.93231001e-01f, 8.60056356e-02f, 1.23075871e-02f, -1.95279598e-01f, 2.91597471e-02f,
  4.53765392e-02f, 1.00614384e-01f, 1.70540720e-01f, 1.12336941e-01f, 3.53870988e-02f, 1.81056157e-01f, -7.82623217e-02f, 1.13802962e-01f, 1.99137419e-01f, 4.33443666e-01f,
  7.43698701e-02f, 1.20948017e-01f, -5.21645285e-02f, -3.55617911e-01f, -7.95432925e-02f, 4.18414921e-02f, 1.00768749e-02f, -2.53368944e-01f, -1.71580419e-01f, -2.19774619e-01f,
  3.14132720e-01f, -1.34028092e-01f, 4.43907887e-01f, 1.01792336e-01f, 9.73150283e-02f, 2.72200018e-01f, -1.59993023e-02f, -1.39891133e-01f, 1.62619337e-01f, 2.61017513e-02f,
  -3.69441360e-02f, -1.30393624e-01f, -8.85812864e-02f, -4.14117798e-02f, -1.27087042e-01f, 2.72289813e-01f, 3.35952174e-03f, 4.41161126e-01f, -3.22524196e-04f, -9.43136141e-02f,
  -1.66885659e-01f, 2.53355324e-01f, 1.60875425e-01f, 1.87356666e-01f, -5.09366393e-02f, 1.86229274e-01f, 1.03988558e-01f, 2.81491697e-01f, 1.44922808e-01f, 2.29508534e-01f,
  2.65881807e-01f, 2.22891033e-01f, 2.37129420e-01f, -7.19919875e-02f, 4.51847278e-02f, 6.64168075e-02f, 8.78485143e-02f, 2.73438752e-01f, -7.86644518e-02f, 6.48531392e-02f,
  -6.95326738e-03f, 1.79957319e-02f, -3.73760581e-01f, -2.11363956e-02f, 6.55638129e-02f, 8.33605304e-02f, 5.12616336e-01f, -2.86619347e-02f, -2.47697700e-02f, 6.73744306e-02f,
  1.75259799e-01f, 4.32264060e-01f, -4.45720963e-02f, 9.91707072e-02f, 2.07835764e-01f, 1.46659827e-02f, -1.32951066e-01f, -8.80928561e-02f, 7.69524127e-02f, 1.11352861e-01f,
  3.99038017e-01f, -1.18395373e-01f, -4.12814319e-01f, 1.01450056e-01f, 2.10933879e-01f, -1.29213512e-01f, 2.37204209e-01f, 1.36424005e-01f, 2.27698207e-01f, 1.90929100e-01f,
  2.47760698e-01f, -5.08763015e-01f, -1.80882335e-01f, -2.32161079e-02f, -7.04366118e-02f, -1.54005930e-01f, 5.36273234e-02f, -3.34803350e-02f, -3.18602443e-01f, -2.01110557e-01f,
  3.64065804e-02f, 1.62697539e-01f, -3.87585342e-01f, -3.27460408e-01f, -1.51266426e-01f, 2.50087976e-01f, -6.92369640e-02f, 3.67596954e-01f, -3.76060426e-01f, -1.13279745e-01f,
  5.11862617e-03f, 2.39843369e-01f, 1.21105626e-01f, 3.00209284e-01f, 8.34562257e-02f, -1.41850427e-01f, -2.14034021e-02f, -2.42466718e-01f, -2.28367090e-01f, -3.34437817e-01f,
  9.36914757e-02f, 2.91475236e-01f, -3.13159712e-02f, -1.65654719e-01f, 6.61647245e-02f, -1.08474202e-01f, -4.39500302e-01f, -2.26794958e-01f, 8.55133906e-02f, -2.51088828e-01f,
  -1.59829676e-01f, 1.07116058e-01f, 1.49073929e-01f, 2.05071315e-01f, -1.13951966e-01f, 1.58280104e-01f, 5.73867746e-02f, -1.31042197e-01f, -1.40388295e-01f, -6.74079433e-02f,
  6.51416406e-02f, 1.38677403e-01f, 4.22243506e-01f, -2.90983319e-01f, -1.53282717e-01f, -1.78165417e-02f, 2.68084407e-01f, 3.89627784e-01f, -1.10322274e-01f, 4.25211340e-03f,
  -2.43423969e-01f, -4.32403162e-02f, 7.11616576e-02f, 1.67879954e-01f, 2.78472185e-01f, 3.06747127e-02f, 5.02466261e-02f, 1.55671597e-01f, 1.40186176e-01f, 2.13040505e-03f,
  -1.38300478e-01f, 1.88200012e-01f, 9.63603631e-02f, -3.77192527e-01f, -2.77535260e-01f, -4.13407236e-02f, 2.70230353e-01f, 9.17559415e-02f, -2.62016505e-02f, 8.52437988e-02f,
  -4.96720932e-02f, -2.28606742e-02f, 1.79975480e-01f, 2.71442905e-02f, -8.98233056e-02f, -1.02144457e-01f, 1.10343136e-01f, -9.53874961e-02f, -1.06186485e-02f, 1.68463681e-02f,
  1.04935631e-01f, 1.82960093e-01f, 2.69708365e-01f, 2.11017400e-01f, 2.59062946e-01f, -1.14668116e-01f, -2.46617869e-01f, 3.83468002e-01f, 2.41439596e-01f, -3.31153423e-01f,
  -1.14230573e-01f, -9.72369593e-03f, 2.21255288e-01f, 3.48029703e-01f, 2.15901852e-01f, 4.09579992e-01f, 2.14104190e-01f, 9.12386030e-02f, 2.06572995e-01f, 1.91058647e-02f,
  2.75357753e-01f, 2.66365528e-01f, -3.75148356e-02f, 2.29309261e-01f, 8.48243535e-02f, -1.06535926e-01f, -2.57084686e-02f, 1.54022411e-01f, 9.15140137e-02f, -7.57259503e-02f,
  -1.15570292e-01f, -2.03902408e-01f, 2.11722609e-02f, -1.39746621e-01f, -2.98781954e-02f, -1.82325751e-01f, 1.37775019e-01f, -5.51039465e-02f, 1.90546051e-01f, -4.00963426e-02f,
  6.97207376e-02f, -3.56649071e-01f, -2.52834290e-01f, 4.28057238e-02f, 8.86899680e-02f, 4.74568680e-02f, -1.73052847e-02f, 4.23590392e-01f, -3.10442448e-01f, 1.67925954e-01f,
  8.45536888e-02f, -1.49957007e-02f, -3.69910672e-02f, 4.43187021e-02f, 1.22425556e-01f, -1.52721405e-01f, -2.21694559e-01f, 1.95813224e-01f, 2.58731395e-01f, -4.61236909e-02f,
  3.36579412e-01f, -1.38040990e-01f, 1.19098708e-01f, 4.76697296e-01f, 2.90520012e-01f, -1.39579847e-01f, -4.47868742e-02f, -6.73945844e-02f, -4.65060882e-02f, 1.34425744e-01f,
  2.14931279e-01f, -9.62608755e-02f, -3.38279009e-01f, 5.87825999e-02f, -9.63067040e-02f, -6.04238287e-02f, 2.89436072e-01f, 4.45533872e-01f, -3.34529169e-02f, 2.24703446e-01f,
  1.85723856e-01f, 1.44163311e-01f, 2.21790835e-01f, -2.37346087e-02f, 3.52172226e-01f, 4.72072959e-01f, 2.19136365e-02f, 6.56770840e-02f, -8.70210771e-03f, 6.99514076e-02f,
  3.44092965e-01f, 1.80155709e-01f, 2.92928338e-01f, -2.49510527e-01f, 1.81613654e-01f, 4.99913543e-02f, -4.57820654e-01f, -5.88323083e-03f, -8.40130523e-02f, -1.05197527e-01f,
  -1.39102995e-01f, 1.19996622e-01f, 2.17418507e-01f, -3.24843854e-01f, -8.10357928e-03f, -2.12996960e-01f, -1.48643360e-01f, 9.71248373e-02f, 1.75108165e-01f, 1.33409292e-01f,
  -1.46766588e-01f, 1.70495093e-01f, -2.81637341e-01f, 9.41207036e-02f, 2.41138324e-01f, 9.77298021e-02f, 1.03017144e-01f, 1.36258349e-01f, 1.95778549e-01f, -1.96241111e-01f,
  -1.39486060e-01f, 1.95692047e-01f, 6.63309917e-02f, -9.72242504e-02f, 1.08351238e-01f, -1.40972465e-01f, 1.80250313e-02f, 3.93372774e-01f, 1.36420146e-01f, -1.18512101e-01f,
  -1.11698925e-01f, 1.34088516e-01f, 1.68294366e-02f, 2.09968761e-01f, 4.28553149e-02f, 1.04906857e-01f, -3.34633082e-01f, -4.31750752e-02f, -1.13168448e-01f, -2.62283057e-01f,
  -7.24127367e-02f, 7.75172785e-02f, 1.64615646e-01f, 1.96462385e-02f, 7.95342997e-02f, 2.88744628e-01f, -2.15160176e-02f, 2.64673799e-01f, -2.44764630e-02f, 1.67541474e-01f,
  9.60109010e-02f, -8.76332372e-02f, 6.75980151e-02f, 5.67315891e-02f, 1.01311237e-01f, -4.91687953e-02f, 3.19904387e-01f, 3.00581828e-02f, 1.37095004e-01f, -6.47912100e-02f,
  -1.76702023e-01f, 1.62721366e-01f, -5.72904646e-02f, -1.61492556e-01f, 6.76092226e-03f, -7.23324493e-02f, 3.25409248e-02f, -1.90728754e-01f, 1.06823042e-01f, -2.83823639e-01f,
  -1.43997416e-01f, -1.57823652e-01f, 4.41443585e-02f, -7.76489079e-02f, -5.65815508e-01f, 8.91818628e-02f, -4.07996058e-01f, 7.43885711e-02f, 3.05424929e-01f, 2.00253993e-01f,
  -5.21835033e-03f, 2.06672728e-01f, 3.55659276e-01f, -1.44223377e-01f, 4.13898081e-02f, 3.30689639e-01f, -3.15129086e-02f, 1.71206877e-01f, 2.39527941e-01f, -5.86064979e-02f,
  1.99333936e-01f, 1.71477839e-01f, 1.84375286e-01f, 8.53459090e-02f, -8.52361023e-02f, 7.37183243e-02f, 1.62788138e-01f, 1.86930522e-01f, -3.40478448e-03f, -1.54283822e-01f,
  -3.48584987e-02f, -7.27669820e-02f, -1.11049436e-01f, -1.63093030e-01f, 1.04874156e-01f, 4.56843115e-02f, 1.12837255e-01f, 8.97639841e-02f, -8.98707360e-02f, 2.39304930e-01f,
  3.58731359e-01f, 1.11003995e-01f, 3.10097575e-01f, 1.55248836e-01f, 1.74037933e-01f, 2.44196936e-01f, 2.07886666e-01f, -2.54162490e-01f, 1.00526191e-01f, 2.95860022e-01f,
  9.10201818e-02f, -2.94063538e-01f, -2.44952992e-01f, -5.99268861e-02f, -9.22838748e-02f, 5.73312119e-02f, 3.70994397e-02f, 1.77124500e-01f, 7.43440986e-02f, -7.40863383e-02f,
  1.49461825e-03f, -2.19592273e-01f, 1.67901203e-01f, 1.64415345e-01f, -7.24991458e-03f, -1.11699678e-01f, 2.45648414e-01f, -6.46280125e-02f, 5.31152964e-01f, 4.92443293e-01f,
  -2.64742263e-02f, -1.34051079e-02f, 3.07774022e-02f, -1.76103949e-03f, -1.52481213e-01f, -7.83963725e-02f, 1.18537620e-01f, -3.00810099e-01f, -2.02865303e-01f, 1.45267695e-02f,
  2.09210627e-02f, -4.26185206e-02f, 1.89403817e-01f, -5.16933426e-02f, 5.42955510e-02f, 3.48123372e-01f, 1.91988736e-01f, -1.59271598e-01f, 9.70441177e-02f, -1.11248031e-01f,
  8.58759135e-02f, 2.58221716e-01f, 3.14489424e-01f, -1.93482183e-03f, 4.33105715e-02f, -3.72935325e-01f, 1.28690273e-01f, 2.77201105e-02f, 6.95180446e-02f, 1.78114399e-01f,
  4.24804129e-02f, -1.27334058e-01f, 1.28268570e-01f, 1.39109105e-01f, 1.35321766e-01f, 1.98627487e-01f, 2.65648607e-02f, 9.97152403e-02f, 3.98694947e-02f, -1.34893451e-02f,
  3.33884880e-02f, 3.82681757e-01f, 1.61548823e-01f, -4.94176261e-02f, -2.98303198e-02f, 1.59854606e-01f, 2.93007523e-01f, -1.09165259e-01f, -2.18118817e-01f, 1.81659609e-01f,
  -4.30859745e-01f, -4.35483724e-01f, -3.14432681e-01f, -9.40170661e-02f, -1.00595683e-01f, 4.97376062e-02f, -3.88236418e-02f, -1.79031655e-01f, -1.26607850e-01f, 2.06208870e-01f,
  1.37834549e-01f, 8.23130831e-02f, -6.12404309e-02f, 6.30850270e-02f, -2.80978858e-01f, -2.87324786e-01f, 2.30119079e-01f, 1.31204978e-01f, -2.17078805e-01f, -3.99391711e-01f,
  2.58932263e-01f, -6.27699792e-02f, 4.20943826e-01f, 1.78584903e-01f, 8.05383027e-02f, -2.96331167e-01f, -2.89903790e-01f, 2.21377492e-01f, -4.56628412e-01f, -4.38873507e-02f,
  -1.40666768e-01f, 2.47039124e-02f, -5.61474673e-02f, 2.79941022e-01f, -2.34067105e-02f, -2.39407897e-01f, -1.36282220e-01f, 1.04099564e-01f, -5.42343110e-02f, 1.15441084e-01f,
  9.03325975e-02f, -4.98505980e-02f, 1.00214809e-01f, 1.54675484e-01f, 3.61316144e-01f, 1.35022625e-01f, 2.96658538e-02f, 1.06914118e-01f, 9.83844697e-02f, 1.65061727e-01f,
  -6.28552064e-02f, 1.34104580e-01f, 9.51720700e-02f, 4.12503891e-02f, -3.23867612e-02f, -1.40535504e-01f, -3.09169024e-01f, 2.63273478e-01f, 4.35213327e-01f, 5.11529930e-02f,
  -5.42447448e-01f, -3.18907797e-01f, 3.53186816e-01f, -1.62208024e-02f, 3.98869574e-01f, 1.85638979e-01f, 3.16905588e-01f, 2.52389722e-02f, -4.96874657e-03f, 2.73143332e-02f,
  -3.34965944e-01f, 2.56743073e-01f, -6.59452658e-03f, -2.74692386e-01f, 1.49579659e-01f, 4.28778827e-02f, 1.85128376e-01f, 5.07417545e-02f, 3.76514971e-01f, 2.93957502e-01f,
  -4.84886855e-01f, -2.61501044e-01f, -4.96281609e-02f, 4.80119474e-02f, -7.86341131e-02f, 3.93587857e-01f, -3.42878789e-01f, -7.58393034e-02f, 4.77911718e-02f, 9.39919353e-02f,
  6.94794953e-02f, 4.26570594e-01f, 1.80941343e-01f, -2.76141539e-02f, -9.24894363e-02f, -1.57399952e-01f, -7.88540766e-02f, -1.58232093e-01f, 4.40394655e-02f, 2.25354388e-01f,
  1.56978324e-01f, -8.60450640e-02f, 4.05260980e-01f, 7.18843937e-02f, -2.38796309e-01f, 1.12116337e-01f, 7.19741657e-02f, 5.70896447e-01f, 3.64932537e-01f, 1.76617980e-01f,
  -2.73488183e-02f, -1.56849474e-01f, -3.37866805e-02f, 3.76303136e-01f, 1.62179381e-01f, 1.99247554e-01f, -1.82528585e-01f, 1.26654491e-01f, -2.80910611e-01f, -4.58948523e-01f,
  2.65598744e-01f, 1.69870108e-01f, 2.79603839e-01f, -2.33555213e-01f, -1.67533100e-01f, -1.45494804e-01f, 3.04788560e-01f, -3.88829410e-01f, -4.29807082e-02f, -2.97324032e-01f,
  -1.52508467e-01f, -1.26830012e-01f, -1.06123630e-02f, -1.59006163e-01f, 7.99400732e-02f, -8.79968852e-02f, 6.61043152e-02f, 1.42732501e-01f, -8.98660123e-02f, -3.33965458e-02f,
  7.73420855e-02f, 2.58296579e-01f, -1.19101100e-01f, 2.86516398e-01f, -1.94972739e-01f, -6.83845580e-02f, 1.95619330e-01f, -1.34957165e-01f, 6.19483814e-02f, -7.36658424e-02f,
  -4.65512313e-02f, 4.59338538e-02f, 2.97856145e-03f, 1.06443994e-01f, 1.32844806e-01f, 1.36743024e-01f, -1.17132422e-02f, 1.72652021e-01f, 1.78944971e-02f, 2.68599484e-02f,
  -8.22478905e-02f, 2.09232464e-01f, -1.13089859e-01f, 3.74856628e-02f, -3.34975421e-02f, -8.58282298e-02f, -1.60629347e-01f, 4.43287864e-02f, -1.74941290e-02f, -3.96856934e-01f,
  1.18313231e-01f, -3.53951752e-01f, -2.83580661e-01f, 1.36276141e-01f, -7.74495630e-03f, -3.02117970e-02f, 2.10506842e-01f, -3.29667568e-01f, -1.59005463e-01f, -3.02215070e-01f,
  2.13625953e-01f, 1.78688705e-01f, 6.57803789e-02f, 6.56911805e-02f, -3.04752350e-01f, 1.55967236e-01f, -4.58172709e-01f, 2.58397907e-01f, 1.47365093e-01f, -2.29937229e-02f,
  -6.40745983e-02f, 3.78464758e-01f, -5.98504432e-02f, 1.51306137e-01f, 2.38951817e-01f, 2.32352465e-01f, -2.81215131e-01f, 1.32195741e-01f, -2.71333270e-02f, 2.45135710e-01f,
  7.30226412e-02f, 2.08502576e-01f, -9.66697186e-03f, 2.51711309e-01f, 1.98570505e-01f, 1.54183343e-01f, 1.72575608e-01f, -3.11973602e-01f, -1.08680189e-01f, 1.66514397e-01f,
  5.31235933e-02f, -1.29073225e-02f, 1.12820089e-01f, -3.68919671e-01f, 9.59329773e-03f, -7.99426511e-02f, 1.50837183e-01f, 1.41205817e-01f, -1.81738827e-02f, -4.21574175e-01f,
  2.88938433e-02f, 7.20124617e-02f, -1.53719783e-02f, 1.21248379e-01f, 2.78013080e-01f, -5.68024404e-02f, 7.01417625e-02f, -2.24267811e-01f, 1.86857134e-01f, 2.24038959e-01f,
  -6.39747679e-02f, 1.76861733e-01f, 2.31512889e-01f, 1.10881247e-01f, -2.20013976e-01f, -1.64106786e-02f, 3.36982787e-01f, -8.70104358e-02f, 9.43791941e-02f, -1.14850558e-01f,
  1.21318676e-01f, -3.90289389e-02f, -2.71689862e-01f, -3.03816378e-01f, 2.01268449e-01f, -1.72782496e-01f, 1.38067082e-03f, 1.14148790e-02f, -9.71464738e-02f, 2.15551667e-02f,
  -1.47229984e-01f, 2.37545580e-01f, 2.14976817e-01f, -1.36460438e-01f, 1.01721779e-01f, 8.70179608e-02f, -2.56056696e-01f, -2.94640899e-01f, -3.73085976e-01f, -1.52979523e-01f,
  -1.98958009e-01f, 1.20952679e-02f, 6.51522633e-03f, -4.93569314e-01f, -1.13175742e-01f, 4.22209084e-01f, -3.25010717e-02f, 1.18262082e-01f, -2.90662289e-01f, 2.02612102e-01f,
  -2.70481139e-01f, -2.33339876e-01f, 7.87761435e-02f, -2.71177012e-03f, 6.93922043e-02f, -6.53625429e-02f, 1.41083315e-01f, 6.73620105e-02f, 2.94271559e-01f, 2.23039553e-01f,
  -2.38228645e-02f, -1.59315974e-01f, -1.20482765e-01f, -4.53819185e-01f, -3.21863055e-01f, 1.53123841e-01f, 9.90527216e-03f, 3.49207632e-02f, 4.17284854e-02f, 6.43979460e-02f,
  -1.40421987e-01f, -2.27537557e-01f, -9.54594165e-02f, -1.56195596e-01f, -5.14940381e-01f, 2.63067573e-01f, 3.05760294e-01f, -4.08678828e-03f, 1.68697789e-01f, -1.85035825e-01f,
  9.03874785e-02f, 9.14520323e-02f, -9.79953259e-03f, -1.83297917e-01f, -2.13193968e-01f, 7.22900257e-02f, -1.55498192e-01f, -3.53267938e-01f, -6.63820058e-02f, -8.69554933e-03f,
  1.00680981e-02f, 1.08022332e-01f, 2.82417506e-01f, -2.21696332e-01f, 1.25999957e-01f, 6.79453015e-02f, 2.14056134e-01f, 3.22547406e-01f, 4.35610451e-02f, -1.44456932e-02f,
  -6.78456202e-02f, 1.08807549e-01f, 6.60272315e-02f, 1.25186712e-01f, 8.12197179e-02f, 8.06048065e-02f, -3.25037204e-02f, -2.42640972e-01f, 7.29093095e-03f, -1.28796443e-01f,
  -3.25494945e-01f, 2.35350981e-01f, -2.30272666e-01f, -4.04764235e-01f, -2.20884040e-01f, 1.28448591e-01f, -2.07674634e-02f, -1.94823787e-01f, 8.01203102e-02f, 1.99681133e-01f,
  -4.69693691e-02f, 9.81837288e-02f, 1.60732299e-01f, 9.06854589e-03f, 5.97718470e-02f, -4.41653617e-02f, 4.94317152e-02f, -2.51333099e-02f, -2.13654456e-03f, -1.15211323e-01f,
  -4.58896123e-02f, 1.84510335e-01f, 1.51420519e-01f, 2.01048315e-01f, 1.32553667e-01f, 1.97018459e-01f, -1.13669999e-01f, 1.37923658e-01f, 1.16607994e-01f, -1.04711354e-02f,
  9.94692296e-02f, 4.83792834e-02f, -1.44150123e-01f, -5.17099127e-02f, -4.46565337e-02f, 1.02648258e-01f, -4.67448719e-02f, 1.72225777e-02f, -1.78882346e-01f, 1.31410599e-01f,
  -1.92005485e-01f, -3.46255481e-01f, 3.33881788e-02f, -1.35231642e-02f, -3.29725705e-02f, 1.28876626e-01f, 2.35371634e-01f, -3.28951031e-01f, -1.36957929e-01f, 1.92790404e-01f,
  3.40477705e-01f, 2.11162969e-01f, -1.86158150e-01f, -6.25100657e-02f, -2.82841682e-01f, -1.14509888e-01f, 6.10258505e-02f, 2.13188276e-01f, 2.11238652e-01f, 8.91709700e-02f,
  2.85070181e-01f, -2.65828520e-01f, 3.34628299e-02f, 3.33546668e-01f, -2.39397272e-01f, 2.33586788e-01f, -3.32454383e-01f, -1.50093347e-01f, -2.71243274e-01f, -3.74641432e-03f,
  2.94440240e-01f, 7.03554600e-02f, 9.06251147e-02f, 1.82886541e-01f, 2.46789232e-01f, -3.11666019e-02f, 1.29203033e-02f, -3.47098522e-02f, -6.93574846e-02f, 1.78622410e-01f,
  2.51207173e-01f, -2.26053998e-01f, 7.20564090e-03f, 2.02890038e-02f, -1.31808976e-02f, 2.01592177e-01f, 2.88441122e-01f, 1.44016340e-01f, 2.44832024e-01f, 3.25459689e-02f,
  -1.51135907e-01f, 1.74923986e-02f, -3.10224503e-01f, 9.44234654e-02f, 1.91021264e-01f, 8.13381597e-02f, 1.09022267e-01f, -4.77160960e-01f, -9.48897824e-02f, 1.06474655e-02f,
  -3.44462059e-02f, 2.73877215e-02f, 1.72507867e-01f, -3.27050984e-02f, 5.18025039e-03f, 1.01162875e-02f, 3.20739508e-01f, 9.58820730e-02f, -1.05835959e-01f, -2.43499614e-02f,
  -4.28250760e-01f, -6.38444722e-03f, -2.42745608e-01f, 1.15287155e-01f, -2.93397009e-01f, 6.98064044e-02f, 2.06479490e-01f, 3.76216888e-01f, 4.31160420e-01f, 5.13972163e-01f,
  3.12690794e-01f, 2.95974672e-01f, -1.48859322e-01f, 1.32322177e-01f, 4.78546321e-02f, 4.07639116e-01f, 3.08605671e-01f, -6.91179559e-02f, 1.40926778e-01f, 2.11154427e-02f,
  1.01663815e-02f, 2.33160749e-01f, 2.13300571e-01f, 3.99508793e-03f, -2.10631937e-01f, -2.88775060e-02f, 3.08972932e-02f, 1.30914211e-01f, -8.36184900e-03f, 1.03228301e-01f,
  -7.21093789e-02f, -7.70558044e-02f, 9.03216936e-03f, 1.13516159e-01f, -6.79586530e-02f, 8.38253945e-02f, 1.53601825e-01f, -3.39663364e-02f, -8.25195201e-03f, 1.19949698e-01f,
  2.51530409e-01f, -5.98788634e-02f, 1.89818174e-01f, -2.43214630e-02f, 2.47310892e-01f, 1.13595217e-01f, 1.89803630e-01f, -1.75823048e-02f, 2.03430653e-02f, 1.54317498e-01f,
  2.63958484e-01f, 1.69282734e-01f, 7.73997307e-02f, 3.95580418e-02f, 2.38372907e-01f, 9.10671428e-02f, 8.15236196e-02f, -1.53122827e-01f, 9.80380699e-02f, 1.02401569e-01f,
  2.50288583e-02f, 2.84522802e-01f, -1.55885667e-01f, -2.78143883e-01f, 2.06077412e-01f, -1.19952939e-01f, -9.45527703e-02f, -1.29125252e-01f, 2.45507360e-01f, -6.57953415e-03f,
  1.59410581e-01f, -2.32834131e-01f, 1.97726086e-01f, 3.58710766e-01f, -4.97972332e-02f, 6.77367449e-02f, -2.06435863e-02f, 1.73922151e-01f, 3.54671553e-02f, -4.81338233e-01f,
  -8.09225217e-02f, -1.60474807e-01f, -6.84442520e-02f, 1.68621272e-01f, -2.74308950e-01f, 1.05342753e-01f, -3.12614232e-01f, -8.23912695e-02f, 1.72007725e-01f, 1.33905159e-02f,
  6.56963140e-02f, 1.38954163e-01f, 5.36374636e-02f, -7.67574236e-02f, -2.49805421e-01f, 2.45267481e-01f, 3.18288893e-01f, 1.17689632e-01f, 1.82165921e-01f, -8.34754631e-02f,
  6.76724613e-02f, 1.33121699e-01f, 2.86643595e-01f, 1.28536462e-03f, 1.74254686e-01f, 1.32804304e-01f, 4.83908579e-02f, 9.80849043e-02f, 1.42057821e-01f, -1.42177604e-02f,
  -9.51890573e-02f, 1.94288373e-01f, 5.98591305e-02f, 1.79331601e-01f, 1.46935508e-01f, -2.19975952e-02f, -2.40085647e-02f, 2.66069099e-02f, 8.45689252e-02f, 1.35267600e-02f,
  -5.43431193e-03f, -3.11858952e-01f, -5.02597215e-03f, 1.29978759e-02f, 3.25270236e-01f, 2.01401338e-01f, 1.41854048e-01f, -2.89219588e-01f, -4.12666351e-01f, 2.02822670e-01f,
  1.14028402e-01f, 8.26207399e-02f, -1.31019533e-01f, -2.01232553e-01f, 1.00368485e-01f, 1.98354602e-01f, 1.60780028e-01f, 1.73094049e-01f, 1.02269106e-01f, -1.04006961e-01f,
  -1.96682081e-01f, 7.13726953e-02f, -1.05910011e-01f, 2.41588578e-01f, -8.05494003e-03f, -1.52875558e-01f, 2.15578213e-01f, -5.61234318e-02f, -2.76436508e-01f, 1.48679763e-01f,
  4.30652015e-02f, 2.55372897e-02f, 2.30573073e-01f, 6.49138466e-02f, -7.99907520e-02f, -1.46890461e-01f, 1.50087342e-01f, -1.61384672e-01f, -6.81921691e-02f, 2.88279951e-01f,
  7.55743757e-02f, 5.32454848e-02f, 1.21139184e-01f, 1.83156803e-01f, -1.34985253e-01f, 1.11112535e-01f, 1.61190718e-01f, -1.42643666e-02f, -1.29238144e-01f, -2.63802797e-01f,
  1.30349517e-01f, -8.59699473e-02f, 3.59589487e-01f, -1.46952808e-01f, -5.58114946e-02f, -3.21382061e-02f, 3.64372209e-02f, 1.05953656e-01f, 4.54887226e-02f, -2.53473707e-02f,
  -5.37491962e-02f, -2.37166584e-02f, 3.49765979e-02f, 1.46095930e-02f, -7.05857351e-02f, -2.13798583e-02f, -6.01790138e-02f, -3.35379899e-01f, 1.02455616e-01f, -1.18472442e-01f,
  -1.58800557e-01f, 2.52181739e-01f, -2.67808735e-01f, -4.68667597e-02f, 1.70967624e-01f, 1.98718682e-01f, 2.24497482e-01f, -2.34631851e-01f, -3.15858275e-01f, 1.92864552e-01f,
  -3.05337518e-01f, -9.71139520e-02f, -1.22659071e-03f, -1.23117045e-01f, -2.96603739e-01f, 4.48402762e-02f, -2.25544900e-01f, 2.23590031e-01f, 2.24185884e-01f, -1.25446796e-01f,
  4.81817238e-02f, -1.12434648e-01f, 2.49525130e-01f, 4.49536592e-02f, 2.59383917e-01f, -3.86509120e-01f, 1.64239317e-01f, 3.06515813e-01f, 3.07775110e-01f, -3.43137592e-01f,
  8.85513574e-02f, -1.86627746e-01f, 1.16454445e-01f, -7.05398396e-02f, 1.60880104e-01f, 6.44294322e-02f, 1.48718253e-01f, 1.45871654e-01f, -3.85142624e-01f, -1.66142955e-01f,
  -6.98952824e-02f, 1.78886577e-01f, 1.54278455e-02f, 4.18982431e-02f, 7.51035213e-02f, -2.33131215e-01f, 1.03120051e-01f, -2.00507924e-01f, -6.96307197e-02f, 4.72258292e-02f,
  3.22190732e-01f, 1.20406738e-02f, -2.51779761e-02f, 1.51213212e-02f, -8.84040669e-02f, 1.98362872e-01f, 3.26528102e-02f, 9.15687457e-02f, 3.17415446e-01f, 6.70293719e-02f,
  6.17484655e-03f, 6.96227094e-03f, -1.07232332e-01f, 2.74686486e-01f, 3.42356056e-01f, 2.48261899e-01f, 1.41753688e-01f, 1.22059941e-01f, -2.99694359e-01f, 2.88098872e-01f,
  2.96209008e-01f, 3.14858317e-01f, -3.10441822e-01f, 1.52180076e-01f, -4.44262981e-01f, -2.93045819e-01f, -3.99235308e-01f, 1.76171940e-02f, 9.50384140e-03f, 1.90952867e-01f,
  5.11825010e-02f, -1.10037766e-01f, 2.28718016e-02f, 1.80382550e-01f, -1.19436637e-01f, 1.43782496e-01f, 2.08229259e-01f, -7.54474252e-02f, -1.50617659e-01f, -5.43325007e-01f,
  1.36680096e-01f, 6.60196915e-02f, -1.85972378e-01f, -2.77283758e-01f, -1.09654695e-01f, -1.68866426e-01f, 2.54525810e-01f, -3.44734527e-02f, 5.94698526e-02f, -2.46624336e-01f,
  1.84701458e-02f, -4.94815350e-01f, -5.97245574e-01f, 9.26994681e-02f, 1.01790547e-01f, -2.50835381e-02f, -6.90559968e-02f, 1.46687016e-01f, -2.50773311e-01f, -5.43411136e-01f,
  1.23985879e-01f, 2.41791621e-01f, 1.19072787e-01f, 7.54462704e-02f, 1.77649289e-01f, 1.29919693e-01f, 1.64853647e-01f, 2.15281159e-01f, 3.39680344e-01f, 1.53050601e-01f,
  1.45620361e-01f, 4.40224446e-02f, -1.24902809e-02f, 2.43934020e-01f, 2.18747735e-01f, 4.32634391e-02f, -1.41096324e-01f, 1.94222242e-01f, 2.63295770e-02f, 2.70055175e-01f,
  2.81925023e-01f, 1.74074590e-01f, 6.20219171e-01f, -3.22857164e-02f, 3.21538359e-01f, -5.16525023e-02f, -8.95780027e-02f, -3.87662128e-02f, -8.88497457e-02f, -1.92761913e-01f,
  -1.74720570e-01f, 1.99879389e-02f, -5.15038371e-02f, 9.75316390e-02f, -4.19135660e-01f, -3.75847638e-01f, -3.84958386e-02f, -2.01349363e-01f, 3.40593576e-01f, 1.26543552e-01f,
  -3.44935119e-01f, -1.42834753e-01f, -2.13666156e-01f, 1.62852332e-01f, 2.51513809e-01f, 9.55135375e-03f, 1.62637055e-01f, 1.38623670e-01f, 3.62473190e-01f, 1.28889516e-01f,
  6.97675049e-02f, 9.75972041e-02f, 2.25567684e-01f, -1.81242734e-01f, 3.61438096e-02f, 3.13748628e-01f, 1.03404082e-01f, 5.70235923e-02f, -3.31199132e-02f, 1.52117843e-02f,
  -3.82523984e-02f, 2.01709524e-01f, -1.46667525e-01f, 1.15091920e-01f, 1.59899367e-03f, -2.79478818e-01f, 2.46689215e-01f, 2.62273233e-02f, -9.56367999e-02f, -8.23353380e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 40)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 40;
const float L2_fan_Bp_bar_data[] = {
  6.34718686e-02f, -1.98294334e-02f, -2.03505065e-02f, 2.63490766e-01f, 1.64260104e-01f, -3.44753899e-02f, 2.40287796e-01f, 4.72492799e-02f, 6.11234754e-02f, 1.93377614e-01f,
  2.04547286e-01f, 2.33836010e-01f, 1.38286442e-01f, 6.30338639e-02f, 1.66005373e-01f, 7.06869140e-02f, 3.59041728e-02f, 1.57629952e-01f, 1.70781806e-01f, 9.75389704e-02f,
  1.79405078e-01f, -8.41420963e-02f, 1.02997698e-01f, 1.50990516e-01f, 2.99881585e-02f, -2.62320478e-04f, 2.15356976e-01f, 9.86453369e-02f, 3.30265164e-02f, -8.17494467e-03f,
  1.13720626e-01f, 5.41940071e-02f, -3.28573957e-02f, 7.87458271e-02f, 2.21896663e-01f, 8.08702558e-02f, 8.83323550e-02f, 1.23106971e-01f, 2.84715742e-02f, 1.37474492e-01f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  -1.63293988e-01f, -1.97670236e-01f, -6.39580339e-02f, 5.44186570e-02f, -1.66797236e-01f, -2.46689558e-01f, -1.32229954e-01f, -1.99510783e-01f, 1.44616663e-01f, -4.23157573e-01f,
  -3.79167885e-01f, -1.00806676e-01f, -1.29650488e-01f, 5.09554408e-02f, -1.12565108e-01f, 2.11195976e-01f, -7.39811212e-02f, 8.62009078e-02f, 9.08215493e-02f, -2.71089107e-01f,
  1.91375818e-02f, -1.35424316e-01f, -1.62159786e-01f, 2.79131532e-01f, -2.52468258e-01f, 1.62284538e-01f, 1.82053610e-03f, -4.20022428e-01f, -1.70001108e-03f, -2.92421311e-01f,
  -6.26032293e-01f, 8.22864026e-02f, 2.15212926e-01f, 8.94619375e-02f, -3.50444138e-01f, -3.94373387e-01f, -2.30395019e-01f, 1.85669869e-01f, -1.30996436e-01f, -3.88486981e-01f,
  8.37185830e-02f, -2.26430938e-01f, -4.50446010e-01f, -4.14694548e-02f, 9.59504470e-02f, 2.25863546e-01f, 1.10025153e-01f, -2.85217483e-02f, -2.25076541e-01f, 1.64627090e-01f,
  -3.39822769e-01f, -9.07640159e-02f, 1.12414859e-01f, -2.13253573e-01f, -1.54307023e-01f, -5.39477132e-02f, 1.91898659e-01f, 1.74335629e-01f, 1.19654506e-01f, -8.74686316e-02f,
  -2.47829184e-01f, -6.80498302e-01f, 1.62550081e-02f, -8.01631212e-02f, 9.70293283e-02f, 6.02508057e-03f, 2.89087296e-02f, 5.59205413e-02f, -3.91891062e-01f, -2.57641245e-02f,
  2.21061543e-01f, -8.49717557e-02f, 2.14206466e-05f, -5.44309132e-02f, -1.14898913e-01f, -2.32192144e-01f, 3.50376904e-01f, 2.63322651e-01f, 5.02088130e-01f, -4.35425974e-02f,
  2.65478641e-01f, -1.81749836e-01f, -3.37029308e-01f, 1.13270074e-01f, -3.24137479e-01f, -3.07239573e-02f, 1.61954179e-01f, -1.72659770e-01f, 2.88775787e-02f, 1.02845229e-01f,
  -2.97399133e-01f, -3.89959276e-01f, 1.90181971e-01f, 5.14617823e-02f, -4.21150744e-01f, 5.20896353e-02f, 2.55171090e-01f, 1.97373942e-01f, 1.59502268e-01f, -3.89548659e-01f,
  8.53757039e-02f, 8.62926543e-02f, 1.54500708e-01f, 2.01933548e-01f, 1.27746060e-01f, -2.72648662e-01f, -2.55077213e-01f, -2.87146699e-02f, -5.72563102e-03f, -3.83787960e-01f,
  2.12747842e-01f, -3.89485687e-01f, -1.45776927e-01f, -2.97720581e-01f, -3.92735749e-01f, -9.95132178e-02f, -4.47301626e-01f, -8.53958577e-02f, 1.01812497e-01f, -1.08671993e-01f,
  2.52868295e-01f, 2.23042428e-01f, 7.11020082e-02f, 1.57326728e-01f, -3.85236926e-02f, -2.97016837e-02f, 1.57884389e-01f, 1.33083358e-01f, 3.27935994e-01f, 2.41809800e-01f,
  -1.93971973e-02f, 9.70641896e-02f, -7.07817003e-02f, 3.06270495e-02f, 9.60855410e-02f, 4.70735840e-02f, 2.23953798e-01f, -1.59229804e-02f, 1.82862524e-02f, 1.99463040e-01f,
  -2.32956886e-01f, 4.31263417e-01f, 9.31911245e-02f, 4.82460931e-02f, 4.31325957e-02f, 9.13699865e-02f, -3.21749121e-01f, 1.74777523e-01f, 1.54663831e-01f, 2.21989810e-01f,
  -2.07150817e-01f, 6.87629580e-02f, -8.02040622e-02f, 5.12846000e-02f, 7.23741725e-02f, -4.44158167e-01f, 1.08924888e-01f, 1.79427750e-02f, -5.79268575e-01f, -1.77197486e-01f,
  -2.14683741e-01f, 3.36456358e-01f, -1.09308019e-01f, -9.49517067e-04f, -3.41707885e-01f, -1.51120096e-01f, -3.27668786e-01f, 5.67017719e-02f, 1.92667931e-01f, -1.87277898e-01f,
  -4.07045305e-01f, 8.82382989e-02f, 2.05168232e-01f, -3.96908462e-01f, -7.26942196e-02f, 1.94236860e-01f, -1.22126147e-01f, 8.31834823e-02f, 2.22423673e-01f, -1.12794258e-01f,
  -6.79102689e-02f, -3.82941067e-01f, 2.34444618e-01f, -1.94631573e-02f, -1.08597197e-01f, -8.39737728e-02f, 3.05421859e-01f, 1.11272492e-01f, 3.21299672e-01f, -5.72682381e-01f,
  -2.42089093e-01f, -4.83866423e-01f, -1.27506882e-01f, 1.58851638e-01f, 2.60814220e-01f, -8.24998319e-02f, 2.58401453e-01f, 4.76364717e-02f, 1.35323495e-01f, 2.10315064e-01f,
  -1.48747697e-01f, 6.73996285e-02f, -7.59997740e-02f, 1.13876395e-01f, -3.29512991e-02f, 1.86891705e-01f, -2.60790922e-02f, -3.00625592e-01f, 1.54937645e-02f, -2.61196077e-01f,
  2.48468310e-01f, -1.63708329e-01f, -1.15849255e-02f, -7.72777870e-02f, 2.34458014e-01f, 2.51086466e-02f, -1.04502492e-01f, -2.24760294e-01f, 2.19002604e-01f, -2.44374618e-01f,
  2.45878175e-01f, -2.75358677e-01f, -2.51846284e-01f, -3.90737981e-01f, 1.91347986e-01f, -8.83935913e-02f, -3.54610294e-01f, 2.55141884e-01f, -4.51424755e-02f, -2.87873894e-01f,
  5.79074882e-02f, -1.74047396e-01f, -1.01290986e-01f, 3.17523293e-02f, -6.48770407e-02f, -1.69555679e-01f, 1.45456284e-01f, 1.47107348e-01f, -5.14788032e-02f, -1.59372598e-01f,
  -4.83439207e-01f, -3.46129715e-01f, -1.40932515e-01f, -1.53951183e-01f, 1.84026182e-01f, -5.77074885e-02f, -3.47865105e-01f, -1.77359506e-01f, -9.53960270e-02f, -4.98130053e-01f,
  2.12856799e-01f, -2.77065635e-01f, 1.23405725e-01f, -4.58587736e-01f, 4.63574333e-03f, -1.77767247e-01f, 1.20693900e-01f, -7.07841367e-02f, -2.45379925e-01f, 1.73252776e-01f,
  1.87092736e-01f, 8.89673382e-02f, -2.99993813e-01f, 2.13326752e-01f, -1.49487033e-01f, 6.97824433e-02f, -4.77854908e-02f, -5.43870479e-02f, -1.01372391e-01f, -5.06927073e-01f,
  -6.80215657e-02f, -3.61995012e-01f, 1.97177365e-01f, 2.13436365e-01f, 1.14475764e-01f, 1.31794497e-01f, -1.55340359e-01f, 1.33135691e-04f, 2.98652083e-01f, -8.95070210e-02f,
  -3.66914123e-01f, 1.23591714e-01f, -8.19723904e-02f, -1.64083242e-01f, 1.94802150e-01f, -2.04660714e-01f, 7.38944188e-02f, 8.33875462e-02f, -6.13973625e-02f, -3.16126108e-01f,
  -1.15435459e-02f, -1.21568926e-02f, -7.10086077e-02f, 9.04956013e-02f, -2.16644928e-02f, -2.30636731e-01f, 1.57650054e-01f, -2.74447709e-01f, 4.12265025e-02f, -3.97131026e-01f,
  6.03664815e-02f, 1.96753472e-01f, -4.55772251e-01f, 2.87338555e-01f, 1.21267207e-01f, -1.67916790e-02f, 3.59359272e-02f, -1.83856502e-01f, 1.56477988e-01f, 2.61625171e-01f,
  -1.32567272e-01f, -2.04839557e-01f, 4.89448495e-02f, -3.02359104e-01f, -4.51915450e-02f, 1.68852687e-01f, -1.13246076e-01f, 1.02003001e-01f, -4.65314388e-02f, 3.07957470e-01f,
  -4.25944686e-01f, -1.34809420e-01f, 1.75980002e-01f, -7.96683803e-02f, 2.15275034e-01f, -2.79488396e-02f, 4.84056436e-02f, 2.47479200e-01f, -1.66916534e-01f, -1.91352412e-01f,
  1.69851080e-01f, 1.83575880e-02f, -5.99732399e-02f, 1.36187905e-02f, -3.04008722e-01f, -8.17837939e-02f, -3.71449552e-02f, -8.78215805e-02f, 1.50596455e-01f, -1.28680766e-01f,
  1.88277513e-01f, -1.72899947e-01f, 9.78031084e-02f, -2.68156886e-01f, 1.26958743e-01f, 1.29043579e-01f, -3.27164158e-02f, -5.84633052e-02f, -8.75343829e-02f, 4.64413427e-02f,
  2.48983398e-01f, 1.02801651e-01f, -1.75917342e-01f, 1.07954413e-01f, -2.74638057e-01f, 1.92311153e-01f, -2.33484507e-01f, 1.64248928e-01f, 6.61860183e-02f, 1.49064377e-01f,
  6.93441108e-02f, -2.50088304e-01f, -3.73916291e-02f, -2.98665553e-01f, 2.20835935e-02f, -9.05843899e-02f, 1.42645895e-01f, 5.38607687e-02f, 2.36882553e-01f, 1.32407472e-01f,
  -1.45014435e-01f, -2.16152892e-01f, -3.66049200e-01f, 2.73917109e-01f, -1.23513304e-01f, 6.78256303e-02f, 6.83015436e-02f, 1.92399547e-01f, -2.16878220e-01f, 4.20706347e-02f,
  -3.06138188e-01f, -4.40062806e-02f, -2.57901102e-01f, -2.93008611e-02f, 7.89401233e-02f, -8.45477208e-02f, 8.80793203e-03f, -1.20722279e-01f, 9.40851420e-02f, 1.94853637e-02f,
  -8.96193385e-02f, -1.85198918e-01f, -1.06101930e-02f, -8.63659158e-02f, -8.13009888e-02f, 1.43587543e-02f, -2.75656022e-02f, 1.21001966e-01f, -2.47782022e-01f, -2.18008813e-02f,
  -1.52141497e-01f, -2.77053714e-01f, 2.06825957e-02f, 1.79757580e-01f, 3.42921495e-01f, 2.35639870e-01f, -1.04680255e-01f, 5.31241819e-02f, 3.36588956e-02f, -3.31794620e-01f,
  -3.36655319e-01f, 1.34877205e-01f, -6.42224029e-02f, 2.84915101e-02f, 1.40225505e-02f, 1.88190509e-02f, -2.33314306e-01f, 1.30828962e-01f, 6.74812272e-02f, -3.68475646e-01f,
  -8.66030231e-02f, -4.94005904e-02f, -3.68509263e-01f, 1.72289476e-01f, -1.91803664e-01f, -2.15819761e-01f, 1.94356248e-01f, 1.42468244e-01f, -2.95305490e-01f, -5.58564328e-02f,
  -2.75825024e-01f, 8.85013714e-02f, 1.01591825e-01f, 8.21348578e-02f, -1.55659512e-01f, 2.37561941e-01f, -9.89302993e-02f, -5.41758398e-03f, 7.83646628e-02f, 4.59887028e-01f,
  -1.17441006e-01f, 1.87167764e-01f, -4.46855038e-01f, -7.56676914e-03f, 5.09183295e-02f, 1.48687333e-01f, 2.86817133e-01f, 1.36661008e-01f, 1.37783900e-01f, 1.15554780e-01f,
  2.98668668e-02f, -2.62473430e-02f, 3.38031054e-02f, 8.26292560e-02f, 2.94334125e-02f, -2.14277849e-01f, 9.14430544e-02f, 1.45727592e-02f, 8.31841379e-02f, -1.29697785e-01f,
  -2.37217262e-01f, 2.34395087e-01f, -9.22316164e-02f, 1.17531262e-01f, -1.87501028e-01f, 8.06947425e-02f, -6.17934316e-02f, 2.00892001e-01f, -1.09714858e-01f, 2.95671020e-02f,
  -3.27732414e-03f, 1.69446588e-01f, -3.40243042e-01f, 1.04550477e-02f, 2.69340992e-01f, 1.71525896e-01f, 1.04208507e-01f, -1.42492011e-01f, 4.66227904e-02f, 4.04113568e-02f,
  1.75134744e-02f, -3.03579897e-01f, 1.05951637e-01f, 1.56251967e-01f, -2.71138251e-01f, -3.05394772e-02f, -4.65373732e-02f, -3.61896120e-02f, -2.81679273e-01f, -4.54885066e-02f,
  -2.33164504e-01f, -2.68369038e-02f, -3.85816365e-01f, -4.50430334e-01f, -1.34753898e-01f, -3.19092512e-01f, -3.76056552e-01f, -2.94442236e-01f, 1.31577194e-01f, -1.03035182e-01f,
  1.57558464e-03f, -1.36641383e-01f, 2.49851286e-01f, -2.60702968e-01f, -1.10135771e-01f, -1.64057240e-01f, 1.73783347e-01f, -2.94200063e-01f, 1.53609142e-01f, 3.84031117e-01f,
  -6.28824979e-02f, -1.36396840e-01f, -2.85945266e-01f, 8.99608955e-02f, 4.07054685e-02f, 2.03048959e-01f, 1.56929612e-01f, 3.58205959e-02f, -1.12623483e-01f, -6.56726435e-02f,
  -3.34002823e-02f, -2.80407239e-02f, 1.76967874e-01f, 7.59211108e-02f, 5.99726290e-02f, -4.55525786e-01f, 4.91797784e-03f, -5.78891151e-02f, 2.90050749e-02f, -6.54908363e-03f,
  -1.15984865e-01f, -1.02901049e-01f, 4.03638154e-01f, -1.86307281e-01f, 3.00038248e-01f, 3.84879887e-01f, 2.26298377e-01f, 2.62468830e-02f, -1.64478108e-01f, 1.37730703e-01f,
  -1.40952066e-01f, -5.40907308e-02f, 2.87995249e-01f, 1.64441049e-01f, -3.08911979e-01f, 1.38965651e-01f, -3.91624160e-02f, -1.11536674e-01f, 2.62323916e-01f, -6.19674549e-02f,
  2.29646727e-01f, 2.05732927e-01f, -4.27430183e-01f, 2.46345788e-01f, 1.59912884e-01f, -2.11814210e-01f, -6.39209151e-01f, -1.72829852e-01f, 2.05302447e-01f, -3.44316065e-01f,
  4.69056504e-05f, -5.29416203e-01f, 4.72459197e-03f, 9.33796540e-02f, -1.35932222e-01f, -4.76903260e-01f, 6.82209283e-02f, -9.09177139e-02f, -7.06534386e-02f, -4.27118838e-02f,
  -1.24425806e-01f, -4.85498965e-01f, -1.35254323e-01f, -9.39176828e-02f, 4.66467142e-01f, -3.80838066e-01f, -3.85401808e-02f, 2.33942494e-01f, -1.40298650e-01f, -1.39293045e-01f,
  5.66541106e-02f, -6.23649396e-02f, 1.40938371e-01f, -2.63836738e-02f, 1.28406584e-01f, 2.21943602e-01f, -3.16203013e-02f, 6.15388937e-02f, 1.61638796e-01f, -1.26721591e-01f,
  3.40312421e-02f, 3.88227284e-01f, 6.55853897e-02f, 2.93081164e-01f, 2.29196817e-01f, 6.81998283e-02f, 3.04036617e-01f, 1.88017353e-01f, -2.01358780e-01f, 1.55349895e-01f,
  -2.18583807e-01f, 2.04490066e-01f, 4.95307930e-02f, 1.56128347e-01f, -5.09142101e-01f, -2.54959781e-02f, 1.79728910e-01f, 5.03714150e-03f, -4.47650105e-01f, -1.43620893e-01f,
  4.60747890e-02f, 1.75389186e-01f, -1.99660882e-01f, -2.73880333e-01f, -4.43033397e-01f, -2.18408853e-01f, 8.22652131e-02f, -1.74125254e-01f, -6.80793151e-02f, 2.36317202e-01f,
  -1.40937101e-02f, -5.75986683e-01f, -4.62893322e-02f, 2.27823868e-01f, 1.24468058e-01f, 2.13618606e-01f, 1.92508504e-01f, -2.55431861e-01f, -5.18410206e-01f, -2.13866651e-01f,
  -1.04821734e-01f, -4.33886856e-01f, -2.68725276e-01f, -1.39842117e-02f, -1.76863059e-01f, 1.81275517e-01f, 2.07956627e-01f, -6.89832717e-02f, -1.53847381e-01f, 1.27925277e-01f,
  3.56342271e-02f, 3.74886878e-02f, 8.69363025e-02f, -1.62047446e-01f, -2.65938103e-01f, -2.14729264e-01f, -1.55957669e-01f, -6.39664680e-02f, 1.50507808e-01f, -1.89513341e-02f,
  4.03988883e-02f, -4.05995809e-02f, 3.54404151e-02f, -2.43681327e-01f, 1.70346811e-01f, -1.77625045e-01f, 1.74013048e-01f, -2.56180227e-01f, 2.37033218e-01f, -8.80284086e-02f,
  -2.34625757e-01f, -1.20446607e-01f, -6.31720126e-02f, 1.71063170e-01f, 1.05832011e-01f, -9.50478315e-02f, 1.35975122e-01f, 1.31347075e-01f, -1.16552107e-01f, 2.70867825e-01f,
  -2.36589685e-01f, 7.21486062e-02f, 6.47034943e-02f, 2.62891889e-01f, -7.45144486e-02f, -3.44600588e-01f, 3.00981432e-01f, 1.85699403e-01f, 1.04190089e-01f, -1.59225404e-01f,
  -1.35467708e-01f, 3.65803331e-01f, -5.05274236e-01f, -2.26635337e-01f, 6.22963794e-02f, -2.66561300e-01f, -2.09493581e-02f, 6.75194338e-02f, 2.01621167e-02f, -2.51157403e-01f,
  2.57916212e-01f, -2.04423457e-01f, 6.94705034e-03f, 3.10532272e-01f, -5.20125985e-01f, 4.34481353e-03f, -1.91807970e-01f, -4.12936270e-01f, -7.92350546e-02f, -4.08383518e-01f,
  -4.44671452e-01f, -4.16257590e-01f, -4.26245570e-01f, -4.03255373e-01f, -3.33260074e-02f, -2.56928280e-02f, 8.59008208e-02f, -1.85214996e-01f, 9.98438373e-02f, -7.59874806e-02f,
  -1.96237236e-01f, 2.44360313e-01f, -5.90267591e-02f, 5.47393262e-02f, -1.07402608e-01f, 2.15269458e-02f, -1.27129301e-01f, 2.19208464e-01f, 3.59852105e-01f, 2.06628248e-01f,
  -1.60007268e-01f, -9.26608890e-02f, -2.46724649e-03f, 3.20073329e-02f, -4.77779299e-01f, -6.92774802e-02f, -2.37477824e-01f, -3.04227788e-02f, 1.23298652e-01f, -4.15138513e-01f,
  -2.11786821e-01f, 4.81118485e-02f, 1.07199676e-01f, 2.39219069e-01f, 2.13326618e-01f, -6.42171443e-01f, -2.45624363e-01f, -2.26452291e-01f, 2.58545876e-01f, 2.64053285e-01f,
  1.67857155e-01f, -5.31467259e-01f, 1.65755346e-01f, 1.36218742e-01f, -1.98685110e-01f, 1.46072194e-01f, 1.25432372e-01f, 1.20250091e-01f, -9.18674022e-02f, 3.12417489e-03f,
  1.38477176e-01f, -4.30917054e-01f, 2.36929934e-02f, 1.97896436e-01f, -1.51931524e-01f, 2.31288239e-01f, 3.13292779e-02f, 8.97093024e-03f, -2.67842084e-01f, -1.10074617e-01f,
  4.61385585e-02f, -2.15106178e-02f, -3.11450005e-01f, -4.04351056e-01f, -4.15703803e-02f, 1.34281859e-01f, -6.33949190e-02f, 3.81887734e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -9.30149481e-02f, 8.13831687e-02f, -4.85668182e-02f, -9.49822888e-02f, -7.19354814e-03f, 2.71957684e-02f, -1.02859680e-02f, 9.39215571e-02f, 3.24965939e-02f, -6.07425794e-02f,
  -5.91425896e-02f, -2.39944980e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    