/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.77594328e-01f, -1.78032983e-02f, 1.96801096e-01f, -1.77027509e-01f, 2.03894183e-01f, 1.34288654e-01f, 2.59567380e-01f, 3.82794626e-02f, -8.90983492e-02f, 1.41089574e-01f,
  -1.69790871e-02f, 1.11829964e-02f, -1.24810077e-01f, -2.65650731e-02f, -1.12657040e-01f, 1.49994031e-01f, 2.07964852e-02f, 6.76210783e-03f, 1.35914505e-01f, 2.13032424e-01f,
  -6.85025528e-02f, -1.18209034e-01f, -3.12467068e-01f, -1.53912574e-01f, -5.86359277e-02f, 1.61275476e-01f, 1.07917719e-01f, -4.06348668e-02f, 4.29192595e-02f, 1.59571879e-02f,
  1.84342742e-01f, -2.23708302e-02f, 5.62979244e-02f, -3.00223622e-02f, 1.02394722e-01f, 9.32182521e-02f, 1.29284263e-01f, 2.25736424e-02f, 6.46104515e-02f, -2.31079459e-02f,
  8.45727250e-02f, -1.64940897e-02f, 4.81193401e-02f, 4.42093611e-02f, 7.30594294e-03f, 4.37797643e-02f, 2.04170197e-02f, -7.16755241e-02f, -1.25677273e-01f, 1.20820560e-01f,
  7.31302127e-02f, 6.36117756e-02f, -3.19100507e-02f, 9.00222734e-02f, 8.53088126e-02f, 7.27024525e-02f, 8.71145651e-02f, 7.89888576e-02f, 7.77507722e-02f, 1.13278873e-01f,
  1.70085505e-01f, -6.86916411e-02f, 2.47237477e-02f, -3.09897810e-02f, -5.04681617e-02f, -1.24449087e-02f, -1.65679634e-01f, 1.30935237e-02f, 3.37147969e-03f, -3.32611725e-02f,
  -1.63877472e-01f, 6.72188168e-03f, -5.45429764e-03f, -7.50861168e-02f, 4.23808880e-02f, -5.69157861e-02f, -1.58940498e-02f, -6.04110025e-02f, -5.14943525e-02f, -1.06192924e-01f,
  1.96595099e-02f, -1.67322420e-02f, -5.29861934e-02f, -4.60909866e-02f, -6.85347468e-02f, -6.88618496e-02f, -1.51576046e-02f, -2.47028358e-02f, -1.09845391e-02f, -1.01800233e-01f,
  8.81372839e-02f, 5.86895905e-02f, 6.10589534e-02f, 4.09303717e-02f, 2.02134103e-01f, 5.14670834e-02f, 5.02175316e-02f, 4.77383099e-02f, -2.87861074e-03f, 1.10656872e-01f,
  5.14348894e-02f, 1.17811128e-01f, 4.86579239e-02f, 1.31849367e-02f, 8.69102851e-02f, 6.88927248e-02f, 2.15442758e-02f, -5.09705991e-02f, -2.34212633e-03f, 6.46919459e-02f,
  8.15090463e-02f, 1.54341221e-01f, 2.57321820e-02f, 4.70774397e-02f, 2.92982515e-02f, 1.12314947e-01f, 1.32147789e-01f, 1.36023760e-01f, 3.47300582e-02f, 1.89715683e-01f,
  -5.51751375e-01f, 2.75136739e-01f, 1.90010723e-02f, -6.18449375e-02f, 2.56717891e-01f, -3.56105680e-04f, 5.22887968e-02f, -1.03888027e-02f, 8.11065808e-02f, 1.81885839e-01f,
  2.45944098e-01f, -6.88310806e-03f, 1.45412892e-01f, 7.70946220e-02f, -3.66922887e-03f, 1.59757301e-01f, 1.22419015e-01f, 2.12296341e-02f, -1.09470688e-01f, -1.68733224e-02f,
  9.36480612e-03f, -2.40122490e-02f, -9.25814882e-02f, 7.81060383e-02f, 1.00161828e-01f, -3.34375724e-03f, 2.64586806e-01f, 1.84991658e-01f, 1.31715432e-01f, 2.08988219e-01f,
  -8.91258568e-02f, 2.18934026e-02f, 5.61382174e-02f, 1.66719198e-01f, 2.29182482e-01f, -3.63796926e-03f, 1.92928743e-02f, 1.23519845e-01f, 6.61497042e-02f, 5.59312999e-02f,
  9.25004780e-02f, 5.12549430e-02f, 5.57268858e-02f, 7.82021414e-03f, 6.46900833e-02f, 5.44603390e-04f, 1.53712645e-01f, 1.95426866e-02f, 1.06491156e-01f, 2.38865856e-02f,
  1.74374446e-01f, 5.24448901e-02f, 2.70821899e-02f, 9.41611305e-02f, 2.35530920e-02f, 9.34880748e-02f, 1.22731633e-01f, -1.94576997e-02f, 1.23755544e-01f, -7.60371462e-02f,
  2.51842551e-02f, 2.26159282e-02f, -7.76787987e-03f, -1.27139121e-01f, -7.25191273e-03f, -1.60051718e-01f, -8.87961239e-02f, -7.10082874e-02f, -7.47107714e-02f, -1.32092372e-01f,
  -1.02705263e-01f, -1.34772062e-01f, -1.21201701e-01f, -6.48248717e-02f, -6.21705949e-02f, -1.50298342e-01f, -1.92359239e-02f, -6.14705980e-02f, -1.05770208e-01f, -7.63900951e-02f,
  -8.72456431e-02f, -1.24132581e-01f, -4.83210459e-02f, -4.60133478e-02f, -3.21075171e-02f, -8.10417384e-02f, -1.04305625e-01f, -9.04410630e-02f, -4.49406467e-02f, -4.20921370e-02f,
  -7.69120678e-02f, 9.79456156e-02f, -2.81356126e-02f, 6.52505681e-02f, 4.88989875e-02f, 1.15357749e-01f, 3.69009562e-02f, 7.03977942e-02f, 9.36718434e-02f, 8.05963483e-03f,
  -6.63168728e-03f, 1.50395092e-02f, 7.25369826e-02f, 5.37923239e-02f, 4.97157946e-02f, -8.79806653e-03f, 1.19817853e-01f, 1.12430044e-01f, 1.36493742e-01f, 3.33687104e-02f,
  5.79104722e-02f, 3.22203338e-02f, 5.80988452e-02f, -5.02923988e-02f, 1.02209948e-01f, -6.86327927e-03f, 4.63816673e-02f, 1.92994287e-03f, 1.13013759e-02f, -2.80245468e-02f,
  2.01583743e-01f, -1.15254104e-01f, -2.82645762e-01f, 1.88121021e-01f, -1.74603760e-01f, -3.23273242e-01f, -3.54217827e-01f, -1.16497368e-01f, 6.85617253e-02f, -9.77365375e-02f,
  -5.28127812e-02f, 1.16266251e-01f, 2.17360646e-01f, 5.48968799e-02f, -4.35526203e-03f, -1.80194601e-01f, -1.23970225e-01f, -3.27802338e-02f, -2.36760989e-01f, -1.08058371e-01f,
  8.90779402e-03f, 2.09673364e-02f, 1.50520846e-01f, 3.82623747e-02f, 5.08860201e-02f, -2.48889998e-02f, 2.89598834e-02f, 4.13247608e-02f, -7.25185499e-02f, 1.85984209e-01f,
  1.09999463e-01f, -1.48954466e-01f, 5.61392643e-02f, 1.33815054e-02f, 1.31979836e-02f, 6.62098676e-02f, 9.02854558e-03f, -1.49422027e-02f, 3.09507269e-02f, 5.16910963e-02f,
  2.90005002e-02f, 2.97376718e-02f, -5.49897850e-02f, 3.59335095e-02f, -2.42111441e-02f, 1.16763012e-02f, 1.41618913e-02f, 9.17105973e-02f, -2.38278415e-02f, -6.54215813e-02f,
  2.42159632e-03f, -1.02578729e-01f, -7.66870752e-02f, -3.89439203e-02f, -9.39476788e-02f, 1.04390837e-01f, -1.77093204e-02f, -1.07285909e-01f, -1.58686310e-01f, 1.46072492e-01f,
  7.25521892e-02f, 2.77625676e-02f, -9.64976549e-02f, 1.43564409e-02f, 3.77207659e-02f, 1.21871978e-01f, 4.37881723e-02f, 1.60099324e-02f, 5.68401739e-02f, -6.23886324e-02f,
  -6.56484207e-03f, 1.72635056e-02f, 5.18383235e-02f, 5.46381921e-02f, 1.41665250e-01f, 1.66458618e-02f, -6.41081855e-02f, 2.65348237e-02f, 7.44861066e-02f, 5.28508574e-02f,
  -1.59401335e-02f, 1.78290196e-02f, -6.31931424e-02f, 8.04810878e-03f, 6.45092577e-02f, -7.35504413e-03f, 1.73520315e-02f, 8.64376780e-03f, -4.78487201e-02f, 2.22353078e-03f,
  3.50471199e-01f, 1.55498888e-02f, 1.94147855e-01f, 5.81327267e-02f, -3.86894979e-02f, -4.36248370e-02f, 3.94352973e-02f, -2.30367947e-02f, 2.88639236e-02f, 7.86645785e-02f,
  -6.78359419e-02f, -3.22123878e-02f, 1.78444711e-03f, -8.27633664e-02f, -5.21106496e-02f, 5.12717627e-02f, 1.68720260e-02f, 1.69878937e-02f, -1.17110386e-02f, 2.20973999e-03f,
  -2.73893010e-02f, -9.12663713e-02f, 4.06095199e-02f, 5.02410606e-02f, -1.66327618e-02f, 3.15521173e-02f, -5.76847903e-02f, 5.23814559e-02f, -9.51771587e-02f, 1.56597476e-02f,
  -2.28712171e-01f, -2.24940673e-01f, -1.18874319e-01f, 1.27952754e-01f, 1.08346790e-01f, 2.23966911e-01f, 7.96050802e-02f, 1.00171834e-01f, 9.76881310e-02f, -2.45759208e-02f,
  -3.00664417e-02f, 1.81414932e-01f, 1.67517904e-02f, -4.84569930e-02f, 2.87800990e-02f, -1.35185476e-03f, -1.68658182e-01f, -7.55374432e-02f, 2.16743037e-01f, 3.69812697e-01f,
  1.23863205e-01f, 1.36211840e-02f, 1.02302944e-02f, 7.21002892e-02f, -5.61097302e-02f, 1.26035899e-01f, -1.02734752e-01f, -8.41140971e-02f, -7.22471252e-02f, -2.05227062e-01f,
  -7.04114810e-02f, -1.52734354e-01f, 2.55099572e-02f, -4.43636178e-04f, -8.65326449e-02f, 5.14465533e-02f, 1.30251735e-01f, -4.36376855e-02f, 2.94193458e-02f, -8.50662440e-02f,
  2.67231651e-02f, 7.59142414e-02f, 5.61503656e-02f, -4.08715531e-02f, -4.42049764e-02f, -9.88020748e-02f, -7.62029411e-03f, -1.50221691e-01f, -1.06669016e-01f, 1.03843406e-01f,
  -1.81028321e-02f, -2.43291520e-02f, -6.49866462e-02f, 3.77197489e-02f, -8.14805403e-02f, 7.26394076e-03f, -8.36595297e-02f, -2.67380439e-02f, -1.44437075e-01f, -3.89577448e-02f,
  2.41559688e-02f, -1.61616310e-01f, -7.47213066e-02f, -1.21184625e-01f, 1.57285333e-02f, -8.80996287e-02f, -1.12359010e-01f, -4.10051085e-02f, -1.81945041e-02f, 7.80020654e-03f,
  -1.81221141e-04f, -5.12408577e-02f, -5.32459952e-02f, -4.47409004e-02f, 9.55705270e-02f, -8.35204497e-02f, -6.83302805e-02f, -4.95920256e-02f, -6.80434257e-02f, -9.68880057e-02f,
  -1.16177954e-01f, -2.19706222e-02f, -6.92683607e-02f, -6.77932203e-02f, 2.31082235e-02f, -1.29399016e-01f, 6.66846260e-02f, 1.18705645e-01f, 5.52663989e-02f, 8.89983997e-02f,
  2.37253040e-01f, -3.73803452e-02f, -7.97350481e-02f, 2.52170898e-02f, -2.51344107e-02f, 4.04739678e-02f, 4.32420000e-02f, -1.45566638e-03f, -1.41371593e-01f, -6.38749497e-03f,
  7.12989792e-02f, -6.68016262e-03f, -1.20085165e-01f, -1.17704868e-02f, 8.88120383e-02f, 1.19182393e-01f, -5.14807403e-02f, -1.39926476e-02f, 8.37567374e-02f, 2.54230686e-02f,
  -3.04353926e-02f, 4.29412946e-02f, 2.14268416e-01f, -2.57157888e-02f, 4.91494639e-03f, 8.87545645e-02f, 7.99216107e-02f, 9.43746790e-02f, 1.27141863e-01f, 1.72801331e-01f,
  4.80476350e-01f, -1.14983348e-02f, -2.22528741e-01f, 1.46231681e-01f, -1.71989501e-01f, -1.87391430e-01f, -2.68682152e-01f, 4.52610515e-02f, 7.94860497e-02f, 3.93476188e-02f,
  1.15219764e-02f, 8.37039202e-02f, 8.53942409e-02f, 6.23908155e-02f, 7.59723336e-02f, -1.86497927e-01f, -1.97591037e-01f, -6.02996945e-02f, 4.99750264e-02f, -2.20954306e-02f,
  3.88876796e-02f, 1.64416298e-01f, 2.41091132e-01f, 1.10290283e-02f, 8.91108215e-02f, 8.12302455e-02f, -2.03118563e-01f, -4.23525199e-02f, -1.01785950e-01f, 2.80040558e-02f,
  1.89999361e-02f, -3.68360654e-02f, 1.89242493e-02f, 1.95963718e-02f, -2.16349605e-02f, 1.91943217e-02f, 3.84196709e-03f, 1.21951466e-02f, -4.69041653e-02f, 1.06115684e-01f,
  -3.26697566e-02f, 6.09198213e-02f, 8.78397375e-02f, -1.71214119e-02f, -7.14471340e-02f, -1.65273063e-03f, -1.20419718e-01f, 4.84993048e-02f, -5.57142235e-02f, 6.42738864e-02f,
  1.56404730e-02f, -6.01010257e-03f, -1.09806843e-01f, -2.72870678e-02f, 2.36176588e-02f, -5.37979528e-02f, -1.16553590e-01f, -3.29392552e-02f, -3.01481821e-02f, 6.22012205e-02f,
  3.36558670e-02f, -4.42511635e-03f, -4.12272476e-02f, -2.09462028e-02f, -3.32148820e-02f, 2.53901575e-02f, -1.79224629e-02f, -4.26911600e-02f, -4.11846191e-02f, -5.95153729e-03f,
  -6.90964162e-02f, -2.49122269e-02f, 5.51144704e-02f, -1.64636262e-02f, 9.26327519e-03f, -1.09128058e-01f, 6.40357211e-02f, -1.13833807e-02f, 1.47690000e-02f, -1.45098697e-02f,
  2.78370492e-02f, -3.99683267e-02f, 3.35481763e-02f, 3.79965566e-02f, -8.79766122e-02f, -3.90837854e-03f, -3.05575375e-02f, -1.13166515e-02f, -1.00405522e-01f, -8.31643343e-02f,
  6.44057468e-02f, -9.91356596e-02f, 2.19220683e-01f, 7.96489418e-03f, -4.95276116e-02f, -5.08247428e-02f, 4.30695713e-02f, 1.02301359e-01f, 2.65100808e-03f, 1.71972141e-02f,
  1.27993419e-03f, 3.59356478e-02f, 9.64400247e-02f, 3.21208388e-02f, 4.41564471e-02f, 5.48442490e-02f, -7.54054189e-02f, 5.85450158e-02f, 6.40016794e-02f, -2.71148533e-02f,
  -3.67893814e-03f, -1.16559908e-01f, 1.31579369e-01f, -5.53677343e-02f, 8.53877664e-02f, -4.25854772e-02f, -8.77871290e-02f, 4.50341515e-02f, 3.25027108e-02f, 4.90426011e-02f,
  -8.68798435e-01f, 1.28951043e-01f, -2.67884463e-01f, -1.64883852e-01f, 2.81421274e-01f, -4.62222323e-02f, 8.82685855e-02f, -5.38016148e-02f, -7.69277439e-02f, 9.57236961e-02f,
  -2.50946768e-02f, -1.63907379e-01f, -1.56779792e-02f, -2.82734004e-03f, -1.46230951e-01f, 5.41116782e-02f, 1.16520524e-01f, -1.98302984e-01f, -2.55833000e-01f, -2.12773215e-03f,
  1.30101964e-01f, -2.06967089e-02f, -1.60915390e-01f, -5.89935295e-03f, 1.13832019e-02f, -1.12091765e-01f, 7.99522474e-02f, -1.01187743e-01f, -1.17777526e-01f, -5.41889574e-03f,
  -3.64834309e-01f, -3.29892755e-01f, -1.04438543e-01f, -5.18709235e-02f, -1.04780570e-01f, -2.26778135e-01f, -9.00001451e-02f, -1.33276582e-01f, -1.59607351e-01f, -1.40876353e-01f,
  -7.41260424e-02f, -1.31126210e-01f, -1.25818655e-01f, -1.88016146e-02f, -1.30440503e-01f, -1.53958678e-01f, -1.32309571e-01f, -2.72077888e-01f, -2.00497910e-01f, -1.50806025e-01f,
  5.10731451e-02f, -2.40752492e-02f, -1.75463572e-01f, -6.49132729e-02f, -1.51463658e-01f, -1.62426218e-01f, -1.45702139e-01f, -1.92375243e-01f, -2.17884719e-01f, -9.60801989e-02f,
  6.84919357e-02f, 8.45181495e-02f, 9.34309661e-02f, 3.08795366e-04f, 1.80779666e-01f, 2.77328826e-02f, -1.01504736e-02f, 9.00684297e-02f, 4.82970178e-02f, 5.58500364e-02f,
  3.79000977e-02f, 1.79460850e-02f, 5.27758487e-02f, 1.67741459e-02f, 2.54681222e-02f, 4.82969992e-02f, 1.00383516e-02f, 7.16399625e-02f, 5.08127622e-02f, 9.90101099e-02f,
  1.48840928e-02f, -2.33794395e-02f, 6.38513118e-02f, 5.46569936e-02f, 1.21154018e-01f, 2.06474774e-02f, -5.84693160e-03f, 5.79279065e-02f, 1.43446952e-01f, 3.36629897e-02f,
  5.42364176e-03f, 2.46249698e-02f, -2.04680637e-01f, -9.14144069e-02f, -1.23858370e-01f, -1.49140060e-01f, -1.27145484e-01f, -1.62446171e-01f, -2.18117192e-01f, -1.88002527e-01f,
  -1.44849747e-01f, -2.09487379e-01f, -7.85572082e-02f, -5.95247187e-02f, -1.21577866e-01f, -1.17350943e-01f, 5.03089428e-02f, -1.38780102e-01f, -1.42272234e-01f, -8.61349478e-02f,
  3.88686620e-02f, -1.03574350e-01f, -9.91298184e-02f, -8.78607035e-02f, -2.89708171e-02f, -6.97933361e-02f, -7.88094252e-02f, -3.56243663e-02f, -1.87499002e-01f, -7.69954324e-02f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -8.38918746e-01f, -1.39126956e-01f, -5.21500297e-02f, -4.03682530e-01f, 1.45510599e-01f, -2.99014486e-02f, -1.22871146e-01f, -1.00233197e-01f, -8.29694495e-02f, -9.47109386e-02f,
  1.32538661e-01f, -5.86952157e-02f, -1.12496518e-01f, -3.93700525e-02f, -3.39739054e-01f, -2.60981172e-01f, -2.65730500e-01f, -2.69474328e-01f, 8.83688927e-02f, 2.63948768e-01f,
  6.23167306e-02f, -2.51859099e-01f, -2.78836340e-01f, -3.04987058e-02f, -1.44004019e-03f, -6.49527237e-02f, 4.08240631e-02f, -4.94183674e-02f, 1.11442387e-01f, -1.68609425e-01f,
  -1.05582699e-01f, 1.21313907e-01f, 2.47664705e-01f, -8.11112747e-02f, 1.90921277e-01f, 1.97131008e-01f, 1.42656676e-02f, 4.20655571e-02f, 2.06616998e-01f, -1.14920758e-01f,
  -1.05341539e-01f, 3.28688957e-02f, -9.26486850e-02f, -5.30768977e-03f, -2.11085416e-02f, -1.61464304e-01f, -2.81841829e-02f, 5.06184287e-02f, 3.70659381e-02f, 1.12776123e-01f,
  -1.28084436e-01f, -5.01953717e-03f, -3.34030956e-01f, -4.34424765e-02f, 4.62950543e-02f, 7.29248896e-02f, 1.57543853e-01f, 1.75816953e-01f, 9.52873603e-02f, -1.83027446e-01f,
  1.05077446e-01f, 1.10692136e-01f, 1.17329627e-01f, -4.56900075e-02f, -9.29343030e-02f, -7.08249286e-02f, -2.20136195e-02f, 4.84847985e-02f, 2.26295590e-02f, -3.95151749e-02f,
  1.45207867e-01f, 3.89631391e-02f, 1.49986474e-02f, 5.06004356e-02f, 5.19910157e-02f, -9.01509169e-03f, 1.07437849e-01f, 4.84665520e-02f, 9.89325270e-02f, 4.64266911e-03f,
  -6.39701411e-02f, 2.34551132e-02f, -1.46556154e-01f, -2.62930356e-02f, 6.18957132e-02f, 1.22797281e-01f, 1.77589551e-01f, 3.11093200e-02f, -5.50111420e-02f, 4.96062860e-02f,
  -3.44734758e-01f, 3.27569395e-01f, -1.25555143e-01f, -4.94748913e-02f, -2.38593832e-01f, 6.83183447e-02f, -2.67088600e-02f, -1.77411228e-01f, 5.18372953e-02f, -8.93438235e-02f,
  9.10480917e-02f, -5.88591024e-02f, -1.24389783e-01f, 1.47880847e-02f, -2.66203247e-02f, 5.15420102e-02f, -4.47169282e-02f, -7.21887350e-02f, 1.46224380e-01f, -2.20890995e-03f,
  -2.72319645e-01f, -3.76663923e-01f, -4.50775146e-01f, -2.65428364e-01f, -1.82746688e-03f, -1.55346856e-01f, -1.65216014e-01f, -1.76249161e-01f, -1.77091405e-01f, -5.15063524e-01f,
  7.83883929e-01f, -3.48588407e-01f, 2.07083169e-02f, -1.08816199e-01f, -2.95202792e-01f, -5.25202006e-02f, -1.64910764e-01f, 5.92658222e-02f, -4.18790523e-03f, -1.53828785e-01f,
  -1.52286971e-02f, 1.90809295e-01f, 2.45662674e-01f, 1.60066605e-01f, 3.14680129e-01f, -1.31890863e-01f, -1.83852449e-01f, 1.88843369e-01f, 3.34164709e-01f, -3.17085460e-02f,
  -3.49598676e-01f, -1.55627638e-01f, 1.28379434e-01f, -1.30862013e-01f, -2.68386334e-01f, 1.79912504e-02f, -2.74013400e-01f, -1.84536293e-01f, -1.91496208e-01f, -2.42357358e-01f,
  4.08189714e-01f, 6.00690432e-02f, 6.82782158e-02f, 6.48449361e-02f, -1.21913143e-01f, 8.09372962e-02f, 1.13613298e-02f, -6.39078319e-02f, 1.73749179e-02f, -1.31034911e-01f,
  8.62694718e-03f, 8.01995248e-02f, 1.71093702e-01f, -1.49292890e-02f, -9.52765420e-02f, 1.34189334e-02f, -5.91020323e-02f, -7.66464770e-02f, 6.45855442e-02f, -8.50281492e-02f,
  -1.55769408e-01f, -1.24197260e-01f, -5.04230335e-02f, 9.97311156e-03f, 1.53430700e-01f, 8.71586055e-02f, -2.48770475e-01f, 1.48951970e-02f, -2.71727275e-02f, -2.85365313e-01f,
  -8.97906721e-02f, -2.62746271e-02f, -7.20216036e-02f, -4.16698456e-02f, 4.86547351e-02f, -4.99756560e-02f, 8.66735205e-02f, -3.77584398e-02f, 2.10596342e-02f, -8.01143125e-02f,
  1.81204025e-02f, 2.28023268e-02f, -1.24498326e-02f, -5.97437564e-03f, 3.98087092e-02f, 5.33890761e-02f, 1.42825991e-01f, 4.62308228e-02f, 1.55109651e-02f, -6.65087402e-02f,
  9.96147655e-03f, -2.83533614e-02f, 5.36330091e-03f, 1.51187303e-02f, -1.50777753e-02f, 1.39032048e-03f, 6.39616698e-02f, -9.91755947e-02f, -2.24518888e-02f, -1.33334145e-01f,
  1.27312422e-01f, -4.87556309e-03f, -1.90615784e-02f, 2.28515640e-02f, -7.16339871e-02f, 5.81490844e-02f, 1.01593591e-01f, -3.72404568e-02f, 2.14106888e-02f, 6.33001849e-02f,
  1.24180526e-01f, 6.73002601e-02f, -8.62270221e-02f, -7.63486549e-02f, -7.71028572e-04f, -2.98650786e-02f, -1.21803228e-02f, 9.74664167e-02f, -2.08588485e-02f, -1.58277661e-01f,
  -1.28788305e-02f, -9.20361131e-02f, 1.64314225e-01f, 4.67070453e-02f, -8.63833874e-02f, 1.75042689e-01f, -6.20688079e-03f, -4.50517572e-02f, 1.82569131e-01f, -2.32908025e-01f,
  9.24998105e-01f, -3.79475802e-01f, -1.61167130e-01f, 1.03600346e-01f, -2.03982204e-01f, -5.36030233e-02f, -1.87646344e-01f, -3.20989937e-02f, 1.34334967e-01f, -1.08540557e-01f,
  -5.23260236e-02f, 2.69464701e-01f, 9.26700309e-02f, 3.46263126e-02f, 1.28380820e-01f, -1.92141429e-01f, -1.28693193e-01f, 1.41705036e-01f, 3.18939120e-01f, 5.10699674e-02f,
  -9.54329744e-02f, -7.66469315e-02f, 2.38838062e-01f, 1.32716730e-01f, -2.26326451e-01f, 9.21137929e-02f, -2.40472108e-01f, -1.51452124e-01f, -1.77088886e-01f, -4.13654238e-01f,
  -2.90049136e-01f, -1.90286055e-01f, 1.92935959e-01f, 6.92561036e-03f, -1.77760161e-02f, 6.08959682e-02f, 1.64975747e-02f, 4.07554721e-03f, 4.39768620e-02f, -5.83773479e-02f,
  2.66605243e-02f, 3.00599951e-02f, 9.87407193e-02f, -1.40825078e-01f, -1.95105642e-01f, 2.81336624e-03f, -1.53131485e-01f, -3.79602909e-02f, 9.65600833e-03f, -1.64039955e-01f,
  -4.44207992e-03f, -1.38350978e-01f, -8.86542425e-02f, -3.45443748e-02f, 6.59185275e-02f, 6.67768531e-03f, -5.13608269e-02f, -4.24967110e-02f, 6.43015280e-02f, -8.77450928e-02f,
  -1.73014887e-02f, 9.14311185e-02f, 1.14476807e-01f, -5.95161431e-02f, 5.49735241e-02f, 9.65244025e-02f, -3.73973213e-02f, 6.90615475e-02f, 1.53842866e-01f, 6.13247603e-02f,
  -1.04066685e-01f, 5.19056479e-03f, -2.98554264e-02f, -1.93477124e-02f, 8.84592906e-02f, -2.10238975e-02f, -5.75135387e-02f, -4.13106492e-04f, -1.70146003e-02f, 8.96167085e-02f,
  -7.06077367e-03f, -4.66156453e-02f, -4.90314811e-02f, -1.68559998e-01f, -2.56425440e-01f, -1.25899017e-01f, -7.90431723e-02f, -1.34793282e-01f, -3.12497430e-02f, -4.43675602e-03f,
  -1.88602269e-01f, 3.16983730e-01f, 7.93849900e-02f, 1.87071897e-02f, -9.98504087e-02f, 8.98438171e-02f, 1.10697113e-01f, 1.42173842e-04f, -7.80450925e-02f, -1.87001020e-01f,
  -2.93031763e-02f, 3.25686932e-02f, 9.09019783e-02f, 2.19359435e-02f, 1.25235081e-01f, 4.24240157e-02f, 1.85927749e-02f, 7.66839162e-02f, 4.69378009e-02f, -1.43916532e-01f,
  2.24310327e-02f, 1.27242148e-01f, 1.77682146e-01f, 1.62162945e-01f, 1.22903578e-01f, 2.58209288e-01f, 3.18796560e-02f, -3.91015690e-03f, 8.76882300e-02f, 7.95659050e-03f,
  -1.38021260e-01f, -2.79148579e-01f, 2.98693329e-01f, 5.85708320e-01f, 6.04119837e-01f, 5.02403677e-01f, 2.51212537e-01f, 1.39396638e-01f, 3.31655681e-01f, 1.45560920e-01f,
  -1.48792535e-01f, -6.26696721e-02f, 4.08406295e-02f, -6.80125505e-02f, -1.56807452e-01f, 3.37264389e-01f, 3.74211401e-01f, 1.42087683e-01f, 1.68217823e-01f, 2.79490709e-01f,
  2.75978774e-01f, 7.06777573e-02f, -9.76875052e-02f, 1.19384542e-01f, 1.71930224e-01f, 2.70040661e-01f, 1.98165730e-01f, 1.16335258e-01f, 1.50553867e-01f, 1.26361907e-01f,
  -1.26034155e-01f, -2.34780371e-01f, 1.01382256e-01f, -1.34072706e-01f, -2.11710975e-01f, -1.49181157e-01f, -4.11287062e-02f, -2.29589775e-01f, -1.52864143e-01f, -4.32561338e-03f,
  -1.20294027e-01f, -2.00332701e-01f, 1.35895446e-01f, -4.80669290e-02f, 6.23305924e-02f, -4.29853350e-02f, -1.22056738e-01f, -1.15442529e-01f, 5.75290876e-04f, -1.04472786e-01f,
  -1.00303389e-01f, 6.00313619e-02f, 9.77615938e-02f, 1.50421247e-01f, 3.15500833e-02f, 7.67598897e-02f, -1.89490810e-01f, 3.93314734e-02f, -5.48275858e-02f, -4.83791009e-02f,
  2.59072691e-01f, 2.34005656e-02f, 6.80336356e-02f, -1.27417007e-02f, 3.04183718e-02f, 2.92307101e-02f, 1.08391136e-01f, 4.04482009e-03f, 6.80718422e-02f, 5.25905490e-02f,
  -1.70784874e-03f, 8.46615881e-02f, 7.76252300e-02f, 7.04494342e-02f, 7.13252276e-03f, -3.29248607e-03f, 4.67878617e-02f, -1.17306694e-01f, -1.51132002e-01f, 1.60178114e-02f,
  -5.16044721e-02f, 2.19828524e-02f, -1.60353389e-02f, -1.40922181e-02f, -8.79148319e-02f, 1.07385078e-02f, 6.33881241e-02f, -3.60676832e-02f, 2.37325225e-02f, -2.36246167e-04f,
  -1.18817113e-01f, -7.94567727e-03f, 1.79108322e-01f, 6.46382719e-02f, 1.03497826e-01f, -1.34293079e-01f, 2.30251234e-02f, -3.58614251e-02f, 4.97475229e-02f, 1.96658194e-01f,
  -7.23076761e-02f, 1.41261481e-02f, -2.12816447e-02f, -1.17181219e-01f, 6.94022700e-02f, -3.55853059e-04f, -1.48555696e-01f, 8.95477906e-02f, -1.19113952e-01f, -1.17737681e-01f,
  -2.09524836e-02f, 1.13674425e-01f, 1.47226080e-01f, 1.29450426e-01f, 1.77241102e-01f, 1.69150665e-01f, -3.17307785e-02f, -3.51226367e-02f, 1.84177607e-01f, 1.34573996e-01f,
  6.73185959e-02f, -7.14528918e-01f, -1.07059777e-01f, -2.84600049e-01f, 3.32026929e-02f, 1.40085950e-01f, -8.61620083e-02f, -1.03239246e-01f, -2.12683957e-02f, -2.70251602e-01f,
  -8.81087035e-02f, 2.03283839e-02f, -6.04901351e-02f, -1.68161187e-02f, 2.05213856e-02f, -1.58412218e-01f, -3.37533280e-02f, 1.27830237e-01f, 5.48457861e-01f, 2.72457749e-01f,
  -1.00621358e-01f, -1.86816901e-01f, -3.81754152e-02f, -9.18612853e-02f, -3.58701408e-01f, -5.61819002e-02f, -3.18182796e-01f, -9.41520333e-02f, -1.15707524e-01f, -4.80068982e-01f,
  1.96390226e-01f, 4.36960049e-02f, 1.28962085e-01f, 1.85438769e-03f, -5.01573943e-02f, -4.70095314e-02f, -1.81010664e-02f, -2.19711149e-03f, 3.66583280e-02f, -5.17548323e-02f,
  3.70707959e-02f, -5.70186321e-03f, 3.05835679e-02f, -1.75630152e-02f, 4.16036248e-02f, 3.10820881e-02f, -2.55280845e-02f, 2.70172711e-02f, -1.30084716e-02f, -1.15097657e-01f,
  -1.91642910e-01f, 1.30122587e-01f, 1.71408594e-01f, 1.56362042e-01f, 1.46660343e-01f, 2.39536807e-01f, -1.39269337e-01f, 1.18504241e-02f, 1.37154683e-01f, -1.50567472e-01f,
  6.04212359e-02f, -1.39392847e-02f, -3.75702977e-02f, 7.40885064e-02f, 1.45540074e-01f, 1.82694331e-01f, 8.86587873e-02f, 1.08269595e-01f, 1.15748584e-01f, -2.86848447e-03f,
  7.06152543e-02f, 6.14122003e-02f, 1.72683269e-01f, -6.39009848e-02f, -2.45518442e-02f, 1.16180144e-01f, -1.65823009e-02f, -8.08921531e-02f, 1.45830885e-02f, -5.03236689e-02f,
  6.20465539e-02f, -3.35910432e-02f, 6.33713230e-02f, 7.44980723e-02f, -6.34837449e-02f, 6.64162189e-02f, 1.36078522e-01f, -3.79994772e-02f, 2.23772749e-02f, -6.78824484e-02f,
  1.57500803e-01f, 2.47605547e-01f, 7.75444135e-03f, 3.10444348e-02f, 9.35340393e-03f, -6.51010424e-02f, -7.48234093e-02f, -3.11016589e-02f, -1.17089981e-02f, 3.72236110e-02f,
  5.32756448e-02f, 7.97271207e-02f, 3.93888205e-02f, -6.68316782e-02f, 2.04613373e-01f, 1.66180074e-01f, -3.43691967e-02f, 5.80988079e-02f, 4.16968241e-02f, -7.57631809e-02f,
  -7.80238509e-02f, 1.32594734e-01f, 2.37895802e-01f, 3.24865170e-02f, 1.89565465e-01f, 3.00496191e-01f, 4.13074205e-03f, 2.39387527e-02f, 9.68585610e-02f, -1.62276123e-02f,
  5.80762267e-01f, -3.15607223e-03f, -4.77779090e-01f, 2.32355073e-01f, -2.25191966e-01f, -1.14162743e-01f, -9.00221467e-02f, 1.50770351e-01f, 1.34750247e-01f, -1.81329831e-01f,
  -1.68248802e-01f, 2.58048326e-01f, 4.63200249e-02f, -1.29866481e-01f, 5.04929721e-02f, -3.86671484e-01f, -3.53222877e-01f, -2.14783058e-01f, -1.49191871e-01f, 7.11526573e-02f,
  1.56842102e-03f, 4.18965481e-02f, 5.57113439e-02f, 1.27350986e-02f, -1.08831473e-01f, -1.24846540e-01f, -4.05780375e-01f, -1.71936139e-01f, -1.11648671e-01f, -1.99812144e-01f,
  -1.89475074e-01f, -4.63131331e-02f, -2.32252672e-01f, 1.49243996e-01f, -1.02054618e-01f, -1.06976349e-02f, -5.24717532e-02f, -2.27423713e-01f, 2.64183083e-03f, 5.91908619e-02f,
  -5.50976954e-04f, -1.28569424e-01f, 1.14768699e-01f, -1.39766503e-02f, 4.62138839e-02f, 3.65991183e-02f, -1.32832393e-01f, -1.69329509e-01f, -2.16614991e-01f, -1.24290474e-01f,
  -1.99473370e-03f, -1.71012565e-01f, -7.97398984e-02f, -1.30836636e-01f, -2.09385917e-01f, -1.49659500e-01f, -1.22555397e-01f, -1.55579686e-01f, -2.49147654e-01f, -2.42152419e-02f,
  6.32415265e-02f, -4.15246859e-02f, -6.41185641e-02f, -2.70789843e-02f, 9.29684192e-03f, 2.89375354e-02f, 1.31694883e-01f, -1.70064308e-02f, 1.60657912e-02f, 3.71592082e-02f,
  1.21886425e-01f, -1.09436959e-01f, 8.18738490e-02f, 3.77437733e-02f, -1.49424719e-02f, 2.28568222e-02f, 8.08254406e-02f, 8.23825039e-03f, -8.85909200e-02f, -4.47563827e-02f,
  8.37955251e-02f, -3.35808354e-03f, 2.68509760e-02f, -1.33416355e-02f, -1.90012336e-01f, 2.99608521e-02f, -1.67806465e-02f, 5.77742886e-03f, 1.35764211e-01f, -2.01956742e-02f,
  3.43745977e-01f, -1.05258599e-01f, -2.78852172e-02f, 1.51696261e-02f, -7.58293942e-02f, 5.85151464e-02f, 1.20047815e-01f, 3.43158208e-02f, 1.51161104e-01f, 3.49102058e-02f,
  -7.00767711e-02f, 3.04591730e-02f, 9.96301621e-02f, -2.77289394e-02f, -2.45436225e-02f, -6.47919998e-02f, 7.01964796e-02f, 1.75242424e-02f, -4.40436490e-02f, -2.30579190e-02f,
  5.19453250e-02f, 9.84418765e-03f, 2.25729614e-01f, 7.51006231e-02f, 1.43790215e-01f, 4.38998006e-02f, 1.15691803e-01f, 5.83284721e-02f, 1.73819155e-01f, 2.56428361e-01f,
  -3.54242980e-01f, 4.38459441e-02f, 4.35155630e-02f, -4.71374989e-02f, 1.80653423e-01f, 1.89677104e-01f, 4.28834498e-01f, 6.40532672e-02f, -1.39520243e-01f, 1.04998931e-01f,
  7.63527453e-02f, -8.55952427e-02f, -6.28620386e-03f, 1.39729334e-02f, -2.46741381e-02f, 1.13770753e-01f, 2.44537681e-01f, -1.56666726e-01f, -7.59153515e-02f, -6.02311231e-02f,
  8.92599598e-02f, -1.36836573e-01f, -4.85082299e-01f, -9.06122476e-02f, 2.41007414e-02f, -8.61179084e-03f, -1.02605186e-01f, -5.20369150e-02f, 3.50313075e-02f, 1.16122298e-01f,
  -4.10249025e-01f, -3.44637781e-01f, 1.49256289e-01f, -7.83843473e-02f, -1.03158318e-01f, -1.14661805e-01f, 4.50319313e-02f, -2.41764486e-01f, -3.16947363e-02f, 7.93572795e-03f,
  -3.65678519e-02f, -1.72741428e-01f, -7.21899385e-04f, 1.09340698e-02f, -1.03998065e-01f, -5.00601716e-04f, -6.59353882e-02f, -1.97526440e-01f, -1.22087426e-01f, -8.56494233e-02f,
  1.84564784e-01f, -8.10075738e-03f, -1.09140560e-01f, -6.91639781e-02f, -5.79928197e-02f, -9.21342596e-02f, -1.56899229e-01f, -7.46868104e-02f, -1.25393802e-02f, -3.15268457e-01f,
  -6.57829130e-03f, -1.88628510e-01f, 1.69994324e-01f, -6.18779399e-02f, -1.81322008e-01f, -3.41797285e-02f, 4.35830504e-02f, 2.71336455e-02f, -2.35586539e-02f, -9.88059640e-02f,
  -3.43161356e-03f, 8.91720317e-03f, -2.89389640e-02f, -5.79203218e-02f, 3.32117826e-02f, 8.06956813e-02f, 1.69496566e-01f, 8.95346329e-02f, -8.66076946e-02f, 5.28922677e-02f,
  3.81839424e-02f, -8.07087589e-03f, -2.35648140e-01f, 3.54544669e-02f, 1.29416734e-01f, -1.71572324e-02f, -6.05109632e-02f, -8.04241374e-02f, -7.98142254e-02f, -4.12243530e-02f,
  -3.15023661e-01f, -6.39029741e-02f, -1.52091995e-01f, 3.31167877e-02f, 9.14815441e-02f, -1.12656139e-01f, 9.06022713e-02f, -4.72866297e-02f, 6.78058043e-02f, -6.64451197e-02f,
  9.14797112e-02f, -2.53787898e-02f, -6.86411783e-02f, 1.55560628e-01f, 4.66696825e-03f, 8.80839154e-02f, 7.76495561e-02f, 2.22709123e-02f, 6.69361576e-02f, -1.74535308e-02f,
  1.09250687e-01f, 8.18195567e-02f, 1.05170365e-02f, 6.60387501e-02f, -3.46660167e-02f, -8.41267556e-02f, 1.82809141e-02f, 1.09028131e-01f, 3.57610732e-02f, 2.56860796e-02f,
  4.24372703e-01f, -7.05612302e-02f, -3.82358372e-01f, 4.73422021e-01f, 1.91165805e-01f, -1.31193057e-01f, -2.67861515e-01f, -1.03702985e-01f, 3.38732481e-01f, 8.14410076e-02f,
  6.68834010e-03f, 7.52567500e-02f, -5.73193654e-02f, -2.24033028e-01f, -4.91758525e-01f, -3.13298792e-01f, -2.60593057e-01f, -2.28195861e-01f, -3.80173653e-01f, -4.08652276e-02f,
  2.09638000e-01f, 4.77901064e-02f, -3.66312899e-02f, -1.11243822e-01f, 1.41720757e-01f, 4.98067252e-02f, -1.24398589e-01f, 5.05841943e-03f, -8.65147263e-02f, 9.36812535e-02f,
  -8.97386149e-02f, 9.91015434e-02f, -1.33914456e-01f, 1.48109764e-01f, -7.02340677e-02f, 2.80570015e-02f, -1.20779663e-01f, -1.57855034e-01f, -1.31910384e-01f, -1.04394063e-01f,
  1.42728053e-02f, -1.30378287e-02f, 6.25768900e-02f, 6.21973276e-02f, 1.25628337e-01f, -1.22822896e-01f, -1.25551850e-01f, -1.73847824e-01f, -2.34068915e-01f, -1.77291915e-01f,
  1.08249068e-01f, -6.46336377e-02f, -1.56455621e-01f, -6.78661987e-02f, -2.15736046e-01f, -7.01236501e-02f, -1.46256477e-01f, -1.07315548e-01f, -1.62573069e-01f, 1.22042127e-01f,
  -2.20506489e-02f, -6.45428300e-02f, -6.79203570e-02f, 1.53896630e-01f, 1.25955135e-01f, 9.19390023e-02f, 9.43920612e-02f, 3.15225273e-02f, -1.31479986e-02f, -1.07143763e-02f,
  -2.63308026e-02f, -5.76912388e-02f, -5.49737662e-02f, -1.24304578e-01f, 7.80658200e-02f, 1.31646246e-02f, 3.68325748e-02f, -8.97037387e-02f, -1.64977267e-01f, 8.73811468e-02f,
  4.19985242e-02f, -8.98899063e-02f, -6.47122934e-02f, -9.40800831e-02f, -9.18119103e-02f, -1.52248323e-01f, -2.15265178e-03f, -5.19456416e-02f, -4.79092412e-02f, 8.45935196e-02f,
  2.94689894e-01f, -2.05578089e-01f, 6.44837841e-02f, -1.70556620e-01f, -1.23810181e-02f, 4.49633524e-02f, 8.62977430e-02f, -1.29349470e-01f, 1.41367644e-01f, -1.59924462e-01f,
  -1.08743899e-01f, -1.00354373e-01f, 2.15319529e-01f, 8.82201865e-02f, 7.28389947e-03f, 3.37240361e-02f, -4.26768735e-02f, -2.38955691e-02f, -9.15545505e-03f, 1.04506992e-01f,
  1.16820201e-01f, 3.39215458e-03f, -1.47565499e-01f, -1.04303494e-01f, 1.44761398e-01f, 2.54041944e-02f, -1.89590603e-01f, -1.36873992e-02f, -1.82029977e-01f, 1.28943697e-01f,
  -8.97210091e-02f, 2.18428388e-01f, 2.50273466e-01f, 3.79828960e-02f, 1.46804661e-01f, -1.00719780e-01f, -9.75347310e-02f, -1.53323293e-01f, 2.17368342e-02f, 9.12717059e-02f,
  1.52366713e-01f, -1.12401463e-01f, 8.27711448e-02f, -2.49119878e-01f, -2.83211201e-01f, 8.05847272e-02f, 4.70236279e-02f, -1.90992460e-01f, -4.73097950e-01f, -4.78914082e-01f,
  -3.05646271e-01f, -2.08308727e-01f, -1.07841402e-01f, -1.47587851e-01f, 1.02726668e-01f, -1.63448080e-01f, 3.20501179e-01f, 9.01684090e-02f, 2.71167848e-02f, 1.89758524e-01f,
  2.12346628e-01f, 9.20129120e-02f, -5.06433696e-02f, -7.56061524e-02f, 8.02582949e-02f, 5.35196587e-02f, 3.58460508e-02f, 1.76795587e-01f, 4.69462201e-02f, 3.08846701e-02f,
  1.40463755e-01f, -1.08786158e-01f, 8.04297030e-02f, -6.23627193e-02f, -6.43358752e-02f, -1.51307806e-01f, -1.60280794e-01f, -3.17401171e-01f, -9.73746330e-02f, -8.78587216e-02f,
  -1.12002246e-01f, 1.16708733e-01f, 9.64235514e-02f, 2.53072958e-02f, -1.17268711e-02f, 1.03286631e-01f, 1.13834351e-01f, -1.31331697e-01f, 5.03829829e-02f, 1.56912833e-01f,
  -8.86422116e-03f, -1.37806274e-02f, 5.57225086e-02f, -4.00609747e-02f, -2.23996658e-02f, 5.76295704e-02f, 8.22924376e-02f, -9.49097797e-02f, -2.71739904e-02f, 2.64681447e-02f,
  8.48611146e-02f, 1.69179880e-03f, 4.48204055e-02f, 2.13723257e-03f, -3.40975709e-02f, 1.02854418e-02f, -8.21234211e-02f, -7.16841519e-02f, -1.67740844e-02f, 1.04588576e-01f,
  -7.67586529e-02f, 8.99215788e-03f, 8.29489231e-02f, -1.29371703e-01f, 1.29761130e-01f, -1.00300372e-01f, 4.50140908e-02f, -8.50243941e-02f, -1.19068593e-01f, -1.08456435e-02f,
  -1.36088029e-01f, -7.19183832e-02f, 1.39935881e-01f, -1.65464491e-01f, -8.41776803e-02f, 6.47795945e-02f, 1.63972691e-01f, -2.20418461e-02f, 1.29878102e-02f, -1.54314607e-01f,
  -1.05493404e-01f, 7.87730096e-04f, 7.75291249e-02f, -1.68867975e-01f, -1.30527899e-01f, -3.15895677e-02f, -1.05133124e-01f, -1.43877462e-01f, -2.01768145e-01f, -7.49688074e-02f,
  -4.94362488e-02f, -1.70292825e-01f, -2.23865777e-01f, 6.86328113e-02f, 1.08727492e-01f, -2.83349864e-02f, -8.69750828e-02f, -1.74235225e-01f, -6.69590309e-02f, -9.36766565e-02f,
  9.60370898e-03f, 2.08956450e-02f, -1.65826842e-01f, 2.24451855e-01f, 2.07959011e-01f, -2.12016895e-01f, -5.73892415e-01f, -2.83654571e-01f, 2.16567025e-01f, 1.05047049e-02f,
  2.55970627e-01f, 2.45322704e-01f, 9.34943780e-02f, -1.04100809e-01f, -2.20919743e-01f, -9.35841575e-02f, -9.99241918e-02f, -1.23365983e-01f, -2.09831119e-01f, -3.78573835e-02f,
  4.72310036e-02f, 1.22102357e-01f, 1.21706519e-02f, -8.32827687e-02f, 2.15670779e-01f, 1.78803563e-01f, 8.61003175e-02f, 3.74291033e-01f, 2.43836805e-01f, 3.30299526e-01f,
  2.71587402e-01f, -9.55052599e-02f, -1.48671061e-01f, 2.35429436e-01f, 2.15680525e-01f, -1.01363428e-01f, 5.57326414e-02f, 4.98090424e-02f, 1.57752875e-02f, 8.23132917e-02f,
  2.82922179e-01f, 1.05188780e-01f, 1.05451904e-01f, 8.94737244e-02f, 3.07107829e-02f, -1.90352410e-01f, -8.57978538e-02f, -2.19485402e-01f, -3.30428332e-01f, -1.82022855e-01f,
  8.83870721e-02f, 2.09446192e-01f, -1.51143640e-01f, -2.27773800e-01f, -2.09667921e-01f, 4.00569849e-03f, -1.41810551e-01f, 7.23178387e-02f, -6.35851622e-02f, -1.15936697e-01f,
  -1.08516850e-01f, 4.88100089e-02f, 7.03362748e-02f, -4.70577814e-02f, 3.37844677e-02f, 9.65905413e-02f, 3.58435363e-02f, 6.61336780e-02f, 5.46619073e-02f, -6.71330020e-02f,
  -4.89095263e-02f, -7.07132518e-02f, -3.01603545e-02f, 2.06428785e-02f, 6.73125088e-02f, 1.11845352e-01f, 8.38599801e-02f, 5.41806705e-02f, -3.78833860e-02f, -2.99787391e-02f,
  -9.31230281e-03f, 1.59702618e-02f, 2.74193995e-02f, 1.07489474e-01f, 8.00422356e-02f, -4.20671143e-02f, 1.16495319e-01f, 1.16150424e-01f, 3.68785076e-02f, -9.49965883e-03f,
  -5.98681085e-02f, -8.41934532e-02f, 1.25169039e-01f, -6.93499073e-02f, 6.15764745e-02f, -9.48399231e-02f, -1.29895546e-02f, 1.36650335e-02f, 6.90669492e-02f, -7.61179999e-02f,
  -3.47232297e-02f, -4.94726524e-02f, -1.65038947e-02f, -3.78021188e-02f, -2.98455991e-02f, 1.55060843e-01f, 8.42468515e-02f, -4.12407890e-02f, -8.97909105e-02f, 1.88698452e-02f,
  -4.63947952e-02f, -1.34661764e-01f, -2.70791769e-01f, -3.22225451e-01f, 3.13264616e-02f, -5.46494387e-02f, -1.01650491e-01f, -5.80098443e-02f, -1.64968953e-01f, -4.95240778e-01f,
  -6.01350605e-01f, 3.48517418e-01f, -1.29402637e-01f, 1.13648802e-01f, 1.56884827e-02f, -3.50296944e-01f, -1.66550159e-01f, -1.44263014e-01f, 2.15340659e-01f, 2.88186103e-01f,
  2.48974890e-01f, 4.09857966e-02f, 1.50774429e-02f, -2.07957886e-02f, -4.19322699e-01f, -9.83964801e-02f, -1.55616269e-01f, -4.59322095e-01f, -4.85980570e-01f, -1.90979660e-01f,
  -8.93570483e-02f, -2.26481929e-01f, -3.23759675e-01f, -1.67963177e-01f, 3.77330989e-01f, 9.05909482e-03f, 5.94445728e-02f, -7.48089477e-02f, 4.30938527e-02f, 3.35886568e-01f,
  4.05376732e-01f, -6.29954934e-02f, -2.25178432e-02f, -1.27110153e-01f, 5.17951027e-02f, -1.33074657e-03f, -1.73859764e-02f, 4.08097766e-02f, -4.09565829e-02f, 7.87671730e-02f,
  -4.55691516e-02f, -8.93156603e-03f, -7.16434270e-02f, 6.11710325e-02f, -1.03179179e-01f, 1.08548431e-02f, -5.70680797e-02f, -9.77330282e-02f, -7.68517852e-02f, 1.47222489e-01f,
  1.51747391e-01f, -1.53003767e-01f, 8.55537355e-02f, 8.54832083e-02f, -1.57095715e-01f, -6.45014942e-02f, 1.80489421e-01f, 3.22358049e-02f, -2.14785531e-01f, 2.38041595e-01f,
  1.51475459e-01f, 1.90700665e-02f, -4.19353284e-02f, 3.13770995e-02f, -1.20280543e-02f, 6.28768131e-02f, 4.77602668e-02f, 1.67808264e-01f, -2.10773777e-02f, -1.87135227e-02f,
  1.84217766e-01f, -8.75690654e-02f, -9.43693966e-02f, 1.18207000e-01f, -1.06101977e-02f, -3.50552425e-02f, 1.63513627e-02f, 5.98472357e-02f, -4.68083620e-02f, 4.18120474e-02f,
  -1.16648050e-02f, 5.10232821e-02f, 7.49129951e-02f, 3.60863544e-02f, 4.57835682e-02f, -8.55068490e-02f, 1.92360599e-02f, -6.44238070e-02f, -9.95879695e-02f, -8.98814425e-02f,
  3.54257345e-01f, -3.72073889e-01f, 1.30525813e-01f, -4.76099662e-02f, -7.63453245e-02f, 1.20071955e-01f, 1.32396653e-01f, 3.41976024e-02f, 2.05317184e-01f, 1.44383267e-01f,
  8.54950473e-02f, 4.22423370e-02f, 4.07059416e-02f, 7.24828541e-02f, -3.89586203e-02f, -1.02256527e-02f, 8.51626508e-03f, 7.38076046e-02f, -3.95026244e-03f, 2.56206244e-01f,
  2.49197215e-01f, 6.64300546e-02f, 2.02070758e-01f, 1.18575245e-01f, 1.87596101e-02f, -3.45796719e-02f, 2.45258480e-01f, 1.05322696e-01f, -1.49906904e-01f, 2.04646170e-01f,
  6.42063797e-01f, 3.53801250e-01f, 1.52592748e-01f, 1.93768054e-01f, -2.45187879e-01f, -1.28074018e-02f, -9.75396186e-02f, 1.47172865e-02f, 9.02730078e-02f, 2.51031339e-01f,
  2.59886503e-01f, 2.75548011e-01f, -4.45834128e-03f, 5.39439842e-02f, 4.27990854e-02f, -2.73628253e-02f, -6.31575882e-02f, 5.99073507e-02f, 1.20478878e-02f, 3.10758669e-02f,
  1.40562624e-01f, 1.46801189e-01f, 2.99837142e-01f, 7.02833161e-02f, 1.53322101e-01f, 1.82999045e-01f, 3.87006178e-02f, 1.15629129e-01f, 1.98510006e-01f, 3.23376298e-01f,
  2.81723112e-01f, 1.06978163e-01f, -2.88540265e-03f, 4.16397080e-02f, 1.35016128e-01f, 9.70819816e-02f, 6.67061284e-02f, 4.64722663e-02f, 1.06104035e-02f, -4.76284325e-02f,
  2.15924717e-02f, 8.22619200e-02f, -1.86197311e-01f, 1.00836568e-01f, -6.57407418e-02f, 7.51487538e-02f, -1.06129646e-01f, 6.81723952e-02f, 3.30954194e-02f, 1.16823681e-01f,
  5.35546914e-02f, 9.43531469e-02f, -1.45145327e-01f, -1.78499386e-01f, -4.47556600e-02f, -1.16130020e-02f, 4.47010025e-02f, 2.53242459e-02f, -1.06431358e-02f, 1.90443605e-01f,
  3.40501405e-02f, -4.31278981e-02f, 2.26363186e-02f, -7.84162655e-02f, -8.86987746e-02f, -1.03666641e-01f, -2.80313585e-02f, 3.58719677e-02f, -8.58678892e-02f, -8.82981420e-02f,
  -6.16365485e-02f, -6.20372109e-02f, -7.75747001e-03f, 1.82496980e-02f, 8.10742080e-02f, 7.18095899e-02f, 1.27690271e-01f, 1.39495447e-01f, -6.23873398e-02f, 3.77288833e-03f,
  7.32645765e-02f, -5.43503873e-02f, 3.66531126e-02f, 6.11063465e-03f, 3.86180878e-02f, -2.70453710e-02f, 1.03920937e-01f, -3.70717724e-03f, -5.63532338e-02f, 1.98602490e-02f,
  9.27277934e-03f, -2.79846162e-01f, 9.36544985e-02f, 3.73618938e-02f, 7.48412907e-02f, 7.89874643e-02f, 7.63330236e-02f, -3.35492752e-02f, -3.41503285e-02f, 9.80615467e-02f,
  4.85674851e-02f, 1.75271675e-01f, 5.52768409e-02f, 3.47906239e-02f, -6.42908737e-02f, 1.01566790e-02f, 1.51687816e-01f, 3.41725312e-02f, 2.82490179e-02f, 8.29450637e-02f,
  5.15063368e-02f, 4.11032885e-02f, -5.70208281e-02f, -2.90985852e-02f, -4.28817794e-02f, -1.37434900e-01f, -6.80031180e-02f, -1.67075451e-03f, -3.01700253e-02f, -1.80595353e-01f,
  -3.85911524e-01f, 1.20108053e-01f, -2.43368849e-01f, -3.41515660e-01f, -1.49972484e-01f, -1.08043775e-01f, 3.13263297e-01f, 1.20777898e-02f, -2.37771019e-01f, 9.23141558e-03f,
  6.22464307e-02f, -7.43630994e-03f, -9.33279693e-02f, 7.23268390e-02f, 7.36858696e-02f, 1.24168143e-01f, -2.15306669e-01f, -1.09020367e-01f, 1.98568217e-02f, 1.00879744e-01f,
  1.99864641e-01f, 6.35176003e-02f, -9.31576267e-02f, -7.06926212e-02f, -8.85798484e-02f, -2.66056266e-02f, -1.11275099e-01f, -2.81533450e-01f, -1.03583746e-01f, -2.08087504e-01f,
  3.54657710e-01f, -4.01412338e-01f, -2.04104066e-01f, -2.54962444e-01f, 4.38120961e-02f, -1.22126535e-01f, 3.96075360e-02f, -1.25264898e-01f, -1.00592799e-01f, 3.14440159e-03f,
  -2.21758574e-01f, -1.31566167e-01f, -4.85395594e-03f, -1.05235599e-01f, 3.02430820e-02f, 1.76360831e-02f, -1.38716381e-02f, -2.40091562e-01f, -1.93305627e-01f, -6.48327544e-03f,
  -1.79659892e-02f, -7.57547021e-02f, -3.96234402e-03f, -5.71074076e-02f, -1.16388261e-01f, -1.06555568e-02f, 4.27157916e-02f, -8.47163647e-02f, -1.72510549e-01f, 8.09390768e-02f,
  -6.86314031e-02f, -3.08264215e-02f, 3.78497248e-03f, 1.24361351e-01f, 1.36298776e-01f, 1.45367071e-01f, 1.04715340e-02f, 2.00581968e-01f, 2.63501089e-02f, 8.81904513e-02f,
  5.89946881e-02f, -5.87249286e-02f, 6.58118799e-02f, 2.01468151e-02f, -4.10917066e-02f, -6.44723997e-02f, 3.85196414e-03f, 3.24916430e-02f, -1.65479079e-01f, -1.72107011e-01f,
  -7.08808452e-02f, -2.00272053e-01f, -2.74277627e-02f, -3.45314741e-02f, -1.75086349e-01f, -4.00406905e-02f, -7.45243132e-02f, -8.25216919e-02f, 1.29012257e-01f, -9.00241733e-02f,
  4.78500754e-01f, -1.99740469e-01f, 1.66578874e-01f, -4.04831432e-02f, 1.50441693e-03f, -5.47131933e-02f, -1.08441591e-01f, -1.02397442e-01f, -9.13690254e-02f, 1.10937014e-01f,
  -2.33556330e-02f, 1.54131576e-01f, 1.30859792e-01f, 7.62070389e-03f, 7.71346167e-02f, -1.41343083e-02f, 1.02782525e-01f, 4.33563106e-02f, -1.75948128e-01f, -8.10353830e-02f,
  -7.37204477e-02f, 9.98157412e-02f, 1.87232107e-01f, 1.36146918e-01f, 1.53999686e-01f, 2.38184094e-01f, 2.48867497e-01f, 3.31376530e-02f, 1.94589235e-02f, 4.12370503e-01f,
  -5.44220209e-01f, 1.61516577e-01f, 5.55204451e-02f, 8.22424144e-02f, 2.86078185e-01f, 2.65289485e-01f, 3.28492492e-01f, 1.98884964e-01f, 8.16475749e-02f, 2.52481438e-02f,
  -3.36004682e-02f, -6.92610443e-02f, 1.76274199e-02f, 1.75720856e-01f, 2.20151812e-01f, 1.91942304e-01f, 2.54615873e-01f, -7.75229111e-02f, -9.07515362e-02f, 4.86893915e-02f,
  1.19545445e-01f, -1.14817128e-01f, -2.65520245e-01f, 4.74637821e-02f, 2.73719821e-02f, 6.44218177e-02f, 1.71326905e-01f, 2.81956736e-02f, 1.18441060e-01f, 7.75071383e-02f,
  -2.47328598e-02f, -2.44486898e-01f, -6.17763773e-02f, 8.70206133e-02f, 1.64108202e-02f, -2.92635590e-01f, -2.06921756e-01f, -8.48332569e-02f, -1.55794751e-02f, -9.94492546e-02f,
  6.21201210e-02f, 1.79012623e-02f, 9.42142978e-02f, -2.88310852e-02f, -1.00850493e-01f, -5.66834435e-02f, 1.71838962e-02f, 5.87455928e-02f, 2.18318418e-01f, 1.72448903e-01f,
  1.15825951e-01f, -6.70292974e-02f, 2.26518884e-01f, 1.45398214e-01f, 2.37742245e-01f, 1.61026642e-02f, 1.23612538e-01f, -2.23018415e-03f, 1.20233983e-01f, 8.02766532e-02f,
  1.30104139e-01f, 1.81457214e-02f, 8.17520767e-02f, 1.39916271e-01f, 3.21336873e-02f, 1.77172124e-02f, 1.55458758e-02f, 4.39255796e-02f, 1.83130741e-01f, -8.25708434e-02f,
  -9.64645073e-02f, 4.93425652e-02f, -4.72624861e-02f, -6.75974563e-02f, -1.39510497e-01f, -7.20409676e-02f, 1.43550057e-02f, 4.98521095e-03f, -5.94179258e-02f, 2.73499242e-03f,
  -5.15551269e-02f, 1.27190039e-01f, -1.18955048e-02f, 2.57921126e-02f, -5.98304421e-02f, -8.79418328e-02f, -7.80789033e-02f, 8.93719960e-03f, -1.76834017e-01f, -1.74480289e-01f,
  1.77695915e-01f, 5.47552072e-02f, -1.32909417e-01f, -2.18324102e-02f, -8.26276317e-02f, -9.55483317e-02f, -1.38438076e-01f, -6.89025894e-02f, 7.06579909e-03f, 5.84834777e-02f,
  3.75739671e-02f, -9.48083103e-02f, -4.40438986e-02f, -8.33472610e-02f, -2.65101194e-01f, -8.24641809e-02f, 5.29148243e-03f, 1.41721696e-01f, 1.53402671e-01f, 1.56888977e-01f,
  3.83080095e-02f, 2.48355400e-02f, -9.33669582e-02f, -2.54191365e-03f, -6.54414594e-02f, -1.42360389e-01f, -1.12430744e-01f, -9.75858420e-02f, -6.24032766e-02f, -1.36889607e-01f,
  6.43324614e-01f, 2.95779198e-01f, 6.55940473e-02f, 2.03663692e-01f, -1.57650858e-01f, -5.30198850e-02f, -7.35752359e-02f, -3.33056413e-02f, 7.65730962e-02f, 2.83681720e-01f,
  2.15132758e-01f, 2.02330753e-01f, -1.92346200e-02f, -4.90920991e-02f, 3.18920538e-02f, -8.73770416e-02f, -4.93277535e-02f, 3.40717621e-02f, -1.05710007e-01f, 1.17576532e-01f,
  8.23754221e-02f, 1.06105424e-01f, 2.29163960e-01f, -5.21829575e-02f, 1.13143250e-01f, -9.83521109e-04f, 7.82328919e-02f, 8.13794732e-02f, 2.78308289e-03f, 2.04885185e-01f,
  1.29145131e-01f, 3.09640020e-01f, -1.30337879e-01f, 3.34535055e-02f, 8.55136290e-03f, 6.31933212e-02f, -4.69244681e-02f, 9.88425985e-02f, 1.55640300e-02f, -4.93071461e-03f,
  8.03720206e-03f, 8.63694400e-02f, 1.10392831e-02f, -1.50514171e-02f, 5.07756323e-03f, -4.79926765e-02f, 9.71659571e-02f, -2.31408019e-04f, -1.63145233e-02f, 4.55134362e-02f,
  6.80974275e-02f, 6.09553903e-02f, -7.27123022e-02f, -9.38464701e-02f, 2.52814554e-02f, -3.61873880e-02f, -3.48024890e-02f, 3.14400755e-02f, -9.75903720e-02f, 3.09292316e-01f,
  2.07348257e-01f, 5.23750149e-02f, 5.63803054e-02f, 2.21714247e-02f, 2.18870670e-01f, 3.85911539e-02f, -3.09711266e-02f, 3.10728364e-02f, -5.54376319e-02f, 2.79719359e-03f,
  2.96191573e-02f, 7.75163993e-03f, 3.81426476e-02f, 5.48635535e-02f, -2.28106324e-02f, -7.93213323e-02f, -9.36307609e-02f, 3.44249904e-02f, 3.67008820e-02f, -2.99103442e-03f,
  2.03801058e-02f, -4.37439866e-02f, 2.01200298e-03f, 7.91902095e-02f, 1.23009793e-02f, 7.51906261e-02f, -4.82570007e-02f, 9.29296166e-02f, 1.13881618e-01f, 1.45060420e-01f,
  -3.51641178e-01f, -7.18934759e-02f, 1.85544744e-01f, -3.83647718e-02f, -2.83768494e-02f, 2.15865043e-03f, 3.62110808e-02f, -1.24541976e-01f, -1.05932690e-01f, 7.22043663e-02f,
  2.67725810e-03f, 7.72559494e-02f, -9.48591009e-02f, -3.02374549e-02f, 7.43117556e-02f, -1.68387741e-02f, 4.60030995e-02f, -1.10138275e-01f, -1.91002056e-01f, -4.10104729e-02f,
  -2.50402503e-02f, -8.09349120e-02f, -1.89453378e-01f, -1.04733057e-01f, 1.98479481e-02f, -9.47576761e-02f, -1.87834233e-01f, -1.82985425e-01f, -9.54660326e-02f, -4.58149835e-02f,
  2.67243385e-01f, 6.75501600e-02f, -5.41026771e-01f, 1.07307076e-01f, -9.60228145e-02f, -4.83120456e-02f, -6.90025091e-02f, 1.91028327e-01f, 2.30397925e-01f, -7.70066008e-02f,
  -2.05303747e-02f, 1.34874880e-01f, -2.16938108e-01f, -3.66670117e-02f, -1.63439870e-01f, -4.12428379e-01f, -3.66581172e-01f, -2.86210656e-01f, 6.39719283e-03f, 1.46486968e-01f,
  1.60139501e-01f, -8.01942497e-02f, 8.57976153e-02f, 6.76370040e-02f, -5.78207560e-02f, -2.34561160e-01f, -4.55667496e-01f, -2.03539267e-01f, -1.65255293e-01f, -3.71016622e-01f,
  -5.18922031e-01f, -7.84026384e-02f, 5.49362320e-03f, 1.83351845e-01f, -1.08964965e-01f, 1.20515295e-04f, -4.91685383e-02f, -1.46295667e-01f, -3.16363946e-02f, -2.12726723e-02f,
  -9.55895483e-02f, 1.14439756e-01f, -9.16391835e-02f, -4.86930758e-02f, -1.83168128e-02f, 7.21592680e-02f, 6.72028139e-02f, -4.86506075e-02f, -3.55543867e-02f, 1.79155190e-02f,
  1.83320105e-01f, -5.09366579e-02f, -1.32306457e-01f, -5.20436019e-02f, -1.08909100e-01f, -2.02882513e-01f, -9.66078788e-02f, -1.23074085e-01f, -2.60352522e-01f, -7.18911067e-02f,
  1.06539562e-01f, 3.49694304e-02f, 7.37396777e-02f, 2.17601597e-01f, 1.50256649e-01f, 1.04463063e-02f, -6.55732453e-02f, 5.41644059e-02f, 2.93962434e-02f, 4.63133268e-02f,
  1.10026225e-01f, -5.59835136e-02f, 2.49036402e-02f, -6.77202195e-02f, -2.43560150e-01f, -8.72496590e-02f, -2.03561205e-02f, -6.37174398e-02f, -6.43587857e-02f, 1.12687387e-01f,
  6.86134920e-02f, 3.49312872e-02f, 5.41111380e-02f, -5.66299073e-03f, -1.12300692e-02f, -1.72625107e-04f, -2.24026740e-02f, 1.10666126e-01f, 1.83887422e-01f, -5.95346242e-02f,
  1.71994671e-01f, -1.40377164e-01f, -7.32726082e-02f, -3.68541777e-02f, 1.18588328e-01f, 7.04180971e-02f, 3.26741338e-02f, 7.06889927e-02f, 1.88649133e-01f, 1.02867447e-01f,
  1.25579953e-01f, 8.54633525e-02f, -2.79008709e-02f, -4.46647294e-02f, 8.71671587e-02f, -2.01932341e-02f, 1.50624827e-01f, 5.24238013e-02f, 9.37462673e-02f, 1.55321404e-01f,
  2.16758430e-01f, 2.53132612e-01f, 2.07310677e-01f, -2.36222949e-02f, 1.08459711e-01f, -2.08873510e-01f, -3.55095640e-02f, -4.22747582e-02f, -7.08665326e-02f, 1.63657427e-01f,
  -2.68759519e-01f, -2.83513188e-01f, -3.01041812e-01f, 4.07650657e-02f, 6.47139251e-02f, -8.31413493e-02f, -4.10222769e-01f, -3.15344147e-02f, -4.33254465e-02f, -2.93879807e-01f,
  2.22148225e-02f, 2.04580680e-01f, -1.49980679e-01f, -1.23831265e-01f, -4.18499261e-01f, -6.24456406e-01f, -5.00814319e-01f, -3.87873024e-01f, -3.87106277e-02f, 2.16377661e-01f,
  1.50579125e-01f, -3.34663689e-02f, -1.25557482e-01f, -1.28286988e-01f, -3.03588025e-02f, -1.39891386e-01f, -2.29270995e-01f, -1.38717815e-01f, -4.31421809e-02f, -3.14234912e-01f,
  -3.03582728e-01f, 7.24732950e-02f, 1.76352058e-02f, 7.67285898e-02f, -1.07362464e-01f, 7.16623440e-02f, -1.12532467e-01f, -1.76478505e-01f, 2.86703333e-02f, -7.53295645e-02f,
  2.28835046e-01f, 3.45837474e-01f, 7.15380237e-02f, 1.79834574e-01f, -1.65136587e-02f, -4.00460549e-02f, -1.75011918e-01f, -9.16864127e-02f, -1.35541126e-01f, 6.81530731e-03f,
  1.36402562e-01f, 3.62469554e-02f, -1.44420713e-01f, 9.71461460e-02f, 7.15613142e-02f, 3.51817571e-02f, -1.40806884e-02f, 2.22934604e-01f, -1.02314860e-01f, -2.18668818e-01f,
  -1.10064156e-01f, -1.59153953e-01f, 1.89800223e-04f, 4.65242229e-02f, 6.30061775e-02f, 8.87278691e-02f, -2.56856978e-02f, -1.74355567e-01f, -8.09482634e-02f, -8.37860033e-02f,
  -6.81559369e-02f, 2.44531892e-02f, 7.45946541e-02f, -2.25661285e-02f, -1.08930334e-01f, -8.27233959e-03f, -8.60644728e-02f, -1.36285886e-01f, 3.36213857e-02f, -8.23633522e-02f,
  -7.97272027e-02f, 1.54175192e-01f, 1.35304006e-02f, -2.23839190e-02f, -8.78326297e-02f, -1.83294520e-01f, -4.21106704e-02f, -9.78862420e-02f, 2.93518752e-02f, -9.78325009e-02f,
  -2.79820025e-01f, -1.43777832e-01f, -2.66734272e-01f, -4.57686931e-02f, -1.41992524e-01f, 5.41859008e-02f, 4.63890396e-02f, 6.59092097e-03f, -3.28670926e-02f, -4.90287766e-02f,
  1.08956341e-02f, 7.30692670e-02f, 1.11915106e-02f, 8.66488069e-02f, 1.97834522e-02f, 1.31221876e-01f, -3.90650779e-02f, -1.21772379e-01f, 1.63468391e-01f, 2.21752346e-01f,
  5.66028431e-02f, -1.06662862e-01f, -1.58669844e-01f, -1.74041409e-02f, -6.50878763e-03f, -1.77212898e-02f, -2.42416531e-01f, -6.62314240e-03f, -2.13892028e-01f, -3.05254549e-01f,
  -5.41015267e-01f, 2.12009609e-01f, -9.42364857e-02f, -2.62573212e-01f, 2.89465547e-01f, 1.07755840e-01f, 1.70328572e-01f, 1.81767240e-03f, -1.49360806e-01f, 1.22715391e-01f,
  2.98089564e-01f, 1.95111066e-01f, 1.85599536e-01f, 1.75306380e-01f, 1.25579640e-01f, 3.02512586e-01f, 1.72016948e-01f, 1.18993158e-02f, 2.11085528e-02f, -1.97433314e-04f,
  9.15988684e-02f, -1.28337830e-01f, -3.47435147e-01f, 3.98948863e-02f, -9.76871699e-02f, -4.65761386e-02f, -3.88874635e-02f, -2.92798765e-02f, -5.56095466e-02f, -3.21508721e-02f,
  -1.39056265e-01f, -2.53322721e-01f, 7.81071708e-02f, 1.20523952e-01f, -3.48240398e-02f, -1.45392165e-01f, 1.54028321e-02f, -1.39995977e-01f, 6.32163584e-02f, -9.59927887e-02f,
  1.13366783e-01f, -9.02068093e-02f, 2.24348247e-01f, -4.70641181e-02f, -2.44210899e-01f, -1.73742771e-01f, -1.15239225e-01f, -1.81292340e-01f, -2.97964960e-01f, -1.62512138e-01f,
  2.49641582e-01f, 6.32119253e-02f, -2.06074297e-01f, -1.95328388e-02f, 5.05107604e-02f, 5.77813499e-02f, -1.63186833e-01f, -1.95729777e-01f, -3.12746942e-01f, -4.02504563e-01f,
  2.46832203e-02f, 4.08764705e-02f, -1.59869567e-02f, 3.11338641e-02f, 9.78432298e-02f, 1.22368015e-01f, 1.12086266e-01f, 1.28656089e-01f, 5.29302172e-02f, -7.38727152e-02f,
  4.71977480e-02f, -6.77928627e-02f, -4.62365225e-02f, -2.47277059e-02f, 8.26891605e-03f, 8.15329701e-03f, -1.15745431e-02f, -1.37853846e-01f, 4.43051048e-02f, 4.31003496e-02f,
  -6.11963263e-03f, 3.09575424e-02f, 9.39037353e-02f, -3.53999399e-02f, 3.48769948e-02f, -1.16360508e-01f, -2.60666180e-02f, 9.50787496e-03f, 8.94235913e-03f, -9.68755409e-02f,
  -1.65103078e-01f, 2.64280915e-01f, -9.17896032e-02f, 1.33757129e-01f, -8.86390805e-02f, -4.18204404e-02f, -5.87629229e-02f, 3.49053778e-02f, -4.10808511e-02f, -1.26693889e-01f,
  6.26703501e-02f, -9.79257897e-02f, 3.25642787e-02f, 2.57299133e-02f, -1.14931174e-01f, -2.50110067e-02f, 6.45077154e-02f, -8.89657214e-02f, 8.89486913e-03f, -8.37463364e-02f,
  -1.28303990e-02f, 1.85664073e-02f, -1.82101026e-01f, -1.27938882e-01f, -1.22507906e-03f, -2.07490325e-01f, -2.25483388e-01f, -2.43106708e-01f, -2.34692693e-01f, -3.62364709e-01f,
  1.34269252e-01f, 1.01187378e-02f, 2.84211755e-01f, 2.42811114e-01f, 8.89401510e-02f, -3.25472564e-01f, -4.27091956e-01f, -3.20684940e-01f, -3.93235013e-02f, -4.79304604e-02f,
  2.25961711e-02f, -1.08194664e-01f, 6.27207085e-02f, -8.46151263e-02f, -1.62858516e-01f, -2.29312610e-02f, 1.37012899e-01f, 1.39338508e-01f, -1.48003653e-01f, -3.09150755e-01f,
  -3.64526734e-02f, 1.45221859e-01f, 2.09092483e-01f, -6.09597228e-02f, 1.49801880e-01f, -7.09660277e-02f, 2.76254684e-01f, 2.85560727e-01f, 4.29168306e-02f, 2.87991226e-01f,
  1.91001505e-01f, 7.75419623e-02f, -6.52828291e-02f, 1.38033167e-01f, 3.66438657e-01f, -1.05261378e-01f, -1.59619227e-01f, 2.07057491e-01f, -3.75717431e-02f, -4.88081165e-02f,
  3.32056493e-01f, 5.37712127e-02f, 1.64648801e-01f, -1.10157616e-01f, -7.88467079e-02f, -1.06243886e-01f, -1.15801049e-02f, 5.73494546e-02f, 8.46283734e-02f, -2.73261696e-01f,
  -4.05103937e-02f, 6.65130690e-02f, 4.05860208e-02f, -7.58769810e-02f, -8.10540169e-02f, 1.99994043e-01f, -5.73021639e-03f, -1.91687122e-01f, -1.20666094e-01f, -6.56228662e-02f,
  -1.46918237e-01f, 1.25196055e-01f, -4.48750146e-02f, -1.11856930e-01f, -2.91482881e-02f, 4.44872258e-03f, 9.91146266e-02f, 2.18265969e-02f, 3.39935395e-05f, -7.29604810e-02f,
  -6.82435110e-02f, 3.80251072e-02f, -3.72261032e-02f, -4.53746468e-02f, 6.40608072e-02f, -5.31542897e-02f, -9.57920849e-02f, -7.83184543e-02f, -8.36089253e-02f, 9.71309666e-04f,
  -3.91076617e-02f, 1.53746635e-01f, -1.19801471e-03f, -6.84555471e-02f, -1.64373040e-01f, 6.82090893e-02f, -9.94047299e-02f, -1.12470537e-01f, 1.71083137e-02f, 3.19709778e-02f,
  -7.68903866e-02f, 5.94641156e-02f, 2.13989615e-02f, -2.49743480e-02f, 7.76738226e-02f, -4.87747118e-02f, -3.64391170e-02f, -1.79336901e-04f, 8.09401497e-02f, -1.00394271e-01f,
  -2.11739078e-01f, -4.67680059e-02f, 8.70354697e-02f, -6.63445964e-02f, -9.57717821e-02f, -1.40262708e-01f, 5.56096435e-02f, -6.24019578e-02f, -5.20458445e-02f, 5.75366372e-04f,
  -1.41410217e-01f, -2.65221149e-01f, -1.29862562e-01f, -1.31911770e-01f, 2.17548385e-02f, -1.34345502e-01f, -1.78336993e-01f, -2.88034171e-01f, -2.52632260e-01f, -3.09372246e-01f,
  7.96656311e-02f, 4.99342203e-01f, 3.41027558e-01f, -8.65590125e-02f, 2.18000129e-01f, 3.43945712e-01f, 4.85478401e-01f, 7.24612325e-02f, -1.51273042e-01f, 1.40829623e-01f,
  2.77804792e-01f, -1.00931004e-01f, -1.39543936e-01f, -1.94015786e-01f, -1.69124693e-01f, -8.08922108e-03f, -5.15762493e-02f, -1.86015993e-01f, -3.77163738e-01f, -3.01033944e-01f,
  -2.10584417e-01f, 3.21810395e-02f, -5.76088168e-02f, -2.27749437e-01f, -1.80770233e-01f, -4.32597846e-01f, 1.84972227e-01f, 1.20648116e-01f, 6.70441315e-02f, -1.08978227e-01f,
  7.70311877e-02f, 4.95890647e-01f, -3.64993364e-01f, -2.02206716e-01f, 1.82207555e-01f, -1.62359685e-01f, -1.03291139e-01f, -3.18040326e-02f, 3.77129540e-02f, 2.27602362e-03f,
  1.57130599e-01f, 6.78414032e-02f, 3.89579087e-02f, 2.43589119e-03f, 2.02725306e-01f, 2.04440001e-02f, 1.12446278e-01f, -1.61300004e-01f, -8.25107172e-02f, 2.13570669e-02f,
  8.24684352e-02f, 2.09534392e-01f, 3.16222250e-01f, 4.55051754e-03f, 9.99053046e-02f, -1.92320690e-01f, 2.07738224e-02f, 1.53383529e-02f, 1.02761924e-01f, -8.99475291e-02f,
  8.19472820e-02f, 9.83359292e-02f, -6.83718873e-03f, -7.46454298e-03f, 1.13343842e-01f, 1.18308239e-01f, 9.18228552e-03f, 8.01819712e-02f, -1.33770600e-01f, 4.60449867e-02f,
  1.00379236e-01f, -9.15591270e-02f, 5.79540171e-02f, 1.08782418e-01f, 1.62010994e-02f, 1.27932295e-01f, 8.30674320e-02f, -7.51574934e-02f, 2.36056950e-02f, -1.39019815e-02f,
  4.61495761e-03f, 1.97849981e-02f, 5.64896800e-02f, -2.82753445e-02f, 7.21105635e-02f, -3.26210260e-02f, -4.43008319e-02f, 7.60991732e-03f, 6.23176135e-02f, 2.09823996e-01f,
  -1.96421713e-01f, 2.24789113e-01f, -2.58104891e-01f, 4.45167236e-02f, 1.54398724e-01f, 1.11415824e-02f, 8.60166848e-02f, -6.75967932e-02f, 8.11474025e-02f, -1.74297001e-02f,
  3.03816702e-02f, 5.67429550e-02f, 1.36896908e-01f, -4.06802446e-02f, -2.44452097e-02f, 3.31620798e-02f, 1.12740472e-01f, -5.80250286e-02f, -1.58471748e-01f, -2.91594192e-02f,
  -9.07671675e-02f, -1.78303346e-01f, -1.66378513e-01f, -6.60211593e-02f, -1.89331416e-02f, -2.05406398e-01f, -1.21342968e-02f, -1.10045686e-01f, -7.26022646e-02f, -2.63276875e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  2.35435013e-02f, 1.97015300e-01f, 3.49391043e-01f, 1.40243703e-02f, 1.42156780e-01f, 1.15017705e-01f, -8.87474492e-02f, 2.66589783e-02f, 1.94034204e-02f, 7.18061700e-02f,
  2.88828522e-01f, -7.24107549e-02f, 2.38389447e-01f, -4.60347310e-02f, 3.34175676e-01f, 1.28957376e-01f, 1.99234992e-01f, 5.67668341e-02f, 1.83532998e-01f, 2.64748391e-02f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  8.94359574e-02f, 9.04446915e-02f, 1.28605098e-01f, 2.28926599e-01f, -1.90237369e-02f, -1.63821504e-01f, 2.09318265e-01f, 1.88046426e-01f, 8.23587459e-03f, 4.80128117e-02f,
  -2.29793012e-01f, 3.88155542e-02f, 1.69959292e-02f, -1.37916222e-01f, 2.05745827e-02f, 1.47231296e-01f, 6.45345598e-02f, -2.86451072e-01f, 2.82681078e-01f, -2.96658516e-01f,
  3.39993626e-01f, -9.50045139e-02f, -3.39518897e-02f, -2.94968516e-01f, 1.20580606e-01f, 1.07057504e-01f, -2.78323710e-01f, -7.91628510e-02f, -1.15295954e-01f, 1.53312668e-01f,
  -2.21963283e-02f, -6.54433388e-03f, -2.02266589e-01f, -6.97146878e-02f, 6.28563985e-02f, -2.83140186e-02f, -1.10395342e-01f, 5.66138960e-02f, 1.20327927e-01f, 2.99501996e-02f,
  -1.39629304e-01f, 1.77331716e-01f, -1.40823517e-02f, -1.27653927e-01f, -5.93087561e-02f, -3.15308750e-01f, 1.40003219e-01f, -6.86810315e-02f, -4.95575480e-02f, -1.46124929e-01f,
  1.05342858e-01f, -2.83872157e-01f, -1.15943566e-01f, -2.93309808e-01f, 7.75988698e-02f, -1.22556575e-01f, 1.00095131e-01f, -6.02642596e-02f, -1.15919828e-01f, -1.20333180e-01f,
  -3.11965466e-01f, -1.79965317e-01f, -1.65869877e-01f, -1.17033824e-01f, 2.70581921e-03f, 1.01500805e-02f, 2.20205057e-02f, 7.70642534e-02f, -3.74591202e-02f, 5.97057045e-02f,
  -1.73586950e-01f, -2.85975356e-02f, 2.09967375e-01f, -1.94296241e-01f, 7.48243630e-02f, -9.59971845e-02f, -2.49143422e-01f, 2.95925111e-01f, -9.79458019e-02f, -1.60722181e-01f,
  -4.91522960e-02f, 2.26091713e-01f, -4.64844853e-02f, 1.65181533e-01f, 3.09955537e-01f, -7.99884647e-02f, 1.21084966e-01f, 2.16397494e-01f, 3.80677991e-02f, 1.01237327e-01f,
  1.83360249e-01f, 1.00482516e-01f, -1.03499718e-01f, -2.15843990e-01f, 2.51793146e-01f, 2.59364516e-01f, -8.00008550e-02f, 8.57787430e-02f, 1.20609790e-01f, 1.45783238e-02f,
  -4.98627350e-02f, -7.79646784e-02f, -2.01639887e-02f, 2.33089417e-01f, 2.15874016e-01f, 1.81377098e-01f, -7.54124373e-02f, 2.33783066e-01f, 3.96069646e-01f, -4.34415638e-01f,
  -4.96242158e-02f, 7.25904182e-02f, -9.11347717e-02f, -4.66853566e-02f, 2.88304657e-01f, 2.58199900e-01f, -7.40425810e-02f, 8.32285658e-02f, 3.26402009e-01f, -1.77724063e-02f,
  3.01976830e-01f, -5.66644408e-02f, -2.27232352e-01f, 1.05377875e-01f, -2.50602774e-02f, 2.86738157e-01f, -5.52907040e-05f, -2.82303959e-01f, 1.05301075e-01f, 1.09345473e-01f,
  1.36011228e-01f, 1.77431442e-02f, 1.59509972e-01f, -8.47861916e-03f, 4.52961959e-02f, -6.49944767e-02f, 1.88040491e-02f, -8.48361030e-02f, 1.09683655e-01f, 8.97497125e-03f,
  -2.01921523e-01f, -2.52840668e-01f, -2.29194716e-01f, -2.05429435e-01f, -1.63652733e-01f, -8.16349164e-02f, -2.65890695e-02f, 2.37970605e-01f, 3.71112406e-01f, 1.12931408e-01f,
  2.15330705e-01f, 1.77423909e-01f, 1.80489495e-02f, 7.38576874e-02f, 1.42410919e-01f, -7.89845660e-02f, -1.63787857e-01f, 4.08956334e-02f, 6.65680915e-02f, 8.55441839e-02f,
  -4.19167578e-02f, 7.59224668e-02f, 2.03137621e-01f, -1.15214661e-01f, -7.35466853e-02f, 1.16046093e-01f, 3.20937008e-01f, -3.26260850e-02f, -3.05661827e-01f, 2.75390387e-01f,
  -4.57393266e-02f, 9.37203243e-02f, 3.54847282e-01f, -3.53330940e-01f, -9.26428810e-02f, 1.68890640e-01f, -1.99342549e-01f, 7.12281317e-02f, -1.46963634e-02f, 1.30053252e-01f,
  -1.09971099e-01f, 6.69822320e-02f, 3.98278952e-01f, -9.94079039e-02f, 2.36348167e-01f, 7.16396747e-03f, 1.62439644e-01f, 2.76365191e-01f, -3.31241004e-02f, 2.37165485e-02f,
  -2.70012170e-01f, -1.82243362e-01f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.89856604e-01f, -1.08850189e-02f, -2.61554495e-02f, -1.34275695e-02f, -1.53147364e-02f, -4.81404886e-02f, 5.19585330e-03f, -1.39821455e-01f, -3.66858661e-01f, 2.15259641e-01f,
  -1.31739527e-01f, -9.05282125e-02f, 2.03330249e-01f, -1.49516448e-01f, 3.44006233e-02f, 3.61860633e-01f, 4.47473586e-01f, 5.82741499e-02f, 1.67849865e-02f, 4.09498625e-02f,
  -3.09924930e-01f, 5.54034896e-02f, -3.41462791e-02f, -1.21675536e-01f, -6.25121891e-02f, -2.86091357e-01f, -2.65358448e-01f, 7.43547454e-02f, 3.67066830e-01f, 9.54343826e-02f,
  -3.36244166e-01f, 1.65328607e-02f, 3.63468707e-01f, 2.45022386e-01f, -7.44852517e-03f, 2.49898076e-01f, 3.12164724e-01f, 3.20141673e-01f, -1.38025090e-01f, 4.55024019e-02f,
  2.91600287e-01f, 3.08719367e-01f, 3.43186766e-01f, 1.16416946e-01f, 3.11797440e-01f, -5.01459002e-01f, 9.83354747e-02f, -1.79066826e-02f, -5.73465347e-01f, 1.87282279e-01f,
  -2.34149843e-01f, 3.05624425e-01f, 4.12879735e-02f, 3.40754420e-01f, -4.40647500e-03f, -1.62135754e-02f, 5.47379162e-03f, -2.45559633e-01f, -2.44808057e-03f, 2.83151746e-01f,
  2.45518282e-01f, 1.86323285e-01f, 7.32116774e-02f, 5.77521659e-02f, 6.70548975e-02f, 2.56356895e-01f, 1.84151620e-01f, 2.36889884e-01f, 1.42157897e-01f, 1.52934745e-01f,
  1.01136163e-01f, -9.91678052e-03f, -2.82048464e-01f, -2.05380097e-01f, -1.93352908e-01f, 5.94865240e-04f, -5.88999875e-02f, 2.33480439e-01f, -2.26950631e-01f, 1.99983686e-01f,
  2.52520233e-01f, -1.65834740e-01f, 1.73349842e-01f, -2.42902324e-01f, 2.68965870e-01f, -3.04280013e-01f, -1.75729722e-01f, -1.63858503e-01f, 1.15173891e-01f, 3.38654667e-01f,
  -1.59385964e-01f, -2.73579329e-01f, 3.55674364e-02f, 2.23322779e-01f, 8.67940858e-02f, 4.22465652e-01f, -2.80679502e-02f, -5.37685305e-02f, 1.45374194e-01f, -7.06421137e-02f,
  1.09061003e-01f, 1.97116449e-01f, -1.80913210e-01f, 6.11986853e-02f, 1.46834940e-01f, 2.30747476e-01f, 2.23817021e-01f, 1.20064192e-01f, 4.13841801e-03f, -3.62529270e-02f,
  2.14431450e-01f, -9.51376185e-02f, 1.98116690e-01f, 4.00178909e-01f, -4.77875583e-02f, 2.21024469e-01f, -2.41552517e-01f, 5.32638967e-01f, 8.11718497e-03f, 1.10605240e-01f,
  7.68181169e-03f, -1.37515530e-01f, 1.22420557e-01f, -2.32005045e-02f, 8.39094445e-02f, -7.71244988e-02f, 2.64512062e-01f, -3.23987275e-01f, 3.18270206e-01f, 6.88439906e-02f,
  3.07251930e-01f, 1.64275959e-01f, 7.02744424e-02f, 2.76590884e-01f, -3.40798438e-01f, -1.13215663e-01f, 2.00121254e-02f, 3.94627571e-01f, 2.23951012e-01f, 2.19856445e-02f,
  2.89337695e-01f, 2.67806947e-01f, 3.56245995e-01f, 1.67063460e-01f, 2.24548027e-01f, 1.78146765e-01f, -3.56767952e-01f, 1.53102100e-01f, -5.21385431e-01f, 5.65394498e-02f,
  -6.35904491e-01f, -2.14402586e-01f, -4.05689403e-02f, -1.57548085e-01f, -2.37142593e-01f, 1.63860589e-01f, 1.39402673e-01f, 1.93317920e-01f, -1.57338917e-01f, -2.05629200e-01f,
  6.21509589e-02f, 1.80366859e-01f, 4.34739739e-01f, 1.53700098e-01f, 1.70444131e-01f, 3.94531190e-01f, 1.50598079e-01f, -2.46061146e-01f, -2.39722073e-01f, 3.68020266e-01f,
  -4.65822145e-02f, -4.73664887e-02f, 9.53777209e-02f, 4.10816707e-02f, 5.77587746e-02f, 2.76222408e-01f, 6.65966645e-02f, 2.56829977e-01f, 8.14314708e-02f, -6.42836317e-02f,
  -3.95548403e-01f, -2.66278923e-01f, -9.79447179e-03f, -2.83363223e-01f, 5.70030391e-01f, -3.37338746e-01f, -3.61647993e-01f, 1.68619201e-01f, 5.30706812e-03f, -9.53424945e-02f,
  -5.09273931e-02f, 7.25995973e-02f, 2.39865556e-01f, 4.03654352e-02f, 2.59589016e-01f, 3.24887000e-02f, 1.13692626e-01f, 1.27053589e-01f, -1.28134772e-01f, -1.60450101e-01f,
  2.28305101e-01f, 7.05013722e-02f, 2.57697225e-01f, 6.71601072e-02f, -1.93745628e-01f, 2.63704091e-01f, 3.51773828e-01f, 2.23369017e-01f, -5.94224147e-02f, 2.79627979e-01f,
  -3.84255797e-02f, 1.84028834e-01f, -4.44795012e-01f, 1.70560896e-01f, -5.25547504e-01f, -2.46158950e-02f, -9.01873261e-02f, -1.15877576e-01f, 4.21565920e-01f, 3.93909246e-01f,
  2.55860716e-01f, 7.40746781e-03f, -8.52098465e-02f, -2.95443833e-01f, 1.84580281e-01f, 1.62443250e-01f, 1.09456480e-01f, 2.72995293e-01f, 2.45652631e-01f, 1.52861938e-01f,
  -2.66375899e-01f, 2.48289090e-02f, -3.98548573e-01f, -3.94342154e-01f, -7.97390863e-02f, 4.60617132e-02f, 1.02671772e-01f, -1.08846440e-03f, -1.91389136e-02f, 5.31035513e-02f,
  2.12112382e-01f, -2.68086404e-01f, 2.00429380e-01f, -4.23963934e-01f, 2.26501413e-02f, -1.45805618e-02f, -3.93184483e-01f, -1.02545366e-01f, -1.92096516e-01f, 3.68329823e-01f,
  2.72819370e-01f, -3.83705705e-01f, -1.29047260e-01f, 3.21274132e-01f, 1.38668522e-01f, 6.57157063e-01f, 4.31769311e-01f, 1.71707243e-01f, 8.94145742e-02f, 4.33814764e-01f,
  1.15289912e-01f, 4.08806056e-01f, -4.06814009e-01f, 2.62457252e-01f, 2.18213916e-01f, -1.78671181e-01f, -2.20829427e-01f, 1.42481044e-01f, 3.75367582e-01f, -1.85058281e-01f,
  1.46968275e-01f, -4.37739581e-01f, -1.05119094e-01f, -1.40684694e-01f, -2.91315407e-01f, 3.37562412e-02f, 3.41304928e-01f, 1.74951062e-01f, 2.10925609e-01f, -3.41819465e-01f,
  -3.85065883e-01f, 4.27209251e-02f, -6.54568151e-02f, 4.14803810e-02f, 1.72476582e-02f, 1.64990127e-01f, 4.81142014e-01f, -6.96255192e-02f, 1.04735076e-01f, 9.98893902e-02f,
  -6.91740662e-02f, 6.17357455e-02f, 7.84561932e-02f, 2.99354065e-02f, 1.79490373e-02f, -1.14465259e-01f, 5.72821908e-02f, 1.27188861e-01f, 9.64934006e-02f, -1.13438792e-03f,
  -1.43498704e-01f, 4.74236757e-01f, 4.82233316e-01f, 2.65289307e-01f, 1.65975511e-01f, 9.04415548e-02f, 3.16490717e-02f, -9.06688794e-02f, -1.56612128e-01f, -2.89324522e-01f,
  -1.63472295e-01f, 1.10263348e-01f, 3.91682312e-02f, 1.80550754e-01f, -1.10751092e-01f, 4.82615419e-02f, 2.35329792e-01f, -6.98722228e-02f, -6.26680404e-02f, -2.16619402e-01f,
  1.51013657e-01f, 6.80574328e-02f, 5.16707860e-02f, 6.95016906e-02f, -6.12815991e-02f, -1.13792352e-01f, -8.02905634e-02f, 1.96129888e-01f, -1.20328479e-01f, -3.15096051e-01f,
  -1.07521914e-01f, 2.98019260e-01f, 3.12577069e-01f, 6.79408982e-02f, -9.51062664e-02f, 2.41346136e-01f, -2.68822419e-03f, -2.60888904e-01f, 3.53155613e-01f, -9.52716842e-02f,
  1.33031771e-01f, 1.49308816e-02f, 9.25451517e-02f, -2.30622754e-01f, -7.26936236e-02f, 1.22193761e-01f, -3.02727461e-01f, 3.09147988e-03f, 1.64858878e-01f, 3.61380577e-01f,
  -1.51109904e-01f, -7.64141884e-03f, 4.27952483e-02f, 1.22199275e-01f, -1.50389194e-01f, -8.78544804e-03f, 8.65774974e-02f, 7.14223087e-02f, 2.53316104e-01f, 9.37575325e-02f,
  -3.50797586e-02f, -9.40508470e-02f, -1.24067396e-01f, -4.51691262e-02f, 1.64311171e-01f, -2.29309708e-01f, -4.43076164e-01f, -1.60858750e-01f, 1.73057884e-01f, -7.29302466e-02f,
  -1.20628126e-01f, 2.08021164e-01f, 3.59335750e-01f, 2.24435344e-01f, 3.84906441e-01f, 1.99053392e-01f, -3.11666936e-01f, 7.35492334e-02f, -3.40700299e-01f, 7.37333298e-02f,
  3.74753475e-01f, 9.42634568e-02f, -1.59729823e-01f, 5.46413004e-01f, 2.43898332e-02f, 4.86284755e-02f, -1.65686578e-01f, 5.68616949e-02f, -1.38793007e-01f, 3.01568955e-02f,
  6.81747124e-02f, 6.37195185e-02f, -1.80607781e-01f, -1.38695702e-01f, -7.48087019e-02f, -4.95449901e-02f, -1.01487577e-01f, -1.02199495e-01f, 2.69605964e-01f, 2.96033379e-02f,
  1.75215110e-01f, 5.62358163e-02f, 4.27094281e-01f, -1.93153754e-01f, 2.10581720e-01f, -1.73314959e-01f, 6.62429333e-02f, 1.31751761e-01f, 2.03180732e-03f, 6.07756898e-02f,
  -1.70695662e-01f, -8.95007327e-02f, 1.13029562e-01f, 2.86689848e-01f, -1.82797566e-01f, 3.11274886e-01f, 1.07745096e-01f, 1.24098606e-01f, 6.48422614e-02f, 1.73275266e-02f,
  9.84609574e-02f, 2.44460315e-01f, -5.23568206e-02f, -8.50993395e-02f, 1.54321790e-01f, -6.10437281e-02f, 1.06658868e-01f, 7.99247809e-03f, -4.35442150e-01f, 5.05095422e-02f,
  1.47743285e-01f, 1.02249041e-01f, -3.24702322e-01f, 3.58031541e-01f, -1.08989608e-02f, -1.97270010e-02f, -9.41497311e-02f, -1.17342114e-01f, -6.37781098e-02f, 7.13153332e-02f,
  4.10222232e-01f, -2.10557655e-01f, 4.40085888e-01f, 2.90582657e-01f, -3.24006528e-01f, -1.62013635e-01f, -1.74779087e-01f, -2.92073876e-01f, 2.84151614e-01f, 3.81529003e-01f,
  3.05624872e-01f, 3.25745553e-01f, 3.07099611e-01f, 2.47640684e-01f, 3.98548953e-02f, 2.45757829e-02f, 1.58193305e-01f, 9.03859511e-02f, -8.38036612e-02f, 2.07843140e-01f,
  1.27582744e-01f, -6.98588267e-02f, -5.03398851e-02f, -5.68062901e-01f, 4.99888323e-02f, 2.98738122e-01f, 1.15892673e-02f, -5.49814329e-02f, 1.01881504e-01f, -5.89191020e-02f,
  5.43762207e-01f, -1.88541591e-01f, 4.19788182e-01f, 1.25469789e-01f, -1.30962878e-01f, 1.73014119e-01f, 5.40109016e-02f, 3.32194626e-01f, -1.01754732e-01f, -2.81893164e-01f,
  3.20258021e-01f, 2.42651209e-01f, 1.84102759e-01f, 2.65193224e-01f, 1.38388842e-01f, 2.66430974e-01f, 8.65905136e-02f, -6.89658225e-02f, -3.02865896e-02f, -1.68954313e-01f,
  1.96046866e-02f, -7.94094354e-02f, -7.98108205e-02f, -1.66911393e-01f, -1.87008791e-02f, -9.15524140e-02f, -6.06231987e-01f, 2.21587747e-01f, -2.13246569e-01f, 2.73471653e-01f,
  4.32215989e-01f, 3.40315342e-01f, 2.76638895e-01f, 2.32768238e-01f, 1.59069151e-01f, -2.56512493e-01f, 3.27970237e-01f, -8.53004307e-02f, 1.19346470e-01f, -1.67307347e-01f,
  3.13491344e-01f, 3.46650809e-01f, 3.06233525e-01f, 3.36255878e-02f, -5.85229369e-04f, 1.79193288e-01f, -5.54405712e-03f, 2.19652131e-02f, -8.40769857e-02f, 2.83463329e-01f,
  1.94734067e-01f, 1.28501251e-01f, 2.30574399e-01f, 1.44357696e-01f, 1.55518547e-01f, -3.95979553e-01f, -5.93004882e-01f, 2.77730405e-01f, -2.44903401e-01f, 2.13615462e-01f,
  3.72836232e-01f, 8.85852352e-02f, 1.34244457e-01f, 5.92723250e-01f, 4.48954821e-01f, -3.28267030e-02f, -8.73349980e-02f, 3.42298299e-01f, 1.04683429e-01f, 3.27741444e-01f,
  4.33167636e-01f, 4.72220182e-01f, 1.74206644e-01f, 1.29748538e-01f, 2.14302987e-01f, 2.97984898e-01f, 3.91467452e-01f, 1.64673060e-01f, 3.05540949e-01f, 1.64061502e-01f,
  -2.66765922e-01f, 5.14813811e-02f, 1.44557074e-01f, -1.94676723e-02f, 1.25877276e-01f, -8.46961886e-02f, -1.12567663e-01f, -7.33716339e-02f, 1.56236380e-01f, -4.88968790e-01f,
  -9.65688229e-02f, 1.78256035e-01f, -2.44715005e-01f, 3.18023473e-01f, -1.40500546e-01f, 3.39201123e-01f, 1.01459660e-01f, 2.12003142e-01f, -1.32931679e-01f, -2.76943535e-01f,
  3.07307690e-01f, 1.08057044e-01f, -1.34065688e-01f, -3.61533649e-02f, 4.34360534e-01f, -3.28840792e-01f, -6.29410297e-02f, 2.62418926e-01f, 2.97754973e-01f, 2.01527268e-01f,
  6.90893903e-02f, -1.27488729e-02f, 3.09928190e-02f, -1.14084762e-02f, -5.60296327e-02f, 2.29260966e-01f, -6.83833729e-04f, -1.56777561e-01f, -2.50686288e-01f, 9.69023332e-02f,
  -1.09241724e-01f, 4.09851432e-01f, 5.73099293e-02f, -8.45283493e-02f, 4.14971024e-01f, -9.99752581e-02f, 1.67571232e-01f, 7.77152702e-02f, -1.14956781e-01f, -2.85178628e-02f,
  3.53418678e-01f, 7.29169250e-02f, 1.04070112e-01f, -2.75110036e-01f, -2.34994486e-01f, 1.61868751e-01f, -1.79807574e-01f, -3.54425013e-01f, 5.45901014e-04f, 1.50983315e-02f,
  -8.71518552e-02f, 3.98650095e-02f, -9.50085521e-02f, 2.49082759e-01f, -1.25354201e-01f, 8.42278916e-03f, -4.96115722e-02f, -1.96762860e-01f, -3.13728210e-03f, -7.47639537e-02f,
  -2.98604310e-01f, 4.19869125e-01f, 4.65688586e-01f, 1.00792043e-01f, 9.18361321e-02f, 3.78522456e-01f, -1.75602496e-01f, 2.04323202e-01f, -1.68330133e-01f, -3.07789922e-01f,
  -3.47541943e-02f, 2.30319723e-01f, 7.93945640e-02f, -3.70720923e-02f, 4.47775051e-02f, 8.44412223e-02f, -2.05429539e-01f, -3.12952131e-01f, 4.92587723e-02f, -5.01157418e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  -7.38045648e-02f, 2.15680495e-01f, 4.46869165e-01f, 1.74389079e-01f, 1.96794540e-01f, 4.23329264e-01f, 2.87954628e-01f, 5.16488135e-01f, 4.35600877e-01f, 1.61033005e-01f,
  7.23810419e-02f, -5.86419851e-02f, -1.37116447e-01f, 2.18404680e-01f, 7.33445510e-02f, 1.04575358e-01f, 4.17929769e-01f, 2.80985028e-01f, 7.14806914e-02f, 1.25334069e-01f
};

// L2_fan_Wp (Shape: 6 x 32)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  1.61345869e-01f, -3.29765052e-01f, 3.87845375e-02f, -8.31070095e-02f, 1.00288168e-01f, 9.57730189e-02f, -6.21912599e-01f, 1.30686805e-01f, 3.84687841e-01f, -9.10004899e-02f,
  1.69854343e-01f, -1.59763992e-01f, -5.92199787e-02f, 1.49894496e-02f, -1.84820235e-01f, -6.65989751e-03f, 8.33103359e-02f, -2.39286944e-01f, 3.85590136e-01f, -1.63405076e-01f,
  4.80546951e-02f, 1.22878365e-01f, -7.78066367e-02f, 5.24076596e-02f, -2.46961787e-02f, 1.40708163e-01f, -4.23061438e-02f, 3.05475861e-01f, 1.40219375e-01f, -5.11968061e-02f,
  -1.20167412e-01f, 3.26186344e-02f, -4.06759381e-02f, -1.42924059e-02f, 8.98299590e-02f, -3.10271531e-01f, -5.11467792e-02f, -2.26533145e-01f, 3.03059310e-01f, -3.44843239e-01f,
  -4.55586016e-01f, -2.48278603e-01f, -3.88576388e-01f, -4.83852774e-01f, 3.10048223e-01f, -7.31306672e-02f, 2.08539650e-01f, -2.76273699e-03f, 2.43694916e-01f, -7.11184889e-02f,
  5.42574786e-02f, 3.88652653e-01f, 1.69493293e-03f, 2.64645845e-01f, 6.44903183e-02f, 1.27765134e-01f, 2.13565394e-01f, -1.26164779e-01f, -1.36691675e-01f, -1.54649571e-01f,
  -2.63330005e-02f, -2.02293843e-01f, 2.38265488e-02f, 1.78739980e-01f, -7.00393245e-02f, -2.84534931e-01f, -4.18995507e-03f, -4.66042310e-02f, -1.52539045e-01f, 1.06914394e-01f,
  3.05989943e-02f, -1.67021394e-01f, 2.47119442e-01f, -2.67818511e-01f, 1.63892284e-01f, -4.08126980e-01f, -1.40835494e-01f, -1.16329096e-01f, 6.87860250e-02f, 1.52691305e-01f,
  1.17347330e-01f, 4.33079116e-02f, -8.84758905e-02f, -4.19658050e-02f, 3.07657212e-01f, -2.34997496e-02f, -9.84008387e-02f, -1.44036382e-01f, -9.58068445e-02f, -3.69758494e-02f,
  -1.47544686e-02f, -7.57284984e-02f, -1.15650713e-01f, 1.78964242e-01f, -2.25965098e-01f, -1.58771142e-01f, -6.44832030e-02f, -3.08854818e-01f, 1.13649584e-01f, -1.36479273e-01f,
  1.06553249e-01f, -2.40023911e-01f, 2.56531388e-01f, 9.58408192e-02f, -2.74437875e-01f, 2.22246110e-01f, -5.85850894e-01f, -1.38343975e-01f, 1.60322897e-02f, -9.70904827e-02f,
  -4.51208539e-02f, -1.56624660e-01f, 1.29378781e-01f, 1.64984241e-01f, 1.66690454e-01f, -1.24842107e-01f, -1.41913757e-01f, 1.28016651e-01f, 2.89908439e-01f, -2.47899294e-01f,
  -7.91452825e-02f, 1.35372253e-02f, 1.70069247e-01f, -1.95085749e-01f, 1.80579424e-01f, -1.83840007e-01f, 1.76145703e-01f, 7.40897283e-02f, 8.72860104e-02f, -1.19966067e-01f,
  6.71120314e-03f, -5.00838459e-01f, 2.78358976e-03f, 1.75258711e-01f, 1.64871112e-01f, -1.97380260e-01f, -3.67546737e-01f, -1.61257938e-01f, -3.29720020e-01f, -5.08799776e-02f,
  -3.97125781e-01f, -1.10735886e-01f, 4.83600087e-02f, 1.19588420e-01f, -1.33490205e-01f, -3.86681594e-02f, -2.32341200e-01f, 4.44036499e-02f, -2.74216413e-01f, 1.93311870e-01f,
  1.96490753e-02f, -1.06455892e-01f, 1.62978441e-01f, 1.52047589e-01f, 1.14004709e-01f, -6.71845153e-02f, -4.50731963e-02f, -5.72546050e-02f, 1.36188105e-01f, 1.26752123e-01f,
  8.77945349e-02f, 7.08356351e-02f, 2.71231979e-02f, -3.08633357e-01f, -2.23954499e-01f, 2.95494236e-02f, -2.33365253e-01f, 3.71380337e-02f, -3.74003708e-01f, -3.82824689e-01f,
  -1.72422886e-01f, 1.54805079e-01f, 2.28420660e-01f, 4.32269648e-03f, -1.99150413e-01f, 1.04512490e-01f, 1.68589488e-01f, 3.05934191e-01f, 1.45028248e-01f, -1.08483814e-01f,
  -3.73596936e-01f, 1.30010515e-01f, -1.62909165e-01f, -1.50581449e-02f, 6.08817562e-02f, 1.53044075e-01f, 7.04714954e-02f, 1.30886044e-02f, -1.86700672e-01f, -1.00666191e-02f,
  -9.24135745e-02f, 1.52376071e-01f
};

// L2_fan_Wp_bar (Shape: 20 x 32)
const int L2_fan_Wp_bar_rows = 20;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  2.95116156e-01f, -1.02617275e-02f, 1.43370375e-01f, 1.55322254e-01f, 2.88412832e-02f, 4.04118821e-02f, 2.13038355e-01f, -1.41000107e-01f, -7.05579877e-01f, 3.98368537e-01f,
  -2.41839826e-01f, 3.78491729e-01f, 6.06647618e-02f, 3.65637481e-01f, -1.39423519e-01f, 2.21513379e-02f, 3.38296235e-01f, 4.07442749e-01f, -6.58971667e-02f, -1.85275733e-01f,
  2.64412284e-01f, -1.96615197e-02f, -5.72305135e-02f, 4.35275406e-01f, -4.67307754e-02f, 7.82104582e-02f, 2.02662915e-01f, 5.94906919e-02f, 1.80699423e-01f, -3.66874561e-02f,
  2.55006589e-02f, 1.47806361e-01f, 3.59301381e-02f, 9.72249359e-02f, -2.75267094e-01f, 2.64569789e-01f, -9.43057761e-02f, 1.87120691e-01f, 2.02580355e-02f, -3.95328939e-01f,
  2.43434891e-01f, -4.26494807e-01f, 4.55505222e-01f, -2.10341379e-01f, -5.27633429e-01f, -3.93902026e-02f, 1.63161129e-01f, -2.37266049e-01f, -5.65617502e-01f, -4.46041703e-01f,
  -1.70404986e-01f, 4.46793914e-01f, -1.28188804e-01f, 1.80799395e-01f, 1.62645280e-01f, -7.25264568e-03f, 7.95047879e-02f, -2.17450099e-04f, -6.27944052e-01f, 2.59679914e-01f,
  1.54890820e-01f, 1.13369441e-02f, 7.69890426e-03f, 2.08790779e-01f, 2.84585655e-02f, 3.82139653e-01f, 2.98024803e-01f, 2.65956879e-01f, 2.33247265e-01f, 2.49020860e-01f,
  5.37479103e-01f, -4.22993600e-01f, -1.74462005e-01f, -1.59024239e-01f, 5.99776511e-04f, -2.51938671e-01f, 1.05454557e-01f, 6.99458867e-02f, 2.98037946e-01f, -2.65555173e-01f,
  1.49889722e-01f, 1.81532696e-01f, -1.83841124e-01f, 4.73098367e-01f, 2.20112309e-01f, -2.22343028e-01f, 2.38220960e-01f, 2.84454942e-01f, 1.29791453e-01f, -2.87416577e-01f,
  2.41822302e-02f, 1.23610578e-01f, -8.07651579e-02f, -2.74980247e-01f, -5.69738075e-02f, -3.48109454e-01f, 3.88712943e-01f, 3.90108377e-01f, 1.71267122e-01f, 3.42910085e-03f,
  4.64498073e-01f, 4.29686420e-02f, 4.88397658e-01f, -5.25378704e-01f, -1.02130048e-01f, 1.20366685e-01f, 6.21921904e-02f, -3.00289482e-01f, -1.24022126e-01f, -8.94576088e-02f,
  4.19811547e-01f, -3.03519756e-01f, -3.79604027e-02f, 3.83846834e-02f, -3.95523548e-01f, 4.16853070e-01f, 4.95476514e-01f, -4.80930023e-02f, 3.69173497e-01f, -8.06023926e-03f,
  2.21228637e-02f, -4.61331755e-01f, 1.19953372e-01f, 7.87433013e-02f, 2.13930354e-01f, 2.73010377e-02f, -2.13521004e-01f, -1.89604625e-01f, 3.47582810e-02f, 2.84173131e-01f,
  3.36224250e-02f, 2.80903369e-01f, 6.15157709e-02f, 1.38346553e-01f, -5.51426038e-02f, -3.96422029e-01f, -5.34574836e-02f, -1.96039945e-01f, -4.56955612e-01f, -2.18288243e-01f,
  1.26106486e-01f, 2.66445041e-01f, -1.07497647e-01f, 4.41203475e-01f, 5.43466032e-01f, 2.39165932e-01f, 5.41329324e-01f, -1.41689135e-02f, 1.62982225e-01f, 1.65132672e-01f,
  1.43472597e-01f, -5.23776822e-02f, 1.67967543e-01f, 7.98350871e-02f, 1.79549739e-01f, -4.01228428e-01f, 5.29965460e-02f, 2.83175379e-01f, 4.84235808e-02f, 3.59264880e-01f,
  2.84285218e-01f, 1.32832170e-01f, 3.09614420e-01f, 2.58968413e-01f, 5.04738450e-01f, 1.33687451e-01f, -3.71240467e-01f, -7.93459043e-02f, 5.43951392e-01f, 3.81525099e-01f,
  2.37619445e-01f, 4.11494434e-01f, -3.29073131e-01f, 3.16314727e-01f, -2.67556220e-01f, 2.01178640e-01f, -1.93358704e-01f, -8.70359093e-02f, -1.35465683e-02f, -3.08136374e-01f,
  2.58729279e-01f, -2.70076375e-03f, -2.73008704e-01f, -1.90210611e-01f, -3.47914696e-01f, 1.76689431e-01f, 3.35504383e-01f, 2.95904547e-01f, 3.79313752e-02f, 1.75284460e-01f,
  2.31531411e-02f, -7.01926574e-02f, 1.87907204e-01f, 4.01958674e-01f, 3.41511816e-01f, 2.06814468e-01f, 5.43011010e-01f, 9.61244851e-02f, 1.24592289e-01f, -3.63004833e-01f,
  3.45502913e-01f, -6.34428620e-01f, 2.02022851e-01f, -1.07514873e-01f, -4.26647156e-01f, -2.00508326e-01f, 5.28225005e-01f, -1.67788655e-01f, -1.10018723e-01f, 5.09990454e-01f,
  -2.32309818e-01f, 4.08620954e-01f, 2.49020770e-01f, 1.39691487e-01f, -2.23919064e-01f, -5.34066677e-01f, -2.68023670e-01f, 2.40479186e-01f, 4.74229366e-01f, 1.14610687e-01f,
  -3.23054224e-01f, 2.74191648e-01f, 4.73616309e-02f, 6.34301677e-02f, 4.30431217e-01f, 5.75947404e-01f, 1.84095666e-01f, 2.40188703e-01f, 7.02964723e-01f, 3.84569943e-01f,
  2.12939411e-01f, 2.79187202e-01f, 7.97802657e-02f, 2.72756934e-01f, 8.35070536e-02f, 5.31427622e-01f, -8.81819800e-02f, 2.95533717e-01f, 1.21672772e-01f, -5.19739948e-02f,
  3.51340771e-02f, 2.49055281e-01f, 7.80826062e-02f, -3.07631623e-02f, 1.48855507e-01f, -3.56981874e-01f, -1.48600757e-01f, -3.64488214e-01f, -1.73119336e-01f, 3.68834317e-01f,
  4.38454807e-01f, 2.93996453e-01f, -9.80080366e-02f, -4.47085984e-02f, 3.27747241e-02f, -4.63243350e-02f, 2.31796563e-01f, 1.63297519e-01f, 3.49292994e-01f, 1.03418320e-01f,
  2.29159683e-01f, -7.38753602e-02f, 4.52495320e-03f, 5.53551912e-01f, 2.61713620e-02f, 4.98795778e-01f, 8.65353330e-04f, 5.29008806e-01f, -1.05249085e-01f, 1.23145998e-01f,
  1.33648202e-01f, 7.47636631e-02f, -1.31861418e-01f, 4.29009914e-01f, 8.79741460e-03f, -5.23548245e-01f, 5.57401814e-02f, -4.84696887e-02f, -2.76853442e-02f, 2.37486258e-01f,
  -2.39791840e-01f, 1.12828799e-01f, 2.37670541e-01f, 3.11239451e-01f, 5.05460083e-01f, -1.79116532e-01f, 3.23051929e-01f, -1.65668234e-01f, -2.14539263e-02f, -3.80011648e-01f,
  4.87075336e-02f, 2.22850725e-01f, -2.05400899e-01f, 1.08642876e-01f, -5.77968717e-01f, -1.56684205e-01f, 6.64507270e-01f, -4.02208686e-01f, 5.16468287e-01f, 8.20590407e-02f,
  -1.12317607e-01f, 2.20575437e-01f, 2.02734545e-01f, -5.54903895e-02f, -4.12790835e-01f, -2.02120334e-01f, -1.68087408e-01f, 2.98267692e-01f, 1.41977176e-01f, -5.50324798e-01f,
  -1.11243144e-01f, 1.81085140e-01f, -6.31553456e-02f, -2.31358021e-01f, -1.12091921e-01f, 4.09412205e-01f, 2.24453136e-01f, 8.75662174e-03f, -2.55890280e-01f, -2.41641611e-01f,
  1.05647705e-01f, -2.95469433e-01f, 2.15000957e-01f, 1.57439664e-01f, -7.01784045e-02f, 1.28617436e-01f, -1.86817162e-02f, -9.67810005e-02f, -3.07368524e-02f, 1.60070688e-01f,
  7.91075379e-02f, -3.61153096e-01f, 5.78849725e-02f, 2.11176500e-01f, 2.75125057e-01f, 1.40923217e-01f, 9.27126110e-02f, -2.52100885e-01f, -3.79888602e-02f, 4.25481081e-01f,
  2.82419205e-01f, 1.15970215e-02f, 8.38908702e-02f, 3.03204924e-01f, -2.22338304e-01f, -3.72215629e-01f, -8.55126828e-02f, -6.15567761e-03f, 2.83941627e-01f, 2.07107350e-01f,
  -1.47011831e-01f, -4.57366884e-01f, 5.42582432e-03f, -6.53962716e-02f, 2.93743134e-01f, 3.88819017e-02f, 9.30969566e-02f, 6.72634244e-02f, -1.09911270e-01f, 2.35590026e-01f,
  -5.92842400e-02f, 2.57425755e-01f, 6.92613050e-02f, -9.17673185e-02f, 9.88345891e-02f, 1.18127689e-01f, 4.42092344e-02f, 1.32698447e-01f, 5.44853434e-02f, 1.78631827e-01f,
  1.46640390e-01f, -3.76600951e-01f, -1.62373632e-01f, -2.95542330e-02f, -2.44839564e-01f, -4.31620836e-01f, -2.95426637e-01f, 3.72783720e-01f, 7.70031512e-02f, -5.08487225e-02f,
  1.62293807e-01f, 1.75524712e-01f, 1.53459283e-02f, 1.37233976e-02f, 1.13107473e-01f, -1.82111517e-01f, -5.30033410e-02f, 3.59561503e-01f, -7.74039701e-02f, 3.66027772e-01f,
  -5.93358338e-01f, -1.33714780e-01f, 5.16090333e-01f, -6.71569034e-02f, 3.58422428e-01f, -1.49017036e-01f, 9.68325883e-02f, 1.66652262e-01f, 4.43703821e-03f, 4.71468329e-01f,
  2.15752214e-01f, -2.11055055e-01f, 4.03841227e-01f, -4.77999114e-02f, 1.93786755e-01f, -1.30914435e-01f, -2.24164188e-01f, -1.64022326e-01f, -2.33436540e-01f, 1.71548158e-01f,
  -7.64478445e-02f, 3.74195814e-01f, -2.76816450e-02f, 4.30098355e-01f, 3.59204449e-02f, 4.84463610e-02f, -9.26948860e-02f, -8.92919023e-03f, -6.04370460e-02f, -6.13743775e-02f,
  -1.80446640e-01f, 8.23157188e-03f, 2.07606032e-02f, -5.34260035e-01f, 4.35173273e-01f, -3.24703082e-02f, 2.77283937e-01f, -2.78021336e-01f, -1.69926673e-01f, -5.93592338e-02f,
  -1.31959757e-02f, 6.83198720e-02f, -1.09945349e-01f, -2.68425703e-01f, 4.17984992e-01f, 3.78811985e-01f, -2.67789721e-01f, 4.07529831e-01f, -1.81724746e-02f, -1.80755377e-01f,
  1.49060875e-01f, 3.59246403e-01f, -2.54094630e-01f, 3.83687645e-01f, 2.93023020e-01f, 2.36291289e-01f, 2.04975903e-01f, 3.28703433e-01f, -3.77852619e-02f, 2.51057267e-01f,
  3.53983194e-02f, 1.45282730e-01f, 2.45195851e-02f, -2.33312529e-02f, 1.60924479e-01f, -2.73019765e-02f, -4.07741964e-01f, -3.23703408e-01f, -3.03174019e-01f, -2.09674090e-01f,
  4.89173025e-01f, -2.20528468e-01f, 3.80204469e-01f, 7.87623748e-02f, 3.57895702e-01f, 2.72055298e-01f, 3.22296083e-01f, 3.48820418e-01f, -1.76759228e-01f, 2.64673561e-01f,
  1.68290466e-01f, -1.51718751e-01f, -1.41889632e-01f, 2.94308923e-02f, -7.11084455e-02f, -3.54939014e-01f, 2.59382993e-01f, -2.00552568e-01f, 4.09483910e-01f, -2.22326610e-02f,
  8.22237283e-02f, 1.99043542e-01f, 2.87938062e-02f, 2.87011862e-01f, -2.12287143e-01f, 2.21091717e-01f, -3.44945282e-01f, -3.28246087e-01f, 3.40101004e-01f, -1.97505608e-01f,
  1.42237023e-01f, 1.26988366e-01f, -1.35970265e-01f, 2.00295970e-01f, -3.31655562e-01f, 2.79965252e-01f, 3.22939813e-01f, -2.99916297e-01f, 3.44925761e-01f, 1.11354180e-01f,
  2.00843975e-01f, -1.40414625e-01f, -4.21661139e-02f, 2.08810329e-01f, -1.84108093e-01f, 1.19948238e-01f, 1.21439099e-02f, 2.01876193e-01f, 1.61274448e-01f, 6.76178694e-01f,
  -3.63096148e-01f, 5.41146062e-02f, -9.96484701e-03f, -2.92312533e-01f, 2.71990359e-01f, 1.14510752e-01f, 2.60056049e-01f, 8.29095915e-02f, -1.53621495e-01f, 4.75294478e-02f,
  -3.46017182e-02f, 4.53509212e-01f, 2.37898454e-01f, 1.26071438e-01f, 1.94170624e-01f, 8.65559205e-02f, 3.62640679e-01f, -1.43281907e-01f, -4.59932443e-03f, -1.52145624e-01f,
  -1.41661540e-01f, 3.83657575e-01f, 3.17793600e-02f, -3.13280970e-01f, 3.76990288e-01f, 1.76727608e-01f, 1.62961543e-01f, -4.76093203e-01f, 8.97774175e-02f, 1.26671009e-02f,
  4.32744563e-01f, -3.11464313e-02f, -6.96516484e-02f, -5.16456246e-01f, 9.95621085e-02f, 2.88155884e-01f, 3.59083563e-01f, 3.61536443e-01f, 5.86776197e-01f, 2.60080010e-01f,
  -1.41680568e-01f, 8.88820291e-02f, -3.12924713e-01f, 4.74135548e-01f, -8.23290870e-02f, 6.28717899e-01f, 2.72736192e-01f, 4.08189237e-01f, -2.87188351e-01f, 1.36193395e-01f,
  1.01513334e-01f, -6.32322803e-02f, 2.19728947e-01f, -1.08923458e-01f, 4.10390019e-01f, -2.97976613e-01f, 2.17151597e-01f, 2.13256374e-01f, -3.68764371e-01f, 2.26949491e-02f,
  3.67141306e-01f, 1.19884074e-01f, 2.54258066e-01f, -4.71413732e-02f, -4.91447359e-01f, -4.35000539e-01f, 1.19454131e-01f, 2.58268207e-01f, 1.66568995e-01f, 3.24310124e-01f,
  4.36129533e-02f, 2.46952161e-01f, 1.52120069e-01f, -4.64233220e-01f, 2.19062939e-02f, -6.21080756e-01f, -4.78165179e-01f, -3.88283819e-01f, 1.64628148e-01f, 8.51203576e-02f,
  2.14117423e-01f, -4.77333814e-02f, 1.51002482e-01f, 3.26672345e-01f, 4.23648715e-01f, 3.31855327e-01f, 1.31963909e-01f, 1.55259594e-01f, 7.54222944e-02f, -5.67057729e-01f,
  -8.29612017e-02f, 1.22887522e-01f, -1.12589085e-02f, -1.86009482e-01f, -1.00586727e-01f, 6.60445122e-03f, 4.31187153e-02f, -2.71687545e-02f, 2.00372949e-01f, 6.70523196e-02f,
  3.97681668e-02f, 6.44547224e-01f, 2.70352930e-01f, -6.12420999e-02f, -1.24520548e-01f, -3.32462609e-01f, 6.26028419e-01f, -5.47088832e-02f, 2.35656157e-01f, -1.17132246e-01f,
  -4.56797957e-01f, -3.90010588e-02f, -1.35895848e-01f, -1.33431517e-02f, -1.15674667e-01f, 1.82882715e-02f, 3.87700647e-01f, 2.02579305e-01f, 1.21785635e-02f, 1.07881084e-01f,
  -2.75562048e-01f, -6.42826736e-01f, -1.28405035e-01f, 4.98955250e-01f, 1.93113551e-01f, 8.41922760e-02f, 3.26286163e-03f, 2.79932559e-01f, 1.38367504e-01f, 9.88817737e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 20)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 20;
const float L2_fan_Bp_bar_data[] = {
  3.48016232e-01f, 2.29840934e-01f, 6.34514764e-02f, 1.24416970e-01f, 7.44988173e-02f, 3.02605301e-01f, 3.07277054e-01f, 6.86595067e-02f, 7.35895783e-02f, 1.38337150e-01f,
  2.61996150e-01f, 1.60677746e-01f, 2.70078540e-01f, -1.43586649e-02f, -1.47096941e-03f, 3.17454606e-01f, 3.09858043e-02f, 1.35333106e-01f, 2.22229352e-03f, 1.25240043e-01f
};

// L3_fan_Wp (Shape: 6 x 32)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  -2.79688030e-01f, -2.98405528e-01f, -1.49753287e-01f, 1.13235824e-01f, -2.21099362e-01f, -2.83924907e-01f, 1.01748006e-02f, 2.54987359e-01f, 1.98669761e-01f, 2.09892437e-01f,
  -8.89369845e-02f, -3.89809757e-02f, 1.31523341e-01f, 1.12660773e-01f, -1.37504876e-01f, -1.83288798e-01f, 7.48528168e-02f, -2.50582278e-01f, -1.98053941e-01f, -1.69699118e-01f,
  2.62051895e-02f, -9.44905281e-02f, -5.50005436e-02f, 1.73787237e-03f, 5.55932187e-02f, 2.06733152e-01f, 2.09575981e-01f, -3.98407094e-02f, 1.79337531e-01f, -5.27874194e-02f,
  -4.91843224e-02f, -2.49632969e-01f, 5.12218848e-02f, 1.31459292e-02f, -4.39167656e-02f, 1.95826069e-01f, -1.34643033e-01f, -3.31430078e-01f, 5.68923429e-02f, 3.54990304e-01f,
  -7.64077529e-02f, -5.60711436e-02f, -2.94977069e-01f, -5.23070619e-02f, 3.11284691e-01f, -5.27051687e-02f, 1.22311004e-01f, 8.08340609e-02f, 2.20192567e-01f, -9.59686190e-02f,
  -7.93485418e-02f, -1.30371705e-01f, -4.13396321e-02f, -2.27614209e-01f, -8.01846683e-02f, 4.87580486e-02f, -1.39438927e-01f, 8.69961679e-02f, -4.28039879e-02f, -4.45263349e-02f,
  7.76167512e-02f, 2.35374257e-01f, -8.14284012e-02f, 6.41246513e-02f, -1.18808411e-01f, 1.45301521e-01f, -1.61557406e-01f, 2.94510216e-01f, 6.34398535e-02f, -3.79548874e-03f,
  -1.73441612e-03f, -1.37481093e-02f, 5.81921697e-01f, 2.30362743e-01f, -2.02086389e-01f, -2.01794371e-01f, -1.24478482e-01f, -1.46241598e-02f, 1.35294423e-01f, 2.19980761e-01f,
  -4.84993635e-03f, 1.39143854e-01f, 1.81502089e-01f, 9.76630300e-02f, -1.16148852e-01f, -2.96559453e-01f, 7.88449496e-02f, 9.57655683e-02f, -1.65698633e-01f, -5.97341508e-02f,
  -1.59661442e-01f, -1.06378466e-01f, 1.17085353e-01f, -1.17507942e-01f, 4.56130318e-02f, 2.61631191e-01f, -5.13331741e-02f, -8.25380161e-02f, 2.06114829e-01f, 2.38072902e-01f,
  -9.24342573e-02f, 2.11635664e-01f, -1.34420330e-02f, 3.58293414e-01f, -1.29818827e-01f, 1.01947196e-01f, 4.97126460e-01f, -3.01532060e-01f, -2.89092809e-01f, 2.28355810e-01f,
  -6.35824949e-02f, 6.03246093e-02f, 1.84705220e-02f, 1.78002581e-01f, -7.16800019e-02f, 8.34856629e-02f, 1.48060650e-01f, 2.09980965e-01f, -7.08336681e-02f, 8.00944567e-02f,
  1.41670071e-02f, -6.36702776e-03f, -1.24416247e-01f, -1.01302207e-01f, 1.30874962e-01f, -1.29083708e-01f, -1.13246404e-02f, 1.93996996e-01f, 4.08747904e-02f, -3.18254828e-02f,
  3.24809998e-02f, -1.76612169e-01f, -2.74836361e-01f, -4.67785597e-02f, -1.37065100e-02f, 1.06290817e-01f, 3.16100508e-01f, 2.77568787e-01f, -3.04153226e-02f, 6.81401119e-02f,
  -9.73468125e-02f, 3.81459534e-01f, 4.05329615e-02f, 2.96655353e-02f, -1.01886131e-01f, -3.50071862e-02f, 4.17339616e-02f, -6.02147654e-02f, -6.07712660e-03f, 2.42434010e-01f,
  -1.73261911e-02f, 1.28898174e-01f, -2.43805021e-01f, 1.09721966e-01f, 1.72153473e-01f, -1.40716270e-01f, -9.34398249e-02f, -1.42891005e-01f, 1.29278794e-01f, -3.07774208e-02f,
  -4.21748497e-02f, 5.47922626e-02f, 2.85271794e-01f, -2.50431746e-01f, 2.04810560e-01f, 2.90390015e-01f, 2.41008494e-02f, -2.56816000e-01f, -1.91886470e-01f, 2.46838287e-01f,
  4.24484134e-01f, -2.54692622e-02f, -2.26006344e-01f, -1.29338354e-02f, -2.76059825e-02f, -1.45644292e-01f, -1.79962561e-01f, 2.19555095e-01f, 1.85121894e-01f, 1.23755135e-01f,
  -1.30123394e-02f, -5.19715585e-02f, -9.12564099e-02f, 1.76580831e-01f, 1.27162486e-01f, -1.10408016e-01f, 1.86130498e-02f, 9.67949033e-02f, 1.19480163e-01f, -1.76963553e-01f,
  -1.74082413e-01f, 2.34622195e-01f
};

// L3_fan_Wp_bar (Shape: 20 x 32)
const int L3_fan_Wp_bar_rows = 20;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  9.34900045e-02f, 5.77450953e-02f, 3.47378641e-01f, 1.72527432e-01f, 1.86637461e-01f, 3.57124448e-01f, -9.04892907e-02f, -9.88733489e-03f, -4.23849255e-01f, 2.69234508e-01f,
  6.11180842e-01f, 3.37948054e-01f, 2.38641016e-02f, -3.14020485e-01f, -9.27625597e-02f, -2.10965946e-01f, 9.55042541e-02f, 3.70226443e-01f, 5.58665633e-01f, 3.86352748e-01f,
  1.84348360e-01f, -4.54277754e-01f, -4.91534531e-01f, 2.31333271e-01f, 1.00025877e-01f, -2.49980450e-01f, 2.47939333e-01f, -2.97459692e-01f, -5.01964629e-01f, -2.55694687e-01f,
  2.68552929e-01f, 4.88592952e-01f, 2.73787469e-01f, -2.05073476e-01f, -1.02318786e-01f, -7.59745762e-02f, -1.40234560e-01f, 1.15318477e-01f, 1.36067808e-01f, -4.07485068e-01f,
  4.37036812e-01f, -2.76827186e-01f, -2.83216834e-01f, 1.89965218e-02f, 3.67232740e-01f, -2.40356520e-01f, -1.30651277e-02f, 1.90259993e-01f, 4.64291930e-01f, 3.78050834e-01f,
  -2.80924346e-02f, 1.85955837e-02f, 6.71696588e-02f, -2.99648404e-01f, 2.69540548e-01f, -1.29217938e-01f, 3.77900958e-01f, -8.83801132e-02f, -2.90858269e-01f, 3.84390533e-01f,
  -6.20200410e-02f, 2.74073899e-01f, -1.86566219e-01f, -1.67683184e-01f, 2.33902514e-01f, 1.69998586e-01f, 2.46925885e-03f, -3.95799726e-01f, -8.22556391e-02f, 7.29782060e-02f,
  1.16670661e-01f, 4.32805628e-01f, -3.79821174e-02f, -1.49318799e-01f, -1.11342698e-01f, -6.34283051e-02f, 4.19420451e-02f, -3.01082768e-02f, 3.61914575e-01f, -6.68338016e-02f,
  1.66264892e-01f, 6.11379892e-02f, 2.14312837e-01f, -8.57713744e-02f, -3.95948350e-01f, 4.60688084e-01f, 3.69888783e-01f, -1.15796793e-02f, 5.73311210e-01f, 6.41548559e-02f,
  -2.55818844e-01f, 5.34954011e-01f, -1.20833041e-02f, 1.56053007e-01f, 1.66147441e-01f, 2.01666117e-01f, 7.41106421e-02f, 1.44999743e-01f, -3.46079141e-01f, -4.09460440e-02f,
  4.14613634e-01f, 2.48333290e-01f, 4.53877896e-01f, -3.99743617e-01f, 4.17465061e-01f, -5.12651443e-01f, -1.61483407e-01f, 1.19741350e-01f, -1.43833652e-01f, 3.32477897e-01f,
  -1.68009792e-02f, 2.21888170e-01f, 1.65686786e-01f, 3.76134366e-01f, 5.82106888e-01f, 3.86528403e-01f, -3.21286321e-01f, 8.35738182e-02f, 9.11541283e-02f, 2.03624442e-01f,
  5.93443036e-01f, 1.54779315e-01f, -3.13568085e-01f, 5.01913071e-01f, -1.44305870e-01f, -4.92514335e-02f, 2.74128884e-01f, 4.96241868e-01f, -4.33383398e-02f, 8.60568732e-02f,
  3.14874172e-01f, 2.53272712e-01f, 2.92517930e-01f, 1.46100402e-01f, -3.56350750e-01f, -4.12768602e-01f, -7.41558969e-01f, 2.48757899e-01f, 1.90086469e-01f, 4.69092160e-01f,
  2.31672138e-01f, -4.38142478e-01f, 1.80313125e-01f, 1.13164306e-01f, 7.03937933e-02f, 9.76157710e-02f, 1.78760201e-01f, 4.38668996e-01f, 2.77777106e-01f, -1.48169547e-01f,
  -2.04484805e-01f, 1.43799379e-01f, -3.11196614e-02f, -3.40615928e-01f, -2.18045395e-02f, -2.79297501e-01f, -7.77076930e-02f, 2.87092984e-01f, 4.64297198e-02f, 6.49906769e-02f,
  1.62787557e-01f, 2.30178326e-01f, 2.09637865e-01f, 4.83462624e-02f, 2.63288677e-01f, 1.13998950e-01f, -3.06994379e-01f, 3.22744846e-01f, -1.89671785e-01f, -2.52328187e-01f,
  2.42420599e-01f, -7.26085901e-01f, 1.29117608e-01f, 4.09140706e-01f, 4.12778080e-01f, 5.41053891e-01f, -3.14499021e-01f, 1.22888066e-01f, 4.24868673e-01f, 1.69098437e-01f,
  2.03539088e-01f, 3.99009168e-01f, 3.65143716e-01f, -3.12814601e-02f, -1.29245937e-01f, 8.69026594e-03f, -1.17674597e-01f, -2.02021405e-01f, 4.41416293e-01f, 5.84465750e-02f,
  -7.36310333e-02f, -2.37040475e-01f, -3.26301157e-02f, 1.97335362e-01f, 3.91337462e-02f, 3.20572644e-01f, 9.82612818e-02f, 1.24676183e-01f, -2.93510497e-01f, 4.16833043e-01f,
  -6.59578741e-02f, 2.16104388e-01f, 4.70585257e-01f, 4.78841662e-01f, 2.99101084e-01f, -2.82954395e-01f, 3.87238003e-02f, -1.06340080e-01f, 4.52399254e-01f, 1.93799157e-02f,
  9.75866616e-02f, 2.67331302e-01f, 1.29736602e-01f, -5.18536687e-01f, -2.70702243e-01f, 1.84398487e-01f, 1.15285859e-01f, -2.29806781e-01f, 1.07412323e-01f, -3.38936672e-02f,
  -2.06693813e-01f, 1.63208812e-01f, 3.64506334e-01f, 1.07907459e-01f, -3.66789758e-01f, -1.35351196e-01f, 2.26030666e-02f, -1.73555717e-01f, -1.62312776e-01f, 2.16064751e-01f,
  4.67209429e-01f, -6.77410722e-01f, 4.49454695e-01f, 2.76441723e-01f, -7.45533824e-01f, -1.92219079e-01f, -1.24731772e-01f, 3.29554200e-01f, -2.65976459e-01f, -9.86924842e-02f,
  -1.25282601e-01f, 2.42548943e-01f, -1.34747699e-01f, 2.05902323e-01f, 2.96593308e-01f, 5.93398213e-01f, 1.13665033e-02f, 5.55459484e-02f, 4.12510961e-01f, 3.56360346e-01f,
  -2.00480133e-01f, 9.90345180e-02f, 1.61169600e-02f, 3.97269502e-02f, -3.62584949e-01f, 2.83309758e-01f, 1.83050558e-01f, 3.43699306e-02f, 1.10178426e-01f, 5.38834259e-02f,
  -3.62767339e-01f, -7.06259310e-02f, -2.29587331e-01f, -3.36716254e-03f, 3.71211290e-01f, -4.16014791e-01f, -2.29140997e-01f, -4.19015825e-01f, -3.75272445e-02f, -4.06838089e-01f,
  4.81966473e-02f, 3.80879581e-01f, 1.28844297e-02f, 3.37662101e-01f, 1.49386764e-01f, 1.74587250e-01f, 2.43854180e-01f, -1.05637051e-01f, 3.03522080e-01f, -4.82119201e-03f,
  -2.31467951e-02f, -4.90157336e-01f, 9.95188486e-03f, 2.69747466e-01f, 2.65734285e-01f, 3.03413808e-01f, -1.53936908e-01f, 1.10444053e-04f, 2.22262636e-01f, 1.43555105e-01f,
  8.26974809e-02f, 2.83705562e-01f, -2.07405403e-01f, -2.05699831e-01f, 1.71732917e-01f, 2.51977265e-01f, -1.28645390e-01f, -3.19034725e-01f, 1.70257804e-03f, -2.69773066e-01f,
  2.67818213e-01f, -5.19103765e-01f, 1.42325521e-01f, -4.23181765e-02f, 2.34255672e-01f, 2.95599908e-01f, -4.24745560e-01f, 2.21831724e-01f, 2.41875634e-01f, -2.32445057e-02f,
  4.39728886e-01f, 1.48625150e-01f, 7.07801804e-02f, -2.31728643e-01f, -1.80550084e-01f, 1.58796057e-01f, 4.62128848e-01f, 4.76592869e-01f, -6.13835156e-02f, -8.52009282e-02f,
  -2.25234643e-01f, -3.54886018e-02f, 2.58319438e-01f, -2.28463694e-01f, 5.90703823e-03f, 1.10115632e-01f, -6.01590276e-01f, 6.95637167e-01f, -5.65201938e-01f, 4.84495223e-01f,
  3.18376690e-01f, -2.81217515e-01f, 1.87748432e-01f, 1.64609283e-01f, 2.97917038e-01f, 1.65354908e-01f, 2.30900139e-01f, -3.70563030e-01f, 1.14397213e-01f, 7.34830201e-02f,
  2.78378129e-01f, 1.64092854e-01f, 1.72242790e-01f, -2.48225704e-02f, -2.30925173e-01f, -2.14030728e-01f, 4.76025641e-01f, -7.28049502e-02f, 3.11760396e-01f, 3.55484553e-05f,
  3.19750816e-01f, -1.86281018e-02f, 1.61284015e-01f, 1.95518062e-01f, 1.90952808e-01f, 1.42031655e-01f, 1.91722676e-01f, 3.66359621e-01f, 1.53767094e-01f, -1.26517758e-01f,
  2.35801786e-01f, -6.70475364e-01f, -4.15950269e-01f, -3.29228789e-01f, -9.99261998e-03f, 1.07343003e-01f, 4.57918346e-01f, 5.70236206e-01f, -2.25772023e-01f, 1.23344794e-01f,
  4.06223059e-01f, 1.40445426e-01f, -9.65588465e-02f, 3.04887772e-01f, 1.21178247e-01f, -3.53140414e-01f, -4.00504470e-02f, -3.94367613e-02f, -4.67724860e-01f, 2.07846269e-01f,
  -3.88292819e-02f, 1.83696359e-01f, 1.09001346e-01f, 1.23117916e-01f, -9.52373538e-03f, 1.95142597e-01f, 4.62031931e-01f, 1.48844615e-01f, 3.00972372e-01f, 2.29010895e-01f,
  6.41660988e-02f, -7.73876011e-01f, -1.50188744e-01f, -3.57687891e-01f, 2.76015729e-01f, 2.70335615e-01f, -3.27021368e-02f, -2.32982874e-01f, -1.06117547e-01f, -4.58296202e-02f,
  -1.63515806e-01f, 2.54018098e-01f, 3.23301554e-01f, 3.26642275e-01f, 3.55963111e-01f, -9.14358497e-02f, -2.92780340e-01f, 1.34179741e-01f, -5.95769659e-02f, -3.27367455e-01f,
  -3.26336414e-01f, 1.72087520e-01f, -4.85830307e-02f, 1.36391863e-01f, -1.70965493e-01f, 1.04997888e-01f, 1.59233466e-01f, 3.07863563e-01f, -7.70088509e-02f, 5.50309062e-01f,
  -2.10899245e-02f, -6.55423552e-02f, 3.71519387e-01f, 2.02858269e-01f, 2.79789120e-01f, -1.16851732e-01f, 3.15454364e-01f, 4.65108335e-01f, 9.68274772e-02f, -4.35682945e-02f,
  -1.93408266e-01f, -1.71078891e-01f, 3.53187174e-01f, 1.74696311e-01f, 1.11556396e-01f, 3.93559694e-01f, -1.40115216e-01f, -2.86600411e-01f, -9.12520364e-02f, 2.73013592e-01f,
  2.23098680e-01f, 2.89829463e-01f, 1.60380766e-01f, 1.67981222e-01f, -1.82611242e-01f, 3.14137697e-01f, 2.72465378e-01f, 4.14907068e-01f, 4.76486385e-01f, 3.02067429e-01f,
  -1.85100138e-01f, 1.66656002e-02f, 2.80292302e-01f, 3.95824790e-01f, 2.26237297e-01f, 5.85093796e-01f, 4.06800836e-01f, -3.33784372e-01f, 5.20158589e-01f, -1.96337685e-01f,
  -3.70703936e-01f, 3.50706547e-01f, 3.15260082e-01f, 3.02856714e-01f, 3.12354118e-01f, -1.55631542e-01f, 1.85627133e-01f, -1.98890164e-01f, -2.63571769e-01f, 1.32477984e-01f,
  2.51718443e-02f, -8.40456709e-02f, 8.62999260e-02f, 3.97572905e-01f, 4.31964755e-01f, -8.80325679e-03f, -1.08120702e-02f, -2.33108506e-01f, 4.75820899e-01f, 2.99650788e-01f,
  -2.62617707e-01f, -1.36593401e-01f, 3.13126862e-01f, -9.13411826e-02f, -1.56954259e-01f, 4.78872173e-02f, 1.52863329e-02f, -1.04985692e-01f, -6.09325409e-01f, -1.20478190e-01f,
  2.30305810e-02f, -2.82849401e-01f, -9.31272060e-02f, -2.30171263e-01f, 2.15667501e-01f, 1.28647983e-01f, -2.85317034e-01f, 2.22775668e-01f, -4.15301949e-01f, -4.10526432e-02f,
  8.19672123e-02f, 1.78035229e-01f, 3.37462842e-01f, 9.72452834e-02f, 1.32642284e-01f, -1.47622228e-01f, 5.82783110e-02f, 1.11391053e-01f, 5.06941378e-01f, 2.79504925e-01f,
  -6.12718225e-01f, -9.06054601e-02f, 3.29878740e-02f, 2.13488445e-01f, 9.77964103e-02f, 5.52960411e-02f, 2.02663183e-01f, 2.62131363e-01f, -4.89012390e-01f, 2.66605824e-01f,
  3.08746360e-02f, -1.38779387e-01f, 3.77694443e-02f, -4.49287444e-01f, 8.82641673e-02f, 1.10381074e-01f, 5.93009830e-01f, 4.05145437e-01f, -6.89658448e-02f, -9.90086421e-02f,
  3.75123888e-01f, 2.15105847e-01f, 1.98783781e-02f, 2.33469501e-01f, -2.97142137e-02f, -1.79550219e-02f, -3.77191544e-01f, -3.86668742e-01f, 1.13009661e-02f, -6.28847927e-02f,
  2.30980203e-01f, 1.57051831e-01f, 1.04863174e-01f, -1.05824791e-01f, -3.08693517e-02f, -1.27702644e-02f, 3.63146663e-01f, 1.50382340e-01f, -4.24396154e-03f, 3.13527972e-01f,
  -2.89763570e-01f, -4.47206318e-01f, -3.99449736e-01f, 3.07120949e-01f, -1.82529017e-01f, 1.90566465e-01f, 4.74896103e-01f, -5.74055351e-02f, 3.66670519e-01f, 1.00134239e-01f,
  -1.42104095e-02f, 1.15399532e-01f, 2.19119802e-01f, 4.36713904e-01f, 5.06740451e-01f, -5.63797280e-02f, -2.57843416e-02f, -7.14811906e-02f, -1.87196717e-01f, -6.14397749e-02f,
  1.41046554e-01f, -1.12775281e-01f, 1.45112664e-01f, 3.94848973e-01f, -1.76983386e-01f, -2.04807296e-01f, 1.29232770e-02f, 6.70762807e-02f, -2.83885121e-01f, 1.37167439e-01f,
  2.46085435e-01f, -2.46011674e-01f, -6.57747746e-01f, 4.45619792e-01f, -6.38429165e-01f, 2.70556241e-01f, 7.90117532e-02f, -2.21270338e-01f, 8.58344361e-02f, -1.97996393e-01f,
  2.72659242e-01f, 3.49254370e-01f, 6.67873472e-02f, -3.10168087e-01f, -2.30621830e-01f, -9.99618229e-03f, 5.50919138e-02f, -3.03295940e-01f, 1.14759641e-04f, -1.19814603e-02f,
  -2.24113211e-01f, -6.91614971e-02f, 4.66842324e-01f, -1.05948567e-01f, 4.27934617e-01f, -1.05431363e-01f, 4.25672889e-01f, -2.22275764e-01f, -1.61715731e-01f, -3.04870661e-02f,
  3.09209347e-01f, 9.12276581e-02f, -1.37700543e-01f, -1.29034132e-01f, -8.68504271e-02f, -6.08816087e-01f, 1.78807437e-01f, 2.82915890e-01f, -1.50718510e-01f, 3.06190908e-01f,
  2.24501863e-01f, -6.52740225e-02f, -4.33678985e-01f, -4.86565351e-01f, -3.02284062e-02f, 1.16430782e-01f, -3.35958004e-01f, 5.69167286e-02f, 4.37940478e-01f, 9.29451287e-02f,
  -1.81856789e-02f, 3.46479654e-01f, -5.85506447e-02f, 4.47824933e-02f, -3.77276652e-02f, 3.08369219e-01f, 1.34397551e-01f, 3.01260710e-01f, -7.94610828e-02f, 1.57908395e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 20)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 20;
const float L3_fan_Bp_bar_data[] = {
  2.79410928e-01f, 1.88914642e-01f, 8.15332085e-02f, 2.44189471e-01f, 1.98916942e-01f, 1.44803628e-01f, 7.54212355e-03f, -6.53285608e-02f, -9.41505581e-02f, 6.47456059e-03f,
  2.48842865e-01f, 1.76460490e-01f, -2.08130386e-02f, -3.72820459e-02f, 3.56291443e-01f, 1.15792908e-01f, 2.36703277e-01f, 3.22500706e-01f, 1.90125197e-01f, -1.02517717e-01f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -9.05974135e-02f, -1.96891680e-01f, -3.55887175e-01f, -3.65677327e-01f, -1.32598588e-02f, -2.16721632e-02f, 7.07397044e-01f, -2.05988899e-01f, -1.11844309e-01f, -3.45873564e-01f,
  -4.69781086e-02f, -1.84011295e-01f, -3.59574229e-01f, 1.72364265e-01f, 1.30090311e-01f, -1.70349196e-01f, 9.59014446e-02f, -3.57726574e-01f, 1.66773990e-01f, -3.26864213e-01f,
  7.23823681e-02f, 2.13584259e-01f, 1.53427720e-01f, -3.94844204e-01f, -4.83068638e-02f, 3.14864628e-02f, -4.62543160e-01f, 9.36832931e-03f, -7.82539919e-02f, 8.02062228e-02f,
  -1.49618334e-03f, 2.64164418e-01f, 5.04880436e-02f, 2.39212975e-01f, 1.91914365e-01f, -2.54688621e-01f, 2.28798464e-02f, 2.53229588e-01f, 4.94456947e-01f, 9.92209092e-02f,
  -8.07959810e-02f, 2.60993272e-01f, 2.09497195e-02f, 2.46917680e-01f, 1.33004859e-01f, -4.71286327e-02f, 2.31510345e-02f, 1.11442216e-01f, -3.05564255e-01f, -2.54095823e-01f,
  3.06353986e-01f, -2.11520582e-01f, -5.57014585e-01f, -7.76035115e-02f, 1.72581822e-02f, -5.57827234e-01f, -2.81221002e-01f, 3.30309600e-01f, 3.67970675e-01f, -1.39822721e-01f,
  -5.11725068e-01f, -6.64189935e-01f, -2.19035283e-01f, -8.01375285e-02f, 1.11032045e-02f, 4.64121103e-02f, -4.71658021e-01f, 3.47494930e-01f, 2.62731612e-01f, 2.61849970e-01f,
  1.17529362e-01f, 4.51844126e-01f, 3.16452265e-01f, -3.66328061e-01f, -2.58152336e-01f, -4.62870687e-01f, -2.40334883e-01f, 2.53962964e-01f, 1.31845638e-01f, 2.51118064e-01f,
  -4.67441380e-01f, 1.32520702e-02f, -9.86310765e-02f, -6.25594258e-01f, 4.77526188e-01f, 1.82820126e-01f, -3.45366865e-01f, 3.02820891e-01f, -2.33498782e-01f, 9.80187058e-02f,
  1.14227600e-01f, -3.94290358e-01f, 1.61930844e-01f, -5.61465845e-02f, -6.81290850e-02f, -5.11666298e-01f, 3.22773695e-01f, -2.43889272e-01f, -5.36661735e-03f, -1.32868096e-01f,
  -1.98305383e-01f, 3.44723873e-02f, 4.37888242e-02f, -2.08686009e-01f, 2.14915752e-01f, -2.33387813e-01f, -4.36194360e-01f, -1.28381252e-01f, -5.19805729e-01f, -8.30983296e-02f,
  -1.13752261e-01f, -7.79541194e-01f, 9.29951072e-02f, 2.22885564e-01f, 3.29170600e-02f, -3.44734341e-01f, -4.72068368e-03f, -3.98494899e-02f, 2.78866887e-01f, 3.02485395e-02f,
  -1.73473462e-01f, -4.76022214e-01f, -6.59316063e-01f, 2.09930941e-01f, 3.45133901e-01f, 2.70345718e-01f, 2.71883935e-01f, -1.83480576e-01f, -6.80768192e-02f, -7.56038874e-02f,
  -3.68378796e-02f, 2.79001206e-01f, -5.69956362e-01f, -4.09742482e-02f, -2.70821214e-01f, 4.27119762e-01f, -4.43313420e-01f, -5.50334789e-02f, 5.54644316e-02f, -5.62740266e-01f,
  -5.15862882e-01f, 1.83168471e-01f, -1.79130465e-01f, -3.70014012e-01f, -1.77871972e-01f, 3.28727961e-02f, -2.14877322e-01f, 2.27474153e-01f, 2.91501313e-01f, 1.86535135e-01f,
  -1.52086653e-02f, 8.70008916e-02f, 2.85869628e-01f, -1.59499049e-01f, -1.33996695e-01f, 3.05165648e-01f, 5.71902245e-02f, 1.18117593e-01f, -4.65329051e-01f, 9.64685157e-02f,
  -1.04753077e-01f, -1.18421175e-01f, 2.14063540e-01f, 3.39889646e-01f, -3.15956712e-01f, 5.44044934e-02f, -4.61468041e-01f, 3.50057304e-01f, -1.05988525e-01f, 1.11101739e-01f,
  -3.22710313e-02f, 2.66771406e-01f, 1.74949452e-01f, 4.96029928e-02f, -2.58862972e-01f, 1.61943272e-01f, 2.95839727e-01f, -4.29293782e-01f, -1.47191780e-02f, 1.11624189e-01f,
  -2.47064009e-01f, 1.27581075e-01f, -5.94297230e-01f, -2.17227917e-02f, 3.49769771e-01f, 2.92113543e-01f, -1.42360210e-01f, -2.26589277e-01f, -2.18498960e-01f, 1.25202954e-01f,
  -3.69971454e-01f, 1.71771049e-01f, -2.52451092e-01f, -3.98408979e-01f, 2.25962266e-01f, 1.89512949e-02f, 2.57125556e-01f, -3.80047679e-01f, -2.90928520e-02f, -3.22674900e-01f,
  6.43124431e-02f, 1.57648563e-01f, -6.53248699e-03f, 3.32780063e-01f, -3.51545841e-01f, 4.28513847e-02f, 2.38776788e-01f, 4.32413965e-01f, -2.54569948e-01f, -2.79502630e-01f,
  -5.27757108e-01f, 3.12923580e-01f, -2.55734175e-01f, -9.99463677e-01f, -7.28915572e-01f, 1.25923246e-01f, 7.61438301e-03f, -1.25899598e-01f, -6.34868369e-02f, -1.34679869e-01f,
  -4.15861040e-01f, -7.51146674e-01f, -1.14894390e-01f, -8.86023343e-02f, -3.09544057e-01f, 1.13966204e-01f, 1.10448562e-01f, 2.83136424e-02f, 2.70955041e-02f, 1.71957389e-01f,
  3.90958697e-01f, 3.57057393e-01f, 1.67247161e-01f, 4.13918167e-01f, 4.52956885e-01f, -4.00974333e-01f, -4.63895828e-01f, -5.54209292e-01f, -2.56866604e-01f, -4.45466936e-01f,
  -6.89278126e-01f, 2.86790103e-01f, -4.39717770e-01f, -1.20747946e-01f, -2.55399287e-01f, 1.19271176e-02f, 3.78515810e-01f, -3.35480779e-01f, -2.38702640e-01f, -2.70953566e-01f,
  2.89521813e-01f, 6.42760172e-02f, 1.21277021e-02f, -3.98226753e-02f, 4.45896685e-01f, -2.29235545e-01f, 3.37091357e-01f, 6.78467155e-02f, 1.47384375e-01f, -8.47478509e-02f,
  9.25572142e-02f, 2.23159157e-02f, 5.53549170e-01f, -2.54344195e-01f, 1.15504459e-01f, -2.47973874e-01f, 3.05117905e-01f, -9.82329771e-02f, 3.22720677e-01f, -5.20575523e-01f,
  -3.19937050e-01f, -3.34061444e-01f, 2.58018732e-01f, -2.46713161e-01f, 2.05502823e-01f, -7.20427036e-02f, -6.26908302e-01f, -2.39727020e-01f, 4.19759423e-01f, -2.27676719e-01f,
  -4.88090456e-01f, -8.32254514e-02f, -1.79603368e-01f, -4.37880546e-01f, 1.26257122e-01f, 1.85129479e-01f, 4.82769996e-01f, -1.76727369e-01f, 3.66538793e-01f, 2.64999330e-01f,
  -1.73010558e-01f, -1.73123881e-01f, 1.37043804e-01f, 2.82025248e-01f, -2.83731163e-01f, -6.26500487e-01f, -2.96943635e-01f, -4.82327677e-02f, -4.59009409e-01f, 5.22452116e-01f,
  -4.69747633e-01f, 2.41932813e-02f, 2.21117839e-01f, 2.75285840e-02f, -7.08707511e-01f, -9.49283037e-03f, -5.33684731e-01f, 3.39365214e-01f, 1.32074550e-01f, 2.02235922e-01f,
  -4.74825263e-01f, -7.37719759e-02f, -1.66089654e-01f, -1.15983654e-02f, -4.00394917e-01f, 4.49571490e-01f, -4.42526162e-01f, -4.05979902e-01f, -8.44757482e-02f, 3.03333253e-01f,
  -2.95837104e-01f, 2.33582005e-01f, -9.32146795e-03f, -1.92182824e-01f, 2.04886615e-01f, -4.20919657e-01f, -5.27566075e-02f, -2.53845215e-01f, 4.48750615e-01f, 2.60781735e-01f,
  1.05695777e-01f, 3.04104239e-01f, 3.26383024e-01f, -2.87496746e-01f, -8.09786201e-01f, -9.41687822e-02f, 3.66565168e-01f, 1.98187321e-01f, 1.22806728e-01f, -3.66504163e-01f,
  2.85611525e-02f, -2.44767383e-01f, 3.79410349e-02f, -2.37384990e-01f, 4.50814217e-01f, -1.21016100e-01f, -5.19891381e-01f, -1.24841869e-01f, 2.23047704e-01f, 3.36054504e-01f,
  -4.66528058e-01f, 1.51393577e-01f, 4.67053562e-01f, 4.29024100e-01f, 7.80082718e-02f, -1.19710557e-01f, -8.67945179e-02f, 2.74280816e-01f, -4.57633913e-01f, -1.56462833e-01f,
  1.42084107e-01f, 1.42534509e-01f, 2.97398180e-01f, 1.34883359e-01f, -1.05191685e-01f, -6.68737471e-01f, 2.94221997e-01f, 9.19371992e-02f, -5.83861917e-02f, 4.31037486e-01f,
  -3.14213067e-01f, -2.43481666e-01f, -8.32875222e-02f, -4.94669199e-01f, 6.04151152e-02f, 3.33078206e-01f, -3.18440855e-01f, -5.14693260e-01f, 2.45614797e-01f, 3.37414332e-02f,
  3.83099496e-01f, -2.33727813e-01f, -3.17723334e-01f, -4.69605386e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -1.71241209e-01f, -1.28124073e-01f, -1.24467500e-01f, -6.32911697e-02f, 6.92333058e-02f, 9.24564227e-02f, -1.15452290e-01f, 3.36366333e-02f, -2.71234550e-02f, -2.10226566e-01f,
  -2.43339792e-01f, -6.13356344e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    