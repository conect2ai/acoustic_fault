/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -5.56277215e-01f, 1.12644427e-01f, -1.95260033e-01f, -1.79520562e-01f, 8.45624879e-02f, 1.85958028e-01f, 1.70688450e-01f, 1.19272061e-02f, -1.45712227e-01f, -6.60586804e-02f,
  -1.57894760e-01f, -2.24024370e-01f, -2.50409007e-01f, -2.65275717e-01f, -2.08194658e-01f, -5.43486234e-03f, -1.34225398e-01f, -2.37416252e-01f, -1.10486545e-01f, 7.73024186e-02f,
  1.87174678e-02f, -1.04787841e-01f, -2.28649586e-01f, -1.85865700e-01f, -5.77741265e-02f, -1.39896661e-01f, -1.24936782e-01f, -9.85359251e-02f, 5.91267347e-02f, -2.56207258e-01f,
  -4.42661464e-01f, 2.51674037e-02f, -2.89439440e-01f, -2.57137358e-01f, -1.38460651e-01f, -1.40369147e-01f, -1.79064006e-01f, -1.69896454e-01f, -1.23217382e-01f, -1.65780529e-01f,
  -1.91242889e-01f, -2.29707286e-01f, -1.85016498e-01f, -8.37929472e-02f, -1.71287805e-01f, -1.34477064e-01f, -1.99454218e-01f, -1.61499113e-01f, -1.85778007e-01f, -1.45486087e-01f,
  -3.88532504e-02f, -1.10335775e-01f, -7.15334266e-02f, -1.05371155e-01f, 1.58986840e-02f, -2.70278722e-01f, -6.69781044e-02f, -1.49340704e-01f, -2.11773172e-01f, -2.26556599e-01f,
  5.62023483e-02f, 4.24504541e-02f, 6.10872135e-02f, 7.20495060e-02f, -2.60171611e-02f, 7.97563493e-02f, 7.96604306e-02f, 1.40607864e-01f, 2.88081337e-02f, 3.57250161e-02f,
  9.04467404e-02f, 8.20557587e-03f, 3.64441960e-03f, 8.07418302e-03f, 5.48683070e-02f, 2.33147126e-02f, 3.85384858e-02f, 6.72680140e-02f, 1.44721922e-02f, 6.57212809e-02f,
  -4.54859920e-02f, 1.24271668e-01f, 1.88949779e-02f, 1.02627397e-01f, 4.47889864e-02f, 4.06941697e-02f, 9.96573735e-03f, 6.59719184e-02f, 1.17130876e-02f, 2.79269237e-02f,
  -3.93122911e-01f, -1.22521512e-01f, -3.08049887e-01f, -1.50358871e-01f, -4.97108139e-02f, -7.70899057e-02f, -9.05530974e-02f, -1.27242088e-01f, -1.18810825e-01f, -8.04697052e-02f,
  -1.81896016e-02f, -1.31263524e-01f, -7.46460408e-02f, -7.82362446e-02f, -7.28032663e-02f, -8.06920007e-02f, -6.22810610e-02f, -9.31100622e-02f, -8.62070471e-02f, -1.93462335e-02f,
  -1.11526936e-01f, -8.18744823e-02f, -2.45346159e-01f, -1.88687146e-01f, -1.03817478e-01f, -2.75225163e-01f, -1.39806524e-01f, -2.11310446e-01f, -2.22675189e-01f, -3.74080092e-01f,
  -1.40530959e-01f, 1.42947525e-01f, 5.06657511e-02f, -1.14008948e-01f, 1.72212765e-01f, 1.39789730e-01f, 1.07485265e-01f, -1.01744868e-01f, -1.42444924e-01f, 9.10811052e-02f,
  3.81221682e-01f, 1.75711364e-01f, 7.98251480e-02f, -7.35299587e-02f, -1.04210347e-01f, -1.10940225e-01f, -3.80503625e-01f, -2.86419600e-01f, -1.79415837e-01f, 5.06852083e-02f,
  -9.21779871e-02f, -2.56588191e-01f, -2.33131349e-01f, -2.18757629e-01f, -5.31576499e-02f, -5.52019551e-02f, -4.40876260e-02f, 7.57322758e-02f, 3.22556235e-02f, -2.36147985e-01f,
  1.37532070e-01f, 1.57776415e-01f, -1.04770422e-01f, -1.08566284e-01f, 1.63014650e-01f, -6.03330508e-02f, -4.52623218e-02f, -4.39760350e-02f, -1.74236838e-02f, -8.29581767e-02f,
  5.05567305e-02f, -1.39408866e-02f, 4.95566688e-02f, -2.89684720e-02f, 3.60728949e-02f, -5.03283925e-02f, -1.73735902e-01f, -1.18902452e-01f, -2.46628523e-02f, 4.91974875e-02f,
  -5.24399392e-02f, -6.82919174e-02f, 1.10868223e-01f, -5.76461852e-02f, 1.43478326e-02f, -1.64472416e-01f, 6.89739734e-02f, -5.47107793e-02f, -4.60754409e-02f, -1.68926418e-01f,
  3.19883712e-02f, 7.58685917e-02f, 1.94050074e-01f, 1.39407769e-01f, 7.05183744e-02f, -7.84935355e-02f, 1.97373815e-02f, 1.32648990e-01f, -5.31428605e-02f, 1.41447410e-02f,
  -1.98417548e-02f, 1.05750054e-01f, -1.17960647e-02f, 8.87870565e-02f, -9.06986222e-02f, 1.19237266e-02f, 9.48774070e-02f, 6.80471165e-03f, -5.20122796e-02f, 2.11108774e-02f,
  1.20265177e-02f, 5.63211776e-02f, 7.06837922e-02f, 4.73102406e-02f, 4.29540826e-03f, -1.96520034e-02f, -4.78546247e-02f, 1.90686822e-01f, 9.91698727e-02f, 2.39738021e-02f,
  4.58415709e-02f, 8.37455317e-02f, -1.42887250e-01f, -1.77876920e-01f, -1.52177691e-01f, -9.03524235e-02f, 3.44579369e-02f, -1.46857649e-01f, 2.56551392e-02f, -9.53328609e-02f,
  -2.49861255e-02f, -9.11481380e-02f, -9.17561073e-03f, -7.01147541e-02f, -1.08908884e-01f, -9.38456059e-02f, -1.60310254e-01f, -1.44959927e-01f, -1.25532001e-01f, -2.88646184e-02f,
  -1.71494558e-01f, -1.80961415e-01f, -1.28672436e-01f, -5.14826253e-02f, -3.20215221e-03f, -1.01704538e-01f, 5.20608164e-02f, -6.65799901e-02f, -4.57118638e-03f, -1.89943239e-01f,
  -4.63079028e-02f, 5.60078800e-01f, 1.23122059e-01f, 1.72347263e-01f, 3.54708552e-01f, 3.41368288e-01f, 4.61001664e-01f, 1.81382000e-01f, 1.53687119e-01f, 2.43258595e-01f,
  -3.48734446e-02f, -1.40153676e-01f, -1.98274478e-01f, -1.32801265e-01f, -9.61138606e-02f, 3.99102241e-01f, 3.16012502e-01f, 3.62140685e-02f, -7.45000541e-02f, -2.14083232e-02f,
  1.59742519e-01f, 1.38404697e-01f, 1.04347337e-02f, 1.95891540e-02f, 3.69132817e-01f, 8.04206952e-02f, 2.59863496e-01f, 2.60969490e-01f, 1.66497737e-01f, 4.27038461e-01f,
  -1.42134521e-02f, 1.78438008e-01f, 1.38507867e-02f, 4.71163122e-03f, 9.54451263e-02f, 5.94942039e-03f, 9.07957777e-02f, 5.38970456e-02f, 1.21340327e-01f, 1.08179979e-01f,
  1.18576802e-01f, 3.58045474e-02f, 1.55013189e-01f, 1.23048745e-01f, 7.40558431e-02f, 1.29493922e-01f, 9.74743143e-02f, 1.70567378e-01f, 1.83140725e-01f, 1.16449170e-01f,
  2.20305189e-01f, 3.77061546e-01f, 3.13686162e-01f, 1.14020139e-01f, 1.57981768e-01f, 5.41292019e-02f, 1.78533345e-01f, 2.28723213e-01f, 2.10455552e-01f, 2.91619599e-01f,
  -1.18624002e-01f, -7.97636434e-02f, -3.65875177e-02f, -1.12611793e-01f, -1.23644888e-01f, -5.61018251e-02f, -5.05719781e-02f, -4.45409827e-02f, -7.67428204e-02f, -1.16220295e-01f,
  -9.49845091e-02f, -1.34451717e-01f, -8.10741708e-02f, -1.19315451e-02f, -9.51591954e-02f, 4.45670113e-02f, 2.43648216e-02f, -1.13898210e-01f, -9.89174917e-02f, -7.53161684e-02f,
  -1.45046875e-01f, -5.39034419e-02f, -1.19752780e-01f, -3.55260409e-02f, -3.37017179e-02f, -9.08987522e-02f, -9.93564352e-02f, -1.52814224e-01f, -7.71270916e-02f, -1.07662566e-01f,
  -4.30249749e-03f, -2.49765962e-02f, 3.56479473e-02f, 5.10072000e-02f, 1.78927481e-01f, 1.15710177e-01f, 9.25986543e-02f, 9.61336717e-02f, 4.52665985e-02f, 1.44117400e-01f,
  1.12511843e-01f, 8.40364397e-02f, 1.23975068e-01f, 1.35781899e-01f, 7.49951303e-02f, 9.93673056e-02f, 1.32340193e-01f, 1.02620885e-01f, 6.53064549e-02f, 2.14475662e-01f,
  1.16860121e-01f, 3.00176948e-01f, 8.02739486e-02f, 1.85843483e-01f, 1.80969328e-01f, 6.98655322e-02f, 1.20230146e-01f, 1.19243868e-01f, 1.22770034e-01f, 1.48719594e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.18592656e-01f, 3.09439719e-01f, 5.50231934e-01f, -3.63494158e-01f, -5.70206106e-01f, -3.43949258e-01f, -3.46881539e-01f, -1.21885620e-01f, -8.66643265e-02f, -9.10354704e-02f,
  -4.38199192e-01f, -3.48782450e-01f, 1.54754609e-01f, 1.35815620e-01f, 1.85632274e-01f, 5.63451469e-01f, 6.36516988e-01f, 4.11374301e-01f, -2.14414090e-01f, -6.10404134e-01f,
  -2.88676828e-01f, -4.03343216e-02f, -8.68726522e-02f, 6.07258566e-02f, 2.19125539e-01f, 4.73793410e-02f, 3.45757455e-01f, 4.44450453e-02f, 1.53706744e-01f, 6.44759834e-01f,
  9.57599841e-03f, -2.29719669e-01f, -1.84713621e-02f, -3.14567089e-01f, -9.24055651e-03f, 5.11753634e-02f, 8.90717804e-02f, 2.34732777e-01f, 4.39035986e-03f, 7.63277262e-02f,
  -2.47965202e-01f, -8.66471082e-02f, -1.32456914e-01f, -4.66895215e-02f, -2.29060903e-01f, -3.09206665e-01f, 1.40559971e-01f, 2.35932156e-01f, 3.60316157e-01f, -1.96604937e-01f,
  -7.84806162e-02f, -4.82667148e-01f, -3.03103179e-01f, -2.03345306e-02f, 1.40467256e-01f, -9.19842198e-02f, -3.63663845e-02f, -2.56526083e-01f, 9.75411236e-02f, 1.62091091e-01f,
  9.75219235e-02f, 1.43537104e-01f, 7.22334981e-02f, 1.24462269e-01f, -1.67531474e-03f, 2.65123043e-02f, 6.15698732e-02f, -7.10442066e-02f, 5.42589538e-02f, -1.18000522e-01f,
  1.80509202e-02f, -2.15424016e-01f, -2.85070799e-02f, -1.16742119e-01f, 1.85123626e-02f, -5.10078901e-03f, -1.56320482e-02f, 4.67638038e-02f, 1.01864792e-01f, 1.66551664e-01f,
  6.50209934e-02f, 7.43369013e-02f, 6.41666949e-02f, 9.78262573e-02f, 4.58831713e-02f, 1.70177355e-01f, -7.15327486e-02f, -1.11298352e-01f, -2.55544726e-02f, -1.68873265e-01f,
  -1.76267564e-01f, 2.32294440e-01f, 6.94281384e-02f, 4.04687971e-02f, 2.90312115e-02f, 6.59897476e-02f, 1.88290030e-02f, -2.10746497e-01f, -9.71407667e-02f, -1.40296251e-01f,
  -2.99807996e-01f, 3.95815168e-03f, 1.57108307e-01f, 1.23854131e-01f, -3.66468221e-01f, -2.05004722e-01f, -2.48334616e-01f, -2.86279827e-01f, 5.24367578e-02f, -5.91914579e-02f,
  8.09862018e-02f, -4.45705235e-01f, -5.49798667e-01f, -1.87521189e-01f, -1.58727810e-01f, -3.96300435e-01f, -9.21068341e-02f, -2.32649267e-01f, -3.99181187e-01f, -2.82264441e-01f,
  1.92599624e-01f, 3.36185098e-01f, -5.04277050e-01f, 5.31041741e-01f, 1.68406561e-01f, -2.49704067e-02f, 3.88409793e-02f, -1.04559988e-01f, 1.58251300e-01f, 1.11056402e-01f,
  9.94178206e-02f, 2.50303566e-01f, 2.30850220e-01f, 1.83861360e-01f, 1.71014257e-02f, 9.57678184e-02f, 2.04600334e-01f, 5.30927852e-02f, -1.15551606e-01f, 3.47544044e-01f,
  5.87689281e-01f, 3.98134053e-01f, 1.53253198e-01f, 7.59954602e-02f, 4.24104601e-01f, 3.40083241e-01f, -4.43611927e-02f, 1.55300111e-01f, 2.05714881e-01f, 6.70300245e-01f,
  -1.83942884e-01f, -7.51862600e-02f, -1.18349671e-01f, 9.94941443e-02f, -1.80037230e-01f, 2.36577183e-01f, -1.00761823e-01f, -2.15347819e-02f, 1.42778710e-01f, 1.46246284e-01f,
  1.28830269e-01f, -8.15573335e-02f, 2.23385602e-01f, 3.45131457e-02f, -2.67904736e-02f, -1.26102149e-01f, -2.28979930e-01f, -2.92158633e-01f, -2.47215882e-01f, -3.85933727e-01f,
  6.15777314e-01f, 1.86648905e-01f, -4.53844875e-01f, -4.30462360e-01f, -4.59885985e-01f, -3.29166561e-01f, -4.24724549e-01f, -2.04762056e-01f, -5.29968202e-01f, -3.95214930e-02f,
  -1.07846996e-02f, -2.11327881e-01f, -4.79979664e-02f, 1.73087437e-02f, 8.98499712e-02f, 2.46368274e-02f, 1.36307597e-01f, -4.88513745e-02f, -3.32629234e-02f, -1.75775468e-01f,
  1.35376547e-02f, -2.30448931e-01f, -3.26294780e-01f, 3.09049655e-02f, 3.07400018e-01f, 3.31189260e-02f, 9.41592976e-02f, 4.02647555e-02f, -1.03489347e-01f, -7.28014857e-02f,
  1.29491955e-01f, 6.85596392e-02f, -2.99274735e-02f, -5.07747270e-02f, 7.31741963e-03f, -6.26083910e-02f, 1.33424789e-01f, 8.55365321e-02f, 2.89996024e-02f, 2.94593096e-01f,
  -1.11788921e-02f, -4.47791010e-01f, -6.37458265e-02f, 5.33529278e-03f, -2.70671397e-01f, -1.82277426e-01f, -4.15667668e-02f, -1.91608682e-01f, 1.74589187e-01f, -2.03301404e-02f,
  -1.18949667e-01f, -7.67443404e-02f, -2.79753581e-02f, -1.18774913e-01f, -1.57445669e-01f, -1.54152244e-01f, -9.11897495e-02f, 4.63876389e-02f, -1.94114640e-01f, -5.38279653e-01f,
  6.10820092e-02f, -1.19979143e-01f, -2.20238447e-01f, -2.87196040e-01f, -2.23455012e-01f, 1.05469860e-01f, -3.36938053e-01f, -2.34873801e-01f, -4.75911319e-01f, -1.55167043e-01f,
  -4.07192141e-01f, -5.16966701e-01f, -3.87504011e-01f, -1.61385149e-01f, 3.33434016e-01f, -3.43937576e-01f, -9.51263130e-01f, -4.83138293e-01f, 3.26244198e-02f, -7.37172961e-02f,
  2.32826725e-01f, 2.84428626e-01f, -3.13248672e-02f, -4.43431064e-02f, -3.53068411e-01f, -3.66924137e-01f, -1.96623698e-01f, -1.13086492e-01f, -8.32073316e-02f, 2.51006931e-01f,
  3.60804260e-01f, 1.25945181e-01f, 4.86960411e-02f, 3.23281884e-02f, 3.52326512e-01f, 2.35409275e-01f, 1.25325739e-01f, 2.91402012e-01f, 1.55650273e-01f, 1.03642836e-01f,
  1.32688016e-01f, -1.43122628e-01f, -3.80085818e-02f, 4.11982358e-01f, 3.51076186e-01f, -1.37279272e-01f, -2.40702942e-01f, 1.62793156e-02f, -6.41754121e-02f, -1.94422230e-02f,
  1.62000000e-01f, 2.25538477e-01f, 3.67942490e-02f, -3.86599004e-02f, 1.29097208e-01f, -2.81177968e-01f, -2.30338186e-01f, -3.39994490e-01f, -3.32174063e-01f, 2.70869080e-02f,
  3.62132549e-01f, 3.23294073e-01f, -2.58921444e-01f, -3.29060227e-01f, -2.86186755e-01f, -8.03485438e-02f, -1.97182655e-01f, 9.52708349e-02f, -4.43737656e-01f, -2.95295119e-01f,
  -1.90618467e-02f, 1.36428297e-01f, -8.64997432e-02f, -2.25026503e-01f, -6.34190291e-02f, 7.20069855e-02f, 4.84735370e-02f, 1.57663561e-02f, 1.83850508e-02f, 6.23918790e-03f,
  -1.16643406e-01f, -1.18220121e-01f, -6.21909201e-02f, -4.01081443e-02f, 1.27088621e-01f, -3.45986225e-02f, 2.90330276e-02f, -7.65420422e-02f, 6.50177225e-02f, -5.20811006e-02f,
  -4.79367487e-02f, 3.16886455e-02f, 1.38060302e-01f, -1.72096193e-01f, -8.88856798e-02f, -1.35264426e-01f, -6.30977899e-02f, 8.79523754e-02f, 3.93814081e-03f, 7.08210319e-02f,
  -2.58121081e-02f, -2.81665385e-01f, -5.06660230e-02f, -1.07999463e-02f, 9.94638354e-02f, 2.28840545e-01f, -7.84158036e-02f, -1.29897904e-03f, -7.72666559e-02f, -1.64571941e-01f,
  -2.14145165e-02f, -2.34117359e-01f, 2.55231578e-02f, -1.49433121e-01f, -1.76419690e-02f, -8.36061090e-02f, 2.78220512e-02f, -2.18533695e-01f, -2.31082484e-01f, 6.93802349e-03f,
  -2.36664042e-01f, -3.10227752e-01f, -4.41962481e-01f, -5.86525857e-01f, -2.22349353e-02f, -3.56436551e-01f, -2.75190115e-01f, -2.27373108e-01f, -4.62403148e-01f, -7.66683519e-01f,
  1.07179856e+00f, 6.07559264e-01f, 3.00862014e-01f, 4.62649286e-01f, 2.10057318e-01f, 1.25377506e-01f, 1.03187643e-01f, -6.43953606e-02f, 1.95936263e-02f, 1.66543856e-01f,
  3.44053596e-01f, 1.87306866e-01f, 1.41964272e-01f, -3.15021202e-02f, 1.10955529e-01f, 6.45352900e-02f, -9.33742970e-02f, 6.72421306e-02f, -6.36211634e-02f, 1.94904163e-01f,
  1.90566391e-01f, 4.77360711e-02f, 1.95903346e-01f, 4.18224372e-02f, 3.06673408e-01f, 5.87006323e-02f, 6.24981336e-02f, 1.30967304e-01f, 2.65786976e-01f, 3.47144842e-01f,
  2.39945531e-01f, 4.96247143e-01f, -3.40652853e-01f, -1.57016724e-01f, 1.64270401e-01f, -1.04671583e-01f, 1.40365884e-01f, -1.29152238e-01f, -5.36484942e-02f, -1.13264851e-01f,
  -3.40013281e-02f, -3.15583940e-03f, -4.69156168e-02f, -1.22399945e-02f, -1.37035549e-01f, -7.50216544e-02f, -7.21386150e-02f, 1.84308551e-02f, -8.84686708e-02f, 1.19721152e-01f,
  5.73074892e-02f, 5.53269871e-02f, -1.04121260e-01f, -3.42315882e-02f, 1.60661221e-01f, -9.47875753e-02f, 1.07686669e-01f, 1.34454250e-01f, -6.17223978e-02f, 1.39052808e-01f,
  6.32317886e-02f, 4.01086330e-01f, 3.96590352e-01f, 1.55702963e-01f, 9.16595235e-02f, 3.53768021e-02f, -6.78621680e-02f, 1.11130094e-02f, 1.28760532e-01f, 4.37045805e-02f,
  -2.40341291e-01f, 7.99435005e-02f, 4.38109413e-02f, -4.93012294e-02f, 1.94516584e-01f, 1.04386523e-01f, -1.05905542e-02f, -6.88907355e-02f, 7.93118626e-02f, -1.56942606e-01f,
  -5.76318502e-02f, -1.53576300e-01f, -1.56125024e-01f, -7.46374726e-02f, -2.56059676e-01f, 1.36326864e-01f, 1.19192287e-01f, 2.57273577e-02f, -1.81029178e-02f, -6.19173869e-02f,
  -9.10417199e-01f, -6.57353699e-02f, 4.49405164e-02f, -1.64522737e-01f, 4.11413498e-02f, 6.77179545e-02f, 2.66985327e-01f, -4.92202714e-02f, 1.41914198e-02f, -2.08068956e-02f,
  -8.44639316e-02f, -4.87043858e-02f, 2.28676833e-02f, -6.01253174e-02f, -2.67840236e-01f, -1.63147718e-01f, 1.38331903e-02f, -1.13231093e-01f, -2.30324522e-01f, -2.46093441e-02f,
  -1.48745745e-01f, -2.84795254e-01f, -2.13278845e-01f, -1.57259792e-01f, -4.75622490e-02f, -2.13621989e-01f, -2.13302150e-01f, -2.56126940e-01f, -2.86535501e-01f, -2.68793285e-01f,
  1.26242089e+00f, 1.71042502e-01f, -3.83633673e-01f, 2.07384035e-01f, -3.95458460e-01f, -2.44775981e-01f, -1.06967583e-01f, 2.20517516e-01f, 1.78656384e-01f, 1.00446418e-01f,
  1.45185308e-03f, 5.12402225e-03f, 8.07732195e-02f, -2.18913015e-02f, 3.18642318e-01f, 1.54717684e-01f, -8.79675895e-03f, 6.40826952e-03f, -5.39071113e-02f, 1.23540964e-02f,
  -6.98944693e-03f, 2.62794405e-01f, 3.87646556e-01f, 1.21896610e-01f, -1.68187156e-01f, -1.43869519e-01f, -7.38823414e-02f, -3.43180627e-01f, -3.90518159e-01f, -2.03921318e-01f,
  -6.94923759e-01f, -1.48101881e-01f, 1.77406237e-01f, -4.18716557e-02f, 2.23694723e-02f, 3.06106299e-01f, 1.76509440e-01f, 2.59568822e-02f, 3.12886052e-02f, 2.36961376e-02f,
  7.54561350e-02f, -2.00311397e-03f, -1.39112011e-01f, -2.15487242e-01f, -5.90354055e-02f, -1.35200873e-01f, -4.35506329e-02f, 3.99063528e-02f, -1.38783187e-01f, -1.51067317e-01f,
  -1.01003863e-01f, -2.22530618e-01f, -1.31964162e-01f, -1.18691556e-01f, 6.20133579e-02f, 1.70132436e-03f, -1.88268885e-01f, -1.21636696e-01f, -1.41863838e-01f, 1.22110091e-01f,
  -1.12553351e-01f, 2.08081767e-01f, -6.43541366e-02f, -9.21443030e-02f, 1.66813806e-01f, 8.81046876e-02f, -4.23560031e-02f, 1.47829488e-01f, 6.77245185e-02f, 4.72758971e-02f,
  -5.45213819e-02f, -9.50982720e-02f, -1.41155779e-01f, 7.91034549e-02f, -9.80703756e-02f, -1.31530762e-01f, -9.75138135e-03f, -1.17111951e-01f, -1.29956856e-01f, -3.21280137e-02f,
  8.76867473e-02f, 8.13442916e-02f, -7.03817680e-02f, -1.19525008e-01f, -2.81210393e-01f, -1.45487905e-01f, -1.71113163e-01f, -1.63162783e-01f, 6.05677143e-02f, 1.44199580e-01f,
  -1.24147616e-01f, -3.30148876e-01f, 2.42690444e-01f, 2.47763440e-01f, -3.84573601e-02f, 3.67578794e-03f, 2.52828132e-02f, -4.93829362e-02f, -1.90085858e-01f, -1.25382185e-01f,
  -9.41829756e-02f, 3.28351483e-02f, -1.28451407e-01f, -3.92681286e-02f, 9.35197528e-03f, -2.98896227e-02f, 7.82177299e-02f, 1.50604188e-01f, -1.92085709e-02f, -8.17103237e-02f,
  1.05914306e-02f, 1.43332675e-01f, 2.12590218e-01f, 1.65375233e-01f, 6.32309318e-02f, 2.16348737e-01f, 2.86219716e-02f, 5.05988933e-02f, 4.10980061e-02f, 4.53636080e-01f,
  -8.47023010e-01f, -1.14201926e-01f, -3.54324877e-02f, 3.13821584e-01f, 3.29832107e-01f, 3.29696983e-01f, 4.76393312e-01f, 3.37188870e-01f, 3.93471122e-01f, 2.16085285e-01f,
  4.92415689e-02f, 3.90983164e-01f, 4.78521407e-01f, 2.51439571e-01f, 3.05902272e-01f, 4.70905662e-01f, 5.20056784e-01f, 3.99640948e-03f, 2.62875799e-02f, 1.72013104e-01f,
  3.61091405e-01f, 1.49510801e-01f, -1.81429073e-01f, 1.32048771e-01f, 1.31130233e-01f, 3.76780182e-01f, 2.66175419e-01f, 1.38525173e-01f, 1.47797614e-01f, 2.36798540e-01f,
  -6.59538209e-02f, -4.47836488e-01f, 1.67474955e-01f, -7.86672011e-02f, -3.31146985e-01f, -1.77288726e-01f, -1.16660567e-02f, -1.02583624e-01f, -2.14256316e-01f, 4.63883299e-03f,
  -5.30339368e-02f, -1.70702159e-01f, -1.74897071e-02f, -5.28655909e-02f, -1.08015023e-01f, -1.75980315e-01f, -2.40948200e-01f, 5.95072992e-02f, 1.45351887e-01f, -6.15014024e-02f,
  -4.86969575e-02f, -1.45201445e-01f, 9.92393494e-02f, 1.88874647e-01f, 4.66166437e-03f, 9.06255376e-03f, -1.34073958e-01f, -1.83950782e-01f, -7.51370862e-02f, 4.66631651e-02f,
  2.72583038e-01f, 3.12760845e-02f, -1.14681736e-01f, 1.23320334e-01f, -4.12637740e-02f, 7.35585913e-02f, 6.70294464e-02f, 2.29568675e-01f, 7.95377567e-02f, 8.96021053e-02f,
  2.74518460e-01f, 1.85247973e-01f, 9.79589894e-02f, 1.88576832e-01f, -5.46513870e-03f, -7.21876323e-02f, -2.20225409e-01f, -3.49341892e-02f, -1.55386180e-01f, -1.26547769e-01f,
  -1.60840929e-01f, -1.43155158e-02f, -2.56808490e-01f, -4.20055538e-03f, -1.77836400e-02f, 6.66196272e-02f, 8.07177797e-02f, 4.25378419e-02f, -4.75543104e-02f, -2.14733873e-02f,
  4.88376647e-01f, -8.81835669e-02f, 9.56364498e-02f, 5.37395626e-02f, -2.46407419e-01f, -2.78859138e-01f, 1.69623997e-02f, -9.85898897e-02f, -1.75452247e-01f, 1.05692700e-01f,
  -4.85935695e-02f, -2.54040927e-01f, -7.40045086e-02f, -8.30187090e-03f, -7.58295208e-02f, -3.01644318e-02f, -1.93003953e-01f, 1.55285075e-01f, 1.63753510e-01f, -1.35678484e-03f,
  -5.51568670e-03f, 1.86097935e-01f, 1.38864547e-01f, 1.85491443e-01f, 2.07079321e-01f, 1.32560924e-01f, 3.45125198e-02f, -4.39019203e-02f, 1.19123787e-01f, 2.47775063e-01f,
  -2.36220554e-01f, 2.41252333e-01f, -1.01081169e+00f, -8.24785829e-01f, -7.90157974e-01f, -3.03687453e-01f, 5.19128621e-01f, -4.36624065e-02f, -4.19122249e-01f, 1.01358473e-01f,
  2.87253320e-01f, 1.95878580e-01f, 4.12993878e-02f, 2.62343377e-01f, 6.27043605e-01f, 2.89263159e-01f, -3.19663376e-01f, -1.58010378e-01f, 1.13056079e-01f, 2.75999397e-01f,
  3.77310991e-01f, -7.71855190e-02f, -5.90359718e-02f, -1.13842271e-01f, -4.43932533e-01f, -1.48792818e-01f, -5.38801014e-01f, -4.83657420e-01f, -5.31846732e-02f, -5.37253261e-01f,
  2.89861679e-01f, -6.00546777e-01f, -1.16002224e-01f, -6.67534843e-02f, -8.60889107e-02f, 6.43221736e-02f, -9.06202383e-03f, -2.52005547e-01f, -3.00295930e-02f, -6.21147342e-02f,
  -2.25506023e-01f, -9.40637216e-02f, -1.45663455e-01f, -7.37727759e-03f, -2.96661437e-01f, -3.22599001e-02f, -2.42744982e-01f, -2.49961987e-01f, -1.55644044e-01f, 8.90633613e-02f,
  1.76456124e-01f, -2.40404978e-01f, -2.18965009e-01f, -1.04698226e-01f, -2.45161131e-01f, -1.83546975e-01f, -1.50656328e-01f, -2.59858549e-01f, -1.87379599e-01f, -2.80135963e-02f,
  1.47934169e-01f, -9.95113254e-02f, -1.67304531e-01f, -5.13079017e-02f, 1.73585489e-01f, -4.11743484e-02f, -1.44475088e-01f, 1.82777271e-01f, 5.79269342e-02f, 1.05198048e-01f,
  -1.70357779e-01f, 1.31020591e-01f, -3.61894816e-02f, -2.71067377e-02f, -2.96842791e-02f, -1.76467374e-03f, 1.33377388e-01f, 2.98457861e-01f, 1.99294835e-02f, -2.27707550e-02f,
  -2.71847155e-02f, -1.03742875e-01f, -1.88157380e-01f, 2.20365524e-01f, 2.81453971e-02f, -6.79701790e-02f, 8.00011680e-03f, 1.50831625e-01f, 9.24768299e-03f, -8.25390890e-02f,
  5.33875883e-01f, 1.11695834e-01f, 7.24101812e-02f, 1.40753016e-01f, -1.53046787e-01f, -1.34326011e-01f, -4.13689092e-02f, -4.52951994e-03f, -1.34060875e-01f, 5.25471456e-02f,
  -2.80275010e-02f, 1.27331644e-01f, 8.31599608e-02f, 6.83311298e-02f, -7.04192324e-03f, -9.86242667e-02f, 2.15049312e-01f, -2.29756255e-02f, 2.90132761e-02f, -1.09333538e-01f,
  1.55404150e-01f, 3.13052058e-01f, 4.67068285e-01f, 2.26410061e-01f, 4.17195559e-02f, 3.08871418e-02f, 1.77635700e-01f, 1.63494751e-01f, 3.97296727e-01f, 5.61153650e-01f,
  -5.30021012e-01f, -3.11981350e-01f, 3.81706715e-01f, -9.30502772e-01f, -3.95627707e-01f, 2.43709460e-01f, 3.52263987e-01f, -3.65029365e-01f, -6.21665001e-01f, -6.75099120e-02f,
  1.68727949e-01f, 6.22670315e-02f, -7.75857419e-02f, 9.34538916e-02f, 4.49477971e-01f, 1.74365282e-01f, -1.67166561e-01f, 2.10514992e-01f, 4.12779242e-01f, 1.65668413e-01f,
  -1.60661444e-01f, -4.77816910e-01f, -3.38564456e-01f, -2.47062609e-01f, -5.78573942e-01f, -1.73760593e-01f, -3.69654834e-01f, -4.19749200e-01f, 1.21533848e-01f, -4.96183604e-01f,
  4.83705670e-01f, -4.63219851e-01f, -1.67186573e-01f, -2.44404390e-01f, -2.08029673e-01f, -3.81502658e-02f, -1.43850058e-01f, -3.52027893e-01f, -1.30883589e-01f, -5.10317571e-02f,
  -2.05372050e-01f, -6.92335069e-02f, -1.40729755e-01f, 3.54985595e-02f, -1.07119180e-01f, -7.57060722e-02f, -2.22837821e-01f, -2.51841158e-01f, -2.07277328e-01f, -7.15114027e-02f,
  -1.12481013e-01f, 3.30774905e-03f, 3.10158134e-01f, 1.10117398e-01f, -6.44679815e-02f, 6.64691627e-02f, -2.62740273e-02f, -7.22421035e-02f, 8.73627961e-02f, -1.68831438e-01f,
  -8.95439163e-02f, 2.75718272e-02f, 3.32444683e-02f, -5.75028360e-02f, -4.93346248e-04f, 8.15335736e-02f, 7.24422038e-02f, 8.73452798e-02f, -9.52679384e-03f, -6.23863824e-02f,
  1.09155914e-02f, 9.32517350e-02f, 2.35973150e-02f, 2.89769284e-02f, -6.80987956e-03f, 6.90384060e-02f, 1.61667690e-01f, -1.95115968e-03f, -1.16797507e-01f, -8.13023597e-02f,
  -9.06025246e-02f, -7.30566960e-03f, -2.60584801e-02f, -6.56390190e-03f, 2.48188227e-02f, -3.84815745e-02f, -4.44079563e-02f, 1.14179119e-01f, 9.88805592e-02f, -7.61875808e-02f,
  8.76381174e-02f, 3.27047348e-01f, 3.01672183e-02f, -2.27487981e-01f, -2.30913267e-01f, -1.32383689e-01f, -8.73669758e-02f, -2.49293670e-01f, -1.46048903e-01f, 8.14498588e-02f,
  -4.20209095e-02f, 1.58528816e-02f, 6.14536926e-02f, 8.15289968e-04f, 1.74760744e-01f, 4.89505194e-02f, 4.18579727e-02f, -2.87712160e-02f, -4.04634550e-02f, -1.29556224e-01f,
  -2.57394612e-01f, 1.61454126e-01f, 5.08141637e-01f, 1.85678095e-01f, -7.75580034e-02f, 2.92666167e-01f, 2.91706830e-01f, 1.26408413e-01f, 4.37266231e-01f, 2.89268911e-01f,
  -4.73300815e-02f, 2.22445978e-03f, -3.45016271e-01f, 4.91363667e-02f, -1.31703839e-01f, -2.50766993e-01f, -2.87567616e-01f, -6.78008720e-02f, 1.40648201e-01f, 9.53990519e-02f,
  8.81237984e-02f, -1.70127943e-01f, -3.38415086e-01f, -4.61525768e-01f, -4.33002710e-01f, -1.91945553e-01f, -2.11985663e-01f, -4.64231521e-01f, -5.56122422e-01f, -1.19657069e-01f,
  5.67039549e-02f, -3.26001681e-02f, -1.51975080e-01f, -1.26854673e-01f, -9.51242968e-02f, -3.53434026e-01f, -1.55449361e-01f, -2.17670798e-01f, -3.29176247e-01f, -3.94642800e-01f,
  -3.24929893e-01f, -2.46488348e-01f, 1.27402738e-01f, -8.43006223e-02f, 3.00842911e-01f, 9.07809809e-02f, 6.03276677e-02f, 4.99717146e-02f, 7.37043545e-02f, 8.73108655e-02f,
  -1.52305841e-01f, -1.53103452e-02f, 1.20525956e-02f, 6.82886108e-04f, -4.39269692e-02f, -7.07634985e-02f, -8.28494225e-03f, -1.42230257e-01f, -8.97524655e-02f, -7.21338987e-02f,
  -8.28819573e-02f, -2.80643016e-01f, -5.91797054e-01f, -4.63028103e-02f, -4.89250571e-02f, -2.77907342e-01f, -2.65336245e-01f, -2.20164657e-01f, -2.70630896e-01f, -1.54079333e-01f,
  4.35239613e-01f, -7.82040656e-02f, -6.61093229e-03f, -2.24221736e-01f, 4.25765850e-03f, 9.55281481e-02f, -1.53460979e-01f, -8.66528824e-02f, -3.79303135e-02f, -1.12636626e-01f,
  2.05043688e-01f, 1.18426800e-01f, 7.17430189e-02f, 1.10196792e-01f, -2.29564250e-01f, 3.10097151e-02f, 1.16414584e-01f, -3.29036191e-02f, -7.43734092e-02f, -5.15767112e-02f,
  -1.88631222e-01f, -1.04755268e-01f, 1.52848922e-02f, -1.65576637e-02f, 4.88496898e-03f, -1.11012859e-03f, 1.05843157e-01f, -6.56440705e-02f, 3.55534516e-02f, 1.89776883e-01f,
  -4.58888859e-02f, 7.72962943e-02f, 1.65761765e-02f, -1.57198161e-01f, -8.90162289e-02f, 1.68678105e-01f, 6.82526380e-02f, 1.95434406e-01f, 2.92911921e-02f, 6.07609637e-02f,
  -1.96136981e-01f, 1.40531838e-01f, 4.23464917e-05f, 4.38995175e-02f, 4.54326235e-02f, -1.68615371e-01f, -4.04976979e-02f, -2.47740909e-01f, -3.29464823e-01f, 1.82277605e-01f,
  -3.76412668e-03f, -2.81783223e-01f, -4.45250541e-01f, -1.66663438e-01f, -1.15801804e-01f, -4.26373780e-01f, -3.49536806e-01f, -2.56925404e-01f, -2.62615889e-01f, -8.39208663e-02f,
  -4.15670156e-01f, -8.77152324e-01f, -1.57995135e-01f, -4.38061118e-01f, 5.90867281e-01f, 8.48155677e-01f, 6.88889563e-01f, 5.21640182e-01f, 1.41200051e-01f, -1.56938508e-01f,
  -5.07977664e-01f, -4.79567885e-01f, -7.07540929e-01f, -2.77299315e-01f, -4.69213761e-02f, 1.54193804e-01f, 1.08719818e-01f, -1.55054796e-02f, 5.63058436e-01f, 6.87236726e-01f,
  8.91555026e-02f, -2.71696448e-01f, -2.97921240e-01f, -1.85849607e-01f, -3.87253672e-01f, -9.82036591e-02f, -4.40456390e-01f, -3.16442281e-01f, -2.69665918e-03f, -6.13302350e-01f,
  7.47493804e-02f, -1.35214269e-01f, 2.42518514e-01f, -2.14892238e-01f, -3.14448476e-01f, 2.56611872e-02f, 2.36110985e-02f, -2.47203887e-01f, -1.27906827e-02f, -1.83561556e-02f,
  -2.39930719e-01f, 1.35778068e-02f, -2.16499910e-01f, -3.80240157e-02f, 2.64733229e-02f, 3.29207703e-02f, -2.29196757e-01f, -1.60716966e-01f, -1.64229006e-01f, 4.49167304e-02f,
  -1.74895227e-01f, -2.68929033e-03f, 3.22670443e-03f, 1.39956281e-01f, 8.49721357e-02f, 7.03577325e-02f, -1.15618452e-01f, 1.49085954e-01f, 1.10692367e-01f, -2.10658759e-01f,
  -2.90359333e-02f, -2.81726830e-02f, 6.83473572e-02f, 8.09544139e-03f, 2.89903842e-02f, 1.18718132e-01f, 1.56707820e-02f, 2.26250174e-03f, -3.39682028e-02f, -1.07641853e-01f,
  3.62057909e-02f, -1.24011347e-02f, 7.17294682e-03f, -1.49208263e-01f, -2.13315114e-01f, -2.68663689e-02f, 2.31383890e-02f, -2.32440338e-01f, -9.57201049e-02f, -8.28483552e-02f,
  -1.96856037e-02f, 1.06132738e-01f, -3.47344615e-02f, -5.53819500e-02f, -5.75900357e-03f, -8.23525935e-02f, 8.24224669e-03f, -1.02636613e-01f, -6.30933791e-02f, 1.71290021e-02f,
  -2.99125403e-01f, 1.83290586e-01f, 9.13517252e-02f, -6.66318983e-02f, -1.91506855e-02f, -1.50596187e-01f, -2.93639570e-01f, 5.34180962e-02f, -3.59881446e-02f, 1.52737498e-01f,
  4.42977510e-02f, -8.04061592e-02f, -2.83215553e-01f, -1.63185243e-02f, 1.43106073e-01f, 1.29075855e-01f, -2.05278501e-01f, -1.70692623e-01f, 3.92752551e-02f, -5.87913692e-02f,
  -5.70317544e-02f, 2.87853479e-01f, 9.50688794e-02f, 1.54485226e-01f, 1.97538704e-01f, 3.50260496e-01f, 1.45566419e-01f, 2.75545895e-01f, 2.94361800e-01f, 2.05183491e-01f,
  -8.22908223e-01f, 8.63054514e-01f, 4.80579406e-01f, -5.08656263e-01f, 4.03980225e-01f, 3.61205697e-01f, 5.40461719e-01f, -4.17688899e-02f, -1.39353588e-01f, 3.65309387e-01f,
  3.64182621e-01f, -1.94399983e-01f, 7.51409680e-02f, -1.96866885e-01f, -4.66163099e-01f, 3.89670283e-02f, -1.50872916e-01f, -5.91439903e-01f, -7.32515633e-01f, -6.59111977e-01f,
  -2.52434611e-01f, -3.49041224e-01f, -5.62610984e-01f, -3.64388436e-01f, 1.52322873e-01f, -1.70923918e-01f, 4.28768575e-01f, 9.62967500e-02f, 3.92641574e-01f, 1.53536931e-01f,
  2.70665567e-02f, 3.89701873e-01f, -2.25206077e-01f, -2.25827619e-01f, -3.94406123e-03f, -4.39583182e-01f, -6.02508038e-02f, -7.63228238e-02f, -1.19940728e-01f, -9.00602713e-02f,
  1.88929699e-02f, -5.16416393e-02f, -3.28503363e-02f, -4.95518371e-02f, -1.94062904e-01f, -2.36394256e-01f, -2.73288488e-01f, -4.78604347e-01f, -3.99060756e-01f, -9.36348736e-02f,
  -1.46137103e-01f, 5.24197035e-02f, 2.01785535e-01f, 1.90420020e-02f, -3.96916457e-02f, -2.32254729e-01f, 1.68483257e-01f, -8.52507055e-02f, 1.09258279e-01f, -1.43653322e-02f,
  -1.49321467e-01f, -1.97521038e-02f, 7.92757869e-02f, 9.90754589e-02f, -4.16126773e-02f, 7.27146864e-02f, -1.45590203e-02f, -1.01174027e-01f, -8.82655382e-02f, -6.25129491e-02f,
  1.14113338e-01f, 4.12503518e-02f, -5.04941754e-02f, -9.62743594e-04f, -9.76662263e-02f, 4.60058898e-02f, -1.79749995e-01f, -1.00884259e-01f, 5.41575216e-02f, -8.99331272e-03f,
  -1.83158010e-01f, -7.96580315e-02f, -7.26450160e-02f, -2.60801226e-01f, 3.85167822e-02f, 1.17896199e-01f, -4.23727930e-02f, -3.96780595e-02f, -8.76771063e-02f, 1.74612075e-01f,
  -5.47220349e-01f, -6.99033737e-02f, -2.33934730e-01f, -1.72173858e-01f, 3.50027308e-02f, -2.00332459e-02f, 2.09475562e-01f, -6.49336874e-02f, 1.28401130e-01f, -1.32956907e-01f,
  1.00658305e-01f, -1.14022776e-01f, 1.93351582e-01f, -9.56645533e-02f, -2.04441100e-01f, 3.91271114e-02f, -1.43927485e-01f, -6.88054487e-02f, -1.37994543e-01f, -8.21084380e-02f,
  -2.15362728e-01f, -1.47553995e-01f, -3.85747969e-01f, -4.91513610e-02f, -9.05141011e-02f, -1.87884495e-01f, -9.79817063e-02f, -5.74042462e-02f, -1.38450444e-01f, -1.87501922e-01f,
  4.21349019e-01f, -3.14423025e-01f, 9.45965201e-03f, 3.45778853e-01f, -9.18766484e-02f, -3.29982281e-01f, -5.20633340e-01f, -1.67795643e-01f, 3.17029059e-01f, -1.48498029e-01f,
  -4.00976986e-01f, -9.07634422e-02f, 3.73418629e-01f, -1.85380086e-01f, -3.23678911e-01f, -1.70430362e-01f, -2.48353481e-02f, -1.10122032e-01f, -2.25296319e-01f, -7.67506957e-01f,
  -3.73512715e-01f, 5.39168529e-02f, -4.86951470e-02f, -4.65917923e-02f, 8.03267062e-02f, 4.35198285e-02f, 1.56001106e-01f, -7.95959607e-02f, -5.07390976e-01f, -8.13884137e-04f,
  5.22730172e-01f, -3.58397275e-01f, -1.44726172e-01f, -4.00364101e-01f, -6.90421686e-02f, -1.31361201e-01f, -2.37876382e-02f, 1.52748004e-01f, -1.25831783e-01f, -4.52024490e-02f,
  -2.13101715e-01f, -4.67167109e-01f, -2.02747062e-02f, -1.57900289e-01f, -1.25350300e-02f, 2.52393223e-02f, -7.30476454e-02f, -2.98968136e-01f, -7.00735375e-02f, -2.82177538e-01f,
  -4.64188248e-01f, -3.22285920e-01f, 6.81747720e-02f, 1.86000057e-02f, -1.26913592e-01f, -1.08251385e-01f, -8.07659030e-02f, -2.27289200e-01f, -1.50048463e-02f, 2.76744157e-01f,
  2.80144271e-02f, 2.89894342e-01f, -6.06666356e-02f, -8.56963322e-02f, 1.51526090e-02f, 8.79488289e-02f, 1.81041166e-01f, 3.84610482e-02f, -6.77609891e-02f, 7.02658221e-02f,
  6.12773420e-03f, -6.09850660e-02f, 1.48661047e-01f, 6.21092506e-02f, 1.79948155e-02f, 1.67065963e-01f, -1.04211733e-01f, -7.78891239e-03f, -3.17787118e-02f, -4.67580184e-03f,
  -3.13070230e-02f, 1.62191704e-01f, 1.96622714e-01f, 1.05701879e-01f, -2.32626259e-01f, -4.02170699e-03f, -1.11596949e-01f, -1.61339015e-01f, 4.44029681e-02f, -1.92018285e-01f,
  7.09761858e-01f, -4.56143707e-01f, 4.87987459e-01f, -1.21410459e-01f, -3.16140354e-02f, -1.30836532e-01f, 1.83566026e-02f, -1.67415023e-01f, 3.93096618e-02f, -4.96450886e-02f,
  -4.58300263e-01f, -5.83090149e-02f, 1.76716387e-01f, -8.92325342e-02f, 8.01227801e-03f, -9.86129045e-02f, -4.49324012e-01f, -9.29776281e-02f, -1.08487874e-01f, -3.56684577e-05f,
  -2.94893477e-02f, -7.78100034e-03f, 4.28686380e-01f, 4.86712575e-01f, 1.04648858e-01f, 2.86742866e-01f, 4.53825504e-01f, 2.19802856e-01f, 2.37186447e-01f, 4.52787966e-01f,
  -1.25475609e+00f, -1.65681109e-01f, 5.36407173e-01f, -8.23113084e-01f, -2.30880842e-01f, 1.38675168e-01f, 8.81903991e-02f, 2.37582717e-02f, -1.80662066e-01f, -8.09995309e-02f,
  -5.93015514e-02f, -3.58315438e-01f, -3.18450272e-01f, 7.43744569e-03f, -2.20023930e-01f, 3.37518305e-01f, -5.54508455e-02f, -3.77234370e-01f, -2.66893983e-01f, -1.55442171e-02f,
  -2.57138699e-01f, -6.13766849e-01f, -7.12149620e-01f, -2.17623949e-01f, -6.12059087e-02f, -1.75727561e-01f, -1.51415654e-02f, -3.33669394e-01f, -8.40536505e-02f, -1.75340697e-01f,
  5.87755680e-01f, -3.70831996e-01f, 9.67922155e-03f, -2.96354115e-01f, 4.37040627e-02f, -1.33589149e-01f, -5.33147044e-02f, 1.26783596e-02f, -8.28651488e-02f, 2.43619643e-02f,
  -1.86927944e-01f, -3.96824740e-02f, -8.43042135e-02f, 4.37647514e-02f, -1.15811199e-01f, -2.13371906e-02f, -3.34299058e-02f, -1.63090974e-01f, 1.24532096e-01f, 3.75988811e-01f,
  1.23282865e-01f, -1.65750772e-01f, -8.05740943e-04f, 8.51325318e-02f, 9.35436934e-02f, -1.98276013e-01f, 7.53747895e-02f, 7.26354271e-02f, 1.29978910e-01f, 7.05476478e-02f,
  2.09469825e-01f, 1.03614897e-01f, 8.75116810e-02f, -7.36565655e-03f, -9.83175635e-02f, -4.27658530e-03f, -4.53039370e-02f, -3.92569453e-02f, 2.69557592e-02f, -6.12223335e-02f,
  -4.79821190e-02f, 9.40310284e-02f, -6.45480759e-04f, -8.67183879e-02f, -9.19502787e-03f, -6.59517869e-02f, -1.25809535e-01f, 9.41086113e-02f, 1.28824338e-01f, -1.50765091e-01f,
  -1.20206572e-01f, 1.01456344e-02f, 5.40639944e-02f, 5.87187484e-02f, 9.12095830e-02f, -1.20664120e-01f, 2.06145737e-02f, -1.73667222e-02f, 5.03459247e-03f, -6.89042881e-02f,
  1.95709631e-01f, -3.08920532e-01f, -1.59841120e-01f, 1.75874215e-02f, -7.42749572e-02f, 9.73806009e-02f, -2.45527979e-02f, 3.39960456e-02f, -1.18343040e-01f, 1.62240937e-01f,
  5.26839457e-02f, 1.66144483e-02f, 5.01549020e-02f, 1.01046577e-01f, -9.86032039e-02f, 3.27355415e-02f, -1.39014110e-01f, -6.00322485e-02f, 2.06187740e-01f, 3.62665981e-01f,
  1.64931282e-01f, -1.03882618e-01f, -8.74296948e-02f, 1.42387494e-01f, 1.93784088e-01f, -7.26594850e-02f, 7.71258250e-02f, 1.64324507e-01f, 9.05082673e-02f, -6.06728792e-02f,
  -3.38510394e-01f, 6.01421595e-01f, 1.15777031e-01f, -1.51755974e-01f, 3.59113693e-01f, 4.33094203e-01f, 8.84790063e-01f, 3.74797642e-01f, -9.47770104e-02f, 3.83934021e-01f,
  3.97428572e-01f, -3.23556602e-01f, -9.58433449e-02f, -2.55747944e-01f, 9.77242738e-03f, 3.96395832e-01f, 1.28983110e-01f, -5.35058916e-01f, -6.82768464e-01f, -3.85368556e-01f,
  -1.66871727e-01f, -5.13196625e-02f, -2.59388447e-01f, -3.02805722e-01f, 2.17066482e-02f, -2.66832590e-01f, 4.77320313e-01f, 2.28055134e-01f, 7.22399950e-02f, -5.51048636e-01f,
  -4.01124150e-01f, 5.28718472e-01f, -4.45338726e-01f, -1.66656330e-01f, 1.14694335e-01f, -1.69794440e-01f, -3.70912552e-02f, -1.28375903e-01f, 4.79990579e-02f, -3.95098440e-02f,
  2.60679182e-02f, 3.44286077e-02f, 1.40246764e-01f, 7.02057108e-02f, 2.08889678e-01f, 1.79732248e-01f, 7.97925442e-02f, -1.44159243e-01f, 6.04924820e-02f, -2.73119118e-02f,
  1.91493239e-02f, 1.48455903e-01f, 3.09402883e-01f, 2.89597332e-01f, 1.53320432e-01f, -1.68937773e-01f, 3.00058722e-01f, -2.63063937e-01f, -1.06938235e-01f, -4.32819992e-01f,
  -3.33616048e-01f, -1.32934377e-01f, 1.00495376e-01f, 4.29948680e-02f, 2.04214230e-02f, -1.90859232e-02f, -2.80991918e-03f, 5.07124234e-04f, 2.05901507e-02f, 5.78118414e-02f,
  -1.81023106e-01f, -5.47105335e-02f, -6.31280094e-02f, 4.32185642e-02f, -1.34997919e-01f, 1.53532758e-01f, -2.70997323e-02f, 2.60708686e-02f, 1.43975854e-01f, 2.15070099e-01f,
  3.66168991e-02f, -6.52392115e-03f, 2.42207516e-02f, -1.87366813e-01f, 7.92745315e-03f, -1.44451112e-01f, -9.81671065e-02f, -6.31463155e-02f, 2.86267120e-02f, 1.62624538e-01f,
  1.13881715e-01f, 6.13032281e-01f, -1.74246311e-01f, -1.19926352e-02f, 1.26019523e-01f, -2.19586752e-02f, -3.40193510e-02f, -2.45957300e-01f, 1.86328799e-01f, -5.49544580e-02f,
  -1.12773301e-02f, -2.62413889e-01f, 3.60235631e-01f, -3.31904367e-02f, -2.73506194e-01f, -1.83363874e-02f, -2.28618160e-02f, -2.42041662e-01f, -6.75230175e-02f, -1.13474233e-02f,
  3.90253328e-02f, -1.81267649e-01f, -3.62450182e-01f, -1.05075687e-01f, -3.52314338e-02f, -5.10829270e-01f, -6.51958734e-02f, -2.16065928e-01f, -2.84021907e-02f, -2.21189782e-01f,
  7.50400841e-01f, -4.52299625e-01f, -4.92591709e-01f, -3.95826809e-02f, -3.89207423e-01f, -3.42702925e-01f, -8.29057455e-01f, -3.85287613e-01f, 9.15516466e-02f, -6.47544324e-01f,
  -1.58197150e-01f, 7.13173866e-01f, 1.74768046e-01f, -1.24413799e-02f, -4.31689382e-01f, -1.09999835e+00f, -1.02505875e+00f, -2.83738434e-01f, 8.16164538e-02f, 1.81509778e-01f,
  7.58917443e-03f, 7.91036244e-03f, 4.88561578e-02f, -7.50348195e-02f, -1.89922713e-02f, 1.95644628e-02f, -6.11557543e-01f, -1.61769718e-01f, -3.46086144e-01f, -2.40177333e-01f,
  -1.33393914e-01f, 1.35775805e-01f, -1.35343820e-01f, 2.06351951e-02f, -1.65783167e-01f, 3.40229310e-02f, 2.08321097e-03f, 2.76859906e-02f, -6.09315597e-02f, -1.28094694e-02f,
  6.14473447e-02f, 1.36871189e-01f, 2.08579734e-01f, 1.20357811e-01f, -9.34261009e-02f, 1.01430498e-01f, -1.59158736e-01f, -1.20098568e-01f, -2.28739053e-01f, 2.06839517e-02f,
  2.49346495e-02f, 1.40188992e-01f, 7.54729658e-02f, -2.16844037e-01f, -5.05018607e-02f, 2.11426169e-01f, 1.44737111e-02f, 1.26304165e-01f, 4.92002517e-02f, -4.46293242e-02f,
  -9.34856310e-02f, 2.04175897e-02f, -6.42156154e-02f, 3.85602042e-02f, 1.81278773e-02f, -1.31557947e-02f, 1.27815483e-02f, -2.52724662e-02f, 1.06243901e-01f, -5.64177558e-02f,
  -1.01533927e-01f, -1.37557030e-01f, -1.08492792e-01f, -1.45325169e-01f, -1.46126449e-01f, 6.62605092e-02f, -1.05271794e-01f, -8.06945115e-02f, 3.79749611e-02f, -1.23112965e-02f,
  5.23796901e-02f, 4.80379425e-02f, 8.07197839e-02f, -1.56841278e-02f, -1.27229467e-01f, -5.44240959e-02f, 6.96806163e-02f, 1.62121817e-01f, 1.16935223e-01f, 3.16966996e-02f,
  4.27684397e-01f, -2.32569620e-01f, -3.03886347e-02f, 5.67470095e-04f, -1.29838631e-01f, -2.96054147e-02f, -4.05385680e-02f, -1.44300863e-01f, 5.11207692e-02f, -1.85899902e-02f,
  2.28441395e-02f, 1.14582166e-01f, 5.90002276e-02f, 1.42447231e-02f, 1.78887116e-04f, 3.94505821e-02f, -1.32294819e-01f, 7.60894120e-02f, -1.05638057e-01f, -2.25485303e-02f,
  -2.41170585e-01f, -4.81244512e-02f, 4.72521037e-02f, -2.96265390e-02f, -1.55782420e-02f, 1.40774801e-01f, -7.18018264e-02f, 1.87978577e-02f, -6.36810139e-02f, -2.37390682e-01f,
  -1.17621228e-01f, -2.13113010e-01f, -7.10112393e-01f, -3.40484440e-01f, -3.10238987e-01f, -2.04744637e-01f, 6.56534508e-02f, 1.84821904e-01f, 1.61996558e-01f, 4.61015590e-02f,
  1.91431828e-02f, -1.31951883e-01f, -1.00771666e-01f, -2.20449388e-01f, -3.43891561e-01f, -2.15718031e-01f, -3.38123232e-01f, -5.66710234e-01f, -6.10538423e-01f, -2.41488874e-01f,
  -3.68400306e-01f, -5.59340298e-01f, -4.12503988e-01f, -3.94177854e-01f, -1.73089132e-01f, -3.18403661e-01f, -2.83960313e-01f, -4.02944267e-01f, -2.61732876e-01f, -5.72349668e-01f,
  -4.26274151e-01f, -1.03647120e-01f, 3.91305685e-02f, 1.51764631e-01f, -3.27335186e-02f, 1.23153657e-01f, 5.61793684e-04f, 5.41942604e-02f, 2.72007436e-01f, 9.06104594e-02f,
  5.30662276e-02f, 5.13407439e-02f, -8.92912596e-02f, -9.33637545e-02f, -9.16247889e-02f, -5.03718033e-02f, 1.41138121e-01f, 1.34538695e-01f, 1.97468549e-01f, 3.10835212e-01f,
  2.19800115e-01f, 4.95758094e-02f, 1.80013910e-01f, 2.95210153e-01f, 2.77544498e-01f, -5.77236898e-02f, 7.95113742e-02f, 2.65668720e-01f, 4.18788008e-02f, 4.29023355e-02f,
  -2.09181771e-01f, 1.36274248e-01f, 5.64315878e-02f, -7.77730048e-02f, 6.72968626e-02f, 2.33067468e-01f, 5.36643937e-02f, -4.85548638e-02f, 2.01740265e-02f, -9.26829204e-02f,
  1.77727759e-01f, 7.24411458e-02f, -1.12753373e-03f, -1.80817489e-02f, -1.21970214e-01f, 1.07754365e-01f, 6.39919713e-02f, 4.35635112e-02f, 1.21184714e-01f, 1.68978468e-01f,
  1.70173526e-01f, 1.93532467e-01f, 1.72311198e-02f, -6.32107863e-03f, -1.11103626e-02f, -5.02751097e-02f, -2.81341840e-02f, -6.80824928e-03f, -7.55745405e-03f, 8.28398317e-02f,
  -2.88212329e-01f, -1.02079034e-01f, 3.33430544e-02f, 9.50484723e-02f, -2.61506420e-02f, 1.73520386e-01f, -1.09659120e-01f, 2.36417092e-02f, 1.66760013e-02f, -1.63896784e-01f,
  -6.75693825e-02f, -5.99697977e-02f, -1.41871020e-01f, 4.54659350e-02f, -1.83464736e-01f, -4.02487852e-02f, 1.46910802e-01f, -5.32659777e-02f, 4.44364063e-02f, 1.02860890e-01f,
  1.89024225e-01f, 2.25312382e-01f, 1.49671480e-01f, 8.39141756e-02f, 9.75116491e-02f, -5.39444238e-02f, -1.75761119e-01f, 7.75314867e-02f, -1.36466533e-01f, 7.69527778e-02f,
  1.03024745e+00f, -4.31694761e-02f, -9.22054291e-01f, 5.47918141e-01f, -8.77262235e-01f, -4.91214871e-01f, -1.19776130e-01f, 6.82254374e-01f, 5.34889579e-01f, -2.25013103e-02f,
  -4.69911784e-01f, -1.53423652e-01f, -1.04545236e-01f, -1.04361407e-01f, 3.04784030e-01f, -2.42103934e-01f, -3.80986631e-01f, -1.76494285e-01f, -1.80933345e-02f, 1.10324070e-01f,
  -3.91060747e-02f, 3.07509571e-01f, 5.40975749e-01f, 3.09300333e-01f, 1.38974963e-02f, 1.46192014e-02f, -2.29132771e-01f, -2.06221968e-01f, -3.21442544e-01f, -3.80072713e-01f,
  -3.16952169e-01f, 4.46218193e-01f, -2.31330827e-01f, 3.21807787e-02f, -4.78520751e-01f, 2.04678491e-01f, -5.85925840e-02f, -1.29882917e-02f, -8.62029046e-02f, 2.61311401e-02f,
  -4.75730240e-01f, 6.14857243e-04f, -7.37308636e-02f, 8.54624063e-02f, 9.62406397e-02f, 1.20118961e-01f, 1.95014700e-01f, 2.01990873e-01f, 1.63498133e-01f, -3.71919312e-02f,
  -4.69499648e-01f, -5.82114518e-01f, -5.17440796e-01f, -2.06518427e-01f, 2.74700552e-01f, -3.50823760e-01f, -6.90237284e-02f, 9.92425904e-02f, 2.39531577e-01f, 3.59576881e-01f,
  4.11495194e-02f, -1.40209228e-01f, 8.98638666e-02f, 1.86089367e-01f, 8.53300914e-02f, -1.21549480e-01f, 5.98170459e-02f, -1.22260250e-01f, 1.23748988e-01f, 3.13337818e-02f,
  2.47359574e-02f, 8.86073261e-02f, 1.16603464e-01f, 1.68724746e-01f, 2.16640189e-01f, 2.13755444e-02f, -1.71539098e-01f, 9.59498063e-02f, -3.10653970e-02f, 1.45208463e-01f,
  6.64019138e-02f, -2.64120072e-01f, -8.49173814e-02f, 1.09815754e-01f, -1.47704571e-01f, 1.77637313e-03f, 1.30618766e-01f, 1.21448189e-01f, 1.42811581e-01f, -1.17201516e-02f,
  3.14819902e-01f, -3.29360306e-01f, 1.13557642e-02f, 4.00788188e-02f, -1.96149826e-01f, -9.06176344e-02f, -7.53812864e-02f, -6.28436357e-02f, -1.03630841e-01f, 7.49907196e-02f,
  -4.00450826e-02f, 1.26365334e-01f, 1.52771613e-02f, 8.21970850e-02f, 7.46296868e-02f, 1.01669259e-01f, 3.72478589e-02f, -4.65221167e-01f, -8.24093148e-02f, -1.98566884e-01f,
  5.38113341e-02f, -5.65159582e-02f, -8.62729624e-02f, -2.15895027e-01f, -1.69707518e-02f, -6.11385889e-02f, -1.56435788e-01f, -8.73405784e-02f, -1.30973756e-01f, 2.99670726e-01f,
  1.08180217e-01f, 4.54259306e-01f, -3.53751361e-01f, 4.78804201e-01f, 2.48861536e-02f, -4.07408834e-01f, -1.53849244e-01f, -2.80902117e-01f, 2.82987595e-01f, 6.11977696e-01f,
  2.90819556e-01f, -2.36356795e-01f, -4.74678017e-02f, -4.38312173e-01f, -7.12337196e-01f, 8.31374228e-02f, 2.14131419e-02f, -7.25078940e-01f, -1.04968655e+00f, -7.11891353e-01f,
  7.58480281e-02f, 1.39474526e-01f, -1.50036335e-01f, -1.65719509e-01f, 5.79207540e-01f, 1.42108738e-01f, 4.96852487e-01f, 3.11381876e-01f, -8.65675509e-03f, 5.37047505e-01f,
  6.33212402e-02f, -1.68116018e-01f, -2.16529936e-01f, -2.38874871e-02f, 1.11968480e-01f, -7.12851509e-02f, -2.71619469e-01f, -2.26922408e-01f, 5.92430215e-03f, 1.22250192e-01f,
  5.39708100e-02f, -2.09469330e-02f, -2.18981594e-01f, -2.42384411e-02f, -1.08053535e-01f, -1.55184925e-01f, -9.17088613e-02f, -3.73897552e-01f, -1.49530962e-01f, -7.81072453e-02f,
  -3.19706164e-02f, -2.30892688e-01f, -3.07195753e-01f, -2.04365492e-01f, -4.10309881e-01f, -2.51820385e-01f, -2.48676669e-02f, -3.78535569e-01f, -3.30832124e-01f, 4.75620359e-01f,
  -5.19638099e-02f, -5.43503761e-02f, -5.09100966e-02f, 8.74778926e-02f, 6.45125210e-02f, -2.54419670e-02f, 1.34149507e-01f, 3.23380232e-02f, -2.88303327e-02f, 1.79121532e-02f,
  -1.32801563e-01f, 1.08043499e-01f, -7.04333484e-02f, 1.58250835e-02f, 2.20447853e-02f, -2.14071875e-03f, -6.18784828e-03f, 1.83805361e-01f, -2.13182077e-01f, 2.64886916e-02f,
  -1.01261683e-01f, 4.62455526e-02f, 4.49872389e-02f, 3.96323949e-03f, 1.19980359e-02f, -3.77074182e-02f, 6.01982772e-02f, -6.18883334e-02f, -1.11443363e-01f, 1.49804145e-01f,
  3.86076003e-01f, -3.04278463e-01f, 4.10265923e-01f, -1.60061389e-01f, 3.34132798e-02f, -2.98296511e-02f, 1.81854829e-01f, 3.22617181e-02f, 2.71634042e-01f, -6.15743361e-02f,
  -1.81552783e-01f, -1.35194018e-01f, 5.83114140e-02f, 7.69733340e-02f, -1.12416722e-01f, 4.77649551e-03f, 3.07089388e-02f, 1.54511750e-01f, -1.74732715e-01f, 1.76395729e-01f,
  3.30409288e-01f, 3.09590367e-03f, 6.33659735e-02f, 1.42980948e-01f, -1.33748010e-01f, -1.16729490e-01f, 2.13015273e-01f, 1.00939304e-01f, -3.11658800e-01f, 7.39495933e-01f,
  4.43450630e-01f, -7.51823857e-02f, -9.79043245e-01f, 2.27356613e-01f, 3.58531699e-02f, -3.01381886e-01f, 1.59405486e-03f, -1.97469108e-02f, 9.76753235e-02f, 3.64069380e-02f,
  5.61276376e-02f, -3.50493602e-02f, -4.92528617e-01f, -2.51831889e-01f, -4.96701032e-01f, -6.31046295e-01f, -5.78422904e-01f, -6.03578269e-01f, -9.97696742e-02f, 6.72732353e-01f,
  7.76140749e-01f, 5.48566997e-01f, 4.10780132e-01f, -1.84979857e-04f, 3.48063074e-02f, -7.75014758e-02f, -2.64456660e-01f, 8.04699808e-02f, -1.26931578e-01f, -3.28500241e-01f,
  -5.39346039e-01f, -6.40955627e-01f, -1.88791621e-02f, 1.66350733e-02f, 7.61660337e-02f, -7.24898353e-02f, 2.21774671e-02f, -3.62100393e-01f, -1.56661540e-01f, -1.15340263e-01f,
  -9.91038531e-02f, -1.03228278e-01f, -1.05388321e-01f, 2.80925091e-02f, -7.46231601e-02f, -7.66168386e-02f, 1.86522275e-01f, -2.18794212e-01f, -2.47059941e-01f, -3.12909782e-01f,
  2.66533941e-01f, -3.15128043e-02f, -5.67762911e-01f, -9.08749476e-02f, -2.59188920e-01f, -1.09465122e-01f, -1.12616450e-01f, -1.21252880e-01f, -3.44913453e-01f, -4.36024442e-02f,
  1.05350301e-01f, 3.05721145e-02f, 7.35252574e-02f, 2.25423530e-01f, 4.07293051e-01f, -6.32570609e-02f, -1.34791821e-01f, -3.96082439e-02f, 5.69032840e-02f, 1.19689805e-02f,
  -9.43649560e-02f, -6.27627522e-02f, -9.02376100e-02f, -1.98537394e-01f, -6.56743422e-02f, -1.15809843e-01f, -2.18967795e-01f, 1.03620134e-01f, 6.72006831e-02f, 1.17661141e-01f,
  5.60431555e-02f, -9.30501446e-02f, 3.82309556e-02f, 1.40156103e-02f, -1.52204692e-01f, -1.92705199e-01f, -3.50705795e-02f, 2.83205286e-02f, 6.16747662e-02f, -7.14439228e-02f,
  2.28834987e-01f, -1.79980099e-02f, -2.49692738e-01f, -1.14327960e-01f, -1.33115947e-01f, -7.25430921e-02f, 7.88623318e-02f, -3.05955205e-02f, -1.45990431e-01f, -3.38077941e-03f,
  -1.78069681e-01f, -1.76276729e-01f, -6.72906563e-02f, 5.18249944e-02f, 3.49600315e-02f, -2.99690589e-02f, 1.49867922e-01f, -1.93258837e-01f, 4.66309972e-02f, 5.14788441e-02f,
  2.01678142e-01f, 9.26783085e-02f, 9.49339271e-02f, 1.31173106e-02f, 1.08429417e-01f, -2.16869661e-03f, -1.18787408e-01f, -6.58745691e-02f, -3.13319504e-01f, 2.89760768e-01f,
  8.59753072e-01f, -8.64593804e-01f, 2.26191640e-01f, 3.82144958e-01f, 4.58074033e-01f, 3.19604427e-01f, -4.72527482e-02f, 1.07482105e-01f, 2.57094741e-01f, 8.10436308e-02f,
  -5.39534576e-02f, 1.48358762e-01f, 6.66554123e-02f, 3.06033939e-02f, -8.85616057e-03f, -2.82142814e-02f, 2.22162053e-01f, 4.37466502e-01f, 4.60277945e-01f, 1.27692953e-01f,
  -7.55016506e-02f, -8.40543136e-02f, 7.64775202e-02f, 7.99905881e-02f, -2.77347118e-02f, 2.44550735e-01f, -3.35889980e-02f, -2.68931892e-02f, -1.80895522e-01f, -2.20600143e-01f,
  -2.82520473e-01f, -1.38759658e-01f, 3.58177930e-01f, -2.57894788e-02f, -1.43447295e-01f, -1.75855950e-01f, -1.98570993e-02f, -1.31156728e-01f, -1.35401502e-01f, -6.82613254e-02f,
  -1.23605274e-01f, -1.52822882e-01f, -8.28579143e-02f, -1.52174830e-01f, 2.36200332e-03f, 3.29534709e-02f, -1.27257690e-01f, -3.99683826e-02f, -1.15531057e-01f, -2.98146278e-01f,
  -2.57556677e-01f, 9.23842564e-02f, 1.75256178e-01f, -5.51801510e-02f, -3.87419388e-02f, 1.71453476e-01f, -2.50704139e-02f, -9.70861390e-02f, 1.03590965e-01f, -1.37694208e-02f,
  2.36701131e-01f, 1.19232401e-01f, 1.34574831e-01f, 8.61852169e-02f, 8.79705399e-02f, 5.44580771e-03f, 9.30404589e-02f, -7.39771361e-03f, 2.48602763e-01f, 9.60004777e-02f,
  -4.92063202e-02f, 2.20372826e-01f, 2.95747761e-02f, 3.22709270e-02f, 3.22799057e-01f, -2.32438277e-02f, 1.01118185e-01f, 2.91764997e-02f, 1.89387172e-01f, 2.15359509e-01f,
  2.18952268e-01f, -8.64462703e-02f, 3.33148800e-02f, -1.92008346e-01f, 2.06054654e-02f, 3.08486164e-01f, 3.65446419e-01f, 1.76991522e-01f, 1.39775023e-01f, 9.22763869e-02f,
  -4.15566832e-01f, 4.55761254e-01f, 2.23448291e-01f, -1.67297885e-01f, -1.49573386e-01f, -1.22781783e-01f, -4.98281233e-02f, -1.27281725e-01f, -1.58862352e-01f, -1.10090151e-01f,
  -1.72099829e-01f, -9.27499533e-02f, -1.64863691e-01f, -1.11904465e-01f, 2.08677411e-01f, 6.26974031e-02f, -4.26934250e-02f, -4.13144603e-02f, -2.04413846e-01f, -2.83451468e-01f,
  -2.03034922e-01f, 6.48634359e-02f, 2.02664971e-01f, 1.49933457e-01f, 3.57761011e-02f, 3.54843229e-01f, 7.32115358e-02f, -1.13299629e-02f, 2.99348652e-01f, 1.66617975e-01f,
  -1.34649003e+00f, -4.92555290e-01f, 1.22477479e-01f, -4.51702327e-01f, 1.76454782e-01f, 3.18411320e-01f, 2.85601556e-01f, 7.71936625e-02f, -1.54859632e-01f, -4.10312980e-01f,
  -4.44163650e-01f, -2.13430271e-01f, -1.00166559e-01f, 1.45380467e-01f, 2.34534726e-01f, 2.50049889e-01f, 4.82061863e-01f, 4.82411504e-01f, 2.82018661e-01f, 9.13232937e-02f,
  2.16532260e-01f, -9.90245715e-02f, -2.49065876e-01f, 2.59690136e-01f, -2.86560982e-01f, 1.07707329e-01f, 1.26183376e-01f, -1.24586307e-01f, 7.80955553e-02f, -2.11005807e-02f,
  -1.04667044e+00f, -6.93063617e-01f, 4.28893477e-01f, -3.19328271e-02f, -1.34440079e-01f, -3.43368202e-01f, -2.94946618e-02f, -1.83797538e-01f, -4.34878133e-02f, -1.53330326e-01f,
  -1.46515146e-01f, -1.54459983e-01f, -5.35596348e-02f, -1.99076645e-02f, -1.44432694e-01f, -1.17022274e-02f, 4.04561721e-02f, 5.45153767e-02f, -4.93222848e-02f, -1.60425857e-01f,
  3.11119586e-01f, -2.61148214e-01f, -4.39690679e-01f, 3.37373555e-01f, 3.73724960e-02f, 1.30466670e-01f, -8.85311514e-02f, -1.43283010e-01f, -5.93333207e-02f, -7.75771618e-01f,
  -6.58963397e-02f, -3.57682668e-02f, 1.36427149e-01f, -8.30245763e-02f, 7.14127859e-03f, -5.56027815e-02f, 1.46529987e-01f, 1.58101127e-01f, -6.12463336e-03f, -2.10519284e-02f,
  7.87878036e-02f, -1.34650441e-02f, 1.60288051e-01f, -6.57560900e-02f, 6.75853118e-02f, -2.57520322e-02f, 5.07179163e-02f, 1.77993566e-01f, 6.32347018e-02f, -4.31841463e-02f,
  7.51613779e-03f, 6.97420388e-02f, -6.58633038e-02f, 1.17308304e-01f, 2.56615765e-02f, 2.70473719e-01f, -5.64575605e-02f, -1.17815956e-02f, -1.45810544e-01f, -2.49566436e-01f,
  -5.41307569e-01f, 5.00794232e-01f, -5.88330388e-01f, -2.91584060e-03f, -1.65994599e-01f, 8.49501416e-02f, 9.74130630e-02f, 2.89125046e-06f, -2.27163434e-01f, -2.04537973e-01f,
  5.51606566e-02f, -1.31621823e-01f, -1.52342319e-01f, 2.09557921e-01f, 4.42285389e-02f, -9.42486376e-02f, -8.45586732e-02f, 1.14236675e-01f, 3.06987646e-03f, -1.34773314e-01f,
  2.48743251e-01f, -3.45381796e-02f, -6.55952692e-01f, -1.20616466e-01f, -2.06379145e-01f, -2.77587235e-01f, -2.97451884e-01f, -1.71065584e-01f, -2.23280475e-01f, -6.07278764e-01f,
  3.19536850e-02f, 1.11351833e-01f, 7.17000127e-01f, 4.79413383e-02f, 2.92750616e-02f, -5.25440514e-01f, -8.33926976e-01f, -4.72285241e-01f, 4.56108116e-02f, 2.37579912e-01f,
  2.13002741e-01f, 4.78390753e-02f, 8.99764746e-02f, -5.05931415e-02f, -3.78397226e-01f, -4.87997197e-02f, 2.36618415e-01f, 2.20092908e-02f, -4.56709445e-01f, -4.15257603e-01f,
  -2.52408624e-01f, -1.25343442e-01f, 5.34575731e-02f, -1.96175762e-02f, 3.52285177e-01f, 1.42252505e-01f, 5.31466842e-01f, 2.92062968e-01f, 2.38656625e-01f, 7.14253187e-01f,
  6.24843001e-01f, 3.30877393e-01f, -4.96807545e-01f, 6.03733631e-03f, 2.73104519e-01f, 2.16316208e-02f, -1.28164917e-01f, 1.44096658e-01f, -3.38836499e-02f, 1.72366381e-01f,
  2.86643296e-01f, 1.02796882e-01f, -8.63343328e-02f, 7.13139996e-02f, -6.40580356e-02f, -1.12250760e-01f, 2.59080350e-01f, -9.77547392e-02f, 7.94340484e-03f, 1.14604816e-01f,
  9.94030833e-02f, 7.08543733e-02f, 1.31953359e-01f, -2.60084331e-01f, -1.30826429e-01f, 4.37332354e-02f, -1.54297188e-01f, -2.39693490e-03f, -2.43420731e-02f, 1.41063556e-01f,
  -1.75543875e-01f, 7.56883696e-02f, -1.43568944e-02f, 1.04135588e-01f, -1.37983888e-01f, 1.33062243e-01f, 1.36912525e-01f, 3.27210203e-02f, -1.19298272e-01f, 1.27478644e-01f,
  4.04952206e-02f, 5.54820336e-02f, -5.66078611e-02f, 5.07056043e-02f, 5.29703051e-02f, 2.19527796e-01f, 9.01953727e-02f, -1.60943940e-02f, 5.18472008e-02f, 8.74649957e-02f,
  -5.14747053e-02f, -1.31568285e-02f, 1.71670690e-01f, -6.54327944e-02f, 1.27276629e-01f, 7.16960579e-02f, 1.32944986e-01f, 1.65617391e-02f, 1.45621514e-02f, 1.21948510e-01f,
  -1.33341059e-01f, -4.33279127e-01f, -9.27884430e-02f, -6.07758015e-02f, 1.14866398e-01f, 1.56887978e-01f, 1.83365956e-01f, 7.63600692e-03f, 2.72956848e-01f, -7.64138550e-02f,
  1.57818105e-02f, 2.17234381e-02f, 5.46408854e-02f, 9.76926461e-03f, -2.85917670e-01f, 4.85193096e-02f, 7.62855560e-02f, 8.93430933e-02f, -1.21469267e-01f, 1.40103757e-01f,
  3.26437727e-02f, -5.49432278e-01f, -5.30119121e-01f, -4.13981259e-01f, -2.11600587e-01f, -3.58327538e-01f, -3.76506686e-01f, -2.57471085e-01f, -3.88516068e-01f, -7.27244735e-01f,
  8.02788734e-01f, 1.03669964e-01f, 7.01887369e-01f, -4.01376970e-02f, -3.46351773e-01f, -6.80756047e-02f, 5.39586768e-02f, 1.52752027e-01f, -2.42866665e-01f, -1.52002141e-01f,
  -6.69683576e-01f, -8.00836384e-01f, -6.66543484e-01f, -4.14873600e-01f, 1.78223968e-01f, 2.29508400e-01f, 4.93329048e-01f, 6.42960012e-01f, 5.80659986e-01f, 1.53533205e-01f,
  -2.78488874e-01f, 5.05917013e-01f, 6.94105029e-01f, 3.07165623e-01f, -1.56814102e-02f, -2.73535520e-01f, 3.97231609e-01f, 2.87159920e-01f, -5.64863458e-02f, 1.46731719e-01f,
  1.27410889e-01f, 3.95982325e-01f, -1.38564840e-01f, -2.56160289e-01f, -3.67654972e-02f, 4.09475453e-02f, -8.46910626e-02f, 1.90032661e-01f, -6.79890439e-02f, 3.56634893e-02f,
  -3.15787673e-01f, -1.67057157e-01f, -2.49458328e-01f, -7.97238201e-02f, 4.64192666e-02f, 4.42006160e-03f, 1.72358856e-01f, 3.36511046e-01f, -4.82975952e-02f, -1.47533342e-01f,
  -6.43275559e-01f, -8.49326421e-03f, 2.23661199e-01f, -7.18505085e-02f, -1.56873643e-01f, -2.22247601e-01f, 9.94385853e-02f, -7.96802789e-02f, 1.80943966e-01f, 1.72293574e-01f,
  -1.97230905e-01f, -9.61907655e-02f, -1.34384274e-01f, 1.72939431e-02f, -2.94938125e-02f, -1.41439900e-01f, -2.62155563e-01f, -1.65099323e-01f, -2.48095058e-02f, 9.30773392e-02f,
  -1.76041991e-01f, 1.30089689e-02f, -4.36266512e-02f, -1.06471509e-01f, -1.85244843e-01f, 1.33972272e-01f, -1.87372603e-02f, 8.83294791e-02f, 5.74619621e-02f, 1.16194710e-01f,
  -1.01933032e-01f, -3.33166048e-02f, 1.39366314e-01f, -2.06174683e-02f, -2.32427567e-02f, -2.52420474e-02f, -2.90044826e-02f, -1.92547385e-02f, 7.27484748e-02f, 6.94972090e-03f,
  -2.02989861e-01f, -1.36021614e-01f, -7.62062669e-02f, 4.71205115e-02f, 1.95655841e-02f, -1.02279454e-01f, -1.52388483e-01f, -1.24845818e-01f, -1.91942051e-01f, 1.08848445e-01f,
  4.65500914e-02f, -1.46283358e-01f, -1.40820891e-01f, 1.50110247e-02f, -1.32226069e-02f, 7.17716375e-06f, -9.34366137e-02f, -1.03427924e-01f, -9.38420892e-02f, -3.83735262e-02f,
  -1.20299377e-01f, 7.24985525e-02f, 1.49904311e-01f, -1.14685357e-01f, -2.75500208e-01f, -1.54203027e-01f, 2.53050346e-02f, -8.04058537e-02f, 1.02227882e-01f, 2.01261461e-01f,
  6.51416719e-01f, -1.01122701e+00f, -1.04009643e-01f, -1.63705215e-01f, -2.30950639e-01f, -3.37615013e-01f, -9.06043410e-01f, -2.81294435e-01f, 1.80016998e-02f, -7.11129010e-01f,
  -1.73447877e-02f, 9.93200600e-01f, 6.73807561e-01f, 5.65049827e-01f, 2.60298938e-01f, -8.35759223e-01f, -6.08998656e-01f, 5.19436181e-01f, 7.67560363e-01f, -2.46188417e-02f,
  -2.54991651e-01f, 3.39261256e-02f, 5.26566446e-01f, 1.55435622e-01f, -6.69134021e-01f, 2.07491815e-01f, -4.50842708e-01f, -1.35996640e-01f, -2.96568871e-01f, -5.21400571e-01f,
  -1.92069873e-01f, 3.15382332e-02f, 4.24588114e-01f, 4.35584605e-01f, -1.06443726e-01f, -1.04280666e-01f, -3.30728471e-01f, -5.12344530e-03f, 1.95529088e-01f, -1.01450667e-01f,
  1.45581231e-01f, 1.25030831e-01f, 8.61046314e-02f, -1.75692126e-01f, -2.50276983e-01f, -5.16953208e-02f, -1.84437007e-01f, 1.22154385e-01f, 9.98325050e-02f, -2.82800972e-01f,
  -3.76406968e-01f, 3.22913751e-02f, 2.07440704e-02f, -2.60339171e-01f, -1.28652558e-01f, 4.15994674e-01f, -3.37417632e-01f, -1.26800323e-02f, 5.49065182e-03f, -7.93990314e-01f,
  -3.98482494e-02f, -8.09951797e-02f, 1.83906779e-02f, -2.00241320e-02f, 3.83383944e-03f, 1.27435504e-02f, -1.55973330e-01f, -1.46379367e-01f, 3.98339145e-03f, -1.21859401e-01f,
  4.86882403e-02f, 3.97672094e-02f, 2.11134449e-01f, -5.94164394e-02f, 3.87206972e-02f, -4.39549573e-02f, -3.23567688e-02f, -1.30409792e-01f, -5.27668931e-02f, 6.63377568e-02f,
  2.17276394e-01f, 9.43864733e-02f, -6.82948679e-02f, 1.39162943e-01f, -6.02184646e-02f, -3.13626900e-02f, -1.04459405e-01f, -3.48646976e-02f, -1.54117271e-01f, -1.46761939e-01f,
  -1.71619415e-01f, 6.21312022e-01f, -1.72964394e-01f, 1.97955415e-01f, -7.34717026e-02f, 1.49335135e-02f, 6.01230329e-03f, -6.53757825e-02f, 2.54952192e-01f, 3.24757099e-02f,
  3.51766720e-02f, 3.20187658e-02f, -2.99249679e-01f, -6.10673055e-03f, -6.55599609e-02f, -1.24062495e-02f, -3.33305031e-01f, 7.48917535e-02f, 1.24508627e-01f, -9.19682905e-02f,
  -1.70261651e-01f, -2.36130133e-01f, -1.25645220e-01f, -8.11586455e-02f, -1.30027324e-01f, 1.43455327e-01f, -3.01922828e-01f, -2.00793982e-01f, 4.50852662e-02f, -8.81905258e-01f,
  4.17030811e-01f, -2.19074383e-01f, 1.10963151e-01f, -4.93305922e-02f, -2.61785865e-01f, -2.13419870e-01f, -3.64562333e-01f, -1.83187291e-01f, -8.20232704e-02f, 7.50807300e-02f,
  3.00657481e-01f, 4.94205236e-01f, 3.36895019e-01f, 3.58986109e-01f, 2.32178718e-01f, -1.56720221e-01f, -1.97197825e-01f, 2.83998430e-01f, 1.98919192e-01f, 4.02524173e-02f,
  -1.47251651e-01f, -2.49471664e-01f, 1.54737055e-01f, 3.69188562e-02f, 3.94463446e-03f, 1.08976424e-01f, 1.23021120e-04f, -1.04530357e-01f, -1.48315236e-01f, -1.80948675e-01f,
  2.04290077e-01f, 1.85195267e-01f, 2.70526767e-01f, 6.99960161e-03f, 6.93379641e-02f, 8.58262852e-02f, 9.37716439e-02f, -6.81449547e-02f, -8.97751674e-02f, -2.41900161e-01f,
  -1.52366478e-02f, 2.21709795e-02f, 3.59079279e-02f, -1.77202607e-03f, -1.38018712e-01f, 1.07592367e-01f, 7.55713731e-02f, 5.58132306e-02f, 2.60846689e-02f, 6.15381263e-02f,
  9.47263017e-02f, 8.09815750e-02f, 3.68722603e-02f, 3.62235308e-02f, 2.78361011e-02f, 1.29583359e-01f, 1.70825958e-01f, 1.12316020e-01f, 1.59986317e-01f, 1.56614229e-01f,
  -9.45388004e-02f, -7.95716047e-02f, 1.31335482e-01f, 1.90008581e-01f, 1.36492774e-01f, -2.37808321e-02f, -1.83285996e-01f, -2.25848243e-01f, 8.97082463e-02f, -8.49478245e-02f,
  -3.29396315e-02f, 9.33530480e-02f, 4.65961322e-02f, -9.25451145e-02f, 2.14236617e-01f, -6.07733801e-02f, -5.43506891e-02f, 8.54259953e-02f, 1.44088104e-01f, -3.05013563e-02f,
  4.42587249e-02f, -1.60982937e-01f, -1.90393671e-01f, -7.27583319e-02f, -8.18909928e-02f, 3.31223682e-02f, -4.15660553e-02f, 4.48533185e-02f, -6.69970959e-02f, -3.24480236e-01f,
  -3.88872065e-02f, 6.91879451e-01f, 9.72324759e-02f, -5.03155030e-02f, -9.74401757e-02f, -5.89239504e-03f, 2.12346524e-01f, -1.73977353e-02f, -3.12852859e-01f, -9.38923582e-02f,
  -5.48202060e-02f, 1.46880709e-02f, 7.12315589e-02f, -4.97542415e-03f, 4.05648835e-02f, 1.16902873e-01f, 7.59124160e-02f, 7.04365969e-02f, -1.33319974e-01f, -2.98445038e-02f,
  -9.90414247e-02f, 1.21188741e-02f, 5.30822352e-02f, 1.84028491e-01f, 1.10989630e-01f, 1.72732055e-01f, 1.32717818e-01f, 4.28610705e-02f, 9.18676257e-02f, -1.96631346e-03f,
  5.56520402e-01f, 6.77897334e-01f, 3.04372966e-01f, 8.10413714e-03f, 1.65796146e-01f, 3.34811836e-01f, 7.38106489e-01f, 4.39416677e-01f, -2.23831031e-02f, 1.75819099e-01f,
  -8.13832507e-02f, -4.83229131e-01f, -3.33386451e-01f, -3.33150238e-01f, -1.70367602e-02f, 1.27798840e-01f, 1.30286872e-01f, -1.44234730e-03f, -4.89371158e-02f, 1.19429296e-02f,
  3.03292032e-02f, 2.72099525e-01f, 3.13484281e-01f, 3.65286320e-02f, -7.10002705e-03f, -4.30625439e-01f, -3.87605354e-02f, 6.39932826e-02f, -5.28403632e-02f, -1.95231423e-01f,
  -3.60363483e-01f, 1.15461759e-01f, -2.82783508e-01f, -2.04861946e-02f, 7.57182240e-02f, 1.64443210e-01f, -2.37543397e-02f, 1.03397600e-01f, 1.65198699e-01f, 1.99486867e-01f,
  1.34119987e-01f, -3.50865647e-02f, -3.95664684e-02f, -4.90468368e-02f, 2.45905951e-01f, 1.20898947e-01f, 9.89720002e-02f, 1.48404881e-01f, 3.61348242e-02f, -5.73996827e-02f,
  3.56723997e-03f, -8.40258598e-03f, 3.09221536e-01f, -2.63101365e-02f, -7.51674324e-02f, -1.07431039e-01f, -7.35546798e-02f, -7.33140334e-02f, -7.45337307e-02f, -5.95762059e-02f,
  2.79016465e-01f, 2.67426789e-01f, -1.16188340e-01f, -2.04308614e-01f, -9.24170464e-02f, 1.20633289e-01f, 4.21601944e-02f, 1.63616657e-01f, -6.03201091e-02f, 6.10223077e-02f,
  -5.29170595e-02f, -1.40384674e-01f, 3.49714532e-02f, -1.90310355e-03f, -1.65394351e-01f, 4.55099903e-02f, 1.22674055e-01f, 3.51701938e-02f, -1.59655839e-01f, -6.72653690e-02f,
  -5.00063710e-02f, 2.03794554e-01f, 7.54539296e-02f, 1.60078198e-01f, 5.72666265e-02f, -3.10859084e-02f, -2.66786572e-02f, -5.18511161e-02f, 6.10043146e-02f, 1.72230288e-01f,
  9.22680423e-02f, -4.52798009e-01f, -2.25851789e-01f, -9.42654386e-02f, -3.28620374e-02f, 1.57784149e-01f, -3.15532297e-01f, -1.15063287e-01f, 1.37614116e-01f, 1.27592221e-01f,
  1.30886346e-01f, 1.07614212e-01f, 1.21276282e-01f, -2.66755503e-02f, -4.70270775e-02f, -4.21334766e-02f, 2.19544582e-02f, 6.75737187e-02f, 4.32728231e-02f, 5.58886006e-02f,
  3.04103553e-01f, 1.14682510e-01f, 1.72536999e-01f, -1.20905871e-02f, -1.98878005e-01f, -9.16544124e-02f, 5.50836921e-02f, 9.60457698e-02f, 2.22946201e-02f, 2.01606065e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  7.42850125e-01f, 3.71393025e-01f, 2.95468271e-01f, 6.08515263e-01f, 9.02901173e-01f, 4.82315272e-01f, 5.61258078e-01f, 7.58104384e-01f, 3.92045408e-01f, 7.41003573e-01f,
  7.08031774e-01f, 6.55473828e-01f, 7.64850438e-01f, 7.86931634e-01f, 1.47115499e-01f, 3.75536412e-01f, 8.01284552e-01f, 6.40301526e-01f, 4.94067729e-01f, 6.61866367e-01f,
  8.02696407e-01f, 6.66341782e-01f, 8.39527965e-01f, 6.49814606e-01f, 4.12348449e-01f, 5.03207564e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -2.77985066e-01f, -7.87495896e-02f, -1.08928554e-01f, 5.57605438e-02f, -1.55363092e-02f, 5.89305302e-03f, -1.06599605e+00f, -4.62517768e-01f, 3.75485539e-01f, -2.75637984e-01f,
  -7.45971203e-01f, -1.05226552e+00f, -9.36636701e-02f, -3.20100456e-01f, 3.67942840e-01f, 3.06999326e-01f, -4.69518840e-01f, -5.01018763e-01f, -1.25943691e-01f, -4.78516132e-01f,
  5.60172975e-01f, 2.37455219e-01f, 5.73995948e-01f, -9.04165626e-01f, 6.19020939e-01f, -5.50876319e-01f, 3.36689383e-01f, -9.53043580e-01f, -7.19781756e-01f, 4.44076121e-01f,
  1.82202160e-01f, 1.25073120e-01f, -9.83832851e-02f, 1.27814323e-01f, -5.20335883e-02f, -2.01583356e-01f, -7.91552067e-02f, -2.72070408e-01f, -8.14548373e-01f, -3.50140147e-02f,
  -1.11152506e+00f, 7.58191049e-01f, 2.60257632e-01f, 9.55976024e-02f, 4.03253108e-01f, 3.03292334e-01f, -4.04476136e-01f, -3.55317235e-01f, -8.65816176e-01f, 3.26460779e-01f,
  -9.54220176e-01f, -6.22316003e-01f, 6.98944271e-01f, 6.48411140e-02f, 1.51102766e-01f, -1.34946728e+00f, -3.81073862e-01f, 3.93277168e-01f, -8.98816824e-01f, -9.14227724e-01f,
  -6.77748919e-01f, 1.25316989e+00f, 2.19632626e-01f, -3.23062539e-01f, 8.24423954e-02f, 9.61251482e-02f, 8.28839764e-02f, -3.07500750e-01f, -1.42582372e-01f, -4.26969558e-01f,
  7.44419634e-01f, -6.58489525e-01f, 1.36196643e-01f, -8.99168611e-01f, -1.50362417e-01f, -7.13004529e-01f, -6.05251789e-01f, -1.01608619e-01f, -1.43669248e-01f, -3.23639125e-01f,
  -4.77670342e-01f, -7.34168105e-03f, -1.63598254e-01f, -5.40041864e-01f, -4.98415977e-01f, -4.12010163e-01f, -3.50393981e-01f, -8.81757379e-01f, -7.45850801e-02f, 1.16389342e-01f,
  9.81824756e-01f, 2.59188563e-01f, 3.16592425e-01f, 9.05316293e-01f, 3.00716043e-01f, -7.04163089e-02f, -2.75300622e-01f, -1.00214906e-01f, -7.18801320e-02f, 2.50375181e-01f,
  2.00090539e-02f, -2.01224700e-01f, 3.19698155e-01f, -5.15742481e-01f, -8.57168585e-02f, -3.27898145e-01f, -8.34595084e-01f, -5.96765697e-01f, 3.89035434e-01f, 5.32672226e-01f,
  2.75300711e-01f, 7.02856898e-01f, 6.42497659e-01f, -1.33052599e+00f, 5.41247964e-01f, 3.01829755e-01f, -1.05102921e+00f, 2.44354278e-01f, -9.72524285e-01f, -3.06876034e-01f,
  -2.82432109e-01f, -9.84976068e-02f, 5.32394409e-01f, -2.46866092e-01f, -4.77614760e-01f, -4.91468102e-01f, -4.89286095e-01f, -5.94418466e-01f, -1.42061070e-01f, -3.25909346e-01f,
  -1.65071368e-01f, 1.49792776e-01f, 1.43498331e-01f, -1.77235201e-01f, 3.37014824e-01f, -1.13967288e+00f, 2.94271946e-01f, -3.53662103e-01f, -4.34277207e-01f, 2.43189856e-01f,
  -9.66222465e-01f, -6.02670789e-01f, 3.26239675e-01f, -6.12948179e-01f, 6.02147222e-01f, 5.20303667e-01f, 4.87213045e-01f, 1.98269755e-01f, 2.88762734e-03f, 2.86460191e-01f,
  -1.14898324e-01f, 7.03945160e-01f, -3.65140140e-01f, -3.85559320e-01f, -6.00319386e-01f, 4.23359722e-01f, -5.61946809e-01f, -1.98861472e-02f, 5.18468879e-02f, -2.13301182e-02f,
  1.26720846e-01f, 2.92314775e-02f, 1.74801543e-01f, -2.23174796e-01f, 5.18037379e-03f, -1.79125637e-01f, -3.21995676e-01f, 5.03092647e-01f, -4.11491275e-01f, -5.57849944e-01f,
  5.76514065e-01f, 4.22841981e-02f, 5.39869845e-01f, -3.77607286e-01f, 3.85347873e-01f, -3.58665496e-01f, -7.48857856e-01f, 3.65387201e-01f, -6.77190006e-01f, 1.24609441e-01f,
  -4.08121675e-01f, 2.67681092e-01f, 8.91974092e-01f, 9.97132003e-01f, 7.86882818e-01f, -3.81252587e-01f, -1.19295847e+00f, -1.25270391e+00f, -9.97457802e-02f, -1.02268338e+00f,
  -2.54009277e-01f, 3.14452916e-01f, -1.19537920e-01f, 6.18570782e-02f, 2.87091106e-01f, -1.26479551e-01f, -3.24943304e-01f, 2.06348732e-01f, 6.11755013e-01f, 1.94278225e-01f,
  -7.02258110e-01f, 2.66184360e-01f, 5.91356754e-01f, -5.21341383e-01f, -2.76415467e-01f, -5.08475840e-01f, -8.46750379e-01f, -7.67647326e-01f, -5.67032278e-01f, -2.92561620e-01f,
  -3.10785621e-01f, -1.21016192e+00f, -5.81802249e-01f, -9.52285111e-01f, 1.04449713e+00f, -3.30068022e-01f, -8.62907052e-01f, -9.27978933e-01f, -6.52186811e-01f, 6.53144836e-01f,
  8.76665413e-01f, -5.52913010e-01f, 2.51554009e-02f, 1.15679525e-01f, -2.02757016e-01f, -2.17134312e-01f, -2.72785544e-01f, 2.15063155e-01f, -1.46384716e-01f, 2.57183090e-02f,
  4.17803168e-01f, 3.34455162e-01f, -3.20443243e-01f, -2.17566505e-01f, -6.22732103e-01f, 5.58415473e-01f, -5.74316561e-01f, -7.37649977e-01f, -4.86032009e-01f, 5.75158745e-02f,
  3.97532642e-01f, -3.89044523e-01f, 4.69938010e-01f, 1.96162537e-01f, -9.13109556e-02f, -6.05826676e-01f, -6.85515225e-01f, 4.60070759e-01f, 4.68766280e-02f, -4.89483714e-01f,
  8.65841568e-01f, -5.68423569e-01f, -1.00630951e+00f, -7.28238344e-01f, -7.07787797e-02f, -2.75753677e-01f, 1.06120832e-01f, -8.55880752e-02f, -7.38507137e-02f, -2.58568108e-01f,
  -4.27443564e-01f, 4.02761519e-01f, -5.58889031e-01f, -1.92426786e-01f, -1.53664604e-01f, -7.37446070e-01f, 1.92366555e-01f, 8.96118730e-02f, -7.11037457e-01f, 2.97062188e-01f,
  -1.41757667e-01f, 1.16519272e+00f, -6.36251271e-01f, 5.07015049e-01f, -2.00983629e-01f, -3.52214068e-01f, -6.71973467e-01f, -9.45121825e-01f, -5.60066700e-01f, -4.34753001e-01f,
  -1.22377977e-01f, 6.12015426e-01f, -4.34073396e-02f, -3.79965663e-01f, 6.72225058e-01f, -7.74419963e-01f, -4.07554656e-01f, 1.53905958e-01f, 1.41413640e-02f, 9.05171186e-02f,
  2.74160087e-01f, -2.08795860e-01f, -3.10336165e-02f, 3.37703638e-02f, -3.30905914e-01f, 4.52057332e-01f, 9.61373091e-01f, 2.75901884e-01f, -7.28135169e-01f, -3.78746778e-01f,
  -6.74961269e-01f, -6.96724057e-01f, 1.25198975e-01f, -5.35927057e-01f, -7.80065507e-02f, -4.29308563e-01f, -7.92526245e-01f, -1.04882932e+00f, 3.46719950e-01f, -3.05611044e-01f,
  -1.15515637e+00f, 7.25431085e-01f, 5.85044026e-01f, 1.17795736e-01f, -7.25834846e-01f, 8.84128511e-01f, -6.74018621e-01f, -4.98854034e-02f, 4.44428802e-01f, -9.19330299e-01f,
  7.49041960e-02f, -9.64311436e-02f, 8.97785127e-02f, -2.37920880e-01f, 3.67643565e-01f, -2.87350476e-01f, -1.58046186e-01f, -1.38958275e-01f, -2.16954887e-01f, -1.85967088e-01f,
  -4.24237132e-01f, 2.35953137e-01f, 8.26229393e-01f, 7.49386489e-01f, -8.21279347e-01f, -1.65198684e-01f, 1.14584498e-01f, 4.10629034e-01f, 7.92388558e-01f, -3.62919480e-01f,
  -3.19690481e-02f, -9.53156292e-01f, -6.20720804e-01f, 1.62573844e-01f, -6.78805053e-01f, -5.49834192e-01f, -5.61710775e-01f, -1.10647589e-01f, -5.39610863e-01f, -6.71193182e-01f,
  -2.42133625e-02f, -9.85957384e-01f, -4.37170714e-02f, 3.59371722e-01f, -1.24267884e-01f, 3.38419735e-01f, 3.93264055e-01f, 2.95587331e-01f, -5.15754938e-01f, -3.89865339e-01f,
  -6.52412534e-01f, 3.56616944e-01f, -4.68448222e-01f, -6.60132349e-01f, -4.09981012e-02f, 2.60522515e-01f, -3.99081737e-01f, -4.21235263e-01f, 9.56137180e-01f, -3.31216335e-01f,
  -2.27161527e-01f, 1.13647544e+00f, -1.98603585e-01f, -2.97398806e-01f, -7.33635724e-01f, -2.17743695e-01f, -3.06213140e-01f, -6.53161481e-02f, -5.29398263e-01f, 9.57175344e-03f,
  4.88524228e-01f, -3.00678223e-01f, -4.71295387e-01f, 7.82437861e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -4.41770226e-01f, 1.40672341e-01f, 3.05280983e-01f, -2.55627692e-01f, -3.60595882e-01f, -4.67176773e-02f, 1.60169676e-01f, -1.44375578e-01f, 1.89728901e-01f, 4.94522631e-01f,
  1.59913808e-01f, 1.75256252e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    