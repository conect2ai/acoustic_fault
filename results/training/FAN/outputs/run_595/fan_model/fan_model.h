/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  8.11091006e-01f, -5.89537174e-02f, 1.41015813e-01f, 8.27738866e-02f, -1.19648516e-01f, 6.48190975e-02f, 1.05764464e-01f, 5.20689338e-02f, -6.42195567e-02f, -1.11932509e-01f,
  4.16351408e-02f, -2.64599882e-02f, -9.96473804e-03f, -8.05359781e-02f, 8.78106654e-02f, -1.56248257e-01f, -3.49136770e-01f, 1.65845558e-01f, 2.71102190e-01f, 2.32602775e-01f,
  -2.23837495e-01f, -1.46442145e-01f, 1.64645478e-01f, 5.11992648e-02f, -1.39842346e-01f, -2.09318906e-01f, -2.75238514e-01f, -1.39131816e-02f, -3.74821536e-02f, -7.44633675e-02f,
  1.83237717e-01f, 1.92700684e-01f, -5.20447828e-02f, -2.74368338e-02f, -9.76384580e-02f, 9.63812042e-03f, 2.52454635e-02f, -1.14557985e-02f, -4.28417400e-02f, 7.90313073e-03f,
  -5.39313816e-03f, 1.57644618e-02f, 7.95180351e-03f, -9.41681638e-02f, -6.57068891e-03f, -5.50726205e-02f, -4.77911420e-02f, 8.21897537e-02f, 3.90689932e-02f, 1.01587266e-01f,
  -1.05514236e-01f, 6.25552312e-02f, 1.85481936e-01f, -5.06989770e-02f, 7.24402517e-02f, -1.70852859e-02f, -6.38567358e-02f, 3.94583158e-02f, 6.46469444e-02f, -6.00432046e-02f,
  2.68416740e-02f, 4.57881205e-02f, 3.47165857e-03f, -3.02580800e-02f, 2.40851827e-02f, 5.23937233e-02f, 1.15384618e-02f, 6.13396708e-03f, -5.42383350e-04f, 7.32850879e-02f,
  -3.64192389e-02f, 3.71282138e-02f, 5.08591672e-03f, 3.51262577e-02f, -2.03178078e-02f, 7.20003694e-02f, 1.00419767e-01f, -2.42718067e-02f, 7.35090114e-03f, -1.14604300e-02f,
  8.03307071e-02f, 2.00126730e-02f, 8.94506928e-03f, 5.22699691e-02f, 2.48187911e-02f, 6.73459992e-02f, 7.04065934e-02f, 8.00992548e-02f, 1.89694259e-02f, 2.07594577e-02f,
  -1.74395025e-01f, -8.76304135e-02f, 4.29650322e-02f, 1.56891090e-03f, 3.46345119e-02f, -4.53295112e-02f, -4.10156585e-02f, -1.02258502e-02f, -6.56211842e-03f, 1.98044013e-02f,
  4.40764725e-02f, 3.23925801e-02f, -8.19748417e-02f, -5.68421464e-03f, -2.48273294e-02f, 4.93466817e-02f, -8.55808631e-02f, 3.27152796e-02f, -7.73242721e-03f, -8.11646730e-02f,
  -4.55510728e-02f, 4.27520685e-02f, 3.31576094e-02f, 3.35112549e-02f, -2.35635714e-04f, 1.93115957e-02f, -5.34024872e-02f, 4.23243828e-02f, 8.46241117e-02f, -7.10005537e-02f,
  -9.65579301e-02f, 3.19747776e-01f, 1.46061614e-01f, -2.63587058e-01f, -2.32568711e-01f, -4.87167202e-02f, -1.22921134e-04f, 6.70282468e-02f, 1.73939094e-02f, -3.02254502e-02f,
  2.28074178e-01f, 1.22139573e-01f, 1.85870036e-01f, 1.05607420e-01f, -1.30751524e-02f, -9.32748020e-02f, -1.08053192e-01f, -1.83352724e-01f, -1.32948071e-01f, -3.00775141e-01f,
  -1.48463950e-01f, -2.45534852e-02f, 4.52879025e-03f, -7.66356736e-02f, -2.13310584e-01f, -2.55580604e-01f, 7.21185505e-02f, -1.73304066e-01f, -6.69638067e-02f, -4.42406088e-01f,
  1.61518499e-01f, 1.95872843e-01f, -1.66155756e-01f, -6.92668483e-02f, -4.09994237e-02f, -3.48628424e-02f, 4.07145545e-02f, -1.49995722e-02f, -1.07418984e-01f, 8.11129138e-02f,
  -1.37332842e-01f, -9.35701802e-02f, -8.24673474e-02f, 1.79225970e-02f, -2.93862112e-02f, -5.32124366e-04f, 3.54826935e-02f, -4.60363589e-02f, 1.05395420e-02f, 2.39566118e-02f,
  -6.39166012e-02f, -1.12524591e-01f, -1.63885832e-01f, 6.56729266e-02f, -3.45640816e-02f, -1.82052687e-01f, -7.04391208e-03f, -1.55558705e-01f, -1.30363956e-01f, -2.59244025e-01f,
  -1.31074756e-01f, -6.68306798e-02f, 1.66973844e-02f, 7.52196014e-02f, 6.55115023e-02f, -1.27755338e-03f, 3.02285869e-02f, 9.51698050e-02f, -6.67521879e-02f, 5.25699602e-03f,
  6.35032058e-02f, 8.25081542e-02f, 4.57609259e-02f, -4.35099974e-02f, -2.70661432e-02f, 1.38363848e-02f, -1.00862077e-02f, 1.33647278e-01f, 1.15594357e-01f, 1.40548497e-01f,
  5.56824096e-02f, -1.03421919e-01f, -7.18162879e-02f, 6.86096922e-02f, 2.50880625e-02f, 1.17732659e-01f, -5.47915883e-02f, 1.16319165e-01f, 7.42582930e-03f, 8.97988901e-02f,
  1.37489334e-01f, 7.43662193e-02f, -1.79743066e-01f, 2.87217926e-02f, -3.03495172e-02f, -1.04992956e-01f, 2.48784289e-01f, 2.76666451e-02f, 8.21814016e-02f, 1.50115443e-02f,
  2.72126812e-02f, -1.80751532e-02f, 7.72677138e-02f, -4.30882089e-02f, -8.98560584e-02f, -9.34726372e-02f, -1.13112196e-01f, -2.59407219e-02f, -1.55086201e-02f, 1.03715137e-02f,
  -5.76450601e-02f, -8.59871283e-02f, -1.46662265e-01f, 4.36329246e-02f, -1.15543686e-01f, -1.14868410e-01f, -4.58120741e-02f, -1.66812256e-01f, -1.72579333e-01f, -1.99550778e-01f,
  -3.63029301e-01f, 3.78592610e-01f, 8.92721266e-02f, 1.62759777e-02f, 1.52037367e-01f, 2.05133423e-01f, 3.13602537e-01f, 1.36855528e-01f, 1.22664332e-01f, 1.31531864e-01f,
  -1.46351025e-01f, -3.21230531e-01f, -2.25446269e-01f, -1.22899227e-01f, -2.00736463e-01f, 3.51620942e-01f, 2.89924175e-01f, -2.67684400e-01f, -2.93813914e-01f, 1.69018917e-02f,
  1.43919483e-01f, -3.71077470e-02f, -2.88668483e-01f, -8.52143243e-02f, 3.01847458e-01f, 6.90920278e-02f, 2.85899192e-01f, 1.06601417e-01f, 6.41025454e-02f, 2.51006126e-01f,
  -2.88901143e-02f, 7.07500726e-02f, -4.84299958e-02f, 1.60843655e-02f, 7.90772662e-02f, 1.13594629e-01f, 8.09592754e-02f, 7.95380846e-02f, 6.23038672e-02f, 6.18055575e-02f,
  1.99787039e-02f, -1.03205834e-02f, 1.09042050e-02f, 1.00277051e-01f, 4.29405086e-02f, 9.65931192e-02f, 1.12582251e-01f, -2.41821744e-02f, 1.05393998e-01f, 1.07361093e-01f,
  1.71102852e-01f, -5.97820394e-02f, 8.23498219e-02f, 2.03665361e-01f, 7.12035000e-02f, -8.24069530e-02f, 1.21790424e-01f, 6.91979378e-02f, -2.60552447e-02f, 2.61361748e-01f,
  -3.15149650e-02f, -6.60555884e-02f, -6.94166198e-02f, -6.34011179e-02f, -6.06541783e-02f, -9.90615785e-03f, -8.96341652e-02f, -1.58195905e-02f, -3.45348753e-02f, -5.37028462e-02f,
  -1.86102502e-02f, 4.39515896e-02f, -2.68425830e-02f, 2.74724700e-02f, -2.92468071e-02f, -2.28141304e-02f, -3.18337306e-02f, -2.93454900e-02f, -7.07715899e-02f, -7.89338723e-02f,
  -1.05702065e-01f, -1.91013459e-02f, -3.42391618e-02f, -3.97025468e-03f, -1.21433754e-02f, -4.64750081e-03f, -2.85000689e-02f, -4.38612662e-02f, -1.43237878e-02f, -1.60346981e-02f,
  3.44432704e-02f, -5.26810586e-02f, 2.12962534e-02f, 2.24366542e-02f, 1.06272921e-01f, 8.11408535e-02f, 5.49214259e-02f, 7.89277777e-02f, -8.05213861e-03f, 1.85267925e-02f,
  -2.87519917e-02f, 5.70026711e-02f, 8.58004168e-02f, 5.10637686e-02f, 2.87486594e-02f, 6.12081140e-02f, 1.53044164e-01f, 3.49394940e-02f, 6.19552545e-02f, 1.71597973e-01f,
  1.29209533e-01f, 1.34699881e-01f, 7.07614049e-02f, 8.48967582e-02f, 5.33409901e-02f, 1.73187107e-02f, 1.64015591e-01f, 1.20876946e-01f, 6.17476925e-02f, 2.98320144e-01f,
  3.66083682e-02f, 1.46847025e-01f, -5.95713615e-01f, 1.55777708e-01f, -3.53205502e-02f, 1.23015158e-02f, 2.49940291e-01f, 1.81090251e-01f, -1.93623211e-02f, 8.04772824e-02f,
  -2.07335711e-01f, -1.17376573e-01f, -1.50581360e-01f, -1.67379662e-01f, 1.36859706e-02f, 1.56500697e-01f, 1.17528103e-01f, 6.08137548e-02f, -7.39747807e-02f, 1.40379325e-01f,
  2.13013977e-01f, 1.15164489e-01f, 2.41680369e-02f, -1.22516667e-02f, 5.53623922e-02f, 1.13667615e-01f, -2.93719441e-01f, -6.79413080e-02f, -7.80917630e-02f, 1.57072380e-01f,
  -3.19171488e-01f, -8.75058845e-02f, -3.60641927e-02f, 1.47070408e-01f, -2.73630172e-01f, -1.08944990e-01f, -5.16407304e-02f, -7.97609389e-02f, -1.81522034e-02f, 2.13574693e-02f,
  -1.52130529e-01f, -6.39008954e-02f, -1.09096244e-02f, -2.46723322e-03f, -7.21996278e-02f, -4.11312915e-02f, 2.27908213e-02f, -2.18448341e-02f, -1.03494681e-01f, -1.66310091e-02f,
  9.04874504e-02f, -9.45780501e-02f, -1.88857570e-01f, -1.12577349e-01f, -1.47428811e-01f, -1.18748374e-01f, -6.02336340e-02f, 8.09987932e-02f, -1.58636600e-01f, 3.05434644e-01f,
  7.70989060e-02f, -7.04498868e-03f, 1.53317992e-02f, 1.16378993e-01f, 1.59685820e-01f, -1.35905286e-02f, -1.56079810e-02f, 4.58752029e-02f, 5.16377501e-02f, 8.37506652e-02f,
  3.08008995e-02f, 1.96992303e-03f, 2.79242080e-02f, 3.14387530e-02f, 4.87426519e-02f, 1.52656585e-02f, 5.26311845e-02f, 9.99568105e-02f, 3.34877819e-02f, 1.47912815e-01f,
  8.82954597e-02f, -6.93062246e-02f, 1.31832482e-02f, 2.14614235e-02f, 4.40828204e-02f, 3.69019210e-02f, -1.35268504e-03f, 1.20157085e-01f, 3.38164717e-02f, 4.90133017e-02f,
  6.18268065e-02f, -2.38480538e-01f, 4.76981164e-04f, 2.77407989e-02f, 5.77814877e-04f, -5.49212545e-02f, -4.74130549e-02f, -6.39154315e-02f, -1.00792415e-01f, -1.46920718e-02f,
  -5.37734367e-02f, -4.27601449e-02f, -9.57303122e-02f, 9.15411487e-03f, 2.07796115e-02f, -2.50193011e-02f, 5.01957349e-02f, 2.91463751e-02f, -3.53687108e-02f, -7.01225251e-02f,
  4.29521762e-02f, 9.80935171e-02f, 3.89953740e-02f, 2.91268360e-02f, -4.70215455e-02f, -1.63499918e-02f, 2.45540701e-02f, -2.59888005e-02f, -7.34364390e-02f, 2.23493278e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -9.79751825e-01f, 2.22781524e-01f, -2.44845301e-01f, 1.43913627e-01f, 4.95265573e-01f, -5.54172158e-01f, -9.27835464e-01f, -7.25810051e-01f, 5.12768701e-02f, -3.61826010e-02f,
  2.91335404e-01f, 4.70637649e-01f, 5.19940197e-01f, 3.32707226e-01f, -4.76031125e-01f, 2.71746051e-02f, 4.04314190e-01f, -1.90575808e-01f, -5.35419464e-01f, -3.97569209e-01f,
  3.62166911e-01f, 2.08019093e-02f, -4.27069247e-01f, -2.80356973e-01f, 5.86939812e-01f, 9.39632393e-03f, 2.04089910e-01f, 3.83395821e-01f, 2.47248635e-01f, 9.18146014e-01f,
  -3.19256857e-02f, -1.84381470e-01f, -9.41711217e-02f, 2.21768826e-01f, 2.30190918e-01f, -2.20127597e-01f, -3.05345684e-01f, -4.53058710e-05f, 1.39065012e-02f, -5.92583008e-02f,
  3.21358681e-01f, -3.10466578e-03f, 2.28018552e-01f, 2.33275041e-01f, -1.44046217e-01f, -3.37150604e-01f, -1.04013674e-01f, -3.60967606e-01f, -2.58409381e-01f, -2.04461291e-01f,
  5.89765072e-01f, 1.23567566e-01f, -2.05268890e-01f, -1.48658380e-01f, -3.76689583e-01f, 1.15050398e-01f, -1.25025928e-01f, -2.11314023e-01f, -5.01299441e-01f, -5.35986066e-01f,
  -1.00504279e-01f, -6.52541891e-02f, 8.08140934e-02f, 1.20226495e-01f, -4.92721386e-02f, 5.49139641e-02f, 1.56143889e-01f, 1.02055054e-02f, -9.08237940e-04f, -4.14689118e-03f,
  3.23018478e-03f, 7.37024173e-02f, -5.93207143e-02f, -2.27856919e-01f, 2.24742964e-02f, -4.45895903e-02f, 6.09463640e-02f, 2.96178162e-02f, -5.28832711e-03f, -8.43154266e-02f,
  8.43506679e-02f, -7.44340569e-02f, 1.49862871e-01f, 2.20316947e-02f, -4.31268252e-02f, 4.92371395e-02f, 3.39528769e-02f, -2.63563134e-02f, -9.33840573e-02f, -4.69286069e-02f,
  3.91536690e-02f, 9.22369882e-02f, 1.10784411e-01f, -5.36909327e-02f, -8.08868259e-02f, 2.01423183e-01f, 1.20471895e-01f, -2.13191062e-02f, 5.54072782e-02f, -2.53252476e-01f,
  -2.46832862e-01f, -5.67794070e-02f, 1.33003682e-01f, -4.71437238e-02f, -3.66743892e-01f, 8.94779339e-02f, 2.37014592e-01f, 1.74329579e-01f, -8.74618441e-02f, 1.52886063e-01f,
  -1.11315347e-01f, -5.14867961e-01f, -4.83469069e-01f, -1.68427333e-01f, -1.58639047e-02f, -3.46272081e-01f, -1.99240655e-01f, -1.87447131e-01f, -3.25856000e-01f, -7.30039120e-01f,
  -1.62263066e-01f, 4.10115361e-01f, 4.98324543e-01f, -7.03033984e-01f, 1.72403172e-01f, 3.72268677e-01f, 5.87261736e-01f, -3.58208120e-02f, -6.53190792e-01f, -1.20983489e-01f,
  3.65012139e-01f, -3.87833774e-01f, -5.55830181e-01f, -4.26093079e-02f, 3.90241086e-01f, -1.55225312e-02f, -6.14508502e-02f, 1.39404416e-01f, 1.18875667e-01f, 2.34634981e-01f,
  -2.41584063e-01f, 9.71808955e-02f, 3.23284686e-01f, 4.27170806e-02f, -6.26803637e-01f, -3.67891669e-01f, -1.30082250e-01f, 2.47357249e-01f, 3.40380639e-01f, -4.97798890e-01f,
  -6.21709041e-02f, 2.21315458e-01f, -2.11423039e-01f, -8.66694748e-02f, 1.83177054e-01f, -2.17537627e-01f, -2.07479849e-01f, -4.29824553e-02f, 1.04582049e-01f, -8.48680735e-02f,
  -9.37099103e-03f, 1.32122055e-01f, -1.37228556e-02f, 8.01375806e-02f, 3.47905327e-03f, -7.99447298e-02f, 1.92768991e-01f, 1.32514969e-01f, -4.34384979e-02f, 2.49279253e-02f,
  -1.28824294e-01f, 1.92187190e-01f, 3.36716503e-01f, 5.53789735e-02f, 4.09671925e-02f, 8.34056810e-02f, 3.95799041e-01f, 9.70620066e-02f, 3.40415627e-01f, -2.82864809e-01f,
  -1.61912516e-01f, 2.19110642e-02f, 1.36485517e-01f, 9.78966337e-03f, -1.09825499e-01f, -1.50938600e-01f, 1.19566552e-01f, 9.68948156e-02f, 2.31025741e-02f, -4.08072490e-03f,
  3.75851355e-02f, 3.40399798e-03f, 1.14484802e-01f, -1.22271821e-01f, -1.54694542e-01f, -2.33476870e-02f, 9.62348878e-02f, 1.39813587e-01f, -9.26484466e-02f, 4.64882590e-02f,
  5.34621589e-02f, 6.46831617e-02f, -7.81439468e-02f, 2.16420874e-01f, 6.15876690e-02f, -2.05793548e-02f, -1.53864488e-01f, 3.41403931e-02f, -2.09828362e-01f, -7.13645071e-02f,
  -4.86521363e-01f, 5.48758626e-01f, -4.90224630e-01f, 8.61537084e-02f, 8.67146701e-02f, -2.76881997e-02f, 1.28437445e-01f, 3.02481819e-02f, -4.02127095e-02f, 4.99651628e-03f,
  9.51989144e-02f, -1.11803345e-01f, 7.16808960e-02f, 2.00647637e-01f, -1.54391527e-01f, -1.90838724e-01f, 1.69446543e-01f, -1.39852211e-01f, 1.03682615e-01f, 1.50668740e-01f,
  7.88676441e-02f, -2.71022111e-01f, -4.58111972e-01f, -3.23137552e-01f, -3.18198144e-01f, -5.51712334e-01f, -2.60720849e-01f, -2.57524282e-01f, -1.00120880e-01f, -6.80315256e-01f,
  -1.70593977e+00f, -9.31586385e-01f, 1.50587214e-02f, -6.92207098e-01f, -1.51146740e-01f, -8.36263895e-02f, -6.32808864e-01f, 2.41931668e-03f, 2.14764968e-01f, -4.57576185e-01f,
  -1.43792570e-01f, 7.69713074e-02f, -1.07659765e-01f, 2.24072069e-01f, -2.05519143e-02f, -5.89378893e-01f, -2.81942695e-01f, -2.02599615e-01f, 3.73036534e-01f, 5.28071404e-01f,
  -1.72694966e-01f, -4.60544944e-01f, -7.95544982e-02f, 3.89327556e-01f, -2.89766490e-01f, -8.61918554e-02f, -3.18954110e-01f, -3.38946700e-01f, -1.01257212e-01f, -1.00067282e+00f,
  -7.08113253e-01f, -4.93580103e-02f, 3.43177378e-01f, 1.89831536e-02f, -3.59925926e-01f, 1.25744030e-01f, -1.39064640e-01f, -2.30743531e-02f, 2.31788799e-01f, 1.19547434e-02f,
  4.29377034e-02f, 1.73416063e-01f, 1.49855362e-02f, -9.52189863e-02f, -6.16262779e-02f, -6.76875412e-02f, -1.03923911e-02f, 2.86388025e-02f, 1.67056292e-01f, 1.60454363e-01f,
  6.22054525e-02f, -1.58817738e-01f, -1.25012860e-01f, 3.70924026e-01f, 3.48537356e-01f, 2.96943843e-01f, 3.28000516e-01f, 2.51533091e-01f, 3.61579269e-01f, -5.62061667e-01f,
  7.92581216e-02f, -1.38924599e-01f, -3.50435451e-02f, 7.77576789e-02f, 1.02197686e-02f, 4.84429710e-02f, -6.64691925e-02f, -1.86294496e-01f, 2.25658771e-02f, -9.86060798e-02f,
  1.26043007e-01f, -5.25103770e-02f, 5.63970767e-02f, -2.09980682e-01f, 5.24843000e-02f, -2.54162662e-02f, -1.32090956e-01f, -5.68461558e-03f, 6.17579147e-02f, -1.12931758e-01f,
  1.96100086e-01f, 7.55740851e-02f, 3.28781866e-02f, 1.15356259e-01f, 7.25919679e-02f, -8.78762007e-02f, 9.21200514e-02f, 1.63416669e-01f, -1.92420781e-01f, 1.48261920e-01f,
  -4.87469643e-01f, 3.20453256e-01f, -3.87254566e-01f, 1.54012606e-01f, -1.78984236e-02f, 8.07555690e-02f, -1.95189118e-01f, 4.69801538e-02f, -6.58988357e-02f, -1.00601137e-01f,
  1.31070703e-01f, -5.66940084e-02f, -8.77561122e-02f, 1.06258854e-01f, -2.17917096e-02f, 2.62270067e-02f, -1.15394294e-01f, -1.34288967e-01f, 2.76246905e-01f, 4.22114916e-02f,
  9.96856391e-02f, -1.11784577e-01f, -2.97988355e-01f, -3.20043147e-01f, 9.89079755e-03f, -4.98544350e-02f, -2.20885485e-01f, 5.83071308e-03f, 1.33111868e-02f, -5.14004886e-01f,
  1.10090590e+00f, 8.38171542e-02f, 1.57653823e-01f, 5.00432439e-02f, -7.83659816e-01f, -6.68345749e-01f, -6.89330935e-01f, -1.03893779e-01f, 4.51744869e-02f, -6.77906200e-02f,
  -1.93160340e-01f, 9.10300761e-02f, 1.23471804e-01f, 2.04176307e-01f, 3.28579485e-01f, -3.17163318e-02f, 1.30228892e-01f, 5.51038384e-01f, 2.80690014e-01f, -2.30772495e-01f,
  -2.21896186e-01f, 5.07161282e-02f, 5.34270406e-01f, 2.55565226e-01f, -1.09528966e-01f, 1.07805990e-01f, 1.59597248e-01f, -4.74932939e-02f, -1.74372345e-02f, 3.35691869e-01f,
  2.19974145e-01f, 1.31511122e-01f, 3.17417681e-02f, 6.85901567e-02f, -3.61796953e-02f, 1.75719574e-01f, -8.04547220e-02f, 1.15778752e-01f, -6.21161237e-02f, -1.64950788e-02f,
  -5.35702854e-02f, -3.35270390e-02f, 4.13111597e-02f, -7.12079629e-02f, -1.15179762e-01f, -6.13771565e-02f, 1.32207394e-01f, 2.20198676e-01f, 9.90366563e-02f, -9.31170583e-02f,
  -5.08519486e-02f, -2.51287758e-01f, -2.30598181e-01f, -1.49929494e-01f, 1.19525172e-01f, -1.70622822e-02f, -5.24509139e-02f, -3.03310081e-02f, 2.73075234e-02f, 2.58163422e-01f,
  7.54489973e-02f, 6.26280010e-02f, -2.48231236e-02f, 1.00640897e-02f, 3.53590474e-02f, -1.67229343e-02f, -4.81682196e-02f, -5.71922623e-02f, 7.04951584e-02f, 4.69335392e-02f,
  -7.09291697e-02f, 3.69845927e-02f, -6.56786114e-02f, -4.35741358e-02f, 3.73861529e-02f, -1.03643216e-01f, 7.24713877e-03f, 3.35236080e-02f, -4.68331948e-02f, 1.13947421e-01f,
  1.16040774e-01f, 1.82031211e-03f, 7.60110617e-02f, -1.07381389e-01f, -7.93691799e-02f, 1.04418127e-02f, -9.75987781e-03f, -5.84088489e-02f, 1.78900659e-02f, 1.15535473e-02f,
  -3.62073153e-01f, -6.37986511e-02f, 2.69346237e-01f, 1.69212490e-01f, 4.77771275e-03f, 1.25077024e-01f, -4.30081896e-02f, 1.05557876e-04f, -1.70514435e-01f, -9.27718133e-02f,
  -1.50057599e-01f, 1.25706598e-01f, 7.74138793e-02f, 9.14765149e-02f, -6.93282858e-02f, -1.36491925e-01f, 8.08256865e-02f, -8.93042386e-02f, -2.60034073e-02f, -8.95446390e-02f,
  5.23512736e-02f, -2.05205232e-01f, -1.34384304e-01f, -1.13217555e-01f, -6.30513802e-02f, -1.06998771e-01f, -1.78748015e-02f, 3.47339944e-03f, 1.23995710e-02f, -1.44451540e-02f,
  6.12077355e-01f, 1.09373972e-01f, 4.85940725e-01f, 5.28176427e-01f, 6.27163947e-01f, 7.85948634e-01f, 8.90983701e-01f, 5.59022784e-01f, 1.41673103e-01f, 2.88007259e-01f,
  -6.09031022e-02f, -1.85914725e-01f, -1.38767913e-01f, -1.22232534e-01f, 2.75910676e-01f, 4.31787491e-01f, 5.23933649e-01f, 2.79134661e-01f, 2.64545739e-01f, 2.58691788e-01f,
  -4.43744846e-02f, -1.37883229e-02f, 2.43152883e-02f, 1.34392947e-01f, 1.18105337e-02f, -8.09149593e-02f, 1.46328822e-01f, 9.94471833e-02f, -6.31813407e-02f, -3.85229513e-02f,
  -9.52669382e-02f, 4.56607461e-01f, -2.11166307e-01f, -3.17693144e-01f, -2.50232071e-01f, -3.58094275e-01f, -3.70547213e-02f, -2.76251227e-01f, -3.04076821e-01f, -2.76576668e-01f,
  -2.28405148e-01f, -2.06139594e-01f, 5.62223885e-03f, -9.20472518e-02f, -8.80284905e-02f, -2.26482451e-01f, -5.12605086e-02f, 2.23819315e-01f, 1.77059531e-01f, 7.53084421e-02f,
  -1.11562885e-01f, 8.99824724e-02f, 2.88140833e-01f, 1.59332067e-01f, 1.66465655e-01f, -6.76118433e-02f, 1.51632354e-03f, 8.60345140e-02f, 1.50298223e-01f, 8.70992243e-03f,
  1.81613907e-01f, 1.26543880e-01f, 6.33651763e-02f, 1.68630496e-01f, 7.90719464e-02f, -4.67057675e-02f, 6.91053085e-03f, 4.30404060e-02f, 1.94366932e-01f, 5.44259101e-02f,
  -6.86691478e-02f, 1.73290595e-01f, 6.02796674e-02f, 1.40161261e-01f, 3.43857445e-02f, 1.28065959e-01f, -3.49480510e-02f, 1.96823664e-03f, -5.52741857e-03f, 4.13401276e-02f,
  3.66078503e-02f, -1.07955642e-01f, -1.78956896e-01f, -9.55913588e-03f, -7.47568309e-02f, 4.07686345e-02f, -9.24194753e-02f, -1.73884988e-01f, -7.64193162e-02f, -1.49803370e-01f,
  -2.60579944e-01f, 2.26569921e-01f, -1.29505128e-01f, -6.29810840e-02f, 2.14812476e-02f, -3.34177166e-01f, -1.52497841e-02f, -2.04132468e-01f, -3.27693224e-01f, -1.05818294e-01f,
  -1.77822448e-02f, -1.76268250e-01f, 1.45077398e-02f, -7.59802312e-02f, -2.84857359e-02f, -9.51887593e-02f, -7.24033313e-03f, 2.30489969e-01f, 2.94519383e-02f, -2.15140004e-02f,
  -9.53960046e-03f, 2.21706823e-01f, 2.58603573e-01f, 1.23804055e-01f, 3.79665606e-02f, -6.35420009e-02f, -8.78270492e-02f, -4.44465317e-02f, 2.50317552e-03f, -5.02577424e-02f,
  7.95191228e-01f, 2.30886415e-01f, -1.28698730e+00f, 7.19860196e-01f, -6.55397952e-01f, -4.91745472e-01f, -3.88977021e-01f, 4.87075627e-01f, 5.95579207e-01f, 3.63047794e-02f,
  -2.36860424e-01f, -1.18226901e-01f, 4.23357524e-02f, -2.47589603e-01f, -3.40811074e-01f, -5.01912832e-01f, -7.83525944e-01f, -7.89769471e-01f, -8.01253378e-01f, -6.83731377e-01f,
  -3.82739842e-01f, 7.63600171e-02f, 1.34420088e-05f, 3.24745849e-02f, 2.75207013e-01f, -8.97244290e-02f, 6.10031793e-03f, -8.64680409e-02f, -2.88357407e-01f, -2.63914496e-01f,
  -7.38846004e-01f, 5.06096473e-03f, -1.30375221e-01f, 1.27793746e-02f, 2.42796987e-02f, 7.02226311e-02f, -2.90984493e-02f, 1.67080432e-01f, 1.46151170e-01f, 6.37623593e-02f,
  -4.51977253e-02f, 9.39939229e-04f, -2.98746992e-02f, -4.76863720e-02f, 5.02799861e-02f, -6.36344329e-02f, 1.46096230e-01f, -2.50470266e-02f, 3.21490839e-02f, -3.43402587e-02f,
  -1.00233153e-01f, -4.29000139e-01f, -2.80566156e-01f, 3.95321250e-02f, 5.03789745e-02f, -1.23670802e-01f, 8.25228617e-02f, 1.72686175e-01f, 4.83606150e-03f, 4.13431674e-01f,
  3.87749374e-02f, 1.12559967e-01f, -4.81596105e-02f, 6.90627024e-02f, 1.05080806e-01f, -3.77764180e-02f, 5.38985152e-03f, -2.74072904e-02f, -5.01547195e-03f, 7.75759900e-03f,
  1.05426610e-01f, -2.91798543e-02f, 5.26524968e-02f, -1.06095737e-02f, -1.48142070e-01f, -7.05115348e-02f, -5.99866696e-02f, 7.87795801e-03f, -2.22800951e-02f, 1.27321482e-01f,
  -5.91095984e-02f, -7.30483159e-02f, 1.38217866e-01f, 1.03453621e-01f, -2.08021775e-01f, -5.89599274e-03f, -1.69537842e-01f, 2.11304594e-02f, 5.75149842e-02f, -2.01083571e-02f,
  5.85292161e-01f, -1.38293818e-01f, 5.08690588e-02f, 1.04531102e-01f, 2.52339207e-02f, 7.42626265e-02f, -6.16333857e-02f, 2.54537314e-02f, 4.82349433e-02f, -8.59300494e-02f,
  -1.38719678e-01f, 2.64720712e-02f, 1.08022936e-01f, 6.26826808e-02f, -8.92890170e-02f, -1.95271894e-01f, -1.52181491e-01f, -2.40181595e-01f, -3.93064767e-02f, 2.83015162e-01f,
  2.00167835e-01f, 3.17139104e-02f, 8.20910558e-02f, -3.68042104e-02f, 1.18824095e-01f, -1.15734674e-01f, -1.53727680e-01f, 2.41970215e-02f, -2.25972891e-01f, 3.82441729e-01f,
  -8.79755855e-01f, -4.03142154e-01f, 4.82449502e-01f, -1.08315849e+00f, 9.25199613e-02f, 4.57209498e-01f, 7.34248519e-01f, 1.96998030e-01f, -2.33585730e-01f, 9.52576101e-02f,
  -1.53469995e-01f, -2.54478753e-01f, -4.01894599e-01f, 2.25319844e-02f, -3.51930708e-01f, -5.25270496e-03f, -2.99306929e-01f, -3.57990503e-01f, 2.27258503e-01f, 7.24485040e-01f,
  1.17289022e-01f, -4.68725890e-01f, -6.97851121e-01f, -3.26590538e-01f, 1.70716885e-02f, 1.67545021e-01f, 2.03987397e-02f, -2.75291055e-01f, -2.68077161e-02f, -3.86564881e-01f,
  6.64888144e-01f, -6.68224752e-01f, 7.53373727e-02f, -4.14322823e-01f, 5.85419461e-02f, -2.12455794e-01f, -7.48165175e-02f, -1.26425803e-01f, -2.16698404e-02f, -8.76873583e-02f,
  -4.88023072e-01f, -1.59177482e-01f, -1.69221580e-01f, -9.11358967e-02f, -1.22656703e-01f, 9.87839997e-02f, -1.47984147e-01f, -2.34214202e-01f, -1.62582502e-01f, 2.47980878e-01f,
  -1.32402629e-01f, -1.98454201e-01f, -1.52989715e-01f, 2.45143443e-01f, -1.23964772e-02f, -1.38331175e-01f, 1.83706313e-01f, 7.78545439e-02f, 1.96056411e-01f, 3.21534455e-01f,
  9.36003402e-02f, 9.92495716e-02f, 1.31427810e-01f, -2.12025065e-02f, 6.95901588e-02f, 4.72817943e-02f, -7.46572241e-02f, -8.92750174e-02f, 4.71969023e-02f, -1.67234764e-02f,
  2.93863285e-02f, -4.08576839e-02f, 5.29418327e-02f, -1.78020492e-01f, 7.97110721e-02f, -1.56766981e-01f, 2.50455691e-04f, 6.78827241e-02f, 5.37359109e-03f, -1.59932867e-01f,
  -1.83749259e-01f, -1.09682471e-01f, -3.60561460e-02f, 1.67040359e-02f, 1.04861580e-01f, -1.55760571e-01f, -3.53369378e-02f, 7.75094852e-02f, 5.56747289e-03f, -7.66467452e-02f,
  1.25701457e-01f, -3.53945792e-01f, 8.66058376e-03f, -4.70263399e-02f, -1.26730859e-01f, -2.96021141e-02f, -5.15493453e-02f, -4.86580543e-02f, -3.17879558e-01f, 4.08085482e-03f,
  -7.33524561e-02f, -1.28665725e-02f, -6.63130432e-02f, 2.32204664e-02f, 1.23258367e-01f, 8.79025534e-02f, -1.84865911e-02f, -2.36413777e-01f, -1.01108357e-01f, -1.51868649e-02f,
  1.39993965e-03f, 1.13145053e-01f, 1.06062077e-01f, 1.84583157e-01f, 1.53116941e-01f, -8.84732008e-02f, 2.86479175e-01f, 2.65324533e-01f, 2.18406647e-01f, 6.29365861e-01f,
  4.86638136e-02f, -5.31782329e-01f, -1.00320578e+00f, -1.81635544e-01f, -6.23178542e-01f, -4.60279018e-01f, -6.62455201e-01f, 1.94491912e-02f, 5.84679702e-03f, -6.87103808e-01f,
  2.13698134e-01f, 7.00703263e-01f, 5.47761261e-01f, 5.25541425e-01f, 8.28746021e-01f, -6.58721030e-01f, -7.92672217e-01f, 8.29864740e-02f, 6.81391060e-01f, 2.97640920e-01f,
  3.48732211e-02f, 1.31035015e-01f, 2.96175361e-01f, 3.48362565e-01f, -3.42259884e-01f, 3.01335990e-01f, -5.72976470e-01f, -2.46252045e-01f, -2.77349502e-01f, -1.05581820e+00f,
  -5.33911139e-02f, -5.98249435e-01f, 9.14511532e-02f, 8.10736567e-02f, -1.97649732e-01f, 8.28624144e-02f, -2.15199497e-02f, -2.78086334e-01f, -1.28041163e-01f, -1.47131547e-01f,
  -1.67315844e-02f, -5.70579506e-02f, 7.60326069e-03f, 9.07468349e-02f, 1.38250031e-02f, 3.42174098e-02f, -2.06370175e-01f, -1.14475869e-01f, -3.32547389e-02f, -3.40651944e-02f,
  8.52387175e-02f, -2.66785741e-01f, -1.43678904e-01f, -2.40412895e-02f, 2.37410158e-01f, -3.59774120e-02f, -1.58723280e-01f, -1.09322801e-01f, -1.05448872e-01f, -3.54802102e-01f,
  7.55772963e-02f, -4.29247282e-02f, 1.96954142e-02f, 1.78250819e-02f, 2.97419969e-02f, 1.00288436e-01f, -7.80103579e-02f, 7.29488879e-02f, -1.29618878e-02f, 7.86281824e-02f,
  -1.93048827e-02f, 2.43878718e-02f, 7.34076323e-03f, -2.17723832e-01f, -5.36487140e-02f, -4.37462516e-02f, -1.32362530e-01f, 2.28832543e-01f, 2.17582732e-02f, 5.69665357e-02f,
  -1.06553407e-02f, -1.27918035e-01f, 2.32581738e-02f, 1.57893971e-01f, -2.13157415e-01f, -6.37018122e-03f, -1.63601592e-01f, 8.78665298e-02f, 7.69413337e-02f, -2.31173694e-01f,
  6.16441309e-01f, 2.60285977e-02f, 1.19205587e-01f, 2.32253462e-01f, -1.49169505e-01f, -1.85287674e-03f, -3.07355495e-03f, 1.43194543e-02f, -1.84119083e-02f, -1.13101847e-01f,
  -9.24007669e-02f, 2.32082624e-02f, -3.32587026e-02f, -1.50088176e-01f, -4.26836014e-02f, 6.97122365e-02f, 1.21314831e-01f, 1.43666044e-01f, -8.85969996e-02f, -8.09036121e-02f,
  -1.04106449e-01f, -1.68966755e-01f, 2.68859148e-01f, 1.74481526e-01f, 6.95189312e-02f, 9.63663682e-02f, 3.32501344e-02f, 2.04783976e-01f, 2.66472399e-01f, 1.76908270e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  8.35670352e-01f, 9.46817636e-01f, 7.06455171e-01f, 7.57438183e-01f, 5.98511875e-01f, 6.31528199e-01f, 1.23518980e+00f, 6.01712167e-01f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  5.17078191e-02f, 1.53281577e-02f, 1.46189719e-01f, 4.71629314e-02f, -1.53100461e-01f, -1.45929500e-01f, 5.47820963e-02f, 1.99645579e-01f, 2.87579507e-01f, -4.46156591e-01f,
  -4.14483011e-01f, -6.55042768e-01f, 6.18802086e-02f, 3.51463795e-01f, 2.41163477e-01f, -9.39055390e-05f, -3.19146290e-02f, -1.49174660e-01f, -2.44227722e-01f, 1.03334777e-01f,
  8.81847322e-01f, -2.12057292e-01f, -2.59411454e-01f, -3.82338434e-01f, -7.00903311e-02f, -5.28801419e-02f, 4.65243846e-01f, -5.20676553e-01f, 1.92706123e-01f, -1.73718855e-01f,
  -1.80347651e-01f, 3.50140423e-01f, -1.63844422e-01f, 9.57551785e-03f, 8.08792338e-02f, -2.61751622e-01f, -4.37497318e-01f, 1.08618841e-01f, 8.85783657e-02f, 1.25505939e-01f,
  -9.62899104e-02f, 2.64094770e-01f, -3.62208307e-01f, 2.77213573e-01f, 2.37507448e-01f, -9.46903527e-02f, 1.34882897e-01f, -2.68474460e-01f, -3.80000621e-01f, 1.82319775e-01f,
  -1.89037561e-01f, 1.92582026e-01f, -3.00665479e-02f, -7.61235729e-02f, -8.81829187e-02f, -2.75777310e-01f, -3.72349471e-01f, 4.51397955e-01f, 2.11866602e-01f, 1.52014360e-01f,
  -9.56821665e-02f, -3.43268842e-01f, -8.30653869e-03f, 3.66242468e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  4.26180661e-01f, 8.83862853e-01f, 4.32590008e-01f, 3.01785588e-01f, 3.45741063e-02f, 5.50868154e-01f, -5.23633182e-01f, 5.72741143e-02f, -7.83024013e-01f, 9.66113687e-01f,
  1.75131515e-01f, 9.33613896e-01f, -6.40455782e-02f, -2.18826950e-01f, -2.81948715e-01f, 1.46885085e+00f, 4.46254686e-02f, 6.48533940e-01f, 2.87262380e-01f, 4.22863960e-01f,
  2.99747616e-01f, 4.48369682e-01f, -1.69034854e-01f, -2.31121063e-01f, 1.57699358e+00f, 1.24752259e+00f, 3.65508705e-01f, -1.91198289e-01f, -5.38467318e-02f, -4.61458266e-02f,
  -8.46930444e-02f, -4.88250405e-01f, 3.90618056e-01f, -1.02426216e-01f, 5.40970743e-01f, 4.39492643e-01f, 4.21073139e-01f, -1.39883654e-02f, 5.97454131e-01f, -8.46720561e-02f,
  -3.36715221e-01f, 1.46017826e+00f, 5.93277574e-01f, -1.33503854e+00f, 2.09046036e-01f, -7.53624082e-01f, 1.33516765e+00f, 3.37020725e-01f, 1.09684753e+00f, -5.67236543e-01f,
  5.67386210e-01f, -1.02728307e-01f, -9.21873868e-01f, 3.20977241e-01f, 3.11462671e-01f, 9.10258964e-02f, 7.00198889e-01f, 4.50663567e-01f, 1.29961562e+00f, 6.56002164e-02f,
  -1.36705768e+00f, 1.04394639e+00f, 7.33655930e-01f, 1.96436107e-01f, -1.51790217e-01f, 3.28622133e-01f, -3.34536135e-01f, -3.25267196e-01f, -3.96128953e-01f, -2.27672860e-01f,
  -6.19840510e-02f, -1.47629172e-01f, 7.20696270e-01f, -3.45761448e-01f, 9.31099236e-01f, -3.50077748e-01f, 5.24753749e-01f, -8.76200378e-01f, -6.45786643e-01f, 3.00778627e-01f,
  6.36511564e-01f, 6.07134402e-01f, 6.99055254e-01f, 6.09905064e-01f, 5.22651374e-01f, 1.21716812e-01f, -1.67948931e-01f, -9.41208191e-03f, 3.30790520e-01f, 1.15402080e-01f,
  -1.05823457e+00f, 9.48820770e-01f, -1.65252507e-01f, 3.77242923e-01f, 5.06223977e-01f, 7.69476295e-01f, 6.15144432e-01f, -2.60623991e-01f, 3.95171940e-01f, 4.09044832e-01f,
  2.62852848e-01f, -2.28264853e-01f, 1.87041000e-01f, 2.92911947e-01f, 7.97997594e-01f, 1.01090539e+00f, 5.20600975e-01f, 6.55960381e-01f, -1.60557330e-01f, -4.26593184e-01f,
  8.50069761e-01f, -1.05690837e+00f, 4.10690367e-01f, -5.86153492e-02f, 4.78416145e-01f, 3.10082853e-01f, 9.86860871e-01f, -1.82361752e-01f, 8.39441642e-02f, 3.12959880e-01f,
  -7.24463522e-01f, 2.28862107e-01f, 2.14431062e-01f, 4.44638580e-01f, 3.81607026e-01f, 7.58437634e-01f, -3.78672093e-01f, 8.09484482e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  1.88937157e-01f, 5.45903683e-01f, 1.88903049e-01f, 1.01988912e+00f, 1.07057303e-01f, 6.21160008e-02f, 4.66002524e-01f, 4.22728658e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  3.15961182e-01f, -3.08234066e-01f, 9.89004850e-01f, 7.75746778e-02f, -6.12404823e-01f, -4.39562738e-01f, 1.09243405e+00f, 7.17884183e-01f, 2.85092026e-01f, -3.14886123e-01f,
  -6.45762905e-02f, 4.40613896e-01f, -1.46938100e-01f, -7.80476391e-01f, -8.30307722e-01f, 5.75857870e-02f, 2.41587162e-01f, -6.55310333e-01f, -8.27162683e-01f, 1.65343970e-01f,
  -8.75143528e-01f, 8.75844121e-01f, 3.37330580e-01f, 5.82501292e-01f, 7.78028965e-01f, -1.22186577e+00f, -8.03867817e-01f, -3.95031571e-01f, 1.84954107e-01f, 1.33638039e-01f,
  -8.69279802e-01f, 7.14307070e-01f, -8.04424465e-01f, 5.56051135e-01f, 8.27905774e-01f, -4.46538985e-01f, -4.61681962e-01f, -6.95081651e-02f, -2.79752731e-01f, 8.91253829e-01f,
  7.77940810e-01f, -2.81544626e-01f, -7.61533856e-01f, 8.86795297e-02f, 8.97808298e-02f, -3.70481521e-01f, 2.46977538e-01f, -5.58749676e-01f, -3.73577774e-01f, -1.98237196e-01f,
  -6.10457957e-01f, -2.75781065e-01f, -1.01230705e+00f, 1.84620544e-01f, -8.12030852e-01f, 7.57626951e-01f, -4.19883430e-01f, -2.68022656e-01f, 7.55633056e-01f, 2.79351443e-01f,
  -8.07897389e-01f, -1.68305981e+00f, 1.04418546e-01f, -1.15528357e+00f, 2.11700484e-01f, -4.90901858e-01f, -9.07447934e-01f, 1.30444854e-01f, 4.13935214e-01f, 5.09538412e-01f,
  -7.75480866e-01f, -1.27649796e+00f, -1.06230199e+00f, -2.94662386e-01f, -4.91314203e-01f, 6.78186774e-01f, 3.99966598e-01f, -4.04469579e-01f, -2.39909872e-01f, -2.14388847e-01f,
  1.62801236e-01f, 8.45808685e-01f, 4.21827197e-01f, 5.44657290e-01f, 1.73566151e+00f, -7.98447490e-01f, -1.50484726e-01f, -1.68684542e+00f, 2.37707883e-01f, -5.91837823e-01f,
  -6.95230901e-01f, 1.41663838e-03f, -1.35809660e-01f, 4.60758448e-01f, -1.77310407e+00f, 4.13268298e-01f, -1.08314037e+00f, -4.39122111e-01f, -9.53771770e-01f, 2.43976206e-01f,
  -2.48788580e-01f, -5.15511811e-01f, 1.03498828e+00f, -3.18136334e-01f, 2.01135620e-01f, 1.10025451e-01f, -1.79770529e+00f, -1.14041221e+00f, -1.07696545e+00f, 5.52638650e-01f,
  4.66629893e-01f, -5.56077547e-02f, -6.73047006e-02f, 1.12869954e-02f, 1.18172742e-01f, 5.64714298e-02f, 4.80452716e-01f, -2.81453967e-01f, 6.93050683e-01f, -2.59247154e-01f,
  -1.19661176e+00f, 7.28218079e-01f, 5.75876562e-03f, -5.60957432e-01f, 6.69398904e-01f, -1.43664837e+00f, -7.92036206e-02f, -3.57285857e-01f, 3.61373246e-01f, 3.50585699e-01f,
  3.95764321e-01f, -2.26687163e-01f, 9.17091787e-01f, 2.60000050e-01f, -2.54919827e-01f, -6.23163879e-01f, -8.75236869e-01f, -9.89045620e-01f, 7.80719817e-01f, -1.12213898e+00f,
  -5.30325711e-01f, -6.92197978e-02f, 5.48841894e-01f, 3.74446154e-01f, 1.42670178e+00f, 1.61273032e-01f, -2.76853651e-01f, 3.38469297e-01f, -9.85397995e-01f, -9.30300176e-01f,
  -7.55950868e-01f, -6.86326027e-01f, -6.14277840e-01f, 3.70584339e-01f, -9.09272790e-01f, -3.15945297e-01f, -5.62173545e-01f, 6.21844351e-01f, 4.14403766e-01f, -1.08028424e+00f,
  -2.35404581e-01f, -3.35008025e-01f, 1.48992807e-01f, -8.33760500e-01f, 7.58808970e-01f, 2.50878911e-02f, -7.84865439e-01f, 1.08609593e+00f, 4.74359035e-01f, -1.19893587e+00f,
  9.73269999e-01f, 3.60481106e-02f, -1.05015862e+00f, 4.24934477e-01f, -8.66060138e-01f, -1.62242293e+00f, -4.10231084e-01f, -1.59012508e-02f, -5.86773828e-02f, -1.03995748e-01f,
  -1.14909780e+00f, 2.26842701e-01f, 1.01428702e-02f, 1.15203142e+00f, 1.90053716e-01f, 6.77055180e-01f, 6.38609171e-01f, -1.08511198e+00f, -5.40060401e-01f, -4.43859965e-01f,
  -4.47642982e-01f, -2.90251411e-02f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.87434107e-01f, 3.32709879e-01f, 5.96473180e-02f, -4.27461058e-01f, 8.03823471e-02f, 3.37220103e-01f, -4.06962156e-01f, -1.67183831e-01f, 1.76895410e-01f, -1.38501963e-02f,
  -3.98591191e-01f, -3.70546252e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    