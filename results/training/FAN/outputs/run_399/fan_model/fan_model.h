/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.01490258e-02f, 3.88225056e-02f, -1.70342654e-01f, -2.40321979e-01f, -1.96048856e-01f, -5.57371974e-01f, -3.79718065e-01f, -1.64451480e-01f, -3.68560761e-01f, 1.05810173e-01f,
  -8.83401781e-02f, 1.89567320e-02f, -1.63381547e-01f, -6.64225370e-02f, -2.05568835e-01f, -3.16701204e-01f, -2.28635222e-02f, -1.21343896e-01f, -5.09390309e-02f, -7.33297765e-02f,
  -6.42778259e-03f, 5.72823584e-02f, -2.19994709e-02f, 6.68786019e-02f, -1.28141835e-01f, 3.63225602e-02f, 1.79313689e-01f, 2.85683479e-02f, 1.96183577e-01f, -2.05506478e-02f,
  4.66854796e-02f, 1.73081771e-01f, 1.39568280e-03f, -1.11534330e-03f, 1.50156273e-02f, -1.70494542e-02f, -8.31333268e-03f, -1.01911509e-02f, 1.05086237e-01f, -2.86391862e-02f,
  -4.20505665e-02f, 5.24243228e-02f, -4.35822597e-03f, -5.32160178e-02f, -1.32415682e-01f, -4.70285211e-03f, -4.94318269e-02f, -6.71238899e-02f, -5.60775362e-02f, 1.73345637e-02f,
  1.68713909e-02f, -7.28820860e-02f, -7.40159452e-02f, -1.07137874e-01f, -3.93598676e-02f, 1.78796463e-02f, -2.51024403e-02f, -3.48245278e-02f, -6.21782392e-02f, -7.65402801e-04f,
  1.51509782e-02f, 9.54033900e-03f, 4.78027854e-03f, 8.70290175e-02f, 5.11702942e-03f, 1.09481364e-01f, -1.17044244e-02f, 1.43350614e-02f, 5.07508740e-02f, -7.69251063e-02f,
  -4.25326414e-02f, 1.71559919e-02f, 1.59503333e-02f, -7.90572837e-02f, 6.95541501e-02f, 2.02733055e-02f, 1.98751092e-02f, -1.30528316e-01f, -1.52551159e-02f, -6.63654432e-02f,
  -3.68331489e-03f, -2.32095569e-02f, -3.43154743e-02f, -1.78998169e-02f, 2.98515074e-02f, -1.09378368e-01f, 6.35122342e-05f, -1.00153640e-01f, -7.17327371e-02f, -2.94501372e-02f,
  -1.10471860e-01f, 5.22094108e-02f, 3.00057698e-02f, -5.24609676e-03f, 1.18974969e-03f, -5.43318242e-02f, -9.33035761e-02f, 7.31506273e-02f, -2.15266850e-02f, -4.93942723e-02f,
  -1.01636481e-02f, -3.01931258e-02f, 1.48330489e-02f, 5.79348858e-03f, 1.04051501e-01f, -7.56202415e-02f, -6.11532778e-02f, 9.64397416e-02f, 1.02709040e-01f, -6.72112405e-02f,
  1.14558171e-02f, -1.78859495e-02f, 9.40080360e-02f, 5.43374456e-02f, 8.17173049e-02f, -1.56127680e-02f, -5.20659275e-02f, 5.59797138e-02f, 3.57816145e-02f, -4.78908326e-03f,
  1.53904468e-01f, 1.79722548e-01f, 2.02871978e-01f, -1.11806564e-01f, -3.53459060e-01f, 2.81092882e-01f, 5.21771133e-01f, -2.67408341e-01f, -1.26616850e-01f, 6.07435293e-02f,
  -1.50861666e-01f, 1.74189761e-01f, 2.04686910e-01f, 9.69533399e-02f, 4.87256944e-02f, 2.03049630e-01f, -2.02254411e-02f, -3.50231640e-02f, 4.81020063e-02f, -7.21360743e-02f,
  -4.73951809e-02f, -2.16844484e-01f, 1.62849277e-01f, -2.79505700e-01f, 1.25302132e-02f, -1.53079713e-02f, -5.85676432e-02f, 9.99821797e-02f, -1.18854806e-01f, -4.38568927e-02f,
  1.29796505e-01f, -3.18705407e-03f, 2.04941811e-04f, -2.89534628e-02f, -4.07115445e-02f, 7.99917430e-02f, 9.66387093e-02f, 1.03128850e-01f, 3.66701484e-02f, 7.58929295e-04f,
  1.20226815e-01f, -7.40811005e-02f, -6.89737648e-02f, 1.44822625e-02f, 5.61238686e-03f, -2.32256968e-02f, 1.34679731e-02f, 4.11797836e-02f, 1.24481069e-02f, 1.39265776e-01f,
  9.00106058e-02f, 1.56666199e-03f, -3.94495949e-02f, -4.89430642e-03f, 1.65113434e-02f, 6.09966815e-02f, 1.15498655e-01f, 1.37139186e-01f, 4.12516184e-02f, -1.66240074e-02f,
  7.65034783e-05f, 2.54667886e-02f, 1.76159572e-02f, -2.99980212e-02f, 2.34054122e-02f, -4.57733423e-02f, 6.60488382e-02f, 8.42939764e-02f, -8.23612362e-02f, 1.55635076e-02f,
  -9.02218968e-02f, -3.59101482e-02f, -7.97470883e-02f, 3.54253277e-02f, 8.29797387e-02f, 3.44067141e-02f, 3.45726721e-02f, -4.18586582e-02f, -1.10858627e-01f, 2.99558043e-02f,
  -1.80274330e-03f, -7.68441036e-02f, 3.61535884e-02f, 6.61827698e-02f, 2.39194483e-02f, -7.30110519e-03f, -6.76912889e-02f, 2.38533299e-02f, 4.88563851e-02f, -6.29686518e-03f,
  -8.13618768e-03f, -1.15455918e-01f, 8.68319068e-03f, -3.72646539e-03f, 1.41203878e-02f, -1.56923592e-01f, 1.82047561e-02f, -1.22883141e-01f, -6.15967661e-02f, -7.08598718e-02f,
  -3.13010812e-02f, 7.10446434e-03f, -1.11959733e-01f, -6.13679737e-02f, -1.36434240e-02f, -4.95935790e-02f, 1.08115703e-01f, -8.37690979e-02f, -3.02003622e-02f, -9.27249119e-02f,
  -3.53317820e-02f, 9.13101062e-02f, -2.53820661e-02f, 2.66276095e-02f, -8.77184272e-02f, 1.10103711e-02f, -1.11778535e-01f, 1.02297897e-02f, 6.20608442e-02f, 1.45549215e-02f,
  8.55732262e-02f, 3.52062672e-01f, 2.02779859e-01f, 7.52033889e-02f, -5.52751832e-02f, 9.27680731e-02f, -2.01790273e-01f, 2.50675887e-01f, 3.09325218e-01f, -2.23857407e-02f,
  -9.89554077e-02f, -1.15182571e-01f, -7.79421851e-02f, 2.27488741e-01f, -5.25741816e-01f, -2.01067012e-02f, 6.96763471e-02f, 2.34356313e-03f, 1.56564921e-01f, 8.64544660e-02f,
  3.12499199e-02f, -2.46793643e-01f, -1.51704609e-01f, 1.64533090e-02f, 7.17803836e-02f, 1.78813085e-01f, -3.53431106e-01f, 7.35097900e-02f, -1.04408965e-01f, -3.01005375e-02f,
  -1.56564103e-03f, 2.71667570e-01f, 2.82796212e-02f, 8.95631760e-02f, 2.11883113e-02f, 5.32773361e-02f, -5.97222857e-02f, -8.43281746e-02f, -4.41754051e-02f, 3.09102796e-02f,
  1.36413192e-02f, -1.81067605e-02f, 1.71563197e-02f, -2.28096507e-02f, 4.71478179e-02f, 3.25557180e-02f, 4.94109318e-02f, 9.25029367e-02f, 3.16213369e-02f, 2.76548825e-02f,
  3.47771868e-02f, -2.69072689e-02f, 4.11529504e-02f, -6.98337704e-02f, 4.26031202e-02f, 1.12273298e-01f, -4.28408943e-02f, -5.97841963e-02f, -6.03097603e-02f, 7.20305517e-02f,
  -3.37288599e-03f, 1.27619520e-01f, 1.37832938e-02f, 9.92374960e-03f, -1.41741298e-02f, 5.40479226e-03f, -4.45466824e-02f, -1.23695187e-01f, 1.05435215e-02f, -1.12768352e-01f,
  -2.14351807e-02f, -7.45142475e-02f, 5.22825085e-02f, -1.60167068e-02f, -1.59380566e-02f, 1.66679490e-02f, -9.05327573e-02f, -3.86574790e-02f, -3.86091210e-02f, -2.12136269e-01f,
  -2.14323103e-02f, 3.22505645e-02f, -2.58532874e-02f, 3.89761664e-02f, -8.18668902e-02f, -1.25186741e-01f, 1.30465686e-01f, 2.80581750e-02f, -2.15035882e-02f, -1.23240866e-01f,
  6.89624920e-02f, 2.00214207e-01f, 2.00501941e-02f, -1.25848696e-01f, -3.28386724e-02f, -3.10820751e-02f, 4.84773964e-02f, -2.95579131e-03f, 5.29129505e-02f, -3.66019867e-02f,
  -3.24044900e-04f, -1.43068656e-02f, 1.73730385e-02f, -1.05145186e-01f, -5.10194562e-02f, 1.96574908e-02f, -8.92805383e-02f, -2.60017812e-02f, -3.53964642e-02f, -8.41455981e-02f,
  -3.01677976e-02f, 4.80526946e-02f, -2.81707309e-02f, 1.50818005e-02f, -7.75480941e-02f, -6.82939142e-02f, -4.69700812e-04f, 8.38471279e-02f, 3.50080314e-03f, -1.42258164e-02f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.49359345e+00f, -4.31242399e-02f, 4.20552105e-01f, -2.95166820e-01f, -1.51068702e-01f, 8.99734497e-02f, 3.28508675e-01f, -1.16799034e-01f, -1.78827420e-01f, 3.61520141e-01f,
  3.58179182e-01f, -2.42031023e-01f, 3.61182332e-01f, 4.42669481e-01f, -1.12040184e-01f, 2.86261708e-01f, 3.42825577e-02f, 4.19049934e-02f, 7.58953542e-02f, -2.37058610e-01f,
  -2.79348362e-02f, 1.82799637e-01f, 3.05012822e-01f, 6.75110295e-02f, 3.94027568e-02f, -1.76999465e-01f, 1.59203110e-03f, 1.07255213e-01f, 1.71931069e-02f, 1.01524228e-02f,
  -3.76071364e-01f, -2.37272933e-01f, 8.34123492e-02f, -4.39838208e-02f, -7.80831045e-03f, 3.02253645e-02f, -7.47288167e-02f, 1.28518017e-02f, -1.34313017e-01f, -3.22321840e-02f,
  2.87410561e-02f, -4.45803925e-02f, -6.41900487e-03f, 3.21628191e-02f, -2.02311918e-01f, 5.74221350e-02f, 3.13222334e-02f, 2.73447428e-02f, -2.18360480e-02f, -1.37305288e-02f,
  2.19827250e-01f, -3.09050493e-02f, 9.48187038e-02f, 1.51472494e-01f, 8.51947069e-02f, -4.12838673e-03f, 1.16423048e-01f, 1.69966482e-02f, -1.26977777e-02f, -9.82787460e-02f,
  -1.38020784e-01f, 8.27699751e-02f, 4.56225500e-03f, -3.66137400e-02f, -5.26979826e-02f, 1.34888723e-01f, 7.82830045e-02f, -8.41669738e-02f, -1.31506966e-02f, 6.90799253e-03f,
  -1.74244419e-01f, -8.97585824e-02f, -6.85622618e-02f, 1.05346583e-01f, -1.15347072e-01f, -7.29820803e-02f, 3.68072987e-02f, -4.22773957e-02f, -4.43217121e-02f, -4.12940793e-03f,
  2.92650191e-03f, 5.11428453e-02f, 6.28813952e-02f, 1.88246754e-03f, -7.36057982e-02f, -6.55843988e-02f, 7.59517178e-02f, -2.53466312e-02f, 1.14333637e-01f, -4.51415963e-02f,
  -8.98039222e-01f, -5.23174763e-01f, 1.16524018e-01f, -1.19872890e-01f, -7.38705546e-02f, -8.55457783e-02f, -4.90926355e-02f, -6.60548210e-02f, -9.54391658e-02f, -4.95245568e-02f,
  1.77071861e-03f, -2.77619641e-02f, -2.53095776e-02f, 6.72584074e-03f, -1.05403410e-02f, -1.11209648e-02f, -1.55366465e-01f, -1.24039233e-01f, -1.65603794e-02f, -6.75307661e-02f,
  -5.71040511e-02f, -5.63124940e-02f, 1.31260633e-01f, 1.30899781e-02f, -7.24713653e-02f, -1.07085155e-02f, -2.44820684e-01f, -1.80479102e-02f, -3.49995196e-02f, 1.81324825e-01f,
  -9.15821671e-01f, 6.58658266e-01f, 4.35868531e-01f, -5.14907420e-01f, 2.82572061e-01f, 3.15549940e-01f, -3.59551072e-01f, 3.47788274e-01f, 1.96371116e-02f, -7.13763833e-02f,
  -2.37320930e-01f, 4.18264866e-02f, -1.25672698e-01f, -1.50677338e-01f, -2.35885769e-01f, -2.05259234e-01f, -1.97878137e-01f, -3.55701953e-01f, 2.59964019e-01f, -2.79235076e-02f,
  3.56465727e-02f, -5.47899045e-02f, 9.11174193e-02f, 6.70482635e-01f, 1.85072750e-01f, 1.45229086e-01f, -4.12904501e-01f, 2.81904459e-01f, -1.65333617e-02f, 1.48214504e-01f,
  -1.48711175e-01f, -4.14320966e-03f, -8.88230726e-02f, -1.16182864e-02f, 6.15350902e-02f, -3.80497277e-02f, -1.49297372e-01f, 1.34885823e-02f, -5.99854663e-02f, 1.03049912e-01f,
  1.42349973e-02f, 1.45469800e-01f, 6.95422068e-02f, 1.11708432e-01f, 3.76055837e-02f, 5.66610545e-02f, 1.55721709e-01f, -3.21622379e-02f, 1.64655492e-01f, 1.60745665e-01f,
  4.34067324e-02f, 9.74939987e-02f, -5.55372238e-02f, -1.90933958e-01f, 5.19146919e-02f, 1.00011446e-01f, 1.22831061e-01f, 2.24920623e-02f, 9.01731569e-03f, -6.87931180e-02f,
  2.65288390e-02f, 6.28575236e-02f, 7.97233637e-03f, -6.99947104e-02f, 1.70188751e-02f, -6.96700439e-02f, 4.61817607e-02f, -2.32609455e-02f, 4.17263880e-02f, 3.91435483e-03f,
  -3.68816406e-02f, -5.99190630e-02f, 3.06458641e-02f, -2.04500183e-02f, -5.79063296e-02f, -9.98928249e-02f, -1.34887651e-01f, -9.63775441e-02f, -9.49689001e-03f, 2.43298318e-02f,
  -2.40231175e-02f, -1.01583384e-01f, -3.93767431e-02f, -1.06364585e-01f, -1.13750305e-02f, 7.44599402e-02f, 3.75581160e-02f, -7.41518056e-03f, -1.45518230e-02f, -2.42142696e-02f,
  -5.55519998e-01f, -4.00573999e-01f, 5.61064528e-03f, -5.77283427e-02f, 2.86476836e-02f, 9.79449376e-02f, 1.20910339e-01f, 6.95789382e-02f, 6.94191903e-02f, -4.96963114e-02f,
  8.13869759e-02f, -3.49483490e-02f, -6.03420809e-02f, -9.55150872e-02f, -6.54437691e-02f, -6.81931227e-02f, -1.73161998e-01f, -1.12053730e-01f, -1.97278053e-01f, 1.08841799e-01f,
  -1.48465291e-01f, -8.52994099e-02f, -3.70481238e-02f, 1.71686292e-01f, -1.20455613e-02f, -8.51649716e-02f, 4.00679448e-04f, -1.93364602e-02f, 1.05542012e-01f, 8.72341245e-02f,
  -1.46925813e-02f, 1.10620165e+00f, 4.24579859e-01f, 8.93436193e-01f, -6.42685354e-01f, 1.52380601e-01f, 4.09395635e-01f, 1.51297420e-01f, 5.10601819e-01f, 5.07544041e-01f,
  -3.12177557e-02f, 3.41233790e-01f, 1.14488445e-01f, 7.57651150e-01f, -2.26216823e-01f, 3.52136582e-01f, 6.20478511e-01f, 4.44171071e-01f, 7.27179809e-04f, 2.76575267e-01f,
  1.38939664e-01f, 2.27460474e-01f, 1.61246017e-01f, -1.11689359e-01f, 1.40926465e-01f, 7.03124478e-02f, -1.60988078e-01f, -3.01061243e-01f, 1.88018352e-01f, -2.27350801e-01f,
  -2.22249106e-01f, -8.50781053e-02f, 1.31146591e-02f, 9.50371921e-02f, -9.49430466e-02f, -7.90468082e-02f, -5.07695191e-02f, -1.06815659e-01f, -1.61875173e-01f, 3.82939875e-02f,
  3.28383222e-02f, -7.16318376e-03f, 5.07187918e-02f, -2.74194330e-02f, 2.06772536e-02f, 1.85558572e-02f, -1.43326994e-03f, 3.26011814e-02f, 1.53825745e-01f, -1.57553598e-01f,
  -7.19153963e-04f, -4.74506058e-02f, 3.37209329e-02f, -1.58206851e-03f, -8.51480812e-02f, 9.82710570e-02f, 1.60140678e-01f, -8.37731659e-02f, -1.41652487e-02f, -3.42958309e-02f,
  2.82300655e-02f, 2.00705361e-02f, 3.77985090e-02f, -7.43094608e-02f, 7.85299465e-02f, -4.61623967e-02f, 5.15903309e-02f, -1.82419881e-01f, 1.04430353e-03f, 3.37027051e-02f,
  4.33842391e-02f, -4.27353233e-02f, 7.76417404e-02f, 6.69537634e-02f, -7.64746778e-03f, 5.31980731e-02f, 2.28009894e-02f, -6.84608817e-02f, 7.63494894e-02f, -4.42440100e-02f,
  8.19694400e-02f, 7.12042823e-02f, 2.29304079e-02f, 1.78668480e-02f, -6.36945888e-02f, -7.55009204e-02f, -1.72753800e-02f, -1.57439876e-02f, -1.89868324e-02f, -7.75006264e-02f,
  3.79219383e-01f, 4.68341708e-01f, 1.73398510e-01f, -1.08198225e-01f, 3.54370512e-02f, 9.01119027e-04f, 1.06681094e-01f, 8.23039487e-02f, 1.52555153e-01f, 7.05274567e-02f,
  -9.27236527e-02f, 6.06172308e-02f, 5.86165115e-02f, -7.53945187e-02f, -3.71956043e-02f, 1.09350182e-01f, 2.46204454e-02f, 1.38395369e-01f, 6.09608293e-02f, -1.01016097e-01f,
  -2.29231864e-02f, -6.52551744e-03f, -2.18587890e-02f, 7.79080316e-02f, 5.84262386e-02f, -4.72616814e-02f, -2.63693966e-02f, -1.54344618e-01f, -1.11678839e-01f, 1.19282283e-01f,
  -5.55366814e-01f, 2.01340094e-01f, -2.66257793e-01f, -1.41577542e-01f, 6.32396787e-02f, -8.97359312e-01f, -4.62258607e-01f, 7.08782002e-02f, 2.85953641e-01f, 1.76733583e-01f,
  5.27483039e-02f, 2.82419294e-01f, 2.60400683e-01f, -3.07785958e-01f, -4.58974838e-01f, -8.00583512e-02f, -7.70196080e-01f, -2.95159519e-01f, 2.03798905e-01f, -2.12658241e-01f,
  -2.65132427e-01f, -2.00438276e-01f, -3.80757391e-01f, 3.41416061e-01f, -3.12175184e-01f, 5.70800975e-02f, -1.38657298e-02f, 1.59339651e-01f, -2.90393591e-01f, 7.40431100e-02f,
  1.55817822e-01f, 2.96835363e-01f, 1.12672843e-01f, 1.09788440e-01f, -2.36694798e-01f, -1.72568411e-01f, -7.81016126e-02f, 1.52567834e-01f, 1.10581866e-03f, -6.41403999e-03f,
  5.95118031e-02f, 1.68446600e-02f, -8.29535872e-02f, 1.33969307e-01f, -2.58273277e-02f, 1.03483506e-01f, -7.93718919e-03f, -8.88419989e-03f, 1.56668618e-01f, -1.89097360e-01f,
  1.15142716e-02f, 3.20339538e-02f, -3.15295309e-01f, -1.20661281e-01f, -7.24587142e-02f, 8.16145819e-03f, -3.38010162e-01f, -1.81775630e-01f, -7.53188655e-02f, -7.69678652e-02f,
  -7.13753253e-02f, -1.64788619e-01f, -1.73813090e-01f, 8.40723068e-02f, -2.92276274e-02f, 5.88981435e-02f, -1.39327377e-01f, -8.02696508e-04f, -2.06221879e-01f, 5.19555323e-02f,
  5.89578040e-02f, 2.76199169e-02f, 1.35435179e-01f, -9.26021710e-02f, -8.77272487e-02f, 5.46385460e-02f, 1.39447663e-03f, 1.06575094e-01f, -1.17582016e-01f, 5.20983376e-02f,
  2.90607661e-01f, -1.25890955e-01f, 9.33561772e-02f, -6.28551319e-02f, 9.18401703e-02f, -5.86368330e-02f, -6.38436154e-02f, -5.13147749e-02f, 5.45447133e-02f, -1.07810430e-01f,
  2.69621015e-02f, -5.08343503e-02f, 1.56778917e-01f, 2.18048424e-01f, 8.31155255e-02f, -1.87642902e-01f, -7.62629956e-02f, -1.77989721e-01f, -4.06040065e-02f, -6.66874498e-02f,
  -2.48995468e-01f, -2.39278078e-02f, -1.46924734e-01f, 3.46036209e-03f, 6.41508773e-02f, -9.62541178e-02f, 2.05106996e-02f, 2.75338739e-01f, 9.68730450e-02f, -6.49049580e-02f,
  9.56328884e-02f, -1.54485563e-02f, 6.70848340e-02f, -2.95695420e-02f, -1.18547995e-02f, -8.27281028e-02f, -9.21454728e-02f, 1.23623930e-01f, -3.56237218e-02f, -9.12858844e-02f,
  1.92797288e-01f, 5.90380952e-02f, -1.56656697e-01f, -1.44258380e-01f, -1.96426928e-01f, -3.08845013e-01f, -3.81351203e-01f, -2.21049309e-01f, 4.04257119e-01f, -1.25218377e-01f,
  -3.82302999e-01f, 4.86399829e-01f, 4.53653634e-02f, -5.06561160e-01f, 4.43152875e-01f, 3.53559464e-01f, 5.10602668e-02f, -3.93483490e-02f, 2.48611659e-01f, -8.32820535e-02f,
  1.75458193e-01f, -4.76347059e-01f, -3.00343066e-01f, -3.80029619e-01f, -5.74914098e-01f, -1.43308446e-01f, -8.46474916e-02f, -3.28054428e-01f, -4.09478217e-01f, 5.96230142e-02f,
  -2.25192979e-01f, 2.30059419e-02f, -2.39681438e-01f, 6.78123906e-02f, 3.93503644e-02f, -4.22762446e-02f, -9.33303908e-02f, -1.64345860e-01f, 5.23478314e-02f, 8.96831453e-02f,
  1.35384187e-01f, 1.16786674e-01f, 8.48632231e-02f, 3.68494466e-02f, -2.09009483e-01f, -5.02756946e-02f, -1.50081310e-02f, -2.20971331e-01f, 2.27535460e-02f, -8.40911865e-02f,
  -8.28267336e-02f, -6.83621615e-02f, -8.66253600e-02f, 1.28327399e-01f, 7.09126219e-02f, -5.58455102e-02f, -1.61161944e-02f, -6.91908821e-02f, -8.77119377e-02f, 1.54507190e-01f,
  7.82976896e-02f, 1.10757537e-01f, -1.37555733e-01f, -1.34205475e-01f, -1.03167959e-01f, -8.93504918e-02f, 1.00657143e-01f, -1.63019970e-02f, 7.18516260e-02f, -4.69944067e-02f,
  -9.07916427e-02f, -1.05860814e-01f, -6.04965910e-02f, 1.38354963e-02f, -2.56539825e-02f, -4.90646204e-03f, -5.57389408e-02f, -6.23623747e-03f, -5.86859360e-02f, -5.74505422e-03f,
  5.59847429e-03f, 2.93237790e-02f, 8.82493556e-02f, -1.08897137e-02f, -1.73813060e-01f, -7.23967105e-02f, 3.81559730e-02f, -6.39695153e-02f, -4.13763598e-02f, -4.10838313e-02f,
  1.16689771e-01f, 2.69355953e-01f, 1.08620018e-01f, -3.22356187e-02f, 4.81847115e-02f, -4.98002023e-02f, 3.98274735e-02f, 5.90288937e-02f, 9.16204676e-02f, 2.49427836e-02f,
  3.02176327e-02f, -7.39221796e-02f, 3.66351679e-02f, -6.18528575e-02f, 2.40606572e-02f, -6.50996789e-02f, 2.62599755e-02f, 4.78799231e-02f, 1.19489938e-01f, 7.17352005e-03f,
  -5.66473268e-02f, 1.69946402e-02f, 1.21824414e-01f, -9.09102708e-02f, -4.67350222e-02f, 3.31115760e-02f, 2.24513076e-02f, 3.58221270e-02f, 1.33866752e-02f, 1.57900959e-01f,
  -2.54033446e-01f, 1.36624500e-01f, -2.88568735e-01f, -3.24041456e-01f, 1.93059206e-01f, -1.99270159e-01f, -1.84582472e-01f, -1.88567817e-01f, -2.13135391e-01f, 2.23437741e-01f,
  -1.81350276e-01f, -5.99817820e-02f, -6.51396513e-02f, -6.45449996e-01f, -1.01514554e+00f, -5.92189908e-01f, -4.80269015e-01f, -1.72710299e-01f, -6.91037700e-02f, -4.53728773e-02f,
  -1.64745122e-01f, -2.90015340e-01f, -4.71894056e-01f, 1.02936372e-01f, 1.10481426e-01f, 3.47018421e-01f, 3.06219697e-01f, 2.97483534e-01f, 1.47991240e-01f, -3.42892855e-01f,
  -3.34156036e-01f, -2.02885345e-01f, 1.60361037e-01f, -1.81240782e-01f, -1.35581374e-01f, 2.48430938e-01f, 1.55273035e-01f, -1.26501039e-01f, -2.58721709e-02f, -3.90293933e-02f,
  1.66283846e-01f, -6.14822395e-02f, -7.62315020e-02f, 1.29602151e-02f, 3.49318497e-02f, -1.80805959e-02f, -6.68992996e-02f, 8.62223059e-02f, -4.34999876e-02f, -6.12912886e-02f,
  -2.28546700e-03f, -3.08013801e-03f, 7.57441074e-02f, -1.76333543e-02f, -9.22279581e-02f, -4.88883480e-02f, 4.70136479e-02f, 1.81601986e-01f, 7.47989044e-02f, 1.53769422e-02f,
  -9.74905267e-02f, 1.20287962e-01f, -9.66704860e-02f, -2.71814726e-02f, -8.89314413e-02f, 1.40972078e-01f, -5.73027693e-02f, 6.75643161e-02f, 8.88902396e-02f, 9.22047943e-02f,
  4.06256914e-02f, 3.38221751e-02f, -1.07280038e-01f, -3.38796787e-02f, 7.40132853e-02f, 3.26484665e-02f, 2.60789059e-02f, 5.27713522e-02f, -5.41609339e-02f, 5.19802943e-02f,
  -1.21104203e-01f, -1.01733143e-02f, 2.35165898e-02f, 9.51256528e-02f, -2.02744633e-01f, 1.35500416e-01f, 6.83495477e-02f, 2.41431259e-02f, 4.84634638e-02f, 1.44941598e-01f,
  2.84986966e-03f, 1.45038683e-02f, -2.68122051e-02f, -3.09880301e-02f, 2.98911463e-02f, -9.59882662e-02f, -1.86391607e-01f, -8.59201103e-02f, 2.00979430e-02f, -1.34734005e-01f,
  1.58120066e-01f, 7.27534145e-02f, 6.03571944e-02f, -4.34120782e-02f, -5.81415519e-02f, 8.05313289e-02f, -1.11050101e-03f, -6.97023794e-03f, 3.71309370e-02f, 1.07384525e-01f,
  1.80075154e-01f, 9.05885249e-02f, 9.32525247e-02f, 7.58436322e-02f, 1.21105872e-01f, 1.08909681e-01f, 1.62337199e-01f, -9.32656750e-02f, 1.18206121e-01f, -4.57457490e-02f,
  6.80390894e-01f, -1.87519044e-01f, 6.03724957e-01f, 6.42527401e-01f, 1.54691547e-01f, -2.53269941e-01f, 7.39388391e-02f, -9.29339752e-02f, 4.43433851e-01f, -2.73326993e-01f,
  -1.79958776e-01f, 5.44816792e-01f, -7.00354397e-01f, 2.82625079e-01f, -2.62766153e-01f, -5.18481910e-01f, 1.13324873e-01f, 2.94976056e-01f, -3.39484327e-02f, 1.80640817e-01f,
  2.02429146e-01f, -4.40314412e-01f, 9.17107624e-04f, -3.46394241e-01f, 4.08863306e-01f, 2.74489909e-01f, -3.12296778e-01f, -2.07778826e-01f, 1.85221165e-01f, -3.07750441e-02f,
  4.67190929e-02f, 1.50539905e-01f, 2.63965577e-01f, 8.88215974e-02f, -4.29479256e-02f, -5.84785827e-03f, 8.64193141e-02f, -3.48465294e-02f, 3.82365510e-02f, 8.21851417e-02f,
  8.96839648e-02f, -1.02616861e-01f, 1.75109640e-01f, 3.79220769e-02f, 1.22822173e-01f, 1.86094701e-01f, 2.11209476e-01f, 9.77517217e-02f, 1.99575737e-01f, 1.13770626e-01f,
  1.79026008e-01f, 2.66500533e-01f, 1.45568252e-01f, 7.27924779e-02f, 4.39283513e-02f, 6.89336238e-03f, 1.33008629e-01f, 5.37908114e-02f, 3.23572718e-02f, 7.77662918e-02f,
  -4.14239839e-02f, -1.55687109e-01f, -1.38398722e-01f, -2.58895494e-02f, 1.51725924e-02f, 1.81660965e-01f, -7.03343153e-02f, -6.90658838e-02f, 3.82675976e-02f, 6.94246739e-02f,
  2.31099855e-02f, 1.01582199e-01f, 6.32189289e-02f, 4.52232722e-04f, -2.14375127e-02f, 1.16558306e-01f, 8.60109553e-02f, -2.42591146e-02f, 8.48691389e-02f, 3.60525250e-02f,
  -1.49514228e-02f, -7.30655566e-02f, -4.87869121e-02f, 9.73417163e-02f, -3.26979011e-02f, -6.70907944e-02f, -2.44469196e-02f, 1.26490250e-01f, 5.21505326e-02f, -4.13160250e-02f,
  -8.86533141e-01f, -7.41733491e-01f, -9.99966487e-02f, -2.84177940e-02f, 5.05128466e-02f, -3.86128612e-02f, 2.26999260e-02f, 1.76680848e-01f, -2.36486495e-01f, -1.26308978e-01f,
  -5.08635584e-03f, 1.23762548e-01f, -7.62980729e-02f, 9.47177857e-02f, -9.08826217e-02f, -8.41907337e-02f, -1.40220478e-01f, -6.83300570e-02f, -1.83899835e-01f, -1.03361599e-01f,
  -3.48069035e-02f, -6.83210790e-02f, 2.08970942e-02f, 1.35765374e-01f, 3.16815823e-02f, 1.11461811e-01f, 1.48620014e-03f, 1.58386340e-03f, -6.73229471e-02f, -7.86974058e-02f,
  1.61121085e-01f, -4.17765021e-01f, 3.11921149e-01f, 7.96745420e-01f, 1.93786502e-01f, -7.90451169e-01f, -4.09794569e-01f, 4.14157540e-01f, 1.81661353e-01f, -4.43176210e-01f,
  1.84244052e-01f, -4.69123453e-01f, -3.29136729e-01f, 1.52429819e-01f, 2.82514513e-01f, -4.50719833e-01f, 2.87165016e-01f, -1.88006207e-01f, 2.36785099e-01f, 4.73346770e-01f,
  5.69917977e-01f, 2.73109287e-01f, 4.88703966e-01f, 3.84952486e-01f, 3.01481903e-01f, 5.60987234e-01f, 6.92369580e-01f, 6.03335835e-02f, 4.24073786e-01f, -1.98615685e-01f,
  -9.90083143e-02f, 1.00483581e-01f, 5.69173545e-02f, -2.03428030e-01f, 1.41319394e-01f, -5.11281602e-02f, -1.01789005e-01f, -1.05904542e-01f, 1.48418888e-01f, -1.03545927e-01f,
  -2.23200232e-01f, 8.58873036e-03f, -2.12930068e-02f, 3.71250696e-02f, -6.09799810e-02f, 3.96713093e-02f, 1.21659987e-01f, 4.86101098e-02f, -1.56783573e-02f, -1.27901295e-02f,
  2.10078254e-01f, 1.65008958e-02f, 2.95694242e-03f, 4.69482765e-02f, 1.55422181e-01f, 7.38274977e-02f, -1.07075758e-01f, -4.04087007e-02f, -4.36200090e-02f, -1.21946065e-02f,
  3.39199207e-03f, -3.78580391e-02f, -5.88348210e-02f, 2.58984417e-02f, 3.06927133e-02f, 1.44298851e-01f, -5.86442836e-03f, -5.04346611e-03f, 3.46670151e-02f, 5.32818176e-02f,
  1.21121548e-01f, 1.38490483e-01f, 5.40834889e-02f, 1.32676765e-01f, -1.70987137e-02f, 7.16447085e-02f, -8.15835744e-02f, -2.62015238e-02f, 1.26283139e-01f, 1.97684184e-01f,
  7.91113824e-02f, 2.67488323e-02f, -3.58211361e-02f, -6.63906801e-03f, -9.14631635e-02f, 8.67373347e-02f, -6.08173572e-02f, -7.72776753e-02f, 7.09122419e-03f, 6.73853466e-03f,
  -1.05336390e-01f, 2.24562567e-02f, -7.29881320e-03f, -6.92000687e-02f, 3.83155164e-03f, 4.84803654e-02f, -1.64599828e-02f, -9.34629329e-03f, -1.03712929e-02f, 6.55153468e-02f,
  4.80599254e-02f, 8.46930519e-02f, -1.37890771e-01f, 7.12670907e-02f, 7.53472969e-02f, 1.05953850e-02f, 7.85012469e-02f, 1.10637031e-01f, 1.49463385e-01f, 1.09745413e-01f,
  1.09792843e-01f, -1.42750740e-01f, -8.33906606e-03f, 9.70328674e-02f, 4.90676686e-02f, -1.38829947e-01f, -3.25331651e-02f, 3.32683064e-02f, 1.07598729e-01f, 3.37100811e-02f,
  7.72898257e-01f, -5.47582567e-01f, -2.97496706e-01f, 1.88297749e-01f, 5.64899921e-01f, 5.86327732e-01f, 5.58451831e-01f, -5.01238704e-02f, 6.06252439e-02f, -4.84974056e-01f,
  1.77488834e-01f, -2.70538449e-01f, -2.97581375e-01f, 4.00668949e-01f, 8.93620372e-01f, -2.45285347e-01f, 4.51517940e-01f, 1.14832476e-01f, 2.94405036e-02f, 7.03101680e-02f,
  2.59649873e-01f, 5.76119721e-01f, -1.12204410e-01f, -1.58038661e-01f, 4.08093721e-01f, -3.75220597e-01f, -4.76918370e-02f, -2.74661005e-01f, 3.13280113e-02f, 1.68750957e-01f,
  1.39789268e-01f, 8.76950696e-02f, 1.92949213e-02f, -1.50513560e-01f, -6.89026043e-02f, 3.08910087e-02f, -1.07149631e-01f, 2.78754421e-02f, 1.07557297e-01f, -1.36981502e-01f,
  -1.13634579e-01f, 6.33258671e-02f, 1.05040140e-01f, -2.41682436e-02f, 1.33669853e-01f, 4.33120802e-02f, -1.76633056e-02f, -2.06028689e-02f, -1.12541154e-01f, -6.84617385e-02f,
  -5.30600734e-02f, -3.61837931e-02f, 8.91069695e-02f, -1.54264346e-01f, -9.83118862e-02f, 8.36295914e-03f, -8.59418213e-02f, -8.73995125e-02f, -2.65050586e-02f, 2.53514908e-02f,
  -1.57911964e-02f, 5.29695638e-02f, -1.47662079e-02f, 6.44555986e-02f, 5.85605353e-02f, 8.65727514e-02f, 5.32194152e-02f, 4.64267982e-03f, -1.83812976e-02f, -3.34259383e-02f,
  8.59226659e-03f, -1.81699507e-02f, 8.52068365e-02f, 2.78239548e-02f, 7.04175085e-02f, 6.51803836e-02f, -9.87802818e-02f, -9.03811157e-02f, -9.32359919e-02f, 3.29849422e-02f,
  -7.32633322e-02f, 1.86202884e-01f, -1.96579900e-02f, -4.53839917e-03f, -4.10893634e-02f, -9.29445177e-02f, -3.12690660e-02f, -2.78446451e-02f, 7.37954453e-02f, -9.88913104e-02f,
  -1.41294291e-02f, -3.86034638e-01f, -1.13717102e-01f, 5.84655791e-04f, -6.95911273e-02f, -6.03206456e-03f, 1.85251161e-02f, 3.81158628e-02f, -4.96363603e-02f, 1.48750305e-01f,
  4.73477021e-02f, 4.37425338e-02f, -3.29386890e-02f, 6.40008450e-02f, -4.14305590e-02f, -2.21217759e-02f, -2.34332219e-01f, -3.40735051e-03f, 4.62834015e-02f, -1.00726284e-01f,
  -1.58280134e-02f, 6.35658763e-03f, 1.43711241e-02f, 1.19301319e-01f, 6.33309856e-02f, -7.76804164e-02f, 1.64492235e-01f, -1.65183693e-01f, -5.28060272e-02f, -1.03928879e-01f,
  2.27211401e-01f, -1.33852452e-01f, -7.44286001e-01f, 2.40367651e-02f, 1.05264857e-02f, 1.13928892e-01f, -2.92764395e-01f, 7.31491968e-02f, -6.23521984e-01f, 3.39845955e-01f,
  3.88700694e-01f, -1.85581878e-01f, -3.56125534e-01f, 6.76777244e-01f, -1.37871783e-02f, -1.81957275e-01f, 5.51547229e-01f, 1.67630911e-01f, -2.79324800e-01f, 5.35366952e-01f,
  4.35439050e-02f, 9.23109293e-01f, -1.27759680e-01f, 5.13115466e-01f, 3.98738950e-01f, -8.53031129e-02f, 6.05630279e-01f, -2.74939060e-01f, 8.46176445e-01f, 2.81037241e-01f,
  6.54168194e-03f, -1.72757506e-02f, -8.49837959e-02f, -1.36528581e-01f, 1.63584426e-01f, 1.55321673e-01f, -4.32422124e-02f, -3.78840156e-02f, -2.00907066e-01f, -2.32633911e-02f,
  -4.37041484e-02f, -2.66793314e-02f, 1.25603929e-01f, -1.11598074e-01f, 7.02784816e-03f, -1.02226883e-02f, -5.81635423e-02f, -9.22281891e-02f, -1.10675268e-01f, 7.33609051e-02f,
  -1.96944326e-01f, -2.05554049e-02f, -1.02017276e-01f, 8.28058049e-02f, -2.37273812e-01f, 4.64595146e-02f, -1.06134459e-01f, -1.16982318e-01f, -1.77369006e-02f, 8.97537023e-02f,
  2.56300360e-01f, 3.32447398e-03f, -1.16500251e-01f, 1.39623642e-01f, -4.50596167e-03f, 6.44202828e-02f, -8.54919851e-03f, 9.33088139e-02f, -1.09579615e-01f, 1.35947257e-01f,
  3.54765132e-02f, -3.46558578e-02f, 1.47244707e-01f, 3.07517573e-02f, 4.25706916e-02f, -6.75077736e-02f, -9.13609564e-03f, 3.75885814e-02f, -2.48834062e-02f, -5.18569760e-02f,
  1.34781212e-01f, -4.19938713e-02f, 9.93227027e-03f, 1.60164423e-02f, 1.39651792e-02f, -9.94237736e-02f, 1.55530274e-01f, 5.44090420e-02f, -8.23517218e-02f, -9.79764089e-02f,
  1.52449667e-01f, 3.69031757e-01f, -1.06043175e-01f, 4.35608327e-02f, 7.60354325e-02f, 1.36150438e-02f, -4.91371714e-02f, 1.01875938e-01f, 5.57130240e-02f, -4.90621440e-02f,
  7.73091689e-02f, -9.05300602e-02f, 1.44159466e-01f, 6.28828034e-02f, 8.29577167e-03f, 4.16654311e-02f, 1.01915643e-01f, 3.18251923e-02f, 4.44564819e-02f, 2.41046518e-01f,
  1.42212167e-01f, 3.59357260e-02f, -3.38283665e-02f, -1.58881143e-01f, 8.62575918e-02f, 8.74179453e-02f, -8.89816135e-02f, -1.09797671e-01f, 1.83917582e-01f, 3.43504176e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  5.50985098e-01f, 3.22685421e-01f, 8.69659007e-01f, 1.27609417e-01f, 2.56319523e-01f, 3.88779312e-01f, 7.85685182e-01f, 5.61701000e-01f, 5.88021457e-01f, 8.13577771e-01f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  3.17555428e-01f, 1.94031596e-01f, -2.90742904e-01f, -4.20370907e-01f, 5.72545469e-01f, -5.60863674e-01f, 4.48923320e-01f, 3.44066411e-01f, -3.23639989e-01f, 3.74299437e-01f,
  3.47853564e-02f, 8.19942355e-03f, -5.12269139e-02f, -2.53516555e-01f, -1.70003638e-01f, 1.93385169e-01f, -1.47989064e-01f, 1.41838521e-01f, -2.34450884e-02f, 7.00707912e-01f,
  -5.65338254e-01f, 4.95532453e-01f, -1.33652002e-01f, 2.84706801e-01f, -3.37286204e-01f, 2.85904169e-01f, -9.92144719e-02f, 2.07873970e-01f, 3.01460475e-01f, -1.31314084e-01f,
  1.45481706e-01f, 3.02196741e-02f, 2.28507310e-01f, 2.54136562e-01f, 1.73315033e-01f, -2.45354101e-01f, 1.51978880e-01f, 2.29536876e-01f, -3.59345376e-01f, 3.36655498e-01f,
  8.41615815e-03f, -2.37127945e-01f, -1.45977929e-01f, -1.62808627e-01f, 1.79467425e-01f, 3.91854703e-01f, 2.37576306e-01f, -3.25408541e-02f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  3.82550150e-01f, 3.53468180e-01f, 3.65399122e-01f, 7.24868119e-01f, -1.13051641e+00f, 9.53928471e-01f, 2.21588179e-01f, 1.03071928e+00f, -3.56525242e-01f, 3.63886982e-01f,
  -6.25357449e-01f, 9.84920025e-01f, 3.49118441e-01f, 1.04992461e+00f, 2.67656058e-01f, 4.54074353e-01f, 3.65137339e-01f, 6.41634524e-01f, 7.02522099e-01f, 5.83938770e-02f,
  -6.89240694e-01f, -1.36827469e-01f, -6.78913116e-01f, -2.78837979e-01f, 3.89949799e-01f, 1.46070663e-02f, 1.21631944e+00f, 9.32327390e-01f, -8.70859742e-01f, 8.22775841e-01f,
  -1.05713928e+00f, 4.78914499e-01f, -4.86601293e-01f, 5.50789475e-01f, 4.88979399e-01f, -4.43526208e-01f, -5.84541894e-02f, 8.36817443e-01f, -8.01695466e-01f, -1.79322854e-01f,
  5.53821266e-01f, 2.84921080e-01f, 1.09027946e+00f, 8.23693946e-02f, 1.20205891e+00f, 2.09937006e-01f, 6.51432097e-01f, -1.02591169e+00f, 6.19420052e-01f, 3.08134735e-01f,
  5.40788509e-02f, 2.62576073e-01f, 2.62208492e-01f, 8.30268919e-01f, 1.08363056e+00f, 8.89802217e-01f, 9.09034535e-02f, 1.15432763e+00f, -4.60919619e-01f, 3.36325645e-01f,
  2.32709199e-01f, -6.00687087e-01f, -7.33197212e-01f, 1.68306142e-01f, 4.64405954e-01f, 8.48837554e-01f, 1.94641680e-01f, -7.56196737e-01f, 1.10532999e+00f, 7.15609908e-01f,
  1.85147941e-01f, 7.45885849e-01f, 7.15520859e-01f, -5.84441543e-01f, 3.68169010e-01f, -4.43228781e-01f, 1.12320411e+00f, 1.11057761e-03f, -4.73899722e-01f, -5.07267058e-01f,
  4.77043062e-01f, -1.42661259e-02f, -2.65356809e-01f, 1.06740999e+00f, -1.01186633e+00f, 1.14871159e-01f, -2.71943063e-01f, -3.90343461e-03f, 3.31946403e-01f, 5.23827791e-01f,
  7.10310996e-01f, 1.25402462e+00f, 8.28172386e-01f, 1.14811611e+00f, -2.51317441e-01f, 1.13449521e-01f, -2.11437717e-01f, 5.34745753e-01f, 4.15664911e-01f, -9.52556968e-01f,
  -1.34200931e-01f, 4.78247255e-01f, 3.67478907e-01f, 9.11756635e-01f, -7.73148894e-01f, 9.30850446e-01f, 4.71995115e-01f, -4.52962101e-01f, -4.61553261e-02f, 7.13453114e-01f,
  7.65618086e-01f, -7.83915102e-01f, 7.52160370e-01f, -1.28523573e-01f, 2.97695667e-01f, -7.81986594e-01f, 8.96056116e-01f, -1.00907183e+00f, 1.23883939e+00f, 3.68265837e-01f,
  -3.17327708e-01f, -7.46517628e-02f, -1.44021347e-01f, -2.14054346e-01f, 9.22594130e-01f, 4.07746971e-01f, 5.39379194e-02f, -4.73130196e-01f, 5.00350893e-01f, -5.23345619e-02f,
  1.68857962e-01f, -7.12185740e-01f, 6.17543817e-01f, -1.32067561e+00f, 4.25748765e-01f, -5.35406649e-01f, 1.19160432e-02f, -4.67604160e-01f, -3.16402465e-01f, -8.16397488e-01f,
  3.17422330e-01f, 2.79427558e-01f, 1.33627927e+00f, 9.19954717e-01f, -3.02635670e-01f, 6.93780601e-01f, 8.38008940e-01f, -8.16042125e-01f, 5.67460418e-01f, 1.08791482e+00f,
  6.06210291e-01f, -2.75030602e-02f, 1.61881256e+00f, -1.39643386e-01f, 1.41354442e-01f, -9.64768648e-01f, -1.12238896e+00f, 2.00845733e-01f, -7.63882920e-02f, 8.91361773e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  3.31848741e-01f, 3.48824352e-01f, 5.71275473e-01f, 4.79575604e-01f, 7.50422716e-01f, -2.65999865e-02f, 5.84103703e-01f, 7.42824793e-01f, 5.55984676e-01f, 4.14066017e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  -1.48733228e-01f, -6.80215418e-01f, 2.21581049e-02f, 6.78475320e-01f, -3.21417511e-01f, -8.47074509e-01f, -4.56041902e-01f, -3.55409503e-01f, -1.09717321e+00f, 3.26956034e-01f,
  1.36149243e-01f, -6.28514171e-01f, -1.08955133e+00f, 4.07769352e-01f, 8.02396834e-02f, 6.02405787e-01f, 3.23613763e-01f, 3.33777040e-01f, 4.94156480e-01f, 1.98694974e-01f,
  -2.56195635e-01f, 6.58430457e-01f, -4.63267982e-01f, -2.68388748e-01f, -6.23559177e-01f, -1.49000788e+00f, -1.05471003e+00f, -8.02948773e-01f, -6.49758875e-01f, -1.05776358e+00f,
  8.87086093e-01f, 8.16782176e-01f, 6.79320022e-02f, -3.40570420e-01f, -4.27482903e-01f, -4.48264599e-01f, 2.29677618e-01f, 9.95525569e-02f, 5.95380723e-01f, -9.46499586e-01f,
  -4.28221196e-01f, -5.91355801e-01f, -9.22396064e-01f, 4.26815599e-01f, -2.60663569e-01f, -2.64118254e-01f, 7.04215169e-01f, -9.92685139e-01f, -4.07393515e-01f, -4.93539691e-01f,
  -2.03256056e-01f, -1.27466442e-02f, -2.13029787e-01f, -6.15989864e-01f, 3.63874167e-01f, -6.97538376e-01f, -5.83503067e-01f, 8.40825737e-01f, -9.91890550e-01f, 7.45833218e-02f,
  7.79559851e-01f, -3.16689014e-01f, -1.01266086e+00f, -1.41639948e+00f, -7.47060001e-01f, 6.82498276e-01f, 1.51150897e-01f, 4.87465143e-01f, 2.13073641e-01f, 7.07632780e-01f,
  1.02215201e-01f, -3.04902524e-01f, -5.97052932e-01f, 5.24438083e-01f, 4.70956415e-01f, -1.04340875e+00f, 9.60798621e-01f, 3.83321315e-01f, -6.72203541e-01f, -2.39813447e-01f,
  3.52411330e-01f, 2.26125807e-01f, 1.93409175e-01f, -3.11377756e-02f, -7.98737586e-01f, 3.96511734e-01f, -7.41144419e-01f, -5.79577573e-02f, 6.28343701e-01f, -9.78988409e-01f,
  8.39213669e-01f, -4.70253527e-01f, 3.66924293e-02f, -7.77859807e-01f, -6.00050628e-01f, 7.29873538e-01f, -1.65529326e-01f, 7.54793882e-02f, -5.70163369e-01f, -1.15294909e+00f,
  9.48326349e-01f, 4.35034707e-02f, 1.24502741e-01f, -7.88512111e-01f, 7.80903995e-01f, -8.64511430e-01f, -3.46886627e-02f, -2.29336053e-01f, 7.75558829e-01f, 1.66728914e-01f,
  -1.84419200e-01f, -9.93424714e-01f, -3.01379383e-01f, -5.22278845e-02f, -5.90781093e-01f, 5.24973631e-01f, 2.64398247e-01f, -5.64771950e-01f, -8.01707268e-01f, 4.27107662e-01f,
  6.31644070e-01f, -5.19863367e-01f, -6.67130589e-01f, 5.74350715e-01f, 3.35100234e-01f, -4.75615859e-01f, -4.77818847e-01f, -6.03208601e-01f, -6.20683610e-01f, -1.87715441e-02f,
  -6.58499300e-01f, -5.94853878e-01f, -5.41133702e-01f, 4.88218635e-01f, 2.05900118e-01f, 4.68312442e-01f, -3.33428830e-01f, -1.56808472e+00f, -4.27577376e-01f, 6.28563941e-01f,
  -4.27334398e-01f, -2.56160162e-02f, -5.69719017e-01f, 3.61217856e-01f, 2.91981697e-01f, 6.29690528e-01f, 4.10741270e-01f, 1.17361033e+00f, -1.11545908e+00f, 5.87475896e-01f,
  -1.31447601e+00f, -4.94587749e-01f, -1.00108624e-01f, -5.84494710e-01f, 7.35168979e-02f, -1.04420769e+00f, 4.01628852e-01f, 9.45868134e-01f, 8.08611512e-01f, -1.24739695e+00f,
  8.00162077e-01f, -5.56886017e-01f, 5.09475768e-01f, 3.80854338e-01f, 7.26418495e-01f, -2.77954161e-01f, 6.37638450e-01f, 5.07544875e-01f, -6.23825312e-01f, -5.88794015e-02f,
  -6.61339700e-01f, 5.41020989e-01f, -1.44839370e+00f, -9.52184141e-01f, -9.35475230e-01f, -9.25740421e-01f, 4.20727819e-01f, -4.43191603e-02f, 8.42523053e-02f, 7.11177737e-02f,
  2.78222650e-01f, 3.89179170e-01f, -9.85812992e-02f, -7.59330034e-01f, 4.36031431e-01f, 3.48391294e-01f, 6.97353899e-01f, 6.14171624e-01f, -1.21024263e+00f, 9.49119031e-02f,
  -9.87545788e-01f, -8.85405481e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -5.29458858e-02f, 3.19590718e-01f, -2.27674603e-01f, -1.94394574e-01f, 1.56036645e-01f, 1.30218387e-01f, -3.37080032e-01f, -2.95282528e-02f, -4.87062544e-01f, 4.77873117e-01f,
  3.32403839e-01f, -1.24501616e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    