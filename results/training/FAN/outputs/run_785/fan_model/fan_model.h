/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.95905328e-01f, 9.93639827e-02f, -1.72430694e-01f, 4.02782997e-03f, -1.70333505e-01f, 4.74616475e-02f, 4.44566041e-01f, 1.84081078e-01f, 4.93821427e-02f, 2.16749102e-01f,
  -4.40642357e-01f, -2.84973472e-01f, -2.01742813e-01f, -6.01742044e-02f, 3.15604806e-02f, 3.58371824e-01f, 3.43714923e-01f, -6.05083071e-03f, 3.15895453e-02f, -2.87406240e-02f,
  1.54875115e-01f, 1.34234875e-02f, -6.64879605e-02f, -7.72174820e-02f, 2.31620327e-01f, 1.19833939e-01f, -2.32959427e-02f, -4.53542806e-02f, -1.32937118e-01f, 4.70580280e-01f,
  -1.63781956e-01f, -7.32993707e-02f, -4.05832343e-02f, -1.90925822e-01f, -1.52115434e-01f, 1.29898399e-01f, 7.52102137e-02f, -3.98595398e-03f, -5.66019900e-02f, 8.67319331e-02f,
  -1.15117453e-01f, -8.93088207e-02f, -8.64338055e-02f, -5.22096008e-02f, 5.60518913e-03f, 6.43790290e-02f, 5.83033524e-02f, -8.23678821e-03f, 7.75175020e-02f, 5.04803173e-02f,
  -5.96560761e-02f, -2.33468920e-01f, -1.52930707e-01f, -3.39543633e-02f, -9.19180736e-02f, -1.50567263e-01f, -8.18444937e-02f, 5.46441297e-04f, -4.62700799e-02f, 2.83215821e-01f,
  1.22314114e-02f, -3.27081047e-02f, 3.35974991e-02f, -3.59037332e-02f, 8.40718746e-02f, -2.07321104e-02f, 2.86167748e-02f, -3.11400276e-02f, 5.31545356e-02f, 3.09684370e-02f,
  -2.72088293e-02f, 9.66814533e-03f, 2.79926360e-02f, -1.76934022e-02f, -1.62968729e-02f, 1.06475744e-02f, 3.97682674e-02f, 5.49399294e-02f, -1.30505025e-01f, 5.74041493e-02f,
  -1.33590761e-03f, 2.65644807e-02f, -6.97757909e-03f, -1.17012416e-03f, -5.94358705e-03f, -1.44136371e-02f, -1.15841525e-02f, -3.08234561e-02f, -3.83195607e-03f, -1.38104870e-03f,
  7.28441775e-02f, -2.50303596e-01f, 8.80113989e-02f, 7.37421289e-02f, -5.90462573e-02f, -9.51355398e-02f, -7.18779191e-02f, -8.05048645e-02f, -8.93500596e-02f, -5.41774929e-03f,
  -5.47385179e-02f, 3.16583253e-02f, 1.44811173e-03f, 4.20181900e-02f, 3.91658545e-02f, 1.29661253e-02f, -6.62477612e-02f, 5.96460246e-04f, -5.26089408e-02f, 3.07181738e-02f,
  5.03192544e-02f, 1.73970968e-01f, 1.53397352e-01f, 8.45465511e-02f, 6.25927150e-02f, 6.33389652e-02f, 1.39931932e-01f, 1.37974709e-01f, 9.09984708e-02f, 3.81497145e-01f,
  -3.78507301e-02f, -8.78224075e-02f, 1.11672590e-02f, -1.03828661e-01f, -1.78850964e-01f, 1.32514924e-01f, 1.53811917e-01f, 1.33038834e-01f, 4.00646813e-02f, -1.42338052e-01f,
  1.01696350e-01f, -3.88568081e-02f, 4.52588834e-02f, 1.25948593e-01f, 2.39459187e-01f, 2.66307238e-02f, 5.97156696e-02f, -5.62931038e-03f, 2.13861421e-01f, 1.44353649e-02f,
  -6.56481236e-02f, -1.24328882e-01f, 2.24266257e-02f, 8.04552995e-03f, -4.01378393e-01f, -8.24153647e-02f, -1.67118236e-01f, -3.26707542e-01f, -1.55514687e-01f, -6.03013694e-01f,
  -1.31343514e-01f, -1.58095062e-01f, 1.63470134e-01f, 5.31337149e-02f, -1.75982296e-01f, 1.55429924e-02f, -1.57222506e-02f, -6.67077526e-02f, -1.23624442e-04f, 1.98276062e-03f,
  -3.92792746e-02f, -3.15539949e-02f, -1.54638253e-02f, -1.69532206e-02f, -1.54388808e-02f, 3.26244310e-02f, 1.48477769e-02f, 2.61969082e-02f, -8.77511315e-03f, 1.05562232e-01f,
  -7.70560876e-02f, -7.67863169e-02f, -1.82702601e-01f, 1.24301486e-01f, -2.74697971e-02f, 8.41680821e-03f, -1.05931751e-01f, -1.75191060e-01f, 1.48191229e-02f, -4.69386220e-01f,
  -1.59023132e-03f, -5.43768778e-02f, -2.66466439e-02f, 2.85804383e-02f, -1.56152025e-02f, 1.53766694e-02f, -9.63789318e-03f, 7.23576546e-02f, -3.34274992e-02f, -6.54017329e-02f,
  5.93474098e-02f, 4.86735925e-02f, 9.33347940e-02f, -8.47691521e-02f, -3.47036943e-02f, -2.75097806e-02f, 3.17700692e-02f, -3.73402424e-02f, 2.21419316e-02f, 4.19403613e-02f,
  4.97325584e-02f, -3.15484814e-02f, -6.49988651e-02f, 2.65309005e-03f, -3.60875949e-02f, 4.30655889e-02f, 1.54126692e-03f, 7.12932497e-02f, 4.07327339e-03f, -4.44705412e-02f,
  1.50524201e-02f, 3.53077531e-01f, -1.50692239e-01f, -2.11220072e-03f, 1.47348177e-03f, -3.58017497e-02f, 2.55038515e-02f, 4.88200635e-02f, 3.53748468e-03f, 7.80826285e-02f,
  -9.13335662e-03f, 5.29340394e-02f, -7.04087550e-03f, 1.94747467e-02f, 7.57714733e-02f, -8.65146704e-03f, 2.16275640e-02f, -1.27630867e-03f, 5.96148521e-02f, -1.13702819e-01f,
  5.92642054e-02f, -1.01266243e-01f, -3.93586718e-02f, 5.56230433e-02f, -1.36121232e-02f, 6.06074110e-02f, -3.05194855e-02f, -7.04244748e-02f, 1.43578082e-01f, -1.04558162e-01f,
  5.72913527e-01f, -7.16646612e-02f, -2.93755740e-01f, 8.03754479e-02f, -4.02732313e-01f, -1.61358044e-01f, -1.71724379e-01f, 3.41583550e-01f, 1.03890419e-01f, -3.58036794e-02f,
  -1.63916484e-01f, 1.09326318e-01f, 2.89645970e-01f, 2.45119408e-01f, 4.57893342e-01f, 1.95048898e-02f, -1.33573472e-01f, 1.18445046e-01f, 1.47061124e-01f, -3.29733901e-02f,
  -2.17482194e-01f, -8.16300213e-02f, 1.52931049e-01f, 3.19020152e-02f, -1.56406969e-01f, 1.43228276e-02f, -5.36620468e-02f, -2.04424247e-01f, -6.73435777e-02f, -2.52141178e-01f,
  -1.89090684e-01f, -3.13669220e-02f, 1.09495379e-01f, -1.73449013e-02f, -1.72522560e-01f, 1.08690970e-01f, 2.71294266e-02f, -7.15908129e-04f, -4.34612893e-02f, 2.81950422e-02f,
  -1.32776797e-01f, -6.22698702e-02f, -3.65605094e-02f, -3.99635695e-02f, 3.04313540e-03f, 8.45606497e-04f, 1.01029664e-01f, 7.21554458e-02f, 1.20035835e-01f, 4.15070578e-02f,
  -2.10266203e-01f, -3.71617585e-01f, -8.98056924e-02f, 4.82052937e-02f, 1.56856418e-01f, -1.13356195e-01f, -1.20362945e-01f, -7.54501596e-02f, -6.60609752e-02f, -3.61609273e-02f,
  -1.95539612e-02f, -8.08805693e-03f, -7.20606521e-02f, -1.37546482e-02f, -1.60317570e-02f, 4.69222330e-02f, -4.26265597e-02f, -3.67450118e-02f, 2.98879966e-02f, -2.05753352e-02f,
  4.35351729e-02f, -4.68921140e-02f, 5.02267526e-03f, 5.45058325e-02f, 1.72950290e-02f, -5.33710048e-02f, -4.37099300e-02f, -3.05697303e-02f, 5.67396842e-02f, 1.30170332e-02f,
  4.45041284e-02f, 8.30705930e-03f, -2.71298084e-02f, 1.94007698e-02f, 8.69616214e-03f, -1.34693859e-02f, -2.00049058e-02f, -2.81170662e-02f, 6.11713342e-02f, -6.15986176e-02f,
  3.45008373e-01f, 1.70809254e-01f, 1.23477004e-01f, 7.91123882e-02f, -1.01072285e-02f, 8.19342770e-03f, 8.21266585e-05f, 2.79920362e-02f, -7.55863786e-02f, 4.26265188e-02f,
  7.00680465e-02f, 9.95334834e-02f, 1.75393019e-02f, 4.88187186e-02f, 2.16188487e-02f, 6.42563924e-02f, 1.14536360e-02f, 1.32095572e-02f, 3.68107669e-02f, -1.01229571e-01f,
  1.03094429e-01f, 8.59972090e-02f, 1.63856834e-01f, 1.13290504e-01f, 9.64323953e-02f, 1.04843765e-01f, 8.66364390e-02f, -8.86476226e-03f, 1.83485076e-01f, 2.77014226e-01f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.83478290e-01f, -3.73919457e-01f, -6.63139462e-01f, 9.98790958e-04f, -2.27481008e-01f, -2.67453611e-01f, -3.99416357e-01f, -3.22742984e-02f, 1.01010628e-01f, -3.15578371e-01f,
  -1.23841912e-01f, 1.78823173e-01f, 3.80284712e-02f, -6.75860792e-02f, 9.06501263e-02f, -5.23065567e-01f, -4.78872210e-01f, -1.96013600e-01f, 4.36994173e-02f, 6.74970448e-02f,
  1.73356794e-02f, -2.96420902e-02f, 3.39218341e-02f, 1.22054555e-01f, -1.85621515e-01f, -3.31000574e-02f, -4.74644572e-01f, -2.36122608e-01f, -1.33421123e-01f, -4.14314687e-01f,
  -3.16087931e-01f, -5.30730821e-02f, 5.62442131e-02f, 1.11331590e-01f, -2.14838892e-01f, 5.89987449e-02f, -1.23954955e-02f, -5.74612059e-02f, 3.25745940e-02f, -7.77197117e-03f,
  2.05273833e-03f, 2.43889391e-02f, 9.78847742e-02f, -1.70885760e-03f, 2.36532930e-02f, 9.52895880e-02f, -2.52739731e-02f, 4.20778356e-02f, -1.23883411e-02f, -7.52034737e-03f,
  8.07038136e-03f, 5.05959615e-03f, 2.26036757e-02f, -2.89158579e-02f, 1.71798617e-01f, 3.87941971e-02f, 1.86031368e-02f, 1.39830589e-01f, -2.80943252e-02f, -1.47776246e-01f,
  -5.73275089e-02f, -2.24292721e-03f, 6.81087226e-02f, 4.55851927e-02f, 5.72088249e-02f, 7.67692691e-03f, -5.57799749e-02f, -5.78344129e-02f, 6.99802488e-03f, 4.18002158e-02f,
  -3.52110639e-02f, -6.29867464e-02f, -4.51197773e-02f, 2.10761111e-02f, -4.77211699e-02f, -1.22994911e-02f, 8.89580250e-02f, -2.40015909e-02f, 2.40710229e-02f, 7.09611690e-03f,
  2.52786744e-02f, 1.50964514e-03f, -8.81922618e-03f, 3.16754431e-02f, -1.11270212e-02f, -9.31529850e-02f, 8.42932910e-02f, 1.22010045e-01f, 1.98643282e-02f, 6.77374378e-02f,
  1.43345490e-01f, -1.93479821e-01f, -2.04827338e-02f, 7.61911198e-02f, -2.12074593e-02f, 4.56306040e-02f, 2.93968935e-02f, 8.77034813e-02f, -2.09753793e-02f, -5.58161065e-02f,
  3.35488133e-02f, 5.36048934e-02f, -2.54314765e-02f, 6.47837669e-03f, 5.26901660e-03f, 1.72714014e-02f, 2.32618526e-02f, -6.54308572e-02f, 3.68816368e-02f, 2.21804809e-02f,
  6.21463433e-02f, 2.43440643e-02f, 1.96189985e-01f, 1.48000510e-03f, 9.56971347e-02f, 5.32703400e-02f, -6.83851726e-03f, 4.28466219e-03f, 1.22142099e-01f, -3.96185145e-02f,
  1.08795106e+00f, 3.90659273e-02f, 3.53195012e-01f, 2.30023786e-01f, 4.30587947e-01f, 5.34384549e-01f, 5.54935873e-01f, 3.03610146e-01f, 1.30377531e-01f, 1.14851892e-01f,
  -8.88765007e-02f, -1.81779921e-01f, -2.67466277e-01f, -1.51861966e-01f, 5.73692657e-02f, 6.48543313e-02f, -2.48251352e-02f, 1.07975066e-01f, 2.23674431e-01f, 1.74047768e-01f,
  -1.43358737e-01f, 7.60389045e-02f, 7.38910511e-02f, 5.37195951e-02f, -2.51367092e-01f, -2.47868448e-01f, -2.57467311e-02f, 2.41571926e-02f, -2.72254109e-01f, -3.70649904e-01f,
  -2.73062401e-02f, 4.47114974e-01f, -9.12902877e-02f, -1.99079886e-01f, -4.57457639e-02f, -5.29723428e-03f, 7.48482943e-02f, -5.08275181e-02f, -5.50262630e-02f, -1.51827680e-02f,
  -1.54135033e-01f, -1.19045854e-01f, -8.93656611e-02f, -1.25781670e-01f, 9.67479572e-02f, 6.07655384e-02f, -1.75704919e-02f, 4.97393459e-02f, -4.00415733e-02f, -1.14169769e-01f,
  -2.92593658e-01f, 6.60088882e-02f, 2.86832422e-01f, 1.01895317e-01f, 1.04418881e-02f, -4.04113531e-03f, 3.90636101e-02f, 5.17571680e-02f, 1.22834578e-01f, 1.36483628e-02f,
  -3.06141339e-02f, 1.08064890e-01f, 7.48501793e-02f, -1.25055970e-03f, -1.09353662e-02f, -1.53005321e-03f, -6.49704272e-03f, 2.23305859e-02f, 9.73426402e-02f, 2.42121983e-02f,
  -8.07697177e-02f, 6.82070777e-02f, -3.50273736e-02f, 1.04146756e-01f, -1.51358381e-01f, 5.18515054e-03f, -9.24660242e-04f, -1.24417823e-02f, -2.61365958e-02f, 4.84710895e-02f,
  -6.03851955e-03f, 3.48650701e-02f, -3.41676809e-02f, -1.03582919e-01f, -7.13686692e-03f, -1.59697048e-02f, -1.28717078e-02f, -7.74364024e-02f, -2.16160975e-02f, 8.23541880e-02f,
  -3.58915627e-01f, 1.97112024e-01f, -1.17342241e-01f, -1.38533890e-01f, 8.22793599e-03f, -1.69776499e-01f, -8.64651520e-03f, -1.05110757e-01f, -1.16051048e-01f, -1.74822267e-02f,
  -2.16240063e-02f, 7.67121837e-02f, 3.38409506e-02f, 5.50915580e-03f, 3.62123959e-02f, -4.71305549e-02f, -9.15558115e-02f, 9.61801931e-02f, -3.53324823e-02f, -7.71948472e-02f,
  -7.18239546e-02f, 9.64886323e-02f, 3.07258338e-01f, 8.61261785e-02f, -8.90284777e-02f, 1.12821899e-01f, 8.88352096e-02f, -4.72075902e-02f, 2.71225482e-01f, 1.56395689e-01f,
  -6.60953522e-02f, 2.85900440e-02f, -4.40368243e-02f, 8.96286070e-02f, 1.32211983e-01f, 2.08609290e-02f, -1.82261690e-01f, -1.05830856e-01f, 9.50045288e-02f, 5.82652390e-02f,
  1.66755110e-01f, 7.64296204e-02f, 1.19518235e-01f, -4.60688025e-02f, -2.07088832e-02f, -9.47431177e-02f, -1.62231196e-02f, 7.41646662e-02f, -4.79187705e-02f, 5.80228446e-03f,
  2.35275045e-01f, 1.61331490e-01f, 8.27306323e-03f, 1.86211336e-02f, 9.30989906e-02f, 1.55715823e-01f, 1.04787953e-01f, 1.01137191e-01f, 9.60527286e-02f, 2.30138853e-01f,
  5.11304326e-02f, 4.45912145e-02f, 6.77882433e-02f, 1.40390396e-01f, 2.95534693e-02f, 1.17358282e-01f, 1.20651640e-01f, 7.47319907e-02f, 8.16368684e-02f, 8.86417627e-02f,
  6.81233034e-02f, 7.34439418e-02f, 3.88895795e-02f, 8.68569687e-02f, 5.09407520e-02f, 5.23907170e-02f, -7.34592155e-02f, -8.17838311e-02f, 1.05650224e-01f, 8.93466547e-03f,
  2.19383702e-01f, 1.64427161e-01f, 2.80904192e-02f, 2.07972210e-02f, 2.95395683e-02f, 8.09456129e-03f, 1.01641685e-01f, -1.60711352e-02f, -9.54573043e-03f, 1.45136625e-01f,
  -1.24348467e-02f, -5.95588498e-02f, -4.31882516e-02f, 4.21737544e-02f, 2.50047445e-02f, -8.94323885e-02f, -2.14922186e-02f, -9.45689976e-02f, -5.21859452e-02f, -1.01060189e-01f,
  -7.73214623e-02f, 4.48992997e-02f, -1.52089121e-02f, 6.37611523e-02f, -2.06644591e-02f, 9.14985285e-05f, 7.95580596e-02f, 2.37726588e-02f, 6.33806735e-02f, -3.73031944e-02f,
  5.84604889e-02f, -1.86952651e-02f, 3.92616075e-03f, -1.98617876e-02f, 1.63673759e-02f, 1.99784227e-02f, 8.13732296e-02f, -1.77391320e-02f, 3.01921163e-02f, 8.34541172e-02f,
  7.97903985e-02f, -1.24807939e-01f, 8.99645910e-02f, 2.29061861e-02f, -2.15060748e-02f, 4.19623172e-03f, 2.25680396e-02f, 7.98423141e-02f, 7.29613975e-02f, 6.96804598e-02f,
  1.15136914e-01f, 3.42217088e-02f, -6.56484962e-02f, -2.89593693e-02f, -4.64656577e-02f, 8.62288103e-02f, -3.72650586e-02f, -4.13449481e-02f, 8.77065584e-03f, 4.63253222e-02f,
  -1.55770814e-03f, -6.05331361e-03f, -8.48629698e-02f, -1.62511580e-02f, -1.01067871e-01f, 1.00719161e-01f, 4.31115478e-02f, -5.15076742e-02f, -1.03757530e-01f, 1.81565946e-03f,
  6.81741595e-01f, 3.04968566e-01f, 3.42010491e-04f, 4.95422669e-02f, -1.98077574e-01f, -2.01257229e-01f, -1.40380979e-01f, -9.89712253e-02f, -5.94344828e-03f, 6.82631284e-02f,
  -7.09441304e-02f, -1.07888296e-01f, -4.57226448e-02f, -1.55736152e-02f, 2.30349153e-02f, 1.18446141e-01f, -7.58927092e-02f, 1.66537929e-02f, 4.30482365e-02f, 2.03475635e-02f,
  5.72191589e-02f, -1.93051323e-02f, 9.54684913e-02f, 7.37328976e-02f, 2.48570040e-01f, 5.70720099e-02f, 2.01671384e-02f, 1.24167949e-01f, 1.53100520e-01f, 2.98255712e-01f,
  2.09778339e-01f, 3.15769255e-01f, -1.31610990e-01f, 6.76419586e-02f, -1.01822400e-02f, 7.26902708e-02f, 6.29134104e-02f, -2.75105368e-02f, -3.86717403e-03f, -9.93986521e-03f,
  -2.40529012e-02f, 9.89333019e-02f, -2.77546719e-02f, 3.37899886e-02f, -2.04192824e-03f, -1.52242938e-02f, 5.61776347e-02f, 1.18126445e-01f, -1.02390200e-02f, 6.54262975e-02f,
  -4.69732285e-02f, 4.05683480e-02f, 1.34916633e-01f, -7.96634778e-02f, 3.63936946e-02f, 1.54375937e-02f, 7.49883205e-02f, 1.30708039e-01f, 5.70306070e-02f, 2.98524261e-01f,
  -8.35460871e-02f, 7.61708990e-02f, 1.12684339e-01f, 1.34543339e-02f, 2.72611585e-02f, 8.38277861e-03f, 1.34540284e-02f, -7.28288258e-04f, -7.13577792e-02f, 2.16040593e-02f,
  -9.76300463e-02f, -2.07493603e-02f, 4.14523184e-02f, -5.99021614e-02f, 3.35329548e-02f, -7.41725489e-02f, 1.77131891e-02f, -2.51134820e-02f, -6.87514618e-02f, 1.62581708e-02f,
  1.52136469e-02f, -2.04477739e-02f, -1.50774360e-01f, 7.32624009e-02f, 9.76193324e-03f, 5.87600730e-02f, -2.52013169e-02f, 3.98466028e-02f, -8.61740857e-02f, 6.22305796e-02f,
  -2.10362047e-01f, -2.02874303e-01f, 7.49393925e-02f, 1.07079722e-01f, 1.40930908e-02f, -5.06253317e-02f, 7.27022439e-02f, 9.98768136e-02f, -3.98431830e-02f, 6.49369061e-02f,
  7.97875896e-02f, -4.52749021e-02f, -4.66271900e-02f, 1.14511168e-02f, -6.98901862e-02f, -3.58875766e-02f, 3.93984020e-02f, -1.80914104e-02f, 1.35391513e-02f, 4.54023108e-02f,
  -4.57876064e-02f, -1.49278671e-01f, -1.49662718e-01f, -1.60603791e-01f, 1.41043672e-02f, -8.66667703e-02f, -1.21686660e-01f, 2.62592435e-02f, -1.90643117e-01f, -1.90518454e-01f,
  2.14809865e-01f, -2.08061203e-01f, -3.07939798e-01f, 4.01902432e-03f, 2.33623311e-02f, 3.56436633e-02f, -1.55104278e-02f, 2.04538405e-01f, -7.54024228e-03f, -7.95961395e-02f,
  6.64261132e-02f, 9.21733379e-02f, -1.35974055e-02f, 6.18356317e-02f, -7.59559125e-02f, -3.50848138e-01f, -3.45290959e-01f, -2.22117424e-01f, 1.50721297e-01f, 3.04523855e-01f,
  2.52069347e-03f, -4.87104710e-03f, 4.09299321e-02f, 5.84752262e-02f, -9.83053520e-02f, -8.17330182e-02f, -3.04021060e-01f, -1.63548440e-01f, -7.02872053e-02f, -3.70757997e-01f,
  -4.24604416e-02f, 5.15074953e-02f, 5.91755770e-02f, -7.63493925e-02f, 2.15074364e-02f, 5.15052415e-02f, -6.83219265e-03f, -2.67554019e-02f, 3.64264809e-02f, -5.74551970e-02f,
  9.10567027e-03f, 1.04437985e-01f, -4.30311747e-02f, -6.66427463e-02f, 5.95433936e-02f, -7.39438385e-02f, -1.82567224e-01f, -1.68169409e-01f, -1.42862782e-01f, -3.73462811e-02f,
  -9.85296518e-02f, -8.08278471e-02f, 4.47457433e-02f, 4.08891588e-02f, -3.16196755e-02f, -1.16333999e-01f, -3.83839756e-02f, 4.10444029e-02f, 4.92822379e-02f, -7.65907988e-02f,
  -3.01267244e-02f, -5.07289656e-02f, 9.34066658e-04f, -2.19387338e-02f, 1.03436276e-01f, -6.25703856e-02f, 4.76393737e-02f, 8.59410241e-02f, 4.37776670e-02f, -1.00556150e-01f,
  3.93230356e-02f, 2.45369207e-02f, -1.25172990e-03f, 5.84357008e-02f, -8.35383981e-02f, -7.10533038e-02f, -9.17214826e-02f, -3.85235064e-03f, -6.62445426e-02f, -9.19463187e-02f,
  7.08065331e-02f, 8.55848044e-02f, -5.86722344e-02f, -7.41804671e-03f, -7.09006935e-02f, -1.16447873e-01f, -4.94045615e-02f, -5.57066947e-02f, -3.09475251e-02f, -1.27187341e-01f,
  3.12722325e-02f, -8.24175775e-02f, -4.60383855e-02f, 1.17341913e-01f, -4.14277054e-02f, -5.77301160e-02f, 2.75546461e-02f, -7.03528747e-02f, -6.50736317e-03f, 1.03592284e-01f,
  3.49927917e-02f, 1.01407431e-01f, -2.27217097e-02f, 4.88961637e-02f, 4.80889939e-02f, 7.34696835e-02f, -9.57566425e-02f, 7.38662155e-03f, -3.00384946e-02f, 2.42451355e-02f,
  -1.21930510e-01f, -5.43090217e-02f, -8.17019418e-02f, -9.98078138e-02f, -7.76799321e-02f, 4.96933097e-03f, -3.26559134e-02f, -1.17548741e-02f, -2.34668124e-02f, -2.75859416e-01f,
  -1.58031285e-01f, 3.52195054e-01f, -2.70325560e-02f, 3.32735062e-01f, 3.59045327e-01f, 3.37086439e-01f, 5.71680009e-01f, 2.69779354e-01f, 4.15134095e-02f, 2.00336620e-01f,
  1.50688529e-01f, 1.43014729e-01f, 8.52415264e-02f, 1.09783106e-01f, 5.16062938e-02f, 3.38014334e-01f, 1.52710304e-01f, -3.10559068e-02f, -1.77792698e-01f, 5.02189212e-02f,
  2.05135882e-01f, 5.04400246e-02f, -2.90752739e-01f, -9.14759263e-02f, 2.63437450e-01f, 1.00446858e-01f, -4.74571064e-02f, 2.65638512e-02f, 1.40427321e-01f, 3.07842433e-01f,
  5.09956852e-02f, 1.20545164e-01f, -1.59834668e-01f, -1.96206961e-02f, -3.59717757e-02f, -2.30515197e-01f, -1.11985896e-02f, -3.02520305e-01f, -3.36775109e-02f, -1.54147089e-01f,
  4.37483713e-02f, -8.70391950e-02f, 9.13069770e-02f, -6.89848885e-02f, -5.79734892e-02f, -1.07534833e-01f, -1.33465603e-03f, -1.27560377e-01f, -7.49358907e-02f, 1.36249959e-02f,
  3.09972346e-01f, 4.66741696e-02f, 2.26050168e-02f, 9.56856385e-02f, -2.27392782e-02f, -4.49487604e-02f, -3.17625292e-02f, 6.24708720e-02f, -1.44770786e-01f, -4.60955165e-02f,
  5.87833533e-03f, 6.81980476e-02f, -5.33721000e-02f, 1.23736141e-02f, 8.85861591e-02f, 1.99581087e-02f, 5.62671609e-02f, 4.25615497e-02f, 6.94478452e-02f, -1.12682596e-01f,
  -5.08279365e-04f, 2.90406086e-02f, -7.12387264e-02f, -1.22108636e-02f, 7.98208341e-02f, -3.52237523e-02f, 9.91019681e-02f, 2.90252808e-02f, -4.52743359e-02f, -2.82301977e-02f,
  8.46692547e-03f, -4.16386835e-02f, -4.29210328e-02f, 1.16093442e-01f, 6.44436013e-03f, 9.86397192e-02f, -3.49569134e-02f, -2.94562103e-03f, -1.18379798e-02f, -9.07649174e-02f,
  -2.47782841e-01f, -9.12980512e-02f, 1.19186252e-01f, -2.73038261e-02f, -1.26683395e-02f, -6.26358762e-02f, 6.23741895e-02f, -5.73234819e-02f, -5.71253337e-02f, -2.18830351e-03f,
  -6.37660623e-02f, -6.76605701e-02f, 2.00156644e-02f, -1.17342904e-01f, -3.70613001e-02f, -1.93387587e-02f, 2.15790998e-02f, -4.95133139e-02f, -4.82310839e-02f, -1.09963961e-01f,
  2.06984002e-02f, -1.15577906e-01f, -2.56358176e-01f, -1.35413960e-01f, 4.20223735e-03f, -8.05082470e-02f, -7.89994746e-02f, -1.76771969e-01f, -2.15484172e-01f, -1.72254354e-01f,
  -2.60678679e-01f, 1.43282026e-01f, 6.04600497e-02f, -1.62554100e-01f, -1.47546068e-01f, -2.41535589e-01f, -1.91504788e-02f, -3.61146964e-02f, -1.06667385e-01f, 7.09633604e-02f,
  3.87260579e-02f, 1.00019850e-01f, 1.93721429e-01f, 4.59460681e-03f, 3.67066413e-02f, 1.43614011e-02f, 4.08784719e-03f, -1.09556757e-01f, -3.72585803e-02f, 9.10565164e-03f,
  7.49494415e-03f, 1.65204838e-01f, -4.41407524e-02f, -4.19042185e-02f, -1.87551733e-02f, 8.62396434e-02f, -2.16804519e-02f, -9.63885710e-02f, -5.57920225e-02f, 1.90676525e-02f,
  3.69741261e-01f, -2.99414605e-01f, -2.92796511e-02f, 9.48845467e-04f, -4.67218794e-02f, -1.48909032e-01f, -4.90957052e-02f, -6.13930486e-02f, -5.68959713e-02f, 1.11988811e-02f,
  -2.32561585e-02f, 5.32487705e-02f, -2.38747690e-02f, -2.33287327e-02f, 3.73897739e-02f, -1.07127525e-01f, 1.36894928e-02f, -2.48945020e-02f, -2.19248943e-02f, -6.62859762e-03f,
  2.46183854e-02f, -6.70493171e-02f, -2.72414889e-02f, -1.18654706e-02f, -6.09013215e-02f, -3.37217860e-02f, -9.18571081e-04f, -1.45058393e-01f, -1.66489258e-01f, 6.20930009e-02f,
  -1.65145297e-03f, -7.28114787e-03f, -2.44057123e-02f, 3.41802873e-02f, 6.67014644e-02f, 2.37833671e-02f, 1.14747835e-02f, 1.38990730e-01f, 2.63145082e-02f, 8.89737234e-02f,
  3.30667272e-02f, 5.43565601e-02f, 8.37518945e-02f, 2.49468163e-02f, -2.03247722e-02f, -1.06472105e-01f, -1.80808231e-02f, 7.29098096e-02f, -1.68295782e-02f, -8.51698443e-02f,
  1.29172476e-02f, -4.12901379e-02f, 5.93502447e-02f, -4.18854728e-02f, -1.54837891e-01f, -1.03029475e-01f, -6.47762865e-02f, -1.63470525e-02f, 4.59773913e-02f, -4.90996912e-02f,
  4.80550796e-01f, -1.56841472e-01f, -5.45368623e-03f, -3.86619605e-02f, -3.44872251e-02f, -5.66418171e-02f, 6.95726424e-02f, -2.92552523e-02f, -3.27124596e-02f, 7.86704943e-02f,
  -2.55549024e-03f, -3.61713907e-03f, 5.63589036e-02f, 1.30606666e-01f, 7.95451030e-02f, 7.47693256e-02f, 7.42441462e-03f, 6.30590841e-02f, -2.68101320e-02f, 4.57196385e-02f,
  7.43670315e-02f, 1.91343836e-02f, 1.51339233e-01f, 5.88651448e-02f, 2.91788727e-02f, -1.67172961e-02f, 1.95682257e-01f, -2.94677932e-02f, 1.30398005e-01f, 3.30331534e-01f,
  -1.11725235e+00f, 3.07508614e-02f, 1.74225315e-01f, -5.74034512e-01f, -1.21716514e-01f, 1.40608400e-01f, 1.43986791e-01f, 3.22058015e-02f, -1.21397585e-01f, 9.79878679e-02f,
  3.49686071e-02f, -7.89537653e-02f, -8.41460451e-02f, -5.82292974e-02f, -4.80069816e-02f, 1.51824774e-02f, -2.88846999e-01f, -4.08804148e-01f, -1.69240400e-01f, -8.02584440e-02f,
  -8.99592191e-02f, -3.88931215e-01f, -4.76973027e-01f, -2.71985173e-01f, -1.59950629e-01f, -2.06049427e-01f, -1.24486595e-01f, -2.34551325e-01f, -9.30984467e-02f, -2.37775221e-01f,
  3.05824876e-01f, -2.39109531e-01f, -4.43477705e-02f, -2.70179898e-01f, 2.30755638e-02f, 1.55128855e-02f, 2.59015150e-02f, -2.17657760e-02f, 1.86635572e-02f, 4.79782326e-03f,
  -6.62297383e-02f, -2.36031935e-02f, -7.79759958e-02f, 2.03402583e-02f, -1.11083843e-01f, -1.66639948e-04f, 5.12768477e-02f, -9.46136490e-02f, -1.70546528e-02f, 2.55924970e-01f,
  1.10181585e-01f, -1.03031412e-01f, -3.11705340e-02f, 1.33596852e-01f, 2.07987055e-01f, -9.07407627e-02f, 6.83741122e-02f, 9.53907296e-02f, 1.36953813e-03f, -5.92916794e-02f,
  3.43040749e-02f, 2.29704976e-02f, -6.46169437e-03f, -5.82514554e-02f, 6.16686232e-02f, -6.32428303e-02f, -9.39276814e-03f, -7.57331178e-02f, 1.28163695e-02f, -2.83795334e-02f,
  2.80803088e-02f, 9.43446532e-02f, -1.78317763e-02f, -6.87694475e-02f, 3.42677571e-02f, -2.15620436e-02f, -3.76997329e-02f, 8.42629522e-02f, -4.17920835e-02f, -5.16662821e-02f,
  -2.29500886e-02f, 3.98045070e-02f, 1.75807606e-02f, 3.35905179e-02f, -1.95570011e-02f, -2.02244613e-02f, 5.55843040e-02f, 4.51854244e-02f, 1.48820905e-02f, -5.93873439e-03f,
  1.75862070e-02f, -1.29000396e-01f, -6.74223751e-02f, 4.12333459e-02f, -8.34293291e-02f, 9.04316977e-02f, -6.03182912e-02f, 3.35056148e-02f, -1.38637861e-02f, 2.57140733e-02f,
  3.79421748e-02f, 1.57078803e-02f, 2.50350982e-02f, 6.34352937e-02f, -4.34975512e-02f, -3.43731083e-02f, 1.36613576e-02f, -1.68363094e-01f, 4.81674597e-02f, 1.69922099e-01f,
  1.43267691e-01f, -8.82620513e-02f, -1.62089154e-01f, 6.50948882e-02f, 2.75803581e-02f, -1.57102853e-01f, 8.78245682e-02f, 4.37705182e-02f, 3.82062350e-03f, 6.54753670e-02f,
  3.41684788e-01f, 4.89191204e-01f, 4.82779533e-01f, -2.71154463e-01f, -1.26191139e-01f, 8.13448429e-02f, 3.92955393e-01f, 4.68802266e-02f, -2.93969959e-01f, 9.62620899e-02f,
  5.36539666e-02f, -3.27849507e-01f, -2.58430719e-01f, -6.30509034e-02f, 1.98213518e-01f, 1.81501970e-01f, 8.01352859e-02f, 7.49932462e-03f, 1.01421513e-02f, -2.82716639e-02f,
  -1.56860545e-01f, -1.27164692e-01f, -4.60390560e-03f, -1.23848272e-02f, -1.64521739e-01f, -2.25036934e-01f, 4.01562266e-02f, 9.13390443e-02f, 1.71788856e-01f, 3.63024548e-02f,
  2.77869493e-01f, 3.95275086e-01f, -2.37176821e-01f, -9.68256220e-02f, 2.27314304e-03f, -2.27787881e-03f, -4.58884332e-03f, 1.28654405e-01f, -1.56430081e-02f, 9.89303924e-03f,
  -3.72551270e-02f, 8.70747790e-02f, 6.50194287e-02f, 4.15912643e-03f, 1.21224567e-01f, -1.44698890e-02f, 9.96076688e-02f, 1.06461994e-01f, -7.70830736e-02f, 1.06964476e-01f,
  -8.47829953e-02f, 5.97639894e-03f, 1.10070303e-01f, -1.12981930e-01f, 1.16154596e-01f, -2.18215615e-01f, 1.42641068e-01f, 6.77438527e-02f, 1.08148828e-02f, 9.62534249e-02f,
  -9.03685391e-02f, -4.51563997e-03f, 1.62363425e-02f, -1.83783136e-02f, -3.15017551e-02f, -6.86171278e-02f, 7.07936212e-02f, -1.91013366e-02f, -2.65837219e-02f, 8.78901482e-02f,
  3.83563302e-02f, 1.12583935e-02f, 1.91975094e-03f, 5.56816608e-02f, -8.47401395e-02f, 4.58997041e-02f, 1.24954753e-01f, 1.23606762e-02f, 3.95453908e-02f, 5.77067360e-02f,
  1.42628588e-02f, 2.66733244e-02f, 4.91941953e-03f, -3.91970836e-02f, 3.94343212e-02f, -3.54776643e-02f, -1.26847420e-02f, -3.59503068e-02f, -6.00692034e-02f, -1.07502632e-01f,
  -3.44050288e-01f, -1.72905140e-02f, -7.96960294e-03f, 2.18710280e-03f, 6.32791072e-02f, -5.06017394e-02f, -4.94560152e-02f, 1.33029390e-02f, -1.58650242e-03f, 1.24601007e-01f,
  5.79822920e-02f, 2.12498140e-02f, 6.33251518e-02f, 8.78684446e-02f, -6.58226386e-02f, 4.29722518e-02f, -5.62276179e-03f, -4.44787443e-02f, -1.82525963e-02f, -4.10244288e-03f,
  -7.11925402e-02f, -1.16598755e-01f, -2.81443685e-01f, -1.42289817e-01f, -7.18688965e-02f, -3.09824258e-01f, -4.93950062e-02f, -1.13256760e-01f, -1.50361270e-01f, -3.19488287e-01f,
  3.31564754e-01f, 2.00758308e-01f, -4.82805610e-01f, 2.01729491e-01f, -2.79895127e-01f, -4.29812551e-01f, -3.45761389e-01f, -9.34248492e-02f, 1.65845931e-01f, 1.29213810e-01f,
  1.06910355e-02f, 2.54618973e-02f, 1.47823125e-01f, -2.64583707e-01f, -2.73741692e-01f, -3.00864100e-01f, -2.63453037e-01f, -4.79699582e-01f, -5.52693427e-01f, -4.94346172e-01f,
  -3.78990889e-01f, -7.46621117e-02f, -1.56341627e-01f, -8.19459185e-02f, 1.53984904e-01f, 1.83709681e-01f, 1.35970920e-01f, -3.29778567e-02f, -3.03050399e-01f, -9.24528539e-02f,
  -1.15155116e-01f, 3.24549600e-02f, -1.79588526e-01f, -7.50281960e-02f, 1.00190111e-01f, 6.34134263e-02f, -4.61494885e-02f, 1.32348806e-01f, 1.83794662e-01f, -4.07447629e-02f,
  6.31315112e-02f, -3.65319438e-02f, 6.34980798e-02f, -5.50979860e-02f, 1.03104282e-02f, -4.61255573e-02f, -4.00524735e-02f, -1.39111206e-01f, -4.82526310e-02f, -8.29852670e-02f,
  -4.56369445e-02f, -1.95075437e-01f, -1.58870667e-01f, -5.88236563e-02f, -5.51180169e-03f, -1.17478006e-01f, 1.99246816e-02f, 7.20748827e-02f, -9.00894180e-02f, 3.57602507e-01f,
  -5.68786226e-02f, 7.23063061e-03f, -5.07868491e-02f, 4.47089672e-02f, 1.16445377e-01f, 9.55831446e-03f, 2.43781321e-02f, 7.83581510e-02f, -5.57763688e-02f, 5.73347397e-02f,
  6.14832342e-02f, 5.03236875e-02f, 3.13878320e-02f, 5.62703190e-03f, 1.67138723e-03f, -3.48778740e-02f, -4.37757745e-02f, 6.37736404e-03f, -1.95743423e-02f, 1.82217676e-02f,
  -1.86735182e-03f, -4.79997359e-02f, 7.85554945e-02f, 2.87453141e-02f, -1.97783425e-01f, 2.11904570e-02f, -8.26231316e-02f, -5.16720563e-02f, 6.56654462e-02f, -1.09837867e-01f,
  5.20946860e-01f, -4.11107212e-01f, 1.35495707e-01f, 1.74177572e-01f, -2.33734027e-02f, 9.18906853e-02f, 1.08705007e-01f, 1.26736581e-01f, 1.18787162e-01f, 1.50976190e-02f,
  -1.08247176e-01f, 1.88834205e-01f, 1.44921154e-01f, -6.05243035e-02f, -7.91991726e-02f, -5.67824841e-02f, -1.88608421e-03f, 3.37755904e-02f, -9.40192863e-02f, 2.02861354e-02f,
  1.63413975e-02f, -3.20262201e-02f, 9.72952619e-02f, 1.54171035e-01f, 6.45368174e-02f, 2.75226161e-02f, -7.98734743e-03f, 1.15788296e-01f, -6.93865120e-02f, 3.65312427e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  -1.85658827e-01f, 6.39307678e-01f, -2.01619610e-01f, 4.36236802e-03f, -3.68939266e-02f, 3.41863751e-01f, 1.89861163e-01f, 4.97176915e-01f, 3.63327444e-01f, 4.17098761e-01f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -2.67381698e-01f, -2.98459470e-01f, 1.79481298e-01f, 3.07103563e-02f, -4.42427009e-01f, -4.00333703e-01f, -1.58588991e-01f, 3.54964435e-01f, 1.72292605e-01f, 2.18424454e-01f,
  2.71695834e-02f, -2.31515303e-01f, -2.14952260e-01f, -1.42649308e-01f, 3.05912554e-01f, -4.27663743e-01f, 4.32615042e-01f, -1.26957953e-01f, -3.28624845e-01f, -9.05307710e-01f,
  5.23889959e-01f, -2.29336899e-02f, 1.94082797e-01f, 2.06121638e-01f, -6.75008586e-03f, -4.18708771e-01f, 2.09436506e-01f, -5.68808708e-03f, -3.94747734e-01f, 4.88987565e-02f,
  -9.29847583e-02f, 2.92091500e-02f, -1.45262420e-01f, -4.32089306e-02f, 3.70556444e-01f, 1.12553263e+00f, -5.10920584e-01f, 4.69420552e-01f, -4.38881338e-01f, -1.17454536e-01f,
  -1.72949746e-01f, 3.06611478e-01f, -4.43184048e-01f, -4.54290863e-03f, -1.08072229e-01f, -1.58931792e-01f, -9.89665017e-02f, 5.49960554e-01f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  3.91301692e-01f, 3.22137535e-01f, -3.06452326e-02f, 6.10137761e-01f, -8.39477926e-02f, 3.71787488e-01f, -4.84618336e-01f, -3.34683448e-01f, -1.99966520e-01f, -1.04645610e-01f,
  -3.76069546e-01f, 8.38092864e-02f, 6.75119579e-01f, 1.05515373e+00f, 8.52689520e-02f, 1.21163398e-01f, -3.41041237e-01f, -2.96052009e-01f, -7.94690028e-02f, -2.42164418e-01f,
  3.08456838e-01f, 1.92685708e-01f, 9.86826718e-01f, 3.38334978e-01f, -8.02466366e-03f, 1.81737825e-01f, 6.36631072e-01f, 2.41120145e-01f, 9.37089976e-03f, 1.51676491e-01f,
  -2.37057194e-01f, 6.24457121e-01f, 3.57565552e-01f, -2.04729870e-01f, -6.92724586e-01f, -3.29299808e-01f, -3.17449093e-01f, -3.12094599e-01f, 4.21070680e-02f, 6.98464811e-01f,
  -3.61341953e-01f, 4.47515398e-01f, 2.21632168e-01f, 9.38297868e-01f, -2.46531114e-01f, -2.79149823e-02f, 6.72740281e-01f, 5.34680963e-01f, -3.18058968e-01f, 2.68719912e-01f,
  -8.38563815e-02f, 1.24760062e-01f, 1.55281082e-01f, -1.81697030e-03f, 2.93056577e-01f, 2.65395969e-01f, 1.63899884e-01f, -1.82438850e-01f, -1.72326997e-01f, 4.06240702e-01f,
  9.39677283e-02f, -8.97733197e-02f, -2.89151102e-01f, -1.23689845e-01f, -4.27981354e-02f, 3.93795103e-01f, 8.43200207e-01f, 1.27101347e-01f, 1.16936982e-01f, -2.14266106e-02f,
  -1.89741045e-01f, 1.12179577e+00f, -6.53659344e-01f, 5.89235649e-02f, -1.34570330e-01f, -3.36139530e-01f, -3.46440673e-01f, -1.66735724e-01f, 7.50250340e-01f, -5.69908202e-01f,
  5.31425960e-02f, -6.60658181e-01f, 2.12629974e-01f, 7.32550249e-02f, -1.55392125e-01f, -1.55009076e-01f, 1.78220719e-01f, 3.42456132e-01f, -1.19889379e-01f, 1.25460848e-01f,
  3.55228633e-01f, 4.54665869e-02f, -5.42249560e-01f, 1.29313433e+00f, 2.33198389e-01f, -2.96320409e-01f, -2.03980818e-01f, 4.85840172e-01f, -4.57865298e-01f, 6.53113067e-01f,
  3.21484596e-01f, -1.59388036e-01f, -1.35255724e-01f, -2.73045123e-01f, -1.80644393e-01f, -4.28415895e-01f, 1.27296105e-01f, 8.84444654e-01f, -1.95727199e-01f, -1.82737365e-01f,
  -4.14472401e-01f, -1.12062611e-01f, -2.74035245e-01f, 1.04441023e+00f, 4.72468525e-01f, 4.85281974e-01f, 3.43142837e-01f, -5.64729385e-02f, -6.41899824e-01f, 6.97769523e-01f,
  -8.91024545e-02f, -3.77789438e-01f, -4.20824498e-01f, -1.61402196e-01f, 7.00057149e-02f, 5.04397750e-01f, -1.02000274e-01f, 8.73815596e-01f, 5.30169070e-01f, 1.77003145e-01f,
  -6.03691697e-01f, 6.06684685e-01f, 5.91195226e-01f, 8.01049888e-01f, 7.70571768e-01f, 9.54631507e-01f, -2.11631581e-01f, -2.33950302e-01f, 2.01590762e-01f, 3.80342603e-01f,
  1.04827799e-01f, -4.97487843e-01f, -5.67376554e-01f, 5.11037529e-01f, 1.80280805e-02f, 2.24113062e-01f, 2.14365765e-01f, 3.66018802e-01f, -2.20470428e-01f, 2.20661238e-01f,
  -2.66687959e-01f, 2.44417354e-01f, -1.62650406e-01f, -2.64447570e-01f, -4.62349728e-02f, -3.74425232e-01f, 2.28542075e-01f, 2.94482172e-01f, -3.99296790e-01f, 7.69459546e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  7.14625837e-03f, -2.29712963e-01f, 4.52820420e-01f, -1.58357978e-01f, 4.84618545e-01f, -1.74082704e-02f, 1.22901954e-01f, 6.35210693e-01f, 3.00688505e-01f, 2.84909327e-02f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  -9.89995375e-02f, -2.87852854e-01f, -8.78732383e-01f, -1.11608110e-01f, -8.61145332e-02f, -9.02950093e-02f, -3.75187516e-01f, 1.04431117e+00f, -3.78935397e-01f, -1.64543927e-01f,
  5.12191132e-02f, 4.57084149e-01f, -2.31377445e-02f, -5.49470663e-01f, 1.78440720e-01f, 6.01247475e-02f, -5.74174941e-01f, -4.82797325e-01f, 4.82891947e-01f, -3.89553934e-01f,
  8.16166937e-01f, -5.59028387e-01f, -4.44517881e-01f, 4.62747961e-01f, 3.80175799e-01f, 3.09925020e-01f, -7.51429498e-02f, -4.41472292e-01f, -1.32550120e-01f, -4.11611795e-01f,
  1.16227007e+00f, -3.34304243e-01f, 1.32816696e+00f, 6.27968132e-01f, 8.86436224e-01f, -5.53142488e-01f, 5.43542564e-01f, -1.16600132e+00f, -6.79164054e-03f, -5.21727741e-01f,
  -9.28829253e-01f, 1.92726087e-02f, 7.14376032e-01f, -3.77740592e-01f, -2.72447497e-01f, 4.89369690e-01f, -4.18083131e-01f, -1.71219155e-01f, 3.22186440e-01f, -2.79843450e-01f,
  -6.04271889e-01f, -6.94626153e-01f, 5.50281465e-01f, -4.41165835e-01f, 5.68519056e-01f, -4.22050893e-01f, -1.88374687e-02f, -1.54008135e-01f, -8.74938592e-02f, 1.24647009e+00f,
  -8.12137127e-02f, -8.66267607e-02f, -5.78194320e-01f, -3.65071625e-01f, -4.27186042e-01f, -3.15266192e-01f, -3.60040456e-01f, -4.98291343e-01f, 3.74803901e-01f, -7.24508166e-01f,
  -1.14398092e-01f, 3.87761533e-01f, 5.24481237e-02f, 7.76125640e-02f, -4.18394297e-01f, 1.17032290e-01f, -3.69848520e-01f, 1.04091775e+00f, -4.79765743e-01f, 3.64700705e-01f,
  -9.73800793e-02f, 3.32218975e-01f, 4.55790102e-01f, -5.01615226e-01f, 3.88593316e-01f, 6.75359905e-01f, 1.33332849e-01f, 1.53265800e-02f, -1.83439493e-01f, -1.26590893e-01f,
  -5.27543783e-01f, -3.32652271e-01f, 3.80771309e-02f, 5.36638796e-01f, 1.12579691e+00f, 3.15134346e-01f, -9.20338482e-02f, -4.25346613e-01f, 2.08357908e-02f, 1.05938053e+00f,
  -1.02959621e+00f, 1.24119723e+00f, -7.75449723e-02f, -1.43128142e-01f, 6.15068674e-01f, -1.78050026e-01f, 7.70992756e-01f, -2.97002289e-02f, -5.42113423e-01f, -7.90677428e-01f,
  -6.91604555e-01f, -4.29575503e-01f, -3.59897465e-02f, -7.22771466e-01f, -6.69236556e-02f, 2.11835861e-01f, -4.54753935e-01f, 1.89290062e-01f, -7.94013217e-03f, 6.11807257e-02f,
  2.56065398e-01f, 6.38163209e-01f, -2.70426035e-01f, -2.99724996e-01f, 1.29317164e+00f, 2.64060289e-01f, 2.00933777e-02f, -2.66134799e-01f, 1.96784988e-01f, -3.36461067e-01f,
  -1.41618207e-01f, 3.80257815e-01f, -3.64156157e-01f, 9.02112842e-01f, -6.47024572e-01f, -3.62900198e-01f, -4.20028836e-01f, 2.40719438e-01f, 7.74359226e-01f, -2.40998164e-01f,
  1.79595947e-01f, 8.47270846e-01f, 3.51892978e-01f, 3.23874414e-01f, 1.08876514e+00f, 1.06877494e+00f, 1.06663132e+00f, 9.56132770e-01f, -6.48508132e-01f, 2.00266764e-02f,
  -3.56080383e-01f, -4.51751590e-01f, 8.71863365e-01f, -1.78211689e-01f, -7.51369715e-01f, -3.85390788e-01f, -1.89401209e-01f, -4.24898446e-01f, -6.54047310e-01f, -4.37665075e-01f,
  -2.22291395e-01f, 5.29086031e-03f, -9.56448391e-02f, -1.74350187e-01f, -3.06066483e-01f, 7.42769420e-01f, 1.20912075e+00f, -4.14627314e-01f, -6.03357732e-01f, 3.65973748e-02f,
  -4.75717843e-01f, -4.96052325e-01f, -2.91962504e-01f, 7.12084174e-01f, -3.99867803e-01f, 5.48494399e-01f, -5.18393457e-01f, 1.73697427e-01f, 5.75073622e-02f, 2.42301524e-01f,
  3.89671922e-01f, -8.04367244e-01f, -1.81636974e-01f, 1.94052272e-02f, 6.69929445e-01f, -1.41810521e-01f, 7.73766041e-01f, -4.69814949e-02f, -2.90048391e-01f, -1.48024738e-01f,
  -9.87349600e-02f, -2.27641091e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -2.60490328e-01f, -1.37793392e-01f, 9.47243273e-01f, -6.40988499e-02f, 1.05440589e-02f, -9.43932906e-02f, 1.39943913e-01f, -4.83007610e-01f, -1.72925055e-01f, 7.64931977e-01f,
  -3.44279379e-01f, -5.85874736e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    