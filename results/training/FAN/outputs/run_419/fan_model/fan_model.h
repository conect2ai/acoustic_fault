/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -5.66433929e-03f, 1.09200396e-01f, 6.19787984e-02f, -5.99508286e-02f, -1.83918878e-01f, -2.86391050e-01f, -3.69912565e-01f, 1.12771597e-02f, 1.59549445e-01f, 9.60111842e-02f,
  -1.20048776e-01f, -9.03465822e-02f, 7.54359737e-02f, -1.72310814e-01f, 1.58009067e-01f, 2.64890641e-01f, 2.24775802e-02f, -2.49086116e-02f, 4.10382114e-02f, -1.89252310e-02f,
  8.95090029e-02f, -3.21361385e-02f, -1.03380457e-02f, -3.84367183e-02f, -1.75750747e-01f, -8.75186399e-02f, 7.53529444e-02f, -1.33679017e-01f, -1.70590281e-01f, -1.23761304e-01f,
  -1.22303136e-01f, 1.27763078e-01f, 1.44382371e-02f, 1.46897331e-01f, 1.94136761e-02f, -4.62975353e-02f, -5.54019287e-02f, -2.74964143e-02f, -2.55653635e-02f, -5.31081706e-02f,
  4.63177264e-02f, -5.76979034e-02f, 1.36764664e-02f, 1.32623957e-02f, -2.65304465e-02f, -4.37048785e-02f, 2.93810405e-02f, 6.51807059e-03f, -1.64933805e-03f, -4.65372490e-04f,
  -4.99445759e-03f, 1.65437497e-02f, -7.54834265e-02f, 9.27625895e-02f, -8.67791381e-03f, 3.31191942e-02f, -6.30921125e-02f, -6.33315369e-02f, 9.73471850e-02f, 4.65333201e-02f,
  4.21003178e-02f, 3.97547428e-03f, 3.19199637e-02f, 4.52892855e-03f, -5.98919131e-02f, -3.32739614e-02f, -4.60730447e-03f, -3.59636769e-02f, -5.20393811e-02f, 2.73354575e-02f,
  -9.37051997e-02f, -6.45789951e-02f, 4.58168983e-02f, 2.86595784e-02f, -4.31395099e-02f, 2.50106864e-03f, -1.86378900e-02f, -1.35980349e-03f, 3.09892222e-02f, -6.32892922e-02f,
  8.46721008e-02f, 6.80573732e-02f, -3.18204239e-02f, -6.54459447e-02f, 2.47373357e-02f, 1.40962470e-02f, -4.71933000e-02f, -5.43920882e-02f, -4.36236672e-02f, -8.23589042e-03f,
  1.03010170e-01f, 1.69372767e-01f, -4.70840670e-02f, -8.59163925e-02f, 4.15255651e-02f, 3.91684240e-03f, 7.32585341e-02f, -2.26140977e-03f, -1.56758111e-02f, 2.38653016e-03f,
  -4.63620164e-02f, 9.40657780e-02f, 5.33548966e-02f, 3.25785019e-03f, -3.99973104e-03f, 5.69166318e-02f, 5.31748608e-02f, -9.55392234e-03f, 2.82896496e-02f, -3.89429554e-02f,
  -1.54028991e-02f, -3.93047072e-02f, 9.88156348e-02f, -1.08308919e-01f, 2.49028895e-02f, -1.85243115e-02f, -7.40605369e-02f, 1.70463249e-02f, 7.64679015e-02f, 5.13107143e-02f,
  -4.44186598e-01f, 1.78233683e-02f, -1.77047759e-01f, -1.17535882e-01f, 1.10498905e-01f, 5.60064912e-01f, 4.57115844e-02f, 3.93326730e-02f, -1.97189816e-04f, 2.35201105e-01f,
  -5.58442101e-02f, 2.63088476e-02f, -1.74181849e-01f, 2.68866569e-01f, -2.85657614e-01f, -6.46436065e-02f, 2.34362274e-01f, 9.63748470e-02f, -5.88774271e-02f, -9.55576077e-02f,
  -2.62712128e-02f, 2.26758048e-01f, -1.96269378e-01f, -4.28351425e-02f, 8.46409574e-02f, -2.70190556e-02f, -2.32420489e-01f, -1.14311026e-02f, 4.12264168e-02f, 1.00903204e-02f,
  -1.19447067e-01f, -3.25854793e-02f, 1.16568744e-01f, -5.83739579e-02f, 6.55486882e-02f, -4.22069281e-02f, 2.64347121e-02f, 1.41014215e-02f, 4.76175547e-02f, 1.02425620e-01f,
  -1.60963889e-02f, -5.71936741e-03f, 8.27815831e-02f, 6.82500005e-03f, 1.15186498e-01f, -7.90002663e-03f, 3.43374461e-02f, 2.27192920e-02f, -1.55953327e-02f, -2.92163771e-02f,
  3.15958299e-02f, -3.40039954e-02f, 4.43287641e-02f, -7.93092698e-02f, -7.16545880e-02f, -7.39663653e-03f, -2.44593546e-02f, 2.95602139e-02f, 4.90105040e-02f, 7.74161518e-02f,
  -2.02836958e-03f, -6.68280646e-02f, -5.84844546e-03f, -3.95894349e-02f, -6.32553995e-02f, -2.32938677e-02f, 9.74546652e-04f, -2.72754058e-02f, -5.75354137e-02f, -4.74745035e-02f,
  -1.07450588e-02f, 3.41485627e-02f, -1.05747916e-02f, 2.03042813e-02f, -9.91385244e-03f, 3.00697889e-02f, -5.14247864e-02f, 5.25511429e-03f, -1.86712351e-02f, 7.94231072e-02f,
  -5.67350835e-02f, -3.28393616e-02f, -6.52586520e-02f, -2.26639733e-02f, 1.98882893e-02f, -7.78335379e-03f, -7.58226635e-03f, -3.24797258e-02f, 2.04323474e-02f, 5.21743037e-02f,
  -1.28335208e-01f, -2.42991313e-01f, 4.20176098e-03f, 3.12531181e-02f, -8.73657092e-02f, 5.99393658e-02f, 2.31440719e-02f, 6.32397011e-02f, -9.39469710e-02f, -3.16968262e-02f,
  7.05225244e-02f, -9.04461928e-03f, -6.23283423e-02f, -4.46757628e-03f, -6.82879314e-02f, 1.96203720e-02f, -6.05239272e-02f, 1.00908661e-03f, 6.25370815e-02f, 5.74826524e-02f,
  -6.18410408e-02f, 6.93419203e-02f, -1.39585240e-02f, 5.62929921e-02f, 8.65964666e-02f, -2.89365295e-02f, -1.19926836e-02f, 2.85363570e-02f, -5.39999902e-02f, -5.92751428e-02f,
  -4.90122557e-01f, 2.29993939e-01f, 2.10550308e-01f, 4.81497459e-02f, 2.36493628e-02f, 9.35701430e-02f, -1.11521654e-01f, 3.24517041e-02f, 5.58282696e-02f, -1.97159037e-01f,
  2.84078512e-02f, -2.21366972e-01f, 8.56666453e-03f, -4.81505394e-02f, -1.26607597e-01f, 4.32197452e-02f, -1.49873644e-01f, -8.29153135e-02f, -3.51712443e-02f, -1.08505994e-01f,
  1.03932926e-02f, -2.53155500e-01f, 1.18824244e-01f, -5.43413386e-02f, -7.21919090e-02f, 4.50109094e-02f, -5.29770367e-02f, -5.82896508e-02f, 5.15905283e-02f, 2.71630026e-02f,
  1.20658927e-01f, 1.63647309e-01f, 4.77978922e-02f, 5.57466559e-02f, 2.73167901e-02f, 3.45723704e-02f, 1.78189464e-02f, -5.24044186e-02f, 5.17477319e-02f, -1.31141981e-02f,
  -3.87512967e-02f, -3.09051275e-02f, 8.31068382e-02f, -4.05904688e-02f, -8.49654302e-02f, 7.67144412e-02f, -1.18147535e-02f, -2.47326307e-02f, -6.41033128e-02f, 8.90413765e-03f,
  -2.96122264e-02f, 1.54487966e-02f, 7.44868361e-04f, 3.06924782e-03f, 5.05335978e-04f, 6.21234328e-02f, 5.37766796e-03f, 6.05673762e-03f, -6.40929937e-02f, 1.97271854e-02f,
  -9.04962718e-02f, -1.29905734e-02f, -2.38202163e-03f, 4.16922495e-02f, -2.04063151e-02f, 1.75590649e-05f, -2.52938587e-02f, 5.60291447e-02f, -6.43151477e-02f, -5.77771775e-02f,
  -1.05562247e-02f, -3.31784151e-02f, -7.95593765e-03f, -9.96094719e-02f, -5.60065843e-02f, -3.55641916e-02f, -2.61121280e-02f, -4.09146510e-02f, 5.94165213e-02f, -3.74557264e-02f,
  -4.84528355e-02f, -1.19507194e-01f, 5.15558645e-02f, 3.58763337e-02f, -5.37679456e-02f, -3.42182554e-02f, 9.53741744e-02f, 8.62742215e-03f, 3.31621580e-02f, -2.65276674e-02f,
  -4.85627819e-03f, -3.25878747e-02f, 3.10257636e-02f, 1.84293203e-02f, -7.08732405e-04f, 1.00690514e-01f, 7.05272332e-02f, -4.78446595e-02f, -2.83803064e-02f, 9.50981211e-03f,
  1.66839510e-02f, 1.42077263e-02f, -6.78998828e-02f, -2.49123108e-02f, 1.28466333e-03f, 5.96452169e-02f, 4.48058471e-02f, 5.03119789e-02f, -4.56468537e-02f, 1.17505090e-02f,
  5.90687618e-02f, -1.82492025e-02f, -2.97042541e-02f, -9.31227230e-04f, -2.67284140e-02f, -8.56158808e-02f, -2.93065906e-02f, -8.75619706e-03f, 4.94736098e-02f, -5.80227487e-02f,
  -6.48795292e-02f, -1.22540027e-01f, 6.74940273e-02f, -2.59022921e-01f, 2.19461337e-01f, -1.14852309e-01f, -1.17552079e-01f, 9.40301344e-02f, -1.81500614e-02f, 2.34262913e-01f,
  2.49973871e-02f, -4.90477448e-03f, -6.10780641e-02f, -1.96672887e-01f, -4.01540518e-01f, -2.97755688e-01f, -2.33488336e-01f, -5.09996302e-02f, -2.21280664e-01f, -1.11588627e-01f,
  -1.70185473e-02f, -2.00942323e-01f, -1.14271328e-01f, -5.35818525e-02f, 7.33918846e-02f, 1.13500118e-01f, 1.00975268e-01f, 6.74241260e-02f, 7.21338764e-03f, -2.96772774e-02f,
  -8.86478052e-02f, 6.13904782e-02f, 1.44856066e-01f, -8.37382744e-04f, 1.12755492e-01f, 6.25539795e-02f, 3.26166046e-03f, -7.19471946e-02f, -3.73121887e-03f, 3.96761205e-03f,
  1.45414928e-02f, -6.27712626e-03f, 1.00022340e-02f, 8.70573241e-03f, 5.24442866e-02f, -5.28333150e-02f, -5.85631542e-02f, 5.68943806e-02f, -2.18895357e-02f, -7.95419365e-02f,
  -5.74295595e-02f, -2.25735661e-02f, 5.67219332e-02f, 1.16278017e-02f, 1.53249884e-02f, 2.32871864e-02f, 4.49685678e-02f, 7.77208880e-02f, -2.23418232e-02f, 1.03143588e-01f,
  7.25496002e-03f, -1.37382494e-02f, -5.96236549e-02f, 2.59999074e-02f, -2.67883707e-02f, -4.01939414e-02f, -5.53258695e-03f, 3.70490961e-02f, -2.96106879e-02f, 5.61665706e-02f,
  -8.98759067e-02f, 8.16147774e-02f, -9.58242565e-02f, -2.80849580e-02f, -1.31223639e-02f, 3.84317935e-02f, -7.62169808e-02f, -5.97228557e-02f, 4.75431085e-02f, -8.54539946e-02f,
  -2.37258337e-02f, 3.70146744e-02f, -6.59180656e-02f, -6.45298802e-04f, 7.97318816e-02f, -5.20608090e-02f, 5.75389303e-02f, -2.19323859e-02f, 1.70167759e-02f, -1.31895738e-02f,
  -3.01752444e-02f, -7.12172836e-02f, -5.96638769e-03f, -2.11975556e-02f, -7.83907175e-02f, -7.63401575e-03f, -6.90586418e-02f, 6.18490539e-02f, -4.34978195e-02f, 3.47279734e-03f,
  7.54302070e-02f, 3.35284509e-02f, -1.39326300e-03f, -3.96975949e-02f, 1.16237416e-03f, 8.33250433e-02f, 7.27965636e-03f, 1.14366701e-02f, 5.65588847e-02f, 2.34122993e-03f,
  -5.73445298e-02f, 1.83672216e-02f, -4.75119363e-04f, 4.63757999e-02f, 9.40377731e-03f, 8.25999156e-02f, -5.88256046e-02f, -4.00256142e-02f, -1.84380766e-02f, -4.76039313e-02f,
  4.92262244e-01f, 1.23488612e-01f, 2.84625798e-01f, 3.33678395e-01f, 7.48488083e-02f, -2.84817278e-01f, 2.02573076e-01f, -3.37149464e-02f, 3.11492175e-01f, -1.32219866e-01f,
  -1.03650033e-01f, 2.82838225e-01f, 1.17734179e-01f, -1.06888134e-02f, 2.43834838e-01f, 1.45765036e-01f, 3.52518237e-03f, 1.28601147e-02f, 1.10718727e-01f, 3.60890701e-02f,
  9.91326720e-02f, -1.66294098e-01f, 1.22028902e-01f, -3.02307069e-01f, -4.53571863e-02f, -5.87610118e-02f, -1.25501588e-01f, 6.13526925e-02f, -1.18484914e-01f, -6.04238287e-02f,
  -9.71141830e-02f, -6.38963580e-02f, -2.00902913e-02f, -6.59486204e-02f, -3.79711539e-02f, -4.88061085e-02f, 7.67654413e-03f, 4.68052784e-03f, 5.68661653e-02f, 3.39924283e-02f,
  -1.02881785e-03f, -2.09032502e-02f, -4.37783562e-02f, 5.90178668e-02f, -1.27354842e-02f, -4.82277153e-03f, 1.67561769e-02f, 2.16348039e-04f, 2.50867028e-02f, 6.56880066e-02f,
  4.69962396e-02f, 2.04894356e-02f, -3.40685286e-02f, 3.00770439e-02f, 6.02076799e-02f, -1.93387765e-04f, -7.27885449e-03f, 1.78427398e-02f, 2.65953764e-02f, -1.69391222e-02f,
  -6.56989813e-02f, -1.84249356e-02f, 3.10407430e-02f, -9.80886910e-03f, -9.15757474e-03f, -1.23993595e-04f, -3.72679606e-02f, -8.08676798e-03f, 5.25469072e-02f, -2.51505636e-02f,
  3.35906819e-02f, 1.39915093e-04f, 1.70585774e-02f, 2.08022930e-02f, -8.49397667e-03f, 2.98556536e-02f, -1.54122915e-02f, -1.15969619e-02f, 4.16603498e-03f, 5.53275310e-02f,
  2.39789840e-02f, 2.28748918e-02f, 4.81142290e-03f, 2.19441243e-02f, -2.13840753e-02f, 3.81531306e-02f, -1.14428392e-03f, 5.44660725e-02f, -2.54519307e-03f, 1.40921203e-02f,
  -1.57331266e-02f, -1.21168438e-02f, 4.05516401e-02f, 4.85055447e-02f, 2.83018090e-02f, -2.79351696e-02f, 1.13475109e-02f, 1.57472398e-02f, -2.08907258e-02f, -5.87667339e-02f,
  -9.82783269e-03f, 4.49722111e-02f, -6.15852978e-03f, -2.16523670e-02f, 1.37517219e-02f, -4.10434119e-02f, -8.74840553e-05f, 9.53541696e-03f, -2.14388613e-02f, -2.64817048e-02f,
  7.58734252e-03f, -3.66128758e-02f, 4.14699838e-02f, -3.84458266e-02f, -2.74098832e-02f, -2.59138756e-02f, 1.57199707e-02f, 1.73259340e-02f, -1.67998057e-02f, 1.15513410e-02f,
  3.04784358e-01f, -3.08082938e-01f, -6.49984032e-02f, -1.53995961e-01f, 1.01276912e-01f, -1.58959925e-01f, -2.94297375e-02f, -1.23889700e-01f, 9.18730199e-02f, -7.51238987e-02f,
  -8.78120959e-02f, -2.91628242e-02f, -7.40571246e-02f, -2.86979705e-01f, -2.35838398e-01f, -8.33818913e-02f, -6.93500116e-02f, -7.38021731e-02f, 5.85076772e-02f, -2.02057466e-01f,
  -4.48999144e-02f, -3.67984891e-01f, -7.66724497e-02f, -1.71885312e-01f, -1.98724076e-01f, -5.45841157e-02f, -5.09640127e-02f, 8.72438401e-03f, -1.98326826e-01f, -6.90218359e-02f,
  7.85090700e-02f, 9.77110351e-04f, 1.99940056e-02f, -1.86110451e-03f, -5.80314137e-02f, -3.52184963e-03f, 1.67998113e-02f, 5.22240028e-02f, 4.83139156e-04f, 5.84208444e-02f,
  -7.10021565e-03f, 2.64852997e-02f, -8.09020624e-02f, -8.94302595e-03f, -6.29923819e-03f, 5.90129616e-03f, 2.83245575e-02f, 4.21596840e-02f, 2.61845384e-02f, 2.56108418e-02f,
  -1.20809786e-02f, 2.19685975e-02f, 1.75509844e-02f, 6.25275075e-03f, -2.01241449e-02f, 1.63366366e-02f, 4.22939919e-02f, 8.18454921e-02f, 6.31228760e-02f, 2.14232095e-02f,
  3.39952111e-02f, -9.26125888e-03f, -1.86562594e-02f, 4.25503356e-03f, -1.40729900e-02f, -4.13461737e-02f, -8.33075587e-03f, -2.03346815e-02f, -2.31985711e-02f, 8.11191369e-03f,
  -4.70058545e-02f, -1.96861923e-02f, -4.47331741e-02f, 2.39661317e-02f, -4.06043008e-02f, -4.62601148e-02f, 3.15617882e-02f, -2.30226796e-02f, -7.05902232e-04f, 1.44438641e-02f,
  8.36004876e-03f, 6.86711445e-03f, -3.29072517e-03f, 5.31131625e-02f, 1.51401591e-02f, 2.08259393e-02f, -4.83278520e-02f, -8.71075969e-03f, 8.08467809e-03f, 4.58621792e-03f,
  -9.29432586e-02f, -1.87315553e-01f, -2.61847321e-02f, -1.17342751e-02f, 4.62343590e-03f, 1.14393961e-02f, 7.18456286e-04f, -3.97258401e-02f, -3.20704021e-02f, -4.30715643e-02f,
  6.19720332e-02f, -2.86839027e-02f, 5.30259684e-02f, 9.08810180e-03f, 4.48347218e-02f, -5.90157397e-02f, -2.55071186e-02f, 1.46517092e-02f, 1.40807200e-02f, -1.23951689e-03f,
  1.90326404e-02f, 8.34232103e-03f, -5.47477277e-03f, -2.04610545e-02f, 1.43818441e-03f, 4.94383685e-02f, -9.28131491e-03f, 7.68250600e-02f, -2.01071817e-02f, 2.82813571e-02f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.47451913e+00f, 5.18116832e-01f, -1.44966856e-01f, -3.13467383e-01f, 2.47297809e-01f, -2.16007322e-01f, 1.23529108e-02f, 3.55426446e-02f, -3.93698737e-02f, 1.98466703e-01f,
  -7.62494132e-02f, -5.30222654e-02f, 1.03594370e-01f, -2.41370909e-02f, -4.14725512e-01f, 2.47750115e-02f, -1.95643336e-01f, -9.62441489e-02f, 1.05113037e-01f, -7.34027028e-02f,
  -7.84098431e-02f, 3.76789570e-01f, -9.92792025e-02f, 4.07643586e-01f, 8.33107978e-02f, 4.53927405e-02f, -1.28825888e-01f, 2.66679615e-01f, -5.37746400e-02f, 1.24620005e-01f,
  -4.63620797e-02f, 3.28324288e-02f, 1.04104085e-02f, -9.30753350e-02f, -1.42073438e-01f, -5.83605096e-02f, -3.48395109e-03f, -3.88737135e-02f, 6.32779896e-02f, -3.57902646e-02f,
  -5.99797815e-02f, 5.96278831e-02f, 2.81299055e-02f, 1.03473641e-01f, 7.08511770e-02f, 5.94860502e-02f, 9.44720805e-02f, 2.19525788e-02f, 6.73014820e-02f, 9.84461829e-02f,
  1.11064143e-01f, -3.14342578e-05f, -3.71231623e-02f, -3.60756740e-02f, 8.81748125e-02f, -1.25861570e-01f, -2.39403211e-02f, -4.07143235e-02f, -2.67003151e-03f, -3.25461477e-02f,
  5.09037636e-02f, -1.00933053e-01f, 1.24860115e-01f, -2.58143432e-02f, 6.35213926e-02f, -1.49169343e-03f, 1.19573129e-02f, -9.65010654e-03f, 3.52997296e-02f, -3.93057764e-02f,
  -5.80970645e-02f, 3.50079201e-02f, 2.33094528e-04f, 3.85985151e-02f, -4.71920408e-02f, 1.46443322e-02f, -8.27538967e-02f, 3.07801906e-02f, -6.70493841e-02f, 4.05191593e-02f,
  7.27150738e-02f, -4.36627492e-03f, -3.44971679e-02f, 2.74665169e-02f, -4.66417614e-03f, 4.39711250e-02f, 2.69797910e-02f, 2.51419544e-02f, -4.10348326e-02f, -4.11157236e-02f,
  -6.63336337e-01f, -4.68988568e-01f, -1.80854145e-02f, 5.59390672e-02f, 4.02308367e-02f, -5.59093505e-02f, -7.21909106e-02f, 3.94199602e-02f, -4.15965207e-02f, 1.32238884e-02f,
  -9.29122120e-02f, -1.90582648e-02f, -1.18074924e-01f, 6.25972729e-03f, 1.37372054e-02f, -7.94380903e-02f, -8.91819224e-02f, 1.33448252e-02f, -9.64811072e-02f, -7.10011274e-02f,
  -5.55080958e-02f, -4.87125292e-02f, 3.59149999e-05f, 6.31012619e-02f, -6.94998652e-02f, 8.69634002e-02f, -1.11407980e-01f, 2.33716033e-02f, -1.44672208e-02f, -6.06527785e-04f,
  -7.89765492e-02f, 6.71559632e-01f, 4.57540542e-01f, 9.92986560e-02f, -3.35861742e-01f, 1.40290096e-01f, 5.91537990e-02f, 3.37726086e-01f, 4.25416529e-01f, 3.07841569e-01f,
  -3.13027710e-01f, 6.30204022e-01f, -3.35344493e-01f, 1.69549286e-01f, -5.85376561e-01f, -1.42961144e-01f, -1.44078493e-01f, 9.10934955e-02f, 1.23621836e-01f, 7.00502172e-02f,
  -2.46960551e-01f, -8.36255178e-02f, -3.33589613e-01f, 1.32769058e-02f, -9.71108973e-02f, 4.09127325e-01f, -6.62660003e-01f, -4.24842611e-02f, -1.63619574e-02f, -2.94767017e-03f,
  -2.25858271e-01f, 3.03113967e-01f, 8.90923664e-02f, 8.21533948e-02f, -1.54825002e-01f, -2.03136057e-02f, 6.67606145e-02f, -4.70166840e-02f, -3.50779071e-02f, -2.40116306e-02f,
  6.91046268e-02f, 2.18409747e-02f, 2.72108633e-02f, -2.77285853e-05f, 1.83850825e-01f, 8.70004743e-02f, 3.80816944e-02f, -2.41643228e-02f, 1.45962179e-01f, -1.00935765e-01f,
  -5.66748297e-03f, -1.85994487e-02f, 4.83699441e-02f, 1.76333322e-03f, -4.88311425e-02f, 6.59651384e-02f, 2.66350415e-02f, -1.09791026e-01f, 6.24857321e-02f, -2.28012949e-02f,
  3.33633311e-02f, -3.23706642e-02f, -9.96163487e-02f, 9.28076357e-03f, 9.61820930e-02f, -2.00974327e-02f, 2.75792764e-03f, -1.20073751e-01f, 4.53552753e-02f, -1.15051292e-01f,
  9.60448906e-02f, -2.98827980e-02f, 1.18064187e-01f, -1.73035311e-03f, 1.12517878e-01f, -2.92295441e-02f, -1.23093026e-02f, -2.12787166e-02f, -2.55938489e-02f, -4.91032675e-02f,
  1.10007323e-01f, -2.79419590e-02f, 3.84976007e-02f, -1.20243900e-01f, 1.46236662e-02f, -5.27414940e-02f, -8.91750827e-02f, 6.43504634e-02f, -1.51164576e-01f, -1.66351408e-01f,
  -2.47760430e-01f, 4.67886999e-02f, 9.28130895e-02f, 3.18586491e-02f, 5.99076636e-02f, -3.38118896e-02f, -7.04987049e-02f, 4.94986132e-04f, 4.65408936e-02f, 3.06677949e-02f,
  -1.15078919e-01f, -6.54486939e-02f, -8.09180513e-02f, -2.35472573e-03f, -8.31970051e-02f, 6.22691102e-02f, -9.90256965e-02f, 6.46906951e-03f, -1.55125886e-01f, -1.58316512e-02f,
  -7.60561824e-02f, -1.24437129e-02f, -1.22165214e-02f, 1.88282598e-02f, 1.63725540e-02f, -2.42156312e-01f, 2.30822675e-02f, 1.00729197e-01f, -9.67918038e-02f, 5.00193648e-02f,
  -1.25709534e+00f, 4.26455885e-01f, -6.65144548e-02f, 4.53616023e-01f, -2.63854891e-01f, 4.01826352e-01f, 5.05994856e-01f, 1.12719730e-01f, 2.33103126e-01f, 4.14582342e-01f,
  1.41938711e-02f, 1.41973823e-01f, 2.14388836e-02f, 3.23427707e-01f, -5.77810369e-02f, 2.30625987e-01f, 1.34435847e-01f, 1.14291467e-01f, 2.94742975e-02f, -7.97359571e-02f,
  -6.23312406e-02f, -5.83268367e-02f, 6.41677007e-02f, -2.10757539e-01f, -2.85055161e-01f, -1.41704619e-01f, -1.08776540e-01f, -5.85228167e-02f, -7.09419465e-03f, -3.94196212e-02f,
  -3.75464320e-01f, -1.92565411e-01f, -8.02999139e-02f, -1.36084169e-01f, -4.84060682e-02f, -4.70091850e-02f, 1.08394567e-02f, -4.74099666e-02f, -7.72548318e-02f, 8.34089071e-02f,
  3.57246697e-02f, -3.15559879e-02f, -5.07441759e-02f, -5.89796994e-03f, 4.66664620e-02f, -4.93533835e-02f, -2.39195004e-02f, 3.68979499e-02f, 7.63453692e-02f, 5.58915697e-02f,
  8.01694095e-02f, 5.01969904e-02f, 3.02083492e-02f, 8.65658373e-02f, -1.71295572e-02f, 1.83568262e-02f, 1.87663943e-01f, 4.37020557e-03f, -3.98263782e-02f, 7.61562437e-02f,
  -2.88686827e-02f, -3.04907374e-02f, -6.16412461e-02f, 5.75652234e-02f, 1.45415636e-02f, -8.05764347e-02f, -1.97529700e-02f, -1.07840247e-01f, 4.71533649e-02f, 3.99268791e-02f,
  1.91344675e-02f, 2.34616790e-02f, -5.69252484e-02f, 4.20600921e-02f, 1.56584550e-02f, -1.00569380e-02f, -3.99493650e-02f, -3.76242623e-02f, 7.36443028e-02f, 3.21121421e-03f,
  9.35883746e-02f, 1.06739569e-02f, -4.90323314e-03f, 1.15617320e-01f, 9.27890651e-03f, 2.79606407e-04f, 2.04905551e-02f, 5.11188619e-02f, -5.02282046e-02f, 2.40037814e-02f,
  4.29084629e-01f, 9.66209993e-02f, 2.24696808e-02f, 1.88263580e-02f, 1.56055959e-02f, -6.79699555e-02f, -5.24036251e-02f, -1.92053840e-02f, 1.19394124e-01f, -7.81902522e-02f,
  -2.61864178e-02f, -3.32844467e-03f, -4.98079471e-02f, 2.93498076e-02f, 7.76399970e-02f, 9.77091342e-02f, -6.65261596e-02f, 1.31895859e-02f, -9.55694914e-03f, -4.99793515e-02f,
  -5.68752661e-02f, -6.34011328e-02f, 1.69139393e-02f, -2.83401590e-02f, -4.74507362e-02f, 1.74994755e-03f, -2.54955236e-02f, -7.01647531e-03f, -3.84911001e-02f, 1.91460606e-02f,
  6.47450805e-01f, -3.59160125e-01f, 2.02466697e-02f, 5.96092999e-01f, 4.39854175e-01f, -1.61242455e-01f, -1.87340796e-01f, 4.03103620e-01f, 5.62239170e-01f, -4.41896260e-01f,
  1.29132926e-01f, -4.19028580e-01f, -4.88285512e-01f, 2.92343259e-01f, 3.31267834e-01f, -4.48421508e-01f, 3.82051170e-01f, -5.57542481e-02f, 1.53220892e-01f, 1.57543063e-01f,
  2.46554792e-01f, 3.47294986e-01f, 1.23973116e-01f, 2.69996822e-01f, 1.50181562e-01f, 1.52751476e-01f, 4.92235869e-02f, -2.64935136e-01f, 2.91307151e-01f, 5.14823385e-03f,
  -3.16916369e-02f, 2.15157438e-02f, 7.75068030e-02f, -8.28603730e-02f, -3.38440598e-03f, -4.42844406e-02f, -1.37946889e-01f, -6.99123070e-02f, 1.03272960e-01f, -2.64995657e-02f,
  -1.16817638e-01f, 3.20489681e-03f, 7.93830305e-02f, 6.75387159e-02f, 1.11639000e-01f, 4.53667305e-02f, -3.56281153e-03f, -7.32305422e-02f, -5.79963811e-03f, -9.56066102e-02f,
  -8.22681934e-03f, 1.06464475e-01f, 1.51985794e-01f, -7.48322755e-02f, 4.30936599e-03f, 2.77666673e-02f, 2.88181962e-03f, -1.29515976e-01f, 5.02177887e-02f, 5.19402288e-02f,
  -1.50531046e-02f, -3.03055439e-02f, -2.30504330e-02f, 2.58919112e-02f, 6.86682165e-02f, 1.03915580e-01f, 5.61249861e-03f, -9.64776650e-02f, 4.73183393e-02f, 1.55812567e-02f,
  8.15812424e-02f, 1.31108657e-01f, 2.60927901e-02f, 3.50876786e-02f, 2.95106061e-02f, -1.86598464e-03f, 8.80240053e-02f, -1.39081150e-01f, 4.13219146e-02f, 2.72869971e-02f,
  6.93190545e-02f, 6.50786087e-02f, -1.51814790e-02f, 1.01537127e-02f, 2.29985695e-02f, 3.63003202e-02f, 5.97604513e-02f, -2.21590791e-02f, 3.75223458e-02f, -8.41582417e-02f,
  1.34883951e-02f, -2.68929806e-02f, -3.51658091e-02f, -1.82315130e-02f, -6.10949211e-02f, -6.30588010e-02f, 1.77796725e-02f, 7.18912110e-02f, -1.68532729e-02f, 6.27791882e-02f,
  1.26068359e-02f, 9.32088867e-02f, -7.69198686e-02f, 3.65468673e-02f, 1.97824296e-02f, -5.55375591e-02f, -6.57697022e-02f, 2.83271559e-02f, 1.04165070e-01f, 8.59775990e-02f,
  -8.50404352e-02f, -1.31240115e-01f, -1.17603794e-01f, 5.15911952e-02f, -2.92662811e-02f, 8.79879016e-03f, -3.01697683e-02f, 2.06466075e-02f, -5.38126938e-02f, 4.23080940e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  -1.25925049e-01f, 3.30703646e-01f, 1.24066710e-01f, 3.00845891e-01f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -2.08818644e-01f, -4.72789079e-01f, -7.14794993e-02f, 2.76755214e-01f, 2.65434921e-01f, -5.47006965e-01f, 2.25534156e-01f, -2.47412741e-01f, -1.14407085e-01f, -2.46845156e-01f,
  1.52183637e-01f, -3.01251233e-01f, -2.79290020e-01f, -1.62951186e-01f, 3.80839556e-01f, -3.98708194e-01f, -9.18527413e-03f, -2.54463017e-01f, -4.30856347e-01f, -2.21180241e-03f,
  2.29906753e-01f, -2.07930520e-01f, 4.88626391e-01f, 1.01352118e-01f, 6.15966991e-02f, -3.57069105e-01f, -3.87102753e-01f, -3.03088188e-01f, -2.24374413e-01f, 8.40644836e-02f,
  4.37535405e-01f, 2.34239683e-01f, -3.68384778e-01f, -1.01340905e-01f, -2.11835846e-01f, -1.24298356e-01f, -1.74696781e-02f, -1.68471768e-01f, -2.97073901e-01f, -3.84899586e-01f,
  -2.85374850e-01f, 4.69704658e-01f, -5.35579100e-02f, 1.06454670e-01f, 2.70927668e-01f, 9.25175697e-02f, -3.61359149e-01f, -5.81089854e-01f, -3.06875765e-01f, -5.33273160e-01f,
  -4.28740293e-01f, 1.35204703e-01f, 9.27424133e-02f, -4.28032607e-01f, 3.39551419e-01f, -3.51956427e-01f, -2.08140984e-02f, -1.72394276e-01f, -6.49760723e-01f, -5.47965229e-01f,
  -1.66128173e-01f, -9.62566491e-03f, 2.61724234e-01f, 1.46484464e-01f, 1.46094441e-01f, 8.82630125e-02f, -5.47635972e-01f, -3.44082534e-01f, -6.20387048e-02f, 3.36321503e-01f,
  -1.80968437e-02f, 3.44294995e-01f, -2.67223530e-02f, -3.66081059e-01f, -7.32088625e-01f, -4.03737277e-01f, 4.45511825e-02f, -3.54939997e-01f, 1.13833338e-01f, -2.46994430e-03f,
  -3.23452741e-01f, -4.56402689e-01f, 3.39042246e-02f, -9.22743604e-03f, -1.60632282e-01f, -5.70125937e-01f, -2.50977844e-01f, -9.13987830e-02f, -3.85316104e-01f, 3.46807926e-03f,
  -6.08348489e-01f, -4.53022569e-01f, -2.21498936e-01f, -4.25330251e-01f, -7.43799806e-02f, -8.53698403e-02f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  6.48400486e-01f, 7.05634177e-01f, 2.88556129e-01f, -3.18200886e-01f, 4.41926390e-01f, 8.96495819e-01f, 6.54086053e-01f, 7.09058717e-03f, 8.88537586e-01f, -7.86094144e-02f,
  -4.45627123e-01f, 3.33125070e-02f, 1.08372080e+00f, 9.47119772e-01f, 1.61591038e-01f, -5.46850979e-01f, 8.09599042e-01f, 3.39749575e-01f, -2.60280948e-02f, 2.09834605e-01f,
  6.59409165e-01f, 3.51437718e-01f, 5.72381139e-01f, 6.12953246e-01f, 6.48489520e-02f, -8.58576894e-01f, -6.65362239e-01f, -7.49333858e-01f, 6.95632279e-01f, 1.18505247e-01f,
  1.06914663e+00f, -2.51464099e-01f, 3.36045951e-01f, -1.41003281e-01f, 7.72303700e-01f, 6.77590311e-01f, 3.61026943e-01f, 2.00588956e-01f, 9.23138410e-02f, -3.32450867e-01f,
  -5.48902690e-01f, -8.91951919e-01f, 7.24646628e-01f, -5.21786988e-01f, -3.95385981e-01f, -4.54339266e-01f, -5.81409633e-01f, 1.01425457e+00f, -2.28100166e-01f, -2.11433098e-01f,
  9.51240003e-01f, 7.77223587e-01f, 7.87316918e-01f, 6.87021837e-02f, 1.93069786e-01f, -4.40143049e-01f, -2.81008035e-01f, -5.62830865e-01f, 1.26383185e+00f, -2.60998189e-01f,
  -7.49140263e-01f, 5.92508197e-01f, -9.52630788e-02f, -1.75669029e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  2.72544205e-01f, 3.54899883e-01f, 3.71701181e-01f, 6.19947791e-01f
};

// L2_fan_Wp (Shape: 6 x 16)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -4.00103897e-01f, -4.33444142e-01f, -5.19531369e-01f, -2.23584667e-01f, -5.02965569e-01f, -2.34383270e-01f, 3.85591537e-01f, 1.13699710e+00f, -8.85097802e-01f, 7.53488958e-01f,
  6.04507029e-01f, 2.25411862e-01f, -2.82092243e-01f, 1.66551948e-01f, 2.74994642e-01f, -1.13619119e-01f, 8.34976971e-01f, -1.22948047e-02f, 1.00261420e-01f, 1.10071227e-01f,
  5.36061525e-02f, -4.97166477e-02f, 3.22090685e-01f, 3.50571454e-01f, 3.60477090e-01f, 6.26264334e-01f, -2.60815263e-01f, 1.85586348e-01f, -5.46887331e-02f, -3.70179802e-01f,
  -3.54719162e-01f, 5.37648022e-01f, -8.87427330e-01f, 7.60112926e-02f, -5.24279512e-02f, -9.58676115e-02f, 1.66394822e-02f, -2.55115330e-01f, -4.91804808e-01f, -4.97387618e-01f,
  4.32904750e-01f, -9.61054802e-01f, -3.07636987e-02f, 1.88116413e-02f, 1.71821788e-01f, -3.16483706e-01f, 6.69309730e-03f, -3.45611274e-01f, 3.74797493e-01f, -1.11860491e-01f,
  -9.63277277e-03f, 1.78487480e-01f, -2.16075361e-01f, -3.92730832e-01f, 3.59145880e-01f, 3.78154479e-02f, 6.06781960e-01f, 7.08525538e-01f, 1.80611923e-01f, -3.01731139e-01f,
  2.70404935e-01f, 7.54149109e-02f, -3.38447064e-01f, 4.49872911e-01f, 2.56118774e-01f, -1.84552535e-01f, 3.68313134e-01f, -1.75703794e-01f, 4.25260901e-01f, 4.90839243e-01f,
  -1.41054213e-01f, -5.23782432e-01f, -2.66359031e-01f, -2.55145669e-01f, -1.45831689e-01f, -1.09027386e-01f, -7.77160302e-02f, -3.48578602e-01f, 4.51807640e-02f, 4.35277522e-01f,
  -1.11597204e+00f, 6.19995371e-02f, -5.23472786e-01f, 7.72796571e-02f, -5.19501507e-01f, -1.01571548e+00f, -4.92178679e-01f, -6.54334873e-02f, 7.30510578e-02f, -5.27159572e-01f,
  3.94722641e-01f, -4.59497839e-01f, 3.34864497e-01f, -9.96241793e-02f, -5.41371778e-02f, -2.47777849e-01f
};

// L2_fan_Wp_bar (Shape: 4 x 16)
const int L2_fan_Wp_bar_rows = 4;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  7.53100455e-01f, 3.62250954e-01f, -7.54125535e-01f, 4.66785789e-01f, 8.92629087e-01f, 2.55112886e-01f, 7.65792370e-01f, 4.83225733e-01f, -5.69039762e-01f, 2.42516637e-01f,
  -7.99932778e-01f, 2.54092485e-01f, -4.31425035e-01f, -2.67292082e-01f, 1.56967497e+00f, 1.80694151e+00f, 7.47391760e-01f, 5.47808483e-02f, -3.45991203e-03f, 9.02647197e-01f,
  8.00235808e-01f, 6.44640088e-01f, -4.06902105e-01f, 9.29847300e-01f, -6.72414362e-01f, 3.26907039e-01f, 9.98839378e-01f, -1.16166246e+00f, 7.97458649e-01f, 1.19637966e+00f,
  -2.04033241e-01f, -1.14942825e+00f, -6.58527136e-01f, 1.88150555e-01f, 5.06462097e-01f, -1.29062599e-02f, 6.19317353e-01f, -1.61844325e+00f, -9.85858619e-01f, -7.31889367e-01f,
  7.13454634e-02f, -1.42284811e+00f, -1.66611627e-01f, -9.17706788e-01f, 1.53798616e+00f, 6.47939563e-01f, 2.67643631e-01f, 5.74050903e-01f, 8.13824773e-01f, -4.70616400e-01f,
  -6.96314275e-01f, 2.67343074e-01f, 3.05029571e-01f, 6.01118505e-01f, 1.49353564e-01f, 1.50235105e+00f, -1.52473187e+00f, 1.26055050e+00f, 1.32633102e+00f, 5.45713365e-01f,
  1.41759843e-01f, 1.19536936e+00f, 6.28669739e-01f, -8.31115246e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 4)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 4;
const float L2_fan_Bp_bar_data[] = {
  1.02953243e+00f, 5.93632340e-01f, 1.40341476e-01f, 2.57891923e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  -2.66674340e-01f, -5.96739471e-01f, -3.54591638e-01f, -5.97258151e-01f, -6.68769121e-01f, 2.93796778e-01f, 1.08980942e+00f, -3.16047668e-01f, 6.90342426e-01f, 3.13614190e-01f,
  1.41648620e-01f, -4.46431994e-01f, -1.75908291e+00f, 5.86178899e-01f, -4.36551809e-01f, 7.22453594e-01f, -6.74762204e-02f, 6.85424805e-01f, -7.42580116e-01f, 1.17387640e+00f,
  3.88439864e-01f, -1.33875108e+00f, 4.70939934e-01f, -3.87477160e-01f, 8.94816443e-02f, -1.99933305e-01f, -9.58674252e-01f, -1.83289930e-01f, -2.29437247e-01f, 3.37254763e-01f,
  -1.16406095e+00f, 7.42116749e-01f, -1.03176974e-01f, -1.55612767e+00f, 1.50566137e+00f, -1.08862221e+00f, 6.79667592e-01f, 1.49989963e+00f, 1.02749550e+00f, -2.55170524e-01f,
  -6.71665788e-01f, -8.32566798e-01f, -1.70863211e-01f, -4.88208771e-01f, 2.39201382e-01f, -2.76627868e-01f, -8.68325114e-01f, 5.24639487e-01f, 1.65941432e-01f, -8.95335138e-01f,
  -5.03750324e-01f, -1.24375761e+00f, -2.88823843e-01f, -2.41694629e-01f, 6.20156169e-01f, 9.09624755e-01f, 1.77710410e-02f, 5.60549736e-01f, -7.31453180e-01f, -1.80550718e+00f,
  -6.94686115e-01f, 3.76265973e-01f, 5.69323957e-01f, -1.13893664e+00f, -5.73900402e-01f, -1.38680607e-01f, 1.12123179e+00f, 4.34214413e-01f, 2.56437749e-01f, -4.01885882e-02f,
  -1.04147172e+00f, -3.34063709e-01f, -1.45025599e+00f, 1.11065578e+00f, -1.33396471e+00f, 1.47480154e+00f, -1.45854211e+00f, 5.37008941e-01f, 2.40173504e-01f, 1.01413630e-01f,
  9.24614727e-01f, 9.36824679e-01f, -1.18450987e+00f, -6.59615695e-01f, 1.66156247e-01f, 8.84627104e-01f, -4.48155515e-02f, 2.05822065e-01f, 7.34490976e-02f, 5.95003545e-01f,
  -7.07955837e-01f, -5.66425323e-02f, 1.14905536e-02f, 1.78250998e-01f, 1.68553144e-01f, 2.31403951e-02f, 1.28616345e+00f, -8.32648039e-01f, 2.86140501e-01f, -3.60450387e-01f,
  7.95222759e-01f, 6.78497851e-01f, -4.32865471e-01f, -9.35476780e-01f, 1.41112447e+00f, -9.85728264e-01f, 6.96965456e-01f, 1.58013594e+00f, 3.75722855e-01f, -6.10475123e-01f,
  7.77738690e-02f, -8.86400521e-01f, 2.79333949e-01f, -8.18537116e-01f, -9.86987710e-01f, 2.95056522e-01f, -1.35610670e-01f, -1.09036326e+00f, -1.19126582e+00f, 1.03524399e+00f,
  -8.70410025e-01f, 7.61261284e-01f, 8.45073342e-01f, -3.86597186e-01f, 7.20259964e-01f, -5.15036345e-01f, -1.45838141e+00f, -1.41627336e+00f, -9.87408161e-02f, 1.07152045e+00f,
  -6.77166879e-01f, 3.93560171e-01f, -2.86039323e-01f, -9.28640723e-01f, 1.28275025e+00f, 7.00366855e-01f, 4.37950790e-01f, -4.56371278e-01f, 6.90349638e-01f, 4.37333345e-01f,
  5.05870104e-01f, -1.36976326e+00f, -1.15929317e+00f, 3.16362113e-01f, -7.96790779e-01f, 1.10289276e+00f, 6.77264571e-01f, 7.26487041e-01f, -1.30434847e+00f, -1.74688563e-01f,
  -7.37211049e-01f, -5.96627831e-01f, -1.33935702e+00f, -6.30320370e-01f, -6.10328138e-01f, -1.39179873e+00f, 2.98772395e-01f, -9.58154023e-01f, 1.19656682e-01f, -3.42183948e-01f,
  -1.06066620e+00f, -6.38323426e-01f, -8.26946050e-02f, 1.12566864e+00f, 4.30397958e-01f, 7.38635063e-01f, -2.04992533e-01f, -1.34527004e+00f, 1.24754071e+00f, -1.29923856e+00f,
  1.58326113e+00f, 1.04234982e+00f, -1.40091765e+00f, 4.29522365e-01f, 4.35749561e-01f, -1.56990445e+00f, -9.03072059e-02f, 6.95179641e-01f, 3.75985116e-01f, -5.31436741e-01f,
  2.98993349e-01f, -7.17759967e-01f, 4.57326800e-01f, 1.04830837e+00f, 7.28105366e-01f, 7.15914607e-01f, 4.11091864e-01f, 1.05650496e+00f, -6.29950941e-01f, -1.16717267e+00f,
  9.98334050e-01f, -6.44557178e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -2.06920356e-01f, 1.82218954e-01f, -7.24344254e-02f, -1.88673303e-01f, -3.03540975e-01f, -3.66350532e-01f, -4.46418710e-02f, 6.08754158e-01f, -2.82694548e-01f, 6.70447573e-02f,
  6.02556050e-01f, -6.30971789e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    