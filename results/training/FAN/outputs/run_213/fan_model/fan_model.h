/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -7.38991564e-03f, 2.23743357e-02f, 8.39459375e-02f, -6.02145605e-02f, -2.35868543e-01f, 3.10348213e-01f, 3.46769333e-01f, -1.54808357e-01f, -2.19782278e-01f, 8.35509226e-03f,
  -2.59692818e-02f, 1.60341725e-01f, 2.47912318e-01f, 4.18202057e-02f, 8.70760977e-02f, 1.89348504e-01f, 6.17470033e-02f, 1.86696835e-02f, -9.66139436e-02f, -1.41660515e-02f,
  -6.33607013e-03f, -2.53943391e-02f, 2.49323472e-01f, -1.66089565e-01f, 3.18150744e-02f, -4.25496623e-02f, -9.20808408e-03f, 7.28303269e-02f, -7.34565966e-03f, -2.74019409e-02f,
  -1.80634446e-02f, -9.19056609e-02f, -1.29239978e-02f, 1.05954222e-01f, 2.44809054e-02f, 4.30514514e-02f, 8.41338485e-02f, 8.21142122e-02f, -4.17820476e-02f, 2.22200919e-02f,
  9.53327343e-02f, -1.66900344e-02f, -4.87726852e-02f, -1.02836033e-02f, -6.56952010e-03f, -7.14044943e-02f, -4.02656868e-02f, -7.05419155e-03f, 3.24819610e-02f, 3.64595354e-02f,
  -1.76390095e-04f, -5.23586832e-02f, 1.14396242e-02f, 8.80603120e-03f, -1.64306071e-02f, -1.49071189e-02f, 3.56869437e-02f, 6.31072894e-02f, -6.18229713e-03f, -7.39038959e-02f,
  -2.35030148e-02f, 3.77933867e-02f, 1.15600163e-02f, -5.54264523e-02f, -6.61025580e-04f, -5.37433363e-02f, 1.85180232e-02f, -1.26723954e-02f, -1.67463832e-02f, -2.52396222e-02f,
  -9.10856947e-03f, 1.08520975e-02f, -5.41944010e-03f, 1.48237413e-02f, 1.97275002e-02f, -3.20371203e-02f, 3.43919210e-02f, -2.25841962e-02f, -2.56934557e-02f, -4.76150401e-02f,
  2.72731315e-02f, -1.43765621e-02f, -8.04697815e-03f, 2.30561141e-02f, -1.63896531e-02f, 6.86915172e-03f, -4.01067697e-02f, -5.37746772e-02f, 9.78803542e-03f, 2.76030954e-02f,
  3.08562983e-02f, 1.08938806e-01f, -3.05440067e-03f, -6.89060390e-02f, -2.04563756e-02f, -7.99926277e-03f, -1.69148557e-02f, -4.63626161e-02f, 1.50828501e-02f, 4.81170509e-03f,
  -8.53957385e-02f, 1.25504388e-02f, 8.67897868e-02f, -2.97038201e-02f, -1.86422002e-02f, 1.27205104e-02f, 5.13559729e-02f, -5.58271632e-03f, -4.80126357e-03f, -5.17176278e-02f,
  -3.61141600e-02f, 2.40159612e-02f, -3.85997258e-02f, -5.36434315e-02f, -1.01928376e-02f, 3.20912115e-02f, -2.35647764e-02f, 1.30848456e-02f, 1.38330432e-02f, 4.25048433e-02f,
  2.85993516e-01f, 6.60228357e-02f, 1.81653157e-01f, 6.09574281e-02f, -6.69838563e-02f, 1.03864349e-01f, -1.38626575e-01f, -3.94249596e-02f, 1.64221212e-01f, -1.29901618e-01f,
  -3.43078449e-02f, 9.15600061e-02f, -2.70839105e-03f, 1.21254697e-01f, 4.98336673e-01f, 2.20326722e-01f, 2.72515535e-01f, 2.31656320e-02f, 8.59947503e-02f, -5.67079484e-02f,
  1.13038607e-01f, -6.23947456e-02f, 1.20472282e-01f, -1.46108359e-01f, -1.14609629e-01f, -1.26814991e-01f, -1.12971216e-01f, -2.26775452e-01f, -8.01150594e-03f, 5.56088611e-02f,
  5.07762805e-02f, -1.79013554e-02f, -9.48154405e-02f, 5.21974787e-02f, -1.41570894e-02f, -6.20891936e-02f, -3.06909103e-02f, -8.92041344e-03f, -3.88014726e-02f, 4.02918868e-02f,
  -4.13676165e-02f, 8.12867098e-03f, 9.18064117e-02f, -2.21934486e-02f, -2.87016798e-02f, 2.08158623e-02f, 7.13856965e-02f, 4.68481070e-04f, -1.42530641e-02f, 4.80787680e-02f,
  8.26368779e-02f, 5.77900857e-02f, -2.73795594e-02f, 5.33683524e-02f, 8.66022054e-03f, -1.07887825e-02f, 1.31408954e-02f, -1.12260198e-02f, 5.49880452e-02f, 4.02076654e-02f,
  -2.98440102e-02f, -4.26787138e-02f, -1.61322542e-02f, -2.13940479e-02f, 7.60104088e-03f, -4.90695946e-02f, -9.89716779e-03f, 4.29295329e-03f, 2.42945012e-02f, -3.41175571e-02f,
  -2.02151611e-02f, -1.46939820e-02f, -5.70801273e-03f, -2.75905989e-02f, 1.88184511e-02f, -3.09649389e-02f, 3.84442657e-02f, 1.79605242e-02f, 3.21054384e-02f, 3.60325053e-02f,
  -7.29047731e-02f, 5.48272803e-02f, -4.66223760e-03f, 5.00752218e-03f, 8.49836227e-03f, -2.11057737e-02f, -4.24027592e-02f, 5.29837050e-02f, 3.27485218e-03f, -3.54638584e-02f,
  4.96131182e-02f, 8.22194964e-02f, 2.37303097e-02f, -1.64497364e-02f, 1.64688230e-02f, 5.91066442e-02f, 7.23388791e-02f, 1.88113768e-02f, 1.08857974e-01f, -2.60925386e-02f,
  -1.78373430e-03f, -3.26175280e-02f, -6.83362111e-02f, 1.69664361e-02f, -3.62596773e-02f, 8.27315375e-02f, -1.35399625e-02f, -1.95495188e-02f, -4.12397236e-02f, 1.37589155e-02f,
  -6.54686019e-02f, -2.06350014e-02f, -1.86217920e-04f, -4.10089120e-02f, 4.30572517e-02f, -3.48569751e-02f, 1.51535118e-04f, 5.28222695e-02f, -6.43432885e-02f, 1.20357433e-02f,
  5.18167198e-01f, -1.05458945e-01f, -8.78179595e-02f, 2.19928205e-01f, 2.46218413e-01f, 2.37660035e-01f, 3.31592053e-01f, 2.80768760e-02f, 1.44773215e-01f, -8.29495490e-02f,
  1.36212975e-01f, -1.36817455e-01f, -2.87684172e-01f, 2.12718159e-01f, -2.57991329e-02f, -1.07738897e-01f, 2.85184205e-01f, 4.91588376e-02f, 8.41873325e-03f, 7.22760633e-02f,
  4.41421792e-02f, 9.90895778e-02f, -7.57412538e-02f, -7.01511577e-02f, 1.48090109e-01f, 1.24174748e-02f, -9.28022340e-02f, -1.00913763e-01f, 2.18850635e-02f, 2.90477108e-02f,
  -7.15207905e-02f, -6.88000247e-02f, -2.95924451e-02f, -1.23344734e-03f, 1.29975989e-01f, 4.89140861e-02f, -1.86929237e-02f, 1.30722625e-03f, 5.07718930e-03f, 6.08029310e-03f,
  -2.92730480e-02f, 8.08418437e-04f, 2.91533973e-02f, -3.07752248e-02f, 8.74082670e-02f, 4.73123305e-02f, -3.17462087e-02f, 7.89298210e-03f, 1.74817294e-02f, -2.83489190e-02f,
  4.73960582e-03f, 1.50174079e-02f, 7.55619183e-02f, 2.06529777e-02f, 3.02716922e-02f, 8.61072466e-02f, 4.43206057e-02f, -8.86227563e-03f, 3.07210721e-02f, 1.00540467e-01f,
  2.17800736e-02f, 9.60625149e-03f, 3.56880575e-02f, -3.50011513e-02f, 1.79724414e-02f, 1.96068231e-02f, -5.54567948e-03f, -2.96007395e-02f, 1.44203929e-02f, 1.73162494e-03f,
  4.71463203e-02f, -1.08240056e-03f, 1.48318242e-02f, 3.52937467e-02f, 4.31567542e-02f, 8.72486085e-03f, 1.72329694e-02f, 2.50384323e-02f, 5.34696542e-02f, 2.33786404e-02f,
  -3.39502171e-02f, 3.07243243e-02f, -6.70556352e-02f, 2.93204412e-02f, 6.54609269e-03f, -2.23728567e-02f, 1.75882336e-02f, -2.83556040e-02f, 6.43519359e-03f, 1.94838941e-02f,
  8.15575421e-02f, 8.47242251e-02f, -1.54872090e-02f, 1.59763340e-02f, -8.43448713e-02f, -1.07763615e-02f, -8.07446521e-03f, 9.29305330e-04f, -1.78780984e-02f, 7.81534985e-03f,
  5.55691905e-02f, 2.83657834e-02f, -2.44797133e-02f, 5.15021347e-02f, -6.00013919e-02f, -3.00739892e-02f, 2.07628263e-03f, 2.11771112e-02f, 3.08113061e-02f, -2.82728113e-03f,
  -5.52211367e-02f, -2.18261819e-04f, -1.76693760e-02f, -7.39450799e-04f, 4.84580472e-02f, -3.93062942e-02f, -6.38937997e-03f, 1.47279250e-02f, -2.68697529e-03f, -5.77649884e-02f,
  2.58526564e-01f, 1.06327780e-01f, -2.80742913e-01f, -2.08235309e-02f, 2.92273350e-02f, 2.22647250e-01f, 1.32271694e-02f, -5.95452935e-02f, 5.49966656e-02f, 1.73204571e-01f,
  -5.16742393e-02f, 1.55828908e-01f, -1.45460501e-01f, -9.73507389e-02f, -9.85346958e-02f, -9.65308994e-02f, 5.98600693e-02f, 1.44251034e-01f, -1.30414188e-01f, 7.62630254e-02f,
  -4.32712510e-02f, -8.91980007e-02f, -1.82222724e-01f, -6.02574982e-02f, 5.32001406e-02f, 5.05611748e-02f, -1.81172527e-02f, -1.02595598e-01f, 2.12862492e-02f, -6.49740398e-02f,
  -4.64365780e-02f, -2.13244960e-01f, -3.09783965e-02f, 8.85322131e-03f, 7.14467466e-02f, 1.01345807e-01f, 9.50896144e-02f, -3.96681838e-02f, -4.61806692e-02f, -1.55080007e-02f,
  5.82726151e-02f, -1.77969988e-02f, -4.28195223e-02f, -5.63704111e-02f, 6.06266633e-02f, -5.86318336e-02f, -1.23131368e-02f, -4.65298444e-02f, -6.38270229e-02f, -1.75290611e-02f,
  -7.45582357e-02f, -4.84485514e-02f, 1.28930220e-02f, 4.41726260e-02f, -2.28214450e-02f, 2.28284113e-02f, -1.06757283e-02f, -8.91816802e-03f, 6.75970018e-02f, 4.66937050e-02f,
  -1.73897967e-02f, 4.53920253e-02f, -1.85703766e-02f, -3.81309772e-03f, 1.71095394e-02f, -2.96905749e-02f, 4.50562462e-02f, -5.22158220e-02f, 8.59514228e-04f, -2.01674900e-03f,
  4.41038795e-02f, 1.21451234e-02f, 3.11688357e-03f, 5.69114611e-02f, 3.32306623e-02f, 3.49442847e-02f, 2.29941364e-02f, 2.19269060e-02f, 1.72035936e-02f, 1.47676747e-03f,
  -1.93858240e-02f, 4.16361466e-02f, -2.63517890e-02f, 4.65976335e-02f, 1.78371172e-03f, 1.20356688e-02f, -2.63691023e-02f, 1.80422459e-02f, -1.27818063e-02f, -7.11583998e-03f,
  4.25622433e-01f, 1.92236498e-01f, 2.22014007e-03f, 6.90718973e-03f, 9.18308925e-03f, 2.40462925e-02f, -8.50980207e-02f, 3.45959142e-02f, 2.15995386e-02f, 2.73205079e-02f,
  4.36558165e-02f, 4.71972413e-02f, 1.03465885e-01f, 6.90844841e-04f, -6.93730786e-02f, 7.39076510e-02f, -6.01726410e-04f, 8.97653624e-02f, 6.79091215e-02f, 3.01773828e-02f,
  4.16696593e-02f, 4.09006365e-02f, -3.24666090e-02f, -8.07062909e-03f, 2.29345672e-02f, 1.83856674e-02f, 6.84777275e-02f, -2.19376590e-02f, -8.70524254e-03f, -3.84001993e-02f,
  -5.94627142e-01f, 5.83399177e-01f, 1.90267012e-01f, 6.53512627e-02f, -3.09224516e-01f, -1.21878885e-01f, -1.65827386e-02f, 4.28000139e-03f, -3.35017480e-02f, 3.02734047e-01f,
  -1.19464390e-01f, 5.61769977e-02f, 1.39667705e-01f, 9.12416875e-02f, -3.01718265e-01f, 2.11182222e-01f, -9.16812271e-02f, 2.41809357e-02f, 3.37663218e-02f, 5.53334244e-02f,
  -1.25797376e-01f, -8.30903128e-02f, 6.32589906e-02f, 6.17362186e-02f, -5.69060110e-02f, 7.84928128e-02f, 2.45469604e-02f, 8.41321796e-02f, -2.13713497e-02f, -5.20657673e-02f,
  -7.31245726e-02f, 5.85676357e-02f, -2.93719657e-02f, 8.84006843e-02f, -8.63766223e-02f, 1.23258987e-02f, 7.58474600e-03f, 3.69603932e-02f, -5.03096990e-02f, -6.58448413e-03f,
  -1.02693413e-03f, 3.99793824e-03f, -4.84438129e-02f, -2.00278275e-02f, -4.31840867e-02f, -4.73341579e-03f, -8.16152897e-03f, -5.21793552e-02f, 1.11476630e-01f, 1.11992778e-02f,
  9.96025652e-03f, 4.74737845e-02f, -6.96293777e-03f, 1.70198362e-02f, 2.19412427e-02f, 3.23814601e-02f, -2.96884403e-03f, 3.40896100e-02f, -2.97663659e-02f, -3.86115313e-02f,
  -1.04934543e-01f, 2.29226276e-02f, 2.89648864e-02f, -6.17752187e-02f, 3.02743744e-02f, -4.80009429e-02f, 1.62444506e-02f, 4.93602222e-03f, -2.66114622e-02f, 3.86477355e-03f,
  -2.36444641e-02f, 2.28915783e-03f, 3.28508648e-03f, -3.18828449e-02f, -2.30119983e-03f, -6.18018629e-03f, 2.70178244e-02f, 8.63281451e-03f, 5.41687291e-03f, 7.24016281e-04f,
  4.19657864e-02f, 1.83232548e-03f, 6.51607737e-02f, 8.66519101e-03f, 2.65081432e-02f, -1.86605379e-02f, -9.36052483e-03f, -1.01131396e-02f, -2.19408441e-02f, -3.74262817e-02f,
  5.93826212e-02f, 2.85855114e-01f, 7.04996064e-02f, -4.38469537e-02f, 1.11319676e-01f, 2.06463924e-03f, -1.24929789e-02f, -6.09179288e-02f, 1.23098753e-02f, -1.38398493e-02f,
  -3.94308660e-03f, 1.43572884e-02f, -1.47208394e-02f, -1.18326275e-02f, -6.41598273e-03f, -3.35014239e-02f, 1.34071499e-01f, 1.06177609e-02f, -6.24149852e-02f, -2.46309098e-02f,
  3.38639952e-02f, -1.48181738e-02f, -7.67080160e-03f, -2.99360193e-02f, -5.71212848e-04f, -3.38867903e-02f, -6.87295152e-03f, -2.73623802e-02f, 1.69444911e-03f, 2.61029545e-02f,
  -1.54587090e-01f, 1.52105302e-01f, 4.44341041e-02f, -1.15982957e-01f, -1.91450100e-02f, 3.75935957e-02f, -1.42555624e-01f, 9.72342938e-02f, 1.85875535e-01f, -2.60545090e-02f,
  -6.42610863e-02f, -5.80474921e-02f, -2.61224736e-03f, -1.90042630e-01f, -3.17953616e-01f, 8.99615735e-02f, -1.82157516e-01f, -9.82951894e-02f, 1.48465350e-01f, -2.09170043e-01f,
  -7.26543413e-03f, -2.56799310e-01f, -5.77476285e-02f, -7.40875825e-02f, -7.84506276e-02f, 9.01220515e-02f, -2.35722974e-01f, 4.26167548e-02f, -1.44765437e-01f, -7.02254921e-02f,
  -9.46473982e-03f, 1.13928378e-01f, 4.17686952e-03f, 4.50315513e-02f, 1.21160280e-02f, -1.10854749e-02f, -5.36877923e-02f, -3.45696285e-02f, 6.86926115e-03f, 6.30670264e-02f,
  1.74315441e-02f, -9.22561344e-03f, -3.14167677e-03f, 9.16968193e-03f, 4.48895842e-02f, 2.61461418e-02f, 5.08186221e-02f, 1.84797850e-02f, 4.59629819e-02f, 4.27335687e-02f,
  8.46606120e-03f, 4.21643592e-02f, -7.33509474e-03f, -1.98484026e-02f, 2.13773383e-04f, 3.88979428e-02f, 4.70316224e-02f, -3.30418609e-02f, 4.48130071e-02f, 1.65864713e-02f,
  -3.30184698e-02f, -1.33179978e-03f, -3.08095030e-02f, -9.57614649e-03f, -4.22109850e-02f, -2.79167648e-02f, -3.98319494e-03f, -7.08536133e-02f, 3.27815190e-02f, -7.17710033e-02f,
  -1.17519293e-02f, -3.15203238e-03f, -4.16577458e-02f, 9.98418313e-03f, -4.01930809e-02f, -1.28108365e-02f, -5.07295132e-02f, -1.76136643e-02f, 3.53716053e-02f, -8.18617828e-03f,
  -7.99825974e-03f, 1.43001173e-02f, -4.65297773e-02f, -4.48428653e-02f, -1.31191611e-02f, -1.75094325e-02f, 9.33770835e-03f, -2.17784708e-03f, 1.82004683e-02f, -4.63390863e-03f,
  -2.58212555e-02f, -6.93341270e-02f, 3.41921821e-02f, -2.74543706e-02f, -1.32697104e-02f, 7.37002306e-03f, 2.30692849e-02f, 1.83076970e-02f, 3.55420187e-02f, -1.89709496e-02f,
  -2.73725018e-02f, -1.43283745e-04f, -2.32621022e-02f, -1.45493159e-02f, -3.00243869e-02f, 2.49768682e-02f, -9.19267461e-02f, 2.63916627e-02f, -3.26571576e-02f, -2.20475346e-02f,
  -3.92092243e-02f, -5.16097210e-02f, 3.03856609e-03f, 2.49007973e-03f, -3.04787662e-02f, -3.92854810e-02f, -4.28833216e-02f, 5.30570783e-02f, -5.89968376e-02f, -1.70792211e-02f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.86662489e-01f, 3.95420551e-01f, 2.05978423e-01f, 3.45624954e-01f, -7.89610818e-02f, -3.18753093e-01f, -3.22757453e-01f, 1.90810084e-01f, -3.07839036e-01f, 1.17983781e-01f,
  9.88942832e-02f, 3.19823399e-02f, -9.05607045e-02f, -8.87207314e-02f, -3.53167564e-01f, -3.06188703e-01f, -4.48179804e-02f, -1.74300864e-01f, -1.69719517e-01f, 3.83316785e-01f,
  -1.74282230e-02f, 4.47745286e-02f, 5.60282953e-02f, 1.72087520e-01f, 1.54998854e-01f, 3.95076662e-01f, 5.22467494e-01f, 1.50678873e-01f, 3.74225646e-01f, -1.70928553e-01f,
  -2.71424174e-01f, -5.06689539e-03f, 8.66144747e-02f, -6.53981641e-02f, 1.59579646e-02f, 4.41813320e-02f, 3.98231111e-02f, -1.22864656e-01f, 1.14243878e-02f, -5.84877608e-03f,
  3.20767686e-02f, 1.68397166e-02f, -1.62124988e-02f, -8.08452368e-02f, -9.11381021e-02f, 1.60820112e-02f, 4.88090031e-02f, -1.91264357e-02f, -1.08189555e-02f, -1.89415645e-02f,
  3.74444947e-02f, 7.52510428e-02f, 1.29733741e-01f, -2.65364572e-02f, 2.21144613e-02f, 6.12046162e-04f, -2.18149531e-03f, 8.86261463e-02f, 1.46120731e-02f, -2.42896788e-02f,
  4.82579097e-02f, -2.93524638e-02f, -1.14231566e-02f, -7.54106715e-02f, 3.28412838e-02f, -1.84462965e-02f, -4.28938679e-02f, -5.46187162e-02f, -5.47590442e-02f, 7.36867217e-03f,
  4.88765351e-03f, 2.49701012e-02f, -9.56015065e-02f, 5.11503406e-02f, 3.04286517e-02f, 9.05783847e-03f, -2.84238346e-02f, 4.78931628e-02f, -9.52592236e-04f, -2.28833943e-03f,
  -7.53752291e-02f, 3.31144817e-02f, 5.68486452e-02f, 1.53989000e-02f, -5.78543171e-02f, 2.13819072e-02f, 6.93057328e-02f, 6.77258074e-02f, 4.18152697e-02f, -2.73506418e-02f,
  2.60807097e-01f, 5.92234612e-01f, -3.48357931e-02f, -8.06957036e-02f, 1.83167215e-02f, -5.21265343e-02f, -5.67080863e-02f, 7.58119598e-02f, 1.56939134e-01f, -1.20272208e-02f,
  7.01186433e-02f, -2.53117532e-02f, 5.27233072e-02f, -2.38095522e-02f, 8.06929767e-02f, 4.97748852e-02f, 1.05216570e-01f, 3.58720645e-02f, 1.17675275e-01f, 1.48442596e-01f,
  1.60212755e-01f, 1.45180998e-02f, -8.36620182e-02f, -5.13627976e-02f, 3.14508118e-02f, 1.12871453e-02f, 3.44522558e-02f, 6.43588901e-02f, -1.46555179e-03f, 2.45018024e-02f,
  6.48277640e-01f, 1.93413749e-01f, 5.46958625e-01f, 4.54733372e-01f, 1.00190856e-01f, -2.48599816e-02f, 3.87667954e-01f, -8.96188691e-02f, 2.54220158e-01f, -1.36788636e-01f,
  -8.23764801e-02f, 4.25412416e-01f, -1.63806766e-01f, 1.54453486e-01f, -1.97888836e-01f, -1.93638340e-01f, 3.80286239e-02f, 9.52921882e-02f, 4.59717065e-02f, 5.32606356e-02f,
  2.99022216e-02f, -4.09083247e-01f, 1.47038192e-01f, -3.59195232e-01f, 3.42607498e-01f, 1.36438370e-01f, -3.02444369e-01f, -3.03537119e-02f, -3.27523015e-02f, -1.02943733e-01f,
  7.29826838e-02f, 4.62672226e-02f, 1.27843156e-01f, -1.13224439e-01f, -3.16370763e-02f, 1.95874926e-02f, 7.41888806e-02f, -1.62567440e-02f, 5.71083985e-02f, 8.78087357e-02f,
  7.49170082e-03f, -5.32118604e-02f, -5.33270016e-02f, 3.19767147e-02f, -1.40489889e-02f, 5.27651645e-02f, 2.98135020e-02f, 5.25093898e-02f, 9.47186947e-02f, 1.24150664e-01f,
  1.08549960e-01f, 9.85640511e-02f, 8.21109712e-02f, -1.00141102e-02f, 7.53821880e-02f, 4.25472893e-02f, 6.32905439e-02f, 1.09078109e-01f, 6.60178736e-02f, 5.37552722e-02f,
  -7.69556388e-02f, -9.84700024e-02f, -2.01610364e-02f, -2.13177614e-02f, 3.00687589e-02f, 1.79597531e-02f, -2.81038665e-04f, -3.18396953e-03f, 4.85850237e-02f, -1.66103225e-02f,
  6.53552711e-02f, 7.87282083e-03f, -3.03756930e-02f, 9.30747092e-02f, 5.73265413e-03f, 6.20449893e-02f, 6.65382743e-02f, 4.25996538e-03f, 3.81615944e-02f, 2.03028526e-02f,
  2.83226054e-02f, -4.99676205e-02f, 3.32239717e-02f, 5.75216711e-02f, -2.87879612e-02f, 3.31875607e-02f, 1.85087174e-02f, 1.61845654e-01f, 3.85352038e-02f, 2.70099525e-04f,
  -3.08988065e-01f, -4.44700688e-01f, -3.83143798e-02f, 1.00577533e-01f, 5.37747401e-05f, -6.45345356e-03f, -9.01191756e-02f, 3.76093760e-02f, -5.30443341e-02f, -6.44953698e-02f,
  7.38106389e-03f, 7.34573379e-02f, 2.75517721e-02f, 5.90748759e-03f, -2.21160296e-02f, -1.91315599e-02f, -1.12486510e-02f, -1.17148288e-01f, -7.08529204e-02f, -6.60836324e-02f,
  -5.55006135e-03f, -3.06099020e-02f, 1.88593771e-02f, 5.07189110e-02f, 1.98607724e-02f, -6.52960390e-02f, 6.36233017e-02f, -1.68162361e-02f, -2.41720211e-02f, -1.04851656e-01f,
  3.62452894e-01f, -6.75683990e-02f, 1.04691580e-01f, 2.71295816e-01f, 1.17618591e-01f, 2.66852260e-01f, 6.20826006e-01f, 6.81433454e-02f, 5.40513754e-01f, -7.82431439e-02f,
  -9.61495265e-02f, 1.36913687e-01f, 6.71824664e-02f, 2.65097134e-02f, 2.24655196e-01f, 1.16865374e-01f, 1.56684384e-01f, 1.66068211e-01f, 1.60334900e-01f, 1.94121599e-01f,
  9.59346294e-02f, 1.30738348e-01f, -1.93431482e-01f, -3.24178427e-01f, -4.87768240e-02f, -8.07117671e-02f, -2.78872371e-01f, 4.35468927e-02f, -2.78690070e-01f, 1.47039734e-03f,
  -1.54133171e-01f, -1.54266544e-02f, -9.41589102e-02f, 2.63933036e-02f, -7.86613449e-02f, -5.35700656e-02f, -1.79244466e-02f, 1.66144464e-02f, -1.64600089e-03f, 5.33679277e-02f,
  9.22912452e-03f, -2.99817137e-02f, -9.83366463e-03f, 5.89824878e-02f, 3.52737866e-02f, -5.89373410e-02f, -1.03452250e-01f, -4.40183729e-02f, -7.27246553e-02f, -5.75551577e-02f,
  -1.13326823e-02f, -8.32578316e-02f, 7.64483027e-03f, -3.93172689e-02f, -4.37867977e-02f, 7.34729916e-02f, 2.96048019e-02f, -2.07345113e-02f, -1.85264263e-03f, 5.68263456e-02f,
  4.26589362e-02f, 4.00126427e-02f, 4.99338582e-02f, -2.22306233e-02f, -1.61432773e-02f, -7.78204575e-03f, -2.01963633e-02f, 1.69938225e-02f, 3.31025645e-02f, 5.98218217e-02f,
  3.87291191e-03f, 1.68879051e-02f, 5.96490204e-02f, -5.79288267e-02f, 5.12828380e-02f, -1.80158913e-02f, 7.17769191e-03f, -4.40213643e-03f, -1.21131237e-03f, 3.65217589e-03f,
  1.96136218e-02f, -5.95415849e-03f, -1.47830788e-02f, -1.06434254e-02f, -2.94182096e-02f, -1.20068407e-02f, -4.24297936e-02f, 4.33112979e-02f, -9.61484537e-02f, 1.29290912e-02f,
  2.09167913e-01f, 3.47560287e-01f, 2.02783253e-02f, -1.32410312e-02f, 1.56995468e-02f, -1.00112289e-01f, 5.19799702e-02f, 1.03534810e-01f, 1.69616211e-02f, 2.63377223e-02f,
  -1.44252395e-02f, 3.07849459e-02f, -6.38777856e-03f, -6.80692270e-02f, 1.36394557e-02f, 3.22739128e-03f, 4.73326482e-02f, 8.29522610e-02f, 8.17084387e-02f, -4.72453423e-02f,
  -2.66152546e-02f, 1.71657011e-01f, 9.28517208e-02f, 1.22383898e-02f, -8.07415578e-04f, -6.49784356e-02f, 6.58142120e-02f, -2.68781502e-02f, -1.09396428e-02f, 6.49309456e-02f,
  -7.65910566e-01f, 4.67036337e-01f, -8.02640691e-02f, 2.77414441e-01f, -1.62522107e-01f, 2.37663299e-01f, 3.12218994e-01f, 9.20610204e-02f, 2.29263932e-01f, 5.16570628e-01f,
  1.65447235e-01f, -7.26197064e-02f, 1.91788852e-01f, 4.05017972e-01f, -1.80995949e-02f, 3.93589497e-01f, 3.98501813e-01f, 2.46233135e-01f, -5.95563184e-03f, -1.33332208e-01f,
  -4.30202819e-02f, 1.11763529e-01f, -1.47543112e-02f, -1.45026445e-01f, -1.19050659e-01f, -2.47619301e-01f, 5.56459744e-03f, -2.94115126e-01f, 3.58561315e-02f, -2.56485515e-03f,
  -1.13244124e-01f, -1.92882583e-01f, -8.25051740e-02f, -9.13318098e-02f, 1.27490433e-02f, -3.40294763e-02f, -1.33318081e-02f, -8.99838433e-02f, -1.38170039e-02f, 5.46443788e-03f,
  -6.66698366e-02f, -1.06541529e-01f, -2.52104290e-02f, -3.03835119e-03f, -2.04358511e-02f, -1.22612054e-02f, -2.88007110e-02f, 5.38199842e-02f, -2.59873234e-02f, -2.61195749e-03f,
  -2.28438969e-03f, 8.09666216e-02f, 6.00448053e-04f, 1.33245781e-01f, -1.69442687e-02f, 8.29733610e-02f, 1.10845029e-01f, -6.54832572e-02f, 8.53416175e-02f, 6.45309240e-02f,
  -3.04552130e-02f, -8.64763707e-02f, 3.57813276e-02f, 2.59103347e-02f, -5.28359525e-02f, 1.04534682e-02f, -1.20651163e-02f, -2.72978842e-02f, -8.92803539e-03f, 1.86759401e-02f,
  1.15533303e-02f, 2.15248708e-02f, -7.81179667e-02f, 7.92817324e-02f, -6.28890619e-02f, 1.52734406e-02f, -4.29441258e-02f, -1.58286002e-02f, 6.86309561e-02f, 2.90472973e-02f,
  3.42506319e-02f, -6.18585851e-03f, 5.83549850e-02f, 2.32471116e-02f, -9.96755250e-03f, -5.88437133e-02f, 4.83345911e-02f, 5.50022162e-02f, -1.61629207e-02f, -1.71578936e-02f,
  1.50793418e-01f, 1.34509802e-01f, 8.26437771e-03f, -2.66416986e-02f, 3.75775434e-02f, -2.11922415e-02f, 2.08883844e-02f, 2.54150145e-02f, -1.05417185e-02f, -4.70862724e-02f,
  3.87136824e-02f, -2.22511031e-02f, 1.91994831e-02f, -2.48536207e-02f, 3.93228717e-02f, 1.35062575e-01f, -2.20430903e-02f, 1.09705869e-02f, 6.83008283e-02f, 1.20601512e-03f,
  -2.56346948e-02f, -3.44024599e-02f, 1.39607592e-02f, -2.59950254e-02f, 7.54473498e-03f, -2.42052339e-02f, -1.53372884e-02f, -7.85939246e-02f, 1.29987365e-02f, 1.16673112e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  5.39425790e-01f, 7.31889725e-01f, 1.55418620e-01f, 1.30973443e-01f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  1.60821021e-01f, -4.49709624e-01f, -4.57296103e-01f, 2.45269045e-01f, 7.05864847e-01f, 8.52398127e-02f, -3.22083980e-01f, -1.65350690e-01f, -8.03560019e-01f, 5.37764788e-01f,
  5.05536020e-01f, 9.85309720e-01f, -6.32517412e-02f, -2.16591861e-02f, 2.05764353e-01f, -3.23743373e-01f, 2.57381082e-01f, 2.59425551e-01f, -1.12516366e-01f, 1.43941775e-01f,
  -3.65399092e-01f, -4.87470746e-01f, -2.08254829e-01f, -2.31226116e-01f, 2.71544367e-01f, -2.40689088e-02f, -5.46842873e-01f, -7.47542500e-01f, 4.52551153e-03f, -3.87019962e-01f,
  -4.14803833e-01f, 3.29455256e-01f, 4.43279594e-02f, -8.74756694e-01f, -5.30314803e-01f, 2.31254712e-01f, -5.42165637e-01f, -8.53129551e-02f, -8.00696135e-01f, -5.99310935e-01f,
  3.26070398e-01f, -2.40198225e-01f, -1.02703147e-01f, 2.13406518e-01f, -2.66694039e-01f, -1.68400146e-02f, 1.90994561e-01f, -4.60781902e-01f, 2.83202022e-01f, -2.08702143e-02f,
  -3.22201073e-01f, -1.72929853e-01f, -5.83166257e-02f, -2.30480749e-02f, -2.82256544e-01f, 2.76834577e-01f, -3.43061984e-01f, -4.92590107e-02f, 5.68985343e-01f, 6.21211350e-01f,
  3.29401731e-01f, 2.17331015e-02f, -8.59050006e-02f, 1.51898578e-01f, -7.04903603e-01f, 3.86936426e-01f, 6.48290992e-01f, -2.67068446e-01f, -1.27781555e-01f, 1.68323547e-01f,
  1.08215320e+00f, 1.03049353e-01f, 8.44855905e-02f, -4.54625696e-01f, 3.11788440e-01f, -3.49807471e-01f, -7.74181113e-02f, 1.84306711e-01f, 9.98534560e-02f, 2.47323215e-01f,
  -1.48408949e-01f, -4.60106075e-01f, 5.47079980e-01f, -1.29358202e-01f, 7.92605430e-02f, 5.93661308e-01f, 7.06924871e-02f, -6.12680435e-01f, -1.35163546e-01f, -1.11062840e-01f,
  3.99142981e-01f, 7.90223300e-01f, -6.82338178e-02f, 4.88510519e-01f, 8.21589455e-02f, 1.57135457e-01f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  4.07239914e-01f, -5.72764933e-01f, 6.64133728e-01f, -2.51168549e-01f, 1.27363771e-01f, 2.19555482e-01f, -4.85066652e-01f, -7.87538648e-01f, 4.37782072e-02f, 2.22118333e-01f,
  6.06577694e-01f, -5.04248664e-02f, 1.56788433e+00f, 3.51289004e-01f, -3.87618989e-01f, -2.15965342e-02f, 4.88718480e-01f, 3.51307124e-01f, 1.69935510e-01f, 8.49546134e-01f,
  -2.55846500e-01f, 3.46509703e-02f, -4.66846317e-01f, -1.64476201e-01f, 2.29935139e-01f, -3.38423073e-01f, -7.10025609e-01f, 4.25986759e-02f, -1.69762120e-01f, 1.54156840e+00f,
  3.20540488e-01f, -4.89983618e-01f, 1.98591262e-01f, -3.18937153e-02f, 2.35948503e-01f, 3.27178299e-01f, 5.81703663e-01f, 4.06077266e-01f, 5.88922858e-01f, -1.28638789e-01f,
  9.46920633e-01f, 8.76912534e-01f, -1.18286565e-01f, -7.51310945e-01f, 3.66562665e-01f, -3.41046572e-01f, 9.17404771e-01f, 9.04562354e-01f, 5.06863117e-01f, 5.88696063e-01f,
  6.79871365e-02f, 5.02954721e-01f, -9.58624706e-02f, -2.61951745e-01f, -2.65682280e-01f, 6.28128052e-02f, -4.47615296e-01f, -1.25135505e+00f, 4.65902507e-01f, 2.02041820e-01f,
  2.84110993e-01f, -3.23295236e-01f, -6.90971017e-01f, 9.21938002e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  3.01256299e-01f, 5.16561985e-01f, 5.29637992e-01f, 7.37342238e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  -2.30765343e-01f, 5.44899888e-02f, -1.97188765e-01f, 1.42690778e-01f, -7.82288015e-01f, 2.52567660e-02f, -4.62461799e-01f, 5.92754602e-01f, 3.00731272e-01f, -1.64075300e-01f,
  4.94275093e-01f, 2.80132741e-01f, -2.98874885e-01f, -8.65148544e-01f, 4.87299562e-01f, 8.36761057e-01f, -1.45872891e-01f, -5.89455813e-02f, -4.67378765e-01f, 5.29518761e-02f,
  6.24741793e-01f, -2.90308688e-02f, -7.09847808e-01f, 1.01423526e+00f, -5.15029967e-01f, -2.19040722e-01f, 5.30165374e-01f, -1.24063873e+00f, -1.56104624e-01f, -6.41342103e-01f,
  1.11962211e+00f, -4.52071518e-01f, -5.49112976e-01f, -6.70686841e-01f, 6.35880172e-01f, 2.59587616e-01f, 3.94933820e-01f, -1.08629130e-01f, -6.69290543e-01f, 1.31120598e+00f,
  7.11303830e-01f, -7.46190608e-01f, -5.86348712e-01f, -8.44506025e-01f, 2.21828014e-01f, 6.04093909e-01f, -6.69862255e-02f, 1.54094458e-01f, -7.66898334e-01f, 4.46948558e-02f,
  3.07002664e-01f, -2.65726358e-01f, -2.80198574e-01f, -1.38050377e-01f, 5.48984647e-01f, -2.52230525e-01f, 1.17710304e+00f, 7.55439579e-01f, -8.34226310e-01f, 8.07937562e-01f,
  5.74331284e-01f, -1.76721543e-01f, -9.59224761e-01f, 6.27395272e-01f, 8.38378608e-01f, 4.58254337e-01f, -5.60722709e-01f, 5.75297713e-01f, 5.47941387e-01f, 6.15142733e-02f,
  4.75480825e-01f, -5.80985665e-01f, -8.56679857e-01f, 3.22352201e-01f, 6.62766874e-01f, 8.09398592e-01f, -4.57707375e-01f, 1.63856208e-01f, -5.12272477e-01f, 1.01915061e+00f,
  9.53605354e-01f, -1.66969046e-01f, 2.89606093e-03f, 3.06046903e-01f, 8.01926702e-02f, -2.21897643e-02f, 6.38345599e-01f, -1.04488993e+00f, -1.32165134e-01f, 1.05354264e-01f,
  7.92166471e-01f, 3.94573033e-01f, -4.42775756e-01f, -3.12687576e-01f, 1.20076799e+00f, -6.81297004e-01f, 3.67557466e-01f, 4.95381989e-02f, 4.87830967e-01f, 7.36739784e-02f,
  7.46385932e-01f, -1.14531107e-01f, -6.00535691e-01f, -5.36679864e-01f, 9.20692742e-01f, -3.15496713e-01f, -1.07474901e-01f, 4.16371644e-01f, -6.97607815e-01f, 1.03385735e+00f,
  -1.60747498e-01f, -5.15101731e-01f, -3.21702838e-01f, 6.67341053e-01f, 7.52850354e-01f, 5.46469450e-01f, -1.25936940e-01f, 7.82897532e-01f, 1.15407813e+00f, -9.95427072e-02f,
  -5.40164113e-01f, 4.62497652e-01f, -1.26691186e+00f, -8.58391643e-01f, -9.38510060e-01f, 3.45806688e-01f, -4.96007085e-01f, 5.74604511e-01f, 4.22852039e-01f, -4.10879292e-02f,
  -6.63552642e-01f, -4.23148364e-01f, 2.36815378e-01f, -9.56181660e-02f, -8.22067857e-01f, -3.22908117e-03f, 3.86272594e-02f, 3.48460793e-01f, 3.00234079e-01f, -3.89827549e-01f,
  9.39308822e-01f, -5.67807734e-01f, -2.98538297e-01f, 4.37895805e-01f, -1.78107545e-01f, 2.29314670e-01f, -1.34674013e-01f, -2.24272817e-01f, -1.26465499e+00f, 9.73214954e-02f,
  -6.35809243e-01f, -5.93904853e-01f, -1.04175878e+00f, -8.23846698e-01f, 7.74681985e-01f, -1.60457920e-02f, -7.16657102e-01f, 8.78180087e-01f, 1.23129293e-01f, -6.23903453e-01f,
  -3.65844630e-02f, 1.90914288e-01f, 2.29387641e-01f, 5.50812595e-02f, -3.30100656e-01f, -4.81614709e-01f, 7.70197690e-01f, -1.53457046e-01f, -1.94435924e-01f, -8.10845345e-02f,
  -6.81981206e-01f, 5.51654816e-01f, 1.05199325e+00f, -7.48843729e-01f, 3.88933510e-01f, -7.59500802e-01f, 2.87587121e-02f, -8.03903043e-01f, -1.58064842e-01f, -1.19676106e-01f,
  2.64944553e-01f, -5.77150285e-01f, 7.39212513e-01f, -5.10466576e-01f, -2.43866310e-01f, 3.03682629e-02f, -6.33266717e-02f, -5.32618575e-02f, 6.47094607e-01f, 8.18330169e-01f,
  -7.75645614e-01f, -5.86090982e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -5.75163402e-02f, -3.85860428e-02f, 1.24152400e-01f, 2.23172307e-01f, 1.14168510e-01f, -7.85185099e-02f, -1.53747872e-01f, 3.75542909e-01f, -3.23877126e-01f, 6.95752501e-02f,
  -1.11750225e-02f, -7.16736466e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    