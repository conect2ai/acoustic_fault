/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.48134604e-01f, -1.92371577e-01f, -2.95375884e-01f, 7.25249350e-02f, -4.22934704e-02f, 1.59550563e-01f, 2.16743201e-01f, 3.92081728e-03f, -2.11552009e-01f, 1.72403574e-01f,
  1.53652340e-01f, -4.12716299e-01f, -1.07821412e-01f, 1.97634637e-01f, -4.14673090e-01f, -7.54279271e-02f, 1.55525342e-01f, 1.22453757e-01f, -3.02651137e-01f, 4.65509258e-02f,
  -6.26639947e-02f, 1.29406929e-01f, -1.03220847e-02f, 4.49617170e-02f, 3.15857381e-01f, -5.47084026e-02f, 2.81243533e-01f, -1.22611061e-01f, 2.46777683e-01f, -8.67936760e-02f,
  3.39306369e-02f, -8.96373615e-02f, 4.90855165e-02f, -6.97935373e-02f, 1.87914506e-01f, 9.14824158e-02f, -5.97596802e-02f, -7.12079480e-02f, 5.08502638e-03f, -5.13677113e-02f,
  -5.30051254e-02f, -1.55126631e-01f, -6.70779049e-02f, -6.80586621e-02f, 3.54811065e-02f, -1.01010740e-01f, -7.17167184e-02f, 1.27340704e-01f, -1.50690407e-01f, 1.41876214e-03f,
  -7.21613616e-02f, -2.25372333e-02f, 7.89619908e-02f, -3.36618721e-02f, -1.17443435e-01f, -6.98087960e-02f, 1.62368156e-02f, -2.67753061e-02f, 1.80825144e-02f, -3.46034728e-02f,
  4.07332741e-03f, -7.15017766e-02f, 6.40251162e-03f, 2.22949348e-02f, -6.23072460e-02f, 5.23155071e-02f, -9.57883671e-02f, 3.62303369e-02f, 4.08720002e-02f, -5.68675846e-02f,
  8.45723376e-02f, -5.45184314e-03f, -7.12762326e-02f, 8.18245783e-02f, 5.82767017e-02f, -4.65367176e-02f, 1.55361462e-02f, -2.06788369e-02f, 3.69431973e-02f, 9.12256166e-02f,
  -4.93412279e-02f, -2.51771603e-02f, -3.50825861e-02f, 5.19918911e-02f, -6.61403686e-02f, -1.32603154e-01f, -6.68484494e-02f, 6.87345117e-03f, -3.85772847e-02f, -1.71181094e-02f,
  1.62879035e-01f, 4.31684367e-02f, 1.96529422e-02f, -5.65573499e-02f, 1.26221718e-03f, -2.68041380e-02f, -1.01344727e-01f, 3.67296599e-02f, -5.81362657e-02f, 8.34773388e-03f,
  -2.74963323e-02f, 1.81857243e-01f, 2.53646448e-02f, 6.76723346e-02f, -3.37037002e-03f, 3.99791636e-02f, 4.77603450e-02f, 4.91727293e-02f, 1.39356896e-01f, 2.89946906e-02f,
  7.76637867e-02f, 1.86189692e-02f, -2.33059805e-02f, 6.84843808e-02f, 1.71668336e-01f, 1.64659563e-04f, -2.21335962e-02f, -2.03951299e-02f, 1.89258438e-02f, 2.09028535e-02f,
  -5.63150823e-01f, 3.58010113e-01f, 2.02808112e-01f, -3.50367963e-01f, 8.56871158e-03f, -3.21880132e-01f, -2.05171764e-01f, 2.51364913e-02f, -2.06474021e-01f, 3.29333693e-01f,
  -2.19855651e-01f, 1.43874720e-01f, 1.03172071e-01f, -1.55401558e-01f, -5.57127416e-01f, -4.16006371e-02f, -2.12740675e-01f, -1.10332906e-01f, -1.55919362e-02f, -2.00648885e-02f,
  -1.15762800e-01f, -1.93010390e-01f, 5.39952703e-02f, 1.48967028e-01f, 7.36167356e-02f, 1.59262165e-01f, 3.27565260e-02f, 2.32442230e-01f, -6.36806414e-02f, 2.37118583e-02f,
  -5.17241508e-02f, 9.19081047e-02f, 1.61031693e-01f, 6.02057539e-02f, -6.57843724e-02f, 2.75713857e-02f, -2.47625094e-02f, 5.97546026e-02f, -1.01154940e-02f, -1.33272298e-02f,
  4.11544144e-02f, -5.79882823e-02f, -6.92198873e-02f, 5.77130131e-02f, 3.44514544e-03f, 8.62613693e-02f, 7.03757927e-02f, 3.44608426e-02f, 3.32874171e-02f, -6.85416802e-04f,
  7.73394033e-02f, 1.73809845e-02f, 8.30230210e-03f, 3.83675545e-02f, -6.01060688e-03f, 1.21132685e-02f, -1.59350745e-02f, 5.09714074e-02f, -4.84603643e-02f, -6.35107458e-02f,
  2.88182292e-02f, -3.46537307e-02f, 1.00290477e-01f, -5.36746066e-03f, -7.48313516e-02f, 4.43130061e-02f, 7.41078481e-02f, -8.07334576e-03f, 9.50303599e-02f, 1.50681706e-03f,
  -1.24317899e-01f, -1.37182958e-02f, -2.88583413e-02f, 9.29310638e-03f, -1.36896409e-02f, -2.98355930e-02f, 3.95497270e-02f, 6.79717660e-02f, -9.12051201e-02f, -1.88040826e-02f,
  2.26299744e-02f, -1.01452563e-02f, 4.02962882e-03f, 1.69961005e-02f, 3.42352018e-02f, -6.61232928e-03f, 2.82306243e-02f, 3.77227068e-02f, 4.14338289e-03f, -1.04339004e-01f,
  -2.60042936e-01f, -2.18673244e-01f, -6.23433776e-02f, 2.20302511e-02f, 5.47059067e-02f, 7.25381002e-02f, -3.11145671e-02f, 1.57827549e-02f, 9.67645049e-02f, -7.80335590e-02f,
  1.50189204e-02f, 4.58884127e-02f, -8.62722751e-03f, 1.81937907e-02f, -6.60688803e-02f, -7.98139721e-02f, -2.22559981e-02f, -1.73006654e-02f, -8.11457038e-02f, -4.89176586e-02f,
  -2.31369622e-02f, -5.36266118e-02f, 2.33710147e-02f, -2.31416384e-03f, -4.02573943e-02f, -4.39599901e-02f, -4.83334027e-02f, -5.15509979e-04f, 2.53171362e-02f, 4.16675173e-02f,
  4.82193381e-02f, -1.01731382e-01f, -4.26986307e-01f, -9.93341431e-02f, -6.20716996e-02f, 1.57624379e-01f, 2.74023861e-01f, -1.76816866e-01f, -1.48638442e-01f, 2.20742106e-01f,
  2.60852784e-01f, -1.03778265e-01f, 1.03608377e-01f, 6.45568944e-04f, 1.38792723e-01f, 1.53024837e-01f, 1.90822706e-01f, 1.67965353e-01f, -1.61113039e-01f, -3.44640985e-02f,
  -1.19506963e-01f, 2.00429544e-01f, -9.64997560e-02f, -3.25026244e-01f, -2.15271413e-01f, -1.41409501e-01f, 2.90272266e-01f, -1.06027424e-01f, 1.48951441e-01f, 7.89540261e-02f,
  1.18239783e-01f, -1.90377235e-01f, -1.12255596e-01f, -7.95487165e-02f, 7.84902647e-02f, 1.46691084e-01f, 8.45927373e-02f, -4.43858542e-02f, -2.84964759e-02f, -7.15446798e-03f,
  5.68944849e-02f, 1.40776746e-02f, -3.76347452e-02f, -5.08560464e-02f, -5.95767349e-02f, -1.38407290e-01f, -1.57798767e-01f, -7.05712736e-02f, -3.31821404e-02f, 1.46271000e-02f,
  -1.17561743e-01f, 4.97105531e-02f, 5.67715839e-02f, 6.16087615e-02f, -1.36258788e-02f, -1.12481087e-01f, 1.82943344e-02f, 5.34772463e-02f, 2.14666016e-02f, -6.95199072e-02f,
  -1.14504047e-01f, 7.30511099e-02f, -8.07892345e-03f, 7.22130295e-04f, -5.35231689e-03f, 2.02935450e-02f, -3.91128771e-02f, 4.57073599e-02f, -5.37661761e-02f, 3.88637073e-02f,
  3.01676374e-02f, 6.88554123e-02f, -2.98494194e-02f, 6.14202395e-03f, 2.56875367e-03f, 3.35643440e-02f, -1.58451346e-03f, 7.29197562e-02f, 2.15503257e-02f, 2.56507937e-02f,
  3.90773080e-02f, 2.42078640e-02f, -2.66148318e-02f, 4.33288924e-02f, -2.34798770e-02f, 1.61271505e-02f, -1.18128760e-02f, -5.75619899e-02f, -9.59406141e-03f, 1.55265359e-02f,
  3.61986250e-01f, 1.27160624e-01f, 2.38861423e-02f, 4.19265181e-02f, -6.43390417e-02f, 6.70560598e-02f, -6.12013228e-02f, 6.70475140e-03f, -4.10394296e-02f, -1.69921424e-02f,
  -1.46944206e-02f, 5.66400997e-02f, 5.95123433e-02f, 1.08098410e-01f, -4.93362024e-02f, 1.14043586e-01f, 1.55002147e-01f, 1.14611149e-01f, 9.11342949e-02f, 2.42202953e-02f,
  2.95595322e-02f, -4.69565541e-02f, -9.06074867e-02f, 9.33200717e-02f, 1.03855789e-01f, 5.71029708e-02f, -3.87768447e-02f, -4.35567759e-02f, -2.08053761e-03f, 8.43610540e-02f,
  3.96420002e-01f, -4.57119226e-01f, -8.68037269e-02f, -4.19683345e-02f, -1.10152438e-01f, 2.41822228e-02f, -1.30669504e-01f, -2.06248745e-01f, -3.73898536e-01f, -1.30452365e-01f,
  -2.06404209e-01f, 2.15526313e-01f, -2.61886001e-01f, 1.04713842e-01f, 3.54658633e-01f, -3.55823368e-01f, 2.53973335e-01f, -3.78579013e-02f, -1.20875604e-01f, 1.70477927e-02f,
  -4.80716713e-02f, 5.13561964e-02f, 1.89130053e-01f, -3.89380902e-02f, 1.09745875e-01f, -9.70135555e-02f, 2.76938915e-01f, -1.63616404e-01f, 2.19732866e-01f, -8.24118033e-03f,
  -5.94393909e-02f, -1.57620028e-01f, 4.79266606e-02f, 7.31117418e-03f, -1.54587934e-02f, -3.60142477e-02f, 2.99443863e-02f, -2.96531022e-02f, -1.23291416e-02f, -4.76587750e-02f,
  -1.04797408e-02f, 5.55494167e-02f, 3.50787956e-03f, -3.83772552e-02f, -4.41813283e-03f, -4.71151769e-02f, 6.01881370e-02f, 4.85443771e-02f, -1.02186516e-01f, -2.43720859e-02f,
  -2.06841286e-02f, -2.31015123e-02f, 3.73370163e-02f, -3.19709890e-02f, 5.27244247e-02f, -1.21684410e-01f, -4.02287841e-02f, -3.90880108e-02f, 4.92341183e-02f, -3.19931693e-02f,
  2.95182709e-02f, -1.10653333e-01f, 2.87304837e-02f, -4.61179614e-02f, -3.41515765e-02f, -6.73082322e-02f, 5.28964661e-02f, 3.53509933e-02f, 1.13012634e-01f, -6.58496004e-03f,
  3.71618830e-02f, 6.53806515e-03f, -3.02868336e-02f, -6.44528482e-04f, 4.64164503e-02f, -2.03953646e-02f, 8.92406106e-02f, -6.40784949e-02f, -1.13009370e-03f, 2.27635670e-02f,
  -2.26852261e-02f, -5.86910639e-03f, -5.09749027e-03f, -1.77710298e-02f, 1.99140068e-02f, -1.22728990e-02f, -2.12288741e-02f, 9.14528500e-03f, -4.78786230e-02f, 6.11385889e-02f,
  -7.88525492e-02f, -1.55983940e-01f, -4.38918844e-02f, 7.70057291e-02f, 2.50017550e-02f, 6.02305904e-02f, 5.10170758e-02f, 8.18369761e-02f, -8.91074538e-02f, 1.68885514e-02f,
  2.85949092e-02f, 2.84815915e-02f, 4.43104655e-02f, -5.28273080e-03f, 3.89684960e-02f, 3.07223713e-03f, 1.10458815e-03f, 3.37851867e-02f, 9.76160988e-02f, -5.55057041e-02f,
  1.26137450e-01f, 3.92262638e-02f, 3.53526510e-02f, 1.03671942e-03f, 4.72755656e-02f, 3.23281921e-02f, 2.54302043e-02f, 3.15563828e-02f, 2.22771876e-02f, 4.24916446e-02f,
  1.44906923e-01f, 1.31054997e-01f, 6.00999743e-02f, 2.78135538e-01f, 4.50332388e-02f, -4.47198421e-01f, -4.61444467e-01f, 2.33745992e-01f, -2.33565886e-02f, -1.15888871e-01f,
  -2.61081830e-02f, 2.72601426e-01f, -2.51597106e-01f, 2.39787370e-01f, 4.63648379e-04f, -2.33069077e-01f, -1.66315585e-02f, 8.25587474e-03f, -7.83497700e-04f, 1.48339123e-01f,
  1.55742317e-01f, 8.06095358e-03f, 7.89843947e-02f, 1.24978319e-01f, 9.95618403e-02f, 1.34481296e-01f, 1.96851298e-01f, 1.12000905e-01f, 1.44656315e-01f, -3.73994671e-02f,
  -1.18807711e-01f, -8.07243064e-02f, 9.66916010e-02f, -3.11786286e-03f, -4.97433059e-02f, -4.17970903e-02f, -8.86833109e-03f, 8.64618924e-03f, 2.66021416e-02f, -1.77748455e-03f,
  6.05988968e-03f, 8.36724415e-02f, 4.46849950e-02f, 5.71315829e-03f, 4.05988432e-02f, 6.28668740e-02f, 1.10916588e-02f, -4.12586518e-02f, 5.98820718e-03f, 1.96635677e-03f,
  -1.00567624e-01f, -2.54597012e-02f, -2.96799690e-02f, -4.96200100e-02f, -3.76809668e-03f, -5.04042357e-02f, -5.76341785e-02f, -5.70031889e-02f, 6.90191286e-03f, 1.07449507e-02f,
  -5.92543446e-02f, -2.49134507e-02f, -1.09013328e-02f, -2.56772875e-03f, -2.41676290e-02f, -5.59644140e-02f, -3.19791175e-02f, -2.25826278e-02f, 8.29209238e-02f, -4.15449888e-02f,
  -1.39352903e-02f, 2.32214965e-02f, 2.30762530e-02f, 1.89529061e-02f, -9.15648695e-03f, -3.80078815e-02f, -2.38290727e-02f, -1.53450854e-02f, -1.64203290e-02f, 3.40097286e-02f,
  1.25920167e-02f, -2.76257042e-02f, -2.44955067e-02f, -2.97933705e-02f, -1.07955165e-01f, -1.64396758e-03f, 9.11626965e-02f, -2.31463742e-02f, 8.93848296e-03f, -2.23928131e-03f,
  -9.62959528e-02f, 1.84611365e-01f, -9.74247828e-02f, -1.62552930e-02f, 2.69551352e-02f, 9.96303335e-02f, 9.31499749e-02f, 7.37562925e-02f, 8.65930878e-03f, -5.44936210e-02f,
  1.23927921e-01f, -2.03107111e-02f, 1.09821733e-03f, -2.71447338e-02f, -4.03315015e-02f, -6.62995130e-02f, -1.61000974e-02f, 9.38967690e-02f, 5.65029643e-02f, 9.66393650e-02f,
  5.44453152e-02f, -9.90031194e-03f, 3.33722564e-03f, -5.12927398e-02f, 8.40607099e-03f, -6.63685650e-02f, 9.67207998e-02f, -2.83457022e-02f, -2.08680313e-02f, 8.31783097e-03f,
  -3.44258606e-01f, 4.99024957e-01f, -3.63341391e-01f, -2.22533923e-02f, -9.72347450e-04f, 1.55589566e-01f, -2.34677922e-03f, 1.51124761e-01f, -8.11229795e-02f, 2.46431112e-01f,
  6.76770285e-02f, 2.69902050e-01f, -7.45280012e-02f, 4.04754192e-01f, -4.00813282e-01f, 1.58545062e-01f, 6.83437437e-02f, 1.25156224e-01f, 6.56268373e-02f, 6.38270425e-03f,
  -7.29791522e-02f, 9.13691595e-02f, 4.15772609e-02f, 6.06124289e-02f, 9.30089056e-02f, -1.52647063e-01f, -3.69952381e-01f, -7.20219165e-02f, 6.09172508e-02f, 1.10171355e-01f,
  5.72752208e-02f, -8.25945064e-02f, 2.03700047e-02f, -1.34743124e-01f, -7.83784240e-02f, -1.30104482e-01f, -1.13044400e-02f, -5.79007566e-02f, 4.05814275e-02f, 3.62069421e-02f,
  3.83897871e-02f, 1.85254924e-02f, 5.58484942e-02f, 9.16538108e-03f, 1.72181688e-02f, -1.02111930e-02f, 9.14934501e-02f, 1.28818765e-01f, 1.05283909e-01f, 8.10765252e-02f,
  5.76353706e-02f, 5.05184866e-02f, -4.11178246e-02f, 2.19319761e-02f, -6.06597327e-02f, -5.55019677e-02f, -3.61666642e-02f, 5.40670827e-02f, 9.95141938e-02f, 2.50235968e-03f,
  -2.84464732e-02f, 1.03682722e-03f, 4.80793901e-02f, 2.29112115e-02f, -5.99594228e-02f, 8.46196786e-02f, -1.01047773e-02f, 3.36939618e-02f, -5.86393438e-02f, -5.63650765e-02f,
  5.28243817e-02f, -9.52082593e-03f, -7.04357550e-02f, -9.29348841e-02f, -4.78774123e-02f, 7.18948171e-02f, -9.68953688e-03f, 4.68115471e-02f, 4.96779308e-02f, 1.01050420e-03f,
  -7.57954642e-03f, -3.22044529e-02f, 9.88437757e-02f, 4.49555628e-02f, 3.85130979e-02f, -5.22696227e-02f, -2.54054442e-02f, 9.93293449e-02f, 2.78730486e-02f, -1.32530972e-01f,
  -9.95086953e-02f, -3.80335897e-01f, 1.39270267e-02f, 2.05999408e-02f, -5.09280562e-02f, 1.23508036e-01f, 4.49917372e-03f, 4.66660522e-02f, -8.88315290e-02f, -7.16951415e-02f,
  -4.58384529e-02f, -2.71183308e-02f, -9.32697430e-02f, -9.87929571e-03f, -4.65100668e-02f, -1.64056960e-02f, 1.93742651e-03f, -1.28056303e-01f, -1.26084462e-01f, -1.83583573e-02f,
  -3.90307270e-02f, -5.80010116e-02f, -1.16412088e-01f, -6.48023784e-02f, -2.31237784e-02f, 9.96478461e-03f, -6.77571669e-02f, -1.70467254e-02f, -1.43072352e-01f, 8.97552222e-02f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  8.12458932e-01f, 9.39015210e-01f, 1.97882935e-01f, 3.81801605e-01f, -2.35400442e-02f, 7.08204031e-01f, 2.98029333e-01f, 1.41192541e-01f, 4.25660402e-01f, 3.67232561e-01f,
  -2.66113818e-01f, 6.67889893e-01f, -3.43795717e-01f, 4.09269780e-01f, -1.18133992e-01f, -2.44093210e-01f, 4.71130759e-01f, 3.45175296e-01f, -2.19904315e-02f, 4.50235754e-01f,
  5.22233881e-02f, -3.24238576e-02f, -3.05169612e-01f, -1.68970093e-01f, 3.21525365e-01f, -3.07959085e-03f, -6.26984656e-01f, -4.35957998e-01f, -6.98350668e-02f, -1.26284748e-01f,
  -7.10425004e-02f, 5.70416152e-02f, 6.53448254e-02f, -8.66385326e-02f, 8.97375867e-02f, 1.84888840e-02f, -1.17418073e-01f, -1.32219598e-01f, -1.79304838e-01f, 6.20688349e-02f,
  1.40102580e-01f, -1.31551055e-02f, 1.52485520e-01f, -5.24296612e-03f, 1.56012729e-01f, 2.77158860e-02f, 3.45016867e-02f, -1.65276020e-03f, 5.12987860e-02f, 5.69449440e-02f,
  1.06470160e-01f, 4.10336778e-02f, 4.30966429e-02f, -2.79278718e-02f, 4.26471122e-02f, 5.64961769e-02f, 3.49772759e-02f, 3.96229932e-03f, 1.74252242e-01f, 1.74158424e-01f,
  3.11781298e-02f, -3.56760249e-02f, -2.74287555e-02f, -1.41619861e-01f, 1.37630269e-01f, -7.33595341e-02f, 5.85956797e-02f, -8.41404349e-02f, 8.62503648e-02f, 9.01488140e-02f,
  -2.73074713e-02f, -2.57962085e-02f, -6.45550936e-02f, 4.39427458e-02f, 9.47513431e-02f, 1.03309326e-01f, -5.89564741e-02f, -7.95182213e-02f, 2.47164797e-02f, -5.05974181e-02f,
  -1.40129566e-01f, 3.61053795e-02f, 1.43370535e-02f, -7.51262084e-02f, 1.19504426e-02f, -8.68785530e-02f, 6.03715405e-02f, 1.28071621e-01f, -7.33769536e-02f, -8.37618951e-03f,
  1.92979127e-01f, 4.69035417e-01f, -6.80346638e-02f, -4.24443372e-02f, -1.38188070e-02f, 1.16192810e-01f, 1.62875671e-02f, 2.77028471e-01f, 4.83651944e-02f, 5.99472225e-03f,
  4.26531918e-02f, -8.93055927e-03f, -3.82627659e-02f, -2.20207553e-02f, -1.09258972e-01f, 1.77220806e-01f, -7.52396360e-02f, -1.03044249e-02f, -7.23514482e-02f, 1.68931931e-02f,
  4.78968918e-02f, 9.50745121e-02f, 4.90026409e-03f, 6.52726367e-03f, 6.98156506e-02f, -9.61185247e-02f, 2.50615567e-01f, -1.00947611e-01f, -8.63341168e-02f, -1.82018094e-02f,
  -8.05179477e-01f, 6.43930972e-01f, 9.67774168e-02f, -1.87577307e-01f, -1.66394979e-01f, -4.55147922e-01f, -5.26528895e-01f, 1.06087014e-01f, -3.70854825e-01f, -1.74670648e-02f,
  1.31225365e-03f, -2.93783665e-01f, 3.94682854e-01f, 1.91680655e-01f, 1.37539238e-01f, 7.48609364e-01f, 5.95626235e-02f, -1.56817332e-01f, 1.75102040e-01f, 8.27884004e-02f,
  9.98305678e-02f, 1.97902471e-01f, 6.49465084e-01f, 3.39289248e-01f, -1.01215214e-01f, -1.44252941e-01f, 3.95316668e-02f, 8.28455314e-02f, -1.64816916e-01f, -1.06308080e-01f,
  2.17205867e-01f, 3.25105578e-01f, -1.35094216e-02f, -2.08327323e-02f, 1.60727173e-01f, -1.64585531e-01f, -1.58914104e-01f, -1.40549123e-01f, -1.28547460e-01f, -1.44052014e-01f,
  -9.76706892e-02f, 8.22832733e-02f, -1.35262623e-01f, -4.25804555e-02f, -2.99147397e-01f, -1.26790805e-02f, 2.18449026e-01f, -3.13264853e-03f, 8.18483382e-02f, 1.26891389e-01f,
  9.51692462e-02f, 1.26027003e-01f, -5.74160032e-02f, 2.96487249e-02f, 8.96134079e-02f, -8.73106495e-02f, 1.98204536e-02f, 4.80632149e-02f, 4.77745086e-02f, -1.17871374e-01f,
  -3.43111418e-02f, -1.33349970e-01f, 9.53117535e-02f, -6.12831302e-02f, 5.70906587e-02f, 1.16975039e-01f, -3.42815518e-02f, 6.01423196e-02f, -1.56776235e-01f, 1.19184546e-01f,
  2.81127635e-02f, -2.91829053e-02f, -4.88616097e-05f, -1.38753861e-01f, -4.99070473e-02f, 1.10416757e-02f, -1.03465185e-01f, 8.05289745e-02f, -7.67648444e-02f, -6.35014027e-02f,
  -1.34940650e-02f, -6.71043023e-02f, -2.04858053e-02f, 3.52634788e-02f, 7.79067352e-02f, -1.03884593e-01f, 5.21291140e-03f, 6.03855960e-02f, 5.98849021e-02f, -1.96613967e-02f,
  1.82155684e-01f, 3.68644863e-01f, 1.33994907e-01f, 2.58172862e-02f, 3.80104501e-03f, -4.55394201e-03f, 7.20459297e-02f, 8.43219981e-02f, 7.38583207e-02f, -1.76756829e-02f,
  -8.11258182e-02f, -1.03115618e-01f, -1.02333017e-01f, -1.65712982e-01f, -8.02957565e-02f, 6.10076077e-02f, -3.43603035e-03f, -1.67593017e-01f, -1.16919793e-01f, 4.57842983e-02f,
  3.17631997e-02f, -6.22513779e-02f, -3.87344323e-02f, -7.67934248e-02f, -1.02015324e-01f, 6.09413907e-02f, -1.43802971e-01f, -9.07268841e-03f, 1.27604395e-01f, 6.77226782e-02f,
  3.79474640e-01f, 1.22863673e-01f, 3.23355049e-01f, 1.76346079e-01f, -1.83046237e-02f, 2.03510836e-01f, 1.70330226e-01f, 3.28486472e-01f, 7.70602643e-01f, -2.24064633e-01f,
  -4.39982563e-01f, -6.25996888e-02f, -2.21494079e-01f, -3.51161838e-01f, 2.27652535e-01f, 2.43598714e-01f, 1.57199472e-01f, -1.78625405e-01f, 2.85752892e-01f, -5.14455959e-02f,
  1.14984311e-01f, -4.18220073e-01f, -3.31668139e-01f, -4.18046743e-01f, -4.50167894e-01f, 1.14751711e-01f, -6.88658595e-01f, -1.37670532e-01f, -5.34977674e-01f, -7.65570998e-02f,
  3.26749422e-02f, 5.53382710e-02f, -3.85407321e-02f, 7.90806115e-02f, 1.10345036e-01f, -4.95508984e-02f, -1.33565977e-01f, -2.06485331e-01f, 2.01166466e-01f, 2.76077893e-02f,
  -3.28746364e-02f, -4.32907380e-02f, 1.20908931e-01f, -7.43189901e-02f, 7.44520500e-02f, -8.76656324e-02f, -4.00266610e-02f, 7.68676549e-02f, -3.67480032e-02f, -6.24866560e-02f,
  1.61592960e-02f, 5.29968701e-02f, 1.04771294e-01f, 7.90332153e-04f, 6.80404305e-02f, 4.92669716e-02f, 8.77959281e-02f, -3.18346284e-02f, -1.60294455e-02f, 1.38257101e-01f,
  -2.46458147e-02f, 1.47573397e-01f, -7.12015182e-02f, -1.00166447e-01f, -4.00923453e-02f, 5.03447168e-02f, -1.02711067e-01f, -3.62439454e-02f, 1.31291494e-01f, -1.61929473e-01f,
  5.35114668e-02f, -2.98213195e-02f, 9.27916840e-02f, -6.43720105e-02f, -2.27486547e-02f, 4.12507169e-02f, -4.61525992e-02f, 8.39798152e-02f, 1.38236985e-01f, -2.64589693e-02f,
  -3.77593823e-02f, -4.83399397e-03f, -1.05701201e-01f, -1.58336014e-01f, -2.23749336e-02f, -4.90091033e-02f, -1.12521410e-01f, 4.24497947e-02f, -1.00672446e-01f, -1.33764029e-01f,
  1.32190719e-01f, 2.11590722e-01f, 4.67459783e-02f, -4.22550216e-02f, 8.01539235e-03f, -1.34634286e-01f, -8.17985367e-03f, 6.22694008e-02f, 9.35867652e-02f, -4.00025584e-02f,
  -3.86971608e-02f, -4.53467481e-02f, 6.46934798e-03f, -1.19172940e-02f, 1.68251663e-01f, -2.98705846e-02f, -6.62415096e-06f, 8.90554264e-02f, 7.80191496e-02f, -8.42084438e-02f,
  -1.70465767e-01f, -1.72043853e-02f, 2.26385016e-02f, -3.64574790e-02f, 2.75511127e-02f, -1.13548324e-01f, 5.96489757e-02f, 4.38436307e-02f, -5.85955679e-02f, -8.11810978e-03f,
  5.50274968e-01f, -4.30010885e-01f, -2.59966195e-01f, -3.18441361e-01f, -2.99152732e-01f, -4.70506668e-01f, -1.15806349e-01f, -6.60333872e-01f, -4.22250897e-01f, -3.18964094e-01f,
  -2.51536965e-01f, 2.01688990e-01f, 5.67344785e-01f, -4.61136281e-01f, 6.77308202e-01f, 4.46597874e-01f, -5.19407809e-01f, -1.75466344e-01f, -1.43345580e-01f, -1.13279149e-01f,
  -5.02002053e-02f, -1.54910102e-01f, 2.38701791e-01f, -4.44440395e-01f, -1.83136746e-01f, -1.82760552e-01f, 2.35929817e-01f, 6.26354441e-02f, -4.78980243e-01f, 2.52205990e-02f,
  -8.56753364e-02f, -7.68032596e-02f, -1.64277390e-01f, 8.64447951e-02f, -7.12159798e-02f, -1.33043248e-02f, 8.22751075e-02f, 2.75953799e-01f, 6.36298209e-02f, -5.51377013e-02f,
  1.62033930e-01f, 1.57888040e-01f, -1.52840570e-01f, 1.94065526e-01f, -6.57334402e-02f, -2.81590551e-01f, -8.42080936e-02f, -1.88170299e-01f, -9.21554863e-02f, 1.90482199e-01f,
  6.54252653e-06f, -1.00482516e-01f, -6.77970275e-02f, -2.07625926e-02f, 1.45425582e-02f, -1.01040289e-01f, 1.62973166e-01f, 1.76787317e-01f, -7.68767148e-02f, -1.07480295e-01f,
  8.00828710e-02f, 1.06700040e-01f, 6.67672139e-03f, -2.18216539e-03f, -5.36047593e-02f, -3.54829617e-02f, 5.20584472e-02f, 4.77855206e-02f, 3.32040004e-02f, -9.78702214e-03f,
  -1.38256490e-01f, -7.59001896e-02f, -8.18928555e-02f, -2.48398464e-02f, -5.15274629e-02f, 6.72803298e-02f, 1.23353392e-01f, 6.47073463e-02f, -1.19378485e-01f, -1.01930290e-01f,
  5.74614778e-02f, -4.94121909e-02f, -5.79888187e-02f, 1.40825182e-01f, -3.35022397e-02f, 2.04283483e-02f, -1.39441296e-01f, 1.14102878e-01f, -6.72016367e-02f, 8.60838592e-02f,
  -2.07083851e-01f, -1.43898427e-01f, -1.42205745e-01f, 8.00971990e-04f, 5.09312004e-02f, -1.54988065e-01f, -3.91152687e-02f, -1.93180978e-01f, -5.98572381e-02f, -8.58727172e-02f,
  -1.31666780e-01f, 3.35412957e-02f, -1.58023387e-01f, -2.70369016e-02f, -1.83863677e-02f, -2.51983285e-01f, 1.51929304e-01f, -1.32287547e-01f, 2.99647525e-02f, -6.05159551e-02f,
  9.62486565e-02f, 6.33614287e-02f, 2.17536420e-01f, -1.26105100e-01f, 3.80104147e-02f, 1.76533192e-01f, -7.21816644e-02f, -1.07388310e-02f, 1.30687177e-01f, -4.23009433e-02f,
  -6.28003571e-03f, 8.83754194e-02f, 4.89595681e-01f, 6.36793196e-01f, -4.06461328e-01f, -4.70947146e-01f, -3.61471355e-01f, -2.33112812e-01f, -6.26057908e-02f, -3.87759358e-01f,
  -3.87055516e-01f, 5.32569766e-01f, -6.22592747e-01f, 4.76756126e-01f, 1.23601459e-01f, -5.48603952e-01f, 2.47085154e-01f, 1.62081689e-01f, -1.91316605e-01f, 1.07510705e-02f,
  8.71013626e-02f, -2.20715523e-01f, 1.63668558e-01f, 3.93507667e-02f, 5.39458320e-02f, 5.41305661e-01f, 1.91149086e-01f, 1.14240997e-01f, 7.71508694e-01f, 2.16833964e-01f,
  -1.74033071e-03f, -3.52786630e-02f, 1.10669069e-01f, 1.73319429e-01f, -1.22458093e-01f, -7.27452412e-02f, 1.00950040e-01f, 3.38883251e-02f, 1.13253757e-01f, 1.81235857e-02f,
  -9.47882142e-03f, 2.23148361e-01f, 1.36227429e-01f, 8.07626843e-02f, 2.55547501e-02f, 2.66179621e-01f, 2.92504672e-02f, -9.38061103e-02f, 8.89302716e-02f, -9.75225419e-02f,
  4.34599333e-02f, 6.93200752e-02f, -6.49705008e-02f, 2.00731665e-01f, 7.54112527e-02f, 4.84205708e-02f, 1.83322858e-02f, 1.10822387e-01f, 1.58181518e-01f, -2.45544035e-02f,
  -4.63193096e-02f, -1.90287054e-01f, -8.61000493e-02f, -2.85164006e-02f, -1.09797195e-01f, 9.65823010e-02f, -6.68732077e-02f, -1.79080933e-03f, 1.10195152e-01f, -7.81382695e-02f,
  8.09997991e-02f, 6.35662898e-02f, -2.52313036e-02f, -3.30476426e-02f, -9.92108062e-02f, -8.84054974e-02f, -1.00673512e-02f, 6.27374053e-02f, 4.68923934e-02f, 3.11375875e-03f,
  1.97038334e-02f, 6.53086677e-02f, 4.49825674e-02f, 2.88783554e-02f, -1.81776494e-01f, -7.69201741e-02f, 5.92538491e-02f, 8.39905515e-02f, -1.52993187e-01f, -1.82494581e-01f,
  5.41573837e-02f, 1.41721979e-01f, 5.46704233e-02f, 6.32992312e-02f, 7.76616260e-02f, -1.52571769e-02f, 5.97421266e-03f, 1.44987613e-01f, 8.65785852e-02f, -1.62024871e-01f,
  1.20169809e-02f, 6.73947334e-02f, -3.84259149e-02f, 1.26245245e-01f, 8.25879499e-02f, -9.72045362e-02f, 1.30525278e-02f, 5.36555052e-02f, 3.63539271e-02f, 1.32080883e-01f,
  -1.69887077e-02f, -2.14943215e-01f, -1.85271748e-03f, -5.62643781e-02f, -1.66796017e-02f, -6.48981845e-03f, 4.65809228e-03f, 2.98910569e-02f, 4.02786210e-02f, 1.11949556e-01f,
  -1.28946736e-01f, -1.40105888e-01f, 6.63066804e-01f, -2.38166153e-01f, -1.50434598e-01f, 3.85670632e-01f, 4.46088165e-01f, -3.85592341e-01f, -4.75846589e-01f, -1.21535853e-01f,
  -1.05808094e-01f, 3.90085399e-01f, 4.00150120e-01f, -5.78094982e-02f, 4.25363123e-01f, 1.61916465e-01f, -4.73348126e-02f, 1.47547975e-01f, -3.84301305e-01f, -2.41597056e-01f,
  -1.74018756e-01f, -5.31229556e-01f, 4.12511885e-01f, -6.53004050e-01f, 7.79744685e-02f, -1.47751123e-01f, -1.22803509e-01f, 1.74170882e-01f, -2.98445728e-02f, 5.25174364e-02f,
  -1.90931201e-01f, -3.81769180e-01f, -6.33426290e-03f, -1.22158900e-02f, -9.81361326e-03f, 1.18251920e-01f, 2.48922512e-01f, 1.99874789e-01f, -1.07065253e-01f, 5.33943484e-03f,
  1.36925071e-01f, -6.88919201e-02f, -2.00485021e-01f, -6.12750975e-03f, -1.32426158e-01f, -6.02617338e-02f, 9.95310992e-02f, 1.91107377e-01f, 5.25283068e-03f, 1.51461929e-01f,
  1.61845788e-01f, 1.95945770e-01f, 7.24995658e-02f, 6.35297410e-03f, 3.14876884e-02f, -2.24277601e-02f, 1.01502500e-01f, 2.32750297e-01f, 8.21475387e-02f, -1.25722006e-01f,
  -6.07015602e-02f, -6.26989305e-02f, -3.05268746e-02f, 6.26225993e-02f, -1.16126843e-01f, -3.99829186e-02f, 1.30947605e-02f, -1.41231278e-02f, 2.53483932e-02f, 3.66541892e-02f,
  -9.37305391e-02f, 4.92289700e-02f, -2.10728303e-01f, -2.01140344e-02f, -1.80235356e-02f, -3.90091911e-02f, 1.72190934e-01f, -7.70709142e-02f, -5.78166731e-02f, 3.75593752e-02f,
  -2.36392077e-02f, -3.23518626e-02f, 6.91156834e-02f, -8.45575612e-03f, -1.09046541e-01f, 1.39061615e-01f, -6.94664344e-02f, 1.17890589e-01f, -5.12038656e-02f, 9.60026905e-02f,
  -4.80143785e-01f, -6.14585400e-01f, -1.25744089e-01f, -1.39533728e-01f, -9.06574428e-02f, 4.76042973e-03f, -1.23091608e-01f, -1.37085333e-01f, -5.68678267e-02f, -8.48424956e-02f,
  7.88536761e-03f, 5.57572879e-02f, -8.72079730e-02f, -4.05584313e-02f, -1.24124981e-01f, -1.60427541e-02f, -1.92888465e-03f, -5.89680150e-02f, -1.03803659e-02f, -7.57685900e-02f,
  2.21205801e-02f, -4.36516255e-02f, -3.67630273e-02f, -1.20140284e-01f, -1.40929177e-01f, 1.01275519e-01f, -9.80936289e-02f, -7.85165206e-02f, 2.14874204e-02f, 5.06272539e-02f,
  2.76987642e-01f, 1.00624286e-01f, -3.55412722e-01f, -1.29975125e-01f, 1.63712248e-01f, -4.54231612e-02f, -1.72279611e-01f, 1.69983447e-01f, -3.27078015e-01f, 2.99551517e-01f,
  2.65920877e-01f, -1.62555084e-01f, 9.98483412e-03f, 2.61384219e-01f, 1.52744070e-01f, -2.75748312e-01f, 4.06776011e-01f, 1.45064086e-01f, -5.58570065e-02f, 5.29634535e-01f,
  2.18673170e-01f, 5.05793154e-01f, 1.56698376e-01f, 3.42684418e-01f, 4.03268307e-01f, 8.16814676e-02f, 4.83229876e-01f, 2.02804636e-02f, 3.45532268e-01f, 1.94962807e-02f,
  8.73024948e-03f, 7.61626055e-03f, 3.95880342e-02f, -2.43520781e-01f, 2.83355355e-01f, 1.37060374e-01f, 6.80344924e-02f, -1.29342109e-01f, -2.17559665e-01f, -3.59001048e-02f,
  -1.12041727e-01f, 6.38696328e-02f, -5.33486381e-02f, -1.04194999e-01f, 1.03709951e-01f, -3.20492126e-02f, 1.37786847e-03f, -1.85442772e-02f, -1.46517813e-01f, 1.41638920e-01f,
  1.02064563e-02f, -8.83750916e-02f, 2.27294378e-02f, -6.45700619e-02f, -7.06447149e-03f, -2.50501148e-02f, -3.60999070e-02f, 1.02943383e-01f, -1.17989987e-01f, 1.03985019e-01f,
  2.05173969e-01f, -1.83294702e-03f, -1.96298845e-02f, -1.23026885e-01f, -3.17318477e-02f, -1.23933226e-01f, -4.46104333e-02f, 6.20000288e-02f, -1.97571293e-02f, 2.00335626e-02f,
  2.28144601e-02f, 3.01500466e-02f, -1.08510882e-01f, 7.97998831e-02f, 1.37588590e-01f, -1.26180246e-01f, -5.98516390e-02f, 7.34877959e-02f, 7.24147335e-02f, 2.57832184e-02f,
  -1.18149363e-01f, 7.22249448e-02f, 2.46756021e-02f, -6.70345128e-02f, -1.42633870e-01f, 4.27974686e-02f, 1.53455779e-01f, 6.58970475e-02f, -1.00545555e-01f, -3.23649719e-02f,
  2.00958154e-03f, 4.50934350e-01f, -8.84092376e-02f, -2.17876852e-01f, -4.05257195e-02f, 1.65852726e-01f, -1.05633341e-01f, 3.78123410e-02f, 1.05386779e-01f, 4.07063253e-02f,
  1.69857636e-01f, 3.49716720e-04f, 1.01189129e-02f, -1.03312042e-02f, -9.98321474e-02f, 1.27935439e-01f, 8.53679236e-03f, -1.36531904e-01f, -8.40218924e-03f, 2.12668136e-01f,
  4.19444293e-02f, 1.29777351e-02f, 7.81724527e-02f, -1.39126971e-01f, 3.62113565e-02f, 5.43154106e-02f, 1.69744238e-03f, 1.30984366e-01f, 1.97192151e-02f, -1.37000039e-01f,
  -8.92992079e-01f, 5.19120038e-01f, 1.63667127e-01f, -8.58585477e-01f, 3.81106257e-01f, 2.92354256e-01f, -3.02225888e-01f, 3.71083140e-01f, -4.10075366e-01f, 1.98153302e-01f,
  -4.54575717e-02f, -3.00607771e-01f, 3.67353678e-01f, -4.94600981e-01f, -4.85518903e-01f, -2.51303941e-01f, -6.31210804e-01f, -5.14589429e-01f, -2.79766191e-02f, -1.77417055e-01f,
  -2.39622831e-01f, -3.11632752e-01f, -2.43881926e-01f, 5.39171696e-01f, -4.11801599e-02f, 6.80313930e-02f, -1.40828103e-01f, 5.08245468e-01f, -1.71787500e-01f, 6.14211336e-03f,
  -1.06177079e-02f, 4.01137583e-02f, 9.76885706e-02f, 1.59814358e-01f, 6.86094090e-02f, -6.38066754e-02f, -8.86216536e-02f, -1.74068492e-02f, -6.79133385e-02f, -8.03660080e-02f,
  -7.97625780e-02f, 6.71451613e-02f, -8.85992423e-02f, 3.04502286e-02f, -1.43240551e-02f, 8.16079155e-02f, 6.96137249e-02f, 2.63029896e-02f, 5.85502833e-02f, -2.35573277e-02f,
  -2.85771443e-03f, -1.07004261e-02f, -1.31002113e-01f, -1.92045763e-01f, -9.51753557e-03f, 7.82709345e-02f, -1.09343119e-01f, 3.71656008e-02f, -4.85700741e-02f, -7.79775977e-02f,
  -1.10207558e-01f, -4.68243472e-02f, 6.16899400e-04f, -2.50867382e-02f, 2.87885163e-02f, 1.57745415e-03f, -8.47308114e-02f, 1.38783678e-02f, 1.42185781e-02f, 4.01538722e-02f,
  1.35252941e-02f, -6.14636429e-02f, 1.09629650e-02f, -3.81886661e-02f, -1.39363393e-01f, -1.15464546e-01f, -6.82211816e-02f, -4.61007729e-02f, -8.47329348e-02f, 1.42158871e-03f,
  -5.94313778e-02f, 3.32035944e-02f, -1.25724096e-02f, 5.19991145e-02f, 2.84056123e-02f, -2.81878952e-02f, 1.27579048e-02f, 2.88113840e-02f, -3.02069224e-02f, -3.76061536e-02f,
  5.87339811e-02f, -1.76996887e-02f, 1.23344632e-02f, 7.01529905e-02f, 1.98299131e-05f, 3.33851948e-02f, -3.93766351e-02f, 2.15594098e-02f, -3.95810828e-02f, -7.64621096e-03f,
  -6.63073594e-03f, -9.66090988e-03f, 6.86192364e-02f, -3.81110236e-03f, -7.54594654e-02f, 2.54011489e-02f, -1.63925260e-01f, -1.43675804e-01f, -9.91042629e-02f, 3.01776212e-02f,
  2.51489729e-02f, -7.28749707e-02f, -9.15949792e-02f, 1.15168802e-02f, -4.49120551e-02f, -6.37622625e-02f, -1.92103791e-03f, -4.10986459e-03f, -2.19220947e-02f, -3.18610333e-02f,
  8.74707997e-01f, -2.73181796e-02f, -7.35564157e-02f, 2.71121532e-01f, 1.02209724e-01f, -7.06213892e-01f, -2.20247552e-01f, -1.09476976e-01f, 5.51844418e-01f, -1.56284377e-01f,
  -1.89122364e-01f, 1.83078468e-01f, -1.09226488e-01f, -1.99361950e-01f, -5.08814096e-01f, -1.49337620e-01f, -4.30098891e-01f, -1.42080188e-01f, 3.18770140e-01f, -1.79713890e-01f,
  6.84492663e-02f, -3.78188282e-01f, -2.26489484e-01f, -1.59430563e-01f, 5.05482443e-02f, 1.80178627e-01f, -2.67507643e-01f, 6.70236349e-02f, -2.67566830e-01f, -9.64316055e-02f,
  6.03750944e-02f, 5.38839877e-01f, 1.32920116e-01f, -3.33357975e-02f, -1.23592138e-01f, 1.14875399e-02f, -6.21515997e-02f, -1.16081409e-01f, 4.60581593e-02f, -7.65158236e-02f,
  -6.84860796e-02f, 3.22353877e-02f, -2.81614959e-02f, -3.56970392e-02f, 2.16131195e-01f, 5.06446324e-02f, 5.29956929e-02f, -6.56483918e-02f, 1.48428202e-01f, 1.25852630e-01f,
  8.20772871e-02f, 5.62750511e-02f, -5.50915375e-02f, -5.28087392e-02f, 2.80386321e-02f, 2.04654962e-01f, -6.61064684e-02f, -1.26397789e-01f, -1.78661704e-01f, 2.00745001e-01f,
  2.69126873e-02f, 3.65138389e-02f, -2.59972122e-02f, 1.32105455e-01f, -1.42329305e-01f, 2.86611430e-02f, 1.75429899e-02f, -1.34366468e-01f, 7.03505129e-02f, -4.46068011e-02f,
  -7.36631826e-02f, 1.83251232e-01f, 1.64570674e-01f, -4.86125425e-02f, 1.00486487e-01f, 1.13872826e-01f, -1.69116169e-01f, -6.48421198e-02f, 2.96630859e-02f, -2.49156989e-02f,
  9.34511274e-02f, -8.33604783e-02f, 5.81323393e-02f, -3.24003883e-02f, -1.10198215e-01f, -4.71796654e-02f, -1.04911085e-02f, 7.75861368e-02f, -1.26859425e-02f, -1.10447973e-01f,
  -5.75780213e-01f, -5.16566753e-01f, -4.69813421e-02f, 9.97763053e-02f, -1.65612116e-01f, -6.27624169e-02f, -4.29732352e-03f, 9.74756405e-02f, -1.23432219e-01f, 1.36395693e-02f,
  -5.32549210e-02f, 2.61300169e-02f, -5.82441576e-02f, 1.04385972e-01f, -1.16238497e-01f, -2.53664982e-02f, 3.36024724e-02f, 1.79152042e-02f, -2.09703103e-01f, -7.52606317e-02f,
  -9.23461393e-02f, 1.62896246e-03f, -7.76292980e-02f, -4.05801982e-02f, -7.90783763e-02f, -1.85112387e-03f, -7.15136081e-02f, 1.71247318e-01f, -1.03183210e-01f, -7.93647319e-02f,
  4.75553393e-01f, -6.71207547e-01f, 3.43328089e-01f, -7.60409012e-02f, 5.09062648e-01f, 3.73851329e-01f, 4.35610592e-01f, 2.18168013e-02f, 2.66335994e-01f, -6.29360139e-01f,
  -4.27767774e-03f, -5.62748432e-01f, 7.39787221e-02f, -3.39397669e-01f, 6.09539092e-01f, 2.67539360e-02f, -7.62394965e-02f, -4.37698394e-01f, 1.23599939e-01f, -8.38132948e-02f,
  1.01402484e-01f, -2.29095355e-01f, -6.79443181e-02f, -4.32332635e-01f, -1.12354457e-01f, -3.58673662e-01f, -3.01090151e-01f, -8.18815008e-02f, -4.55873579e-01f, -9.04758573e-02f,
  1.75767809e-01f, -5.48913516e-02f, -7.94041306e-02f, 7.79033289e-05f, 2.35529635e-02f, 1.35182859e-02f, -1.58657849e-01f, -4.10374207e-03f, 1.93256542e-01f, 8.67812186e-02f,
  -2.08445340e-01f, -8.96120537e-03f, -2.05115542e-01f, 1.45735458e-01f, 7.87716880e-02f, 1.19297177e-01f, 1.06890850e-01f, 5.01306653e-02f, -7.51493424e-02f, 9.56313908e-02f,
  1.45182490e-01f, -8.24150164e-03f, 1.11514635e-01f, -1.14100628e-01f, 4.20952961e-02f, -9.26179625e-03f, -8.55407491e-02f, 1.03471410e-02f, -6.40495941e-02f, -2.44502854e-02f,
  -1.70013472e-01f, -1.02450162e-01f, 6.87871501e-02f, -3.40794064e-02f, 1.31253645e-01f, 1.14999712e-01f, 5.61428145e-02f, -2.53053568e-02f, 7.38144591e-02f, -1.92923807e-02f,
  1.36493832e-01f, -6.46863580e-02f, 4.49589118e-02f, 6.18948042e-02f, -6.06338643e-02f, 2.44312431e-03f, 3.42763611e-04f, -5.34073338e-02f, -2.35327203e-02f, 1.41754836e-01f,
  2.07667351e-02f, 6.64294735e-02f, 1.70966402e-01f, -3.34199122e-03f, 2.56919470e-02f, 7.17829764e-02f, -9.82057154e-02f, 1.33750394e-01f, 4.59952392e-02f, -8.13115835e-02f,
  -9.00850520e-02f, -6.79310501e-01f, -9.45031866e-02f, 2.00409852e-02f, -7.58349150e-02f, 5.74121438e-02f, -1.60210505e-01f, 1.14540616e-02f, -1.45869672e-01f, -3.39443162e-02f,
  -1.14146456e-01f, -7.42042214e-02f, -3.66508439e-02f, 1.14750594e-01f, -7.20468685e-02f, 1.94931924e-01f, -2.93303490e-01f, -1.31258547e-01f, -1.49674967e-01f, -9.12839770e-02f,
  -1.14725694e-01f, -3.07173971e-02f, -4.14842255e-02f, -6.17629439e-02f, -9.19880867e-02f, -8.38607363e-03f, 2.95838043e-02f, -5.49945012e-02f, 3.08757015e-02f, -5.19272722e-02f,
  -1.02723014e+00f, 4.48262632e-01f, 5.49599767e-01f, -1.41919047e-01f, -5.49882472e-01f, 5.28878093e-01f, 2.92145222e-01f, 8.87139887e-03f, 1.97042644e-01f, 3.89949143e-01f,
  -2.08523348e-01f, -3.22020710e-01f, 3.29366386e-01f, 1.08997993e-01f, -1.30997717e-01f, 4.15545702e-01f, 3.08665991e-01f, 1.48870796e-01f, 3.91691290e-02f, -2.35590547e-01f,
  -8.11191425e-02f, -3.34367871e-01f, 2.69850314e-01f, -8.59192163e-02f, -3.28909963e-01f, -8.00292566e-02f, -1.65242285e-01f, 5.05342428e-03f, -8.19863603e-02f, -1.95589870e-01f,
  -2.60167480e-01f, -3.46444637e-01f, -1.54446363e-01f, 9.86252427e-02f, 6.04893453e-02f, 7.74627626e-02f, 3.59430537e-02f, -1.13558196e-01f, -4.30529229e-02f, 7.20787374e-03f,
  -1.11466996e-01f, -1.19144004e-02f, -1.82168067e-01f, -5.78392707e-02f, -3.82613391e-03f, -8.39367583e-02f, 1.75492096e-04f, 5.97838797e-02f, -1.27752274e-02f, 1.64808426e-02f,
  1.91510752e-01f, 1.80181965e-01f, 2.35392321e-02f, 1.46904662e-01f, -1.16526045e-01f, 6.67735413e-02f, 2.49711871e-01f, -5.40010147e-02f, -5.96412905e-02f, -1.00637814e-02f,
  1.12084351e-01f, 1.09736994e-01f, 2.63770148e-02f, -3.78396995e-02f, -1.10688277e-01f, 1.42421182e-02f, 6.29094616e-02f, -3.74424122e-02f, 1.09102242e-01f, -5.52559458e-02f,
  -1.18172511e-01f, -1.10518008e-01f, -3.81719954e-02f, 1.39391199e-01f, 1.63490989e-03f, -3.93563993e-02f, -3.37438881e-02f, -1.14106677e-01f, 1.19757384e-01f, -1.32204471e-02f,
  1.26441047e-02f, -3.38294804e-02f, -7.84011781e-02f, 6.85781091e-02f, 1.19969375e-01f, -3.84403858e-03f, 3.90730910e-02f, 1.22730926e-01f, 5.44122569e-02f, -8.56256187e-02f,
  -1.56762227e-01f, -3.37393545e-02f, -1.55588597e-01f, -1.95539251e-01f, -8.22491571e-03f, -5.16002439e-02f, 3.10743116e-02f, -4.80959788e-02f, 4.05696705e-02f, -1.21094063e-02f,
  2.91893706e-02f, 9.68580414e-03f, -7.03981146e-02f, -2.93294843e-02f, 7.70737007e-02f, 1.73542514e-01f, 5.56348898e-02f, 1.20394141e-03f, 3.52439731e-02f, 8.33278522e-02f,
  7.23162666e-02f, -3.00630871e-02f, 1.53319567e-01f, -7.52683729e-02f, 1.07963890e-01f, 5.65114012e-03f, -1.22065656e-01f, -3.01139262e-02f, -1.82707116e-01f, 1.42808855e-01f,
  -1.16092078e-02f, 3.10380220e-01f, -4.61231560e-01f, 4.56939220e-01f, -2.68032163e-01f, 4.78262395e-01f, 7.00376391e-01f, 8.92359540e-02f, 4.56317604e-01f, 7.14003563e-01f,
  2.12269008e-01f, 2.42461205e-01f, 2.56924659e-01f, 7.47368217e-01f, 1.51572332e-01f, 4.83611852e-01f, 5.70470572e-01f, 4.94579017e-01f, 1.06926084e-01f, 2.47670233e-01f,
  5.21197096e-02f, 6.62074864e-01f, -2.85506725e-01f, -7.52578024e-03f, -9.70257223e-02f, -4.20934588e-01f, -1.55216873e-01f, -3.76192391e-01f, 1.40510723e-01f, 4.56322767e-02f,
  8.54548886e-02f, 2.32583463e-01f, -1.63110271e-01f, -1.60931703e-02f, -5.79474345e-02f, -1.30614683e-01f, -1.27905995e-01f, -2.20798239e-01f, -2.05471680e-01f, 6.21554628e-02f,
  5.48184030e-02f, 1.41591029e-02f, 2.16241091e-01f, -2.55591199e-02f, -4.95076440e-02f, -6.66383132e-02f, -8.60637892e-03f, -1.31653816e-01f, 3.25818546e-02f, -8.90114531e-02f,
  -2.76961494e-02f, -8.59374851e-02f, -1.27928588e-03f, 1.91594228e-01f, -5.53246737e-02f, 2.09903330e-01f, 7.09984824e-02f, -1.28605515e-01f, 4.37880084e-02f, 6.21118583e-02f,
  -4.22208086e-02f, 8.00360814e-02f, -1.33112632e-02f, -6.79550916e-02f, 4.40853238e-02f, -9.66181755e-02f, 1.54382557e-01f, -5.32021746e-02f, -5.77761829e-02f, 7.35019594e-02f,
  -1.46715846e-02f, -3.04673146e-02f, 8.67023245e-02f, 5.85579090e-02f, 1.58215538e-01f, 2.26966515e-02f, -5.02079092e-02f, 1.27826154e-01f, -1.88637152e-02f, -7.29567111e-02f,
  6.37876466e-02f, 1.32961676e-01f, 9.45239365e-02f, -1.06469080e-01f, 1.30465463e-01f, -5.18758595e-02f, 1.07184350e-01f, -7.95817003e-02f, 1.41144758e-02f, -4.00027372e-02f,
  3.23954612e-01f, 5.71469724e-01f, 9.58132297e-02f, 8.15034881e-02f, 3.38791162e-02f, 2.80701108e-02f, 7.09777102e-02f, -5.98987974e-02f, 1.35341749e-01f, 4.90048043e-02f,
  2.12332793e-03f, 9.50991362e-02f, -1.05168752e-01f, -9.40420479e-02f, -5.11309989e-02f, 1.45076051e-01f, 2.25773290e-01f, 7.99613968e-02f, 9.35412869e-02f, -5.58906682e-02f,
  -7.30358884e-02f, 7.94422925e-02f, -3.94385606e-02f, -8.87456350e-03f, -4.23948616e-02f, 6.40027449e-02f, -9.37940902e-04f, -1.24079481e-01f, -1.22644939e-01f, 5.56549653e-02f,
  -7.29361892e-01f, 6.23830259e-02f, -5.73732555e-01f, -1.10500790e-01f, -6.40072763e-01f, -3.94791335e-01f, -1.01527840e-01f, -2.56207615e-01f, 1.32000431e-01f, 6.15848899e-01f,
  6.59940392e-02f, 1.97546128e-02f, 4.31637168e-01f, -4.06418256e-02f, -4.94519204e-01f, 5.88003695e-01f, -2.58023471e-01f, 1.40824750e-01f, -6.66542444e-03f, -2.00246155e-01f,
  -3.56691539e-01f, -1.39884889e-01f, -3.37022841e-01f, -2.33771175e-01f, -5.76750994e-01f, -3.26856434e-01f, -2.80416403e-02f, -3.24985921e-01f, -2.67840266e-01f, -2.64430344e-01f,
  -4.33468521e-01f, -1.81791142e-01f, -1.48756087e-01f, -5.02194017e-02f, -1.88341245e-01f, -3.47577371e-02f, -6.30255416e-02f, 4.13812473e-02f, -1.05707012e-01f, 4.12230678e-02f,
  8.40644836e-02f, -6.00390546e-02f, 4.93593998e-02f, 1.09441124e-01f, -5.05032428e-02f, -1.35649800e-01f, -5.76586202e-02f, -1.71331361e-01f, -1.70333698e-01f, -1.97682440e-01f,
  -1.99531883e-01f, -3.23834196e-02f, -1.83884397e-01f, 6.62689656e-03f, -2.54506826e-01f, -1.49660692e-01f, -5.95940975e-03f, -1.28330037e-01f, -1.80067092e-01f, -2.14089796e-01f,
  -6.15915433e-02f, -6.02926016e-02f, -2.42133550e-02f, 3.16480398e-02f, 6.55269101e-02f, -4.00077999e-02f, 5.98878413e-02f, 1.19224213e-01f, 3.65931988e-02f, -1.43479198e-01f,
  -3.37955169e-02f, -1.08655423e-01f, 2.59052292e-02f, -6.31641448e-02f, 3.40484791e-02f, 1.22377411e-01f, 7.10121356e-03f, -1.01759098e-01f, 8.60197842e-03f, 4.79959138e-03f,
  -9.96686611e-03f, -1.96150187e-02f, 7.93780088e-02f, 1.63872652e-02f, 1.77271534e-02f, -5.49531467e-02f, 2.51674373e-02f, 2.19292864e-02f, -6.18216582e-02f, -1.82109907e-01f,
  -6.22599065e-01f, -4.29937571e-01f, -5.04301265e-02f, -6.77587688e-02f, 5.53177521e-02f, 3.33030634e-02f, 9.91683379e-02f, -6.12516515e-02f, -2.47944921e-01f, 3.17017771e-02f,
  1.47562125e-03f, 1.72573671e-01f, -1.07004628e-01f, 1.07679002e-01f, 1.27486095e-01f, -6.95810001e-03f, -1.76966889e-03f, 2.14702748e-02f, -1.92531675e-01f, -1.32992923e-01f,
  -1.53084872e-02f, 4.43366393e-02f, 4.78106961e-02f, -7.52304262e-03f, 1.19924538e-01f, -2.68809218e-02f, -2.10857503e-02f, 2.07910966e-02f, -1.06546290e-01f, -1.40741356e-02f,
  -6.04050696e-01f, 2.57346600e-01f, -3.40425044e-01f, -1.66490629e-01f, 3.29829305e-01f, -6.08777523e-01f, -1.19610220e-01f, 1.33621186e-01f, -2.65461177e-01f, 5.23658514e-01f,
  1.62666470e-01f, -1.30224288e-01f, 2.20725894e-01f, -4.55734015e-01f, -8.33242476e-01f, -5.22397697e-01f, -4.14979428e-01f, -2.87369728e-01f, -3.08388054e-01f, 3.20645094e-01f,
  -2.19263941e-01f, 1.22597769e-01f, -3.68217707e-01f, 4.96381015e-01f, 1.48364887e-01f, 3.24851215e-01f, 5.78473926e-01f, 3.54076058e-01f, 1.23509698e-01f, -2.12193698e-01f,
  -2.98565984e-01f, 1.63995042e-01f, 8.14183499e-04f, -9.86915007e-02f, 1.59777049e-02f, 1.55031040e-01f, -3.64779718e-02f, -1.03391625e-01f, -6.81371018e-02f, -1.45608768e-01f,
  6.87150210e-02f, -3.24498340e-02f, 1.68643717e-03f, 7.14779124e-02f, 7.32154325e-02f, -2.67229369e-03f, -1.75531253e-01f, -1.09002344e-01f, 2.12942739e-03f, -2.41254643e-01f,
  -1.30163431e-01f, -9.51551571e-02f, 1.76071320e-02f, -1.54315410e-02f, 1.50332078e-02f, 5.07856980e-02f, -9.20877904e-02f, 1.83390267e-02f, -1.96558554e-02f, -1.54942155e-01f,
  1.42791495e-01f, 3.41268778e-02f, -1.10868737e-01f, -1.00852370e-01f, -6.80119023e-02f, 6.93245679e-02f, 5.76034598e-02f, -4.14594561e-02f, 3.23808119e-02f, 7.84684345e-02f,
  3.84404436e-02f, -7.68517668e-04f, 2.47929730e-02f, -1.31544974e-02f, -4.56758868e-03f, -8.18687677e-02f, 5.02213016e-02f, 3.03102601e-02f, -6.67017475e-02f, -1.31657287e-01f,
  1.32919237e-01f, -5.64575605e-02f, 1.18045863e-02f, 1.39832437e-01f, -9.22923684e-02f, 1.47073522e-01f, 1.05995961e-01f, -1.04644679e-01f, -4.32910025e-02f, 1.02224231e-01f,
  1.70770258e-01f, 5.62938273e-01f, 1.87524729e-05f, -2.31621880e-02f, 7.05784932e-02f, -1.15837809e-02f, -1.36726126e-01f, -1.01409435e-01f, 1.21674903e-01f, 7.37396181e-02f,
  1.72915176e-01f, 1.04657918e-01f, 7.63718411e-02f, -3.58043797e-02f, -6.42252713e-02f, 3.84503528e-02f, 1.93111792e-01f, 4.76663820e-02f, 1.91516295e-01f, 1.90599915e-02f,
  2.65372634e-01f, 1.91499740e-01f, 4.88167852e-02f, 5.45633584e-02f, 1.38774216e-01f, 1.57880709e-01f, 1.53422311e-01f, -1.83786592e-03f, 9.04052109e-02f, 7.31582493e-02f,
  5.58925033e-01f, -1.05167739e-01f, 3.06740969e-01f, 6.85422361e-01f, -2.37637255e-02f, -4.80859071e-01f, -1.33404702e-01f, 2.12957427e-01f, 4.48536694e-01f, -5.66710889e-01f,
  3.25156376e-02f, -7.45004863e-02f, -2.43676245e-01f, 2.72735596e-01f, 5.04540145e-01f, -1.45965561e-01f, 2.74601936e-01f, -1.84903234e-01f, 1.69795841e-01f, 2.43408278e-01f,
  4.50853109e-01f, 1.20333090e-01f, 4.39573288e-01f, 3.84262821e-04f, 1.99269429e-01f, 3.51953149e-01f, 3.47988188e-01f, -8.02923068e-02f, 6.88585639e-02f, -2.71335661e-01f,
  -1.33988619e-01f, 1.19189270e-01f, 6.51546195e-02f, -1.84650391e-01f, 1.37524292e-01f, -8.06939378e-02f, -1.23806752e-01f, -8.56923983e-02f, 1.33459121e-01f, 2.86807567e-02f,
  -9.58395302e-02f, -4.21372727e-02f, 3.10527068e-02f, 3.62152681e-02f, 3.35214846e-02f, 1.31888106e-01f, 1.87674519e-02f, -2.64421124e-02f, 2.35978840e-03f, -6.46471083e-02f,
  1.31868660e-01f, 8.16147327e-02f, 1.36156783e-01f, 1.43719772e-02f, 8.19403976e-02f, 2.86674104e-03f, -6.41169548e-02f, 5.66382986e-03f, -8.47384855e-02f, 9.38974470e-02f,
  -6.64230511e-02f, 2.34026853e-02f, 2.69211531e-02f, 7.58574381e-02f, 1.14126936e-01f, 5.73663339e-02f, 5.08309118e-02f, -1.35430202e-01f, 2.44062301e-02f, -1.03107341e-01f,
  1.23295642e-01f, 6.18359484e-02f, -8.94958079e-02f, -3.25908251e-02f, 1.20098144e-01f, 1.19120792e-01f, -6.18115179e-02f, -8.28640833e-02f, 9.06529799e-02f, 1.31797582e-01f,
  8.05448592e-02f, -4.95536290e-02f, 7.40736127e-02f, -1.02228418e-01f, -1.00200869e-01f, 1.55578051e-02f, 6.75856918e-02f, -5.73743097e-02f, 3.99519727e-02f, 5.10829724e-02f,
  -1.58714160e-01f, 1.48131520e-01f, 2.62657106e-02f, -2.45405391e-01f, -1.01285735e-02f, -3.44148651e-02f, 4.09194967e-03f, 5.73310964e-02f, 7.90280402e-02f, 1.66044291e-02f,
  -1.25220731e-01f, -5.31727187e-02f, -1.08293638e-01f, -4.38434258e-02f, -5.22903958e-03f, 5.55145741e-02f, 1.71085522e-02f, 2.56785769e-02f, 2.09031794e-02f, 2.85654757e-02f,
  7.32202455e-02f, -8.80694538e-02f, 1.98178887e-02f, 1.13919333e-01f, -7.53972307e-02f, 1.67033332e-03f, 3.85980755e-02f, 1.63756963e-02f, 2.15559360e-02f, 1.03146791e-01f,
  -8.62535417e-01f, 8.78570676e-02f, -6.85174108e-01f, -6.25733212e-02f, 3.28673989e-01f, 4.22581226e-01f, -1.40487835e-01f, 5.36246896e-02f, -4.44156259e-01f, 4.50578257e-02f,
  3.16443831e-01f, -2.27410004e-01f, -2.70531088e-01f, 5.84054708e-01f, 1.93558976e-01f, 2.86308303e-02f, 4.12913978e-01f, 8.38056877e-02f, -2.82152127e-02f, -2.72381544e-01f,
  -8.16732273e-02f, 6.69858277e-01f, -7.20309420e-03f, 2.96482980e-01f, 3.50340083e-02f, -1.99096292e-01f, 5.30863255e-02f, -2.69346774e-01f, 4.94968206e-01f, 4.12296027e-01f,
  -1.96904227e-01f, -4.73230243e-01f, -2.25572795e-01f, -2.74405360e-01f, -1.96181610e-01f, -2.29248181e-01f, -2.94165999e-01f, -1.02004800e-02f, -1.12091042e-01f, 5.59054911e-02f,
  -1.89881265e-01f, 6.50765225e-02f, 1.95822626e-01f, 3.12062050e-03f, -6.20476305e-02f, 3.62383537e-02f, 2.93221809e-02f, 6.73638238e-03f, 1.78685989e-02f, -5.93176205e-03f,
  -2.59718578e-02f, 7.16722533e-02f, 5.95022887e-02f, 7.61301443e-02f, -2.63815299e-02f, 1.03885204e-01f, 4.64819632e-02f, -7.10837692e-02f, 3.06604244e-02f, -1.00636398e-02f,
  -6.55333232e-03f, -1.02964982e-01f, -5.09313345e-02f, -2.68312208e-02f, 1.11107148e-01f, 8.11876655e-02f, 4.25099544e-02f, 3.32934037e-02f, -1.55580580e-01f, 9.33049023e-02f,
  8.96965861e-02f, 1.29776085e-02f, -6.74542263e-02f, -3.39022614e-02f, 6.87907338e-02f, 5.62976114e-03f, -6.67559057e-02f, 5.52516542e-02f, 7.71888997e-03f, 1.58543494e-02f,
  -1.06762499e-01f, -5.64861260e-02f, 3.05153988e-02f, -9.95556191e-02f, 6.96313530e-02f, -8.36327225e-02f, -2.82394700e-02f, -6.11317270e-02f, -1.16033539e-01f, 2.35259082e-04f,
  -6.25835836e-01f, -6.06361091e-01f, -1.05708785e-01f, 1.21676542e-01f, -3.22108604e-02f, 9.11647268e-03f, -1.06541649e-01f, 1.05664544e-01f, -1.30664855e-01f, -8.06978196e-02f,
  -1.19063810e-01f, -1.26694441e-01f, -1.73482776e-01f, 5.73995896e-02f, 8.35376680e-02f, -5.20257689e-02f, -8.02884698e-02f, -8.59219506e-02f, -7.21525550e-02f, -3.02479025e-02f,
  -7.05578104e-02f, -6.30596504e-02f, 1.68812741e-02f, 4.92689684e-02f, 1.17519826e-01f, 1.00704409e-01f, -1.12407126e-01f, -1.16837872e-02f, 1.83974117e-01f, 4.33034599e-02f,
  2.15177536e-01f, -3.85010123e-01f, -4.92640376e-01f, -3.80595148e-01f, 2.77362436e-01f, 7.36564696e-01f, -1.84997171e-01f, -3.03905327e-02f, -4.56368893e-01f, 1.52306065e-01f,
  6.91515133e-02f, -4.57548648e-01f, -5.49925983e-01f, 3.08980197e-02f, 8.23928416e-02f, -3.49212259e-01f, 3.21393341e-01f, 1.36715934e-01f, -1.77421004e-01f, 2.00307474e-01f,
  -5.89016592e-03f, 4.87229198e-01f, -3.77876669e-01f, 5.34250200e-01f, 3.07751596e-01f, 2.80406848e-02f, 4.37783062e-01f, -5.92344105e-02f, 4.27648693e-01f, 7.93687627e-02f,
  3.52044925e-02f, -1.43250927e-01f, -8.65389407e-02f, -2.57803109e-02f, 1.87917039e-01f, 2.01837823e-01f, 2.13655829e-01f, -6.27585500e-02f, -1.09069884e-01f, -2.44031176e-01f,
  8.45557526e-02f, 4.49000038e-02f, 8.52682889e-02f, -9.59306732e-02f, 1.03377648e-01f, -5.83992265e-02f, -1.33243784e-01f, -1.81186851e-02f, -2.78506011e-01f, -1.65865570e-01f,
  -2.68617064e-01f, -1.03847839e-01f, 8.12442452e-02f, 1.56884585e-02f, -7.97752589e-02f, -9.25448239e-02f, 5.67672402e-02f, -7.86517933e-02f, 9.72911790e-02f, 3.76674309e-02f,
  1.60382181e-01f, 9.63886827e-02f, 1.93066951e-02f, -3.84866185e-02f, -4.28401195e-02f, 4.79138680e-02f, 3.59615050e-02f, 1.23642031e-02f, -8.23907629e-02f, 3.85949574e-02f,
  5.85858617e-03f, -4.00363468e-02f, 3.86924222e-02f, 1.74334392e-01f, 1.10253608e-02f, -4.94478270e-02f, 9.64175165e-02f, 9.65734571e-02f, -1.08423894e-02f, 3.77496332e-02f,
  -1.11355476e-01f, 1.26765728e-01f, -5.52687831e-02f, 1.17333904e-01f, -3.93741578e-02f, -1.61575869e-01f, 1.11598082e-01f, 2.49794368e-02f, -7.16900304e-02f, 8.02941024e-02f,
  1.01952903e-01f, 2.78119624e-01f, -5.83959185e-02f, -1.12489639e-02f, -1.02230068e-02f, 2.53700405e-01f, 3.02724335e-02f, 1.12312824e-01f, 5.34258634e-02f, 1.23450659e-01f,
  2.31294543e-01f, 5.96382096e-02f, 2.78317869e-01f, -1.09831402e-02f, -3.08684055e-02f, 1.76027969e-01f, 1.80583015e-01f, -2.15098634e-02f, 2.16070861e-01f, 5.93349449e-02f,
  1.29035413e-01f, 1.43623427e-01f, -5.15733324e-02f, 1.41439348e-01f, 5.59672005e-02f, 2.54725143e-02f, 1.83507040e-01f, -5.76799661e-02f, 1.23141631e-01f, -1.16174547e-02f,
  -3.35078001e-01f, -3.19972545e-01f, 5.52626371e-01f, -1.39557287e-01f, 4.90643919e-01f, 5.77892244e-01f, 4.86280024e-01f, -5.31928763e-02f, 1.53360337e-01f, -5.35038531e-01f,
  -3.69860798e-01f, 4.22004983e-02f, 8.72983485e-02f, -1.80226788e-01f, 7.37330735e-01f, 2.64101833e-01f, 2.29083046e-01f, 1.23417057e-01f, 3.50286722e-01f, 5.69970757e-02f,
  8.25267881e-02f, -1.87652126e-01f, 1.72149077e-01f, -2.21770436e-01f, -7.95321912e-02f, -1.06052831e-01f, -3.09339374e-01f, 5.77028155e-01f, -2.73009211e-01f, 3.37483019e-01f,
  -1.61183998e-01f, -1.91274464e-01f, -1.65347591e-01f, -1.24227665e-01f, -1.61637664e-01f, 2.62262188e-02f, 7.75279552e-02f, 3.22468668e-01f, 1.52008206e-01f, -9.02755857e-02f,
  -9.04744864e-02f, 5.89967258e-02f, -7.12222680e-02f, 4.06244434e-02f, 9.09017771e-02f, -9.02995169e-02f, 1.18317291e-01f, -1.24662139e-01f, -1.45169348e-02f, 1.36606485e-01f,
  2.82646101e-02f, -6.43986017e-02f, -7.80790746e-02f, -2.52743997e-02f, 6.75665811e-02f, -1.63007528e-02f, 1.21379480e-01f, 1.37203768e-01f, 4.88992361e-03f, 3.40142511e-02f,
  1.38883621e-01f, 1.46278992e-01f, -1.33630604e-01f, -1.09343948e-02f, 1.98736191e-02f, -1.37269735e-01f, -5.97815122e-03f, -9.68532264e-02f, 9.45180096e-03f, -1.69404671e-02f,
  -5.31905740e-02f, 4.08664905e-02f, -4.96371686e-02f, 1.12193733e-01f, -1.02407441e-01f, -1.83101982e-01f, 6.04739748e-02f, 2.42750719e-02f, -4.14568707e-02f, -4.89236079e-02f,
  -5.28732352e-02f, 1.22139581e-01f, -1.37792071e-02f, -2.46129613e-02f, 4.71191201e-03f, 7.29275569e-02f, -1.09087184e-01f, 2.53867451e-02f, -1.21772125e-01f, 6.06467240e-02f,
  -1.07910395e-01f, -2.51545869e-02f, -2.19544675e-03f, -1.51585475e-01f, -9.30074006e-02f, -1.49225175e-01f, 1.13116562e-01f, -5.77898845e-02f, 1.50818536e-02f, 1.55039346e-02f,
  -1.60015538e-01f, 2.60285120e-02f, 9.04242992e-02f, 4.23093475e-02f, 5.66748250e-03f, -7.72431567e-02f, 1.07223451e-01f, -1.10004529e-01f, -1.14898406e-01f, -3.40665206e-02f,
  -1.34768665e-01f, -1.58286933e-02f, 8.35877471e-03f, -7.28547126e-02f, -2.71026313e-01f, -1.15743190e-01f, -1.07216053e-01f, 4.27067280e-02f, 8.89440812e-03f, 8.03342089e-02f,
  7.41459131e-01f, -4.50890660e-01f, 2.38734975e-01f, 5.12724757e-01f, 3.56559992e-01f, 2.67670583e-02f, -1.09022327e-01f, 2.58311093e-01f, 3.72095078e-01f, -2.09278569e-01f,
  -1.20391808e-01f, -2.15912461e-01f, -5.67050815e-01f, 1.00490101e-01f, -4.60103244e-01f, -4.86006886e-01f, 2.71594852e-01f, -2.09174305e-02f, 7.92065412e-02f, 1.60606638e-01f,
  2.11545825e-01f, -2.39309877e-01f, -1.17597550e-01f, -6.42203316e-02f, 3.48034233e-01f, 2.67107725e-01f, -1.91022217e-01f, -2.57823884e-01f, 1.75419882e-01f, -1.59244806e-01f,
  8.99187997e-02f, 1.23232327e-01f, 7.17420131e-02f, 1.39323156e-03f, 1.01014756e-01f, 9.35931504e-02f, 6.43557832e-02f, -2.02427015e-01f, 1.86888017e-02f, 2.20890976e-02f,
  -2.60482393e-02f, 1.77394897e-01f, 9.36849937e-02f, -1.05715856e-01f, 2.26566970e-01f, 8.37979168e-02f, 1.89416930e-01f, 2.18619451e-01f, 5.81112690e-02f, 8.33698437e-02f,
  1.05129443e-01f, 1.05597593e-01f, 1.97596848e-01f, 3.18700187e-02f, 5.25332205e-02f, 1.60810217e-01f, 1.67180344e-01f, 1.38016706e-02f, 6.74378201e-02f, 1.09859124e-01f,
  -1.37550477e-02f, -1.37210889e-02f, -1.54693291e-01f, 1.14285685e-02f, -2.24791598e-02f, 1.13215126e-01f, -5.54641895e-02f, -6.21838204e-04f, 9.75238532e-03f, -2.84630200e-03f,
  9.49645787e-02f, -3.66761088e-02f, 4.96215336e-02f, 1.65031224e-01f, -5.87466955e-02f, 1.30041063e-01f, -5.33337379e-03f, 5.59279881e-02f, 4.66869883e-02f, 6.03768900e-02f,
  -1.26948074e-01f, 5.81709035e-02f, -1.84925139e-01f, 1.81190059e-01f, 1.38552897e-02f, -1.46971121e-01f, 7.42435977e-02f, 1.05806284e-01f, 1.23407699e-01f, -1.60464987e-01f,
  -5.64742982e-01f, -6.10375881e-01f, -1.12271912e-01f, 8.83816183e-03f, -1.69272393e-01f, -1.01133315e-02f, 4.70553264e-02f, 9.06252936e-02f, -2.07387879e-01f, 2.14386079e-02f,
  1.04986005e-01f, 1.65837273e-01f, 3.22183110e-02f, 8.35669339e-02f, -3.02932411e-01f, -8.27143192e-02f, 4.43239287e-02f, -7.84152076e-02f, -7.12940795e-03f, 3.99807207e-02f,
  9.76144224e-02f, 2.36249920e-02f, 1.62894905e-01f, 2.66467571e-01f, 1.37578800e-01f, -1.03274308e-01f, -1.59856081e-02f, -5.39837889e-02f, -6.45048590e-03f, -8.03896338e-02f,
  8.09337273e-02f, 4.04694259e-01f, -2.09615510e-02f, -2.49970838e-01f, -3.27066809e-01f, -2.10278913e-01f, -3.64781499e-01f, -3.11376806e-02f, 2.38870442e-01f, 3.19103688e-01f,
  -4.01475936e-01f, 7.18408167e-01f, 9.03378334e-03f, -4.63540018e-01f, -6.17884278e-01f, -2.63791263e-01f, -4.45228308e-01f, -7.17536435e-02f, 2.24610344e-02f, -1.21976346e-01f,
  -3.18941832e-01f, -6.18808985e-01f, -3.85892987e-01f, -2.85938144e-01f, -1.97539732e-01f, 2.37150088e-01f, -2.49324203e-01f, -1.16372988e-01f, -1.80767462e-01f, -2.46227548e-01f,
  -1.55743554e-01f, 1.10178046e-01f, 1.04598284e-01f, 4.43293825e-02f, -1.98417008e-02f, 2.33894046e-02f, -9.87227187e-02f, -1.87102005e-01f, -1.02944948e-01f, 5.33380918e-02f,
  1.25067875e-01f, 3.23711638e-03f, -8.81956983e-03f, -7.90331364e-02f, -1.54198296e-02f, 6.70395121e-02f, 1.13323838e-01f, 7.67134354e-02f, 1.34086892e-01f, 7.38094840e-03f,
  2.16658227e-02f, 1.05725847e-01f, -1.40147945e-02f, 2.29967088e-01f, 5.43091632e-02f, 2.21178718e-02f, 5.82259782e-02f, 1.08964607e-01f, 2.63683170e-01f, 7.01093003e-02f,
  -8.58264342e-02f, 5.24944998e-03f, -1.63767729e-02f, -1.06307730e-01f, -4.65297997e-02f, -1.23784952e-01f, -1.31617725e-01f, -3.87686826e-02f, -6.86557963e-04f, -5.27283438e-02f,
  2.06461549e-02f, 1.31124288e-01f, -1.78343326e-01f, 7.69180134e-02f, -1.36042923e-01f, 9.87298787e-02f, -1.17941611e-01f, 1.68397039e-01f, -6.44271672e-02f, 6.77778348e-02f,
  7.11099878e-02f, -1.17998600e-01f, 4.36683744e-02f, -1.09763309e-01f, -1.47249445e-01f, 3.51874419e-02f, 1.01492092e-01f, 2.68160664e-02f, 7.65990326e-03f, -2.51668859e-02f,
  7.27113262e-02f, 1.49116009e-01f, -4.27578725e-02f, 6.44708052e-02f, 6.77360445e-02f, 8.16148371e-02f, -1.64195895e-01f, 8.50228518e-02f, -6.00338774e-03f, -1.66467242e-02f,
  -7.86209945e-03f, -9.66354534e-02f, 6.15613945e-02f, -2.35370193e-02f, -2.71778759e-02f, -9.44529995e-02f, 1.10017592e-02f, 2.17819721e-01f, -6.30997568e-02f, 1.03007458e-01f,
  1.14926010e-01f, 8.32766965e-02f, 5.84993474e-02f, 7.91090801e-02f, 9.53126699e-02f, 1.55211821e-01f, 1.59097835e-01f, 1.07626334e-01f, 2.10208446e-02f, 1.19639985e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  8.29299271e-01f, 5.61592102e-01f, 4.47306603e-01f, 3.26899379e-01f, 4.67567205e-01f, 6.69942856e-01f, 5.73615015e-01f, 8.12104523e-01f, 6.04027510e-01f, 5.11228442e-01f,
  4.43859577e-01f, 4.64352429e-01f, 2.54987150e-01f, 3.99348110e-01f, 5.45988679e-01f, 4.57374364e-01f, 7.27634192e-01f, 7.51808763e-01f, 4.39290404e-01f, 7.62275696e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -4.08288896e-01f, 2.37319395e-01f, -3.17464501e-01f, 2.29021534e-01f, -3.38949114e-01f, -5.42918444e-01f, 6.70732260e-01f, 3.73506933e-01f, 4.71172720e-01f, -4.92601961e-01f,
  -4.07751769e-01f, 3.45454328e-02f, -5.68184197e-01f, 6.62526369e-01f, -5.43253541e-01f, -4.72415924e-01f, -2.61146784e-01f, 2.21241042e-01f, -2.17703357e-01f, -5.42517960e-01f,
  -3.87173831e-01f, -7.06321478e-01f, 7.26781547e-01f, 5.25420725e-01f, 7.53827631e-01f, -3.82199198e-01f, -5.15516043e-01f, 3.13652307e-01f, -8.60287547e-02f, -9.18455958e-01f,
  -9.74308550e-02f, -7.10408270e-01f, 2.20951676e-01f, -3.20942104e-01f, -6.10561907e-01f, 4.09913272e-01f, 3.94376993e-01f, -9.09182727e-02f, 6.70256138e-01f, -5.48264861e-01f,
  4.88523781e-01f, 4.03265327e-01f, -2.39711091e-01f, 7.60628402e-01f, 6.34606123e-01f, -2.25885674e-01f, -6.57464921e-01f, 3.68119538e-01f, -1.03668725e+00f, -5.03900766e-01f,
  6.26525164e-01f, -5.66127717e-01f, 3.53189647e-01f, -2.29702033e-02f, -7.82269180e-01f, 5.73787391e-01f, -1.01879025e+00f, -4.68189478e-01f, -4.93426085e-01f, 4.11586255e-01f,
  7.10888147e-01f, -5.77426672e-01f, -5.28882921e-01f, -8.50878179e-01f, 2.03162078e-02f, -1.00584663e-01f, 1.74262017e-01f, -8.07395816e-01f, 4.82813939e-02f, 1.66770503e-01f,
  1.33591607e-01f, -2.12414786e-01f, -1.54311359e-01f, 4.18841451e-01f, 5.24507821e-01f, 3.78330634e-03f, -9.32301164e-01f, -8.99689794e-01f, -2.88484693e-01f, -3.64749789e-01f,
  8.41928780e-01f, -3.20337206e-01f, -1.15971655e-01f, -3.40949208e-01f, -4.05766249e-01f, -3.01980078e-01f, -4.22477752e-01f, -2.88573474e-01f, -3.56664211e-01f, -4.72332895e-01f,
  1.32689714e-01f, 8.10005188e-01f, 6.50320947e-01f, -2.45038178e-02f, 3.82260680e-01f, -3.24084431e-01f, 3.01856190e-01f, -5.31084180e-01f, -2.43570462e-01f, -8.00873756e-01f,
  1.73951700e-01f, -3.74944866e-01f, -3.36804450e-01f, -1.85738355e-01f, -4.29770768e-01f, -4.43356097e-01f, 2.58977376e-02f, 7.38311470e-01f, -5.00808656e-01f, 3.24901074e-01f,
  -7.18047440e-01f, -4.05205846e-01f, -2.84528732e-01f, -8.15796196e-01f, -8.02033186e-01f, 7.11741507e-01f, 4.92632389e-01f, -6.39933646e-01f, -1.90532997e-01f, -8.36966559e-02f,
  5.08277297e-01f, 5.66433191e-01f, -3.92371416e-01f, 1.27360523e-01f, -9.11611259e-01f, -4.75280523e-01f, -6.12960756e-01f, 2.49540389e-01f, 1.13077454e-01f, 1.53884441e-01f,
  9.00676847e-02f, -1.29439831e-01f, 7.18587190e-02f, 1.38627023e-01f, -5.38132071e-01f, 1.11973631e+00f, -7.28506863e-01f, -3.42151165e-01f, -3.18093687e-01f, 5.42404950e-01f,
  -3.11459064e-01f, 7.91517556e-01f, 1.45045683e-01f, -5.85094213e-01f, -5.79400718e-01f, 3.68920833e-01f, -3.82707678e-02f, 7.70079613e-01f, -7.57033408e-01f, 2.33521566e-01f,
  6.07724667e-01f, -1.18279898e+00f, -3.36724073e-01f, -1.09891677e+00f, -5.08658588e-01f, 3.72084200e-01f, 5.27397282e-02f, 3.77182394e-01f, -2.27968663e-01f, -4.49810401e-02f,
  2.86145419e-01f, 2.30987743e-01f, 4.31941390e-01f, -3.93533468e-01f, 2.41693705e-01f, 3.74105811e-01f, -4.88422245e-01f, -8.94194186e-01f, 2.61283457e-01f, -4.29031402e-01f,
  -3.78506869e-01f, -2.12522611e-01f, 6.81995749e-01f, -2.98754185e-01f, 7.53415525e-01f, -5.03993519e-02f, 3.41652662e-01f, -4.62900221e-01f, -6.84681296e-01f, -6.95487678e-01f,
  -1.01059997e+00f, -5.28777778e-01f, 3.23029876e-01f, 5.48467100e-01f, 2.43460327e-01f, -4.82637465e-01f, -1.28910989e-01f, -9.97482121e-01f, -2.41898954e-01f, 4.82605249e-01f,
  -6.06502950e-01f, 1.77681327e-01f, -1.23772323e-01f, -1.26447439e-01f, -1.46243349e-01f, 2.24182099e-01f, 3.21603507e-01f, 8.05472657e-02f, 2.05019280e-01f, -1.41092986e-01f,
  -3.19571316e-01f, 1.35052055e-01f, -2.58609712e-01f, -4.03143018e-01f, 4.49955165e-02f, -3.95743400e-01f, 5.32850564e-01f, -8.24952722e-01f, -6.77547276e-01f, -3.27882469e-01f,
  -8.23081732e-02f, -5.03125131e-01f, 8.17462623e-01f, 7.69832730e-01f, -9.69684839e-01f, -2.72831380e-01f, -3.44820410e-01f, -3.02520335e-01f, 7.07240820e-01f, -4.16180998e-01f,
  -4.56796855e-01f, 1.32375406e-02f, 9.90390360e-01f, -1.00539267e+00f, -4.63564813e-01f, 2.36345395e-01f, 1.42201915e-01f, -3.02210331e-01f, -5.44554293e-01f, -2.21179962e-01f,
  -2.77884841e-01f, 7.59374052e-02f, 9.23049226e-02f, 2.26019174e-01f, 1.62789319e-02f, -3.18919361e-01f, -8.11483800e-01f, 2.31371894e-01f, 1.29444644e-01f, 6.28525734e-01f,
  -1.85076833e-01f, -1.05981715e-01f, -3.95357251e-01f, -2.27906048e-01f, 4.43724096e-01f, 1.45656943e-01f, -3.32111597e-01f, -1.49457186e-01f, 4.93952632e-01f, -6.07219994e-01f,
  -1.95425645e-01f, -5.33446968e-01f, -5.29755533e-01f, -5.80314875e-01f, -4.55837578e-01f, 6.01526141e-01f, 9.46816728e-02f, 2.70475656e-01f, -4.13851775e-02f, 4.17983904e-02f,
  -7.36377358e-01f, -2.01071605e-01f, -3.87874931e-01f, 2.88639646e-02f, -3.20055097e-01f, 1.45979017e-01f, 6.21526130e-02f, -4.89138991e-01f, 6.17737770e-02f, 4.66978222e-01f,
  -2.10254148e-01f, -1.85685828e-01f, 5.08981645e-01f, -3.65386575e-01f, 4.90627855e-01f, -6.86185777e-01f, -3.57923120e-01f, -3.70040596e-01f, -7.35208541e-02f, -1.50471553e-01f,
  -3.78949314e-01f, 2.99517423e-01f, 7.64268458e-01f, -6.13429546e-01f, -3.01433980e-01f, -5.47658503e-01f, -3.13977629e-01f, -3.39885831e-01f, 5.99579478e-04f, 1.37614951e-01f,
  2.90094763e-01f, 1.85118735e-01f, -2.13157143e-02f, -1.95491891e-02f, -2.31167570e-01f, -6.34802997e-01f, 2.88801610e-01f, 6.76750958e-01f, -3.20568532e-01f, -5.62985897e-01f,
  -7.50526011e-01f, -7.28431404e-01f, -1.47786573e-01f, 8.96486223e-01f, -2.04822794e-01f, 9.96310532e-01f, -6.04177356e-01f, -9.03874338e-01f, -7.06840575e-01f, 5.73238373e-01f,
  -1.54069439e-01f, -7.34301984e-01f, -7.10911453e-01f, -1.55830607e-01f, -1.03387892e-01f, -4.24248427e-01f, -3.02965760e-01f, 7.11243689e-01f, -5.96300185e-01f, -5.19002378e-01f,
  -2.86496252e-01f, 2.80647367e-01f, 2.78639227e-01f, 7.31416702e-01f, 3.55386823e-01f, 4.67376888e-01f, 6.02454007e-01f, 5.88659942e-01f, 5.20476818e-01f, -1.35038152e-01f,
  7.86835030e-02f, -8.20106387e-01f, -3.05756807e-01f, -8.03797364e-01f, -3.57968032e-01f, -4.87998158e-01f, -4.06807959e-01f, -4.14048374e-01f, 2.22743362e-01f, 4.60677087e-01f,
  -6.52331531e-01f, -3.23482752e-01f, -7.18755648e-02f, -5.93862832e-01f, -4.47190225e-01f, 7.60736823e-01f, -6.78483963e-01f, -6.40893698e-01f, 7.66715646e-01f, -3.71454775e-01f,
  6.85175285e-02f, 1.95881888e-01f, -7.65530616e-02f, -3.17138106e-01f, -6.90088347e-02f, 1.90276951e-01f, 1.44316226e-01f, 1.65185049e-01f, -2.70175099e-01f, 6.18034184e-01f,
  -2.79488623e-01f, -7.43875653e-02f, 3.63489449e-01f, 5.39420724e-01f, 8.12669873e-01f, -5.61517954e-01f, 2.60257479e-02f, -6.66794837e-01f, 6.29132271e-01f, 3.97931725e-01f,
  -1.48734301e-01f, -2.67964959e-01f, 5.32663584e-01f, -6.21267200e-01f, -2.73576260e-01f, -8.96563292e-01f, -4.62258339e-01f, -4.07906592e-01f, -1.70954615e-01f, -4.22063619e-01f,
  -6.29250109e-01f, -6.40966475e-01f, 4.69703466e-01f, 7.18613923e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.16656482e-01f, 1.61161333e-01f, 1.23888822e-02f, -1.11529253e-01f, 1.15302943e-01f, -4.29274105e-02f, 6.17682263e-02f, -1.15321733e-01f, -3.30094956e-02f, 1.49327070e-01f,
  -2.50236746e-02f, 2.40054037e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    