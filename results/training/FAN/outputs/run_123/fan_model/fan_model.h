/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.52960315e-01f, 9.63319317e-02f, 7.55569786e-02f, -1.69552475e-01f, 2.38704801e-01f, -9.77574512e-02f, -2.68526644e-01f, 1.81985855e-01f, -4.35139649e-02f, -1.70897096e-01f,
  2.74494872e-03f, 6.73548505e-02f, -2.32590005e-01f, -1.65001571e-01f, -1.13076091e-01f, -2.10338011e-01f, -5.64051829e-02f, -1.69061333e-01f, 1.23198852e-01f, 4.02323827e-02f,
  -7.42864907e-02f, 8.43140017e-03f, -6.45157769e-02f, 1.56568646e-01f, 2.59664040e-02f, 1.34456336e-01f, -4.57324833e-02f, 7.47285336e-02f, 6.07153866e-04f, 1.24339886e-01f,
  -2.02423185e-02f, -1.41471729e-01f, -4.63762879e-02f, -1.41301844e-02f, -5.27377501e-02f, -2.44566631e-02f, -7.35547990e-02f, -4.71749082e-02f, 8.55178237e-02f, -2.54475698e-02f,
  -2.83524077e-02f, 6.46394566e-02f, 6.28969222e-02f, -6.62345625e-03f, 1.78958289e-02f, 9.51692089e-02f, 7.28318468e-02f, 6.44754618e-02f, 3.27835418e-02f, -5.06844521e-02f,
  -2.78692823e-02f, -5.73737100e-02f, -1.16911732e-01f, -6.53582960e-02f, 8.87010172e-02f, 4.02353033e-02f, 4.45277132e-02f, -4.32817042e-02f, -4.64324802e-02f, 9.67429485e-03f,
  2.76803859e-02f, 9.97835025e-03f, -1.52993565e-02f, 1.36802495e-01f, 8.93150568e-02f, 7.34880269e-02f, -2.60415431e-02f, 8.14623199e-03f, 1.19191771e-02f, 5.80562018e-02f,
  3.25102755e-03f, 6.40391111e-02f, 4.41511236e-02f, -4.98056561e-02f, -2.79658511e-02f, 3.27906273e-02f, 6.36164919e-02f, -4.14745770e-02f, -3.44366941e-04f, 1.04599766e-01f,
  -2.09700800e-02f, -3.65449261e-04f, 7.87056517e-03f, -3.94525975e-02f, -4.75445576e-02f, -8.63010213e-02f, 1.98378251e-03f, -2.16486249e-02f, 3.52706090e-02f, -9.37893428e-03f,
  -2.38752607e-02f, -1.00206628e-01f, -7.30320662e-02f, 7.98776448e-02f, 7.01323478e-03f, -1.16202466e-01f, -2.12195106e-02f, 2.66142190e-02f, -5.49370237e-02f, 7.54293352e-02f,
  6.74713552e-02f, -3.33915353e-02f, 8.81221369e-02f, 3.37252505e-02f, -5.67065068e-02f, 1.61491968e-02f, -8.25652704e-02f, 2.67268196e-02f, -1.51861180e-02f, 8.35601538e-02f,
  1.24685476e-02f, -6.58674613e-02f, -5.05468771e-02f, 3.64941694e-02f, -5.70172269e-04f, -6.22161739e-02f, 5.21749146e-02f, -7.56617263e-02f, -2.57490408e-02f, -5.88700525e-04f,
  -2.50462592e-01f, -2.92774409e-01f, -1.01023793e-01f, -1.74659729e-01f, -4.95633595e-02f, -2.26153210e-02f, 1.68957058e-02f, -2.07674444e-01f, -2.62539923e-01f, 1.07148342e-01f,
  2.49927714e-01f, -1.57516837e-01f, 1.16070203e-01f, 5.56854866e-02f, 1.18818320e-01f, 2.11211234e-01f, -3.66067030e-02f, 2.93944255e-02f, -1.05616398e-01f, -2.16488287e-01f,
  -8.53518993e-02f, 1.47702888e-01f, 1.37604967e-01f, -1.11021921e-01f, -5.92632592e-02f, -1.75767183e-01f, 1.15819804e-01f, 6.48590401e-02f, 1.15786418e-01f, 1.29351661e-01f,
  -9.65611115e-02f, -9.53048691e-02f, 3.09891235e-02f, -8.75229314e-02f, 3.78769301e-02f, -6.51037171e-02f, 1.16755217e-02f, 1.25251904e-01f, -2.26128008e-02f, -2.23166719e-02f,
  7.14207441e-02f, -2.83884108e-02f, 3.49086244e-03f, 2.50578132e-02f, -9.82880220e-03f, 2.59784888e-02f, 7.80822039e-02f, 1.04444688e-02f, -1.01777181e-01f, -4.36123647e-02f,
  -3.44840474e-02f, 3.94289643e-02f, 8.85352865e-03f, -7.05245533e-04f, 5.15814982e-02f, 1.47270295e-03f, 7.92417824e-02f, 7.26394132e-02f, 2.04983577e-02f, -1.05698243e-01f,
  1.21143229e-01f, -6.94673434e-02f, 1.72558222e-02f, -2.15925947e-02f, -2.83076297e-02f, 1.15091931e-02f, 7.44213834e-02f, 4.01173532e-02f, 6.00261800e-02f, 4.09019785e-03f,
  7.69249117e-03f, -1.04435280e-01f, -1.07008055e-01f, -4.56077084e-02f, 2.10499223e-02f, -2.83457208e-02f, 1.04410369e-02f, 2.59914696e-02f, -5.41722178e-02f, -3.70930135e-03f,
  -1.46627957e-02f, -3.77397835e-02f, 3.48655805e-02f, 1.68598033e-02f, -1.46063585e-02f, 8.18182249e-03f, -7.88103268e-02f, 5.83455674e-02f, 9.63616371e-02f, 2.47375499e-02f,
  -9.92608219e-02f, -1.40092000e-01f, -2.58961059e-02f, -4.56532873e-02f, 1.02028713e-01f, 5.83433211e-02f, -2.13890597e-02f, -3.86535972e-02f, 1.05811410e-01f, -8.00811592e-03f,
  2.72327103e-02f, 1.63721386e-02f, -6.43813461e-02f, 7.53774634e-03f, 3.12040336e-02f, -7.63648525e-02f, -3.33258100e-02f, -5.54428957e-02f, -1.65825114e-02f, -2.45165098e-02f,
  4.84126136e-02f, 3.50954123e-02f, 5.96177997e-03f, -5.49469627e-02f, -9.16010235e-03f, 4.53165993e-02f, -1.14524759e-01f, -3.13985124e-02f, 8.42861980e-02f, 5.82260601e-02f,
  1.73744544e-01f, -2.47352019e-01f, -3.75494547e-02f, -4.42848802e-02f, 2.67136812e-01f, 2.68309917e-02f, -8.90947729e-02f, 1.19332321e-01f, 1.06060021e-01f, -8.00769478e-02f,
  1.60041489e-02f, -5.44878468e-02f, -1.53728276e-01f, -2.20038354e-01f, 6.30783513e-02f, -2.60900021e-01f, 5.67195266e-02f, -1.32304907e-01f, 1.08963810e-02f, 6.61388412e-02f,
  -1.42307971e-02f, 6.15704320e-02f, -1.84551314e-01f, 4.02770936e-02f, 7.28668272e-03f, -8.32888559e-02f, 6.56234398e-02f, -2.71360595e-02f, -1.28867805e-01f, 1.06930815e-01f,
  -1.78986974e-02f, -1.56066209e-01f, -2.57141329e-02f, -1.07247457e-01f, -2.72212410e-03f, -1.76502094e-02f, 2.67168451e-02f, -6.52577356e-02f, 4.24485840e-02f, -4.72902581e-02f,
  2.14901939e-02f, 5.27015664e-02f, -1.05939331e-02f, -1.23644173e-02f, 1.55178842e-03f, -4.17485237e-02f, -1.26689479e-01f, -2.25952789e-02f, -7.13807419e-02f, -2.24204250e-02f,
  -8.41052309e-02f, -2.20508948e-02f, 3.28833833e-02f, 1.05867237e-02f, -2.01021731e-02f, -1.79972295e-02f, -6.79741427e-02f, -7.57505670e-02f, -5.48670143e-02f, 4.94958386e-02f,
  1.31132817e-02f, 3.40855010e-02f, -1.15070976e-01f, -2.73722392e-02f, 3.77709903e-02f, 4.39515375e-02f, 4.51531773e-03f, 5.66627225e-03f, -5.75252296e-03f, 7.36000761e-02f,
  3.68323475e-02f, 1.19688250e-02f, -3.97086032e-02f, 4.06449251e-02f, 3.84324193e-02f, -5.31836152e-02f, 2.04061884e-02f, 8.22843686e-02f, -2.79167350e-02f, 1.96732441e-03f,
  6.32366687e-02f, 1.77179638e-04f, 9.30863805e-03f, -3.45749781e-02f, 1.66401211e-02f, 7.63952918e-03f, -4.41404954e-02f, -3.47100981e-02f, -4.79955721e-04f, -1.99949276e-02f,
  1.03003941e-02f, -2.75639147e-02f, -7.28688389e-02f, 2.89568137e-02f, -3.96572575e-02f, -3.11412197e-02f, 2.88482569e-02f, -1.92542803e-02f, -6.69271825e-03f, 8.00464768e-03f,
  7.15709925e-02f, -7.19407797e-02f, 1.05474129e-01f, 2.59926543e-02f, 8.89265258e-03f, -3.98515053e-02f, 7.71108363e-03f, 6.72286078e-02f, 6.08542599e-02f, 3.90402488e-02f,
  1.04819104e-01f, 1.36681728e-03f, -9.95336697e-02f, -5.13067842e-02f, 3.99679691e-02f, 1.93759240e-03f, 6.66931272e-02f, 2.50611417e-02f, -6.78418018e-03f, 2.84108780e-02f,
  -1.37188226e-01f, 1.84264272e-01f, -2.85870790e-01f, -1.01926640e-01f, -1.16607044e-02f, 7.63927847e-02f, -2.34041065e-02f, -1.75286494e-02f, -4.19323482e-02f, 3.37401092e-01f,
  4.71368916e-02f, -2.12979227e-01f, 1.98328926e-04f, 1.95264220e-01f, -6.59616366e-02f, 6.97170710e-03f, 1.64943859e-01f, 2.99886931e-02f, -5.72788119e-02f, 5.71052469e-02f,
  -8.34691897e-02f, 9.64600071e-02f, -1.32924452e-01f, -7.29030138e-03f, -4.94725555e-02f, -1.04979649e-01f, 2.07901262e-02f, -1.58607110e-01f, 2.07458034e-01f, -7.09293038e-02f,
  1.46530330e-01f, -5.13954312e-02f, 2.78905057e-03f, 7.50046456e-03f, 3.78818214e-02f, -5.29162809e-02f, -2.67462828e-03f, -9.20307860e-02f, -7.02883601e-02f, 1.73081830e-03f,
  -3.58151495e-02f, 9.48408619e-03f, -6.97530806e-02f, -7.13349208e-02f, -1.69072058e-02f, 6.50141016e-02f, -5.69417365e-02f, 4.94778827e-02f, -2.81266496e-02f, -5.82285896e-02f,
  -3.91939096e-02f, 6.02401718e-02f, 1.68072544e-02f, 6.47839978e-02f, -6.63949102e-02f, -3.44309281e-03f, 6.79130405e-02f, -6.94168881e-02f, 4.17550392e-02f, 1.02666309e-02f,
  -1.01518847e-01f, -5.86262792e-02f, -2.20512357e-02f, 2.46664770e-02f, -9.09811351e-03f, 1.29628545e-02f, 5.05619794e-02f, 2.43774448e-02f, -1.36303408e-02f, 8.79513100e-02f,
  1.35079637e-01f, 3.29438373e-02f, -1.13290949e-02f, 5.01542315e-02f, -1.19512722e-01f, 1.06008857e-01f, 3.92372534e-02f, 9.17374864e-02f, 7.41206780e-02f, -2.71988334e-03f,
  1.93959530e-02f, 4.00847420e-02f, 8.71936306e-02f, 6.65506274e-02f, 5.69333732e-02f, -7.48616755e-02f, 5.36247119e-02f, 6.57217158e-03f, 8.45381245e-02f, -6.58428892e-02f,
  2.86555111e-01f, 1.82276040e-01f, -1.88926961e-02f, 1.80350825e-01f, -3.22898701e-02f, -1.23249441e-02f, 3.52903306e-02f, 2.92857015e-03f, 1.35869812e-02f, 8.07673112e-02f,
  5.23325615e-03f, 1.08679347e-01f, 3.53193916e-02f, 1.56192482e-02f, -6.31192699e-02f, 6.90536797e-02f, 5.27371801e-02f, 1.47094240e-03f, 1.06215402e-01f, 3.60332988e-02f,
  7.44497925e-02f, 6.83362782e-02f, -3.78917940e-02f, -7.48486295e-02f, -3.10065672e-02f, 3.84315141e-02f, -2.30180603e-02f, -1.05687052e-01f, 1.37489289e-02f, 5.18674590e-03f,
  2.56558001e-01f, -2.35941425e-01f, -1.13776423e-01f, 1.72816098e-01f, -9.32351276e-02f, 1.85069159e-01f, 1.77548692e-01f, -1.83495060e-01f, 7.32354894e-02f, -5.37805259e-02f,
  1.09207958e-01f, -1.11150511e-01f, 3.44980136e-02f, 2.11654708e-01f, 3.05989921e-01f, 1.70684263e-01f, 1.23857796e-01f, 4.11256813e-02f, 2.29974762e-02f, -6.65981546e-02f,
  2.99991854e-02f, 1.10836677e-01f, -3.40673290e-02f, -1.99878156e-01f, -2.35056784e-02f, -7.83653408e-02f, -1.04843117e-01f, -2.27860242e-01f, 5.54194376e-02f, 4.84455191e-02f,
  5.16082942e-02f, 1.12463804e-02f, 6.37532249e-02f, -4.27998826e-02f, -2.86597945e-02f, -6.92668632e-02f, -7.45966733e-02f, 7.32435212e-02f, -8.64803046e-03f, 2.75711026e-02f,
  4.44322452e-02f, -4.10096124e-02f, 6.82004765e-02f, 1.78203471e-02f, -5.58163933e-02f, -5.08957654e-02f, 8.88290256e-02f, 6.42990246e-02f, 1.48954950e-02f, 2.45520007e-02f,
  4.51608673e-02f, 1.03489952e-02f, 1.23880585e-04f, -4.39289026e-02f, 1.40835699e-02f, 6.70776367e-02f, -1.47474147e-02f, -8.75681546e-03f, 5.31242229e-02f, 2.59393714e-02f,
  6.69000074e-02f, -7.76329935e-02f, -6.07006550e-02f, -2.66236067e-03f, 2.22779717e-02f, 1.29645228e-01f, 5.13059609e-02f, 4.34227772e-02f, 1.17706927e-03f, -3.62797752e-02f,
  -3.11030205e-02f, 7.00571155e-03f, 3.44805568e-02f, -6.21421933e-02f, 9.01111290e-02f, 5.75735979e-02f, 2.53004730e-02f, -5.82977943e-02f, 4.29975651e-02f, -3.86144668e-02f,
  -1.23915393e-02f, -7.02500790e-02f, -4.71215434e-02f, -4.52315137e-02f, -4.02981788e-02f, -4.61076805e-03f, 1.28194019e-01f, -2.15010922e-02f, -3.17697413e-02f, -6.31897524e-02f,
  -1.58747599e-01f, -1.71464950e-01f, -4.68380228e-02f, -5.53609207e-02f, -1.41337123e-02f, 1.41677503e-02f, 3.09215896e-02f, 1.11420318e-01f, -7.24648461e-02f, -6.56350255e-02f,
  -2.49141548e-02f, -5.29518239e-02f, -1.19412793e-02f, -1.38331288e-02f, -8.10680091e-02f, -1.98187660e-02f, 5.06982431e-02f, -2.60566194e-02f, 1.55003620e-02f, 1.51135195e-02f,
  -1.03157170e-01f, -6.70558065e-02f, -1.39855756e-03f, 7.86702707e-03f, 7.18629286e-02f, 1.31711930e-01f, -3.19329761e-02f, -1.21813469e-01f, -4.10707854e-02f, 4.28231619e-03f,
  -5.36830008e-01f, 4.50325347e-02f, 1.29006384e-03f, -3.15239638e-01f, 1.88306123e-01f, 5.91090955e-02f, -5.79899587e-02f, 6.86007738e-02f, -2.34084755e-01f, 6.21228665e-02f,
  1.23528205e-01f, -2.03333691e-01f, 1.49174049e-01f, 1.46486228e-02f, -5.00281416e-02f, -3.24690342e-03f, -5.76686114e-02f, -3.91942896e-02f, -5.03918827e-02f, 3.91159914e-02f,
  -7.28621557e-02f, 9.13519785e-02f, 5.68694733e-02f, 1.86724439e-01f, -6.60351617e-03f, -9.07599404e-02f, 6.48293272e-02f, 4.66330349e-02f, 1.27761230e-01f, 2.18303483e-02f,
  -2.79271789e-02f, -9.43421796e-02f, -2.15014704e-02f, -6.26460835e-02f, -8.80174804e-03f, 8.30220431e-02f, 5.76177873e-02f, -2.92196199e-02f, -6.94724619e-02f, 3.29378210e-02f,
  3.45220007e-02f, 4.37738927e-04f, 2.27237586e-02f, 6.55010417e-02f, 6.27787877e-03f, -3.35187539e-02f, 7.89071620e-02f, 7.63875917e-02f, -4.74501261e-03f, 7.42910877e-02f,
  -6.31608143e-02f, -9.79373511e-03f, -8.44746828e-03f, -1.60780419e-02f, 3.47988270e-02f, 8.10156092e-02f, -3.23703326e-02f, 5.92833534e-02f, -4.28767279e-02f, -7.44164884e-02f,
  6.43632039e-02f, -2.26985700e-02f, -9.97603536e-02f, 6.95675728e-04f, -1.08282641e-01f, 1.59185473e-02f, 3.39428484e-02f, -4.32685018e-02f, -1.32287130e-01f, -5.35387993e-02f,
  -4.66977013e-03f, -4.96848635e-02f, 5.81172742e-02f, -8.90980959e-02f, -4.49245684e-02f, -2.89894808e-02f, 4.21633162e-02f, -7.75895491e-02f, -6.10530004e-03f, 6.29473105e-02f,
  -5.61267696e-02f, 5.70086762e-02f, 4.52970155e-02f, 4.66288812e-03f, 3.60762211e-03f, -2.01561265e-02f, 5.24120172e-03f, 5.49383722e-02f, 7.26949871e-02f, -1.20668262e-02f,
  -1.23290434e-01f, -2.44352773e-01f, -7.68467411e-02f, -5.24259694e-02f, -1.62306223e-02f, 4.85527180e-02f, 1.62128024e-02f, -5.01263747e-03f, -5.90706654e-02f, -3.55176032e-02f,
  6.35268390e-02f, -9.51865986e-02f, 4.36930135e-02f, -5.06381765e-02f, 1.56423431e-02f, -3.74956913e-02f, 3.97535451e-02f, -9.56198797e-02f, 1.01712635e-02f, 6.19804338e-02f,
  -7.33776614e-02f, -1.22585334e-01f, 1.24375187e-02f, -1.28532657e-02f, 1.59733500e-02f, 7.36784562e-02f, -7.23978430e-02f, -8.73213187e-02f, 2.03928854e-02f, -1.87273454e-02f,
  2.11359397e-01f, -1.24538094e-01f, -1.58516482e-01f, 1.89304333e-02f, 9.71378833e-02f, -1.45248488e-01f, -1.04650840e-01f, -9.69466045e-02f, -2.14460433e-01f, 2.67060054e-03f,
  1.41180992e-01f, -1.76002815e-01f, -1.61228955e-01f, 6.29368573e-02f, 4.35836054e-02f, -3.12946200e-01f, 1.67652369e-02f, 8.31400231e-02f, -1.47148192e-01f, 1.50053874e-01f,
  -2.13034675e-02f, 1.77294150e-01f, 2.26495527e-02f, 9.67705473e-02f, 3.09079178e-02f, 8.36873129e-02f, 1.49126008e-01f, -2.77699418e-02f, 1.87210768e-01f, -1.27321377e-01f,
  4.56124619e-02f, 3.42855118e-02f, -3.14803645e-02f, -7.26347715e-02f, 1.34439632e-01f, 1.07229389e-01f, 1.18841212e-02f, -6.43476546e-02f, 1.24321505e-01f, -6.40597381e-03f,
  -1.00420108e-02f, 1.38461487e-02f, -9.26958630e-04f, -1.34422019e-01f, 2.45793406e-02f, -5.85555360e-02f, 8.09793770e-02f, 6.46675657e-03f, 4.26966585e-02f, -3.79390828e-02f,
  -4.80055176e-02f, 9.66448430e-03f, -8.40350911e-02f, 7.64763951e-02f, -5.94308553e-03f, 5.06825112e-02f, 4.17037355e-03f, 6.71596080e-02f, -1.32248610e-01f, 1.04984315e-02f,
  -3.86940092e-02f, -5.38902096e-02f, 7.91699812e-02f, -4.81956080e-02f, 3.99130657e-02f, 3.82551067e-02f, -3.37014534e-02f, 6.69867024e-02f, 5.42906970e-02f, 3.65509875e-02f,
  1.30829483e-01f, -3.19593549e-02f, -9.92207378e-02f, 5.42152114e-02f, 7.41946399e-02f, -1.97102204e-01f, -7.63303228e-03f, 3.65296155e-02f, 8.83869529e-02f, 7.26669133e-02f,
  -1.38314933e-01f, -8.91131873e-04f, 1.44599020e-01f, -9.17456076e-02f, 7.33047202e-02f, 3.55906934e-02f, -3.70090120e-02f, -1.66728646e-01f, 6.28700703e-02f, -3.97256985e-02f,
  1.25729933e-01f, 1.39510809e-02f, -3.49305980e-02f, 2.56561060e-02f, 4.29996811e-02f, 1.75582841e-02f, -1.77811503e-01f, 2.57674493e-02f, 8.21669586e-03f, -6.20851852e-02f,
  1.14134029e-01f, 8.78591985e-02f, -1.05745524e-01f, 6.61050752e-02f, -5.35657108e-02f, -4.06394266e-02f, -2.11703572e-02f, 1.01713039e-01f, 7.40858018e-02f, 8.14656690e-02f,
  5.28435260e-02f, 9.21372622e-02f, -4.84442851e-03f, 4.89519425e-02f, 7.09616840e-02f, 2.88535208e-02f, 2.66791731e-02f, 1.95433684e-02f, -1.50082575e-03f, -5.30456789e-02f,
  -3.45173329e-02f, 3.27366753e-03f, -2.05521435e-01f, -7.26860836e-02f, 5.88979684e-02f, -1.57621652e-01f, -2.00122967e-01f, 3.06058675e-03f, -1.66089594e-01f, -3.25739272e-02f,
  1.06806129e-01f, -1.05453238e-01f, -7.77178556e-02f, 7.95445591e-02f, 1.07331164e-01f, -1.07659817e-01f, 1.17703222e-01f, 2.95545962e-02f, -5.80684803e-02f, 1.01331763e-01f,
  -9.54952240e-02f, 2.30944067e-01f, 4.08764146e-02f, 9.00462046e-02f, 2.83002164e-02f, -2.56051961e-02f, 2.97688156e-01f, -1.43052330e-02f, 2.93889433e-01f, 5.11543676e-02f,
  8.51504952e-02f, 5.15279034e-03f, -8.17299262e-02f, -5.61877154e-02f, 9.28911045e-02f, -1.04957270e-02f, -6.49505854e-02f, -1.01743385e-01f, -3.76987010e-02f, 1.70004293e-02f,
  -5.93443289e-02f, -2.51397993e-02f, 8.46938044e-02f, -4.89636660e-02f, -7.54356012e-02f, 6.45222068e-02f, -2.92929448e-02f, -7.71412924e-02f, -5.55137470e-02f, -2.59561203e-02f,
  -1.50650978e-01f, -2.10884046e-02f, -4.54830118e-02f, 4.01246510e-02f, -7.46689588e-02f, -2.39999592e-03f, 3.08102798e-02f, 3.40438494e-03f, 4.75792699e-02f, 7.67283002e-03f,
  -5.51187024e-02f, -6.00202978e-02f, -6.36501089e-02f, 3.96576636e-02f, -4.16330472e-02f, 4.14575450e-02f, 8.82078800e-03f, -1.59023888e-02f, 4.67962623e-02f, 1.28226504e-01f,
  1.10706091e-01f, -2.28515863e-02f, -4.40083966e-02f, -8.00854191e-02f, -7.59020820e-02f, 1.40684210e-02f, 3.37745287e-02f, 1.39009990e-02f, -5.69721200e-02f, 1.51980491e-02f,
  3.25381048e-02f, 8.86419136e-03f, 1.07700504e-01f, -6.74074842e-03f, 1.39792170e-02f, -4.00968120e-02f, -8.19672048e-02f, 1.32718626e-02f, 9.74030718e-02f, 1.86157096e-02f,
  1.79001197e-01f, 2.53465921e-01f, -8.00741985e-02f, -5.50389197e-03f, 1.04036614e-01f, 1.77901033e-02f, -4.76297662e-02f, -1.52059142e-02f, 2.14046221e-02f, -1.27768377e-02f,
  -8.03088322e-02f, 4.08642925e-03f, 6.39902949e-02f, 1.61019918e-02f, -1.14345700e-02f, 4.20541093e-02f, 8.95168111e-02f, -5.48069179e-02f, 1.22133300e-01f, 6.89116940e-02f,
  1.22096471e-01f, 8.59774277e-02f, -2.02549752e-02f, 2.92462967e-02f, -8.78135022e-03f, 1.28270745e-01f, -4.35346141e-02f, -5.08154705e-02f, 9.55047384e-02f, 8.24175626e-02f,
  1.13888882e-01f, 6.70971647e-02f, -5.50422110e-02f, 9.73632783e-02f, 1.11119486e-01f, -1.52490407e-01f, -3.15801471e-01f, 2.36157253e-01f, 4.21190023e-01f, -1.06292516e-02f,
  -4.22404744e-02f, -9.98700969e-03f, -1.24471113e-01f, -1.68322116e-01f, -1.43134221e-01f, -1.72597915e-01f, -8.57907161e-02f, -1.36682883e-01f, 1.73085228e-01f, 1.41791003e-02f,
  1.01572473e-03f, -1.44447401e-01f, -2.87640184e-01f, 1.07058026e-01f, -8.97093490e-02f, 1.56549633e-01f, -4.85269651e-02f, -4.86508496e-02f, -1.30314022e-01f, -9.56622660e-02f,
  -5.91670722e-02f, -1.94251165e-02f, -3.52431573e-02f, 3.31236199e-02f, -8.22389871e-03f, 8.78416933e-03f, -7.36429393e-02f, -8.61989856e-02f, 3.23797539e-02f, 4.17225212e-02f,
  -5.98431341e-02f, 1.24693634e-02f, 3.29560898e-02f, 7.25494623e-02f, 4.88623567e-02f, -2.76435330e-03f, 3.38536650e-02f, -8.81528109e-03f, 2.06584387e-04f, -3.02315932e-02f,
  6.33554021e-03f, -8.20844769e-02f, -3.77968177e-02f, -1.68128274e-02f, -6.40300522e-03f, 1.46466885e-02f, -9.66799334e-02f, -5.20918109e-02f, -8.20129886e-02f, 1.38348982e-01f,
  3.06580644e-02f, 1.96375903e-02f, -3.40680778e-02f, 2.17746804e-03f, 2.08815597e-02f, 3.76125774e-03f, -3.40946317e-02f, -8.07519257e-02f, 1.00192510e-01f, -8.61452147e-02f,
  -2.07032897e-02f, 7.47804195e-02f, -2.64708921e-02f, 1.16155446e-02f, -5.51550649e-02f, 4.07990254e-02f, -1.59924645e-02f, 1.82227138e-02f, 6.36642724e-02f, 2.49089450e-02f,
  -8.18985107e-04f, 2.63181943e-02f, -3.76318917e-02f, 8.21766723e-03f, -6.21546283e-02f, 3.25629339e-02f, 1.92374177e-02f, -7.27660730e-02f, -6.48742765e-02f, -5.40010817e-02f,
  -5.31479158e-03f, 8.43023285e-02f, -3.06712873e-02f, -2.08151061e-02f, 1.14038575e-03f, -4.48323302e-02f, -7.76506439e-02f, 3.94500755e-02f, 7.89456889e-02f, 4.52276915e-02f,
  -3.39639820e-02f, -6.16951846e-02f, -2.09722086e-03f, 1.99150573e-02f, -1.00147706e-02f, 4.96210009e-02f, -5.62771000e-02f, 7.92365745e-02f, 5.60917072e-02f, 5.52315749e-02f,
  -4.31415178e-02f, 5.30933263e-03f, 1.44776907e-02f, 1.26188463e-02f, -2.92561259e-02f, -6.21828809e-03f, 1.08747356e-01f, 5.11785708e-02f, 1.79890636e-02f, -1.58125814e-02f,
  2.82786991e-02f, 1.88068580e-02f, 7.39469305e-02f, -1.12493441e-01f, 4.45071906e-02f, 2.13701352e-01f, -1.60843700e-01f, 1.21186249e-01f, 2.16492891e-01f, -1.29429579e-01f,
  -1.93696007e-01f, 3.75586897e-02f, -1.09294221e-01f, -3.30196470e-02f, 3.26916486e-01f, 5.03594801e-02f, 2.62142532e-02f, -1.49143845e-01f, 6.06208108e-02f, 5.94316944e-02f,
  1.05047442e-01f, -1.25456806e-02f, 3.30072083e-02f, 4.70582992e-02f, -2.14173011e-02f, -1.25455335e-01f, -4.56247926e-02f, -7.59198368e-02f, -9.73976403e-02f, 1.63226798e-02f,
  1.25090554e-01f, -1.12837657e-01f, -9.19346735e-02f, 7.69030973e-02f, 5.85899465e-02f, -1.08355083e-01f, -8.23162347e-02f, -7.77945518e-02f, 1.10511743e-02f, -2.23540072e-03f,
  -3.23515236e-02f, 1.10506773e-01f, 6.21245056e-02f, 4.35953913e-03f, -8.80341902e-02f, 6.25814945e-02f, -1.22156315e-01f, -1.38985857e-01f, 4.61873226e-02f, -1.27531476e-02f,
  9.62908864e-02f, 7.33241290e-02f, -1.10986039e-01f, -3.42162959e-02f, 1.84863787e-02f, 5.53440005e-02f, -2.38384791e-02f, -4.68541794e-02f, -5.32113202e-02f, 2.92786714e-02f,
  2.48334147e-02f, -8.05260241e-02f, -1.20827973e-01f, 3.83896679e-02f, 4.11342131e-03f, -1.14519270e-02f, 2.42564995e-02f, -2.34716106e-02f, -4.54080570e-03f, 8.73924792e-02f,
  -6.82506785e-02f, -4.52329591e-02f, -1.31235681e-02f, -1.17203534e-01f, -1.39462858e-01f, -1.73698608e-02f, 3.56971920e-02f, -6.66535795e-02f, -3.15416567e-02f, -1.16061727e-02f,
  -3.49476673e-02f, 3.68110016e-02f, 1.42258080e-02f, -6.13694713e-02f, 9.69217997e-03f, 6.22788146e-02f, 1.27675487e-02f, 9.34812427e-02f, -2.22877171e-02f, 8.29037372e-03f,
  1.97085306e-01f, 6.65633827e-02f, -3.96329984e-02f, 1.12088934e-01f, 3.26551758e-02f, -5.83897084e-02f, 5.37377596e-02f, -1.91531871e-02f, -1.05778677e-02f, 1.42280404e-02f,
  -1.35124788e-01f, -8.33078027e-02f, 1.49379060e-01f, 5.00239953e-02f, -2.97007654e-02f, 4.76789996e-02f, -9.63599309e-02f, -6.77043125e-02f, 2.46612504e-02f, 1.86834391e-02f,
  1.24394177e-02f, 1.41836315e-01f, -3.35823409e-02f, -6.61206618e-02f, -5.45874983e-02f, -3.33092511e-02f, -1.12151457e-02f, -2.05325074e-02f, -2.57556979e-03f, 1.20734088e-01f,
  2.06381112e-01f, -1.59446031e-01f, -6.02131486e-02f, 1.70702845e-01f, -5.67621328e-02f, 1.19389735e-01f, 1.24949172e-01f, 2.60710511e-02f, 2.76933908e-01f, 1.20367594e-01f,
  2.10984766e-01f, -1.10982634e-01f, -7.05200806e-02f, 3.38187546e-01f, 2.75648385e-01f, 2.16596305e-01f, 2.56292015e-01f, 1.28238022e-01f, 4.74273302e-02f, -7.15436786e-02f,
  -5.94191849e-02f, 1.48354024e-01f, -4.04904038e-02f, -2.56974120e-02f, -4.12131920e-02f, -2.18369856e-01f, -1.03457414e-01f, -1.40723258e-01f, -2.48364229e-02f, -3.63317728e-02f,
  1.06625162e-01f, -1.31370062e-02f, 8.52522403e-02f, -1.51862085e-01f, -1.01314634e-01f, -1.86368719e-01f, -7.91482329e-02f, -3.37702408e-02f, 3.22157030e-05f, -2.12544110e-02f,
  -1.51130185e-01f, -2.75604445e-02f, 2.39365734e-02f, 9.29641351e-03f, -3.89686674e-02f, -2.41013747e-02f, -3.09549123e-02f, -1.94027461e-02f, 4.10454236e-02f, 2.93456912e-02f,
  -3.52765955e-02f, 2.49315351e-02f, 2.68484615e-02f, -4.01377380e-02f, -5.34177534e-02f, 2.50348300e-02f, -2.53522880e-02f, -1.01344869e-01f, 7.41526717e-03f, -1.63657647e-02f,
  3.48020047e-02f, -1.06787831e-01f, -2.52614588e-01f, -3.00876312e-02f, 4.38150801e-02f, 6.38032928e-02f, 5.01376837e-02f, 1.32723339e-02f, -1.15718571e-02f, -3.50064551e-03f,
  3.87819186e-02f, 3.39456573e-02f, 4.11616638e-02f, -3.57765146e-02f, -9.01988670e-02f, -1.46716246e-02f, -5.74975125e-02f, 3.25855729e-03f, 1.06517151e-02f, 9.22559872e-02f,
  -7.78799003e-04f, 8.82845074e-02f, 1.20901801e-02f, 6.25372902e-02f, 1.21776924e-01f, -1.05338050e-02f, 8.64710584e-02f, -4.02483605e-02f, -3.78302857e-02f, -3.64017971e-02f,
  -7.41265938e-02f, -1.45086095e-01f, -4.12766412e-02f, -6.43730238e-02f, 4.20215800e-02f, -8.14394951e-02f, 4.17909166e-03f, -6.18091691e-03f, -5.98107800e-02f, -2.25745011e-02f,
  -2.20949501e-01f, -7.41247013e-02f, -5.10446765e-02f, 2.00559497e-02f, 7.60943517e-02f, 1.45192491e-02f, -8.87559280e-02f, -4.18622680e-02f, -2.07817983e-02f, 4.04485278e-02f,
  -9.98655409e-02f, -5.71017824e-02f, 2.83527970e-02f, -1.55855596e-01f, 4.98363562e-02f, -5.87097891e-02f, -2.53980756e-02f, -1.15416355e-01f, 4.91750017e-02f, 2.15262361e-02f,
  -3.37513983e-01f, 1.81796059e-01f, 1.11726165e-01f, -8.83228704e-02f, 5.78070944e-03f, 1.26877964e-01f, 1.66318163e-01f, -3.84279825e-02f, 4.06327918e-02f, -4.55213934e-02f,
  -2.48763591e-01f, 1.98497519e-01f, 9.61372554e-02f, -6.78444142e-03f, 9.11678299e-02f, 1.79368526e-01f, -7.18488321e-02f, -2.51605753e-02f, 1.61291838e-01f, -6.75745979e-02f,
  -5.94548099e-02f, -2.26368792e-02f, 3.55482548e-02f, 2.32581042e-05f, -1.97323099e-01f, -1.39869466e-01f, -1.61522269e-01f, 4.65770178e-02f, -1.06526129e-02f, 8.31024647e-02f,
  -4.30622883e-02f, -7.56832659e-02f, -7.83380568e-02f, -2.68416181e-02f, -1.44016594e-01f, 3.29523743e-03f, 5.61033860e-02f, 1.26891956e-01f, -2.05822964e-03f, -1.37272701e-01f,
  3.37363854e-02f, -3.92118730e-02f, -1.72994193e-02f, 6.54126629e-02f, 7.72026414e-03f, 3.38142067e-02f, 5.41618876e-02f, -2.84236837e-02f, 5.26847690e-02f, -2.66085509e-02f,
  -2.46071480e-02f, -5.14125042e-02f, 2.41742563e-02f, -1.35133475e-01f, 4.83569913e-02f, 4.39047739e-02f, 1.24312632e-01f, 6.50600865e-02f, -4.71714064e-02f, -3.23044807e-02f,
  -7.36452565e-02f, 6.77791610e-02f, -1.72138289e-02f, 8.19436610e-02f, -1.01593444e-02f, -9.24039185e-02f, 7.40694851e-02f, 2.58767847e-02f, -4.70099747e-02f, -3.19629386e-02f,
  -7.61030838e-02f, 4.42655832e-02f, -8.01483635e-03f, -3.73258023e-03f, 1.30928624e-02f, 6.41090944e-02f, 3.86784924e-03f, -2.47006025e-02f, 4.06958573e-02f, -6.36152774e-02f,
  -8.52783695e-02f, -7.08231181e-02f, -1.79142680e-03f, -4.41775434e-02f, -9.89123620e-03f, 9.94917080e-02f, 1.35832936e-01f, 9.18871611e-02f, -8.94036959e-04f, -3.04520670e-02f,
  2.96259802e-02f, -2.29215063e-02f, -1.00676499e-01f, -1.30559489e-01f, -8.29170272e-02f, 5.46721779e-02f, 1.27976269e-01f, -8.81077126e-02f, 1.93743557e-01f, -8.65409523e-02f,
  -2.00982969e-02f, -1.04140043e-01f, 2.15591397e-02f, 3.09280623e-02f, 4.15406562e-02f, 1.35367453e-01f, 5.21942824e-02f, 6.39453670e-03f, -6.99780881e-02f, -3.32711376e-02f,
  -1.01119600e-01f, 2.96624191e-02f, -1.36247068e-03f, -6.07499257e-02f, -6.34506643e-02f, -9.09573864e-03f, -8.38484168e-02f, -2.92682648e-02f, -7.90028926e-03f, 4.73314486e-02f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.14657167e-02f, -1.13047972e-01f, 2.92449325e-01f, -6.36285022e-02f, 1.22649364e-01f, 1.92002088e-01f, 2.13573828e-01f, 9.26156193e-02f, 1.02531247e-01f, -2.19685435e-01f,
  -1.04132652e-01f, -8.75303373e-02f, 1.51544839e-01f, -2.71932304e-01f, 4.02871251e-01f, 2.02205971e-01f, 3.62444483e-02f, -6.26602918e-02f, 6.54776543e-02f, -2.21745521e-01f,
  -1.57495409e-01f, -2.60627836e-01f, -5.13482057e-02f, -3.01059723e-01f, -3.28534216e-01f, -1.33195743e-01f, -1.38351604e-01f, 3.10875475e-02f, -2.80448943e-01f, 1.79525390e-01f,
  -6.81763291e-02f, -1.02259934e-01f, -1.12667009e-01f, 1.20305024e-01f, -5.98645620e-02f, 1.31165266e-01f, -3.39869149e-02f, 7.73106888e-02f, 5.21887317e-02f, -2.59931833e-02f,
  3.04023764e-04f, -3.72251384e-02f, -1.17256477e-01f, 7.96175674e-02f, 1.31248206e-01f, -3.26198526e-02f, -5.73000535e-02f, 1.82980462e-03f, -7.12332353e-02f, 1.23088159e-01f,
  -2.89464127e-02f, -8.32844153e-02f, -1.42957689e-02f, -2.02418715e-02f, 5.02426960e-02f, -4.97601740e-03f, -3.82429734e-02f, 1.09810941e-01f, -6.22792281e-02f, 2.56418940e-02f,
  -2.09492650e-02f, 1.54860631e-01f, 6.69941828e-02f, -9.49042737e-02f, -2.61452720e-02f, -8.56495425e-02f, -9.05917957e-02f, -7.81101882e-02f, 4.94213626e-02f, -9.49846581e-02f,
  -2.56619416e-02f, 2.90615764e-03f, -2.16248222e-02f, -5.79184331e-02f, 1.37279062e-02f, 1.13515723e-02f, -6.25184700e-02f, 2.00189352e-02f, -8.50232551e-04f, -4.43118513e-02f,
  -6.08575456e-02f, 3.84173766e-02f, -1.85029749e-02f, -6.92855716e-02f, -6.65715290e-03f, -9.23491642e-03f, -1.51196405e-01f, 7.04008639e-02f, -9.73560382e-04f, 1.21881149e-03f,
  -5.28912712e-03f, -7.01505244e-02f, -7.96718597e-02f, -1.19363882e-01f, -7.39082024e-02f, -6.92118332e-02f, -9.46525112e-02f, -1.62795022e-01f, 7.61015266e-02f, -2.09104884e-02f,
  -2.29575690e-02f, -8.40060934e-02f, 3.75408381e-02f, 6.38706982e-02f, 5.25896288e-02f, 1.04272999e-02f, -1.07144125e-01f, -2.72266306e-02f, 4.97486442e-02f, 1.36990352e-02f,
  -1.33671770e-02f, -9.91664641e-03f, 2.94565428e-02f, -1.38044894e-01f, -5.96798211e-02f, 2.50370502e-02f, -7.50686824e-02f, 3.68194506e-02f, 1.33762611e-02f, 1.73865203e-02f,
  9.30960402e-02f, 1.27276987e-01f, 1.46233484e-01f, 1.23346820e-01f, -8.98745656e-02f, -2.74554759e-01f, -1.99393570e-01f, 1.01293482e-01f, -1.92054480e-01f, 3.18801403e-02f,
  1.33541241e-01f, 3.61600183e-02f, 1.91112071e-01f, 5.47461547e-02f, -4.85710278e-02f, 7.11760819e-02f, 8.37185606e-02f, 1.21509647e-02f, 1.98384151e-02f, 1.41290963e-01f,
  9.97905135e-02f, 8.87404904e-02f, 2.44951144e-01f, 1.10295296e-01f, 8.93167183e-02f, 1.50053367e-01f, 1.96900561e-01f, 6.34237304e-02f, 1.36671275e-01f, -2.32132636e-02f,
  1.84710994e-02f, 1.53665051e-01f, 4.86872596e-04f, -4.26027887e-02f, 1.19694114e-01f, -1.25419991e-02f, -4.48800176e-02f, -8.20950046e-02f, -9.87637490e-02f, 1.51844367e-01f,
  -8.81031156e-03f, -2.35993322e-02f, 4.89584543e-03f, 2.78621260e-02f, -1.01727746e-01f, -9.14002284e-02f, -1.03695102e-01f, -1.05629951e-01f, -7.14405626e-02f, 1.66894078e-01f,
  -2.07259282e-02f, -7.07013384e-02f, -6.02824390e-02f, 4.37787920e-02f, 2.36778948e-02f, 6.56097904e-02f, -4.43929769e-02f, 3.23513150e-02f, -9.89599377e-02f, 5.20370789e-02f,
  4.42010611e-02f, 1.03881620e-02f, -1.48556223e-02f, -3.15361880e-02f, -3.51898260e-02f, 5.74738383e-02f, -1.24319054e-01f, -8.19664262e-03f, -4.63043638e-02f, 4.05939035e-02f,
  -1.43197430e-02f, -1.86744444e-02f, 1.04887806e-01f, 8.63451883e-02f, -1.25201151e-03f, 1.84643175e-02f, 8.27221572e-03f, 2.71545891e-02f, -1.11217998e-01f, -8.20163637e-02f,
  1.03241429e-02f, -1.05535194e-01f, -1.06241174e-01f, 4.08277772e-02f, -1.07571393e-01f, 2.23702155e-02f, 8.24380592e-02f, 3.47662568e-02f, 3.96576859e-02f, -2.98629777e-04f,
  7.91471303e-02f, 1.67879283e-01f, -4.99838293e-02f, -7.63815222e-03f, -1.51273375e-02f, -2.42034066e-02f, -1.66938864e-02f, -2.39820313e-02f, 1.42429536e-02f, 4.09307331e-02f,
  1.26464903e-01f, -6.32933080e-02f, -3.36761177e-02f, 4.47581289e-04f, -1.26858905e-01f, 4.31807898e-02f, 1.35896578e-01f, -5.47969565e-02f, -5.47563517e-03f, 1.15389951e-01f,
  7.38819176e-03f, -1.05077028e-01f, -6.55107573e-02f, -1.23590939e-01f, -1.26832947e-02f, -3.16736884e-02f, -7.97083676e-02f, 6.33263811e-02f, 6.02704808e-02f, 3.42903510e-02f,
  2.58161336e-01f, -1.99886590e-01f, 1.22670554e-01f, 2.66463906e-01f, 2.10603684e-01f, 9.44098234e-02f, 2.77845472e-01f, 5.39788194e-02f, 3.21231365e-01f, -2.18400106e-01f,
  -1.12760477e-01f, -1.07416190e-01f, -8.05190951e-02f, -1.12309970e-01f, 1.87194347e-01f, -7.23688975e-02f, 1.19055375e-01f, 2.02353876e-02f, 1.83749199e-01f, 7.68063590e-02f,
  2.79533155e-02f, 5.00235148e-03f, -1.50413457e-02f, -1.48155928e-01f, 6.61936030e-02f, -1.31585672e-01f, -6.02789558e-02f, 2.81054005e-02f, -2.31565878e-01f, 3.09690051e-02f,
  5.76896071e-02f, -1.27808489e-02f, -6.30728230e-02f, -3.78911830e-02f, -3.27225775e-02f, -1.49881348e-01f, -9.14972499e-02f, -6.27382398e-02f, 9.76597816e-02f, -3.82374413e-02f,
  -2.51623951e-02f, -2.26531811e-02f, -5.79685308e-02f, -3.37362364e-02f, 7.68928006e-02f, -9.77161713e-03f, 7.27336388e-03f, -6.52158335e-02f, 1.93593986e-02f, -9.53525379e-02f,
  2.25089653e-03f, -8.45483411e-03f, 8.34980905e-02f, -1.01242252e-01f, -3.14292568e-03f, 2.04418357e-02f, -7.67892823e-02f, 1.07117472e-02f, 2.93365922e-02f, 1.19251497e-02f,
  -1.72215104e-02f, 1.28848723e-03f, 1.43416356e-02f, -4.28656628e-03f, 1.96357239e-02f, 2.80208401e-02f, -6.10961253e-03f, -3.03517729e-02f, 4.95508388e-02f, 2.37686932e-02f,
  2.49064229e-02f, 3.38755138e-02f, 7.83748850e-02f, 1.34234741e-01f, 5.99197522e-02f, -4.09080163e-02f, -2.37915218e-02f, -5.09509258e-02f, 4.79366593e-02f, -1.56186139e-02f,
  -7.86490142e-02f, -4.03160490e-02f, 3.73684838e-02f, -5.74365556e-02f, -3.79963294e-02f, -1.72392502e-02f, 5.34158461e-02f, -1.34764183e-02f, -1.21167693e-02f, -5.05850837e-02f,
  -1.09865246e-02f, -2.18150392e-01f, -4.40725386e-02f, -5.53622358e-02f, 1.78133268e-02f, -3.84231992e-02f, -1.93414092e-03f, 8.54074657e-02f, 3.65688168e-02f, -6.79639867e-03f,
  -8.35815817e-02f, 5.39660566e-02f, -8.23564753e-02f, -7.75905699e-02f, -3.66532393e-02f, -2.03456618e-02f, -3.97714637e-02f, 8.28258619e-02f, 3.86217758e-02f, -5.92350066e-02f,
  1.29961343e-02f, -7.35455304e-02f, -5.11438847e-02f, -7.00275525e-02f, -5.63678592e-02f, -2.90660299e-02f, -1.08925767e-01f, -8.06114345e-04f, -9.65341106e-02f, 2.35342626e-02f,
  1.69544011e-01f, -3.83332651e-03f, -4.32923660e-02f, -2.14274437e-03f, -4.77954186e-02f, -3.85175012e-02f, -2.66124427e-01f, -2.29638703e-02f, -2.96095490e-01f, -1.75096184e-01f,
  1.00486010e-01f, -1.00479074e-01f, -8.84782150e-02f, 2.47091234e-01f, 2.52654135e-01f, -5.40941842e-02f, 1.51316628e-01f, 1.35420740e-01f, 1.14523120e-01f, 9.74839404e-02f,
  1.97373241e-01f, 3.28231454e-01f, 2.30727494e-01f, 2.45750204e-01f, 1.72775820e-01f, 1.84563294e-01f, 1.62720397e-01f, 1.45864515e-02f, 2.33121991e-01f, 1.00008324e-01f,
  2.16577705e-02f, 2.23025735e-02f, -2.90569030e-02f, 2.80751493e-02f, -5.31767607e-02f, 2.56576035e-02f, -4.38581072e-02f, 1.27564371e-01f, 3.10703414e-03f, 6.38655350e-02f,
  -2.50337552e-02f, 1.05440788e-01f, 3.60437892e-02f, -5.36435749e-03f, 7.76551366e-02f, -7.08997473e-02f, -2.43264232e-02f, -1.33559862e-02f, -7.46708512e-02f, 9.66284201e-02f,
  -4.96503748e-02f, -2.21817624e-02f, -8.11299533e-02f, -3.05333901e-02f, 3.82405668e-02f, -3.94329578e-02f, -8.26608986e-02f, -7.26998523e-02f, -3.67055051e-02f, -7.84073696e-02f,
  4.82900403e-02f, 3.19024771e-02f, 2.45275907e-02f, 7.51977786e-03f, 1.25397258e-02f, 3.06072552e-02f, 2.90457234e-02f, -3.88288964e-03f, -3.39882448e-02f, -1.12436913e-01f,
  -1.54990871e-02f, 4.83766571e-03f, -1.15207531e-01f, 2.02265773e-02f, 9.83127132e-02f, 4.52577695e-03f, -3.23482789e-02f, 4.44237366e-02f, -1.61113456e-01f, -7.87603557e-02f,
  -9.53955576e-02f, 1.53650001e-01f, -2.60078926e-02f, 5.06724976e-02f, 3.27411927e-02f, -4.70668599e-02f, 3.42857763e-02f, -4.62565292e-03f, -5.39614260e-02f, -3.75507772e-02f,
  -6.85517862e-02f, 5.99930733e-02f, -2.35704519e-03f, 5.94544820e-02f, -7.81280696e-02f, -1.17239162e-01f, -4.95709069e-02f, 3.92772891e-02f, -5.23805544e-02f, 1.08429387e-01f,
  8.84618163e-02f, 1.74751244e-02f, -5.78755839e-03f, -3.00486200e-02f, 1.21917501e-01f, -4.15696874e-02f, 5.42537048e-02f, -6.27181381e-02f, -1.05557211e-01f, 5.79444394e-02f,
  -3.33476812e-03f, -1.98643087e-04f, -7.97627047e-02f, -7.26576969e-02f, 2.79178061e-02f, -3.70632634e-02f, 3.90593521e-02f, -4.47607301e-02f, 1.15749903e-01f, -4.02435251e-02f,
  1.86699688e-01f, -3.02291691e-01f, -3.10214274e-02f, 1.52307451e-01f, 2.02798352e-01f, -2.20268127e-02f, -6.10424951e-02f, 5.16705476e-02f, -3.07794958e-02f, -2.07976222e-01f,
  6.20016083e-02f, -6.17519952e-04f, -1.93983749e-01f, 2.35749763e-02f, 1.95588425e-01f, -1.82052195e-01f, 1.62472367e-01f, 6.92955330e-02f, -2.40061115e-02f, 2.75057945e-02f,
  4.34406586e-02f, 5.38801104e-02f, 8.17571133e-02f, 1.02395013e-01f, 3.28104272e-02f, -2.11854521e-02f, 7.60608688e-02f, 5.38898930e-02f, 6.87884763e-02f, 1.22970268e-01f,
  -9.08005424e-03f, -5.57679385e-02f, 1.00456089e-01f, -8.21952522e-02f, -8.80208611e-02f, -7.24505782e-02f, 3.13011440e-03f, -9.17870179e-03f, 5.54976314e-02f, -1.29339367e-01f,
  -5.51496111e-02f, -2.77205091e-02f, 4.68158908e-02f, -5.22134081e-02f, -2.79153325e-02f, -5.34051433e-02f, -2.39920840e-02f, -3.32632624e-02f, -6.39902055e-02f, -3.52632807e-04f,
  -1.03412662e-02f, -4.96849157e-02f, 5.83578125e-02f, -6.68581622e-03f, -2.51326361e-03f, 5.72099490e-03f, 2.71606799e-02f, -1.09620867e-02f, 8.49982798e-02f, 4.69024330e-02f,
  1.06261976e-01f, 5.81148900e-02f, -1.68565835e-03f, -9.35961455e-02f, 1.17382556e-02f, 7.72818774e-02f, -1.14518650e-01f, 4.77981605e-02f, 9.74167697e-03f, -5.01555726e-02f,
  -2.78566126e-02f, 3.48630920e-02f, -3.20442487e-05f, -2.06727609e-02f, -1.54554266e-02f, -5.59778214e-02f, -2.80317012e-02f, 9.09096282e-03f, -9.26591679e-02f, 1.36447074e-02f,
  5.48767950e-03f, -4.83794101e-02f, -1.01989448e-01f, -8.65769014e-02f, 4.23314273e-02f, 1.42841991e-02f, -3.61135826e-02f, -7.59678259e-02f, 9.33748949e-03f, -3.26863006e-02f,
  -2.78573155e-01f, -2.08494693e-01f, 8.40134453e-03f, 4.57638269e-03f, -6.06040023e-02f, -5.85271530e-02f, 7.39068538e-02f, -2.65114065e-02f, -7.58504821e-03f, -4.81433235e-02f,
  -1.28635973e-01f, 6.06091842e-02f, -6.74307421e-02f, -9.68742184e-03f, -3.48375663e-02f, -2.38871593e-02f, -6.34755716e-02f, 1.00962911e-02f, 2.40697712e-02f, -7.50553459e-02f,
  -5.08410158e-03f, -6.45024553e-02f, -5.67190442e-03f, -6.56462982e-02f, -1.07930273e-01f, 2.96399798e-02f, 2.71714162e-02f, 4.29540537e-02f, -7.24894414e-03f, -4.51245941e-02f,
  3.71402875e-02f, -1.79351106e-01f, -3.55878919e-01f, -1.83406740e-01f, -8.71245936e-02f, -2.53155082e-01f, -2.71438450e-01f, -8.08523968e-02f, 6.69051856e-02f, 1.17233537e-01f,
  -1.03257589e-01f, 1.18502937e-01f, 1.61978677e-01f, -1.91254824e-01f, 3.93089987e-02f, 2.50065565e-01f, -2.18668655e-01f, -1.09580256e-01f, 1.29996672e-01f, -1.08986787e-01f,
  -8.27142149e-02f, -1.64662506e-02f, -8.55568945e-02f, 1.05762444e-01f, -2.66679406e-01f, -1.08947761e-01f, 2.14027688e-02f, -4.40290682e-02f, -1.99691400e-01f, -1.25359073e-01f,
  -5.39903529e-02f, 1.25661820e-01f, -9.01657064e-03f, -4.00319099e-02f, -1.27698258e-01f, -9.83736143e-02f, -5.84833324e-02f, 7.02353120e-02f, 9.26519372e-03f, 7.50871524e-02f,
  -2.11105309e-02f, 8.99643973e-02f, -3.11201136e-03f, 1.57324061e-01f, -2.90595274e-02f, 3.53085585e-02f, -7.33626401e-03f, -1.69813797e-01f, 4.67126397e-03f, -2.28492580e-02f,
  -6.41386285e-02f, -8.06111619e-02f, -1.36091441e-01f, 6.09034635e-02f, 5.08237071e-02f, -5.80557659e-02f, 1.42042916e-02f, 6.49323389e-02f, 2.23666392e-02f, 1.71861462e-02f,
  1.47877019e-02f, 1.95224793e-03f, 1.29891410e-01f, -5.00012189e-02f, 6.12262264e-03f, -9.72107649e-02f, 1.02710702e-01f, 6.57180920e-02f, -9.74362940e-02f, 5.87639324e-02f,
  -8.53301026e-04f, -5.86661883e-02f, 4.27237079e-02f, -4.15817872e-02f, -3.74634787e-02f, 4.85330485e-02f, 6.90499227e-03f, -1.40588311e-02f, -1.21596500e-01f, -7.66671672e-02f,
  1.15401804e-01f, -2.17129197e-02f, -8.08880180e-02f, -1.32561460e-01f, -6.25052303e-02f, 7.43624792e-02f, -2.26956289e-02f, 5.70436306e-02f, 8.56319536e-03f, -5.19367345e-02f,
  -4.08592895e-02f, -6.55841902e-02f, 7.04331324e-02f, -1.48434995e-03f, 8.63316935e-03f, -3.89211103e-02f, 1.09351594e-02f, 5.16502149e-02f, -4.06333059e-02f, 2.02267691e-02f,
  -1.21181071e-01f, -6.50536418e-02f, -8.26668963e-02f, -1.37296198e-02f, -2.19896082e-02f, -1.22407712e-01f, -3.78908403e-02f, 2.74172053e-02f, -1.42320856e-01f, -6.31372025e-03f,
  -1.32807598e-01f, 5.18979467e-02f, 2.17427984e-02f, 9.71959382e-02f, 5.13113802e-03f, 1.07666077e-02f, -7.42188618e-02f, 3.23315919e-03f, -1.35152806e-02f, -4.47532907e-02f,
  -4.17076796e-01f, 8.41599479e-02f, -1.88398026e-02f, -1.74430057e-01f, -9.48672369e-02f, -8.43054354e-02f, 6.62638759e-03f, 2.00840846e-01f, 4.44837548e-02f, 1.93300694e-01f,
  2.49745220e-01f, -1.14483804e-01f, 2.01717526e-01f, 5.55067584e-02f, -1.06226146e-01f, 7.50098899e-02f, -1.68817416e-02f, -7.85516649e-02f, -9.77127627e-02f, -2.04902589e-01f,
  -2.27940723e-01f, -5.82843553e-03f, -3.85140255e-02f, 7.94586912e-02f, -1.04276910e-01f, 3.22406963e-02f, -9.37004909e-02f, 6.94004670e-02f, 1.53202442e-02f, 7.24179745e-02f,
  9.09877792e-02f, 1.66007206e-01f, 2.55426466e-02f, 3.12226322e-02f, -4.00487222e-02f, -1.96165945e-02f, -4.90789078e-02f, 1.71132218e-02f, -4.79231365e-02f, 2.23902240e-02f,
  -9.45061371e-02f, 1.03437386e-01f, 3.35193835e-02f, 3.90579514e-02f, -9.82289016e-02f, 5.43005355e-02f, 2.96385866e-02f, -5.93599640e-02f, 4.38189171e-02f, 1.62766024e-01f,
  4.39395243e-03f, -3.46085280e-02f, -1.55287281e-01f, -1.10448562e-01f, -7.69779161e-02f, 1.00239433e-01f, 1.55248102e-02f, 4.89900541e-03f, -1.20515451e-01f, -5.18067069e-02f,
  -1.04362980e-01f, 4.43764366e-02f, 3.59243155e-02f, 1.25190228e-01f, -8.85851011e-02f, 1.10943109e-01f, 4.46357429e-02f, -7.25438520e-02f, -1.69721812e-01f, 3.33918346e-04f,
  -1.92903113e-02f, -5.72538599e-02f, 8.67901891e-02f, 5.22496877e-03f, -1.50180802e-01f, 3.38096754e-03f, 5.36159016e-02f, 9.81549248e-02f, 2.17544418e-02f, 2.57667378e-02f,
  3.70987467e-02f, 1.42039247e-02f, 3.91746638e-04f, -4.87084799e-02f, 2.66621616e-02f, -6.99573159e-02f, -1.06209636e-01f, 2.21612342e-02f, 1.87589213e-01f, -2.48082052e-03f,
  -1.10652298e-02f, -1.19098559e-01f, 5.51812090e-02f, 4.78616171e-02f, 2.12019570e-02f, -8.39475915e-02f, -2.26413645e-02f, -1.06596723e-01f, -1.37790412e-01f, -1.59976594e-02f,
  -5.76001517e-02f, -4.79417257e-02f, -7.47153983e-02f, 6.66710585e-02f, -1.43489212e-01f, 5.26902899e-02f, 4.04488333e-02f, -3.05170175e-02f, 2.23674104e-02f, 6.57998174e-02f,
  2.35164398e-03f, -6.43850192e-02f, 1.01491973e-01f, -1.26723155e-01f, -1.33179706e-02f, 5.33979759e-02f, -8.25029165e-02f, -5.95398284e-02f, -1.60133809e-01f, -8.13305825e-02f,
  -1.60420999e-01f, -2.69938111e-01f, 7.65235126e-02f, -3.29550654e-02f, 1.74140669e-02f, -9.22840014e-02f, -1.66473836e-01f, 8.14938247e-02f, -1.59598231e-01f, -2.49525085e-01f,
  -4.77006733e-02f, -1.32613689e-01f, -1.16766304e-01f, -2.61953343e-02f, 2.62031823e-01f, -4.01680022e-02f, 1.75066404e-02f, 3.04072164e-02f, -4.22824211e-02f, 1.04916980e-02f,
  1.61016077e-01f, 7.75110051e-02f, 3.85253102e-01f, 3.00387263e-01f, 5.42832687e-02f, 2.67410338e-01f, 1.72636971e-01f, 1.81179717e-01f, 2.63369143e-01f, 2.50014305e-01f,
  -9.09002032e-03f, -1.09264292e-01f, 1.04181416e-01f, 8.75489488e-02f, 6.88571930e-02f, 8.07397347e-03f, 1.13777496e-01f, 8.85431319e-02f, -2.14729924e-02f, -4.59392965e-02f,
  2.50232103e-03f, 1.21382557e-01f, -3.30543853e-02f, 5.53130209e-02f, 8.96541700e-02f, 3.70625183e-02f, 8.10857341e-02f, 4.29003052e-02f, 7.83131551e-03f, -4.54648733e-02f,
  -8.49071797e-03f, 1.63847748e-02f, -9.85850990e-02f, 1.14059359e-01f, -1.69431195e-02f, -1.48711905e-01f, -1.09951861e-01f, -3.36231962e-02f, -2.51089036e-02f, 7.07263127e-03f,
  1.07596740e-01f, 3.74594666e-02f, -1.44630015e-01f, 1.94492582e-02f, 1.36862062e-02f, -1.06819294e-01f, 5.72215915e-02f, -3.36650312e-02f, -6.70236116e-03f, -7.03157037e-02f,
  -4.41089198e-02f, -9.08158794e-02f, -3.86563167e-02f, -6.57080635e-02f, 1.10249855e-02f, -1.02669217e-01f, 9.34461057e-02f, -1.54876895e-02f, -4.32800017e-02f, 1.90108325e-02f,
  -9.35021266e-02f, 9.50256363e-02f, -2.35714763e-02f, 6.87389225e-02f, -9.03015286e-02f, -2.32626554e-02f, -1.54060554e-02f, -3.67917269e-02f, 3.82544361e-02f, 1.00657888e-01f,
  -1.13017894e-02f, -2.78189685e-02f, -9.78082325e-03f, -2.75414735e-02f, 8.08224082e-03f, -2.73231342e-02f, 1.46247465e-02f, 5.56031354e-02f, 3.71173024e-02f, -3.28186788e-02f,
  9.21240300e-02f, 5.95699064e-02f, -2.34349724e-02f, 3.99199277e-02f, 1.77707985e-01f, -5.07990271e-02f, -6.59623221e-02f, 1.69531594e-03f, -9.99167934e-02f, 3.42322774e-02f,
  2.28207428e-02f, -1.70925558e-02f, 4.70914729e-02f, 8.19615871e-02f, -7.46510476e-02f, -6.87870830e-02f, 1.05371978e-02f, -4.77406196e-02f, -8.30962975e-03f, 2.97457296e-02f,
  -5.80202937e-01f, 1.50312871e-01f, 1.47849768e-01f, -1.77761003e-01f, -1.01018570e-01f, 1.82171240e-01f, 2.04789221e-01f, -3.62477801e-03f, -1.98459953e-01f, 9.48345289e-02f,
  7.65094981e-02f, -1.03984162e-01f, 1.44137830e-01f, 1.08612932e-01f, 9.72430259e-02f, 1.49846077e-01f, -4.73996699e-02f, -5.69357052e-02f, 7.63266906e-02f, -2.52238121e-02f,
  -4.55261841e-02f, 1.87442601e-02f, 1.98772863e-01f, 6.25547916e-02f, -3.43648978e-02f, -1.53814539e-01f, 3.99855524e-02f, 1.27452523e-01f, 1.33589819e-01f, 5.10051474e-02f,
  -1.34465560e-01f, -2.31515422e-01f, -1.16979986e-01f, -8.70039612e-02f, 9.20151453e-03f, -5.43323234e-02f, -7.85087347e-02f, -7.33832195e-02f, -1.19349368e-01f, -2.93809306e-02f,
  -7.85864443e-02f, -1.21308388e-02f, -4.88384180e-02f, -2.11744197e-02f, -1.32559359e-01f, -7.34096020e-02f, 7.96968043e-02f, 4.97772694e-02f, 6.53345510e-02f, -4.33695205e-02f,
  2.06058696e-02f, -6.90754801e-02f, 3.76390778e-02f, 6.29041195e-02f, 1.37401477e-01f, -5.65601215e-02f, -2.42044982e-02f, -6.44755736e-02f, -4.50474850e-04f, -5.00899628e-02f,
  -2.25699749e-02f, 1.02865316e-01f, -6.87867180e-02f, -2.80351173e-02f, -5.69960028e-02f, 4.41857986e-02f, -9.82848462e-03f, -5.82863279e-02f, 3.23669873e-02f, 4.28717658e-02f,
  -3.60716172e-02f, -2.54565142e-02f, -5.21311944e-04f, -4.17407677e-02f, 8.39768723e-03f, -3.35899778e-02f, -2.99183857e-02f, 2.78001232e-03f, 5.62141612e-02f, 3.94174904e-02f,
  -3.25838476e-02f, -5.34963980e-02f, 4.11160998e-02f, -4.52696122e-02f, 1.26898307e-02f, 2.27063578e-02f, 5.11094220e-02f, 8.10801312e-02f, -2.58936975e-02f, -3.29126567e-02f,
  -2.21027434e-01f, -2.50769496e-01f, 6.80535333e-03f, -5.11263609e-02f, -5.08477204e-02f, -5.04341684e-02f, 2.30353512e-03f, -4.89178188e-02f, -8.11934248e-02f, -1.14937782e-01f,
  -7.18394890e-02f, -2.22779792e-02f, -2.25560218e-02f, -3.74678113e-02f, -4.27956395e-02f, -1.77964047e-02f, -5.45788966e-02f, -1.59382284e-01f, -2.38398020e-03f, -7.61567950e-02f,
  -1.04049392e-01f, -1.05658695e-01f, 1.95007429e-01f, 2.94485800e-02f, -6.60585426e-03f, 3.03179640e-02f, -1.63080931e-01f, -6.97067454e-02f, -3.86781916e-02f, 4.22187299e-02f,
  -2.53325194e-01f, 1.11029282e-01f, 1.34737615e-03f, 1.12510130e-01f, -3.37315239e-02f, 3.22686583e-01f, 3.07073236e-01f, -1.77153088e-02f, 2.13286623e-01f, 3.39137942e-01f,
  1.84633449e-01f, 3.55920196e-02f, 1.46816999e-01f, 2.26981878e-01f, 6.19095862e-02f, 1.33914977e-01f, 9.06625837e-02f, 1.67287678e-01f, -1.65635780e-01f, -3.84901278e-02f,
  -2.21658647e-02f, 1.33451879e-01f, 1.53699564e-02f, -1.68607622e-01f, -8.31350870e-03f, -1.50851741e-01f, 1.59729850e-02f, -1.08701997e-01f, 1.29896402e-01f, 4.39142361e-02f,
  -9.09613222e-02f, -7.52399191e-02f, -9.11922529e-02f, -7.64255151e-02f, -8.18857774e-02f, 1.49230743e-02f, -6.36224896e-02f, -5.50598279e-02f, -4.19651717e-02f, 1.49083091e-02f,
  1.63207725e-02f, -9.92661938e-02f, 5.57586141e-02f, 4.54907045e-02f, -5.25476830e-03f, 4.99885827e-02f, 1.06399516e-02f, 4.24546637e-02f, -3.62406559e-02f, -1.00521207e-01f,
  4.09995243e-02f, -7.68144131e-02f, 1.46409953e-02f, 5.73737845e-02f, -8.75237584e-02f, -1.58361520e-03f, 1.86305996e-02f, 5.07662073e-02f, -1.98930185e-02f, -2.36692075e-02f,
  -4.75046970e-02f, -1.49832383e-01f, 8.01626500e-03f, 1.53701631e-02f, -2.03845389e-02f, -1.13882348e-01f, 3.35714892e-02f, -1.69559438e-02f, 1.54844401e-02f, 5.65442145e-02f,
  3.14929970e-02f, 3.40181403e-02f, -8.96686390e-02f, -1.72429532e-02f, 6.10213354e-02f, 6.54073581e-02f, 2.66559608e-02f, -8.10720026e-02f, 1.18773110e-01f, 2.82709189e-02f,
  7.75750726e-02f, 6.56226799e-02f, 1.37042746e-01f, 6.27902001e-02f, 1.82791743e-02f, 5.32960184e-02f, 6.87636733e-02f, 2.06095763e-02f, 1.34227142e-01f, -3.83608229e-02f,
  1.45123526e-01f, -1.93698481e-02f, -5.11121564e-03f, -3.62364799e-02f, -1.00921437e-01f, 2.91381516e-02f, -6.82858974e-02f, -5.78448549e-02f, 5.13768233e-02f, -4.43854555e-03f,
  7.56251216e-02f, -3.82457464e-03f, -8.99643600e-02f, 3.71747129e-02f, 4.58923131e-02f, 1.62731633e-01f, 8.84486660e-02f, -1.09809153e-02f, 1.19769864e-01f, -8.61167014e-02f,
  -3.29198316e-02f, -4.63013202e-02f, -1.96354743e-02f, 5.21550141e-02f, 2.61733942e-02f, -2.74781417e-02f, -1.72461551e-02f, -6.35537654e-02f, -6.86630234e-02f, 8.49745609e-03f,
  -5.93335152e-01f, 1.95183933e-01f, 2.96070665e-01f, -2.93950081e-01f, 1.66326642e-01f, 1.88614532e-01f, -1.32812515e-01f, 1.34158626e-01f, -2.17702255e-01f, -1.02425948e-01f,
  -9.26403701e-02f, -7.31547400e-02f, 9.73649770e-02f, -6.94999993e-02f, 5.17119979e-03f, 1.29053012e-01f, -2.75168512e-02f, -1.24047339e-01f, 1.51950240e-01f, 3.37838344e-02f,
  -1.24367084e-02f, -3.56748141e-02f, 1.35789379e-01f, 1.03677213e-01f, -8.83627310e-02f, -1.21468596e-01f, -1.34800896e-01f, 1.51466325e-01f, -8.62996727e-02f, -3.43417227e-02f,
  2.99524982e-02f, -1.43044487e-01f, 1.28986314e-01f, 1.07928872e-01f, 4.96989228e-02f, -2.26587467e-02f, -3.42856757e-02f, -2.62532122e-02f, -7.22810999e-02f, 2.46187691e-02f,
  -4.48515639e-02f, 8.07494111e-03f, -6.11259714e-02f, 1.53132584e-02f, 7.58785307e-02f, 6.04978502e-02f, 1.80914387e-01f, 1.57199502e-01f, 6.93154484e-02f, 2.27442961e-02f,
  7.86601976e-02f, 1.29128188e-01f, 4.33157906e-02f, -5.05085327e-02f, 9.53909084e-02f, -6.43624365e-02f, 1.96992350e-03f, 4.97045405e-02f, 3.70674692e-02f, -8.04454982e-02f,
  -6.61597177e-02f, 3.54268514e-02f, 8.41540024e-02f, 2.34109703e-02f, 7.93325994e-03f, -1.06528871e-01f, -1.68825071e-02f, -2.17599515e-02f, -1.86620671e-02f, 2.98466086e-02f,
  -5.90954237e-02f, -1.21558877e-02f, 4.09804098e-02f, -1.14008952e-02f, 2.98543461e-02f, -1.20247044e-01f, -6.22547753e-02f, -8.04010853e-02f, 2.79741921e-02f, 1.86848256e-03f,
  -4.89410572e-02f, -1.17323205e-01f, -1.56665504e-01f, -9.85868089e-03f, 7.81946853e-02f, 5.43639846e-02f, 4.78347540e-02f, 3.19058895e-02f, -7.99348056e-02f, -1.35168647e-02f,
  -6.31908476e-02f, -1.98846802e-01f, -2.02997252e-02f, 3.76463076e-03f, -5.21681570e-02f, 6.31117746e-02f, 3.26710157e-02f, -1.32736638e-01f, -6.74944073e-02f, 3.02098342e-03f,
  -2.59467587e-02f, -1.11004017e-01f, -1.33720851e-02f, -4.20356058e-02f, -1.91936120e-02f, 5.48180155e-02f, -1.29542112e-01f, 3.88893336e-02f, 2.34169196e-02f, 2.29278654e-02f,
  1.73305757e-02f, -5.36944419e-02f, -8.07425305e-02f, -8.66111964e-02f, -3.36000435e-02f, -8.72315615e-02f, -1.21690281e-01f, -5.59845474e-03f, 4.17451635e-02f, -3.74349952e-02f,
  6.91767111e-02f, 3.35846275e-01f, -1.56745926e-01f, 1.21143967e-01f, 1.59339651e-01f, 2.88117409e-01f, 1.50862500e-01f, 5.37818000e-02f, 1.97358549e-01f, 1.82104945e-01f,
  -3.71058807e-02f, 2.30650783e-01f, -5.45630492e-02f, 2.96264172e-01f, 1.42569438e-01f, 3.40538807e-02f, 3.83498490e-01f, 1.56116337e-01f, -1.86849739e-02f, 1.81527734e-01f,
  -2.45483709e-03f, 1.42263353e-01f, -2.07993492e-01f, -3.11861746e-02f, -2.11722218e-02f, -1.69780433e-01f, -2.22296774e-01f, -1.61967263e-01f, -8.68583247e-02f, 5.49964607e-03f,
  3.14666395e-04f, 3.69293522e-03f, -6.17137663e-02f, -3.71938907e-02f, 1.58056931e-03f, -2.95121949e-02f, -3.99679579e-02f, -4.70761359e-02f, -2.11823490e-02f, 2.47312081e-03f,
  1.12882838e-01f, 2.21579261e-02f, 4.82785404e-02f, 8.34282022e-03f, 6.10743240e-02f, -3.10825650e-02f, -3.69616523e-02f, -7.72616565e-02f, 5.75263277e-02f, -2.87264623e-02f,
  6.56381771e-02f, 3.20309744e-04f, 5.56321852e-02f, 4.11738083e-02f, -2.16521844e-02f, 1.08698666e-01f, 5.99517673e-02f, -3.85047942e-02f, 2.88206376e-02f, 1.07216664e-01f,
  9.69315995e-04f, 3.64059918e-02f, -2.49452908e-02f, -1.19500779e-01f, 7.08018094e-02f, -8.98330808e-02f, 2.39084475e-02f, -1.36614060e-02f, -1.72446091e-02f, 8.03518444e-02f,
  -6.92318678e-02f, -7.72423744e-02f, 1.88247822e-02f, 1.31807923e-01f, 2.67693847e-02f, -4.85230163e-02f, -1.40713220e-02f, 2.34842417e-03f, 6.82262331e-02f, -7.95093775e-02f,
  -7.28779584e-02f, 6.33942261e-02f, -5.79636395e-02f, -1.21187784e-01f, 5.81308827e-02f, -3.94768007e-02f, -6.23654053e-02f, -1.27364174e-01f, -4.33513895e-02f, 3.69918570e-02f,
  6.28601015e-02f, 2.47083992e-01f, -3.13388109e-02f, 3.66057977e-02f, 9.30910334e-02f, 4.09151502e-02f, 1.05443522e-01f, 6.63410947e-02f, 3.19930986e-02f, 8.09449777e-02f,
  7.05838352e-02f, 5.32694422e-02f, 6.02376610e-02f, -1.31824985e-02f, 1.03901565e-01f, 3.37378010e-02f, 5.45916148e-02f, 2.48605032e-02f, 9.47700739e-02f, -2.35582348e-02f,
  1.95756722e-02f, 9.64682996e-02f, 1.62985608e-01f, 4.67725247e-02f, 1.44174889e-01f, -4.91571352e-02f, 1.61286697e-01f, -1.39205679e-02f, -6.23936467e-02f, 2.78075729e-02f,
  1.49751708e-01f, 1.68626502e-01f, -1.20821245e-01f, 2.36953363e-01f, -2.79217288e-02f, 3.55519265e-01f, 2.92553544e-01f, 1.13240652e-01f, 3.14487189e-01f, 2.15200737e-01f,
  5.81064820e-02f, 3.52997407e-02f, 1.35615980e-03f, 3.25062305e-01f, 2.23399494e-02f, 2.00186610e-01f, 2.14780718e-01f, 1.53696835e-01f, -1.79066211e-02f, 2.07106516e-01f,
  5.87964617e-02f, 2.09627852e-01f, -1.01810664e-01f, -6.61978498e-02f, 7.25592300e-03f, -1.25528708e-01f, -1.89610481e-01f, -1.82639241e-01f, -9.42363739e-02f, -9.11293253e-02f,
  -2.06211880e-02f, -5.33355493e-03f, -6.23783767e-02f, 1.77873746e-02f, -7.40463138e-02f, -9.24482122e-02f, -4.46068794e-02f, -8.80040005e-02f, -1.06390022e-01f, 5.26410639e-02f,
  1.37034738e-02f, 1.00504644e-01f, 7.96421915e-02f, 3.60857509e-02f, 2.57680733e-02f, -3.01759876e-02f, 2.33593974e-02f, -6.60622343e-02f, 1.45539269e-02f, -1.10306621e-01f,
  5.04965000e-02f, -5.50869443e-02f, 4.03151140e-02f, -4.49568927e-02f, -1.28458679e-01f, 5.58785461e-02f, -3.05125513e-03f, -6.39332533e-02f, -5.82866278e-03f, 9.38947499e-02f,
  -6.71275854e-02f, -1.83425490e-02f, 2.53852177e-02f, -1.78180691e-02f, 7.02546015e-02f, -7.61253759e-02f, -2.29781382e-02f, -2.24987790e-02f, -7.46487230e-02f, -1.17076822e-02f,
  -7.70272762e-02f, -1.53063107e-02f, 2.29992326e-02f, 2.74726897e-02f, 1.47434101e-02f, 1.14176488e-02f, -3.25244591e-02f, 5.83094396e-02f, 6.56580254e-02f, 6.07377887e-02f,
  -1.14411619e-02f, 1.99464355e-02f, -8.94679502e-02f, -5.78580201e-02f, -7.30948746e-02f, -1.43452007e-02f, -3.46446149e-02f, 9.89723951e-03f, -8.20001066e-02f, -2.79326290e-02f,
  1.20230906e-01f, 1.55974463e-01f, 6.29086718e-02f, -4.19189408e-02f, -1.41006475e-02f, 7.71597633e-03f, 1.95965497e-03f, 7.52414539e-02f, 1.15140975e-02f, 5.47052734e-02f,
  -1.90162007e-02f, 1.32863224e-02f, -2.99657844e-02f, -2.32068868e-03f, 5.06219678e-02f, 4.73748241e-03f, 6.39353842e-02f, 3.89773846e-02f, -2.02421527e-02f, -3.03194858e-02f,
  -3.63035724e-02f, 8.05067420e-02f, -5.37850820e-02f, 7.14848340e-02f, 2.15520747e-02f, -5.12369536e-02f, 1.23950362e-01f, -5.07502705e-02f, -5.54230325e-02f, 1.37201203e-02f,
  8.31489265e-02f, -8.16074759e-02f, 1.65014490e-01f, -1.66289076e-01f, 1.28788901e-02f, 2.95084268e-01f, 3.30014050e-01f, -1.32798031e-01f, -2.97774732e-01f, -1.27747461e-01f,
  -1.55957304e-02f, 6.95346519e-02f, 2.64074266e-01f, -4.50120196e-02f, 2.58899599e-01f, 1.81217194e-01f, 1.40784746e-02f, 6.79202229e-02f, -7.94902295e-02f, 4.81389649e-02f,
  1.46300392e-02f, 6.69583008e-02f, 3.77657637e-02f, -1.21264234e-01f, 8.95548984e-02f, -1.55372158e-01f, -3.62984873e-02f, 3.17500345e-02f, -3.12252752e-02f, 8.04032460e-02f,
  1.30238593e-01f, 5.76335145e-03f, -4.10227329e-02f, 3.97405364e-02f, 8.52205977e-02f, 8.28234181e-02f, 2.95436922e-02f, 1.36935592e-01f, -1.98967271e-02f, 5.34027591e-02f,
  8.95645395e-02f, -6.17900379e-02f, -5.31373471e-02f, -4.72577326e-02f, -8.68789107e-02f, -1.10951960e-01f, -1.87019072e-02f, -2.20815688e-02f, 1.21387211e-03f, 2.35133283e-02f,
  4.19567898e-02f, 1.70010957e-03f, -7.51233399e-02f, -7.35465586e-02f, -5.55541180e-03f, -6.03534803e-02f, -1.30351689e-02f, 4.65580858e-02f, -8.50113947e-03f, 5.26597574e-02f,
  -1.33699505e-02f, 1.19754814e-01f, 1.15427136e-01f, 6.63860440e-02f, 4.01517116e-02f, -5.43235242e-02f, 3.39599587e-02f, 7.41950236e-03f, -9.12945867e-02f, -6.72324002e-02f,
  -2.11085547e-02f, -4.31408063e-02f, -2.51405928e-02f, 9.12243966e-03f, 6.67195991e-02f, 4.55796756e-02f, 9.09017473e-02f, -4.27030437e-02f, -1.11548662e-01f, -7.16780573e-02f,
  1.32691506e-02f, 4.04428430e-02f, 4.85301092e-02f, -1.06790558e-01f, 1.00577250e-01f, 4.52460870e-02f, 1.78741422e-02f, -8.29977170e-02f, -3.25173475e-02f, 1.00346565e-01f,
  2.69709043e-02f, 2.73970198e-02f, -9.96866636e-03f, 4.89991195e-02f, -2.30536815e-02f, 9.33898240e-02f, 1.68877039e-02f, -3.34989019e-02f, 1.05012190e-02f, 1.29405605e-02f,
  -1.24538634e-02f, -6.56817900e-03f, -5.54650612e-02f, -7.22284243e-02f, -2.15081358e-03f, -6.05656952e-02f, 7.52074420e-02f, -1.02902120e-02f, -6.63181953e-03f, -6.08718693e-02f,
  5.54269995e-04f, 7.06600770e-02f, -5.42183779e-02f, -3.26179178e-03f, -3.08558997e-02f, -3.05928173e-03f, 3.96900885e-02f, -4.74135727e-02f, 5.57394512e-02f, 5.34964446e-03f,
  -5.67395806e-01f, 3.56903732e-01f, 5.55098839e-02f, 1.25409827e-01f, -1.39251679e-01f, 1.16367685e-02f, 4.88214567e-02f, 8.70113727e-03f, -7.01505691e-02f, 1.54427081e-01f,
  3.79416198e-02f, -1.54460058e-01f, 6.18690029e-02f, 2.08223209e-01f, -1.40592888e-01f, 1.73540920e-01f, 1.40695989e-01f, 5.30330800e-02f, 6.01826273e-02f, 6.92457706e-02f,
  1.44604007e-02f, 1.68493167e-01f, 1.56356171e-01f, 7.33051673e-02f, -3.99112981e-03f, 4.88204509e-02f, 2.81421058e-02f, 3.71462107e-02f, 9.79318395e-02f, -3.79150850e-03f,
  -1.53396219e-01f, -1.68756414e-02f, -7.46643245e-02f, -8.65718573e-02f, -4.48248945e-02f, -1.14015773e-01f, -5.11700250e-02f, -5.02026491e-02f, -7.41195679e-03f, -1.44859252e-03f,
  -9.48661491e-02f, -6.01355396e-02f, -1.75132193e-02f, 2.73621045e-02f, -1.11711517e-01f, 3.54342014e-02f, -6.05735928e-03f, 2.61502992e-02f, 1.76645573e-02f, -4.13147435e-02f,
  3.17303576e-02f, 4.46579158e-02f, 6.88559487e-02f, 1.94388293e-02f, -7.82570988e-03f, 2.83319727e-02f, 3.73478718e-02f, 4.46775518e-02f, -9.63537954e-03f, 3.18317972e-02f,
  -1.49604172e-01f, 1.15884289e-01f, -3.59244943e-02f, 3.91425714e-02f, 5.95577694e-02f, 2.39545554e-02f, 1.72986779e-02f, -7.73190707e-02f, -8.90783314e-03f, -4.62894067e-02f,
  -1.08541518e-01f, 2.69255415e-02f, 2.84083150e-02f, -3.89328636e-02f, -8.78440514e-02f, -2.64862017e-03f, -2.43055448e-03f, -3.39992456e-02f, 6.95697889e-02f, -2.08128877e-02f,
  -6.95092455e-02f, 2.56517455e-02f, 4.29950431e-02f, -1.89639330e-02f, 1.34702131e-01f, 3.97929922e-02f, 8.70791003e-02f, 3.77428792e-02f, 7.61097670e-02f, 7.23770773e-03f,
  6.39264053e-03f, 1.54259764e-02f, -2.38181241e-02f, -1.37862056e-01f, -8.41274485e-02f, -1.01031475e-02f, -3.74232754e-02f, 3.12129352e-02f, -3.61205824e-02f, -3.32752727e-02f,
  8.22608732e-03f, -3.49483304e-02f, 2.53213202e-05f, -2.29540002e-02f, -4.56094742e-02f, 1.07755885e-01f, -3.27926055e-02f, -6.34641424e-02f, 8.11971202e-02f, -3.20559926e-02f,
  -9.98358354e-02f, -2.16231309e-02f, 8.79638419e-02f, -2.23873146e-02f, -4.06923927e-02f, -1.40061323e-02f, -3.22432034e-02f, -1.15243241e-01f, -1.45437708e-02f, -2.77952775e-02f,
  2.42066249e-01f, 2.47713715e-01f, 3.38474780e-01f, 2.65647441e-01f, -1.80540398e-01f, -3.20457935e-01f, -1.92863137e-01f, 3.59352343e-02f, 4.81618987e-03f, 7.14790598e-02f,
  -1.45812869e-01f, 3.45966339e-01f, -1.46028101e-01f, 6.55345470e-02f, -1.23142265e-01f, -2.61395425e-01f, 1.14251621e-01f, 4.11222279e-02f, -7.51543045e-02f, 8.43379796e-02f,
  -4.91245240e-02f, -2.24875182e-01f, 7.36547858e-02f, -2.54458655e-02f, 1.19511582e-01f, 2.36075193e-01f, 1.00121591e-02f, -1.25753447e-01f, 2.10286260e-01f, -3.75870615e-02f,
  -4.37962003e-02f, -3.80128797e-04f, 1.47771358e-01f, 5.33702075e-02f, 9.74310488e-02f, -2.33989898e-02f, 7.32111633e-02f, -6.21038079e-02f, 5.39501645e-02f, 7.63219520e-02f,
  3.35042342e-03f, -4.99616470e-03f, 1.95842218e-02f, 6.71728253e-02f, -2.93437298e-02f, 7.31312111e-02f, -9.57517512e-03f, 8.58576074e-02f, 7.19404072e-02f, 8.24089497e-02f,
  6.85411543e-02f, 7.86358044e-02f, 6.99936599e-02f, 1.60245020e-02f, 7.56977424e-02f, -2.13843472e-02f, -2.07813568e-02f, -1.83652509e-02f, -2.14256980e-02f, 8.22706074e-02f,
  2.53225919e-02f, -7.12058991e-02f, -6.07103445e-02f, -4.70049977e-02f, -5.12627559e-03f, -3.13838087e-02f, -5.03031649e-02f, 3.86205800e-02f, 1.16599454e-02f, -8.14620927e-02f,
  -6.56901114e-03f, 1.17601000e-01f, -1.41900927e-01f, -3.43694165e-02f, -4.53080684e-02f, -2.26108022e-02f, -2.23560613e-02f, 2.56253891e-02f, -2.56719682e-02f, 8.14272091e-02f,
  -5.04931659e-02f, -6.44496903e-02f, 8.24625045e-02f, -1.41744362e-02f, -7.14398921e-02f, 4.17063339e-03f, 5.13754673e-02f, 8.51353034e-02f, -3.67719084e-02f, -5.67671061e-02f,
  3.68320197e-02f, 9.99750569e-02f, -3.27415168e-02f, 8.33974481e-02f, -7.50780404e-02f, 2.15799082e-02f, 3.01273279e-02f, 5.16787320e-02f, 3.70523483e-02f, -3.66423614e-02f,
  1.22468527e-02f, 2.27847677e-02f, -1.73607878e-02f, -1.43424245e-02f, -3.39661092e-02f, 3.80678996e-02f, -2.63421182e-02f, -5.90928234e-02f, 5.29170260e-02f, 6.86170235e-02f,
  5.39691374e-02f, -8.95150527e-02f, -2.40215082e-02f, -3.35197523e-02f, 7.20549449e-02f, 2.77286451e-02f, -3.46047059e-02f, 8.34631324e-02f, 2.65370775e-02f, -4.47966829e-02f,
  2.21212864e-01f, -6.27542362e-02f, 8.31763372e-02f, 2.72017181e-01f, 3.42938788e-02f, -2.90560693e-01f, -7.13076368e-02f, 6.88460916e-02f, 1.73724681e-01f, -9.53051820e-02f,
  -9.65196863e-02f, 4.87240478e-02f, -2.35457376e-01f, -7.22714001e-03f, 1.88322842e-01f, -2.35455826e-01f, 1.27075002e-01f, -1.42931879e-01f, 8.06884654e-03f, 6.60649464e-02f,
  1.48706198e-01f, 1.78605244e-02f, 1.47160023e-01f, 1.51193947e-01f, -1.27648870e-02f, 2.04909638e-01f, 2.41298258e-01f, -3.06875855e-02f, 1.68410227e-01f, -6.09705970e-02f,
  -4.90535125e-02f, -3.74727882e-02f, 1.92605762e-03f, -5.97829856e-02f, 9.56247654e-03f, -1.90941654e-02f, -7.18672723e-02f, -4.39672023e-02f, 1.36821538e-01f, 3.70103084e-02f,
  -6.84420839e-02f, 6.43970072e-02f, -4.15720751e-06f, -1.94150873e-03f, 3.33012789e-02f, 1.64447397e-01f, 2.50906702e-02f, -1.02493707e-02f, -4.57806103e-02f, -6.92966953e-02f,
  5.03565669e-02f, -6.48028329e-02f, 1.10008515e-01f, 3.70159093e-03f, 4.37389240e-02f, 6.86110631e-02f, 2.53982749e-02f, -5.35594241e-04f, 6.72046021e-02f, 1.58526227e-01f,
  -1.12665810e-01f, -1.48597676e-02f, 6.93397224e-02f, 1.84774473e-01f, 3.56499329e-02f, -5.49205467e-02f, -2.47416385e-02f, 4.83566672e-02f, 2.18535680e-02f, -1.31322350e-02f,
  6.56138211e-02f, -1.49872003e-03f, -9.13361609e-02f, -3.98716070e-02f, -6.64998740e-02f, 1.60010420e-02f, 1.09037928e-01f, -2.77407970e-02f, -1.40411658e-02f, 6.86866120e-02f,
  -5.09777032e-02f, 1.06936228e-02f, -1.81234181e-02f, 2.81045586e-02f, 5.62257618e-02f, -2.05307808e-02f, 2.35732319e-03f, -8.75436664e-02f, 5.24546206e-02f, -1.23470172e-01f,
  -5.96480928e-02f, 3.57423909e-02f, -1.47231556e-02f, -6.87928796e-02f, -3.19409296e-02f, 7.31807277e-02f, 7.90788010e-02f, 1.35959340e-02f, 2.39883382e-02f, -5.55118080e-03f,
  -9.08141062e-02f, 1.63847998e-01f, -6.47193044e-02f, 3.11124995e-02f, -6.68545514e-02f, 4.60918061e-02f, -4.84226318e-03f, 8.19801353e-03f, 5.33284657e-02f, -7.97877684e-02f,
  -8.62666126e-03f, -1.22479990e-01f, 1.42254636e-01f, 4.46965843e-02f, -1.77520607e-02f, -5.30657843e-02f, 3.43407169e-02f, -1.02785267e-02f, -3.07091046e-03f, 5.88567629e-02f,
  3.25507253e-01f, 2.10552782e-01f, 2.73912787e-01f, 3.26646864e-01f, 9.08035692e-03f, -2.04664618e-01f, -8.31895918e-02f, 5.69179244e-02f, 1.84912667e-01f, 1.57342535e-02f,
  -8.38271454e-02f, 3.02245855e-01f, -2.56492555e-01f, 1.95406824e-01f, -2.77816981e-01f, -1.43399999e-01f, 7.19545484e-02f, 1.11835346e-01f, -3.29415351e-02f, 1.36304677e-01f,
  7.25742653e-02f, -1.87788978e-01f, 7.81989843e-02f, -7.69056454e-02f, 2.75886893e-01f, 2.11819902e-01f, -5.29741608e-02f, -1.18579879e-01f, 1.07409015e-01f, -1.88805982e-01f,
  -3.31384167e-02f, -8.48105177e-03f, 1.17426276e-01f, -9.50147435e-02f, 5.61201759e-02f, 6.30750954e-02f, 6.93747541e-03f, -4.55703847e-02f, -5.35543971e-02f, 3.65386792e-02f,
  6.77716509e-02f, -8.27029794e-02f, 2.88486965e-02f, 1.19171172e-01f, 2.54059192e-02f, 3.59052643e-02f, 6.49581775e-02f, 8.97351578e-02f, 4.17979993e-02f, 8.85391310e-02f,
  1.17104314e-01f, 7.52364844e-02f, 4.43663150e-02f, -6.75672144e-02f, -6.93222582e-02f, 2.70544514e-02f, -4.08289507e-02f, 6.32636249e-02f, 1.97965708e-02f, -4.41412395e-03f,
  3.90270352e-02f, -3.86511795e-02f, 3.55796777e-02f, 2.35287175e-02f, -1.30188726e-02f, 6.51001036e-02f, -1.86850987e-02f, -5.87222874e-02f, -2.55327374e-02f, 8.90731439e-03f,
  2.07486879e-02f, 6.11787960e-02f, -6.79081958e-03f, 8.92362669e-02f, 5.89000732e-02f, 8.11851323e-02f, 5.06887300e-05f, 3.22455801e-02f, 3.18194404e-02f, 1.60913393e-02f,
  -1.96043905e-02f, 2.63387896e-03f, 5.68445399e-02f, 3.94531675e-02f, 8.63693375e-03f, 1.07724220e-02f, 9.68874171e-02f, 5.27861863e-02f, 7.43011609e-02f, 2.35067997e-02f,
  -4.23309058e-02f, 2.92639527e-03f, -5.12907915e-02f, -2.83837225e-02f, -3.92356850e-02f, 1.25213284e-02f, -3.35486210e-03f, 8.13455284e-02f, -1.24694109e-01f, -1.13899214e-02f,
  3.44836190e-02f, 4.39783297e-02f, -1.63980573e-02f, 5.22828335e-03f, -6.01121150e-02f, -2.59996224e-02f, 1.01372838e-01f, 1.34697007e-02f, -7.65317678e-02f, 4.26834859e-02f,
  1.37137219e-01f, -2.04162765e-02f, 4.32749316e-02f, -4.33660895e-02f, 3.80815566e-02f, -5.82591072e-02f, 6.27640113e-02f, 3.13154981e-02f, 3.52769494e-02f, -1.51359349e-01f,
  1.21338345e-01f, 3.92977774e-01f, 3.31007808e-01f, 2.50080168e-01f, -3.48056257e-02f, -3.21557254e-01f, -1.24375865e-01f, 5.81392087e-03f, 1.28871322e-01f, -2.41943151e-02f,
  -1.37901008e-01f, 3.59169215e-01f, -1.95162907e-01f, 1.08783446e-01f, -5.34365736e-02f, -1.84611574e-01f, 1.24168642e-01f, 2.51973458e-02f, 9.25465822e-02f, 1.49552571e-02f,
  1.73341006e-01f, -7.15847835e-02f, 5.84612451e-02f, -5.72230592e-02f, 9.96255651e-02f, 1.38943911e-01f, 4.28008363e-02f, -7.30227903e-02f, 1.38168201e-01f, 2.41482705e-02f,
  -9.65004042e-02f, 1.57115445e-01f, 6.65795580e-02f, 3.78955975e-02f, -4.91699651e-02f, -9.53247696e-02f, 1.07173873e-02f, -1.95217610e-03f, -5.19665591e-02f, 3.63218337e-02f,
  -5.34682488e-03f, 4.42388058e-02f, 1.66325811e-02f, 1.84896030e-02f, -4.57834307e-04f, 7.97540545e-02f, -6.15284964e-02f, 1.06437176e-01f, 1.07924148e-01f, 5.37589714e-02f,
  1.60977215e-01f, 7.02454671e-02f, 4.84036021e-02f, -2.26006303e-02f, 1.89808860e-01f, 3.24728340e-02f, -4.26961146e-02f, -1.39176259e-02f, 3.77199762e-02f, 6.96140006e-02f,
  1.73071578e-01f, -1.12340167e-01f, -1.54347688e-01f, -1.11586310e-01f, 4.48905602e-02f, 5.00601903e-02f, 5.68900779e-02f, -6.64016977e-02f, -1.21462541e-02f, -7.29063898e-02f,
  -1.65421933e-01f, 9.63372216e-02f, -8.13156366e-02f, -8.06338936e-02f, -2.54089828e-03f, -9.49970353e-03f, -7.86031634e-02f, -7.38718137e-02f, 7.79004619e-02f, -7.92678967e-02f,
  5.24994880e-02f, -6.16098531e-02f, 3.10484786e-02f, -8.45837519e-02f, -6.12395070e-02f, -2.90982779e-02f, -3.55070755e-02f, 8.92341062e-02f, -6.09406866e-02f, -2.83155218e-02f,
  3.24603207e-02f, 2.21875936e-01f, -4.49495949e-03f, -1.31851463e-02f, 6.77069789e-03f, -8.29269290e-02f, 6.04822785e-02f, 5.12560308e-02f, 1.40753716e-01f, -1.10027410e-01f,
  6.95106536e-02f, -3.65320854e-02f, -9.78190824e-02f, -1.16599590e-01f, -1.90422358e-03f, 1.94489975e-02f, -1.20608462e-03f, 6.37527257e-02f, 7.05138072e-02f, -6.96537420e-02f,
  6.42577559e-02f, -6.97497874e-02f, -3.95339029e-03f, 5.87863140e-02f, -1.54586239e-02f, 1.12235332e-02f, 7.70177180e-03f, 3.72860469e-02f, -3.32802907e-02f, -2.93689594e-02f,
  3.46755296e-01f, -1.26284704e-01f, 3.34517993e-02f, 2.40517735e-01f, 2.20224727e-02f, -1.16948336e-01f, -3.55917662e-02f, 2.08570689e-01f, 1.99142084e-01f, -1.02285603e-02f,
  2.70020729e-03f, -1.51740387e-01f, -5.61683923e-02f, 1.53953999e-01f, 1.47986621e-01f, -1.31034255e-01f, 8.58819708e-02f, -1.09312348e-01f, 7.69914165e-02f, 1.07967980e-01f,
  2.48424515e-01f, 1.49280444e-01f, 5.70204668e-02f, 2.15670373e-02f, 1.47157460e-01f, 1.96838498e-01f, 5.76829724e-02f, -1.12384021e-01f, 1.46960691e-01f, -5.08841425e-02f,
  -2.05946881e-02f, 8.52269381e-02f, 2.98335459e-02f, -4.09550034e-02f, 3.16330865e-02f, 2.61393376e-03f, -8.29341188e-02f, 1.43270241e-02f, -9.21352804e-02f, 5.93983382e-03f,
  -7.63593167e-02f, 5.63053526e-02f, 2.96532065e-02f, -2.69555580e-02f, 6.75530210e-02f, 2.68512536e-02f, 7.10797533e-02f, -1.15339644e-02f, -6.33456111e-02f, 5.03321923e-02f,
  -3.78771462e-02f, 3.03350408e-02f, -1.96699332e-02f, -1.45082071e-01f, -2.80060433e-02f, 8.41966942e-02f, -9.63049680e-02f, -1.09363094e-01f, -1.44629121e-01f, -9.21061821e-03f,
  8.83824378e-02f, 6.09798124e-03f, 4.45703696e-03f, -4.41414975e-02f, -2.86613442e-02f, 5.00047989e-02f, 4.12398158e-03f, -1.20808937e-01f, -1.23466268e-01f, -5.43322451e-02f,
  5.15950136e-02f, 1.90187067e-01f, 6.55643176e-03f, 4.70350236e-02f, 7.29820356e-02f, -3.93942930e-02f, 6.15561157e-02f, -3.07004247e-02f, 1.74900088e-02f, -1.05815325e-02f,
  -7.32545704e-02f, 2.00177040e-02f, -3.92229073e-02f, 5.33766709e-02f, -9.51248854e-02f, 2.62593012e-02f, 6.83974549e-02f, 6.86753914e-02f, -5.46323955e-02f, -4.87267552e-03f,
  -3.36571038e-02f, 1.00090699e-02f, -5.36290593e-02f, -2.73910444e-02f, -1.68196604e-01f, -1.08556449e-01f, -1.45173863e-01f, 6.23679422e-02f, 8.83843843e-03f, 1.04942247e-01f,
  -1.43773407e-02f, 6.23887368e-02f, -1.06561827e-02f, -8.05463195e-02f, -6.22507744e-02f, 4.68216799e-02f, 9.45115462e-03f, 1.85225531e-02f, -5.09823486e-02f, 1.44218817e-01f,
  -5.41561954e-02f, 3.79696190e-02f, -9.73260477e-02f, -1.00746617e-01f, -1.90918110e-02f, -4.47413139e-03f, -8.78953487e-02f, 2.73278467e-02f, 4.82650095e-04f, -3.40153798e-02f,
  -2.49498203e-01f, 2.56402045e-02f, -3.61182719e-01f, -1.61522493e-01f, -1.46235898e-01f, -3.29182833e-01f, -2.94421673e-01f, 2.37717219e-02f, 7.99489468e-02f, 1.41162902e-01f,
  -7.82845020e-02f, 6.90543130e-02f, 1.41045332e-01f, -1.55679379e-02f, -1.24236383e-01f, 2.74999797e-01f, -1.69733062e-01f, 9.94265452e-03f, 2.57401373e-02f, -4.60095033e-02f,
  -1.02418125e-01f, 7.84212351e-02f, -8.34451169e-02f, 1.56501561e-01f, -3.26496005e-01f, -1.40500292e-01f, -2.52972916e-02f, -1.39909700e-01f, -1.59363374e-01f, -1.93349823e-01f,
  -3.23150694e-01f, -2.29054824e-01f, -1.40587941e-01f, -4.10964340e-02f, -1.76572904e-01f, -8.62589702e-02f, -1.11726560e-01f, -4.59975526e-02f, -2.78796889e-02f, -1.12107582e-03f,
  2.68553142e-02f, 1.27461791e-01f, 1.10786162e-01f, 1.33378645e-02f, -3.70451398e-02f, -8.63305330e-02f, -2.91139726e-02f, -6.41211346e-02f, -5.11811227e-02f, -1.65570695e-02f,
  4.48475331e-02f, -1.41797602e-01f, -1.09964922e-01f, 1.55747216e-02f, -8.76461118e-02f, -1.92115650e-01f, -2.23304350e-02f, -4.26819921e-03f, -1.40648097e-01f, -3.09896152e-02f,
  9.44243092e-03f, -3.72625627e-02f, -3.17418054e-02f, -1.62241012e-02f, 5.52682485e-03f, 9.86962765e-02f, 4.47685272e-02f, 5.68262152e-02f, 6.74148127e-02f, 6.14276098e-04f,
  3.79614756e-02f, -2.13893317e-02f, -7.58138224e-02f, -7.76991472e-02f, 3.01324744e-02f, -7.65496790e-02f, -6.37509748e-02f, -4.34482247e-02f, 5.90987988e-02f, -3.90908401e-03f,
  1.42830834e-01f, -4.89626005e-02f, 9.62981507e-02f, 6.29990026e-02f, -3.97377834e-02f, -1.64214432e-01f, 2.30810605e-02f, 2.69857105e-02f, -3.20768617e-02f, -2.93160528e-02f,
  -3.65831882e-01f, -2.63021022e-01f, -5.11148572e-02f, -4.25519198e-02f, 6.05354160e-02f, -1.20585345e-01f, -2.57062279e-02f, 1.43503714e-02f, -1.40172318e-01f, 6.33877218e-02f,
  -3.38933691e-02f, 3.38918269e-02f, -6.38330206e-02f, 1.79753359e-02f, 1.09532334e-01f, -9.31824222e-02f, -2.38028616e-02f, -4.03961204e-02f, -9.61794332e-02f, -3.90877314e-02f,
  -1.52861066e-02f, 7.65322819e-02f, 3.24249035e-04f, 9.47764963e-02f, 2.37762798e-02f, -1.61796901e-02f, -4.92080972e-02f, -3.81793492e-02f, -1.24835245e-01f, 1.75525919e-02f,
  -4.02213037e-01f, -3.12451809e-03f, -9.14536119e-02f, -2.77509123e-01f, 1.64601862e-01f, -1.57554686e-01f, -5.99512905e-02f, 5.38484380e-02f, -6.56894222e-02f, 2.52223283e-01f,
  7.34007210e-02f, -2.09189087e-01f, 1.47521332e-01f, -3.05493414e-01f, -4.89434808e-01f, -2.95480043e-01f, -2.04789102e-01f, -8.36666450e-02f, -8.07438716e-02f, 6.82454407e-02f,
  -9.87017304e-02f, -1.34820072e-02f, -1.82740077e-01f, 2.28075907e-01f, 5.63058294e-02f, 6.43116683e-02f, 2.54244924e-01f, 2.82544583e-01f, -2.54472941e-02f, -1.63900834e-02f,
  -1.14866979e-01f, 5.94879687e-02f, -5.87546453e-02f, -1.05209380e-01f, -1.42394099e-02f, 9.86012071e-02f, 3.22677828e-02f, -2.12620478e-02f, -4.45327023e-03f, -9.95371118e-02f,
  -3.68227623e-02f, -2.83530150e-02f, 2.94357841e-03f, -8.36112071e-03f, 5.16346619e-02f, -7.60689676e-02f, -6.21895269e-02f, -4.15772460e-02f, -4.06714454e-02f, -1.14929907e-01f,
  -7.75379166e-02f, -1.19312987e-01f, -1.32819954e-02f, -7.24785179e-02f, -1.45871146e-02f, -1.32754317e-03f, -1.34283146e-02f, -2.70976257e-02f, -9.85863134e-02f, 4.55174595e-02f,
  2.15993188e-02f, 2.31065154e-02f, -2.98373308e-02f, -8.62939358e-02f, -7.49045536e-02f, -2.46902574e-02f, -1.11130066e-02f, -6.32043229e-03f, 5.05584665e-02f, 3.61465923e-02f,
  -5.34814186e-02f, -7.68931136e-02f, 3.02493712e-03f, 4.27671894e-02f, 2.88286656e-02f, -5.93534373e-02f, 3.87499593e-02f, 3.99253517e-02f, -3.71496305e-02f, -1.60924140e-02f,
  2.82162596e-02f, 9.35135130e-03f, -1.88725647e-02f, 7.11283460e-02f, -9.01688784e-02f, 1.87512189e-02f, 2.68610520e-03f, -6.19440200e-03f, -4.59380262e-02f, 5.30627929e-02f,
  7.90346041e-02f, 2.13249624e-01f, -4.60210890e-02f, -4.64397706e-02f, 2.07835133e-03f, -1.21889235e-02f, -7.16759786e-02f, -3.96557003e-02f, -1.12135606e-02f, 7.21930712e-02f,
  5.96356764e-02f, 3.33347023e-02f, 2.55261939e-02f, -5.16058020e-02f, 2.08269921e-03f, -5.13896346e-02f, 1.40204310e-01f, 3.53549235e-02f, 2.68104039e-02f, -1.21727800e-02f,
  4.50388081e-02f, 7.87214283e-03f, 2.15441431e-03f, 2.34700348e-02f, 6.56756805e-03f, 2.54279766e-02f, 7.03195035e-02f, 5.79800010e-02f, 4.27151360e-02f, 4.42490466e-02f,
  -2.26058394e-01f, 5.35782129e-02f, 1.28293470e-01f, -2.84967087e-02f, 3.03612854e-02f, -1.98162898e-01f, -5.63143976e-02f, 4.62681651e-02f, 3.52460742e-02f, 2.24667504e-01f,
  8.65567029e-02f, 1.34230442e-02f, 8.02906230e-02f, -8.87603536e-02f, -3.91854703e-01f, -2.51236022e-01f, -2.46486031e-02f, 7.08278567e-02f, -5.14301546e-02f, 4.32661176e-02f,
  -2.14055568e-01f, -1.20833136e-01f, -1.48454234e-01f, 8.49599019e-02f, 6.38389587e-02f, 1.36548162e-01f, 5.54253496e-02f, 8.79362449e-02f, 7.20320344e-02f, -4.10348065e-02f,
  1.94388237e-02f, 2.06877649e-01f, -2.03595255e-02f, 4.49266145e-03f, 6.45240173e-02f, 4.42640930e-02f, 6.22420013e-02f, -2.71667633e-02f, 7.67328218e-02f, -6.88635707e-02f,
  -2.16930965e-03f, -4.84173670e-02f, -2.59365197e-02f, 5.56457741e-03f, 3.93862724e-02f, 1.08453386e-01f, -6.89433068e-02f, -7.37384707e-02f, 6.36071861e-02f, -2.79516112e-02f,
  -3.33336964e-02f, 3.15450169e-02f, -2.46248748e-02f, 5.19842878e-02f, -5.73385805e-02f, -2.22373940e-03f, 3.15556638e-02f, 1.19719270e-03f, -3.51653881e-02f, 1.56530999e-02f,
  -8.01904276e-02f, 2.22192425e-02f, -7.85364807e-02f, 8.12767670e-02f, -5.72742224e-02f, 3.72822247e-02f, 8.55224207e-03f, 6.56791702e-02f, 2.08904725e-02f, -9.14527010e-03f,
  9.35267471e-03f, -1.11731157e-01f, 2.26531383e-02f, 3.83398719e-02f, -8.59934315e-02f, 2.86447983e-02f, -1.10191889e-01f, 1.38193756e-01f, -1.17321983e-01f, 3.11306096e-03f,
  -1.65355415e-03f, 2.27487162e-02f, 7.60297328e-02f, 1.72887761e-02f, -4.87542972e-02f, -4.66674902e-02f, -6.37306497e-02f, -2.17320919e-02f, 3.38934548e-02f, 3.42951491e-02f,
  -2.08332241e-02f, 7.52747059e-02f, 5.81956059e-02f, 5.25512770e-02f, -4.45466780e-04f, -6.08239695e-02f, -6.36363104e-02f, -5.00070788e-02f, 3.88867781e-02f, -7.54943863e-02f,
  3.31255533e-02f, -3.13230082e-02f, -4.86000367e-02f, -9.35772210e-02f, 1.12147713e-02f, 1.07789552e-02f, 2.54696216e-02f, 5.55898957e-02f, -1.96268279e-02f, -8.32525827e-03f,
  2.96795275e-02f, -9.37950052e-03f, 9.64029226e-03f, -2.33299341e-02f, 1.12059398e-03f, 6.09009806e-03f, 2.84655392e-02f, 2.31587775e-02f, 6.24777675e-02f, 3.11444513e-02f,
  -4.57204543e-02f, 7.67794624e-02f, 2.06343401e-02f, -3.42331885e-04f, 1.41090035e-01f, -2.10667565e-01f, -2.89462004e-02f, 1.14292309e-01f, 2.49824435e-01f, -1.38901477e-03f,
  -5.61220432e-03f, -5.77775165e-02f, -6.13024570e-02f, -1.48834527e-01f, -2.30378047e-01f, -1.30672634e-01f, -2.01214030e-01f, -1.71250805e-01f, 1.00636305e-02f, -1.41875297e-01f,
  -7.50499070e-02f, -4.00822572e-02f, -7.27216601e-02f, 4.31516878e-02f, 5.34262918e-02f, 5.73283881e-02f, -2.24414289e-01f, 2.04321817e-02f, -1.66908398e-01f, -4.43372950e-02f,
  5.28962016e-02f, 1.26532003e-01f, 5.57210632e-02f, -7.43159503e-02f, -2.56736185e-02f, 9.26339766e-04f, -6.36831969e-02f, 7.16696260e-03f, 4.31730524e-02f, -3.06061134e-02f,
  1.30620133e-02f, -4.80124056e-02f, -3.86393555e-02f, -6.80446252e-02f, 1.03034601e-01f, 7.09812492e-02f, 6.30401894e-02f, 1.05337575e-01f, 4.27205488e-02f, -2.39434205e-02f,
  1.25752598e-01f, -1.79457460e-02f, -1.71171967e-03f, -7.56080672e-02f, -1.44451410e-02f, 9.79663953e-02f, -1.34579301e-01f, -1.20935552e-01f, 3.78318829e-03f, -2.58957706e-02f,
  -4.20241430e-02f, -2.41155997e-02f, -3.70219536e-02f, 1.97607428e-02f, 7.08431304e-02f, 1.14557252e-03f, -7.07235858e-02f, -1.78571958e-02f, 1.33843683e-02f, 6.30447790e-02f,
  -9.20672715e-02f, 7.74549395e-02f, -2.28664782e-02f, -3.98686272e-04f, -1.82851050e-02f, 1.23464111e-02f, -7.13906735e-02f, -9.32490826e-02f, 6.85146227e-02f, -6.54715225e-02f,
  -2.18875352e-02f, 2.06448752e-02f, 5.58351427e-02f, 1.27036800e-03f, 4.29467112e-02f, -6.09851070e-02f, -1.30858142e-02f, -7.45229572e-02f, 5.84514327e-02f, 5.70919411e-03f,
  1.29950289e-02f, -9.44596156e-02f, 3.59723121e-02f, -5.82203851e-04f, -6.83856852e-05f, -4.16144393e-02f, -1.21032089e-01f, -1.06859626e-02f, -3.84711772e-02f, -1.75234489e-02f,
  4.19489183e-02f, 7.77261332e-02f, -6.68070242e-02f, -5.81885651e-02f, 1.04783989e-01f, -6.77135810e-02f, -2.09701546e-02f, 1.74947917e-01f, 2.74184421e-02f, -4.32679504e-02f,
  7.74659589e-02f, -1.85213946e-02f, 7.91138634e-02f, 6.14163466e-02f, -5.76584674e-02f, -3.88605669e-02f, -1.43203028e-02f, 2.32396400e-04f, -3.04098316e-02f, -1.26231119e-01f,
  -1.93893343e-01f, 1.80844188e-01f, 7.21509755e-02f, -1.94037467e-01f, 2.34613791e-02f, -9.29656997e-03f, -1.29680913e-02f, 1.87178239e-01f, 6.50528148e-02f, 1.52532101e-01f,
  -1.07671162e-02f, -5.15332818e-02f, -7.07875937e-02f, -1.72896892e-01f, -2.69449711e-01f, -2.74912804e-01f, -1.68699041e-01f, -6.78455010e-02f, -1.24883637e-01f, -8.81767571e-02f,
  -2.48015821e-02f, -2.01369360e-01f, -1.10833831e-01f, 7.96715692e-02f, 2.28361338e-02f, 1.10799775e-01f, 6.39264425e-03f, 1.64013624e-01f, 1.62611287e-02f, 1.43438414e-01f,
  5.64269200e-02f, 1.02086678e-01f, 9.35499370e-02f, 9.52436998e-02f, -1.80482790e-02f, 2.91559175e-02f, -1.39596052e-02f, -3.66609320e-02f, 9.17500444e-03f, -4.73855585e-02f,
  3.31723057e-02f, 8.36521108e-03f, -9.72844660e-02f, 9.61538590e-03f, 1.50690302e-01f, 3.77598144e-02f, 5.57600195e-03f, -1.21936686e-02f, 8.24753940e-02f, 1.60115901e-02f,
  -5.22166602e-02f, 2.29589036e-03f, 2.25369213e-03f, -2.41510496e-02f, -1.43178087e-03f, 9.87446234e-02f, 2.54085544e-03f, 1.33886682e-02f, -5.65795973e-02f, -5.96455783e-02f,
  1.08070523e-02f, -9.51403007e-02f, -1.48151827e-04f, -2.21106373e-02f, 6.34182096e-02f, 7.70670846e-02f, 4.64365631e-02f, -2.62499598e-05f, 2.75567081e-02f, 7.63229653e-02f,
  -5.21884635e-02f, -2.43450385e-02f, -1.11550689e-02f, -1.00069260e-02f, -1.92652531e-02f, 2.95829363e-02f, -5.31150512e-02f, -8.01896900e-02f, -4.61697653e-02f, 3.59292850e-02f,
  -6.44972622e-02f, 2.14991532e-02f, 3.28728519e-02f, -7.62032494e-02f, 1.06818631e-01f, 3.57197709e-02f, 2.40606046e-03f, 1.20252110e-01f, -3.55080590e-02f, -7.19363689e-02f,
  -5.36295846e-02f, -5.02970628e-02f, -6.30927384e-02f, 2.04367135e-02f, 5.04240617e-02f, -1.95598938e-02f, -9.49417949e-02f, 3.10613066e-02f, -2.41208766e-02f, 5.70561476e-02f,
  9.43872482e-02f, 4.28795889e-02f, -7.49701113e-02f, -1.88665744e-02f, 4.30246145e-02f, 2.88365446e-02f, -5.18791713e-02f, 5.82122989e-02f, -5.55800647e-02f, 4.55258451e-02f,
  -5.73922880e-03f, 4.56894329e-03f, 4.28236686e-02f, 9.48653650e-03f, 3.37633584e-03f, 5.59334364e-03f, -4.09769965e-03f, 3.01370230e-02f, -9.51623172e-02f, 4.86545675e-02f,
  -1.71898350e-01f, -4.48381342e-02f, 1.36294076e-02f, -6.68415576e-02f, -1.58944264e-01f, -1.11094974e-01f, 4.15354259e-02f, -2.71783650e-01f, -2.51345426e-01f, -4.42335978e-02f,
  4.02981713e-02f, -4.58048331e-03f, 2.22680792e-01f, -4.30055633e-02f, 5.18808700e-02f, 1.14461832e-01f, -5.66918626e-02f, 8.16320553e-02f, -5.51374331e-02f, -1.90902367e-01f,
  -2.56575178e-03f, -1.25440404e-01f, 1.58500910e-01f, -2.59805709e-01f, -1.37991980e-01f, -1.11101300e-01f, -1.83604062e-02f, 6.06014691e-02f, -3.41470316e-02f, -1.85038093e-02f,
  -9.32308212e-02f, -1.93853244e-01f, 8.62393714e-03f, -2.88824402e-02f, -2.16593184e-02f, 1.54917575e-02f, 1.71163566e-02f, 9.66093317e-02f, -4.53655608e-02f, -7.44296834e-02f,
  6.99958056e-02f, -4.40277308e-02f, -1.35099933e-01f, 9.67348833e-03f, 6.67089522e-02f, -2.65352186e-02f, -5.90039156e-02f, 5.73342592e-02f, 2.20493209e-02f, 9.28391516e-02f,
  -5.64136356e-02f, 2.32042987e-02f, -4.39150408e-02f, -4.09317426e-02f, -1.17703434e-02f, -5.98063245e-02f, 7.57049248e-02f, 7.25893080e-02f, -1.44402713e-01f, -1.82543397e-01f,
  -1.22603811e-01f, 2.23812200e-02f, -2.62228679e-02f, 6.73898831e-02f, -8.18103030e-02f, -3.01803723e-02f, -4.78179306e-02f, 5.64658977e-02f, 7.69395977e-02f, 2.17130035e-02f,
  1.01612303e-02f, -3.51237506e-02f, -6.52635694e-02f, 1.58340670e-03f, 9.61422641e-03f, -4.82694097e-02f, 1.19881451e-01f, -3.44226211e-02f, 1.88836921e-02f, -2.67169010e-02f,
  6.50436850e-03f, -1.16194941e-01f, 1.12898718e-03f, 1.02002062e-01f, -1.00004807e-01f, 4.88356985e-02f, -4.81720641e-02f, 1.17330849e-02f, 2.39765383e-02f, -2.97441650e-02f,
  -2.32591689e-01f, -2.77799249e-01f, -5.08335456e-02f, -6.75409362e-02f, -4.52805236e-02f, 2.40333453e-02f, 6.43555373e-02f, -1.52605306e-02f, -8.81147236e-02f, -8.70811269e-02f,
  -3.89037915e-02f, -6.83691166e-03f, -3.34691703e-02f, -3.65580022e-02f, 4.28631008e-02f, -3.59409824e-02f, 1.34554794e-02f, 1.05374148e-02f, 1.15152560e-02f, -6.45873770e-02f,
  -3.06867007e-02f, -8.14152285e-02f, 4.19671759e-02f, -6.81352690e-02f, -1.66023392e-02f, 2.58878041e-02f, -1.48333702e-03f, -5.26761115e-02f, -3.83303836e-02f, -4.20806035e-02f,
  4.04184125e-02f, 2.47910023e-01f, 1.38207674e-01f, -6.95100129e-02f, 2.22800206e-02f, -1.18106142e-01f, -1.54413819e-01f, -8.71989504e-02f, -5.89373969e-02f, -9.54759791e-02f,
  -1.31341740e-01f, 3.37848455e-01f, -6.24086298e-02f, 2.34185103e-02f, -1.37603715e-01f, -1.09202571e-01f, -1.48847044e-01f, -3.07886731e-02f, 9.11815315e-02f, -5.42662218e-02f,
  -4.07741778e-02f, -2.14936703e-01f, -2.25083344e-02f, 1.71375256e-02f, 2.60976013e-02f, 4.86827604e-02f, -2.15307593e-01f, 3.21563110e-02f, 4.12985273e-02f, -1.66509021e-02f,
  -4.88582775e-02f, -8.73979181e-02f, 2.07409076e-02f, 3.96623500e-02f, -9.34583768e-02f, -2.11491361e-02f, 4.83147204e-02f, 9.43455249e-02f, -1.54333547e-01f, 2.61403043e-02f,
  6.09427802e-02f, 8.82715136e-02f, -5.13866544e-02f, -1.66389793e-02f, -6.95728958e-02f, 9.54459980e-02f, -3.65719050e-02f, -2.20673550e-02f, 5.74416928e-02f, 1.13786701e-02f,
  1.43735901e-01f, -4.98259440e-02f, -2.65998673e-03f, -6.26149178e-02f, 5.29681779e-02f, -8.57022554e-02f, -7.58136585e-02f, 3.66278477e-02f, 7.92606473e-02f, -5.54289110e-02f,
  -6.63545281e-02f, -7.11559430e-02f, -1.69584975e-02f, 4.86139655e-02f, 9.61266086e-02f, -5.11937961e-03f, -8.86147376e-03f, 2.29058042e-02f, -2.26733331e-02f, -9.57379118e-02f,
  1.07960757e-02f, 7.03293979e-02f, 2.08568368e-02f, -5.46417274e-02f, -2.54642894e-03f, 4.57829519e-05f, 2.29849834e-02f, 6.15967102e-02f, 1.03924600e-02f, -2.00585704e-02f,
  3.21622305e-02f, -3.07983290e-02f, 1.11213982e-01f, 1.50633911e-02f, 2.60561761e-02f, 1.24656511e-02f, 7.28277713e-02f, 5.89026399e-02f, -3.56076248e-02f, -4.14666124e-02f,
  -3.19398046e-01f, -1.78434446e-01f, -9.02869925e-02f, 1.86776649e-02f, -1.65455304e-02f, 3.82602476e-02f, 2.56203525e-02f, 2.73690466e-02f, -1.12717107e-01f, 1.94007549e-02f,
  -4.29202728e-02f, -4.90073413e-02f, -5.72626702e-02f, 1.70088056e-02f, 5.61730638e-02f, -8.20088759e-02f, -1.14841953e-01f, -7.36503750e-02f, -3.65999080e-02f, -3.63890901e-02f,
  2.11811736e-02f, -4.22300473e-02f, -3.73338498e-02f, 4.62365523e-02f, -7.73516856e-03f, -3.26993540e-02f, 4.53077927e-02f, 8.40510428e-02f, -5.69002964e-02f, -6.40812740e-02f,
  2.40767151e-01f, -3.67832720e-01f, 1.83699671e-02f, 2.30766967e-01f, 3.56304139e-01f, 2.17841733e-02f, 1.77672550e-01f, 3.01654730e-03f, 1.08610965e-01f, -2.94527084e-01f,
  2.31666714e-02f, 8.53842066e-04f, -1.89572141e-01f, 7.90895298e-02f, 3.46386313e-01f, -1.36453927e-01f, 1.37057140e-01f, 2.00145668e-03f, -4.08462211e-02f, -5.65842278e-02f,
  1.55302152e-01f, 1.57966435e-01f, 8.82133245e-02f, -6.15050346e-02f, 5.43057658e-02f, -1.23748630e-01f, -6.79525658e-02f, -6.97841495e-02f, 2.23055296e-03f, 8.75997543e-02f,
  7.68200755e-02f, 4.23875004e-02f, 8.27080458e-02f, -7.37434551e-02f, -5.60689569e-02f, -3.19749862e-02f, 4.15353030e-02f, 4.00189385e-02f, 1.38700932e-01f, -1.38502922e-02f,
  -2.42694374e-02f, 8.34850669e-02f, 2.80876714e-03f, -3.08502046e-03f, -1.99505892e-02f, 8.37646499e-02f, 8.88865218e-02f, 8.87418762e-02f, 1.24819828e-02f, -5.79395443e-02f,
  3.33488435e-02f, 1.44966729e-02f, -4.23421860e-02f, 2.10454259e-02f, 3.86975519e-03f, 4.88455445e-02f, -4.61538211e-02f, -5.70179671e-02f, -8.34362675e-03f, 2.14664489e-02f,
  -1.78062141e-01f, -4.56996588e-03f, -6.61861300e-02f, 8.65905825e-03f, -7.50664016e-03f, 1.04299165e-01f, -2.06372999e-02f, 2.43100356e-02f, -4.20103520e-02f, -1.71281677e-02f,
  6.78578392e-02f, -3.53773758e-02f, -5.49314450e-03f, 9.23898220e-02f, -5.82782505e-03f, 7.14777643e-03f, 1.52458204e-02f, 4.48060930e-02f, 1.91274341e-02f, 3.21677811e-02f,
  2.65883040e-02f, 1.62606556e-02f, -2.28825510e-02f, -6.44297972e-02f, 6.65736292e-03f, -2.32307836e-02f, 2.35620164e-03f, -5.03802150e-02f, -3.41658369e-02f, -6.54249731e-03f,
  -2.10834175e-01f, -3.85823280e-01f, -5.01281321e-02f, 3.00717819e-03f, -3.78551446e-02f, -1.22992158e-01f, 3.68764251e-02f, 4.59359027e-02f, -8.43322724e-02f, 1.99973900e-02f,
  3.09703555e-02f, 1.96036380e-02f, -5.35505451e-02f, 8.07164062e-04f, -3.16420011e-02f, -7.11102411e-02f, -3.20351310e-02f, -3.69354859e-02f, 3.08766160e-02f, -3.06932759e-02f,
  -2.56325025e-02f, -6.23245314e-02f, 3.84216122e-02f, 1.55481538e-02f, 2.37773694e-02f, -1.70892738e-02f, -5.68502583e-02f, -1.35610113e-02f, -8.80379304e-02f, 6.20705895e-02f,
  -2.73206711e-01f, 3.13881159e-01f, 9.29557160e-02f, 3.52664053e-01f, -1.24324962e-01f, -1.80346817e-02f, 4.03716415e-02f, 1.28511205e-01f, 1.34150907e-01f, 1.05770662e-01f,
  1.64708540e-01f, 2.14380156e-02f, 1.28767043e-01f, 2.29865000e-01f, 1.50080984e-02f, 2.44601145e-01f, 1.86027735e-01f, 7.95651227e-02f, 1.07094094e-01f, 1.26518652e-01f,
  6.82583600e-02f, 1.99311033e-01f, 1.03089325e-01f, 8.73766318e-02f, 6.26154914e-02f, 3.17440629e-02f, 1.59488559e-01f, 9.10812914e-02f, 6.15718439e-02f, -4.00391519e-02f,
  8.12651310e-03f, 9.84009728e-02f, -6.27655610e-02f, 1.02187954e-02f, 3.61826606e-02f, -3.15600857e-02f, -3.73935103e-02f, 4.79952171e-02f, -3.16692814e-02f, 9.82360989e-02f,
  -5.32941706e-02f, 4.18352075e-02f, -2.50913501e-02f, 6.14795983e-02f, -8.53410885e-02f, -9.91869643e-02f, -5.94996214e-02f, -9.27903876e-02f, -1.85509529e-02f, -8.39957669e-02f,
  -9.35083032e-02f, 9.66133922e-03f, -3.33229452e-02f, 1.35562852e-01f, -1.87806766e-02f, 4.27578762e-02f, 5.25395721e-02f, 3.73999290e-02f, 5.79497330e-02f, 1.22490607e-01f,
  -4.34131548e-02f, 1.91528294e-02f, 9.90861878e-02f, 9.73896682e-02f, 4.51584235e-02f, 6.54847398e-02f, -1.14916518e-01f, -6.28166273e-02f, 1.57260783e-02f, 4.03395630e-02f,
  2.25321278e-02f, -3.51403095e-02f, -4.02480038e-03f, 4.58191335e-02f, 1.23440558e-02f, 2.84385607e-02f, -5.21832630e-02f, -2.90676001e-02f, -8.64212513e-02f, -6.98697194e-02f,
  7.55367130e-02f, -6.14471510e-02f, 5.69930859e-02f, -1.37580354e-02f, -2.56229993e-02f, 4.71201688e-02f, 9.29003488e-03f, -3.91260348e-02f, 8.70830286e-03f, -3.18456925e-02f,
  1.31636366e-01f, 3.20726961e-01f, 2.17928030e-02f, 2.52215192e-02f, -1.66040771e-02f, -3.51587147e-03f, 3.71703990e-02f, 6.80401102e-02f, 1.65880591e-01f, 5.63095883e-02f,
  -8.20058584e-02f, 2.33608559e-02f, -1.58608556e-02f, -3.17307524e-02f, -4.17477265e-03f, 1.79368537e-02f, 1.11370437e-01f, 5.40533178e-02f, 8.74518976e-02f, -5.93927968e-03f,
  -5.51587567e-02f, 2.46804836e-03f, -1.04361484e-02f, 9.52315331e-03f, -6.65713400e-02f, -7.85643756e-02f, -2.42041890e-02f, 6.37247832e-03f, 3.86966276e-03f, 1.05423927e-01f,
  2.73864210e-01f, -2.81718429e-02f, -2.11358145e-01f, -5.44907898e-02f, -3.28038633e-02f, -3.85129631e-01f, -3.34386259e-01f, -1.20711818e-01f, 1.70932431e-02f, 4.37496416e-02f,
  -8.75256062e-02f, 7.53021389e-02f, 6.89070597e-02f, -2.91271687e-01f, -2.17301667e-01f, -5.03617004e-02f, -1.69642970e-01f, 2.83506755e-02f, 6.05045706e-02f, -1.08849414e-01f,
  -1.92336924e-02f, -1.51832134e-01f, -1.78193718e-01f, -1.48285246e-02f, -1.37744978e-01f, 8.83833021e-02f, 1.58630125e-02f, 4.34366660e-03f, -5.62331229e-02f, -1.16441481e-01f,
  -1.15348421e-01f, 1.34385405e-02f, -1.57761537e-02f, -1.84591003e-02f, -1.13960234e-02f, -4.97358181e-02f, -6.32197829e-03f, -5.09969369e-02f, 1.83932316e-02f, 8.27057436e-02f,
  -4.53708880e-02f, 4.62747104e-02f, -5.43276872e-03f, 3.96720786e-03f, -3.22545617e-04f, 5.14930002e-02f, 9.22682136e-03f, 3.86592075e-02f, 2.43157372e-02f, 7.11788386e-02f,
  1.46595603e-02f, -1.13502340e-02f, -3.07641793e-02f, 7.00204596e-02f, -2.10266337e-02f, -6.23073727e-02f, -4.01443243e-02f, 5.39456941e-02f, 9.68954191e-02f, 1.57834664e-01f,
  -2.98286118e-02f, 2.94946842e-02f, -5.24120359e-03f, -9.83027928e-03f, 3.33299711e-02f, 4.91820425e-02f, -1.78959947e-02f, 2.93774419e-02f, -4.18237820e-02f, 1.10385418e-02f,
  -3.16208899e-02f, -2.06859410e-02f, -4.45374474e-02f, 3.76077220e-02f, -2.39773300e-02f, 3.86619754e-02f, -2.69532693e-03f, 1.43186122e-01f, -6.58279704e-03f, -2.94244681e-02f,
  7.07471967e-02f, -7.91721418e-02f, -6.47560693e-03f, 1.33704124e-02f, -6.19369512e-03f, -9.42701846e-03f, -3.60257365e-03f, -7.11729601e-02f, -1.00555569e-02f, -6.37273863e-02f,
  -1.55867711e-01f, -1.57437965e-01f, -2.62609478e-02f, 1.66476145e-02f, -2.80932225e-02f, -3.52940895e-02f, -6.19299076e-02f, 2.38409848e-03f, 3.17904651e-02f, -4.04445380e-02f,
  3.38148959e-02f, 2.68068444e-02f, -4.76770923e-02f, -1.45208417e-02f, 7.02120215e-02f, -8.33733231e-02f, 4.84819748e-02f, 9.08290446e-02f, -6.83862939e-02f, 8.00157860e-02f,
  -5.91467740e-03f, 8.50895345e-02f, -5.59788048e-02f, 6.79787025e-02f, 4.32765968e-02f, 3.34895328e-02f, 1.19166430e-02f, 3.51485470e-03f, 1.07310243e-01f, -2.11729202e-02f,
  5.59299774e-02f, -3.20056826e-01f, -1.07980575e-02f, -5.13893738e-02f, -4.26379219e-02f, -1.31930441e-01f, -7.54344277e-04f, -2.78538764e-01f, -1.77615538e-01f, -3.04032981e-01f,
  -6.64469376e-02f, 1.81716800e-01f, 2.50827610e-01f, -3.41889769e-01f, 3.99780601e-01f, 1.67767465e-01f, -2.14580953e-01f, -2.46998407e-02f, 8.48919600e-02f, -1.89916238e-01f,
  -4.47102328e-04f, -1.98193997e-01f, 7.48172998e-02f, -2.42031828e-01f, -2.30282366e-01f, -1.28394037e-01f, 6.16704337e-02f, 9.11197886e-02f, -2.61086047e-01f, 9.73840505e-02f,
  -1.40129896e-02f, -5.13973571e-02f, -5.30887097e-02f, 3.99259990e-03f, -1.93687268e-02f, 7.93975964e-02f, 9.78589803e-02f, 1.88263804e-01f, 4.04328555e-02f, -2.96626277e-02f,
  1.12080783e-01f, -1.51512977e-02f, -8.77725035e-02f, 1.05768770e-01f, 3.28530557e-02f, -8.72508660e-02f, -1.70786623e-02f, 5.34260506e-03f, -2.42897570e-02f, 2.43136398e-02f,
  2.31861677e-02f, -4.09708433e-02f, -4.33550999e-02f, -5.48953600e-02f, 1.82645917e-02f, -4.68555838e-02f, -1.20485295e-02f, 1.72959223e-01f, -5.74837290e-02f, -2.88790558e-02f,
  -5.21353669e-02f, 1.73483193e-01f, -1.74605697e-02f, -6.27570506e-03f, 3.84620595e-04f, -1.49158880e-01f, 4.43092827e-03f, 1.74340531e-02f, 4.63897508e-04f, -7.60444859e-03f,
  -7.95915630e-03f, -6.75343350e-02f, -1.95993539e-02f, -1.99472462e-03f, 7.47094974e-02f, 1.39190843e-02f, 4.93430905e-03f, -2.21080929e-02f, -5.36625311e-02f, -9.00142454e-03f,
  9.53004695e-03f, -1.59030985e-02f, -7.35985190e-02f, -6.08183667e-02f, 1.39658200e-03f, 1.47573248e-01f, 2.68858857e-02f, -8.49587172e-02f, 9.83848050e-03f, 1.00928403e-01f,
  2.21798606e-02f, -1.52708083e-01f, -3.87615338e-02f, -5.03920838e-02f, 1.45601025e-02f, 1.20229833e-02f, 5.61280213e-02f, -1.59669712e-01f, -1.50250914e-02f, -8.81045237e-02f,
  1.47720380e-02f, 8.37046653e-04f, -7.27691427e-02f, 1.44317765e-02f, -7.62895076e-03f, -9.52159315e-02f, -2.20691413e-02f, 6.92631677e-02f, 6.05200119e-02f, -9.83427465e-03f,
  -9.00432840e-03f, -2.00092383e-02f, 1.51343020e-02f, 3.91859449e-02f, -6.09894469e-02f, 4.76231724e-02f, -1.89397857e-02f, 2.57868189e-02f, 2.21906509e-02f, -1.85532775e-02f,
  3.19496840e-02f, -1.96805969e-02f, -1.68210953e-01f, -8.02597851e-02f, -1.76894814e-01f, 7.74783362e-03f, 4.83336933e-02f, -1.21508032e-01f, 1.67581514e-01f, 1.07717574e-01f,
  -5.34123406e-02f, 1.06226400e-01f, 6.65653422e-02f, -1.53405964e-01f, 9.16040093e-02f, 2.54287362e-01f, -2.39708298e-03f, -2.57159248e-02f, 9.03312862e-02f, -3.73776816e-02f,
  -7.84377102e-03f, -2.46661976e-02f, -9.90098417e-02f, -9.40644071e-02f, -2.03658745e-01f, 4.15377039e-03f, -8.17883834e-02f, -8.91739205e-02f, -1.77177951e-01f, -5.56837097e-02f,
  2.11781766e-02f, 6.49911910e-02f, 1.30157368e-02f, 9.21683311e-02f, 3.25475782e-02f, -5.13840057e-02f, -2.64879968e-02f, 3.83419567e-03f, 7.75096938e-02f, 3.34502868e-02f,
  1.41923189e-01f, -4.95095477e-02f, -1.26931584e-02f, -6.34377673e-02f, -5.69041306e-03f, -2.09047068e-02f, -7.99783599e-03f, -1.02227688e-01f, -1.60346236e-02f, -6.97303265e-02f,
  5.79225272e-02f, 3.04370802e-02f, -6.42803460e-02f, 2.58115232e-02f, -1.26533647e-04f, 7.86811262e-02f, 1.09442316e-01f, 2.68836077e-02f, 9.30306688e-02f, 5.20670451e-02f,
  5.11804856e-02f, 1.10140545e-02f, 1.12324044e-01f, -7.50533193e-02f, 7.12163821e-02f, 4.24596667e-02f, 4.47663059e-03f, -6.42923862e-02f, 4.59336303e-03f, -4.11375202e-02f,
  -4.54586558e-02f, -2.64641996e-02f, 9.04657468e-02f, 2.43617240e-02f, 6.56746477e-02f, 1.05247445e-01f, -2.88321897e-02f, -9.55757350e-02f, 2.41339058e-02f, 1.00212377e-02f,
  2.12128572e-02f, 3.79330176e-03f, -1.03486665e-01f, -1.02363884e-01f, 3.87412310e-02f, 9.78113785e-02f, -3.19523849e-02f, -1.33317662e-02f, 7.96824917e-02f, -1.23001877e-02f,
  7.63158128e-02f, 8.18353593e-02f, 1.19674854e-01f, 4.33158539e-02f, -3.22843082e-02f, -1.18980417e-02f, -9.84789059e-02f, 5.41407093e-02f, 9.96062309e-02f, 8.09991509e-02f,
  -8.36200416e-02f, -9.80095640e-02f, -2.13821908e-03f, -1.35267398e-03f, 1.02545857e-01f, 8.98985192e-02f, 1.36854397e-02f, 1.56992137e-01f, -1.11537548e-02f, -7.58347064e-02f,
  -4.17292863e-02f, 7.22265169e-02f, 6.66894540e-02f, 1.76170990e-01f, -6.59119263e-02f, -1.21888153e-01f, 1.53663894e-02f, 1.18455170e-02f, -2.52987202e-02f, -8.18365216e-02f,
  1.15406573e-01f, 4.63735722e-02f, -3.17748427e-01f, 2.34586727e-02f, -1.32625597e-02f, 6.08367398e-02f, 3.04171946e-02f, 1.28310755e-01f, -1.62998632e-01f, 1.12384193e-01f,
  2.38529190e-01f, -2.44590733e-03f, -9.13744941e-02f, 3.15196097e-01f, 2.48126775e-01f, -5.52957803e-02f, 1.79937452e-01f, 9.37361568e-02f, -4.55386415e-02f, 1.02326393e-01f,
  3.26933153e-02f, 4.13323879e-01f, 7.77769312e-02f, 1.99505568e-01f, 2.43247658e-01f, -8.42872709e-02f, 1.79781273e-01f, -4.18210924e-02f, 2.72609293e-01f, 8.34183246e-02f,
  1.14166491e-01f, -2.87949331e-02f, -4.24657129e-02f, -2.35057827e-02f, -5.29237650e-03f, 2.51487661e-02f, -7.75367022e-02f, -1.09212190e-01f, -3.83815430e-02f, -9.93944611e-03f,
  -1.03765735e-02f, -2.35592555e-02f, 3.05330344e-02f, -1.42299142e-02f, 4.76786122e-03f, -1.44075584e-02f, -5.32929264e-02f, -1.19892575e-01f, -5.82972243e-02f, 6.41393363e-02f,
  -9.56065804e-02f, -4.21245992e-02f, -6.72233328e-02f, -1.00336209e-01f, -7.30703026e-02f, -4.16817069e-02f, -8.75630602e-02f, 1.29621206e-02f, -4.07318063e-02f, 7.27371722e-02f,
  1.43292874e-01f, -3.36454250e-02f, 1.11170724e-01f, 1.59074236e-02f, 8.61362834e-03f, 1.60424225e-02f, -3.60899828e-02f, -5.67670129e-02f, -3.00263874e-02f, 6.43600002e-02f,
  -4.57979329e-02f, 2.27727741e-02f, 7.38483761e-03f, 5.33851646e-02f, 4.37222049e-02f, -3.42125557e-02f, 4.23437543e-02f, -5.05945040e-03f, -1.22692674e-01f, 5.07625677e-02f,
  2.25757994e-02f, -3.69023066e-03f, 1.19433533e-02f, 1.78672541e-02f, -8.76040664e-03f, -1.08455844e-01f, 4.15323302e-02f, 9.93416458e-03f, -5.23292720e-02f, -9.23376679e-02f,
  1.44972906e-01f, 6.23373128e-02f, -5.52292876e-02f, 7.49764079e-03f, -5.36342449e-02f, 5.78251407e-02f, 3.05455718e-02f, -2.01349724e-02f, -9.45139751e-02f, 3.67812626e-02f,
  -2.42585372e-02f, -2.38252208e-02f, -1.52344620e-02f, -7.48898610e-02f, -9.61385481e-03f, 5.14346622e-02f, 5.10833487e-02f, -6.14109226e-02f, -5.84058277e-02f, 7.15926290e-02f,
  1.05036600e-02f, 2.81559676e-02f, -8.37186575e-02f, -3.90416831e-02f, -7.83174559e-02f, 7.52925053e-02f, 5.17355604e-03f, 2.16015484e-02f, 6.93214461e-02f, -1.11038443e-02f,
  2.77923077e-01f, -2.74243414e-01f, 9.23396051e-02f, 1.94730610e-01f, 2.39661410e-01f, 6.76693395e-02f, 7.46385977e-02f, -9.72523354e-03f, 1.58225670e-01f, -2.40753323e-01f,
  -9.06456783e-02f, -9.58917215e-02f, -9.30548087e-02f, 1.76087469e-02f, 5.57638742e-02f, -1.33716285e-01f, -1.84444766e-02f, -9.08246115e-02f, 8.74776766e-02f, 2.72465721e-02f,
  1.21936761e-01f, -4.83715907e-02f, 6.08735718e-02f, -5.02742976e-02f, 1.74277380e-01f, 5.23376614e-02f, -9.63137895e-02f, -2.82369461e-03f, 2.74230354e-02f, -2.46557090e-02f,
  3.78985889e-02f, -6.66268989e-02f, -1.06517315e-01f, -4.57276106e-02f, 4.03448418e-02f, -6.05081618e-02f, -1.67351514e-01f, -3.93095538e-02f, 1.07985400e-01f, 6.62398487e-02f,
  -7.78659359e-02f, 3.18361260e-02f, 4.40199152e-02f, 3.45948674e-02f, 3.47478911e-02f, 1.12483151e-01f, 1.07016146e-01f, -5.97834550e-02f, 4.43541929e-02f, 2.32104305e-02f,
  1.14228629e-01f, 4.09105234e-02f, 8.26925188e-02f, -5.32072596e-02f, -3.73762660e-02f, -3.38218994e-02f, -1.41117303e-02f, -6.53629005e-02f, -1.50182908e-02f, -3.32915187e-02f,
  -1.52574450e-01f, -1.06252201e-01f, 6.81783706e-02f, 1.30599394e-01f, -1.37751400e-02f, 1.33674711e-01f, 1.25881717e-01f, 3.13956700e-02f, 5.55728376e-02f, -9.15037282e-03f,
  -8.15885738e-02f, -1.13225073e-01f, -4.03163843e-02f, 7.81026483e-02f, -2.14668773e-02f, 3.09897624e-02f, 1.62295811e-02f, 8.50183740e-02f, -6.68630153e-02f, 3.56600359e-02f,
  3.58374268e-02f, -5.72400019e-02f, -2.99178977e-02f, 1.65292740e-01f, 1.09100863e-02f, 2.09892411e-02f, -3.51498052e-02f, 8.26912597e-02f, -5.18699130e-03f, 2.92888586e-03f,
  -1.01596221e-01f, -2.92376667e-01f, -7.28578046e-02f, -7.27483183e-02f, -6.97234571e-02f, -8.73209462e-02f, -8.05596709e-02f, 6.55801371e-02f, -8.03121179e-02f, -1.44113125e-02f,
  -2.58619525e-02f, 3.52217816e-02f, -3.55786644e-02f, 2.37557329e-02f, -1.65662125e-01f, 4.25695069e-02f, -3.04920468e-02f, -1.26559511e-01f, -6.66961893e-02f, -9.70905796e-02f,
  -1.23617403e-01f, 4.42766435e-02f, 3.19844857e-02f, 4.47464548e-02f, 2.84193028e-02f, -5.07412069e-02f, 2.24804021e-02f, -2.50697192e-02f, 4.85918187e-02f, -5.43122925e-02f,
  3.92275691e-01f, 9.46834460e-02f, 1.55188933e-01f, 4.06945825e-01f, 6.91079125e-02f, 9.50707793e-02f, 4.52289246e-02f, 1.62049443e-01f, 5.34833431e-01f, -1.44276038e-01f,
  -1.32394284e-01f, 8.37611184e-02f, -1.52518511e-01f, 6.35884777e-02f, -3.04872572e-01f, -1.65280718e-02f, 1.75087094e-01f, 1.42153934e-01f, 2.17864245e-01f, 1.29826933e-01f,
  -1.32230176e-02f, -2.81243294e-01f, -2.53628105e-01f, -1.87939838e-01f, 8.75762329e-02f, 1.34760767e-01f, -3.14905703e-01f, -1.91724561e-02f, -1.87177405e-01f, -1.07474804e-01f,
  5.09003177e-04f, 1.31579936e-01f, -1.06700622e-01f, -1.74719058e-02f, 5.41204326e-02f, -3.58652920e-02f, -7.46866986e-02f, -1.29793689e-01f, 5.17446026e-02f, 2.93490686e-03f,
  -8.35907832e-02f, -7.23461583e-02f, 1.36635303e-01f, -6.28364366e-03f, 9.18981880e-02f, 8.79214145e-03f, 4.52135131e-02f, 8.01107436e-02f, -3.50825787e-02f, 3.47308926e-02f,
  -2.13641152e-02f, 4.95410338e-02f, -5.53542003e-03f, 3.15825641e-03f, -2.97096139e-03f, 1.54274717e-01f, 4.48480509e-02f, 3.29925157e-02f, -6.57046214e-02f, 7.33480453e-02f,
  8.48985389e-02f, -1.28416866e-02f, -9.33879539e-02f, -2.75516491e-02f, -1.62764322e-02f, 5.62517494e-02f, -7.78558552e-02f, -5.68154193e-02f, 2.37272307e-02f, -5.47991619e-02f,
  -2.69715320e-02f, 7.26762787e-02f, 4.81166989e-02f, 9.66703445e-02f, 1.15780599e-01f, -3.78702208e-02f, -4.95809969e-03f, 9.70618725e-02f, 4.76058424e-02f, 1.08471578e-02f,
  -4.70512779e-03f, 5.99072799e-02f, -8.99149477e-02f, -1.13631189e-02f, 3.28408591e-02f, -1.14216274e-02f, 1.20099531e-02f, -1.35137038e-02f, 4.96616103e-02f, 3.27868946e-02f,
  1.17236711e-01f, 6.94528893e-02f, -1.28313461e-02f, -2.20875777e-02f, 7.64159188e-02f, -4.69532348e-02f, 2.06547845e-02f, 9.70610306e-02f, 3.35968770e-02f, 3.78182670e-03f,
  -2.91098058e-02f, -7.31376652e-03f, 8.10911413e-03f, 7.10441824e-03f, -2.92508285e-02f, -1.34575054e-01f, -4.16749157e-02f, 1.27714887e-01f, -2.98452415e-02f, -7.04242140e-02f,
  -2.47698128e-02f, 5.18803112e-02f, -1.12980213e-02f, -5.83015829e-02f, 3.51662748e-02f, -1.14860743e-01f, 1.37086213e-01f, -1.79531053e-02f, 1.60678010e-02f, 1.25483191e-02f,
  -6.39934838e-01f, 1.83435753e-01f, -7.39882663e-02f, 7.76593536e-02f, -3.48174050e-02f, -1.89589515e-01f, 5.16753979e-02f, -1.38846293e-01f, 4.73097190e-02f, 2.41441205e-01f,
  2.07175761e-01f, -2.39286676e-01f, 2.44764853e-02f, 6.35194927e-02f, -3.18381250e-01f, 1.33212388e-01f, -3.31159756e-02f, 3.39106843e-02f, 1.08216051e-02f, -1.90318212e-01f,
  -1.14966646e-01f, 1.50165915e-01f, -1.13573849e-01f, 6.99136108e-02f, -8.24863166e-02f, -6.96631670e-02f, 3.07597779e-03f, -9.24948454e-02f, 1.15840500e-02f, -7.80743212e-02f,
  -1.59166634e-01f, -8.49679634e-02f, -4.97635975e-02f, -6.53074607e-02f, -9.26346779e-02f, -1.62975758e-01f, -6.32350743e-02f, 8.40435456e-03f, 4.52166907e-02f, -7.41206929e-02f,
  -1.78608038e-02f, -6.96365759e-02f, 3.77352117e-03f, -7.53489509e-02f, -1.03858069e-01f, 2.56537721e-02f, -3.63960676e-02f, -1.06484536e-02f, 3.07346769e-02f, -5.96556850e-02f,
  -1.35083487e-02f, 4.39440645e-03f, -1.92126036e-02f, 1.69792790e-02f, -8.17177668e-02f, 9.21624079e-02f, 2.77922247e-02f, -1.06458135e-01f, -3.85339633e-02f, 3.67498845e-02f,
  -3.62757891e-02f, 6.91417232e-02f, 6.40359670e-02f, 8.20324570e-02f, -6.42086267e-02f, 5.56053855e-02f, 6.45625358e-03f, -1.72041487e-02f, 9.44383219e-02f, 1.58158708e-02f,
  -3.52538526e-02f, -5.60186170e-02f, -3.63079347e-02f, 1.24491416e-02f, -6.90141246e-02f, -5.72805014e-03f, -3.27528268e-02f, 8.16691220e-02f, 3.21047753e-02f, -2.81868074e-02f,
  1.03498705e-01f, 3.04257795e-02f, 2.18569897e-02f, 2.62107980e-02f, 8.14881548e-02f, 1.99220330e-03f, 2.15821452e-02f, -1.07520901e-01f, 2.52872650e-02f, -1.01162471e-01f,
  -2.01918915e-01f, -1.20946728e-01f, 7.46881068e-02f, 4.68406491e-02f, -4.83784266e-03f, -1.53043151e-01f, 4.75381576e-02f, 5.33600710e-02f, 7.77034909e-02f, -4.02679071e-02f,
  6.78687636e-03f, -1.57330446e-02f, -1.33275747e-01f, 3.92851084e-02f, 2.42391508e-02f, 1.33558229e-01f, 1.11378923e-01f, -6.08944297e-02f, 9.95812416e-02f, -6.22740835e-02f,
  -1.91658381e-02f, 4.62284833e-02f, 1.91788152e-02f, -3.34345140e-02f, -1.49018625e-02f, 1.30918147e-02f, -1.76892374e-02f, -9.98001993e-02f, -1.67084336e-02f, 6.09351322e-02f,
  2.46051550e-01f, -2.55913824e-01f, -3.91511589e-01f, -4.66075763e-02f, 2.61221945e-01f, 2.20514089e-01f, 4.54979241e-02f, 1.13601312e-01f, -7.71367550e-02f, 1.33346736e-01f,
  4.51116301e-02f, -3.40350956e-01f, -1.64483607e-01f, -6.53295815e-02f, -1.09807760e-01f, -3.35940719e-01f, 1.02293752e-01f, 2.66741533e-02f, -1.51624188e-01f, 9.95480362e-03f,
  -4.62876260e-02f, 1.74517483e-01f, -1.97022989e-01f, 2.35162333e-01f, 2.20717207e-01f, 6.04367554e-02f, 2.68624514e-01f, 8.13819654e-03f, 1.13019481e-01f, 4.25381474e-02f,
  3.80462501e-03f, -1.20463654e-01f, -1.66033164e-01f, 5.19353785e-02f, 1.06435426e-01f, 1.88180745e-01f, -1.12607572e-02f, -9.90225375e-02f, -5.01303636e-02f, -1.37194648e-01f,
  -1.78156849e-02f, -3.48811187e-02f, -1.16955899e-02f, 4.47156094e-03f, 1.18390985e-01f, 3.36757228e-02f, -1.42072290e-01f, 2.83346549e-02f, -8.49190354e-02f, -6.00042678e-02f,
  -1.11623682e-01f, -2.93125771e-02f, 6.27024891e-03f, 6.37899861e-02f, -2.73301583e-02f, 1.02307538e-04f, -4.07000519e-02f, 2.13483851e-02f, 1.15620345e-02f, 8.12404882e-03f,
  4.65083234e-02f, 8.73542354e-02f, 8.12792256e-02f, 2.86868066e-02f, -2.00376436e-02f, -1.71137564e-02f, 1.12318598e-01f, -2.27206275e-02f, 2.46469025e-02f, -8.21586605e-03f,
  1.57052688e-02f, -1.20821269e-02f, 5.57604246e-02f, -2.26655751e-02f, 3.92617956e-02f, -1.28851552e-02f, -6.04178533e-02f, -8.65920708e-02f, 8.07204396e-02f, -3.93457897e-02f,
  5.99734969e-02f, 6.73470050e-02f, 1.31066982e-03f, 1.89255213e-03f, -1.32706491e-02f, -1.17303938e-01f, 5.06652109e-02f, -4.48972918e-02f, -1.42747927e-02f, 1.18541725e-01f,
  8.10592920e-02f, 4.08450887e-02f, -1.71610266e-02f, 1.61738768e-02f, 5.07841483e-02f, 2.02758893e-01f, -2.95097139e-02f, -2.94170007e-02f, -7.76376501e-02f, -4.01236676e-02f,
  8.16596448e-02f, 5.44548742e-02f, 7.44839236e-02f, -6.27157316e-02f, 3.21469344e-02f, 7.99139217e-02f, 6.11620769e-03f, 5.65943234e-02f, 1.31627973e-02f, -4.90245260e-02f,
  9.25684571e-02f, 7.23188221e-02f, 7.87566453e-02f, 4.67797853e-02f, 2.45577898e-02f, 4.64280993e-02f, 5.16491644e-02f, 4.56686355e-02f, 4.84131165e-02f, -6.80975467e-02f,
  -1.59625396e-01f, 1.60708278e-01f, -1.20549656e-01f, -6.08217753e-02f, 5.22145517e-02f, -2.80312598e-01f, -1.25669077e-01f, -2.60778274e-02f, 7.69923031e-02f, 1.54304534e-01f,
  7.50919757e-03f, 1.15903594e-01f, -6.29445165e-02f, -8.21317197e-04f, -2.12214500e-01f, -5.01220599e-02f, -2.15511024e-01f, -1.04085140e-01f, -4.06573042e-02f, -9.34752226e-02f,
  -1.27475828e-01f, -7.56611824e-02f, -1.56752929e-01f, -6.96197674e-02f, -1.15554824e-01f, 4.98883389e-02f, -1.29085287e-01f, -1.63587742e-02f, -7.86051005e-02f, -1.42631968e-02f,
  7.05753267e-03f, 1.34766787e-01f, 7.72669241e-02f, 6.94652051e-02f, -1.41604245e-01f, -1.11008778e-01f, -3.93638201e-02f, 6.66443780e-02f, 2.21329406e-02f, 1.15834279e-02f,
  -5.18000200e-02f, -6.02995418e-02f, 3.38788331e-02f, 2.23162156e-02f, -6.47789836e-02f, 4.55671698e-02f, -6.46376517e-03f, -1.13552332e-01f, 1.29112482e-01f, -8.65031928e-02f,
  -2.21778043e-02f, 1.51559301e-02f, -6.57049865e-02f, -6.14515431e-02f, -4.78752237e-03f, -1.51825836e-03f, 3.23687978e-02f, -4.24856022e-02f, -2.75940821e-02f, -2.63802391e-02f,
  -7.02962503e-02f, -2.97768954e-02f, 4.17283103e-02f, 5.46749197e-02f, 9.65034142e-02f, 6.17595622e-03f, -6.87952638e-02f, -1.11026010e-02f, -9.12765712e-02f, -3.61756794e-02f,
  3.10297981e-02f, 3.33851855e-03f, -2.51040272e-02f, -9.99177694e-02f, -8.97038504e-02f, 1.00948282e-01f, -5.65553419e-02f, 4.12185863e-02f, 2.03843135e-02f, -1.02061599e-01f,
  6.53593391e-02f, -1.02835651e-02f, -1.75780263e-02f, -8.50773454e-02f, 1.14671215e-02f, -7.50615895e-02f, -1.30646471e-02f, -5.60193658e-02f, -7.90150687e-02f, -1.51776439e-02f,
  -1.19362928e-01f, 1.33758709e-02f, 1.62830338e-01f, 5.36419414e-02f, 3.96813750e-02f, 8.39600805e-03f, -2.76139211e-02f, 1.02466997e-02f, -6.14809394e-02f, 2.82128081e-02f,
  -5.26075959e-02f, -2.84930021e-02f, -5.58255613e-02f, -5.33330813e-02f, -1.11672536e-01f, -1.06091253e-01f, -5.03579564e-02f, 1.18777370e-02f, -6.95370659e-02f, -6.58324584e-02f,
  -3.54130715e-02f, -2.30953377e-02f, 6.31357580e-02f, 2.67145503e-02f, 4.90402170e-02f, -1.32818921e-02f, 8.90708193e-02f, 5.04071936e-02f, -3.73758674e-02f, -9.17983428e-03f,
  -8.26737508e-02f, -1.48351446e-01f, -3.93998891e-01f, -1.74235687e-01f, -8.48003924e-02f, -3.82847399e-01f, -2.42158115e-01f, -9.08748731e-02f, 4.16588038e-02f, 1.58749223e-01f,
  -2.39949673e-02f, 4.55363542e-02f, 1.79999590e-01f, -1.53642565e-01f, -2.19618306e-01f, 1.14391156e-01f, -2.03724623e-01f, -5.04643060e-02f, 1.29094347e-01f, -1.36836633e-01f,
  -5.35887517e-02f, -3.72471334e-03f, -2.31630698e-01f, 1.61343217e-01f, -2.46123612e-01f, -2.64850967e-02f, 1.07599981e-01f, 8.04090966e-03f, -1.17006667e-01f, -1.03429213e-01f,
  -7.69799203e-02f, 8.64745751e-02f, -5.76288067e-02f, -6.37145117e-02f, -1.00810423e-01f, -2.62422152e-02f, -1.28592867e-02f, 8.35495535e-03f, 4.38368618e-02f, -2.55318359e-02f,
  -8.16255361e-02f, 5.41786626e-02f, 3.92763764e-02f, 7.81098828e-02f, -2.50743050e-02f, 1.35328639e-02f, -2.21030437e-03f, -5.20871058e-02f, 2.90151723e-02f, -4.80075404e-02f,
  -4.64162901e-02f, -8.09424967e-02f, -1.39028564e-01f, 6.31904677e-02f, 2.12200377e-02f, -2.95054279e-02f, -1.15475215e-01f, 9.17233620e-03f, 9.33313917e-04f, 5.15009128e-02f,
  -2.08773650e-02f, 5.32434396e-02f, 7.79192820e-02f, -2.24158075e-02f, 7.59011358e-02f, -3.47056016e-02f, 4.58118320e-02f, 2.83372533e-02f, -3.80742736e-02f, -2.10204255e-02f,
  2.15813071e-02f, -8.64004269e-02f, -9.87628251e-02f, 4.26045852e-03f, -4.28465679e-02f, 6.80918545e-02f, 2.50554606e-02f, 1.29977884e-02f, -5.60427047e-02f, -8.13372806e-02f,
  1.29361972e-01f, -1.24490887e-01f, -4.02927101e-02f, 1.28870476e-02f, -1.95477698e-02f, -4.27642465e-02f, 1.00199608e-02f, -7.43234232e-02f, -5.70392534e-02f, -4.58530039e-02f,
  -1.36387482e-01f, -2.43731383e-02f, 5.82000203e-02f, 3.72794233e-02f, 3.57646309e-02f, -8.82831216e-02f, 2.02227775e-02f, -3.42085473e-02f, -3.08376253e-02f, 6.23178892e-02f,
  -7.30955601e-02f, 4.28055041e-02f, -5.73386960e-02f, -5.75051755e-02f, -2.57801004e-02f, -1.56239167e-01f, 5.22697531e-03f, 7.73569047e-02f, -5.37956841e-02f, -6.95169866e-02f,
  -3.18835489e-02f, 9.21770632e-02f, -5.74559271e-02f, 3.44008952e-02f, 1.26337307e-02f, 4.65826504e-02f, -7.41621852e-02f, -1.32805696e-02f, 1.82952434e-02f, 8.12170282e-03f,
  -5.18538132e-02f, -1.80240124e-01f, 2.20452454e-02f, 1.34364530e-01f, 4.03563194e-02f, -2.77542919e-01f, -2.82572210e-01f, 9.14009511e-02f, -1.14909716e-01f, -1.00748271e-01f,
  1.52625535e-02f, -1.60819620e-01f, -2.44008705e-01f, 1.24564087e-02f, 1.82445183e-01f, -3.19305301e-01f, 1.14387922e-01f, -2.10571988e-03f, -1.14352420e-01f, 1.72457024e-02f,
  1.46204457e-01f, 1.32636875e-01f, 2.01035142e-01f, 2.54807442e-01f, -2.71334872e-02f, 2.57965147e-01f, 3.54401529e-01f, -2.57293438e-03f, 1.92527384e-01f, 1.36074468e-01f,
  2.94702258e-02f, -1.05127066e-01f, 2.34691594e-02f, -4.26922552e-03f, 5.45404926e-02f, 1.92700867e-02f, 5.78514719e-03f, -6.99631944e-02f, 1.92730501e-02f, -1.13644838e-01f,
  -1.43170193e-01f, -1.94477383e-02f, 3.95859107e-02f, -5.66765992e-03f, 5.94445094e-02f, 6.19255193e-03f, 1.86602175e-02f, 4.41239402e-02f, 3.06311902e-03f, -1.36059210e-01f,
  -1.24798398e-02f, -5.64503577e-03f, -9.55976322e-02f, 4.37910855e-02f, 1.86285209e-02f, 1.69963855e-02f, 7.31018465e-03f, 8.93963501e-02f, -4.07490656e-02f, 6.69394247e-03f,
  3.42279747e-02f, -4.00294140e-02f, -4.58893962e-02f, -7.93990493e-02f, -8.70323554e-03f, -9.47858244e-02f, -1.48061752e-01f, -6.68215081e-02f, -3.10185384e-02f, -4.51634824e-02f,
  -8.21951032e-02f, 1.15376003e-01f, -7.27057755e-02f, -6.04174398e-02f, 5.90558238e-02f, -1.26953110e-01f, -1.33002952e-01f, 8.50499608e-03f, 6.03211857e-02f, 3.66646573e-02f,
  -1.35253444e-01f, 4.71659638e-02f, 3.10644414e-02f, -1.27222398e-02f, -4.45854217e-02f, 4.27742079e-02f, -1.02967964e-02f, -5.92633113e-02f, 1.59826558e-02f, -5.07492386e-02f,
  -1.36251422e-03f, 1.05621062e-01f, 1.71234049e-02f, 2.65251119e-02f, 8.28103796e-02f, -4.81208451e-02f, -2.72128489e-02f, 3.78264934e-02f, 4.09829542e-02f, -9.54091251e-02f,
  2.26759501e-02f, 5.61880246e-02f, -3.07474341e-02f, 2.08294652e-02f, 2.58410443e-02f, -5.51726148e-02f, -2.36471351e-02f, 5.86483218e-02f, 1.66794255e-01f, 7.66835734e-02f,
  1.61786806e-02f, -7.05083981e-02f, 5.95166683e-02f, -9.33865272e-03f, 6.78891763e-02f, 6.69831261e-02f, -4.29920666e-02f, 3.29118408e-02f, -2.92854477e-02f, -3.49425524e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  2.81103611e-01f, 7.19546303e-02f, 1.31076351e-01f, 9.66208894e-03f, 1.23866342e-01f, 3.35064009e-02f, 3.50759327e-02f, 1.53099000e-01f, 8.32358748e-02f, 1.42005518e-01f,
  1.33050993e-01f, 8.92662778e-02f, 1.98428020e-01f, 1.08527087e-01f, 2.25219801e-01f, 2.94856019e-02f, 1.22070670e-01f, 9.02862549e-02f, 1.02494866e-01f, 1.09260418e-01f,
  1.96246002e-02f, 1.14005819e-01f, 4.92390767e-02f, 1.22456841e-01f, 8.83288458e-02f, 1.44061148e-01f, 1.80572510e-01f, 9.21847075e-02f, 1.01664297e-01f, 6.75214827e-02f,
  1.29829124e-01f, 2.36742832e-02f, 1.09993219e-01f, 1.01071559e-01f, 1.26688331e-01f, 1.43159047e-01f, 2.07059234e-01f, 1.06526509e-01f, 1.18975274e-01f, 5.23434579e-02f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  7.24068508e-02f, 2.49571316e-02f, 9.12556723e-02f, -6.75224066e-02f, 3.79166007e-02f, 5.71273752e-02f, 2.08694786e-02f, -5.04889041e-02f, 4.81606908e-02f, 1.02599978e-01f,
  8.47944021e-02f, 4.28355709e-02f, 8.05783346e-02f, 8.27446878e-02f, -4.52357046e-02f, 7.60332495e-02f, 3.38019580e-02f, 6.44175634e-02f, 8.47029388e-02f, 7.09624290e-02f,
  -1.00507237e-01f, 2.98155751e-02f, 1.09292254e-01f, -1.49438931e-02f, 7.38090277e-02f, 1.00217812e-01f, 8.59636720e-03f, 2.39308342e-01f, 8.50247443e-02f, -2.30862647e-01f,
  -6.91703521e-03f, 2.57588029e-01f, 1.96477681e-01f, 6.42082980e-03f, 1.66287467e-01f, -3.90048102e-02f, 6.86282068e-02f, 1.24872550e-01f, 3.85136530e-02f, -5.25419042e-02f,
  -7.42711574e-02f, -6.22381456e-02f, -1.32314190e-01f, 4.38387394e-02f, -1.92166433e-01f, -1.05996132e-01f, -6.42770603e-02f, -6.22965097e-02f, 4.76706065e-02f, 3.87420692e-02f,
  2.78649572e-02f, 1.36706024e-01f, -7.87160471e-02f, -1.28815845e-01f, 1.80943916e-03f, -6.49214685e-02f, 1.78923145e-01f, 6.47271201e-02f, -1.54091656e-01f, -7.28558525e-02f,
  9.86119211e-02f, -1.19283982e-02f, -2.29087159e-01f, 9.63021070e-02f, -1.11859208e-02f, -4.17222902e-02f, -4.27308828e-02f, -2.77822949e-02f, 2.44860817e-02f, 2.39908956e-02f,
  1.11861706e-01f, 3.45392749e-02f, -1.07260838e-01f, -1.22542086e-03f, 1.05086014e-01f, -3.65356691e-02f, -3.69446427e-02f, 2.68312562e-02f, -3.77125815e-02f, -4.35845219e-02f,
  2.47950982e-02f, -8.74076411e-03f, -2.01720744e-02f, -6.96607158e-02f, -5.15533518e-03f, -9.08075944e-02f, -9.83568579e-02f, 6.34155273e-02f, 6.03486747e-02f, -1.04780748e-01f,
  -1.11460197e-03f, -1.47631422e-01f, -6.11311942e-02f, 1.65198356e-01f, 1.01365231e-01f, -1.33617803e-01f, 7.85649344e-02f, 6.52192459e-02f, 1.47317881e-02f, -9.77688730e-02f,
  2.10555707e-04f, -5.12871332e-02f, -9.38698556e-03f, -4.26022187e-02f, -6.72094077e-02f, 4.96853553e-02f, -5.21987379e-02f, -6.97455481e-02f, 2.30884090e-01f, -3.88130061e-02f,
  3.70333120e-02f, 7.86937997e-02f, 4.46536206e-02f, 1.49155498e-01f, 7.10779056e-02f, 6.27280271e-04f, -1.50870398e-01f, 2.70941034e-02f, 1.47485491e-02f, -2.29336303e-02f,
  -1.48310483e-01f, 7.45188072e-02f, -1.72169209e-02f, 1.34953037e-01f, -7.69502744e-02f, 1.31847709e-01f, 1.43544465e-01f, -1.91758037e-01f, -6.49113432e-02f, -8.08283165e-02f,
  -3.53774824e-03f, -5.32003865e-02f, 2.94096097e-02f, -1.45379147e-02f, 1.04194276e-01f, 4.25033160e-02f, -8.52726549e-02f, 1.25141128e-03f, 1.27200652e-02f, 8.71668532e-02f,
  3.99678722e-02f, 1.36171237e-01f, -2.56530251e-02f, -1.36516439e-02f, -9.06611606e-03f, 6.99501485e-02f, 4.18761221e-04f, -7.06892982e-02f, -8.02984759e-02f, -1.39034703e-01f,
  -1.37873858e-01f, 2.00322699e-02f, -1.08594231e-01f, 1.43065348e-01f, -1.34824589e-01f, -1.16626499e-02f, -5.89488633e-03f, 4.41496298e-02f, 7.28447735e-02f, -5.69550022e-02f,
  1.32128224e-01f, -9.25049260e-02f, 7.30683878e-02f, -1.65225521e-01f, -1.74030557e-01f, 1.73820741e-02f, 9.88868847e-02f, 9.73379984e-02f, -1.67498723e-01f, 9.79421958e-02f,
  7.12487027e-02f, -1.24416567e-01f, 8.67131874e-02f, 4.18882184e-02f, 1.30184472e-01f, -4.82877064e-03f, 2.10299920e-02f, 1.67341843e-01f, 1.18103117e-01f, 2.75200326e-03f,
  5.11928275e-02f, 7.29589537e-02f, 1.52501576e-02f, -1.66240573e-01f, 5.56972101e-02f, -3.73433419e-02f, -2.03903005e-01f, 1.41267449e-01f, -5.94947189e-02f, 2.05310602e-02f,
  5.98960109e-02f, -1.19544208e-01f, 3.75194065e-02f, -6.19582161e-02f, 6.01020902e-02f, 3.45667452e-02f, 1.58358607e-02f, 7.56756216e-02f, 1.78643033e-01f, 5.64658307e-02f,
  4.76744287e-02f, -3.46537083e-02f, 1.54607877e-01f, 1.17545314e-01f, -2.43593398e-02f, 1.92911997e-02f, 2.82462612e-02f, -2.11449936e-01f, 2.94298027e-02f, -1.28028169e-01f,
  -6.39291480e-02f, -1.19812615e-01f, -8.26544166e-02f, -1.04885004e-01f, -1.15197904e-01f, 3.52492109e-02f, 1.43314019e-01f, -1.02318853e-01f, 6.61902502e-02f, -9.82325152e-02f,
  5.36846742e-02f, 3.84724215e-02f, -8.08828697e-03f, 7.93070812e-03f, 1.69960111e-02f, -1.10737368e-01f, 7.72245303e-02f, -2.38856390e-01f, -1.65658087e-01f, -2.09184922e-02f,
  -7.30555430e-02f, 1.32382110e-01f, -3.75584960e-02f, 8.54639411e-02f, 1.04595302e-02f, -1.37436017e-01f, 1.07376061e-01f, -2.51510944e-02f, 2.78826803e-02f, 1.07232153e-01f,
  6.73268363e-02f, 1.42374754e-01f, 1.00622110e-01f, 1.39658272e-01f, -1.42995700e-01f, 5.32791056e-02f, 1.59900069e-01f, -1.57809481e-02f, -1.66509643e-01f, 1.10259898e-01f,
  -4.60469387e-02f, -2.27591395e-02f, -1.71045303e-01f, 4.31216806e-02f, 2.13110819e-02f, -1.90577917e-02f, 3.96919213e-02f, 1.25312516e-02f, 8.54347944e-02f, 1.61489353e-01f,
  -1.75789610e-01f, 3.06280535e-02f, -2.92799845e-02f, 8.86607096e-02f, -2.80554816e-02f, -1.37656674e-01f, -2.06201300e-02f, 8.07766709e-03f, 8.60370323e-02f, 2.09580306e-02f,
  9.19416845e-02f, -2.42979154e-01f, 6.24378435e-02f, -3.50687071e-03f, 8.82211700e-02f, -6.76515102e-02f, 5.10525852e-02f, -9.88813564e-02f, -1.41441487e-02f, -7.57573918e-02f,
  -6.01239204e-02f, -1.80205926e-01f, 8.89409557e-02f, -2.53647063e-02f, 1.20304935e-01f, -1.24640562e-01f, 4.43770960e-02f, 1.02368250e-01f, 3.61945108e-02f, -2.39553362e-01f,
  9.11256820e-02f, -1.43414095e-01f, -1.53406695e-01f, -1.55818313e-01f, -1.70904890e-01f, -7.28605986e-02f, 4.82428484e-02f, -1.02112643e-01f, -1.79318517e-01f, -5.68360724e-02f,
  -1.33685546e-03f, 3.16439599e-01f, 1.08891599e-01f, 1.47816271e-01f, 1.45613313e-01f, -1.44893676e-02f, 1.59297902e-02f, 2.83312589e-01f, -2.00759485e-01f, -5.94933964e-02f,
  -4.97147925e-02f, 2.78413445e-02f, -1.05319008e-01f, 1.69710979e-01f, 4.57789153e-02f, 5.25644310e-02f, 4.20522466e-02f, 9.94257927e-02f, 7.80515820e-02f, 1.12104297e-01f,
  -6.56384528e-02f, 2.45113615e-02f, 5.11807296e-03f, 3.22586223e-02f, 7.49701783e-02f, 6.49307743e-02f, 1.19194858e-01f, 1.03961229e-01f, -2.20807996e-02f, -5.79192750e-02f,
  -1.02562422e-03f, 2.30792165e-02f, -5.36192693e-02f, -1.47583023e-01f, 7.36928582e-02f, -1.33564591e-01f, -4.46944451e-03f, -1.44985557e-01f, -1.20463045e-02f, -1.24378584e-01f,
  4.45391871e-02f, -4.00741175e-02f, -6.40697330e-02f, 5.55457436e-02f, 5.78113012e-02f, -1.55171454e-01f, 1.37835771e-01f, -2.28813052e-01f, -9.18505192e-02f, 1.70144826e-01f,
  -9.16626379e-02f, -2.95604855e-01f, -1.67086527e-01f, -6.78456128e-02f, -4.08596955e-02f, 2.62685511e-02f, -3.95158269e-02f, 4.57144715e-02f, -1.40171826e-01f, 6.25833049e-02f,
  3.32949869e-03f, 8.57731104e-02f, 3.28455903e-02f, -2.69162692e-02f, 1.35224193e-01f, -3.19920853e-02f, -1.22416234e-02f, 4.83752117e-02f, 3.41955423e-02f, 2.07860172e-02f,
  1.07295007e-01f, -6.54065702e-03f, -1.75881490e-01f, 1.21458687e-01f, 1.07692756e-01f, 1.24178819e-01f, -2.40484431e-01f, 8.42044875e-02f, 2.58958071e-01f, -7.87873492e-02f,
  -2.71873195e-02f, 2.34125089e-02f, 1.26499847e-01f, -1.33969903e-01f, -8.39264542e-02f, 1.51128694e-02f, -5.96634634e-02f, 1.56136006e-02f, -5.94684668e-02f, -2.64253728e-02f,
  3.02277189e-02f, 9.84429270e-02f, -4.93809767e-02f, -2.32005995e-02f, 9.22957808e-02f, -5.78507707e-02f, -4.10357304e-02f, -5.62138744e-02f, 8.05685967e-02f, -8.51951167e-02f,
  -4.89780074e-03f, -2.25318149e-02f, -9.34442654e-02f, -1.79692451e-02f, 1.40465423e-01f, 1.19420901e-01f, -2.20895484e-02f, 1.04582958e-01f, 1.66369960e-01f, -1.20397814e-01f,
  1.91721633e-01f, -7.42918402e-02f, -1.20864235e-01f, 2.45386481e-01f, 8.07236284e-02f, -1.22084394e-01f, -1.16949476e-01f, -7.46056736e-02f, -4.58003469e-02f, 6.71738852e-03f,
  4.32985947e-02f, 1.11644529e-01f, -1.51494980e-01f, -1.78206086e-01f, 2.55837552e-02f, -1.57284409e-01f, -6.54460341e-02f, -4.93527129e-02f, 2.24471748e-01f, 1.33150235e-01f,
  -5.81728201e-03f, 7.93140829e-02f, 4.47106641e-03f, -8.16709027e-02f, -8.79599452e-02f, -4.29108273e-03f, -4.03660163e-03f, -2.84301303e-02f, 8.91962051e-02f, 1.40649766e-01f,
  -1.24658123e-01f, 3.85345146e-02f, 1.34335563e-01f, 2.83576250e-02f, -7.07047135e-02f, 9.59178284e-02f, 1.56280100e-01f, -6.96081072e-02f, -4.10500132e-02f, 7.27477949e-03f,
  6.65596351e-02f, -4.01244722e-02f, 7.78404102e-02f, -7.44810849e-02f, 3.47178616e-02f, 5.46226129e-02f, -2.95618419e-02f, 8.24939683e-02f, 7.66202733e-02f, 1.60846226e-02f,
  7.54827634e-02f, -1.09866723e-01f, -9.44672003e-02f, 2.49508023e-01f, -1.46691307e-01f, 1.05548911e-01f, -6.15535118e-02f, 1.11039571e-01f, 4.13613878e-02f, 9.86515433e-02f,
  -6.10421896e-02f, 1.39884979e-01f, -1.79738149e-01f, 2.32074127e-01f, -1.71368539e-01f, 9.81326550e-02f, -2.24356085e-01f, -2.07036044e-02f, 1.14092231e-01f, -5.91059104e-02f,
  9.82102901e-02f, 1.02440804e-01f, 8.14102665e-02f, 1.48558259e-01f, 8.34203959e-02f, 5.28732548e-03f, 2.43892387e-01f, 8.25679377e-02f, -1.27796933e-01f, 7.52511770e-02f,
  1.33164749e-01f, -2.69756857e-02f, 4.59000617e-02f, 5.58272079e-02f, 9.17615965e-02f, -1.65523160e-02f, 5.68111837e-02f, -8.76829475e-02f, 4.33974192e-02f, -3.39293271e-01f,
  1.93504557e-01f, -2.45944671e-02f, -2.60040909e-01f, -2.06624400e-02f, 1.34743229e-02f, -1.66573286e-01f, 3.91272902e-02f, 1.45162940e-01f, 2.08623614e-03f, 5.02721556e-02f,
  -1.82215963e-02f, -1.46274447e-01f, -3.76117555e-03f, 4.06412594e-03f, -8.09964899e-04f, 1.11508399e-01f, 3.21718119e-02f, 6.20111488e-02f, 3.07147987e-02f, -3.96452919e-02f,
  9.77333933e-02f, -1.33893371e-01f, 1.30346073e-02f, -5.43029159e-02f, 5.89539297e-02f, -1.70219064e-01f, 5.23597747e-02f, -1.11037396e-01f, -7.78315663e-02f, -1.47177175e-01f,
  -1.10114105e-01f, 1.97986234e-02f, 1.42866209e-01f, 7.72838593e-02f, -1.83392704e-01f, 7.85297677e-02f, 4.75537479e-02f, -5.69891036e-02f, 1.76185612e-02f, -1.16573721e-01f,
  -2.92862225e-02f, 2.39320368e-01f, 6.56896911e-04f, -1.06084518e-01f, -1.47277892e-01f, -1.30872980e-01f, 4.17022593e-02f, 3.85197960e-02f, -2.16167904e-02f, -8.06387812e-02f,
  -3.06139626e-02f, 1.23743929e-01f, 1.84643224e-01f, 4.92740646e-02f, 2.08230197e-01f, -3.77896652e-02f, 1.45033628e-01f, 7.17050284e-02f, 1.73732340e-02f, 1.42123803e-01f,
  1.33523881e-01f, -1.04354061e-01f, 1.42535582e-01f, -9.55639407e-02f, -1.03543587e-02f, 8.71584862e-02f, 2.88050808e-02f, 6.58569485e-02f, -1.25874951e-01f, 1.95324738e-02f,
  2.40375072e-01f, -1.79215707e-02f, -1.57989889e-01f, 1.27765477e-01f, 1.57705978e-01f, 6.24435060e-02f, -9.25149396e-02f, -6.31088465e-02f, -3.34782497e-04f, 3.85113843e-02f,
  6.10876121e-02f, -2.80518504e-03f, 7.32448325e-02f, 5.34813739e-02f, -2.86005326e-02f, 1.66622624e-02f, 3.42720672e-02f, -4.33879904e-02f, -3.07014026e-02f, -6.86806664e-02f,
  -6.70679063e-02f, 2.49876343e-02f, -9.47012901e-02f, -9.98914894e-03f, -1.15165032e-01f, -4.81091850e-02f, 7.81203359e-02f, 3.73340514e-03f, -1.45646647e-01f, 1.07352443e-01f,
  6.60358444e-02f, 1.61314934e-01f, -1.56277403e-01f, -8.39649141e-02f, -1.26236618e-01f, -7.91226625e-02f, 4.28523980e-02f, 5.71104549e-02f, -1.54827386e-02f, -1.18396528e-01f,
  9.23717916e-02f, -3.13127376e-02f, -5.14440984e-02f, -1.31087884e-01f, 2.12665051e-01f, 1.96570098e-01f, 8.03153589e-02f, 2.04595149e-01f, 1.81811824e-01f, -4.22867481e-03f,
  1.10940419e-01f, -6.62383735e-02f, 3.10008004e-02f, -1.45726353e-02f, 1.58385709e-02f, -6.11784756e-02f, 3.42307277e-02f, -2.82161504e-01f, 2.08234951e-01f, -6.70508370e-02f,
  -1.89531818e-01f, -8.93787593e-02f, -1.46050781e-01f, -7.87879229e-02f, 8.43780264e-02f, 7.53240287e-02f, -2.84777075e-01f, -5.98556129e-03f, -8.03137496e-02f, 4.77908365e-02f,
  2.73068435e-02f, 6.50288165e-02f, -1.80766545e-02f, -2.13975072e-01f, 9.68476459e-02f, -4.73271534e-02f, 7.23841563e-02f, -9.82950479e-02f, -5.23310304e-02f, 8.17295089e-02f,
  4.25697751e-02f, 8.03115219e-02f, -2.97063049e-02f, 1.28838897e-01f, 4.89154384e-02f, 1.09984294e-01f, 1.00033097e-01f, -1.38733787e-02f, 7.04943538e-02f, 3.67764803e-03f,
  -1.22953102e-01f, 9.18829441e-03f, -1.53156964e-03f, 2.11073365e-02f, -2.67050602e-02f, -4.75080870e-02f, -1.06760122e-01f, -5.39258996e-04f, -6.34203898e-03f, 9.47803184e-02f,
  -6.71389848e-02f, 1.82593707e-02f, 5.82736731e-02f, 4.73630019e-02f, -3.57063836e-03f, -1.63238775e-02f, -1.47101153e-02f, 1.13465495e-01f, -1.31054716e-02f, 2.42057219e-02f,
  -1.32760331e-01f, -2.44593807e-02f, -1.22666724e-01f, -7.88399130e-02f, 4.46833037e-02f, -1.44479230e-01f, -1.06983684e-01f, -1.70727268e-01f, -9.83516574e-02f, 1.73762798e-01f,
  3.39145511e-02f, 3.26572321e-02f, -1.48991138e-01f, 1.32225379e-01f, 2.34338969e-01f, -5.76628931e-02f, 9.37062949e-02f, -3.34046334e-02f, -3.17058682e-01f, -5.03134169e-02f,
  -8.13578516e-02f, -1.11545675e-01f, 3.11935861e-02f, -1.14376329e-01f, 8.17031041e-02f, 2.77466029e-02f, -5.20607159e-02f, -3.54959406e-02f, 8.22695866e-02f, 2.77980673e-03f,
  -3.98368426e-02f, -8.40242952e-02f, 7.55604431e-02f, 4.90980223e-02f, 9.89874452e-02f, -2.01028120e-02f, -1.52337328e-02f, -4.75718491e-02f, -8.47768635e-02f, -6.03429824e-02f,
  2.61601675e-02f, -6.41650781e-02f, -7.87316263e-03f, -4.78875674e-02f, -7.48874024e-02f, 1.05492972e-01f, 1.67986855e-01f, 2.96943374e-02f, 6.27336204e-02f, 3.67657617e-02f,
  1.39143035e-01f, 1.87076494e-01f, 1.19462468e-01f, -1.94315746e-01f, -2.60945200e-03f, 1.00792833e-01f, 8.53884742e-02f, 1.01614594e-01f, 5.62251508e-02f, 5.69789596e-02f,
  1.72096878e-01f, 1.46815687e-01f, -3.88222933e-03f, -7.64220906e-03f, 8.34594518e-02f, -3.12013812e-02f, -6.03598543e-02f, 1.26479521e-01f, -1.35442749e-01f, -1.74961790e-01f,
  -9.96326655e-02f, -7.35539943e-02f, -5.01511432e-02f, -6.23433702e-02f, -7.11145625e-02f, 1.06575832e-01f, 3.88384871e-02f, -1.68071121e-01f, -5.63306808e-02f, 3.39941494e-02f,
  5.97141385e-02f, 6.56096116e-02f, -2.75661558e-04f, -1.18992224e-01f, -1.65387255e-03f, -4.48740534e-02f, -2.25162253e-01f, 1.22350276e-01f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  5.64297549e-02f, 5.38166165e-02f, 1.07689306e-01f, 6.36228174e-02f, 1.35400414e-01f, -4.05954942e-03f, 3.01756766e-02f, 1.63567625e-02f, 1.18837610e-01f, 4.20635380e-02f,
  2.10408926e-01f, 4.20630537e-02f, 1.14729427e-01f, -2.47202888e-02f, -1.57875083e-02f, -1.21389881e-01f, -3.30718793e-02f, 8.89482275e-02f, -1.55214027e-01f, -1.55465186e-01f,
  5.68505283e-03f, 1.05395474e-01f, -5.00022918e-02f, 1.72123656e-01f, 2.70075887e-01f, 5.17476490e-03f, 9.90101099e-02f, -3.07743046e-02f, -5.23539307e-03f, 1.64886806e-02f,
  9.68528390e-02f, 1.20772138e-01f, 1.26314938e-01f, -5.01136482e-02f, 2.59518117e-01f, -1.13612719e-01f, -4.48311679e-02f, 6.47049323e-02f, 2.62363981e-02f, -1.51321273e-02f,
  -7.80467093e-02f, -7.47813191e-03f, -8.37673098e-02f, -1.37182817e-01f, 9.04832780e-02f, -1.17482230e-01f, -2.49113180e-02f, 5.81827462e-02f, 1.12270594e-01f, 2.30381060e-02f,
  9.69873294e-02f, -4.96590734e-02f, -1.68929443e-01f, -8.07493776e-02f, 5.65653369e-02f, 9.80758741e-02f, -5.63208684e-02f, 1.53738871e-01f, 2.25202665e-02f, 2.58171130e-02f,
  -1.82311952e-01f, 1.08344920e-01f, -8.12626928e-02f, -7.79054686e-02f, 1.20188110e-01f, 1.39975473e-01f, 8.89672637e-02f, 3.66473272e-02f, 1.10328935e-01f, 7.56207034e-02f,
  3.86887677e-02f, 8.95083100e-02f, 1.11177079e-01f, 1.20184943e-01f, 4.02467027e-02f, 1.04453750e-01f, -6.10656627e-02f, -1.42933965e-01f, 9.23946723e-02f, 1.02244103e-02f,
  1.48330092e-01f, -2.28149578e-01f, 5.64445667e-02f, -5.86321531e-03f, 9.52860788e-02f, 5.22555225e-02f, 6.25463426e-02f, -1.03295825e-01f, 1.90394118e-01f, -1.73657566e-01f,
  2.25857824e-01f, -5.11605144e-02f, 6.44729063e-02f, 1.21754363e-01f, -1.07854605e-01f, -7.33718276e-02f, -2.08044827e-01f, 1.35344997e-01f, -1.52015001e-01f, 2.11738974e-01f,
  2.15183720e-01f, 9.07884091e-02f, -1.52192041e-01f, -3.23387720e-02f, 1.70364276e-01f, 1.05119385e-02f, 6.90497532e-02f, 1.86521530e-01f, -5.45955338e-02f, -4.35985997e-02f,
  -7.89910629e-02f, -1.05054667e-02f, -4.88019101e-02f, -4.45347279e-02f, -1.15707628e-02f, 1.05725117e-01f, -3.60239074e-02f, 1.46054819e-01f, 1.83808804e-01f, 8.13951120e-02f,
  4.10126522e-02f, 1.46464050e-01f, 2.44154632e-01f, -1.53154477e-01f, 1.50598928e-01f, -3.20201106e-02f, 4.61821482e-02f, 6.95200041e-02f, 1.22861497e-01f, 5.57120293e-02f,
  2.30275150e-02f, 1.80183932e-01f, 6.28390163e-02f, 2.74727903e-02f, 7.19624981e-02f, 1.71060786e-02f, 1.38178200e-01f, 3.54070067e-02f, 2.78412178e-03f, 6.34014234e-02f,
  -2.06455309e-02f, -1.19805679e-01f, -4.48837280e-02f, -1.13710091e-01f, -4.32579108e-02f, -1.65411070e-01f, -4.50153016e-02f, -5.69143109e-02f, 7.53965899e-02f, 7.02544022e-03f,
  -9.21389926e-03f, -1.79675203e-02f, 5.60288131e-02f, 1.30218342e-01f, 9.82177183e-02f, -2.03272477e-02f, 7.40179373e-03f, -1.08709306e-01f, -9.54815298e-02f, 6.35283738e-02f,
  -1.03863582e-01f, -2.10781693e-02f, -5.93840666e-02f, 5.59594035e-02f, 5.36173917e-02f, -7.59521499e-02f, 7.28093684e-02f, 2.11025625e-01f, 2.27635488e-01f, 1.72941983e-01f,
  2.04130247e-01f, 1.32845417e-01f, -1.22304812e-01f, -1.65226012e-01f, -5.04357368e-02f, -2.19043880e-03f, -2.24095564e-02f, -8.10142234e-02f, 2.51902230e-02f, -7.50133246e-02f,
  2.49848902e-01f, -4.24665846e-02f, -1.16083801e-01f, -4.37305123e-02f, -5.20293862e-02f, 8.46228842e-03f, 2.76161999e-01f, -8.25291425e-02f, -7.47574717e-02f, 7.20489770e-03f,
  -1.43414840e-01f, 1.54566243e-01f, 7.11880475e-02f, 2.02545866e-01f, 1.98678330e-01f, 9.06091649e-03f, 3.81987654e-02f, 1.33135781e-01f, -6.67135119e-02f, 1.36670619e-01f,
  1.27779081e-01f, 9.35259089e-02f, -1.13645904e-01f, 1.25213906e-01f, 7.89140388e-02f, 3.85162272e-02f, 1.01777606e-01f, 1.96404472e-01f, -1.08928144e-01f, 1.58302635e-01f,
  2.17817694e-01f, 2.50500977e-01f, 7.61939213e-02f, -1.26798898e-01f, -9.58118439e-02f, -1.50404334e-01f, -3.74120921e-01f, 1.46257728e-01f, -1.87902361e-01f, 1.40149787e-01f,
  1.42390013e-01f, 8.06398515e-04f, -8.01875368e-02f, 1.81324333e-01f, -5.40276989e-03f, -7.08554015e-02f, 4.15293165e-02f, 7.74174482e-02f, -3.71030457e-02f, -8.75469148e-02f,
  1.34399429e-01f, 5.88537902e-02f, 6.41836552e-03f, -3.11112329e-02f, -3.59384120e-02f, 4.08452637e-02f, -1.25684574e-01f, 2.66731173e-01f, 8.09104368e-02f, 6.49135262e-02f,
  1.37251005e-01f, -8.65211412e-02f, -1.01702645e-01f, -6.29373733e-03f, 5.29669523e-02f, 2.30193119e-02f, -1.27308533e-01f, -1.43986613e-01f, 2.15458408e-01f, -1.73656106e-01f,
  -1.01458304e-01f, 1.16509609e-01f, 2.98906565e-01f, 5.97969592e-02f, 1.07173532e-01f, 1.85268134e-01f, 1.33527815e-01f, 5.11793047e-02f, 6.97144195e-02f, 9.55057293e-02f,
  1.03136465e-01f, 9.41334218e-02f, -2.99615995e-03f, 4.14282270e-02f, 1.01807222e-01f, 1.39859058e-02f, 1.64695561e-01f, 4.70934026e-02f, 5.84603734e-02f, 1.60793900e-01f,
  2.38154102e-02f, -2.32782722e-01f, 8.47377032e-02f, 3.12353298e-02f, -3.11171450e-03f, -1.54194951e-01f, -1.41988382e-01f, 2.96398867e-02f, 8.25213790e-02f, 2.43963208e-03f,
  2.98076928e-01f, -9.87030938e-02f, 2.13453889e-01f, 8.12285319e-02f, 2.73324549e-01f, -1.96125552e-01f, 4.95258085e-02f, 2.35450819e-01f, 2.15574890e-01f, -5.74351028e-02f,
  2.60453194e-01f, -2.40295067e-01f, -1.35830164e-01f, 1.11910932e-01f, -5.41606247e-02f, -1.16020136e-01f, 9.28863417e-03f, -1.23424888e-01f, -2.18916759e-01f, -3.16653103e-02f,
  -1.78222060e-01f, -1.28583014e-01f, -7.67900571e-02f, 4.89109978e-02f, 7.77211487e-02f, 6.37638196e-02f, 8.67400542e-02f, 3.62595052e-01f, -2.38547087e-01f, -2.62812465e-01f,
  1.97749376e-01f, -1.64254867e-02f, -3.01882159e-02f, 2.86798060e-01f, -1.38678208e-01f, -1.09580725e-01f, -8.16617832e-02f, 7.52046332e-03f, -2.38360152e-01f, 1.36347458e-01f,
  -8.62716138e-02f, -2.32654847e-02f, -5.54864593e-02f, 1.00882247e-01f, -7.11022466e-02f, -6.01299368e-02f, 1.54592246e-01f, 6.06101230e-02f, -1.37803271e-01f, -8.45109075e-02f,
  6.63533388e-03f, 1.84029769e-02f, -1.56997889e-01f, 1.14270169e-02f, -4.34435122e-02f, 2.63985526e-02f, -2.92936843e-02f, -1.12933032e-01f, -9.62610096e-02f, -1.66160781e-02f,
  4.27599847e-02f, -9.46881175e-02f, -5.86604215e-02f, -5.21021604e-04f, 2.59262901e-02f, 2.05891039e-02f, -5.99680729e-02f, -1.09128855e-01f, -4.72729281e-02f, 2.45706946e-01f,
  7.79529810e-02f, -1.98975593e-01f, -1.26017079e-01f, 1.06777690e-01f, -1.76538616e-01f, 7.38461167e-02f, 1.15012556e-01f, -9.78507251e-02f, 5.95308840e-02f, 1.24720093e-02f,
  1.52432024e-01f, 9.77336913e-02f, 1.61994919e-01f, 2.19468046e-02f, 3.16987932e-01f, 6.97197691e-02f, 9.47106332e-02f, 3.32762972e-02f, -6.05428517e-02f, 8.84910971e-02f,
  -6.33582356e-04f, -9.10393894e-02f, 1.87582836e-01f, 1.93377107e-01f, 2.64310669e-02f, 1.63808763e-01f, -4.98673245e-02f, -1.12128422e-01f, 1.04955800e-01f, 2.13248298e-01f,
  -1.54101297e-01f, 5.46345189e-02f, 3.07746351e-01f, 2.47489903e-02f, -1.30633265e-02f, 1.34394015e-03f, 6.80120960e-02f, -7.03353249e-03f, 1.51393056e-01f, -5.70772141e-02f,
  5.95130771e-02f, 7.61662498e-02f, 3.80208604e-02f, 6.85346946e-02f, 1.93950370e-01f, 1.56391039e-02f, 3.14510241e-02f, 1.17375441e-01f, -2.69716512e-02f, 1.05612896e-01f,
  -4.19549942e-02f, 1.31200328e-01f, -1.37022167e-01f, 1.62948761e-02f, -8.21694136e-02f, 5.25431000e-02f, 3.61467265e-02f, 1.52694523e-01f, 1.45249337e-01f, 1.70170873e-01f,
  8.21725745e-03f, 1.24955244e-01f, -2.87945755e-02f, 1.87195122e-01f, 2.49057233e-01f, 3.11771054e-02f, 2.38369063e-01f, 1.22993596e-01f, 2.04992712e-01f, -7.53975958e-02f,
  4.53900769e-02f, 1.87842607e-01f, 1.44290403e-01f, -8.93287137e-02f, -1.70399174e-01f, -1.35406867e-01f, -8.22735801e-02f, -1.05782211e-01f, 2.82741755e-01f, 7.50549361e-02f,
  9.97104123e-03f, 6.51595294e-02f, 5.79810375e-03f, 1.82357445e-01f, 7.21901208e-02f, -1.21410877e-01f, 1.08613297e-01f, 8.02616999e-02f, 1.08216435e-01f, 8.78804922e-02f,
  2.90266834e-02f, -7.08640218e-02f, -2.01336309e-01f, 2.65326798e-01f, -4.04537506e-02f, 2.70435698e-02f, 1.62366614e-01f, -1.59850270e-01f, 1.74662650e-01f, 1.31387219e-01f,
  5.14273942e-02f, 1.20056793e-01f, 1.57124043e-01f, 1.72403362e-02f, 1.27907349e-02f, 7.32679069e-02f, 1.29221365e-01f, 1.09090365e-01f, 9.25306380e-02f, 8.69263895e-03f,
  7.91162346e-03f, -8.15450549e-02f, 3.09445839e-02f, -5.40510155e-02f, 2.82357037e-02f, -4.30225506e-02f, -7.10912496e-02f, -4.21695299e-02f, 5.26174530e-02f, 1.51906312e-01f,
  8.59222412e-02f, 4.42014225e-02f, 3.07561010e-01f, -1.65274054e-01f, 2.16592789e-01f, 4.15894352e-02f, 6.97181672e-02f, -3.37280333e-02f, 1.97108695e-03f, 1.18178926e-01f,
  -1.01203565e-02f, 9.29132998e-02f, 1.20007172e-01f, 1.16566733e-01f, 1.56670660e-01f, 6.88664541e-02f, -7.49779642e-02f, -9.03724283e-02f, 1.00087002e-01f, -8.40525106e-02f,
  -6.48939935e-03f, 3.83500047e-02f, -7.51017556e-02f, -8.59928653e-02f, -9.58908051e-02f, 2.03030016e-02f, 2.09692754e-02f, -1.14499390e-01f, -2.89209210e-03f, 9.66005325e-02f,
  -6.81191459e-02f, -1.16949759e-01f, -1.49684958e-02f, 9.93974656e-02f, -2.54862756e-02f, 1.59058377e-01f, 2.04300687e-01f, -1.33862510e-01f, 3.59273478e-02f, 2.97470149e-02f,
  -1.14723250e-01f, 1.25982255e-01f, 6.14361987e-02f, 1.73966646e-01f, 1.44049302e-01f, 3.50120850e-02f, -1.17641196e-01f, 8.41746628e-02f, -7.35933036e-02f, 4.59296368e-02f,
  1.59452513e-01f, 3.38026397e-02f, -1.97442740e-01f, 4.56524231e-02f, 8.39454159e-02f, -5.83563047e-03f, 1.29973844e-01f, 1.75317109e-01f, 6.12511067e-03f, 1.06943540e-01f,
  1.81587368e-01f, 2.11191669e-01f, 1.01800017e-01f, 6.08052080e-03f, 1.86686162e-02f, -1.97366193e-01f, -1.63623556e-01f, -3.19471955e-02f, 9.83052179e-02f, 9.16872695e-02f,
  1.26415402e-01f, -6.00673109e-02f, -2.54128948e-02f, 8.65045711e-02f, -3.81177589e-02f, 4.72640358e-02f, -4.32406068e-02f, 1.69741258e-01f, 8.11910778e-02f, -8.54769573e-02f,
  -1.23551749e-01f, -1.73577949e-01f, -5.12409210e-02f, -1.36256725e-01f, -2.01246694e-01f, 1.41491428e-01f, -1.66481093e-01f, 2.94705480e-01f, 8.40282217e-02f, 3.95751223e-02f,
  1.29295334e-01f, -1.66843459e-01f, -7.25702345e-02f, 1.44847050e-01f, -2.03783825e-01f, 8.41539875e-02f, -8.59292522e-02f, 1.60094760e-02f, 1.88257247e-01f, 1.68054737e-02f,
  4.98898886e-03f, 1.95771270e-02f, 3.62857193e-01f, 3.53656150e-02f, 8.92366767e-02f, 6.46724403e-02f, -8.60445958e-04f, -1.54043790e-02f, 1.66906402e-01f, -1.12364152e-02f,
  6.87948689e-02f, 4.83653508e-02f, 9.83343571e-02f, 1.43716976e-01f, -3.09095327e-02f, 7.53679872e-02f, 4.96900305e-02f, 4.29087840e-02f, 8.10775608e-02f, 2.01202542e-01f,
  2.99995467e-02f, 4.67040762e-02f, -6.47325292e-02f, 2.17911631e-01f, -8.96184053e-03f, 3.63880303e-03f, -7.88798928e-02f, -9.49857607e-02f, -8.48377794e-02f, 4.18803133e-02f,
  8.73468816e-02f, 1.01266749e-01f, -7.84173831e-02f, 1.32915135e-02f, -5.02507053e-02f, 1.10662267e-01f, 2.44489223e-01f, 1.03609726e-01f, 2.77677685e-01f, 8.18213820e-02f,
  1.59253448e-01f, -1.84815928e-01f, -6.01295643e-02f, 9.28613991e-02f, 1.78224429e-01f, -2.11954787e-01f, -2.04333618e-01f, -1.73934117e-01f, -2.22124234e-01f, -1.69887275e-01f,
  2.15115994e-01f, 2.74736553e-01f, 1.84220403e-01f, 9.30428281e-02f, 1.42362893e-01f, 1.38803869e-01f, 6.11713156e-03f, 2.23017745e-02f, 2.04462255e-03f, 1.06591452e-02f,
  1.62899390e-01f, -1.87911354e-02f, -3.12921894e-03f, -6.74692690e-02f, -2.32709289e-01f, 2.64001369e-01f, 4.49475609e-02f, 8.47275332e-02f, 2.15833217e-01f, -1.43583596e-01f,
  5.73657406e-03f, 1.04908049e-01f, -4.80804518e-02f, 2.70289462e-02f, 1.05877213e-01f, 4.28816676e-02f, 1.87020317e-01f, 7.06092566e-02f, -6.37289733e-02f, 1.43970236e-01f,
  1.28789609e-02f, -2.18044929e-02f, -1.76551834e-01f, -2.96650734e-02f, -3.83758582e-02f, 1.29116327e-01f, 1.50748258e-02f, -2.30663881e-01f, -3.61121148e-02f, 3.75862718e-02f,
  -5.64136654e-02f, -1.05505958e-01f, 5.11241518e-02f, -7.46452659e-02f, 1.98114216e-02f, 1.45702809e-01f, -1.54089776e-03f, -7.59208873e-02f, -7.80520290e-02f, 1.79423556e-01f,
  2.13526562e-03f, -1.88466758e-01f, -1.21479444e-01f, 1.83161080e-01f, -1.94474265e-01f, 1.73694625e-01f, 1.43306211e-01f, 6.57636225e-02f, 9.73827690e-02f, 1.80384889e-01f,
  1.79140434e-01f, 1.63459420e-01f, 2.77938694e-01f, 1.83409393e-01f, 1.74191251e-01f, -1.62464052e-01f, -2.27064323e-02f, -5.51619660e-03f, -1.36275411e-01f, 1.51361927e-01f,
  1.87670311e-03f, -1.74905375e-01f, 3.37235659e-01f, 2.31593966e-01f, 9.38498899e-02f, 1.13592803e-01f, -6.34616939e-03f, -1.41612843e-01f, 1.17646262e-01f, 1.24981552e-02f,
  1.72694959e-02f, -1.51347518e-02f, 1.52849719e-01f, -4.88875210e-02f, 1.37921050e-01f, 2.05064446e-01f, 5.03786840e-02f, -7.48862773e-02f, 2.51532979e-02f, 4.18935195e-02f,
  -3.56239527e-02f, -3.16957049e-02f, 3.24819647e-02f, 1.63962260e-01f, -8.87424685e-03f, 1.20205872e-01f, 6.93673044e-02f, 8.82782266e-02f, 1.21230260e-01f, 8.40989798e-02f,
  2.19605155e-02f, 3.02642360e-02f, 1.58184484e-01f, 2.10158318e-01f, -6.97117820e-02f, 1.87174848e-03f, 6.80697039e-02f, -1.03967711e-01f, -1.42320201e-01f, 1.83267683e-01f,
  -5.24276830e-02f, 2.44465262e-01f, 1.55661583e-01f, -8.90855491e-02f, -8.07048976e-02f, 2.28376806e-01f, 5.46519905e-02f, -2.66246335e-03f, -2.23689936e-02f, 1.33568393e-02f,
  -2.10922640e-02f, 1.06041700e-01f, -3.58103961e-03f, -2.54080445e-02f, -3.36927809e-02f, -9.39975381e-02f, -1.47162294e-02f, 1.40615508e-01f, -2.17011884e-01f, 9.07519013e-02f,
  -5.50703844e-03f, -1.50561839e-01f, -2.87055294e-03f, -1.39526995e-02f, -9.71039832e-02f, 1.35332286e-01f, 5.78237101e-02f, 4.79135849e-02f, 9.17001516e-02f, -9.86788049e-02f,
  1.62962586e-01f, -1.15851074e-01f, -2.69685715e-01f, -2.54421867e-02f, 2.32074380e-01f, -1.42922655e-01f, -2.92985849e-02f, 1.48084939e-01f, 7.09870383e-02f, -7.34050013e-03f,
  1.01800896e-01f, 1.73442945e-01f, 1.50993884e-01f, -1.76714137e-02f, 1.23230025e-01f, 1.58261545e-02f, 8.83132964e-02f, -1.86340231e-02f, 4.86709066e-02f, 1.01738818e-01f,
  4.92346622e-02f, -1.18335605e-01f, -6.83260337e-02f, -8.26298520e-02f, -1.23648860e-01f, -3.47467810e-02f, -6.37001917e-03f, -1.85945183e-02f, 5.56576662e-02f, -3.32896151e-02f,
  -1.93861648e-01f, 2.88548078e-02f, -5.82878850e-02f, 1.20106958e-01f, -3.82223763e-02f, -3.55932117e-02f, -2.06204746e-02f, -9.25165862e-02f, 4.64306882e-04f, 1.49219786e-03f,
  -5.76749258e-02f, -9.97689590e-02f, 1.16795368e-01f, 7.61135528e-03f, -5.33790886e-02f, -1.43165067e-01f, 1.09153986e-01f, 2.36593992e-01f, 9.56840217e-02f, 2.80363739e-01f,
  3.27666938e-01f, 3.69515531e-02f, 5.40660694e-03f, 6.04918301e-02f, 1.07881837e-01f, 8.72398838e-02f, 9.11744982e-02f, -2.74924189e-03f, 1.83654994e-01f, -1.12441376e-01f,
  1.64140016e-01f, -3.15258512e-04f, -1.66469350e-01f, -1.42729074e-01f, -3.63865569e-02f, -9.39795282e-03f, 2.07747057e-01f, -3.40142590e-03f, -1.51221126e-01f, 5.83997183e-02f,
  -6.47363439e-02f, 1.24008618e-02f, 3.06112114e-02f, -1.50503544e-03f, 1.52416423e-01f, 2.61135101e-02f, 1.04688607e-01f, -4.21932116e-02f, 4.93948013e-02f, -7.66426837e-03f,
  1.81521162e-01f, -6.14442155e-02f, 2.07928270e-01f, 4.86932732e-02f, 2.15096503e-01f, -4.41075638e-02f, -7.38832355e-02f, -2.37745047e-02f, -1.59243658e-01f, 2.26537064e-01f,
  -1.30336016e-01f, -2.34001670e-02f, -1.72037911e-02f, 7.06803352e-02f, -1.65263444e-01f, 9.72436070e-02f, -2.37713978e-02f, 1.44459620e-01f, -1.46478593e-01f, 1.21007994e-01f,
  -2.77873017e-02f, -9.49544425e-04f, 2.20601887e-01f, 8.85934532e-02f, 2.57456571e-01f, -1.41504034e-01f, 3.14715207e-01f, -1.52133495e-01f, -1.58693805e-01f, -6.10742606e-02f,
  1.73904106e-01f, 1.26262441e-01f, -1.68213695e-01f, 4.01374511e-02f, 5.02121355e-03f, -1.73852384e-01f, 4.27356368e-04f, -5.19608380e-04f, 6.79309443e-02f, 1.55416146e-01f,
  1.78075433e-01f, -3.86413224e-02f, 1.50963500e-01f, -1.10954940e-01f, -9.95663851e-02f, -1.01203747e-01f, -1.67780817e-01f, -1.46610215e-01f, 8.42125565e-02f, 1.11241817e-01f,
  4.52932063e-03f, 7.79124349e-02f, -1.58831328e-01f, 1.93484455e-01f, -1.21401854e-01f, 1.62965357e-02f, 1.02256592e-02f, 3.32395546e-02f, 1.77445859e-01f, 9.83001813e-02f,
  -1.47676483e-01f, 5.67054078e-02f, -1.76630449e-02f, 6.02381490e-02f, 1.30619900e-02f, -8.65745023e-02f, -3.58705670e-02f, -2.01110691e-02f, 4.36976179e-02f, 7.99270794e-02f,
  9.79072899e-02f, 3.43146585e-02f, -1.25085607e-01f, 1.67696923e-01f, 1.22313403e-01f, 1.89037636e-01f, 1.14390373e-01f, -8.91887993e-02f, -1.62748650e-01f, -1.84947848e-02f,
  -8.81981775e-02f, -2.29959991e-02f, -4.97153960e-02f, -2.90887095e-02f, -2.68101953e-02f, 2.17524961e-01f, 1.21174119e-01f, 4.48730290e-02f, -3.87650542e-02f, -2.06742465e-01f,
  2.59487214e-03f, -8.08765516e-02f, -1.25183567e-01f, -8.73862281e-02f, -6.15335219e-02f, -2.04496682e-01f, -6.45186603e-02f, -1.78625509e-01f, -2.08868966e-01f, -1.04354791e-01f,
  1.78731188e-01f, 4.41238940e-01f, 1.35541663e-01f, 1.14746191e-01f, 1.39192790e-01f, -4.23030294e-02f, -5.89627698e-02f, 2.11546780e-03f, -8.80530104e-02f, 1.20349176e-01f,
  -5.53489290e-03f, -1.53836282e-02f, 7.57835014e-03f, -3.50590460e-02f, -5.97928911e-02f, 1.56106368e-01f, 6.89017251e-02f, 8.69964138e-02f, 3.34584326e-01f, 9.48203281e-02f,
  1.09051608e-01f, 1.53790146e-01f, 1.25812158e-01f, -1.50201814e-02f, 6.60028215e-03f, 1.08972177e-01f, -4.85966764e-02f, 1.79863460e-02f, 1.67776048e-01f, 1.19969063e-01f,
  -7.89290220e-02f, -6.81209785e-05f, 2.79237311e-02f, -1.33625969e-01f, 1.61931634e-01f, 1.68302506e-01f, 5.48794307e-02f, 2.10412256e-02f, 1.26878396e-01f, 1.72959164e-01f,
  1.55313641e-01f, 1.55535802e-01f, 6.21782392e-02f, -9.73539352e-02f, 2.68178396e-02f, 5.18950485e-02f, 1.42145514e-01f, 1.04321830e-01f, 3.08681838e-02f, 1.11855874e-02f,
  -9.79902372e-02f, 9.51628909e-02f, -1.08828790e-01f, 9.96800289e-02f, -1.17714345e-01f, 2.62349099e-01f, 2.67683923e-01f, 1.41510991e-02f, -5.03426827e-02f, -1.56492487e-01f,
  1.01018369e-01f, -1.16965607e-01f, -7.82532170e-02f, 2.50618041e-01f, -1.46614224e-01f, 1.52676821e-01f, -2.10728627e-02f, -2.10584644e-02f, -1.43584879e-02f, -1.95097402e-01f,
  -1.82942614e-01f, 3.81398089e-02f, 2.62220018e-03f, 2.84392908e-02f, -8.02828595e-02f, 9.59551260e-02f, 9.01104137e-02f, -1.26648182e-02f, 1.35310560e-01f, -9.07915831e-02f,
  3.00560296e-01f, -5.22821359e-02f, 2.42240727e-03f, 9.96071026e-02f, 1.71767697e-01f, 1.06073752e-01f, 2.55380701e-02f, 1.27680346e-01f, 2.12163478e-01f, 9.00423154e-02f,
  2.56935060e-02f, 8.91269837e-03f, 1.95832938e-01f, 5.38756698e-02f, 5.43624349e-02f, 5.81756532e-02f, 1.42966332e-02f, -1.54764131e-01f, -9.76596922e-02f, -1.22586824e-01f,
  -3.55443247e-02f, -1.21447563e-01f, -1.04918934e-01f, -7.87208974e-02f, 6.48875162e-02f, 1.17664501e-01f, -4.19778824e-02f, -2.73374915e-02f, 1.92554325e-01f, 1.00629553e-01f,
  9.84932110e-02f, 8.68564770e-02f, 3.30127515e-02f, -9.24241543e-02f, -6.54884204e-02f, 1.41103223e-01f, 5.12931612e-04f, 5.22619188e-02f, 2.04231277e-01f, 1.23838849e-01f,
  1.45826712e-01f, -7.07325935e-02f, 6.25073835e-02f, 2.50062734e-01f, 2.26654798e-01f, 2.13168189e-01f, 2.78062224e-01f, 1.82833895e-01f, -1.33118376e-01f, -2.06771031e-01f,
  -5.93828186e-02f, 4.05378044e-02f, 1.08347759e-01f, -7.34149888e-02f, 9.19880792e-02f, 1.34615302e-02f, 7.25637004e-02f, -9.81292054e-02f, -1.71170682e-01f, 1.51307052e-02f,
  -3.58783230e-02f, 1.53014868e-01f, 2.25780159e-01f, -1.47498608e-01f, -7.93623477e-02f, 8.92047584e-03f, -2.48767748e-01f, 1.40223354e-01f, 7.88707659e-02f, 2.30601733e-03f,
  9.76458844e-03f, 4.40345295e-02f, -3.07810232e-02f, 1.07984617e-01f, 1.28305122e-01f, 1.07559673e-01f, 7.87619650e-02f, 2.48479154e-02f, -4.64647301e-02f, 1.91335212e-02f,
  -5.57866618e-02f, -1.89549983e-01f, -4.91901115e-03f, -2.58060247e-01f, -3.34088467e-02f, -6.22247458e-02f, 8.09055418e-02f, -1.75578520e-01f, 2.28485628e-03f, -1.60745546e-01f,
  -5.86172938e-02f, -1.53689489e-01f, 3.03706918e-02f, -4.95147742e-02f, 1.24949113e-01f, -2.46024624e-01f, 2.94516440e-02f, 3.48473303e-02f, -1.53459281e-01f, -1.47142395e-01f,
  -1.57112017e-01f, -5.74472398e-02f, -1.01007991e-01f, -6.37247637e-02f, -9.97954793e-03f, -3.42849419e-02f, -1.30589560e-01f, 1.69703215e-01f, 2.98789330e-02f, 2.37658396e-01f,
  1.09030411e-01f, 1.15726970e-01f, -2.90838182e-02f, -3.55698690e-02f, 7.67895356e-02f, 1.39159039e-01f, 1.19675897e-01f, 3.85312028e-02f, 1.47185072e-01f, 1.05535559e-01f,
  -1.85552046e-01f, 4.83736582e-02f, 3.00505422e-02f, 8.70382637e-02f, -8.32946151e-02f, 2.08615199e-01f, 2.03940004e-01f, -1.65218279e-01f, 2.13135704e-02f, 9.78043750e-02f,
  -2.93907356e-02f, -7.60561675e-02f, 1.38542667e-01f, 1.10857949e-01f, 5.98035753e-02f, 9.09370556e-02f, 3.73601913e-02f, 7.18864277e-02f, 2.15584785e-02f, 9.23033953e-02f,
  1.63901314e-01f, 7.17112496e-02f, 2.54159141e-02f, 5.77427372e-02f, 1.68994144e-02f, -1.65686026e-01f, -2.46484168e-02f, -1.20914550e-02f, -8.59153941e-02f, -8.30990728e-03f,
  2.57421378e-03f, -3.60294431e-02f, 4.90325056e-02f, -1.45976515e-02f, -6.60015196e-02f, -1.58860497e-02f, 1.89097896e-02f, 1.33655772e-01f, -1.76018812e-02f, -6.96674362e-02f,
  -8.62930417e-02f, -4.98015136e-02f, -1.83239616e-02f, -4.79103146e-05f, -7.06800669e-02f, -3.83202434e-02f, 8.45890567e-02f, 7.17314184e-02f, 6.52198568e-02f, -8.01165178e-02f,
  4.41411585e-02f, 1.70235515e-01f, 5.01852520e-02f, 1.67016268e-01f, 1.90593153e-01f, 8.96940455e-02f, -1.04262330e-01f, 2.73674410e-02f, 5.31993210e-02f, 2.36859452e-02f,
  1.03789814e-01f, -9.12405029e-02f, 7.26136640e-02f, -9.10943002e-02f, 9.36145931e-02f, 5.89013239e-03f, -1.46360204e-01f, -4.91039976e-02f, -7.52277598e-02f, 2.38813646e-02f,
  1.90528393e-01f, -4.41769138e-02f, 4.17166501e-02f, 2.66898200e-02f, -5.09361178e-02f, 2.54403409e-02f, -8.93369913e-02f, 7.45588820e-03f, -5.83916605e-02f, -1.56882972e-01f,
  -3.42251025e-02f, -3.84649709e-02f, 1.49696404e-02f, 6.61804527e-02f, -1.24938197e-01f, 2.93572843e-02f, -1.08242482e-01f, -4.83502150e-02f, -2.02093393e-01f, 8.33681971e-02f,
  -1.32293016e-01f, 3.66595417e-01f, 1.07637145e-01f, 1.10399321e-01f, 1.35915443e-01f, 4.38752584e-02f, -1.21923357e-01f, -1.36055261e-01f, 2.21680939e-01f, -7.14540929e-02f,
  -2.59655952e-01f, 1.35744646e-01f, -5.96147031e-02f, 4.46002521e-02f, -8.85425583e-02f, -7.65602961e-02f, 1.05836153e-01f, -2.09485948e-01f, 1.27003342e-01f, 2.87302464e-01f,
  -1.23679914e-01f, 1.52659565e-01f, 2.20328718e-01f, 8.92550051e-02f, 1.84183374e-01f, -1.14381284e-01f, -1.58327356e-01f, 1.75701622e-02f, -1.11889154e-01f, 1.29301280e-01f,
  2.23546848e-02f, -1.24931172e-01f, 4.58727553e-02f, -5.34308553e-02f, -1.52548134e-01f, 1.70968056e-01f, -1.25182301e-01f, -2.97871605e-02f, 1.40322939e-01f, 2.39420477e-02f,
  -1.36568263e-01f, 2.58103106e-02f, 2.14270219e-01f, -1.25048786e-01f, -1.37300581e-01f, 2.52324611e-01f, 2.26238891e-01f, -1.15960643e-01f, -6.32895231e-02f, -2.36030430e-01f,
  6.56079203e-02f, 5.46601005e-02f, 9.79975760e-02f, -2.80866753e-02f, -8.73571541e-03f, 8.27655569e-02f, -1.10373408e-01f, -4.09949124e-02f, 7.51006752e-02f, 5.40359840e-02f,
  -7.43673667e-02f, 1.04574569e-01f, 6.65335655e-02f, 7.80154690e-02f, 8.40123519e-02f, 1.56101361e-01f, -2.37763841e-02f, 9.05422047e-02f, 1.43330082e-01f, 2.71709561e-01f,
  3.63096688e-03f, 2.45164707e-02f, 8.61666724e-02f, -1.80760324e-01f, -2.67455280e-01f, 1.97567806e-01f, -1.46791145e-01f, 2.38468692e-01f, 7.09249228e-02f, -9.76948589e-02f,
  -4.80162911e-02f, 2.52682745e-01f, -9.21572931e-03f, -4.52007800e-02f, -6.39826432e-02f, 1.40496790e-01f, -5.54395281e-03f, -3.03460993e-02f, 8.35006088e-02f, -2.13637504e-05f,
  1.31137580e-01f, -2.17102543e-02f, 7.62048066e-02f, 9.73648727e-02f, -1.67107522e-01f, 1.25768915e-01f, 3.53538804e-02f, -7.81561658e-02f, -4.39196303e-02f, -1.33959457e-01f,
  -1.80795789e-01f, 7.11127603e-03f, 1.00487910e-01f, 6.86842501e-02f, 1.95350535e-02f, -1.24434516e-01f, 2.27556512e-01f, -1.49561182e-01f, -1.11929171e-01f, -3.43311056e-02f,
  2.55540311e-01f, -8.39750171e-02f, -4.12560403e-02f, 2.40963534e-01f, 4.53235507e-02f, 1.58710614e-01f, -5.65214194e-02f, -7.60966614e-02f, 6.45735785e-02f, 9.88524221e-03f,
  -2.77576540e-02f, 1.21690438e-03f, -4.72035408e-02f, 8.93222615e-02f, 7.42237736e-03f, -2.71092681e-03f, -4.13532853e-02f, -9.51046217e-03f, 9.84461531e-02f, 5.58414906e-02f,
  4.58714217e-02f, -1.96779951e-01f, -5.30681685e-02f, 1.70638099e-01f, 8.85675624e-02f, 1.05536647e-01f, 6.14274815e-02f, -6.15581730e-03f, 1.35406867e-01f, 8.68130252e-02f,
  1.96475387e-02f, 1.31168336e-01f, -6.55321851e-02f, 1.10765651e-01f, -3.09853256e-02f, 1.67860501e-02f, -7.16656148e-02f, 1.47181302e-01f, -1.47628084e-01f, 1.58422962e-01f,
  1.07340209e-01f, 1.11637479e-02f, 8.95132571e-02f, 4.05107588e-02f, 2.01521799e-01f, -3.99608202e-02f, 1.04674041e-01f, 1.20982721e-01f, 4.64562923e-02f, -1.83865204e-01f,
  -1.85029745e-01f, -1.07443854e-01f, -1.54414639e-01f, 3.40610482e-02f, -8.51865858e-02f, -9.82696041e-02f, 2.21665978e-01f, 1.24211691e-01f, 1.92266822e-01f, 1.04900092e-01f,
  9.12263468e-02f, -9.75487679e-02f, -2.85712373e-03f, -6.11068681e-02f, -6.85953200e-02f, -5.65637723e-02f, 4.85072508e-02f, 7.65791461e-02f, 8.29657540e-02f, 9.36546847e-02f,
  1.16392702e-01f, 1.02367466e-02f, 2.04710692e-01f, -9.42559242e-02f, 5.93440086e-02f, 6.70657605e-02f, 8.37554336e-02f, 7.54976645e-02f, 1.94930166e-01f, -6.75213933e-02f,
  2.92964485e-02f, 5.66538312e-02f, -1.06332935e-01f, 2.99651176e-01f, -6.06863610e-02f, 1.98750362e-01f, -1.33837640e-01f, 1.92341767e-02f, 3.51703502e-02f, 1.47345111e-01f,
  7.58737233e-03f, 2.19593629e-01f, 2.67923251e-03f, 1.21486790e-01f, -5.30875511e-02f, 1.44570634e-01f, -1.95018604e-01f, 6.96505085e-02f, 2.33859628e-01f, 6.93994537e-02f,
  2.39795491e-01f, 2.03891963e-01f, 1.82429001e-01f, 1.37366578e-01f, 1.70270815e-01f, 2.49074046e-02f, 2.16184661e-01f, -7.50020668e-02f, -1.02259070e-01f, -7.46131241e-02f,
  8.19171369e-02f, -3.27721499e-02f, 2.64902979e-01f, 4.44035046e-02f, 3.37184593e-02f, -3.56293167e-03f, 7.91722685e-02f, 7.92718306e-03f, -2.94779781e-02f, -3.18018526e-01f,
  2.13245288e-01f, -3.83520424e-02f, -2.18394712e-01f, 4.94420081e-02f, 1.59958959e-01f, -1.11899972e-01f, 1.66984722e-02f, 2.94209212e-01f, -1.06614558e-02f, 1.00884989e-01f,
  6.02972060e-02f, -1.00958049e-01f, 1.03260025e-01f, 9.46483389e-02f, 1.18298240e-01f, -2.99895164e-02f, 2.17831463e-01f, 6.18454516e-02f, 1.43753797e-01f, 3.02171335e-03f,
  7.23062605e-02f, 1.76586941e-01f, 2.24373221e-01f, 6.10895380e-02f, -8.70839804e-02f, 6.49214610e-02f, 1.12836799e-02f, 3.65226492e-02f, 1.22777089e-01f, -6.46705702e-02f,
  -3.16397958e-02f, 2.60062627e-02f, -1.02738686e-01f, 8.88355225e-02f, 1.32775441e-01f, 1.26733229e-01f, 2.42641613e-01f, -1.00212626e-01f, 1.90983325e-01f, 7.93391541e-02f,
  1.11474777e-02f, 6.13435470e-02f, 3.67712826e-02f, 4.07292508e-03f, 8.04067105e-02f, 2.51578510e-01f, 1.08348928e-01f, 1.19889997e-01f, 1.34990498e-01f, 2.62361825e-01f,
  -3.04772146e-02f, -9.68994647e-02f, -8.98509696e-02f, -1.19842127e-01f, -1.46610990e-01f, 4.10888977e-02f, -1.91485882e-03f, -2.16534555e-01f, -7.61027485e-02f, -1.23345755e-01f,
  -6.09821305e-02f, 1.08202398e-01f, 5.99843897e-02f, 1.10993357e-02f, -1.37995407e-01f, 1.02525339e-01f, 2.62997210e-01f, 1.44157261e-01f, 4.98324744e-02f, 2.00167466e-02f,
  1.03004230e-03f, -9.33224410e-02f, -3.81747633e-02f, -1.65152885e-02f, -2.66262330e-02f, -1.37876928e-01f, -3.74660902e-02f, -8.98135267e-03f, 4.69823703e-02f, 9.23589468e-02f,
  2.24266220e-02f, 5.81137370e-03f, 1.04037024e-01f, 1.01674765e-01f, 6.29025921e-02f, -6.80205002e-02f, 2.41769687e-03f, 2.98594497e-02f, 5.53069077e-03f, 7.48413755e-03f,
  -1.93229411e-02f, -5.02438610e-03f, -8.61163363e-02f, 9.12587121e-02f, -2.50327657e-03f, 2.62210909e-02f, 2.33568829e-02f, -5.78519665e-02f, -1.35092571e-01f, 1.55552784e-02f,
  -1.57121629e-01f, 4.17496078e-02f, -9.61371064e-02f, -1.17633350e-01f, -8.90838876e-02f, 9.71570238e-02f, 1.04458839e-01f, -7.05563277e-02f, 6.53020218e-02f, -1.26161039e-01f,
  8.38175714e-02f, -6.12762496e-02f, -5.51157296e-02f, -3.59397717e-02f, 9.23462734e-02f, 1.06826052e-01f, -3.81303765e-02f, 5.93190640e-02f, 1.34867370e-01f, -1.26503736e-01f,
  1.61327258e-01f, 2.14807764e-01f, 1.65342882e-01f, 1.46214902e-01f, 1.56017393e-01f, 3.24475244e-02f, 1.23651735e-01f, -1.02469832e-01f, 8.35607797e-02f, -1.04720080e-02f,
  -1.26411438e-01f, -2.41794921e-02f, -4.23701406e-02f, -2.06374377e-02f, 7.65583813e-02f, 2.23925248e-01f, -5.16267121e-02f, 1.20712444e-01f, 1.36824891e-01f, -8.85845814e-03f,
  1.05128549e-01f, 6.09650873e-02f, 4.72954847e-02f, 6.61474690e-02f, -4.39240374e-02f, 1.20793939e-01f, -5.98256849e-02f, -4.90916707e-03f, 6.27552420e-02f, 5.51431738e-02f,
  -6.29360527e-02f, 3.24882194e-02f, 5.48512414e-02f, -3.66640501e-02f, 8.96796063e-02f, 7.55534507e-03f, -2.45277975e-02f, -6.02714112e-03f, 8.52901787e-02f, 1.67223036e-01f,
  6.82092980e-02f, 3.73042189e-02f, 7.11807534e-02f, -1.36412829e-01f, -3.63036282e-02f, 9.70173031e-02f, 2.78838780e-02f, 1.02290556e-01f, 7.86863789e-02f, -1.03597403e-01f,
  -9.87130627e-02f, 1.48339882e-01f, -9.47495177e-02f, -1.17810592e-02f, -6.25928789e-02f, 6.67889565e-02f, 5.88514097e-02f, -1.29918411e-01f, 7.38242418e-02f, 5.06171659e-02f,
  2.38830909e-01f, 2.47573946e-03f, 5.56726903e-02f, 1.97063178e-01f, -1.78986982e-01f, 1.12670459e-01f, -6.34541214e-02f, -2.56721564e-02f, 2.34073047e-02f, -1.42821550e-01f,
  -1.08727723e-01f, 8.71852785e-02f, 1.36501163e-01f, -2.68332474e-02f, -8.93846601e-02f, -7.14485273e-02f, 7.08117560e-02f, -1.96204204e-02f, 5.02922498e-02f, -5.93628697e-02f,
  1.40301585e-01f, -7.08929673e-02f, -4.92207557e-02f, 2.90761352e-01f, 1.19288027e-01f, 1.14691854e-02f, -2.11486612e-02f, 1.05015330e-01f, -3.11998967e-02f, 1.85583964e-01f,
  1.12894826e-01f, 1.28970116e-01f, 1.54376626e-01f, -5.17090410e-02f, -2.28569098e-03f, 1.52473986e-01f, -5.89582473e-02f, -1.11504249e-01f, -2.28714291e-03f, -2.71241874e-01f,
  7.20250085e-02f, -1.39540508e-01f, 1.62729800e-01f, -8.30829069e-02f, -1.71551798e-02f, -2.19235376e-01f, -8.04207772e-02f, -2.43689626e-01f, 1.74508744e-03f, 5.16245402e-02f,
  1.65126637e-01f, -9.22577903e-02f, 1.65872097e-01f, -1.75945520e-01f, -2.49192581e-01f, -3.96935157e-02f, -1.80429399e-01f, -1.15642838e-01f, -1.30776182e-01f, -1.22366995e-01f,
  -1.26744881e-01f, -8.97367746e-02f, -9.94834378e-02f, 2.56337285e-01f, 1.82143122e-01f, 2.77918905e-01f, 1.35372669e-01f, 1.76569074e-01f, -2.41346046e-01f, 1.53680537e-02f,
  9.38309506e-02f, 6.71495497e-02f, 9.83650535e-02f, 8.05126652e-02f, 1.68628633e-01f, 1.66823730e-01f, -6.96657449e-02f, 9.59286690e-02f, 2.31458284e-02f, -1.05394283e-02f,
  -1.96263790e-02f, 1.54916704e-01f, 1.42646745e-01f, -2.11504981e-01f, 1.05730608e-01f, 6.27828762e-02f, -9.57870036e-02f, 1.74920157e-01f, 5.98843955e-03f, 4.82659377e-02f,
  6.69683004e-03f, -5.67932650e-02f, 1.13108233e-01f, 1.01528287e-01f, 1.57696113e-01f, 2.03961190e-02f, -9.48769376e-02f, 1.29770830e-01f, 9.75720510e-02f, 8.19645151e-02f,
  -9.00920108e-02f, 1.84337452e-01f, -1.65743865e-02f, 3.18263210e-02f, 5.78496046e-02f, 4.71073389e-02f, -7.30689466e-02f, -5.53091727e-02f, -2.02155992e-01f, -1.12407692e-01f,
  1.95145179e-02f, 6.69246390e-02f, 1.92277521e-01f, 2.17950046e-02f, 7.59712532e-02f, -5.14693409e-02f, 7.29014426e-02f, 1.08188957e-01f, 1.57174096e-01f, 8.45113322e-02f,
  2.49607295e-01f, 3.16672288e-02f, 1.25097603e-01f, -3.17607224e-01f, -1.34234905e-01f, 1.24057651e-01f, 1.07891090e-01f, -5.65411001e-02f, -1.69682741e-01f, -1.18079819e-01f,
  -1.62627071e-01f, -2.10333914e-01f, 2.20907450e-01f, -8.23639408e-02f, -5.98924309e-02f, -4.18402515e-02f, -7.86607265e-02f, 2.97794342e-01f, 4.83995788e-02f, -2.81665679e-02f,
  -1.13978647e-01f, 1.03617944e-01f, 2.86496460e-01f, -2.28834115e-02f, -1.27980828e-01f, -3.79938409e-02f, -3.50875199e-01f, 2.12667152e-01f, -2.34611392e-01f, -4.55529604e-04f,
  9.11790058e-02f, -1.54478535e-01f, 2.94229649e-02f, 6.64462848e-03f, -2.22740378e-02f, 3.15839499e-02f, 1.23517692e-01f, 7.99284428e-02f, 1.41144753e-01f, 1.53029591e-01f,
  -6.14394583e-02f, 1.58602327e-01f, 7.42549226e-02f, 5.65027632e-02f, -1.92625895e-01f, 9.12393555e-02f, 5.83568960e-02f, -6.87939208e-03f, 1.22633927e-01f, -2.09255457e-01f,
  -1.16624981e-02f, -5.05338386e-02f, -8.50930065e-02f, -1.51624069e-01f, 6.02751374e-02f, 5.16692176e-02f, 2.43935287e-01f, -4.91658673e-02f, 1.49868205e-01f, -1.50351778e-01f,
  -2.48717926e-02f, 1.25157699e-01f, -9.59977228e-03f, -1.65466145e-01f, -9.36705768e-02f, 1.81965917e-01f, -1.09778494e-01f, 2.00530048e-02f, 1.03371084e-01f, 8.33664760e-02f,
  -1.41559422e-01f, -8.58102217e-02f, 7.06519857e-02f, -3.31365429e-02f, -8.04346949e-02f, -4.97444570e-02f, 1.96535200e-01f, -1.32033408e-01f, -6.73410892e-02f, -1.36112332e-01f,
  -1.59444377e-01f, 1.39245525e-01f, -9.55799744e-02f, 1.49058355e-02f, -2.02514809e-02f, 8.03941861e-02f, 2.11471751e-01f, 7.77900070e-02f, -9.32098404e-02f, 4.77663148e-03f,
  1.20706232e-02f, -4.38693725e-02f, -8.50620717e-02f, -8.69448036e-02f, 1.28487036e-01f, -1.09908119e-01f, 1.00035490e-02f, -7.64183849e-02f, -1.70375835e-02f, 7.13874400e-02f,
  -5.15672006e-03f, -8.35535750e-02f, 1.16343215e-01f, 1.08087743e-02f, -2.13833936e-02f, -6.09207563e-02f, 1.03302337e-01f, -5.85101023e-02f, -3.21472697e-02f, 1.82045363e-02f,
  2.62611061e-02f, 7.45083019e-02f, 1.99218113e-02f, -8.93862918e-02f, -1.51391879e-01f, 4.12212797e-02f, 1.26878828e-01f, 6.66584596e-02f, -1.02528803e-01f, 1.22250780e-01f,
  1.64725423e-01f, -5.47494665e-02f, -8.68976787e-02f, -1.05158947e-01f, -6.53693825e-02f, 3.35212380e-01f, 6.58337921e-02f, -1.23657465e-01f, -1.19543932e-01f, 4.06868495e-02f,
  -1.00602612e-01f, 7.08085150e-02f, 6.73865601e-02f, 4.17701565e-02f, 2.68166140e-02f, -5.56067228e-02f, 1.01458155e-01f, -4.64072116e-02f, 6.36104494e-02f, -1.54822648e-01f,
  3.62177223e-01f, 6.67946041e-03f, 3.22957784e-02f, 5.20704128e-02f, -2.62815170e-02f, 1.98370051e-02f, 6.76238385e-04f, -1.82341814e-01f, 1.27470776e-01f, 1.68875322e-01f,
  1.14142247e-01f, 2.37958476e-01f, -6.48792386e-02f, -1.13242969e-01f, 9.31672305e-02f, 7.03541785e-02f, -1.96054623e-01f, 8.38614553e-02f, 2.95413047e-01f, -1.38942595e-03f,
  1.45967184e-02f, -1.00231804e-02f, 1.04320928e-01f, 1.65324241e-01f, 4.02733944e-02f, 4.55762679e-03f, 9.95079875e-02f, 1.38155550e-01f, 1.14671141e-01f, 8.27761739e-02f,
  6.66568503e-02f, 7.00235516e-02f, 5.74962497e-02f, -5.78794815e-02f, -6.92628622e-02f, 9.75905508e-02f, -5.71114346e-02f, 1.39075920e-01f, 3.50232748e-03f, -2.43602972e-02f,
  -6.36214092e-02f, -5.00478484e-02f, -1.19460873e-01f, 6.07603453e-02f, -1.85143068e-01f, 2.18679607e-02f, -1.32402167e-01f, -1.08638257e-01f, -8.02073628e-02f, -2.68245377e-02f,
  8.63206536e-02f, -2.46153083e-02f, 8.61559734e-02f, -9.65418518e-02f, 1.85075164e-01f, 4.39447016e-02f, 8.58399831e-03f, 5.50520681e-02f, 1.22618698e-01f, 8.07278007e-02f,
  -6.37535378e-02f, 9.71948430e-02f, 8.18420798e-02f, -1.28370196e-01f, 1.31190464e-01f, 3.19631308e-01f, 2.08809316e-01f, 5.61762042e-02f, 1.69482440e-01f, -9.00781229e-02f,
  1.07200049e-01f, -1.82582915e-01f, 1.07431501e-01f, -8.38448927e-02f, -2.81494051e-01f, -8.50814953e-03f, -2.90846583e-02f, -9.59050208e-02f, 1.74519211e-01f, 2.18340844e-01f,
  -2.14469973e-02f, 1.18965790e-01f, 7.27738664e-02f, 1.02232629e-02f, 8.01468715e-02f, 2.58193593e-02f, -2.62062084e-02f, -9.08100791e-03f, 1.73161879e-01f, -1.32406447e-02f,
  3.50923352e-02f, -7.53736570e-02f, 7.03082234e-02f, -1.52410241e-02f, 1.12579733e-01f, -1.95592716e-02f, -9.97071061e-03f, 3.28000076e-02f, 6.23337366e-03f, -2.79140491e-02f,
  -3.77073959e-02f, -1.12461671e-01f, -8.20860937e-02f, 3.55491485e-03f, 2.56984979e-02f, 1.22474089e-01f, -1.06816806e-01f, 1.14729911e-01f, 2.09753782e-01f, 4.11263481e-02f,
  -1.50683582e-01f, 4.46297191e-02f, -1.98445283e-02f, 1.36252388e-01f, -1.24671292e-02f, 1.00886431e-02f, -6.94191530e-02f, -3.03680655e-02f, 6.11045733e-02f, 2.91769262e-02f,
  -5.82889318e-02f, 1.00670770e-01f, 3.43987346e-02f, 1.90591201e-01f, 5.76109327e-02f, 6.47982582e-02f, 1.13138430e-01f, -9.70413387e-02f, 1.59666955e-01f, -2.00726941e-01f,
  3.17517505e-03f, -2.03815307e-02f, -2.49647517e-02f, 6.19483367e-02f, 3.72133888e-02f, -1.28411755e-01f, 9.90063976e-03f, 1.07062787e-01f, 1.81170195e-01f, 1.29207298e-01f,
  -4.51064259e-02f, -5.55270389e-02f, 2.36840043e-02f, -7.31719062e-02f, -1.73181698e-01f, 7.40659162e-02f, 3.77113707e-02f, 5.73205668e-03f, 9.74134281e-02f, 1.45398766e-01f,
  2.37778556e-02f, -1.47929609e-01f, 1.02117874e-01f, -3.58965397e-02f, 7.91485608e-02f, 1.31208092e-01f, 7.77530596e-02f, 3.05855334e-01f, 7.11810738e-02f, -4.28171866e-02f,
  -9.69450548e-02f, 2.76838453e-03f, -9.58726257e-02f, 3.52835298e-01f, 1.20890774e-01f, 1.07143134e-01f, -2.32261233e-03f, 4.91787903e-02f, -5.19737750e-02f, 1.36009187e-01f,
  1.41610250e-01f, 1.13808438e-01f, 2.50901771e-03f, -2.51433086e-02f, 4.99518253e-02f, 4.84981984e-02f, -1.82341173e-01f, 9.56537649e-02f, 4.49648537e-02f, -1.86402038e-01f,
  5.19725941e-02f, 3.05216342e-01f, -1.83096509e-02f, 2.94203073e-01f, 4.22390103e-01f, 2.09749296e-01f, 1.30550917e-02f, -1.56741276e-01f, -2.26056039e-01f, -9.69000384e-02f,
  -6.01888373e-02f, 5.99083677e-02f, 1.39233787e-02f, -1.79797277e-01f, -5.52761853e-02f, -1.30404428e-01f, -1.19648039e-01f, 1.77945662e-02f, -7.26117343e-02f, -1.54405266e-01f,
  7.61585459e-02f, 1.02110496e-02f, -5.26142344e-02f, 9.96274725e-02f, 1.66472182e-01f, -1.35330543e-01f, 7.13896528e-02f, 5.85308783e-02f, 2.47594804e-01f, -8.48416612e-02f,
  -3.15231644e-02f, -2.79589921e-01f, 2.65246890e-02f, 9.35336798e-02f, 1.32405892e-01f, 7.17936978e-02f, 1.65382966e-01f, -5.46509959e-02f, 6.52438030e-02f, 1.15577698e-01f,
  1.19808882e-01f, 6.80019408e-02f, 2.12386370e-01f, -1.76683459e-02f, 1.14574865e-01f, -3.24323438e-02f, -4.39676046e-02f, -7.04863146e-02f, -8.44596624e-02f, 9.10248086e-02f,
  -1.71571508e-01f, -6.44969866e-02f, 4.98037413e-02f, 1.19356371e-01f, -1.08923934e-01f, 1.69787124e-01f, 2.06383303e-01f, -4.97908704e-03f, -3.82800438e-02f, -5.39688729e-02f,
  2.09273584e-03f, 9.14859921e-02f, 1.50350168e-01f, 2.83223251e-03f, 6.82018772e-02f, -5.20932525e-02f, 2.02719882e-01f, 1.90898050e-02f, -6.93703964e-02f, 1.19428135e-01f,
  -2.34951805e-02f, 5.87318167e-02f, -7.48471841e-02f, -3.22850682e-02f, -2.18618959e-02f, -1.95838615e-01f, 1.82977706e-01f, -2.36236639e-02f, 3.30072008e-02f, 6.13838881e-02f,
  8.91058072e-02f, 1.94567107e-02f, 8.50656703e-02f, -1.13549344e-01f, -1.00829467e-01f, -1.99789293e-02f, 3.91001813e-02f, 1.09293628e-02f, -9.39273983e-02f, 7.06134811e-02f,
  7.76869506e-02f, 7.77892619e-02f, -2.02217802e-01f, 6.44306913e-02f, 7.01400125e-03f, -5.60267232e-02f, 2.47180816e-02f, -2.11351048e-02f, 8.15585554e-02f, 3.85332555e-02f,
  1.48128003e-01f, 6.93111941e-02f, 1.00147203e-01f, -3.53421364e-03f, 8.50168094e-02f, 1.89375374e-02f, 2.31645152e-01f, 5.26253544e-02f, 1.10381708e-01f, 5.92173301e-02f,
  2.41173785e-02f, -2.13733107e-01f, -1.46022802e-02f, -1.33548845e-02f, -1.19502500e-01f, -1.21510968e-01f, 7.87107646e-02f, 1.33952558e-01f, 1.07949683e-02f, 9.33384225e-02f,
  3.04456621e-01f, -8.76035392e-02f, 1.66111454e-01f, 6.63476204e-03f, 1.61150232e-01f, 1.12728462e-01f, 1.29907236e-01f, 1.82237208e-01f, 8.92369151e-02f, -1.04348727e-01f,
  1.75260872e-01f, -1.51551470e-01f, -5.95430546e-02f, 4.83385324e-02f, -8.93873274e-02f, -1.39212951e-01f, -9.82572325e-03f, -1.14204459e-01f, -1.22950271e-01f, -1.24335743e-01f,
  1.44386753e-01f, -1.17415255e-02f, -1.06645845e-01f, 1.24710642e-01f, 1.09814495e-01f, 6.10519052e-02f, 4.21852320e-02f, 1.47861332e-01f, -1.74803197e-01f, -8.43537822e-02f,
  2.21025065e-01f, 1.43971235e-01f, -5.00415564e-02f, 1.80831596e-01f, -4.21907119e-02f, -9.07317456e-03f, -1.05614714e-01f, 3.32491621e-02f, 2.80226506e-02f, 7.62872919e-02f,
  8.50165412e-02f, 1.02840215e-02f, 2.76573524e-02f, -6.06929213e-02f, -6.91372380e-02f, 1.54968172e-01f, 9.32274535e-02f, 5.20800240e-03f, -4.36751917e-02f, 1.01629950e-01f,
  -3.20408680e-02f, 5.70510104e-02f, -3.71000692e-02f, 4.07767072e-02f, 1.42200887e-01f, -1.36193037e-01f, 1.46845385e-01f, -1.01452015e-01f, 1.27674177e-01f, 5.50806373e-02f,
  -1.78954005e-02f, -1.74240340e-02f, 1.13075368e-01f, -2.21597522e-01f, 7.18363076e-02f, -1.83905095e-01f, 2.20966592e-01f, 6.56382814e-02f, 1.86447442e-01f, 1.32527292e-01f,
  -1.12764433e-01f, -1.99708920e-02f, -9.26568285e-02f, 1.06879450e-01f, -1.94021985e-01f, 2.76137684e-02f, -2.22273674e-02f, 1.15405060e-01f, -2.86302447e-01f, -1.97807610e-01f,
  1.15987532e-01f, -1.29164875e-01f, -1.96470097e-01f, 8.16234797e-02f, -5.61460219e-02f, -1.73266735e-02f, -1.14226237e-01f, 4.42233905e-02f, -3.28003392e-02f, 1.31390348e-01f,
  -2.24589910e-02f, 3.99464577e-01f, -2.25908071e-01f, 1.47604913e-01f, 2.87732631e-01f, 5.37051223e-02f, 1.10632963e-01f, 2.19062254e-01f, -6.69669583e-02f, -1.40656888e-01f,
  2.27957308e-01f, -4.93678004e-02f, 1.33113638e-01f, 2.20265538e-02f, 5.71504049e-02f, 9.94321480e-02f, 4.60149944e-02f, 1.31580755e-01f, -2.34473366e-02f, 1.26177430e-01f,
  5.36331274e-02f, 4.80957180e-02f, 1.63232297e-01f, 7.08514005e-02f, -1.27976298e-01f, 9.16261524e-02f, 7.08774403e-02f, -2.80253664e-02f, 6.46166354e-02f, 6.12544678e-02f,
  2.67479522e-03f, 4.96248193e-02f, 1.82108074e-01f, 7.74621591e-02f, 5.83193153e-02f, -2.10294183e-02f, 3.00300904e-02f, -2.04102352e-01f, -1.00107282e-01f, -2.89360080e-02f,
  4.57137115e-02f, 3.74019369e-02f, 1.26870424e-01f, -1.39871597e-01f, -1.40111491e-01f, 1.24324612e-01f, -1.13243081e-01f, -6.68066069e-02f, -4.71373200e-02f, 5.66796027e-02f,
  3.32673229e-02f, -1.41636595e-01f, -6.78182691e-02f, -5.71609773e-02f, 1.52595520e-01f, 1.73690021e-02f, -6.31703138e-02f, 1.55669942e-01f, -2.05333933e-01f, 1.85816243e-01f,
  3.12560908e-02f, 5.15005700e-02f, 1.36115760e-01f, -1.56507611e-01f, -7.69572705e-02f, 1.15135536e-01f, -1.04698867e-01f, 1.36861606e-02f, -5.56976236e-02f, -5.02584204e-02f,
  8.90958980e-02f, 9.79490206e-02f, 9.15582031e-02f, -1.22510575e-01f, 2.80937105e-01f, -5.03202006e-02f, -4.62885462e-02f, 2.28738278e-01f, 9.44850817e-02f, 1.24385014e-01f,
  9.09247100e-02f, 6.14917986e-02f, 1.34676218e-01f, 5.28507344e-02f, 5.33184670e-02f, -1.45366684e-01f, 6.43379316e-02f, 8.18947554e-02f, 1.93485275e-01f, 7.36652240e-02f,
  7.29685053e-02f, 1.56085819e-01f, 9.13912281e-02f, -1.38795571e-02f, 5.16825095e-02f, -1.39421821e-01f, -3.03206202e-02f, 1.47114784e-01f, -9.44337249e-02f, 1.47258520e-01f,
  3.76664251e-02f, 7.32785016e-02f, 5.03392294e-02f, 1.29174203e-01f, 1.98039524e-02f, 3.06876779e-01f, 1.63529709e-01f, 6.89583048e-02f, -6.03469983e-02f, 2.74276137e-01f,
  6.11772165e-02f, -6.42023236e-02f, 4.51505706e-02f, -2.14310177e-02f, -1.23068362e-01f, 7.73066729e-02f, 1.06859371e-01f, 2.57568508e-02f, 1.19402714e-01f, -9.59738642e-02f,
  8.14769566e-02f, -1.98952463e-02f, -2.94016525e-02f, -1.70688599e-01f, -1.94203988e-01f, -1.71546713e-01f, -1.41388163e-01f, 2.28701606e-02f, -1.71363843e-03f, 5.75664714e-02f,
  6.99252114e-02f, 1.64026592e-03f, 2.73825526e-01f, -4.79359999e-02f, 1.60057262e-01f, -4.23703231e-02f, -2.20792338e-01f, -1.33959532e-01f, -9.11906138e-02f, -1.08421959e-01f,
  4.39240364e-03f, 2.11754680e-01f, 3.47730033e-02f, 3.51806991e-02f, 2.84801628e-02f, 8.08663592e-02f, -2.03274060e-02f, 6.19773492e-02f, 7.60061890e-02f, 1.28532901e-01f,
  6.85925484e-02f, -4.10734713e-02f, -3.25796828e-02f, 1.08708121e-01f, -4.60212156e-02f, -1.23478904e-01f, 7.64949471e-02f, -1.70775428e-01f, -1.06600784e-01f, -9.36410669e-03f,
  1.58735678e-01f, -5.72598316e-02f, 9.22196954e-02f, -2.07036391e-01f, -2.12545604e-01f, -1.84701145e-01f, -1.56811953e-01f, -2.80506294e-02f, 4.11504135e-02f, -2.66485482e-01f,
  -5.53905740e-02f, 1.66451752e-01f, -9.58636403e-02f, -2.04489410e-01f, -2.35391349e-01f, -1.28710330e-01f, -5.00023291e-02f, -5.12969308e-02f, -9.80108082e-02f, -1.10701397e-01f,
  -1.46197185e-01f, 6.08103238e-02f, 1.54020218e-02f, 1.87900573e-01f, 1.19341619e-01f, 7.68447369e-02f, 1.19705401e-01f, 2.54624933e-01f, 1.84056088e-01f, 1.61511168e-01f,
  1.76891863e-01f, 2.43698787e-02f, 1.17556624e-01f, 4.47301939e-02f, -6.80584386e-02f, 1.91341802e-01f, 1.63219161e-02f, -5.65288961e-02f, -7.87104368e-02f, 1.21057503e-01f,
  2.21927002e-01f, 4.95450832e-02f, 1.19831555e-01f, 1.32558122e-01f, 2.51588643e-01f, -1.09207243e-01f, 3.08183450e-02f, -7.74892885e-03f, 4.54303399e-02f, 1.15358748e-01f,
  6.16794936e-02f, -1.05000651e-02f, -4.55920584e-03f, 8.71318355e-02f, 1.02996990e-01f, -2.76302770e-02f, 3.62370838e-03f, -6.17066175e-02f, -8.75856541e-03f, -2.26611212e-01f,
  -3.07329819e-02f, -1.07259639e-01f, 1.37264505e-02f, -1.16196312e-01f, -1.00658409e-01f, -1.32592335e-01f, 1.31622836e-01f, 1.02092251e-01f, 5.76400943e-02f, 1.03814267e-02f,
  9.53172669e-02f, -1.78060800e-01f, 1.68845713e-01f, -9.07702148e-02f, -6.62327744e-03f, 3.71055491e-03f, -8.44619051e-03f, -3.78113277e-02f, -1.69633374e-01f, 9.11956504e-02f,
  -8.10972974e-03f, 2.19193563e-01f, 2.22290456e-01f, -7.14608356e-02f, -1.08364955e-01f, -2.17179637e-02f, 1.32122412e-01f, 1.54917864e-02f, 5.29862680e-02f, 1.12996496e-01f,
  -1.95789840e-02f, -1.13022216e-01f, -7.77262971e-02f, 6.65249527e-02f, 7.48317838e-02f, -1.72143295e-01f, -4.27534804e-02f, 8.91716629e-02f, -2.82624364e-02f, -9.53476727e-02f,
  -1.45227119e-01f, 1.20141514e-01f, -5.99284619e-02f, 1.43642753e-01f, 3.62693489e-01f, -1.00844242e-01f, 3.13165747e-02f, 8.26071575e-02f, -5.12303226e-02f, 1.85806360e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  1.39612004e-01f, 3.81237976e-02f, 1.74453855e-02f, 1.01517290e-01f, 1.26285896e-01f, 5.41526340e-02f, 5.32216206e-02f, 5.32825142e-02f, 8.32621604e-02f, 5.29117137e-02f,
  7.15034455e-02f, 8.22735876e-02f, 1.04444683e-01f, 1.71390362e-02f, 9.17909667e-02f, 9.25982371e-02f, 2.82874629e-02f, 1.02412164e-01f, 2.70409323e-02f, 4.73342650e-02f,
  7.81793222e-02f, -5.77201992e-02f, 1.24935150e-01f, 1.21228792e-01f, 9.49728042e-02f, 9.92572010e-02f, 9.69624296e-02f, 9.54629108e-02f, 7.36362785e-02f, -4.04023267e-02f,
  1.64222673e-01f, 1.17998281e-02f, 1.20675460e-01f, 1.26327038e-01f, 9.82069299e-02f, 1.16062902e-01f, 4.63883318e-02f, 4.64974059e-04f, 9.95415524e-02f, 2.97518894e-02f
};

// L2_fan_Wp (Shape: 12 x 64)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  8.25753063e-02f, 9.95399356e-02f, 6.00262098e-02f, 1.00170746e-01f, -3.66299525e-02f, 9.97835323e-02f, 1.33459847e-02f, -4.25374471e-02f, 3.45904641e-02f, 4.66907993e-02f,
  6.77639619e-02f, 7.68792480e-02f, -8.46699402e-02f, 1.05427176e-01f, 7.68806636e-02f, 1.25245780e-01f, 1.36623889e-01f, 1.48925662e-01f, 1.55842766e-01f, -8.55846182e-02f,
  1.50958329e-01f, -4.58001345e-03f, -3.16842459e-02f, -9.42131877e-02f, 5.23029193e-02f, -2.20104828e-02f, -3.16776056e-03f, -1.88178327e-02f, 1.13748334e-01f, -2.20528129e-03f,
  4.39712852e-02f, -1.16731543e-02f, 1.30304461e-02f, 4.86463346e-02f, -2.44003683e-02f, -6.89945072e-02f, 3.64235044e-02f, 1.15943760e-01f, 1.68961823e-01f, -6.76695779e-02f,
  -2.30126940e-02f, 1.84811324e-01f, 6.25708029e-02f, -1.81307197e-01f, -1.18626237e-01f, -5.31689636e-02f, -1.30048722e-01f, 6.39797747e-03f, 1.56358004e-01f, -4.44985293e-02f,
  1.47786215e-01f, 3.72355357e-02f, 6.03973074e-03f, 3.66684794e-02f, 3.35574858e-02f, 1.95995383e-02f, -1.78637654e-01f, 8.35254937e-02f, 1.29711494e-01f, 1.16329655e-01f,
  3.74674015e-02f, -5.88549040e-02f, 2.22937271e-01f, 2.14005150e-02f, -2.82688662e-02f, 3.32230143e-02f, 1.95684507e-02f, -8.33083317e-02f, -6.45046309e-02f, -4.32047844e-02f,
  -1.25104119e-03f, -1.52726900e-02f, 2.09734477e-02f, -4.01357487e-02f, -6.53903410e-02f, 5.23198256e-03f, 4.26769555e-02f, -5.44128083e-02f, -3.26502919e-02f, -9.65104401e-02f,
  -1.99983991e-03f, -1.13090612e-01f, -8.98587629e-02f, 4.32554223e-02f, -5.11823446e-02f, 2.01304480e-02f, -3.50807384e-02f, 7.02787116e-02f, -9.10613164e-02f, -4.40684147e-02f,
  1.18536809e-02f, 8.77908468e-02f, -6.39655814e-02f, -2.32739728e-02f, 6.57661771e-03f, -6.85496721e-03f, 3.31895351e-02f, -7.68799707e-02f, 3.03384643e-02f, 3.41570824e-02f,
  -4.84416746e-02f, -4.96540777e-02f, -9.77822393e-02f, 3.08245458e-02f, -2.34815478e-02f, -1.46827430e-01f, 6.22523017e-03f, 1.59447178e-01f, 7.02390894e-02f, 1.62141956e-02f,
  8.17890167e-02f, 1.31096151e-02f, -1.13309376e-01f, 1.27757087e-01f, -1.32645503e-01f, -2.43071700e-03f, -2.86192745e-02f, -1.01484574e-01f, -9.34404954e-02f, -8.90518352e-02f,
  1.11071710e-02f, -1.80686295e-01f, -1.56677440e-01f, -6.22246750e-02f, 6.58516660e-02f, 2.97240019e-02f, -1.62911236e-01f, -3.69891599e-02f, 1.02222152e-02f, -3.51905413e-02f,
  -1.47582020e-03f, -2.65616626e-02f, -8.21843147e-02f, -1.42129455e-02f, -8.96285400e-02f, -1.88122541e-02f, 3.40518504e-02f, 1.64121184e-02f, 3.55553664e-02f, 1.52638054e-03f,
  -8.89950711e-03f, -1.88272223e-02f, -4.10626680e-02f, -1.17130606e-02f, 1.14136904e-01f, -7.82406703e-02f, -3.51588503e-02f, -1.00851342e-01f, -4.98870574e-02f, -8.27197060e-02f,
  -9.47481990e-02f, 2.81132408e-03f, -7.87829310e-02f, 2.52389647e-02f, -2.44237222e-02f, 1.75270215e-01f, -4.95119169e-02f, 3.32535291e-03f, -4.77511175e-02f, -4.45841476e-02f,
  1.47077098e-01f, -2.58583259e-02f, -1.13636971e-01f, 8.95863473e-02f, -3.61133218e-02f, -6.43740892e-02f, 1.10713527e-01f, 8.61651748e-02f, -3.21197622e-02f, -1.31782023e-02f,
  -5.60146698e-04f, 1.29999444e-01f, 1.49197102e-01f, -6.73346892e-02f, -7.64454305e-02f, -6.29303530e-02f, 2.77968515e-02f, 6.74257427e-02f, 3.54345292e-02f, -1.09418720e-01f,
  -8.87405202e-02f, -9.47269574e-02f, 1.14686936e-02f, -1.28144622e-01f, -1.77218188e-02f, -1.44981518e-01f, -1.38938859e-01f, 8.68993849e-02f, 1.21544883e-01f, -1.07050918e-01f,
  2.46652495e-03f, 1.33730238e-02f, 9.30550918e-02f, 4.53903899e-03f, 2.92694625e-02f, -2.13116985e-02f, 8.15426931e-03f, 2.39371024e-02f, 1.79862529e-02f, -9.16654840e-02f,
  1.77914500e-02f, -4.04335745e-02f, 4.92066368e-02f, -1.92002859e-02f, 9.36127901e-02f, -1.09935217e-01f, 2.73438822e-02f, 7.21259341e-02f, 7.91535992e-03f, -5.88877276e-02f,
  4.72970419e-02f, -1.39183318e-03f, -6.26811162e-02f, 8.17167945e-03f, -4.87923585e-02f, 1.18988700e-01f, 5.30485213e-02f, -5.30026481e-02f, 8.33785310e-02f, -1.04592353e-01f,
  1.92421377e-01f, -9.07752588e-02f, -1.55063393e-02f, 3.21588144e-02f, -8.58779773e-02f, -1.89905185e-02f, 2.73000300e-02f, 1.30268008e-01f, -4.25579101e-02f, 1.27274869e-03f,
  -1.26920864e-01f, 1.18465209e-02f, 5.63012064e-02f, -4.15558107e-02f, -8.08873549e-02f, -3.72835696e-02f, 1.48708820e-01f, 1.35463789e-01f, -5.84249496e-02f, 1.07821956e-01f,
  -1.15123071e-01f, 1.13476597e-01f, -3.60177248e-04f, 9.84805599e-02f, -3.30951787e-03f, -8.78545493e-02f, -9.91388485e-02f, -5.27259782e-02f, -8.20001215e-02f, -4.75009484e-03f,
  -2.47762259e-02f, -2.94861123e-02f, 3.11308876e-02f, 1.63058847e-01f, -1.75205857e-01f, -8.52760747e-02f, -4.44254372e-03f, -7.80529983e-04f, 2.94492785e-02f, -4.33123484e-02f,
  -4.58469652e-02f, 2.77598631e-02f, 5.41611612e-02f, -7.14809597e-02f, -4.47263978e-02f, 1.85137000e-02f, -3.13526429e-02f, -3.27174999e-02f, -7.95846507e-02f, 2.77723316e-02f,
  9.85181406e-02f, 6.11418076e-02f, 5.80601022e-02f, 1.30084343e-02f, 3.81607488e-02f, 5.20440098e-03f, -3.21525522e-02f, -6.41279761e-03f, 4.91449237e-02f, -9.53700021e-02f,
  6.37717098e-02f, -1.20421849e-01f, -9.53968838e-02f, -3.20662111e-02f, 6.09316938e-02f, 4.71650027e-02f, 1.41313985e-01f, -9.05880332e-02f, -5.03600715e-03f, 2.07085982e-01f,
  -1.57273486e-02f, 4.95559024e-03f, 2.38256119e-02f, -5.03629446e-03f, 1.63931370e-01f, -4.74550910e-02f, -1.76058859e-01f, -2.71539241e-02f, -1.34468181e-02f, 2.15973035e-02f,
  -7.86605105e-02f, -9.90073383e-02f, 9.43414494e-02f, 2.66268570e-03f, 7.22148195e-02f, -6.96785226e-02f, -6.04613423e-02f, 1.52778164e-01f, 4.82381396e-02f, 1.16293691e-01f,
  5.47262728e-02f, 2.28994247e-02f, 2.58572772e-02f, -1.99439526e-02f, 7.91338235e-02f, 2.16295719e-02f, -1.16992146e-02f, -2.43337937e-02f, 1.13736004e-01f, -8.78188610e-02f,
  -1.05690822e-01f, -6.41953051e-02f, -7.60328397e-02f, -3.62434089e-02f, -7.74213523e-02f, -6.28647655e-02f, 2.89675384e-03f, -9.88749191e-02f, -6.56654313e-02f, -1.17188394e-01f,
  -1.96148634e-01f, -8.60189050e-02f, -1.51041467e-02f, -1.36168553e-02f, -1.33745112e-02f, -1.07161917e-01f, 4.53942604e-02f, -4.77589481e-02f, -3.80730778e-02f, 1.79079305e-02f,
  -5.14444150e-02f, 4.56231758e-02f, -7.91993737e-02f, -5.99915441e-03f, -1.33180276e-01f, -1.25063017e-01f, -1.39162660e-01f, -1.10293981e-02f, -2.06028834e-01f, -8.00194442e-02f,
  -7.72382990e-02f, -8.39789286e-02f, 6.75007775e-02f, -3.19950543e-02f, -1.29999921e-01f, -4.93348651e-02f, -9.38554257e-02f, -9.25933048e-02f, -1.85567774e-02f, 1.74244177e-02f,
  -1.86183080e-01f, -1.55322418e-01f, -9.56253633e-02f, 4.47140224e-02f, -5.24061322e-02f, -9.17217508e-02f, 2.01133117e-02f, -1.25518993e-01f, -4.44578938e-02f, -2.84511782e-02f,
  -1.94777280e-01f, -1.47826254e-01f, -1.21966459e-01f, -1.49194792e-01f, 2.19068248e-02f, -2.22965971e-01f, 1.03308111e-01f, -1.99809253e-01f, -1.21620104e-01f, -5.52431457e-02f,
  -4.50188890e-02f, -1.71712965e-01f, -1.27005935e-01f, -2.28689238e-02f, 4.55966927e-02f, -3.40245897e-03f, 6.41723350e-02f, -7.29995221e-02f, -1.64364427e-02f, 1.30174644e-02f,
  6.26290739e-02f, -5.51789254e-02f, 2.44973064e-03f, 2.81378441e-02f, -5.90838213e-03f, -9.64371637e-02f, -7.40057901e-02f, -1.30303860e-01f, 1.01433787e-02f, -1.81916114e-02f,
  3.79403159e-02f, 2.34784279e-02f, 5.41198486e-03f, -1.32066980e-02f, -5.75835630e-02f, -1.49647221e-01f, 1.41067982e-01f, -7.19797239e-02f, -5.84303774e-02f, 6.93558827e-02f,
  -1.18259996e-01f, 1.54182985e-01f, -4.92829159e-02f, -1.48402508e-02f, 5.94785027e-02f, -9.46262777e-02f, 1.44622251e-01f, 1.23063818e-01f, 1.57208238e-02f, 5.77123761e-02f,
  -1.07554950e-01f, -1.28372401e-01f, 1.47571504e-01f, 6.85504153e-02f, -2.22882420e-01f, -3.58442254e-02f, -3.82607169e-02f, 8.88466239e-02f, 1.71286911e-01f, 1.02926731e-01f,
  -8.01077709e-02f, 1.36323825e-01f, -3.82650718e-02f, -4.50767800e-02f, 4.41709906e-03f, 1.23845711e-01f, 1.01870090e-01f, 1.62311215e-02f, -4.84807789e-02f, 3.26273963e-02f,
  6.17911294e-02f, 1.97725315e-02f, -5.39757572e-02f, 1.80617288e-01f, 3.96714639e-03f, 1.20781325e-02f, 4.37873565e-02f, -1.40136063e-01f, -4.78910692e-02f, 3.04262079e-02f,
  -2.64652893e-02f, 4.31881547e-02f, -2.35250220e-03f, -8.69227424e-02f, -2.18078196e-02f, -2.33757123e-02f, -7.60637820e-02f, -4.80516441e-02f, -1.19856641e-01f, -2.40515992e-02f,
  6.84874803e-02f, -8.62603076e-03f, -1.31029457e-01f, -1.10672303e-02f, -1.32513419e-01f, 6.59019547e-03f, 5.07314354e-02f, -9.20401141e-02f, -8.08001235e-02f, -1.03656314e-01f,
  1.21519985e-02f, 1.06465630e-01f, -1.18213877e-01f, 9.94381458e-02f, -4.11007255e-02f, -1.43999279e-01f, -3.86670269e-02f, 8.63220915e-02f, -2.02406924e-02f, 3.49373370e-02f,
  -5.53172594e-03f, -6.21235184e-02f, 1.05818786e-01f, -5.55723310e-02f, -1.80454150e-01f, -2.16942757e-01f, -5.92204146e-02f, 1.06753428e-02f, -1.63625218e-02f, 1.38695883e-02f,
  -1.56297222e-01f, 1.45308942e-01f, -1.31942838e-01f, 9.84599069e-02f, -4.95497473e-02f, 1.54335737e-01f, -1.05994880e-01f, -1.99176427e-02f, -5.11115305e-02f, -4.43109088e-02f,
  1.61127016e-01f, 6.48528859e-02f, -1.74386203e-01f, -1.05061606e-01f, 2.00286880e-01f, -8.54760706e-02f, 2.28880364e-02f, 1.47392675e-01f, -5.53220101e-02f, 2.32701413e-02f,
  -1.16634712e-01f, 6.31925315e-02f, 5.40811270e-02f, -2.01846864e-02f, -2.97196899e-02f, 9.62805226e-02f, -2.60127950e-02f, 1.25497757e-02f, 2.91110575e-02f, 4.62528318e-02f,
  4.65145446e-02f, -2.84896269e-02f, 1.16391638e-02f, 2.70753559e-02f, 4.60362062e-02f, -4.03234735e-02f, -8.53006989e-02f, -4.30367962e-02f, 5.29441647e-02f, -3.84158902e-02f,
  -1.99581794e-02f, -1.34489700e-01f, 5.19437343e-03f, -2.67536845e-02f, -1.84013341e-02f, 1.12880781e-01f, -3.20648327e-02f, 1.82956029e-02f, 1.19773582e-01f, -7.54750520e-02f,
  1.21102504e-01f, -3.26252952e-02f, -1.58720076e-01f, 1.17095776e-01f, -1.22545129e-02f, -1.59771010e-01f, -1.23969838e-02f, -2.84349942e-03f, -8.33431184e-02f, -1.19375661e-01f,
  -1.44660875e-01f, 2.46499348e-02f, 6.92105293e-02f, -7.81138688e-02f, -1.08852945e-02f, -1.53179377e-01f, 7.59540871e-02f, 6.60451129e-02f, -1.49624869e-01f, -3.75188813e-02f,
  -1.28639936e-01f, 7.91193619e-02f, 6.93874434e-02f, -1.15713075e-01f, 9.19890404e-02f, -3.60742621e-02f, -1.21867381e-01f, 2.10319459e-02f, -1.22229792e-01f, -1.06382847e-01f,
  -1.73634738e-02f, -1.84461512e-02f, 3.50876153e-02f, 8.82595554e-02f, -1.71301678e-01f, 1.94736235e-02f, 8.99898782e-02f, -2.77999621e-02f, -4.16676924e-02f, -6.26693442e-02f,
  -9.27035660e-02f, 1.12432986e-01f, 1.92636754e-02f, -6.33442998e-02f, 7.69401118e-02f, -7.39567564e-04f, -4.88840118e-02f, 1.93124805e-02f, 4.35131565e-02f, -5.13707334e-03f,
  9.04739648e-03f, -2.04815306e-02f, 1.36582851e-02f, -1.29719913e-01f, 5.79519160e-02f, 1.57604024e-01f, -1.16035296e-02f, -1.01009449e-02f, -4.42220010e-02f, 9.14426520e-03f,
  1.75591093e-02f, -1.12281993e-01f, -3.85229439e-02f, 9.72779393e-02f, -3.63625102e-02f, 1.57061424e-02f, 1.04269512e-01f, -5.27390316e-02f, 1.19211376e-01f, 1.81204587e-01f,
  -4.78789695e-02f, 1.09247275e-01f, 2.35551945e-03f, 1.84748366e-01f, 7.63754770e-02f, 4.77650948e-02f, 8.85336921e-02f, -1.36703476e-01f, 3.03983595e-02f, 5.64628541e-02f,
  1.33609563e-01f, 7.43817985e-02f, 1.98215961e-01f, -3.81895304e-02f, 6.52680499e-03f, 9.95288566e-02f, -1.99317917e-01f, 5.41382544e-02f, -1.65641859e-01f, -4.81737964e-03f,
  3.00474348e-03f, -1.49160763e-03f, 3.87319177e-02f, -3.45071964e-02f, 7.16555342e-02f, -6.23945482e-02f, 2.42479681e-03f, -2.29288731e-03f, -1.71347205e-02f, -1.04431510e-02f,
  4.26008068e-02f, 3.60994339e-02f, -3.29131000e-02f, -7.64094060e-03f, 1.55580398e-02f, -1.22848727e-01f, -6.36413172e-02f, 9.24012735e-02f, 7.61596533e-03f, -5.83900139e-02f,
  -4.41020215e-03f, -3.59659083e-02f, 8.01801980e-02f, -8.89604911e-02f, -9.46548879e-02f, -3.75604220e-02f, -1.63798574e-02f, 7.34245852e-02f, -8.05204362e-02f, -5.60267158e-02f,
  5.00880629e-02f, 2.20897552e-02f, -2.00860971e-03f, 1.13865703e-01f, -4.07211483e-02f, 7.77511746e-02f, 1.73760012e-01f, -4.36497666e-02f, -5.03782146e-02f, -4.63364311e-02f,
  -1.26097620e-01f, 1.00167923e-01f, -6.62183017e-02f, -2.75849074e-01f, 4.19504158e-02f, 9.17317048e-02f, 5.39616048e-02f, -5.54704107e-02f, -1.48123026e-01f, 8.92610550e-02f,
  1.53767049e-01f, 6.94768969e-03f, 9.29340795e-02f, -5.64250760e-02f, 8.49983096e-02f, 1.05400316e-01f, -1.69073939e-01f, -1.12230994e-01f, -4.98250760e-02f, 1.21058352e-01f,
  8.12997669e-02f, -2.20822975e-01f, -5.37041835e-02f, -1.10068917e-01f, -7.38761798e-02f, -1.35163181e-02f, -9.50754713e-03f, -3.27785388e-02f, -7.92342573e-02f, 5.77770881e-02f,
  4.23899703e-02f, 3.71224210e-02f, -4.20029880e-03f, 1.09731011e-01f, 7.12869167e-02f, 8.73693544e-03f, 1.53373545e-02f, 1.80753972e-02f, 3.25659029e-02f, 5.27201630e-02f,
  -9.67036467e-03f, 3.12738260e-03f, 7.62995034e-02f, -1.38159068e-02f, 3.44519205e-02f, -2.52489303e-03f, 7.42264837e-02f, 3.76039185e-02f, -7.82364085e-02f, -1.02998830e-01f,
  -6.76323101e-02f, -2.20406931e-02f, 4.42755222e-02f, -2.68336926e-02f, 3.02032083e-02f, -2.17970107e-02f, -7.33875707e-02f, 1.49992313e-02f, -9.93116125e-02f, 1.12190798e-01f,
  9.22219530e-02f, 3.53260711e-02f, -2.91469395e-02f, 9.03364504e-04f, -2.72643603e-02f, 5.52052967e-02f, 4.31300551e-02f, -1.70840189e-01f, 1.30983189e-01f, 2.94508617e-02f,
  1.03644552e-02f, -5.74916862e-02f, -9.97144654e-02f, 1.61378548e-01f, 8.14458430e-02f, -6.47679344e-02f, 4.72945645e-02f, 8.47092569e-02f, 7.91668221e-02f, 9.16283354e-02f,
  3.01900022e-02f, 4.49895933e-02f, -4.73543145e-02f, 9.98327211e-02f, -1.67328678e-02f, -1.92817569e-01f, -7.34424442e-02f, -1.13731707e-02f, -1.09750144e-01f, -4.28685956e-02f,
  1.40055388e-01f, -9.94479656e-02f, -1.37361750e-01f, 4.56976108e-02f, 4.48426232e-02f, -1.29389269e-02f, -1.21720605e-01f, 1.30729258e-01f
};

// L2_fan_Wp_bar (Shape: 40 x 64)
const int L2_fan_Wp_bar_rows = 40;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  4.86807078e-02f, -3.49303670e-02f, 4.21591476e-02f, -4.68372926e-02f, 2.66216584e-02f, 5.12346551e-02f, 6.22151308e-02f, -6.93270713e-02f, 4.99186441e-02f, 1.23882862e-02f,
  1.64786000e-02f, -1.14069236e-02f, 6.93336427e-02f, 4.28015813e-02f, 6.32623658e-02f, 9.75095779e-02f, 1.27264559e-02f, -5.83300926e-02f, -7.43004978e-02f, -1.08229175e-01f,
  -2.06592277e-01f, -1.36322647e-01f, 1.53075576e-01f, 1.02378018e-01f, -5.56168072e-02f, 7.92905912e-02f, -7.74047673e-02f, -6.18000329e-02f, 1.89475149e-01f, 1.55368261e-02f,
  1.10213952e-02f, 2.80820746e-02f, 1.19504370e-02f, 1.01558276e-01f, 7.78075159e-02f, 7.78013319e-02f, -1.60461560e-01f, -9.76113901e-02f, -1.93749100e-01f, -2.96664480e-02f,
  -8.71537402e-02f, -2.31109113e-02f, -1.23304844e-01f, 2.76651263e-01f, -4.51191096e-03f, 6.78198338e-02f, -5.38898259e-02f, 6.95218295e-02f, -7.85193369e-02f, 6.28428487e-03f,
  5.38746640e-02f, 1.87892109e-01f, 8.65836293e-02f, -1.38841569e-01f, -8.06185082e-02f, -1.59948692e-01f, 1.93041340e-01f, -8.09259787e-02f, -7.09097087e-02f, 1.95098355e-01f,
  8.14951211e-03f, 1.20494096e-02f, -1.72490746e-01f, -7.19772503e-02f, 2.53714491e-02f, 3.49938609e-02f, 5.68265915e-02f, 4.60712984e-02f, 1.09569520e-01f, 2.85005569e-02f,
  -1.16112726e-02f, 8.97401199e-02f, -5.09135844e-03f, 1.30228922e-01f, -4.83496487e-02f, 1.04805846e-02f, -5.12850732e-02f, 6.12211600e-02f, -4.00496051e-02f, 1.29417153e-02f,
  -1.07073635e-01f, 1.34302750e-01f, 2.43744869e-02f, -4.30060774e-02f, 6.92219287e-03f, -9.14296694e-03f, 1.25307307e-01f, 3.50921415e-02f, 7.36697093e-02f, 1.66643679e-01f,
  3.70101072e-02f, -2.93995529e-01f, 3.19354050e-02f, 1.88436314e-01f, 1.09725893e-01f, 1.24527626e-01f, -1.10498868e-01f, 7.15919510e-02f, 2.36913621e-01f, -9.37310159e-02f,
  -8.49278346e-02f, -1.40227914e-01f, -9.58741754e-02f, -7.52321258e-02f, -3.11432555e-02f, 8.08413252e-02f, -3.82277444e-02f, 2.90841181e-02f, -1.90218315e-01f, 1.01808660e-01f,
  1.61815733e-02f, 2.27609858e-01f, -7.07654580e-02f, -1.26340419e-01f, 8.07434767e-02f, 1.43816069e-01f, 3.24407101e-01f, 2.06203356e-01f, -1.10260062e-01f, 1.11642286e-01f,
  1.84524238e-01f, 5.90942577e-02f, 1.59946635e-01f, 9.13406685e-02f, -4.49096560e-02f, -3.77437472e-02f, 4.18315381e-02f, 7.86715746e-02f, 1.29842967e-01f, 6.72485828e-02f,
  3.54196434e-03f, 1.88143775e-01f, 6.73914701e-02f, 6.88765422e-02f, -2.10213643e-02f, 1.34833708e-01f, 1.27512887e-01f, 1.07465439e-01f, 5.82366772e-02f, 6.68414384e-02f,
  -6.88951910e-02f, 1.38344234e-02f, -8.92031193e-02f, -7.77595937e-02f, -8.09536651e-02f, 1.26392553e-02f, 1.32848307e-01f, 2.51324534e-01f, 2.28072822e-01f, 2.36361951e-01f,
  -1.26194298e-01f, 3.45330313e-02f, 1.37702256e-01f, 7.88028985e-02f, 2.84618437e-01f, -3.97348106e-02f, -2.58978549e-02f, -1.13627492e-02f, -8.82689189e-03f, 9.25375819e-02f,
  -1.38448477e-01f, -1.12088642e-03f, 4.50396864e-03f, -5.37015013e-02f, 2.00283110e-01f, 2.48516560e-01f, -9.23754051e-02f, 3.72052751e-02f, 1.86157957e-01f, -4.30734409e-03f,
  2.28229150e-01f, -2.00987011e-01f, -4.46237484e-03f, -2.06995942e-02f, 2.72417635e-01f, 2.54461379e-03f, 1.42013103e-01f, 1.34639621e-01f, -3.99562716e-02f, -1.28347665e-01f,
  -8.75882879e-02f, 1.00454642e-02f, 2.41514862e-01f, 7.92877078e-02f, 8.92619342e-02f, 2.04193234e-01f, 2.80454122e-02f, -3.52351606e-01f, -2.11293492e-02f, 7.91843608e-02f,
  -5.47557287e-02f, 2.03411415e-01f, 1.54988971e-02f, -1.34412954e-02f, -6.74266517e-02f, -2.88912538e-03f, -3.72650586e-02f, -4.80347909e-02f, -2.92450245e-02f, -7.68177584e-02f,
  -1.69615895e-02f, -6.33974820e-02f, 1.92987863e-02f, -9.04822052e-02f, -1.01807803e-01f, -7.30955228e-02f, 1.42088056e-01f, 1.68778989e-02f, 2.07324531e-02f, -6.92413077e-02f,
  -4.07960154e-02f, 4.35912795e-02f, 6.65996373e-02f, 1.90661982e-01f, -1.15830056e-01f, -4.88959141e-02f, -6.57513589e-02f, -1.72522932e-01f, 2.15915173e-01f, 2.02795058e-01f,
  -1.64919794e-01f, 9.79404449e-02f, -1.35311102e-02f, -1.69108555e-01f, -8.08637142e-02f, 2.24828944e-02f, 1.30727246e-01f, 7.54482597e-02f, 2.49004647e-01f, 6.50289655e-02f,
  8.47618654e-02f, -4.50818725e-02f, 5.59578352e-02f, 5.33140972e-02f, 1.38382286e-01f, -6.94220373e-03f, 1.49682507e-01f, -8.50093737e-03f, -1.41846295e-02f, -2.80368626e-01f,
  1.20357081e-01f, 1.23080984e-01f, 1.96300924e-01f, -1.16267726e-01f, -1.89291611e-01f, -8.63947347e-02f, 1.26019686e-01f, -4.27029952e-02f, -2.28628770e-01f, -2.94627156e-02f,
  -1.46976948e-01f, -2.93539494e-01f, 8.83339718e-02f, 4.82071675e-02f, 1.74783766e-01f, -1.35283515e-01f, -2.71176528e-02f, -2.89924964e-02f, 2.31206045e-02f, -5.51497191e-02f,
  4.97417934e-02f, -4.35743630e-02f, 4.90454026e-02f, -1.04976848e-01f, -1.32571876e-01f, -2.16506775e-02f, 1.24367531e-02f, 8.88548885e-03f, -9.02719572e-02f, 5.55379912e-02f,
  1.78960636e-01f, 1.02129392e-01f, 3.34433429e-02f, 1.44007849e-02f, -1.18424989e-01f, 2.20233072e-02f, -2.08622999e-02f, 5.03876805e-02f, -2.25342400e-02f, -1.52726576e-01f,
  6.86373338e-02f, -1.51491627e-01f, -2.31615473e-02f, 1.23108611e-01f, -6.95105642e-02f, 1.46045566e-01f, 1.87170163e-01f, -1.46769613e-01f, -5.61349131e-02f, 2.19406605e-01f,
  1.15799904e-01f, -9.27198306e-02f, 2.01587215e-01f, 1.62570253e-01f, 1.35345757e-01f, -2.02111676e-01f, -6.76780641e-02f, 1.64037406e-01f, 1.08566150e-01f, 1.71755359e-01f,
  -8.51219967e-02f, -1.29617110e-01f, 1.64225549e-01f, -1.61603346e-01f, 2.23311573e-01f, -6.44446835e-02f, 7.04303309e-02f, 1.24310978e-01f, -9.70325917e-02f, 9.49624330e-02f,
  2.25914836e-01f, -5.32128615e-03f, -8.26253965e-02f, 1.04392409e-01f, 4.29462865e-02f, -8.65407661e-02f, -5.31511195e-02f, -1.78201899e-01f, 2.55323261e-01f, -8.79029408e-02f,
  4.71777953e-02f, 8.38866606e-02f, 8.65742192e-02f, 1.51822582e-01f, 1.13650654e-02f, 8.35230425e-02f, 8.60954076e-02f, -1.35155860e-02f, 1.36752009e-01f, 2.73845606e-02f,
  9.55130160e-02f, 3.33217867e-02f, 6.30348101e-02f, 1.09753823e-02f, 1.15791867e-02f, 1.37278512e-01f, 3.39770198e-01f, -4.56915386e-02f, 4.55374718e-02f, -1.40588790e-01f,
  2.23556086e-02f, -6.12243637e-02f, -4.16020770e-03f, -3.29617336e-02f, 1.78581312e-01f, -8.51517171e-02f, -7.53219351e-02f, 1.46776602e-01f, 3.98839355e-01f, -1.56457603e-01f,
  1.93987358e-02f, 1.06758326e-01f, 1.29491404e-01f, 1.87217623e-01f, -3.01878214e-01f, 1.07939281e-01f, 4.15978692e-02f, 1.81977823e-01f, 1.32070646e-01f, -1.33819850e-02f,
  1.59091074e-02f, 3.01821940e-02f, -1.96666252e-02f, -2.39871249e-01f, 5.05676642e-02f, -1.64439335e-01f, -7.51736090e-02f, -1.44496970e-02f, 5.99927492e-02f, 6.56858459e-02f,
  4.45788801e-02f, 2.77180038e-02f, -7.23957047e-02f, -1.37193441e-01f, 1.28757894e-01f, -1.06652953e-01f, -1.65846184e-01f, 6.47953525e-02f, 2.19679981e-01f, 1.23042949e-01f,
  1.34189039e-01f, 3.93039063e-02f, 9.75550711e-02f, 1.69126820e-02f, 7.47303739e-02f, -4.09469977e-02f, 1.47977229e-02f, 7.30142221e-02f, 9.20544118e-02f, -8.02202150e-03f,
  9.56438705e-02f, 7.86679760e-02f, -2.87579037e-02f, 1.10341087e-01f, -1.74860973e-02f, 1.37678003e-02f, -1.01090856e-01f, -6.29279688e-02f, 5.44975027e-02f, -1.56216875e-01f,
  -2.74613887e-01f, 3.19131166e-02f, -1.23414695e-01f, 2.58534014e-01f, -6.05263095e-03f, 8.33773315e-02f, 7.32671395e-02f, -2.16594394e-02f, -3.74879129e-02f, -3.93331982e-03f,
  5.38373254e-02f, 1.13225728e-01f, -3.07667166e-01f, 1.86927378e-01f, 1.33111611e-01f, -7.42023215e-02f, -2.48115975e-02f, 1.78986397e-02f, 2.15422794e-01f, 1.24419276e-02f,
  1.23325229e-01f, -8.72265697e-02f, -1.71437468e-02f, 7.11046606e-02f, 1.22476503e-01f, -7.97296390e-02f, 4.85027395e-02f, 1.89364985e-01f, 5.32694645e-02f, 9.13307741e-02f,
  2.04409361e-01f, 1.05374172e-01f, 5.88098615e-02f, 8.16847384e-02f, -3.45028192e-03f, 6.89104870e-02f, 7.98529238e-02f, 7.67579377e-02f, 1.48464397e-01f, 5.92204593e-02f,
  1.61761865e-01f, -1.72890387e-02f, -2.04483107e-01f, -1.67000681e-01f, 2.73849233e-03f, -7.62088830e-03f, 1.90709271e-02f, -1.82992611e-02f, 6.16343282e-02f, 1.21520430e-01f,
  -2.84972577e-03f, 1.33484587e-01f, -8.77531320e-02f, 1.19014747e-01f, 4.88743223e-02f, 1.18290037e-01f, 1.49825841e-01f, 2.24360768e-02f, 7.61113986e-02f, -1.47273289e-02f,
  4.43450511e-02f, -2.70568337e-02f, -1.14575185e-01f, -6.70418441e-02f, 3.73459831e-02f, -2.46070866e-02f, 3.48229259e-02f, -5.29125407e-02f, 3.84980440e-02f, -1.06953375e-01f,
  2.26865299e-02f, 2.27885060e-02f, -6.91701770e-02f, 2.60121971e-01f, 4.86093387e-02f, 1.40805438e-01f, 1.56401880e-02f, -8.28296915e-02f, -1.46327734e-01f, 1.14329204e-01f,
  2.70578265e-01f, -1.27989367e-01f, 7.78649608e-03f, 1.90146193e-01f, -8.75838920e-02f, -1.08779542e-01f, 5.01109287e-02f, 3.12024266e-01f, 1.04226746e-01f, 2.58652624e-02f,
  5.33815064e-02f, -6.09796420e-02f, 1.32021248e-01f, 8.03788528e-02f, -8.43568295e-02f, 1.51919603e-01f, -4.47905473e-02f, 1.53137445e-01f, 6.54838607e-02f, -2.10077584e-01f,
  2.91623455e-02f, -6.93093836e-02f, -4.60985415e-02f, -3.55576649e-02f, 9.19150785e-02f, -9.24307406e-02f, 4.09319028e-02f, 1.66727260e-01f, 2.28711620e-01f, 1.09660111e-01f,
  5.26184961e-02f, 1.37091026e-01f, 2.05899775e-02f, -1.17426424e-03f, 4.38924469e-02f, 1.01843581e-01f, -4.52913577e-03f, 8.07879213e-03f, -4.69960421e-02f, -2.29354165e-02f,
  -1.27048977e-02f, 5.80537133e-02f, -9.19718016e-03f, 1.99176949e-02f, -6.50578439e-02f, 9.89727750e-02f, -7.77434185e-02f, 5.96401580e-02f, -5.63498586e-02f, 1.70731634e-01f,
  8.06731060e-02f, -1.43139452e-01f, 1.93664785e-02f, 1.91234387e-02f, -4.65621613e-02f, 2.01430768e-02f, 8.40805918e-02f, 2.07594454e-01f, 3.49600576e-02f, -2.81024069e-01f,
  1.80278737e-02f, 1.84402615e-01f, -1.25484448e-02f, 5.10041453e-02f, -1.00535378e-01f, -2.63494276e-03f, 1.75766140e-01f, -1.79741412e-01f, -6.44354448e-02f, -2.18810573e-01f,
  -6.75658882e-02f, 3.31225954e-02f, -9.69637092e-03f, 1.95545867e-01f, -1.90260652e-02f, -3.33097018e-03f, -2.71091431e-01f, 1.55623453e-02f, -1.31481558e-01f, 2.02911764e-01f,
  -3.23521681e-02f, -5.51824123e-02f, 2.20926315e-01f, 4.93970476e-02f, 3.02990943e-01f, 1.26834199e-01f, -1.01153515e-01f, 5.79921305e-02f, 8.11152980e-02f, 1.82750225e-02f,
  1.75679713e-01f, 1.99749932e-01f, -9.74259004e-02f, -1.18005455e-01f, 1.18684962e-01f, 1.21193558e-01f, 1.19980067e-01f, 7.52185807e-02f, 1.62659530e-02f, -1.47826970e-02f,
  -4.95933788e-03f, 1.35441139e-01f, 1.65986925e-01f, 1.79615722e-03f, 4.38758619e-02f, 3.07967998e-02f, 3.56056653e-02f, -2.33663227e-02f, -4.63326760e-02f, 3.84474024e-02f,
  1.77290648e-01f, -4.81969491e-02f, 7.19065079e-03f, -9.73687321e-02f, -5.44222482e-02f, 1.49720356e-01f, -1.31467670e-01f, -9.90673900e-02f, 1.89511552e-02f, -1.91934913e-01f,
  -1.40183792e-01f, -1.21752813e-01f, -1.63984880e-01f, 2.32294232e-01f, -2.94537425e-01f, 3.74987535e-02f, 1.37944266e-01f, -2.11572886e-01f, 2.49418214e-01f, 2.97139287e-01f,
  3.88933346e-02f, 1.60508096e-01f, -5.05651720e-02f, -4.94240448e-02f, 2.26738617e-01f, 1.27191603e-01f, -2.55210876e-01f, -2.83666160e-02f, -2.95873987e-03f, 4.36806887e-01f,
  1.14343986e-01f, -1.10671431e-01f, 2.03218058e-01f, -3.73190194e-02f, 6.10065274e-02f, 2.17714123e-02f, -3.27831097e-02f, 6.40741363e-02f, 1.29992664e-02f, -1.22897632e-01f,
  1.97459728e-01f, -2.31243983e-01f, 2.81401634e-01f, -8.02696720e-02f, -2.24698946e-01f, -5.46726137e-02f, 1.04733266e-01f, -2.47772172e-01f, 1.47730842e-01f, -1.48439243e-01f,
  1.08844861e-01f, 4.80584614e-02f, -8.25041998e-03f, 1.93035826e-02f, -7.94611964e-03f, -2.27745995e-02f, -2.42405608e-02f, 1.82479843e-01f, 4.33463603e-03f, -2.16326658e-02f,
  3.27375382e-02f, 5.29419221e-02f, 2.65093930e-02f, -5.46881929e-02f, -6.32098615e-02f, -1.30103156e-01f, -7.99663737e-02f, -3.54178026e-02f, -8.47205743e-02f, 3.97584252e-02f,
  3.43163908e-02f, -3.79032791e-02f, -2.44484302e-02f, -4.96817455e-02f, -1.39058232e-01f, 1.89002469e-01f, 8.55456442e-02f, 2.52411902e-01f, -2.01703712e-01f, -7.81392381e-02f,
  -1.01276614e-01f, 9.09274742e-02f, 2.48604700e-01f, -1.05554141e-01f, 1.05875693e-01f, 1.99411795e-01f, 2.54097581e-02f, -1.28570404e-02f, 4.04739305e-02f, 2.80883729e-01f,
  6.97441399e-02f, 7.00787529e-02f, 1.27076030e-01f, -1.37381884e-03f, 1.70014665e-01f, 1.60752788e-01f, -5.28308302e-02f, -9.74260923e-03f, -3.51968333e-02f, 1.56693414e-01f,
  6.47753030e-02f, -3.00539017e-01f, -1.17520459e-01f, -6.92418590e-02f, 4.45245430e-02f, 4.79334481e-02f, 2.03600377e-01f, -1.08026952e-01f, -1.61733270e-01f, 1.09197304e-01f,
  1.82025984e-01f, 4.43177968e-02f, 1.00295462e-01f, 4.79263999e-02f, -2.59969067e-02f, 5.37717044e-02f, 9.19435322e-02f, -3.14598829e-02f, 9.97021943e-02f, 5.02588833e-03f,
  4.52996977e-02f, -3.42298001e-02f, -1.74235713e-04f, -4.38646041e-02f, 2.41477042e-02f, -6.25866838e-03f, 6.47177966e-03f, -2.79660802e-02f, 1.69886187e-01f, 1.84618443e-01f,
  8.09264034e-02f, 5.23429103e-02f, -5.62829599e-02f, 3.51191945e-02f, -6.39870614e-02f, 4.40582484e-02f, 1.54210627e-01f, -1.18231498e-01f, 2.15614423e-01f, -6.99112862e-02f,
  -4.90742847e-02f, 8.53896420e-03f, 1.71624184e-01f, -1.13354839e-01f, 1.00015067e-01f, -5.19665368e-02f, -9.82218608e-02f, 2.08108887e-01f, -1.31345898e-01f, 8.26281905e-02f,
  1.40728235e-01f, 1.94842279e-01f, 6.15469664e-02f, -2.15004161e-01f, -1.36345193e-01f, 8.05855691e-02f, 7.05060288e-02f, -2.02219427e-01f, -2.41827834e-02f, -1.67399704e-01f,
  -2.28287317e-02f, 1.15231894e-01f, 1.34640798e-01f, -1.06835321e-01f, 4.53072712e-02f, 2.72711247e-01f, 4.63369079e-02f, -3.96216139e-02f, 1.11413442e-01f, 1.29987493e-01f,
  -1.97680801e-01f, 2.34304428e-01f, 2.02992082e-01f, 3.65547277e-02f, -6.47773668e-02f, 9.25930664e-02f, 1.14687853e-01f, -1.95191592e-01f, -7.49508590e-02f, -8.51374492e-02f,
  -3.56374159e-02f, -2.21063495e-02f, -2.05963366e-02f, -4.45498228e-02f, -1.32027969e-01f, 2.52014548e-02f, -4.47056256e-02f, 4.63303253e-02f, -2.94073690e-02f, -1.45188170e-02f,
  -9.64252204e-02f, 3.71098821e-03f, -4.88792993e-02f, 6.44933581e-02f, -1.22734167e-01f, 1.44079149e-01f, 9.11380053e-02f, 8.60365033e-02f, 1.60182104e-01f, 2.22991303e-01f,
  -8.98744240e-02f, 8.12499598e-02f, 1.64913699e-01f, 7.01775029e-03f, 1.68674648e-01f, -2.43624762e-01f, 2.53363866e-02f, 7.29018226e-02f, 7.41128922e-02f, 4.86430451e-02f,
  -2.71525741e-01f, -7.90897906e-02f, 1.38712361e-01f, -1.23118699e-01f, 1.79270193e-01f, 1.08317070e-01f, -1.17438048e-01f, -3.76344211e-02f, 2.35675991e-01f, 8.95421281e-02f,
  7.45250061e-02f, -2.63216883e-01f, -1.08597703e-01f, 1.45666942e-01f, 4.35459428e-02f, 9.47159231e-02f, 6.09573573e-02f, 2.13714037e-02f, 1.79156046e-02f, 1.24731159e-03f,
  7.66572431e-02f, 1.52915105e-01f, -2.52903700e-02f, 1.35648876e-01f, -1.66213542e-01f, 1.35573402e-01f, 1.31949171e-01f, -1.67132899e-01f, -1.48453504e-01f, 1.43532187e-01f,
  7.24903941e-02f, 1.21119849e-01f, 4.36212569e-02f, 9.42856260e-03f, 4.89242971e-02f, -4.30607200e-02f, 3.37039307e-02f, 9.96530149e-03f, -3.82480957e-02f, 1.17998883e-01f,
  6.34862185e-02f, -5.73322922e-02f, 7.82554876e-03f, 1.18302017e-01f, 1.02647476e-01f, -8.03868696e-02f, 6.82675093e-02f, 2.88541778e-03f, -5.91122825e-03f, -8.94989669e-02f,
  -1.62368804e-01f, 8.33607242e-02f, 1.52142784e-02f, 5.74708544e-02f, 3.50488722e-02f, -9.01786461e-02f, -3.87172811e-02f, -2.38603563e-03f, 6.27705529e-02f, 8.72511938e-02f,
  -1.00199198e-02f, -2.25576326e-01f, -6.66577742e-02f, -2.19152030e-02f, 5.56435697e-02f, -9.71941277e-03f, -1.03741691e-01f, 7.83704519e-02f, 5.89766428e-02f, 1.05205193e-01f,
  -4.45004962e-02f, 4.48051319e-02f, 1.18938610e-01f, 1.81287248e-02f, 1.02537923e-01f, -9.11543816e-02f, 1.57414511e-01f, -7.48108849e-02f, -4.00813185e-02f, -1.38307568e-02f,
  -2.55042594e-02f, 3.24619897e-02f, 5.93739934e-02f, -6.95966110e-02f, -1.99078009e-01f, -2.15206206e-01f, -4.29238938e-02f, -4.62547690e-03f, -9.05445311e-03f, 9.41300299e-03f,
  -6.51615784e-02f, -9.30974483e-02f, 7.27829710e-02f, 5.57189360e-02f, 1.26346329e-03f, -4.09732684e-02f, 1.28297061e-01f, 1.90192703e-02f, 5.86096309e-02f, 1.01720087e-01f,
  1.21948138e-01f, 3.65664884e-02f, 9.26375911e-02f, -6.16463087e-03f, 5.46320826e-02f, 3.81171587e-04f, 1.31639212e-01f, 7.48535842e-02f, 7.19661489e-02f, -4.38553952e-02f,
  2.02685550e-01f, 1.42567987e-02f, 3.04625444e-02f, -1.14353076e-01f, -1.56244084e-01f, 1.75154924e-01f, -1.97028480e-02f, 1.23814203e-01f, -4.05717120e-02f, -2.37721894e-02f,
  1.31016374e-01f, -2.70378053e-01f, 1.36762187e-01f, 2.14408472e-01f, 1.08758613e-01f, -4.22116518e-02f, 1.10859856e-01f, -5.32326512e-02f, -3.10282558e-02f, 1.38929397e-01f,
  -5.50148962e-03f, 9.53671634e-02f, 2.68230110e-01f, 3.65854442e-01f, 1.59841671e-03f, -1.02466531e-01f, 2.03995645e-01f, 7.59097338e-02f, 1.45899177e-01f, 6.15056939e-02f,
  1.34133592e-01f, -6.74448609e-02f, 1.93198010e-01f, -1.63517803e-01f, 2.01803461e-01f, 1.20468535e-01f, 1.58145264e-01f, 4.24143523e-02f, -2.60567814e-01f, -1.33956313e-01f,
  2.81721681e-01f, -2.65970454e-02f, -8.92430469e-02f, 1.47584945e-01f, 1.72695778e-02f, -3.09042633e-01f, 1.21075064e-01f, -1.19994013e-02f, 9.54027325e-02f, -1.29024670e-01f,
  1.42742872e-01f, 1.34220243e-01f, 2.67994814e-02f, -1.54176050e-05f, 1.26655370e-01f, 1.21546514e-01f, 1.69317231e-01f, -9.44676623e-03f, 3.00547183e-02f, 2.82037966e-02f,
  9.80424136e-02f, 1.65976375e-01f, 7.58098662e-02f, 1.27291292e-01f, 1.32556567e-02f, 9.45065692e-02f, -1.53303415e-01f, 1.27925158e-01f, -5.31021133e-02f, 1.14669316e-01f,
  -1.43096954e-01f, -3.80470492e-02f, 4.64334227e-02f, 7.69160017e-02f, 4.30247150e-02f, 1.18399099e-01f, 2.91543989e-03f, -1.27387166e-01f, 7.94721544e-02f, -5.94444759e-02f,
  4.57860753e-02f, 5.30775301e-02f, 7.37182051e-03f, -5.66947684e-02f, 8.46644491e-02f, -5.14082424e-02f, -3.04359887e-02f, -2.95155868e-02f, -2.83240676e-01f, 1.02604218e-01f,
  1.25923142e-01f, 1.53755113e-01f, 9.97616947e-02f, 2.78267324e-01f, -1.55531779e-01f, 7.49141537e-03f, 5.03948964e-02f, 2.33672768e-01f, -5.39941303e-02f, -4.21110950e-02f,
  6.41244352e-02f, 9.33784470e-02f, 1.91875041e-01f, -1.65192574e-01f, -2.02881638e-03f, -6.17226958e-02f, 3.68268192e-01f, -4.88807932e-02f, -5.71718216e-02f, 1.10151589e-01f,
  3.38123962e-02f, -1.80329591e-01f, 4.31223884e-02f, 1.53108060e-01f, -9.96982828e-02f, -9.23479423e-02f, -1.20024152e-01f, -5.34048863e-02f, 1.82852242e-02f, -3.89419086e-02f,
  -7.72488415e-02f, -8.67290273e-02f, -1.33156732e-01f, 1.98503379e-02f, -5.68350069e-02f, -2.22782455e-02f, -3.67440842e-02f, 1.47385567e-01f, 1.17689043e-01f, 6.32184595e-02f,
  -9.19833686e-03f, -1.38775874e-02f, 5.37763387e-02f, 1.31008448e-02f, -1.52421212e-02f, 4.78413776e-02f, 7.73156714e-03f, -9.14667994e-02f, 2.88974904e-02f, -1.85950994e-01f,
  -1.23474605e-01f, -6.24781288e-02f, -1.00637443e-01f, 2.49084800e-01f, 2.87953109e-01f, -1.67577073e-01f, -1.48803443e-01f, 2.49755934e-01f, 1.38492867e-01f, -2.07373470e-01f,
  -4.43541668e-02f, 1.42638728e-01f, 1.36874065e-01f, -2.17598677e-01f, -2.44900778e-01f, -3.95101085e-02f, -2.16585007e-02f, 1.57056645e-01f, -1.87185317e-01f, -1.96557827e-02f,
  2.50944704e-01f, -3.86841223e-02f, 1.73968911e-01f, -1.28141254e-01f, -1.94618583e-01f, 2.42803410e-01f, 2.31647287e-02f, 1.93131551e-01f, 5.24080582e-02f, -2.28310023e-02f,
  4.14778888e-02f, 6.82443678e-02f, 9.25763249e-02f, -2.66816039e-02f, -2.20552370e-01f, -1.32137522e-01f, 4.12592851e-02f, -1.03695408e-01f, 1.87075082e-02f, 2.71566454e-02f,
  2.86092367e-02f, -1.57642886e-02f, -2.36568414e-02f, 5.45214079e-02f, 4.65526544e-02f, -3.22058722e-02f, -3.60683091e-02f, 6.06534258e-02f, -5.27934991e-02f, -8.69973302e-02f,
  -5.66061586e-02f, 5.85203953e-02f, 5.37894368e-02f, 2.20457762e-02f, -3.27995121e-02f, 4.29373235e-02f, 1.13567643e-01f, 5.91210723e-02f, -1.75067149e-02f, -1.84090286e-02f,
  1.09568149e-01f, -4.77532335e-02f, -1.30090415e-02f, 6.39620349e-02f, -1.43747360e-01f, 7.23937713e-03f, 5.38305379e-02f, 1.45582840e-01f, 2.68466890e-01f, 1.00659474e-03f,
  -2.86941584e-02f, 2.85569876e-01f, 8.35898891e-02f, 6.35155961e-02f, -9.67068896e-02f, -5.58609664e-02f, 1.55421421e-01f, 9.09053814e-03f, -1.81149676e-01f, -7.73678496e-02f,
  7.10896356e-03f, 4.54676114e-02f, -8.88497680e-02f, 4.39938763e-03f, 1.38683081e-01f, 1.80104464e-01f, 1.18957385e-01f, -3.96630876e-02f, -1.46301791e-01f, 2.70272881e-01f,
  1.51784077e-01f, 1.07957587e-01f, 4.29056473e-02f, 1.21237664e-02f, 7.95647353e-02f, 1.29237086e-01f, 4.61774580e-02f, 2.50688009e-02f, -1.13822147e-01f, 5.59717380e-02f,
  3.81984487e-02f, -1.25868604e-01f, 1.43985510e-01f, 3.60093676e-02f, 3.97765115e-02f, 1.86957181e-01f, 1.09346926e-01f, 4.57264222e-02f, -1.87031813e-02f, 1.28856778e-01f,
  4.00534943e-02f, 6.51786774e-02f, 7.92259797e-02f, 7.36656040e-02f, -1.30177051e-01f, 2.37569194e-02f, -5.71947247e-02f, -3.16223688e-02f, -1.79628432e-02f, 1.54866233e-01f,
  1.04107345e-02f, 9.56780538e-02f, 1.82457238e-01f, 1.40296414e-01f, -1.89648405e-01f, -8.10249820e-02f, 2.09737686e-03f, 1.26671016e-01f, 1.89073339e-01f, 1.05136849e-01f,
  -1.07565865e-01f, 2.59894747e-02f, -1.82380438e-01f, 1.55045301e-01f, 2.24670600e-02f, -1.88761398e-01f, 1.85417414e-01f, -9.04299617e-02f, 2.54155964e-01f, 8.99911970e-02f,
  -1.99604351e-02f, 8.65521356e-02f, 2.51382947e-01f, 1.61839783e-01f, 1.86863020e-01f, -1.26312912e-01f, -2.30755676e-02f, -4.34523784e-02f, 2.65461411e-02f, -1.68928988e-02f,
  6.36320710e-02f, 9.87123400e-02f, 1.79567486e-01f, -2.76409388e-01f, -1.31145027e-02f, 2.71832086e-02f, 2.05625892e-01f, 3.62667143e-02f, -5.61295599e-02f, 8.77120122e-02f,
  -3.35007422e-02f, -2.01097608e-01f, 1.52804479e-01f, -1.54779747e-01f, 1.47037044e-01f, 2.48392954e-01f, -3.48339267e-02f, -3.88662843e-03f, 8.46015811e-02f, 6.62179291e-02f,
  1.08072676e-01f, 1.66970566e-02f, 3.61955985e-02f, 1.23949461e-01f, 5.78970416e-03f, 3.10187358e-02f, 4.64473888e-02f, 1.60701379e-01f, -7.87660927e-02f, 6.67215837e-03f,
  7.43085444e-02f, -5.00948131e-02f, -8.74589160e-02f, 4.06950079e-02f, -2.03356184e-02f, 1.53699085e-01f, 7.02281743e-02f, 1.45549849e-01f, -3.33923437e-02f, -8.85258242e-02f,
  1.88270688e-01f, -1.04251243e-01f, -3.35708894e-02f, -9.02232155e-02f, -1.07752964e-01f, 1.21858455e-01f, 1.96483210e-01f, 2.25849357e-02f, -5.66420145e-02f, 1.03334635e-01f,
  -2.09301934e-02f, -1.22727878e-01f, 1.50646016e-01f, 1.96848512e-01f, 7.86768049e-02f, -7.97390044e-02f, 9.98837873e-02f, 5.76551165e-03f, 9.30411294e-02f, -1.05166644e-01f,
  -2.82692648e-02f, -1.13011681e-01f, 2.03537121e-01f, 6.83025420e-02f, 1.00886017e-01f, -5.82199246e-02f, -7.68428221e-02f, 2.55373288e-02f, 3.74844298e-02f, 2.14887038e-01f,
  2.03804687e-01f, 1.37915269e-01f, 4.24683765e-02f, 1.41489848e-01f, 1.23860143e-01f, -2.02244416e-01f, -3.43438014e-02f, -7.41585195e-02f, 1.89818833e-02f, 1.90292876e-02f,
  3.32316831e-02f, 7.95081928e-02f, 1.66564673e-01f, -8.43263045e-02f, 1.46760434e-01f, 2.51827519e-02f, 1.87389150e-01f, -5.43544218e-02f, 7.25457594e-02f, 6.25838786e-02f,
  6.37427121e-02f, 8.49563926e-02f, 1.79104254e-01f, -3.34472172e-02f, 1.67874083e-01f, 8.53131562e-02f, -1.02389313e-01f, -1.85521021e-01f, -1.00777782e-01f, 1.20092243e-01f,
  -2.07088783e-01f, -2.52701133e-03f, 2.68871248e-01f, 8.24650750e-02f, 1.54173389e-01f, -1.20130837e-01f, -8.32185224e-02f, -5.46477959e-02f, 2.43049905e-01f, -2.07181603e-01f,
  2.67107636e-01f, 5.10938205e-02f, -8.47022161e-02f, 1.89133435e-01f, -3.87309156e-02f, 2.17047542e-01f, -7.23609403e-02f, 1.76933601e-01f, -1.93128347e-01f, 2.98783183e-02f,
  -4.08033431e-02f, -1.67365476e-01f, -3.92055176e-02f, 1.23867802e-01f, 8.65768194e-02f, 5.48318289e-02f, 1.33099779e-01f, 1.82509318e-01f, 4.31246869e-03f, -8.79058540e-02f,
  -1.94687054e-01f, 3.50009471e-01f, 1.44282877e-01f, -1.91617817e-01f, -4.73895632e-02f, 8.57575089e-02f, 1.57813728e-01f, 2.20034290e-02f, 1.25603080e-01f, -2.23404970e-02f,
  -1.12604387e-01f, 1.79882780e-01f, -3.10727924e-01f, -8.59862193e-02f, -3.95007208e-02f, -7.08480030e-02f, -3.14169042e-02f, -2.18927469e-02f, -8.91678184e-02f, -1.34650424e-01f,
  -1.08824074e-01f, -5.52393822e-03f, -7.55633563e-02f, -2.39176713e-02f, -2.34698541e-02f, -9.44916382e-02f, -1.29831374e-01f, -5.35625778e-02f, 6.74366280e-02f, -2.18394780e-04f,
  1.17374010e-01f, -4.92988564e-02f, -4.78173327e-03f, -1.10104337e-01f, 9.43441838e-02f, -3.06465570e-03f, -5.83046377e-02f, -1.51314482e-01f, -3.51069085e-02f, -5.41572124e-02f,
  -3.00074331e-02f, 2.39179164e-01f, -1.21459194e-01f, 2.13246956e-01f, 2.48907860e-02f, -1.14496507e-01f, 1.59134135e-01f, 1.65454060e-01f, 2.89186444e-02f, 4.17939797e-02f,
  9.42056626e-03f, -1.38803914e-01f, 3.05991441e-01f, 5.91901392e-02f, -2.16436893e-01f, -6.57006204e-02f, 1.16712432e-02f, -1.00823410e-01f, 1.26179904e-01f, 7.72397146e-02f,
  -1.02575980e-01f, -1.84562251e-01f, 6.81036711e-02f, 1.09379046e-01f, -1.58265675e-03f, 3.61843035e-02f, 3.84749807e-02f, 2.11848006e-01f, 1.98808629e-02f, 2.04639863e-02f,
  -2.24607423e-01f, 2.19510738e-02f, 6.82399198e-02f, 9.51524228e-02f, 9.85316113e-02f, 4.26285081e-02f, 1.85547352e-01f, -1.47948951e-01f, -1.50407320e-02f, 1.09242052e-02f,
  -8.52963328e-02f, 2.20033787e-02f, -8.32750797e-02f, 6.02234006e-02f, -3.79081480e-02f, -1.46989347e-02f, -7.88083747e-02f, -2.68790890e-02f, -2.71581914e-02f, -1.33306503e-01f,
  -1.90119579e-01f, -1.51054421e-02f, 3.77225094e-02f, -1.22616319e-02f, 8.23527128e-02f, 5.07292785e-02f, 4.01083082e-02f, -1.39331240e-02f, 4.01700139e-02f, 1.08678984e-02f,
  6.55309483e-03f, -1.37941018e-01f, -1.22685984e-01f, -1.23661101e-01f, -1.00816026e-01f, 2.46384174e-01f, -1.88141584e-01f, 8.87920633e-02f, -1.76626425e-02f, -1.77003607e-01f,
  1.29011527e-01f, 1.19006634e-01f, -5.04520759e-02f, -3.23283449e-02f, 2.30485518e-02f, 1.75201590e-03f, 2.94363350e-01f, -3.34478244e-02f, -2.35373110e-01f, -3.92113626e-02f,
  -3.61326113e-02f, -2.37003248e-02f, -4.73627495e-03f, -4.15504836e-02f, -5.15331440e-02f, -2.34105423e-01f, 1.63165376e-01f, 2.55766734e-02f, 3.97764565e-03f, -3.72255631e-02f,
  -7.54436329e-02f, 5.26461937e-02f, 1.39816999e-01f, -1.02171481e-01f, -1.62835509e-01f, -5.37462942e-02f, -3.37661430e-02f, -2.35721748e-02f, 1.70132145e-02f, -8.96198973e-02f,
  2.03398004e-01f, -9.37904865e-02f, 8.37873369e-02f, 6.39822185e-02f, 1.81043837e-02f, 1.32468313e-01f, 9.85621214e-02f, 1.47010252e-01f, 8.63155350e-02f, 1.03871755e-01f,
  7.06230178e-02f, 7.64861777e-02f, 9.39564258e-02f, 1.16575316e-01f, -4.16024588e-02f, 4.87096608e-02f, -5.53925335e-02f, -4.44023125e-02f, -3.56119126e-02f, 6.59431815e-02f,
  1.60444587e-01f, 2.06199095e-01f, 1.49693280e-01f, 9.97167975e-02f, -1.01442523e-01f, 1.53472992e-02f, 1.90375954e-01f, -4.22303304e-02f, 2.09553298e-02f, 1.14823633e-03f,
  -1.35082137e-02f, 6.43544421e-02f, 1.66657820e-01f, 8.81220549e-02f, -3.15986341e-03f, 8.94400552e-02f, -9.51427966e-02f, -1.16748065e-01f, 1.58795863e-01f, 2.63524443e-01f,
  3.31919417e-02f, 2.60323938e-02f, 9.98320505e-02f, 1.96435209e-02f, 7.99453333e-02f, -1.33110493e-01f, -1.16384417e-01f, -7.23223761e-02f, 2.51002491e-01f, -3.95883061e-02f,
  1.07984699e-01f, -5.29569574e-02f, -1.58823237e-01f, -1.05288543e-01f, -8.83908346e-02f, 1.27125695e-01f, 2.85977721e-01f, 4.33459803e-02f, 1.49338216e-01f, 2.38323048e-01f,
  1.12516806e-01f, -2.49679103e-01f, -6.84682727e-02f, -2.80281864e-02f, -1.48354908e-02f, 1.66286573e-01f, 6.11738749e-02f, -1.48562975e-02f, 4.60401038e-03f, 3.29920091e-02f,
  2.00328808e-02f, 1.27276838e-01f, 1.17488869e-01f, 1.41689792e-01f, 1.04013085e-01f, 6.12700060e-02f, -1.87362693e-02f, -4.07916261e-03f, -9.94595066e-02f, 4.18108739e-02f,
  3.42861675e-02f, -1.93083793e-01f, -1.99238911e-01f, -5.56118786e-02f, 7.37478286e-02f, 3.27192098e-01f, 5.07424809e-02f, 2.60084197e-02f, -1.16092721e-02f, -3.87300886e-02f,
  -1.63124746e-03f, -2.88967341e-02f, 3.59713496e-03f, 1.48970753e-01f, -3.11403424e-01f, 1.25651017e-01f, 2.31396988e-01f, 2.56925374e-02f, 7.43802041e-02f, 2.14969859e-01f,
  1.12371191e-01f, 1.04585119e-01f, 3.14043500e-02f, 4.96250913e-02f, 2.13705346e-01f, 1.88818976e-01f, -8.86046886e-02f, -1.66351750e-01f, 9.51473042e-02f, 1.69487074e-01f,
  6.43541366e-02f, 1.31570518e-01f, 3.99768651e-01f, 6.58444166e-02f, 9.30455849e-02f, 2.48462483e-02f, -2.89589226e-01f, 4.05841944e-04f, 6.74425811e-02f, 1.53155357e-01f,
  1.76536441e-01f, -8.35921429e-03f, 3.71151358e-01f, 6.80284798e-02f, -1.11836411e-01f, -1.65945143e-01f, 7.17191165e-03f, -2.10649353e-02f, 3.45147885e-02f, 2.84006298e-02f,
  -7.51056056e-03f, 1.12663759e-02f, 1.06122442e-01f, 3.03242840e-02f, 6.71720877e-02f, -1.15271527e-02f, 5.00692520e-03f, 1.69253424e-01f, 1.15286805e-01f, 1.85978115e-02f,
  -2.44585536e-02f, 1.14358999e-01f, 8.29931945e-02f, -6.19023256e-02f, -2.48177201e-02f, -1.03215374e-01f, -2.83682317e-01f, -4.48704809e-02f, -8.99879541e-03f, 1.82338253e-01f,
  3.62642743e-02f, 7.97905475e-02f, 1.45434529e-01f, 1.17463388e-01f, 1.52209371e-01f, 1.57061636e-01f, 1.21160276e-01f, -1.70807570e-01f, 2.87608635e-02f, 4.11002226e-02f,
  2.05751181e-01f, 1.69645697e-01f, -1.46957174e-01f, -6.41183788e-03f, 2.32870385e-01f, 1.63559809e-01f, 8.30418989e-02f, 1.02412149e-01f, -2.09059164e-01f, 8.53559896e-02f,
  2.40545794e-01f, -1.08547851e-01f, 9.30705369e-02f, -6.26322553e-02f, 1.28862679e-01f, 2.93871462e-01f, 2.10355803e-01f, 2.26954043e-01f, -1.28243849e-01f, 5.41235507e-02f,
  -1.71025455e-01f, 1.01032615e-01f, 8.17635953e-02f, 1.38703570e-01f, -4.95142341e-02f, 2.45240256e-01f, 1.75046697e-01f, 8.23825449e-02f, 1.43047228e-01f, -1.14103839e-01f,
  -1.14789307e-01f, 3.19008470e-01f, -2.44401917e-01f, -3.41428369e-02f, -1.27371047e-02f, -4.82910313e-02f, 9.04657226e-03f, -8.81537870e-02f, 7.50172585e-02f, -9.04399902e-02f,
  -1.06600402e-02f, 4.24698815e-02f, -3.40156332e-02f, -3.22284899e-03f, -3.69359478e-02f, -2.75510643e-02f, 4.38596457e-02f, -7.92428032e-02f, 1.10149540e-01f, -1.08027175e-01f,
  -3.00007701e-01f, -7.84447789e-02f, -2.25723550e-01f, 1.84850827e-01f, -1.16546892e-01f, 1.12029724e-01f, 1.10298365e-01f, 7.45578110e-02f, -1.04302689e-02f, 3.83533314e-02f,
  1.30056351e-01f, -6.01923615e-02f, -1.74086228e-01f, 1.35598809e-01f, 7.38742277e-02f, -1.82866044e-02f, -1.59689724e-01f, -4.40846942e-03f, 2.56671101e-01f, 7.33551905e-02f,
  1.28221840e-01f, -1.22012086e-02f, -2.23394260e-01f, -4.20552641e-02f, 1.01146102e-01f, -8.89474899e-02f, 2.90343966e-02f, 1.98230818e-01f, 7.65994936e-02f, 2.08759099e-01f,
  2.09439963e-01f, 1.21405274e-01f, -6.03048764e-02f, 1.04672544e-01f, 3.48759140e-03f, 1.96199372e-01f, 1.34257684e-02f, 7.97678754e-02f, -5.57729416e-02f, 1.96602583e-01f,
  1.14092439e-01f, -4.58132895e-03f, -1.14742599e-01f, -1.21148922e-01f, -7.55163655e-02f, 1.18577994e-01f, -6.87075034e-02f, -1.28974929e-01f, -8.17100890e-03f, 6.22678921e-02f,
  8.97957871e-05f, 1.22074835e-01f, 2.28880290e-02f, 8.96289349e-02f, 4.85400334e-02f, 1.01255000e-01f, 1.00008808e-01f, 1.43667325e-01f, 4.27368097e-03f, 5.46006896e-02f,
  -4.19393331e-02f, 1.51052363e-02f, -2.11759746e-01f, -1.13280207e-01f, -3.04288547e-02f, 5.48586175e-02f, 9.92316380e-02f, -1.19344458e-01f, 1.24560438e-01f, -3.08777746e-02f,
  -1.15871608e-01f, 1.47499532e-01f, -4.52898741e-02f, 2.76069850e-01f, 2.14651778e-01f, -3.46444882e-02f, 1.68111548e-02f, 8.69323835e-02f, -1.75434321e-01f, 2.38231286e-01f,
  5.61352558e-02f, -2.30814844e-01f, 1.36889026e-01f, 9.69701167e-03f, -1.23674618e-02f, -2.15928495e-01f, -1.26540527e-01f, 2.50608236e-01f, 1.54746994e-01f, 1.44692689e-01f,
  7.65011907e-02f, -6.28866851e-02f, 2.07034163e-02f, 2.00841114e-01f, -3.24610025e-02f, 3.16914462e-04f, -6.65824711e-02f, 1.45352408e-01f, 2.00690135e-01f, -2.50210136e-01f,
  1.36872426e-01f, 1.11696519e-01f, -7.64734000e-02f, 1.89911807e-03f, 3.68693918e-02f, -8.28066319e-02f, -2.05378123e-02f, 1.57603666e-01f, 1.53420106e-01f, 7.76090026e-02f,
  2.64496151e-02f, 2.58155972e-01f, -4.57545258e-02f, 1.53973270e-02f, 5.67199476e-02f, -2.63863541e-02f, -3.87310386e-02f, -7.77767822e-02f, -2.10531075e-02f, -4.93288003e-02f,
  4.11986709e-02f, -1.21341243e-01f, 2.53999978e-03f, -2.11623348e-02f, 1.39427498e-01f, -1.25087634e-01f, 8.60364661e-02f, -1.47219479e-01f, 2.74875034e-02f, -2.44326949e-01f,
  -1.80397123e-01f, -8.18396453e-03f, -1.18152395e-01f, -9.11561996e-02f, 1.29815578e-01f, 3.71192284e-02f, -1.35314599e-01f, -7.80057386e-02f, 5.16396314e-02f, 3.23035330e-01f,
  -2.71641999e-03f, -1.02961481e-01f, 4.44424935e-02f, -6.34795278e-02f, 2.60012597e-01f, 4.53522429e-02f, -3.26536484e-02f, 3.19388181e-01f, 1.15220975e-02f, 1.16582640e-01f,
  1.04159161e-01f, 1.98775351e-01f, 9.40408856e-02f, -1.94195151e-01f, -1.84449684e-02f, 4.95375171e-02f, 3.56108606e-01f, 6.95095286e-02f, 3.41130979e-02f, 5.57423048e-02f,
  5.25093731e-03f, 2.05870822e-01f, -8.32312182e-02f, 8.80949385e-03f, -1.78065807e-01f, -1.05599694e-01f, -3.07074795e-03f, 5.30663365e-03f, 1.01333097e-01f, -1.17833003e-01f,
  -7.31325075e-02f, 1.33065507e-01f, 1.68307304e-01f, 2.90276468e-01f, -1.38209611e-01f, -1.28466919e-01f, -6.97804466e-02f, -1.00051858e-01f, -8.73667300e-02f, -1.01971023e-01f,
  2.38882657e-02f, -1.65309787e-01f, -1.33406088e-01f, -4.40504700e-02f, -2.51567006e-01f, -5.71928322e-02f, -2.95949858e-02f, -1.22321427e-01f, -1.81394979e-01f, 4.12335768e-02f,
  1.23666979e-01f, 5.46361208e-02f, -7.81706274e-02f, 5.21685220e-02f, -1.10575691e-01f, -5.17872870e-02f, -1.25757912e-02f, 1.13683932e-01f, -1.17290940e-03f, -1.11179188e-01f,
  -2.26313937e-02f, -4.75726090e-03f, 8.75489935e-02f, -2.61839922e-03f, -2.15852112e-01f, 3.10635030e-01f, 7.57867992e-02f, -2.11305782e-01f, -1.91644147e-01f, -1.16124647e-02f,
  3.12120795e-01f, -1.53042629e-01f, 1.97358742e-01f, 1.69291869e-02f, 4.97467220e-02f, -2.15686738e-01f, 2.47275550e-02f, 8.98513421e-02f, 1.96189247e-02f, 1.78300396e-01f,
  -9.14157778e-02f, 8.30582678e-02f, 1.24110433e-04f, -1.13618225e-01f, 1.37063161e-01f, -4.22656126e-02f, 1.13282301e-01f, 7.54691660e-02f, 3.46867293e-02f, 1.92583650e-01f,
  1.27375498e-01f, 1.44280985e-01f, -1.71395421e-01f, -2.64049843e-02f, 3.72363697e-03f, -4.32219841e-02f, -9.38107222e-02f, -5.76776713e-02f, 2.26625234e-01f, -9.84571874e-02f,
  2.70290673e-02f, 6.45273402e-02f, 2.92344708e-02f, 9.08406219e-05f, 1.08726040e-01f, -9.31667909e-02f, 2.11528875e-02f, -2.77246404e-02f, -3.65253501e-02f, 1.15627795e-03f,
  6.55300543e-02f, 1.35856392e-02f, 9.33663324e-02f, 5.41195273e-03f, 8.44115540e-02f, 2.56866813e-01f, 2.83886850e-01f, 4.56459448e-03f, -1.24849558e-01f, -3.00758988e-01f,
  8.86984169e-03f, -6.37866482e-02f, -1.33322943e-02f, -6.77425638e-02f, 1.79728106e-01f, 4.61621992e-02f, -9.85824224e-03f, 5.17590158e-02f, 3.06958169e-01f, -8.95495713e-02f,
  -4.97102216e-02f, 8.88074115e-02f, 3.24555822e-02f, 6.19112588e-02f, -1.99204296e-01f, 4.65423316e-02f, 9.40385759e-02f, 2.16352195e-01f, 4.93099242e-02f, -3.10484786e-02f,
  7.69011676e-02f, 3.06997657e-01f, -6.17383746e-03f, -2.05526799e-01f, -2.51673739e-02f, -2.84981672e-02f, -2.38603324e-01f, -6.33065701e-02f, 1.17558479e-01f, 7.80698508e-02f,
  3.58432889e-01f, 1.06986865e-01f, 5.20155393e-03f, -2.33493298e-02f, -1.35299256e-02f, 7.97965229e-02f, -3.56987149e-01f, 1.28483951e-01f, 2.87325084e-01f, 1.87616795e-01f,
  1.39199018e-01f, 1.75874531e-02f, 2.15851486e-01f, -9.12503153e-03f, 7.33457804e-02f, 1.11726590e-01f, 1.30442217e-01f, 1.30849108e-01f, -5.71762100e-02f, 2.34819818e-02f,
  1.17544927e-01f, 7.00701550e-02f, 1.78665549e-01f, -6.04961626e-03f, 1.14237688e-01f, 3.84004265e-02f, 9.80757624e-02f, -6.53838888e-02f, -1.05344981e-01f, 3.98256741e-02f,
  1.99782848e-01f, -4.36833501e-02f, 5.33857904e-02f, -2.09415466e-01f, -8.45834613e-03f, -1.61030486e-01f, 4.88515161e-02f, 5.29387221e-02f, 5.58458641e-02f, 2.68151402e-01f,
  4.18952070e-02f, 1.89153805e-01f, 2.72656828e-01f, -1.18739918e-01f, -4.26373929e-02f, 2.27938384e-01f, 2.25340679e-01f, 3.26748900e-02f, 1.18711097e-02f, 1.85195759e-01f,
  -1.51386634e-01f, -1.44286707e-01f, 1.78449705e-01f, 1.73760757e-01f, 8.64780545e-02f, 6.45130128e-02f, -4.74854410e-02f, -9.41940472e-02f, 1.70317963e-01f, 1.49193212e-01f,
  -2.03929320e-01f, 1.53809324e-01f, -1.03079274e-01f, 2.14374080e-01f, 1.31026089e-01f, -3.89394015e-02f, 1.35910079e-01f, -8.51493403e-02f, -9.37488452e-02f, -5.19011617e-02f,
  -5.04439846e-02f, -5.99858463e-02f, 2.23912358e-01f, 3.31292659e-01f, 2.39846706e-01f, 1.60022765e-01f, 4.51568812e-02f, 5.88361397e-02f, 7.04989508e-02f, 1.41402975e-01f,
  -1.00071030e-02f, 7.83679187e-02f, 7.67185465e-02f, 1.33288547e-01f, 6.44076169e-02f, 5.08839749e-02f, -1.54529605e-03f, 9.42555442e-02f, 1.07294463e-01f, 6.71661347e-02f,
  -9.61270705e-02f, 1.01554960e-01f, -1.70221291e-02f, 8.12207609e-02f, 1.26593038e-01f, 1.71397373e-01f, 8.08402970e-02f, 2.05127224e-02f, 1.54424608e-01f, 4.99086268e-02f,
  -1.34994328e-01f, -1.45493880e-01f, 1.68673158e-01f, 7.26406649e-02f, 4.93857935e-02f, 5.66743612e-02f, -1.67470369e-02f, 2.55812914e-03f, -1.22833848e-01f, 4.66945618e-02f,
  9.42230523e-02f, -1.07151000e-02f, -4.73925024e-02f, -1.37162223e-01f, 1.28908634e-01f, 1.64190993e-01f, 1.21310435e-01f, 7.98441768e-02f, 1.19630896e-01f, 2.77994543e-01f,
  1.98290735e-01f, -8.55875537e-02f, -1.55138806e-01f, -1.70292348e-01f, -5.56440763e-02f, -4.90650870e-02f, 1.20245233e-01f, -4.97870035e-02f, 1.82068422e-01f, -1.95998460e-01f,
  -4.57341708e-02f, -5.82996868e-02f, 2.06207022e-01f, -2.86820550e-02f, -1.48073649e-02f, 1.06074162e-01f, 4.82104309e-02f, -5.01719788e-02f, 1.47375926e-01f, -2.68516481e-01f,
  3.07991773e-01f, 1.67514652e-01f, 1.21918686e-01f, 3.53653803e-02f, 5.27257137e-02f, -4.99494299e-02f, 1.09009460e-01f, 1.98200252e-02f, 4.03800346e-02f, 2.73403674e-02f,
  1.06275521e-01f, 2.25859769e-02f, 5.08941486e-02f, 1.20708354e-01f, 6.24649562e-02f, -4.00437915e-04f, 7.67684877e-02f, 8.75293389e-02f, -6.57459944e-02f, 2.68360563e-02f,
  -1.29203588e-01f, -2.14098743e-03f, -7.74689466e-02f, 1.36572802e-02f, 1.30401820e-01f, -2.88670938e-02f, 3.40509438e-03f, 5.55785373e-02f, 4.52437960e-02f, 5.98642938e-02f,
  8.18926618e-02f, -1.62972480e-01f, -8.02575275e-02f, 1.40312519e-02f, -6.44378066e-02f, -6.91700801e-02f, 9.28212479e-02f, 5.65877780e-02f, 6.34690002e-02f, -5.03405929e-03f,
  -1.62111521e-01f, -7.94435889e-02f, 1.00257747e-01f, 9.99481231e-02f, 9.66011062e-02f, 6.99147955e-02f, 3.26849557e-02f, -3.58732305e-02f, -2.98710652e-02f, 1.28367484e-01f,
  -3.70238535e-02f, -2.64564976e-02f, 1.61014423e-01f, 1.02402076e-01f, 1.80001799e-02f, -2.26713032e-01f, 7.55716339e-02f, -4.28460678e-03f, -3.22345123e-02f, -5.22262119e-02f,
  -9.75496992e-02f, -3.37802619e-02f, 3.47708426e-02f, 6.32836521e-02f, 8.38419050e-02f, -6.14165105e-02f, 3.69800776e-02f, -6.92577139e-02f, -1.65563039e-02f, -1.58505607e-02f,
  -5.05456626e-02f, -2.44456101e-02f, 4.37917933e-02f, 3.47406603e-02f, 7.41286054e-02f, 1.07069630e-02f, -6.30738214e-02f, -7.18328729e-02f, -3.07491818e-03f, -4.63367663e-02f,
  7.47828782e-02f, -1.46902904e-01f, -4.75426018e-02f, -1.68244600e-01f, -4.49452586e-02f, 9.52005982e-02f, -7.34273940e-02f, -1.89763661e-02f, -1.93973798e-02f, -1.66744106e-02f,
  -1.66585922e-01f, 1.26822907e-02f, 7.09291399e-02f, 2.66916484e-01f, -1.61909297e-01f, 3.58504578e-02f, 1.00668460e-01f, -2.38035880e-02f, 2.50214487e-01f, 1.88281000e-01f,
  7.57458657e-02f, 1.96223721e-01f, -2.58983336e-02f, 9.60993022e-02f, 1.57027617e-01f, 1.60948306e-01f, -1.17921922e-02f, -2.43617624e-01f, 1.10421196e-01f, 2.04822704e-01f,
  2.06132129e-01f, 1.21026762e-01f, 2.40618154e-01f, 8.49944260e-03f, 5.01612239e-02f, 1.97442383e-01f, -1.63233191e-01f, 7.76539266e-04f, -5.57281002e-02f, -8.49869847e-02f,
  1.49799466e-01f, -1.28824592e-01f, 1.37339056e-01f, -1.11243591e-01f, -1.21097453e-01f, -1.15030952e-01f, 6.00902922e-02f, 7.19210356e-02f, -1.10570155e-01f, -5.10903336e-02f,
  -1.83524899e-02f, 8.46525803e-02f, 1.18148014e-01f, 4.86373864e-02f, -6.29905835e-02f, 3.09656896e-02f, 3.77867147e-02f, -2.15033405e-02f, 4.73752990e-02f, 4.51494493e-02f,
  9.12065804e-03f, 2.51458194e-02f, 1.17440760e-01f, -1.92378424e-02f, -7.35133663e-02f, 9.47878882e-03f, 7.42515028e-02f, -8.04947689e-02f, 3.20083499e-02f, -7.77046159e-02f,
  -3.48906852e-02f, -6.39386848e-02f, 2.05612704e-02f, 7.85427541e-02f, 1.86431929e-01f, 1.09648861e-01f, -9.68167782e-02f, -5.46619967e-02f, 3.25049430e-01f, -9.43074599e-02f,
  7.38257393e-02f, 1.56088814e-01f, 7.44118765e-02f, 1.47537859e-02f, -1.79043099e-01f, 9.77395326e-02f, -1.23920396e-01f, 6.17985912e-02f, 2.16530897e-02f, 6.61503077e-02f,
  1.18577488e-01f, -1.12339165e-02f, -7.18506351e-02f, -1.89980611e-01f, 2.57037692e-02f, 1.00720584e-01f, 1.97824873e-02f, 2.00203240e-01f, -8.18509310e-02f, 3.16166244e-02f,
  -2.44395602e-02f, 2.24356875e-02f, 2.25248933e-03f, 6.67983219e-02f, -1.30939305e-01f, 9.08165053e-02f, -2.63727158e-02f, 1.57427520e-01f, 2.47702718e-01f, 1.71591863e-01f,
  9.54809412e-02f, 1.78024739e-01f, -9.33851004e-02f, 1.07778914e-01f, -1.16422679e-02f, -4.32892097e-03f, 1.27246618e-01f, 1.03951380e-01f, 6.20783791e-02f, 8.27247724e-02f,
  1.55448308e-02f, -6.29016086e-02f, 1.26178697e-01f, -6.58474490e-03f, 6.36942983e-02f, 1.22226909e-01f, 1.64929122e-01f, -2.14965027e-02f, -4.00748402e-02f, 7.78569430e-02f,
  2.02447534e-01f, -1.21753551e-01f, 5.61068431e-02f, -7.95637220e-02f, -3.52584422e-02f, -4.27322686e-02f, 7.24392682e-02f, 9.16317478e-02f, 1.97484031e-01f, -1.27392501e-01f,
  -7.89104924e-02f, -2.01291498e-02f, 3.18740547e-01f, -2.44165674e-01f, 2.53728293e-02f, 1.79884329e-01f, 3.53940837e-02f, 1.29966810e-01f, -2.78485149e-01f, 1.90699816e-01f,
  -9.34602097e-02f, 2.01780394e-01f, -7.39704678e-03f, -2.30109598e-02f, 9.36615318e-02f, 2.04036431e-03f, -2.79542971e-02f, -2.23881155e-01f, 1.16940171e-01f, -8.80173370e-02f,
  -1.63288172e-02f, 1.67446360e-01f, -4.84052114e-02f, 4.75146919e-02f, -1.02803156e-01f, 9.64858457e-02f, -9.96010154e-02f, -1.55682310e-01f, -1.75835770e-02f, -8.87236148e-02f,
  -1.07220031e-01f, 4.69730385e-02f, 1.82225883e-01f, 5.10050654e-02f, 1.06258571e-01f, 1.54173359e-01f, -1.89778805e-01f, 5.99541329e-03f, -5.80750331e-02f, -7.98419770e-03f,
  5.39941750e-02f, -1.65606007e-01f, 4.38719802e-02f, -1.58888936e-01f, -8.21244046e-02f, -4.06120829e-02f, -1.07399955e-01f, -5.23571596e-02f, -2.94127837e-02f, -4.35933024e-02f,
  3.81980464e-02f, -2.55115293e-02f, 7.06805736e-02f, 7.06939548e-02f, -4.12407778e-02f, 5.53261079e-02f, -1.43675238e-01f, -1.62708223e-01f, -4.02781814e-02f, -2.19209902e-02f,
  8.33069682e-02f, 3.90509889e-02f, 3.70928682e-02f, 1.45082310e-01f, 1.21199958e-01f, 6.33014040e-03f, 9.47236940e-02f, 1.14743024e-01f, -5.47478423e-02f, -3.99636850e-02f,
  -1.51803583e-01f, -1.60298258e-01f, 1.95591822e-01f, 9.97559428e-02f, 8.70621204e-02f, -6.11837544e-02f, -7.94828385e-02f, -5.03406003e-02f, 8.96870643e-02f, 2.27066502e-01f,
  6.90907016e-02f, -1.17178226e-03f, 3.98741439e-02f, 1.75027192e-01f, -2.19182104e-01f, 8.73827860e-02f, -5.76370098e-02f, 4.97040488e-02f, 2.96475291e-01f, 1.08308859e-01f,
  9.78186950e-02f, 8.29222947e-02f, -1.91643029e-01f, 1.73124224e-01f, -6.03016578e-02f, 1.97222531e-02f, 8.45842063e-02f, 2.61724532e-01f, -3.28857787e-02f, 1.67465255e-01f,
  1.07425205e-01f, -9.69009623e-02f, 6.62826970e-02f, 5.19279651e-02f, -1.13690160e-02f, 1.05152130e-01f, 6.48600832e-02f, 5.33059388e-02f, 4.82400991e-02f, -4.85590892e-03f,
  3.95861715e-02f, 7.06320703e-02f, 6.80131316e-02f, 1.11473203e-01f, -3.61853130e-02f, 5.08768186e-02f, 7.61019215e-02f, 2.01430656e-02f, 2.81028394e-02f, 2.98790839e-02f,
  -7.09679052e-02f, 9.53874439e-02f, 5.19405641e-02f, 9.42350850e-02f, -7.74236470e-02f, -9.71643254e-02f, 1.13891400e-01f, -1.59305930e-01f, 3.34340818e-02f, 1.11742228e-01f,
  -5.16216792e-02f, 1.68685839e-02f, 6.35836869e-02f, -3.20687965e-02f, 3.75538953e-02f, 6.74757510e-02f, -6.69703539e-03f, -8.46815184e-02f, 1.48620322e-01f, 1.55821234e-01f,
  7.33533278e-02f, -5.57433404e-02f, 8.01476836e-02f, 1.14600308e-01f, 1.09863713e-01f, 1.74975116e-02f, -9.52418800e-03f, -1.24621078e-01f, 1.51196212e-01f, -5.89161627e-02f,
  1.74923137e-01f, 1.39668053e-02f, 8.29488263e-02f, -5.09691983e-02f, -6.52686581e-02f, -9.09235328e-03f, 2.26774260e-01f, -5.42448349e-02f, 1.94115918e-02f, 6.41475394e-02f,
  -1.93946101e-02f, -1.97803944e-01f, 4.00897339e-02f, -1.49384081e-01f, 1.11743256e-01f, 3.40722799e-02f, 2.14656554e-02f, 4.59365211e-02f, 4.30596806e-02f, 1.92288738e-02f,
  -1.40051153e-02f, 8.25084224e-02f, -9.25546512e-04f, 7.44209737e-02f, 1.33966962e-02f, 1.00715265e-01f, -4.89321165e-02f, 3.91029753e-02f, -8.60748962e-02f, 1.26048150e-02f,
  -3.87534797e-02f, -8.16585571e-02f, -1.46263257e-01f, 4.73634452e-02f, 1.52162656e-01f, 1.54813796e-01f, 2.16278378e-02f, -4.70211133e-02f, 8.69418457e-02f, 2.09640842e-02f,
  4.58923019e-02f, 6.01838045e-02f, -1.60935715e-01f, -7.14376941e-02f, -9.66233239e-02f, 1.25035971e-01f, 2.17517793e-01f, 1.34347767e-01f, 2.91325133e-02f, 1.95535704e-01f,
  8.74080136e-02f, 8.51496588e-03f, -1.20810084e-01f, 6.27702251e-02f, 1.45432070e-01f, 8.45297053e-02f, -1.31668210e-01f, -5.80899604e-02f, -6.96791261e-02f, 2.89227162e-02f,
  -4.31199335e-02f, 3.54487933e-02f, 2.49954119e-01f, 1.49560422e-01f, 9.09911096e-03f, -6.44641370e-02f, -2.36332521e-01f, 1.74566746e-01f, 1.77076221e-01f, 1.75212756e-01f,
  4.92620729e-02f, 4.64186743e-02f, 3.01660299e-01f, 1.28850475e-01f, 8.27058628e-02f, 3.21793072e-02f, -7.15419278e-02f, 6.67938441e-02f, 7.51907229e-02f, 1.05371913e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 40)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 40;
const float L2_fan_Bp_bar_data[] = {
  7.49088749e-02f, 2.28545461e-02f, 1.25265345e-02f, -4.43321951e-02f, 8.36976618e-02f, 2.98792310e-02f, 6.65676519e-02f, 1.00871138e-01f, -4.68790121e-02f, 2.03162245e-02f,
  -3.42583358e-02f, 8.02234560e-02f, -1.22730038e-03f, -2.21334063e-02f, 5.37363961e-02f, 6.76435605e-02f, 2.23670397e-02f, 8.48102011e-03f, 9.79502052e-02f, 1.15192831e-02f,
  1.02996372e-01f, -6.12722076e-02f, -1.95538383e-02f, 6.14223443e-02f, 5.72353974e-02f, 7.99218714e-02f, -4.20722514e-02f, 3.63014149e-03f, 5.63446358e-02f, -4.56447853e-03f,
  1.04230657e-01f, 1.53191518e-02f, -1.17363071e-03f, 8.02604631e-02f, 3.82322669e-02f, -3.07760201e-02f, 3.23029757e-02f, 2.68016607e-02f, 6.63954392e-02f, 9.00543630e-02f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  -3.32231149e-02f, 5.24856411e-02f, 5.77453114e-02f, 4.55576666e-02f, 1.15268424e-01f, 1.04931004e-01f, 5.79327866e-02f, 5.89894764e-02f, -6.28086925e-02f, 2.55522653e-02f,
  4.66200225e-02f, 5.48242554e-02f, -1.75205782e-01f, 2.40005791e-01f, -8.85862261e-02f, -2.25418974e-02f, 1.50807142e-01f, 1.37852132e-01f, 1.87610649e-02f, 1.38322189e-01f,
  6.87256977e-02f, 1.27355292e-01f, -1.83028519e-01f, -1.89858526e-01f, 2.33952463e-01f, 1.38833404e-01f, -1.99929640e-01f, -5.08477129e-02f, 1.88654229e-01f, -2.16817185e-01f,
  2.55073726e-01f, -2.43505523e-01f, 9.14156996e-03f, 4.50932652e-01f, -2.47809619e-01f, -1.58593029e-01f, -2.60660440e-01f, -1.38349041e-01f, 5.16426638e-02f, 2.03808621e-01f,
  2.90804058e-01f, 8.42819288e-02f, -3.36219639e-01f, -4.11776118e-02f, 2.13903531e-01f, -1.18447676e-01f, -1.37567550e-01f, -1.85527280e-01f, 2.04872057e-01f, -5.72026707e-02f,
  2.31726781e-01f, -4.08715904e-01f, -3.50299031e-02f, 1.70765832e-01f, -4.09464151e-01f, -3.83929253e-01f, -3.62239093e-01f, 5.05381227e-02f, 1.93714976e-01f, -3.82312924e-01f,
  -1.69019967e-01f, -2.29904458e-01f, 7.66835883e-02f, 5.10090590e-02f, -1.16213590e-01f, -5.86196668e-02f, 7.01852068e-02f, 7.07674399e-02f, -7.54524693e-02f, 7.85826892e-02f,
  -4.69927415e-02f, 1.58613678e-02f, 4.74900119e-02f, -2.74336208e-02f, 3.09103709e-02f, -5.18363118e-02f, 2.50919815e-03f, 6.09614290e-02f, 8.89981836e-02f, -1.10012114e-01f,
  -1.47944123e-01f, 1.66998968e-01f, 3.83292176e-02f, 1.43851683e-01f, -1.62875071e-01f, 1.90628752e-01f, 2.05050170e-01f, 1.44267440e-01f, 8.09558183e-02f, -4.87567410e-02f,
  -2.17324212e-01f, -3.11292857e-01f, -3.75742584e-01f, -2.24199891e-01f, 6.33746013e-02f, 1.75009072e-01f, -1.23427920e-01f, 2.82652110e-01f, 2.62157500e-01f, -2.77078569e-01f,
  -2.73930758e-01f, 6.40317053e-02f, -4.19850111e-01f, 1.83369562e-01f, -2.85157323e-01f, 1.34483154e-03f, -2.60442466e-01f, -3.23275805e-01f, 2.25829810e-01f, -1.70671299e-01f,
  -1.12123981e-01f, -2.78998375e-01f, 2.70487666e-01f, 1.91374332e-01f, 1.03055291e-01f, -5.82497530e-02f, 2.53498137e-01f, -2.70267159e-01f, -4.72643912e-01f, 5.13323117e-04f,
  -2.72791088e-01f, 2.36044079e-02f, 2.68117487e-01f, -4.38691340e-02f, -9.20123607e-02f, 7.65448213e-02f, -2.77730018e-01f, 9.16624963e-02f, 1.47760645e-01f, 1.06226370e-01f,
  -6.09707870e-02f, 4.25242037e-02f, -1.12241328e-01f, 1.33693770e-01f, -3.53473686e-02f, 1.04421481e-01f, -1.83607593e-01f, 7.70403519e-02f, -1.31922960e-01f, -6.40305830e-03f,
  -1.30076289e-01f, 9.53107774e-02f, -5.32110371e-02f, 8.83125216e-02f, 3.92953046e-02f, 6.30055647e-03f, 2.26204798e-01f, 3.76586132e-02f, 1.67551816e-01f, -6.31965548e-02f,
  1.28982626e-02f, 1.24269597e-01f, 1.05804838e-01f, -2.35877544e-01f, -2.94636011e-01f, -1.58783555e-01f, -1.49404615e-01f, 2.41932943e-01f, -4.44763243e-01f, 2.07092062e-01f,
  -3.82109582e-01f, -3.96352977e-01f, 4.00539637e-02f, -1.99541494e-01f, -3.39908570e-01f, 6.20397069e-02f, -2.79067874e-01f, -2.53815442e-01f, 1.65080782e-02f, -2.63071567e-01f,
  -2.25245163e-01f, -1.21466562e-01f, -4.23791632e-02f, 1.69440493e-01f, -1.24171488e-01f, -6.25811666e-02f, -4.16394383e-01f, -1.59829423e-01f, -2.35596597e-01f, 1.74892604e-01f,
  3.41577619e-01f, -2.90181022e-02f, 1.53499052e-01f, 2.49400735e-01f, -3.67728114e-01f, 2.47041155e-02f, 1.86162472e-01f, 1.88058034e-01f, 2.20536947e-01f, 1.31939113e-01f,
  -3.11633855e-01f, -3.38709176e-01f, -9.00385752e-02f, -1.05259471e-01f, 1.33239716e-01f, -1.01996079e-01f, -1.18705407e-01f, 1.00932084e-01f, 3.17439362e-02f, 2.24034060e-02f,
  -1.74382012e-02f, -2.40690522e-02f, -4.17295471e-02f, -7.00898543e-02f, 1.80924553e-02f, -9.15095210e-02f, -1.83676571e-01f, -2.60978695e-02f, 3.42778452e-02f, 9.96222794e-02f,
  9.60768908e-02f, -8.59929919e-02f, 2.27563620e-01f, 8.73172283e-02f, -1.57295149e-02f, 1.91411108e-01f, -2.58170292e-02f, -2.69182593e-01f, 1.04918465e-01f, 1.45028383e-01f,
  2.82577604e-01f, 1.49890661e-01f, 1.18906731e-02f, -4.21063066e-01f, -2.31963828e-01f, 9.19567943e-02f, -3.37106407e-01f, 1.08213909e-01f, 1.17996363e-02f, -1.88087314e-01f,
  1.21275030e-01f, -4.72719789e-01f, 3.15696895e-01f, 1.66759327e-01f, -8.30527917e-02f, 2.93200146e-02f, -3.61851364e-01f, 1.22181974e-01f, 3.12891901e-01f, 1.87983513e-01f,
  1.40254527e-01f, -4.36927468e-01f, -4.09824520e-01f, -2.11900219e-01f, -3.49780321e-01f, 2.24964291e-01f, 2.41470151e-02f, -4.72666174e-01f, 8.57567787e-02f, -3.07548612e-01f,
  3.18027362e-02f, -2.53949344e-01f, -1.27352864e-01f, -2.21125752e-01f, 1.24169476e-01f, 8.47859457e-02f, 7.30852857e-02f, 2.29492914e-02f, -5.67353927e-02f, 1.37389779e-01f,
  1.61649033e-01f, -6.33487031e-02f, 8.51320699e-02f, 1.69312999e-01f, -9.46395248e-02f, -4.21268232e-02f, 1.48229627e-02f, -1.83355957e-01f, 6.71032295e-02f, -3.68472338e-02f,
  1.17811514e-02f, 6.54338077e-02f, 1.88438132e-01f, -1.70596480e-01f, -2.07419962e-01f, -3.50109100e-01f, -2.22107142e-01f, 2.14028671e-01f, -7.38052204e-02f, -1.75201535e-01f,
  -3.29413980e-01f, -7.86085576e-02f, 2.21022293e-01f, -3.36830169e-01f, -4.40670028e-02f, 2.40448818e-01f, -6.26852214e-02f, -1.96860567e-01f, -2.31720686e-01f, -3.31522018e-01f,
  -2.56138891e-01f, 1.79072008e-01f, 9.84393805e-02f, 1.47905558e-01f, 1.73183352e-01f, -9.46940482e-02f, 2.66909972e-03f, -6.77578002e-02f, -8.48428234e-02f, 2.63386130e-01f,
  3.10052991e-01f, -3.47872794e-01f, -2.46368870e-01f, 2.64988542e-01f, 9.80337113e-02f, 2.02173308e-01f, -3.12640741e-02f, -3.75420481e-01f, 1.32847562e-01f, -3.05525541e-01f,
  9.87764075e-02f, -2.33997598e-01f, -6.06866728e-04f, -8.09034705e-02f, -4.81813215e-02f, 2.67452896e-01f, 3.60427886e-01f, -3.61387730e-01f, 1.05461605e-01f, 1.02679476e-01f,
  2.90547013e-01f, 2.16132209e-01f, -5.04290573e-02f, 3.03217787e-02f, -7.36720189e-02f, 1.25513494e-01f, 7.19034374e-02f, 1.04086347e-01f, 1.25477582e-01f, 1.18763350e-01f,
  -4.86562923e-02f, 5.45153730e-02f, -1.80599228e-01f, -2.91596919e-01f, -1.43037289e-01f, 4.88431240e-03f, -8.26713815e-02f, 7.19102398e-02f, -1.85337663e-01f, 2.34952092e-01f,
  2.02282146e-02f, -2.33858928e-01f, 5.02596758e-02f, 1.66826084e-01f, -1.55941069e-01f, 2.38684401e-01f, 3.30036312e-01f, -3.45424831e-01f, -3.20347190e-01f, -4.76135701e-01f,
  3.04757535e-01f, 4.48718295e-02f, 1.34021670e-01f, -3.93938810e-01f, -1.23707198e-01f, -3.55214536e-01f, 1.84335679e-01f, -1.92726225e-01f, -4.05536652e-01f, 6.36972114e-02f,
  -1.78107828e-01f, 6.75842166e-02f, 2.33989045e-01f, 1.12461634e-01f, -1.21134132e-01f, -1.84556037e-01f, -4.49948013e-02f, 1.90035805e-01f, 2.44698584e-01f, 2.34918252e-01f,
  9.55354795e-02f, 2.14421049e-01f, -3.89486879e-01f, -1.94788173e-01f, -5.12812972e-01f, -1.68518782e-01f, -7.83313066e-02f, -5.34647703e-02f, -7.19095543e-02f, -1.13173276e-01f,
  -1.22163258e-01f, -1.79228142e-01f, 1.34505900e-02f, 2.17832431e-01f, -4.40672562e-02f, -9.16777179e-02f, -5.13739660e-02f, 6.35803491e-02f, -1.25183433e-01f, 6.98954985e-02f,
  5.30601740e-02f, -1.22353369e-02f, 5.06104678e-02f, -3.34550999e-02f, -1.64463773e-01f, -7.14185610e-02f, 1.79472446e-01f, -1.57726213e-01f, 1.40606359e-01f, 1.38105094e-01f,
  -5.14352322e-02f, -4.83958535e-02f, -1.49930045e-01f, 7.80750290e-02f, 1.77753121e-01f, -1.53750837e-01f, 1.06658995e-01f, 1.88469678e-01f, -1.23122139e-02f, 8.30723196e-02f,
  -1.17276646e-01f, -1.54987887e-01f, -3.19502175e-01f, 6.29944503e-02f, -2.75121540e-01f, 2.28454337e-01f, 3.09607863e-01f, -2.48451121e-02f, -1.87300164e-02f, -3.43137711e-01f,
  2.16893293e-02f, -1.60648718e-01f, -2.17892617e-01f, 1.91267803e-01f, -2.01496948e-02f, -2.57768571e-01f, 2.18160212e-01f, -2.69215971e-01f, -3.96532357e-01f, -6.57970980e-02f,
  -4.97723892e-02f, -2.15641320e-01f, -3.79359841e-01f, -2.11434722e-01f, -3.97293061e-01f, 2.88737863e-01f, -3.99234772e-01f, -2.69143432e-01f, 1.81763902e-01f, 2.32770696e-01f,
  2.77465731e-01f, -1.65185556e-02f, -2.83952177e-01f, 6.94910437e-02f, 3.14570218e-02f, 1.13721602e-01f, -9.34609398e-02f, -1.34627193e-01f, -3.21184732e-02f, -9.88289341e-03f,
  -1.25479400e-01f, -1.46922633e-01f, 7.59344697e-02f, 8.90242904e-02f, -1.74773365e-01f, -1.26872780e-02f, -6.90938681e-02f, 7.40475394e-03f, 9.61895585e-02f, -7.15324059e-02f,
  -3.77969667e-02f, 1.21705130e-01f, 1.04788519e-01f, -1.08724616e-01f, 5.31259999e-02f, -1.61893755e-01f, 1.24972142e-01f, 2.83735812e-01f, -4.57976796e-02f, -1.52765900e-01f,
  -3.57750878e-02f, -4.58587892e-02f, -1.71119601e-01f, 2.50442654e-01f, -2.88374007e-01f, -1.96646363e-01f, 1.48748547e-01f, -2.03165799e-01f, 1.09049156e-01f, -1.63852617e-01f,
  2.20600963e-01f, -2.00629652e-01f, -7.88228586e-02f, 1.04695626e-01f, 1.17796637e-01f, -1.36718258e-01f, -2.81661212e-01f, -2.95348614e-01f, 2.46886849e-01f, 1.61290213e-01f,
  -2.36286178e-01f, 1.13790140e-01f, -1.86452791e-01f, 3.64790857e-01f, 8.82313922e-02f, -1.93541899e-01f, 4.01919968e-02f, 9.69219357e-02f, 1.39419973e-01f, -1.00574210e-01f,
  -8.74199420e-02f, 3.38794887e-01f, 1.27616391e-01f, -1.14832960e-01f, -1.73982605e-01f, -2.60140151e-01f, -2.43235260e-01f, 3.85942869e-02f, -3.27978104e-01f, 3.68440509e-01f,
  -1.04142986e-01f, 1.87617898e-01f, 1.55809324e-03f, 6.07356941e-03f, 5.69157936e-02f, 2.79500168e-02f, -1.35739282e-01f, -4.00188342e-02f, -2.89725419e-02f, -5.47165461e-02f,
  1.67877151e-04f, -1.21113613e-01f, -7.46890754e-02f, -1.42569125e-01f, -1.60457477e-01f, 1.30063742e-01f, 6.71855807e-02f, 2.04664037e-01f, 8.80846977e-02f, -6.62861094e-02f,
  -2.64342964e-01f, -1.16128966e-01f, 2.45494679e-01f, 1.83187395e-01f, -1.60651475e-01f, 7.59620145e-02f, -2.30063751e-01f, -2.91488647e-01f, 1.97439730e-01f, 3.40718031e-01f,
  -2.16180712e-01f, -2.12238312e-01f, 5.50740324e-02f, 6.48962483e-02f, -2.83399284e-01f, -3.67599338e-01f, 1.19263507e-01f, -1.79291561e-01f, 1.89602420e-01f, 1.34777859e-01f,
  1.72623754e-01f, -3.77162635e-01f, -2.71248166e-02f, -2.91355729e-01f, 1.44195274e-01f, -1.92891359e-01f, -1.29021481e-01f, 9.94621888e-02f, -1.22493885e-01f, -2.32825235e-01f,
  -5.52532338e-02f, 2.02016771e-01f, 2.27102458e-01f, 6.08046874e-02f, 1.13238111e-01f, 1.09049678e-01f, -1.75107762e-01f, -8.02323129e-03f, -3.08747947e-01f, 9.20589864e-02f,
  1.78244874e-01f, -1.50538847e-01f, -4.99540977e-02f, 2.52669185e-01f, -1.39781564e-01f, -3.52784038e-01f, -1.39555976e-01f, -2.76996046e-02f, -1.10170720e-02f, -1.29241496e-01f,
  1.75616398e-01f, -3.10390666e-02f, 5.51016349e-03f, 6.77037090e-02f, 9.37007442e-02f, 2.35936828e-02f, 8.85556713e-02f, 1.57143518e-01f, 1.93106577e-01f, -2.01061532e-01f,
  -1.48457572e-01f, 2.15277702e-01f, -4.98859324e-02f, -4.87186462e-02f, 2.79424042e-01f, 2.01462865e-01f, 1.28101662e-01f, -2.74653018e-01f, 1.02112070e-01f, -1.50162309e-01f,
  2.46995836e-01f, 1.71684772e-01f, -3.45433980e-01f, -1.02563009e-01f, -3.37661415e-01f, 1.37820363e-01f, -1.65422007e-01f, -4.55878191e-02f, 1.24161094e-01f, -1.81682631e-01f,
  -4.10444230e-01f, 1.92475632e-01f, 4.76261564e-02f, -9.67910811e-02f, -2.91771859e-01f, 1.24744460e-01f, -2.18557745e-01f, 1.83705330e-01f, -4.22964513e-01f, -2.29401380e-01f,
  3.05728644e-01f, -2.55565137e-01f, 4.42303941e-02f, -3.84244025e-01f, -3.43455821e-01f, 8.48463550e-02f, -6.78307191e-02f, -1.47094652e-01f, -1.25068814e-01f, -2.84321398e-01f,
  8.80060643e-02f, 1.40829578e-01f, -2.16185033e-01f, 1.55352533e-01f, -2.05428854e-01f, 1.16498724e-01f, 2.00507402e-01f, 1.85260102e-01f, -2.46132985e-01f, 2.24484410e-02f,
  5.57229221e-02f, 7.93839991e-02f, -2.99193878e-02f, -1.47963911e-01f, 7.80463889e-02f, 1.14731342e-01f, -1.23820283e-01f, -1.62347451e-01f, 1.60182156e-02f, 3.90954316e-02f,
  9.54353735e-02f, 7.58546963e-02f, -6.43439889e-02f, -9.54937562e-02f, 2.77379721e-01f, -2.11911827e-01f, -1.59958880e-02f, 4.41061333e-02f, 1.95850849e-01f, 2.36323196e-02f,
  -1.09743841e-01f, 5.79076894e-02f, 8.43762606e-02f, -2.11689517e-01f, -1.81725115e-01f, -3.35920602e-01f, -6.92630634e-02f, 1.06840491e-01f, -1.84976067e-02f, 2.35301137e-01f,
  5.39712561e-03f, 1.04736462e-01f, -2.17973784e-01f, 4.08428878e-01f, 9.61149260e-02f, 5.77010475e-02f, -3.23103666e-01f, 1.62746727e-01f, 1.33832365e-01f, -2.46663868e-01f,
  -3.10104907e-01f, -4.41363528e-02f, 1.26956314e-01f, 8.72741546e-03f, -2.08433986e-01f, 2.99260467e-01f, 2.61375785e-01f, -7.78873488e-02f, 1.43181533e-01f, -4.41287845e-01f,
  -3.73273015e-01f, -1.35833785e-01f, 4.43730466e-02f, -2.22337201e-01f, 4.47265655e-02f, 1.11105748e-01f, 1.03655688e-01f, -4.41055559e-03f, 1.92372948e-01f, -1.39487550e-01f,
  4.10333741e-03f, -2.56288528e-01f, 6.01803102e-02f, -9.78918970e-02f, -3.54306921e-02f, -1.03058532e-01f, 1.07058369e-01f, 4.51795794e-02f, 3.82501073e-02f, -1.35756880e-01f,
  -5.76419719e-02f, -1.08654305e-01f, 4.60994849e-03f, -7.05340505e-02f, -1.47240385e-01f, 8.14260170e-02f, 1.14042267e-01f, 9.01252963e-04f, -1.42616481e-01f, -2.21352965e-01f,
  -2.39651605e-01f, -4.31027710e-02f, -1.32439863e-02f, -2.04561830e-01f, -1.69945911e-01f, -1.19505949e-01f, 1.27129853e-01f, -1.58630192e-01f, -8.86955559e-02f, -3.44419293e-02f,
  1.27218649e-01f, 1.23770908e-01f, 1.56519905e-01f, -7.97213912e-02f, 1.26861393e-01f, -1.26010805e-01f, -4.85068513e-03f, -2.12909371e-01f, -2.84517277e-02f, 1.01917729e-01f,
  1.07159346e-01f, 1.53834790e-01f, 2.16138706e-01f, 8.41944143e-02f, -2.28954017e-01f, -3.19039702e-01f, 3.04285288e-01f, 8.89677852e-02f, -2.51161784e-01f, -2.24338606e-01f,
  -6.84006661e-02f, 1.75726339e-02f, -2.27164447e-01f, -1.43826097e-01f, -3.16520757e-03f, -9.21360031e-03f, -2.98323989e-01f, 2.64437407e-01f, 2.27137566e-01f, -3.11473846e-01f,
  2.38393232e-01f, 2.01956958e-01f, -3.67568433e-01f, -1.79357424e-01f, -2.11998001e-01f, 2.38868088e-01f, 1.59713656e-01f, -2.38169178e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  2.71957107e-02f, 8.21281746e-02f, 5.79381362e-02f, -9.77663919e-02f, 1.44321308e-01f, 6.01844341e-02f, -2.72519588e-02f, -1.39933983e-02f, 4.78483289e-02f, -1.99755579e-02f,
  -9.43442881e-02f, -2.32790131e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    