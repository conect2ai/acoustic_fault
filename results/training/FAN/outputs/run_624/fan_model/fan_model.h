/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.12474851e-01f, 2.90863037e-01f, -9.82298851e-02f, 1.69649690e-01f, -2.10311398e-01f, -2.83480018e-01f, -9.09734890e-02f, 7.06926733e-02f, 7.44045898e-02f, 7.99158812e-02f,
  -6.75487816e-02f, 9.01924148e-02f, 2.79897541e-01f, 3.01168472e-01f, 3.58394682e-01f, 1.87162638e-01f, 2.77846724e-01f, 3.51144940e-01f, 8.73403922e-02f, 5.03836051e-02f,
  2.21471488e-01f, 4.12449419e-01f, 2.79250532e-01f, 2.88934141e-01f, 1.31441474e-01f, 1.51684523e-01f, -1.93814281e-02f, 1.37974203e-01f, 1.28254607e-01f, 3.06014597e-01f,
  8.64489451e-02f, -1.62745789e-01f, 1.63457617e-02f, 9.61387828e-02f, -5.83485179e-02f, 1.50200084e-01f, 4.49838117e-02f, 1.21623509e-01f, 7.89668486e-02f, 8.01507533e-02f,
  -4.98758582e-03f, 7.69892186e-02f, 1.54104903e-01f, 7.86904842e-02f, 7.94811025e-02f, 6.79685995e-02f, 2.34329358e-01f, 2.17223316e-01f, 1.44725561e-01f, 1.39130056e-01f,
  1.13099746e-01f, -3.96357812e-02f, -9.82507244e-02f, -5.07305227e-02f, -5.08371508e-03f, -4.24191765e-02f, 7.84327239e-02f, -9.52925831e-02f, -5.53873405e-02f, 2.24400565e-01f,
  -1.13152573e-02f, -7.16010556e-02f, -1.39785722e-01f, -6.58245087e-02f, -1.34497657e-02f, -1.54577240e-01f, -9.97792929e-02f, -9.50403959e-02f, -9.45371315e-02f, -8.35350677e-02f,
  -1.45095766e-01f, -1.01883382e-01f, -6.66343272e-02f, -8.99027586e-02f, 2.37962650e-03f, -9.53406394e-02f, -8.73350799e-02f, 2.54122564e-03f, -1.36401772e-01f, -1.49817377e-01f,
  -1.77265435e-01f, -1.55568898e-01f, -1.55783623e-01f, -4.24867347e-02f, -1.54855236e-01f, -1.20388940e-01f, -1.42337590e-01f, -1.03730626e-01f, -1.16971999e-01f, -1.68527633e-01f,
  1.61285698e-01f, -1.88597497e-02f, 7.21463636e-02f, 1.23089626e-01f, 1.97590180e-02f, 6.51265308e-02f, 2.91439909e-02f, 1.30401179e-01f, 1.00628860e-01f, 1.03854798e-01f,
  2.38027517e-03f, 1.70792878e-01f, 1.13674082e-01f, 7.14649707e-02f, 2.80770622e-02f, 4.63846847e-02f, 1.94721043e-01f, 9.29369479e-02f, 5.05902618e-02f, 2.26274077e-02f,
  1.84165403e-01f, 2.57260748e-03f, 1.97645441e-01f, 4.65852134e-02f, 2.32158452e-02f, 3.63688171e-02f, 1.47426814e-01f, 5.52508831e-02f, 3.59592326e-02f, 3.39833230e-01f,
  3.70359957e-01f, 5.36029160e-01f, 1.11410357e-01f, -1.13395587e-01f, -3.81945252e-01f, 3.31866532e-03f, 2.55163848e-01f, 7.40698576e-02f, -1.51332781e-01f, 8.88451859e-02f,
  -5.43816164e-02f, -1.41290203e-01f, 3.21342424e-02f, -4.24329937e-02f, 2.75252372e-01f, 2.43464455e-01f, 5.60851693e-02f, -6.37504756e-02f, -1.59235924e-01f, -2.03876451e-01f,
  -9.43816081e-02f, -4.76623401e-02f, -1.48176989e-02f, -3.00002415e-02f, -1.80304557e-01f, -2.44873852e-01f, 6.86640560e-04f, -5.05195633e-02f, -2.31302381e-02f, -1.52655706e-01f,
  1.26732901e-01f, 9.25346836e-02f, -6.54901005e-03f, -1.40625030e-01f, -1.22075751e-01f, 1.79140351e-03f, 3.57184447e-02f, -1.04194790e-01f, -7.96258356e-03f, 5.27827954e-03f,
  -9.64914709e-02f, -5.93353324e-02f, -1.68412343e-01f, -1.61768228e-01f, 5.69424108e-02f, -7.00721052e-03f, 4.04659398e-02f, 4.70782369e-02f, 5.57375252e-02f, -6.10001124e-02f,
  -1.22633338e-01f, -1.63279861e-01f, 2.78539360e-02f, 3.24601494e-02f, -6.20123446e-02f, -6.00552186e-02f, -5.88311888e-02f, -1.01049773e-01f, -6.68651760e-02f, 6.53515086e-02f,
  2.34008022e-02f, 2.25211568e-02f, -6.11084811e-02f, 5.29716872e-02f, 2.57795583e-02f, 2.03271061e-02f, 3.42289135e-02f, 3.63098197e-02f, 2.16194987e-02f, 3.49866338e-02f,
  5.30620776e-02f, 9.61467773e-02f, -1.75849609e-02f, 5.91101348e-02f, -4.10769694e-02f, 1.44966850e-02f, -1.90417692e-02f, 6.52920753e-02f, -5.16352989e-02f, 7.44068250e-02f,
  1.12428190e-02f, 1.67960748e-02f, -5.75996861e-02f, 1.09285749e-02f, 2.19128001e-02f, -1.91904418e-02f, -7.65131488e-02f, -8.41080397e-02f, -8.34432915e-02f, 3.38934138e-02f,
  1.26413524e-01f, 3.74126136e-02f, 1.07540719e-01f, 2.95050293e-02f, -8.44469294e-02f, -7.28715360e-02f, -6.32887706e-02f, 3.03846486e-02f, -1.31599912e-02f, -1.44019788e-02f,
  -4.36926968e-02f, 5.24987541e-02f, 5.47169857e-02f, -3.62620293e-03f, -1.04959011e-01f, 5.06526716e-02f, 2.01278888e-02f, -4.69164699e-02f, -1.56858340e-02f, -6.38159588e-02f,
  -3.73652950e-02f, 1.19040087e-01f, 1.53312057e-01f, 1.18057661e-01f, 9.44314897e-03f, -7.28173479e-02f, 2.72752512e-02f, 1.66764949e-02f, 1.71984941e-01f, 1.82656944e-01f,
  -4.77003664e-01f, 2.69300342e-01f, 1.85160860e-01f, -1.75830290e-01f, -2.45314687e-01f, 1.43972352e-01f, 3.13518941e-01f, 1.19933456e-01f, -3.89068387e-02f, 1.45216033e-01f,
  -3.48387837e-01f, -2.31711134e-01f, -5.33203557e-02f, 9.19427797e-02f, 6.14800304e-02f, 5.43257356e-01f, 3.31664175e-01f, 4.02297005e-02f, -1.19848244e-01f, -1.51028946e-01f,
  -8.37482810e-02f, -1.93583146e-01f, -2.43233696e-01f, -1.11461326e-01f, 2.77414769e-02f, -5.15729859e-02f, 2.00271085e-01f, -4.13905270e-02f, 1.34574503e-01f, 2.45162323e-01f,
  9.00555626e-02f, -9.33983698e-02f, 2.80143712e-02f, -6.81894720e-02f, -3.72744352e-02f, -6.27080770e-03f, 1.07433917e-02f, 4.60685194e-02f, -2.92678513e-02f, 1.46366581e-01f,
  -5.71212396e-02f, 2.10378766e-02f, -1.22248068e-01f, 4.83385660e-02f, -2.61335447e-02f, 3.60816754e-02f, 3.09371040e-03f, 2.75667701e-02f, 5.59887812e-02f, 1.75863691e-02f,
  -7.29326755e-02f, -8.65238458e-02f, -1.40792817e-01f, 1.06732003e-01f, 4.67483513e-02f, -3.48258391e-02f, 8.81591365e-02f, 9.20939371e-02f, -7.90101290e-03f, 2.65100390e-01f,
  1.21773385e-01f, -1.64405559e-03f, -4.60142344e-02f, -4.94070612e-02f, -1.19803352e-02f, -5.44031486e-02f, -3.08955628e-02f, -3.74241956e-02f, 1.15461098e-02f, -1.92947185e-03f,
  -1.27823856e-02f, -4.05389480e-02f, 1.16962194e-02f, -2.73786560e-02f, -1.02924788e-02f, -4.65305783e-02f, 5.77071458e-02f, 8.04931391e-03f, -4.56335545e-02f, -5.84514067e-03f,
  -3.22861671e-02f, -6.52321056e-02f, -1.22165650e-01f, -3.29880207e-03f, -4.62982766e-02f, 1.17565067e-02f, 2.68776920e-02f, -6.64429292e-02f, 1.40944319e-02f, -1.67134777e-02f,
  6.65357932e-02f, -9.60024297e-02f, 6.51495755e-02f, -4.14642831e-03f, 5.89411648e-04f, 5.39442757e-03f, -4.79365475e-02f, -9.57656838e-03f, -3.66971716e-02f, -4.22097603e-03f,
  -3.98623385e-02f, -1.01119958e-01f, -3.39979418e-02f, 5.59429675e-02f, -2.76875999e-02f, -2.00422108e-02f, 4.38975915e-03f, 5.66339716e-02f, -1.41579965e-02f, 1.06393714e-02f,
  3.58268917e-02f, 6.24944493e-02f, 4.92802747e-02f, 1.83422148e-01f, 4.83730324e-02f, 2.72433157e-03f, 1.16538160e-01f, 1.43102929e-01f, 1.49845824e-01f, 2.26265356e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -9.20443296e-01f, -4.24034625e-01f, 1.53996512e-01f, -6.83501735e-02f, 3.34956378e-01f, 4.83700544e-01f, 4.44969177e-01f, 1.62763104e-01f, 6.57829037e-03f, -2.28035450e-01f,
  -4.94453192e-01f, -3.22182596e-01f, -1.57944158e-01f, -2.01503679e-01f, -9.52731073e-02f, 3.06516409e-01f, 3.90820742e-01f, 2.82411575e-01f, 3.00235659e-01f, 1.84147105e-01f,
  1.72155425e-01f, -8.81188884e-02f, -3.36099088e-01f, -1.40346557e-01f, 4.18306887e-02f, 1.69040039e-01f, -2.34033614e-02f, -1.30472794e-01f, -1.31478921e-01f, -1.02887340e-02f,
  1.34149730e-01f, -6.10774457e-01f, 8.12676698e-02f, -2.46819481e-01f, -2.57674396e-01f, -2.93076336e-01f, -9.03249457e-02f, -1.50645435e-01f, -1.74708083e-01f, 9.40441638e-02f,
  -1.21672980e-01f, -7.81566575e-02f, 9.75021198e-02f, 2.59958226e-02f, 7.85059668e-03f, -1.19338714e-01f, -2.98429012e-01f, -2.28358999e-01f, -4.15619761e-02f, -2.28978470e-01f,
  -1.73670575e-01f, 4.68917079e-02f, 1.63761288e-01f, 9.51540172e-02f, -8.66044760e-02f, 6.41631931e-02f, -1.14739880e-01f, -1.04938157e-01f, -1.27448648e-01f, -2.59949416e-02f,
  -2.24919114e-02f, -1.70915183e-02f, -1.23444736e-01f, -3.03503368e-02f, -2.85123970e-04f, 1.05387449e-01f, 1.25837311e-01f, 3.87280039e-03f, 8.92730728e-02f, 1.64446551e-02f,
  1.21153956e-02f, 8.79137367e-02f, 6.50853142e-02f, -6.15982749e-02f, -1.29281402e-01f, 6.25070110e-02f, -2.42833532e-02f, -1.24628380e-01f, -9.71862227e-02f, 3.74135040e-02f,
  1.82219893e-02f, 1.08360477e-01f, -4.53818105e-02f, 8.46469998e-02f, -1.52087957e-01f, 1.45875774e-02f, -7.60817453e-02f, -1.75052404e-01f, 8.70479494e-02f, -2.56253276e-02f,
  2.03321844e-01f, -7.69021586e-02f, 2.27899730e-01f, 7.91081116e-02f, 9.21881422e-02f, -1.77926540e-01f, -2.86240838e-02f, -5.72985560e-02f, 3.65339145e-02f, 2.44039997e-01f,
  -1.34296402e-01f, 7.85811767e-02f, 7.50064291e-03f, 2.53145397e-03f, 1.83714837e-01f, 8.74874145e-02f, -3.14076275e-01f, 3.52820382e-02f, 3.77014093e-02f, -4.78610881e-02f,
  2.29917224e-02f, 2.37660244e-01f, 2.18743190e-01f, 2.46876016e-01f, 9.49564129e-02f, 2.44817987e-01f, 2.24451780e-01f, 9.79124680e-02f, 2.82599539e-01f, 3.10006440e-01f,
  -4.66728777e-01f, -6.51977882e-02f, -3.95838469e-01f, -6.63065255e-01f, -6.76513016e-01f, -2.33274251e-01f, -4.03547883e-01f, -1.13706753e-01f, -1.39186755e-01f, -1.05605662e-01f,
  1.04004003e-01f, -6.94192797e-02f, 5.99817708e-02f, -1.72612727e-01f, -2.29965225e-01f, -2.46293783e-01f, -2.52391428e-01f, -5.22706568e-01f, -5.73286474e-01f, -4.93382931e-01f,
  -6.25561416e-01f, -8.61504316e-01f, -6.52881265e-01f, -4.78101224e-01f, -4.41916794e-01f, -2.87673175e-01f, -2.54882932e-01f, -4.45984870e-01f, -5.83106056e-02f, -2.75178432e-01f,
  -4.83663410e-01f, 1.25633523e-01f, -2.41128594e-01f, 3.28745297e-03f, -2.32354194e-01f, 2.94455327e-02f, -1.62486926e-01f, -6.90679103e-02f, 9.71988589e-02f, -5.04748002e-02f,
  -1.76354535e-02f, -2.97844200e-03f, -1.12834573e-01f, -1.52628690e-01f, -2.55039543e-01f, -6.58801496e-02f, 6.08333796e-02f, -1.39859080e-01f, 2.24782646e-01f, 2.28347719e-01f,
  2.46992141e-01f, 2.13539168e-01f, 3.00907642e-01f, 1.31813705e-01f, 2.74642944e-01f, 4.49277051e-02f, 1.32568479e-01f, 1.30747944e-01f, 2.76356757e-01f, -2.51337029e-02f,
  -2.18781710e-01f, 9.16747898e-02f, 4.57354374e-02f, -3.60107087e-02f, 4.06813510e-02f, 1.44735590e-01f, 5.61813191e-02f, -1.99500583e-02f, -3.02572884e-02f, -6.45736977e-02f,
  -3.28467190e-02f, 2.11958736e-01f, -4.02197475e-03f, -3.87960821e-02f, 2.88689230e-02f, 5.74187338e-02f, 6.77700266e-02f, 2.03383416e-02f, 6.83461428e-02f, 1.34375677e-01f,
  1.43133402e-01f, 2.04519346e-01f, 9.04062986e-02f, 1.14012416e-03f, 1.03690386e-01f, 3.14421020e-02f, 1.51325479e-01f, 4.45257612e-02f, 5.41107310e-03f, 8.01470876e-02f,
  -6.36035919e-01f, 1.94371447e-01f, -4.29261364e-02f, 1.02936581e-01f, -6.33976283e-03f, 3.67544815e-02f, 3.39331254e-02f, -6.84843212e-02f, -1.49426818e-01f, -2.43503198e-01f,
  5.02931252e-02f, 3.74972797e-03f, -6.47858754e-02f, 5.95548898e-02f, -6.97759539e-02f, 7.36865625e-02f, 5.83264828e-02f, -5.20079629e-03f, 2.68697858e-01f, 2.16694653e-01f,
  2.75941521e-01f, 2.80464739e-01f, 4.74881344e-02f, 9.55125466e-02f, 1.13169484e-01f, 7.28530483e-03f, 6.40688417e-03f, 9.83367488e-02f, 1.65267304e-01f, -1.12465397e-01f,
  8.62938523e-01f, -7.10944891e-01f, -9.01790440e-01f, 1.36637121e-01f, -6.05036616e-01f, -5.73077679e-01f, -6.68579400e-01f, 4.95955460e-02f, 1.37318254e-01f, -5.11441469e-01f,
  -1.56806663e-01f, 6.33686960e-01f, 5.59400260e-01f, 5.50166547e-01f, 6.43513262e-01f, -7.94355094e-01f, -5.91216266e-01f, 1.70159250e-01f, 5.85378051e-01f, 1.04941659e-01f,
  2.33090799e-02f, 2.18778595e-01f, 6.21000886e-01f, 2.59240121e-01f, -4.86560166e-01f, -2.15547979e-02f, -6.87666178e-01f, -3.65738153e-01f, -4.32392508e-01f, -9.80406344e-01f,
  -5.94356477e-01f, -4.42279041e-01f, 1.40262321e-01f, 2.76884913e-01f, -2.22606078e-01f, 5.19583337e-02f, -7.34998137e-02f, -3.39767002e-02f, -5.55956699e-02f, -2.46711493e-01f,
  -1.28700929e-02f, 1.59921303e-01f, 7.48309717e-02f, -1.64842755e-01f, -1.65309802e-01f, -1.62726328e-01f, 6.61197752e-02f, 5.44330291e-02f, 3.84457186e-02f, -2.73276418e-01f,
  -3.68052900e-01f, -3.12197983e-01f, -2.60957956e-01f, -2.39304185e-01f, -1.62001714e-01f, 2.19717503e-01f, -3.16581041e-01f, -1.70659751e-01f, -6.95792958e-02f, -6.04299605e-01f,
  1.05953366e-02f, -1.51157498e-01f, -5.94615266e-02f, 2.98894141e-02f, 8.92261490e-02f, -5.39576225e-02f, 9.07117724e-02f, 6.43942563e-04f, -7.47299334e-03f, -3.93964984e-02f,
  4.26714309e-02f, -1.49443448e-02f, 5.32775447e-02f, -1.71273828e-01f, -4.44756411e-02f, -8.50918330e-03f, -1.46780550e-01f, 1.41624033e-01f, 3.00074778e-02f, 6.51295707e-02f,
  2.55923737e-02f, -4.66707572e-02f, 7.02796578e-02f, 1.11213326e-01f, -1.18438773e-01f, 2.22108841e-01f, 1.43156238e-02f, 1.67312846e-01f, 3.04450899e-01f, -3.49796452e-02f,
  5.15727282e-01f, 3.05142313e-01f, -1.09890312e-01f, 3.23487729e-01f, -1.97405845e-01f, -1.10644244e-01f, -2.23822221e-01f, 2.21576035e-01f, -8.02509114e-03f, 6.98696896e-02f,
  4.20395937e-03f, 1.21308558e-01f, -6.47490621e-02f, -2.06534594e-01f, 4.84357961e-02f, -3.00805643e-02f, 1.83028221e-01f, 1.32376969e-01f, -5.54170012e-02f, -1.39557362e-01f,
  5.85925989e-02f, 8.05122852e-02f, 2.86436379e-01f, 9.67119485e-02f, -1.22228228e-01f, 1.96211040e-01f, -2.90427238e-01f, -1.70122892e-01f, 2.42106944e-01f, 5.59621211e-03f,
  5.85583627e-01f, 3.79393250e-01f, -3.05925068e-02f, -1.02124199e-01f, 1.58214092e-01f, 4.21709448e-01f, 6.09014273e-01f, 3.05873305e-01f, -5.55448420e-02f, 3.01924467e-01f,
  5.18682957e-01f, 6.94726557e-02f, -3.42893451e-02f, -3.23161595e-02f, 7.67454356e-02f, -1.39055261e-02f, -1.82131067e-01f, -3.14549297e-01f, -1.39073893e-01f, 6.23990446e-02f,
  -7.34213665e-02f, 5.85272349e-02f, 1.35222107e-01f, -1.88865140e-01f, -2.19187245e-01f, -1.67052582e-01f, 1.41576886e-01f, -3.76970060e-02f, -1.14793992e-02f, -6.41595542e-01f,
  -2.16725364e-01f, 2.34522372e-01f, -1.62105069e-01f, -1.67133093e-01f, 1.68581933e-01f, 2.75227651e-02f, 6.67061508e-02f, 1.31793305e-01f, 2.25765198e-01f, 8.12526979e-03f,
  -1.60787866e-01f, 3.86453420e-02f, 2.25980714e-01f, 1.01514764e-01f, 5.97582497e-02f, 4.23035696e-02f, -2.10271049e-02f, -5.90945296e-02f, -1.14124222e-02f, -6.04788177e-02f,
  -1.01919197e-01f, 2.20067501e-01f, 6.81584477e-02f, 6.23453557e-02f, -1.73193980e-02f, -5.47437146e-02f, 1.29695922e-01f, -1.09018378e-01f, -1.22304752e-01f, -1.62011489e-01f,
  1.72089592e-01f, 1.95447192e-01f, 8.81994888e-02f, 1.32378578e-01f, 2.93592125e-01f, 9.37234238e-02f, -1.46403253e-01f, 3.07765673e-03f, 1.32598475e-01f, 9.08671245e-02f,
  -2.10493416e-01f, 1.97705686e-01f, 2.75653720e-01f, 2.34355912e-01f, 6.66713789e-02f, 1.75884753e-01f, 1.82233192e-03f, 1.33138910e-01f, 1.77374884e-01f, 1.51174068e-01f,
  4.46917191e-02f, -8.03921546e-04f, -5.44985421e-02f, 7.42807090e-02f, 1.88335761e-01f, 1.46613732e-01f, 2.94702481e-02f, 3.58347744e-01f, 2.33157247e-01f, 2.71179497e-01f,
  1.43580455e-02f, 4.70018148e-01f, -1.79706022e-01f, -3.29561204e-01f, -1.11757725e-01f, -5.30997291e-02f, -6.48035109e-02f, -6.40502647e-02f, 8.63452256e-03f, -1.36303231e-01f,
  -2.79320795e-02f, -1.85297787e-01f, 2.96365738e-01f, 5.75506575e-02f, -1.47955623e-02f, -1.25642449e-01f, -4.30677757e-02f, -1.33905828e-01f, -1.04586370e-01f, -3.73034865e-01f,
  -2.62901217e-01f, -1.21717192e-02f, -5.08320378e-03f, -1.10767134e-01f, -1.44377872e-01f, -9.20343101e-02f, -7.93066621e-03f, 1.10295528e-04f, 4.36428264e-02f, 9.13779512e-02f,
  7.12045610e-01f, 4.37395155e-01f, 6.00837111e-01f, 3.76745582e-01f, 5.52111685e-01f, 5.34284174e-01f, 5.20510912e-01f, 2.39966571e-01f, 4.32020612e-02f, 1.31791785e-01f,
  3.30369592e-01f, -5.85712381e-02f, -8.93492326e-02f, 4.35231328e-02f, 3.89026701e-02f, 1.59898579e-01f, 5.27008511e-02f, 5.32877631e-02f, 6.76242933e-02f, 1.73591316e-01f,
  -2.89821178e-02f, -1.02715351e-01f, -6.83604702e-02f, 4.36291471e-02f, -8.03882908e-03f, -1.00000262e-01f, 3.13308500e-02f, 2.64324129e-01f, 4.52433825e-02f, -1.44107267e-01f,
  -2.08119169e-01f, 2.54171878e-01f, -2.88015157e-01f, -3.34141664e-02f, 4.87165004e-02f, -3.89607131e-01f, -9.07593220e-02f, -2.58828461e-01f, -1.30062416e-01f, -1.45619974e-01f,
  2.53796428e-02f, -7.97135606e-02f, 1.63932040e-01f, -1.37711078e-01f, -1.28254015e-02f, -6.32810965e-02f, -4.68822271e-02f, -8.76560435e-02f, -2.40492970e-02f, -1.36458408e-02f,
  -6.34558573e-02f, 1.66501760e-01f, 2.64072925e-01f, 2.09240228e-01f, 2.30065346e-01f, 7.31992498e-02f, 1.27759352e-01f, 1.85633972e-02f, 2.07929268e-01f, 3.37176174e-02f,
  -3.34504664e-01f, 1.63964987e-01f, 3.59789401e-01f, -3.38368043e-02f, 1.37075940e-02f, -8.46679658e-02f, 2.91291736e-02f, 1.29830420e-01f, 9.86953229e-02f, 1.56336308e-01f,
  2.81083602e-02f, 2.79172044e-02f, -7.37495488e-03f, -5.28916754e-02f, -1.43364981e-01f, 3.30894738e-02f, 5.82801141e-02f, 2.21051760e-02f, 9.52495858e-02f, -5.35034761e-02f,
  3.51825915e-02f, 3.86294089e-02f, -8.33613724e-02f, -2.71886196e-02f, -2.56207228e-01f, -4.47320156e-02f, -6.23810068e-02f, -5.54033220e-02f, -9.16386861e-03f, -1.41286448e-01f,
  -5.41584015e-01f, 1.20058611e-01f, -2.48100176e-01f, -1.55290976e-01f, 1.47733003e-01f, 2.91488180e-03f, 1.01995766e-02f, -2.16612950e-01f, -1.94894284e-01f, -1.41753182e-01f,
  1.65789563e-03f, 6.72696754e-02f, -5.67900948e-03f, -1.40517935e-01f, -9.83266756e-02f, -1.72794491e-01f, -1.38819292e-01f, -1.71892866e-01f, -1.22803405e-01f, -7.33079091e-02f,
  -1.54429292e-02f, -4.26485091e-02f, 1.20389266e-02f, 2.19258503e-03f, -1.75298184e-01f, -2.17490479e-01f, -1.87786356e-01f, -1.79871470e-01f, 5.32292388e-02f, -1.50049403e-01f,
  6.05706573e-01f, 9.37780201e-01f, -2.69380182e-01f, 1.18763790e-01f, -1.95362881e-01f, -1.41604245e-01f, 4.22849298e-01f, 2.82523692e-01f, -1.64788906e-02f, 7.43295997e-02f,
  -1.40281945e-01f, -2.10623309e-01f, -2.38067601e-02f, -1.12704098e-01f, 7.46522248e-02f, 2.66550183e-01f, 2.11704180e-01f, -8.32433328e-02f, -2.94662744e-01f, 7.89188966e-03f,
  -2.38745101e-02f, 1.91658512e-01f, 1.94024563e-01f, 1.11775458e-01f, 2.42434368e-01f, -2.51162529e-01f, -8.84914957e-03f, 3.69575690e-03f, -4.48367670e-02f, 4.46558088e-01f,
  -5.61913073e-01f, 2.12742254e-01f, -5.92103779e-01f, -1.67752489e-01f, -1.16761781e-01f, 1.05501391e-01f, 2.10379303e-01f, 1.81136742e-01f, 8.47730339e-02f, 1.13436162e-01f,
  -6.95339143e-02f, 6.10441417e-02f, 1.63176626e-01f, 5.45301624e-02f, 1.14359342e-01f, -1.06440455e-01f, 2.36601502e-01f, 1.57182887e-01f, -1.18789636e-01f, -4.82660308e-02f,
  5.03555723e-02f, -1.46107720e-02f, -1.04833528e-01f, -4.29225527e-03f, -3.03091705e-02f, -4.89679486e-01f, -9.88615863e-03f, 3.51234302e-02f, -1.88461810e-01f, 3.63292307e-01f,
  2.80576590e-02f, 1.47955688e-02f, 1.53346106e-01f, 3.54417980e-01f, 1.43312529e-01f, -4.80315723e-02f, 1.21172238e-03f, -3.69636677e-02f, -1.06913418e-01f, 2.53697455e-01f,
  -8.70266035e-02f, -2.92142570e-01f, -1.36573076e-01f, -5.86312823e-02f, -2.63982117e-01f, 8.83424729e-02f, 8.19235221e-02f, 4.87652868e-02f, -1.52260557e-01f, 5.09457476e-02f,
  4.30463348e-03f, -4.69443649e-02f, -2.20484272e-01f, 1.58398688e-01f, -3.68576236e-02f, 1.81815829e-02f, 1.40412189e-02f, -2.55089086e-02f, 1.34568289e-01f, 1.11751787e-01f,
  -1.84977397e-01f, -5.88378787e-01f, -4.33901846e-02f, 3.51231098e-01f, -1.62526116e-01f, -4.30513531e-01f, -1.65846899e-01f, -2.13831306e-01f, -1.25040665e-01f, -2.49692909e-02f,
  1.19620524e-01f, 1.81061365e-02f, 7.76889399e-02f, 1.17134064e-01f, -1.84144258e-01f, -1.55790940e-01f, -1.45883132e-02f, 7.02228770e-02f, 4.14098762e-02f, -1.74387023e-02f,
  1.01843424e-01f, -1.63170099e-01f, -6.36259839e-02f, -1.14152774e-01f, -1.26280919e-01f, -4.58096087e-01f, -2.38959983e-01f, -1.69854864e-01f, -2.48859763e-01f, 2.12908566e-01f,
  2.51798183e-01f, -4.68945086e-01f, 2.79158235e-01f, -1.53551966e-01f, -2.78604984e-01f, -2.41258666e-01f, -6.43117189e-01f, -2.82811671e-01f, -1.52346760e-01f, -3.13989103e-01f,
  5.22245020e-02f, 5.34719110e-01f, 5.08014083e-01f, 1.38398677e-01f, 5.74486777e-02f, -3.91377985e-01f, -5.19603431e-01f, 5.57665378e-02f, 9.77842286e-02f, -5.27405918e-01f,
  -5.41661978e-01f, -4.07053322e-01f, -1.93972632e-01f, -1.72839448e-01f, -3.33776295e-01f, 1.04825452e-01f, -1.15887493e-01f, -3.48229170e-01f, -3.34797174e-01f, -2.74046451e-01f,
  4.25339341e-01f, 8.39303061e-02f, 5.44099435e-02f, -5.82340322e-02f, -1.36623293e-01f, 7.52236918e-02f, 8.50259364e-02f, -6.57042190e-02f, 7.26206675e-02f, 5.70252128e-02f,
  -1.01847552e-01f, -1.09059073e-01f, 2.68338583e-02f, 4.24238369e-02f, -6.40217364e-02f, -1.96054988e-02f, -2.58459300e-01f, -8.29734504e-02f, -3.72620858e-02f, -1.73023850e-01f,
  -1.61692426e-01f, -7.69904852e-02f, 1.94138706e-01f, -3.37827653e-02f, 3.57869565e-02f, 1.28612116e-01f, -6.12928160e-02f, -3.06422263e-02f, 1.20486751e-01f, -3.23188342e-02f,
  -1.11474849e-01f, 1.32249758e-01f, -4.89185080e-02f, -1.78709999e-02f, -1.16060544e-02f, 8.82242899e-03f, 9.89386514e-02f, 4.84809987e-02f, -7.09671974e-02f, 1.34288650e-02f,
  -1.06520230e-04f, 3.06593869e-02f, 9.03782472e-02f, -2.77655534e-02f, -1.25335967e-02f, -5.81391454e-02f, 9.54630673e-02f, -1.21062458e-01f, -3.30089852e-02f, -2.32474618e-02f,
  -5.41881733e-02f, -1.18209727e-01f, 3.85091417e-02f, -1.27106249e-01f, -1.82078034e-01f, 3.24515323e-03f, -4.96971048e-03f, 7.96326399e-02f, 1.08947806e-01f, 1.18263473e-03f,
  5.17676532e-01f, 8.26663226e-02f, 1.18964620e-01f, -6.39315275e-03f, 6.09497912e-03f, -1.49034381e-01f, 1.29285147e-02f, -1.21637873e-01f, 7.17601478e-02f, 6.91126287e-03f,
  -8.52719247e-02f, 4.54798453e-02f, -4.89187688e-02f, -1.21536173e-01f, 3.42318811e-03f, -8.39399770e-02f, -2.41040111e-01f, -9.23651457e-02f, -2.80724838e-02f, -1.45521656e-01f,
  -2.95871615e-01f, -1.65875014e-02f, 1.88217849e-01f, 1.99291885e-01f, 5.43022752e-02f, 2.94046938e-01f, 1.77605674e-01f, 5.05166082e-03f, 1.77039862e-01f, -1.41178489e-01f,
  6.60792708e-01f, -2.67505109e-01f, -2.26734698e-01f, 7.94190764e-02f, -3.67308766e-01f, -2.12323859e-01f, -3.98638487e-01f, -6.19241968e-02f, 5.02356179e-02f, -3.05382982e-02f,
  -3.70490402e-02f, 3.11394840e-01f, 2.52549767e-01f, 1.86581403e-01f, 2.33657822e-01f, -1.25183076e-01f, 1.78369358e-02f, 2.00159997e-01f, 1.48547500e-01f, -1.87343210e-01f,
  -1.84275985e-01f, -1.06021784e-01f, 2.18733206e-01f, 8.81981477e-02f, -2.38562047e-01f, -2.51323404e-03f, -9.51696783e-02f, -1.98060796e-01f, -2.35186100e-01f, -2.68602401e-01f,
  -3.59926581e-01f, 4.32711765e-02f, 3.18899661e-01f, 1.95081383e-01f, 1.40215814e-01f, 1.51010036e-01f, 2.06817277e-02f, -3.52113582e-02f, -8.78746733e-02f, -1.52257010e-01f,
  1.23096807e-02f, -5.79160936e-02f, 9.27722752e-02f, -3.11003104e-02f, -1.10116914e-01f, -5.19165695e-02f, 4.62676100e-02f, 6.10951222e-02f, 6.50093378e-03f, -9.09941420e-02f,
  5.41348346e-02f, -7.31948912e-02f, -2.09375247e-01f, 3.53453606e-02f, 1.88657284e-01f, 9.71410722e-02f, -5.06404527e-02f, 4.10765707e-02f, 1.10646576e-01f, 6.90293983e-02f,
  3.20837237e-02f, 1.24299079e-01f, 2.99028695e-01f, 2.36381710e-01f, 1.28735885e-01f, 5.40712439e-02f, -1.10454105e-01f, -9.65323672e-02f, 1.41976595e-01f, 6.79060668e-02f,
  -1.68943837e-01f, 2.67454442e-02f, 1.45304985e-02f, 8.63604844e-02f, 1.05711333e-01f, -7.87614882e-02f, -1.56729937e-01f, 8.82986784e-02f, 1.48944005e-01f, 5.31792920e-03f,
  1.90143421e-01f, -1.54453546e-01f, -1.17290325e-01f, 1.48450630e-02f, -1.48110583e-01f, -2.12232731e-02f, -1.37336493e-01f, -7.27668926e-02f, -1.16939126e-02f, -1.58775881e-01f,
  -2.11475044e-01f, 5.15834689e-01f, 1.89824417e-01f, 8.30692649e-02f, -2.76350621e-02f, 5.01999520e-02f, 1.88647225e-01f, -1.41693309e-01f, -1.18384130e-01f, -1.02709264e-01f,
  -1.35896921e-01f, 7.78190559e-03f, 1.41845733e-01f, 1.16817415e-01f, 1.21477038e-01f, 4.84378934e-02f, 1.81545705e-01f, 1.13773204e-01f, 3.54939364e-02f, -1.46656677e-01f,
  -7.87624344e-02f, -4.57608402e-02f, -8.34765658e-02f, 1.65484428e-01f, 9.78421494e-02f, 1.44854277e-01f, 6.57975748e-02f, 2.56412011e-02f, 8.66574049e-02f, -1.04752658e-02f,
  -1.78301290e-01f, -6.74693227e-01f, -3.94483507e-01f, -6.00784063e-01f, -6.81489408e-02f, -2.95294583e-01f, -6.64441884e-01f, -5.48118532e-01f, -2.71080017e-01f, -4.97917652e-01f,
  5.25338873e-02f, 6.28897190e-01f, -1.31901965e-01f, 2.56493259e-02f, -4.86650795e-01f, -7.26118207e-01f, -5.74161589e-01f, -2.39361346e-01f, 3.40875000e-01f, 6.49159849e-01f,
  4.01494414e-01f, 1.65985703e-01f, 1.09581321e-01f, 2.18104318e-01f, -1.65665597e-01f, 2.44048283e-01f, -2.05308184e-01f, -1.41630054e-01f, -4.19163220e-02f, -3.11863691e-01f,
  -4.52687293e-01f, -4.47026879e-01f, 1.59626245e-01f, 4.18428570e-01f, 1.71393096e-01f, -1.88902959e-01f, -3.06657642e-01f, -3.00675839e-01f, 1.06741861e-01f, -2.19616696e-01f,
  2.11235464e-01f, 1.39660195e-01f, 9.45915729e-02f, 8.26520175e-02f, -1.25100538e-01f, -2.12758392e-01f, -3.82801473e-01f, -1.52780294e-01f, -2.52991349e-01f, -2.75435776e-01f,
  1.28213331e-01f, 2.51613349e-01f, -3.97183865e-01f, -1.78553313e-01f, -4.68801111e-01f, 1.44113138e-01f, -1.06492370e-01f, 7.01355934e-02f, -4.01798904e-01f, -5.06289482e-01f,
  3.31846699e-02f, -4.78839092e-02f, -1.19482026e-01f, -1.85730919e-01f, 8.65585208e-02f, -6.89435378e-02f, -6.88032582e-02f, -2.84114592e-02f, 1.97085962e-01f, -2.17592865e-01f,
  -9.59780766e-04f, -1.77174091e-01f, 6.93552643e-02f, -1.23909026e-01f, 1.00580081e-01f, -1.46285240e-02f, 1.13882296e-01f, -1.10483266e-01f, 4.26698588e-02f, -5.66930790e-03f,
  5.54089658e-02f, 5.71445888e-03f, -1.25374362e-01f, 1.35513857e-01f, 7.25185452e-03f, -1.06244542e-01f, -6.09201342e-02f, 4.15671915e-02f, -1.64729968e-01f, 3.65370698e-02f,
  -3.20946246e-01f, 4.49885458e-01f, -3.96566331e-01f, 5.14820628e-02f, -1.43778518e-01f, 1.40471429e-01f, -9.35762376e-03f, 4.93875407e-02f, -2.57605314e-02f, -4.51698974e-02f,
  -4.27801348e-02f, -1.60558268e-01f, -2.79994279e-01f, 2.43516713e-01f, 1.13529690e-01f, -1.02142617e-01f, -3.29326361e-01f, 1.83535859e-01f, 1.27204910e-01f, 6.06259564e-03f,
  -4.45657790e-01f, -2.17712134e-01f, -4.65757400e-01f, -3.68183821e-01f, -2.66313672e-01f, -1.13632262e-01f, -1.60934463e-01f, -4.35466655e-02f, -4.11267042e-01f, -6.05859458e-01f,
  -4.45944488e-01f, -5.17097354e-01f, 3.04497480e-01f, -1.25827894e-01f, -7.96686783e-02f, -4.29319888e-01f, -6.81840479e-01f, -4.77450997e-01f, -3.71697515e-01f, -1.11752205e-01f,
  2.33445451e-01f, 5.68978488e-01f, 5.32974303e-01f, 4.38790143e-01f, 1.08415663e-01f, -1.78579479e-01f, -1.99943632e-01f, 3.93441319e-01f, 5.24284244e-01f, 1.09083392e-01f,
  6.43869862e-02f, 1.35164276e-01f, 1.96948156e-01f, -3.62092927e-02f, -1.63916901e-01f, 3.36101443e-01f, -1.30426764e-01f, -7.33079538e-02f, -5.43354861e-02f, 1.10101951e-02f,
  7.63724983e-01f, -6.19506478e-01f, 1.46244660e-01f, -3.41192298e-02f, 1.47998780e-01f, -1.29086018e-01f, -5.90656959e-02f, -2.47752085e-01f, -4.12017971e-01f, -3.09584737e-01f,
  -1.17331356e-01f, -6.85202628e-02f, -8.21670815e-02f, -1.35811837e-02f, -1.28670156e-01f, -1.07035302e-01f, -5.55021986e-02f, -1.33005396e-01f, -7.81303197e-02f, 6.41902164e-02f,
  1.19772181e-01f, 1.25969620e-02f, -2.18070652e-02f, -1.15833558e-01f, -2.37162098e-01f, 1.52088657e-01f, -1.66923270e-01f, -1.71873271e-01f, -1.60966933e-01f, -2.66947836e-01f,
  3.65307406e-02f, 3.05968463e-01f, 1.58513173e-01f, 3.94125804e-02f, 1.86066031e-02f, -1.06340885e-01f, 2.41046716e-02f, 2.53275096e-01f, -5.72806317e-03f, 1.78756043e-02f,
  -6.11399242e-04f, 8.23859647e-02f, -3.69320028e-02f, -2.47684315e-01f, 1.19371535e-02f, -2.25603059e-02f, 8.19439627e-03f, -4.25671414e-02f, -6.92589730e-02f, -1.23851620e-01f,
  8.93559959e-03f, -1.06733412e-01f, 1.02524996e-01f, -4.84805182e-02f, -7.93360770e-02f, 6.83412477e-02f, -6.42056391e-02f, 2.77751923e-01f, 2.71092415e-01f, -1.14744797e-01f,
  2.99880207e-01f, -1.78914264e-01f, 1.63234025e-01f, 1.45359356e-02f, -1.42504871e-01f, -8.15250501e-02f, -9.39773470e-02f, -1.26374409e-01f, -1.68370202e-01f, -2.05188811e-01f,
  -3.82123515e-02f, -1.29738346e-01f, -1.44873969e-02f, -9.79572069e-03f, 5.85058378e-03f, -9.64364484e-02f, -5.36663458e-03f, 1.38198927e-01f, -1.18823968e-01f, -4.28529456e-02f,
  -1.13942295e-01f, -2.90013105e-01f, 3.24914664e-01f, 1.08725362e-01f, -9.25180409e-03f, 2.09838852e-01f, 3.04510474e-01f, 1.48288891e-01f, 1.21479407e-01f, -8.25258791e-02f,
  4.45096850e-01f, 1.02195732e-01f, 2.18245596e-01f, 3.98466051e-01f, -6.03311025e-02f, -5.18598139e-01f, -9.79665339e-01f, -3.76419157e-01f, 3.54827493e-01f, -1.41656501e-02f,
  3.47718503e-03f, 1.39183924e-01f, 5.30608557e-02f, -1.72449738e-01f, -5.71060002e-01f, -4.33319807e-01f, -1.19861916e-01f, -1.04681194e-01f, -4.84811783e-01f, -4.61151928e-01f,
  -2.06057221e-01f, -9.53954384e-02f, 7.59841427e-02f, 2.99768969e-02f, 6.61191821e-01f, 2.48347834e-01f, 2.89462328e-01f, 2.24564582e-01f, -2.44704932e-02f, 7.21310318e-01f,
  3.44217241e-01f, 4.68439400e-01f, -3.76601964e-01f, 7.63178319e-02f, 1.69346705e-01f, 7.96571895e-02f, -3.00973412e-02f, 2.93389440e-01f, -1.13785313e-02f, 7.21683279e-02f,
  8.02397430e-02f, 8.00562799e-02f, 5.92484213e-02f, 7.22367018e-02f, 3.75387110e-02f, -1.24206938e-01f, 6.78022876e-02f, 8.35320875e-02f, 4.32143435e-02f, 9.61489975e-02f,
  -2.14817077e-01f, -7.99538121e-02f, -6.87904581e-02f, -1.31395251e-01f, 1.13668419e-01f, 2.52209604e-03f, -7.82073289e-02f, 2.74610072e-01f, -1.22593015e-01f, 3.43881696e-01f,
  1.12193385e-02f, 1.76230714e-01f, 1.12509176e-01f, 1.07966430e-01f, -9.75755882e-03f, 1.37949884e-01f, 7.96984062e-02f, -1.67365596e-01f, 1.18295439e-01f, 6.75360486e-03f,
  -1.59004051e-02f, 1.61965355e-01f, 2.42849529e-01f, 8.36088806e-02f, -2.92611178e-02f, 1.59653828e-01f, 6.58844858e-02f, -1.41360983e-01f, -6.87699839e-02f, 8.97822678e-02f,
  1.93014983e-02f, -4.22827266e-02f, 1.94599956e-01f, 3.93090732e-02f, 7.98113421e-02f, 1.49824709e-01f, 9.90294591e-02f, 6.45850971e-02f, 2.07151398e-02f, 6.34769723e-02f,
  2.29166541e-02f, -6.02140248e-01f, 1.04731724e-01f, 3.57165113e-02f, 8.60404745e-02f, 1.13226429e-01f, 8.80980045e-02f, -1.05384231e-01f, 1.90032959e-01f, -1.63419873e-01f,
  -1.13059759e-01f, 2.44744793e-02f, -1.87883545e-02f, 3.45147103e-02f, -2.24528179e-01f, 6.39417917e-02f, -2.46121287e-01f, -2.88724136e-02f, -8.11944529e-02f, 1.39761508e-01f,
  -1.45761013e-01f, -5.11292398e-01f, -6.40375137e-01f, -3.83381307e-01f, -5.75265624e-02f, -3.71018261e-01f, -2.10631087e-01f, -1.39162242e-01f, -5.42782843e-01f, -6.05530202e-01f,
  6.66734099e-01f, 1.91821262e-01f, 3.26856673e-01f, 1.73908114e-01f, -3.61831963e-01f, -6.46108091e-01f, -7.48513043e-01f, -4.28426057e-01f, -2.09847942e-01f, -9.44682956e-02f,
  -1.78284019e-01f, -1.15405738e-01f, -1.01827748e-01f, 6.21256009e-02f, 2.58753926e-01f, 1.51164625e-02f, 3.34895998e-01f, 5.96765876e-01f, 3.17020893e-01f, 1.75569147e-01f,
  6.38491660e-02f, 2.45014668e-01f, 5.80129385e-01f, 2.97355235e-01f, 2.24248290e-01f, 8.04048870e-03f, 1.02768593e-01f, 1.96834385e-01f, 1.10666491e-01f, 5.41510165e-01f,
  5.03049433e-01f, 7.90434927e-02f, -4.22705323e-01f, 7.57943606e-03f, -1.58079080e-02f, 1.34751022e-01f, -2.62250584e-02f, 1.67690665e-01f, 6.62332103e-02f, 1.10410780e-01f,
  -3.89581621e-02f, 2.82667391e-02f, -3.57876904e-03f, 1.45255610e-01f, -1.26101999e-02f, -1.76958531e-01f, 1.65502310e-01f, 2.61726797e-01f, 4.60792147e-02f, 6.15015589e-02f,
  4.05762391e-03f, -3.23581472e-02f, -1.08288854e-01f, -4.18048918e-01f, -1.05061397e-01f, -1.91607736e-02f, -6.96450248e-02f, -5.74903600e-02f, -2.01521665e-01f, 1.84875742e-01f,
  -2.27385044e-01f, 1.37886941e-01f, 7.62870312e-02f, 1.99613690e-01f, 9.11694542e-02f, -2.68041622e-02f, 1.02235921e-01f, 5.72989099e-02f, 1.79104120e-01f, 2.26964280e-01f,
  2.63653938e-02f, 7.02587962e-02f, 1.30341053e-01f, 9.20234695e-02f, -1.26284093e-01f, 1.31668299e-01f, 2.11882129e-01f, 1.36826172e-01f, 8.30422044e-02f, 7.13169277e-02f,
  3.89610305e-02f, 5.42955883e-02f, -1.51869468e-02f, 2.13376746e-01f, 4.60243560e-02f, 1.37352556e-01f, 1.35771438e-01f, 3.01326234e-02f, 1.26003614e-02f, -3.26195955e-02f,
  -2.05695078e-01f, -4.59331304e-01f, -5.70721664e-02f, 1.66576996e-01f, -2.49761604e-02f, -1.47773713e-01f, -1.25164185e-02f, 5.24164811e-02f, -6.10198416e-02f, -8.04307777e-03f,
  -3.30926701e-02f, 7.45088309e-02f, -9.53743309e-02f, -1.08705470e-02f, -1.57598466e-01f, -3.32666069e-01f, -3.90654281e-02f, 2.37452537e-02f, -1.26003167e-02f, 3.46566029e-02f,
  1.49806619e-01f, -2.65909582e-01f, -3.22062612e-01f, -4.00194764e-01f, -4.01606798e-01f, -3.77362847e-01f, -2.98629403e-01f, -3.45176160e-01f, -5.02716839e-01f, -3.02566618e-01f,
  -6.97529376e-01f, 6.35554552e-01f, -2.36331090e-01f, -1.84177086e-01f, 3.78615737e-01f, 2.59045977e-02f, -3.71782146e-02f, -4.92987782e-01f, 7.22146928e-02f, 4.69738275e-01f,
  3.12897563e-01f, 2.57170964e-02f, 1.45792723e-01f, -3.90003212e-02f, -4.23017859e-01f, 3.97338420e-01f, 4.93756026e-01f, -5.84241092e-01f, -9.50277388e-01f, -5.28010249e-01f,
  2.16919020e-01f, -1.90139577e-01f, -4.64292407e-01f, -4.28954631e-01f, 2.68010408e-01f, 1.85180277e-01f, 3.72095793e-01f, 1.10975683e-01f, 4.16531801e-01f, 4.00605530e-01f,
  3.21422927e-02f, -4.05386209e-01f, -1.93675548e-01f, 1.75308079e-01f, 2.09036529e-01f, -9.84033421e-02f, -2.26098254e-01f, -1.34963930e-01f, 2.41865702e-02f, -4.17945124e-02f,
  2.09599137e-01f, -1.87725271e-03f, 1.20277241e-01f, -6.43483028e-02f, -4.46461001e-03f, -2.05056563e-01f, -2.13681266e-01f, -6.34027481e-01f, -5.81537962e-01f, -3.50505054e-01f,
  4.40387547e-01f, 7.16346875e-02f, -3.54321301e-01f, -3.57138574e-01f, -5.18624008e-01f, -2.34240696e-01f, -4.10447299e-01f, -6.00819170e-01f, -5.04638374e-01f, -3.57656777e-01f,
  -9.97354388e-02f, 1.02791198e-01f, 1.00664720e-01f, 2.07217615e-02f, -3.26482132e-02f, 9.39980894e-02f, 1.72534615e-01f, 1.04063109e-01f, 2.66353413e-02f, -1.42700270e-01f,
  -9.10547227e-02f, -9.92048159e-02f, -1.63480371e-01f, -9.37638655e-02f, -9.72198173e-02f, -2.31564883e-02f, -1.06060885e-01f, -4.05073911e-02f, -1.92392599e-02f, -8.84603709e-03f,
  4.30946471e-03f, 2.62234826e-02f, 1.95400700e-01f, -1.54200181e-01f, 1.88072011e-01f, 1.04028517e-02f, 1.63646981e-01f, -1.03022777e-01f, -1.98862225e-01f, 1.72493290e-02f,
  -4.31693308e-02f, 9.73001197e-02f, 2.16293316e-02f, -1.31723240e-01f, 1.78504273e-01f, -9.34719890e-02f, 5.94953448e-02f, 3.34420688e-02f, 4.44587916e-02f, -2.34508201e-01f,
  -1.32041812e-01f, -1.18532464e-01f, 2.05383986e-01f, -8.99624974e-02f, -3.47470224e-01f, -3.31607834e-02f, 4.28250819e-01f, 7.54350200e-02f, -1.00584671e-01f, 6.04326874e-02f,
  2.45756671e-01f, -1.34745792e-01f, -1.95092678e-01f, -1.51163682e-01f, 7.40793869e-02f, 3.08744740e-02f, -1.83451593e-01f, -2.96309084e-01f, -5.81161305e-02f, -1.33549243e-01f,
  7.83932984e-01f, 7.29295015e-01f, -1.47612974e-01f, 3.34450781e-01f, 3.19926649e-01f, 2.59915739e-01f, 5.47330379e-01f, 4.73758012e-01f, 2.49239013e-01f, 2.91250050e-01f,
  2.33905554e-01f, 2.07874835e-01f, 2.27487311e-01f, 7.06473067e-02f, 1.21933542e-01f, 3.06711227e-01f, 1.60334215e-01f, -8.80360156e-02f, -9.91623625e-02f, 2.13816702e-01f,
  2.28871897e-01f, 2.40409449e-01f, 5.97193018e-02f, -1.89822223e-02f, 1.65469766e-01f, 2.41676107e-01f, 2.19357401e-01f, 2.36018971e-01f, 1.87046200e-01f, 2.28689179e-01f,
  -4.86518651e-01f, 4.48296592e-02f, -7.60153681e-02f, -7.44817555e-02f, -1.81801572e-01f, -4.49925885e-02f, -5.61261438e-02f, -9.62560251e-02f, -3.71678211e-02f, -9.11668390e-02f,
  1.82826966e-02f, -1.06051080e-01f, -8.31713006e-02f, -3.36957835e-02f, -1.41524851e-01f, -2.04040766e-01f, -2.05069147e-02f, -9.97474417e-03f, -5.67644760e-02f, -1.83634639e-01f,
  -8.96883309e-02f, 7.90761039e-03f, -5.98474070e-02f, 1.40865315e-02f, -3.02585624e-02f, -4.99432012e-02f, -1.11408353e-01f, -7.28110746e-02f, -5.86908646e-02f, -3.73405516e-02f,
  -3.60072434e-01f, 2.79111825e-02f, -1.75331324e-01f, -2.42749989e-01f, -1.42084405e-01f, -3.30591053e-02f, 1.17451986e-02f, 1.10600077e-01f, 8.20408762e-03f, 4.25732024e-02f,
  -3.94599838e-03f, -1.27490208e-01f, -1.38449460e-01f, -1.26029208e-01f, -1.66340664e-01f, -5.44496067e-02f, 1.00847602e-01f, -1.85035899e-01f, -4.36285287e-01f, -2.31060386e-01f,
  -6.05038367e-02f, 2.00204700e-02f, -1.12290293e-01f, -1.93443596e-01f, -1.11115528e-02f, -1.81401327e-01f, -1.38388872e-01f, -1.73846126e-01f, 4.94172983e-02f, 1.70335650e-01f,
  -4.00524884e-02f, -3.19922954e-01f, 6.48341998e-02f, 1.96137339e-01f, 1.05555706e-01f, 1.43235940e-02f, -1.65608943e-01f, -1.93608910e-01f, -2.22456176e-02f, -1.60013244e-01f,
  1.80548150e-02f, -4.97816876e-02f, -5.22754015e-03f, -8.36540908e-02f, -6.54306114e-02f, -5.99015281e-02f, 7.78134167e-02f, 4.38834503e-02f, -7.37784570e-03f, -3.60222155e-04f,
  8.03067014e-02f, 1.16731167e-01f, -1.31970113e-02f, 1.90102272e-02f, 1.02947429e-01f, -9.44882855e-02f, -7.06232414e-02f, -9.54031572e-02f, -2.15357363e-01f, 2.72222590e-02f,
  6.12039328e-01f, -6.16905272e-01f, 6.74468935e-01f, 1.19616561e-01f, 1.04695894e-01f, 1.54312238e-01f, -5.13810888e-02f, 2.59706266e-02f, -7.96158388e-02f, -9.52961296e-02f,
  -3.44566882e-01f, -3.54436368e-01f, -2.37032741e-01f, -2.45044351e-01f, -2.02667594e-01f, 3.38791274e-02f, 2.89795160e-01f, 5.96531034e-01f, 5.40782034e-01f, 1.33210808e-01f,
  -1.27294272e-01f, 1.25493035e-01f, 2.90412813e-01f, 1.26625866e-01f, -2.22593527e-02f, -2.96745487e-02f, 3.88040692e-02f, 1.40222535e-02f, -1.46378234e-01f, 6.80181757e-02f,
  1.93562612e-01f, -1.79696098e-01f, 1.29743144e-01f, -3.43208492e-01f, 1.47172650e-02f, 9.20025706e-02f, 8.12678859e-02f, 1.21256039e-01f, -4.64942940e-02f, -2.31418107e-02f,
  -8.44206065e-02f, -8.01157057e-02f, -8.00601169e-02f, -5.35050593e-03f, 1.17245749e-01f, 6.02689646e-02f, 7.15578767e-03f, 7.96066597e-02f, -1.66232273e-01f, -1.12051629e-01f,
  -1.63847879e-01f, 9.60914418e-02f, 1.62254885e-01f, -5.82216133e-04f, -5.26707880e-02f, 1.12433918e-01f, 5.82270138e-03f, 1.78361088e-02f, 6.10720739e-02f, 1.73850823e-03f,
  -1.77818507e-01f, -1.50085539e-01f, -4.32322808e-02f, 1.47744387e-01f, 1.57943472e-01f, 3.05052280e-01f, 1.05075449e-01f, -1.16944879e-01f, 1.19777940e-01f, 1.54701144e-01f,
  1.74824432e-01f, 2.35951673e-02f, 1.65559307e-01f, 5.16612176e-03f, 7.84652382e-02f, 1.95002779e-01f, 2.44986445e-01f, -3.56455594e-02f, 1.55734956e-01f, 1.43903360e-01f,
  1.14565499e-01f, 2.12747410e-01f, 1.44807950e-01f, 1.68508038e-01f, 1.31643802e-01f, 1.85836673e-01f, 1.08578756e-01f, -6.30101338e-02f, -3.43634449e-02f, 5.83694093e-02f,
  -2.78510630e-01f, -1.06952675e-01f, 1.12432733e-01f, -1.41244799e-01f, -8.17921758e-02f, -5.58626838e-02f, -1.39260486e-01f, -1.15716875e-01f, -4.66646627e-02f, -3.95409297e-03f,
  -3.28614339e-02f, 8.17043707e-02f, 3.42889619e-03f, -1.72608010e-02f, 2.69877821e-01f, 9.68522131e-02f, -2.97801401e-02f, 1.84214581e-02f, -7.12805167e-02f, -8.83719069e-04f,
  -1.38532698e-01f, 1.00569554e-01f, 1.17780656e-01f, 9.10166129e-02f, 1.96075421e-02f, 9.33955088e-02f, 1.96941286e-01f, 7.60987997e-02f, 9.23560485e-02f, 9.65517163e-02f,
  -6.06486142e-01f, -2.16565713e-01f, -4.66441721e-01f, -3.75063181e-01f, -1.39624864e-01f, 2.00141475e-01f, 1.73422068e-01f, 4.55438793e-01f, 1.81297526e-01f, -1.25022054e-01f,
  -2.15861518e-02f, -2.28942171e-01f, -4.86865163e-01f, -3.09188545e-01f, -2.41962105e-01f, -3.15162808e-01f, -6.43528879e-01f, -5.34047842e-01f, -2.19870899e-02f, 4.35569286e-01f,
  -8.62924531e-02f, -2.37617135e-01f, -3.33480567e-01f, -2.54512101e-01f, -2.34588787e-01f, -4.76644784e-01f, -5.89746833e-01f, -4.74211723e-01f, -3.48780274e-01f, -7.52895474e-01f,
  -6.24192357e-02f, 1.31103829e-01f, 4.94514108e-02f, -2.42476702e-01f, -1.00451395e-01f, 1.67744935e-01f, 1.27388671e-01f, -1.76317226e-02f, -4.41940501e-02f, 1.29221961e-01f,
  2.22925749e-02f, 2.04018027e-01f, 6.73372969e-02f, -1.04798682e-01f, -2.88151279e-02f, 1.38073713e-01f, 9.04404968e-02f, 9.10726096e-03f, -2.09654376e-01f, 1.41486183e-01f,
  9.61493999e-02f, -2.77907073e-01f, -3.35552752e-01f, 6.74744993e-02f, 2.37043634e-01f, -3.72994184e-01f, 7.29046687e-02f, 1.60656735e-01f, -1.90007195e-01f, -5.09498835e-01f,
  1.13412254e-01f, 2.62270905e-02f, 4.14185315e-01f, 2.37280115e-01f, 1.78084671e-02f, 4.68110889e-02f, -8.13956708e-02f, 7.10108280e-02f, 1.28179893e-01f, 5.23215793e-02f,
  7.56881014e-02f, -6.29975125e-02f, -6.87111467e-02f, -1.40234545e-01f, -3.06484133e-01f, -7.21785873e-02f, -1.59167960e-01f, -1.41282484e-01f, -1.66772872e-01f, -2.07427368e-01f,
  -2.51749367e-01f, -5.28960228e-02f, -6.91953395e-03f, 3.75719275e-03f, 1.49261095e-02f, -5.65148443e-02f, 1.67027101e-01f, 2.79448062e-01f, 2.37547040e-01f, 9.18857306e-02f,
  -1.66002810e-01f, -9.74317268e-02f, -4.51181561e-01f, -4.73485142e-02f, 1.25469491e-02f, 1.48047179e-01f, -2.09490836e-01f, 2.53202379e-01f, -1.22236907e-01f, 1.97100744e-01f,
  3.18275005e-01f, 2.00586468e-02f, -8.59080069e-03f, 4.02614847e-02f, 1.42117977e-01f, 2.29199994e-02f, 4.26446348e-02f, -3.15802932e-01f, -2.27358818e-01f, 1.32506922e-01f,
  1.41649824e-02f, -4.63504672e-01f, -5.04125357e-01f, -4.15229678e-01f, -1.43285424e-01f, -6.56155407e-01f, -3.74909192e-01f, -2.24616304e-01f, -4.63373274e-01f, -5.73684156e-01f,
  7.51444161e-01f, 8.18466917e-02f, -1.21598661e-01f, 3.90757710e-01f, 2.89570302e-01f, 4.80826525e-03f, -9.15936977e-02f, -9.27709043e-02f, 1.42479658e-01f, 2.09769100e-01f,
  2.72535920e-01f, 5.18564105e-01f, 2.23782867e-01f, 2.58949637e-01f, -7.07798004e-02f, 1.73042305e-02f, -7.45718880e-03f, 7.56792352e-02f, 9.38278511e-02f, 3.04272205e-01f,
  4.83555377e-01f, 1.86051130e-01f, 1.14667833e-01f, 1.60243332e-01f, 4.86066699e-01f, 3.90006870e-01f, 2.16523875e-02f, 9.92031619e-02f, 3.04760247e-01f, 4.66496468e-01f,
  4.25868809e-01f, -7.44511262e-02f, 1.02585182e-01f, 3.83459292e-02f, 5.04695550e-02f, -6.11679330e-02f, 3.80437039e-02f, -1.56967193e-01f, 3.27799022e-02f, 2.21306132e-03f,
  4.40223254e-02f, -1.81846297e-03f, -5.96265905e-02f, -2.51527987e-02f, -1.39959887e-01f, -6.76101223e-02f, -1.33950621e-01f, -1.81921259e-01f, -1.71574518e-01f, -3.61738354e-02f,
  1.70506403e-01f, 3.51200514e-02f, -2.66123861e-01f, -1.71808183e-01f, -7.07672834e-02f, -7.07195103e-02f, -7.25940689e-02f, 4.70153503e-02f, -1.49651453e-01f, 4.18157466e-02f,
  4.28798527e-01f, 5.67441573e-03f, 2.75855869e-01f, 3.55630249e-01f, 3.17276746e-01f, 7.18510896e-02f, -4.49253209e-02f, -1.96704678e-02f, 8.84031504e-02f, 5.65112196e-02f,
  -3.92338112e-02f, 2.57353801e-02f, -1.50983199e-01f, 9.08184499e-02f, 2.86774009e-01f, 6.82389811e-02f, -8.83845538e-02f, -9.50413495e-02f, -2.35933643e-02f, -3.71419787e-02f,
  1.20054998e-01f, -1.28584996e-01f, -4.55932990e-02f, -4.05912623e-02f, -4.02811505e-02f, -1.71939886e-04f, 2.46695474e-01f, 7.16232508e-02f, 1.46678180e-01f, 8.14952701e-02f,
  -3.17364126e-01f, -2.88615018e-01f, 4.01862621e-01f, -1.01245277e-01f, -1.01843253e-01f, -4.81181890e-02f, 1.73089296e-01f, -1.57251313e-01f, -3.76916975e-02f, 8.16180650e-03f,
  -1.70203686e-01f, 7.16841128e-03f, -1.25484839e-01f, -1.61996618e-01f, -6.02991208e-02f, -4.54689674e-02f, 6.62574172e-02f, -3.54037769e-02f, -1.45237997e-01f, -1.24603093e-01f,
  -2.09866285e-01f, -2.44071111e-01f, -1.47411495e-01f, -2.23490804e-01f, -7.74527714e-02f, -3.22651379e-02f, -1.08985350e-01f, -1.23855561e-01f, -2.40743726e-01f, -2.41868064e-01f,
  -7.78540432e-01f, 5.79576254e-01f, -9.47582442e-03f, -3.96908104e-01f, -1.96358472e-01f, -2.57923037e-01f, 1.52424887e-01f, -5.98315261e-02f, -5.24852462e-02f, 5.44593453e-01f,
  4.01760280e-01f, -4.08147246e-01f, -3.68133217e-01f, -3.31308424e-01f, -4.57920343e-01f, 7.03698695e-02f, -2.87519068e-01f, -7.28555381e-01f, -8.82752240e-01f, -3.74692202e-01f,
  -7.43333623e-02f, -3.61392409e-01f, -3.98487955e-01f, -2.98800945e-01f, 2.56458730e-01f, -3.83403115e-02f, 1.50391489e-01f, -1.36035353e-01f, 2.62257531e-02f, 2.31713980e-01f,
  3.06567103e-01f, -8.69938731e-02f, -1.63155645e-01f, -3.43347132e-01f, 2.02579498e-01f, -6.78867474e-02f, 1.35341465e-01f, -2.61779368e-01f, -2.45965391e-01f, -1.88811459e-02f,
  -2.78355569e-01f, -4.62307110e-02f, -4.05463398e-01f, 3.02070770e-02f, -1.14981987e-01f, -1.48392871e-01f, -1.46033183e-01f, -3.57685834e-01f, -2.51610905e-01f, 2.51613647e-01f,
  1.83911204e-01f, -9.78776067e-02f, -1.12513145e-02f, 1.93377420e-01f, -5.59026003e-02f, -2.94173777e-01f, 3.54506642e-01f, 1.25200242e-01f, -3.36152241e-02f, 5.20658374e-01f,
  1.82951152e-01f, 1.21031776e-01f, -1.75535306e-01f, 2.51210630e-02f, 3.10147703e-01f, -3.35723162e-02f, -2.42481753e-03f, 1.12148792e-01f, -9.77876931e-02f, 1.19139977e-01f,
  1.76126555e-01f, 3.07556123e-01f, 8.20825621e-02f, 4.90643121e-02f, 1.59347560e-02f, -6.33150339e-02f, 1.48952097e-01f, 2.50041068e-01f, 1.31728411e-01f, 7.95835480e-02f,
  -9.35011655e-02f, -4.74469140e-02f, -1.10311367e-01f, 6.07211217e-02f, 7.51598030e-02f, 3.14214788e-02f, -2.91607883e-02f, 5.16067818e-02f, -1.95820734e-01f, -1.65846094e-01f,
  2.74995685e-01f, -3.33771467e-01f, 1.59666687e-01f, -2.19864964e-01f, -7.02560768e-02f, 9.47387740e-02f, 3.45648229e-02f, -4.11212891e-02f, 1.39792979e-01f, 2.89622188e-01f,
  -1.00573048e-01f, 1.71184242e-01f, -3.82163748e-02f, -3.25641781e-02f, -1.93447948e-01f, -2.90911067e-02f, 7.39899650e-02f, 2.06596237e-02f, -9.06791091e-02f, 1.50573626e-01f,
  -6.24979697e-02f, -1.21291392e-01f, -1.25688493e-01f, 1.93325579e-01f, -2.92303297e-03f, -1.79501027e-01f, 1.21361136e-01f, 1.20545372e-01f, -2.28397816e-01f, 5.99446476e-01f,
  -7.36323655e-01f, 3.91886324e-01f, -1.64208226e-02f, -6.92323565e-01f, 4.73018497e-01f, 7.33447492e-01f, 1.06062710e+00f, 2.76906639e-01f, -5.48222184e-01f, -6.32603019e-02f,
  3.08722228e-01f, -2.87445545e-01f, -5.35248697e-01f, -1.46762833e-01f, 1.97962672e-01f, 2.14620382e-01f, -9.15692598e-02f, -2.70192474e-01f, 2.39538863e-01f, 6.31845891e-01f,
  3.30328315e-01f, -1.71448022e-01f, -3.34398180e-01f, -3.03878039e-01f, -3.89000237e-01f, -3.86125565e-01f, -4.18314517e-01f, -8.05192441e-02f, 2.87534624e-01f, -3.54766130e-01f,
  -2.13109940e-01f, 1.07345276e-01f, 2.52440453e-01f, -1.53981581e-01f, -3.61249261e-02f, -2.57509261e-01f, 4.62799054e-03f, -3.80432159e-01f, -1.33417115e-01f, -2.13506013e-01f,
  -1.21845111e-01f, -1.61710143e-01f, -2.52365500e-01f, 1.30446449e-01f, 1.35345403e-02f, 1.55167714e-01f, 6.93398202e-03f, -7.60390535e-02f, -2.61270046e-01f, 3.04825723e-01f,
  3.64801228e-01f, 2.50071019e-01f, 2.40791291e-02f, 2.43567273e-01f, 1.07461415e-01f, -4.08830345e-01f, 1.75483987e-01f, 5.66610061e-02f, 3.02074291e-02f, -4.06074345e-01f,
  -4.25155647e-02f, -4.63301614e-02f, 9.26291570e-02f, -5.55646047e-03f, -8.88155699e-02f, 1.66597441e-02f, -9.09163281e-02f, 1.31810859e-01f, -1.95475593e-02f, -2.95579974e-02f,
  1.98755443e-01f, 1.75619423e-02f, 9.38123614e-02f, -1.17831901e-01f, -1.86852321e-01f, 2.46629361e-02f, 1.92992046e-01f, 5.30796684e-02f, -1.05416112e-01f, -4.06644866e-02f,
  3.61763984e-02f, -1.69031005e-02f, -8.03542063e-02f, 1.11542940e-01f, 1.69052109e-01f, 4.75057475e-02f, -1.09037749e-01f, 1.29639655e-01f, -7.08510131e-02f, 1.26145154e-01f,
  -5.32472670e-01f, 3.96432400e-01f, -3.82392436e-01f, 1.07256956e-01f, -4.28058542e-02f, -1.12701498e-01f, 2.26325709e-02f, 9.35989805e-03f, -1.81508809e-01f, -1.27855673e-01f,
  2.24572659e-01f, -1.18892007e-01f, -1.00084625e-01f, 2.36765191e-01f, 4.33011614e-02f, -1.41259298e-01f, 2.30310902e-01f, -3.96675952e-02f, 6.78210631e-02f, 4.76034768e-02f,
  1.08086169e-01f, 8.05851351e-03f, -3.44420522e-01f, -6.24588504e-02f, 9.11862776e-02f, -3.63470703e-01f, -2.15963304e-01f, -4.32548411e-02f, -1.35889056e-03f, -4.42322016e-01f,
  1.17733610e+00f, -6.24747455e-01f, -5.97650051e-01f, 6.26126587e-01f, 5.32729737e-02f, -6.07907921e-02f, 2.52184063e-01f, 2.37123638e-01f, 3.26360643e-01f, 1.30563989e-01f,
  -5.19004345e-01f, -5.03017306e-01f, -6.39033437e-01f, -4.41530824e-01f, -6.41842335e-02f, 1.48431867e-01f, 2.00847015e-01f, 4.18022759e-02f, 2.15505585e-01f, 2.56967187e-01f,
  1.18376613e-01f, 3.84609669e-01f, 4.68485832e-01f, 5.94463386e-02f, -3.17437828e-01f, -1.57145172e-01f, -3.54350775e-01f, -2.70889461e-01f, -4.94579196e-01f, -3.40558439e-01f,
  -4.53021467e-01f, -6.05890393e-01f, 7.95067102e-02f, -8.49657506e-02f, -2.29841903e-01f, 9.30134580e-02f, -3.23392414e-02f, -1.95214882e-01f, -1.41443595e-01f, -6.70105172e-03f,
  -1.63109973e-01f, -1.30429342e-01f, -2.97740430e-01f, -3.27004999e-01f, -2.56202668e-02f, -1.36008002e-02f, -1.24854863e-01f, -1.33088648e-01f, -2.62040764e-01f, -1.83479905e-01f,
  -3.40226263e-01f, 5.42447977e-02f, -1.64189816e-01f, -1.40295669e-01f, -3.12734783e-01f, 2.60735136e-02f, -4.67430860e-01f, -3.50755721e-01f, -1.52190521e-01f, 6.76209107e-02f,
  1.52870342e-01f, 6.49192482e-02f, -3.56556592e-03f, 8.17895979e-02f, 1.56075314e-01f, 1.10943494e-02f, 8.64096079e-03f, -2.13373508e-02f, -4.63439384e-03f, 2.92764436e-02f,
  1.49100572e-02f, 2.80493032e-03f, -5.82377426e-02f, 4.97823097e-02f, -5.83277047e-02f, -1.35658607e-01f, 9.62212458e-02f, 1.07922629e-02f, -1.54496729e-01f, 7.16355741e-02f,
  -7.27450103e-02f, -9.78239775e-02f, -8.58503506e-02f, -9.20234099e-02f, -6.59591481e-02f, -1.07272767e-01f, 8.45519751e-02f, -1.65929630e-01f, -5.73146455e-02f, 7.54187256e-02f,
  4.83832330e-01f, -2.75461078e-01f, 2.52670825e-01f, 2.40742415e-02f, -5.59113994e-02f, -1.82917520e-01f, -9.41267908e-02f, -9.81846228e-02f, -1.69667602e-01f, -8.21652412e-02f,
  -3.02614838e-01f, -7.13338181e-02f, -3.89366776e-01f, -1.00243494e-01f, 1.68607011e-01f, 8.10488909e-02f, 1.49781644e-01f, 1.41533583e-01f, -7.84541443e-02f, 8.60112682e-02f,
  5.63371330e-02f, 4.65326846e-01f, 4.90593851e-01f, 1.48045540e-01f, -1.57132410e-02f, 4.19162422e-01f, 4.03973348e-02f, 1.11373208e-01f, 3.15276712e-01f, 6.83141887e-01f,
  4.09708560e-01f, 5.14857888e-01f, 3.18829656e-01f, 1.86606541e-01f, 6.23522460e-01f, 1.20925218e-01f, -1.92187130e-01f, -3.23697954e-01f, -1.88734055e-01f, 1.49190696e-02f,
  2.03595832e-01f, -5.73196635e-02f, -9.32933465e-02f, -3.35005671e-01f, -4.19779778e-01f, -3.02479804e-01f, -9.94029045e-02f, -1.61218911e-01f, -4.20007497e-01f, -3.53832453e-01f,
  -2.05312774e-01f, 1.09097444e-01f, 6.85992911e-02f, -1.79958180e-01f, 1.86208054e-01f, -9.66025423e-03f, 2.94087321e-01f, 4.54824239e-01f, 2.08512112e-01f, 1.59943298e-01f,
  2.27660894e-01f, 4.43866730e-01f, -4.60762143e-01f, 6.78414479e-02f, 4.45498079e-01f, -1.84437752e-01f, -2.17215672e-01f, 1.15300946e-01f, -6.82455301e-02f, -5.93008026e-02f,
  4.19569761e-01f, -8.07533320e-03f, 1.63029224e-01f, -1.01997420e-01f, 1.13459855e-01f, -2.43110284e-01f, -9.15084407e-02f, -3.83773416e-01f, -3.75179321e-01f, -4.18812595e-02f,
  7.11400434e-02f, 4.88485634e-01f, 4.19554830e-01f, -2.90254921e-01f, -2.48517275e-01f, 1.63865268e-01f, 1.46495566e-01f, -8.73928890e-02f, -4.87957187e-02f, -2.10644990e-01f,
  -1.88827381e-01f, 1.83337376e-01f, 1.31461741e-02f, 8.80804062e-02f, -1.44102097e-01f, 3.78427561e-04f, 1.02545582e-01f, -1.40294760e-01f, -1.72706634e-01f, 1.47700089e-03f,
  -2.31613778e-02f, -1.47044584e-02f, -8.89808871e-03f, -3.22976373e-02f, -1.05425432e-01f, 2.26905257e-01f, -9.43463892e-02f, -1.59979507e-01f, 4.13429178e-02f, 1.28959632e-02f,
  -2.10338347e-02f, -9.06682611e-02f, 1.31498665e-01f, -2.35670224e-01f, -2.54853833e-02f, 6.15441501e-02f, -7.74123594e-02f, -3.28845866e-02f, 6.13344237e-02f, 3.67904991e-01f,
  -3.26136678e-01f, 1.74006924e-01f, -8.78283456e-02f, -1.92345381e-01f, 3.42371196e-01f, 7.16002658e-02f, 2.80873608e-02f, 6.14025630e-02f, 3.20364267e-01f, -1.07577972e-01f,
  1.58383697e-01f, 3.51634584e-02f, 1.38421148e-01f, -1.88533828e-01f, -1.28696546e-01f, -7.75239095e-02f, 1.53401056e-02f, -6.25419244e-02f, -3.10261458e-01f, 1.60808131e-01f,
  -1.06221795e-01f, -3.10994864e-01f, -3.07185739e-01f, -3.13251644e-01f, 5.15389396e-03f, -2.43296281e-01f, -2.79729396e-01f, -1.91997066e-01f, -4.08428431e-01f, -5.03686786e-01f,
  8.47672045e-01f, 6.51832148e-02f, -9.69204009e-01f, 8.62751544e-01f, 1.63552299e-01f, -1.65282220e-01f, 5.46065532e-02f, 2.91175425e-01f, 5.37038326e-01f, 2.36295253e-01f,
  -5.18695831e-01f, -5.94029963e-01f, -4.32431519e-01f, -5.78090429e-01f, -6.91457808e-01f, -2.16746584e-01f, -1.89214587e-01f, -6.79076970e-01f, -5.74542224e-01f, -3.01572774e-02f,
  3.45986128e-01f, 6.75508857e-01f, 3.57353359e-01f, 4.13362905e-02f, 4.18821752e-01f, -2.74902745e-03f, 9.44255516e-02f, 1.50262237e-01f, -3.59074831e-01f, -1.88996807e-01f,
  -4.62246805e-01f, -1.10798433e-01f, -2.21093506e-01f, 8.23866874e-02f, 4.59458027e-03f, 4.16225456e-02f, -2.26037771e-01f, -6.41508959e-03f, -1.04045518e-01f, 4.23036329e-02f,
  -2.05042884e-01f, -3.97816807e-01f, -3.12031776e-01f, -7.21784383e-02f, 8.00770447e-02f, -1.72997639e-01f, 2.89409738e-02f, -2.98060387e-01f, -1.69536337e-01f, -8.41524228e-02f,
  -4.29793596e-02f, -1.38076693e-01f, -3.98215503e-01f, -1.41041651e-01f, -2.46736750e-01f, -1.70579255e-01f, -2.50889540e-01f, -3.21512759e-01f, -3.88228238e-01f, 2.94647187e-01f,
  1.12415021e-02f, 1.26689505e-02f, -3.16464640e-02f, -9.43760276e-02f, 3.17142569e-02f, -2.01513752e-01f, -3.74789461e-02f, 3.84082342e-03f, -5.32666259e-02f, 3.82127911e-02f,
  -2.37712517e-01f, 5.37015274e-02f, 2.12019333e-03f, 6.15628511e-02f, -4.74721044e-02f, 1.00085288e-01f, -1.00491449e-01f, 2.24971548e-01f, 1.18758753e-01f, 2.54877061e-02f,
  5.40517922e-03f, -4.11315933e-02f, 7.17577562e-02f, -4.78505976e-02f, -2.32527219e-03f, -1.26146674e-01f, 1.44040599e-01f, -1.30097065e-02f, 4.40055728e-02f, 5.03837354e-02f,
  5.10976613e-01f, -3.49149257e-01f, 1.51631996e-01f, -1.44313008e-01f, 7.61126950e-02f, -4.47409227e-02f, 3.70542556e-02f, -5.65903261e-02f, -1.74617544e-01f, -3.93111967e-02f,
  -2.13533774e-01f, -1.72618493e-01f, -3.13235521e-02f, -1.70306526e-02f, -1.16459101e-01f, -5.52937128e-02f, 2.27371529e-02f, -1.46422848e-01f, 7.16175511e-02f, 2.83383191e-01f,
  4.19870824e-01f, 1.12573527e-01f, -6.37628511e-02f, 7.82575756e-02f, 2.34729379e-01f, -7.25592971e-02f, 2.01678481e-02f, 9.67702866e-02f, -2.87364751e-01f, 6.55544579e-01f,
  5.84806442e-01f, 4.17547345e-01f, 6.68339074e-01f, -4.23178017e-01f, -7.59772658e-01f, -2.49259830e-01f, 2.21615527e-02f, 2.50012785e-01f, -1.54676601e-01f, 1.55057907e-01f,
  -7.29698241e-02f, -5.19867539e-01f, -8.27727765e-02f, -2.60729305e-02f, 4.69824970e-01f, 3.57626021e-01f, 4.95946854e-02f, 4.56834584e-01f, 1.49525911e-01f, -2.31854096e-01f,
  -4.71567720e-01f, -3.27222571e-02f, 3.12571198e-01f, 1.68150797e-01f, 8.46712291e-03f, -3.30733538e-01f, 2.54717052e-01f, 3.93712558e-02f, -7.15361983e-02f, 1.30594864e-01f,
  3.76100749e-01f, 4.59897131e-01f, -3.96018952e-01f, -1.76321536e-01f, 6.41619787e-02f, 2.37190798e-01f, 6.67487979e-02f, 6.69138655e-02f, -9.78036448e-02f, 9.75778922e-02f,
  -7.65486509e-02f, -1.04631018e-02f, -1.56002715e-01f, 9.90378633e-02f, 3.85574773e-02f, 9.84630734e-03f, 9.53441560e-02f, 2.72437274e-01f, 1.21769428e-01f, 8.63115862e-02f,
  -2.85413712e-01f, -2.18447953e-01f, -2.36607436e-02f, -1.12656780e-01f, 1.48604825e-01f, -2.14552075e-01f, 1.13572426e-01f, 1.09277368e-01f, 2.72763401e-01f, 1.99452728e-01f,
  -3.37476641e-01f, 2.40707159e-01f, 2.22317472e-01f, -1.20083414e-01f, -1.55606285e-01f, -1.16479196e-01f, -4.41059060e-02f, -1.01461120e-01f, -1.04989558e-01f, -6.59539402e-02f,
  -8.57933462e-02f, -2.91373041e-02f, 4.35387529e-02f, 2.78183818e-02f, -6.82421625e-02f, 1.76390573e-01f, 4.52694856e-02f, 1.14431232e-01f, -1.03781477e-01f, 1.45475045e-02f,
  -6.63039088e-02f, -1.79292504e-02f, 2.66684406e-02f, 1.46992102e-01f, 3.29865739e-02f, 6.97468640e-04f, -9.34875477e-03f, -1.41564026e-01f, -6.40844330e-02f, -1.05068274e-01f,
  -1.43576592e-01f, 5.54379709e-02f, -1.40064895e-01f, 1.02729514e-01f, 1.01475976e-01f, 1.66229889e-01f, -4.30801064e-02f, -4.92047518e-02f, -1.50624752e-01f, 8.04891959e-02f,
  3.84410098e-02f, 1.73021600e-01f, 1.84639860e-02f, 1.40086517e-01f, -2.13490531e-01f, -3.10480952e-01f, -1.74865738e-01f, -1.51242679e-02f, -1.24608520e-02f, 1.27734140e-01f,
  -9.37925205e-02f, -3.30695599e-01f, -4.03012425e-01f, -2.54387021e-01f, -2.76649535e-01f, -5.02953529e-01f, -1.68491319e-01f, -1.75239310e-01f, 2.54513845e-02f, -1.71311647e-01f,
  -3.83452892e-01f, 9.38902516e-03f, -7.95140192e-02f, 3.26641738e-01f, 5.05915105e-01f, 3.92563999e-01f, 3.58324379e-01f, 3.81160319e-01f, 4.67235774e-01f, 4.04486865e-01f,
  4.19941068e-01f, 4.93155777e-01f, 4.78465617e-01f, 3.89171809e-01f, 3.13368440e-01f, 3.89793664e-01f, 3.92562717e-01f, 8.36758986e-02f, 8.10820535e-02f, 2.28929117e-01f,
  4.31921631e-01f, 5.74760400e-02f, -1.55768126e-01f, 3.74542587e-02f, 2.61103183e-01f, 1.99012861e-01f, 2.13732809e-01f, 1.06408007e-01f, 1.59989432e-01f, 1.62509859e-01f,
  -1.48948103e-01f, -1.78330407e-01f, 1.49062220e-02f, -2.43225712e-02f, -1.67969212e-01f, -2.34270111e-01f, -6.39460161e-02f, -1.56468645e-01f, -7.07108900e-02f, 3.74985375e-02f,
  4.17749258e-03f, -3.98814864e-02f, -7.94381052e-02f, 1.80685185e-02f, -1.54733211e-01f, -2.03638002e-02f, -2.49466840e-02f, 1.52433932e-01f, 2.52400786e-01f, 1.08058490e-01f,
  2.25428969e-01f, 7.43544325e-02f, 6.73194379e-02f, 8.12116563e-02f, 8.78376067e-02f, 7.86577538e-02f, -6.70371428e-02f, -7.17397928e-02f, -2.19724700e-02f, 3.76519486e-02f,
  3.66407961e-01f, 1.10308632e-01f, 2.11803004e-01f, 2.06623822e-01f, 1.37545004e-01f, 6.42563179e-02f, 4.96940613e-02f, 1.04554340e-01f, 1.30128935e-01f, -6.31043538e-02f,
  8.57710540e-02f, 2.07892910e-01f, 1.02729358e-01f, 9.08009410e-02f, 5.20390123e-02f, 1.22460492e-01f, -3.73435318e-02f, 2.61027496e-02f, -6.56019822e-02f, 8.92414674e-02f,
  4.03637588e-02f, -8.50575119e-02f, -1.77587882e-01f, -1.27212610e-02f, 8.98517761e-03f, 1.55121461e-01f, 1.01339504e-01f, 1.41475454e-01f, 7.16132373e-02f, -8.18206891e-02f,
  4.00297105e-01f, 2.54079372e-01f, -4.53674458e-02f, 2.13685725e-02f, -2.28313610e-01f, -1.87890872e-01f, 2.12013051e-02f, -1.68231875e-01f, -2.15825304e-01f, -9.78557095e-02f,
  -8.34390894e-02f, -1.58520013e-01f, -1.73991099e-01f, -1.49544859e-02f, -1.40243292e-01f, -1.11001395e-01f, -5.69272600e-02f, 1.03275433e-01f, 7.63960257e-02f, -3.68948504e-02f,
  -9.45085362e-02f, 1.58973426e-01f, 1.94558091e-02f, 6.42095953e-02f, -2.92509496e-02f, 9.10250321e-02f, -1.52820647e-01f, -4.94967811e-02f, -2.17433944e-02f, -3.40808965e-02f,
  -3.88788968e-01f, 3.64738137e-01f, -2.69515663e-01f, 2.82428443e-01f, -2.34307628e-02f, -6.09914780e-01f, -3.96557152e-01f, -3.18223059e-01f, -7.43549913e-02f, 3.10782105e-01f,
  3.53489846e-01f, 1.25019804e-01f, 1.43881246e-01f, -2.02757835e-01f, -5.13732076e-01f, -1.73936948e-01f, -2.91657060e-01f, -7.09786236e-01f, -7.80179143e-01f, -3.81481707e-01f,
  -9.46759135e-02f, 4.57728058e-02f, -3.06187481e-01f, -2.16243744e-01f, 4.24143404e-01f, 1.18720375e-01f, 1.37786344e-01f, -1.39861256e-01f, -1.91275224e-01f, 2.28069052e-01f,
  3.47098798e-01f, -2.02368051e-01f, -2.41098657e-01f, 3.69015452e-03f, 8.82488936e-02f, -7.43563697e-02f, -4.90341485e-02f, 4.51195948e-02f, 1.58069551e-01f, 1.78967461e-01f,
  -2.81211399e-02f, 8.42958167e-02f, 9.91010517e-02f, 5.68992794e-02f, 1.05902836e-01f, 3.02811861e-02f, 3.59710865e-02f, -1.81187000e-02f, -2.64495760e-02f, 1.75348312e-01f,
  5.81430793e-02f, -5.51471710e-02f, -3.38046774e-02f, -1.10595822e-01f, -2.49330491e-01f, -1.77815944e-01f, -1.60908718e-02f, -1.88362673e-01f, -4.06963110e-01f, 3.21293414e-01f,
  -2.68344790e-01f, -7.78823020e-03f, -2.91443057e-02f, 3.77842151e-02f, 8.95483270e-02f, 1.93725348e-01f, 7.74809867e-02f, 8.59009326e-02f, -3.09672728e-02f, 9.96453464e-02f,
  3.69610310e-01f, -9.14896466e-03f, -5.96362911e-02f, 1.51356161e-01f, 1.24338036e-03f, -3.48994583e-02f, -1.28219035e-02f, 4.69371397e-03f, -1.15229435e-01f, 4.42945063e-02f,
  2.17170008e-02f, 5.11162914e-02f, 2.16908678e-01f, 7.41557181e-02f, -1.03166878e-01f, 2.90304851e-02f, -1.11508615e-01f, 1.35728130e-02f, -4.53566052e-02f, 1.10028222e-01f,
  5.41281760e-01f, -3.85950714e-01f, 3.43075067e-01f, -8.16071182e-02f, 2.60595866e-02f, 7.39141703e-02f, 1.14281371e-01f, 5.57454936e-02f, 1.91857010e-01f, 1.12582237e-01f,
  -1.40115380e-01f, 2.76487693e-02f, 7.98537955e-02f, 1.94252536e-01f, 4.01383750e-02f, -1.12506069e-01f, 1.01196826e-01f, 1.29943252e-01f, -9.74497199e-02f, 2.09703058e-01f,
  1.98472366e-01f, -1.69529999e-03f, 8.71193111e-02f, 1.53105870e-01f, -1.97070822e-01f, -1.89982533e-01f, 1.88269839e-01f, -1.99785992e-03f, -1.72522351e-01f, 3.94500673e-01f,
  -1.10026777e+00f, -1.23943269e-01f, 5.45147896e-01f, -1.03470199e-01f, 4.28874940e-02f, 2.21424829e-02f, -2.39000916e-01f, -5.65951802e-02f, 1.18493319e-01f, -1.74744263e-01f,
  -3.74614477e-01f, -2.83944070e-01f, 2.33961403e-01f, 8.44921619e-02f, -1.18735313e-01f, 4.67083633e-01f, 7.42175817e-01f, 2.98013657e-01f, -3.66401285e-01f, -6.43434107e-01f,
  -1.60548165e-01f, -2.92118460e-01f, -3.96479845e-01f, 1.08894124e-03f, 1.86971232e-01f, 8.27902406e-02f, 4.57561553e-01f, 4.42016609e-02f, 8.98265094e-02f, 4.69048709e-01f,
  -3.35725784e-01f, -2.85891622e-01f, 2.91130930e-01f, -2.08053336e-01f, -2.16249675e-02f, -1.63510785e-01f, -7.74883851e-02f, 1.74445137e-01f, -5.31415343e-02f, 5.05459532e-02f,
  -3.22433561e-01f, -2.05833584e-01f, -2.62099743e-01f, -1.03624970e-01f, -2.72526950e-01f, -3.49675328e-01f, 1.61521822e-01f, -4.32307757e-02f, 8.66005570e-02f, -2.36017719e-01f,
  -5.73274605e-02f, -4.93473381e-01f, -2.36853123e-01f, 2.16281310e-01f, 1.44564405e-01f, 4.79525626e-02f, -1.06964141e-01f, -2.66005814e-01f, -1.02478616e-01f, -3.22876066e-01f,
  4.37714867e-02f, 3.91709358e-02f, 8.80393237e-02f, 1.06857121e-01f, -3.05988602e-02f, 2.99308151e-02f, 1.58765450e-01f, 2.28467193e-02f, 6.86809123e-02f, -1.38450235e-01f,
  1.09896675e-01f, -1.07360832e-01f, -1.26662040e-02f, 6.38351217e-03f, 6.48737326e-02f, -8.34351033e-02f, -1.24230929e-01f, -4.05119127e-03f, 3.11689097e-02f, -2.65720412e-02f,
  -1.05118364e-01f, 5.76029997e-03f, 1.01251505e-01f, 4.26352136e-02f, 1.12918183e-01f, 1.98706567e-01f, -9.25206989e-02f, -1.38026655e-01f, 2.19515525e-02f, -1.51454480e-02f,
  -2.54581720e-01f, 4.06220198e-01f, -1.80002511e-01f, -1.89277902e-02f, -9.60810110e-02f, 3.05432621e-02f, 1.28648028e-01f, -3.88299339e-02f, 4.47101295e-02f, -2.62969881e-01f,
  -2.79709399e-01f, -1.60931423e-01f, 4.62335683e-02f, 7.67570809e-02f, -2.81475812e-01f, -1.63074121e-01f, -2.57249117e-01f, -1.02018028e-01f, -2.52722111e-02f, -1.29876867e-01f,
  1.39815241e-01f, -5.47332346e-01f, -6.13302469e-01f, -2.43742883e-01f, -2.57378012e-01f, -4.44562048e-01f, -4.94921990e-02f, -2.95426935e-01f, -2.33579442e-01f, -6.18744731e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  8.62511694e-01f, 6.66512191e-01f, 7.50410199e-01f, 8.30563128e-01f, 3.92044395e-01f, 6.77551985e-01f, 2.34666646e-01f, 6.85710251e-01f, 2.75350899e-01f, 7.67752647e-01f,
  4.17359531e-01f, 5.21613836e-01f, 6.91333711e-01f, 2.69480258e-01f, 8.16155195e-01f, -1.26568228e-01f, 4.40895826e-01f, 8.48094940e-01f, 7.24640906e-01f, 8.28300774e-01f,
  4.67222720e-01f, 7.09367573e-01f, 8.24322999e-01f, 2.12256655e-01f, 8.42181206e-01f, 7.75913894e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -1.77549839e-01f, -4.39571857e-01f, -4.54735100e-01f, -1.28175452e-01f, -3.68564248e-01f, -3.42945576e-01f, -6.94106102e-01f, -1.64031297e-01f, 5.36259770e-01f, -4.64637071e-01f,
  -5.36072403e-02f, -5.95278084e-01f, -2.52806485e-01f, 3.99327606e-01f, 7.56643534e-01f, -3.34412783e-01f, -3.02169681e-01f, -3.27690691e-01f, -8.50953221e-01f, -4.54581916e-01f,
  -4.77837771e-01f, 7.26457119e-01f, -8.71250480e-02f, -2.19805554e-01f, 4.74942565e-01f, -3.43776524e-01f, -8.83832276e-01f, 2.12802336e-01f, -1.02756512e+00f, -6.83030188e-01f,
  -3.21200550e-01f, -7.58131921e-01f, -7.72021934e-02f, -7.40553290e-02f, 1.75373070e-02f, 9.42693502e-02f, 1.60428151e-01f, -1.87557995e-01f, -2.44400144e-01f, 2.79869705e-01f,
  1.05582213e+00f, 8.59796703e-02f, 5.86154521e-01f, -9.89663839e-01f, 8.70641470e-01f, 3.66289854e-01f, 3.98521721e-02f, 6.38223365e-02f, -7.19406128e-01f, -2.65973836e-01f,
  -1.24550939e+00f, -2.55134180e-02f, -1.11479729e-01f, -5.35185456e-01f, 5.91872215e-01f, -1.21529007e+00f, -8.00348520e-01f, 1.67802840e-01f, -5.93679845e-01f, -6.77555740e-01f,
  -1.36154994e-01f, 1.19494371e-01f, -8.69977355e-01f, -1.10973179e+00f, -1.60087727e-03f, 1.53453007e-01f, 6.19560890e-02f, 2.11509898e-01f, -2.34893307e-01f, -4.00527686e-01f,
  -3.35147828e-01f, -6.92819834e-01f, 6.19201005e-01f, -5.26629567e-01f, -3.40529084e-01f, -7.86894500e-01f, -3.13545138e-01f, 3.88062298e-01f, 5.18776476e-01f, 6.06524169e-01f,
  -1.57278821e-01f, 2.94349730e-01f, -5.36633193e-01f, -7.27720916e-01f, 7.81884611e-01f, -6.21234775e-01f, -8.25597882e-01f, -6.54749572e-01f, -2.14491174e-01f, -5.92097998e-01f,
  -2.53226459e-02f, -6.78185225e-01f, 6.46237135e-01f, -3.26533377e-01f, -7.75963485e-01f, 9.51636195e-01f, -1.55939519e-01f, 2.07889855e-01f, -1.14976123e-01f, -1.40481547e-01f,
  6.61164224e-02f, 6.37065649e-01f, 6.60626544e-03f, 4.76867408e-01f, -9.02460992e-01f, 4.92841974e-02f, -3.41924816e-01f, -5.51232517e-01f, -4.98607665e-01f, -6.96707249e-01f,
  4.97493781e-02f, -7.42572606e-01f, -1.13456249e+00f, -4.30823654e-01f, 6.14439011e-01f, -6.83411777e-01f, -2.58128762e-01f, 3.16832721e-01f, -5.79775631e-01f, 4.88175362e-01f,
  1.03689551e+00f, -5.69835186e-01f, -7.58766830e-01f, -1.54840255e+00f, 2.25756302e-01f, -4.06113446e-01f, -5.53513467e-01f, 4.25261974e-01f, -6.51158392e-02f, 2.41611768e-02f,
  9.88865197e-02f, -3.94488275e-02f, -1.37471423e-01f, 9.51714739e-02f, -1.02572691e+00f, 3.88557762e-01f, -6.24190688e-01f, -4.21192080e-01f, -4.59159493e-01f, 9.99188349e-02f,
  1.68577433e-01f, -2.48579189e-01f, -2.63727874e-01f, -2.18864366e-01f, 9.03200150e-01f, -1.10620522e+00f, 3.79689634e-01f, 1.52504712e-01f, -1.57123804e-01f, -2.63003632e-02f,
  -6.63587391e-01f, 2.99740374e-01f, -1.01781523e+00f, -1.22325766e+00f, 3.02262604e-01f, 1.27279580e-01f, -1.54496312e-01f, 3.54844660e-01f, 3.39474410e-01f, 4.89624918e-01f,
  7.80010372e-02f, -4.10855673e-02f, 7.53984973e-02f, 3.03389400e-01f, 1.52048439e-01f, -4.25708666e-02f, -4.13150787e-01f, -3.32757860e-01f, 2.69966722e-01f, 5.75430274e-01f,
  -6.50012076e-01f, 6.50060833e-01f, -4.64545399e-01f, -1.72689810e-01f, -6.98166847e-01f, -4.59707528e-01f, -7.88042247e-01f, -3.19907784e-01f, 2.39540696e-01f, 3.90155882e-01f,
  -9.01472747e-01f, -5.96126914e-02f, 4.40027453e-02f, 2.60054886e-01f, -1.03767741e+00f, 6.48466289e-01f, -1.00056100e+00f, 1.30070662e+00f, -5.42449355e-01f, -1.34537935e-01f,
  4.18564469e-01f, -8.52163196e-01f, -2.13103250e-01f, 6.39400706e-02f, 2.30510637e-01f, 5.19379497e-01f, 2.83537745e-01f, 5.11175767e-02f, -8.85517001e-01f, -7.53768921e-01f,
  -7.90155888e-01f, -5.14312565e-01f, -4.13754851e-01f, 6.53492987e-01f, -3.57528418e-01f, 5.25589734e-02f, -1.02465665e+00f, -4.46245819e-01f, 6.74032509e-01f, 7.51424789e-01f,
  -1.02926743e+00f, 3.32203627e-01f, 3.28745097e-01f, -6.23398304e-01f, 1.80705950e-01f, -7.00383008e-01f, -7.74711549e-01f, -1.26278520e-01f, -1.90700158e-01f, -7.25557804e-02f,
  6.47874713e-01f, -8.29605281e-01f, -5.51408172e-01f, -1.11323990e-01f, -1.93217412e-01f, -1.42289549e-01f, -1.08613111e-01f, -1.38703929e-02f, 2.01285779e-02f, 1.94014400e-01f,
  3.66513759e-01f, -6.10049307e-01f, -5.41013658e-01f, -6.90256953e-01f, -9.37430486e-02f, 5.10557473e-01f, -1.15231991e-01f, -3.49715382e-01f, -7.00527132e-01f, -6.83889151e-01f,
  -1.99520022e-01f, -3.56922954e-01f, 8.56066942e-01f, -3.37852202e-02f, -4.81325001e-01f, -4.78919357e-01f, -3.12529951e-02f, -4.88948166e-01f, 5.37233055e-01f, -5.48618495e-01f,
  -3.73382956e-01f, 1.95502490e-01f, -8.47999990e-01f, 5.27511179e-01f, -2.66369641e-01f, 7.68589735e-01f, 1.02799788e-01f, 2.88808674e-01f, 5.83677627e-02f, -2.56244034e-01f,
  3.92085277e-02f, 3.87534738e-01f, 7.95411646e-01f, -9.54608381e-01f, -9.45435047e-01f, 3.43393311e-02f, 1.16241783e-01f, -3.29766095e-01f, 1.10436127e-01f, -2.57371128e-01f,
  -3.29869151e-01f, 1.88128278e-03f, -3.73117000e-01f, -8.48312527e-02f, -4.71561611e-01f, -6.21969029e-02f, 7.85897613e-01f, -2.50536561e-01f, -5.99129088e-02f, -1.04738677e+00f,
  9.58151147e-02f, 1.02059662e+00f, -2.01809615e-01f, 4.10981148e-01f, -5.59620440e-01f, -2.99256623e-01f, -1.04454112e+00f, -2.36867830e-01f, 1.54221490e-01f, -5.01029015e-01f,
  -2.84581751e-01f, 4.92387824e-02f, -4.95836288e-01f, -4.64389533e-01f, -5.76990545e-01f, -6.79922342e-01f, -9.09831643e-01f, -4.09023970e-01f, -3.74235302e-01f, -3.25924695e-01f,
  -6.30906522e-01f, -7.99098611e-02f, 6.58618867e-01f, 5.04103839e-01f, 6.08564317e-01f, 3.40028286e-01f, 6.74454331e-01f, 3.99816073e-02f, -2.22987369e-01f, -8.29975247e-01f,
  5.84308922e-01f, 4.66236956e-02f, -5.42679191e-01f, -6.28618419e-01f, 6.75104678e-01f, 1.86197534e-01f, -9.53013897e-01f, -3.08701098e-01f, 5.66379905e-01f, -4.32057023e-01f,
  -2.24401634e-02f, -1.54479109e-02f, -2.43762165e-01f, 1.38511941e-01f, 2.56663114e-01f, 5.15837133e-01f, 5.44948757e-01f, -5.30689538e-01f, -1.91779494e-01f, 1.33731519e-03f,
  -3.93908679e-01f, -2.48550698e-01f, 4.91469651e-01f, -6.77543581e-01f, -7.06457734e-01f, 1.24310219e+00f, -6.82815254e-01f, -6.87400177e-02f, -2.65500277e-01f, -6.10444546e-01f,
  -2.73067296e-01f, -5.74347019e-01f, -7.55827278e-02f, 6.48391187e-01f, -3.60597740e-03f, -6.68898165e-01f, -2.34452665e-01f, -6.77234769e-01f, -1.25448585e-01f, -5.02924502e-01f,
  4.62223947e-01f, -6.07684374e-01f, 8.83435532e-02f, 2.15101298e-02f, -2.44564842e-02f, -2.79274523e-01f, 3.84729981e-01f, -2.01067552e-01f, -4.86250281e-01f, -1.73623681e-01f,
  -5.50612569e-01f, 9.38114882e-01f, 6.15057886e-01f, 5.10802805e-01f, -1.35543004e-01f, -7.88968861e-01f, -6.06515765e-01f, -6.44782126e-01f, -5.11017561e-01f, -2.91979015e-01f,
  -5.49134128e-02f, 9.58563536e-02f, -4.63480055e-02f, -3.77255082e-01f, -6.34446025e-01f, -2.99328685e-01f, 9.27548051e-01f, -6.53495371e-01f, 7.94001520e-01f, -2.23526098e-02f,
  4.91323948e-01f, -3.32392156e-01f, -7.13288069e-01f, -7.30995655e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  1.67702228e-01f, -1.28493324e-01f, 3.71321142e-01f, -1.44352927e-03f, -3.72559041e-01f, 1.79232582e-01f, -1.48262426e-01f, -3.67278337e-01f, 1.47668004e-01f, 1.10966630e-01f,
  7.20554143e-02f, -1.92550763e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    