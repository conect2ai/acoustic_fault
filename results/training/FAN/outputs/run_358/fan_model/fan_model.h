/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x2)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 51 x 120)
const int L0_fan_Wp_rows = 51;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.94025183e-01f, 2.62400120e-01f, -3.91612202e-03f, 2.72045806e-02f, -4.52460982e-02f, -1.15087546e-01f, -1.01588890e-01f, 1.17108278e-01f, 2.96303965e-02f, 1.33619189e-01f,
  1.47622097e-02f, 1.40429642e-02f, 1.36429474e-01f, 3.75598930e-02f, -5.38263656e-02f, 1.87624604e-01f, 1.48281837e-02f, -3.07312720e-02f, 2.70560533e-02f, -2.44906247e-02f,
  9.54828709e-02f, -7.33031631e-02f, -4.90388907e-02f, 8.18363503e-02f, -1.53813913e-01f, -3.68773304e-02f, 7.32765049e-02f, 8.31073895e-02f, 4.78651840e-03f, -3.20929363e-02f,
  -5.61733395e-02f, 1.01783194e-01f, -7.71319345e-02f, 4.22174782e-02f, -1.18542753e-01f, -1.12074047e-01f, -2.40248535e-02f, -4.53851782e-02f, -2.40684617e-02f, 6.49546692e-03f,
  -2.39918940e-03f, 1.13848057e-02f, 2.47479323e-02f, 4.54237647e-02f, -3.51082310e-02f, 5.86209744e-02f, -1.62767842e-02f, -2.22491976e-02f, 4.26336639e-02f, -2.30709407e-02f,
  7.36192092e-02f, -3.12126037e-02f, -7.74851367e-02f, 4.13792301e-03f, -2.50543263e-02f, 5.12816980e-02f, 6.63288534e-02f, -4.43075551e-03f, -1.83677673e-02f, -1.63294747e-02f,
  -3.86766344e-02f, -3.35714519e-02f, 1.41720343e-02f, -3.79588269e-02f, -6.07257709e-03f, -8.99179429e-02f, 1.43756336e-02f, 1.08502535e-02f, -4.36172932e-02f, 3.09253447e-02f,
  3.99199082e-03f, -3.90047282e-02f, -6.73116595e-02f, -5.54235727e-02f, -6.70227185e-02f, -5.70785068e-02f, -3.88429463e-02f, -2.93886010e-02f, -5.73517308e-02f, -1.08668931e-01f,
  3.58077101e-02f, 2.98099387e-02f, 3.40475887e-02f, 3.03964876e-02f, 7.80259222e-02f, 1.94956418e-02f, -1.14351232e-02f, -4.17623818e-02f, -4.64366525e-02f, -2.25112662e-02f,
  9.59434062e-02f, 1.48013905e-01f, -2.65067164e-03f, -5.27196825e-02f, 3.51782106e-02f, -6.30509481e-02f, -4.04804349e-02f, 4.12613675e-02f, 1.04166992e-01f, -1.64848212e-02f,
  3.37419063e-02f, -2.66062878e-02f, -4.46153916e-02f, -3.35210264e-02f, -6.00011274e-03f, 6.70955852e-02f, 8.14691260e-02f, -3.20428610e-02f, 1.04036015e-02f, -3.01790517e-03f,
  -9.92967468e-03f, -8.01759213e-02f, -4.29843478e-02f, -2.05984712e-02f, 1.45729398e-02f, -7.04025403e-02f, -6.28349036e-02f, 5.48737198e-02f, -7.96204619e-03f, 1.07522406e-01f,
  -4.53307927e-02f, 2.69649863e-01f, -1.79048046e-01f, 1.01188153e-01f, 3.35785635e-02f, 8.12181830e-02f, 3.42242680e-02f, 1.18396372e-01f, -3.99196194e-03f, 2.91084051e-01f,
  1.26000747e-01f, 2.14847010e-02f, -3.70162316e-02f, 2.64577180e-01f, -3.76126885e-01f, -1.79698348e-01f, 1.14607044e-01f, 1.46749064e-01f, -1.06442750e-01f, 9.44214985e-02f,
  -2.85723489e-02f, 1.79148406e-01f, -6.55837730e-02f, 3.45470086e-02f, 4.56900634e-02f, 5.71942441e-02f, -4.82032970e-02f, -1.82962760e-01f, 1.86690167e-01f, -3.64318378e-02f,
  -9.73130204e-03f, -5.43455333e-02f, 2.48745158e-02f, -4.63288017e-02f, -2.83987299e-02f, 3.19974385e-02f, 1.84499640e-02f, -4.57781926e-02f, -9.75739211e-03f, -5.43349870e-02f,
  -5.85361235e-02f, -4.39003594e-02f, 6.59571812e-02f, 1.63225457e-02f, 1.90817583e-02f, -1.59075689e-02f, -3.06546176e-03f, 9.77287628e-03f, -4.69724163e-02f, 2.52049882e-02f,
  2.69308984e-02f, 2.32047178e-02f, 5.50437570e-02f, 9.59778279e-02f, -8.04947242e-02f, 5.94014823e-02f, 1.54905748e-02f, -2.56113820e-02f, 9.68863145e-02f, -8.51032697e-03f,
  2.38570869e-02f, 2.35230513e-02f, 3.58940661e-02f, 4.74199839e-03f, 6.89637363e-02f, 4.52379100e-02f, 9.56022460e-03f, -1.68767609e-02f, -5.30012138e-02f, 6.92010596e-02f,
  1.25043071e-03f, 3.20771001e-02f, 3.28469947e-02f, 6.84269238e-03f, 6.83141872e-02f, 6.82041571e-02f, -3.25180180e-02f, 1.39275836e-02f, -1.70450117e-02f, 1.11875637e-03f,
  -9.35467950e-04f, 4.54240739e-02f, 5.29663302e-02f, 3.13775265e-03f, 4.37740833e-02f, -7.31438696e-02f, 7.83043951e-02f, 2.09751967e-02f, -6.65085390e-02f, 1.06347119e-03f,
  1.54449612e-01f, 6.91336319e-02f, 1.55498972e-03f, -4.14199108e-04f, -6.17343448e-02f, 9.42572281e-02f, -8.44692532e-03f, 1.97810363e-02f, -4.91364449e-02f, 5.95107675e-02f,
  5.69178797e-02f, 4.25655860e-03f, 3.94853316e-02f, -4.97148000e-03f, -6.55031763e-03f, 5.04081324e-02f, -1.91134755e-02f, 8.29418283e-03f, 1.43398065e-03f, -2.06040330e-02f,
  2.83451360e-02f, -2.40200572e-02f, -4.72120345e-02f, -3.79553251e-02f, 9.97899920e-02f, -1.82134602e-02f, -1.92174921e-03f, -3.95977125e-02f, -5.00362813e-02f, -4.96927798e-02f,
  1.71296783e-02f, 4.24299352e-02f, -6.20645704e-03f, 2.24144030e-02f, -2.10631162e-01f, -1.66213453e-01f, -7.96525478e-02f, -7.97957275e-03f, -7.37159455e-04f, 5.19140549e-02f,
  6.79507479e-02f, 1.66837662e-01f, 1.08309947e-01f, -4.28217128e-02f, -2.00486094e-01f, 1.23517693e-03f, -1.55205056e-02f, 5.84915616e-02f, -2.15963833e-02f, 1.06930293e-01f,
  1.89128909e-02f, -4.58504222e-02f, 1.20123178e-02f, -1.47263870e-01f, -5.02915047e-02f, 8.66794772e-03f, 2.92449612e-02f, -3.91564108e-02f, -9.74585563e-02f, -1.27832398e-01f,
  -2.77658682e-02f, -1.13160815e-02f, 4.07072119e-02f, -2.42553279e-02f, -8.46230835e-02f, -2.45844126e-02f, -6.02935813e-02f, -5.52326813e-02f, -3.57560534e-03f, -2.75310618e-03f,
  3.92923392e-02f, 4.01731990e-02f, -5.46093062e-02f, 6.09006137e-02f, -2.59762164e-02f, 2.82606017e-02f, 1.26562575e-02f, -3.14578153e-02f, 4.80177924e-02f, 5.41264676e-02f,
  -4.30542156e-02f, 9.77139268e-03f, 3.22766602e-02f, 5.76668829e-02f, -6.02990650e-02f, -2.79393438e-02f, 7.71552138e-03f, -4.66884784e-02f, -4.40823734e-02f, -9.18354690e-02f,
  6.83812052e-02f, -4.87005245e-03f, -2.19634902e-02f, -1.58723351e-02f, -1.22183666e-03f, 9.51086879e-02f, 2.82202810e-02f, -1.37655698e-02f, 1.92212816e-02f, 1.15379244e-02f,
  2.34406870e-02f, 8.94683786e-03f, -1.86397936e-02f, 1.69787612e-02f, -3.83266830e-03f, 4.36233580e-02f, -1.40884947e-02f, 2.12182999e-02f, 3.70164067e-02f, -4.49663512e-02f,
  6.35568947e-02f, 1.05038742e-02f, 1.79563388e-02f, -4.68245447e-02f, -2.99499370e-02f, 2.31039599e-02f, -3.39637026e-02f, 2.81215236e-02f, -5.07309996e-02f, -5.46981804e-02f,
  -9.01543573e-02f, 7.84169957e-02f, 2.79498436e-02f, 5.13636619e-02f, 5.68603724e-02f, -2.44671609e-02f, 7.36922920e-02f, -4.26526852e-02f, 3.89445312e-02f, -7.13885725e-02f,
  2.30176784e-02f, -2.74976268e-02f, -1.60248186e-02f, -6.65682629e-02f, 1.50725637e-02f, -9.22951102e-02f, 6.80465773e-02f, 9.57057253e-02f, -3.86490338e-02f, -2.49088369e-03f,
  7.43228123e-02f, 9.52410325e-03f, 2.25437358e-02f, -6.49949163e-02f, 6.63972273e-02f, 3.33359838e-02f, 7.26015717e-02f, -2.56092139e-02f, 5.69322798e-03f, 4.82495455e-03f,
  2.85544485e-01f, 1.55922785e-01f, -3.99319753e-02f, 1.02160305e-01f, -1.33781180e-01f, -4.97089811e-02f, 6.66161105e-02f, -7.46168718e-02f, 1.59832820e-01f, 7.12668523e-02f,
  -4.44342680e-02f, 9.24876481e-02f, 4.31136563e-02f, 7.71208853e-02f, 1.62631199e-01f, 1.41594023e-01f, 1.04614511e-01f, 9.49021652e-02f, 4.34550084e-02f, 9.37203839e-02f,
  -1.37418965e-02f, -7.63015151e-02f, 2.25730799e-02f, -7.99667612e-02f, 7.11532980e-02f, 3.46953310e-02f, -4.09177132e-02f, -2.03545302e-01f, 6.20686971e-02f, -2.84405369e-02f,
  -7.60855749e-02f, 1.16706811e-01f, 1.38706435e-02f, -2.73931939e-02f, -4.57970537e-02f, 5.94072714e-02f, -7.37768337e-02f, -6.74719289e-02f, 4.60078344e-02f, 5.40045574e-02f,
  -3.77379023e-02f, 3.67469862e-02f, 8.54211822e-02f, 3.47321182e-02f, -3.08141839e-02f, 4.46960912e-04f, 3.21249776e-02f, 3.94032942e-03f, -1.29929092e-02f, -4.05377671e-02f,
  3.87836364e-03f, 1.04143165e-01f, 8.42189714e-02f, 7.98733309e-02f, 6.67641684e-02f, 3.35781127e-02f, -6.79527223e-02f, -3.77114309e-04f, -2.23532282e-02f, -4.05376256e-02f,
  5.00070080e-02f, 4.59500253e-02f, 3.08750290e-02f, 1.65327545e-02f, 2.51404401e-02f, -7.89210349e-02f, 3.49426866e-02f, -2.54117362e-02f, -1.95018407e-02f, -5.58026545e-02f,
  6.33638874e-02f, 5.81121333e-02f, -3.87553149e-03f, 3.72935645e-02f, 2.39075087e-02f, 3.17478292e-02f, -1.33539345e-02f, -2.86304094e-02f, 1.31060109e-02f, -6.62049204e-02f,
  -9.36687272e-03f, -4.35634851e-02f, -1.20679801e-02f, 3.81799005e-02f, -7.12005496e-02f, -2.91421916e-02f, 1.31910732e-02f, 4.40228172e-02f, -4.05498110e-02f, -5.96300103e-02f,
  1.96271464e-02f, 9.50647369e-02f, -8.90617631e-03f, 3.09375804e-02f, -7.61371925e-02f, 7.89018720e-03f, 1.08069792e-01f, -2.00430155e-02f, 3.33140939e-02f, 5.99370562e-02f,
  -3.39855924e-02f, 4.04548757e-02f, -3.19767073e-02f, 8.26982185e-02f, 4.87768278e-02f, 3.63043509e-02f, 6.61516041e-02f, 2.35691816e-02f, -3.57716121e-02f, -5.85770682e-02f,
  -5.22873402e-02f, -2.64748372e-02f, 4.40505287e-03f, -4.73368280e-02f, 4.96496931e-02f, 5.37005216e-02f, -4.93698716e-02f, 5.89687116e-02f, -4.46794815e-02f, 6.15437217e-02f,
  1.42295718e-01f, 1.79830678e-02f, 7.51214996e-02f, 2.01799691e-01f, 8.47416073e-02f, -2.55564511e-01f, -1.44512668e-01f, 1.13626346e-01f, 2.39092544e-01f, -7.67520443e-02f,
  -8.39777887e-02f, 4.70730616e-03f, -1.85635075e-01f, -9.99175236e-02f, -8.78479928e-02f, -2.03898922e-01f, -9.78312716e-02f, -1.44654378e-01f, 1.27983660e-01f, 5.29876910e-02f,
  6.64741918e-02f, -1.56917512e-01f, -5.77335916e-02f, 6.76522553e-02f, -3.22622731e-02f, 1.66086555e-01f, 8.41656583e-04f, 6.25484250e-03f, 5.37452549e-02f, 2.03069625e-03f,
  -9.20374915e-02f, 4.04009148e-02f, -5.78102539e-04f, -5.31900488e-02f, -4.77506965e-02f, -5.14840893e-02f, 3.96843776e-02f, -6.65507391e-02f, 1.09638773e-01f, -4.02191803e-02f,
  -1.11453488e-01f, -6.86569465e-03f, 4.51516099e-02f, -1.56657938e-02f, 8.71032849e-03f, -2.72556096e-02f, 7.83212632e-02f, 5.95634654e-02f, 2.64954977e-02f, -9.83867869e-02f,
  -5.00197560e-02f, 3.26800533e-02f, 3.84908915e-02f, 7.08121210e-02f, 7.50199780e-02f, 1.17870402e-02f, -3.96871231e-02f, 1.11760693e-02f, -7.96161499e-03f, -2.45031528e-03f,
  -2.09419783e-02f, -3.38755399e-02f, -5.85369058e-02f, 4.41619791e-02f, -2.68801898e-02f, -4.97098267e-02f, -3.67843881e-02f, -6.43429765e-03f, -5.57237826e-02f, 1.07723335e-02f,
  3.70664336e-02f, 7.94406682e-02f, -4.72072512e-02f, 1.30689451e-02f, -6.84785843e-02f, 3.55741009e-02f, -4.69175838e-02f, 7.31917694e-02f, 1.46893505e-02f, 6.73618214e-03f,
  3.67651992e-02f, 1.16766607e-02f, 3.37021425e-03f, -8.16893019e-03f, -5.55762053e-02f, 1.23043349e-02f, 4.12560813e-03f, -5.93055375e-02f, -1.60855800e-03f, -7.43458420e-02f,
  -2.71212365e-02f, 1.39575690e-01f, 9.02764052e-02f, 1.97323710e-02f, -1.49090122e-02f, -3.38621475e-02f, -1.71531811e-02f, 4.69589233e-02f, -1.18680717e-02f, 6.47564093e-03f,
  -1.34296725e-02f, 4.31368500e-03f, -5.51141845e-03f, 3.09020728e-02f, -1.56337079e-02f, -2.04331018e-02f, -4.29265238e-02f, 1.26055311e-02f, 2.69432161e-02f, -8.82986095e-03f,
  1.06692482e-02f, -9.74891260e-02f, 4.37143296e-02f, 4.52593081e-02f, -6.50851354e-02f, -2.71668397e-02f, 6.34278655e-02f, -2.57794559e-02f, -2.50253901e-02f, 1.59300752e-02f,
  -1.65601820e-01f, -2.63868440e-02f, 1.70431271e-01f, 7.63873979e-02f, -1.36327237e-01f, 1.00010755e-02f, 9.30222571e-02f, -9.21464246e-03f, 1.15828596e-01f, 1.00253252e-02f,
  1.22384792e-02f, 2.87273750e-02f, 2.10169211e-01f, 5.59463911e-02f, 1.39927059e-01f, 2.53208607e-01f, -2.88203619e-02f, 5.35211191e-02f, 1.07959561e-01f, -5.60264178e-02f,
  3.02654728e-02f, -1.03716254e-01f, 3.18369418e-02f, -1.80609956e-01f, -1.05430424e-01f, -1.31568074e-01f, -2.15453103e-01f, 3.95175852e-02f, -2.03517467e-01f, -3.59881409e-02f,
  -1.17183186e-01f, -1.55334091e-02f, -6.82265386e-02f, 4.19628322e-02f, -5.31836748e-02f, -8.43068361e-02f, -1.87974181e-02f, 1.23262748e-01f, 8.29317719e-02f, 6.71458319e-02f,
  8.15670714e-02f, -3.52309528e-03f, -8.86971205e-02f, 9.05558318e-02f, -7.98158348e-02f, -5.02339080e-02f, 1.69737525e-02f, -2.90470999e-02f, 4.48569469e-02f, 6.57648519e-02f,
  7.59873986e-02f, -7.85061275e-04f, 8.76655709e-03f, -8.14218447e-02f, 4.84461933e-02f, 7.44834319e-02f, 3.18886974e-04f, -1.51946805e-02f, -9.99298096e-02f, -5.48461378e-02f,
  5.24478815e-02f, 3.34998383e-03f, -1.80755500e-02f, 1.61080901e-02f, 7.38484436e-04f, -1.98533218e-02f, -4.26552966e-02f, -6.40673414e-02f, -1.09773166e-02f, 8.76105484e-03f,
  -2.97739208e-02f, -3.70130092e-02f, 5.85709624e-02f, 2.40946398e-03f, 2.46480908e-02f, 2.57354192e-02f, -1.71463843e-02f, 4.05692495e-02f, -1.53972572e-02f, 9.15541649e-02f,
  -5.43137128e-03f, -1.31915566e-02f, 6.13498017e-02f, -1.03815775e-02f, -3.85771133e-02f, 2.55802330e-02f, -6.07770905e-02f, 1.56851094e-02f, 1.75543297e-02f, 1.88132320e-02f,
  -1.91216379e-01f, -1.61757708e-01f, 6.18868470e-02f, -4.52355854e-02f, -3.21254134e-02f, -5.89995235e-02f, -5.28411418e-02f, -3.17086047e-03f, -2.55170446e-02f, -2.80092731e-02f,
  -6.05141595e-02f, -3.19692940e-02f, -5.49128428e-02f, -5.37950993e-02f, 5.84480017e-02f, -5.50288372e-02f, -3.80700640e-02f, -3.38865407e-02f, -6.75523952e-02f, 1.30551718e-02f,
  -7.87892938e-02f, 2.19301898e-02f, -1.86155979e-02f, -5.24524115e-02f, -5.89246228e-02f, -8.90188515e-02f, -7.83993155e-02f, 2.90643275e-02f, 4.65272404e-02f, 6.14540698e-03f,
  -4.20775637e-02f, 4.52153571e-03f, -1.74262926e-01f, -3.23678665e-02f, -9.65551753e-03f, 1.65580332e-01f, 9.38987434e-02f, 5.53003475e-02f, 4.83803339e-02f, 1.74056992e-01f,
  8.73140432e-03f, -1.34250537e-01f, 5.05745113e-02f, 5.90848327e-02f, 1.08286127e-01f, 1.10802762e-01f, 5.86458668e-02f, 1.99804977e-02f, -2.07971060e-03f, 1.12414822e-01f,
  -4.22991030e-02f, 1.47625878e-01f, -1.26130670e-01f, 3.35627273e-02f, -6.50748517e-03f, -9.75623876e-02f, -4.64106202e-02f, -9.27147921e-03f, -7.65287802e-02f, -3.94645445e-02f,
  8.65755081e-02f, 1.60764698e-02f, 2.44517624e-03f, 5.71875693e-03f, 3.71977575e-02f, 1.83107965e-02f, -7.92707354e-02f, -6.52328059e-02f, -1.57317575e-02f, -1.36487158e-02f,
  4.78488579e-02f, -6.64751530e-02f, 4.12198640e-02f, 2.56253150e-03f, -6.05640560e-02f, -1.11697055e-01f, -4.59932610e-02f, -4.78062928e-02f, -5.23106642e-02f, -3.88778709e-02f,
  -1.25560477e-01f, 5.52404206e-03f, 5.38986959e-02f, -4.25158702e-02f, 3.94073725e-02f, 1.99590269e-02f, -4.99378331e-03f, -7.28625804e-03f, -6.23908229e-02f, 1.96223706e-02f,
  5.89469522e-02f, 1.40513349e-02f, 4.86064143e-02f, -2.98530255e-02f, 2.73529813e-03f, -9.41989943e-03f, -6.62322566e-02f, -2.33141780e-02f, 3.78815532e-02f, -4.17809710e-02f,
  4.80093919e-02f, 2.36366596e-02f, 4.64464463e-02f, -6.38168231e-02f, 5.91880605e-02f, -1.29230961e-03f, 5.32763172e-03f, -2.88511422e-02f, 4.44625057e-02f, -1.83890085e-03f,
  6.68845475e-02f, 5.88546917e-02f, -2.88709290e-02f, 4.91672754e-02f, 4.22432832e-03f, 6.98653981e-02f, -4.23484072e-02f, -7.32900128e-02f, 6.27539530e-02f, -6.40961006e-02f,
  1.89048454e-01f, 1.18006676e-01f, 6.55829906e-02f, 4.88871783e-02f, 2.96779368e-02f, -2.59205308e-02f, 4.71528769e-02f, -1.53734805e-02f, -5.31390635e-03f, 6.22579344e-02f,
  -1.35466307e-02f, -2.58271657e-02f, -1.06892819e-02f, -1.87165793e-02f, 3.35279927e-02f, 4.63206135e-02f, 3.39607783e-02f, -1.15768863e-02f, 6.54939637e-02f, -1.88033041e-02f,
  8.91122315e-03f, -8.34961946e-04f, -5.16022332e-02f, 3.19991037e-02f, -2.30745319e-02f, -2.23160181e-02f, 3.42169218e-02f, -7.13387728e-02f, 3.86878885e-02f, 6.02857582e-02f,
  1.40663266e-01f, -3.09426248e-01f, 4.32051308e-02f, -8.74606818e-02f, 1.89281955e-01f, 1.92554682e-01f, 6.49004355e-02f, 1.48096848e-02f, -3.07518570e-03f, -2.70046026e-01f,
  -3.82176228e-02f, -1.46142617e-01f, -1.36241198e-01f, -1.66161910e-01f, 1.02120519e-01f, -8.85891467e-02f, -1.20962642e-01f, -1.26891658e-01f, -1.90441273e-02f, -1.40731871e-01f,
  6.99338019e-02f, -2.21789479e-01f, -4.86652888e-02f, -4.53267880e-02f, -6.03228807e-02f, 4.81556281e-02f, -1.10058747e-01f, -6.09223777e-03f, -8.38387683e-02f, 3.34869302e-03f,
  6.39531240e-02f, -1.09778591e-01f, 6.90590218e-02f, 5.36314733e-02f, 2.88030934e-02f, 5.96172400e-02f, 4.45860960e-02f, 1.96949393e-03f, 6.98606297e-02f, -3.94927152e-02f,
  -4.37235869e-02f, 5.67794032e-02f, 3.41238678e-02f, 2.57341061e-02f, -2.08824724e-02f, 2.69367043e-02f, -1.47702852e-02f, 3.69330980e-02f, -2.21746322e-02f, 4.24084365e-02f,
  7.45660737e-02f, 1.97450984e-02f, 3.68593931e-02f, -4.87977713e-02f, 1.31365750e-02f, 4.59267087e-02f, -1.65650267e-02f, -6.35870360e-03f, 3.14187147e-02f, -2.77755149e-02f,
  -2.53346898e-02f, 3.98549251e-03f, -8.17834660e-02f, 6.22274019e-02f, -3.25737894e-02f, 1.07243741e-02f, -5.28603792e-03f, -2.32972726e-02f, -3.85534018e-02f, 3.87795977e-02f,
  3.92869450e-02f, -1.54861128e-02f, 4.51132171e-02f, 4.06645723e-02f, 1.40989777e-02f, 1.16700651e-02f, 5.76710477e-02f, -7.78021440e-02f, -4.60231341e-02f, -6.05701981e-03f,
  -1.21057816e-02f, 3.38945016e-02f, 2.21923064e-03f, 3.05756666e-02f, 6.42540455e-02f, -4.55696322e-02f, -4.80103791e-02f, 2.27630790e-02f, 1.83355641e-02f, -2.46129688e-02f,
  -1.06234200e-01f, -1.62370116e-01f, 1.00587234e-02f, -3.44302766e-02f, -5.32118380e-02f, -2.88543534e-02f, -3.36977802e-02f, -2.97566149e-02f, -5.95367588e-02f, -1.92014929e-02f,
  4.53553014e-02f, -1.40244942e-02f, 5.86371422e-02f, -2.84837727e-02f, 3.58143039e-02f, -2.83904150e-02f, -3.10073439e-02f, 5.06042540e-02f, 5.01435362e-02f, -2.24618465e-02f,
  -2.89419722e-02f, 4.29906137e-03f, -5.59677519e-02f, -1.12384986e-02f, 7.37995747e-03f, -8.44892301e-03f, -5.61997353e-04f, 2.27639936e-02f, -1.35632139e-02f, -7.10335234e-03f,
  -5.71891069e-02f, 1.50191575e-01f, 1.78888589e-01f, -2.92581040e-02f, -9.88972001e-03f, 1.07444473e-01f, 7.40469294e-03f, 7.75502250e-02f, 1.25926748e-01f, -1.61754899e-02f,
  -2.50279047e-02f, -4.88893315e-02f, 5.01071103e-02f, 7.41989911e-02f, -1.54521778e-01f, -8.60066339e-02f, 5.91021888e-02f, -6.37331977e-02f, 3.96028310e-02f, -5.96284568e-02f,
  -3.39012989e-03f, -4.60241735e-02f, 7.59037957e-02f, 1.21832430e-01f, 6.23741522e-02f, 9.23127905e-02f, -7.80667290e-02f, 1.15423337e-01f, -6.98859990e-02f, -8.13649148e-02f,
  8.89951736e-02f, 2.06371304e-02f, 4.84395325e-02f, -5.61073720e-02f, 6.19115867e-02f, 8.14872887e-03f, 8.01128671e-02f, 8.39196146e-03f, 3.97545286e-02f, -1.43870106e-03f,
  -1.91887803e-02f, 6.98807463e-02f, 4.84811068e-02f, 5.08910418e-03f, 8.40244815e-02f, -2.84260698e-02f, -2.81773228e-02f, 4.34258729e-02f, -4.00461219e-02f, -4.47671525e-02f,
  2.36583553e-04f, 4.66451719e-02f, 3.88852768e-02f, 4.99947444e-02f, -4.14983034e-02f, -3.23526450e-02f, 1.72768049e-02f, -8.99226516e-02f, -2.85002794e-02f, -1.93637703e-02f,
  -2.09325142e-02f, 8.07311833e-02f, 5.51697873e-02f, 3.32234278e-02f, -7.91182891e-02f, 1.06293727e-02f, -7.94647634e-02f, -6.54705092e-02f, -4.74165268e-02f, 5.09237908e-02f,
  -2.66613830e-02f, -3.49343196e-02f, -7.42096975e-02f, 3.84881012e-02f, -4.77382950e-02f, -4.24221791e-02f, 7.13052368e-03f, 3.33058164e-02f, 7.93690905e-02f, -1.82054695e-02f,
  -3.41089889e-02f, -2.75583309e-03f, 1.32991452e-04f, 7.38744764e-03f, -8.34572539e-02f, 1.21497037e-02f, -3.03841103e-02f, 6.98902979e-02f, 9.36567970e-03f, -5.05410694e-02f,
  -4.85036261e-02f, 7.26730004e-02f, 4.78839017e-02f, 8.10864195e-02f, -4.57156599e-02f, 6.25107030e-04f, -1.13935387e-02f, 4.79232110e-02f, 4.74781319e-02f, -1.48993945e-02f,
  2.62920260e-02f, -8.05478022e-02f, -7.27034062e-02f, -7.71532506e-02f, -8.53243768e-02f, 6.34311605e-03f, 6.53024539e-02f, 4.35859188e-02f, -1.92729346e-02f, 6.37748241e-02f,
  5.62612116e-02f, -1.35094684e-03f, 1.36461565e-02f, -2.79332288e-02f, 2.39046402e-02f, -4.77883080e-03f, -2.78984085e-02f, 3.85512635e-02f, 4.96549271e-02f, 7.29088709e-02f,
  1.87844709e-01f, -1.70587022e-02f, 1.10634625e-01f, -4.85095605e-02f, -1.58299327e-01f, -1.17826611e-01f, 7.90036544e-02f, -1.72443956e-01f, -2.05627875e-03f, -1.50926173e-01f,
  3.13245580e-02f, 1.55343637e-02f, 8.67823958e-02f, -3.53127047e-02f, 2.87736505e-01f, 1.69997051e-01f, -4.23552878e-02f, 5.49216159e-02f, -3.20156850e-02f, -9.77064371e-02f,
  -7.72869959e-03f, 1.14058200e-02f, 1.46275267e-01f, -1.03053324e-01f, -1.24861948e-01f, -3.71285453e-02f, -1.36020824e-01f, -7.33922496e-02f, -1.62992887e-02f, 9.93244201e-02f,
  5.55582866e-02f, 3.67230140e-02f, 6.18405901e-02f, -3.13098952e-02f, -2.97197420e-02f, -2.35646721e-02f, -1.41875995e-02f, -5.42358612e-04f, 6.80382103e-02f, -1.77182518e-02f,
  -4.67025228e-02f, -2.90539861e-02f, 2.37901020e-03f, -2.12607253e-02f, 5.34972325e-02f, -7.19030015e-03f, 3.63887735e-02f, -8.99926275e-02f, -4.89924140e-02f, 2.49212589e-02f,
  8.42938870e-02f, -4.41243090e-02f, -6.74801841e-02f, 2.25876756e-02f, 1.08861281e-02f, -6.35057837e-02f, 6.45840690e-02f, -9.47852619e-03f, -5.28549850e-02f, -6.39615133e-02f,
  -8.34370591e-03f, -6.04140945e-03f, 1.89647228e-02f, -4.26368862e-02f, 1.85187869e-02f, -1.28493076e-02f, 2.29807366e-02f, -1.08682448e-02f, -4.12026457e-02f, 6.37439564e-02f,
  -6.34357259e-02f, -8.81168172e-02f, 2.90552229e-02f, 4.53118347e-02f, 1.09365024e-02f, 5.56918383e-02f, 4.05197591e-02f, 1.03837801e-02f, -4.13529724e-02f, -4.06074226e-02f,
  3.01065086e-03f, -4.46974114e-02f, 2.45880820e-02f, -1.65713858e-02f, -2.80625746e-02f, 9.28353798e-03f, -3.10073737e-02f, -5.30356206e-02f, -2.09530964e-02f, 4.25004438e-02f,
  -5.93632646e-02f, -2.28901133e-02f, -6.07102849e-02f, 6.85345456e-02f, -2.61883717e-02f, -1.57424342e-02f, 4.66917939e-02f, -1.19257607e-02f, -6.78446963e-02f, -5.11379838e-02f,
  -1.75156742e-02f, 4.52234969e-02f, -9.20100603e-03f, -5.98654849e-03f, 2.21145134e-02f, -8.38947594e-02f, -2.80813337e-03f, -5.03756776e-02f, 2.20264941e-02f, -5.54921962e-02f,
  -1.01284266e-01f, -8.73199999e-02f, 1.96748152e-02f, -7.74219334e-02f, -8.95677805e-02f, -8.36386438e-03f, -2.28600651e-02f, 3.27359214e-02f, -7.52306283e-02f, 3.96795310e-02f,
  2.67046154e-01f, -1.63454905e-01f, -1.45890370e-01f, 2.25848243e-01f, 2.16136947e-01f, 2.29334608e-02f, -1.25236124e-01f, 2.12201983e-01f, 6.69462085e-02f, -1.72636211e-01f,
  1.01741344e-01f, -1.68733478e-01f, -2.04340324e-01f, -2.03722548e-02f, 4.91209589e-02f, -1.93998009e-01f, 1.33186281e-01f, -8.23909510e-03f, -5.63355833e-02f, 1.28902793e-01f,
  1.45973772e-01f, 2.11596116e-01f, -2.64240261e-02f, 1.59841940e-01f, 4.10378873e-02f, 1.01523168e-01f, 2.26328775e-01f, -5.09878397e-02f, 6.84278905e-02f, -1.78563409e-02f,
  5.85596375e-02f, 1.81223154e-01f, -3.01280990e-02f, -8.23424384e-02f, 8.66326764e-02f, 4.01917025e-02f, -7.19583556e-02f, -9.98174176e-02f, -7.67419115e-02f, 1.50685972e-02f,
  -2.95347776e-02f, 7.75278211e-02f, 4.62541394e-02f, -3.82753946e-02f, 4.00364026e-02f, -2.24535894e-02f, -1.64867309e-03f, -6.85720593e-02f, 2.56624538e-02f, -5.43136634e-02f,
  -9.85703170e-02f, 7.56134558e-03f, -4.13944647e-02f, 4.13272576e-03f, 3.25749815e-02f, 2.65340339e-02f, -5.99156953e-02f, 5.30268066e-03f, 4.55509648e-02f, 6.19291812e-02f,
  2.71698292e-02f, -6.71511069e-02f, -7.12085441e-02f, 2.80548409e-02f, -1.82976741e-02f, 7.64487719e-04f, -2.89905407e-02f, 3.53463204e-03f, -8.20562169e-02f, 6.85471483e-03f,
  6.47872835e-02f, 5.05776741e-02f, -1.56748155e-03f, 2.22904515e-02f, -3.46883163e-02f, 2.37274710e-02f, -4.35209228e-03f, 2.92859618e-02f, 6.37250990e-02f, 5.20629287e-02f,
  1.11405374e-02f, 3.62829529e-02f, 1.41203962e-03f, 1.48916524e-02f, -2.67502386e-02f, -3.21247964e-03f, -2.31463294e-02f, -4.72872145e-03f, -2.07254551e-02f, 7.14536309e-02f,
  1.48244217e-01f, 2.70739138e-01f, 1.70495175e-02f, 6.62752911e-02f, 1.74324121e-02f, -5.79650626e-02f, -5.17680384e-02f, -5.48073500e-02f, 1.69914234e-02f, 7.81360734e-03f,
  -2.59724017e-02f, 1.93616608e-04f, 8.12490955e-02f, 2.27362458e-02f, -4.47361954e-02f, 4.93103527e-02f, 4.50384578e-05f, 3.90199609e-02f, 3.06386463e-02f, 5.48495129e-02f,
  5.77925257e-02f, 5.12076579e-02f, 4.70039435e-02f, 6.86667636e-02f, -2.31028832e-02f, 2.49440540e-02f, 6.05975650e-02f, -7.07041398e-02f, 7.85017153e-04f, 7.41533702e-03f,
  -1.47898421e-01f, -1.14465147e-01f, -1.74823076e-01f, -2.25998342e-01f, 5.75923221e-03f, -4.21345793e-02f, 1.20381325e-01f, -1.24872662e-01f, -7.57219940e-02f, 8.97708312e-02f,
  1.63029321e-02f, -7.79517218e-02f, 1.88711569e-01f, -1.05955906e-01f, -7.97018036e-02f, 1.07135259e-01f, -1.76106945e-01f, 2.10077665e-03f, -3.76018472e-02f, -1.30346000e-01f,
  -1.73709393e-01f, -8.85994434e-02f, -6.13197535e-02f, -4.41547334e-02f, -1.99206337e-01f, -1.40269339e-01f, -6.73650205e-02f, 5.44185564e-02f, -1.11344814e-01f, 1.78102392e-03f,
  7.52799213e-02f, -1.84175614e-02f, -2.23745275e-02f, 3.64916287e-02f, -1.89239625e-03f, -2.84556393e-02f, 6.85782824e-03f, 1.58312544e-02f, 2.20555672e-03f, -2.87655387e-02f,
  1.10105477e-01f, 2.78112832e-02f, -1.70546118e-02f, -1.79273579e-02f, -1.05448812e-01f, 2.74121240e-02f, 3.41087882e-03f, 2.21101120e-02f, 2.13315431e-02f, 3.12059671e-02f,
  -8.46627727e-02f, 2.64023407e-03f, -7.71217793e-02f, -8.08949023e-03f, -1.52040739e-02f, -3.00353710e-02f, 1.32932318e-02f, 1.02308258e-01f, -2.30137445e-02f, -2.10788473e-02f,
  9.40476358e-02f, -4.23369966e-02f, 7.51892850e-03f, 4.19636592e-02f, -2.10023373e-02f, 3.79161816e-03f, 3.15170325e-02f, 8.68093316e-03f, 1.21025033e-02f, 3.48325595e-02f,
  -1.22915506e-02f, -2.28397623e-02f, -6.66661933e-02f, -1.74547676e-02f, 2.17455272e-02f, 3.04471496e-02f, 9.31717530e-02f, -5.85996397e-02f, -5.49684055e-02f, -8.91902894e-02f,
  2.39113364e-02f, -4.30013239e-02f, 3.30971964e-02f, -6.56821951e-03f, -1.02349021e-03f, 4.21255343e-02f, -6.54429570e-02f, -1.03205487e-01f, -2.87013836e-02f, 4.80553694e-03f,
  -7.59591386e-02f, -6.25967011e-02f, 3.99190448e-02f, 1.43775558e-02f, 8.07469860e-02f, -2.14548148e-02f, 3.57351862e-02f, -1.10501023e-02f, 2.75514163e-02f, -7.08762184e-02f,
  -6.65048882e-02f, 7.27838278e-02f, 1.74823124e-02f, -2.83917282e-02f, 7.16971830e-02f, -7.13738278e-02f, -2.40400489e-02f, -7.03821629e-02f, -2.33395621e-02f, -7.54965171e-02f,
  -5.19089885e-02f, -1.53465697e-03f, -2.30141245e-02f, 6.04305975e-02f, -3.20430547e-02f, 2.40276903e-02f, -5.30176312e-02f, -5.28771393e-02f, 1.24840941e-02f, -1.61860585e-02f,
  -1.18836500e-01f, -3.50331254e-02f, -5.54598086e-02f, -1.67338282e-01f, 4.07635830e-02f, -9.66903660e-03f, 7.07321838e-02f, 6.47036405e-03f, -6.44947365e-02f, -2.05777716e-02f,
  -1.98144037e-02f, 4.14153449e-02f, 6.25940189e-02f, -8.28565285e-02f, -7.31293261e-02f, -5.38099632e-02f, -1.79893300e-01f, 1.84641555e-02f, -1.24825306e-01f, 4.03418206e-02f,
  -9.57164839e-02f, -8.69517252e-02f, -5.60086668e-02f, 1.01769771e-02f, -2.88083889e-02f, -1.03546176e-02f, 6.95101917e-02f, 3.38679142e-02f, -1.04919799e-01f, -5.79633974e-02f,
  2.15635952e-02f, 2.20065471e-02f, -5.68626821e-02f, 6.26257882e-02f, -6.35925457e-02f, 9.58290324e-02f, -1.90809686e-02f, -7.77176302e-03f, -2.45627686e-02f, -2.91863084e-02f,
  1.11801110e-01f, 8.24068114e-02f, -4.33489308e-02f, -6.09371476e-02f, 1.32071879e-02f, 4.15716553e-03f, -9.21180695e-02f, -7.08219688e-03f, -4.26470786e-02f, -4.78715673e-02f,
  6.63048699e-02f, 3.23931389e-02f, -5.36975078e-02f, -5.25676236e-02f, 5.60055114e-02f, 6.79499805e-02f, -8.03697184e-02f, 7.54024610e-02f, 4.95914184e-02f, -8.39532688e-02f,
  3.93118896e-02f, 2.05570664e-02f, -7.59570347e-03f, -3.18331532e-02f, -4.12439788e-03f, -9.49808061e-02f, -4.05153632e-02f, -4.16192301e-02f, 3.52102667e-02f, 1.59767326e-02f,
  -2.54095029e-02f, -3.25192921e-02f, 6.74396306e-02f, -4.35051285e-02f, -5.05535826e-02f, 6.24112487e-02f, 3.73772942e-02f, 5.50430752e-02f, -2.16340031e-02f, 6.44608662e-02f,
  -2.10618768e-02f, 4.59220260e-02f, 9.45975706e-02f, -3.14327329e-02f, 5.44515736e-02f, -3.59013630e-03f, -1.05974982e-02f, 1.39037874e-02f, 5.01046591e-02f, -6.45676702e-02f,
  1.37989670e-02f, -3.13204564e-02f, -2.84554455e-02f, -2.07403284e-02f, 6.80922940e-02f, 5.05371541e-02f, 9.35669150e-03f, 2.94131432e-02f, 2.24002507e-02f, -4.53977771e-02f,
  9.22841802e-02f, 7.32788444e-02f, 6.28408194e-02f, 3.50683145e-02f, -7.48275518e-02f, 1.23530151e-02f, 2.61517018e-02f, -3.70221995e-02f, 6.14527091e-02f, 3.31740081e-02f,
  3.26331914e-03f, -3.05704251e-02f, -6.59797201e-03f, -1.90593842e-02f, 3.09144817e-02f, -2.26495266e-02f, 8.15236196e-02f, -1.66930798e-02f, -7.45642185e-02f, -2.44273879e-02f,
  -1.50709063e-01f, 1.60432668e-04f, -1.29409701e-01f, -2.36627206e-01f, 9.12361592e-02f, 1.47585079e-01f, 9.06714574e-02f, -4.30224314e-02f, -5.24110459e-02f, 1.92385703e-01f,
  1.19575523e-01f, -7.82521442e-02f, 1.07724912e-01f, -1.78871572e-01f, -2.26641536e-01f, 8.75278935e-03f, -1.68548539e-01f, -4.41784710e-02f, -3.42393890e-02f, 7.62630813e-03f,
  -9.47304592e-02f, -3.01695652e-02f, -3.21055055e-02f, -1.21328682e-02f, -7.36405179e-02f, -4.94644642e-02f, -3.46435644e-02f, 1.44127384e-01f, -6.56839758e-02f, -2.99681388e-02f,
  4.65193056e-02f, -5.50021324e-03f, 6.69032056e-03f, 2.58816481e-02f, 1.60644688e-02f, 1.07206538e-01f, 4.35715429e-02f, 7.43955523e-02f, -5.15127331e-02f, 4.42103297e-02f,
  -7.24362358e-02f, 1.46376044e-02f, 1.44099037e-03f, 1.67573262e-02f, -9.44229588e-03f, 5.14260158e-02f, -1.17113544e-02f, 5.22871800e-02f, 6.07975433e-03f, -1.65785365e-02f,
  5.41761145e-02f, -1.96964992e-03f, 2.88670044e-02f, -4.04172465e-02f, -4.83236015e-02f, -1.47997783e-02f, -8.00132193e-03f, -2.15133373e-02f, -4.24810946e-02f, -5.20172566e-02f,
  -5.74490055e-02f, -2.67151613e-02f, -1.68626625e-02f, -6.87260330e-02f, 2.91892793e-02f, -5.69921508e-02f, -5.65310866e-02f, 2.43834849e-03f, -1.02248691e-01f, 4.16676961e-02f,
  -9.03622136e-02f, -2.12554224e-02f, -2.25341618e-02f, 2.08615847e-02f, 1.20811928e-02f, 3.74593362e-02f, -3.97939458e-02f, -4.09801155e-02f, 4.26775254e-02f, 3.45530473e-02f,
  -1.01476610e-02f, -7.99735114e-02f, -1.05759073e-02f, -3.87300923e-02f, 1.33055849e-02f, -3.94057808e-03f, -3.27029228e-02f, -6.67913929e-02f, -2.41372883e-02f, 4.02575620e-02f,
  -7.77360797e-02f, 4.60041501e-02f, -5.17967567e-02f, 4.39855009e-02f, -6.27743592e-03f, -6.21651532e-03f, -7.87415355e-02f, -6.00714870e-02f, -5.35442457e-02f, -7.05002323e-02f,
  4.90254350e-02f, 1.71927102e-02f, 7.27811456e-02f, -4.99799429e-03f, 3.01470719e-02f, -3.56806889e-02f, 5.37774675e-02f, -5.70095032e-02f, -1.55365551e-02f, -2.24718787e-02f,
  -2.73505226e-03f, 7.64340237e-02f, -2.43836772e-02f, -5.06913383e-03f, -2.76828259e-02f, 4.57948423e-04f, 1.34819690e-02f, -1.69824865e-02f, 5.15913684e-03f, -4.11921144e-02f,
  2.42454961e-01f, -6.87337369e-02f, 1.37722388e-01f, 1.51888922e-01f, 1.08380452e-01f, 3.99414413e-02f, -5.02991267e-02f, 2.23479904e-02f, -8.68262798e-02f, -1.13706375e-02f,
  2.76727062e-02f, 1.29816800e-01f, -8.72643963e-02f, 7.92962089e-02f, 1.46873087e-01f, -9.60412845e-02f, 4.25583273e-02f, 1.11506006e-03f, -4.61988449e-02f, 1.78327158e-01f,
  1.02903165e-01f, 1.94460936e-02f, 3.14558810e-03f, 5.60298748e-03f, 1.37782022e-01f, -4.68769623e-03f, 5.05257584e-02f, -2.80924905e-02f, 8.13336000e-02f, -6.35645464e-02f,
  -7.00377002e-02f, 1.60330757e-02f, 1.60489026e-02f, -3.51748690e-02f, -1.91942211e-02f, 7.84059167e-02f, 2.35695336e-02f, -7.57710487e-02f, 9.02605895e-03f, 4.78190556e-02f,
  -1.66187789e-02f, 6.72382861e-02f, -4.75079147e-03f, -3.88430171e-02f, 1.15722641e-02f, 4.75156456e-02f, -1.07162567e-02f, 4.07911465e-02f, -9.32535604e-02f, 5.47318533e-02f,
  7.62820765e-02f, 1.01457341e-02f, 7.05752373e-02f, -4.44221981e-02f, 4.08924930e-02f, -4.49025743e-02f, 9.96684749e-03f, 9.99689996e-02f, -7.69546479e-02f, -5.10074906e-02f,
  2.62638200e-02f, -2.27755103e-02f, -5.94458133e-02f, -7.08701275e-03f, -5.22222556e-03f, -7.09560812e-02f, 4.83792983e-02f, -6.44703880e-02f, 4.94103655e-02f, -3.00155506e-02f,
  8.33694264e-02f, 7.07255080e-02f, 1.26532689e-02f, 8.10716674e-02f, 9.23553854e-02f, 6.96339831e-02f, -3.49892974e-02f, -7.99254794e-03f, -3.44575159e-02f, -4.18254472e-02f,
  -7.86656663e-02f, 5.92640899e-02f, 1.58177037e-02f, 7.65775740e-02f, -9.37546343e-02f, 6.04135357e-02f, -6.38557598e-02f, 3.31854783e-02f, -6.63112849e-02f, -2.02773847e-02f,
  2.15773042e-02f, -5.33560477e-02f, -2.30328757e-02f, 4.86689853e-03f, 3.80985066e-02f, 7.35955983e-02f, -6.77527860e-02f, 9.52144340e-02f, 6.05288111e-02f, 4.45583425e-02f,
  6.46514744e-02f, 6.40450453e-04f, -9.59188491e-03f, -2.03358158e-02f, -6.32050931e-02f, -7.14104697e-02f, 5.08454703e-02f, -2.50145588e-02f, -3.11069544e-02f, 1.73527505e-02f,
  8.36984739e-02f, -6.69111386e-02f, -4.07404229e-02f, 7.37466142e-02f, 2.26789918e-02f, -7.68237114e-02f, 2.67251693e-02f, 1.47875967e-02f, -1.11258440e-02f, 2.68512443e-02f,
  -7.77914301e-02f, -1.74941346e-01f, 2.64031254e-02f, 5.49588837e-02f, 3.39023732e-02f, -1.55453086e-01f, -2.38353878e-01f, -4.50722277e-02f, 1.59466267e-03f, -8.63869861e-02f,
  -9.10763443e-02f, 7.50710592e-02f, -1.37250125e-01f, -1.45169511e-01f, -7.76684359e-02f, -8.07937011e-02f, -1.15688168e-01f, -1.87854525e-02f, 6.98042959e-02f, -4.14484292e-02f,
  -3.97635531e-03f, -1.45331100e-01f, 1.29662871e-01f, 8.98959339e-02f, 2.62906775e-02f, 1.64623305e-01f, 1.21547945e-01f, 2.59655844e-02f, 5.18128835e-02f, 9.45755616e-02f,
  -5.15441559e-02f, -5.64418733e-02f, -9.46291909e-03f, 9.75048915e-02f, 1.72196571e-02f, 4.29847604e-03f, 6.46851063e-02f, 4.24602441e-02f, 1.13732852e-01f, -2.10293103e-02f,
  -5.83474189e-02f, 2.71491576e-02f, -9.65546072e-03f, 6.69726878e-02f, -5.04947342e-02f, -4.18035761e-02f, 1.42103834e-02f, 5.54360971e-02f, -3.93529944e-02f, -1.10644149e-02f,
  -1.28154131e-03f, -6.36354163e-02f, -4.03003320e-02f, -2.82298997e-02f, 9.03057680e-02f, 4.69037592e-02f, 5.01899198e-02f, -1.62545070e-02f, -1.27449697e-02f, -7.06527233e-02f,
  -5.08381799e-02f, -4.09337655e-02f, -6.49323268e-03f, -1.58249605e-02f, -1.52852423e-02f, 6.97113201e-02f, 2.25681216e-02f, -5.48363402e-02f, 6.55971691e-02f, -7.49785826e-03f,
  4.96557802e-02f, 7.92404041e-02f, -5.08134551e-02f, -9.28372741e-02f, 2.93456968e-02f, 2.64244117e-02f, -1.22345956e-02f, -4.20454815e-02f, 7.91545957e-02f, 4.98396493e-02f,
  1.11365048e-02f, 4.70263418e-04f, 1.94242243e-02f, -2.25110911e-02f, -2.75927875e-02f, 5.05358959e-03f, 2.12670080e-02f, -2.92960368e-02f, 6.42719492e-02f, 2.10278109e-02f,
  -1.14941774e-02f, -1.75870329e-01f, -5.40023968e-02f, -2.53049061e-02f, 6.37794263e-04f, -1.02256313e-02f, -2.01083776e-02f, -8.76558051e-02f, -7.50808883e-03f, 3.53072174e-02f,
  4.72943783e-02f, -2.18418688e-02f, -4.76464443e-03f, 2.66990587e-02f, 9.58709139e-03f, -5.24355248e-02f, -7.88468122e-02f, 5.18761165e-02f, -1.40317371e-02f, -3.28499898e-02f,
  6.58970475e-02f, 4.41828929e-02f, 7.13847131e-02f, -3.71995792e-02f, 2.64229532e-02f, -4.18014489e-02f, -2.18684673e-02f, 1.58835631e-02f, 4.44220193e-02f, 3.53751183e-02f,
  -1.43963754e-01f, 2.21221939e-01f, 2.46705353e-01f, 1.21051669e-02f, -1.52169913e-01f, -1.07871704e-01f, -1.08943582e-01f, -3.50090116e-02f, -9.33731571e-02f, 2.10147370e-02f,
  -1.16482459e-01f, 2.08312005e-01f, -7.86846206e-02f, 9.07720029e-02f, -4.74649146e-02f, -7.03720897e-02f, -1.33191675e-01f, -5.54466248e-02f, -6.13749668e-04f, 3.41200344e-02f,
  -6.73607513e-02f, -3.40317562e-02f, 8.06431845e-02f, 3.79902571e-02f, 9.70381200e-02f, 7.12534413e-02f, 8.73163622e-03f, 4.20209467e-02f, 6.72542974e-02f, -1.10331113e-02f,
  -2.58169919e-02f, 1.08923525e-01f, -3.93324159e-03f, 3.98580134e-02f, -3.98739986e-02f, -1.14402985e-02f, 4.73263152e-02f, 7.77408257e-02f, -4.70826887e-02f, 1.74403414e-02f,
  1.04365160e-03f, 2.92644072e-02f, 6.91996813e-02f, 1.47096096e-02f, 3.01531283e-04f, 4.40791138e-02f, -2.98193167e-03f, -3.51421088e-02f, 1.19727008e-01f, 4.15771306e-02f,
  1.22285010e-02f, 1.29319802e-02f, -5.29742092e-02f, 8.20808485e-02f, 2.34969016e-02f, -4.07883264e-02f, -3.04099973e-02f, 8.42517316e-02f, 4.95415106e-02f, 6.14060983e-02f,
  3.06906439e-02f, -2.12345123e-02f, 5.47687570e-03f, 2.51373015e-02f, 1.94724277e-02f, -3.05727255e-02f, -7.22072646e-02f, -2.07661111e-02f, -1.20703373e-02f, 1.94528960e-02f,
  -2.73053441e-02f, 7.54170343e-02f, -1.32358093e-02f, -1.60742123e-02f, 2.08138060e-02f, 5.45710325e-02f, 1.09546082e-02f, -3.17065567e-02f, -1.46987299e-02f, 7.59509206e-02f,
  3.03341243e-02f, 1.25379357e-02f, 5.41948304e-02f, 3.46617885e-02f, 4.12569158e-02f, -3.54128480e-02f, -5.68189695e-02f, 6.94782212e-02f, 1.43746436e-02f, -1.10932793e-02f,
  -8.57025106e-03f, -9.42140352e-03f, 1.26812071e-01f, 7.44088665e-02f, 6.08940050e-02f, -6.55016378e-02f, -3.72419618e-02f, 1.94673743e-02f, 1.93173923e-02f, -3.17777619e-02f,
  -5.57748750e-02f, -6.46172911e-02f, 1.94501374e-02f, -4.79736589e-02f, 3.64870429e-02f, -2.12460179e-02f, 6.40929583e-03f, 2.13075592e-03f, -8.43079239e-02f, -3.18536931e-03f,
  4.78020459e-02f, -1.30303875e-02f, -4.77440581e-02f, -5.73587716e-02f, 3.13037969e-02f, -4.04528975e-02f, -3.08061875e-02f, -3.23662460e-02f, 3.31790820e-02f, 1.97626911e-02f,
  1.96610555e-01f, -7.42579550e-02f, -8.00751150e-02f, 2.01751858e-01f, 1.11519527e-02f, 8.27232152e-02f, 8.06250647e-02f, 1.13170236e-01f, 1.10521130e-01f, -7.64473453e-02f,
  2.62911618e-02f, -3.80665511e-02f, -2.37929691e-02f, 9.20058191e-02f, 1.69865310e-01f, -5.26871607e-02f, 1.57307804e-01f, 7.27231577e-02f, 6.33999854e-02f, 1.20181412e-01f,
  5.25936782e-02f, 1.13991119e-01f, 4.82381359e-02f, -6.64764270e-02f, 1.01704553e-01f, -7.60893598e-02f, -3.93496454e-02f, -7.81347975e-02f, 7.57352039e-02f, -9.16353911e-02f,
  -4.69644032e-02f, -3.81199084e-02f, -4.61870879e-02f, -5.03617153e-02f, 9.45777819e-02f, 5.57336882e-02f, 9.25182644e-03f, 4.15459238e-02f, 4.19443697e-02f, 1.29457545e-02f,
  1.98776349e-02f, -1.23459687e-02f, 7.04264939e-02f, 1.10770613e-02f, 8.24992359e-02f, -4.65360582e-02f, -6.84804469e-02f, 1.95292216e-02f, 7.80102378e-03f, 2.04167422e-02f,
  -1.89816467e-02f, 4.08061780e-02f, -2.29396042e-03f, -3.15766782e-02f, 9.71612148e-03f, -1.35655515e-02f, 4.11894657e-02f, 1.64663419e-02f, -9.16754175e-03f, -1.47622647e-02f,
  -3.18071805e-02f, -1.96303297e-02f, -4.55390625e-02f, -2.88665593e-02f, -5.91244474e-02f, 1.31733716e-02f, -1.39555484e-02f, 4.26991880e-02f, 8.67183134e-02f, -1.64457746e-02f,
  1.03621036e-02f, 2.10406557e-02f, 3.44511941e-02f, -4.44079451e-02f, -1.97676215e-02f, -4.45925817e-02f, -7.10272044e-03f, -2.70998515e-02f, 8.22925642e-02f, 2.99532805e-02f,
  5.45769744e-02f, -2.46662032e-02f, 2.82913912e-02f, -3.80135812e-02f, 6.54053912e-02f, -6.35969490e-02f, -1.60485040e-02f, -7.15122893e-02f, 6.82211295e-02f, -5.17161600e-02f,
  8.12408142e-03f, 6.40819743e-02f, -6.05084412e-02f, -5.20361178e-02f, 1.93009619e-02f, 5.41099049e-02f, 5.62476441e-02f, -3.12916599e-02f, -1.43723432e-02f, -2.27366742e-02f,
  -6.10645511e-05f, -3.72530743e-02f, -3.36049572e-02f, -2.86250096e-02f, 1.62849668e-02f, 7.99953118e-02f, 7.20662400e-02f, 5.68487979e-02f, 8.78961906e-02f, -4.61759865e-02f,
  4.37646843e-02f, 6.01451425e-03f, -4.68255915e-02f, 4.92174290e-02f, -5.75724170e-02f, 6.44381717e-02f, -4.26595390e-04f, 3.88895981e-02f, -6.44014701e-02f, 6.73639402e-02f,
  -5.15478589e-02f, 1.16440155e-01f, 1.39427409e-01f, -1.13520520e-02f, 5.36421649e-02f, -1.43421099e-01f, 8.77182838e-03f, -1.44761726e-02f, 6.81022033e-02f, -5.05500892e-03f,
  -9.21477824e-02f, 3.22819017e-02f, 6.53444454e-02f, -1.90490335e-01f, -2.45846018e-01f, -8.60890448e-02f, -2.48540148e-01f, -9.06460360e-03f, 3.83071862e-02f, 5.54551929e-02f,
  -8.83436576e-03f, -9.66752172e-02f, -9.17355269e-02f, 8.08896124e-02f, 6.56657293e-02f, 8.19076821e-02f, 1.17966738e-02f, 8.49469975e-02f, 3.13830152e-02f, -9.93691944e-03f,
  -1.45270647e-02f, -1.37866745e-02f, 1.24702752e-01f, 3.97249460e-02f, -2.86598075e-02f, -9.59419552e-03f, -1.91396731e-03f, 4.77787480e-02f, 6.02175817e-02f, -1.11741275e-02f,
  9.64446440e-02f, -4.91856858e-02f, -2.79813744e-02f, 1.91132049e-03f, 7.46617913e-02f, 1.02146931e-01f, 1.04912650e-02f, 7.67319649e-02f, -3.82911228e-02f, 5.06736636e-02f,
  -7.02936808e-03f, -4.12349626e-02f, 3.24943773e-02f, -6.07664920e-02f, -5.72690405e-02f, -4.27163132e-02f, -3.83639596e-02f, 5.36339134e-02f, 3.05742230e-02f, -4.89648208e-02f,
  -1.33243248e-01f, -1.88937616e-02f, 6.32396340e-02f, 8.79968405e-02f, 6.79498985e-02f, 2.75543481e-02f, 4.31623906e-02f, -2.02207882e-02f, 2.37915702e-02f, -7.08922520e-02f,
  -2.22554039e-02f, -2.35893168e-02f, 3.45270932e-02f, 2.18618903e-02f, 1.99453365e-02f, 2.25286018e-02f, -1.97940450e-02f, -3.34791541e-02f, -1.67784858e-02f, 2.29587257e-02f,
  -4.42494527e-02f, 3.08909826e-03f, 7.04685599e-02f, -3.48168239e-03f, -1.95720457e-02f, 4.61491421e-02f, -5.77312633e-02f, 3.93713489e-02f, 3.18244062e-02f, 7.16440156e-02f,
  -1.76162481e-01f, -1.28637686e-01f, -4.07569557e-02f, 6.18525408e-02f, -3.89516889e-03f, -3.95099595e-02f, -5.33738546e-02f, -2.82026827e-02f, -5.27068861e-02f, -5.33553027e-02f,
  -6.87395260e-02f, 6.80480301e-02f, -7.47017488e-02f, -2.00549401e-02f, 5.33273630e-02f, -1.06322132e-01f, -6.58112317e-02f, 3.28757279e-02f, -7.25052843e-04f, -6.38656542e-02f,
  8.07818025e-02f, 5.82541116e-02f, -7.30175078e-02f, 1.39990160e-02f, -2.52411161e-02f, 6.94818795e-02f, -1.04708225e-02f, 1.01488293e-03f, -9.26327929e-02f, 2.30306759e-03f,
  1.88993603e-01f, -7.01356307e-03f, -1.77378058e-01f, -2.36678030e-02f, 1.89811558e-01f, -3.82083245e-02f, -1.13990843e-01f, 1.55626275e-02f, -2.06240676e-02f, -8.84622559e-02f,
  3.68518382e-03f, -3.85492779e-02f, -1.72874346e-01f, -2.36387495e-02f, 1.11520998e-01f, -9.79523882e-02f, -3.70520316e-02f, -5.23648560e-02f, 4.26058806e-02f, 1.34567738e-01f,
  1.74340215e-02f, 2.01503009e-01f, -8.63517225e-02f, 7.07970262e-02f, 6.84029609e-02f, -5.90444356e-02f, 1.26569912e-01f, -5.44945374e-02f, 1.48317203e-01f, 1.12230472e-01f,
  3.25565785e-02f, 4.50215787e-02f, -1.28939196e-01f, 1.13840960e-02f, 9.75127215e-04f, 5.78818992e-02f, -1.37367786e-03f, 5.18730879e-02f, -7.68533722e-03f, 7.00853467e-02f,
  5.36994375e-02f, 4.45066802e-02f, 5.93870841e-02f, 1.87153928e-02f, -6.42539188e-03f, 2.60970201e-02f, -6.80783540e-02f, 3.59168276e-03f, -6.97982684e-02f, 2.77452245e-02f,
  -1.18735053e-01f, 2.00750493e-02f, -1.02407180e-01f, -8.62480775e-02f, -8.94505531e-02f, -4.60885353e-02f, -2.67906580e-02f, 2.53050681e-02f, 6.40844479e-02f, -4.82096598e-02f,
  7.63470083e-02f, 2.93286983e-02f, -4.83300723e-02f, -4.59018275e-02f, -1.74654238e-02f, 2.40094271e-02f, -6.35467023e-02f, -1.54817021e-02f, 3.45225260e-02f, -5.59478365e-02f,
  4.07181419e-02f, 4.79453653e-02f, 1.13704661e-02f, -6.35434361e-03f, 6.06374778e-02f, -3.21314344e-03f, 2.23219786e-02f, -2.20914353e-02f, -6.04417734e-02f, -5.32703996e-02f,
  -2.90266275e-02f, -1.51383672e-02f, -2.58803070e-02f, -1.97343717e-04f, 5.30116223e-02f, 2.85796411e-02f, 1.85245872e-02f, -5.59475273e-02f, 3.96003909e-02f, 2.43501421e-02f,
  3.44642103e-02f, 4.00059223e-02f, 3.03799007e-02f, -1.52989784e-02f, -5.07466644e-02f, 6.25537559e-02f, -1.11263849e-01f, -1.80003699e-02f, -5.81170395e-02f, 2.47589983e-02f,
  1.81638747e-02f, -1.98820364e-02f, -3.09884008e-02f, -1.35609449e-03f, 1.04043605e-02f, 2.12896485e-02f, 8.81144181e-02f, -3.89258523e-04f, 3.05241477e-02f, 1.92146618e-02f,
  -1.74536854e-02f, 2.53417697e-02f, 7.13765481e-03f, -1.62486322e-02f, 4.19117771e-02f, 3.56341973e-02f, 9.13137794e-02f, 1.90700758e-02f, 9.22819823e-02f, 1.93514749e-02f,
  3.05877645e-02f, 3.86128947e-03f, 1.49884999e-01f, 1.03921942e-01f, 7.01774955e-02f, 6.91884384e-02f, 1.39885649e-01f, 8.34363773e-02f, 3.09675783e-01f, 7.81878904e-02f,
  -4.93242815e-02f, 1.21597171e-01f, 2.44483142e-03f, 1.17768109e-01f, -2.92312670e-02f, -8.02908018e-02f, 9.52116400e-03f, 6.12468570e-02f, -5.04278429e-02f, 5.96943684e-02f,
  9.36746970e-03f, -1.36440396e-01f, -1.41234636e-01f, -1.57569185e-01f, 2.50855274e-02f, -3.75597849e-02f, -2.13128656e-01f, -1.14560351e-01f, 5.02006384e-03f, -8.79999157e-03f,
  3.60595174e-02f, 1.06541783e-01f, -4.44998778e-02f, 7.60174245e-02f, -4.94849943e-02f, -2.46644560e-02f, 1.65158219e-03f, -6.00826703e-02f, -2.29271166e-02f, 3.36040221e-02f,
  -6.48405552e-02f, 6.32985830e-02f, 5.25941700e-02f, 1.41991097e-02f, 7.04987943e-02f, -4.29264642e-03f, -2.34727524e-02f, 2.08396092e-02f, -3.12354546e-02f, -4.63683233e-02f,
  1.03757549e-02f, 8.04641098e-03f, 6.13998063e-02f, 3.46575491e-03f, -3.15740295e-02f, 7.57594630e-02f, -5.14093274e-03f, 4.01840098e-02f, -1.48280300e-02f, 8.93711671e-02f,
  -3.80770788e-02f, 1.72646139e-02f, 3.83698903e-02f, 6.88612312e-02f, -4.67559099e-02f, 1.84248202e-02f, 5.06323203e-02f, -6.23451397e-02f, 6.46541268e-02f, 5.59456274e-03f,
  -3.31359245e-02f, -9.55502223e-03f, 8.27268958e-02f, -3.14184390e-02f, 4.87583317e-02f, 5.84794804e-02f, 1.89183075e-02f, -2.34909579e-02f, 1.43055255e-02f, 3.43066305e-02f,
  3.68744321e-02f, -2.55707446e-02f, 4.99821007e-02f, -3.50911878e-02f, 7.99482092e-02f, 3.97925004e-02f, -4.77585420e-02f, 4.51095812e-02f, -5.35051385e-03f, -9.97883528e-02f,
  -1.43944006e-02f, -2.08404176e-02f, 3.00546028e-02f, 9.24664363e-03f, -3.18050310e-02f, 1.41489701e-02f, -4.88409139e-02f, 8.96349251e-02f, 5.70103861e-02f, 2.55627837e-02f,
  3.00825033e-02f, -6.77209115e-04f, 1.68079920e-02f, 6.53951755e-03f, 3.15224752e-02f, 4.59411032e-02f, -2.93044001e-02f, 1.19186277e-02f, 9.46637429e-03f, -2.57177036e-02f,
  -5.36650121e-02f, 6.82599768e-02f, 2.53407061e-02f, -3.15720960e-02f, 6.68053478e-02f, -4.93260399e-02f, 4.46343329e-03f, 3.58831361e-02f, -5.81059419e-02f, 5.53703606e-02f,
  1.45253781e-02f, 1.88434139e-01f, 7.27960318e-02f, 1.80749595e-01f, -3.80589887e-02f, -4.30521592e-02f, -1.68740824e-01f, 1.27638116e-01f, 1.22907177e-01f, 4.85128835e-02f,
  -9.71270427e-02f, 1.54119059e-01f, -1.05541110e-01f, -3.36947702e-02f, -1.78004697e-01f, -1.29708573e-01f, -3.47060449e-02f, 7.71273999e-03f, 5.80087118e-03f, 5.57329990e-02f,
  -7.44267851e-02f, 3.63313779e-02f, -1.55783176e-01f, 1.26215011e-01f, 7.00162351e-02f, 1.01756476e-01f, -5.94940707e-02f, -7.79086128e-02f, 4.88150902e-02f, -3.14863995e-02f,
  2.85516102e-02f, 9.76497605e-02f, -3.26852538e-02f, 5.75577021e-02f, 1.61341317e-02f, -4.31604497e-02f, -1.47823375e-02f, -6.99198470e-02f, 5.85306846e-02f, -2.20089089e-02f,
  7.62637332e-02f, -1.63125172e-02f, 1.20894596e-01f, -1.02013899e-02f, 2.65889857e-02f, 8.74967873e-02f, -1.94071382e-02f, 1.13954330e-02f, 5.82819358e-02f, 6.29201680e-02f,
  2.02334113e-02f, 5.83554432e-02f, 6.30120635e-02f, -5.17866910e-02f, -6.38779551e-02f, -7.30634434e-03f, -7.93072507e-02f, -2.95440126e-02f, 9.46381688e-03f, 7.73629248e-02f,
  6.89911917e-02f, -6.13648593e-02f, -2.00741664e-02f, 5.95566556e-02f, -3.66694666e-02f, 2.92217024e-02f, 6.87367916e-02f, -5.81460493e-03f, 3.10968291e-02f, 1.53046260e-02f,
  4.77791913e-02f, -1.57474559e-02f, 5.63252792e-02f, 4.06984687e-02f, 5.69172502e-02f, 5.97082265e-02f, 2.85830884e-05f, 2.78634275e-03f, -5.46688549e-02f, -5.29432260e-02f,
  -3.31355743e-02f, -1.98126789e-02f, -2.33329250e-03f, -5.06951250e-02f, 4.02331464e-02f, -6.73148334e-02f, 1.87286157e-02f, -1.02196028e-02f, -5.54264709e-02f, 1.91673506e-02f,
  -8.28785300e-02f, 1.65675133e-01f, 1.59038603e-02f, 5.36279529e-02f, 1.16426134e-02f, -2.81999279e-02f, 4.12443429e-02f, 6.96712211e-02f, -1.74316708e-02f, -7.70079112e-03f,
  -2.42033377e-02f, -8.63873959e-03f, -5.02431393e-02f, 5.65976538e-02f, -9.91692673e-03f, 3.83854546e-02f, -7.96038564e-03f, 1.77488750e-04f, 5.28878197e-02f, -1.89815871e-02f,
  7.00671822e-02f, -4.66858931e-02f, -8.72434750e-02f, -4.26412560e-02f, 5.52331358e-02f, 4.76567000e-02f, 6.79752231e-02f, -5.97145967e-03f, 1.83774531e-02f, 2.12890692e-02f,
  -1.59572318e-01f, 1.77920610e-02f, 1.80620268e-01f, -3.49831060e-02f, 2.02165335e-01f, -1.39202699e-01f, -2.80970991e-01f, 2.03423843e-01f, -1.08384430e-01f, -1.58499077e-01f,
  1.43259317e-02f, -1.74341261e-01f, -1.52414158e-01f, -4.33304571e-02f, -1.31339341e-01f, -2.05340192e-01f, -1.82802733e-02f, -1.07647508e-01f, 2.76211109e-02f, 1.53859317e-01f,
  8.20444450e-02f, -3.47943455e-02f, -3.95174604e-03f, 2.17900857e-01f, 1.30226091e-01f, 9.57945660e-02f, -3.15961950e-02f, 1.48097664e-01f, 1.24837622e-01f, 2.37757061e-02f,
  -8.94784629e-02f, 4.89723124e-02f, 9.99881402e-02f, -3.26805972e-02f, 6.08219132e-02f, -3.31004560e-02f, -7.39721060e-02f, 3.62412725e-03f, 2.77047162e-03f, 1.59984920e-02f,
  -1.85717009e-02f, -3.17059010e-02f, -8.17088969e-03f, -1.00289173e-02f, 6.49894476e-02f, 7.20910802e-02f, 9.50299576e-02f, -4.00532177e-03f, 8.86764973e-02f, -3.50469351e-02f,
  7.06503110e-04f, 1.58230867e-02f, 1.48527622e-02f, -1.05984949e-01f, -8.27016495e-03f, 1.79452803e-02f, -1.70825161e-02f, -2.80919373e-02f, -5.03460616e-02f, -4.12008427e-02f,
  9.02094170e-02f, 2.67755613e-02f, -3.19100507e-02f, 6.93839267e-02f, 1.53932339e-02f, 9.63553712e-02f, 4.07011770e-02f, 3.08527388e-02f, 5.28254285e-02f, -1.45337079e-02f,
  4.69878055e-02f, 1.09880771e-02f, -1.91177782e-02f, -7.07607791e-02f, -6.92179650e-02f, 8.23783968e-03f, 4.83154953e-02f, -2.29250900e-02f, 2.91436780e-02f, 8.92268401e-03f,
  -6.83798715e-02f, 3.80477831e-02f, -4.05858532e-02f, 9.41205397e-03f, -4.55738045e-02f, 1.18459435e-02f, 1.76582634e-02f, 6.26937672e-02f, -3.34990360e-02f, -3.36140320e-02f,
  3.26812267e-02f, 4.80260588e-02f, 7.15753734e-02f, -4.08908576e-02f, -5.24573289e-02f, 2.24547125e-02f, -5.86604141e-03f, 2.18659025e-02f, 6.06144685e-03f, -2.44281292e-02f,
  -4.72406335e-02f, 2.91610751e-02f, -1.74684860e-02f, 1.14865163e-02f, 2.62943078e-02f, -1.07958335e-02f, -6.69434518e-02f, -7.36427009e-02f, 6.26253858e-02f, 4.44502272e-02f,
  -2.13765111e-02f, -2.89741326e-02f, 1.17368437e-02f, 5.00552841e-02f, 4.27710898e-02f, -2.30742432e-02f, 4.43516113e-02f, 5.22930920e-02f, 6.15445338e-02f, 1.65159553e-02f,
  -2.00138852e-01f, 2.61118095e-02f, 6.96471930e-02f, -9.98796150e-02f, 2.76369378e-02f, -7.03802630e-02f, 9.59877223e-02f, -1.19832642e-01f, -2.38388538e-01f, 3.75333354e-02f,
  1.42944157e-01f, -5.04752472e-02f, 1.30368799e-01f, -6.02478012e-02f, -1.76839098e-01f, 6.17078990e-02f, -1.94698051e-02f, -4.39922772e-02f, -1.37980953e-01f, -2.37449794e-03f,
  -1.37034461e-01f, 3.04841320e-03f, -2.27098968e-02f, 8.58117118e-02f, 8.95168334e-02f, 6.34281291e-03f, -6.67636096e-02f, 7.41502270e-02f, 7.25156963e-02f, -1.69040356e-03f,
  3.54316942e-02f, 2.05151234e-02f, -2.16463488e-03f, -5.53892516e-02f, -7.56727858e-03f, 6.59545735e-02f, -3.12176924e-02f, 7.48773664e-02f, 5.68288639e-02f, -4.28599417e-02f,
  -7.46218488e-02f, -3.07172108e-02f, -2.00535581e-02f, 4.44738716e-02f, -7.23164082e-02f, 1.13949152e-02f, 3.53996158e-02f, 7.47194365e-02f, 4.68522534e-02f, 8.26361403e-02f,
  4.21209894e-02f, -1.37754688e-02f, -6.09505698e-02f, -5.91659620e-02f, -9.39492718e-04f, -6.83579594e-02f, -7.29547888e-02f, -3.14904414e-02f, -8.52698460e-02f, -8.67995843e-02f,
  3.73064466e-02f, 4.25086394e-02f, -1.23347668e-02f, 6.50584251e-02f, 4.71225120e-02f, 3.61235142e-02f, 1.35629391e-02f, 3.25624384e-02f, 4.66506463e-03f, 4.91959080e-02f,
  3.58895250e-02f, -4.30868715e-02f, 6.94704726e-02f, -5.32617643e-02f, 1.06727211e-02f, 1.83353052e-02f, 1.76413003e-02f, 3.25228833e-02f, 5.52960038e-02f, 7.38900006e-02f,
  -7.59057142e-03f, -7.37943947e-02f, -3.99764925e-02f, 5.91829494e-02f, -2.78183375e-03f, -4.67213206e-02f, -7.39675984e-02f, 6.33457676e-02f, 1.34512931e-02f, -3.59659865e-02f,
  -1.37932496e-02f, -1.56272992e-01f, -1.59790693e-03f, -3.16976309e-02f, -4.16968912e-02f, -1.58346146e-02f, -4.16640677e-02f, -6.13230355e-02f, -1.63737014e-02f, 1.17894029e-03f,
  3.05505209e-02f, -3.96649353e-02f, -4.21242826e-02f, -7.60658309e-02f, -1.85269825e-02f, 4.27030027e-02f, 2.61623971e-02f, 2.00805664e-02f, 3.93455327e-02f, -4.78341058e-02f,
  7.48333707e-02f, -1.48197757e-02f, -1.37953153e-02f, -7.60598332e-02f, -9.25686490e-03f, 4.95674554e-03f, -8.38168710e-02f, 1.85346659e-02f, -1.57046672e-02f, 8.66221730e-03f,
  2.89404362e-01f, -2.02625021e-01f, 4.21953686e-02f, 1.66311059e-02f, 7.32842013e-02f, 3.01750451e-01f, 1.80298105e-01f, -3.48626077e-02f, -2.11316850e-02f, -6.09186478e-02f,
  6.70578554e-02f, 5.48874401e-02f, -1.63499743e-01f, 4.94655967e-02f, 6.15595877e-02f, -1.36101365e-01f, 1.62333041e-01f, 3.04956306e-02f, -8.16874132e-02f, 4.84519452e-02f,
  -5.22371270e-02f, -6.87306002e-02f, -8.03445950e-02f, -1.43071920e-01f, 9.91535187e-02f, 2.44454518e-02f, -1.22534499e-01f, -5.10940216e-02f, 4.02759574e-02f, 7.66800046e-02f,
  1.20490991e-01f, -2.31633652e-02f, 5.31514995e-02f, 8.79649371e-02f, 1.13003060e-01f, -9.01216583e-04f, -5.73472725e-03f, 5.40754236e-02f, 7.14240372e-02f, -3.75224613e-02f,
  6.78261891e-02f, -9.01079737e-03f, 2.66890228e-02f, -3.51137971e-03f, 7.92030543e-02f, -1.49445664e-02f, 1.43568991e-02f, 2.11614147e-02f, 4.46758792e-02f, 6.51927069e-02f,
  -2.56866664e-02f, 3.83876674e-02f, 1.03741344e-02f, 6.23584678e-03f, -3.64349447e-02f, -6.90713748e-02f, 1.45707717e-02f, -6.91393614e-02f, 5.18394560e-02f, -1.73088331e-02f,
  8.97188932e-02f, -3.33090350e-02f, 3.65562774e-02f, -5.54474257e-02f, 6.26269355e-03f, -7.40188584e-02f, -1.29511151e-02f, 2.23479699e-02f, 6.51070625e-02f, -3.92274596e-02f,
  1.67601630e-02f, 3.72910798e-02f, -2.93679815e-02f, -5.60761392e-02f, 4.30605263e-02f, 6.66057765e-02f, 2.53716763e-02f, 1.45885069e-02f, -3.24046537e-02f, -6.47518113e-02f,
  -2.59982254e-02f, -4.50275950e-02f, -4.93171066e-02f, 2.05585901e-02f, 3.37753147e-02f, -1.96784195e-02f, -5.17026633e-02f, 3.95482639e-03f, -8.14231634e-02f, 4.14544307e-02f,
  -2.08515842e-02f, -1.63129956e-01f, 1.93535946e-02f, 3.70502956e-02f, 8.20190553e-03f, -9.68901266e-04f, -4.18761699e-03f, -4.86553162e-02f, -6.71804547e-02f, 4.61286725e-03f,
  6.89141750e-02f, -4.30909395e-02f, 8.22951645e-02f, 2.98050046e-02f, -6.08217865e-02f, -3.83022688e-02f, -7.39196688e-02f, 2.66303513e-02f, 8.04358944e-02f, -5.41603714e-02f,
  1.65289477e-03f, 3.70156541e-02f, -8.65323469e-02f, -5.83667979e-02f, 4.63977791e-02f, 3.18770111e-02f, 6.54775500e-02f, 7.17140958e-02f, -1.43414848e-02f, -1.45307919e-02f,
  -9.01653897e-03f, -5.66518791e-02f, 9.30430368e-02f, -5.71465120e-03f, -7.44303465e-02f, 9.37839076e-02f, 2.30556186e-02f, 1.71160735e-02f, 1.81547359e-01f, -6.36233948e-03f,
  -3.64459604e-02f, 3.75254527e-02f, 1.21143870e-01f, -1.52988538e-01f, -1.21458629e-02f, 1.07412823e-01f, -9.56930816e-02f, -1.06555313e-01f, 1.97909810e-02f, 4.61957753e-02f,
  -7.12612793e-02f, -1.00171134e-01f, -2.33802591e-02f, -1.52028367e-01f, -5.38233183e-02f, -7.10612461e-02f, -1.74727321e-01f, 6.31449744e-03f, -1.39587238e-01f, -8.93858224e-02f,
  -3.90684512e-03f, 5.29114045e-02f, -3.25464979e-02f, 4.53925645e-03f, -4.12560627e-02f, 6.77424818e-02f, -2.39725839e-02f, 7.39530772e-02f, 1.52778123e-02f, -3.79346311e-02f,
  4.22340967e-02f, 2.28568702e-03f, 2.68020388e-03f, -3.11547797e-02f, -1.17947478e-02f, 7.14215636e-02f, 6.86032232e-03f, -2.43610283e-03f, 1.13775797e-01f, -6.52826950e-02f,
  5.38477162e-03f, 1.74632501e-02f, 4.00539115e-02f, 5.59626892e-02f, 4.60234843e-02f, 7.33830035e-02f, -4.68529537e-02f, 1.01534285e-01f, 6.55857101e-02f, 7.50615224e-02f,
  -6.29505664e-02f, -3.67777981e-02f, 1.30377123e-02f, -5.50508164e-02f, -6.43221512e-02f, -6.42286241e-02f, -3.27172466e-02f, -9.61944535e-02f, -1.24685392e-02f, -7.08896071e-02f,
  3.98989916e-02f, -1.19427852e-02f, -7.52364993e-02f, 5.02971672e-02f, -5.25884070e-02f, 6.80091307e-02f, 6.93657622e-02f, -8.36354308e-03f, -5.35152331e-02f, -5.14318012e-02f,
  5.79651892e-02f, 3.89178842e-02f, -4.26990576e-02f, -7.39970058e-02f, -6.92941844e-02f, -5.32738268e-02f, -2.37422958e-02f, 3.58411134e-03f, 8.91836807e-02f, 3.78824049e-03f,
  -1.03353038e-02f, -7.24338070e-02f, 8.35983604e-02f, 2.35348493e-02f, 5.02073430e-02f, -3.16165276e-02f, 4.43339720e-02f, -4.59903590e-02f, 2.78370548e-02f, 2.10810620e-02f,
  -4.69811298e-02f, 2.90338024e-02f, 8.22348446e-02f, -4.08675447e-02f, 7.39753544e-02f, -2.71336790e-02f, -3.31422240e-02f, 4.62769791e-02f, -8.13262984e-02f, -8.73118788e-02f,
  -3.35092917e-02f, -1.92665625e-02f, -1.81564260e-02f, -2.00595129e-02f, -8.65928978e-02f, -4.75709997e-02f, 4.29591611e-02f, -9.47120693e-03f, 5.00063635e-02f, 1.88695581e-03f,
  2.07589746e-01f, -8.02054927e-02f, -2.79609151e-02f, 2.36129850e-01f, -1.03233941e-01f, -9.57102515e-03f, 4.10960894e-03f, -8.06878414e-03f, -6.77242205e-02f, -1.13743670e-01f,
  1.74001809e-02f, -5.50682507e-02f, -1.20596401e-01f, 1.14641160e-01f, 2.31119558e-01f, 6.50913492e-02f, 2.14360595e-01f, 1.06858559e-01f, 2.91655585e-02f, 1.04547828e-01f,
  1.53140530e-01f, 7.07313884e-03f, 6.52263686e-02f, -3.24616842e-02f, -4.76437844e-02f, 7.77144283e-02f, 1.62822336e-01f, 7.35124748e-04f, 6.95127472e-02f, -1.95153877e-02f,
  -1.14621140e-01f, -5.48696204e-04f, -3.02212611e-02f, 4.86181267e-02f, -3.42325354e-03f, 4.29134108e-02f, -4.54826020e-02f, -2.94067580e-02f, 5.96402399e-03f, 6.66301325e-02f,
  1.78013910e-02f, 8.45729709e-02f, -1.97574515e-02f, -5.30485995e-02f, -6.22798316e-02f, -6.91395774e-02f, 3.70041765e-02f, -1.40979959e-04f, -7.25178942e-02f, 7.60543644e-02f,
  -3.69857368e-03f, -2.92400066e-02f, 8.29430893e-02f, -2.00659446e-02f, -4.55688164e-02f, 6.80355309e-03f, 8.48550573e-02f, 9.13908184e-02f, 6.30427971e-02f, 1.13612860e-01f,
  -3.00688390e-02f, -6.03829473e-02f, 4.56429422e-02f, -6.43925667e-02f, 4.07877378e-02f, 2.76071057e-02f, 5.67659438e-02f, -5.08068614e-02f, -8.18474218e-03f, -6.31566718e-02f,
  -4.94359760e-03f, 3.42268534e-02f, -6.85923472e-02f, 7.19537437e-02f, -1.62460487e-02f, -5.65656349e-02f, -5.39393798e-02f, -2.31062267e-02f, 9.19800028e-02f, 3.95510299e-03f,
  -4.44129854e-02f, -9.29096192e-02f, -4.51987348e-02f, 1.11475829e-02f, -1.01440400e-01f, 6.40524030e-02f, 7.93436468e-02f, -2.82955561e-02f, 1.67338364e-02f, 3.67195010e-02f,
  5.54202544e-03f, -7.61872204e-03f, 3.84542421e-02f, -1.08152077e-01f, 4.56092842e-02f, -6.80776238e-02f, 5.70898056e-02f, -1.38092041e-02f, 4.82329056e-02f, -5.36432639e-02f,
  -2.64000576e-02f, -6.76949024e-02f, -5.73937483e-02f, 1.89277772e-02f, 6.81651086e-02f, 5.96181378e-02f, 1.44830765e-03f, -5.43797798e-02f, 8.55061412e-02f, 4.16058861e-02f,
  8.86281487e-03f, -3.13787460e-02f, -3.50794531e-02f, -5.56192324e-02f, 1.21235764e-02f, 1.14236306e-03f, -7.85387605e-02f, 6.53806552e-02f, 9.41474885e-02f, -4.65616509e-02f,
  3.05693656e-01f, -1.09598793e-01f, 1.95337720e-02f, 1.18749440e-01f, 9.73974243e-02f, 4.71920561e-04f, 5.45903780e-02f, 1.55170128e-01f, 2.34656096e-01f, -7.10840300e-02f,
  -6.07463866e-02f, -2.65364926e-02f, -1.13237403e-01f, 1.03166625e-02f, 1.13753654e-01f, 1.70156676e-02f, -3.52415554e-02f, -1.36319146e-01f, 5.80597222e-02f, 5.72008155e-02f,
  6.06669784e-02f, -1.36580050e-01f, -4.68784869e-02f, -1.13275133e-01f, 4.18142369e-03f, -7.06111938e-02f, -7.44300708e-02f, -1.30396008e-01f, -1.48682177e-01f, -7.13162422e-02f,
  -9.13040042e-02f, 5.36162965e-02f, 2.71342858e-03f, 4.51328345e-02f, -6.83700964e-02f, 2.93286089e-02f, -3.13321650e-02f, 3.53517234e-02f, -2.48425622e-02f, -2.26724595e-02f,
  2.47812122e-02f, 3.35172587e-03f, 5.39810359e-02f, 1.64552666e-02f, 7.75193721e-02f, 5.38374409e-02f, 6.85376376e-02f, 3.22853923e-02f, 8.15832838e-02f, 7.26753101e-02f,
  2.88472828e-02f, -4.85009216e-02f, -8.15988183e-02f, -1.51533568e-02f, 6.69667206e-04f, 9.35984962e-03f, 1.31736435e-02f, -8.33831653e-02f, -2.84689888e-02f, 3.67777087e-02f,
  7.46538416e-02f, 3.04599814e-02f, 2.40853950e-02f, 2.22925209e-02f, -3.95741425e-02f, -4.22539674e-02f, -3.08667924e-02f, -6.12065010e-02f, -4.97659855e-02f, 1.56426150e-02f,
  -2.33017467e-02f, -4.10963874e-03f, 1.97382236e-04f, -4.36391048e-02f, -3.55062596e-02f, 5.82640544e-02f, 1.55573785e-02f, -2.63468903e-02f, 2.99717542e-02f, 3.23698530e-03f,
  6.81608617e-02f, -1.44019155e-02f, -9.50905606e-02f, -8.70680735e-02f, -6.16167020e-03f, -3.75762023e-02f, 3.93838771e-02f, -2.92057078e-02f, -3.29788923e-02f, -2.55339649e-02f,
  -1.30346686e-01f, -6.68494850e-02f, -7.77575523e-02f, -2.85161994e-02f, -1.04252800e-01f, 1.82990264e-02f, -3.22180465e-02f, -1.88465677e-02f, -9.96980444e-02f, 5.08613102e-02f,
  3.58044053e-03f, -5.89343794e-02f, -1.99893769e-02f, -2.27247849e-02f, -9.74813662e-03f, 3.31187472e-02f, 1.70169994e-02f, 1.08331237e-02f, -5.34407459e-02f, -6.53394386e-02f,
  -5.28945588e-02f, -4.51665819e-02f, 6.05419166e-02f, 1.11319423e-02f, -2.22697239e-02f, -8.52380693e-02f, 3.91469598e-02f, 3.40340920e-02f, -1.02048844e-01f, -8.26752782e-02f,
  1.85448110e-01f, -2.43991524e-01f, -4.01663259e-02f, 1.47108853e-01f, 8.37495849e-02f, -3.48479226e-02f, -1.29959257e-02f, -3.58314179e-02f, -9.13980901e-02f, -6.43701777e-02f,
  9.88044292e-02f, -9.25585777e-02f, -5.49254157e-02f, -6.22872710e-02f, 1.57084525e-01f, -1.21669054e-01f, 1.96704213e-02f, -7.97644258e-03f, -9.33525935e-02f, -2.82721631e-02f,
  3.23795900e-02f, 1.18620269e-01f, 6.63760900e-02f, -5.51095046e-02f, 6.99894354e-02f, 6.79513663e-02f, 2.45457008e-01f, 6.39367709e-03f, 5.53318635e-02f, -4.47975136e-02f,
  -2.00375095e-02f, -8.19354802e-02f, 3.62489447e-02f, -9.20070708e-02f, -8.35263077e-03f, -3.94252539e-02f, 6.55396208e-02f, 3.28648761e-02f, -1.15862126e-02f, -4.69387881e-02f,
  -1.24383187e-02f, -5.86849712e-02f, -4.10625190e-02f, -3.31238210e-02f, -4.12962027e-02f, -4.74487506e-02f, -7.25335851e-02f, 1.32267242e-02f, -6.77847490e-02f, -7.99447894e-02f,
  -2.92624217e-02f, 4.63838726e-02f, 6.75907508e-02f, -1.67592522e-02f, -3.01921610e-02f, 3.56357247e-02f, -1.77567583e-02f, -1.29013639e-02f, 4.33902070e-02f, -1.30737107e-02f,
  -3.07109132e-02f, 1.49191469e-02f, 4.48869728e-02f, 5.39253801e-02f, 5.95061434e-03f, -4.49413098e-02f, 4.49598394e-02f, -4.03989246e-03f, -2.63071712e-02f, 3.29614468e-02f,
  1.43569605e-02f, -4.76410054e-02f, -4.85499054e-02f, 5.80638759e-02f, -3.32326000e-03f, -1.53245255e-02f, 2.64485870e-02f, -8.50942219e-04f, 1.23567777e-02f, 1.36683211e-02f,
  -3.45102064e-02f, 8.80952701e-02f, -3.58160934e-03f, 7.06674531e-02f, -3.37909013e-02f, -3.86856566e-03f, -3.21968310e-02f, -6.27299920e-02f, -4.81224470e-02f, -8.06121342e-03f,
  -7.36196041e-02f, -8.48464966e-02f, -9.82858390e-02f, 2.40312647e-02f, 1.75780188e-02f, 4.97619808e-02f, 3.27370055e-02f, -5.33672906e-02f, -3.91330235e-02f, -6.10680945e-05f,
  6.07315302e-02f, 8.76823142e-02f, 6.60598353e-02f, 3.48988697e-02f, -2.50065774e-02f, -2.98003368e-02f, 5.73584475e-02f, -8.14422127e-03f, 1.81513596e-02f, 3.01232543e-02f,
  1.45300366e-02f, 2.00443119e-02f, 6.29118532e-02f, 4.36181156e-03f, 3.29922289e-02f, 9.33388695e-02f, 1.15730253e-03f, -6.92235902e-02f, 8.29709973e-03f, 4.37032953e-02f,
  9.21712667e-02f, 6.25305325e-02f, -1.80060156e-02f, 5.47489189e-02f, 1.36161923e-01f, -1.26025518e-02f, -7.46453032e-02f, 1.39552549e-01f, -1.09576836e-01f, 6.14525862e-02f,
  4.34975466e-03f, 5.77174686e-02f, -1.63672403e-01f, -2.28490513e-02f, -6.37605041e-02f, -1.98710889e-01f, -1.66566912e-02f, 1.56090437e-02f, -8.09508637e-02f, 1.70981020e-01f,
  1.03793189e-01f, -1.96477231e-02f, 5.42713590e-02f, 1.61460042e-01f, 1.84448555e-01f, 1.40527084e-01f, 1.00502156e-01f, -5.85840307e-02f, 1.34272322e-01f, -4.81612794e-02f,
  -1.01180777e-01f, 7.70942271e-02f, 7.73791894e-02f, -2.27483585e-02f, 4.05402966e-02f, 4.93564457e-02f, 4.55165133e-02f, -9.60100815e-02f, 6.37571812e-02f, -6.97032213e-02f,
  2.34417040e-02f, -4.57613170e-02f, -1.24209868e-02f, 8.53397511e-03f, -3.35996374e-02f, -6.07282519e-02f, -1.98229472e-03f, -4.31697927e-02f, 5.69205396e-02f, 6.40571862e-02f,
  7.13418424e-02f, 4.34395410e-02f, 2.80581210e-02f, -2.53910813e-02f, 2.53294092e-02f, 1.39816571e-02f, 3.42646129e-02f, 8.66170321e-03f, -4.55360636e-02f, 1.05166495e-01f,
  -5.34591777e-03f, 7.23378081e-03f, -3.38668982e-03f, -9.64107290e-02f, 6.21057749e-02f, -6.48722127e-02f, -7.70889148e-02f, 3.76234157e-03f, -1.30398087e-02f, 5.08002676e-02f,
  -3.41516174e-02f, -4.99974042e-02f, 4.23379168e-02f, -4.06506360e-02f, 9.66737121e-02f, -1.37692029e-02f, -3.12948390e-03f, 7.74170132e-03f, 2.10593008e-02f, 3.11940126e-02f,
  -9.02268738e-02f, 1.83778442e-02f, 8.21877122e-02f, -4.88332659e-02f, -7.85221979e-02f, 4.20557149e-02f, -6.75780028e-02f, -5.52894920e-02f, -2.63417754e-02f, -4.32868302e-02f,
  8.68907943e-02f, 2.39678659e-02f, -6.01378642e-02f, 8.20634700e-03f, -6.48115005e-04f, 4.94800098e-02f, 7.79164582e-03f, 4.42557549e-03f, 3.59321348e-02f, -4.28530723e-02f,
  7.65845329e-02f, 7.16880858e-02f, -6.53210357e-02f, 6.07335800e-03f, -2.55801361e-02f, 4.89508733e-02f, 1.70153473e-02f, 4.63268980e-02f, -2.23415885e-02f, 4.44096550e-02f,
  7.78854489e-02f, 2.36888360e-02f, 3.72163281e-02f, 2.00061146e-02f, 3.58116552e-02f, 6.64942563e-02f, -5.88854812e-02f, -1.57729294e-02f, -4.41405997e-02f, -8.11256394e-02f,
  1.37972653e-01f, -2.14822441e-01f, 2.48639077e-01f, 1.31022632e-01f, 8.95720571e-02f, -5.35473935e-02f, 6.34471700e-02f, -6.01624604e-03f, 1.15121324e-02f, -2.99407333e-01f,
  -1.60287529e-01f, 1.27543882e-01f, -4.13789116e-02f, -1.50553510e-01f, 1.94152772e-01f, -1.72864888e-02f, -1.51808023e-01f, -8.16239193e-02f, 1.13894381e-01f, -5.45929559e-02f,
  4.86851931e-02f, -1.21630780e-01f, 1.48459956e-01f, -3.62820290e-02f, -6.69184849e-02f, 7.89037123e-02f, -9.21512395e-02f, 1.50870368e-01f, -1.31900162e-01f, 7.87924528e-02f,
  -1.25520498e-01f, -7.28144171e-03f, 3.51398103e-02f, -6.76526502e-02f, -9.28573161e-02f, -4.94965501e-02f, -2.81713735e-02f, 2.95736268e-02f, 5.31237535e-02f, -1.21576022e-02f,
  2.24577226e-02f, -4.37861979e-02f, 3.36239636e-02f, 1.39440205e-02f, 2.92795617e-03f, -6.94891717e-03f, -4.44623381e-02f, 5.19892015e-03f, -2.31121555e-02f, 1.13276886e-02f,
  6.38310462e-02f, 2.34218268e-03f, 6.08327873e-02f, -3.55340354e-02f, 1.12948552e-01f, -4.26636413e-02f, 5.86426146e-02f, 3.58128957e-02f, -1.13215372e-02f, -4.54758964e-02f,
  1.49670258e-01f, 2.93733142e-02f, -1.84021778e-02f, 1.31686986e-03f, 6.70634257e-03f, 3.03282402e-02f, -7.00863153e-02f, 1.58074815e-02f, 2.17378195e-02f, -5.92577420e-02f,
  -6.45631459e-03f, 2.45143566e-02f, 5.51346801e-02f, -8.05086922e-03f, -2.50954852e-02f, 2.39723660e-02f, -3.74613218e-02f, -1.48394946e-02f, -6.15469366e-03f, 2.31297966e-02f,
  2.67141927e-02f, -4.42975424e-02f, -3.54963243e-02f, -3.75854075e-02f, 2.95071304e-02f, 7.95002207e-02f, -4.66538258e-02f, 2.04591881e-02f, 2.84381714e-02f, 6.97631538e-02f,
  -2.92351842e-01f, -1.62214980e-01f, -4.60360898e-03f, -6.84436783e-02f, -7.38130091e-03f, -1.21509535e-02f, 1.27941533e-03f, 2.62360852e-02f, -6.01752149e-03f, -1.92416478e-02f,
  -4.27573957e-02f, -2.54932418e-02f, -5.09919673e-02f, -2.84589734e-02f, 1.30764153e-02f, -2.80506853e-02f, -2.11678222e-02f, -3.87872197e-02f, -9.49185565e-02f, -9.22983289e-02f,
  -9.22456756e-02f, 4.45136195e-03f, 4.66969982e-02f, -1.49523849e-02f, 1.77687705e-02f, 6.25515878e-02f, -1.79006960e-02f, 1.06214695e-01f, -4.59025539e-02f, -6.29727123e-03f,
  3.92612934e-01f, -1.18902162e-01f, 1.35283887e-01f, -1.34462118e-01f, 7.99092054e-02f, 1.89761687e-02f, -1.12023883e-01f, -2.72053592e-02f, 1.33055955e-01f, -6.14624135e-02f,
  -1.21224195e-01f, 9.65144709e-02f, 2.83012316e-02f, -1.62893862e-01f, -7.38805532e-02f, -1.57828480e-01f, -1.06484652e-01f, 5.91707863e-02f, 4.94959317e-02f, 6.07782975e-02f,
  -2.18996610e-02f, -1.46560863e-01f, -1.47997588e-01f, -9.42441002e-02f, 7.04193190e-02f, 1.36542292e-02f, -6.66064098e-02f, 3.10510993e-02f, -8.20472687e-02f, -1.37132257e-01f,
  7.34164938e-02f, 1.92997381e-01f, 1.05366074e-01f, 1.57282293e-01f, 5.24880700e-02f, 8.93517882e-02f, 9.28167179e-02f, -4.51656953e-02f, -1.52185392e-02f, 5.37991524e-02f,
  -1.78019181e-02f, -9.05877072e-03f, 2.58894898e-02f, -2.82944683e-02f, 5.72903715e-02f, 4.70337905e-02f, 4.15884256e-02f, -3.82694043e-02f, 5.24577163e-02f, 4.27778140e-02f,
  1.18965302e-02f, -4.22283299e-02f, 3.43049429e-02f, -3.40867415e-02f, 3.93169820e-02f, -1.89832561e-02f, 1.46480380e-02f, 6.71068206e-02f, -4.59705517e-02f, 3.71777974e-02f,
  -2.55938303e-02f, -6.19454589e-03f, 4.33235876e-02f, 4.69194241e-02f, -5.60955629e-02f, -1.55251430e-04f, -5.03074080e-02f, -2.66416408e-02f, -2.32348256e-02f, 7.72893475e-03f,
  6.49609463e-03f, -2.63593048e-02f, 8.57098587e-03f, 7.61983451e-03f, -3.68490927e-02f, 3.79114598e-02f, 9.33414549e-02f, 3.08405254e-02f, 4.10192646e-02f, -5.59617281e-02f,
  -1.03308083e-02f, -4.84856032e-02f, -8.14116970e-02f, 2.47235503e-02f, 5.21182828e-03f, -1.25594418e-02f, -4.65850718e-02f, 7.36107677e-03f, -3.24755125e-02f, 5.01993718e-03f,
  6.71968162e-02f, 2.84928512e-02f, 3.72291133e-02f, -8.44653696e-03f, -7.65663981e-02f, -3.14555131e-02f, -4.65418026e-02f, 1.84156783e-02f, -3.16300616e-02f, -3.35183274e-03f,
  5.24198301e-02f, 8.76159221e-02f, -2.56746281e-02f, -5.18889837e-02f, -1.62743479e-02f, 1.69171896e-02f, -1.75817963e-02f, 2.44891010e-02f, 3.51581238e-02f, -7.50302477e-03f,
  -7.40367174e-02f, -2.52159517e-02f, -5.05752489e-02f, -2.48178523e-02f, -5.59161603e-02f, -3.93669382e-02f, 4.42057624e-02f, -3.38414684e-02f, 6.38674945e-02f, -5.29939309e-02f,
  1.71611637e-01f, -1.80637892e-02f, -1.06990449e-02f, 2.76453257e-01f, -1.09123670e-01f, 1.79622136e-02f, 3.24963331e-02f, 5.74246123e-02f, 5.85785024e-02f, 9.52303689e-03f,
  8.64306316e-02f, 7.62940794e-02f, -1.18222788e-01f, 1.67734101e-01f, -3.57850129e-03f, -1.13090806e-01f, 1.78120866e-01f, -1.28439218e-02f, -4.86796796e-02f, 1.27526194e-01f,
  9.30383205e-02f, -2.02230061e-03f, -2.18747323e-03f, -7.08921626e-02f, 1.56815848e-04f, 8.97804573e-02f, -5.66734374e-02f, -2.74046995e-02f, 1.67465478e-01f, -1.11202642e-01f,
  7.31461048e-02f, 3.83384414e-02f, 4.70096394e-02f, 8.87372810e-03f, 1.82455778e-02f, 1.89029314e-02f, -4.84420024e-02f, 4.85751331e-02f, -4.70020957e-02f, -1.39586069e-02f,
  3.74584794e-02f, 7.22583104e-03f, 1.05433509e-01f, -1.65071543e-02f, 8.05842504e-02f, 5.45298792e-02f, 5.81374653e-02f, 8.33194703e-02f, 5.00997454e-02f, -1.25412559e-02f,
  5.59556261e-02f, -7.53489435e-02f, 5.50135337e-02f, 3.33800763e-02f, 6.84485584e-02f, 6.26490489e-02f, 2.51674782e-02f, -1.85901467e-02f, 4.25156951e-02f, 2.89699677e-02f,
  1.94110945e-02f, -2.72491816e-02f, -2.96168514e-02f, -3.28354351e-02f, -2.79712882e-02f, 2.39860527e-02f, 5.13920002e-02f, -2.05652113e-03f, -2.97599435e-02f, 4.29698564e-02f,
  -5.32800294e-02f, -2.14213505e-02f, 1.08453400e-01f, -3.63949947e-02f, 4.72967466e-03f, -6.02880046e-02f, -3.50707732e-02f, -4.51734178e-02f, -2.87318975e-02f, 2.49013733e-02f,
  -2.29875203e-02f, -6.52272403e-02f, -1.22113442e-02f, 5.14318515e-03f, 2.49990020e-02f, -9.33376849e-02f, -2.94336677e-02f, 2.75249453e-03f, 7.82014206e-02f, 3.11157852e-02f,
  -5.83896674e-02f, 4.62501198e-02f, -6.05820753e-02f, -2.39190105e-02f, -9.33020189e-02f, -7.17838109e-02f, -1.80663094e-02f, -1.99006889e-02f, 1.20706530e-02f, 2.58561317e-02f,
  -3.56989056e-02f, 9.81998891e-02f, -1.08340313e-03f, -4.65796292e-02f, 3.40252444e-02f, 4.03753184e-02f, 1.57387480e-02f, 1.88725386e-02f, 9.90696326e-02f, 5.50897904e-02f,
  -5.76001182e-02f, 4.05153111e-02f, -7.74617791e-02f, 6.19400330e-02f, -5.36147058e-02f, -9.55780968e-02f, 8.92264619e-02f, -8.48811045e-02f, 1.34194996e-02f, 4.25073877e-02f,
  -3.99031430e-01f, 9.18638185e-02f, -1.93706378e-02f, 5.00522852e-02f, 7.24727660e-02f, 2.32618153e-01f, 5.02958000e-02f, 1.26134574e-01f, 4.39215414e-02f, 1.74620166e-01f,
  4.02705111e-02f, -1.55614361e-01f, 2.12823879e-02f, 1.83994934e-01f, -1.23409793e-01f, 2.76402012e-02f, 1.84590682e-01f, -5.77864412e-04f, 1.35075236e-02f, 9.54058841e-02f,
  -1.23227231e-01f, 1.59219205e-01f, -3.91580276e-02f, 1.92208230e-01f, 5.71569726e-02f, -4.57229428e-02f, -1.43747833e-02f, -7.11462498e-02f, 3.64233106e-02f, -1.91272777e-02f,
  3.55262458e-02f, -1.56556237e-02f, -3.69534716e-02f, 2.89846361e-02f, 7.04483315e-02f, 1.00536253e-02f, 1.00396741e-02f, -2.13909652e-02f, -6.04170300e-02f, 1.11984489e-02f,
  -5.54460846e-02f, -6.11178577e-02f, -3.33242794e-03f, -6.27525225e-02f, -6.88298373e-03f, -6.39204010e-02f, -4.27547880e-02f, 4.36363891e-02f, 6.45136386e-02f, 1.33798411e-03f,
  1.16595149e-03f, 5.50632700e-02f, 3.28424067e-04f, 1.07452618e-02f, -6.01890832e-02f, 2.67176423e-02f, 8.62018913e-02f, -6.45405427e-02f, 4.80673499e-02f, -2.04136856e-02f,
  -3.43215615e-02f, -2.59750783e-02f, -1.03722070e-03f, -5.40069342e-02f, -6.78076223e-02f, 3.36710811e-02f, -4.49055014e-03f, -3.05308364e-02f, -8.50742534e-02f, 4.93655987e-02f,
  2.09069848e-02f, 7.55416974e-03f, 5.12989722e-02f, 4.39168699e-02f, -4.22580466e-02f, 5.66760376e-02f, 1.26208812e-02f, 1.69818383e-02f, -1.34762842e-03f, 1.38529076e-03f,
  -1.37951234e-02f, -3.39041208e-03f, -7.93059841e-02f, -5.96994795e-02f, -2.41383612e-02f, -1.27335535e-02f, 8.57534036e-02f, -6.05445169e-02f, 2.03120559e-02f, -1.74101815e-02f,
  1.53346822e-01f, 1.23712651e-01f, 4.04173043e-03f, 2.23330278e-02f, -2.00441182e-02f, 2.06441656e-02f, 4.57027107e-02f, -5.92022436e-04f, -2.78219115e-02f, 4.69052680e-02f,
  -1.60825066e-02f, 4.91271392e-02f, -1.52890272e-02f, -8.27697106e-03f, 3.41200158e-02f, 3.96778099e-02f, -5.29850237e-02f, -1.29485608e-03f, -1.55319544e-02f, -4.46546525e-02f,
  3.00744586e-02f, -1.63898170e-02f, -3.73837091e-02f, -3.65566574e-02f, 6.16004691e-03f, 3.74378189e-02f, -1.35139795e-02f, 5.02811838e-03f, 2.05307007e-02f, -1.60307474e-02f,
  3.07716671e-02f, -2.03654487e-02f, 6.34307414e-02f, -9.92385596e-02f, -8.80629942e-02f, -2.45886177e-01f, -5.60355932e-03f, -1.06335118e-01f, -1.82976678e-01f, 4.84513342e-02f,
  1.17597066e-01f, -5.01757711e-02f, 1.53824508e-01f, 7.47788465e-03f, -2.30707332e-01f, -1.39883116e-01f, -1.52342305e-01f, -7.23710582e-02f, -1.07108079e-01f, 6.90949336e-02f,
  -6.20068274e-02f, -3.06202453e-02f, 5.26495911e-02f, 5.53212240e-02f, 6.77735060e-02f, 1.45658359e-01f, 3.47566605e-02f, 4.46884781e-02f, 7.61414506e-03f, -5.85129000e-02f,
  -6.23609684e-02f, 1.30569384e-01f, 1.15017079e-01f, 6.59107342e-02f, 1.34978384e-01f, 1.66485310e-02f, -3.23833851e-03f, 3.39465700e-02f, -5.29529676e-02f, -4.53041084e-02f,
  9.28850248e-02f, -2.00119079e-03f, -4.31669317e-02f, 3.29329967e-02f, -9.55548659e-02f, 2.41529532e-02f, 4.73933816e-02f, 7.68298507e-02f, -4.91171665e-02f, -3.00166253e-02f,
  4.35835719e-02f, 4.05157395e-02f, -4.04977798e-02f, -5.53574674e-02f, 3.17230038e-02f, 2.39129812e-02f, -1.42699387e-02f, 4.72727939e-02f, -8.30153599e-02f, -1.00606181e-01f,
  -4.62886542e-02f, -7.99693391e-02f, 9.41983704e-03f, -1.76290050e-02f, 6.50049448e-02f, 3.28479707e-02f, -4.73209880e-02f, 1.90865453e-02f, 3.28570306e-02f, 6.61768466e-02f,
  2.97467094e-02f, 8.05095360e-02f, -3.80407870e-02f, 8.48358683e-03f, -4.94772382e-02f, -5.55812556e-04f, 3.74507532e-02f, -3.44416648e-02f, -4.56069447e-02f, 4.09114361e-02f,
  3.26654650e-02f, -1.00137576e-01f, -2.74474965e-03f, 3.33301388e-02f, -2.78086495e-02f, -4.26455215e-02f, 4.94093187e-02f, -3.80108394e-02f, 4.11272123e-02f, -9.86459665e-03f,
  -1.16936684e-01f, 1.85377691e-02f, 8.63015577e-02f, -5.82806282e-02f, -4.37438041e-02f, 8.62548351e-02f, -4.34098504e-02f, -9.98900905e-02f, 6.14793098e-04f, 5.78611903e-02f,
  2.51760893e-02f, 1.76887438e-02f, -1.04471128e-02f, -4.66547012e-02f, -2.88570467e-02f, -5.07787289e-03f, 3.47762369e-02f, -7.30873868e-02f, -2.99311330e-04f, 6.08302131e-02f,
  -2.07169671e-02f, 3.17145512e-02f, -7.74916485e-02f, -1.08836163e-02f, -7.79039487e-02f, -2.64565516e-02f, 1.59522630e-02f, -3.28237303e-02f, 4.64904830e-02f, -2.62571163e-02f,
  1.11372426e-01f, -5.43170273e-02f, 2.27308825e-01f, 8.85243341e-03f, 2.93095354e-02f, 7.10441247e-02f, 8.94843712e-02f, -2.43936777e-02f, 1.11833528e-01f, -1.85102880e-01f,
  3.35281566e-02f, -2.39599240e-03f, 8.07280093e-02f, 1.41981035e-01f, 7.82620236e-02f, 8.39999616e-02f, -6.53263703e-02f, 9.17800330e-03f, -1.85736064e-02f, -1.23284817e-01f,
  5.87125868e-03f, -4.79394831e-02f, 1.31837219e-01f, -1.56474113e-01f, 2.67439280e-02f, -7.62517229e-02f, -4.06289697e-02f, 5.30738756e-02f, -6.50379732e-02f, -7.29245543e-02f,
  2.45084111e-02f, -1.81512274e-02f, -2.44101863e-02f, 5.92035577e-02f, -6.55558258e-02f, -8.71794522e-02f, -6.23852722e-02f, 3.04044914e-02f, -5.65870963e-02f, 2.05482561e-02f,
  1.98512189e-02f, -2.67547108e-02f, -2.11101137e-02f, 7.97131881e-02f, -1.11077586e-02f, 8.99370462e-02f, 1.17551729e-01f, 2.75109857e-02f, 3.67319211e-02f, 1.43955737e-01f,
  1.34046718e-01f, 7.94515654e-04f, 6.23343401e-02f, 5.97996786e-02f, -3.72095443e-02f, 4.99521308e-02f, 5.40916733e-02f, 7.32868090e-02f, 5.78027070e-02f, 6.85526580e-02f,
  -3.89678590e-02f, -1.16585799e-01f, -4.11829054e-02f, 1.31752249e-02f, 1.72307361e-02f, 2.68636700e-02f, 4.47920710e-02f, 1.65411327e-02f, -1.06962491e-02f, -3.21232639e-02f,
  2.70105209e-02f, 2.88212136e-03f, -1.30417235e-02f, -9.15442966e-03f, 1.29322084e-02f, 8.45425297e-03f, 7.95373470e-02f, -5.42740077e-02f, 4.23043557e-02f, 5.29001653e-02f,
  5.14003858e-02f, 2.78560929e-02f, 5.89087866e-02f, 1.82101615e-02f, 3.16304490e-02f, 2.97839474e-02f, 2.83088610e-02f, -3.10848784e-02f, -3.38147581e-02f, -6.57720938e-02f,
  -1.48997590e-01f, -1.10122457e-01f, 1.74509380e-02f, 5.89840859e-02f, -7.99454227e-02f, 2.68149506e-02f, -4.93567549e-02f, -1.59768127e-02f, -1.95177980e-02f, -9.84260906e-03f,
  2.38105822e-02f, -5.14939502e-02f, -1.09921344e-01f, -1.47965522e-02f, -7.11881220e-02f, 4.34149839e-02f, 7.69321248e-03f, -1.09361261e-01f, -2.11122469e-03f, -4.89966087e-02f,
  1.63895846e-03f, -1.05223972e-02f, -2.26267092e-02f, -4.15089354e-02f, -7.15444097e-03f, -1.43231936e-02f, -5.80995828e-02f, -2.45271418e-02f, 2.32230574e-02f, 4.31139655e-02f,
  1.96544558e-01f, 2.37662897e-01f, 4.98411134e-02f, -1.16458014e-02f, -2.10355401e-01f, -3.33278254e-03f, 7.93028995e-02f, -7.54603222e-02f, 3.38388719e-02f, 4.88325581e-02f,
  -5.40193869e-03f, 1.51535586e-01f, 1.47063509e-01f, -6.84753060e-03f, 8.43642727e-02f, 1.33243486e-01f, 5.25744148e-02f, 1.01718269e-01f, -1.85888801e-02f, -2.78068595e-02f,
  6.14727437e-02f, -8.97309557e-02f, -1.99158452e-02f, -7.05424920e-02f, -1.07706867e-01f, -5.63023910e-02f, 7.00228959e-02f, -4.75740880e-02f, -1.09766439e-01f, -7.62751978e-03f,
  8.13508704e-02f, 9.96607170e-02f, 3.99192832e-02f, -1.28457583e-02f, -2.46793106e-02f, -7.55378529e-02f, 5.37219383e-02f, 5.16464598e-02f, -5.86730763e-02f, -3.72918695e-02f,
  9.68481153e-02f, -2.82509029e-02f, 1.34375626e-02f, 3.89792286e-02f, 1.14747304e-02f, -4.94446792e-02f, -1.57461613e-02f, -6.02440126e-02f, 3.38202938e-02f, -8.97317603e-02f,
  -5.19689433e-02f, 8.24403577e-03f, -3.86666171e-02f, 1.76423918e-02f, 2.79142633e-02f, 1.02250427e-02f, 5.67012616e-02f, -3.79120894e-02f, 2.98971646e-02f, -1.04168365e-02f,
  -6.47492632e-02f, 7.88927972e-02f, -3.60206589e-02f, 1.41388094e-02f, -2.13467758e-02f, -7.70238712e-02f, 2.62047946e-02f, -4.95852418e-02f, 3.75422835e-02f, 1.82093624e-02f,
  -1.88834723e-02f, -1.28240213e-02f, 2.32411898e-03f, -4.00246084e-02f, 1.08453901e-02f, 3.70175056e-02f, 1.26551753e-02f, -3.62142175e-03f, 2.51779407e-02f, -1.08296098e-02f,
  -1.90639184e-04f, -4.03430313e-03f, -6.01783581e-02f, 3.72712351e-02f, 3.15790214e-02f, -3.55948647e-03f, 9.84887499e-03f, 7.20834360e-03f, -6.78099394e-02f, 1.56064667e-02f,
  2.57879823e-01f, 2.78279275e-01f, 3.06660291e-02f, 1.20826280e-02f, -2.48474982e-02f, -1.17432764e-02f, 2.73628123e-02f, -4.02178615e-02f, 7.66540095e-02f, 4.95459065e-02f,
  -8.51401314e-02f, 2.44222991e-02f, 1.38636921e-02f, 2.04152763e-02f, 2.01389333e-03f, -4.80540879e-02f, 2.45537963e-02f, 7.94524103e-02f, 8.86230022e-02f, -1.18169468e-02f,
  4.98195477e-02f, 4.78117131e-02f, 3.18448409e-03f, -2.66647246e-02f, -5.98250069e-02f, -3.24534699e-02f, 4.62668948e-02f, -3.50842997e-02f, -3.58585492e-02f, -3.96468788e-02f,
  1.35998309e-01f, -4.40361798e-02f, 1.56444356e-01f, 1.64959475e-01f, 5.43946996e-02f, 1.77913547e-01f, 2.42118523e-01f, -2.42184903e-02f, 1.55772403e-01f, 1.11024743e-02f,
  5.04999012e-02f, -4.57034037e-02f, 4.36595492e-02f, 9.11759362e-02f, -1.97485159e-03f, -6.01190440e-02f, -1.70751344e-02f, 9.64269936e-02f, -2.34238934e-02f, 7.62166232e-02f,
  2.27686241e-02f, -7.48210922e-02f, 4.15448993e-02f, -1.03400037e-01f, 6.81686178e-02f, 1.14999823e-02f, -1.55472398e-01f, 8.95510688e-02f, 1.35964388e-02f, -4.46953205e-03f,
  9.56133753e-02f, -5.34299016e-02f, 3.22868153e-02f, -3.02413031e-02f, -5.33298403e-02f, 4.36146669e-02f, 4.66334708e-02f, -3.98727208e-02f, 6.23654276e-02f, -7.58927763e-02f,
  8.90051499e-02f, -1.43251596e-02f, -3.72967497e-02f, -9.17739198e-02f, 6.84361905e-02f, 8.10054392e-02f, -6.35223612e-02f, 8.79672840e-02f, -6.84566572e-02f, 3.00280866e-03f,
  2.13739481e-02f, 4.87221107e-02f, 4.09338251e-02f, -4.30907607e-02f, 2.73427386e-02f, 2.30413824e-02f, 7.34646618e-03f, -4.75291125e-02f, -2.17661634e-02f, 4.86122891e-02f,
  1.16486736e-02f, -1.84697043e-02f, -5.34360372e-02f, -3.18963602e-02f, -5.59948459e-02f, 4.81857769e-02f, -2.96188742e-02f, 6.63165152e-02f, -6.66763540e-03f, 6.18503103e-03f,
  -2.92944945e-02f, 6.73024505e-02f, -4.87295836e-02f, -1.08125089e-02f, 1.00454286e-01f, -8.77580047e-02f, 3.33517008e-02f, -5.33417165e-02f, 9.51603502e-02f, 6.49088845e-02f,
  -4.75719869e-02f, 3.84590290e-02f, -8.93650204e-02f, 6.83884248e-02f, 5.50398864e-02f, -6.67760596e-02f, -3.68045270e-02f, -5.06840721e-02f, -6.12730794e-02f, 4.40592505e-02f,
  5.41986413e-02f, -8.00157338e-02f, 4.69507352e-02f, -6.54891953e-02f, 3.55738960e-02f, -1.76550646e-03f, -5.81753589e-02f, -2.63368525e-02f, -3.80742736e-03f, 4.56323847e-02f,
  2.90754307e-02f, -3.33073474e-02f, 3.63552235e-02f, 4.50143665e-02f, -5.91164604e-02f, 1.47427125e-02f, 1.07097132e-02f, -9.25740525e-02f, -4.74636583e-03f, 1.41502898e-02f,
  9.11488235e-02f, 1.94467362e-02f, 6.61892816e-02f, 7.67009258e-02f, 6.57512620e-02f, 7.61107281e-02f, 6.94148540e-02f, -6.85219420e-03f, 3.77435163e-02f, 1.28317019e-02f,
  7.44336247e-02f, -3.45725045e-02f, 3.34567651e-02f, 9.72651616e-02f, -1.10968240e-02f, 5.10776378e-02f, 1.14822008e-01f, -3.17148007e-02f, 1.88701808e-01f, -1.46016568e-01f,
  5.59079349e-02f, -2.92832647e-02f, 1.09632798e-02f, 2.60952450e-02f, 2.11171091e-01f, 1.78062439e-01f, 7.33254775e-02f, -6.29796833e-02f, 8.76645967e-02f, -2.69943345e-02f,
  5.43735065e-02f, -7.60275051e-02f, 1.51320726e-01f, -1.57541394e-01f, -1.09854853e-02f, -1.15296863e-01f, -1.34418577e-01f, -2.57082507e-02f, -1.58890560e-01f, 3.46390493e-02f,
  -3.81816109e-03f, 2.80361716e-02f, -2.02265847e-02f, -7.44007342e-03f, 6.64700866e-02f, -4.00529541e-02f, 1.88972068e-03f, 8.97028148e-02f, -4.81912419e-02f, 2.55107135e-02f,
  -3.00071295e-02f, -8.22841749e-03f, 5.42456545e-02f, 5.14388084e-02f, -6.85442612e-02f, -3.68160196e-02f, 2.70506181e-02f, 7.69373626e-02f, -1.75881311e-02f, -3.86949182e-02f,
  7.46907592e-02f, 6.89287782e-02f, -2.02303492e-02f, 7.08064064e-03f, -2.39658114e-02f, -5.65771125e-02f, -5.16504794e-02f, -5.17189912e-02f, -4.94712070e-02f, -7.19786212e-02f,
  2.79920399e-02f, 5.40189706e-02f, 3.22656669e-02f, 1.31072355e-02f, 3.63766439e-02f, 2.84566870e-03f, 3.53574683e-03f, -1.23146214e-02f, -3.71631868e-02f, 3.09637804e-02f,
  7.57124228e-03f, 6.38776198e-02f, 7.63031915e-02f, 4.50931564e-02f, -6.58534318e-02f, 1.82936639e-02f, -7.15489611e-02f, -4.14104797e-02f, -2.24713869e-02f, 7.38266781e-02f,
  1.71227753e-02f, 6.65970445e-02f, -7.84935150e-03f, -6.09472245e-02f, 6.74989447e-02f, -6.33090269e-03f, -6.62554279e-02f, -1.00767910e-02f, -2.64012348e-03f, 2.25282405e-02f,
  2.86397245e-02f, -1.41453087e-01f, 7.35342130e-03f, -2.69945301e-02f, -8.26785043e-02f, 1.61500685e-02f, 7.66888335e-02f, -5.43673448e-02f, -2.72542536e-02f, -6.49033785e-02f,
  -9.69536379e-02f, -4.69645225e-02f, -1.07588388e-01f, 4.30941805e-02f, 1.24929380e-02f, -4.88204919e-02f, 2.80359872e-02f, -4.46320027e-02f, -3.33133824e-02f, -5.15190773e-02f,
  -1.99207515e-02f, -6.10325448e-02f, -6.00236244e-02f, -3.05808466e-02f, -7.47874305e-02f, 4.29947600e-02f, -7.94900432e-02f, -5.63932732e-02f, -1.35733252e-02f, -1.14392228e-02f,
  1.49417475e-01f, -1.08664175e-02f, 3.04714032e-02f, 6.24109171e-02f, -1.01925954e-01f, 1.61352847e-02f, -9.37057510e-02f, -3.39192785e-02f, -2.02052277e-02f, -5.08060567e-02f,
  -9.61638689e-02f, 1.00617945e-01f, 8.18229467e-02f, 3.32243927e-03f, 9.70534235e-02f, -3.52160297e-02f, 7.52502754e-02f, 1.02062626e-02f, 1.93005037e-02f, -2.74658464e-02f,
  9.07429531e-02f, -1.20169543e-01f, -7.27175102e-02f, 5.80272684e-03f, -1.13343564e-03f, -3.54635715e-02f, -7.65441032e-03f, 8.31600279e-02f, -1.32772550e-01f, -1.02055691e-01f,
  6.82133362e-02f, 1.04329571e-01f, 5.23221642e-02f, -3.04749403e-02f, 4.16357256e-02f, 4.89548445e-02f, -2.74118092e-02f, 3.90092470e-02f, -3.64039280e-02f, 9.03260782e-02f,
  7.53969029e-02f, -8.15883651e-02f, 5.89131452e-02f, -1.27235232e-02f, -8.76522362e-02f, 2.48743594e-03f, -1.07721932e-01f, -2.27623358e-02f, -1.02566741e-01f, 8.25392529e-02f,
  -6.96848929e-02f, -4.81236055e-02f, -8.30113962e-02f, -5.22323661e-02f, 2.17813663e-02f, -3.64028886e-02f, -4.02120873e-02f, -3.36595736e-02f, -1.07337972e-02f, -2.94142440e-02f,
  -3.00320610e-02f, -2.15785559e-02f, 2.05929168e-02f, -1.69858485e-02f, -4.85439319e-03f, 1.13506624e-02f, -1.71303414e-02f, 4.96644489e-02f, 5.80897108e-02f, -1.70218796e-02f,
  -1.73918402e-03f, -5.24615943e-02f, 6.57229125e-02f, 2.29127537e-02f, 5.07052764e-02f, -1.27284387e-02f, 7.33417273e-02f, -1.26811340e-02f, 2.78914198e-02f, 5.67824095e-02f,
  1.26360254e-02f, -2.14327704e-02f, 5.02788574e-02f, -8.57588723e-02f, -4.28259671e-02f, -8.69764239e-02f, -3.99814509e-02f, 6.72219694e-02f, -1.22805126e-02f, 7.51212388e-02f,
  5.91087081e-02f, 8.42939988e-02f, -2.67387908e-02f, -9.40374210e-02f, 6.75956607e-02f, 3.41534577e-02f, 1.20200682e-03f, 5.27958274e-02f, 6.82794675e-02f, -1.44975791e-02f,
  -6.22176789e-02f, 4.23540398e-02f, 6.85904250e-02f, -6.72951564e-02f, 3.92665714e-02f, -7.66820535e-02f, 1.07049253e-02f, -3.44198868e-02f, -7.91109949e-02f, -2.72181462e-02f,
  1.67316906e-02f, -6.99723512e-02f, 3.14653642e-03f, -3.96033563e-02f, -7.89039880e-02f, 6.58219727e-03f, -7.07554668e-02f, 4.52884175e-02f, -9.22998264e-02f, -5.49986921e-02f,
  -4.02821898e-02f, 5.06563149e-02f, 3.99890244e-02f, 2.45844200e-02f, 1.29220039e-01f, 3.37329090e-01f, 2.93481797e-01f, -1.87297091e-02f, -3.92378159e-02f, 1.75689738e-02f,
  -8.40736181e-02f, 1.32235527e-01f, -1.13007938e-02f, 1.90267429e-01f, 2.17311203e-01f, 1.06266536e-01f, 1.54771104e-01f, 1.17149033e-01f, 7.45640770e-02f, -1.71966590e-02f,
  5.41590564e-02f, -1.58800427e-02f, 6.89564198e-02f, -6.60078675e-02f, 8.77534747e-02f, -1.75612047e-01f, -6.39412627e-02f, -4.52428270e-04f, 1.05449729e-01f, 7.70964250e-02f,
  -3.99320908e-02f, -1.52539760e-01f, 2.48382073e-02f, 3.46009620e-02f, -8.88321623e-02f, -4.89015738e-03f, -1.86992902e-02f, 6.83227554e-02f, 4.15445790e-02f, 6.68603182e-02f,
  3.18860076e-02f, -2.84166560e-02f, 6.15751781e-02f, 2.92293206e-02f, -6.59169350e-03f, -6.54072911e-02f, 3.88312861e-02f, 5.26155122e-02f, 7.80596659e-02f, 7.19802752e-02f,
  -2.03033909e-03f, 2.17516366e-02f, 2.13084519e-02f, 4.11150381e-02f, 7.65958847e-03f, -4.79317717e-02f, -2.73178313e-02f, -2.50317510e-02f, -3.41615751e-02f, 9.85202119e-02f,
  6.36646152e-02f, -3.30130979e-02f, -6.81238994e-02f, 5.96841574e-02f, -3.80086079e-02f, 1.82752833e-02f, 3.84422727e-02f, 1.48167331e-02f, -7.26774260e-02f, 2.62926947e-02f,
  4.21124958e-02f, -7.92287849e-03f, -5.02961613e-02f, 2.06179414e-02f, -6.58742338e-02f, -7.73820356e-02f, -1.13350209e-02f, 3.48759927e-02f, -1.72199169e-03f, -2.41466742e-02f,
  5.49683021e-03f, -1.13575822e-02f, -4.97191884e-02f, 2.18271464e-02f, -3.24909016e-02f, 3.68374139e-02f, 4.35282215e-02f, -4.87405546e-02f, -2.82863621e-02f, 5.86606562e-02f,
  -8.29351246e-02f, -1.90324903e-01f, -9.75562085e-04f, 3.62866074e-02f, 2.94546336e-02f, 1.08124549e-02f, -4.08243723e-02f, -2.74868100e-03f, 8.21575429e-03f, -1.15147661e-02f,
  -7.71413147e-02f, 2.55855676e-02f, 3.28056104e-02f, 8.08928628e-03f, 4.87643220e-02f, 5.02989329e-02f, -7.43150041e-02f, 1.49805062e-02f, -4.27166931e-02f, 1.81487179e-03f,
  -3.26982848e-02f, 1.85053758e-02f, 6.81875125e-02f, -2.21986752e-02f, 3.70752215e-02f, -2.95974198e-03f, 3.67085971e-02f, 5.22382408e-02f, 4.63329814e-02f, -8.82324576e-03f,
  8.23213682e-02f, 2.54398286e-01f, 6.63163662e-02f, 8.73424709e-02f, 3.80913503e-02f, -2.41754904e-01f, -2.42323563e-01f, 1.23855032e-01f, 2.35665888e-01f, 4.98714335e-02f,
  -1.44388065e-01f, 1.62312120e-01f, -8.86728466e-02f, -1.28783152e-01f, -2.80035645e-01f, -2.61417888e-02f, -2.13197678e-01f, -1.55218333e-01f, 1.00586317e-01f, -8.14548321e-03f,
  -4.57174703e-03f, -9.77547318e-02f, -1.80724859e-01f, -1.52423931e-02f, -2.31234338e-02f, 1.14831947e-01f, -2.79344860e-02f, 2.34005414e-02f, -8.02528039e-02f, -4.52638716e-02f,
  1.41208433e-02f, 6.55480400e-02f, 8.21347460e-02f, 2.61402000e-02f, -7.74855986e-02f, -4.35422175e-02f, -9.23901722e-02f, -8.79000276e-02f, -2.22670548e-02f, 4.67567742e-02f,
  -2.69070398e-02f, -3.83594148e-02f, 1.82927419e-02f, -3.25910561e-02f, 4.73093688e-02f, 1.01115592e-01f, 2.57169213e-02f, -6.02872996e-03f, 5.05898008e-03f, -4.48456546e-03f,
  6.28182516e-02f, -5.00360392e-02f, -3.58392410e-02f, -2.56392043e-02f, 4.20422740e-02f, 4.49427404e-02f, 7.74957612e-03f, 2.68004020e-03f, -5.70029728e-02f, 9.50935576e-03f,
  -3.37350480e-02f, 1.38018625e-02f, -3.03323586e-02f, -5.08112051e-02f, -1.48411214e-04f, 1.81287602e-02f, -5.61588146e-02f, 8.89395364e-03f, 3.58118899e-02f, -1.46142226e-02f,
  -5.06986827e-02f, 3.19468267e-02f, -5.90843568e-03f, 6.36276044e-03f, -7.47580919e-03f, 4.49574180e-02f, -4.29000966e-02f, 3.68083804e-03f, 5.03167845e-02f, 2.38327421e-02f,
  -3.45372707e-02f, -1.02634532e-02f, 6.22313656e-02f, -5.59136420e-02f, -3.60462330e-02f, -5.73803484e-03f, 6.15742989e-02f, 1.10341609e-02f, 2.17809100e-02f, -4.51700352e-02f,
  -6.85698092e-02f, 8.86110291e-02f, -1.53322676e-02f, 1.00673074e-02f, -1.45377032e-03f, 3.04941777e-02f, -2.68757902e-02f, 4.50671725e-02f, 1.46655431e-02f, -2.27203406e-02f,
  -7.47546554e-02f, 3.80085153e-03f, -8.52570683e-03f, 3.07519734e-02f, -2.90191155e-02f, -7.56001025e-02f, -6.11805245e-02f, -5.04311025e-02f, -7.96563029e-02f, 4.22045449e-03f,
  -3.28120925e-02f, 2.48544849e-02f, 3.76493111e-02f, 2.89956685e-02f, -2.69877110e-02f, -5.96083105e-02f, 8.29320028e-03f, 4.33037931e-04f, 3.59797403e-02f, 5.89453056e-02f,
  -7.94461519e-02f, 3.01922429e-02f, 6.79386407e-02f, -9.62795615e-02f, 7.63634816e-02f, 7.25307092e-02f, -9.12624821e-02f, 1.41231403e-01f, 1.42809436e-01f, 2.47802362e-02f,
  -1.10189810e-01f, -1.59173191e-01f, -3.90826873e-02f, -1.62585095e-01f, -2.23828852e-01f, 8.09377879e-02f, -1.26685694e-01f, -1.08636227e-02f, 8.34443048e-02f, -1.27693251e-01f,
  -2.78926156e-02f, -1.22354887e-01f, 3.24058011e-02f, 2.29371265e-02f, -7.60577768e-02f, -1.00656310e-02f, -2.42360756e-01f, 1.11872718e-01f, -3.90965454e-02f, -5.62148467e-02f,
  -6.54621571e-02f, 1.00462725e-02f, 1.54688265e-02f, -7.12838676e-03f, -2.13130489e-02f, 6.03767857e-02f, -9.20605138e-02f, -5.77646941e-02f, 6.19339123e-02f, 4.92423736e-02f,
  6.29768614e-03f, 3.76069732e-02f, -7.52906054e-02f, 6.52540624e-02f, 1.80382133e-02f, 3.16208089e-03f, 6.87479079e-02f, 5.87877780e-02f, 6.05265647e-02f, -3.74706625e-03f,
  6.87691867e-02f, 7.74195120e-02f, 3.39697227e-02f, -3.47994603e-02f, -4.80737053e-02f, 7.68468529e-02f, -1.74840074e-02f, -5.14460020e-02f, 7.31177442e-03f, 6.80774376e-02f,
  2.28277352e-02f, -2.98930313e-02f, -1.00233490e-02f, -4.60829698e-02f, 3.80203687e-02f, -3.91763933e-02f, 3.41613851e-02f, 4.25441898e-02f, 2.44655386e-02f, -5.06014898e-02f,
  1.93755925e-02f, 2.61878129e-02f, 5.24633601e-02f, 3.99681330e-02f, -2.97145937e-02f, -4.61544134e-02f, 3.10554286e-03f, -2.19452009e-02f, 4.66663763e-02f, -3.11830435e-02f,
  -1.01234321e-03f, -3.59272361e-02f, -4.81873825e-02f, 6.64069364e-03f, 6.71956465e-02f, 5.58481738e-02f, -3.71765979e-02f, 2.61950623e-02f, -4.15060110e-02f, -6.57379255e-02f,
  -5.74892806e-03f, -1.76103473e-01f, 1.33895623e-02f, -1.55532337e-03f, -6.31686626e-03f, -4.54311706e-02f, 3.39788161e-02f, -2.20658723e-02f, -4.63614091e-02f, 3.68952826e-02f,
  -6.94163963e-02f, 5.67561872e-02f, -1.12889847e-02f, -2.58060843e-02f, -2.53945012e-02f, 5.88922165e-02f, -9.53246728e-02f, -2.87423078e-02f, -8.29060525e-02f, 4.04408388e-02f,
  -3.98786254e-02f, -1.11377262e-01f, -1.98977441e-02f, -1.48979463e-02f, 3.67276222e-02f, -1.51781663e-02f, 6.29680306e-02f, -1.86441820e-02f, 2.59617921e-02f, 1.68588720e-02f,
  1.91783592e-01f, 1.08593732e-01f, 7.42853507e-02f, -2.42051971e-03f, 3.80100422e-02f, -1.15376525e-01f, -7.68679157e-02f, -6.92376196e-02f, 1.94728985e-01f, -1.29016653e-01f,
  -1.74387574e-01f, 3.63859124e-02f, -1.11916013e-01f, -2.11022422e-01f, -1.71045378e-01f, -1.21119961e-01f, -3.02808378e-02f, -6.02731900e-03f, 1.22715764e-01f, -5.31254672e-02f,
  -6.71287673e-03f, -2.42808893e-01f, -1.14988320e-01f, -1.47216395e-01f, -4.22456823e-02f, 5.17301336e-02f, -2.04860568e-01f, -3.50813568e-02f, -2.08922252e-01f, -1.11131862e-01f,
  -5.84134944e-02f, 8.32256954e-03f, 3.36297229e-02f, -1.32695502e-02f, 8.45867917e-02f, 4.49901167e-03f, 4.11199294e-02f, -3.11006419e-02f, -3.08416560e-02f, 2.98155099e-02f,
  5.48526496e-02f, -2.81848870e-02f, -6.03324957e-02f, -4.91659939e-02f, 2.77520660e-02f, 1.99464448e-02f, -1.64231155e-02f, 2.05416344e-02f, -1.80265065e-02f, 3.32615189e-02f,
  1.68332122e-02f, 8.18773806e-02f, 2.08009575e-02f, -8.78171921e-02f, -2.34195348e-02f, 2.49061752e-02f, 5.02642803e-02f, -5.99277802e-02f, -3.82651109e-03f, 6.51256964e-02f,
  -2.60541332e-04f, 8.89418796e-02f, -4.83453646e-02f, -4.39220518e-02f, 2.02253722e-02f, 7.49477604e-03f, 3.13158222e-02f, 4.07154206e-03f, 9.86870937e-03f, 2.18869578e-02f,
  -1.61082614e-02f, -2.08524689e-02f, -2.55713649e-02f, 4.84451205e-02f, -6.29495308e-02f, -4.06099819e-02f, -8.48408267e-02f, -5.14613092e-02f, -2.93361023e-03f, 4.81749792e-03f,
  -4.70738783e-02f, -6.83624484e-03f, -7.25780874e-02f, 5.87272532e-02f, 2.12010909e-02f, 1.03010265e-02f, 3.53778526e-02f, 4.86890711e-02f, -1.98866464e-02f, -4.24296148e-02f,
  2.11440045e-02f, 1.95783768e-02f, -3.43163125e-02f, 1.35119725e-02f, 2.19085440e-02f, 1.67146418e-02f, 3.85410041e-02f, -2.00481582e-02f, -1.87043529e-02f, -7.36939311e-02f,
  3.44917439e-02f, -1.62713509e-02f, 5.14864884e-02f, 2.67843939e-02f, -1.38845472e-02f, -2.29223426e-02f, 8.40681791e-03f, -6.00067563e-02f, -5.34718595e-02f, -2.48464923e-02f,
  4.35283268e-03f, -8.66229236e-02f, -3.84673737e-02f, 4.77883741e-02f, -4.81602550e-02f, 1.82913598e-02f, 1.21589722e-02f, 5.07317409e-02f, -1.62376463e-02f, -6.37014061e-02f,
  3.79441649e-01f, -2.89915316e-02f, 7.91533887e-02f, 1.62646562e-01f, 1.81299508e-01f, 1.04754619e-01f, 2.10493207e-01f, 4.92092222e-02f, 9.64921266e-02f, -1.33324321e-02f,
  1.82777755e-02f, 1.06230460e-01f, -1.60486355e-01f, -4.91507128e-02f, 7.78957084e-02f, -1.82947978e-01f, 1.58470586e-01f, 1.30368486e-01f, 1.47403711e-02f, 1.53861642e-01f,
  5.94436191e-02f, 2.90922653e-02f, -1.19275063e-01f, -8.27072412e-02f, 2.42889494e-01f, 5.83010353e-02f, -8.96766111e-02f, -5.55940680e-02f, -3.45160626e-02f, 4.27252240e-02f,
  1.39556229e-01f, 3.63265760e-02f, 7.82274380e-02f, -4.44860868e-02f, 1.12080999e-01f, 7.69720301e-02f, 8.49651396e-02f, -6.15006909e-02f, 2.59909015e-02f, -1.67285278e-02f,
  -3.71975787e-02f, -4.62848060e-02f, -3.12552229e-02f, -5.19989841e-02f, -7.20772368e-04f, 8.74148589e-03f, 2.08255611e-02f, 5.29255345e-02f, 7.71355182e-02f, 5.85031770e-02f,
  8.44155401e-02f, 8.38868991e-02f, -4.47091348e-02f, -4.22024019e-02f, 2.52793543e-02f, 3.62075232e-02f, 3.39278542e-02f, -4.92237229e-03f, -3.33557911e-02f, 4.83854748e-02f,
  -2.85831261e-02f, -5.59669845e-02f, -2.94353124e-02f, -1.13927072e-03f, 1.37585186e-04f, 1.61621608e-02f, -4.18642834e-02f, -2.50054430e-02f, -4.34587151e-02f, 3.87631543e-02f,
  5.41942157e-02f, -7.01430142e-02f, -1.96178239e-02f, 5.78646809e-02f, 4.35627736e-02f, 2.48435121e-02f, -2.31947210e-02f, 5.81278130e-02f, -1.58581901e-02f, 6.45271167e-02f,
  -2.80968510e-02f, 6.23269286e-03f, 2.60972939e-02f, -1.11925835e-03f, 1.45962127e-02f, -5.54558672e-02f, 1.35760596e-02f, -5.22595607e-02f, 3.42126191e-02f, 7.09249750e-02f,
  1.27224192e-01f, -1.56573318e-02f, -7.34460354e-02f, 5.83436079e-02f, 6.22702716e-03f, -7.45673478e-02f, -7.47165009e-02f, 8.07365254e-02f, 6.49323910e-02f, 3.78618389e-02f,
  4.27113324e-02f, 4.13339548e-02f, 4.02441733e-02f, -2.95763947e-02f, 1.44957257e-02f, 3.26238498e-02f, 5.61675429e-02f, 7.59921223e-03f, 1.04345590e-01f, -4.35995013e-02f,
  -1.59608349e-02f, -2.47991886e-02f, -2.41791643e-02f, 1.35502676e-02f, 2.90078521e-02f, 7.44062662e-02f, -2.77222190e-02f, -2.87353788e-02f, 7.46200159e-02f, 3.27484831e-02f,
  -1.61945671e-01f, -1.62542667e-02f, -8.17162022e-02f, -1.47129521e-01f, -1.06801167e-02f, -8.14600065e-02f, -9.07766894e-02f, 9.01766047e-02f, -6.79543763e-02f, -3.04651186e-02f,
  1.12559134e-02f, -2.79957913e-02f, -5.21712638e-02f, -1.16922699e-01f, -9.25316736e-02f, -1.46233356e-02f, -1.49496362e-01f, -8.90644193e-02f, -7.07961917e-02f, 2.90909987e-02f,
  3.76943797e-02f, -1.43340155e-01f, -5.25910445e-02f, -6.33222610e-02f, 3.50401364e-03f, 7.22294254e-03f, 1.96961816e-02f, 1.93130597e-02f, 2.26662494e-02f, -6.05973378e-02f,
  2.16372106e-02f, 6.50349483e-02f, 2.24960241e-02f, 2.95783225e-02f, 8.47450197e-02f, 8.35702494e-02f, -5.84830381e-02f, -7.78767467e-02f, 8.43510404e-03f, 5.50047047e-02f,
  5.48869595e-02f, -6.10558987e-02f, -8.45615044e-02f, -7.19608441e-02f, -6.31591771e-03f, -7.52211213e-02f, 5.82656041e-02f, -9.68359690e-03f, -6.69939891e-02f, -1.36026572e-02f,
  7.62670338e-02f, 7.82678053e-02f, -2.39620320e-02f, 4.56733517e-02f, -7.62452409e-02f, -8.75649508e-03f, -8.12261626e-02f, -4.24940661e-02f, 9.42197889e-02f, -8.79060011e-03f,
  8.17582160e-02f, 6.65013418e-02f, 1.02409989e-01f, 4.72542308e-02f, -4.01074588e-02f, -2.05704123e-02f, 3.32022347e-02f, -7.08542615e-02f, -2.33338345e-02f, -1.83322448e-02f,
  2.26310398e-02f, 8.09806138e-02f, 1.66261904e-02f, -7.81230107e-02f, 2.78695598e-02f, 3.42308879e-02f, -8.21913183e-02f, 1.49369743e-02f, -9.07414854e-02f, 4.41153981e-02f,
  5.87794483e-02f, -4.50518206e-02f, -7.89149548e-04f, 2.56985929e-02f, -1.67347733e-02f, -4.42113578e-02f, -6.30198196e-02f, 3.36259305e-02f, -1.21933389e-02f, -2.12503653e-02f,
  2.53561549e-02f, -4.69387062e-02f, 6.43006116e-02f, 5.07241189e-02f, -7.22451508e-03f, 1.15444563e-01f, -7.98666477e-02f, 6.63775997e-03f, -1.78275630e-02f, -6.94648102e-02f,
  8.36166516e-02f, -6.00454062e-02f, 3.54475752e-02f, 5.82454465e-02f, 1.24260839e-02f, 1.34328501e-02f, 1.54476091e-02f, -6.17655143e-02f, 4.27914523e-02f, 7.97304511e-02f,
  5.51095083e-02f, 6.40997812e-02f, 8.37678835e-03f, 7.25219166e-03f, 7.09992498e-02f, 5.08832596e-02f, 5.49583742e-03f, 8.60054269e-02f, -2.22060084e-03f, 1.08795576e-01f,
  -2.64151305e-01f, -2.53593415e-01f, 1.07603513e-01f, -1.54013366e-01f, 6.35404722e-04f, 2.72583310e-02f, -6.46411330e-02f, 4.16217893e-02f, -3.52490127e-01f, -1.71808913e-01f,
  -8.44460726e-03f, -1.76424414e-01f, 1.09472208e-01f, -2.96369614e-03f, 1.47997573e-01f, -8.96974951e-02f, 7.19237775e-02f, -6.08459860e-02f, 3.73341120e-03f, 5.44974953e-02f,
  1.47667944e-01f, 1.42252922e-01f, 2.51923651e-01f, 1.29812881e-01f, 1.58185828e-02f, -7.10339248e-02f, 1.83209956e-01f, 1.74460024e-01f, 1.61376193e-01f, 7.46586025e-02f,
  -3.01534368e-04f, -1.27141222e-01f, -1.31374560e-02f, -3.24676037e-02f, 4.97024395e-02f, 6.85749426e-02f, 5.02328314e-02f, 5.95210716e-02f, 9.65014175e-02f, -3.77255045e-02f,
  -3.08545232e-02f, 7.06020668e-02f, -3.85805629e-02f, 5.14459647e-02f, -1.72152445e-02f, 5.30750714e-02f, 5.42861130e-03f, 3.56304273e-02f, 4.60253395e-02f, 2.86639351e-02f,
  -1.92142893e-02f, 4.00514863e-02f, 2.73549091e-02f, 1.68224163e-02f, 6.68637455e-02f, -1.27915395e-02f, 2.29087099e-03f, 5.34189939e-02f, -4.54284484e-03f, -6.72398880e-02f,
  -8.53084028e-02f, 7.08842501e-02f, 3.41912434e-02f, -1.10168625e-02f, -9.52230021e-03f, -2.74560950e-03f, 2.29665525e-02f, 3.06237787e-02f, -2.71085426e-02f, -3.52895334e-02f,
  -5.01616821e-02f, -1.46685457e-02f, 4.84909564e-02f, -5.43046556e-02f, 1.48455948e-02f, -5.56070209e-02f, -6.65379164e-04f, -2.41678096e-02f, -2.61521805e-02f, 5.06101698e-02f,
  -2.60710903e-02f, -1.35439895e-02f, -4.82119098e-02f, 4.56549181e-03f, 3.94328237e-02f, 2.93357018e-02f, 3.09646521e-02f, -3.31367962e-02f, 4.38607094e-05f, 7.75477961e-02f,
  -6.13151565e-02f, -1.23394817e-01f, -4.32448126e-02f, -1.38249854e-03f, -4.87633422e-02f, 1.45718893e-02f, -2.67540105e-02f, 1.43937441e-02f, -6.16082661e-02f, 4.46072146e-02f,
  2.47308761e-02f, 3.82027179e-02f, 2.21738517e-02f, 2.03662440e-02f, 2.77014356e-02f, -3.14510167e-02f, 4.03655507e-02f, 4.08202298e-02f, 5.58770560e-02f, 9.91374487e-04f,
  -1.03742424e-02f, -6.31893650e-02f, -3.91320959e-02f, 8.07681680e-02f, 2.93850508e-02f, -2.92840339e-02f, -4.62079328e-03f, -4.17770147e-02f, -7.27536948e-03f, -2.17927750e-02f,
  1.39949501e-01f, 1.98360048e-02f, -6.37005419e-02f, 6.83579147e-02f, -1.91226369e-03f, 2.06707224e-01f, 2.06084430e-01f, -1.01198085e-01f, 9.54378024e-02f, -1.25148632e-02f,
  6.26964611e-04f, 5.22997715e-02f, -3.01314164e-02f, 8.03175494e-02f, 1.29898891e-01f, 8.55531245e-02f, 1.56375274e-01f, 4.58103493e-02f, -7.95565918e-02f, 8.99832323e-02f,
  5.09130880e-02f, 7.01652840e-03f, -1.76114719e-02f, -1.27892137e-01f, 6.91714436e-02f, -1.27041534e-01f, -8.30938444e-02f, -3.02851386e-02f, 4.77788076e-02f, 8.95921513e-02f,
  1.64946929e-01f, -9.49749574e-02f, 1.71336066e-02f, -4.65600044e-02f, -5.91493864e-03f, 4.63323900e-03f, 2.96882521e-02f, 2.98314504e-02f, -1.83370728e-02f, 8.29611793e-02f,
  3.86801623e-02f, 4.58691716e-02f, -9.84314680e-02f, -5.37811629e-02f, -5.74902771e-03f, -1.82690863e-02f, -2.01716330e-02f, 3.35600525e-02f, -4.34230901e-02f, -4.98003140e-02f,
  1.86607651e-02f, -2.41709072e-02f, -8.84792134e-02f, -4.18839939e-02f, -9.73485857e-02f, -2.02919412e-02f, -6.51439419e-03f, -6.75172061e-02f, 3.06362715e-02f, -7.18814731e-02f,
  -8.41645822e-02f, 6.24151789e-02f, 6.87061474e-02f, 6.54179603e-02f, 8.53165239e-02f, -1.77216493e-02f, -3.24373767e-02f, 3.64324339e-02f, -3.82133201e-02f, 1.99315492e-02f,
  7.40080476e-02f, 7.09535033e-02f, 1.23795001e-02f, -1.38972281e-02f, -1.73570178e-02f, -5.64239323e-02f, 1.26304692e-02f, 6.98849210e-04f, 4.49720472e-02f, 5.97626232e-02f,
  1.66246593e-02f, 5.40921353e-02f, 5.25013544e-02f, 2.48632152e-02f, 1.59283597e-02f, -3.56607027e-02f, 1.11176567e-02f, 7.66871050e-02f, 5.24700955e-02f, -7.59307295e-03f,
  2.17741162e-01f, 1.36385396e-01f, 4.33841161e-02f, 9.20873210e-02f, 2.76494231e-02f, 7.57271945e-02f, -8.45562294e-02f, -2.66489480e-02f, -1.05035724e-04f, -4.46224958e-02f,
  -4.54319753e-02f, -3.44760343e-02f, 3.82674206e-03f, -2.47358736e-02f, 3.20779569e-02f, 6.55978099e-02f, 8.60494152e-02f, -1.58356838e-02f, 4.32724133e-02f, -5.44116013e-02f,
  -4.05619927e-02f, -5.04353307e-02f, 1.98713914e-02f, -5.93312196e-02f, 1.81204565e-02f, 1.58862155e-02f, 5.14268056e-02f, -4.70852815e-02f, 5.06682098e-02f, 4.31369990e-02f,
  8.70141909e-02f, -4.55748551e-02f, 1.47366762e-01f, 6.18853159e-02f, 7.37160444e-02f, 3.27679403e-02f, 1.57412425e-01f, -6.71526119e-02f, 1.31854117e-01f, -1.10411093e-01f,
  -4.87223268e-03f, 1.06372237e-01f, 6.33639693e-02f, 1.78970024e-02f, 7.61451572e-02f, -6.27139062e-02f, -4.02807184e-02f, -6.32601455e-02f, 2.38220338e-02f, -6.38290215e-03f,
  9.84164514e-03f, -8.37701708e-02f, 1.85901672e-02f, -9.96845886e-02f, 9.13571939e-02f, 1.59954708e-02f, -9.51563567e-02f, -1.39493980e-02f, -1.44321918e-01f, -5.78930136e-03f,
  1.01712113e-02f, 1.08960696e-01f, 6.95930198e-02f, 8.65915045e-02f, -7.74466321e-02f, -3.46180908e-02f, -1.69092435e-02f, 6.15982190e-02f, 2.85198763e-02f, 6.34638369e-02f,
  -4.08427268e-02f, -6.02310407e-04f, -4.95650768e-02f, -4.52721901e-02f, 6.01850376e-02f, -4.49143313e-02f, 5.14722131e-02f, -6.55423403e-02f, -4.13318276e-02f, 3.76049057e-02f,
  -3.64172496e-02f, -5.97918369e-02f, 1.57499835e-02f, -6.20275997e-02f, 6.38507009e-02f, 8.76963809e-02f, 4.80875336e-02f, 3.19817513e-02f, -3.66448611e-02f, -2.95218937e-02f,
  5.63208088e-02f, 3.71102622e-04f, -4.41702157e-02f, -5.46530038e-02f, -4.91319457e-03f, -6.18505888e-02f, -7.57649988e-02f, -3.13354693e-02f, -8.23613927e-02f, 3.17906700e-02f,
  4.15375642e-03f, -3.29004899e-02f, -3.17028798e-02f, 1.14548784e-02f, -3.39312851e-02f, 3.74015868e-02f, -3.39115784e-02f, 2.00936552e-02f, -6.22362532e-02f, -7.70236477e-02f,
  -8.34110565e-03f, 8.02320521e-03f, 3.39599587e-02f, 4.19722423e-02f, -2.54277214e-02f, 5.52953035e-02f, 5.30314781e-02f, -3.41426674e-03f, 4.57762703e-02f, 6.18187934e-02f,
  -1.07964657e-01f, -1.80613935e-01f, -3.57895531e-02f, 3.20261084e-02f, 2.57322639e-02f, -7.42080212e-02f, -2.29699165e-02f, 2.80770753e-02f, -6.24681227e-02f, 6.93486333e-02f,
  -6.04882203e-02f, 1.02193160e-02f, -7.45926127e-02f, -6.06603920e-03f, -6.37883544e-02f, 7.44430199e-02f, 1.69952363e-02f, -1.16015682e-02f, 3.40526402e-02f, -5.43732420e-02f,
  3.71626616e-02f, 5.38912565e-02f, 3.75752002e-02f, -2.49035787e-02f, 1.71839297e-02f, -1.10746343e-02f, -6.35313615e-02f, -5.30436672e-02f, 2.06267145e-02f, -4.15708870e-03f,
  1.29717261e-01f, 4.25422704e-03f, 1.76805466e-01f, 1.23967960e-01f, 1.03498325e-02f, -5.93292750e-02f, 4.90465164e-02f, -9.05098915e-02f, 7.49892220e-02f, -2.01592654e-01f,
  -1.53250426e-01f, 2.33867884e-01f, -2.81641558e-02f, -1.47017360e-01f, 9.42534357e-02f, -2.17455367e-04f, 8.31957161e-03f, 1.45597272e-02f, -5.56127634e-03f, 6.39535114e-02f,
  4.37515490e-02f, -1.65379465e-01f, 9.20770839e-02f, -1.10178523e-01f, -2.63975281e-02f, 1.08672924e-01f, -1.18783630e-01f, 2.93807685e-02f, 4.83852252e-03f, -2.61149593e-02f,
  -1.98977459e-02f, 7.76508152e-02f, 5.72475940e-02f, -4.25881743e-02f, 1.41391028e-02f, -8.11633766e-02f, -6.79352041e-03f, 9.73413233e-03f, 4.44654450e-02f, 7.46716559e-02f,
  -1.10401660e-02f, 6.85710162e-02f, 2.99484655e-02f, 2.51745954e-02f, -7.50436261e-02f, 7.05675483e-02f, -1.03735849e-02f, 2.66626850e-02f, 8.10811520e-02f, 6.46045879e-02f,
  2.36528534e-02f, 2.13249214e-02f, -5.35337105e-02f, 3.33313569e-02f, 1.03936598e-01f, -5.36489189e-02f, 3.28804296e-03f, 2.94612665e-02f, 1.38337359e-01f, -1.28619664e-03f,
  -7.31542706e-02f, 5.54797724e-02f, 5.78020476e-02f, -4.85224463e-02f, 8.02537873e-02f, -7.93129802e-02f, -4.35990356e-02f, -5.80843985e-02f, 7.96553865e-02f, -2.68219933e-02f,
  -4.43880260e-02f, -5.40246256e-02f, -4.38557826e-02f, -2.03950098e-03f, 3.35425511e-02f, -6.22490235e-02f, -5.58440834e-02f, -4.23750654e-02f, 5.23877889e-02f, 2.67838165e-02f,
  -1.00090906e-01f, -8.80607404e-03f, -7.71518871e-02f, 3.05344928e-02f, 3.93176898e-02f, -7.34805018e-02f, 5.50065562e-02f, -1.20814377e-02f, 1.42536107e-02f, 4.58482467e-02f,
  -4.45463434e-02f, -6.85983002e-02f, -4.47559878e-02f, 4.96611260e-02f, 1.00557962e-02f, 1.39382221e-02f, 6.06896915e-02f, -7.19815716e-02f, 9.91565734e-02f, -6.31700829e-03f,
  1.91444457e-02f, -7.67946467e-02f, 2.13476866e-02f, -8.61714035e-03f, 9.95793268e-02f, 2.47069020e-02f, 1.15994923e-02f, 5.80615997e-02f, 3.97835225e-02f, 4.84957695e-02f,
  4.19310927e-02f, 3.39436047e-02f, -1.27064902e-02f, 5.15294932e-02f, -7.28934258e-02f, -3.06049287e-02f, 6.87627345e-02f, -9.21408273e-03f, -4.71196063e-02f, -5.45855835e-02f,
  1.56956136e-01f, 3.06363851e-02f, 1.60190716e-01f, 8.00688118e-02f, -1.79370314e-01f, 5.71058057e-02f, 1.41908631e-01f, 1.11661583e-01f, 1.25448704e-01f, -9.91849899e-02f,
  -6.22520149e-02f, 7.08170459e-02f, -3.88078019e-02f, 6.92746937e-02f, 1.83396384e-01f, 2.04246491e-01f, 8.71536061e-02f, 8.49158242e-02f, 3.61315683e-02f, 7.51286466e-03f,
  1.15682982e-01f, 1.57788713e-02f, 1.08108312e-01f, -3.23433280e-02f, 4.40016128e-02f, -8.79954472e-02f, -7.28294551e-02f, -6.89306855e-02f, -1.47449214e-03f, -3.32335830e-02f,
  -5.72704673e-02f, 8.17107186e-02f, 6.45789728e-02f, -4.44498770e-02f, 4.97278646e-02f, -1.43012162e-02f, -3.12945731e-02f, -2.26198547e-02f, 1.28786759e-02f, -2.81688999e-02f,
  4.38450128e-02f, 4.03533243e-02f, 4.70526796e-03f, 8.49586725e-03f, -2.90071163e-02f, 7.85165578e-02f, -1.07404850e-01f, -2.03420850e-03f, -6.29574060e-02f, -4.46787924e-02f,
  1.01494789e-02f, 3.17984028e-03f, -1.78449601e-02f, -4.12104512e-03f, 3.58396396e-02f, 3.92031744e-02f, 3.81601863e-02f, -7.60026351e-02f, -5.31836674e-02f, -1.92494423e-03f,
  -3.33941616e-02f, 2.82744188e-02f, -1.27255935e-02f, -2.14436054e-02f, 8.40373784e-02f, -2.03251429e-02f, -2.18745898e-02f, 2.25705002e-02f, 2.31603906e-02f, -1.47716934e-02f,
  3.73400412e-02f, 3.20979692e-02f, -2.31894553e-02f, 2.37522181e-02f, 5.66783361e-02f, 4.86480892e-02f, 1.64178424e-02f, -6.95319101e-02f, 4.17857282e-02f, 3.30460668e-02f,
  3.23752053e-02f, -1.66639257e-02f, -1.61442459e-02f, -8.59366283e-02f, -2.20446065e-02f, 5.43078557e-02f, -1.15994746e-02f, 4.59866449e-02f, 7.22643919e-03f, 1.85376825e-03f,
  6.51012957e-02f, 2.25211784e-01f, -3.22240382e-03f, -1.47558423e-02f, -7.22916890e-03f, -2.26252005e-02f, 6.28602281e-02f, 2.55092196e-02f, 8.43056291e-02f, -1.61999110e-02f,
  -6.43879473e-02f, -4.13603894e-02f, -1.18493270e-02f, 1.58634763e-02f, -4.30453829e-02f, 7.03838989e-02f, 6.64049760e-02f, -4.01237197e-02f, -3.26778255e-02f, 4.91370261e-02f,
  2.35902518e-03f, 2.11394094e-02f, -1.62071474e-02f, 4.63163368e-02f, -4.34948392e-02f, -6.08305968e-02f, 3.35282646e-02f, -2.84406077e-02f, -6.17031381e-02f, 4.02999297e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.71672478e-01f, -8.61683339e-02f, -7.64771327e-02f, 1.53808724e-02f, 8.64720941e-02f, 1.39279142e-01f, 5.33448905e-02f, 9.66012776e-02f, 3.21518108e-02f, -5.47443591e-02f,
  1.07979015e-01f, -9.03221518e-02f, -5.13628908e-02f, 6.72530159e-02f, 2.94150505e-02f, -1.00867540e-01f, 1.65413581e-02f, -4.30216491e-02f, -5.13178371e-02f, -4.31285463e-02f,
  2.65978314e-02f, 1.56486616e-01f, 6.77047521e-02f, -4.87241037e-02f, 4.40755822e-02f, -9.70162973e-02f, 5.88467456e-02f, 1.48761282e-02f, -2.14028135e-02f, -9.35172513e-02f,
  6.39597327e-02f, 8.19667131e-02f, -6.17623795e-03f, -1.41188540e-02f, 1.57401115e-02f, -5.91283850e-02f, -1.02132782e-01f, -2.99461074e-02f, 9.42095295e-02f, 6.68565109e-02f,
  -5.61589859e-02f, 5.27038649e-02f, -1.72239598e-02f, -3.82794440e-02f, 4.39810939e-02f, 4.26061563e-02f, -3.91908735e-02f, -8.11746120e-02f, 3.63416201e-03f, 2.35035503e-03f,
  4.57466282e-02f, -8.35949380e-04f, 5.02975807e-02f, -2.93133315e-03f, 7.41300210e-02f, -3.17118391e-02f, -9.10098776e-02f, -4.60221246e-02f, -9.94865317e-04f, 6.89338818e-02f,
  3.51865403e-02f, -1.56341568e-02f, 2.29800157e-02f, 7.57797658e-02f, 8.65962952e-02f, 1.54392775e-02f, -5.51476702e-02f, 5.58900796e-02f, 7.78936036e-03f, 4.79947552e-02f,
  -6.95060268e-02f, 8.54341462e-02f, -2.87328828e-02f, -6.16829172e-02f, 8.96512792e-02f, -8.49929824e-02f, -7.29659945e-02f, -5.55666089e-02f, 7.49351606e-02f, 2.88666710e-02f,
  2.18538828e-02f, 1.25875939e-02f, -4.85825017e-02f, 1.62339099e-02f, -6.81769848e-02f, 6.10778630e-02f, 8.79678354e-02f, 4.67397496e-02f, -1.23746227e-02f, -6.94544837e-02f,
  -3.55785117e-02f, -5.67537360e-02f, 3.52133587e-02f, -5.48915006e-02f, -5.07797375e-02f, 4.21648994e-02f, -4.10538493e-03f, 5.15948273e-02f, -7.27560222e-02f, 8.43430087e-02f,
  -2.47643404e-02f, 4.63568419e-02f, -7.44583979e-02f, 7.70332813e-02f, -9.23038051e-02f, 7.58197606e-02f, 1.75637342e-02f, 6.00211285e-02f, -7.40882829e-02f, 3.54523994e-02f,
  4.26868200e-02f, -5.38072139e-02f, -4.73643877e-02f, -6.60256743e-02f, -6.87352717e-02f, 1.86517928e-02f, -7.16754869e-02f, -1.63536835e-02f, -8.80281162e-03f, -9.35793668e-02f,
  -1.37695447e-01f, 2.38666404e-02f, -1.50890663e-01f, -7.27334619e-02f, -2.72341445e-02f, 8.26793090e-02f, -3.01665254e-02f, 1.87899899e-02f, -7.00100586e-02f, 1.01221509e-01f,
  2.08763108e-01f, -6.71316087e-02f, 1.44543320e-01f, 1.18768901e-01f, -2.54392475e-02f, 4.62383777e-02f, 9.87670124e-02f, -1.98495165e-02f, -9.77271944e-02f, -1.15807936e-01f,
  -1.18409708e-01f, 7.12940842e-02f, 5.08806296e-02f, -6.37137443e-02f, -4.92309555e-02f, -1.11447118e-01f, -5.32542840e-02f, -6.46415949e-02f, 6.18055426e-02f, -2.12731145e-04f,
  4.92105149e-02f, 8.02904442e-02f, 6.75748289e-02f, -7.14269280e-02f, -7.50473840e-03f, -4.64334451e-02f, -7.08221644e-03f, -9.46224257e-02f, -9.77252573e-02f, 1.67748500e-02f,
  -6.35492727e-02f, -7.18587562e-02f, -1.17619976e-03f, -6.10286444e-02f, -9.99820158e-02f, 4.30690050e-02f, -9.62863788e-02f, -1.30175119e-02f, 1.61084370e-03f, 4.60014232e-02f,
  -7.91050196e-02f, -9.45500061e-02f, 5.29355034e-02f, -2.13962272e-02f, 9.57011618e-03f, 3.79188266e-03f, -4.69845608e-02f, -9.38902199e-02f, 7.37450346e-02f, 3.59699987e-02f,
  -4.92125414e-02f, 8.00470635e-03f, 6.85506240e-02f, 8.32467452e-02f, -6.32559955e-02f, -3.67976585e-03f, -2.81334091e-02f, 5.13764322e-02f, -1.16933785e-01f, -2.74308845e-02f,
  -7.94939920e-02f, -5.71174435e-02f, 1.85170639e-02f, 3.17740254e-02f, 2.53870673e-02f, -1.45240221e-03f, -2.86390278e-02f, 2.00644899e-02f, -5.33019081e-02f, 3.89853120e-03f,
  -8.33397880e-02f, -2.10746005e-02f, 1.08470559e-01f, 9.67772827e-02f, -3.01787183e-02f, -3.81227955e-02f, 3.69129218e-02f, 1.66973062e-02f, 5.45316450e-02f, 4.15748619e-02f,
  9.30526108e-02f, 1.00253478e-01f, 9.51655582e-02f, 9.52956080e-02f, 3.34409811e-02f, -6.27145171e-02f, 4.02924791e-02f, -5.43256700e-02f, 7.78158829e-02f, -7.32097775e-02f,
  -1.92579976e-03f, -7.16496035e-02f, 1.61856096e-02f, -6.64203754e-03f, -2.28584111e-02f, 1.17687009e-01f, -8.46517086e-02f, -1.00656189e-01f, -8.93454626e-02f, -1.08097661e-02f,
  1.98701527e-02f, -6.00184128e-02f, -1.00914039e-01f, -3.80514599e-02f, -2.00993847e-02f, 6.95833415e-02f, -6.93641752e-02f, 4.08353843e-02f, -5.57198748e-02f, -4.11292240e-02f,
  1.96701884e-02f, 4.64882180e-02f, 9.11220610e-02f, 6.14795508e-03f, -1.18985064e-01f, -9.32547748e-02f, 2.87635028e-02f, -2.67343670e-02f, -4.44254614e-02f, 1.01127453e-01f,
  -9.86943692e-02f, 1.74542338e-01f, -8.65766406e-02f, 8.16051587e-02f, -7.68519714e-02f, 2.33777110e-02f, -6.27749637e-02f, -4.06313092e-02f, -5.09770699e-02f, 2.87204795e-02f,
  2.69853864e-02f, -9.30770636e-02f, -2.48898882e-02f, -4.80074435e-02f, -6.02161363e-02f, 1.25038311e-01f, 4.14406173e-02f, -8.01245868e-02f, -4.75160368e-02f, -6.41656741e-02f,
  -4.14343995e-05f, 7.50185847e-02f, 8.46574008e-02f, -4.62628230e-02f, -5.71925417e-02f, 1.08054444e-01f, 7.60384127e-02f, 4.27994430e-02f, 1.61895007e-02f, -5.16408384e-02f,
  1.90273896e-02f, -4.48771194e-03f, -6.77802879e-03f, -6.18147440e-02f, 1.44031993e-03f, 2.38228124e-02f, -4.47487049e-02f, -6.43020868e-02f, 6.66273311e-02f, 5.23746125e-02f,
  1.20583668e-01f, 6.66489229e-02f, -1.99551042e-02f, -5.51906824e-02f, 4.60594893e-02f, -3.06230485e-02f, 1.38480645e-02f, -3.29960845e-02f, 8.22229832e-02f, -5.95775805e-02f,
  -5.32704219e-02f, 7.63011724e-02f, -8.13289080e-03f, 8.37225690e-02f, -6.91119805e-02f, 2.11989251e-03f, -6.81484789e-02f, 5.18858284e-02f, -8.10190570e-03f, 4.24557999e-02f,
  5.35635240e-02f, 7.21821263e-02f, 4.34372202e-02f, -6.29891381e-02f, -8.01038817e-02f, 2.93734521e-02f, 7.80748725e-02f, -2.38723587e-02f, 6.86156526e-02f, 3.60984392e-02f,
  -6.37638047e-02f, 6.80919662e-02f, 4.78319414e-02f, -1.58394929e-02f, -6.68452829e-02f, -4.15847916e-03f, 4.75089177e-02f, 3.11422795e-02f, 6.39411658e-02f, -7.70134032e-02f,
  -5.69131859e-02f, 4.02127393e-02f, 6.56473041e-02f, -8.30652192e-03f, 1.54171130e-02f, -1.08891111e-02f, -7.22287744e-02f, 7.04026520e-02f, -2.28081532e-02f, 3.98378558e-02f,
  1.08129103e-02f, -2.76155560e-03f, -6.45434931e-02f, -2.31364965e-02f, -2.05413178e-02f, -7.14039952e-02f, 2.46548150e-02f, 4.96365204e-02f, -3.48855108e-02f, 6.78384826e-02f,
  -5.93625642e-02f, -5.71959056e-02f, 8.30198824e-02f, 7.23438039e-02f, -1.94326695e-02f, -7.75028691e-02f, -2.98794340e-02f, 6.15092628e-02f, 4.41201068e-02f, 1.09638209e-02f,
  2.32469700e-02f, 8.14907439e-03f, 1.39265597e-01f, 1.19565234e-01f, 1.35330874e-02f, -4.13289480e-02f, 1.00551479e-01f, 2.68593174e-03f, -1.33915329e-02f, -4.34225751e-03f,
  -7.08498200e-03f, 5.60307652e-02f, 4.39900868e-02f, -8.81531835e-02f, -3.49793211e-02f, -1.16914853e-01f, 4.35963906e-02f, 3.72293964e-02f, 6.46548867e-02f, 7.73719847e-02f,
  3.27716284e-02f, -1.28090475e-02f, 3.82109061e-02f, 2.57729217e-02f, -6.57235645e-03f, -4.72716913e-02f, -5.36489226e-02f, 3.97633314e-02f, -5.07219955e-02f, -7.88098276e-02f,
  -5.72433770e-02f, -1.91288050e-02f, 2.03093160e-02f, -3.77681740e-02f, -5.26744947e-02f, 8.68520886e-02f, -4.11704555e-02f, -6.20370079e-03f, -1.80505700e-02f, 3.41041647e-02f,
  6.47526532e-02f, -1.49240438e-02f, -6.01370856e-02f, 2.72873119e-02f, -7.48236924e-02f, -3.19765210e-02f, -5.95217012e-03f, 3.24101895e-02f, -7.80421868e-02f, 6.60290185e-04f,
  -1.98740158e-02f, -6.97494000e-02f, 1.01228341e-01f, 1.66534744e-02f, -7.86611065e-02f, 8.78922492e-02f, -1.35123823e-02f, 6.25986978e-02f, 2.53326148e-02f, -6.04635105e-02f,
  -8.19649845e-02f, 6.02083243e-02f, -1.34911295e-02f, -1.93312932e-02f, -6.18608668e-02f, 8.41221884e-02f, -1.42225139e-02f, 8.41538757e-02f, 9.69631448e-02f, 1.33936917e-02f,
  -3.61993425e-02f, -8.95791352e-02f, 8.56301747e-03f, -8.48973095e-02f, -8.40561539e-02f, 5.09850569e-02f, 7.30901957e-02f, 7.21044466e-02f, -3.14737596e-02f, -4.04303037e-02f,
  -5.17925695e-02f, 3.73152345e-02f, 1.19576761e-02f, 6.69056259e-04f, -4.87579266e-03f, -4.53570560e-02f, -1.95606295e-02f, -4.52088937e-02f, 1.69724301e-02f, 4.93260473e-02f,
  6.51489347e-02f, -3.23927663e-02f, 7.81998038e-02f, -2.33429112e-02f, 1.59795582e-02f, 1.66796707e-03f, 3.25689316e-02f, -8.81679635e-03f, -7.49368817e-02f, 6.66843355e-03f,
  7.03252777e-02f, 8.72995183e-02f, -1.38822254e-02f, 2.59019416e-02f, 5.19574666e-03f, 6.62011057e-02f, 1.61681995e-02f, 7.44360238e-02f, -7.13209957e-02f, 3.34734507e-02f,
  2.89506968e-02f, -6.88967481e-02f, 6.11228347e-02f, -2.74189841e-02f, -7.89469853e-02f, 6.40865564e-02f, 7.01957718e-02f, 8.24467912e-02f, -4.80594672e-02f, 9.52529535e-03f,
  -9.46965888e-02f, 8.21895450e-02f, -7.23992363e-02f, -9.02462676e-02f, 5.96951833e-03f, -2.49450859e-02f, -1.12212382e-01f, -4.13022600e-02f, 8.82188231e-03f, -1.01844566e-02f,
  -5.66413850e-02f, -1.26512302e-02f, 2.70483270e-03f, 2.20904965e-02f, 1.18382983e-02f, 3.01900730e-02f, -9.72803012e-02f, -1.12182476e-01f, 6.18670508e-02f, 1.05000604e-02f,
  7.26800188e-02f, -1.04455292e-01f, 4.95995628e-03f, 7.66893476e-02f, -1.15853697e-01f, -2.59381179e-02f, -5.84108615e-03f, 7.08718970e-02f, -8.46958160e-02f, 5.54730706e-02f,
  -3.61158699e-02f, 3.53673846e-02f, 9.78459492e-02f, 1.03012873e-02f, -1.20955035e-01f, 4.06813323e-02f, 6.60171285e-02f, -6.54783193e-03f, -1.88025311e-02f, 7.09133595e-02f,
  5.51534258e-02f, 5.92534728e-02f, -1.01474702e-01f, 1.90232985e-03f, 5.17800450e-02f, -3.70191373e-02f, -7.03280559e-03f, -5.71579933e-02f, 3.72355208e-02f, -4.52948287e-02f,
  -6.90613091e-02f, 8.84170160e-02f, 7.13233575e-02f, 4.92070988e-02f, -3.43224779e-02f, -8.91801268e-02f, 5.04043028e-02f, -1.18187387e-02f, 4.09083115e-03f, -4.76602465e-02f,
  4.72542830e-02f, 7.71730812e-03f, 7.65074790e-02f, 1.30533744e-02f, 5.09888120e-02f, -6.35778755e-02f, -6.07769936e-02f, 1.31429741e-02f, -1.03688585e-02f, -5.03481403e-02f,
  4.96611856e-02f, -5.06067649e-02f, -1.18822809e-02f, -1.85967062e-03f, -3.31650600e-02f, -1.88423798e-03f, -1.32685741e-02f, 1.92629285e-02f, -2.93139350e-02f, -1.40643269e-02f,
  -3.26681137e-02f, 6.20016549e-03f, 6.45485055e-03f, 8.37422460e-02f, 6.39896914e-02f, -4.57327440e-02f, -3.82030867e-02f, -5.66374436e-02f, -6.91165775e-02f, -4.24491614e-02f,
  -9.67033505e-02f, -1.57055169e-01f, 1.50181325e-02f, -2.28924435e-02f, -4.72466089e-02f, 2.75282958e-03f, 1.91404633e-02f, -4.59064543e-02f, -1.15825087e-01f, 5.16558997e-02f,
  -4.42654267e-02f, -7.27338940e-02f, 2.60870401e-02f, -4.33287360e-02f, 2.07078196e-02f, 5.02624996e-02f, 2.56414153e-02f, 2.46945722e-03f, 5.54998815e-02f, 7.68284127e-02f,
  -3.80358137e-02f, -3.58827934e-02f, -8.27813074e-02f, 3.31592821e-02f, -3.42895575e-02f, -1.22942012e-02f, 6.82343245e-02f, 3.17687467e-02f, -3.71080972e-02f, -1.87723450e-02f,
  -5.53541668e-02f, 2.47492701e-01f, 1.10981926e-01f, -2.56808698e-02f, -3.51441093e-02f, -1.65211767e-01f, -9.94475558e-03f, -6.12758771e-02f, 1.47899725e-02f, 5.48354127e-02f,
  2.21669152e-02f, 2.32592672e-01f, -2.91371644e-02f, 9.73878875e-02f, -2.84847528e-01f, -1.23333586e-02f, -6.39022663e-02f, 6.17647283e-02f, 1.53817877e-03f, -5.41055342e-03f,
  -1.31145775e-01f, -2.94456501e-02f, 2.59878300e-03f, 1.13907699e-02f, 1.29870042e-01f, 5.75424321e-02f, -9.81691256e-02f, -1.42033976e-02f, 1.15217276e-01f, -5.17935157e-02f,
  -1.08879387e-01f, -6.96098357e-02f, 1.06154516e-01f, -1.52641181e-02f, -1.21367097e-01f, 1.89725365e-02f, 1.30218053e-02f, -3.46922539e-02f, -7.39532709e-02f, 1.18760411e-02f,
  1.13641173e-01f, 2.57477816e-02f, 1.33295571e-02f, -7.55321980e-03f, 6.61486853e-03f, -1.31455949e-02f, 2.71014683e-02f, 1.85005404e-02f, 4.99704368e-02f, 1.20837465e-01f,
  1.29683197e-01f, 2.00382574e-03f, -2.22800430e-02f, 7.18735680e-02f, -3.79313976e-02f, 6.98953271e-02f, 6.46817163e-02f, 6.83319494e-02f, 2.58436687e-02f, -3.24658528e-02f,
  6.33668303e-02f, -8.14829022e-02f, -6.10567890e-02f, 3.92236970e-02f, -6.66692182e-02f, -7.83449970e-03f, -2.49269754e-02f, -8.24217051e-02f, -4.51396331e-02f, -3.99207417e-03f,
  -5.15891202e-02f, 5.78443334e-02f, 4.63672914e-02f, -7.48222470e-02f, 6.80118278e-02f, -4.84698638e-02f, -3.64349713e-03f, 2.76070461e-03f, -6.16217516e-02f, -6.66704029e-03f,
  -7.22635612e-02f, -5.76793216e-04f, -4.18439955e-02f, 2.55042780e-02f, 3.86544950e-02f, 6.18164577e-02f, 2.33836472e-02f, -1.47318784e-02f, 2.49195229e-02f, 4.93884203e-04f,
  4.83597862e-03f, -1.62171409e-01f, 2.89828107e-02f, 1.14758536e-02f, -7.13938056e-03f, -8.24280754e-02f, -2.67797839e-02f, -4.65250686e-02f, -9.83672515e-02f, -5.16883284e-02f,
  -3.87494527e-02f, -3.15374173e-02f, 4.03901413e-02f, -3.92642990e-02f, -6.84553385e-02f, 4.98805903e-02f, -6.81237429e-02f, 5.08265123e-02f, 2.19704565e-02f, -2.97635403e-02f,
  -7.78396204e-02f, -2.73891818e-02f, -8.40646625e-02f, -5.10211885e-02f, -1.22232735e-01f, 4.78313528e-02f, -6.52796850e-02f, 5.20656668e-02f, -8.17865133e-02f, 4.77959849e-02f,
  -9.40906107e-02f, -8.19512606e-02f, 4.05130908e-02f, 6.49270862e-02f, 1.22717351e-01f, -3.14000808e-02f, -3.86503004e-02f, -4.82650511e-02f, 7.62657821e-02f, 9.56271738e-02f,
  -7.63263926e-02f, -5.00903353e-02f, -1.35016833e-02f, -6.96795657e-02f, -1.02233477e-01f, -7.93071017e-02f, -1.18578756e-02f, 6.42431676e-02f, 5.82883246e-02f, 9.53431055e-02f,
  -2.27047540e-02f, -6.31804094e-02f, -7.45593086e-02f, -4.65395041e-02f, -6.24744855e-02f, -3.66542973e-02f, 1.68445706e-02f, 3.82759869e-02f, 8.93828943e-02f, -5.31320013e-02f,
  -3.17609943e-02f, -5.18318824e-02f, -1.07299173e-02f, -3.56654637e-02f, 1.03114776e-01f, 5.29756285e-02f, 1.21157812e-02f, 5.29167568e-03f, 2.93546519e-03f, -2.03858521e-02f,
  -4.29234169e-02f, -6.29494935e-02f, -5.17942421e-02f, -5.90963364e-02f, 1.58145791e-03f, -3.63196544e-02f, -4.79099639e-02f, 2.88772229e-02f, 5.76808527e-02f, 1.56580005e-02f,
  -9.08734053e-02f, -8.68579745e-02f, -3.30688953e-02f, -5.33750579e-02f, 4.74573635e-02f, -5.83750494e-02f, 6.51339516e-02f, -5.11231162e-02f, -1.01619773e-02f, -8.33600387e-02f,
  -3.75239551e-02f, 5.07490374e-02f, 7.23122507e-02f, -7.67324641e-02f, 8.06285366e-02f, -3.70638408e-02f, 5.84033579e-02f, 9.89743229e-03f, -1.33322170e-02f, -4.05045226e-02f,
  -1.86190717e-02f, 2.33035199e-02f, -1.09991655e-02f, -4.91757989e-02f, -7.29193985e-02f, -3.18966061e-02f, -3.24358270e-02f, -1.77261842e-04f, 8.76864940e-02f, -1.44942338e-02f,
  8.92316550e-03f, 3.67880091e-02f, -7.12695867e-02f, -2.18310487e-02f, -4.91979718e-02f, -9.22755823e-02f, 7.88212568e-02f, 5.40406108e-02f, 4.55099158e-02f, -1.00567946e-02f,
  9.30675864e-02f, 1.28544211e-01f, -4.33919057e-02f, -2.39948533e-03f, -4.58751544e-02f, 8.75762552e-02f, 1.12023614e-02f, 4.71182093e-02f, -7.59308692e-03f, -7.07352310e-02f,
  2.37105675e-02f, 9.41206068e-02f, -6.48306012e-02f, 7.94966593e-02f, 3.41078043e-02f, 2.47387867e-03f, 5.23917377e-02f, 7.85697103e-02f, -6.87658861e-02f, 5.30579276e-02f,
  7.98417553e-02f, -7.33683817e-03f, 2.43702512e-02f, -8.00763294e-02f, -5.35780601e-02f, 2.06929501e-02f, -7.93260634e-02f, 2.51089390e-02f, 6.54807547e-03f, -6.25919476e-02f,
  1.43445700e-01f, -7.53757805e-02f, -2.20045615e-02f, 6.80496693e-02f, 1.60232689e-02f, -8.49009529e-02f, -9.63448212e-02f, -1.44871831e-01f, 3.07047814e-02f, -1.44741803e-01f,
  -1.23195969e-01f, 7.12308139e-02f, 3.51219554e-03f, -1.12721764e-01f, 9.76214185e-02f, 5.80107868e-02f, -1.16210938e-01f, 2.86698192e-02f, 1.47459144e-03f, -1.15447976e-01f,
  -3.59947197e-02f, -1.08812876e-01f, -3.17023396e-02f, -1.03965655e-01f, 3.66087407e-02f, 5.24709374e-02f, 6.34334758e-02f, -1.34828776e-01f, 4.04159538e-03f, -4.94992733e-02f,
  -4.53139059e-02f, 1.59767475e-02f, 3.35378125e-02f, -6.66424334e-02f, 3.47960601e-03f, 2.65742391e-02f, 1.64962523e-02f, -2.00688262e-02f, -3.79507691e-02f, -3.82411219e-02f,
  3.99094559e-02f, -4.82127853e-02f, -5.60707897e-02f, -1.40753407e-02f, -7.53381401e-02f, 1.00863660e-02f, -4.79769781e-02f, 3.88718210e-02f, -2.21953331e-03f, -3.25423665e-02f,
  4.94475476e-02f, -2.20937859e-02f, -6.93739206e-02f, 6.32568821e-02f, 2.08931230e-02f, 3.42727751e-02f, 5.94409332e-02f, 2.74901781e-02f, -2.28001121e-02f, -2.76320223e-02f,
  4.41454612e-02f, -8.35039094e-03f, 9.72698722e-03f, 4.32930551e-02f, 5.47039136e-02f, -1.22357067e-02f, 4.43425477e-02f, 4.73860512e-03f, 7.83085153e-02f, -1.14068696e-02f,
  4.85790335e-02f, -5.51709086e-02f, -4.39239927e-02f, -5.04450649e-02f, -4.69970144e-02f, -8.04102141e-03f, -3.84636074e-02f, 2.32865028e-02f, 7.96713382e-02f, -3.85862365e-02f,
  2.80078072e-02f, 7.40799829e-02f, 3.58930603e-02f, -8.81807972e-03f, -7.51493946e-02f, 4.70236652e-02f, -8.41860846e-02f, 4.39271666e-02f, -1.24521405e-02f, -3.24282050e-02f,
  1.41103314e-02f, -7.84257874e-02f, -8.89195502e-03f, 5.04685640e-02f, 5.15669808e-02f, 8.61932859e-02f, 7.00510689e-04f, -5.48907556e-02f, -5.05301654e-02f, -3.39850187e-02f,
  1.92971807e-02f, 3.57472934e-02f, 7.63655156e-02f, -5.01075312e-02f, -5.43692382e-03f, -7.40404502e-02f, -2.47635767e-02f, 9.81200114e-03f, -5.40053807e-02f, -7.49716014e-02f,
  -7.66658336e-02f, 2.72765327e-02f, 1.11421831e-02f, 9.18674767e-02f, -2.28007650e-03f, 7.33285397e-02f, -5.21698035e-02f, -5.68053611e-02f, 5.61092189e-03f, 2.72468496e-02f,
  -7.20280409e-02f, 2.74752565e-02f, 1.25698835e-01f, 1.13377357e-02f, 1.34482130e-01f, 1.16774328e-01f, 8.39812458e-02f, 1.36040539e-01f, 1.03968628e-01f, -2.98966710e-02f,
  2.70799994e-02f, 2.84588616e-02f, -3.55245806e-02f, -3.93848009e-02f, 4.09393944e-02f, 6.86410815e-02f, 1.10601053e-01f, -7.51214176e-02f, 7.94784278e-02f, -1.66539997e-02f,
  -4.12906446e-02f, -9.20169652e-02f, -3.43905725e-02f, -5.98186292e-02f, 1.21758729e-02f, -9.51860100e-02f, -7.07342401e-02f, -1.03080519e-01f, -4.96961689e-03f, 6.48589730e-02f,
  -1.42533658e-02f, -4.47241887e-02f, -7.79667944e-02f, -8.19077641e-02f, 3.22272107e-02f, 6.72856495e-02f, -2.58980710e-02f, 5.58647029e-02f, -5.68925515e-02f, 2.47557834e-02f,
  7.05115206e-04f, 5.75997047e-02f, 2.01093666e-02f, 3.46414261e-02f, -2.52746232e-03f, 8.11623484e-02f, 6.82489872e-02f, 5.00738546e-02f, -4.34151478e-02f, 6.78029209e-02f,
  -6.16616197e-02f, 2.96122730e-02f, -3.62730250e-02f, 3.57320607e-02f, -6.90464005e-02f, -1.46531714e-02f, 1.74763873e-02f, 5.57395816e-02f, 6.23760037e-02f, 2.56257299e-02f,
  8.95200223e-02f, 1.68176014e-02f, -4.54941951e-02f, -7.40700811e-02f, -9.35253128e-03f, -4.70655002e-02f, -4.45819162e-02f, -1.09073904e-03f, 8.34837183e-02f, 5.34803383e-02f,
  7.31542334e-02f, 7.81715140e-02f, -5.21189012e-02f, -7.11495429e-02f, -6.79964423e-02f, -4.89037521e-02f, 4.29951176e-02f, -3.84714641e-02f, 3.30370176e-03f, -5.17496699e-03f,
  -4.63994183e-02f, 8.43088552e-02f, 3.14244628e-02f, 3.60792056e-02f, 1.02876186e-01f, 5.34754358e-02f, 5.06661199e-02f, 6.51967749e-02f, 5.31001799e-02f, -6.60871267e-02f,
  3.96294445e-02f, -2.11229082e-02f, -3.80925275e-02f, 1.61444899e-02f, -4.09930851e-03f, -9.12365504e-03f, 4.36329730e-02f, -2.04470437e-02f, 4.44145463e-02f, 6.56334385e-02f,
  8.96592215e-02f, 5.93776442e-02f, 6.79608062e-02f, -5.40930517e-02f, 2.87768692e-02f, -2.60490887e-02f, -7.82968625e-02f, -5.53441122e-02f, -2.65765022e-02f, 7.23537952e-02f,
  5.92231825e-02f, 3.73723991e-02f, -2.03033835e-02f, 7.65609965e-02f, 8.78454372e-02f, 5.10379896e-02f, -1.09446552e-02f, -7.66012594e-02f, -5.38138789e-04f, -1.63516346e-02f,
  5.22906370e-02f, -6.72182962e-02f, -9.54458416e-02f, -2.25840341e-02f, -1.02934323e-01f, -2.23613292e-01f, -2.12051213e-01f, -6.78614229e-02f, -1.73677988e-02f, 6.97760358e-02f,
  -9.34382528e-02f, 4.71603908e-02f, 2.72475719e-03f, -1.97976381e-01f, -8.94385353e-02f, 3.67496312e-02f, -1.85902432e-01f, -1.18716605e-01f, 3.94488685e-03f, -1.06746852e-01f,
  -1.46081736e-02f, -9.28431377e-02f, -8.04565102e-02f, -1.03596628e-01f, -1.37736991e-01f, -5.47649860e-02f, 2.04670243e-02f, 2.46506259e-02f, -1.44205704e-01f, -5.29019125e-02f,
  -4.90499549e-02f, 2.94081345e-02f, -5.26199751e-02f, 9.51306149e-03f, -2.88473312e-02f, -8.93667415e-02f, -1.01008844e-02f, 8.09669793e-02f, 9.17655852e-05f, -4.39829901e-02f,
  9.83187705e-02f, -1.53742742e-03f, -1.05008725e-02f, -2.02008858e-02f, -6.38096705e-02f, -2.20771097e-02f, 5.43797053e-02f, -5.21094725e-02f, -8.47154483e-03f, 2.39056610e-02f,
  -1.33025115e-02f, -8.74191746e-02f, -3.67083140e-02f, 1.46512175e-02f, -1.37371384e-02f, 2.15609116e-03f, 7.54107386e-02f, 3.85128036e-02f, -2.24633496e-02f, -3.51881012e-02f,
  2.42556296e-02f, -2.81856842e-02f, -4.70708162e-02f, 9.10491496e-03f, -1.60900876e-02f, -8.47943425e-02f, -6.90974668e-02f, 1.12420823e-02f, 6.65066764e-02f, -6.38782680e-02f,
  7.14288726e-02f, 7.21702501e-02f, 3.28202769e-02f, 4.38502319e-02f, 4.61519435e-02f, 2.05664728e-02f, -5.01528829e-02f, 3.61968689e-02f, -7.75960609e-02f, 3.00581828e-02f,
  8.66496563e-02f, 5.94956055e-03f, 2.53924429e-02f, -1.96125414e-02f, -1.22434460e-02f, -3.00572086e-02f, -1.56043610e-03f, 3.32515612e-02f, 2.29900666e-02f, -4.69834842e-02f,
  -4.40619327e-02f, 4.69864830e-02f, -2.99958512e-03f, -9.22693498e-03f, -5.26994243e-02f, -4.19909917e-02f, 1.40897753e-02f, 7.33689070e-02f, 4.77038957e-02f, 4.81833657e-03f,
  -1.00980308e-02f, 9.08835679e-02f, 7.44029284e-02f, 1.01183720e-01f, -4.04041596e-02f, -2.41905116e-02f, -4.16445844e-02f, 6.12774603e-02f, 3.87454033e-02f, -5.61690629e-02f,
  -2.19081659e-02f, 7.26118088e-02f, 1.01060703e-01f, 6.13964424e-02f, 8.72913003e-02f, 7.04846233e-02f, -4.34100814e-02f, -1.06779002e-02f, -8.82151886e-04f, 3.87108438e-02f,
  4.36441451e-02f, 7.47808665e-02f, 1.37503728e-01f, 8.93626213e-02f, -1.13891385e-01f, -2.73565769e-01f, -5.27270176e-02f, 1.03446856e-01f, -3.92606966e-02f, 1.28441898e-03f,
  1.22018844e-01f, -1.56245742e-03f, 6.90214932e-02f, 1.09198779e-01f, 5.22002578e-02f, 1.48371921e-03f, -4.74710464e-02f, -4.53195050e-02f, 3.17686945e-02f, 1.50315285e-01f,
  8.41617584e-03f, 4.33301665e-02f, 2.20319554e-01f, 8.07876959e-02f, 1.02665924e-01f, 1.27740234e-01f, 1.49807438e-01f, -4.16611088e-03f, 2.75433026e-02f, 1.19511047e-02f,
  5.01394924e-03f, 1.01076223e-01f, -3.28128412e-02f, -3.27997305e-03f, -5.23494333e-02f, 1.85977493e-03f, -4.26712446e-02f, -3.00734676e-02f, -3.37851830e-02f, 7.66296908e-02f,
  4.53074841e-04f, 7.99321905e-02f, -7.65881166e-02f, -7.85592347e-02f, 5.69570577e-03f, -6.18246906e-02f, 1.10469004e-02f, 6.34856895e-02f, -4.75066975e-02f, -3.33129875e-02f,
  4.55424227e-02f, 7.57605433e-02f, -6.13048032e-04f, 4.92777862e-02f, -2.29384676e-02f, -3.18100229e-02f, -1.49023468e-02f, 9.08373445e-02f, -2.62080263e-02f, -1.29158087e-02f,
  7.09853545e-02f, 1.58564635e-02f, -1.98383424e-02f, -3.44979130e-02f, -5.83030879e-02f, 1.48914838e-02f, -7.43654072e-02f, 6.26727268e-02f, 2.90074032e-02f, 6.42355829e-02f,
  2.66405623e-02f, 4.79959920e-02f, 6.71397075e-02f, -4.62303609e-02f, 8.93667787e-02f, -7.11842701e-02f, 3.59192081e-02f, -6.16718009e-02f, -2.58593597e-02f, 4.70688455e-02f,
  3.89681756e-02f, 2.45967805e-02f, 3.68360654e-02f, 3.80785838e-02f, 4.99154143e-02f, -2.11597197e-02f, 6.19313959e-03f, -4.35070209e-02f, -3.67097333e-02f, -8.01882967e-02f,
  6.89826831e-02f, 2.33663544e-01f, 5.00766225e-02f, -1.18146233e-01f, -5.12391515e-02f, -1.54606057e-02f, -1.75162721e-02f, 7.13366866e-02f, 6.75010234e-02f, -2.74490472e-02f,
  -3.94918919e-02f, -1.02176759e-02f, 5.99993393e-02f, -6.65316284e-02f, 4.51148935e-02f, 6.15946576e-02f, -2.02904902e-02f, 2.13104375e-02f, 1.89853515e-02f, -3.59125100e-02f,
  4.75871377e-02f, 2.17031725e-02f, 4.72427756e-02f, -1.23260990e-01f, 5.98565228e-02f, -1.34228198e-02f, -4.49166298e-02f, -5.21799810e-02f, 1.01912737e-01f, 8.23881328e-02f,
  9.98072848e-02f, -3.60499769e-01f, -9.29447711e-02f, 3.01716588e-02f, 1.85105890e-01f, 9.00885314e-02f, -7.73954540e-02f, 4.81737480e-02f, -6.55707018e-03f, -1.85910791e-01f,
  6.30195960e-02f, -8.08158889e-02f, -2.12067872e-01f, 1.30608425e-01f, 1.04583360e-01f, -6.92217350e-02f, 1.45148620e-01f, -3.63507159e-02f, -1.03414863e-01f, 7.40249921e-03f,
  9.47166979e-02f, 1.82865709e-01f, 3.82646248e-02f, 1.47195801e-01f, 1.48816034e-01f, 6.95025176e-02f, 6.51250705e-02f, -4.20627668e-02f, 9.70566124e-02f, 1.00612983e-01f,
  9.19851810e-02f, -1.91114154e-02f, 4.19480205e-02f, -5.76029159e-02f, -1.09506957e-01f, -7.70446360e-02f, 1.40852835e-02f, 4.89872582e-02f, 6.36569336e-02f, -4.58139144e-02f,
  1.50374637e-03f, 6.74235970e-02f, 9.65548605e-02f, 6.74058273e-02f, -5.23588061e-02f, 8.05932358e-02f, -3.01784482e-02f, -2.30022836e-02f, -2.88593732e-02f, -1.07595503e-01f,
  8.09170213e-03f, -9.88941640e-02f, 1.14787193e-02f, -8.80544074e-03f, 1.59044599e-03f, 6.08938634e-02f, -8.01064596e-02f, -8.05650577e-02f, -1.04978263e-01f, 5.23221083e-02f,
  5.26073128e-02f, 6.86569288e-02f, 3.64480205e-02f, 3.27030867e-02f, -1.01751477e-01f, -1.24790790e-02f, -1.93478875e-02f, -9.70124677e-02f, -5.13153290e-03f, -1.66196339e-02f,
  3.73995639e-02f, 5.29185534e-02f, 4.25236225e-02f, 3.36522050e-02f, 2.40401179e-03f, 7.80526251e-02f, 4.45947386e-02f, 2.21125390e-02f, -1.26711344e-02f, 6.06430136e-02f,
  7.15037733e-02f, 2.52628513e-02f, -5.03122993e-02f, 7.83662200e-02f, -4.67543416e-02f, -2.95115542e-02f, -2.30333558e-03f, -2.74238568e-02f, -1.19248824e-02f, 4.78141084e-02f,
  -4.35200036e-02f, -8.94930661e-02f, 2.22352762e-02f, 8.53559673e-02f, -9.09616239e-03f, -1.10455200e-01f, 2.88270954e-02f, 4.44241054e-02f, 1.56552829e-02f, -9.04004052e-02f,
  6.06464483e-02f, 2.46300250e-02f, 2.99791172e-02f, -3.83090694e-04f, 1.13276780e-01f, -1.64748356e-02f, -2.07141452e-02f, -7.35859349e-02f, 3.73151875e-03f, 3.27083357e-02f,
  1.54682053e-02f, -1.23696074e-01f, -2.84001920e-02f, -4.81916554e-02f, -6.52253032e-02f, -2.28222292e-02f, 4.44518290e-02f, -4.49465699e-02f, -5.05362637e-03f, -1.19410595e-02f,
  -7.48311821e-03f, 5.89627437e-02f, -8.87141600e-02f, -1.59169674e-01f, 4.92326915e-03f, -2.54406538e-02f, -1.75988138e-01f, 5.24481311e-02f, -8.43585506e-02f, -5.35259023e-02f,
  -9.36034471e-02f, 2.55267508e-02f, -1.34254014e-02f, -1.83133811e-01f, 5.77976778e-02f, 1.60517842e-02f, -7.47173745e-03f, -7.15448931e-02f, -5.24507947e-02f, -9.58707035e-02f,
  -1.57729536e-02f, -6.36601001e-02f, 5.45412041e-02f, 1.67759117e-02f, -1.03501566e-01f, 2.41729314e-04f, -1.18033169e-02f, -2.56509893e-02f, -3.12613621e-02f, -2.79982202e-02f,
  -1.03630304e-01f, -1.15298547e-01f, -5.76111488e-02f, 2.18172744e-02f, -3.88241746e-02f, -5.29864691e-02f, -8.86935368e-02f, 8.11895207e-02f, -7.94737935e-02f, 1.88462425e-03f,
  7.07527176e-02f, 4.06580493e-02f, -8.64700153e-02f, 7.24544972e-02f, 2.72506457e-02f, 2.05703136e-02f, -4.23661396e-02f, 5.44609204e-02f, 7.75624290e-02f, -9.32449661e-03f,
  4.77334484e-02f, 8.59979764e-02f, 2.05776822e-02f, 2.04801057e-02f, 3.30625102e-02f, 4.77514900e-02f, -3.75117734e-02f, -7.41769373e-02f, -7.12707415e-02f, 7.51229525e-02f,
  -4.76111472e-03f, 5.65175079e-02f, -6.07689656e-02f, 5.01856674e-03f, -1.01217330e-01f, 3.61056440e-02f, -3.33466977e-02f, 3.51712294e-02f, 4.47770879e-02f, 3.58116366e-02f,
  1.70377642e-02f, 3.42097208e-02f, -7.10811652e-03f, 4.06752788e-02f, 5.76526970e-02f, 4.57294211e-02f, -1.38766337e-02f, 3.96439731e-02f, 7.42262006e-02f, 2.71936581e-02f,
  5.81414551e-02f, 4.73414585e-02f, -8.06446970e-02f, 7.44068101e-02f, 2.44026054e-02f, 4.61432524e-02f, 5.95757104e-02f, 5.82678504e-02f, 1.86977759e-02f, 3.34488563e-02f,
  5.03325723e-02f, -1.10657897e-03f, -9.83683113e-03f, 3.23140211e-02f, -5.79933487e-02f, -1.35839265e-02f, -3.53630520e-02f, -2.63277963e-02f, -6.34480268e-02f, 6.93000257e-02f,
  -6.63474128e-02f, -3.07271257e-02f, 4.64118123e-02f, -7.82778636e-02f, -5.16163073e-02f, -5.29375710e-02f, -8.63217190e-03f, 1.89636722e-02f, 2.84665339e-02f, -3.66988801e-03f,
  -5.37481345e-02f, 5.96304238e-02f, 6.71962425e-02f, 2.69230362e-02f, 1.64587777e-02f, 4.07219445e-03f, -2.65031122e-02f, 2.49855313e-02f, 8.96780714e-02f, -1.74189601e-02f,
  -1.35207519e-01f, -5.10376925e-03f, -4.33212699e-04f, 1.05400592e-01f, -6.55716062e-02f, 4.38851453e-02f, 1.80091783e-02f, -1.70011111e-02f, 1.37796775e-01f, 7.66961351e-02f,
  5.51464707e-02f, 4.00496237e-02f, -4.97848988e-02f, 4.27917279e-02f, -1.15941294e-01f, 8.05076435e-02f, 1.73271358e-01f, 1.24901563e-01f, -3.28222476e-03f, 6.45470247e-02f,
  -7.96606392e-02f, 2.75933221e-02f, 3.65437046e-02f, -4.07841094e-02f, -8.31422582e-03f, -8.07230473e-02f, -7.14841560e-02f, -1.17726803e-01f, -4.77887467e-02f, -2.99764033e-02f,
  8.86777416e-02f, -1.31362686e-02f, -2.08486188e-02f, -7.21047968e-02f, -7.77429296e-03f, -2.59349328e-02f, -6.91928715e-02f, -7.86700249e-02f, 3.65728885e-02f, 1.32188182e-02f,
  -7.55242556e-02f, -3.64048779e-02f, -6.63294047e-02f, -1.46444077e-02f, -2.80404687e-02f, 1.34432232e-02f, 8.06875229e-02f, -7.58167207e-02f, 5.14092669e-02f, -2.93192510e-02f,
  -5.91736585e-02f, -6.57748152e-03f, 7.75818005e-02f, 5.44367507e-02f, -4.30255011e-02f, -2.19218321e-02f, -5.05907573e-02f, 3.51184756e-02f, 5.39190322e-02f, -5.39565422e-02f,
  -5.24168322e-03f, -5.33139259e-02f, 2.71090101e-02f, -6.60512000e-02f, 4.17291522e-02f, 5.68426214e-02f, 8.69530216e-02f, 4.18352187e-02f, -3.25264083e-03f, -6.32405281e-03f,
  -2.80849487e-02f, 5.33954650e-02f, -7.04650506e-02f, -3.01383696e-02f, 1.21776639e-02f, -1.88944899e-02f, -6.24071918e-02f, -7.63454139e-02f, 5.41190356e-02f, 6.72505572e-02f,
  -1.49618331e-02f, -8.32196623e-02f, 1.85843613e-02f, -1.32275540e-02f, 2.82135680e-02f, 3.31761166e-02f, 3.76968198e-02f, 5.68119287e-02f, 7.56331235e-02f, 4.72215153e-02f,
  2.40146071e-02f, -5.51697426e-02f, 3.21644433e-02f, -2.41668671e-02f, -2.26276852e-02f, 2.11370047e-02f, -4.18746695e-02f, -5.93205281e-02f, 1.90989543e-02f, 2.52414197e-02f,
  -5.38631603e-02f, 7.89644346e-02f, 5.85629456e-02f, 1.39857316e-02f, 6.97242618e-02f, 1.04940072e-01f, -6.35115802e-02f, 7.73344114e-02f, -3.83813716e-02f, -5.15684262e-02f,
  -6.46357834e-02f, 4.19104584e-02f, 5.28543070e-02f, -6.68869540e-02f, 7.60139823e-02f, 7.31779411e-02f, -2.12764479e-02f, 5.39894551e-02f, -8.75247419e-02f, 2.48525143e-02f,
  -3.33191501e-03f, 5.86094931e-02f, 2.41047572e-02f, 2.20628325e-02f, -6.78836480e-02f, -5.70361502e-02f, -8.86088088e-02f, -2.04045251e-02f, 5.11882221e-03f, 2.91063674e-02f,
  -2.76428331e-02f, 7.34000728e-02f, -3.55158523e-02f, 4.53346223e-02f, 1.82065368e-02f, -1.12805374e-01f, 8.76162648e-02f, -4.04750519e-02f, -2.00283900e-02f, 5.64259514e-02f,
  2.37642732e-02f, 9.69877988e-02f, 9.70887840e-02f, 5.26359258e-03f, 5.96527159e-02f, 1.21232681e-01f, 3.58937681e-02f, 6.11595996e-02f, 3.20479907e-02f, 1.03002995e-01f,
  -5.38819060e-02f, -1.60254706e-02f, -7.82044083e-02f, 2.60889959e-02f, 3.83936092e-02f, -1.08444355e-02f, 5.56085594e-02f, 5.34814745e-02f, -5.47390245e-03f, -3.26940306e-02f,
  -4.25787382e-02f, 5.83849847e-03f, -8.12290534e-02f, 8.35302379e-03f, 2.51312833e-02f, 3.62971835e-02f, -6.42575622e-02f, -1.85662527e-02f, 5.04732579e-02f, -3.37025449e-02f,
  -6.28135502e-02f, -8.28363374e-02f, 5.44069633e-02f, 2.74611171e-04f, 4.84100282e-02f, 6.63190335e-02f, 7.40773305e-02f, -6.29651845e-02f, 2.53350008e-02f, -9.25830100e-03f,
  -5.80665618e-02f, -4.63223457e-03f, 2.11347565e-02f, -9.34921056e-02f, -2.02979222e-02f, 3.98783796e-02f, -7.78390514e-03f, 8.40227827e-02f, -5.73717728e-02f, -5.82792424e-02f,
  -3.81021127e-02f, -4.38052975e-02f, 3.82860936e-02f, 6.09649047e-02f, 8.04112777e-02f, 6.73223883e-02f, 9.46333632e-02f, 4.83400328e-03f, 4.52691540e-02f, -5.88179417e-02f,
  -7.73714781e-02f, 6.67830035e-02f, 6.31383881e-02f, 7.30305836e-02f, 1.18522076e-02f, 5.52924909e-02f, -6.85609058e-02f, -7.37218410e-02f, 3.83696891e-02f, 4.92571108e-02f,
  -2.71322075e-02f, 2.42260266e-02f, 1.87499523e-02f, -9.22468156e-02f, -2.34956276e-02f, 6.50446042e-02f, 8.72290134e-02f, -1.61339790e-02f, -6.79601729e-02f, 1.95785426e-02f,
  -3.20146605e-02f, 1.23973121e-03f, 3.39398161e-02f, -7.77029544e-02f, -5.58001809e-02f, 7.52531365e-02f, 8.77982602e-02f, -6.42017201e-02f, -5.04578762e-02f, -3.09348851e-02f,
  6.26062155e-02f, 6.71545416e-02f, -1.27319992e-02f, 5.58256619e-02f, -2.05456577e-02f, 4.75317985e-02f, -8.59989524e-02f, 9.23300833e-02f, -4.82127406e-02f, 1.90188587e-02f,
  -2.30873257e-01f, 2.14918807e-01f, 6.24595210e-02f, -3.01444884e-02f, 4.65762280e-02f, 2.99976673e-03f, -7.49392137e-02f, 1.12023063e-01f, 1.44903407e-01f, 9.30677727e-02f,
  3.47910188e-02f, -1.37378260e-01f, 8.90669450e-02f, 6.77214116e-02f, 9.22970325e-02f, 1.60692990e-01f, 1.81212388e-02f, -5.10408506e-02f, 1.24009110e-01f, 4.53542471e-02f,
  1.12917759e-01f, 6.99494556e-02f, 1.58107102e-01f, 5.51925190e-02f, -7.17036352e-02f, -8.27877074e-02f, -5.21907099e-02f, 9.69954729e-02f, 2.50059348e-02f, 7.07432404e-02f,
  -8.16880018e-02f, -4.87512723e-02f, -5.29886596e-02f, -2.57501435e-02f, 9.32469517e-02f, -1.48619190e-01f, 1.17206502e-04f, 1.80459283e-02f, -8.43094885e-02f, 4.88294335e-03f,
  -8.09044167e-02f, 2.34416383e-03f, 2.51200832e-02f, -2.04875078e-02f, -4.89160791e-03f, 8.60094652e-02f, 1.62477493e-02f, 9.23124328e-03f, 4.98926938e-02f, 3.55999805e-02f,
  -3.39301974e-02f, 2.75893826e-02f, -8.07795823e-02f, 5.00885248e-02f, -8.42724647e-03f, 2.12180838e-02f, -3.08298916e-02f, -7.07753971e-02f, 1.72561277e-02f, 2.76306961e-02f,
  1.70738846e-02f, 5.89613542e-02f, 4.46817502e-02f, 6.08994365e-02f, 6.64550066e-02f, -2.18467116e-02f, -6.91846311e-02f, -2.26823203e-02f, -5.91033734e-02f, -8.59830827e-02f,
  3.72073911e-02f, 2.23548894e-04f, 1.23842005e-02f, -5.81809469e-02f, -9.85371228e-03f, 6.49493933e-02f, 1.13101937e-02f, 4.00117673e-02f, 1.60224196e-02f, 4.50786762e-02f,
  -1.04596606e-02f, 3.84758785e-02f, 2.22859774e-02f, -8.60193670e-02f, 2.71675754e-02f, -8.86373594e-02f, 9.57822874e-02f, -4.02749777e-02f, -4.84544504e-03f, -8.56671408e-02f,
  -4.55660671e-02f, 1.91232860e-01f, 7.84590617e-02f, 2.47626361e-02f, 7.42723420e-02f, 6.21467568e-02f, -1.08537404e-02f, -9.40743312e-02f, 1.88782085e-02f, 4.81899418e-02f,
  6.45651370e-02f, 5.97226694e-02f, -1.17761567e-02f, -5.70316724e-02f, 5.05633354e-02f, 5.12867421e-02f, 5.56958430e-02f, 9.03670937e-02f, 2.91024875e-02f, -7.95987528e-03f,
  4.57734726e-02f, 5.08609526e-02f, -5.66004328e-02f, 5.04373685e-02f, -7.73765193e-03f, -7.09329322e-02f, 1.42750507e-02f, 1.80117916e-02f, 3.27706616e-03f, -4.54098685e-03f,
  -7.30528086e-02f, 2.02118102e-02f, 3.88579108e-02f, -4.00260836e-02f, 5.69177903e-02f, 8.35259557e-02f, -9.83231440e-02f, -6.45710528e-02f, -1.48995757e-01f, -5.12275957e-02f,
  -5.55659495e-02f, -7.96598122e-02f, 1.42551623e-02f, 4.27938513e-02f, 1.22691639e-01f, 5.22480272e-02f, 1.29412845e-01f, 1.14717409e-01f, 4.21890281e-02f, 2.73973066e-02f,
  7.97818601e-02f, 8.49064738e-02f, 1.73287392e-02f, 1.69616207e-01f, 3.18904035e-02f, 9.88017544e-02f, -3.05200778e-02f, -4.57221493e-02f, 1.70670301e-01f, 6.46008104e-02f,
  -3.20125148e-02f, 5.97519614e-02f, 9.43241417e-02f, 1.08732961e-01f, 6.16374314e-02f, 6.36741295e-02f, 1.37024522e-02f, 2.90010665e-02f, -5.60212433e-02f, -2.84050684e-02f,
  -3.77217680e-02f, 3.82217355e-02f, 7.13327974e-02f, -6.82699680e-02f, -2.58007515e-02f, 5.47784455e-02f, 2.08372585e-02f, -5.03495261e-02f, 5.58006763e-02f, 8.40699077e-02f,
  3.25468183e-02f, -6.17327653e-02f, -1.56947058e-02f, -1.80031545e-02f, 6.44745380e-02f, -7.34603480e-02f, 7.08931759e-02f, -1.02392524e-01f, 8.28845352e-02f, -3.93851282e-04f,
  6.51804432e-02f, -3.49419042e-02f, -3.83116752e-02f, 2.87642013e-02f, -5.97661734e-03f, -2.33739112e-02f, 1.81118883e-02f, -1.99768431e-02f, 3.39772403e-02f, 1.51566267e-02f,
  5.54637089e-02f, -5.09579759e-03f, -5.16406968e-02f, -2.40843203e-02f, 5.02872802e-02f, -5.82008027e-02f, 3.99221480e-02f, 2.60636248e-02f, 4.29784022e-02f, 7.10047409e-02f,
  -5.08564226e-02f, -8.37939680e-02f, 6.32047057e-02f, 2.84376517e-02f, 6.18209131e-02f, 2.73950920e-02f, -5.41280396e-02f, 4.29822307e-04f, -1.47012752e-02f, 2.79025808e-02f,
  1.98209789e-02f, -5.02207375e-04f, 2.55139116e-02f, 7.52122561e-03f, -8.76885932e-03f, 7.98154846e-02f, 1.78645109e-03f, 9.59720165e-02f, 3.03245168e-02f, -6.49162605e-02f,
  1.97024643e-02f, -1.61926840e-02f, -1.88133139e-02f, 1.13407612e-01f, 7.85540044e-02f, 1.45150637e-02f, 4.50941846e-02f, 7.55751655e-02f, 4.81082760e-02f, 5.99762388e-02f,
  -6.85305223e-02f, -2.23551970e-03f, 6.52711615e-02f, 4.97258566e-02f, 3.50167751e-02f, -9.48953815e-03f, 7.45197088e-02f, -7.71185849e-03f, -1.01236543e-02f, -7.96389654e-02f,
  2.24765807e-01f, -2.29699627e-01f, -1.57358557e-01f, -1.04631316e-02f, 8.41834471e-02f, 1.51805699e-01f, 8.24885517e-02f, -5.55281937e-02f, -2.28508487e-01f, -5.57382219e-02f,
  9.70270634e-02f, 2.16482673e-02f, -1.05352320e-01f, 1.39506057e-01f, 2.25199878e-01f, -1.11581840e-01f, 9.48151046e-06f, 6.11574017e-03f, -1.13648199e-01f, -8.99133533e-02f,
  -1.03015173e-02f, 8.14358220e-02f, -5.74055091e-02f, 1.45062367e-02f, 1.46890819e-01f, -1.07494384e-01f, 2.95915920e-02f, 2.39569903e-03f, 9.07908902e-02f, 1.24329075e-01f,
  2.93108262e-03f, -2.89770756e-02f, -9.74769890e-02f, -2.54130308e-02f, -2.57139336e-02f, 3.24425288e-02f, 6.96850941e-02f, 1.29330114e-01f, -3.24142575e-02f, -6.91939669e-04f,
  1.13753835e-02f, -1.77148134e-02f, 3.87269482e-02f, 7.06315637e-02f, 1.01862457e-02f, -5.64013310e-02f, 2.65265908e-02f, -7.54333287e-02f, 1.90161390e-03f, 1.80255121e-03f,
  4.14439756e-03f, 6.80646822e-02f, -2.65768351e-04f, 1.47348633e-02f, -8.50244761e-02f, -2.77690496e-02f, 2.68110633e-02f, -6.58397423e-03f, 5.01296064e-03f, -4.31913659e-02f,
  2.00102869e-02f, 7.79768080e-02f, 1.38592971e-02f, 5.00570983e-02f, 2.98227966e-02f, -9.53221880e-03f, 7.29555041e-02f, -4.99755591e-02f, -4.15034890e-02f, -2.33337581e-02f,
  -1.70303620e-02f, -7.49885067e-02f, -2.10522348e-03f, -8.57931003e-02f, -2.74990145e-02f, 2.55093202e-02f, 9.79952291e-02f, -3.45713571e-02f, -1.03272714e-01f, 4.27591987e-02f,
  -8.21558908e-02f, 1.03050424e-02f, 2.76916288e-02f, -5.04476242e-02f, 6.35220483e-02f, -8.53122771e-02f, -2.18704361e-02f, -4.25810181e-02f, -8.39810595e-02f, -5.20298779e-02f,
  8.87824371e-02f, -1.47253916e-01f, -1.06288185e-02f, -1.76359657e-02f, -1.01552181e-01f, 8.95061269e-02f, -1.49848722e-02f, -4.44502793e-02f, -8.42983555e-03f, -5.53714558e-02f,
  3.99238337e-03f, 1.87709071e-02f, -6.98716864e-02f, 5.05319098e-03f, -5.34861013e-02f, -1.28838066e-02f, -1.94223057e-02f, -9.85342823e-03f, -6.19958974e-02f, -4.79918644e-02f,
  2.83245333e-02f, 4.90906872e-02f, -1.50019573e-02f, 6.10833280e-02f, 4.98597650e-03f, -6.53145760e-02f, 3.66395563e-02f, -4.91277277e-02f, 4.06422056e-02f, 2.99312435e-02f,
  -5.09509705e-02f, -8.28251317e-02f, 9.24638752e-03f, 8.17817226e-02f, -3.34076546e-02f, 2.51916759e-02f, -1.14830188e-01f, -9.50623229e-02f, -2.59503871e-02f, -2.47111619e-02f,
  -3.77856530e-02f, 5.27880490e-02f, -8.32232013e-02f, 1.13560632e-01f, 2.19803620e-02f, -7.12911114e-02f, -3.14323865e-02f, -6.39877319e-02f, 3.37341987e-02f, 3.78491059e-02f,
  1.11336082e-01f, 2.17716265e-02f, 5.01606017e-02f, -3.55403163e-02f, -2.24892143e-02f, 4.89306077e-02f, -6.27544001e-02f, -7.57720247e-02f, 3.17022130e-02f, 2.80229673e-02f,
  3.07817906e-02f, -4.38152142e-02f, 4.97651733e-02f, 4.08655889e-02f, 6.79790378e-02f, -8.98809209e-02f, -7.87679181e-02f, 4.27854806e-02f, -5.79709224e-02f, -5.18662222e-02f,
  1.18762404e-02f, 2.60873821e-05f, 7.00760484e-02f, 1.35963438e-02f, -4.38093729e-02f, 1.32812292e-03f, 1.02113895e-01f, -5.36076576e-02f, 3.49305943e-02f, -2.49225646e-02f,
  2.80244034e-02f, 1.90077238e-02f, -2.47500394e-03f, -2.18332484e-02f, 4.91065113e-03f, -3.73674877e-04f, -3.60485837e-02f, 1.99305383e-03f, -1.11912889e-02f, 3.07865739e-02f,
  3.84273715e-02f, 3.19310948e-02f, 3.24716419e-02f, 4.50344291e-03f, 7.21927062e-02f, -3.53465565e-02f, -1.08293658e-02f, 4.03986983e-02f, -6.35688901e-02f, 2.16752402e-02f,
  -8.92949104e-03f, 5.36301509e-02f, -7.96610862e-02f, -7.08815232e-02f, 6.67817593e-02f, -1.55177724e-03f, -8.71072039e-02f, 4.35808720e-03f, -5.50137274e-02f, 6.84436783e-02f,
  -4.05050032e-02f, 5.45694306e-03f, -3.93327475e-02f, -6.47523552e-02f, 6.10284731e-02f, -5.66649903e-03f, 3.75928842e-02f, 6.91778287e-02f, 1.00392118e-01f, -4.72341105e-03f,
  -2.46499293e-02f, 4.07368410e-03f, 9.60207265e-03f, 4.74409014e-03f, -5.61866388e-02f, 7.05178976e-02f, 1.54929236e-02f, 3.81509028e-02f, -8.40613712e-03f, 4.70437594e-02f,
  8.43906030e-02f, 4.60512713e-02f, -7.67378435e-02f, -5.92207536e-02f, -5.06579839e-02f, -7.18056187e-02f, 6.52745515e-02f, -2.88389251e-03f, 7.58875459e-02f, -3.56554203e-02f,
  2.97299642e-02f, 6.38655722e-02f, -3.90352197e-02f, 5.52726574e-02f, 7.67035484e-02f, 4.98515181e-03f, 6.01225998e-03f, -6.42880723e-02f, 2.97972914e-02f, 4.35245074e-02f,
  -8.78347307e-02f, -1.73106685e-01f, 7.95232281e-02f, -2.70407405e-02f, 1.29454300e-01f, -6.46441127e-04f, 1.10171258e-01f, -7.37734605e-03f, -1.22014195e-01f, -5.51554859e-02f,
  3.82711552e-02f, 3.49230841e-02f, 6.73859799e-03f, -4.08473499e-02f, 1.20272361e-01f, -1.06362894e-01f, -6.74527958e-02f, 2.08239304e-03f, -2.55758986e-02f, -8.87358412e-02f,
  3.90525497e-02f, 7.52449781e-02f, 2.22218130e-02f, 1.34543504e-03f, -5.47281839e-02f, 1.85354482e-02f, 1.81939546e-02f, 1.26885056e-01f, -1.88032668e-02f, 5.04789762e-02f,
  3.53117771e-02f, 2.50197574e-02f, 6.81329099e-03f, 4.55249660e-02f, -6.02567196e-02f, 4.10825126e-02f, -3.27400640e-02f, -3.32458355e-02f, -3.92920747e-02f, 1.68896113e-02f,
  8.46089497e-02f, -6.03802353e-02f, -3.93012129e-02f, -6.51310012e-02f, 4.50001238e-03f, -2.24758759e-02f, -6.09123893e-02f, 2.63532833e-03f, -5.94824627e-02f, -1.27140793e-03f,
  -4.99056242e-02f, 7.32575357e-03f, -6.46350086e-02f, 3.13013010e-02f, -7.03690052e-02f, 3.84004861e-02f, -4.43551615e-02f, 8.58137533e-02f, 8.78267922e-04f, 7.03054294e-02f,
  5.29694781e-02f, 4.42332625e-02f, -5.62991463e-02f, -3.92686389e-03f, -1.51944589e-02f, 3.19625102e-02f, -4.11803164e-02f, 4.25805598e-02f, -1.06471665e-02f, -2.13505141e-02f,
  -7.98892751e-02f, -4.41498049e-02f, -2.73663569e-02f, 8.21262002e-02f, -2.05236971e-02f, -9.43048969e-02f, -2.65618004e-02f, -4.34674881e-02f, 6.99563920e-02f, -6.33875653e-02f,
  -7.77920559e-02f, 4.49473783e-02f, 7.36602992e-02f, -2.43746340e-02f, 4.38366830e-02f, -7.15872273e-02f, -7.04891011e-02f, -4.67908569e-02f, 2.99805924e-02f, 1.01843752e-01f,
  -2.16834825e-02f, -2.76968889e-02f, 2.42093112e-02f, -6.74277246e-02f, 1.04200847e-01f, -1.06994773e-03f, 4.40737270e-02f, 5.38117737e-02f, 7.87507463e-03f, -7.65518397e-02f,
  -3.74252610e-02f, 6.81542307e-02f, -9.41212382e-03f, -7.75952637e-02f, 1.94966849e-02f, -9.15476587e-03f, -3.19320485e-02f, -2.90274005e-02f, 8.12497959e-02f, -5.98094538e-02f,
  6.62014708e-02f, -2.97099687e-02f, 2.52138171e-02f, -9.83503833e-02f, 7.26178885e-02f, 1.08080752e-01f, 5.28304949e-02f, 1.97599959e-02f, -3.11716516e-02f, -4.22769226e-02f,
  -4.63066623e-02f, -4.62784842e-02f, 1.89276576e-01f, -8.19281712e-02f, 4.62740138e-02f, 1.46909691e-02f, 5.64308986e-02f, 7.50125051e-02f, -1.11363716e-01f, -1.20809656e-02f,
  -5.56283779e-02f, -1.94053072e-02f, 1.28579900e-01f, -1.14729680e-01f, 1.02634788e-01f, 6.91923499e-02f, -3.50391902e-02f, -7.23629594e-02f, 9.60480347e-02f, 4.09989767e-02f,
  -3.04272231e-02f, 4.02633138e-02f, 4.48541865e-02f, -6.22723661e-02f, 8.42078123e-03f, -5.24408780e-02f, -1.01793967e-01f, -1.42996684e-02f, 3.96727510e-02f, 5.02840951e-02f,
  -3.36867496e-02f, -6.52614310e-02f, -1.34923793e-02f, 9.99178141e-02f, 4.33689021e-02f, -4.76009920e-02f, 5.39268665e-02f, -2.41428092e-02f, 4.95672747e-02f, -2.29131503e-04f,
  -6.00501224e-02f, 6.69019148e-02f, 2.47669425e-02f, 7.30005577e-02f, -6.88752234e-02f, -2.89553534e-02f, 5.18312864e-02f, 6.13885280e-03f, 4.61834541e-04f, 1.47562604e-02f,
  3.11266128e-02f, -6.81654513e-02f, 7.31359888e-03f, -1.78174581e-02f, -6.74929172e-02f, 5.67068197e-02f, -5.16519286e-02f, 7.78387561e-02f, -7.49718100e-02f, -2.17658300e-02f,
  -7.47812465e-02f, 5.56791499e-02f, -3.02662561e-03f, -5.97642846e-02f, -5.61917275e-02f, 6.71779811e-02f, 1.20807032e-04f, 3.60070728e-02f, 3.32141891e-02f, -3.91205363e-02f,
  6.45664930e-02f, 5.95439151e-02f, -9.33958888e-02f, -6.87252209e-02f, -1.57048274e-02f, 5.57138510e-02f, 2.88903713e-02f, -5.40882722e-02f, -8.98108482e-02f, 1.04516987e-02f,
  -9.93902758e-02f, 5.87015934e-02f, 4.68913317e-02f, 5.87059110e-02f, -4.13232744e-02f, -6.41775653e-02f, 3.61281149e-02f, 1.29934482e-03f, -2.38150209e-02f, 7.06085414e-02f,
  4.03819382e-02f, 1.27302483e-02f, 6.73394427e-02f, 5.34655862e-02f, -6.01601116e-02f, 7.06057474e-02f, 6.34149909e-02f, -9.72263794e-03f, 2.29545054e-03f, 7.90624917e-02f,
  6.29274622e-02f, 9.81673971e-03f, -4.63188440e-02f, 6.76264986e-02f, -2.44625919e-02f, 3.97708900e-02f, -1.51589727e-02f, -8.26250911e-02f, -3.31954807e-02f, -2.27181762e-02f,
  9.27313119e-02f, -1.21868681e-03f, 5.04184999e-02f, -4.98583503e-02f, 6.72204942e-02f, -6.39782334e-03f, -5.76319508e-02f, 7.64707774e-02f, 2.81004459e-02f, 2.45086886e-02f,
  1.14905588e-01f, -6.46827742e-03f, 5.06220832e-02f, 1.05750941e-01f, -5.95052056e-02f, -8.69034305e-02f, 6.88872635e-02f, -5.28832115e-02f, 1.41801173e-02f, -4.22681570e-02f,
  -2.50685941e-02f, -3.10007147e-02f, -4.49947119e-02f, 1.51350908e-03f, 1.01482375e-02f, 2.27548853e-02f, -2.24315338e-02f, 9.59441289e-02f, -3.13655101e-02f, 3.34242508e-02f,
  1.09120019e-01f, -4.17556949e-02f, 2.19167899e-02f, 1.05690040e-01f, -4.59532887e-02f, 5.34531055e-03f, -6.28552884e-02f, -7.92684853e-02f, -8.90560355e-03f, -2.05898006e-02f,
  5.49034476e-02f, 1.17225554e-02f, -2.81016137e-02f, -6.44222088e-03f, -2.03690361e-02f, 4.21910360e-02f, -7.64243156e-02f, -4.96767871e-02f, 5.01091592e-02f, -1.58583038e-02f,
  -7.06237033e-02f, -5.80767542e-02f, 1.69446152e-02f, 8.11300520e-03f, 1.42830014e-02f, 8.14916939e-02f, 9.39665064e-02f, -2.23293863e-02f, 7.58454874e-02f, 6.66417331e-02f,
  4.75786664e-02f, 3.42978537e-02f, -8.11870918e-02f, -7.31916279e-02f, 1.09824557e-02f, 4.85595688e-02f, -3.10765840e-02f, -7.08223060e-02f, 4.71664332e-02f, 7.27898106e-02f,
  -1.07632997e-03f, -2.30620112e-02f, 3.12668607e-02f, 5.09634316e-02f, 6.93385676e-02f, 1.96279329e-03f, 3.70287448e-02f, 5.41784465e-02f, 4.21574060e-03f, 8.26946422e-02f,
  1.15522016e-02f, -6.06322894e-03f, -4.70713899e-02f, -7.05075217e-03f, -4.21634726e-02f, 8.39375257e-02f, 1.40263960e-02f, 2.88149063e-03f, 6.29735589e-02f, 8.85220021e-02f,
  -5.24371630e-03f, 4.62313481e-02f, -5.69645129e-02f, -4.34759259e-02f, 3.39411944e-02f, -3.69214341e-02f, -6.84114546e-02f, -1.78488344e-02f, -7.01681972e-02f, 9.10506099e-02f,
  8.56961235e-02f, 2.68456787e-02f, 3.14292423e-02f, -9.68442559e-02f, -2.02430915e-02f, -6.31436855e-02f, 7.42039308e-02f, 9.32301581e-02f, -2.48084273e-02f, 1.73338670e-02f,
  -8.65997374e-02f, -2.85155829e-02f, 4.39662002e-02f, -5.45464456e-02f, -8.99730548e-02f, -8.62169042e-02f, 1.35280034e-02f, 5.49684316e-02f, -2.86820978e-02f, -4.14559292e-03f,
  -6.59294352e-02f, -2.07147580e-02f, -3.37279378e-03f, -3.46643813e-02f, -6.04422353e-02f, 6.93474859e-02f, 6.69400096e-02f, -3.04556917e-02f, -1.03912139e-02f, -4.70831469e-02f,
  1.44584343e-01f, -4.10993099e-02f, -1.52287912e-02f, 1.35539755e-01f, 1.54128283e-01f, 1.06577948e-01f, 9.55366418e-02f, 9.86009836e-02f, 6.73406497e-02f, -1.42277360e-01f,
  -1.33413196e-01f, -7.59044616e-03f, -1.60657987e-01f, 1.72454547e-02f, 1.34198386e-02f, 6.33779168e-02f, 1.04410507e-01f, 2.73732413e-02f, 4.58719209e-02f, -8.70853215e-02f,
  1.22334361e-01f, -3.56660038e-02f, 2.00881660e-02f, -6.47088920e-04f, 5.01040630e-02f, 7.45495185e-02f, -8.66471678e-02f, -8.19385052e-02f, -7.32490048e-02f, 7.83661827e-02f,
  -2.52643675e-02f, 6.07074238e-03f, -7.42792487e-02f, -8.39861631e-02f, 2.80837640e-02f, -6.81414232e-02f, -5.79682700e-02f, -5.07746870e-03f, -4.82539050e-02f, 4.86443900e-02f,
  -3.36328894e-02f, 2.10810900e-02f, -3.67385373e-02f, -8.19198713e-02f, 1.81044396e-02f, 9.38182399e-02f, -4.63945158e-02f, 3.12613323e-03f, 3.39588150e-02f, -1.58798676e-02f,
  -6.11259528e-02f, -6.29316410e-03f, 1.54401187e-03f, -1.37270782e-02f, -6.53702244e-02f, 5.55774420e-02f, -3.39766927e-02f, -6.86864974e-03f, -5.03458781e-03f, -8.25162604e-02f,
  -1.12225473e-01f, 6.00341447e-02f, 2.99098939e-02f, -3.47196609e-02f, 9.67386365e-02f, -2.28770468e-02f, 8.54082778e-03f, -2.45892955e-03f, 7.41699189e-02f, 6.04391545e-02f,
  -7.73074925e-02f, 1.07964044e-02f, 5.78743070e-02f, -5.69457598e-02f, -3.89116406e-02f, 4.59424444e-02f, 5.66491261e-02f, 9.13713947e-02f, 3.55132669e-02f, -3.54469344e-02f,
  -7.45894909e-02f, -3.27941142e-02f, -3.02873901e-03f, -9.39765424e-02f, -3.67263407e-02f, -1.35352165e-02f, 4.34260964e-02f, 8.70803371e-03f, -8.16208217e-03f, -6.39428943e-02f,
  6.68822974e-02f, 2.21916493e-02f, -2.84690242e-02f, -7.94687942e-02f, 2.75150016e-02f, 4.98766974e-02f, 1.09068699e-01f, -9.35481675e-03f, 4.26338241e-02f, -6.40263557e-02f,
  -3.48310545e-02f, 3.87448743e-02f, -5.54601029e-02f, 4.24391888e-02f, -3.68265472e-02f, -7.58438036e-02f, -7.55513459e-02f, -7.28468969e-02f, -9.97982174e-02f, -7.63265043e-02f,
  -4.88779768e-02f, -7.24896565e-02f, -5.85621558e-02f, 3.87420468e-02f, -4.09407988e-02f, -4.83182408e-02f, -1.74803715e-02f, -3.58178206e-02f, 6.20459057e-02f, -4.37887721e-02f,
  7.55420253e-02f, -5.97825982e-02f, -2.09855363e-02f, 9.43363458e-02f, 7.96755478e-02f, -5.95341176e-02f, -1.03364019e-02f, -6.71725571e-02f, -4.09134813e-02f, -1.48527339e-01f,
  5.88508137e-02f, 4.01704386e-02f, 4.08228599e-02f, -2.57379226e-02f, 3.97890024e-02f, 8.02049786e-02f, -6.76637217e-02f, 9.36530828e-02f, 6.87354207e-02f, -5.19767813e-02f,
  7.83192217e-02f, -2.97939703e-02f, 1.28541946e-01f, -1.25863580e-02f, -8.11872184e-02f, -2.94369962e-02f, 1.04576237e-01f, 5.23191653e-02f, -1.82412192e-02f, -1.39015745e-02f,
  -7.04047605e-02f, 4.05869819e-03f, 8.22052732e-02f, 2.95208506e-02f, 2.85381228e-02f, 7.36089945e-02f, -3.46211866e-02f, 1.54902292e-02f, 6.74138516e-02f, -3.26597653e-02f,
  -4.38153632e-02f, 2.45735049e-04f, 6.29670871e-03f, 5.87143116e-02f, -8.57178867e-02f, -4.80949655e-02f, -4.64613251e-02f, -6.81328624e-02f, 1.25270113e-02f, 4.21864986e-02f,
  5.87287582e-02f, 3.08977794e-02f, -2.89573800e-02f, -3.10844257e-02f, -2.49000872e-03f, -4.83595766e-02f, -1.46463318e-02f, -1.99261829e-02f, 8.89161776e-04f, 1.25622768e-02f,
  -5.15452363e-02f, -2.58845948e-02f, -1.83302239e-02f, -1.34272194e-02f, 7.29058124e-03f, -1.39715392e-02f, -4.73361425e-02f, -6.60432726e-02f, -6.26359284e-02f, -1.49359563e-02f,
  2.47032437e-02f, -3.22130471e-02f, 8.10010880e-02f, 6.14350028e-02f, -7.47114345e-02f, 3.21144089e-02f, 1.10476337e-01f, 3.83899957e-02f, 5.21359295e-02f, 7.10676759e-02f,
  4.40755524e-02f, 8.47769156e-02f, -7.79058933e-02f, 7.93765560e-02f, 5.07824384e-02f, -7.51917288e-02f, -6.12308048e-02f, -3.28945294e-02f, 8.55050534e-02f, 6.54301196e-02f,
  5.53299934e-02f, 4.93287928e-02f, -1.72374789e-02f, 8.34271237e-02f, -8.10144097e-02f, 1.10200290e-02f, 7.13841543e-02f, -9.06424075e-02f, 2.77783535e-02f, 5.90892732e-02f,
  -7.80746713e-02f, 2.96431426e-02f, -9.42524672e-02f, 3.73892486e-02f, 1.03597227e-03f, 6.19261116e-02f, -1.61974747e-02f, 5.27911931e-02f, 3.01036257e-02f, -6.30143881e-02f,
  -8.25094208e-02f, 2.36453842e-02f, -1.38926960e-03f, -3.11062429e-02f, -2.65710969e-02f, -4.94879531e-03f, 6.29547238e-02f, 5.45221567e-02f, -5.40524796e-02f, 1.04298824e-02f,
  -4.35260572e-02f, 5.15763126e-02f, -8.56860504e-02f, -7.85541832e-02f, 4.36550342e-02f, -9.41598490e-02f, -5.62806912e-02f, 6.79495633e-02f, -1.30155474e-01f, 1.53264269e-01f,
  -3.22399405e-03f, -5.22290617e-02f, -1.47461779e-02f, -1.06037848e-01f, -1.41440883e-01f, -1.88932922e-02f, -1.13942564e-01f, 5.59841096e-03f, -1.43831428e-02f, 8.18046033e-02f,
  3.39310952e-02f, 5.40951453e-02f, -4.06063460e-02f, -3.91814783e-02f, 4.17201929e-02f, 1.04037538e-01f, 7.16174021e-02f, 5.52772246e-02f, 8.76931101e-02f, -2.10760515e-02f,
  4.92061339e-02f, -2.43845973e-02f, -5.15173376e-02f, -5.21587878e-02f, 3.69348936e-02f, -6.16307894e-04f, 2.51862430e-03f, 2.12082099e-02f, -3.11954785e-02f, 8.10665786e-02f,
  4.54473086e-02f, -3.67001779e-02f, -1.03445956e-02f, 5.01310714e-02f, -1.44326659e-02f, 4.75136004e-02f, -1.03019888e-03f, 3.05029694e-02f, -6.06406853e-02f, 3.37099098e-02f,
  1.60749089e-02f, 4.06558072e-04f, -7.63474181e-02f, 3.43563333e-02f, -2.81075332e-02f, -1.23288957e-02f, 8.64153821e-03f, -1.74005274e-02f, 3.76161672e-02f, -4.08209562e-02f,
  -3.24925296e-02f, 6.07891418e-02f, -3.83684598e-02f, -5.18276170e-02f, -1.40456576e-02f, -3.89058664e-02f, 7.31260329e-02f, -7.36232772e-02f, -9.54116955e-02f, 5.78245819e-02f,
  -7.18364269e-02f, -9.26916450e-02f, -2.50113737e-02f, 7.50329718e-02f, -6.86253458e-02f, -4.66684485e-03f, 7.08292574e-02f, 6.18601069e-02f, -4.14433107e-02f, -3.18738297e-02f,
  -6.27109632e-02f, -4.57628779e-02f, -2.13695057e-02f, 2.42375373e-03f, -1.93410646e-03f, -6.34343252e-02f, -3.77327204e-02f, -3.24148685e-02f, 1.23586571e-02f, -8.24198499e-03f,
  7.14478269e-02f, 1.60263583e-01f, 8.67269188e-03f, -5.38187809e-02f, 5.01572751e-02f, 4.45722863e-02f, -6.31348193e-02f, -5.91396056e-02f, 4.13998589e-02f, 1.39158536e-02f,
  4.70226109e-02f, -8.16403106e-02f, 1.15761198e-01f, -1.62011143e-02f, -6.99065300e-03f, 9.23825949e-02f, 9.12685543e-02f, -5.65819629e-02f, 9.21808109e-02f, -1.54674882e-02f,
  1.38706816e-02f, 3.38382944e-02f, 7.80168781e-03f, -5.46448007e-02f, 8.13221037e-02f, 1.02681085e-01f, 2.80825421e-02f, 7.84344673e-02f, 7.35418499e-02f, 4.50522825e-02f,
  -7.40756691e-02f, -1.02209374e-01f, -1.61142021e-01f, -1.19102255e-01f, -8.91855806e-02f, -1.91519558e-01f, -1.37893885e-01f, -1.32238893e-02f, 4.99852598e-02f, 3.76814902e-02f,
  -3.48158777e-02f, -3.53947207e-02f, 7.61166820e-03f, -1.86961293e-01f, -3.51384506e-02f, 1.21432155e-01f, -1.20805420e-01f, -2.73898966e-03f, -1.02255516e-01f, -9.71284583e-02f,
  5.89496223e-03f, -1.03998013e-01f, -4.85922061e-02f, -1.24838380e-02f, -1.24469370e-01f, -4.13356163e-02f, 1.48293283e-02f, -8.88652653e-02f, -1.44194171e-01f, -3.70207503e-02f,
  -8.84050503e-02f, -5.28294668e-02f, -5.08891717e-02f, -2.67680362e-02f, 3.45638357e-02f, 2.65828278e-02f, -2.27212086e-02f, -7.43317977e-02f, -3.62531058e-02f, -7.21636713e-02f,
  7.34657198e-02f, -2.48235110e-02f, 6.91749007e-02f, 2.75386460e-02f, 7.49262646e-02f, -5.30745648e-02f, -4.45591565e-03f, -1.91146284e-02f, 2.80126929e-02f, -6.02470245e-03f,
  -5.50124124e-02f, -8.32058564e-02f, -2.02132668e-02f, 9.18309689e-02f, -6.68870509e-02f, -3.64690423e-02f, -6.39387518e-02f, -7.32148737e-02f, 7.46917352e-02f, -7.48897493e-02f,
  6.13400638e-02f, -3.47750308e-03f, -4.72162105e-02f, -7.07037002e-02f, -7.43732378e-02f, 7.92682171e-02f, 2.00088508e-02f, 9.96171460e-02f, -6.23109527e-02f, -8.88653006e-03f,
  -5.87404296e-02f, -2.75839698e-02f, -6.01709634e-02f, 1.89394522e-02f, 6.84697926e-02f, 7.38550574e-02f, 6.67669624e-02f, 3.78009640e-02f, -6.25662357e-02f, -1.09815225e-02f,
  -1.53589370e-02f, 5.24668843e-02f, -4.36868146e-02f, -1.45031279e-02f, -2.54529770e-02f, -6.14443161e-02f, -1.34501066e-02f, -6.94637448e-02f, 8.44963938e-02f, 4.67584692e-02f,
  3.35464105e-02f, 9.22547951e-02f, 6.91872612e-02f, 1.89749040e-02f, 1.55989919e-02f, 6.72962070e-02f, -3.56891230e-02f, -8.00418407e-02f, -2.14591753e-02f, -2.75763255e-02f,
  -5.04482128e-02f, 5.83380535e-02f, -3.62691544e-02f, 6.01220615e-02f, -4.54552937e-03f, 5.25273345e-02f, 3.64662483e-02f, 2.22115647e-02f, -7.26303160e-02f, -3.97833847e-02f,
  2.23311391e-02f, -2.17998400e-02f, -3.18474136e-02f, 4.64024134e-02f, -4.26655263e-02f, 3.94790620e-02f, 3.40996906e-02f, 1.26797874e-02f, -5.25254756e-02f, -1.71979442e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  9.03683156e-02f, 1.33559301e-01f, 5.00697270e-02f, -2.82106008e-02f, 1.15825467e-01f, 1.63018808e-01f, -2.18250435e-02f, 6.72852620e-02f, -5.39582670e-02f, -2.23918296e-02f,
  6.03979500e-03f, 1.73954934e-01f, 5.83708696e-02f, 1.15439683e-01f, -5.83997034e-02f, 1.83621541e-01f, 1.04338475e-01f, 9.73966941e-02f, -2.94139422e-02f, -2.76647229e-02f,
  -2.27676518e-02f, -3.49328667e-02f, -1.98518038e-02f, -4.95133325e-02f, -1.14228139e-02f, 7.65630677e-02f
};

// L1_fan_Wp (Shape: 51 x 128)
const int L1_fan_Wp_rows = 51;
const int L1_fan_Wp_cols = 128;
const float L1_fan_Wp_data[] = {
  -7.84473345e-02f, -9.28485468e-02f, -8.81952569e-02f, -6.59720153e-02f, -7.58865401e-02f, -7.06457049e-02f, -9.47257578e-02f, -4.90574688e-02f, -6.19238652e-02f, -5.31992242e-02f,
  -7.60633592e-03f, 3.96410888e-03f, 6.65196180e-02f, -3.89206931e-02f, -2.88529098e-02f, -1.05990097e-01f, 7.52731226e-03f, -9.32828523e-03f, 5.90934185e-03f, -4.25127074e-02f,
  -7.13012889e-02f, 4.76746596e-02f, -4.03409228e-02f, -8.66467413e-03f, 1.31528061e-02f, -1.83069836e-02f, 7.21188337e-02f, -7.57731870e-02f, 4.12109010e-02f, 5.22490554e-02f,
  1.39787402e-02f, 8.78996123e-03f, 4.07473929e-02f, -2.59497203e-02f, -2.12522745e-02f, -1.11555614e-01f, -3.57227735e-02f, -4.07471806e-02f, 2.68809367e-02f, -6.23691678e-02f,
  -5.26197515e-02f, -1.48834344e-02f, -3.35429646e-02f, -9.14591625e-02f, -6.31514788e-02f, 6.75716922e-02f, -4.06754129e-02f, -9.39733833e-02f, 5.49927764e-02f, 6.86450079e-02f,
  3.27573810e-03f, -1.43281445e-01f, 1.38644770e-01f, 1.75848231e-02f, -5.40290996e-02f, 5.59442863e-02f, -2.26673156e-01f, -2.75091305e-02f, -5.87526523e-03f, -1.49050420e-02f,
  3.59474942e-02f, 2.00914741e-01f, -1.52166918e-01f, -1.64881907e-02f, -4.77557108e-02f, 1.40859440e-01f, -1.22205988e-02f, -1.60033386e-02f, 4.09993762e-03f, -4.11311500e-02f,
  1.41580477e-01f, 5.93606420e-02f, -1.16266003e-02f, 8.27257931e-02f, -6.85435683e-02f, 1.33513778e-01f, 1.47574032e-02f, 1.18141480e-01f, 8.99912864e-02f, 1.38607889e-01f,
  1.39207959e-01f, -5.22858799e-02f, 1.76164314e-01f, 3.77966426e-02f, -4.56091166e-02f, 5.67093827e-02f, -5.63592277e-02f, -6.60475716e-02f, 9.68550891e-02f, -1.45706590e-02f,
  2.48834360e-02f, -5.29972017e-02f, -6.99982643e-02f, -4.01493348e-02f, 5.57188727e-02f, 1.34399012e-01f, -4.32465933e-02f, 3.23372781e-02f, 5.35288155e-02f, -5.47908694e-02f,
  4.09953296e-02f, -9.72880721e-02f, 4.39474210e-02f, -7.13256076e-02f, 5.92877232e-02f, 6.91816509e-02f, -1.14317343e-01f, 5.29760942e-02f, 3.76194604e-02f, 4.94783446e-02f,
  2.73868460e-02f, -9.40293148e-02f, 5.37655316e-02f, 6.27040956e-03f, 1.51856458e-02f, -1.74669772e-02f, -1.07681472e-02f, -1.27762690e-01f, -2.32951026e-02f, 9.51112993e-03f,
  -1.51686068e-03f, -2.43498888e-02f, -6.46620095e-02f, 4.08631489e-02f, 2.55436655e-02f, -1.06801711e-01f, 8.10706317e-02f, 5.67451082e-02f, 9.24329739e-03f, 8.43122303e-02f,
  -1.08779119e-02f, -6.29024729e-02f, -7.23754317e-02f, -6.50071055e-02f, -6.86742291e-02f, 2.21426263e-02f, 6.01960570e-02f, -1.84150171e-02f, 3.65977958e-02f, -6.65908009e-02f,
  -4.42794263e-02f, 2.64746919e-02f, -3.28725800e-02f, 2.53535770e-02f, -6.37253048e-03f, 1.84527580e-02f, -7.60593638e-02f, 4.06709313e-02f, -6.69341683e-02f, -3.55688110e-02f,
  8.84245187e-02f, -2.61715818e-02f, -4.27830741e-02f, -6.45397380e-02f, -1.13971569e-02f, -1.01699084e-01f, -2.91583389e-02f, 8.05426314e-02f, -4.74726669e-02f, 2.67672148e-02f,
  -1.86951179e-02f, -1.68679450e-02f, -3.89834009e-02f, 2.72029694e-02f, -9.29873511e-02f, -7.17981905e-02f, 4.77545783e-02f, 5.58588244e-02f, -7.27646723e-02f, 7.49066398e-02f,
  6.99115619e-02f, -7.56614432e-02f, -2.13536564e-02f, -1.08463764e-02f, -1.98864508e-02f, -4.13698815e-02f, 4.11573425e-02f, -2.42821965e-03f, -4.00113948e-02f, -8.84218067e-02f,
  -9.81701985e-02f, 5.62971458e-02f, 1.18027210e-01f, 8.22093040e-02f, -7.23311380e-02f, 2.67437380e-03f, 8.74184966e-02f, 4.53678668e-02f, 8.51507187e-02f, 1.90288145e-02f,
  -9.29023772e-02f, -1.20699555e-02f, -9.76107121e-02f, 1.32429883e-01f, -8.14604685e-02f, -5.52034527e-02f, 6.62926212e-02f, -7.47598633e-02f, 6.17818274e-02f, 6.50597140e-02f,
  5.08311838e-02f, -4.04465608e-02f, -4.66645844e-02f, 1.42609060e-01f, 8.32286179e-02f, -2.25233426e-03f, 7.32100531e-02f, 7.20961764e-02f, 5.72045241e-03f, 9.68241096e-02f,
  1.12749711e-01f, 5.01459055e-02f, -9.25192088e-02f, -1.26373723e-01f, -4.39924654e-03f, 1.60267100e-01f, 1.43429413e-01f, 1.49478778e-01f, 8.95491242e-02f, 5.18550649e-02f,
  5.39999502e-03f, -5.19102663e-02f, 4.26110029e-02f, 1.27212420e-01f, -1.24354586e-01f, -2.02768799e-02f, 1.17799692e-01f, 2.80772918e-03f, 9.42584872e-02f, 1.25968054e-01f,
  -4.85607348e-02f, -1.14178307e-01f, -6.25782982e-02f, 5.02999835e-02f, -4.63737585e-02f, -3.62887941e-02f, -6.32117968e-03f, 5.18256910e-02f, 4.65793908e-02f, -4.62847529e-03f,
  -4.28395718e-02f, -6.94510862e-02f, -9.58778709e-02f, 8.26915056e-02f, 6.89002350e-02f, -3.60541530e-02f, -3.34091149e-02f, 9.19141173e-02f, 8.31017178e-03f, 4.27949391e-02f,
  8.87019634e-02f, -1.78821385e-02f, 3.73676829e-02f, 6.28455952e-02f, -9.49276090e-02f, -9.32316557e-02f, 9.77233145e-03f, 5.64383417e-02f, 4.07682657e-02f, 6.26209676e-02f,
  -1.40708992e-02f, 7.93070421e-02f, 4.44186702e-02f, -5.14773950e-02f, 7.98261091e-02f, 7.36054778e-02f, -1.08322397e-01f, -3.30488570e-02f, 3.48579511e-02f, -1.15654312e-01f,
  5.74995875e-02f, 4.15385328e-02f, 7.52779692e-02f, -1.56973451e-02f, 7.02601224e-02f, 8.52834582e-02f, -1.98491327e-02f, 1.44191897e-02f, 5.06757163e-02f, 7.13516772e-02f,
  -8.60555768e-02f, 7.55640790e-02f, -1.08580217e-01f, 9.40358862e-02f, 9.32745263e-02f, 6.75750524e-02f, 7.06854537e-02f, -7.66297579e-02f, 2.63995342e-02f, -3.58052887e-02f,
  1.53000593e-01f, 8.03054050e-02f, 1.27003491e-01f, 2.25160923e-02f, -4.25244272e-02f, 1.10683911e-01f, -5.67986257e-03f, -8.73500481e-02f, 2.95900088e-02f, -5.48264571e-02f,
  -6.86057135e-02f, -6.96103796e-02f, -8.48721340e-02f, 2.60256194e-02f, 8.88984427e-02f, -2.63408199e-02f, -5.95548339e-02f, 7.26100206e-02f, -2.23008260e-01f, 5.33083826e-02f,
  -6.66222647e-02f, 9.19471979e-02f, 8.65234956e-02f, -1.67340413e-01f, -6.93047717e-02f, -2.73790117e-02f, 4.82363403e-02f, -7.65355229e-02f, 2.63622571e-02f, 6.52257726e-02f,
  -2.42788959e-02f, 3.44659388e-02f, 9.85157937e-02f, 1.06140979e-01f, -1.27655506e-01f, 1.96578875e-02f, -7.38644004e-02f, -1.23313300e-01f, -7.24081472e-02f, 1.30024463e-01f,
  3.39327678e-02f, -1.95464417e-01f, 8.43280926e-02f, 5.86948395e-02f, 1.96490679e-02f, 7.32776821e-02f, -6.90720081e-02f, 1.86278656e-01f, 3.57768908e-02f, -1.05289929e-01f,
  -7.36225620e-02f, 9.62152258e-02f, 3.12936418e-02f, -7.79175386e-02f, -2.24165805e-03f, 4.66749929e-02f, -2.91694216e-02f, -1.37948006e-01f, 1.14553511e-01f, -2.30780691e-02f,
  3.31924558e-02f, -2.11773783e-01f, 2.89167035e-02f, 2.05927253e-01f, -1.47488818e-01f, 1.08078576e-03f, 6.00134097e-02f, -1.88045688e-02f, -8.57531801e-02f, 7.95773715e-02f,
  7.76496083e-02f, 7.57961795e-02f, 1.18088774e-01f, -8.64645652e-03f, -9.62592065e-02f, 5.87756373e-02f, -1.07441261e-01f, 1.45478636e-01f, 2.73102578e-02f, -8.29363894e-03f,
  1.02513552e-01f, 4.88294801e-03f, 2.30868030e-02f, -1.33864600e-02f, 4.48876657e-02f, -1.23903379e-01f, 1.46533996e-02f, 2.71980953e-03f, 9.73581225e-02f, 1.82792377e-02f,
  -8.93748850e-02f, 2.07192618e-02f, 5.54524139e-02f, 7.80471787e-02f, 6.46423325e-02f, 6.18499964e-02f, 7.94544816e-02f, -6.11262992e-02f, -5.57816178e-02f, 1.07726268e-01f,
  -5.28001264e-02f, 5.60952071e-03f, 5.60576953e-02f, 1.27965644e-01f, -2.08085701e-02f, -7.40635470e-02f, 8.13474879e-02f, 3.32608223e-02f, -4.07184996e-02f, 1.18037708e-01f,
  -5.87035418e-02f, 2.08567996e-02f, -5.65170236e-02f, 3.65488306e-02f, -2.49381922e-02f, -1.13372974e-01f, 3.87054421e-02f, -7.43680224e-02f, 6.95066750e-02f, -1.34896981e-02f,
  -1.22054731e-02f, 3.41991857e-02f, 6.06492721e-02f, 9.88794956e-03f, 1.13459773e-01f, -1.54411316e-01f, -1.73524451e-02f, 9.73679498e-02f, 5.23350500e-02f, -3.14739347e-02f,
  -1.92447763e-03f, -2.26841271e-02f, -1.71937943e-02f, 8.34809840e-02f, 1.10905580e-01f, -1.16491513e-02f, 4.74388935e-02f, 3.51657607e-02f, -1.71885919e-02f, -5.93131036e-02f,
  2.66786832e-02f, 2.22798269e-02f, -4.13653813e-03f, -2.27785818e-02f, -1.36681190e-02f, 1.33911088e-01f, -9.80977714e-03f, 2.02782825e-02f, 3.08394502e-03f, 1.21515326e-01f,
  1.82593614e-01f, -1.46282241e-01f, -3.48435552e-03f, 9.15645212e-02f, 4.84010652e-02f, -2.50221074e-01f, 1.56866126e-02f, -3.38196494e-02f, 9.13796946e-02f, -8.09796527e-02f,
  -1.97116584e-02f, 1.30677193e-01f, -6.49952218e-02f, 1.63398474e-01f, -1.86053619e-01f, 1.31185070e-01f, 1.74339563e-02f, 6.45765066e-02f, 1.19321629e-01f, -2.03127768e-02f,
  1.46811694e-01f, -1.93945840e-02f, 3.58626619e-02f, -1.46349177e-01f, -5.99426813e-02f, 5.23055531e-02f, -5.48148938e-02f, -9.24733281e-02f, 3.24463621e-02f, -1.71482209e-02f,
  1.09849930e-01f, -9.30869505e-02f, 1.68966744e-02f, 9.07470062e-02f, 2.03201734e-02f, -4.33644913e-02f, 2.03883007e-01f, 1.43803865e-01f, 3.54397600e-03f, -1.39479548e-01f,
  3.24025191e-02f, -8.66685286e-02f, -3.82097550e-02f, 4.19584624e-02f, 4.97866832e-02f, -5.66476248e-02f, -8.11960176e-02f, 6.89985603e-02f, 7.52835581e-03f, -2.66767037e-03f,
  -3.05391084e-02f, 2.03572005e-01f, -5.33053949e-02f, 1.55936377e-02f, -7.01096430e-02f, -4.44937088e-02f, 8.64323974e-02f, -6.17490299e-02f, -2.51001511e-02f, 7.63007626e-03f,
  -1.46196652e-02f, 6.91688582e-02f, 4.92118709e-02f, -1.32235378e-01f, 1.54101113e-02f, -1.16165332e-01f, -7.92424101e-03f, 4.74326424e-02f, 6.44306988e-02f, -8.31809081e-03f,
  2.88745854e-02f, 3.85569334e-02f, 9.31061879e-02f, -2.69677266e-02f, 7.37041980e-02f, -3.24857160e-02f, -8.92235935e-02f, -7.54431039e-02f, 2.43017692e-02f, 3.86638008e-02f,
  -4.70879152e-02f, 6.13349192e-02f, -3.79544199e-02f, -1.83886364e-02f, -3.81273516e-02f, 6.11935891e-02f, -8.79103243e-02f, 4.51220870e-02f, 1.07004084e-01f, -6.57358915e-02f,
  2.19246536e-03f, 7.77838752e-02f, -7.00559765e-02f, 2.77852714e-02f, -8.58793035e-02f, 8.61428380e-02f, -2.38895994e-02f, 2.93953978e-02f, 5.05017303e-02f, -5.97567372e-02f,
  6.83237314e-02f, 2.75058132e-02f, -6.47454709e-02f, 4.78209332e-02f, -6.71365112e-02f, -5.59536740e-03f, -3.95915285e-02f, 6.73193634e-02f, 2.72512790e-02f, -2.65852939e-02f,
  3.19776987e-03f, 5.13184145e-02f, -9.00575295e-02f, -1.22420201e-02f, -3.73567268e-02f, 5.38486950e-02f, -4.90546301e-02f, 7.45978430e-02f, 8.94473791e-02f, -2.13149264e-02f,
  8.41777772e-03f, 9.85420123e-02f, 1.54163130e-02f, 9.86793190e-02f, -1.54388070e-01f, -4.72776107e-02f, -4.08706293e-02f, -9.05222371e-02f, 1.16521455e-01f, 1.35016561e-01f,
  7.24305511e-02f, 4.93671708e-02f, 8.40898529e-02f, -2.05539793e-01f, 9.92830396e-02f, 1.01385735e-01f, 1.81712255e-01f, -1.02635562e-01f, -2.66749808e-03f, -4.60581519e-02f,
  -1.22451231e-01f, -5.26214987e-02f, -8.50581937e-03f, 5.87800182e-02f, -1.33935004e-01f, -2.07970645e-02f, 4.11477834e-02f, -1.25926539e-01f, 1.08504497e-01f, -1.68294713e-01f,
  -2.63906941e-02f, -7.87725747e-02f, -9.08107758e-02f, 6.82141036e-02f, -8.77499282e-02f, -1.87046677e-01f, 7.38783777e-02f, 2.63664443e-02f, 1.48764048e-02f, -4.33172658e-02f,
  -2.41179615e-02f, 1.08312339e-01f, 4.01807651e-02f, -4.32635918e-02f, 6.22889102e-02f, 1.69890672e-01f, 7.28768110e-03f, -1.37040764e-01f, 1.08537905e-01f, -6.94183558e-02f,
  -1.06081635e-01f, -1.89513750e-02f, 6.28869236e-03f, -4.04498242e-02f, -3.03933341e-02f, 1.08297497e-01f, -3.41734178e-02f, -9.62365940e-02f, 4.37497608e-02f, -9.93816033e-02f,
  3.37106995e-02f, -3.37466486e-02f, -6.54575590e-04f, -8.50448385e-03f, -5.28888926e-02f, -1.05537444e-01f, 8.11346844e-02f, 2.72648558e-02f, -8.12405441e-03f, 1.17825918e-01f,
  -5.33320047e-02f, -4.77100350e-02f, -1.08186603e-01f, -6.51922897e-02f, 1.13195322e-01f, -4.09097672e-02f, -1.91193875e-02f, -5.49209081e-02f, 5.26138321e-02f, 4.76542339e-02f,
  8.72334652e-03f, 2.67354511e-02f, -1.02964848e-01f, 3.83394212e-02f, -3.36233079e-02f, -9.86844972e-02f, -1.76019315e-02f, -8.53670761e-02f, -8.92769694e-02f, 6.49128407e-02f,
  -1.35384500e-01f, 2.57004295e-02f, -7.36567825e-02f, -5.12541644e-02f, 2.14784425e-02f, -4.77745831e-02f, -6.49723932e-02f, 1.91577636e-02f, 1.04518577e-01f, -4.15380597e-02f,
  8.05685073e-02f, 1.01017363e-01f, 3.02360933e-02f, -4.17727306e-02f, 4.32054177e-02f, 5.17085120e-02f, -2.13757064e-02f, -8.09051320e-02f, 3.83381844e-02f, -3.89211290e-02f,
  -5.59344217e-02f, -7.81843625e-03f, 7.73914233e-02f, -5.63247390e-02f, 5.63791357e-02f, 4.37239818e-02f, -1.00030221e-01f, 8.27511996e-02f, 2.24447493e-02f, 2.53351983e-02f,
  4.96537127e-02f, -5.12085930e-02f, 5.69533966e-02f, -2.05927882e-02f, -3.51847485e-02f, 4.84186374e-02f, -1.81979276e-02f, -1.32073835e-02f, 4.06815857e-02f, -3.01070139e-02f,
  4.24495824e-02f, -1.19013436e-01f, -7.04389289e-02f, -6.06970824e-02f, 5.72549440e-02f, -2.33724955e-02f, 1.03125185e-01f, 4.36974876e-03f, 1.11513563e-01f, -2.58250218e-02f,
  8.32167715e-02f, 1.08461201e-01f, -8.63405596e-03f, -1.13029405e-01f, -1.30772948e-01f, 6.42246529e-02f, 5.46936467e-02f, -1.37235954e-01f, 1.70452803e-01f, -1.14462711e-01f,
  9.16020945e-02f, 1.50415152e-02f, -6.25828058e-02f, -4.84854579e-02f, 1.75246429e-02f, 1.11440554e-01f, 3.92187238e-02f, 1.45593777e-01f, 3.65144461e-02f, 1.43547922e-01f,
  -1.47166044e-01f, 9.15724337e-02f, -1.19833656e-01f, 4.52013426e-02f, -6.73144087e-02f, -1.45815283e-01f, 5.70779331e-02f, 1.62746180e-02f, 1.18956668e-02f, 1.13827333e-01f,
  4.23883535e-02f, 7.69264847e-02f, -1.40670851e-01f, -5.44013567e-02f, -1.66845262e-01f, 1.14979975e-01f, -1.31363645e-01f, 3.61677222e-02f, 5.85280657e-02f, 8.03843215e-02f,
  -6.40205890e-02f, 5.94626665e-02f, -3.91698480e-02f, 1.24074891e-03f, -9.11108181e-02f, -8.84927735e-02f, 8.22160114e-03f, -1.12362653e-01f, -4.83410880e-02f, 7.01295510e-02f,
  1.58271287e-02f, -1.25355823e-02f, -6.98428378e-02f, 1.86584294e-01f, -7.66942650e-02f, -2.96426564e-02f, 1.57363396e-02f, -7.60838808e-03f, -3.53933312e-02f, -6.17416983e-04f,
  6.98143095e-02f, 6.14532828e-02f, -6.91999355e-03f, 2.61325408e-02f, 7.98315778e-02f, 2.28625517e-02f, -1.28436819e-01f, 5.68928383e-02f, 6.36909902e-02f, 8.43331683e-03f,
  9.37868431e-02f, -3.56233530e-02f, 5.43781109e-02f, -8.25230926e-02f, -4.16481821e-03f, -2.10396461e-02f, 5.71126081e-02f, -2.95086093e-02f, 1.00278571e-01f, 9.00722072e-02f,
  -1.45227797e-02f, 1.03483126e-01f, 1.08199222e-02f, 1.15429915e-01f, -9.93053778e-04f, -1.95019972e-02f, 1.23506032e-01f, -1.00598636e-03f, -3.64504941e-02f, 7.64979273e-02f,
  1.03641756e-01f, 6.36752769e-02f, 1.03535555e-01f, 3.45874242e-02f, 4.73806597e-02f, -8.70765597e-02f, 6.93863723e-03f, 6.93614855e-02f, -6.19905740e-02f, 1.12236671e-01f,
  -3.69121805e-02f, 1.28687352e-01f, 5.87788448e-02f, -7.76000544e-02f, 6.75205067e-02f, 2.21262872e-02f, 2.25928742e-02f, -6.66113347e-02f, 4.16128933e-02f, 6.83976114e-02f,
  7.24824592e-02f, 2.87646092e-02f, 2.20244029e-03f, -3.77441645e-02f, 6.34282306e-02f, 9.53661352e-02f, -7.97071829e-02f, 6.32476211e-02f, -1.65556818e-02f, -1.38343990e-01f,
  -1.12534743e-02f, -1.56544343e-01f, -1.74662456e-01f, -2.81091519e-02f, 6.19723946e-02f, 7.38513023e-02f, 2.06474304e-01f, 8.37703496e-02f, -6.24754354e-02f, 1.26105934e-01f,
  1.05206937e-01f, -1.65037927e-03f, 5.86445257e-03f, 1.74277499e-02f, -1.34833772e-02f, -8.16653669e-02f, -3.89032662e-02f, -5.62382452e-02f, -4.03540470e-02f, 6.00268133e-02f,
  -9.30936188e-02f, 9.51763913e-02f, 8.81760567e-02f, 1.55606046e-01f, 4.24612537e-02f, -9.57199261e-02f, 9.61314589e-02f, 4.21993993e-03f, 3.73308919e-02f, 1.47551686e-01f,
  5.71028478e-02f, -7.75291920e-02f, 7.70458803e-02f, -4.73677441e-02f, -2.99702622e-02f, -1.54684260e-01f, 3.25392559e-02f, 7.54799768e-02f, -1.07506223e-01f, 1.37076780e-01f,
  -1.12776235e-01f, 8.76666382e-02f, 5.56426458e-02f, -3.55499238e-02f, -3.73999178e-02f, 1.00958630e-01f, -5.77102341e-02f, 7.43697211e-02f, -3.30423489e-02f, -6.12105876e-02f,
  1.10797934e-01f, -7.59256557e-02f, -1.22236706e-01f, 3.68325971e-02f, -8.45145658e-02f, -9.77996960e-02f, 6.69302940e-02f, -2.45907903e-02f, 3.07709891e-02f, -1.43317774e-01f,
  -1.11807078e-01f, 1.32475689e-01f, -4.63094264e-02f, -5.26681282e-02f, -4.91484217e-02f, -7.73792481e-03f, 4.53645363e-02f, 4.49647307e-02f, -4.84738201e-02f, 6.06466420e-02f,
  4.28801402e-02f, -3.77203785e-02f, 6.21526875e-02f, 6.36913925e-02f, -5.83893321e-02f, -1.41494036e-01f, 1.79151241e-02f, 5.93152046e-02f, -7.85484612e-02f, 4.38056290e-02f,
  -3.40119528e-04f, 1.15064485e-02f, -1.39601119e-02f, -3.68556008e-02f, -4.07886738e-03f, 4.63306680e-02f, 9.24294293e-02f, -8.63550417e-03f, 1.09567577e-02f, 4.23097722e-02f,
  1.15006054e-02f, -1.50148561e-02f, -4.44946699e-02f, 3.92123610e-02f, -8.11749250e-02f, -2.56483629e-02f, -1.87574588e-02f, -4.24647480e-02f, 3.86311524e-02f, 2.53335368e-02f,
  -5.18648559e-03f, 8.44030902e-02f, 3.11504700e-03f, -5.89797944e-02f, 1.10703683e-03f, 8.43897171e-04f, -6.16190694e-02f, 2.92061903e-02f, 3.54861394e-02f, 1.17568839e-02f,
  -2.30231043e-02f, 1.61980484e-02f, 8.77159983e-02f, 2.39453837e-02f, 6.77284375e-02f, -4.29569110e-02f, -6.14328533e-02f, 9.90271475e-03f, 9.12061483e-02f, 6.98649585e-02f,
  -3.24268416e-02f, 1.16054520e-01f, 1.43769547e-01f, -9.04873982e-02f, -5.24441972e-02f, -5.12606539e-02f, -1.97444931e-02f, -5.81572652e-02f, 1.56059727e-01f, 6.39522523e-02f,
  8.97567570e-02f, -7.19758198e-02f, -6.90501125e-04f, 1.06188133e-01f, -3.09383944e-02f, 8.80599245e-02f, -8.86098593e-02f, -1.16076432e-02f, -1.10273249e-01f, -1.67961270e-02f,
  6.84108073e-03f, 4.35208827e-02f, -1.03104278e-01f, 8.58462229e-02f, 1.36481956e-01f, 2.77775060e-02f, -7.67617077e-02f, 5.76780178e-02f, 6.82953419e-03f, 3.70925255e-02f,
  5.94882928e-02f, 9.14302543e-02f, -2.77821869e-02f, 1.94653776e-03f, 1.03894182e-01f, 5.83760533e-03f, -6.90317452e-02f, -1.10088356e-01f, 5.85397854e-02f, 8.46637115e-02f,
  -2.54210718e-02f, 4.09286730e-02f, 9.21269432e-02f, -8.34773257e-02f, 6.90099970e-02f, 7.14491680e-02f, -7.01111928e-02f, -8.16248078e-03f, -7.64260218e-02f, 9.22645479e-02f,
  -1.67759228e-02f, 1.46677092e-01f, -1.36074036e-01f, -4.96172197e-02f, 7.35028088e-02f, 1.34659946e-01f, 5.43977693e-02f, 1.22441344e-01f, 4.79683988e-02f, 1.09651618e-01f,
  6.57192990e-02f, -7.92903174e-03f, 2.19742861e-02f, 4.02042307e-02f, 3.87430340e-02f, -1.49699580e-02f, 9.30603594e-02f, -6.73056245e-02f, -1.11171417e-02f, 6.60649792e-04f,
  -1.41510025e-01f, 5.97126447e-02f, -7.76011497e-02f, -6.09718077e-02f, -9.30110887e-02f, 2.01937575e-02f, 6.91165254e-02f, -8.90805200e-02f, -8.84381384e-02f, 6.67797923e-02f,
  8.77450854e-02f, -9.61647555e-02f, -9.84362811e-02f, -7.15544596e-02f, 4.54545058e-02f, 7.00697186e-04f, 4.15860638e-02f, -7.08061084e-02f, -6.17417917e-02f, 5.41107468e-02f,
  -4.01337035e-02f, 4.85414900e-02f, 6.67273849e-02f, -7.72137567e-02f, 3.56543176e-02f, 9.23049003e-02f, 7.23836124e-02f, -3.64042073e-02f, 3.94666903e-02f, 6.14012443e-02f,
  6.02922053e-04f, -6.89210668e-02f, -1.09114937e-01f, -7.21773952e-02f, 3.97213586e-02f, -4.69883112e-03f, -9.34160501e-03f, -7.01373294e-02f, -6.99348077e-02f, 6.32393584e-02f,
  -4.63641398e-02f, 3.21714580e-02f, 3.53343822e-02f, 3.82137261e-02f, -4.58772741e-02f, -1.46067336e-01f, -2.41363123e-02f, 8.11193883e-02f, -5.53247379e-03f, -6.17743395e-02f,
  -4.18028086e-02f, 4.24548797e-02f, 5.40252849e-02f, -3.04182488e-02f, -1.93564594e-02f, -1.30413130e-01f, -6.74255416e-02f, -4.58983295e-02f, -3.43830250e-02f, 7.69223124e-02f,
  4.29159105e-02f, 5.59792630e-02f, 5.74336722e-02f, -3.21101807e-02f, -1.06512466e-02f, -1.27081558e-01f, -1.30952587e-02f, -2.02437993e-02f, 2.72950530e-02f, -5.00289015e-02f,
  1.35408819e-01f, -3.23107429e-02f, -3.09207961e-02f, -2.78597809e-02f, -3.06185447e-02f, -4.32482511e-02f, 8.00611377e-02f, 3.09116319e-02f, 4.34510745e-02f, -9.83357951e-02f,
  4.65155691e-02f, 2.11217366e-02f, 2.85581406e-02f, 1.02740511e-01f, -1.97660290e-02f, 1.44932736e-02f, 9.12746508e-03f, 3.97889614e-02f, 1.46002203e-01f, 1.38214920e-02f,
  3.21397483e-02f, -5.09792194e-02f, -1.58165640e-03f, -1.41267059e-02f, -4.59106676e-02f, -8.48627910e-02f, -4.71652411e-02f, -4.64348421e-02f, 1.82455108e-02f, 1.21938594e-01f,
  6.30706549e-02f, -1.90868109e-01f, 5.00848442e-02f, 6.96266145e-02f, -1.38399512e-01f, 1.47605717e-01f, -1.49804592e-01f, 6.21146671e-02f, -6.21298254e-02f, -1.55183598e-02f,
  -1.25348717e-01f, 5.02814278e-02f, -5.61269708e-02f, 8.30507353e-02f, -1.25913754e-01f, -4.86729294e-03f, 3.60738416e-03f, 3.22217261e-03f, 4.57268655e-02f, 1.15746539e-02f,
  9.58771817e-03f, 4.81215864e-02f, -6.74886480e-02f, -1.85698911e-03f, -7.92040303e-02f, -1.48836315e-01f, -7.50552937e-02f, 1.30789563e-01f, -7.52155781e-02f, 3.28928344e-02f,
  2.84135304e-02f, -1.75244398e-02f, -3.53261940e-02f, 1.68421924e-01f, -6.69763833e-02f, 3.35636660e-02f, 4.70746076e-03f, -3.10193785e-02f, -9.20727775e-02f, 2.45558023e-02f,
  -6.07060306e-02f, -1.47532180e-01f, 8.82743150e-02f, -4.89868922e-03f, 1.23046078e-02f, 3.52473669e-02f, 1.52576733e-02f, 1.52093247e-02f, 6.63539395e-03f, 9.71701071e-02f,
  3.16984393e-02f, 1.31190745e-02f, -6.32777140e-02f, 1.54782701e-02f, -3.84643413e-02f, 4.80013825e-02f, 8.67318213e-02f, 2.27693766e-02f, -6.88526258e-02f, 1.07512679e-02f,
  2.81112362e-02f, -7.22967507e-03f, 1.94973387e-02f, 1.01908542e-01f, 6.78276345e-02f, 3.60593498e-02f, 9.27954614e-02f, -5.89233451e-02f, 4.04285863e-02f, -6.43825233e-02f,
  4.87591363e-02f, 2.45950324e-03f, 5.91949970e-02f, 1.54850148e-02f, -4.61193360e-02f, -1.86532550e-02f, 4.72955825e-03f, -7.82680418e-03f, 7.21666068e-02f, 6.39569461e-02f,
  -8.75716209e-02f, 8.22816044e-02f, 6.23848522e-03f, -4.28733677e-02f, -4.86898189e-03f, 8.63440894e-03f, 4.36272360e-02f, 5.93961626e-02f, 6.17623217e-02f, -6.65458739e-02f,
  1.86840817e-02f, 3.96392122e-02f, 6.85932189e-02f, -8.25067163e-02f, 2.05279112e-01f, -4.81269509e-02f, 1.13994196e-01f, 6.00835308e-03f, -1.87640071e-01f, 2.96163596e-02f,
  4.10875864e-02f, -8.33401158e-02f, -1.33203790e-01f, 1.42001182e-01f, -1.21773846e-01f, 2.80458964e-02f, -9.89709198e-02f, 1.35107026e-01f, -3.93539667e-02f, -2.07361281e-02f,
  1.14393882e-01f, -1.51514396e-01f, 8.33735913e-02f, -7.45481625e-02f, -1.67189650e-02f, -2.41280813e-02f, 4.16389853e-02f, 8.01515430e-02f, -8.89282376e-02f, 7.24835172e-02f,
  -6.16414919e-02f, 1.10201977e-01f, 1.51416227e-01f, -1.45054638e-01f, -2.10212357e-03f, 6.79500774e-02f, -3.97474784e-03f, -1.13975341e-02f, -1.77680790e-01f, -5.03523760e-02f,
  2.70785447e-02f, -1.43954515e-01f, -7.06470683e-02f, -1.20327994e-01f, -2.80377958e-02f, -1.54467314e-01f, -5.45751564e-02f, 9.85043868e-02f, -5.17205335e-02f, 2.43292134e-02f,
  6.62847012e-02f, -2.62637287e-02f, -1.15055941e-01f, 4.37556319e-02f, -2.07982175e-02f, -3.69032323e-02f, 3.59507874e-02f, 5.14406487e-02f, -1.03684999e-01f, -4.45455797e-02f,
  5.84283620e-02f, 7.86295757e-02f, -6.58000410e-02f, -2.45241262e-02f, 7.74262846e-02f, 1.44744724e-01f, -1.01319805e-01f, 6.05823323e-02f, 6.57962412e-02f, -2.46378519e-02f,
  1.35708777e-02f, 1.16933174e-01f, -6.16209656e-02f, -8.37156698e-02f, -1.07387686e-02f, 7.75134340e-02f, -7.38109425e-02f, -5.34909628e-02f, -1.94239784e-02f, -4.16837633e-02f,
  -4.15341519e-02f, -5.74374087e-02f, 8.24537277e-02f, -1.52934166e-02f, -6.82607666e-02f, 7.34336600e-02f, -2.61855833e-02f, 1.02201991e-01f, 3.01072225e-02f, -2.71348655e-02f,
  8.57933909e-02f, -2.25687679e-03f, -1.23622606e-03f, 7.51264766e-02f, 3.80146243e-02f, 8.31009913e-03f, -3.92934196e-02f, -5.88543043e-02f, -3.19703966e-02f, -7.48492628e-02f,
  -4.72866036e-02f, 8.05927143e-02f, 6.41599968e-02f, -3.45858186e-02f, 8.44202489e-02f, -3.31090987e-02f, 8.64487067e-02f, -6.35347739e-02f, 3.01247444e-02f, 1.28196320e-02f,
  4.12243269e-02f, -1.24360165e-02f, 7.90996924e-02f, 5.96306333e-03f, -3.18685398e-02f, 6.18915074e-03f, -1.01828622e-02f, -6.58399612e-02f, -6.47402182e-02f, -5.76727241e-02f,
  -6.72970787e-02f, 1.84927490e-02f, 1.23827010e-02f, -2.28064228e-02f, -1.57845076e-02f, 7.53863826e-02f, -1.85550265e-02f, -1.13820927e-02f, -9.97839589e-03f, 1.80454329e-02f,
  4.97657359e-02f, -5.04050814e-02f, -1.39667705e-01f, -3.71404327e-02f, -1.20266572e-01f, -1.32036716e-01f, 6.54606223e-02f, 5.99205792e-02f, 5.00491895e-02f, -1.11711957e-01f,
  1.30855590e-01f, -1.76992193e-01f, 2.84011140e-02f, 3.23197283e-02f, 1.42353684e-01f, -1.06260173e-01f, -7.59667978e-02f, -6.16719313e-02f, -4.32661287e-02f, -6.04833625e-02f,
  6.87293857e-02f, 8.01822320e-02f, -7.81950168e-03f, -1.01689279e-01f, 3.21802385e-02f, 5.13657965e-02f, 5.80058955e-02f, -2.12334078e-02f, 1.02656014e-01f, 5.23277149e-02f,
  -3.31368274e-03f, 4.14881669e-02f, 1.76091213e-02f, -3.23248096e-02f, -7.07967877e-02f, -1.22696474e-01f, 2.17723902e-02f, 8.27906504e-02f, -1.17035722e-02f, -9.61577147e-03f,
  -2.93926243e-02f, -2.37853024e-02f, -7.23861232e-02f, 9.13593322e-02f, 1.74573530e-02f, -8.75160992e-02f, 8.54991674e-02f, 2.51115095e-02f, 8.85424912e-02f, 6.53098449e-02f,
  -1.57928560e-02f, -8.77246931e-02f, 4.02557887e-02f, 4.97730747e-02f, 5.58060519e-02f, -8.25130939e-02f, -4.56273742e-02f, 5.27746640e-02f, 5.52322576e-03f, 5.91920540e-02f,
  8.84016529e-02f, -1.35046002e-02f, -1.67319298e-01f, 6.63894936e-02f, 7.40305260e-02f, -3.43768150e-02f, -6.92534000e-02f, -1.34607732e-01f, -5.30829020e-02f, 3.50560807e-02f,
  3.07092015e-02f, 1.14460655e-01f, -4.64898758e-02f, -1.42860189e-02f, -1.11993181e-03f, -5.65731451e-02f, -7.40110874e-02f, 6.24127388e-02f, -4.72096205e-02f, 8.25374722e-02f,
  7.81845115e-03f, -6.86071860e-03f, -4.70163412e-02f, 1.18683010e-01f, -7.09091723e-02f, -1.00921243e-01f, -6.93222834e-03f, 1.20876372e-01f, -6.44594803e-02f, -1.13005981e-01f,
  -3.90224252e-03f, -5.13371173e-03f, 8.93850159e-03f, 7.76302489e-03f, -1.55527610e-02f, -4.33888696e-02f, -2.13301517e-02f, 2.85950694e-02f, 1.59547366e-02f, 4.72605089e-03f,
  -5.39546870e-02f, -6.89589679e-02f, -8.97361562e-02f, -7.57218450e-02f, -4.50738221e-02f, -7.36017004e-02f, -3.88674438e-02f, -7.26551935e-02f, 3.01412344e-02f, 7.71616846e-02f,
  -3.35431285e-02f, 1.57428887e-02f, 1.31390076e-02f, -2.03193389e-02f, 1.68952197e-02f, -7.75662512e-02f, 7.43022189e-02f, 8.02178681e-02f, 8.27230066e-02f, 6.86941370e-02f,
  -1.59699412e-03f, 3.07903588e-02f, -9.64165553e-02f, 2.54746061e-02f, 2.33704112e-02f, 5.72592020e-02f, -4.41023335e-02f, -1.28005231e-02f, -1.66265946e-02f, 6.26538545e-02f,
  -3.42633622e-03f, 7.62997642e-02f, 5.34784794e-02f, 2.35087499e-01f, 6.31929412e-02f, 1.74196959e-02f, -1.37063652e-01f, -1.55766141e-02f, 7.25187585e-02f, 5.67464205e-03f,
  -1.05459034e-01f, 1.31412754e-02f, -6.82696924e-02f, -6.61607310e-02f, 1.03452049e-01f, 5.56372739e-02f, 8.36654976e-02f, 5.21794446e-02f, 2.92542409e-02f, 5.41757420e-02f,
  6.46215007e-02f, 5.18737324e-02f, -5.71584329e-02f, -3.27529274e-02f, 9.71411541e-02f, 9.44747180e-02f, 9.86241996e-02f, -3.46270539e-02f, 4.03364189e-02f, 4.82708886e-02f,
  2.64725294e-02f, 1.40967190e-01f, -1.02288565e-02f, 9.43572968e-02f, -7.64018372e-02f, 4.11515832e-02f, 5.76287657e-02f, 6.89514773e-03f, 1.09167404e-01f, -8.61332864e-02f,
  2.30311513e-01f, 5.91459824e-03f, 6.60909154e-03f, -1.10276595e-01f, -4.66767959e-02f, -5.67545556e-02f, -2.31083203e-02f, 8.75385553e-02f, 1.32070988e-01f, 7.70247430e-02f,
  -5.92725053e-02f, 8.99564382e-03f, -4.09685485e-02f, -3.44604664e-02f, 5.11083417e-02f, 5.74996434e-02f, 4.73867171e-02f, 3.56890559e-02f, -6.81177527e-02f, 1.21191241e-01f,
  1.33120731e-01f, 2.17298772e-02f, 9.40230638e-02f, 4.22647130e-03f, 2.67517008e-03f, -5.40802674e-03f, 5.92026487e-02f, -1.20518282e-01f, 9.69071314e-02f, -1.23929255e-01f,
  2.22956296e-03f, 7.00445399e-02f, -3.38580981e-02f, 3.43605205e-02f, -1.25265904e-02f, 8.69609118e-02f, 4.48578224e-02f, 8.99869502e-02f, -2.57858969e-02f, -3.47985923e-02f,
  -4.40834537e-02f, -4.60046418e-02f, -6.86567798e-02f, 8.16876143e-02f, -6.42625266e-04f, -5.84094087e-04f, 3.71092861e-03f, 4.90059368e-02f, -2.31858715e-02f, 5.90838306e-03f,
  -7.14700995e-03f, 8.87413099e-02f, -5.43738380e-02f, -6.94455653e-02f, 7.55239651e-02f, 8.77217576e-03f, 5.37360534e-02f, -3.83343361e-02f, -4.72723432e-02f, -2.02787593e-02f,
  -1.79628208e-02f, 2.02073678e-02f, 4.33742590e-02f, -1.47628980e-02f, -4.86714989e-02f, -9.88729647e-04f, 9.73204672e-02f, 6.72784597e-02f, 3.88497785e-02f, 7.51439203e-03f,
  5.54690622e-02f, -2.33415291e-02f, 5.52163310e-02f, -7.49051049e-02f, -1.03212617e-01f, -2.49870494e-02f, 1.74732599e-03f, -5.17097600e-02f, 1.03331842e-01f, 7.35689402e-02f,
  -8.12624916e-02f, -2.39504874e-02f, -4.50084209e-02f, -3.73695083e-02f, 1.81646757e-02f, 1.37604289e-02f, 5.62163554e-02f, 1.09512568e-03f, -1.24047995e-01f, 9.68168527e-02f,
  -1.83586292e-02f, 1.76544234e-01f, 2.34860592e-02f, -4.81874421e-02f, -2.18907427e-02f, 8.09417441e-02f, 4.26044911e-02f, -4.56488021e-02f, 3.69316749e-02f, 6.68462664e-02f,
  -8.36030617e-02f, 4.06346098e-02f, 4.53575738e-02f, 7.58125037e-02f, -3.46448980e-02f, 1.46091282e-01f, -5.01998365e-02f, 4.17445675e-02f, -8.05741176e-02f, -8.29582959e-02f,
  5.53951710e-02f, 7.44658411e-02f, 2.48744581e-02f, 6.66320994e-02f, 1.51531786e-01f, 6.98618740e-02f, -7.29340762e-02f, 1.02092355e-01f, 2.03465566e-01f, -7.74273500e-02f,
  -1.28655136e-01f, 1.15502952e-02f, 5.59031032e-03f, 2.55711358e-02f, 5.69664426e-02f, 5.89341531e-03f, -3.15553276e-03f, -7.97554404e-02f, 1.33471221e-01f, -4.84269410e-02f,
  1.60087824e-01f, 8.21423680e-02f, -5.48472926e-02f, -1.25449240e-01f, 4.89085615e-02f, 1.16881862e-01f, 1.55760542e-01f, -3.96410748e-02f, 4.19909395e-02f, -7.08464757e-02f,
  -2.38406062e-02f, 5.59636094e-02f, 9.79024842e-02f, 8.72363523e-02f, 3.68551873e-02f, 5.19165434e-02f, -2.48938184e-02f, 6.24673218e-02f, -5.99173643e-02f, -5.15806787e-02f,
  2.21255142e-02f, -5.29825427e-02f, -2.04585996e-02f, 1.61377043e-02f, -1.21478923e-01f, -6.15937449e-03f, 6.70390651e-02f, -2.74343789e-02f, 7.51516968e-02f, 2.13276427e-02f,
  9.62130874e-02f, -5.63298762e-02f, 5.27511612e-02f, -1.61234587e-02f, -2.55933050e-02f, -1.02401547e-01f, -6.98727891e-02f, -2.91383304e-02f, -9.16542336e-02f, -1.11732885e-01f,
  1.48955127e-02f, -5.78913279e-02f, -2.29228311e-03f, -5.49224652e-02f, 1.62168834e-02f, 7.40353987e-02f, 4.16048616e-02f, -7.05161542e-02f, -3.81770283e-02f, -4.28820662e-02f,
  5.74922599e-02f, 7.84798563e-02f, 5.31156100e-02f, -4.70796078e-02f, 2.22745840e-03f, -7.46913478e-02f, -1.04294419e-01f, -1.86859071e-02f, 6.48208288e-03f, -6.53383583e-02f,
  3.35192420e-02f, 1.82127822e-02f, 3.41513976e-02f, -3.65133137e-02f, 2.37602610e-02f, 1.62904765e-02f, -8.88267457e-02f, -4.39749062e-02f, -1.08672947e-01f, 5.40254042e-02f,
  3.09608802e-02f, 3.77721228e-02f, 3.61420127e-04f, -6.10750206e-02f, -4.95878533e-02f, 1.75919272e-02f, 6.99722394e-02f, 1.50323045e-02f, 1.00294441e-01f, -3.49739045e-02f,
  2.45383400e-02f, 6.33681864e-02f, 5.41294701e-02f, -6.33499026e-02f, -8.67264643e-02f, -4.22222391e-02f, 4.56948616e-02f, 9.87847373e-02f, 5.76083958e-02f, -6.08059280e-02f,
  -1.29701585e-01f, 1.23246334e-01f, -4.93912809e-02f, -4.43648919e-02f, -8.01110789e-02f, 1.19470600e-02f, 1.98988747e-02f, 3.38651054e-02f, 1.78071915e-03f, 6.98241368e-02f,
  -1.11349970e-01f, -7.82448575e-02f, 3.04001085e-02f, -1.19070992e-01f, 8.41192715e-03f, -4.12847400e-02f, 9.87210125e-02f, 4.27729599e-02f, 2.02575815e-03f, 2.19845455e-02f,
  1.64642800e-02f, -2.82964576e-02f, -9.49881077e-02f, 2.09703818e-02f, 7.49735981e-02f, -2.18633562e-01f, -1.37888140e-03f, 2.71021500e-02f, 9.84585732e-02f, -2.24553403e-02f,
  -1.40331417e-01f, 8.24461058e-02f, 7.74567202e-02f, -3.09446026e-02f, -3.37917507e-02f, 7.28199119e-03f, 4.86798435e-02f, -1.20974652e-01f, -9.65541527e-02f, -4.12217639e-02f,
  2.27931812e-02f, 2.65258066e-02f, 1.33803859e-01f, -2.26640459e-02f, 2.56485082e-02f, -5.56555353e-02f, 2.95982808e-02f, 3.49111445e-02f, -3.35346572e-02f, -7.00493976e-02f,
  -9.56445560e-02f, -6.46067038e-02f, -5.13004810e-02f, -4.16122302e-02f, 2.98493989e-02f, 7.99084678e-02f, 4.85797189e-02f, 1.32951764e-02f, -2.74581090e-02f, 2.37552300e-02f,
  -6.86626807e-02f, -5.00976183e-02f, 5.56793623e-02f, -4.90789190e-02f, 6.21045753e-02f, -3.98666598e-02f, 2.69321967e-02f, 6.29820377e-02f, 2.41837073e-02f, 5.70388278e-04f,
  1.30764693e-01f, -3.95597424e-03f, -5.72976749e-03f, -2.91820467e-02f, 1.11837305e-01f, 5.87139390e-02f, 4.95329052e-02f, -3.96272801e-02f, 2.69294009e-02f, 1.68087482e-02f,
  7.26927957e-03f, -5.07720513e-04f, -2.78497562e-02f, -3.19112954e-03f, 9.87965986e-03f, -8.25100541e-02f, 1.64491069e-02f, -6.86787302e-03f, 2.02190019e-02f, 5.35265878e-02f,
  -4.16088477e-02f, 4.11377698e-02f, -3.08500454e-02f, -7.93895647e-02f, 5.80765717e-02f, 4.28512469e-02f, 7.91923702e-02f, 1.23821452e-01f, -2.99046673e-02f, 3.87060083e-02f,
  2.20053061e-03f, -1.70552153e-02f, 3.65889408e-02f, -6.68121055e-02f, 6.53606728e-02f, 4.50861715e-02f, -7.40842223e-02f, 1.12762218e-02f, 8.64571854e-02f, -1.91897526e-02f,
  6.00852929e-02f, 2.65950263e-02f, 2.25187968e-02f, -6.20330125e-02f, 3.78789864e-02f, -4.85987440e-02f, 9.00475085e-02f, 2.80646491e-04f, -3.85024734e-02f, -8.36396962e-02f,
  7.17378184e-02f, -9.37110558e-02f, -7.11674914e-02f, 6.38099536e-02f, 1.03883743e-01f, 1.08638398e-01f, -4.18951921e-02f, -1.43749183e-02f, -1.52709633e-01f, 2.20381580e-02f,
  -1.96717322e-01f, 9.89931673e-02f, -9.02804285e-02f, -1.00135490e-01f, -1.01201646e-02f, 9.45420861e-02f, 1.35885864e-01f, -1.02548838e-01f, -4.68461066e-02f, -1.15936697e-02f,
  -1.07918702e-01f, 5.91503792e-02f, 6.15739413e-02f, -3.31508480e-02f, 3.44989337e-02f, 1.42607242e-01f, 3.73081006e-02f, -1.21484980e-01f, -6.70918450e-02f, -2.26361509e-02f,
  -1.74487978e-01f, -8.14865530e-02f, 9.28832442e-02f, -2.05611035e-01f, -1.02951691e-01f, -5.49180508e-02f, 5.92152961e-02f, 1.45933837e-01f, -7.49555305e-02f, 2.93819536e-03f,
  -2.77568889e-03f, -7.37561435e-02f, -5.98865710e-02f, -1.57259211e-01f, 5.77743053e-02f, 8.22312087e-02f, -5.76249324e-02f, -2.99222562e-02f, 1.36537567e-01f, -7.64828697e-02f,
  -6.90034255e-02f, -5.10753058e-02f, -7.54681006e-02f, -1.18956253e-01f, 1.71096008e-02f, 7.35575333e-02f, 7.93289021e-02f, -1.42495020e-03f, -6.01832159e-02f, 1.61989406e-01f,
  5.72690405e-02f, 2.11503133e-02f, -5.67985810e-02f, 5.00756167e-02f, 1.37723804e-01f, -6.73578382e-02f, -2.26999111e-02f, -3.97621915e-02f, -6.82425797e-02f, 1.20230699e-02f,
  3.55136693e-02f, -9.91002172e-02f, 2.55291462e-02f, -1.18714415e-01f, 4.99747433e-02f, 3.84080224e-02f, -1.36516094e-01f, -6.74065799e-02f, 1.14349186e-01f, 4.48337011e-02f,
  -9.26704705e-02f, 3.60891446e-02f, 3.28904986e-02f, 4.45286967e-02f, 9.30071846e-02f, 7.50680342e-02f, 1.43534353e-03f, 3.40259522e-02f, -4.30568270e-02f, 5.28563708e-02f,
  -3.86126526e-02f, 1.29600525e-01f, -1.65954791e-02f, 4.09710482e-02f, -8.71063024e-03f, 1.34626962e-02f, 2.65414035e-03f, 7.00761154e-02f, -5.43465093e-02f, 8.06055143e-02f,
  1.11979768e-01f, -7.42681995e-02f, 9.56561342e-02f, -8.17072093e-02f, 8.57109651e-02f, 1.90761350e-02f, -3.73958796e-02f, -5.05795851e-02f, 1.20587749e-02f, -4.46232967e-02f,
  -1.24608334e-02f, 3.16993669e-02f, -1.97762568e-02f, 1.86370395e-03f, 5.67318499e-02f, -8.11337307e-03f, -6.19362406e-02f, 8.50915834e-02f, -1.17586091e-01f, -2.91874968e-02f,
  9.08183903e-02f, -7.67362043e-02f, 1.36157215e-01f, -3.64474207e-02f, -5.33245802e-02f, -4.39463817e-02f, 7.25364462e-02f, -2.20275130e-02f, 5.62338531e-02f, 1.29238917e-02f,
  -4.74451594e-02f, -2.16615036e-01f, 2.40408326e-03f, -3.28260139e-02f, 2.19073407e-02f, 1.36237815e-01f, -2.65941885e-03f, -1.04375839e-01f, 2.10934784e-02f, -4.99862283e-02f,
  -8.80627036e-02f, 1.43366456e-02f, -1.15023822e-01f, 8.72145072e-02f, 5.96433580e-02f, 1.07071005e-01f, 3.92738432e-02f, 1.58813819e-02f, -1.05885779e-02f, 1.29301012e-01f,
  8.75964016e-02f, 8.79190266e-02f, 9.35677737e-02f, 9.48693454e-02f, -4.50034030e-02f, 1.78832889e-01f, 7.05405548e-02f, 4.06010114e-02f, 4.02005166e-02f, -9.94377770e-03f,
  -1.33381682e-02f, 1.43965915e-01f, 1.66199356e-01f, 1.23784818e-01f, -1.53618187e-01f, 3.92168164e-02f, 3.19491886e-02f, -1.09077595e-01f, 8.11506063e-02f, -4.24424000e-02f,
  -5.03113382e-02f, 6.44423813e-02f, 1.34782240e-01f, 7.61636272e-02f, 1.10340647e-01f, 1.97981790e-01f, -3.79957221e-02f, -8.74550715e-02f, 1.10260397e-02f, 1.06315598e-01f,
  1.32812843e-01f, -6.15851283e-02f, 1.17808320e-01f, -1.46526918e-01f, -3.68262753e-02f, -2.84455828e-02f, -8.46646726e-02f, 1.94088276e-02f, -2.94869430e-02f, -2.65537351e-02f,
  -5.15473522e-02f, -1.46203069e-02f, -4.92097531e-03f, 1.01511795e-02f, -1.27796307e-01f, -5.73921166e-02f, 6.80082142e-02f, -7.42221251e-02f, -2.38027312e-02f, 1.28404066e-01f,
  -3.75454091e-02f, 7.78924897e-02f, -1.00608222e-01f, -3.87145281e-02f, 6.80082962e-02f, -7.09296344e-03f, -6.35642335e-02f, -6.55597374e-02f, -5.46054468e-02f, 1.16770066e-01f,
  -4.99691814e-02f, -6.18104190e-02f, -5.28139584e-02f, -7.56033063e-02f, -5.51314652e-02f, -5.57529368e-02f, 6.16107248e-02f, -1.78734791e-02f, 3.59673202e-02f, 2.83666495e-02f,
  3.09786331e-02f, -7.71238878e-02f, -2.75776279e-03f, -5.31742945e-02f, -1.03001177e-01f, -8.18358883e-02f, -1.60733107e-02f, 8.99274424e-02f, 3.51558588e-02f, 4.43314239e-02f,
  -1.96935423e-02f, -5.77410460e-02f, 1.05464347e-02f, -9.62003917e-02f, -1.22991847e-02f, -1.18777528e-01f, 2.46534497e-02f, 2.34667622e-02f, -8.36346764e-03f, 5.23025878e-02f,
  -3.42487320e-02f, 8.38461444e-02f, 1.21205729e-02f, 5.88363223e-02f, -4.12728414e-02f, -9.87697095e-02f, -1.74897145e-02f, 3.39374468e-02f, 2.58246362e-02f, 1.10451937e-01f,
  -3.20432074e-02f, -9.44328979e-02f, -1.17249526e-01f, 8.67506862e-03f, -7.42590353e-02f, 2.48486325e-02f, -8.46923143e-02f, 2.33489703e-02f, -6.06883280e-02f, -2.61585824e-02f,
  -6.54049814e-02f, 3.98682989e-02f, -3.57986763e-02f, 2.20648900e-01f, -1.55265793e-01f, -2.71197669e-02f, 7.16852769e-02f, 6.44522309e-02f, -7.38739222e-02f, 2.75474995e-01f,
  -1.42511740e-01f, -9.01873335e-02f, -1.80769905e-01f, -1.60059575e-02f, 1.40679955e-01f, 1.90117620e-02f, 9.72223356e-02f, -3.93936411e-02f, 1.47791728e-01f, 2.20120810e-02f,
  6.49506971e-02f, 1.29551873e-01f, -1.58587933e-01f, -3.10425144e-02f, -9.03642029e-02f, 4.30598035e-02f, 8.53940621e-02f, 5.25655225e-02f, 9.13449600e-02f, 3.30095217e-02f,
  1.16113357e-01f, 1.45453885e-01f, -7.40798116e-02f, -4.10591587e-02f, -5.71767688e-02f, -6.26755357e-02f, 1.02823665e-02f, -3.79239745e-03f, 7.47609064e-02f, -8.94396529e-02f,
  1.36872772e-02f, -4.04334068e-02f, 6.11413270e-02f, -1.08261555e-02f, -1.13326227e-02f, -5.77828027e-02f, -9.59172621e-02f, -5.07063679e-02f, -5.58427311e-02f, -1.43010560e-02f,
  1.22703768e-01f, -4.04432490e-02f, 5.00953905e-02f, 2.81445496e-02f, -9.93259996e-02f, -7.18481243e-02f, 2.00936422e-02f, 3.78971845e-02f, -3.64093967e-02f, 7.03275483e-03f,
  -1.20752240e-02f, 1.77772313e-01f, -6.66255653e-02f, 3.84211764e-02f, 6.05872944e-02f, 2.53504254e-02f, -1.11751314e-02f, -4.12985049e-02f, 1.84261501e-02f, -5.86531386e-02f,
  -1.02552004e-01f, 4.23885919e-02f, 8.04277435e-02f, 3.72046120e-02f, 4.06667218e-02f, -2.98593403e-03f, 1.52065428e-02f, 4.68674526e-02f, 4.07744981e-02f, 7.01492429e-02f,
  1.84860975e-02f, -2.57580150e-02f, -9.07002017e-02f, 2.08263062e-02f, -5.69115430e-02f, 1.06050991e-01f, -1.03403982e-02f, 8.19242559e-03f, -3.35155763e-02f, 4.21352917e-03f,
  1.59543157e-02f, 4.94857952e-02f, 9.94553342e-02f, -6.03943467e-02f, 8.97335261e-02f, -5.97058311e-02f, -9.48696733e-02f, 4.31437716e-02f, 1.48675740e-02f, -5.40934131e-02f,
  7.75426477e-02f, 7.16910511e-02f, 1.95378885e-02f, -7.49950409e-02f, -9.77951214e-02f, 1.93762742e-02f, 8.95079374e-02f, -9.75564064e-04f, 4.58276607e-02f, -9.33285356e-02f,
  -1.75311789e-02f, 1.98071208e-02f, 4.11107577e-02f, 7.42581338e-02f, 8.19012076e-02f, -3.95887010e-02f, 6.92026690e-02f, -8.69953353e-03f, -2.04509906e-02f, 3.19611914e-02f,
  1.87643990e-02f, -4.53102663e-02f, -4.27982584e-02f, 2.54393443e-02f, -4.46628891e-02f, -4.41863313e-02f, -1.98685545e-02f, 1.52591959e-01f, -3.56660597e-02f, -2.03974755e-03f,
  4.32271585e-02f, -2.97871861e-03f, 1.26113743e-01f, 1.03656672e-01f, -1.83006048e-01f, -1.64436363e-02f, 1.97970569e-02f, -1.90066069e-01f, -5.88719584e-02f, -1.07935376e-01f,
  -4.27438281e-02f, 1.36185540e-02f, -1.16404794e-01f, 5.31776510e-02f, -1.35973245e-02f, -7.36508369e-02f, -7.56632090e-02f, 5.91801964e-02f, -3.80734950e-02f, -1.09710850e-01f,
  6.60611093e-02f, -7.55564421e-02f, -1.22510754e-02f, 1.10137118e-02f, -5.52884750e-02f, -2.13320851e-02f, -2.64597647e-02f, -1.02069005e-01f, -2.29708791e-01f, 6.00759834e-02f,
  8.77522901e-02f, -6.46806229e-03f, 5.77862859e-02f, 9.36720073e-02f, 4.37390544e-02f, 7.47102425e-02f, 4.54714820e-02f, 1.27485707e-01f, -1.39559299e-01f, -5.67799807e-03f,
  -9.66914892e-02f, -1.60978168e-01f, -5.16149662e-02f, -8.08340982e-02f, 1.85570996e-02f, 8.27611331e-03f, -5.30704111e-02f, -6.47247117e-03f, -4.02802154e-02f, 1.01333603e-01f,
  4.02811840e-02f, -6.70311078e-02f, -5.71343563e-02f, -7.32197586e-05f, 3.07001155e-02f, -1.02151737e-01f, 6.65640384e-02f, -6.20253347e-02f, 9.17056501e-02f, -8.77651051e-02f,
  -9.12104622e-02f, 1.42648622e-01f, -7.32001737e-02f, 1.35562718e-01f, 7.26544783e-02f, -9.57283452e-02f, 8.58160034e-02f, -2.49167718e-02f, -4.91753221e-02f, 3.23692039e-02f,
  2.77249273e-02f, -2.59117633e-02f, -6.10478371e-02f, 2.13230252e-02f, 1.58401742e-03f, 1.51784182e-01f, 6.43828735e-02f, -1.04523666e-01f, -1.11700464e-02f, 5.28618358e-02f,
  -4.82805558e-02f, -2.92920861e-02f, -4.93009016e-02f, -7.39141628e-02f, -3.55428308e-02f, 3.96916270e-02f, -7.73924142e-02f, -2.18593106e-02f, -1.08523063e-01f, 1.12203702e-01f,
  9.15429443e-02f, -2.30975673e-02f, 8.00181404e-02f, -2.95564272e-02f, -1.00072794e-01f, -7.95494244e-02f, 1.48263003e-03f, -4.54656780e-02f, -4.35447581e-02f, 3.37628685e-02f,
  -1.07438661e-01f, 3.95393483e-02f, -3.23428549e-02f, 1.89490709e-02f, 8.71797875e-02f, 2.88776178e-02f, 6.31590039e-02f, 1.16298877e-01f, -2.22220924e-02f, -9.64606106e-02f,
  8.15459937e-02f, 8.04743245e-02f, -3.22683007e-02f, -4.48077023e-02f, -3.65609862e-02f, 5.85153606e-03f, -9.70319496e-04f, 9.16892141e-02f, 3.41397673e-02f, 1.16258813e-02f,
  6.12901673e-02f, -3.57031934e-02f, -8.31698403e-02f, 4.99669602e-03f, 1.51711348e-02f, 7.94255510e-02f, -2.36037690e-02f, 6.05011210e-02f, -1.67477652e-01f, 1.74554229e-01f,
  -9.39257219e-02f, -4.42762896e-02f, -4.72179130e-02f, 1.05928302e-01f, -1.71248987e-01f, 4.35168445e-02f, -1.07579920e-02f, -1.94950763e-03f, 1.29733428e-01f, 3.02788033e-03f,
  9.98009965e-02f, 1.20408662e-01f, -7.53026083e-02f, 6.89828694e-02f, -1.09674949e-02f, 1.60932634e-02f, 4.26661298e-02f, 2.36107722e-01f, 2.45634969e-02f, -2.02095538e-01f,
  -5.23430854e-02f, -2.57696416e-02f, 6.93422137e-03f, -9.95338783e-02f, 2.27248743e-02f, 2.19986401e-02f, -6.88337861e-03f, -2.98516843e-02f, 2.40369830e-02f, 6.62560165e-02f,
  -1.06028393e-01f, -1.44330502e-01f, -7.94312209e-02f, -1.15046591e-01f, -5.93596604e-03f, -1.37611449e-01f, 1.74004063e-01f, 5.98665960e-02f, 1.00846000e-01f, -8.16105455e-02f,
  4.04410958e-02f, 7.52249360e-02f, -1.80867851e-01f, -1.04557365e-01f, -3.67598794e-02f, -3.16159539e-02f, 1.14898495e-02f, 3.40003110e-02f, -7.78164268e-02f, 8.02773610e-02f,
  1.83869842e-02f, -9.48820785e-02f, 5.64274639e-02f, -1.14821501e-01f, 4.86810179e-03f, -1.04329817e-01f, 5.74344695e-02f, 3.92757691e-02f, -3.98428999e-02f, -1.00570865e-01f,
  -1.60249826e-02f, 1.54635221e-01f, -6.66533783e-02f, -1.25600889e-01f, -3.36444303e-02f, 5.35186864e-02f, 5.03218248e-02f, -2.14847587e-02f, -5.40526677e-03f, -7.62450844e-02f,
  7.44572058e-02f, -6.90747350e-02f, 6.44196337e-03f, -5.33974878e-02f, -6.93802685e-02f, 9.06863287e-02f, 2.63298359e-02f, -8.16121101e-02f, 5.21891415e-02f, -2.06005443e-02f,
  5.83136939e-02f, 4.92579862e-02f, -3.61049618e-03f, -8.17919225e-02f, -6.45342618e-02f, -6.83616176e-02f, -3.48015130e-02f, -2.02862676e-02f, -8.34091902e-02f, 3.88915353e-02f,
  4.89200912e-02f, -1.84982747e-03f, 3.52095179e-02f, 6.78724647e-02f, 9.48257819e-02f, -2.83400286e-02f, 1.02222906e-02f, 3.65985744e-02f, 9.55870748e-02f, -3.19482498e-02f,
  -5.89719824e-02f, -3.22930180e-02f, -7.74495602e-02f, 6.02072291e-02f, -2.32979953e-02f, -1.09299058e-02f, 1.18707187e-01f, -4.39388156e-02f, 4.97368872e-02f, -8.78446475e-02f,
  -3.15491818e-02f, -2.33671889e-02f, -2.23005321e-02f, 6.33586645e-02f, 8.32109991e-03f, -8.12135339e-02f, 7.63509795e-02f, 5.04454114e-02f, -9.34823826e-02f, -4.71847691e-02f,
  5.72851636e-02f, 9.93596017e-02f, 4.76696528e-02f, -1.49246544e-01f, -1.74520642e-01f, -1.02800494e-02f, -1.85331479e-02f, 8.88212100e-02f, -9.27990079e-02f, -8.67645666e-02f,
  1.77185282e-01f, -8.87863487e-02f, 4.15811054e-02f, 1.25073954e-01f, -1.21462300e-01f, -1.87809803e-02f, -1.31812587e-01f, 1.42395452e-01f, 1.30908921e-01f, 4.34436947e-02f,
  -1.12206480e-02f, 4.59265485e-02f, 1.32638454e-01f, -3.02393138e-02f, 7.80126138e-04f, -2.26066299e-02f, -5.77497557e-02f, 5.76216504e-02f, -5.64495698e-02f, 5.32647707e-02f,
  1.31625533e-01f, 1.21456221e-01f, -5.20450063e-02f, 1.55846596e-01f, 1.57939941e-01f, -7.17860535e-02f, -2.13148013e-01f, -7.00560957e-02f, 7.34474584e-02f, -2.79821511e-02f,
  -2.19266918e-02f, 9.89156291e-02f, -2.57387757e-02f, 4.44734795e-03f, -1.06871255e-01f, -7.69115239e-02f, -4.84047718e-02f, 1.08144715e-01f, 1.05747737e-01f, 1.19560912e-01f,
  4.04963903e-02f, 3.87031324e-02f, 1.41420856e-01f, -7.52071887e-02f, -2.47725043e-02f, 2.96998915e-04f, -6.65812418e-02f, 1.84236057e-02f, 6.77221641e-02f, -8.59603211e-02f,
  1.90735385e-02f, 9.92760733e-02f, 2.37839874e-02f, 3.89262550e-02f, -3.16397958e-02f, 1.52836919e-01f, 8.81572533e-03f, -1.49830982e-01f, -1.30534628e-02f, -8.63520727e-02f,
  -4.33609709e-02f, 1.66930631e-01f, 5.29736876e-02f, 1.83589908e-03f, 7.61106387e-02f, 7.33486712e-02f, 3.00819427e-02f, -3.01351259e-03f, 1.64763220e-02f, -3.60925309e-02f,
  6.61203191e-02f, 2.79928129e-02f, 4.06029224e-02f, -2.17387863e-02f, -5.07786050e-02f, 1.04648108e-02f, -1.10081166e-01f, 6.93279654e-02f, 9.58690420e-02f, 1.06736489e-01f,
  3.04444078e-02f, -1.10316589e-01f, 2.16858834e-02f, -4.00951551e-03f, 4.58705314e-02f, 2.68869717e-02f, -9.75716710e-02f, 3.24500049e-03f, -9.59923118e-02f, -2.56460607e-02f,
  -9.16773453e-02f, -1.21301217e-02f, -3.89496647e-02f, -2.31782570e-02f, -1.58287920e-02f, 5.15924916e-02f, -6.89016134e-02f, 2.50185113e-02f, -1.10540353e-03f, 8.07632431e-02f,
  7.78594539e-02f, -6.53989092e-02f, 1.67410169e-02f, 3.48260775e-02f, -1.30446693e-02f, -2.50139497e-02f, -9.45386067e-02f, 3.22268568e-02f, 1.14560857e-01f, -7.45292455e-02f,
  1.48514761e-02f, -2.24471092e-03f, -8.37587379e-03f, -4.23274413e-02f, -4.01488580e-02f, -2.01056637e-02f, 1.19066481e-02f, 2.77224928e-03f, 8.40075091e-02f, -9.25715454e-03f,
  -8.53014067e-02f, 2.85763107e-02f, 2.31344998e-01f, 9.83364359e-02f, 1.47315666e-01f, -9.27671324e-03f, -1.08293161e-01f, 1.78774109e-03f, -1.97594523e-01f, 2.48342156e-02f,
  -5.38116992e-02f, -4.51235548e-02f, -4.66061272e-02f, -9.97962803e-02f, -1.41193792e-01f, 8.76631960e-02f, -3.61853503e-02f, 7.26299360e-02f, 1.11424945e-01f, -7.48897642e-02f,
  2.50637643e-02f, 9.64353308e-02f, 2.02174589e-01f, -2.30416078e-02f, -9.99624208e-02f, -5.85440956e-02f, -4.74969819e-02f, 1.91524848e-02f, 2.17527393e-02f, -1.02513172e-01f,
  3.24307084e-02f, -1.18772790e-01f, -4.46989425e-02f, 8.29072073e-02f, 3.05413380e-02f, 9.21424851e-03f, -5.57430126e-02f, 9.29082111e-02f, -1.25079021e-01f, -5.18299155e-02f,
  -4.11156490e-02f, 6.66474476e-02f, 1.13762699e-01f, -1.36439400e-02f, -6.47518635e-02f, 1.10925809e-01f, -9.97234732e-02f, -1.98506773e-01f, 7.20798820e-02f, -1.05003551e-01f,
  -1.18592180e-01f, 1.37987539e-01f, 8.54111277e-03f, 2.88256886e-03f, -3.25080045e-02f, -6.88141584e-02f, -3.43448971e-03f, 8.38011280e-02f, -7.58696496e-02f, -6.31950423e-02f,
  -4.51734737e-02f, -5.83986156e-02f, 4.59087789e-02f, 6.21707104e-02f, 2.65298840e-02f, 5.35703115e-02f, -4.23693433e-02f, 5.41553088e-02f, -2.38398332e-02f, -4.48162034e-02f,
  4.23766337e-02f, -1.34524152e-01f, 3.12833451e-02f, -2.00384464e-02f, -2.98250150e-02f, -8.55760276e-02f, -1.52784283e-03f, -5.26088849e-02f, -2.89812014e-02f, -1.02562152e-01f,
  2.64643151e-02f, 2.27593165e-03f, 7.30493367e-02f, 1.14754915e-01f, -1.07762232e-01f, -1.22794257e-02f, -4.18618321e-02f, 2.24443693e-02f, -7.69722834e-02f, -1.11337751e-01f,
  -2.14684941e-03f, -2.95430198e-02f, 2.28040107e-03f, -2.64656562e-02f, -5.77372424e-02f, 8.75446126e-02f, 4.83643115e-02f, 3.21553051e-02f, 3.58810164e-02f, -3.43480147e-02f,
  4.27907929e-02f, 1.63194910e-02f, -1.05643153e-01f, -9.40585211e-02f, -3.73344496e-02f, -6.29403517e-02f, 2.21854057e-02f, -1.88205335e-02f, -3.29989269e-02f, -9.32735428e-02f,
  -8.59738961e-02f, -7.70170316e-02f, -1.99058540e-02f, 2.45285267e-03f, 3.50778066e-02f, -1.15792505e-01f, 7.76507184e-02f, -3.11983377e-02f, -5.14844209e-02f, 3.59178404e-04f,
  -1.01569824e-01f, -3.87639031e-02f, -5.18186130e-02f, 2.76781730e-02f, -8.38344321e-02f, -6.12653792e-02f, 7.81160221e-02f, 9.16702077e-02f, 6.56058416e-02f, 7.90645555e-02f,
  -2.40694266e-03f, 2.40700296e-03f, 1.01803824e-01f, 7.71375299e-02f, 3.17468904e-02f, -6.13962188e-02f, -3.52656245e-02f, -4.60136645e-02f, 1.31472256e-02f, 9.03392490e-03f,
  -5.95052466e-02f, -6.91515356e-02f, -1.36863098e-01f, 2.26144064e-02f, -8.05606693e-02f, 1.46776557e-01f, -1.52617414e-02f, -8.18606988e-02f, -2.80029718e-02f, -9.31468530e-05f,
  1.15565233e-01f, -1.42814973e-02f, -4.09866646e-02f, -1.04392312e-01f, -7.22274929e-02f, 9.34204385e-02f, -3.63442525e-02f, -1.29702345e-01f, -6.29212633e-02f, 7.71193858e-03f,
  -7.17688212e-03f, 5.30411154e-02f, -9.75346714e-02f, -2.13987334e-03f, -5.81159703e-02f, 4.45006303e-02f, -1.02471694e-01f, 4.48043048e-02f, -5.78780565e-03f, 1.51603073e-02f,
  -2.58676591e-03f, 3.01362947e-02f, 6.22727573e-02f, 4.75118402e-03f, -2.35736277e-02f, -1.07301913e-01f, -8.96185338e-02f, -8.10510144e-02f, -2.40068715e-02f, 1.06516615e-01f,
  -8.82450342e-02f, 1.12436051e-02f, 1.22830778e-01f, -1.76022798e-02f, -4.04383168e-02f, 1.34377182e-01f, 5.02042994e-02f, 4.73310947e-02f, 7.78081343e-02f, 1.19696364e-01f,
  3.15717459e-02f, -7.06558675e-02f, 8.98040533e-02f, -4.40182276e-02f, 2.03862637e-02f, 6.52854890e-02f, 8.36087167e-02f, -9.90428552e-02f, -2.86450367e-02f, -1.29400864e-01f,
  -5.72252162e-02f, 1.87382400e-02f, 9.22053531e-02f, -6.22863416e-03f, 6.86497539e-02f, -7.06768129e-04f, 5.62650785e-02f, 3.04662623e-02f, 5.76917008e-02f, 3.43947811e-03f,
  4.06920426e-02f, -7.67926648e-02f, -4.89367656e-02f, -6.38973340e-02f, 7.82825891e-03f, 9.32337865e-02f, -1.20326830e-02f, -8.94564241e-02f, -8.78285915e-02f, -1.99659001e-02f,
  3.92095186e-02f, -5.30298352e-02f, -1.08536385e-01f, 4.21928950e-02f, -7.41489381e-02f, 5.32611236e-02f, -8.55839774e-02f, -2.22691298e-02f, -4.69368463e-03f, 2.62607448e-02f,
  -4.33901232e-03f, -7.99922496e-02f, -1.05907708e-01f, -3.96679640e-02f, 6.38095289e-02f, -9.51226503e-02f, 3.31367552e-02f, 4.49011289e-02f, -7.42136687e-02f, 5.03313430e-02f,
  2.11174712e-02f, 1.67176742e-02f, -2.28704624e-02f, 1.51710240e-02f, 4.46335413e-02f, -3.07108536e-02f, -1.55102485e-03f, 1.41394846e-02f, -1.01955505e-02f, -1.40887238e-02f,
  7.77614787e-02f, 8.47385172e-03f, 1.76667012e-02f, 5.97706959e-02f, -4.84613292e-02f, 1.70207433e-02f, -4.64151278e-02f, 4.61362535e-03f, -3.19094062e-02f, -4.72556278e-02f,
  3.33589427e-02f, 1.71854436e-01f, -1.20353714e-01f, -1.33249434e-02f, 1.87545177e-03f, 8.14473704e-02f, -2.64884550e-02f, 2.11906746e-01f, -1.39697284e-01f, -7.29656219e-02f,
  -9.47734639e-02f, 8.23680907e-02f, 6.30583167e-02f, 2.19903868e-02f, 5.33133075e-02f, -1.46745695e-02f, 5.95906824e-02f, 6.53022230e-02f, 1.25040546e-01f, 1.08250268e-01f,
  7.10568437e-03f, 7.12284669e-02f, 3.13730985e-02f, 3.49056572e-02f, -1.81371886e-02f, 1.05413266e-01f, 7.79343769e-02f, 1.42033324e-01f, 1.19634971e-01f, 3.19669694e-02f,
  3.51959765e-02f, 3.34125906e-02f, 5.08156084e-02f, -1.20973624e-01f, 1.29197873e-02f, -6.72988296e-02f, 6.98261335e-02f, -1.42129108e-01f, 5.81586920e-02f, 7.37704635e-02f,
  -3.14142816e-02f, 1.12885892e-01f, 6.37171119e-02f, 4.76710014e-02f, -4.53367606e-02f, -4.95428294e-02f, 4.94830124e-02f, 7.30185658e-02f, -2.25094031e-03f, -1.31247595e-01f,
  -2.88833957e-02f, 1.53747518e-02f, -5.62895089e-02f, 4.77281995e-02f, 2.25793831e-02f, -7.39328638e-02f, 7.05544800e-02f, -1.03605412e-01f, -2.96905842e-02f, 1.55008316e-01f,
  -5.27888574e-02f, -7.83122852e-02f, -3.41416686e-03f, -7.20645040e-02f, -4.24343534e-02f, -9.17059109e-02f, 2.69520115e-02f, 3.56111377e-02f, -7.87506849e-02f, 2.66450103e-02f,
  9.27606374e-02f, -8.28525722e-02f, 9.77606997e-02f, -9.01425257e-02f, -4.21376713e-02f, 4.47441563e-02f, -9.36285779e-02f, 6.00234717e-02f, 2.91218925e-02f, 1.13851294e-01f,
  2.18052473e-02f, -5.65584823e-02f, -7.35463426e-02f, 2.66214292e-02f, -9.50036049e-02f, -1.24691278e-01f, -5.47996312e-02f, -6.86186850e-02f, -7.20578730e-02f, 4.58329245e-02f,
  -4.43565510e-02f, -9.32672471e-02f, -7.51553848e-02f, -2.47747474e-03f, 6.13551214e-02f, -1.20073624e-01f, -6.49982765e-02f, -1.04607135e-01f, -1.56842954e-02f, -7.22753331e-02f,
  -7.03511983e-02f, 1.05524214e-03f, 3.99847589e-02f, -9.04668346e-02f, 1.32670641e-01f, 3.43681052e-02f, -2.12596916e-02f, 4.13898490e-02f, -5.45740984e-02f, 7.24383257e-03f,
  -4.09447327e-02f, -6.36280254e-02f, 2.20788829e-02f, -4.81171086e-02f, -3.68499421e-02f, -1.32249221e-01f, 1.95905343e-02f, -1.63150802e-02f, 3.67499553e-02f, 1.74383912e-02f,
  -1.34164453e-01f, -3.60359885e-02f, -3.99309769e-02f, 3.06927394e-02f, -2.02408470e-02f, 1.27398148e-01f, 8.88065845e-02f, 7.60661885e-02f, 4.37383987e-02f, 1.72347069e-01f,
  1.00296028e-01f, -1.12757742e-01f, -1.11176930e-01f, 8.45169127e-02f, -1.49531635e-02f, -1.85247436e-01f, -9.20829102e-02f, -4.18883525e-02f, -8.00750330e-02f, 5.36323227e-02f,
  9.43348631e-02f, 7.22108707e-02f, -4.21901457e-02f, 6.92394748e-02f, -7.90236592e-02f, -6.26621023e-02f, 1.45793170e-01f, 4.98781214e-03f, -2.10000835e-02f, -1.19878635e-01f,
  -3.17408778e-02f, -8.74135271e-03f, -7.04999838e-04f, -7.58585632e-02f, 6.12679161e-02f, 8.59745070e-02f, -1.75837129e-02f, 6.48179129e-02f, -5.53454943e-02f, 8.37356001e-02f,
  1.47287268e-02f, 9.69777107e-02f, -1.17549766e-02f, 3.26014385e-02f, -3.89744602e-02f, -2.02046353e-02f, 1.47146598e-01f, 2.19487902e-02f, -1.07956696e-02f, -9.79746804e-02f,
  -6.59983680e-02f, 2.80326745e-03f, -1.33216411e-01f, 9.64715029e-04f, 8.16961974e-02f, 8.60337615e-02f, -3.83157432e-02f, -4.17313054e-02f, 1.05856314e-01f, -6.58204705e-02f,
  -3.42053957e-02f, 1.60008505e-01f, -6.24720491e-02f, -1.15159582e-02f, -1.15723543e-01f, 1.22921094e-02f, 1.28966838e-01f, -5.86161651e-02f, 7.77861755e-03f, -5.15072234e-02f,
  3.55676040e-02f, 4.61380705e-02f, -5.43151610e-02f, -1.50144666e-01f, 6.24555685e-02f, -3.07579953e-02f, 6.11287765e-02f, 5.40349409e-02f, -2.95756627e-02f, -2.32942495e-02f,
  3.79293635e-02f, -4.29068990e-02f, 6.03445619e-02f, -1.91579312e-02f, 1.80731062e-02f, 4.86450680e-02f, 3.71921472e-02f, 9.63753313e-02f, 3.21196653e-02f, 7.56518245e-02f,
  -1.68068260e-02f, 1.11870214e-01f, -5.10437377e-02f, 2.90366635e-02f, -1.31753273e-03f, -2.85946095e-04f, -3.31164934e-02f, 7.31067732e-02f, -8.71664733e-02f, -8.60459805e-02f,
  -1.48493284e-02f, -2.81295590e-02f, -2.31265631e-02f, 1.35435490e-02f, 4.44247201e-02f, -8.38564262e-02f, 1.33605646e-02f, -2.30310429e-02f, -2.95934733e-02f, -1.14046358e-01f,
  -3.33189592e-02f, -7.41841272e-02f, 6.10665977e-02f, 7.35364482e-02f, -3.08856033e-02f, 9.66618396e-03f, 6.52705878e-02f, -2.95012277e-02f, -6.10801484e-03f, 3.94586846e-02f,
  3.81318405e-02f, 6.93183541e-02f, 3.27617824e-02f, 9.54198167e-02f, 1.59130152e-02f, -4.68342118e-02f, -2.76068896e-02f, -4.17914987e-02f, 3.96204591e-02f, 6.60115629e-02f,
  1.99890602e-02f, 3.66923250e-02f, 9.47690383e-02f, -1.12925239e-01f, -1.04496740e-01f, -1.95373464e-02f, 4.33574840e-02f, 1.51324823e-01f, 7.82715753e-02f, -5.35073578e-02f,
  1.24575496e-01f, -6.35140389e-02f, 6.79225549e-02f, -5.48019968e-02f, -4.26829085e-02f, -8.95837769e-02f, -1.27322152e-01f, -6.71128258e-02f, -3.13847214e-02f, -5.40253595e-02f,
  1.42805744e-02f, 1.00806117e-01f, -9.09577459e-02f, 9.51087400e-02f, -8.85550212e-03f, -8.31182599e-02f, -7.06172884e-02f, 1.25624418e-01f, 7.25268424e-02f, -5.66099435e-02f,
  2.04418302e-01f, -8.60209689e-02f, -2.08983570e-02f, 1.73285127e-01f, 1.82161495e-01f, 1.63631253e-02f, -1.50734395e-01f, -1.20176822e-01f, 1.45268947e-01f, -4.26035672e-02f,
  5.51911704e-02f, 5.91557436e-02f, 7.93887079e-02f, 2.45183036e-02f, 1.83534101e-01f, 1.39818564e-01f, 5.24237826e-02f, 5.23113273e-02f, 8.28449205e-02f, -9.97950509e-02f,
  3.83041538e-02f, 9.05732885e-02f, 1.55759126e-01f, 1.10320270e-01f, -1.16405264e-03f, -4.90980297e-02f, 6.66272566e-02f, 2.50408202e-02f, 5.69047965e-03f, 4.48306266e-04f,
  8.51416681e-03f, -1.64456491e-03f, 8.32400993e-02f, 8.86757523e-02f, -4.88614067e-02f, 7.12852180e-02f, 1.07397996e-02f, 2.90800002e-03f, -2.49220729e-02f, -8.10736641e-02f,
  -8.93968195e-02f, -1.27746342e-02f, 9.22558084e-03f, -4.25947504e-03f, -1.60632432e-02f, 6.92801327e-02f, 1.31550625e-01f, -5.39435931e-02f, -1.17855787e-01f, 6.96029440e-02f,
  -9.04567838e-02f, -1.27292182e-02f, 6.03232495e-02f, 4.82378118e-02f, -8.36933181e-02f, 3.36097069e-02f, 8.77955109e-02f, -4.50675078e-02f, -6.07697293e-02f, 4.48194891e-02f,
  -5.54590039e-02f, -1.73596165e-03f, 2.81751528e-02f, -1.02897517e-01f, -1.69620272e-02f, -5.31254448e-02f, 4.33266163e-02f, -6.56463876e-02f, 5.30831795e-03f, -5.31753618e-03f,
  1.19753502e-01f, -2.68683676e-02f, -4.72885109e-02f, -9.46978256e-02f, 4.30670343e-02f, 5.57699762e-02f, -1.05763987e-01f, 1.11339070e-01f, -3.44185457e-02f, 5.94793595e-02f,
  -9.23687220e-02f, 3.03736497e-02f, 5.25274724e-02f, -1.56429764e-02f, 2.43443474e-02f, 9.15295929e-02f, 8.01321864e-02f, 4.74578701e-02f, -3.14932875e-02f, 2.23361943e-02f,
  -1.39695764e-01f, -4.92462888e-02f, 5.71376234e-02f, 9.79752541e-02f, -4.89825681e-02f, 1.12757785e-02f, -2.68651154e-02f, -2.37127300e-02f, 3.79308872e-02f, -5.35149500e-02f,
  -4.74324413e-02f, 1.51106089e-01f, -6.45404458e-02f, 8.69155526e-02f, -1.05966389e-01f, -1.38331965e-01f, 3.86622064e-02f, 1.33226037e-01f, -4.28339764e-02f, -1.10111468e-01f,
  5.14373630e-02f, -1.14963643e-01f, 1.57340974e-01f, 3.30256782e-02f, 6.89881071e-02f, -1.92292824e-01f, -4.02405635e-02f, -1.67309737e-03f, -3.47127281e-02f, -1.65808722e-02f,
  -5.06870635e-02f, -9.39968973e-02f, -1.08840570e-01f, -1.35066390e-01f, 5.76034896e-02f, -6.34299144e-02f, 3.17132361e-02f, -1.02746606e-01f, -1.32478476e-01f, 2.10213456e-02f,
  -1.50613189e-01f, -1.31221414e-01f, -4.52365242e-02f, -1.36129275e-01f, 1.99128296e-02f, 1.01538887e-02f, -4.25605960e-02f, -8.70383680e-02f, -1.28059179e-01f, 4.82521206e-03f,
  -2.51422059e-02f, -3.86658683e-02f, -1.11347727e-01f, -7.13749602e-02f, -1.38050318e-01f, -1.05592497e-01f, -7.39861000e-03f, -3.46283168e-02f, -2.65685213e-03f, -9.63177755e-02f,
  -1.19638778e-01f, -1.41497642e-01f, 4.12871279e-02f, 1.45709291e-01f, -1.11590074e-02f, -1.85623411e-02f, -5.40197548e-03f, -3.90880629e-02f, 5.30592278e-02f, 5.27875125e-02f,
  -8.29246342e-02f, 1.45299196e-01f, 1.70735759e-04f, 8.92069116e-02f, -6.25901371e-02f, 9.60498154e-02f, -2.37463303e-02f, 2.10840479e-02f, 4.01523598e-02f, 1.09596603e-01f,
  1.15173450e-02f, -8.26119503e-04f, 1.37958629e-02f, -8.12364146e-02f, -9.98944417e-02f, -4.83741611e-03f, -8.59544892e-03f, 4.54673469e-02f, -1.67762283e-02f, 1.76600292e-02f,
  -3.32893580e-02f, 5.36564142e-02f, 5.88176101e-02f, -1.22681558e-01f, -8.79808590e-02f, -5.06961253e-03f, -1.20735886e-02f, 1.52586298e-02f, -9.46922898e-02f, -8.13212171e-02f,
  -3.43435593e-02f, 7.71006495e-02f, -2.35743914e-02f, -4.53359336e-02f, 7.34702796e-02f, -2.27580424e-02f, 1.90050080e-02f, -9.22772884e-02f, 2.57617142e-02f, 6.18359856e-02f,
  2.00433694e-02f, 7.51091074e-03f, -2.88606510e-02f, -9.24909394e-03f, -1.30728669e-02f, -7.85785690e-02f, -2.06997897e-02f, -2.43467726e-02f, -4.81973030e-02f, 5.98267019e-02f,
  -9.30054784e-02f, -2.89054151e-04f, 5.55094369e-02f, -7.26730451e-02f, 2.71594729e-02f, -7.83788487e-02f, -7.44976243e-03f, -1.04951844e-01f, 3.77377793e-02f, 2.34470572e-05f,
  -2.97504012e-03f, -3.32640707e-02f, 9.41557139e-02f, -3.64688784e-02f, 5.95950373e-02f, 7.64502510e-02f, 1.81983202e-03f, 6.71009272e-02f, -2.30580121e-02f, -1.92038849e-01f,
  3.83164249e-02f, 1.49691785e-02f, -4.49200682e-02f, -1.19533148e-02f, 3.06339357e-02f, -1.01319226e-02f, 2.76132654e-02f, -4.09311838e-02f, 1.34731665e-01f, 1.91956937e-01f,
  7.29684858e-03f, -3.23552117e-02f, -1.06588133e-01f, 1.19944103e-01f, -6.18222803e-02f, -1.56956717e-01f, 1.84118181e-01f, -1.36191472e-01f, 1.51922464e-01f, -5.68745583e-02f,
  -1.27321243e-01f, -1.22645674e-02f, -1.06619999e-01f, 1.36563793e-01f, -2.19815951e-02f, 4.77638580e-02f, 2.02098750e-02f, 8.72941464e-02f, 3.39304879e-02f, -9.36471596e-02f,
  -8.67546275e-02f, 5.42339236e-02f, 5.88696077e-02f, -6.73078001e-02f, 8.23004991e-02f, -7.27617517e-02f, 1.03224494e-01f, 6.02838323e-02f, -1.65752154e-02f, 5.02564535e-02f,
  -2.51111627e-01f, -1.31355673e-01f, -1.24072358e-01f, 1.24330543e-01f, -5.28090969e-02f, 1.47849694e-01f, 1.40129343e-01f, -1.53302317e-02f, -9.20699036e-04f, -3.31758987e-04f,
  1.18650213e-01f, 6.34838045e-02f, -1.30970150e-01f, 4.51172106e-02f, -8.70967805e-02f, -1.71287343e-01f, -4.16776501e-02f, 7.03971684e-02f, 2.36427970e-02f, -6.17263243e-02f,
  -4.90760542e-02f, 1.93695232e-01f, 5.46211982e-03f, 7.75079951e-02f, -5.55532388e-02f, -6.29042834e-02f, 3.60774994e-02f, 1.13215610e-01f, 7.75239104e-03f, 8.13463628e-02f,
  1.32775903e-02f, -2.55687963e-02f, 4.03092355e-02f, 8.12967867e-02f, 5.40553927e-02f, -5.19070402e-02f, -2.85836831e-02f, 4.08152677e-02f, -4.59515583e-03f, 2.67253760e-02f,
  3.83410603e-02f, -1.34112537e-02f, 5.39608710e-02f, -1.79044455e-02f, 5.69526153e-03f, 6.48498237e-02f, -1.08696267e-01f, -8.79829451e-02f, -7.53874332e-02f, -1.33853825e-02f,
  1.76821500e-02f, -3.83108035e-02f, 3.99754047e-02f, 5.28906509e-02f, -3.28489654e-02f, 3.62439230e-02f, -7.72367939e-02f, 1.22405745e-01f, 2.20855828e-02f, -6.10995218e-02f,
  6.95164427e-02f, 7.02637359e-02f, -5.20073846e-02f, 1.90505721e-02f, -9.00682211e-02f, -7.08694803e-03f, 1.23999231e-02f, 2.52441149e-02f, -1.61508117e-02f, 7.26185814e-02f,
  1.53151900e-02f, 7.78916925e-02f, 3.80619057e-03f, 9.16824490e-03f, 5.28423078e-02f, -4.00429480e-02f, -1.43039133e-03f, 3.69400606e-02f, -6.89036697e-02f, -2.71654353e-02f,
  -4.82239425e-02f, 3.38233449e-02f, 1.89359821e-02f, -3.80036980e-02f, -2.52207927e-02f, 2.95069274e-02f, -6.01997115e-02f, 4.84758653e-02f, 9.96970162e-02f, -6.78150803e-02f,
  -5.56363426e-02f, 1.17933728e-01f, -7.80987442e-02f, 1.29228398e-01f, -2.23167073e-02f, 1.90760605e-02f, -8.47071931e-02f, 1.69708014e-01f, -4.86580022e-02f, -7.74598494e-02f,
  -7.21877515e-02f, -8.75318050e-02f, 5.36030903e-02f, 2.34132744e-02f, 5.22000007e-02f, -4.68619950e-02f, -3.31710577e-02f, 1.15707614e-01f, 1.62338480e-01f, 1.22518383e-01f,
  -9.88801271e-02f, -9.09112021e-02f, -8.81918967e-02f, 5.69220446e-02f, 8.72166380e-02f, -4.84002121e-02f, 1.46684572e-02f, -6.55326992e-02f, -3.33039351e-02f, 5.62373400e-02f,
  -4.03201627e-03f, -4.57080500e-03f, -9.54916477e-02f, -9.02933031e-02f, -5.64574562e-02f, -5.37681468e-02f, -3.41751240e-02f, -1.08712710e-01f, 1.51336491e-01f, 9.52707082e-02f,
  8.99152309e-02f, -3.27425562e-02f, 5.62463328e-02f, -1.69963554e-01f, -5.30123226e-02f, 3.76080871e-02f, 3.44114639e-02f, -2.92420406e-02f, 4.90930378e-02f, 5.48244528e-02f,
  5.62734865e-02f, 1.23350434e-02f, 8.98770764e-02f, -7.08390474e-02f, 3.29616852e-02f, -1.68161318e-02f, -7.18968734e-02f, 1.84897650e-02f, 2.92755868e-02f, 7.43437111e-02f,
  4.67474945e-03f, 1.56338443e-03f, 5.04675461e-03f, 8.56392160e-02f, -6.16902225e-02f, 3.65074538e-02f, 7.75241246e-03f, 3.80228981e-02f, -7.72794560e-02f, 5.51189017e-03f,
  1.10501118e-01f, 5.77674583e-02f, 1.94206508e-03f, 8.39426294e-02f, 6.09075725e-02f, 2.02309322e-02f, 1.03324287e-01f, -2.34624166e-02f, -2.08274554e-02f, -3.32016647e-02f,
  -3.06259072e-03f, 3.52515578e-02f, 1.30040515e-02f, -5.97685985e-02f, 5.70587888e-02f, -8.71661529e-02f, -4.18607779e-02f, -6.64589629e-02f, 3.60526145e-02f, -3.57532315e-03f,
  6.45184368e-02f, 1.30136535e-02f, 4.56869006e-02f, -1.84541047e-02f, 3.85089070e-02f, 3.31733674e-02f, -7.42308050e-02f, 1.53911076e-02f, -8.89817104e-02f, -6.55295029e-02f,
  -1.21812344e-01f, 1.11187853e-01f, -6.31975457e-02f, -8.93120766e-02f, 3.89622673e-02f, -8.70938227e-03f, -5.66226849e-03f, 9.36836377e-02f, -4.80255596e-02f, -1.94043107e-02f,
  7.09994808e-02f, -4.70582992e-02f, 5.00122570e-02f, -7.22431317e-02f, -1.83641799e-02f, -5.95813505e-02f, -1.16379544e-01f, 3.18692289e-02f, 8.25436637e-02f, -3.89704145e-02f,
  -1.01072870e-01f, -6.82227239e-02f, 6.80383891e-02f, -8.07640851e-02f, -1.01649746e-01f, 3.09985951e-02f, 7.13069886e-02f, 8.64522532e-03f, -9.71694440e-02f, 5.87168373e-02f,
  -1.87512469e-02f, -4.30611037e-02f, -9.95802656e-02f, 6.12230413e-02f, -1.01453714e-01f, -1.80008579e-02f, -6.45806789e-02f, 4.69422415e-02f, 1.34772807e-02f, 1.38991475e-02f,
  9.03775319e-02f, 9.67481434e-02f, -7.60394707e-02f, -2.23984607e-02f, -3.04724313e-02f, -1.30948663e-01f, 4.62577529e-02f, 1.53123468e-01f, 1.41601503e-01f, -8.69377777e-02f,
  -3.20611149e-02f, -1.66610291e-03f, -1.85719579e-01f, 6.16010875e-02f, -3.04397456e-02f, -5.74394017e-02f, -7.66974390e-02f, -1.15341417e-01f, -3.56543511e-02f, 7.11786598e-02f,
  -7.31383159e-04f, 1.91645417e-02f, -6.06512576e-02f, -2.01964140e-01f, 5.44447266e-02f, 7.28133135e-03f, 9.38692763e-02f, 2.99186446e-03f, -3.08765541e-03f, -1.25438809e-01f,
  1.30378023e-01f, 1.70231372e-01f, -1.60372674e-01f, -1.50580704e-01f, -2.75707580e-02f, -1.36780858e-01f, -9.04702991e-02f, -2.87956689e-02f, -6.88320175e-02f, -6.73344955e-02f,
  6.81718532e-03f, 5.72421178e-02f, 4.43123654e-02f, -3.91066521e-02f, -7.24101290e-02f, 2.19107065e-02f, 1.30425677e-01f, 6.40868992e-02f, 3.15749249e-03f, 4.28816862e-02f,
  9.71200392e-02f, 6.07127249e-02f, 1.06952690e-01f, -4.81245853e-03f, 5.03687793e-03f, 3.99582013e-02f, -4.29383032e-02f, -2.65205409e-02f, 1.41887115e-02f, -7.28413463e-02f,
  8.33025053e-02f, -1.16047887e-02f, 1.40503654e-02f, 3.75008360e-02f, -7.47066960e-02f, 6.52235374e-02f, -1.68940313e-02f, 5.88492490e-03f, -7.30626881e-02f, -3.81584279e-02f,
  2.59902552e-02f, 7.14726448e-02f, -2.74745021e-02f, -1.13920739e-03f, 4.09544483e-02f, -1.64664462e-02f, 8.76483023e-02f, -1.68656409e-02f, -2.90714623e-03f, 4.33662906e-02f,
  -3.98505526e-03f, -8.97313431e-02f, -2.30327509e-02f, -2.58910432e-02f, -1.21212743e-01f, -3.70763242e-02f, -2.02096388e-04f, -9.25512090e-02f, 6.68789744e-02f, 8.98169652e-02f,
  5.08050434e-02f, -1.22726768e-01f, 5.69177680e-02f, 1.00191660e-01f, -5.72064240e-03f, -6.11475222e-02f, -3.93401124e-02f, 7.63333887e-02f, -3.11085638e-02f, -6.17207140e-02f,
  -5.06368205e-02f, -7.20654503e-02f, -1.93613991e-02f, 1.25280386e-02f, -5.47822416e-02f, 2.92603206e-02f, 9.32138264e-02f, 4.71048132e-02f, -1.00088388e-01f, 5.93808107e-02f,
  4.02408466e-02f, 1.68601535e-02f, 1.51060158e-02f, 5.72360940e-02f, 1.23235941e-01f, 4.56569493e-02f, 1.62868857e-01f, -7.08532557e-02f, -5.04154563e-02f, 8.65496770e-02f,
  -1.31101355e-01f, 2.52073095e-03f, -4.91400324e-02f, 1.73423380e-01f, -6.65069297e-02f, 1.55399432e-02f, -1.99295223e-01f, 1.49674609e-01f, -1.09116860e-01f, 6.51037320e-02f,
  1.53747424e-01f, -1.15310714e-01f, -5.90159744e-02f, -5.36426250e-03f, 9.37619731e-02f, -9.77131724e-02f, -1.27270475e-01f, 9.97652933e-02f, -5.15005030e-02f, 1.18781760e-01f,
  -3.75998653e-02f, 9.23131034e-02f, 3.69176082e-02f, -5.86365946e-02f, -2.56881788e-02f, 1.77010655e-01f, 5.98665103e-02f, -1.27721680e-02f, -9.15984511e-02f, 1.95838571e-01f,
  -1.27814468e-02f, 5.84093221e-02f, 3.36951986e-02f, -4.78297547e-02f, -1.32437468e-01f, -1.66935563e-01f, -1.64636225e-02f, 1.53617695e-01f, -1.34955689e-01f, -4.42166030e-02f,
  1.44544706e-01f, -6.51811957e-02f, 7.40738660e-02f, 1.85642660e-01f, -8.92313048e-02f, -8.90464261e-02f, 4.09635007e-02f, 3.53420787e-02f, -4.93894033e-02f, -3.70112211e-02f,
  2.37221383e-02f, -1.70373078e-02f, -4.86662574e-02f, -8.97674859e-02f, 5.98728508e-02f, -1.04542315e-01f, 3.01774708e-04f, 1.15986122e-02f, 8.16289335e-02f, 2.91224457e-02f,
  8.19552913e-02f, 5.06948903e-02f, -5.68461493e-02f, 6.38533160e-02f, 4.26626429e-02f, 5.33332229e-02f, 1.68975666e-02f, 5.43716177e-02f, -2.85740918e-03f, -9.51110721e-02f,
  -3.40269804e-02f, 4.32398580e-02f, -6.87413439e-02f, -6.82935938e-02f, -2.67321542e-02f, -7.76112601e-02f, -5.27329259e-02f, -2.76271123e-02f, -3.30953253e-03f, 9.89873037e-02f,
  -5.49621917e-02f, -2.44728327e-02f, -4.29022349e-02f, 6.87295869e-02f, -6.11729585e-02f, 4.08521816e-02f, 7.36136809e-02f, -2.43255100e-03f, 4.00526542e-03f, 1.31505774e-02f,
  -3.41847129e-02f, 5.37793264e-02f, 3.30094807e-02f, -3.87655608e-02f, 8.97905901e-02f, -7.67679140e-02f, 1.07350774e-01f, 2.10768003e-02f, -1.83490533e-02f, -1.59230288e-02f,
  -2.86670476e-02f, -7.95359015e-02f, -4.95943762e-02f, 1.73335115e-03f, -2.12874226e-02f, 8.67624059e-02f, 3.70766856e-02f, 5.62806316e-02f, 9.79853123e-02f, -6.46492140e-03f,
  5.08433357e-02f, 8.49413686e-03f, -2.72034872e-02f, 4.19699214e-02f, 8.75234082e-02f, 2.20603496e-02f, 2.18571257e-02f, -1.35901915e-02f, 4.54745330e-02f, 5.78302965e-02f,
  9.90967155e-02f, -8.24826062e-02f, -1.44265443e-01f, -1.02998309e-01f, 1.33731589e-01f, -1.54542789e-01f, 2.26560593e-01f, 1.29755996e-02f, 2.43601948e-02f, 1.05212582e-02f,
  1.72021046e-01f, -6.62628263e-02f, -5.19742221e-02f, -4.21542227e-02f, -1.58479020e-01f, 2.40052538e-03f, -2.17248499e-02f, -1.65140387e-02f, 7.66077563e-02f, -8.73914137e-02f,
  -1.29897252e-01f, 1.41477093e-01f, -1.35843396e-01f, -1.51735216e-01f, -2.72042560e-03f, 1.28993988e-02f, -2.28089485e-02f, 1.21783026e-01f, 1.44055292e-01f, -7.02644736e-02f,
  -4.39435951e-02f, 6.89724237e-02f, -3.98888476e-02f, 2.98119057e-02f, 5.24880271e-03f, -1.26116991e-01f, 1.36198565e-01f, 7.86859840e-02f, 1.62762731e-01f, 9.38268676e-02f,
  2.11419258e-02f, 1.49792954e-01f, -9.39007476e-02f, -3.89319547e-02f, 8.47612917e-02f, 2.60308627e-02f, -3.30845676e-02f, -8.55762810e-02f, 9.95192379e-02f, 1.20672956e-01f,
  4.20501865e-02f, 1.45290002e-01f, -1.50219761e-02f, -3.79471891e-02f, -5.76442946e-03f, 4.71013822e-02f, -3.15452032e-02f, -2.49210671e-02f, -4.09039408e-02f, 8.12643841e-02f,
  -2.64449064e-02f, -1.09065697e-01f, -5.79493195e-02f, 6.08387403e-02f, -4.63498272e-02f, 4.21305597e-02f, -4.29982990e-02f, 5.65147661e-02f, 4.66985628e-02f, -6.11681677e-02f,
  1.81247648e-02f, 1.90299060e-02f, 3.66162471e-02f, -3.71995866e-02f, 1.31133378e-01f, 6.73763305e-02f, -2.24473793e-02f, -1.06084101e-01f, -1.56482235e-02f, -1.04323171e-01f,
  -2.22078897e-02f, 4.12746556e-02f, -1.10908337e-02f, -1.48754707e-02f, 3.12472973e-02f, 6.25438914e-02f, 9.83126834e-03f, -8.31261054e-02f, 2.71275286e-02f, 4.47459752e-03f,
  7.32254982e-02f, -4.16829996e-02f, 6.28146082e-02f, 6.22419931e-04f, 4.20436636e-02f, 2.59608179e-02f, 3.14841606e-02f, 8.12819228e-02f, -2.00306065e-02f, -7.55708441e-02f,
  9.27380398e-02f, 1.97890028e-02f, -7.26767629e-02f, 6.96946830e-02f, 1.16483041e-03f, 8.35501552e-02f, 4.79984097e-02f, -2.64073983e-02f, -8.03355500e-02f, -1.11411974e-01f,
  2.88652070e-02f, -5.33124469e-02f, 4.19097468e-02f, -3.30083556e-02f, 7.20528215e-02f, -8.69243126e-03f, -4.26838621e-02f, -1.06690116e-02f, -2.82167234e-02f, -9.19893384e-02f,
  6.35480136e-02f, -8.27595219e-02f, 3.16296369e-02f, 4.20988761e-02f, 1.83910175e-04f, -4.40529399e-02f, -2.21557450e-02f, -8.30523744e-02f, 5.17616645e-02f, -1.54839540e-02f,
  1.02026619e-01f, -2.57294290e-02f, -8.74673650e-02f, -1.33910365e-02f, -1.11410908e-01f, -1.09268285e-01f, 1.44968763e-01f, -4.46757814e-03f, -6.03240430e-02f, -3.04002706e-02f,
  -1.50906779e-02f, 1.20780349e-01f, 6.86782449e-02f, -2.22121570e-02f, 9.90307480e-02f, -2.74854656e-02f, 3.94921154e-02f, 1.13336176e-01f, 7.95573443e-02f, 4.20393609e-02f,
  -1.70699731e-02f, 7.96210095e-02f, 9.57679469e-03f, 4.04986478e-02f, -3.47584747e-02f, -2.30689142e-02f, 7.97780827e-02f, -2.52000224e-02f, 1.82998478e-02f, -3.74614596e-02f,
  -1.86659256e-03f, -6.20278567e-02f, -5.58838211e-02f, 1.12304993e-01f, 8.47437903e-02f, -5.36357425e-02f, 4.91499417e-02f, 1.59688492e-03f, -4.02528094e-03f, -2.71658916e-02f,
  4.46349457e-02f, 4.03706394e-02f, 4.24117707e-02f, 1.57507751e-02f, 8.56587514e-02f, 3.61538678e-02f, -1.23817399e-01f, 1.25669688e-02f, -2.73642782e-02f, -1.21106513e-01f,
  1.62252132e-02f, -2.17426606e-02f, 1.10059276e-01f, 1.26393912e-02f, 1.13320991e-01f, 7.84185827e-02f, -3.37281823e-02f, 9.71912593e-02f, -6.03666604e-02f, 1.21586315e-01f,
  -6.27257973e-02f, 6.62862435e-02f, 9.86737758e-02f, -6.15752954e-03f, -8.83085355e-02f, -1.51921168e-01f, 5.98044209e-02f, 1.13887250e-01f, 7.17629865e-02f, 3.08502689e-02f,
  -5.79367392e-03f, -1.55405356e-02f, 7.10697146e-03f, 1.36650931e-02f, 2.55716834e-02f, -1.09544965e-02f, 5.01713995e-03f, 3.21338959e-02f, 4.23764884e-02f, -3.40637900e-02f,
  -9.45392251e-03f, 6.96806461e-02f, 1.41957412e-02f, 6.09387867e-02f, -8.49103257e-02f, 6.80614784e-02f, 1.00456059e-01f, -9.58347693e-02f, -4.61040586e-02f, 4.73567955e-02f,
  6.18945546e-02f, -8.85865018e-02f, 7.17737079e-02f, -7.50619248e-02f, -2.12945454e-02f, -1.81512460e-02f, -9.62994546e-02f, 3.19302455e-02f, 1.05970819e-02f, 1.27282441e-02f,
  6.35153130e-02f, 1.17104361e-02f, -3.03685572e-02f, 2.22835522e-02f, -6.99602673e-03f, -8.76967609e-02f, 7.09958151e-02f, 9.69200879e-02f, -6.94925059e-03f, -4.76669185e-02f,
  -7.48181567e-02f, -2.13261638e-02f, 1.68048162e-02f, -4.38426854e-03f, 9.94257350e-03f, 2.19299160e-02f, -4.48741466e-02f, -2.86284275e-03f, 6.13353476e-02f, 4.99365255e-02f,
  -7.56396726e-02f, 2.01192088e-02f, -5.12910038e-02f, 5.33609353e-02f, 3.92442644e-02f, -4.87110503e-02f, -3.07426210e-02f, 4.05951105e-02f, -3.64474244e-02f, 1.24084577e-01f,
  8.41896906e-02f, 1.44077510e-01f, -9.82311070e-02f, 6.52287453e-02f, -1.26130715e-01f, -7.52242655e-02f, 1.38511993e-02f, -1.74668673e-02f, 3.28948386e-02f, 1.05477907e-01f,
  -7.08058942e-03f, -1.07295409e-01f, -8.10662881e-02f, 4.65361886e-02f, -3.24997716e-02f, -1.41131962e-02f, -2.30755731e-02f, 2.91063450e-02f, 5.47928661e-02f, -6.57535866e-02f,
  -5.34427352e-02f, -1.13021202e-01f, 2.76218504e-02f, -3.52047086e-02f, -3.71050984e-02f, -1.63258165e-01f, -7.20696822e-02f, 2.98989471e-02f, 3.22970971e-02f, -4.37314175e-02f,
  5.44058122e-02f, -7.08819553e-02f, -7.41316602e-02f, 1.68055549e-01f, -1.25130042e-01f, -6.83638677e-02f, 1.78574293e-04f, -2.16182880e-03f, 1.44656092e-01f, 1.05590485e-01f,
  1.21585332e-01f, -2.43946426e-02f, 7.90604651e-02f, -1.65949091e-01f, 1.12919714e-02f, -2.83666831e-02f, 5.40934280e-02f, 7.37413019e-02f, -1.23949885e-01f, -6.02652784e-03f,
  -4.74258065e-02f, 3.30988429e-02f, -4.28498164e-02f, -6.83355033e-02f, 9.37876403e-02f, 9.33247432e-03f, -1.72473956e-02f, 6.72299713e-02f, 3.49075571e-02f, -1.69269472e-01f,
  6.80443719e-02f, -7.66456872e-02f, -8.43555259e-04f, 1.21107791e-03f, -4.29151915e-02f, -1.65499374e-01f, -1.79862119e-02f, 4.64851521e-02f, 2.70300801e-03f, -3.95526849e-02f,
  -3.64972763e-02f, -2.71086805e-02f, 9.84369591e-02f, 1.41273469e-01f, -6.81706443e-02f, 7.89431855e-02f, 6.33253828e-02f, -3.52562964e-02f, 5.78869954e-02f, 3.46450433e-02f,
  7.27462769e-02f, 9.31480229e-02f, -7.21550658e-02f, -2.05587633e-02f, 7.22832009e-02f, -2.76905093e-02f, -1.11015467e-02f, -2.70266179e-02f, 3.21921632e-02f, -6.55014887e-02f,
  5.93624711e-02f, 1.43579943e-02f, -1.10786423e-01f, 4.26866785e-02f, -8.65601376e-02f, 6.61833435e-02f, 9.65434983e-02f, -6.78221062e-02f, 5.42097688e-02f, -3.15774903e-02f,
  -5.08490279e-02f, 2.96940040e-02f, -5.47221489e-02f, 3.15427370e-02f, -8.31331983e-02f, 1.04842290e-01f, 6.81937337e-02f, -3.12024895e-02f, 1.80894474e-03f, -7.50610977e-02f,
  -7.44401664e-02f, 1.04667291e-01f, -4.21605669e-02f, 1.90108642e-02f, -5.41103818e-02f, 5.39556565e-03f, -2.25007683e-02f, 4.10841079e-03f, 7.98921734e-02f, 8.77160579e-02f,
  5.63227013e-02f, -1.25315078e-02f, -4.13308032e-02f, -7.83939213e-02f, -3.32000591e-02f, -7.13052750e-02f, 6.31131157e-02f, -8.58847797e-02f, 4.30234410e-02f, -2.82801706e-02f,
  -2.33064353e-01f, -3.12182046e-02f, 4.19987813e-02f, -8.46998170e-02f, -7.44341463e-02f, 2.11706325e-01f, -8.82916972e-02f, -4.54441495e-02f, -1.19675107e-01f, 1.35836080e-01f,
  1.09248638e-01f, 5.23707867e-02f, 4.64014821e-02f, -8.03531557e-02f, 2.87251752e-02f, -1.18122682e-01f, -4.46300283e-02f, 1.23815797e-01f, -9.07576829e-02f, 1.29326135e-01f,
  -8.62458497e-02f, 6.59709126e-02f, -5.75806759e-02f, 1.42657636e-02f, 1.02107957e-01f, -8.80812332e-02f, 9.26853940e-02f, 9.71260890e-02f, 5.33542559e-02f, 3.80867720e-02f,
  -9.19274613e-02f, -9.10267159e-02f, -7.68758506e-02f, -1.07503921e-01f, -6.90384656e-02f, 1.50909564e-02f, 5.11001796e-03f, -8.48595947e-02f, -8.89436826e-02f, 1.77610189e-01f,
  -2.64722984e-02f, 7.05002844e-02f, -4.32925671e-02f, -9.33689773e-02f, 6.24930486e-03f, -7.88214356e-02f, 1.11590169e-01f, -4.99918275e-02f, -8.49248245e-02f, -5.20226429e-04f,
  2.64503583e-02f, -9.75797698e-02f, 3.07402462e-02f, 1.08690299e-02f, -6.35932460e-02f, 1.49588902e-02f, 3.68221700e-02f, 9.17296857e-02f, -7.01831579e-02f, 2.31949519e-03f,
  3.99601460e-02f, -4.02319767e-02f, 5.61081544e-02f, 1.21718861e-01f, 9.67152044e-02f, 9.06929970e-02f, -7.99358040e-02f, -1.94701161e-02f, 6.54440671e-02f, -3.89545038e-02f,
  9.80469808e-02f, -3.25104408e-02f, -7.54588544e-02f, -4.83644195e-02f, 5.09541817e-02f, 3.54941860e-02f, -1.09907307e-01f, 7.32602477e-02f, -7.68503994e-02f, -6.01706677e-04f,
  2.54093073e-02f, 6.12335093e-03f, 2.58850697e-02f, -7.78290704e-02f, -6.93466291e-02f, 8.47042650e-02f, -1.06105180e-02f, -6.03884980e-02f, 2.14546751e-02f, 5.98382615e-02f,
  -7.15071186e-02f, -1.36519093e-02f, 3.57773826e-02f, 2.21917387e-02f, -5.95126189e-02f, 5.66435270e-02f, -8.47924277e-02f, -3.12821828e-02f, 1.04082204e-01f, 6.04234375e-02f,
  4.06807922e-02f, 5.34930155e-02f, 2.51426473e-02f, -5.58594242e-02f, -7.17632920e-02f, -5.30502163e-02f, 1.02108583e-01f, -3.30166183e-02f, 7.71165192e-02f, -1.10147215e-01f,
  9.43849534e-02f, -8.84480551e-02f, -6.83089644e-02f, 2.09546951e-03f, -7.10387304e-02f, -2.22082473e-02f, -7.53398146e-03f, 4.81700748e-02f, 2.06571277e-02f, -8.21311987e-05f,
  -5.65035529e-02f, -2.52190828e-02f, -4.07514349e-02f, 4.37844247e-02f, -1.21985875e-01f, 8.49234238e-02f, 6.25979006e-02f, -7.68623948e-02f, 8.28775242e-02f, 3.25856060e-02f,
  -8.68106931e-02f, -6.05826229e-02f, 2.04557881e-01f, -1.85471773e-01f, 1.04185298e-01f, 8.79960041e-03f, -7.07869530e-02f, -7.87826777e-02f, 2.13799048e-02f, -4.12243046e-03f,
  7.91967437e-02f, -1.11334741e-01f, -1.81845650e-02f, 6.73664436e-02f, -1.40121102e-01f, -1.89300373e-01f, 1.43435011e-02f, -2.07211655e-02f, 7.16605857e-02f, -1.69434713e-03f,
  -2.55618095e-02f, 8.61711241e-03f, -1.74161285e-01f, 5.97710088e-02f, -3.03772883e-03f, -1.25224814e-02f, -1.59852147e-01f, 7.58385751e-03f, 3.46964486e-02f, 9.41162854e-02f,
  -6.24845475e-02f, 7.92709664e-02f, 7.18382699e-03f, 5.08682337e-03f, -7.54467547e-02f, -1.18599199e-01f, -1.14263281e-01f, -4.04192284e-02f, -9.48021710e-02f, -4.02647518e-02f,
  -1.47907790e-02f, -4.88622449e-02f, -2.06902754e-02f, -4.63553853e-02f, -1.08713172e-01f, 4.18588556e-02f, 5.34689128e-02f, -3.51604298e-02f, 6.86681420e-02f, -6.80228323e-02f,
  1.70533522e-03f, 7.10119084e-02f, -5.07287905e-02f, 1.04373410e-01f, -4.76736389e-02f, -4.99997959e-02f, -3.34536135e-02f, -2.24657971e-02f, 4.82792817e-02f, -6.99648485e-02f,
  -4.37182784e-02f, 3.32789011e-02f, -9.03037470e-03f, -1.35801155e-02f, 8.06027055e-02f, -5.73497936e-02f, -1.30529283e-03f, 1.97144467e-02f, -1.02734283e-01f, 3.97579670e-02f,
  -3.75292823e-02f, 6.74365461e-02f, -3.56519632e-02f, 4.59295399e-02f, 6.43127114e-02f, -3.24393176e-02f, -5.70841972e-03f, -6.70897961e-02f, 7.37755150e-02f, -9.45869684e-02f,
  -3.28188203e-02f, 3.18271667e-02f, 1.50948053e-03f, -8.24626237e-02f, 7.46687725e-02f, -9.48581323e-02f, -1.60760283e-02f, -2.10767277e-02f, 1.15626842e-01f, -7.34478831e-02f,
  -3.91290002e-02f, 1.19870402e-01f, 3.26083004e-02f, -5.29175475e-02f, 8.04703832e-02f, -7.05009401e-02f, -6.01699995e-03f, -1.26272663e-01f, 3.74809350e-03f, -1.05844736e-01f,
  -6.06494695e-02f, 1.24285422e-01f, -5.52883334e-02f, -3.04973479e-02f, -5.81404902e-02f, -1.06321089e-01f, -9.85943619e-03f, -7.87017681e-03f, -4.68225218e-02f, -7.02996403e-02f,
  -2.93061566e-02f, 1.66620255e-01f, -5.02873622e-02f, 1.42539432e-03f, 1.91251561e-02f, 4.92116883e-02f, 1.39367944e-02f, 2.84042582e-03f, -1.59785729e-02f, 1.14516385e-01f,
  1.68103240e-02f, -1.74829811e-01f, -9.42624286e-02f, -5.19576371e-02f, 7.52953589e-02f, 1.48461178e-01f, -7.77101070e-02f, 3.98884490e-02f, 1.05823398e-01f, -8.75215977e-02f,
  7.64204264e-02f, 2.13926226e-01f, -6.19406253e-02f, -9.51359570e-02f, -1.11501902e-01f, 8.37159529e-02f, 4.40436453e-02f, -1.61371678e-01f, 1.02098696e-01f, 2.38131937e-02f,
  9.82157364e-02f, -1.08885854e-01f, 5.22642061e-02f, 2.86504142e-02f, -1.62198231e-01f, 2.70204339e-02f, -3.33810970e-02f, 3.54105867e-02f, 1.78113878e-01f, 7.19053447e-02f,
  -1.00977086e-02f, 1.51690887e-03f, 1.34382859e-01f, -1.60182063e-02f, -1.16864689e-01f, -2.25467030e-02f, -5.52518442e-02f, -4.29353900e-02f, 5.44447601e-02f, 5.25001474e-02f,
  5.73979095e-02f, -1.45435378e-01f, -1.69583019e-02f, -6.30144924e-02f, 7.43307024e-02f, 9.94797274e-02f, -3.98697816e-02f, 9.17847008e-02f, 6.64876848e-02f, -1.38157215e-02f,
  1.11320904e-02f, 8.53379592e-02f, 1.30782038e-01f, -4.36577052e-02f, -5.09240013e-03f, -9.88182724e-02f, -4.21503484e-02f, -1.77867830e-01f, 2.13508960e-02f, 1.21526025e-01f,
  3.55473012e-02f, 4.20203358e-02f, 7.47940317e-02f, 1.80040896e-01f, 1.09036252e-01f, -4.19279225e-02f, -7.06855431e-02f, -4.61042523e-02f, -7.35567883e-02f, 1.15902543e-01f,
  1.08238883e-01f, -4.58243266e-02f, 1.23283211e-02f, -1.24933310e-02f, 1.14909306e-01f, 8.95812511e-02f, -1.89902056e-02f, 1.08229332e-01f, 2.69192401e-02f, 6.39928803e-02f,
  2.44538635e-02f, -1.42054595e-02f, 9.88625363e-02f, 1.14422567e-01f, 7.97405392e-02f, -2.46433336e-02f, -7.01574981e-02f, 7.54324198e-02f, -6.86136484e-02f, 1.51524581e-02f,
  -4.47228327e-02f, -3.11251264e-02f, -1.00481577e-01f, -4.73938212e-02f, -1.04263969e-01f, -3.26284878e-02f, -1.01952814e-01f, -3.94494738e-03f, 9.74197984e-02f, -7.91513473e-02f,
  8.16564262e-02f, 5.88639639e-02f, 6.52148155e-03f, 7.46607706e-02f, -6.41163886e-02f, 5.63876107e-02f, -7.51723200e-02f, -2.59819888e-02f, 7.71224573e-02f, -2.81039979e-02f,
  -8.03378001e-02f, 6.05251491e-02f, 5.55470474e-02f, 9.18851495e-02f, -1.26851816e-03f, -5.32198101e-02f, 1.10469442e-02f, -4.74981330e-02f, 1.07069323e-02f, -6.02796562e-02f,
  4.96858321e-02f, 4.56259921e-02f, -7.13262856e-02f, -3.91004868e-02f, -4.34722714e-02f, 6.66769280e-04f, -4.37728390e-02f, -9.60118920e-02f, 4.43454608e-02f, -4.66815270e-02f,
  1.89796612e-02f, 1.19718999e-01f, 1.18051376e-02f, 1.51754320e-01f, -1.41482785e-01f, -1.86384290e-01f, -1.18048161e-01f, -7.00956061e-02f, -6.24294579e-02f, 9.25383046e-02f,
  -7.30912760e-02f, 4.77122143e-02f, -3.39865382e-03f, 6.81862161e-02f, 1.39201954e-01f, 8.59432667e-02f, -7.18348995e-02f, 1.59850597e-01f, 5.40808365e-02f, -4.58160862e-02f,
  1.43923298e-01f, 1.50758609e-01f, 1.08780041e-01f, -1.60906136e-01f, 3.11434567e-02f, -7.82745034e-02f, -7.67728239e-02f, 1.75589770e-02f, 1.76270828e-01f, 1.02407672e-01f,
  4.94656637e-02f, 3.76718119e-02f, -1.32637724e-01f, 1.90431073e-01f, -1.71958953e-02f, 2.57165376e-02f, -6.51441291e-02f, -6.43667355e-02f, 2.53362861e-02f, -1.82010323e-01f,
  2.10528985e-01f, -7.26520941e-02f, 5.51886670e-02f, -1.19914589e-02f, 4.53807488e-02f, 1.05231954e-02f, -1.41336545e-01f, -6.54474124e-02f, 8.25241134e-02f, -1.23989880e-01f,
  7.81247839e-02f, -8.83544534e-02f, 9.45616513e-02f, -4.89558699e-03f, -2.83697359e-02f, 1.05754286e-01f, 1.36796036e-03f, 1.95444655e-02f, 1.10437432e-02f, 2.00162306e-02f,
  1.34294227e-01f, 4.49921191e-02f, -5.87328523e-02f, -8.23977068e-02f, 9.48184952e-02f, -7.46455640e-02f, -2.12633461e-02f, -8.55250061e-02f, 8.40885714e-02f, -1.88442338e-02f,
  -2.18049390e-04f, -8.01437870e-02f, -9.62172747e-02f, 4.41522971e-02f, 3.71633917e-02f, 1.20098092e-01f, -1.74399447e-02f, 1.12662897e-01f, -3.51769030e-02f, -1.14260785e-01f,
  -6.36642724e-02f, -5.13121411e-02f, 1.71073359e-02f, -4.17477712e-02f, -4.93671559e-02f, -2.67540254e-02f, 1.14539772e-01f, -2.49133315e-02f, 2.10854895e-02f, 4.96487468e-02f,
  1.99920796e-02f, -8.03309679e-02f, -1.29082814e-01f, 1.85137261e-02f, -6.64824545e-02f, 8.15750062e-02f, 5.28730974e-02f, 7.51399174e-02f, -2.68969927e-02f, 9.09561440e-02f,
  7.66541809e-02f, 9.94399041e-02f, 8.15329403e-02f, -5.89445122e-02f, -3.97807471e-02f, -9.13968906e-02f, -2.00608745e-02f, -4.36420143e-02f, -2.15772912e-02f, 9.36302915e-02f,
  -8.06275904e-02f, -8.34249556e-02f, -4.58529890e-02f, -2.98361061e-04f, -1.47457227e-01f, -7.27518126e-02f, -2.91905608e-02f, 5.94383590e-02f, -6.73279457e-04f, -8.44351053e-02f,
  7.69867003e-02f, -4.80717011e-02f, 4.92206253e-02f, 4.35480177e-02f, -3.42225432e-02f, -9.41761211e-02f, -6.41033277e-02f, -8.56658444e-02f, 1.68980494e-01f, 5.22102155e-02f,
  1.05802873e-02f, 1.39702618e-01f, -8.16961452e-02f, 1.41198829e-01f, -1.74007267e-02f, 1.30857497e-01f, -6.10844940e-02f, 1.79100171e-01f, -1.65118963e-01f, 3.17828394e-02f,
  1.48010431e-02f, 1.34769142e-01f, -3.56896371e-02f, -4.93477508e-02f, 1.29415020e-01f, -5.96712977e-02f, -4.28418629e-03f, 1.48731202e-01f, 1.07518509e-01f, 1.13239355e-01f,
  1.11690136e-02f, 2.48825699e-02f, 5.10347076e-02f, 1.95313748e-02f, 2.42095329e-02f, 5.85794523e-02f, 7.37090930e-02f, -1.85757905e-01f, 7.88640901e-02f, 8.89774561e-02f,
  6.26994818e-02f, -2.45529767e-02f, 1.63503550e-02f, 2.69313157e-03f, 9.00770947e-02f, -1.01212092e-01f, 7.49633685e-02f, -1.21957503e-01f, 5.72313294e-02f, -3.63841429e-02f,
  6.37199357e-02f, 2.15764523e-01f, 4.46087718e-02f, -1.05512470e-01f, 2.08999263e-03f, 2.67442781e-03f, -6.21731719e-03f, 8.88961833e-03f, -2.56603565e-02f, -5.00596613e-02f,
  5.54340035e-02f, 4.83451337e-02f, -1.20466262e-01f, 3.19136754e-02f, 1.15212396e-01f, -5.74811175e-02f, -3.45376916e-02f, -4.65128571e-02f, -4.73107956e-02f, -9.22657773e-02f,
  1.20160999e-02f, 1.23631768e-01f, 7.39922514e-04f, -4.83801998e-02f, -2.93602273e-02f, -1.31109923e-01f, 3.58417071e-02f, -7.66860694e-02f, -6.40495196e-02f, -3.17892544e-02f,
  3.34217884e-02f, -1.04531549e-01f, 2.59400401e-02f, -6.83380198e-03f, -2.23212764e-02f, -1.24963149e-01f, 2.60143485e-02f, 6.27959031e-04f, 2.96878312e-02f, 1.04084462e-01f,
  -3.41261066e-02f, -1.02866422e-02f, 2.31796019e-02f, 2.00480297e-02f, 3.56493294e-02f, -2.55454052e-02f, 4.69247885e-02f, -1.56144323e-02f, -2.75740903e-02f, -4.44878712e-02f,
  -9.32219103e-02f, 5.69688156e-02f, 2.87973583e-02f, -7.49028847e-03f, -1.66345313e-02f, 6.28849631e-03f, -8.16284195e-02f, 3.71376686e-02f, -8.41068476e-02f, -4.27035950e-02f,
  5.44809885e-02f, -1.16710104e-02f, -4.82325517e-02f, -4.17786315e-02f, -5.55841029e-02f, -5.58381788e-02f, 3.09579395e-04f, -6.46163002e-02f, 8.74941051e-02f, 8.39450061e-02f,
  3.49819958e-02f, 3.31207439e-02f, -1.43200299e-02f, 2.43195053e-03f, 4.37613092e-02f, -8.89128298e-02f, -4.60601524e-02f, 1.22000184e-02f, -2.69272104e-02f, -3.53015698e-02f,
  -6.85360655e-02f, -1.67750008e-02f, 3.48328613e-02f, -2.54344717e-02f, 2.67084315e-02f, 2.99359057e-02f, -6.65630251e-02f, 2.17313450e-02f, 8.67670029e-02f, -9.96079147e-02f,
  1.15109764e-01f, -6.81374781e-03f, -6.40413091e-02f, -7.18872175e-02f, 3.94456089e-02f, -1.92373723e-01f, 8.46074447e-02f, 8.09401181e-03f, -1.31855711e-01f, 7.21534565e-02f,
  2.95393728e-02f, 5.24271019e-02f, 2.82967351e-02f, -6.03625365e-02f, -9.28430483e-02f, 9.47665274e-02f, -1.07328676e-01f, -8.55882764e-02f, -5.06451074e-03f, 5.26387207e-02f,
  6.35120571e-02f, 4.00016680e-02f, -2.75627431e-02f, -8.50742012e-02f, -1.11150078e-01f, 1.16317928e-01f, -2.43368875e-02f, -7.79728740e-02f, -1.60760164e-01f, 4.07395102e-02f,
  1.60112396e-01f, 1.47970453e-01f, 6.61157072e-02f, 7.85887539e-02f, 1.12653524e-01f, 8.47502425e-02f, 5.60192429e-02f, -1.14262253e-01f, 1.16109923e-01f, 6.75510690e-02f,
  5.57293743e-02f, -5.16300164e-02f, 6.76514804e-02f, 7.68484548e-02f, 9.39996988e-02f, 4.70533371e-02f, -5.04493862e-02f, -6.36267066e-02f, 5.22588454e-02f, 8.42088759e-02f,
  5.19355647e-02f, 7.03973249e-02f, -5.27603254e-02f, 9.69643444e-02f, -4.37878557e-02f, 6.52694553e-02f, 1.03384972e-01f, -5.91294207e-02f, 6.25762623e-03f, -4.30164225e-02f,
  5.52898739e-03f, 3.82065475e-02f, -8.66662338e-02f, -2.47731246e-02f, -3.14298123e-02f, -8.43166858e-02f, 2.17730328e-02f, 1.00417756e-01f, 7.98554793e-02f, -1.08635128e-02f,
  -1.58935823e-02f, 4.39071059e-02f, 2.58099679e-02f, 1.11983210e-01f, 3.60339917e-02f, 2.20926218e-02f, -2.92788818e-02f, 2.50826422e-02f, -2.95214877e-02f, -5.87042160e-02f,
  -4.42076437e-02f, -6.13262802e-02f, -6.55148625e-02f, 7.33255744e-02f, -6.10303208e-02f, 1.19941039e-02f, 7.06279054e-02f, -6.99494481e-02f, 3.27608176e-02f, 6.52560312e-03f,
  8.94544870e-02f, 2.44100038e-02f, -4.86321263e-02f, -4.60131168e-02f, -5.14916815e-02f, 4.13148925e-02f, 3.12040802e-02f, -5.88226691e-02f, 8.57650414e-02f, -5.96767887e-02f,
  4.18343283e-02f, -6.03736304e-02f, 1.54198185e-02f, -1.33555636e-01f, 1.51403686e-02f, -1.70853885e-03f, -3.90337966e-02f, 8.35121274e-02f, 4.26524170e-02f, 7.92339593e-02f,
  1.04635665e-02f, 3.21560050e-03f, 5.61855100e-02f, 7.00589940e-02f, 1.71154700e-02f, 2.35026591e-02f, -2.15464160e-02f, -4.83695082e-02f, -8.67229477e-02f, -5.46125248e-02f,
  3.32153887e-02f, 7.44032040e-02f, -4.78799753e-02f, -1.26058325e-01f, 1.81609005e-01f, -1.48282647e-01f, 3.54334079e-02f, -6.27667159e-02f, -1.18566277e-02f, 9.59436446e-02f,
  -2.25786753e-02f, 8.41956064e-02f, 1.13790194e-02f, -2.70914063e-02f, -1.06148586e-01f, 2.54461952e-02f, -1.04954258e-01f, -7.69999325e-02f, -8.93561766e-02f, -5.50766662e-02f,
  8.74582827e-02f, -3.25661898e-02f, -3.20628993e-02f, 1.80286095e-02f, 1.69848595e-02f, -6.19780570e-02f, -3.47787850e-02f, 1.42268881e-01f, -1.33515164e-01f, -2.23919898e-02f,
  -2.67714523e-02f, 7.19014555e-02f, -6.31510317e-02f, -7.02338666e-02f, -2.09016085e-01f, -4.16808054e-02f, 1.69477582e-01f, -8.45858753e-02f, 7.13464525e-03f, -9.59096998e-02f,
  -2.39985045e-02f, -1.33157242e-02f, -5.28083965e-02f, 1.24775536e-01f, -1.29251748e-01f, -6.84347078e-02f, -1.23780392e-01f, -3.00140958e-02f, -4.49036323e-02f, 8.86045322e-02f,
  1.18508644e-01f, -1.09859772e-01f, 3.97804147e-03f, -7.21531808e-02f, 5.57505190e-02f, -2.12534461e-02f, -4.08495329e-02f, -1.82097144e-02f, -6.52927672e-03f, -8.52789804e-02f,
  -8.94687138e-03f, -7.88960159e-02f, 5.94340488e-02f, -4.27306965e-02f, -1.18109345e-01f, 1.07824139e-01f, -3.78213301e-02f, -9.30552091e-03f, -6.36661425e-02f, 6.65429756e-02f,
  9.85664651e-02f, 1.04065523e-01f, -4.06497978e-02f, 7.56488591e-02f, -1.32858958e-02f, -2.93927342e-02f, 7.43420124e-02f, -5.76057024e-02f, 4.24274132e-02f, 2.02919245e-02f,
  7.15309530e-02f, 9.16410238e-02f, 6.27275184e-02f, 6.26325384e-02f, -9.77535099e-02f, 3.74137796e-02f, 1.71476305e-02f, 2.06631180e-02f, -8.50277860e-03f, 4.62899581e-02f,
  -8.50199014e-02f, 6.98945820e-02f, -5.71123324e-02f, 7.21802041e-02f, 4.27658781e-02f, 4.27054875e-02f, 8.65326822e-02f, 5.21353297e-02f, 6.64016989e-04f, -9.49571058e-02f,
  -3.94761264e-02f, 1.09343328e-01f, 2.40856083e-03f, -1.36452718e-02f, -3.50329429e-02f, -6.29645213e-02f, 2.31228285e-02f, 9.00139660e-02f, -5.37470318e-02f, 5.62010445e-02f,
  2.17530262e-02f, -6.72326013e-02f, -5.43044694e-02f, 4.81397323e-02f, -3.37818116e-02f, 1.72138102e-02f, -3.69178392e-02f, 2.43248865e-02f, 4.77686897e-02f, -2.06325427e-02f,
  -3.99241634e-02f, 6.25690296e-02f, -8.86796787e-02f, -8.54616538e-02f, 8.99119601e-02f, 6.40967563e-02f, -7.22407624e-02f, -2.56813839e-02f, 8.88999775e-02f, 4.59843837e-02f,
  -5.85354306e-02f, 8.73562992e-02f, 1.72449857e-01f, -1.19022727e-01f, 1.23238213e-01f, -1.54619932e-01f, -2.38135643e-02f, 3.34433727e-02f, -1.47229910e-01f, 8.36562961e-02f,
  7.78540298e-02f, -1.10881617e-02f, 1.87157243e-02f, 1.45038096e-02f, -1.79198454e-03f, -1.73893627e-02f, -1.15739301e-01f, -8.15371871e-02f, 6.62703514e-02f, -1.70230478e-01f,
  4.15528975e-02f, 9.96195525e-02f, 5.38637117e-02f, -8.90161395e-02f, -2.58994978e-02f, 7.11892396e-02f, -1.00727886e-01f, 1.14353381e-01f, -7.42690936e-02f, 3.06933224e-02f,
  -3.45416297e-03f, -1.98961467e-01f, -2.60219276e-01f, 1.19363636e-01f, 2.27085918e-01f, -1.34280294e-01f, -3.50626511e-03f, 8.01802650e-02f, -3.88268083e-02f, 3.66201140e-02f,
  -9.35838446e-02f, 1.13570206e-01f, -8.19055438e-02f, -1.28291979e-01f, -2.07904980e-01f, 2.78222393e-02f, -9.57267210e-02f, 4.57728654e-02f, 2.55014747e-02f, -5.90931289e-02f,
  -1.14120148e-01f, 1.00457110e-01f, 1.83706116e-02f, 1.54048070e-01f, -5.64361252e-02f, -1.75003503e-02f, -1.99006256e-02f, 2.77555529e-02f, -6.85841441e-02f, -9.58532393e-02f,
  1.63268857e-02f, -1.40001774e-01f, -6.94285706e-03f, 3.93068939e-02f, -6.07001111e-02f, -1.11544747e-02f, 5.84593341e-02f, 2.55655348e-02f, 1.34136796e-01f, -2.70629339e-02f,
  -3.75881419e-02f, 4.00369614e-02f, -6.96471706e-02f, -2.76693311e-02f, -2.61216015e-02f, -8.79580900e-02f, 4.80463617e-02f, -4.02876735e-02f, -4.94199954e-02f, 9.18944851e-02f,
  3.08778556e-03f, 5.00780717e-02f, 4.26688008e-02f, -3.89608741e-02f, 3.75149027e-02f, 9.29885879e-02f, -2.85238568e-02f, 1.07958108e-01f, -4.41690087e-02f, 8.96422938e-02f,
  -3.51279750e-02f, -1.90382246e-02f, 5.16386218e-02f, 1.19969368e-01f, -3.74997817e-02f, 1.47013813e-02f, -5.43142855e-02f, -2.60102600e-02f, 1.09716885e-01f, -7.77653605e-02f,
  5.05555421e-02f, 9.32032019e-02f, -3.89273763e-02f, 2.21487600e-02f, 5.29350601e-02f, -2.19736081e-02f, 4.73530702e-02f, 2.72735897e-02f, -7.31635764e-02f, -4.63831462e-02f,
  4.10360936e-03f, 1.17099717e-01f, 2.25402229e-03f, -4.31458503e-02f, -1.21360039e-02f, 1.03543662e-01f, 3.97088267e-02f, 1.25816809e-02f, 5.66723421e-02f, -3.38342898e-02f,
  8.00644606e-02f, 5.88751696e-02f, 5.65762296e-02f, 1.00573152e-01f, 1.34636071e-02f, 1.08679272e-01f, -2.27455813e-02f, -1.86847560e-02f, -1.00926477e-02f, -1.59432560e-01f,
  7.37029389e-02f, -3.39000188e-02f, -1.08761437e-01f, -5.38309403e-02f, -1.79017354e-02f, -1.61082566e-01f, -2.68522045e-03f, 8.65041614e-02f, -3.37728076e-02f, -8.21344703e-02f,
  -3.33042704e-02f, -6.21921308e-02f, 7.71767348e-02f, -4.07317132e-02f, -1.36284344e-02f, 6.38511851e-02f, -8.80941376e-02f, -1.42930569e-02f, -4.90325838e-02f, 7.35580325e-02f,
  5.33430977e-03f, 4.70164530e-02f, 1.16422996e-01f, 4.69323732e-02f, 2.31984667e-02f, -5.08274958e-02f, 1.60146710e-02f, 2.73365006e-02f, 7.02531859e-02f, 5.44664375e-02f,
  7.72829447e-03f, 9.31305438e-02f, 5.69357090e-02f, 7.18753710e-02f, 2.03862377e-02f, -1.82840943e-01f, 1.07017308e-01f, 2.82727815e-02f, -7.94387460e-02f, 2.17205100e-02f,
  -3.69053409e-02f, 1.98881608e-02f, 7.90382251e-02f, 1.59582645e-02f, -2.03482173e-02f, 6.42277673e-02f, -1.61218317e-03f, 8.41827616e-02f, 7.01247752e-02f, -1.14936940e-01f,
  -4.26209308e-02f, -4.11059484e-02f, 8.15648660e-02f, 7.88302794e-02f, 3.82590294e-02f, 6.28238618e-02f, -1.06354535e-01f, 7.59292692e-02f, 2.17206832e-02f, -7.72624761e-02f,
  -5.57734333e-02f, 1.16232596e-01f, 3.24640051e-02f, 4.53918427e-02f, -3.62917557e-02f, -1.07725933e-01f, -2.43699867e-02f, -3.57676856e-02f, 5.51529862e-02f, -2.29846481e-02f,
  1.99750904e-03f, 7.90317804e-02f, 5.85081391e-02f, 5.06650582e-02f, -6.68541119e-02f, -7.54967257e-02f, 4.58687432e-02f, -5.14712594e-02f, -9.03291181e-02f, -1.30798742e-02f,
  -3.56012397e-02f, -1.10969305e-01f, 9.06676985e-03f, 4.90896143e-02f, 5.91521859e-02f, 7.48267472e-02f, -6.70609847e-02f, 8.11649114e-02f, -1.19613158e-02f, -7.39262626e-02f,
  -9.11320448e-02f, -1.01590738e-01f, -4.92973551e-02f, -2.23804284e-02f, -3.59433666e-02f, -1.28706485e-01f, 3.07218935e-02f, 2.53077354e-02f, -2.86005381e-02f, -8.42809826e-02f,
  6.81364387e-02f, -8.33780318e-02f, -9.80052981e-04f, -3.21948193e-02f, -8.50094184e-02f, 4.75375094e-02f, 3.50746885e-02f, -1.16709813e-01f, 6.64133951e-02f, -3.09598297e-02f,
  -9.43567604e-03f, 2.78776493e-02f, -2.20624022e-02f, 5.75346649e-02f, -1.92224421e-02f, -5.98667264e-02f, 1.43186385e-02f, -6.11383356e-02f, -5.57245612e-02f, -1.86790526e-02f,
  -4.35656356e-03f, -5.33966236e-02f, 2.12709997e-02f, -6.56933710e-02f, -5.20106666e-02f, -2.06987038e-02f, -4.00435142e-02f, -1.88063234e-02f, 1.36983633e-01f, -2.04364359e-02f,
  3.94449607e-02f, -1.19907118e-01f, 1.55646116e-01f, -3.96527275e-02f, 5.61812669e-02f, -8.79186839e-02f, -1.95130017e-02f, -1.47573516e-01f, 3.70435640e-02f, 2.44654063e-02f,
  4.28486429e-02f, -2.25669015e-02f, 8.59153047e-02f, 7.02361315e-02f, -7.68641457e-02f, -6.51966855e-02f, 4.13318761e-02f, 3.17257568e-02f, -7.28636011e-02f, -4.11634780e-02f,
  5.00830486e-02f, -4.11314182e-02f, -8.96084607e-02f, -5.79885244e-02f, -1.25185430e-01f, -5.08636534e-02f, -1.25933677e-01f, -1.01531520e-01f, -2.34473184e-01f, 6.99995533e-02f,
  1.40300199e-01f, -9.39914659e-02f, 1.22373430e-02f, -1.71780333e-01f, 1.59541816e-02f, -1.45050921e-02f, -1.07731096e-01f, 7.22447783e-02f, -1.44803137e-01f, 7.49861374e-02f,
  -2.29922198e-02f, -1.71208262e-01f, -6.12314232e-02f, 1.39840648e-01f, 2.37451075e-03f, -1.23322047e-01f, -1.45512938e-01f, -7.33663589e-02f, -3.13000493e-02f, -1.22267939e-02f,
  1.29407803e-02f, -1.39339976e-02f, -4.15917952e-03f, 1.02183864e-01f, -4.01860364e-02f, 5.11407964e-02f, -8.51274207e-02f, -1.10619806e-01f, -1.26941577e-01f, 4.23575193e-02f,
  4.34370004e-02f, 5.94792515e-02f, -3.53865586e-02f, -8.36142153e-03f, -1.43868197e-03f, 8.75663683e-02f, 9.09462273e-02f, -6.83787465e-02f, -5.16413264e-02f, 1.74033828e-02f,
  3.39549147e-02f, -1.04787782e-01f, -5.92444725e-02f, -7.42524639e-02f, -7.14013204e-02f, -1.35031426e-02f, 1.31526841e-02f, -1.97217204e-02f, -2.26503871e-02f, -2.26212125e-02f,
  3.28715076e-03f, -4.02456522e-02f, 5.39609492e-02f, -8.69588181e-02f, 4.90079224e-02f, -7.41320252e-02f, 2.91404240e-02f, -3.98148187e-02f, 5.43862842e-02f, -3.99957262e-02f,
  -2.25333422e-02f, 8.66163000e-02f, 1.98528562e-02f, 3.58001590e-02f, 7.74737820e-02f, -6.09908551e-02f, -1.23106636e-01f, -7.91047886e-02f, 6.19668001e-03f, -4.51660529e-02f,
  5.28863482e-02f, 6.03117794e-02f, -1.76663883e-02f, -8.33320692e-02f, 2.46326663e-02f, 1.29648698e-02f, 3.91424820e-02f, 2.17696801e-02f, 1.93183515e-02f, 1.58005077e-02f,
  8.16872716e-02f, 3.33124176e-02f, 8.94495398e-02f, 7.83358961e-02f, -3.31486133e-03f, -4.62345742e-02f, -3.27914543e-02f, -2.35583708e-02f, -5.66996448e-02f, -7.29803666e-02f,
  -1.46343214e-02f, -1.96630023e-02f, 6.05128892e-02f, -7.70770386e-02f, -2.46116687e-02f, 3.20660397e-02f, -1.21264771e-01f, 7.37840161e-02f, -3.75121944e-02f, -2.98886262e-02f,
  1.50383502e-01f, 1.65497269e-02f, -1.51230589e-01f, -4.11753953e-02f, 1.79525116e-04f, -1.47432208e-01f, 7.64663443e-02f, 4.77718376e-02f, -2.10177805e-02f, -6.86235353e-02f,
  -7.97020122e-02f, 4.97278273e-02f, -3.56845297e-02f, -7.23720342e-02f, -9.87723395e-02f, -5.51511627e-03f, -9.64198411e-02f, -1.51640639e-01f, -2.07818276e-03f, -6.45232797e-02f,
  -4.37115319e-02f, -3.70541029e-02f, 3.93820181e-02f, 4.42344733e-02f, -4.27104793e-02f, -7.39494339e-02f, -1.27310216e-01f, -3.74493748e-02f, 4.78661358e-02f, -1.25725809e-02f,
  5.57673946e-02f, 5.78392930e-02f, 7.71046281e-02f, -2.15887581e-03f, 7.41122961e-02f, 2.49336883e-02f, -1.08167484e-01f, -1.64054893e-02f, -1.14622071e-01f, -7.44578913e-02f,
  1.34843942e-02f, 7.87121356e-02f, -1.71935197e-03f, -4.98318151e-02f, -5.47241159e-02f, 8.63155536e-03f, -3.18253636e-02f, -4.55588140e-02f, -7.43786842e-02f, 3.53612825e-02f,
  -9.16628316e-02f, -3.06412787e-03f, -8.23466703e-02f, -4.46383432e-02f, 2.87467651e-02f, -4.82492484e-02f, 9.88077819e-02f, -9.47062746e-02f, -8.40416774e-02f, -2.57015433e-02f,
  1.06323445e-02f, -1.35854352e-02f, -6.70467168e-02f, -3.87739539e-02f, 2.56622490e-02f, -1.71948802e-02f, 3.14398520e-02f, 6.18302710e-02f, 1.91264991e-02f, 5.49189374e-02f,
  -9.30971093e-03f, 8.81377235e-02f, -4.88502532e-03f, -1.50866300e-01f, -3.13338712e-02f, 1.95418880e-03f, 3.04265823e-02f, 7.14742616e-02f, 6.29772618e-02f, 2.09499076e-02f,
  -2.91561428e-02f, -1.10156283e-01f, -5.58411255e-02f, -1.05654202e-01f, -1.74091873e-03f, 1.80947781e-02f, 1.22059823e-03f, -1.04419617e-02f, 1.11809134e-01f, -8.00807700e-02f,
  -1.01118639e-01f, -8.22916180e-02f, 1.30880252e-01f, 5.39530348e-03f, -3.32480185e-02f, 6.55264631e-02f, -4.43247445e-02f, -4.66852263e-02f, 1.16079934e-02f, 1.12077303e-01f,
  8.62342194e-02f, -6.10888824e-02f, -1.40376568e-01f, -5.45421802e-02f, -3.06901783e-02f, -1.20349132e-01f, 9.55883265e-02f, 4.70417999e-02f, 2.62662843e-02f, 1.51784923e-02f,
  -7.22668245e-02f, 4.10814509e-02f, -9.86503139e-02f, -3.45065296e-02f, 5.68434559e-02f, 3.77940610e-02f, -2.41599400e-02f, -7.00429687e-03f, 1.19525008e-01f, -6.41971603e-02f,
  9.04116197e-04f, 5.10825105e-02f, 4.00818028e-02f, 4.64840718e-02f, 3.07499710e-02f, 1.15905650e-01f, -1.98489837e-02f, -1.74767338e-02f, 3.03672869e-02f, 1.00058533e-01f,
  -1.52163669e-01f, -1.43755719e-01f, 7.32306810e-03f, -1.14821503e-02f, 1.01146750e-01f, 1.20254271e-01f, 4.95047122e-02f, -9.66621041e-02f, 6.33030757e-02f, -1.04148887e-01f,
  3.73624265e-02f, -4.27372418e-02f, 9.80271259e-04f, -1.47131070e-01f, -1.17619067e-01f, -6.26020432e-02f, 3.94755509e-03f, -1.32694677e-01f, -9.74896550e-02f, -7.21208099e-03f,
  -1.70848239e-02f, 1.38180643e-01f, -6.12316243e-02f, -1.25532642e-01f, -5.40866284e-04f, 1.11622103e-02f, -3.37858684e-02f, 1.71033368e-01f, -6.44230768e-02f, -5.77578670e-04f,
  -7.50993043e-02f, 1.86712965e-02f, 3.96313183e-02f, -1.29916489e-01f, -1.07610591e-01f, -1.60515577e-01f, -7.00212792e-02f, -6.07552240e-03f, 6.31311759e-02f, 3.95156294e-02f,
  -2.63472013e-02f, 2.37819422e-02f, -1.28255323e-01f, -1.42197674e-02f, 4.18370813e-02f, 7.98825547e-02f, -4.26955596e-02f, -4.14253250e-02f, 6.61001354e-02f, -4.04396616e-02f,
  8.83122310e-02f, 2.20092554e-02f, -1.02667585e-01f, 1.22164287e-01f, 1.27967492e-01f, 3.50836739e-02f, 2.09164526e-02f, 6.85496395e-03f, 6.81972727e-02f, -4.21590172e-02f,
  -1.08080290e-01f, -1.74005516e-02f, -8.45321715e-02f, 2.97685228e-02f, -5.10382280e-02f, -8.95211473e-02f, -7.98701718e-02f, -7.00587779e-03f, 2.98868492e-02f, 8.22909921e-02f,
  6.67030588e-02f, 8.55469555e-02f, 1.04041025e-01f, 6.81329053e-03f, 1.05114058e-01f, 4.00385484e-02f, 2.67628767e-02f, 4.27786075e-02f, -7.12779164e-02f, 4.07244302e-02f,
  -3.67747881e-02f, 5.64980470e-02f, 7.59726986e-02f, 8.28809515e-02f, 1.23867672e-02f, 6.76363260e-02f, 7.20894486e-02f, 1.50731048e-02f, 8.74879956e-03f, 5.80859814e-05f,
  -7.61802169e-03f, 8.24982747e-02f, 1.08795792e-01f, 7.87381679e-02f, 5.57042398e-02f, -3.90281826e-02f, -6.48090169e-02f, 5.67272566e-02f, 6.47892756e-03f, 4.04918641e-02f,
  5.55298477e-02f, 1.88595392e-02f, -1.73098072e-02f, 8.80032629e-02f, 1.07437834e-01f, 2.78356113e-02f, 7.16031492e-02f, 6.47496432e-02f, 5.24476990e-02f, 6.94837198e-02f,
  8.61532614e-02f, -3.61128598e-02f, 7.99833089e-02f, 6.88141659e-02f, -1.77948344e-02f, -6.54100552e-02f, 1.71448980e-02f, 1.27299964e-01f, 4.08276543e-02f, 9.84235331e-02f,
  4.35499698e-02f, -2.20340788e-02f, -9.87205729e-02f, 1.68323377e-03f, -2.26468574e-02f, 1.11673273e-01f, -2.35023238e-02f, -1.17939547e-01f, 2.22193643e-01f, 7.70286694e-02f,
  -6.29124716e-02f, -1.16319016e-01f, 5.86274005e-02f, 9.70414877e-02f, 1.07678249e-01f, -4.86647971e-02f, 1.55741632e-01f, 1.58347543e-02f, -7.68164545e-02f, 5.07432967e-02f,
  -8.34865198e-02f, -7.85922557e-02f, -1.37797324e-02f, 1.32221252e-01f, -3.96205224e-02f, -5.23657873e-02f, 6.28863275e-02f, 3.24281538e-03f, 2.17796043e-02f, 4.03368920e-02f,
  1.73509978e-02f, 2.40815207e-01f, 1.09353118e-01f, -4.31190798e-04f, -4.54349369e-02f, -1.53364064e-02f, -1.10123577e-02f, -1.24635622e-01f, -2.81058252e-02f, -6.55402392e-02f,
  1.41334021e-02f, -1.02940306e-01f, 1.81699842e-01f, 1.62768558e-01f, 1.24682195e-01f, -5.20802997e-02f, 8.35994110e-02f, 1.13868281e-01f, -4.91275340e-02f, 3.20270248e-02f,
  1.96698420e-02f, -9.27344412e-02f, -4.85206544e-02f, -9.29268897e-02f, -3.02380733e-02f, 8.96679461e-02f, 1.02288611e-01f, 6.93975762e-02f, 6.87953383e-02f, 3.99942063e-02f,
  2.63074636e-02f, 6.92543313e-02f, -1.48200080e-01f, -6.20235980e-04f, 1.19588360e-01f, 2.95435060e-02f, -4.55112047e-02f, -9.87919271e-02f, -2.79199425e-02f, -7.11601973e-02f,
  4.44399975e-02f, 5.34917898e-02f, 6.27216399e-02f, -6.47715433e-03f, -7.07250312e-02f, 3.61598022e-02f, 3.72338966e-02f, -4.27228771e-02f, -9.57593471e-02f, -4.91597643e-03f,
  4.89825271e-02f, 4.05452140e-02f, -5.33873551e-02f, -7.26792663e-02f, 3.16123143e-02f, -1.81848686e-02f, -6.04989007e-03f, 1.59633569e-02f, 1.75229404e-02f, 1.44195072e-02f,
  5.32831214e-02f, -4.55884524e-02f, 4.66743857e-02f, 2.59973370e-02f, -6.05602339e-02f, 2.60518771e-02f, 5.37743010e-02f, -1.10223435e-01f, 2.45233271e-02f, -8.78022984e-02f,
  1.00220069e-01f, 9.30213258e-02f, 4.30851541e-02f, 7.18727112e-02f, 6.97118640e-02f, 7.13715181e-02f, -1.72715932e-02f, -4.53025512e-02f, -7.12020770e-02f, -2.24010274e-02f,
  5.35980463e-02f, 7.33417124e-02f, 5.20700626e-02f, -6.85159937e-02f, 5.76758757e-02f, -4.79291119e-02f, -4.51548286e-02f, 7.25894868e-02f, 6.23714551e-02f, 4.22857068e-02f,
  -3.96283343e-02f, -3.28808762e-02f, 2.32895669e-02f, -3.99496630e-02f, 9.59788188e-02f, 3.44918147e-02f, -9.19182450e-02f, 5.22802882e-02f, 8.72147456e-02f, -1.71215847e-01f,
  -9.29643214e-02f, -1.22975498e-01f, -1.43531188e-01f, -1.06036216e-01f, 1.12961680e-01f, -9.27733909e-03f, 1.07569233e-01f, -6.30917326e-02f, 6.53460771e-02f, 1.14253730e-01f,
  7.00524524e-02f, 7.58330151e-02f, -2.05245707e-02f, 1.02337562e-01f, 2.42483662e-03f, -1.32032797e-01f, 2.43958812e-02f, 1.43867871e-02f, -1.38427047e-02f, -1.44159138e-01f,
  -1.69158757e-01f, 5.17579429e-02f, 1.45627201e-01f, 1.07774645e-01f, -9.63491276e-02f, 5.38232289e-02f, -1.68639012e-02f, 1.13060445e-01f, -3.38650942e-02f, 1.54741213e-01f,
  -3.15965600e-02f, -3.24535929e-02f, 5.72377667e-02f, 9.72965639e-03f, 1.04460239e-01f, -1.89594612e-01f, 5.32512879e-03f, 7.58691803e-02f, 8.27162410e-04f, 5.77710383e-03f,
  -1.14560112e-01f, 3.06276517e-04f, -2.03122258e-01f, 4.19319309e-02f, 5.25470786e-02f, 2.71589130e-01f, -6.55032918e-02f, 2.42700465e-02f, -2.51007825e-02f, 9.73382313e-03f,
  7.29832202e-02f, 6.29185736e-02f, -7.48926029e-02f, -1.62921771e-02f, 1.68701485e-02f, -1.13887638e-02f, -9.29936208e-03f, -1.85058154e-02f, 4.48572934e-02f, -7.99432620e-02f,
  4.72436324e-02f, 2.23298654e-01f, -6.16258979e-02f, -5.70621081e-02f, -6.56313002e-02f, -8.80653411e-02f, 4.15579379e-02f, 1.92091838e-01f, 1.21065620e-02f, -1.30362064e-02f,
  1.00235708e-01f, 2.14848183e-02f, 5.15979305e-02f, -6.36271834e-02f, 5.74019365e-02f, -3.52806561e-02f, -4.01772000e-02f, -3.44155952e-02f, 5.21507747e-02f, 4.03810404e-02f,
  -1.38508491e-02f, -5.57618961e-02f, -5.34199439e-02f, 3.58100310e-02f, -4.03533019e-02f, 6.89790100e-02f, -6.75058067e-02f, -1.25114962e-01f, -2.34305374e-02f, -5.93902729e-02f,
  -1.22852605e-02f, -3.50236855e-02f, 3.17878425e-02f, -4.34155539e-02f, -4.70900685e-02f, -5.04800789e-02f, 3.30332890e-02f, -6.69457316e-02f, 5.78328334e-02f, 7.46067753e-03f,
  3.34671289e-02f, 2.62894984e-02f, -9.02015939e-02f, -4.63401526e-02f, -1.24499470e-01f, 8.24545696e-02f, 5.38794212e-02f, 7.72380782e-03f, -7.12587982e-02f, 2.36939136e-02f,
  -3.48579735e-02f, 7.04124048e-02f, -8.41260925e-02f, -2.77910437e-02f, 2.89649540e-03f, 1.92921534e-02f, 1.57811362e-02f, 3.02155688e-03f, -4.57931161e-02f, -5.83983473e-02f,
  1.73951183e-02f, 4.59359325e-02f, -1.38360634e-01f, 3.44827287e-02f, 7.01477230e-02f, 6.37157112e-02f, -9.41302686e-04f, 1.28298938e-01f, 2.86997873e-02f, -8.72554779e-02f,
  -8.32587183e-02f, 6.98310435e-02f, -2.28628255e-02f, 1.56533532e-02f, -1.25470199e-02f, -1.50412908e-02f, -6.89607859e-02f, 4.18070108e-02f, 5.48676308e-03f, 2.34203450e-02f,
  -8.15570951e-02f, 4.08552699e-02f, -2.98835281e-02f, -3.46737392e-02f, -4.47510742e-02f, -9.86265317e-02f, 5.76015487e-02f, -1.03769124e-01f, 7.44501650e-02f, 1.64336234e-01f,
  7.25104958e-02f, -8.47232789e-02f, -5.45177273e-02f, 2.42920537e-02f, -1.08632453e-01f, -2.67494004e-02f, 2.99902558e-02f, 6.96731210e-02f, -1.22150697e-01f, -1.15631958e-02f,
  3.72041650e-02f, -6.70529604e-02f, -1.09050103e-01f, -3.89834680e-02f, -1.69911116e-01f, -5.03971241e-02f, 1.86775941e-02f, 3.21561210e-02f, 1.68647002e-02f, 3.78423766e-03f,
  -8.37288499e-02f, -2.17628945e-02f, -3.99815738e-02f, 5.69109730e-02f, 2.29245871e-02f, -1.10957123e-01f, 3.85646448e-02f, -2.17239460e-04f, -1.50627131e-02f, 9.25374702e-02f,
  -6.70011863e-02f, -1.10782817e-01f, 3.51716429e-02f, -1.03950880e-01f, 1.66999009e-02f, -1.16220163e-02f, 2.36621499e-03f, -9.17882323e-02f, 4.84491587e-02f, 1.12820677e-01f,
  2.70079114e-02f, -9.18073431e-02f, -9.66192130e-03f, 1.28807321e-01f, 1.10913947e-01f, 7.60840848e-02f, 7.08603412e-02f, -2.90008038e-02f, -7.08219558e-02f, -1.51833594e-02f,
  1.32602304e-02f, 1.90188587e-02f, -3.54734659e-02f, 6.91764355e-02f, -2.23742798e-03f, 9.94131789e-02f, 5.72601821e-05f, -1.92374848e-02f, -6.53736293e-02f, 6.65687695e-02f,
  2.56118104e-02f, 2.59297621e-02f, -3.51263210e-02f, -8.84512998e-03f, -1.26546901e-02f, -8.43911320e-02f, -7.59097487e-02f, -8.99268612e-02f, 1.23228459e-02f, -1.96852814e-03f,
  -8.08945820e-02f, -1.06315702e-01f, -6.83236122e-02f, -1.35237463e-02f, 6.20837137e-02f, 7.01021105e-02f, -1.50644602e-02f, -9.39069986e-02f, -6.92300126e-02f, 1.32841356e-02f,
  3.17161088e-03f, -1.19471643e-02f, -1.08306475e-01f, 1.55586619e-02f, -5.90530932e-02f, 8.49901065e-02f, -4.71277945e-02f, 8.55422989e-02f, -3.02209239e-02f, 8.36018026e-02f,
  1.16789043e-02f, -1.09271482e-01f, 5.28507195e-02f, 4.28840406e-02f, 2.93163001e-03f, -5.20058051e-02f, 1.14969462e-02f, 1.81532726e-02f, -9.31311399e-02f, 3.75578068e-02f,
  1.30238198e-02f, 7.20399246e-02f, 4.33955304e-02f, -6.25846675e-03f, -7.79117718e-02f, 4.69289422e-02f, -1.26343042e-01f, -3.30177695e-02f, 4.49979641e-02f, 9.83816385e-02f,
  1.02967553e-01f, 9.17944387e-02f, -1.19022056e-01f, -6.09980263e-02f, -6.26432616e-03f, 1.08695418e-01f, 3.86125334e-02f, -1.19570836e-01f, -1.34496421e-01f, -7.58324713e-02f,
  7.96336904e-02f, 4.70344909e-02f, -7.19228433e-03f, -1.16955534e-01f, 3.21150906e-02f, 7.91700110e-02f, -4.38573696e-02f, -1.74017921e-02f, -1.51219249e-01f, 5.74318320e-02f,
  5.08333929e-02f, 4.06986699e-02f, 4.79428135e-02f, 5.97641654e-02f, -1.16484962e-01f, -2.35869251e-02f, -8.60693231e-02f, 2.24589668e-02f, -4.69155647e-02f, -7.13897943e-02f,
  4.82454459e-04f, 1.08817287e-01f, 5.70520498e-02f, 6.61748350e-02f, 3.47480625e-02f, -3.78614999e-02f, 2.91684289e-02f, -6.96492195e-02f, -2.48922817e-02f, 1.36708235e-02f,
  -8.04213062e-02f, 2.44760346e-02f, 2.09730230e-02f, 1.20538846e-01f, 3.51285152e-02f, 6.51184767e-02f, 4.18857820e-02f, 1.80609943e-03f, 3.40843238e-02f, 4.08029854e-02f,
  -2.23210566e-02f, 1.06447944e-02f, -2.84984801e-02f, 8.58364329e-02f, -2.94485241e-02f, 1.91648453e-02f, 6.77768663e-02f, 1.25178590e-01f, -3.14298421e-02f, -1.73404124e-02f,
  5.87869957e-02f, 9.11071599e-02f, 4.59885485e-02f, -6.63356707e-02f, 1.00123346e-01f, 1.82562135e-02f, -6.89727888e-02f, -4.52061854e-02f, 9.00307894e-02f, 5.06934896e-02f,
  -5.70244417e-02f, -4.90518659e-02f, 8.47782649e-05f, -1.39471442e-01f, 5.48300631e-02f, 3.22697032e-03f, 4.01713029e-02f, -4.62573254e-04f, -9.95671302e-02f, -5.20589389e-02f,
  -1.50254490e-02f, -4.19219770e-02f, 4.33630310e-02f, -8.03778246e-02f, 2.19472479e-02f, -4.01404575e-02f, 2.25531999e-02f, -1.61219612e-02f, 7.81996772e-02f, 6.16189875e-02f,
  -9.10200477e-02f, 2.87242513e-02f, 4.19469997e-02f, -4.64764759e-02f, -7.27946013e-02f, 4.50498890e-03f, -5.65951765e-02f, -3.39496285e-02f, 1.20635040e-01f, 4.64145616e-02f,
  1.07883900e-01f, -8.56502876e-02f, -4.26995233e-02f, 6.21838681e-02f, 3.41389440e-02f, -1.59570277e-01f, 1.25674093e-02f, -5.14490753e-02f, 5.92636988e-02f, -5.70332371e-02f,
  -6.62694871e-02f, 3.47604454e-02f, -1.10980272e-01f, 5.05286343e-02f, -3.80292237e-02f, -3.85591425e-02f, -9.33470428e-02f, -1.01173140e-01f, -2.47706380e-02f, -7.98172578e-02f,
  -2.36242581e-02f, -5.52256964e-02f, -7.85187557e-02f, 8.24397281e-02f, 1.30078837e-01f, -5.27051799e-02f, 1.05616242e-01f, -1.55318320e-01f, -2.91014761e-02f, 1.38473660e-01f,
  -1.61628142e-01f, -4.93268892e-02f, -9.19123068e-02f, -5.41998893e-02f, 1.14655137e-01f, 8.88048634e-02f, 1.63181484e-01f, -7.45409429e-02f, -6.49715737e-02f, -1.68119416e-01f,
  -1.09808154e-01f, 2.80157458e-02f, 4.50614206e-02f, 1.50461178e-02f, -6.05363473e-02f, -1.52126059e-01f, 8.86647254e-02f, 3.68488021e-02f, 6.65066540e-02f, -6.30703988e-03f,
  -1.21272109e-01f, -4.27852906e-02f, -9.29768831e-02f, -2.31515989e-01f, 2.99788956e-02f, -4.93580662e-02f, 2.92249303e-02f, 1.73502043e-02f, -8.96384269e-02f, 5.35286330e-02f,
  -1.21212313e-02f, -4.53234278e-02f, 4.76456108e-03f, -7.80380890e-02f, -8.05078670e-02f, -3.23398896e-02f, -2.05337964e-02f, 4.93543819e-02f, 1.18380204e-01f, -1.49350092e-01f,
  9.95593071e-02f, -9.04322118e-02f, -5.76813929e-02f, -2.97962315e-02f, 2.27295998e-02f, 1.22608110e-01f, -5.87987117e-02f, 1.05318259e-02f, -5.23807257e-02f, -4.41343710e-02f,
  -1.52331842e-02f, 8.18448961e-02f, 3.85219380e-02f, 6.53785542e-02f, -6.16936050e-02f, -1.39985844e-01f, 6.82903081e-02f, 1.74836721e-02f, -4.95090745e-02f, -7.63986409e-02f,
  -1.18451238e-01f, 5.43626808e-02f, 9.56614781e-03f, -2.66433898e-02f, -4.82176244e-02f, 2.67008040e-02f, -1.14315361e-01f, -9.22140032e-02f, 1.35188743e-01f, 6.60269409e-02f,
  1.01588527e-02f, -3.49714234e-02f, 6.79627731e-02f, 1.14626409e-02f, -5.54017760e-02f, -4.51960638e-02f, 6.53137267e-02f, -1.09178081e-01f, -7.87910894e-02f, -6.15036823e-02f,
  -7.35454485e-02f, 2.54570339e-02f, -8.50888416e-02f, 3.02249901e-02f, -1.61547232e-02f, 6.40237629e-02f, 4.37677838e-02f, 6.71349689e-02f, 8.00495446e-02f, 5.69695011e-02f,
  4.88485582e-02f, 3.24552320e-02f, 8.29001963e-02f, -3.35893445e-02f, -1.16169434e-02f, 4.96891923e-02f, 8.76304880e-02f, -6.85181171e-02f, -9.47234556e-02f, -9.04341489e-02f,
  -5.47566451e-04f, 4.88071553e-02f, 4.26932499e-02f, -3.32668759e-02f, 1.05448298e-01f, -1.02240920e-01f, 2.75255591e-02f, 5.20104244e-02f, -4.82268333e-02f, 1.09311149e-01f,
  1.03133202e-01f, -1.08083347e-02f, 1.08940201e-02f, 8.03023055e-02f, -1.26987752e-02f, 2.35027503e-02f, -2.05657966e-02f, 2.95272022e-02f, -1.10468790e-01f, 4.79491018e-02f,
  7.92599749e-04f, -1.10227674e-01f, -2.54142851e-01f, -6.14081547e-02f, -3.47452983e-02f, 7.95022920e-02f, -1.44379418e-02f, -5.79780266e-02f, 2.35352576e-01f, -7.39856064e-02f,
  6.60549104e-02f, 7.44799478e-03f, -6.47055730e-02f, 5.78969792e-02f, -8.11661929e-02f, 3.97713371e-02f, 8.28139335e-02f, 3.41732129e-02f, -1.41141312e-02f, 6.97090924e-02f,
  -6.08775504e-02f, -9.20566246e-02f, -3.12733799e-02f, 4.05537401e-04f, 6.28058463e-02f, 4.16441746e-02f, 1.21114023e-01f, 1.02005765e-01f, 3.25816162e-02f, 1.73749462e-01f,
  -2.94979624e-02f, 2.79009730e-01f, 1.47586867e-01f, 4.90380898e-02f, -1.62904501e-01f, -5.39312363e-02f, 9.54549015e-02f, -1.34083465e-01f, -3.48557830e-02f, 1.30515918e-01f,
  7.08949193e-02f, 7.87570849e-02f, -4.16351184e-02f, 7.63287470e-02f, 6.74540848e-02f, -2.43475083e-02f, -1.45510612e-02f, 1.11092202e-01f, -8.75949636e-02f, 1.03303850e-01f,
  1.48727149e-01f, -2.00763196e-02f, 3.63396816e-02f, -9.02257040e-02f, -1.14890821e-02f, -2.09355634e-02f, 2.64686551e-02f, -7.49399215e-02f, -3.67868394e-02f, 5.00487201e-02f,
  -1.04639448e-01f, -9.02399595e-04f, 3.34769934e-02f, 1.08771153e-01f, 2.42140014e-02f, 1.94161907e-02f, 8.57534334e-02f, -1.35781884e-01f, -5.71120083e-02f, 9.38734189e-02f,
  5.95175810e-02f, -2.94247898e-03f, 6.80691749e-02f, -3.09243202e-02f, 6.87436089e-02f, 4.08187062e-02f, -5.77761866e-02f, -2.48651635e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 128)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 128;
const float L1_fan_Wp_bar_data[] = {
  -4.00615633e-02f, -8.08212683e-02f, 2.89026089e-02f, 1.24794647e-01f, -1.93003509e-02f, 5.42601272e-02f, 6.33042231e-02f, -5.25373146e-02f, -6.97204396e-02f, 7.11007863e-02f,
  -1.02790907e-01f, -8.49636719e-02f, -4.51143719e-02f, 9.46468636e-02f, 5.15360199e-02f, 5.18314987e-02f, -2.60664262e-02f, 1.15268461e-01f, 1.12899072e-01f, -9.41448584e-02f,
  7.20300078e-02f, 7.73284212e-02f, -5.55203706e-02f, 9.65556502e-02f, 9.78069901e-02f, -5.06107397e-02f, 6.74983412e-02f, -3.19356611e-03f, -2.75382195e-02f, 4.34891284e-02f,
  2.74946727e-02f, 3.30537893e-02f, 6.45847246e-02f, -7.63166472e-02f, -8.28049611e-03f, 7.98568279e-02f, -3.24884877e-02f, -1.01542249e-02f, 1.20717295e-01f, 9.13388729e-02f,
  -3.02951951e-02f, -8.35580826e-02f, 6.38622269e-02f, -2.33089421e-02f, 1.22292131e-01f, -3.38738337e-02f, -4.52848971e-02f, 6.16857186e-02f, 7.37574399e-02f, 7.21945241e-02f,
  -5.89173054e-03f, 6.37642965e-02f, -8.98739845e-02f, 2.48163454e-02f, -2.53255852e-02f, -1.28163502e-01f, 1.49375889e-02f, -3.19919288e-02f, 5.57836927e-02f, 2.55903024e-02f,
  5.57868183e-02f, -9.08855200e-02f, 4.43928577e-02f, -2.28489060e-02f, -9.50227231e-02f, 4.14981544e-02f, 1.21107765e-01f, 7.40595981e-02f, 5.18461429e-02f, -1.08485252e-01f,
  -5.03342859e-02f, -1.44317895e-01f, -1.07294805e-01f, -9.14234594e-02f, -4.92434539e-02f, 7.26611726e-03f, -4.46586125e-02f, 1.04914747e-01f, -9.83626842e-02f, 4.54722010e-02f,
  -9.54242498e-02f, -5.80332335e-03f, -1.38024524e-01f, 8.86212382e-03f, 2.36512516e-02f, 5.85645735e-02f, 3.99252549e-02f, -4.09047119e-02f, 3.46971862e-03f, -4.36308011e-02f,
  -4.45560887e-02f, 1.34179210e-02f, -1.40729189e-01f, -3.69604789e-02f, -1.26521632e-01f, -1.36690095e-01f, -4.22119386e-02f, 2.12359667e-01f, -1.06635958e-01f, -9.78266746e-02f,
  4.79625631e-03f, -7.93094710e-02f, -6.09725388e-03f, 1.26414821e-01f, 3.27052176e-03f, 7.52921179e-02f, 7.36405402e-02f, -3.12406421e-02f, -5.28105497e-02f, 1.80531032e-02f,
  -4.09362018e-02f, -5.25504351e-02f, -3.44340019e-02f, 1.96389984e-02f, 1.14314511e-01f, -1.45882834e-02f, 6.53177872e-02f, 8.41780379e-02f, 1.42786786e-01f, 6.36848211e-02f,
  -1.23656802e-02f, 6.79833293e-02f, 8.00001472e-02f, 6.33186288e-03f, -6.50131479e-02f, 7.74405152e-02f, -7.97767639e-02f, 9.35885534e-02f, 8.12463835e-02f, -6.92051230e-03f,
  1.06748767e-01f, -4.39697169e-02f, 3.82308550e-02f, 6.43781275e-02f, -2.16015950e-02f, -7.17728063e-02f, 8.08442160e-02f, 6.48932764e-03f, 6.65760487e-02f, 1.22092236e-02f,
  1.21115059e-01f, 1.10458337e-01f, -2.29428299e-02f, -8.49872176e-03f, 6.96883276e-02f, 7.40921777e-03f, -5.53714409e-02f, -4.13061120e-02f, -4.93464582e-02f, -2.35385764e-02f,
  -1.93779040e-02f, 3.23255844e-02f, 5.75652272e-02f, 9.67324972e-02f, 3.03570163e-02f, 1.06306458e-02f, 4.06100117e-02f, -4.43850942e-02f, -7.03914687e-02f, 3.09487749e-02f,
  1.14555687e-01f, -6.57424703e-02f, 1.31123677e-01f, 1.46271084e-02f, 1.13386018e-02f, 4.28578146e-02f, 5.91194369e-02f, -2.84298323e-02f, -4.08586413e-02f, 9.76881385e-02f,
  9.32408273e-02f, -1.53761031e-02f, -7.00194910e-02f, 1.11986123e-01f, 1.23984084e-01f, 4.10271548e-02f, 4.14365679e-02f, -5.63280359e-02f, 1.16682783e-01f, -5.35784736e-02f,
  -5.73202111e-02f, 1.05421185e-01f, 1.09939262e-01f, -5.44648506e-02f, -5.39050214e-02f, 5.07436022e-02f, -1.44051671e-01f, -1.06248759e-01f, 9.20923725e-02f, 9.46960002e-02f,
  -4.14225459e-02f, 3.49749178e-02f, -5.77039681e-02f, 5.34670912e-02f, 8.38006753e-03f, -1.02502272e-01f, 9.72705334e-02f, -3.32467258e-02f, 1.79690253e-02f, 7.12993145e-02f,
  -4.11299709e-03f, -1.46323100e-01f, -2.54124496e-02f, -4.33485210e-02f, -8.11396241e-02f, 1.32541090e-01f, 7.50077814e-02f, 4.26763184e-02f, 1.12903431e-01f, -1.46058360e-02f,
  2.38502510e-02f, 6.97315112e-02f, -4.73143235e-02f, 1.07949853e-01f, 5.96485753e-03f, 1.37061030e-01f, -1.04534114e-02f, -3.80370691e-02f, 4.13560458e-02f, -4.40253280e-02f,
  -3.81098986e-02f, -9.91599113e-02f, 8.35421756e-02f, -3.06425081e-03f, 9.90711972e-02f, -8.15354735e-02f, -4.95553799e-02f, -3.41785401e-02f, 2.02299654e-02f, 8.02463740e-02f,
  1.22907065e-01f, 4.85501476e-02f, 8.58078673e-02f, 8.51084962e-02f, -5.90213686e-02f, -2.04674620e-02f, -2.72405930e-02f, -1.59459449e-02f, 6.94021657e-02f, 2.42523495e-02f,
  1.56594768e-01f, 3.26714292e-02f, -1.10246660e-02f, 2.25586221e-02f, 4.42582965e-02f, 9.99876764e-03f, -6.47722185e-02f, -3.00642243e-03f, 4.07599099e-03f, 3.63778025e-02f,
  -5.35026193e-02f, 7.40047023e-02f, -9.23186017e-04f, 6.32100999e-02f, -2.42751348e-03f, 1.29205078e-01f, 1.01128541e-01f, -3.40112709e-02f, 4.77103218e-02f, 9.56572592e-02f,
  8.25247169e-03f, -9.57323387e-02f, 1.01415820e-01f, -2.67956629e-02f, 5.44135235e-02f, 4.73521315e-02f, 1.17645347e-02f, -9.65923071e-02f, 3.86004820e-02f, 4.92650382e-02f,
  2.46623233e-02f, -9.27652325e-03f, -6.29303977e-02f, -3.84925790e-02f, 9.74895582e-02f, -4.42477129e-02f, 8.20855424e-02f, 3.42589268e-03f, -6.84535205e-02f, 8.07320327e-02f,
  8.26166645e-02f, -1.97128672e-02f, -5.19257747e-02f, -3.03976350e-02f, -1.85101479e-03f, -6.73352331e-02f, 9.00945216e-02f, -3.52870338e-02f, -7.91970715e-02f, -1.52506903e-02f,
  1.28853312e-02f, -3.23343053e-02f, 6.46537691e-02f, 7.11093768e-02f, -5.92260920e-02f, 5.96406348e-02f, -3.35846879e-02f, 2.18797736e-02f, 6.62431642e-02f, -8.90190229e-02f,
  2.82568075e-02f, -6.54925650e-04f, -1.00046054e-01f, 9.67390835e-02f, 2.66534500e-02f, -1.62947513e-02f, -6.17457777e-02f, -5.89337712e-03f, -4.92211804e-02f, 7.49496697e-03f,
  -4.73769568e-02f, 3.02407076e-03f, -4.55865748e-02f, 4.40022983e-02f, 4.05679755e-02f, -2.03545149e-02f, 9.12798792e-02f, 4.52130064e-02f, 3.05743795e-02f, -6.34100065e-02f,
  -6.15283698e-02f, -9.41111296e-02f, 1.26887588e-02f, 2.70267557e-02f, -2.78743971e-02f, 3.58876325e-02f, -8.01159143e-02f, -7.71826580e-02f, 3.01085804e-02f, 5.14858738e-02f,
  2.06116028e-03f, 2.43382286e-02f, -7.59868398e-02f, -3.08736041e-03f, 5.92599995e-02f, -1.83651652e-02f, -8.68521482e-02f, -3.15396599e-02f, -7.91525692e-02f, 1.87644698e-02f,
  1.22960052e-02f, 1.64411273e-02f, 1.04780067e-02f, -1.45980576e-02f, -2.87618302e-02f, 5.00354916e-02f, 5.18594794e-02f, 6.29869243e-03f, 6.54314905e-02f, 7.34545849e-03f,
  -8.07943270e-02f, -4.23365235e-02f, -8.28878507e-02f, 3.48147377e-02f, 3.41240987e-02f, -2.42146589e-02f, -6.81892931e-02f, 7.59576559e-02f, 7.76212104e-03f, 2.74079423e-02f,
  4.94188070e-02f, 9.11135674e-02f, 7.54057989e-02f, -4.24538478e-02f, 4.08716612e-02f, -4.70492393e-02f, -1.42449532e-02f, -2.84571517e-02f, -4.21909690e-02f, 7.97188878e-02f,
  2.82466933e-02f, 1.83393694e-02f, 4.00632322e-02f, -2.53183506e-02f, -3.49972285e-02f, 3.56806405e-02f, -1.37718134e-02f, -5.73459896e-04f, -1.67498481e-03f, -6.93141483e-03f,
  -7.50754699e-02f, -4.42245677e-02f, 6.42218515e-02f, 2.79276539e-02f, 4.93222997e-02f, -1.24666207e-02f, 9.02269110e-02f, 1.52891204e-02f, -2.13078782e-02f, 7.66931027e-02f,
  1.25285134e-01f, 7.28248730e-02f, 5.96812069e-02f, 8.53886753e-02f, -5.37173860e-02f, 6.49958774e-02f, -2.33381111e-02f, 3.76407579e-02f, -4.10981895e-03f, 1.19248554e-01f,
  1.34452060e-01f, 6.34740889e-02f, -4.27503884e-03f, 1.06866054e-01f, 8.11114535e-02f, 6.07561432e-02f, 2.12887488e-02f, 1.67176556e-02f, -1.06374454e-02f, -3.08405235e-02f,
  -7.15765916e-03f, 4.93622757e-02f, 1.16640285e-01f, 7.06853420e-02f, 1.33308783e-01f, 2.24249694e-03f, 3.91197763e-02f, 9.39448401e-02f, -3.23208496e-02f, 4.32902500e-02f,
  1.20252389e-02f, -1.74393784e-02f, 9.92207453e-02f, 1.82126928e-02f, -4.43682782e-02f, 5.29889092e-02f, 2.00847983e-02f, 9.13950279e-02f, 5.89767359e-02f, 4.73040082e-02f,
  -2.10344233e-02f, -1.98266227e-02f, 8.41563866e-02f, 5.63748665e-02f, -4.56242729e-03f, 2.47543380e-02f, -1.18182097e-02f, -1.49811991e-02f, -1.37919247e-01f, 5.04134148e-02f,
  1.44548103e-01f, -5.97781464e-02f, 3.79236229e-02f, 7.81423375e-02f, -2.52219159e-02f, -2.68717408e-01f, 1.81864917e-01f, 1.30364239e-01f, 6.56782612e-02f, -1.44865185e-01f,
  -3.06161083e-02f, 8.59852601e-03f, -4.95488234e-02f, 9.36033726e-02f, -1.45687297e-01f, -2.92444136e-02f, 7.64837116e-02f, 7.69933546e-03f, 8.04600716e-02f, -1.39513537e-01f,
  8.69553834e-02f, -1.67133704e-01f, -1.26641989e-01f, -1.72457904e-01f, -4.59423102e-02f, -8.21296312e-03f, -9.78543460e-02f, -4.58272956e-02f, 1.01182953e-01f, -1.48278568e-02f,
  5.72834071e-03f, -7.42618814e-02f, -5.43934181e-02f, -5.21297082e-02f, -6.04991019e-02f, -6.66821375e-02f, 2.61248518e-02f, 1.48959398e-01f, 9.50802416e-02f, -2.19563812e-01f,
  8.87774155e-02f, -8.56178328e-02f, -8.19251090e-02f, 1.49522740e-02f, -2.01107608e-03f, -8.01461264e-02f, -7.50118196e-02f, -1.55748706e-02f, 3.62473764e-02f, 1.26867564e-02f,
  5.57433143e-02f, 2.57542357e-02f, 7.30004301e-03f, -4.99977581e-02f, -3.06573790e-03f, 3.80065441e-02f, -8.80128145e-02f, -1.35353386e-01f, -1.96512174e-02f, -3.13530639e-02f,
  -5.75091764e-02f, 1.36001259e-01f, 9.05713663e-02f, 1.98954553e-03f, -6.50749803e-02f, 6.01991341e-02f, 1.97554715e-02f, -6.49435669e-02f, -6.32409975e-02f, 2.54104491e-02f,
  1.01608075e-02f, -1.61940791e-02f, -4.85233217e-02f, -1.32844314e-01f, 4.63064462e-02f, -5.53803779e-02f, -1.67314578e-02f, 3.92677672e-02f, -5.74205518e-02f, -3.41867730e-02f,
  1.17412977e-01f, 8.30162410e-03f, -4.26926389e-02f, -5.49511276e-02f, 2.71276198e-02f, -2.16618404e-02f, 7.36132041e-02f, 6.99938321e-03f, 7.17086717e-02f, -3.70126814e-02f,
  -1.86337251e-02f, 8.25884845e-03f, -2.10659727e-02f, -4.53841537e-02f, -3.79667617e-02f, 7.90863633e-02f, 7.44330809e-02f, 4.89303470e-02f, -4.24059778e-02f, 7.10102543e-02f,
  5.25766574e-02f, -6.18657321e-02f, -7.68231153e-02f, -6.45484924e-02f, 8.97302758e-03f, 1.84192020e-03f, 6.07489683e-02f, -6.47521764e-02f, -6.88394010e-02f, 6.26953393e-02f,
  1.20335922e-01f, 2.63039730e-02f, 2.56832619e-03f, -1.09174192e-01f, 2.60657351e-03f, -4.91908602e-02f, 8.94091055e-02f, 9.26097557e-02f, 1.01278074e-01f, 5.55048548e-02f,
  -4.89836521e-02f, 7.27769285e-02f, 1.13721378e-01f, -8.30328912e-02f, 9.48464796e-02f, 4.18284200e-02f, 3.48096788e-02f, -1.59538537e-01f, -6.47651926e-02f, 8.37812200e-02f,
  -7.99554139e-02f, -7.70683140e-02f, 4.15643826e-02f, 5.71786948e-02f, 3.29454592e-03f, -1.00226320e-01f, -4.35819514e-02f, 1.13712914e-01f, -1.12732463e-01f, -1.10380761e-01f,
  -7.61173712e-03f, -1.66569546e-01f, 3.15684602e-02f, -1.45194912e-02f, -3.27868983e-02f, -7.70806521e-02f, -3.60974669e-02f, 2.98112780e-02f, -9.13740993e-02f, 1.35691181e-01f,
  -2.46359110e-02f, 9.78155434e-02f, 9.63278040e-02f, -8.42688680e-02f, -1.99614480e-01f, -5.58460839e-02f, 2.57772133e-02f, -3.75624709e-02f, 4.46031913e-02f, 8.30303691e-03f,
  -4.29117307e-02f, -9.11234170e-02f, -5.09581342e-02f, -2.51034629e-02f, -1.81948826e-01f, -1.65447757e-01f, -2.06888050e-01f, -2.28591189e-02f, -7.67526180e-02f, 2.33972948e-02f,
  8.11550394e-02f, 6.34047017e-03f, -1.15950219e-01f, 1.91977993e-02f, 1.19028382e-01f, 1.16498061e-01f, -4.31543514e-02f, -3.27503458e-02f, -2.34143008e-02f, 7.59168193e-02f,
  -3.22619155e-02f, -9.53096710e-03f, 1.84111055e-02f, 6.09661415e-02f, 8.26700479e-02f, 3.38722505e-02f, -2.50223931e-02f, -2.34566014e-02f, 2.36501265e-02f, 2.59516817e-02f,
  8.87852907e-02f, 1.08078107e-01f, -4.14570831e-02f, -4.67211474e-03f, -9.06602144e-02f, 6.42299280e-02f, 2.98436619e-02f, -6.63809478e-02f, 7.97735453e-02f, -4.98577319e-02f,
  1.16622195e-01f, 6.64031953e-02f, 2.09902357e-02f, 1.31864818e-02f, 1.14362977e-01f, 8.87112506e-03f, 8.73775259e-02f, 5.61866760e-02f, 1.26101254e-02f, 8.17039236e-02f,
  7.14893565e-02f, 3.53896767e-02f, -3.03608235e-02f, -1.09075918e-03f, 6.82785213e-02f, 3.22741382e-02f, 1.43511621e-02f, 2.99814697e-02f, -5.84223345e-02f, 5.90174757e-02f,
  1.21032380e-01f, 8.52539539e-02f, 5.27733639e-02f, -2.96206474e-02f, 6.80762008e-02f, -1.57922041e-02f, -6.96485490e-02f, 1.26071826e-01f, 1.08046494e-01f, 1.36464331e-02f,
  1.42729208e-01f, -1.60464719e-02f, -3.52357589e-02f, 4.92380150e-02f, 1.95348915e-02f, 2.58787554e-02f, -5.11431322e-03f, 4.22637502e-04f, 2.00553332e-02f, 1.12848826e-01f,
  -4.72072437e-02f, -9.15254429e-02f, 9.39563438e-02f, 3.47485095e-02f, 3.12976688e-02f, -4.18635122e-02f, -5.32357581e-02f, 5.57191446e-02f, 8.93747136e-02f, 8.51128474e-02f,
  -8.22058395e-02f, -1.39253614e-02f, -2.41255052e-02f, 7.87308067e-02f, -4.10344750e-02f, 3.47063430e-02f, -2.03811243e-01f, 1.61607005e-02f, -6.81367815e-02f, -9.89137739e-02f,
  -2.24797633e-02f, 6.08168207e-02f, 9.55827460e-02f, 1.48885716e-02f, 1.16888814e-01f, 2.47104466e-02f, 1.69817820e-01f, 8.81266966e-02f, -3.55255567e-02f, 8.77684578e-02f,
  8.33702683e-02f, 1.82017628e-02f, 1.44254282e-01f, 1.16314203e-01f, 6.64174929e-02f, -2.83901319e-02f, -1.09787621e-01f, -2.83001065e-02f, -1.05656080e-01f, 2.33010128e-02f,
  2.87710559e-02f, -4.03633254e-04f, 1.08470649e-01f, 3.51632982e-02f, -7.78933838e-02f, 1.15897611e-01f, -1.54276729e-01f, -1.25567187e-02f, -1.44793078e-01f, -1.59714654e-01f,
  -4.61683050e-02f, -1.47890896e-01f, 1.91761643e-01f, 4.73226905e-02f, 5.53829968e-02f, -1.47213280e-01f, 7.83200711e-02f, 5.47554009e-02f, -6.44447654e-02f, -9.57037434e-02f,
  -9.12727118e-02f, -1.81597322e-01f, -5.32449782e-02f, 2.91496748e-03f, -3.28009091e-02f, -6.22073635e-02f, 9.51537415e-02f, 1.10818565e-01f, -1.81749910e-02f, 9.68301594e-02f,
  -3.08862031e-02f, 1.78855702e-01f, -3.00686490e-02f, 8.11792761e-02f, 1.26822919e-01f, -8.44595283e-02f, 8.81168246e-02f, -1.63310859e-02f, -6.96333200e-02f, -1.46832792e-02f,
  -3.05333138e-02f, -2.97989715e-02f, -4.96674068e-02f, -8.69205445e-02f, -4.77673188e-02f, -2.10441668e-02f, 1.81695838e-02f, 1.57348230e-01f, 5.47979549e-02f, 6.83391243e-02f,
  6.86575398e-02f, -3.61125991e-02f, -1.67548843e-02f, 6.77036308e-03f, 4.57990132e-02f, -3.44441682e-02f, 1.03757575e-01f, -3.60409729e-02f, 6.97618201e-02f, 8.28847140e-02f,
  3.34665440e-02f, -1.83165092e-02f, -3.09361815e-02f, -1.12603614e-02f, 1.94143411e-02f, -4.18496877e-03f, 1.13883659e-01f, 8.19838420e-02f, -1.82996001e-02f, 1.85220867e-01f,
  -8.28246847e-02f, 6.09024800e-03f, 9.31671336e-02f, 1.34129757e-02f, 1.06653027e-01f, -3.85348387e-02f, 1.26068398e-01f, 5.44214733e-02f, 2.24806238e-02f, 1.23016752e-01f,
  -2.33870633e-02f, -5.78264892e-02f, -7.54710147e-03f, -4.08932865e-02f, 1.01889241e-02f, -1.02188952e-01f, -1.16630923e-02f, -9.25170165e-03f, 7.96496496e-02f, 1.24001659e-01f,
  1.25797495e-01f, 7.05005601e-03f, -3.14716585e-02f, 6.45539686e-02f, 7.52956644e-02f, 5.13197295e-02f, -3.22991945e-02f, 8.75677392e-02f, 4.19239067e-02f, 6.53887838e-02f,
  -1.56139899e-02f, 3.84178460e-02f, 1.26716569e-01f, 2.11291015e-02f, -4.93476354e-02f, 1.09309204e-01f, -1.46751460e-02f, -1.04660736e-02f, -4.46823388e-02f, 1.97519749e-01f,
  -5.48475273e-02f, 1.42960995e-02f, -3.45804468e-02f, -2.66930033e-02f, -1.14466324e-01f, -2.21648827e-01f, 3.30225937e-02f, -3.29748951e-02f, -1.37814889e-02f, 4.20361795e-02f,
  2.10626852e-02f, -1.32529572e-01f, -9.83613655e-02f, -3.94259132e-02f, 1.18545093e-01f, -3.82612273e-02f, 1.85637474e-01f, 2.59173159e-02f, -5.72899319e-02f, -1.34145737e-01f,
  2.32946686e-02f, 4.24014026e-04f, 4.52466831e-02f, -1.56350076e-01f, -6.32072985e-02f, 4.18080352e-02f, 1.89747976e-03f, 1.22934043e-01f, -1.31039638e-02f, -6.61788061e-02f,
  1.06718481e-01f, 1.14601374e-01f, 1.01373054e-01f, 1.43476622e-02f, -3.18775885e-02f, -1.81819230e-01f, -3.00496537e-02f, -1.84799396e-02f, -8.43535587e-02f, 5.31659313e-02f,
  1.62335366e-01f, -2.63864007e-02f, 8.20659660e-03f, 2.99819671e-02f, -2.99162194e-02f, -1.46755025e-01f, -3.91949937e-02f, 1.13849215e-01f, -1.22632049e-02f, 1.26270160e-01f,
  -3.72954160e-02f, 5.88403782e-03f, -4.09883000e-02f, 1.45277217e-01f, -3.06829400e-02f, 3.18116285e-02f, -9.94811952e-02f, -1.23014793e-01f, 3.80684435e-02f, -2.53908476e-03f,
  -7.37440661e-02f, -2.78384262e-03f, 1.00210551e-02f, -6.65629879e-02f, -2.08880641e-02f, 1.68309957e-01f, -1.49480263e-02f, -1.19698390e-01f, -4.36675139e-02f, 7.22125592e-03f,
  1.98006555e-02f, 9.10194367e-02f, 6.12814017e-02f, 4.61606123e-02f, 7.23677501e-02f, -6.27015391e-03f, -7.63557777e-02f, -1.53067745e-02f, 2.96292198e-03f, 2.17039865e-02f,
  9.12991539e-02f, 1.44158816e-02f, 6.01044409e-02f, 1.28311832e-02f, 9.39613022e-03f, 4.92429361e-02f, 1.17952213e-01f, 4.55600880e-02f, -2.17868965e-02f, 2.90771369e-02f,
  4.20514010e-02f, 5.88897020e-02f, -3.62815745e-02f, 1.23709321e-01f, 5.70869930e-02f, 1.02493547e-01f, 2.66626384e-02f, 6.48232028e-02f, 7.91572630e-02f, -8.35622400e-02f,
  -3.65613028e-02f, 8.49895999e-02f, -6.03184775e-02f, 6.57963306e-02f, 1.23616144e-01f, 5.43813482e-02f, -1.50131304e-02f, -1.37703612e-01f, 3.93835269e-02f, 1.24477437e-02f,
  -4.82023284e-02f, 6.48626462e-02f, 7.97760785e-02f, -4.23261411e-02f, -5.48089296e-02f, -2.62034107e-02f, 6.93730414e-02f, -4.79763895e-02f, -9.45270136e-02f, 3.64167802e-02f,
  -6.32186532e-02f, -9.79822651e-02f, 6.35121614e-02f, 5.32687195e-02f, 4.20058034e-02f, -6.45738933e-03f, 1.28185779e-01f, -7.95146450e-02f, 1.23505637e-01f, 8.07332844e-02f,
  5.13431691e-02f, -1.07763395e-01f, 5.30891418e-02f, -7.71103576e-02f, -1.09627016e-01f, -8.52390528e-02f, 7.17870742e-02f, -5.74233010e-02f, 2.93652457e-03f, -1.30914286e-01f,
  1.06882550e-01f, -9.57147107e-02f, 1.99420601e-02f, -3.19521204e-02f, -4.18341868e-02f, -2.81617213e-02f, -7.46594742e-02f, 4.84001078e-02f, -1.05230182e-01f, -1.12907588e-01f,
  -1.11628622e-01f, 1.45135904e-02f, -2.51772609e-02f, 5.96753135e-02f, -8.94425903e-03f, -5.18856868e-02f, 6.57531470e-02f, 4.13535647e-02f, 3.95432636e-02f, -1.72768384e-02f,
  -9.69876200e-02f, -8.76837298e-02f, -7.43917078e-02f, 4.85013947e-02f, -4.10045199e-02f, 5.69606163e-02f, 5.14755845e-02f, -6.87950850e-02f, 3.76512855e-02f, 5.24596684e-02f,
  -3.69469561e-02f, 7.63146803e-02f, 1.00795865e-01f, 7.93158188e-02f, -7.33691454e-02f, -3.02125029e-02f, 4.52566426e-03f, 1.71799064e-02f, -3.27079669e-02f, 8.74688029e-02f,
  6.80860057e-02f, -5.42036518e-02f, -4.25859876e-02f, -5.72956949e-02f, -6.71493635e-02f, 1.07611522e-01f, 2.14824826e-02f, 9.53487679e-02f, -4.28613871e-02f, -9.40960273e-02f,
  -6.80517256e-02f, 7.38319084e-02f, 6.28126487e-02f, 9.58521962e-02f, 9.22086537e-02f, 1.21321023e-01f, 6.99009001e-02f, -4.50643152e-02f, 1.00418493e-01f, 1.13728806e-01f,
  -2.73691993e-02f, 1.30576089e-01f, 1.12503404e-02f, 1.31025568e-01f, 4.22485471e-02f, 8.37785229e-02f, 1.16802536e-01f, 8.54783691e-03f, 6.83555827e-02f, -3.66666093e-02f,
  -8.22752994e-03f, 3.32194306e-02f, 9.89373848e-02f, 1.02285586e-01f, -7.02495724e-02f, -3.64723839e-02f, -7.69734150e-03f, -3.22152004e-02f, 1.07158929e-01f, 4.57631163e-02f,
  2.31896732e-02f, 8.97614062e-02f, -5.49192093e-02f, 4.82501946e-02f, 1.70578271e-01f, -3.77969518e-02f, 3.61458957e-02f, 2.40507647e-02f, 6.44328222e-02f, 1.02171473e-01f,
  3.74976955e-02f, 1.65943708e-03f, -1.49201714e-02f, 8.31929594e-02f, 8.63273144e-02f, 8.43564495e-02f, 3.17252576e-02f, 3.55873778e-02f, -6.91360235e-02f, 3.54906991e-02f,
  -7.55036995e-02f, -3.83566953e-02f, 3.65415476e-02f, -2.29077190e-02f, 3.58974375e-02f, 1.92599148e-02f, 2.50736959e-02f, 2.42827218e-02f, 7.21232593e-02f, 6.95145801e-02f,
  2.54353918e-02f, 6.92397356e-02f, -9.11093131e-02f, 1.12266473e-01f, 2.36236937e-02f, -1.05452687e-01f, -9.03169066e-03f, 4.90422808e-02f, -6.34764209e-02f, -8.69013444e-02f,
  -1.02513984e-01f, 7.74187893e-02f, -9.28255543e-02f, -3.71297337e-02f, -4.23533050e-03f, 3.96737382e-02f, 1.41620263e-01f, -3.17623392e-02f, -5.07343300e-02f, 5.32661155e-02f,
  1.31424055e-01f, -9.66493785e-02f, 1.04697354e-01f, -1.77375957e-01f, -8.87540579e-02f, 1.31529225e-02f, 4.28797975e-02f, 5.89229772e-03f, 1.35255903e-01f, -1.01414509e-01f,
  -1.46749876e-02f, -4.23721336e-02f, -5.30969240e-02f, 3.57821696e-02f, 8.42309184e-03f, 1.22440346e-01f, 1.80997267e-01f, 1.60179377e-01f, 1.63188994e-01f, -5.08145019e-02f,
  -2.96210544e-03f, -1.39150679e-01f, 3.08487695e-02f, -4.87196706e-02f, 7.32793957e-02f, -2.03126762e-02f, 5.40243685e-02f, 4.72465716e-02f, -3.67496349e-02f, -6.52832910e-02f,
  1.24406971e-01f, 1.07432000e-01f, -6.30394667e-02f, -7.47188032e-02f, 1.41414508e-01f, 2.08167378e-02f, 2.48767268e-02f, -1.03931047e-01f, 5.82987070e-03f, 1.19125247e-01f,
  -8.33205227e-03f, 1.57167599e-01f, -4.27588867e-03f, -1.26047224e-01f, -5.09167649e-02f, 2.89663561e-02f, 9.12878513e-02f, 1.02411680e-01f, -1.72183588e-02f, -2.51546744e-02f,
  -4.21013087e-02f, -7.76495636e-02f, -4.42075059e-02f, 8.33718777e-02f, 2.14897282e-02f, 6.36839271e-02f, 8.03920478e-02f, -8.28223303e-02f, 6.80105612e-02f, 1.02453932e-01f,
  -2.95235738e-02f, 8.52912962e-02f, 1.00739159e-01f, 1.49661731e-02f, -2.70435773e-02f, -2.46518403e-02f, -1.97960325e-02f, 2.56118346e-02f, 1.38941839e-01f, 3.88746709e-02f,
  1.10714927e-01f, 6.15049116e-02f, -5.74179040e-03f, 1.04627587e-01f, 7.90328979e-02f, 3.88958640e-02f, 1.05140798e-01f, -4.59856205e-02f, -7.70473778e-02f, -6.98065162e-02f,
  -3.16213146e-02f, 6.81468612e-03f, 1.67832747e-01f, 1.34547383e-01f, 5.07722758e-02f, 1.65375575e-01f, -5.11947498e-02f, -3.98506364e-03f, 5.84809594e-02f, 1.24959335e-01f,
  -5.97842336e-02f, 3.31713259e-02f, 2.82899830e-02f, 1.76495984e-01f, 8.57082233e-02f, 1.26136094e-01f, 1.96560398e-02f, -6.16828166e-02f, -9.42068920e-02f, 8.78749415e-02f,
  -3.50266248e-02f, 4.24490822e-03f, -1.07183773e-02f, 1.03860542e-01f, -6.10380024e-02f, -1.43365100e-01f, -1.40982121e-01f, -2.11653505e-02f, -7.78140798e-02f, -2.93426076e-03f,
  8.26548412e-02f, 8.23179930e-02f, -5.40501289e-02f, 2.67354515e-03f, 9.82715338e-02f, 6.76077679e-02f, 1.03697225e-01f, -8.92519951e-02f, 2.93138414e-03f, -2.62034740e-02f,
  4.01959866e-02f, 7.55895302e-02f, 8.38387534e-02f, -7.78800920e-02f, 7.59324729e-02f, 1.59672469e-01f, 8.99944007e-02f, -8.12978148e-02f, -1.41785212e-03f, -8.94706845e-02f,
  -8.71708691e-02f, -8.23369995e-02f, 7.37592727e-02f, -1.26928594e-02f, -1.37965679e-01f, -9.45561901e-02f, 1.73748091e-01f, -6.02747612e-02f, -7.05093071e-02f, -4.76046018e-02f,
  5.17431460e-02f, -1.45901190e-02f, -9.94214565e-02f, -6.59517795e-02f, 2.85606124e-02f, 2.29315292e-02f, -2.45558824e-02f, -2.07135677e-02f, 1.77317653e-02f, 6.24393113e-02f,
  -5.55447936e-02f, -8.32369402e-02f, -1.64318662e-02f, -7.73200346e-03f, -2.76250057e-02f, -4.31489497e-02f, -4.80120815e-02f, -8.41163397e-02f, 3.61054763e-02f, -8.01041499e-02f,
  7.92800859e-02f, -1.14888087e-01f, 1.24651222e-02f, -8.79381001e-02f, -4.83034179e-02f, -2.79271565e-02f, 1.18051134e-01f, 1.91818196e-02f, 3.40107642e-03f, 1.46905839e-01f,
  5.59362806e-02f, -1.05417818e-01f, -6.92490712e-02f, 7.96229541e-02f, 1.02126554e-01f, -9.74079408e-03f, 9.36777443e-02f, 8.13285559e-02f, 1.31530404e-01f, 1.14970822e-02f,
  1.08927891e-01f, 6.74747974e-02f, 2.63115223e-02f, -3.94279230e-03f, 1.20062083e-01f, -9.65205133e-02f, 1.20672308e-01f, 5.57592809e-02f, 9.73906666e-02f, 1.28010679e-02f,
  -3.84757891e-02f, 6.93438277e-02f, -5.06148934e-02f, 7.56541491e-02f, -3.04417145e-02f, 3.01564503e-02f, 1.26303628e-01f, 8.25880095e-02f, 1.71039663e-02f, -7.92994499e-02f,
  7.61705860e-02f, -1.63366776e-02f, -3.49667482e-02f, 1.10774517e-01f, -3.48631069e-02f, -1.37564540e-02f, 1.75594911e-02f, 1.00699827e-01f, -1.10571552e-02f, 6.22161776e-02f,
  1.17076440e-02f, -5.69786988e-02f, 6.77791908e-02f, 1.01465948e-01f, 1.17169954e-02f, -2.95391437e-02f, 1.05548829e-01f, 1.38956094e-02f, 3.04540489e-02f, 6.37251418e-04f,
  5.63580394e-02f, 3.45631093e-02f, 5.46375196e-03f, 2.57283635e-02f, 4.73909788e-02f, 8.36150646e-02f, -6.39032722e-02f, 1.16423659e-01f, 5.14055863e-02f, 8.34299177e-02f,
  4.03816029e-02f, -1.34454489e-01f, -1.70351844e-02f, -1.51728392e-01f, -1.10917106e-01f, 4.18210961e-02f, -6.09348305e-02f, 5.56735545e-02f, 1.17046140e-01f, -4.65155169e-02f,
  -6.63771406e-02f, 1.08661547e-01f, -1.44446552e-01f, -3.37780751e-02f, -2.87160147e-02f, 9.28463638e-02f, 3.26558836e-02f, -3.90016101e-02f, 1.92754455e-02f, -1.08078480e-01f,
  8.54315050e-03f, -3.61029059e-02f, -4.16071899e-02f, 1.53599635e-01f, -3.52922082e-02f, -5.40234905e-04f, -9.01831165e-02f, 7.66006019e-03f, -2.64815595e-02f, 9.27138180e-02f,
  2.96842624e-02f, 8.03011134e-02f, -1.39175490e-01f, 3.49167064e-02f, -4.08966430e-02f, -1.06975744e-02f, 7.25245476e-02f, -1.21268451e-01f, 2.19133943e-02f, 1.42154926e-02f,
  1.77310091e-02f, 8.54412168e-02f, -1.16043717e-01f, 2.46427581e-02f, -9.09785554e-02f, 6.92299679e-02f, 5.96045367e-02f, 1.73226461e-01f, -7.68755525e-02f, -8.61563310e-02f,
  -3.34560163e-02f, 2.17183214e-02f, 7.99194947e-02f, 1.03635617e-01f, -1.37030650e-02f, -7.96373636e-02f, -7.17883706e-02f, -6.72957823e-02f, -2.70476937e-02f, -2.33927220e-02f,
  -4.70634513e-02f, -5.05796410e-02f, 7.75523707e-02f, 2.00011507e-01f, -4.82778549e-02f, -2.93479040e-02f, 5.78085519e-02f, 5.07296212e-02f, 1.78080052e-01f, 3.00189853e-02f,
  1.05455235e-01f, 1.23231150e-01f, 6.43334389e-02f, 8.47823247e-02f, -5.32214763e-04f, -6.53698202e-03f, -6.80350885e-02f, -2.88833398e-02f, 8.27374905e-02f, 1.87154915e-02f,
  -3.53742251e-03f, -7.58839846e-02f, 3.33107375e-02f, 6.32560030e-02f, 5.41182421e-03f, 8.87795985e-02f, 5.47264181e-02f, -4.90858518e-02f, -7.82116055e-02f, -8.43542367e-02f,
  -3.08755934e-02f, -4.39893976e-02f, -6.45539537e-02f, -4.43579815e-03f, 3.31639685e-02f, -1.71270575e-02f, -3.79146561e-02f, -2.69577596e-02f, 1.44642573e-02f, -4.53532971e-02f,
  1.79771911e-02f, -8.58580172e-02f, -8.25059488e-02f, 2.17292290e-02f, 6.03451915e-02f, 3.50849181e-02f, 7.79700428e-02f, 7.68393874e-02f, 9.74061340e-03f, -6.86416961e-03f,
  -4.54582348e-02f, -3.73537801e-02f, 4.40128334e-02f, -1.15695717e-02f, -4.49784249e-02f, 3.00728027e-02f, -2.43901778e-02f, 5.48646376e-02f, -4.25441489e-02f, 6.97491243e-02f,
  -2.32753367e-03f, -4.93653268e-02f, -6.30906597e-02f, 7.97918439e-02f, -4.08370569e-02f, -5.57953417e-02f, -3.62532423e-03f, -3.30366641e-02f, 6.53712675e-02f, 2.15393659e-02f,
  7.56036714e-02f, 4.83682007e-02f, -3.64596620e-02f, 2.04305705e-02f, -3.58099081e-02f, -4.92448285e-02f, -3.86198238e-02f, -4.09297608e-02f, -3.27126645e-02f, -1.40317678e-02f,
  1.49251260e-02f, 4.91054691e-02f, 7.05136508e-02f, 1.75269302e-02f, -4.18552160e-02f, -4.30626981e-02f, -5.28989471e-02f, 7.88474903e-02f, 6.72005862e-02f, 1.37468949e-02f,
  -3.76345031e-02f, -7.94345699e-03f, -8.21573287e-02f, 2.59562489e-02f, 2.76746601e-02f, 3.31324749e-02f, -4.86367270e-02f, -8.37360509e-03f, -2.56189983e-02f, 2.30939742e-02f,
  3.29175256e-02f, 5.39170466e-02f, -3.73486942e-03f, -1.59963965e-02f, 7.44011402e-02f, 6.50281087e-02f, 3.80867496e-02f, 6.55646250e-02f, 6.67599514e-02f, 5.34802862e-02f,
  4.58072908e-02f, -3.59679870e-02f, -7.28561953e-02f, 5.83094172e-03f, 3.66333723e-02f, 3.85258980e-02f, 2.71311440e-02f, 4.24501933e-02f, 4.62275147e-02f, -3.03844281e-04f,
  -6.60503283e-02f, -1.42631326e-02f, -6.26819432e-02f, 8.66769254e-02f, -8.37953389e-02f, 5.89880832e-02f, -8.56616125e-02f, 2.05128435e-02f, 5.17586805e-02f, -4.51125614e-02f,
  2.16105338e-02f, -8.27710107e-02f, -7.44732991e-02f, 1.42995100e-02f, -4.96556833e-02f, -9.14296322e-03f, 3.07690874e-02f, -6.71727136e-02f, 7.48159736e-02f, 4.59183939e-02f,
  1.50334397e-02f, 6.38613403e-02f, 7.84163401e-02f, 5.16331606e-02f, -8.50643963e-02f, -3.43568064e-02f, 5.95031977e-02f, 1.28344253e-01f, 1.31741473e-02f, -4.49854806e-02f,
  1.37672974e-02f, -3.29405330e-02f, 5.61302975e-02f, 1.92228079e-01f, -6.93483790e-03f, -6.93179434e-03f, 1.73775539e-01f, 2.59916633e-02f, -5.04198596e-02f, 2.29680426e-02f,
  1.20412208e-01f, 1.23869143e-01f, 3.74542959e-02f, -2.04514042e-02f, -3.02681550e-02f, 9.52689648e-02f, 4.56280299e-02f, 6.61036968e-02f, 8.55358839e-02f, 5.41447625e-02f,
  1.17534310e-01f, 6.49683028e-02f, 7.20303729e-02f, 1.21057682e-01f, -2.02766974e-02f, 1.32926896e-01f, -5.24466718e-03f, -5.71040101e-02f, 1.09611854e-01f, 9.26267356e-02f,
  -6.02587461e-02f, 1.19454497e-02f, 8.98004919e-02f, 1.18330345e-01f, 3.51966545e-02f, -2.23100353e-02f, -2.43332069e-02f, 6.56678304e-02f, 9.48569328e-02f, 6.43096343e-02f,
  -2.73648985e-02f, -4.19788472e-02f, 1.31014258e-01f, -4.28022780e-02f, -2.00059880e-02f, 6.09929226e-02f, -1.59928333e-02f, -1.74174979e-02f, 2.72095352e-01f, 9.68313776e-03f,
  -7.92807862e-02f, 7.24525750e-02f, -2.09053844e-01f, 4.40991744e-02f, -9.76001620e-02f, 5.70152327e-02f, -1.78589478e-01f, 8.08266550e-02f, 7.16191530e-02f, 2.53524855e-02f,
  1.81135893e-01f, -4.91859280e-02f, -6.66917413e-02f, -1.65345892e-02f, -3.72900218e-02f, 9.44513306e-02f, 7.94333220e-02f, 1.01749621e-01f, 6.68181106e-02f, 7.22637400e-02f,
  8.76721963e-02f, 4.89596315e-02f, -5.31135835e-02f, -1.61496833e-01f, -1.30804554e-01f, -1.39080947e-02f, 9.59700719e-02f, -1.38761178e-01f, 2.18139496e-02f, 2.22379528e-02f,
  1.29817888e-01f, 1.68300478e-03f, -1.72486961e-01f, -1.40965721e-02f, -2.11827252e-02f, -1.23898126e-01f, 9.76412091e-03f, -8.30328763e-02f, 3.38366218e-02f, 9.58193988e-02f,
  2.62976233e-02f, 3.46530527e-02f, 4.49658856e-02f, -8.64432082e-02f, 1.04061486e-02f, 1.62083711e-02f, -1.58680409e-01f, -1.47162884e-01f, -1.83466747e-02f, 7.48450235e-02f,
  -5.81335975e-03f, 7.55703226e-02f, -1.98577810e-02f, 1.14848964e-01f, 4.10876609e-02f, -1.11760937e-01f, -5.66016957e-02f, 9.57608223e-03f, -9.56141502e-02f, 1.74454488e-02f,
  -5.43625653e-03f, 1.01092309e-01f, -7.22272024e-02f, -8.76195356e-02f, -9.78044979e-03f, 1.10260762e-01f, 2.65299752e-02f, 3.83688509e-02f, 4.74484302e-02f, 1.44787580e-02f,
  -8.98432732e-02f, -1.10621095e-01f, 7.77760372e-02f, 7.70306587e-02f, 2.02387981e-02f, -5.43367825e-02f, 2.94376444e-02f, 6.96261004e-02f, -5.60125783e-02f, 6.43103942e-02f,
  -5.57834730e-02f, -6.36236817e-02f, 8.85186493e-02f, 2.98666563e-02f, 7.20647573e-02f, 9.85969007e-02f, 2.15489380e-02f, 6.42865002e-02f, -1.17309457e-02f, 9.52586606e-02f,
  2.40753256e-02f, -2.24316232e-02f, -2.20019165e-02f, -1.39890739e-03f, 8.59637633e-02f, -3.88026088e-02f, 3.25482339e-02f, 6.15238845e-02f, -4.87491079e-02f, 7.13004321e-02f,
  9.83354896e-02f, -8.88302401e-02f, 9.31449309e-02f, -5.34914359e-02f, -6.19591353e-03f, 4.18069698e-02f, 3.97366509e-02f, 1.03232237e-02f, 1.67190824e-02f, 7.13893995e-02f,
  -1.98715348e-02f, -5.78591414e-02f, -4.87720892e-02f, -4.51955721e-02f, 9.90042388e-02f, 1.50839044e-02f, 5.55173308e-02f, 8.97025969e-03f, 4.46279012e-02f, 2.68650185e-02f,
  2.87275538e-02f, 1.26677543e-01f, -3.82274911e-02f, 5.89572126e-03f, 1.25669241e-01f, -4.14285995e-02f, -1.28227333e-02f, 8.39446187e-02f, 8.44494104e-02f, 1.67777836e-02f,
  9.97013971e-02f, -4.89829369e-02f, 7.05452859e-02f, -4.02494799e-03f, -4.16644616e-03f, -9.15329903e-02f, -7.23697692e-02f, -1.02853365e-01f, -2.19659600e-02f, -1.01797879e-01f,
  4.17546071e-02f, -7.39198225e-03f, 5.38767911e-02f, -6.95692748e-02f, -1.00240633e-01f, 2.44651902e-02f, -4.70811389e-02f, -6.78808540e-02f, -6.15074039e-02f, 2.19824426e-02f,
  9.29763615e-02f, -7.53005296e-02f, -2.32151290e-03f, 3.51860262e-02f, -5.65165840e-02f, -3.71016562e-02f, 8.90678838e-02f, 9.32101998e-03f, -5.14099784e-02f, -9.10703316e-02f,
  4.79551917e-03f, 9.71903950e-02f, -5.44555206e-03f, 7.33903423e-02f, -5.68670966e-02f, 8.60200822e-02f, 9.69494134e-02f, 5.01385890e-02f, 1.23759564e-02f, 1.28228245e-02f,
  1.57610755e-02f, -1.41435727e-01f, -6.77241385e-02f, -6.79582777e-03f, -4.19676583e-03f, 1.08369969e-01f, 6.50012959e-03f, 1.02376752e-01f, -2.48523764e-02f, 7.52512366e-02f,
  -3.85235101e-02f, -6.87347502e-02f, -6.91190362e-02f, -8.22288077e-03f, 4.28838022e-02f, 2.14703903e-02f, -3.25246565e-02f, -1.66259683e-03f, 1.13337981e-02f, 4.92949560e-02f,
  8.41724575e-02f, -1.97447594e-02f, 9.90237109e-03f, 3.68845707e-04f, 6.73379377e-02f, -6.99387789e-02f, -2.29600091e-02f, 1.85755454e-03f, 1.61473043e-02f, 5.42625822e-02f,
  -5.45972027e-02f, 5.80213964e-02f, 3.06217466e-02f, 5.83635308e-02f, 5.23297954e-03f, -5.67867467e-03f, 6.98284656e-02f, -1.46870175e-03f, 1.28696561e-01f, -4.72206026e-02f,
  5.59915453e-02f, 8.30003321e-02f, 1.06297567e-01f, 1.68398768e-01f, -1.30344331e-02f, 2.94092651e-02f, 8.76645520e-02f, 8.28390345e-02f, -1.43860998e-02f, 1.86142768e-03f,
  7.48498663e-02f, 1.59864232e-01f, 2.42767809e-03f, -5.21062762e-02f, 1.41729400e-01f, 1.77814942e-02f, 7.27129504e-02f, 7.87321478e-03f, 1.67149588e-01f, 4.46535088e-02f,
  -2.67736204e-02f, 1.25685811e-01f, -5.52161224e-02f, 9.30348933e-02f, 1.34920254e-01f, 6.42797425e-02f, 1.26455501e-01f, 1.06058426e-01f, 1.17151201e-01f, 4.99216802e-02f,
  7.11078048e-02f, -3.66712059e-03f, 1.26501262e-01f, 5.21845929e-02f, 1.34273618e-01f, 7.12959915e-02f, 1.40484810e-01f, 2.79526622e-03f, 5.54448180e-03f, 1.20113067e-01f,
  -3.93254459e-02f, 4.43150336e-03f, 1.50011733e-01f, -8.93872082e-02f, -1.42143488e-01f, -1.22749552e-01f, -7.07492884e-03f, -9.75949243e-02f, 1.52315602e-01f, -5.25937527e-02f,
  1.65975764e-01f, 9.57011804e-02f, 9.45767537e-02f, -3.87768596e-02f, 1.61177050e-02f, 4.81299963e-03f, 4.73282523e-02f, 1.00353025e-02f, 9.98902414e-03f, -1.26467133e-02f,
  1.03649825e-01f, 6.97966591e-02f, -9.36881676e-02f, 1.15162827e-01f, -1.29100025e-01f, -1.45100012e-01f, 1.51843391e-02f, 1.01433605e-01f, 1.32833555e-01f, 1.72408838e-02f,
  1.61944076e-01f, 7.44666681e-02f, -7.28661865e-02f, 1.68295383e-01f, 1.53340283e-03f, 1.22150527e-02f, -1.13999777e-01f, 7.13296118e-04f, 1.99692428e-01f, 9.88691896e-02f,
  1.87434718e-01f, 1.94067731e-01f, 7.45651051e-02f, 1.47829846e-01f, -1.64781705e-01f, -5.37120178e-02f, 5.70729524e-02f, 1.88959539e-01f, 6.01130119e-03f, -3.34508419e-02f,
  1.01941414e-01f, 1.91885233e-01f, 6.18462525e-02f, 1.25801533e-01f, -1.40647590e-02f, -2.49757003e-02f, 7.58973584e-02f, 9.08858851e-02f, -9.96651351e-02f, 5.33687919e-02f,
  -6.52590534e-05f, 1.77557524e-02f, -2.28833593e-02f, -1.49482593e-01f, -3.96360829e-02f, -4.49064150e-02f, 1.51998913e-02f, 4.03681956e-02f, -1.45890033e-02f, -6.18058257e-02f,
  -8.57419223e-02f, 6.77489564e-02f, 2.67032590e-02f, 4.88310531e-02f, 8.44096616e-02f, 3.17074209e-02f, 4.00379673e-02f, -3.44377458e-02f, -9.64861214e-02f, -1.44332200e-01f,
  -1.29680363e-02f, 3.18536274e-02f, -3.50490981e-03f, 6.46212548e-02f, 8.86724703e-03f, -6.12507425e-02f, 7.34484717e-02f, 1.12763466e-02f, 6.16446249e-02f, 4.98338863e-02f,
  1.06473133e-01f, 3.62200513e-02f, -5.20643108e-02f, 6.87349662e-02f, 4.15979065e-02f, -9.26704109e-02f, 1.98641177e-02f, 7.98317511e-03f, 1.21693119e-01f, 9.07252058e-02f,
  -9.19139534e-02f, 1.54804111e-01f, -4.59898785e-02f, -2.29010321e-02f, 7.38545284e-02f, -5.34612127e-02f, 8.44902843e-02f, 7.16149211e-02f, 4.69819121e-02f, 2.11456744e-03f,
  8.67577121e-02f, 5.78333139e-02f, 2.89248880e-02f, 7.96149019e-03f, -9.97863933e-02f, -4.07581665e-02f, 8.73111337e-02f, 5.66909090e-02f, 8.84730518e-02f, 6.54318258e-02f,
  -3.29699949e-03f, 1.36538967e-02f, -7.16875717e-02f, -8.08065012e-03f, 1.08887598e-01f, 5.37433177e-02f, -2.12762337e-02f, -4.81173396e-02f, 1.18182443e-01f, 6.80518299e-02f,
  -2.19870098e-02f, 6.74777776e-02f, 3.23573127e-02f, -5.06688356e-02f, 7.01663941e-02f, -1.63811576e-02f, -1.27739673e-02f, 9.37927812e-02f, -8.25290754e-02f, -5.79134710e-02f,
  2.59100460e-02f, 9.97019410e-02f, -3.59213986e-02f, -3.90744321e-02f, 4.68925238e-02f, -4.11826335e-02f, -1.06434353e-01f, -9.68958661e-02f, -2.34944606e-03f, -1.15690075e-01f,
  1.16764687e-01f, 3.99446534e-03f, 6.21235296e-02f, -9.42568108e-02f, 5.56374714e-03f, -9.61423069e-02f, -3.04048583e-02f, 1.42081669e-02f, -3.62300798e-02f, 2.48870291e-02f,
  -4.22903290e-03f, -1.27126053e-02f, 3.42306755e-02f, -9.52643156e-02f, 7.35727400e-02f, -1.11604393e-01f, -9.48657542e-02f, 1.42433405e-01f, -7.15568066e-02f, -7.37375244e-02f,
  6.92991912e-02f, -2.67938767e-02f, -8.76699612e-02f, -1.17885605e-01f, -2.77480111e-02f, -2.71790437e-02f, 9.31758806e-02f, 2.82485876e-02f, 1.22972146e-01f, -5.73807061e-02f,
  4.04541902e-02f, 1.41775329e-02f, 2.53848936e-02f, 8.06008950e-02f, 4.97983955e-02f, -6.95050284e-02f, -1.83080987e-03f, -3.77939604e-02f, -5.99439032e-02f, 3.85017209e-02f,
  1.21641330e-01f, 2.28496036e-03f, 1.59806013e-02f, -3.23307179e-02f, 6.07755110e-02f, 3.41043212e-02f, -5.30817062e-02f, 9.13008526e-02f, 5.00614382e-03f, 4.96799015e-02f,
  5.38750971e-03f, -8.54780301e-02f, -3.51502188e-02f, -1.34412581e-02f, 2.51096431e-02f, -1.67603337e-03f, 4.41195816e-02f, 1.00200981e-01f, 4.52391692e-02f, -2.11010464e-02f,
  3.17704156e-02f, -8.17169324e-02f, -1.22178858e-02f, 4.39422280e-02f, -7.08968416e-02f, 6.88843280e-02f, 4.12823632e-02f, 3.89971919e-02f, 2.14168802e-02f, -6.12597391e-02f,
  -1.06350183e-02f, 5.63516095e-02f, -3.56400535e-02f, -4.98937592e-02f, -3.94873954e-02f, 1.14841275e-02f, 6.75076991e-02f, -6.50788695e-02f, -5.38485795e-02f, 2.82616392e-02f,
  6.15823045e-02f, -7.43247122e-02f, -1.00863604e-02f, -4.72841226e-02f, -7.39155561e-02f, -2.18696911e-02f, -3.46195847e-02f, -3.72243784e-02f, 4.45224345e-02f, -3.44928093e-02f,
  -9.05045792e-02f, 7.78059587e-02f, -1.26613388e-02f, 2.61885058e-02f, -3.00152949e-03f, -7.27730021e-02f, -8.92908499e-02f, -3.39419283e-02f, 1.98088195e-02f, -6.45576138e-03f,
  -7.75671601e-02f, -4.13221195e-02f, 8.81668366e-03f, -3.68876383e-02f, -3.15450765e-02f, 2.57786978e-02f, 7.15107545e-02f, -3.60656381e-02f, 8.26876238e-02f, -2.32122317e-02f,
  7.25474907e-03f, 6.27095178e-02f, -5.14425337e-02f, -6.37334734e-02f, 1.08449291e-02f, 1.65344458e-02f, 4.99063581e-02f, -4.71972711e-02f, -5.81094325e-02f, -7.16155395e-02f,
  1.22320494e-02f, -1.29463011e-02f, -7.15547055e-02f, 3.58574502e-02f, -1.45973926e-02f, 8.50419234e-03f, 3.91502772e-03f, 1.65272094e-02f, -5.12530431e-02f, -3.29245664e-02f,
  -5.44835720e-03f, 4.41983491e-02f, 6.61926493e-02f, -2.86283577e-03f, -8.30214173e-02f, 6.17378727e-02f, -1.77367572e-02f, -4.90997769e-02f, -6.87676445e-02f, 5.98552451e-02f,
  4.28199209e-02f, 2.88488362e-02f, -1.38140628e-02f, -5.07351942e-02f, -7.32268346e-03f, 5.53613678e-02f, -5.53439483e-02f, 9.04080123e-02f, 6.09893277e-02f, -3.81631628e-02f,
  2.63675526e-02f, 4.58545163e-02f, -7.76075292e-03f, -5.57580702e-02f, -6.31455258e-02f, -8.37012157e-02f, 1.20906886e-02f, 3.88110392e-02f, 4.63429913e-02f, -7.38863871e-02f,
  -5.78889214e-02f, 4.65832688e-02f, -4.06005383e-02f, 7.22382143e-02f, -6.63072243e-02f, 9.22838459e-04f, -4.02835105e-03f, -1.85781680e-02f, -1.14914477e-02f, 6.43781871e-02f,
  6.25059474e-03f, 3.89269926e-02f, -5.88993132e-02f, -4.81037274e-02f, -4.89388406e-02f, 2.87048463e-02f, -7.56733939e-02f, 8.00195411e-02f, -1.41977705e-02f, 3.34184477e-03f,
  3.57629396e-02f, -3.14049795e-02f, -6.66556880e-02f, 1.00611951e-02f, 6.90586343e-02f, 3.30672897e-02f, 9.81724076e-03f, -1.78192044e-03f, 9.93222371e-02f, 6.26181886e-02f,
  -1.00931861e-01f, 7.06406012e-02f, 1.51351355e-02f, -5.16090207e-02f, -1.13859978e-02f, 4.39747199e-02f, -7.93944076e-02f, -2.53573023e-02f, -5.91327846e-02f, 2.20271274e-02f,
  5.21866493e-02f, -1.14490660e-02f, 4.06811312e-02f, 1.08547695e-02f, -6.47889823e-02f, -3.73419374e-02f, 1.29401788e-01f, 7.22217336e-02f, 1.59577318e-02f, -6.15691021e-02f,
  9.92559344e-02f, 1.70823536e-03f, -5.14868200e-02f, 5.73337264e-02f, 1.15422741e-01f, -7.54221007e-02f, -3.52425762e-02f, -9.67548713e-02f, -1.53169110e-02f, -1.78390257e-02f,
  1.26809344e-01f, 3.82510833e-02f, 7.33512938e-02f, -2.82374048e-03f, 5.26871942e-02f, -7.09592029e-02f, -5.69084361e-02f, 5.70998937e-02f, -1.41680716e-02f, -1.87340956e-02f,
  9.07848310e-03f, -6.13344014e-02f, 8.35593492e-02f, 1.01407371e-01f, 9.21223909e-02f, -8.60523805e-03f, 5.59823625e-02f, -2.70575099e-02f, 1.72295600e-01f, 6.78603947e-02f,
  -2.09036060e-02f, 1.65261757e-02f, 1.04391046e-01f, 9.72233191e-02f, -1.32613361e-01f, -3.88649255e-02f, -8.28691795e-02f, 1.25742275e-02f, 1.19801313e-01f, -8.13547447e-02f,
  9.97635946e-02f, -4.26551141e-02f, -7.57784471e-02f, -5.87730817e-02f, -7.45140985e-02f, 4.19895053e-02f, -1.29083380e-01f, -9.36119407e-02f, -4.40498330e-02f, -8.72231573e-02f,
  6.21469505e-02f, -4.55785021e-02f, -5.49095012e-02f, -2.96560507e-02f, -5.85235171e-02f, -3.13446368e-03f, 9.05600097e-03f, -1.44269168e-01f, -1.46511897e-01f, 7.36370590e-03f,
  1.22619502e-01f, 1.10638164e-01f, -3.28308530e-02f, 2.06043152e-03f, 5.40283136e-02f, 1.50003824e-02f, -9.76545289e-02f, -5.04935421e-02f, -7.64548108e-02f, -8.61890614e-02f,
  -1.46125048e-01f, -8.42544660e-02f, 2.01937221e-02f, 4.88584228e-02f, -5.92358336e-02f, -5.05196564e-02f, -1.15441911e-01f, -3.21635976e-02f, -3.00954469e-02f, 5.31288721e-02f,
  -5.94771206e-02f, 1.70531012e-02f, -5.07744998e-02f, 9.32890773e-02f, -4.95947152e-03f, 1.12963459e-02f, -5.30586354e-02f, 8.49732384e-03f, 4.73358519e-02f, -2.85186246e-02f,
  2.13193707e-02f, 1.35952637e-01f, 7.99212605e-02f, -5.62693365e-02f, -7.95281306e-02f, 3.61254141e-02f, -6.16388433e-02f, -7.89575204e-02f, -6.51131198e-02f, -5.57665527e-02f,
  -9.27638486e-02f, -4.83163036e-02f, 8.85356665e-02f, 1.77658889e-02f, 1.42653259e-02f, -2.44894736e-02f, 4.99762967e-02f, 6.71034902e-02f, 7.03496635e-02f, 7.90818781e-02f,
  -8.19340721e-02f, -9.58782434e-02f, -4.66409512e-02f, -1.85071025e-02f, 1.38106765e-02f, -8.52225125e-02f, 4.45638075e-02f, -7.79775018e-03f, -7.49559924e-02f, 1.43807754e-02f,
  7.10984617e-02f, -4.02433909e-02f, 2.43396778e-02f, 2.72408419e-04f, 4.42587361e-02f, -8.39744806e-02f, -8.71217530e-03f, -7.73397312e-02f, 2.49057263e-02f, -4.35843654e-02f,
  -2.25863457e-02f, 9.49937031e-02f, 1.00859545e-01f, 1.49610871e-02f, -7.75072873e-02f, 3.70615683e-02f, -5.09199016e-02f, 5.13689779e-02f, -1.24155469e-02f, -3.65920961e-02f,
  2.63494998e-02f, -2.28695832e-02f, -3.07878032e-02f, 3.73972319e-02f, -6.40522465e-02f, 7.57027268e-02f, 2.38429429e-03f, 1.44747766e-02f, 7.94879496e-02f, 1.02062272e-02f,
  7.79346824e-02f, 4.84156609e-02f, -3.38453427e-02f, 6.15060963e-02f, -5.47252968e-02f, -4.87135202e-02f, -6.18849024e-02f, -1.54355029e-02f, -7.81842098e-02f, -7.54892975e-02f,
  8.46957564e-02f, -7.22446060e-03f, 1.59684792e-02f, 5.26530296e-02f, -1.69289876e-02f, 2.93746195e-03f, -6.41160607e-02f, 2.12601628e-02f, -4.68042307e-02f, 7.62198120e-04f,
  -1.64399724e-02f, -2.78958995e-02f, 7.17539787e-02f, -8.08438286e-02f, -9.55491960e-02f, 3.15002515e-03f, 5.92918023e-02f, -7.24548027e-02f, 3.71554345e-02f, -9.71135721e-02f,
  -5.36573380e-02f, 7.35934451e-02f, -2.68976483e-03f, 6.10497184e-02f, -8.65979642e-02f, -6.30491003e-02f, -1.13156803e-01f, -4.21996415e-02f, 1.84367131e-02f, 8.62577707e-02f,
  -7.79492483e-02f, 7.66353831e-02f, 7.61645064e-02f, 6.13852739e-02f, -1.86975244e-02f, 6.72119809e-03f, 5.56705482e-02f, -9.67892120e-04f, -1.12386748e-01f, -1.82320420e-02f,
  -5.18752746e-02f, -2.57351920e-02f, -5.31621426e-02f, -6.72721565e-02f, 4.46635811e-03f, 7.92002007e-02f, 3.74831222e-02f, 6.77273935e-03f, 6.58542383e-03f, 6.71984553e-02f,
  -1.15274964e-02f, -4.40753363e-02f, -4.41716611e-02f, -1.18424920e-02f, -2.05531381e-02f, 1.94292571e-02f, 1.01197161e-01f, 6.04870580e-02f, 1.98840071e-02f, -4.38435655e-03f,
  -1.66479517e-02f, 7.03760702e-03f, 8.52226540e-02f, 9.15270112e-03f, 5.81427254e-02f, -1.01443101e-02f, 6.80588855e-05f, -7.23864213e-02f, -7.43180588e-02f, -1.64900944e-02f,
  -3.68050523e-02f, 7.15498924e-02f, 4.16384153e-02f, 5.87170050e-02f, 1.36169419e-01f, -2.86566168e-02f, 2.15195604e-02f, 5.05496599e-02f, 1.01793364e-01f, -1.10781632e-01f,
  -8.36191513e-03f, 1.29005194e-01f, -2.16681999e-03f, -1.03760451e-01f, 6.05629198e-02f, -1.80022642e-02f, 6.88939691e-02f, 8.52516945e-03f, 1.04858428e-02f, 6.86979741e-02f,
  8.96277130e-02f, 1.60397179e-02f, 2.16697361e-02f, 8.91613662e-02f, -1.77179463e-02f, -3.80773912e-03f, -2.26864573e-02f, 9.46131423e-02f, -8.26479942e-02f, 8.48306268e-02f,
  5.07036038e-02f, 4.36815880e-02f, -4.33604009e-02f, -1.81878079e-02f, -4.13044244e-02f, 1.07477196e-01f, -1.52264601e-02f, 6.07868284e-02f, 7.85305947e-02f, 1.06608525e-01f,
  1.40399069e-01f, -3.50537971e-02f, 9.24722292e-03f, -7.76102394e-02f, -7.01095760e-02f, -5.47861196e-02f, 9.07169580e-02f, 1.96071342e-02f, -3.76757309e-02f, 7.85970837e-02f,
  -1.76534560e-02f, 1.44679882e-02f, 1.09593652e-01f, 9.49163064e-02f, 9.13554337e-03f, -3.69833820e-02f, 1.49469748e-02f, -3.77800055e-02f, 5.23588620e-02f, -1.23875178e-02f,
  -1.22081287e-01f, 2.83026695e-02f, 6.96980432e-02f, -6.29122406e-02f, -2.83603836e-02f, -5.51723577e-02f, -7.27691650e-02f, -3.12242266e-02f, 4.29753074e-03f, 1.35890886e-01f,
  3.89739797e-02f, 7.30712339e-02f, 1.10060545e-02f, -1.56112909e-01f, -7.83590749e-02f, 1.60634845e-01f, 5.50109223e-02f, -2.15135843e-01f, -1.06691949e-01f, 1.75328590e-02f,
  -6.98207840e-02f, -6.55121822e-03f, -2.21170653e-02f, 8.99348930e-02f, -1.12714946e-01f, -9.62639600e-03f, 4.21508327e-02f, 1.18956469e-01f, -6.45175867e-04f, -1.49990141e-01f,
  -1.62025705e-01f, 4.79438305e-02f, -9.20302570e-02f, 3.96836223e-03f, 1.27486186e-02f, -4.18770760e-02f, -1.87066257e-01f, -2.44418025e-01f, 3.23412381e-02f, 2.20357105e-01f,
  -8.02230760e-02f, -3.08164768e-03f, -1.03694707e-01f, 2.15649009e-02f, 8.93741176e-02f, 9.24967006e-02f, 4.27037552e-02f, -6.38995171e-02f, -1.15677975e-02f, 1.13887191e-01f,
  4.99889813e-02f, -1.23625129e-01f, 5.51330894e-02f, 3.38698104e-02f, 1.39431834e-01f, 2.61162641e-03f, -1.18295895e-02f, 8.02640170e-02f, 7.57879019e-02f, 1.01760559e-01f,
  4.20771986e-02f, -1.11790799e-01f, 7.84772933e-02f, -1.32233053e-02f, -5.51824283e-04f, -7.91312021e-04f, -4.43704464e-02f, 6.62743449e-02f, 7.00887516e-02f, -2.92314552e-02f,
  4.82958928e-02f, -1.07053086e-01f, 1.19993880e-01f, -7.58859003e-03f, -2.90493178e-03f, -1.02571980e-03f, -3.71851325e-02f, -3.29059269e-03f, -3.06093059e-02f, -2.82515567e-02f,
  3.24045271e-02f, -1.44123081e-02f, -2.88889725e-02f, -2.59949770e-02f, 8.13968256e-02f, 6.44834936e-02f, -7.29763284e-02f, -1.08944355e-02f, -6.87382519e-02f, -5.78075573e-02f,
  8.30131844e-02f, -5.13441116e-02f, 9.53030437e-02f, 1.06450379e-01f, 7.40948366e-03f, -4.62847389e-03f, -2.12552045e-02f, 8.73312056e-02f, 8.00190791e-02f, 3.03556453e-02f,
  -2.92672571e-02f, -7.70167122e-03f, 1.02941900e-01f, -6.40101656e-02f, 4.22063805e-02f, -2.07548458e-02f, 6.70745149e-02f, -3.80582064e-02f, 1.06735833e-01f, 1.34473955e-02f,
  -1.40770469e-02f, 5.71229607e-02f, -3.82998697e-02f, 2.01667510e-02f, -1.02354921e-02f, -3.16620767e-02f, 5.83828650e-02f, -7.82222748e-02f, 3.07766795e-02f, -7.41101056e-02f,
  6.01224191e-02f, 5.83914854e-02f, 1.44444913e-01f, 4.35756408e-02f, -1.99589459e-03f, -1.06365949e-01f, 2.21075751e-02f, 3.19080949e-02f, -5.94003312e-02f, 7.03285411e-02f,
  -1.58079248e-02f, 4.48607728e-02f, -1.00645266e-01f, 2.49006394e-02f, 3.61898430e-02f, 6.57460243e-02f, -1.18369050e-01f, -5.93853220e-02f, 1.21335266e-02f, -1.04162619e-01f,
  7.18103051e-02f, 5.14215305e-02f, 5.58428802e-02f, -4.64657173e-02f, 9.92724672e-02f, -1.01932660e-01f, 2.24799532e-02f, -3.73572335e-02f, -8.41413289e-02f, 7.35863894e-02f,
  1.23361722e-01f, -1.83613390e-01f, 1.52827073e-02f, 9.38969031e-02f, 1.07716873e-01f, 1.19789392e-01f, -6.74662217e-02f, 5.40858768e-02f, 4.66260128e-02f, 2.88873240e-02f,
  -2.15639528e-02f, -1.26243129e-01f, -9.20316800e-02f, -9.83852223e-02f, -1.35417342e-01f, 3.30403522e-02f, 3.78511809e-02f, -9.08200145e-02f, 1.15223356e-01f, -6.85435310e-02f,
  -1.04738884e-01f, 4.25730906e-02f, 4.98193614e-02f, 1.29681036e-01f, 9.41976309e-02f, 1.22938212e-02f, -2.50023138e-02f, 4.37440770e-03f, 7.86474068e-03f, 3.74044143e-02f,
  -6.36729365e-03f, -2.24011242e-02f, 1.59334391e-01f, 1.49140954e-02f, -6.40797094e-02f, 8.91216770e-02f, -6.00000620e-02f, 2.16789246e-02f, -3.10229361e-02f, 8.43702257e-03f,
  7.54249841e-02f, -4.96488325e-02f, -6.27942234e-02f, 8.41330066e-02f, -1.00228488e-02f, 1.15256598e-02f, 1.31856412e-01f, 4.57965629e-03f, 7.33729899e-02f, 6.49785474e-02f,
  -3.25752087e-02f, -4.28288169e-02f, -1.00532137e-02f, 1.01353116e-01f, 6.37830645e-02f, 5.38893007e-02f, 1.20326392e-02f, -4.10432257e-02f, 3.45045179e-02f, -7.54936337e-02f,
  5.40850535e-02f, -1.66007073e-03f, 8.79561082e-02f, 3.36320214e-02f, 6.55212551e-02f, -6.13138564e-02f, -2.47054675e-04f, 2.59119552e-02f, 6.82760775e-02f, -8.83576740e-03f,
  -1.31939556e-02f, 6.48899227e-02f, 2.23217271e-02f, 2.92307585e-02f, 4.76306342e-02f, 7.49598518e-02f, 7.38102896e-03f, 3.14007662e-02f, -4.10411432e-02f, -6.43763458e-03f,
  -1.47801721e-02f, -3.74190286e-02f, -4.74296659e-02f, 3.67242703e-03f, 1.98301449e-02f, 1.61757655e-02f, 4.66321521e-02f, 8.72351006e-02f, -5.97924143e-02f, 9.73910093e-02f,
  3.09546851e-02f, 2.19635628e-02f, 1.18891910e-01f, 1.03937156e-01f, 3.77500765e-02f, 7.39671960e-02f, 8.09257999e-02f, 9.92360190e-02f, 3.63810323e-02f, -6.03951365e-02f,
  5.38543761e-02f, -4.98998538e-02f, 6.36291280e-02f, -6.77501634e-02f, -6.72152564e-02f, 2.91201286e-02f, -1.01808049e-01f, -9.15158764e-02f, 3.20939273e-02f, 9.18715149e-02f,
  -8.16293359e-02f, 4.50902507e-02f, -1.15230575e-01f, 2.58964952e-02f, 4.52540927e-02f, -6.48153424e-02f, 9.57585201e-02f, -4.73066233e-02f, 1.83790609e-01f, -2.49819290e-02f,
  5.68409115e-02f, 1.27887741e-01f, 7.47485552e-03f, -7.12945163e-02f, 1.08645717e-02f, 1.64690331e-01f, -4.50434275e-02f, 7.23862499e-02f, 1.01651676e-01f, -2.75840443e-02f,
  4.20296490e-02f, 6.37802482e-02f, -6.72679096e-02f, -1.31945293e-02f, -2.43433323e-02f, -4.17193919e-02f, -1.07287355e-02f, 1.46927936e-02f, 1.08221456e-01f, -9.24178287e-02f,
  -2.51789507e-03f, -1.01521775e-01f, -2.92149908e-03f, 1.14587843e-01f, -7.48878345e-02f, 1.57762170e-01f, 8.32127333e-02f, -5.49977599e-03f, 3.23878042e-02f, 1.17043786e-01f,
  -5.62733486e-02f, 2.23965868e-02f, 1.04045114e-02f, -2.49483343e-02f, -7.55876154e-02f, -1.06441855e-01f, 5.37800528e-02f, 8.41490626e-02f, 2.47688517e-02f, -4.18376289e-02f,
  7.12605342e-02f, 1.10221796e-01f, 9.33291018e-02f, -2.01232675e-02f, 3.34066711e-02f, -2.66956594e-02f, 3.84653360e-02f, 7.21753240e-02f, -5.38499989e-02f, -3.72474231e-02f,
  6.64143339e-02f, 7.81444758e-02f, 7.19252527e-02f, 1.15062162e-01f, -6.96687922e-02f, -7.44273812e-02f, -7.12601468e-02f, -5.29003404e-02f, 2.24352926e-02f, 5.39349280e-02f,
  7.68236965e-02f, 1.09498035e-02f, -4.08821180e-02f, 8.62955526e-02f, 9.57938551e-04f, -6.56515434e-02f, 4.35684845e-02f, 7.05185831e-02f, 5.34154102e-02f, 5.89690320e-02f,
  9.49169789e-03f, 3.36113013e-02f, -7.92983547e-03f, 6.88900650e-02f, 2.90593952e-02f, -3.54103036e-02f, -4.64523863e-03f, 3.14226933e-02f, 1.52246021e-02f, 6.10972866e-02f,
  8.88333917e-02f, -1.69067513e-02f, -2.14047660e-03f, -3.46761234e-02f, -1.44671905e-03f, -1.73065625e-02f, 6.28161728e-02f, 2.89846249e-02f, -7.00176507e-02f, 6.03198782e-02f,
  -1.31264785e-02f, 1.09296432e-02f, 3.34146782e-03f, 3.89103289e-03f, -1.71099622e-02f, -3.69495479e-03f, 5.69094606e-02f, -2.75193397e-02f, -1.00166583e-02f, -6.92043677e-02f,
  6.91071376e-02f, -1.74043514e-02f, -2.27372311e-02f, 8.52838233e-02f, -1.17982842e-03f, 2.22707354e-02f, 4.95313783e-04f, 3.46596017e-02f, -5.70190996e-02f, -7.39277974e-02f,
  -8.61051455e-02f, -2.91873533e-02f, -9.48290005e-02f, -9.36529227e-03f, 1.04329392e-01f, -8.47527012e-03f, 2.45995875e-02f, -6.36649411e-03f, -6.14189133e-02f, -3.10140625e-02f,
  -7.40832016e-02f, 9.26522911e-03f, 3.31163965e-02f, -6.56339899e-02f, -4.25603278e-02f, -5.39953858e-02f, 3.63120250e-02f, 4.96997163e-02f, 5.99654354e-02f, -4.66390699e-02f,
  8.39517042e-02f, 4.75713015e-02f, -5.22170812e-02f, 5.73792215e-03f, 4.85120118e-02f, -4.06115490e-04f, 7.92415719e-03f, 9.38453302e-02f, -7.12866336e-02f, -8.97707120e-02f,
  -3.10611650e-02f, -6.22283407e-02f, -7.34337270e-02f, -2.86769625e-02f, -1.11677900e-01f, -5.93990611e-04f, -7.71259293e-02f, 9.89014469e-03f, 9.36187506e-02f, -2.20159162e-02f,
  6.17062412e-02f, -9.82089564e-02f, 7.21551180e-02f, 6.57151341e-02f, -8.91614854e-02f, -5.95627986e-02f, -7.91978240e-02f, -1.98286436e-02f, -6.27487004e-02f, -6.29456155e-03f,
  -4.12611198e-03f, 7.46524557e-02f, -3.90904509e-02f, 4.00574133e-02f, 4.87782545e-02f, 9.98409763e-02f, 1.89589299e-02f, -5.81372119e-02f, -4.91199456e-02f, 6.17497340e-02f,
  7.55148157e-02f, 7.33751282e-02f, -5.50235845e-02f, -6.67115375e-02f, 8.33876804e-02f, 1.02259427e-01f, 8.17288384e-02f, 2.94719078e-02f, -8.07672292e-02f, -1.48511427e-02f,
  6.50823936e-02f, 1.12285567e-02f, 5.81197347e-03f, 2.57704109e-02f, -4.44997028e-02f, -7.28542581e-02f, 1.17463671e-01f, -4.05905843e-02f, -3.08831204e-02f, -3.06387749e-02f,
  -2.87478752e-02f, -6.91509992e-02f, 9.82891843e-02f, -5.60232960e-02f, 1.09566353e-01f, 1.94440465e-02f, -4.84402478e-03f, 8.98631886e-02f, -1.14408769e-02f, 6.66906610e-02f,
  3.04599386e-02f, -1.50836620e-03f, 5.71724921e-02f, 5.94039075e-02f, 5.55833839e-02f, -6.35916293e-02f, -7.07941875e-02f, 7.21531883e-02f, -2.29183640e-02f, -3.81312817e-02f,
  8.21208954e-02f, 1.14790171e-01f, 4.24316004e-02f, 7.02684969e-02f, -2.16989890e-02f, 1.78088769e-02f, 6.41812012e-02f, 1.01846017e-01f, 5.86133040e-02f, 9.79917347e-02f,
  4.37586308e-02f, 7.14394748e-02f, 6.55168146e-02f, -5.12635931e-02f, -1.46270534e-02f, 7.80642629e-02f, -7.59434402e-02f, 9.48201194e-02f, 1.19033977e-01f, 4.18706313e-02f,
  3.22237164e-02f, 7.84883648e-03f, -4.32423204e-02f, 2.12034043e-02f, 6.28494248e-02f, 1.68488309e-01f, -1.40429065e-01f, 7.88046047e-02f, -8.16669539e-02f, -1.36525169e-01f,
  1.64122861e-02f, 1.93123873e-02f, -1.29731581e-01f, 3.44150029e-02f, -1.68657508e-02f, -5.02279103e-02f, 8.28007609e-02f, -1.26635116e-02f, 6.54578805e-02f, 2.27239896e-02f,
  -3.49904709e-02f, 1.26710981e-01f, 3.67497131e-02f, -5.13137728e-02f, -8.18833932e-02f, 3.95258628e-02f, 5.26139932e-03f, 4.64564376e-02f, -1.89650990e-02f, -1.44282341e-01f,
  7.49096349e-02f, 4.05156091e-02f, -1.20280743e-01f, -1.07813604e-01f, -3.55833583e-02f, -3.51390243e-02f, -1.19623676e-01f, -1.45915419e-01f, 2.10114494e-02f, 2.59369519e-02f,
  9.67817381e-02f, 7.67748505e-02f, -8.16532818e-04f, -3.94316874e-02f, 7.49572460e-03f, -9.74767958e-04f, -1.03501208e-01f, 3.12961414e-02f, -1.42159924e-01f, -6.65217638e-02f,
  -2.07462404e-02f, 1.74051553e-01f, 6.25851378e-02f, 1.49661014e-02f, 6.95758536e-02f, 1.13938019e-01f, -2.30991170e-02f, 1.65073015e-02f, 5.71956858e-03f, 8.37222580e-03f,
  5.00616841e-02f, -2.21237373e-02f, -4.91238497e-02f, 2.40992010e-02f, 4.68160305e-03f, 3.75738740e-02f, 1.55568302e-01f, 1.45072900e-02f, 6.43837750e-02f, -6.14679977e-02f,
  -1.25780776e-02f, 1.40288830e-01f, -1.78787690e-02f, 3.95096540e-02f, 2.86606532e-02f, 9.26125199e-02f, 1.27718389e-01f, 2.22134069e-02f, 1.35413203e-02f, 2.87725534e-02f,
  -7.44225904e-02f, 8.53148941e-03f, 6.97884113e-02f, -3.05636670e-03f, -6.56366441e-03f, -2.09804322e-03f, -1.08486805e-02f, -6.30056784e-02f, 4.86168005e-02f, -3.42515185e-02f,
  -3.37611325e-02f, 4.13935483e-02f, 8.21123924e-03f, -7.43146017e-02f, -4.96571250e-02f, -9.93762910e-03f, -3.21377143e-02f, 5.15019074e-02f, -2.27749639e-04f, -4.28691432e-02f,
  -8.35443661e-02f, -6.11459427e-02f, 4.86638844e-02f, 2.76253074e-02f, 4.53281328e-02f, -7.28200078e-02f, 4.43433374e-02f, -3.05510522e-03f, 7.18585253e-02f, 7.88348988e-02f,
  -4.47674282e-02f, -7.44523853e-02f, 8.25421587e-02f, -1.54809682e-02f, -5.03636850e-03f, -3.48555259e-02f, -5.23373932e-02f, -3.52487154e-02f, 1.18899746e-02f, -6.98693022e-02f,
  -2.28194837e-02f, -4.13892083e-02f, -6.59308210e-02f, -4.74176630e-02f, -7.86082223e-02f, -5.55383565e-04f, -1.56050697e-02f, 4.93951747e-03f, -8.42515379e-02f, -6.12374069e-03f,
  2.40259320e-02f, -2.90830769e-02f, -6.17238507e-02f, 2.64007188e-02f, 5.50110601e-02f, -4.51825261e-02f, 4.77819815e-02f, -6.70197383e-02f, -8.62952098e-02f, -2.40521431e-02f,
  -8.89940709e-02f, -5.76217845e-02f, -6.65902570e-02f, 6.24070466e-02f, -4.63011116e-02f, 4.05643880e-03f, -1.11359889e-02f, -6.49099350e-02f, -3.23925540e-03f, 1.25999823e-02f,
  -6.99619502e-02f, -3.89373042e-02f, 3.06904758e-03f, 4.21400741e-03f, -4.42086048e-02f, 8.27852041e-02f, -8.46943185e-02f, -7.12901354e-02f, -1.44960163e-02f, -1.48264701e-02f,
  2.18094718e-02f, 2.15868112e-02f, 3.13006938e-02f, 4.56209183e-02f, -2.17631795e-02f, 4.64136712e-02f, -1.26822805e-02f, 4.83314246e-02f, 2.45986674e-02f, -8.00589174e-02f,
  8.41127560e-02f, 8.73657763e-02f, -1.88046899e-02f, -7.40483925e-02f, 6.56747520e-02f, 1.46750091e-02f, 6.88319057e-02f, -2.73318030e-02f, 4.82486337e-02f, 5.92625812e-02f,
  3.87846120e-02f, 4.10425551e-02f, 7.10020587e-02f, 2.94477418e-02f, -1.57825917e-03f, 7.58371651e-02f, 1.03710210e-02f, -3.42860706e-02f, -4.18502875e-02f, 7.15752840e-02f,
  3.59623842e-02f, -6.40269220e-02f, 2.55945697e-02f, -3.29983942e-02f, 6.02591448e-02f, -4.21310700e-02f, -2.48281881e-02f, -1.01459306e-02f, 7.87883103e-02f, -2.29756720e-02f,
  -5.74548580e-02f, -7.61078075e-02f, -2.45337933e-02f, -4.39251773e-02f, 8.38492960e-02f, 3.14597934e-02f, -1.33939246e-02f, 1.40866556e-03f, 7.74328262e-02f, 5.06929122e-03f,
  1.11234307e-01f, 1.11284249e-01f, -4.74875532e-02f, 2.06553489e-02f, -1.68855675e-02f, 3.51634286e-02f, -1.82524808e-02f, 8.16601887e-02f, 2.93881875e-02f, 8.01136047e-02f,
  1.45610139e-01f, 5.69237582e-02f, 1.29876193e-02f, 1.04188152e-01f, 8.96825567e-02f, 7.91469961e-02f, 1.88056957e-02f, 1.38253018e-01f, 7.82747194e-03f, 1.00279167e-01f,
  7.31363446e-02f, -7.86866173e-02f, 5.57702221e-02f, 1.22622907e-01f, 1.23728171e-01f, 3.78828198e-02f, 7.30560496e-02f, 1.85723361e-02f, 5.90137057e-02f, -4.05773185e-02f,
  9.20085758e-02f, 9.70142484e-02f, -3.71902324e-02f, 2.57923435e-02f, 2.63791122e-02f, 9.19347927e-02f, 3.84223312e-02f, -2.19633970e-02f, -6.52919263e-02f, -1.17919017e-02f,
  1.58174828e-01f, 1.10590912e-01f, 1.33185789e-01f, -8.19070414e-02f, -2.04345863e-02f, 1.19008183e-01f, -4.94658537e-02f, 1.50511963e-02f, -6.57082116e-03f, -2.04888042e-02f,
  -2.67211888e-02f, -7.60700330e-02f, 1.18123017e-01f, 1.58067737e-02f, 1.73634201e-01f, 1.01432860e-01f, -7.94849992e-02f, -4.85236049e-02f, -8.27230886e-03f, 6.79656938e-02f,
  1.36930598e-02f, -1.07947841e-01f, -2.02544848e-03f, -6.69999942e-02f, -1.11115165e-01f, 1.27858832e-01f, 8.92685428e-02f, 1.24682814e-01f, -6.41573519e-02f, 3.45161036e-02f,
  -4.81666550e-02f, 1.30580261e-01f, 1.27904177e-01f, -1.25462428e-01f, -7.81990439e-02f, 1.79651231e-01f, 5.42335398e-02f, -7.01068155e-03f, 1.02261283e-01f, -8.85397568e-02f,
  -3.37830372e-03f, 8.46359208e-02f, 1.82884187e-01f, 1.05140120e-01f, -1.69330284e-01f, -1.14634968e-02f, -5.04550524e-04f, 1.82622105e-01f, -2.26479936e-02f, -4.42661569e-02f,
  1.19800888e-01f, -4.42735665e-02f, 1.18435487e-01f, -1.09542698e-01f, 1.72935948e-01f, 1.42403051e-01f, 6.79042786e-02f, -1.69790983e-01f, 3.51309925e-02f, 1.03113884e-02f,
  1.74803331e-01f, 7.59188980e-02f, -5.57769127e-02f, -1.49806857e-01f, 1.52545571e-01f, 2.72705220e-02f, 4.80524916e-03f, 8.38729590e-02f, 9.30516049e-02f, 1.48024738e-01f,
  5.60628064e-02f, 8.33593160e-02f, -6.06465638e-02f, -3.35282944e-02f, 1.57622863e-02f, -8.39499198e-03f, 8.06215256e-02f, -1.91914700e-02f, 6.00636117e-02f, -3.91776152e-02f,
  6.26314506e-02f, 5.93581684e-02f, -2.22445056e-02f, 4.31832252e-03f, -3.95445190e-02f, -5.51674403e-02f, -4.73597459e-02f, -3.41323130e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  1.02598317e-01f, 4.48305868e-02f, -5.42740263e-02f, 6.73724338e-04f, 2.38667578e-02f, 8.30813795e-02f, 1.41986817e-01f, -3.45499925e-02f, -3.56608592e-02f, -4.41892557e-02f,
  4.70560230e-02f, -8.41313750e-02f, -7.87171815e-03f, 5.77676371e-02f, 2.95544993e-02f, -1.97734665e-02f, 4.06289399e-02f, -1.61276162e-02f, -3.18582691e-02f, -9.08129103e-03f,
  1.03115313e-01f, 3.26716196e-04f, -2.33028214e-02f, 1.07196078e-03f, -4.01605144e-02f, 4.29409035e-02f
};

// L2_linear_W (Shape: 12 x 128)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 128;
const float L2_linear_W_data[] = {
  -2.14959860e-01f, -1.51753262e-01f, 1.96409345e-01f, -4.77835070e-03f, 1.07117727e-01f, 2.45224647e-02f, 1.14808552e-01f, 4.28021289e-02f, 2.12851353e-02f, 8.98231640e-02f,
  -4.82316762e-02f, -1.38348769e-02f, -1.06085442e-01f, -3.71907465e-02f, -9.82833356e-02f, -1.53287157e-01f, -2.49321446e-01f, -3.73527348e-01f, 2.69193258e-02f, -2.41554976e-01f,
  7.82825947e-02f, 4.07670885e-02f, -2.40855873e-01f, 5.34500852e-02f, 8.81339237e-02f, -2.41493762e-01f, 6.14444017e-02f, -8.76275972e-02f, 1.27387866e-01f, 1.49754971e-01f,
  2.48939022e-02f, 4.30827104e-02f, 1.00143932e-01f, 1.86093040e-02f, 8.81801546e-03f, -2.09658578e-01f, -5.20171709e-02f, -1.83419837e-03f, -5.98790571e-02f, -1.34018019e-01f,
  -2.91898191e-01f, -6.24125227e-02f, 5.19767515e-02f, -4.32342775e-02f, -1.89093035e-02f, 2.34066218e-01f, 1.13248035e-01f, 7.51517564e-02f, -1.35013480e-02f, 4.17415127e-02f,
  -2.25616638e-02f, -8.49211961e-02f, -1.24627322e-01f, 2.22281888e-02f, 2.06962839e-01f, 2.41152272e-01f, 1.03495143e-01f, -6.73599541e-02f, 1.18614845e-01f, 2.48394951e-01f,
  4.24340032e-02f, -3.28132026e-02f, -8.25600699e-02f, -1.26627788e-01f, 9.55215394e-02f, 1.65997416e-01f, -2.80901760e-01f, -1.77071303e-01f, 1.98646799e-01f, -2.29264125e-01f,
  -3.35910290e-01f, 1.29566953e-01f, -3.59663740e-02f, -1.43558368e-01f, -1.31245896e-01f, -2.07502663e-01f, 2.61163145e-01f, 7.39552081e-02f, -9.24553648e-02f, -8.31403285e-02f,
  6.76885694e-02f, 1.35637850e-01f, -1.22660421e-01f, -1.28888071e-01f, -3.19328457e-01f, 2.33599573e-01f, -3.69574964e-01f, -2.73451865e-01f, -7.98089132e-02f, 3.14056203e-02f,
  1.63763449e-01f, 2.47208595e-01f, 1.07158059e-02f, 4.24771667e-01f, 3.19457024e-01f, 1.62215576e-01f, -1.77790344e-01f, 4.99509685e-02f, -1.14498936e-01f, -2.12360751e-02f,
  1.61630884e-01f, -2.23510668e-01f, 2.15529755e-01f, 5.64901643e-02f, 6.79689124e-02f, 1.14989072e-01f, 1.78056151e-01f, -2.50543684e-01f, 1.35813141e-02f, 9.43647698e-02f,
  -1.14866560e-02f, -1.07877456e-01f, -7.94099495e-02f, -1.30710760e-02f, 1.63309928e-02f, 1.34239540e-01f, -2.95899827e-02f, -2.32828017e-02f, -5.52277043e-02f, 4.41668391e-01f,
  8.23857859e-02f, 1.90534607e-01f, 2.21827149e-01f, -1.71950296e-01f, -8.13910738e-02f, 9.00110304e-02f, -7.60893384e-03f, -2.42656022e-01f, 1.43337384e-01f, 1.21524341e-01f,
  3.19278650e-02f, -1.13711588e-01f, 1.33982465e-01f, 3.37341577e-02f, 1.09377921e-01f, -1.11100726e-01f, -9.33031458e-03f, -2.38515764e-01f, 9.16163810e-03f, -8.42232928e-02f,
  -1.25518724e-01f, 8.14012140e-02f, 1.69761721e-02f, 4.85164449e-02f, 8.98949876e-02f, 4.89270948e-02f, -1.32355392e-01f, 1.95434272e-01f, -8.20944458e-02f, 2.93968357e-02f,
  3.88758108e-02f, -3.32682878e-01f, 4.42269742e-02f, 1.82988346e-02f, -9.26377252e-02f, 7.86920823e-03f, -4.27216999e-02f, 1.50147416e-02f, 1.37616232e-01f, 1.04838938e-01f,
  3.07424217e-02f, -9.01927203e-02f, 1.17291063e-01f, 7.50145018e-02f, 2.12317370e-02f, 5.53994700e-02f, -4.75222059e-02f, -4.97746989e-02f, -2.96592921e-01f, 1.40521601e-01f,
  1.10149883e-01f, 5.04376292e-02f, 5.82021289e-02f, 1.88869089e-01f, -1.31968651e-02f, 9.15380195e-02f, 9.73342285e-02f, 2.27707386e-01f, -6.75013065e-02f, 1.45717472e-01f,
  3.30154225e-02f, -4.71982837e-01f, -3.70050550e-01f, -1.55920967e-01f, 8.51260200e-02f, -1.04679158e-02f, 1.77511305e-01f, 6.99943751e-02f, 5.40698469e-02f, -2.14350689e-02f,
  -2.54855722e-01f, -2.03582540e-01f, 2.23280370e-01f, 8.51403028e-02f, -1.33355841e-01f, -1.35518894e-01f, 1.22812828e-02f, -2.25604177e-01f, -1.82245336e-02f, 2.47217804e-01f,
  4.09205677e-04f, -1.93410784e-01f, -1.04053959e-01f, -2.68014252e-01f, 8.36692750e-02f, 3.93280298e-01f, 2.22908822e-03f, -4.31429148e-02f, 3.37045848e-01f, -1.98634211e-02f,
  4.81675826e-02f, -1.82298318e-01f, 2.72968173e-01f, -8.31944775e-03f, 4.98593263e-02f, -3.30602020e-01f, 4.11525480e-02f, -2.25863997e-02f, 1.25866488e-01f, 8.33586305e-02f,
  -1.00112647e-01f, 9.23039764e-03f, -6.75932392e-02f, 1.68969676e-01f, -4.03624445e-01f, 1.09698243e-01f, 3.46603580e-02f, -5.59534170e-02f, 2.66982704e-01f, -3.35921198e-01f,
  -6.95118308e-02f, 2.13108689e-01f, -9.04026330e-02f, -3.06663215e-01f, 4.20301676e-01f, -1.64357424e-01f, 8.67032632e-02f, 5.18173650e-02f, -1.27257124e-01f, -1.61616370e-01f,
  7.47418553e-02f, -3.03234346e-02f, 2.02924088e-01f, -7.23764375e-02f, -1.15244076e-01f, 2.49143437e-01f, -1.89376436e-02f, 1.49444006e-02f, -1.31931240e-02f, -1.42245620e-01f,
  3.61480951e-01f, 1.67964399e-01f, -1.27589963e-02f, 8.72187410e-03f, 2.84104086e-02f, -1.54564559e-01f, 1.34294510e-01f, -5.78655340e-02f, 9.89449099e-02f, -6.58857152e-02f,
  -2.29833007e-01f, -3.06836545e-01f, -7.25815147e-02f, 6.25707805e-02f, -6.22201003e-02f, -2.79113382e-01f, 1.02107279e-01f, 4.08035405e-02f, 8.32383484e-02f, 5.47475666e-02f,
  1.18763261e-02f, 6.74014688e-02f, 6.85312971e-02f, 4.31263670e-02f, 3.15850861e-02f, -1.40423417e-01f, 1.07312448e-01f, -4.45293188e-02f, -5.97413592e-02f, -1.02915019e-02f,
  3.34538557e-02f, 1.10224016e-01f, -2.57326275e-01f, 5.52622117e-02f, 4.66703437e-02f, 4.50916849e-02f, 4.78422605e-02f, 3.71646173e-02f, -1.92167312e-01f, -2.88818806e-01f,
  2.56207935e-03f, -4.90045212e-02f, -1.35694528e-02f, -3.80979665e-02f, -7.06176683e-02f, -1.92418709e-01f, -1.31687716e-01f, -9.24691558e-02f, 1.96995601e-01f, 1.86945628e-02f,
  7.08845407e-02f, 4.32803743e-02f, -2.44289726e-01f, -8.82833265e-04f, -7.00971037e-02f, -3.36042672e-01f, -6.10951222e-02f, 9.61946622e-02f, 1.25926286e-02f, -3.59133780e-02f,
  -2.80352056e-01f, -3.00879925e-01f, 3.20489466e-01f, 2.09953591e-01f, -8.33774060e-02f, 1.53249189e-01f, 1.03756249e-01f, -7.52553418e-02f, -9.60624814e-02f, -2.00631797e-01f,
  -2.47322042e-02f, -2.62164980e-01f, 1.50007576e-01f, 3.31386834e-01f, -6.25889003e-02f, -1.26580730e-01f, 2.19367430e-01f, -1.16681652e-02f, -7.24925324e-02f, 8.09014216e-02f,
  -7.71994591e-02f, 1.26418211e-02f, 2.43637320e-02f, 2.73057818e-01f, 1.16613567e-01f, 1.21704444e-01f, 1.01676010e-01f, -1.86022390e-02f, 1.01411417e-01f, -1.83248192e-01f,
  2.24768236e-01f, -4.15008813e-02f, 2.86498308e-01f, -3.15363370e-02f, -1.44130588e-01f, -2.23956630e-01f, 2.55565673e-01f, 1.92773044e-01f, 9.71240550e-02f, 2.36745253e-01f,
  -1.01506487e-01f, -1.04595698e-01f, 6.89412877e-02f, 1.10761814e-01f, 3.23750764e-01f, 1.22148618e-01f, -2.57451892e-01f, 2.72158653e-01f, 2.10734457e-01f, -1.36696920e-01f,
  5.00486270e-02f, -1.69390589e-01f, 1.43896416e-01f, 1.23307809e-01f, -2.37575546e-01f, 6.79237247e-02f, -2.10619867e-01f, 2.49881465e-02f, 4.07375664e-01f, 7.03164712e-02f,
  -4.08593677e-02f, -1.15017474e-01f, -7.19365850e-02f, -3.53052355e-02f, -3.30307633e-02f, -1.48530647e-01f, -7.81657919e-02f, 8.34957957e-02f, -1.68644637e-01f, 1.90675482e-01f,
  1.62684947e-01f, -1.78332001e-01f, 4.01514173e-02f, -7.65363947e-02f, -2.43511990e-01f, -2.02977180e-01f, -1.62544325e-01f, -2.27980912e-01f, -4.32621650e-02f, -1.42450586e-01f,
  2.59135980e-02f, -2.59542838e-02f, -1.14406245e-02f, 7.69865960e-02f, 8.31478834e-02f, 9.13785771e-02f, 2.16459557e-02f, -8.66659656e-02f, -2.18452901e-01f, 4.64049727e-02f,
  2.01357692e-03f, 7.18374997e-02f, -1.92844480e-01f, -1.10908538e-01f, 7.67739788e-02f, 2.81099360e-02f, -7.58715197e-02f, 1.63377583e-01f, 1.65122464e-01f, -1.74114719e-01f,
  -3.94847453e-01f, -9.37250182e-02f, -3.63333747e-02f, -3.22361201e-01f, -1.76588699e-01f, 2.72325519e-02f, -4.97581102e-02f, 1.32854223e-01f, 5.94151281e-02f, -2.24737540e-01f,
  -6.60067797e-02f, -1.14463106e-01f, 2.42308844e-02f, -6.08406998e-02f, 1.26961976e-01f, 5.66461217e-03f, 2.39831931e-03f, 3.67038362e-02f, 1.09829806e-01f, -9.33408067e-02f,
  -7.57564157e-02f, 1.23404283e-02f, 6.02663979e-02f, 3.14880870e-02f, -5.97414486e-02f, -8.50450769e-02f, -1.25504687e-01f, 1.14024617e-01f, 2.09122851e-01f, 2.94427305e-01f,
  -1.53798297e-01f, -1.13507040e-01f, -2.19429415e-02f, 2.05808878e-01f, -1.93580016e-01f, -6.07381128e-02f, 6.64545074e-02f, 4.57469486e-02f, -1.10717878e-01f, 1.49361029e-01f,
  7.85284191e-02f, -4.03099507e-02f, -2.26764828e-02f, 1.98453352e-01f, -3.07179660e-01f, 8.39303136e-02f, -5.69440387e-02f, -5.42575046e-02f, 2.26732284e-01f, -1.77895248e-01f,
  2.41712630e-01f, -2.31091931e-01f, 2.34839946e-01f, 2.46614844e-01f, -2.87061125e-01f, -3.63222212e-01f, 9.77922752e-02f, 1.57702699e-01f, -2.02729508e-01f, -4.18019965e-02f,
  -2.19305634e-01f, 3.34060967e-01f, -1.55868664e-01f, -1.43614456e-01f, -1.77897513e-01f, -1.70914039e-01f, 6.92968769e-03f, 4.83746976e-02f, 1.35654742e-02f, 1.61131755e-01f,
  1.61178373e-02f, -1.63355157e-01f, 7.32591525e-02f, 3.17129418e-02f, -1.16388341e-02f, -2.48413160e-01f, -1.67601645e-01f, -1.92638561e-01f, -1.18818320e-01f, 3.64725143e-01f,
  -8.28256011e-02f, 3.51740330e-01f, -8.30080062e-02f, 2.36585602e-01f, 1.51766449e-01f, 1.12475701e-01f, -2.53151745e-01f, -1.71877220e-02f, 3.15406531e-01f, -1.85906038e-01f,
  -3.34835231e-01f, -1.70434922e-01f, -9.12232995e-02f, 9.27600786e-02f, -2.62157526e-02f, 1.91488743e-01f, -1.23742791e-02f, -2.02457383e-01f, -1.79204042e-03f, 7.63067380e-02f,
  2.49671657e-02f, -2.55014390e-01f, -2.24307135e-01f, -6.83565661e-02f, 2.46044435e-02f, -2.33123928e-01f, -1.71905652e-01f, 1.94973648e-01f, -2.47712001e-01f, 1.37372226e-01f,
  1.25947773e-01f, 1.28121063e-01f, 1.91082750e-02f, -2.83418559e-02f, 4.76968735e-02f, -9.92679596e-02f, 1.96739361e-01f, 1.17657885e-01f, -1.52770057e-01f, 8.92581884e-03f,
  2.33267188e-01f, 2.00664774e-01f, -2.00542435e-02f, 5.44368587e-02f, 3.81201990e-02f, -1.92421969e-04f, -1.40199754e-02f, 1.07123971e-01f, 2.22517401e-02f, 1.17180934e-02f,
  1.18439406e-01f, -9.85768735e-02f, 2.24359795e-01f, 1.09135434e-02f, 1.41033866e-02f, 7.53676742e-02f, 5.53544797e-02f, 2.52046995e-02f, 1.61810711e-01f, -2.12029144e-01f,
  1.23050228e-01f, 6.61831945e-02f, 1.63075924e-01f, -8.91833156e-02f, 5.73791750e-02f, 3.64788063e-02f, 5.14763854e-02f, -2.29815573e-01f, -7.77012408e-02f, 1.85540002e-02f,
  1.03300037e-02f, -7.19473585e-02f, 7.90437981e-02f, -8.42816234e-02f, -1.78178415e-01f, 2.82521099e-01f, 1.30169198e-01f, 3.69451612e-01f, -1.80142269e-01f, 2.68045157e-01f,
  -8.47425684e-02f, 6.57556206e-02f, -3.21081817e-01f, 7.25840181e-02f, -1.12076104e-01f, -7.99562261e-02f, -2.01267391e-01f, 9.97481644e-02f, -1.84556052e-01f, -1.92404777e-01f,
  1.97305307e-01f, 1.82496905e-01f, -1.18633881e-01f, -1.72920257e-01f, 1.50011654e-03f, -1.16137631e-01f, -3.18069346e-02f, 5.19848093e-02f, -3.61135826e-02f, -2.20118746e-01f,
  -7.94350505e-02f, 7.10685477e-02f, -3.67531270e-01f, 2.01998040e-01f, -8.77638720e-03f, -9.77489501e-02f, -1.89710826e-01f, -1.43529683e-01f, -1.67755827e-01f, -2.79772460e-01f,
  -1.47789270e-01f, 7.76878034e-04f, 9.19638947e-02f, 1.30965710e-01f, 1.10073835e-01f, 1.30691528e-01f, -1.55427391e-02f, -3.82908016e-01f, 1.53571486e-01f, 2.19193295e-01f,
  1.38268322e-01f, -1.53199255e-01f, -2.13280767e-01f, 1.00645415e-01f, 1.28860235e-01f, -2.90096283e-01f, 1.98050905e-02f, 3.51816535e-01f, -1.77348629e-01f, -1.89585254e-01f,
  -1.66159049e-01f, 1.79377068e-02f, 2.52283812e-01f, 3.34077805e-01f, 1.69015333e-01f, -8.15582424e-02f, -1.69045299e-01f, 4.51559536e-02f, 8.49479064e-02f, 2.57725026e-02f,
  2.93691661e-02f, -1.31074205e-01f, -3.45535111e-03f, 2.37318277e-01f, -2.17522323e-01f, -7.63819069e-02f, 6.72563463e-02f, 1.94873899e-01f, -7.24269450e-02f, -2.18464226e-01f,
  -1.29024282e-01f, 1.45456761e-01f, 1.92381665e-01f, 1.67984352e-01f, -4.96591777e-02f, 9.65218395e-02f, 1.11953579e-01f, 6.53686672e-02f, -4.68256995e-02f, 1.67162225e-01f,
  1.78071056e-02f, -2.65132803e-02f, 1.62362233e-01f, -3.19947256e-03f, 1.82412758e-01f, 2.36912929e-02f, -5.83961084e-02f, -1.18923463e-01f, -5.64386621e-02f, 1.33388400e-01f,
  -2.52250340e-02f, 2.27234494e-02f, -7.86432903e-03f, 3.31801549e-02f, 5.15918247e-02f, 1.51172921e-01f, 3.21079701e-01f, 6.77766502e-02f, -1.47744611e-01f, -4.44478868e-03f,
  -6.27055317e-02f, -4.72352095e-02f, 3.87940072e-02f, 3.71098295e-02f, 1.11512616e-01f, 1.97177097e-01f, -6.75399899e-02f, 1.07489958e-01f, 1.12191267e-01f, 1.05465397e-01f,
  -5.79030700e-02f, 1.54240504e-01f, 8.59120488e-03f, -6.17453177e-03f, -4.06854004e-02f, 2.33006611e-01f, 1.54792592e-01f, 8.49365816e-02f, 7.64117911e-02f, 9.17451680e-02f,
  2.32592687e-01f, -7.93819055e-02f, 2.57485509e-01f, -3.29112828e-01f, 4.92000878e-02f, 9.49783158e-03f, 8.53496492e-02f, 3.55581790e-02f, 7.40815401e-02f, -2.17886284e-01f,
  6.53394731e-03f, 6.42076461e-03f, 6.45612925e-02f, 1.00584149e-01f, 1.06527343e-01f, -1.93141177e-01f, -7.14652464e-02f, 1.56461131e-02f, 2.43334606e-01f, -1.37648821e-01f,
  -2.41213530e-01f, 2.21419260e-01f, 3.99495549e-02f, -1.26399606e-01f, -3.84512953e-02f, 2.49444321e-01f, -6.13637418e-02f, -6.46591336e-02f, 9.80111137e-02f, -1.97166622e-01f,
  3.30031186e-01f, 2.34087855e-01f, -3.20579618e-01f, 3.10187519e-01f, -1.51126176e-01f, 7.23857433e-02f, -2.76834760e-02f, -3.21458966e-01f, 1.46807030e-01f, 1.25418305e-01f,
  9.36047733e-02f, 3.42421055e-01f, -1.47598326e-01f, -1.63600475e-01f, 1.10951304e-01f, -2.41271123e-01f, -2.76181027e-02f, -4.05342847e-01f, -1.00617751e-01f, 2.00585216e-01f,
  2.90660765e-02f, -2.51052588e-01f, -2.19844148e-01f, -6.31323233e-02f, 2.64666528e-02f, -1.58339590e-02f, -2.18711987e-01f, -2.01369584e-01f, 2.73731142e-01f, -8.35641772e-02f,
  3.33186895e-01f, 1.27594203e-01f, -2.07428902e-01f, 8.67600515e-02f, 3.03032976e-02f, 1.01239145e-01f, 1.85743541e-01f, 2.31339350e-01f, 4.53505553e-02f, -2.30968803e-01f,
  -7.63091892e-02f, -3.33622903e-01f, -8.45526233e-02f, 9.19774990e-04f, -1.08248875e-01f, 6.44634515e-02f, 2.25116033e-02f, 3.09362680e-01f, 2.16122553e-01f, -3.84448394e-02f,
  2.97428668e-02f, 1.45996168e-01f, 6.13779090e-02f, 3.16151008e-02f, -2.79220521e-01f, -1.19132847e-01f, 8.72816667e-02f, 1.45273015e-01f, -9.98595357e-03f, 1.03950627e-01f,
  1.26348361e-02f, -6.58783391e-02f, -8.99012238e-02f, -2.36912146e-01f, 7.47910887e-02f, 5.62198572e-02f, -6.45068183e-04f, -1.62893925e-02f, 1.44926921e-01f, -3.78557183e-02f,
  1.10547669e-01f, -1.18289985e-01f, -3.42508703e-01f, -6.09471649e-02f, 6.68051764e-02f, 3.75973172e-02f, -2.86877126e-01f, 1.72590524e-01f, -8.05046335e-02f, 1.34420842e-01f,
  6.24429323e-02f, 1.54062659e-01f, -1.53664052e-02f, -1.89552322e-01f, 5.49719073e-02f, 2.40479350e-01f, 2.74475571e-03f, 1.58018321e-01f, 2.55164564e-01f, -5.85583076e-02f,
  -1.52608559e-01f, -3.95658389e-02f, -7.37066716e-02f, -7.59841353e-02f, 4.50137928e-02f, -2.90833507e-02f, 9.68658254e-02f, -1.62822962e-01f, -1.64807722e-01f, 1.41010135e-01f,
  1.47788629e-01f, -1.13792397e-01f, 2.27366891e-02f, -4.89110686e-02f, 3.51505339e-01f, 1.01430759e-01f, 2.08536640e-01f, -5.05926972e-03f, 1.19965434e-01f, -2.04002764e-02f,
  1.43465728e-01f, 2.10490257e-01f, -1.78354993e-01f, -1.91251099e-01f, 2.46421501e-01f, 3.57794017e-01f, -2.04397842e-01f, 1.52563406e-02f, 1.55944005e-01f, -2.04622433e-01f,
  -8.90294537e-02f, 2.12991908e-01f, -1.16049007e-01f, 2.58831680e-01f, -2.76642144e-01f, 2.58545011e-01f, 1.51139960e-01f, -2.41410032e-01f, -9.91394520e-02f, 8.31687823e-02f,
  -6.95991563e-03f, -2.36640468e-01f, 7.80927390e-02f, -1.62645295e-01f, 4.47933763e-01f, -7.46258423e-02f, 1.88796028e-01f, -9.96578634e-02f, 3.58903259e-02f, -1.30288333e-01f,
  9.46084633e-02f, -1.81931511e-01f, -2.41434768e-01f, -1.79176688e-01f, 4.66819778e-02f, 3.03151250e-01f, -1.63570106e-01f, 1.43576562e-01f, -6.92117736e-02f, 2.64999658e-01f,
  -3.03336680e-01f, 1.26328573e-01f, -8.24614391e-02f, -2.24516273e-01f, -1.87973514e-01f, -2.17517003e-01f, 3.61371845e-01f, -1.81894317e-01f, 1.19401999e-02f, -7.38250837e-02f,
  6.96927309e-02f, -2.89757438e-02f, -8.71117488e-02f, 1.42886072e-01f, 3.30014676e-01f, -1.64880663e-01f, 5.52810468e-02f, 6.14494411e-03f, -7.68737346e-02f, -1.83303863e-01f,
  -2.19594445e-02f, 2.57542282e-02f, 1.43432282e-02f, -2.95764774e-01f, 7.72124603e-02f, 6.41285703e-02f, -1.62703022e-02f, 1.54077169e-02f, -3.06033432e-01f, 4.42824475e-02f,
  -1.51182100e-01f, 1.36492223e-01f, 1.48894668e-01f, -4.74689566e-02f, -1.23472288e-01f, 1.12602323e-01f, -3.59025747e-02f, -6.40813410e-02f, -2.01673657e-02f, 3.91540639e-02f,
  8.92094001e-02f, 1.70141030e-02f, 4.77817021e-02f, 7.64734745e-02f, -3.03921029e-02f, 1.27982840e-01f, -6.97884336e-02f, 7.61980861e-02f, -9.41658542e-02f, 1.57856792e-01f,
  -1.05580039e-01f, -5.67447841e-02f, -7.06045851e-02f, 6.30905107e-02f, -2.82844305e-02f, -3.53123210e-02f, 9.48003605e-02f, -6.58121556e-02f, -3.27086560e-02f, -1.37196884e-01f,
  -8.24175924e-02f, 2.10641008e-02f, 4.78472896e-02f, -2.41923675e-01f, -7.27197900e-03f, -4.70704697e-02f, -1.18721470e-01f, 9.08175111e-02f, 1.90762132e-02f, 1.01791747e-01f,
  -1.21376356e-02f, -1.22974142e-01f, 2.16003004e-02f, 1.01981178e-01f, 2.29081679e-02f, 1.65226087e-02f, -2.42641270e-02f, -7.28722140e-02f, -9.10238847e-02f, 1.20423101e-01f,
  8.53167940e-03f, 1.72982663e-01f, -8.91765952e-02f, -3.77324373e-01f, -4.06216085e-01f, -2.52627224e-01f, -1.51648745e-01f, 1.38793945e-01f, 1.87049165e-01f, 1.77453697e-01f,
  -1.18093893e-01f, 6.34291247e-02f, -2.04542607e-01f, -4.56858166e-02f, -1.34883836e-01f, -2.05882683e-01f, 1.79634064e-01f, -1.00804813e-01f, 2.68072814e-01f, -2.40442604e-01f,
  5.37008280e-03f, 1.39505461e-01f, 1.29864141e-01f, -1.25611439e-01f, 3.09002288e-02f, 7.89346639e-03f, -2.03414097e-01f, -8.79776403e-02f, 1.12652205e-01f, 3.00934404e-01f,
  -1.98700324e-01f, 3.20358962e-01f, 1.82295635e-01f, 1.52226254e-01f, -2.19203785e-01f, 2.62514353e-01f, -2.59424925e-01f, -2.34375164e-01f, -2.37955168e-01f, -1.84948668e-01f,
  5.90835437e-02f, 2.46741891e-01f, 1.78164154e-01f, -2.03360751e-01f, -8.73851776e-02f, 1.05495108e-02f, 2.11403802e-01f, 9.50977579e-02f, 1.00816727e-01f, 1.69358954e-01f,
  4.42809090e-02f, 1.03596263e-01f, -6.20378740e-02f, 2.18501687e-01f, 2.64973313e-01f, 2.33001083e-01f, 1.14807617e-02f, -2.02977374e-01f, -2.20766589e-01f, 4.11948077e-02f,
  -2.59982795e-01f, 1.23273738e-01f, -1.99112907e-01f, 1.35933191e-01f, -1.08330864e-02f, -8.40129480e-02f, -2.73173694e-02f, -7.69366920e-02f, -2.51975060e-02f, -1.87178906e-02f,
  9.21595842e-02f, -7.34508634e-02f, 1.92369521e-02f, 1.22600183e-01f, 4.79693413e-02f, 8.68260395e-03f, -1.57387927e-01f, 1.36867255e-01f, -5.66528505e-03f, 4.26303148e-02f,
  1.80893168e-01f, 2.41723284e-03f, -6.95616379e-02f, -1.68112472e-01f, -2.73414701e-01f, -6.35481551e-02f, 3.78218591e-02f, 7.32546672e-02f, -5.90557568e-02f, 9.52407420e-02f,
  2.38751571e-04f, 4.70245769e-03f, 7.49258474e-02f, 5.76705076e-02f, -1.09692492e-01f, 2.08541472e-02f, -2.63333265e-02f, 1.34927943e-01f, 6.27112761e-02f, 6.76586330e-02f,
  -1.66429058e-02f, -4.09710631e-02f, 1.56710949e-02f, -2.12823629e-01f, 8.04878622e-02f, -7.14120343e-02f, -5.14848307e-02f, -6.84247389e-02f, 5.01268953e-02f, 5.87887950e-02f,
  -9.69360396e-02f, 8.05017054e-02f, 1.32421060e-02f, 5.26176393e-02f, -2.70591527e-02f, 7.36815855e-02f, -1.77390009e-01f, 9.48428586e-02f, 1.43135302e-02f, 1.48456365e-01f,
  1.06484517e-01f, 1.48912966e-02f, 7.94671550e-02f, -8.85925591e-02f, 3.98110487e-02f, 2.67130267e-02f, -2.61409674e-02f, 2.56276906e-01f, -1.00261852e-01f, -2.68647939e-01f,
  -3.77967171e-02f, -3.36169302e-01f, -8.98345485e-02f, -2.01773465e-01f, -1.86712090e-02f, -2.93521285e-01f, 3.46827030e-01f, -8.00417513e-02f, 4.93398570e-02f, 1.83590695e-01f,
  -2.03102320e-01f, 2.93700576e-01f, 6.54071569e-02f, 2.80284554e-01f, 2.64272839e-02f, 1.38753086e-01f, 1.99949279e-01f, 1.71374813e-01f, 2.83435106e-01f, -2.49204814e-01f,
  -2.00410455e-01f, 4.78280149e-02f, 9.93190557e-02f, 3.59104782e-01f, 3.06261957e-01f, -1.35882810e-01f, -1.65255651e-01f, 1.10691376e-02f, 1.12861402e-01f, -6.10203035e-02f,
  1.81673542e-01f, 3.31229687e-01f, 3.37187350e-02f, -1.91440713e-02f, -7.97641203e-02f, 1.70386285e-01f, -1.25608087e-01f, -9.06417891e-02f, 4.84531634e-02f, 1.10467814e-01f,
  -1.31342843e-01f, -7.79381162e-03f, 1.75790474e-01f, 1.54325247e-01f, -2.04482853e-01f, -2.24757399e-02f, 1.17269166e-01f, 2.34811679e-01f, 7.23349825e-02f, -2.29800537e-01f,
  8.25849771e-02f, 5.90037787e-03f, -1.56572431e-01f, -1.14692904e-01f, -1.48733094e-01f, 2.40503903e-02f, 1.79584980e-01f, 1.15953498e-02f, -2.13688210e-01f, -9.86344144e-02f,
  -2.26020351e-01f, 1.33820906e-01f, 8.01747739e-02f, 4.62257443e-03f, 7.19512925e-02f, 4.06981349e-01f, 2.21380815e-01f, 2.82707125e-01f, -7.94853717e-02f, 2.34737083e-01f,
  2.35675294e-02f, -2.57269349e-02f, -2.58289352e-02f, 1.34534746e-01f, -8.04947019e-02f, 4.97253612e-02f, 1.04237676e-01f, 1.51241338e-02f, -1.71855330e-01f, 7.49920383e-02f,
  7.29229525e-02f, 1.39854237e-01f, -5.73615395e-02f, -1.13792241e-01f, 2.18540039e-02f, -8.73474702e-02f, -3.19113657e-02f, -6.16084784e-03f, -1.19353138e-01f, 4.44146544e-02f,
  -1.56978667e-01f, -4.40280661e-02f, -2.37825185e-01f, -1.15346573e-01f, -3.24870087e-02f, -9.40289125e-02f, 4.38015610e-02f, 1.74307361e-01f, 1.08726375e-01f, -1.77119523e-01f,
  -9.12349448e-02f, 4.68361229e-02f, -3.16115953e-02f, 4.61370088e-02f, -8.64687264e-02f, 1.41626224e-01f, -3.51500288e-02f, 1.29607439e-01f, -6.84237182e-02f, -2.13058323e-01f,
  -6.46922737e-02f, 3.68332304e-02f, 1.35719121e-01f, -6.24993928e-02f, -2.84991767e-02f, -2.04075631e-02f, 1.46949649e-01f, 1.49344560e-02f, -2.66970128e-01f, -8.83193016e-02f,
  9.22233835e-02f, 4.05656099e-02f, -2.59483784e-01f, -1.37416646e-01f, 1.46120042e-01f, 1.83619946e-01f, -7.33768418e-02f, 3.96041162e-02f, 2.25950971e-01f, 1.73329338e-01f,
  4.69702370e-02f, 2.30786309e-01f, -1.16814882e-01f, 1.96055219e-01f, -2.14253560e-01f, 1.73673466e-01f, -9.66256186e-02f, -2.56794751e-01f, 2.02237442e-01f, -3.08046669e-01f,
  -8.92404020e-02f, -2.54512370e-01f, 2.97151446e-01f, -3.23126525e-01f, -2.29901731e-01f, -2.00020909e-01f, -7.75547326e-02f, 1.92789465e-01f, 8.27493817e-02f, 2.81268954e-01f,
  -4.35210735e-01f, -1.86619207e-01f, -6.21266663e-02f, 2.03069717e-01f, 3.05454750e-02f, -1.62649736e-01f, -1.02443546e-01f, 3.10259461e-01f, 4.04590853e-02f, -5.92696071e-02f,
  -1.88174754e-01f, 2.58660793e-01f, -8.19135979e-02f, -9.81457159e-02f, 4.60028425e-02f, -9.16640386e-02f, 1.63908690e-01f, 9.41520259e-02f, 1.67192221e-01f, 1.80730239e-01f,
  -2.07630843e-01f, 2.80797612e-02f, -1.56745657e-01f, 2.84494400e-01f, 1.15855001e-01f, 2.01302134e-02f, -6.84821233e-02f, -8.48888904e-02f, -2.13208310e-02f, -2.45608658e-01f,
  -2.90448934e-01f, 2.91098505e-01f, -2.77310401e-01f, -1.91475749e-01f, 4.46065515e-02f, -3.96466907e-03f, -2.75594473e-01f, -1.50376065e-02f, 5.77689826e-01f, -1.37823001e-01f,
  -4.12673689e-02f, -8.73693675e-02f, 1.30555006e-02f, -1.01445794e-01f, -5.47698252e-02f, 3.76515277e-02f, -2.55434122e-02f, 2.23323494e-01f, -1.88522618e-02f, 1.99318826e-02f,
  1.88883737e-01f, -1.29000887e-01f, 8.72940645e-02f, 2.12256417e-01f, 1.07536979e-01f, -5.32884300e-02f, -1.34861544e-01f, -4.98587936e-02f, 3.57612520e-02f, -1.60853937e-01f,
  8.52155238e-02f, 5.32796532e-02f, -4.83925492e-02f, 9.59212035e-02f, -1.79712847e-01f, 9.69946012e-03f, 1.00228645e-01f, 1.03771940e-01f, -5.03103510e-02f, 1.26664326e-01f,
  -9.32457075e-02f, -1.07958958e-01f, 1.16433844e-01f, -1.77182734e-01f, 1.21457409e-03f, 1.12380289e-01f, 8.01829323e-02f, -8.74613300e-02f, -3.52613926e-02f, 3.02527957e-02f,
  -2.36296594e-01f, -3.17878253e-03f, 1.19905360e-01f, -1.03399932e-01f, -1.49405897e-01f, 1.76519692e-01f, 6.89888140e-03f, 8.21237117e-02f, -2.41849989e-01f, 7.05199167e-02f,
  -2.84218099e-02f, 1.41945677e-02f, -4.04186593e-03f, -2.49334946e-02f, -1.39094060e-02f, -1.99700505e-01f, 2.57982593e-03f, -2.59009749e-02f, -1.15719125e-01f, 1.84361741e-01f,
  1.95998456e-02f, 9.15453210e-02f, -1.83240756e-01f, 1.69143900e-02f, -1.83281466e-01f, 7.08310604e-02f, -2.70817757e-01f, 1.66007012e-01f, -1.75912887e-01f, -1.70212254e-01f,
  2.37785310e-01f, -4.09882925e-02f, -2.15688035e-01f, -4.40873690e-02f, 2.38298833e-01f, 2.94365466e-01f, 1.71226319e-02f, 5.74683249e-02f, -3.01204711e-01f, 2.49736682e-01f,
  -7.88411498e-02f, -2.40806669e-01f, -2.48184979e-01f, 6.89793676e-02f, -2.21362725e-01f, -2.82690674e-01f, 3.15913372e-02f, -1.83638036e-01f, -5.93097089e-03f, 2.59442002e-01f,
  -1.39127120e-01f, -3.66260707e-01f, 1.57299995e-01f, 2.32311375e-02f, 1.63988203e-01f, -2.25431457e-01f, 7.81995431e-02f, 1.57947779e-01f, 2.64702320e-01f, -2.66105056e-01f,
  4.19687070e-02f, -1.24618359e-01f, 4.42981906e-02f, -1.19613744e-01f, -1.08899169e-01f, 1.14350945e-01f, 1.65187821e-01f, 9.76712033e-02f, -3.88358608e-02f, -2.44733557e-01f,
  1.50640145e-01f, -2.00202540e-02f, -9.20885503e-02f, -6.03025109e-02f, 4.83059511e-03f, 3.22871171e-02f, -1.13257520e-01f, 2.91554987e-01f, 3.56545150e-02f, -4.23020273e-02f,
  -1.93382293e-01f, 3.68703872e-01f, 3.15785520e-02f, 2.19757520e-02f, 4.52625334e-01f, -9.28045064e-02f, -2.31337234e-01f, 8.23154971e-02f, 2.45807655e-02f, 1.23184837e-01f,
  -9.38283950e-02f, -1.23422652e-01f, 7.49918148e-02f, -4.68455628e-02f, 6.45079985e-02f, -6.33519515e-02f, -5.48207760e-02f, -1.45207072e-04f, 1.55966178e-01f, 1.38102904e-01f,
  1.00657076e-01f, -1.87659711e-01f, 1.90135777e-01f, 6.45780712e-02f, 8.03169608e-02f, -5.31257614e-02f, 8.58782604e-02f, 8.70337114e-02f, 7.81582147e-02f, -7.28300586e-02f,
  -1.03982352e-01f, 3.49694485e-04f, -4.98753134e-03f, -2.28724137e-01f, 8.66575018e-02f, 1.44869000e-01f, 1.58034161e-01f, 4.76720184e-02f, 5.85447736e-02f, 1.30661353e-01f,
  7.60319233e-02f, 2.02808931e-01f, -9.46108028e-02f, 3.10209133e-02f, -1.07549027e-01f, 6.73472732e-02f, 1.37108266e-01f, 1.74853578e-01f, 4.12193388e-02f, -9.21598375e-02f,
  1.89602058e-02f, 4.27663736e-02f, 7.15291649e-02f, -3.68121825e-02f, -1.41091213e-01f, 1.24328323e-01f, 5.74364029e-02f, 2.69581508e-02f, 3.71570922e-02f, -2.26867542e-01f,
  2.22074445e-02f, -6.65997714e-02f, -8.24260935e-02f, -1.75664008e-01f, 1.13772213e-01f, -3.40191126e-02f, 6.36030138e-02f, -2.76544616e-02f, 5.78226745e-02f, 1.21783286e-01f,
  2.59054527e-02f, 3.64484191e-02f, 2.26023480e-01f, -2.44736686e-01f, -3.97822559e-01f, -1.33326337e-01f, 1.81606621e-01f, 2.19542310e-02f, 1.18596293e-01f, -1.05160110e-01f,
  1.21834926e-01f, 1.58094093e-01f, -7.63740838e-02f, 2.26702124e-01f, 3.37662488e-01f, -3.76087278e-02f, -1.32158741e-01f, -3.33598219e-02f, -5.03882170e-02f, 2.09437102e-01f,
  1.33630544e-01f, 8.88161361e-02f, 2.40925044e-01f, 1.14948690e-01f, -4.07356828e-01f, -3.18216860e-01f, 1.16815616e-03f, -2.76800524e-02f, -2.90027447e-02f, -7.78114796e-02f,
  2.28514701e-01f, -5.74214943e-03f, -3.81308608e-02f, -1.54582068e-01f, -1.49363860e-01f, 3.41328025e-01f, 2.05614269e-01f, 1.70008555e-01f, -1.49992779e-01f, -1.41039997e-01f,
  1.60056636e-01f, -1.15525149e-01f, -1.14603817e-01f, -2.41369441e-01f, 8.13775286e-02f, -2.20834523e-01f, -2.05009416e-01f, -1.70942768e-01f, -1.80527255e-01f, -4.04492505e-02f,
  -1.62042320e-01f, 6.27526715e-02f, -7.20867589e-02f, 5.05399108e-02f, -1.69639796e-01f, 1.25739604e-01f, -2.18649790e-01f, -9.62911472e-02f, 2.29168728e-01f, -2.73483962e-01f,
  -1.60440773e-01f, -3.25043760e-02f, 1.84141383e-01f, 5.97305223e-02f, 1.20611146e-01f, -2.13000059e-01f, -5.16989380e-02f, -8.09689835e-02f, -5.92530612e-03f, -1.59998164e-01f,
  3.18973772e-02f, -1.17063306e-01f, 3.86059307e-03f, -1.96547657e-01f, 8.03430900e-02f, 5.72674692e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -9.58457515e-02f, -5.08615896e-02f, 4.13548388e-02f, -4.88480553e-02f, 4.84119616e-02f, 3.37191969e-02f, 5.70455343e-02f, 1.03395060e-01f, 7.66210034e-02f, -2.70880945e-02f,
  -1.46544981e-03f, -7.11484775e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 51, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        128, 51, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        128, 12
    );
    }
    