/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.16854718e-02f, -1.52283385e-01f, -3.98395151e-01f, -1.78842291e-01f, 3.22015025e-02f, -5.74976616e-02f, -3.60550322e-02f, 9.11308080e-02f, 2.28518575e-01f, -9.04159695e-02f,
  9.81879830e-02f, 3.07437927e-01f, 1.50586024e-01f, 1.98357821e-01f, -7.47977719e-02f, -3.75135511e-01f, -4.57833618e-01f, -1.83763444e-01f, 1.08979098e-01f, 2.27852806e-01f,
  1.41210139e-01f, 3.43015417e-02f, -3.24478075e-02f, -1.38152465e-01f, -3.19826156e-01f, -2.06137121e-01f, -2.86775261e-01f, -3.32181334e-01f, -2.70306528e-01f, -5.61767161e-01f,
  -2.19095796e-01f, 2.05777828e-02f, 1.18252538e-01f, 1.34127364e-01f, -6.41484037e-02f, -1.15929218e-02f, -6.56818971e-03f, -3.74453096e-03f, 3.01733389e-02f, -1.29096815e-02f,
  2.35068053e-03f, 4.99521308e-02f, -9.15726125e-02f, 1.22576216e-02f, -5.30660786e-02f, 6.40391260e-02f, -7.00059161e-03f, -6.13337532e-02f, -1.20375166e-02f, 3.84728871e-02f,
  -3.31769548e-02f, -7.57031441e-02f, -8.42129588e-02f, 8.89562815e-02f, -1.96654517e-02f, -1.80926338e-01f, -1.75542727e-01f, -5.31506203e-02f, -1.66305736e-01f, -2.71182299e-01f,
  -8.97358451e-03f, -8.22726637e-02f, 7.25684464e-02f, 4.38458733e-02f, 3.87048237e-02f, -7.40008503e-02f, -8.18670839e-02f, -2.31952849e-03f, 9.63877961e-02f, 5.17904609e-02f,
  2.37054899e-02f, 1.90748908e-02f, 4.76962328e-03f, -7.39633515e-02f, -6.44886307e-03f, -6.45285938e-03f, -7.56413862e-02f, -1.44927539e-02f, 8.87154974e-03f, 1.87069457e-02f,
  7.35449046e-02f, -1.07773565e-01f, 3.20830159e-02f, 1.66102052e-02f, -4.00615437e-03f, -1.44272354e-02f, -1.55316489e-02f, 1.12159707e-01f, 9.35348198e-02f, 2.63723545e-02f,
  1.82535022e-01f, 6.24605827e-02f, -1.51182279e-01f, -5.36704659e-02f, -6.80648610e-02f, -1.89817734e-02f, -1.34394998e-02f, 5.47373146e-02f, 6.73134476e-02f, 3.51273417e-02f,
  -1.13612544e-02f, -7.76431486e-02f, -5.09958193e-02f, 5.08713834e-02f, 1.00764863e-01f, 7.66669586e-02f, 1.82287935e-02f, 1.99796427e-02f, -3.20849121e-02f, -2.48980243e-02f,
  -2.04077791e-02f, -5.01474962e-02f, -2.31946316e-02f, 1.33708995e-02f, -9.40023959e-02f, -9.35377274e-03f, -5.37657514e-02f, -1.51361629e-01f, -1.88501671e-01f, -2.14326665e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -6.36848390e-01f, 2.98314005e-01f, -1.23185217e+00f, 1.90320760e-01f, -2.77390908e-02f, -1.38620108e-01f, 7.24357665e-01f, 2.37130806e-01f, -1.56740169e-03f, 2.86807269e-01f,
  -2.89532810e-01f, -2.53277302e-01f, -2.77584612e-01f, -1.41113877e-01f, 3.39638665e-02f, 4.68656123e-01f, 1.16735756e-01f, -5.53113937e-01f, -3.86170119e-01f, 2.71115333e-01f,
  5.98430991e-01f, 4.32190657e-01f, 1.77704226e-02f, 4.35361639e-02f, 1.18257634e-01f, -2.76294369e-02f, -8.85900781e-02f, -7.49723688e-02f, -1.13630835e-04f, 3.08413561e-02f,
  -8.15758586e-01f, -3.62758249e-01f, -1.77982345e-01f, -2.82834798e-01f, -5.10597706e-01f, -1.06396981e-01f, -7.34077916e-02f, -4.09373552e-01f, -1.29418582e-01f, 1.81181833e-01f,
  -2.86534369e-01f, -1.96620911e-01f, -2.00094163e-01f, 6.57413434e-03f, 2.02843755e-01f, -3.46747935e-02f, -1.44416336e-02f, -2.11073011e-01f, -3.34576100e-01f, -5.36344171e-01f,
  4.62721616e-01f, -3.66804391e-01f, -8.61893237e-01f, -7.83366635e-02f, -2.77784765e-01f, -4.55270141e-01f, -3.29348952e-01f, -5.29709220e-01f, -6.77284241e-01f, -9.54832882e-02f,
  2.66282763e-02f, -1.28949523e-01f, -2.77287955e-03f, 1.26491836e-03f, 2.39547834e-01f, -1.07363351e-01f, 1.61929980e-01f, 7.55508468e-02f, 1.64535075e-01f, 1.30299777e-01f,
  -2.34976634e-01f, 4.89659831e-02f, -2.73124874e-02f, 1.01218648e-01f, 4.45495397e-02f, -9.23073143e-02f, 7.38268942e-02f, 3.67222190e-01f, -1.38403013e-01f, 1.51767194e-01f,
  2.58524693e-03f, -1.58163249e-01f, -3.45350578e-02f, 1.56737983e-01f, -2.72612330e-02f, -2.07308471e-01f, 2.27986574e-01f, 1.39481435e-02f, -1.43439069e-01f, -3.83415520e-02f,
  4.76713240e-01f, 1.02008641e-01f, -9.45328102e-02f, 9.68584567e-02f, 3.08388788e-02f, -1.37220487e-01f, 7.42883384e-02f, 5.18032834e-02f, -1.50402948e-01f, -4.30571884e-02f,
  -1.66054722e-02f, -5.18901087e-02f, 9.95578468e-02f, 2.12990299e-01f, 8.21882039e-02f, 6.66033030e-02f, 3.52180123e-01f, -2.80266404e-02f, 2.55946428e-01f, -4.01092088e-03f,
  5.28561652e-01f, 3.70187223e-01f, 1.59151509e-01f, 6.65167719e-02f, 2.00966388e-01f, -9.45003256e-02f, -4.59102169e-03f, -4.21314547e-03f, -3.13289851e-01f, 8.82619679e-01f,
  1.23646891e+00f, -6.04939580e-01f, -1.89946935e-01f, 5.12998581e-01f, -1.76945955e-01f, -1.97871476e-01f, -4.11322355e-01f, 6.63065771e-03f, 3.18932921e-01f, -9.48700979e-02f,
  -3.23923528e-01f, -4.51816134e-02f, 1.07510686e-01f, -6.74391016e-02f, 1.17692180e-01f, 1.93256959e-01f, 2.37119913e-01f, 4.96800274e-01f, 2.12347984e-01f, -4.91715558e-02f,
  1.40572200e-02f, 2.83972621e-01f, 4.21058148e-01f, 2.31713727e-01f, -2.57325351e-01f, 8.36687759e-02f, -1.37911201e-01f, -2.53654480e-01f, -3.24507087e-01f, -3.13050091e-01f,
  -6.70340836e-01f, -4.39006031e-01f, 1.83542028e-01f, 4.69966233e-02f, -1.06775522e-01f, 1.42376631e-01f, 7.78891593e-02f, 4.44949456e-02f, 4.86450084e-02f, 3.62923257e-02f,
  -3.01721673e-02f, -9.97009501e-02f, -9.92597938e-02f, -9.30655822e-02f, -1.26006022e-01f, -2.38386374e-02f, -1.43582091e-01f, -5.40853012e-03f, -6.47133887e-02f, -2.28070036e-01f,
  -1.70092329e-01f, -2.34664202e-01f, -1.89535558e-01f, -5.58814872e-03f, -3.53614129e-02f, 8.38466510e-02f, -1.56907395e-01f, -2.57794052e-01f, -1.02369353e-01f, 7.33257309e-02f,
  1.32853493e-01f, 1.08775362e-01f, -2.74361432e-01f, -9.98485610e-02f, 1.47867817e-02f, 8.72616619e-02f, 6.59006387e-02f, 1.38970003e-01f, 1.55233786e-01f, 1.60808802e-01f,
  9.01566353e-03f, 9.35226306e-03f, 3.33557427e-02f, 1.78789482e-01f, 9.63466428e-03f, -2.82140851e-01f, -9.95915085e-02f, -6.66629747e-02f, -3.57098617e-02f, -6.45279512e-02f,
  4.80267741e-02f, 1.24014154e-01f, 3.55034284e-02f, -1.68638736e-01f, -1.77643448e-01f, -5.23784272e-02f, 1.03877105e-01f, -3.89268212e-02f, 8.55372846e-02f, 4.71128412e-02f,
  -4.12494689e-02f, 3.13995518e-02f, 1.33073375e-01f, -1.55500788e-02f, -1.30182549e-01f, 4.88648284e-03f, 5.37278876e-02f, -5.79725653e-02f, -1.27146915e-01f, -1.23989329e-01f,
  -1.15633182e-01f, 2.63697729e-02f, -7.52324760e-02f, -2.17631832e-02f, 2.32433081e-01f, 8.21304694e-02f, -8.78845528e-02f, -1.63469855e-02f, -5.35238683e-02f, -1.73995972e-01f,
  1.16878554e-01f, 2.30415136e-01f, 2.72656143e-01f, 1.86664790e-01f, 1.42899647e-01f, 3.87980938e-01f, 9.34240818e-02f, 4.83088521e-03f, 1.66255817e-01f, 5.87309659e-01f,
  8.01545918e-01f, -2.60554347e-02f, 6.35821939e-01f, 4.43445504e-01f, -8.16763759e-01f, -1.07262087e+00f, -1.01692760e+00f, -3.07858855e-01f, -6.22650683e-02f, -5.94039671e-02f,
  -7.88817346e-01f, -9.72641051e-01f, -7.61681376e-03f, -3.73716205e-01f, -2.92643905e-01f, 1.43274620e-01f, 6.99079156e-01f, 4.85364497e-01f, -4.45262522e-01f, -1.18448305e+00f,
  -7.96497464e-01f, 1.82768986e-01f, 6.36906505e-01f, 3.58399421e-01f, 2.16272712e-01f, -1.17517859e-02f, 7.85944223e-01f, 4.66912866e-01f, 2.63405815e-02f, 6.09228313e-01f,
  2.34659091e-01f, 4.49337691e-01f, -3.99044573e-01f, -3.41845661e-01f, -1.66301981e-01f, 1.83124840e-01f, -1.33781672e-01f, 4.95981961e-01f, -1.59552976e-01f, 1.83954254e-01f,
  -2.97663540e-01f, -2.28009745e-01f, -1.77093700e-01f, -2.13474482e-01f, -1.21455073e-01f, -2.42675126e-01f, 5.35156369e-01f, 2.59369761e-01f, 3.81693989e-01f, -1.52480930e-01f,
  -7.26319730e-01f, -4.56584543e-01f, 9.34462994e-02f, -3.98096740e-02f, -3.67237218e-02f, -6.74006194e-02f, 2.16117725e-02f, -7.52659664e-02f, 3.64863604e-01f, 6.09654844e-01f,
  -7.76343122e-02f, 1.04696518e-02f, -3.41009833e-02f, 1.31648004e-01f, -3.47093157e-02f, -1.19244732e-01f, 2.40379572e-01f, -1.40856102e-01f, -1.47048635e-02f, -2.33561359e-02f,
  -5.88115081e-02f, -1.03408903e-01f, 3.28323990e-02f, 1.18910201e-01f, 8.67666584e-03f, 1.60212636e-01f, -4.70423736e-02f, 1.89556509e-01f, 1.64022565e-01f, 1.49942979e-01f,
  -8.76150355e-02f, 1.52852600e-02f, 6.07222952e-02f, -1.91742703e-02f, -8.67939517e-02f, 1.83189660e-01f, 3.95999253e-02f, -1.29052997e-02f, 1.41200349e-01f, 6.01505190e-02f,
  -9.72980335e-02f, -9.81765091e-02f, -1.58252865e-01f, -3.88256758e-02f, 1.41371936e-02f, -3.66189964e-02f, -1.06878281e-01f, -1.03375793e-01f, 1.06965102e-01f, -5.59403971e-02f,
  -3.73358577e-01f, -1.44891471e-01f, 1.93293527e-01f, 1.54751033e-01f, -3.66231680e-01f, -1.36534065e-01f, -1.57132119e-01f, -2.54273564e-01f, -1.51852593e-01f, -5.75050190e-02f,
  1.34109303e-01f, -6.07576787e-01f, -4.27137494e-01f, -2.35255614e-01f, -9.76270139e-02f, -6.89698517e-01f, 2.38477495e-02f, -5.01915514e-01f, -3.70433420e-01f, -7.12043419e-02f,
  -4.63966489e-01f, -1.31390542e-01f, -2.39775032e-01f, 2.76795745e-01f, -1.42086176e-02f, -1.47786841e-01f, -3.23033333e-01f, -8.27702656e-02f, 2.39241913e-01f, 1.72042638e-01f,
  -7.91392401e-02f, 2.72966534e-01f, 2.56000102e-01f, 3.23235065e-01f, 2.69535601e-01f, 2.75323004e-01f, 5.12577653e-01f, 2.97177255e-01f, 2.60286871e-02f, 1.22085825e-01f,
  4.25012767e-01f, 2.17812508e-01f, 4.34510643e-03f, 1.85798839e-01f, 3.95948917e-01f, 4.05036449e-01f, 2.38210127e-01f, 1.57351986e-01f, 2.26805478e-01f, 7.87929058e-01f,
  4.61827964e-01f, -9.72388685e-02f, 3.52484226e-01f, 1.00135550e-01f, -7.52537251e-02f, -4.59566191e-02f, -7.62011260e-02f, -2.01191694e-01f, -1.86955333e-01f, 5.69436885e-02f,
  7.14394916e-03f, -1.87837124e-01f, -1.25364184e-01f, -1.69460192e-01f, -2.83848166e-01f, -1.97711185e-01f, -8.05528983e-02f, 1.26189038e-01f, 2.14745849e-01f, 1.47082746e-01f,
  1.87142864e-02f, -1.06556997e-01f, -2.64519811e-01f, -1.80855736e-01f, -2.57899147e-02f, 7.42928684e-02f, -2.10833907e-01f, 2.83894539e-02f, -8.79788995e-02f, -1.38489038e-01f,
  1.28263682e-01f, -1.60646066e-02f, 1.82510495e-01f, 1.14595771e-01f, 3.50520723e-02f, -1.20761685e-01f, -1.29256835e-02f, -1.70406401e-01f, -1.26966640e-01f, -6.24749027e-02f,
  4.19000193e-04f, 2.10176378e-01f, -1.45093590e-01f, 6.34023547e-02f, 2.23235428e-01f, 1.60566922e-02f, -3.85702997e-02f, 8.11813995e-02f, -6.71410263e-02f, 9.36576072e-03f,
  -8.39160606e-02f, 4.19324078e-02f, -1.23172969e-01f, -1.57969594e-01f, 5.32131381e-02f, -4.07209061e-03f, 3.23974825e-02f, -8.19310953e-04f, -3.99215752e-03f, 1.39739454e-01f,
  3.27118516e-01f, -1.98485404e-01f, 4.91084129e-01f, 1.67566016e-01f, 1.07162036e-01f, -1.74252182e-01f, 1.74929425e-01f, 1.10231433e-03f, -5.29589839e-02f, 8.58769119e-02f,
  -1.60043955e-01f, -5.99746555e-02f, -1.51712835e-01f, -1.02180161e-01f, -1.52448863e-01f, -1.32164076e-01f, 1.38271749e-01f, 2.43690476e-01f, 2.06013694e-01f, 1.44625202e-01f,
  -8.23376980e-03f, -6.36987165e-02f, -1.88193619e-01f, -1.25856310e-01f, 1.16109163e-01f, 1.10049553e-01f, -2.53846705e-01f, 4.64345142e-02f, -9.82052088e-02f, -3.43713492e-01f,
  1.03172278e+00f, 6.34695172e-01f, -7.44815290e-01f, 1.70557275e-01f, -5.39327800e-01f, -6.62301719e-01f, -6.68611646e-01f, -2.79438376e-01f, 2.70706058e-01f, -5.93978465e-02f,
  3.80146027e-01f, 7.03762650e-01f, 4.95247006e-01f, -4.91755456e-01f, -7.95714736e-01f, -6.67685866e-01f, -9.67346311e-01f, -9.01748240e-01f, -1.35333121e+00f, -1.21449411e+00f,
  -9.07113969e-01f, -4.53357369e-01f, -4.47059810e-01f, -4.91763234e-01f, 1.75507098e-01f, 2.15485305e-01f, 4.27127518e-02f, -1.26643348e-02f, -3.40839028e-01f, 1.24027789e-01f,
  7.98369125e-02f, 1.41742438e-01f, -4.77383792e-01f, -7.81421289e-02f, 3.81889530e-02f, -1.51631143e-02f, -1.14312328e-01f, -6.35424852e-02f, 7.88725764e-02f, -9.86940637e-02f,
  -3.60327214e-02f, -4.84659314e-01f, -2.85203401e-02f, -3.21962386e-01f, -1.74312949e-01f, -4.12112355e-01f, -3.11567485e-01f, -5.19097447e-01f, -3.65869552e-01f, -1.70351937e-01f,
  -2.76885778e-01f, -1.92693800e-01f, 7.37400725e-02f, -2.70029724e-01f, -2.60956079e-01f, -1.81328252e-01f, -5.50022162e-02f, -1.98022887e-01f, -1.93550259e-01f, 5.69342136e-01f,
  -3.08097899e-02f, 1.94856897e-01f, -1.21146947e-01f, -7.40382746e-02f, 4.04394269e-02f, 2.67365396e-01f, 3.12526226e-02f, -2.58276850e-01f, 1.46100475e-02f, 2.16057971e-01f,
  -2.49720234e-02f, 1.05051212e-01f, -4.02806886e-02f, 1.77770466e-01f, -2.66427151e-03f, -3.14286381e-01f, 9.79803037e-03f, 1.84588637e-02f, -6.29046112e-02f, 6.87918365e-02f,
  2.42553260e-02f, -1.69700354e-01f, 1.27220958e-01f, -7.87656382e-02f, -7.37452731e-02f, -1.05547663e-02f, -3.01161557e-02f, 3.61241139e-02f, 3.18137743e-02f, -6.28572181e-02f,
  7.07924902e-01f, -1.50142401e-01f, 4.77845252e-01f, -2.91732907e-01f, -1.04388729e-01f, -2.17467151e-03f, 3.89414966e-01f, -1.94334447e-01f, 1.40974522e-01f, -1.45801017e-02f,
  -1.59815267e-01f, 2.30539009e-01f, 2.51004156e-02f, 7.63761532e-03f, -1.89026430e-01f, -5.05489968e-02f, -1.47781342e-01f, -1.30230203e-01f, -2.57654667e-01f, -1.24462890e-02f,
  1.09729230e-01f, -1.05413862e-01f, 4.36604351e-01f, 3.21007907e-01f, 2.01846324e-02f, 9.01239663e-02f, 4.54048932e-01f, 1.72052801e-01f, 1.01258056e-02f, 4.65854913e-01f,
  -1.65205157e+00f, 3.72264713e-01f, 6.91158548e-02f, -1.20979881e+00f, -6.78078175e-01f, -1.19422689e-01f, 5.59545994e-01f, 4.18715850e-02f, -5.99463642e-01f, 2.90425420e-01f,
  1.83112442e-01f, -3.02683771e-01f, -3.62655133e-01f, 2.37397805e-01f, 3.41431677e-01f, 4.15765285e-01f, -3.57826442e-01f, -4.75414753e-01f, 4.84250411e-02f, 4.86100465e-01f,
  3.37275535e-01f, -5.05333364e-01f, -7.26557732e-01f, -3.18420351e-01f, -2.17658937e-01f, -3.90391201e-01f, -3.60546052e-01f, -5.26509941e-01f, 7.21124783e-02f, -6.53408170e-01f,
  8.81638050e-01f, -8.19108546e-01f, 2.07255438e-01f, -5.25876403e-01f, 1.17884204e-01f, -1.60774142e-01f, -1.10390030e-01f, -1.86027661e-01f, -2.43061483e-01f, -6.96249828e-02f,
  -3.86585802e-01f, 1.02108352e-01f, -4.08268481e-01f, 1.28339738e-01f, -1.87829390e-01f, -5.97028509e-02f, -1.55155391e-01f, -1.86507910e-01f, -7.78125226e-03f, 3.73838186e-01f,
  1.90777227e-01f, -3.38199764e-01f, -2.12516323e-01f, 1.96194053e-01f, 1.40248999e-01f, -1.53678477e-01f, 3.83409619e-01f, 4.05252986e-02f, -4.11864221e-02f, 6.52296245e-02f,
  3.51453066e-01f, 3.42395566e-02f, -4.56677936e-02f, -1.19986363e-01f, 1.39024416e-02f, -1.15527064e-02f, -3.13940435e-03f, 1.15053922e-01f, -5.15821166e-02f, 1.46116242e-01f,
  2.18631759e-01f, 3.38253349e-01f, -3.23013142e-02f, -1.05317228e-01f, -8.93360823e-02f, -2.07983151e-01f, -1.97695851e-01f, 2.30563462e-01f, 3.69549915e-02f, -2.23281503e-01f,
  1.62691772e-02f, 3.63603458e-02f, -1.82933345e-01f, 1.34602860e-01f, 1.19931854e-01f, -6.83348104e-02f, -1.87158287e-01f, 1.30680814e-01f, 9.03365240e-02f, -2.80683815e-01f,
  1.53629482e-01f, -1.36284843e-01f, -1.79350346e-01f, -1.19929746e-01f, -3.23780291e-02f, 1.44263119e-01f, -1.55329496e-01f, 1.22975931e-01f, -2.25198403e-01f, -6.44169524e-02f,
  -1.00932673e-01f, 1.65124580e-01f, -4.85021882e-02f, 7.96022713e-02f, -3.26986536e-02f, -8.87971818e-02f, 1.43513039e-01f, -1.84079543e-01f, 5.29455766e-03f, 9.35353339e-02f,
  2.03898802e-01f, -5.81644438e-02f, 1.03638396e-01f, 4.52723056e-02f, 1.26683652e-01f, -3.81860197e-01f, 3.08915704e-01f, 2.90070772e-01f, -1.03260353e-01f, 6.02796555e-01f,
  3.07580799e-01f, -6.51627123e-01f, -7.81917274e-01f, 4.53401655e-01f, 4.89717096e-01f, -5.20552218e-01f, -1.09435725e+00f, -6.69186831e-01f, 1.53942809e-01f, -5.36720872e-01f,
  1.23620592e-01f, 5.78813910e-01f, -1.20863341e-01f, -2.84488082e-01f, -9.87980247e-01f, -9.78837132e-01f, -6.80400491e-01f, -2.98605770e-01f, 1.37060598e-01f, 6.92195535e-01f,
  5.71904063e-01f, 5.41547537e-01f, 3.26436192e-01f, 9.59306508e-02f, 4.22675192e-01f, 2.67578632e-01f, -1.97925448e-01f, 4.24329519e-01f, -6.42873794e-02f, -1.28441285e-02f,
  5.10470085e-02f, -2.21428312e-02f, -7.46816099e-02f, 3.33609521e-01f, 2.54398912e-01f, -1.36066675e-01f, -3.02893907e-01f, 2.70239990e-02f, -2.02446669e-01f, -5.33881411e-02f,
  2.32462764e-01f, 9.77125466e-02f, 8.18566754e-02f, -5.15890419e-02f, 1.77482992e-01f, -2.26047248e-01f, -2.55870372e-01f, -3.40965241e-01f, -5.48191249e-01f, -2.66113311e-01f,
  3.55015218e-01f, 4.13300306e-01f, -3.76117259e-01f, -5.82998157e-01f, -2.11803347e-01f, 1.29883662e-01f, -3.98016758e-02f, 2.10250467e-01f, -6.24207497e-01f, -2.96063721e-01f,
  1.67216927e-01f, 8.55443254e-03f, -1.32823944e-01f, -1.23670269e-02f, -1.64977238e-01f, -2.38955580e-03f, -1.07675139e-02f, 6.63570240e-02f, 9.53543037e-02f, 3.60286213e-03f,
  -2.34422207e-01f, -3.72790322e-02f, 1.56035751e-01f, -1.02225952e-01f, 2.53924169e-02f, -2.76840460e-02f, -7.15785623e-02f, -9.13197547e-02f, 4.12525982e-02f, -1.46572351e-01f,
  1.55662507e-01f, -1.52173722e-02f, 2.53078014e-01f, -1.40533522e-01f, 9.85074565e-02f, -1.65325403e-01f, 7.16693774e-02f, 1.87892020e-01f, 2.92318091e-02f, 1.33451432e-01f,
  -8.35219026e-03f, -2.88382083e-01f, -1.90766066e-01f, -2.93456707e-02f, -6.37507439e-02f, 2.12752774e-01f, -6.91662133e-02f, -2.76766010e-02f, -2.04407796e-02f, 1.30819092e-02f,
  -7.75384251e-04f, -3.12195450e-01f, -3.37496787e-01f, -1.12714641e-01f, 1.30819842e-01f, 6.51172400e-02f, -9.14662108e-02f, -1.90717846e-01f, -1.44725457e-01f, 9.75893512e-02f,
  -1.05099119e-01f, -4.10147309e-01f, -4.20139432e-01f, -7.03787982e-01f, 3.07302713e-01f, -1.16571710e-01f, -4.28772569e-01f, -9.08428654e-02f, -8.63285840e-01f, -1.01122355e+00f,
  1.15261722e+00f, -7.56891370e-01f, -1.25458932e+00f, 4.97055769e-01f, 2.90496624e-03f, -1.57048285e-01f, -5.23988679e-02f, 5.39299905e-01f, 6.79895401e-01f, -2.77745396e-01f,
  -4.21528459e-01f, -1.90712541e-01f, -3.05038393e-01f, -1.78683311e-01f, 1.99980233e-02f, -4.37368184e-01f, -3.59646708e-01f, -1.64492100e-01f, 3.89704555e-01f, 6.09811544e-01f,
  2.54007846e-01f, 4.20378298e-01f, 4.34551835e-01f, 1.55964881e-01f, -2.79637039e-01f, -1.40565544e-01f, -7.12040603e-01f, -5.53749025e-01f, -6.02624178e-01f, -9.80289876e-01f,
  -8.04374933e-01f, -3.89263153e-01f, 3.95869285e-01f, 1.67081356e-01f, -1.57986030e-01f, 1.92257300e-01f, 1.60797209e-01f, 1.86252445e-01f, 2.13104025e-01f, -2.24690251e-02f,
  -1.18585832e-01f, 1.78104907e-01f, 1.81975961e-01f, -7.32115135e-02f, 7.91697800e-02f, -1.31200561e-02f, 1.10135578e-01f, 4.42975834e-02f, 8.00664257e-03f, -8.77529830e-02f,
  -3.10125351e-01f, -1.89690128e-01f, -6.96425140e-02f, 2.68518068e-02f, -1.18694283e-01f, -1.91439819e-02f, -2.98832327e-01f, -2.84966435e-02f, -2.43536457e-01f, 2.50744680e-03f,
  -1.15430370e-01f, -1.45992963e-02f, -1.50550622e-02f, 9.42925140e-02f, 1.76888362e-01f, 1.59695610e-01f, 2.68978775e-02f, -8.90958682e-02f, 1.40047381e-02f, 1.91818236e-03f,
  1.84697896e-01f, -6.89933300e-02f, -9.25821736e-02f, -9.68356244e-03f, -1.04208544e-01f, -1.54918907e-02f, 1.79986898e-02f, -1.94815457e-01f, -1.70856118e-01f, 2.36463398e-01f,
  1.04994550e-02f, -7.38460198e-02f, -4.65524048e-02f, -4.54368256e-02f, -2.46997505e-01f, -1.24989890e-01f, -2.11723208e-01f, -1.28140226e-01f, 1.30434006e-01f, 1.60631970e-01f,
  2.16359168e-01f, -6.07776009e-02f, 3.74959558e-02f, 4.45937552e-02f, -1.34903997e-01f, -2.63233036e-02f, -3.62073421e-01f, 2.32044365e-02f, -1.03166355e-02f, -3.79784149e-04f,
  -2.41046324e-01f, -1.14401048e-02f, -1.75294235e-01f, -1.26491010e-01f, 1.04284205e-01f, -1.42863631e-01f, -4.16677557e-02f, -8.88478234e-02f, -8.41586441e-02f, -1.46658614e-01f,
  -1.67988345e-01f, 7.14176074e-02f, 2.85468727e-01f, 1.09986722e-01f, 5.68814762e-02f, 2.89131761e-01f, 8.67372230e-02f, 2.97159050e-02f, 1.07379042e-01f, 5.66462636e-01f,
  4.13642019e-01f, 1.76247701e-01f, 5.83558917e-01f, 5.02916813e-01f, 7.14268208e-01f, 7.15227723e-01f, 9.24357295e-01f, 5.13243794e-01f, 2.88681686e-01f, 3.35143715e-01f,
  3.53579670e-01f, -8.64756182e-02f, -1.64895635e-02f, -6.58214986e-02f, 5.33970892e-02f, 1.46721780e-01f, 1.20244883e-01f, -7.14932382e-03f, 1.23256996e-01f, 2.15755805e-01f,
  -6.35861233e-02f, -1.90278646e-02f, -1.04754582e-01f, 8.06480125e-02f, 1.10171333e-01f, -9.77930650e-02f, 2.22483933e-01f, 2.72295177e-01f, -4.01795320e-02f, -2.85031974e-01f,
  -1.92049861e-01f, 1.86180487e-01f, -2.05302462e-01f, -2.56421745e-01f, -1.86667427e-01f, -2.49723300e-01f, -1.19019523e-01f, -1.97596490e-01f, -1.78043753e-01f, -2.25592777e-01f,
  -6.29915968e-02f, -1.14156924e-01f, 1.04810089e-01f, 1.19311593e-01f, 1.27249166e-01f, 9.69620124e-02f, 1.50999263e-01f, 1.05794944e-01f, 1.50758728e-01f, -4.48935218e-02f,
  9.72805917e-02f, 4.35487866e-01f, 3.85499924e-01f, 1.74507305e-01f, 1.08668216e-01f, -9.25332233e-02f, 5.17457388e-02f, -8.56007040e-02f, 5.50403669e-02f, -9.06679705e-02f,
  2.06088543e-01f, -9.51535478e-02f, 9.48537961e-02f, 5.72599322e-02f, -1.92958228e-02f, -1.47665724e-01f, 1.18754372e-01f, 2.17272803e-01f, 1.26480624e-01f, -6.90948591e-02f,
  -2.97392663e-02f, -5.44174900e-03f, 1.58825442e-01f, 6.16519637e-02f, -2.09133117e-03f, 2.49087587e-01f, 5.49012125e-02f, 5.44989370e-02f, 4.87927869e-02f, -1.06527954e-02f,
  4.67985123e-02f, -2.02341471e-02f, -4.08739820e-02f, 4.90029082e-02f, 7.50781372e-02f, 2.26248801e-02f, -4.22729105e-02f, 5.28040994e-03f, -4.79125185e-03f, -1.08365774e-01f,
  -2.02986952e-02f, 2.28354797e-01f, -1.66438758e-01f, 2.82966136e-03f, -7.00474828e-02f, -1.89318404e-01f, 2.88733188e-02f, -3.14724073e-02f, -2.73951679e-01f, -2.04473764e-01f,
  -1.37290925e-01f, -1.87857032e-01f, -2.07881741e-02f, -6.99817613e-02f, -2.80290917e-02f, -1.08108789e-01f, 1.59493551e-01f, 2.65181214e-01f, -1.69294089e-01f, -1.39675774e-02f,
  -1.32180125e-01f, 1.45056188e-01f, 2.88691819e-01f, 1.92930810e-02f, -1.08662665e-01f, -1.21742986e-01f, -1.90403774e-01f, -1.79215148e-01f, -3.86952348e-02f, -1.70109794e-01f,
  -1.44933200e+00f, 2.65545070e-01f, 3.00213814e-01f, -9.59837809e-02f, 8.92079115e-01f, 1.32256731e-01f, -2.83970356e-01f, -5.72561979e-01f, 7.05089867e-02f, 1.68991134e-01f,
  4.78255749e-01f, 5.29710464e-02f, 1.97833344e-01f, -2.71812342e-02f, -5.74715734e-01f, 3.81647497e-01f, 6.42874777e-01f, -3.46952558e-01f, -8.65898252e-01f, -7.71882594e-01f,
  6.88184565e-03f, -3.07658166e-01f, -7.68731236e-01f, -3.75273287e-01f, 2.27735698e-01f, -2.14002142e-03f, 5.55268764e-01f, 7.92007372e-02f, 9.86983478e-02f, 3.24624240e-01f,
  -4.58499968e-01f, -4.01504308e-01f, 5.14392443e-02f, 2.85650730e-01f, 4.74803627e-01f, -3.89935851e-01f, -1.56806156e-01f, 6.92284899e-03f, 1.33208215e-01f, 7.62219429e-02f,
  1.16711617e-01f, -4.22876701e-02f, 3.99290740e-01f, -4.40475494e-02f, -1.28698155e-01f, -4.18078691e-01f, -2.05196679e-01f, -7.57272184e-01f, -4.93661046e-01f, -3.53877157e-01f,
  6.00238681e-01f, 1.24236047e-01f, -2.07183182e-01f, -2.47331858e-01f, -3.78179669e-01f, -1.54375896e-01f, -4.13751036e-01f, -5.91084063e-01f, -7.67314434e-01f, -7.95348704e-01f,
  9.47816856e-03f, 1.73880458e-01f, 1.89567730e-01f, -8.12821463e-02f, 6.96687587e-03f, 1.93727806e-01f, 1.98945001e-01f, 3.05109262e-01f, -7.96398371e-02f, -1.14153326e-01f,
  2.61745192e-02f, 1.00661898e-02f, -6.50762096e-02f, -3.50280479e-02f, -5.02291359e-02f, 6.08691871e-02f, -1.06266148e-01f, -1.08795233e-01f, -7.18300696e-03f, -3.46753970e-02f,
  -8.75855312e-02f, 2.08360571e-02f, 9.73506346e-02f, -3.18635523e-01f, -5.06882183e-02f, 4.28046063e-02f, -5.77883646e-02f, -3.66939418e-02f, -7.11638778e-02f, -5.78241572e-02f,
  -2.85406649e-01f, 3.27313989e-01f, -1.19968466e-01f, -1.21488333e-01f, -2.25702282e-02f, 2.33010098e-01f, 1.45150155e-01f, 4.30170447e-02f, 9.07104090e-02f, -2.45040596e-01f,
  -2.37429664e-01f, -8.98782536e-02f, 1.24082677e-01f, -8.93405750e-02f, -1.69687331e-01f, 2.74826456e-02f, -1.42787620e-01f, 4.19398621e-02f, -9.41288844e-02f, 4.92704138e-02f,
  1.70430347e-01f, -4.79298383e-01f, -7.20809758e-01f, -4.77929741e-01f, -1.30029544e-01f, -4.84282523e-01f, -4.02718961e-01f, -6.04965687e-01f, -6.11770034e-01f, -9.58414376e-01f,
  3.62859428e-01f, -1.07084227e+00f, 1.29245475e-01f, -3.68933886e-01f, -3.08109820e-01f, -6.43695220e-02f, -3.89888138e-01f, -2.14453951e-01f, -3.33354563e-01f, -4.75923866e-01f,
  3.76581075e-03f, 6.82697058e-01f, 6.73518777e-01f, 5.33111334e-01f, 6.35236740e-01f, -4.03493762e-01f, -3.30715746e-01f, 6.77526772e-01f, 9.44632769e-01f, 1.41609043e-01f,
  -1.83606192e-01f, -8.49223137e-02f, 1.32984921e-01f, 1.21393427e-02f, -5.73729336e-01f, 1.58188090e-01f, -7.99101815e-02f, -2.53254920e-01f, -2.03957289e-01f, -5.12546122e-01f,
  2.33866617e-01f, -9.05393809e-03f, 4.21031684e-01f, 5.03542870e-02f, 7.82756321e-03f, 1.33845611e-02f, 8.74115038e-04f, -5.96449971e-02f, -1.66317910e-01f, -2.62374550e-01f,
  -4.19047894e-03f, -1.27283344e-02f, 8.36333632e-02f, -1.48919031e-01f, -8.51844698e-02f, -6.77483436e-03f, -1.27796993e-01f, 8.46103355e-02f, 4.45499793e-02f, -2.02099949e-01f,
  -1.55972406e-01f, -1.22863069e-01f, 1.63919523e-01f, 1.56481460e-01f, 1.75243974e-01f, 3.63287747e-01f, 1.13640964e-01f, 3.07240011e-03f, 7.38487095e-02f, -1.92891791e-01f,
  1.17019385e-01f, -1.25233531e-02f, 8.23101699e-02f, 2.97117308e-02f, 1.43171415e-01f, 6.77715093e-02f, 2.30767820e-02f, 5.85545078e-02f, 2.02127412e-01f, 1.02066830e-01f,
  -1.26004085e-01f, 1.10398084e-02f, 7.47299171e-04f, -1.37294412e-01f, 1.01185642e-01f, -1.05645649e-01f, -2.43125726e-02f, -1.16401566e-02f, 1.76073521e-01f, -1.32111028e-01f,
  1.59813479e-01f, 4.79423739e-02f, -4.07868139e-02f, -4.61311750e-02f, -1.17684454e-01f, -4.39617485e-02f, -6.03728741e-03f, 1.89930275e-02f, -4.06264141e-02f, -2.19586775e-01f,
  -1.04578935e-01f, 5.91276109e-01f, 2.77224462e-02f, 6.66942671e-02f, -1.60782516e-01f, -1.58896565e-01f, -1.40604109e-03f, -6.78798109e-02f, -1.42455742e-01f, -1.05379596e-01f,
  -4.01795544e-02f, 4.32762094e-02f, -4.57247496e-02f, -7.53352884e-04f, 1.36744976e-01f, 3.01037319e-02f, -8.97432119e-02f, 9.02241841e-02f, -4.35584076e-02f, -3.14086616e-01f,
  -2.68420607e-01f, -2.45943107e-02f, 2.11109519e-01f, 1.07564591e-01f, 3.64890397e-02f, 3.25623214e-01f, 1.57759473e-01f, 5.74001856e-02f, 2.63861835e-01f, -3.01903337e-01f,
  -8.96413267e-01f, -8.65696192e-01f, -3.20270777e-01f, -1.23017454e+00f, -7.73264766e-01f, -5.19379117e-02f, -5.28627396e-01f, -3.28210354e-01f, -3.52008879e-01f, -8.23452950e-01f,
  -2.41688624e-01f, -4.12636325e-02f, -1.33510277e-01f, 3.57582599e-01f, 7.18148410e-01f, -5.32870471e-01f, -4.56736743e-01f, 1.09087370e-01f, 4.53739673e-01f, -2.16571540e-01f,
  -4.52920884e-01f, -6.37938619e-01f, -1.31918592e-02f, -1.02884606e-01f, -1.01707172e+00f, -4.03572500e-01f, -6.43655658e-01f, -6.79058671e-01f, -3.99799272e-02f, -1.06722879e+00f,
  -9.12366033e-01f, -8.10120627e-02f, 3.13988805e-01f, 1.93530157e-01f, -4.17571306e-01f, 2.41426423e-01f, -1.95977241e-01f, 4.05716449e-02f, 1.38737068e-01f, -8.45700651e-02f,
  -2.32364729e-01f, -1.07200267e-02f, 7.18078390e-02f, 1.61676228e-01f, -2.91385859e-01f, -4.79141846e-02f, 7.59423599e-02f, 2.91451573e-01f, 9.52502526e-03f, -7.65927732e-02f,
  4.38431166e-02f, 1.76220030e-01f, 1.26229703e-01f, 4.30178642e-01f, 2.94967562e-01f, 3.70332211e-01f, -8.68236795e-02f, 1.55731887e-01f, 5.18212140e-01f, -8.67538273e-01f,
  4.43709753e-02f, -4.19380330e-02f, -1.53903961e-01f, -1.22476913e-01f, 1.16378039e-01f, -1.46230489e-01f, -2.64444221e-02f, -1.32035509e-01f, 7.38314167e-02f, -1.56789243e-01f,
  2.92370729e-02f, 1.26696974e-01f, 1.63937230e-02f, -2.51984224e-02f, -2.68764347e-02f, -1.23803601e-01f, 4.61423770e-02f, 3.86415236e-03f, -1.69070461e-03f, 4.13505957e-02f,
  7.49972137e-03f, 4.43126410e-02f, -1.75986484e-01f, -1.51526127e-02f, 1.56632796e-01f, 1.18530072e-01f, -3.94549072e-02f, 1.75435454e-01f, -1.45033792e-01f, 2.09774420e-01f,
  -7.19465435e-01f, 9.98152196e-01f, -6.67591691e-01f, 8.28923956e-02f, -3.23100865e-01f, -3.28968801e-02f, -2.18964517e-01f, 2.58083880e-01f, -1.08392671e-01f, -2.95093566e-01f,
  -4.37025391e-02f, -1.23319425e-01f, -2.33353376e-01f, -4.43461761e-02f, -2.46156361e-02f, -5.95530309e-02f, 1.78442542e-02f, -3.77155632e-01f, 1.75754607e-01f, -2.21808285e-01f,
  -3.52359749e-02f, -2.80161272e-03f, -4.94115442e-01f, -3.38949919e-01f, -1.78953692e-01f, -3.28854546e-02f, -4.30083096e-01f, -2.02699289e-01f, 1.45631731e-01f, -9.88580048e-01f,
  1.50077975e+00f, 7.38417745e-01f, 4.49101537e-01f, 3.83032709e-01f, -1.55569747e-01f, -4.39057127e-02f, 1.57840610e-01f, 1.83463067e-01f, 4.40512113e-02f, 4.60807800e-01f,
  3.40614319e-01f, 2.07735270e-01f, 2.32226402e-01f, 1.40060484e-01f, 2.20385730e-01f, 4.91989544e-03f, -2.11198166e-01f, 2.12693274e-01f, 1.05970435e-01f, 1.84426904e-01f,
  1.07036762e-01f, 3.43522102e-01f, 4.30904090e-01f, -2.05139928e-02f, -9.42008719e-02f, -2.20560670e-01f, -1.22706711e-01f, 2.32614316e-02f, 1.67450681e-01f, 1.32423520e-01f,
  4.24912184e-01f, 5.69812775e-01f, -5.63304543e-01f, -1.85253173e-01f, 3.57568786e-02f, 2.66226809e-02f, -4.72231954e-02f, -1.84512064e-02f, 2.91090272e-02f, 4.48608883e-02f,
  1.33021753e-02f, 1.53978676e-01f, 2.70573348e-01f, -1.01742141e-01f, 2.41865255e-02f, -8.77440199e-02f, 1.41274914e-01f, 1.80568412e-01f, 1.10212319e-01f, 1.26877276e-03f,
  2.50219498e-02f, 1.35121107e-01f, -7.49840364e-02f, -2.50796974e-01f, 4.36582007e-02f, -1.50713161e-01f, -5.82930855e-02f, -1.50325359e-03f, 4.91335280e-02f, 1.24848329e-01f,
  -1.58999935e-02f, 1.47479847e-01f, 1.75108448e-01f, 1.30771592e-01f, 3.46941441e-01f, 3.18194665e-02f, -2.37153191e-02f, 1.19077712e-01f, 3.93900536e-02f, -1.15374550e-01f,
  4.81623691e-03f, 5.64778298e-02f, 9.01948735e-02f, -1.26731351e-01f, -9.73648131e-02f, 4.95229550e-02f, 4.25760224e-02f, -3.57190482e-02f, -8.08834583e-02f, -2.05260083e-01f,
  1.29067272e-01f, -1.32724077e-01f, -1.92392975e-01f, 1.43574951e-02f, -2.26432011e-01f, 9.69817340e-02f, -2.01040413e-02f, 5.27221374e-02f, 8.40422139e-02f, 1.44359976e-01f,
  -5.86699545e-01f, -1.15482800e-01f, -2.41022810e-01f, -2.55049944e-01f, 1.59100667e-02f, -1.06963078e-02f, 8.41047466e-02f, 3.49030495e-02f, -2.62542292e-02f, 4.63995710e-02f,
  -1.78827450e-01f, 4.50504757e-02f, 1.63189054e-01f, 1.04711941e-02f, -2.37886250e-01f, -2.45641410e-01f, -4.11967225e-02f, -7.09959865e-02f, -1.54527187e-01f, -1.80528939e-01f,
  -1.10473007e-01f, -1.19157493e-01f, -2.35457703e-01f, -3.01043212e-01f, -1.80239990e-01f, -3.78908038e-01f, -4.08386588e-01f, -4.19755280e-01f, -3.27431589e-01f, -2.35334218e-01f,
  3.81276637e-01f, -1.08923562e-01f, 9.24884796e-01f, -2.28257447e-01f, 7.44695485e-01f, 9.31251347e-01f, 1.13842905e+00f, 4.48475361e-01f, -1.74332187e-01f, 3.52266878e-01f,
  -3.08000803e-01f, -1.19500637e+00f, -1.17870498e+00f, -8.01842153e-01f, -2.47103885e-01f, 7.47379661e-01f, 6.32321715e-01f, 8.86553377e-02f, 7.99249113e-02f, 3.16833824e-01f,
  -1.71807572e-01f, 1.22812167e-01f, -1.16166905e-01f, -1.88482657e-01f, -3.45306218e-01f, -6.04262888e-01f, 2.47525349e-01f, 1.33109465e-01f, 1.30482733e-01f, -6.42544687e-01f,
  6.42517433e-02f, 5.29874146e-01f, 7.50092119e-02f, -4.41376448e-01f, -3.22321802e-01f, -2.41124183e-01f, -1.26782693e-02f, -3.05629194e-01f, -3.11990589e-01f, -3.82489823e-02f,
  -1.39719516e-01f, -2.73705661e-01f, -4.66687769e-01f, -1.82942599e-01f, 1.21005498e-01f, -2.15537671e-04f, -1.23095371e-01f, -8.06600600e-02f, -4.44587231e-01f, -2.77801186e-01f,
  -3.21352899e-01f, 3.45374912e-01f, 3.85818601e-01f, 3.77791405e-01f, -5.70812076e-02f, -1.02452233e-01f, 3.12411319e-02f, 5.26701799e-03f, 2.16231123e-01f, -2.24394396e-01f,
  1.39741749e-01f, 6.62277490e-02f, -7.40287011e-04f, 1.15162022e-01f, -4.69010137e-02f, 7.34377354e-02f, -1.27446234e-01f, -1.24866836e-01f, 1.01576671e-01f, 5.51263765e-02f,
  -1.12416781e-01f, 4.82640648e-03f, 1.56528458e-01f, -1.30174896e-02f, -1.97893858e-01f, 3.01748235e-02f, 1.72463968e-01f, -2.85506129e-01f, -1.28775805e-01f, 3.32097262e-02f,
  4.05147597e-02f, 8.28041062e-02f, -7.80983418e-02f, -2.25856736e-01f, 1.73797309e-01f, 7.29577942e-03f, 1.71601288e-02f, -1.59063980e-01f, -6.47742823e-02f, 4.04459119e-01f,
  -6.14353597e-01f, 1.22651100e-01f, -3.48326921e-01f, -1.13138378e-01f, 1.43863587e-02f, -1.12458497e-01f, 4.39844355e-02f, -1.13697462e-01f, 6.79457858e-02f, -7.54685998e-02f,
  1.33906826e-01f, -2.92884588e-01f, -1.89998835e-01f, 7.30372295e-02f, -4.43045162e-02f, 1.87680706e-01f, -7.78367296e-02f, -1.41217291e-01f, -1.91102803e-01f, -1.03976808e-01f,
  -1.01600483e-01f, 2.39538997e-01f, 2.15262413e-01f, 3.00981682e-02f, 2.19275691e-02f, 1.35103703e-01f, 1.06865086e-01f, 1.45459428e-01f, 2.33470678e-01f, 1.17719747e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  6.35833740e-01f, 1.33586729e+00f, 1.12761176e+00f, 9.53799665e-01f, 1.37227046e+00f, 9.01026011e-01f, 3.10088098e-01f, 8.02975714e-01f, 5.40322542e-01f, 6.33692801e-01f,
  8.61711979e-01f, 8.36393654e-01f, 1.16783428e+00f, 1.20994103e+00f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -4.84319657e-01f, -7.77935088e-01f, 2.03942508e-01f, -1.20749986e+00f, -1.46053553e+00f, -6.83786392e-01f, -2.18821943e-01f, -2.70833280e-02f, 9.26120043e-01f, 6.09110594e-01f,
  -6.52508974e-01f, -6.47143245e-01f, 6.60938203e-01f, 5.25701225e-01f, -5.33938468e-01f, -3.72258574e-01f, 1.52392061e-02f, 2.86617547e-01f, -8.13450992e-01f, 4.32935983e-01f,
  -9.72157538e-01f, -2.89356057e-02f, 4.51207787e-01f, -1.26468778e+00f, -8.25525045e-01f, 2.03457981e-01f, 1.29125372e-01f, -1.34490168e+00f, 6.56389594e-01f, 9.19275224e-01f,
  4.81683314e-01f, -8.82424593e-01f, 4.36528563e-01f, 8.32671374e-02f, -8.19200933e-01f, 3.90846521e-01f, 1.02658832e+00f, -1.77868813e-01f, -1.72699833e+00f, -4.06849653e-01f,
  -3.11775375e-02f, -3.88068378e-01f, -6.34305358e-01f, 4.51548904e-01f, 6.84144258e-01f, 6.59493208e-01f, -7.50440955e-01f, -6.69778943e-01f, -3.85579795e-01f, 6.81773871e-02f,
  -9.40896943e-02f, -3.85348380e-01f, -1.06056118e+00f, -7.47450292e-01f, -8.44013989e-01f, 8.55801344e-01f, -9.12700891e-01f, -1.03074205e+00f, -8.28672469e-01f, 6.30446315e-01f,
  -8.00869286e-01f, 8.86197686e-01f, -7.53355622e-01f, 9.04856920e-01f, -5.56810439e-01f, 6.31537020e-01f, -9.72437263e-01f, -8.25673401e-01f, 4.35006499e-01f, 4.55747768e-02f,
  6.55202389e-01f, -2.57101834e-01f, 8.00987482e-02f, -7.90478230e-01f, 3.89866412e-01f, 6.95773661e-01f, -5.97563982e-01f, -1.31732762e-01f, -1.02153516e+00f, -4.55486327e-01f,
  2.66449034e-01f, 2.34532014e-01f, 1.15530443e+00f, 7.92003810e-01f, -1.91928297e-01f, 1.22879632e-01f, 3.99307013e-01f, 5.37251756e-02f, -3.17021310e-01f, 9.47681308e-01f,
  -2.73243576e-01f, -9.39508557e-01f, -1.96205413e+00f, -3.73406529e-01f, 2.72862036e-02f, -5.10766447e-01f, -6.55302629e-02f, -1.68183818e-01f, -8.14488947e-01f, 2.49026656e-01f,
  1.25191438e+00f, 4.71178293e-01f, -1.42958176e+00f, -4.12029952e-01f, -3.69152814e-01f, -1.02415931e+00f, -7.51204312e-01f, -1.52204657e+00f, -1.48272145e+00f, -7.99060524e-01f,
  8.08377385e-01f, -8.91679525e-01f, -8.70369151e-02f, 4.85885590e-02f, 1.23610055e+00f, -4.30704832e-01f, -2.59124666e-01f, 5.52052200e-01f, -8.05532038e-01f, -5.85104764e-01f,
  -1.58757758e+00f, -6.71171546e-01f, 3.47862244e-02f, 1.29000223e+00f, -7.43141249e-02f, -5.66446543e-01f, -5.15327990e-01f, -7.87519515e-01f, 4.37069871e-02f, -3.61816496e-01f,
  2.62222469e-01f, 4.91619825e-01f, -3.64396572e-01f, -2.97919095e-01f, -1.26527286e+00f, -4.56015766e-01f, -5.41790783e-01f, 7.10539281e-01f, 3.75619382e-01f, -3.93411398e-01f,
  -2.42284745e-01f, -7.85944998e-01f, -1.16195953e+00f, 1.26066267e+00f, 6.53695345e-01f, -1.23329654e-01f, -7.91229546e-01f, -1.18233585e+00f, -2.91894615e-01f, 5.50302565e-01f,
  4.17843372e-01f, -1.49051905e+00f, 1.45542741e+00f, -6.52256727e-01f, -6.14321291e-01f, 5.52211225e-01f, -9.05186653e-01f, -1.14401317e+00f, 2.98539013e-01f, -1.56764436e+00f,
  3.95414233e-01f, 1.06259249e-01f, 2.82288253e-01f, -7.58709371e-01f, -9.47545409e-01f, -2.85286188e-01f, 4.17571634e-01f, 1.36356413e+00f, -5.63087523e-01f, -5.10029554e-01f,
  -7.89406419e-01f, -7.20122635e-01f, 2.20440060e-01f, -1.31040406e+00f, -5.14223158e-01f, -6.33494258e-01f, 8.06763247e-02f, -1.62868857e-01f, -1.09795809e+00f, -1.72999680e+00f,
  -7.52700493e-02f, -1.34800339e+00f, 1.17232343e-02f, -9.97495174e-01f, -3.61165196e-01f, -5.62082112e-01f, 6.25146151e-01f, -1.38273686e-02f, -1.80316325e-02f, -4.44791347e-01f,
  4.98758674e-01f, 1.12544584e+00f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  4.89669651e-01f, -5.35085320e-01f, 5.54131307e-02f, -6.21602595e-01f, 8.54084134e-01f, 4.65055928e-02f, 3.65508497e-01f, -7.21035719e-01f, -5.05192101e-01f, 2.83659965e-01f,
  -5.68122089e-01f, -4.59733643e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    