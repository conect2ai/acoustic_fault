/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.80305243e-02f, -2.26432055e-01f, 3.69950384e-01f, -2.65335441e-01f, 7.78297931e-02f, 2.75657624e-01f, 3.36946607e-01f, -2.16273144e-01f, -1.18759625e-01f, -2.78252244e-01f,
  -1.55770972e-01f, 1.55017957e-01f, 1.27708614e-01f, -2.32458174e-01f, 4.61825341e-01f, 1.50697902e-01f, -1.10476725e-01f, -6.26410171e-02f, -7.85386041e-02f, -1.73777789e-01f,
  -4.16644327e-02f, -1.44425333e-01f, 1.28831744e-01f, -1.65556997e-01f, -3.37122381e-02f, -8.74024853e-02f, -3.88831533e-02f, 1.00064427e-01f, -1.04528494e-01f, 3.21297571e-02f,
  1.11959472e-01f, -2.57537067e-01f, 9.78702903e-02f, 8.63532908e-03f, -8.15107524e-02f, 7.31813237e-02f, 8.85479674e-02f, 1.69646516e-01f, 2.52117752e-03f, 3.88236009e-02f,
  1.45457834e-01f, 3.48797301e-03f, -3.79233547e-02f, -1.73486676e-02f, -5.98126650e-02f, 2.61261202e-02f, -2.07351111e-02f, -2.76270360e-02f, 6.87866518e-03f, 6.75611570e-02f,
  1.37950154e-02f, 4.71755341e-02f, 6.30497336e-02f, -2.74309069e-02f, 3.39194350e-02f, 5.19108539e-03f, 8.20664689e-02f, 1.29338726e-01f, 1.42328963e-02f, -6.33539557e-02f,
  8.56231749e-02f, 6.89118281e-02f, -4.55874801e-02f, -2.08107345e-02f, -1.69828571e-02f, -5.51340878e-02f, -3.60810868e-02f, -1.43875359e-02f, -2.79359054e-03f, -3.15422355e-03f,
  -8.83298274e-03f, -1.12881251e-02f, -3.84476446e-02f, 8.89616087e-03f, 5.22502093e-03f, -1.07865661e-01f, 9.55713987e-02f, 2.18677912e-02f, 1.75403766e-02f, -3.35390083e-02f,
  5.41763306e-02f, 3.29071656e-02f, -2.06288369e-03f, 2.42121164e-02f, -2.36770865e-02f, 1.30914561e-02f, 6.66372338e-03f, -3.09946891e-02f, -7.02227280e-02f, 1.16330534e-01f,
  -1.98631093e-01f, -2.44755298e-01f, 4.82531823e-02f, -7.80393854e-02f, -1.31710470e-02f, -8.13293271e-03f, 1.24202490e-01f, -2.57310309e-02f, 5.00087701e-02f, -8.66367742e-02f,
  -1.27239555e-01f, -2.62012575e-02f, -3.70427109e-02f, 6.03118958e-03f, 2.72939969e-02f, -1.44653267e-03f, 2.06982214e-02f, 9.76238921e-02f, 1.61768738e-02f, -3.34236957e-02f,
  -5.95143065e-02f, -5.61706955e-03f, 6.23151958e-02f, -4.40529399e-02f, 3.84586379e-02f, -1.71716418e-02f, 4.38352823e-02f, 3.25839259e-02f, 1.26262093e-02f, 7.11547211e-02f,
  -1.31903574e-01f, -2.09650025e-02f, -8.41716677e-02f, 2.28960142e-02f, 5.57073653e-02f, 2.32592791e-01f, 9.26385913e-03f, 1.13915831e-01f, -3.32358748e-01f, 6.09037913e-02f,
  1.90739676e-01f, -9.05097276e-02f, -1.27979353e-01f, 2.93680012e-01f, -3.09426745e-04f, -1.20672196e-01f, 1.58593282e-01f, 1.90808803e-01f, -1.38066158e-01f, 1.66140452e-01f,
  -2.86249747e-03f, 2.07318932e-01f, 1.77832097e-01f, 1.39071792e-01f, 1.04121201e-01f, 5.75583503e-02f, 1.40840784e-01f, -1.91107113e-02f, 4.30880278e-01f, 1.59562547e-02f,
  -2.45846361e-02f, -6.99721128e-02f, -2.59104259e-02f, -6.17596172e-02f, 7.82777667e-02f, 2.38588471e-02f, 9.81712043e-02f, -3.49540599e-02f, 3.45656462e-02f, 8.91790166e-02f,
  -6.71747625e-02f, 2.27012578e-02f, 4.54710349e-02f, -3.15027758e-02f, 3.97890806e-03f, -9.55729000e-03f, 4.18660202e-04f, 3.01099531e-02f, -4.20234241e-02f, 1.18467724e-02f,
  -3.35282972e-03f, 5.22224382e-02f, -4.99567436e-03f, -4.00879011e-02f, -2.46813577e-02f, -7.17633823e-03f, -4.82834838e-02f, 5.42699965e-03f, 2.74250433e-02f, 2.26636417e-02f,
  3.10531855e-02f, -4.20961902e-02f, 6.48215562e-02f, -1.49713270e-02f, 1.54538499e-02f, 1.74323972e-02f, 1.74422637e-02f, -2.25470718e-02f, -3.69126573e-02f, -3.48388217e-03f,
  -1.34214750e-02f, 1.79053731e-02f, -4.62611839e-02f, 1.96434837e-02f, 3.42037231e-02f, -4.91535589e-02f, -3.22082192e-02f, 4.12369072e-02f, -6.22064471e-02f, -1.96034778e-02f,
  7.61436252e-03f, -2.09315848e-02f, 2.89344154e-02f, -4.04412067e-03f, -9.20512676e-02f, -4.86434437e-02f, 4.85674739e-02f, -5.51232733e-02f, -1.66774895e-02f, 2.96815252e-03f,
  1.73790723e-01f, 6.45466819e-02f, -3.82907838e-02f, 1.70999643e-04f, -7.52100572e-02f, 5.28629450e-03f, -7.92208388e-02f, 6.49962872e-02f, 4.79371697e-02f, -7.38817528e-02f,
  1.49454728e-01f, -2.04468798e-03f, -5.13654277e-02f, 8.22307914e-03f, -1.30885346e-02f, 3.93793769e-02f, -3.85405906e-02f, 1.61084011e-02f, -7.50299543e-03f, 8.94339830e-02f,
  6.84876787e-03f, 1.67983118e-02f, -2.49951798e-02f, -4.95021651e-03f, 3.78167033e-02f, 3.95106971e-02f, 4.39682975e-02f, 9.86531656e-03f, 6.14116192e-02f, -6.83422834e-02f,
  -2.00076833e-01f, 6.69008866e-02f, 1.76804304e-01f, 9.88172218e-02f, -1.13069519e-01f, 4.45234746e-01f, 1.95446670e-01f, 1.78101528e-02f, 2.15158150e-01f, 1.09457061e-01f,
  -5.42979501e-02f, 1.63227558e-01f, -1.30703241e-01f, 2.94130445e-01f, -3.79511714e-02f, 5.78861870e-02f, 1.24802060e-01f, 1.07940078e-01f, -6.62411824e-02f, -8.92519485e-03f,
  -6.35720566e-02f, 4.72939527e-03f, 5.17908521e-02f, -3.19230072e-02f, -7.51872361e-02f, -1.14441648e-01f, -1.00639842e-01f, -5.62424287e-02f, 3.05275861e-02f, 3.80008630e-02f,
  -3.89157347e-02f, -8.71594995e-02f, 2.96649872e-03f, 4.30369414e-02f, -3.72049510e-02f, -3.11705191e-02f, -6.64513335e-02f, 8.98921117e-03f, 2.90076272e-03f, 5.16295023e-02f,
  -2.68855598e-02f, 1.46853933e-02f, -2.36180238e-03f, 5.45314476e-02f, 9.99865383e-02f, -4.66268659e-02f, 4.40780893e-02f, 7.80353919e-02f, -2.16597002e-02f, -4.39693518e-02f,
  6.68532476e-02f, -6.27140403e-02f, 3.51531692e-02f, 4.45448309e-02f, 6.59184754e-02f, 1.63098685e-02f, -6.34359121e-02f, -2.79590059e-02f, -4.59210165e-02f, 1.66045874e-02f,
  -1.66586637e-02f, -6.88612387e-02f, -2.21750028e-02f, 1.02680521e-02f, 2.59067416e-02f, -4.27932665e-02f, 6.96212351e-02f, -4.28795442e-02f, -1.79639198e-02f, -2.01117191e-02f,
  -3.05057177e-03f, -3.81548665e-02f, -3.81576307e-02f, 6.75839335e-02f, -3.02506946e-02f, -2.12423485e-02f, 2.22951472e-02f, 2.77979597e-02f, 5.17325476e-02f, 2.06943750e-02f,
  -1.03494413e-02f, 1.20140342e-02f, 1.88754294e-02f, -6.50686994e-02f, -6.35370016e-02f, 7.64333010e-02f, 1.99281126e-02f, 5.47836311e-02f, 3.46264839e-02f, -6.25208318e-02f,
  -2.87479851e-02f, -1.98811367e-01f, -3.05209700e-02f, -4.94858995e-02f, 5.09274751e-02f, 4.25132252e-02f, 5.63102141e-02f, -2.73245592e-02f, 2.70856861e-02f, -7.59500265e-02f,
  4.70457878e-03f, 1.68154910e-02f, -7.50643909e-02f, 2.33019870e-02f, -6.19781055e-02f, 2.03875545e-02f, -7.79616460e-02f, 1.30056851e-02f, 1.94345042e-02f, -4.23686765e-02f,
  -3.40891927e-02f, 4.00863253e-02f, -4.65499163e-02f, 5.05937301e-02f, -6.11457005e-02f, -5.67730032e-02f, -1.95971057e-02f, 1.14614330e-02f, -7.43839070e-02f, 1.05385818e-02f,
  2.12834418e-01f, -2.64787301e-02f, -2.03142792e-01f, 4.09139553e-03f, -6.53050020e-02f, 1.05445229e-01f, 4.23573196e-01f, -3.20332080e-01f, 1.59901395e-01f, 1.21995114e-01f,
  2.40292192e-01f, -7.90181160e-02f, 2.83360332e-01f, 1.01681180e-01f, -4.62775193e-02f, 1.75616041e-01f, -1.22485058e-02f, 1.36837050e-01f, -2.53389943e-02f, -5.38554601e-02f,
  -4.38663885e-02f, 1.35311902e-01f, -1.03787616e-01f, -1.61882177e-01f, 1.30106453e-02f, -2.40296409e-01f, -6.73084892e-03f, -9.92895439e-02f, -2.62064248e-01f, -4.50120643e-02f,
  -1.00453027e-01f, 1.57258570e-01f, -1.05104007e-01f, -2.68525928e-02f, 1.77021120e-02f, 7.43518351e-03f, -2.06149295e-02f, 1.75738148e-02f, -3.87389697e-02f, -7.82329515e-02f,
  8.35408941e-02f, -6.31187111e-02f, -2.04893760e-02f, -1.75706428e-02f, 2.88465898e-02f, -4.79921103e-02f, 1.84993929e-04f, 7.90889561e-03f, -1.88695826e-02f, 3.69858667e-02f,
  5.06843142e-02f, -2.68055201e-02f, 1.05177127e-01f, -2.76558604e-02f, -5.30574992e-02f, 5.20751774e-02f, 2.68142414e-03f, -4.70030680e-02f, -1.96395442e-03f, 1.73811428e-03f,
  2.57754344e-02f, 8.43359623e-03f, 5.79136088e-02f, -1.31356016e-01f, 3.76456901e-02f, -2.91015673e-02f, 3.24924290e-02f, 1.51380068e-02f, 6.42935839e-03f, 5.52615933e-02f,
  -1.33735547e-02f, -7.16761425e-02f, -2.10361346e-03f, 3.44425160e-03f, 1.88861024e-02f, -1.87152587e-02f, -3.56673636e-02f, -7.92379752e-02f, 8.43587592e-02f, -1.19924434e-01f,
  1.91302523e-02f, 4.58707055e-03f, 1.86960911e-03f, 3.66515154e-03f, 6.51301667e-02f, -7.54831918e-03f, 3.93801965e-02f, -7.58504122e-02f, -5.85376844e-03f, 1.99916796e-03f,
  1.59567252e-01f, 2.58677639e-02f, -1.61081291e-04f, 1.83568820e-02f, -2.49461047e-02f, -2.88279485e-02f, 1.12035954e-02f, -7.94476196e-02f, -3.95294316e-02f, 1.22583173e-01f,
  -1.01352647e-01f, -1.35521591e-03f, -4.99188676e-02f, -2.63031237e-02f, -6.81707039e-02f, 2.95752417e-02f, 6.16321303e-02f, -2.34303698e-02f, 6.04836689e-03f, -3.66111211e-02f,
  -9.63230338e-03f, 1.16058908e-01f, -5.33669665e-02f, -8.93771723e-02f, 4.41328809e-02f, 6.09028116e-02f, -6.54239282e-02f, 2.67485436e-02f, -6.69803396e-02f, -4.68107779e-03f,
  -3.98884207e-01f, -7.25720311e-04f, 3.08890995e-02f, -2.08290651e-01f, 4.32252400e-02f, 4.75511938e-01f, 4.45851028e-01f, -7.29865730e-02f, 1.10855829e-02f, 1.61773801e-01f,
  1.69994190e-01f, -1.38386577e-01f, 2.44247347e-01f, 1.77126937e-02f, 2.30724201e-01f, 3.12508851e-01f, -1.51615376e-02f, 4.29621898e-02f, -6.54511228e-02f, -1.46722525e-01f,
  4.85675223e-02f, -2.67916303e-02f, -5.52284811e-03f, -8.79285038e-02f, -7.55803660e-02f, -2.88619697e-01f, -2.18669280e-01f, 1.00430891e-01f, -2.18197852e-01f, -6.90212920e-02f,
  1.38988540e-01f, -8.63257125e-02f, -5.94292097e-02f, 4.82804067e-02f, -6.75247461e-02f, 7.43727908e-02f, 2.87944991e-02f, 6.98062181e-02f, -4.70917076e-02f, -1.06926449e-02f,
  7.52067789e-02f, -3.31759714e-02f, -3.15463208e-02f, -4.61175106e-02f, -1.10614067e-02f, -1.03110848e-02f, 7.41435587e-03f, -3.33653092e-02f, -5.94830662e-02f, 3.77538390e-02f,
  -2.80434974e-02f, 4.87187132e-03f, -1.27060443e-01f, -1.05505215e-03f, -1.23207793e-02f, -7.73581043e-02f, -1.57224410e-03f, -1.07219651e-01f, -3.57990749e-02f, -1.51100472e-01f,
  -1.48454625e-02f, -1.75626893e-02f, 3.48369181e-02f, -6.25959188e-02f, -1.48629993e-02f, -4.85097170e-02f, -1.81431164e-06f, -2.11230908e-02f, -3.95664275e-02f, 4.55801114e-02f,
  -1.81766879e-02f, 1.30580459e-02f, -5.78017905e-02f, 4.38029841e-02f, -6.12504259e-02f, -3.20448205e-02f, 3.27092484e-02f, -8.48316103e-02f, -2.61030104e-02f, -1.07350975e-01f,
  3.90958898e-02f, -2.28751395e-02f, 8.32459256e-02f, 5.80952018e-02f, 3.68772671e-02f, -2.21694703e-03f, -6.04071021e-02f, -6.51044175e-02f, 7.45768696e-02f, 7.95830935e-02f,
  1.95105657e-01f, -1.98452830e-01f, -1.65570732e-02f, 2.39331722e-02f, -1.00030703e-02f, 6.89317519e-03f, 4.40416597e-02f, 1.53442360e-02f, -5.15948609e-02f, -1.66740976e-02f,
  -3.91300805e-02f, -9.19738133e-03f, -1.22368455e-01f, 1.19564729e-02f, 6.81809038e-02f, 3.11023872e-02f, 1.18770879e-02f, -1.98389329e-02f, -4.98447344e-02f, -7.19936341e-02f,
  -7.07896426e-02f, -4.62421887e-02f, 1.75740905e-02f, -1.42275216e-02f, 3.32431979e-02f, 4.49783802e-02f, -9.57316235e-02f, -3.91004086e-02f, 3.96019556e-02f, 3.79260257e-03f,
  4.93067682e-01f, 2.25075841e-01f, 7.38539994e-02f, 2.05731481e-01f, 1.04240805e-01f, 1.29605249e-01f, -1.17584862e-01f, 2.41704389e-01f, 2.08782539e-01f, -2.86678448e-02f,
  7.83511028e-02f, 1.65063173e-01f, -2.35618502e-01f, 2.96948582e-01f, 3.66240174e-01f, -1.83808178e-01f, 2.46016607e-01f, 7.18108267e-02f, 6.22978620e-02f, 1.06770128e-01f,
  1.42272294e-01f, 2.84917146e-01f, 1.09013440e-02f, 1.09410234e-01f, 8.49276856e-02f, 2.29419628e-03f, 3.45246792e-02f, -1.26109317e-01f, 1.07004918e-01f, 5.65312132e-02f,
  -1.05851784e-01f, 9.74796414e-02f, 3.87038314e-03f, -3.88363330e-03f, 1.85419023e-02f, -7.66136050e-02f, -5.43780513e-02f, -3.96173224e-02f, 3.03165661e-03f, -4.69153328e-03f,
  -8.98987874e-02f, 1.18401386e-01f, 8.62171724e-02f, -3.52749112e-03f, 5.56797199e-02f, 7.80925602e-02f, 6.90467330e-03f, -3.75910401e-02f, 3.92333791e-02f, 6.21601120e-02f,
  1.61328949e-02f, -2.84141698e-03f, 7.30247200e-02f, -5.99088259e-02f, -4.55753226e-03f, 3.65276448e-02f, -2.57707834e-02f, -7.01722205e-02f, 4.95093018e-02f, -1.49209714e-02f,
  1.86011195e-03f, 3.77071053e-02f, 1.77396424e-02f, 3.19835655e-02f, 7.91862607e-02f, -8.05428438e-03f, -2.43540127e-02f, -1.33243529e-02f, 7.83590041e-03f, -4.89318073e-02f,
  7.91601464e-03f, 2.90412512e-02f, 3.44868675e-02f, 1.25841927e-02f, 1.50918113e-02f, 3.60681303e-02f, -5.33272102e-02f, -2.00497005e-02f, -3.58080454e-02f, 1.53054502e-02f,
  -3.41305248e-02f, 1.90204903e-02f, -2.20447667e-02f, -7.60096759e-02f, 7.58506684e-03f, 5.89016005e-02f, 3.52492146e-02f, -2.09495332e-02f, 4.54588532e-02f, -2.29762448e-03f,
  4.26946878e-02f, 1.16944611e-01f, -9.03602038e-03f, -1.54972880e-03f, -7.54601136e-02f, 7.08759353e-02f, 1.22167937e-01f, -2.39506960e-02f, 5.93005195e-02f, 2.74267495e-02f,
  4.01081368e-02f, -8.94970894e-02f, -2.77776681e-02f, -1.80330966e-02f, -2.94629275e-03f, 1.43324593e-02f, -2.19776183e-02f, 3.01501295e-03f, 6.95202947e-02f, 6.26074970e-02f,
  1.77362878e-02f, -3.87234204e-02f, -3.55853625e-02f, -1.19949048e-02f, -2.49244105e-02f, -1.06412947e-01f, 9.09512416e-02f, -1.58389248e-02f, -9.52723324e-02f, 2.17712503e-02f,
  8.27613547e-02f, 3.21947008e-01f, 2.16478631e-01f, -2.06596553e-01f, 5.52520296e-03f, 4.75869060e-01f, 1.39356643e-01f, 1.20515987e-01f, -3.63013335e-02f, -1.15165412e-01f,
  -2.70280898e-01f, 2.26204112e-01f, -3.08792703e-02f, -1.29593357e-01f, 1.39584064e-01f, 6.28750548e-02f, 9.93144587e-02f, 2.15380993e-02f, 1.40146598e-01f, 1.05706438e-01f,
  5.10612838e-02f, -1.80770770e-01f, 2.57786084e-03f, 1.47598321e-02f, 3.66951749e-02f, 1.42182950e-02f, -2.39104182e-01f, -4.75136936e-02f, -1.04514301e-01f, 3.06996722e-02f,
  9.88694280e-02f, -2.47416347e-02f, 6.14798022e-03f, -1.07722897e-02f, 5.12907244e-02f, -9.40233376e-03f, 5.74319903e-03f, -9.38256830e-02f, -5.30268885e-02f, 3.25094983e-02f,
  7.44296089e-02f, -4.89607491e-02f, 2.12505437e-03f, -3.92471924e-02f, 4.47467044e-02f, 1.09327529e-02f, -3.33190076e-02f, -7.84527063e-02f, 2.90606264e-02f, 4.31097895e-02f,
  3.88095714e-02f, -4.15633358e-02f, 1.27153937e-02f, 4.51612808e-02f, 3.35905626e-02f, 2.28595734e-02f, 7.77090341e-02f, 5.51079065e-02f, 7.58013278e-02f, 1.09572589e-01f,
  7.95460045e-02f, 4.27968949e-02f, -6.73805699e-02f, -1.63613319e-01f, 1.44019470e-01f, -3.85531113e-02f, -4.86686788e-02f, -8.14396888e-02f, 5.43537959e-02f, -2.33612880e-02f,
  -8.73359665e-02f, 4.44080085e-02f, -6.31523877e-02f, 4.12834734e-02f, -9.87011343e-02f, 2.26957668e-02f, -6.04049154e-02f, 5.00065694e-03f, -7.02931359e-02f, 6.20948635e-02f,
  -9.91916209e-02f, -1.74588822e-02f, -3.59695079e-03f, -9.05820578e-02f, -5.10095805e-02f, 7.47229159e-03f, -1.12961300e-01f, 1.02088340e-02f, -5.20221777e-02f, 2.74684988e-02f,
  1.27889931e-01f, 1.81512877e-01f, -3.46654765e-02f, 3.81478146e-02f, -2.12912019e-02f, -1.72937848e-02f, 1.04136346e-02f, 4.00639288e-02f, 9.07412991e-02f, 3.23206373e-02f,
  5.26413880e-02f, 1.89582724e-02f, 6.62456825e-02f, -1.28993183e-01f, 6.44988269e-02f, -2.63084434e-02f, -1.40847698e-01f, 8.44155380e-04f, 1.75623484e-02f, 8.38315263e-02f,
  -4.56505455e-02f, 1.41904419e-02f, -1.18578039e-02f, -2.74498630e-02f, -2.29931343e-02f, -8.36235285e-03f, -4.04507574e-03f, 6.53754920e-02f, -9.58276540e-03f, 1.16535230e-03f,
  -3.48368466e-01f, 2.05274388e-01f, -2.84833666e-02f, -2.78275073e-01f, 2.31026083e-01f, -2.58882880e-01f, -1.32924512e-01f, 1.45087689e-01f, -7.73880705e-02f, -1.68896288e-01f,
  7.62570277e-02f, -1.97514609e-01f, 2.41993859e-01f, 8.95014256e-02f, 2.86557466e-01f, 2.20861837e-01f, -1.11879908e-01f, -2.03808978e-01f, 1.96363367e-02f, -8.10822621e-02f,
  6.92855418e-02f, 6.31327257e-02f, 2.12473944e-01f, 9.43721309e-02f, 4.76923212e-02f, -1.81792721e-01f, 1.45034581e-01f, 5.11736311e-02f, -1.64644495e-01f, 5.94656169e-02f,
  -4.82986635e-03f, -3.26803364e-02f, 8.93846452e-02f, -4.66929236e-03f, -1.48234060e-02f, -2.13569421e-02f, -9.98147652e-02f, 1.41895562e-02f, -1.58899091e-02f, -3.14886197e-02f,
  1.99314579e-02f, 2.11153757e-02f, -1.00689337e-01f, 1.45709693e-01f, -7.08153695e-02f, 2.83213984e-02f, 3.99566367e-02f, 4.09268178e-02f, -5.10161035e-02f, 1.20453216e-01f,
  7.19419941e-02f, 5.67089543e-02f, -2.25583510e-03f, -1.19909070e-01f, 9.24732350e-03f, -6.93693459e-02f, 5.33754099e-03f, 6.34565353e-02f, -5.35844751e-02f, -1.90413352e-02f,
  6.18295232e-03f, -2.83504371e-02f, 6.41733110e-02f, -3.05362307e-02f, 7.72504089e-03f, 9.27327387e-03f, -1.93571411e-02f, -1.54904928e-02f, -6.91725761e-02f, 1.93746556e-02f,
  9.65459272e-03f, 7.15081301e-03f, 8.69624391e-02f, -3.58110107e-02f, 3.61296944e-02f, -5.14954627e-02f, -7.27933049e-02f, -3.49868797e-02f, -1.22133791e-02f, 6.27867654e-02f,
  2.31386744e-03f, -3.88982184e-02f, 8.12144205e-03f, 2.61865035e-02f, 3.26062031e-02f, 9.62527394e-02f, 4.55497093e-02f, 7.20033329e-03f, -4.75886576e-02f, 1.02298968e-02f,
  -1.60358306e-02f, -1.42439008e-01f, -2.29554754e-02f, -4.47363257e-02f, -2.51446515e-02f, 6.03093542e-02f, -3.96448709e-02f, 2.41907593e-02f, -3.81587818e-02f, 1.21203121e-02f,
  -3.37529220e-02f, -2.78288443e-02f, -2.91382968e-02f, -1.10693976e-01f, 8.01563356e-03f, 3.55002955e-02f, -7.39403144e-02f, -1.13065176e-01f, -3.80254202e-02f, -7.19506368e-02f,
  -5.12099750e-02f, -1.09268650e-01f, 6.92547951e-03f, 5.02012707e-02f, -6.76039681e-02f, 7.51976529e-03f, -9.48763564e-02f, -5.15643694e-02f, 3.30544375e-02f, 5.87530248e-03f,
  -1.96333140e-01f, 1.76465854e-01f, -1.44582823e-01f, -3.32574934e-01f, -1.48846149e-01f, 3.45759839e-01f, -1.15453135e-02f, -6.16726577e-02f, -3.03571790e-01f, 1.27167240e-01f,
  7.32922181e-02f, -2.38436535e-02f, 2.49905717e-02f, 1.89753976e-02f, -4.52750102e-02f, 1.11631207e-01f, -6.98276460e-02f, -8.50263685e-02f, 2.02713925e-02f, -1.40755903e-03f,
  -6.62419870e-02f, -1.57424323e-02f, 6.81544468e-02f, 9.22763627e-03f, 8.96455422e-02f, -7.62060359e-02f, 2.36449361e-01f, -3.27166095e-02f, -4.38671298e-02f, -5.62390238e-02f,
  5.33661544e-02f, -1.96684659e-01f, 3.73741835e-02f, -5.72526678e-02f, 1.92495421e-01f, 1.01963282e-01f, 7.20635131e-02f, -8.10302887e-03f, 4.73891647e-04f, -5.23095801e-02f,
  4.77281474e-02f, -1.03158373e-02f, -1.36845127e-01f, -6.74501956e-02f, 2.23318264e-02f, -7.00656772e-02f, 3.16979699e-02f, 1.21936180e-01f, -9.26800296e-02f, -7.87761621e-03f,
  4.14415672e-02f, 7.36480057e-02f, 1.09669887e-01f, -3.70296389e-02f, -1.40439495e-02f, -6.92849373e-03f, 2.64331829e-02f, 3.65739851e-03f, -3.38649820e-03f, 7.23806992e-02f,
  -7.58414492e-02f, 4.25939672e-02f, -2.93694958e-02f, -2.83522364e-02f, -7.92284161e-02f, -5.94694801e-02f, 1.52964741e-02f, 1.14087537e-02f, -1.21195894e-02f, 1.24841191e-01f,
  5.57286032e-02f, -2.77579669e-02f, -5.00790216e-02f, 7.52649158e-02f, -3.54779847e-02f, -2.78590377e-02f, 4.59582880e-02f, -1.06788114e-01f, 1.87442839e-01f, 6.23339340e-02f,
  -7.58611560e-02f, 7.89039806e-02f, 9.60560590e-02f, 6.16194122e-02f, 4.78105135e-02f, -3.76065858e-02f, 2.23128311e-02f, 1.32681327e-02f, 6.70727491e-02f, 4.46881652e-02f,
  3.93846154e-01f, 6.81294277e-02f, 9.28965434e-02f, 9.38031748e-02f, -3.70943807e-02f, 1.17449231e-01f, -1.47517264e-01f, -5.07649109e-02f, 1.67388842e-02f, 1.69884376e-02f,
  -6.10592123e-03f, 8.00697431e-02f, 1.20376505e-01f, -4.63369042e-02f, -1.96303818e-02f, 6.92026615e-02f, 1.38490845e-03f, 4.07273434e-02f, 1.45476818e-01f, 1.53563148e-03f,
  8.83212611e-02f, -7.98170082e-03f, -1.86916273e-02f, 1.99820530e-02f, 1.36112630e-01f, 9.70870629e-02f, -7.78757110e-02f, -6.85356930e-02f, -2.21658982e-02f, -8.28193873e-02f,
  4.95693296e-01f, -2.69575238e-01f, 5.66248484e-02f, 2.58944958e-01f, -6.32584766e-02f, -7.97788613e-03f, 1.38239652e-01f, -1.53319404e-01f, -8.53565186e-02f, -1.97400808e-01f,
  -3.43893133e-02f, 1.56361014e-01f, -9.93820280e-02f, 9.87520814e-02f, 3.17021310e-01f, -2.48323325e-02f, 1.46870106e-01f, 2.35315580e-02f, -2.49081999e-01f, 1.02393098e-01f,
  4.35814448e-02f, -9.91054922e-02f, 2.31704429e-01f, -2.96581328e-01f, 3.13033350e-02f, -5.35542555e-02f, 1.93154544e-01f, -1.29012376e-01f, 1.12547539e-01f, -3.08773387e-02f,
  4.51727845e-02f, -1.08513221e-01f, 3.59461978e-02f, -8.17875564e-02f, 1.36733782e-02f, 2.57646963e-02f, 4.24876884e-02f, 6.83076605e-02f, -3.09396423e-02f, -3.83449085e-02f,
  1.53954819e-01f, -3.54599878e-02f, -2.42385529e-02f, -5.40249385e-02f, -1.98273640e-02f, -2.69232243e-02f, 5.43502197e-02f, -2.68839058e-02f, -7.15199187e-02f, 1.67687293e-02f,
  -1.84355155e-02f, 5.35952374e-02f, 7.29395300e-02f, -2.23542359e-02f, 5.65474816e-02f, -9.23997536e-02f, 3.93627807e-02f, 1.28135875e-01f, -6.31878749e-02f, -2.46300343e-02f,
  -5.75291784e-03f, -5.09922467e-02f, -1.63659360e-02f, -3.63386422e-02f, -4.15961891e-02f, -3.19857188e-02f, 1.38409743e-02f, 1.80918332e-02f, -2.56261486e-03f, 7.27049261e-03f,
  4.63334918e-02f, -3.25369388e-02f, -5.80083206e-03f, 6.44127727e-02f, 8.93089771e-02f, 4.56419140e-02f, 1.13203987e-01f, 7.92884268e-03f, 3.71302254e-02f, 2.08425000e-02f,
  -5.15852831e-02f, 4.34390269e-02f, 1.45029193e-02f, 8.84794369e-02f, 2.19707135e-02f, 7.00511634e-02f, -4.64755334e-02f, 3.32739986e-02f, 3.90474647e-02f, 1.11147836e-01f,
  -1.30934209e-01f, 5.82195446e-02f, -3.07807848e-02f, -8.79682880e-03f, 3.04728560e-02f, 3.53318602e-02f, 9.29338019e-03f, 2.76279934e-02f, -3.28147318e-03f, 1.82557702e-02f,
  -3.54947038e-02f, 4.96050157e-02f, 3.97423543e-02f, -5.85249290e-02f, 4.23351228e-02f, -2.54179202e-02f, 8.06170106e-02f, -1.39545389e-02f, 6.65725470e-02f, -6.12737648e-02f,
  5.72346151e-02f, -1.92776620e-02f, -2.36703623e-02f, 3.57276797e-02f, 3.86240780e-02f, 1.33844063e-01f, 2.97335107e-02f, -2.16335338e-02f, 8.41133371e-02f, 4.21126224e-02f,
  1.44584939e-01f, -4.44192559e-01f, -4.65008497e-01f, -9.42126811e-02f, 3.67105633e-01f, 1.32255524e-01f, -7.17980340e-02f, 9.54546481e-02f, -1.35852367e-01f, -6.95196465e-02f,
  1.37561619e-01f, -2.29074851e-01f, -2.18347251e-01f, -1.14421047e-01f, 1.18000865e-01f, -3.80919993e-01f, 2.65684333e-02f, -5.20120114e-02f, -1.25749782e-01f, 1.89467296e-02f,
  -1.00921290e-02f, 2.34744862e-01f, -2.46266708e-01f, 1.74777716e-01f, 1.04524091e-01f, -5.01502268e-02f, 2.35520482e-01f, -4.16706875e-02f, 1.79789826e-01f, 1.08090475e-01f,
  -3.82513665e-02f, -1.58553466e-01f, -1.09761603e-01f, -3.24916877e-02f, 3.01401652e-02f, 9.26940218e-02f, 1.61977373e-02f, -5.75687550e-02f, -7.73278326e-02f, -3.81613784e-02f,
  -1.50981527e-02f, 1.94497511e-03f, 2.73177796e-03f, -1.27552059e-02f, 2.35704239e-02f, 3.74841429e-02f, -5.57456817e-03f, 7.15550827e-03f, -3.76423039e-02f, -3.22362222e-02f,
  -5.29501028e-02f, -1.03510898e-02f, 3.47749889e-02f, 1.97188091e-02f, 7.97847472e-03f, -2.73012687e-02f, -1.25221564e-02f, -5.97781278e-02f, 4.86885756e-02f, 5.96833043e-02f,
  8.39757025e-02f, 1.27477441e-02f, 2.09568460e-02f, -1.63628738e-02f, 4.19585891e-02f, -6.16963394e-03f, -6.93352893e-04f, 5.11188842e-02f, 3.53174377e-03f, -3.32733355e-02f,
  5.04262485e-02f, 4.43146974e-02f, 3.63588110e-02f, 3.64109315e-02f, -2.33716350e-02f, 3.30137648e-02f, 1.01219369e-02f, 3.15349959e-02f, 3.42592783e-02f, 2.12375429e-02f,
  -7.29297400e-02f, 3.92762460e-02f, -4.68270890e-02f, 5.06476983e-02f, 1.91885550e-02f, 6.50156066e-02f, 7.51344115e-02f, -2.89951894e-03f, -4.29859795e-02f, 5.03138416e-02f,
  6.52072951e-02f, 6.82456866e-02f, -1.01689920e-02f, 2.08562706e-02f, -3.18116881e-02f, 4.22615558e-02f, -5.05796336e-02f, -4.54315823e-03f, -3.08549348e-02f, 2.60425415e-02f,
  9.26448777e-02f, -2.74476968e-03f, 5.17720878e-02f, 8.23604241e-02f, 3.11668068e-02f, 5.51333614e-02f, -3.08093280e-02f, -3.12062427e-02f, 9.05689597e-02f, 2.43931338e-02f,
  9.56120566e-02f, 8.37136433e-03f, 5.17706163e-02f, 5.26587553e-02f, 1.05678238e-01f, 2.03438755e-02f, 2.21606791e-02f, 2.48110481e-02f, 8.38199332e-02f, -7.37089589e-02f,
  1.56795412e-01f, 3.73036787e-02f, -1.56862587e-01f, 3.74802649e-01f, -1.00435950e-01f, 1.96484119e-01f, 1.11005507e-01f, 2.10011867e-03f, 5.05582355e-02f, 2.50187993e-01f,
  6.15013838e-02f, -1.83544815e-01f, 2.41359752e-02f, 1.86640084e-01f, -1.70120314e-01f, 5.10793664e-02f, 2.81528026e-01f, 2.02106506e-01f, -7.77815953e-02f, 1.48200557e-01f,
  7.85551965e-02f, 1.91250414e-01f, -1.28383115e-01f, 7.09013641e-02f, 6.88787177e-02f, 8.86632688e-03f, 1.20726593e-01f, -1.37911886e-01f, -9.16531309e-03f, -1.23742312e-01f,
  -5.42538799e-02f, 1.42379120e-01f, 1.22198937e-02f, -2.57830042e-02f, 1.18751578e-01f, 5.93610760e-03f, 2.52493378e-02f, -1.31130293e-01f, -3.09747830e-02f, -2.98426971e-02f,
  -2.79855505e-02f, -1.82013270e-02f, 1.02346325e-02f, -6.92181960e-02f, -3.96752805e-02f, -5.17207272e-02f, -3.16670723e-02f, -3.27262767e-02f, -7.22029731e-02f, -7.35980719e-02f,
  -4.50827926e-02f, -3.64135951e-02f, 5.61846793e-02f, 9.52024311e-02f, -6.17567450e-02f, -3.11605399e-03f, 1.05431182e-02f, -5.62868193e-02f, 2.65993290e-02f, 4.05167677e-02f,
  1.76484287e-01f, 2.18249001e-02f, 1.27908532e-02f, -5.94996959e-02f, 3.78263853e-02f, 3.85320038e-02f, -8.50294065e-03f, -8.84954818e-03f, -4.00341116e-02f, 6.93650842e-02f,
  5.67429960e-02f, -1.11843599e-02f, -4.14816365e-02f, 3.22300242e-03f, 4.14023921e-02f, 7.09259734e-02f, -2.08100863e-02f, -1.58238516e-03f, 6.51627872e-03f, 3.53115350e-02f,
  1.58363096e-02f, 3.32587212e-02f, -2.58740615e-02f, 2.22856700e-02f, 4.90111560e-02f, -5.05740754e-02f, 3.00586279e-02f, -1.04862414e-02f, 4.95053232e-02f, 4.14296193e-03f,
  1.25551388e-01f, 4.03785318e-01f, 4.38584387e-02f, -2.26071253e-02f, -2.89592450e-03f, 3.13188806e-02f, 3.89062450e-03f, -4.07172143e-02f, 7.41800293e-02f, 7.87624121e-02f,
  7.76171759e-02f, 3.70443380e-03f, 1.38703901e-02f, 3.03979609e-02f, -8.28314666e-03f, 5.81649058e-02f, 1.14950560e-01f, 7.03292247e-03f, 1.22679129e-01f, 6.01263717e-02f,
  1.11579478e-01f, 7.64725059e-02f, 4.37374935e-02f, 1.35880392e-02f, 3.21631841e-02f, 5.92559911e-02f, 2.74581257e-02f, 1.05846770e-01f, -1.42236603e-02f, 4.41078171e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  6.85926318e-01f, 1.21414587e-01f, 4.01068836e-01f, 4.79302555e-01f, 2.14541420e-01f, -4.76169251e-02f, 2.27280125e-01f, 1.09258443e-01f, 8.13318133e-01f, -8.48979652e-02f,
  -2.47666985e-01f, 9.65927467e-02f, -3.10773909e-01f, 2.14963168e-01f, -4.08134878e-01f, -2.11599037e-01f, 2.88176369e-02f, -4.99860384e-02f, 1.58517152e-01f, 1.07544728e-01f,
  1.03172719e-01f, -2.92848200e-01f, -7.16507211e-02f, -2.52222955e-01f, 3.31064075e-01f, 1.57943442e-01f, -4.39159870e-01f, -1.63332060e-01f, -7.69293085e-02f, -1.36565641e-01f,
  5.71828224e-02f, 1.85051426e-01f, 1.36563450e-01f, 6.50750706e-04f, 1.92192718e-01f, 1.32796541e-02f, -1.13313280e-01f, -1.24241054e-01f, 7.05753872e-03f, 9.30828974e-02f,
  8.63213837e-02f, -3.97823527e-02f, -3.21416706e-02f, 4.24451679e-02f, 1.41383380e-01f, 1.14184842e-01f, 1.45860121e-01f, 2.51267880e-01f, 7.33868182e-02f, 1.12778820e-01f,
  2.51018018e-01f, 2.07064822e-01f, 1.57152891e-01f, -1.20964618e-02f, -8.92321020e-02f, 1.04280390e-01f, 1.06862471e-01f, -1.42480522e-01f, 9.17157307e-02f, 1.15482718e-01f,
  -1.50381774e-01f, -7.35365823e-02f, 1.80073287e-02f, 1.16991453e-01f, -1.72592308e-02f, 7.77495606e-03f, 1.15209520e-01f, -4.19374891e-02f, 1.58944890e-01f, 2.29026396e-02f,
  3.50280963e-02f, 3.52272205e-02f, 6.67391196e-02f, 1.49472058e-01f, 7.61679634e-02f, 9.09505188e-02f, -9.35629383e-02f, -1.35554792e-02f, 1.71309590e-01f, 7.96141848e-02f,
  -7.28175715e-02f, -7.47368038e-02f, -4.60137166e-02f, 1.47083312e-01f, 4.12307568e-02f, 4.89268042e-02f, 5.88125847e-02f, 1.26643524e-01f, -2.49354430e-02f, -7.77772814e-02f,
  -1.21972114e-01f, -2.82815278e-01f, -7.04877526e-02f, -4.85607572e-02f, -3.02973669e-02f, -8.13702419e-02f, -3.94803733e-02f, 1.09034497e-03f, -8.40928555e-02f, -1.16947936e-02f,
  -3.52191553e-02f, 1.06694832e-01f, -3.10759991e-02f, -3.52907367e-02f, -1.48188904e-01f, -2.61009578e-02f, -7.96893090e-02f, -1.72791600e-01f, -1.48438394e-01f, -1.62927702e-01f,
  -1.10473402e-01f, -1.12851456e-01f, -2.29151584e-02f, 6.05152640e-03f, 5.44338375e-02f, -9.05982479e-02f, -5.18529713e-02f, 1.88132860e-02f, -9.72857326e-02f, -9.35512707e-02f,
  -3.16959590e-01f, 5.24127305e-01f, -4.35814381e-01f, 4.03245717e-01f, -2.78568327e-01f, 4.61692303e-01f, 5.17807841e-01f, 3.40286121e-02f, 3.20050895e-01f, 4.99418855e-01f,
  2.81888902e-01f, 1.62836313e-01f, 1.90152094e-01f, 6.75177395e-01f, 1.89280018e-01f, 5.31465471e-01f, 4.95502532e-01f, 3.48606348e-01f, -2.68111806e-02f, 1.51087523e-01f,
  1.02971280e-02f, 5.19588470e-01f, -8.04350078e-02f, -1.01895206e-01f, 9.62491205e-04f, -3.36566567e-01f, -4.95807603e-02f, -3.69003624e-01f, 8.81364048e-02f, 5.86351864e-02f,
  1.66026086e-01f, -5.87071255e-02f, -7.31643364e-02f, -7.77693540e-02f, -1.35341257e-01f, -6.81106001e-02f, -1.03937559e-01f, -9.23010409e-02f, -1.58155978e-01f, 4.14570887e-03f,
  5.13861421e-03f, -1.23935804e-01f, 1.29643798e-01f, -4.69998568e-02f, -2.81678257e-03f, -1.16999984e-01f, -1.18107609e-01f, 4.96406183e-02f, 4.49773204e-03f, -1.67616233e-02f,
  -1.08835712e-01f, -1.49440682e-02f, 2.73314025e-02f, 1.39320314e-01f, -7.43201673e-02f, 5.34259453e-02f, 1.39742315e-01f, -7.79065117e-02f, 4.66533192e-02f, 7.15471357e-02f,
  -4.62986790e-02f, -2.22134050e-02f, -1.07384557e-02f, -1.61465199e-03f, 7.66617730e-02f, -3.03869415e-02f, 1.40790686e-01f, -6.17897585e-02f, -4.64974791e-02f, 6.03814423e-02f,
  1.39609789e-02f, -1.30211050e-02f, 4.74441163e-02f, 4.75246236e-02f, 1.03965022e-01f, 1.47929871e-02f, -8.05602148e-02f, -1.41934296e-02f, 5.62987244e-03f, -3.69850323e-02f,
  1.03178203e-01f, -5.79761155e-02f, -2.17998214e-02f, 1.45657826e-02f, 1.06094517e-01f, -1.21394105e-01f, 5.81443906e-02f, 3.42268087e-02f, -1.12397842e-01f, -4.73857708e-02f,
  3.28810990e-01f, 3.61768603e-01f, 4.65810858e-02f, 6.60195015e-03f, 6.60053417e-02f, -4.07627560e-02f, 8.00981298e-02f, 5.25486432e-02f, 1.30275607e-01f, -2.83746477e-02f,
  -8.54759216e-02f, 9.01460554e-03f, 8.14692825e-02f, -8.13869666e-03f, 3.20208748e-03f, 1.33820996e-01f, 8.45973045e-02f, -1.55172208e-02f, 3.67618017e-02f, -1.14615746e-01f,
  -8.74620304e-02f, 3.00042834e-02f, -9.69091523e-03f, -8.30331370e-02f, -8.82492680e-03f, 1.57328751e-02f, -2.41017286e-02f, -9.47576538e-02f, 1.94732808e-02f, 1.05391391e-01f,
  -5.58600366e-01f, 2.35902712e-01f, -3.51256639e-01f, -3.96322161e-01f, 3.05470854e-01f, -4.03684050e-01f, -1.49869651e-01f, 1.05187207e-01f, -1.31302878e-01f, 3.90760601e-01f,
  1.77019700e-01f, -2.04158068e-01f, 1.72970444e-01f, -3.42840433e-01f, -6.61185682e-01f, -4.75209951e-01f, -5.34813046e-01f, -1.65902928e-01f, -4.14740928e-02f, 2.27288324e-02f,
  -1.97391331e-01f, -7.08642006e-02f, -5.36238968e-01f, 4.07395095e-01f, 4.13031131e-02f, 8.85906965e-02f, 6.94011673e-02f, 3.67446065e-01f, -2.26398870e-01f, -1.99891143e-02f,
  -6.81237206e-02f, 3.48273925e-02f, 8.15006420e-02f, -9.19601023e-02f, -1.62575185e-01f, 1.20204806e-01f, -9.65600610e-02f, -1.37875099e-02f, -8.51132274e-02f, -1.27828911e-01f,
  4.81169745e-02f, 2.58082654e-02f, -1.05173625e-01f, 7.13142976e-02f, 3.20205167e-02f, 1.47107104e-02f, -1.04803942e-01f, -6.18435331e-02f, 5.53356931e-02f, -1.77485004e-01f,
  -1.01102658e-01f, -1.97345123e-01f, -1.12742884e-02f, -1.28014222e-01f, -1.19463839e-01f, 4.33838144e-02f, -5.68012409e-02f, 5.52809350e-02f, -1.27248988e-01f, -7.13148192e-02f,
  2.58907452e-02f, -5.85929491e-02f, -4.50653099e-02f, -3.26650627e-02f, 4.75323051e-02f, 1.06154032e-01f, -3.82221192e-02f, -8.60393420e-02f, 3.82096209e-02f, 6.46230355e-02f,
  -1.79261547e-02f, -5.16836196e-02f, -9.23763141e-02f, -8.63301978e-02f, -7.67573267e-02f, -4.57437849e-03f, -2.65070871e-02f, -1.84728194e-03f, -4.96919304e-02f, -2.30418518e-02f,
  1.28188338e-02f, -1.13772959e-01f, 5.65525256e-02f, 9.51469094e-02f, 4.37388476e-03f, 5.11905700e-02f, 1.67657100e-02f, -3.22348555e-03f, -2.85878461e-02f, 1.68945473e-02f,
  8.92634541e-02f, 2.90287018e-01f, 3.98617871e-02f, 3.00871674e-03f, 1.08985521e-01f, -6.29966557e-02f, -9.80023518e-02f, -6.81249797e-02f, 4.89534903e-03f, 8.93364176e-02f,
  5.69852516e-02f, -1.11393727e-01f, -4.71162237e-02f, -3.24926712e-02f, -4.92389910e-02f, 7.01113343e-02f, 8.57736915e-03f, 3.86050902e-02f, 3.63543406e-02f, 8.85528401e-02f,
  9.81967002e-02f, 7.22721592e-02f, 6.74099177e-02f, 4.40145545e-02f, -8.31194967e-03f, 9.30727199e-02f, -4.91873436e-02f, -5.84974093e-03f, 4.04158831e-02f, 4.12237607e-02f,
  -7.34308958e-01f, -3.91096920e-02f, 5.50004303e-01f, 2.38004088e-01f, -3.03350329e-01f, -2.39535809e-01f, 5.21565557e-01f, -2.28309497e-01f, -4.63606983e-01f, 5.62013313e-02f,
  1.96923018e-01f, -3.60973924e-02f, 3.97543490e-01f, 2.13872254e-01f, 3.36514682e-01f, 2.61033744e-01f, 1.61112070e-01f, 1.17173180e-01f, 5.97762922e-03f, 8.86289775e-02f,
  1.41184255e-01f, 1.01239502e-01f, 6.36932611e-01f, -1.38708755e-01f, 1.40416622e-01f, -5.21134061e-04f, 3.19495112e-01f, 1.88768104e-01f, 6.97695613e-02f, -3.64922956e-02f,
  -4.40919787e-01f, -3.68746638e-04f, 6.45980984e-02f, -1.03290919e-02f, -2.23076753e-02f, -3.52264829e-02f, 1.19628139e-01f, 4.57334742e-02f, 5.11419177e-02f, 5.53885940e-03f,
  -1.11972749e-01f, -7.71195367e-02f, -7.71547183e-02f, 3.59506756e-02f, -1.40715733e-01f, -1.04933120e-01f, -7.90289566e-02f, 2.07163636e-02f, 8.80688720e-04f, 2.70487042e-03f,
  3.16060819e-02f, 6.92960545e-02f, 1.96879163e-01f, -2.84747072e-02f, 5.38470075e-02f, -1.25357568e-01f, 1.94527488e-02f, 7.42731318e-02f, -5.35939708e-02f, -8.16978291e-02f,
  -6.46746606e-02f, -1.15905777e-02f, 1.42063433e-02f, -6.71828017e-02f, 2.71021877e-03f, -2.72818040e-02f, 1.81651041e-02f, 3.97126488e-02f, 4.54863161e-02f, -4.32534665e-02f,
  -1.45847827e-01f, 3.92014068e-03f, -5.83496615e-02f, -9.53213591e-03f, -8.76863860e-03f, -4.80326125e-03f, 6.58182427e-02f, -7.25748688e-02f, -2.65982877e-02f, 5.52093722e-02f,
  -5.85754178e-02f, -7.68881142e-02f, -1.16047673e-02f, 2.85720807e-02f, -5.16678132e-02f, 1.44281492e-01f, -3.92805524e-02f, 1.44690657e-02f, 1.30153269e-01f, 1.55031443e-01f,
  -2.55120695e-01f, 1.21070281e-01f, 1.64033398e-02f, -1.46465212e-01f, -3.94016802e-02f, -1.58718750e-02f, -3.03444732e-02f, -1.11161776e-01f, 6.54342631e-03f, 4.81278673e-02f,
  -1.15744695e-01f, 4.94133979e-02f, -7.31505528e-02f, 1.48865823e-02f, 1.45830512e-02f, 7.32034026e-03f, 1.85741670e-02f, 3.26998197e-02f, 2.27532014e-02f, 3.54766175e-02f,
  9.45889056e-02f, -3.40607427e-02f, 5.81582561e-02f, -8.88549909e-03f, -4.71447296e-02f, 1.14796221e-01f, -1.17248885e-01f, -4.54568006e-02f, 1.59018021e-02f, 7.13121742e-02f,
  7.75361538e-01f, -2.52447337e-01f, -7.18186721e-02f, 2.31530331e-02f, 3.47259790e-01f, 5.10322332e-01f, 5.93458056e-01f, 2.05577567e-01f, 4.37611520e-01f, -1.13822535e-01f,
  -2.93295812e-02f, 1.18350185e-01f, 7.10807145e-02f, 3.65117490e-02f, 6.30551517e-01f, 2.15230033e-01f, 2.47195378e-01f, 5.84636405e-02f, 9.81713310e-02f, 2.32274801e-01f,
  1.94312975e-01f, 1.67398602e-01f, -8.95267799e-02f, -1.50722712e-01f, 7.39160702e-02f, -2.52795368e-01f, -1.97485134e-01f, 8.14158376e-03f, -3.00808549e-01f, 2.99797691e-02f,
  5.50719723e-02f, 4.43842225e-02f, -2.96364725e-02f, -1.02004372e-01f, -1.15035608e-01f, -1.35266602e-01f, -5.02634309e-02f, -3.20241717e-03f, 9.94773731e-02f, -2.95453761e-02f,
  -4.02463302e-02f, -8.29869732e-02f, -5.60315605e-03f, 4.27719615e-02f, 9.67236906e-02f, -2.08111219e-02f, -3.96460518e-02f, 5.25069702e-03f, -9.60683450e-02f, -1.14488816e-02f,
  -5.81007190e-02f, -1.27275050e-01f, -4.60938849e-02f, -5.36659993e-02f, 3.01252231e-02f, 5.68450382e-03f, 5.29453978e-02f, -3.66728939e-02f, -3.44777219e-02f, 9.28968266e-02f,
  -5.38183702e-03f, 8.73069391e-02f, 1.73066538e-02f, -9.35355648e-02f, 5.59048168e-03f, -6.94313422e-02f, -2.84213666e-02f, 4.88602854e-02f, 4.56336848e-02f, 3.78620028e-02f,
  -2.53801001e-03f, 4.70593832e-02f, -1.14975907e-02f, 7.96086714e-02f, -3.12703364e-02f, 2.01130807e-02f, -1.87087280e-03f, -7.64020160e-02f, 5.85380010e-02f, 6.72737807e-02f,
  2.17041243e-02f, 1.52877584e-01f, -3.28339264e-02f, -8.50523636e-02f, 4.43253480e-02f, 3.50192711e-02f, -6.77259117e-02f, 9.46469232e-03f, 4.95399870e-02f, 2.45630797e-02f,
  -2.71937829e-02f, 1.27908230e-01f, 3.75920571e-02f, -6.04219874e-03f, -4.67828736e-02f, 6.12787157e-02f, 6.32841047e-03f, 1.14295498e-01f, 6.37338758e-02f, 1.60988435e-01f,
  -3.44886184e-02f, 5.91853634e-02f, 8.88857711e-03f, 1.45697175e-02f, 4.24222238e-02f, 6.75375983e-02f, -7.52801001e-02f, 5.61294556e-02f, 7.60266259e-02f, -6.40865341e-02f,
  -3.82411890e-02f, 2.34151021e-01f, -1.10048866e-02f, 1.83967743e-02f, 4.12110128e-02f, -5.50343879e-02f, 1.44605666e-01f, -3.31220292e-02f, 1.28210220e-03f, 1.62024132e-03f,
  2.13951707e-01f, 5.58211088e-01f, 1.66225508e-01f, 4.09943797e-02f, -2.55725890e-01f, -6.27952874e-01f, -5.22136390e-01f, -1.16725322e-02f, 2.21103549e-01f, 2.38440812e-01f,
  -2.54096448e-01f, 5.30724943e-01f, 1.08519800e-01f, -2.73757309e-01f, -4.54617172e-01f, -1.07735023e-01f, -4.50925499e-01f, -7.29097193e-03f, -3.87470685e-02f, -1.31163150e-01f,
  -6.68920130e-02f, -4.18219447e-01f, -1.22460753e-01f, -3.00187349e-01f, -1.57336608e-01f, 1.93774834e-01f, -1.21617302e-01f, -2.49030069e-01f, -3.73912379e-02f, -1.66120216e-01f,
  -1.28971055e-01f, 1.89530626e-01f, 1.31647766e-01f, -4.82019149e-02f, -1.66918352e-01f, -5.45888878e-02f, -4.39858586e-02f, -4.86257449e-02f, -2.33122818e-02f, 4.73344997e-02f,
  7.42731094e-02f, 5.40125333e-02f, 1.00814076e-02f, -2.94969697e-02f, -3.02270940e-03f, 6.41880333e-02f, 8.05800185e-02f, 1.14243567e-01f, 1.27776355e-01f, 2.76005846e-02f,
  8.01036954e-02f, 1.57846376e-01f, 5.91346212e-02f, 2.77783982e-02f, 7.36225164e-03f, -5.94116896e-02f, 1.04374392e-02f, -4.66868877e-02f, 5.18973209e-02f, 6.92493170e-02f,
  -5.28934337e-02f, 7.64530152e-02f, -1.14023648e-01f, -2.28711218e-02f, 8.67472589e-03f, -1.17889404e-01f, 8.96706730e-02f, -1.02636078e-02f, 4.77142930e-02f, -6.43218979e-02f,
  2.94137690e-02f, 1.14857152e-01f, -6.30810857e-02f, -3.03772371e-02f, -2.66393069e-02f, 1.12163760e-01f, -2.81887427e-02f, -1.80008076e-02f, -9.76857021e-02f, -2.05012672e-02f,
  6.41984716e-02f, -7.90319070e-02f, 8.21879134e-02f, -1.49112210e-01f, -1.35054648e-01f, 1.36384368e-01f, 4.71277349e-02f, 1.65377080e-01f, 3.07504628e-02f, -8.09402987e-02f,
  -1.24564685e-01f, 1.66102320e-01f, 3.09786648e-02f, 1.08880483e-01f, 2.07151212e-02f, 7.36032380e-03f, -1.19657807e-01f, 3.88221815e-02f, -3.67829688e-02f, -5.03751636e-02f,
  -1.59044966e-01f, -4.94239405e-02f, 1.06232222e-02f, -7.11190403e-02f, 2.97292639e-02f, -6.33489862e-02f, -5.83992247e-03f, 1.42208666e-01f, -7.40761459e-02f, 9.28400084e-03f,
  1.45174608e-01f, -1.51000824e-02f, 4.26524691e-02f, -9.03603882e-02f, -1.90249290e-02f, 4.99341898e-02f, 2.71211937e-03f, 1.23619929e-01f, -1.07975025e-02f, -7.78153837e-02f,
  5.21165609e-01f, -3.22090715e-01f, -2.55497873e-01f, -3.82700443e-01f, -8.21280032e-02f, -4.26956862e-01f, -2.72907585e-01f, -4.06069934e-01f, -1.44480303e-01f, -3.86545211e-01f,
  -2.18255922e-01f, 7.71152452e-02f, 2.31154203e-01f, -4.06784832e-01f, 5.02694786e-01f, 3.69641185e-01f, -3.61477882e-01f, -2.23353803e-01f, 1.40900195e-01f, -1.69766963e-01f,
  8.67453590e-02f, -3.34600866e-01f, -3.29714306e-02f, -2.48209596e-01f, -2.45818034e-01f, -1.12286858e-01f, 9.76039618e-02f, -5.20941690e-02f, -3.72103482e-01f, 2.50650402e-02f,
  7.02206790e-02f, 4.69385386e-02f, 3.26813236e-02f, 2.72127260e-02f, 1.84058473e-02f, 4.33045551e-02f, -1.11977812e-02f, 1.61184922e-01f, -2.49775648e-02f, 2.59529124e-03f,
  4.36181538e-02f, 3.73380706e-02f, -2.08969023e-02f, 1.54424295e-01f, -5.42856306e-02f, -1.10511251e-01f, -8.83390009e-02f, 1.98016781e-02f, -2.03250065e-01f, 9.58025977e-02f,
  -5.64454682e-02f, -6.04578927e-02f, -1.95823327e-01f, -3.43439318e-02f, -1.32606968e-01f, -8.59832689e-02f, 7.76428655e-02f, 7.64279291e-02f, 2.91785155e-03f, -2.27411836e-02f,
  1.06629297e-01f, 9.43063051e-02f, 3.01954877e-02f, -4.44089659e-02f, 7.15894327e-02f, -4.88124117e-02f, -8.48191008e-02f, 4.75639328e-02f, 3.86290662e-02f, 5.60663417e-02f,
  -1.51588589e-01f, -4.37576473e-02f, 8.70516989e-03f, -2.09580753e-02f, -3.41222598e-03f, 1.96401075e-01f, 7.95497745e-02f, 1.92280151e-02f, -1.16176181e-01f, -3.89522873e-02f,
  -1.48436539e-02f, -6.32290309e-03f, -5.87140210e-02f, 5.25838807e-02f, 2.95476392e-02f, -3.81130576e-02f, -1.51101306e-01f, 9.30109248e-02f, 3.54403257e-02f, -2.99812928e-02f,
  -1.51146874e-01f, -9.80115831e-02f, -7.09346905e-02f, -1.89943209e-01f, 1.01274781e-01f, 4.28352766e-02f, 1.29541293e-01f, -1.09736517e-01f, -6.36222884e-02f, -3.33248116e-02f,
  -1.54630095e-01f, 9.33558270e-02f, -7.35115856e-02f, 3.03323846e-02f, -1.71903431e-01f, -1.44895643e-01f, 1.01560950e-01f, -7.54903257e-02f, -1.25986069e-01f, -9.26028192e-02f,
  -7.35693201e-02f, -2.03339588e-02f, 1.60040736e-01f, -1.53796479e-01f, -1.18148528e-01f, -4.28722501e-02f, 2.63062846e-02f, -3.58933993e-02f, -3.62864435e-02f, -9.00560394e-02f,
  7.39169419e-01f, -6.66942835e-01f, -1.33049609e-02f, 4.56522256e-01f, 5.00348985e-01f, 1.93850860e-01f, 5.88530183e-01f, -2.16327906e-01f, -1.99372768e-02f, -4.85021621e-01f,
  2.37886399e-01f, -1.39200166e-01f, -2.92784184e-01f, -2.28573736e-02f, 6.61696911e-01f, -2.15441838e-01f, 1.79499179e-01f, 6.44006580e-02f, -1.52256861e-01f, -2.14576069e-02f,
  2.26984233e-01f, 3.26537937e-01f, 7.10663870e-02f, -1.96488872e-01f, 1.29792482e-01f, -2.11517021e-01f, 8.14722404e-02f, -1.23557732e-01f, 9.18346494e-02f, 1.61928818e-01f,
  1.78324044e-01f, -3.93071100e-02f, 2.45354380e-02f, -1.51037257e-02f, -6.42588735e-02f, 4.26735356e-02f, -2.14307243e-03f, 8.42347816e-02f, 1.21856645e-01f, -1.02557376e-01f,
  -9.01835486e-02f, -2.26223618e-02f, 1.10887535e-01f, -1.72196366e-02f, 2.40699742e-02f, -3.76358768e-03f, 1.80820506e-02f, -2.88327485e-02f, -1.11199468e-01f, -8.13183337e-02f,
  -5.69571964e-02f, -6.50062561e-02f, 9.07850564e-02f, -4.03015688e-02f, -6.33147545e-03f, 1.47190792e-02f, -7.33951554e-02f, -6.37075752e-02f, -3.78237851e-02f, -7.24079385e-02f,
  -9.49902236e-02f, -3.70376334e-02f, -6.92551807e-02f, 7.24170506e-02f, 6.69933185e-02f, 7.41192847e-02f, 5.01395203e-02f, -5.80170564e-02f, 5.28980605e-03f, 4.93141785e-02f,
  9.61253345e-02f, 9.89036914e-03f, -4.17841300e-02f, 5.32847866e-02f, 1.85788814e-02f, -4.54086252e-02f, 2.32483018e-02f, -5.72094694e-02f, -1.26904156e-02f, -3.63720134e-02f,
  -5.85590862e-03f, -2.27860641e-02f, -7.48659223e-02f, -9.64652002e-03f, 6.49601873e-03f, 2.82791443e-02f, -8.48417729e-02f, -1.17360055e-01f, -1.70374308e-02f, 4.84936088e-02f,
  -2.21519500e-01f, -7.41090775e-01f, 1.24290576e-02f, 2.48156171e-02f, -6.34634346e-02f, -4.08506878e-02f, -1.14403293e-02f, -8.26093927e-02f, -1.77767053e-01f, -3.46081480e-02f,
  4.75534936e-03f, 1.12161376e-01f, -1.01520672e-01f, 1.17192134e-01f, 2.24532164e-03f, -5.39419167e-02f, -1.27463803e-01f, 9.12954733e-02f, -2.89434846e-03f, -6.53163195e-02f,
  -6.13891557e-02f, -4.84761819e-02f, 7.78253824e-02f, 4.28217128e-02f, -9.48339924e-02f, -1.92128029e-02f, -2.53692493e-02f, 7.33453687e-03f, -1.35934949e-01f, 3.39754075e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  2.18462020e-01f, 3.81588399e-01f, 1.81186974e-01f, 4.55772102e-01f, 4.77823585e-01f, 5.60388207e-01f, 1.18393593e-01f, 1.58735082e-01f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  1.15566649e-01f, 2.43450716e-01f, 6.67817742e-02f, -6.41709119e-02f, -2.58721083e-01f, 2.01475382e-01f, 2.03680232e-01f, -3.32638174e-01f, 9.95160360e-03f, -1.46217093e-01f,
  1.06314093e-01f, -3.39710489e-02f, 2.99709678e-01f, -3.80633235e-01f, 1.67483613e-01f, -1.65514410e-01f, 1.76937461e-01f, -2.22030029e-01f, -8.68907720e-02f, 1.85746551e-02f,
  -1.94419175e-01f, -1.07327871e-01f, -2.23196298e-01f, -2.56560177e-01f, 4.84203935e-01f, -2.70237207e-01f, -4.27177958e-02f, 3.80420268e-01f, -5.14758863e-02f, 7.76781589e-02f,
  -3.72022569e-01f, 1.33902565e-01f, 3.52318972e-01f, 1.93895921e-01f, 3.19061875e-01f, -5.40622743e-03f, -2.14191914e-01f, -1.17893614e-01f, -1.55241296e-01f, -4.95058112e-02f,
  6.21568821e-02f, 1.62242770e-01f, 1.73522055e-01f, 7.28225932e-02f, 3.66576821e-01f, -1.24407157e-01f, 1.97466820e-01f, -6.08879745e-01f, 2.09053397e-01f, 4.30739701e-01f,
  1.43168971e-01f, 5.49157858e-01f, 4.30350304e-02f, -2.37265989e-01f, -2.40407288e-01f, 3.07157546e-01f, 3.77251655e-01f, 4.63972569e-01f, -3.42817813e-01f, -1.53773194e-02f,
  -1.06168658e-01f, 1.11572668e-01f, -2.83465445e-01f, -1.42756045e-01f, 1.77758306e-01f, -4.20146525e-01f, -2.62654036e-01f, -7.83124119e-02f, -1.66455507e-01f, -2.56329834e-01f,
  1.95134223e-01f, 2.39311367e-01f, -1.12900406e-01f, 2.52376437e-01f, -2.25628465e-01f, 1.62536949e-02f, -3.40561718e-01f, 5.59967697e-01f, -2.11977273e-01f, 1.26922682e-01f,
  -2.06631348e-01f, 2.18327850e-01f, -2.68687695e-01f, -2.99645532e-02f, 3.94792050e-01f, 3.63667049e-02f, 5.79278469e-01f, 1.58438653e-01f, -4.36390609e-01f, 2.68272549e-01f,
  -2.01674867e-02f, -7.59262294e-02f, -2.28488773e-01f, -5.68928942e-02f, 2.16508254e-01f, 2.17021052e-02f, 3.37505013e-01f, 3.85601938e-01f, 3.96179631e-02f, -1.81989614e-02f,
  -9.77280065e-02f, 4.04799670e-01f, -5.37808277e-02f, -2.85978049e-01f, -1.40690774e-01f, 3.63599807e-01f, -2.61496663e-01f, 6.78507611e-02f, 2.71589190e-01f, -1.01631127e-01f,
  5.01429200e-01f, -2.02710450e-01f, -1.66136444e-01f, -5.24144769e-01f, 2.16785803e-01f, -4.43155438e-01f, 2.55353391e-01f, -4.77981210e-01f, -2.87879735e-01f, 3.53602082e-01f,
  2.77891159e-01f, 7.50392899e-02f, 2.61477642e-02f, 1.44241052e-02f, -1.70617819e-01f, -2.53268540e-01f, -1.24579616e-01f, -4.10100698e-01f, 5.56010567e-02f, 2.37288013e-01f,
  -9.71409753e-02f, 2.41069477e-02f, -3.72688323e-02f, 1.92363709e-01f, -1.47998065e-01f, -3.73710357e-02f, 7.29369521e-02f, -1.11960180e-01f, 4.66464311e-01f, -8.43606610e-03f,
  1.04035385e-01f, -3.11614722e-01f, 4.79596406e-01f, 2.12942511e-01f, 2.65565693e-01f, -4.91349161e-01f, -8.25506449e-02f, 1.92982163e-02f, -5.98325878e-02f, -2.19514102e-01f,
  -4.55358237e-01f, -1.27625033e-01f, -1.45610094e-01f, 1.34822577e-01f, 3.46068710e-01f, 1.68373555e-01f, -1.63243890e-01f, -7.99949188e-03f, -6.15694076e-02f, -3.45038027e-01f,
  -3.77574176e-01f, -2.09521223e-02f, -3.52422595e-01f, -1.50761545e-01f, -3.81374091e-01f, -1.31217942e-01f, 6.41405508e-02f, 1.60245672e-01f, 2.03117251e-01f, -4.64358836e-01f,
  3.22547853e-01f, -2.28314891e-01f, -9.82454494e-02f, -9.74638239e-02f, 2.74617821e-02f, 2.41755635e-01f, 2.47823834e-01f, -3.24426740e-01f, -4.57695901e-01f, 4.15326953e-01f,
  -4.21783477e-01f, 3.75550508e-01f, -1.38995484e-01f, -3.79194319e-01f, -3.24947447e-01f, 3.26941274e-02f, 7.50742331e-02f, 3.17314029e-01f, -3.27704757e-01f, 2.24267617e-01f,
  8.62173289e-02f, -4.03166078e-02f, 1.54318780e-01f, 1.75143361e-01f, -1.04538843e-01f, 2.37153053e-01f, -1.84199899e-01f, 4.51810271e-01f, 1.20957270e-01f, 6.49696887e-02f,
  -1.90391108e-01f, 2.91699827e-01f, -1.17852017e-01f, -2.88607270e-01f, 1.67837322e-01f, -9.02480111e-02f, 2.03234404e-01f, 1.82050318e-01f, 4.64558721e-01f, -4.99936640e-01f,
  2.24144816e-01f, -1.89460352e-01f, 6.05328918e-01f, -5.12277842e-01f, 1.51003867e-01f, 2.89019849e-02f, -1.56669497e-01f, 3.50784630e-01f, -2.10459847e-02f, 1.01441406e-01f,
  -4.24503610e-02f, -3.67062569e-01f, 1.65446654e-01f, -1.93433955e-01f, -2.60709107e-01f, 4.63774800e-01f, 1.50711834e-01f, 2.67825630e-02f, -2.33668946e-02f, 3.57747644e-01f,
  -2.74726331e-01f, -2.24894240e-01f, 4.81836237e-02f, -2.98210025e-01f, 2.01300263e-01f, -3.33716981e-02f, 2.95978665e-01f, -3.33970159e-01f, 5.50573885e-01f, 1.82141781e-01f,
  3.07783544e-01f, -4.88959402e-01f, 2.91860878e-01f, 2.03549024e-02f, -2.31113538e-01f, -3.03584710e-02f, -4.35226977e-01f, -1.36417866e-01f, 1.03182219e-01f, 1.04839779e-01f,
  -2.27220669e-01f, 2.89194822e-01f, -8.44276622e-02f, -4.66692671e-02f, -7.24930912e-02f, -2.50981510e-01f, 2.10048668e-02f, 8.08714479e-02f, 5.57175325e-03f, -3.41097802e-01f,
  2.33895481e-01f, -2.67236948e-01f, -1.30582824e-01f, -3.02033365e-01f, 1.03777282e-01f, -3.72441262e-01f, 1.39282003e-01f, 1.90552786e-01f, 7.78012583e-03f, -2.95610934e-01f,
  -2.23983377e-02f, 1.07336581e-01f, -4.24397409e-01f, 3.39058250e-01f, -1.47231638e-01f, -3.98514457e-02f, -6.04093552e-01f, 3.56914848e-01f, -1.97536886e-01f, 1.35047152e-03f,
  2.56826490e-01f, -4.39893484e-01f, 1.09509639e-01f, -3.04868460e-01f, 1.28927425e-01f, 5.56548163e-02f, 3.24911296e-01f, 5.35234436e-02f, 1.61680430e-01f, -1.75396159e-01f,
  -3.72430775e-03f, 9.04302374e-02f, -3.26707482e-01f, 3.29495490e-01f, -7.13464711e-03f, -3.11849326e-01f, -7.93787185e-04f, 3.32951903e-01f, 7.78150931e-02f, -1.96851701e-01f,
  8.09216127e-02f, 2.86521703e-01f, 5.74587703e-01f, -1.00084126e-01f, 1.39491782e-01f, -4.47646409e-01f, 1.04622848e-01f, 6.93687648e-02f, 1.97766423e-01f, -4.26652282e-01f,
  -1.82146773e-01f, -2.61236668e-01f, 1.07209958e-01f, 4.19962332e-02f, -3.29183191e-01f, -7.47780651e-02f, -3.97448987e-01f, 8.18789080e-02f, 1.57398835e-01f, -4.22937602e-01f,
  -1.95043515e-02f, 1.96583435e-01f, 1.76637441e-01f, 1.84715256e-01f, 3.22050788e-02f, 2.38443211e-01f, -1.38954446e-01f, -1.94801956e-01f, 2.16671795e-01f, -9.28548872e-02f,
  3.54000956e-01f, 8.37036129e-03f, 2.58505821e-01f, -5.06318867e-01f, 3.42173815e-01f, 3.48563761e-01f, 2.26143733e-01f, -2.09267497e-01f, 2.92388976e-01f, 4.17228378e-02f,
  -3.63078743e-01f, -1.49915665e-01f, -5.06587923e-01f, -4.13386226e-01f, 3.37030023e-01f, -1.59397364e-01f, -1.43768802e-01f, 7.98199028e-02f, 2.18312457e-01f, 2.18888298e-01f,
  -9.17102471e-02f, -1.90475434e-01f, -1.12934336e-01f, -7.76848495e-02f, 1.85658962e-01f, -6.28675222e-02f, 2.84372903e-02f, -2.05768690e-01f, -5.58671867e-03f, -4.68009822e-02f,
  2.61429369e-01f, 4.93634641e-02f, -2.22293943e-01f, 2.11501881e-01f, -2.89540768e-01f, 4.98118430e-01f, -3.04143131e-01f, -5.44521987e-01f, -5.26006997e-01f, 2.09124953e-01f,
  -2.06621155e-01f, -5.16361296e-02f, 1.66878272e-02f, 2.86091149e-01f, 2.52887636e-01f, 7.48675391e-02f, 7.74805397e-02f, -4.88697253e-02f, 4.11587894e-01f, 4.46841083e-02f,
  -2.57210165e-01f, 1.72421545e-01f, -1.50875509e-01f, -4.64036129e-02f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  4.99430686e-01f, 4.17352617e-01f, 5.39590299e-01f, 1.79053381e-01f, 4.07943696e-01f, 1.97860867e-01f, 4.19132411e-02f, 2.89461344e-01f, 2.36669987e-01f, 2.98104614e-01f,
  -8.91951546e-02f, 7.90815949e-01f, 6.56696498e-01f, -2.86273330e-01f, 4.06686991e-01f, -3.07246596e-01f, -7.59245753e-01f, 7.26564109e-01f, 9.46004018e-02f, -1.05532348e+00f,
  -9.54267859e-01f, 6.36075974e-01f, -4.57350731e-01f, 1.31120561e-02f, 9.34943080e-01f, -1.09781779e-01f, -7.32349694e-01f, 9.63287130e-02f, 3.36509198e-01f, 4.64399517e-01f,
  -4.97975558e-01f, 8.11574638e-01f, 9.91787553e-01f, 4.82257962e-01f, 2.13479534e-01f, 1.32983372e-01f, 4.84795183e-01f, 5.57505906e-01f, -1.41396038e-02f, 8.40439275e-02f,
  5.32621797e-03f, 5.52936435e-01f, 4.65628386e-01f, 1.45153612e-01f, 1.60914376e-01f, -6.09988391e-01f, 6.21551931e-01f, 6.76543772e-01f, 5.21864295e-01f, 3.60541999e-01f,
  4.47655886e-01f, -6.96500251e-03f, 4.22174156e-01f, -8.66026580e-01f, -5.20991981e-01f, 8.75946701e-01f, 7.27530122e-01f, 9.49988663e-01f, -2.04047278e-01f, -3.13955665e-01f,
  3.98190588e-01f, -4.99761820e-01f, 2.40936756e-01f, -2.23490149e-01f, 7.33081996e-01f, 1.90337896e-01f, 2.38040179e-01f, 1.48581937e-01f, 8.19260776e-01f, 3.51110876e-01f,
  1.56941652e-01f, 4.76121515e-01f, 2.46373960e-03f, 4.39594895e-01f, -1.86888009e-01f, 1.73246324e-01f, -3.10702592e-01f, -4.97216992e-02f, 3.64524335e-01f, 7.51348317e-01f,
  -3.89740229e-01f, 9.49620605e-01f, 1.78183034e-01f, -8.50828409e-01f, 5.85666120e-01f, 2.90637631e-02f, 5.61456382e-01f, 7.35652149e-01f, 5.99506915e-01f, 5.98404229e-01f,
  -1.51047170e-01f, -5.14811099e-01f, 8.65514517e-01f, -1.78292900e-01f, 3.38048905e-01f, 5.70376217e-01f, 2.23488763e-01f, 5.36188066e-01f, 6.45045578e-01f, 6.77476108e-01f,
  4.67660785e-01f, 2.70794719e-01f, 5.42818546e-01f, 3.20587792e-02f, 5.29977739e-01f, 5.04635453e-01f, 2.41325304e-01f, 2.75574625e-01f, -4.19057637e-01f, 1.54887021e-01f,
  -4.74639922e-01f, -6.81521297e-01f, -5.73189378e-01f, -6.78256869e-01f, 2.22941101e-01f, -4.54022199e-01f, 6.16724849e-01f, -6.71826422e-01f, -3.38179991e-02f, -3.53545099e-01f,
  4.26869690e-01f, -6.98429585e-01f, 8.84442806e-01f, 5.67086600e-02f, -5.73342860e-01f, 7.27461040e-01f, -3.34422253e-02f, -5.62067568e-01f, 2.06347108e-01f, -4.18794416e-02f,
  5.40769398e-01f, 6.78698480e-01f, 8.49350728e-03f, 2.13887349e-01f, 9.11557153e-02f, -1.18782289e-01f, 6.32189631e-01f, 7.31745064e-02f, 5.75619519e-01f, -1.95789322e-01f,
  8.18081558e-01f, -5.26380420e-01f, 4.56656367e-01f, -4.39926416e-01f, 5.90688467e-01f, -1.77477323e-03f, 9.56397533e-01f, 5.19255042e-01f, -5.35454035e-01f, -5.21110713e-01f,
  -7.19647944e-01f, -7.04577565e-01f, 1.07516721e-01f, -2.00319156e-01f, 2.89601296e-01f, -1.40239000e-01f, 4.40721393e-01f, 7.93432653e-01f, 3.33305031e-01f, -6.17014229e-01f,
  -7.43653238e-01f, -3.87804419e-01f, 3.95747423e-01f, 1.82370409e-01f, -5.87506175e-01f, 1.24423034e-01f, 6.39953196e-01f, 6.06541097e-01f, 6.82958305e-01f, 1.38265684e-01f,
  2.10600138e-01f, 5.54442964e-02f, -2.00472381e-02f, 8.18269551e-01f, -4.82151955e-01f, -4.69834656e-01f, 5.71446121e-01f, 2.37996742e-01f, -2.26970837e-01f, 6.44890249e-01f,
  1.97296171e-03f, 7.02633500e-01f, 2.47209035e-02f, -4.69661415e-01f, -8.01066160e-01f, 2.84312069e-01f, -5.48318624e-01f, 1.02876890e+00f, 1.02680080e-01f, 3.90496731e-01f,
  9.63587224e-01f, 6.23446643e-01f, 2.24706516e-01f, 4.92023647e-01f, -1.32193536e-01f, 2.88947970e-01f, -2.93226451e-01f, 4.06037420e-01f, 4.43358898e-01f, 2.38822520e-01f,
  4.96707171e-01f, 8.90569448e-01f, 4.24847066e-01f, 2.51034021e-01f, -3.25950354e-01f, 6.42104685e-01f, 3.72806191e-01f, -6.16401434e-01f, 1.08288072e-01f, -2.35327538e-02f,
  2.83161759e-01f, 2.56786495e-01f, 5.12828231e-01f, -1.82126105e-01f, -6.25605226e-01f, 4.82195139e-01f, 3.67521822e-01f, 9.46098864e-01f, -2.18419194e-01f, 9.59172130e-01f,
  -5.81677079e-01f, 3.12794179e-01f, -4.37647700e-01f, -7.38236547e-01f, -6.64385319e-01f, 5.33379614e-01f, 4.25380260e-01f, 3.99305403e-01f, 4.52593833e-01f, 7.40228295e-01f,
  4.17513698e-01f, 1.33258745e-01f, -2.01550629e-02f, -2.75996953e-01f, 8.01390827e-01f, 1.86861679e-01f, 6.21936381e-01f, -7.41850853e-01f, 1.63158447e-01f, 7.20578362e-04f,
  9.76921499e-01f, -7.06336677e-01f, 6.32376790e-01f, 9.08932149e-01f, -3.26925248e-01f, -4.76513445e-01f, -5.80080688e-01f, -5.56957364e-01f, 7.11703300e-01f, -8.69126081e-01f,
  5.18719733e-01f, 2.56600529e-01f, 4.54705507e-01f, -6.54465735e-01f, -2.52986420e-02f, 6.51104987e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  2.70683050e-01f, 3.07758272e-01f, 3.42552781e-01f, 5.16745627e-01f, 5.09000719e-01f, 6.29014254e-01f, 4.19676304e-01f, 2.64511734e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  2.06813335e-01f, -1.43465549e-01f, 2.53470629e-01f, 7.14193508e-02f, -6.36925280e-01f, 2.12885171e-01f, -5.76756060e-01f, -3.22304517e-01f, -3.28272492e-01f, 1.76510245e-01f,
  3.44038874e-01f, 1.39656886e-01f, 1.36126697e-01f, 3.06355953e-01f, 7.26074338e-01f, 7.34708369e-01f, 4.52509731e-01f, 9.03784394e-01f, -1.81733102e-01f, 5.56759715e-01f,
  2.78394639e-01f, 7.60761857e-01f, -7.01339468e-02f, -5.47577083e-01f, -7.87653625e-01f, 3.87607962e-01f, -2.52428383e-01f, -6.54431045e-01f, -9.21755254e-01f, 9.74356160e-02f,
  7.47507513e-01f, -8.65453899e-01f, -8.95030379e-01f, -1.10967465e-01f, -4.47731286e-01f, 1.74732476e-01f, 4.51876849e-01f, -1.43038437e-01f, -2.22282901e-01f, 1.96444288e-01f,
  -5.97572386e-01f, 1.46935835e-01f, 9.33130831e-02f, 2.66973466e-01f, -3.77630740e-01f, 1.13792695e-01f, 6.10670984e-01f, -6.60112739e-01f, -6.05096281e-01f, -5.09635210e-01f,
  6.78670585e-01f, -8.91141772e-01f, -6.82156235e-02f, -4.54971522e-01f, -7.71560311e-01f, -2.53491610e-01f, -6.85679495e-01f, 2.91075379e-01f, 7.00548232e-01f, -5.15281737e-01f,
  -8.58835340e-01f, 1.88453078e-01f, -4.18622307e-02f, -5.15183270e-01f, 5.11683166e-01f, 4.74320114e-01f, 4.14615035e-01f, 5.58211394e-02f, -6.02699518e-01f, 2.50502974e-01f,
  -2.88336307e-01f, -4.78858501e-01f, 2.38273099e-01f, -3.52225631e-01f, -3.37916464e-01f, -1.05439208e-01f, -2.07926836e-02f, -1.62215643e-02f, 7.06286728e-01f, -3.48489106e-01f,
  -3.31625521e-01f, -7.18147397e-01f, -5.58004677e-01f, -1.93726897e-01f, 1.95008054e-01f, -2.33800948e-01f, -6.24015868e-01f, 4.70917374e-01f, 8.68628681e-01f, -8.31406951e-01f,
  9.49452221e-02f, -6.36939526e-01f, -8.17104280e-01f, 4.28007096e-01f, -7.97278583e-01f, -7.33468175e-01f, 2.54598528e-01f, 2.03163534e-01f, 2.40606386e-02f, 3.76924813e-01f,
  -6.49074316e-01f, -2.80392021e-01f, 5.00617456e-03f, 5.46473324e-01f, 2.17455775e-01f, 7.00221732e-02f, 3.33920866e-01f, -2.02371106e-01f, 2.15694934e-01f, -4.29705143e-01f,
  -5.97928405e-01f, -5.02627611e-01f, 2.20394701e-01f, 8.39937627e-01f, -4.19697791e-01f, -2.50159055e-01f, 7.88634121e-01f, -6.02810025e-01f, 6.11021876e-01f, 5.91213644e-01f,
  -7.06285894e-01f, -8.21042776e-01f, -4.26638395e-01f, 3.96750003e-01f, 4.73163575e-01f, -8.16631615e-01f, -5.26575625e-01f, 3.01535785e-01f, -1.85019001e-01f, -1.28864914e-01f,
  -1.65592790e-01f, 3.68909121e-01f, -5.91557920e-02f, 5.04111588e-01f, -7.12938905e-02f, -7.18303621e-02f, -1.63617119e-01f, 1.93233758e-01f, -4.10916544e-02f, 1.96861416e-01f,
  5.93702137e-01f, 9.37710881e-01f, -2.87239581e-01f, 5.36875606e-01f, 2.25615650e-01f, -2.03807428e-01f, 6.61072671e-01f, 6.95057511e-01f, -5.51857710e-01f, 1.00874293e+00f,
  2.24889457e-01f, -4.11793947e-01f, -6.58471584e-01f, -6.24139095e-04f, -7.22179115e-01f, -2.24950954e-01f, 5.53578019e-01f, -2.83593014e-02f, 2.03114539e-01f, 6.10493898e-01f,
  6.40584052e-01f, -2.84377545e-01f, 3.59402984e-01f, 7.99769983e-02f, 3.89441043e-01f, -3.12892109e-01f, 4.75544296e-02f, -7.14750513e-02f, 5.41067004e-01f, 1.14041641e-01f,
  -1.90846771e-01f, -1.23330563e-01f, -3.83262724e-01f, 1.77767828e-01f, -6.68144405e-01f, 6.41328096e-01f, 7.53274560e-01f, -4.97077465e-01f, 4.87243921e-01f, 6.19596660e-01f,
  -7.37784982e-01f, -2.00751230e-01f, 6.26376331e-01f, -4.61676240e-01f, 2.30347693e-01f, 5.76152205e-01f, 3.23267072e-01f, -9.48975742e-01f, 9.37959403e-02f, -8.45019400e-01f,
  -6.51201094e-03f, -6.24787748e-01f, -1.13004006e-01f, 9.41510797e-02f, -1.12300321e-01f, 1.97538689e-01f, -1.05016701e-01f, -5.24380028e-01f, -1.07337236e-01f, 2.73878485e-01f,
  -3.60241920e-01f, -3.77440184e-01f, 1.45271242e-01f, 1.74313039e-01f, 3.23306322e-01f, 3.92803222e-01f, -4.33477819e-01f, -3.68941307e-01f, -4.58858520e-01f, -2.24215791e-01f,
  -5.10740638e-01f, -4.59645540e-01f, 6.44631565e-01f, -1.20295510e-02f, 4.36234206e-01f, -1.56237930e-01f, 4.16782051e-01f, 3.55185777e-01f, 3.61221433e-01f, -4.76391584e-01f,
  -6.39650226e-01f, -8.77033114e-01f, -1.14113545e+00f, 4.87527072e-01f, -1.40808612e-01f, -3.42133015e-01f, -1.51624987e-02f, -5.16842067e-01f, 1.20358139e-01f, -3.54661196e-01f,
  -1.81875508e-02f, -2.31893018e-01f, -4.17838752e-01f, 8.61552805e-02f, 1.33696645e-01f, 4.28871900e-01f, -4.25592750e-01f, -3.17852169e-01f, 4.91670609e-01f, -2.08194807e-01f,
  7.60386512e-02f, 1.28858611e-01f, -3.11075062e-01f, -3.78271818e-01f, 3.52197379e-01f, 6.65753305e-01f, 3.63967538e-01f, 1.28063504e-02f, -4.42207545e-01f, -6.12079561e-01f,
  -4.08044726e-01f, -1.73206434e-01f, 6.76214397e-01f, 6.96532309e-01f, -6.54195368e-01f, -7.90736854e-01f, 2.25168113e-02f, 8.75123441e-02f, 1.66936144e-01f, 1.81200914e-02f,
  4.90794390e-01f, 1.90299598e-03f, -3.32058817e-02f, 3.48595202e-01f, 1.60094202e-01f, 1.14801891e-01f, -3.61502841e-02f, -5.01111090e-01f, -2.28887826e-01f, 7.53920615e-01f,
  4.44084913e-01f, -5.05882621e-01f, -4.34285581e-01f, 6.46230042e-01f, -6.55567467e-01f, -5.04476190e-01f, -5.01907945e-01f, -5.66310167e-01f, -5.47003210e-01f, 5.08845508e-01f,
  -2.64393777e-01f, -8.74304533e-01f, -7.73588598e-01f, -2.67598450e-01f, -6.03546917e-01f, 7.87417173e-01f, 7.31504858e-01f, -8.29564452e-01f, 5.27379252e-02f, -3.59242260e-02f,
  -1.71977893e-01f, -2.16595680e-01f, 3.91251773e-01f, 1.45153835e-01f, 4.29305047e-01f, -1.66854803e-02f, 9.69815105e-02f, -3.91915917e-01f, -7.59263039e-02f, -6.93824887e-02f,
  3.35615069e-01f, -1.02220547e+00f, -6.11634076e-01f, -4.68132555e-01f, -2.07590297e-01f, 4.36086088e-01f, 2.30993345e-01f, 6.07718587e-01f, -2.31269911e-01f, -4.13858414e-01f,
  4.10075247e-01f, -5.90324581e-01f, 4.81128171e-02f, -5.67278683e-01f, -2.91010767e-01f, -9.88475084e-01f, -2.81757772e-01f, 6.18935704e-01f, -4.49560046e-01f, 6.40047729e-01f,
  2.94707954e-01f, -2.51144260e-01f, 1.20722950e-01f, 3.18558037e-01f, 3.99597794e-01f, 1.20628327e-01f, 2.61262178e-01f, -6.17282271e-01f, 2.33618870e-01f, 5.71340024e-02f,
  -9.18452516e-02f, -2.91260481e-01f, -4.63251263e-01f, -5.90708613e-01f, 8.24172974e-01f, 7.27203608e-01f, 5.52776873e-01f, -7.73902595e-01f, 6.57179832e-01f, -4.45255876e-01f,
  -8.23518217e-01f, -2.65772521e-01f, -7.54203796e-01f, 1.86818630e-01f, -8.71428668e-01f, -2.49101460e-01f, 8.99376050e-02f, 7.73679495e-01f, -6.22575164e-01f, -7.54572630e-01f,
  2.91949958e-01f, -3.95303875e-01f, -3.91942292e-01f, 5.80270179e-02f, -2.11891815e-01f, -1.53761744e-01f, 3.57262135e-01f, -9.77880731e-02f, -1.27402648e-01f, 1.56400010e-01f,
  -1.39616743e-01f, 9.26131532e-02f, -1.89848781e-01f, -2.30371714e-01f, 2.27326035e-01f, 4.98684287e-01f, -2.52840132e-01f, 5.36455452e-01f, -1.23867774e-02f, -6.21695518e-01f,
  -6.56069696e-01f, 3.70325059e-01f, 4.64255601e-01f, 7.53906250e-01f, 1.10016607e-01f, 4.63848740e-01f, 6.66818798e-01f, -3.95554483e-01f, -1.81582570e-01f, 2.95734823e-01f,
  2.15099137e-02f, -8.17427158e-01f, 2.77322650e-01f, -6.63834870e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  9.27978307e-02f, 6.51351511e-02f, 1.28444389e-01f, -3.95866223e-02f, -1.66911066e-01f, 2.41426751e-02f, -1.69174254e-01f, 1.24396771e-01f, 1.12621665e-01f, 2.31411234e-02f,
  1.92979276e-02f, -2.36338779e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    