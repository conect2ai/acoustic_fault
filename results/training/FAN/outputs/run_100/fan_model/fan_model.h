/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  6.49392188e-01f, -2.88336843e-01f, 2.20512394e-02f, 3.07988793e-01f, 4.82896790e-02f, 4.38055634e-01f, 2.86167920e-01f, -6.61853328e-02f, 1.83530316e-01f, -2.44970083e-01f,
  6.49235100e-02f, 8.69219229e-02f, -2.28430778e-01f, 2.13457182e-01f, 2.96134621e-01f, -1.21333137e-01f, 3.24492067e-01f, 1.63341552e-01f, -6.24950156e-02f, 1.25392959e-01f,
  8.25143233e-02f, 7.14230016e-02f, -2.09374316e-02f, -2.30631366e-01f, 1.47408932e-01f, -1.42789260e-01f, -1.73788205e-01f, -1.66850582e-01f, 5.19780144e-02f, 7.11833127e-03f,
  7.53763318e-02f, -9.84326601e-02f, -9.53579023e-02f, -1.26551269e-02f, 5.32040335e-02f, -6.83142850e-03f, 1.62491836e-02f, -5.01403362e-02f, 4.75111045e-02f, 2.54237652e-02f,
  -8.01384915e-03f, 3.71677391e-02f, 3.83179002e-02f, -4.46675383e-02f, 7.09742829e-02f, -4.06175815e-02f, 5.10980673e-02f, 7.64900744e-02f, -3.21642868e-02f, 7.23128468e-02f,
  -1.16742188e-02f, 2.66643483e-02f, 9.83171165e-02f, -1.93683263e-02f, -3.16866231e-03f, 9.90256295e-03f, 6.01722971e-02f, -2.44863275e-02f, 6.25876859e-02f, 3.64537798e-02f,
  -1.87727474e-02f, 2.76909322e-02f, 1.42684309e-02f, -5.19230068e-02f, 7.33103380e-02f, -1.11367833e-02f, 3.32622938e-02f, -4.46205847e-02f, 2.50985734e-02f, 1.88653283e-02f,
  6.77802488e-02f, -2.05386709e-02f, 4.41966625e-03f, 1.38455583e-02f, 2.73111574e-02f, 5.51380143e-02f, 1.02950481e-03f, -1.61086768e-02f, 3.46675776e-02f, 1.49389682e-02f,
  -5.17388582e-02f, 2.76262257e-02f, -3.37923355e-02f, -6.09509647e-03f, -2.03320030e-02f, -3.04511935e-02f, -3.14108940e-04f, 5.16972020e-02f, 1.22173745e-02f, 8.97511318e-02f,
  -6.32307818e-03f, -1.32045597e-01f, -3.30949761e-02f, -1.75806526e-02f, -4.50662225e-02f, -3.42026800e-02f, 2.70962790e-02f, 2.45700069e-02f, -1.24229575e-02f, 4.27816547e-02f,
  3.87433022e-02f, -6.18819101e-03f, -3.00468840e-02f, 1.38386795e-02f, 3.44255045e-02f, 4.18992434e-03f, 1.20607503e-02f, 2.98412866e-03f, 3.72626968e-02f, -1.81202870e-02f,
  4.21316698e-02f, 2.94741932e-02f, 1.04837054e-02f, -1.65960472e-03f, 2.36164425e-02f, -5.29752225e-02f, 4.18259762e-02f, 1.19051160e-02f, 6.71520457e-03f, -3.69527265e-02f,
  -2.96363413e-01f, 2.10182354e-01f, 2.02168360e-01f, -6.54473677e-02f, 2.83441663e-01f, 3.21209967e-01f, -5.39831966e-02f, 2.05927894e-01f, 2.93571115e-01f, -2.69824147e-01f,
  -5.31942695e-02f, -1.11548983e-01f, -3.52336951e-02f, 1.12727731e-02f, -2.22273935e-02f, 2.07105815e-01f, 1.51129474e-03f, -1.08356297e-01f, 1.82859555e-01f, -5.63083664e-02f,
  2.47502804e-01f, -1.13235869e-01f, 3.82007584e-02f, 3.09926253e-02f, 3.22490670e-02f, 1.05536811e-03f, -2.83014745e-01f, 1.35801777e-01f, -1.27721921e-01f, 1.21658601e-01f,
  7.28060352e-03f, 1.31503001e-01f, -2.93058585e-02f, 2.15524025e-02f, -9.25459266e-02f, -3.75009254e-02f, 1.71186082e-04f, -2.41267476e-02f, -4.84524388e-03f, 9.42791328e-02f,
  -1.16967894e-01f, 2.53399480e-02f, -2.42169034e-02f, 3.12524997e-02f, 1.15084879e-01f, 7.68177258e-03f, 1.02869071e-01f, 8.34809467e-02f, 5.82856908e-02f, 4.89682332e-02f,
  9.01308432e-02f, 9.68625322e-02f, 1.09555135e-02f, 7.12182075e-02f, 9.70019996e-02f, 3.16033997e-02f, 8.45629722e-02f, -3.29999514e-02f, 1.11646302e-01f, -1.94099359e-03f,
  1.27352521e-01f, 1.43189564e-01f, -7.33549893e-02f, -5.53843714e-02f, 1.38161369e-02f, 7.50484411e-03f, 2.79121492e-02f, 1.94637161e-02f, 4.04860452e-02f, 4.12762426e-02f,
  -1.03298292e-01f, -2.42730416e-02f, 5.93763143e-02f, 1.38363475e-02f, -4.93976809e-02f, -7.52696693e-02f, -6.22035563e-02f, -8.37880224e-02f, -8.11117329e-03f, -7.23092034e-02f,
  5.10931648e-02f, 4.84316908e-02f, -1.16311517e-02f, -2.12080292e-02f, -7.49396021e-03f, 6.38066381e-02f, 6.42209053e-02f, -2.14082729e-02f, 8.26074108e-02f, -1.17017087e-02f,
  9.09784138e-02f, 1.25824258e-01f, 6.24415651e-02f, 2.91410554e-02f, 1.50528941e-02f, -6.35399297e-02f, 2.02424470e-02f, -1.13376128e-02f, 5.81521094e-02f, -3.14185508e-02f,
  6.08495250e-03f, -9.67086107e-02f, 2.80798357e-02f, 5.14165731e-03f, -6.28630668e-02f, -3.32374759e-02f, -3.92437875e-02f, -1.10360216e-02f, -9.54685137e-02f, -1.21420883e-02f,
  -7.65066245e-04f, 1.57609042e-02f, -5.97696453e-02f, -1.30230173e-01f, -9.15533975e-02f, -1.33178189e-01f, -6.78794384e-02f, 5.20092212e-02f, -2.46131141e-02f, 4.03732061e-02f,
  2.75536895e-01f, 4.53076437e-02f, 2.79918343e-01f, -9.44461823e-02f, -2.24790663e-01f, -4.58558857e-01f, -6.04933389e-02f, -9.55305770e-02f, 4.15152423e-02f, -1.06229141e-01f,
  -1.08405314e-01f, 8.71577486e-02f, 2.78036118e-01f, -2.06226587e-01f, -1.44731402e-01f, 2.32571304e-01f, -4.06457037e-01f, -1.19089350e-01f, 2.21636564e-01f, -1.33269861e-01f,
  3.60799991e-02f, -2.62451679e-01f, 1.49399623e-01f, -1.38106242e-01f, 3.60793471e-02f, 1.44053236e-01f, -1.02806583e-01f, 2.67770022e-01f, -2.31900990e-01f, -1.50545398e-02f,
  6.63791820e-02f, 1.80482924e-01f, 9.41094942e-03f, 9.76572558e-02f, -9.31784883e-02f, -5.63262179e-02f, -5.06417900e-02f, 9.40176919e-02f, 5.25988750e-02f, 2.03726515e-02f,
  4.00329195e-02f, 9.14175808e-02f, -7.27035776e-02f, 3.22207659e-02f, 1.90511737e-02f, 5.95783219e-02f, 1.06985927e-01f, 9.84186074e-04f, 9.74461064e-02f, 1.13024041e-01f,
  6.72464073e-02f, 4.77543697e-02f, -8.48014802e-02f, 5.90461632e-03f, 2.20413953e-02f, 5.04105166e-02f, -8.55568238e-03f, -3.50508094e-02f, -6.92989752e-02f, -8.19820464e-02f,
  1.43458955e-02f, -3.40520404e-02f, 2.74597737e-03f, 9.31412280e-02f, -4.77173030e-02f, 7.40038529e-02f, 3.46721075e-02f, 1.72179919e-02f, 3.29319350e-02f, 1.93389822e-02f,
  -8.69255513e-02f, 3.36907245e-02f, 4.23163921e-02f, -3.22739817e-02f, -1.09621175e-01f, 3.48237418e-02f, -1.66582596e-02f, 5.49890772e-02f, -5.41693829e-02f, -6.90235347e-02f,
  1.35270938e-01f, -7.05954358e-02f, -2.56164651e-02f, 2.94028781e-03f, -8.03944841e-03f, 1.97870880e-02f, -4.83013764e-02f, 4.57861759e-02f, -4.41720486e-02f, -3.29864360e-02f,
  -3.25361788e-01f, -2.56040424e-01f, -3.63447517e-02f, -2.88116839e-02f, 9.93884634e-03f, 2.32162839e-03f, -5.41434102e-02f, -4.52805646e-02f, 4.99992967e-02f, -2.50434261e-02f,
  -1.01569869e-01f, -4.05426137e-02f, -7.68457949e-02f, 6.14875518e-02f, -5.15571982e-02f, -1.12055585e-01f, -3.30524445e-02f, -6.25671223e-02f, -2.13822857e-01f, -5.81650399e-02f,
  -5.98854460e-02f, -2.72514950e-02f, -5.10475375e-02f, -7.45261684e-02f, -1.08948402e-01f, 9.47582163e-03f, -1.37117639e-01f, 5.07124662e-02f, -3.25194299e-02f, 4.06941772e-03f,
  -3.97693783e-01f, 5.18909633e-01f, -2.60934412e-01f, -3.59787256e-01f, 1.79676235e-01f, 3.47668618e-01f, -1.35517880e-01f, 7.38492906e-02f, -2.56358922e-01f, 1.84702441e-01f,
  7.75921419e-02f, 8.29835236e-02f, 1.07072119e-03f, 5.29332459e-02f, -2.98506647e-01f, -1.00616686e-01f, -1.93362162e-01f, 3.66800316e-02f, 7.22966576e-03f, -6.29955679e-02f,
  -2.13140577e-01f, 1.41692176e-01f, -1.86309651e-01f, 2.52240151e-01f, 1.49033666e-01f, -1.05060622e-01f, 4.00048122e-02f, 9.94717926e-02f, 1.18194208e-01f, 1.64354742e-01f,
  4.88565350e-03f, -1.19676366e-01f, -4.63383980e-02f, -4.24080975e-02f, -2.62046251e-02f, 2.12614704e-02f, 1.24481488e-02f, 1.45483240e-02f, 4.32046689e-03f, 6.61056489e-02f,
  1.01474866e-01f, 7.02011883e-02f, 4.65856716e-02f, -4.21575196e-02f, 2.72688456e-02f, 4.23332900e-02f, 8.41101632e-02f, 3.97976600e-02f, 1.00149974e-01f, 3.97663265e-02f,
  -2.30662953e-02f, 6.40386110e-03f, -5.76494783e-02f, 5.82744218e-02f, -3.01012993e-02f, -3.37129668e-03f, -1.68011654e-02f, 1.71733275e-02f, 2.92516276e-02f, 3.65576483e-02f,
  4.00821418e-02f, -3.87731418e-02f, 5.72904758e-02f, -4.10367213e-02f, 8.28851312e-02f, -6.63277581e-02f, -1.25081167e-02f, 4.48687635e-02f, -1.75895076e-02f, 1.30443079e-02f,
  -2.37148181e-02f, -3.93625535e-02f, -1.75330006e-02f, -3.23904566e-02f, -2.05289088e-02f, 8.06956552e-03f, -1.01221660e-02f, 1.61482301e-02f, -7.59344026e-02f, 1.05010150e-02f,
  2.19632909e-02f, -4.56491336e-02f, 3.65792699e-02f, 2.66841371e-02f, 7.38281570e-03f, -1.59721542e-02f, -3.31882834e-02f, 1.14888581e-03f, -2.19325647e-02f, 1.73387304e-02f,
  8.73766243e-02f, -2.99510416e-02f, -5.50836809e-02f, 5.41266939e-03f, -3.58409546e-02f, 8.07544664e-02f, 2.03245897e-02f, 7.16727227e-02f, 9.67718884e-02f, 3.56177390e-02f,
  -6.07801639e-02f, -4.38450985e-02f, -1.12648368e-01f, 2.12885905e-02f, -6.92686415e-04f, 4.83378358e-02f, -1.15862139e-01f, 5.28435670e-02f, -2.60124840e-02f, 1.01747222e-01f,
  3.86900418e-02f, -1.62073430e-02f, 4.49032243e-03f, 5.13021871e-02f, 1.79673992e-02f, 7.45659694e-02f, -3.21369548e-03f, -9.08739306e-03f, 7.74148703e-02f, -2.02511102e-02f,
  -3.62549007e-01f, 3.31737071e-01f, -3.90847862e-01f, -9.04992744e-02f, -3.00418492e-02f, 2.57293940e-01f, 1.03076212e-01f, 1.59733415e-01f, 6.17253296e-02f, 4.24904794e-01f,
  1.98809385e-01f, -8.66444856e-02f, 1.62124977e-01f, 3.00280958e-01f, -2.25305751e-01f, 1.57645822e-01f, 2.39424124e-01f, 1.20294690e-01f, -7.11584911e-02f, 1.81733996e-01f,
  -1.01965345e-01f, 2.84982353e-01f, -3.25958780e-03f, 2.22906396e-01f, 1.03658371e-01f, -5.13264649e-02f, 4.81321700e-02f, -7.40010142e-02f, 2.00569317e-01f, 6.35729879e-02f,
  -3.65600060e-03f, -6.10650741e-02f, -6.23270795e-02f, -8.09500962e-02f, -2.12451033e-02f, -1.86092407e-02f, -2.91890129e-02f, -1.32743225e-01f, -7.88043961e-02f, 1.43805817e-02f,
  -5.87868541e-02f, -1.87761895e-02f, 9.38755833e-03f, -1.56045826e-02f, 4.03742678e-02f, -7.51880333e-02f, -8.72819219e-03f, -1.07957218e-02f, 9.49286520e-02f, -4.71647158e-02f,
  -5.37500344e-02f, -2.60773804e-02f, -2.84351371e-02f, 4.21241373e-02f, -7.08172694e-02f, 3.31348344e-03f, 1.38367219e-02f, 2.07721014e-02f, 3.77874784e-02f, 4.66194376e-02f,
  1.35383476e-02f, 2.36540753e-03f, 1.04373405e-02f, 1.27646429e-02f, -2.02036090e-02f, -1.45421112e-02f, 4.97289374e-02f, -4.05025523e-04f, -8.37650448e-02f, 1.22637292e-02f,
  -1.42174456e-02f, -6.26539588e-02f, 4.27122228e-02f, 1.62436329e-02f, 3.92500125e-02f, -1.87037084e-02f, -1.06177717e-01f, 5.14790751e-02f, 1.02116112e-02f, -2.15515140e-02f,
  -4.87016626e-02f, 4.46064435e-02f, 8.98334906e-02f, -1.76029596e-02f, 3.46465930e-02f, -6.18116483e-02f, 2.39025317e-02f, 4.19606268e-02f, 5.87720983e-02f, -1.05445366e-02f,
  2.47904450e-01f, 3.09652030e-01f, 4.42439616e-02f, 4.85730134e-02f, -2.12721853e-03f, -4.41870987e-02f, -2.13990640e-02f, 3.41694504e-02f, -5.25632501e-03f, 1.01771774e-02f,
  -3.54008824e-02f, 4.12999801e-02f, 4.35627205e-03f, -2.50551123e-02f, 8.16665776e-03f, 4.95448075e-02f, 8.06773901e-02f, -3.56892385e-02f, 7.43043562e-03f, 4.69740070e-02f,
  4.23713177e-02f, 3.00796181e-02f, -3.24857868e-02f, 6.46299273e-02f, 5.76329092e-03f, -7.38946348e-03f, 4.88747470e-03f, -1.07995547e-01f, -3.13961431e-02f, 3.65752727e-02f,
  -4.99084204e-01f, -2.39596859e-01f, -2.16133341e-01f, -2.60882020e-01f, 6.24495978e-03f, -1.74844190e-01f, -1.66787773e-01f, -1.79542094e-01f, -2.08546519e-01f, -5.74115552e-02f,
  -1.52518544e-02f, -9.75864008e-02f, -6.74925447e-02f, -1.12876162e-01f, -1.04821227e-01f, -1.97131187e-03f, -1.95930317e-01f, -1.53713182e-01f, 9.18842629e-02f, -1.81219041e-01f,
  -4.40122820e-02f, -1.58840343e-02f, -1.15277380e-01f, 3.38544659e-02f, -2.23094195e-01f, -5.57193067e-03f, 1.17889091e-01f, 4.35000509e-02f, 2.68248916e-02f, 8.69750082e-02f,
  -6.29577339e-02f, -1.10280730e-01f, -1.46532089e-01f, -3.51019041e-03f, -1.19041711e-01f, 6.26905933e-02f, -4.32530455e-02f, 2.47977413e-02f, 3.35638188e-02f, 1.86755843e-02f,
  1.27914296e-02f, 5.90134365e-03f, 2.69467942e-02f, 1.98996998e-02f, -5.76908514e-02f, -3.99020948e-02f, -1.42387161e-02f, -1.24846045e-02f, -1.55883357e-02f, -2.42218953e-02f,
  -7.18148202e-02f, -5.56116691e-03f, -4.33718935e-02f, 7.06821978e-02f, -2.30668969e-02f, 1.91604793e-02f, 3.49409543e-02f, -2.21638978e-02f, -5.66516481e-02f, -9.90105718e-02f,
  1.54838432e-02f, 2.98980009e-02f, -7.24458173e-02f, 7.14802183e-03f, 2.88934559e-02f, -3.87263298e-02f, -4.48124744e-02f, 3.07794195e-04f, -4.56107445e-02f, -4.85818796e-02f,
  5.95264835e-03f, -7.61707053e-02f, 4.77066487e-02f, -4.40267585e-02f, 3.53925861e-02f, -3.16661200e-03f, 1.38858268e-02f, -8.22010934e-02f, 5.76833077e-02f, 1.47589734e-02f,
  -6.24121092e-02f, 1.74713843e-02f, -6.04763851e-02f, 2.97688171e-02f, 1.31955314e-02f, -3.01885977e-02f, -5.73715381e-02f, -1.13233320e-01f, 4.48155925e-02f, -5.70548046e-03f,
  -2.76826948e-01f, -3.54163289e-01f, 3.30059081e-02f, -1.93023905e-02f, 1.29438322e-02f, -7.64073581e-02f, 1.72893070e-02f, 4.76305895e-02f, -4.98789363e-02f, -6.60578385e-02f,
  -3.69410525e-04f, 1.25734424e-02f, 1.22982375e-02f, -4.31064144e-03f, -1.15289399e-02f, -4.92463522e-02f, 2.65499149e-02f, 5.25523070e-03f, -4.68139611e-02f, 2.44394154e-03f,
  -7.36084431e-02f, -3.86633798e-02f, 1.03179343e-01f, -2.62385588e-02f, 7.24287033e-02f, 2.16784142e-02f, -3.12607363e-02f, 3.12946849e-02f, 5.47172911e-02f, -1.72017165e-03f,
  -4.41276670e-01f, 2.00626552e-01f, -5.50453216e-02f, -8.20650831e-02f, -7.50240758e-02f, 6.28429651e-02f, 1.65370539e-01f, -1.05494946e-01f, -5.38398372e-03f, 2.14552373e-01f,
  7.72528648e-02f, 2.66603529e-01f, 1.31076664e-01f, 2.65745580e-01f, -3.04223537e-01f, 1.83748841e-01f, -7.05388561e-02f, 8.39882270e-02f, -1.68784820e-02f, -7.06201345e-02f,
  -1.46664977e-01f, 7.70886242e-02f, 1.28011417e-03f, -7.80658573e-02f, -4.67468463e-02f, -2.37277329e-01f, -2.13217497e-01f, 5.17431609e-02f, 1.21045962e-01f, 6.53095692e-02f,
  -2.41785664e-02f, -2.09043361e-02f, -1.47659946e-02f, -6.69448227e-02f, -1.40937984e-01f, -4.62574959e-02f, -3.46850082e-02f, 1.00873828e-01f, 2.50789220e-03f, 5.43666407e-02f,
  -9.52863973e-03f, -3.06219496e-02f, 4.84263375e-02f, 2.98976083e-03f, -2.07371321e-02f, 6.53567910e-02f, 6.08183220e-02f, -1.31841088e-02f, 5.08268401e-02f, -5.10374755e-02f,
  6.27680123e-02f, -1.50530110e-03f, -1.16659543e-02f, 6.99252822e-03f, -5.94703145e-02f, 5.58214001e-02f, -5.93979247e-02f, 4.00241837e-02f, -2.41659377e-02f, -1.65771283e-02f,
  -5.02236336e-02f, -7.42580220e-02f, 3.57602648e-02f, 3.88198607e-02f, 9.73864459e-03f, -9.58391950e-02f, 8.95889774e-02f, 2.96883397e-02f, 7.76860630e-03f, -3.86802256e-02f,
  -3.80466431e-02f, 3.34407873e-02f, -1.42894909e-02f, -1.89869832e-02f, -6.87388703e-03f, -1.51269212e-02f, -4.57864068e-03f, -1.03565184e-02f, -7.23739192e-02f, -1.39345508e-02f,
  2.15208065e-03f, -2.26881225e-02f, 1.17164418e-01f, -4.08261716e-02f, 6.51413351e-02f, 4.91520949e-03f, -2.92697530e-02f, -2.39432044e-02f, 2.06349883e-02f, -6.03134818e-02f,
  -1.32530585e-01f, -2.86726475e-01f, 3.66630740e-02f, 8.86795595e-02f, 4.52805944e-02f, 2.51756120e-03f, -9.99184176e-02f, -4.16160636e-02f, 3.09386849e-02f, -5.04252203e-02f,
  -6.37549162e-02f, -2.58579222e-03f, -1.15627930e-01f, 4.98334952e-02f, 1.41737529e-03f, -2.17074919e-02f, 8.53820797e-03f, -3.24195214e-02f, 4.39323747e-04f, -5.95661812e-02f,
  -3.08780670e-02f, 1.13466745e-02f, 5.02095185e-03f, -1.12457529e-01f, -6.64281426e-03f, 4.03882973e-02f, -3.67121287e-02f, -9.01656598e-03f, 1.01800431e-02f, 4.76289690e-02f,
  -2.14030027e-01f, 3.05107921e-01f, 5.86885512e-02f, -3.28632593e-01f, 1.13252766e-01f, -1.20491534e-01f, -3.61699849e-01f, 7.59014711e-02f, -2.49859124e-01f, 3.06864548e-02f,
  -2.64423877e-01f, 8.76396373e-02f, -9.23002660e-02f, -2.95953363e-01f, -3.00689280e-01f, -1.48878381e-01f, -3.40201765e-01f, -1.71292499e-01f, 3.90278697e-02f, 3.94581072e-02f,
  -7.04621971e-02f, -1.37313053e-01f, -2.05234319e-01f, 2.56075829e-01f, -3.83181788e-04f, 2.09447861e-01f, -8.51407275e-03f, 1.50933534e-01f, 4.81235720e-02f, 6.39346475e-03f,
  -1.10598169e-01f, -2.46135741e-02f, -4.48330827e-02f, -1.94263607e-02f, -5.43364659e-02f, 3.76604199e-02f, -3.26425843e-02f, -2.01312220e-03f, -1.88834965e-02f, 1.07605960e-02f,
  -1.22400075e-02f, 3.55504965e-03f, -1.43414214e-02f, 5.74073829e-02f, 9.98157077e-03f, 8.59205797e-03f, 1.51258428e-03f, -3.82548645e-02f, 1.93830449e-02f, -3.99117246e-02f,
  -5.63963428e-02f, 6.12608017e-03f, -1.55572658e-02f, -3.41029809e-05f, 1.26993265e-02f, -4.04746942e-02f, -5.68308830e-02f, 7.12010860e-02f, 4.60071340e-02f, -2.22468693e-02f,
  3.71197388e-02f, 1.29113649e-03f, 3.21351141e-02f, -4.56755012e-02f, 2.13350020e-02f, 7.57245068e-03f, -4.06858400e-02f, -4.07113554e-03f, 1.41137484e-02f, 1.17233833e-02f,
  -4.59633581e-02f, -1.82133471e-03f, -6.78090453e-02f, -5.77518903e-02f, -5.15198410e-02f, -6.46171421e-02f, 4.56271768e-02f, 1.13116391e-01f, -1.91849228e-02f, -2.10475028e-02f,
  -6.10502027e-02f, -5.43680042e-03f, 3.46099213e-02f, -7.75540387e-03f, -6.08296730e-02f, -1.18775591e-02f, 6.42822310e-02f, 1.44281978e-04f, 6.05414435e-02f, -3.19523141e-02f,
  2.13529691e-02f, 1.74296990e-01f, -2.43476033e-02f, 5.65478243e-02f, -6.39593974e-03f, -1.82084944e-02f, -4.16376255e-02f, 7.71827176e-02f, 4.92463894e-02f, -2.11268216e-02f,
  8.04814622e-02f, -2.85823978e-02f, 4.26264964e-02f, 1.87216457e-02f, 2.25841366e-02f, -1.16423946e-02f, 1.64218638e-02f, -3.34673398e-03f, 1.14411088e-02f, 3.74956578e-02f,
  3.28331217e-02f, 1.01924920e-02f, -1.00169042e-02f, 4.45792042e-02f, 3.95490564e-02f, -1.76244844e-02f, 9.40833315e-02f, -5.41872494e-02f, 1.84081718e-02f, -7.68249258e-02f,
  -3.11931908e-01f, 1.05283573e-01f, -3.22651297e-01f, 1.76705971e-01f, -9.72318128e-02f, -2.91541815e-01f, 6.31683040e-03f, 1.21128689e-02f, 3.20896745e-01f, 1.91216126e-01f,
  1.64971784e-01f, -1.08253755e-01f, 2.42446378e-01f, 1.65638670e-01f, -2.15728134e-01f, 3.16377133e-01f, 5.08868992e-02f, 8.42855573e-02f, 1.54794874e-02f, -5.17268628e-02f,
  -3.97527881e-04f, 2.13789359e-01f, 2.71179480e-03f, 5.64909056e-02f, -2.06448525e-01f, -1.27879411e-01f, 1.44270286e-01f, -1.10802844e-01f, -8.10729042e-02f, -1.40567318e-01f,
  -2.02870555e-02f, 1.59053653e-01f, -1.13514718e-02f, -4.94269431e-02f, -1.67301372e-02f, -2.83769947e-02f, -9.02481601e-02f, -9.80946701e-03f, 6.10108189e-02f, 2.53116656e-02f,
  2.59329379e-02f, 3.26987877e-02f, 6.32353500e-02f, 3.16399559e-02f, -2.70066392e-02f, -4.34716567e-02f, -3.46117839e-02f, -8.83721039e-02f, -1.43326446e-02f, -2.34838538e-02f,
  -1.04317218e-02f, -1.50034964e-01f, -2.41280962e-02f, 2.42313072e-02f, -2.28255186e-02f, 5.91845028e-02f, -5.00645563e-02f, -8.31332579e-02f, -3.56822535e-02f, 3.90330702e-02f,
  -1.33161210e-02f, 2.52495892e-02f, -1.47049740e-01f, 1.64593738e-02f, 8.12973380e-02f, -7.21052475e-03f, -4.77611721e-02f, -9.35626496e-03f, -6.23349324e-02f, 3.69627811e-02f,
  1.87294167e-02f, 1.63780265e-02f, 2.20508687e-02f, 2.30216160e-02f, -4.11068164e-02f, -3.31276655e-02f, -4.40986082e-02f, -3.91203761e-02f, 5.94833381e-02f, -9.87611935e-02f,
  9.91306007e-02f, -7.22994749e-03f, 5.36297299e-02f, -1.33676277e-02f, 1.83131546e-02f, 6.64173141e-02f, 1.09902859e-01f, -5.68764769e-02f, 7.35270157e-02f, -9.76259112e-02f,
  1.33950086e-02f, 1.62867263e-01f, 1.06230944e-01f, 1.29797263e-02f, 2.18498632e-02f, -6.36610240e-02f, -8.67542997e-03f, -3.10027786e-02f, 7.86357820e-02f, 6.44943193e-02f,
  -4.22483981e-02f, -6.10414073e-02f, -6.47011399e-02f, -2.72297207e-02f, -6.77399933e-02f, 4.12425920e-02f, 4.95565683e-03f, -7.41994055e-03f, -2.92717833e-02f, -5.13746552e-02f,
  8.74428637e-03f, 3.30311023e-02f, 2.00697575e-02f, 4.20636125e-02f, 3.12382006e-04f, -4.10702825e-02f, -9.28127840e-02f, 3.81023996e-02f, -6.53532296e-02f, 3.13568637e-02f,
  -1.56002581e-01f, 3.55064571e-02f, -2.99153060e-01f, -1.23444036e-01f, -1.07754976e-01f, 3.68279964e-01f, 8.69176760e-02f, -2.04104185e-01f, 1.67995784e-02f, 2.24466190e-01f,
  1.62658077e-02f, -2.18636349e-01f, 2.77727786e-02f, -2.12731604e-02f, -1.62424356e-01f, 2.63046026e-01f, 1.35395214e-01f, 3.03878095e-02f, 5.59413508e-02f, -1.46755427e-01f,
  -1.00649238e-01f, 9.28223431e-02f, -1.53000757e-01f, 6.01827167e-02f, -1.52442619e-01f, -2.88451891e-02f, -8.76405463e-02f, -1.81826219e-01f, -4.00030613e-02f, 9.07436386e-03f,
  9.93534550e-02f, -9.44754109e-02f, -1.65599242e-01f, -6.48241863e-03f, 1.16586583e-02f, 2.89118271e-02f, -9.05873328e-02f, -9.61656123e-02f, -2.62638014e-02f, -4.42236252e-02f,
  -4.56821211e-02f, 8.74862168e-03f, -7.86501095e-02f, -3.64230610e-02f, -4.93683061e-03f, -4.56222892e-02f, -3.69417220e-02f, 4.63286191e-02f, -9.65909660e-02f, -3.31177376e-02f,
  -9.04428512e-02f, 3.79830003e-02f, 1.58613119e-02f, 3.00503243e-02f, -7.25924298e-02f, 4.29933891e-02f, -5.81563227e-02f, -9.99994650e-02f, 5.36828786e-02f, -6.98282151e-03f,
  4.47652787e-02f, -4.33206223e-02f, -4.57670242e-02f, 7.31219118e-03f, -1.98781211e-02f, -7.27264257e-03f, -2.91663292e-03f, -2.13991087e-02f, 2.68942062e-02f, 7.67280301e-03f,
  7.37500414e-02f, -9.28672552e-02f, 2.44632661e-02f, -1.13682530e-03f, 6.24950305e-02f, 1.02849277e-02f, -7.91230984e-03f, -6.57931715e-03f, 2.94181798e-02f, -4.58412850e-03f,
  -6.01123720e-02f, 1.47436485e-02f, 4.92989458e-03f, 2.24485900e-02f, 1.18171342e-01f, -2.67184079e-02f, -2.89145913e-02f, 6.79422766e-02f, -1.92322284e-02f, -3.34013812e-02f,
  2.47901276e-01f, -3.22524235e-02f, -3.25405017e-05f, 4.21170145e-02f, 5.47805466e-02f, -1.09820208e-02f, 2.57911556e-03f, -1.50891300e-03f, 2.69057639e-02f, 2.05880627e-02f,
  8.86399206e-03f, 5.62364049e-03f, 3.24331783e-02f, 2.22633388e-02f, 3.86254825e-02f, 3.35096307e-02f, -1.22705661e-02f, 5.04233222e-03f, -3.44300792e-02f, 5.71980933e-03f,
  -7.13544711e-02f, -2.77701183e-03f, -5.90214506e-02f, 1.28805609e-02f, -3.87583934e-02f, 3.32184089e-03f, -3.20363939e-02f, 2.41889358e-02f, -7.24608004e-02f, -5.71532873e-03f,
  -5.05574703e-01f, -2.83578604e-01f, -1.03419432e-02f, -2.15398651e-02f, -2.02924818e-01f, -1.01853356e-01f, 9.92387459e-02f, -3.44269603e-01f, -2.13426381e-01f, -7.99448863e-02f,
  -1.99902833e-01f, -3.61484587e-02f, -3.71094272e-02f, 4.85662818e-02f, 1.78920612e-01f, 2.02147499e-01f, -4.19574641e-02f, -2.00572889e-02f, 7.05432892e-02f, -9.03823897e-02f,
  -4.16349545e-02f, 2.43614465e-02f, 1.94586620e-01f, 1.13259844e-01f, -1.97899193e-01f, -1.03090987e-01f, 9.09762308e-02f, 1.29090443e-01f, 4.77058105e-02f, 5.88521473e-02f,
  -1.06914617e-01f, -9.79500413e-02f, -6.68347031e-02f, -2.29934230e-03f, -7.30003789e-02f, 6.50318936e-02f, 2.13207621e-02f, 5.27173579e-02f, 5.59346005e-02f, 4.96585779e-02f,
  3.69846188e-02f, -2.23211255e-02f, 5.28214052e-02f, 1.03621058e-01f, -1.32698685e-01f, -4.93123084e-02f, -9.95390862e-03f, -1.53814003e-01f, -2.17545684e-02f, -2.95648649e-02f,
  -7.17391772e-03f, -3.35612036e-02f, -6.27294853e-02f, -5.14972769e-02f, -4.33952212e-02f, -4.15020809e-02f, -6.24186266e-03f, -1.33865234e-02f, -5.90964295e-02f, -6.05762303e-02f,
  4.12679166e-02f, 1.81341227e-02f, 5.24059907e-02f, 1.83136873e-02f, -3.62986326e-02f, -1.08829672e-02f, 9.22325850e-02f, 2.30604280e-02f, 3.43189500e-02f, -6.78622201e-02f,
  -5.01385629e-02f, -1.15982138e-01f, -5.09900711e-02f, -1.63459871e-02f, -6.09203184e-04f, -5.30082099e-02f, -6.03082450e-03f, -5.17767146e-02f, -1.01125859e-01f, -5.31938113e-02f,
  6.01486824e-02f, -1.00913486e-02f, -6.75679743e-02f, -4.64165062e-02f, 2.08823960e-02f, -3.37201580e-02f, -1.43205971e-01f, -1.16933182e-01f, 5.75592257e-02f, 4.40807752e-02f,
  -2.14888245e-01f, -1.21464796e-01f, 7.28394166e-02f, -2.65267491e-02f, 1.11554459e-01f, 4.09537042e-03f, 1.19257890e-01f, -1.67736020e-02f, 1.96014065e-02f, 6.66949153e-02f,
  -2.08388288e-02f, -1.86816622e-02f, -7.23682418e-02f, 6.76001562e-03f, 8.57733041e-02f, -3.61604579e-02f, 9.95915756e-03f, 3.57513800e-02f, -5.77452630e-02f, -4.05807383e-02f,
  5.36575131e-02f, 9.21838135e-02f, 1.46822497e-01f, -6.40085991e-03f, 6.65662959e-02f, -2.68386099e-02f, -9.37279537e-02f, 5.50107099e-02f, 6.32325783e-02f, 2.20600832e-02f,
  -2.90102214e-02f, -1.19984066e-02f, 6.94530979e-02f, 1.50953308e-02f, 1.42561302e-01f, -4.26273555e-01f, -3.44597250e-01f, 7.41515905e-02f, -2.47683730e-02f, -9.93705392e-02f,
  -2.70666867e-01f, 3.91533673e-01f, -2.87569255e-01f, -1.50452122e-01f, -1.28529117e-01f, -4.00596112e-01f, -5.85259236e-02f, -1.55516461e-01f, 1.49013460e-01f, 1.77934207e-02f,
  5.14609506e-03f, 1.58389788e-02f, -2.52555124e-02f, 2.75324315e-01f, 4.04295288e-02f, 2.13849604e-01f, 1.60318851e-01f, 1.43304542e-01f, 1.12033688e-01f, 1.32054374e-01f,
  -1.74415991e-01f, 1.55250272e-02f, 1.12197667e-01f, 6.63213655e-02f, -9.82255116e-02f, 1.73187684e-02f, -1.40940651e-01f, 3.38381790e-02f, 7.72669092e-02f, 2.25588847e-02f,
  -3.61727402e-02f, 8.30662437e-03f, 8.32550377e-02f, 9.53231230e-02f, 9.90635082e-02f, 1.76723123e-01f, -1.49754193e-02f, -7.59533048e-02f, 9.09404531e-02f, -5.30944066e-03f,
  -4.61704694e-02f, -6.29813150e-02f, -9.27323252e-02f, 3.74355130e-02f, 4.20365036e-02f, -7.40930811e-03f, 4.32048291e-02f, 1.64600406e-02f, 3.40482369e-02f, 5.19878119e-02f,
  -7.18797371e-02f, 4.18741815e-02f, 7.79823735e-02f, 7.16884211e-02f, 8.53423923e-02f, 7.48066083e-02f, 7.14699402e-02f, 2.41767298e-02f, -3.25140863e-04f, -3.97485383e-02f,
  -3.22210975e-02f, -1.62214711e-02f, 2.87514012e-02f, 4.35984731e-02f, 1.24166701e-02f, 7.13026449e-02f, 1.13201924e-02f, 1.00467153e-01f, -3.92598622e-02f, 9.35018994e-03f,
  -3.33015583e-02f, -3.74103971e-02f, 5.20674400e-02f, -1.91519912e-02f, -4.47921269e-02f, 2.18405183e-02f, -5.71733005e-02f, 8.94459803e-03f, -6.28324598e-02f, 2.39938702e-02f,
  -1.63783044e-01f, 1.12744480e-01f, 3.70622077e-03f, 3.78915183e-02f, 1.46993175e-02f, 1.66393593e-02f, 7.85017200e-03f, -1.16428211e-02f, 6.40542209e-02f, -2.36773603e-02f,
  -1.94331389e-02f, 6.58525452e-02f, 1.00860291e-03f, -3.26364785e-02f, -8.97479281e-02f, -8.66098404e-02f, -5.41048497e-02f, -7.29883648e-03f, 9.15837213e-02f, 3.37850638e-02f,
  -4.11984185e-03f, -7.48204663e-02f, 4.47121933e-02f, 6.18898571e-02f, -2.37776358e-02f, -2.92000994e-02f, 7.59658441e-02f, 6.59492761e-02f, -1.11268731e-02f, -2.02400405e-02f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  7.85136689e-03f, 3.31052214e-01f, 1.47894084e-01f, 2.31953278e-01f, 2.50215512e-02f, 1.12798028e-01f, 3.41956198e-01f, 8.84448737e-02f, 4.12405103e-01f, -1.38821468e-01f,
  -2.34294876e-01f, 5.55180274e-02f, 4.91775349e-02f, -1.60159189e-02f, -1.74280077e-01f, -6.29802060e-04f, 7.78094754e-02f, 9.88501981e-02f, 4.20196086e-01f, 8.61679614e-02f,
  2.49257381e-03f, -2.05736056e-01f, -1.44361854e-01f, -7.54294842e-02f, -4.53326143e-02f, 1.49398088e-01f, -3.31069648e-01f, 1.92156196e-01f, -2.27376074e-01f, 1.22149840e-01f,
  -1.66544504e-02f, 2.62761384e-01f, 8.49747062e-02f, 1.47033200e-01f, -8.60685855e-02f, -2.99475752e-02f, -1.82541888e-02f, 3.11209466e-02f, 1.17972888e-01f, 7.31099816e-03f,
  -5.13684079e-02f, -1.10079713e-01f, -6.34583458e-02f, -1.66239157e-01f, 1.13017134e-01f, -9.54151973e-02f, 9.56844911e-02f, 3.40993574e-04f, 1.11024357e-01f, 2.27280315e-02f,
  -2.79230699e-02f, -6.14498034e-02f, -4.66988273e-02f, 8.01281929e-02f, 3.98223810e-02f, 1.51924312e-01f, 6.82162866e-02f, -1.03853252e-02f, 5.00314031e-03f, 3.78390476e-02f,
  1.07247360e-01f, 7.40617737e-02f, -2.62165871e-02f, -1.10646803e-02f, 7.80246872e-03f, -6.92700327e-04f, -2.27909144e-02f, -4.99856919e-02f, 1.70442045e-01f, -1.98800918e-02f,
  -5.26598655e-02f, 6.23746626e-02f, 4.93925065e-02f, 9.07723606e-03f, 4.34486233e-02f, 3.94958407e-02f, -3.99740525e-02f, -1.58620961e-02f, 3.68049555e-02f, -9.38365906e-02f,
  -2.39500273e-02f, 4.33976622e-03f, 6.43204898e-02f, -7.36184940e-02f, -3.07715647e-02f, 4.66370285e-02f, -1.67615399e-01f, -8.79108757e-02f, 4.56070155e-02f, 1.67574026e-02f,
  1.59880593e-01f, 4.11143094e-01f, 1.44832969e-01f, 1.08405679e-01f, 1.15617979e-02f, -1.21158786e-01f, 4.15179916e-02f, 2.64682043e-02f, 1.40420765e-01f, 7.90361781e-03f,
  -2.93417908e-02f, 3.44844051e-02f, -1.45689920e-01f, -1.68441787e-01f, -2.11046077e-02f, -8.25935975e-02f, 1.55675747e-02f, 2.20172480e-01f, -5.32274880e-03f, -8.45744759e-02f,
  -4.92089577e-02f, 7.50928223e-02f, -2.49181986e-02f, 8.42388049e-02f, -2.55576707e-02f, -1.71981324e-02f, -5.52142560e-02f, 1.10619366e-01f, -8.31762552e-02f, -5.72432317e-02f,
  -7.37232119e-02f, -6.94835857e-02f, 6.06057167e-01f, -1.64147735e-01f, 1.59702793e-01f, 3.54759723e-01f, 1.76371589e-01f, -1.05204225e-01f, -2.66666830e-01f, -2.57036597e-01f,
  -8.23836699e-02f, 1.65293261e-01f, 1.31435245e-01f, -1.90389767e-01f, 1.23299383e-01f, -2.24922702e-01f, -1.13345735e-01f, -1.45127907e-01f, -2.34667391e-01f, -4.87690791e-02f,
  6.40306668e-03f, -3.56638283e-01f, 2.61736691e-01f, -2.32274517e-01f, 1.26223490e-01f, -3.01075983e-03f, -1.59446314e-01f, 1.73347428e-01f, 2.37144139e-02f, 7.21314251e-02f,
  -4.57216501e-02f, -1.47375450e-01f, -3.42891812e-02f, 3.08360532e-02f, 9.46195126e-02f, 2.54138745e-02f, 1.08472630e-01f, 3.38596888e-02f, -6.70056865e-02f, 4.12071757e-02f,
  5.43784350e-02f, 1.73806265e-01f, -1.76408604e-01f, -3.19852009e-02f, -2.09209900e-02f, -4.54358310e-02f, 2.12466300e-01f, 8.47776756e-02f, 5.89573383e-02f, 1.66054264e-01f,
  1.20976359e-01f, 1.64039269e-01f, 1.24134742e-01f, -3.97008052e-03f, 3.63484845e-02f, 4.25882079e-02f, 1.15231246e-01f, 1.93093389e-01f, -2.15948243e-02f, 3.24330591e-02f,
  1.63746141e-02f, -4.24624830e-02f, 8.17551538e-02f, -8.78207684e-02f, -1.73240453e-02f, -5.78571185e-02f, -1.09284893e-01f, 7.21868593e-03f, -1.24120824e-02f, -6.17458718e-03f,
  -5.06012747e-03f, -4.09019738e-02f, -3.90440300e-02f, -9.40788612e-02f, 7.13793114e-02f, -7.82276411e-03f, 7.21205175e-02f, 3.84558998e-02f, 4.80939597e-02f, -4.02321778e-02f,
  -7.44246468e-02f, -2.13315990e-02f, 5.85527346e-02f, 1.58312805e-02f, 5.88719361e-02f, 6.13692077e-03f, -6.68622404e-02f, 1.32460713e-01f, -7.46695101e-02f, 1.96577851e-02f,
  -2.53597200e-01f, -3.64903271e-01f, -1.04892269e-01f, -9.63499211e-03f, -9.34075788e-02f, -2.75209434e-02f, -1.88332036e-01f, -6.14500530e-02f, -7.16067702e-02f, -4.81101461e-02f,
  6.92996532e-02f, -1.45236189e-02f, -1.25723267e-02f, -1.32310957e-01f, -7.89714530e-02f, -4.52117510e-02f, -2.39907708e-02f, 2.79316753e-02f, 1.63469557e-02f, -6.26733974e-02f,
  -5.71391806e-02f, 8.43126886e-03f, 7.07721412e-02f, -3.12572271e-02f, -1.38157412e-01f, -6.32304978e-03f, -2.92243715e-02f, 4.66482341e-03f, -3.99284512e-02f, -3.23995613e-02f,
  1.63025185e-02f, -3.50024551e-01f, -9.00067538e-02f, -3.27502161e-01f, -5.05861966e-03f, -1.85197383e-01f, 3.20065506e-02f, -2.93760121e-01f, -5.60678840e-02f, -2.12262943e-01f,
  -1.35066301e-01f, 1.87029675e-01f, 4.08360064e-01f, -3.92292291e-01f, 4.93080109e-01f, 3.19317371e-01f, -4.35379416e-01f, -1.23117790e-01f, -3.28965262e-02f, -1.57636017e-01f,
  -4.92157489e-02f, -2.87733585e-01f, 8.26789737e-02f, -3.71493638e-01f, -3.38206053e-01f, -2.67943233e-01f, 2.04760842e-02f, 2.57249200e-03f, -3.28485310e-01f, 4.60796691e-02f,
  -8.63051191e-02f, -4.80653867e-02f, 2.03807801e-02f, -1.25341276e-02f, -1.45176828e-01f, -5.39373904e-02f, -2.31244997e-03f, 1.45351976e-01f, 8.10801089e-02f, 3.21946573e-03f,
  2.65947096e-02f, 1.32735416e-01f, -1.10564172e-01f, 8.53061825e-02f, -1.50778115e-01f, -8.67655426e-02f, -2.69740522e-02f, -1.30823022e-02f, 6.90664649e-02f, -9.57813486e-03f,
  -6.04412407e-02f, -4.36923765e-02f, -1.22009695e-01f, 2.67735962e-02f, 4.42385562e-02f, -1.33721784e-01f, 7.84381181e-02f, 9.68972221e-02f, 1.85929947e-02f, -5.80425002e-02f,
  -5.34045398e-02f, 4.85082641e-02f, -2.68617645e-02f, -4.74275742e-03f, 2.57964768e-02f, 3.92055511e-03f, 6.30184636e-02f, 6.34256080e-02f, 5.33408159e-03f, 1.34383999e-02f,
  2.53981855e-02f, 4.39578108e-02f, -3.25772353e-02f, -6.84729740e-02f, -1.25777841e-01f, -1.33233340e-02f, 4.48511317e-02f, -3.45160924e-02f, -1.26198977e-01f, -3.87785695e-02f,
  -5.63821243e-03f, -3.94360162e-02f, -4.76459460e-03f, -1.47818550e-02f, -8.29444453e-02f, 1.21630438e-01f, -8.27104002e-02f, 5.72443269e-02f, -2.50948798e-02f, 1.19051374e-01f,
  -1.87090170e-02f, -2.13721558e-01f, -4.50462289e-03f, 2.68326942e-02f, -2.46496089e-02f, -1.05937310e-01f, -1.09498121e-01f, -1.11852325e-01f, -8.25847965e-04f, 1.62606351e-02f,
  -2.32989416e-01f, 7.32372776e-02f, -8.96634310e-02f, -3.09451520e-02f, 4.30571325e-02f, -1.30723134e-01f, 4.13585715e-02f, -6.59706667e-02f, -1.27773331e-02f, -7.38630295e-02f,
  4.45081927e-02f, 1.44758662e-02f, 1.20266624e-01f, -3.31950784e-02f, -2.21691467e-02f, 6.95073698e-03f, 4.13705073e-02f, -2.72410903e-02f, 2.37833206e-02f, -6.74932450e-02f,
  -5.44148028e-01f, 2.30316043e-01f, -2.03904018e-01f, -3.82895172e-01f, -2.16661826e-01f, -3.05666089e-01f, -1.99776024e-01f, 6.02608435e-02f, 2.65355527e-01f, 1.57750800e-01f,
  2.83117946e-02f, 2.27022752e-01f, 4.65497017e-01f, -1.57713503e-01f, -1.38036072e-01f, 4.14031535e-01f, -3.81930023e-01f, -2.06222013e-01f, 1.73588470e-02f, -7.96712339e-02f,
  -8.59297067e-02f, 1.48563797e-03f, -2.37961665e-01f, 1.05501041e-01f, -4.31012154e-01f, -2.84508407e-01f, -2.57777691e-01f, -6.92181066e-02f, -4.07222420e-01f, -1.71791568e-01f,
  -3.56588066e-01f, -2.67433137e-01f, -1.99448422e-01f, -1.75067753e-01f, -2.13065848e-01f, -1.51838273e-01f, -2.02186435e-01f, 4.88456860e-02f, -2.47767493e-02f, 2.73644575e-03f,
  9.73579437e-02f, 1.27358422e-01f, -4.86586578e-02f, 2.51533419e-01f, -6.29704371e-02f, -9.16025639e-02f, -6.96901530e-02f, -2.36179724e-01f, 3.64036188e-02f, -6.93105087e-02f,
  -7.57233575e-02f, -7.55515844e-02f, -2.40096331e-01f, -1.21921226e-01f, -1.98051602e-01f, -1.73463121e-01f, -1.98178068e-02f, -1.24713160e-01f, -2.77755976e-01f, -1.16481647e-01f,
  1.77708622e-02f, -1.59510206e-02f, 9.38165560e-03f, 3.25733609e-02f, -4.98951692e-03f, -3.99075262e-02f, 3.00527029e-02f, 8.37024599e-02f, -2.29908191e-02f, -5.08845523e-02f,
  4.33319109e-03f, -2.69054323e-02f, -5.77546321e-02f, -1.22303464e-01f, 4.30370420e-02f, 9.34364200e-02f, 9.79925133e-03f, -4.24522460e-02f, 7.69958226e-03f, -5.65321743e-02f,
  -2.61833915e-03f, 3.40466574e-02f, -3.46932397e-03f, -3.07034068e-02f, -9.41546187e-02f, 1.85746234e-02f, 2.04261509e-03f, -2.88348552e-02f, -2.87314449e-02f, -1.80863235e-02f,
  -3.86133373e-01f, -2.88514376e-01f, 1.13249067e-02f, -1.35682955e-01f, -5.71878739e-02f, -3.31384614e-02f, 6.80793226e-02f, -5.26592992e-02f, -1.23459965e-01f, 7.37511963e-02f,
  -4.14121263e-02f, 8.86939839e-03f, -1.44168451e-01f, -2.94900704e-02f, 1.07432052e-01f, 2.53126677e-02f, 1.68203246e-02f, -1.06835132e-02f, -1.03688940e-01f, -1.01459138e-01f,
  -2.67016143e-02f, 1.41898423e-01f, 1.31354675e-01f, -7.81838782e-03f, -4.16280143e-02f, -1.20361634e-01f, -1.14236334e-02f, 6.75458387e-02f, -1.69697031e-01f, 6.42167702e-02f,
  3.73821646e-01f, 1.69239163e-01f, 2.59925961e-01f, 2.83937961e-01f, 1.44569278e-01f, 3.69817652e-02f, 4.24665175e-02f, 3.39106351e-01f, 5.80859601e-01f, 7.74013158e-03f,
  -8.91721472e-02f, 4.37171124e-02f, -1.82187885e-01f, 1.46719605e-01f, -3.56659889e-01f, -1.20661199e-01f, 3.03301457e-02f, -4.04668152e-02f, 1.80585891e-01f, -3.33015323e-02f,
  -4.82343547e-02f, -3.12124848e-01f, -3.38957876e-01f, -1.60036385e-01f, 1.55430049e-01f, 1.66734055e-01f, -3.43259394e-01f, -2.07266957e-02f, -5.82356192e-02f, -1.05092721e-02f,
  1.86900929e-01f, 2.67855823e-01f, 8.09766203e-02f, 9.97336879e-02f, 9.66271684e-02f, -1.07639387e-01f, -9.06250775e-02f, -5.34901619e-02f, 4.22235094e-02f, 5.30431084e-02f,
  -6.92588165e-02f, 3.77699430e-03f, -2.81362217e-02f, -1.22768488e-02f, 1.44242510e-01f, 1.63733408e-01f, 8.20679665e-02f, 5.04124053e-02f, 6.24803267e-02f, 4.14452553e-02f,
  8.30452703e-03f, 8.12019557e-02f, 1.06693134e-01f, -4.24140133e-02f, 1.24277165e-02f, 2.36809894e-01f, 1.57766119e-02f, 5.11379689e-02f, 6.33125100e-03f, 1.60440028e-01f,
  -8.99462029e-02f, -4.07744497e-02f, 1.11161448e-01f, 8.55896547e-02f, 1.03269853e-01f, -1.60816293e-02f, 5.74944867e-03f, -3.63340415e-02f, 5.23831397e-02f, -1.08164415e-01f,
  3.78191173e-02f, 1.33011118e-01f, 1.07355990e-01f, 2.11688448e-02f, -5.03664874e-02f, 7.79738352e-02f, -1.12158589e-01f, 4.13144678e-02f, 3.26736155e-03f, -7.31686410e-03f,
  2.76451800e-02f, -1.05046287e-01f, 3.68459709e-02f, -2.67491862e-02f, 9.64615420e-02f, 1.37935188e-02f, -1.24963671e-02f, 1.47976160e-01f, 7.23358914e-02f, -1.71154335e-01f,
  -1.44107506e-01f, -1.71006322e-01f, -9.29556265e-02f, 2.98918653e-02f, -5.88334575e-02f, -1.81438550e-02f, 4.77024838e-02f, 1.47449851e-01f, -3.66070010e-02f, 5.07743284e-02f,
  -2.64766142e-02f, -4.40153368e-02f, -1.11742049e-01f, 3.10716126e-02f, -1.78597093e-01f, 1.10344827e-01f, -1.05920680e-01f, -2.06781272e-02f, -1.01019911e-01f, -6.85899258e-02f,
  -1.47003993e-01f, -1.60385117e-01f, -5.90475462e-02f, 4.28857990e-02f, -5.90197369e-02f, -7.36473920e-03f, -8.42959732e-02f, 2.96946010e-03f, -1.02816358e-01f, -1.27777174e-01f,
  2.38205224e-01f, 4.96243894e-01f, 3.37714344e-01f, 1.40199259e-01f, -2.39074692e-01f, -3.02614182e-01f, -3.31480861e-01f, 1.95264369e-01f, -1.49236500e-01f, 3.41910496e-03f,
  -9.07502919e-02f, 1.30301803e-01f, 4.35558669e-02f, 2.52538383e-01f, -7.85092786e-02f, 1.87363438e-02f, 1.06486060e-01f, 4.24263477e-02f, 1.15099378e-01f, 3.34136307e-01f,
  9.59281325e-02f, -7.36075118e-02f, 2.84780949e-01f, 1.24254435e-01f, 3.21766675e-01f, 2.41180301e-01f, 2.66058594e-02f, 8.11827742e-03f, 1.37568846e-01f, -1.16840623e-01f,
  -1.91206094e-02f, 8.03023726e-02f, 1.84578910e-01f, -5.09131178e-02f, -4.78497799e-03f, -3.04567926e-02f, 8.15579668e-02f, -1.13350358e-02f, -9.41693038e-02f, -4.04145196e-02f,
  3.47090960e-02f, 1.00086041e-01f, -1.42054667e-03f, -4.62332107e-02f, 1.06732436e-02f, -4.90697958e-02f, 1.04396202e-01f, 5.46540022e-02f, 1.34090245e-01f, 1.57191589e-01f,
  8.93225335e-03f, 1.06850341e-01f, 1.96700227e-02f, 3.96986790e-02f, -3.06467619e-02f, -8.51426274e-02f, 1.77043315e-03f, 2.96842363e-02f, 2.99657397e-02f, 5.87188639e-04f,
  1.89028978e-01f, -1.07135288e-01f, -3.89272571e-02f, -8.44157487e-02f, -9.80596989e-04f, 2.01940257e-02f, 1.39880078e-02f, -2.74223741e-02f, -1.24011301e-02f, -2.41750125e-02f,
  -9.83532965e-02f, 8.00075904e-02f, -1.18307985e-01f, -1.34209290e-01f, -1.50232101e-02f, -7.87326694e-02f, 3.87838557e-02f, 4.56408188e-02f, -4.16301042e-02f, 1.72739371e-03f,
  -8.21705461e-02f, -4.17034887e-02f, -4.22377028e-02f, -2.63468679e-02f, -1.07905447e-01f, -5.69018871e-02f, 6.43105246e-03f, 1.00497879e-01f, 5.55117205e-02f, 8.39352515e-03f,
  1.76664472e-01f, 2.09580630e-01f, -6.25256002e-02f, -1.26652166e-01f, -2.74353977e-02f, -5.70244621e-04f, 9.69505534e-02f, 3.16508636e-02f, 1.19261099e-02f, -2.21198499e-02f,
  -3.60651091e-02f, -6.91631734e-02f, -8.42291936e-02f, -3.86999585e-02f, -4.39018123e-02f, -7.70989060e-02f, -7.29368478e-02f, -1.26016334e-01f, 7.35412398e-03f, 6.97661936e-02f,
  7.07198679e-02f, -1.06625810e-01f, 3.29894386e-02f, -4.26898934e-02f, -2.48573255e-02f, -4.64299880e-02f, 3.52548696e-02f, -2.45173853e-02f, 9.73469689e-02f, 1.25881694e-02f,
  -7.60435909e-02f, -4.10416454e-01f, -4.84177954e-02f, 2.36046851e-01f, 2.88921118e-01f, -6.74072802e-02f, -2.47651905e-01f, 2.79108025e-02f, 9.75580066e-02f, -4.40244496e-01f,
  -1.54263228e-01f, -2.96133876e-01f, -4.10666764e-01f, 1.97071910e-01f, 5.69160329e-03f, -1.49213716e-01f, 1.37616083e-01f, -5.21670841e-02f, 7.77886137e-02f, 2.00948007e-02f,
  1.18094511e-01f, 2.42509067e-01f, -7.29368180e-02f, 2.55567551e-01f, 5.19572347e-02f, 6.93475232e-02f, -1.75207600e-01f, -2.44666152e-02f, 2.27702960e-01f, 2.90014986e-02f,
  -1.12185456e-01f, 9.05576069e-03f, -5.24576604e-02f, -1.30360872e-01f, -8.53185356e-02f, -8.14244151e-02f, -1.20530047e-01f, -5.95093295e-02f, 6.31423527e-03f, 5.56396209e-02f,
  -1.41302153e-01f, 6.39751330e-02f, 1.66881293e-01f, -1.78785119e-02f, 6.11465834e-02f, 4.38578166e-02f, 7.68806189e-02f, -6.40683249e-03f, 3.86079699e-02f, -6.68075383e-02f,
  -3.93710658e-02f, -4.24503051e-02f, 4.76555526e-02f, -1.42805884e-02f, -5.72590716e-02f, 1.49107184e-02f, 1.84693843e-01f, -1.02040313e-01f, -1.78698488e-02f, 6.02901839e-02f,
  9.35006291e-02f, -3.49588715e-03f, -2.78472789e-02f, -1.65909957e-02f, 1.48077076e-03f, 5.15977927e-02f, -2.96377018e-02f, 8.51849765e-02f, -3.40275280e-02f, -1.85596272e-02f,
  5.41410223e-02f, 1.66729954e-03f, 9.60209891e-02f, 1.57231893e-02f, -1.79807227e-02f, 3.50053646e-02f, 1.82572268e-02f, 9.42709967e-02f, 4.13683429e-02f, 3.71895880e-02f,
  -1.81054883e-02f, -2.33541857e-02f, -2.43800282e-02f, 2.17429325e-02f, -6.05964512e-02f, -9.37231556e-02f, 1.49180815e-02f, 3.57533991e-02f, -1.11942748e-02f, -5.91215640e-02f,
  -5.37635803e-01f, -3.65345031e-01f, -5.62981442e-02f, 1.98101755e-02f, 1.00536365e-02f, -6.66708127e-02f, 1.85455516e-04f, 4.22251709e-02f, -1.37083068e-01f, -3.98508981e-02f,
  -9.58324298e-02f, 3.26652825e-02f, 3.30897830e-02f, 1.05815701e-01f, 2.78393980e-02f, -9.46783498e-02f, -8.77636373e-02f, -2.38815267e-02f, -9.57085863e-02f, -5.44410646e-02f,
  -1.37915596e-01f, -4.84483875e-02f, 2.52428837e-02f, 5.41858934e-02f, 7.24912137e-02f, -7.63223469e-02f, 4.56797443e-02f, -2.27532312e-02f, 4.20410559e-02f, 3.10114902e-02f,
  5.88557720e-01f, -5.06520450e-01f, -4.35394913e-01f, 7.72537217e-02f, 6.35046542e-01f, 3.30785155e-01f, 2.81688273e-01f, 5.34679368e-02f, -1.88428402e-01f, -3.07542235e-01f,
  2.98968673e-01f, -1.34129524e-01f, -2.10192844e-01f, 2.56206632e-01f, 4.63836163e-01f, -3.16595793e-01f, 2.29725152e-01f, 6.12456091e-02f, -8.97579715e-02f, 1.09690748e-01f,
  2.06995919e-01f, 4.67079252e-01f, -3.84495929e-02f, 1.05352176e-03f, 3.50151032e-01f, -2.63581276e-01f, 6.40800670e-02f, -2.14879632e-01f, 6.44320697e-02f, 2.10040599e-01f,
  6.62443116e-02f, 2.60874238e-02f, 3.17848958e-02f, -9.74722505e-02f, 6.62622154e-02f, 9.93832648e-02f, 1.29680298e-02f, 1.15630992e-01f, 4.21268046e-02f, -1.09933699e-02f,
  -1.26689970e-02f, 1.17548488e-01f, 8.59757438e-02f, -3.92749608e-02f, 3.78733538e-02f, 4.32578959e-02f, -2.45776474e-02f, -2.65899058e-02f, -3.30681615e-02f, 6.25229329e-02f,
  -4.16781101e-03f, 2.12843232e-02f, 3.06596402e-02f, -3.85567583e-02f, -7.59961307e-02f, 8.01485498e-03f, -5.57543226e-02f, 8.12652893e-03f, -2.58147717e-02f, 6.36583716e-02f,
  6.48049936e-02f, -6.24812283e-02f, 8.08647871e-02f, -1.25542246e-02f, -1.11232428e-02f, 2.67125946e-02f, -2.12351978e-02f, 2.83910837e-02f, -1.06347993e-01f, 6.40951842e-02f,
  -1.86185371e-02f, 1.30920380e-01f, -6.04092702e-03f, 4.16927747e-02f, 1.09954670e-01f, 3.43029760e-02f, 8.15863069e-03f, -2.90605752e-03f, -2.27732006e-02f, -8.79825000e-03f,
  7.55123375e-03f, 4.37066033e-02f, -1.38936108e-02f, 2.98864953e-02f, 1.29811037e-02f, -3.26714292e-02f, -7.51649365e-02f, 2.25961283e-02f, -4.03922647e-02f, -2.14524232e-02f,
  -1.44118980e-01f, -3.29604983e-01f, -7.28949457e-02f, 1.51758930e-02f, -1.43678322e-01f, 6.70741200e-02f, -8.76026079e-02f, 5.15978821e-02f, 1.05566066e-03f, 5.24637662e-02f,
  6.11942559e-02f, -1.73827615e-02f, -7.30106756e-02f, 3.04960757e-02f, -7.14792013e-02f, 3.26126628e-02f, -8.31459090e-02f, -5.79468459e-02f, 9.90218073e-02f, -2.68116873e-02f,
  -4.80902679e-02f, -3.61521505e-02f, -1.74997542e-02f, 7.21577778e-02f, -5.21825999e-03f, -1.24781458e-02f, 1.11871446e-02f, -8.85977075e-02f, 1.89979486e-02f, -8.01813453e-02f,
  -4.24140692e-02f, -4.12243098e-01f, -2.74244696e-01f, 6.22733720e-02f, 9.97853698e-04f, 4.15992916e-01f, 5.66111207e-01f, -3.01423430e-01f, -5.73732495e-01f, 1.42587975e-01f,
  2.58217663e-01f, 8.05986002e-02f, -1.80191025e-01f, 4.06799585e-01f, 3.45062107e-01f, -6.35837466e-02f, 1.82971448e-01f, 2.56063730e-01f, -2.83173680e-01f, -2.57835448e-01f,
  -1.25104040e-01f, 2.63820678e-01f, 2.98700724e-02f, -4.86258008e-02f, 8.30718428e-02f, -3.87399979e-02f, 2.66617686e-01f, 2.53635226e-04f, 4.62921530e-01f, 4.50843573e-01f,
  3.92486379e-02f, -1.02037758e-01f, -9.47628543e-02f, 6.14885380e-03f, 4.22958992e-02f, 1.65154546e-01f, 2.32505158e-01f, 2.70524740e-01f, 1.06236815e-01f, -6.79976642e-02f,
  8.09521452e-02f, -1.75605305e-02f, 2.44317129e-02f, 6.14518709e-02f, -1.64887600e-03f, -5.51951490e-02f, -1.46268100e-01f, -4.30115648e-02f, -1.30645767e-01f, -6.75139017e-03f,
  -2.67609239e-01f, -1.97734803e-01f, 3.80058996e-02f, 7.09269717e-02f, -7.13684084e-03f, -1.68584377e-01f, 1.88055895e-02f, 1.29089563e-03f, 2.65759900e-02f, -7.38570541e-02f,
  8.71332549e-03f, 6.76196674e-03f, -1.11669734e-01f, 4.59435731e-02f, 5.57003394e-02f, 6.87298477e-02f, -3.12658325e-02f, 3.74402478e-02f, 8.70720372e-02f, -9.84546691e-02f,
  -3.15539539e-03f, -3.53608057e-02f, 3.39569263e-02f, -1.43780764e-02f, 2.75170570e-03f, -9.20830667e-02f, 1.48317233e-01f, -1.67243071e-02f, -7.12643787e-02f, -1.42626697e-02f,
  3.76351550e-02f, -1.10005988e-02f, 6.01009876e-02f, 9.95021090e-02f, -7.58734718e-02f, -5.51630184e-03f, 6.26740605e-02f, -3.90886702e-02f, 3.37821394e-02f, 6.20892122e-02f,
  1.28822485e-02f, -1.48279712e-01f, -1.26689717e-01f, 6.34932518e-02f, 7.75776058e-03f, -6.97155222e-02f, 3.30078863e-02f, -4.22626510e-02f, 2.35923138e-02f, -1.44106910e-01f,
  1.63023442e-01f, 2.86412034e-02f, 4.23098132e-02f, 1.03032909e-01f, 8.36868733e-02f, -9.30382311e-02f, 4.26397324e-02f, 1.27973100e-02f, 1.80141050e-02f, -2.69063991e-02f,
  5.52382171e-02f, 7.83769488e-02f, 1.34111136e-01f, -9.78428051e-02f, -7.39862919e-02f, 1.24451585e-01f, -4.75364774e-02f, -2.50054486e-02f, 2.63286866e-02f, 4.07877304e-02f,
  -1.05563654e-02f, 3.39707643e-01f, 4.20852602e-01f, 3.86645645e-01f, -2.75059313e-01f, -3.25110823e-01f, -1.04509152e-01f, -2.39302982e-02f, 6.30426332e-02f, -1.17225632e-01f,
  -7.37611279e-02f, 2.30269834e-01f, -5.07247373e-02f, 1.95615545e-01f, 5.42020090e-02f, -9.10886228e-02f, 1.15293987e-01f, 2.80681141e-02f, 2.10913457e-03f, 1.27424598e-01f,
  7.16098174e-02f, -6.07691146e-02f, 1.96587369e-01f, -1.23778954e-01f, 1.31044611e-01f, 2.82378316e-01f, 1.96634099e-01f, 1.25829130e-01f, 2.61737823e-01f, -7.15318397e-02f,
  -4.86632697e-02f, 3.28080147e-03f, 7.12583512e-02f, 1.36499731e-02f, 4.17671576e-02f, -6.69372827e-02f, -5.10438858e-03f, -1.62189752e-02f, -3.86027396e-02f, 8.94738734e-02f,
  -2.39401311e-03f, -3.76542136e-02f, 7.54250139e-02f, 4.50022258e-02f, -1.26050815e-01f, 7.93258995e-02f, 3.27251386e-03f, -2.87629478e-03f, 5.34381643e-02f, 4.96281572e-02f,
  1.22502550e-01f, -1.99293904e-02f, 7.25756586e-02f, 4.10061404e-02f, 9.31324512e-02f, 2.58306488e-02f, 3.30793820e-02f, 1.11750446e-01f, 2.98573617e-02f, 2.47709770e-02f,
  4.32167314e-02f, -1.42389117e-02f, -5.04649207e-02f, -1.86466407e-02f, -4.20842972e-03f, -1.96541920e-02f, -4.70521376e-02f, -6.27969997e-03f, 1.79073736e-02f, 5.32803163e-02f,
  -7.92959891e-03f, 1.21671651e-02f, -2.50174664e-02f, -1.73029322e-02f, -3.32628340e-02f, 2.69554593e-02f, -1.71741620e-02f, 8.28474388e-03f, 2.84239780e-02f, 9.90866031e-03f,
  2.70202737e-02f, -2.75691319e-03f, 3.49540226e-02f, -3.29291150e-02f, -5.71082309e-02f, -2.40656529e-02f, 1.29735976e-01f, 1.02623841e-02f, 3.17972968e-03f, 5.80436252e-02f,
  1.78308710e-01f, 3.87618095e-01f, 3.70394774e-02f, -1.41842738e-01f, 1.07624866e-02f, 1.89459268e-02f, 6.25233259e-03f, 9.02842656e-02f, 1.44511193e-01f, -5.74120581e-02f,
  -6.08786307e-02f, 2.26452556e-02f, 6.74772263e-03f, -1.94543507e-02f, 1.01018371e-02f, 1.22429192e-01f, 9.23574495e-04f, -1.66391488e-02f, 6.06051534e-02f, 8.66714492e-02f,
  6.25991225e-02f, -1.13934070e-01f, 7.37489387e-02f, -3.08112856e-02f, -7.06852749e-02f, 1.10661261e-01f, -1.15016792e-02f, 1.84329320e-02f, 1.08249359e-01f, 1.29740149e-01f,
  1.32716343e-01f, -1.33584052e-01f, -3.09359014e-01f, -2.74455667e-01f, 1.62683532e-01f, -9.22157019e-02f, -9.68371704e-02f, -4.40433010e-04f, -9.64524969e-02f, 1.66794777e-01f,
  1.05800308e-01f, -2.76344657e-01f, -2.50763763e-02f, -3.62693399e-01f, -2.82003284e-01f, -2.29376763e-01f, -2.23249465e-01f, -2.05340326e-01f, -9.85895768e-02f, 1.50413141e-02f,
  -1.07468203e-01f, 5.68815973e-03f, -2.62817174e-01f, 2.16057301e-01f, 3.67970690e-02f, 8.39895457e-02f, 3.13376158e-01f, 1.17914729e-01f, -2.18230132e-02f, -5.39673455e-02f,
  -4.77759913e-02f, -7.32946396e-03f, -1.22165613e-01f, -2.51061786e-02f, 4.90066111e-02f, 1.99392527e-01f, -1.73959751e-02f, -9.97328088e-02f, -9.01245605e-03f, -1.05912060e-01f,
  1.56008359e-03f, -7.95731321e-02f, -1.78629041e-01f, 4.43928763e-02f, 7.02116191e-02f, 1.17452042e-02f, -1.40047863e-01f, -2.42342725e-02f, -1.16244562e-01f, -1.09234497e-01f,
  -1.30284607e-01f, -8.57679993e-02f, 1.33559003e-01f, -7.14857131e-02f, -4.31507044e-02f, 3.70010138e-02f, -3.87104554e-03f, -6.24014735e-02f, -7.54432613e-03f, -8.24972913e-02f,
  9.47815627e-02f, 1.57780662e-01f, 2.44266652e-02f, -1.31903991e-01f, 5.80636691e-03f, -1.71089042e-02f, -1.23631610e-02f, -3.18993554e-02f, 3.45284529e-02f, 1.03239007e-02f,
  2.41569821e-02f, -6.69638142e-02f, 4.10232581e-02f, 7.99586549e-02f, 2.24866960e-02f, -2.23610364e-02f, 3.02298442e-02f, -5.80025241e-02f, 1.05633559e-02f, -6.02524839e-02f,
  4.21227403e-02f, 6.49509812e-03f, -8.39033946e-02f, -5.24478918e-03f, -6.99063390e-02f, 3.47642899e-02f, 1.17272258e-01f, -7.30159432e-02f, -7.50180557e-02f, 3.94876152e-02f,
  2.19297688e-02f, 5.08214980e-02f, -4.95564789e-02f, -8.57799575e-02f, -6.07255287e-02f, 9.93517861e-02f, -3.40131633e-02f, -9.30541232e-02f, 5.40793799e-02f, 8.93386081e-02f,
  5.15500978e-02f, 6.10924028e-02f, 1.21529587e-01f, 1.70688499e-02f, -5.98394359e-03f, 8.47479701e-02f, -2.78176498e-02f, -6.89755566e-03f, 4.43616509e-02f, -3.62200327e-02f,
  1.66686937e-01f, 8.12953934e-02f, 5.81330732e-02f, -6.48792880e-03f, 2.03496628e-02f, 1.12727672e-01f, 3.46817151e-02f, 4.31065969e-02f, 1.15899533e-01f, -1.41379848e-01f,
  4.66272771e-01f, -1.20049566e-01f, 2.03432724e-01f, 4.53934968e-01f, 1.87216654e-01f, -6.18746877e-02f, 3.49062324e-01f, 2.82355156e-02f, 5.63648760e-01f, -2.03936741e-01f,
  -6.35930076e-02f, 2.01935634e-01f, 4.84744012e-02f, -1.89255044e-01f, -1.80567905e-01f, 3.83305456e-03f, -1.41356930e-01f, 1.34096205e-01f, 2.38614619e-01f, 1.57229558e-01f,
  1.40831381e-01f, -9.16573033e-02f, -1.29506752e-01f, -1.89887479e-01f, -7.49409571e-02f, 3.64987068e-02f, -4.05785590e-01f, 1.61259826e-02f, -3.32307220e-01f, -6.87631145e-02f,
  -1.75225779e-01f, 2.02032179e-01f, -6.35403544e-02f, -9.99104083e-02f, -1.31107457e-02f, 2.12092865e-02f, 3.66956256e-02f, 4.14818041e-02f, 1.05512783e-01f, 2.93403305e-02f,
  2.99147870e-02f, 1.94336921e-02f, 5.66212647e-02f, 1.12502957e-02f, 3.71546894e-02f, -2.14143336e-04f, 6.45499630e-03f, -1.13575421e-01f, 5.13604507e-02f, -6.19443096e-02f,
  9.25131142e-02f, -3.95019073e-03f, -4.79684733e-02f, -1.27875701e-01f, 4.98246495e-03f, 8.84717330e-02f, -3.24180722e-02f, -1.73808977e-01f, -1.30069152e-01f, 1.36518538e-01f,
  1.20049447e-01f, 1.11128882e-01f, -6.89926744e-02f, 6.63278252e-02f, 2.50264574e-02f, -5.71819255e-03f, 1.36867235e-03f, 2.37615425e-02f, 6.51852712e-02f, 3.81044894e-02f,
  -2.41554715e-03f, 2.74842624e-02f, 1.30723760e-01f, 8.81633069e-03f, 1.23602860e-01f, 5.53638190e-02f, -1.19162574e-01f, -7.45908469e-02f, -1.01605490e-01f, 1.52674699e-02f,
  7.27538019e-02f, 3.25771198e-02f, -5.80174476e-03f, -3.02217789e-02f, -4.38575745e-02f, 2.79371589e-02f, -1.86898783e-02f, -1.33261383e-01f, 3.60577293e-02f, -2.70250030e-02f,
  -2.17395931e-01f, -3.84146087e-02f, -6.95589855e-02f, -6.48827925e-02f, -2.51977332e-02f, -1.41643330e-01f, 1.38422340e-01f, -9.75570679e-02f, 3.43148522e-02f, 1.29316347e-02f,
  -5.78806363e-03f, 7.04573933e-03f, -2.96640713e-02f, -7.39419684e-02f, -6.41088858e-02f, -5.82722425e-02f, 1.87220797e-02f, 3.14931832e-02f, -1.17162049e-01f, -7.16921315e-02f,
  3.01017500e-02f, 1.01803675e-01f, -8.56000464e-03f, 1.50927613e-02f, -1.97778359e-01f, -7.32541010e-02f, 2.30887346e-02f, -4.78393175e-02f, 1.58004276e-02f, -2.58330088e-02f,
  1.26653492e-01f, -1.26625717e-01f, 8.13181773e-02f, -8.49539265e-02f, -1.01845168e-01f, 3.58279377e-01f, 5.88093698e-01f, -2.29950398e-01f, -2.93403208e-01f, 8.44012871e-02f,
  -9.07403082e-02f, 1.61964625e-01f, 3.90237302e-01f, 7.77583867e-02f, 2.69391388e-01f, 1.93557009e-01f, 8.27476531e-02f, 1.17867664e-01f, -2.45641857e-01f, 2.84234211e-02f,
  -8.35594535e-02f, 8.86808410e-02f, 1.69744000e-01f, -2.28781179e-01f, -1.35009363e-03f, -1.91583425e-01f, -1.22626305e-01f, 1.56645462e-01f, -1.74962506e-01f, 2.14993842e-02f,
  9.75629687e-02f, -1.76590458e-01f, -6.68302625e-02f, -2.47354303e-02f, 4.33217399e-02f, 6.25700951e-02f, 2.33072415e-01f, 1.66108936e-01f, -3.04648876e-02f, 2.01648325e-02f,
  1.52229249e-01f, -5.96150346e-02f, -1.54827520e-01f, 8.20532963e-02f, -6.06370680e-02f, -1.38925642e-01f, -1.10774614e-01f, -6.93256110e-02f, -3.64987068e-02f, 4.32271883e-02f,
  3.44792642e-02f, -3.39226276e-02f, -1.84720442e-01f, -8.57122913e-02f, -1.07032731e-01f, -1.23695463e-01f, 1.78629473e-01f, 1.67744681e-01f, -3.59740853e-03f, -3.63846421e-02f,
  2.95009036e-02f, 8.08923468e-02f, 1.76497195e-02f, -5.44107966e-02f, -8.62287730e-03f, -7.63451830e-02f, 7.84244835e-02f, 4.65117948e-04f, -1.48913443e-01f, 6.64450228e-03f,
  -4.65064198e-02f, -3.66035569e-03f, -1.00039154e-01f, 4.07428518e-02f, 6.63990304e-02f, -1.31414114e-02f, 5.60671873e-02f, -2.84470394e-02f, -1.32891191e-02f, -3.55015956e-02f,
  -2.63468362e-02f, 4.57918039e-03f, 5.55217685e-03f, -4.07363148e-03f, 9.36333016e-02f, 5.86010404e-02f, -4.16815057e-02f, 9.38993227e-03f, -1.08050182e-01f, 1.25784010e-01f,
  4.86135557e-02f, 1.88926999e-02f, -5.88556416e-02f, -1.07827470e-01f, 5.56425750e-02f, -4.10315804e-02f, -5.97291684e-04f, -8.68913159e-02f, -4.37826244e-03f, 5.69445975e-02f,
  -9.19003561e-02f, 3.83814350e-02f, -3.50061432e-02f, 1.11231450e-02f, -2.22202688e-02f, -5.80257550e-02f, 1.60263225e-01f, -2.72796173e-02f, 1.27172740e-02f, -7.19017535e-03f,
  -7.98123926e-02f, 1.07697256e-01f, -7.04445839e-02f, -7.03579634e-02f, -1.15255982e-01f, -2.70124134e-02f, -1.46970851e-02f, -2.43335087e-02f, -6.39326945e-02f, -1.23463562e-02f,
  1.90461427e-01f, 1.16305359e-01f, 5.21675823e-03f, -1.57416999e-01f, -2.69471139e-01f, -1.51749238e-01f, -3.33485723e-01f, -8.23575631e-02f, 1.13128938e-01f, 1.19514905e-01f,
  -3.27464223e-01f, 3.81700099e-01f, -1.04637191e-01f, -1.87060371e-01f, -2.59915292e-02f, -1.11435689e-02f, -2.19643936e-01f, -7.44617134e-02f, -5.24154082e-02f, -1.38547465e-01f,
  -8.55080485e-02f, -3.96616489e-01f, -1.68043867e-01f, -3.00022751e-01f, -2.19927162e-01f, 6.04885146e-02f, -1.23725869e-01f, -2.56843776e-01f, -5.97401038e-02f, -1.60967410e-01f,
  -2.38956828e-02f, -3.45339999e-02f, 1.00337036e-01f, 4.38624918e-02f, 2.20441446e-03f, 7.96345547e-02f, 5.44334538e-02f, -5.84621206e-02f, -5.75301498e-02f, 4.31862660e-02f,
  8.75997096e-02f, 2.20189411e-02f, 3.29493247e-02f, -6.21637367e-02f, -4.60279211e-02f, 2.38185842e-02f, 5.98594844e-02f, 1.34267956e-01f, 4.42920579e-03f, 3.08756139e-02f,
  -7.09347101e-03f, 1.35765225e-01f, -8.63594469e-03f, 1.08802833e-01f, -1.78465769e-02f, -9.74875465e-02f, 1.26123562e-01f, -3.70965637e-02f, 5.20007685e-02f, 1.94908702e-03f,
  -4.32733893e-02f, 1.38763348e-02f, -3.48893590e-02f, 2.33581103e-02f, -2.85839587e-02f, -1.46410812e-03f, 2.80863810e-02f, -1.83762144e-02f, -2.19695587e-02f, -2.40275562e-02f,
  1.26173571e-02f, 3.31465267e-02f, -8.58211294e-02f, 5.30684330e-02f, 1.11720962e-02f, 4.53796983e-02f, -1.41186481e-02f, 4.64783944e-02f, 2.53036376e-02f, 6.29467145e-02f,
  -1.30653471e-01f, -1.16324164e-02f, -1.19542666e-01f, -2.97115017e-02f, -9.80138928e-02f, 2.54726969e-02f, 4.28577140e-02f, 3.98204550e-02f, -1.01241171e-02f, -7.96282068e-02f,
  -3.07645537e-02f, -3.53772119e-02f, -9.65878740e-03f, 4.09543253e-02f, 2.68104319e-02f, 8.61774683e-02f, -1.71025784e-03f, 4.64441180e-02f, -5.97699732e-03f, -1.05253756e-01f,
  7.04235286e-02f, -5.05748838e-02f, 1.24826103e-01f, -2.63860393e-02f, -3.15936133e-02f, -6.90976828e-02f, -7.09077902e-03f, 5.75391538e-02f, 1.76383201e-02f, 2.60510761e-02f,
  5.24112619e-02f, 5.86773865e-02f, 4.48438823e-02f, 4.98475619e-02f, 7.01086968e-02f, 2.68100053e-02f, 1.12466492e-01f, 1.31164631e-02f, -5.43200523e-02f, 4.01540436e-02f,
  -1.64159104e-01f, -3.53024788e-02f, 4.32723105e-01f, -2.09006712e-01f, 2.41256997e-01f, 4.30229515e-01f, 5.25525713e-04f, 2.91626364e-01f, 1.09887376e-01f, -2.64458656e-01f,
  -1.43574163e-01f, -2.26510257e-01f, 3.69629561e-04f, -1.90061375e-01f, 4.25614536e-01f, 1.98545843e-01f, -6.20260499e-02f, -2.87514180e-01f, 1.46462247e-01f, -5.40385917e-02f,
  7.43083982e-03f, -2.16744363e-01f, 1.09075435e-01f, -8.59801769e-02f, -1.13788113e-01f, -1.52504668e-01f, -2.44185090e-01f, 9.76036191e-02f, -1.43567830e-01f, 2.15736385e-02f,
  -4.43691090e-02f, -1.49516165e-01f, -2.17983961e-01f, -7.08784536e-02f, 3.69254947e-02f, -1.26419356e-02f, -7.33575225e-02f, -1.89783499e-02f, 6.60364702e-02f, 2.02392694e-02f,
  -1.03397451e-01f, 5.20596430e-02f, -4.32030298e-02f, -4.36322242e-02f, -3.14577781e-02f, 3.10768280e-02f, 1.14907429e-01f, 1.53291076e-02f, 3.69263627e-02f, 2.50763118e-01f,
  1.16616853e-01f, 3.05322986e-02f, 1.26553953e-01f, 1.35147711e-02f, 1.15490414e-01f, 2.89752940e-03f, -2.72544217e-04f, 1.59048084e-02f, 3.26608457e-02f, 4.57044169e-02f,
  3.22773419e-02f, 9.56358239e-02f, -5.70662960e-04f, 4.16368619e-02f, -2.86217127e-02f, 4.60674986e-02f, -2.21581459e-02f, 1.84704885e-02f, -2.28311513e-02f, -3.99517827e-02f,
  2.10002623e-02f, -1.40180942e-02f, 5.92662916e-02f, 5.08973859e-02f, -4.28403281e-02f, -3.95250618e-02f, -9.35337469e-02f, -9.72813740e-02f, 3.16556506e-02f, 6.74547404e-02f,
  -3.75335142e-02f, 3.22976485e-02f, 6.73182905e-02f, -4.06094603e-02f, -6.16106810e-03f, 3.65272686e-02f, -8.73277187e-02f, 7.44085982e-02f, 2.32199840e-02f, -4.31152172e-02f,
  -2.59299070e-01f, -2.59441942e-01f, -1.16521619e-01f, -6.84752315e-02f, -7.22713768e-02f, -4.72177155e-02f, -9.96530205e-02f, 6.38169423e-02f, -4.18358669e-02f, -1.83904190e-02f,
  -1.07724294e-02f, -1.01850271e-01f, -3.01734209e-02f, 4.33712155e-02f, -5.84358871e-02f, 1.52185068e-01f, -1.69730693e-01f, -1.89321965e-01f, -1.78930208e-01f, -4.45079282e-02f,
  -1.04121000e-01f, -8.21953788e-02f, 7.56419823e-02f, -2.21877806e-02f, -2.74996925e-02f, -2.10074037e-02f, -2.24659722e-02f, 1.55334575e-02f, 7.03202114e-02f, 1.08449489e-01f,
  -5.21779001e-01f, 4.12349999e-01f, 1.30425289e-01f, 4.03026313e-01f, -3.59533638e-01f, -1.33226782e-01f, 2.53301293e-01f, 1.35259047e-01f, -6.88371528e-03f, 2.41006449e-01f,
  2.32741609e-01f, -9.03226212e-02f, 3.86022568e-01f, 3.82996857e-01f, 1.50954500e-01f, 3.37292075e-01f, 3.05727810e-01f, 1.55211821e-01f, 1.29269660e-01f, 1.46803275e-01f,
  1.85436204e-01f, 1.91980764e-01f, 3.83635163e-01f, -6.14082860e-03f, 8.15456435e-02f, -3.82112451e-02f, 2.04424471e-01f, -3.57719287e-02f, 1.32868096e-01f, -1.12310447e-01f,
  -5.72635718e-02f, -1.77931425e-03f, -1.14455037e-01f, -1.46606741e-02f, 7.08202124e-02f, -1.51323408e-01f, -1.81879718e-02f, -1.44018745e-02f, -4.24347073e-02f, 6.52109534e-02f,
  -3.85756493e-02f, -6.36448264e-02f, 1.46811446e-02f, -9.74835530e-02f, -1.74943626e-01f, -6.32392615e-02f, 2.77826451e-02f, -3.07632033e-02f, 6.67565018e-02f, -2.42965706e-02f,
  3.22685204e-02f, 6.67292252e-02f, 4.17229682e-02f, 1.04756951e-01f, 1.77549478e-02f, -1.12328064e-02f, 1.07639059e-02f, -7.33645409e-02f, -1.44903110e-02f, -4.24095951e-02f,
  -1.37692258e-01f, 3.80379595e-02f, 3.74701992e-02f, -1.60213013e-03f, 7.32342005e-02f, 5.87563142e-02f, -8.81278049e-03f, 3.52912098e-02f, -6.01641200e-02f, 8.13470483e-02f,
  2.17379164e-02f, -2.99809920e-03f, 5.45706181e-03f, 1.11215981e-03f, 2.61425041e-02f, 5.16101085e-02f, -1.46698253e-02f, -4.75093797e-02f, 9.83858332e-02f, 9.30363778e-03f,
  9.53241661e-02f, -9.96548980e-02f, 1.06406711e-01f, -3.21398377e-02f, -8.66916589e-03f, -3.12181818e-03f, 5.71115389e-02f, 3.09976730e-02f, 8.08134004e-02f, -1.22365206e-02f,
  1.44772500e-01f, 4.12697673e-01f, 6.69960901e-02f, 5.81918284e-05f, 5.05782589e-02f, -1.46151166e-02f, 4.45980094e-02f, -3.32904272e-02f, 1.00595206e-01f, 7.02665225e-02f,
  1.25756115e-02f, 4.59916256e-02f, 7.47836009e-02f, -4.95822355e-02f, 3.10826357e-02f, 1.27034366e-01f, 1.55167744e-01f, 1.30695358e-01f, 7.89838731e-02f, 9.09490660e-02f,
  8.42998251e-02f, -2.40275613e-03f, -4.10302244e-02f, -2.76037678e-02f, -9.15512368e-02f, 1.25249043e-01f, -1.28397971e-01f, -7.59209618e-02f, -1.58398375e-02f, 3.48422341e-02f,
  -5.40247321e-01f, 1.97083443e-01f, 6.38805553e-02f, -4.98105615e-01f, 3.20205927e-01f, 5.15647233e-01f, -5.32009825e-02f, 2.92684674e-01f, -1.38208136e-01f, 1.42903924e-01f,
  5.50974533e-02f, -2.71783113e-01f, 8.09233040e-02f, -2.49129906e-01f, -2.83207089e-01f, -1.46815613e-01f, -1.94345504e-01f, -9.45643783e-02f, -3.13336365e-02f, 5.74283935e-02f,
  -1.57249093e-01f, -6.38375655e-02f, -2.42323175e-01f, 3.19073617e-01f, -8.10571387e-02f, -1.22033022e-02f, 3.49095762e-02f, 1.61602870e-01f, -5.97002804e-02f, 4.13813666e-02f,
  -3.75904217e-02f, -7.66698644e-02f, 3.87617871e-02f, -2.13924404e-02f, 1.19819075e-01f, 3.32278386e-02f, 7.49413669e-02f, -1.09683191e-02f, -8.78628716e-02f, -3.78647968e-02f,
  -4.69384529e-02f, -6.31930605e-02f, -1.31858429e-02f, 1.07992655e-02f, -7.72722531e-04f, 2.74115559e-02f, -1.22715719e-01f, 2.41952832e-03f, 3.70771177e-02f, -2.50064339e-02f,
  -1.47360131e-01f, -3.44743431e-02f, 3.70199755e-02f, -1.47072062e-01f, -3.45541202e-02f, -2.07590796e-02f, -4.79886234e-02f, 4.18571644e-02f, -7.05005452e-02f, 4.03803177e-02f,
  2.73887292e-02f, 7.92606324e-02f, 6.15378357e-02f, -1.95498634e-02f, 2.76522767e-02f, -5.61216148e-05f, -3.38103212e-02f, 6.32687658e-03f, -9.39030945e-02f, 4.43646684e-03f,
  1.25924740e-02f, -2.63631269e-02f, -5.88865466e-02f, -1.22286810e-03f, -1.11875860e-02f, -1.06400803e-01f, -2.26215064e-03f, -4.30058241e-02f, -1.13276467e-01f, 1.93462111e-02f,
  2.17619203e-02f, -3.97316143e-02f, -2.82422751e-02f, -2.41228174e-02f, -6.10836186e-02f, -2.71705016e-02f, 1.39675632e-01f, -1.67011589e-01f, 1.37758814e-02f, 7.04796985e-02f,
  2.20230773e-01f, 2.62627423e-01f, 7.60404840e-02f, -5.43085858e-02f, 6.33546039e-02f, 9.89006683e-02f, 3.93453725e-02f, -2.51046512e-02f, 3.48068104e-04f, 1.30904585e-01f,
  1.29729345e-01f, 5.65702422e-03f, 9.98229384e-02f, -1.34796370e-02f, -8.52302983e-02f, 1.77833214e-01f, -1.38165787e-01f, -5.65478764e-02f, 4.47442494e-02f, 9.94293317e-02f,
  -5.12269698e-02f, 2.82096099e-02f, -4.58939523e-02f, 6.75569922e-02f, -6.85102725e-03f, -1.41048469e-02f, 9.35863256e-02f, -1.03677958e-01f, -3.75884064e-02f, 2.67003756e-02f,
  3.36057872e-01f, -7.65007436e-02f, -1.49601251e-01f, -3.33099514e-01f, -6.21216744e-02f, -1.54912442e-01f, -1.24636047e-01f, -3.22973907e-01f, -2.24296391e-01f, -3.06718588e-01f,
  -2.66325176e-01f, -2.64164042e-02f, 1.87791452e-01f, -2.83564419e-01f, 3.26553881e-01f, 3.68245542e-01f, -1.41890585e-01f, -1.73695162e-01f, 1.68803290e-01f, -1.42324328e-01f,
  2.94330865e-02f, -8.36846232e-02f, 2.46373236e-01f, -5.29606231e-02f, -8.57314467e-02f, -1.94999188e-01f, -1.00472249e-01f, -6.54075146e-02f, -3.91827732e-01f, -2.04260517e-02f,
  1.17798984e-01f, 1.48848861e-01f, 1.16121791e-01f, 1.04007363e-01f, 7.14840516e-02f, 4.37373519e-02f, 8.36543459e-03f, 2.96569541e-02f, 4.84996513e-02f, -5.35693206e-02f,
  2.73329373e-02f, 1.58900153e-02f, -1.57956362e-01f, 7.78156146e-02f, -6.22114586e-03f, -2.72780191e-02f, 7.17058107e-02f, 2.00628070e-03f, -8.67493078e-02f, 1.37660220e-01f,
  -4.94244136e-02f, -2.04484593e-02f, -2.13015247e-02f, 8.50115996e-03f, -4.22478467e-02f, -1.07889064e-01f, 4.57218401e-02f, -9.69180558e-03f, 5.32210805e-02f, -1.28297210e-01f,
  6.13701995e-03f, 9.58147645e-02f, 1.64708272e-01f, -4.34701890e-02f, 7.71661028e-02f, -6.29513636e-02f, -3.82527560e-02f, -7.98019022e-02f, 5.67823648e-02f, 5.15195578e-02f,
  -1.15670495e-01f, -1.97004750e-02f, 1.28374532e-01f, -2.92490572e-02f, -3.37344743e-02f, 4.07486670e-02f, 5.20991907e-02f, -4.85710576e-02f, -8.35403949e-02f, -1.78319469e-01f,
  -4.43980284e-02f, -5.06530050e-04f, 3.66196558e-02f, 3.73937041e-02f, -2.80869808e-02f, 3.32313552e-02f, -5.76981865e-02f, 2.06874218e-03f, 3.11994106e-02f, -1.67530030e-02f,
  6.92405365e-03f, -7.29012564e-02f, -1.39172506e-02f, 1.98542103e-02f, 4.92574908e-02f, 3.77510339e-02f, 8.11308697e-02f, -9.55965295e-02f, -2.44399887e-02f, 2.47978792e-02f,
  -1.12673365e-01f, -3.22425440e-02f, -1.14708342e-01f, -2.49360446e-02f, -2.93797385e-02f, -4.65397798e-02f, -3.52103412e-02f, -3.50718275e-02f, -9.85412076e-02f, -6.99270144e-02f,
  -7.22272024e-02f, 1.44021073e-02f, 6.88028261e-02f, -5.11467748e-04f, -6.86636344e-02f, -1.48247927e-01f, 1.03159405e-01f, -5.48801161e-02f, 2.73086280e-02f, -8.98958370e-02f,
  5.26862383e-01f, 5.55208176e-02f, 1.51726872e-01f, 3.17580938e-01f, 2.10025519e-01f, -1.44268617e-01f, -6.16337098e-02f, 9.70422626e-02f, 3.26394588e-01f, -1.51697680e-01f,
  -1.83829919e-01f, 1.38294980e-01f, -3.14432412e-01f, 6.32927567e-02f, -5.14273584e-01f, -3.37814778e-01f, -1.28916979e-01f, -7.99746066e-02f, 6.56023249e-02f, 3.25470679e-02f,
  5.35067134e-02f, -1.90864161e-01f, -1.65653024e-02f, 9.48107801e-04f, 3.48162830e-01f, 2.26488724e-01f, -3.41043293e-01f, -7.04674050e-02f, 9.06418189e-02f, -1.48885604e-02f,
  -2.28973664e-02f, 1.61829486e-01f, 1.78859547e-01f, -1.35812778e-02f, -3.59179713e-02f, -4.07190733e-02f, 4.22058068e-02f, -7.55878761e-02f, 3.72164883e-02f, 2.56468486e-02f,
  4.04386930e-02f, 2.38746703e-02f, 1.32351801e-01f, 9.22902487e-03f, 8.18624571e-02f, 1.54665604e-01f, 9.27246362e-02f, 8.44235793e-02f, 1.22044072e-01f, 1.55085891e-01f,
  7.43108988e-02f, 8.08280185e-02f, -2.94707576e-03f, -7.48347118e-02f, 1.97002292e-02f, 8.77622738e-02f, -8.27956386e-03f, -2.81080343e-02f, -6.48728237e-02f, 1.21874377e-01f,
  8.92548356e-04f, -1.54248118e-01f, -1.05664283e-01f, 9.37825441e-02f, -1.18902668e-01f, 9.52454954e-02f, -4.89532836e-02f, 4.63304445e-02f, -3.98974083e-02f, -7.37724677e-02f,
  3.26942429e-02f, 7.99516886e-02f, 8.83201957e-02f, -5.64886630e-03f, -3.18782777e-02f, 1.20426811e-01f, -1.43933808e-03f, -3.31999883e-02f, -3.25058065e-02f, 2.03181412e-02f,
  1.72057073e-03f, -5.11370786e-02f, 3.24154198e-02f, 7.86518306e-02f, -1.12312280e-01f, -9.28581432e-02f, 3.06243766e-02f, 1.23530239e-01f, 3.35240178e-03f, 1.05264196e-02f,
  -5.53526580e-01f, -5.25817931e-01f, -8.66323486e-02f, 1.39428541e-01f, -8.18741471e-02f, -1.19737007e-01f, 8.19176435e-02f, 9.54361260e-02f, -2.05935016e-01f, 1.39949974e-02f,
  -3.29795219e-02f, -2.23372895e-02f, -4.67939042e-02f, 4.83878888e-02f, -3.41997333e-02f, 1.55137191e-02f, -6.58666641e-02f, -1.03686899e-01f, -1.40453085e-01f, 2.71281637e-02f,
  6.29518703e-02f, 3.82332481e-03f, -8.35024193e-02f, 1.98488720e-02f, 3.53083499e-02f, 1.35137618e-03f, -6.32908335e-03f, 4.52971607e-02f, -1.51565000e-01f, 8.71892925e-03f,
  -3.53286922e-01f, -4.13656831e-01f, -1.07509241e-01f, 4.20117714e-02f, 2.29770362e-01f, -9.76606235e-02f, -1.50200441e-01f, -5.56909665e-02f, -5.37735559e-02f, -3.39704424e-01f,
  -2.47049645e-01f, -3.04962337e-01f, -4.35985565e-01f, -9.69607234e-02f, 1.63206294e-01f, -3.37630183e-01f, 1.60022408e-01f, 5.53629268e-03f, 5.01461290e-02f, 5.01808152e-02f,
  1.25422254e-01f, 1.14584386e-01f, 5.89970611e-02f, 3.08238029e-01f, -8.48220363e-02f, 3.48340899e-01f, 2.84348279e-01f, 2.52603799e-01f, 4.62199539e-01f, 1.25559285e-01f,
  1.81537624e-02f, -2.32296452e-01f, -1.16816416e-01f, 4.86439839e-02f, 1.14393011e-01f, 4.93022203e-02f, 1.32139534e-01f, 2.55866870e-02f, 2.01547861e-01f, -1.23050317e-01f,
  -1.23233825e-01f, 1.40602872e-01f, -5.87033331e-02f, -5.86983748e-02f, 1.20152786e-01f, 1.23324662e-01f, 7.88966343e-02f, -9.13965926e-02f, -2.35057101e-02f, -1.91762507e-01f,
  -1.37776941e-01f, -1.20618887e-01f, -3.67411785e-03f, 1.35184705e-01f, 2.97135245e-02f, 2.61028279e-02f, 6.83846772e-02f, -7.73342699e-03f, -6.92207590e-02f, 1.14037767e-01f,
  -9.00003407e-03f, -7.25375637e-02f, -5.98549172e-02f, -1.30979165e-01f, -2.52119005e-02f, 7.35524222e-02f, 3.03770918e-02f, -3.10599245e-02f, -9.62526165e-03f, -1.38328165e-01f,
  9.44675282e-02f, 3.62902991e-02f, 3.18263620e-02f, 8.38884190e-02f, -6.81450218e-03f, -9.11146998e-02f, 1.25111744e-01f, 6.77861199e-02f, 6.07335828e-02f, -7.41917267e-02f,
  -1.31104693e-01f, 5.20573817e-02f, 1.96129810e-02f, 1.27632171e-01f, 8.66737310e-03f, 2.30835062e-02f, 1.87211093e-02f, -5.63398143e-03f, -1.25519499e-01f, -1.00637190e-01f,
  1.34276569e-01f, 1.61180675e-01f, -8.24364647e-02f, 8.67260247e-02f, 3.43782827e-02f, -6.72872886e-02f, 1.13115661e-01f, 6.63621351e-02f, 1.78340584e-01f, -1.11224636e-01f,
  3.52538414e-02f, 6.24270104e-02f, -1.17248282e-01f, -1.10466024e-02f, 7.24016652e-02f, -9.05328244e-02f, 8.11012536e-02f, 1.79964751e-01f, 1.95044115e-01f, 6.82668686e-02f,
  -1.92384273e-02f, 6.26211017e-02f, -1.17930940e-04f, 1.04951464e-01f, -6.24960959e-02f, -4.03838493e-02f, -8.07845936e-05f, 2.01210715e-02f, 2.75352299e-02f, 3.86125669e-02f,
  -6.00757450e-02f, 5.18432438e-01f, 1.69353299e-02f, 2.16224581e-01f, -2.69667655e-01f, 4.39384431e-01f, 3.85607511e-01f, -4.49353866e-02f, 1.79305553e-01f, 4.27672088e-01f,
  -1.30139375e-02f, 3.96536216e-02f, 3.36518846e-02f, 3.67492586e-01f, -1.63408086e-01f, 3.49434346e-01f, 3.82536203e-01f, 2.91267455e-01f, -1.05643466e-01f, 3.17581557e-02f,
  -8.56904089e-02f, 6.29461110e-02f, -7.06176460e-02f, -1.85591146e-01f, -6.92364573e-02f, -1.60471857e-01f, -2.60010242e-01f, -2.78447062e-01f, 4.73439135e-02f, -1.37266055e-01f,
  5.81776425e-02f, -1.66783985e-02f, -1.52456658e-02f, 1.39979556e-01f, 1.19027957e-01f, 3.64052281e-02f, -4.02726755e-02f, -6.70197830e-02f, -1.98419303e-01f, 2.41161231e-02f,
  7.81461298e-02f, -7.17559755e-02f, 1.01971172e-01f, -1.36328787e-01f, 6.06180122e-03f, 8.87993537e-03f, 2.32214052e-02f, -2.52290964e-02f, -3.37609136e-03f, -2.29590088e-02f,
  3.96697968e-02f, 6.17728103e-03f, 3.00557762e-02f, 1.14019543e-01f, -1.20541774e-01f, -2.73322221e-02f, 1.52058005e-01f, -2.42241416e-02f, 8.11104625e-02f, 5.32530360e-02f,
  -4.23350111e-02f, 5.76473139e-02f, 1.08076647e-01f, 3.43339681e-03f, 1.91532701e-04f, -1.59628969e-03f, 2.49495320e-02f, -5.39269894e-02f, -4.42442894e-02f, -2.80527689e-04f,
  1.87586583e-02f, -9.23455209e-02f, 2.91589256e-02f, 5.30241989e-02f, -5.91607112e-03f, 1.27415415e-02f, -4.01543686e-03f, -2.27938760e-02f, 3.41102225e-03f, -1.44070294e-02f,
  -3.76508571e-02f, 3.53411213e-03f, 1.07079661e-02f, -1.26544051e-02f, 7.64340684e-02f, -8.57943296e-02f, -2.21119151e-02f, -1.47007480e-02f, -3.49673517e-02f, -8.88987109e-02f,
  1.75436810e-01f, 1.88695356e-01f, 2.43767407e-02f, -5.32016158e-03f, 5.01884185e-02f, 8.13850760e-02f, -2.17782166e-02f, 1.09151274e-01f, 5.35269938e-02f, 4.25926335e-02f,
  -4.17591725e-03f, 5.01981191e-02f, 5.45775071e-02f, -1.21797301e-01f, -4.17591780e-02f, 1.88589558e-01f, 8.27015936e-02f, -5.70994839e-02f, -1.62462592e-02f, -8.22118074e-02f,
  -5.46470433e-02f, 8.26684013e-02f, 2.36711279e-02f, 3.86893414e-02f, 5.69326393e-02f, -1.30263986e-02f, -2.17424426e-03f, -8.58129188e-02f, -3.91230136e-02f, 8.01936686e-02f,
  2.84769118e-01f, -6.83442727e-02f, -2.68588364e-01f, -2.37644345e-01f, -2.86897086e-02f, -4.22308117e-01f, -3.98543060e-01f, -2.62597710e-01f, -1.57348007e-01f, 1.33585498e-01f,
  -1.83744669e-01f, 1.64091378e-01f, 4.23961468e-02f, -3.94543171e-01f, -5.03744781e-01f, -1.36657894e-01f, -3.81819963e-01f, -1.06224954e-01f, -3.38282660e-02f, -6.81896359e-02f,
  -1.10192008e-01f, -2.79017061e-01f, -3.36116910e-01f, -2.61833649e-02f, -6.20828383e-02f, 1.55318752e-01f, 1.70383364e-01f, 5.16120121e-02f, -8.96116123e-02f, -1.48405820e-01f,
  -5.81360608e-02f, -9.12018716e-02f, -9.15175378e-02f, -1.87200271e-02f, -7.01821735e-03f, 7.52288401e-02f, 1.12282373e-01f, -1.68082878e-01f, -6.91056773e-02f, -9.31765046e-03f,
  1.31818593e-01f, 5.87592311e-02f, -1.23592906e-01f, 4.52054441e-02f, 1.28348202e-01f, -3.50836329e-02f, -1.17916008e-02f, 8.64474848e-02f, -4.78174463e-02f, 6.10534549e-02f,
  -7.48249739e-02f, 1.23400174e-01f, 7.25623742e-02f, 1.16433553e-01f, 3.83208059e-02f, -6.21491037e-02f, -2.75835376e-02f, 1.08062774e-01f, 1.15193591e-01f, 5.15856966e-02f,
  5.03540523e-02f, 1.99344337e-01f, -2.66020875e-02f, 1.34201813e-02f, -3.09468545e-02f, -1.21081071e-02f, 1.96647830e-02f, 7.16528594e-02f, 4.36228402e-02f, -1.06419493e-02f,
  -1.29208677e-02f, -2.92912424e-02f, -8.39728713e-02f, -1.62692498e-02f, 5.73426299e-02f, 6.93046302e-02f, 9.62813720e-02f, 4.54141423e-02f, -2.33503822e-02f, -6.28763959e-02f,
  1.51293194e-02f, -3.12246084e-02f, -1.51870586e-02f, 8.84889215e-02f, -1.14158347e-01f, 3.10331117e-02f, 2.72617191e-02f, -4.96427063e-04f, -3.86880152e-02f, -4.99635711e-02f,
  -2.70247255e-02f, -1.37549594e-01f, -8.12698975e-02f, -1.01774912e-02f, -4.24436219e-02f, 3.46462876e-02f, -6.40929565e-02f, -1.09989628e-01f, -6.73175789e-03f, -2.23137587e-02f,
  1.50548398e-01f, 8.55938494e-02f, 1.60688892e-01f, 8.91437158e-02f, -2.55441014e-02f, -1.43626481e-01f, 2.92922743e-02f, 8.60571340e-02f, 5.11317551e-02f, 9.70032513e-02f,
  9.72323567e-02f, 7.73708150e-02f, 2.26924364e-02f, 3.60470940e-03f, 5.31109944e-02f, 6.19432405e-02f, 7.00765774e-02f, 2.83693373e-02f, 1.26571864e-01f, 7.01664016e-02f,
  4.36574101e-01f, 1.16782505e-02f, -9.81028825e-02f, 2.41381973e-01f, 2.39031941e-01f, 4.53903109e-01f, 2.41306722e-01f, 3.23102027e-01f, 5.13585985e-01f, -3.64253158e-03f,
  8.92336965e-02f, -1.25451609e-01f, -2.03455329e-01f, 2.30039716e-01f, 1.14131205e-01f, 2.61875987e-02f, 3.80616665e-01f, 1.06983468e-01f, 2.24678263e-01f, 2.10176334e-01f,
  1.45510331e-01f, 1.60316095e-01f, -3.64227355e-01f, -1.38355836e-01f, 8.66060555e-02f, -6.05496280e-02f, -3.15600127e-01f, -2.54222810e-01f, -2.18875006e-01f, 3.19224410e-02f,
  5.92999123e-02f, 2.29474064e-02f, -2.04556748e-01f, -1.12148426e-01f, 3.07924263e-02f, -4.13162559e-02f, -7.25692064e-02f, -1.64906695e-01f, -1.18820012e-01f, -1.57531016e-02f,
  1.13766706e-02f, -4.70737033e-02f, 1.04961149e-01f, 4.51301150e-02f, 1.72530226e-02f, -5.34182638e-02f, 1.50836771e-02f, 7.11221248e-02f, -9.80525464e-02f, -6.49809763e-02f,
  -6.42527714e-02f, -2.92721763e-02f, 1.14170432e-01f, 7.29994997e-02f, -3.05575188e-02f, 5.46112023e-02f, 6.61954209e-02f, -5.41381240e-02f, -1.40156457e-02f, 7.91455954e-02f,
  -1.77780222e-02f, 7.34021291e-02f, -3.15431170e-02f, -6.14382997e-02f, 5.33889048e-02f, 7.17818458e-03f, 4.90827821e-02f, -6.27604350e-02f, 1.55938089e-01f, 5.34208603e-02f,
  3.25131640e-02f, 6.50867745e-02f, 1.51406169e-01f, -1.12583796e-02f, 1.32426500e-01f, 1.08088017e-01f, 4.16268269e-03f, 1.52522624e-01f, 1.09630212e-01f, 1.66504234e-02f,
  -4.19253372e-02f, 2.50796285e-02f, -1.38786361e-01f, -7.68838823e-02f, -5.53381816e-02f, -7.83333704e-02f, 3.40001397e-02f, 1.07583448e-01f, -7.56116072e-03f, 2.24070605e-02f,
  1.75700217e-01f, 2.35273615e-01f, -6.15601353e-02f, -8.28768387e-02f, -9.57646370e-02f, 3.93008105e-02f, 2.47833431e-02f, 5.11161834e-02f, 8.99870396e-02f, 3.03193405e-02f,
  7.42261484e-02f, 8.23079050e-02f, -5.75608276e-02f, 3.44179124e-02f, -6.88660219e-02f, 1.41309602e-02f, -3.95251997e-02f, 6.15772270e-02f, 7.78039098e-02f, -5.16396686e-02f,
  -1.49780750e-01f, 5.50406389e-02f, 4.40478185e-03f, 1.11870259e-01f, 4.88668047e-02f, -3.91701274e-02f, 9.99683440e-02f, -1.91234443e-02f, -2.40696482e-02f, 4.00505662e-02f,
  1.07945159e-01f, 2.05523655e-01f, -1.69894606e-01f, -2.10691661e-01f, -1.39394570e-02f, 3.45551036e-02f, 3.74616422e-02f, -6.32483587e-02f, -2.33140975e-01f, 3.38892788e-01f,
  -5.97262010e-02f, 1.18455298e-01f, -7.96185136e-02f, -1.99852154e-01f, -4.91435885e-01f, -3.56401533e-01f, -1.29293099e-01f, 9.27127972e-02f, -1.21199943e-01f, 2.74922639e-01f,
  -1.62071675e-01f, -5.96598014e-02f, -3.09873730e-01f, 1.25320539e-01f, 1.56437054e-01f, 1.82706296e-01f, -3.23807932e-02f, -2.97009554e-02f, 1.08403347e-01f, -1.49234101e-01f,
  3.76711460e-03f, -2.73254253e-02f, 8.46855417e-02f, -3.25478353e-02f, 2.66550551e-03f, 1.02287658e-01f, 1.65130451e-01f, -1.37593716e-01f, -9.97216776e-02f, -3.23746353e-02f,
  1.45818844e-01f, -2.08310951e-02f, 1.19872130e-02f, -1.19534984e-01f, 1.60956532e-01f, 7.23662553e-03f, 2.44648010e-02f, -8.34094360e-03f, -8.33426486e-04f, -1.76803097e-02f,
  2.26930883e-02f, -4.26414795e-02f, 2.20676698e-02f, -5.88355139e-02f, -7.52481744e-02f, -3.16110179e-02f, 5.14459349e-02f, 7.15769781e-03f, 4.49500605e-02f, -8.03930461e-02f,
  -2.78811473e-02f, 8.57033730e-02f, -1.06264437e-02f, -1.41299199e-02f, -6.34122342e-02f, -8.66203606e-02f, 5.78722246e-02f, -2.28235852e-02f, -7.76507845e-03f, 8.33746791e-02f,
  -1.89874861e-02f, 4.19904962e-02f, 1.34820938e-02f, 1.11621141e-01f, -8.26355293e-02f, 3.77847394e-03f, 3.09057478e-02f, 3.70344557e-02f, -6.39884174e-02f, -9.12846401e-02f,
  -3.67757566e-02f, 4.72078584e-02f, 4.83594686e-02f, 7.71587268e-02f, -1.04734320e-02f, -1.07165370e-02f, 8.16641599e-02f, 1.49429711e-02f, -1.48348259e-02f, 2.09684186e-02f,
  -7.09209815e-02f, -1.25012949e-01f, -2.76772119e-02f, 3.12569737e-02f, 2.83890776e-02f, 2.09025498e-02f, -4.07606997e-02f, 5.68632316e-03f, -2.86250487e-02f, -3.04003730e-02f,
  4.63749543e-02f, 7.08062723e-02f, 8.84695798e-02f, -4.58226465e-02f, 1.65482203e-03f, -2.20352188e-02f, 1.01649471e-01f, 3.55550125e-02f, -8.18141401e-02f, 5.83925247e-02f,
  9.66942459e-02f, 1.42156854e-01f, -1.82448849e-02f, 4.59486693e-02f, 6.41992614e-02f, 7.00683985e-03f, 8.51786658e-02f, 4.68570963e-02f, -3.35489661e-02f, 1.27808340e-02f,
  3.47686410e-01f, 2.14805808e-02f, 4.18462306e-01f, 9.92260650e-02f, -1.58644244e-01f, 1.40111387e-01f, 1.70859113e-01f, -5.18639088e-02f, 2.45364010e-01f, -3.19067031e-01f,
  -3.08418989e-01f, 2.65045196e-01f, 1.05263025e-01f, -2.25361392e-01f, 5.03733933e-01f, 3.16452235e-01f, 7.57910833e-02f, -1.43328542e-02f, 8.92291069e-02f, -1.89703584e-01f,
  -8.85811299e-02f, -4.95449990e-01f, -1.55285969e-01f, -3.87892753e-01f, -4.11065578e-01f, -1.60205185e-01f, -3.39190483e-01f, -2.98962221e-02f, -3.47096056e-01f, 1.56244142e-02f,
  -2.18560144e-01f, -8.77327546e-02f, -2.22642124e-02f, 1.25610128e-01f, -1.45657688e-01f, 4.27816659e-02f, 6.60976097e-02f, 1.29721239e-01f, 3.04928012e-02f, 3.15437652e-02f,
  -7.01452792e-03f, -5.56782112e-02f, -1.25294611e-01f, 4.44900766e-02f, 2.41363887e-02f, -5.31443357e-02f, -5.85354753e-02f, -7.95439705e-02f, -5.58749698e-02f, 1.03723586e-01f,
  7.55669326e-02f, -5.91225747e-04f, -3.39279659e-02f, 2.37691943e-02f, 1.36681706e-01f, 7.24914074e-02f, 1.44156311e-02f, 1.15344577e-01f, -7.55644217e-03f, 8.65991563e-02f,
  6.71469048e-02f, 1.22526690e-01f, -1.18615469e-02f, -1.09069332e-01f, -1.50720432e-01f, -2.34359413e-01f, -4.33337241e-02f, -1.05689503e-01f, -1.60620790e-02f, -1.02347896e-01f,
  -1.17764369e-01f, 6.33990392e-02f, -2.05556508e-02f, 3.71835232e-02f, -1.03656635e-01f, -2.28050202e-02f, 1.31010309e-01f, -1.64740290e-02f, 3.10385376e-02f, 2.82993410e-02f,
  -5.41120209e-02f, 8.20103511e-02f, 1.42033002e-03f, -1.54154999e-02f, 3.20223086e-02f, 1.61726754e-02f, 1.28593785e-03f, 1.51691132e-03f, 1.02544606e-01f, -6.26282301e-03f,
  -1.09624408e-01f, -8.08985680e-02f, -1.50448782e-02f, -3.41273821e-03f, -5.10752909e-02f, -4.06780466e-03f, -1.32202227e-02f, 6.25126529e-03f, 3.56446877e-02f, 1.85012873e-02f,
  -5.31128384e-02f, -1.32016297e-02f, 3.11475508e-02f, 7.10425079e-02f, 2.34847777e-02f, -1.55420573e-02f, 4.29745577e-02f, 2.50024814e-02f, 3.70849855e-02f, -3.76968533e-02f,
  -7.89033920e-02f, 2.59195082e-02f, -9.11290044e-05f, -6.75703436e-02f, 5.67712113e-02f, 4.89620259e-03f, 6.95563629e-02f, 7.81264678e-02f, -3.14488523e-02f, -4.32119295e-02f,
  1.74721673e-01f, 5.62261581e-01f, 3.90955091e-01f, 3.60717714e-01f, -2.79729456e-01f, -2.21916325e-02f, 5.38715310e-02f, -1.44113466e-01f, -5.90486676e-02f, 1.12467617e-01f,
  -1.41913012e-01f, 3.44913274e-01f, -2.09728748e-01f, 2.25041941e-01f, 3.20415497e-02f, -9.78470668e-02f, 2.14456201e-01f, 1.05280980e-01f, -1.30159020e-01f, 6.14055134e-02f,
  -3.28259170e-02f, -5.22029167e-03f, 8.11863989e-02f, -6.40591308e-02f, 2.22286820e-01f, 2.81768620e-01f, 8.56938362e-02f, 5.52739669e-03f, 3.67646694e-01f, -3.65550555e-02f,
  -4.94475067e-02f, -1.01877777e-02f, -1.35576101e-06f, 5.19026481e-02f, 1.94375850e-02f, -3.37836780e-02f, 1.04407549e-01f, 9.83477943e-03f, -9.44193825e-02f, -1.97683536e-02f,
  6.84664994e-02f, -8.57084990e-02f, 1.30030930e-01f, 1.28451660e-02f, -4.89420816e-02f, 4.78867330e-02f, 6.57587051e-02f, 7.62799606e-02f, 6.67351931e-02f, 3.09980921e-02f,
  9.74863395e-02f, -5.85476868e-03f, 3.50830182e-02f, 1.48198470e-01f, 1.32606179e-02f, 1.85620096e-02f, 1.90976381e-01f, 1.17629893e-01f, 2.01744139e-01f, 3.62122804e-02f,
  2.45403219e-02f, 5.43151796e-02f, 7.03859329e-02f, -1.68547425e-02f, -2.90534962e-02f, -1.09208807e-01f, -7.47063830e-02f, -7.99677670e-02f, 1.11627358e-03f, -3.60914171e-02f,
  -4.57298234e-02f, 4.72106636e-02f, -3.21944132e-02f, -5.86505383e-02f, 3.84707451e-02f, 1.19344071e-02f, -7.55859688e-02f, 5.41747957e-02f, 6.70077186e-03f, -2.66899634e-02f,
  -1.03728704e-01f, 8.41420293e-02f, -2.83326749e-02f, -4.77587245e-02f, -8.16375297e-03f, -6.27895724e-03f, 7.00949058e-02f, 8.14373866e-02f, -1.03298947e-01f, -4.75951880e-02f,
  2.21359000e-01f, 3.32320005e-01f, -3.29854414e-02f, -1.15796611e-01f, 6.10110052e-02f, 9.37325284e-02f, -1.76142696e-02f, 1.38232559e-01f, 1.89371884e-01f, -7.07017165e-03f,
  3.35380472e-02f, 1.52069479e-02f, -2.91597228e-02f, -3.90687436e-02f, 3.43247131e-02f, 6.36984780e-02f, -2.98939012e-02f, -1.29916230e-02f, 2.42892522e-02f, 9.38682854e-02f,
  -2.74427030e-02f, -1.07187545e-02f, -7.05243871e-02f, -8.57076302e-05f, 5.26721217e-02f, 1.08407214e-02f, -8.28632154e-03f, -3.42674032e-02f, 8.33616871e-03f, 7.50886649e-02f,
  -6.54553831e-01f, 7.49217153e-01f, 2.83181340e-01f, -2.19820455e-01f, -6.00717179e-02f, 1.20931849e-01f, -2.14225143e-01f, 1.88461542e-01f, 1.19764656e-02f, 2.56540298e-01f,
  -2.08124459e-01f, 3.70398462e-01f, 1.87276810e-01f, 8.53564497e-03f, -2.55216300e-01f, 1.96814969e-01f, -4.93022799e-02f, -3.95663418e-02f, 8.65038410e-02f, -8.07363167e-02f,
  -8.56395289e-02f, -3.33566189e-01f, -2.75451764e-02f, 8.11393782e-02f, -7.21858293e-02f, -2.90622804e-02f, -3.83653194e-01f, -6.41723499e-02f, -1.36717409e-01f, -8.50294679e-02f,
  -2.34463662e-01f, -9.15965363e-02f, -3.95917222e-02f, -7.97244627e-03f, -6.75046593e-02f, -3.93045396e-02f, -1.53896615e-01f, 1.34549467e-02f, -3.80042605e-02f, 3.68357189e-02f,
  5.70288748e-02f, 1.93121564e-02f, -3.16749252e-02f, 3.34023312e-02f, -6.09001936e-03f, -2.83105411e-02f, 1.47272691e-01f, 6.55179173e-02f, 4.23264764e-02f, 7.79360831e-02f,
  1.64967880e-01f, 1.73680652e-02f, -8.71070325e-02f, -3.42862457e-02f, -1.06883131e-01f, -3.69691364e-02f, -5.26458658e-02f, -5.85132316e-02f, 4.22189496e-02f, -4.02890444e-02f,
  -4.95131984e-02f, -2.16238201e-02f, 4.46822196e-02f, -4.87933233e-02f, 1.26777485e-01f, 1.63134781e-03f, 5.97244911e-02f, -1.25148714e-01f, 1.18510211e-02f, -6.69037402e-02f,
  -1.27478033e-01f, 3.87044176e-02f, -4.30096947e-02f, 4.69232118e-03f, -1.96449365e-02f, 4.20868248e-02f, -3.63416912e-04f, -3.72716528e-03f, 1.44889504e-02f, 1.40940659e-02f,
  -6.90579787e-02f, -5.18553630e-02f, -1.98837537e-02f, -1.49272038e-02f, 3.23990136e-02f, -3.24398465e-02f, -1.41382432e-02f, 1.17975324e-01f, 1.05427541e-02f, -1.35076582e-01f,
  -3.03555876e-01f, -2.83890367e-01f, -1.23991020e-01f, 1.62961595e-02f, 1.37304086e-02f, 1.86680909e-02f, -2.93722115e-02f, -3.45361605e-02f, -3.51593271e-02f, -4.76191714e-02f,
  3.01934383e-03f, 5.85221872e-02f, -1.25393808e-01f, 3.60613018e-02f, 6.22977912e-02f, 2.77928333e-03f, -4.71822247e-02f, -4.93513756e-02f, -1.01604834e-01f, -3.54476981e-02f,
  -2.43052673e-02f, 7.57056009e-03f, -2.51758407e-04f, -6.87637925e-02f, -3.48411277e-02f, -1.09378435e-01f, 2.90740710e-02f, 1.29874915e-01f, -7.52681568e-02f, 2.33313944e-02f,
  2.25928679e-01f, 8.95881578e-02f, -1.84130549e-01f, -2.59017438e-01f, 2.17136815e-01f, 4.78863090e-01f, 3.10269445e-01f, -1.52569905e-01f, -3.55883449e-01f, 2.75805388e-02f,
  2.80051857e-01f, -2.20587268e-01f, 3.14568281e-01f, 1.86425805e-01f, 2.78907478e-01f, 3.03460181e-01f, 1.11739561e-01f, 9.80179533e-02f, -7.28345942e-03f, 5.46222320e-04f,
  -5.09771425e-03f, 3.02813768e-01f, 2.39770055e-01f, -3.66167799e-02f, 3.63032997e-01f, -1.72282860e-01f, 4.83548567e-02f, 7.45177567e-02f, -1.29759058e-01f, 7.17583150e-02f,
  1.72530800e-01f, -9.13109258e-02f, 3.76807265e-02f, -7.61777908e-02f, 1.54103056e-01f, 9.12622735e-02f, 4.68137152e-02f, 8.48716050e-02f, -7.79973194e-02f, 2.77478099e-02f,
  -3.46351154e-02f, -1.85834169e-01f, -1.10194609e-01f, -2.71083391e-03f, 2.05287337e-02f, -1.10930756e-01f, 8.13250523e-03f, 5.49551249e-02f, -8.87891874e-02f, 1.05548494e-01f,
  9.87903252e-02f, -5.47025390e-02f, -5.92784733e-02f, -1.00066863e-01f, -3.07133850e-02f, -6.05817363e-02f, -5.90737350e-02f, 8.57887715e-02f, -4.83349934e-02f, -5.70823513e-02f,
  -7.55762728e-03f, 1.53144067e-02f, 1.10237248e-01f, 5.01064546e-02f, 6.15935437e-02f, 1.10062361e-02f, 3.95236872e-02f, 4.18399610e-02f, -4.29150015e-02f, 6.68976381e-02f,
  -9.08776075e-02f, -2.69578751e-02f, -6.18645996e-02f, -3.57446186e-02f, 4.31866609e-02f, -1.21627912e-01f, 1.61183532e-02f, 4.51371036e-02f, -6.87070489e-02f, 8.30831081e-02f,
  -4.41634282e-02f, -2.03810651e-02f, 1.13435306e-01f, -6.04947023e-02f, -5.40253632e-02f, 7.16286227e-02f, -3.34914178e-02f, 6.21177070e-02f, 4.59660143e-02f, 5.71647435e-02f,
  6.84245750e-02f, -1.97995603e-01f, -2.00274941e-02f, -1.08973078e-01f, 1.52293248e-02f, 1.55786231e-01f, 2.91934237e-02f, 5.80642978e-03f, 2.17147544e-02f, 3.83630991e-02f,
  -8.51429254e-02f, -2.66162939e-02f, -5.49308881e-02f, -5.28575182e-02f, -8.10887963e-02f, 4.86958511e-02f, -3.44978534e-02f, -8.09723735e-02f, -9.63681936e-02f, -9.14053917e-02f,
  9.14532878e-03f, 2.27754489e-02f, -9.93785486e-02f, 7.98392743e-02f, -5.88563643e-02f, -2.38589775e-02f, 1.20318457e-02f, -1.40398070e-01f, -2.30307039e-03f, -9.06689316e-02f,
  2.22463652e-01f, 1.74180090e-01f, 1.74893722e-01f, 3.25681865e-01f, 9.95400324e-02f, -3.55558008e-01f, 5.80695048e-02f, 1.85190335e-01f, 2.45927781e-01f, -5.47814704e-02f,
  -1.17496327e-01f, 4.17698473e-02f, -1.36400163e-01f, -2.09230751e-01f, -4.16063458e-01f, -4.82604146e-01f, 4.22699079e-02f, -7.86021054e-02f, -4.26021814e-02f, 2.02158868e-01f,
  1.61366150e-01f, -1.88569948e-01f, 3.35774422e-01f, 6.98583201e-02f, 2.20459178e-01f, 3.54505599e-01f, 1.76403284e-01f, 1.63890105e-02f, 1.41941294e-01f, -3.08323801e-01f,
  1.10624256e-02f, 5.72575592e-02f, 1.15313858e-01f, -4.86059822e-02f, 2.22840279e-01f, 7.86741376e-02f, 5.97359566e-03f, -1.51068687e-01f, 1.30478010e-01f, 8.58019814e-02f,
  8.35817680e-02f, -8.22361186e-02f, -1.31055683e-01f, -1.37743264e-01f, 7.05795065e-02f, 8.90400186e-02f, 3.92795599e-04f, 1.34025335e-01f, 5.23843057e-02f, -5.42397685e-02f,
  2.17845678e-01f, -1.72944888e-02f, 4.39421386e-02f, -9.29180458e-02f, 4.27069180e-02f, -6.39074147e-02f, -4.43261079e-02f, 9.29595903e-02f, 6.69875965e-02f, 3.36434469e-02f,
  -1.23746529e-01f, 3.43552120e-02f, 6.11300096e-02f, 1.49894673e-02f, -4.35075425e-02f, 1.23381749e-01f, -7.13935867e-02f, -6.40096813e-02f, 4.45238315e-02f, -8.69355202e-02f,
  9.78452638e-02f, 3.45910825e-02f, -5.56842126e-02f, 9.28956922e-03f, 6.42991811e-02f, 2.34025028e-02f, -5.39389923e-02f, -1.64692953e-01f, 1.29682377e-01f, 9.38004330e-02f,
  -9.70903412e-02f, -6.56018704e-02f, 8.26858282e-02f, 6.46988675e-02f, -5.85100912e-02f, 8.49982649e-02f, -6.69316500e-02f, 2.14957856e-02f, 1.05752870e-01f, -6.67839795e-02f,
  1.24186024e-01f, -1.02261961e-01f, 1.37063697e-01f, -6.35081828e-02f, -4.30911686e-03f, -9.54400599e-02f, -1.50924906e-01f, -6.34736419e-02f, 6.59763301e-03f, -1.62511840e-01f,
  8.03351104e-02f, 1.40965253e-01f, -4.33012806e-02f, -1.17399298e-01f, -6.79139271e-02f, -7.60137662e-03f, 7.89143816e-02f, 5.58580607e-02f, 6.04598112e-02f, -2.31017405e-03f,
  1.48484021e-01f, 1.32476941e-01f, 7.37528950e-02f, 1.25061750e-01f, -2.40208320e-02f, 5.41185737e-02f, -4.78843674e-02f, 6.38196096e-02f, -2.78853532e-02f, -1.21097110e-01f,
  -7.00674415e-01f, 1.85042053e-01f, 5.47090590e-01f, -2.89434493e-01f, -2.00703159e-01f, 3.75791669e-01f, 8.72244760e-02f, 8.67314637e-02f, -4.05441493e-01f, 3.32273431e-02f,
  -8.74788314e-02f, -1.05803102e-01f, 6.16950989e-02f, 1.61424756e-01f, 4.37280349e-02f, 4.98501584e-02f, 1.66226774e-01f, 1.30967304e-01f, -2.99903974e-02f, -7.12518394e-02f,
  -3.87872122e-02f, -1.83672175e-01f, 2.94800937e-01f, -2.64941016e-03f, 5.40909283e-02f, -4.79309484e-02f, -1.16897479e-01f, 3.04175783e-02f, 1.34052813e-01f, 1.02157593e-01f,
  -1.14516668e-01f, -2.96901643e-01f, -9.60721914e-03f, 1.31453156e-01f, 9.16223302e-02f, 6.97020022e-03f, 1.35882258e-01f, -1.33940745e-02f, -1.05630405e-01f, 3.88955027e-02f,
  -1.36420699e-02f, -4.16402565e-03f, -8.68040770e-02f, -3.15871015e-02f, -4.78554815e-02f, 7.28686014e-03f, 1.16484106e-01f, 1.02413408e-01f, 6.65321946e-02f, 1.16582066e-01f,
  2.30908338e-02f, 1.65618137e-01f, 1.49307430e-01f, 8.64429176e-02f, 5.49559668e-02f, 5.23727611e-02f, 1.42999917e-01f, 5.99604324e-02f, 3.56230661e-02f, -3.94412950e-02f,
  8.51626545e-02f, -2.04624888e-02f, -5.03027178e-02f, -2.74189301e-02f, -1.17154263e-01f, 7.77482539e-02f, -1.79040749e-02f, -5.13578989e-02f, 2.75685731e-02f, 5.68522513e-02f,
  -4.29671220e-02f, -1.73453502e-02f, 6.28614649e-02f, 4.80143875e-02f, -5.96336909e-02f, -5.39657883e-02f, 7.31913447e-02f, 4.32564281e-02f, -4.62881438e-02f, 2.52995752e-02f,
  -6.41386881e-02f, 3.91013734e-03f, -8.75864085e-03f, 3.49351019e-02f, 3.38844620e-02f, 4.23038751e-02f, 6.87939078e-02f, 6.94770813e-02f, 5.01043834e-02f, 2.19952073e-02f,
  -3.91968012e-01f, -4.35868800e-01f, -7.02693313e-02f, -8.31901282e-02f, -4.91735339e-02f, 3.99257988e-02f, 6.26495630e-02f, -7.85155036e-03f, -3.95367295e-02f, -6.59955516e-02f,
  2.65592374e-02f, 5.57805561e-02f, 4.24641296e-02f, -1.21885194e-02f, 1.01653002e-02f, -2.43560039e-02f, -1.51589915e-01f, -1.29913062e-01f, -7.31194541e-02f, -5.57923429e-02f,
  3.49800452e-03f, -1.37566358e-01f, 7.38590723e-03f, -8.33866745e-03f, 5.47028985e-03f, -1.05480857e-01f, -1.81951404e-01f, -2.95465589e-02f, -2.69541424e-02f, -1.28166680e-03f,
  1.66080222e-01f, -1.34382956e-02f, -3.77606988e-01f, -5.34412451e-02f, 7.34743616e-03f, -1.52597046e-02f, -1.95850223e-01f, 1.30104795e-01f, -2.90021867e-01f, 2.39559039e-01f,
  2.11390585e-01f, -4.20748666e-02f, -2.03038469e-01f, 5.23074746e-01f, 3.05218965e-01f, -2.46164855e-02f, 4.54621643e-01f, 2.23195061e-01f, 8.71235784e-03f, 2.29747966e-01f,
  2.36484960e-01f, 5.81271350e-01f, 1.14011392e-01f, 4.63415772e-01f, 2.89834917e-01f, -1.38616690e-03f, 2.96738327e-01f, -9.87130851e-02f, 4.10482913e-01f, 1.80512235e-01f,
  4.42870818e-02f, 1.95377823e-02f, -5.03792204e-02f, -4.99702245e-02f, 1.22612473e-02f, -5.60920238e-02f, -2.03951541e-02f, -8.33459124e-02f, -7.63147473e-02f, 3.69228683e-02f,
  -1.34631306e-01f, 7.50741810e-02f, 8.37999955e-02f, -9.14808959e-02f, -5.86972423e-02f, -5.52126840e-02f, 6.86191441e-03f, -9.47186723e-02f, -7.27631226e-02f, 1.31728901e-02f,
  -1.74644992e-01f, -4.40539345e-02f, -5.49570844e-02f, -2.10434012e-02f, -8.80462006e-02f, -7.68206418e-02f, -8.98604989e-02f, -3.46762240e-02f, 1.73152797e-02f, 2.86965817e-02f,
  1.23141035e-01f, -1.50448764e-02f, -3.66736352e-02f, 2.21412219e-02f, -4.63742949e-02f, 4.98931482e-03f, 2.99111474e-02f, 6.28162250e-02f, -2.92854626e-02f, 5.92575260e-02f,
  4.51854430e-02f, -1.58300754e-02f, 1.20302979e-02f, -2.38533411e-02f, 6.30337223e-02f, 2.14870237e-02f, -1.53684383e-02f, 5.99873886e-02f, -7.67084062e-02f, 5.04136272e-02f,
  -3.17568635e-03f, -5.05657308e-02f, 6.62531778e-02f, 3.56338322e-02f, 4.94226664e-02f, -2.16741897e-02f, 1.33832201e-01f, 8.71103108e-02f, -4.11777943e-02f, -3.88650130e-03f,
  1.49446785e-01f, 1.93186164e-01f, -7.74291307e-02f, -5.90119176e-02f, -4.03976589e-02f, 1.20422296e-01f, 1.26722213e-02f, 4.56211763e-03f, 5.18458374e-02f, -1.29445689e-02f,
  9.64689534e-03f, -8.38506892e-02f, 1.78415030e-02f, 2.07549566e-03f, 3.88439484e-02f, 8.10738429e-02f, -1.17620891e-02f, -1.41491160e-01f, -9.19368677e-03f, 1.05523027e-01f,
  6.51186006e-03f, -8.65383074e-03f, 1.98316611e-02f, -1.45229548e-01f, 1.31318569e-02f, -2.61087511e-02f, -1.25052696e-02f, 2.99677886e-02f, 1.04927637e-01f, -3.67304422e-02f,
  1.73525847e-02f, -1.60093993e-01f, 4.26509440e-01f, 7.68277794e-02f, 2.79939026e-01f, 2.78185040e-01f, 3.12828153e-01f, 1.44006446e-01f, 3.92107487e-01f, -2.46533707e-01f,
  -3.32255989e-01f, -1.24415651e-01f, 1.12481497e-01f, -2.11319625e-01f, 3.82594198e-01f, 2.15351656e-01f, 3.85977440e-02f, -1.24744989e-01f, 2.44071290e-01f, 6.98318779e-02f,
  1.13730617e-01f, -2.41380468e-01f, 5.41536175e-02f, -8.65955055e-02f, 2.82707587e-02f, -3.49011235e-02f, -3.59875202e-01f, 2.76465714e-01f, -3.45648348e-01f, 6.85358569e-02f,
  9.44296923e-03f, -5.27650528e-02f, -6.42639995e-02f, -8.03596228e-02f, 3.38684693e-02f, -5.85701726e-02f, -5.37936985e-02f, 7.26007968e-02f, 1.39950648e-01f, -4.54509296e-02f,
  3.62985171e-02f, -1.77618936e-02f, -7.77504072e-02f, 3.47359441e-02f, 1.03378668e-01f, -2.79818792e-02f, 1.48554463e-02f, -3.83730829e-02f, 4.46710773e-02f, 9.23807248e-02f,
  1.05323993e-01f, 7.29269013e-02f, 8.75878260e-02f, -1.55795634e-01f, 1.34186679e-03f, -4.92331944e-02f, 1.27491765e-02f, 3.23817134e-02f, 1.89123843e-02f, 3.42526995e-02f,
  -1.17999479e-01f, -5.67299388e-02f, 7.88913593e-02f, 2.07808316e-02f, 1.28735840e-01f, 1.54734291e-02f, 2.88545731e-02f, -7.11307749e-02f, 1.35052547e-01f, -6.36781305e-02f,
  -7.55596384e-02f, -1.53343081e-01f, -1.67006124e-02f, 6.47584200e-02f, -8.63809064e-02f, -3.46634015e-02f, 1.65655315e-02f, -1.11601818e-02f, 3.66128683e-02f, -2.17771977e-02f,
  7.62421265e-02f, -3.95339634e-03f, -6.12429120e-02f, 2.77319867e-02f, 3.28108594e-02f, 1.31280288e-01f, -2.63227951e-02f, 1.00644141e-01f, -8.71351808e-02f, 1.84569135e-02f,
  6.27443269e-02f, -1.86229110e-01f, -1.07466586e-01f, -1.43948972e-01f, -7.29073538e-03f, -1.27024993e-01f, 2.53747497e-02f, 5.32912575e-02f, 1.53750703e-01f, -4.02304530e-02f,
  -4.27595638e-02f, -9.30551961e-02f, -4.65622731e-02f, 7.68996542e-03f, 4.77683963e-03f, 3.10894065e-02f, 4.14167205e-03f, -6.96354359e-02f, -8.43902156e-02f, -1.13638766e-01f,
  -1.82585269e-02f, -1.46356467e-02f, 4.82395589e-02f, -9.17891115e-02f, -1.22969843e-01f, -6.80019706e-02f, -1.04945116e-01f, -1.83925703e-02f, 8.30240641e-03f, 1.49472544e-04f,
  -2.67510831e-01f, -3.30684543e-01f, 9.36094448e-02f, -2.32166387e-02f, 7.27637578e-03f, -6.37441948e-02f, -1.64675355e-01f, 1.54070687e-02f, -3.68811071e-01f, -3.16429108e-01f,
  5.77493086e-02f, -1.11878581e-01f, -2.15549335e-01f, -1.18887119e-01f, 2.15347975e-01f, -2.11173519e-01f, 1.20677173e-01f, -4.69222199e-03f, 1.28904253e-01f, 1.84337094e-01f,
  2.27652401e-01f, 9.19422135e-02f, 4.30260956e-01f, 3.33788276e-01f, 1.59833372e-01f, 3.82613331e-01f, 3.32804084e-01f, 3.47330600e-01f, 4.19604868e-01f, 1.29809722e-01f,
  -5.90577051e-02f, -7.68665895e-02f, -2.14548130e-02f, 3.50272693e-02f, 1.53510183e-01f, -4.88362871e-02f, 1.78073943e-01f, 1.06233306e-01f, 5.40522076e-02f, -1.63822323e-02f,
  -4.33210135e-02f, 1.18427821e-01f, -6.67433895e-04f, 3.26962955e-02f, 4.23054807e-02f, 6.51323423e-02f, 1.99647970e-03f, 1.87706333e-02f, -7.99307507e-03f, -1.01779342e-01f,
  -4.10365164e-02f, -7.04337955e-02f, -1.94306416e-03f, 9.16537195e-02f, 1.17456332e-01f, 5.66980802e-02f, -7.33256480e-03f, 2.12505553e-02f, -9.67157111e-02f, 6.08250946e-02f,
  3.26164886e-02f, -8.51205289e-02f, -3.20730880e-02f, -1.13694303e-01f, -6.99098734e-03f, -1.90197006e-02f, -1.25262542e-02f, -1.53835677e-02f, 6.22420199e-02f, -1.87226534e-02f,
  6.57684878e-02f, 8.08471888e-02f, -3.61746661e-02f, -1.64954811e-01f, 5.92638878e-03f, -1.20660581e-01f, 2.50547994e-02f, -1.15092099e-02f, 3.43001983e-03f, -7.27484375e-02f,
  -5.01306914e-02f, 7.07597136e-02f, -1.15443744e-01f, -2.96680070e-02f, -1.82421863e-01f, -3.32704629e-03f, -5.92428893e-02f, -8.16326812e-02f, 5.23643428e-03f, 2.25348666e-01f,
  -1.22822565e-03f, 8.62656236e-02f, 8.14126804e-02f, 4.99849720e-03f, -9.71321985e-02f, 6.35862525e-04f, 1.44322421e-02f, 2.99478769e-02f, -2.10047308e-02f, 7.67427534e-02f,
  1.16117790e-01f, 9.98707488e-02f, -1.54577702e-01f, -8.12586956e-03f, 7.27929771e-02f, -5.28138429e-02f, -3.53552513e-02f, -3.21637467e-02f, -1.79708637e-02f, 8.04554969e-02f,
  -4.83060367e-02f, 1.52036613e-02f, -6.37769178e-02f, 5.83020446e-04f, -2.52453852e-02f, 2.05296241e-02f, 1.25758164e-02f, -2.81283148e-02f, 5.94034865e-02f, 8.65683146e-03f,
  -8.75516176e-01f, 4.59693223e-01f, 4.55544144e-02f, -9.22272429e-02f, -1.45116806e-01f, 5.50362505e-02f, 6.26135468e-02f, 1.81037486e-02f, -3.57392095e-02f, 3.78883690e-01f,
  3.86587791e-02f, -1.12056985e-01f, 2.85832912e-01f, 3.20825309e-01f, -4.17486370e-01f, 3.87510389e-01f, 4.50365711e-03f, -4.25016619e-02f, 5.94895259e-02f, -1.78233251e-01f,
  -1.32325396e-01f, -3.27091143e-02f, 1.58043876e-01f, 1.11622535e-01f, -1.44994721e-01f, -9.76897404e-02f, -2.19354972e-01f, 9.13714245e-02f, -1.80511065e-02f, -1.04911052e-01f,
  -2.93608278e-01f, -1.79024264e-01f, -1.66275904e-01f, -1.30378321e-01f, -1.66445166e-01f, -7.65485391e-02f, -1.21143989e-01f, 2.36277655e-02f, -3.32989357e-02f, 3.09442799e-03f,
  -6.52459338e-02f, -1.35344071e-02f, -4.13652323e-02f, 2.68829241e-02f, -6.62764013e-02f, 2.75380537e-02f, 7.06252158e-02f, 6.39040768e-02f, 7.90170953e-02f, 9.64296684e-02f,
  1.53449029e-01f, 9.79986861e-02f, 2.06205696e-02f, 7.15757385e-02f, -2.33442225e-02f, 2.91665234e-02f, 3.63361314e-02f, -2.71373279e-02f, -6.08414598e-02f, -3.11350022e-02f,
  -3.94588597e-02f, 9.79393441e-03f, 5.64391501e-02f, -3.47744673e-02f, 3.10753863e-02f, -5.18765077e-02f, 4.10687691e-03f, -2.20474303e-02f, 1.63209566e-04f, 3.05020455e-02f,
  -8.97668488e-03f, -2.51534060e-02f, -8.80034268e-02f, 7.96788430e-04f, -8.04402307e-03f, -7.24794269e-02f, -3.45834233e-02f, -3.45938727e-02f, 1.42184563e-03f, -2.54434329e-02f,
  -6.31430671e-02f, 3.00828256e-02f, 5.85854577e-04f, -1.80876553e-02f, -7.01429993e-02f, -1.16898799e-02f, 1.27464300e-02f, 5.23192510e-02f, -1.02507025e-02f, -7.18092099e-02f,
  -4.64094102e-01f, -3.59474421e-01f, -3.13100778e-02f, -1.73866436e-01f, -5.77251725e-02f, -5.16208075e-02f, 3.21820304e-02f, -8.43904242e-02f, -7.60254785e-02f, -7.83426836e-02f,
  -6.10912219e-02f, 4.00670245e-02f, -6.14357889e-02f, -3.00501529e-02f, 5.27048670e-02f, -1.11562861e-02f, -8.06832761e-02f, -6.25728592e-02f, -1.43462509e-01f, -2.66254954e-02f,
  -1.82201434e-02f, -7.51458183e-02f, 2.93707941e-02f, 8.38201214e-03f, -3.68304588e-02f, -9.61465687e-02f, -1.02380827e-01f, 9.02040824e-02f, -7.73913935e-02f, 6.89048693e-02f,
  6.63478553e-01f, -2.51494586e-01f, -2.06770286e-01f, 3.92861933e-01f, 3.58557075e-01f, -6.22122213e-02f, -1.89990699e-01f, 2.72130638e-01f, 1.31831408e-01f, -2.70184487e-01f,
  2.46378824e-01f, -3.68845761e-01f, -2.76827812e-01f, 3.77758265e-01f, 2.30586350e-01f, -1.88644364e-01f, 3.96359980e-01f, 2.39244495e-02f, 4.21890877e-02f, 2.34069839e-01f,
  2.31936082e-01f, 5.15079856e-01f, 1.84156686e-01f, 1.99112982e-01f, 2.95248508e-01f, 8.59871060e-02f, 1.34835005e-01f, -2.85454631e-01f, 1.84655756e-01f, -4.78282804e-03f,
  1.03030734e-01f, 1.74218833e-01f, 5.92642203e-02f, -1.07069924e-01f, 1.36378661e-01f, 3.80269028e-02f, -1.38280198e-01f, -5.27884588e-02f, -8.12114123e-03f, -5.11024222e-02f,
  -1.14601955e-01f, 3.15125212e-02f, -1.03117777e-02f, -3.28395441e-02f, 1.77180558e-01f, 3.57703567e-02f, 4.16432917e-02f, -1.06020086e-02f, -8.52985084e-02f, 4.03155647e-02f,
  -6.31044107e-03f, 1.34895230e-02f, 2.56915502e-02f, -5.46453260e-02f, 1.47783132e-02f, 6.48970436e-03f, -1.82262480e-01f, -1.40906841e-01f, -1.09717995e-02f, 8.15285221e-02f,
  3.72664668e-02f, -1.02758802e-01f, 4.18699943e-02f, 2.89048161e-03f, 5.07225841e-02f, 6.44053146e-02f, -4.48703803e-02f, -2.11267546e-02f, -3.96906771e-02f, 1.84711944e-02f,
  4.04149070e-02f, 7.93815255e-02f, 3.42240930e-03f, -2.65626945e-02f, 3.31331715e-02f, 6.62447661e-02f, -1.11329377e-01f, -1.09949626e-01f, 1.13642113e-02f, -3.62546928e-02f,
  -6.48235902e-02f, 4.48995158e-02f, -7.10309818e-02f, -3.58491242e-02f, -3.38693298e-02f, 2.19549220e-02f, 9.75980610e-02f, -4.58078869e-02f, 4.16474417e-02f, -3.29657868e-02f,
  -3.46060582e-02f, -6.49060905e-02f, -8.81575793e-02f, -5.56534305e-02f, -8.24478790e-02f, 3.61573584e-02f, -7.57594556e-02f, 5.77868111e-02f, -6.76618069e-02f, 8.58217627e-02f,
  8.56701806e-02f, -3.04584187e-02f, -7.27645904e-02f, 5.09483665e-02f, -2.37737112e-02f, 2.76206322e-02f, -1.15264237e-01f, -4.17059772e-02f, -1.07300663e-02f, 9.22584683e-02f,
  4.03701439e-02f, 4.64963354e-02f, -1.72858927e-02f, 1.05602860e-01f, 8.84202644e-02f, -8.72079283e-02f, -3.36431414e-02f, -3.46418433e-02f, -2.87493616e-02f, -1.03620961e-01f,
  -1.46134362e-01f, 8.14226344e-02f, -2.70157963e-01f, -1.22137897e-01f, 5.13725504e-02f, -3.72880310e-01f, -2.15043053e-01f, 1.41213492e-01f, -2.07951680e-01f, 2.09427610e-01f,
  1.63868949e-01f, -2.94377178e-01f, 2.43057191e-01f, -1.55323386e-01f, -4.34764385e-01f, -1.52141079e-01f, -1.72304347e-01f, -2.01352149e-01f, -1.25139594e-01f, 1.54778600e-01f,
  2.18642056e-02f, 1.73930287e-01f, -1.83695048e-01f, 2.55726993e-01f, 3.20008770e-02f, 1.36753097e-01f, 4.50450063e-01f, 9.78702977e-02f, 8.05611198e-05f, -9.26480442e-02f,
  -1.81082144e-01f, 1.36326104e-01f, -8.19407776e-02f, -8.93732086e-02f, -1.20925810e-02f, 8.04876387e-02f, -7.45254681e-02f, 3.48166912e-03f, -1.12336747e-01f, -3.99981737e-02f,
  7.02806488e-02f, -7.20738806e-03f, -4.75699641e-02f, -4.33462374e-02f, 3.04418691e-02f, 8.78837705e-02f, -8.14990476e-02f, -1.27947092e-01f, -4.20059711e-02f, -6.14275187e-02f,
  -9.08437148e-02f, -4.69485857e-02f, 1.13917649e-01f, -5.62589616e-03f, 5.64766750e-02f, 3.50562446e-02f, -9.72484052e-02f, -5.66440374e-02f, 1.09839020e-03f, -1.53037359e-03f,
  2.16622144e-01f, 3.78051336e-04f, -1.41533336e-03f, -7.49552324e-02f, -6.30987510e-02f, 2.82682367e-02f, 1.66292898e-02f, -1.75993238e-02f, 5.68774156e-02f, -2.20163800e-02f,
  -4.75918800e-02f, 2.54194606e-02f, 1.66307222e-02f, 3.58323962e-03f, 2.58798636e-02f, -1.02255933e-01f, 3.39542888e-02f, 7.41072744e-02f, -2.22322978e-02f, -7.12985843e-02f,
  1.05977068e-02f, -1.73639171e-02f, -2.31121909e-02f, 8.95420909e-02f, -1.55301439e-02f, 8.42125388e-04f, 1.07141979e-01f, -9.17016640e-02f, -2.44357120e-02f, 1.72394477e-02f,
  5.83435111e-02f, 3.30785066e-01f, -3.90521772e-02f, -3.28341452e-03f, 9.16323811e-03f, 1.17464326e-02f, -1.18222415e-01f, -1.11110294e-02f, 5.61317801e-02f, 8.32238942e-02f,
  9.75698531e-02f, 1.32638710e-02f, 6.89140111e-02f, 1.26992669e-02f, -6.66517466e-02f, 9.92999226e-02f, 1.72188386e-01f, -8.26043412e-02f, 9.58045870e-02f, 1.27547503e-01f,
  1.29603878e-01f, 7.79808313e-02f, 3.98954973e-02f, -3.03655840e-03f, 5.89698330e-02f, 7.18811601e-02f, 8.17919448e-02f, -9.71288607e-02f, 1.19054757e-01f, -9.12789349e-03f,
  3.63879139e-03f, 4.18235630e-01f, 5.81978448e-03f, 1.51284724e-01f, -2.27610886e-01f, -1.56374246e-01f, 1.69248864e-01f, 1.14868674e-02f, 2.75858045e-01f, 2.29797706e-01f,
  -1.76815227e-01f, 5.45004249e-01f, 1.27244759e-02f, 5.10247760e-02f, -4.78086650e-01f, -2.14069411e-01f, -1.81931406e-01f, 1.31706506e-01f, 1.77735090e-01f, 1.59039721e-01f,
  -1.13040522e-01f, -1.24264769e-01f, -2.61155993e-01f, 8.01567808e-02f, 2.10179333e-02f, 9.78984982e-02f, -3.40737998e-01f, 8.79489630e-02f, -1.34286150e-01f, -3.08361799e-02f,
  -1.30365610e-01f, 2.83920437e-01f, 3.67511958e-02f, 7.58002326e-02f, -1.33218303e-01f, -9.74880904e-02f, -6.25374839e-02f, -3.47235091e-02f, -3.58189344e-02f, 1.22441195e-01f,
  1.15075760e-01f, 9.37636569e-02f, 1.02167921e-02f, 3.36145200e-02f, 1.32405862e-01f, 4.12060097e-02f, -6.77137226e-02f, -1.54215306e-01f, 5.91148138e-02f, 1.80828795e-02f,
  1.01012036e-01f, 4.06913757e-02f, -2.32196599e-02f, -5.72576188e-02f, -3.81792488e-04f, -7.37075694e-03f, -9.24688652e-02f, -1.48523569e-01f, 4.20549698e-02f, 9.54304934e-02f,
  1.33095020e-02f, -7.66318887e-02f, 3.17821018e-02f, 5.66350682e-05f, 8.07106569e-02f, 6.52522147e-02f, 1.05509713e-01f, -7.09636807e-02f, 6.48676977e-02f, -1.79727059e-02f,
  -1.75289735e-02f, 6.23375885e-02f, 7.04553649e-02f, -3.52827907e-02f, 5.52017391e-02f, 1.14477910e-01f, -6.81574717e-02f, 9.43758786e-02f, 9.87256039e-03f, -7.18942881e-02f,
  1.25697196e-01f, -4.29651216e-02f, 1.17880166e-01f, -1.30174458e-01f, -2.04718160e-03f, 3.32154669e-02f, -4.42983815e-03f, 4.93299700e-02f, -3.66357341e-02f, -7.74555802e-02f,
  -9.94708315e-02f, 1.15818337e-01f, 1.56641677e-01f, 2.29009390e-01f, 1.76754579e-01f, -2.30700672e-02f, 4.60923910e-02f, 1.31550627e-02f, -5.32971919e-02f, 1.51880786e-01f,
  -2.46292874e-02f, 6.12259656e-02f, -1.20944582e-01f, -5.97689711e-02f, -1.97731075e-03f, -1.44034922e-01f, -1.01529188e-01f, -1.10129602e-02f, -1.52759254e-01f, -9.73232742e-03f,
  9.50044543e-02f, -1.21755032e-02f, 1.92592833e-02f, 1.40573019e-02f, 1.01423435e-01f, -2.56103184e-02f, 2.55108736e-02f, -3.47771980e-02f, -2.28943992e-02f, 1.37531254e-02f,
  -6.91442609e-01f, 2.25060537e-01f, -1.01320781e-01f, -4.35806930e-01f, 2.38262743e-01f, 2.05157008e-02f, -1.16853788e-01f, 1.66072577e-01f, -2.26392657e-01f, 3.04906726e-01f,
  2.23967150e-01f, -4.34104472e-01f, 2.44437113e-01f, -2.73847818e-01f, -4.88447577e-01f, -4.86700349e-02f, -3.20981085e-01f, -1.31474808e-01f, -2.01588482e-01f, -1.55933768e-01f,
  -3.14108700e-01f, 2.09145956e-02f, 1.65691804e-02f, 3.25685591e-01f, -1.59683488e-02f, 1.99421812e-02f, 9.66615602e-02f, 3.49671543e-01f, -1.03812024e-01f, 3.56559418e-02f,
  4.79626544e-02f, 1.10297009e-01f, 1.10241897e-01f, 1.14142202e-01f, 7.24649653e-02f, 2.85654943e-02f, 3.47187556e-02f, 1.57964490e-02f, 3.21048684e-02f, -4.74101268e-02f,
  -2.42378339e-02f, -1.00663617e-01f, -1.60295099e-01f, -4.82175387e-02f, 3.66168991e-02f, 4.88792220e-03f, 4.47609946e-02f, 2.48312000e-02f, 6.12717308e-02f, -1.23611704e-01f,
  4.96127643e-03f, -5.24802646e-03f, -9.16030630e-02f, -9.07514989e-02f, -8.83980393e-02f, 3.17291655e-02f, -7.98170567e-02f, -2.55748928e-02f, -1.94027424e-02f, -1.06286146e-01f,
  -1.29411995e-01f, -7.24411756e-02f, 8.35974663e-02f, 7.14073554e-02f, -3.08921784e-02f, 3.74514498e-02f, -3.13523337e-02f, -3.97511385e-03f, -1.87863540e-02f, -1.41504034e-02f,
  4.78351079e-02f, -3.44794244e-02f, 6.22843169e-02f, -4.76638041e-02f, -1.33034185e-01f, -5.14265299e-02f, -2.21496429e-02f, 3.09558008e-02f, -8.78454298e-02f, 6.04939535e-02f,
  1.28939375e-01f, -6.86213374e-03f, 1.26293555e-01f, 8.48951861e-02f, 6.57277405e-02f, -7.76071846e-02f, -4.16559018e-02f, 9.39464644e-02f, 3.92849967e-02f, -4.27499712e-02f,
  2.33991757e-01f, 7.07287192e-02f, 9.98269841e-02f, 1.26673728e-01f, 4.16088663e-02f, 4.79523167e-02f, -6.87725320e-02f, -1.05023123e-01f, -1.90598965e-02f, -1.31022841e-01f,
  -4.46606241e-02f, -5.66916401e-03f, 1.07414909e-02f, -2.31927838e-02f, -2.89592426e-02f, -4.35266033e-04f, 1.65083017e-02f, 3.17365639e-02f, 9.18060765e-02f, -1.78608149e-02f,
  8.84910002e-02f, 5.13273552e-02f, -1.56902090e-01f, -7.21036515e-04f, -5.21415696e-02f, 6.23993874e-02f, -1.90658066e-02f, -2.08986308e-02f, 4.77338880e-02f, 4.29130904e-02f,
  1.38255423e-02f, 2.25433335e-01f, -4.56418902e-01f, 1.09486625e-01f, -1.08959042e-01f, 5.32923639e-01f, 3.26161295e-01f, 8.56977180e-02f, 1.68270126e-01f, 3.42763245e-01f,
  1.59538969e-01f, 6.05687946e-02f, -1.45035312e-01f, 4.67880279e-01f, 2.67797589e-01f, 2.41241947e-01f, 4.89999920e-01f, 3.86029541e-01f, 4.47463128e-04f, 1.85841456e-01f,
  2.70775668e-02f, 4.52341348e-01f, -2.40958974e-01f, 5.79830669e-02f, 3.28780408e-03f, -2.84073383e-01f, -2.66704023e-01f, -3.90586466e-01f, 2.01697066e-01f, 1.68729067e-01f,
  9.34986472e-02f, -2.89905686e-02f, -9.30666029e-02f, -8.06244314e-02f, -2.89302673e-02f, -3.20725925e-02f, -8.88572782e-02f, -1.40318349e-01f, -9.08621401e-02f, -3.30613628e-02f,
  5.11138700e-02f, 9.41911712e-03f, 1.40590936e-01f, -1.35827307e-02f, 7.53785744e-02f, -5.00807315e-02f, -3.48617397e-02f, -5.76826632e-02f, 1.09984931e-02f, -5.38594164e-02f,
  -8.47506747e-02f, 1.65683385e-02f, 7.17271864e-02f, 4.83203940e-02f, -7.62087032e-02f, 1.29954427e-01f, 1.94406062e-02f, -7.80640021e-02f, 3.38064097e-02f, 1.20448545e-01f,
  -5.63130481e-03f, 8.92525762e-02f, 4.67169881e-02f, -4.78035994e-02f, 5.70477657e-02f, -1.75850037e-02f, 6.01423606e-02f, -5.51837832e-02f, -8.94842297e-02f, 2.84621287e-02f,
  -2.07177438e-02f, -1.05651155e-01f, 4.61530462e-02f, 2.68430728e-02f, 9.84238461e-02f, 4.26274985e-02f, -2.64738165e-02f, -6.68247649e-03f, -7.66345933e-02f, -8.10873732e-02f,
  -7.19296485e-02f, 3.67485061e-02f, -2.48650052e-02f, -1.30456641e-01f, 6.93092272e-02f, -1.85529798e-01f, 4.47976217e-02f, -6.76292628e-02f, -2.99416259e-02f, -6.85405061e-02f,
  2.06446916e-01f, 1.93638355e-01f, 1.22641129e-02f, 1.16812803e-01f, -3.01468913e-02f, 8.11679140e-02f, 6.49762452e-02f, -2.44866759e-02f, 4.62092087e-02f, 6.12236746e-02f,
  3.43776084e-02f, 4.46631424e-02f, -6.72186119e-03f, -1.51511906e-02f, 3.20441797e-02f, 3.32580842e-02f, 4.78582457e-02f, -5.99572109e-03f, 3.45096327e-02f, 8.05279519e-03f,
  -7.06075206e-02f, 9.23065320e-02f, -6.58500120e-02f, -9.05901659e-03f, 9.73087326e-02f, -2.63981074e-02f, 4.24632430e-02f, -6.20792843e-02f, -7.34425262e-02f, 1.32386684e-02f,
  -5.57851255e-01f, 1.63289625e-02f, 6.81743845e-02f, 1.95489302e-01f, -2.27899835e-01f, -3.09743255e-01f, 3.45522732e-01f, -2.16986686e-01f, -1.03447177e-01f, 2.97186881e-01f,
  3.45700711e-01f, 1.31654525e-02f, 2.70295054e-01f, 2.52540648e-01f, -4.80874658e-01f, 2.37982988e-01f, 1.74224731e-02f, 1.39091000e-01f, -4.60356399e-02f, -8.28263685e-02f,
  -2.32663944e-01f, 6.03072047e-02f, 8.27722251e-02f, -3.20939153e-01f, -1.40299201e-02f, -8.73539522e-02f, 1.42955527e-01f, 5.37991337e-02f, -7.43601695e-02f, -1.60701834e-02f,
  -1.23758912e-01f, 1.42989829e-01f, 1.27619088e-01f, -1.16010264e-01f, -1.33073732e-01f, 4.36196104e-02f, 8.17328244e-02f, 4.08766344e-02f, 2.21736939e-03f, -1.31065175e-01f,
  1.16448412e-02f, -1.18226856e-01f, -1.61923707e-01f, -2.08714958e-02f, -9.07184780e-02f, -4.34552431e-02f, -1.31730903e-02f, 1.30081609e-01f, 3.49066854e-02f, 3.87823172e-02f,
  6.73141107e-02f, -3.82459126e-02f, 1.31308764e-01f, 7.51586854e-02f, 7.31661245e-02f, 3.81399356e-02f, 4.13605981e-02f, 4.36071865e-02f, -1.06685348e-01f, -1.51163727e-01f,
  2.39490736e-02f, -7.96681736e-03f, 1.66556448e-01f, -4.86912653e-02f, 6.02096952e-02f, 1.17988274e-01f, 5.53061860e-03f, 2.42649857e-02f, -4.22564708e-02f, 2.27424074e-02f,
  -4.68835272e-02f, -7.29647279e-02f, -2.99509875e-02f, 1.91698819e-02f, 1.17853945e-02f, 5.21005467e-02f, 6.12679943e-02f, -9.72440615e-02f, 6.53876141e-02f, -4.50798273e-02f,
  -1.53318851e-03f, -9.33197215e-02f, 4.19230126e-02f, 1.14499450e-01f, -4.18973118e-02f, 1.77509885e-03f, 1.18060529e-01f, 1.16674220e-02f, 7.49179050e-02f, -5.95902354e-02f,
  -4.97954756e-01f, -3.98288518e-01f, 4.70048329e-03f, 3.44340061e-03f, -3.12328190e-02f, -7.75778964e-02f, 2.21589468e-02f, -2.09648922e-01f, -1.90597981e-01f, -2.19615102e-01f,
  -8.90329704e-02f, 1.22743011e-01f, -1.31269887e-01f, 4.13029157e-02f, -7.10288137e-02f, 4.10552211e-02f, -1.84678398e-02f, -3.14297527e-02f, -6.01441748e-02f, -1.42538622e-01f,
  -7.73504525e-02f, 3.93885486e-02f, 1.19672325e-02f, 6.90919831e-02f, 1.28411561e-01f, -2.92965397e-03f, -1.37724295e-01f, 6.52461052e-02f, -6.19008951e-02f, -4.94708419e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  2.96635509e-01f, 4.31067020e-01f, 2.61040181e-01f, 2.87053347e-01f, 3.30175459e-01f, 2.40013629e-01f, 2.25908250e-01f, 3.50894183e-01f, 3.49450052e-01f, 1.24032192e-01f,
  3.98582846e-01f, 4.73117471e-01f, 3.45168859e-01f, 2.90144145e-01f, 1.23280667e-01f, 3.82363856e-01f, 4.91472870e-01f, 1.89898387e-01f, 3.23345095e-01f, 3.38962168e-01f,
  3.98487687e-01f, 3.87888372e-01f, 3.07741314e-01f, 4.29053038e-01f, 5.38962007e-01f, 3.97885889e-01f, 4.33866769e-01f, 3.76006544e-01f, 3.62542272e-01f, 2.71601498e-01f,
  2.86585033e-01f, 5.13578653e-01f, 3.94773066e-01f, 1.89856395e-01f, 3.65869850e-01f, 4.75814044e-01f, 2.84355223e-01f, 3.88803691e-01f, 2.91457266e-01f, 2.86215663e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  1.23883240e-01f, 1.96363240e-01f, 1.47662945e-02f, 4.76231240e-02f, -4.09814119e-01f, 8.44934583e-02f, -4.21197802e-01f, -2.63415307e-01f, -4.70382839e-01f, -3.96906465e-01f,
  -1.57866970e-01f, -4.47187692e-01f, -2.82092631e-01f, -4.36245590e-01f, -3.39631796e-01f, -4.90429997e-02f, 1.16735362e-01f, 2.91121513e-01f, 2.44094357e-01f, -3.74029070e-01f,
  2.80188769e-01f, 2.34795302e-01f, 4.32727456e-01f, -1.63227245e-01f, -1.73999563e-01f, -2.66887993e-01f, -1.89724624e-01f, 3.55181880e-02f, -3.80516291e-01f, -1.86676160e-01f,
  -6.64320141e-02f, -5.88892817e-01f, 2.59460777e-01f, -2.89750025e-02f, -3.00302953e-01f, -4.60366338e-01f, 1.66516840e-01f, -4.16204661e-01f, -4.44641203e-01f, 6.08563423e-01f,
  -2.73306221e-01f, -1.41179800e-01f, -1.97586939e-01f, -3.74405473e-01f, 5.07572591e-01f, -4.71917897e-01f, -2.66850203e-01f, -2.54504778e-03f, -4.15949553e-01f, -5.08112349e-02f,
  1.53349459e-01f, 1.83723077e-01f, 2.42090970e-02f, 4.08227593e-01f, 5.20376824e-02f, -6.25201821e-01f, -5.28296709e-01f, 5.33015907e-01f, -3.20240289e-01f, -1.83005601e-01f,
  -2.32255772e-01f, 1.74852729e-01f, 2.49680996e-01f, 7.49282837e-01f, -1.53139522e-02f, 5.32767586e-02f, -3.40458006e-01f, 8.82220343e-02f, -6.10638916e-01f, -1.30212799e-01f,
  -2.60822475e-03f, -8.48158449e-03f, 4.04881239e-02f, 1.75433874e-01f, 1.26302525e-01f, 1.63388535e-01f, 4.78984714e-01f, -1.16098456e-01f, 2.01708227e-01f, 7.57563114e-01f,
  4.45572227e-01f, -4.21854079e-01f, 3.21860731e-01f, -1.88685209e-02f, 4.04603817e-02f, 5.21230221e-01f, -6.98122025e-01f, -6.37181282e-01f, -3.31066906e-01f, -3.00140679e-01f,
  -1.62886873e-01f, -6.94028795e-01f, -1.46759093e-01f, 1.16338111e-01f, -5.22335768e-01f, 6.28758252e-01f, 2.99140126e-01f, -2.80158460e-01f, 1.97717890e-01f, -5.27638495e-01f,
  2.02101767e-01f, -3.02464396e-01f, -1.54112771e-01f, 2.64983047e-02f, 1.03122041e-01f, 1.86031699e-01f, -2.30617285e-01f, -5.34334779e-01f, 1.97439075e-01f, 1.03555895e-01f,
  3.71035039e-01f, 1.09351583e-01f, -7.21087635e-01f, 9.63756889e-02f, -4.80351508e-01f, 5.00535846e-01f, -6.23550355e-01f, -3.93870652e-01f, 5.36586046e-01f, -5.17475843e-01f,
  -3.49546641e-01f, -5.39429724e-01f, 4.17917520e-01f, 1.11027315e-01f, -2.90000260e-01f, -6.38674498e-01f, 5.93521237e-01f, -3.85133773e-01f, -1.16097845e-01f, 5.34981824e-02f,
  -3.08735400e-01f, 4.26748209e-03f, 2.61426151e-01f, -4.88867946e-02f, 2.82132234e-02f, -1.66226104e-02f, -7.59662092e-02f, 6.43486679e-02f, -9.84908864e-02f, -1.57551579e-02f,
  2.68265128e-01f, -2.10749060e-01f, -3.48867267e-01f, -1.00303642e-01f, -2.63438940e-01f, 4.65137839e-01f, -1.26121342e-01f, -8.02257732e-02f, -3.53204578e-01f, -1.20423667e-01f,
  4.53855038e-01f, 3.63160044e-01f, -4.24016893e-01f, -1.73359200e-01f, -2.20861316e-01f, -1.63036615e-01f, -2.64298677e-01f, -3.64962995e-01f, 5.96835017e-01f, 5.01849890e-01f,
  5.32560170e-01f, -1.29861042e-01f, -3.03228740e-02f, -4.30630118e-01f, -2.56249338e-01f, -1.42511472e-01f, -3.06654453e-01f, -4.74374712e-01f, -3.84549558e-01f, -2.96920508e-01f,
  2.10037470e-01f, 6.42991424e-01f, -4.53288972e-01f, -2.59636521e-01f, -1.27104536e-01f, -1.20818213e-01f, -2.75512099e-01f, -3.84388007e-02f, -1.46491647e-01f, -4.05948400e-01f,
  -1.78251281e-01f, -3.71152684e-02f, 3.59983534e-01f, -3.74689966e-01f, 4.42899406e-01f, -2.13941261e-01f, 3.77824634e-01f, -3.81702393e-01f, -1.65187269e-01f, -1.14695542e-01f,
  1.61807835e-01f, -3.78320783e-01f, -6.12152994e-01f, 1.59894437e-01f, -2.35202233e-03f, -4.65916306e-01f, 1.24907099e-01f, -3.50920558e-01f, -8.59340578e-02f, -1.68290734e-01f,
  -2.28710443e-01f, 1.21637709e-01f, 3.52355130e-02f, 3.15535031e-02f, -5.83201125e-02f, 1.00606032e-01f, 6.46624923e-01f, 8.72442871e-02f, 1.01529650e-01f, 3.06414366e-01f,
  5.27150929e-01f, 2.84387529e-01f, 5.06377697e-01f, -1.14884928e-01f, 8.91669095e-02f, 4.91372645e-01f, 3.22735488e-01f, -4.19052094e-01f, -5.40210828e-02f, 5.62308073e-01f,
  1.10172145e-01f, -2.10716084e-01f, 1.91879123e-01f, -1.91048265e-01f, -3.66825759e-01f, -1.89792246e-01f, 1.22763366e-01f, 2.07315534e-01f, -4.15789336e-01f, -3.03509384e-01f,
  -3.91455561e-01f, -2.81163484e-01f, 2.51993716e-01f, -1.65534899e-01f, 2.20477074e-01f, -4.23485339e-01f, -5.08745313e-01f, 3.39859771e-03f, -4.63030338e-01f, 1.68471217e-01f,
  -6.87083602e-01f, -4.21725214e-01f, 3.52988720e-01f, -3.20818007e-01f, -1.49013251e-01f, -3.60157400e-01f, -3.17851037e-01f, -2.08540216e-01f, -6.59420550e-01f, 2.82586098e-01f,
  -2.44774446e-01f, 3.20119679e-01f, 5.64236581e-01f, 5.47367454e-01f, -3.07088166e-01f, 3.90995532e-01f, 4.47302788e-01f, -4.09018457e-01f, 2.48732597e-01f, 5.85939512e-02f,
  2.61373937e-01f, 6.77830651e-02f, 1.00476265e-01f, 5.35536885e-01f, 3.17513824e-01f, -9.09654126e-02f, -1.52178913e-01f, 3.85632366e-01f, -7.51247525e-01f, 6.03213787e-01f,
  2.06703991e-01f, 4.76616830e-01f, -1.36628270e-01f, 2.15364978e-01f, 1.72317281e-01f, 4.78588969e-01f, -3.31966639e-01f, 1.18326917e-01f, 8.36227164e-02f, -4.16184306e-01f,
  -1.91193074e-02f, 4.87446100e-01f, -8.25891867e-02f, 4.83774431e-02f, 2.01812267e-01f, 2.06646979e-01f, 1.36213571e-01f, -3.66030395e-01f, -6.48511231e-01f, -1.29836515e-01f,
  -3.05788308e-01f, -5.33229589e-01f, -9.38960910e-02f, -1.08613260e-02f, 6.00740194e-01f, -2.35709678e-02f, 4.46510464e-01f, 2.49204114e-01f, -2.02664524e-01f, 1.23671912e-01f,
  -1.20077468e-01f, -7.07288206e-01f, -4.40537244e-01f, -2.63890237e-01f, -8.48140288e-03f, -4.08581138e-01f, 4.83024478e-01f, 2.95589238e-01f, -4.04517829e-01f, 6.54522598e-01f,
  5.80028929e-02f, 3.34649861e-01f, 3.55727434e-01f, 3.98056746e-01f, -2.32797310e-01f, -5.30722201e-01f, -3.41192394e-01f, 2.77514040e-01f, -5.42333126e-01f, -2.26463869e-01f,
  2.11621106e-01f, -4.00070280e-01f, 1.92892984e-01f, 4.11478162e-01f, 4.05803502e-01f, 1.04162723e-01f, 2.40748107e-01f, 2.09635615e-01f, 1.53044149e-01f, 5.72512224e-02f,
  9.48634967e-02f, 9.32233110e-02f, 5.92922747e-01f, 4.78814960e-01f, -6.26777053e-01f, -4.21539843e-01f, 5.16645730e-01f, -4.71812636e-01f, -5.26968576e-02f, -3.26201856e-01f,
  3.72301728e-01f, 3.17909300e-01f, 4.60688546e-02f, -5.06032817e-02f, 6.52293742e-01f, -6.26634181e-01f, -8.37080032e-02f, 2.84113824e-01f, 1.08855352e-01f, -3.14034462e-01f,
  -2.13116795e-01f, -7.52097845e-01f, -2.12449774e-01f, 2.61145234e-01f, -2.98275381e-01f, 3.38976562e-01f, 2.83053428e-01f, 6.20809533e-02f, -1.96878999e-01f, 9.98159274e-02f,
  1.80247873e-02f, -5.53738624e-02f, -6.82921708e-01f, 3.45396668e-01f, 4.86912072e-01f, -2.39487290e-01f, 4.49365646e-01f, 7.42638335e-02f, 4.77146029e-01f, 4.34759885e-01f,
  1.50134414e-01f, -3.93361062e-01f, -3.78756970e-01f, -5.51206052e-01f, -4.24014926e-01f, 2.95087159e-01f, -8.66492018e-02f, -2.30035514e-01f, -5.78682542e-01f, -3.04301232e-01f,
  3.60909581e-01f, -6.47404909e-01f, 3.43562692e-01f, -5.46905637e-01f, -3.44610602e-01f, -1.19632535e-01f, 6.71307966e-02f, -4.36623484e-01f, -1.41942147e-02f, 1.24455348e-01f,
  -1.93532020e-01f, -2.36270815e-01f, 1.79279104e-01f, 1.60761729e-01f, 2.24733353e-01f, -1.44354790e-01f, -1.74048051e-01f, 1.18373856e-01f, 2.05105767e-02f, -4.26658601e-01f,
  -5.29163241e-01f, -3.08965832e-01f, -4.29435343e-01f, -2.91017294e-01f, 4.24411073e-02f, -1.23135470e-01f, -3.90742213e-01f, -8.74884874e-02f, 2.10996270e-01f, -1.78197045e-02f,
  -3.25093031e-01f, -4.88601655e-01f, 5.78860283e-01f, -3.90510112e-01f, 4.22144353e-01f, 4.17299181e-01f, -8.05147231e-01f, -4.11939412e-01f, 1.28669426e-01f, 5.55120230e-01f,
  -3.60627711e-01f, -2.39843339e-01f, 2.51623511e-01f, -5.91468036e-01f, -2.27552980e-01f, -2.93522682e-02f, 5.89623511e-01f, -2.97761224e-02f, -1.72592178e-01f, -3.87829781e-01f,
  4.86256421e-01f, -3.13653827e-01f, 1.50671631e-01f, -7.38570690e-01f, -5.67597866e-01f, 8.02314281e-03f, 4.99170750e-01f, -4.62957948e-01f, -5.59336901e-01f, 3.68894726e-01f,
  -1.03323847e-01f, -3.81909281e-01f, 6.26560450e-01f, -1.63209260e-01f, -2.40165606e-01f, -1.39583483e-01f, -8.67542550e-02f, -1.25824939e-02f, 2.69222315e-02f, -1.13746300e-02f,
  -2.39190578e-01f, 3.32277082e-02f, -2.75612205e-01f, -2.81158715e-01f, 8.38592276e-02f, 1.53209373e-01f, 5.82658425e-02f, -9.17965770e-02f, -2.04943959e-02f, -2.79729426e-01f,
  -2.25246280e-01f, -3.06398094e-01f, 1.95961103e-01f, -3.07389677e-01f, -2.75882244e-01f, 2.68968612e-01f, -3.76341134e-01f, 1.78300470e-01f, 2.28429630e-01f, 1.39078259e-01f,
  2.24157363e-01f, 1.48463920e-01f, -1.90428346e-01f, -2.36966729e-01f, 5.99198163e-01f, 4.29476202e-01f, -1.32936910e-01f, -6.84882030e-02f, -1.88748896e-01f, -3.70663524e-01f,
  -3.13266486e-01f, -1.23385593e-01f, 6.13586791e-02f, 2.64888015e-02f, -3.78719956e-01f, 5.22997200e-01f, 2.03134671e-01f, -1.45932108e-01f, -3.21931124e-01f, 4.22403067e-01f,
  -2.71174878e-01f, -1.84445437e-02f, -2.13110745e-01f, 4.83770102e-01f, -2.20429450e-01f, -2.41637766e-01f, 4.14363891e-01f, -2.07826301e-01f, 9.22952592e-02f, -3.42124104e-01f,
  -1.16418630e-01f, -3.23603839e-01f, -1.37657598e-01f, -7.49598071e-02f, -1.22274801e-01f, -2.12604761e-01f, -2.22156882e-01f, -1.15896188e-01f, -2.40666017e-01f, -2.43483111e-01f,
  -2.12398052e-01f, -3.25737596e-01f, 1.72187209e-01f, -6.93092169e-03f, 2.55704168e-02f, -1.08682223e-01f, 6.70864508e-02f, -2.10431442e-01f, -1.88466832e-01f, 5.77801419e-03f,
  -3.51164155e-02f, -2.94284433e-01f, 1.21767893e-01f, -1.55176193e-01f, -2.60260135e-01f, -2.18843948e-02f, -5.55995703e-02f, -3.67516637e-01f, -6.35311157e-02f, -2.61958420e-01f,
  -3.01907599e-01f, 6.59740046e-02f, 6.57833219e-02f, -3.64667833e-01f, -1.83232099e-01f, 3.33293557e-01f, -1.42006934e-01f, -1.60417527e-01f, -1.75690114e-01f, -2.19388619e-01f,
  -2.78816521e-01f, 5.73211730e-01f, -2.91042030e-01f, -2.30164140e-01f, -2.50104606e-01f, 6.74952865e-01f, -7.60841519e-02f, -8.74326527e-02f, -3.49074692e-01f, -1.76386714e-01f,
  -1.27476782e-01f, 6.15125179e-01f, -4.22394931e-01f, -2.22551540e-01f, -3.14858913e-01f, 1.25939071e-01f, -1.74520552e-01f, -2.13939726e-01f, -3.10999990e-01f, -4.54090208e-01f,
  -2.13488981e-01f, 4.42042649e-01f, -2.13749200e-01f, -4.13660586e-01f, 2.11700618e-01f, -2.54256070e-01f, 3.68988693e-01f, -1.22615829e-01f, 4.37480152e-01f, -7.43348151e-02f,
  2.92627931e-01f, 2.67374486e-01f, -1.72166109e-01f, -2.85676539e-01f, -3.27476084e-01f, -1.12943336e-01f, -1.18573353e-01f, 2.58122474e-01f, 2.83941358e-01f, 5.49880750e-02f,
  -1.78609580e-01f, 3.29210907e-01f, 2.49824896e-01f, -5.55244759e-02f, -2.13627204e-01f, 6.47079051e-02f, 1.57776289e-02f, 7.08050206e-02f, 5.33753455e-01f, -1.09966561e-01f,
  4.27474201e-01f, -1.85905203e-01f, -4.08079267e-01f, 7.24667832e-02f, 2.85405037e-03f, -4.34116960e-01f, -3.31065536e-01f, -3.73628676e-01f, 4.10347074e-01f, -3.61340910e-01f,
  -1.81195840e-01f, 5.34798145e-01f, 6.35983646e-01f, -1.90378115e-01f, -7.02480137e-01f, -2.41513073e-01f, -2.43154868e-01f, 2.89335966e-01f, 5.66628635e-01f, -8.28705161e-05f,
  -3.06235164e-01f, 1.60569146e-01f, 6.51405990e-01f, -3.22286159e-01f, 1.20844461e-01f, -1.04768768e-01f, -5.47575355e-01f, 2.78617233e-01f, -2.71746278e-01f, -1.91554815e-01f,
  -4.73506004e-01f, -1.92413568e-01f, -3.48573923e-01f, -3.55612755e-01f, 4.58511829e-01f, -5.77872247e-02f, -5.61604261e-01f, 3.21943969e-01f, -5.46736896e-01f, 8.34727213e-02f,
  -5.60721517e-01f, 3.96968216e-01f, 1.15942106e-01f, -4.05470967e-01f, -4.82611209e-01f, -2.86028475e-01f, -2.93659896e-01f, -3.57391179e-01f, -6.95299685e-01f, 3.00592661e-01f,
  1.44791633e-01f, 1.49062380e-01f, 1.31512940e-01f, 9.46498215e-02f, 3.83040644e-02f, 1.81811765e-01f, 2.16958016e-01f, -1.67545021e-01f, 3.07081014e-01f, 1.91818714e-01f,
  8.86903629e-02f, 1.84520289e-01f, -4.41923499e-01f, -3.88526767e-01f, -6.19214356e-01f, 4.36407804e-01f, 1.80111915e-01f, 2.84081936e-01f, -4.71614182e-01f, 3.22699785e-01f,
  -1.50887087e-01f, 1.48942664e-01f, -3.37191492e-01f, 1.00383997e-01f, -2.71770239e-01f, 9.31262225e-02f, -4.25138324e-01f, -5.83911717e-01f, -4.32071328e-01f, -3.72465611e-01f,
  -4.07234788e-01f, -1.17234059e-01f, 1.18027031e-01f, -1.76913708e-01f, 6.08596385e-01f, -3.96869332e-01f, -1.28541231e-01f, 5.30095436e-02f, -1.50288835e-01f, -2.40861133e-01f,
  5.55844843e-01f, -7.12724209e-01f, -3.68654221e-01f, 3.72105956e-01f, -1.20441742e-01f, 4.44995999e-01f, -2.92125866e-02f, 5.44676840e-01f, -3.13532770e-01f, -1.80572942e-01f,
  -4.84722197e-01f, -2.49769926e-01f, 2.37312898e-01f, -1.68648809e-01f, -1.50412381e-01f, -2.96211541e-01f, 2.54951447e-01f, -6.89251721e-01f, -3.46723467e-01f, 5.12115002e-01f,
  -3.62051427e-01f, 4.17731196e-01f, -1.80781782e-01f, -2.93922633e-01f, 1.04654618e-01f, 6.82934076e-02f, 5.32093458e-02f, 1.92510918e-01f, 1.43029645e-01f, -8.58243555e-02f,
  1.99372903e-01f, -6.79336675e-03f, -2.06672922e-01f, -1.20297328e-01f, -1.71113089e-01f, -9.73908976e-02f, -3.60648073e-02f, -1.13330886e-01f, 3.01303983e-01f, 1.47666320e-01f,
  -1.93267703e-01f, -2.24871784e-01f, 2.43105456e-01f, 3.24798912e-01f, -3.99776965e-01f, -2.46667728e-01f, -2.78340429e-01f, 3.72604072e-01f, 1.87037155e-01f, 2.94627964e-01f,
  -4.21981633e-01f, -5.09567976e-01f, 4.13820952e-01f, 3.90606880e-01f, -1.35941103e-01f, -2.48628706e-01f, -1.75078467e-01f, 2.79159009e-01f, -2.83182859e-01f, 1.97090849e-01f,
  -1.97432280e-01f, 4.36871052e-01f, -4.27169234e-01f, -4.08432037e-01f, -4.70258057e-01f, -4.65877146e-01f, 5.75791359e-01f, -4.71574694e-01f, 1.29692078e-01f, 2.44358167e-01f,
  -2.36561850e-01f, 4.40275937e-01f, 7.62246773e-02f, 4.63583142e-01f, 3.80523890e-01f, -3.22962672e-01f, 3.87848645e-01f, 1.72318801e-01f, -2.00026616e-01f, -1.88400358e-01f,
  -2.84316212e-01f, -1.77525654e-01f, -3.37920904e-01f, -4.28846389e-01f, 4.78523284e-01f, -5.02332032e-01f, -4.23719555e-01f, 1.22477390e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  2.93795969e-02f, -5.41759133e-02f, -1.55115232e-01f, 5.39719388e-02f, 2.79545747e-02f, -3.06693614e-02f, -7.12428242e-04f, 2.58333348e-02f, 1.19284978e-02f, 1.00492127e-01f,
  1.02295063e-01f, -4.78606336e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    