/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -7.51691684e-02f, -8.91404450e-02f, -5.96438907e-02f, -1.23614758e-01f, -1.92773476e-01f, 4.32959273e-02f, 9.38457400e-02f, -1.20622166e-01f, -2.16712043e-01f, 7.78727457e-02f,
  7.09203258e-03f, 2.12575588e-02f, 1.93419904e-01f, 6.58265129e-02f, 2.22618431e-01f, 1.32991105e-01f, -1.81721821e-02f, -2.00689901e-02f, -1.13548175e-01f, -6.81866333e-02f,
  -6.72101229e-02f, -1.03301089e-02f, 1.13235556e-01f, -2.63043251e-02f, 4.99906316e-02f, -3.77638750e-02f, 4.06393372e-02f, -2.58672163e-02f, 5.69562651e-02f, 4.13762815e-02f,
  -7.79216439e-02f, -2.58795261e-01f, -1.54038472e-02f, -2.18928773e-02f, -2.72232872e-02f, -1.20748812e-02f, -3.37854512e-02f, 2.38952227e-02f, 2.37522461e-02f, -3.21347676e-02f,
  8.51626601e-03f, 7.65908360e-02f, -1.22778928e-02f, 8.90155137e-02f, -6.43772408e-02f, 3.30809429e-02f, 1.38211045e-02f, -1.33158639e-03f, -1.51185440e-02f, 5.69995567e-02f,
  8.07301104e-02f, -7.45821595e-02f, -1.26172835e-02f, -1.40585834e-02f, 2.41050702e-02f, -3.90275642e-02f, -3.56522873e-02f, -4.05430049e-02f, -3.46774347e-02f, -3.56793664e-02f,
  -1.00653186e-01f, 3.62140462e-02f, 4.06312309e-02f, -8.70925635e-02f, 1.84699632e-02f, -4.22795303e-02f, 3.77741084e-02f, -6.37387531e-03f, -5.68107292e-02f, -4.79726084e-02f,
  -2.50075981e-02f, -5.08947037e-02f, 1.01109184e-02f, 6.11286331e-03f, 8.52642523e-04f, -1.62940957e-02f, -9.38040391e-03f, -4.10605855e-02f, -6.11218857e-04f, -4.04070057e-02f,
  2.93750241e-02f, -5.86954737e-03f, 5.87428324e-02f, 2.97216065e-02f, -3.83376740e-02f, 3.22484113e-02f, 3.12906802e-02f, -1.32526923e-02f, 4.44910638e-02f, -2.09522024e-02f,
  -1.89334676e-01f, -3.07518572e-01f, -6.04319386e-02f, -1.84066873e-02f, 2.05254778e-02f, 8.63966569e-02f, -2.51958147e-02f, -2.71342043e-02f, -7.69625306e-02f, 4.71647233e-02f,
  2.61440054e-02f, 1.12056946e-02f, -2.99203563e-02f, -1.48888268e-02f, 1.02238074e-01f, -4.53214385e-02f, -9.99148190e-03f, -3.11138723e-02f, 1.30642178e-02f, -5.69589995e-03f,
  -4.66629751e-02f, 2.10918877e-02f, 6.53475076e-02f, 3.44157629e-02f, 3.03087160e-02f, -7.90424272e-02f, -3.29247862e-02f, 5.11164963e-03f, -4.18731645e-02f, -7.68294383e-04f,
  -2.06309482e-01f, -1.35260731e-01f, -2.99852878e-01f, -9.85643119e-02f, 9.68118086e-02f, 7.37973526e-02f, 8.52369294e-02f, -9.35935900e-02f, -2.91778117e-01f, 1.77692920e-01f,
  9.17019695e-02f, -2.45234653e-01f, 8.08751956e-02f, -4.24713865e-02f, -1.25523388e-01f, -3.15352269e-02f, -9.05391201e-03f, -1.52524719e-02f, -1.27697229e-01f, 7.49305263e-02f,
  -9.66267437e-02f, 2.65336066e-01f, -7.15061277e-02f, 1.47620216e-01f, -1.28446817e-01f, -5.65309785e-02f, 1.94681630e-01f, 1.04322344e-01f, 9.46273580e-02f, 6.65880442e-02f,
  -1.03378661e-01f, -2.55969237e-03f, -1.42269116e-02f, -8.51367116e-02f, 3.42794918e-02f, 2.64633521e-02f, 9.62296035e-03f, 5.13320602e-02f, -2.05841269e-02f, -2.31462400e-04f,
  -5.29349856e-02f, 1.07361235e-01f, -1.62000246e-02f, 4.66357591e-03f, -4.82742973e-02f, -2.08086837e-02f, -9.20213684e-02f, -1.67030189e-02f, -4.28221934e-03f, -4.56228890e-02f,
  -8.57204944e-02f, -7.78479353e-02f, 4.66056587e-03f, 4.39541899e-02f, -3.34340055e-03f, 3.15325819e-02f, -1.33495387e-02f, -1.38486251e-02f, -2.17248648e-02f, -3.55050154e-02f,
  7.44568035e-02f, 6.93427473e-02f, 1.14580011e-02f, -3.44003588e-02f, 6.08212203e-02f, -2.88702291e-03f, 2.94499751e-02f, 3.80862877e-03f, -2.73191594e-02f, 6.77185431e-02f,
  -1.52181240e-03f, -2.21737437e-02f, -2.35720314e-02f, 4.53999685e-03f, -2.06681490e-02f, 1.74750369e-02f, -1.31516077e-03f, 1.46967517e-02f, -5.65121062e-02f, -3.91009934e-02f,
  -1.00334045e-02f, 2.98192855e-02f, -2.47646086e-02f, 3.65838781e-02f, 1.84548832e-02f, 2.52864733e-02f, -6.58533797e-02f, 9.90629848e-03f, -2.00977065e-02f, 3.51573415e-02f,
  1.18169509e-01f, 2.17985976e-02f, 2.94604190e-02f, 6.28091097e-02f, 3.17127258e-02f, 1.78769957e-02f, 3.15319076e-02f, -1.34387081e-02f, -1.82449389e-02f, -2.61748768e-02f,
  1.17155187e-01f, -7.78755872e-03f, -2.63049081e-02f, -6.39328314e-03f, 2.45993361e-02f, -3.07047162e-02f, 1.12149738e-01f, -1.87317263e-02f, 4.63180004e-05f, -8.04148556e-04f,
  6.99148774e-02f, -9.87575948e-03f, -1.55818891e-02f, -2.80957799e-02f, 6.81437925e-03f, 2.18625814e-02f, -4.70051542e-02f, 3.09746414e-02f, 3.05743758e-02f, -1.54764848e-02f,
  7.83860534e-02f, -2.51484752e-01f, 2.46494599e-02f, 4.98191044e-02f, -5.04112393e-02f, 2.34588638e-01f, 9.19134766e-02f, 3.09408898e-03f, 1.79423001e-02f, 8.62603821e-03f,
  2.51772344e-01f, -1.33841902e-01f, 9.46138650e-02f, 1.64693788e-01f, 2.89244175e-01f, 7.86562115e-02f, 1.95969760e-01f, 9.67083722e-02f, -1.06294870e-01f, 2.71517690e-02f,
  -1.26695000e-02f, 1.36630729e-01f, 7.77970031e-02f, -5.38497753e-02f, 8.75846744e-02f, -1.10151961e-01f, 5.61988130e-02f, -1.36035442e-01f, -1.60078611e-02f, -8.02024305e-02f,
  4.78595607e-02f, 6.10202141e-02f, 2.32988205e-02f, -4.55646664e-02f, 1.57139018e-01f, 5.58091924e-02f, 2.48895753e-02f, -2.12603714e-02f, 1.57373268e-02f, 1.06977979e-02f,
  -3.60929035e-02f, -1.17663153e-01f, 3.27338427e-02f, -9.91322324e-02f, -6.96868002e-02f, -7.57090375e-02f, -3.84606086e-02f, 1.02148373e-02f, -1.10467914e-02f, 9.99661069e-03f,
  -1.91490687e-02f, 4.20172028e-02f, 1.22692185e-02f, 9.48836841e-03f, -6.42890483e-02f, 1.63408776e-03f, 7.01000169e-02f, -9.15806915e-04f, -1.75450719e-03f, 2.86741946e-02f,
  -3.24281491e-02f, 8.91917944e-03f, 8.65424890e-03f, 1.98225435e-02f, -5.24167046e-02f, 1.01926826e-01f, -9.91933607e-03f, 7.14422390e-02f, -1.66707449e-02f, 3.35220210e-02f,
  2.33402681e-02f, 3.11971884e-02f, 2.16292758e-02f, 1.63702779e-02f, 9.21584368e-02f, 3.48975882e-02f, 1.49739124e-02f, 7.96849094e-03f, -3.05629857e-02f, 2.43499279e-02f,
  5.44633046e-02f, 1.69432145e-02f, -5.69568388e-02f, 2.71980558e-02f, 7.14318678e-02f, -1.81501117e-02f, -3.56472260e-03f, -7.65566528e-02f, 2.31101587e-02f, 2.07411069e-02f,
  9.70092192e-02f, 9.79116485e-02f, 1.46374786e-02f, -2.22702627e-03f, 1.83108672e-02f, -1.96247399e-02f, 3.27309445e-02f, 9.89598967e-03f, 7.92750157e-03f, 3.60785574e-02f,
  -3.10373157e-02f, 3.97851504e-02f, -2.60737934e-03f, -3.90694775e-02f, 4.46584038e-02f, 3.53378803e-02f, 1.04254566e-01f, 7.90706500e-02f, 1.22007526e-01f, 1.70807336e-02f,
  2.84697209e-02f, 1.13081690e-02f, -5.54251624e-03f, 7.62255713e-02f, 3.75931971e-02f, 2.92037074e-02f, 4.11373153e-02f, -1.27011659e-02f, -3.80049013e-02f, 3.96147661e-04f,
  -2.81459093e-01f, 1.63055375e-01f, 9.93010104e-02f, -7.21531138e-02f, -1.16716065e-01f, -1.40400693e-01f, 5.72205409e-02f, 2.74491664e-02f, -1.56573921e-01f, 6.97492510e-02f,
  1.00719675e-01f, -6.04204275e-02f, 1.10214405e-01f, -5.42363301e-02f, -9.66186151e-02f, 1.26403704e-01f, -4.62488793e-02f, -1.03505282e-02f, 1.28519097e-02f, 5.23667783e-02f,
  -6.59049600e-02f, 4.56351005e-02f, -4.61680721e-03f, 1.21417701e-01f, 8.61273408e-02f, 9.84573178e-03f, 2.30877712e-01f, 1.45504102e-01f, 2.90877875e-02f, -7.75054619e-02f,
  -6.90624863e-02f, -3.59503040e-03f, -9.64145064e-02f, 2.37662680e-02f, 2.44760960e-02f, 2.97300499e-02f, 1.41482463e-03f, 4.68993410e-02f, 6.98112026e-02f, 1.71109866e-02f,
  7.50773549e-02f, 2.71752719e-02f, -3.56894806e-02f, 5.71959391e-02f, 3.41609865e-02f, -4.76544574e-02f, -4.22294363e-02f, -3.62030081e-02f, 1.48578305e-02f, -3.64357345e-02f,
  -1.42429797e-02f, -4.11553718e-02f, -1.75144728e-02f, 3.61169055e-02f, -1.98309477e-02f, 9.10506118e-03f, 3.59897353e-02f, 6.84070662e-02f, -6.30776733e-02f, -3.70777845e-02f,
  6.56777993e-02f, 1.67549793e-02f, 5.49187921e-02f, 5.76516874e-02f, -3.92441675e-02f, -1.81812365e-02f, 7.39547536e-02f, 1.48244984e-02f, -3.41447722e-03f, -2.94991173e-02f,
  -8.64537507e-02f, 8.53588898e-03f, 3.06021497e-02f, 5.48151042e-03f, 2.79825963e-02f, -5.58017939e-02f, -4.94468072e-03f, 2.87016649e-02f, 4.44281567e-03f, -3.21406238e-02f,
  -3.14057916e-02f, 3.07636615e-03f, 4.99378219e-02f, 3.47777596e-03f, 2.09916313e-03f, -7.71694332e-02f, 2.73772161e-02f, 4.66869175e-02f, 3.56228426e-02f, -5.04001565e-02f,
  1.53790385e-01f, 1.89301640e-01f, 4.28703539e-02f, -8.48897025e-02f, -5.11450358e-02f, -4.02421365e-03f, 1.23772807e-02f, -4.29321229e-02f, -1.40697761e-02f, -2.14762129e-02f,
  -2.16823891e-02f, -9.70773399e-03f, 1.12923561e-02f, -5.34157716e-02f, -8.74969289e-02f, 1.37175880e-02f, 6.31283894e-02f, 6.77761361e-02f, 8.44394322e-03f, -6.75170645e-02f,
  1.01614855e-01f, -1.66880665e-03f, 5.68220578e-02f, 1.37303406e-02f, 2.19744183e-02f, 3.52886207e-02f, 3.35516408e-02f, 1.36138750e-02f, 3.43420804e-02f, 6.02060705e-02f,
  -4.56957221e-01f, 5.26464498e-03f, -8.21543708e-02f, -3.19595151e-02f, 4.30855229e-02f, 1.51269019e-01f, 5.06911092e-02f, 7.28687271e-02f, 1.95050947e-02f, 1.21917225e-01f,
  5.68660982e-02f, -9.27609280e-02f, 9.23744217e-03f, -1.54311284e-02f, -2.97221869e-01f, 9.42883082e-03f, -3.47360857e-02f, 3.83538827e-02f, -9.29339882e-03f, -1.07314207e-01f,
  -7.47839957e-02f, -1.28351718e-01f, -2.57456135e-02f, -8.19190219e-02f, -1.39455467e-01f, 5.30830920e-02f, -1.34538114e-01f, -1.11361418e-03f, 7.53686354e-02f, -2.42730435e-02f,
  8.61761719e-03f, -5.91309592e-02f, 1.14493966e-02f, 1.19414814e-02f, 3.12562697e-02f, 1.85150914e-02f, 2.59652771e-02f, -1.01883914e-02f, 4.74219117e-03f, -1.49301961e-02f,
  9.15682986e-02f, -7.75349289e-02f, 4.27905545e-02f, -4.30165865e-02f, -1.39135141e-02f, -9.13618505e-03f, 4.65524010e-03f, 2.54227985e-02f, -3.16560827e-02f, -6.75534233e-02f,
  5.87847158e-02f, 2.91776434e-02f, 8.87129903e-02f, 4.15934809e-03f, -1.77126862e-02f, -8.61358568e-02f, 9.89233237e-03f, 1.61068421e-02f, 2.52940357e-02f, 8.90233647e-03f,
  -4.18355167e-02f, 4.51545045e-02f, -1.63917150e-02f, -3.46995704e-02f, 1.05656206e-03f, -2.29329728e-02f, -1.31638572e-02f, -8.90001305e-04f, -5.08723333e-02f, -5.10570221e-02f,
  4.07794900e-02f, -4.74726148e-02f, -2.38769576e-02f, 3.18851210e-02f, -6.73257336e-02f, 7.26734176e-02f, 2.15165387e-03f, 6.57677948e-02f, -1.00194989e-03f, 7.07982574e-03f,
  5.06221578e-02f, -8.77694115e-02f, 2.78354287e-02f, 6.40929192e-02f, 4.76776212e-02f, -3.17944922e-02f, -5.24929985e-02f, -6.14200085e-02f, 5.19582108e-02f, 2.88673979e-03f,
  1.32169858e-01f, 2.71754600e-02f, -8.65335166e-02f, 1.13211265e-02f, -6.24997392e-02f, 2.96877641e-02f, 2.51298063e-02f, 3.74176609e-03f, -1.68278515e-02f, 1.95449796e-02f,
  -6.62121549e-03f, 8.06109011e-02f, 3.70726315e-03f, -5.37493229e-02f, -8.87124520e-03f, -2.80592833e-02f, 5.87214343e-03f, -1.31997578e-02f, 7.48490617e-02f, -4.64569125e-03f,
  -4.64769779e-03f, -2.88929623e-02f, -7.91948512e-02f, 8.77612159e-02f, 8.43950883e-02f, 1.06940344e-01f, 8.79501924e-03f, -1.79126691e-02f, 6.53836876e-02f, -1.85000878e-02f,
  1.63120314e-01f, -5.40446304e-03f, -3.39055732e-02f, -1.00263275e-01f, -1.97564989e-01f, -1.34205326e-01f, -1.72421902e-01f, -1.35562113e-02f, -7.12027773e-02f, -3.71344690e-03f,
  -8.30382407e-02f, 4.06194553e-02f, 1.75323829e-01f, -4.46453094e-02f, 9.27356258e-02f, 1.40267462e-01f, -6.89348355e-02f, -3.67672965e-02f, 5.74748255e-02f, 2.29096152e-02f,
  2.26090495e-02f, -1.26185551e-01f, 7.49830827e-02f, -5.46632744e-02f, -6.52414886e-03f, 9.94670689e-02f, -9.18636844e-02f, -2.54271459e-02f, -7.37734810e-02f, -7.32622296e-02f,
  1.03446558e-01f, 1.14866547e-01f, -5.27039208e-02f, 9.32350531e-02f, -2.09107436e-02f, -1.88419092e-02f, 6.19132966e-02f, -4.44035120e-02f, 5.71414940e-02f, -1.85918007e-02f,
  7.40833208e-03f, 4.41168882e-02f, -3.47205028e-02f, 3.79097201e-02f, -5.48866354e-02f, -1.04338974e-01f, 1.25337802e-02f, -1.05593400e-02f, 2.50640837e-03f, -3.99487652e-02f,
  -7.95500875e-02f, 5.15896222e-03f, 2.70012412e-02f, -4.99822646e-02f, -1.31738037e-02f, 4.62415144e-02f, -1.16111366e-02f, 5.86932041e-02f, 3.98299992e-02f, -8.43350068e-02f,
  1.30143791e-01f, 7.48132244e-02f, -1.27648814e-02f, -2.30436889e-03f, -3.96402441e-02f, 2.17238795e-02f, 3.23067512e-03f, 3.16948555e-02f, -4.48702089e-02f, 2.99481675e-02f,
  -5.13496920e-02f, 3.09450403e-02f, -2.62234397e-02f, -1.26595283e-02f, 5.60781220e-03f, 3.92926112e-02f, 5.88014238e-02f, 8.15546364e-02f, 5.06021408e-03f, 2.13644910e-03f,
  8.31822213e-03f, -3.56356613e-02f, 2.99459603e-02f, -5.78604862e-02f, -1.55927977e-02f, -3.84223796e-02f, -7.10074306e-02f, 5.40774353e-02f, -2.65727323e-02f, 2.12863423e-02f,
  -4.66412827e-02f, 9.85839888e-02f, 1.41365854e-02f, 4.83431965e-02f, 1.43212397e-02f, 3.43704820e-02f, -3.43663730e-02f, 7.54603818e-02f, 3.84251550e-02f, -8.66052508e-03f,
  -4.44669798e-02f, 2.01744027e-02f, -6.83120638e-02f, -8.37720186e-03f, 8.34757313e-02f, -3.84125821e-02f, 1.13606115e-03f, -7.29108676e-02f, -3.64449173e-02f, 2.77523044e-02f,
  3.50007005e-02f, -3.86078842e-02f, 2.38085054e-02f, -5.59920743e-02f, 2.00744700e-02f, -2.37373654e-02f, -2.45491229e-02f, -1.01146614e-02f, -4.03559804e-02f, -5.71914800e-02f,
  3.60678405e-01f, -8.06403309e-02f, -1.71403468e-01f, 2.11149186e-01f, 1.53698251e-01f, -1.02290116e-01f, -1.34182781e-01f, 2.00566635e-01f, -6.26240894e-02f, 2.66105123e-02f,
  7.42361695e-02f, -1.41527623e-01f, -1.37344480e-01f, 5.97698018e-02f, -1.32900523e-02f, -9.72749516e-02f, 7.95801077e-03f, -1.02596888e-02f, -1.34425625e-01f, 2.82175969e-02f,
  1.16805285e-01f, 1.69986919e-01f, -4.36545461e-02f, 1.01506241e-01f, 7.25233927e-02f, 1.11981548e-01f, 1.53009087e-01f, -6.57039657e-02f, 1.27869502e-01f, -1.76944017e-01f,
  -1.04860961e-01f, -9.59149599e-02f, 6.14046119e-02f, -4.12454158e-02f, 1.97245795e-02f, 1.01037752e-02f, -8.86143148e-02f, -7.38819912e-02f, -2.20196974e-02f, -9.93364304e-03f,
  -5.93164051e-03f, 1.56163499e-02f, 2.39265207e-02f, -4.33420613e-02f, -1.47026749e-02f, 8.05929489e-03f, 1.41431680e-02f, 7.14768609e-03f, -1.82487890e-02f, -6.31850660e-02f,
  5.77580091e-03f, -7.42896125e-02f, -1.24500459e-02f, -6.88549504e-03f, 4.02722768e-02f, 1.73798092e-02f, -7.06886575e-02f, -6.60455152e-02f, 1.48697924e-02f, 1.44893862e-02f,
  7.96292126e-02f, -9.17291567e-02f, -5.07482663e-02f, -8.87975562e-03f, 1.85492467e-02f, 3.28492038e-02f, -4.75802412e-03f, -1.87964235e-02f, -3.03165615e-02f, -2.37876903e-02f,
  1.01875134e-01f, -3.45047303e-02f, -6.41816780e-02f, 1.79644674e-02f, -4.01850156e-02f, 1.50077092e-02f, -2.08597500e-02f, 5.41249104e-02f, 6.87467530e-02f, -1.03873247e-02f,
  3.71341743e-02f, 5.05873784e-02f, 4.67302650e-02f, -2.21790187e-02f, 3.41580883e-02f, -4.87419590e-02f, -3.62921432e-02f, -8.85094749e-04f, -7.73452036e-03f, -2.55882442e-02f,
  -4.89969030e-02f, 6.24813847e-02f, -1.22919986e-02f, -4.00634445e-02f, -4.69307154e-02f, 6.81968927e-02f, -6.28896132e-02f, 6.88474029e-02f, -6.23587565e-03f, 5.53759560e-02f,
  3.97249125e-02f, 1.80182586e-04f, -8.72902386e-03f, -4.83691692e-02f, 1.52717549e-02f, -1.85232460e-02f, -5.47021404e-02f, 3.76802124e-02f, 8.96890238e-02f, 1.95314977e-02f,
  8.05224180e-02f, 1.75928883e-02f, 1.62226129e-02f, 1.25984281e-01f, -2.35902192e-03f, -4.37953584e-02f, 4.34844233e-02f, -3.65115665e-02f, 1.67947635e-02f, -5.11900820e-02f,
  1.07789464e-01f, 1.78405330e-01f, -2.16893643e-01f, -7.18153566e-02f, -8.88013095e-02f, -5.83086275e-02f, -1.36118740e-01f, -1.39224920e-02f, -9.23472866e-02f, 6.65297508e-02f,
  3.93526107e-02f, -3.72420773e-02f, 4.66420464e-02f, 6.18723594e-02f, -2.33441591e-01f, 1.81530565e-02f, -3.05872373e-02f, 6.26957789e-02f, 4.53624129e-02f, 1.40932620e-01f,
  7.07791699e-03f, 7.01621249e-02f, -1.11302316e-01f, 1.96144041e-02f, 4.59543951e-02f, 4.05520713e-03f, -5.42229526e-02f, -3.47054340e-02f, 5.93123063e-02f, -2.64647882e-02f,
  7.24836066e-02f, -1.03773810e-02f, 9.82117280e-02f, 1.27652083e-02f, 1.08073212e-01f, -3.61274555e-02f, -5.92628820e-03f, -1.41532779e-01f, -3.41549776e-02f, -1.17986016e-02f,
  -2.45798216e-03f, 1.26968902e-02f, 5.01862308e-03f, -1.81426127e-02f, -2.46276204e-02f, -8.31658952e-03f, 1.30876424e-02f, 1.07486499e-02f, 7.50191335e-04f, -5.42385727e-02f,
  4.81770970e-02f, -1.85949299e-02f, 5.13079278e-02f, -2.85744797e-02f, -1.16192270e-02f, -5.58431484e-02f, -2.98608411e-02f, -2.47271545e-02f, 7.97154456e-02f, -2.50818562e-02f,
  -7.05327615e-02f, 2.57926118e-02f, 3.07807494e-02f, 5.53010516e-02f, -8.03121831e-03f, 5.70667870e-02f, -5.65104792e-03f, -5.24862520e-02f, -3.32723446e-02f, -8.27375101e-04f,
  2.22718157e-02f, -1.81647893e-02f, 5.15951850e-02f, 7.23800063e-02f, 2.21182518e-02f, 1.27590653e-02f, 1.28596388e-02f, -6.93388004e-03f, 6.04033880e-02f, 5.75734414e-02f,
  -5.95233291e-02f, -8.40796828e-02f, 1.42598161e-02f, -5.12162000e-02f, -4.24921885e-02f, -5.01800589e-02f, 6.00293512e-03f, -5.79332747e-03f, 2.17921454e-02f, -4.43817116e-02f,
  2.85676301e-01f, 6.87565804e-02f, 4.32926044e-02f, 6.25093803e-02f, -5.78070171e-02f, 3.96562777e-02f, 1.97142810e-02f, 5.01751639e-02f, 4.15323675e-02f, -6.19306043e-02f,
  6.42805099e-02f, 2.02988870e-02f, 4.09755111e-02f, -5.91808185e-03f, 1.43458024e-02f, -3.33741903e-02f, -2.03096084e-02f, 6.82849735e-02f, 6.80292994e-02f, 9.15959850e-02f,
  9.07844119e-03f, 1.37508944e-01f, -4.07773666e-02f, 1.31623885e-02f, -1.77675881e-03f, -3.86838429e-02f, -2.12149695e-02f, -9.38984379e-03f, -5.21213748e-02f, 1.20167667e-02f,
  4.25011188e-01f, -3.88155341e-01f, 2.52704084e-01f, 6.55957088e-02f, 1.17259078e-01f, -1.00864522e-01f, 1.16453074e-01f, -4.31654491e-02f, -1.90609291e-01f, -2.06885114e-01f,
  7.87393302e-02f, 7.25610405e-02f, 1.07468039e-01f, -4.58021387e-02f, 1.65017918e-01f, -1.06158189e-01f, -4.37781513e-02f, -4.51877117e-02f, -1.19400360e-01f, 4.39893752e-02f,
  -1.12819429e-02f, -1.23372577e-01f, 1.55136496e-01f, -3.17342132e-02f, 1.39256760e-01f, 3.56900431e-02f, 8.67546722e-02f, 1.46994308e-01f, -6.19923957e-02f, 6.14969209e-02f,
  7.38686994e-02f, 1.48316592e-01f, 1.54890880e-01f, -4.02522869e-02f, 1.32509887e-01f, 6.35147542e-02f, 4.12093811e-02f, 8.53560343e-02f, 6.80291504e-02f, -4.29803915e-02f,
  1.58705972e-02f, 2.06158720e-02f, -6.08315095e-02f, 8.59362334e-02f, -1.91936940e-02f, 2.59472145e-04f, -4.10157628e-02f, -7.68142343e-02f, -3.72751579e-02f, -5.68082295e-02f,
  -7.37625435e-02f, -5.52047491e-02f, -1.40186315e-02f, -7.53695369e-02f, 1.40010323e-02f, -5.50780520e-02f, -9.77358781e-03f, 3.71608920e-02f, -7.92394802e-02f, -2.15075891e-02f,
  -2.52370443e-02f, 6.06447384e-02f, -1.27625708e-02f, 1.57257468e-02f, 6.81126416e-02f, -2.78394483e-02f, 1.57710668e-02f, 5.63138574e-02f, 1.10688815e-02f, 8.09659995e-03f,
  4.97969575e-02f, -8.32338724e-03f, -3.34866978e-02f, -1.07376743e-02f, -1.16559453e-02f, 5.20388819e-02f, 2.78326217e-02f, 2.03013662e-02f, -9.88584608e-02f, -2.53564101e-02f,
  -4.16367762e-02f, -4.92668115e-02f, 3.64812016e-02f, -1.59727894e-02f, -1.54144382e-02f, 2.86939107e-02f, -4.53241207e-02f, -7.14999437e-02f, 5.25676161e-02f, 1.22540006e-02f,
  -1.69431612e-01f, -4.25215326e-02f, -5.31509370e-02f, 1.05381832e-02f, -8.59040469e-02f, -7.17966631e-02f, -1.47288283e-02f, -1.71392187e-02f, -5.92029542e-02f, 1.12867523e-02f,
  3.86698428e-03f, 4.91799526e-02f, 2.95737330e-02f, -5.57955243e-02f, -3.67359109e-02f, -8.42945948e-02f, 4.06511463e-02f, 3.26109640e-02f, 9.24653932e-03f, -5.70411757e-02f,
  2.65762806e-02f, 5.16966991e-02f, 2.10133530e-02f, -1.75949861e-03f, 3.04859784e-02f, 7.01611042e-02f, 5.08905835e-02f, -1.41757615e-02f, 1.69890784e-02f, -2.77199093e-02f,
  -2.93008059e-01f, 1.43752143e-01f, 3.65291238e-01f, -1.49956018e-01f, 2.28604913e-01f, 2.92894751e-01f, 1.34066597e-01f, 1.22201808e-01f, -3.59127000e-02f, -1.43591583e-01f,
  2.29924079e-03f, -1.65690586e-01f, -1.78314336e-02f, -5.41560398e-03f, 1.32191524e-01f, -2.91663292e-03f, 1.29449219e-01f, -1.14896456e-02f, 1.31775159e-02f, 9.24846530e-02f,
  1.05400354e-01f, 1.47106647e-01f, 1.10629991e-01f, 1.12578616e-01f, 1.63194463e-01f, -5.00485562e-02f, -7.27620795e-02f, 1.17281616e-01f, 8.02703723e-02f, -8.16411898e-03f,
  -6.35614153e-03f, -1.97658613e-01f, 1.07176334e-01f, 2.54549570e-02f, 3.58924791e-02f, 1.75623856e-02f, 6.39705211e-02f, -1.80385821e-02f, 1.16304599e-03f, -6.46470934e-02f,
  -8.09626561e-03f, 4.17031124e-02f, -1.82760023e-02f, -3.27308103e-02f, 3.82164009e-02f, -6.18646038e-04f, 5.35679460e-02f, 4.71652001e-02f, 4.07660939e-02f, 3.94378304e-02f,
  6.93540722e-02f, -3.80728990e-02f, 1.29845887e-01f, -9.41173434e-02f, 8.33770633e-02f, -8.60146992e-03f, 4.89644967e-02f, -1.85917392e-02f, 1.66842411e-03f, -2.78067943e-02f,
  -4.05791998e-02f, 1.10660717e-01f, 1.90932360e-02f, 3.46129318e-03f, 6.62721992e-02f, -7.66968057e-02f, 4.37582098e-02f, -5.00938520e-02f, 8.04514363e-02f, 2.35396735e-02f,
  1.73348393e-02f, -2.71350723e-02f, -5.30948229e-02f, -1.00580063e-02f, 1.00519704e-02f, -6.57475218e-02f, 6.53072894e-02f, -1.68639608e-02f, 1.63954869e-02f, -1.68585032e-02f,
  2.75639333e-02f, 5.24922237e-02f, -3.33962888e-02f, 8.41581449e-03f, 3.12406011e-02f, 5.13440333e-02f, 7.13316724e-03f, -3.41952890e-02f, -3.79459970e-02f, 2.77102254e-02f,
  1.00828908e-01f, 2.29882095e-02f, -3.27779986e-02f, -1.75418276e-02f, -3.97418067e-03f, 1.46834087e-02f, 7.21508730e-03f, -4.76922281e-02f, 5.61840236e-02f, 3.63263711e-02f,
  -1.84426568e-02f, -6.02176823e-02f, 2.51887944e-02f, 3.14688981e-02f, 1.46574294e-03f, -8.49385653e-03f, -2.11352222e-02f, -8.61985143e-03f, -1.66832190e-02f, 5.69265336e-03f,
  -3.57656516e-02f, 4.72245459e-03f, -1.04757458e-01f, -1.47302067e-02f, 3.80375534e-02f, -1.38256485e-02f, 1.87787767e-02f, -4.91444245e-02f, 8.16573109e-03f, -1.23159960e-03f,
  1.04634706e-02f, 7.14575946e-02f, 3.29520494e-01f, 1.32816974e-02f, 1.06560096e-01f, 8.41712728e-02f, 1.33459717e-01f, 1.36630267e-01f, 4.15340625e-03f, -1.69149965e-01f,
  -9.89226028e-02f, 3.48699801e-02f, -3.31099443e-02f, -5.85025661e-02f, -1.58488359e-02f, -3.19687538e-02f, 9.01889279e-02f, 3.23980115e-02f, 1.22649871e-01f, 8.51123333e-02f,
  4.23862860e-02f, 4.39252108e-02f, 1.51911721e-01f, 1.44882709e-01f, 1.30023077e-01f, 5.27056605e-02f, -4.83110473e-02f, 1.09498762e-01f, -3.93793657e-02f, -8.85305330e-02f,
  -1.35840133e-01f, -1.57634057e-02f, 1.65279537e-01f, 7.59987682e-02f, 2.57170815e-02f, 1.09054921e-02f, 5.54325525e-03f, -1.49000995e-02f, 4.97927889e-02f, 8.58523138e-03f,
  1.53029682e-02f, 8.06985348e-02f, -7.87998736e-02f, -7.01206103e-02f, 5.89457192e-02f, 3.68683762e-03f, 7.55568445e-02f, 7.99432173e-02f, 9.61753801e-02f, 5.10298610e-02f,
  4.82760482e-02f, -1.00381849e-02f, 8.06897413e-04f, -1.01632476e-02f, 5.51054720e-03f, 3.78760189e-04f, -6.50548860e-02f, -3.90408784e-02f, 6.81172535e-02f, -1.95294172e-02f,
  2.74434648e-02f, -2.39049960e-02f, 7.56542832e-02f, 8.23110435e-03f, 2.79510412e-02f, -5.34809008e-03f, -6.56844750e-02f, -6.14593029e-02f, -5.46267666e-02f, -6.48472607e-02f,
  1.76474481e-04f, 2.67389659e-02f, 6.01112545e-02f, -3.96644808e-02f, 2.36260742e-02f, -6.50156066e-02f, 2.23451704e-02f, -5.44761047e-02f, 3.21517363e-02f, -5.21219857e-02f,
  -1.53252846e-02f, -4.46839035e-02f, -4.91305850e-02f, -4.55289297e-02f, 1.71076134e-02f, 1.24453539e-02f, 1.19994697e-03f, -2.06117872e-02f, 1.09703451e-01f, -5.27280942e-02f,
  -1.31509960e-01f, 2.98830308e-02f, -2.18953229e-02f, -6.18026853e-02f, 5.22892736e-02f, -9.98339523e-03f, 7.29937926e-02f, 3.04784570e-02f, -5.51021695e-02f, 6.78152889e-02f,
  4.05035540e-03f, -7.51148090e-02f, 2.14649644e-02f, -4.76642661e-02f, 1.39131201e-02f, -6.83370829e-02f, -1.87525433e-03f, -8.02234933e-02f, 6.02306686e-02f, -1.97518195e-04f,
  6.93376511e-02f, -9.28567909e-03f, -6.19735382e-02f, 4.32593152e-02f, -9.26161259e-02f, -2.66085882e-02f, -5.44978194e-02f, 4.51049581e-02f, 1.37873208e-02f, 1.66120734e-02f,
  -2.97807276e-01f, -7.53066549e-03f, -4.63031195e-02f, -2.78864473e-01f, -8.11522752e-02f, 5.37330061e-02f, -3.69857699e-02f, -1.33818403e-01f, -2.28495255e-01f, -3.80866751e-02f,
  1.31273448e-01f, -1.49133936e-01f, 2.80403078e-01f, -3.16665904e-03f, 6.87025189e-02f, 2.68729091e-01f, -2.33016074e-01f, -1.21742614e-01f, 2.15432737e-02f, -2.40359679e-01f,
  -9.92025482e-04f, -2.18126038e-03f, 1.25585243e-01f, 1.16605915e-01f, -5.15536517e-02f, -5.88822179e-02f, -4.16891985e-02f, 1.81355342e-01f, -3.85109521e-02f, 7.92229474e-02f,
  9.31912661e-02f, -7.01938430e-03f, -1.35654153e-03f, 2.39756517e-02f, -3.37084047e-02f, -6.84142811e-03f, 6.20467076e-03f, 1.04814999e-01f, 9.33145639e-03f, 1.11761522e-02f,
  -3.68476175e-02f, -1.56190554e-02f, -5.27513921e-02f, 3.44124548e-02f, -4.50111181e-02f, -4.04327624e-02f, -2.78344378e-02f, 1.23865539e-02f, 1.56023772e-02f, -1.15626119e-03f,
  1.39726242e-02f, 8.90864804e-03f, -9.30117518e-02f, -7.31304241e-03f, 1.82951381e-03f, 1.39589878e-02f, 2.46901773e-02f, 4.72344831e-02f, 1.73364840e-02f, -2.26786677e-02f,
  3.91134322e-02f, -2.83752251e-02f, 7.83476681e-02f, -4.22420502e-02f, 4.84165922e-02f, 2.93342043e-02f, 1.43657951e-02f, 3.41036767e-02f, -1.08169038e-02f, -4.52894205e-03f,
  -1.33554600e-02f, 2.09068805e-02f, -7.17549846e-02f, -5.07776476e-02f, -4.15879712e-02f, 1.01917135e-02f, -2.93810107e-02f, 1.08190253e-02f, -6.59756288e-02f, -5.30799031e-02f,
  -3.75368036e-02f, -4.40584728e-03f, 5.44239432e-02f, 1.21846348e-02f, 4.18449864e-02f, 6.15351275e-02f, -4.14459184e-02f, -1.57989413e-02f, 4.03375030e-02f, 1.41169149e-02f,
  -3.59591059e-02f, -7.95978457e-02f, 1.22651236e-05f, 3.28185782e-03f, -3.69011378e-03f, 5.11932373e-03f, -9.77934338e-03f, -1.95259899e-02f, -9.08634160e-03f, -4.78723459e-02f,
  -9.93882269e-02f, -6.31421655e-02f, 8.84650927e-03f, -8.00488815e-02f, 1.98272965e-03f, 7.09828921e-03f, 2.74517178e-03f, -5.21616004e-02f, -4.18198146e-02f, -5.73674275e-04f,
  4.84829070e-04f, 1.76054239e-02f, 1.25243450e-02f, -2.99230013e-02f, -7.28360489e-02f, 1.36884628e-02f, -1.43475607e-01f, -3.09159737e-02f, 2.38400642e-02f, -7.41712330e-03f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.40531815e-03f, 8.43414813e-02f, 1.16964415e-01f, -3.36463191e-02f, -5.22586145e-02f, 7.40816444e-02f, 8.87927264e-02f, -4.56827395e-02f, -9.65712313e-03f, 6.60076067e-02f,
  8.02603811e-02f, 6.01891719e-04f, -7.86738545e-02f, -1.00409359e-01f, -1.23764820e-01f, -1.15698457e-01f, 1.31522315e-02f, 6.31945150e-04f, -7.17452615e-02f, 8.53568539e-02f,
  -8.03293213e-02f, -4.88798916e-02f, -2.94238571e-02f, 2.35499684e-02f, 1.01417758e-01f, 2.08718702e-02f, -1.95418634e-02f, 5.09682000e-02f, 3.06751020e-02f, -6.42472133e-02f,
  3.44300456e-02f, 1.12895474e-01f, 6.81645796e-02f, -9.23491865e-02f, 5.09942211e-02f, 5.55167273e-02f, 2.92485431e-02f, -3.16160619e-02f, 1.02424137e-01f, -1.05643913e-03f,
  2.47651506e-02f, 6.86348826e-02f, 5.50015876e-03f, 1.17263068e-02f, 6.57820031e-02f, 1.42076639e-02f, 1.36706885e-03f, 1.87714249e-02f, 8.03295150e-02f, 3.02613489e-02f,
  -5.61611950e-02f, -1.69609990e-02f, 4.37418222e-02f, 1.04828745e-01f, 1.55935371e-02f, 4.23920415e-02f, -5.35522737e-02f, -4.88490984e-02f, -3.34860273e-02f, 5.61886393e-02f,
  -2.34558899e-02f, 1.75929163e-02f, -8.04642662e-02f, -1.29508786e-02f, 8.35181475e-02f, -4.18994203e-02f, -8.01450089e-02f, -3.05449441e-02f, 6.09453069e-03f, -3.61330248e-02f,
  6.39161691e-02f, 6.57312423e-02f, -2.39625592e-02f, -1.46012018e-02f, 6.37088865e-02f, 8.35218653e-02f, 6.67405408e-03f, -4.48842533e-02f, 6.61925692e-03f, -5.67181520e-02f,
  3.26542067e-03f, 6.27344660e-03f, 2.68994384e-02f, -4.99531887e-02f, 5.24584614e-02f, 8.41204822e-02f, -6.82659373e-02f, 4.43515815e-02f, -5.12789525e-02f, -2.05043666e-02f,
  7.14419186e-02f, 2.46571843e-03f, 4.98659983e-02f, -5.90606108e-02f, 2.37609074e-02f, 6.17770758e-03f, -5.81930391e-02f, -4.87655737e-02f, -3.83404866e-02f, -1.04036681e-01f,
  4.86079650e-03f, 6.09224662e-03f, -6.50863349e-02f, -1.99735165e-03f, 5.94691075e-02f, -1.74843315e-02f, -4.79467474e-02f, 1.72221777e-03f, 6.62748069e-02f, 3.81946727e-03f,
  -7.53481761e-02f, -5.30957393e-02f, -3.03797517e-02f, -2.24334337e-02f, -6.22465089e-02f, 4.55762958e-03f, -5.48336245e-02f, 4.11976725e-02f, -1.75956357e-02f, 8.11207965e-02f,
  -4.20247130e-02f, -3.96480560e-02f, -2.28846446e-02f, -1.25919759e-01f, -9.12232101e-02f, -8.02328363e-02f, -9.47184935e-02f, -1.25469789e-01f, 2.39638947e-02f, -5.99116348e-02f,
  1.37020741e-02f, -7.86821768e-02f, 2.86364593e-02f, -6.68718889e-02f, -2.50830911e-02f, 1.20755658e-01f, -6.91841692e-02f, -5.78393452e-02f, -4.97422181e-02f, -4.16144878e-02f,
  -4.63074744e-02f, -1.89605616e-02f, 1.16672665e-01f, 1.31760389e-01f, -8.98441821e-02f, -7.74844438e-02f, -2.47269552e-02f, -3.46662700e-02f, -9.46695283e-02f, 2.18808968e-02f,
  3.26046348e-02f, -9.75212902e-02f, -1.12092923e-02f, 1.52990511e-02f, 3.69050074e-03f, -2.35319622e-02f, -6.29200563e-02f, -4.30754460e-02f, 5.99669181e-02f, -6.99435174e-02f,
  -1.67461508e-03f, -3.85773070e-02f, 4.66861241e-02f, -6.99307770e-02f, 4.91383746e-02f, -8.25520754e-02f, 5.66445664e-02f, 5.86905293e-02f, 3.05197164e-02f, -6.75068200e-02f,
  -6.57149851e-02f, 7.16572031e-02f, -3.73019390e-02f, -4.40418497e-02f, -2.39633061e-02f, -6.40466511e-02f, 2.25629769e-02f, 3.63800228e-02f, -2.28560958e-02f, -8.81569907e-02f,
  6.32644072e-02f, -1.85468942e-02f, -7.88907856e-02f, -1.62261017e-02f, -1.48902480e-02f, -6.35535736e-03f, -5.66403456e-02f, -3.89233753e-02f, -2.38912627e-02f, 9.00696591e-02f,
  7.18784705e-02f, 1.57330055e-02f, 5.71038201e-02f, -4.55868896e-04f, 2.87498794e-02f, -5.05183339e-02f, 3.86441462e-02f, -2.45685186e-02f, 3.09206592e-03f, 4.35381643e-02f,
  -4.98427898e-02f, 4.71486114e-02f, -2.52714958e-02f, -4.47606444e-02f, -5.93567789e-02f, 9.10557881e-02f, -8.19173530e-02f, -8.16413909e-02f, -1.79316197e-02f, 4.99929748e-02f,
  -3.75559628e-02f, -1.42963052e-01f, 2.81508043e-02f, -1.80463083e-02f, 1.14158001e-02f, 3.03234104e-02f, 5.92329279e-02f, -3.19613628e-02f, -1.27929062e-01f, 1.53165041e-02f,
  -2.27841921e-02f, -6.81404397e-02f, -3.37645635e-02f, -7.90238827e-02f, 5.58688082e-02f, -2.26739049e-02f, 1.23214452e-02f, -4.38115820e-02f, -1.08466603e-01f, -9.06396210e-02f,
  1.63947251e-02f, 4.88789417e-02f, 1.88961588e-02f, 3.75018716e-02f, 6.69032261e-02f, -5.04243448e-02f, 3.44569460e-02f, 5.83620705e-02f, -4.88538621e-03f, -2.60864906e-02f,
  7.50492588e-02f, -1.37455836e-01f, 1.99099392e-01f, 6.59705326e-02f, 8.71705487e-02f, 9.08417180e-02f, 1.20831236e-01f, 1.07354738e-01f, -2.51336377e-02f, -1.65556297e-01f,
  1.07244486e-02f, 1.45854997e-02f, 1.11856408e-01f, -1.44619912e-01f, 6.31535128e-02f, -6.07633479e-02f, -2.59439480e-02f, 2.26817857e-02f, -3.04300934e-02f, -4.33646850e-02f,
  -7.14646801e-02f, -9.17866230e-02f, 9.68920887e-02f, -9.49573144e-02f, -5.82862422e-02f, -6.79875445e-03f, -9.73812267e-02f, -4.75145541e-02f, -9.83250886e-02f, -1.79070923e-02f,
  -6.16806410e-02f, -5.48165478e-02f, 5.15677705e-02f, 8.31424445e-02f, 2.56592017e-02f, 4.72777570e-03f, 7.62359053e-02f, -2.97278631e-02f, 2.30197739e-02f, -3.94290648e-02f,
  3.64777967e-02f, 1.95685681e-02f, -9.92257893e-02f, -6.84952959e-02f, -6.79744929e-02f, 5.49722761e-02f, 8.13417137e-02f, 1.36484737e-02f, 6.61572441e-02f, -1.31159173e-02f,
  -2.09541363e-03f, -2.97726691e-02f, 6.10839278e-02f, 5.64111546e-02f, 5.31241708e-02f, -7.36612678e-02f, 8.17390680e-02f, 9.24811512e-02f, 8.99060443e-02f, -1.64052714e-02f,
  -4.56979163e-02f, -7.76608139e-02f, -4.61692028e-02f, 3.83627275e-03f, -5.95532283e-02f, 1.66142527e-02f, 1.16633382e-02f, -8.63369331e-02f, 3.18667330e-02f, 1.02590129e-01f,
  4.83449027e-02f, -1.46938404e-02f, -1.84153020e-03f, 5.84557839e-02f, -9.19528678e-02f, -3.44611630e-02f, -8.34498405e-02f, -5.48843630e-02f, 5.67176938e-02f, -4.51199487e-02f,
  -1.01762332e-01f, -1.64038707e-02f, -8.58799815e-02f, -3.67477015e-02f, 9.46003273e-02f, 4.97894287e-02f, -8.90652090e-02f, 2.99548861e-02f, -7.45858327e-02f, 4.07307521e-02f,
  -9.74670351e-02f, -7.29493424e-02f, -6.30080178e-02f, -8.02004486e-02f, -1.00394182e-01f, -9.18750688e-02f, 1.27689186e-02f, -5.25052659e-02f, 4.92622964e-02f, -2.24726442e-02f,
  -1.82899069e-02f, 5.32971025e-02f, 6.48921281e-02f, 5.00007719e-03f, 3.44036669e-02f, -6.96568117e-02f, -4.41337936e-03f, -1.65818464e-02f, 4.71281111e-02f, -5.39009906e-02f,
  -6.44614622e-02f, 6.39141798e-02f, 7.52511770e-02f, 3.28483917e-02f, -1.32132024e-02f, 3.37560512e-02f, 3.82536165e-02f, 8.40352383e-04f, -3.27472873e-02f, -7.29063377e-02f,
  5.59542794e-03f, -6.93516284e-02f, -1.73624545e-01f, -9.28866416e-02f, -3.44731323e-02f, -1.47237197e-01f, -1.55324563e-01f, 1.36469370e-02f, -1.41645372e-01f, 1.23959795e-01f,
  -4.40066978e-02f, -8.96452665e-02f, 8.37728232e-02f, -4.12364788e-02f, -5.57824448e-02f, -9.35685709e-02f, -2.73227971e-02f, 2.31070239e-02f, -8.27716962e-02f, -2.81778984e-02f,
  -4.54414785e-02f, 7.37276226e-02f, -8.64755884e-02f, -7.37323007e-03f, -1.05374128e-01f, 2.02360619e-02f, 3.99864949e-02f, 5.44565506e-02f, -2.96812877e-02f, 2.14143265e-02f,
  -1.16264395e-01f, -1.44446582e-01f, -4.93012443e-02f, -4.85135987e-03f, 4.13005101e-03f, -7.49974623e-02f, 7.32713789e-02f, -2.02575028e-02f, -3.26404721e-02f, 3.13914157e-02f,
  3.25773917e-02f, -3.09360567e-02f, -6.20590970e-02f, -3.94196101e-02f, 6.61167828e-03f, -7.33270049e-02f, 7.57503211e-02f, -7.24014416e-02f, 9.84911714e-03f, -1.61105469e-02f,
  -3.99995260e-02f, -4.54007797e-02f, 3.96144353e-02f, 5.10195941e-02f, -1.29557475e-02f, 7.67490268e-02f, 2.68116146e-02f, -7.73084164e-02f, -7.32472539e-02f, -1.02645069e-01f,
  3.96474712e-02f, 7.17290640e-02f, -1.08254440e-02f, -6.47711456e-02f, -8.21785033e-02f, 3.98625843e-02f, 3.42967696e-02f, -2.51470339e-02f, 3.75429019e-02f, 2.49625184e-02f,
  4.21300232e-02f, 1.90987450e-03f, -7.33616054e-02f, 6.73099533e-02f, -4.46767323e-02f, -9.05391388e-03f, -1.76020786e-02f, 1.36415884e-02f, 5.13870735e-03f, 3.51402089e-02f,
  -6.23257831e-02f, -7.70440996e-02f, -6.96245208e-02f, -5.88517189e-02f, -3.46212871e-02f, -6.60042018e-02f, 2.27029491e-02f, -1.03759840e-01f, -5.42870425e-02f, 8.24127570e-02f,
  -8.31229910e-02f, -1.54636353e-01f, -4.32519242e-02f, 3.10242688e-03f, 3.33102718e-02f, -4.86795492e-02f, -1.72442291e-03f, -2.27694735e-02f, 2.66341995e-02f, -2.23639011e-02f,
  2.54997667e-02f, -9.82468575e-03f, -1.00419447e-01f, 2.05020458e-02f, -4.37174924e-02f, 1.59496011e-03f, -1.02643371e-02f, -5.35305776e-02f, -5.70591390e-02f, 7.40895495e-02f,
  -4.17586006e-02f, -2.30828393e-02f, -2.72239596e-02f, 3.96886058e-02f, -2.38072388e-02f, -2.26831064e-02f, 4.51303683e-02f, -4.36536558e-02f, -9.55914259e-02f, -7.61400163e-02f,
  1.99047085e-02f, 1.39691785e-01f, 2.63766468e-01f, 2.41381526e-01f, -1.49499267e-01f, -2.58271158e-01f, -1.64021149e-01f, -1.47082321e-02f, -9.16764736e-02f, 5.13110161e-02f,
  -2.04020087e-02f, 9.23522115e-02f, 2.96539329e-02f, 5.96067496e-02f, 1.01434596e-01f, -3.59577946e-02f, 4.73251566e-02f, -6.41098619e-02f, 1.44309830e-02f, 2.18229711e-01f,
  1.18742548e-01f, 7.93343484e-02f, 2.80562133e-01f, 9.75622702e-03f, 6.39906079e-02f, 1.13676406e-01f, 2.21379131e-01f, 9.76955593e-02f, 7.85172656e-02f, 4.18652967e-02f,
  -3.84276882e-02f, 6.12150393e-02f, 6.76011965e-02f, -1.88502297e-02f, 3.27266045e-02f, -4.69995327e-02f, -2.70339716e-02f, -4.32063863e-02f, 9.43846628e-02f, 8.62220116e-03f,
  -9.56233293e-02f, -2.20686570e-03f, 5.35324030e-02f, 9.27449018e-02f, 3.60237248e-02f, -2.30211783e-02f, -5.49512468e-02f, 6.95987120e-02f, -6.34907410e-02f, 1.04177378e-01f,
  1.43206716e-01f, 1.32174632e-02f, -4.83837575e-02f, -7.23952129e-02f, 6.22264035e-02f, 2.45105866e-02f, 6.45569116e-02f, 5.13341315e-02f, -2.38868650e-02f, -6.32358119e-02f,
  -3.50493146e-03f, 2.49541849e-02f, -3.13868448e-02f, 2.76827365e-02f, -3.07868198e-02f, -6.59048408e-02f, -7.46021420e-02f, -5.45427725e-02f, 2.96654720e-02f, 3.42439227e-02f,
  -1.44735456e-03f, -1.95084512e-02f, 3.01669370e-02f, -6.38759509e-02f, -6.57269685e-03f, -2.90233139e-02f, 8.17593187e-02f, -1.90158281e-02f, 9.09025408e-03f, -3.73046920e-02f,
  -3.83335799e-02f, 5.20134121e-02f, 7.86788203e-03f, -9.37384292e-02f, -7.50018582e-02f, 1.84061937e-02f, 3.59970927e-02f, -1.69666298e-02f, 2.11287439e-02f, 1.98851414e-02f,
  3.67574394e-02f, 2.33118668e-01f, -1.42834699e-02f, -1.36446953e-02f, 4.61307615e-02f, -1.31460845e-01f, -1.68781809e-03f, 1.36243161e-02f, 5.88636734e-02f, 4.61836010e-02f,
  -5.67448400e-02f, -6.92097610e-03f, -7.83197433e-02f, 1.00004181e-01f, 5.11937588e-02f, 2.16551255e-02f, 8.44274163e-02f, 2.17542071e-02f, -4.48323078e-02f, 7.70771652e-02f,
  1.09404087e-01f, -1.22895144e-01f, -1.26695670e-02f, 3.99205796e-02f, 9.97253060e-02f, 1.49376625e-02f, 2.16109231e-02f, 8.81244540e-02f, 8.32864828e-03f, -6.66976795e-02f,
  1.45651713e-01f, -1.44922305e-02f, 1.23491898e-01f, 9.53970999e-02f, 2.32534613e-02f, -5.60597051e-03f, 3.21562774e-03f, -1.85752194e-02f, 6.39907122e-02f, -8.89408961e-02f,
  4.03712802e-02f, 3.89065184e-02f, -6.62025586e-02f, -5.90460980e-03f, -8.56891572e-02f, -2.29159910e-02f, -2.16309214e-03f, -6.80462644e-02f, -4.26282622e-02f, -9.63682830e-02f,
  2.88697481e-02f, -1.11461215e-01f, -2.33411207e-03f, -1.34975180e-01f, -2.27561295e-02f, 8.99284482e-02f, -1.15229405e-01f, 2.98327766e-03f, 4.65630293e-02f, -1.03845641e-01f,
  -9.66186523e-02f, -5.56419697e-03f, 1.90555770e-02f, 1.63576230e-02f, -6.77663833e-02f, 9.80960131e-02f, -4.02598716e-02f, 7.66107533e-03f, 1.61718652e-02f, -3.67626548e-02f,
  5.44322990e-02f, -1.14763584e-02f, 1.09192422e-02f, -9.29877684e-02f, 3.30938101e-02f, 2.51499610e-03f, 6.93683419e-03f, 8.98900107e-02f, 4.20161374e-02f, 1.88654605e-02f,
  7.01359147e-03f, -6.27207756e-03f, 7.06855506e-02f, 6.81717247e-02f, -2.11780332e-02f, 4.56642658e-02f, 6.85851276e-02f, 5.14034666e-02f, 5.63561916e-02f, 1.32559687e-02f,
  -4.27888185e-02f, -2.70131119e-02f, 5.96018918e-02f, 1.15844952e-02f, -2.51768343e-02f, 1.87911801e-02f, 5.65490732e-03f, -9.03692469e-02f, 2.87832245e-02f, -2.88307481e-02f,
  2.77076382e-03f, 3.34867686e-02f, 9.03432742e-02f, 7.07169473e-02f, -7.32323304e-02f, 3.32003506e-03f, -2.62370743e-02f, -3.56190018e-02f, -5.08990884e-02f, 1.76633373e-02f,
  -5.53964749e-02f, 9.26411301e-02f, -8.34056456e-03f, -3.69053707e-02f, -1.51361516e-02f, 1.35180177e-02f, -5.85701577e-02f, -7.50766397e-02f, 9.47202966e-02f, -1.25602514e-01f,
  -4.47191000e-02f, -1.09940000e-01f, 8.44422877e-02f, 9.20861885e-02f, -1.09515764e-01f, 7.98593387e-02f, 7.51192495e-02f, -2.78598424e-02f, -1.75069962e-02f, 6.68941066e-02f,
  -3.93745722e-03f, -6.04847372e-02f, 4.77220155e-02f, 3.67634930e-02f, 6.34000897e-02f, -4.04712819e-02f, -1.03367619e-01f, -9.84710380e-02f, 2.91560367e-02f, -6.80211931e-02f,
  3.33606265e-02f, -1.02475747e-01f, -4.27623168e-02f, 8.27530678e-03f, 1.93829853e-02f, 2.68154349e-02f, 3.26387994e-02f, 2.26200353e-02f, -4.18137014e-02f, 3.85610312e-02f,
  -2.51185149e-02f, -1.24515586e-01f, -1.17462471e-01f, -3.37615125e-02f, 3.25806700e-02f, -1.23381265e-01f, -1.34427458e-01f, -5.49992807e-02f, -7.90356174e-02f, -1.85185000e-02f,
  -1.45039886e-01f, -4.61511351e-02f, 8.38956889e-03f, -1.61444902e-01f, 1.74849823e-01f, 3.80800627e-02f, -1.81304678e-01f, -6.10006973e-02f, -6.11252747e-02f, -2.09328219e-01f,
  1.59660995e-01f, -1.53316883e-02f, -7.29038566e-02f, -1.14207547e-02f, -1.56819567e-01f, 4.66284156e-02f, 5.73713817e-02f, -6.36365563e-02f, -1.44549450e-02f, 8.44157953e-03f,
  -1.74590290e-01f, -6.84927702e-02f, -1.43509537e-01f, -7.68825784e-02f, -4.05462272e-02f, -8.79610851e-02f, -3.26690748e-02f, 2.41465773e-02f, -9.32573304e-02f, 6.64649298e-03f,
  7.80796111e-02f, 7.49175996e-02f, -4.90938462e-02f, -9.77712125e-03f, -5.30719198e-02f, -4.95384522e-02f, 7.02663558e-03f, -1.12609670e-01f, -7.26958588e-02f, 5.21240868e-02f,
  8.78246967e-03f, -2.64435932e-02f, -8.48131180e-02f, -5.04231453e-02f, 4.78376038e-02f, -2.53712367e-02f, 5.80787323e-02f, -2.66865012e-03f, 2.24172045e-03f, -2.44356431e-02f,
  7.63935819e-02f, -2.45580450e-02f, -3.54636647e-02f, 1.91802848e-02f, 1.23858182e-02f, 1.92516632e-02f, -5.19108213e-02f, -1.59933977e-02f, 4.58059497e-02f, -5.65128913e-03f,
  2.54354421e-02f, -9.19342339e-02f, 5.23035042e-02f, 2.15849597e-02f, 9.61789023e-03f, -4.67768945e-02f, 1.81262475e-02f, 4.57601659e-02f, -5.62883765e-02f, -4.32056934e-02f,
  5.04218526e-02f, 3.30146961e-02f, -2.31276993e-02f, -7.91826844e-03f, -6.82153506e-04f, -3.16545852e-02f, -1.06644966e-01f, 5.28112911e-02f, -8.98323804e-02f, -1.79429713e-03f,
  -2.02854678e-01f, -2.02113748e-01f, -6.93564937e-02f, -1.09954998e-01f, 4.33136076e-02f, 7.41795683e-03f, -5.10330535e-02f, -2.03557052e-02f, -8.57707262e-02f, -5.17642722e-02f,
  -5.54990433e-02f, -5.74000925e-02f, 9.46979374e-02f, 7.95861483e-02f, -4.03436981e-02f, -6.65165633e-02f, -9.86184776e-02f, 1.54447109e-02f, -1.13939969e-02f, -9.05284286e-02f,
  -3.92901711e-02f, 1.26471296e-02f, 5.14565296e-02f, 9.80784371e-02f, -2.68091988e-02f, -7.21724480e-02f, -6.51874617e-02f, 2.44892053e-02f, -1.37495538e-02f, -1.95082705e-02f,
  -4.78887260e-02f, 1.48439199e-01f, 3.64276953e-02f, 6.67606220e-02f, -5.99412322e-02f, -1.24705680e-01f, -6.34487942e-02f, 1.70938578e-02f, 6.16406500e-02f, 9.38130096e-02f,
  1.63711742e-01f, -2.23097708e-02f, 2.08805919e-01f, 9.52808186e-02f, -8.43467563e-02f, 4.27391380e-02f, -1.22633524e-01f, -1.03261702e-01f, -1.65305156e-02f, -2.14736462e-02f,
  8.13262910e-03f, 8.97911713e-02f, 1.80273682e-01f, 1.76910639e-01f, 5.54604903e-02f, 1.05013393e-01f, 1.73307247e-02f, 1.38122410e-01f, -8.62475671e-03f, 1.35310590e-02f,
  1.41959637e-02f, 2.25078743e-02f, -9.28071607e-03f, 5.68818487e-02f, 8.01498815e-02f, -6.41223043e-02f, -5.30644730e-02f, -8.65692571e-02f, -5.35663888e-02f, -6.41876012e-02f,
  1.52852125e-02f, 3.13570425e-02f, -4.46046293e-02f, -2.02925876e-02f, -5.65545894e-02f, 3.30659971e-02f, -3.05822734e-02f, -6.40013441e-02f, 9.48173702e-02f, 4.64289375e-02f,
  -8.26671794e-02f, -6.75603971e-02f, 5.95927122e-04f, 6.32417947e-02f, 3.61402892e-02f, -1.04924820e-01f, -7.36363456e-02f, 6.81047887e-02f, 1.20438579e-02f, -1.00386217e-01f,
  -4.39039171e-02f, -4.68885675e-02f, 1.91155095e-02f, -2.82539558e-02f, 8.22344329e-03f, -5.75617664e-02f, 1.72669757e-02f, 6.18865341e-02f, -8.08788016e-02f, 5.71170412e-02f,
  -2.77376175e-02f, -3.55375297e-02f, 5.57380356e-02f, 5.60265146e-02f, 7.73326159e-02f, 9.72686335e-03f, -8.46787263e-03f, -3.15398946e-02f, 1.05905287e-01f, 3.18324240e-03f,
  -3.78436670e-02f, 6.68465719e-02f, -7.50009045e-02f, -4.09405008e-02f, -2.25842074e-02f, -2.63566002e-02f, -1.11308470e-02f, -8.97212699e-02f, -5.49402013e-02f, -1.05397520e-03f,
  7.65140206e-02f, 4.06943038e-02f, 6.86632022e-02f, 4.90538515e-02f, 1.88441027e-03f, -1.75314341e-02f, -2.17340398e-03f, -3.53900008e-02f, 8.08998644e-02f, -5.41939139e-02f,
  -1.63572021e-02f, 1.45675624e-02f, 5.82457222e-02f, 8.69891346e-02f, 2.25087982e-02f, -1.67436004e-02f, 1.48704443e-02f, -1.50311803e-02f, 9.30331647e-02f, 2.08303556e-02f,
  -4.32366617e-02f, -2.61169095e-02f, -2.90874988e-02f, -4.82375696e-02f, -6.22312631e-03f, -1.09660558e-01f, -2.64756437e-02f, 7.23884106e-02f, 1.17940251e-02f, -6.19390495e-02f,
  -6.82208408e-03f, -1.33935539e-02f, -4.04792689e-02f, -5.53329140e-02f, -6.01419434e-02f, 4.63014953e-02f, -4.14366014e-02f, -7.56130815e-02f, -9.17255431e-02f, 6.84640184e-02f,
  -7.31996000e-02f, -4.59542572e-02f, 3.49910296e-02f, -3.27367857e-02f, -7.95045495e-02f, -5.46325929e-02f, -7.80417249e-02f, 1.21113406e-02f, 5.04533947e-03f, -6.66761026e-02f,
  -4.85482663e-02f, -7.51717240e-02f, 7.54110664e-02f, 3.74362990e-02f, 6.31582662e-02f, 5.48159424e-03f, -5.23367040e-02f, -5.55601381e-02f, -4.61027585e-02f, 7.38741606e-02f,
  3.24676163e-03f, 1.40279271e-02f, 8.92555155e-03f, -1.14200348e-02f, 6.39125556e-02f, 6.75214976e-02f, 4.35914658e-02f, 5.38713634e-02f, 4.98209894e-02f, -1.29938358e-03f,
  -6.17582984e-02f, -8.03119615e-02f, -2.00986415e-02f, -2.00727005e-02f, 1.62329022e-02f, 1.50182936e-02f, -2.46111713e-02f, -7.13450164e-02f, -8.13517645e-02f, 8.03050585e-04f,
  -2.12995727e-02f, -1.54339476e-02f, -6.92459643e-02f, -4.53787521e-02f, 4.97156987e-03f, -7.91321397e-02f, 5.83877489e-02f, 7.65682980e-02f, 9.17406902e-02f, -1.37907965e-02f,
  -3.43838967e-02f, 4.70723398e-03f, 3.34755741e-02f, -2.13398635e-02f, -6.87684417e-02f, -4.85190898e-02f, 9.71501842e-02f, 4.49012816e-02f, 5.31094819e-02f, 5.43566458e-02f,
  -5.80104105e-02f, -1.86282024e-02f, -7.42221549e-02f, 2.26539876e-02f, -9.25827771e-02f, -2.30428241e-02f, -8.30953121e-02f, -3.27584930e-02f, -4.24049646e-02f, 2.51639839e-02f,
  -6.13131374e-02f, 4.80213352e-02f, -2.00834274e-02f, -7.02608749e-02f, -5.02590928e-03f, -5.61693981e-02f, 1.41802728e-02f, 6.52902424e-02f, -8.16505849e-02f, 5.77434525e-02f,
  6.94180094e-03f, -1.09353736e-01f, -5.72193600e-02f, 3.03414483e-02f, 9.96342744e-04f, -4.80008610e-02f, -5.80059439e-02f, 3.20237577e-02f, 2.68355571e-02f, -9.25097838e-02f,
  6.02752045e-02f, 5.37051819e-02f, -5.50757386e-02f, -7.27057829e-02f, -5.41213043e-02f, -7.98225850e-02f, -7.46403411e-02f, -7.87755251e-02f, 1.18374580e-03f, -8.67225304e-02f,
  7.89044872e-02f, 4.47010249e-02f, 6.94968998e-02f, -4.89213690e-02f, 5.46914227e-02f, -5.93292229e-02f, -5.56462677e-03f, -4.86197509e-02f, 1.96398869e-02f, -8.00656006e-02f,
  -3.44605632e-02f, 9.22079850e-03f, 1.04469836e-01f, -6.78900331e-02f, -2.95826774e-02f, -8.74841586e-02f, -1.44755080e-01f, -1.13733234e-02f, 3.12548736e-03f, -9.00748558e-03f,
  1.47601068e-02f, 1.40350936e-02f, -7.41591379e-02f, -7.28209913e-02f, -2.72811085e-01f, -1.72861010e-01f, -1.80445865e-01f, 1.69076398e-02f, -5.67165837e-02f, 8.76064301e-02f,
  -1.02008678e-01f, -1.99106067e-01f, -1.19794741e-01f, 7.47945607e-02f, 7.00662583e-02f, 1.87406033e-01f, -4.22257138e-03f, -6.33422518e-03f, 1.07466109e-01f, -1.51373729e-01f,
  3.23516168e-02f, -1.30095053e-02f, -1.61714330e-02f, 1.70486774e-02f, -9.93477553e-02f, 3.55970412e-02f, -1.68197211e-02f, -8.91716853e-02f, -8.72417092e-02f, -4.80337292e-02f,
  -5.32492017e-03f, -3.79432365e-02f, -3.55150155e-03f, 6.88069675e-04f, -6.41561300e-02f, 3.10455747e-02f, 5.87418228e-02f, 7.67174214e-02f, -3.61440144e-03f, 7.21169561e-02f,
  -2.95379739e-02f, 8.21348187e-03f, 8.81612971e-02f, -9.06679705e-02f, -9.07019302e-02f, 5.36621250e-02f, -5.68626560e-02f, 1.00062927e-02f, 3.06116827e-02f, -7.84050580e-03f,
  -4.40325104e-02f, 1.43332295e-02f, 1.65951978e-02f, -8.20940733e-02f, 4.79406156e-02f, 6.25403365e-03f, 3.83123793e-02f, -3.14367414e-02f, -3.99324484e-02f, 2.07854388e-03f,
  2.62644030e-02f, -6.83228001e-02f, 2.23873649e-02f, 5.59604960e-03f, -5.71340211e-02f, -6.94678202e-02f, -6.62221462e-02f, -2.24976670e-02f, -1.24713004e-01f, -3.88320871e-02f,
  -6.75675422e-02f, 3.23421098e-02f, 3.52071808e-03f, 4.17018160e-02f, 4.40504067e-02f, 1.07496783e-01f, 6.59928545e-02f, 9.80325565e-02f, -5.25391661e-03f, 7.87096620e-02f,
  -7.33627006e-02f, -6.19691908e-02f, -4.04563136e-02f, -2.73479242e-03f, 2.00660620e-02f, 2.42327750e-02f, 3.68122980e-02f, -2.56425012e-02f, 1.71525571e-02f, 2.98131746e-03f,
  -4.22425792e-02f, -3.21002193e-02f, -1.49599016e-02f, -3.30848023e-02f, -5.94689697e-02f, 3.40413861e-02f, 5.57506718e-02f, 3.68766002e-02f, -9.42990035e-02f, -5.31270690e-02f,
  1.29393682e-01f, 9.27636176e-02f, -4.28988039e-02f, 9.61026829e-03f, 2.10972037e-02f, 6.51861308e-03f, 9.86155048e-02f, -6.16138987e-02f, -1.79565549e-02f, -1.70783047e-03f,
  2.13115755e-02f, -1.44545749e-01f, 9.78018157e-03f, 1.02861077e-02f, 1.28323287e-01f, 1.68617770e-01f, 7.31765181e-02f, -9.36888158e-02f, -1.59593597e-01f, -1.96049049e-01f,
  -3.57283503e-02f, 1.12540983e-02f, 7.43819028e-02f, -4.32571769e-03f, 1.04959086e-01f, 7.60853812e-02f, 9.81632546e-02f, -3.99276875e-02f, -6.30189478e-02f, -3.07351034e-02f,
  4.71580401e-03f, 1.03811085e-01f, 1.87706798e-02f, -9.92942527e-02f, -2.48385761e-02f, -8.91678333e-02f, -6.58392534e-02f, 9.27398056e-02f, 5.99187575e-02f, 5.31230271e-02f,
  -9.57452971e-03f, -1.06457978e-01f, 6.82575107e-02f, 8.34571347e-02f, 4.83303145e-02f, 5.32107018e-02f, -7.17828199e-02f, 2.17233878e-03f, -4.39545922e-02f, -2.20149960e-02f,
  1.02908455e-01f, 4.75471951e-02f, 4.71922234e-02f, 2.76587647e-03f, -7.07563013e-02f, -2.09897291e-02f, -8.15474764e-02f, 5.33873625e-02f, -7.32562765e-02f, -3.04658543e-02f,
  -3.85042243e-02f, -7.15462770e-03f, 4.39071143e-03f, 2.55631916e-02f, -9.33948997e-03f, -1.56485345e-02f, 3.56944427e-02f, 8.52265880e-02f, 1.23318732e-02f, -8.05056654e-04f,
  -2.44288221e-02f, 3.31586599e-02f, -1.51850097e-02f, -8.77501909e-04f, -1.87870543e-02f, -4.99253385e-02f, 1.86430514e-02f, -4.61606383e-02f, 3.56089207e-03f, 8.39985311e-02f,
  -5.93216494e-02f, -5.26426919e-02f, 1.25599382e-02f, 2.73392610e-02f, -9.37604234e-02f, -6.59826696e-02f, 6.15195669e-02f, 4.95975313e-04f, 6.66170344e-02f, 1.16998171e-02f,
  -6.01259917e-02f, -7.06702247e-02f, -5.37663512e-02f, -7.50741512e-02f, -1.96348205e-02f, -7.23545551e-02f, -4.27590832e-02f, -2.85134949e-02f, 2.22481433e-02f, -9.00587160e-03f,
  -7.76176825e-02f, -8.74243379e-02f, -7.27897510e-02f, 2.39238758e-02f, 2.39212047e-02f, -4.37226817e-02f, 4.91954759e-02f, 2.53907591e-02f, 1.02473408e-01f, -8.50792453e-02f,
  -3.18342485e-02f, 8.08088947e-03f, -1.73856635e-02f, -1.84824392e-02f, 3.55178863e-02f, -7.45073706e-02f, -5.16210943e-02f, 8.29986781e-02f, -6.74434677e-02f, -6.87139407e-02f,
  3.13856900e-02f, -7.38589838e-02f, -8.30670539e-03f, -5.96321411e-02f, -1.77061465e-02f, 6.45272508e-02f, 5.46040833e-02f, 1.42116575e-02f, 9.42821130e-02f, 2.21965462e-03f,
  1.66526899e-01f, -1.63925052e-01f, -1.67247593e-01f, 9.73891392e-02f, -6.29805028e-02f, -5.23878634e-02f, -2.07856461e-01f, 1.05798908e-01f, -2.67365903e-01f, -2.63255276e-02f,
  8.51095170e-02f, -1.65184617e-01f, -1.73716486e-01f, 9.04421806e-02f, 1.28864408e-01f, -1.86435804e-01f, 6.18500076e-02f, -4.54364950e-03f, -1.40172809e-01f, -1.32749061e-04f,
  9.55690518e-02f, 2.45003358e-01f, 8.91176537e-02f, 3.69769126e-01f, 7.09575787e-02f, 1.63539395e-01f, 2.88883626e-01f, -2.91410624e-03f, 3.83862168e-01f, 1.48645684e-01f,
  -4.01707279e-04f, -7.54216537e-02f, -1.48379225e-02f, -3.67936073e-03f, 1.12310916e-01f, 1.20708935e-01f, 5.71943335e-02f, 9.06557515e-02f, 1.29541801e-02f, -2.80616563e-02f,
  -8.17347392e-02f, 2.12745927e-02f, -1.54404351e-02f, -1.29158590e-02f, 3.15407813e-02f, 5.36206216e-02f, -5.88726290e-02f, -3.59362029e-02f, -9.84244570e-02f, -4.28659804e-02f,
  -9.29089859e-02f, -5.51690422e-02f, -6.15420789e-02f, 4.59333807e-02f, -1.30720455e-02f, -8.79960507e-03f, 6.54946594e-03f, 1.25510674e-02f, -5.28776236e-02f, 5.29250801e-02f,
  3.11073381e-02f, -1.34487655e-02f, 9.74867940e-02f, 2.89963521e-02f, 7.12286308e-02f, -6.22774300e-04f, 9.07076672e-02f, 2.37440877e-02f, -4.14797515e-02f, -3.31419893e-02f,
  5.18196821e-02f, 9.41658486e-03f, -2.25387774e-02f, 5.54874865e-03f, 1.37148118e-02f, -1.29553750e-01f, 2.72952635e-02f, 5.57582863e-02f, 4.97526601e-02f, -1.62622556e-02f,
  -7.36301392e-02f, 3.08850147e-02f, 1.29574044e-02f, 8.59547313e-03f, -2.08847821e-02f, 3.60398591e-02f, 4.40653823e-02f, 2.43823696e-02f, -4.59509380e-02f, 2.08173823e-02f,
  7.84603879e-02f, 9.80683118e-02f, -5.90431355e-02f, 1.53118866e-02f, -4.78962660e-02f, 7.32188821e-02f, -3.76716927e-02f, -4.15294757e-03f, 4.87275273e-02f, -1.16400467e-02f,
  3.76883410e-02f, -3.71896243e-03f, -1.60789657e-02f, 4.29408140e-02f, -3.04963142e-02f, 2.98694484e-02f, -4.41131517e-02f, -1.76798571e-02f, -2.26422236e-03f, 2.55118851e-02f,
  5.54426461e-02f, 3.79474685e-02f, -4.09625657e-02f, 1.02531596e-03f, -3.16325985e-02f, 3.52715552e-02f, 3.25005166e-02f, 7.07970792e-03f, 7.44905323e-02f, -2.78251320e-02f,
  6.19157106e-02f, -1.13782100e-01f, -4.84617054e-02f, 4.11633998e-02f, 1.80945452e-02f, 4.97078858e-02f, 8.58214945e-02f, -3.56470346e-02f, 4.33157310e-02f, -1.03545338e-01f,
  4.57338877e-02f, 5.38803115e-02f, -7.65923709e-02f, 7.18276277e-02f, 3.83826345e-03f, -7.75308460e-02f, -2.13458128e-02f, -6.10396918e-03f, 4.01286818e-02f, -1.37463314e-02f,
  3.62848416e-02f, -1.37048448e-02f, 6.94983006e-02f, 4.02178392e-02f, -4.14612405e-02f, -8.14926028e-02f, -7.98267722e-02f, -1.22197337e-01f, -9.08219069e-02f, 8.27233680e-03f,
  1.31609648e-01f, -4.06233817e-02f, 2.04341654e-02f, 9.67513304e-03f, 1.04949605e-02f, 7.97769502e-02f, -4.26943973e-02f, -3.53511013e-02f, 1.02890521e-01f, 5.42516299e-02f,
  -7.38383085e-02f, -4.81032692e-02f, 8.67583901e-02f, -4.28957865e-02f, 1.77336093e-02f, -5.98131008e-02f, -1.94577947e-02f, -7.60991592e-03f, 5.15812337e-02f, 5.35341874e-02f,
  -5.70615642e-02f, -8.01994056e-02f, -3.22315358e-02f, -6.17793091e-02f, 5.51659353e-02f, -2.03966089e-02f, 2.16763379e-04f, -2.74569429e-02f, -3.72224413e-02f, -2.20138431e-02f,
  -1.94057096e-02f, 4.17086780e-02f, -6.60439357e-02f, -7.60345086e-02f, 3.12416889e-02f, 8.15699100e-02f, 5.38223721e-02f, 1.43687502e-02f, -1.60311479e-02f, 5.85035793e-02f,
  4.89852345e-03f, 1.96439009e-02f, -5.62583394e-02f, 6.87442124e-02f, -8.08271542e-02f, 6.34427508e-03f, 4.12855409e-02f, -3.09317391e-02f, -1.01351812e-01f, 7.14146271e-02f,
  -3.38654928e-02f, 1.64532512e-02f, -6.06859848e-02f, 8.70720949e-03f, -5.65970615e-02f, -4.34504710e-02f, -3.42308693e-02f, -8.40380266e-02f, 1.16281388e-02f, 6.13872819e-02f,
  -3.94411981e-02f, -1.09150358e-01f, -6.55501336e-02f, 2.18837894e-02f, -3.73408683e-02f, 4.96027060e-02f, -7.82671794e-02f, -5.39360046e-02f, 3.28756385e-02f, 4.30672653e-02f,
  -8.80190358e-02f, -3.93968523e-02f, 5.22152968e-02f, 3.94917876e-02f, -2.45562866e-02f, 2.01435741e-02f, -4.29223031e-02f, -5.11939898e-02f, -6.10349476e-02f, -1.96211226e-02f,
  7.99501967e-03f, 6.35347217e-02f, -7.83830434e-02f, 1.19028781e-02f, -8.56594667e-02f, -4.80956398e-03f, 6.26249909e-02f, -4.43951663e-04f, 2.53513902e-02f, -1.14605846e-02f,
  7.42341205e-02f, -2.94163022e-02f, 8.85430817e-03f, 2.59624887e-02f, 7.79479370e-02f, 1.08096115e-01f, 2.42105126e-03f, 6.70032576e-02f, 7.20086098e-02f, -2.84040738e-02f,
  4.40830551e-02f, -6.46524280e-02f, -1.27262235e-01f, -3.69475521e-02f, 2.99095511e-02f, 9.90265794e-03f, 6.07195422e-02f, 8.54294747e-02f, -5.35386764e-02f, 3.78222018e-02f,
  1.24040823e-02f, -6.15354106e-02f, -1.38233736e-01f, -2.07254291e-02f, -5.96018843e-02f, -2.45807096e-02f, -4.00066450e-02f, -1.07921630e-01f, 2.81161629e-02f, 7.25934878e-02f,
  2.36181878e-02f, 3.98949757e-02f, -4.50479798e-02f, 7.52256885e-02f, -1.69398636e-02f, -2.74124108e-02f, 1.05420277e-01f, -2.67893858e-02f, 4.79980558e-02f, -9.06416252e-02f,
  9.09636244e-02f, 7.92788267e-02f, -3.82292792e-02f, 9.42195058e-02f, -3.65812294e-02f, -1.02600060e-01f, -7.20235705e-02f, 1.15408432e-02f, -6.31538685e-03f, -1.31791428e-01f,
  9.55247059e-02f, 6.12288415e-02f, 7.01693445e-02f, -4.08839360e-02f, 1.83484964e-02f, 5.25861196e-02f, 5.99663295e-02f, -2.61938591e-02f, 1.69704501e-02f, -7.30868429e-02f,
  6.19592406e-02f, 6.74551576e-02f, 4.40076403e-02f, -8.30742791e-02f, -3.84289213e-02f, -5.55258952e-02f, -4.21068855e-02f, -2.42068595e-03f, 8.96842703e-02f, 9.71312728e-03f,
  -9.15859491e-02f, 6.05513789e-02f, -6.44739419e-02f, 4.61095609e-02f, -1.70563906e-02f, -2.59147584e-02f, 7.07297996e-02f, 1.40029415e-02f, 1.26690380e-02f, -3.17090973e-02f,
  -1.85696762e-02f, -1.17141297e-02f, -8.22162479e-02f, 3.81393097e-02f, -1.39697213e-02f, 3.07654701e-02f, 5.14229275e-02f, 2.20935512e-02f, 1.64576732e-02f, 3.55408303e-02f,
  1.89860873e-02f, 3.15842591e-02f, -5.76391555e-02f, -1.94773276e-03f, 9.63571598e-04f, 1.99690070e-02f, 4.27990742e-02f, 6.74191937e-02f, -9.56039727e-02f, 5.79066053e-02f,
  4.68485393e-02f, 1.54585848e-02f, 6.62461966e-02f, 4.79470752e-02f, -2.69914605e-02f, -8.99928436e-02f, 2.08195653e-02f, 3.45935635e-02f, 5.57844825e-02f, -6.67081177e-02f,
  1.51602654e-02f, 7.04171434e-02f, -8.50430131e-02f, 8.80640745e-02f, 5.54788411e-02f, 1.04814380e-01f, 7.94544518e-02f, -9.48019549e-02f, 6.69807121e-02f, -5.82048930e-02f,
  7.23596215e-02f, 7.36297341e-03f, -1.09653734e-01f, -9.96046364e-02f, -1.47483479e-02f, -1.41255870e-01f, -1.21577285e-01f, -9.75866690e-02f, 1.86181869e-02f, 8.71651173e-02f,
  -1.27482012e-01f, -2.38797590e-02f, -6.68336153e-02f, -1.59333810e-01f, -2.11943388e-01f, -1.32946596e-01f, -2.36708075e-01f, -1.24850413e-02f, 1.39363727e-03f, -7.36310109e-02f,
  -5.01074567e-02f, -1.02704406e-01f, -7.93615505e-02f, 1.65295489e-02f, -1.00508869e-01f, 8.39417800e-02f, 7.13329315e-02f, 2.61700302e-02f, 1.69901345e-02f, -2.71431003e-02f,
  -6.01964816e-02f, 7.32977092e-02f, 3.12603191e-02f, 1.55715421e-02f, -4.58837077e-02f, 3.72955091e-02f, 2.27203630e-02f, 6.82197139e-02f, 7.83888251e-02f, -2.17703301e-02f,
  -5.84575124e-02f, -1.28852367e-01f, -1.20475125e-02f, 1.43621524e-03f, -1.49854887e-02f, 5.55527722e-03f, -4.04211991e-02f, -5.54447062e-02f, 5.18962555e-03f, 2.50063203e-02f,
  -9.62518230e-02f, -4.92122285e-02f, -6.65481538e-02f, -1.06139891e-02f, -7.76175410e-02f, 4.59530465e-02f, 8.29363149e-03f, -8.43306538e-03f, -4.02488150e-02f, -2.27996595e-02f,
  -4.75555658e-02f, 3.89206000e-02f, 3.86766456e-02f, -8.17934871e-02f, -3.51363197e-02f, -1.16499858e-02f, -2.99491808e-02f, 3.13971192e-02f, 2.96079312e-02f, 5.31024523e-02f,
  -3.95810604e-02f, 8.84920210e-02f, 5.16628250e-02f, 3.25569920e-02f, -1.17235919e-02f, 7.91823715e-02f, 3.04478854e-02f, -4.08500992e-02f, -8.50470960e-02f, -2.95473170e-02f,
  1.92883071e-02f, -1.74186416e-02f, 4.64220531e-02f, 5.53090982e-02f, -5.89546673e-02f, -7.60285929e-02f, 4.49524149e-02f, -3.87132280e-02f, -5.38486913e-02f, -3.73208225e-02f,
  -1.56390704e-02f, -8.22035745e-02f, -7.91477561e-02f, -4.94115576e-02f, 2.64530405e-02f, 6.52261898e-02f, -3.80677804e-02f, -1.02430500e-01f, -9.03682038e-02f, 2.25193854e-02f,
  3.66671123e-02f, -3.13460901e-02f, 2.28370447e-03f, 7.03742057e-02f, -3.89359593e-02f, -5.17478548e-02f, -4.01325412e-02f, 3.65156569e-02f, -2.87396740e-02f, 1.16478518e-01f,
  -3.51282023e-02f, 9.42903906e-02f, 3.60835493e-02f, 8.49462375e-02f, -5.11886999e-02f, 1.88893657e-02f, 5.06435335e-02f, 3.43661457e-02f, -6.37718523e-03f, 3.12837772e-04f,
  -9.41533446e-02f, 3.36635374e-02f, -1.29066035e-01f, 2.50136363e-03f, -4.01455052e-02f, 5.25354929e-02f, 1.15635939e-01f, -4.81884666e-02f, 2.32385844e-02f, 1.02119967e-01f,
  7.60279521e-02f, -8.51292610e-02f, 9.66266543e-02f, 2.39574924e-01f, 1.38445288e-01f, 9.57522765e-02f, 2.51279145e-01f, 1.84373081e-01f, -1.03797428e-01f, -6.67182505e-02f,
  -1.20874289e-02f, 8.77047852e-02f, 1.05752006e-01f, -1.50001235e-02f, 6.42154664e-02f, -7.64116421e-02f, -1.60218647e-03f, -1.36440352e-01f, 5.94487302e-02f, 3.08403187e-02f,
  1.50766568e-02f, -9.31890309e-02f, -2.92451810e-02f, -2.41421279e-03f, -1.35249078e-01f, 1.80799235e-02f, 4.37635556e-02f, -5.05092964e-02f, -3.25942785e-02f, -2.89835725e-02f,
  -3.81817445e-02f, -4.54846807e-02f, -2.33155787e-02f, -1.15074357e-02f, 1.56737212e-02f, -3.38271173e-04f, 1.68707650e-02f, -2.68036854e-02f, 6.08757101e-02f, -7.35465065e-02f,
  -8.07025135e-02f, 5.41894622e-02f, 6.89235255e-02f, -6.74691424e-02f, 4.67077345e-02f, -4.07791808e-02f, -3.34439762e-02f, -7.65982270e-02f, -4.04945351e-02f, -9.51025337e-02f,
  -6.24859370e-02f, -5.44881634e-02f, -1.46190599e-02f, -5.64591661e-02f, -3.45360972e-02f, 3.86708453e-02f, -4.94351052e-02f, 3.94755453e-02f, 2.95557566e-02f, 4.05523479e-02f,
  -9.23612565e-02f, -5.35131879e-02f, 2.27668770e-02f, 1.51636004e-02f, -1.63896028e-02f, 5.93115017e-02f, 4.45179790e-02f, 5.94560392e-02f, 4.73511666e-02f, 6.45935955e-03f,
  -6.26853528e-03f, -8.31112489e-02f, 2.15646531e-03f, 5.79449581e-03f, 4.68866862e-02f, 2.91113723e-02f, 7.58071616e-02f, 2.27190237e-02f, 3.68341921e-06f, -6.84488639e-02f,
  2.29726639e-03f, -9.27795190e-03f, 6.48823380e-02f, 4.21198457e-02f, -6.70447350e-02f, -9.45407525e-03f, -2.86379475e-02f, 4.73353155e-02f, -8.87655765e-02f, -8.35911557e-02f,
  -1.11407809e-01f, -9.24095511e-02f, 1.34462137e-02f, -2.87798233e-02f, -5.31887077e-02f, 2.68935207e-02f, -5.23618981e-02f, -4.69284281e-02f, -4.48648147e-02f, -9.17299762e-02f,
  -6.65738806e-02f, -7.58431330e-02f, 4.58893739e-02f, 6.97713549e-05f, -4.76030596e-02f, 6.63397163e-02f, -6.42383413e-04f, -5.08430600e-02f, -5.22117093e-02f, 2.70098634e-02f,
  2.71202117e-01f, -2.94115663e-01f, -1.84804663e-01f, 6.75824881e-02f, 1.40052840e-01f, 1.43263012e-01f, 9.41217598e-03f, 1.08596254e-02f, -5.54666594e-02f, -1.17798440e-01f,
  1.16741046e-01f, -1.12925358e-02f, -1.73806921e-01f, 8.09730813e-02f, 1.92681134e-01f, -1.17072605e-01f, 9.83230844e-02f, 7.98318610e-02f, 3.63781722e-03f, -5.71310036e-02f,
  1.18604913e-01f, 1.28148600e-01f, -6.40647784e-02f, 7.80315474e-02f, -8.42374004e-03f, -1.11116804e-01f, -6.76051900e-02f, -4.86484133e-02f, 1.39993280e-01f, 1.70833468e-01f,
  3.43624279e-02f, -7.47562572e-02f, -2.79898904e-02f, 5.74353803e-03f, -2.28916686e-02f, -1.08628497e-01f, 5.80272563e-02f, 2.53976882e-02f, 4.10209820e-02f, -3.53072211e-02f,
  -3.93732898e-02f, 3.78688499e-02f, 9.57226455e-02f, 6.58992007e-02f, 8.87416899e-02f, -1.77861676e-02f, 1.06813833e-02f, -3.55486237e-02f, 5.97558990e-02f, -3.02502904e-02f,
  -3.79483104e-02f, -3.11920829e-02f, -8.75462778e-03f, -1.03316950e-02f, 1.73757598e-02f, -3.68380584e-02f, 6.52992539e-03f, -6.43296167e-02f, 4.40428965e-02f, 2.43752208e-02f,
  -1.77174974e-02f, -5.33620156e-02f, -2.57279370e-02f, 6.62121102e-02f, -5.67563698e-02f, 1.09328050e-02f, 2.35554650e-02f, -5.21778427e-02f, -4.80559692e-02f, -8.14123824e-03f,
  -9.32186395e-02f, -2.54738866e-03f, 7.15641156e-02f, -2.26571504e-02f, 1.43517461e-02f, 3.37935947e-02f, -6.65639639e-02f, 2.63399482e-02f, -4.61288169e-02f, 1.78360101e-02f,
  -4.73959222e-02f, 2.16261931e-02f, -5.61534837e-02f, -3.67337503e-02f, 6.51242882e-02f, 3.80447251e-03f, 5.50418794e-02f, 1.98952537e-02f, 3.11138257e-02f, -8.82681906e-02f,
  1.39314840e-02f, -1.94045991e-01f, 5.35151511e-02f, 2.63231695e-02f, -6.75316602e-02f, -5.16212620e-02f, 5.48694730e-02f, 2.42026318e-02f, -8.58941302e-02f, -6.76489696e-02f,
  -3.08769718e-02f, 2.91628018e-02f, -6.39946982e-02f, -2.88288835e-02f, -1.19671999e-02f, -5.44505641e-02f, -2.51575969e-02f, 3.00447369e-04f, -2.06271056e-02f, 3.21444720e-02f,
  -7.19581470e-02f, -1.13623284e-01f, 9.49393213e-02f, -2.42161024e-02f, 1.60227790e-02f, -9.94410440e-02f, -2.47434694e-02f, -2.09462736e-02f, -6.86740428e-02f, 5.36056980e-02f,
  -3.28304805e-02f, 9.59281400e-02f, -5.36964089e-02f, -7.42458627e-02f, 8.11889842e-02f, -8.73606801e-02f, -1.33572847e-01f, -3.02130431e-02f, 8.23208410e-03f, -3.65258865e-02f,
  -1.09601855e-01f, 7.19900727e-02f, 3.95587198e-02f, -1.85082033e-01f, -2.50021309e-01f, -7.97252208e-02f, -9.63223353e-02f, -3.94889228e-02f, -7.35639706e-02f, 8.18532556e-02f,
  -3.39907780e-02f, -1.38916954e-01f, -1.09089026e-02f, 1.51067600e-01f, 7.55690858e-02f, 1.71400309e-01f, 1.51166487e-02f, -1.32934691e-03f, 4.31815498e-02f, 2.46345513e-02f,
  -3.68480273e-02f, -2.12470219e-02f, 7.26750568e-02f, 3.57571132e-02f, 5.92745170e-02f, 5.50252087e-02f, 1.06970407e-02f, 2.64157429e-02f, 5.06928451e-02f, 8.95840675e-02f,
  -6.34526536e-02f, -8.37507378e-03f, -5.55198528e-02f, 4.24252413e-02f, 7.31480196e-02f, -2.80258786e-02f, -6.63522482e-02f, 4.27833125e-02f, 8.75367820e-02f, 1.05192602e-01f,
  -2.34252447e-03f, -7.29401484e-02f, 6.51911795e-02f, 1.16205410e-04f, -1.61738638e-02f, -6.69189319e-02f, -6.98307678e-02f, -4.34796959e-02f, 7.76482150e-02f, 4.71705422e-02f,
  -8.95247236e-02f, 4.65551503e-02f, -6.85653687e-02f, -6.43872991e-02f, 6.06058128e-02f, 1.37590030e-02f, 3.01680085e-03f, 6.12667538e-02f, -2.18761861e-02f, -1.92138292e-02f,
  -4.53109993e-03f, -2.89064813e-02f, -7.70732611e-02f, 3.67264673e-02f, 4.87006120e-02f, 3.71164531e-02f, 7.53144026e-02f, 3.58854681e-02f, 5.65181598e-02f, -4.83816154e-02f,
  -2.52258573e-02f, -1.15397960e-01f, -3.15916128e-02f, -9.73497424e-03f, -8.00251737e-02f, -4.03629132e-02f, 4.05410677e-02f, -3.67507562e-02f, 2.19308008e-02f, 6.78752139e-02f,
  -6.51461780e-02f, -5.21398894e-02f, 6.26178784e-03f, 1.67224184e-02f, 3.45377289e-02f, -1.88622307e-02f, -4.74769883e-02f, 3.72781977e-02f, -2.40786113e-02f, -8.46790373e-02f,
  1.00770608e-01f, 8.40081871e-02f, 5.98232597e-02f, 2.56945547e-02f, 4.75045247e-03f, 1.65423620e-02f, -6.84863850e-02f, -7.17816874e-02f, 2.15537827e-02f, -2.01346762e-02f,
  -8.06452532e-04f, -2.01414227e-02f, 3.16374861e-02f, 7.17572346e-02f, -4.12273407e-02f, -5.59935570e-02f, -6.00961484e-02f, 4.91499677e-02f, -2.94414777e-02f, -2.10165102e-02f,
  -1.76850669e-02f, 4.23731562e-03f, 2.85394657e-02f, 1.62641052e-03f, 1.93809997e-02f, 1.91188026e-02f, 1.76549982e-02f, 4.79687862e-02f, 9.22410786e-02f, -1.03800692e-01f,
  -4.59083654e-02f, 5.31459861e-02f, -4.41082120e-02f, -1.39510967e-02f, 6.09654784e-02f, -8.61000642e-02f, -5.55368103e-02f, -1.17496982e-01f, 5.62388375e-02f, 8.33492875e-02f,
  1.03092939e-01f, 3.98484655e-02f, 3.70421894e-02f, 3.53656337e-02f, 2.33768634e-02f, 6.50344789e-03f, -6.48373738e-02f, 1.09921001e-01f, -1.45079941e-03f, 2.31838413e-02f,
  -1.39806559e-02f, 1.52088311e-02f, -6.24057651e-02f, -6.57971427e-02f, -8.45426321e-02f, -4.79049794e-03f, -5.35849817e-02f, 3.00144479e-02f, 4.12549935e-02f, -8.25513601e-02f,
  -3.52374166e-02f, 5.90636060e-02f, 4.71648127e-02f, -2.78321486e-02f, 4.86982390e-02f, 7.79005736e-02f, -6.24457672e-02f, 4.19094712e-02f, -3.26640420e-02f, -6.06837645e-02f,
  -8.39105546e-02f, 4.54242155e-02f, 4.42278422e-02f, 6.19651899e-02f, 3.24543901e-02f, -5.23449795e-04f, -2.73839347e-02f, 1.01447171e-02f, -7.79064596e-02f, -1.94505434e-02f,
  -2.73825843e-02f, 6.14329502e-02f, -7.04617705e-03f, -7.61649907e-02f, 2.89677344e-02f, -6.84383810e-02f, 4.88288552e-02f, -2.19552238e-02f, 5.01103289e-02f, -6.12251125e-02f,
  -3.44475247e-02f, -4.41412963e-02f, 2.59738211e-02f, 1.75518903e-03f, 4.45631072e-02f, -1.11708520e-02f, 5.08384407e-03f, 3.25941965e-02f, 1.51263699e-02f, 1.80453062e-02f,
  5.03384583e-02f, 2.98417006e-02f, 9.81879234e-03f, 3.92882563e-02f, -2.45462805e-02f, -5.72662726e-02f, -8.74379724e-02f, 8.80802348e-02f, -3.61013860e-02f, 1.99634656e-02f,
  -8.81159529e-02f, -8.47129971e-02f, 4.91553172e-02f, 5.19277118e-02f, 8.72427523e-02f, -4.32232842e-02f, -6.81713298e-02f, -3.50627452e-02f, -6.97967112e-02f, 1.92002095e-02f,
  -2.52426807e-02f, -9.22147334e-02f, -5.06037883e-02f, -2.24465635e-02f, -3.33081745e-02f, 4.54287231e-03f, 8.55066925e-02f, 2.10522879e-02f, 1.04766656e-02f, 2.06796061e-02f,
  5.19976169e-02f, -8.84009227e-02f, 4.94988970e-02f, -5.04061813e-04f, 6.15982264e-02f, -7.55404085e-02f, -8.85348618e-02f, 6.72785714e-02f, 4.87738475e-03f, -3.67139876e-02f,
  1.99498981e-02f, -5.63507937e-02f, 4.41497415e-02f, -2.31499653e-02f, 3.59984078e-02f, 9.87211242e-02f, 9.75978225e-02f, -7.44995195e-03f, -6.88824430e-02f, 1.06915243e-01f,
  1.96129419e-02f, -6.80095106e-02f, 1.04816414e-01f, -9.04060155e-02f, 1.94577258e-02f, 2.92083016e-04f, 5.69278449e-02f, 6.21900111e-02f, 3.19159515e-02f, 5.88895045e-02f,
  1.79569554e-02f, -7.03891888e-02f, -2.87441933e-03f, -9.60474834e-02f, -4.15618867e-02f, 6.13992363e-02f, 6.82533234e-02f, 4.41406555e-02f, 6.85505196e-02f, -3.40108089e-02f,
  3.39577384e-02f, -1.12329377e-02f, 2.51093954e-02f, -7.93524459e-02f, 5.59507385e-02f, 8.97111073e-02f, -4.67600971e-02f, -8.41033161e-02f, -1.39767453e-02f, -9.63811949e-03f,
  -6.31694356e-03f, -1.28917107e-02f, -4.49415632e-02f, 7.57186934e-02f, -4.55027632e-02f, -6.82114810e-02f, -4.63272743e-02f, -5.35776988e-02f, -6.09137565e-02f, -1.03728091e-02f,
  7.59654641e-02f, 5.59181981e-02f, -1.31874429e-02f, 6.90715909e-02f, 1.22114122e-02f, -4.92823683e-02f, -4.21353020e-02f, 7.32486770e-02f, -1.22895101e-02f, 1.55122653e-02f,
  2.75978688e-02f, -8.71663634e-03f, 5.49047403e-02f, 8.72220546e-02f, 5.65482080e-02f, 1.24557931e-02f, -5.79324886e-02f, -7.07889721e-02f, -3.81654538e-02f, 8.70302320e-03f,
  -6.73780143e-02f, -2.96856314e-02f, 3.08341230e-03f, 3.38377580e-02f, 6.04842789e-02f, -8.21084529e-02f, 8.44526589e-02f, 6.19666539e-02f, 7.18791038e-02f, 1.22125456e-02f,
  4.47937660e-02f, 6.73454702e-02f, -5.85567057e-02f, -3.60847861e-02f, 2.21622996e-02f, -2.44904105e-02f, -9.20401514e-02f, -4.90514189e-03f, 8.01910311e-02f, -1.21145295e-02f,
  -7.62910694e-02f, 6.63996190e-02f, -6.64551109e-02f, 4.36246954e-03f, 3.40176187e-02f, 1.74697619e-02f, 2.23391596e-02f, 1.34551208e-02f, -2.53384337e-02f, -6.87179118e-02f,
  4.80108410e-02f, -5.96216240e-04f, -2.59968173e-02f, -1.89530421e-02f, 7.88927358e-03f, 3.66033614e-02f, -3.69084850e-02f, 7.70326108e-02f, -2.39272714e-02f, 7.65556246e-02f,
  -7.90548883e-03f, -3.16869393e-02f, -3.71644087e-02f, -5.58008589e-02f, -6.01668060e-02f, 9.26346108e-02f, -1.71253439e-02f, -4.66834418e-02f, -8.74581113e-02f, 5.11193536e-02f,
  -4.49683797e-03f, -1.19746506e-01f, -1.24166254e-02f, -2.37805713e-02f, -5.14312126e-02f, -1.24110393e-01f, -1.11820921e-01f, -7.11460486e-02f, -8.22583064e-02f, -6.36372790e-02f,
  -1.10356107e-01f, -5.90164810e-02f, 6.16872646e-02f, -1.38338834e-01f, 1.87337607e-01f, 1.32388115e-01f, -9.00729224e-02f, -1.03074305e-01f, -4.14109714e-02f, -8.11743364e-02f,
  -2.77094692e-02f, -1.11140229e-01f, 3.18666659e-02f, -4.97066751e-02f, -3.22971679e-02f, -9.13622603e-03f, -1.53815262e-02f, 1.99395027e-02f, -1.21923434e-02f, -3.28570977e-02f,
  -2.30559260e-02f, -5.89618646e-02f, 2.28376724e-02f, -4.42035161e-02f, -8.19253698e-02f, 3.90433706e-02f, 2.38875449e-02f, 9.44804326e-02f, -4.46573757e-02f, 3.80395800e-02f,
  -2.60853842e-02f, -9.27173942e-02f, -5.02422787e-02f, 8.15272257e-02f, -7.96316341e-02f, 8.69513154e-02f, 7.64742568e-02f, 6.87621236e-02f, -4.71291468e-02f, -4.78828251e-02f,
  -1.27980532e-02f, -3.63152325e-02f, 7.95677584e-03f, -4.02082540e-02f, 8.75834972e-02f, 7.77193010e-02f, -3.18220613e-04f, 4.81258705e-03f, -9.61842537e-02f, -4.00373191e-02f,
  -3.65110720e-03f, -8.02166164e-02f, -2.66689137e-02f, 4.68684472e-02f, 1.22672059e-02f, -5.20413481e-02f, -1.14509370e-02f, -8.79328884e-03f, -4.39961143e-02f, -8.25557783e-02f,
  8.46133307e-02f, -8.35699514e-02f, -1.89654045e-02f, -1.06820457e-01f, 5.35505451e-02f, 2.71738451e-02f, 1.49060227e-02f, 5.57378531e-02f, 2.84649543e-02f, 3.10156681e-03f,
  8.92022401e-02f, 3.04406509e-02f, 3.84211726e-02f, 2.83238366e-02f, 3.62049676e-02f, 1.24859472e-03f, -7.66392574e-02f, -6.47707954e-02f, 7.29941726e-02f, -5.41391857e-02f,
  7.56319687e-02f, -8.85461643e-02f, 7.69462287e-02f, 3.31314430e-02f, 3.21452022e-02f, -6.14085943e-02f, 1.09627787e-02f, -3.06278784e-02f, 7.88529590e-03f, -4.21781912e-02f,
  3.48734818e-02f, 2.66003218e-02f, 5.49149932e-03f, -5.90106174e-02f, -1.09381638e-02f, -7.14886487e-02f, 8.91255494e-03f, 1.06593613e-02f, 4.67792116e-02f, -7.50943497e-02f,
  -3.96587774e-02f, 8.67130142e-03f, 3.03146187e-02f, -5.41440621e-02f, -1.02863625e-01f, -8.76474157e-02f, -6.74674138e-02f, 3.17859724e-02f, -3.68824080e-02f, -4.22099531e-02f,
  1.65347800e-01f, -1.06200702e-01f, 5.73996641e-02f, 1.48441538e-01f, 1.26983866e-01f, -9.21601616e-03f, 3.53326346e-03f, -3.60775962e-02f, -6.48821443e-02f, -8.57464820e-02f,
  -1.04298547e-01f, -1.00537978e-01f, -1.31946117e-01f, -6.48418218e-02f, -1.37234703e-01f, -2.23152161e-01f, -8.80776271e-02f, -7.09718689e-02f, -2.19129957e-02f, -1.55333802e-01f,
  5.90713471e-02f, 8.83373618e-02f, 9.88064483e-02f, 1.05791681e-01f, 1.15033105e-01f, 1.50913835e-01f, 8.20444971e-02f, 7.77796209e-02f, 1.78897023e-01f, 1.49596751e-01f,
  -8.45683962e-02f, -1.10210195e-01f, -6.49760514e-02f, 8.15414414e-02f, 9.59855393e-02f, -9.31964139e-04f, 7.32308850e-02f, -3.31913009e-02f, -1.14973187e-02f, -6.30098656e-02f,
  2.59467792e-02f, 2.78769527e-02f, 1.19226240e-01f, 1.11121900e-01f, -1.16297519e-02f, -2.49688923e-02f, 6.32403046e-02f, 8.63668248e-02f, 8.22687969e-02f, -1.00323334e-01f,
  -4.64935601e-02f, 9.84397009e-02f, -5.30152470e-02f, 1.30534440e-01f, 2.65401583e-02f, -6.08805753e-02f, 7.28294030e-02f, 5.64020313e-02f, 3.52614112e-02f, -3.86320800e-02f,
  -1.48635940e-03f, 5.88168018e-02f, 6.54958561e-02f, 4.17002663e-02f, -4.54854816e-02f, 8.90590623e-02f, -1.20046427e-02f, -1.75476875e-02f, 3.12013067e-02f, -2.19884072e-03f,
  4.05466068e-04f, 9.00642872e-02f, -1.55778471e-02f, 5.52480444e-02f, -9.78984497e-03f, 1.60428435e-02f, 5.23118861e-02f, 7.20832571e-02f, 2.20435709e-02f, -4.87196818e-02f,
  -2.00695824e-03f, 9.79176983e-02f, -6.26420975e-02f, 9.09961537e-02f, 1.73336659e-02f, -4.31932099e-02f, 3.30684036e-02f, -5.60526177e-02f, -3.91062908e-02f, -3.06360777e-02f,
  -7.44979307e-02f, -1.20128334e-01f, -8.25502425e-02f, -1.54438708e-02f, -6.10815361e-02f, 2.51621455e-02f, 3.76824886e-02f, -5.01852110e-02f, -4.65058126e-02f, 1.76495630e-02f,
  4.31085452e-02f, -3.56745459e-02f, 1.76252406e-02f, 1.41086085e-02f, -2.57821474e-02f, 1.62877534e-02f, -4.98486236e-02f, -2.75187939e-02f, -2.41619330e-02f, -1.79970078e-02f,
  -5.85735664e-02f, -2.72265505e-02f, 2.26939712e-02f, -3.35758738e-02f, 5.29471450e-02f, 9.72151682e-02f, -7.24439174e-02f, 1.12730093e-01f, -5.39533794e-02f, -4.21753665e-03f,
  -1.12618677e-01f, -1.46028213e-02f, -1.85633264e-02f, -2.23674662e-02f, -3.85870226e-02f, 1.34020239e-01f, 2.92092469e-02f, -1.09087527e-01f, -2.83967741e-02f, 2.31531113e-02f,
  1.86131708e-02f, -1.09909005e-01f, -8.21745694e-02f, -6.54729530e-02f, -3.43223219e-03f, -1.19231287e-02f, -5.09215659e-03f, -4.47233431e-02f, 8.67265649e-03f, -3.84857431e-02f,
  5.20054027e-02f, 1.65254157e-02f, -5.13894893e-02f, -2.26232074e-02f, 4.91694100e-02f, -4.22317348e-02f, 2.86223479e-02f, -3.23709063e-02f, -1.77619699e-02f, -6.05732575e-02f,
  -1.64250266e-02f, -5.60484547e-03f, 2.73489375e-02f, -5.78137534e-03f, 6.97856471e-02f, -2.64067501e-02f, -1.01810582e-01f, -1.40884495e-03f, -3.96836959e-02f, -1.25682661e-02f,
  5.57377003e-03f, -7.11222067e-02f, 5.07135950e-02f, -7.63676018e-02f, 4.94208336e-02f, 3.41154262e-02f, -5.44332191e-02f, 9.99343023e-02f, 2.56784000e-02f, 7.99100772e-02f,
  -3.25819850e-02f, -1.60254575e-02f, 2.07591355e-02f, -5.87932691e-02f, -3.62225436e-02f, -2.66325194e-03f, 4.69509959e-02f, -2.68619489e-02f, 4.36449535e-02f, 3.14057693e-02f,
  -7.48425648e-02f, -5.43231424e-03f, -5.32189012e-02f, -5.70339002e-02f, 4.57107648e-02f, -6.88303262e-02f, 5.39575815e-02f, 1.53737189e-02f, 5.92847690e-02f, -1.87399685e-02f,
  -4.78251837e-02f, -4.20607999e-02f, -4.73472327e-02f, -1.36735830e-02f, -8.01955462e-02f, -5.01687452e-02f, -2.69085448e-02f, -9.06970873e-02f, 6.10127524e-02f, -7.15649426e-02f,
  -9.50363725e-02f, -8.70972425e-02f, -4.01295014e-02f, 2.51654685e-02f, 9.11206603e-02f, -4.43302803e-02f, 9.54981223e-02f, 8.34850147e-02f, 8.15193281e-02f, -4.50016595e-02f,
  -3.50730233e-02f, -9.66934040e-02f, -6.73481375e-02f, 5.27828783e-02f, 6.87844306e-02f, -1.49235632e-02f, 6.07721023e-02f, 2.60099266e-02f, -1.74103417e-02f, -4.19451594e-02f,
  4.42041866e-02f, -2.14839383e-05f, -2.33646799e-02f, -1.43772587e-02f, -2.34902948e-02f, 2.66060941e-02f, 1.30405035e-02f, -2.65073348e-02f, 3.47871929e-02f, -1.80427209e-02f,
  -4.05082963e-02f, -4.62643839e-02f, -3.01817339e-02f, -5.60749173e-02f, -7.31651932e-02f, 7.79143944e-02f, -2.74576247e-02f, 8.38283263e-03f, -6.60298541e-02f, 5.54577522e-02f,
  4.78866622e-02f, 3.95338386e-02f, -5.12161143e-02f, -7.68421963e-02f, 5.38410284e-02f, 1.19116858e-01f, 1.10251596e-03f, -1.99112911e-02f, 8.78038555e-02f, 1.00901917e-01f,
  2.96376329e-02f, -5.42523153e-02f, -1.20875435e-02f, -8.03148933e-03f, 7.47320801e-02f, 7.65727758e-02f, 1.06086850e-01f, 7.14897886e-02f, -6.30802140e-02f, 7.62897730e-02f,
  4.30320874e-02f, 1.08948611e-02f, -8.42309073e-02f, -1.02145016e-01f, -1.45529592e-02f, -1.46855071e-01f, -2.42854655e-03f, -1.25305355e-01f, -6.59096912e-02f, -3.44082601e-02f,
  6.55936375e-02f, -2.04424951e-02f, 1.91269983e-02f, -6.25788420e-02f, -3.24987955e-02f, -1.84747484e-02f, -2.20822822e-02f, -4.05730307e-02f, 4.16739732e-02f, -7.13341236e-02f,
  5.62294573e-02f, -1.23146586e-02f, -5.07391654e-02f, -3.42812389e-02f, 1.07485401e-02f, -2.87621468e-02f, 2.29909495e-02f, -3.06560807e-02f, 8.26376528e-02f, 2.34768000e-02f,
  7.21487626e-02f, -5.18820956e-02f, -1.54142361e-03f, 1.38681727e-02f, 1.78984944e-02f, -7.25328103e-02f, 2.48735864e-02f, -1.90966260e-02f, 6.03701500e-03f, -7.62318075e-02f,
  -3.72422077e-02f, 3.24744843e-02f, -5.35461269e-02f, -1.44931925e-02f, 6.08454039e-03f, 3.97181474e-02f, 6.67809695e-02f, 6.21968359e-02f, 3.90656404e-02f, 2.92973742e-02f,
  6.85313046e-02f, 4.19896208e-02f, 4.18993607e-02f, -7.27883428e-02f, 2.30703447e-02f, -4.99040931e-02f, -1.52441431e-02f, 1.46846827e-02f, -4.33099009e-02f, -1.24046206e-02f,
  -3.91884707e-02f, -4.08691093e-02f, 4.43114899e-02f, 1.06942412e-02f, -1.72566518e-03f, 4.42619585e-02f, 7.41983578e-02f, -6.31245226e-02f, -8.13854486e-02f, 6.79029226e-02f,
  2.85909176e-02f, 2.58496357e-03f, -5.63229062e-02f, -6.32364079e-02f, -8.77807364e-02f, -2.25249175e-02f, -4.42093844e-03f, -3.43257636e-02f, -8.16402137e-02f, -1.58072207e-02f,
  1.50221633e-02f, 6.17580339e-02f, -8.83631874e-03f, -6.25239462e-02f, -5.04330359e-02f, -3.41818668e-03f, -4.77159061e-02f, -9.31904241e-02f, 1.23938490e-02f, 4.28214222e-02f,
  -6.54584318e-02f, -2.68087387e-02f, -7.33525231e-02f, -3.80763635e-02f, -7.18429610e-02f, -5.29200621e-02f, -9.93906707e-02f, 2.12708917e-02f, -5.06586581e-02f, -4.53659147e-02f,
  4.77520451e-02f, -3.23027223e-02f, -8.78817365e-02f, -1.00237355e-01f, -1.26429006e-01f, 3.61238457e-02f, 1.28885768e-02f, -1.20846152e-01f, -1.26377523e-01f, 1.01528158e-02f,
  -3.36646028e-02f, 1.99465454e-02f, 7.97516927e-02f, 9.94927064e-02f, -4.13436666e-02f, 3.83111686e-02f, 3.11501510e-02f, -2.59305909e-02f, 5.49541414e-02f, 1.53031657e-02f,
  8.79216045e-02f, 3.38192582e-02f, 8.23694244e-02f, -1.37812141e-02f, 5.45869768e-02f, -1.14236020e-01f, 6.95087761e-02f, -4.52946424e-02f, -4.04314585e-02f, 3.91139276e-02f,
  1.83726847e-02f, -6.15897700e-02f, 1.79325473e-02f, -4.55788523e-02f, 6.18612282e-02f, 3.16733494e-02f, -4.19555381e-02f, 4.22601476e-02f, -2.95236539e-02f, 5.62890470e-02f,
  -5.78118581e-03f, -4.69127856e-03f, -5.94425946e-02f, -1.12811988e-02f, -2.45792372e-03f, -7.62974843e-02f, -5.24297031e-03f, 3.05501614e-02f, 5.36154956e-02f, -6.77713603e-02f,
  5.21788336e-02f, -2.71383431e-02f, -8.24959353e-02f, 2.92694326e-02f, -6.21622689e-02f, -6.69876710e-02f, -6.11282326e-02f, -8.62233639e-02f, 2.21703434e-04f, -9.87196341e-02f,
  5.76163158e-02f, 2.19750907e-02f, 8.76062810e-02f, 9.61245298e-02f, 3.38449888e-02f, -1.62762757e-02f, 7.40903914e-02f, -5.27220592e-02f, -1.00282781e-01f, 4.83870804e-02f,
  3.88895907e-02f, -8.09093714e-02f, -1.67628899e-02f, -5.67585155e-02f, -6.61691129e-02f, 3.01872380e-02f, 8.54150355e-02f, -4.60661612e-02f, 5.48981465e-02f, -1.63428532e-03f,
  8.80817920e-02f, 4.04340550e-02f, -7.47521520e-02f, 7.14926720e-02f, 7.51425102e-02f, 6.72705024e-02f, 4.95052412e-02f, -6.33549094e-02f, -8.28631595e-02f, 4.27701175e-02f,
  3.53577845e-02f, -1.32862404e-01f, -6.38490617e-02f, -7.87670612e-02f, 8.29866994e-03f, -4.66683954e-02f, -7.32401833e-02f, -3.10162897e-03f, -1.20162535e-02f, 3.05107497e-02f,
  8.14851969e-02f, -3.57851647e-02f, 3.68910730e-02f, 6.88868091e-02f, 1.93142369e-02f, -1.38765890e-02f, -1.68325435e-02f, 7.93831572e-02f, 3.90241705e-02f, 4.47451063e-02f,
  6.09620251e-02f, 8.04357976e-02f, -9.28452611e-03f, 7.03645721e-02f, 2.35319361e-02f, -3.74610610e-02f, 5.17519787e-02f, 4.68204916e-02f, 1.55792600e-02f, 3.72568890e-02f,
  6.15092553e-02f, -5.91099150e-02f, -2.97452360e-02f, -8.74864403e-03f, -3.67911272e-02f, -3.17518443e-01f, -2.97067136e-01f, -1.68173239e-02f, -9.32325423e-03f, 1.03217013e-01f,
  -1.02910884e-01f, 1.58027232e-01f, -6.68000579e-02f, -2.67997414e-01f, -1.44615397e-01f, 4.61842353e-03f, -3.30561548e-01f, -1.09913073e-01f, 1.37665553e-03f, -2.21097425e-01f,
  1.98932714e-04f, -1.23924993e-01f, -1.91947684e-01f, -1.50976027e-03f, -5.29577285e-02f, -4.06683944e-02f, 1.09872073e-01f, -1.08740091e-01f, -2.93185934e-02f, -6.49716109e-02f,
  -5.04344106e-02f, 7.83489645e-02f, 1.10713944e-01f, 2.24308912e-02f, -4.39118780e-02f, -3.18201147e-02f, -6.36463463e-02f, -6.01562932e-02f, 1.88925993e-02f, -2.13770615e-03f,
  5.64891733e-02f, 7.73332454e-03f, -4.05994095e-02f, 9.60205793e-02f, -5.58590144e-02f, 8.19184035e-02f, -3.13633829e-02f, 3.21791619e-02f, 1.74276773e-02f, -2.65302806e-04f,
  3.26754525e-02f, 4.13307697e-02f, -4.63661812e-02f, 4.31947038e-02f, -1.80216040e-02f, 4.93834205e-02f, 2.43395548e-02f, -3.10971700e-02f, -2.88063567e-02f, -4.74582799e-02f,
  -2.49773692e-02f, -3.86978425e-02f, -2.43202895e-02f, 3.57233137e-02f, -5.99810816e-02f, -5.65700233e-02f, 6.96633980e-02f, -2.15598522e-03f, 3.34250443e-02f, -1.38706174e-02f,
  -3.93110961e-02f, -2.15607248e-02f, -4.23368849e-02f, -7.56492466e-02f, 3.37821036e-03f, -6.61580125e-03f, 1.74311567e-02f, 1.21761762e-01f, 1.59457363e-02f, 1.72421988e-02f,
  7.68493265e-02f, 2.95750182e-02f, 1.83601025e-02f, -7.24186376e-02f, 4.61656079e-02f, -2.08685435e-02f, 5.99356182e-02f, 1.78433806e-02f, 3.36588696e-02f, -6.16650693e-02f,
  -3.42718251e-02f, -8.95324647e-02f, -2.84745861e-02f, 1.93786118e-02f, -3.69213242e-03f, -1.82423869e-03f, -8.67407545e-02f, 4.26263250e-02f, -3.21477763e-02f, -1.23677589e-03f,
  -1.73058026e-02f, 2.79574189e-02f, 5.09999227e-03f, -1.65073834e-02f, 8.36006850e-02f, -4.10889499e-02f, -1.91053711e-02f, 2.26684548e-02f, -3.99647430e-02f, -3.87895964e-02f,
  -2.88482476e-02f, 3.48200873e-02f, 5.10701872e-02f, -9.54676345e-02f, 6.29292652e-02f, -6.85582608e-02f, 7.86023140e-02f, 1.38940453e-03f, 1.50405860e-03f, -7.29333609e-02f,
  9.87773538e-02f, -8.77583548e-02f, 1.09615937e-01f, 1.07685283e-01f, 4.23478968e-02f, 1.02321036e-01f, 9.14311782e-02f, -4.10022847e-02f, 3.03196218e-02f, -7.57895708e-02f,
  -6.64048269e-02f, 6.41337642e-03f, -2.39097998e-02f, -7.32682794e-02f, -5.75612485e-02f, 5.67861460e-02f, 4.59397919e-02f, 9.18292776e-02f, 9.45361629e-02f, 5.77906221e-02f,
  4.63691466e-02f, -4.36606407e-02f, -1.38431499e-02f, -1.67155638e-01f, 6.52605742e-02f, 1.70420744e-02f, -1.37477294e-01f, 6.76030219e-02f, -6.89799860e-02f, -2.67486144e-02f,
  6.20349608e-02f, -9.57468152e-02f, -7.62242824e-02f, 7.06800595e-02f, -5.58708161e-02f, 6.47938028e-02f, 4.82948385e-02f, 6.99239448e-02f, 1.94209069e-02f, -4.61467095e-02f,
  8.11059773e-02f, 2.42056791e-02f, -1.54530834e-02f, -8.42152629e-03f, 8.65351260e-02f, -1.88187752e-02f, 9.49527398e-02f, -2.72299107e-02f, -3.91477235e-02f, -1.35989701e-02f,
  -1.58855449e-02f, 3.19104530e-02f, 9.86680537e-02f, -2.30889861e-02f, 6.07260913e-02f, 9.28864442e-03f, -5.46602719e-02f, 6.53064623e-02f, 2.40914728e-02f, 6.97032511e-02f,
  -9.98715758e-02f, -2.06164710e-04f, -7.67393261e-02f, 4.34141681e-02f, 9.15721059e-02f, -5.96845187e-02f, -8.51937085e-02f, 7.26048499e-02f, -5.41533455e-02f, -7.24264464e-05f,
  2.16050316e-02f, -5.60832061e-02f, 8.16975087e-02f, -2.61836518e-02f, -2.93550957e-02f, 1.32879615e-02f, 1.29492255e-02f, 1.06459625e-01f, -7.90933985e-03f, -9.68766399e-03f,
  -2.87959259e-02f, 7.95155205e-03f, -6.99525476e-02f, -8.25129524e-02f, 5.21595553e-02f, -4.25344184e-02f, -2.55909748e-02f, -2.82260515e-02f, 6.05872907e-02f, -6.74290285e-02f,
  -4.11110790e-03f, -9.55101624e-02f, -3.95158529e-02f, 9.72363204e-02f, -7.16913640e-02f, 5.82732670e-02f, -5.35185151e-02f, -6.81376159e-02f, 7.47975195e-03f, 2.15824265e-02f,
  -3.66535485e-02f, 6.59740940e-02f, 2.12600306e-02f, 1.05096899e-01f, -6.29529282e-02f, 3.60849015e-02f, -3.44731808e-02f, -4.79000024e-02f, 1.08773857e-02f, -5.53015098e-02f,
  -6.37140349e-02f, -6.39725775e-02f, 5.06272465e-02f, -1.39178364e-02f, -9.50285345e-02f, 3.59912962e-02f, -2.52194200e-02f, 2.07835678e-02f, -7.60424184e-03f, -1.07221521e-01f,
  1.97694730e-02f, 1.28103986e-01f, -2.24823874e-04f, 1.12631153e-02f, 3.32618542e-02f, 5.53304255e-02f, -5.63635118e-02f, 9.50482115e-03f, 5.80266789e-02f, -7.85577297e-02f,
  1.55529380e-03f, 1.31371737e-01f, -5.63267805e-02f, -4.00963500e-02f, -1.29657621e-02f, -7.43929893e-02f, -5.59871420e-02f, -7.99257159e-02f, 9.48858336e-02f, 1.13438837e-01f,
  -6.05387837e-02f, -7.36478204e-03f, -3.87524851e-02f, 5.95564730e-02f, -1.24936411e-02f, 3.24933268e-02f, -1.05094142e-01f, 1.84131525e-02f, 5.34955375e-02f, -1.12411156e-01f,
  8.53100885e-03f, -5.01149707e-03f, -8.21613446e-02f, -7.55601078e-02f, 1.93001647e-02f, 1.88765489e-02f, 5.97155653e-02f, -1.29771726e-02f, -1.45906145e-02f, -2.88393162e-02f,
  -2.30649766e-03f, 2.81532109e-02f, 7.16837198e-02f, -9.70863476e-02f, -7.40540624e-02f, 8.02357718e-02f, 3.95880453e-02f, 6.90451711e-02f, -2.50625648e-02f, 1.11763380e-01f,
  7.71633312e-02f, 8.82108789e-03f, 8.01977292e-02f, -7.61173526e-03f, 1.74503308e-03f, 7.88149014e-02f, 3.63266841e-02f, -4.81148772e-02f, -3.96127477e-02f, -2.04260126e-02f,
  7.54495561e-02f, -7.43455365e-02f, 7.71142021e-02f, -3.13736498e-02f, -5.11716641e-02f, -1.84015520e-02f, 4.18863306e-03f, 2.88226139e-02f, -7.70003647e-02f, -3.07496935e-02f,
  -5.54482192e-02f, -6.56039342e-02f, 5.55880591e-02f, 1.50337825e-02f, 4.00105193e-02f, 7.94328451e-02f, 2.08560620e-02f, -5.49086966e-02f, -8.34169090e-02f, 6.60019787e-03f,
  -7.51269460e-02f, -2.28202455e-02f, -2.85740457e-02f, 2.35679708e-02f, 3.59871276e-02f, -2.50614211e-02f, -6.20041192e-02f, -5.34041151e-02f, -3.01580839e-02f, 1.84822828e-02f,
  -7.23916888e-02f, 6.08493015e-02f, -1.13112694e-02f, -1.73931045e-03f, 6.09568544e-02f, 7.72714764e-02f, 2.95657683e-02f, -7.51998946e-02f, 8.90477002e-02f, 5.37771583e-02f,
  1.15063069e-02f, 4.27185744e-02f, 5.67031316e-02f, -6.80153668e-02f, -1.04202200e-02f, -1.76487435e-02f, 1.92798153e-02f, -1.80969480e-02f, -5.37747219e-02f, -5.97293340e-02f,
  6.82199746e-02f, 6.00177310e-02f, 8.08561519e-02f, -6.55526742e-02f, 4.65692021e-02f, -1.06670670e-01f, -6.07585860e-03f, 5.53165786e-02f, 7.29628578e-02f, 7.64593035e-02f,
  -5.61296567e-02f, -1.08609081e-03f, 2.80793216e-02f, 6.27442747e-02f, 9.63744819e-02f, 3.03183515e-02f, 1.27884135e-01f, 3.74439247e-02f, -8.00816119e-02f, -3.85505669e-02f,
  6.95602819e-02f, -2.19066292e-02f, -9.74584464e-03f, 6.51233792e-02f, 1.10915661e-01f, -4.19174023e-02f, 6.96368739e-02f, 6.97000772e-02f, -2.53535211e-02f, -1.24915183e-01f,
  -1.16551533e-01f, 7.54411370e-02f, -3.81365791e-02f, 4.59674895e-02f, 7.99428225e-02f, -6.84141144e-02f, -5.86627908e-02f, 4.10869569e-02f, 7.11655542e-02f, 8.54149163e-02f,
  5.36484979e-02f, -8.60599279e-02f, -1.54597580e-03f, -2.50065885e-02f, -3.40779759e-02f, -5.16466722e-02f, 7.27492794e-02f, 5.84042780e-02f, 4.49198671e-02f, -6.13386557e-02f,
  -1.49655472e-02f, 8.52525160e-02f, 7.39573827e-03f, -1.66334696e-02f, -7.52173411e-03f, -1.01149179e-01f, -1.04444079e-01f, 6.79315999e-03f, -4.91143838e-02f, -1.41453324e-02f,
  -8.73265043e-02f, 2.99571063e-02f, -7.11482763e-02f, -4.68936078e-02f, -1.64492317e-02f, -5.98885454e-02f, 4.38282117e-02f, 8.76926184e-02f, -5.11939712e-02f, 8.52307156e-02f,
  -8.02988708e-02f, -5.64317033e-02f, -9.43384394e-02f, -5.29448539e-02f, -1.93820950e-02f, -5.72234392e-02f, -5.82140349e-02f, -3.24255750e-02f, -8.09823275e-02f, -5.58148548e-02f,
  5.27593046e-02f, -3.93182784e-02f, -2.03789882e-02f, 3.72744836e-02f, 1.57383934e-03f, 2.54493579e-02f, -7.83151984e-02f, 3.26618366e-02f, 2.51004491e-02f, -4.35723364e-02f,
  5.52939065e-02f, 7.08615333e-02f, -1.63744707e-02f, -3.06390300e-02f, 3.47855724e-02f, -1.20766517e-02f, -1.36025464e-02f, 5.50490171e-02f, 3.75775956e-02f, 5.14384881e-02f,
  -5.19615319e-03f, 2.40027811e-02f, 7.10383505e-02f, 5.29603846e-02f, -8.38633627e-02f, -4.87583056e-02f, 4.37616445e-02f, -2.72970460e-03f, -8.58259201e-03f, -1.63396709e-02f,
  -6.37493730e-02f, 9.27858278e-02f, 7.24381506e-02f, 5.80354556e-02f, 6.03465289e-02f, -7.49514103e-02f, -8.46110210e-02f, -2.72766482e-02f, 1.23276771e-03f, -7.46611878e-02f,
  4.28325906e-02f, 1.25914449e-02f, -2.96903439e-02f, 3.53948474e-02f, 4.83893305e-02f, 9.08691064e-02f, 4.57719304e-02f, -2.48525813e-02f, -7.87603855e-03f, -8.67467746e-03f,
  2.57275496e-02f, -2.10098270e-02f, 1.96318328e-01f, -1.29282400e-02f, 1.17909037e-01f, 7.32716843e-02f, 9.06081423e-02f, -7.03096986e-02f, -6.06140606e-02f, -2.05497205e-01f,
  1.77193694e-02f, -2.83433162e-02f, -7.82601982e-02f, -2.61888038e-02f, 9.35474336e-02f, -1.94896609e-02f, -8.20290595e-02f, 6.47722706e-02f, 9.93785821e-03f, 1.25290453e-02f,
  9.11111012e-02f, -1.35392129e-01f, 4.64023799e-02f, -8.58127251e-02f, 6.10848293e-02f, 6.08055927e-02f, -9.70266163e-02f, 1.11375295e-01f, -9.90606397e-02f, -4.89126593e-02f,
  1.25307459e-02f, 3.35418992e-02f, 8.24658852e-03f, 1.13660201e-01f, 2.63561998e-02f, -5.26116975e-02f, 5.59163243e-02f, 9.31275338e-02f, -3.18639949e-02f, -1.56460162e-02f,
  -7.36267641e-02f, 4.43143807e-02f, -1.07455784e-02f, 8.23420938e-03f, 4.36000973e-02f, 6.03548959e-02f, -7.16474503e-02f, 3.05456314e-02f, 7.61125833e-02f, 9.11141187e-02f,
  3.30361910e-03f, 5.87479956e-02f, 1.43716661e-02f, -5.92485778e-02f, 3.95687073e-02f, -2.99214236e-02f, -7.58466795e-02f, 2.98756994e-02f, -3.99180390e-02f, -5.07550314e-02f,
  6.67348504e-02f, 3.32464315e-02f, 1.67126562e-02f, -4.20111977e-02f, -7.48465508e-02f, 6.90042377e-02f, 1.70294530e-04f, 2.94601992e-02f, 1.74991805e-02f, -7.70807564e-02f,
  -1.03734341e-02f, 4.23103757e-02f, 1.72704998e-02f, -7.00705051e-02f, 4.77898866e-02f, -1.78097263e-02f, 6.56170845e-02f, 5.32086603e-02f, 1.14294123e-02f, 6.04869761e-02f,
  -9.35045555e-02f, -1.91686377e-02f, 2.72509572e-03f, 4.18661125e-02f, 2.77239177e-02f, -5.11866100e-02f, -6.11152612e-02f, 5.68110347e-02f, -2.05132123e-02f, -2.55982671e-02f,
  -1.59308612e-01f, -3.34164426e-02f, 7.95085281e-02f, -8.91594142e-02f, -2.64397934e-02f, -4.32790667e-02f, 5.39949946e-02f, 3.56937572e-02f, -4.42349762e-02f, -6.03535026e-02f,
  -9.67803374e-02f, 5.92381023e-02f, -5.55778146e-02f, -3.36027369e-02f, -2.64538620e-02f, 2.28900313e-02f, 4.06523012e-02f, 4.78041060e-02f, -6.05974868e-02f, 5.80428578e-02f,
  1.42202554e-02f, -1.37698958e-02f, -2.80836993e-03f, 5.77038415e-02f, 1.63680613e-02f, -5.53120077e-02f, 3.65433916e-02f, 5.21405824e-02f, -3.43837170e-03f, 3.88794206e-02f,
  -7.86961094e-02f, 6.70581907e-02f, -4.35539670e-02f, -2.97818389e-02f, -1.02861293e-01f, -4.34800610e-02f, -1.51922375e-01f, 5.58443926e-02f, -8.79254565e-02f, -8.30261409e-03f,
  4.79475297e-02f, 3.23496689e-03f, 6.87840395e-03f, -1.16998507e-02f, -9.13780332e-02f, -4.16859798e-02f, -9.54979584e-02f, -9.48568657e-02f, -4.05685380e-02f, -6.34690747e-02f,
  6.57171197e-03f, -1.98034402e-02f, -1.05690338e-01f, -1.04594538e-02f, -1.11248992e-01f, -5.62560782e-02f, 7.90782459e-03f, -7.71915466e-02f, 2.73961332e-02f, -7.33982548e-02f,
  2.75560599e-02f, 1.87439341e-02f, 6.96989847e-03f, 4.05586697e-02f, -9.25210714e-02f, -1.10585585e-01f, -2.01986004e-02f, 1.48984343e-02f, -4.10501100e-02f, -6.18703365e-02f,
  2.64153406e-02f, 7.73442239e-02f, -1.62097123e-02f, -3.73602249e-02f, 5.91050051e-02f, -3.80697027e-02f, 4.07167897e-02f, 1.93697959e-03f, 4.30174842e-02f, -7.61762187e-02f,
  2.43411376e-03f, -6.79169446e-02f, 9.61043499e-03f, 4.47583012e-02f, 8.00513383e-03f, 2.19766907e-02f, 3.47185275e-03f, 4.27053422e-02f, 4.34775278e-02f, -5.56447320e-02f,
  -1.96706876e-02f, 2.73774397e-02f, 3.31697874e-02f, 8.01051781e-02f, -6.74861148e-02f, -3.47281732e-02f, 1.12029826e-02f, 4.20593359e-02f, -2.44631488e-02f, 4.23807539e-02f,
  -3.46013270e-02f, 1.46659408e-02f, -1.11506265e-02f, -7.72407278e-04f, 5.54802753e-02f, -8.98021832e-02f, 6.71303645e-02f, 3.10977572e-03f, 4.13240977e-02f, 2.33192351e-02f,
  -5.65327564e-03f, 6.26090541e-02f, -5.19359931e-02f, 6.69796914e-02f, -3.29118930e-02f, -3.25068571e-02f, 4.86140884e-02f, -7.90667459e-02f, 1.27939107e-02f, -7.92207047e-02f,
  -2.89500449e-02f, 1.02256266e-02f, 3.17281932e-02f, 3.83316614e-02f, 6.84901606e-03f, -2.72092633e-02f, 8.09810609e-02f, 6.70811906e-02f, 4.39449027e-02f, -2.94461418e-02f,
  -4.35820520e-02f, 7.71545246e-02f, 8.05777013e-02f, 2.33783596e-03f, -4.22150120e-02f, -4.49438915e-02f, -3.14668976e-02f, 8.59819353e-02f, 3.82664800e-02f, -5.72846122e-02f,
  -5.97651117e-02f, -5.17829917e-02f, -1.47333159e-03f, -2.15333384e-02f, -8.34000036e-02f, 8.54920596e-02f, -1.88202318e-02f, 1.22639146e-02f, -1.21405385e-02f, -3.51872615e-04f,
  4.16372120e-02f, 1.13817370e-02f, -3.55702452e-02f, -1.11418374e-01f, 1.93357244e-02f, -2.78607216e-02f, -8.88761133e-02f, 2.92109163e-03f, -4.15940434e-02f, 6.51222616e-02f,
  -1.14222849e-02f, -1.34278405e-02f, 1.21651869e-02f, 6.92911148e-02f, 5.58746792e-02f, 6.68531284e-02f, 6.97704777e-02f, -2.62521226e-02f, -4.78533395e-02f, -6.96067810e-02f,
  5.40448353e-02f, 5.13944589e-02f, -1.03024788e-01f, 1.29201133e-02f, -5.76729029e-02f, -9.07485485e-02f, 5.70862852e-02f, -7.21344575e-02f, -1.44250458e-02f, -9.10307467e-02f,
  2.26397216e-02f, -4.13454063e-02f, -1.21520251e-01f, 2.00941786e-02f, -7.13500604e-02f, -3.55033241e-02f, -3.51439714e-02f, -4.91007455e-02f, 4.58622351e-02f, 1.55176886e-03f,
  6.78436086e-02f, 5.56081533e-02f, -1.99188944e-02f, 5.54989539e-02f, 8.84367451e-02f, 3.39014865e-02f, 2.65629217e-02f, -3.18723805e-02f, -1.04267292e-01f, -3.76121961e-02f,
  -8.78046304e-02f, -1.57184992e-02f, 4.61416915e-02f, -1.51877454e-03f, 5.17206714e-02f, -4.20455411e-02f, -5.01633529e-03f, 2.59973202e-03f, 6.47755116e-02f, 7.77550265e-02f,
  -5.07435724e-02f, 9.55435038e-02f, 4.03227843e-02f, -1.20022092e-02f, 9.47914571e-02f, -2.70135570e-02f, -4.86894660e-02f, -4.53871824e-02f, 2.85501089e-02f, -4.96972166e-02f,
  4.65346090e-02f, -2.70727463e-02f, -7.96486139e-02f, -7.40959123e-02f, 5.33104427e-02f, 1.19628664e-02f, 1.94405913e-02f, 6.49328753e-02f, -7.70423561e-02f, -8.24434087e-02f,
  -1.15080569e-02f, 7.56030856e-03f, 2.53439900e-02f, -6.29443675e-02f, 3.16060036e-02f, -4.03631181e-02f, 4.15321812e-03f, -8.38894397e-02f, -4.87213023e-02f, 6.37134165e-02f,
  7.02742860e-02f, 8.99989530e-02f, 6.14300743e-02f, -1.31573873e-02f, -3.99861857e-02f, -2.83569321e-02f, -9.78059880e-03f, 8.20098072e-02f, -1.89685989e-02f, -7.28594065e-02f,
  -2.39130948e-03f, -1.42776649e-02f, -2.12275647e-02f, 6.04252145e-02f, 7.06976047e-03f, 7.71912038e-02f, 5.21550365e-02f, 3.06010079e-02f, -1.02086086e-02f, 3.11440565e-02f,
  -6.77870065e-02f, -8.45597759e-02f, -9.49713588e-02f, 6.47897348e-02f, 1.44393090e-02f, -2.07476597e-02f, -5.77260628e-02f, -3.18451598e-02f, 6.32422194e-02f, 6.00638508e-04f,
  1.26053125e-01f, -5.66575490e-02f, 6.44012094e-02f, -4.74709123e-02f, -5.07568792e-02f, -1.19225934e-01f, -1.61751825e-02f, -8.28377455e-02f, 9.63089541e-02f, -9.05600265e-02f,
  -7.92673081e-02f, 8.35797340e-02f, 5.86143136e-02f, -1.25552669e-01f, 1.47187561e-01f, 3.63588147e-02f, -1.34710968e-01f, -8.80560726e-02f, 5.76817542e-02f, -1.39912650e-01f,
  8.79776943e-03f, -1.05787694e-01f, 4.63306308e-02f, -8.53203014e-02f, -1.58195198e-01f, -8.94099176e-02f, -6.91882372e-02f, -5.63683137e-02f, -8.04191572e-04f, -5.84385842e-02f,
  1.13374498e-02f, 1.91748459e-02f, 6.50048256e-02f, -2.02503931e-02f, -3.00038029e-02f, -9.16438252e-02f, 7.41146578e-05f, -3.16794403e-02f, -7.57841021e-03f, 4.42953669e-02f,
  -1.01355150e-01f, 1.55515606e-02f, -1.06265815e-02f, -7.69984126e-02f, 1.54609354e-02f, -1.56834368e-02f, -2.29907017e-02f, -5.83385117e-02f, 2.65898760e-02f, -9.61045325e-02f,
  -1.07620813e-01f, 3.52445152e-03f, -8.38113651e-02f, 2.09542830e-02f, -3.24899033e-02f, 8.85813609e-02f, -6.60041496e-02f, -7.70548284e-02f, 1.00656496e-02f, -8.94503891e-02f,
  -1.19507918e-02f, 7.59137049e-02f, 5.36550321e-02f, 4.03471524e-03f, -2.33877692e-02f, -1.04723349e-01f, 6.72043189e-02f, -3.50623131e-02f, -7.18225166e-02f, 7.75629096e-03f,
  8.60187933e-02f, 6.28618225e-02f, -5.84425963e-02f, 6.47786409e-02f, 2.42953841e-02f, 7.46979862e-02f, -1.19151719e-01f, 1.96904456e-03f, -1.34763466e-02f, 8.66072774e-02f,
  -3.50789130e-02f, -2.25731600e-02f, -1.87105369e-02f, 2.66852528e-02f, -5.81900887e-02f, -6.21876977e-02f, -3.46226133e-02f, 4.14639264e-02f, -2.74493103e-03f, 4.57546078e-02f,
  4.75295521e-02f, 4.26756740e-02f, 5.23122922e-02f, 6.68787435e-02f, -2.88682897e-02f, -3.24815214e-02f, 4.69342805e-02f, -9.22503322e-02f, -3.02012581e-02f, 1.79030746e-02f,
  4.49120402e-02f, 5.72391413e-02f, -5.73619120e-02f, -6.30369410e-02f, -3.33287120e-02f, -6.29408434e-02f, -3.58151682e-02f, 8.71790498e-02f, -5.93535304e-02f, -1.14401402e-02f,
  -5.61447777e-02f, 1.96586102e-02f, 1.75746542e-03f, 9.01707448e-03f, -8.87364000e-02f, -6.27772063e-02f, 8.91824812e-02f, -2.54819170e-02f, -3.86241563e-02f, -1.41201625e-02f,
  -1.25827923e-01f, 1.64318949e-01f, 9.24628153e-02f, 5.23430146e-02f, -1.34143919e-01f, -1.73005939e-01f, -7.59034008e-02f, 2.85231844e-02f, -2.44366396e-02f, 5.74858077e-02f,
  1.33766308e-01f, 2.10885108e-02f, 1.01603083e-01f, -1.21888903e-03f, -1.11558571e-01f, 4.07933220e-02f, 1.91555843e-02f, -5.78569695e-02f, 4.48114276e-02f, 1.07365429e-01f,
  -1.76979806e-02f, -2.98132636e-02f, -4.71269758e-03f, 5.82364723e-02f, -8.58328119e-02f, -2.36199368e-02f, 7.75256380e-02f, 5.09580486e-02f, 8.42591152e-02f, 5.01635298e-02f,
  -3.29712220e-02f, -5.96906282e-02f, -9.59898606e-02f, -2.62691732e-02f, -9.51951463e-03f, -7.42364153e-02f, 5.17580844e-02f, -1.01775117e-01f, -1.51862064e-02f, 6.01089187e-02f,
  -7.48040378e-02f, -2.47454140e-02f, 5.81750600e-03f, -4.69052838e-03f, -1.98179251e-03f, 6.19500130e-02f, 8.45234767e-02f, 8.44526365e-02f, 4.61633317e-02f, -3.98670696e-02f,
  -6.05180524e-02f, -7.28614256e-02f, -3.63937356e-02f, 6.17764145e-02f, 2.66438685e-02f, -9.20316651e-02f, 2.93140728e-02f, -1.42569039e-02f, -8.03442672e-02f, -8.54452327e-02f,
  -4.90480922e-02f, 3.62383537e-02f, 9.57754776e-02f, 5.39113842e-02f, -7.27118477e-02f, 6.56597838e-02f, -6.93040937e-02f, -1.76508389e-02f, -4.77875434e-02f, 4.85982411e-02f,
  -3.98736338e-05f, -1.44380862e-02f, -3.28042097e-02f, -6.43478930e-02f, -4.98238802e-02f, 7.94935599e-03f, -6.78537190e-02f, -2.96880174e-02f, 5.19378297e-02f, -4.02312353e-02f,
  3.92714366e-02f, 4.30324897e-02f, 7.49770850e-02f, 2.36900356e-02f, 4.12213616e-02f, 4.20128889e-02f, -3.11511457e-02f, -1.70699377e-02f, -6.21903762e-02f, -7.62633458e-02f,
  -4.42072190e-02f, 1.41727984e-01f, 5.77131994e-02f, -5.15828021e-02f, 5.53279780e-02f, -1.15535408e-01f, -4.58257869e-02f, -7.40939900e-02f, -3.47916223e-02f, 4.64312248e-02f,
  -9.26259607e-02f, -3.75600979e-02f, 2.65547093e-02f, -2.26659421e-02f, -7.15361014e-02f, -9.13642272e-02f, -1.23079754e-02f, 8.02448168e-02f, -4.75674681e-02f, -2.58582067e-02f,
  5.81070818e-02f, 3.44038336e-03f, 6.25064820e-02f, 3.26653430e-03f, 3.92277129e-02f, 7.40493760e-02f, 5.81559725e-02f, -5.57856075e-02f, -2.01940443e-02f, 2.62587462e-02f,
  -3.84469144e-02f, 3.10880952e-02f, 1.33767875e-03f, -1.91799887e-02f, 1.20226247e-03f, -1.51491717e-01f, -1.25690565e-01f, -1.19055966e-02f, -5.30708283e-02f, -4.39097621e-02f,
  7.18303546e-02f, 2.99700703e-02f, 4.78890026e-03f, 2.69486159e-02f, -1.07638843e-01f, 7.92967752e-02f, -5.56184687e-02f, -5.52806668e-02f, -8.81075263e-02f, -9.44139287e-02f,
  -2.86174659e-02f, -1.77658303e-03f, 8.58236672e-05f, 2.98913997e-02f, -2.79456191e-02f, -8.81543159e-02f, -3.90149578e-02f, -9.58120301e-02f, 1.62144043e-02f, -7.57908896e-02f,
  -4.01640236e-02f, 1.08277306e-01f, -4.78416914e-04f, 2.37624310e-02f, -1.10760843e-02f, 6.18526042e-02f, -4.66499515e-02f, 8.20813514e-03f, 7.71258026e-02f, -7.11293072e-02f,
  -2.06426121e-02f, -9.52303857e-02f, 5.21803126e-02f, -6.20239750e-02f, 6.16806522e-02f, -6.45467341e-02f, -2.00817287e-02f, 7.56890550e-02f, 4.66147512e-02f, -5.28203286e-02f,
  2.48344522e-02f, 1.33900959e-02f, -4.47430722e-02f, 6.17088415e-02f, 3.94567940e-03f, -6.90490752e-02f, -2.59202551e-02f, 3.91726606e-02f, 1.19292072e-03f, 7.07743391e-02f,
  -6.91356286e-02f, 6.09932176e-04f, -3.90485451e-02f, 3.29900943e-02f, -2.26015095e-02f, -1.18691325e-02f, 3.91255803e-02f, -2.31883097e-02f, 1.03185765e-01f, -8.85998160e-02f,
  6.65132850e-02f, 7.05095157e-02f, 2.98555451e-03f, 4.20142375e-02f, 5.20167165e-02f, -4.55859862e-02f, 7.80841410e-02f, -3.04047111e-02f, -7.78857321e-02f, 5.48156677e-03f,
  -3.40926573e-02f, 6.80878386e-02f, 2.66468357e-02f, 7.70246163e-02f, -5.34436330e-02f, 2.05068011e-02f, 8.51244386e-03f, 7.86104649e-02f, 5.92190996e-02f, -6.07555136e-02f,
  -4.94376458e-02f, 5.58400974e-02f, 4.23251502e-02f, -8.06760229e-03f, -1.02579176e-01f, -8.38938281e-02f, 9.18138772e-03f, -8.83679613e-02f, -4.68476303e-03f, -8.79912674e-02f,
  -6.56492636e-02f, -7.02698156e-02f, -6.60390854e-02f, 3.99528630e-02f, -5.56632988e-02f, 8.36300403e-02f, -6.67881826e-03f, 4.93501574e-02f, -8.12557936e-02f, -9.37682390e-02f,
  -5.51297329e-02f, 5.85865788e-03f, -1.70669351e-02f, 6.17991239e-02f, -1.96951604e-03f, -4.94322926e-02f, 5.05226143e-02f, -3.69923599e-02f, -9.29335225e-03f, -3.66167575e-02f,
  -1.22020669e-01f, -5.06754126e-03f, -1.21861145e-01f, -1.90713219e-02f, 5.40351532e-02f, 4.99121509e-02f, -2.73871738e-02f, -4.26373854e-02f, -1.63561285e-01f, 1.37089267e-01f,
  1.29542127e-01f, -6.45707622e-02f, -4.62804642e-03f, 6.79234043e-02f, -9.66252387e-02f, 4.14158516e-02f, 1.44202888e-01f, 4.46273759e-02f, -1.28449112e-01f, 1.23020280e-02f,
  -4.76853400e-02f, 1.17368400e-01f, 1.93606727e-02f, 7.19238371e-02f, -6.96111992e-02f, 2.63927085e-03f, 3.58726457e-02f, 7.40627944e-02f, 2.92145442e-02f, -5.46995066e-02f,
  7.88538679e-02f, -9.19191260e-03f, -7.77726322e-02f, -7.15443417e-02f, 2.77264360e-02f, 7.67665058e-02f, 8.39086920e-02f, -3.46131809e-02f, -5.87746277e-02f, -8.29775482e-02f,
  -4.68633138e-03f, 2.26238533e-03f, -8.91480073e-02f, -4.10983749e-02f, -2.76886020e-02f, -1.92260351e-02f, -4.76547815e-02f, -1.51956789e-02f, -6.24843352e-02f, 4.59545515e-02f,
  -1.19047217e-01f, 7.93542117e-02f, -1.85523070e-02f, -5.28790615e-02f, 4.52842154e-02f, 2.01198161e-02f, -3.92946228e-02f, 2.91712061e-02f, 8.55028033e-02f, -6.18703663e-04f,
  5.40075079e-02f, -4.55977283e-02f, -2.84607131e-02f, -3.35789956e-02f, -2.70893928e-02f, 4.12644744e-02f, 1.34508563e-02f, 7.84272179e-02f, 1.75881304e-03f, 4.67413627e-02f,
  5.55319488e-02f, 6.50170669e-02f, 8.65201931e-03f, -3.59024182e-02f, 4.20454890e-02f, 4.40314636e-02f, -7.65555277e-02f, 1.96131383e-04f, -7.15270638e-02f, -8.62191916e-02f,
  5.74836368e-03f, 5.41653372e-02f, -1.96319204e-02f, -4.95376810e-03f, -4.52672653e-02f, -3.37089226e-02f, -2.76628099e-02f, -2.24296935e-02f, 4.65409122e-02f, -5.04990444e-02f,
  6.16286546e-02f, 1.26172841e-01f, 1.64726824e-02f, -2.31097955e-02f, 3.41872759e-02f, -8.01493153e-02f, -7.85905719e-02f, -9.01658311e-02f, 6.85712770e-02f, 5.71229421e-02f,
  5.52801527e-02f, 8.61880109e-02f, 7.50251189e-02f, 3.08731087e-02f, 1.74708124e-02f, 9.32846069e-02f, 5.29305339e-02f, -5.75549863e-02f, 1.03847958e-01f, -6.35437369e-02f,
  5.87539673e-02f, -1.80619527e-02f, -3.33205448e-03f, 5.42019717e-02f, 1.52386213e-02f, 1.33771449e-02f, -1.08889788e-01f, 2.56597027e-02f, 3.78207155e-02f, -9.93977189e-02f,
  7.94711709e-02f, 3.12882923e-02f, -1.61895856e-01f, -2.33643390e-02f, -9.48343202e-02f, 4.00691740e-02f, 1.06549494e-01f, -6.81361407e-02f, -1.89917952e-01f, 2.73965169e-02f,
  1.39238954e-01f, -1.14024151e-02f, 1.15199201e-01f, 1.48597687e-01f, 5.60947210e-02f, 1.55711323e-01f, 5.86115010e-02f, 1.41849056e-01f, 1.77422538e-02f, 4.29213159e-02f,
  -8.07485431e-02f, 9.47383046e-02f, 2.35637799e-02f, -7.40863383e-03f, -2.64872424e-02f, -1.47732407e-01f, 1.08782619e-01f, -7.05386559e-03f, 5.28092459e-02f, 3.34610194e-02f,
  1.39673561e-01f, 2.60358602e-02f, 5.32938614e-02f, -2.67747371e-03f, -2.97097513e-03f, 8.31598565e-02f, -1.28643196e-02f, 3.66251618e-02f, -9.16815102e-02f, -5.61165698e-02f,
  8.12089667e-02f, -2.29982994e-02f, -8.21932778e-03f, -7.27217272e-02f, -4.89390045e-02f, -1.40917376e-02f, -4.94340919e-02f, -3.75035219e-02f, -1.10373655e-02f, 5.81828766e-02f,
  1.29198628e-02f, -1.01085193e-02f, 1.30492197e-02f, 5.97258955e-02f, -1.98004786e-02f, 6.19861633e-02f, -4.70429882e-02f, -3.89219797e-03f, -5.46592660e-02f, -3.59536931e-02f,
  -7.33446628e-02f, -4.08405773e-02f, 5.00994623e-02f, -8.09723232e-03f, 4.22241725e-02f, -5.53681329e-02f, 3.20323780e-02f, -4.90572788e-02f, -2.11381000e-02f, -3.36333737e-02f,
  -1.37151815e-02f, -5.31580932e-02f, 9.44370683e-03f, 4.01793942e-02f, -2.24307249e-03f, 2.90067438e-02f, 6.11329302e-02f, -4.99807745e-02f, -9.39416874e-04f, -5.05933166e-02f,
  -5.18759452e-02f, 4.64466140e-02f, 6.77298307e-02f, -3.03876624e-02f, -7.11818263e-02f, -5.33351786e-02f, -2.73040570e-02f, -1.62327737e-02f, -1.19297253e-02f, 7.04885721e-02f,
  1.19054671e-02f, -3.06798611e-03f, -9.20707062e-02f, 8.56796652e-03f, 2.69307420e-02f, 6.37036376e-03f, -1.50893657e-02f, 7.22090714e-03f, 4.32942584e-02f, 4.40301560e-02f,
  6.50900453e-02f, -3.36519219e-02f, 3.73079740e-02f, 7.14965686e-02f, -8.26651901e-02f, 5.80196455e-02f, 1.22148748e-02f, 6.71964511e-02f, -3.43727544e-02f, -2.90504210e-02f,
  -6.62284531e-03f, 5.80031909e-02f, -7.63216168e-02f, -7.82637298e-02f, -9.86604244e-02f, -1.34249292e-02f, 2.04377007e-02f, -3.40416208e-02f, -3.09821572e-02f, -1.93152819e-02f,
  1.66453674e-01f, -2.06185710e-02f, -9.08549875e-02f, -1.41255208e-03f, -2.67156046e-02f, 5.61536439e-02f, 1.34317502e-02f, -2.75553367e-03f, 3.38771865e-02f, -4.75023687e-02f,
  -4.55736741e-02f, -4.88482602e-02f, -1.17588587e-01f, 1.01341836e-01f, 1.30429953e-01f, 5.15171103e-02f, 1.32916749e-01f, -2.32225228e-02f, 1.14527464e-01f, 8.00938625e-03f,
  3.25886384e-02f, 5.76846898e-02f, -7.45204017e-02f, -9.64569219e-04f, 1.08469166e-02f, 2.22185720e-02f, -9.24155340e-02f, -1.10566271e-02f, 4.72460538e-02f, 6.69787591e-03f,
  -2.41852226e-03f, -7.80878961e-03f, -2.46000495e-02f, 1.73727553e-02f, -6.45270720e-02f, -4.52672839e-02f, 4.99099400e-03f, -7.96869397e-02f, 7.33466372e-02f, 2.97855884e-02f,
  -4.05280814e-02f, -3.04994714e-02f, -3.13072205e-02f, -7.19804913e-02f, 1.05647445e-02f, 7.13682696e-02f, -1.35602709e-02f, -6.78900555e-02f, -4.10906784e-02f, -8.32846165e-02f,
  -1.65659394e-02f, -7.99042359e-02f, 8.80533606e-02f, -5.02548814e-02f, 1.64348800e-02f, 2.57076360e-02f, -1.23290429e-02f, 4.96313535e-02f, -6.51809573e-02f, -1.52120907e-02f,
  -8.66316706e-02f, -2.88357772e-02f, 4.10181321e-02f, 7.86225721e-02f, -4.41514403e-02f, 2.75294972e-03f, 5.36187459e-03f, -3.69335595e-03f, 4.93329130e-02f, -3.09486706e-02f,
  6.93531185e-02f, -1.21044787e-02f, -1.38443820e-02f, 8.38848646e-04f, 7.45880380e-02f, -5.94955198e-02f, -7.45379552e-02f, -5.03349230e-02f, 4.50592749e-02f, -4.47784886e-02f,
  2.33480954e-04f, -2.09175795e-02f, 3.92916128e-02f, 2.05052886e-02f, -6.46739453e-02f, -6.78745210e-02f, -2.65749041e-02f, 8.05137530e-02f, 5.41824214e-02f, -2.07463522e-02f,
  5.41896783e-02f, -3.73615548e-02f, -7.13245720e-02f, 7.32083768e-02f, 1.16995974e-02f, -3.22039947e-02f, -3.09762787e-02f, -3.32219228e-02f, -3.72990333e-02f, -6.25586882e-02f,
  2.04448402e-02f, 4.53079864e-02f, 8.47832337e-02f, 9.14386287e-03f, 5.67479320e-02f, -6.74069896e-02f, 4.52325642e-02f, -3.19734141e-02f, 3.46758924e-02f, -4.02542762e-02f,
  6.62462227e-03f, 7.81513527e-02f, 5.90468645e-02f, -2.56624315e-02f, 2.36589797e-02f, -9.73794088e-02f, 5.29904366e-02f, -2.84090526e-02f, 5.45462184e-02f, 1.75002459e-02f,
  -5.03976271e-02f, -9.27916393e-02f, 1.17594805e-02f, -1.07193202e-01f, -4.32331935e-02f, -9.59346667e-02f, -1.68376863e-01f, -1.37027413e-01f, 4.33518738e-02f, -6.32806122e-03f,
  -1.23017393e-01f, 7.89954737e-02f, -1.46654323e-01f, 4.14157175e-02f, -8.09501782e-02f, -7.95279518e-02f, -9.16813686e-02f, 3.50464769e-02f, -4.29973826e-02f, -1.17494531e-01f,
  7.60949701e-02f, -1.06958464e-01f, 6.70672655e-02f, -7.34163597e-02f, 3.17846350e-02f, 1.49268499e-02f, 1.01438209e-01f, -1.50798224e-02f, -5.74913435e-02f, 4.59570996e-02f,
  5.27553819e-02f, 1.07236311e-01f, 5.48824109e-02f, 4.43795659e-02f, 4.45893742e-02f, -8.96435976e-02f, -2.30003987e-03f, 6.35225922e-02f, -3.19914240e-03f, -2.69904621e-02f,
  3.13272402e-02f, 7.43092149e-02f, 9.11037102e-02f, -7.17553124e-02f, -6.19511493e-02f, 6.74398765e-02f, 4.78729010e-02f, 7.41790831e-02f, -6.26628250e-02f, 2.58378908e-02f,
  -1.86997484e-02f, 1.28278723e-02f, -1.03865862e-01f, 1.00329947e-02f, 2.90410519e-02f, -3.94163728e-02f, 2.82050017e-03f, 5.18430024e-02f, -6.64735138e-02f, 7.97455758e-02f,
  -8.58037546e-02f, -9.38406140e-02f, -8.95169377e-03f, 9.31579694e-02f, -3.32775824e-02f, 3.89471576e-02f, -6.12916686e-02f, 4.33018878e-02f, -5.24884872e-02f, 4.73545976e-02f,
  -1.43470811e-02f, 4.39209789e-02f, 3.88257578e-02f, 3.17603610e-02f, -4.20019627e-02f, 9.68906730e-02f, 7.37009868e-02f, 7.42064640e-02f, -7.83316270e-02f, 2.61534937e-03f,
  1.11094480e-02f, 2.69132201e-02f, -1.80237275e-02f, 5.28699905e-02f, -9.98384953e-02f, 4.94015366e-02f, -8.30526184e-03f, -1.59447994e-02f, -8.40788521e-03f, -8.51534754e-02f,
  3.90724652e-02f, -9.85661242e-03f, -3.39075699e-02f, 5.88306133e-03f, 6.10929681e-03f, -1.98838208e-02f, 3.50113176e-02f, 5.78458458e-02f, -1.35563696e-02f, 4.15189192e-02f,
  -8.65225196e-02f, 4.30069081e-02f, 2.65991967e-02f, 4.39606868e-02f, -3.67246531e-02f, -6.95583001e-02f, -7.79625475e-02f, -5.95653839e-02f, 1.35546625e-02f, 5.99470399e-02f,
  -1.40025597e-02f, -3.95787209e-02f, 1.51081514e-02f, 3.49205397e-02f, -2.34905500e-02f, 1.62401870e-02f, 4.97017205e-02f, -3.75304967e-02f, -5.08706644e-02f, -7.02817515e-02f,
  8.40843990e-02f, -6.72849789e-02f, 3.40688750e-02f, 5.61406054e-02f, 3.30438092e-03f, -5.43898568e-02f, -5.29852659e-02f, -8.26896727e-03f, 1.57289580e-01f, -8.27808902e-02f,
  -7.62212370e-03f, 3.48218121e-02f, -1.07739963e-01f, -2.45154295e-02f, -5.23545742e-02f, 5.39336391e-02f, -1.86758209e-02f, -6.01791777e-02f, 1.03877582e-01f, -8.96660611e-02f,
  6.83704438e-03f, -6.71745688e-02f, 1.25932880e-02f, -8.12911093e-02f, 2.64241509e-02f, -7.72004202e-02f, -1.05447330e-01f, 6.71426393e-03f, -1.08999886e-01f, -8.64572227e-02f,
  1.01447985e-01f, 6.87549636e-02f, 4.49108742e-02f, 9.22414362e-02f, 7.28802904e-02f, 5.07034957e-02f, -8.62790868e-02f, -6.33302107e-02f, 9.19174477e-02f, -8.40396062e-02f,
  -3.44754867e-02f, -1.03451610e-01f, 1.62800141e-02f, -6.36480004e-02f, 7.37993419e-02f, 9.27124098e-02f, 1.03439830e-01f, -1.74746513e-02f, 3.93496193e-02f, -1.84236299e-02f,
  6.77052736e-02f, 2.17459965e-02f, -1.40324859e-02f, 4.47975881e-02f, 2.69487929e-02f, -5.40666617e-02f, 1.44020785e-02f, -5.20216487e-02f, -3.54516022e-02f, -6.20687306e-02f,
  -5.20256609e-02f, 3.03316563e-02f, -3.95469666e-02f, -5.68485335e-02f, -1.31017333e-02f, 9.19062868e-02f, -3.57903987e-02f, 2.07995856e-03f, 1.01186723e-01f, 5.94604351e-02f,
  5.54436371e-02f, -3.43192294e-02f, 6.48727342e-02f, 1.11910040e-02f, -2.03840006e-02f, 6.45031184e-02f, 5.97119853e-02f, -5.67518994e-02f, 1.29209952e-02f, -8.18495080e-02f,
  -4.61683236e-02f, -7.25949125e-04f, -5.07581085e-02f, -5.27686719e-03f, -1.12097403e-02f, 8.03734958e-02f, -7.09881708e-02f, 5.71643785e-02f, 2.15276703e-02f, 4.01232913e-02f,
  -1.06538581e-02f, 5.90206459e-02f, -4.75619622e-02f, 7.35760061e-03f, 2.34653223e-02f, -2.77751242e-03f, -4.58625555e-02f, 5.52283227e-02f, -4.22234647e-02f, -2.03384850e-02f,
  -4.14419314e-03f, -4.72024083e-02f, -6.23478368e-02f, -1.40260924e-02f, 3.36571634e-02f, 4.24145050e-02f, 2.02567186e-02f, 6.32567517e-03f, -6.81387782e-02f, 4.20844443e-02f,
  1.08647989e-02f, 2.13991515e-02f, -6.61657825e-02f, 2.90276250e-03f, -5.43052033e-02f, 2.21502725e-02f, -6.66611316e-03f, 6.81938007e-02f, -9.67521220e-02f, -4.24307911e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  -1.12400940e-02f, -4.34426665e-02f, 6.42149076e-02f, 4.82806601e-02f, 4.63223718e-02f, 6.09609485e-02f, -3.78268259e-03f, -3.43768746e-02f, 5.75467683e-02f, 1.65316030e-01f,
  1.40079126e-01f, -2.36703809e-02f, 1.96898766e-02f, -5.22891656e-02f, 1.33800179e-01f, 5.01251295e-02f, -3.25818323e-02f, 1.23197109e-01f, -2.79363338e-02f, -9.41206217e-02f,
  1.62495039e-02f, 5.39732054e-02f, 1.03755370e-01f, 4.09741029e-02f, -4.34316844e-02f, 1.08379140e-01f, 1.30736409e-02f, -3.90928015e-02f, 4.56443094e-02f, 1.06361218e-01f,
  8.85059610e-02f, 7.06641078e-02f, 3.41487229e-02f, 1.30329579e-01f, 8.00525695e-02f, 1.51351199e-01f, 1.18575253e-01f, -4.44881581e-02f, -4.24374044e-02f, 3.38156708e-02f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -1.17356926e-01f, 1.09726563e-01f, -5.55447824e-02f, 1.65236458e-01f, 9.10016522e-02f, -1.08202383e-01f, 8.54689777e-02f, 4.32379656e-02f, -1.50663435e-01f, -3.59660871e-02f,
  2.17112284e-02f, 1.52396634e-01f, 1.93428978e-01f, 2.37918481e-01f, 2.22524896e-01f, -1.16331428e-02f, 1.11205950e-01f, -1.13801405e-01f, 2.55346559e-02f, -1.02816679e-01f,
  -5.71506191e-03f, -5.44453003e-02f, -1.96882144e-01f, 1.48481533e-01f, -3.17333564e-02f, -1.89449079e-02f, 5.34834377e-02f, 1.16304107e-01f, 1.62604060e-02f, -9.09420326e-02f,
  -1.04481779e-01f, -8.40743706e-02f, 1.00777499e-01f, -9.45522860e-02f, -6.63338974e-03f, 9.95752588e-02f, 3.62260938e-02f, -2.33316682e-02f, 2.50398125e-02f, 1.94182873e-01f,
  5.20683266e-02f, -1.71430469e-01f, -1.55779213e-01f, 7.22783282e-02f, 4.37132679e-02f, -9.62041095e-02f, 9.91396606e-02f, 1.33981436e-01f, 1.81528449e-01f, -1.28004909e-01f,
  -1.45224771e-02f, -1.52910382e-01f, 1.49343967e-01f, 2.42939275e-02f, -8.32261369e-02f, 9.13804248e-02f, -1.33127019e-01f, 1.76398065e-02f, -2.42422931e-02f, 1.22974135e-01f,
  2.27898836e-01f, 9.45940167e-02f, 8.41842219e-02f, -8.74714926e-02f, 1.21670393e-02f, -2.94593483e-01f, -5.66523783e-02f, -1.28596276e-01f, 8.45552608e-02f, 3.62124480e-02f,
  6.27458692e-02f, -8.40017796e-02f, 5.06065860e-02f, -1.15184253e-03f, 5.85118420e-02f, 7.15135559e-02f, -1.37126341e-01f, 1.74235478e-02f, 2.85457782e-02f, -1.46678602e-02f,
  1.01838522e-01f, -1.51785553e-01f, 1.60217345e-01f, 1.19304165e-01f, -5.55230305e-02f, -9.89572033e-02f, -9.27858949e-02f, -2.82736093e-01f, -1.16114253e-02f, -5.00418469e-02f,
  -9.49804857e-02f, 1.08708926e-02f, 2.31790263e-02f, -7.93774724e-02f, -9.31621119e-02f, -1.42959028e-01f, -4.18970967e-03f, 1.22622468e-01f, 1.83794443e-02f, 1.74758002e-01f,
  1.30339652e-01f, 1.55198187e-01f, 3.27333398e-02f, 7.66722709e-02f, 2.26839617e-01f, 1.39419347e-01f, 9.97174159e-03f, 4.18347567e-02f, -1.01193925e-03f, 1.19230412e-01f,
  2.17777137e-02f, 1.28207132e-01f, -4.63537164e-02f, 1.10591009e-01f, 6.88013136e-02f, 7.78688565e-02f, -5.38011715e-02f, -3.86884250e-02f, -2.88105216e-02f, -5.50396331e-02f,
  -1.31609112e-01f, -1.51968971e-01f, -4.37221825e-02f, 6.12845011e-02f, -1.53635606e-01f, 5.87746091e-02f, 8.76213983e-02f, 2.88310535e-02f, -1.07900761e-01f, -5.71660213e-02f,
  8.74122605e-02f, -5.94849372e-03f, -1.11701759e-02f, -2.30408832e-03f, 5.63065056e-04f, 4.65373732e-02f, 2.04731580e-02f, -6.12689629e-02f, -1.02269836e-01f, -7.70296231e-02f,
  -1.87373504e-01f, 6.63886964e-02f, -1.11463070e-01f, 3.18712331e-02f, 1.27189875e-01f, 1.72202006e-01f, -5.32060266e-02f, 2.01793507e-01f, -1.39722098e-02f, -1.75235316e-01f,
  -4.02731337e-02f, -1.15969479e-01f, 4.98433709e-02f, 4.04088870e-02f, 1.29754227e-02f, 4.72681113e-02f, 1.99809834e-01f, 5.40249385e-02f, -5.66777587e-02f, 4.33992706e-02f,
  7.38156363e-02f, 8.88531804e-02f, -1.90951362e-01f, -6.55714944e-02f, -1.77070826e-01f, 1.94682814e-02f, 1.59806713e-01f, -1.07339643e-01f, -1.55963793e-01f, 6.40099943e-02f,
  -9.39663872e-02f, -3.83955464e-02f, 7.15367943e-02f, -7.18294084e-02f, -1.16696715e-01f, 1.18163135e-02f, -4.26310711e-02f, 1.66791230e-01f, -9.40933526e-02f, -1.03713937e-01f,
  -1.45893514e-01f, -8.46123993e-02f, 3.46985050e-02f, 9.67532471e-02f, -1.01017855e-01f, 3.58773656e-02f, 3.68670858e-02f, -7.66444951e-02f, -6.75699934e-02f, -8.19750801e-02f,
  9.33112055e-02f, -9.51176807e-02f, -1.92407593e-02f, -1.74770549e-01f, 2.85637137e-02f, 3.09968293e-02f, 4.02243845e-02f, -1.12021826e-01f, 1.15653567e-01f, 3.87997106e-02f,
  4.01314050e-02f, -1.26303539e-01f, -3.06154117e-02f, -1.03186317e-01f, -1.35807648e-01f, 1.29503027e-01f, -1.68591633e-01f, 2.31298566e-01f, 3.59553754e-01f, -1.41420081e-01f,
  -1.99821040e-01f, 2.39731863e-01f, -3.36638570e-01f, -9.75342989e-02f, -3.36343870e-02f, 1.02624312e-01f, 4.63202484e-02f, 1.08559221e-01f, -1.47334665e-01f, -8.51219706e-03f,
  -5.29507063e-02f, -1.00153536e-01f, 5.28583042e-02f, -1.44288406e-01f, 6.94859996e-02f, 1.07928500e-01f, 6.19558580e-02f, -1.00718193e-01f, -1.00447454e-01f, 8.59585181e-02f,
  1.87607676e-01f, 6.46752939e-02f, -1.14519067e-01f, 6.96256012e-02f, -6.31254762e-02f, 1.68899093e-02f, -1.01090454e-01f, -1.62426949e-01f, 6.17588609e-02f, -1.41068399e-01f,
  1.33356631e-01f, 3.99516746e-02f, 4.12210822e-03f, -1.69808622e-02f, 9.67518613e-02f, -4.92390953e-02f, 7.99564570e-02f, -5.52863479e-02f, -1.19836256e-01f, -4.83966395e-02f,
  6.67956397e-02f, 1.76967248e-01f, 5.02703972e-02f, -4.31801984e-03f, 1.25546777e-03f, -8.64510164e-02f, -1.77344620e-01f, 1.73543766e-01f, 2.38763411e-02f, 4.93860655e-02f,
  -6.75255433e-02f, -9.24443826e-02f, -1.09626232e-02f, -1.02841072e-01f, -1.43210560e-01f, -1.70806959e-01f, -8.03514123e-02f, 5.41042611e-02f, 9.28306207e-02f, -1.04798608e-01f,
  1.66254744e-01f, -1.06528243e-02f, -6.50866479e-02f, 4.66034785e-02f, -2.38717571e-01f, -2.14617863e-01f, -2.10864022e-01f, 1.44719720e-01f, -1.49305537e-01f, 2.25767225e-01f,
  -1.38437282e-02f, 1.48573130e-01f, 8.79578143e-02f, -1.01149611e-01f, -2.28636757e-01f, -2.22123936e-02f, 1.01937234e-01f, -1.21362202e-01f, -1.09368540e-01f, -1.19790904e-01f,
  1.32745415e-01f, -1.41185641e-01f, 1.20354466e-01f, -1.63237005e-02f, -1.21870443e-01f, 1.75435007e-01f, 6.93020150e-02f, -2.31040150e-01f, -1.39396563e-01f, 9.82090980e-02f,
  1.51434690e-01f, -1.71612203e-01f, 8.46574455e-02f, 1.76823154e-01f, 6.50509447e-02f, -1.29306287e-01f, 2.58018207e-02f, -5.28463759e-02f, -8.62202123e-02f, 4.11686637e-02f,
  9.02056042e-03f, 1.71128929e-01f, 1.62794709e-01f, -6.13054484e-02f, 8.43929127e-02f, -1.41847193e-01f, 2.11265579e-01f, 1.40204340e-01f, -3.15391831e-02f, -2.07775887e-02f,
  7.26263374e-02f, -1.56857774e-01f, 2.35981662e-02f, 1.04011111e-01f, 8.86259601e-02f, -7.60723427e-02f, 8.26712772e-02f, -4.67453375e-02f, 7.63190538e-02f, -1.93685994e-01f,
  -1.11358710e-01f, -2.87769716e-02f, 1.27071524e-02f, 1.38283134e-01f, -1.55124545e-01f, -5.26023097e-02f, -4.65674791e-03f, 3.68583389e-02f, -1.15801685e-01f, 4.32314314e-02f,
  -1.17368132e-01f, 1.08350322e-01f, -1.12747490e-01f, -7.10873380e-02f, 1.46564186e-01f, 7.88368732e-02f, 3.59998047e-02f, 1.13382742e-01f, -1.47847190e-01f, 6.51538745e-02f,
  8.43394250e-02f, -7.96692595e-02f, -4.51155491e-02f, 7.47240260e-02f, -8.28038678e-02f, -1.02183975e-01f, -5.13359122e-02f, -4.99609038e-02f, 6.58321828e-02f, -1.15870371e-01f,
  7.39677623e-02f, 3.12095154e-02f, -7.43597373e-02f, 9.83211845e-02f, -5.50450645e-02f, 9.37894136e-02f, 7.56107941e-02f, 8.73394981e-02f, -7.69385546e-02f, 9.17478427e-02f,
  -6.75675496e-02f, -1.27874777e-01f, -9.03342739e-02f, -1.41686514e-01f, 1.07074738e-01f, 5.00229932e-02f, -9.78259966e-02f, 1.60219707e-02f, 1.82325281e-02f, 9.93090216e-03f,
  1.00403978e-02f, -8.83381441e-02f, 6.30288273e-02f, 6.78855404e-02f, 1.09875806e-01f, 1.58130750e-01f, 6.87392056e-02f, -5.10094538e-02f, -1.24020651e-01f, 1.33050203e-01f,
  -5.86998500e-02f, 1.03812814e-01f, -1.54855967e-01f, 2.99419314e-01f, 1.40902668e-01f, 6.82647377e-02f, 8.92480370e-03f, 2.39975363e-01f, 2.31512368e-01f, -6.76202253e-02f,
  -1.31431937e-01f, -1.31406151e-02f, 3.74749601e-02f, -7.36490637e-02f, 1.06797926e-01f, -1.11997440e-01f, -4.25755456e-02f, 5.73177561e-02f, -8.58448446e-02f, -1.22070886e-01f,
  -5.05228527e-02f, 2.39919536e-02f, 1.55079570e-02f, -1.20101281e-01f, -7.32218698e-02f, 1.35207608e-01f, 4.48151305e-02f, -8.02179128e-02f, 2.62918472e-02f, 1.23906672e-01f,
  -6.22061715e-02f, 9.15212631e-02f, 1.85662489e-02f, 3.41089591e-02f, 1.87319741e-01f, -8.91503245e-02f, -4.54972684e-02f, 7.77014643e-02f, -2.20615007e-02f, 1.64437875e-01f,
  -9.14945155e-02f, 7.28064328e-02f, 9.44693945e-03f, -1.26379594e-01f, -2.07150411e-02f, -9.78424400e-02f, -1.82232831e-03f, -1.23794161e-01f, -1.04961552e-01f, 1.41115487e-01f,
  1.58666391e-02f, -1.30987978e-02f, -8.57336149e-02f, 2.08613314e-02f, 8.32017511e-02f, -7.29898289e-02f, -1.02946937e-01f, -1.08964749e-01f, 1.36592120e-01f, -6.05666749e-02f,
  -6.95170928e-03f, 2.48320587e-02f, -4.78914194e-02f, 3.02047259e-03f, -1.31934837e-01f, -1.91039830e-01f, -9.03662890e-02f, 1.49485007e-01f, 9.05493572e-02f, -4.29967940e-02f,
  -6.30514622e-02f, 1.06374957e-01f, -8.96837749e-03f, -1.56696156e-01f, -1.60457164e-01f, 8.86573344e-02f, 9.91486087e-02f, 5.68378121e-02f, 2.55703956e-01f, 6.02201261e-02f,
  1.70024019e-02f, -1.58261582e-01f, 1.78045463e-02f, -2.88054366e-02f, 2.53845826e-02f, 2.19181105e-02f, -7.96365589e-02f, -2.12952700e-02f, -2.07779352e-02f, -8.58133882e-02f,
  1.00359246e-01f, -3.10974047e-02f, 1.16759337e-01f, 1.05619587e-01f, 7.62086511e-02f, 1.42603651e-01f, 2.12204549e-02f, -8.36457908e-02f, 2.37462431e-01f, -1.06688283e-01f,
  -4.51490562e-03f, -4.42671180e-02f, -1.44479185e-01f, 2.80872472e-02f, 7.95102045e-02f, -4.86729201e-03f, 2.79823951e-02f, -1.95345730e-02f, -1.90448463e-02f, -1.91965010e-02f,
  9.91171673e-02f, 1.21567152e-01f, -4.49693874e-02f, 1.15830321e-02f, -6.66033030e-02f, 1.62721369e-02f, 4.70498689e-02f, -1.03001287e-02f, 4.17824537e-02f, 4.89823669e-02f,
  -1.37387604e-01f, -4.92545478e-02f, -8.78162906e-02f, 7.88509175e-02f, -5.51201124e-03f, -5.05297221e-02f, -1.12574816e-01f, -5.61041310e-02f, 1.75415855e-02f, -7.94236511e-02f,
  -1.76475897e-01f, 1.89869091e-01f, 7.56201297e-02f, 1.74222365e-01f, -3.90826799e-02f, 1.16252847e-01f, 2.53681809e-01f, 1.05078422e-01f, 2.56133247e-02f, 1.44205671e-02f,
  1.34842709e-01f, 2.69302465e-02f, -1.91820651e-01f, 2.08785087e-02f, -6.14757612e-02f, 1.10896062e-02f, -1.13095894e-01f, -5.93430735e-02f, -1.70234889e-01f, 9.34042409e-02f,
  1.74009353e-01f, -1.57241762e-01f, -2.05508843e-01f, 2.03470856e-01f, -8.48196447e-02f, -3.75810973e-02f, -1.09197930e-01f, 4.36707698e-02f, -1.30800471e-01f, -9.81236771e-02f,
  -1.43778145e-01f, 1.49853542e-01f, -1.44687025e-02f, -1.41793102e-01f, -1.26504064e-01f, 6.48532212e-02f, -1.05641022e-01f, -1.93681061e-01f, 1.12249795e-02f, 2.05389503e-02f,
  2.80781072e-02f, -1.67807937e-02f, -1.87761232e-01f, 7.07251877e-02f, 8.21074173e-02f, -1.59294829e-01f, -2.01971121e-02f, -4.19616923e-02f, -3.44745517e-02f, 1.44929245e-01f,
  -5.78547828e-03f, 1.40094891e-01f, 1.06426984e-01f, -7.97070116e-02f, -1.46151558e-01f, -8.08225479e-03f, -5.91706783e-02f, -1.79427788e-01f, 1.01176498e-03f, -1.46984473e-01f,
  -1.43594578e-01f, -3.23267281e-02f, -1.14406295e-01f, -4.40423638e-02f, 7.44688418e-03f, 2.41763175e-01f, 1.36951029e-01f, 2.15384871e-01f, -8.15915540e-02f, 9.96071622e-02f,
  1.96975797e-01f, 1.53768668e-02f, 5.89971654e-02f, 8.25823247e-02f, 1.66641250e-01f, 7.72547498e-02f, -7.77568817e-02f, -1.24771215e-01f, -2.14732602e-01f, -1.67936340e-01f,
  -1.30135149e-01f, -1.03161454e-01f, -4.77737002e-02f, 2.19583213e-02f, -7.35666901e-02f, -1.32602617e-01f, -1.92691252e-01f, 7.65056834e-02f, -1.48535823e-03f, -2.73720897e-03f,
  7.48584121e-02f, 2.62215465e-01f, -3.14952736e-03f, 6.70117661e-02f, 2.50629652e-02f, 1.57685190e-01f, 1.62997708e-01f, 3.59481648e-02f, -8.47475752e-02f, -1.06511563e-01f,
  -1.38016894e-01f, 1.36793479e-01f, 1.04097329e-01f, 6.91887066e-02f, -4.46213260e-02f, -1.29824027e-01f, 1.29533820e-02f, 4.87864949e-02f, -1.89765319e-02f, -9.42599103e-02f,
  -1.23503560e-03f, 1.25402927e-01f, -1.30574867e-01f, -7.97560439e-02f, -3.52189131e-02f, 1.35564759e-01f, 7.47109205e-02f, 1.15222886e-01f, -1.75919235e-01f, -4.58040275e-02f,
  -9.34612229e-02f, 1.43706292e-01f, -8.41821209e-02f, 1.12188578e-01f, -1.13017395e-01f, 3.48077528e-02f, -6.01143986e-02f, 8.37339461e-02f, 3.78359593e-02f, 1.13970283e-02f,
  -3.12492177e-02f, -2.20995732e-02f, -5.36502637e-02f, 2.03003883e-01f, -8.14859495e-02f, -4.06681970e-02f, -2.21755691e-02f, -1.14947550e-01f, -8.60548690e-02f, 6.83178082e-02f,
  -1.69797897e-01f, -7.46575817e-02f, -1.77610099e-01f, -3.98705378e-02f, -1.19090146e-04f, -6.18272200e-02f, 8.41685906e-02f, 1.08384408e-01f, -1.72804654e-01f, -1.39651701e-01f,
  7.80497640e-02f, -1.41356379e-01f, -1.01961792e-01f, -1.25807673e-01f, 5.01943491e-02f, 3.21477465e-02f, -5.32429889e-02f, 8.28112364e-02f, 6.96885288e-02f, -7.53539568e-03f,
  -1.04985282e-01f, 8.15009028e-02f, 9.89496782e-02f, -7.70054385e-02f, 1.03375457e-01f, 7.78672844e-02f, 3.30426991e-02f, -8.85667801e-02f, 1.21486172e-01f, -5.55779301e-02f,
  -1.20062947e-01f, -9.46497694e-02f, 1.29918128e-01f, -1.63570605e-02f, -4.77836952e-02f, 4.40502018e-02f, 1.09542571e-01f, 2.86894664e-03f, -5.25529645e-02f, -5.18808365e-02f,
  -1.33237047e-02f, 1.21788308e-01f, -4.69561592e-02f, 9.04391482e-02f, 8.98569301e-02f, -1.27444535e-01f, -5.66164888e-02f, -2.59021893e-02f, -9.68127791e-03f, 8.38519484e-02f,
  -2.33843252e-02f, 1.25460494e-02f, 1.69346422e-01f, 2.74800152e-01f, 5.25186509e-02f, 9.08292979e-02f, -2.05818474e-01f, -8.32387060e-02f, 1.03568837e-01f, -3.74296978e-02f,
  -3.89500894e-02f, 4.45392691e-02f, 1.03938214e-01f, -1.24651985e-02f, 2.84104466e-01f, -1.78947851e-01f, 9.33214352e-02f, -2.50086606e-01f, -2.42455155e-02f, -1.49763271e-01f,
  -8.75056162e-02f, -6.42338246e-02f, 1.08914666e-01f, 8.85224715e-02f, -1.18717186e-01f, -7.05815910e-05f, -1.03816248e-01f, -7.31521696e-02f, 4.28040251e-02f, 2.09432300e-02f,
  2.54678540e-02f, 1.58500016e-01f, 1.99370887e-02f, -1.42532185e-01f, -4.90901507e-02f, -2.72846147e-02f, 1.08559355e-01f, 1.08589321e-01f, -1.56543050e-02f, 1.32058963e-01f,
  -1.18904501e-01f, 1.32063642e-01f, -1.82759568e-01f, -7.73080736e-02f, 4.78912219e-02f, 1.05073906e-01f, -5.22929728e-02f, -3.10575273e-02f, 1.16794724e-02f, -2.99045239e-02f,
  4.94320802e-02f, -2.16321740e-02f, -3.47376913e-02f, -1.16339050e-01f, -1.50548458e-01f, -7.82101136e-03f, -5.88161126e-02f, 1.03748040e-02f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -2.77026482e-02f, -4.37469222e-03f, 8.00273120e-02f, -7.25287944e-02f, 1.07336067e-01f, -1.36788070e-01f, 3.24272225e-03f, 1.10187076e-01f, -7.90726990e-02f, -7.92603567e-02f,
  -7.67799690e-02f, 2.69802148e-03f, 4.56317849e-02f, 2.73877606e-02f, 1.02927804e-01f, -6.89515099e-02f, -3.17542888e-02f, 8.87079537e-02f, -8.04336444e-02f, 1.03275418e-01f,
  -6.34866059e-02f, -4.62788269e-02f, -1.01863950e-01f, -1.04002215e-01f, -5.02447896e-02f, 1.11423060e-02f, -1.10560648e-01f, 8.18154775e-03f, -7.82730281e-02f, 3.90612222e-02f,
  -1.25101581e-01f, -3.72564085e-02f, -3.81278209e-02f, -1.28538668e-01f, 9.67325568e-02f, -4.89472002e-02f, 6.31028861e-02f, 1.30752064e-02f, 7.84872845e-02f, 7.18950406e-02f,
  -7.28358030e-02f, -5.52446954e-02f, 2.22484041e-02f, 7.12241605e-02f, 5.09008504e-02f, -8.55425894e-02f, -2.86277775e-02f, -8.39085970e-03f, -6.31276891e-02f, -6.85810074e-02f,
  5.14981663e-03f, 3.65336798e-02f, 9.93906707e-02f, -2.31473688e-02f, 5.56493960e-02f, 2.35261745e-03f, -4.99432459e-02f, -1.14178449e-01f, -7.53936321e-02f, -1.20307542e-01f,
  6.61908388e-02f, 6.84657097e-02f, -3.47125321e-03f, -3.50511931e-02f, 1.24804556e-01f, -5.72412312e-02f, 4.95209023e-02f, -8.57895240e-02f, -3.61591242e-02f, -1.52141117e-02f,
  1.33058373e-02f, 4.83055376e-02f, -3.63917127e-02f, 3.46390554e-03f, 9.87161547e-02f, -8.88350420e-03f, 2.91229766e-02f, 1.43066362e-01f, 1.11461774e-01f, -2.56953388e-02f,
  1.10124554e-02f, 1.07706085e-01f, 4.04532738e-02f, 9.33007598e-02f, 7.64468834e-02f, 1.25491954e-02f, -8.63268822e-02f, 4.83912118e-02f, 7.50867203e-02f, 8.77744332e-02f,
  3.85694467e-02f, -1.45873539e-02f, 7.98786357e-02f, -5.53391539e-02f, 1.02425255e-01f, 8.06967914e-02f, -2.12673657e-02f, 1.19595146e-02f, -1.17327526e-01f, 1.69187441e-01f,
  -1.12237744e-01f, 7.28357397e-03f, 3.09796515e-03f, 1.32133067e-01f, 1.22492455e-01f, 5.94696403e-03f, -1.34752914e-02f, -8.22842941e-02f, 6.35631308e-02f, 1.02794550e-01f,
  -2.84976382e-02f, 1.55796250e-02f, -1.05837621e-02f, -8.02479237e-02f, -3.29684690e-02f, 1.19915284e-01f, 1.57264378e-02f, -1.28766879e-01f, -1.22986436e-01f, -5.49263172e-02f,
  -5.63196465e-02f, -8.56773928e-02f, -8.95675346e-02f, 5.54294288e-02f, -5.24191968e-02f, 8.72517675e-02f, -3.18679260e-03f, -5.71432225e-02f, -5.99292591e-02f, -7.07205012e-02f,
  -8.45765695e-03f, 1.59185812e-01f, -3.88817936e-02f, 3.23967542e-03f, 1.42975911e-01f, 1.29744131e-02f, -6.08500913e-02f, -4.06081672e-04f, -7.64887407e-03f, -9.89891961e-02f,
  1.35767892e-01f, -5.26807085e-02f, -1.02187030e-01f, 1.15042582e-01f, -9.56648514e-02f, 1.10503979e-01f, 6.40807897e-02f, -3.98363099e-02f, -1.06806755e-01f, -2.65907422e-02f,
  6.01182096e-02f, 2.65766343e-04f, -9.21046594e-04f, -4.28264849e-02f, 6.92922920e-02f, 1.32591382e-01f, -5.41742072e-02f, 5.64152189e-02f, 1.38795689e-01f, 1.23206735e-01f,
  -3.24474508e-03f, -4.18103971e-02f, 8.76044631e-02f, -1.51871502e-01f, 7.40308911e-02f, -1.14290282e-01f, 9.75319818e-02f, 7.57401362e-02f, -1.20010138e-01f, 2.77195056e-03f,
  -8.56089294e-02f, 1.06885806e-01f, -7.51103368e-03f, -1.51049048e-02f, -8.85345861e-02f, 5.38965054e-02f, 1.41147496e-02f, -1.45873344e-02f, 9.20049772e-02f, -1.11555971e-01f,
  -9.44902673e-02f, 8.66414011e-02f, -9.60104242e-02f, -1.18433267e-01f, -7.32537955e-02f, 1.19926386e-01f, -6.92727268e-02f, 2.39431653e-02f, -6.24408498e-02f, 4.67511974e-02f,
  2.14314442e-02f, -2.73418869e-03f, 1.14341259e-01f, 2.41937004e-02f, 3.82080190e-02f, -4.66344766e-02f, -3.66127230e-02f, -2.38382444e-02f, -7.70195201e-02f, -6.03252985e-02f,
  1.06067672e-01f, 1.20727628e-01f, 1.55080721e-01f, -2.72705443e-02f, -2.47215517e-02f, -2.22838353e-02f, 1.72938511e-01f, 1.77279651e-01f, -1.25521109e-01f, 5.18113226e-02f,
  1.49060041e-01f, 1.09837160e-01f, 5.48277982e-02f, -1.20858103e-01f, -8.20679776e-03f, 1.12243660e-01f, 6.36769310e-02f, 5.57680093e-02f, 8.21331665e-02f, -3.13729346e-02f,
  2.30966747e-01f, -4.51356620e-02f, -1.02823898e-01f, 1.37773767e-01f, 3.12197451e-02f, -3.74266226e-03f, 7.95315281e-02f, 1.58629969e-01f, -1.13736823e-01f, 2.81394850e-02f,
  -1.39094451e-02f, 1.30233705e-01f, 5.71611486e-02f, -1.49642779e-02f, -5.11722341e-02f, -9.93044376e-02f, -3.01072709e-02f, -1.13252029e-01f, -5.05420566e-02f, 4.11069654e-02f,
  -6.65234327e-02f, -9.32863802e-02f, 6.43674955e-02f, 5.02334647e-02f, -1.24662384e-01f, 7.36338496e-02f, 1.12927496e-01f, 6.06159233e-02f, -7.26358443e-02f, 1.21895276e-01f,
  -3.80744077e-02f, 1.59700543e-01f, 1.22590341e-01f, 1.10906281e-01f, -8.67506936e-02f, 1.36933085e-02f, 4.78331782e-02f, 1.97211266e-01f, 8.01972300e-02f, 1.01791993e-01f,
  1.09585412e-01f, 1.54006518e-02f, -6.52342513e-02f, 1.66919291e-01f, 8.07939619e-02f, 6.71402216e-02f, 5.11543415e-02f, -5.78544289e-02f, 2.35173609e-02f, 9.34871957e-02f,
  8.87078792e-02f, -1.25530198e-01f, 3.43990177e-02f, -8.70914478e-03f, -1.19788133e-01f, -1.13238610e-01f, 1.00997448e-01f, 1.50860548e-01f, -8.57225060e-02f, -5.14197461e-02f,
  -1.05670147e-01f, 9.02627036e-02f, 1.49634466e-01f, 9.88532156e-02f, -8.99919271e-02f, -1.00157619e-01f, -3.10509019e-02f, 7.26953149e-02f, 7.10228905e-02f, -7.54438788e-02f,
  1.13108158e-01f, -7.90399238e-02f, 2.00732443e-02f, -2.31129359e-02f, -2.38124337e-02f, -9.05497968e-02f, -1.17960563e-02f, 1.76623631e-02f, 7.99599886e-02f, -2.99485903e-02f,
  -1.83893442e-02f, 8.66444632e-02f, -1.07851572e-01f, -7.28365779e-02f, -2.05040183e-02f, -1.20829709e-01f, 1.44583350e-02f, 8.39861669e-03f, 9.97745693e-02f, 5.58059812e-02f,
  -5.54649085e-02f, -1.12792403e-01f, -4.02987413e-02f, -4.88432050e-02f, -7.34632909e-02f, -9.22515392e-02f, 1.28829896e-01f, -6.93030208e-02f, -8.31844062e-02f, -3.07218693e-02f,
  8.36598054e-02f, -2.54889708e-02f, 7.22605884e-02f, 1.88335717e-01f, 7.78985843e-02f, 1.21938765e-01f, 1.90811709e-01f, 1.68454692e-01f, 2.91089088e-01f, 1.75600365e-01f,
  4.23881598e-02f, 4.19269921e-03f, -2.07518578e-01f, 1.08868785e-01f, -1.20021902e-01f, -4.25748155e-02f, -6.38639107e-02f, -1.21947393e-01f, 1.18079856e-01f, 1.74338087e-01f,
  8.01474527e-02f, -8.61728378e-03f, 3.07458509e-02f, -1.37133077e-01f, 8.62820670e-02f, 8.52615610e-02f, 1.02554828e-01f, 1.30954489e-01f, -2.05095741e-03f, 1.24992646e-01f,
  1.12853102e-01f, 4.44020368e-02f, 1.40333533e-01f, 2.13102013e-01f, -1.26923472e-01f, 1.50625035e-01f, -1.15072064e-01f, -1.33537445e-02f, 1.67964011e-01f, -2.81785466e-02f,
  2.54189987e-02f, 2.34337524e-01f, -8.02970231e-02f, 1.07477978e-01f, 1.03203885e-01f, 4.02799062e-02f, -4.32030968e-02f, -7.16505796e-02f, -1.28554955e-01f, 1.68620273e-01f,
  -5.24972975e-02f, -1.71274114e-02f, 1.03477463e-01f, -6.00490831e-02f, -1.91359147e-02f, -8.85495842e-02f, 9.69981477e-02f, -7.26469606e-02f, 2.15030946e-02f, 8.10813233e-02f,
  -6.98009282e-02f, 3.80686522e-02f, -6.56498373e-02f, -6.58552349e-02f, 1.33265883e-01f, 6.74411505e-02f, -8.56471062e-02f, -4.73758355e-02f, -1.94414556e-02f, 6.00838326e-02f,
  1.24925822e-01f, 1.72612682e-01f, 9.98347551e-02f, 9.25972611e-02f, 1.10616777e-02f, 1.25096470e-01f, -3.69844288e-02f, -7.02583492e-02f, -9.75781605e-02f, 2.98867933e-02f,
  -1.00162931e-01f, 1.34038448e-01f, -5.87825552e-02f, -2.16552196e-03f, -1.23987831e-01f, -6.31008893e-02f, 2.59049684e-02f, -4.28594388e-02f, 1.29504651e-01f, 1.35614276e-01f,
  6.95072263e-02f, 2.95250602e-02f, 8.11685547e-02f, -1.48941558e-02f, -7.00018033e-02f, 1.18065000e-01f, 1.28403469e-03f, -6.29967675e-02f, -6.83548003e-02f, -2.44651660e-02f,
  -3.62453349e-02f, 1.09036088e-01f, 1.18908584e-01f, -8.04715678e-02f, -8.70729424e-03f, -2.75742598e-02f, 3.90439443e-02f, -7.50739053e-02f, 9.41712633e-02f, 2.74385908e-03f,
  -4.50392254e-02f, -7.52070770e-02f, 3.50917615e-02f, 1.95500508e-01f, -5.45483045e-02f, -7.96928629e-02f, -1.31664217e-01f, 4.83777598e-02f, 1.66318025e-02f, -1.59051158e-02f,
  -1.90251898e-02f, 3.31331007e-02f, 7.18564242e-02f, -9.49468985e-02f, -8.09126869e-02f, 4.90244366e-02f, 1.47722894e-02f, -2.55444217e-02f, -8.79087374e-02f, -5.72074242e-02f,
  7.51098096e-02f, 6.37291968e-02f, -1.26997247e-01f, 8.82547572e-02f, -5.85454740e-02f, -9.42194164e-02f, 6.31928444e-02f, 1.08347252e-01f, -9.28412378e-02f, 6.66744933e-02f,
  -1.34496242e-01f, -1.31983563e-01f, 1.59530550e-01f, -2.72832159e-02f, -1.33517787e-01f, 5.33063337e-02f, 1.30697101e-01f, -5.04267365e-02f, 1.28857821e-01f, 4.11285535e-02f,
  -4.56700213e-02f, -1.61836818e-01f, 3.84806246e-02f, 7.38465711e-02f, -8.80274028e-02f, -2.69495901e-02f, 9.42579806e-02f, -3.88843659e-03f, 7.25132599e-02f, 7.78571069e-02f,
  -1.41900048e-01f, 1.94187220e-02f, -5.14802076e-02f, 1.19913161e-01f, 4.90904748e-02f, 4.88494337e-02f, 7.88594633e-02f, 2.37815678e-02f, 1.18532978e-01f, 5.52110635e-02f,
  -1.01491928e-01f, -6.53928220e-02f, 3.18968967e-02f, 8.62357859e-03f, -3.85523550e-02f, -1.10077355e-02f, -6.52730986e-02f, -9.51351076e-02f, 9.06161964e-02f, -1.05006501e-01f,
  1.22619197e-01f, -5.02940528e-02f, 3.78115010e-03f, 6.75965548e-02f, -1.02371700e-01f, 1.20931923e-01f, 3.55025977e-02f, 1.02654047e-01f, 5.29270880e-02f, 7.07824230e-02f,
  -9.69989318e-03f, -8.60799775e-02f, 8.63247886e-02f, 1.30446360e-01f, -9.48548615e-02f, 1.48285002e-01f, -5.53731397e-02f, -4.06922810e-02f, 8.62665996e-02f, -2.90973261e-02f,
  6.32782951e-02f, 5.36322296e-02f, -4.06014808e-02f, 1.40696421e-01f, -2.47443486e-02f, 1.36843592e-01f, -2.66711437e-03f, 1.02595434e-01f, 1.08012520e-01f, -1.99460424e-02f,
  1.45685319e-02f, -1.13992114e-03f, -1.59318686e-01f, 7.08313733e-02f, -1.76577151e-01f, 4.50270735e-02f, -6.51851520e-02f, -2.45839339e-02f, -3.05597261e-02f, -1.83004178e-02f,
  -7.30635151e-02f, 3.96102928e-02f, 4.97963950e-02f, -9.15740058e-03f, 1.12934873e-01f, -8.91167372e-02f, -9.40914080e-02f, 1.35593951e-01f, -1.06844874e-02f, 4.67451960e-02f,
  6.18863367e-02f, 4.53240797e-03f, 3.82384770e-02f, -1.12110794e-01f, -2.11951956e-02f, -2.16233563e-02f, -1.11468986e-01f, -4.48689759e-02f, 1.28104221e-02f, 1.42458186e-01f,
  7.32091740e-02f, 7.26722106e-02f, 1.21619003e-02f, -3.26105356e-02f, -3.93818505e-03f, -1.57056004e-02f, -2.27028485e-02f, -5.67606278e-02f, 4.93966304e-02f, -7.40835592e-02f,
  8.29225853e-02f, 1.31550357e-01f, -8.46078843e-02f, 4.67914678e-02f, -1.87044162e-02f, 1.15548119e-01f, 1.55249506e-01f, 2.28420764e-01f, 3.28996956e-01f, 2.38968566e-01f,
  2.10154042e-01f, 1.59275889e-01f, 1.79106280e-01f, 4.05031256e-02f, 7.61122350e-03f, 7.28688166e-02f, 8.20265040e-02f, 1.77312016e-01f, 2.06237614e-01f, -2.57764816e-01f,
  4.97099832e-02f, -1.91072434e-01f, -1.23001792e-01f, 1.26156464e-01f, -2.38440320e-01f, -2.95773208e-01f, 1.30172893e-01f, -1.80919990e-02f, 1.40304476e-01f, 1.09849893e-01f,
  -3.69585888e-03f, -7.30876476e-02f, 2.51546472e-01f, -5.69812357e-02f, -1.03153018e-02f, 4.53506373e-02f, 2.17619743e-02f, -1.52473703e-01f, 6.56244457e-02f, -4.20069620e-02f,
  2.52853423e-01f, -1.84255734e-01f, -6.67408407e-02f, 7.55922347e-02f, -1.53059497e-01f, -9.49892625e-02f, 9.89566557e-03f, -6.19879663e-02f, 1.22724921e-01f, -3.83412428e-02f,
  1.01920471e-01f, 1.45566061e-01f, 1.14766262e-01f, 5.92818670e-02f, 3.96989211e-02f, -1.25818327e-01f, 2.22122014e-01f, -8.50748196e-02f, 1.57392904e-01f, 2.20380560e-01f,
  -9.59514156e-02f, -1.21432573e-01f, 1.21471100e-01f, -6.18164726e-02f, -1.44033954e-01f, -1.16232811e-02f, -2.72664484e-02f, -1.16570152e-01f, -9.95782539e-02f, 1.83320139e-02f,
  -4.56632562e-02f, -5.63458912e-02f, -7.98712745e-02f, -5.14664911e-02f, 1.06150053e-01f, 9.21972170e-02f, 1.15860701e-01f, 1.86203539e-01f, 6.73592687e-02f, -1.57344237e-01f,
  7.29107559e-02f, -3.19783911e-02f, 1.07512079e-01f, -1.91171840e-01f, -1.11951910e-01f, -3.94935906e-02f, -1.39928432e-02f, -2.27675997e-02f, -1.38999492e-01f, 1.07139170e-01f,
  -1.28546879e-01f, -9.55707058e-02f, 1.02802381e-01f, 1.04272574e-01f, 1.19455298e-02f, 1.40582278e-01f, 2.99455430e-02f, 2.47676708e-02f, 1.09385997e-02f, 8.65142569e-02f,
  2.16716193e-02f, 1.31946811e-02f, 5.08482940e-02f, 1.65567726e-01f, 2.83645652e-02f, -8.88702348e-02f, 2.02609487e-02f, -5.92419580e-02f, 1.55717760e-01f, -9.82570113e-04f,
  -9.94533226e-02f, 1.70624569e-01f, 1.18340001e-01f, 8.45577046e-02f, 8.68762285e-02f, 1.28104612e-01f, 1.02405302e-01f, 1.01018660e-01f, -9.30879265e-02f, 1.75161242e-01f,
  -2.28263978e-02f, 3.35288458e-02f, -7.80845731e-02f, 1.08049735e-01f, 1.40760569e-02f, 1.08762458e-01f, 1.00435898e-01f, 2.51269657e-02f, -1.00777913e-02f, -3.45705152e-02f,
  -3.58614661e-02f, -4.86143194e-02f, 2.63326876e-02f, -3.35433148e-02f, 1.37975784e-02f, 1.32504165e-01f, 5.76433316e-02f, 2.78912969e-02f, 6.53621182e-02f, 1.54344067e-01f,
  -3.58696431e-02f, 5.37287556e-02f, 1.29517049e-01f, 1.94290355e-01f, -4.09767814e-02f, -1.98669937e-02f, -7.59029612e-02f, -2.05831572e-01f, -1.71946008e-02f, -1.95766147e-02f,
  -1.19339958e-01f, -5.15709119e-03f, 4.91203682e-04f, 1.06425628e-01f, 1.55619189e-01f, -1.29263818e-01f, -2.48397216e-02f, -1.81117490e-01f, -1.08414933e-01f, -1.02880195e-01f,
  3.86916474e-02f, -1.27887219e-01f, 2.42653936e-01f, -1.01916462e-01f, -3.61589744e-04f, -1.92877706e-02f, 3.78446653e-02f, 1.50247544e-01f, 1.63497813e-02f, -2.26493808e-03f,
  -9.62498784e-02f, -1.12518184e-01f, 1.28402084e-03f, -7.17885792e-02f, 1.78506896e-02f, -9.59105790e-02f, -9.91919786e-02f, 8.99227485e-02f, -1.47842523e-02f, 3.15116607e-02f,
  3.65103744e-02f, -6.46829903e-02f, 7.58235976e-02f, -3.51612382e-02f, 4.07518931e-02f, 1.03570111e-02f, -5.51463552e-02f, 1.26431555e-01f, 4.59502265e-03f, 3.22815962e-02f,
  -3.45595106e-02f, -7.11946785e-02f, 1.29934266e-01f, -1.21546984e-01f, 1.49323912e-02f, -8.97209272e-02f, -1.12953916e-01f, 9.79161635e-02f, -3.28558907e-02f, -2.05569472e-02f,
  -2.04419456e-02f, -1.04378924e-01f, -8.50175023e-02f, 1.27801612e-01f, 5.95191866e-02f, -7.03005353e-03f, 1.28813133e-01f, -6.19726442e-02f, -2.71664001e-03f, 1.43380567e-01f,
  -1.55621454e-01f, 8.87886882e-02f, 1.73006300e-02f, 8.84448737e-02f, -5.40754609e-02f, 8.82221162e-02f, -3.05117741e-02f, 1.67280003e-01f, 1.49593828e-02f, -4.96922135e-02f,
  3.14084329e-02f, -1.44180238e-01f, 1.11679584e-01f, -4.48177196e-02f, 1.78984702e-02f, 4.98682335e-02f, 1.16725132e-01f, 8.61277729e-02f, -1.28391325e-01f, 3.42450961e-02f,
  -1.03970952e-01f, 9.16352943e-02f, -5.68558499e-02f, 5.54125682e-02f, -1.31141663e-01f, -6.69736341e-02f, -3.98017652e-02f, 3.42948325e-02f, -1.25678834e-02f, -2.99132485e-02f,
  -2.57291570e-02f, 5.96155934e-02f, 1.10384017e-01f, -6.91413283e-02f, 6.58470616e-02f, 4.42441516e-02f, -8.70574787e-02f, 1.70091335e-02f, -1.50300646e-02f, 1.25165984e-01f,
  -1.09507805e-02f, 6.59634098e-02f, 3.92114148e-02f, 1.25149742e-01f, -6.28704056e-02f, 4.71328162e-02f, 4.32015508e-02f, 6.21178970e-02f, -1.43836588e-01f, 8.18485618e-02f,
  3.67524922e-02f, 5.39484881e-02f, 2.25417335e-02f, 9.39530954e-02f, 1.38200730e-01f, 1.41978800e-01f, 1.16056681e-01f, 1.78151589e-03f, 1.44049644e-01f, 1.45512328e-01f,
  1.66789129e-01f, 1.40013143e-01f, 1.23908944e-01f, 1.80362567e-01f, -1.85602114e-01f, -1.56657189e-01f, -9.59487855e-02f, -4.25679684e-02f, 9.18422863e-02f, -1.80245787e-02f,
  -1.10917047e-01f, -2.52524652e-02f, -4.20601107e-02f, -5.37352562e-02f, 4.36827950e-02f, -8.53899121e-03f, 3.25110182e-03f, -6.06177710e-02f, 1.34866774e-01f, -3.82893346e-02f,
  -2.45516989e-02f, 1.13905910e-02f, -1.36930272e-01f, -1.23243585e-01f, -1.37601374e-02f, 9.18642059e-02f, -6.97001517e-02f, 8.86630118e-02f, 1.81635395e-02f, 1.15588769e-01f,
  -6.25859350e-02f, 1.05169751e-01f, -7.01188482e-03f, -5.38538210e-02f, -7.65010118e-02f, 6.16966449e-02f, -1.16032459e-01f, 1.87794808e-02f, 2.00254321e-02f, -4.40206863e-02f,
  -5.72110303e-02f, 1.21692896e-01f, 1.44740269e-01f, 7.91029632e-02f, 1.37393907e-01f, 1.16119497e-01f, -1.66836176e-02f, -1.45666348e-02f, 3.26204747e-02f, -1.31501108e-01f,
  -5.72971031e-02f, -3.02078370e-02f, -8.97751004e-02f, -6.06816784e-02f, -9.76350158e-02f, 1.34038687e-01f, 2.05338717e-01f, 1.27639249e-01f, 1.15077823e-01f, 3.21440883e-02f,
  3.41344252e-02f, 2.76594013e-02f, 9.28578824e-02f, 3.41583304e-02f, 1.34947672e-01f, 3.24700266e-01f, 1.66128248e-01f, 2.33360693e-01f, -1.96235135e-01f, 1.37177692e-03f,
  2.16987208e-01f, -1.87612534e-01f, -9.51116905e-02f, 2.66290898e-03f, 2.34063491e-01f, 1.62507534e-01f, -5.88059425e-02f, 8.18365589e-02f, 9.64161083e-02f, -2.27955684e-01f,
  -7.45824203e-02f, -1.99973676e-02f, -1.16553627e-01f, -1.29263461e-01f, 1.09356634e-01f, -1.42605780e-02f, -7.70767033e-02f, 1.01735247e-02f, -6.52375892e-02f, 2.94079911e-02f,
  -2.21445542e-02f, 3.08802605e-01f, 8.08657184e-02f, 8.46724212e-02f, 1.06182016e-01f, 4.22075996e-03f, 2.62614012e-01f, 7.24248588e-02f, 3.75943258e-02f, -1.11038037e-01f,
  -1.79777741e-01f, 1.25315040e-01f, -1.81287434e-02f, 7.54910409e-02f, -2.01557856e-02f, 2.39585657e-02f, 9.55831259e-02f, -2.98076663e-02f, -2.46246047e-02f, -1.31514063e-02f,
  7.30955824e-02f, 1.58516735e-01f, 1.04363881e-01f, -7.37215132e-02f, 1.04795098e-02f, -5.55732921e-02f, 7.56013319e-02f, 1.68914750e-01f, -5.85273467e-02f, 6.50619566e-02f,
  9.46863890e-02f, 1.71361770e-02f, -1.85571332e-02f, 1.18781835e-01f, 6.13098182e-02f, 1.07519016e-01f, 2.76249088e-02f, 1.06162064e-01f, 5.81545755e-02f, 3.45532782e-02f,
  6.51652962e-02f, 3.96387242e-02f, -3.64298970e-02f, 1.17991544e-01f, 3.71729843e-02f, 5.34880580e-03f, 1.47091612e-01f, 9.38286185e-02f, 4.10951190e-02f, 2.46450473e-02f,
  -1.05653659e-01f, 6.61326051e-02f, 9.25278366e-02f, 2.03810148e-02f, -4.23155986e-02f, -3.57831866e-02f, -2.38208566e-02f, 2.88299378e-02f, 2.26304263e-01f, -1.05495401e-01f,
  -1.20523021e-01f, 1.83910325e-01f, 9.13128909e-03f, 1.39360572e-03f, -5.51409274e-02f, 8.42881501e-02f, -4.59279828e-02f, -7.09154159e-02f, 1.08216017e-01f, -3.98797020e-02f,
  -1.54171452e-01f, -7.30204955e-03f, 1.16180114e-01f, -1.02652676e-01f, -3.93257849e-02f, -1.27228871e-01f, -1.25472620e-01f, 2.51647141e-02f, -3.28421779e-02f, 3.95648042e-03f,
  -7.12775812e-02f, 1.53667843e-02f, -1.04893833e-01f, -9.51170921e-02f, 8.96468759e-02f, -9.35961157e-02f, 5.60137220e-02f, -1.14115160e-02f, -5.64227477e-02f, 2.29503457e-02f,
  4.18480765e-03f, -5.39552160e-02f, -6.46656007e-02f, -6.80336282e-02f, 3.78522053e-02f, -4.10217233e-02f, 3.10165472e-02f, 6.67251125e-02f, 9.01861563e-02f, 5.89474440e-02f,
  1.02619454e-01f, 2.00839229e-02f, -9.05777887e-02f, -3.45206521e-02f, 3.66081037e-02f, 1.10239491e-01f, -3.13801342e-03f, 6.73837438e-02f, 3.31958868e-02f, 8.07121173e-02f,
  9.78644490e-02f, 1.02101967e-01f, -3.41013931e-02f, 4.03542779e-02f, -6.38990924e-02f, -1.18085384e-01f, -1.59423530e-01f, -2.28068270e-02f, -6.54989779e-02f, -8.82584155e-02f,
  -1.26552373e-01f, 2.40857378e-02f, -6.95799012e-03f, 5.57691380e-02f, -5.44875022e-03f, 1.65775884e-02f, 4.11438663e-03f, -4.47743647e-02f, -2.49070628e-03f, -8.88681710e-02f,
  8.07086155e-02f, -8.90797004e-03f, 6.79357424e-02f, 3.35569307e-02f, -2.24570092e-02f, -1.76884308e-02f, -9.04220864e-02f, 1.67419191e-03f, 8.87283757e-02f, 5.94858415e-02f,
  -5.44195175e-02f, -8.82028118e-02f, 9.68188792e-02f, -8.26725550e-03f, 1.10006794e-01f, -1.30260557e-01f, 9.63087603e-02f, 1.60128102e-02f, -8.66145641e-03f, 7.25144520e-02f,
  1.92714557e-02f, 1.08007222e-01f, 7.58960694e-02f, 3.70227695e-02f, -7.55404821e-03f, -3.04951761e-02f, -4.01391014e-02f, 1.75704230e-02f, 4.25495021e-02f, 6.26150072e-02f,
  -7.86462426e-02f, 9.42217857e-02f, 1.09691039e-01f, 1.52866364e-01f, 2.39288211e-01f, 1.77100018e-01f, 1.44832700e-01f, 3.00205290e-01f, 2.89054900e-01f, 2.20211580e-01f,
  -4.75266501e-02f, 2.15028644e-01f, 3.55112702e-02f, 2.23378152e-01f, 3.08695704e-01f, -7.28475451e-02f, -1.57645717e-01f, 1.59548726e-02f, -2.33750239e-01f, 1.26698196e-01f,
  -1.60070173e-02f, 2.26889059e-01f, 4.35970612e-02f, 8.11050534e-02f, -9.92406085e-02f, 9.50585380e-02f, 6.74997084e-03f, -1.78382218e-01f, -5.67424148e-02f, 1.17722265e-01f,
  -3.72668244e-02f, 1.14276432e-01f, 9.76020172e-02f, 1.44315977e-02f, -1.36331335e-01f, -1.32139355e-01f, -1.74648210e-03f, 1.91646099e-01f, -4.56449054e-02f, 1.06395176e-02f,
  1.07899904e-01f, 9.40929912e-03f, -1.04808748e-01f, -2.68185511e-02f, 2.67606527e-02f, 9.93094370e-02f, -3.77530456e-02f, 1.63606796e-02f, -2.50994489e-02f, -4.58085872e-02f,
  1.60538778e-01f, -1.73688810e-02f, 1.62677333e-01f, 1.18560068e-01f, -1.51338488e-01f, 2.05607146e-01f, 1.17374696e-01f, 1.92704737e-01f, 4.90944870e-02f, -1.26734942e-01f,
  -7.49979541e-02f, -1.65802881e-01f, -2.23178621e-02f, 1.42856091e-02f, -9.27644521e-02f, -1.14647716e-01f, -2.60023680e-02f, 6.29818439e-02f, 1.15765721e-01f, 6.24799840e-02f,
  6.41157245e-03f, -8.33988264e-02f, 1.40008461e-02f, 2.77433135e-02f, -4.57037799e-02f, -4.76415716e-02f, 7.91758597e-02f, -2.56394930e-02f, -3.58220115e-02f, 8.00105035e-02f,
  8.52968469e-02f, -4.40691411e-02f, 1.54700712e-03f, -1.07036635e-01f, -1.16147183e-01f, 8.55327100e-02f, -1.43508632e-02f, 6.56566443e-03f, 8.90200362e-02f, 1.10317923e-01f,
  -3.53437699e-02f, -9.82486978e-02f, 1.01617813e-01f, -4.83784564e-02f, -5.71672134e-02f, -2.35767756e-02f, -7.35363811e-02f, -1.08152948e-01f, -1.35415435e-01f, 1.01590008e-01f,
  2.86888611e-02f, -6.18518405e-02f, -2.84435153e-02f, 4.51299958e-02f, 9.18998569e-02f, -2.66242139e-02f, -1.13943564e-02f, -1.21962339e-01f, 1.09575592e-01f, -1.19686805e-01f,
  -9.75480527e-02f, -5.69218583e-02f, -8.58550891e-02f, 7.95157850e-02f, 4.82470877e-02f, 2.09533796e-02f, -6.67195469e-02f, 8.67560804e-02f, 5.13144769e-02f, 3.62197571e-02f,
  -7.53999799e-02f, 7.82813579e-02f, 1.10706128e-01f, -4.50800397e-02f, 1.35405913e-01f, -6.92246705e-02f, 1.46315321e-01f, 2.94960551e-02f, -9.33887735e-02f, 1.36020720e-01f,
  8.51123780e-02f, -9.78295431e-02f, 1.24716878e-01f, 2.20927402e-01f, 1.82762384e-01f, -1.93815157e-01f, -9.47352499e-02f, 1.53974757e-01f, -2.65859440e-02f, 1.29851505e-01f,
  -3.44623141e-02f, 6.57113865e-02f, 2.12091599e-02f, 3.96983251e-02f, -1.08369924e-01f, 1.06783636e-01f, -2.13077158e-01f, -1.50657594e-01f, -2.37754583e-01f, 2.12020967e-02f,
  -4.26343754e-02f, -7.34922010e-03f, -1.03164621e-01f, 2.04901546e-01f, -1.16233259e-01f, 6.97930604e-02f, 2.64385045e-01f, 2.32354123e-02f, 5.45276748e-03f, 7.98116475e-02f,
  -3.58501114e-02f, -8.41078237e-02f, 6.96127128e-04f, 2.08909754e-02f, 2.33450875e-01f, 5.64807989e-02f, -7.22961780e-03f, 1.12522423e-01f, -4.88183722e-02f, 4.85588275e-02f,
  1.04130737e-01f, -8.66018757e-02f, -1.76638979e-02f, 1.53530333e-02f, 5.21378741e-02f, 3.19165498e-01f, -1.70658126e-01f, -1.04543261e-01f, 3.29098701e-02f, -3.47747356e-02f,
  1.15950316e-01f, 6.40527904e-02f, 1.57473654e-01f, -2.62278807e-03f, 1.75348043e-01f, 1.24694332e-01f, 1.08939774e-01f, -5.21621741e-02f, -2.39439569e-02f, 2.71885656e-02f,
  1.18600756e-01f, -7.50305131e-02f, -7.21146017e-02f, 1.46285892e-02f, 7.14031756e-02f, 3.51250693e-02f, -8.93571153e-02f, 1.33225173e-01f, 1.23662084e-01f, 1.00002609e-01f,
  -7.06579164e-02f, 1.50236428e-01f, 7.92334750e-02f, 1.02425024e-01f, 1.30651176e-01f, -1.94600046e-01f, -1.61558837e-01f, -2.00549066e-01f, 2.03573048e-01f, 9.48052201e-03f,
  1.09125011e-01f, 5.60509823e-02f, -7.99840838e-02f, 4.22851034e-02f, 1.06350495e-03f, -1.16960227e-01f, -6.63159490e-02f, 7.26269037e-02f, -1.29669100e-01f, -1.12587281e-01f,
  -1.14597589e-01f, -9.57459137e-02f, -5.40748388e-02f, 5.67674823e-03f, 7.84246773e-02f, 2.18875036e-01f, -5.20650037e-02f, -1.87973529e-02f, -3.88927534e-02f, 2.29210854e-02f,
  1.47108436e-01f, -4.56432905e-03f, 1.19147390e-01f, -1.46728545e-01f, -3.25942449e-02f, 1.43336535e-01f, -2.25583762e-02f, -5.08352481e-02f, -1.12560205e-02f, 7.84961060e-02f,
  1.00700501e-02f, -6.97353706e-02f, 6.53583929e-02f, 9.03098360e-02f, -4.47542593e-02f, 6.44527450e-02f, -8.92983899e-02f, -1.51054308e-01f, -8.26507360e-02f, -8.77899900e-02f,
  1.04123004e-01f, -4.46435772e-02f, 1.00102998e-01f, 5.39743342e-02f, 5.30367903e-02f, 1.07483998e-01f, -4.17707488e-03f, 5.41520165e-03f, 9.89324450e-02f, 4.46181446e-02f,
  1.43005401e-01f, 1.57229140e-01f, 1.97070003e-01f, 6.14184029e-02f, -7.68579468e-02f, -4.76050340e-02f, -1.76183298e-01f, -1.08982407e-01f, -1.44949660e-01f, -1.49429590e-02f,
  1.47777228e-02f, -1.21479169e-01f, 1.72396213e-01f, 6.40274137e-02f, 7.33077750e-02f, -1.11925744e-01f, 3.90191115e-02f, -7.37345442e-02f, 5.79806976e-02f, -1.26480043e-01f,
  6.29149899e-02f, 9.96110588e-02f, 1.58009738e-01f, -2.58911420e-02f, -1.00078527e-02f, -8.79681334e-02f, -7.63287172e-02f, 1.16364904e-01f, -5.30274846e-02f, 9.24803317e-02f,
  9.05663334e-03f, 1.15243681e-01f, 2.52358355e-02f, 3.75377685e-02f, 1.03765605e-02f, 6.72753602e-02f, -2.91892756e-02f, 7.54969120e-02f, 3.71061675e-02f, 1.50047347e-01f,
  8.07547644e-02f, -2.64304969e-02f, -6.58934489e-02f, -1.03483358e-02f, 7.74055868e-02f, 2.73534097e-02f, -7.84765556e-02f, 5.31302243e-02f, -1.15412265e-01f, 2.24665459e-02f,
  9.08045843e-02f, -2.95661651e-02f, -1.97142772e-02f, -1.36712551e-01f, -6.13327185e-03f, 9.86396521e-02f, -9.43472832e-02f, 1.48947388e-01f, 1.40614167e-01f, -3.01863775e-02f,
  3.67801599e-02f, -8.42457488e-02f, 5.75177483e-02f, 2.39671357e-02f, -3.52413058e-02f, 1.21733971e-01f, 7.86848962e-02f, 1.06254697e-01f, 1.18624650e-01f, 1.74489945e-01f,
  -3.02934516e-02f, -2.97734258e-03f, 1.56240761e-01f, -1.02051599e-02f, -1.24832459e-01f, -4.18613292e-02f, 1.31263047e-01f, 2.18380950e-02f, -3.78265008e-02f, 9.65796858e-02f,
  -2.48481520e-03f, -4.11811471e-02f, -5.00998460e-02f, -1.44234737e-02f, -3.60578820e-02f, -1.20147847e-01f, 8.44744444e-02f, -4.04163525e-02f, 7.11867660e-02f, -1.16326720e-01f,
  -1.33101091e-01f, 7.50400648e-02f, -2.80610044e-02f, 2.01095060e-01f, 1.30183443e-01f, -7.88388103e-02f, 1.08155027e-01f, -3.24959904e-02f, 1.51216388e-01f, -1.25848502e-01f,
  1.10816643e-01f, -1.10293761e-01f, -4.88352999e-02f, -7.20380899e-03f, 1.59349069e-02f, 1.36687577e-01f, 3.63955670e-03f, -5.18259481e-02f, 1.02327384e-01f, -4.04720008e-02f,
  1.44633427e-01f, -9.24487188e-02f, 2.75734644e-02f, -5.04760491e-03f, -6.50627986e-02f, -1.20437546e-02f, -9.41083133e-02f, 5.04694097e-02f, -8.96987692e-02f, 1.68376863e-01f,
  -7.33633935e-02f, -2.62273718e-02f, 7.97507763e-02f, 1.29562855e-01f, -1.68087613e-02f, 6.84243515e-02f, -3.28710377e-02f, 3.87164615e-02f, 1.59878820e-01f, 7.61340410e-02f,
  -8.83781463e-02f, 1.85928702e-01f, 1.36850089e-01f, -7.80015485e-03f, 1.10711433e-01f, 2.43580952e-01f, 1.38087496e-01f, 1.24038197e-01f, 1.88362136e-01f, 2.17715763e-02f,
  7.84821138e-02f, 1.28999442e-01f, -1.74872890e-01f, -8.33925381e-02f, -3.25846449e-02f, 9.01055709e-02f, -1.14034079e-01f, 1.05462223e-01f, -4.98099104e-02f, 1.55736163e-01f,
  -8.14357996e-02f, 3.37170735e-02f, -7.84167275e-02f, 3.85830589e-02f, -2.30846703e-02f, 1.56881794e-01f, 1.15838155e-01f, 1.93103537e-01f, 6.14462309e-02f, 3.29814688e-03f,
  1.54187262e-01f, 2.01353803e-01f, -4.14017262e-03f, 3.62266339e-02f, -1.18220188e-01f, -1.15512587e-01f, -9.21856463e-02f, 7.66908899e-02f, 8.83442014e-02f, 8.75922665e-02f,
  1.84865315e-02f, -4.85387072e-02f, -2.87717879e-02f, 1.11077400e-02f, 5.88973984e-02f, -1.59716532e-01f, 4.40289034e-03f, 9.34611354e-03f, -4.76946086e-02f, -3.83065455e-03f,
  2.37816777e-02f, 1.13416351e-01f, 4.77163680e-02f, -4.03883010e-02f, 4.42047603e-02f, -1.19404294e-01f, 1.50803640e-01f, -1.37626797e-01f, -2.97976881e-02f, 4.74413820e-02f,
  5.97366840e-02f, -9.50598940e-02f, 1.50279850e-01f, 1.76584795e-01f, 1.84542418e-01f, -8.06579068e-02f, -1.45671442e-01f, 7.67399520e-02f, -8.98858756e-02f, -2.23185241e-01f,
  -2.20816121e-01f, -1.79118216e-01f, -1.82248026e-01f, 1.47080030e-02f, 1.67062972e-02f, 1.37240842e-01f, -5.65895922e-02f, -1.33277208e-05f, 1.14345744e-01f, -1.72071591e-01f,
  1.15564719e-01f, -7.98877403e-02f, -9.23868176e-03f, 1.41695395e-01f, -2.02631932e-02f, 1.28402621e-01f, 1.27747387e-01f, -5.57667241e-02f, 1.43667147e-01f, 2.67267972e-02f,
  -5.80859296e-02f, -1.07130460e-01f, 4.14025895e-02f, -4.34799604e-02f, 1.16849959e-01f, -1.18859798e-01f, 2.74964869e-02f, -1.53766247e-03f, -2.79495772e-02f, 6.46322872e-03f,
  1.13606609e-01f, 1.36842906e-01f, 3.52764651e-02f, -1.12852000e-01f, 4.32384945e-02f, 1.48906454e-01f, -2.37735696e-02f, 1.09858662e-01f, 4.30201814e-02f, 2.90183388e-02f,
  1.20271966e-01f, -6.00155629e-02f, 5.77601418e-02f, -7.96875805e-02f, 4.55958024e-02f, -1.42929107e-01f, -4.05645408e-02f, -3.57480235e-02f, 7.33386204e-02f, 1.29385859e-01f,
  3.06037012e-02f, 4.09710370e-02f, 3.04724481e-02f, -6.65047839e-02f, -9.44172144e-02f, 8.94877464e-02f, -1.05601996e-02f, 6.22375645e-02f, -6.60313666e-02f, 5.84165612e-03f,
  -8.43045339e-02f, 3.73181212e-03f, -1.08296536e-01f, -1.60990451e-02f, 1.82754453e-02f, 4.67872946e-03f, 8.99630785e-02f, -1.03614330e-01f, 1.05625942e-01f, 1.33313164e-01f,
  1.36466384e-01f, -1.25872374e-01f, 1.31246015e-01f, -1.51655629e-01f, 9.74473581e-02f, 1.28582036e-02f, -8.44626203e-02f, 1.05916560e-01f, -5.34993969e-02f, -1.02449425e-01f,
  8.34731832e-02f, 7.56583363e-02f, 7.87875429e-02f, -2.16997340e-02f, -7.69974142e-02f, 7.13856891e-02f, -1.12614714e-01f, -5.36868442e-03f, 3.13310102e-02f, -1.31121635e-01f,
  -1.43978484e-02f, 1.33386046e-01f, -1.20107420e-01f, 9.09501985e-02f, 5.48172072e-02f, 3.95319276e-02f, 9.83372852e-02f, -3.66303474e-02f, -1.02979869e-01f, 8.57403781e-03f,
  1.27247814e-02f, -9.62421000e-02f, -4.96443994e-02f, 5.34952842e-02f, -5.65551855e-02f, 8.48857313e-02f, -5.84978387e-02f, 9.89847854e-02f, -8.20291787e-02f, 1.27164707e-01f,
  -1.12850435e-01f, -7.92310908e-02f, 4.53267321e-02f, -1.24470927e-01f, 1.70526177e-01f, -6.86305985e-02f, 3.55068557e-02f, 1.30899191e-01f, -3.72215696e-02f, -1.18103502e-02f,
  3.35949399e-02f, -6.61832094e-02f, -2.37569511e-02f, -2.03659311e-02f, 1.31821334e-01f, -3.50378938e-02f, -1.14276342e-01f, -1.62233174e-01f, -1.33614466e-01f, -9.27396342e-02f,
  -4.33463603e-02f, -3.27695459e-02f, -1.97299831e-02f, 1.19254291e-01f, 1.40197426e-01f, -6.31863847e-02f, -4.42277603e-02f, -9.10422206e-02f, 4.27316241e-02f, 1.14272252e-01f,
  3.64335105e-02f, -6.67546988e-02f, 1.23619484e-02f, 1.07890151e-01f, -1.06285457e-02f, 6.01471402e-02f, -1.72805153e-02f, 1.43217370e-01f, -7.81215578e-02f, -2.95317788e-02f,
  7.41996914e-02f, 9.90906730e-04f, 5.01182266e-02f, -1.13915123e-01f, -4.81882170e-02f, -4.50633280e-03f, 1.05583772e-01f, 8.30693170e-02f, -2.51966659e-02f, -1.25607233e-02f,
  -5.35890348e-02f, 1.18641175e-01f, -1.19585998e-01f, -6.33013472e-02f, 9.77529362e-02f, 6.35254383e-02f, -1.10385083e-01f, 7.96984434e-02f, -1.09184161e-01f, 2.44251024e-02f,
  -9.72711742e-02f, -4.23199385e-02f, 7.73011968e-02f, -1.20475821e-01f, -2.68154703e-02f, -8.19750726e-02f, 5.20116575e-02f, 8.19121823e-02f, 3.71729881e-02f, 1.40840456e-01f,
  -6.26527667e-02f, 2.83170287e-02f, 1.28349900e-01f, -7.76704475e-02f, 1.08732097e-01f, 1.53273836e-01f, 1.63529485e-01f, -2.05755204e-01f, 3.85682248e-02f, 2.53841840e-02f,
  4.16268781e-02f, -4.80768308e-02f, -1.49488002e-01f, 4.04384993e-02f, -4.79591191e-02f, 1.02029637e-01f, -3.17163244e-02f, -1.61073774e-01f, 2.36162711e-02f, 3.54312249e-02f,
  9.86527950e-02f, 1.32381152e-02f, -7.01809749e-02f, 7.76801556e-02f, 8.20258409e-02f, 6.01506792e-02f, -2.06274483e-02f, 1.11515094e-02f, 2.44507536e-01f, -1.13716424e-01f,
  -7.71948621e-02f, 9.86693278e-02f, -4.75242315e-03f, -1.93515308e-02f, 6.61701038e-02f, -1.23589039e-01f, 1.50693014e-01f, 8.13008025e-02f, -8.98282882e-03f, 3.32124047e-02f,
  -9.12937671e-02f, -3.27891707e-02f, 1.54728085e-01f, -5.75509667e-02f, 1.00373901e-01f, 7.07767978e-02f, -6.32060915e-02f, 8.06769729e-02f, -3.83422226e-02f, -4.86862436e-02f,
  -4.06898446e-02f, 1.69348508e-01f, -1.60848517e-02f, 4.94266339e-02f, 1.09120883e-01f, -6.79990500e-02f, -6.88067973e-02f, -1.24362603e-01f, -7.78356865e-02f, -2.34471038e-02f,
  9.42481458e-02f, 9.64911748e-03f, -2.30941400e-02f, 1.43183559e-01f, -5.88907721e-03f, -8.59203786e-02f, 1.00073040e-01f, -7.37853125e-02f, 4.11019176e-02f, 2.53627785e-02f,
  -5.64859249e-02f, 1.48976818e-01f, 1.35983735e-01f, 3.61423381e-02f, 1.45321757e-01f, 3.83106470e-02f, 1.05976285e-02f, -2.27630809e-01f, -9.18656439e-02f, -1.57245979e-01f,
  -4.70391773e-02f, -3.91462967e-02f, 1.60293385e-01f, 1.33931890e-01f, -4.56288084e-02f, -8.76134112e-02f, -1.11738250e-01f, -8.38297233e-02f, 1.70552805e-02f, -2.66548730e-02f,
  3.40360999e-02f, 5.50839230e-02f, 1.04147829e-01f, 4.49864268e-02f, -6.00013286e-02f, -1.41762778e-01f, 1.77626252e-01f, 2.01307952e-01f, -2.72236019e-02f, 1.59438979e-02f,
  1.04615632e-02f, 4.54563461e-02f, 1.63257509e-01f, 2.48922780e-02f, 7.25261942e-02f, -1.11852035e-01f, 8.20723996e-02f, 1.94404617e-01f, 9.29735899e-02f, -1.61919855e-02f,
  -3.15009281e-02f, -1.20365009e-01f, 1.16989158e-01f, -1.19532615e-01f, -6.35033995e-02f, -7.46531188e-02f, -2.86599398e-02f, -1.00030363e-01f, 9.14927796e-02f, -1.04628175e-01f,
  3.45356800e-02f, -8.17099735e-02f, 1.14354622e-02f, 1.56761315e-02f, 4.26731482e-02f, 1.16854506e-02f, 4.18654941e-02f, 1.52564332e-01f, 5.11513166e-02f, 7.34637976e-02f,
  9.10451412e-02f, 1.62410334e-01f, 1.86319411e-01f, -2.86860615e-02f, -1.31178135e-02f, -4.71132919e-02f, 1.91283580e-02f, 1.33190425e-02f, 5.19542843e-02f, -1.65245399e-01f,
  -2.25910991e-01f, 5.27122878e-02f, -6.93468750e-02f, 1.60541430e-01f, -9.05956104e-02f, 5.17292991e-02f, -5.41809807e-03f, -3.68872359e-02f, 1.19043581e-01f, 2.15425882e-02f,
  -1.01539351e-01f, 1.39394075e-01f, 2.09106170e-02f, -8.53084251e-02f, -3.35607007e-02f, -2.03729831e-02f, 4.21534218e-02f, 6.27780184e-02f, -8.49351808e-02f, 6.91866279e-02f,
  1.29371330e-01f, -3.79773788e-02f, 5.06949238e-02f, -7.59718865e-02f, -6.32051155e-02f, -4.26590256e-02f, -1.51160091e-01f, 9.20024216e-02f, 4.88462625e-04f, -2.09268592e-02f,
  -5.80183752e-02f, 6.07017092e-02f, -3.54856290e-02f, -8.04277584e-02f, -9.79822204e-02f, 2.13289604e-01f, -6.74144831e-03f, 6.99820817e-02f, 1.54788755e-02f, 8.41932446e-02f,
  1.84221826e-02f, 1.92419309e-02f, 1.34685844e-01f, 1.14747606e-01f, 1.44033477e-01f, 5.40528335e-02f, -6.30073599e-04f, 1.09860227e-01f, 1.42331734e-01f, -2.75573451e-02f,
  -5.42239472e-02f, -1.08813114e-01f, 9.40828100e-02f, 9.26721767e-02f, -1.07270338e-01f, -6.66713491e-02f, 1.02079827e-02f, 1.09496526e-01f, 1.05412960e-01f, 1.49505474e-02f,
  2.34812479e-02f, -9.72616300e-03f, -9.28781703e-02f, -7.47199804e-02f, -1.09098703e-02f, 1.68272600e-01f, -1.02859370e-01f, 5.39147183e-02f, 1.14549443e-01f, -1.35756172e-02f,
  -3.77179720e-02f, 6.35546595e-02f, 1.64238557e-01f, -2.75637452e-02f, 7.78134167e-02f, -7.98456073e-02f, -1.56987444e-01f, -1.01427861e-01f, 1.50197610e-01f, -8.11769590e-02f,
  -1.15331061e-01f, -1.19350301e-02f, 5.24913296e-02f, 7.92661086e-02f, -1.86878461e-02f, 6.43250272e-02f, -3.21999080e-02f, -7.26085082e-02f, 1.43132452e-02f, -9.96052325e-02f,
  -3.43346074e-02f, 1.23508938e-01f, -7.78278708e-03f, 3.34269218e-02f, 1.08515255e-01f, 2.91252472e-02f, -1.33518141e-03f, -1.95606649e-02f, 2.12416630e-02f, -3.63310985e-02f,
  4.75970842e-02f, -1.00730576e-01f, -8.86532962e-02f, 1.05291702e-01f, 1.29258446e-02f, -6.15754277e-02f, 2.19609942e-02f, 1.50906697e-01f, 5.78549802e-02f, -6.50777072e-02f,
  7.61791021e-02f, -8.98596570e-02f, -1.22267209e-01f, 9.32883397e-02f, 7.62377009e-02f, -6.03385009e-02f, 6.35257587e-02f, 3.68244164e-02f, 1.79916732e-02f, 1.09775938e-01f,
  2.65763812e-02f, -1.04725182e-01f, -7.35236332e-02f, -1.87021252e-02f, -1.12611605e-02f, -3.83612923e-02f, 1.58394240e-02f, 8.56929421e-02f, 1.42326802e-01f, -3.69084068e-02f,
  2.64516915e-03f, 1.24118537e-01f, 3.83188576e-02f, 1.25947028e-01f, -3.53283435e-02f, 9.97785106e-02f, 1.18491687e-01f, -1.37493774e-01f, -2.65833139e-02f, -1.36822447e-01f,
  7.26885572e-02f, -9.16321129e-02f, 1.53512239e-01f, 1.14116538e-02f, -7.71233961e-02f, 1.49875609e-02f, -4.36254293e-02f, -6.20337650e-02f, -6.50291592e-02f, -6.61580218e-03f,
  3.53304036e-02f, 7.54653513e-02f, -1.26615996e-02f, 6.21076040e-02f, -6.55200928e-02f, 2.42300816e-02f, -7.42407795e-03f, 8.51223469e-02f, 1.06535427e-01f, -1.00276925e-01f,
  -1.23463795e-01f, -1.09849684e-01f, 6.76057935e-02f, 2.38143820e-02f, -6.17295317e-02f, 1.64999114e-03f, -5.97556420e-02f, 4.35839221e-02f, 4.84230071e-02f, 1.12925127e-01f,
  2.89037842e-02f, 1.80685837e-02f, 9.45997536e-02f, 7.08966982e-03f, 6.86035305e-02f, 1.30199967e-02f, -5.16163856e-02f, 2.50283219e-02f, 1.41950026e-01f, -2.87008248e-02f,
  3.15806046e-02f, 6.68638721e-02f, -5.02665713e-02f, -7.81216398e-02f, 4.62711714e-02f, 1.47568300e-01f, 1.23550229e-01f, -3.61953750e-02f, 1.72722340e-01f, 7.76636004e-02f,
  -5.91647997e-03f, 1.29574835e-01f, -6.56439811e-02f, -2.82018818e-02f, 7.35048205e-02f, -1.11433081e-01f, 4.40973155e-02f, 1.10116869e-01f, -5.34980446e-02f, -4.08758856e-02f,
  -1.50071308e-01f, -5.19413576e-02f, -5.14047109e-02f, -1.16257608e-01f, -9.82879922e-02f, -3.10631050e-03f, -3.87361124e-02f, -9.56077427e-02f, 3.25484611e-02f, 9.11368057e-02f,
  4.50261757e-02f, -1.11410730e-01f, 9.50861350e-02f, 9.76101458e-02f, -1.26479626e-01f, 1.23690754e-01f, -3.97076877e-03f, 5.97298183e-02f, 2.35258858e-03f, -1.15753353e-01f,
  4.13207673e-02f, 8.76702741e-02f, -8.09551701e-02f, -3.61912767e-04f, 1.24289699e-01f, 3.42682526e-02f, -9.84773561e-02f, -1.37354895e-01f, 5.17569147e-02f, 5.76828085e-02f,
  -3.05814645e-03f, -5.59534617e-02f, 7.20311031e-02f, 1.15281440e-01f, 5.07269055e-02f, 8.30569025e-03f, 1.81489401e-02f, 3.69981229e-02f, 9.86888409e-02f, 1.03225566e-01f,
  -2.71094572e-02f, -1.23229086e-01f, -7.62946904e-02f, -7.62884393e-02f, -7.28456751e-02f, -8.62286910e-02f, -1.26878142e-01f, -1.26421764e-01f, 1.20150462e-01f, 1.03550054e-01f,
  -2.28910688e-02f, -1.10406809e-01f, -4.40203473e-02f, 4.93403450e-02f, -2.73359008e-02f, -3.38320397e-02f, -1.22340396e-01f, -1.46216070e-02f, -4.85898964e-02f, 1.98391322e-02f,
  6.85310140e-02f, 1.04035102e-02f, -3.61900032e-02f, -3.37080583e-02f, 1.20757580e-01f, -2.49120127e-02f, 2.63804365e-02f, 2.20133569e-02f, -3.05385832e-02f, 5.95946051e-02f,
  2.42703687e-02f, -1.19367294e-01f, 4.97793257e-02f, -4.17640507e-02f, -9.33823064e-02f, 1.30485445e-01f, -1.64415315e-02f, -1.20391548e-01f, 7.31802136e-02f, -1.83306169e-03f,
  3.96228954e-02f, -2.97213662e-02f, 6.81657195e-02f, -1.02608852e-01f, 8.33557546e-02f, -7.36304447e-02f, -9.95460432e-03f, 2.77670249e-02f, 1.03085896e-03f, 2.47054864e-02f,
  8.68203714e-02f, 6.32001311e-02f, 1.61947726e-04f, 8.43963623e-02f, -6.49262071e-02f, -9.71881524e-02f, -7.35222399e-02f, -8.60679224e-02f, -6.33499101e-02f, 2.73425970e-02f,
  -1.04780838e-01f, -7.31221363e-02f, -6.85546175e-02f, -1.10555179e-01f, 1.13969063e-02f, 1.59576423e-02f, 1.04020789e-01f, -2.11855192e-02f, 1.91698968e-02f, -6.06820919e-02f,
  2.84690969e-02f, -9.23657939e-02f, 1.02633476e-01f, 1.17920130e-01f, -4.09483835e-02f, 1.52940303e-02f, -8.59862417e-02f, 8.05176795e-02f, 1.60821706e-01f, 4.51427996e-02f,
  8.95485431e-02f, -6.59858659e-02f, -5.31029329e-02f, -2.33448688e-02f, 3.67392786e-02f, -1.34364530e-01f, 4.98662516e-02f, 1.37328684e-01f, -7.89162070e-02f, 9.01277065e-02f,
  8.06658715e-02f, 1.23378754e-01f, 7.71712419e-03f, 2.70347856e-02f, -3.26512307e-02f, 1.14374459e-01f, -9.49098766e-02f, -8.91747512e-03f, 3.58538479e-02f, -1.41827196e-01f,
  6.21848181e-02f, 6.93746060e-02f, 2.03100243e-03f, 1.12233922e-01f, 4.75150198e-02f, -7.66140446e-02f, 1.05399549e-01f, -4.20476384e-02f, -3.85852344e-02f, 1.51455514e-02f,
  -1.59390382e-02f, -1.04031242e-01f, 1.01736613e-01f, 3.83677036e-02f, -1.01534031e-01f, -9.42645818e-02f, -9.01917890e-02f, -4.11639735e-03f, 9.00233909e-02f, -1.49194933e-02f,
  5.40311448e-02f, -6.84382915e-02f, 2.57682637e-03f, 2.10270286e-02f, -4.16450463e-02f, -1.04602817e-02f, -6.72976896e-02f, -6.35972172e-02f, -8.69199559e-02f, 7.84330070e-02f,
  2.39265576e-01f, 6.52337680e-03f, 1.57185301e-01f, 4.61239517e-02f, -3.31199914e-02f, 1.24300666e-01f, 1.44752279e-01f, 1.67460099e-01f, 4.86518405e-02f, 2.35389560e-01f,
  8.67053419e-02f, 5.69913089e-02f, -2.24878505e-01f, -2.10007936e-01f, 1.13389790e-01f, -3.68879102e-02f, 3.89996879e-02f, 7.03903660e-02f, 2.22104266e-01f, 8.40690956e-02f,
  -1.79067943e-02f, 4.40029427e-02f, 1.48961663e-01f, -1.88087583e-01f, -1.30213201e-02f, -1.27629235e-01f, 1.17936134e-01f, -1.42283127e-01f, 1.14823379e-01f, 1.57036096e-01f,
  -8.78902748e-02f, -4.71618585e-02f, -1.00689113e-01f, 9.04462039e-02f, -1.69983227e-02f, 1.60555765e-01f, -9.13869292e-02f, 9.39756930e-02f, 4.86864299e-02f, -9.20146611e-03f,
  1.49506759e-02f, 6.84325397e-02f, 1.00393996e-01f, -4.73060980e-02f, -5.63653372e-02f, 1.58162251e-01f, -1.27538294e-01f, 9.35056210e-02f, 5.98508231e-02f, -6.11764714e-02f,
  1.21801987e-01f, -3.91504820e-03f, -9.99156460e-02f, -1.03547489e-02f, -1.31700697e-04f, -4.69588712e-02f, -2.07694937e-02f, 1.26986563e-01f, 2.84425705e-03f, 4.44050953e-02f,
  -7.41647929e-02f, 6.86907247e-02f, 8.83353595e-03f, 7.95991495e-02f, -9.00285542e-02f, 4.21673320e-02f, -8.33989903e-02f, 2.40628738e-02f, -5.44206146e-03f, 1.57156497e-01f,
  -2.41801199e-02f, 6.02171272e-02f, -7.11482018e-02f, -9.94625837e-02f, 2.21995264e-02f, 1.13163792e-01f, 7.97754228e-02f, -1.11612573e-01f, -1.41465366e-01f, -8.61164089e-03f,
  3.80725414e-02f, -8.89704674e-02f, 8.70247260e-02f, -1.17657192e-01f, 1.15242653e-01f, 6.86802268e-02f, 1.41545773e-01f, 8.30846578e-02f, -5.50649241e-02f, -2.41575651e-02f,
  8.37046355e-02f, -6.60692379e-02f, 6.90659881e-02f, 1.18435659e-01f, -6.14159182e-03f, 7.84520991e-03f, -9.06435996e-02f, 1.26136318e-02f, -6.77039623e-02f, -2.94356588e-02f,
  -9.28469002e-02f, 3.56178507e-02f, 1.15389504e-01f, 9.74557176e-02f, -4.94555905e-02f, 1.11115992e-01f, -3.13944109e-02f, -7.22188726e-02f, -2.77892072e-02f, -1.27258822e-02f,
  1.13499478e-01f, -7.15903342e-02f, 9.63300616e-02f, -9.56114531e-02f, 5.32377437e-02f, 9.25858766e-02f, -1.06908888e-01f, -9.27594900e-02f, -3.97117771e-02f, 4.84821349e-02f,
  9.10052508e-02f, 5.97926714e-02f, -4.94515859e-02f, -5.14802188e-02f, 1.02411196e-01f, 3.80010232e-02f, -9.92910117e-02f, 6.78791776e-02f, -1.70475226e-02f, 1.23372925e-02f,
  1.23987291e-02f, -2.41054241e-02f, 3.88497859e-02f, 9.20101255e-02f, 1.74733077e-03f, 1.71557114e-01f, 9.90916416e-02f, 5.24980351e-02f, -5.30160069e-02f, 1.62459776e-01f,
  4.31866013e-02f, 1.00703485e-01f, -7.83556048e-03f, 1.73142433e-01f, 4.39720079e-02f, 2.57149022e-02f, 1.27082393e-01f, 2.75730565e-02f, 1.04180127e-01f, -1.37459666e-01f,
  2.16282811e-02f, 2.57495940e-02f, 1.23561144e-01f, -5.64305894e-02f, -1.53183630e-02f, -8.82290155e-02f, 1.57815859e-01f, -1.28018439e-01f, -9.20368135e-02f, 3.96358669e-02f,
  -6.31503910e-02f, 1.32844187e-02f, -9.68132913e-02f, -3.31330113e-02f, -9.26795229e-02f, -2.12103687e-03f, -1.03296719e-01f, 4.65606526e-02f, -3.27905789e-02f, 7.84261823e-02f,
  1.62578709e-02f, -2.08630487e-02f, -2.25799065e-02f, -9.10979360e-02f, 2.58417297e-02f, -3.47860046e-02f, -2.03902461e-02f, 1.02632292e-01f, -7.98371360e-02f, -8.37131143e-02f,
  4.39876951e-02f, 6.78389817e-02f, 8.68039392e-03f, -1.92720462e-02f, -1.24503464e-01f, 1.34095117e-01f, 1.99675802e-02f, 9.80018452e-02f, -6.55597895e-02f, -4.07009758e-02f,
  -4.59413901e-02f, 1.79229286e-02f, -6.62278160e-02f, -2.54846402e-02f, -9.69123617e-02f, -8.57799500e-02f, 8.47538784e-02f, -4.31664214e-02f, -7.26834610e-02f, 1.03690557e-01f,
  -9.92744416e-03f, 5.35347946e-02f, -9.49682519e-02f, -1.01439439e-01f, -5.41479625e-02f, -1.07232139e-01f, -1.54427290e-01f, -1.47596240e-01f, 6.51558638e-02f, 7.31192976e-02f,
  -2.05914024e-02f, -4.65921499e-02f, -7.28984326e-02f, 9.03104693e-02f, 1.46772012e-01f, 2.08792463e-02f, 1.25300974e-01f, -6.63968548e-02f, -2.80042868e-02f, 3.00470702e-02f,
  8.80949795e-02f, -6.90048337e-02f, 2.65762378e-02f, 1.01057142e-01f, -7.98526630e-02f, 3.54162455e-02f, -2.90490296e-02f, -1.12863526e-01f, 2.04573236e-02f, 2.76549030e-02f,
  1.10777020e-01f, -4.02370328e-03f, -6.29262254e-02f, -1.15237266e-01f, 1.03081511e-02f, 7.33491406e-02f, 6.46559075e-02f, 1.26664331e-02f, -8.20746063e-05f, 1.14866249e-01f,
  -9.08522998e-05f, 1.39623806e-01f, 1.26617700e-01f, 1.18304037e-01f, 8.88706818e-02f, 1.37442932e-01f, 6.09780438e-02f, 7.47635439e-02f, 1.56821590e-02f, 7.05180094e-02f,
  -1.36974407e-02f, -7.53203854e-02f, -7.79162273e-02f, -1.19980425e-01f, 8.79068151e-02f, 1.37278184e-01f, 1.69482633e-01f, -3.70736644e-02f, -3.24341133e-02f, 1.40991181e-01f,
  -2.75952718e-03f, 5.84458932e-02f, 8.46450329e-02f, 6.26897290e-02f, 1.59650043e-01f, -3.89047302e-02f, 9.61320698e-02f, -1.19251736e-01f, 5.26882708e-03f, -2.52196759e-01f,
  -1.63868874e-01f, -1.39618590e-01f, 6.46372288e-02f, 3.12994979e-02f, 1.07422650e-01f, -6.33703172e-02f, 8.38505998e-02f, 1.07498266e-01f, -2.25295741e-02f, 5.69070987e-02f,
  -6.67777956e-02f, 1.29599303e-01f, 3.66221480e-02f, 1.57558417e-03f, 5.95642366e-02f, 1.55547485e-01f, 1.92700215e-02f, -1.04475044e-01f, 2.67171115e-02f, 2.57140351e-03f,
  4.79972176e-02f, -1.52093053e-01f, -2.73449756e-02f, -6.22690953e-02f, 1.36293530e-01f, -1.34294197e-01f, -1.10179961e-01f, 1.36029720e-01f, 1.13146135e-03f, -3.97674926e-02f,
  3.70569676e-02f, 1.06443100e-01f, -8.06940794e-02f, -1.15063272e-01f, -9.72598419e-02f, 1.81717008e-01f, 7.72577971e-02f, 2.26828158e-02f, 1.58858523e-02f, -3.61164212e-02f,
  1.12968482e-01f, 1.15113825e-01f, 7.24980757e-02f, 8.47378001e-02f, 1.12425163e-01f, -5.03507666e-02f, 7.51261935e-02f, -4.55089025e-02f, 5.42525426e-02f, -2.94189155e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  -1.31542549e-01f, -5.07010743e-02f, 1.19791172e-01f, 7.30774477e-02f, 4.88177650e-02f, 7.45842159e-02f, -1.00488064e-03f, -8.45626555e-03f, 2.66286638e-02f, 2.14651749e-01f,
  1.48746029e-01f, -1.16468733e-02f, -1.23226931e-02f, 1.05198443e-01f, 2.38890201e-01f, 6.45211861e-02f, 9.45967734e-02f, 3.18970680e-01f, -3.16973627e-02f, 1.94653109e-01f,
  9.64417830e-02f, 1.56822726e-02f, -1.42847169e-02f, 1.52162179e-01f, -7.44667426e-02f, -9.67156813e-02f, 1.54860631e-01f, 1.82668194e-01f, -9.70696285e-02f, 9.12256166e-03f,
  8.50439519e-02f, -1.52080273e-03f, 1.42886251e-01f, -6.33567423e-02f, -1.60600932e-03f, 1.60796642e-01f, -3.53528298e-02f, -4.21460904e-02f, 2.67384015e-02f, 4.31440771e-02f
};

// L2_fan_Wp (Shape: 12 x 64)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -1.39483869e-01f, -2.07677633e-02f, -6.18499778e-02f, -5.51952980e-03f, -3.88498567e-02f, 1.17465191e-01f, -1.07665084e-01f, 1.00174166e-01f, -8.33597630e-02f, 1.41381279e-01f,
  -3.77185531e-02f, 1.27865495e-02f, -1.99566707e-02f, 6.80867210e-02f, -2.05427587e-01f, -1.58253431e-01f, -5.69049716e-02f, -2.00244993e-01f, 1.18655764e-01f, 7.69457296e-02f,
  1.92872882e-01f, 1.02195866e-01f, -3.04564815e-02f, 1.45184532e-01f, -1.23187955e-02f, 1.47706211e-01f, -6.89243004e-02f, 9.78626311e-03f, -3.89464833e-02f, -1.26281977e-01f,
  -1.41678434e-02f, 9.26919058e-02f, 1.99175961e-02f, 5.27887512e-03f, -3.61017766e-03f, 7.61486888e-02f, -1.28242433e-01f, -8.81461054e-02f, 5.84367327e-02f, 4.24535610e-02f,
  -4.40855660e-02f, 5.69434576e-02f, -9.66511965e-02f, -1.94173217e-01f, 8.72345269e-02f, 7.24270269e-02f, 2.53758766e-02f, 1.01745985e-01f, -1.47395000e-01f, 1.99187119e-02f,
  -1.51270166e-01f, -7.61757419e-02f, 1.10762939e-01f, 6.00019544e-02f, -4.02451865e-02f, -3.84390913e-03f, 4.78107035e-02f, -9.48261395e-02f, -4.17933390e-02f, -4.18255776e-02f,
  -5.25645504e-04f, -6.43853545e-02f, -1.17135093e-01f, -4.44287173e-02f, 5.94985895e-02f, 8.20366070e-02f, -1.53008759e-01f, -2.30904549e-01f, 8.82467404e-02f, 9.19796452e-02f,
  -4.83652391e-02f, -1.02320574e-01f, 3.84300016e-02f, -6.39984682e-02f, -1.75613239e-02f, 9.96673852e-02f, -6.57626539e-02f, -1.30128592e-01f, -2.64840305e-01f, -2.64901459e-01f,
  -6.46489114e-02f, -2.31954336e-01f, 2.09751233e-01f, 1.93068773e-01f, 3.32873799e-02f, 7.68043473e-02f, -7.63867497e-02f, 4.96460311e-02f, 9.08436254e-02f, 3.26149538e-02f,
  -8.54389146e-02f, 1.02867439e-01f, 1.30801320e-01f, 2.27546971e-02f, -3.35025718e-03f, 1.38675705e-01f, -1.27855822e-01f, -1.82493366e-02f, -6.88325316e-02f, -1.52224535e-02f,
  -1.12587072e-01f, -1.06603075e-02f, 3.41491103e-02f, -5.76603636e-02f, -1.62478700e-01f, 1.04611784e-01f, -1.39248088e-01f, -2.85257667e-01f, 2.08224386e-01f, 5.04766181e-02f,
  4.70470190e-02f, 4.98611592e-02f, -1.28923967e-01f, 6.05076812e-02f, -1.99359842e-02f, 2.33664960e-02f, 1.90691605e-01f, -1.48787752e-01f, 1.13168381e-01f, 1.78417414e-02f,
  -1.41471669e-01f, -1.23204805e-01f, 3.88740897e-02f, -2.95733996e-02f, 1.33437380e-01f, -1.68053359e-02f, -1.37514612e-02f, -4.71358411e-02f, -1.98627502e-01f, 1.91615447e-02f,
  -4.70370837e-02f, -6.63198978e-02f, 1.35821432e-01f, 7.28055984e-02f, -6.09883331e-02f, -7.16869459e-02f, -5.87629303e-02f, -5.38247786e-02f, -1.05159216e-01f, -5.14207371e-02f,
  1.86021045e-01f, 1.54835964e-02f, 8.54540393e-02f, -8.30670074e-02f, 1.60968587e-01f, -1.88558344e-02f, 1.74209103e-01f, -1.17059641e-01f, 1.81939527e-01f, 3.24040353e-02f,
  -3.31412889e-02f, -1.81197017e-01f, 6.49165139e-02f, 9.31408927e-02f, 1.26692906e-01f, 1.05574459e-01f, -1.00421123e-01f, -1.25442863e-01f, 1.78726092e-02f, -7.76285902e-02f,
  4.93843257e-02f, -3.63742635e-02f, -1.28800347e-01f, 3.27529050e-02f, -8.17434639e-02f, 1.86951943e-02f, -1.10278182e-01f, 1.09813675e-01f, 1.34715274e-01f, -5.02621718e-02f,
  -5.87413460e-03f, -4.08223942e-02f, -1.34525359e-01f, -1.55430049e-01f, 1.15905888e-03f, -6.43024072e-02f, -9.97658968e-02f, 8.14589486e-02f, -9.55908149e-02f, -4.03791331e-02f,
  -9.29447338e-02f, -9.51672196e-02f, 4.40971814e-02f, -5.21037132e-02f, -5.08539984e-03f, -1.32282704e-01f, 1.46762714e-01f, -1.53194582e-02f, 7.19138309e-02f, -6.71960041e-02f,
  -7.26752728e-02f, 8.29085894e-03f, -8.23937282e-02f, -7.31441900e-02f, -3.48772779e-02f, 1.00371219e-01f, -8.43259394e-02f, -7.38193020e-02f, 6.18761517e-02f, -4.99526151e-02f,
  4.41475660e-02f, -1.11059919e-01f, 7.13944286e-02f, -5.36516309e-02f, 6.04452081e-02f, -5.14096841e-02f, -2.16071662e-02f, -1.20976582e-01f, -4.54165637e-02f, 1.08692601e-01f,
  -7.34147951e-02f, 5.47439158e-02f, -1.60855018e-02f, 2.23467518e-02f, 8.92069284e-03f, 1.14683159e-01f, 9.70804244e-02f, -4.25736234e-02f, -3.93032655e-02f, -4.36272956e-02f,
  -8.93167257e-02f, -1.69268139e-02f, -7.93562308e-02f, 1.00722328e-01f, 9.03662443e-02f, -1.14347056e-01f, 3.55587862e-02f, 6.69141561e-02f, -4.91506457e-02f, 6.07907362e-02f,
  1.02748223e-01f, -1.43349797e-01f, -1.79317556e-02f, -1.65449098e-01f, 1.07345931e-01f, 2.67389566e-02f, 3.62966978e-03f, 1.28250286e-01f, 6.74196631e-02f, 7.46300444e-02f,
  1.15323298e-01f, 6.66434318e-02f, -2.41444092e-02f, 7.77102187e-02f, 6.07341640e-02f, -4.37825434e-02f, -9.89092216e-02f, 1.98486336e-02f, 1.69578418e-02f, 1.10148311e-01f,
  1.25105396e-01f, 1.50063010e-02f, -1.12313487e-01f, -1.31046668e-01f, 6.79379925e-02f, -3.87691148e-02f, 2.84254830e-02f, -5.21777868e-02f, 1.02868035e-01f, -1.46288082e-01f,
  -1.79731935e-01f, 7.16905668e-02f, -7.24282265e-02f, 1.10513508e-01f, -1.84821971e-02f, 2.06624414e-03f, 6.46868423e-02f, -3.95109840e-02f, -1.38588980e-01f, -9.63944122e-02f,
  -2.46877000e-02f, -1.51590437e-01f, -1.97924122e-01f, -1.29906744e-01f, 8.78548101e-02f, 1.35410577e-01f, 4.76308987e-02f, -1.37030661e-01f, -2.49122843e-01f, 2.04901010e-01f,
  6.35220855e-03f, -5.44079505e-02f, 1.20726518e-01f, 5.53627573e-02f, 1.15546742e-02f, -3.91002372e-02f, 4.80325893e-02f, 1.33892462e-01f, -1.70009062e-01f, 1.71989769e-01f,
  3.05998027e-02f, 1.89089373e-01f, -3.21659334e-02f, 1.28533289e-01f, 1.44445986e-01f, 1.22092292e-01f, -4.35962528e-02f, -1.60592005e-01f, 5.46414666e-02f, -3.21264088e-01f,
  -1.08729206e-01f, 8.91433284e-03f, -1.12011731e-01f, -9.33479667e-02f, -6.35264367e-02f, 9.75751281e-02f, 8.26305598e-02f, -6.48544356e-02f, 1.24723405e-01f, 5.22813424e-02f,
  1.55713856e-02f, -2.68035904e-02f, -9.50945690e-02f, 6.60274401e-02f, 2.79932134e-02f, 1.69190943e-01f, 7.84061030e-02f, 1.19601600e-01f, 5.62665015e-02f, 1.20931730e-01f,
  6.88001812e-02f, 4.98514883e-02f, 6.56959265e-02f, 1.17529206e-01f, -1.53638050e-01f, 1.07597046e-01f, 7.89270401e-02f, 8.21696371e-02f, 5.57172559e-02f, -1.24690086e-01f,
  9.42215025e-02f, 1.11684896e-01f, -1.87977612e-01f, 2.03981385e-01f, 2.02673227e-01f, 2.41510630e-01f, -1.13641359e-01f, 1.14304245e-01f, -8.53874087e-02f, -8.98104906e-02f,
  -1.35822505e-01f, -5.47491126e-02f, -1.02613360e-01f, -1.81152448e-01f, 7.77029991e-02f, -6.81468844e-02f, 1.35956155e-02f, -1.24887101e-01f, 8.49236771e-02f, 1.63220227e-01f,
  -3.53641361e-02f, -2.57092845e-02f, -1.02956928e-01f, -1.51947930e-01f, -3.12657133e-02f, -1.03740506e-01f, 4.78541590e-02f, 1.22154228e-01f, -3.53046954e-02f, 5.78371696e-02f,
  -1.91860795e-02f, -3.55851352e-02f, 4.49183248e-02f, 1.93889678e-01f, 4.45709117e-02f, -1.65133867e-02f, -1.17048159e-01f, 3.47093306e-02f, 1.62927181e-01f, -2.04442292e-02f,
  1.07762218e-01f, -6.90153614e-02f, 3.38323787e-02f, -2.01755692e-03f, -2.37720273e-02f, -9.04565901e-02f, 1.07537933e-01f, 1.04272790e-01f, -1.23407401e-01f, 8.30263719e-02f,
  4.92725745e-02f, 9.85304937e-02f, 1.27503946e-01f, -3.08326278e-02f, 1.44721985e-01f, -8.20427537e-02f, -1.39563784e-01f, -2.84106787e-02f, -1.58919707e-01f, 8.39579403e-02f,
  -1.76037222e-01f, 1.32587329e-02f, 7.78363794e-02f, -1.89905129e-02f, -5.01238741e-03f, 6.37366176e-02f, -1.14036195e-01f, 2.23655149e-01f, -2.98241358e-02f, -1.05193540e-01f,
  -8.17807466e-02f, 1.58661991e-01f, -1.51015401e-01f, 1.95528269e-01f, -3.08720410e-01f, -2.92021707e-02f, 1.10335268e-01f, -2.04523746e-02f, -1.09772474e-01f, 1.25448644e-01f,
  -1.55847492e-02f, -1.28041595e-01f, 3.75014767e-02f, 2.21484378e-01f, 7.24530369e-02f, -4.19826433e-02f, 8.86849612e-02f, -3.14707570e-02f, 8.02936032e-02f, 4.83278148e-02f,
  -1.00030182e-02f, 1.01503134e-01f, 1.29076809e-01f, -1.59877017e-01f, 1.30108492e-02f, -2.53564864e-01f, -1.27964363e-01f, 1.49619013e-01f, 1.89546451e-01f, 1.43740803e-01f,
  3.78340320e-03f, -1.27067864e-01f, 1.12976201e-01f, 1.42618865e-01f, -4.71968576e-02f, 1.12486504e-01f, 1.78138271e-01f, -7.54489005e-02f, 2.01388579e-02f, -1.27526730e-01f,
  -5.59439883e-02f, 6.07641302e-02f, -1.26636019e-02f, 1.02166772e-01f, -3.75701860e-02f, -1.79089844e-01f, -9.85151082e-02f, 1.55190185e-01f, 1.30793214e-01f, 6.29368424e-02f,
  1.42007113e-01f, -4.77252714e-02f, -7.46046081e-02f, -8.14424537e-04f, 1.72697082e-02f, 8.78460407e-02f, -1.15214042e-01f, 3.18405852e-02f, -4.79038712e-03f, -2.84365993e-02f,
  -2.28720561e-01f, 7.71140084e-02f, 2.01474831e-01f, -3.15521918e-02f, -2.59536415e-01f, 2.79528107e-02f, -9.21787992e-02f, -5.48011065e-02f, 5.86960316e-02f, -8.15316141e-02f,
  7.66145661e-02f, 9.00063887e-02f, -1.34253696e-01f, 4.60027077e-04f, 9.55696627e-02f, 2.59721465e-03f, -1.59253597e-01f, 1.59117058e-01f, 1.39167428e-01f, 1.26324028e-01f,
  -8.82556513e-02f, -1.62249818e-01f, -2.16653123e-02f, 6.87102303e-02f, 1.41535848e-01f, 9.20243710e-02f, 1.33382648e-01f, 5.31555414e-02f, 5.83052821e-02f, -7.50042722e-02f,
  2.50761807e-02f, 8.67511183e-02f, -1.50829121e-01f, -1.37848193e-02f, 2.67544724e-02f, -5.88506274e-02f, 1.79612994e-01f, 1.78510603e-02f, 1.27972588e-01f, 1.35198861e-01f,
  -1.39709786e-01f, 1.03264287e-01f, 1.14513583e-01f, 7.64417723e-02f, -6.09615520e-02f, -1.14038782e-02f, -2.38481015e-02f, 1.49515688e-01f, 3.67901251e-02f, 3.13535705e-02f,
  3.17801610e-02f, 1.75559595e-01f, -1.57612056e-01f, 1.91589426e-02f, 1.40766660e-02f, -1.87334016e-01f, -1.56201676e-01f, -1.19612470e-01f, -1.94854692e-01f, -9.41575542e-02f,
  -5.67091703e-02f, -1.58801500e-03f, 3.32855689e-03f, 9.97199491e-02f, 5.10338582e-02f, 1.54415250e-01f, 3.55988443e-02f, 1.38587356e-01f, -7.71204084e-02f, -1.44699156e-01f,
  1.90618113e-01f, 1.38704121e-01f, 3.76054317e-01f, 2.95495868e-01f, -4.59892601e-02f, -6.21267594e-03f, -9.01115686e-02f, 6.22373894e-02f, -8.88860971e-02f, 2.12502897e-01f,
  2.17748974e-02f, 7.32599944e-02f, -1.36689931e-01f, 1.90281436e-01f, -3.06658307e-03f, -2.53894687e-01f, -1.29381031e-01f, 6.50879443e-02f, 5.93294017e-02f, -1.48315504e-01f,
  2.07783908e-01f, 1.53667837e-01f, -1.28916234e-01f, 1.27225310e-01f, 2.43333299e-02f, -9.46790501e-02f, 5.38942143e-02f, -4.00182270e-02f, 1.16277702e-01f, 1.63326815e-01f,
  -1.04824752e-01f, 1.10104710e-01f, -7.15806708e-02f, -1.57462463e-01f, 2.29009204e-02f, -1.59443870e-01f, 8.72360915e-02f, -2.96102464e-02f, 1.18743852e-01f, 7.18051046e-02f,
  1.68178212e-02f, 3.80958170e-02f, -4.29471321e-02f, 1.68848395e-01f, -1.17247082e-01f, -1.92753479e-01f, 2.45483130e-01f, 1.57025948e-01f, 9.79908556e-02f, 3.62135470e-01f,
  1.03307761e-01f, 1.34937227e-01f, 6.98684305e-02f, -9.48060229e-02f, 2.18520705e-02f, 4.11787145e-02f, 1.09088726e-01f, 1.24531053e-01f, -7.63830617e-02f, -6.05019480e-02f,
  8.40512589e-02f, 1.85708106e-01f, 4.30770777e-02f, 1.33425668e-01f, -1.78737178e-01f, -2.47959927e-01f, -1.79364622e-01f, -2.07171753e-01f, -3.08004655e-02f, -9.68187824e-02f,
  1.00234449e-02f, -1.32885247e-01f, -1.11791857e-01f, -1.18470006e-01f, 8.00437257e-02f, -2.79451404e-02f, 1.09249130e-01f, -1.51756741e-02f, -1.11582063e-01f, 1.16442613e-01f,
  1.17279962e-01f, -4.75740135e-02f, -8.49341750e-02f, 1.52115032e-01f, -2.31039494e-01f, 9.55841541e-02f, 2.36373078e-02f, 4.50068116e-02f, -5.20176813e-02f, 1.50443166e-01f,
  -9.78595242e-02f, 1.19266361e-01f, -1.62523538e-01f, -1.27302587e-01f, 1.98460579e-01f, 1.09243236e-01f, -1.02969043e-01f, 9.11902115e-02f, -1.33577332e-01f, 1.64759159e-01f,
  6.62743673e-03f, -6.96232468e-02f, 7.91747048e-02f, 5.96200898e-02f, 6.77048275e-03f, -9.68658254e-02f, 1.94912422e-02f, -1.39486805e-01f, 7.19631314e-02f, 1.45321757e-01f,
  -1.38330728e-01f, -5.04834466e-02f, -5.54517135e-02f, 1.92558229e-01f, 5.26627935e-02f, 9.54843089e-02f, 3.75222303e-02f, -1.91268638e-01f, 7.69604892e-02f, -1.70481861e-01f,
  -2.79855132e-02f, -1.40493307e-02f, 7.86720216e-02f, -2.93754991e-02f, -8.36513788e-02f, 2.56633013e-01f, 1.40650734e-01f, 1.45557597e-01f, -9.00143385e-02f, -8.02315101e-02f,
  -8.50751624e-02f, -2.04570994e-01f, -7.85097331e-02f, -2.72995740e-01f, -2.49897260e-02f, 6.35987520e-02f, 1.14067048e-01f, -7.06290752e-02f, 6.35358095e-02f, -1.94668416e-02f,
  9.50373039e-02f, -1.26492605e-01f, 2.88871881e-02f, 6.88158572e-02f, 1.53370246e-01f, 6.77112415e-02f, -1.29454762e-01f, -3.75838019e-02f, -2.65351176e-01f, 1.20559804e-01f,
  1.34529481e-02f, 8.08020085e-02f, 1.53041596e-03f, 2.12165624e-01f, -1.06432669e-01f, 2.28302870e-02f, -1.66610360e-01f, 7.19639510e-02f, 1.51570737e-02f, -1.14321396e-01f,
  1.54519659e-02f, 1.60524473e-01f, -1.38066709e-01f, -4.09851633e-02f, 1.00462526e-01f, -2.93029379e-02f, 3.83440778e-02f, -6.86218143e-02f, -3.00421333e-03f, -2.18683124e-01f,
  7.90963322e-02f, -1.09446026e-01f, -1.05498335e-03f, 3.55945751e-02f, -1.12457536e-01f, 1.46447375e-01f, 1.42747551e-01f, 1.62667245e-01f, 8.22048634e-02f, 7.80839995e-02f,
  -7.54078701e-02f, -4.94700223e-02f, -4.06882912e-02f, 1.04963735e-01f, 1.54691905e-01f, -9.15142447e-02f, 9.42175910e-02f, -1.69520974e-01f, -9.09811109e-02f, 1.60786718e-01f,
  7.17953742e-02f, 3.56430747e-02f, 9.89964008e-02f, -1.16265573e-01f, 1.61948562e-01f, -9.59922373e-02f, 1.07792690e-02f, -2.30312631e-01f, -8.00655261e-02f, 3.40774134e-02f,
  1.07390016e-01f, 1.35299191e-01f, 9.46578234e-02f, -1.39309704e-01f, -1.57896727e-02f, -7.85920024e-02f, 6.76551089e-02f, -6.64284751e-02f, -9.86097902e-02f, -1.25998214e-01f,
  -1.29640222e-01f, -8.65379944e-02f, -1.89532936e-02f, -8.83847028e-02f, -6.28926083e-02f, 1.21205069e-01f, 1.14669390e-01f, 1.39304563e-01f, -7.07155615e-02f, -1.51394248e-01f,
  7.31772184e-02f, -8.11779313e-03f, 3.21408212e-02f, -1.34778485e-01f, -1.65728360e-01f, 1.08879812e-01f, 6.15302920e-02f, -1.35952793e-02f, 1.06104530e-01f, -1.70818698e-02f,
  -1.09244391e-01f, -9.39756706e-02f, 9.94685292e-02f, -4.08477709e-02f, -1.19959153e-02f, 6.46651983e-02f, 1.16376817e-01f, -9.22344849e-02f
};

// L2_fan_Wp_bar (Shape: 40 x 64)
const int L2_fan_Wp_bar_rows = 40;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  5.96203431e-02f, 1.82237461e-01f, 1.39712542e-01f, -3.00618801e-02f, -1.02282688e-01f, 6.78103268e-02f, 1.45596936e-01f, 5.70167117e-02f, 2.41025567e-01f, -1.91787574e-02f,
  6.35919645e-02f, 9.08225179e-02f, 1.82837680e-01f, 1.62119120e-01f, 7.98042119e-02f, 2.10552558e-01f, -9.41335335e-02f, 7.18675256e-02f, 2.30359986e-01f, 3.83281559e-02f,
  4.20185775e-02f, 2.64012992e-01f, 1.88753664e-01f, 4.70939763e-02f, -8.63243043e-02f, 6.92425743e-02f, -6.56668320e-02f, -1.53572466e-02f, 1.14728272e-01f, 2.17891634e-01f,
  -1.38637573e-02f, 6.46318719e-02f, 1.69473782e-01f, -1.37850150e-01f, -1.40142485e-01f, -1.01804145e-01f, -3.18646803e-02f, 1.09978542e-02f, 1.80398017e-01f, 8.90745148e-02f,
  5.03576212e-02f, 2.84772426e-01f, -6.44867495e-02f, 1.30629271e-01f, 1.58111341e-02f, -1.14967152e-01f, 1.00642733e-01f, 2.57614374e-01f, -1.28463551e-01f, 1.44122317e-01f,
  -8.02589394e-03f, -1.31021455e-01f, -8.04338977e-02f, -1.72095671e-01f, -4.96256389e-02f, 3.46171446e-02f, 8.82308651e-03f, 4.11222056e-02f, -4.80515277e-03f, -4.44410257e-02f,
  -1.27083212e-01f, -9.20302495e-02f, -6.38588220e-02f, -9.30222720e-02f, -1.99520309e-02f, -7.25588575e-02f, -6.98501989e-02f, -4.35744151e-02f, -8.63250718e-02f, -6.29626960e-02f,
  7.90681019e-02f, -3.93390097e-02f, -2.92941816e-02f, 3.16283070e-02f, 2.83390675e-02f, 8.61093923e-02f, -1.32142991e-01f, 7.28672147e-02f, 8.97088051e-02f, -3.15690003e-02f,
  -8.66497084e-02f, 7.84457624e-02f, -9.44557935e-02f, -3.18272822e-02f, 2.63545681e-02f, -1.27704665e-01f, 9.70385969e-02f, -2.82147806e-02f, 4.94904555e-02f, 1.45793203e-02f,
  -5.18659130e-02f, -7.58394152e-02f, -8.77857581e-02f, 2.21017469e-02f, 7.85325021e-02f, -1.00498162e-02f, 9.12087932e-02f, -5.21340407e-02f, 1.43959492e-01f, -6.82307631e-02f,
  -1.32091399e-02f, -6.56493828e-02f, -9.53171104e-02f, 1.80690959e-02f, -1.10966489e-01f, 1.09126315e-01f, 2.61655673e-02f, -1.34965014e-02f, -8.63161162e-02f, 3.55671570e-02f,
  -2.51810122e-02f, -5.62069006e-02f, 1.45673186e-01f, 1.05363704e-01f, 1.03304647e-01f, -7.85973892e-02f, -1.30607814e-01f, -8.39060992e-02f, -9.77392718e-02f, -7.06524402e-02f,
  -2.82779220e-03f, -1.18680475e-02f, 6.05493831e-03f, -1.73914190e-02f, 7.97528401e-02f, -4.26186174e-02f, -7.61759793e-03f, 1.07019044e-01f, 6.11724705e-02f, 3.30564268e-02f,
  5.54153249e-02f, -7.72611797e-02f, -5.91972619e-02f, 3.38269323e-02f, 6.32653087e-02f, 4.69497256e-02f, 2.81466302e-02f, -3.07932831e-02f, -5.65951616e-02f, 3.99585776e-02f,
  -1.06135290e-02f, -1.60135794e-03f, -9.01437551e-02f, -2.11240407e-02f, 1.55431807e-01f, 8.75027757e-03f, 8.01433772e-02f, 1.30856693e-01f, -6.18983507e-02f, -4.79859672e-02f,
  -6.80499226e-02f, 7.45261088e-02f, 7.70763457e-02f, -4.90903482e-02f, 5.64490035e-02f, 8.40173066e-02f, 6.05682768e-02f, -3.13063078e-02f, 5.41700162e-02f, 9.95516330e-02f,
  -1.41574470e-02f, 1.58404529e-01f, -9.46255773e-02f, -1.08971149e-01f, -6.75307438e-02f, 6.35563806e-02f, 4.76799458e-02f, 6.69568777e-02f, 6.05998896e-02f, -8.68784934e-02f,
  1.03657983e-01f, -7.95885772e-02f, 8.30846429e-02f, -9.26533118e-02f, 6.79937238e-03f, 2.92964699e-03f, -1.53433248e-01f, -1.44471243e-01f, -1.30466580e-01f, -3.34905460e-02f,
  -4.66321632e-02f, -5.92689961e-02f, -4.53151688e-02f, -3.75861973e-02f, 7.55803883e-02f, -1.19973265e-01f, 1.45738155e-01f, -7.94591457e-02f, -6.67122155e-02f, 2.41662804e-02f,
  -1.19429000e-01f, -6.18683137e-02f, -6.95545152e-02f, -3.70044596e-02f, -5.09830303e-02f, 1.49623662e-01f, 1.75470337e-01f, 1.28124669e-01f, -1.58765502e-02f, -1.84881929e-02f,
  8.08557197e-02f, -2.14952230e-02f, 1.25359884e-02f, 1.59735978e-01f, 1.11779273e-01f, 1.44067943e-01f, -1.02257647e-01f, -7.79672414e-02f, 1.28903911e-01f, -1.52493231e-02f,
  1.73825547e-01f, -3.47931311e-02f, 1.32066756e-01f, 7.96319097e-02f, 1.69763818e-01f, -6.94101751e-02f, 1.15766600e-01f, -6.20935969e-02f, -9.17300396e-03f, 1.22878030e-02f,
  6.40761331e-02f, 1.96700525e-02f, -6.80005252e-02f, -3.28521430e-02f, 2.33032014e-02f, 9.35053751e-02f, 2.72187106e-02f, -7.25613907e-02f, 4.67790999e-02f, 1.23854399e-01f,
  1.27869129e-01f, -6.96054697e-02f, -3.46398167e-02f, 1.77712470e-01f, -9.90474671e-02f, -2.06646435e-02f, 1.38532564e-01f, 1.85105542e-03f, 7.85175562e-02f, 3.71058173e-02f,
  -9.84787121e-02f, -1.15489654e-01f, -1.65062323e-02f, -5.18705845e-02f, 1.36195943e-01f, -1.11583225e-01f, -1.01843253e-01f, 6.55474886e-02f, 1.17014900e-01f, -1.34771466e-01f,
  1.65425837e-02f, 6.80620298e-02f, 2.28910595e-02f, 6.33389726e-02f, -1.32543221e-01f, -7.05702230e-02f, 6.40305802e-02f, 1.29820332e-02f, 7.19000003e-04f, 1.98128507e-01f,
  2.14289259e-02f, 3.00104003e-02f, 6.16185889e-02f, 1.02689311e-01f, 9.14076269e-02f, 1.50034532e-01f, 1.13314070e-01f, 1.16015919e-01f, -4.25139256e-03f, -7.79655650e-02f,
  -6.03157617e-02f, 1.47649750e-01f, -6.77279308e-02f, 1.81061949e-03f, -1.45190284e-02f, -1.86626360e-01f, 1.94397464e-01f, -3.78690958e-02f, 9.50272754e-03f, -1.22993082e-01f,
  -4.55526151e-02f, 7.11492822e-02f, -4.28830199e-02f, 1.00127131e-01f, 5.82087077e-02f, -6.71784580e-03f, -1.00440234e-01f, 1.46255956e-03f, -6.47532215e-05f, -4.21339162e-02f,
  1.16000868e-01f, -1.35055587e-01f, -3.64020914e-02f, 3.62519920e-02f, 6.36334196e-02f, -2.34407298e-02f, -2.32790187e-02f, 1.90877602e-01f, -1.53231830e-03f, 2.72707976e-02f,
  7.45296031e-02f, -5.86603656e-02f, -1.28048480e-01f, 1.80681288e-01f, -1.62932664e-01f, -1.37250172e-02f, -8.53500515e-02f, -1.34522080e-01f, 6.10389262e-02f, 4.03908007e-02f,
  2.22161617e-02f, -4.60151508e-02f, 1.22767240e-01f, 8.87720957e-02f, -3.08366120e-02f, 4.19963486e-02f, -6.24274462e-02f, 6.16994724e-02f, -6.61978126e-02f, -3.17205153e-02f,
  -7.91037232e-02f, 1.17830627e-01f, -4.88457978e-02f, 1.08101510e-01f, -7.30387270e-02f, -9.33391899e-02f, -9.81013924e-02f, 3.90469618e-02f, 3.55783664e-02f, -1.07831731e-01f,
  3.03489942e-04f, 5.91865852e-02f, 1.37548864e-01f, -1.45595672e-03f, 9.84908864e-02f, 1.14625163e-01f, 8.96854624e-02f, -9.67888534e-03f, 4.38292250e-02f, 4.17851424e-03f,
  -2.70457193e-02f, 3.15182246e-02f, -1.50891328e-02f, -1.43837363e-01f, -5.00192493e-02f, 5.54845072e-02f, 5.35400622e-02f, 6.63078725e-02f, -4.37074862e-02f, -1.52176721e-02f,
  1.09340698e-02f, -6.77186400e-02f, -7.89119974e-02f, -1.70910563e-02f, 9.21710134e-02f, -7.31197745e-02f, 7.55590424e-02f, -5.84523939e-02f, 6.92380145e-02f, 1.11106366e-01f,
  1.40078470e-01f, 1.35169536e-01f, 3.72675271e-03f, 1.31777469e-02f, -1.09161139e-02f, 6.47567660e-02f, -2.74608675e-02f, 8.57027248e-02f, 6.38703331e-02f, -6.91055283e-02f,
  9.62767676e-02f, -3.62286381e-02f, 5.75342774e-02f, -4.12327200e-02f, -1.02166615e-01f, -6.42955154e-02f, 6.94349259e-02f, 1.01992175e-01f, -9.83619839e-02f, 1.12324744e-03f,
  4.66889143e-02f, -2.61373762e-02f, 1.19124897e-01f, 6.71757534e-02f, -1.32885024e-01f, 1.20711938e-01f, -1.00871362e-01f, 1.01732038e-01f, 3.59899774e-02f, 1.22088008e-01f,
  5.38211241e-02f, 1.09685175e-01f, -1.21537849e-01f, -2.87061725e-02f, 1.05745241e-01f, 1.31648764e-01f, 6.49957880e-02f, -5.82589060e-02f, 1.04280844e-01f, 1.04678892e-01f,
  -9.28381085e-02f, 9.97965932e-02f, -9.47636887e-02f, -1.22750729e-01f, -4.22096997e-02f, -2.69495770e-02f, -7.59209394e-02f, 6.30505309e-02f, 6.92427978e-02f, -9.99499261e-02f,
  8.38040784e-02f, 5.28796688e-02f, -4.62564034e-03f, 8.09466839e-02f, -4.80587408e-02f, 6.19559810e-02f, 1.30126834e-01f, 1.77342203e-02f, 9.65235308e-02f, -6.67888597e-02f,
  -9.56122938e-04f, -8.53991807e-02f, 9.63364765e-02f, 4.28803004e-02f, 6.44297898e-02f, -5.02573848e-02f, 6.41265884e-02f, 1.45650089e-01f, -1.69053841e-02f, -1.11028319e-02f,
  -8.17015246e-02f, 9.95986983e-02f, -5.20794950e-02f, 3.81687507e-02f, 1.10166155e-01f, 2.41858745e-03f, 2.80374028e-02f, 4.16663568e-03f, -4.54778038e-03f, -5.27791232e-02f,
  9.00811777e-02f, 2.74391081e-02f, 5.01514189e-02f, -1.77582223e-02f, 6.27447814e-02f, 1.07493445e-01f, 2.63929553e-02f, -3.36629301e-02f, -2.56532226e-02f, 9.03047696e-02f,
  -2.02067290e-02f, -8.88939351e-02f, -1.12802736e-01f, 7.88219925e-03f, 1.09711714e-01f, 1.50460884e-01f, 5.10590114e-02f, 8.09335634e-02f, -4.15363424e-02f, -2.87904628e-02f,
  -8.00595060e-02f, 4.56874110e-02f, 5.09900004e-02f, -3.83225232e-02f, 7.05623552e-02f, -8.96424800e-02f, 1.50149480e-01f, 6.61708117e-02f, 1.36788592e-01f, -6.25253320e-02f,
  -1.29166007e-01f, 1.44642398e-01f, 3.44508551e-02f, 7.00909644e-02f, -1.31494045e-01f, 1.29646406e-01f, 7.38898441e-02f, -7.50071257e-02f, -6.45050332e-02f, 1.62766740e-01f,
  -8.44442397e-02f, -1.27976984e-01f, -9.27697122e-02f, -6.62810111e-04f, 1.47290647e-01f, -2.85443496e-02f, -1.24962060e-02f, 1.27318099e-01f, -2.40728795e-03f, 6.85592741e-02f,
  1.09192461e-01f, -1.05004519e-01f, -3.81784476e-02f, 1.24576576e-01f, -5.59724718e-02f, -4.41219797e-03f, -5.37087321e-02f, 7.38625899e-02f, 9.17787626e-02f, -1.33577347e-01f,
  -7.97852874e-02f, -2.72580925e-02f, 1.19181089e-01f, 3.05971988e-02f, 9.85086784e-02f, -8.95673484e-02f, -7.31072053e-02f, 1.31901458e-01f, -1.00173363e-02f, -5.75025342e-02f,
  -3.47227529e-02f, -1.77312680e-02f, -5.60227111e-02f, -4.74156924e-02f, 1.65991485e-01f, 2.02828925e-02f, 1.39738113e-01f, 4.09092344e-02f, 4.84603606e-02f, 1.92618296e-01f,
  1.43962964e-01f, 1.39069885e-01f, 1.99374810e-01f, 6.23456724e-02f, 6.53266162e-03f, -2.06522092e-01f, -1.57407105e-01f, -5.42280674e-02f, 2.00262666e-01f, -1.58908829e-01f,
  1.91841364e-01f, -6.38518184e-02f, 1.77018344e-01f, -1.14808232e-03f, 6.58254921e-02f, 1.01423487e-02f, 7.79136717e-02f, 1.00034602e-01f, 4.57157046e-02f, 9.87442657e-02f,
  1.10619210e-01f, -5.97206540e-02f, 8.56735483e-02f, 6.65423572e-02f, 5.34142479e-02f, 1.55378133e-01f, -4.07879464e-02f, 1.16257630e-01f, -3.03936936e-03f, -6.70026243e-02f,
  5.26542068e-02f, -3.96314785e-02f, -1.05628055e-02f, 3.45010050e-02f, -9.04019997e-02f, 3.78907472e-02f, -1.18230782e-01f, 2.27316897e-02f, 6.69864044e-02f, 9.21643898e-02f,
  -1.28723279e-01f, -2.02098005e-02f, -8.93607512e-02f, 1.05606720e-01f, 7.58456718e-03f, 9.21677127e-02f, -6.26645163e-02f, 6.01979643e-02f, 9.96066853e-02f, -1.50501635e-03f,
  -2.03814190e-02f, 3.05269845e-02f, -1.03494436e-01f, 8.95058662e-02f, 7.82570615e-02f, -6.87577873e-02f, 2.29678556e-01f, 2.16945156e-01f, 8.17004889e-02f, -1.12845721e-02f,
  2.49039114e-01f, 1.30572975e-01f, 1.80024616e-02f, 1.52581021e-01f, 1.32796243e-01f, 2.01069266e-01f, 2.56455809e-01f, 1.12022586e-01f, 6.60184622e-02f, -1.16314895e-01f,
  -3.00572783e-01f, -2.86142498e-01f, 2.64632076e-01f, -1.39567316e-01f, 1.77557245e-01f, 1.59877419e-01f, -3.04085463e-02f, -9.25108865e-02f, -1.18140563e-01f, 8.64970163e-02f,
  -9.64950696e-02f, -2.60878187e-02f, 4.30302955e-02f, -7.67258406e-02f, 2.20301867e-01f, -8.48358572e-02f, -2.59812344e-02f, -1.18505687e-01f, 7.17420578e-02f, 4.75228578e-01f,
  -8.77244174e-02f, -1.32706389e-02f, -1.30925342e-01f, 1.29234344e-01f, 1.01161622e-01f, -2.81775296e-02f, -8.32579434e-02f, -8.93788636e-02f, -1.24270886e-01f, -1.43958211e-01f,
  1.23849167e-02f, -3.58119048e-02f, -9.92987379e-02f, -1.32442415e-01f, -1.57658011e-01f, -2.05919910e-02f, 9.46772993e-02f, -3.30786854e-02f, 1.81416184e-01f, 4.30338867e-02f,
  -1.14574686e-01f, 1.08901292e-01f, 9.29856226e-02f, -9.51050371e-02f, 1.44649714e-01f, 7.53421709e-02f, 1.25335082e-01f, -1.45329028e-01f, 6.82856217e-02f, 9.69644263e-02f,
  -6.01644674e-03f, 4.07497846e-02f, -5.17584868e-02f, -1.22456536e-01f, 4.36822437e-02f, -5.81576079e-02f, -8.82045180e-03f, 9.54201818e-02f, -1.08020738e-01f, -6.43672720e-02f,
  -3.42072882e-02f, 6.92649186e-02f, -7.00635761e-02f, 1.10480644e-01f, -6.90744165e-03f, 9.78468359e-02f, -7.06782714e-02f, 5.84177040e-02f, -5.48792928e-02f, 7.50399679e-02f,
  1.06516965e-01f, -8.84509161e-02f, 1.20943278e-01f, -1.33502975e-01f, -7.24419206e-02f, 1.26663437e-02f, 6.11075386e-02f, -6.57031685e-02f, 7.61702880e-02f, 9.59243476e-02f,
  -2.80158082e-03f, -6.89716190e-02f, -3.15712392e-02f, -7.43738562e-02f, -2.35570632e-02f, -5.51396757e-02f, -3.73082198e-02f, -4.12925109e-02f, 9.78423208e-02f, 3.59782651e-02f,
  1.41741876e-02f, -6.54463097e-02f, 5.19868135e-02f, -2.63626110e-02f, 7.48470500e-02f, -9.47022364e-02f, -1.07720442e-01f, 1.42933533e-01f, 4.06008549e-02f, 5.78981973e-02f,
  -6.60663694e-02f, 1.62559543e-02f, 1.20963417e-01f, 2.41693798e-02f, -4.77301292e-02f, 1.04577079e-01f, -1.75366476e-02f, -7.45225996e-02f, -1.10154293e-01f, 6.82748258e-02f,
  -2.77214851e-02f, -5.41168898e-02f, -1.24903359e-01f, 3.43406871e-02f, 1.79998502e-02f, 6.14907071e-02f, -2.90268101e-02f, -8.32816586e-02f, 1.13896631e-01f, 1.24277867e-01f,
  1.92277476e-01f, 1.02353059e-01f, 1.44175798e-01f, 5.60099818e-02f, -1.43889971e-02f, -6.53873309e-02f, -2.91341133e-02f, -1.10474668e-01f, -8.68745968e-02f, 1.49375185e-01f,
  2.38345377e-02f, 5.25293080e-03f, -1.50677249e-01f, -5.05104661e-02f, -1.25705451e-01f, -2.31906474e-01f, 1.51179768e-02f, 3.54576223e-02f, -3.68267559e-02f, -1.44332290e-01f,
  9.83299017e-02f, 5.21377251e-02f, 1.16599441e-01f, 6.83508217e-02f, 1.85762513e-02f, -7.89742321e-02f, 4.98387665e-02f, -3.58584635e-02f, 6.28646687e-02f, 5.85509231e-03f,
  -1.27259120e-01f, 3.81236039e-02f, -7.51725361e-02f, 7.77886733e-02f, -3.43088359e-02f, 1.18199579e-01f, 1.15502672e-02f, -4.39764783e-02f, -1.31949648e-01f, 9.72866490e-02f,
  -1.73352230e-02f, 7.81335086e-02f, 4.82460223e-02f, 3.47409844e-02f, 2.28858478e-02f, 1.62326157e-01f, 3.64590436e-02f, 1.31553054e-01f, -5.75047061e-02f, -2.30225082e-02f,
  9.83342342e-03f, -4.37546484e-02f, 5.92904426e-02f, 1.60138570e-02f, 1.27818495e-01f, 1.27449363e-01f, -1.33221252e-02f, 1.17151417e-01f, 2.67880946e-01f, 3.53708342e-02f,
  1.35023482e-02f, 1.26543596e-01f, 2.38353521e-01f, 1.18528232e-01f, 2.44551942e-01f, 1.57502010e-01f, 4.39823642e-02f, -5.74366897e-02f, 1.31455436e-01f, 1.92423224e-01f,
  5.92785561e-03f, -2.33868326e-04f, 1.70028601e-02f, 1.70370460e-01f, 7.11712092e-02f, 1.47078827e-01f, -7.07806870e-02f, -1.39566705e-01f, -1.71006903e-01f, -2.10764498e-01f,
  -4.28504078e-03f, -1.98963940e-01f, -6.76811039e-02f, -1.26134977e-01f, 1.29245624e-01f, -1.11385427e-01f, -5.57293557e-02f, 5.47313988e-02f, 5.23317643e-02f, -1.46929041e-01f,
  -7.65363500e-03f, 1.15250044e-01f, 9.27317142e-02f, -2.82265861e-02f, -1.41780436e-01f, 1.17684208e-01f, -2.75348835e-02f, 9.08292159e-02f, 1.51558488e-03f, -4.99952026e-02f,
  9.89749432e-02f, 7.33619854e-02f, -4.88942638e-02f, -1.35368519e-02f, -6.30006790e-02f, 8.32405686e-02f, -7.29678795e-02f, 1.26849180e-02f, -6.69175982e-02f, 2.17351824e-01f,
  3.59788314e-02f, 1.58081025e-01f, -1.01555385e-01f, -9.03779939e-02f, -1.02358162e-01f, -1.16186179e-01f, -3.33930142e-02f, -1.35904789e-01f, -8.88943151e-02f, 2.37502046e-02f,
  -8.55375379e-02f, 5.69095351e-02f, 9.14909467e-02f, -5.25887012e-02f, -2.03709248e-02f, 1.88615136e-02f, -1.56129338e-02f, 6.86065331e-02f, 1.58701483e-02f, 1.13308281e-01f,
  -7.30981529e-02f, 1.44709080e-01f, 1.41268909e-01f, -7.53231440e-03f, 7.93895796e-02f, -8.00038725e-02f, 1.09917611e-01f, -4.81363796e-02f, 2.96480190e-02f, -7.50820786e-02f,
  -9.14739370e-02f, -2.87546441e-02f, 1.12237461e-01f, 9.32655334e-02f, -8.59330893e-02f, 9.20295641e-02f, 1.16563030e-02f, -1.12924278e-01f, -1.21702664e-01f, -1.74958017e-02f,
  1.13923758e-01f, -6.41657934e-02f, 5.33658117e-02f, 3.71431671e-02f, -9.18433517e-02f, -3.58452536e-02f, 1.74964145e-02f, 4.77311090e-02f, -1.10208675e-01f, 1.23245806e-01f,
  5.57779558e-02f, 2.86079217e-02f, 6.00194074e-02f, -1.64839476e-02f, 4.93365712e-02f, 4.05107737e-02f, -1.15723759e-01f, 9.39700752e-02f, -2.75838301e-02f, -1.18583709e-01f,
  -9.22929943e-02f, -6.23511113e-02f, 1.26887456e-01f, -6.25412911e-02f, 1.91301405e-02f, 1.21233761e-01f, 1.51071832e-01f, 1.17626272e-01f, 3.22827995e-02f, 3.44081484e-02f,
  -3.91252674e-02f, 1.85508609e-01f, -3.75237279e-02f, -6.38613999e-02f, -2.18121205e-02f, -2.13823877e-02f, -3.52144316e-02f, 8.86219274e-03f, 7.36980215e-02f, -6.38737530e-02f,
  -3.90796252e-02f, 1.83375627e-02f, 8.57655928e-02f, 2.18726292e-01f, 7.42242709e-02f, 2.30766088e-01f, 1.86539829e-01f, 1.13498926e-01f, -2.93217301e-02f, 1.44992471e-01f,
  3.01581286e-02f, -7.32415318e-02f, 3.31971236e-02f, -7.18901753e-02f, 2.01474831e-01f, 1.11612380e-01f, 1.34803727e-01f, 1.44184068e-01f, 1.17936864e-01f, 1.38269901e-01f,
  1.20799467e-01f, 5.30735217e-03f, -2.15045176e-02f, 1.63118392e-01f, 2.94560473e-02f, 1.19849397e-02f, -5.72924390e-02f, 1.42591313e-01f, 8.28371793e-02f, 1.29517809e-01f,
  -1.37903973e-01f, 1.44874072e-02f, -9.03963000e-02f, 8.86997730e-02f, 1.20295502e-01f, 1.58302151e-02f, 1.13872021e-01f, 6.67765066e-02f, 9.14510153e-03f, -7.91083276e-02f,
  9.74635258e-02f, -9.29799974e-02f, 1.74079239e-01f, -3.60325202e-02f, -1.30681351e-01f, 1.08690642e-01f, -1.36621278e-02f, 9.45383124e-03f, -2.37359293e-02f, 6.72771484e-02f,
  4.20716107e-02f, 1.92555655e-02f, 8.14047530e-02f, -9.63863134e-02f, -1.64653491e-02f, 2.81297620e-02f, -3.44257057e-03f, 1.15119778e-02f, -8.03179815e-02f, -6.13121539e-02f,
  2.25537211e-01f, 1.85014218e-01f, 2.97952406e-02f, -3.75460042e-03f, -4.05627489e-02f, 8.92815366e-02f, -3.32893543e-02f, 1.51236191e-01f, 1.64619565e-01f, 6.40691295e-02f,
  4.63207476e-02f, 1.71538860e-01f, 1.52564928e-01f, -7.16097355e-02f, -1.26678646e-02f, -3.95600088e-02f, -9.97339040e-02f, -1.64577574e-01f, 2.50305589e-02f, 2.49426644e-02f,
  1.82441682e-01f, -9.15173814e-03f, -1.02110967e-01f, 1.05872057e-01f, -1.16205856e-01f, 2.03603227e-02f, -1.07006066e-01f, -4.91829887e-02f, 1.31517664e-01f, -8.96368474e-02f,
  -6.53403252e-03f, -4.46570441e-02f, 1.16442710e-01f, 7.26250783e-02f, 4.81097959e-02f, -1.39050139e-02f, 5.88038526e-02f, 1.45340040e-01f, 5.67557029e-02f, 1.11746319e-01f,
  1.02761298e-01f, 7.49661624e-02f, -9.50253531e-02f, -1.43948466e-01f, 4.61304039e-02f, 7.17778131e-02f, 5.62509485e-02f, 1.26116443e-02f, -1.55213654e-01f, -4.90367673e-02f,
  8.40260647e-03f, -2.93942112e-02f, 1.17376789e-01f, -2.55493131e-02f, 2.96769701e-02f, -3.09539270e-02f, 1.07038237e-01f, -3.33703347e-02f, -4.88626920e-02f, 4.41518426e-02f,
  9.32808500e-03f, 1.23824842e-01f, 3.44584696e-02f, -1.12755761e-01f, 7.50408843e-02f, 8.76893178e-02f, 6.54666349e-02f, -1.29768372e-01f, 7.24969059e-02f, 3.90170217e-02f,
  -7.96250906e-03f, -3.69270630e-02f, 1.50114760e-01f, -6.34330660e-02f, 6.55125231e-02f, 9.31802541e-02f, 3.20594222e-03f, 4.13191728e-02f, -1.05290256e-01f, -1.56429052e-01f,
  1.57046486e-02f, -6.38710111e-02f, 1.60557017e-01f, 1.82929650e-01f, 3.09633911e-02f, 1.18543185e-01f, 6.90214112e-02f, 1.44918755e-01f, 1.03305519e-01f, -3.25250179e-02f,
  -9.23602059e-02f, -2.05509420e-02f, 1.35548487e-01f, 7.42557645e-02f, -2.68595386e-02f, 1.07894710e-03f, -1.34175450e-01f, 9.75565985e-02f, 5.58507480e-02f, 9.97125655e-02f,
  -8.17847252e-02f, 9.95404795e-02f, 1.22147240e-01f, -3.71757075e-02f, 9.19964686e-02f, -1.06438980e-01f, 8.68326426e-02f, -3.07082944e-02f, 1.28198117e-01f, -1.99608225e-02f,
  3.85606475e-02f, -9.86001939e-02f, 1.11791983e-01f, -8.19031731e-04f, 1.26126975e-01f, -6.33541569e-02f, -1.89410914e-02f, -4.36112769e-02f, 6.29350990e-02f, -1.35123461e-01f,
  -4.15509529e-02f, -3.41826156e-02f, 9.14487019e-02f, 4.12374325e-02f, -5.27341962e-02f, -9.84362811e-02f, -4.99173738e-02f, 1.36033250e-02f, 4.07037586e-02f, 9.41610932e-02f,
  -2.67552696e-02f, 5.55566959e-02f, -5.21352664e-02f, 1.24707632e-01f, 4.19861190e-02f, 1.27590457e-02f, 6.93977699e-02f, -2.13217475e-02f, 6.95857545e-03f, 5.52469492e-02f,
  1.62629545e-01f, 1.82771191e-01f, -1.22964950e-02f, -4.10058387e-02f, -7.98740909e-02f, 8.11468158e-03f, 1.89980075e-01f, 8.87790546e-02f, 1.44108668e-01f, 4.32208776e-02f,
  -5.59444427e-02f, -3.00123245e-02f, 3.51446830e-02f, 1.53851286e-02f, 4.68544178e-02f, 7.88183734e-02f, 1.10047963e-02f, 7.77435899e-02f, 9.80180055e-02f, 8.73028114e-02f,
  -5.29283881e-02f, -1.52021676e-01f, -1.19976066e-01f, -6.39162064e-02f, 9.32927132e-02f, 1.17603719e-01f, 9.12898555e-02f, -5.41147718e-04f, 4.13596705e-02f, 1.92606553e-01f,
  6.29197061e-02f, 1.22879082e-02f, -1.73554849e-02f, 1.11075453e-01f, 7.16281235e-02f, 8.86647478e-02f, -1.54635474e-01f, 2.72538699e-03f, -1.37272865e-01f, -2.05101911e-02f,
  -9.81852785e-02f, -1.20335348e-01f, 6.99463263e-02f, -6.45276085e-02f, 1.32248178e-01f, -2.70686075e-02f, 3.41283306e-02f, 1.09045535e-01f, 5.12096584e-02f, 1.17694005e-01f,
  -1.14176437e-01f, -3.02262846e-02f, 1.07658610e-01f, 3.99478711e-02f, 6.95172027e-02f, -2.76491418e-02f, -3.38446014e-02f, 1.00930221e-01f, -8.71744454e-02f, 1.12095028e-01f,
  2.20295284e-02f, 1.46983996e-01f, -1.04411095e-02f, 1.04394853e-01f, 4.36190218e-02f, 1.27288520e-01f, 6.86315307e-03f, -1.69147685e-01f, 1.08386867e-01f, -8.02727938e-02f,
  1.51906744e-01f, 8.45867246e-02f, -1.68001190e-01f, 1.76084533e-01f, 3.27825658e-02f, 1.44406036e-01f, -8.67329910e-03f, 1.00712646e-02f, 5.08073084e-02f, -6.42849132e-02f,
  -1.84941124e-02f, 1.84199624e-02f, 5.03751971e-02f, 6.59147874e-02f, -5.13438024e-02f, 1.95884407e-01f, -8.97584483e-02f, 6.92770779e-02f, -8.61710683e-02f, 1.23035535e-01f,
  2.88959891e-01f, 1.41219806e-03f, -5.76650258e-03f, -1.42446265e-01f, 7.02865943e-02f, 7.65798688e-02f, 3.27842049e-02f, 1.04479939e-01f, 1.71146080e-01f, 9.53412056e-02f,
  -1.00428484e-01f, -4.49535511e-02f, 5.69383763e-02f, 1.33621022e-01f, 1.82518005e-01f, -1.31918073e-01f, -7.92576820e-02f, 4.56110537e-02f, 1.62963584e-01f, -1.07793093e-01f,
  1.01196773e-01f, 6.93101110e-03f, -6.20811172e-02f, -9.69813988e-02f, 6.32344708e-02f, -7.03130066e-02f, 1.67438805e-01f, 5.50578237e-02f, -1.88929942e-02f, 1.96031973e-01f,
  4.19991054e-02f, -6.15754686e-02f, 6.84177950e-02f, 1.19108647e-01f, -8.69156048e-03f, 2.92113237e-02f, 7.78237879e-02f, 1.41711473e-01f, -1.16026729e-01f, -4.19920459e-02f,
  -8.30943882e-02f, -1.21189989e-01f, 1.08838893e-01f, -3.55733931e-02f, -8.05805251e-02f, -8.92309919e-02f, -1.74432382e-01f, -1.72137007e-01f, -3.45498733e-02f, -1.04242750e-01f,
  -1.17581688e-01f, -1.16077110e-01f, 1.10676281e-01f, 7.43417814e-02f, 1.15132526e-01f, 1.39365509e-01f, 6.78954646e-02f, 2.30272003e-02f, -4.49506603e-02f, 2.06550434e-01f,
  1.49185032e-01f, 1.06044844e-01f, -2.80138422e-02f, 9.51181352e-02f, -2.13992205e-02f, -1.61244795e-02f, -1.20571390e-01f, 4.59138341e-02f, -5.60766347e-02f, -3.24709378e-02f,
  2.48537250e-02f, 1.02199644e-01f, -3.74740027e-02f, -7.56530389e-02f, 1.51679769e-01f, -1.14409842e-01f, 5.24509214e-02f, 1.19188696e-01f, -8.28468576e-02f, 9.28303078e-02f,
  -8.23018253e-02f, 3.38181704e-02f, -5.32473586e-02f, 1.11704268e-01f, -9.56356898e-02f, -3.77085209e-02f, 1.52819660e-02f, 6.14530705e-02f, -7.65109062e-02f, 1.88689962e-01f,
  -2.10666563e-02f, -5.18315323e-02f, -1.16124600e-01f, -3.16584073e-02f, 1.95507724e-02f, -1.27444252e-01f, 6.59956597e-03f, -8.93848687e-02f, 2.10659839e-02f, -7.85090178e-02f,
  -1.93827730e-02f, -3.59975956e-02f, -3.00305337e-02f, -8.01874921e-02f, -6.40969276e-02f, 8.41649920e-02f, -2.34143920e-02f, -1.09982975e-01f, -6.72032237e-02f, -7.30345920e-02f,
  -1.77228556e-03f, -3.59674171e-02f, -7.17430562e-02f, -1.57055873e-02f, 1.28306523e-02f, -7.80937895e-02f, -2.39540301e-02f, -1.17707551e-01f, -8.39706138e-02f, 3.30521390e-02f,
  9.68167856e-02f, 1.17104724e-01f, -7.18913972e-02f, 1.72996204e-02f, -1.27347335e-01f, 5.50280660e-02f, -1.03315584e-01f, 4.51273918e-02f, 2.81550568e-02f, 6.07978702e-02f,
  -1.10462353e-01f, -6.63578659e-02f, 1.20248906e-01f, 1.09740108e-01f, 1.59841236e-02f, -7.11002499e-02f, 3.48054469e-02f, -4.15717326e-02f, -8.22439939e-02f, -7.00729564e-02f,
  -1.12001430e-02f, -1.09926667e-02f, 1.28889754e-01f, -1.25894278e-01f, 5.39381467e-02f, -7.39852041e-02f, -5.07296883e-02f, 1.08951733e-01f, 5.48084453e-02f, 9.59993899e-02f,
  7.73649961e-02f, -1.01694278e-01f, 4.96206544e-02f, -4.96183299e-02f, -4.46868762e-02f, -7.59595633e-02f, -7.63610005e-03f, 1.10152103e-01f, 1.19166501e-01f, 8.55113491e-02f,
  9.37548727e-02f, 8.98272097e-02f, 1.14708580e-01f, 1.08160404e-02f, -3.95148769e-02f, 1.03223056e-01f, 1.29872516e-01f, -1.06965877e-01f, -1.26820832e-01f, -3.01025417e-02f,
  1.06458567e-01f, -5.45110926e-03f, 6.35708123e-02f, 4.70830686e-02f, 1.99762374e-01f, 9.95395705e-02f, 1.40896654e-02f, -1.86392646e-02f, -3.71724814e-02f, -2.21087374e-02f,
  5.22207208e-02f, -3.14411707e-02f, 3.59501690e-02f, 3.21564004e-02f, -2.01366004e-03f, -1.56270191e-02f, 6.84040114e-02f, 3.22394706e-02f, -1.30182654e-01f, 8.81268904e-02f,
  -4.90509979e-02f, 4.56137694e-02f, 1.62646711e-01f, 7.69886449e-02f, -2.10905346e-04f, 5.93497977e-02f, -1.28669925e-02f, 1.51650667e-01f, 1.10025756e-01f, -8.30062777e-02f,
  -1.63276587e-02f, -8.01585540e-02f, 3.77912894e-02f, -1.05803646e-01f, 2.45306012e-03f, -6.37014210e-02f, 2.11673100e-02f, 6.63548484e-02f, -8.45420137e-02f, 6.28543720e-02f,
  1.47127688e-01f, -9.31920782e-02f, -4.85596806e-02f, -6.03976659e-03f, 8.24803784e-02f, 6.47503063e-02f, -9.75403786e-02f, 1.91513114e-02f, -8.88069049e-02f, 4.78628725e-02f,
  -5.37482686e-02f, 1.24869794e-01f, 4.60305177e-02f, 8.27844143e-02f, 3.89152989e-02f, 1.49365097e-01f, 7.52094314e-02f, 1.14511713e-01f, -9.11066588e-03f, 1.49642467e-01f,
  8.28173533e-02f, 1.85789809e-01f, -1.37230352e-01f, 7.19328076e-02f, -8.13127682e-02f, 1.48916066e-01f, 4.82079610e-02f, 1.62187546e-01f, 5.77153191e-02f, 1.22210860e-01f,
  -8.73257127e-03f, 7.42465332e-02f, 2.37371437e-02f, -9.72128361e-02f, -1.50579870e-01f, -4.17499505e-02f, -1.07531033e-01f, 1.24999501e-01f, -9.90689471e-02f, -2.17094887e-02f,
  5.20887645e-03f, 3.62520181e-02f, 2.00024284e-02f, 3.23668122e-02f, -2.40520425e-02f, 9.82626006e-02f, 1.68795496e-01f, -1.49803028e-01f, 6.50983211e-03f, 1.11304909e-01f,
  -5.55081777e-02f, 5.11599593e-02f, 1.26786411e-01f, 1.39474988e-01f, 1.29944384e-01f, 2.33312361e-02f, 4.36023585e-02f, 9.48098525e-02f, 1.14126414e-01f, 7.67235532e-02f,
  -7.28784874e-03f, -1.02127433e-01f, -1.25546545e-01f, -9.82226878e-02f, 5.39329601e-03f, -6.60848096e-02f, -5.96013330e-02f, 1.52698815e-01f, -4.86708470e-02f, 6.39835745e-02f,
  -6.85048401e-02f, 4.79942299e-02f, 2.95013458e-01f, 2.54545093e-01f, 1.38188422e-01f, 2.49655649e-01f, -1.63321495e-01f, 9.69120068e-04f, 2.77792901e-01f, 1.30996555e-01f,
  1.19488217e-01f, 1.39636636e-01f, 2.21554130e-01f, 2.12030053e-01f, -2.08075628e-01f, 2.13184804e-01f, 2.63713747e-01f, 1.91404000e-02f, -2.95639843e-01f, 1.03792764e-01f,
  8.47101957e-03f, -1.42455176e-01f, 7.06960484e-02f, 5.14004529e-02f, -1.16256408e-01f, 2.35718340e-01f, -1.08959965e-01f, 8.20430294e-02f, 1.07825309e-01f, 1.30109945e-02f,
  -4.42932621e-02f, 2.53264815e-01f, 1.41438022e-01f, -8.60422198e-03f, -9.83580351e-02f, -4.84960787e-02f, 1.46786481e-01f, 1.69567555e-01f, 1.87742636e-01f, 2.01273248e-01f,
  1.60668924e-01f, 1.01994947e-01f, 2.15699598e-02f, 2.17112124e-01f, -8.70195553e-02f, 1.37694955e-01f, 1.52057735e-02f, 1.74339518e-01f, 9.81669798e-02f, -1.16114996e-01f,
  -2.93761864e-02f, 2.48079915e-02f, 1.61788151e-01f, -6.85955882e-02f, -2.08487079e-01f, 9.72498879e-02f, 1.79881439e-01f, 1.24015354e-01f, -7.07958918e-03f, -5.66117242e-02f,
  3.15155610e-02f, 1.63559586e-01f, 7.41867423e-02f, -1.82050490e-03f, 1.69435125e-02f, 2.27175970e-02f, 8.83069485e-02f, 2.23828673e-01f, 1.15311988e-01f, -6.44443417e-03f,
  -2.32560128e-01f, 1.33944675e-01f, 2.48083815e-01f, 9.63257551e-02f, 2.03565970e-01f, 9.26423445e-02f, 6.18865602e-02f, 2.41639107e-01f, -1.13081582e-01f, 2.36297488e-01f,
  2.33211920e-01f, 1.61120296e-01f, -4.07744348e-01f, -3.75062935e-02f, 5.19311391e-02f, -6.45622537e-02f, 2.17436045e-01f, 1.97570592e-01f, -5.25826663e-02f, 2.26748511e-01f,
  -2.54460629e-02f, 1.15585685e-01f, -1.14729591e-01f, 1.53546944e-01f, -6.33220654e-03f, 2.13590890e-01f, 1.86810017e-01f, -1.58201214e-02f, 1.20450221e-02f, -1.91381112e-01f,
  2.04783455e-02f, 1.72329530e-01f, 1.25079244e-01f, 1.48724496e-01f, 2.14163601e-01f, 2.19209313e-01f, 6.49482608e-02f, 2.93040991e-01f, 4.44383314e-03f, 1.25550941e-01f,
  -4.04192209e-02f, 9.50217694e-02f, -8.33262205e-02f, 2.14311600e-01f, -3.45449112e-02f, 2.10306942e-02f, -7.10574677e-04f, -5.84708564e-02f, -1.69782847e-01f, -4.66381945e-02f,
  1.17335439e-01f, 3.22034061e-02f, -1.28300274e-02f, -1.27220061e-02f, -1.29808888e-01f, 2.55018204e-01f, -3.48870084e-02f, 2.06867278e-01f, -1.27448499e-01f, -4.61901650e-02f,
  7.62652084e-02f, 7.19365254e-02f, 1.33009151e-01f, 4.35991585e-02f, 2.04254508e-01f, 1.91570014e-01f, 1.81805417e-01f, 1.78043455e-01f, 1.52883500e-01f, 6.41523823e-02f,
  8.63443241e-02f, 6.83547705e-02f, 6.94997201e-04f, -7.11542591e-02f, -1.58592105e-01f, -2.30709866e-01f, 1.68473452e-01f, -1.34619355e-01f, 3.17150652e-02f, 1.04218259e-01f,
  -2.79463559e-01f, -1.77753985e-01f, -9.83240083e-02f, 2.28584275e-01f, 3.70068289e-02f, 8.61440450e-02f, -7.72734508e-02f, 3.11303288e-02f, 7.38229677e-02f, 5.91528453e-02f,
  6.60741627e-02f, 1.01706237e-01f, 4.61227447e-03f, 3.61054003e-01f, 1.24924798e-02f, 1.45146132e-01f, -3.30693796e-02f, 1.77842036e-01f, 9.48081985e-02f, -4.66767363e-02f,
  -2.95176841e-02f, -1.86410338e-01f, 5.40408911e-03f, -1.05340071e-01f, -4.31128591e-02f, 3.73700336e-02f, 9.43106115e-02f, -1.48560375e-01f, 6.09354675e-02f, -2.97672069e-03f,
  3.09755858e-02f, -3.81857343e-02f, -2.97232922e-02f, 1.18990049e-01f, -6.37447834e-02f, -1.03862621e-01f, -1.44453719e-01f, -1.06480308e-01f, 4.95149232e-02f, 2.36331016e-01f,
  8.28629658e-02f, -9.88382250e-02f, 1.13791794e-01f, 1.56178579e-01f, -6.10108413e-02f, 8.28792080e-02f, -4.59249318e-02f, -4.54193540e-02f, -4.97567002e-03f, 8.31854641e-02f,
  8.15304741e-03f, 7.39593655e-02f, 8.46855864e-02f, -2.13400312e-02f, 1.21867612e-01f, 5.77418022e-02f, 1.42559618e-01f, -1.91422597e-01f, -1.72102135e-02f, -3.13549303e-02f,
  1.76871970e-01f, -7.69870058e-02f, 1.47214621e-01f, 1.17628790e-01f, -1.12472937e-01f, -1.29449993e-01f, -1.26465395e-01f, -1.01320781e-01f, -9.20845643e-02f, -1.05089605e-01f,
  8.56784210e-02f, 1.05603166e-01f, 1.53627351e-01f, -1.10898949e-01f, -8.10557529e-02f, -1.32960707e-01f, -1.24324553e-01f, 2.88509399e-01f, -1.08224370e-01f, 6.34838715e-02f,
  4.53856401e-02f, -2.58553140e-02f, -1.17277071e-01f, -1.37023836e-01f, -2.94234995e-02f, 1.05040491e-01f, 2.23807488e-02f, -1.49612337e-01f, -1.00406751e-01f, -1.01309218e-01f,
  -5.84340803e-02f, -8.33298936e-02f, -1.16086401e-01f, -1.87222157e-02f, 3.54702882e-02f, 7.01781288e-02f, 1.08490989e-01f, 4.41433229e-02f, -4.79923524e-02f, 3.95288542e-02f,
  2.55257245e-02f, -5.22253402e-02f, -2.27648374e-02f, -1.22041412e-01f, -2.81758513e-02f, -6.16443902e-03f, 6.49933331e-03f, -1.26535401e-01f, -4.06428799e-02f, 1.22354031e-01f,
  -8.82777944e-02f, -9.25110132e-02f, 1.86719112e-02f, -6.90691993e-02f, -2.02228781e-02f, 3.01703662e-02f, 3.09669971e-02f, 2.46020854e-02f, 6.64942637e-02f, -2.29804106e-02f,
  1.34330750e-01f, 6.30082116e-02f, -1.10234849e-01f, -1.16937369e-01f, 1.25471175e-01f, 8.14779773e-02f, -6.63854834e-03f, 1.46692574e-01f, 7.51692578e-02f, 6.48010820e-02f,
  1.27658844e-02f, 1.14674516e-01f, 6.81756660e-02f, 8.93304944e-02f, -4.98887226e-02f, 1.04273751e-01f, -4.41173371e-03f, 5.58146164e-02f, -4.30471748e-02f, 7.25916028e-02f,
  3.12660672e-02f, 4.83596697e-02f, -6.76374696e-03f, -1.24369912e-01f, -4.14688215e-02f, -1.02907561e-01f, 6.72131032e-02f, -6.27416149e-02f, 1.19476400e-01f, 6.56576976e-02f,
  -3.46432975e-03f, -1.49445068e-02f, 6.56866804e-02f, -1.24877475e-01f, -1.07809631e-02f, 1.55891076e-01f, -6.40013218e-02f, 6.35799319e-02f, -4.26808596e-02f, -6.47181571e-02f,
  1.00834658e-02f, -4.84776460e-02f, -1.18373349e-01f, 7.76648968e-02f, 1.40280902e-01f, -7.53696635e-02f, 1.12980887e-01f, -3.91358435e-02f, -6.72760084e-02f, -5.11740595e-02f,
  -7.10825324e-02f, 7.61753693e-02f, 3.67016047e-02f, 4.12483551e-02f, 3.43728699e-02f, 7.96179567e-03f, 3.29656363e-03f, 1.42863110e-01f, -4.44232188e-02f, 2.63145044e-02f,
  4.60867025e-02f, 7.13291466e-02f, 3.92609462e-02f, 1.17262095e-01f, -2.67295614e-02f, 8.15926585e-03f, 7.76340216e-02f, -1.28492955e-02f, 1.72442272e-02f, 1.07811198e-01f,
  -1.26509652e-01f, -1.67177856e-01f, -1.32018730e-01f, -2.50248733e-04f, -2.19027586e-02f, -1.56494528e-02f, 1.03365199e-03f, 7.98519701e-03f, -8.65319893e-02f, 5.07142534e-03f,
  2.56525073e-03f, 6.91137984e-02f, 6.87025189e-02f, -7.04671741e-02f, -3.80026698e-02f, 8.28574747e-02f, 1.63664147e-01f, -2.75608059e-02f, 1.23408705e-01f, 3.94890904e-02f,
  -1.32954288e-02f, -9.81470495e-02f, -9.88917872e-02f, 4.61584590e-02f, -9.10162926e-02f, -1.26062967e-02f, -1.19470954e-01f, -3.73178022e-03f, -1.37349412e-01f, -3.31453234e-03f,
  1.67064548e-01f, 7.58277774e-02f, -8.58587548e-02f, 2.17205249e-02f, -4.39069234e-03f, 5.20251170e-02f, -7.60395005e-02f, 1.63768139e-02f, 7.70640075e-02f, -9.51263905e-02f,
  -1.00571156e-01f, -1.02671996e-01f, 3.83187197e-02f, 1.13564625e-01f, 1.53801307e-01f, 9.86590534e-02f, -4.20093387e-02f, 1.32036418e-01f, 8.47070962e-02f, 1.36171773e-01f,
  1.52700797e-01f, 1.69675220e-02f, 1.05157278e-01f, 9.26178619e-02f, 5.73325641e-02f, 1.36689588e-01f, 2.60080257e-03f, -1.50734596e-02f, -1.90797658e-03f, -1.60403192e-01f,
  -1.29387468e-01f, 1.87207878e-01f, -7.55236745e-02f, -5.39003201e-02f, 4.64108475e-02f, -6.33593574e-02f, -1.90054569e-02f, 3.10713463e-02f, 8.89943987e-02f, -1.55311823e-01f,
  1.14363939e-01f, -1.13099366e-01f, -1.12385847e-01f, 4.66851331e-02f, -9.32112187e-02f, -1.57668114e-01f, 4.09169309e-02f, -3.93487811e-02f, 7.44177029e-02f, 2.35334132e-02f,
  2.97584347e-02f, 4.85159345e-02f, -5.57714514e-02f, -5.05238250e-02f, -8.87490138e-02f, -4.98339161e-02f, 8.56447741e-02f, 2.15965733e-01f, -3.58665250e-02f, 1.40886441e-01f,
  4.52695787e-02f, -1.26263157e-01f, 9.67975035e-02f, 9.82441828e-02f, -1.59468994e-01f, -1.02400236e-01f, -7.94202685e-02f, -9.03447792e-02f, -4.72653843e-02f, 7.63548985e-02f,
  -6.84849024e-02f, 1.12241462e-01f, 3.26505564e-02f, -1.11122437e-01f, 2.49723252e-02f, 7.37684369e-02f, 7.71578774e-02f, 9.66372564e-02f, -6.88568801e-02f, -1.29490465e-01f,
  7.34188706e-02f, -1.57271028e-02f, 1.72594190e-02f, 1.99081302e-01f, 2.27995738e-01f, 1.22899078e-01f, 1.36193007e-01f, 8.96338746e-02f, 1.37068897e-01f, -1.32626025e-02f,
  1.27928838e-01f, 1.47717297e-01f, 2.49065578e-01f, -2.22358257e-01f, -1.80135131e-01f, -4.82647680e-02f, 1.18929036e-01f, -1.32343173e-01f, 7.12730363e-02f, 2.19957978e-02f,
  -1.02804072e-01f, -1.62707940e-01f, 1.34820953e-01f, -8.57092664e-02f, 2.69466154e-02f, 7.51626268e-02f, 5.72400168e-02f, -6.33925349e-02f, 1.37878850e-01f, -3.53203602e-02f,
  -3.87578979e-02f, -2.39361469e-02f, 4.45989221e-02f, 9.46040303e-02f, -1.96516663e-02f, -1.00844383e-01f, -9.79133099e-02f, 8.74425396e-02f, -2.07837507e-01f, -6.85259625e-02f,
  1.07954562e-01f, 1.94265485e-01f, -1.78788621e-02f, -7.20580816e-02f, -1.04138747e-01f, -1.19993076e-01f, -6.89822435e-02f, 1.01148851e-01f, -1.68809518e-01f, -8.93651918e-02f,
  -7.65674263e-02f, 6.81994706e-02f, -1.62850544e-02f, 1.43258516e-02f, -9.32185724e-02f, -7.16216415e-02f, -9.66997594e-02f, -9.70255882e-02f, 2.45696995e-02f, -1.54117271e-02f,
  -1.11963987e-01f, -7.33737322e-03f, -1.27433717e-01f, -5.14708459e-03f, -2.54971236e-02f, -2.25451421e-02f, -4.44964506e-02f, -7.48471990e-02f, 4.61372472e-02f, 5.14495559e-03f,
  -4.29259390e-02f, 3.11918631e-02f, 1.60258219e-01f, 1.05089499e-02f, 4.61689606e-02f, 3.43633146e-04f, -6.32742122e-02f, 1.47717252e-01f, -3.35804140e-03f, 5.97580411e-02f,
  -1.86776057e-01f, 1.96912941e-02f, -5.57357725e-03f, -3.73659469e-02f, -9.58260372e-02f, 2.12658241e-01f, -7.42883831e-02f, 1.23840585e-01f, -6.35497347e-02f, 1.24990165e-01f,
  -1.27532482e-01f, -1.35213614e-01f, 7.86971673e-02f, 1.77982897e-01f, -2.79310159e-02f, -4.55672331e-02f, -2.02264152e-02f, -4.95111905e-02f, -8.90478119e-03f, 2.22699679e-02f,
  -8.74634013e-02f, 1.02661930e-01f, 2.28072658e-01f, -7.93693513e-02f, -9.70489606e-02f, 8.27519149e-02f, -5.06318323e-02f, 4.52322885e-02f, 1.53428659e-01f, 1.18734483e-02f,
  1.81904674e-01f, 6.40014932e-02f, 9.50484499e-02f, 1.02196150e-01f, 2.17377618e-02f, -7.99996257e-02f, 1.38296679e-01f, -8.64321142e-02f, -6.70475587e-02f, -8.28041434e-02f,
  -3.81236747e-02f, -2.21893191e-02f, 2.82674842e-02f, 9.43510234e-02f, -3.94516140e-02f, -3.72577086e-02f, -1.07979126e-01f, 2.44302712e-02f, 1.06696464e-01f, 2.04493105e-01f,
  2.48188213e-01f, 2.69321144e-01f, 3.10842693e-01f, 4.78224419e-02f, 1.75062239e-01f, 2.16953859e-01f, 2.27255106e-01f, 1.56406194e-01f, 3.01059693e-01f, 6.75141439e-02f,
  1.94625676e-01f, -1.66618720e-01f, 4.79526371e-02f, 2.15147689e-01f, 1.26962187e-02f, 1.37137383e-01f, -5.39051145e-02f, -1.20430619e-01f, 7.38765486e-03f, -1.86080307e-01f,
  2.05697596e-01f, -2.81468481e-01f, -1.17549479e-01f, -1.43714994e-01f, 7.58626238e-02f, 5.43646924e-02f, 1.19142585e-01f, -9.17638168e-02f, -4.13516909e-02f, -1.34483799e-01f,
  1.55314803e-01f, 2.15478629e-01f, 9.43321660e-02f, -2.73878071e-02f, -4.33030650e-02f, 7.31917024e-02f, -1.64293185e-01f, 1.56797290e-01f, 6.37559369e-02f, 3.99216831e-01f,
  3.33867706e-02f, 1.62774339e-01f, -8.83311778e-02f, -1.64549828e-01f, 6.56365901e-02f, 1.12610959e-01f, -1.12072244e-01f, -1.13446563e-01f, -3.74182202e-02f, 6.57607242e-02f,
  -5.26322089e-02f, -7.07225502e-02f, -7.66323283e-02f, -9.36834514e-02f, 1.56203285e-01f, 4.40022722e-02f, 9.29050706e-03f, -1.61522776e-01f, 1.08117789e-01f, 3.52636464e-02f,
  -6.90002367e-02f, -7.18690306e-02f, -5.87754212e-02f, 2.07682364e-02f, 5.26563823e-02f, 9.69767198e-02f, 2.04691477e-02f, 2.23773196e-02f, -5.35924127e-03f, -1.02846488e-01f,
  -4.40241322e-02f, -1.05624042e-01f, -5.01172096e-02f, 4.34213754e-04f, 1.16505168e-01f, -2.85933483e-02f, 3.32807451e-02f, 9.81928259e-02f, 7.34882429e-02f, -4.57833745e-02f,
  -1.60887793e-01f, 1.24896760e-03f, -1.33476675e-01f, -7.62801543e-02f, 1.04635701e-01f, -1.95181787e-01f, 1.21101141e-01f, 2.62299962e-02f, 7.11801723e-02f, 1.04064941e-01f,
  4.52347472e-03f, -9.69535578e-03f, -4.73015308e-02f, -7.92579725e-02f, -1.14793964e-02f, 7.97442496e-02f, 4.18257415e-02f, 1.99559834e-02f, 1.17414415e-01f, -1.32612213e-01f,
  -9.36627686e-02f, 1.50510250e-02f, 7.77193233e-02f, 1.36667090e-02f, -1.81121693e-03f, 1.79229170e-01f, 8.23301449e-02f, 3.33096273e-03f, -5.06410450e-02f, 7.34201893e-02f,
  -2.70959437e-02f, 4.88238186e-02f, -1.44332303e-02f, 1.57892495e-01f, -1.00893937e-01f, 5.95141836e-02f, 1.48568535e-02f, -3.11102085e-02f, -4.31424044e-02f, -6.27451949e-03f,
  -2.43412750e-03f, -7.22142607e-02f, -7.29950443e-02f, 6.41202480e-02f, -1.69265233e-02f, -2.94617787e-02f, -1.33682221e-01f, -9.92629156e-02f, -2.84744781e-02f, 3.89650911e-02f,
  -6.71430379e-02f, 3.17607298e-02f, 2.62108333e-02f, 1.06054440e-01f, -9.63710248e-02f, 1.13704046e-02f, -2.57450175e-02f, -4.05858718e-02f, -4.23147045e-02f, 7.84104094e-02f,
  1.24446847e-01f, -1.06961682e-01f, 5.36585972e-02f, -4.61267903e-02f, 6.16605841e-02f, 1.02612413e-01f, 1.46482095e-01f, 1.06986657e-01f, -9.43997577e-02f, -3.20610851e-02f,
  5.29933115e-03f, 9.05290395e-02f, -1.20182559e-01f, -3.60640921e-02f, -9.54271927e-02f, 1.20236829e-01f, -9.74608660e-02f, -4.62232763e-03f, -1.83386784e-02f, -1.28593251e-01f,
  -9.83931199e-02f, -1.31655922e-02f, 6.62743896e-02f, 9.23945755e-02f, 6.84231669e-02f, 4.85927649e-02f, 5.22275642e-02f, 3.45321633e-02f, -1.04105227e-01f, 1.16019666e-01f,
  -1.17652848e-01f, 3.52871902e-02f, -1.05162591e-01f, 1.07260004e-01f, 8.44462216e-02f, -7.59014338e-02f, 3.25662494e-02f, -8.29370990e-02f, 3.80154513e-02f, 1.01068564e-01f,
  -9.23392251e-02f, 1.77833065e-03f, 3.65665443e-02f, -3.52235697e-02f, -9.26882848e-02f, -1.26070129e-02f, 2.40014829e-02f, -1.79875065e-02f, -6.72105476e-02f, -3.37572768e-02f,
  -1.44561023e-01f, 1.09295972e-01f, 1.36318924e-02f, 1.15195595e-01f, 5.05852997e-02f, 1.54186472e-01f, -3.47176939e-02f, 1.44331306e-01f, -4.48600249e-03f, -5.35871983e-02f,
  1.10787369e-01f, -4.19341698e-02f, 1.77499563e-01f, 2.51971534e-03f, -6.19549900e-02f, 1.77025825e-01f, 7.82603621e-02f, 2.64913272e-02f, 1.86076432e-01f, 1.31472549e-03f,
  1.40700772e-01f, 1.52829096e-01f, -2.26881239e-03f, -1.60284460e-01f, 3.01364977e-02f, 1.03655823e-01f, 7.82522112e-02f, 6.24125116e-02f, 5.21705896e-02f, -4.94697317e-02f,
  8.61914679e-02f, -1.10789739e-01f, -5.66859692e-02f, -1.09220743e-02f, -5.85576519e-02f, -1.36549100e-01f, 2.55929511e-02f, 7.93785527e-02f, 8.33079070e-02f, -7.55398348e-02f,
  1.36377096e-01f, 2.45949388e-01f, 1.08010441e-01f, 1.34486422e-01f, 1.49297109e-02f, -2.31321193e-02f, 4.99703027e-02f, 2.05605701e-01f, -1.40012726e-01f, -8.26106966e-02f,
  -1.41458839e-01f, -1.35224611e-01f, 9.57925990e-02f, -1.06184766e-01f, -4.42774333e-02f, 9.17297080e-02f, 1.33566484e-01f, -3.25181819e-02f, -3.58164608e-02f, -1.15511864e-01f,
  5.14522344e-02f, 2.90652253e-02f, -3.10958531e-02f, 5.97635955e-02f, 1.16835199e-01f, 2.33227476e-01f, -2.24911030e-02f, -1.60646625e-02f, 7.71056255e-03f, 1.54050484e-01f,
  -4.38321680e-02f, 2.34318644e-01f, 6.44274950e-02f, 9.77138951e-02f, 1.26295537e-01f, 5.22684399e-03f, 7.01178610e-02f, -4.01514098e-02f, 3.41957659e-02f, -2.82106280e-01f,
  -2.23628208e-01f, -4.67711911e-02f, 2.42934480e-01f, 4.67753485e-02f, 2.35733911e-02f, 2.03974336e-01f, -4.39980142e-02f, 2.63547927e-01f, -1.43126443e-01f, 1.18645735e-01f,
  -1.57350525e-01f, 1.42344534e-01f, 4.17902730e-02f, 1.60151780e-01f, -7.33156875e-02f, -4.06382456e-02f, 1.10078931e-01f, -1.60203297e-02f, 1.51656326e-02f, 1.55527815e-01f,
  6.97055757e-02f, 1.22634947e-01f, 2.37896815e-01f, 1.08213529e-01f, -5.73944412e-02f, -4.94911708e-02f, -1.09308384e-01f, 5.83707355e-02f, 2.00492442e-01f, 1.11677058e-01f,
  1.52771592e-01f, 1.18610911e-01f, 5.78976385e-02f, 4.28335257e-02f, -2.04972066e-02f, -1.53854564e-02f, 6.44828156e-02f, -1.16139159e-01f, 9.87390205e-02f, 1.53824529e-02f,
  -1.04758749e-02f, -1.40245333e-01f, -4.87301648e-02f, 2.89325118e-01f, -3.08528617e-02f, 1.33531183e-01f, -9.92600694e-02f, -1.30981490e-01f, -7.16707809e-03f, 1.65993664e-02f,
  3.86520289e-02f, -6.55055642e-02f, 6.19557872e-02f, 6.18953481e-02f, -8.62819329e-02f, -4.00028788e-02f, -8.45988169e-02f, -1.29496291e-01f, 7.61192292e-02f, 1.89691633e-02f,
  -4.98813353e-02f, 2.00257525e-02f, 2.35899072e-02f, 1.32322207e-01f, 4.87424769e-02f, -7.53513873e-02f, 1.78758916e-03f, 1.26845539e-02f, 1.20423950e-01f, 6.81569986e-03f,
  1.19068921e-01f, -9.37902555e-02f, 1.00472514e-02f, -2.38673273e-03f, -1.19920924e-01f, -6.70692045e-03f, 6.73440173e-02f, -7.40134865e-02f, -3.18314880e-02f, -1.05729982e-01f,
  -3.61877121e-02f, -9.08254609e-02f, 1.35773942e-01f, -2.59422064e-02f, 8.76065120e-02f, 5.40518053e-02f, 1.97768845e-02f, 3.81142274e-02f, -7.32277110e-02f, -2.21334584e-02f,
  9.13304742e-03f, 2.86341589e-02f, -8.54060352e-02f, 5.32038547e-02f, 9.23183560e-02f, -7.38580450e-02f, 2.30002180e-02f, 3.53120193e-02f, -2.36222381e-03f, 2.27105673e-02f,
  2.74272636e-02f, 7.66820684e-02f, -8.54693800e-02f, -1.26693532e-01f, 7.42336561e-04f, 6.80250376e-02f, 6.06463738e-02f, -6.64085895e-02f, 4.10776325e-02f, 3.92133407e-02f,
  -6.21964261e-02f, 3.15751098e-02f, 1.88240901e-01f, 3.43683697e-02f, 1.22363821e-01f, 1.98696420e-01f, -3.62543352e-02f, -8.72762036e-03f, -1.22599620e-02f, -6.93882257e-02f,
  -1.13284402e-02f, 9.10127535e-02f, -1.79657862e-02f, 4.30415906e-02f, 4.01312597e-02f, -1.06408313e-01f, -4.82356362e-02f, -6.92379102e-03f, -1.19239666e-01f, 1.59831271e-01f,
  -1.79667190e-01f, -8.41688812e-02f, -1.90709997e-02f, 1.57981925e-02f, 7.44599178e-02f, -7.07150698e-02f, -9.92226601e-02f, 8.44629258e-02f, 4.29281555e-02f, -4.80157062e-02f,
  -7.91772455e-02f, 1.01289548e-01f, 5.90544343e-02f, -2.98335571e-02f, 6.49650022e-02f, -9.78937298e-02f, -5.37301674e-02f, 9.02685821e-02f, 1.50136380e-02f, -3.63763832e-02f,
  -1.06314030e-02f, -3.79008688e-02f, -1.49727212e-02f, 1.23738661e-01f, 7.85136372e-02f, 1.99588329e-01f, 4.62159477e-02f, -1.04024351e-01f, 1.01191536e-01f, 8.20566639e-02f,
  -4.66588996e-02f, 1.11457761e-02f, 5.89775434e-03f, 8.45399722e-02f, -8.53664428e-02f, 1.23742901e-01f, 8.48069414e-02f, 7.91237503e-02f, -7.02114543e-03f, -8.28480721e-02f,
  1.09707586e-01f, -6.29743263e-02f, 4.19523232e-02f, -8.06674138e-02f, 2.66863890e-02f, 1.13877565e-01f, 2.59503186e-01f, 9.21520814e-02f, 1.50041580e-01f, 1.86825797e-01f,
  1.16817780e-01f, 1.71777964e-01f, 8.54896978e-02f, 6.95847347e-02f, 1.84455499e-01f, 8.24978203e-02f, 1.78678691e-01f, 1.25638351e-01f, -1.39661580e-01f, -1.32910013e-01f,
  -5.21020330e-02f, 1.32469878e-01f, -3.78509685e-02f, -9.05160904e-02f, 4.80921380e-02f, -5.16184047e-02f, 8.25127494e-03f, -2.40536153e-01f, 2.22128510e-04f, -1.21839911e-01f,
  -1.13372669e-01f, -1.13642097e-01f, 7.17415512e-02f, -2.30482332e-02f, -1.05732396e-01f, 1.64029762e-01f, 1.41575485e-01f, -1.41445637e-01f, 9.06310752e-02f, 1.32831901e-01f,
  1.67256296e-01f, -3.53694223e-02f, 7.06218854e-02f, -8.72970149e-02f, -5.44502474e-02f, 6.36274144e-02f, -6.13912977e-02f, 1.75583258e-01f, 1.09833889e-01f, 1.91644713e-01f,
  -1.48683026e-01f, 1.36302024e-01f, 4.88999858e-02f, -1.10708013e-01f, -4.16488312e-02f, 9.14921239e-02f, 1.37419999e-01f, 1.98553100e-01f, -1.38690650e-01f, 1.56656712e-01f,
  2.06188522e-02f, -2.67166775e-02f, 1.73338372e-02f, -1.72295198e-02f, -5.10875173e-02f, -3.75538990e-02f, 1.04275286e-01f, 4.01495397e-02f, 1.97192393e-02f, 1.82583407e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 40)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 40;
const float L2_fan_Bp_bar_data[] = {
  7.55136460e-02f, -6.67477772e-02f, -6.98598325e-02f, -2.02400554e-02f, 9.04570520e-02f, -1.01081565e-01f, -9.74396020e-02f, 2.97168475e-02f, 9.42636952e-02f, 1.88833266e-01f,
  -1.03972420e-01f, -3.90580185e-02f, 1.88371256e-01f, 4.54813316e-02f, 6.78303614e-02f, 1.51915014e-01f, -1.14497985e-03f, 3.44946720e-02f, 1.57757193e-01f, 7.74168819e-02f,
  -1.19358808e-01f, -3.90962400e-02f, 9.02118459e-02f, 9.32824761e-02f, 1.50989294e-01f, 1.43382311e-01f, 1.72279641e-01f, -4.92205396e-02f, 1.26452416e-01f, 5.80135509e-02f,
  1.81789607e-01f, 9.65237096e-02f, 2.22511411e-01f, 8.96550715e-02f, -1.03752546e-01f, 9.69191641e-02f, 5.24083711e-02f, -1.15793191e-01f, 5.06693199e-02f, 9.76985842e-02f
};

// L3_fan_Wp (Shape: 12 x 64)
const int L3_fan_Wp_rows = 12;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  -5.55661395e-02f, 5.04717603e-02f, 4.74139713e-02f, 3.15679028e-03f, 1.59753725e-01f, 1.97646096e-02f, 1.15727931e-01f, -4.84326482e-02f, 6.96692914e-02f, -1.72778204e-01f,
  8.14879462e-02f, 5.01174815e-02f, -1.19677678e-01f, -3.10525775e-01f, -2.12132633e-02f, 1.46440163e-01f, -3.80795151e-01f, 2.06581116e-01f, 2.26499662e-02f, 8.22140798e-02f,
  -1.51730567e-01f, 1.11558437e-01f, 1.23006597e-01f, 9.75153446e-02f, 1.50243551e-01f, 9.98050049e-02f, -1.42953515e-01f, 3.82426940e-02f, 6.19953573e-02f, 1.06675111e-01f,
  6.16545975e-02f, 8.07769671e-02f, -1.77383676e-01f, -1.98656678e-01f, 1.41444191e-01f, 6.56443015e-02f, 1.66166037e-01f, 9.23740566e-02f, 5.06025068e-02f, -9.19536948e-02f,
  -8.81395191e-02f, -7.48526081e-02f, 7.26094246e-02f, -3.26812416e-02f, -1.05880229e-02f, 8.21339339e-02f, 1.39513567e-01f, 4.28796820e-02f, 7.57493302e-02f, -2.56049316e-02f,
  -1.62055016e-01f, -1.04965456e-02f, 8.23784024e-02f, 2.15586387e-02f, -7.40452334e-02f, 2.37493608e-02f, 1.23865284e-01f, 1.11577295e-01f, -2.48864144e-02f, -2.87510827e-02f,
  -1.99773878e-01f, 4.44909073e-02f, 1.08961731e-01f, 2.54957154e-02f, -1.35494858e-01f, -1.32966071e-01f, -2.43883003e-02f, -2.34019272e-02f, -9.79369432e-02f, 2.23948117e-02f,
  -3.84762138e-02f, 9.41568464e-02f, -7.74545744e-02f, 1.49017125e-01f, 6.64957166e-02f, 2.70502996e-02f, -4.09660675e-02f, 9.34668630e-02f, -1.70064177e-02f, 9.63204503e-02f,
  1.32431328e-01f, -1.66929942e-02f, 1.93109512e-01f, -9.54161137e-02f, -1.53480545e-01f, -1.40023947e-01f, 4.58862782e-02f, -1.30858645e-01f, -1.16480395e-01f, -2.51626801e-02f,
  1.37379870e-01f, -5.57869971e-02f, -1.51941732e-01f, -1.02895886e-01f, -1.20470785e-01f, -4.86666039e-02f, -8.36451724e-02f, 2.13319212e-01f, -5.66206202e-02f, -4.16700281e-02f,
  -3.14058154e-03f, -1.11052714e-01f, 5.41141219e-02f, 1.52871339e-02f, 1.83820888e-01f, -1.28651097e-01f, 1.42927989e-01f, 1.20896362e-01f, 9.85010155e-03f, 2.80125849e-02f,
  -5.05182371e-02f, -8.96936283e-02f, -2.80324221e-01f, 2.15368927e-01f, 6.24773791e-03f, 2.80833561e-02f, 3.04925465e-03f, -5.84202856e-02f, 1.43103644e-01f, -8.39693472e-02f,
  -4.45688181e-02f, 4.75341529e-02f, -6.76873103e-02f, -1.63529858e-01f, 1.02892876e-01f, -9.62976664e-02f, 8.63055810e-02f, 7.51568377e-02f, 1.01000905e-01f, 1.98217779e-01f,
  -5.59819676e-02f, 6.74185827e-02f, 1.87215600e-02f, 1.41014323e-01f, -6.95677428e-03f, 2.15072230e-01f, -2.26018904e-03f, -2.06550345e-01f, 1.78838149e-01f, 1.30657718e-01f,
  -2.10299015e-01f, -2.48328641e-01f, 4.86249328e-02f, -1.55489922e-01f, -1.18780397e-01f, 6.65158927e-02f, -8.07918981e-02f, 8.88492391e-02f, -3.97940069e-01f, 3.15180898e-01f,
  3.51424724e-01f, 2.92038582e-02f, 1.89705305e-02f, 1.22080505e-01f, 8.99495259e-02f, -2.55613271e-02f, 5.69447353e-02f, -5.77639863e-02f, -7.50288963e-02f, -3.27964313e-02f,
  -4.09039743e-02f, -4.32685129e-02f, -1.20027579e-01f, 2.39201691e-02f, 2.19682634e-01f, -1.19474558e-02f, -1.32979006e-01f, -3.74175571e-02f, 2.99810078e-02f, 8.27950239e-02f,
  -2.73216665e-02f, 1.30195008e-03f, -4.89183441e-02f, 8.21179152e-02f, 2.04647668e-02f, 7.46029243e-02f, -8.27345327e-02f, 3.70082855e-02f, -9.13304389e-02f, -9.68359336e-02f,
  8.69748071e-02f, 1.44370422e-01f, 1.29135489e-01f, 2.34432835e-02f, 2.78601766e-01f, 3.89391966e-02f, -1.33934319e-01f, -4.83618192e-02f, -1.71401277e-01f, -4.39452268e-02f,
  7.40780607e-02f, 4.93278690e-02f, 5.87743856e-02f, -2.02525496e-01f, -1.12255521e-01f, -1.61961634e-02f, 6.41520917e-02f, 1.76153835e-02f, -9.76045951e-02f, 3.49312881e-03f,
  -1.48142487e-01f, -2.73449093e-01f, -5.94881848e-02f, -6.21018298e-02f, -2.07737368e-02f, -1.70968696e-01f, -1.56093404e-01f, 3.39672901e-02f, -1.55753642e-01f, -1.24836434e-02f,
  1.40840158e-01f, 1.68732241e-01f, -7.61847571e-02f, -6.51022568e-02f, 3.56090441e-02f, -1.11660585e-01f, -9.80345234e-02f, 6.69283718e-02f, 3.12275626e-02f, 1.28137618e-01f,
  -7.63750449e-02f, 8.03207532e-02f, -4.55040447e-02f, -1.87528268e-01f, 1.74257364e-02f, 1.82667142e-03f, -2.90680677e-02f, -2.24465579e-02f, 2.44103298e-02f, 4.76256236e-02f,
  -1.58006147e-01f, -5.05112112e-04f, 3.64033389e-03f, 7.16585433e-03f, 1.00705661e-01f, 2.14396734e-02f, 9.29709747e-02f, -4.22150791e-02f, 6.53454894e-03f, 4.00064550e-02f,
  -1.42640173e-01f, 8.94289017e-02f, -1.63013339e-01f, -8.92677903e-02f, 7.65857920e-02f, -2.87812911e-02f, -1.36430115e-01f, 1.55355379e-01f, 1.36663303e-01f, 5.62838614e-02f,
  -1.06538780e-01f, -1.52823538e-01f, -1.08622685e-01f, -9.80195701e-02f, 1.35717094e-01f, -4.74156514e-02f, 5.63074723e-02f, 2.02624187e-01f, 1.04694180e-01f, -6.01235181e-02f,
  -4.02413718e-02f, -1.00818604e-01f, -7.54940882e-02f, 6.67182282e-02f, 1.06809750e-01f, -7.92284161e-02f, 2.03894526e-02f, -1.53530538e-02f, -7.93896541e-02f, -3.44402976e-02f,
  -6.65020570e-03f, -9.85614136e-02f, -1.37885250e-02f, -8.49882439e-02f, -2.32373342e-01f, -7.26172552e-02f, -2.73910642e-01f, 3.52034658e-01f, 1.50410295e-01f, -8.90462995e-02f,
  3.08784842e-02f, 5.49984016e-02f, -1.57878939e-02f, -1.38596505e-01f, 5.10130897e-02f, -2.20025945e-02f, 4.72605489e-02f, -1.06785316e-02f, 9.54961255e-02f, 5.40914461e-02f,
  -6.40016282e-03f, 8.50466117e-02f, 1.24459065e-01f, -7.22964555e-02f, -7.35810623e-02f, -1.03026688e-01f, -1.22299306e-01f, -1.20550610e-01f, -6.21551573e-02f, 1.11200750e-01f,
  -7.63826892e-02f, -5.64049333e-02f, -1.59807838e-02f, 1.38979673e-01f, -6.24466203e-02f, 9.62623209e-02f, 1.85977459e-01f, -1.54691994e-01f, 1.12343229e-01f, 1.86585188e-02f,
  7.04603493e-02f, -5.31287864e-02f, 1.48559779e-01f, 9.41798016e-02f, 8.38969052e-02f, 1.78006086e-02f, -1.58196837e-01f, 5.70533657e-03f, -1.11039266e-01f, 2.16030031e-01f,
  1.26479892e-03f, -1.62165966e-02f, 8.01449046e-02f, -2.86379028e-02f, -2.30476297e-02f, -1.02445908e-01f, 3.21500711e-02f, 2.21022777e-03f, 4.62795198e-02f, 1.11527614e-01f,
  4.89979535e-02f, -2.45927796e-02f, 7.20627382e-02f, -1.44297644e-01f, -2.36092862e-02f, -3.28553505e-02f, 8.78640562e-02f, 3.89803946e-02f, 2.29015443e-02f, 1.71718359e-01f,
  2.27793038e-01f, -1.02513045e-01f, -6.72045797e-02f, -1.22107297e-01f, 9.55673009e-02f, -1.05276823e-01f, 1.30410483e-02f, -1.25807241e-01f, 5.60767874e-02f, -8.73936415e-02f,
  5.78200892e-02f, -2.97300192e-03f, 5.28830029e-02f, -2.58725882e-01f, 7.15661719e-02f, -8.00686702e-02f, -6.90270364e-02f, -9.05958787e-02f, 5.02707250e-02f, -9.93771031e-02f,
  3.13305892e-02f, 1.96828786e-02f, -9.30731744e-02f, -1.62929788e-01f, -1.00028157e-01f, -4.63519022e-02f, 1.48753077e-01f, 1.14737883e-01f, 2.99668521e-01f, -2.09108800e-01f,
  -2.18977756e-03f, -3.22838537e-02f, -3.92072834e-02f, -1.90070793e-02f, -1.89263552e-01f, -4.78291651e-03f, -6.24448732e-02f, 3.66377123e-02f, 9.59368125e-02f, 1.38304994e-01f,
  9.85819697e-02f, -1.00056194e-01f, 1.03237033e-01f, -8.94968361e-02f, 2.24468503e-02f, -2.02251464e-01f, 5.56532592e-02f, -6.25615865e-02f, -1.46977425e-01f, 4.82228845e-02f,
  -1.24395207e-01f, -3.17249671e-02f, -1.87271416e-01f, -2.07799792e-01f, -1.57182634e-01f, 1.25180325e-02f, 1.16073236e-01f, 6.22767881e-02f, -1.21384613e-01f, -5.05008996e-02f,
  1.96183071e-01f, -1.30193159e-01f, -1.12662883e-02f, 6.50394429e-03f, 8.33907127e-02f, -2.49283284e-01f, 1.19907791e-02f, -1.20823458e-02f, -1.15612455e-01f, -1.18384339e-01f,
  -3.52475829e-02f, -8.86935964e-02f, -1.46905594e-02f, -3.56468782e-02f, -6.24252707e-02f, -6.34927023e-03f, -9.97185931e-02f, -8.14794227e-02f, 3.42943817e-02f, 8.05349182e-03f,
  -5.88345639e-02f, 9.32315215e-02f, -8.66024103e-03f, -8.96600634e-03f, 6.45974874e-02f, -7.91824907e-02f, -2.26835385e-02f, 1.25250295e-01f, 1.01701329e-02f, -5.87121164e-03f,
  9.06439126e-02f, 1.96631793e-02f, -6.58422410e-02f, 2.58107986e-02f, -1.49488419e-01f, -5.02546355e-02f, 3.73301953e-02f, -8.30754340e-02f, -1.06307320e-01f, 1.34378523e-01f,
  -1.77157931e-02f, -3.29660475e-02f, 3.05269156e-02f, -1.23322085e-01f, 6.99832663e-02f, -8.56423602e-02f, -3.82069033e-03f, 1.21903364e-02f, -3.83375958e-02f, -1.55409828e-01f,
  -1.21030457e-01f, -1.81149598e-02f, 8.45220536e-02f, -3.73593941e-02f, -1.62492707e-01f, 4.77902703e-02f, 9.36275572e-02f, -2.18825608e-01f, -1.07778618e-02f, 2.85128802e-02f,
  -1.25801012e-01f, -1.69307083e-01f, -2.34472230e-01f, -1.23845041e-02f, -4.21531871e-02f, 3.65966149e-02f, 4.00301069e-01f, 1.64165571e-01f, -5.37292175e-02f, -1.54085636e-01f,
  1.28264306e-02f, -1.93060726e-01f, 8.70071128e-02f, 7.93626830e-02f, -2.33325828e-02f, -3.66934501e-02f, -2.68832929e-02f, -4.81159128e-02f, -9.09503475e-02f, -1.58619165e-01f,
  -1.77341864e-01f, -1.45669565e-01f, 1.20977268e-01f, 1.51848085e-02f, 1.10375687e-01f, -1.38246179e-01f, 4.21109162e-02f, -1.20089643e-01f, 2.62721218e-02f, 1.21043231e-02f,
  3.58977728e-02f, -1.63781308e-02f, 5.20151220e-02f, -7.61838108e-02f, 1.77383050e-01f, 2.58745756e-02f, 4.64298390e-02f, 5.25626689e-02f, -1.38664290e-01f, 1.60922743e-02f,
  7.12368824e-03f, -1.16226725e-01f, -1.67011157e-01f, 2.06719488e-01f, -9.40901637e-02f, 1.05882384e-01f, -4.58116792e-02f, 1.06295999e-02f, 6.81550661e-03f, 1.18492275e-01f,
  -6.76919669e-02f, 1.15114644e-01f, 1.01599216e-01f, 1.21288961e-02f, 9.50091183e-02f, -5.12553677e-02f, -4.12728824e-03f, 5.31045832e-02f, 1.89377010e-01f, 5.01941480e-02f,
  -1.87148094e-01f, -2.45705843e-01f, -1.75971333e-02f, -1.98347494e-02f, -1.13277711e-01f, -1.71310544e-01f, 1.16232693e-01f, -3.60677242e-02f, 4.36626095e-03f, 3.48498449e-02f,
  -2.37781912e-01f, -1.07466644e-02f, -2.15317234e-01f, 1.83464646e-01f, 2.01890320e-01f, 7.34167323e-02f, -1.77159697e-01f, 3.90395895e-02f, -8.58691186e-02f, -1.47441430e-02f,
  4.63754386e-02f, 9.82347801e-02f, -8.29233453e-02f, -1.34235322e-01f, -1.73738766e-02f, 1.12583056e-01f, 1.32713234e-02f, 1.82479881e-02f, 2.33403206e-01f, 1.30461752e-01f,
  -1.01775013e-01f, 1.03840845e-04f, -1.15810655e-01f, -1.63111061e-01f, -1.31958231e-01f, 1.48062482e-01f, -1.14368379e-01f, 7.32169673e-02f, -1.32294342e-01f, 9.75913182e-02f,
  -1.11738436e-01f, 1.24268174e-01f, -4.21500616e-02f, -8.23992342e-02f, 2.24344302e-02f, 1.35179266e-01f, 1.47112012e-01f, -1.79854691e-01f, 1.00175142e-01f, 1.63328275e-01f,
  -1.10236285e-02f, -8.70261155e-03f, -9.86779258e-02f, 8.52666516e-03f, 1.10304758e-01f, 1.81331009e-01f, -1.35836762e-03f, -1.50799200e-01f, 7.62160644e-02f, -8.18824694e-02f,
  -8.24097842e-02f, -6.41086251e-02f, -1.10780798e-01f, 9.58835855e-02f, 6.46511987e-02f, 3.99930123e-03f, -3.28001827e-02f, 4.93089072e-02f, 3.19769830e-02f, 1.22376099e-01f,
  -3.73467017e-04f, 5.59675470e-02f, -4.81906161e-02f, 1.37538504e-04f, 5.37129678e-02f, -1.55436054e-01f, -8.97153392e-02f, 4.83083650e-02f, -5.46060055e-02f, -6.57323301e-02f,
  -1.97080106e-01f, -9.73389074e-02f, 1.33582115e-01f, 5.70702143e-02f, -1.15668498e-01f, -9.21182111e-02f, 1.69772990e-02f, -1.18066914e-01f, -1.15861237e-01f, 1.92466840e-01f,
  -2.21691523e-02f, 9.18136314e-02f, 6.86356649e-02f, 2.29876558e-03f, -8.30319300e-02f, -4.11984604e-03f, 1.46126196e-01f, -7.06973374e-02f, -2.88519077e-02f, 1.42204016e-01f,
  -2.94974055e-02f, -1.23728149e-01f, 3.98911610e-02f, -1.06640115e-01f, -1.95978954e-01f, 2.10548028e-01f, 1.08407348e-01f, 4.30518240e-02f, -6.63939118e-02f, -1.67591631e-01f,
  9.18963626e-02f, -5.60598560e-02f, -4.01834063e-02f, 6.50848225e-02f, 3.34319919e-02f, 3.60026918e-02f, -2.78989095e-02f, -1.06216818e-01f, -1.18665934e-01f, -1.14353605e-01f,
  6.28933907e-02f, 9.19889063e-02f, -1.87403299e-02f, 1.22273952e-01f, -9.29114968e-02f, 1.10868089e-01f, -2.47735064e-02f, -5.87853119e-02f, -1.29409462e-01f, -2.83879310e-01f,
  -1.36473268e-01f, 5.07144397e-03f, -1.90721378e-01f, -5.45948138e-03f, -1.03866346e-01f, -1.08972572e-01f, -4.81190160e-02f, -4.55261320e-02f, -2.08095774e-01f, 8.01404491e-02f,
  -1.51108935e-01f, 7.15464056e-02f, 1.84003606e-01f, 1.48734823e-01f, 2.80715507e-02f, 7.68816248e-02f, -1.56730965e-01f, -1.64167047e-01f, 8.15827921e-02f, 9.93597507e-02f,
  -7.55285919e-02f, 4.62502688e-02f, -6.45327419e-02f, -1.81076944e-01f, 8.50544497e-02f, 1.25419214e-01f, -1.46264545e-04f, 7.97303244e-02f, -1.70905411e-01f, 4.20218445e-02f,
  1.96841103e-03f, -1.04214750e-01f, -5.87412231e-02f, -1.36762522e-02f, 8.64383653e-02f, -2.93281395e-02f, -1.33732334e-01f, 1.13674790e-01f, -5.08994199e-02f, -1.49722397e-01f,
  -7.66854137e-02f, -1.56249911e-01f, -3.13989595e-02f, 1.51147947e-01f, 1.22384839e-01f, -8.50687698e-02f, 7.78038502e-02f, 1.25020817e-01f, -1.18595950e-01f, -9.41024423e-02f,
  -1.41492158e-01f, 3.64819393e-02f, 1.26312986e-01f, 1.69294000e-01f, 6.94648027e-02f, 9.26357433e-02f, 4.70102131e-02f, 6.69705719e-02f, 1.19580440e-01f, -6.65081888e-02f,
  -1.01642244e-01f, -2.38673165e-02f, 1.01822749e-01f, -1.34245008e-01f, 4.59449701e-02f, 8.40779766e-02f, -6.75757304e-02f, -2.38699481e-01f, -3.58254798e-02f, 1.34052485e-01f,
  -1.82141110e-01f, 2.53602326e-01f, 6.76792394e-03f, 9.56038982e-02f, 4.50824127e-02f, 1.87901080e-01f, 2.38771871e-01f, 9.84374527e-03f, 1.97003111e-01f, -4.14907821e-02f,
  -5.93163669e-02f, -4.34610918e-02f, 9.90187824e-02f, 1.25934854e-01f, 1.44017905e-01f, -1.15636490e-01f, -1.11589760e-01f, -2.39886150e-01f, 9.48028415e-02f, 6.12699538e-02f,
  -2.50092689e-02f, -6.98650926e-02f, -8.12081248e-03f, 6.15928434e-02f, 4.27243970e-02f, 2.83175763e-02f, -1.54243663e-01f, 3.24067138e-02f, -4.24332246e-02f, -1.59199253e-01f,
  1.30526414e-02f, 6.53014034e-02f, 1.33927539e-01f, -2.00027868e-01f, 8.06539133e-02f, -3.78858931e-02f, -7.88795650e-02f, -4.08588536e-02f, 1.07108586e-01f, 4.88207825e-02f,
  1.19256720e-01f, 7.17669800e-02f, -1.97629798e-02f, -2.47558933e-02f, -1.90621689e-01f, -4.97573130e-02f, 1.31671531e-02f, 2.95118298e-02f
};

// L3_fan_Wp_bar (Shape: 40 x 64)
const int L3_fan_Wp_bar_rows = 40;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  -2.08594427e-02f, 2.00179890e-02f, -8.97011980e-02f, -8.85797441e-02f, 4.21235617e-03f, 5.89501970e-02f, 1.09630719e-01f, 6.04519546e-02f, 3.55444327e-02f, -1.00815021e-01f,
  1.34032682e-01f, 9.46173221e-02f, 5.62569387e-02f, 1.09534487e-01f, -4.82392265e-03f, 1.13690756e-01f, 5.83856627e-02f, 1.41871087e-02f, -9.04828161e-02f, 6.08112179e-02f,
  -3.72075811e-02f, 7.75941685e-02f, -7.32346028e-02f, -1.12505950e-01f, -1.23149715e-01f, 5.37075251e-02f, -9.49689969e-02f, 3.16857509e-02f, 9.05208364e-02f, 4.79296409e-02f,
  4.13917564e-02f, 4.31336537e-02f, 6.64788485e-02f, 1.47371784e-01f, -7.32756108e-02f, 1.67083554e-02f, -1.82967745e-02f, 3.22303474e-02f, 1.28967866e-01f, 1.84631776e-02f,
  8.46558064e-02f, -1.02459542e-01f, 9.14731547e-02f, -2.60455739e-02f, 2.49462165e-02f, 9.66483429e-02f, 1.27032414e-01f, 1.72749862e-01f, 9.20353010e-02f, 9.68105916e-04f,
  -1.02549545e-01f, -2.60075759e-02f, -7.12337941e-02f, 9.45352912e-02f, -1.38610795e-01f, -1.67767592e-02f, -1.04703166e-01f, -2.96205916e-02f, 9.64579955e-02f, -9.32054073e-02f,
  -4.89987023e-02f, 6.42744973e-02f, 4.45102565e-02f, 6.71380162e-02f, -1.50439078e-02f, 1.80119425e-01f, 8.54358673e-02f, 1.93917364e-01f, -7.00812861e-02f, 8.28436688e-02f,
  1.51213050e-01f, -7.78311864e-02f, -6.23872429e-02f, -1.57811612e-01f, 8.67360532e-02f, 1.30329803e-01f, -2.35402528e-02f, -1.56958714e-01f, -1.72162458e-01f, -1.10241465e-01f,
  1.51921645e-01f, 1.68653026e-01f, 8.49448424e-03f, 1.73985273e-01f, -6.45829067e-02f, 1.03226773e-01f, -4.35777493e-02f, 3.24587859e-02f, -8.54228660e-02f, 1.30252272e-01f,
  -9.75050554e-02f, -1.80408388e-01f, -9.51693356e-02f, 1.46369627e-02f, 8.32832158e-02f, -7.13194236e-02f, -4.94166352e-02f, -9.28045511e-02f, -1.14420205e-01f, 8.72062668e-02f,
  8.73974040e-02f, 1.50561318e-01f, 7.96314776e-02f, 1.28792256e-01f, 2.13348474e-02f, 1.14315577e-01f, -8.07009786e-02f, 2.03111932e-01f, -7.46004730e-02f, -3.95577848e-02f,
  -4.33523133e-02f, 3.14006120e-01f, 3.47041279e-01f, 1.28398314e-01f, -8.20405632e-02f, -2.04950441e-02f, 1.49901286e-01f, -1.17717743e-01f, -8.31748769e-02f, -1.02165826e-01f,
  -7.95219690e-02f, -2.97081638e-02f, 3.50326486e-02f, -1.90959290e-01f, -3.95957194e-02f, 7.15679862e-03f, 1.28382623e-01f, 2.09295630e-01f, 9.54433158e-02f, 1.17722072e-01f,
  -1.12537920e-01f, 1.38256341e-01f, 1.43866807e-01f, 1.80947650e-02f, -2.60225348e-02f, -1.45653542e-02f, 1.02780633e-01f, 5.00472076e-02f, -3.97122540e-02f, 1.50730923e-01f,
  -3.24345231e-02f, 9.55919921e-02f, -1.76006123e-01f, 7.06334338e-02f, 4.24487107e-02f, 1.20278321e-01f, 2.32663915e-01f, 8.52252096e-02f, -1.12405077e-01f, 1.00890011e-01f,
  -1.67889073e-01f, -2.12463304e-01f, 8.06003064e-02f, 9.49886516e-02f, -6.68849200e-02f, 7.19984174e-02f, -1.04550757e-01f, 5.11630699e-02f, 5.30932322e-02f, 4.60986942e-02f,
  -8.95888060e-02f, 1.98014170e-01f, -6.28286153e-02f, -1.47302160e-02f, -1.32652409e-02f, -1.05879679e-02f, 7.20115155e-02f, 9.90975201e-02f, 3.42718139e-02f, 1.22405794e-02f,
  7.81875253e-02f, 2.39283442e-02f, -1.29107818e-01f, 4.03556507e-03f, 7.31341029e-03f, 2.37118348e-01f, 5.71498312e-02f, 1.90037012e-01f, -6.56691641e-02f, -6.97089881e-02f,
  6.25471547e-02f, 7.55494386e-02f, -1.13597289e-01f, 2.02258691e-01f, -1.02535024e-01f, 7.66395926e-02f, 1.32871969e-02f, -1.15240149e-01f, 1.59774795e-01f, -3.00996397e-02f,
  -1.30185736e-02f, -1.13098994e-01f, 1.17383070e-01f, 2.60892451e-01f, -3.45851779e-02f, -6.01042341e-03f, 1.06625231e-02f, 2.04750355e-02f, 1.29543006e-01f, 4.59668450e-02f,
  2.22560734e-01f, -7.57236034e-02f, 1.59023572e-02f, 1.23402290e-01f, -1.52928844e-01f, -1.96579024e-01f, -5.72361648e-02f, -1.65876970e-01f, 2.88045872e-02f, 1.36316180e-01f,
  -2.35758319e-01f, 1.11462809e-01f, -6.25116974e-02f, 3.01334977e-01f, 2.27653176e-01f, -1.57455802e-02f, 2.27742139e-02f, 8.19551721e-02f, -1.14210777e-01f, 6.48035333e-02f,
  1.94955155e-01f, 3.71125229e-02f, 6.34279028e-02f, 7.52334744e-02f, 1.46009147e-01f, 6.00323360e-03f, -1.01652421e-01f, 4.54459665e-03f, 4.98195365e-02f, 5.70690073e-02f,
  1.05880387e-01f, 9.82022285e-02f, -1.68114647e-01f, -7.56182969e-02f, -1.85880780e-01f, 4.14331704e-02f, 5.83393462e-02f, 9.41652283e-02f, -5.30801825e-02f, 1.89082429e-01f,
  1.94973245e-01f, -6.55816570e-02f, -8.35178867e-02f, -6.41030893e-02f, 1.30622372e-01f, 1.42947100e-02f, 1.46797314e-01f, -1.05221821e-02f, 2.05338031e-01f, -1.13469632e-02f,
  7.83480927e-02f, 1.02307133e-01f, 4.34448533e-02f, -1.65509712e-02f, 3.43109034e-02f, -3.15151140e-02f, 1.64566606e-01f, 1.06602959e-01f, 7.17611760e-02f, 2.15897903e-01f,
  5.59757128e-02f, -9.01004970e-02f, 1.41288757e-01f, 3.56870256e-02f, 1.24994174e-01f, -4.67873104e-02f, 1.18643224e-01f, 1.04616359e-01f, -1.49598390e-01f, -2.88462758e-01f,
  -1.03694379e-01f, -8.49754587e-02f, 5.07755466e-02f, 3.11520189e-01f, 2.36915514e-01f, 1.57108322e-01f, -2.29438975e-01f, 3.02357852e-01f, -2.98597980e-02f, -1.68481603e-01f,
  -4.21144366e-02f, 8.08628425e-02f, -4.67016436e-02f, -1.06445208e-01f, 6.98185414e-02f, -1.15587510e-01f, -2.33851597e-02f, -1.24552406e-01f, -6.63028657e-02f, -9.57369730e-02f,
  -8.37129429e-02f, 1.31258085e-01f, 1.73500106e-02f, -9.14137438e-02f, -8.80473107e-02f, -6.87413365e-02f, -3.93419191e-02f, -7.61107132e-02f, -1.14965819e-01f, 1.27324834e-01f,
  -1.05672382e-01f, 4.78999801e-02f, 1.70501783e-01f, 4.00109053e-01f, 2.99660504e-01f, -1.69812739e-02f, -5.18044122e-02f, -8.36808309e-02f, 9.13483202e-02f, -1.56034697e-02f,
  -1.94771424e-01f, 1.92257594e-02f, 6.39306903e-02f, -6.16628788e-02f, -1.18820459e-01f, -1.15631465e-02f, 1.15188599e-01f, -5.06070675e-03f, 6.18888102e-02f, 2.51160264e-01f,
  3.90154682e-02f, 8.49350169e-02f, 2.24308874e-02f, -6.85648322e-02f, 3.59821357e-02f, -9.28354338e-02f, -2.44560540e-02f, -6.01553023e-02f, -8.32248032e-02f, 3.06323245e-02f,
  -1.31681725e-01f, 4.43716114e-03f, 1.19809665e-01f, -8.82267877e-02f, 2.78382692e-02f, 7.80241042e-02f, 1.33660868e-01f, -2.90812850e-02f, 1.51099995e-01f, 1.04587913e-01f,
  3.32720652e-02f, 5.73722236e-02f, -1.73933923e-01f, 3.87317799e-02f, -9.36791897e-02f, -6.89420402e-02f, 5.09328619e-02f, 7.58174583e-02f, -1.03087738e-01f, -4.43657525e-02f,
  1.92421358e-02f, 5.10190129e-02f, 4.49686013e-02f, 3.82591486e-02f, 9.00714993e-02f, -9.36074033e-02f, -4.59367745e-02f, -3.42050157e-02f, 8.43955427e-02f, 1.97091252e-02f,
  7.01648891e-02f, -1.02578335e-01f, 6.11391217e-02f, -4.54841256e-02f, -3.50429080e-02f, -1.20996960e-01f, -5.47680594e-02f, 1.10767975e-01f, 1.82283968e-01f, 5.23017123e-02f,
  1.17252499e-01f, -1.28558740e-01f, 1.60112958e-02f, -1.29955649e-01f, -1.17337719e-01f, 9.71298963e-02f, -1.30224571e-01f, -8.24689791e-02f, -1.25784110e-02f, -6.10263459e-03f,
  1.29716441e-01f, -3.62561494e-02f, 1.12143531e-02f, 1.26910999e-01f, 3.08294203e-02f, 1.01252258e-01f, 7.07151294e-02f, 7.26427808e-02f, 1.86340749e-01f, 1.42328754e-01f,
  2.39484295e-01f, 1.35312408e-01f, 5.84253296e-02f, 1.47736520e-01f, 2.41448894e-01f, 6.90817460e-02f, 4.01106365e-02f, 2.26653010e-01f, -1.45217091e-01f, -1.58207685e-01f,
  -6.44421503e-02f, -1.31440535e-01f, -9.32411104e-02f, -2.13958621e-01f, -1.99111134e-01f, 1.36979342e-01f, 7.73014361e-03f, 3.05005629e-02f, 3.79626118e-02f, -2.30863132e-02f,
  1.68461815e-01f, 4.95267361e-02f, -8.39303285e-02f, -8.71793777e-02f, -3.65814455e-02f, -9.60187167e-02f, 9.19220075e-02f, 2.31387883e-01f, 6.03890195e-02f, -3.07736620e-02f,
  1.43297374e-01f, 9.03623085e-03f, 1.15237452e-01f, 1.84671581e-01f, 1.19836837e-01f, 7.09896386e-02f, 9.71976668e-02f, 6.61845133e-02f, -7.40943616e-03f, -1.34328725e-02f,
  -2.73160860e-02f, -1.18451133e-01f, -1.94343030e-01f, 2.48124283e-02f, 2.25297794e-01f, -1.09281965e-01f, -4.54242527e-02f, 1.61952808e-01f, 2.09303111e-01f, -1.28844768e-01f,
  1.94452301e-01f, -1.24812573e-01f, -1.60028532e-01f, 1.30499363e-01f, -1.28665909e-01f, -7.82978907e-02f, -6.63574487e-02f, -8.61186348e-03f, 2.08564717e-02f, -5.55113852e-02f,
  1.40940771e-01f, 1.21979780e-01f, -1.35421410e-01f, 2.75496580e-02f, 9.40979123e-02f, -5.67399785e-02f, -1.29181534e-01f, 1.00263670e-01f, -5.46048023e-03f, -1.59851331e-02f,
  1.34362623e-01f, -5.31306863e-03f, -2.94493008e-02f, -1.21853083e-01f, 3.70971151e-02f, -1.56729966e-01f, -5.18228859e-02f, 1.32873818e-01f, 1.39538199e-01f, -1.98746577e-01f,
  -7.11168256e-03f, -2.24255212e-02f, 1.71673484e-02f, -9.25763547e-02f, -2.12339442e-02f, -7.80218244e-02f, -6.72747493e-02f, 4.92558479e-02f, 9.03975442e-02f, 5.72155379e-02f,
  -8.20336118e-03f, -8.33207741e-02f, 3.50125059e-02f, -6.52029067e-02f, -1.36212101e-02f, -1.46844108e-02f, 7.71834552e-02f, 1.15142129e-01f, 3.24297859e-03f, 1.15057036e-01f,
  4.24066670e-02f, 5.41322604e-02f, 4.55273390e-02f, -9.48494002e-02f, -1.29164442e-01f, 1.19016670e-01f, 9.44282934e-02f, -7.62115791e-02f, -3.74553800e-02f, 5.76813221e-02f,
  -9.32726488e-02f, 6.25014082e-02f, -6.92023784e-02f, 2.03963891e-02f, 2.86266897e-02f, 4.25454378e-02f, 3.06545030e-02f, -6.42064661e-02f, 1.17221579e-01f, -7.88935348e-02f,
  1.23166576e-01f, -1.18183985e-01f, -1.46217600e-01f, -6.72993213e-02f, -7.94948786e-02f, 3.05627100e-02f, 8.26946720e-02f, 2.90687215e-02f, -9.91247892e-02f, -4.22030389e-02f,
  -1.41167685e-01f, 2.70321257e-02f, -1.48442224e-01f, -7.68135041e-02f, -1.10483728e-01f, -1.95700489e-02f, -2.41644979e-02f, 1.04430817e-01f, -3.66909206e-02f, 1.24993414e-01f,
  1.73339173e-02f, -2.70152576e-02f, -2.73226091e-04f, -1.38769392e-02f, 4.07231972e-02f, 4.36067693e-02f, -1.15089126e-01f, -1.01285629e-01f, -8.84264112e-02f, -8.91353190e-02f,
  -4.66672033e-02f, 7.00549707e-02f, -7.61959776e-02f, 5.17845899e-02f, 1.08366750e-01f, 1.59294918e-01f, 2.55907886e-02f, 2.35033892e-02f, 1.92074910e-01f, 1.12812422e-01f,
  4.57268097e-02f, -1.78514440e-02f, 9.34870541e-02f, -3.29474956e-02f, -6.24419190e-02f, 1.04686178e-01f, -8.30511525e-02f, -8.70936066e-02f, 2.39848439e-02f, 9.21292976e-02f,
  -2.09979620e-02f, 1.45515874e-01f, -8.84739086e-02f, 2.35512536e-02f, 5.87455221e-02f, -9.07450542e-02f, -3.62856984e-02f, 2.42804717e-02f, 1.53183252e-01f, 5.91634661e-02f,
  -1.00809671e-01f, -1.35788202e-01f, 3.81966867e-02f, 1.93117466e-02f, 8.34203660e-02f, 1.82990313e-01f, 1.90265715e-01f, -3.00254822e-02f, 3.82037573e-02f, 5.88034838e-02f,
  -7.86721185e-02f, 5.07379510e-02f, 7.18198791e-02f, -4.13320586e-02f, 9.27860290e-03f, -8.67873430e-02f, 1.43882439e-01f, -3.96347418e-02f, 7.42383972e-02f, 2.03834951e-01f,
  -7.69254342e-02f, -1.32407606e-01f, 2.51939684e-01f, 3.57608050e-02f, 1.27285749e-01f, 2.90814266e-02f, -1.51333228e-01f, 7.46124610e-02f, -1.48551166e-03f, -4.53877077e-02f,
  3.88766569e-03f, -1.32990196e-01f, -1.03169426e-01f, -7.82425404e-02f, -1.20961577e-01f, 4.05495316e-02f, -1.30218089e-01f, 6.06834181e-02f, -3.65189239e-02f, 7.03038648e-02f,
  2.92220060e-02f, 1.68704435e-01f, 2.18615383e-02f, 5.51346652e-02f, 1.21236727e-01f, 4.09763046e-02f, 1.37941197e-01f, -1.49285083e-03f, 7.85307512e-02f, 1.49887323e-01f,
  -7.04935491e-02f, 4.03349102e-02f, -9.36617777e-02f, -4.97446395e-02f, 6.55397251e-02f, 1.04911342e-01f, 1.44757748e-01f, 1.90749355e-02f, -2.76275612e-02f, -2.37775687e-02f,
  1.85988955e-02f, -5.92146888e-02f, 2.47485433e-02f, 2.66767945e-02f, -1.49433047e-01f, -1.68154880e-01f, 1.26043871e-01f, -7.57230222e-02f, -7.46807307e-02f, 1.19954601e-01f,
  4.92746616e-03f, 4.48972359e-02f, 9.21486318e-02f, 6.25143945e-02f, 7.33394548e-02f, -1.08426875e-02f, 9.04293731e-02f, 1.39151081e-01f, 1.18652478e-01f, 5.27115501e-02f,
  2.17130467e-01f, 3.42405564e-03f, -6.71006143e-02f, 2.12248210e-02f, 1.18867636e-01f, 3.49278040e-02f, 1.27001360e-01f, -1.78322028e-02f, -7.31840804e-02f, 3.96523438e-02f,
  -1.68009713e-01f, 2.20782429e-01f, 1.21540330e-01f, 1.20159656e-01f, 1.46389619e-01f, -1.22737050e-01f, -2.23312899e-02f, 1.16715670e-01f, -3.02932356e-02f, 1.00798294e-01f,
  -1.20246120e-01f, 1.33362040e-01f, -1.45993037e-02f, -8.87909234e-02f, -1.32939726e-01f, -1.40315276e-02f, -8.24659914e-02f, 4.93046269e-02f, -1.66694168e-02f, 1.45438805e-01f,
  -8.59710854e-03f, 6.10993952e-02f, -4.76085916e-02f, 3.15943994e-02f, -8.84507224e-02f, 9.32368636e-03f, 6.82939366e-02f, 1.58862397e-01f, 1.36406451e-01f, -1.12715594e-01f,
  -8.60714614e-02f, -7.20137954e-02f, -4.70311604e-02f, -2.38563437e-02f, -4.83294241e-02f, -1.00014642e-01f, 8.12914595e-02f, -1.16687238e-01f, 1.99511144e-02f, -3.69444699e-03f,
  7.15577528e-02f, -2.83045769e-02f, 7.27851614e-02f, 1.24090850e-01f, -2.75617950e-02f, -1.00487724e-01f, 4.03019860e-02f, -8.86585116e-02f, -9.93483067e-02f, 8.74536112e-02f,
  -3.12223397e-02f, -7.59998187e-02f, -1.08747981e-01f, 1.02069914e-01f, 8.45186710e-02f, -1.00046441e-01f, 1.26793131e-01f, 5.23692220e-02f, 3.80769670e-02f, 8.77301693e-02f,
  1.02435663e-01f, 1.64436772e-02f, -6.83301985e-02f, -2.82488856e-02f, 1.22292146e-01f, -1.01905152e-01f, -5.21717891e-02f, -8.71880502e-02f, -3.48064825e-02f, -9.88679528e-02f,
  1.93563197e-03f, 1.21665180e-01f, -4.21606470e-03f, -9.86526385e-02f, 6.69997185e-02f, 4.73614819e-02f, 1.41835049e-01f, 9.22997296e-02f, -3.63188908e-02f, 3.77071463e-02f,
  5.21080978e-02f, -9.53655094e-02f, -7.84874260e-02f, 5.24673611e-02f, -7.74814636e-02f, 7.67508969e-02f, -6.98003694e-02f, -2.01635770e-02f, -1.04356878e-01f, -3.17384265e-02f,
  -1.28287002e-01f, -1.85941737e-02f, -3.53908055e-02f, -6.64749071e-02f, -4.61376905e-02f, 6.62992671e-02f, -4.15629260e-02f, 1.37177780e-01f, 1.16214722e-01f, -1.09586887e-01f,
  7.91126117e-02f, -2.39982828e-02f, 1.14964329e-01f, -3.57546806e-02f, 7.27250278e-02f, 4.84642833e-02f, 2.31053936e-03f, 1.07452914e-01f, 7.09744617e-02f, -2.88784988e-02f,
  -9.85149667e-02f, 1.91143025e-02f, 3.42954397e-02f, -6.18663281e-02f, -7.34637752e-02f, -5.71141355e-02f, -8.81152153e-02f, -9.03968588e-02f, 2.93067265e-02f, 1.20017365e-01f,
  -2.29400486e-01f, -3.32330689e-02f, -3.40505950e-02f, -1.11585051e-01f, -7.12276548e-02f, 1.48631573e-01f, 1.46713048e-01f, 1.28593236e-01f, -1.06367238e-01f, 3.74657772e-02f,
  1.56298444e-01f, -8.14815536e-02f, 4.08916473e-02f, 1.03841834e-01f, -9.85562354e-02f, -1.12844065e-01f, 2.44891159e-02f, 1.69311347e-03f, 1.73011765e-01f, -1.46171421e-01f,
  -9.49550718e-02f, -1.26248762e-01f, -1.91216860e-02f, 5.93403317e-02f, 1.17556520e-01f, 1.12867616e-01f, -1.33969396e-01f, -6.54178262e-02f, -1.30187690e-01f, -3.53065468e-02f,
  -3.38364393e-02f, -6.50043711e-02f, -8.00236464e-02f, -7.62488395e-02f, 6.12377794e-03f, 1.34030387e-01f, 1.62027806e-01f, -5.00792898e-02f, -2.34378111e-02f, -1.14925072e-01f,
  1.36185557e-01f, 1.22262031e-01f, 4.93034907e-02f, 1.30921766e-01f, 1.94720939e-01f, -1.85589399e-02f, 4.67934571e-02f, -8.18032175e-02f, -6.02168366e-02f, 1.11805499e-01f,
  4.15699333e-02f, 1.87254086e-01f, 2.90933456e-02f, 1.11654453e-01f, 1.24692596e-01f, -1.07563371e-02f, 1.05581664e-01f, -2.31293235e-02f, 3.05156589e-01f, -7.56065473e-02f,
  9.93700400e-02f, -1.76823884e-01f, -7.51354620e-02f, 1.92989245e-01f, -1.28422126e-01f, -2.35539779e-01f, -1.56265065e-01f, -7.34559149e-02f, 5.46679720e-02f, 1.77821428e-01f,
  -5.14853708e-02f, 2.64769942e-01f, -9.74470228e-02f, 1.71490312e-01f, -1.12963147e-01f, 4.18787040e-02f, 7.25542083e-02f, -4.30576950e-02f, 5.39396107e-02f, -1.10955825e-02f,
  4.15677018e-02f, -4.55280952e-03f, 5.21365292e-02f, 1.40765488e-01f, -3.06038521e-02f, -1.60069034e-01f, 6.97571877e-03f, 1.57962609e-02f, 1.01058930e-01f, 7.89718255e-02f,
  -5.12538897e-03f, -2.06069611e-02f, -1.02484412e-01f, 3.37130390e-02f, 2.00510565e-02f, -3.36251631e-02f, 8.18271190e-02f, 1.12104654e-01f, -7.89101124e-02f, 3.32369328e-01f,
  3.89589578e-01f, -1.14100613e-01f, -1.79238722e-01f, -1.37572065e-01f, 4.15831478e-03f, 1.22582942e-01f, -2.29841974e-02f, -1.02475889e-01f, 1.78579435e-01f, -5.23200724e-03f,
  5.91385216e-02f, 8.37123953e-03f, 1.44138768e-01f, 9.85382572e-02f, 1.57827079e-01f, 2.05825180e-01f, 1.13768153e-01f, -6.97014853e-02f, 1.24139786e-01f, 1.54063692e-02f,
  2.85493340e-02f, 1.18264042e-01f, -3.85376276e-04f, -2.74088532e-02f, 1.03281528e-01f, 1.41450807e-01f, -5.17412182e-03f, -5.42307098e-04f, 5.11434972e-02f, -4.07639099e-03f,
  -9.30233300e-03f, 3.16877700e-02f, -1.78511560e-01f, -1.24745676e-02f, -1.41958609e-01f, -1.17875136e-01f, -4.51001935e-02f, -1.19542032e-01f, -2.97121750e-03f, 4.67470810e-02f,
  7.46701285e-02f, -1.03447074e-02f, -1.51363965e-02f, 1.13926440e-01f, 1.62704065e-01f, 8.60513300e-02f, 1.02456637e-01f, -2.31252089e-02f, -2.08807718e-02f, -4.38647754e-02f,
  8.92368779e-02f, -8.47315975e-03f, -5.59618138e-02f, -4.76266928e-02f, 8.50133747e-02f, 9.38412920e-02f, 4.14885804e-02f, 1.10677697e-01f, 4.57848534e-02f, 2.59103086e-02f,
  -1.18010603e-01f, 2.10148524e-02f, -9.33926180e-02f, 9.27413255e-03f, -4.89577278e-02f, -1.51269779e-01f, 1.04597793e-03f, -1.14565184e-02f, 7.41482675e-02f, 1.84656586e-02f,
  1.17992073e-01f, 1.20876338e-02f, 1.52691364e-01f, -6.97330683e-02f, 1.09603830e-01f, 1.37232959e-01f, 1.18541278e-01f, -4.03857306e-02f, -4.60514650e-02f, -1.09644420e-02f,
  7.88950920e-02f, -9.04674828e-02f, -9.80779827e-02f, 7.37179220e-02f, 3.47980810e-03f, -6.82646409e-03f, 2.20422857e-02f, -8.47289935e-02f, 2.47125234e-02f, -6.49142563e-02f,
  -7.51032755e-02f, 1.44332960e-01f, 7.59824067e-02f, 1.38116300e-01f, 8.04763064e-02f, -4.97341193e-02f, 1.27796933e-01f, 6.87447703e-03f, -4.73853499e-02f, -7.98429400e-02f,
  1.61742523e-01f, -1.96650118e-01f, -1.15609623e-01f, -1.03831746e-01f, -1.04281411e-03f, 4.46471497e-02f, -6.88952282e-02f, -9.25043672e-02f, 4.51705866e-02f, 2.37271897e-02f,
  -8.25300440e-03f, -6.02943115e-02f, -4.19629849e-02f, -6.74661547e-02f, 5.58044165e-02f, 1.06951244e-01f, 3.74550857e-02f, -2.35785656e-02f, 2.06257473e-03f, 1.60774440e-02f,
  1.19298697e-01f, -2.09953822e-03f, 5.58665097e-02f, -5.16769923e-02f, -2.01307423e-02f, -3.86653058e-02f, 1.28439397e-01f, -7.46722072e-02f, -1.04599535e-01f, 5.75299859e-02f,
  -9.50219408e-02f, 5.50072454e-02f, -7.40153715e-02f, 7.74746612e-02f, -7.61731192e-02f, 5.45806773e-02f, 2.70977579e-02f, -3.94130498e-02f, -1.29215971e-01f, -1.24793991e-01f,
  -2.39775740e-02f, 1.05850197e-01f, -5.95827885e-02f, -1.00059994e-01f, 5.45170121e-02f, 1.24230437e-01f, 1.95918027e-02f, 1.02042489e-01f, 8.63668397e-02f, 6.29590750e-02f,
  2.24468440e-01f, -1.15827106e-01f, 6.56772032e-03f, 1.72553435e-01f, -6.18806854e-02f, -4.99575511e-02f, -4.95952219e-02f, 2.67496496e-03f, 2.77262963e-02f, 4.70856763e-02f,
  9.79904830e-02f, -1.36651486e-01f, -5.96793890e-02f, 1.74789578e-01f, 6.02070875e-02f, 1.36925042e-01f, -7.50977993e-02f, -1.33905888e-01f, 9.21769142e-02f, 1.00627959e-01f,
  1.15167521e-01f, 5.65310754e-02f, -2.33593509e-02f, 1.52594894e-02f, -1.04376584e-01f, -5.66175990e-02f, 1.43734649e-01f, 9.55808833e-02f, -6.65637702e-02f, -6.13575764e-02f,
  -1.41022041e-01f, 1.65738389e-01f, 1.79357454e-01f, 1.04194202e-01f, 8.27762932e-02f, 4.53610793e-02f, -9.32732299e-02f, 9.03393328e-02f, -5.25988787e-02f, 6.94683939e-02f,
  1.41773475e-02f, 2.26053730e-01f, 2.81518906e-01f, 6.78358376e-02f, -4.20827493e-02f, -8.50346982e-02f, -2.14505643e-02f, -1.15079857e-01f, 3.87725532e-02f, 6.13236390e-02f,
  3.08452919e-02f, 6.16056509e-02f, -5.63531928e-03f, 6.86387345e-02f, -3.82601134e-02f, -5.53375259e-02f, -5.34977652e-02f, -8.71877298e-02f, -1.03200682e-01f, -4.01703380e-02f,
  -1.11103497e-01f, -1.21945636e-02f, 2.84268055e-02f, -1.07508413e-01f, 1.43111467e-01f, -7.93310851e-02f, 1.13948070e-01f, -1.41228333e-01f, 9.15365964e-02f, 4.35526446e-02f,
  -2.53829286e-02f, 1.15963072e-02f, 4.43208925e-02f, 5.70951439e-02f, 1.43691152e-01f, -2.02813130e-02f, 3.00521534e-02f, -9.33080018e-02f, 5.69236837e-02f, 4.70784493e-02f,
  -3.01311016e-02f, 1.20964609e-01f, -8.11490044e-02f, 3.46447006e-02f, 1.10561341e-01f, -7.65406489e-02f, 2.97030937e-02f, 2.14511286e-02f, -1.31598068e-03f, 2.81671192e-02f,
  -4.26498353e-02f, 1.48654938e-01f, 3.01294252e-02f, 3.63068990e-02f, -9.19233859e-02f, 4.07248698e-02f, -6.02617785e-02f, 5.76424599e-02f, 8.54203328e-02f, -1.27944173e-02f,
  -6.91157430e-02f, 9.90580581e-03f, -3.34308408e-02f, 5.92321418e-02f, -5.93893379e-02f, 9.06842649e-02f, -3.04048043e-02f, -6.42906129e-02f, 1.14269562e-01f, 6.51408136e-02f,
  2.24058833e-02f, 2.96304617e-02f, 1.25806287e-01f, -3.11916159e-03f, 1.29220992e-01f, 1.05241597e-01f, 9.85422730e-02f, -3.78080942e-02f, 5.87708540e-02f, -1.18931264e-01f,
  2.92243063e-02f, 1.08751133e-01f, -4.24179845e-02f, 7.56199518e-03f, 9.25019234e-02f, -1.58735272e-02f, -6.17982037e-02f, 9.82169136e-02f, -5.29274866e-02f, -3.81989218e-02f,
  -8.09410438e-02f, 9.07021686e-02f, -6.66449890e-02f, -1.92599054e-02f, 7.47234598e-02f, 1.33177266e-02f, 4.15520258e-02f, -1.12885736e-01f, -7.44309975e-03f, -5.86196519e-02f,
  5.40725961e-02f, 4.82152551e-02f, 6.99551925e-02f, -9.27072018e-02f, -3.63949724e-02f, -3.02474443e-02f, -8.25005695e-02f, -1.26263155e-02f, 5.02446629e-02f, -5.46420626e-02f,
  -1.64700262e-02f, 3.47481407e-02f, -1.04139693e-01f, 2.22674888e-02f, -1.02346472e-01f, 4.34926040e-02f, -4.22654115e-02f, -4.23093997e-02f, -1.12442575e-01f, -2.38465369e-02f,
  -2.87083574e-02f, -7.28054196e-02f, 5.01892203e-03f, 5.55869425e-03f, 1.95199102e-02f, 8.16059671e-03f, 1.28601370e-02f, -9.77389067e-02f, 1.04735285e-01f, -5.33980988e-02f,
  -6.86276658e-03f, 5.57553247e-02f, 5.94889186e-02f, -1.28342491e-02f, -5.74576482e-02f, -7.52898455e-02f, 5.09316362e-02f, -9.45201609e-03f, -1.21918656e-01f, -8.88575276e-04f,
  -7.05080181e-02f, 8.40965360e-02f, -9.81948003e-02f, -2.97539448e-03f, -1.55831967e-02f, -1.14932306e-01f, -8.77671316e-02f, -5.44169806e-02f, 6.31916802e-03f, -6.38165325e-02f,
  -4.42256294e-02f, 5.20606488e-02f, -7.10345358e-02f, 2.80598383e-02f, -1.19002111e-01f, -7.97646642e-02f, 4.14967388e-02f, -3.73707674e-02f, 5.62626868e-02f, 8.94016549e-02f,
  1.13032736e-01f, 5.56471311e-02f, -1.48705602e-01f, -1.60878021e-02f, 5.87760545e-02f, -1.37628183e-01f, 9.55736414e-02f, 6.03230000e-02f, 1.41169161e-01f, 1.04771689e-01f,
  8.53759050e-02f, 8.05088580e-02f, 2.26911660e-02f, -8.47890079e-02f, 8.45067278e-02f, -1.51174702e-02f, 2.04032063e-02f, -1.20587446e-01f, 2.92528924e-02f, 5.40179014e-02f,
  -3.20071504e-02f, 6.80536404e-02f, -8.20465088e-02f, -2.54747365e-02f, -9.30219293e-02f, 4.16425131e-02f, 2.30467692e-02f, 1.09001078e-01f, 4.80002612e-02f, -7.24969953e-02f,
  -3.28373574e-02f, -4.77236584e-02f, 9.34943333e-02f, 7.11162947e-03f, -1.10848382e-01f, 1.22177139e-01f, 1.56280454e-02f, -3.53680626e-02f, 1.15937978e-01f, -3.60747352e-02f,
  1.42064780e-01f, 3.70736010e-02f, 9.79629830e-02f, -3.09581812e-02f, -1.00023463e-01f, -4.46829833e-02f, -4.72435132e-02f, 7.15757310e-02f, 1.32189961e-02f, -8.17785412e-02f,
  7.15770572e-02f, -1.19727943e-02f, 4.39498648e-02f, 5.75143211e-02f, -1.00785539e-01f, -5.32449856e-02f, 1.04951955e-01f, -9.98527557e-02f, 1.29616380e-01f, -2.06359383e-02f,
  -7.25561827e-02f, -8.70008469e-02f, 1.03319153e-01f, -8.25705305e-02f, 3.79759516e-03f, -2.93480922e-02f, -1.14110507e-01f, 5.83031625e-02f, -1.22120753e-01f, -1.87527128e-02f,
  9.39487509e-05f, -7.07289129e-02f, 1.93203762e-02f, -5.33988588e-02f, 8.14971421e-03f, -6.35170713e-02f, -5.71771786e-02f, -2.61935741e-02f, 1.97672825e-02f, -1.46778822e-02f,
  5.60649186e-02f, -8.92372802e-03f, -1.04761675e-01f, -4.06937003e-02f, -4.76286151e-02f, -2.38769762e-02f, -1.21223286e-01f, 7.10371509e-03f, 5.41237853e-02f, 1.40928879e-01f,
  -1.08476877e-01f, -2.22710986e-02f, -6.74991906e-02f, -1.21613003e-01f, -1.29414305e-01f, 2.08442891e-03f, -1.16437614e-01f, 1.39581695e-01f, -5.66520505e-02f, 9.07498524e-02f,
  2.60228030e-02f, 4.16658223e-02f, -1.28003135e-01f, -9.59298015e-02f, -2.77526285e-02f, 4.88654152e-02f, 2.24064421e-02f, -2.10570712e-02f, 1.24508537e-01f, 9.97579917e-02f,
  4.56406027e-02f, 6.08435310e-02f, -1.51002510e-02f, 9.87098515e-02f, 1.14370406e-01f, 6.96860030e-02f, 1.24689512e-01f, -5.55508910e-03f, -7.19571263e-02f, -5.80686778e-02f,
  1.40732825e-01f, 8.68843347e-02f, -1.20141856e-01f, -2.03478001e-02f, -6.13429397e-03f, 1.64639950e-01f, -1.12477235e-01f, -1.02222636e-01f, -1.73551008e-01f, -1.07858084e-01f,
  -1.38487801e-01f, 1.37331337e-01f, -2.76523437e-02f, 1.37161404e-01f, -1.59569886e-02f, -6.60952320e-03f, -5.00692762e-02f, -1.25624100e-03f, -4.39291559e-02f, 1.00328304e-01f,
  -7.35323802e-02f, -4.98246215e-02f, 9.30996537e-02f, 8.05042163e-02f, 1.43265724e-01f, 7.28477761e-02f, 4.67932560e-02f, -2.82973796e-02f, 2.97469795e-02f, 9.23315901e-03f,
  1.23408213e-01f, -1.01868890e-01f, -1.27339289e-01f, -4.20612693e-02f, 4.28899154e-02f, -3.16381678e-02f, 4.93263155e-02f, 5.17613702e-02f, -1.16130047e-01f, -3.65868397e-02f,
  -1.31486915e-02f, 1.81315035e-01f, -3.41503993e-02f, 8.72529075e-02f, 2.11048685e-02f, -2.69209780e-02f, 1.05657600e-01f, -1.06657982e-01f, 4.38807085e-02f, 8.13424140e-02f,
  -3.18258703e-02f, 8.37816596e-02f, -1.25436068e-01f, 4.74254601e-02f, 4.56060469e-02f, 5.18746562e-02f, 4.62789908e-02f, -5.12661552e-03f, 1.47469640e-01f, 3.34745735e-01f,
  1.88069254e-01f, -9.45642218e-03f, 2.53597289e-01f, 1.50373161e-01f, 9.40923244e-02f, 2.19778791e-01f, 2.83364177e-01f, -4.59773391e-02f, 2.60689825e-01f, 8.72894749e-02f,
  4.13408875e-02f, -1.75015599e-01f, 1.10067436e-02f, -6.35445639e-02f, -2.93528467e-01f, 1.08397529e-01f, -1.96272790e-01f, -1.45367369e-01f, 3.92531790e-03f, 2.86796987e-01f,
  2.62460321e-01f, 2.08907902e-01f, 4.09801960e-01f, -1.00309357e-01f, 8.63650292e-02f, 2.08420277e-01f, 2.69680381e-01f, 1.26102805e-01f, -3.27041261e-02f, -1.26173005e-01f,
  7.67677426e-02f, 2.26887893e-02f, 7.03679025e-02f, 1.07331388e-01f, 1.67272463e-01f, -1.42551392e-01f, 5.97480908e-02f, 6.93171769e-02f, 4.55839559e-02f, 1.63980648e-01f,
  -8.67557526e-02f, -2.33345300e-01f, -7.20847026e-02f, 3.54174972e-02f, 1.70100227e-01f, -1.17339328e-01f, 1.96779266e-01f, -2.82399684e-01f, -1.99729968e-02f, 1.46367192e-01f,
  -5.22362441e-02f, 2.61953145e-01f, 2.12471336e-01f, -1.23428069e-02f, 4.37569559e-01f, 8.51059407e-02f, 3.84095535e-02f, 3.01876694e-01f, 2.14757863e-02f, -2.55532917e-02f,
  1.29848704e-01f, 1.76095262e-01f, 2.99122799e-02f, -9.43818018e-02f, 9.09063444e-02f, 1.63616970e-01f, 1.61168829e-01f, -3.43640707e-02f, 6.28608614e-02f, 1.25181884e-01f,
  -4.19645017e-04f, -3.88191454e-02f, 4.58525792e-02f, 1.47524238e-01f, -1.46486893e-01f, -1.36724755e-01f, -1.85368761e-01f, -3.19945924e-02f, 1.06016755e-01f, 9.58503038e-02f,
  1.62659049e-01f, 6.83867782e-02f, -1.80543348e-01f, 3.46860401e-02f, 2.74462014e-01f, -5.61726466e-03f, -1.53325319e-01f, 9.08652022e-02f, -1.38923794e-01f, -5.82783855e-02f,
  1.18078627e-02f, 2.05185879e-02f, 1.69736110e-02f, -5.14222831e-02f, -1.52452691e-02f, 1.52108585e-02f, -9.08496231e-02f, 2.17338994e-01f, 2.42537290e-01f, 9.62602720e-02f,
  -9.43076909e-02f, -1.41209349e-01f, 1.15843378e-02f, -1.55675769e-01f, 9.30673331e-02f, 2.55215049e-01f, -7.65502825e-02f, -9.93646458e-02f, 7.39768660e-03f, 8.39616582e-02f,
  -9.49870795e-02f, 4.21006791e-02f, 5.53629845e-02f, -1.66218817e-01f, 1.71851426e-01f, -1.25787631e-01f, 5.26779555e-02f, 2.93773273e-03f, 2.07468569e-02f, 4.96243276e-02f,
  -1.49358064e-03f, -1.78462625e-01f, 9.73103452e-04f, -1.13286071e-01f, 1.47289932e-01f, 1.66276664e-01f, 2.56742448e-01f, -1.62342824e-02f, 1.25707120e-01f, 2.88450897e-01f,
  2.69487649e-01f, 3.16590548e-01f, 3.44598442e-02f, 2.56611556e-01f, 9.49736387e-02f, 3.52285296e-01f, 2.24022985e-01f, 2.60861814e-01f, 2.33327657e-01f, 4.40805614e-01f,
  -4.30559032e-02f, -5.48017137e-02f, 2.23837867e-01f, -1.90831959e-01f, -7.66617656e-02f, -2.55301207e-01f, 2.49875728e-02f, -1.50460735e-01f, -2.91401863e-01f, 8.31113979e-02f,
  1.25114217e-01f, -1.56206906e-01f, 1.19472310e-01f, 2.25973889e-01f, 9.76155251e-02f, 7.22087920e-02f, 2.45647002e-02f, 7.46656880e-02f, 2.93794900e-01f, 5.40968299e-01f,
  -2.22964305e-02f, 6.54935231e-03f, -1.38142124e-01f, 1.06978528e-01f, 1.57805890e-01f, 1.72342181e-01f, 1.70612708e-01f, -6.98665455e-02f, 2.86796004e-01f, -1.23317905e-01f,
  -1.26715794e-01f, 2.30899811e-01f, 1.23355985e-01f, -1.50017127e-01f, -1.45112529e-01f, 3.28505307e-01f, 2.07002938e-01f, 1.03994474e-01f, -1.55142590e-01f, 1.63804181e-02f,
  2.13017359e-01f, 1.17664479e-01f, 1.19229667e-01f, -6.25837445e-02f, -9.32360590e-02f, 4.48977910e-02f, 2.38401219e-01f, -7.14143068e-02f, -1.48964942e-01f, 3.58927809e-02f,
  -1.66367233e-01f, -2.12046713e-01f, 1.23207346e-01f, 3.59642208e-02f, -4.72142994e-02f, 1.90877020e-02f, 1.69899896e-01f, 4.44623008e-02f, -1.28172114e-01f, -1.71211302e-01f,
  -1.12551125e-02f, 8.77665952e-02f, -1.83128819e-01f, -1.49325669e-01f, 1.02417450e-03f, 5.18695414e-02f, -2.55264044e-01f, -9.01391357e-02f, -8.28434229e-02f, 1.24488361e-01f,
  -7.64274746e-02f, -6.33536428e-02f, 2.03021675e-01f, 1.58891201e-01f, 6.84909821e-02f, -8.91318470e-02f, 2.31941342e-02f, -6.57774061e-02f, 9.31101367e-02f, 8.59652385e-02f,
  1.42630026e-01f, -2.40154583e-02f, 1.64793178e-01f, 2.93742772e-02f, -6.09359853e-02f, 1.51947901e-01f, 2.23313764e-01f, -1.06264293e-01f, -8.67504701e-02f, -1.01927727e-01f,
  -1.27226517e-01f, 1.01325780e-01f, 8.07240605e-02f, 1.64619893e-01f, 8.74469653e-02f, 2.52423082e-02f, -9.65298563e-02f, -6.64037913e-02f, -5.03579713e-02f, -4.88981456e-02f,
  -1.59320142e-02f, 1.59493219e-02f, -5.41894324e-02f, 4.11741398e-02f, 1.04034230e-01f, -1.07019328e-01f, 2.44845375e-01f, 1.35281876e-01f, -8.46490785e-02f, 9.82326642e-03f,
  6.12310693e-02f, 2.29049418e-02f, 1.69959560e-01f, 1.60895154e-01f, 9.08160508e-02f, -1.65294945e-01f, -5.66692799e-02f, 1.42843217e-01f, -9.12499055e-02f, -7.40474761e-02f,
  9.70014110e-02f, 3.83049324e-02f, -2.90373024e-02f, -4.63218987e-02f, 4.50298488e-02f, -6.44827187e-02f, -4.17693667e-02f, -1.36726517e-02f, -1.05920814e-01f, -1.86889861e-02f,
  -8.55291933e-02f, 8.25525597e-02f, 2.22012475e-01f, 4.75443825e-02f, 1.99221056e-02f, -1.21802196e-01f, 6.16923533e-02f, 4.90115955e-02f, 1.21899277e-01f, -5.05815931e-02f,
  1.76954595e-03f, 4.52754907e-02f, -1.13369003e-01f, -1.09135903e-01f, 7.36076534e-02f, 3.11436877e-02f, -2.83393636e-02f, 4.41094376e-02f, 4.68846522e-02f, -8.03274214e-02f,
  -7.94233531e-02f, 2.23504603e-02f, 7.44910091e-02f, 4.13766988e-02f, -5.21161407e-02f, -1.69793423e-02f, 4.78970967e-02f, 3.94632965e-02f, -8.60292092e-02f, -5.10162152e-02f,
  5.09943403e-02f, 1.02428563e-01f, -9.63910744e-02f, -9.13004056e-02f, -1.18184380e-01f, -8.13592784e-03f, -5.70399389e-02f, -1.19796991e-01f, 3.00663710e-02f, -2.51744110e-02f,
  -3.52564789e-02f, -9.93304402e-02f, -7.82569200e-02f, 8.04214254e-02f, 7.49975741e-02f, -4.52762358e-02f, -6.43550232e-02f, 1.07779890e-01f, -4.39317562e-02f, -2.06868023e-01f,
  9.01147053e-02f, 1.55570582e-01f, -7.43691344e-04f, -7.65409134e-03f, 7.04673529e-02f, 5.52602448e-02f, -1.82851464e-01f, -2.03864291e-01f, -5.05561605e-02f, 3.97201665e-02f,
  -1.73158124e-01f, -1.01641327e-01f, -1.71076447e-01f, 7.93041885e-02f, -2.77844310e-01f, 2.14161206e-04f, 9.17033255e-02f, 3.57066244e-02f, 5.89829758e-02f, -4.49639000e-02f,
  -4.24761400e-02f, 1.02439113e-01f, -6.69629425e-02f, -5.59609011e-02f, -4.93869446e-02f, -7.90565163e-02f, -9.38358977e-02f, -7.46560916e-02f, 3.04153990e-02f, 3.97634916e-02f,
  -3.39144990e-02f, -2.03695508e-05f, 4.65487950e-02f, -4.43121120e-02f, 1.90520436e-01f, -9.62519646e-02f, -2.28275894e-03f, -1.64711192e-01f, 3.97092775e-02f, -1.38670042e-01f,
  -9.06619504e-02f, 1.65433437e-01f, -1.12345502e-01f, 1.23123728e-01f, 9.32388082e-02f, 5.68575934e-02f, -1.98463902e-01f, -5.64178871e-03f, -1.86439622e-02f, -3.22361626e-02f,
  1.35604233e-01f, 8.51335675e-02f, 3.44894566e-02f, 3.97284180e-02f, 1.81238085e-01f, 1.73293114e-01f, -6.27918914e-02f, 9.68995243e-02f, -1.15614153e-01f, 4.10161912e-03f,
  7.84590617e-02f, 1.31435990e-01f, 1.53024137e-01f, -6.88779801e-02f, -1.39864953e-02f, 1.34905115e-01f, 7.79543668e-02f, 8.78558159e-02f, 1.16139939e-02f, 1.80168673e-01f,
  9.62858051e-02f, -1.00850970e-01f, 8.42661224e-03f, -5.47219962e-02f, 8.58290493e-03f, -1.32076204e-01f, 1.07904404e-01f, -1.03584088e-01f, -1.50766730e-01f, 1.66220054e-01f,
  4.69653644e-02f, 6.01906516e-02f, -1.49166629e-01f, 1.51775047e-01f, 1.21871158e-01f, 1.68490157e-01f, -5.80358468e-02f, 4.42044921e-02f, 3.58449593e-02f, 5.22921123e-02f,
  1.15128912e-01f, -9.34102088e-02f, 1.53573533e-03f, -1.41495854e-01f, 1.30885690e-01f, -5.10670915e-02f, -1.14043541e-01f, -7.74496868e-02f, 8.06232356e-03f, -1.14325024e-01f,
  -7.99335092e-02f, 7.77653307e-02f, 2.59582140e-02f, 4.37368937e-02f, 3.47554567e-03f, -1.25600860e-01f, -4.27455641e-02f, 1.52702471e-02f, 8.00612643e-02f, 1.04268745e-01f,
  -4.61579524e-02f, -6.91523254e-02f, -5.35740256e-02f, -4.86279950e-02f, -4.51633669e-02f, 1.90813944e-01f, 1.78293169e-01f, -7.24870786e-02f, 2.89917052e-01f, -8.39172080e-02f,
  -5.83984889e-02f, -2.54473463e-02f, -3.60263363e-02f, 1.21711887e-01f, 8.30885395e-02f, -2.89425207e-03f, 2.19725877e-01f, 1.24046355e-01f, -1.63974706e-03f, 1.91230595e-01f,
  1.29823431e-01f, 2.20032901e-01f, 2.07639113e-01f, -1.88586712e-02f, 1.16324633e-01f, 1.06360711e-01f, 4.33980189e-02f, -3.47827794e-03f, 1.70337602e-01f, 2.18452781e-01f,
  -9.50336270e-03f, -1.17396805e-02f, 1.60959885e-01f, 6.13471009e-02f, 2.91589200e-02f, 1.88541591e-01f, -1.00845598e-01f, 3.38052139e-02f, -2.37032473e-01f, 8.45474005e-02f,
  -1.25324517e-01f, -2.24167258e-02f, -8.05342272e-02f, -5.44058043e-04f, 9.67179164e-02f, -8.91342238e-02f, -1.11172743e-01f, 1.48538753e-01f, 9.77988467e-02f, 2.48573422e-01f,
  -4.33087610e-02f, -2.43247114e-02f, -1.01320125e-01f, 1.09086409e-01f, 1.99235268e-02f, 1.91471443e-01f, -3.41419410e-03f, -6.52102977e-02f, 1.12461513e-02f, 1.82663072e-02f,
  -4.37715091e-02f, -2.17145812e-02f, -1.67757589e-02f, 7.63317123e-02f, 1.31650809e-02f, 1.97063163e-01f, -4.41863649e-02f, 4.09555286e-02f, 1.94015913e-02f, -5.17145656e-02f,
  -3.94376256e-02f, -5.06409816e-02f, -1.21751450e-01f, -1.51724815e-01f, -1.27510399e-01f, -1.56346276e-01f, 2.25376561e-01f, 7.54455402e-02f, 2.12053936e-02f, 1.38896763e-01f,
  4.08222377e-02f, 3.68459821e-02f, 9.71754193e-02f, 1.70139655e-01f, 7.17034265e-02f, 1.26776189e-01f, 7.28161633e-02f, 4.82984334e-02f, 8.08780454e-03f, -1.62583873e-01f,
  1.69512093e-01f, 4.15110551e-02f, -1.07472353e-01f, -4.37862724e-02f, 1.02653250e-01f, -6.18945397e-02f, -9.66824740e-02f, -1.16726002e-02f, -1.25780374e-01f, -1.16550401e-01f,
  -6.51934966e-02f, 6.51347563e-02f, 2.14223325e-01f, 1.55294925e-01f, -1.39697596e-01f, 7.27865994e-02f, -5.77578768e-02f, 1.16415195e-01f, 1.32060885e-01f, -5.37261814e-02f,
  -3.22629213e-02f, -1.01398736e-01f, 2.00301215e-01f, 1.17950030e-01f, -4.55399714e-02f, 3.24026570e-02f, 2.12355465e-01f, 8.12913775e-02f, 3.49440724e-02f, 1.42232329e-01f,
  -1.14094846e-01f, -1.32975712e-01f, -7.85384700e-02f, 1.96253970e-01f, 7.60013759e-02f, 1.13567151e-01f, -9.60986540e-02f, -1.32172838e-01f, -2.38026187e-01f, 1.46832183e-01f,
  2.08503962e-01f, 4.63145971e-02f, 1.50300547e-01f, -8.97602271e-03f, 2.13138476e-01f, -1.53407723e-01f, 3.42048615e-01f, -4.97496091e-02f, -9.66060013e-02f, 4.09122296e-02f,
  -1.50814354e-01f, 6.19597137e-02f, -1.76886637e-02f, 2.63014346e-01f, 1.52509451e-01f, 7.76433721e-02f, 2.02519298e-01f, 1.81682751e-01f, 7.32215494e-02f, 1.38810933e-01f,
  2.14420378e-01f, 9.16870683e-02f, 1.67644948e-01f, 3.12919617e-01f, -1.36563912e-01f, 3.11396599e-01f, 1.64773569e-01f, 2.20203221e-01f, -1.82574928e-01f, -4.15402614e-02f,
  3.50384653e-01f, -1.25456199e-01f, 1.59991145e-01f, 1.88597322e-01f, 3.64380896e-01f, -2.61330664e-01f, -5.20750701e-01f, -1.35834813e-01f, 2.49561489e-01f, -1.76128641e-01f,
  -4.32127863e-02f, 1.79932132e-01f, 1.05529390e-01f, -7.68053234e-02f, -1.09995306e-01f, 1.40822664e-01f, 2.43734829e-02f, 4.08266746e-02f, 3.69286910e-02f, -1.39035925e-01f,
  -8.99680778e-02f, 3.44420522e-02f, 2.75055200e-01f, 1.50373787e-01f, 1.98478267e-01f, 2.35777095e-01f, 3.36433530e-01f, 1.45239318e-02f, 6.37828112e-02f, 3.42164631e-03f,
  2.72602320e-01f, 2.39728153e-01f, 1.63320586e-01f, 1.26507089e-01f, -1.71535984e-01f, 6.75374269e-02f, -9.63836759e-02f, -1.23764090e-02f, -1.38752773e-01f, 1.12369195e-01f,
  -2.60221213e-01f, -2.02545136e-01f, -6.38748780e-02f, -1.40308753e-01f, 4.48466033e-01f, -1.26724467e-01f, 1.56402122e-02f, -2.61312742e-02f, 3.27726118e-02f, -4.04674746e-03f,
  -6.83395043e-02f, 1.62597392e-02f, 4.62314859e-02f, -1.62576325e-02f, 1.52482614e-01f, -7.80962873e-03f, -2.29703654e-02f, 6.71414658e-02f, 1.15648853e-02f, -1.97056346e-02f,
  1.52610704e-01f, 1.41665384e-01f, -8.58360529e-02f, -1.01006284e-01f, 1.21586621e-01f, 6.56466633e-02f, -3.59847657e-02f, 4.65472899e-02f, 1.92142442e-01f, -1.22900024e-01f,
  -1.56031743e-01f, 1.06065862e-01f, 1.77093804e-01f, 6.66837692e-02f, -9.66394171e-02f, -6.30492344e-02f, 2.11558510e-02f, -1.19596161e-01f, -6.85791969e-02f, 1.32884338e-01f,
  -2.31461674e-02f, -1.75485045e-01f, 4.93222252e-02f, -6.13023564e-02f, -1.49502724e-01f, 1.08562991e-01f, 6.29679039e-02f, 1.59964129e-01f, -1.31756231e-01f, 7.19759911e-02f,
  1.05467603e-01f, 5.31692952e-02f, -1.71563332e-03f, 1.19575426e-01f, -9.90080610e-02f, 1.95138857e-01f, 2.48626173e-01f, -1.04870848e-01f, 5.95881306e-02f, 1.11398891e-01f,
  -1.38304746e-02f, -1.53808640e-02f, -5.60818948e-02f, -6.85440376e-02f, 5.83359338e-02f, -6.09565584e-04f, 8.07535797e-02f, 1.23103604e-01f, 1.72806621e-01f, -2.66388971e-02f,
  -7.34824166e-02f, -1.47769824e-02f, 1.16989106e-01f, -9.34888721e-02f, 3.07782693e-03f, -6.07306845e-02f, 1.05609663e-01f, 1.40480608e-01f, 5.83094694e-02f, 1.33060127e-01f,
  1.34829460e-02f, -3.95540297e-02f, -1.85883325e-02f, -2.97832508e-02f, 4.33604531e-02f, 1.13817804e-01f, -1.27032977e-02f, -1.06396623e-01f, 4.09479477e-02f, -1.13070898e-01f,
  1.12192377e-01f, -7.19483271e-02f, -8.15711729e-03f, -1.51443686e-02f, 8.66294429e-02f, 2.23814324e-02f, -1.26267463e-01f, -8.60360488e-02f, 3.51323113e-02f, 1.12260133e-01f,
  6.05393648e-02f, -3.06327529e-02f, -1.00417607e-01f, 4.99611013e-02f, -1.00213096e-01f, 5.25445584e-03f, 1.76463779e-02f, 3.52896824e-02f, 6.46391660e-02f, 1.87803004e-02f,
  3.80002484e-02f, 1.24138385e-01f, -1.03438087e-01f, -5.59268110e-02f, -2.05596406e-02f, 1.26401405e-03f, -1.10717811e-01f, 9.19455290e-02f, 1.12904474e-01f, -1.18502758e-01f,
  -5.64802140e-02f, -3.27133760e-02f, 1.89352259e-02f, -1.00751556e-01f, 1.01031505e-01f, 9.00841206e-02f, -8.76672715e-02f, -1.00216314e-01f, -9.96208191e-03f, 5.20293452e-02f,
  -1.02595180e-01f, -4.44847867e-02f, -3.35415564e-02f, 7.48207048e-02f, -2.56868247e-02f, 1.41803756e-01f, 1.31673649e-01f, 7.58952051e-02f, 6.83842748e-02f, 1.66578487e-01f,
  -6.43187612e-02f, 1.24068163e-01f, -4.15263064e-02f, 3.20533663e-02f, -3.76904011e-02f, 8.43220353e-02f, 3.52149568e-02f, 3.01158838e-02f, -9.82711613e-02f, -4.10761535e-02f,
  2.48110387e-02f, -7.27967843e-02f, -6.56335726e-02f, 1.11239497e-03f, -6.02391027e-02f, 1.51108533e-01f, 1.31425470e-01f, 1.40233353e-01f, 3.76844406e-02f, -5.78678921e-02f,
  -1.97047647e-02f, 1.02106035e-01f, -2.88608093e-02f, -4.06959541e-02f, 3.70078273e-02f, 3.30762118e-02f, -8.01529437e-02f, 9.29841548e-02f, -6.64940178e-02f, -1.45716146e-01f,
  6.16642758e-02f, -2.63243467e-02f, -9.73514840e-02f, 1.24863148e-01f, 1.59409463e-01f, -3.21085602e-02f, -1.05596550e-01f, 1.61181539e-01f, -1.32540509e-01f, -1.55808115e-02f,
  -1.08655378e-01f, -4.45515253e-02f, 1.89226177e-02f, 2.30404079e-01f, 1.71325892e-01f, 3.57463136e-02f, -1.19080931e-01f, -1.22211263e-01f, -1.30109806e-02f, 2.06372514e-03f,
  -3.12888920e-02f, 2.56763268e-02f, 1.25844181e-01f, -1.17415242e-01f, -9.37785506e-02f, 1.57149434e-01f, 9.74372327e-02f, -1.24980785e-01f, 7.61256441e-02f, -5.36213107e-02f,
  2.81200707e-01f, 2.93792993e-01f, -8.93092975e-02f, 7.83240646e-02f, 4.25327718e-02f, 1.22846894e-01f, 2.39050195e-01f, 8.61201212e-02f, 5.88208660e-02f, -7.73555115e-02f,
  2.66456842e-01f, 2.01433167e-01f, -9.86678451e-02f, 2.77626924e-02f, -2.63531148e-01f, -1.99229680e-02f, 3.44260931e-01f, -6.28701597e-02f, 1.16229214e-01f, 8.47165436e-02f,
  -4.53200877e-01f, 4.18785900e-01f, 2.33054580e-03f, -1.55595392e-01f, -2.28822544e-01f, 2.77038682e-02f, -1.57146566e-02f, -2.05907777e-01f, 4.35130186e-02f, -1.59403577e-01f,
  7.40727931e-02f, -1.58245433e-02f, 9.18889269e-02f, 3.16234857e-01f, -1.16398558e-01f, 1.90210596e-01f, 1.65065885e-01f, 3.02213477e-03f, -6.52450472e-02f, 7.72167891e-02f,
  1.28037214e-01f, -1.00128837e-01f, -3.81299704e-02f, 3.35180014e-02f, 1.24389268e-02f, -1.44966483e-01f, -8.71036761e-03f, 2.26348788e-01f, -4.87806723e-02f, 3.74277025e-01f,
  7.29529113e-02f, -1.50156245e-01f, 1.22134060e-01f, -5.55922948e-02f, 1.34564534e-01f, -1.16804659e-01f, 1.42377838e-01f, -1.79204702e-01f, -1.45585865e-01f, -2.35638320e-01f,
  6.69614300e-02f, -1.47894800e-01f, -6.38753548e-02f, 1.25929594e-01f, 1.76814478e-02f, 1.68057650e-01f, 7.94032887e-02f, 2.03416739e-02f, 1.39580429e-01f, 3.83238904e-02f,
  -6.37325272e-03f, 5.90784438e-02f, -6.18950576e-02f, 9.24985185e-02f, 1.42356455e-02f, 1.28529623e-01f, 5.18284142e-02f, -5.85909560e-02f, 8.86444747e-02f, -3.53728309e-02f,
  1.65360514e-02f, 5.88965695e-03f, -1.16829008e-01f, -1.44988552e-01f, 5.33624664e-02f, 1.30921036e-01f, -1.99115187e-01f, -4.56211418e-02f, 1.25703961e-01f, 7.80721232e-02f,
  -1.80626642e-02f, -1.33404983e-02f, -4.12518485e-03f, -1.11387357e-01f, -4.33062240e-02f, 1.56123629e-02f, 6.71758726e-02f, 1.48351401e-01f, -9.53389332e-02f, -1.49412796e-01f,
  6.41989186e-02f, 4.04220028e-03f, 1.44341409e-01f, 2.10772846e-02f, 2.42189001e-02f, 9.07270014e-02f, 6.38214778e-03f, -1.36931285e-01f, -4.86953706e-02f, 1.45802289e-01f,
  1.42071530e-01f, 1.59960091e-02f, -2.38432642e-02f, 1.52023723e-02f, 1.00445792e-01f, 1.45276695e-01f, 9.13429782e-02f, -1.34165119e-02f, -9.52032357e-02f, 2.37454544e-03f,
  4.35069837e-02f, 5.83083592e-02f, 6.09111376e-02f, 1.08302295e-01f, 1.86937153e-01f, 1.14144996e-01f, 1.62669849e-02f, -1.23485431e-01f, 6.41912073e-02f, -3.76726314e-02f,
  -9.70019624e-02f, -2.52900077e-06f, 9.39761400e-02f, -6.05998524e-02f, 7.59318247e-02f, 8.98302794e-02f, 2.53924932e-02f, 6.06960617e-02f, 2.45976727e-02f, 1.83652028e-01f,
  4.89231199e-02f, -1.33756129e-02f, -1.96119353e-01f, 1.35200053e-01f, -6.94057420e-02f, 1.75589129e-01f, 1.24480754e-01f, 9.32911932e-02f, 2.91495949e-01f, -1.53348967e-01f,
  -2.61402488e-01f, -2.18905434e-02f, 1.59760028e-01f, -2.30137389e-02f, -1.49356574e-02f, -8.90354291e-02f, 2.28348617e-02f, -1.08827181e-01f, -7.62136281e-02f, 2.95287911e-02f,
  -2.21709721e-02f, 4.00738232e-02f, -9.41084400e-02f, -5.05377911e-02f, -1.58487782e-01f, -2.80981092e-03f, 1.09666079e-01f, 1.75110996e-01f, 7.92273358e-02f, 1.64709106e-01f,
  1.31618008e-01f, -5.75925708e-02f, -1.24490283e-01f, 7.73536339e-02f, 1.38188139e-01f, 2.11163133e-01f, 2.78004676e-01f, -1.70877099e-01f, -1.53660566e-01f, -9.56378505e-02f,
  -5.78299426e-02f, -1.02558590e-01f, -1.67822186e-02f, 2.23932296e-01f, -3.43188606e-02f, -1.21545598e-01f, 1.09664008e-01f, 9.62963551e-02f, 1.60761625e-01f, -1.30947858e-01f,
  4.11933661e-02f, 5.68078421e-02f, -1.19367264e-01f, 1.73937064e-03f, 6.43498003e-02f, 2.14593634e-02f, -3.13039273e-02f, 1.05137765e-01f, -5.95643818e-02f, 7.12587684e-02f,
  -5.85928671e-02f, 6.56590387e-02f, -1.11681662e-01f, 1.19934969e-01f, -2.50582732e-02f, -1.35357127e-01f, -6.44539222e-02f, 1.02419920e-01f, -1.30124599e-01f, -2.59711239e-02f,
  8.05135816e-02f, 9.83647630e-02f, -5.28885163e-02f, -1.22140065e-01f, 1.01672255e-01f, -3.14816535e-02f, 1.09403253e-01f, 6.59493506e-02f, -6.85735792e-02f, 5.33075333e-02f,
  -1.07183576e-01f, 9.44873169e-02f, 9.87319574e-02f, 8.41161385e-02f, -1.24325855e-02f, -9.88519639e-02f, 4.14957218e-02f, -8.57249945e-02f, 2.18910538e-02f, 1.29221782e-01f,
  6.69335499e-02f, -2.62667853e-02f, -6.76805973e-02f, 3.97695862e-02f, 1.09177597e-01f, 4.42999369e-03f, 1.14306808e-01f, -2.00809930e-02f, -1.88276153e-02f, -5.18554524e-02f,
  7.68791586e-02f, 7.43448362e-02f, 7.11374879e-02f, -9.18038413e-02f, 3.53753604e-02f, -1.27201572e-01f, -4.64758575e-02f, -1.92973148e-02f, 5.20540364e-02f, 9.72981825e-02f,
  3.16485278e-02f, 3.83874737e-02f, 1.24930985e-01f, -9.62012485e-02f, -3.90701648e-03f, 1.12566605e-01f, 1.50803268e-01f, 2.47867018e-01f, 2.48110309e-01f, -5.83294407e-03f,
  2.05418661e-01f, 2.04324014e-02f, 1.35809511e-01f, 2.40697041e-01f, -4.18156348e-02f, 1.13466978e-01f, 1.52685627e-01f, 9.13842097e-02f, -3.95824946e-02f, -7.93201923e-02f,
  -3.12769040e-02f, -1.49492681e-01f, -2.14766655e-02f, -6.40746579e-02f, -4.76123244e-02f, -2.25673229e-01f, -7.87090808e-02f, 2.85170883e-01f, 6.49987385e-02f, 2.00979754e-01f,
  -8.77453387e-02f, 1.77785065e-02f, 2.75085326e-02f, 4.58448827e-02f, 1.48678243e-01f, 5.92175126e-03f, 8.18603560e-02f, -1.29555658e-01f, 1.16442844e-01f, 1.58177257e-01f,
  4.13377546e-02f, -4.06662226e-02f, 1.30616888e-01f, 8.39609131e-02f, 2.66759116e-02f, -3.73588167e-02f, -1.04680881e-01f, 5.73792234e-02f, 8.66375864e-02f, 1.19194388e-01f,
  1.01859584e-01f, 9.08863842e-02f, 3.59022021e-02f, -6.32509366e-02f, -1.58401087e-01f, -7.29504749e-02f, 5.66182248e-02f, 2.97218207e-02f, -6.07212409e-02f, 4.81511243e-02f,
  1.52017534e-01f, -1.28940687e-01f, 2.96339661e-01f, -1.43297752e-02f, -1.38082147e-01f, 1.42849892e-01f, -1.53092027e-01f, -4.23117615e-02f, 9.30216685e-02f, -5.79379648e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 40)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 40;
const float L3_fan_Bp_bar_data[] = {
  6.28088266e-02f, 9.55784842e-02f, 2.87203267e-02f, 1.25446990e-01f, 1.09363846e-01f, 5.11311330e-02f, 3.10668303e-03f, 1.53874105e-03f, 1.51276097e-01f, -5.97986486e-03f,
  1.25364035e-01f, 8.38556588e-02f, -5.84147908e-02f, 2.79317554e-02f, 8.05560797e-02f, 4.54110578e-02f, 8.99150446e-02f, -8.43897182e-03f, 5.99124469e-02f, -4.72290851e-02f,
  -9.65676680e-02f, -6.42350316e-02f, 7.96767473e-02f, 2.17320040e-01f, 1.21463895e-01f, 1.45626128e-01f, 8.84812772e-02f, 1.54289708e-01f, -5.41705117e-02f, 3.31704319e-02f,
  -8.55346769e-03f, 1.51220441e-01f, 1.42853692e-01f, 1.21813402e-01f, 5.46490960e-02f, 3.25486511e-02f, -3.43273692e-02f, 1.41970515e-01f, -7.47702792e-02f, 1.90047562e-01f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  2.59648830e-01f, -2.04176039e-01f, -8.50825757e-02f, -1.25670657e-01f, -7.67707452e-02f, 2.09171474e-01f, -1.66683972e-01f, -1.34914622e-01f, 2.28156492e-01f, -5.79801127e-02f,
  2.51295090e-01f, 4.69921231e-02f, 1.37293011e-01f, -3.08721185e-01f, 4.03944165e-01f, -2.67517745e-01f, 2.88940579e-01f, 2.96942447e-03f, -2.48674259e-01f, -3.65127176e-01f,
  2.62367398e-01f, -1.33460369e-02f, 3.41429487e-02f, 1.21743500e-01f, -1.56354859e-01f, -2.86992431e-01f, -2.90927500e-01f, 2.77601063e-01f, -2.78496832e-01f, -6.82249963e-02f,
  7.10706711e-02f, -1.89830773e-02f, -1.10765368e-01f, -9.51966420e-02f, 1.02339506e-01f, 8.35988447e-02f, -9.93571132e-02f, -1.86743364e-01f, 2.67448545e-01f, -1.62433505e-01f,
  -7.05071092e-02f, -7.00239837e-02f, -2.04836428e-02f, 9.45487469e-02f, 2.90525034e-02f, -2.21906140e-01f, 6.64002538e-01f, -2.18306974e-01f, 9.29334536e-02f, 3.90420780e-02f,
  -1.29521146e-01f, -1.86999708e-01f, 2.82441944e-01f, -1.28852949e-01f, 1.53617471e-01f, -4.11594778e-01f, -5.02946898e-02f, -2.26414353e-02f, 1.47507787e-01f, -3.93429041e-01f,
  -4.01907600e-03f, -2.88544923e-01f, 1.07077910e-02f, 3.43788475e-01f, 3.31871301e-01f, 5.93039207e-02f, 5.50590396e-01f, -5.42260073e-02f, 1.15814358e-01f, 1.89899758e-01f,
  1.29703125e-02f, -3.00784726e-02f, 2.13090956e-01f, 4.36221175e-02f, -8.70173872e-02f, 3.59314471e-01f, 5.87926246e-02f, -1.95112765e-01f, -6.30156025e-02f, -2.85759479e-01f,
  -4.42904919e-01f, 3.78566206e-01f, -3.06794733e-01f, -2.20217302e-01f, -4.53218788e-01f, -1.44140095e-01f, -2.82528937e-01f, -1.02457300e-01f, 7.98524693e-02f, -2.74659634e-01f,
  -1.46121100e-01f, -9.69061032e-02f, -1.96665898e-01f, -1.71406925e-01f, 4.10195291e-02f, -4.66922186e-02f, -4.05244604e-02f, -2.12798402e-01f, -3.80959213e-02f, 1.91611350e-02f,
  -9.96569619e-02f, -2.14256849e-02f, 1.11864708e-01f, -4.06128131e-02f, 6.77326024e-02f, -1.43645868e-01f, -7.17033297e-02f, 6.10917062e-02f, 9.51453745e-02f, -2.93942783e-02f,
  2.89972186e-01f, -1.74997523e-01f, 4.14441526e-01f, -4.33291234e-02f, -3.53254960e-04f, 7.14818686e-02f, -2.47559845e-02f, 8.40901509e-02f, -1.94638461e-01f, 3.61728519e-01f,
  1.60369888e-01f, 2.76352838e-02f, -3.08985580e-02f, -5.28501511e-01f, 2.54244566e-01f, 1.45088762e-01f, 7.61026219e-02f, -2.62136920e-03f, -7.19276741e-02f, -1.80750843e-02f,
  -2.56537169e-01f, 5.39031532e-03f, -3.50004613e-01f, -7.98269548e-03f, 2.39512064e-02f, -1.72296032e-01f, -4.25685495e-01f, 1.71664149e-01f, -2.23187953e-01f, -6.05024025e-02f,
  -4.16377515e-01f, 3.14209491e-01f, -5.27679741e-01f, 2.25836724e-01f, -4.19166058e-01f, 1.40968427e-01f, 3.02247554e-01f, 2.74522811e-01f, -1.98252514e-01f, -4.98599149e-02f,
  -8.53594020e-02f, -2.73626894e-01f, -1.38000855e-02f, -3.25691700e-01f, 1.93597019e-01f, -3.79785836e-01f, -3.27018708e-01f, 1.59126148e-01f, -1.16539061e-01f, 8.76175016e-02f,
  1.06081605e-01f, 2.02170126e-02f, -2.60652423e-01f, -4.61354014e-03f, 1.01348357e-02f, -3.10684681e-01f, 8.41331258e-02f, 2.49160528e-01f, -5.33034876e-02f, -3.23094577e-02f,
  1.10544711e-01f, -6.35720342e-02f, -9.82182175e-02f, -1.74693137e-01f, -3.18715841e-01f, -1.84849799e-01f, 4.48689073e-01f, -1.05254546e-01f, 1.42699718e-01f, -3.22010810e-03f,
  -5.27758971e-02f, 3.53515930e-02f, -6.18980192e-02f, 6.51817083e-01f, 4.37722206e-02f, 6.59207031e-02f, -2.27466479e-01f, -4.98928159e-01f, -1.02839768e-02f, 3.12530339e-01f,
  2.54075695e-02f, -2.23307922e-01f, -3.05659384e-01f, -2.49643475e-01f, -9.25303772e-02f, -3.30777951e-02f, -1.21476620e-01f, 3.05534713e-02f, -1.81217805e-01f, 1.06067069e-01f,
  -1.32032439e-01f, -2.09005564e-01f, -2.48153418e-01f, -3.84327888e-01f, 7.80128390e-02f, -2.42008612e-01f, -7.73471296e-02f, 6.16797842e-02f, 3.90086919e-02f, 1.14973098e-01f,
  1.27557861e-02f, 2.36115053e-01f, 2.48081684e-01f, 2.10130420e-02f, 3.21486115e-01f, 1.55305520e-01f, 4.32343781e-02f, 1.16730198e-01f, -4.73919548e-02f, 3.00208956e-01f,
  2.67426282e-01f, -1.34262830e-01f, -1.06005475e-01f, -8.74931440e-02f, -4.10070308e-02f, 3.99036743e-02f, 3.36902775e-03f, 5.81658222e-02f, 3.62740517e-01f, 4.72884744e-01f,
  2.19533946e-02f, 6.52444363e-02f, -4.21192423e-02f, 6.01092502e-02f, -1.14207648e-01f, -6.87782392e-02f, 1.32822901e-01f, 8.66248459e-02f, 4.02810305e-01f, 1.10811241e-01f,
  -6.35484815e-01f, 1.44745722e-01f, -6.96037081e-04f, -7.07741380e-02f, 1.77015901e-01f, -2.33694077e-01f, -3.85364518e-02f, -5.31550288e-01f, -4.35054898e-02f, -2.92978007e-02f,
  3.56923528e-02f, -2.77028922e-02f, -2.22341061e-01f, -5.63193224e-02f, -9.86763313e-02f, -1.37392402e-01f, 1.51722252e-01f, 2.43241694e-02f, -1.57780513e-01f, 1.24730721e-01f,
  -1.38786912e-01f, 2.60019209e-03f, 1.44204915e-01f, 8.13074782e-02f, -3.30290169e-01f, 2.08572075e-01f, 7.59906769e-02f, 6.16184212e-02f, 7.33799785e-02f, 3.60096283e-02f,
  -5.97125553e-02f, 1.45514786e-01f, 6.99177384e-02f, -3.40633184e-01f, -1.00901648e-01f, -2.26983398e-01f, 8.26048926e-02f, 1.07080396e-02f, 3.66535485e-01f, 4.40569408e-02f,
  -1.18369602e-01f, -2.74373684e-02f, -2.15144783e-01f, 2.08410531e-01f, 5.31095006e-02f, -1.96497142e-02f, 2.50836879e-01f, -1.25390813e-01f, 1.41444713e-01f, 1.39911354e-01f,
  8.55216533e-02f, 4.29372862e-02f, -2.91619506e-02f, -9.56590772e-02f, -1.06256820e-01f, 4.73625734e-02f, -1.76957771e-01f, 2.05763895e-02f, -3.47642489e-02f, 5.97118139e-02f,
  -7.09956884e-02f, 3.24605666e-02f, 2.46006474e-01f, 2.84619838e-01f, -1.65317014e-01f, 6.99426234e-02f, -3.54343280e-02f, 5.74950799e-02f, 2.09548488e-01f, 6.10410087e-02f,
  4.78164017e-01f, -4.72788811e-01f, -3.42380777e-02f, 1.90775424e-01f, -1.62911311e-01f, 4.39087421e-01f, -2.00592637e-01f, -2.03439474e-01f, -1.62432477e-01f, 3.51858258e-01f,
  2.32793167e-01f, 2.75908679e-01f, -2.56224126e-01f, 7.62452334e-02f, -6.96759149e-02f, 1.69949800e-01f, -1.75593451e-01f, 4.80282726e-03f, 4.80738375e-03f, 1.37619108e-01f,
  1.90382719e-01f, 1.83369949e-01f, 1.33933529e-01f, 1.23219676e-01f, 3.82928461e-01f, -3.50829102e-02f, 1.97983205e-01f, -2.58451015e-01f, -1.22113258e-03f, -2.05542609e-01f,
  3.57144237e-01f, -7.16949850e-02f, -1.87864289e-01f, -1.72490075e-01f, 9.26396996e-02f, -8.64720996e-03f, 8.23880434e-02f, 1.93936646e-01f, -1.37825124e-02f, -1.15199210e-02f,
  2.02335715e-01f, -1.27178118e-01f, -6.17110915e-02f, -5.94841093e-02f, 1.27493352e-01f, -1.28908932e-01f, -1.37390539e-01f, 1.24785021e-01f, -8.45349655e-02f, 6.76520243e-02f,
  2.78925836e-01f, 4.66041230e-02f, 9.41471159e-02f, -9.17653367e-03f, -2.38691419e-02f, -1.01057641e-01f, 9.86557156e-02f, -2.54492342e-01f, 2.15923697e-01f, -7.02207014e-02f,
  -8.59575868e-02f, -2.40433961e-02f, 1.21296972e-01f, 2.21347958e-01f, 5.05992286e-02f, 1.75744995e-01f, -8.60141069e-02f, -2.47430392e-02f, -1.82933686e-03f, 3.29718828e-01f,
  1.71852961e-01f, -4.68083844e-02f, -9.67767760e-02f, 1.51832655e-01f, 9.75824147e-02f, -2.29184300e-01f, 4.43664432e-01f, 1.97378561e-01f, 1.71715513e-01f, 1.12203322e-01f,
  2.58882344e-01f, 1.57324940e-01f, 1.84215233e-01f, 1.19475499e-01f, -1.08858846e-01f, -7.43262544e-02f, -4.70706433e-01f, 3.86106372e-01f, -8.17735046e-02f, -4.64028679e-02f,
  -5.93419597e-02f, -2.22857341e-01f, 4.27929871e-02f, 1.75546899e-01f, -3.06562155e-01f, 2.68986076e-01f, -2.91922390e-01f, -2.47462854e-01f, 7.62823001e-02f, -5.01545593e-02f,
  2.36787185e-01f, -2.64543533e-01f, -4.24044020e-02f, 6.57665133e-02f, -1.27063151e-02f, -1.16371132e-01f, 4.27383482e-02f, 2.56024063e-01f, -1.37392923e-01f, -1.04988337e-01f,
  -1.81553215e-01f, -2.42668629e-01f, -3.02155223e-02f, 8.60646069e-02f, -1.10915741e-02f, -1.41423047e-01f, 5.83242252e-02f, -6.65138587e-02f, 9.19035450e-03f, 3.71870957e-02f,
  -5.01014233e-01f, 1.69948623e-01f, 3.33712965e-01f, -1.91112310e-01f, -4.44461592e-03f, -1.86670586e-01f, -6.34298101e-02f, 4.42986608e-01f, -2.40058348e-01f, 3.80139798e-01f,
  -7.11151212e-02f, 9.42522436e-02f, -8.36404189e-02f, 3.76040816e-01f, -9.34761912e-02f, -1.42399803e-01f, 2.37168223e-02f, -2.41617560e-01f, -5.60665190e-01f, 1.85365990e-01f,
  -2.66719520e-01f, -5.49995042e-02f, 2.13082600e-02f, 7.97915459e-02f, 8.61924961e-02f, -1.01187013e-01f, -1.62351370e-01f, 2.36366153e-01f, -1.01607844e-01f, -8.11748356e-02f,
  4.28981572e-01f, 6.32649735e-02f, 3.49250317e-01f, 4.09680843e-01f, 6.17398098e-02f, -1.13650993e-01f, 1.32307157e-01f, 1.42485112e-01f, 5.66935316e-02f, -2.65126955e-03f,
  2.27434888e-01f, 1.62649125e-01f, -1.25140131e-01f, 1.77999556e-01f, -1.81681991e-01f, -1.15776971e-01f, 1.11437045e-01f, -6.04698025e-02f, -2.03493968e-01f, 2.67203432e-02f,
  3.10467541e-01f, -2.46481985e-01f, -2.47533187e-01f, -5.05057387e-02f, 2.85138071e-01f, 1.20549142e-01f, -2.48279907e-02f, 6.84859529e-02f, -2.37531424e-01f, -7.63075128e-02f,
  -9.12165940e-02f, 5.44758178e-02f, -4.58362550e-02f, 1.41123295e-01f, -1.67569682e-01f, 3.80374879e-01f, -5.62064171e-01f, 5.10099590e-01f, 1.59720764e-01f, 5.77497721e-01f,
  1.78830922e-01f, -3.26154947e-01f, 2.21607059e-01f, -3.77964497e-01f, -1.97349250e-01f, 6.60267025e-02f, -7.91974738e-03f, -1.83887899e-01f, -6.20039962e-02f, -1.02611817e-01f,
  2.65086204e-01f, 7.45451357e-03f, 1.13081619e-01f, -9.02007818e-02f, -9.58793089e-02f, -2.17184484e-01f, -5.12191355e-02f, -2.82500029e-01f, -9.78413820e-02f, 1.22320160e-01f,
  2.65181083e-02f, -1.84959501e-01f, 1.45474270e-01f, 1.36591554e-01f, -4.31934297e-01f, -2.19549447e-01f, -3.91313583e-01f, -1.50231734e-01f, -1.72077060e-01f, 2.51673341e-01f,
  2.27116570e-01f, -2.94690013e-01f, -2.37556040e-01f, -2.62212992e-01f, -1.86260752e-02f, -2.49591634e-01f, 1.01230867e-01f, 3.09528440e-01f, -1.46088928e-01f, -1.69758406e-02f,
  -1.06346838e-01f, 2.09420145e-01f, -3.08077604e-01f, 3.05678070e-01f, 6.43987730e-02f, 4.52807695e-02f, -3.80079038e-02f, 2.00769752e-01f, -1.31342053e-01f, 2.37791643e-01f,
  -5.76290973e-02f, 1.34039700e-01f, 2.76853591e-01f, 4.50692251e-02f, 4.83536534e-02f, -6.36244938e-02f, 1.23693466e-01f, -6.13433607e-02f, -5.27151883e-01f, -1.79076508e-01f,
  -1.28075585e-01f, 3.17356922e-02f, -4.03443500e-02f, -3.94188091e-02f, -1.88926220e-01f, 3.05077851e-01f, -1.66755348e-01f, 4.91346478e-01f, 3.82031769e-01f, 1.91332288e-02f,
  1.76066354e-01f, -1.09669492e-01f, 3.36048901e-02f, 1.75159767e-01f, 8.22464824e-02f, -3.73306185e-01f, -1.76558942e-01f, -2.53310531e-01f, 2.90789306e-01f, -1.77616075e-01f,
  -7.80467838e-02f, -6.01428598e-02f, -2.34121177e-02f, -2.57132828e-01f, -6.22833101e-03f, -6.67536408e-02f, -2.67747287e-02f, -1.34348914e-01f, -5.17460704e-01f, 3.65403444e-01f,
  1.28752455e-01f, -1.86175138e-01f, 2.28458017e-01f, -5.80298826e-02f, -6.05477616e-02f, -2.69869238e-01f, 3.19675319e-02f, 2.96426028e-01f, -1.90713570e-01f, -4.03146565e-01f,
  -2.35986686e-03f, -1.52088448e-01f, -1.15642741e-01f, -2.16462806e-01f, -4.15201455e-01f, 5.13528241e-03f, 5.30944765e-01f, -2.27626730e-02f, -3.35448165e-03f, 1.71104550e-01f,
  -1.01888932e-01f, 1.56291395e-01f, -1.41683787e-01f, -4.18211073e-01f, -7.87337050e-02f, -1.02089085e-02f, 5.66285253e-02f, 1.42397121e-01f, 6.65275156e-02f, 6.01851046e-02f,
  -8.26155487e-03f, -6.85973093e-02f, -1.16733246e-01f, -2.26299763e-02f, 6.46082044e-01f, 2.06491277e-02f, 1.88293494e-02f, -1.09754905e-01f, -1.45947188e-01f, 6.58160076e-02f,
  3.57608080e-01f, -1.99231565e-01f, -1.94159567e-01f, 5.36310673e-02f, -2.49587253e-01f, 2.54498243e-01f, 9.19321552e-02f, -3.49286824e-01f, -1.44335628e-01f, 2.51997113e-01f,
  -5.12417704e-02f, -1.93670377e-01f, 2.70704091e-01f, -5.01517057e-02f, 2.31235340e-01f, -2.24940762e-01f, -1.37391433e-01f, -3.75437438e-02f, 1.05085224e-01f, -2.48066813e-01f,
  -2.48270910e-02f, -3.11872751e-01f, 2.97549307e-01f, -6.74421638e-02f, 5.76241836e-02f, -1.52957276e-01f, 1.72640439e-02f, 3.54811460e-01f, -2.38690406e-01f, 2.68128097e-01f,
  -3.51438165e-01f, -1.62199903e-02f, -1.26153484e-01f, 4.29160327e-01f, -9.83273685e-02f, 1.15244247e-01f, 1.70271948e-01f, -5.24625974e-03f, 3.09913397e-01f, 2.34480239e-02f,
  -2.52299726e-01f, -7.67493993e-02f, -1.53056622e-01f, -5.89933768e-02f, 1.33203134e-01f, -1.23280995e-01f, 6.07914552e-02f, 1.42177567e-01f, -1.04199044e-01f, -1.27022043e-01f,
  1.62605390e-01f, -1.38142049e-01f, 4.80285324e-02f, -3.58381085e-02f, 6.64434955e-02f, 9.20946375e-02f, 2.12711945e-01f, -9.60631594e-02f, -3.93148810e-01f, -2.18426630e-01f,
  1.08793989e-01f, -1.53173983e-01f, 1.78320352e-02f, -6.36022612e-02f, -2.00605109e-01f, 2.65755922e-01f, 2.07650915e-01f, -1.39090106e-01f, 1.60090715e-01f, -6.86652064e-02f,
  2.27569360e-02f, 4.19670165e-01f, 9.57255810e-02f, -1.44816250e-01f, 4.30863313e-02f, 1.04353972e-01f, 7.60177523e-02f, 1.89250156e-01f, 4.17280495e-02f, 9.13272947e-02f,
  1.64724886e-01f, 1.96747575e-02f, 2.66781926e-01f, 1.49891600e-01f, 9.58386958e-02f, -8.53956863e-03f, 5.43425560e-01f, -1.34394094e-01f, 2.78065354e-01f, 1.98821113e-01f,
  1.94611773e-02f, 2.31602862e-01f, 9.10043418e-02f, 2.87182480e-01f, 2.07835838e-01f, -1.12434201e-01f, -2.19766852e-02f, 2.56346494e-01f, 1.77490592e-01f, 4.10729438e-01f,
  2.30977833e-01f, 1.53911561e-01f, 5.07498264e-01f, 1.87404886e-01f, -2.33218014e-01f, -1.48789212e-01f, 5.21021672e-02f, 8.61649215e-02f, 1.40065681e-02f, -1.60596997e-01f,
  1.92648724e-01f, 1.58895224e-01f, -2.21175775e-01f, -5.74499369e-02f, 7.46232048e-02f, 3.52170207e-02f, 2.23487727e-02f, -8.74759555e-02f, -9.56199095e-02f, 2.70288587e-02f,
  -4.38792825e-01f, 2.87597984e-01f, -3.84117275e-01f, -3.19048762e-01f, 1.17556803e-01f, -1.46131992e-01f, -8.97621810e-02f, 5.12060970e-02f, -2.50022233e-01f, -1.74956083e-01f,
  -1.30686074e-01f, -1.18453875e-01f, 3.54390517e-02f, 3.94843429e-01f, -1.46980792e-01f, -3.47030684e-02f, -2.28463113e-02f, -6.58968687e-02f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -1.33343749e-02f, 2.66887713e-02f, 8.15336779e-02f, -1.28576547e-01f, 6.82607368e-02f, -1.65489018e-01f, -6.20321967e-02f, 1.93051353e-01f, -1.69623539e-01f, -1.14157252e-01f,
  9.99882165e-03f, 1.53766766e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    