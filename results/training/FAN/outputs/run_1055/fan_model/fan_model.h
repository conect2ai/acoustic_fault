/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -9.95321393e-01f, 3.35604578e-01f, 2.70284742e-01f, -2.86623865e-01f, 2.41413862e-01f, 1.45999178e-01f, 3.82026345e-01f, -7.35957772e-02f, -2.77075887e-01f, 1.47567138e-01f,
  9.32490304e-02f, -1.33811131e-01f, -1.21206708e-01f, -1.70709178e-01f, -1.38257205e-01f, 2.03114763e-01f, 2.02797517e-01f, -2.44308501e-01f, -2.78537661e-01f, -1.06776685e-01f,
  1.28711447e-01f, -5.57077751e-02f, -2.35264316e-01f, -1.24183804e-01f, 5.25364466e-02f, 1.77452579e-01f, 2.74873614e-01f, 1.18542850e-01f, 2.50751078e-01f, -7.11933970e-02f,
  -1.43872807e-02f, -5.83519749e-02f, -1.11849001e-03f, -1.01611301e-01f, 1.06234618e-01f, -1.04735848e-02f, 6.95063248e-02f, 2.88003553e-02f, 5.61955087e-02f, 1.72269624e-02f,
  -6.77447170e-02f, 2.46727094e-02f, 2.51176376e-02f, 5.57796359e-02f, 3.53720896e-02f, -2.74442676e-02f, -1.32746007e-02f, -1.29806221e-01f, 1.66076012e-02f, 8.71782452e-02f,
  8.65931809e-02f, 4.42474149e-02f, -4.44035754e-02f, 9.06071961e-02f, -3.48019339e-02f, -1.18671849e-01f, -4.97541614e-02f, -6.60783947e-02f, -4.56780382e-03f, 4.20862660e-02f,
  1.49606392e-02f, 4.75808531e-02f, 1.95004009e-02f, 1.93575509e-02f, 1.84157547e-02f, -7.68243670e-02f, 1.16289305e-02f, -4.05092537e-02f, -3.56878415e-02f, -5.14390655e-02f,
  -6.01165136e-03f, 1.78049505e-02f, -4.24806066e-02f, 9.02958438e-02f, 1.29823750e-02f, -4.11312468e-02f, 1.71266142e-02f, 7.60237202e-02f, -1.90985128e-02f, 1.01072015e-02f,
  -4.42531668e-02f, 1.61695201e-02f, 5.34880869e-02f, -5.29823266e-02f, 8.59732851e-02f, 3.43244225e-02f, -5.53768575e-02f, 4.08863798e-02f, -2.33093021e-03f, 1.39394179e-02f,
  6.80323243e-02f, 9.49559826e-03f, -8.55664760e-02f, -5.88483736e-02f, -7.55997002e-03f, 4.31314521e-02f, -3.56992544e-03f, 1.69140734e-02f, 9.76298284e-03f, -5.81059232e-02f,
  2.77568661e-02f, -2.50933096e-02f, 8.46542194e-02f, 2.25516837e-02f, -5.65777607e-02f, 5.19238189e-02f, 6.32484853e-02f, -1.84277352e-02f, -2.41975859e-03f, -5.91176935e-02f,
  4.49196361e-02f, -4.38502096e-02f, -6.01899214e-02f, 1.04318105e-03f, -4.68840748e-02f, -6.03366196e-02f, 1.52811557e-01f, -4.09651361e-02f, 4.81167883e-02f, 1.67797342e-01f,
  5.08804508e-02f, -1.83165744e-01f, 1.62602186e-01f, -1.95365593e-01f, -1.12154916e-01f, 7.50165507e-02f, -1.81897357e-02f, -6.58073649e-03f, -6.18384294e-02f, -3.81417200e-02f,
  -1.38110176e-01f, 1.04446143e-01f, 1.50824994e-01f, 2.17451096e-01f, 2.00728118e-01f, 7.70932287e-02f, 8.22700262e-02f, 2.73753047e-01f, 3.78361553e-01f, 9.59629193e-02f,
  5.45139126e-02f, -2.17580736e-01f, -1.56258434e-01f, -3.27192470e-02f, -1.21379077e-01f, 1.83147416e-01f, -4.11505252e-02f, -1.11856990e-01f, -7.12022483e-02f, -5.49310446e-02f,
  4.47188430e-02f, 1.01457052e-01f, 1.56411886e-01f, 1.07505843e-01f, -1.66590214e-02f, 1.43399194e-01f, 1.51804328e-01f, 4.00480404e-02f, -5.20094931e-02f, -1.04631387e-01f,
  -3.33997719e-02f, -6.35545515e-03f, 8.76280572e-03f, -1.46691920e-02f, -1.00977257e-01f, 1.15068685e-02f, -6.15413114e-02f, 5.65059073e-02f, 4.24716109e-03f, -1.96113233e-02f,
  -2.92862952e-02f, -1.69714436e-01f, -1.32243307e-02f, -3.95099027e-03f, 1.18792593e-01f, 4.47572544e-02f, -1.06017806e-01f, -4.32050601e-02f, 7.00777918e-02f, -1.33674935e-01f,
  4.25009690e-02f, 6.05919138e-02f, -1.42388893e-02f, -9.67649184e-03f, -5.92356436e-02f, 1.51363900e-02f, 6.00693561e-02f, 2.16893342e-04f, 2.19503362e-02f, 1.92454725e-03f,
  2.80418694e-02f, 2.96055675e-02f, -1.71266440e-02f, 2.67797220e-03f, -1.15076825e-01f, -5.34454621e-02f, -2.13272832e-02f, 2.36087274e-02f, -4.00496274e-03f, -1.17913768e-01f,
  4.57788818e-02f, 4.60142922e-03f, -1.66498404e-02f, 9.55102406e-03f, 6.42360598e-02f, 5.51314168e-02f, 2.80722380e-02f, 3.42748202e-02f, 1.85464062e-02f, -4.27850932e-02f,
  -7.06238300e-02f, 4.05069068e-02f, -2.85126804e-03f, 8.03934932e-02f, 9.71449167e-02f, -3.58710475e-02f, -3.03135887e-02f, -1.11802900e-03f, -4.29996476e-02f, 1.49846617e-02f,
  4.66923527e-02f, 2.79762745e-02f, -5.09732775e-02f, -4.98370267e-02f, 3.39395180e-02f, 3.58505957e-02f, -4.90973108e-02f, 1.04227260e-01f, 5.85736260e-02f, -1.50222749e-01f,
  -3.54913063e-03f, 1.13609098e-01f, 3.01938415e-01f, 1.57207265e-01f, 9.47193727e-02f, 2.36410066e-01f, 1.42196864e-01f, 4.75535057e-02f, 1.94747478e-01f, 1.75188288e-01f,
  -3.27953190e-01f, 5.16683757e-01f, -5.72618283e-02f, -2.69046187e-01f, 1.32253617e-01f, 4.03659582e-01f, 5.48931539e-01f, 1.84567064e-01f, -6.99777082e-02f, 1.55766398e-01f,
  1.98978614e-02f, -2.38452092e-01f, -2.75302440e-01f, -7.05828741e-02f, 3.77902687e-02f, 3.57766986e-01f, 6.61802366e-02f, -2.86763668e-01f, -5.75482771e-02f, 1.69393152e-01f,
  5.92115410e-02f, -1.90587103e-01f, -2.59091407e-01f, -9.88893658e-02f, -1.37784854e-01f, -1.79454833e-01f, 1.77923795e-02f, -7.97842443e-03f, 1.43898427e-01f, -2.01916292e-01f,
  -2.06388496e-02f, 1.17412187e-01f, 6.98512122e-02f, -8.48423317e-03f, -5.64144254e-02f, -1.06037349e-01f, 2.37555373e-02f, -1.06294472e-02f, 2.35514678e-02f, 2.01894995e-03f,
  3.37970816e-02f, 1.51935862e-02f, -7.61299729e-02f, 1.21090142e-02f, 1.13462158e-01f, 7.67532885e-02f, -1.83816534e-03f, 1.08977929e-01f, 3.42256390e-02f, 8.43264610e-02f,
  1.24464437e-01f, 3.27265039e-02f, 3.60107347e-02f, 1.55197576e-01f, 1.16354547e-01f, -3.91036943e-02f, -4.80105914e-02f, 6.96156844e-02f, 5.83412498e-02f, -7.66680986e-02f,
  3.74162639e-03f, -5.28743789e-02f, -1.10282458e-03f, 3.49313878e-02f, 2.83998367e-03f, -1.34771084e-02f, -4.70738113e-02f, 1.38863474e-02f, 1.09971128e-01f, -8.68446454e-02f,
  4.09667566e-02f, -5.16880266e-02f, -7.78200179e-02f, 2.49547176e-02f, -1.20920502e-01f, -4.24075462e-02f, -1.61705259e-02f, -1.76345520e-02f, -2.69016605e-02f, 3.08951195e-02f,
  1.82080716e-02f, 1.92432813e-02f, -6.45830575e-03f, 3.48507017e-02f, 4.34855595e-02f, 3.76070589e-02f, -5.74755557e-02f, 2.30020843e-02f, -5.14112525e-02f, 4.10551541e-02f,
  -3.37379500e-02f, -2.02089418e-02f, -5.77539578e-02f, 1.71394441e-02f, -4.10663569e-03f, -3.05421725e-02f, -1.10434659e-01f, -1.60238277e-02f, -3.93995233e-02f, 8.18056539e-02f,
  5.77751268e-03f, 2.13389960e-03f, -6.44626319e-02f, 2.43932884e-02f, 3.85223106e-02f, -1.38747757e-02f, -2.83364439e-03f, -4.88748401e-02f, 1.39026359e-01f, 6.29361942e-02f,
  1.17301233e-01f, 6.66101202e-02f, 7.15759844e-02f, 6.78994879e-02f, 7.55349994e-02f, -3.67823578e-02f, 5.20146787e-02f, 8.70070010e-02f, 1.99795850e-02f, 7.58815259e-02f,
  5.02412498e-01f, -4.28689271e-03f, -9.71357003e-02f, 2.00723246e-01f, -6.78620636e-02f, -4.98075075e-02f, 1.12973213e-01f, -1.74272567e-01f, 4.36697574e-03f, 9.64656845e-02f,
  -1.54259816e-01f, 1.65107444e-01f, 9.88167599e-02f, 1.08993568e-01f, 1.06118597e-01f, 1.63018495e-01f, -5.35599291e-02f, -3.10012363e-02f, 1.70204908e-01f, 7.56415352e-02f,
  1.45856395e-01f, 2.20770448e-01f, -3.03285401e-02f, -6.03965558e-02f, 3.84249650e-02f, -3.50904278e-03f, -1.29470617e-01f, -5.46476468e-02f, -1.17128640e-01f, -5.35868667e-03f,
  1.00187838e-01f, -2.05198601e-01f, 2.15355046e-02f, 5.58080673e-02f, -2.88938843e-02f, -1.03282176e-01f, 8.86239558e-02f, -8.97340924e-02f, -1.25416726e-01f, -2.61202920e-02f,
  -9.91919637e-02f, -2.73026880e-02f, 1.83633436e-02f, 1.49549218e-02f, 2.12726779e-02f, 4.25254293e-02f, -7.51191154e-02f, 6.59809401e-03f, -2.39084903e-02f, -4.82096709e-02f,
  7.91134983e-02f, -1.12869270e-01f, -1.97994888e-01f, -1.01157323e-01f, -7.69460062e-03f, 9.74521879e-03f, -1.35371581e-01f, -6.17847107e-02f, -3.96487117e-02f, -7.86598101e-02f,
  1.31676167e-01f, 4.26714830e-02f, -6.97208568e-04f, -1.79812182e-02f, 1.17450543e-01f, -6.08702637e-02f, 2.76203696e-02f, 8.08502436e-02f, 4.55961451e-02f, -1.36081427e-02f,
  -6.79939240e-02f, 6.49443716e-02f, 4.60382625e-02f, 3.18408981e-02f, 2.34911777e-03f, -3.25793140e-02f, 1.60084385e-02f, -2.75958646e-02f, -6.47594221e-04f, 1.17685169e-01f,
  7.27883130e-02f, -1.56345684e-02f, 8.77018124e-02f, -2.24480778e-02f, 8.89510289e-02f, 1.00400575e-01f, 3.84002067e-02f, 8.32166150e-02f, 2.18583476e-02f, -2.65084789e-03f,
  5.03637120e-02f, -2.06373762e-02f, 8.84439871e-02f, -6.86205849e-02f, -3.55935656e-02f, 6.67938665e-02f, -9.98918042e-02f, 5.16390018e-02f, -7.21878484e-02f, 4.58981246e-02f,
  8.23557973e-02f, 1.56654492e-02f, -1.21514415e-02f, -8.16868842e-02f, -2.16478147e-02f, -8.10615644e-02f, -4.62460853e-02f, -3.30507159e-02f, 4.39023972e-02f, -2.85657998e-02f,
  2.30670650e-03f, 1.10964946e-01f, 4.07934524e-02f, -1.86124612e-02f, -5.65613694e-02f, 3.77576239e-02f, -4.78167832e-02f, 1.92112532e-02f, 9.41736996e-02f, 5.06600067e-02f,
  -1.21353259e-02f, -1.18107118e-01f, -1.29620373e-01f, -1.34406805e-01f, 1.03006810e-01f, 1.73728332e-01f, 3.55883688e-01f, 2.36383349e-01f, 8.63202512e-02f, -4.52283397e-03f,
  3.67025919e-02f, 1.45813406e-01f, 9.48719084e-02f, 1.15567461e-01f, 1.05279116e-02f, -4.31016646e-02f, -1.07958399e-01f, -1.24023728e-01f, 9.09084007e-02f, 6.09807558e-02f,
  -4.35245819e-02f, -1.12025939e-01f, -1.38391554e-01f, -2.75441289e-01f, -2.94728190e-01f, -5.30966781e-02f, -7.56420568e-02f, -2.23769590e-01f, -3.37050967e-02f, -5.61554193e-01f,
  2.77515389e-02f, -7.30607808e-02f, 5.92677370e-02f, 2.63583455e-02f, -2.69689620e-03f, 5.73268197e-02f, -4.61309124e-03f, -4.83449809e-02f, -3.97366675e-04f, -1.21793978e-01f,
  -6.90573975e-02f, -1.48857376e-02f, -4.44982126e-02f, -9.50265899e-02f, 1.00347092e-02f, 3.81933227e-02f, -8.28301683e-02f, -6.02492616e-02f, -1.79929310e-03f, 8.78378823e-02f,
  -4.20332365e-02f, -7.61686340e-02f, 8.19839016e-02f, 6.60365894e-02f, 9.14728865e-02f, 7.98404624e-04f, -3.05954665e-02f, 3.37261334e-02f, 1.22174978e-01f, -5.85864037e-02f,
  5.40432632e-02f, 1.15486735e-03f, -2.01286543e-02f, -5.80676552e-03f, -8.84914957e-03f, -4.26010266e-02f, -7.53695667e-02f, -3.29292752e-02f, 9.46912263e-03f, -9.80526209e-02f,
  -2.41540074e-02f, -2.91503798e-02f, -4.90172021e-02f, -2.15632543e-02f, -1.00782467e-02f, 4.92484076e-03f, 7.16763688e-03f, -5.79160340e-02f, 8.57684202e-03f, -6.29181694e-03f,
  9.13290009e-02f, 1.22506712e-02f, -7.24716159e-03f, -1.83272734e-02f, -6.24042526e-02f, -2.30876058e-02f, -6.74005300e-02f, -2.76758280e-02f, 2.77738944e-02f, 1.11375079e-02f,
  3.17883380e-02f, 1.05547965e-01f, -6.36504814e-02f, 1.70311127e-02f, 1.07324682e-02f, 4.73583536e-03f, -5.35723008e-02f, 7.54818972e-03f, -2.30359528e-02f, 3.09315138e-02f,
  7.89268780e-03f, -3.76170427e-02f, 1.16502509e-01f, -8.68098438e-03f, 8.35003480e-02f, 3.28394771e-02f, 5.89035749e-02f, 5.43566644e-02f, 2.49082819e-02f, -1.35298530e-02f,
  -1.04685882e-02f, 1.58252865e-01f, 2.19763204e-01f, 9.02872905e-02f, 1.81167964e-02f, 9.41671804e-02f, 6.40603006e-02f, 1.25324905e-01f, 1.82426959e-01f, 2.77978927e-01f,
  -2.62223408e-02f, -7.84571767e-02f, -2.75129437e-01f, -1.40523031e-01f, 3.83608565e-02f, -2.06508338e-02f, 2.28259712e-02f, 5.27723096e-02f, -5.90152554e-02f, 5.10914288e-02f,
  3.85434031e-02f, -1.85339510e-01f, -1.97539061e-01f, -1.12861738e-01f, -4.89387065e-02f, -1.72236785e-01f, -1.12517238e-01f, -2.13575080e-01f, -1.87535957e-01f, -1.33191600e-01f,
  -7.21875355e-02f, -1.70766532e-01f, -2.13698652e-02f, 8.98744725e-03f, -1.99304074e-01f, -6.75074980e-02f, 2.22876277e-02f, -7.54883587e-02f, -3.65696885e-02f, -2.36440122e-01f,
  -2.29499727e-01f, 1.51218370e-01f, 2.18196865e-02f, 8.22325721e-02f, 4.31167055e-03f, 6.00239336e-02f, -9.04340006e-04f, 4.70192172e-02f, 1.87279042e-02f, 1.21525051e-02f,
  5.38564287e-02f, 1.38713056e-02f, 7.40163028e-03f, 2.03174055e-02f, 5.41424528e-02f, -1.10420443e-01f, 3.75080779e-02f, -1.04625104e-02f, -7.43391812e-02f, -1.43173952e-02f,
  -1.13862835e-01f, -6.40576407e-02f, -5.94158024e-02f, 5.98158017e-02f, -4.43604141e-02f, -6.54112250e-02f, -6.11983202e-02f, -2.44141221e-02f, -4.24949825e-02f, -6.35911152e-02f,
  -2.65822001e-02f, -5.27106784e-03f, 1.77671462e-02f, 2.91405730e-02f, 2.68592481e-02f, 8.43343884e-02f, -6.15747347e-02f, -5.67295067e-02f, 1.01765506e-02f, 1.18436888e-01f,
  -6.26219213e-02f, -5.45344092e-02f, -7.05347732e-02f, -9.42140166e-03f, -1.03426576e-01f, -5.82851581e-02f, -7.22634932e-03f, -5.88062555e-02f, -8.90279934e-02f, 2.79348232e-02f,
  -7.85394982e-02f, 1.78471319e-02f, -9.96209309e-02f, -9.72497240e-02f, -4.27687466e-02f, -1.07407942e-01f, -3.76567170e-02f, 8.75330344e-02f, 1.20034464e-01f, 1.58158913e-02f,
  -5.74114174e-02f, -1.61238294e-02f, -1.03702351e-01f, -3.38462219e-02f, -1.33708254e-01f, -1.56871736e-01f, -1.32285908e-01f, -3.83918397e-02f, -1.22482896e-01f, -8.24413523e-02f,
  -7.18761981e-02f, -2.54099101e-01f, -1.99916109e-01f, -1.44677490e-01f, -8.59089494e-02f, -2.13353746e-02f, -7.46001974e-02f, -1.12175480e-01f, -5.80086783e-02f, -1.63896546e-01f,
  -4.23162896e-03f, -4.92682680e-02f, -1.74768329e-01f, -9.14680734e-02f, -6.69068024e-02f, -2.20993966e-01f, -8.39155763e-02f, -1.68228731e-01f, -1.87006533e-01f, -1.18053719e-01f,
  1.31378502e-01f, -3.67498279e-01f, -3.30863863e-01f, 1.01818867e-01f, 2.68044341e-02f, 1.64263681e-01f, 1.26488894e-01f, 2.14023754e-01f, 1.62515655e-01f, -2.44077332e-02f,
  4.27135266e-02f, 7.77944475e-02f, 7.07678124e-02f, -5.85852601e-02f, -1.88921496e-01f, -9.83404443e-02f, -1.08210169e-01f, -1.62191838e-01f, -2.07563955e-02f, -5.26349247e-02f,
  -8.44158754e-02f, 4.27473001e-02f, -7.27999508e-02f, -8.33218545e-02f, -5.55151850e-02f, 6.14699395e-03f, -1.78833946e-03f, 1.39874173e-02f, -2.36106217e-01f, -4.68467295e-01f,
  -3.02802801e-01f, -1.45003468e-01f, -7.53969923e-02f, -1.24212421e-01f, -7.62916915e-03f, -6.54875189e-02f, -8.00867938e-03f, -8.91061947e-02f, 1.98711473e-02f, -9.19114500e-02f,
  -6.12431839e-02f, -1.11990020e-01f, -8.58085975e-02f, -1.04668342e-01f, 3.27710286e-02f, -1.04010791e-01f, -8.01954195e-02f, -1.80841163e-01f, -6.69320598e-02f, -4.06980254e-02f,
  -1.23319045e-01f, -1.57925993e-01f, -5.51117063e-02f, -2.65451185e-02f, -1.27184793e-01f, -1.41488006e-02f, -9.20916647e-02f, -1.40590802e-01f, -1.26585022e-01f, -1.15820982e-01f,
  -5.32914773e-02f, 4.32844087e-02f, 6.65107593e-02f, -4.95427893e-03f, 1.51237234e-01f, 1.30969688e-01f, 3.10688466e-02f, 5.89508079e-02f, 5.21782413e-02f, -1.37572689e-02f,
  6.92444220e-02f, 8.89183953e-03f, 4.44508567e-02f, -2.82893889e-02f, -2.42166091e-02f, -1.18185908e-01f, -2.77909730e-02f, 7.33458027e-02f, 2.87778601e-02f, 4.41238433e-02f,
  -5.81525862e-02f, -2.15262640e-02f, 1.26430213e-01f, 4.49109636e-02f, -3.14186215e-02f, 1.03310578e-01f, 1.17208913e-01f, 9.43843334e-04f, 1.41832590e-01f, 3.07452641e-02f,
  4.24436070e-02f, -5.48695922e-02f, -7.06442818e-02f, -9.19103995e-02f, -8.30200016e-02f, 1.63383735e-03f, -6.17925040e-02f, -7.04332814e-02f, -7.68519342e-02f, 2.02001370e-02f,
  -1.17938174e-02f, -2.68725455e-02f, 1.45153413e-02f, -4.80758473e-02f, 3.72207724e-02f, 5.83673380e-02f, -1.91815235e-02f, 1.73120480e-02f, -1.57723799e-02f, -9.10320655e-02f,
  9.10615698e-02f, 1.65461287e-01f, 2.21107319e-01f, 1.20914444e-01f, 2.31870301e-02f, 1.07518137e-01f, 9.42296833e-02f, 1.73623729e-02f, 7.71792829e-02f, 1.43020004e-01f,
  -3.62453490e-01f, -1.05844587e-01f, 1.44089475e-01f, -1.12078808e-01f, 1.55579284e-01f, 3.90298758e-03f, -2.66061217e-01f, -1.18052416e-01f, 2.28891671e-02f, -3.43557931e-02f,
  7.76409805e-02f, -5.55901676e-02f, -1.26535311e-01f, -5.49967065e-02f, -2.31513709e-01f, -1.58987120e-01f, -1.08547822e-01f, 4.38206941e-02f, -2.24975154e-01f, -1.05157837e-01f,
  3.40384170e-02f, 2.26260424e-02f, 3.66891623e-02f, 7.57556455e-03f, -5.28145805e-02f, -3.58949862e-02f, 9.25106779e-02f, 1.02770329e-01f, 8.82582814e-02f, -1.02719888e-01f,
  7.16213649e-03f, 9.18482915e-02f, -5.46248518e-02f, -1.56439215e-01f, 7.90319741e-02f, -1.42903388e-01f, -9.13415477e-02f, 6.01108894e-02f, 5.83271496e-02f, -8.79896879e-02f,
  -5.49978875e-02f, -4.62598121e-03f, 5.37275895e-02f, 6.20884914e-03f, -2.17646100e-02f, -1.59003094e-01f, -9.78404731e-02f, -1.20514005e-01f, -1.06644034e-01f, -5.46956211e-02f,
  1.43989772e-01f, 2.72182506e-02f, 2.31295042e-02f, -5.76341040e-02f, 3.46368994e-03f, -1.46773346e-02f, 7.17361867e-02f, 7.41079301e-02f, 6.43270835e-02f, -8.16583112e-02f,
  2.71141976e-02f, 3.26277167e-02f, -4.41594943e-02f, -7.60872057e-03f, -2.16578439e-01f, 5.63369729e-02f, 5.55741005e-02f, 2.13942435e-02f, 2.91895904e-02f, -4.95724417e-02f,
  3.03298384e-02f, 4.00110111e-02f, 6.56987876e-02f, -8.31462666e-02f, -3.08542177e-02f, 1.41368493e-01f, -2.75891889e-02f, -7.02567175e-02f, 2.22228896e-02f, -6.55520484e-02f,
  9.67828259e-02f, 1.19643465e-01f, 4.46595438e-02f, 1.19553646e-02f, 9.49647054e-02f, 4.17575985e-02f, 1.04730666e-01f, 3.57807502e-02f, 4.22057100e-02f, 8.41384009e-02f,
  -2.82670110e-01f, 1.80820733e-01f, -2.12402329e-01f, -1.93974867e-01f, -1.98606923e-02f, -1.63234368e-01f, 3.30179557e-02f, -7.44788423e-02f, -1.69630311e-02f, -1.45176202e-01f,
  2.00311989e-02f, -1.32352397e-01f, -1.06105320e-01f, -8.65234658e-02f, -1.53458014e-01f, -1.16805911e-01f, -1.05185650e-01f, -1.17921136e-01f, -2.51160711e-02f, -4.39189598e-02f,
  -9.68396068e-02f, -5.94788864e-02f, -2.21564397e-01f, -1.61302939e-01f, -9.42962896e-03f, -1.00774474e-01f, -1.74490780e-01f, -1.73166230e-01f, -1.72846958e-01f, -5.31559527e-01f,
  -5.59465587e-01f, -5.82410544e-02f, 1.07763655e-01f, -1.68826729e-01f, 1.52068272e-01f, 2.23278791e-01f, 2.20944155e-02f, 4.65018675e-02f, 4.58219573e-02f, -1.26645835e-02f,
  2.11837694e-01f, 2.03437075e-01f, 8.71024951e-02f, 2.75777340e-01f, 1.04996011e-01f, -6.99220076e-02f, -3.89257483e-02f, -4.83324938e-02f, 5.53463064e-02f, 5.83727378e-04f,
  4.03843299e-02f, -2.04732776e-01f, -1.11199230e-01f, 1.51503399e-01f, -9.64628011e-02f, 2.46718656e-02f, 1.03516974e-01f, 8.12435597e-02f, 7.50767216e-02f, -1.05411053e-01f,
  -1.25976294e-01f, -1.09827206e-01f, 8.76851827e-02f, 9.72547848e-03f, 2.26631001e-01f, 8.46252739e-02f, 1.45616829e-01f, 4.85539250e-02f, -2.92298328e-02f, -1.46605177e-02f,
  1.66470185e-01f, 1.78094245e-02f, -9.41790873e-04f, 1.15480712e-02f, -6.31559864e-02f, -3.85736376e-02f, -2.54566725e-02f, 3.50040756e-02f, 1.08117713e-02f, -7.76557624e-02f,
  2.29026694e-02f, 1.86141841e-02f, -7.88640790e-03f, 9.92151871e-02f, 1.05981417e-01f, 1.65556464e-02f, 9.15465951e-02f, 4.57959436e-02f, 1.93360850e-01f, 2.94726454e-02f,
  3.95028964e-02f, -1.43500604e-02f, 4.81229797e-02f, -3.48675288e-02f, -6.13160059e-02f, 1.07525913e-02f, -2.88131740e-02f, 3.30351922e-03f, -2.84686238e-02f, 3.96665446e-02f,
  -5.50881214e-03f, -4.86346781e-02f, 9.74122901e-04f, 3.32395695e-02f, -4.17937674e-02f, -5.58983302e-03f, 2.01790873e-03f, 9.20199603e-02f, -7.57448077e-02f, 1.60699815e-03f,
  -1.48693845e-01f, -2.55393628e-02f, -7.77052864e-02f, 1.84086673e-02f, -1.93305947e-02f, 5.84057644e-02f, -5.15207574e-02f, -4.71883155e-02f, -1.06157295e-01f, -3.70557271e-02f,
  -1.60752729e-01f, 2.80837238e-01f, -3.56443562e-02f, 4.33616564e-02f, -1.22755971e-02f, -4.69689667e-02f, -7.28739426e-02f, 1.81858409e-02f, -5.25204688e-02f, -4.93056290e-02f,
  -7.88015053e-02f, 1.98443420e-02f, -3.12680155e-02f, 1.90760158e-02f, 9.12526101e-02f, -5.94619624e-02f, 9.54518840e-02f, 2.22807359e-02f, -1.62532739e-02f, 1.01794964e-02f,
  4.96612675e-02f, -3.25325057e-02f, 3.22520174e-02f, -5.67345135e-02f, 4.56316950e-04f, -1.21148713e-01f, 5.63914776e-02f, -1.02288842e-01f, 2.94458922e-02f, -1.47342965e-01f,
  5.95981300e-01f, 2.03935608e-01f, -2.67920166e-01f, 1.36153877e-01f, -7.42352754e-02f, -2.20837183e-02f, 2.02413484e-01f, 4.81646545e-02f, 5.42631298e-02f, 1.69748336e-01f,
  -1.20811738e-01f, -3.77669245e-01f, -1.87935054e-01f, -2.53086865e-01f, -1.91029876e-01f, 1.36927113e-01f, 8.59733298e-02f, -1.66157112e-01f, -3.70805174e-01f, -9.81823280e-02f,
  -1.11119784e-01f, 1.53281182e-01f, 4.82260808e-02f, -9.50180516e-02f, 2.18642250e-01f, -9.94797871e-02f, 6.55556619e-02f, 8.93093832e-03f, -1.26112476e-01f, 1.46210253e-01f,
  -9.95557308e-02f, 7.57523701e-02f, -1.99797839e-01f, 9.15872380e-02f, -5.71699217e-02f, 8.88969377e-02f, -3.21314968e-02f, 1.96778029e-02f, 1.62978694e-02f, 7.96780214e-02f,
  -4.64021936e-02f, -4.16293517e-02f, -5.46386167e-02f, -8.37953389e-02f, 1.15291239e-03f, -3.92707624e-02f, 5.06588072e-03f, -7.96382409e-03f, -7.89862871e-02f, -2.32482068e-02f,
  -6.00860193e-02f, -9.42118838e-02f, -6.60831481e-02f, -6.96890727e-02f, 8.36902205e-03f, -9.60393175e-02f, -4.03922908e-02f, -9.76899937e-02f, -5.09859324e-02f, 1.91551775e-01f,
  4.98611778e-02f, 7.09212199e-03f, -7.24442024e-03f, 4.19562720e-02f, -6.71359375e-02f, 5.33817010e-03f, -4.76996303e-02f, 3.46139483e-02f, -5.10079935e-02f, 1.84776057e-02f,
  -4.04913425e-02f, 1.27500175e-02f, 3.42300683e-02f, -2.10133754e-02f, -9.87070147e-03f, -2.25938130e-02f, 2.57781502e-02f, -3.23280431e-02f, -1.17416484e-02f, -2.82624848e-02f,
  -2.04999242e-02f, 3.27918008e-02f, 1.94463767e-02f, 1.02187414e-02f, -2.78235320e-02f, -3.11182886e-02f, 1.15596119e-03f, -1.27531052e-01f, -2.01316960e-02f, 6.45035729e-02f,
  -6.57263026e-02f, -3.45596641e-01f, 7.78868124e-02f, -1.18226814e-03f, -5.73963206e-03f, -2.72933324e-03f, -7.23173609e-03f, -2.46731266e-02f, -1.94052681e-02f, 6.85994998e-02f,
  -8.85102525e-02f, 4.97938283e-02f, -7.18369260e-02f, -4.05266974e-03f, 1.35874338e-02f, -6.23759180e-02f, -1.98248625e-02f, -1.03716508e-01f, -3.97648588e-02f, 5.55226170e-02f,
  7.09818527e-02f, -5.39734727e-03f, -6.65991157e-02f, -8.73301923e-03f, -1.53062539e-02f, -7.07245842e-02f, 8.36577732e-04f, 6.83585405e-02f, -1.75915435e-01f, 2.25565746e-01f,
  4.41555619e-01f, 3.06750864e-01f, 3.02228212e-01f, 1.78899452e-01f, 3.36905539e-01f, 1.85325772e-01f, 2.05014631e-01f, -1.31549358e-01f, -1.95340291e-02f, 1.26309767e-01f,
  2.59612292e-01f, 7.24929944e-02f, 1.16564482e-01f, 9.36441943e-02f, 7.41376774e-03f, 1.00368299e-01f, 8.76577199e-02f, 2.48426609e-02f, 8.78904611e-02f, 1.89103916e-01f,
  1.70654178e-01f, 9.53988060e-02f, 1.61527619e-02f, -3.16310823e-02f, 6.94092661e-02f, 3.38070616e-02f, 1.18990459e-01f, 1.12736292e-01f, -1.32352125e-03f, 1.48473397e-01f,
  1.52030796e-01f, 1.80853933e-01f, -7.88371637e-03f, 1.07094288e-01f, 1.69740930e-01f, -8.40971693e-02f, 2.62771808e-02f, -4.92566228e-02f, -3.97973508e-02f, 4.31518592e-02f,
  1.86050862e-01f, -6.18744083e-02f, 5.14880791e-02f, 1.55958803e-02f, 7.77105149e-03f, 3.51569057e-02f, -6.23880997e-02f, -3.25369649e-02f, -4.30289004e-03f, -4.69799787e-02f,
  8.28696191e-02f, 1.89795289e-02f, 8.34693536e-02f, -9.43361297e-02f, -3.92980538e-02f, -1.02793045e-01f, 1.60880126e-02f, -1.63823649e-01f, -5.87677509e-02f, -1.38738444e-02f,
  -6.71164021e-02f, 2.64918506e-02f, 1.24157444e-01f, 5.72248623e-02f, 4.56505083e-02f, -3.86634804e-02f, 2.28623804e-02f, 3.63646597e-02f, -2.21021269e-02f, -2.59275213e-02f,
  6.53223097e-02f, 8.10745806e-02f, -1.04738846e-02f, 4.65493500e-02f, 5.35516888e-02f, 9.16107297e-02f, 9.26463958e-03f, 6.46670759e-02f, 2.09828097e-04f, 4.41098213e-02f,
  6.61244243e-02f, -2.09774263e-03f, 9.03063337e-04f, -8.61120597e-02f, 7.19044656e-02f, -2.38077762e-03f, -1.31000765e-04f, 8.64200890e-02f, 4.66547161e-02f, 1.23831205e-01f,
  -4.08247374e-02f, 1.57805294e-01f, 4.42760959e-02f, -8.81067067e-02f, 6.05173176e-03f, -6.42708614e-02f, 4.39093895e-02f, -8.31210762e-02f, 8.84569585e-02f, 5.98302633e-02f,
  9.80265886e-02f, 9.47146267e-02f, 2.29671560e-02f, -8.44813660e-02f, 4.23252443e-03f, 1.60312280e-01f, 1.01047464e-01f, 4.80099879e-02f, 3.49869654e-02f, -4.10404354e-02f,
  -6.29379079e-02f, -2.54344232e-02f, -1.14339860e-02f, -9.02106911e-02f, 3.06190848e-02f, 8.57962668e-02f, 2.60612778e-02f, -1.50810194e-03f, -5.19200861e-02f, 1.93041302e-02f,
  1.21705219e-01f, 1.46468192e-01f, -3.99571598e-01f, -4.14374992e-02f, -1.19896866e-01f, -6.25974983e-02f, 8.65546837e-02f, 2.01751947e-01f, 4.81500961e-02f, -4.79331687e-02f,
  2.15904981e-01f, 1.85114607e-01f, 9.96788144e-02f, 6.48292750e-02f, 1.14770740e-01f, -1.48986682e-01f, -4.04928505e-01f, -2.62785226e-01f, -2.88051907e-02f, 2.00410753e-01f,
  2.03635797e-01f, -8.64054114e-02f, -6.79904968e-02f, -2.23435864e-01f, -2.22608596e-01f, -1.99713364e-01f, -3.73225063e-01f, -2.11728275e-01f, -1.05622634e-01f, -6.47985339e-01f,
  -1.20671354e-01f, 8.84432867e-02f, 1.39884010e-01f, 4.84844036e-02f, -4.39470746e-02f, 1.33132748e-02f, 9.81175974e-02f, -1.59066916e-02f, 3.36845070e-02f, -2.33322419e-02f,
  -2.37372108e-02f, -3.26231085e-02f, 8.86720419e-03f, 6.83475956e-02f, -1.40801808e-02f, 2.90125441e-02f, -1.59080140e-02f, -2.95465086e-02f, -3.89418518e-03f, 5.35197482e-02f,
  6.61070198e-02f, -1.03819840e-01f, -1.12757519e-01f, -7.89410099e-02f, 8.04564431e-02f, -5.22955321e-02f, -6.01365156e-02f, -2.85855811e-02f, -5.42410091e-02f, -1.38709798e-01f,
  -4.94086370e-02f, -4.52039726e-02f, -2.06602030e-02f, 8.59632120e-02f, 5.38263889e-03f, -1.77685916e-02f, 6.85808584e-02f, 5.90522438e-02f, 2.29670554e-02f, 4.89523187e-02f,
  5.48171811e-02f, -5.78911006e-02f, -1.34272808e-02f, -5.15576750e-02f, -1.25042722e-01f, -1.13983797e-02f, 1.82548929e-02f, 2.18374394e-02f, -3.93979736e-02f, 9.49317515e-02f,
  9.38004106e-02f, 1.96387805e-02f, -7.58004636e-02f, 6.41202182e-02f, -9.32147279e-02f, -4.29309383e-02f, -4.49299999e-02f, 8.36589783e-02f, 1.01935737e-01f, 3.52413282e-02f,
  3.64487320e-01f, -2.30564959e-02f, 6.47010431e-02f, 4.79686446e-02f, -1.29458547e-01f, -1.68280434e-02f, -7.54982755e-02f, 8.95906761e-02f, -3.07216309e-02f, -3.17659825e-02f,
  9.03225082e-05f, 7.00783543e-03f, -5.90586700e-02f, -4.82349657e-02f, 4.81227972e-02f, -5.46403378e-02f, 7.23701417e-02f, -6.75350651e-02f, -3.51587087e-02f, -3.60622890e-02f,
  -4.77222018e-02f, 8.01063925e-02f, 1.28313482e-01f, -1.89613632e-03f, 4.03937278e-03f, 1.97682716e-02f, -8.91042966e-03f, 6.74153417e-02f, 1.01008199e-01f, 8.74161497e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.97342318e-01f, -3.20237279e-01f, 2.39772588e-01f, 5.10479584e-02f, 1.88998237e-01f, 2.16585457e-01f, 3.23033303e-01f, 1.48299679e-01f, 3.61109413e-02f, 5.76927676e-04f,
  -1.43014655e-01f, -8.54775235e-02f, 4.34083790e-02f, -3.12149315e-03f, 1.30268618e-01f, 2.71902621e-01f, 2.12668240e-01f, 9.02948976e-02f, 2.96582282e-01f, 3.05393308e-01f,
  1.67284831e-01f, 8.19228813e-02f, -1.28758997e-01f, 4.20947298e-02f, -2.22560726e-02f, 1.70376450e-01f, 4.30650227e-02f, -1.46073848e-01f, -1.04901291e-01f, 1.03494585e-01f,
  3.85897815e-01f, -3.92876267e-01f, 9.64972302e-02f, -2.76205897e-01f, -1.25085846e-01f, -1.96272552e-01f, 6.24570735e-02f, -1.30871743e-01f, -4.87363152e-02f, -1.66125912e-02f,
  -1.72996163e-01f, -1.20971173e-01f, 4.26645912e-02f, 1.53812906e-03f, -4.48581241e-02f, -5.81336692e-02f, -2.14505762e-01f, 2.11535990e-02f, 7.44250417e-02f, 6.29646182e-02f,
  1.19225383e-01f, -5.09593338e-02f, 1.89200304e-02f, 2.68495772e-02f, -5.20414077e-02f, -4.23055291e-02f, -1.50387451e-01f, -1.62659287e-01f, 1.82405338e-02f, -8.29108357e-02f,
  1.07478872e-01f, 2.50720587e-02f, -5.62553033e-02f, 7.45224208e-02f, -2.82850061e-02f, 4.37475257e-02f, 1.54076833e-02f, 3.93971689e-02f, 7.62893409e-02f, 7.78094828e-02f,
  -3.43993567e-02f, 9.76886973e-03f, 6.88527822e-02f, 2.53413729e-02f, 5.06486297e-02f, -8.31609592e-03f, -6.88202605e-02f, -6.49141744e-02f, -1.23697720e-01f, -7.85180032e-02f,
  -3.01057510e-02f, -7.37553760e-02f, -1.81851890e-02f, -2.97248997e-02f, -1.34368256e-01f, -9.28662866e-02f, 7.29627311e-02f, -1.30822957e-01f, 7.96713904e-02f, 1.72985435e-01f,
  3.08261842e-01f, -1.38561651e-01f, 1.65999904e-01f, 2.14808993e-02f, -1.72633082e-01f, -2.60387659e-01f, 8.07349607e-02f, 1.42202051e-02f, -5.27252443e-02f, 9.10790339e-02f,
  -1.25004739e-01f, 1.31754756e-01f, -2.96220072e-02f, 2.24819575e-02f, 1.63309887e-01f, -7.77825247e-03f, -1.39111996e-01f, 9.09748971e-02f, 7.18396977e-02f, 2.98011694e-02f,
  -7.38699883e-02f, 2.87161767e-02f, 1.77441075e-01f, 1.98804364e-01f, 2.06204817e-01f, 2.06734374e-01f, 2.59412825e-01f, 4.63316627e-02f, 1.17098168e-01f, 1.36277035e-01f,
  6.91369534e-01f, 5.91921031e-01f, 3.37706387e-01f, 3.17498803e-01f, 3.37427966e-02f, 2.08603576e-01f, 4.63120967e-01f, 4.02624995e-01f, -5.84217533e-02f, 2.41158679e-01f,
  1.64161444e-01f, -2.62504637e-01f, -9.64832976e-02f, -1.39211556e-02f, 1.27658010e-01f, 1.15786940e-01f, -9.77472216e-02f, 2.06950486e-01f, 6.75071850e-02f, 1.21920407e-01f,
  -4.97139841e-02f, 1.55749589e-01f, 2.49205187e-01f, 5.76427020e-02f, 2.06789132e-02f, -3.18710268e-01f, 4.77485247e-02f, 2.13017344e-01f, 4.36214171e-03f, -4.98212017e-02f,
  4.49650213e-02f, 4.82385248e-01f, -2.93244839e-01f, -1.74742937e-01f, -4.20786217e-02f, -1.59909189e-01f, -9.64784548e-02f, -4.15243655e-02f, -1.71770081e-01f, -8.53205994e-02f,
  -3.04397028e-02f, -1.15541331e-01f, -7.88379647e-03f, 1.76850297e-02f, 1.96165461e-02f, -5.59892505e-02f, 7.05114603e-02f, 1.61727458e-01f, 1.14287734e-01f, 3.51952314e-02f,
  -1.53391674e-01f, 1.73367411e-01f, 1.96377248e-01f, 2.93300338e-02f, 1.24625871e-02f, -6.77780509e-02f, 1.45510957e-01f, 1.06540747e-01f, 1.20838434e-02f, 1.07646391e-01f,
  -8.97611156e-02f, -2.49062572e-02f, -3.88081931e-02f, 1.82648763e-01f, 8.88631307e-03f, 2.74051279e-02f, 3.93339507e-02f, 8.04185420e-02f, 2.75905542e-02f, 6.22124448e-02f,
  -1.30051553e-01f, -4.24555168e-02f, 5.51715605e-02f, 4.72602993e-02f, -3.59509289e-02f, 6.55924082e-02f, -1.99351227e-03f, -1.44682080e-02f, 2.72554327e-02f, -3.94737460e-02f,
  3.89623158e-02f, -4.08505974e-03f, -1.76177899e-04f, 1.02305949e-01f, 1.72089655e-02f, 1.29561543e-01f, -7.97528848e-02f, 1.24366485e-01f, -3.31175402e-02f, 1.63356531e-02f,
  -3.94062549e-01f, 1.21295623e-01f, -1.12429813e-01f, -1.94957003e-01f, 3.31484452e-02f, -7.33574033e-02f, 2.16997210e-02f, -1.26685426e-02f, -1.92276299e-01f, -1.49497777e-01f,
  1.17569081e-01f, 3.20054255e-02f, 1.42075837e-01f, 7.87893087e-02f, -2.21666992e-02f, -9.18839425e-02f, 1.64034925e-02f, 4.11106236e-02f, -4.63956930e-02f, -7.48502389e-02f,
  3.23694944e-03f, 4.68476973e-02f, -5.13745807e-02f, -1.31337583e-01f, -1.92440189e-02f, -1.60885558e-01f, 1.39710470e-03f, 3.49602439e-02f, -1.20688915e-01f, -2.95845233e-02f,
  -9.89180617e-03f, -4.73508686e-01f, 4.27455276e-01f, 2.82580137e-01f, 4.62878048e-01f, 4.14283067e-01f, 3.45427752e-01f, 1.20981701e-01f, 1.47838771e-01f, -5.80801219e-02f,
  -4.80451524e-01f, -3.42731833e-01f, -3.94289792e-01f, -2.58588940e-01f, -3.03820908e-01f, 1.72316000e-01f, 2.52770931e-01f, 4.16467600e-02f, 8.16017538e-02f, 2.41177216e-01f,
  1.30321681e-01f, 1.62098140e-01f, -1.02876656e-01f, -1.87083825e-01f, 1.38381748e-02f, -1.65521614e-02f, 3.68854292e-02f, -1.72687814e-01f, -1.17798924e-01f, 2.33256649e-02f,
  -2.66357005e-01f, -5.82014099e-02f, 9.76582319e-02f, -1.15385689e-01f, 6.96200831e-03f, -1.39264790e-02f, 7.42685497e-02f, -5.04246764e-02f, 3.75178643e-02f, -1.62778888e-02f,
  3.94681394e-02f, -2.51323674e-02f, 4.83789761e-03f, -9.08809155e-02f, 8.56357366e-02f, -7.89384544e-02f, -2.59847250e-02f, -3.85717899e-02f, -8.06790143e-02f, -1.58678681e-01f,
  -1.92548111e-01f, -5.28288670e-02f, -1.88804381e-02f, -3.46403532e-02f, -1.00348391e-01f, 1.34713585e-02f, -1.15718149e-01f, -7.95466602e-02f, 9.76840034e-03f, -1.57995708e-02f,
  8.65617767e-02f, 1.43728569e-01f, -2.63668015e-03f, 2.67576217e-03f, 3.04123946e-02f, -1.62248779e-02f, 1.64371535e-01f, -4.48383540e-02f, -1.14728034e-01f, -5.09171337e-02f,
  7.11917237e-04f, 3.06720287e-03f, 2.40930337e-02f, -3.73507701e-02f, -9.53762904e-02f, 1.74351223e-02f, 9.74997580e-02f, -1.25717074e-01f, -9.76846665e-02f, 9.75105762e-02f,
  -5.57254143e-02f, 1.20990403e-01f, 1.91871189e-02f, -8.55889693e-02f, -1.31247817e-02f, -2.56042025e-04f, -6.41618147e-02f, -9.55876559e-02f, -1.10144407e-01f, 5.64936250e-02f,
  -2.41724387e-01f, -1.84042931e-01f, 4.04482409e-02f, -2.30847031e-01f, 1.15580320e-01f, -1.82175696e-01f, -9.75272506e-02f, -1.09706977e-02f, -4.64039706e-02f, 9.74986423e-03f,
  -3.23665924e-02f, -3.47361038e-03f, -7.75263086e-02f, 1.09854890e-02f, 1.87471926e-01f, 9.71843153e-02f, -2.00810462e-01f, 1.09110542e-01f, 4.72806320e-02f, 1.17926776e-01f,
  -2.56723668e-02f, 1.08185880e-01f, 1.78346798e-01f, 6.45103678e-02f, 3.92895900e-02f, 7.46274143e-02f, 8.06978345e-02f, 1.29432052e-01f, 1.36524841e-01f, 1.25966802e-01f,
  -9.83101487e-01f, -4.44613993e-01f, -1.24499828e-01f, -4.87979710e-01f, -4.33619358e-02f, 7.73084313e-02f, -1.65165588e-01f, 9.60867554e-02f, -5.84242344e-02f, -2.44527325e-01f,
  -1.64775982e-01f, -5.68024479e-02f, -2.14118987e-01f, 1.49295434e-01f, 9.84721184e-02f, -4.71368253e-01f, -2.08861247e-01f, -8.82981047e-02f, 1.79308817e-01f, 2.33303249e-01f,
  -2.85496786e-02f, -2.03363717e-01f, -6.38402775e-02f, 2.67768562e-01f, 1.99419912e-02f, -3.90489027e-02f, -1.34891793e-01f, -7.04593956e-02f, 7.00847208e-02f, -3.09951872e-01f,
  -1.84474856e-01f, -1.87274024e-01f, 3.83475646e-02f, -4.55038287e-02f, -1.52278945e-01f, 6.43839240e-02f, -1.41163990e-01f, -6.25211000e-02f, -3.71132381e-02f, 1.35597270e-02f,
  2.10996252e-02f, 9.19691473e-02f, -1.05779804e-01f, -2.19841078e-02f, -6.66106865e-02f, -3.00708171e-02f, 1.17622867e-01f, 1.68653615e-02f, 5.00601064e-03f, 1.18473105e-01f,
  -4.10203263e-02f, -5.39864153e-02f, -3.28554714e-04f, 2.53536403e-01f, 4.79550660e-02f, -1.61590073e-02f, 1.31799847e-01f, 1.71040386e-01f, 2.75212139e-01f, -1.14761703e-01f,
  -1.10850453e-01f, 1.46385133e-02f, 5.63133098e-02f, 8.79022945e-03f, 6.07163981e-02f, -2.00223848e-01f, 3.30645554e-02f, 8.71490035e-03f, 1.56583339e-02f, -3.12029086e-02f,
  -4.78209704e-02f, -1.11243010e-01f, 3.42485011e-02f, -1.75871402e-01f, -1.57922748e-02f, 2.00352934e-03f, -5.59484065e-02f, -1.02758287e-02f, 8.93528163e-02f, -1.40543943e-02f,
  -1.74355377e-02f, 1.22063488e-01f, -3.52351053e-04f, 9.32585001e-02f, 1.47912866e-02f, 2.12372150e-02f, 4.83387075e-02f, 4.59409319e-02f, 7.55714998e-02f, 4.03590575e-02f,
  -3.60611171e-01f, 1.93136334e-02f, -2.00994939e-01f, 1.34136960e-01f, 2.87328623e-02f, 5.62980510e-02f, 1.50127532e-02f, 7.77200311e-02f, -1.10997865e-02f, 1.28063440e-01f,
  1.68116927e-01f, 1.90544222e-02f, -9.15998444e-02f, 9.13884267e-02f, -9.19921417e-03f, -6.49394691e-02f, -6.07557483e-02f, -8.85052979e-02f, 1.36062190e-01f, 6.59193397e-02f,
  9.70195532e-02f, -5.16104735e-02f, -1.15031511e-01f, 4.82649170e-02f, 8.36503506e-03f, -4.42452021e-02f, -8.94143656e-02f, -1.61999762e-02f, 1.48855582e-01f, -1.58707172e-01f,
  -6.41354084e-01f, -4.32216860e-02f, -3.22971791e-01f, -5.69763668e-02f, 3.32619548e-01f, 2.09645972e-01f, 6.36336207e-02f, -6.66264072e-02f, 6.74013495e-02f, -8.79998505e-02f,
  -2.49442205e-01f, 6.20788634e-02f, 4.25073877e-02f, 3.34994979e-02f, -2.36812886e-02f, 1.29645988e-01f, 3.78947586e-01f, 1.11066528e-01f, -9.07090306e-03f, -9.89996046e-02f,
  3.04463893e-01f, 5.35194241e-02f, -2.17269629e-01f, 4.43971455e-02f, 1.95697457e-01f, 1.77819133e-01f, -9.73831862e-02f, 2.82933423e-03f, 1.17562272e-01f, 3.54164243e-01f,
  -4.04880673e-01f, -4.24959153e-01f, 9.22902822e-02f, -9.71189439e-02f, 3.60189825e-02f, -1.58735380e-01f, -5.01852073e-02f, -2.45544296e-02f, -8.61683637e-02f, -3.98647338e-02f,
  -2.72217691e-02f, -1.34809285e-01f, 2.33892158e-01f, 1.45657510e-01f, -1.58855394e-01f, -1.07607126e-01f, 6.24850281e-02f, -1.83294773e-01f, -9.25565735e-02f, -1.97357059e-01f,
  4.46939528e-01f, 2.48720169e-01f, -2.06493676e-01f, -3.21309955e-04f, -6.45272136e-02f, 1.17367484e-01f, -2.26614237e-01f, -1.39763772e-01f, -2.71198690e-01f, -7.06381649e-02f,
  -2.40368620e-02f, -1.28539875e-01f, -3.37873921e-02f, 1.66050382e-02f, 1.19981214e-01f, 7.16958940e-02f, 1.24853879e-01f, 1.68293506e-01f, 9.02732164e-02f, -1.27029093e-03f,
  7.24412967e-03f, -1.96430068e-02f, -1.33778714e-02f, -1.62020132e-01f, -5.07446658e-03f, -2.10490376e-02f, 1.03062220e-01f, -1.10242078e-02f, -5.08365892e-02f, 2.51375120e-02f,
  -3.87476310e-02f, -4.35720757e-02f, 3.84811200e-02f, 2.54174341e-02f, 7.38802925e-02f, -1.36232823e-01f, -3.05775832e-03f, -1.02994069e-01f, -5.77574447e-02f, -3.15517485e-02f,
  -1.51948452e-01f, 2.10554525e-01f, -3.86360995e-02f, -2.17298508e-01f, 4.90692258e-03f, -3.82782891e-02f, -1.43759996e-02f, -1.35852247e-01f, -1.48083828e-02f, -1.38001852e-02f,
  -9.42897424e-02f, -1.25764832e-01f, 9.84785426e-03f, -7.02401390e-03f, -6.24751253e-03f, -1.69787169e-01f, 4.80318093e-04f, 7.57666007e-02f, 6.30182307e-03f, -5.49851917e-02f,
  4.51951474e-02f, -7.20919892e-02f, -2.82539874e-01f, -2.02501372e-01f, 1.47611406e-02f, -1.53777286e-01f, -1.36373892e-01f, -1.14066593e-01f, -2.20632389e-01f, -2.30192110e-01f,
  -4.47478652e-01f, 1.56071544e-01f, -8.80915374e-02f, -3.68740648e-01f, 1.97858781e-01f, 2.79765785e-01f, 2.83640176e-01f, 2.44379073e-01f, 2.25547869e-02f, -1.87913924e-02f,
  1.58426061e-01f, -9.54294056e-02f, -2.97049761e-01f, 3.09914853e-02f, 3.64811122e-02f, -1.72913726e-02f, -7.52655789e-02f, -1.52525976e-01f, 1.90748602e-01f, 4.04140800e-01f,
  2.85245236e-02f, -7.72825256e-02f, -1.53489187e-01f, -1.92753207e-02f, -1.93005115e-01f, -1.87219575e-01f, -2.48821482e-01f, -2.65006512e-01f, -1.46296546e-01f, -5.01569629e-01f,
  -1.03875346e-01f, 8.80047828e-02f, 1.88320503e-02f, -2.14333072e-01f, -1.51991919e-01f, -1.93649963e-01f, 6.69650063e-02f, -8.52018222e-02f, 4.60775662e-03f, 2.11500172e-02f,
  -8.35137591e-02f, 1.15713418e-01f, -3.07954773e-02f, -4.54875268e-02f, 1.00524098e-01f, 7.34023005e-02f, -4.28415425e-02f, -2.24734768e-02f, -1.44242980e-02f, 1.31944716e-01f,
  -1.12258084e-01f, 3.49464715e-02f, -2.35805698e-02f, 3.34539823e-02f, 6.91334158e-02f, -1.15920179e-01f, 7.26551935e-02f, -9.77937058e-02f, -6.84453696e-02f, -3.59054804e-01f,
  7.13642538e-02f, -2.04722080e-02f, -4.61087078e-02f, 3.32226902e-02f, -4.87139747e-02f, 1.05697438e-01f, -1.30437380e-02f, 6.31669164e-02f, 1.42643752e-03f, -1.07733801e-01f,
  1.09014466e-01f, 1.11259632e-01f, 6.77854642e-02f, 2.28728843e-03f, -1.06484797e-02f, 8.33843723e-02f, 6.21419437e-02f, -2.60978378e-02f, -4.43490744e-02f, 6.89469371e-03f,
  6.00331947e-02f, -7.94739127e-02f, 7.96652287e-02f, -2.22168006e-02f, -6.51798919e-02f, -1.45099252e-01f, 4.86873575e-02f, 9.35167447e-02f, 2.65197903e-02f, 8.94488543e-02f,
  -7.61717409e-02f, -2.99777761e-02f, -5.66733070e-02f, 8.00595991e-03f, 6.23252755e-03f, -8.59779418e-02f, -3.93801183e-02f, -7.16661885e-02f, -5.24632111e-02f, -1.18016601e-02f,
  1.19238861e-01f, 3.47103854e-03f, -1.32817611e-01f, -3.30690928e-02f, -5.14637418e-02f, 1.47465989e-01f, -7.75511563e-02f, 3.34475450e-02f, 1.25884274e-02f, 4.60305177e-02f,
  -1.61883205e-01f, 7.89958332e-03f, -8.73267353e-02f, -8.95114094e-02f, -9.39486846e-02f, -1.51935741e-01f, -2.74900168e-01f, -1.23550370e-01f, -1.49972171e-01f, -5.12109280e-01f,
  6.12034857e-01f, 2.65063703e-01f, 3.90759498e-01f, 3.72434735e-01f, 1.86165035e-01f, 1.80219054e-01f, 3.22208136e-01f, 5.23719713e-02f, 6.03464656e-02f, 5.72404079e-02f,
  -1.26030430e-01f, -7.14867562e-02f, -2.01821074e-01f, -1.45805255e-01f, 7.61316046e-02f, 1.95615273e-02f, 1.14461891e-01f, 9.68034416e-02f, 9.96330529e-02f, 3.82093042e-02f,
  -2.14623800e-03f, -4.29634340e-02f, -7.81039670e-02f, -1.67323023e-01f, 4.50642928e-02f, -1.44938573e-01f, -5.19717261e-02f, -1.83668640e-02f, -2.04120114e-01f, 1.07039370e-01f,
  1.99531883e-01f, 2.43100822e-01f, 1.89220130e-01f, 4.82213795e-02f, -9.58569050e-02f, -3.17432359e-02f, 1.83756296e-02f, -3.38150701e-03f, 8.35443586e-02f, 9.89476442e-02f,
  4.83194776e-02f, -1.53188676e-01f, -1.34088034e-02f, -2.45574545e-02f, 8.46436024e-02f, 4.56029028e-02f, -4.62210812e-02f, 2.71236568e-05f, 5.95709346e-02f, 4.09596413e-02f,
  -1.37646928e-01f, 2.92186793e-02f, 1.07540153e-01f, 1.07262924e-01f, 1.02904998e-01f, -1.55862039e-02f, 5.92030548e-02f, 1.03752576e-01f, 5.48293330e-02f, 8.39497708e-03f,
  -1.48704901e-01f, -5.00193797e-02f, 2.35430300e-02f, -7.55826831e-02f, -1.12713531e-01f, -4.85084951e-02f, -2.02801526e-02f, 3.71405259e-02f, 1.28347157e-02f, -4.64407690e-02f,
  -2.35095490e-02f, 1.57678783e-01f, 1.87519327e-01f, -6.89327195e-02f, -3.22467536e-02f, 7.36811608e-02f, 1.35036454e-01f, 9.24473256e-02f, 6.23142626e-03f, 5.93539141e-02f,
  9.26181227e-02f, -8.56168866e-02f, -1.45318821e-01f, -1.71303347e-01f, -5.64351166e-03f, -4.82989699e-02f, 8.80006328e-02f, -9.51374043e-03f, -1.51938275e-01f, -1.18592620e-01f,
  1.67225957e-01f, 6.35843202e-02f, 1.43617451e-01f, 3.38133276e-02f, 6.28215522e-02f, -8.89390260e-02f, 1.19335651e-01f, -2.70739309e-02f, 2.92855445e-02f, 3.24349329e-02f,
  6.03243969e-02f, 2.82724053e-02f, -9.69931260e-02f, 1.04686737e-01f, -5.16026653e-02f, 2.23828591e-02f, -6.49575144e-03f, 1.47980928e-01f, 1.27976537e-01f, 7.17841089e-02f,
  1.71315130e-02f, 2.17084736e-01f, 1.99483991e-01f, 6.53524026e-02f, 1.18412398e-01f, 8.68551135e-02f, 2.32526194e-02f, 1.28916934e-01f, -5.79771511e-02f, -2.14936763e-01f,
  -1.54638827e-01f, -2.70666331e-01f, 2.44003646e-02f, -8.36737752e-02f, 9.22624692e-02f, 6.62977174e-02f, -3.28202039e-01f, -4.59075123e-02f, 5.05609147e-04f, -4.25765306e-01f,
  -2.76029743e-02f, 1.29603595e-01f, -1.43444151e-01f, 8.34663957e-03f, 6.78126737e-02f, -4.00723726e-01f, -2.76341200e-01f, 1.19264357e-01f, 4.98784631e-01f, 3.26183259e-01f,
  1.53601408e-01f, 7.14918301e-02f, 2.44569510e-01f, 1.68704957e-01f, -2.30020702e-01f, 7.98221454e-02f, -2.38611713e-01f, -1.40637085e-01f, -1.35031361e-02f, -3.94043297e-01f,
  -2.65619814e-01f, -1.20316304e-01f, 2.18899772e-01f, -1.35607980e-02f, -2.06375755e-02f, -8.48861188e-02f, -1.36747807e-01f, -8.26732144e-02f, 6.69838786e-02f, 3.21665057e-03f,
  -2.58899969e-03f, 1.37196422e-01f, 1.08300894e-01f, 7.87564740e-02f, 7.04373047e-02f, -2.65575945e-02f, 1.81959402e-02f, -3.79100032e-02f, 2.15653852e-02f, -1.50163561e-01f,
  -2.18911558e-01f, -6.92732111e-02f, 3.70886200e-03f, -2.81753484e-02f, 1.94994230e-02f, 5.50409816e-02f, 6.87753558e-02f, 5.77742234e-02f, -5.46847004e-03f, -2.93227285e-01f,
  6.55589476e-02f, 6.91987723e-02f, 1.62398294e-02f, -4.92928810e-02f, -3.93841555e-03f, -7.04954565e-02f, -3.39477398e-02f, -5.92146516e-02f, 8.01611394e-02f, -6.36515990e-02f,
  5.54477461e-02f, 1.74822472e-03f, 1.07345795e-02f, 4.01367769e-02f, 4.24628183e-02f, -1.72647946e-02f, -9.19341389e-03f, -8.99837073e-03f, 4.55004424e-02f, 1.58272460e-02f,
  1.02974534e-01f, 1.90954085e-03f, -5.83129600e-02f, 5.66264875e-02f, 1.67598184e-02f, 1.85644925e-02f, -7.51570836e-02f, 3.78808938e-02f, -7.46390522e-02f, -7.44495243e-02f,
  1.26185030e-01f, 1.93992436e-01f, -2.14405566e-01f, -1.59888715e-02f, -2.56526861e-02f, -4.08756547e-02f, -8.64527524e-02f, 8.56090337e-02f, 2.02041753e-02f, -1.14521250e-01f,
  -3.34031880e-02f, -1.34185165e-01f, -2.69750394e-02f, 3.64242569e-02f, 8.79951045e-02f, -4.94978577e-02f, -2.04830110e-01f, 4.29596752e-02f, 1.14580639e-01f, 1.09582551e-01f,
  -1.89775862e-02f, -1.08525362e-02f, 1.12244552e-02f, -1.51394576e-01f, -3.77391391e-02f, -2.97499821e-02f, -2.23383158e-02f, -6.04336075e-02f, -1.31891835e-02f, -2.92402178e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  2.75812775e-01f, 3.38170320e-01f, -4.11318019e-02f, -4.94311117e-02f, 4.30946425e-02f, 4.37824847e-03f, -2.71457396e-02f, 7.01374188e-03f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  2.93567151e-01f, 1.95131645e-01f, -1.15051225e-03f, 1.00382544e-01f, -1.35346621e-01f, 4.86272126e-02f, -1.06918968e-01f, 1.83149166e-02f, -4.39515002e-02f, -2.43629329e-02f,
  6.61286265e-02f, 7.98011497e-02f, 1.80402353e-01f, -2.51873821e-01f, 7.02734515e-02f, 7.40068629e-02f, -2.24931225e-01f, 1.46317288e-01f, -1.69216514e-01f, 6.60836101e-02f,
  -2.48436034e-01f, 2.55313218e-01f, -4.04013954e-02f, 1.59421489e-01f, -1.52413458e-01f, 2.26011742e-02f, 7.37568960e-02f, -3.44693840e-01f, 5.23822429e-03f, -2.54385650e-01f,
  2.29630843e-01f, -5.51676810e-01f, 6.44815266e-02f, -3.56448442e-02f, -9.97421797e-04f, -7.25717172e-02f, 4.28443914e-03f, 3.78318626e-04f, 6.81451662e-03f, -4.02723290e-02f,
  1.64203197e-02f, 9.40653831e-02f, -2.00780611e-02f, -8.99678282e-03f, -2.81182349e-01f, -5.82357869e-02f, -2.36395672e-01f, 8.62110853e-02f, -1.15676098e-01f, -3.40363185e-04f,
  -9.39054694e-03f, 1.76447913e-01f, 3.46254893e-02f, -8.75399187e-02f, 5.49043668e-03f, -1.37457535e-01f, -3.21539372e-01f, 2.39375994e-01f, -3.71168822e-01f, 2.08121449e-01f,
  -2.44535103e-01f, -2.27269474e-02f, 3.15324888e-02f, 3.64513874e-01f, -3.25717568e-01f, -5.80291674e-02f, -2.29688957e-01f, 2.68695168e-02f, -5.63375950e-01f, 7.35109299e-02f,
  -2.13764548e-01f, -2.42365971e-02f, -9.15172771e-02f, 7.77890384e-02f, 3.01401377e-01f, -6.25499934e-02f, -5.05016327e-01f, 7.87824467e-02f, -4.22784388e-01f, 2.39018112e-01f,
  -1.96823627e-01f, -7.91113600e-02f, -4.41189080e-01f, 2.24925101e-01f, -7.44346753e-02f, -8.25518444e-02f, 4.14329506e-02f, -2.21796408e-01f, -1.59091368e-01f, 4.44189198e-02f,
  -2.69093782e-01f, -7.59737892e-03f, 3.30217361e-01f, -1.85143918e-01f, -1.49319515e-01f, 3.92644793e-01f, -1.86740786e-01f, 1.06832795e-01f, -1.72149509e-01f, 2.24318150e-02f,
  -4.04989570e-02f, -2.73494180e-02f, -1.97161757e-03f, 1.25922561e-01f, -4.78716381e-02f, -5.31375967e-02f, 1.45209849e-01f, 4.43101600e-02f, 2.93369770e-01f, -2.75869220e-02f,
  3.18443179e-01f, 4.14761268e-02f, 6.28021434e-02f, -1.56905353e-01f, 2.11299341e-02f, 4.10939418e-02f, 1.18508026e-01f, -7.90715367e-02f, 7.59626180e-02f, -3.22397530e-01f,
  -5.51190414e-02f, 1.99635521e-01f, 3.45606916e-02f, 8.48061144e-02f, -1.43496454e-01f, 2.45964348e-01f, 1.78808808e-01f, -2.69838441e-02f, 1.42514631e-01f, -1.63985968e-01f,
  1.39342844e-01f, -1.17862083e-01f, 9.02002081e-02f, -9.21652019e-02f, 5.16758487e-03f, -1.01921760e-01f, -1.10426508e-01f, -5.99525236e-02f, -1.79065913e-02f, 1.67303253e-02f,
  -1.10391758e-01f, -6.16802350e-02f, -1.05708942e-01f, 3.43974754e-02f, -7.24305212e-02f, 7.56700058e-03f, -3.90812308e-02f, 4.50383825e-03f, -1.27545327e-01f, 1.33922517e-01f,
  1.30751684e-01f, 1.54224291e-01f, -8.86520967e-02f, 2.53371477e-01f, 2.58101616e-03f, -1.48844838e-01f, -2.69987315e-01f, -1.71886981e-01f, -1.10161759e-01f, -1.90237954e-01f,
  6.49174675e-02f, 9.73882452e-02f, 1.57336399e-01f, 5.38097918e-02f, 9.16413441e-02f, -2.05782838e-02f, -4.34516318e-04f, -1.11921109e-01f, 4.89160456e-02f, -9.19718668e-02f,
  2.83175893e-02f, 5.27736433e-02f, -2.62575373e-02f, -5.20858802e-02f, 1.27274334e-01f, 2.42126286e-02f, -6.31676093e-02f, -8.05874765e-02f, 5.55954501e-02f, -2.14508958e-02f,
  3.54083851e-02f, -8.96632001e-02f, 1.42587230e-01f, -2.20840201e-01f, -7.93635324e-02f, 1.92053705e-01f, 7.12679997e-02f, -4.47687954e-01f, 3.38499427e-01f, -9.93124023e-02f,
  1.75293863e-01f, -1.56833351e-01f, -4.39372408e-04f, -8.78879055e-02f, 2.41281912e-01f, -1.44535244e-01f, 1.06784552e-01f, -7.14869201e-02f, -4.71531041e-02f, -9.33308061e-03f,
  -5.26249446e-02f, 5.13196103e-02f, -7.16863573e-02f, -1.49413839e-01f, -1.65617481e-01f, 2.13794857e-01f, -1.54649258e-01f, -3.64250280e-02f, 1.75938427e-01f, 1.24494713e-02f,
  -3.54384147e-02f, -1.32445991e-01f, -2.83828259e-01f, 1.40105024e-01f, 4.55434946e-03f, 3.00847709e-01f, 2.87668593e-02f, -1.72900453e-01f, -3.58695234e-03f, -1.12029083e-01f,
  -1.22136563e-01f, -3.19451362e-01f, 1.59990013e-01f, -2.59040833e-01f, 3.37384455e-02f, 1.30546838e-01f, 6.25878125e-02f, 4.12967578e-02f, -6.90121278e-02f, 9.92594212e-02f,
  -8.69215131e-02f, -1.29025847e-01f, 3.96198072e-02f, -8.89419913e-02f, -3.13059501e-02f, -4.61313762e-02f, -2.16035172e-01f, 8.55282396e-02f, -5.82720786e-02f, -6.82763606e-02f,
  1.26947522e-01f, 1.17318287e-01f, 6.05105050e-02f, -1.45536423e-01f, -5.26278801e-02f, 1.10541858e-01f, -3.67043503e-02f, 9.79310200e-02f, -1.04824081e-01f, 2.83243090e-01f,
  1.19140603e-01f, -3.03786308e-01f, -5.42086780e-01f, -1.84871182e-01f, 7.42593333e-02f, -1.42305866e-01f, -5.90822548e-02f, 1.15079261e-01f, -2.92910542e-02f, 1.78596675e-01f,
  -3.59889157e-02f, -1.12443622e-02f, -1.84913948e-01f, 5.62069304e-02f, 9.79403481e-02f, -1.15510680e-01f, 2.48504817e-01f, -5.06278649e-02f, 3.05059701e-01f, 2.52910256e-01f,
  1.00623295e-02f, -1.96907178e-01f, 1.55380994e-01f, 8.13593417e-02f, -1.29557371e-01f, -8.28760788e-02f, -3.63104157e-02f, -4.71397698e-01f, -3.19509119e-01f, 3.06812286e-01f,
  9.60976556e-02f, 4.70374264e-02f, -3.25070143e-01f, 4.36469197e-01f, -3.20472002e-01f, 1.32694215e-01f, -1.73793465e-01f, 2.71848440e-01f, 1.93345383e-01f, 3.10190134e-02f,
  2.98627466e-01f, 1.79975957e-01f, -1.56770144e-02f, 9.94329676e-02f, -1.37577087e-01f, 9.87558961e-02f, 3.05630177e-01f, 9.46850479e-02f, 1.53871089e-01f, -1.29174352e-01f,
  -5.62741995e-01f, -7.75199756e-02f, -2.97422886e-01f, 1.19052514e-01f, 1.19565792e-01f, 2.13702116e-02f, -6.57406002e-02f, -1.47035554e-01f, -3.69033158e-01f, 1.65556461e-01f,
  1.54847831e-01f, 9.70647088e-04f, -6.00993708e-02f, 1.98685229e-01f, -4.01278734e-02f, 2.77606789e-02f, -3.91710132e-01f, -2.58930981e-01f, 1.80982798e-02f, 1.21557906e-01f,
  -1.38009012e-01f, 7.08832219e-02f, 1.14984035e-01f, 1.14147559e-01f, 3.24264280e-02f, 1.64387375e-02f, 1.90448388e-02f, 7.03670532e-02f, -1.16509661e-01f, -3.31892376e-03f,
  1.02295242e-01f, -1.18005842e-01f, -3.76814216e-01f, 3.00918967e-01f, -2.27169156e-01f, 1.15125269e-01f, 1.49792299e-01f, 2.40946580e-02f, 3.37162381e-03f, -9.99285951e-02f,
  -7.48464614e-02f, -1.89301401e-01f, 7.63932522e-03f, 1.17918558e-01f, 2.50192910e-01f, -4.41494733e-02f, -2.16636479e-01f, -2.42784917e-01f, 5.13940379e-02f, -4.56019819e-01f,
  1.14114821e-01f, 1.76382568e-02f, 1.22010373e-01f, -2.21886471e-01f, 2.16202009e-02f, 6.68176562e-02f, 5.83910383e-02f, -7.18775541e-02f, -1.59529403e-01f, -1.36625439e-01f,
  -1.46976665e-01f, -6.86574802e-02f, 1.92814142e-01f, -1.31713450e-02f, -1.99544340e-01f, -3.19112360e-01f, -5.97782470e-02f, 1.12823406e-02f, 3.11225373e-03f, 8.48906860e-02f,
  -2.03026459e-02f, 9.98411998e-02f, -1.73264116e-01f, 1.37243405e-01f, 8.78236219e-02f, -1.94184899e-01f, 1.39507174e-01f, 3.73045653e-01f, 2.74389744e-01f, -3.04093897e-01f,
  9.61809456e-02f, -6.70710877e-02f, 2.63339758e-01f, -5.08977063e-02f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  3.92544866e-01f, 2.20653713e-01f, 2.39854515e-01f, 2.57624000e-01f, 1.30171433e-01f, 2.64749616e-01f, -4.58765179e-02f, 8.77381712e-02f, 6.50199205e-02f, 4.36745510e-02f,
  1.71610992e-02f, -1.22797728e-01f, -6.26080902e-03f, -1.68970227e-01f, 2.04248294e-01f, 2.41887644e-01f, 2.12165520e-01f, 1.12187207e-01f, 1.67940915e-01f, -1.11213818e-01f,
  -5.01615882e-01f, 7.09717929e-01f, 1.42679498e-01f, 2.48162925e-01f, -4.81029823e-02f, 3.52522403e-01f, 1.99147299e-01f, -4.64132845e-01f, -1.82413548e-01f, -7.30216131e-02f,
  -2.05852389e-01f, -2.28236437e-01f, -1.80352584e-01f, -1.30657618e-05f, 1.33031458e-01f, 1.69842653e-02f, 4.00856853e-01f, 1.46897599e-01f, 1.60583392e-01f, 2.08813056e-01f,
  1.94743618e-01f, 2.32810274e-01f, -7.61419982e-02f, 3.93079128e-03f, -1.20157488e-01f, 1.18600100e-01f, -1.94934204e-01f, 2.16339007e-02f, 3.57598424e-01f, 4.11029756e-02f,
  2.71702796e-01f, -1.84555069e-01f, 4.07298133e-02f, -5.76848760e-02f, 4.37692888e-02f, 2.37514094e-01f, 4.11506027e-01f, 3.01865697e-01f, 2.25153476e-01f, -1.94854066e-01f,
  -3.23915809e-01f, -2.74159133e-01f, 1.07747301e-01f, -5.33447638e-02f, 3.26593995e-01f, 3.26940298e-01f, 5.30541301e-01f, -6.06689751e-02f, 4.23744410e-01f, 2.16444090e-01f,
  9.45839733e-02f, 1.04609244e-01f, 7.48613849e-02f, 2.31466785e-01f, -1.74968332e-01f, -1.04700662e-01f, -3.40511650e-02f, -3.66541743e-02f, 6.91514835e-02f, 1.43230185e-02f,
  3.50887537e-01f, 3.12352944e-02f, 2.61755526e-01f, -1.39184877e-01f, 9.29223374e-02f, 1.97410271e-01f, -9.36167464e-02f, 2.52900958e-01f, -2.58043468e-01f, 2.34565973e-01f,
  -2.99694598e-01f, 4.50607091e-01f, -2.14194670e-01f, 6.52359605e-01f, 2.97780614e-03f, 1.61441952e-01f, 3.74618471e-01f, 6.00453734e-01f, 2.41438434e-01f, 5.54623961e-01f,
  -7.08400384e-02f, 2.80372590e-01f, 2.79377140e-02f, 5.17361045e-01f, 1.77046061e-01f, 3.15637231e-01f, 9.52824950e-02f, 2.42233556e-02f, -3.97903562e-01f, -2.53603667e-01f,
  -1.39324039e-01f, 3.17204416e-01f, -2.53471196e-01f, -1.00964703e-01f, -3.64388935e-02f, 2.56083876e-01f, -2.28678065e-04f, 2.45905980e-01f, 5.74945547e-02f, -7.60253370e-01f,
  -5.16546257e-02f, 1.14003435e-01f, 2.01242566e-01f, -7.15875113e-03f, 4.54113752e-01f, 2.85899967e-01f, -1.26269698e-01f, 2.91534066e-01f, 6.51513875e-01f, 2.14466825e-01f,
  2.92984873e-01f, 3.63985926e-01f, 3.63653421e-01f, 1.71942666e-01f, 2.92812288e-01f, -2.10839927e-01f, 2.59887367e-01f, 1.70957670e-01f, 1.59294501e-01f, 3.31417471e-01f,
  9.65137899e-01f, -3.55673045e-01f, -2.65090764e-01f, -8.85628089e-02f, -4.07140344e-01f, 3.33330361e-03f, -1.60039932e-01f, 3.40233803e-01f, -3.59209001e-01f, -5.36222802e-03f,
  -2.14604214e-01f, 3.53079826e-01f, 1.49206176e-01f, -4.18793678e-01f, 3.41872573e-02f, -2.81808287e-01f, 3.31049412e-01f, 4.51474860e-02f, -9.42141414e-02f, -2.14102194e-01f,
  1.87793944e-03f, 2.91265160e-01f, 1.90853223e-01f, 1.29259769e-02f, -1.77493408e-01f, -3.49530056e-02f, -2.99973320e-02f, 2.16432109e-01f, 2.50917599e-02f, 1.39270872e-01f,
  1.58626437e-01f, -1.02721870e-01f, 5.44484079e-01f, 1.75806135e-01f, 6.02920711e-01f, 5.20039834e-02f, -2.69773249e-02f, -1.76127106e-02f, -3.20201665e-02f, -9.99464691e-02f,
  -1.38417510e-02f, 1.91371411e-03f, -1.26830190e-02f, -1.48194745e-01f, 4.45491165e-01f, -3.07741106e-01f, 2.54344404e-01f, -6.41907305e-02f, 4.94832784e-01f, 2.32020766e-02f,
  -1.67751476e-01f, -5.25192440e-01f, -4.16605659e-02f, 2.40479499e-01f, -2.53939927e-01f, 1.46615328e-02f, 2.14568511e-01f, 7.46965855e-02f, 2.25874931e-01f, -6.53862879e-02f,
  2.31359571e-01f, 1.22117177e-01f, -1.88771471e-01f, 6.86781481e-02f, 5.75352073e-01f, -1.88895226e-01f, 5.98192573e-01f, -1.42739519e-01f, -3.03066149e-02f, 1.26454130e-01f,
  -1.67412624e-01f, -5.22095663e-03f, 1.11650787e-01f, 8.71594250e-02f, -2.11894557e-01f, 1.64414391e-01f, -4.42190975e-01f, 7.09061474e-02f, 8.54070578e-03f, 1.19991131e-01f,
  -5.87769337e-02f, 2.31223911e-01f, 6.97966814e-02f, -2.02412739e-01f, -1.75876796e-01f, 3.11300866e-02f, 4.07325804e-01f, 3.00957769e-01f, -5.21875881e-02f, 1.01346247e-01f,
  1.80192664e-02f, 1.87733352e-01f, 3.48581761e-01f, 1.41842440e-01f, 3.76841500e-02f, -1.44724876e-01f, -1.72495574e-01f, 5.21891057e-01f, -9.78653952e-02f, 6.44127876e-02f,
  4.00531858e-01f, -1.16090864e-01f, 1.66348189e-01f, -4.29957420e-01f, -2.11023204e-02f, -5.97778074e-02f, -5.57794198e-02f, -1.00299552e-01f, 2.43785337e-01f, -1.79364324e-01f,
  5.75939715e-01f, -9.65537205e-02f, -2.59436518e-01f, -3.70085269e-01f, -2.74815559e-01f, -3.28894794e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  2.39566550e-01f, -4.60996572e-03f, 3.91998738e-01f, 1.52931035e-01f, 5.91124177e-01f, 3.24947864e-01f, 2.95605600e-01f, 2.95974940e-01f
};

// L2_fan_Wp (Shape: 12 x 32)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -3.38586718e-02f, -1.46169797e-01f, 2.19499454e-01f, 3.87175858e-01f, -1.34940758e-01f, 3.70800734e-01f, -1.03550173e-01f, -9.01931059e-03f, -1.14525393e-01f, 2.97084123e-01f,
  -1.54565752e-01f, 1.80120349e-01f, -2.63972461e-01f, 7.85340369e-02f, 3.52267057e-01f, -2.45395929e-01f, -1.55505957e-02f, -2.85332531e-01f, -3.62308741e-01f, -6.06977820e-01f,
  3.22210677e-02f, -1.48853362e-01f, -2.22853586e-01f, -1.48660243e-01f, -2.29263097e-01f, -1.07983679e-01f, -5.10161743e-02f, 2.19514966e-02f, -1.31665431e-02f, -1.53880596e-01f,
  -3.02528709e-01f, -8.13004747e-02f, -1.80642173e-01f, -3.74463469e-01f, -3.10983080e-02f, 1.66072205e-01f, 1.89341515e-01f, 1.84450939e-01f, -5.23829125e-02f, -1.17409050e-01f,
  2.10992068e-01f, 7.96757564e-02f, 6.00650534e-02f, 6.58956766e-02f, 2.50564098e-01f, 3.15077960e-01f, 5.42068124e-01f, -2.51761645e-01f, 2.48382259e-02f, 2.08549842e-01f,
  -3.02215755e-01f, -1.13123879e-01f, 2.45319188e-01f, 1.51471883e-01f, -5.01058996e-03f, 1.54402912e-01f, 1.51116744e-01f, -2.01230958e-01f, -1.00506626e-01f, 3.02630246e-01f,
  5.30705741e-03f, 8.77159387e-02f, -2.63752371e-01f, 3.65521796e-02f, -1.64161742e-01f, 1.37135565e-01f, -1.97846349e-02f, -9.57972258e-02f, -2.69687653e-01f, -1.17750868e-01f,
  -1.12062626e-01f, 1.68173127e-02f, -5.67684099e-02f, 1.63875014e-01f, -3.39227170e-01f, 2.36124974e-02f, -3.72094959e-01f, 4.15886760e-01f, 1.09752230e-01f, 4.06715758e-02f,
  -4.70547020e-01f, -1.33298159e-01f, -1.97082475e-01f, -1.95565298e-01f, 2.51132488e-01f, -4.33115754e-03f, -4.24051061e-02f, -2.34844103e-01f, -4.07995641e-01f, -1.10865422e-01f,
  -5.65852933e-02f, -1.78097412e-02f, 1.34726107e-01f, -2.93380737e-01f, 2.15906352e-01f, 1.08126044e-01f, -1.37964174e-01f, 2.90500820e-01f, 1.77706152e-01f, -2.17277378e-01f,
  -8.77203792e-03f, 1.21275365e-01f, 4.59033810e-03f, 6.05080351e-02f, 4.18561041e-01f, -1.29085630e-01f, -2.43582413e-01f, 8.04631859e-02f, 2.03145117e-01f, 1.78623110e-01f,
  -2.46327877e-01f, 1.24818079e-01f, 1.16212182e-01f, 1.47075832e-01f, -9.56025347e-02f, 2.92971218e-03f, 1.67791709e-01f, -2.74836123e-01f, 7.76530728e-02f, 7.36022368e-02f,
  2.41201192e-01f, -2.42819846e-01f, 3.28754097e-01f, -1.64010584e-01f, 9.31462348e-02f, -2.86170781e-01f, 5.62120855e-01f, -2.51890659e-01f, -3.53816524e-02f, 2.31297448e-01f,
  -1.79108098e-01f, 2.66504139e-01f, 3.19025926e-02f, 4.29110229e-01f, -6.91667646e-02f, 9.68359038e-02f, -6.30611777e-02f, 1.84649900e-01f, -2.17572913e-01f, 3.51004303e-02f,
  -2.01574601e-02f, 2.12433422e-03f, 2.70318657e-01f, -6.04643300e-02f, -3.67971599e-01f, -7.60702342e-02f, -1.16688669e-01f, -3.26512128e-01f, 9.36463401e-02f, 9.68589559e-02f,
  -4.16274853e-02f, 7.55206347e-02f, -1.38529152e-01f, -1.32870108e-01f, 1.53100535e-01f, -1.03562646e-01f, 2.12741539e-01f, -2.71931022e-01f, -1.37418613e-01f, -1.47968486e-01f,
  3.26071605e-02f, 9.45663750e-02f, 2.36091897e-01f, 9.55269709e-02f, -8.70757699e-02f, -1.47216797e-01f, -2.86007524e-01f, -2.62894511e-01f, -1.05563350e-01f, -1.85966715e-02f,
  -5.69186568e-01f, -4.91814502e-02f, -5.71283460e-01f, 1.25268653e-01f, 1.84686601e-01f, 9.65327118e-03f, -5.64280927e-01f, -1.58711314e-01f, 1.44169196e-01f, -4.10490215e-01f,
  -1.04314707e-01f, -1.91668496e-01f, 7.17471614e-02f, -3.83165143e-02f, -4.23937738e-01f, 2.09322408e-01f, 5.96941784e-02f, 1.66494623e-01f, -2.55301535e-01f, 1.75677881e-01f,
  -1.72221780e-01f, -7.07290620e-02f, -4.78002205e-02f, 3.35615754e-01f, 2.58641601e-01f, -3.99778821e-02f, 4.92245108e-02f, 6.79740310e-02f, -1.16664670e-01f, 1.04284277e-02f,
  1.19314222e-02f, 2.95215935e-01f, 4.43716459e-02f, 2.78696448e-01f, -5.08784115e-01f, 2.24776581e-01f, -8.80588740e-02f, -5.84754825e-01f, -6.11769967e-02f, -5.01691759e-01f,
  7.40797445e-02f, -2.54995614e-01f, 2.79853821e-01f, 2.56831616e-01f, 4.10925522e-02f, -3.40241730e-01f, -5.63520603e-02f, 2.33065039e-01f, 3.71147454e-01f, 1.53405946e-02f,
  -1.68862745e-01f, -9.05272141e-02f, -1.05830871e-01f, -1.94808785e-02f, 4.90198173e-02f, 1.66026801e-01f, 1.37323648e-01f, -2.47826334e-02f, -2.65709192e-01f, -1.20533733e-02f,
  -3.36957157e-01f, -5.06333001e-02f, -1.55964032e-01f, -9.74958837e-02f, 3.57160978e-02f, -3.57563734e-01f, -1.95247263e-01f, 2.72850484e-01f, 3.75991017e-01f, 2.39233539e-01f,
  -3.21408570e-01f, 2.12151006e-01f, -2.69911736e-01f, -1.61862060e-01f, -8.37436225e-03f, 8.73456616e-03f, 2.02559140e-02f, -1.21574318e-02f, -3.45831543e-01f, 1.10277340e-01f,
  5.19297011e-02f, 2.23283961e-01f, 8.76795128e-02f, -2.02598885e-01f, 1.62782371e-01f, -4.13086414e-01f, 1.20595992e-01f, -1.85506389e-01f, 4.96831127e-02f, 3.31841290e-01f,
  2.98147082e-01f, 4.88909841e-01f, 4.68894064e-01f, -1.89360064e-02f, 4.55304146e-01f, 3.94852579e-01f, 4.07159537e-01f, 2.54659176e-01f, 4.20375526e-01f, 4.23245460e-01f,
  1.73754990e-02f, -1.32050470e-01f, 3.55714947e-01f, -1.20341994e-01f, 7.27604404e-02f, -1.64442897e-01f, 1.00326367e-01f, 2.88644344e-01f, 1.21945418e-01f, 2.08614528e-01f,
  1.72040239e-01f, -1.43277375e-02f, 7.65489265e-02f, 1.81820229e-01f, -3.77970450e-02f, -1.46624148e-01f, -2.28226796e-01f, 8.36676359e-02f, 3.23598146e-01f, 2.16660723e-01f,
  -3.18377353e-02f, -2.33302340e-01f, 3.77780236e-02f, 2.20114887e-01f, -1.68193907e-01f, 1.08678147e-01f, -3.83751206e-02f, 1.50405258e-01f, -3.40783060e-01f, 2.21575186e-01f,
  -5.02139747e-01f, -1.20779267e-02f, -9.38536599e-02f, -5.75872958e-01f, 2.36218214e-01f, -1.40463471e-01f, 2.26019233e-01f, -6.87512234e-02f, 2.11161934e-02f, -6.49152398e-02f,
  4.71800677e-02f, -3.26588184e-01f, -1.47760034e-01f, 3.42028350e-01f, -1.06263630e-01f, -2.94462949e-01f, 2.18069464e-01f, -1.38279453e-01f, 1.02228992e-01f, 2.09940914e-02f,
  4.60736364e-01f, -4.54618558e-02f, 1.81079462e-01f, 1.69527099e-01f, -2.10347325e-01f, 2.18691006e-01f, -2.32332423e-01f, -1.03231519e-01f, 7.92915002e-02f, 1.50205791e-01f,
  1.68876164e-02f, 1.27309456e-01f, -1.50348112e-01f, 3.71172100e-01f, 1.70634627e-01f, -8.37037340e-03f, -1.01563334e-01f, -2.03597978e-01f, -5.22381067e-01f, -4.49042737e-01f,
  1.86192214e-01f, -4.95699421e-03f, -5.59101880e-01f, 1.51475772e-01f, -1.39785826e-01f, -8.65069777e-02f, -1.38608426e-01f, 5.21986037e-02f, 2.73840874e-01f, 2.22108681e-02f,
  1.24415509e-01f, -7.66871810e-01f, 4.63658012e-02f, -2.55382210e-01f, 2.51070559e-01f, -2.63260931e-01f, 7.53510743e-02f, -9.44510549e-02f, 3.32602888e-01f, 8.13960284e-02f,
  2.69427150e-01f, 2.05434665e-01f, -8.04489553e-02f, 1.27416149e-01f, -3.75334360e-02f, 4.33287144e-01f, -1.50332287e-01f, -1.98407441e-01f, 3.13129216e-01f, -7.92191848e-02f,
  2.96549592e-02f, 3.39037895e-01f, -3.14379744e-02f, 1.44388035e-01f, -6.66080266e-02f, -4.34900559e-02f, 3.48310202e-01f, 9.00662690e-02f, 3.77228141e-01f, 4.76519251e-03f,
  -4.35603082e-01f, -2.67256230e-01f, 2.50528473e-02f, -3.49590570e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 32)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  4.93760556e-01f, 1.44211009e-01f, -4.36203480e-02f, 2.28917524e-01f, 3.23521018e-01f, 5.89614213e-01f, 1.44323766e-01f, 1.55598849e-01f, 6.58631265e-01f, 4.83050704e-01f,
  3.59675437e-02f, 4.92799073e-01f, 5.42775631e-01f, 3.89037877e-01f, -4.17672634e-01f, -4.07866120e-01f, 1.57590285e-01f, -6.38188422e-02f, -4.18923534e-02f, -1.41868964e-01f,
  3.26923728e-01f, -2.04435885e-02f, -5.63849807e-01f, 8.53400752e-02f, 1.86243787e-01f, -1.53772578e-01f, 4.68435764e-01f, 1.48280868e-02f, 7.21571505e-01f, -1.76215768e-01f,
  9.21270847e-02f, -4.05242682e-01f, 7.82916024e-02f, 1.38313189e-01f, 1.86201796e-01f, 2.38059267e-01f, -1.75421201e-02f, -1.75085366e-01f, 9.42789540e-02f, -1.89246498e-02f,
  -1.50972292e-01f, 1.40859231e-01f, 1.36478007e-01f, -8.51254091e-02f, -4.94512208e-02f, -7.68198848e-01f, -5.70556402e-01f, 3.67291331e-01f, -5.39601922e-01f, 1.06584534e-01f,
  -5.99273182e-02f, -2.61684328e-01f, 4.46194559e-02f, -5.94334900e-01f, -4.25322317e-02f, -1.24751687e-01f, -2.06899911e-01f, 2.62274027e-01f, -1.32068932e-01f, -1.75694510e-01f,
  3.62768412e-01f, 6.20217979e-01f, 2.56612062e-01f, 4.10647839e-01f, -4.21213396e-02f, 4.12493438e-01f, -1.78796038e-01f, 7.28224888e-02f, 5.09556293e-01f, 1.28112450e-01f,
  4.23450500e-01f, 2.17242941e-01f, 1.65262341e-01f, 1.30015910e-01f, 2.04416096e-01f, 7.48092979e-02f, -4.93140630e-02f, 2.15636611e-01f, 3.91805880e-02f, 2.05446377e-01f,
  9.41027328e-02f, 3.10770154e-01f, 3.14374655e-01f, 3.03250253e-01f, -3.65199000e-01f, 4.10563469e-01f, 3.56571317e-01f, 3.44447941e-01f, 6.30685985e-01f, 3.69065344e-01f,
  3.23061943e-01f, 5.75212955e-01f, -9.54443812e-02f, -3.67971867e-01f, 6.67475164e-02f, 5.94840050e-01f, 2.39079013e-01f, 9.85959098e-02f, 1.07622137e-02f, -1.01209588e-01f,
  -4.90352273e-01f, -3.66365761e-02f, 2.93882731e-02f, -2.06950260e-03f, 8.97155628e-02f, 2.30167583e-01f, -1.52999625e-01f, 3.78630042e-01f, -4.37674940e-01f, 1.32750750e-01f,
  2.51791060e-01f, -2.34409899e-01f, 3.13141227e-01f, -2.00816616e-01f, -3.15939158e-01f, 1.70728192e-01f, 2.50844628e-01f, 5.52076939e-03f, -4.32461143e-01f, -4.26204130e-02f,
  -3.89161357e-03f, 2.67268002e-01f, -1.07128419e-01f, 1.03494339e-01f, 9.67515036e-02f, -2.33541980e-01f, -2.20148027e-01f, 4.50243205e-02f, -1.08625628e-01f, 8.92512426e-02f,
  3.25593174e-01f, 2.04798713e-01f, 1.23818398e-01f, -1.66383684e-01f, 5.54398857e-02f, -1.43340051e-01f, -7.10222349e-02f, -1.17030762e-01f, 7.50872195e-02f, -1.23618312e-01f,
  -2.72702217e-01f, -7.59152994e-02f, -5.42667024e-02f, 4.84006017e-01f, -2.12569579e-01f, -3.27529728e-01f, -5.02667189e-01f, -3.44934464e-01f, 3.95114601e-01f, -3.21140379e-01f,
  -5.83240330e-01f, -2.79897839e-01f, -5.04468530e-02f, -2.97372311e-01f, 4.56826568e-01f, 3.92885625e-01f, -8.59075785e-02f, 7.36028254e-01f, 3.75737876e-01f, -1.96886525e-01f,
  4.22167569e-01f, 5.32086343e-02f, 3.31331670e-01f, 1.79831818e-01f, 2.01946765e-01f, 4.33948524e-02f, 4.52269167e-01f, -5.20620756e-02f, 6.25146478e-02f, 3.61232340e-01f,
  -1.31866649e-01f, 1.90715745e-01f, -1.42857313e-01f, -1.25917075e-02f, -6.73375010e-01f, 1.27218543e-02f, 4.55434859e-01f, -3.52902889e-01f, -5.35859689e-02f, -1.25419453e-01f,
  3.05201024e-01f, -1.09807700e-01f, -3.21214110e-01f, -4.25944239e-01f, 3.98928910e-01f, 1.24435209e-01f, 4.52834755e-01f, -4.60214503e-02f, 1.35576159e-01f, 7.98892379e-02f,
  3.54582876e-01f, 5.53351566e-02f, 4.28743698e-02f, 9.77205858e-03f, -8.41990951e-03f, 4.67954427e-01f, 1.93349883e-01f, 2.98592374e-02f, 2.51629412e-01f, 3.73019069e-01f,
  -2.17160076e-01f, 9.04353112e-02f, 5.44823766e-01f, 2.67419927e-02f, 4.30630237e-01f, -4.51311320e-01f, 1.95538431e-01f, -6.05027676e-02f, -2.49860182e-01f, 2.34113693e-01f,
  1.59578815e-01f, -1.01465702e-01f, -3.70880872e-01f, 3.57280940e-01f, 4.72458661e-01f, 4.14284527e-01f, 7.84753561e-02f, 1.29619747e-01f, -4.33102071e-01f, 4.87766713e-01f,
  4.87246424e-01f, 5.71254969e-01f, -5.55384755e-01f, 2.73404390e-01f, 3.32450062e-01f, 3.53667177e-02f, -1.00861182e-02f, 4.30826694e-01f, 3.44309866e-01f, 5.29958427e-01f,
  3.78166735e-01f, 2.57683426e-01f, -7.74395838e-02f, 7.24161863e-02f, 3.67062777e-01f, 2.47444376e-01f, -1.90264031e-01f, -4.17007148e-01f, -4.07732159e-01f, -2.67604291e-01f,
  4.62633312e-01f, -2.52014130e-01f, 5.65145552e-01f, -1.80055171e-01f, 3.95110399e-01f, -4.09497656e-02f, 3.12361509e-01f, -4.42698061e-01f, 2.66468316e-01f, 1.34780034e-01f,
  1.78087920e-01f, -2.68914521e-01f, 3.33154917e-01f, 1.81989104e-01f, -2.47446835e-01f, 5.36323369e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  1.35434002e-01f, 1.68397412e-01f, 1.43548191e-01f, -3.12300995e-02f, 1.58571169e-01f, 2.01661229e-01f, 4.38906550e-01f, 5.51153161e-03f
};

// L3_fan_Wp (Shape: 12 x 32)
const int L3_fan_Wp_rows = 12;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  6.28670156e-02f, 7.22134784e-02f, 2.85311431e-01f, -2.48010054e-01f, -5.76509945e-02f, 4.73516792e-01f, -1.94555148e-01f, 3.53115827e-01f, 1.97410583e-01f, 3.07701202e-03f,
  -3.75624418e-01f, 2.82199502e-01f, -2.44045351e-02f, -1.65437665e-02f, -1.53940320e-01f, -3.97126257e-01f, -2.13975199e-02f, -3.04616690e-01f, -5.02189696e-01f, -3.51920158e-01f,
  5.17093599e-01f, 1.01233393e-01f, -2.90130585e-01f, 2.70085245e-01f, -1.12088285e-01f, 2.76667237e-01f, 8.53274763e-02f, 1.60578772e-01f, -1.95416719e-01f, -7.36471564e-02f,
  1.02505483e-01f, 2.63210326e-01f, 4.83074963e-01f, -4.38329101e-01f, 1.03884481e-01f, -2.10410491e-01f, 1.29542574e-01f, -9.31793675e-02f, 1.91015139e-01f, 1.08229555e-01f,
  -1.42253876e-01f, -2.74259783e-02f, 2.59565562e-01f, 2.73739696e-01f, 1.30794747e-02f, -1.18366322e-02f, -8.36328268e-02f, -1.71171457e-01f, 3.14043343e-01f, -8.55660513e-02f,
  -2.18174383e-01f, 4.68224883e-01f, -3.70196640e-01f, -2.78285980e-01f, 9.21206456e-03f, -6.11776531e-01f, -1.99264616e-01f, 1.39010474e-01f, 9.31709409e-02f, 3.88229825e-02f,
  -5.20487987e-02f, -2.21863016e-01f, 2.18068942e-01f, -2.35640272e-01f, -4.20977265e-01f, 3.34503502e-01f, -2.74984062e-01f, -2.88702697e-01f, -2.12608740e-01f, -6.22604072e-01f,
  -1.21193603e-01f, -4.28550035e-01f, -2.01307803e-01f, 2.86510843e-03f, 1.79356426e-01f, -5.97188715e-04f, 6.81800693e-02f, 1.15368098e-01f, -7.69414306e-02f, 2.18405560e-01f,
  -3.17211896e-01f, -1.39910564e-01f, -1.89764947e-01f, -1.85549483e-01f, -3.15309912e-02f, -6.26102388e-01f, 2.99308330e-01f, 3.15745354e-01f, -2.21847207e-03f, 2.36248802e-02f,
  -4.29242775e-02f, -3.89574617e-02f, 1.68775439e-01f, 7.06113502e-02f, -1.86522096e-01f, -4.70053703e-02f, 9.25357938e-02f, 2.45354846e-01f, -8.20549130e-02f, -7.74153247e-02f,
  1.94681078e-01f, -3.40304941e-01f, 3.60148668e-01f, 9.78206694e-02f, -7.33882859e-02f, -7.55716534e-03f, 3.60321313e-01f, 1.50544763e-01f, 2.09753159e-02f, 3.24789494e-01f,
  -1.31214455e-01f, 3.64553839e-01f, -2.20092431e-01f, -1.52115211e-01f, 1.77600965e-01f, 9.38757975e-03f, 4.88283306e-01f, 1.96692973e-01f, 9.42956135e-02f, 2.43430391e-01f,
  3.86859030e-01f, -2.25053325e-01f, -1.37133539e-01f, -1.73929155e-01f, -2.26397440e-01f, 1.18067218e-02f, 9.74277407e-02f, 1.58576190e-01f, -4.83003527e-01f, 2.82541931e-01f,
  -2.32698590e-01f, 1.77238107e-01f, -1.49337016e-02f, -8.48561823e-02f, -1.04142912e-01f, 7.98917562e-02f, -1.09925859e-01f, -1.41539827e-01f, -1.50641024e-01f, -2.44383201e-01f,
  -2.18010604e-01f, 2.15186894e-01f, 4.16413769e-02f, 2.94013590e-01f, -1.19909450e-01f, -2.50819474e-01f, -5.10815263e-01f, -9.14766118e-02f, 3.88033867e-01f, 2.89722960e-02f,
  -2.32963413e-01f, 3.39610279e-02f, -7.60342255e-02f, -2.00208798e-01f, 1.32841766e-01f, -3.76331657e-01f, -1.95387438e-01f, -4.56351340e-02f, -1.01318188e-01f, 8.75184219e-03f,
  2.81082541e-01f, 1.52550310e-01f, -2.51888573e-01f, 3.59130293e-01f, 4.26407784e-01f, 3.66010725e-01f, -1.77086294e-01f, 3.20899636e-01f, 6.20963946e-02f, -1.12529308e-01f,
  2.18383998e-01f, 3.67564589e-01f, -4.72982943e-01f, -2.01600716e-01f, 2.55353637e-02f, -1.81654781e-01f, -3.37672740e-01f, 3.87778133e-02f, 6.90716133e-02f, -2.41664931e-01f,
  -1.63679764e-01f, 5.72042048e-01f, -5.39873660e-01f, 1.32130727e-01f, -1.58887655e-01f, 2.99851269e-01f, -3.41425464e-03f, 2.90738568e-02f, -1.42539963e-01f, 1.31448105e-01f,
  7.78528601e-02f, 1.59353480e-01f, -2.07265876e-02f, -7.46794567e-02f, -4.77938056e-01f, -6.77479580e-02f, 5.86162508e-03f, -6.17694139e-01f, -8.71533826e-02f, -2.53440320e-01f,
  -3.81074816e-01f, 1.44183725e-01f, -1.72515139e-02f, -7.37365037e-02f, -1.78347751e-01f, 1.39030650e-01f, -8.01237971e-02f, -1.24460548e-01f, -1.44966871e-01f, -3.49574178e-01f,
  -9.08153430e-02f, -2.80657798e-01f, -8.24161917e-02f, 6.02491856e-01f, -3.62561166e-01f, 1.70163840e-01f, 7.20932186e-02f, -3.22461843e-01f, 1.09246679e-01f, -1.77045614e-01f,
  -9.81183425e-02f, -1.38737753e-01f, -5.27842529e-03f, 2.57786185e-01f, 9.58641618e-02f, -1.15924843e-01f, -1.99826285e-01f, -2.63485700e-01f, 2.79784232e-01f, -1.62260696e-01f,
  -4.22506750e-01f, -1.95158899e-01f, 2.58374989e-01f, -4.01232392e-02f, -5.69559336e-02f, -1.70909807e-01f, -1.28826043e-02f, 1.48007765e-01f, -4.28783111e-02f, -3.27335000e-01f,
  1.63558170e-01f, -1.05498061e-01f, -1.20764710e-01f, 1.44466506e-02f, -1.19851694e-01f, -2.25590706e-01f, -3.52827340e-01f, -4.74980772e-01f, -4.33728516e-01f, 1.32512972e-01f,
  1.89931080e-01f, -1.62972212e-01f, 4.10582945e-02f, -1.37915969e-01f, 1.89625308e-01f, 5.51161617e-02f, 2.85232514e-01f, 7.95854479e-02f, 4.31882590e-02f, -4.46730614e-01f,
  -2.64170319e-01f, 2.75124222e-01f, -1.97795466e-01f, -3.58534276e-01f, 4.22165506e-02f, -9.95539948e-02f, -2.10021287e-01f, -4.67512719e-02f, 3.00934643e-01f, -9.87756997e-02f,
  -1.42898355e-02f, -1.12088926e-01f, -3.80187482e-02f, 2.26521194e-01f, 1.50244266e-01f, -3.21682394e-01f, -2.50226587e-01f, 2.76877463e-01f, 5.39199412e-01f, -6.37237951e-02f,
  -2.56218761e-01f, 1.87760651e-01f, -1.00664698e-01f, 2.12754235e-01f, 1.72404215e-01f, 2.27625310e-01f, -1.89740226e-01f, 1.38803214e-01f, 2.61440158e-01f, -6.10889420e-02f,
  -1.28600970e-01f, -2.36113489e-01f, 5.03899120e-02f, -2.76646078e-01f, -8.41752067e-02f, -1.34183601e-01f, 5.64777181e-02f, 1.83866218e-01f, 9.43839699e-02f, 1.52269796e-01f,
  -7.31557831e-02f, -1.80498004e-01f, -1.97746694e-01f, -3.08450848e-01f, -6.66182041e-02f, -2.84838639e-02f, -2.98954368e-01f, -2.31652662e-01f, -6.08515263e-01f, 1.81943029e-02f,
  -7.76227266e-02f, -2.38898635e-01f, -1.95114210e-01f, 2.62387067e-01f, -1.27715096e-01f, -1.44283921e-01f, -1.39655322e-01f, -4.91638435e-03f, 3.44521612e-01f, 2.41734535e-01f,
  -5.60115039e-01f, -2.64035314e-01f, -4.36980486e-01f, -8.52521434e-02f, -9.17475671e-02f, -5.65142155e-01f, -1.84222847e-01f, -4.31236565e-01f, -3.38047117e-01f, -4.42624912e-02f,
  -5.73206879e-02f, -2.35367253e-01f, -9.76331159e-02f, 3.96182150e-01f, 7.16922656e-02f, -3.93054038e-02f, -2.79022098e-01f, 1.78313196e-01f, -3.19590360e-01f, -1.42933249e-01f,
  -2.47784987e-01f, -1.97691441e-01f, -4.77195770e-01f, -8.23596045e-02f, -2.29110107e-01f, -4.04409468e-02f, 2.64373999e-02f, -4.09776300e-01f, 3.83858681e-01f, 6.64669962e-04f,
  6.57147989e-02f, 3.63946795e-01f, 3.78822863e-01f, -1.19717993e-01f, 1.61237031e-01f, 2.83611447e-01f, -3.96746844e-02f, 4.95727390e-01f, -8.08440000e-02f, 1.94161072e-01f,
  3.00264299e-01f, -1.86366662e-01f, -4.10496444e-01f, -1.62798449e-01f, 3.33998561e-01f, 1.30584285e-01f, -4.86442558e-02f, -4.93861474e-02f, 2.24619836e-01f, 2.59609669e-01f,
  3.46772909e-01f, 6.10619076e-02f, 5.32260358e-01f, 1.68590277e-01f, 1.98720664e-01f, 1.42909557e-01f, -1.14394585e-02f, -2.00417355e-01f, 5.59307309e-03f, -2.32708119e-02f,
  6.83195814e-02f, 2.39426002e-01f, -2.20620617e-01f, 1.50093570e-01f
};

// L3_fan_Wp_bar (Shape: 8 x 32)
const int L3_fan_Wp_bar_rows = 8;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  -2.39450291e-01f, -3.09218109e-01f, -1.47235096e-01f, 2.22263448e-02f, -6.53994735e-03f, 3.87075007e-01f, 2.56663233e-01f, -6.97753429e-01f, -4.74574089e-01f, 9.39379215e-01f,
  -5.99508464e-01f, 4.13407445e-01f, 2.98344642e-01f, 1.34107873e-01f, 2.43398726e-01f, -7.19785571e-01f, 4.08216894e-01f, -2.37469211e-01f, 1.38783380e-01f, 6.01968495e-04f,
  1.21664397e-01f, -6.58290461e-02f, 1.11401573e-01f, -8.36125195e-01f, 4.07334387e-01f, 6.68177679e-02f, 3.68805140e-01f, -2.46682331e-01f, -5.52021146e-01f, -1.80632114e-01f,
  5.53077042e-01f, 6.28495693e-01f, 9.56666395e-02f, 2.88249224e-01f, 1.84316307e-01f, -6.26920685e-02f, 1.70260683e-01f, -6.06938958e-01f, 2.83447295e-01f, 2.85533518e-01f,
  2.87794054e-01f, -4.47488338e-01f, 3.65173548e-01f, -3.49824935e-01f, -2.93443799e-01f, 4.81225342e-01f, -6.51401222e-01f, 3.96672696e-01f, -2.68025488e-01f, -5.93298495e-01f,
  -8.63679588e-01f, 2.96673626e-01f, -2.32786387e-01f, -6.53228939e-01f, 1.35089278e-01f, -2.91409522e-01f, 3.36654514e-01f, 4.05173630e-01f, 1.04577318e-01f, -6.65636003e-01f,
  4.75391448e-01f, 1.44978343e-02f, 5.62527239e-01f, -9.15298909e-02f, 2.96358347e-01f, -2.63180807e-02f, 1.82809278e-01f, 2.53093421e-01f, 4.49781448e-01f, 5.33007920e-01f,
  7.84172118e-02f, 6.50462985e-01f, -3.39502208e-02f, -3.41346920e-01f, 2.62241930e-01f, 1.88291833e-01f, -3.38663548e-01f, -1.42288357e-02f, -3.69282722e-01f, -4.77712333e-01f,
  -2.22034544e-01f, -1.15041122e-01f, -3.86446923e-01f, -4.65035364e-02f, 4.21103776e-01f, -1.99169636e-01f, -3.65400165e-01f, 3.33310425e-01f, -4.00141120e-01f, -2.18415886e-01f,
  5.63677073e-01f, -2.11214542e-01f, -6.14385128e-01f, -2.34291568e-01f, 3.09461445e-01f, -1.73575506e-02f, -2.84555387e-02f, 3.99002880e-01f, 1.08978627e-02f, 1.73313722e-01f,
  2.19907343e-01f, 2.69968510e-01f, -2.06964403e-01f, 6.62839785e-02f, -2.14549258e-01f, 3.99242580e-01f, -4.81703654e-02f, 3.25630963e-01f, 3.82686466e-01f, -2.21381575e-01f,
  4.99998778e-01f, 5.98749220e-01f, 5.40341139e-01f, 3.86968434e-01f, 6.12369418e-01f, 4.63538587e-01f, -1.03882775e-02f, 5.37531376e-01f, 6.86140656e-02f, 4.38721746e-01f,
  9.55370009e-01f, 7.66769946e-02f, 4.77888063e-02f, 1.22630142e-03f, 1.08803105e+00f, 7.68904448e-01f, -1.90678075e-01f, 2.45086715e-01f, 1.83415323e-01f, 1.59139827e-01f,
  -2.23283231e-01f, 5.75694256e-02f, 2.61045247e-01f, -1.79916441e-01f, 1.70433074e-01f, -5.07201135e-01f, -2.49915749e-01f, 5.48947871e-01f, -2.48711169e-01f, -1.83174044e-01f,
  6.45912811e-02f, -5.97309992e-02f, -4.95317541e-02f, -3.48605603e-01f, -1.31073311e-01f, 3.32252756e-02f, 5.03494799e-01f, -3.47296864e-01f, -5.75153589e-01f, 2.95676768e-01f,
  -1.59111440e-01f, -5.36314666e-01f, 1.43416123e-02f, 7.02101946e-01f, -2.10931942e-01f, -5.77251017e-01f, 3.79352212e-01f, 1.75963551e-01f, 5.80120742e-01f, 5.83930194e-01f,
  -5.24589658e-01f, -1.03093475e-01f, -4.56315041e-01f, 2.88984388e-01f, 3.00176948e-01f, -3.07584375e-01f, 3.65925699e-01f, 2.80148059e-01f, -5.10231137e-01f, 3.93596172e-01f,
  1.85814574e-01f, 4.84469801e-01f, -2.89035529e-01f, 3.70939642e-01f, -2.02199444e-01f, 2.98964679e-01f, -1.94432303e-01f, -4.73018914e-01f, -5.12624681e-01f, -2.41495952e-01f,
  2.17798963e-01f, -4.73395646e-01f, -1.26128877e-02f, -2.16953292e-01f, 3.91006649e-01f, -2.07484141e-01f, 7.02979326e-01f, -7.61121452e-01f, -6.97926998e-01f, -2.54532754e-01f,
  4.08785552e-01f, -1.13381781e-01f, -3.95346671e-01f, 3.63976538e-01f, -2.74647802e-01f, 1.10699363e-01f, -2.06571519e-02f, 5.47479019e-02f, -2.98120648e-01f, 4.27919358e-01f,
  2.56469041e-01f, -6.48520052e-01f, 2.25864217e-01f, -2.22849444e-01f, -4.67403919e-01f, 1.51881486e-01f, -3.52397174e-01f, -5.58327958e-02f, -8.14673245e-01f, 2.55925387e-01f,
  -7.15278089e-02f, -2.43058980e-01f, 1.28874585e-01f, 2.98424333e-01f, -9.11267102e-01f, 7.93836296e-01f, -3.37187976e-01f, 5.66489063e-02f, 5.32197595e-01f, 5.56924604e-02f,
  2.07660794e-01f, 2.82967240e-01f, 1.46451771e-01f, 2.11777136e-01f, -5.31093702e-02f, 7.35073090e-01f, 5.82477190e-02f, -4.50733751e-01f, 5.57547025e-02f, -1.05649933e-01f,
  7.25561976e-02f, -2.20668927e-01f, -4.34168056e-02f, 5.62659428e-02f, 1.20485798e-01f, 1.59632228e-02f, -3.40707484e-03f, -3.76346290e-01f, -4.43679959e-01f, 2.98698079e-02f,
  -5.65439165e-01f, -2.45483264e-01f, 4.60201144e-01f, -3.23834985e-01f, 4.68851537e-01f, 5.03599644e-01f, -1.09024011e-02f, 2.76073605e-01f, 1.91108555e-01f, 4.29719657e-01f,
  2.89775848e-01f, -1.73753545e-01f, -4.97408152e-01f, 5.82600474e-01f, -9.13447067e-02f, 6.42145157e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 8)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 8;
const float L3_fan_Bp_bar_data[] = {
  1.03591770e-01f, 2.24087149e-01f, 3.11759025e-01f, 2.25439355e-01f, 7.81573877e-02f, 3.75256121e-01f, 3.57148141e-01f, 3.06683108e-02f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -2.60417491e-01f, -3.70735526e-01f, -3.95584762e-01f, 5.68559170e-01f, -1.10667646e-01f, -6.14993513e-01f, -4.87176746e-01f, -3.25889260e-01f, 4.15591240e-01f, -5.90215206e-01f,
  3.88249725e-01f, -3.05325359e-01f, -4.65472728e-01f, -3.70536596e-01f, 3.12248826e-01f, -1.55762911e-01f, -7.30071604e-01f, 6.51969016e-02f, -3.91985327e-01f, -6.19215310e-01f,
  4.78377730e-01f, -2.77962625e-01f, 4.26663935e-01f, 6.87109947e-01f, -8.75483036e-01f, -7.11361468e-02f, -3.33126396e-01f, 3.76324803e-01f, -7.44382024e-01f, -7.12998092e-01f,
  -6.52964264e-02f, -2.81608105e-01f, -4.70484644e-01f, -2.58202344e-01f, -1.66824788e-01f, 2.93945909e-01f, 4.01078314e-01f, -3.60136569e-01f, -7.02373162e-02f, 4.54209626e-01f,
  5.12781918e-01f, 2.41168946e-01f, 4.24758375e-01f, -2.91241586e-01f, -1.11771710e-01f, -2.24029869e-01f, -6.88965082e-01f, 3.25232059e-01f, 2.25848347e-01f, 1.37241602e-01f,
  6.57124519e-01f, -5.63856624e-02f, 9.45332348e-02f, 1.04898609e-01f, -1.43825009e-01f, 3.55231911e-01f, -5.14848158e-02f, -7.97453463e-01f, 4.75257337e-01f, -6.27434030e-02f,
  -1.88326851e-01f, -1.42988071e-01f, 5.38962066e-01f, 2.47857317e-01f, 3.25995535e-01f, 1.70625731e-01f, -8.09475780e-02f, 4.70887154e-01f, -1.66719198e-01f, -3.62714350e-01f,
  3.09667856e-01f, 3.15730870e-01f, 1.83035135e-01f, 1.30904973e-01f, 3.58663470e-01f, 3.52067798e-01f, -1.82695955e-01f, 5.20135880e-01f, -4.17126119e-01f, -7.36580938e-02f,
  -2.27516368e-01f, -4.33105022e-01f, -4.92851168e-01f, -2.38840938e-01f, -4.99138087e-01f, -6.80795133e-01f, -2.71772057e-01f, 2.58704096e-01f, 6.24082327e-01f, -6.44293189e-01f,
  -5.36663115e-01f, 1.55179054e-01f, -5.58373481e-02f, -5.49786128e-02f, -3.80411297e-01f, -7.51798511e-01f, -4.11922902e-01f, 2.43230224e-01f, -1.18694820e-01f, -1.59246132e-01f,
  3.83369513e-02f, 4.18746769e-01f, -3.63647968e-01f, 5.68452105e-02f, -7.78872728e-01f, 6.80126131e-01f, 2.87242562e-01f, 2.54542232e-01f, -4.23047632e-01f, -4.12784696e-01f,
  4.07734931e-01f, -6.71620250e-01f, 8.62873793e-01f, -4.09872860e-01f, 2.09470719e-01f, -1.26897339e-02f, -6.74286708e-02f, -2.99477249e-01f, -2.67734915e-01f, 4.15633135e-02f,
  -8.07529449e-01f, -2.00345233e-01f, -7.34443545e-01f, 2.99916536e-01f, 5.37679374e-01f, -2.38709658e-01f, -7.45431244e-01f, -3.98958534e-01f, 4.25319284e-01f, -2.48672411e-01f,
  6.95129335e-01f, -3.07440937e-01f, -3.93480778e-01f, 6.48099303e-01f, 3.61408204e-01f, -2.21163690e-01f, -2.67731994e-01f, -4.22201246e-01f, -7.92493403e-01f, -1.07270241e-01f,
  5.23637772e-01f, 5.67631662e-01f, 5.74412085e-02f, 3.09182554e-01f, -2.65144229e-01f, -4.21762079e-01f, -3.53566647e-01f, 6.11942351e-01f, 5.74681401e-01f, -1.55758530e-01f,
  -6.14320636e-01f, 9.21552405e-02f, -1.99978679e-01f, -1.75818309e-01f, 1.27404913e-01f, 3.16553712e-01f, -3.22000593e-01f, -1.75336510e-01f, -5.79787254e-01f, 4.28950608e-01f,
  2.99496561e-01f, -8.12478587e-02f, 1.71021208e-01f, -6.56988204e-01f, 1.08287349e-01f, -6.22218587e-02f, -4.93985027e-01f, 9.12633985e-02f, 9.24345255e-02f, 4.28872257e-01f,
  -4.13235843e-01f, 3.63593310e-01f, 6.35535061e-01f, 3.13366055e-01f, 2.85933822e-01f, -5.48743531e-02f, 7.04357401e-02f, 7.60211051e-01f, -7.06876993e-01f, -4.39117491e-01f,
  -5.74946702e-01f, 4.54999387e-01f, 2.08811074e-01f, -4.66560781e-01f, 1.54366955e-01f, -2.38982633e-01f, -3.17738473e-01f, -4.60614115e-02f, 1.06211312e-01f, 2.24528402e-01f,
  -2.99754944e-02f, 2.47605041e-01f, -4.41674203e-01f, -4.03573290e-02f, -1.99126340e-02f, 1.10116355e-01f, 9.95757990e-03f, -4.36583251e-01f, -6.95875943e-01f, -9.33291242e-02f,
  -5.82842290e-01f, 3.86235356e-01f, -5.73520899e-01f, -2.33011171e-01f, 1.76600993e-01f, 6.10780120e-01f, -3.94508034e-01f, 3.44758898e-01f, 7.19173074e-01f, 4.70070601e-01f,
  1.08133055e-01f, 2.57936865e-01f, 4.79181349e-01f, 1.97026536e-01f, 6.51870787e-01f, -2.58521158e-02f, -1.08657315e-01f, 1.04405567e-01f, 4.05439764e-01f, -4.82709557e-01f,
  -8.34749222e-01f, 4.23352659e-01f, 2.75112003e-01f, -6.69810295e-01f, -4.23847958e-02f, -1.04413167e-01f, 2.52746880e-01f, 2.20961832e-02f, -1.73937440e-01f, 1.87451318e-02f,
  3.82132292e-01f, 1.19361617e-02f, 5.70831478e-01f, -3.01909000e-01f, 6.78056479e-03f, -1.92687020e-01f, -1.27137629e-02f, 2.82857180e-01f, -1.08348086e-01f, -4.22853440e-01f,
  -5.33221841e-01f, 1.24952659e-01f, -2.68838018e-01f, 5.62974274e-01f, 2.00012714e-01f, 1.75138172e-02f, 2.00789392e-01f, -2.07143873e-01f, -4.66628224e-01f, 5.58224499e-01f,
  8.47525429e-03f, -3.50046486e-01f, 3.75785679e-01f, -7.20262170e-01f, 3.80819231e-01f, -4.00703698e-01f, -6.34508610e-01f, 2.30761319e-01f, 3.37842256e-01f, 3.30933422e-01f,
  3.45369130e-01f, -5.46790808e-02f, 1.16807753e-02f, -8.02013636e-01f, 3.79372656e-01f, -8.20816696e-01f, -3.99772197e-01f, -2.96786040e-01f, -3.10579568e-01f, 4.91489857e-01f,
  2.29976892e-01f, -5.56030869e-01f, 2.64801234e-01f, 5.78546152e-02f, 3.45004022e-01f, 3.35808843e-01f, 8.17055330e-02f, 5.37382662e-02f, 1.92774683e-01f, -2.45807260e-01f,
  4.81638938e-01f, 1.81488954e-02f, -2.76685394e-02f, -1.02932000e+00f, 1.35065004e-01f, 1.09703600e-01f, 9.69123282e-03f, 1.65913284e-01f, 3.79905969e-01f, -1.44773424e-01f,
  -1.40958205e-01f, -5.16379997e-02f, 1.84756860e-01f, 1.80570021e-01f, 4.50206697e-01f, -9.69656482e-02f, -4.25438643e-01f, 2.20371008e-01f, 1.09187871e-01f, 2.30943486e-01f,
  2.13478103e-01f, -3.46447289e-01f, -1.23955324e-01f, 1.21907614e-01f, -6.66606069e-01f, -5.78065872e-01f, 3.59637409e-01f, 7.16591030e-02f, -2.34266400e-01f, 4.57103312e-01f,
  -3.25140655e-01f, -1.81357592e-01f, 4.23685133e-01f, 3.43609840e-01f, 2.73081362e-01f, -6.43315792e-01f, -2.18074068e-01f, 4.44246531e-01f, -7.58646846e-01f, -6.86253905e-01f,
  -3.68261844e-01f, 1.93605974e-01f, -7.61760354e-01f, -2.76663363e-01f, -1.17957219e-01f, -2.64447898e-01f, -1.95964158e-01f, -5.29245138e-02f, -3.99987668e-01f, -6.25563502e-01f,
  5.64937480e-02f, 9.11317915e-02f, -2.03808680e-01f, -6.63687289e-01f, -4.52509746e-02f, 2.26900578e-01f, 1.24653310e-01f, -3.76850456e-01f, 2.82134950e-01f, 3.99254322e-01f,
  2.28620172e-02f, 7.93148652e-02f, 3.53521317e-01f, 4.94451582e-01f, 2.27237374e-01f, -2.09687874e-01f, -6.95861399e-01f, -2.08508387e-01f, 6.27421856e-01f, -1.04113328e+00f,
  -1.78942427e-01f, 3.46994907e-01f, 7.87621513e-02f, -5.14749922e-02f, 2.14456782e-01f, -1.35421276e-01f, -2.09945794e-02f, 5.42755365e-01f, 4.95163500e-01f, 1.35833412e-01f,
  -4.01318818e-01f, -3.44500780e-01f, 4.26636279e-01f, 1.30045712e-01f, -1.98629051e-01f, -8.88050497e-01f, 7.76141942e-01f, 5.02282083e-01f, 7.06225753e-01f, -6.71005905e-01f,
  3.31138372e-01f, -3.50518554e-01f, -5.30761778e-01f, -6.79731607e-01f, 3.68391931e-01f, -5.14290631e-02f, -6.57236874e-01f, 3.61056536e-01f, -6.41238317e-02f, -1.17389217e-01f,
  -9.81124878e-01f, 2.06914186e-01f, 2.83333570e-01f, 5.78108132e-02f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  2.33236983e-01f, 1.62548050e-01f, 2.54351526e-01f, -5.65889440e-02f, -1.07322797e-01f, 2.39273589e-02f, 3.43108177e-02f, -8.40374529e-02f, -2.25355044e-01f, -9.42401811e-02f,
  -2.77147442e-01f, -5.07036746e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    