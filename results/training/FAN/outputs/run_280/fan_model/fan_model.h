/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -5.05320251e-01f, 1.48044631e-01f, -1.30896391e-02f, -6.95773289e-02f, 1.70109067e-02f, 1.97211400e-01f, -1.52339432e-02f, 5.81616275e-02f, -9.73917842e-02f, 5.98667376e-02f,
  -7.65836611e-02f, -7.04341382e-02f, -1.29109323e-01f, 7.05497935e-02f, -2.90934257e-02f, 4.70224991e-02f, -9.37679186e-02f, -7.81374127e-02f, -3.84564772e-02f, -1.96982861e-01f,
  -7.25710988e-02f, 1.85022503e-02f, -1.11254737e-01f, 1.70085970e-02f, -4.33848500e-02f, -2.34431606e-02f, -2.02286653e-02f, -2.98722405e-02f, 6.31394908e-02f, 1.10531405e-01f,
  -3.35762464e-02f, -2.76898537e-02f, 2.07686741e-02f, -6.08774312e-02f, -1.14966379e-02f, -5.48553132e-02f, -8.06942657e-02f, 3.91669758e-02f, -7.47109130e-02f, 2.97873467e-02f,
  -1.23543896e-01f, 8.20322484e-02f, 6.19469658e-02f, 2.47510597e-02f, -3.59595940e-02f, 8.10573250e-02f, -4.99429787e-03f, 4.30436805e-03f, 7.38752782e-02f, 5.81444614e-03f,
  2.21612398e-02f, 4.25093099e-02f, 4.73110974e-02f, 7.40446150e-02f, 3.87709890e-03f, -3.58024500e-02f, 2.17140596e-02f, -1.68150645e-02f, 4.16465588e-02f, 5.74714579e-02f,
  -3.79523002e-02f, -1.05035871e-01f, 3.09709813e-02f, 1.67764339e-03f, 4.47535105e-02f, -1.23444125e-02f, -8.77458695e-03f, -2.69231573e-02f, 2.21012160e-02f, -9.53031778e-02f,
  -1.52870882e-02f, -1.32523375e-02f, -1.34969251e-02f, 3.75805199e-02f, -9.47813597e-03f, 6.83990633e-03f, -1.04735844e-01f, 5.76041127e-03f, -2.87907943e-03f, 3.39065716e-02f,
  -1.99962364e-04f, -6.54726401e-02f, 3.18888389e-02f, 5.53542525e-02f, 2.34208256e-03f, -9.15093943e-02f, 7.22336993e-02f, 7.54245445e-02f, -5.70912994e-02f, -9.89426114e-03f,
  2.17600733e-01f, -3.33254561e-02f, 1.35775069e-02f, 4.63453978e-02f, 2.77429167e-02f, -4.91196550e-02f, -2.91253589e-02f, 1.37876987e-03f, -5.53408340e-02f, -2.18072217e-02f,
  4.63997573e-02f, -2.67563742e-02f, 5.53998747e-04f, -6.37608394e-02f, 5.16484817e-03f, -4.77442928e-02f, -3.78901884e-02f, 5.43821156e-02f, -6.14455752e-02f, -3.83543335e-02f,
  -6.61434904e-02f, 2.64642965e-02f, -1.53718106e-02f, -1.17419637e-03f, -3.05302832e-02f, -1.17738442e-02f, -2.51522847e-02f, 5.17764501e-02f, -1.04098478e-02f, 1.90987103e-02f,
  6.69623911e-02f, -1.41538262e-01f, -4.61903065e-02f, -1.03550114e-01f, 1.76655762e-02f, -5.86278960e-02f, -1.03405111e-01f, -7.26780966e-02f, 1.80856973e-01f, -2.34388690e-02f,
  -1.35028392e-01f, 7.30128363e-02f, -6.48031831e-02f, -8.85925740e-02f, -1.45382166e-01f, 1.26605332e-01f, -2.16760755e-01f, -2.11619493e-02f, 2.19059020e-01f, -2.22099826e-01f,
  -7.35912938e-03f, -2.07996130e-01f, -1.65594861e-01f, 1.86745115e-02f, -1.18485026e-01f, 2.12808214e-02f, -1.41500264e-01f, 6.90742359e-02f, -1.61705926e-01f, -6.55677868e-03f,
  6.45399392e-02f, 8.76412541e-02f, -2.08720714e-02f, 6.08741194e-02f, -1.06564142e-01f, 7.78385391e-03f, -2.13256199e-02f, -4.36726958e-02f, 1.57805681e-02f, -5.08363806e-02f,
  -1.67610366e-02f, -3.75847369e-02f, 5.80564551e-02f, -3.25322933e-02f, -4.86347526e-02f, 7.66181722e-02f, 1.78371463e-02f, 3.62060219e-02f, -1.49009721e-02f, -4.35639881e-02f,
  -5.80042191e-02f, -3.80061269e-02f, -1.10282805e-02f, 2.28110868e-02f, -6.83616698e-02f, -9.60601643e-02f, -2.05129329e-02f, -1.94028448e-02f, 7.42970183e-02f, 3.51416878e-02f,
  -5.04420958e-02f, -4.71555209e-03f, -3.08312401e-02f, 6.32673427e-02f, -4.27524112e-02f, 2.15671528e-02f, 4.14891988e-02f, 2.05011144e-02f, 8.04435983e-02f, -1.72974542e-02f,
  4.44097854e-02f, -4.39530313e-02f, 8.00446123e-02f, -4.67404462e-02f, -7.32352212e-02f, 6.15045615e-02f, -4.22392040e-02f, 3.90831195e-02f, 3.82668078e-02f, -5.00329165e-03f,
  -2.22916957e-02f, -4.74065047e-04f, -2.46019606e-02f, 7.06829280e-02f, 2.46028565e-02f, -1.99143477e-02f, -3.84961888e-02f, 1.84569787e-02f, -7.75363576e-03f, -1.61782019e-02f,
  -1.97616130e-01f, -2.19461769e-01f, 5.60450517e-02f, -3.39461043e-02f, 7.14012831e-02f, -1.23320445e-02f, 6.61833659e-02f, 2.58816127e-02f, -2.38704532e-02f, 1.66679360e-02f,
  -6.35280460e-02f, -4.13918821e-03f, 3.55844013e-02f, -2.78331004e-02f, 4.04993445e-02f, -1.14402145e-01f, -1.04620554e-01f, -1.52480705e-02f, -3.31199877e-02f, -4.39708907e-04f,
  -1.29302889e-02f, -1.72132987e-03f, -1.74857154e-02f, -4.77870144e-02f, 3.19832494e-03f, 2.95055322e-02f, 9.92331281e-03f, -8.51533655e-03f, 3.37176770e-02f, 5.62878624e-02f,
  -3.41230720e-01f, 5.79358302e-02f, -8.31397995e-02f, -1.67865023e-01f, 1.08784838e-02f, 2.95806438e-01f, -1.90224703e-02f, -3.85485888e-02f, -1.18499957e-01f, 9.12113041e-02f,
  4.54440340e-02f, 5.07964790e-02f, 1.03158444e-01f, 4.67917853e-04f, -1.67676941e-01f, 4.91753183e-02f, 8.32367502e-03f, 5.62463179e-02f, -1.45469345e-02f, 8.66098776e-02f,
  -9.92266312e-02f, 1.02867827e-01f, -5.30674234e-02f, 1.03313230e-01f, -3.78683917e-02f, -1.04172438e-01f, -8.21946487e-02f, 1.01959243e-01f, 9.75868255e-02f, -1.17314821e-02f,
  -8.62238277e-03f, 1.67780053e-02f, -4.65029180e-02f, 7.67991915e-02f, -1.84591617e-02f, 2.02660933e-02f, 4.13308479e-02f, -4.27553877e-02f, 1.77334805e-04f, -3.18179466e-02f,
  5.42393103e-02f, -1.35649731e-02f, 3.05024311e-02f, 7.37709403e-02f, -9.43480001e-04f, -8.39528367e-02f, -4.86238487e-02f, -6.93329573e-02f, -6.13856390e-02f, 3.53447087e-02f,
  -6.60882369e-02f, 1.32373879e-02f, -8.31545144e-02f, -2.56345011e-02f, 6.83627324e-03f, -2.00949274e-02f, 1.16505280e-01f, 4.31813300e-02f, -3.01627116e-03f, -5.69736026e-02f,
  -1.30606536e-02f, 1.28851803e-02f, -1.85882337e-02f, 9.28762089e-03f, -5.77030517e-02f, 6.96214736e-02f, 2.87477057e-02f, 1.95424501e-02f, -2.04161257e-02f, 3.56477760e-02f,
  2.28480007e-02f, 2.73508020e-02f, 3.81231424e-04f, -2.34937668e-02f, -5.48728881e-03f, -3.25248688e-02f, -3.45044881e-02f, -6.43366799e-02f, -4.64913286e-02f, 4.03695181e-02f,
  1.18594822e-02f, 2.75416970e-02f, -3.96906361e-02f, -1.41096851e-02f, 6.63222671e-02f, 4.04472873e-02f, 1.29074072e-02f, -9.35986787e-02f, 4.30276291e-03f, 1.75341610e-02f,
  5.08439615e-02f, 5.79380170e-02f, 6.18947111e-03f, -5.01161162e-03f, -5.80352806e-02f, -3.97603810e-02f, -1.62044130e-02f, -1.76171847e-02f, -4.66537997e-02f, 1.33213595e-01f,
  -4.77472655e-02f, 3.23629268e-02f, 2.76461523e-02f, 2.43131332e-02f, -1.84421390e-02f, 4.31680046e-02f, 5.25816642e-02f, 1.72734074e-02f, 4.44131112e-03f, 6.06665947e-02f,
  2.78654024e-02f, 8.10669139e-02f, -1.65474601e-02f, -5.37174940e-03f, 2.93101687e-02f, 2.20825449e-02f, 3.42853670e-03f, -7.57077187e-02f, 3.05326451e-02f, -5.64716235e-02f,
  -5.43733060e-01f, -6.49890229e-02f, 2.22629666e-01f, -2.41749972e-01f, -1.00070998e-01f, 2.21799582e-01f, -1.02098770e-02f, -8.84599164e-02f, -1.86090216e-01f, -6.71280548e-02f,
  2.54177693e-02f, -4.85109910e-03f, 1.06816731e-01f, -3.69469933e-02f, 1.76351145e-01f, 1.64791137e-01f, -4.65194173e-02f, -7.92541429e-02f, -1.03272106e-02f, -1.68968931e-01f,
  1.56896096e-02f, -4.36286032e-02f, 1.28975466e-01f, 2.21832679e-03f, -7.67592415e-02f, -1.13523742e-02f, 1.21033266e-01f, 1.64373383e-01f, -3.43852192e-02f, 4.31008264e-02f,
  1.05003737e-01f, -2.45980754e-01f, 9.90856737e-02f, 2.06621885e-02f, 1.06300842e-02f, -3.23448032e-02f, 7.12935701e-02f, 5.25423214e-02f, -6.54519210e-03f, -5.43188397e-03f,
  2.07223278e-02f, 1.57341920e-02f, -8.05968866e-02f, -4.07264978e-02f, -6.29276782e-02f, -1.06088696e-02f, 8.27551037e-02f, 3.04823816e-02f, 2.66013835e-02f, 7.15403035e-02f,
  1.26865819e-01f, 1.09133892e-01f, 4.87320572e-02f, -1.34498039e-02f, 1.90372467e-02f, 4.32242863e-02f, 5.10425307e-02f, 1.40901012e-02f, 8.51436853e-02f, -3.63692977e-02f,
  -8.95711686e-03f, -1.77040100e-02f, 4.57992852e-02f, -1.54157188e-02f, 3.89149711e-02f, -5.77003099e-02f, 2.63898093e-02f, 3.08690444e-02f, -1.40641804e-03f, -2.60721184e-02f,
  -1.65474694e-02f, -1.84601638e-02f, -1.18689276e-02f, -6.84475228e-02f, -4.18815799e-02f, -5.31600937e-02f, 2.34393142e-02f, 1.10830273e-02f, 3.13196294e-02f, -1.09179514e-02f,
  -5.12165464e-02f, 1.95900705e-02f, 2.98596174e-03f, 1.04468027e-02f, 9.32369498e-04f, 2.23276764e-02f, 2.08852310e-02f, -8.70667957e-03f, -4.48294915e-02f, 5.23424111e-02f,
  -1.50709569e-01f, -1.70748934e-01f, -5.64412773e-02f, -5.64454645e-02f, 5.86605817e-02f, 7.08161965e-02f, -5.50910048e-02f, -2.16614921e-03f, -3.68967429e-02f, -4.79475223e-02f,
  -2.43307110e-02f, -3.34608071e-02f, 3.94862145e-03f, -3.02314609e-02f, 5.34156412e-02f, 3.97127494e-02f, -1.23493699e-02f, -2.15262007e-02f, -4.84753884e-02f, -3.92872058e-02f,
  -3.49442810e-02f, -4.55032401e-02f, -3.13658491e-02f, -3.38271558e-02f, -1.81307469e-03f, -2.46073846e-02f, -7.56916329e-02f, -1.58963539e-03f, 3.66769102e-03f, -4.26652841e-03f,
  -4.69671428e-01f, -6.89773038e-02f, -2.37053484e-01f, -2.28151575e-01f, 5.06076366e-02f, -3.84025536e-02f, -7.98152983e-02f, 8.01514927e-03f, -2.05761746e-01f, 6.95446059e-02f,
  2.03977570e-01f, -3.24852616e-01f, 1.79452941e-01f, -6.54151216e-02f, 1.63928449e-01f, 1.07463188e-02f, -6.22740611e-02f, -1.33824900e-01f, -7.39612132e-02f, -1.25673795e-02f,
  5.40282868e-04f, 8.48436654e-02f, -1.12111546e-01f, 9.58256125e-02f, -1.33484498e-01f, -5.42594679e-02f, 1.12540290e-01f, 9.57170799e-02f, 5.94150946e-02f, -6.60873810e-03f,
  2.63540894e-02f, -1.85861823e-03f, -5.26858084e-02f, 6.10600971e-02f, -9.40481853e-03f, 2.28257645e-02f, 1.72734633e-02f, 1.82677936e-02f, -6.68024924e-03f, -5.54957576e-02f,
  3.55587862e-02f, 1.50527405e-02f, -4.30159010e-02f, -5.26516661e-02f, -1.67551544e-02f, -3.50771286e-02f, -9.09734741e-02f, -5.19384965e-02f, -4.01758291e-02f, -9.01703537e-02f,
  -4.81971242e-02f, -4.90544178e-02f, 1.22997481e-02f, 5.13577759e-02f, 9.17093270e-03f, 1.23686185e-02f, -6.37918189e-02f, 4.93089035e-02f, -6.49570441e-03f, -3.88603322e-02f,
  -7.15500563e-02f, -1.39398221e-03f, -2.48697381e-02f, 4.13844585e-02f, 5.41297682e-02f, 3.31389904e-02f, -3.86926457e-02f, 5.82037866e-02f, -1.44589012e-02f, 2.98033804e-02f,
  1.06950793e-02f, -1.74491759e-02f, -6.90483395e-03f, 2.28113704e-03f, -4.69468385e-02f, 8.25605355e-03f, 2.09095292e-02f, 6.78442866e-02f, -3.75565402e-02f, -1.24973580e-02f,
  3.23887877e-02f, 8.27572048e-02f, -3.31214443e-02f, -3.30935568e-02f, 6.27662987e-02f, 2.80637052e-02f, -1.71357822e-02f, -4.35203016e-02f, -1.19413613e-04f, 5.08819036e-02f,
  2.77274907e-01f, 1.28474817e-01f, 3.97853069e-02f, -2.86560535e-04f, 1.16204738e-03f, 8.50949436e-03f, -1.15322005e-02f, -2.34388281e-02f, 5.62372580e-02f, 5.24272583e-02f,
  -4.21417095e-02f, 4.90155928e-02f, -1.80126783e-02f, 3.84208187e-02f, 4.22642604e-02f, -9.70299169e-03f, 3.63519825e-02f, -4.90339799e-03f, 1.16960490e-02f, 1.82329316e-03f,
  3.44370566e-02f, -1.94457825e-02f, 5.00888750e-03f, -4.24188152e-02f, 1.05850594e-02f, -6.00801483e-02f, 7.37614604e-03f, -6.93180785e-02f, -1.12278881e-02f, 3.61618996e-02f,
  1.46830007e-01f, -6.05397709e-02f, -3.10051501e-01f, 1.65062010e-01f, 8.26826394e-02f, 1.40686825e-01f, 3.11348103e-02f, -4.30997610e-02f, -1.57333329e-01f, 1.14800602e-01f,
  3.06612533e-03f, -5.73287383e-02f, -1.76512077e-01f, 1.66709617e-01f, 1.09832026e-01f, -1.62493020e-01f, 2.08489150e-01f, 6.58562928e-02f, -1.03968522e-02f, 5.66195920e-02f,
  -6.76311627e-02f, 2.42529839e-01f, -1.44975424e-01f, -4.63714032e-03f, 7.34924600e-02f, 2.76981443e-02f, 1.40462548e-01f, -6.80637062e-02f, 3.75709049e-02f, -2.49306224e-02f,
  -1.12242237e-01f, -1.18004419e-01f, -1.83360316e-02f, -7.96001628e-02f, 1.31754559e-02f, 5.21758832e-02f, 5.30086234e-02f, 5.96983358e-02f, -1.35149792e-01f, -5.18740118e-02f,
  -3.62119079e-03f, -5.89856803e-02f, 6.04024492e-02f, -3.74217816e-02f, 2.97875442e-02f, 5.52964769e-03f, 1.66850351e-02f, 3.12743103e-03f, -1.07673490e-02f, -1.24746948e-01f,
  -7.18103871e-02f, 5.64204641e-02f, 4.24142182e-02f, 7.88040012e-02f, -9.53664631e-02f, -5.40069342e-02f, 3.41538079e-02f, -1.65931117e-02f, 1.42205521e-01f, -7.33972201e-03f,
  1.02926888e-01f, -2.85110865e-02f, 1.35579919e-02f, 5.46314567e-03f, 1.84311643e-02f, 1.43208411e-02f, 6.62257746e-02f, 5.07785939e-02f, 1.31071350e-02f, -1.94059238e-02f,
  4.48743328e-02f, -5.15818000e-02f, -9.82560776e-03f, 3.39663122e-03f, 8.57381523e-02f, 1.65707897e-02f, -4.64849919e-02f, 1.80928633e-02f, -7.43186474e-02f, 4.13200213e-03f,
  -2.87468452e-02f, 5.30216657e-02f, -2.55149379e-02f, 4.25163545e-02f, -7.98682403e-03f, -7.41791651e-02f, 2.05271430e-02f, -5.50864860e-02f, 1.12042511e-02f, 4.70778309e-02f,
  7.84668997e-02f, 3.21356505e-02f, 1.42636094e-02f, -3.24110426e-02f, -2.09034383e-02f, 1.73756294e-02f, 8.71900097e-03f, 1.34630045e-02f, 5.66668175e-02f, 4.49589454e-02f,
  3.05366050e-02f, 9.29002240e-02f, 4.27761525e-02f, 3.29988636e-02f, -1.88352715e-03f, -2.55018696e-02f, 6.16236888e-02f, 9.26353317e-03f, 5.40104182e-03f, 4.03296798e-02f,
  4.29661684e-02f, 8.12134892e-03f, 5.88519052e-02f, 4.61832397e-02f, 1.40883863e-01f, 3.81511226e-02f, 5.57553880e-02f, -5.25785703e-03f, 3.85518372e-02f, -1.25480760e-02f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  8.04627873e-03f, -3.56123656e-01f, 6.83674812e-02f, -1.57854453e-01f, 2.08016112e-01f, 2.50470728e-01f, 1.70297533e-01f, -1.64398983e-01f, -2.43697077e-01f, -3.09249282e-01f,
  -1.04930691e-01f, -3.53043117e-02f, -3.98988351e-02f, -1.05657227e-01f, 2.18507469e-01f, -7.37336427e-02f, -7.82768894e-03f, -7.99887106e-02f, 6.45870343e-02f, -1.30747957e-02f,
  -4.99527827e-02f, 7.35164434e-02f, 1.36738122e-01f, -9.87996683e-02f, 9.13388878e-02f, 5.43604232e-02f, -4.23248857e-02f, 9.35698599e-02f, 8.99605919e-03f, 1.05068304e-01f,
  5.03455400e-02f, -1.19578920e-01f, -4.24354784e-02f, -1.07020445e-01f, -3.50397415e-02f, -6.30514622e-02f, 5.75154349e-02f, 4.45748940e-02f, 5.53933941e-02f, 3.79335531e-03f,
  2.70998832e-02f, -3.13768722e-02f, -7.26378057e-03f, 7.15527683e-02f, -1.01690199e-02f, -1.71431024e-02f, 3.72718461e-03f, 1.57411788e-02f, 1.25590879e-02f, 3.70603390e-02f,
  -1.62772033e-02f, -3.80890928e-02f, 5.12641370e-02f, -3.62601168e-02f, -1.36253727e-03f, 3.99587676e-02f, 1.70253050e-02f, -1.94878485e-02f, 4.21729572e-02f, -6.82124868e-02f,
  1.87311023e-02f, 2.86048511e-03f, -8.34638905e-03f, -3.53325903e-02f, -9.55043063e-02f, 4.68107918e-03f, -3.94703001e-02f, -3.18657234e-02f, -4.85424660e-02f, 2.46983208e-03f,
  -8.14637821e-03f, -4.63187322e-03f, 6.62991405e-03f, 3.23145501e-02f, 5.23060672e-02f, 4.25322130e-02f, 3.86265712e-03f, -4.71558943e-02f, 4.20561200e-03f, 7.88370371e-02f,
  3.11241597e-02f, 7.42719276e-03f, 6.87805861e-02f, 1.11959511e-02f, -5.50112594e-03f, 1.69154238e-02f, 7.05269678e-03f, -2.04960443e-02f, 7.17227384e-02f, -2.03596018e-02f,
  -2.92165250e-01f, -2.17191637e-01f, 3.04788444e-02f, -6.14780486e-02f, -3.79317664e-02f, 3.46337296e-02f, -5.59779853e-02f, 2.97031496e-02f, 1.20345391e-02f, -2.71013994e-02f,
  2.04728898e-02f, -4.69433982e-03f, -3.82937049e-03f, 4.21853475e-02f, 3.97824273e-02f, -4.04789448e-02f, 2.95867231e-02f, -3.77244204e-02f, -6.14116266e-02f, -5.74951768e-02f,
  -5.01920730e-02f, -5.11900261e-02f, 3.44018526e-02f, -1.39447013e-02f, -4.79028635e-02f, -3.10415961e-02f, -3.72309648e-02f, -6.42314181e-03f, -4.87696715e-02f, 5.34827262e-02f,
  -1.02201954e-01f, -4.95353267e-02f, -2.09438026e-01f, -9.61446464e-02f, -1.27865355e-02f, -4.58260506e-01f, -2.75465339e-01f, -1.31678358e-01f, -1.28779799e-01f, 6.31234795e-02f,
  -2.10727286e-02f, -4.96744625e-02f, 1.62003040e-01f, -4.88524705e-01f, -4.39172596e-01f, -1.49415955e-01f, -4.10066396e-01f, -1.41830355e-01f, 1.87170003e-02f, -1.68653962e-03f,
  -7.98499212e-02f, -1.76569298e-01f, -1.88843146e-01f, 9.69136879e-02f, -1.04143023e-01f, 1.54689908e-01f, 3.39762509e-01f, 2.19593391e-01f, -5.34041319e-03f, -1.06971100e-01f,
  -2.19386891e-01f, -1.17542326e-01f, -6.05807081e-02f, -4.86565419e-02f, -1.77141130e-02f, 2.79701054e-02f, 4.85664047e-02f, -4.22405005e-02f, -5.93558000e-03f, -1.42460270e-02f,
  -1.03006950e-02f, 4.76349965e-02f, -7.56594315e-02f, -1.59677342e-02f, -3.03993244e-02f, 1.41223567e-02f, -3.92070301e-02f, 7.00954581e-03f, -4.46621254e-02f, -4.72212732e-02f,
  -7.00213984e-02f, -8.77262503e-02f, 4.96064462e-02f, 1.21569121e-02f, 3.20047629e-03f, -1.82743985e-02f, -2.61834310e-03f, -1.44189112e-02f, 2.08303556e-02f, -3.56489569e-02f,
  4.07320298e-02f, 6.44129366e-02f, -1.54046202e-02f, 1.00865699e-02f, 3.37044634e-02f, 4.11542831e-03f, -1.75383817e-02f, 1.01309922e-02f, 2.66939048e-02f, 3.93584780e-02f,
  -5.92957623e-02f, 9.22895968e-03f, -1.78233441e-02f, 7.61099998e-03f, -2.68897247e-02f, -2.56155357e-02f, 2.56660972e-02f, -3.28296376e-03f, -5.63604608e-02f, -5.23396470e-02f,
  1.33435968e-02f, -9.64781269e-03f, 1.34193124e-02f, 3.50105502e-02f, -2.17483994e-02f, -2.26836875e-02f, 5.99241480e-02f, -2.65330561e-02f, 2.15995777e-02f, 4.55097556e-02f,
  -1.09386398e-02f, 2.21645847e-01f, -2.70843338e-02f, 1.34454458e-03f, -4.35697995e-02f, -8.37208331e-02f, -9.23900530e-02f, -5.92536144e-02f, 4.41672690e-02f, -3.83585058e-02f,
  1.40362069e-01f, -1.86673049e-02f, 2.16155536e-02f, 1.44486707e-02f, -9.62829310e-03f, -6.34516682e-03f, 7.36624449e-02f, 4.19289358e-02f, 3.78039440e-05f, 7.99548179e-02f,
  9.81236547e-02f, 8.41334388e-02f, -7.26133026e-03f, -7.37216149e-04f, 1.35440957e-02f, 1.15567800e-02f, 5.24126254e-02f, 6.01541512e-02f, -5.84223028e-03f, -2.93652751e-02f,
  3.47275846e-02f, -1.55990878e-02f, 8.56224522e-02f, 1.53624654e-01f, 1.68454107e-02f, -1.09491661e-01f, -2.04548258e-02f, 1.21627443e-01f, 7.22269788e-02f, -5.03773838e-02f,
  1.45129576e-01f, 5.13529032e-02f, -3.50441672e-02f, 5.21666929e-02f, 2.27225229e-01f, -3.49079631e-02f, 2.95494050e-02f, 2.93773971e-02f, 7.87946284e-02f, 1.33381367e-01f,
  6.79754093e-02f, 1.36516482e-01f, 2.74235696e-01f, 1.43746376e-01f, 1.76256627e-01f, 1.57280684e-01f, 1.81326002e-01f, 1.18001662e-01f, 1.30441725e-01f, 7.03995600e-02f,
  -5.88840283e-02f, -2.26097479e-02f, 3.25581320e-02f, -3.72223482e-02f, 3.87857631e-02f, 1.19433627e-02f, -1.22493081e-01f, 1.42831327e-02f, -7.79847195e-03f, 3.83084863e-02f,
  -9.46112126e-02f, -3.93917598e-02f, 1.10522389e-01f, 5.10355458e-02f, -9.47688892e-02f, 5.01664132e-02f, 9.17462036e-02f, 1.42771369e-02f, 4.15005349e-02f, -5.99849708e-02f,
  7.26368686e-04f, 7.42606223e-02f, -2.47990228e-02f, 5.48856109e-02f, 4.11080085e-02f, -1.10838249e-01f, 7.05023184e-02f, 6.03508092e-02f, 1.47565585e-02f, 5.27953804e-02f,
  -6.07309751e-02f, -4.69029844e-02f, 8.89558494e-02f, 2.79472899e-02f, 8.47506151e-02f, -5.08615226e-02f, -2.74598915e-02f, 6.12335131e-02f, 7.23344535e-02f, -3.34258005e-02f,
  6.28687218e-02f, 4.21987195e-03f, 7.03029633e-02f, -1.78695675e-02f, -5.02934586e-03f, -9.32413489e-02f, -7.29242638e-02f, 7.88601562e-02f, -2.69898660e-02f, -1.58864036e-02f,
  -6.19826987e-02f, -2.55574402e-03f, -2.53733899e-02f, 6.81922063e-02f, -1.03020683e-01f, 2.89823692e-02f, 6.90434501e-02f, 4.93026190e-02f, -2.67819432e-03f, -3.34798470e-02f,
  -4.62732874e-02f, 5.64460456e-02f, 6.83032814e-03f, 6.83487952e-03f, -4.34677415e-02f, -7.24340826e-02f, 4.67613563e-02f, 4.78146523e-02f, 2.43650209e-02f, 1.27032883e-02f,
  -5.41812107e-02f, -1.63398462e-03f, -5.07113673e-02f, 6.44931346e-02f, 6.76430985e-02f, -4.43392396e-02f, 5.06768748e-02f, 2.14430839e-02f, 1.15031406e-01f, -2.14538220e-02f,
  -6.39941245e-02f, 4.59963717e-02f, -3.28648798e-02f, -3.10937706e-02f, 6.54025152e-02f, 2.92103160e-02f, 1.80858020e-02f, -5.70732281e-02f, -5.37008531e-02f, 4.82399203e-02f,
  6.22269064e-02f, -4.07034764e-03f, -1.21195547e-01f, 1.08276188e-01f, 5.00173382e-02f, 5.32973520e-02f, 4.45158035e-03f, 3.96371679e-03f, 4.37642001e-02f, 4.13717367e-02f,
  1.01849094e-01f, -8.83424357e-02f, -1.17362574e-01f, 9.26259384e-02f, 1.81221843e-01f, -7.04704970e-02f, 9.58826765e-02f, 2.06865072e-02f, -7.02908437e-04f, 1.73117086e-01f,
  8.67034718e-02f, 4.71021980e-02f, 9.16496068e-02f, 1.15763746e-01f, 1.01397984e-01f, 1.63493887e-01f, 2.23514691e-01f, -2.11466802e-03f, 1.72580779e-01f, 2.51953839e-03f,
  -1.63877800e-01f, 1.19246887e-02f, -9.73634422e-02f, -1.20919012e-01f, 3.53407161e-03f, -3.07862554e-02f, 1.46597633e-02f, -1.42406495e-02f, 2.68097818e-02f, 3.50899175e-02f,
  2.92512309e-03f, -3.88405807e-02f, -3.77434380e-02f, -3.96760441e-02f, -9.14933383e-02f, 2.65403558e-02f, -7.64516881e-03f, -2.84601911e-03f, -3.10204402e-02f, 5.30429967e-02f,
  -9.23448708e-03f, -7.45801255e-03f, -1.47375483e-02f, -4.06445228e-02f, 6.54504867e-03f, 5.47580197e-02f, 3.51046063e-02f, -8.40135291e-03f, -1.79280061e-02f, 4.98087965e-02f,
  4.72902171e-02f, -1.65121499e-02f, -2.01393776e-02f, 1.62872896e-02f, -8.71742144e-03f, -8.33831057e-02f, 5.42794913e-02f, -1.87397399e-03f, -6.71136305e-02f, 9.79340002e-02f,
  4.02693488e-02f, 1.76626630e-02f, 8.73236582e-02f, 4.32156920e-02f, 1.21816108e-02f, 8.05417970e-02f, -1.07152119e-01f, 3.98982540e-02f, 5.90779111e-02f, -7.25788176e-02f,
  5.14584966e-03f, 6.90665608e-03f, 2.62590460e-02f, -2.87550017e-02f, 8.72782841e-02f, 7.47375330e-03f, 1.26323542e-02f, 1.05402082e-01f, -7.50766248e-02f, -6.29865751e-02f,
  1.47826895e-01f, 2.78126389e-01f, 2.49349661e-02f, -8.92657712e-02f, 3.85474823e-02f, 7.57516101e-02f, 1.99669786e-02f, 8.56553018e-03f, 2.19112961e-03f, -1.63522027e-02f,
  1.26156941e-01f, -9.96348858e-02f, 6.93749934e-02f, 1.58253815e-02f, 2.80990750e-02f, 1.12805203e-01f, -6.33765459e-02f, 1.33103356e-01f, 8.99513289e-02f, 9.36268717e-02f,
  1.28615454e-01f, -2.92665605e-02f, -1.67800672e-02f, -7.14685544e-02f, -3.45352404e-02f, -2.94061247e-02f, 7.82252699e-02f, 6.91880062e-02f, 1.22071870e-01f, 3.19097303e-02f,
  -2.90614188e-01f, 1.04640760e-01f, -1.29252851e-01f, -3.35093238e-03f, -1.17049806e-01f, 8.37740079e-02f, 2.18710154e-01f, 2.27674767e-02f, 1.18625559e-01f, 1.66188374e-01f,
  6.79111406e-02f, -8.84384885e-02f, 9.60612744e-02f, 1.91054702e-01f, 6.99786618e-02f, 1.58352137e-01f, 1.62418067e-01f, 9.36594829e-02f, 1.15025662e-01f, -7.36152455e-02f,
  -3.48540433e-02f, -7.55421817e-02f, -7.09890155e-03f, -4.05942537e-02f, 3.43877785e-02f, -7.74129480e-02f, 4.17311117e-02f, -1.43974662e-01f, -8.17815289e-02f, 2.47687940e-02f,
  -8.95044655e-02f, -4.56636474e-02f, -7.92092681e-02f, 1.59414131e-02f, -2.92943660e-02f, -1.95002684e-03f, -3.66066992e-02f, -8.17352757e-02f, -2.54758894e-02f, 5.17121330e-02f,
  -9.71894115e-02f, -8.31359625e-02f, 3.33826281e-02f, 1.55762117e-02f, -6.76878840e-02f, 4.85880300e-03f, -3.75270727e-04f, 2.75421143e-02f, 3.96899842e-02f, -1.04282618e-01f,
  3.69559936e-02f, -2.00466197e-02f, 2.66819745e-02f, 9.56859291e-02f, -4.94807139e-02f, 5.61695248e-02f, 3.51926982e-02f, -2.68854611e-02f, -7.39403116e-03f, 6.29160702e-02f,
  1.60852168e-03f, 1.92850847e-02f, -9.64183584e-02f, -3.45136598e-02f, -4.60024364e-02f, 1.93618778e-02f, 1.99202560e-02f, -7.22537115e-02f, 2.06882600e-02f, 9.46692899e-02f,
  -1.73599161e-02f, 3.63590382e-02f, -3.94240953e-02f, 3.40477899e-02f, -2.49882173e-02f, -7.32702613e-02f, 3.04540992e-02f, -2.01599263e-02f, 8.22084993e-02f, -5.14373854e-02f,
  -2.40084175e-02f, 2.88089048e-02f, -7.65627101e-02f, 6.98245689e-02f, -6.94277436e-02f, -2.26688460e-02f, -5.80106303e-02f, -6.73936084e-02f, 8.12702551e-02f, -7.71231130e-02f,
  1.33499637e-01f, 8.45506713e-02f, -7.71058127e-02f, -3.19919735e-02f, 9.88730043e-02f, -6.29590452e-02f, 2.63170376e-02f, -7.80526176e-03f, 7.98547864e-02f, 3.78349592e-04f,
  -1.19588873e-03f, -3.34726050e-02f, 1.78996585e-02f, 6.33636340e-02f, 4.95128185e-02f, -3.72598134e-02f, -6.20088466e-02f, -1.91083364e-02f, 7.46294484e-02f, 3.66262235e-02f,
  5.45536578e-02f, 7.02483952e-02f, 4.82918248e-02f, -4.07304913e-02f, -3.21903042e-02f, 5.35002127e-02f, -9.54241492e-03f, 1.16468687e-02f, -6.54254928e-02f, 3.02505605e-02f,
  -1.06027462e-01f, 8.49937573e-02f, 1.88979506e-02f, -8.53108391e-02f, -9.41821039e-02f, -7.30308145e-02f, -2.98265391e-03f, -4.97724377e-02f, 7.65373781e-02f, 9.84517559e-02f,
  1.24615587e-01f, 3.25970054e-02f, 4.51897383e-02f, 1.16313435e-01f, -1.04262486e-01f, 1.11317173e-01f, 8.71123150e-02f, 1.11249663e-01f, -6.55321032e-02f, 2.86447606e-03f,
  -1.05610371e-01f, -1.54921338e-02f, 7.86837712e-02f, -9.48787257e-02f, 4.85463403e-02f, -2.04086117e-02f, -1.61660314e-02f, -2.99910754e-02f, -6.09786585e-02f, -6.53097481e-02f,
  -1.29746318e-01f, 4.13473807e-02f, 4.63999696e-02f, 3.61841265e-03f, -4.60022464e-02f, 6.85167238e-02f, -2.62971539e-02f, -7.14376522e-03f, -1.28579000e-02f, -3.72459330e-02f,
  6.18859604e-02f, 9.01139453e-02f, -8.56940970e-02f, -7.58804306e-02f, -8.83425921e-02f, 3.09448298e-02f, -1.85706988e-02f, -1.08335437e-02f, 7.46687353e-02f, 5.33219352e-02f,
  7.96275213e-02f, -1.54265333e-02f, 6.30411431e-02f, -2.63152421e-02f, -2.73178401e-03f, -9.83372610e-03f, -1.92448553e-02f, -5.88190407e-02f, 2.98639461e-02f, -9.65789109e-02f,
  6.59948960e-02f, -9.17274728e-02f, -4.00046557e-02f, 3.59697640e-02f, -2.32529342e-02f, 2.30748206e-02f, -1.46540590e-02f, -3.28018293e-02f, -4.01505865e-02f, 8.31362829e-02f,
  1.17436331e-02f, 5.20754829e-02f, -1.09513570e-02f, -2.30765231e-02f, -1.56373959e-02f, -3.14621665e-02f, 7.33540803e-02f, -6.36190583e-04f, -6.34526238e-02f, -3.09732649e-03f,
  -4.15297411e-02f, -1.55336410e-02f, -8.36959183e-02f, -8.28408226e-02f, -2.57410444e-02f, 1.12832524e-02f, -2.61649694e-02f, 1.87635347e-02f, 3.55729721e-02f, -2.73469836e-03f,
  -1.15947463e-01f, 2.89481226e-02f, -1.02628484e-01f, 8.67756903e-02f, -7.06847161e-02f, -5.22640627e-03f, -2.60524116e-02f, 2.98948232e-02f, 6.29734155e-03f, 1.01776026e-01f,
  2.95432787e-02f, -7.22861290e-03f, -8.63495097e-02f, 6.62429854e-02f, -6.71846271e-02f, 5.84007129e-02f, 6.44728765e-02f, 6.19636588e-02f, -6.54348210e-02f, -4.73111449e-03f,
  2.03757510e-02f, 5.73830903e-02f, 1.08228654e-01f, -6.25828207e-02f, 5.07865176e-02f, -2.45968178e-02f, 6.11743238e-03f, 2.42403243e-02f, -9.41117629e-02f, -3.02814273e-03f,
  1.26147747e-01f, -2.63254315e-01f, 4.15872373e-02f, 3.30062896e-01f, 1.33153245e-01f, -4.54651844e-03f, -8.45168903e-03f, 8.33314285e-02f, 2.64447927e-03f, -2.24873587e-01f,
  1.30538255e-01f, -1.23599917e-01f, -2.16632277e-01f, 1.43447325e-01f, 2.75600612e-01f, -1.00331031e-01f, 1.63366362e-01f, -3.31886970e-02f, -9.42826420e-02f, 8.19325820e-03f,
  1.76622793e-01f, 1.36051700e-01f, 8.56098011e-02f, 9.77323577e-02f, 8.78343582e-02f, 2.52115298e-02f, 2.13439658e-01f, 2.90643033e-02f, 1.76512316e-01f, 4.33297604e-02f,
  -4.88659460e-03f, 5.15952557e-02f, 1.02487028e-01f, -7.31608644e-02f, -5.29758893e-02f, 5.11026084e-02f, -3.27897035e-02f, -2.30671596e-02f, 4.06145491e-02f, -6.30261004e-02f,
  1.36597296e-02f, 4.49064113e-02f, 8.45415667e-02f, 3.39280404e-02f, 4.57842499e-02f, 2.72630863e-02f, 3.90455173e-03f, -4.75248843e-02f, -2.96363402e-02f, -1.36669921e-02f,
  -9.17175263e-02f, 4.65643266e-03f, -6.84022764e-03f, -1.28044570e-02f, 4.61512320e-02f, 3.71728241e-02f, -8.20742082e-03f, -2.20308658e-02f, 1.32454792e-03f, -5.89319840e-02f,
  1.07200900e-02f, -4.10861745e-02f, -8.55070949e-02f, 1.19626205e-02f, 4.02686335e-02f, 1.20976428e-02f, 4.07214044e-03f, -7.81557057e-03f, 2.98273824e-02f, -2.95875575e-02f,
  -4.10068817e-02f, -3.08420621e-02f, -3.47860977e-02f, -2.70831622e-02f, -1.61773041e-02f, -1.16097376e-01f, 7.54785165e-02f, -2.01867707e-02f, 8.45717043e-02f, 1.97540075e-02f,
  -5.48600219e-04f, 8.72733369e-02f, -1.61226392e-02f, -2.94984151e-02f, 6.45172922e-03f, 2.06843857e-02f, 2.77940333e-02f, -9.87958163e-03f, 1.23615693e-02f, 5.72647862e-02f,
  2.96417028e-02f, 7.04200007e-03f, -6.66334331e-02f, 1.59822628e-02f, 1.45045836e-02f, -1.93431787e-02f, 1.05145748e-03f, -4.36146669e-02f, 5.08308485e-02f, 2.00435407e-02f,
  9.50523540e-02f, 9.42499563e-03f, -6.94019198e-02f, -3.69423851e-02f, 9.18840170e-02f, -6.71540340e-03f, -2.18607262e-02f, 5.74255772e-02f, 2.57474035e-02f, 4.99118343e-02f,
  -3.12393960e-02f, -6.95521990e-03f, 2.67715603e-02f, 3.37413400e-02f, 7.59497099e-03f, -8.91855061e-02f, -2.73046531e-02f, -3.43649164e-02f, 8.18254277e-02f, 6.40584975e-02f,
  -2.05833286e-01f, 1.10691205e-01f, -1.11312971e-01f, -1.59142679e-03f, -2.04072282e-01f, 6.65502623e-02f, 3.52084190e-02f, -4.62861322e-02f, 9.13068205e-02f, 5.91930076e-02f,
  1.00004584e-01f, -3.10886255e-03f, 4.85571660e-03f, 1.86515972e-01f, -3.12089119e-02f, 6.02881387e-02f, -3.06536276e-02f, 6.18269760e-03f, 1.84803884e-02f, -2.13403441e-02f,
  8.90544057e-03f, 1.11655191e-01f, -2.43996363e-02f, -9.01685804e-02f, -6.82139769e-02f, 4.84216772e-02f, 9.10646108e-04f, -9.99512151e-02f, 3.91867608e-02f, -7.57525563e-02f,
  -1.32090291e-02f, -6.58828989e-02f, -1.18134998e-01f, -1.00986049e-01f, -1.14558488e-01f, -5.72355911e-02f, 8.10477417e-03f, -1.97817329e-02f, 4.49589863e-02f, 9.45832208e-02f,
  -9.04742349e-03f, 3.66298445e-02f, 8.12239498e-02f, -5.11064380e-02f, 6.97107390e-02f, -6.48367703e-02f, -7.04813227e-02f, 2.59613409e-03f, 1.90486982e-02f, 1.87494047e-02f,
  -4.23063934e-02f, 3.00507583e-02f, -2.29004007e-02f, 4.20018379e-03f, 4.88855392e-02f, -4.63210698e-03f, 6.03581257e-02f, -6.74062520e-02f, -8.19693232e-05f, 4.49779145e-02f,
  -5.06731085e-02f, 1.23231560e-02f, -4.50810194e-02f, -5.59555041e-03f, 6.28645942e-02f, -4.35393080e-02f, -5.87389022e-02f, -7.26691261e-02f, 4.13092263e-02f, 2.05549952e-02f,
  -4.47973274e-02f, -5.60980104e-02f, 5.32939620e-02f, 4.72882651e-02f, 8.40620324e-02f, -2.35355478e-02f, 6.32208511e-02f, 1.52324268e-04f, 4.11206037e-02f, 8.06511525e-05f,
  6.50401562e-02f, 1.51961353e-02f, 3.48286666e-02f, -3.99696529e-02f, -3.54265198e-02f, 5.63175455e-02f, -1.85563341e-02f, 5.88913299e-02f, 5.80740944e-02f, 5.22143841e-02f,
  -1.46648064e-01f, -7.52742887e-02f, 6.01918437e-03f, 2.09290367e-02f, -5.18722683e-02f, 9.12747532e-03f, 2.43262611e-02f, 2.84372550e-02f, 8.70101303e-02f, -2.75458917e-02f,
  5.70947677e-02f, 8.39362293e-02f, 4.81997989e-02f, -3.85630429e-02f, 3.23532782e-02f, -4.19953726e-02f, -8.12727511e-02f, -3.98179255e-02f, 2.51424238e-02f, 3.70421563e-03f,
  3.36857140e-02f, -9.45133045e-02f, 5.13059422e-02f, 2.28664558e-02f, 9.18091238e-02f, 2.49502324e-02f, -3.89944995e-03f, -2.81767435e-02f, -2.11905707e-02f, 1.83950718e-02f,
  4.19128872e-02f, 2.57571824e-02f, -1.16768122e-01f, -1.18798628e-01f, -7.71323964e-02f, -1.88878566e-01f, -2.39407852e-01f, -5.12439795e-02f, -8.47420916e-02f, 2.70815771e-02f,
  -6.49524108e-03f, 4.25700424e-03f, 3.16830678e-03f, -2.32458428e-01f, 1.03706948e-01f, 7.80627877e-02f, -2.25079320e-02f, -1.50541086e-02f, 3.43067236e-02f, -7.28092417e-02f,
  1.05382971e-01f, -7.97897205e-02f, 4.30183299e-02f, 6.70451596e-02f, -1.51738286e-01f, 1.24157175e-01f, 2.22329751e-01f, 2.22782064e-02f, -7.07207397e-02f, -3.08228377e-02f,
  -1.54959500e-01f, -2.19483934e-02f, 5.12913056e-02f, -5.28245233e-03f, -5.15647233e-03f, 4.39129397e-02f, 1.91396512e-02f, 3.87153551e-02f, 2.02102643e-02f, -4.59509902e-02f,
  6.47320524e-02f, 7.00000115e-03f, -1.17498979e-01f, 1.00789174e-01f, -1.28156720e-02f, 1.81526560e-02f, -1.04142576e-02f, 2.55463813e-02f, -5.59287034e-02f, -1.70830451e-02f,
  2.17766478e-03f, 1.79723483e-02f, -2.07785890e-02f, 1.03057176e-02f, -5.36663905e-02f, 3.07503249e-03f, 2.94837356e-02f, 4.39123996e-02f, -3.88984382e-02f, 1.43769942e-02f,
  -4.45148237e-02f, 4.93391929e-03f, 1.06426813e-02f, -9.83428210e-03f, -4.78556268e-02f, -1.70463007e-02f, -4.30948613e-03f, 6.21264726e-02f, 6.37178198e-02f, -7.87208974e-02f,
  -4.29573059e-02f, -3.73638351e-03f, -7.29913171e-03f, -5.78832738e-02f, 1.86319824e-03f, 1.47645473e-02f, -3.37277912e-02f, 1.26146004e-02f, 1.55141195e-02f, 6.69804960e-02f,
  3.09794582e-02f, 3.94621231e-02f, 2.36742795e-02f, -7.26370364e-02f, 1.22786099e-02f, 5.98734207e-02f, -6.29608333e-02f, -4.64605577e-02f, -5.30183222e-03f, 2.80610602e-02f,
  9.76688713e-02f, 1.52324244e-01f, -3.68292779e-02f, -1.11480020e-01f, 3.96257043e-02f, -8.07389468e-02f, 7.48205781e-02f, -9.14988816e-02f, 1.75648574e-02f, 4.84270416e-03f,
  -6.17496530e-03f, 4.95846607e-02f, 3.30147594e-02f, 3.27267707e-03f, 7.90719539e-02f, 2.12032292e-02f, -5.40604703e-02f, 6.33403361e-02f, 4.28769998e-02f, 7.60639757e-02f,
  -2.19196659e-02f, -2.38173474e-02f, -2.51342170e-02f, -3.31430361e-02f, -4.40593250e-02f, -1.86946802e-02f, -9.16193798e-03f, 1.96004771e-02f, 4.47458215e-02f, 2.17847601e-02f,
  1.38381213e-01f, -1.26896009e-01f, -3.43238354e-01f, 5.01101837e-02f, -4.44716439e-02f, 1.48691043e-01f, -2.28981264e-02f, -1.03507422e-01f, -2.17897430e-01f, -5.84005900e-02f,
  5.84815331e-02f, -2.93375775e-02f, -1.82995021e-01f, 1.67362913e-01f, 2.69799769e-01f, 6.22316217e-03f, 1.62715390e-01f, 1.25604033e-01f, -2.98543368e-03f, 4.88685109e-02f,
  -1.97586026e-02f, 2.95314401e-01f, 9.15109292e-02f, 1.75813362e-01f, 4.66482490e-02f, -1.49714407e-02f, 8.45264196e-02f, -1.45798638e-01f, 2.87584722e-01f, 1.29531637e-01f,
  9.61675867e-02f, -1.57276317e-01f, -6.48068488e-02f, 5.17734215e-02f, 8.25203061e-02f, -4.52976562e-02f, -5.26480936e-03f, 7.60605484e-02f, 4.06109504e-02f, -7.71640847e-03f,
  4.74804081e-02f, 7.38044977e-02f, 2.58005112e-02f, 1.42629677e-02f, -3.75506915e-02f, -2.83975601e-02f, -7.99070001e-02f, -5.06871045e-02f, -1.01525925e-01f, 2.86866557e-02f,
  -4.40551415e-02f, -1.02529123e-01f, -5.39065041e-02f, -8.88175294e-02f, -9.48653221e-02f, 3.03035583e-02f, -7.82133564e-02f, -6.24116100e-02f, -4.08733115e-02f, -4.73129936e-02f,
  1.33518660e-02f, 2.55432725e-02f, 2.32248381e-02f, 5.10640852e-02f, -2.83636916e-02f, 1.15110479e-01f, 4.90332805e-02f, 3.58437635e-02f, -2.46733669e-02f, -1.03833927e-02f,
  -3.82519513e-02f, 5.37482165e-02f, -3.78589444e-02f, 2.21234243e-02f, 7.58066773e-02f, 6.85543008e-03f, 6.22725710e-02f, -3.20794582e-02f, 2.94988416e-02f, -3.84228043e-02f,
  7.98120797e-02f, -2.57600993e-02f, 3.22793461e-02f, 2.98736077e-02f, -7.07765063e-03f, 1.35771791e-02f, 6.83924137e-03f, 2.54574008e-02f, -6.15877733e-02f, 3.75979468e-02f,
  9.88162681e-02f, -1.02639057e-01f, 2.48114821e-02f, 5.13909496e-02f, 3.94779351e-03f, -3.06515954e-03f, 3.28430235e-02f, 3.75277176e-02f, -1.83023848e-02f, -4.05734144e-02f,
  -5.32058207e-03f, -3.74060066e-04f, -1.84398592e-02f, 5.33001386e-02f, -2.95056589e-02f, -7.60936439e-02f, -4.96531576e-02f, -5.90011152e-03f, 2.18293816e-02f, -5.20849787e-02f,
  -3.45863849e-02f, -9.14413333e-02f, -8.72708410e-02f, -3.50445248e-02f, 5.70514053e-02f, 8.95897485e-03f, -5.79610374e-03f, -5.28929755e-02f, 1.53292669e-03f, -8.09493437e-02f,
  -4.95250612e-01f, 1.85433701e-01f, -1.12338327e-01f, 7.20774755e-02f, -2.97852941e-02f, -2.45753992e-02f, 6.66490346e-02f, -3.14778388e-02f, 1.15626439e-01f, 1.90972924e-01f,
  -1.77515280e-02f, -2.86493134e-02f, 1.33738816e-01f, 1.87168673e-01f, -1.72589496e-01f, 1.80692539e-01f, 1.05278559e-01f, 8.32689479e-02f, 8.59776288e-02f, 1.04464278e-01f,
  -4.35576104e-02f, 1.32678464e-01f, -4.33707982e-02f, 8.24447442e-03f, -8.71199593e-02f, -4.99753505e-02f, -7.30246529e-02f, 5.41596524e-02f, -9.65408087e-02f, -5.29579483e-02f,
  -1.43902451e-01f, -1.52224600e-01f, -6.60428628e-02f, -1.06752612e-01f, -7.40113258e-02f, -7.83413202e-02f, -3.42966951e-02f, -4.11714725e-02f, -4.45490063e-04f, 2.09455378e-03f,
  4.62859869e-02f, -9.49894637e-02f, -5.91620952e-02f, 7.33691379e-02f, 8.13481808e-02f, -5.68701625e-02f, -3.65110375e-02f, 8.93711951e-03f, -5.32147847e-02f, -2.94178501e-02f,
  -5.06611876e-02f, -7.63302892e-02f, -2.29039397e-02f, -8.58208016e-02f, 3.27424146e-02f, 4.40059043e-02f, 2.14006454e-02f, 7.43152201e-02f, -1.08031474e-01f, 4.37011085e-02f,
  4.72512580e-02f, 2.06030793e-02f, 2.04073433e-02f, -1.47266490e-02f, -1.94506291e-02f, -3.88419516e-02f, 7.30209947e-02f, 2.21139677e-02f, -7.22278506e-02f, 1.86193697e-02f,
  -5.70245534e-02f, -4.13096771e-02f, 1.08226826e-02f, 3.38075086e-02f, 3.38910408e-02f, 7.79942870e-02f, -1.36236511e-02f, -3.72665226e-02f, -3.84525247e-02f, -4.21655774e-02f,
  4.01137099e-02f, 1.13450512e-02f, 3.41572650e-02f, -1.63221974e-02f, 2.53809243e-02f, 1.09145185e-02f, -6.15162067e-02f, 5.03255613e-02f, 2.76347473e-02f, -2.44710525e-03f,
  -5.83629720e-02f, 3.32659632e-02f, 5.61801204e-03f, -1.00819226e-02f, -1.21937394e-02f, -6.76880255e-02f, 5.75002171e-02f, -6.70073479e-02f, 9.36003029e-03f, 5.02487756e-02f,
  1.07897809e-02f, 3.23701203e-02f, -6.00287467e-02f, 4.19958681e-02f, -5.40750585e-02f, 4.31448258e-02f, 8.54548737e-02f, -1.96677241e-02f, 1.85286533e-02f, -1.24752708e-01f,
  -3.57570127e-02f, -2.95214802e-02f, -7.51854852e-03f, 8.07202328e-03f, 1.14306808e-02f, 6.54429838e-04f, -1.55499969e-02f, -4.96212095e-02f, 1.85469985e-02f, -1.49526158e-02f,
  1.14675052e-01f, -1.66507348e-01f, -2.41677478e-01f, -1.20422333e-01f, 2.48376057e-01f, 1.77619293e-01f, 1.48006612e-02f, 4.92236055e-02f, -1.07588813e-01f, 7.91384950e-02f,
  1.03497468e-01f, 4.82302681e-02f, -1.31749749e-01f, -1.77301525e-03f, -9.20176283e-02f, -1.50312901e-01f, -2.06075180e-02f, -9.14416276e-03f, -4.15212885e-02f, 7.12023452e-02f,
  -2.12236885e-02f, 5.87281138e-02f, -1.67955384e-01f, 1.12294339e-01f, 6.24972880e-02f, 5.24426922e-02f, 1.61080156e-02f, 2.57955510e-02f, 9.74689350e-02f, 1.25803053e-01f,
  -1.47081697e-02f, 2.62365807e-02f, -8.77529308e-02f, 3.67209353e-02f, 9.32543166e-03f, 1.13887124e-01f, 4.73566055e-02f, -6.83481693e-02f, -6.20982870e-02f, -4.24174741e-02f,
  6.09079637e-02f, -1.05932310e-01f, -2.50717346e-03f, 2.92831715e-02f, 2.04425957e-03f, -1.78469326e-02f, 4.02985467e-03f, -8.46009552e-02f, -1.05963983e-01f, 2.04479937e-02f,
  -5.89396954e-02f, 1.55889615e-02f, 3.79416570e-02f, -1.07033141e-01f, -1.13876507e-01f, 5.20043224e-02f, -8.87595788e-02f, 5.68076875e-03f, -3.56857888e-02f, 6.85130358e-02f,
  8.48407000e-02f, 1.30312189e-01f, 3.97430025e-02f, -8.81279707e-02f, -2.10185926e-02f, 6.50172646e-04f, -8.28635171e-02f, -6.68229675e-03f, -2.48142686e-02f, 1.11593999e-01f,
  5.95961772e-02f, -3.35704796e-02f, 4.85967994e-02f, 6.84444308e-02f, -7.86211248e-03f, -1.23980539e-02f, 9.12595242e-02f, 1.17390200e-01f, 2.02309955e-02f, 2.72098668e-02f,
  -2.95221359e-02f, -1.27536701e-02f, -5.29424474e-02f, 1.31828962e-02f, -5.37572131e-02f, 2.05240343e-02f, 5.63292094e-02f, -4.57537099e-04f, -4.24563922e-02f, 3.44287604e-02f,
  6.92959279e-02f, 2.53828485e-02f, -5.85130751e-02f, -2.70568356e-02f, 1.07802637e-02f, 8.02962109e-02f, -5.34546264e-02f, 1.02777578e-01f, 3.76449823e-02f, 1.08216390e-01f,
  5.47954105e-02f, -7.79079720e-02f, 5.26210107e-03f, -1.06541496e-02f, -7.91105181e-02f, 1.09327666e-01f, 1.59658492e-02f, 1.05408300e-02f, 1.68709047e-02f, -2.93998122e-02f,
  2.33594012e-02f, 1.52450934e-01f, 1.63385291e-02f, 8.25793594e-02f, -6.19273307e-03f, 9.11760554e-02f, -3.19327973e-02f, 8.34055245e-02f, 1.87630188e-02f, -8.82096440e-02f,
  1.57600269e-01f, 1.25790656e-01f, 5.00262566e-02f, 9.81794819e-02f, -9.41450819e-02f, 9.97819975e-02f, 2.13882327e-01f, 6.35534376e-02f, 2.22679853e-01f, 1.57056116e-02f,
  -6.42477628e-03f, 2.28425741e-01f, -1.31457210e-01f, 8.69310647e-02f, -1.30142629e-01f, -1.99191887e-02f, 1.05134696e-01f, 9.36325192e-02f, 3.95861119e-02f, 1.01636231e-01f,
  -3.16856429e-02f, -1.31853268e-01f, -1.37286693e-01f, 7.06234109e-03f, -1.03940479e-02f, 8.58068615e-02f, -2.25103274e-01f, 2.00087465e-02f, 8.98188911e-03f, -9.59592015e-02f,
  3.33356038e-02f, 1.21599630e-01f, -1.54473493e-02f, 9.80307441e-03f, -6.11429363e-02f, -8.48322921e-03f, 3.85972485e-02f, 6.23928048e-02f, -3.43380496e-02f, 1.04262210e-01f,
  3.32760476e-02f, 4.84583341e-02f, 1.09390952e-01f, -3.06698624e-02f, 4.08055633e-02f, 6.86999410e-02f, 3.34063568e-03f, -4.22831662e-02f, 7.17983618e-02f, -3.30183990e-02f,
  6.18336834e-02f, -8.49887356e-03f, -1.89180262e-02f, 3.68028171e-02f, -1.16529964e-01f, 7.14235976e-02f, 2.67043686e-03f, 4.79203556e-03f, 6.93481043e-02f, -1.69418212e-02f,
  -5.71208410e-02f, 3.17623019e-02f, -4.15701047e-02f, -7.03592747e-02f, 6.95618540e-02f, -6.34390116e-02f, 2.11767964e-02f, 5.34243435e-02f, 7.12636709e-02f, -4.90497202e-02f,
  3.27052996e-02f, 8.82149581e-03f, -4.61805835e-02f, -2.34465469e-02f, 1.05920069e-01f, -1.00928862e-02f, -1.02501037e-02f, -5.68507165e-02f, 1.06930071e-02f, 1.35747464e-02f,
  1.56472605e-02f, 3.00579239e-02f, -3.43448184e-02f, -1.47549447e-03f, 2.00316068e-02f, -5.62333725e-02f, -1.37607837e-02f, 5.02423644e-02f, 1.52365444e-02f, -7.94090237e-03f,
  9.25301984e-02f, 5.26750498e-02f, 7.96373263e-02f, 5.96991293e-02f, 2.05621179e-02f, -1.70579106e-02f, -2.44034696e-02f, 1.88121200e-02f, 1.16438298e-02f, -4.78973016e-02f,
  -3.62259373e-02f, 2.33612163e-03f, -4.95871156e-02f, 6.39616400e-02f, 2.56582536e-02f, 8.31371080e-03f, 5.87689057e-02f, -2.34846212e-02f, -2.52048392e-03f, 1.07044168e-02f,
  -7.52380351e-03f, 9.93472058e-03f, 4.05351222e-02f, -4.95869070e-02f, 3.11990473e-02f, -6.21946119e-02f, -1.30315544e-02f, 1.90384407e-02f, -7.22913593e-02f, 6.74071386e-02f,
  -2.52763256e-02f, -6.97431341e-02f, -1.48708038e-02f, 1.48657605e-01f, 3.75906415e-02f, -7.25010559e-02f, -7.60750845e-03f, 5.45520373e-02f, -9.27809477e-02f, -8.42195377e-02f,
  7.48417154e-02f, 2.23487266e-03f, -3.55050527e-02f, 7.34279826e-02f, 2.04724640e-01f, -9.97531787e-02f, 4.72594127e-02f, -2.43812110e-02f, -1.11592359e-04f, 7.45192217e-03f,
  1.44465268e-01f, 1.32280454e-01f, 6.09937832e-02f, 1.25741437e-01f, 3.82154733e-02f, 7.12351128e-02f, 6.37525693e-02f, 5.13197891e-02f, 1.59155697e-01f, 7.59717375e-02f,
  -1.11953132e-01f, -2.41074786e-02f, -9.76258516e-03f, 9.31266416e-03f, 2.56447811e-02f, 8.92270729e-02f, -1.08418316e-01f, -5.14108948e-02f, -3.12792659e-02f, 3.43270488e-02f,
  -2.54845880e-02f, 8.11480209e-02f, -3.27432007e-02f, -1.17068796e-03f, 1.87725239e-02f, 2.91390438e-02f, 2.64793504e-02f, 1.22453999e-02f, -2.23587826e-02f, 8.83101486e-03f,
  -1.41115962e-02f, -3.11679356e-02f, 1.17054498e-02f, -7.19163716e-02f, -2.07315162e-02f, -5.75332344e-03f, -7.98442587e-02f, 8.15675482e-02f, -1.88737568e-02f, 4.03346978e-02f,
  -7.68034905e-02f, 1.02907583e-01f, -6.09393567e-02f, 5.86461984e-02f, 5.86339831e-02f, -7.19078034e-02f, 5.22365235e-02f, -3.03695779e-02f, 5.81810549e-02f, 3.36434543e-02f,
  5.59955053e-02f, -2.18934636e-03f, -5.02426028e-02f, -6.99171200e-02f, -1.42207080e-02f, -4.71353866e-02f, 6.76301569e-02f, -8.09693336e-02f, -7.78181478e-02f, 3.69771533e-02f,
  -1.18143894e-01f, 1.64589640e-02f, 4.30408213e-03f, -7.76453968e-03f, 7.33721675e-03f, -4.64710258e-02f, -2.73189694e-02f, -6.56822324e-02f, 4.35584709e-02f, 5.54329939e-02f,
  4.16538119e-02f, 1.33146346e-01f, -6.01034090e-02f, -2.57655117e-03f, -6.01333417e-02f, 7.90788420e-03f, -9.62697715e-03f, 2.06650756e-02f, -4.78868671e-02f, 7.17081502e-02f,
  -2.51420606e-02f, 5.44755682e-02f, 3.45416442e-02f, -2.94146175e-03f, -2.84256749e-02f, 1.26958368e-02f, 9.06952545e-02f, -4.29423563e-02f, 2.58617792e-02f, 7.95672163e-02f,
  1.98535062e-02f, 6.70014098e-02f, -2.73858979e-02f, 9.66094583e-02f, 6.22518957e-02f, -1.14052705e-02f, 2.97868643e-02f, -7.70687312e-02f, -4.17171419e-02f, 4.04666439e-02f,
  -2.37539962e-01f, 2.45310768e-01f, 1.50558457e-01f, -3.15972045e-02f, -1.66422240e-02f, 1.51586354e-01f, -7.35554248e-02f, 4.32561338e-02f, 5.07190563e-02f, 1.11428499e-01f,
  5.02213165e-02f, 1.22373231e-01f, 1.49742857e-01f, -6.03899993e-02f, -1.13740057e-01f, 4.15699929e-02f, -1.45846726e-02f, -4.69070487e-02f, 8.96601155e-02f, -2.10260991e-02f,
  -6.01485185e-02f, 4.72712442e-02f, -2.92447321e-02f, 1.36832772e-02f, 3.21956277e-02f, 7.25686699e-02f, -1.78497791e-01f, 1.48536131e-01f, -1.15223356e-01f, 3.44801112e-04f,
  -1.04980476e-01f, -9.75492597e-03f, -7.34634101e-02f, -7.35369027e-02f, -4.15134020e-02f, 3.94111797e-02f, -6.85315952e-02f, 6.33313581e-02f, 6.32094918e-04f, 1.08112477e-01f,
  1.07694559e-01f, -2.55823489e-02f, -1.63315367e-02f, 4.86291535e-02f, 5.41950166e-02f, -5.57911880e-02f, 3.11766621e-02f, -5.43064764e-03f, 2.47120224e-02f, 1.05842374e-01f,
  2.31171977e-02f, 4.94185649e-02f, 4.63257264e-03f, 5.02508990e-02f, -1.78428832e-02f, -2.89433058e-02f, -5.74618243e-02f, 7.02969357e-02f, -4.28312458e-02f, -1.14388820e-02f,
  6.46476820e-02f, -3.18152085e-02f, -4.85111848e-02f, -8.06406587e-02f, 8.04991573e-02f, -8.89057294e-02f, -8.48084092e-02f, -3.41293514e-02f, 4.47500795e-02f, -5.38846590e-02f,
  -1.16936058e-01f, -4.61267270e-02f, 9.76392999e-02f, 2.27839500e-02f, 3.01388074e-02f, -8.22159275e-03f, -8.11309889e-02f, 7.35914186e-02f, -5.13363443e-02f, -1.53371776e-02f,
  7.75698200e-02f, -1.70288980e-02f, -4.17424105e-02f, 2.09403820e-02f, -4.29415740e-02f, -2.69334967e-04f, -1.59224775e-02f, 3.28100333e-03f, 2.08746400e-02f, 7.32751861e-02f,
  -1.67332187e-01f, -1.05981547e-02f, 3.17821698e-03f, -6.11558855e-02f, 4.98238206e-02f, -4.99841683e-02f, 4.59711216e-02f, -7.69440532e-02f, -6.72814175e-02f, -5.03745079e-02f,
  2.21621315e-03f, -3.56373526e-02f, 4.09182049e-02f, -2.34345086e-02f, -4.35889959e-02f, 2.12929342e-02f, 9.29980259e-03f, 8.39711875e-02f, -4.63734660e-03f, 4.66186665e-02f,
  1.17334379e-02f, -1.71751920e-02f, -1.26636624e-02f, -5.61635271e-02f, -6.11580610e-02f, -4.54546362e-02f, 2.82258000e-02f, 3.56739834e-02f, 7.26325437e-02f, -3.65422182e-02f,
  1.80221975e-01f, -7.43284672e-02f, 3.47489230e-02f, -7.54439831e-02f, 8.55188295e-02f, 8.41661468e-02f, -1.12935733e-02f, -1.44878834e-01f, 4.19468172e-02f, -1.58204734e-01f,
  -1.04157412e-02f, -5.74919544e-02f, 1.20639868e-01f, -1.60144463e-01f, 1.28647745e-01f, 4.12603021e-02f, -1.31626576e-01f, -9.40289348e-02f, 2.35351045e-02f, -1.65447056e-01f,
  -5.37484363e-02f, -2.06903368e-01f, -5.78825288e-02f, -2.24517405e-01f, -5.86097389e-02f, -1.37425408e-01f, 2.95779295e-02f, 4.47016209e-02f, -1.54224387e-03f, -4.72822413e-03f,
  8.68086293e-02f, -9.03304219e-02f, -3.71825844e-02f, -6.35813996e-02f, -6.46210387e-02f, 8.05974081e-02f, -6.11297786e-02f, 1.18662147e-02f, 1.27966348e-02f, -6.56057149e-03f,
  6.45185038e-02f, -2.31968202e-02f, -4.18171622e-02f, 3.34013179e-02f, 1.03785768e-02f, 3.76170292e-03f, -5.73245101e-02f, 5.29888235e-02f, -3.92938964e-02f, -4.30119634e-02f,
  3.46904900e-03f, 8.98711663e-03f, 1.12383449e-02f, 2.15923246e-02f, 7.99994469e-02f, 1.02961719e-01f, 2.12601237e-02f, 4.72622216e-02f, -2.28526220e-02f, 3.96371000e-02f,
  -1.74299195e-01f, -3.95881161e-02f, 6.57128468e-02f, -5.46225086e-02f, 4.16657440e-02f, -1.21926032e-02f, -8.73026904e-04f, 2.61067897e-02f, -4.47797403e-02f, -2.51136441e-02f,
  6.18112050e-02f, -2.60906983e-02f, 3.92626487e-02f, 1.02435343e-01f, -5.30567057e-02f, 2.27714162e-02f, -5.16476519e-02f, -1.79450605e-02f, 5.84525466e-02f, -3.90378535e-02f,
  4.85747047e-02f, 4.16384637e-02f, -4.83955517e-02f, 1.10239416e-01f, 4.85847779e-02f, 5.48047833e-02f, -7.14458674e-02f, 3.78134078e-03f, 3.49818729e-02f, -8.91475976e-02f,
  -8.72131586e-02f, -2.48348832e-01f, -1.23586699e-01f, 2.22872756e-03f, -8.67973343e-02f, 2.08438877e-02f, -6.72493428e-02f, -4.76301238e-02f, -7.83784613e-02f, -2.49673147e-02f,
  1.11180218e-02f, -4.58114371e-02f, 5.82029186e-02f, 6.10990785e-02f, -8.10661241e-02f, 4.26472491e-03f, -9.80532467e-02f, -7.80949444e-02f, -7.40183443e-02f, -2.90554557e-02f,
  -4.38310392e-02f, 6.54303432e-02f, -4.77048568e-02f, -1.08785346e-01f, -2.09380817e-02f, 7.03431442e-02f, -4.07103673e-02f, -4.83555123e-02f, 5.43649271e-02f, -2.62054987e-02f,
  -5.18003739e-02f, -4.01775576e-02f, -1.62845269e-01f, 9.18742567e-02f, -9.77066755e-02f, 1.50369793e-01f, 1.35877086e-02f, -1.76862497e-02f, -1.61783502e-01f, 1.12429880e-01f,
  -2.99078915e-02f, -1.31374359e-01f, -1.17382459e-01f, 7.73230121e-02f, 7.66263157e-02f, 9.64964926e-02f, 9.40030515e-02f, 1.59310833e-01f, -9.15732980e-02f, 1.74618233e-02f,
  4.50410172e-02f, 8.38649422e-02f, 2.58058105e-02f, 8.22959766e-02f, -3.65895927e-02f, -9.97017249e-02f, -9.42404568e-02f, -7.19408467e-02f, -1.88791249e-02f, -6.95918202e-02f,
  1.52139217e-01f, -1.88147891e-02f, -1.33104250e-01f, -9.36463624e-02f, -3.53376456e-02f, 4.94112894e-02f, 7.35993907e-02f, -3.06070782e-02f, -8.59218687e-02f, 1.36913462e-02f,
  -2.02657450e-02f, 3.89390588e-02f, 7.14006973e-03f, -7.06670508e-02f, -6.46297708e-02f, 7.35297799e-02f, -6.99310079e-02f, -4.14242521e-02f, 1.83255188e-02f, 3.16936560e-02f,
  -3.89268771e-02f, 5.13495132e-02f, -1.51101379e-02f, 5.26584126e-02f, -1.00962527e-01f, 5.72855584e-03f, -2.12621670e-02f, 7.71165788e-02f, -5.81288263e-02f, -1.37377251e-02f,
  -7.70344138e-02f, 8.27986449e-02f, -1.03533687e-02f, -7.37582594e-02f, -7.76362233e-03f, 4.97816578e-02f, -8.47257674e-03f, -4.31497991e-02f, -5.06589636e-02f, 7.04736859e-02f,
  -6.95723593e-02f, -2.00560549e-03f, -4.02347557e-03f, -1.95604190e-02f, 2.92137526e-02f, -6.98916847e-03f, -4.12485650e-04f, 4.75540310e-02f, 8.54151547e-02f, 2.50232462e-02f,
  -9.74628329e-02f, -8.50277767e-02f, 5.62471822e-02f, 4.39008661e-02f, -6.18668981e-02f, -4.43977378e-02f, -4.79443520e-02f, 3.68972123e-02f, 5.71135618e-02f, -7.97918141e-02f,
  4.11337838e-02f, -3.24299186e-02f, 5.21991663e-02f, -2.82531381e-02f, -2.55588256e-02f, 4.29542325e-02f, -4.78364341e-02f, -5.00541367e-02f, -9.08351503e-03f, -1.93386879e-02f,
  3.65208574e-02f, -8.41915458e-02f, -1.29881082e-02f, -6.38397709e-02f, -6.93089887e-02f, 4.33223285e-02f, 8.95959213e-02f, -6.47319108e-02f, 7.01509789e-02f, 3.49576995e-02f,
  6.86950609e-02f, -5.09094484e-02f, -7.46408850e-03f, -2.32627965e-03f, -5.95008507e-02f, -1.26421836e-03f, -4.42126505e-02f, 4.92322147e-02f, 3.37090269e-02f, -2.22164392e-02f,
  -5.18641584e-02f, -3.23187895e-02f, 3.14722806e-02f, -5.71097285e-02f, 7.58168846e-02f, 5.34506850e-02f, 8.93894956e-03f, 8.99614394e-02f, -3.49682989e-03f, -6.20801486e-02f,
  -3.24775614e-02f, -2.64371727e-02f, 4.98625776e-03f, 6.33126795e-02f, 4.55968641e-02f, -9.38298181e-02f, -4.21559736e-02f, -4.37658913e-02f, 3.70233250e-03f, -3.41441686e-04f,
  -2.31091655e-03f, -4.87490110e-02f, -2.46299841e-02f, -5.51996902e-02f, 1.13695189e-01f, -1.82629731e-02f, 5.59804440e-02f, -1.31683284e-02f, 1.18219316e-01f, 1.04777753e-01f,
  -2.17107330e-02f, -6.73065409e-02f, -2.74100378e-02f, 2.46312600e-02f, -5.06116524e-02f, 7.18360096e-02f, -4.79915105e-02f, -5.19783087e-02f, 7.28173852e-02f, -5.02760857e-02f,
  1.32685807e-03f, -1.26927327e-02f, 4.58273292e-02f, -9.28374603e-02f, -8.43689498e-03f, -6.74932674e-02f, -4.35401909e-02f, 9.30396374e-03f, -6.71571195e-02f, 7.60786012e-02f,
  -8.36865231e-02f, -4.75154538e-03f, 1.06892660e-02f, -1.19755790e-02f, -6.48881346e-02f, 1.13737816e-02f, -2.35932544e-02f, 3.29393037e-02f, 2.82932743e-02f, -6.11574447e-04f,
  6.31517470e-02f, -3.95927243e-02f, 7.02307094e-03f, 1.02809556e-02f, -6.66983947e-02f, 8.18995461e-02f, -6.03975169e-02f, 4.62461039e-02f, 5.23816794e-02f, -2.97233555e-02f,
  6.44271523e-02f, -6.76071346e-02f, -1.95883457e-02f, -5.72873801e-02f, 3.13220806e-02f, 9.94368829e-03f, 6.47164322e-03f, -6.91697672e-02f, 8.72006565e-02f, 5.27228266e-02f,
  3.67623866e-02f, 5.60347438e-02f, -7.24883378e-02f, 3.44013199e-02f, -3.00183631e-02f, -6.11171767e-04f, 3.89856432e-04f, 7.18080029e-02f, 2.28528213e-03f, 4.26274613e-02f,
  3.86930294e-02f, 4.28282656e-02f, -3.01559530e-02f, 9.41854492e-02f, 1.21231508e-02f, 5.66722499e-03f, -1.38387121e-02f, -3.59490030e-02f, 4.96879965e-02f, -7.27071464e-02f,
  -4.12043883e-03f, 2.90121008e-02f, 2.87423562e-02f, 4.13800366e-02f, 4.20868881e-02f, 8.61151442e-02f, -1.76212676e-02f, -3.15906145e-02f, 9.57644656e-02f, 3.45229097e-02f,
  1.77261662e-02f, -7.39275441e-02f, 2.84993593e-02f, 6.97148964e-02f, 4.76526730e-02f, -3.31683382e-02f, -4.82138097e-02f, -8.83017033e-02f, 1.25594795e-01f, 1.77934335e-03f,
  1.23320483e-01f, -1.74153522e-01f, 6.93667531e-02f, -6.61575273e-02f, 1.16448991e-01f, 6.55277073e-02f, 7.93899670e-02f, -1.16917398e-02f, 3.86018530e-02f, -2.61227973e-02f,
  6.13469370e-02f, -2.41707359e-03f, -8.54520127e-02f, 1.54524446e-02f, 1.11979231e-01f, 5.10713905e-02f, -2.74954885e-02f, 1.04388885e-01f, 5.47391102e-02f, 8.81538987e-02f,
  6.65670931e-02f, -8.45626891e-02f, -1.11146100e-01f, -9.70153064e-02f, -1.13949172e-01f, -5.61701134e-02f, -8.36213008e-02f, 2.72796862e-02f, -1.96327329e-01f, -9.51552764e-02f,
  3.97856943e-02f, -1.07951306e-01f, -8.60010758e-02f, 1.85348804e-03f, -8.70166905e-03f, -1.07461944e-01f, -1.26186758e-02f, -8.14461410e-02f, -9.43378266e-03f, 7.68193835e-03f,
  -4.32914011e-02f, -5.97281083e-02f, -4.45052087e-02f, 7.44794160e-02f, -3.34270112e-02f, -8.03590342e-02f, 1.47418603e-02f, -5.63980564e-02f, 4.49357927e-02f, 1.55305993e-02f,
  -3.33824824e-03f, 4.67062443e-02f, 3.80498692e-02f, -1.03851937e-01f, 9.91730615e-02f, -4.16683629e-02f, 4.41355519e-02f, 6.51776120e-02f, 3.40647884e-02f, 2.26183422e-02f,
  5.45881018e-02f, 3.00543802e-03f, 2.67971084e-02f, -4.83580923e-04f, 4.13855389e-02f, 1.03464797e-01f, 9.80883464e-03f, -9.16057527e-02f, 4.48579788e-02f, 8.94278660e-02f,
  -1.09501323e-03f, -4.83127199e-02f, 7.84903392e-02f, 9.73153338e-02f, 3.26979645e-02f, -2.64992341e-02f, 1.43838553e-02f, 1.05914615e-01f, 7.69845471e-02f, -8.28557275e-03f,
  -2.28219014e-02f, -2.65679490e-02f, 4.94827963e-02f, -1.04186580e-01f, -3.46139795e-03f, -5.02681546e-02f, 3.06274518e-02f, 2.72534341e-02f, 1.44539773e-02f, 9.42817032e-02f,
  6.65509105e-02f, -1.70618683e-01f, -4.55755033e-02f, 1.03548527e-01f, 1.76397637e-02f, -2.52351426e-02f, -6.95738047e-02f, 3.52509134e-02f, -8.61532763e-02f, 5.16611859e-02f,
  8.23825002e-02f, 1.17451653e-01f, 2.30375435e-02f, -4.08873782e-02f, -7.74897486e-02f, 7.99256489e-02f, 2.46637631e-02f, 2.12753247e-02f, -4.89689149e-02f, -9.84173641e-02f,
  -7.73587599e-02f, -2.02403478e-02f, 9.73846763e-02f, 3.86870641e-04f, -4.42679189e-02f, 8.61641543e-04f, 7.67334774e-02f, 3.85427848e-02f, -3.67830023e-02f, -4.61348444e-02f,
  1.16976067e-01f, -2.08782986e-01f, 1.14246927e-01f, 3.88258472e-02f, 1.86295509e-01f, 7.00820759e-02f, 1.94331095e-01f, 2.75869649e-02f, -3.66499200e-02f, -1.08673207e-01f,
  1.01148792e-01f, -8.63681883e-02f, -3.78260436e-03f, 3.10465619e-02f, 1.95748419e-01f, 4.44653668e-02f, -4.84480113e-02f, -8.90582129e-02f, -9.04976483e-03f, -2.33528996e-03f,
  1.05703428e-01f, -7.47940764e-02f, 3.32883038e-02f, -6.44991919e-02f, 4.84045818e-02f, 2.65837982e-02f, 7.40416646e-02f, 1.09580688e-01f, 2.10016090e-02f, 1.91764697e-01f,
  -8.60395748e-03f, -1.04860216e-01f, -1.16026081e-01f, -5.52909672e-02f, -4.10904139e-02f, -3.44043151e-02f, 7.60480389e-02f, 6.35764077e-02f, -1.14877596e-01f, -1.99386328e-02f,
  -6.47297278e-02f, 5.66739477e-02f, 9.22032222e-02f, -9.84971412e-03f, -3.74735259e-02f, -1.27979890e-02f, -5.73212579e-02f, -5.19944541e-02f, 4.02610935e-02f, 1.68064460e-02f,
  -1.17685087e-02f, 2.52301767e-02f, -3.03707384e-02f, 4.49882001e-02f, -3.45473401e-02f, -3.38171013e-02f, 1.68839972e-02f, 8.64812583e-02f, -9.93655771e-02f, 5.94255095e-03f,
  1.31728634e-01f, 7.30540082e-02f, 1.59855653e-02f, -2.94349552e-03f, 7.24812075e-02f, 6.55120909e-02f, 6.12338744e-02f, 1.31597137e-02f, -2.55366601e-02f, 4.73266058e-02f,
  1.35773858e-02f, -2.93223094e-02f, 8.74058809e-03f, -3.82920019e-02f, -6.85032234e-02f, -1.62786730e-02f, -1.56193762e-03f, -7.47772679e-02f, -9.13822725e-02f, 2.99337897e-02f,
  -8.44425261e-02f, 2.72414312e-02f, -6.87605217e-02f, -1.79881451e-03f, -2.38614623e-03f, -3.83935450e-03f, -5.92552796e-02f, 6.01680540e-02f, -3.99863012e-02f, 6.99773356e-02f,
  -2.84069210e-01f, -2.29417995e-01f, -5.70036173e-02f, -7.94779211e-02f, -2.87056472e-02f, -1.15181454e-01f, 9.45887789e-02f, -3.03956103e-02f, -2.79550012e-02f, 9.47951302e-02f,
  -1.87293924e-02f, -7.46148676e-02f, -6.69943988e-02f, -3.21393609e-02f, -7.33877569e-02f, 2.45081037e-02f, -1.27773071e-02f, -1.08318791e-01f, -2.46295761e-02f, 3.29189003e-02f,
  2.70133633e-02f, 4.25179163e-03f, -8.03642161e-03f, 4.63410765e-02f, -6.44906387e-02f, 8.04227293e-02f, -1.04007050e-02f, 4.47486490e-02f, 6.39915885e-03f, -6.67087734e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  1.33847103e-01f, 1.88494086e-01f, -4.59911209e-03f, 2.34176382e-01f, 2.88722627e-02f, -2.04288438e-02f, 1.77211970e-01f, -5.42198196e-02f, 3.88765782e-02f, 4.99952286e-02f,
  1.39267519e-01f, 8.29340369e-02f, 1.48431391e-01f, 9.85174477e-02f, 1.38558045e-01f, 1.49243161e-01f, 3.62550244e-02f, -8.31631050e-02f, 1.15160353e-01f, 2.09945276e-01f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  2.12765470e-01f, 3.65018547e-02f, 6.58039097e-03f, 2.22081184e-01f, -1.13677755e-01f, 1.88260615e-01f, -2.38869399e-01f, -3.23547050e-02f, -2.12033421e-01f, -1.52304292e-01f,
  -1.31142467e-01f, -1.02405697e-01f, 4.75976542e-02f, -1.96047202e-02f, 3.16398144e-02f, -1.04795776e-01f, -5.07028177e-02f, -1.23965971e-01f, -1.01704501e-01f, -1.33052319e-01f,
  1.90440789e-01f, -1.92368299e-01f, 7.80061334e-02f, 1.34973109e-01f, -1.31369485e-02f, 2.84683164e-02f, 1.41897336e-01f, 1.21580631e-01f, -3.30906920e-02f, 3.22865546e-02f,
  -2.92123929e-02f, -4.58927155e-02f, -1.32497400e-01f, 1.82604775e-01f, 6.83740079e-02f, -1.90308318e-01f, -1.25835687e-01f, 5.73588163e-03f, 1.24915265e-01f, 1.27988607e-01f,
  1.75099701e-01f, -1.86423417e-02f, -9.26969722e-02f, -1.20327801e-01f, 1.39738470e-01f, -2.69762903e-01f, -5.83503097e-02f, -1.24886438e-01f, 2.49198452e-02f, 9.78043973e-02f,
  -1.46810994e-01f, -3.88143621e-02f, -1.40383705e-01f, -9.61729139e-02f, 1.61007628e-01f, -1.20531186e-01f, 1.21311970e-01f, 1.64406635e-02f, 8.56587961e-02f, -2.08401866e-02f,
  1.61429778e-01f, 1.36251763e-01f, -1.66600436e-01f, 1.12129375e-01f, 1.13670729e-01f, 1.51864868e-02f, 8.94569531e-02f, -2.31881216e-02f, 1.28369331e-01f, -9.57649872e-02f,
  2.92222887e-01f, 8.28562677e-02f, 2.25941569e-01f, 1.46744668e-01f, 2.47976854e-02f, 7.25566968e-02f, -1.86032295e-01f, 7.68580139e-02f, -9.83262714e-03f, -2.87271272e-02f,
  -2.08542515e-02f, -6.25713319e-02f, -2.50063807e-01f, -5.41901067e-02f, -1.24143548e-01f, 2.88735088e-02f, 2.07398519e-01f, 1.69866726e-01f, -2.60831211e-02f, -1.28797274e-02f,
  1.25491396e-01f, 9.30376649e-02f, 9.56750065e-02f, 7.89376348e-03f, -1.56286836e-01f, -1.78512186e-01f, -1.18499413e-01f, 1.29846126e-01f, -1.21974312e-01f, 2.46240888e-02f,
  3.83986309e-02f, 1.84163451e-01f, -1.97286487e-01f, -1.24445707e-01f, -1.38991714e-01f, 1.16116151e-01f, -1.77246809e-01f, -2.46164054e-01f, 2.35977888e-01f, 8.58222414e-03f,
  -1.11268014e-01f, -1.67632043e-01f, -1.42047703e-01f, -1.35308921e-01f, 1.45614907e-01f, -1.95068136e-01f, -6.66659847e-02f, -2.06606850e-01f, -2.53814131e-01f, -2.70637363e-01f,
  4.77752350e-02f, 1.46759227e-01f, 3.78011093e-02f, 1.62816957e-01f, -1.78709298e-01f, -3.52737829e-02f, 2.24653855e-01f, 2.22613290e-01f, -1.75860420e-01f, -1.25587881e-01f,
  -7.70029947e-02f, 9.16292667e-02f, 1.90529719e-01f, -6.98843524e-02f, 1.39903538e-02f, -2.25876823e-01f, 9.00010020e-03f, 1.15913674e-01f, 2.56191045e-01f, 1.84421286e-01f,
  -2.53471643e-01f, 3.28736976e-02f, 2.91141450e-01f, 3.63972336e-01f, 2.16889083e-01f, 4.78503145e-02f, 3.96056212e-02f, -1.28858000e-01f, 4.00169427e-03f, 2.62546301e-01f,
  7.37683699e-02f, -5.15836384e-03f, -2.49788284e-01f, 1.31319791e-01f, 7.83952512e-03f, -2.59490192e-01f, 1.98141143e-01f, 1.66726306e-01f, -2.68479377e-01f, -1.66160241e-01f,
  9.25146341e-02f, -2.30198458e-01f, 1.64927944e-04f, 1.67227700e-01f, -2.76269168e-01f, 1.97207272e-01f, -1.19106412e-01f, 5.03044650e-02f, -1.42281622e-01f, -2.79505610e-01f,
  -9.11189765e-02f, 1.25328168e-01f, -1.69998482e-01f, 2.17084661e-01f, -6.69605955e-02f, -4.70812544e-02f, -9.65234339e-02f, 2.08744369e-02f, -3.19165476e-02f, -1.82417184e-01f,
  1.95943922e-01f, -2.50404269e-01f, -2.14670315e-01f, -1.44322738e-02f, -1.18511878e-01f, 1.57341018e-01f, -3.43302973e-02f, 1.11261606e-01f, -1.66125059e-01f, 5.66380583e-02f,
  8.58267322e-02f, 1.44249111e-01f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  3.70795697e-01f, 3.70147228e-01f, 1.19753398e-01f, 3.08953583e-01f, -7.57783949e-02f, 3.40812325e-01f, -1.52036041e-01f, 2.20417142e-01f, -5.29852062e-02f, -1.06139667e-01f,
  -4.21399236e-01f, -2.06325933e-01f, 1.13545969e-01f, -1.54848799e-01f, 6.15194887e-02f, -9.14794654e-02f, -1.28459990e-01f, 1.75120041e-03f, 1.46764383e-01f, -5.48485070e-02f,
  -1.29664555e-01f, -7.78597370e-02f, -9.15148929e-02f, 1.42198831e-01f, 3.61832649e-01f, -1.46623731e-01f, 2.69647986e-01f, -1.15117714e-01f, -6.93027899e-02f, 1.37219831e-01f,
  -7.71624744e-02f, 5.61351366e-02f, 3.33254188e-01f, -4.58801799e-02f, -7.68594490e-03f, 3.27809304e-01f, -1.80570230e-01f, 1.63521722e-01f, -1.83116883e-01f, 1.00063168e-01f,
  -6.10267231e-03f, -1.49240419e-01f, -1.67562962e-01f, -9.06273052e-02f, -2.12476850e-01f, 4.34772462e-01f, 1.98054928e-02f, -1.25944009e-02f, 1.49619933e-02f, 9.68926921e-02f,
  -1.07207946e-01f, -6.65850267e-02f, 6.05621026e-04f, -1.73633888e-01f, 8.89363978e-03f, 1.65803745e-01f, 8.14606696e-02f, 1.85705304e-01f, -1.88463144e-02f, 1.58302173e-01f,
  6.49463609e-02f, 7.10296929e-02f, -8.00465792e-02f, -7.39438236e-02f, -7.20885694e-02f, 1.85575768e-01f, 7.38442689e-02f, 1.98905736e-01f, 1.02703929e-01f, -9.94092785e-03f,
  -8.66570137e-03f, -2.11919248e-01f, -5.78617677e-02f, -1.44019797e-01f, 2.02761456e-01f, 2.24914357e-01f, -1.34609595e-01f, -5.37229665e-02f, 8.35213345e-03f, 6.12549148e-02f,
  -6.67818189e-02f, -1.75787807e-02f, 3.14223886e-01f, 1.07088402e-01f, 1.76222194e-02f, 3.81512940e-01f, -1.28920734e-01f, 2.23340094e-01f, -1.55124009e-01f, 2.43311711e-02f,
  -1.94783267e-02f, -1.29507512e-01f, 1.15640290e-01f, 1.88937992e-01f, -8.23824927e-02f, 1.44895464e-01f, 6.71403036e-02f, 4.33373712e-02f, 1.10728681e-01f, 4.89942841e-02f,
  7.03714490e-02f, 1.60748422e-01f, -1.04133055e-01f, -7.74395391e-02f, -8.66966620e-02f, 2.01637093e-02f, -1.43742070e-01f, -1.82689071e-01f, -1.75853774e-01f, 1.14135750e-01f,
  -9.13586169e-02f, 9.81003642e-02f, 8.58982652e-02f, -8.12570974e-02f, -9.36791450e-02f, 1.75472647e-01f, -9.35121551e-02f, 4.66308789e-03f, 2.80016154e-01f, -5.31016625e-02f,
  1.35089591e-01f, 3.51765528e-02f, 2.58945674e-01f, -8.91849920e-02f, -7.65774846e-02f, -1.67749494e-01f, 1.74690485e-02f, 1.45912617e-01f, 1.77854583e-01f, 3.41995150e-01f,
  1.19558483e-01f, 3.31589356e-02f, 2.54181951e-01f, 1.01051934e-01f, 4.46609333e-02f, 1.72712147e-01f, 6.09978549e-02f, 1.37583837e-01f, 6.87609315e-02f, -3.83598834e-01f,
  -1.39355389e-02f, -2.06392035e-01f, 6.34848401e-02f, -2.23423123e-01f, 1.38515115e-01f, 9.13903788e-02f, -1.96877182e-01f, 1.11091055e-01f, 1.30519316e-01f, -8.59318897e-02f,
  2.83854514e-01f, -8.97365436e-02f, 1.07489735e-01f, -1.69234857e-01f, 2.70042151e-01f, 7.24385381e-02f, 1.41972885e-01f, -1.09364964e-01f, 9.38021690e-02f, 1.52593195e-01f,
  4.16618064e-02f, 2.42210478e-02f, 4.85524647e-02f, 1.97765514e-01f, 2.83526003e-01f, 2.29716562e-02f, 2.64160722e-01f, -3.02601069e-01f, 2.28237748e-01f, 1.26710376e-02f,
  2.51617849e-01f, 2.85270482e-01f, -1.08072624e-01f, 2.19693497e-01f, 1.08708829e-01f, 3.77659947e-01f, 3.30776006e-01f, -3.67225148e-02f, 2.42865995e-01f, 2.18921274e-01f,
  -2.05135852e-01f, 2.76025593e-01f, 2.49610022e-01f, 3.26853812e-01f, 1.45072728e-01f, 2.04678625e-01f, -1.86768860e-01f, -2.91455656e-01f, 2.72599131e-01f, -2.57150060e-03f,
  7.18170404e-02f, -2.52160907e-01f, -5.27222008e-02f, 1.51825696e-01f, 1.73408881e-01f, -1.70796029e-02f, 3.68857831e-01f, 2.19906867e-01f, -1.83817908e-01f, -1.87242135e-01f,
  -5.63944876e-02f, 6.21393993e-02f, 6.62539750e-02f, 4.62536514e-02f, 2.32463971e-01f, -8.74782726e-02f, 3.66643578e-01f, 6.13386594e-02f, -5.79728596e-02f, -1.76702827e-01f,
  4.12473440e-01f, -1.06496930e-01f, 6.49259388e-02f, 3.09160918e-01f, -2.10111484e-01f, 2.16296390e-01f, -1.78981468e-01f, 2.30182767e-01f, -1.54808778e-02f, 3.39806348e-01f,
  1.58085108e-01f, -7.61851296e-02f, 3.48422453e-02f, 8.32654312e-02f, -8.13715383e-02f, -1.94416076e-01f, 1.31686583e-01f, 2.96286345e-01f, -8.53512529e-03f, -8.53815153e-02f,
  -7.42311031e-02f, -3.35931145e-02f, 2.52243541e-02f, -2.23158330e-01f, 2.24619955e-01f, -2.90929317e-03f, -1.69760779e-01f, 4.01729703e-01f, 2.34269366e-01f, 2.86074191e-01f,
  8.29334110e-02f, -1.70221373e-01f, -9.37467292e-02f, -2.00719118e-01f, 3.18834245e-01f, 4.82283086e-02f, -1.39301866e-01f, 2.55413264e-01f, 4.98369895e-03f, 2.84482464e-02f,
  -1.88357338e-01f, 1.96231842e-01f, 1.32498533e-01f, -5.16463295e-02f, 2.37569302e-01f, 9.51935127e-02f, -1.55709460e-01f, -4.68218848e-02f, -1.36459857e-01f, -3.48185264e-02f,
  1.03552558e-01f, -1.55654937e-01f, -4.14886326e-02f, 1.97519902e-02f, 1.08300574e-01f, -1.42534226e-01f, 4.12351973e-02f, 1.21889431e-02f, -1.71344072e-01f, -1.31347016e-01f,
  4.44096215e-02f, -1.08553477e-01f, -8.02173652e-03f, 8.49562809e-02f, -5.45559488e-02f, 1.14520237e-01f, 1.26074543e-02f, 9.92585346e-02f, 1.18521951e-01f, -7.09064007e-02f,
  -1.23644263e-01f, -1.45809844e-01f, 3.54538970e-02f, 2.22007707e-02f, -5.92548260e-03f, -1.59977060e-02f, -1.24125056e-01f, 4.32118662e-02f, 2.54945993e-01f, 1.79761738e-01f,
  2.32285142e-01f, 4.78431880e-01f, -1.39829023e-02f, 2.40468964e-01f, -5.54246902e-02f, -2.00281739e-01f, -7.26795867e-02f, -2.94525445e-01f, 1.51760519e-01f, 2.48151004e-01f,
  -2.70665377e-01f, 5.47568917e-01f, -1.90684929e-01f, 1.51752263e-01f, 1.32127494e-01f, -1.45890713e-01f, -1.30503729e-01f, -1.39729500e-01f, -5.90760298e-02f, -1.29548818e-01f,
  1.48262963e-01f, 2.21225172e-01f, 1.88941956e-01f, -1.22034967e-01f, -1.30928317e-02f, -1.73795432e-01f, 8.22332501e-02f, 1.06049135e-01f, 1.53335184e-01f, -1.30259037e-01f,
  -8.08104724e-02f, -4.97936085e-02f, -5.83607927e-02f, 6.96265250e-02f, -3.79954129e-02f, -1.30214527e-01f, 1.37550503e-01f, 4.74351011e-02f, 1.49769038e-01f, 1.79292843e-01f,
  8.63272026e-02f, 4.31791395e-02f, 9.42689776e-02f, -1.40838683e-01f, 6.12891167e-02f, -8.86127353e-02f, 1.10127151e-01f, -1.26752824e-01f, 2.56718099e-02f, -1.36592481e-02f,
  1.66154858e-02f, 1.63346678e-01f, 2.65984014e-02f, -1.04855508e-01f, -4.20938917e-02f, 4.38039117e-02f, 1.66091979e-01f, 1.46435827e-01f, -1.21823683e-01f, -5.69984578e-02f,
  1.63416997e-01f, 2.16254760e-02f, 2.62581855e-01f, 5.65639995e-02f, 1.45559624e-01f, 1.97654385e-02f, -1.20202281e-01f, 2.26680219e-01f, 1.08427696e-01f, 2.59135455e-01f,
  2.01640576e-01f, -8.14664960e-02f, 1.24600902e-01f, -1.75984353e-01f, -1.29443496e-01f, 4.40570921e-01f, -1.67605206e-01f, -9.30133685e-02f, -1.74285531e-01f, 2.91048996e-02f,
  1.07189804e-01f, 5.36759049e-02f, 7.24814758e-02f, 5.06894663e-02f, 1.69403106e-02f, -4.99766693e-02f, 3.16553190e-02f, -1.16777502e-01f, 1.35824248e-01f, 1.53909743e-01f,
  4.76893336e-02f, -4.02604714e-02f, -3.99639867e-02f, 1.39841169e-01f, 2.19325915e-01f, -1.28544392e-02f, 1.03738815e-01f, -1.32377038e-03f, 8.01509470e-02f, 3.01095080e-02f,
  -3.30578000e-03f, 8.09152797e-03f, -1.97780699e-01f, 2.10071541e-02f, 5.83845191e-02f, -1.72157943e-01f, 2.07599357e-01f, -9.95339006e-02f, 2.34785723e-04f, 1.86403513e-01f,
  -6.57899827e-02f, 2.10004687e-01f, 2.66572565e-01f, -1.24813467e-01f, 1.07206382e-01f, 3.85631919e-02f, -1.75415352e-01f, -9.34770927e-02f, -8.07761028e-03f, 1.61506966e-01f,
  -1.55780297e-02f, 2.39292711e-01f, -1.39895141e-01f, 9.11930427e-02f, 8.00259970e-03f, 2.71375895e-01f, 3.46040986e-02f, 3.53466868e-01f, 3.89861176e-03f, 2.54951835e-01f,
  -1.54621303e-01f, 3.21207047e-01f, -7.01444820e-02f, 5.86944334e-02f, -7.29162470e-02f, -1.10290997e-01f, -1.63965642e-01f, -1.64534505e-02f, -6.14991486e-02f, -2.33040303e-01f,
  1.00070640e-01f, -9.08297449e-02f, 2.59282649e-01f, 6.79356083e-02f, 3.40132974e-02f, 2.14065447e-01f, -1.02301829e-01f, -1.55400202e-01f, 2.14887470e-01f, -8.10244381e-02f,
  2.31655359e-01f, -1.22495316e-01f, 1.51991129e-01f, -6.45437092e-03f, -1.36390343e-01f, -1.30764052e-01f, 1.34350538e-01f, 4.83859852e-02f, 1.18269742e-01f, 1.54388711e-01f,
  -6.99785501e-02f, -9.73177608e-03f, 1.85563460e-01f, 1.51744545e-01f, -1.83661997e-01f, -1.86167479e-01f, 6.32570535e-02f, 1.59979668e-02f, 7.88826719e-02f, -3.64755690e-02f,
  -8.47879872e-02f, -5.74792884e-02f, 2.34649047e-01f, 1.55634835e-01f, 2.02713832e-01f, 5.37298582e-02f, 1.85945362e-01f, -8.22676346e-02f, -1.69650652e-02f, 1.88998520e-01f,
  -3.86901125e-02f, 1.29893541e-01f, -5.12688272e-02f, 4.59548943e-02f, -1.52314678e-01f, -1.12038471e-01f, -9.42686796e-02f, -9.02133361e-02f, 1.59973845e-01f, -1.35950044e-01f,
  9.55505949e-03f, 3.69021147e-01f, 3.06969285e-01f, -1.62972957e-01f, 3.86454612e-01f, -1.38118967e-01f, 7.42799416e-02f, 1.34657159e-01f, 9.83158313e-03f, 3.96738738e-01f,
  2.32543066e-01f, 3.57467011e-02f, 3.78220260e-01f, -3.72678846e-01f, 4.97151092e-02f, 2.59251408e-02f, 6.96664676e-02f, 1.18912041e-01f, -6.80359825e-02f, -2.96749268e-02f,
  5.40149398e-02f, 2.46090427e-01f, 8.14112090e-03f, 2.29484979e-02f, -2.06768975e-01f, 1.96165755e-01f, 1.92754507e-01f, 1.51390404e-01f, 3.84598086e-03f, 2.33951062e-01f,
  1.37641042e-01f, 2.97471881e-01f, -9.95305032e-02f, -1.47136331e-01f, 1.33272767e-01f, -1.30291477e-01f, 1.44465134e-01f, -5.00554405e-02f, -1.70624673e-01f, -1.24791086e-01f,
  -1.82343662e-01f, -5.78058697e-03f, 1.10831812e-01f, -1.59972697e-01f, 1.33787334e-01f, 9.74571183e-02f, 2.19228696e-02f, 2.01196715e-01f, -1.57944113e-01f, -1.24259122e-01f,
  8.28625411e-02f, -1.47817299e-01f, -1.46973506e-01f, -9.06184986e-02f, 1.25073195e-01f, -1.91185605e-02f, 6.22267500e-02f, 6.34428114e-02f, 1.14443041e-01f, 8.99128243e-02f,
  -1.18787147e-01f, -1.62221998e-01f, -6.11195453e-02f, -1.52324215e-01f, 3.59075367e-02f, 3.21122892e-02f, -7.67747164e-02f, 6.34720130e-03f, -1.54159172e-02f, -1.01800807e-01f,
  -7.49020576e-02f, -5.31156585e-02f, -7.09804520e-02f, -1.46226734e-01f, -3.81117873e-02f, 3.29088122e-02f, -7.77195990e-02f, 1.30034506e-01f, -3.70430574e-02f, -6.96283206e-02f,
  3.70215140e-02f, 5.05829230e-02f, -1.25331044e-01f, 2.72172913e-02f, 2.35942408e-01f, -1.10430613e-01f, -6.33497606e-04f, -1.50843328e-02f, -1.95793346e-01f, -1.56917959e-01f,
  -7.06620812e-02f, 1.14588765e-03f, -1.50171548e-01f, 4.81186435e-02f, 6.18146472e-02f, 9.57390219e-02f, 3.53569657e-01f, -5.83982021e-02f, -8.44714195e-02f, 3.75648052e-01f,
  1.25123382e-01f, 2.26779565e-01f, -3.84271055e-01f, -2.25929439e-01f, -3.81380767e-01f, -3.87373120e-01f, -2.83456564e-01f, 2.22076192e-01f, 5.91046587e-02f, 1.05817184e-01f,
  4.06430572e-01f, 1.25062823e-01f, -1.36884585e-01f, 1.32140175e-01f, 3.52652103e-01f, -6.24539405e-02f, 2.47217193e-01f, -4.21806686e-02f, -3.29854190e-01f, -1.69826418e-01f,
  7.52021000e-03f, 1.90444037e-01f, -1.64244160e-01f, 1.94742501e-01f, -1.68790415e-01f, 7.87462965e-02f, 2.92436868e-01f, 3.26776445e-01f, 1.87315077e-01f, 3.58026505e-01f,
  3.15833300e-01f, -3.96770351e-02f, 2.41287515e-01f, 1.54309556e-01f, 3.72179002e-02f, -1.13339320e-01f, 8.88229832e-02f, 4.17862892e-01f, -1.62266254e-01f, 8.37547630e-02f,
  3.98340106e-01f, -4.63815808e-01f, 3.19625102e-02f, -7.89842904e-02f, 2.83169389e-01f, 2.31192216e-01f, -6.83240369e-02f, 9.20679793e-02f, -1.51977926e-01f, 1.48555741e-01f,
  9.10117552e-02f, -1.16240308e-01f, -1.14689574e-01f, 1.07841395e-01f, 6.64042979e-02f, 1.23963676e-01f, 2.25668356e-01f, 5.40123656e-02f, 4.40762788e-02f, 1.94323480e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  5.29963076e-02f, 1.25739858e-01f, 1.01144396e-01f, 2.20265940e-01f, 6.99478760e-02f, 9.60737765e-02f, 2.68546164e-01f, 2.49216765e-01f, -1.68925628e-01f, 2.37153277e-01f,
  -5.84737808e-02f, -2.72707231e-02f, 1.15214773e-01f, 1.79026350e-01f, -7.62824565e-02f, 2.78445650e-02f, -7.05123693e-02f, 1.71869829e-01f, 3.64902496e-01f, 3.26910689e-02f
};

// L2_fan_Wp (Shape: 6 x 32)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -7.61121958e-02f, -2.72981729e-02f, -6.49188682e-02f, -1.62924193e-02f, -1.38576210e-01f, -3.90474312e-02f, 3.05938702e-02f, 9.49859545e-02f, -4.47704755e-02f, -2.56927609e-01f,
  2.51280129e-01f, -9.38091129e-02f, -1.05019905e-01f, 9.72630363e-03f, -7.21853599e-02f, 1.08595073e-01f, -1.61719188e-01f, 3.24532658e-01f, -1.71160161e-01f, -1.79816380e-01f,
  -1.23199970e-01f, 2.96150655e-01f, -1.01712681e-01f, -2.37227067e-01f, -3.28114741e-02f, 2.15231985e-01f, 1.87798142e-01f, -1.14674993e-01f, 4.19655852e-02f, -6.98539317e-02f,
  -8.65651295e-02f, -1.32411793e-01f, 2.03551337e-01f, -1.33514702e-01f, 9.65595320e-02f, -3.69533785e-02f, 1.96166828e-01f, -1.45720422e-01f, -6.07643388e-02f, 8.81059468e-02f,
  2.04718471e-01f, -2.79945970e-01f, 2.32396483e-01f, -2.08670095e-01f, 6.17475659e-02f, -1.47763165e-02f, 2.34821945e-01f, -4.34946381e-02f, -2.07161292e-01f, 3.47222924e-01f,
  -1.77254289e-01f, -2.02168211e-01f, -4.82409447e-02f, 2.97906637e-01f, -1.93834141e-01f, 8.21804330e-02f, -2.46130288e-01f, 1.18165217e-01f, 1.81432460e-02f, 7.07788095e-02f,
  -1.56496361e-01f, -1.98636979e-01f, -1.85514405e-01f, -1.77342415e-01f, 2.00728357e-01f, 5.65730445e-02f, 1.32904932e-01f, 5.17348573e-02f, 1.25770643e-01f, 5.90474978e-02f,
  -1.25814766e-01f, 6.64910302e-02f, 1.27727851e-01f, 1.45352241e-02f, 2.20830470e-01f, -2.86733747e-01f, 1.97289288e-02f, -9.84635800e-02f, 1.75538719e-01f, -1.21898361e-01f,
  -1.25031844e-02f, 6.36568442e-02f, 1.52670041e-01f, -2.57662624e-01f, 4.91566136e-02f, -3.31090122e-01f, 5.78366965e-03f, -1.82555333e-01f, 7.32315630e-02f, 9.62281153e-02f,
  -5.05062006e-02f, 1.78600907e-01f, -8.57347921e-02f, -2.19496316e-03f, -2.93515265e-01f, 4.09928322e-01f, -8.93740579e-02f, 1.75434314e-02f, -9.27074999e-02f, -1.19203269e-01f,
  -1.52509212e-01f, -6.12231120e-02f, -2.87171733e-02f, -9.95933115e-02f, -4.79959324e-02f, 7.18598142e-02f, 3.43728289e-02f, 7.57512227e-02f, -1.89936742e-01f, -8.20353478e-02f,
  1.48759037e-01f, -1.49079084e-01f, -4.22561802e-02f, 1.80207819e-01f, 2.01803014e-01f, 5.42229414e-02f, -4.25796248e-02f, 1.55019239e-01f, 1.50013268e-01f, -1.52328029e-01f,
  -1.35922700e-01f, -2.06793740e-01f, -1.25610441e-01f, 2.22611487e-01f, -1.64647549e-01f, 6.96105063e-02f, -1.13016233e-01f, -7.31098577e-02f, 2.19524801e-01f, 2.28434533e-01f,
  1.55287683e-01f, 4.72647063e-02f, 1.89822778e-01f, 1.55248458e-03f, 3.84334810e-02f, 1.49094403e-01f, 2.84994543e-01f, -3.40926200e-01f, 1.08746596e-01f, -5.30261397e-02f,
  9.02169049e-02f, 4.54662405e-02f, 1.15554653e-01f, 1.68404371e-01f, 4.33460958e-02f, 1.80379167e-01f, -5.09570166e-03f, -4.80704904e-02f, 1.57200307e-01f, 1.50600120e-01f,
  1.23301357e-01f, -1.52648121e-01f, -1.47790819e-01f, -2.01925691e-02f, 3.23689543e-02f, 1.81434691e-01f, -5.86331338e-02f, -1.37092710e-01f, -4.31431085e-01f, 1.84877664e-01f,
  -5.56800924e-02f, 1.16254859e-01f, -1.37558496e-02f, 4.17978922e-03f, 1.07319050e-01f, -2.06456967e-02f, 5.11862822e-02f, -7.99362659e-02f, 1.57264963e-01f, 4.96186223e-03f,
  -2.40168869e-01f, 2.10975826e-01f, 2.83036172e-01f, 2.50023156e-01f, -9.69345346e-02f, 7.16765551e-03f, -1.79891661e-01f, 2.10360903e-02f, -2.68237531e-01f, -1.03556521e-01f,
  9.09836590e-02f, 2.12669492e-01f, -1.26518726e-01f, 1.39573857e-01f, -9.45450068e-02f, -4.22281511e-02f, -2.05443025e-01f, -2.15720549e-01f, -1.36049092e-01f, 9.23169404e-02f,
  1.19456694e-01f, -1.70103073e-01f
};

// L2_fan_Wp_bar (Shape: 20 x 32)
const int L2_fan_Wp_bar_rows = 20;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  3.29406679e-01f, 6.83642775e-02f, 2.95301676e-01f, 2.02634349e-01f, 2.61167973e-01f, 2.10509539e-01f, -7.66753927e-02f, -8.91268626e-02f, 1.66239902e-01f, -4.26037997e-01f,
  2.49159262e-01f, 1.06824718e-01f, 2.56904997e-02f, 3.75639379e-01f, 3.60990651e-02f, 2.62358785e-01f, -6.34426251e-03f, 4.71141547e-01f, -3.96514647e-02f, 4.45994377e-01f,
  -1.08999655e-01f, 5.10047853e-01f, -5.28445058e-02f, 2.48181760e-01f, -1.26285419e-01f, -1.33166999e-01f, 7.33527020e-02f, -1.28148599e-02f, 4.23948355e-02f, 1.49610296e-01f,
  -1.97943002e-01f, -1.00961372e-01f, -7.89265111e-02f, 1.08994715e-01f, 1.68163136e-01f, 1.28618069e-02f, 1.09258071e-02f, -9.89347324e-02f, 1.10719865e-02f, -7.17876526e-03f,
  2.54551712e-02f, -2.87393540e-01f, 3.46637100e-01f, -1.74646184e-01f, 1.24440938e-01f, -2.08027840e-01f, 6.40127510e-02f, 8.51298869e-03f, -1.60668150e-01f, 3.39475185e-01f,
  7.20955357e-02f, 1.11064836e-01f, 5.80952652e-02f, -6.73159584e-02f, -1.08470090e-01f, 2.08559725e-02f, -5.16192466e-02f, 1.92638442e-01f, 3.54412049e-02f, -1.53933972e-01f,
  1.53143391e-01f, 6.18909001e-02f, 1.44118100e-01f, 1.88215166e-01f, -3.54096740e-02f, -1.80053011e-01f, -1.00264691e-01f, 1.09160662e-01f, 1.36467576e-01f, -5.28091937e-02f,
  -1.30429521e-01f, -1.67141959e-01f, 1.14627918e-02f, 1.38404835e-02f, -7.28695467e-02f, 9.72380489e-02f, -5.59392245e-03f, 6.68975785e-02f, -6.12551998e-03f, 4.11037877e-02f,
  -1.78635433e-01f, -6.37018532e-02f, 1.93381250e-01f, -1.35975927e-01f, -1.28028601e-01f, 1.09867349e-01f, -2.28159484e-02f, -9.68511552e-02f, 2.70174295e-02f, 9.40344259e-02f,
  8.64347816e-02f, 7.89339021e-02f, -2.52038781e-02f, -1.50251716e-01f, -3.89435850e-02f, 1.04587153e-01f, 2.51740813e-01f, 2.85639137e-01f, 3.29297870e-01f, 1.65050149e-01f,
  1.96562991e-01f, 3.67461741e-01f, 8.45817178e-02f, 2.26552159e-01f, -1.53136343e-01f, 4.28158313e-01f, -8.79948363e-02f, -2.64512420e-01f, 4.26390350e-01f, -1.68122843e-01f,
  1.68894902e-02f, 1.71836346e-01f, 4.72970426e-01f, -2.25888088e-01f, 1.42448589e-01f, -1.67385668e-01f, 1.52585641e-01f, -2.64845043e-01f, 1.02265790e-01f, 9.75465328e-02f,
  2.41770625e-01f, 1.82977989e-01f, 6.64308518e-02f, 4.99540359e-01f, -7.89092109e-02f, -1.90307230e-01f, 2.15476006e-01f, 5.26258051e-01f, 1.45609424e-01f, 1.07869782e-01f,
  -3.90210338e-02f, -2.54735835e-02f, -1.84591025e-01f, -1.47892132e-01f, -1.24504715e-01f, 1.66525003e-02f, -1.49067119e-01f, -3.31293382e-02f, 1.20757654e-01f, -1.35041595e-01f,
  -1.01991788e-01f, 3.09283044e-02f, 1.89618498e-01f, 1.12657376e-01f, 5.93770668e-02f, 6.66711703e-02f, 4.04978022e-02f, 7.09121302e-02f, 1.54088840e-01f, 9.58554596e-02f,
  1.56943709e-01f, 1.03907891e-01f, -1.10914059e-01f, 5.58785275e-02f, 1.09769516e-01f, -5.75050130e-04f, 1.37788221e-01f, -5.45023866e-02f, -9.10613760e-02f, -1.10296264e-01f,
  -8.48324820e-02f, -1.09115511e-01f, -3.61498669e-02f, -2.02607930e-01f, 6.04955815e-02f, -1.06321007e-01f, -1.75196826e-01f, 1.36730969e-01f, 8.52163732e-02f, -6.77124318e-03f,
  4.41152193e-02f, -4.61390018e-02f, -6.95429146e-02f, 8.96155089e-02f, -1.73682600e-01f, 7.15887100e-02f, 1.38855025e-01f, -1.13451980e-01f, -1.42808318e-01f, 8.14896673e-02f,
  8.82348940e-02f, -1.16021655e-01f, 5.92147298e-02f, 9.23194513e-02f, -1.08189270e-01f, -9.01913419e-02f, 1.58537775e-01f, 1.36252642e-01f, 2.77547091e-02f, 1.52004078e-01f,
  9.69834253e-02f, -1.43754080e-01f, 2.98140496e-01f, 1.78422809e-01f, 1.48019210e-01f, 2.68026948e-01f, 3.96330029e-01f, 9.61437747e-02f, 1.15656257e-01f, -9.72693339e-02f,
  3.71200621e-01f, -3.78824770e-01f, -6.74028546e-02f, -1.14847533e-01f, -2.21105982e-02f, 1.66565686e-01f, 7.28525743e-02f, 3.05782974e-01f, 2.67780542e-01f, 3.00722510e-01f,
  -1.72627062e-01f, 1.39271483e-01f, 1.08656280e-01f, 1.62446246e-01f, 2.59788986e-02f, 3.29079658e-01f, -1.42773628e-01f, 2.74276048e-01f, -1.66186646e-01f, -6.55374676e-02f,
  4.57519777e-02f, 2.65490636e-02f, -4.18875933e-01f, -2.41070073e-02f, 1.57962844e-01f, -9.72343236e-02f, 1.49435654e-01f, -8.31753090e-02f, -5.39135523e-02f, 1.08220108e-01f,
  7.21313199e-03f, -1.60406634e-01f, 2.14752182e-01f, -1.34264126e-01f, 7.34090805e-02f, 1.74866375e-02f, -1.02015324e-01f, 3.11404224e-02f, 5.51357493e-02f, 1.51673555e-01f,
  -1.07389487e-01f, 1.52480572e-01f, 5.91008812e-02f, 1.50087446e-01f, 1.56081736e-01f, 3.80546972e-02f, -1.16946451e-01f, 1.53926700e-01f, -1.83019847e-01f, -1.31175488e-01f,
  -6.44582808e-02f, 1.84196785e-01f, 2.92907506e-02f, 1.39194995e-01f, -3.99807096e-02f, 4.81732599e-02f, 5.04678711e-02f, 1.96367308e-01f, 2.57737726e-01f, 1.06572583e-01f,
  2.01655269e-01f, 2.14053571e-01f, 1.29401565e-01f, -1.48388259e-02f, 3.21604788e-01f, -2.40263827e-02f, 1.21662885e-01f, 5.78822419e-02f, -5.02046291e-03f, 1.20713525e-01f,
  -1.36082128e-01f, -3.49246226e-02f, -4.95247915e-02f, 1.56405121e-01f, -8.57885852e-02f, 2.17787370e-01f, -3.24159451e-02f, 4.53922778e-01f, 1.15829930e-01f, 1.84513465e-01f,
  -1.62699423e-03f, 5.43642491e-02f, -5.51126413e-02f, -4.77272943e-02f, -1.50183111e-01f, 1.70147315e-01f, -2.52363205e-01f, -4.06798422e-02f, 1.40366405e-01f, -1.31751239e-01f,
  -4.32966352e-02f, -8.45830366e-02f, 2.22204588e-02f, -6.15060665e-02f, 1.92795414e-02f, -1.24261998e-01f, 1.02384292e-01f, 9.70686749e-02f, 4.12866846e-02f, 1.60518438e-01f,
  9.03319847e-03f, -9.12750885e-02f, 1.26702629e-03f, -2.49037202e-02f, 7.97171220e-02f, -6.77739456e-02f, -1.60951868e-01f, -1.66950494e-01f, 1.59072459e-01f, -9.34596583e-02f,
  6.70187697e-02f, 4.28442284e-02f, -8.17643553e-02f, -7.79886618e-02f, -1.57133743e-01f, -1.74119174e-01f, -6.37534948e-04f, -1.40505970e-01f, -8.81894529e-02f, 4.95844670e-02f,
  2.65891831e-02f, 1.37603298e-01f, -1.03860021e-01f, -1.67168021e-01f, -1.43999457e-01f, 6.54118657e-02f, -8.57379362e-02f, -6.43378403e-03f, -1.12078249e-01f, 7.13126212e-02f,
  -5.11258282e-02f, -7.05466345e-02f, -1.56362876e-02f, 2.26308149e-03f, -1.07975435e-02f, 1.07280567e-01f, -1.69424757e-01f, 4.76112477e-02f, -1.04746275e-01f, -1.78554654e-02f,
  1.51654020e-01f, 1.19109906e-01f, 1.07326806e-01f, 9.68796462e-02f, 8.31078067e-02f, -1.21357709e-01f, 4.92039733e-02f, -1.35962591e-01f, 1.00492045e-01f, -1.75616339e-01f,
  -1.03311643e-01f, -1.39969230e-01f, -1.51171446e-01f, 3.64499576e-02f, -7.09599927e-02f, 1.46473810e-01f, 1.46747127e-01f, 2.33258471e-01f, 6.24929629e-02f, 1.22937098e-01f,
  6.80244938e-02f, 2.05145255e-01f, 5.49152121e-02f, 4.24725562e-02f, 2.19942078e-01f, 3.15204039e-02f, 1.33813947e-01f, 1.58665981e-02f, -4.83265147e-02f, -2.03780577e-01f,
  2.08330885e-01f, 7.36480355e-02f, -1.46462217e-01f, -1.42152578e-01f, -1.50678903e-01f, -9.27050933e-02f, 6.14463314e-02f, 9.58523750e-02f, 1.23102188e-01f, 1.76521331e-01f,
  1.67884916e-01f, -1.30514786e-01f, 1.57024443e-01f, 1.94910422e-01f, 2.16502398e-01f, 9.22690108e-02f, 2.38669544e-01f, 3.74109477e-01f, 1.97118327e-01f, 2.34679073e-01f,
  4.04191792e-01f, -1.46591008e-01f, -1.56628489e-01f, 2.58386493e-01f, -4.28622097e-01f, 4.20931250e-01f, 5.68279982e-01f, 5.16097367e-01f, 4.16622236e-02f, 1.41946658e-01f,
  -7.03212544e-02f, 9.73904058e-02f, 1.46773875e-01f, 1.65950164e-01f, -8.49732012e-02f, 4.35831219e-01f, 3.41652147e-02f, 1.21997125e-01f, 2.73883373e-01f, 3.68656844e-01f,
  2.82697082e-02f, -4.17538881e-01f, 4.60646674e-02f, -4.13373038e-02f, 8.61735880e-01f, -2.08963960e-01f, 7.45827407e-02f, -9.28172320e-02f, 8.44276920e-02f, 1.85134739e-01f,
  3.44381183e-02f, 2.65744716e-01f, 3.47875617e-02f, -3.52270424e-01f, -5.26814014e-02f, -1.22263841e-01f, 3.26254040e-01f, -7.75567070e-02f, -2.00427502e-01f, 1.00655831e-01f,
  2.96304822e-01f, -2.13374630e-01f, -3.02686989e-01f, 4.11444873e-01f, 3.37919384e-01f, 4.20020640e-01f, -1.55471221e-01f, 1.57440811e-01f, 1.43868238e-01f, -2.03224868e-01f,
  3.83167118e-02f, -2.63149381e-01f, 9.80684757e-02f, -6.36276156e-02f, 9.48947966e-02f, -7.61392014e-03f, 3.71857464e-01f, -2.42075458e-01f, 2.57871270e-01f, 7.09050149e-02f,
  1.90400422e-01f, 2.64592856e-01f, 2.62051791e-01f, 1.58161774e-01f, -1.43401185e-02f, 1.00135140e-01f, 1.76867843e-01f, -2.41094336e-01f, -7.91164041e-02f, -4.47905391e-01f,
  1.53571978e-01f, 3.95524092e-02f, 6.75882623e-02f, 1.24656178e-01f, 3.80612850e-01f, 1.55363962e-01f, 2.73921117e-02f, -2.91291147e-01f, -2.68457588e-02f, 4.56526503e-02f,
  8.45798180e-02f, 7.96177834e-02f, -8.55902657e-02f, 9.63958204e-02f, 1.42114371e-01f, 4.60683197e-01f, 1.47351012e-01f, 1.06597617e-01f, -4.25442547e-01f, 4.74583536e-01f,
  3.30758750e-01f, 2.91000623e-02f, 2.11526155e-01f, -3.50887119e-03f, 5.21128103e-02f, 1.72106951e-01f, -1.48621023e-01f, -1.47964731e-01f, 6.39717514e-03f, -1.18122406e-01f,
  2.85276949e-01f, -1.97611466e-01f, -2.09982127e-01f, -1.04630902e-01f, 3.71313483e-01f, -2.29699001e-01f, -2.62353539e-01f, 2.38112822e-01f, 6.98492527e-01f, 2.27962106e-01f,
  -1.46257907e-01f, 1.18081734e-01f, 3.05891968e-03f, -2.04071075e-01f, 3.13843936e-01f, -1.14054456e-01f, 2.48911664e-01f, 4.91297126e-01f, 7.33090611e-03f, -1.80844098e-01f,
  3.51988167e-01f, 5.22538573e-02f, 1.12862334e-01f, 7.89753534e-03f, 4.69283164e-02f, 8.50607604e-02f, 1.82557568e-01f, 6.51891306e-02f, -2.13020653e-01f, 2.98784971e-02f,
  1.52057856e-01f, -2.59187579e-01f, 2.50701874e-01f, -3.89977157e-01f, -1.12792835e-01f, 3.30951959e-02f, 1.05511777e-01f, -3.23722586e-02f, 1.58023313e-01f, 4.05761063e-01f,
  1.65146172e-01f, -8.47276226e-02f, 1.68498740e-01f, 1.45803303e-01f, 7.18978792e-02f, -1.66649014e-01f, -5.81239210e-03f, -8.03790763e-02f, 1.59981176e-01f, 6.55332282e-02f,
  4.28556390e-02f, 1.19007982e-01f, -1.13754161e-01f, 3.26420486e-01f, 2.01195523e-01f, 6.60007074e-02f, 2.70994585e-02f, 4.14593518e-02f, -1.29761204e-01f, -1.00470878e-01f,
  -1.63093969e-01f, 1.40740454e-01f, -1.58167079e-01f, -1.17223598e-01f, 1.73552945e-01f, 1.46099310e-02f, 1.39148980e-01f, -1.61868200e-01f, 1.63137600e-01f, -6.27366602e-02f,
  1.93954766e-01f, 1.94007829e-01f, 1.98884502e-01f, 1.59747396e-02f, -1.49604335e-01f, -1.74804285e-01f, -1.50920628e-02f, -1.13049164e-01f, 1.59535259e-01f, 3.97885554e-02f,
  2.02511087e-01f, 2.41484746e-01f, -1.07210770e-01f, -1.48729563e-01f, -5.06102331e-02f, 4.33562696e-03f, -5.67270927e-02f, 1.09553955e-01f, -9.10445489e-03f, -1.72143847e-01f,
  1.22443810e-02f, -2.83845365e-02f, 1.11650512e-01f, 1.01060010e-01f, 1.02333061e-01f, -1.62526950e-01f, 1.56402826e-01f, -8.33404157e-03f, -3.61467972e-02f, 1.02986708e-01f,
  1.65453538e-01f, -1.42470360e-01f, -1.36746928e-01f, 9.05453488e-02f, 1.34574426e-02f, -1.30025730e-01f, 3.60136293e-02f, -1.68347076e-01f, 1.36892840e-01f, 1.61652133e-01f,
  -1.39290895e-02f, -1.37788266e-01f, 7.28267282e-02f, -5.77700064e-02f, -6.26823679e-02f, 1.59679521e-02f, -1.40906543e-01f, 7.30506182e-02f, -3.44281644e-02f, 3.04057956e-01f,
  6.77850023e-02f, 1.12171113e-01f, 1.19853027e-01f, 2.13258803e-01f, 8.63937512e-02f, 1.80932581e-01f, -2.27192327e-01f, 1.88412204e-01f, -1.92046449e-01f, -2.56382138e-01f,
  4.96168971e-01f, -1.51776254e-01f, -2.64827013e-02f, 5.53992018e-02f, 2.74917632e-01f, -5.80272358e-03f, 5.71115687e-02f, -2.17348099e-01f, 1.05051860e-01f, 1.29244104e-01f,
  -1.22594209e-02f, -2.01298714e-01f, 9.66219530e-02f, 4.02461946e-01f, 9.82738733e-02f, 9.05489773e-02f, -3.29275355e-02f, -1.89434245e-01f, -4.76488695e-02f, 4.06098217e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 20)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 20;
const float L2_fan_Bp_bar_data[] = {
  2.38027692e-01f, 6.42793477e-02f, 7.79326335e-02f, 8.75567570e-02f, -1.77525710e-02f, -5.77186346e-02f, 3.29501331e-01f, 1.76231951e-01f, 2.65695453e-01f, 1.51219726e-01f,
  3.20253521e-02f, -1.21430300e-01f, 9.62088332e-02f, 3.93520221e-02f, 3.11889976e-01f, 2.28416234e-01f, 1.79743156e-01f, 1.95647031e-01f, -9.74522904e-02f, 2.39269599e-01f
};

// L3_fan_Wp (Shape: 6 x 32)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  4.18098047e-02f, 9.51082259e-02f, -2.49474466e-01f, 1.42320767e-01f, -7.08806515e-02f, 1.74583241e-01f, -2.20129922e-01f, -3.84783775e-01f, -3.05113960e-02f, -4.86402586e-02f,
  -2.70561188e-01f, -9.50442106e-02f, -5.69240674e-02f, 1.66313574e-01f, -5.48116937e-02f, 7.83539712e-02f, 6.35834411e-02f, 7.47145107e-03f, -1.33222699e-01f, -1.51850164e-01f,
  -2.45362729e-01f, -2.71437280e-02f, -4.01784442e-02f, 8.58069360e-02f, -7.94637129e-02f, 1.36346877e-01f, 7.47476965e-02f, 2.92139888e-01f, -6.77641034e-02f, 9.17431638e-02f,
  1.54669687e-01f, -2.41564155e-01f, 1.80311829e-01f, 2.91846335e-01f, -7.19809458e-02f, -1.48337111e-02f, -7.18897805e-02f, -2.80047301e-03f, -3.94593589e-02f, 1.67971238e-01f,
  2.67522000e-02f, -2.85727829e-01f, 1.70854092e-01f, 2.47417971e-01f, -8.18298236e-02f, 1.03592455e-01f, 1.67151038e-02f, -2.09174231e-01f, -1.67076916e-01f, -1.21849447e-01f,
  1.82406455e-01f, 9.97703616e-03f, 5.61114289e-02f, 6.80327555e-03f, 7.07133487e-02f, 1.18862428e-01f, 1.38429895e-01f, -3.57764781e-01f, 2.95546651e-01f, -3.88904691e-01f,
  6.35069236e-02f, 1.96163487e-02f, 1.70772895e-01f, 1.83991253e-01f, 1.85017318e-01f, 2.14193568e-01f, -1.09979957e-01f, 1.84234202e-01f, -1.07231908e-01f, 2.94433627e-02f,
  2.29417756e-02f, 4.52551425e-01f, -3.12091038e-02f, -1.29207522e-01f, 3.69927049e-01f, 1.17362618e-01f, 2.98946500e-01f, -7.24199116e-02f, 1.04665227e-01f, -9.02465209e-02f,
  -8.30121934e-02f, 1.55932382e-01f, 2.15527132e-01f, -1.00047857e-01f, 1.59162253e-01f, -1.56523272e-01f, 1.32627919e-01f, -1.05338871e-01f, -3.58163297e-01f, -3.12735066e-02f,
  2.22060308e-01f, 7.56319463e-02f, 2.61297435e-01f, -1.50288269e-01f, 1.38970628e-01f, 9.69551876e-02f, -4.00616005e-02f, 6.81562871e-02f, -1.03423866e-02f, 1.69630479e-02f,
  7.67282099e-02f, 1.83975786e-01f, 1.94577530e-01f, -8.53265598e-02f, -4.40790094e-02f, -4.90566082e-02f, 4.90157567e-02f, 2.27056935e-01f, -4.65025157e-02f, -5.85620888e-02f,
  -6.58922866e-02f, 1.37264863e-01f, -2.22998504e-02f, 1.33512184e-01f, -1.72428489e-01f, -1.49520770e-01f, -5.42805297e-03f, 1.28723860e-01f, 1.48548707e-01f, -1.53029323e-01f,
  4.29160327e-01f, -1.25892580e-01f, -1.47304296e-01f, -1.94348112e-01f, -1.98805109e-01f, -1.70084849e-01f, 1.19153477e-01f, 7.22796842e-02f, 7.15184957e-02f, -1.44451275e-01f,
  -3.17502357e-02f, -4.86916080e-02f, -5.25183044e-02f, 1.58653110e-01f, -4.17305017e-03f, 1.37569532e-01f, -1.37755066e-01f, 1.62467167e-01f, 8.98815393e-02f, -1.13795828e-02f,
  2.94847339e-01f, -2.98079252e-02f, -8.46062005e-02f, -2.14545354e-01f, 1.62957489e-01f, -7.41994753e-02f, 2.25503251e-01f, 2.01574743e-01f, 2.36032769e-01f, -4.81320359e-03f,
  -7.19167888e-02f, -1.85409591e-01f, -2.82992899e-01f, 3.86203900e-02f, -1.17946910e-02f, -1.51274540e-03f, 1.78269252e-01f, -1.09489188e-01f, -1.16879657e-01f, -3.42902094e-01f,
  4.26120088e-02f, -7.80075043e-02f, -1.39590487e-01f, 1.73525259e-01f, -3.10021769e-02f, 1.97814628e-01f, -1.72934860e-01f, -1.17086833e-02f, 1.06442168e-01f, 1.67821333e-01f,
  2.60976881e-01f, 2.49152388e-02f, -2.79166289e-02f, -1.15522422e-01f, 1.50776982e-01f, -2.17200771e-01f, 5.21763600e-02f, 1.70548156e-01f, 3.04499790e-02f, 1.69649020e-01f,
  2.09629938e-01f, 9.74814966e-02f, -1.49929330e-01f, -1.01331294e-01f, 4.77427151e-03f, 1.37560382e-01f, -6.99714273e-02f, 2.33656824e-01f, 1.13125168e-01f, 6.24806769e-02f,
  -1.01940066e-01f, -2.31455266e-01f
};

// L3_fan_Wp_bar (Shape: 20 x 32)
const int L3_fan_Wp_bar_rows = 20;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  1.43230021e-01f, -1.92510441e-01f, 8.74071717e-02f, 6.71413168e-03f, -6.25664890e-02f, -4.61046025e-02f, 1.71784028e-01f, 1.29697606e-01f, -2.59785116e-01f, 1.72580168e-01f,
  -1.26557514e-01f, 2.59412099e-02f, 3.27527702e-01f, -1.12135261e-01f, -1.06700331e-01f, -1.72412366e-01f, -2.58618407e-02f, 6.66015744e-02f, 2.32240632e-01f, 2.35117272e-01f,
  2.76619673e-01f, -7.79170021e-02f, 1.15392484e-01f, -3.92455840e-03f, 2.09843162e-02f, 8.89724568e-02f, -3.25066537e-01f, 1.39871776e-01f, 6.95098266e-02f, -2.62014754e-02f,
  -1.04113789e-02f, -1.64800271e-01f, -5.22198044e-02f, -2.93969244e-01f, 7.79042840e-02f, 1.43864691e-01f, 1.69065550e-01f, -6.92393556e-02f, 7.29144458e-03f, 2.87511852e-02f,
  2.66066045e-01f, 1.97760209e-01f, -7.44588971e-02f, -1.35561451e-01f, 8.34192708e-03f, 1.42905384e-01f, -2.12987475e-02f, 1.06240615e-01f, -1.36989117e-01f, 8.39340761e-02f,
  -1.50737584e-01f, 2.01734081e-01f, -8.73185545e-02f, 1.05308473e-01f, 1.66110024e-01f, 1.02345556e-01f, 6.57249317e-02f, 1.57510370e-01f, 1.19612724e-01f, 5.21147549e-01f,
  -2.73855422e-02f, 6.80730343e-02f, 4.53244522e-02f, 1.29345536e-01f, 7.65835643e-02f, 1.55207217e-01f, 5.78867495e-02f, -1.12335153e-01f, 1.52103469e-01f, -1.83041990e-01f,
  -2.03257408e-02f, 1.34222120e-01f, 1.07108220e-01f, 8.06008875e-02f, 5.16412519e-02f, -3.38708818e-01f, 2.68815756e-01f, 3.67974371e-01f, -1.23159416e-01f, -3.72529954e-01f,
  1.78856432e-01f, -2.67143361e-02f, -3.64242375e-01f, 7.49790519e-02f, -3.30885202e-02f, 5.11606298e-02f, 2.32850052e-02f, 8.04956779e-02f, 5.29146492e-02f, 7.23131299e-01f,
  -2.34897926e-01f, 7.72970438e-01f, 2.83960521e-01f, 1.90260291e-01f, 1.72189966e-01f, -4.46008801e-01f, -1.12465113e-01f, -8.96013528e-02f, -1.67210549e-01f, 1.46385729e-01f,
  -6.54901117e-02f, -6.05644435e-02f, 8.69970322e-02f, -2.98308562e-02f, -1.26528889e-01f, 1.74579099e-01f, -8.79855528e-02f, -7.15568149e-03f, -1.50375500e-01f, -6.35403916e-02f,
  -1.40181497e-01f, -6.22263961e-02f, -4.89583388e-02f, 7.33569562e-02f, 8.90861899e-02f, 4.93405424e-02f, -1.61816940e-01f, 1.08230494e-01f, -6.82644695e-02f, 3.48130018e-02f,
  -6.41250908e-02f, -1.07382936e-02f, 1.17180832e-01f, 4.40321900e-02f, -9.56698433e-02f, 1.38373122e-01f, 3.49531416e-03f, 1.05263172e-02f, -4.27446552e-02f, -4.76471819e-02f,
  -2.87574828e-02f, 1.34734079e-01f, -9.85735059e-02f, -1.53371587e-01f, 5.34705557e-02f, -8.70511308e-02f, -7.82442018e-02f, 1.60401225e-01f, 8.67817551e-02f, 8.46951827e-02f,
  -1.66418031e-01f, 2.64824666e-02f, -7.28215203e-02f, -3.26376176e-03f, 8.71706754e-02f, 1.43935487e-01f, -2.84690745e-02f, -4.61671427e-02f, 1.77931841e-02f, 7.89119601e-02f,
  3.39029878e-02f, 1.27588734e-01f, 2.57868823e-02f, -7.71144405e-02f, -5.90208173e-02f, 1.32423446e-01f, -1.19043328e-01f, -1.07872024e-01f, -4.75892648e-02f, -1.14431135e-01f,
  3.86364222e-01f, 2.23023921e-01f, -8.57026801e-02f, 8.89405832e-02f, -2.24789932e-01f, 2.00065970e-01f, 3.30387384e-01f, 4.39298421e-01f, 5.23162246e-01f, 4.76783179e-02f,
  4.52045679e-01f, -1.60467878e-01f, 4.10348445e-01f, 3.95748079e-01f, -1.18148454e-01f, 1.21234283e-01f, 1.16796650e-01f, 1.44235909e-01f, 5.98216474e-01f, 1.61779195e-01f,
  1.30588815e-01f, -9.54331011e-02f, -7.64822885e-02f, -2.40222692e-01f, -3.76341432e-01f, 9.20079723e-02f, 6.35016561e-01f, 3.25868428e-01f, 7.02838063e-01f, 2.64422953e-01f,
  6.93401024e-02f, 1.55647203e-01f, 1.76700559e-02f, -5.11580221e-02f, 1.51111990e-01f, 1.13612801e-01f, -9.26045850e-02f, -8.60254560e-03f, -3.73495780e-02f, 1.21798463e-01f,
  -2.85127878e-01f, 2.07608357e-01f, 1.78095981e-01f, 2.74487376e-01f, 4.19396937e-01f, -3.50576378e-02f, -1.60894945e-01f, -4.58257288e-01f, -2.87500732e-02f, 1.35136291e-01f,
  3.06846380e-01f, -6.13257959e-02f, 1.91216215e-01f, -7.19330683e-02f, 7.10044727e-02f, -6.54490516e-02f, 1.23392344e-01f, 2.79404879e-01f, 2.57399655e-03f, 1.27932906e-01f,
  2.08748803e-02f, -7.05324337e-02f, -5.08616716e-02f, -4.82828379e-01f, 7.53711760e-02f, -1.69814199e-01f, -8.90076533e-02f, -4.56773080e-02f, -1.26878247e-01f, -8.34141765e-03f,
  1.08039632e-01f, -1.64480105e-01f, 1.31973803e-01f, 4.12406661e-02f, -3.21667530e-02f, -6.08200841e-02f, 5.68942800e-02f, -4.25272956e-02f, -6.17052503e-02f, -1.70842066e-01f,
  1.95586868e-02f, 9.77448747e-02f, -6.37675077e-02f, 5.04970700e-02f, 1.62701994e-01f, -1.10402271e-01f, -9.27273184e-02f, -1.36970207e-01f, -4.53120247e-02f, -5.60742943e-03f,
  2.89523806e-02f, -1.22781135e-01f, -3.07039190e-02f, 9.76747796e-02f, 1.65394694e-01f, -6.68089464e-03f, 2.08180785e-01f, 1.36433184e-01f, 4.57901567e-01f, 1.31037414e-01f,
  2.40457624e-01f, 2.27624923e-01f, 1.76559445e-02f, -1.15995325e-01f, -6.34333551e-01f, -3.02598417e-01f, -1.70582443e-01f, 6.30006552e-01f, 7.52879918e-01f, 4.84153628e-02f,
  2.07638908e-02f, -2.45619103e-01f, -3.18795629e-02f, -4.18025032e-02f, 4.72253323e-01f, 1.46351084e-01f, 5.01872420e-01f, -1.52657390e-01f, -8.23824555e-02f, -4.79203127e-02f,
  1.15638697e+00f, 2.43325874e-01f, -1.87294781e-01f, -2.52348661e-01f, -2.84996748e-01f, -3.20479214e-01f, -8.93790498e-02f, -1.76834390e-01f, 6.68778941e-02f, -1.69877633e-01f,
  6.37333244e-02f, -9.82085839e-02f, 7.01802596e-02f, -4.58088964e-02f, -3.43080834e-02f, -1.05299458e-01f, -5.22182174e-02f, 7.93645009e-02f, 1.55664340e-01f, 1.15101650e-01f,
  4.89933826e-02f, -7.04778135e-02f, -2.93673668e-02f, 8.84290561e-02f, -9.78065655e-02f, -1.92188974e-02f, -5.23922872e-03f, -5.24159372e-02f, -1.31522149e-01f, 4.09827232e-02f,
  -3.05816289e-02f, -5.33561222e-03f, -6.64078742e-02f, 1.53951526e-01f, 1.20094255e-01f, -5.12729138e-02f, -4.67900634e-02f, -1.62914112e-01f, -1.50273755e-01f, -1.38911188e-01f,
  7.75460601e-02f, 1.68426201e-01f, 3.55771840e-01f, -5.75563032e-03f, 3.51261228e-01f, 1.37927057e-02f, -1.41277388e-01f, -1.33846059e-01f, 3.07812124e-01f, -1.89477608e-01f,
  2.62711853e-01f, 4.52312678e-02f, -2.56592900e-01f, -7.43297338e-02f, 1.76665679e-01f, 7.95316815e-01f, -8.87338594e-02f, 1.24424085e-01f, -1.55490354e-01f, -1.29275844e-01f,
  -6.06351811e-03f, -3.72854136e-02f, 3.03666983e-02f, 3.80109400e-01f, 5.75409412e-01f, -1.85668737e-01f, 2.61846930e-01f, 1.06221680e-02f, -2.78245024e-02f, -1.08252205e-02f,
  -4.96905185e-02f, 5.67529678e-01f, 3.36291939e-02f, 3.52850914e-01f, 2.20797043e-02f, 2.66638964e-01f, 3.51137877e-01f, 2.18598351e-01f, -5.16141474e-01f, -3.23449045e-01f,
  -2.65539810e-02f, -3.20743233e-01f, 2.98129916e-01f, 7.07321689e-02f, -1.54428959e-01f, -3.40338707e-01f, -1.31756380e-01f, 5.73996723e-01f, 1.04248986e-01f, 1.27775356e-01f,
  6.41036108e-02f, 3.02708652e-02f, 1.13515601e-01f, 5.53382486e-02f, -9.69407037e-02f, 1.32690715e-02f, 1.20281570e-01f, -2.96059906e-01f, 3.28786850e-01f, 1.70428809e-02f,
  -1.33341029e-01f, -1.33374885e-01f, 8.17750692e-02f, 7.85251558e-02f, 4.79038879e-02f, 1.19069785e-01f, -6.76856041e-02f, 1.31007126e-02f, -8.40072110e-02f, -6.29526302e-02f,
  8.59762505e-02f, -2.53954101e-02f, 1.46634951e-02f, 7.46551901e-02f, -3.13194133e-02f, -1.93797722e-02f, -1.91447623e-02f, 9.38198343e-02f, -3.90428444e-03f, 1.45787135e-01f,
  -7.01210424e-02f, -2.82836668e-02f, -6.18669800e-02f, -1.74477413e-01f, 2.87586488e-02f, -2.61829663e-02f, -1.06377989e-01f, -8.13913139e-05f, -7.58225918e-02f, 6.37749135e-02f,
  -1.64606094e-01f, -5.98517396e-02f, -1.31390125e-01f, -1.74170151e-01f, -1.29476443e-01f, -1.48468077e-01f, -1.68218762e-01f, 1.08164653e-01f, -1.04049705e-01f, -2.99980771e-02f,
  1.39634535e-01f, -1.32591113e-01f, 1.09482035e-01f, 8.53594244e-02f, -1.24483794e-01f, 6.30898103e-02f, -1.76099613e-01f, 1.24815710e-01f, -4.56473455e-02f, -7.83678293e-02f,
  5.75890616e-02f, -1.41062334e-01f, 3.28017399e-02f, 1.14804134e-01f, -6.66448995e-02f, -4.57552895e-02f, 3.77104580e-02f, 1.17543705e-01f, 8.57218876e-02f, -9.03216377e-02f,
  1.59104496e-01f, -8.45615752e-03f, -1.29199117e-01f, -1.00858212e-01f, 7.00002834e-02f, -6.37623668e-02f, 5.32886945e-02f, -4.54866402e-02f, 1.61275059e-01f, 8.67252878e-04f,
  2.20903888e-01f, 1.22453198e-01f, 2.64894459e-02f, 2.30376169e-01f, -1.56623259e-01f, 7.00031817e-02f, -3.11142653e-01f, -7.40865618e-02f, 8.46471414e-02f, -4.42101248e-02f,
  3.47554892e-01f, -2.49443352e-02f, 2.59057730e-02f, -1.35302469e-01f, 1.70868069e-01f, -5.05227223e-02f, -4.14091209e-03f, 2.08569333e-01f, 2.18085706e-01f, -1.67387664e-01f,
  -1.14467412e-01f, 1.21173605e-01f, 1.26096144e-01f, 1.91796601e-01f, -1.68993041e-01f, 1.18419357e-01f, 3.60463187e-02f, -1.38297334e-01f, -1.51013836e-01f, -2.39429355e-01f,
  4.88926955e-02f, -3.62102427e-02f, 1.09312072e-01f, 1.48693517e-01f, 2.66701788e-01f, 8.73895064e-02f, -1.40142813e-01f, -1.41506821e-01f, -1.41079262e-01f, -1.73870683e-01f,
  -3.24039191e-01f, 9.09060985e-02f, -1.46164909e-01f, -3.90713196e-03f, 1.31304204e-01f, 5.11242636e-02f, -1.36347100e-01f, -8.20695311e-02f, -9.32840630e-02f, 7.32361525e-02f,
  -2.57944643e-01f, 9.82304886e-02f, 8.30889940e-02f, 1.24529421e-01f, 7.37291694e-01f, 2.92719275e-01f, -3.88417482e-01f, 1.38618246e-01f, 6.61065355e-02f, 5.22079915e-02f,
  9.24956053e-02f, 2.21323147e-01f, -7.89171159e-02f, -1.53229013e-01f, -2.45997775e-02f, 1.07920915e-01f, -1.39364883e-01f, -7.71733969e-02f, 8.61628354e-02f, -1.19201533e-01f,
  -5.35598546e-02f, -7.13694319e-02f, -2.20192298e-02f, -3.50567931e-03f, 2.04742216e-02f, 5.51726781e-02f, -9.51134488e-02f, 1.25711754e-01f, 2.60033682e-02f, -1.00527368e-01f,
  -6.52203709e-02f, 1.59833491e-01f, -1.72662809e-01f, -1.03614569e-01f, -1.36031181e-01f, 6.91086426e-02f, -1.25289902e-01f, -6.96881190e-02f, 1.56322956e-01f, -1.17123164e-01f,
  1.20384507e-01f, 1.48862556e-01f, 1.19715091e-02f, -7.60036185e-02f, -3.07478644e-02f, 1.66239142e-01f, 4.65880930e-02f, 2.55024433e-01f, -7.75204599e-02f, 7.18773454e-02f,
  2.18051001e-01f, 2.12337309e-03f, 1.71766996e-01f, -5.46474494e-02f, 2.07885087e-01f, -2.47914895e-01f, 2.46338427e-01f, 1.72934636e-01f, -6.87877461e-02f, -4.91383821e-02f,
  -1.80962384e-02f, 7.19754621e-02f, 4.21820432e-02f, 3.35700847e-02f, 2.00390860e-01f, -4.94295470e-02f, -4.40332480e-03f, -1.61626916e-02f, -2.38766685e-01f, 1.90681428e-01f,
  1.38218656e-01f, 2.48932078e-01f, 1.03976063e-01f, 5.22818416e-02f, -1.34702727e-01f, -1.01352356e-01f, 2.14305386e-01f, 1.10887721e-01f, -8.77809897e-02f, -8.97032470e-02f,
  -5.70147112e-02f, -1.62961915e-01f, -2.34788835e-01f, 2.27652982e-01f, 3.26593995e-01f, -6.64969981e-02f, 3.77803475e-01f, -1.85979366e-01f, 2.80780047e-01f, -5.73259294e-02f,
  -5.39884605e-02f, 2.38424361e-01f, -1.22766197e-01f, -1.36760592e-01f, 4.47809339e-01f, 1.86228767e-01f, 9.38034207e-02f, 1.09195977e-01f, 8.80157650e-02f, 1.57112658e-01f,
  -3.10953170e-01f, -1.10854525e-02f, 5.87560594e-01f, -7.83220772e-03f, 1.80121005e-01f, 1.44382134e-01f, -7.12626427e-02f, 4.47262591e-03f, -5.53559251e-02f, 1.56049058e-02f,
  -7.62327537e-02f, 1.88875347e-01f, 2.66823024e-01f, 1.49421409e-01f, -1.74619332e-01f, -3.26738596e-01f, 2.27407873e-01f, 7.10798502e-02f, -5.40412366e-02f, -2.93543875e-01f,
  -2.46611521e-01f, -1.02454677e-01f, 1.29344329e-01f, 5.31589210e-01f, 4.61434536e-02f, 1.64762825e-01f, -4.15113151e-01f, -9.07753929e-02f, -1.90783590e-01f, 8.89944807e-02f,
  -1.26191199e-01f, 1.34319350e-01f, 1.17075555e-01f, 4.39856887e-01f, -1.04048409e-01f, 5.83077788e-01f, -7.17443526e-02f, 2.46646345e-01f, -8.47861320e-02f, 9.76947919e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 20)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 20;
const float L3_fan_Bp_bar_data[] = {
  4.80990969e-02f, 1.99963115e-02f, -1.38870448e-01f, 4.48134122e-03f, 1.22867174e-01f, 2.99696922e-01f, 1.48148254e-01f, -1.17543384e-01f, 3.68147552e-01f, -1.13777943e-01f,
  1.17628947e-01f, 8.54119807e-02f, -2.72807423e-02f, 9.93886888e-02f, 9.49757472e-02f, 3.46632823e-02f, 1.41697243e-01f, -3.70480455e-02f, 1.06192812e-01f, 7.34645799e-02f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  1.23223990e-01f, 6.99602738e-02f, -3.20790410e-01f, 5.48500381e-03f, 2.05879137e-01f, 2.21387133e-01f, -1.33369401e-01f, 4.73339736e-01f, -1.18812136e-02f, -2.81244010e-01f,
  3.67130250e-01f, -4.05494943e-02f, -1.09467179e-01f, -2.94571240e-02f, -2.27809250e-01f, -1.27278462e-01f, -3.55478227e-02f, 1.01283717e+00f, -1.89492464e-01f, 1.37093157e-01f,
  -6.96303248e-01f, -1.08870178e-01f, -4.57334369e-01f, -2.99606591e-01f, -1.40605286e-01f, 8.53294507e-02f, -3.56839597e-01f, -1.14549607e-01f, -5.36328629e-02f, 3.75132948e-01f,
  3.67366612e-01f, -4.08342600e-01f, -1.21485526e-02f, -1.35467395e-01f, -1.78880826e-01f, -4.79598582e-01f, 2.98487134e-02f, -2.53751308e-01f, 1.96987331e-01f, -2.38058731e-01f,
  1.30950689e-01f, -1.26074210e-01f, 4.39704329e-01f, -2.48772930e-03f, 2.67521679e-01f, 1.23079151e-01f, 6.32085323e-01f, -1.41603529e-01f, -1.72587782e-01f, 5.70218027e-01f,
  3.21221262e-01f, -7.28817508e-02f, -4.02049422e-01f, -8.53204429e-02f, -5.21867573e-01f, -2.46701032e-01f, 1.20643511e-01f, 1.61588237e-01f, 2.02555478e-01f, -3.66347492e-01f,
  -1.69644803e-01f, 2.13564143e-01f, 1.24512359e-01f, -2.03269511e-03f, -4.50140208e-01f, 9.64505747e-02f, 4.18214560e-01f, -2.42394924e-01f, -1.74266353e-01f, -2.33756691e-01f,
  1.89746514e-01f, -1.81669295e-01f, 1.02492787e-01f, -2.23122135e-01f, -2.76846200e-01f, 1.32919252e-02f, -2.79792637e-01f, 3.58707577e-01f, 6.02231026e-01f, 1.27083048e-01f,
  -1.76186129e-01f, 1.36885911e-01f, -1.37849733e-01f, -3.95669509e-03f, -7.01147676e-01f, 1.73070580e-02f, -1.01872116e-01f, -2.99090862e-01f, -7.42491931e-02f, -1.66931599e-01f,
  -1.49304137e-01f, 1.49828613e-01f, -1.78541511e-01f, -9.33528505e-03f, 5.13297170e-02f, 5.71628153e-01f, -2.52542526e-01f, -3.44436347e-01f, -3.71863455e-01f, 7.64471143e-02f,
  -2.12692935e-02f, 1.49302945e-01f, -2.98495859e-01f, 2.80279040e-01f, -4.19285670e-02f, 5.12695946e-02f, 4.90613282e-01f, 7.93056488e-02f, 2.03075826e-01f, -3.06288064e-01f,
  -5.78459024e-01f, 1.42746985e-01f, 1.41766042e-01f, 1.19544968e-01f, 4.55017209e-01f, -6.23459183e-02f, 6.23948812e-01f, 7.00841844e-02f, -2.73445398e-01f, 1.27329111e-01f,
  1.13464683e-01f, 1.20117128e-01f, 1.20583005e-01f, -4.26844895e-01f, -1.52133256e-01f, -1.15487635e-01f, 3.33669126e-01f, -1.39193669e-01f, 2.92451411e-01f, 8.96522310e-03f,
  -2.02213496e-01f, 2.77706057e-01f, 2.03706995e-01f, 4.41146344e-01f, 7.74841905e-02f, 2.52575874e-01f, 6.04021847e-01f, -3.31606388e-01f, -4.71091181e-01f, 1.09319292e-01f,
  -9.71723944e-02f, -1.44567922e-01f, -2.63323724e-01f, 1.66831627e-01f, -7.68177882e-02f, 2.64923841e-01f, -1.49009436e-01f, -5.36123812e-02f, -8.27014267e-01f, -1.76022947e-01f,
  3.50982398e-01f, 7.07281113e-01f, 1.52170852e-01f, 6.31484240e-02f, -1.35817751e-01f, -4.20655131e-01f, 4.90551889e-02f, -4.16112039e-03f, 5.85582674e-01f, 1.57412633e-01f,
  7.16086328e-02f, -2.28655517e-01f, -2.45429501e-01f, 3.57650578e-01f, 4.18253452e-01f, 2.22237885e-01f, -4.15853322e-01f, 2.05978274e-01f, 4.01885569e-01f, 8.11756179e-02f,
  -3.95709127e-01f, 8.41210224e-03f, -1.79128259e-01f, -8.46561790e-02f, -1.76073790e-01f, -1.08436212e-01f, -1.07595176e-01f, 5.83025753e-01f, -2.71585047e-01f, 8.13757628e-02f,
  1.82106629e-01f, -6.53498992e-02f, 3.99192750e-01f, -1.44938752e-01f, -1.50439978e-01f, 9.43272412e-02f, 5.44863306e-02f, 9.69782397e-02f, -1.84777483e-01f, -7.20484406e-02f,
  1.35765433e-01f, -2.38663882e-01f, 2.37399936e-01f, 3.85036409e-01f, 3.19903791e-02f, -1.46097124e-01f, -5.00497594e-02f, 2.96312749e-01f, -9.63748805e-03f, -3.31188329e-02f,
  -6.31609038e-02f, 3.47340912e-01f, -1.23351589e-01f, -3.08234096e-01f, -1.21647522e-01f, 1.29590884e-01f, -2.31096461e-01f, 1.70229927e-01f, -1.33071467e-01f, -7.34556079e-01f,
  -2.10076004e-01f, -4.86038625e-02f, 7.16652861e-03f, 3.18502299e-02f, 3.79607171e-01f, 2.82153308e-01f, 7.55290836e-02f, -2.70273928e-02f, -2.26011619e-01f, 6.60402536e-01f,
  -1.61138922e-01f, -6.10418878e-02f, -5.72434485e-01f, 4.56239909e-01f, 2.98905194e-01f, 2.81536728e-01f, 3.85578752e-01f, 1.76856086e-01f, 3.70362997e-01f, -9.42159817e-03f,
  4.13006186e-01f, -2.55335629e-01f, -4.02520537e-01f, 3.30112159e-01f, 6.64000809e-02f, 7.56649971e-02f, 1.71993986e-01f, -1.92569420e-01f, -1.65549830e-01f, 1.10734388e-01f,
  -1.52335778e-01f, -7.12964773e-01f, 7.03148618e-02f, -1.86209530e-02f, 8.73155475e-01f, -2.04228312e-02f, -4.39130455e-01f, 9.95396227e-02f, 1.42798841e-01f, 1.23356596e-01f,
  3.36553037e-01f, 3.05023611e-01f, -2.66235638e-02f, -3.13744515e-01f, -2.43455276e-01f, -2.71962341e-02f, -4.40280646e-01f, -2.56600708e-01f, -1.55155668e-02f, 1.19912378e-01f,
  6.50688931e-02f, 6.13468997e-02f, 2.90510803e-01f, -3.68607998e-01f, -5.03551602e-01f, -8.60524774e-02f, -2.55989879e-01f, -1.37089953e-01f, 2.70648003e-01f, -1.20180650e-02f,
  6.73396289e-01f, 2.31168605e-02f, -6.53514117e-02f, -3.11186850e-01f, 2.18467906e-01f, 1.29555210e-01f, 1.39751613e-01f, 1.82762165e-02f, -2.08747104e-01f, -4.81618166e-01f,
  1.16032504e-01f, -5.63878380e-02f, 2.57622480e-01f, 2.07030699e-01f, 1.64715245e-01f, 8.48719925e-02f, -4.00391310e-01f, 3.85016114e-01f, 7.26701096e-02f, 8.63489583e-02f,
  5.01711428e-01f, 3.53608400e-01f, 8.11092034e-02f, 6.88445345e-02f, 1.37131214e-01f, -1.88280925e-01f, -3.82125765e-01f, 1.33550107e-01f, -8.63850117e-02f, -1.00062281e-01f,
  -5.00459857e-02f, 3.35433394e-01f, -2.83984721e-01f, 9.76076648e-02f, -1.49185151e-01f, -2.52621591e-01f, -3.30083489e-01f, 1.73816442e-01f, -7.44988203e-01f, 7.44426250e-02f,
  6.50963962e-01f, 4.01138186e-01f, -1.24249514e-02f, -6.99868277e-02f, -1.25127643e-01f, -8.58651176e-02f, -8.67836326e-02f, -4.80230786e-02f, 8.31185281e-02f, 5.60481489e-01f,
  1.90523461e-01f, 2.87494212e-01f, -2.81170338e-01f, 4.27603126e-02f, -4.43021566e-01f, -4.97234166e-01f, -2.12596610e-01f, -3.67755651e-01f, 7.67727420e-02f, -1.64704978e-01f,
  1.92057714e-01f, 3.52006331e-02f, 3.68773073e-01f, 8.07685778e-02f, 2.67869264e-01f, 6.13946952e-02f, -1.19152315e-01f, -3.84111218e-02f, 5.61699927e-01f, 5.28748222e-02f,
  4.12132770e-01f, 4.76328097e-02f, -6.05343938e-01f, -3.91118646e-01f, 1.32226013e-02f, -1.02402531e-01f, 3.73513967e-01f, -1.69973880e-01f, 1.74860600e-02f, 2.30536982e-01f,
  -9.77265313e-02f, -2.40892097e-01f, 7.72454217e-02f, -3.39940220e-01f, 4.19762433e-01f, -1.80983528e-01f, -3.62060182e-02f, 2.31735617e-01f, -4.74730909e-01f, 4.35830414e-01f,
  9.83494446e-02f, 3.62829089e-01f, -4.25714076e-01f, -1.35941520e-01f, -1.69867441e-01f, -4.17455226e-01f, -1.88679755e-01f, -1.64826825e-01f, 7.25610852e-02f, -3.94181609e-01f,
  -1.26675829e-01f, -1.37035012e-01f, 6.75843000e-01f, 1.16709217e-01f, 4.34891105e-01f, 2.59128660e-01f, -5.83807230e-02f, 3.47599350e-02f, -8.16836879e-02f, 1.74257919e-01f,
  1.69286400e-01f, -3.13101768e-01f, -1.35475814e-01f, -4.22077566e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -2.57817823e-02f, -7.53320381e-02f, -4.63278405e-02f, 2.73487568e-02f, 1.31932586e-01f, 1.69424102e-01f, 1.07182153e-01f, 1.94774922e-02f, 1.19710770e-02f, 2.87294276e-02f,
  -1.21704422e-01f, 1.49142236e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    