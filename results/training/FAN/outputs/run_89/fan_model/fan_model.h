/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.08770031e-01f, -3.97518650e-02f, 2.79743578e-02f, -1.18400902e-01f, -7.81394243e-02f, -5.06161340e-03f, -7.59990439e-02f, -2.73067737e-03f, -1.20330052e-02f, -6.71764761e-02f,
  5.20903878e-02f, 9.26231965e-02f, 6.45640939e-02f, -1.69369690e-02f, 1.68862805e-01f, 1.02166906e-01f, -7.80822784e-02f, -7.64542297e-02f, -1.10258060e-02f, 3.53972102e-03f,
  -2.16293372e-02f, -3.98082770e-02f, 1.12569042e-01f, 4.48903218e-02f, -4.60251607e-02f, -2.70610806e-02f, 7.13979767e-04f, 6.57657385e-02f, -1.22332819e-01f, 2.21241415e-02f,
  8.11099336e-02f, 4.64134179e-02f, -2.39850348e-03f, -1.02567263e-02f, -2.56031076e-03f, -5.55199478e-03f, 2.24197772e-03f, 8.28547105e-02f, 4.03419174e-02f, 1.39654959e-02f,
  1.39493234e-02f, 5.89344762e-02f, -7.31163472e-03f, 5.11930557e-03f, 7.08302541e-05f, 7.56693259e-02f, 8.37534517e-02f, -2.93205567e-02f, -5.12984470e-02f, 3.12248003e-02f,
  -1.76683851e-02f, -6.06460199e-02f, -2.75061838e-03f, 1.12337889e-02f, -3.47443148e-02f, -1.71451475e-02f, 6.49163797e-02f, 1.35137858e-02f, 1.04727633e-02f, -1.47667164e-02f,
  -3.13416384e-02f, -2.60531250e-02f, 7.21791685e-02f, 6.55149817e-02f, 5.24699837e-02f, 2.78463420e-02f, 3.16389799e-02f, 2.44667232e-02f, -1.97113492e-02f, 1.11886393e-02f,
  -3.57737988e-02f, 1.54396975e-02f, -1.12359412e-02f, -1.66205934e-03f, -5.72171658e-02f, -3.88041958e-02f, -3.35902087e-02f, -1.45642005e-03f, -3.00331172e-02f, 6.30325731e-03f,
  2.44519580e-02f, 1.66100599e-02f, -2.22243033e-02f, -3.27251591e-02f, 4.56455983e-02f, 6.46021543e-03f, -3.97471618e-03f, -1.43392310e-02f, 8.05878639e-03f, -2.36463044e-02f,
  -7.56376311e-02f, 3.12144030e-03f, 4.58325297e-02f, 6.89309537e-02f, -3.84320645e-03f, 2.12763008e-02f, -5.44008575e-02f, -5.06193191e-03f, 6.13529794e-02f, -3.56208393e-03f,
  -4.71058264e-02f, 3.69049385e-02f, 1.89455338e-02f, -1.77039783e-02f, 1.94846094e-02f, 1.70174278e-02f, -4.22385633e-02f, 7.15474505e-03f, -1.83444973e-02f, -3.24528441e-02f,
  -6.21893555e-02f, -5.43736331e-02f, 1.70732681e-02f, -7.83764664e-03f, -6.24596812e-02f, 4.20561805e-02f, -3.06284707e-02f, -1.01891465e-01f, -5.37785888e-02f, 5.32844861e-04f,
  4.05125506e-02f, -2.84572333e-01f, -1.50875419e-01f, 2.94297133e-02f, 4.09630537e-02f, 1.38153702e-01f, 1.09416395e-01f, -3.24766971e-02f, 2.23899782e-01f, -1.44006267e-01f,
  1.16794318e-01f, -2.81965658e-02f, 6.35229871e-02f, 1.16451122e-01f, 2.96736628e-01f, 2.05570668e-01f, 1.05953805e-01f, 6.31202087e-02f, 1.42905846e-01f, -5.52277341e-02f,
  5.24670780e-02f, 1.61688149e-01f, 9.07459354e-04f, -5.53124063e-02f, -1.47093326e-01f, -1.61954567e-01f, -1.85696051e-01f, -7.03593194e-02f, -9.94395092e-02f, 8.57749302e-03f,
  9.01519358e-02f, 6.80157393e-02f, -3.52636240e-02f, -2.40006112e-03f, -5.37968762e-02f, -8.91115218e-02f, -2.33100858e-02f, -5.44217043e-03f, 6.55353516e-02f, -6.66466430e-02f,
  -2.64534410e-02f, -4.18719975e-03f, 6.76198900e-02f, 2.61510555e-02f, 2.01981515e-02f, 7.43212402e-02f, -2.21023168e-02f, -1.69425607e-02f, 2.50355829e-03f, 2.91627552e-02f,
  1.20415632e-02f, -2.77959052e-02f, -4.39863056e-02f, -1.35598499e-02f, -2.23216470e-02f, 4.69818301e-02f, -2.91805156e-02f, 6.02357881e-03f, 1.34414919e-02f, 5.46300299e-02f,
  -2.41763722e-02f, -4.95336019e-04f, -2.11944077e-02f, -1.75419822e-02f, 3.83279622e-02f, 3.18254605e-02f, -5.14099933e-03f, -5.36126122e-02f, 2.69367732e-02f, 4.79625398e-03f,
  -3.86366062e-02f, 2.42911745e-02f, 9.42068920e-02f, 1.28676789e-02f, 4.75589782e-02f, 1.54913617e-02f, -1.22310586e-01f, -1.28524713e-02f, 2.49981967e-04f, 2.25757919e-02f,
  4.24518548e-02f, -1.46412794e-02f, 2.71325205e-02f, -6.05078489e-02f, 3.75070982e-02f, -3.49124782e-02f, 4.23783772e-02f, 1.00759836e-02f, 3.23124975e-02f, -3.35490368e-02f,
  2.60291025e-02f, -1.20415702e-01f, 1.93939153e-02f, 4.07385528e-02f, 2.30885427e-02f, -3.40555375e-03f, 3.88407335e-02f, -4.68267463e-02f, -7.42988065e-02f, 3.10169123e-02f,
  -3.36855091e-03f, -3.98742780e-02f, -1.05307348e-01f, -3.34203541e-02f, -4.86278720e-03f, -5.28222099e-02f, -8.53755884e-03f, -1.15447640e-02f, -1.30350767e-02f, 5.62121719e-02f,
  -4.40410189e-02f, -1.64711736e-02f, 8.35091099e-02f, -3.36700678e-02f, -6.71525002e-02f, -5.96370511e-02f, -6.31836336e-03f, 3.61788180e-03f, -9.64769628e-03f, -2.20601745e-02f,
  1.60528645e-01f, -1.43167391e-01f, 3.43311615e-02f, 1.24346316e-01f, 7.99142793e-02f, -5.97553737e-02f, -2.11231828e-01f, 6.88628852e-02f, -1.03975989e-01f, -6.39156252e-02f,
  -2.20949873e-02f, -2.42526978e-01f, -1.38888404e-01f, 5.41864559e-02f, -4.30237129e-02f, -1.18701838e-01f, 3.28610353e-02f, -1.64176300e-02f, 1.25564551e-02f, 6.94491938e-02f,
  1.32856276e-02f, 9.72756520e-02f, -8.83325562e-02f, 4.54516597e-02f, 7.75527256e-03f, 7.46029094e-02f, 1.64840519e-01f, -2.99387928e-02f, 1.23311155e-01f, -5.83486743e-02f,
  -1.86706297e-02f, -9.30408612e-02f, -1.12238869e-01f, -1.79891440e-03f, -2.25425251e-02f, 6.71296800e-03f, 1.48948198e-02f, -1.75876357e-02f, 1.36049679e-02f, -8.34020376e-02f,
  3.51508940e-03f, -3.53313573e-02f, 2.22947206e-02f, 2.30245702e-02f, -1.65287033e-02f, -1.45525075e-02f, -1.08982287e-02f, 2.60486696e-02f, -4.00090069e-02f, -1.07254302e-02f,
  -7.58352950e-02f, 3.71734053e-02f, 1.43999055e-01f, -2.70378310e-02f, 1.58306994e-02f, -2.09066421e-02f, 3.05084940e-02f, -6.08939230e-02f, 6.17262386e-02f, -5.52997626e-02f,
  8.32225680e-02f, 1.46305235e-02f, 9.17819813e-02f, 5.77542931e-02f, -3.49576250e-02f, -8.43734015e-03f, 4.03582975e-02f, 2.15514116e-02f, -3.34551744e-02f, -2.44331881e-02f,
  2.07110890e-03f, 4.67726216e-02f, -9.22574382e-03f, -1.88627557e-04f, 2.15345062e-02f, 2.18718089e-02f, -2.05071978e-02f, 5.26883788e-02f, 5.62161095e-02f, 2.26290450e-02f,
  -4.24825251e-02f, -3.51011782e-04f, -5.36068752e-02f, 2.95936875e-02f, -4.30633910e-02f, -1.99447162e-02f, 2.60592671e-03f, -8.28639604e-03f, 1.35162836e-02f, 5.26692383e-02f,
  -1.75471939e-02f, 8.92982236e-04f, -3.86087149e-02f, 6.55339891e-03f, -7.06173703e-02f, 5.85334599e-02f, -4.44085300e-02f, 2.56138965e-02f, -5.18482625e-02f, -4.79781115e-03f,
  -2.18122192e-02f, 8.69687349e-02f, 9.16913003e-02f, 2.39082258e-02f, 1.22349765e-02f, 3.83185670e-02f, 9.51239690e-02f, 8.77631083e-03f, -1.61598176e-02f, 5.94921112e-02f,
  1.05652198e-01f, -6.95507899e-02f, -2.64199730e-02f, 3.90577912e-02f, 1.96868591e-02f, 1.67228654e-02f, 2.20342968e-02f, 5.83449602e-02f, 9.66550335e-02f, -4.48011756e-02f,
  3.58899217e-03f, -2.42859982e-02f, -2.39644468e-01f, -1.52659670e-01f, -7.63248354e-02f, 2.13960141e-01f, -5.96627519e-02f, 7.84016680e-03f, 1.90237816e-02f, 9.83017758e-02f,
  5.69119640e-02f, -9.82138440e-02f, 9.64313075e-02f, 1.67733371e-01f, 2.85900623e-01f, 1.19435064e-01f, 2.38934427e-01f, 1.62889343e-02f, -6.96642026e-02f, -5.84455654e-02f,
  -5.19399717e-02f, 1.21576466e-01f, -1.39075786e-01f, 5.75215854e-02f, -1.64177835e-01f, -2.57950097e-01f, 1.04063498e-02f, -7.57546797e-02f, -1.14215970e-01f, 8.52699503e-02f,
  2.63730250e-02f, -1.09385498e-01f, -1.07436895e-01f, 5.85547648e-02f, 3.20568196e-02f, 1.85005795e-02f, -7.68230250e-03f, 3.49269845e-02f, -6.02827035e-02f, -5.76402806e-02f,
  -4.13337983e-02f, 9.23785865e-02f, 1.89696345e-02f, -7.42540602e-03f, -1.65664330e-02f, 3.37852468e-03f, 1.17353071e-02f, -3.94286215e-02f, -1.14466120e-02f, 1.08645763e-02f,
  -3.40588428e-02f, 4.96707624e-03f, 9.58603527e-03f, 7.31355026e-02f, -6.73122630e-02f, -2.49579530e-02f, 6.49100076e-03f, -9.35838372e-02f, -2.92722471e-02f, -2.36787442e-02f,
  3.76502983e-02f, 1.74654573e-02f, -1.60297863e-02f, 1.08528771e-02f, 1.44095048e-02f, -1.08637355e-01f, 7.15585202e-02f, 4.10854854e-02f, -3.33683304e-02f, 6.25847951e-02f,
  -2.05776654e-02f, -6.22549839e-02f, -2.33532246e-02f, -7.57068992e-02f, -7.75143281e-02f, 7.93449488e-03f, 4.15062942e-02f, -1.31091720e-03f, -7.45238289e-02f, -3.07915155e-02f,
  -1.94377955e-02f, 5.73936701e-02f, -4.33901288e-02f, 4.23101801e-03f, 1.00238062e-01f, -8.63862634e-02f, 3.06349155e-02f, -5.85328117e-02f, -4.54247706e-02f, -8.91533680e-03f,
  1.19736463e-01f, 1.42434046e-01f, -3.44289690e-02f, -1.40853440e-02f, -2.05184463e-02f, 1.11431450e-01f, 2.11363547e-02f, 6.23905472e-03f, 3.42938229e-02f, 5.96811734e-02f,
  -1.22823576e-02f, -4.65975255e-02f, 7.17502087e-03f, 1.09647168e-02f, -5.79874357e-03f, 7.50066293e-03f, 5.51929176e-02f, -2.69326158e-02f, 3.25298980e-02f, -1.26144607e-02f,
  -5.61661981e-02f, 9.92133841e-03f, 2.07648352e-02f, -2.85453051e-02f, 1.76937990e-02f, 1.34280715e-02f, 8.92862026e-03f, -6.71527907e-02f, 7.58159813e-03f, 7.51825869e-02f,
  -2.13431910e-01f, 1.41159773e-01f, 3.17683406e-02f, 2.14828774e-01f, -2.47993648e-01f, 2.71905899e-01f, 1.99543953e-01f, -9.88373980e-02f, 1.77717641e-01f, 1.65746346e-01f,
  2.88628042e-02f, 7.93223307e-02f, -5.30374311e-02f, 1.72684699e-01f, -2.38606054e-02f, 1.01880305e-01f, 6.73526824e-02f, 7.47643784e-02f, -9.95770171e-02f, -1.71952322e-01f,
  -2.46067252e-02f, -3.44133154e-02f, -8.60893652e-02f, -1.82471484e-01f, -1.21645369e-01f, -7.59425536e-02f, -2.00372562e-01f, -3.90468836e-02f, 4.22579683e-02f, 5.84301464e-02f,
  -2.64925715e-02f, -9.10105258e-02f, -4.57371399e-02f, -2.32020672e-02f, -1.10016622e-01f, -5.93453925e-03f, -6.56836480e-03f, 2.40057930e-02f, 2.51306184e-02f, -7.39121856e-03f,
  7.53789470e-02f, -2.96639502e-02f, 1.55500956e-02f, 6.37351498e-02f, 3.75663210e-03f, 4.56094891e-02f, 1.04826624e-02f, 5.68989478e-02f, -4.19434942e-02f, -8.34137350e-02f,
  4.67355214e-02f, 5.00400439e-02f, 8.64225104e-02f, 9.07564349e-03f, 2.42729508e-03f, 9.59341601e-03f, 3.64856459e-02f, -5.66106588e-02f, 3.81761789e-02f, -4.53795912e-03f,
  -3.58279571e-02f, -2.86607929e-02f, 1.01141157e-02f, 8.51886272e-02f, -4.56364788e-02f, -5.08744791e-02f, 1.14793502e-01f, -8.79389942e-02f, -6.98332861e-03f, -5.25618978e-02f,
  4.35185805e-02f, 1.49574820e-02f, 3.36361059e-04f, -4.15987987e-03f, -1.05399992e-02f, -2.29741689e-02f, -2.46182363e-02f, -1.11429021e-03f, 9.73560754e-03f, 3.31736356e-02f,
  4.54068258e-02f, 3.09297889e-02f, 1.50661292e-02f, 5.90415671e-03f, -2.40720510e-02f, -1.79078244e-02f, 3.27471159e-02f, -9.70429846e-06f, 1.33637674e-02f, -9.36668273e-03f,
  -1.08431794e-01f, -2.20761031e-01f, 8.19069985e-03f, 8.45635589e-03f, -3.84619436e-03f, 1.06611084e-02f, 1.58143826e-02f, 2.07847711e-02f, 2.18517557e-02f, -5.75906262e-02f,
  -1.16411202e-01f, 4.09827940e-02f, -1.90618765e-02f, -1.86630599e-02f, 9.26995352e-02f, -2.15967819e-02f, -2.50163209e-02f, 9.41405743e-02f, 3.77363302e-02f, -4.11884338e-02f,
  -2.68787611e-02f, -6.82185888e-02f, -1.67058557e-02f, -1.97287351e-02f, -2.49300115e-02f, -1.32600060e-02f, -7.38168806e-02f, -4.10109572e-02f, 6.26421720e-02f, 3.45616899e-02f,
  1.27119841e-02f, -2.28878483e-02f, -3.54339480e-01f, -1.45890594e-01f, 1.48204342e-01f, -2.56173551e-01f, -2.04624906e-01f, -1.28931291e-02f, -2.24895686e-01f, 1.45227343e-01f,
  2.96016950e-02f, 1.17287152e-01f, -1.21582486e-01f, -1.28964067e-01f, 2.82662939e-02f, -2.71475494e-01f, -9.60788056e-02f, -4.77258116e-02f, -1.36812657e-01f, 8.60421509e-02f,
  -9.24279392e-02f, 1.04600102e-01f, -1.75434172e-01f, 1.25210270e-01f, -1.56607889e-02f, -6.41151592e-02f, 2.70214021e-01f, -5.52426837e-02f, 1.53340369e-01f, 7.28046298e-02f,
  -5.49615547e-02f, -3.74791846e-02f, -3.87795945e-03f, -8.50660279e-02f, 3.57587412e-02f, -1.72279533e-02f, 4.89025339e-02f, 2.46616844e-02f, -5.59022240e-02f, -3.24800201e-02f,
  4.11984622e-02f, 5.27849644e-02f, -3.57262418e-02f, -1.09302695e-03f, -5.04631288e-02f, -2.01542005e-02f, -1.31981457e-02f, -6.55461922e-02f, 8.57820082e-03f, -9.82954279e-02f,
  -1.74922366e-02f, -3.67868133e-02f, -5.74889034e-02f, 2.78450474e-02f, -6.23396821e-02f, -1.02119707e-01f, -9.54238400e-02f, 8.35614204e-02f, 6.63423911e-02f, -4.12546434e-02f,
  -1.86962206e-02f, -5.12891077e-02f, -2.62893271e-02f, 6.58107549e-02f, 3.64123136e-02f, 6.25991821e-02f, -5.86350672e-02f, 6.86022863e-02f, 3.90002280e-02f, 2.45455578e-02f,
  1.43750757e-01f, -5.44680357e-02f, 6.22023493e-02f, -4.86496203e-02f, 7.21322596e-02f, 4.10080627e-02f, -1.01302806e-02f, 8.73902999e-03f, 1.72207486e-02f, 2.52465941e-02f,
  9.78636276e-03f, -1.63555238e-02f, -5.29638417e-02f, -1.54295471e-02f, -1.71427261e-02f, -1.16263134e-02f, 5.75514100e-02f, -6.99846223e-02f, 5.12764268e-02f, 1.85208004e-02f,
  9.00264978e-02f, 1.38485551e-01f, 4.28139679e-02f, 1.83114000e-02f, 1.02488026e-01f, 1.24806255e-01f, -4.74777743e-02f, 1.02643415e-01f, 7.26011992e-02f, 6.11870922e-03f,
  1.61041338e-02f, 9.92151909e-03f, 1.55028263e-02f, 9.43746418e-03f, 6.32339530e-03f, 4.44588587e-02f, -2.59024873e-02f, 8.18226710e-02f, 1.62826583e-01f, 1.09931678e-02f,
  6.40352368e-02f, 4.25082929e-02f, 1.20124117e-01f, 5.96870221e-02f, 4.19436507e-02f, 6.61246181e-02f, 8.02300349e-02f, -9.44450051e-02f, 6.42920882e-02f, -2.32661627e-02f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.18144149e-01f, -9.20003653e-02f, -1.19075827e-01f, 1.08509034e-01f, -1.33720338e-02f, -9.80513841e-02f, -1.47510618e-01f, 9.33106244e-02f, -1.40094355e-01f, -1.34772221e-02f,
  8.40438530e-02f, 4.12180983e-02f, -1.42777845e-01f, 3.08012724e-01f, 1.93702534e-01f, -7.05057308e-02f, 2.52659053e-01f, 4.30678576e-02f, -3.91587764e-02f, 2.02900842e-01f,
  1.37806907e-01f, 2.87362278e-01f, 1.26133993e-01f, 2.22974792e-01f, 1.34698048e-01f, -4.86007445e-02f, 2.00868830e-01f, 2.82864999e-02f, 1.21936925e-01f, 1.46425158e-01f,
  -3.27359140e-02f, 2.18253024e-03f, -6.19213767e-02f, -4.08979580e-02f, -2.24305615e-02f, -1.04164012e-01f, -8.46803263e-02f, 8.72015138e-04f, 3.45320925e-02f, 1.66642386e-02f,
  1.15893234e-03f, 3.45248505e-02f, -2.31872369e-02f, -2.61099655e-02f, -2.60629486e-02f, 3.60516272e-02f, -1.11124620e-01f, 2.99996473e-02f, -8.23589712e-02f, -3.41273174e-02f,
  -1.11116961e-01f, -8.10915232e-02f, 1.72793735e-02f, -2.19205748e-02f, -5.59667572e-02f, 4.14665788e-04f, -4.17527966e-02f, 3.28597650e-02f, -7.69515485e-02f, 1.01051651e-01f,
  9.26948786e-02f, 4.12089415e-02f, -5.57810701e-02f, -2.45792116e-03f, 1.66053213e-02f, -1.15233380e-02f, 1.83746759e-02f, -3.96601520e-02f, -5.60459010e-02f, 6.33436022e-03f,
  -2.05319878e-02f, 2.95587834e-02f, 6.44127652e-02f, 5.28725386e-02f, -1.04425466e-02f, 4.66355402e-03f, -4.90605086e-02f, -5.49661331e-02f, 5.46179712e-03f, -3.90856899e-02f,
  8.83565247e-02f, 5.43355420e-02f, 1.94200668e-02f, 6.29519811e-03f, 8.69900733e-02f, 7.97737797e-04f, 1.42253786e-01f, 3.90248001e-02f, -1.69298157e-01f, -7.91750848e-02f,
  1.14245169e-01f, 1.43763140e-01f, 4.39945934e-03f, 3.95516753e-02f, -1.75061766e-02f, 2.64789332e-02f, 2.13191821e-03f, 1.90656334e-02f, 6.79836795e-02f, 8.75764526e-03f,
  3.61831822e-02f, -7.69257396e-02f, -3.25654261e-02f, -2.40971930e-02f, -5.26968529e-03f, 2.25282442e-02f, 9.54090357e-02f, -1.42759373e-02f, 1.40613215e-02f, 4.44889776e-02f,
  7.36695826e-02f, -3.86001542e-02f, 8.14062506e-02f, -1.19252570e-01f, 1.52199473e-02f, -3.85009195e-03f, -1.40306139e-02f, -3.95495258e-02f, -1.81482807e-02f, -8.09562672e-03f,
  3.15539777e-01f, -4.65702057e-01f, 3.07984710e-01f, 7.45577589e-02f, 2.90713489e-01f, 1.76918596e-01f, 3.59498620e-01f, -2.36310095e-01f, -3.12725395e-01f, -4.11002934e-01f,
  -1.10389935e-02f, 1.15798987e-01f, -6.42459095e-03f, -3.38662229e-02f, 5.35125017e-01f, 5.75066498e-03f, 4.30459864e-02f, 3.86090130e-02f, -6.69565424e-02f, 9.05509815e-02f,
  9.20790657e-02f, 1.79369957e-03f, 2.55589783e-01f, -2.53108501e-01f, 1.88569933e-01f, -9.65452492e-02f, 7.01111704e-02f, 2.34120995e-01f, -4.76673740e-04f, 1.78274333e-01f,
  -1.54727653e-01f, -1.12120099e-01f, -6.47541136e-02f, -1.53054029e-01f, -5.11309765e-02f, -3.19185778e-02f, -1.97247206e-03f, 1.92329735e-01f, 1.06371492e-02f, -8.13595392e-03f,
  -1.55337267e-02f, 3.03417463e-02f, -1.66942831e-02f, 9.99883935e-02f, -8.99117738e-02f, 1.13259470e-02f, 2.64524724e-02f, -3.31323780e-02f, -2.65139658e-02f, -8.49345140e-03f,
  -8.69425200e-03f, -4.15432127e-03f, -4.59621958e-02f, 4.94305454e-02f, 6.08958900e-02f, -1.28105013e-02f, 5.27877435e-02f, 1.42491966e-01f, -6.82966411e-02f, 2.45295335e-02f,
  9.30134580e-03f, -4.90187630e-02f, 1.66973732e-02f, -3.00913919e-02f, -1.30010694e-02f, -6.33946285e-02f, -2.52157319e-02f, 3.64145525e-02f, -6.56682327e-02f, -1.15940897e-02f,
  -2.54543088e-02f, -3.60864587e-02f, -3.47257294e-02f, 2.24423390e-02f, -5.08921966e-03f, -5.32611087e-02f, 7.00681433e-02f, -2.70743072e-02f, -4.06445935e-02f, 9.29664169e-03f,
  -1.58407278e-02f, -2.28079315e-02f, 3.72093022e-02f, 2.12125313e-02f, 1.43802222e-02f, 1.80628654e-02f, -4.17928845e-02f, -1.28416456e-02f, -3.84745821e-02f, 5.41145876e-02f,
  -3.37165892e-01f, -3.47814918e-01f, -8.47645700e-02f, -1.13148391e-01f, -2.28362717e-02f, 3.05534136e-02f, 4.11981456e-02f, 2.95350631e-03f, -1.21655144e-01f, 6.53494289e-03f,
  -6.35523945e-02f, 2.92459149e-02f, -3.26217823e-02f, 7.79907405e-02f, -1.13781253e-02f, -1.03771694e-01f, -2.57459357e-02f, -6.40799403e-02f, -5.25584519e-02f, -1.00283176e-01f,
  -3.37967835e-02f, 2.53634397e-02f, 5.31215221e-02f, -5.81220612e-02f, -4.54868190e-02f, 3.72080281e-02f, 6.30497709e-02f, -6.20082915e-02f, 9.63510498e-02f, -2.95488760e-02f,
  -5.30742466e-01f, 9.11591053e-02f, 2.10369527e-01f, 3.49863112e-01f, -2.95664608e-01f, -3.36661071e-01f, -2.85399437e-01f, 9.98874009e-03f, -1.27484441e-01f, -4.54416536e-02f,
  -1.51167020e-01f, -6.65358976e-02f, -3.86040173e-02f, 1.03574194e-01f, 2.08803326e-01f, 2.06534475e-01f, 1.64953336e-01f, 7.23423511e-02f, 2.33782008e-01f, 1.40243888e-01f,
  2.67804503e-01f, 2.21083730e-01f, 4.18713212e-01f, 1.63086250e-01f, 6.04191497e-02f, 1.18021838e-01f, 1.97855234e-01f, 1.48785666e-01f, 6.94013163e-02f, -1.24786869e-01f,
  -2.57008523e-01f, -2.12238054e-03f, -2.51773186e-02f, -5.37191406e-02f, -4.10173796e-02f, -1.40889317e-01f, -3.28905098e-02f, -8.53943229e-02f, -4.08387482e-02f, -5.99176139e-02f,
  -6.32800236e-02f, 5.31646097e-03f, -1.37996105e-02f, 5.06878830e-02f, -6.19462691e-02f, -2.98095625e-02f, 4.92047839e-05f, -3.05125415e-02f, -5.67727396e-03f, -1.90505534e-02f,
  5.17760031e-02f, 1.05213039e-02f, 7.61335641e-02f, 1.20797493e-01f, -8.43700487e-03f, -5.08486070e-02f, 8.55378583e-02f, -2.97031067e-02f, 2.65620779e-02f, -1.95243452e-02f,
  -3.78810987e-02f, 4.33418863e-02f, -1.78931225e-02f, -5.53602129e-02f, 4.38224524e-02f, 1.35139808e-01f, 5.66142797e-03f, -1.83812622e-02f, -6.57950900e-03f, 8.47971626e-03f,
  1.00318789e-02f, -2.31919494e-02f, -2.15695263e-03f, 2.55492646e-02f, 6.38581365e-02f, 8.24839808e-03f, 4.61819284e-02f, -2.50682402e-02f, 4.70422432e-02f, 4.21132445e-02f,
  1.05922306e-02f, 9.60932486e-03f, -3.37319518e-03f, -1.67999435e-02f, -1.34048134e-01f, 5.59175201e-02f, 7.71914609e-03f, 1.88775808e-02f, 1.52991498e-02f, 2.62073055e-02f,
  2.81037781e-02f, 3.45833421e-01f, 1.52790984e-02f, -1.42027736e-01f, 8.32483023e-02f, -2.19931006e-02f, 9.80821401e-02f, 6.14110753e-02f, 9.39099193e-02f, 6.00947440e-02f,
  -1.40197035e-02f, -1.24914143e-02f, -9.27338079e-02f, -1.11903669e-02f, 3.10026165e-02f, 9.12869722e-03f, -1.14558693e-02f, -1.93965323e-02f, 2.44743787e-02f, 1.12203499e-02f,
  1.45242885e-02f, 2.91803554e-02f, 1.78771272e-01f, -8.46457202e-03f, -3.00087556e-02f, 2.61161532e-02f, -1.09759614e-01f, 2.71874592e-02f, 2.24180296e-02f, -1.18971225e-02f,
  1.04291357e-01f, -7.09844157e-02f, 9.16727725e-03f, 1.84736773e-01f, -2.38710903e-02f, -2.05303431e-01f, -2.20966071e-01f, -3.43721770e-02f, -1.43185839e-01f, -1.86540812e-01f,
  1.74977537e-02f, 4.69208770e-02f, -1.77362189e-01f, 2.20794514e-01f, 1.92027450e-01f, -1.44156978e-01f, 1.66196615e-01f, -2.73301285e-02f, -4.26037759e-02f, 8.62552226e-02f,
  1.16207860e-01f, 1.22685127e-01f, 1.62738726e-01f, 2.36276627e-01f, 2.78654136e-02f, 1.50360152e-01f, 1.06412113e-01f, 1.68521069e-02f, 2.49402359e-01f, 1.11064732e-01f,
  -2.19493173e-02f, 9.34378896e-03f, -1.16416579e-02f, 4.87524346e-02f, 4.61926088e-02f, -1.70014966e-02f, 2.62609422e-02f, -3.19978483e-02f, 2.65253875e-02f, -5.48456199e-02f,
  -5.11740185e-02f, 3.75421904e-02f, 9.02522355e-02f, 8.17342624e-02f, 7.58862123e-03f, 7.66940340e-02f, -1.02050424e-01f, -6.79778382e-02f, -6.49701506e-02f, -2.10053008e-02f,
  1.51593201e-02f, -8.42035655e-03f, 1.14807123e-02f, 3.91918328e-03f, 9.97026786e-02f, 3.09488587e-02f, 2.98796054e-02f, 1.14109712e-02f, -2.01880978e-03f, 9.81771387e-03f,
  -3.68994810e-02f, -1.05081730e-01f, -1.20818406e-01f, -1.31502170e-02f, 3.08460146e-02f, 2.47931927e-02f, 3.33885639e-03f, 3.80148403e-02f, 5.31099550e-02f, 2.51379795e-02f,
  -6.24160729e-02f, 7.14925453e-02f, 5.76159172e-03f, -1.11645415e-01f, 8.30136910e-02f, -1.55304503e-02f, -4.84136771e-03f, -2.78198943e-02f, 3.26536670e-02f, -8.28404576e-02f,
  -4.19878028e-03f, -3.32929865e-02f, -1.65872788e-03f, -5.17184697e-02f, 4.84157726e-02f, -3.64990607e-02f, 6.25247136e-02f, 3.78768034e-02f, 2.22131126e-02f, 4.55060303e-02f,
  7.64164180e-02f, 1.00772947e-01f, 5.82647435e-02f, -2.50974614e-02f, 8.93133581e-02f, -5.96864596e-02f, 1.11185558e-01f, 7.28987204e-03f, 3.02968752e-02f, -4.08148095e-02f,
  3.38982753e-02f, 3.91659513e-02f, -2.81439675e-03f, 4.99038957e-02f, 9.55534354e-03f, -2.72657932e-03f, -1.11541580e-02f, 3.46858725e-02f, 6.87004551e-02f, 4.57085855e-02f,
  -1.05045072e-03f, -1.58253744e-01f, 6.05046041e-02f, -3.09389103e-02f, 6.00222126e-02f, -3.74439582e-02f, 6.16996102e-02f, 2.21118773e-03f, -1.22410385e-02f, 3.94344926e-02f,
  3.65146875e-01f, -9.43859864e-04f, 4.00413387e-02f, 2.45983586e-01f, -8.30584541e-02f, -1.23887122e-01f, -6.55187368e-02f, 7.55594149e-02f, 4.70150858e-02f, -9.97879133e-02f,
  1.52513525e-02f, -1.10942900e-01f, -2.19260082e-01f, 1.41017660e-02f, 1.29525021e-01f, -1.33059055e-01f, 7.18001500e-02f, 9.60861146e-03f, -2.15260983e-02f, -1.63391344e-02f,
  6.61266074e-02f, 1.26347452e-01f, 1.43294707e-01f, 1.83528304e-01f, 1.09084081e-02f, 1.37443185e-01f, 1.24142542e-01f, 6.15442917e-02f, 1.53372362e-01f, -9.05852243e-02f,
  -4.20888737e-02f, -9.20713041e-03f, 1.43586680e-01f, 5.36754914e-02f, -9.10019726e-02f, -2.24755015e-02f, -6.93762070e-03f, 2.35490520e-02f, 2.77930908e-02f, -1.25491410e-01f,
  -1.35909140e-01f, 7.66030177e-02f, -1.49274375e-02f, 6.67366982e-02f, 3.69609483e-02f, 5.88226393e-02f, 1.84923299e-02f, -3.01505625e-02f, -5.47636747e-02f, 4.13144752e-02f,
  -1.28037781e-02f, -1.42778661e-02f, -4.74584922e-02f, 4.26986590e-02f, -3.91839780e-02f, -6.37341812e-02f, 4.63064052e-02f, -1.05832748e-01f, -9.06713009e-02f, 2.49625593e-02f,
  -8.81221071e-02f, 5.97812682e-02f, 3.02808043e-02f, 1.20058127e-01f, 9.16148573e-02f, -3.29447619e-04f, 1.17432736e-02f, -1.70430783e-02f, -2.63072941e-02f, -1.01106539e-02f,
  9.00504962e-02f, -1.45251937e-02f, 2.39959676e-02f, -8.08374025e-04f, -1.08988360e-01f, 2.79735904e-02f, 7.00761303e-02f, 4.81244810e-02f, 2.00020596e-02f, -1.70243811e-02f,
  -4.27211970e-02f, 5.62562048e-02f, -8.08766112e-03f, 1.22458572e-02f, -5.48866615e-02f, 1.27968099e-02f, 4.88464832e-02f, 3.84308137e-02f, -1.17689095e-01f, 6.33416250e-02f,
  -5.85790984e-02f, -9.38670617e-03f, -5.19105047e-02f, -5.64810596e-02f, -5.79277277e-02f, 5.08946646e-03f, -6.23717997e-03f, 2.95115784e-02f, 7.24049509e-02f, 8.94409493e-02f,
  -4.57861610e-02f, 1.95844024e-02f, -4.93206494e-02f, 6.40870631e-02f, 4.16820794e-02f, 8.15733448e-02f, -8.83178227e-03f, 4.43584286e-02f, -6.14111274e-02f, -2.32409104e-03f,
  2.96298997e-03f, -1.52830869e-01f, -6.50236458e-02f, 2.63649449e-02f, 1.70036536e-02f, -7.49458745e-03f, -9.99646485e-02f, 2.76353694e-02f, -2.44051404e-02f, 1.56934876e-02f,
  4.91468430e-01f, 1.06771059e-01f, 2.10800186e-01f, 2.46115491e-01f, -1.37718990e-01f, -6.83038682e-02f, 1.05196245e-01f, -3.70385349e-02f, 2.73572296e-01f, 1.01049267e-01f,
  -1.85442224e-01f, 3.54563951e-01f, -5.33162728e-02f, -3.85474670e-03f, -1.65370435e-01f, -2.90084064e-01f, -5.12195285e-03f, 8.90001953e-02f, 4.66963202e-02f, 1.24344029e-01f,
  1.03736050e-01f, -1.99301898e-01f, 9.22781415e-03f, -1.08119085e-01f, 1.48324713e-01f, 1.00579485e-01f, -3.57822031e-01f, -1.48401648e-01f, 5.97488955e-02f, -8.34899992e-02f,
  5.85147403e-02f, -2.22909008e-03f, 2.53954958e-02f, 4.60029244e-02f, -2.68817740e-03f, -4.58132364e-02f, 3.00277285e-02f, -1.06115073e-01f, -6.56475499e-03f, 2.77985688e-02f,
  7.27915466e-02f, -3.71305202e-03f, 6.76531419e-02f, -7.63501152e-02f, -4.55992809e-03f, 1.06488389e-03f, 1.05080940e-01f, 2.18541101e-02f, 3.96694839e-02f, 5.96499182e-02f,
  6.52892962e-02f, 5.48006035e-02f, 8.20921510e-02f, 1.35264844e-02f, -1.76819116e-02f, 1.96663756e-02f, 3.67030054e-02f, 2.06206199e-02f, -2.12167669e-02f, 3.80716473e-02f,
  -9.00794640e-02f, -6.97683543e-02f, -1.91973653e-02f, -9.59817693e-03f, 3.85145769e-02f, -1.90657824e-02f, 2.55207364e-02f, 3.76631841e-02f, 3.77753004e-02f, 1.92629552e-04f,
  2.85067838e-02f, -3.43503803e-02f, -4.32378016e-02f, -8.30399978e-04f, 1.06215164e-01f, 4.35963757e-02f, -3.49295326e-02f, -7.47830272e-02f, 7.41468892e-02f, 3.03171277e-02f,
  -3.85967419e-02f, -1.94674656e-02f, 6.86811358e-02f, 8.30907747e-02f, 1.82636287e-02f, -2.46061366e-02f, -5.36720827e-03f, 1.15075238e-01f, -3.35597657e-02f, -6.09871447e-02f,
  -1.04292296e-01f, -2.19388500e-01f, 1.31135834e-02f, 9.33190435e-02f, -1.22286119e-02f, 1.86007377e-02f, -2.61477828e-02f, 2.80864611e-02f, 1.19628068e-02f, 3.76283862e-02f,
  2.75732344e-03f, 5.10768741e-02f, 2.46365070e-02f, -1.98104717e-02f, -2.69560283e-03f, -2.65417323e-02f, 9.50567517e-03f, -8.33523944e-02f, -7.08304793e-02f, -5.37491217e-02f,
  -3.17826867e-02f, 2.14505922e-02f, 8.78436342e-02f, 7.22939745e-02f, 4.93398272e-02f, -4.85919192e-02f, -4.07976359e-02f, -6.75190389e-02f, -8.38129893e-02f, -1.98530052e-02f,
  -1.08704355e-03f, -2.61855554e-02f, -1.69484273e-01f, 2.43679911e-01f, -1.68466359e-01f, 9.12034884e-02f, -1.33362906e-02f, -6.15427122e-02f, -1.46045983e-01f, 7.91241080e-02f,
  1.63807020e-01f, 2.73763184e-02f, -1.11804858e-01f, 3.70273948e-01f, 7.19656870e-02f, 7.99715295e-02f, 2.46689960e-01f, 2.03341916e-01f, -1.16639035e-02f, 1.53684899e-01f,
  3.86340208e-02f, 3.29285651e-01f, 1.04473852e-01f, 1.11753412e-01f, 2.83199530e-02f, 5.35222478e-02f, 1.41283929e-01f, -2.88529992e-02f, 1.91677168e-01f, 1.10192426e-01f,
  1.60720889e-02f, 1.51346978e-02f, -2.91423760e-02f, 1.97110069e-03f, -1.62987765e-02f, -3.80738117e-02f, 7.48735741e-02f, 3.81090231e-02f, -3.70162949e-02f, 1.08169489e-01f,
  7.64112035e-03f, 4.06392664e-02f, 9.83672496e-03f, -5.64123467e-02f, -7.07613630e-03f, 1.86347794e-02f, -1.86964050e-02f, 2.11320333e-02f, -9.99770239e-02f, 2.02619210e-02f,
  -1.83712784e-02f, -6.50656270e-03f, 1.00535005e-02f, 1.02118067e-02f, 9.56720766e-03f, 4.97973971e-02f, -2.16088612e-02f, -3.02402433e-02f, -6.65817857e-02f, 7.46720890e-03f,
  -1.94290616e-02f, 8.43055919e-03f, 3.51216272e-02f, 5.61278313e-03f, -3.89882103e-02f, 2.09953468e-02f, -3.05749141e-02f, 4.41781245e-02f, 6.11911714e-03f, 6.32686168e-02f,
  2.30219513e-02f, -8.36966485e-02f, -3.71676572e-02f, -1.69933122e-02f, 2.33895592e-02f, -1.16934925e-02f, -2.91579105e-02f, 3.88149694e-02f, 3.87679450e-02f, -3.62704392e-03f,
  1.72317475e-02f, 9.54198744e-03f, 3.24732699e-02f, -4.94694710e-02f, 2.29226928e-02f, -7.92598166e-03f, 6.41050488e-02f, -2.89709251e-02f, -6.87636882e-02f, -8.67116228e-02f,
  3.77377868e-02f, 1.13542028e-01f, 4.77976874e-02f, -1.42600248e-02f, -4.06754389e-03f, -6.65727779e-02f, 1.73498775e-04f, 1.00671574e-01f, 1.02457274e-02f, -8.79863426e-02f,
  -4.32863608e-02f, -9.01444927e-02f, -4.18860372e-03f, 6.76586805e-03f, 6.93469681e-03f, 2.10520364e-02f, 6.89610541e-02f, 1.02669233e-02f, -1.78053156e-02f, 1.89007800e-02f,
  -1.36510348e-02f, -3.83402444e-02f, 5.98620549e-02f, -1.03412881e-01f, -3.40409316e-02f, -4.12242599e-02f, -5.04871644e-02f, -1.59368310e-02f, -1.01390816e-02f, 4.29881401e-02f,
  1.43737003e-01f, -3.32700700e-01f, -2.46261582e-01f, -2.10557595e-01f, -8.80885795e-02f, -3.92053574e-01f, -3.25275302e-01f, -1.47441506e-01f, -6.17721118e-02f, -4.88437712e-04f,
  -1.88009188e-01f, 6.26214370e-02f, 7.50828395e-03f, -4.43984896e-01f, -8.50834027e-02f, 4.71826755e-02f, -2.73471415e-01f, -1.52613118e-01f, 1.19594634e-01f, -2.09082793e-02f,
  9.41506699e-02f, -3.15155983e-01f, -1.48578405e-01f, 2.68926751e-02f, -2.83817947e-01f, 1.16345882e-01f, 2.43675753e-01f, 5.71444631e-03f, -1.16703436e-01f, -1.33417338e-01f,
  -1.78708792e-01f, 6.52776062e-02f, -8.57046098e-02f, 1.92403365e-02f, 1.49286333e-02f, -7.02862861e-03f, 4.94029336e-02f, 4.95041907e-02f, 2.57327911e-02f, -7.14290887e-02f,
  5.63850738e-02f, 1.17258310e-01f, 1.09952753e-02f, 6.50562197e-02f, 2.38193162e-02f, -5.26496097e-02f, -7.33290613e-02f, 4.19718437e-02f, -8.36252719e-02f, 2.79885400e-02f,
  -3.10467891e-02f, -1.21008139e-02f, -9.60934907e-02f, 5.19370399e-02f, -2.70766113e-02f, -1.81154907e-02f, 5.36570325e-02f, 6.89693689e-02f, -3.96285998e-03f, 3.89014892e-02f,
  1.27551839e-01f, 6.38007373e-02f, -3.59422490e-02f, -4.60135601e-02f, -1.06771834e-01f, -2.39399634e-02f, -8.69996008e-03f, 1.12804882e-02f, 6.37058401e-03f, -2.17098594e-02f,
  -7.78129175e-02f, 4.65611555e-03f, 4.54547852e-02f, 6.67100446e-03f, 1.24079650e-02f, 4.95289341e-02f, -4.43208497e-03f, -3.83902923e-03f, -1.04656406e-01f, -6.51378706e-02f,
  3.63342129e-02f, -1.49384653e-02f, -8.81954841e-03f, 4.46409136e-02f, -2.06524786e-02f, 8.99437442e-02f, -2.19467282e-02f, 4.11871076e-02f, -1.19758276e-02f, -1.02535719e-02f,
  5.15083596e-02f, 1.10506050e-01f, -5.31883128e-02f, -4.83999960e-02f, -4.06833924e-03f, -1.09675735e-01f, -5.86216822e-02f, -6.34185523e-02f, 3.92817333e-02f, -1.62199102e-02f,
  9.44111962e-03f, -4.52597905e-03f, 1.22944387e-02f, -2.43889298e-02f, -1.09897908e-02f, -6.72166273e-02f, 5.34139015e-02f, 4.79837805e-02f, -2.34225206e-02f, 7.00641200e-02f,
  3.90356081e-03f, 3.17768306e-02f, 8.31135139e-02f, -3.51218432e-02f, 6.05297927e-03f, 3.56623307e-02f, 1.88475624e-02f, 6.34213835e-02f, 2.45186370e-02f, 3.82115096e-02f,
  1.56347156e-01f, -1.78748116e-01f, -2.13957012e-01f, 8.41458738e-02f, 1.45060256e-01f, 1.43926233e-01f, -5.03539778e-02f, 1.14584818e-01f, -2.48270199e-01f, -1.67918354e-01f,
  7.26633891e-02f, -1.77770004e-01f, -2.23503366e-01f, 2.32799813e-01f, 2.36562714e-01f, -7.77659565e-02f, 1.54987574e-01f, 3.05950139e-02f, -6.20158054e-02f, -4.53406433e-03f,
  1.48631901e-01f, 2.72170484e-01f, 1.74609870e-01f, 2.23008439e-01f, 8.00775960e-02f, 3.96868214e-02f, 1.43070146e-01f, 6.02876628e-03f, 2.56126642e-01f, 2.23835722e-01f,
  -5.01495600e-02f, 4.53814166e-03f, -5.94313852e-02f, -8.40190724e-02f, 6.28140718e-02f, 6.02411553e-02f, -1.08238347e-01f, -1.42393373e-02f, 2.01765671e-02f, 8.96469802e-02f,
  -8.23084116e-02f, 5.03269918e-02f, 6.77201077e-02f, 1.48084061e-02f, 4.96922508e-02f, 3.72122899e-02f, -1.97412744e-02f, -7.11528435e-02f, 2.11708546e-02f, 2.37580538e-02f,
  -7.09691346e-02f, 5.62042408e-02f, -2.83421110e-02f, 1.22644275e-01f, 1.33709880e-02f, 8.21412131e-02f, -7.30103068e-03f, -3.20933945e-02f, -5.61109111e-02f, -4.98524159e-02f,
  -8.16540234e-03f, -5.97160310e-02f, 1.07841901e-02f, -1.28357569e-02f, 6.82904944e-02f, 5.48530370e-02f, 1.53328687e-01f, 3.35283503e-02f, 4.20611426e-02f, -8.53903294e-02f,
  1.24266237e-01f, 2.42888778e-02f, -1.16560347e-01f, -7.08420128e-02f, 2.42156871e-02f, -4.55318652e-02f, 1.19527131e-02f, 8.25173110e-02f, -3.38837765e-02f, 6.49905801e-02f,
  -1.10327162e-01f, 1.00313909e-01f, 3.89536843e-02f, -8.28681979e-04f, -1.55739521e-03f, 2.92962268e-02f, -5.31522324e-03f, 1.64022315e-02f, 8.52260645e-03f, 7.39948601e-02f,
  -9.53815505e-02f, 1.08836247e-02f, -6.63781911e-02f, 9.28047374e-02f, 6.46617934e-02f, 1.03503175e-01f, -3.15001942e-02f, 8.27991590e-02f, -2.75342036e-02f, 4.09026071e-02f,
  -4.82784249e-02f, 5.54946214e-02f, -6.12891428e-02f, -8.85182098e-02f, 8.19855705e-02f, -2.39427611e-02f, -5.10649309e-02f, -5.39964959e-02f, 4.48109582e-02f, 1.01800196e-01f,
  -1.13106623e-01f, 4.38572988e-02f, -7.40704611e-02f, 5.04900292e-02f, 2.46098056e-03f, 3.69777903e-02f, 3.11898682e-02f, -1.04258597e-01f, 6.27678037e-02f, -9.50817838e-02f,
  -1.39622465e-01f, -2.47691527e-01f, -4.39293608e-02f, -1.63250178e-01f, -4.28980961e-02f, -1.37433514e-01f, -1.29211381e-01f, -1.80572778e-01f, -4.66670096e-02f, -1.14093333e-01f,
  -1.78330958e-01f, 9.33887064e-02f, 1.23374186e-01f, -5.95497116e-02f, 2.39499956e-01f, 1.29440337e-01f, -2.07846463e-01f, -2.62719356e-02f, -3.31817009e-02f, -2.19616443e-01f,
  -2.39159483e-02f, -2.20161676e-01f, 3.24314684e-02f, -3.33413661e-01f, -2.21336618e-01f, -1.42036796e-01f, 9.10152197e-02f, -1.47582889e-01f, -1.04970396e-01f, -5.20065203e-02f,
  -2.47471452e-01f, -1.63702935e-01f, 1.52587648e-02f, 7.87212253e-02f, 2.58163624e-02f, 8.55105221e-02f, 6.95795268e-02f, 1.06562361e-01f, 4.79390398e-02f, 3.02691218e-02f,
  9.26237926e-02f, 7.09827337e-03f, -7.27557838e-02f, -1.23387657e-03f, -7.83182029e-03f, -1.15569234e-01f, -5.45833595e-02f, -3.71049792e-02f, -5.68569377e-02f, 5.79254590e-02f,
  7.61650316e-03f, 1.63230971e-02f, -3.61456466e-03f, -4.63317968e-02f, 6.62833899e-02f, -8.50764513e-02f, 3.13744843e-02f, 6.69019967e-02f, -4.93873619e-02f, -6.86938465e-02f,
  3.25709544e-02f, 5.49739711e-02f, -5.82228228e-02f, 2.41458230e-02f, -7.98247457e-02f, -1.31245986e-01f, -1.52554922e-02f, 3.52688693e-02f, -5.99904917e-02f, -8.47214013e-02f,
  -6.05482236e-02f, 3.83400805e-02f, 8.84875935e-03f, 2.07083281e-02f, -9.68548879e-02f, -5.72745092e-02f, 4.37943339e-02f, 4.39131185e-02f, -8.60774666e-02f, -5.17691225e-02f,
  -5.82501628e-02f, -4.24978286e-02f, 1.09029170e-02f, 6.83937967e-02f, -1.06371179e-01f, 3.67239863e-02f, -1.37940645e-02f, -4.27605361e-02f, 6.67736027e-03f, 9.09431130e-02f,
  -2.12918833e-01f, -2.42193535e-01f, -1.09701548e-02f, -4.93385866e-02f, 7.35711679e-03f, 6.01227097e-02f, 9.78751928e-02f, -3.57164107e-02f, 5.21742441e-02f, -4.71617430e-02f,
  -6.99151233e-02f, 6.91169128e-02f, -7.30064362e-02f, 2.90619731e-02f, 4.59200405e-02f, -5.60367964e-02f, -3.49483676e-02f, -3.91208455e-02f, -4.76596393e-02f, -4.75081056e-02f,
  -6.77102730e-02f, -3.04786358e-02f, -3.80939916e-02f, -2.29147822e-02f, 1.23489074e-01f, -7.17574731e-02f, 5.24269305e-02f, -7.81168342e-02f, 2.34463960e-02f, 7.83400610e-03f,
  -4.91359353e-01f, 2.16667697e-01f, -1.82029873e-01f, -2.11748436e-01f, 7.79413432e-02f, -1.74769536e-01f, -2.40462542e-01f, 7.31731430e-02f, -8.61909091e-02f, -8.55663940e-02f,
  -7.75094628e-02f, 5.28916381e-02f, 5.73366769e-02f, -4.60251095e-03f, -7.08625689e-02f, 1.12409487e-01f, -1.54728889e-01f, -1.10090867e-01f, 1.21378131e-01f, -1.69898391e-01f,
  -4.42642607e-02f, -9.37764645e-02f, -2.50995941e-02f, 6.94198087e-02f, -1.12739310e-01f, -4.08501215e-02f, -6.19288236e-02f, -2.22200919e-02f, -9.98407081e-02f, 7.75584504e-02f,
  -2.96769142e-01f, -3.31978619e-01f, -2.99877614e-01f, -1.29242018e-01f, -8.88704136e-02f, -1.91154554e-02f, -7.72617459e-02f, 1.66447479e-02f, -9.52768847e-02f, -2.39791442e-02f,
  2.92125121e-02f, 6.40523285e-02f, -5.50550669e-02f, 2.22371127e-02f, -1.60067696e-02f, -1.10351015e-02f, 4.05528210e-02f, -9.27327424e-02f, 1.40437642e-02f, 8.99554566e-02f,
  3.22574340e-02f, -6.55109733e-02f, -9.49295163e-02f, 5.76334400e-03f, 1.57569591e-02f, -2.15719473e-02f, -1.07327335e-01f, 4.92925681e-02f, 8.17485619e-03f, -1.00693889e-01f,
  5.74333891e-02f, -7.41884718e-03f, -4.78477962e-02f, 9.63408500e-03f, 8.09229631e-03f, -4.49205050e-03f, -8.36920068e-02f, -2.95803454e-02f, -4.51660668e-03f, 2.15706807e-02f,
  4.28035818e-02f, -4.23521511e-02f, -2.06624120e-02f, -4.48478125e-02f, 4.20945277e-03f, -5.19244522e-02f, -2.70397291e-02f, -5.80635183e-02f, -4.20076363e-02f, 2.81770956e-02f,
  -7.72060305e-02f, -4.47753705e-02f, 5.27935885e-02f, 1.78213734e-02f, -7.95125216e-03f, -2.99757924e-02f, -1.69051159e-02f, 5.99053875e-02f, -9.71417874e-02f, -6.53077215e-02f,
  -3.43218029e-01f, -4.40012932e-01f, -9.72313210e-02f, -6.67849332e-02f, -4.25709076e-02f, -5.86743094e-02f, 3.49854380e-02f, 3.02286539e-02f, -1.43523470e-01f, 2.56922841e-02f,
  -6.39874488e-02f, 2.87932921e-02f, -4.56287004e-02f, 3.23507115e-02f, 4.01499048e-02f, -2.83735134e-02f, -9.80992615e-02f, -7.23926201e-02f, -6.81448653e-02f, 2.77498905e-02f,
  -4.78520617e-02f, -7.87397102e-03f, 2.59111505e-02f, 4.88273054e-02f, -2.23754216e-02f, -5.62534370e-02f, 3.39580886e-02f, 4.11869250e-02f, 2.00331118e-03f, -3.99540365e-03f,
  2.01779902e-01f, 1.89652219e-01f, 3.04041151e-02f, 2.62641579e-01f, 3.90790403e-02f, -8.83300044e-03f, 3.91878523e-02f, 1.52121395e-01f, 4.40148056e-01f, -7.61477202e-02f,
  -1.09072469e-01f, 3.59117500e-02f, -1.50010223e-03f, 1.27778366e-01f, 1.22876495e-01f, 4.40234598e-03f, 3.05889636e-01f, 7.48389289e-02f, 2.44032115e-01f, 1.77448109e-01f,
  1.08939581e-01f, -1.83090735e-02f, -2.20691010e-01f, -2.52849787e-01f, -1.10493004e-01f, -8.17384869e-02f, -1.80850089e-01f, -2.09180251e-01f, -1.54878199e-01f, -1.22266643e-01f,
  2.47206055e-02f, 1.77045166e-01f, 1.93775017e-02f, -5.63437911e-03f, -1.37677025e-02f, -5.56053855e-02f, -1.21247828e-01f, -6.11639023e-02f, 4.38888371e-03f, 1.12175327e-02f,
  1.55539121e-02f, 2.55087875e-02f, 1.59738153e-01f, 1.91972312e-02f, -2.31301039e-02f, -1.69366878e-02f, 9.70710814e-03f, -4.94553857e-02f, -2.14677509e-02f, -2.91359853e-02f,
  -6.33893758e-02f, 6.35843351e-02f, 1.31844645e-02f, -5.95440753e-02f, 4.90079708e-02f, 2.17418522e-02f, -1.55974962e-02f, -8.62050280e-02f, 1.95601638e-02f, 5.41032404e-02f,
  4.78363074e-02f, -1.72841724e-03f, -7.93596655e-02f, -2.97038313e-02f, -9.80480202e-03f, -6.40509427e-02f, 7.16799125e-03f, -1.37494328e-02f, -2.64891218e-02f, -3.56937498e-02f,
  -5.60890287e-02f, -4.12547551e-02f, -1.15579749e-02f, -2.75154449e-02f, 5.78860715e-02f, -5.59119955e-02f, -1.84364934e-02f, 7.58684706e-03f, 4.15446423e-02f, 5.39348200e-02f,
  -4.90801707e-02f, -3.48190777e-02f, -1.69432774e-01f, 2.40895711e-02f, -1.25615159e-02f, -4.13685292e-03f, -3.36381048e-02f, -6.06282055e-02f, -2.95870397e-02f, -3.06332018e-02f,
  7.76525512e-02f, 1.98790044e-01f, -1.34917842e-02f, 9.09968652e-03f, 6.85335919e-02f, -8.66988972e-02f, 6.50993958e-02f, 6.66085854e-02f, 5.74790314e-02f, 1.99285317e-02f,
  5.31811379e-02f, -3.74791771e-03f, 5.99677395e-03f, 2.47867424e-02f, 4.13306057e-02f, -5.29014692e-02f, 1.13832559e-02f, 1.52799739e-02f, 7.04911277e-02f, 3.28789130e-02f,
  -1.06041931e-01f, 2.61992402e-02f, -5.83122224e-02f, 9.36075486e-03f, 3.86581905e-02f, -8.96293074e-02f, 9.12908167e-02f, -1.29627483e-02f, -7.01965913e-02f, 5.23558371e-02f,
  -2.22333267e-01f, 2.51070827e-01f, -2.22333446e-01f, 6.30467311e-02f, -7.06699193e-02f, 3.21842432e-01f, 4.06913698e-01f, -6.14336245e-02f, -8.96672308e-02f, 3.50527287e-01f,
  2.72811443e-01f, -1.59509376e-01f, 1.24357633e-01f, 4.52696264e-01f, 6.48418069e-03f, 2.53081352e-01f, 4.28466767e-01f, 2.77568817e-01f, -8.09049681e-02f, 1.18234426e-01f,
  3.52400960e-03f, 4.03835863e-01f, 1.25780165e-01f, -3.14439163e-02f, 1.51819378e-01f, -2.03742594e-01f, 6.32113442e-02f, -2.22996920e-01f, 2.00965583e-01f, -6.93158666e-03f,
  1.17725194e-01f, 4.00004275e-02f, -5.93022965e-02f, -1.18393227e-01f, 1.48251001e-02f, -3.85545916e-03f, -1.66669525e-02f, -1.02531448e-01f, -4.92864512e-02f, -4.04796973e-02f,
  -1.19192831e-01f, -3.97067443e-02f, 2.85702683e-02f, -2.52328515e-02f, -5.64408898e-02f, -6.42042905e-02f, -4.04466465e-02f, -6.96324632e-02f, 2.82552326e-03f, -9.37410537e-03f,
  -8.35901350e-02f, -1.24714244e-02f, -3.93004641e-02f, 3.99612822e-02f, -1.10082999e-01f, 8.46400186e-02f, 5.13432510e-02f, 5.62759303e-03f, -3.27467918e-02f, 3.74789424e-02f,
  1.39562180e-02f, -6.84036091e-02f, 6.16636388e-02f, -5.97767532e-02f, 8.31950903e-02f, -3.77468823e-04f, 4.31071892e-02f, 1.43002132e-02f, -8.18716288e-02f, 7.23539814e-02f,
  -7.73467794e-02f, 2.34556980e-02f, 1.31351156e-02f, 5.91606870e-02f, 7.74916336e-02f, 4.31399494e-02f, -5.14201857e-02f, -6.60489947e-02f, -5.57191968e-02f, 7.78644579e-03f,
  7.37153143e-02f, -3.02413274e-02f, 3.02812667e-03f, 1.91293787e-02f, 6.61807880e-02f, -7.71324784e-02f, 3.20473388e-02f, 5.70334643e-02f, 4.22520470e-03f, -4.02090624e-02f,
  1.02284282e-01f, 2.91046742e-02f, -2.93874219e-02f, -4.65536453e-02f, -4.73545771e-03f, 1.23973817e-01f, 1.19644657e-01f, -3.59759852e-02f, 6.78068446e-03f, 2.27551740e-02f,
  1.60543509e-02f, 3.93144973e-02f, -9.77178756e-03f, -5.85463718e-02f, -1.51897194e-02f, 4.96923402e-02f, 3.01991571e-02f, -3.45520154e-02f, 5.00500277e-02f, -4.93265465e-02f,
  2.89092958e-02f, 1.22688420e-01f, -4.77853492e-02f, -1.10235577e-02f, 3.25969681e-02f, -3.22435200e-02f, -4.62159775e-02f, -6.53700754e-02f, 5.97796179e-02f, 9.34950355e-03f,
  -3.94021213e-01f, 1.45703807e-01f, -5.13647050e-02f, -2.32201666e-01f, 4.52568419e-02f, -2.75329024e-01f, -1.53673276e-01f, 2.73886928e-03f, 2.33746748e-02f, -9.39347669e-02f,
  -8.27973709e-03f, -1.32333875e-01f, 1.00685298e-01f, -1.39090985e-01f, -1.75793216e-01f, -8.41133967e-02f, -2.19902635e-01f, -2.69789428e-01f, 1.97764665e-01f, -1.44942969e-01f,
  -1.16910093e-01f, -4.56827059e-02f, -1.19867526e-01f, 2.76474237e-01f, -5.46406023e-02f, -3.08186263e-02f, -2.69042581e-01f, 1.12788290e-01f, -8.51983875e-02f, -2.85656527e-02f,
  -1.24220699e-01f, -1.78397819e-01f, 9.09664109e-02f, 3.54300588e-02f, -1.74461663e-01f, -3.14256363e-02f, -9.10949036e-02f, 7.35967085e-02f, 1.11834016e-02f, 1.48117505e-02f,
  -8.16520676e-02f, -2.94564161e-02f, 2.89448239e-02f, 1.10880606e-01f, -4.23503630e-02f, 2.91630588e-02f, 3.67502794e-02f, -1.47477421e-03f, 5.91550991e-02f, 6.99679255e-02f,
  1.69865731e-02f, 6.22803830e-02f, -1.02818638e-01f, -1.13511510e-01f, -3.89257669e-02f, 7.14457454e-03f, -9.04363245e-02f, -8.31902251e-02f, -8.02475959e-02f, -1.99328568e-02f,
  1.88064110e-02f, 4.93049845e-02f, 2.60089934e-02f, 5.83001077e-02f, 5.42980023e-02f, -1.27280306e-03f, 5.52615263e-02f, -3.74359405e-03f, -4.80159931e-02f, -2.87170373e-02f,
  -1.00338735e-01f, -5.00048548e-02f, -5.87289184e-02f, -1.76118314e-01f, 3.05214636e-02f, -1.38977850e-02f, -1.55424520e-01f, -3.24769206e-02f, -4.28367667e-02f, -2.03224327e-02f,
  6.29426911e-02f, 4.99497633e-04f, -5.33625968e-02f, -1.09377606e-02f, 7.64021054e-02f, 1.67223476e-02f, 3.77569348e-02f, -4.52718772e-02f, -2.74353642e-02f, 3.95915806e-02f,
  -1.24895029e-01f, -2.99295425e-01f, 1.12530105e-01f, 2.23726928e-02f, 2.80919187e-02f, -4.98418175e-02f, 1.64127667e-02f, -4.57027704e-02f, -1.67051312e-02f, 2.49407496e-02f,
  -1.04364231e-01f, -1.31831616e-01f, -5.71979061e-02f, 2.18904465e-02f, 7.11786151e-02f, -3.56677570e-03f, -2.05363426e-02f, -5.52998371e-02f, 7.90804345e-03f, 1.11813312e-02f,
  5.72121181e-02f, 1.40197994e-02f, 5.06780762e-03f, -3.98935229e-02f, -6.91658854e-02f, -9.37507451e-02f, -6.97389022e-02f, -3.65484990e-02f, -1.10661881e-02f, -6.98271254e-03f,
  4.03850794e-01f, 2.52988279e-01f, 2.30361104e-01f, 1.14088215e-01f, -7.87799954e-02f, -1.27084389e-01f, -7.00976700e-02f, -9.46801305e-02f, -6.99070692e-02f, 7.19359610e-03f,
  -1.42059222e-01f, 3.30289721e-01f, -1.97345600e-01f, 1.17234297e-01f, -2.06510767e-01f, -2.90057868e-01f, 1.05443425e-01f, 7.65335858e-02f, -4.19739000e-02f, 3.92350145e-02f,
  -1.10151403e-01f, -1.41150847e-01f, 3.82811166e-02f, 1.66131724e-02f, 1.87529266e-01f, 2.68473417e-01f, -1.09391220e-01f, -7.30474517e-02f, 2.80742645e-01f, -6.39808327e-02f,
  6.93807155e-02f, 4.80562598e-02f, 1.23229794e-01f, -2.06585657e-02f, -1.07586272e-01f, 6.79032132e-02f, 1.16296589e-01f, -7.98111875e-03f, -2.67144982e-02f, 1.38597768e-02f,
  1.51403481e-02f, 2.28367690e-02f, -6.06035776e-02f, -4.39902395e-02f, 9.97310281e-02f, 4.57293577e-02f, 7.89843723e-02f, 9.76519138e-02f, 9.79792103e-02f, 5.84404133e-02f,
  1.19207166e-01f, 2.05947161e-02f, 6.11364879e-02f, 7.57374242e-02f, -3.08545157e-02f, 3.49130742e-02f, 9.82488319e-02f, 4.60011475e-02f, 3.92068401e-02f, 6.61985949e-02f,
  -1.66690741e-02f, -5.12018315e-02f, -7.63146877e-02f, 2.73335855e-02f, -4.57460014e-03f, -1.84488315e-02f, -1.51733849e-02f, 2.28240956e-02f, 1.60555113e-02f, 3.96939516e-02f,
  -1.16997119e-02f, 3.41098271e-02f, 1.06298765e-02f, 4.98498641e-02f, 7.35686859e-03f, 5.07305004e-02f, 3.15958895e-02f, -3.94937284e-02f, -3.01963952e-03f, 1.09823355e-02f,
  -3.45942788e-02f, 2.18431354e-02f, -1.59763694e-02f, -3.51957828e-02f, 4.95679826e-02f, -1.14505313e-01f, -3.18894684e-02f, 6.11209758e-02f, -1.34737104e-01f, -4.36482020e-03f,
  -1.12264417e-01f, -1.42596260e-01f, 7.38467276e-03f, -1.26620485e-02f, -1.76537558e-02f, 1.56851672e-02f, -7.61089176e-02f, 7.35223368e-02f, 6.48366846e-03f, 4.88155475e-03f,
  2.70416234e-02f, -4.41566557e-02f, -1.36632873e-02f, 3.27049494e-02f, -1.59779191e-02f, -9.80539620e-02f, -8.36785734e-02f, 5.65749779e-02f, 1.86464353e-03f, 4.05252986e-02f,
  1.23726819e-02f, -1.27277626e-02f, 6.64227158e-02f, -1.81852169e-02f, 8.88804626e-03f, -5.72219305e-03f, 1.43700754e-02f, 7.58340657e-02f, -3.44431330e-03f, 2.03156862e-02f,
  4.30813193e-01f, -2.70040601e-01f, -8.57966617e-02f, 1.18684582e-01f, 1.55283943e-01f, 5.21729849e-02f, 7.12749884e-02f, 1.58037599e-02f, 7.33770058e-02f, -1.65348977e-01f,
  -1.22686056e-02f, -1.00264870e-01f, -2.38403723e-01f, 7.34548196e-02f, 2.32425362e-01f, -5.62687702e-02f, 1.36709571e-01f, 4.70530465e-02f, -6.63315179e-03f, 7.15610664e-03f,
  1.28298059e-01f, 2.23224685e-01f, -8.79273638e-02f, -6.10204153e-02f, 8.27368721e-02f, -8.40368941e-02f, -5.15144914e-02f, -1.89828187e-01f, -1.20358676e-01f, -3.45644839e-02f,
  1.41112104e-01f, 7.27865994e-02f, 5.32841980e-02f, -4.33265278e-03f, -5.41369207e-02f, 7.56434053e-02f, 1.20769045e-03f, -9.58467461e-03f, -7.37477420e-03f, -6.04554452e-02f,
  -1.86040383e-02f, -4.90955822e-03f, -1.01030255e-02f, 6.93827495e-02f, 5.69428466e-02f, -3.80699337e-02f, -7.60073438e-02f, -1.17174806e-02f, -1.77495807e-01f, -1.06115572e-01f,
  2.67562619e-03f, -8.70165303e-02f, 9.52890590e-02f, -1.66103601e-01f, -6.75870255e-02f, 1.11113116e-02f, 4.10415865e-02f, -9.26149860e-02f, -4.22742218e-02f, -6.99436590e-02f,
  2.53875349e-02f, 1.30644158e-01f, 5.19227050e-02f, 3.45657207e-02f, 4.42273021e-02f, 5.86923808e-02f, 1.36342663e-02f, -4.66765314e-02f, 9.80606377e-02f, -3.75786908e-02f,
  2.49588443e-03f, 4.19512503e-02f, 7.46796280e-02f, -2.40686722e-02f, 4.16466147e-02f, 7.55932764e-04f, -4.47375886e-02f, -1.51984198e-02f, -5.56263514e-02f, -9.89330001e-03f,
  9.43596587e-02f, 5.13823442e-02f, -1.32934228e-01f, -3.12213507e-02f, -8.68143588e-02f, -1.99649576e-02f, 4.87793609e-02f, -5.44313565e-02f, 1.94742419e-02f, 8.60717986e-03f,
  -7.70344511e-02f, -1.98594376e-01f, -9.65438932e-02f, 7.37327114e-02f, -7.88867697e-02f, -2.54089125e-02f, 9.09381956e-02f, 3.89376208e-02f, -5.56925200e-02f, 3.03687789e-02f,
  1.51316319e-02f, 2.60871457e-04f, 3.26671936e-02f, 4.77037132e-02f, -1.44283706e-02f, -3.35997865e-02f, -3.95210125e-02f, -1.89150684e-02f, -2.02432722e-02f, 2.01829597e-02f,
  -6.09414056e-02f, 1.79358274e-02f, -3.96476425e-02f, -4.02190574e-02f, -2.43212339e-02f, -1.14875972e-01f, -1.83415599e-02f, -1.76865682e-02f, 1.41689321e-02f, -1.11734055e-01f,
  3.42127562e-01f, -2.56382793e-01f, 2.39044055e-03f, 3.45318615e-01f, 1.98540077e-01f, -1.02204546e-01f, 4.22770865e-02f, 1.56347901e-01f, 2.74126858e-01f, -2.61489391e-01f,
  2.00834442e-02f, -2.10472062e-01f, -2.24334359e-01f, 3.40757109e-02f, 1.89291313e-01f, -7.18778595e-02f, 1.24979228e-01f, -4.06365469e-02f, 6.21195473e-02f, 4.65699136e-02f,
  2.14643568e-01f, 6.23611249e-02f, 1.11602359e-01f, 1.16518170e-01f, -1.85929835e-02f, 4.46517617e-02f, -9.96397156e-03f, -8.55769068e-02f, 2.18170770e-02f, 2.32494120e-02f,
  7.28310347e-02f, 6.50452403e-03f, 1.21855915e-01f, -4.85538989e-02f, 9.96613037e-03f, -7.87213743e-02f, -3.84438559e-02f, -4.42078896e-02f, 1.72680706e-01f, -3.25679667e-02f,
  -8.38078782e-02f, -2.42029652e-02f, 1.96593236e-02f, 2.54857214e-03f, 8.49861503e-02f, 8.50967020e-02f, 8.05208310e-02f, 6.09087236e-02f, 4.28893305e-02f, -5.39466701e-02f,
  -1.59140918e-02f, -4.65652831e-02f, 4.76419041e-03f, -5.51675782e-02f, 5.00762500e-02f, 9.81739312e-02f, -3.77302319e-02f, -1.37008242e-02f, 2.78744176e-02f, 5.26674278e-02f,
  -1.83430668e-02f, -7.25474134e-02f, -5.23702689e-02f, 3.44443992e-02f, 1.08474819e-02f, 9.32356268e-02f, 5.40118525e-03f, 1.18235964e-02f, -3.73628014e-03f, -2.22831219e-02f,
  2.78411396e-02f, -8.78657866e-03f, 2.44543888e-02f, 5.06732538e-02f, -5.05710766e-02f, -5.06685153e-02f, 3.07856910e-02f, -5.88190109e-02f, -6.90692291e-02f, 5.95058165e-02f,
  -1.47698121e-02f, 5.00179082e-02f, 1.16085969e-02f, 6.30527958e-02f, 9.12160873e-02f, -2.78228950e-02f, -4.79344800e-02f, -4.01658528e-02f, -3.63188074e-03f, -1.98113564e-02f,
  -1.01022661e-01f, -2.58999109e-01f, -5.94069511e-02f, -4.47357856e-02f, 1.71480123e-02f, 4.20692051e-03f, 7.39922794e-03f, 3.43874693e-02f, -5.00495136e-02f, -8.66450593e-02f,
  -2.77530160e-02f, 5.28769121e-02f, -6.23304546e-02f, 1.04282796e-02f, 2.92202327e-02f, -4.83590551e-02f, 8.24525487e-03f, -3.68243977e-02f, 6.30593225e-02f, -8.72175992e-02f,
  -4.74429540e-02f, 3.01932208e-02f, 8.40817317e-02f, 1.12902783e-01f, -2.52909660e-02f, -4.90901545e-02f, -3.82319055e-02f, 3.16544995e-02f, -6.46987185e-02f, 8.78260061e-02f,
  8.86264667e-02f, -1.62788391e-01f, -2.43524551e-01f, -2.10853726e-01f, -3.27497303e-01f, -1.32450074e-01f, -9.13445130e-02f, -2.03959957e-01f, -2.40127489e-01f, -7.39745563e-03f,
  -1.38981581e-01f, -3.81499641e-02f, 2.32207641e-01f, -5.50320297e-02f, 1.93762228e-01f, 3.36551189e-01f, -1.18340321e-01f, 6.60619959e-02f, 7.37507595e-03f, -1.30037516e-01f,
  -4.92135175e-02f, -1.45416319e-01f, 1.28877625e-01f, -1.90650493e-01f, -1.50988474e-01f, -1.69215873e-01f, -1.00121744e-01f, -2.22945467e-01f, -2.37548411e-01f, -1.78015620e-01f,
  5.97840920e-02f, 1.58437272e-03f, -3.15901376e-02f, 7.40651935e-02f, 6.37821555e-02f, 2.57856324e-02f, 1.28347799e-02f, 6.46958575e-02f, -7.78204650e-02f, 8.89898539e-02f,
  2.17853654e-02f, 1.21558839e-02f, 3.48867439e-02f, -5.42144626e-02f, -1.04496650e-01f, -7.92449862e-02f, -4.50635813e-02f, -6.59223786e-03f, -2.86466349e-02f, -1.35507213e-03f,
  -5.18259294e-02f, 5.15251458e-02f, 8.70284101e-04f, 7.28503987e-02f, -6.45463765e-02f, -1.05957560e-01f, 6.84897602e-02f, -2.88855955e-02f, 1.59570593e-02f, 1.83828492e-02f,
  9.75471921e-03f, -3.19215506e-02f, 9.13287550e-02f, -2.45420877e-02f, 5.05445246e-03f, 4.32588831e-02f, -6.06246963e-02f, 3.78562808e-02f, 4.14800495e-02f, 4.08499315e-02f,
  1.12666041e-02f, -4.23241481e-02f, -5.43014631e-02f, 8.04719515e-03f, -7.43500292e-02f, 1.17017990e-02f, -2.24443264e-02f, -5.33721782e-02f, -3.87247279e-02f, -9.00352448e-02f,
  -9.97142494e-03f, -2.23762635e-02f, 3.85322049e-02f, 5.67595810e-02f, 1.90499611e-02f, -6.06183941e-03f, -9.89043806e-03f, 3.55312005e-02f, -4.38926276e-03f, 1.11001479e-02f,
  -6.49345748e-04f, -6.61502108e-02f, 1.62019469e-02f, 7.15897828e-02f, 2.05820967e-02f, 3.95438150e-02f, 3.44518991e-03f, -1.11690247e-02f, -3.80099900e-02f, -5.52979074e-02f,
  -2.03478280e-02f, 3.11417915e-02f, -1.10635534e-02f, -3.29673588e-02f, -4.40787077e-02f, 4.42121364e-02f, 4.14364189e-02f, 4.15953808e-02f, -2.30833068e-02f, -1.20187759e-01f,
  6.29242510e-02f, 6.44613504e-02f, 4.03894149e-02f, 5.30493893e-02f, 5.13551161e-02f, 6.60937950e-02f, -2.70768758e-02f, 3.89821380e-02f, -1.78087875e-02f, -7.15259686e-02f,
  -1.96768835e-01f, -9.66796204e-02f, -1.28543213e-01f, -2.95827001e-01f, 2.52630282e-02f, -2.13495478e-01f, -2.30866253e-01f, 6.18955567e-02f, -2.73156837e-02f, 2.76567101e-01f,
  1.14326194e-01f, -1.25957012e-01f, 1.16100058e-01f, -2.98204452e-01f, -2.98788190e-01f, -2.06725970e-01f, -3.06817889e-01f, -7.14033172e-02f, -4.75348346e-02f, -5.96684180e-02f,
  -2.04836696e-01f, -8.38585794e-02f, -3.02183568e-01f, 4.83505875e-02f, -9.07214880e-02f, 4.14069667e-02f, 2.55426019e-01f, 9.33399349e-02f, -4.39457735e-03f, 5.99796744e-03f,
  -1.10325456e-01f, 1.82381675e-01f, -9.65460949e-03f, 2.87540760e-02f, 3.50806676e-02f, 7.00468123e-02f, 3.57495211e-02f, 3.09380284e-03f, -2.23149415e-02f, 7.03011360e-03f,
  -1.92256905e-02f, -2.60711759e-02f, -2.37833038e-02f, -1.91337038e-02f, -4.50295359e-02f, -1.61996239e-03f, -6.61124364e-02f, -1.44611346e-02f, -9.97515842e-02f, -1.03217557e-01f,
  -5.38002923e-02f, -1.13420814e-01f, -2.52964348e-02f, 2.73806881e-02f, -3.61454561e-02f, 1.11199999e-02f, -4.14987653e-02f, 3.48074287e-02f, -2.43224762e-03f, -1.26628187e-02f,
  -1.12244310e-02f, -8.16358477e-02f, -1.03125833e-01f, -5.78163341e-02f, 2.28248462e-02f, 3.18797007e-02f, -4.17082831e-02f, 2.12457608e-02f, -7.19301496e-03f, -6.81678252e-03f,
  -2.95482855e-02f, -9.61393304e-03f, 1.08866677e-01f, -2.93254782e-03f, -6.44889027e-02f, -4.48329039e-02f, -1.20002050e-02f, 6.58996701e-02f, -7.55140185e-02f, 3.07966899e-02f,
  5.35999723e-02f, 9.83345062e-02f, 2.77769528e-02f, 5.78604154e-02f, -6.21241704e-02f, -6.17464036e-02f, 1.13291599e-01f, -7.49851763e-03f, -6.73749391e-03f, 2.99827438e-02f,
  9.76817906e-02f, 2.10171640e-01f, 5.76500259e-02f, -3.60939093e-02f, -9.95453680e-04f, -9.77063775e-02f, -1.07659725e-02f, 1.84930593e-03f, -7.47785196e-02f, -2.03226204e-03f,
  4.77889664e-02f, 2.91866846e-02f, 4.24701087e-02f, -1.09692961e-02f, 2.38156542e-02f, 1.08602658e-01f, 5.34885153e-02f, 1.29087763e-02f, -2.36480515e-02f, 6.43648729e-02f,
  -4.77678189e-03f, 2.49556662e-03f, 6.94847554e-02f, -2.59526260e-02f, 2.39262115e-02f, 7.78267160e-02f, -7.31715001e-03f, -5.36395423e-02f, -7.07026124e-02f, 6.00158386e-02f,
  -3.05361003e-02f, 8.25777501e-02f, 4.69635546e-01f, 1.33722931e-01f, -1.46861836e-01f, 1.59111366e-01f, 3.32052439e-01f, 1.26598716e-01f, 1.59295261e-01f, -2.88756434e-02f,
  -1.80692077e-01f, 3.01426351e-01f, 1.00214696e-02f, -2.05300003e-02f, 1.56130224e-01f, -1.25393914e-02f, -9.51661821e-03f, -9.22337919e-03f, 6.10879846e-02f, 6.22252673e-02f,
  1.99775770e-02f, -1.32085800e-01f, 5.17007262e-02f, -1.25859350e-01f, -4.00487967e-02f, -2.46209018e-02f, -2.32785612e-01f, 9.71642509e-02f, -1.40653670e-01f, 5.54600582e-02f,
  -1.39046565e-01f, 2.52325624e-01f, 2.28775330e-02f, 1.12810485e-01f, 2.62505263e-02f, -4.09574062e-02f, 4.22974154e-02f, 4.36182059e-02f, -4.87922728e-02f, -1.51534588e-03f,
  -9.95244086e-03f, -5.30872552e-04f, -8.54558125e-03f, -4.47287150e-02f, 1.94838233e-02f, -4.37842570e-02f, -6.55528973e-04f, -7.79615939e-02f, 9.75808501e-02f, 3.93111110e-02f,
  -5.97688323e-03f, 5.52657247e-02f, 2.40799244e-02f, -3.47263063e-03f, 4.03804556e-02f, 2.78358329e-02f, 1.40762821e-01f, 3.01068462e-02f, 2.14705952e-02f, 1.88284852e-02f,
  6.37035966e-02f, 4.09577321e-03f, -5.93792051e-02f, -3.78843136e-02f, -2.58670449e-02f, -1.27565458e-01f, -5.91361932e-02f, -4.46666852e-02f, 4.95785885e-02f, -1.41740412e-01f,
  8.85342434e-03f, 7.49803483e-02f, 1.53182596e-02f, -3.82576995e-02f, -2.83690169e-02f, 8.53970088e-03f, 2.87142079e-02f, -1.43296998e-02f, -1.19358469e-02f, -2.62115635e-02f,
  1.28703251e-01f, 5.03801145e-02f, -2.82503222e-03f, -4.53784429e-02f, 5.86425327e-02f, 6.79900199e-02f, 1.04548493e-02f, 8.10554996e-02f, -1.90140232e-02f, 2.37975027e-02f,
  -1.04725353e-01f, 2.98631191e-01f, -5.19110598e-02f, -2.84016095e-02f, -4.74961288e-02f, -6.38506468e-03f, 9.17174146e-02f, -2.95127071e-02f, 1.01792037e-01f, 8.37644860e-02f,
  -1.70146357e-02f, -2.94364430e-03f, 4.79505397e-02f, -1.65652186e-02f, 9.95002389e-02f, 3.29297483e-02f, 1.34873360e-01f, -1.76976621e-02f, -1.09005775e-02f, -2.57469546e-02f,
  -7.69433901e-02f, 2.33485438e-02f, -7.52057321e-03f, -3.21034566e-02f, -2.67987419e-02f, -1.13022961e-02f, -1.93964727e-02f, 5.12291305e-02f, 9.94735491e-03f, -3.38778161e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  1.01521589e-01f, 2.55550265e-01f, 2.28753775e-01f, 7.84394071e-02f, 5.88522367e-02f, 1.45673016e-02f, 2.61611938e-01f, 1.06299095e-01f, 2.19955370e-01f, 1.97036937e-02f,
  1.13163829e-01f, 1.48013413e-01f, 1.85919255e-01f, 1.13356747e-01f, 1.85867444e-01f, 2.33535290e-01f, 3.67843546e-02f, 1.79706827e-01f, 3.15943301e-01f, 3.83341432e-01f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -1.01332098e-01f, -2.56210983e-01f, -1.12245940e-01f, -1.59260124e-01f, 9.39344764e-02f, -1.01629958e-01f, -8.61835852e-02f, -1.12830997e-01f, 1.31340995e-01f, -1.41794272e-02f,
  -1.32621288e-01f, 2.51256138e-01f, 1.25860929e-01f, -2.77586421e-03f, -2.43794456e-01f, -5.96399121e-02f, -4.14383784e-03f, -1.62043855e-01f, -2.03237295e-01f, -1.27006635e-01f,
  1.48418576e-01f, -3.07092875e-01f, -1.18383579e-01f, 3.47155780e-02f, 5.66012152e-02f, 7.90619776e-02f, -1.66279033e-01f, 1.75450951e-01f, 1.78074792e-01f, -1.52137190e-01f,
  1.84610840e-02f, -4.87690978e-02f, -6.29087090e-02f, 6.78347871e-02f, 9.99681726e-02f, -1.89728081e-01f, 6.89264312e-02f, -5.43373041e-02f, -1.06642783e-01f, 1.32192373e-01f,
  -1.34628862e-01f, -1.06661774e-01f, 2.69070625e-01f, -8.23174566e-02f, -7.02514499e-02f, -7.02849776e-02f, -8.48316923e-02f, -7.50511363e-02f, 1.11679912e-01f, 2.16022328e-01f,
  1.43817030e-02f, -2.33460695e-01f, -4.37593639e-01f, 3.53101566e-02f, 1.28749069e-02f, 1.64098963e-01f, -1.16368681e-01f, -1.82494685e-01f, 1.85212165e-01f, -6.73174933e-02f,
  -2.42198743e-02f, 2.10077375e-01f, -2.56221443e-01f, 2.36687213e-01f, -2.12202743e-02f, 7.21172243e-02f, 2.67766919e-02f, 2.17722863e-01f, 2.20432714e-01f, -5.49309654e-03f,
  2.76819497e-01f, 6.82856515e-02f, -1.78883359e-01f, -1.79942608e-01f, -2.24581629e-01f, 5.98307736e-02f, -1.73720345e-01f, 2.88208991e-01f, -5.80073148e-02f, -1.47970840e-01f,
  -7.23954365e-02f, -9.98515487e-02f, -1.72204435e-01f, 2.30923757e-01f, 9.59646031e-02f, 2.22268119e-01f, 1.30718082e-01f, -1.81081131e-01f, -2.66479522e-01f, 2.09181502e-01f,
  -1.55647933e-01f, -3.22451442e-02f, 1.06994621e-01f, 3.35059948e-02f, 1.02331504e-01f, -2.63174009e-02f, -2.25580744e-02f, 2.07884595e-01f, -1.18672766e-01f, -1.01030856e-01f,
  -2.74195760e-01f, -3.80729921e-02f, -8.08123425e-02f, -2.80893624e-01f, -6.29578084e-02f, 4.68696691e-02f, 1.22070849e-01f, 7.03869537e-02f, 3.46185528e-02f, -4.23251092e-01f,
  6.72694594e-02f, -1.60056818e-02f, -6.71964213e-02f, -5.01391441e-02f, 1.59328923e-01f, 2.84031659e-01f, -2.13367686e-01f, -6.53959215e-02f, -1.97577327e-01f, 2.00471684e-01f,
  2.17483982e-01f, -1.83130845e-01f, 1.54916853e-01f, -1.71936870e-01f, -3.04435492e-01f, 2.29855642e-01f, 2.66350538e-01f, 2.13098571e-01f, 1.11848734e-01f, 1.65229917e-01f,
  -8.57700929e-02f, 6.35126606e-02f, 2.50877112e-01f, 1.42765148e-02f, 1.50263429e-01f, -1.54018914e-02f, -1.64956599e-01f, -7.61651322e-02f, 4.97128442e-02f, -1.25214517e-01f,
  -1.91140905e-01f, 1.05887681e-01f, -1.36321887e-01f, -5.94988540e-02f, -8.80920961e-02f, 2.11906731e-01f, -9.05772746e-02f, -1.94517210e-01f, -1.74551725e-01f, -1.64895415e-01f,
  7.00374544e-02f, 8.76834020e-02f, -1.78436279e-01f, 3.04174393e-01f, 8.00351650e-02f, 1.41463369e-01f, 5.30525185e-02f, -6.73876777e-02f, 6.91699982e-02f, 1.96837276e-01f,
  6.49853423e-02f, -8.81970823e-02f, -8.57953355e-02f, 3.39536481e-02f, -6.64183870e-02f, 4.89364341e-02f, -1.11947380e-01f, -2.88183689e-01f, -1.41416881e-02f, -1.30564794e-01f,
  8.75711814e-03f, -4.46749851e-03f, 3.83857824e-02f, -5.37035875e-02f, 1.05126202e-01f, 1.66624188e-02f, 8.13387260e-02f, -3.78649123e-02f, 3.09278946e-02f, -1.27858594e-01f,
  7.73790330e-02f, -2.78348655e-01f, -7.00177997e-02f, -1.19609134e-02f, 1.69608936e-01f, -1.56911761e-02f, 8.29057246e-02f, -1.02953836e-01f, -1.34039089e-01f, -2.67132282e-01f,
  -1.03920586e-02f, 7.38140270e-02f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.20714530e-01f, 3.97664398e-01f, 1.38828248e-01f, 3.60190511e-01f, 4.26408835e-02f, 1.83948338e-01f, 2.28892446e-01f, 4.32136655e-02f, -2.61348277e-01f, 5.50230704e-02f,
  2.55940437e-01f, -3.46663624e-01f, -8.68326649e-02f, 9.42182243e-02f, 2.36988783e-01f, 1.27311973e-02f, -1.46591112e-01f, -1.67194366e-01f, -3.25604714e-02f, -2.53110766e-01f,
  -1.25347406e-01f, 2.81651113e-02f, 2.72880018e-01f, -1.79557353e-01f, -1.89598912e-04f, 1.38746366e-01f, -2.08053678e-01f, -7.39587620e-02f, -1.89535290e-01f, 8.02985057e-02f,
  9.91397500e-02f, 2.82958567e-01f, 1.91466540e-01f, 1.12253539e-01f, 2.50180215e-01f, 2.30126947e-01f, 1.73593059e-01f, 1.17484704e-01f, 2.09809234e-03f, -4.04394418e-01f,
  6.48891702e-02f, -3.37831110e-01f, -7.98006728e-03f, 5.84760606e-02f, -1.67172000e-01f, -1.77968573e-02f, 1.83736145e-01f, 4.90711890e-02f, -1.29876301e-01f, 2.23981455e-01f,
  5.26749752e-02f, 1.83782786e-01f, -9.91420075e-02f, 7.13155419e-02f, 3.13631743e-01f, -4.89519769e-03f, 3.97275276e-02f, 2.83893526e-01f, 4.68206823e-01f, -2.79283524e-01f,
  -2.05790192e-01f, 2.08510961e-02f, 4.40879911e-01f, 9.09395590e-02f, 6.67571351e-02f, 1.41419042e-02f, 6.31258488e-02f, -3.63621637e-02f, 5.98005727e-02f, -5.70218526e-02f,
  -1.08760633e-02f, -7.89485648e-02f, 2.04147950e-01f, 9.30863526e-03f, -2.32046008e-01f, 2.85645217e-01f, 3.49152654e-01f, 9.18997228e-02f, 5.17598316e-02f, 1.90970317e-01f,
  1.97956324e-01f, -2.85930246e-01f, 1.85628995e-01f, 2.86227793e-01f, 3.79061729e-01f, -1.43061325e-01f, -1.83238357e-01f, -3.82438861e-02f, 1.76830336e-01f, -1.38662025e-01f,
  4.01127785e-02f, 1.34251595e-01f, 1.11806475e-01f, -8.89067575e-02f, 2.66897708e-01f, -6.64310381e-02f, 1.52055100e-01f, 2.42390588e-01f, 1.74944162e-01f, 3.01626295e-01f,
  4.39467207e-02f, 9.65105146e-02f, 1.96477845e-01f, 4.17495072e-02f, -4.66583893e-02f, 1.62790239e-01f, 1.60062194e-01f, -3.60165387e-01f, 2.14007646e-01f, 1.07522860e-01f,
  5.86843491e-01f, 3.34988773e-01f, 2.05682695e-01f, -1.61076024e-01f, 1.62812635e-01f, -1.19536750e-01f, 1.44456849e-01f, -1.10426180e-01f, 1.76269099e-01f, 3.22806984e-01f,
  1.24155328e-01f, -7.78355524e-02f, -9.72205251e-02f, -1.79595724e-02f, 9.51118395e-02f, 8.25697184e-02f, -5.96961789e-02f, 3.70970219e-01f, 4.46769968e-03f, -1.28118936e-02f,
  1.34801688e-02f, 5.94214983e-02f, -4.36665229e-02f, -9.96203627e-03f, -7.88127333e-02f, 7.73503184e-02f, 1.14092655e-01f, -1.63966909e-01f, -3.53644222e-01f, -1.17290266e-01f,
  2.54913598e-01f, 1.82099223e-01f, 4.86462504e-01f, 3.81091565e-01f, 2.12480709e-01f, -1.49645343e-01f, 9.13521647e-02f, 5.49869128e-02f, 1.28023595e-01f, -7.78670087e-02f,
  -3.13904062e-02f, 4.25044745e-01f, -2.22330630e-01f, 5.81521429e-02f, -6.27773330e-02f, 4.42425087e-02f, 5.09267569e-01f, -1.44506454e-01f, -6.85295016e-02f, 1.08841434e-01f,
  7.30599985e-02f, 1.85908020e-01f, 1.48542464e-01f, 5.75976148e-02f, 8.84436965e-02f, -3.35495099e-02f, -7.55612329e-02f, -2.10594200e-03f, 2.99805254e-02f, -4.87216488e-02f,
  -1.26154795e-01f, 2.38528937e-01f, -3.16598788e-02f, -2.09699646e-01f, -6.45559430e-02f, -7.58546814e-02f, -2.13201314e-01f, -1.21997431e-01f, 6.00876100e-02f, 2.21653253e-01f,
  6.66608438e-02f, 2.77308941e-01f, 9.98891294e-02f, 1.41145408e-01f, 1.37772515e-01f, 3.43306065e-01f, -7.27994218e-02f, -1.58531606e-01f, -1.51789412e-01f, 7.86705911e-02f,
  3.50890368e-01f, 4.45023412e-03f, 3.78810555e-01f, 7.25053251e-02f, 3.15587699e-01f, 2.13742018e-01f, 3.52292985e-01f, 1.93182722e-01f, 4.22271118e-02f, 4.61583957e-02f,
  1.01834454e-01f, 3.78146395e-02f, -2.15351969e-01f, 3.14474821e-01f, 5.39057143e-02f, 5.13057232e-01f, -3.34179997e-01f, -8.23259130e-02f, -4.04861011e-02f, -1.91474155e-01f,
  5.02153710e-02f, 3.76983657e-02f, 2.78065532e-01f, 4.48138863e-02f, 7.08522499e-02f, -2.49729246e-01f, 1.57515317e-01f, 2.13855729e-01f, -1.69902891e-01f, 3.51864398e-01f,
  1.01585232e-01f, -2.33769622e-02f, 3.83214951e-01f, -8.41443017e-02f, 4.11379524e-02f, 2.44396657e-01f, 2.10246950e-01f, 9.36750993e-02f, -1.71373934e-01f, 5.73125258e-02f,
  -5.50423078e-02f, 8.36903229e-02f, 1.50699452e-01f, 2.70682901e-01f, 3.62931155e-02f, 1.32028475e-01f, 1.69492245e-01f, -2.35475615e-01f, -8.68931934e-02f, 4.04415652e-03f,
  -1.42711073e-01f, -2.19624475e-01f, 2.29918525e-01f, 3.49998236e-01f, 8.22293833e-02f, 2.37947747e-01f, 2.24406213e-01f, -1.62698060e-01f, 5.17751575e-01f, -1.81098133e-02f,
  -5.61190210e-03f, -2.65472271e-02f, -1.91696376e-01f, 2.20599219e-01f, 1.18233927e-01f, -1.75581545e-01f, 2.59104464e-03f, 3.36414993e-01f, 1.79288864e-01f, 3.40657234e-01f,
  8.60779807e-02f, 2.90827062e-02f, 3.36553514e-01f, 9.68199149e-02f, -1.35779485e-01f, -1.51143670e-01f, 1.48245934e-02f, -3.16633508e-02f, 4.85255197e-02f, 2.94011105e-02f,
  4.40556645e-01f, 1.71240330e-01f, -1.69568434e-01f, -1.98671252e-01f, 3.14975046e-02f, 2.20426947e-01f, 2.02107709e-02f, 2.61069149e-01f, 3.57321173e-01f, -2.68169194e-02f,
  -2.65379071e-01f, 4.19824064e-01f, -1.64557919e-01f, -3.75126116e-02f, -5.83454743e-02f, 2.13408843e-01f, 5.45151904e-02f, 1.42536998e-01f, -1.73315778e-02f, 1.53564662e-01f,
  1.28956988e-01f, 7.61580691e-02f, -2.30804197e-02f, -4.63035181e-02f, -1.54920876e-01f, -6.54627802e-04f, 1.61457792e-01f, 9.14103538e-02f, 1.46072460e-02f, 1.97712585e-01f,
  6.94813430e-02f, -2.13465422e-01f, -2.54012235e-02f, -9.73325148e-02f, -7.09315389e-02f, -1.27577841e-01f, 8.36632401e-02f, 4.55393642e-01f, 1.27439220e-02f, 2.40672126e-01f,
  7.14841336e-02f, -9.78463292e-02f, 2.79929936e-01f, 1.97701111e-01f, 5.39854029e-03f, 1.78151116e-01f, -1.82934612e-01f, 3.36720765e-01f, 6.41785860e-02f, -2.43425414e-01f,
  3.41856867e-01f, 3.24110508e-01f, 3.83106887e-01f, 2.15936840e-01f, 2.03086808e-01f, 2.20341265e-01f, 9.31362882e-02f, 2.70074725e-01f, -2.05529526e-01f, 2.86088765e-01f,
  2.96118736e-01f, -3.14976245e-01f, 1.76759079e-01f, 2.80279219e-01f, -3.51397395e-02f, -7.19386525e-03f, 7.74344802e-02f, 1.56773999e-01f, 9.26940143e-02f, -9.22096670e-02f,
  7.22155795e-02f, -1.88870635e-02f, 1.03462085e-01f, 3.03374261e-01f, 3.55209738e-01f, -1.29163742e-01f, 1.62735090e-01f, 3.80319566e-01f, 8.81817117e-02f, 3.20714086e-01f,
  -2.15371415e-01f, 3.15584064e-01f, 2.78152674e-01f, 1.10673316e-01f, -3.73009667e-02f, 2.28731297e-02f, -5.37276156e-02f, 6.03569075e-02f, -1.13519337e-02f, 3.18906717e-02f,
  2.09429711e-01f, 3.38559389e-01f, 2.49905586e-02f, 2.94266373e-01f, 3.35777044e-01f, 2.26604491e-02f, -3.02037094e-02f, 2.35317066e-01f, 6.39044680e-03f, -3.01902711e-01f,
  3.52728754e-01f, 2.52745420e-01f, 3.55737150e-01f, -1.47773907e-01f, -1.26784936e-01f, 5.10965362e-02f, 4.91798073e-01f, -1.29991949e-01f, 8.46962035e-02f, 6.53112754e-02f,
  6.40552193e-02f, 8.68168548e-02f, 1.32757977e-01f, -1.99506715e-01f, 1.65715113e-01f, -2.83187516e-02f, 6.86267018e-02f, 1.51084840e-01f, 1.93493903e-01f, 8.86400603e-03f,
  -1.13716997e-01f, -2.35973641e-01f, 2.11962342e-01f, 6.55036047e-03f, -3.61675680e-01f, 3.13338727e-01f, 1.74135089e-01f, 8.34794044e-02f, 1.51075229e-01f, 3.11702818e-01f,
  2.19536394e-01f, -2.65425593e-01f, 1.49378732e-01f, 1.13576666e-01f, 3.28965813e-01f, -2.31123224e-01f, -9.47241783e-02f, 1.32476881e-01f, -1.09147303e-01f, -4.23304550e-02f,
  -4.89668595e-03f, 1.09461024e-02f, 1.10913895e-01f, -2.81527877e-01f, 3.32185835e-01f, -1.78921178e-01f, 2.96974540e-01f, 8.12977031e-02f, 1.09899871e-01f, 1.59050018e-01f,
  4.00393635e-01f, 5.71905747e-02f, 9.96832699e-02f, 3.51652175e-01f, -2.68520892e-01f, -1.47328913e-01f, 6.56182021e-02f, -2.73660332e-01f, -1.14148706e-01f, 4.72862720e-01f,
  -5.51010296e-02f, -7.13096261e-02f, 2.24340841e-01f, 1.93285897e-01f, -1.55590445e-01f, -1.71527699e-01f, -2.15196367e-02f, -5.79034500e-02f, -1.94694176e-02f, 1.79432660e-01f,
  -2.07224846e-01f, 3.95475812e-02f, -2.09134415e-01f, 4.11440879e-01f, 3.97492409e-01f, 7.40587562e-02f, -7.84118101e-03f, 2.38678500e-01f, 1.40935630e-01f, 3.21306229e-01f,
  2.82493204e-01f, 3.47041458e-01f, -1.07107617e-01f, 1.76741645e-01f, 1.54779315e-01f, 2.43492529e-01f, -3.50537211e-01f, 2.71883994e-01f, 3.99183601e-01f, -4.64926660e-01f,
  -2.35623702e-01f, 4.90101762e-02f, 3.52801591e-01f, -2.24932447e-01f, -1.33582786e-01f, -2.15799794e-01f, 1.97660252e-01f, -7.64456019e-02f, 1.99054554e-02f, 3.27769548e-01f,
  1.59202307e-01f, -1.87721506e-01f, 3.37921083e-01f, 1.17738828e-01f, -2.57728070e-01f, -2.62005150e-01f, -1.43810928e-01f, 2.41850004e-01f, -1.04021551e-02f, 1.48906320e-01f,
  2.97936976e-01f, 2.33881712e-01f, 3.75483334e-01f, 1.10592157e-01f, 2.62749404e-01f, 2.66114086e-01f, 2.24445209e-01f, -1.00885518e-01f, -2.74239361e-01f, -8.32351074e-02f,
  3.08858395e-01f, -2.66037881e-01f, -2.18089104e-01f, 4.06434298e-01f, 2.28675514e-01f, -1.27451733e-01f, -1.93791002e-01f, 8.90300721e-02f, -9.44047570e-02f, -3.83494422e-02f,
  -1.95808515e-01f, 6.04825057e-02f, 1.93058118e-01f, -3.37841004e-01f, -9.38440710e-02f, 1.46312848e-01f, 1.85342222e-01f, -7.59876370e-02f, -3.52765232e-01f, 2.17623755e-01f,
  1.06495485e-01f, 2.37023532e-01f, 2.40066543e-01f, 3.37077290e-01f, 1.15365304e-01f, 3.42296839e-01f, 3.12926737e-03f, 2.28712365e-01f, 1.22361034e-01f, 3.20372403e-01f,
  -1.86396807e-01f, 4.04648423e-01f, 2.87450105e-01f, -2.66411036e-01f, 1.98299497e-01f, 8.38499814e-02f, 1.75405845e-01f, 6.12211190e-02f, 2.20593642e-02f, -2.45275185e-01f,
  1.44952178e-01f, 5.54728741e-03f, 2.21259087e-01f, 2.75532514e-01f, 2.14518338e-01f, 2.69024342e-01f, 3.16709846e-01f, -4.17736247e-02f, -4.25236449e-02f, 5.10645881e-02f,
  -2.07621492e-02f, 2.70349979e-01f, -6.26830012e-02f, 1.02949627e-01f, 3.96912470e-02f, -3.82321477e-02f, 2.12882608e-02f, -1.64193213e-02f, 2.77011395e-02f, 9.74758267e-02f,
  -5.67669980e-02f, 3.86684798e-02f, 9.87865329e-02f, 1.77965298e-01f, 1.97191034e-02f, 2.98671126e-01f, 3.39331031e-01f, 2.29659751e-02f, 3.77158821e-02f, 2.07962841e-01f,
  1.33268431e-01f, -2.13203654e-01f, 2.58221358e-01f, 1.24726027e-01f, 1.65646583e-01f, -1.38887987e-01f, -8.23117793e-02f, -7.94735854e-04f, 2.27592051e-01f, -1.36069581e-01f,
  1.15777880e-01f, 6.64733574e-02f, 1.08783185e-01f, -1.67913362e-01f, -1.83371771e-02f, -8.97743274e-03f, 3.64539802e-01f, -5.58619276e-02f, 2.66508341e-01f, 4.15373370e-02f,
  4.55162615e-01f, 3.22737813e-01f, -2.07386568e-01f, 7.91255087e-02f, -6.32473920e-03f, -1.10001132e-01f, 2.21478134e-01f, 1.13819540e-01f, 3.05829402e-02f, 5.10992229e-01f,
  -5.30553639e-01f, 1.82403773e-01f, 2.94972807e-01f, 4.79981601e-01f, 1.52846545e-01f, -1.78231180e-01f, 2.28227705e-01f, -1.04700066e-02f, -3.67022604e-01f, 2.21052334e-01f,
  -3.23701371e-03f, -3.04514378e-01f, 5.13869345e-01f, 4.08126920e-01f, 3.23037356e-01f, 2.24096507e-01f, -1.73067227e-01f, 3.56431305e-01f, 1.72020853e-01f, 2.94722378e-01f,
  1.91440970e-01f, 2.62133658e-01f, 2.48351157e-01f, 4.44280766e-02f, 2.19707370e-01f, 1.15974613e-01f, -1.71734631e-01f, -5.85925654e-02f, -3.65717001e-02f, 9.82727259e-02f,
  -1.80170357e-01f, 3.37567717e-01f, -8.42199288e-03f, -5.42841665e-02f, -2.78664440e-01f, -2.05272436e-01f, -4.49795537e-02f, 7.55238831e-02f, 4.56619859e-02f, 2.09315673e-01f,
  4.17554975e-01f, -3.86960715e-01f, -4.25403081e-02f, 3.58207792e-01f, -2.55213350e-01f, -4.50844020e-02f, -1.34171963e-01f, 1.70410145e-02f, 3.91158372e-01f, 1.26718534e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  2.75317997e-01f, 3.22728813e-01f, 3.20819169e-02f, 3.71880800e-01f, -3.18449810e-02f, 6.73816260e-03f, 2.93880969e-01f, 3.08375478e-01f, -2.71214489e-02f, 1.85561165e-01f,
  3.55937719e-01f, 1.54308245e-01f, 2.53797192e-02f, 3.20809543e-01f, 2.05389380e-01f, 1.68925881e-01f, 1.84622809e-01f, -1.75151825e-02f, 3.27872664e-01f, 2.77712822e-01f
};

// L2_fan_Wp (Shape: 6 x 32)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  2.13607270e-02f, -1.69193577e-02f, -6.23720288e-02f, 1.76990986e-01f, -1.08567104e-01f, 1.49356127e-01f, 1.28101245e-01f, -1.19126223e-01f, -2.38614660e-02f, 6.80256560e-02f,
  -7.95749649e-02f, 5.23989648e-02f, 8.15566629e-02f, -3.08135990e-02f, -1.32906467e-01f, -4.69321050e-02f, 1.12497006e-02f, 7.44430944e-02f, 6.68819174e-02f, 1.16941482e-01f,
  2.47882772e-02f, -8.02593604e-02f, 6.67163208e-02f, 5.89041933e-02f, 1.63126420e-02f, -1.61165416e-01f, 5.82856089e-02f, -3.62191051e-02f, 3.00485715e-02f, 1.86847113e-02f,
  -3.12327892e-01f, 1.80671979e-02f, -5.12749664e-02f, -1.83557525e-01f, -5.71964122e-02f, -4.15657684e-02f, 1.26073480e-01f, -8.73152539e-02f, 2.70119011e-02f, 2.19850421e-01f,
  -5.82514629e-02f, -1.65143907e-01f, 4.57773097e-02f, -6.09200262e-02f, -4.93729152e-02f, -1.30977243e-01f, -6.36447445e-02f, -6.36701435e-02f, -4.22882289e-02f, -1.52031817e-02f,
  5.75307757e-02f, -2.39037886e-01f, -1.46009609e-01f, -2.44171560e-01f, 1.83980435e-01f, -8.90485197e-02f, 8.71701315e-02f, 6.12192275e-03f, -8.58614966e-02f, -2.01674681e-02f,
  -8.48720819e-02f, 1.78898703e-02f, 2.43483171e-01f, -1.55188650e-01f, -3.25794183e-02f, -7.43995681e-02f, -4.37121354e-02f, -4.25011069e-02f, -4.24224623e-02f, -8.56414288e-02f,
  4.77411272e-03f, 4.16585915e-02f, 2.56146975e-02f, -1.89286053e-01f, 1.09013103e-01f, -1.07321609e-02f, -3.66989747e-02f, 9.23966542e-02f, 1.72234681e-02f, -1.56617105e-01f,
  8.56629312e-02f, -8.97539034e-02f, -5.38753867e-02f, -1.36237264e-01f, -9.96095091e-02f, 6.64361492e-02f, 2.58383229e-02f, -2.06397340e-01f, -5.01325727e-02f, 1.09641075e-01f,
  -6.62879646e-02f, 7.49927089e-02f, -1.24482639e-01f, -9.46487188e-02f, 1.59850970e-01f, -5.58012985e-02f, 1.05071582e-01f, -1.34557292e-01f, 7.64141977e-02f, 5.46238199e-02f,
  4.58508395e-02f, -5.02986349e-02f, 1.32869065e-01f, 2.66305417e-01f, -1.65309623e-01f, -3.76386717e-02f, 4.06800583e-02f, -2.57269181e-02f, 1.03115439e-02f, -3.02013814e-01f,
  -9.61488951e-03f, -8.25235471e-02f, 1.87534273e-01f, 6.18079379e-02f, -3.68037149e-02f, -2.92495042e-01f, -7.28820711e-02f, -2.34916836e-01f, 6.28840253e-02f, -7.17329681e-02f,
  3.98055390e-02f, 2.02911586e-01f, -9.50167552e-02f, -1.34711623e-01f, 1.30376831e-01f, 3.67797390e-02f, -1.11365519e-01f, -1.25550687e-01f, -1.94991484e-01f, 3.86812957e-03f,
  -2.73895741e-01f, 5.63226528e-02f, -1.24214612e-01f, -9.04360712e-02f, -1.18795834e-01f, -1.22621812e-01f, 7.08394274e-02f, -8.36988853e-04f, -1.45620424e-02f, -1.37948334e-01f,
  1.94814950e-02f, -1.69916913e-01f, -1.44080222e-01f, -3.08281425e-02f, -1.36874035e-01f, 5.93095832e-02f, 1.46868408e-01f, 4.30419259e-02f, 1.65328503e-01f, -5.20673282e-02f,
  -4.95296158e-02f, 3.26908603e-02f, -2.06302166e-01f, -3.08080856e-02f, 1.86573714e-01f, 1.60912737e-01f, 1.37651518e-01f, -6.92338645e-02f, -4.98705469e-02f, 2.22369894e-01f,
  -1.60107717e-01f, 1.22949034e-01f, -1.13543615e-01f, -1.81801140e-01f, -7.77307302e-02f, -1.20539911e-01f, -1.13038626e-02f, -1.50113583e-01f, 1.32969737e-01f, -2.34609500e-01f,
  7.63079450e-02f, -1.14626832e-01f, -1.34368435e-01f, -4.49372344e-02f, -7.43450597e-02f, -1.76480472e-01f, 3.19096260e-02f, 8.28381330e-02f, 1.42005458e-01f, -4.78777997e-02f,
  2.63846874e-01f, 5.94265796e-02f, 6.04059594e-03f, -1.69986397e-01f, -1.94232881e-01f, 2.19567731e-01f, -3.33669409e-02f, 1.64825007e-01f, -1.26968035e-02f, -4.19512913e-02f,
  -2.93298662e-02f, 1.51157752e-01f
};

// L2_fan_Wp_bar (Shape: 20 x 32)
const int L2_fan_Wp_bar_rows = 20;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  2.51131207e-02f, 1.23451479e-01f, -7.34230503e-02f, 1.14067346e-02f, 9.30541977e-02f, 1.39486551e-01f, -2.80203074e-01f, -1.19572297e-01f, 1.61045328e-01f, 3.80413830e-02f,
  1.16291031e-01f, -1.04032606e-01f, 3.44921559e-01f, 4.32856381e-02f, -7.25613013e-02f, 3.02110642e-01f, -2.17624739e-01f, -3.22427042e-02f, 8.46516639e-02f, 1.13128871e-01f,
  1.47876441e-01f, -9.36718509e-02f, 1.74109459e-01f, 1.82058904e-02f, -2.27015167e-01f, 8.46811086e-02f, 4.62095380e-01f, 2.63968378e-01f, 2.37705618e-01f, -1.13085441e-01f,
  -9.38547030e-02f, 3.69161099e-01f, 1.65557191e-02f, 9.19167995e-02f, 3.54504079e-01f, 2.74988502e-01f, 1.30571991e-01f, 2.94609815e-01f, -2.04058334e-01f, 3.09450328e-01f,
  -3.74062508e-01f, 3.04632336e-01f, 2.51557529e-01f, 1.63123026e-01f, 1.20990314e-01f, 2.14798898e-01f, -1.73291981e-01f, 1.62199467e-01f, -3.86839986e-01f, -1.56352371e-01f,
  -2.43180603e-01f, 1.41439274e-01f, -3.29218447e-01f, -8.46239775e-02f, 4.64754850e-01f, 1.99461117e-01f, -2.32211739e-01f, -1.16437748e-02f, 2.54070640e-01f, 3.31018209e-01f,
  1.05664693e-01f, 7.70701990e-02f, 3.95577222e-01f, -2.37741947e-01f, 2.80584812e-01f, 5.39760701e-02f, 3.01693022e-01f, 5.21977013e-03f, 2.62408346e-01f, 7.80026466e-02f,
  2.80765802e-01f, -2.51561195e-01f, 9.80378389e-02f, -9.21197534e-02f, -8.30614418e-02f, -1.31224856e-01f, -2.05357715e-01f, -1.87060609e-01f, 3.52208823e-01f, 2.88945347e-01f,
  4.47670817e-01f, 2.37756502e-02f, 3.83794367e-01f, 1.14984894e-02f, 1.46757495e-02f, -1.51593909e-02f, 2.20437050e-01f, 2.56826162e-01f, 5.42120099e-01f, 2.03860700e-01f,
  -2.42514536e-01f, -2.80489564e-01f, 2.46934444e-02f, 2.97193140e-01f, 2.23982811e-01f, 1.74933653e-02f, 2.63118714e-01f, 1.38481051e-01f, 2.63605088e-01f, 5.74823581e-02f,
  5.53543605e-02f, 1.76926434e-01f, -1.24055631e-01f, 2.71032423e-01f, -1.47954315e-01f, -9.14370939e-02f, 2.17170402e-01f, -1.77648157e-01f, 9.78777111e-02f, -2.89062768e-01f,
  7.95885175e-02f, 4.10150021e-01f, 7.48692453e-02f, -2.86245912e-01f, 1.35099038e-01f, 6.06666803e-02f, -1.56182349e-01f, -7.64901862e-02f, 4.43667620e-01f, 6.99376836e-02f,
  4.51323427e-02f, 3.28614831e-01f, 2.30924040e-01f, 1.75579846e-01f, 3.77381623e-01f, 1.57664239e-01f, 5.32734275e-01f, -1.21597148e-01f, -2.29346111e-01f, 1.49037883e-01f,
  -1.72192499e-01f, 3.53942662e-02f, 5.25499098e-02f, -9.02484730e-02f, -2.81189978e-01f, -1.95053011e-01f, 4.57181549e-03f, 2.38740087e-01f, -6.02947781e-03f, 2.28443258e-02f,
  2.78675854e-01f, 2.74373263e-01f, -2.74364073e-02f, 2.34262064e-01f, 1.59432992e-01f, 5.06277084e-02f, -4.87160310e-02f, 2.35865727e-01f, 4.60755497e-01f, 1.64331794e-01f,
  1.55951217e-01f, -1.35466471e-01f, -8.01398978e-02f, -1.25380591e-01f, 3.32004100e-01f, 3.17025930e-01f, 2.15631649e-01f, -3.47846858e-02f, -5.64752035e-02f, 2.23369449e-01f,
  -2.50165164e-01f, 1.87413067e-01f, -2.19875798e-01f, -5.71692511e-02f, -6.43766001e-02f, -3.18401903e-01f, -5.91896288e-02f, -1.00110680e-01f, 1.99742600e-01f, 6.64482638e-02f,
  -2.27600168e-02f, 4.84632514e-02f, 7.67846256e-02f, 1.66926444e-01f, -2.51752492e-02f, -2.61993185e-02f, 2.06074789e-01f, 3.80114287e-01f, 4.83458638e-02f, 2.41052762e-01f,
  3.68855685e-01f, 1.61754891e-01f, 7.64740184e-02f, -1.97149962e-02f, -3.15921195e-02f, 7.43715167e-02f, 2.28526533e-01f, 1.02211192e-01f, 2.44890228e-01f, 8.28043651e-03f,
  -1.58509150e-01f, 2.98450500e-01f, 1.98232606e-01f, 1.83737978e-01f, 1.65270433e-01f, 8.95370319e-02f, 2.09802613e-01f, 1.27475038e-01f, 1.99135244e-01f, -1.37084857e-01f,
  -1.63011596e-01f, -2.11778522e-01f, -4.82676253e-02f, -3.79194617e-02f, -1.86310098e-01f, -2.76603997e-01f, 3.34791303e-01f, -1.23260589e-02f, 3.71268727e-02f, -7.27968216e-02f,
  1.47179022e-01f, 1.63908392e-01f, -9.18902531e-02f, 1.50100186e-01f, 2.77672887e-01f, 3.77933562e-01f, 1.81015402e-01f, 1.27586052e-01f, -2.30953902e-01f, -2.03068450e-01f,
  2.93645710e-01f, 1.88009009e-01f, 2.70767123e-01f, 7.36168772e-02f, 1.60357267e-01f, 1.29737422e-01f, 2.03132898e-01f, 6.30168542e-02f, 1.44792005e-01f, 1.38555825e-01f,
  -1.67490348e-01f, 1.72276467e-01f, 2.65359610e-01f, -2.28687644e-01f, 4.31126356e-01f, -2.10162938e-01f, 2.87210464e-01f, 5.95876090e-02f, -2.87225902e-01f, 1.63939044e-01f,
  2.50767060e-02f, -2.05633476e-01f, 5.94620481e-02f, -3.10320348e-01f, 7.03660995e-02f, -2.84942329e-01f, 2.95408428e-01f, -2.31265962e-01f, -8.34013075e-02f, 3.57729435e-01f,
  5.02773114e-02f, 3.77299458e-01f, 1.61852594e-03f, -3.56844336e-01f, 1.44000202e-01f, 1.55860335e-01f, 2.80064464e-01f, 1.14364177e-01f, -6.88074008e-02f, 7.95606058e-03f,
  -1.01114977e-02f, 6.00523911e-02f, -2.76843533e-02f, -3.45631450e-01f, 4.53805089e-01f, -3.72527808e-01f, 2.13341564e-01f, -1.02957740e-01f, 1.56486347e-01f, 1.42896906e-01f,
  -3.47557180e-02f, 1.90843508e-01f, 1.50087118e-01f, -4.66895811e-02f, 3.20830971e-01f, -1.61813259e-01f, 2.37053484e-01f, -1.92215115e-01f, 7.50098377e-02f, -2.49176174e-01f,
  -1.14623383e-01f, 3.09526801e-01f, -7.00024441e-02f, 2.67116457e-01f, -7.97152221e-02f, -1.28461733e-01f, -1.60144046e-01f, 4.34432477e-01f, 1.89839497e-01f, 1.23664737e-01f,
  -7.70756081e-02f, -1.20726466e-01f, 6.76974729e-02f, 1.57263741e-01f, -1.10071853e-01f, -1.43723741e-01f, 4.30468529e-01f, -5.08072019e-01f, 2.91663349e-01f, -1.95368320e-01f,
  2.68007554e-02f, 7.04517066e-02f, -1.10103227e-01f, -1.13526331e-02f, 1.26899719e-01f, -1.96911231e-01f, 2.67795205e-01f, -2.27304563e-01f, 1.14795215e-01f, -1.08645990e-01f,
  1.31277010e-01f, 2.60628015e-03f, 6.10255823e-02f, 4.93582666e-01f, -1.03462949e-01f, 3.03723812e-01f, 7.24644065e-02f, -1.88456684e-01f, 3.46225709e-01f, 2.14566305e-01f,
  4.59081195e-02f, 2.22120002e-01f, -1.55286178e-01f, 1.58674106e-01f, 1.59775931e-02f, 4.13194112e-02f, -1.04625173e-01f, -2.89733410e-01f, 1.39670908e-01f, 4.14278693e-02f,
  -3.57750505e-02f, -7.95082003e-02f, 2.60075867e-01f, 9.89097431e-02f, 8.43527541e-03f, -1.78798605e-02f, -2.37675175e-01f, 2.38379434e-01f, 2.99242616e-01f, 2.93782890e-01f,
  3.08877975e-01f, 3.00228626e-01f, 7.59463832e-02f, 1.43145457e-01f, -1.58300236e-01f, -7.05349492e-03f, 2.41129890e-01f, 1.76635161e-01f, 2.18620226e-01f, -5.10331951e-02f,
  -1.03718556e-01f, 3.84141475e-01f, 2.11124733e-01f, 7.07586855e-02f, -9.01927240e-03f, 3.02044481e-01f, 1.52278468e-01f, 2.30742782e-01f, 5.88509478e-02f, -1.65142670e-01f,
  -8.03079754e-02f, 3.69302481e-01f, -2.34452784e-01f, 6.48487955e-02f, -2.11912259e-01f, 1.79430917e-01f, 2.39571571e-01f, -2.18892813e-01f, -4.10588026e-01f, 3.51740956e-01f,
  4.41565812e-01f, 5.02192795e-01f, -1.16409980e-01f, 4.48137522e-01f, 1.60794586e-01f, 4.41727698e-01f, 6.72832802e-02f, -3.56716007e-01f, -4.53805132e-03f, 4.99729700e-02f,
  1.85061216e-01f, 2.14743286e-01f, 3.27489674e-01f, 2.57993490e-01f, 1.70893162e-01f, -5.34514077e-02f, 3.15571755e-01f, -3.68835479e-02f, 7.32995868e-02f, 3.57943624e-02f,
  1.69659953e-03f, -3.07780434e-03f, -6.54320270e-02f, -1.15949407e-01f, -1.14468798e-01f, 8.64003077e-02f, -5.12183197e-02f, -3.19365859e-02f, 2.77486593e-01f, 5.39231777e-01f,
  4.27653372e-01f, 4.29451326e-03f, -2.30180472e-01f, -1.71253830e-01f, 6.73448890e-02f, -2.07498878e-01f, 3.48643772e-02f, 1.71766326e-01f, 3.51271003e-01f, 1.33848101e-01f,
  -2.92040974e-01f, -2.17876881e-01f, 7.49634355e-02f, 1.73347861e-01f, 1.88149899e-01f, -2.24230066e-01f, 1.51532799e-01f, 2.58015580e-02f, 2.39622891e-01f, 9.89496931e-02f,
  4.16410007e-02f, 2.04044089e-01f, -2.11284503e-01f, 4.39185709e-01f, 3.62886526e-02f, -1.55505642e-01f, 3.20300490e-01f, -2.30481833e-01f, 1.27742723e-01f, -5.69399372e-02f,
  -9.67214704e-02f, 5.95050417e-02f, 5.49798552e-03f, -1.08258851e-01f, -1.19305164e-01f, -2.30041042e-01f, -1.37933016e-01f, -3.13149899e-01f, 3.24733675e-01f, -5.43834753e-02f,
  -5.14529645e-02f, 4.33712274e-01f, 1.17407225e-01f, 3.22059184e-01f, 2.34546095e-01f, -1.62289456e-01f, 4.09854084e-01f, 6.46548718e-02f, -5.63841835e-02f, 2.58163273e-01f,
  1.73905373e-01f, 2.06844509e-01f, 7.28289261e-02f, -8.96103904e-02f, -2.69399583e-01f, 9.46155842e-03f, -2.96492666e-01f, 4.09722000e-01f, -2.49097615e-01f, 9.50864479e-02f,
  8.93153846e-02f, -5.36185130e-02f, 1.58138331e-02f, 3.10163558e-01f, 1.11071736e-01f, 1.27963498e-01f, -2.05137163e-01f, 3.36557180e-01f, 1.53590426e-01f, 1.96402892e-01f,
  3.24890643e-01f, 2.77126223e-01f, -1.11136362e-01f, -2.06148535e-01f, 4.23063993e-01f, -3.68194208e-02f, 4.15368497e-01f, 7.72063714e-03f, -1.99428752e-01f, -1.13386109e-01f,
  8.36145226e-03f, 1.27987638e-01f, -5.73458672e-02f, 7.20924586e-02f, 1.66260317e-01f, 1.81196213e-01f, -2.75238663e-01f, 1.35086015e-01f, 1.18506201e-01f, -4.41297926e-02f,
  2.41977468e-01f, -2.18882143e-01f, 4.09935653e-01f, -2.99074152e-03f, -2.73218542e-01f, 2.26556420e-01f, -1.75439671e-01f, -1.62911400e-01f, 2.37058043e-01f, 4.65012826e-02f,
  9.15470123e-02f, -1.39742251e-02f, 3.59679461e-01f, -2.06003904e-01f, -3.07542115e-01f, 2.06969351e-01f, 4.11702275e-01f, 3.93713623e-01f, 2.36139387e-01f, -1.79423019e-01f,
  2.07441121e-01f, 2.84451485e-01f, 2.47191057e-01f, -8.30878988e-02f, 1.88459933e-01f, 2.93064743e-01f, 1.43384248e-01f, 3.23380738e-01f, -5.36590666e-02f, -1.26367629e-01f,
  2.33332708e-01f, 1.28977433e-01f, 1.86738938e-01f, 3.40936601e-01f, -7.14416206e-02f, 7.47318625e-01f, 1.01458497e-01f, -3.01203847e-01f, -1.33150220e-01f, 4.09378022e-01f,
  3.39453787e-01f, 3.62496674e-02f, -1.00580171e-01f, 6.16713129e-02f, -2.03865588e-01f, -1.51592359e-01f, 3.39834899e-01f, -1.04183048e-01f, -3.33882809e-01f, 2.49365717e-01f,
  -5.06206930e-01f, -5.65850697e-02f, 2.89611816e-01f, 2.94125676e-01f, -4.36891429e-02f, -4.25424017e-02f, -2.13608332e-02f, 1.53326765e-01f, -7.01395199e-02f, -4.78539104e-03f,
  -2.77388483e-01f, 7.89790601e-02f, 1.03818730e-01f, 1.35731801e-01f, 1.64159328e-01f, -9.14965943e-02f, 3.47504079e-01f, 3.64749551e-01f, -1.69861540e-02f, 2.29730323e-01f,
  5.40919192e-02f, 1.99358940e-01f, 3.04154065e-02f, -2.25988459e-02f, 4.09982264e-01f, 1.45454288e-01f, -1.15334727e-02f, -7.71402195e-02f, 4.21476066e-02f, 1.34412616e-01f,
  1.14870675e-01f, 4.08663630e-01f, 1.40154615e-01f, -1.24831885e-01f, -1.09950699e-01f, 4.06680197e-01f, -2.43106689e-02f, -5.90917952e-02f, 1.22416399e-01f, -4.38368097e-02f,
  4.54796329e-02f, -4.87513058e-02f, -1.40928268e-01f, 3.28002721e-01f, 1.07132487e-01f, -1.71700642e-01f, 2.29337916e-01f, -1.40813859e-02f, -9.00997743e-02f, 6.53168857e-02f,
  1.74076005e-03f, -2.01913249e-02f, -3.05492152e-02f, -1.91347718e-01f, 1.50713056e-01f, -1.75905466e-01f, -1.72680631e-01f, -4.30768393e-02f, 2.81881005e-01f, 2.05674525e-02f,
  6.60828361e-03f, 4.06058997e-01f, -5.64959981e-02f, 2.54468232e-01f, -1.64823517e-01f, -5.40963048e-03f, 6.00539088e-01f, -1.78560868e-01f, -8.74713287e-02f, 1.05298512e-01f,
  1.12459816e-01f, 1.60850152e-01f, 3.16847004e-02f, -5.40065859e-03f, -2.67347813e-01f, 1.06964335e-01f, -1.51267976e-01f, 2.71391332e-01f, 2.66782641e-02f, 6.05644621e-02f,
  2.79876530e-01f, 1.82398036e-01f, -4.76599261e-02f, 4.35352176e-01f, 3.38451236e-01f, 5.57713583e-02f, -4.14824516e-01f, 3.59071605e-02f, 2.50327528e-01f, 5.08355126e-02f,
  1.23310469e-01f, 9.70764458e-03f, 2.48180702e-02f, -7.52793029e-02f, 3.85177463e-01f, -6.47464097e-02f, 1.93626657e-01f, -4.62877713e-02f, -3.18924099e-01f, -6.22293465e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 20)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 20;
const float L2_fan_Bp_bar_data[] = {
  -1.70829444e-04f, 1.69659436e-01f, 2.41475150e-01f, 3.00541937e-01f, -2.21862067e-02f, -3.40285935e-02f, 1.06099278e-01f, 1.54497609e-01f, 1.04687372e-02f, 5.55082485e-02f,
  9.04364418e-03f, 9.13205519e-02f, 5.90724573e-02f, 7.92906657e-02f, 9.06884149e-02f, 1.76024750e-01f, 3.17265511e-01f, 1.06980778e-01f, 2.13792622e-01f, 9.35953185e-02f
};

// L3_fan_Wp (Shape: 6 x 32)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  4.84734215e-02f, 1.51243761e-01f, -1.08064584e-01f, -1.69372335e-02f, -3.74246351e-02f, -4.20781560e-02f, -6.11586086e-02f, 8.09798390e-02f, 1.23955242e-01f, 8.59762449e-03f,
  -2.10946366e-01f, 6.57104775e-02f, -1.77760959e-01f, 2.01962180e-02f, 6.09777793e-02f, -2.93501304e-03f, -1.68960616e-01f, 8.50043446e-03f, 3.61873247e-02f, 1.93532947e-02f,
  5.65515272e-02f, 1.47249907e-01f, -9.66050923e-02f, 1.33337066e-01f, -7.72930384e-02f, 1.34596065e-01f, -1.54349491e-01f, 3.93609330e-02f, 1.37077808e-01f, -1.44089937e-01f,
  9.63878259e-02f, -5.25477864e-02f, -8.79177451e-02f, -8.08301643e-02f, 3.37218307e-02f, 2.23060790e-02f, 7.83235356e-02f, -4.71560955e-02f, 3.58683653e-02f, 4.05206457e-02f,
  4.03724657e-03f, -2.05170922e-03f, -8.19695517e-02f, -5.69401979e-02f, -1.10113919e-01f, -1.83534657e-03f, 1.17878482e-01f, 7.85531476e-02f, -1.31357938e-01f, -7.21309409e-02f,
  9.80853755e-03f, -1.20770730e-01f, -1.15884580e-02f, -2.40173214e-03f, -1.34238943e-01f, -4.15396271e-03f, 1.84305817e-01f, -2.21129626e-01f, 6.39101937e-02f, 7.39463568e-02f,
  -1.17787115e-01f, -9.48314220e-02f, -8.31140205e-02f, -2.93085817e-02f, 8.51133559e-03f, 4.03010566e-03f, 1.47648022e-01f, 5.60763068e-02f, 1.65305734e-02f, 6.46267161e-02f,
  9.03975293e-02f, -1.56591311e-01f, -5.72306365e-02f, -5.03313877e-02f, 2.04682171e-01f, -5.34307733e-02f, 7.06890151e-02f, -1.23231299e-01f, 1.79997608e-01f, 1.22699039e-02f,
  4.74726642e-03f, -1.35344386e-01f, 1.55661404e-01f, 1.05305552e-01f, 1.25083014e-01f, 1.21046677e-01f, 1.35011911e-01f, 1.24850109e-01f, -3.98908406e-02f, 8.76653567e-02f,
  -2.26898536e-01f, 4.14553005e-03f, -2.58234978e-01f, -7.11431876e-02f, -1.88100994e-01f, -1.30099192e-01f, -1.37692271e-02f, 3.45110632e-02f, -5.21032065e-02f, 9.99204349e-03f,
  7.49166980e-02f, -5.33683971e-02f, 4.03022654e-02f, 6.81678057e-02f, -1.05659112e-01f, -5.49186245e-02f, -1.31513804e-01f, -5.23149595e-02f, 3.22926082e-02f, -2.78985500e-02f,
  9.44652930e-02f, -1.94653608e-02f, 3.68272737e-02f, 3.95091027e-02f, 1.48451313e-01f, -8.03531408e-02f, -1.54906347e-01f, -2.36593962e-01f, -1.20380275e-01f, 1.13225169e-01f,
  1.36945635e-01f, -1.27715692e-01f, -3.96907218e-02f, -1.34320512e-01f, -1.80209288e-03f, 7.86106214e-02f, 1.17855497e-01f, 2.35079359e-02f, 1.28449425e-01f, 6.96844533e-02f,
  8.76800790e-02f, -5.34818843e-02f, 1.26578793e-01f, -2.32503284e-02f, 4.57850248e-02f, -5.98489791e-02f, -4.81265001e-02f, -4.81379963e-02f, 1.36886938e-02f, -4.88763489e-02f,
  -6.96852878e-02f, -1.09994439e-02f, -5.12575451e-03f, -1.92429259e-01f, -4.97205220e-02f, -2.93645798e-03f, 9.47410166e-02f, -1.47149593e-01f, -1.98365271e-01f, -1.49255380e-01f,
  1.25211537e-01f, 2.29377195e-01f, -1.57817990e-01f, 6.11018129e-02f, 1.79408088e-01f, 6.48839921e-02f, 1.07412226e-01f, 1.05322398e-01f, 3.41505930e-02f, -7.48866471e-03f,
  1.49406129e-02f, 1.28020719e-02f, 8.03163871e-02f, 5.06000267e-03f, -5.52811921e-02f, -9.47752446e-02f, -5.31844981e-03f, 8.22079554e-02f, -2.18124669e-02f, 2.93661430e-02f,
  7.59507045e-02f, 8.73960108e-02f, 1.41394794e-01f, -1.91631749e-01f, 2.06112459e-01f, -9.86895561e-02f, 7.98092410e-02f, 1.06065206e-01f, 1.56483486e-01f, 9.49594937e-03f,
  1.01462089e-01f, 4.55160663e-02f, -2.31093690e-02f, -1.57027930e-01f, 4.01293002e-02f, 6.59834892e-02f, -2.15635315e-01f, 1.12648690e-02f, -1.15518626e-02f, 5.45755960e-02f,
  -1.15269050e-01f, -1.55271828e-01f
};

// L3_fan_Wp_bar (Shape: 20 x 32)
const int L3_fan_Wp_bar_rows = 20;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  -3.48530486e-02f, 9.27401558e-02f, 1.45216927e-01f, 1.72891751e-01f, 2.19610184e-01f, 1.57486677e-01f, -7.94764906e-02f, 1.77704662e-01f, 2.00969204e-01f, 1.99752040e-02f,
  -2.90545046e-01f, -1.35108814e-01f, -5.35643399e-02f, 5.42543590e-01f, 1.10241525e-01f, 2.97944307e-01f, -2.97140568e-01f, -2.74703830e-01f, 1.16716184e-01f, 2.59187788e-01f,
  -1.84661463e-01f, 2.68759549e-01f, -3.57145891e-02f, 3.60146970e-01f, -6.22712374e-02f, 2.50267118e-01f, -1.41878113e-01f, 3.49371769e-02f, 3.41982871e-01f, -1.98828518e-01f,
  3.53568375e-01f, -3.26262802e-01f, -1.02052873e-03f, 3.30405869e-02f, -5.16984612e-02f, 7.59336725e-03f, 6.25693053e-02f, 1.17915601e-01f, -7.13763982e-02f, 7.04240352e-02f,
  1.44580454e-01f, -1.92511126e-01f, 2.11821869e-02f, -9.30919871e-02f, 2.60333568e-01f, 4.77689773e-01f, -2.94057187e-02f, 4.82966930e-01f, -5.08267172e-02f, -2.15016939e-02f,
  2.04661831e-01f, 9.95732769e-02f, -2.24518180e-01f, 1.03369631e-01f, -4.80519421e-02f, 1.96057782e-01f, -2.17276588e-01f, 2.66950846e-01f, 3.07876647e-01f, 3.27758700e-01f,
  -2.22767249e-01f, -1.33270979e-01f, 2.81670690e-01f, -4.42942046e-02f, -7.38207474e-02f, 2.45176628e-01f, 1.11863315e-01f, 2.87923843e-01f, -2.97328494e-02f, 1.16882227e-01f,
  -2.88008600e-01f, 2.34957889e-01f, -1.70269776e-02f, 2.66795933e-01f, -2.76067793e-01f, -1.93204135e-01f, -1.05262958e-01f, 2.79316187e-01f, 1.14660442e-01f, 3.57434571e-01f,
  -2.16712318e-02f, -2.45220050e-01f, -2.59742904e-02f, 2.29099363e-01f, -2.91439801e-01f, -2.98992693e-02f, -2.49822140e-01f, -2.56496578e-01f, 4.40505356e-01f, 4.09581512e-01f,
  -1.86347798e-01f, 7.23660886e-02f, -2.39886846e-02f, 9.71176475e-02f, 3.24327618e-01f, 6.35338053e-02f, 1.34321423e-02f, 1.58929855e-01f, -8.08884390e-03f, -1.06899645e-02f,
  -8.51109773e-02f, -1.71505228e-01f, 9.75720286e-02f, -1.23476163e-01f, -1.22902349e-01f, -8.12492967e-02f, 3.32296193e-01f, 2.36142520e-02f, 3.76141965e-01f, -1.16044749e-02f,
  6.67306632e-02f, 8.08983296e-02f, 4.11751419e-01f, 3.16427946e-01f, 1.77673236e-01f, -2.03054268e-02f, -1.94809660e-02f, -1.09065615e-01f, 4.66355741e-01f, 3.09428364e-01f,
  -2.81760514e-01f, 5.78195415e-02f, 4.73537862e-01f, 3.45514238e-01f, -5.48004389e-01f, 2.46274754e-01f, -1.59045756e-01f, 1.32535100e-01f, 1.06649451e-01f, 4.31891829e-02f,
  7.51402900e-02f, -9.68224406e-02f, -2.91537698e-02f, -1.04417048e-01f, 1.18250893e-02f, -1.55438632e-01f, -2.53657967e-01f, -8.49852487e-02f, -1.54259831e-01f, 1.17506340e-01f,
  -8.43700618e-02f, -4.61365938e-01f, 1.81042925e-01f, -3.30175430e-01f, 1.87506869e-01f, 3.43359292e-01f, -4.14177738e-02f, -1.94096208e-01f, 4.74649966e-02f, -1.31182730e-01f,
  1.15770549e-01f, 3.60658407e-01f, 1.78026214e-01f, -2.65138358e-01f, 2.33553983e-02f, -1.77164808e-01f, 5.19919157e-01f, 2.38706410e-01f, -1.77632809e-01f, 8.32732469e-02f,
  4.05471660e-02f, 2.20638774e-02f, 6.40342534e-02f, 9.04762596e-02f, -1.34710178e-01f, 7.50719849e-03f, 4.47104573e-02f, 3.59784439e-02f, -3.32331024e-02f, -4.51824553e-02f,
  8.95983130e-02f, -6.93118647e-02f, 3.56095612e-01f, 1.87050983e-01f, -1.95053115e-01f, -9.57998484e-02f, 3.91153663e-01f, 1.90906689e-01f, -3.66417289e-01f, 7.72805186e-03f,
  -1.14643782e-01f, -9.90608409e-02f, 1.80092663e-01f, -2.30295770e-02f, -2.51472652e-01f, 1.02575198e-01f, 1.29995108e-01f, 2.34168559e-01f, 2.71241695e-01f, 3.77970695e-01f,
  1.64040208e-01f, 1.63172722e-01f, 9.48088430e-03f, 2.38564104e-01f, 1.29220951e-02f, 1.20739497e-01f, 1.73791841e-01f, 4.15991917e-02f, -1.59781486e-01f, 8.94888043e-02f,
  -4.27825972e-02f, -2.10253848e-03f, -2.42672473e-01f, -1.12561040e-01f, -1.49589956e-01f, 1.25254691e-01f, 4.21704948e-01f, 4.18455392e-01f, -1.95447296e-01f, -1.75103456e-01f,
  3.82868141e-01f, 1.44608304e-01f, -1.43858761e-01f, 1.60642117e-01f, -4.33543883e-02f, 2.29606658e-01f, 1.92109898e-01f, 1.67921960e-01f, -1.60127684e-01f, 2.10988186e-02f,
  1.92863047e-01f, -1.35056563e-02f, 4.15540189e-01f, -2.79321820e-01f, 7.67464042e-02f, -9.80547220e-02f, 5.76150194e-02f, 1.96653437e-02f, -3.23192663e-02f, -1.45515501e-01f,
  5.93558662e-02f, -2.01788947e-01f, -2.51594067e-01f, -2.19129011e-01f, 3.16601485e-01f, 1.93965867e-01f, 4.42649364e-01f, -2.76935130e-01f, -1.96865812e-01f, -1.74926043e-01f,
  4.26375240e-01f, 3.90197814e-01f, -2.98321366e-01f, 1.89401925e-01f, 3.88519436e-01f, 2.43315428e-01f, 3.63385201e-01f, 1.94430694e-01f, -2.52947807e-01f, -3.63396364e-03f,
  -1.18590407e-02f, 2.62302965e-01f, 3.06321591e-01f, 5.16677499e-01f, -1.99712232e-01f, -1.44138634e-02f, 1.37465239e-01f, 1.86799001e-02f, -3.02156899e-03f, 1.63435116e-01f,
  3.86974476e-02f, 4.92176004e-02f, 1.64537430e-01f, -2.19955117e-01f, -2.26420611e-01f, 1.01034671e-01f, 1.33404508e-01f, -1.81643128e-01f, 6.15157373e-02f, 3.22580665e-01f,
  -1.40491322e-01f, 1.84292853e-01f, 1.36175081e-01f, -5.60111366e-02f, -5.86898997e-04f, -5.36549883e-03f, -2.62583792e-01f, -4.10692900e-01f, -9.83419176e-03f, 7.58203445e-03f,
  2.34321907e-01f, 5.24849780e-02f, 5.16780555e-01f, 2.08419397e-01f, -1.70897305e-01f, 1.07257672e-01f, -4.31172282e-01f, 6.24486506e-01f, -3.58141549e-02f, 1.93394683e-02f,
  8.40435252e-02f, 1.21138617e-01f, -1.13451786e-01f, 2.06807274e-02f, -2.05157980e-01f, -3.08244396e-02f, 5.20382337e-02f, 6.38191029e-02f, -3.80931795e-02f, 1.73018649e-01f,
  8.46122503e-02f, -2.06450954e-01f, 4.56355244e-01f, 2.77799457e-01f, 1.60756409e-02f, -2.23136563e-02f, 1.64464302e-02f, 4.11901444e-01f, 3.17208886e-01f, 3.35604459e-01f,
  -1.90420613e-01f, -6.12965107e-01f, 4.51986879e-01f, 1.87593788e-01f, -1.05952740e-01f, 2.25596875e-01f, -2.39697516e-01f, -9.84782004e-04f, 2.03927234e-01f, 1.61604419e-01f,
  1.24383554e-01f, 9.71145183e-02f, -3.98653746e-02f, 4.11477983e-02f, 2.39395306e-01f, 3.25396836e-01f, 1.71289846e-01f, -3.76335829e-01f, -1.47964522e-01f, -4.09949183e-01f,
  1.02402091e-01f, -2.72814572e-01f, 2.73010284e-01f, 3.41124952e-01f, 4.16584499e-02f, 1.78302675e-01f, 3.00500672e-02f, -4.06978160e-01f, -7.13425502e-02f, 1.77034214e-01f,
  -1.45959780e-01f, -2.81174928e-01f, 4.89663295e-02f, 2.97087938e-01f, -3.08120281e-01f, 8.69777054e-02f, 2.32207879e-01f, 8.83683115e-02f, 6.67531565e-02f, -3.72624435e-02f,
  -1.17912099e-01f, 6.71466291e-02f, 1.37474865e-01f, 1.41931117e-01f, 1.36970386e-01f, 2.45982856e-01f, 1.51763931e-01f, 7.51104578e-02f, -1.60232291e-01f, 1.90397307e-01f,
  -1.35303736e-01f, 3.57601523e-01f, -1.83664590e-01f, -1.40486583e-01f, -3.83179891e-03f, 7.04787672e-02f, 3.69676590e-01f, 2.85490066e-01f, -2.68970162e-01f, -1.60303354e-01f,
  2.67401934e-01f, 1.31495088e-01f, -1.80025354e-01f, 2.77476385e-02f, -1.18558437e-01f, -6.14315197e-02f, 4.11602646e-01f, 3.01231235e-01f, 1.15843877e-01f, -1.82810053e-02f,
  -3.34624857e-01f, -1.02224492e-01f, 1.85794860e-01f, 6.35362044e-02f, 9.27968323e-02f, -2.15603188e-02f, 2.33717725e-01f, 1.02389939e-01f, -2.25195452e-03f, 3.00569069e-02f,
  -1.02842316e-01f, -1.12942256e-01f, 8.36789384e-02f, 1.86889410e-01f, 2.34451011e-01f, 2.43704095e-01f, 1.14629790e-01f, 1.18065327e-01f, -2.10223213e-01f, 1.26016065e-01f,
  -4.86198328e-02f, -1.04110748e-01f, -1.47135556e-01f, 5.05647063e-01f, 5.25656760e-01f, 3.73250276e-01f, 1.00067303e-01f, -3.12354863e-01f, -2.15164647e-01f, 3.79096955e-01f,
  -2.97841400e-01f, 4.29936051e-01f, 8.34646914e-03f, 2.57206023e-01f, 1.60447806e-01f, -1.54080400e-02f, 1.54118810e-03f, -6.38967976e-02f, 5.65071963e-02f, -9.48745683e-02f,
  5.10673039e-02f, 8.07766169e-02f, 1.90365110e-02f, -9.23836082e-02f, -1.33139133e-01f, 9.25147012e-02f, 6.65587410e-02f, 1.10691108e-01f, 1.29664496e-01f, -2.80279398e-01f,
  4.96275812e-01f, 1.77754074e-01f, -2.09453389e-01f, -1.68475993e-02f, 4.32269752e-01f, -1.08566940e-01f, 1.82077751e-01f, 3.03537667e-01f, 2.03792423e-01f, 3.30455720e-01f,
  1.28758073e-01f, -7.56407157e-02f, -2.27645040e-01f, -1.61839239e-02f, 3.34941328e-01f, -1.10038497e-01f, 9.14544687e-02f, -4.15122837e-01f, 1.47659391e-01f, -3.55456304e-03f,
  3.60866711e-02f, 3.45098451e-02f, 6.50544241e-02f, 3.06027755e-02f, 5.69222309e-02f, -8.57041478e-02f, -2.09693685e-01f, -1.37908086e-01f, -1.05261922e-01f, -1.42736346e-01f,
  -7.68097416e-02f, 3.82056981e-02f, 4.29277509e-01f, 7.97912776e-02f, 6.11479022e-03f, 6.78336772e-04f, 3.52650195e-01f, -4.04897273e-01f, -8.27511922e-02f, -1.47033870e-01f,
  -2.53459215e-02f, 3.56924027e-01f, 2.79387534e-01f, -2.54980087e-01f, 9.10250247e-02f, -2.63915181e-01f, 9.30572152e-02f, 6.99979020e-03f, -1.29859373e-01f, -2.69366130e-02f,
  1.96747839e-01f, -8.60707685e-02f, -7.50729814e-03f, -2.57776380e-02f, 2.90213595e-03f, -6.20364882e-02f, 2.12137446e-01f, -2.40090087e-01f, -9.05221403e-02f, -1.96979538e-01f,
  -8.94726887e-02f, -1.04046702e-01f, -5.20486720e-02f, -5.77716827e-02f, 3.22363973e-01f, 6.01743832e-02f, 1.29603833e-01f, 2.36073032e-01f, 5.75570092e-02f, -3.99435014e-01f,
  -6.27578199e-02f, -2.85134345e-01f, 3.94098043e-01f, 4.45361912e-01f, 1.06478177e-01f, -3.02467614e-01f, 1.94366157e-01f, 6.82816058e-02f, 2.78078705e-01f, -6.06918987e-03f,
  -3.02128404e-01f, 2.10544039e-02f, 7.68411085e-02f, 1.10118702e-01f, 8.60268176e-02f, 7.03859702e-02f, 4.04043198e-02f, 2.65132815e-01f, 1.27697419e-02f, -4.39018011e-02f,
  -7.68612325e-02f, -3.06279689e-01f, -2.58382946e-01f, -3.65611613e-01f, -2.81305220e-02f, 4.55765307e-01f, 5.28697073e-02f, 5.74995438e-03f, -4.73384224e-02f, -2.29730293e-01f,
  5.60393557e-03f, -1.87245578e-01f, -2.35554069e-01f, -1.94195032e-01f, -1.20606162e-01f, 3.86186212e-01f, 2.00490132e-01f, 1.42606333e-01f, 1.33110300e-01f, -2.46176533e-02f,
  4.70071882e-01f, 9.94738489e-02f, 1.25482872e-01f, 1.69136211e-01f, -8.85404553e-03f, 6.53669015e-02f, 2.10501254e-01f, 5.54986484e-02f, 1.21968858e-01f, 1.79904416e-01f,
  -1.46290094e-01f, 1.23633631e-02f, 1.36009872e-01f, -5.87125793e-02f, 1.55262619e-01f, 3.59227240e-01f, 2.40111887e-01f, 1.25691727e-01f, 4.05239669e-04f, 2.21111998e-01f,
  -5.71005046e-02f, -2.76056707e-01f, -9.91517231e-02f, 5.22849500e-01f, 5.49158096e-01f, 5.40676773e-01f, 2.28277128e-02f, -1.83555692e-01f, -6.09798990e-05f, 3.64154547e-01f,
  -3.62578988e-01f, 2.67520338e-01f, 3.36542040e-01f, 2.63951659e-01f, 4.01509523e-01f, -2.46401742e-01f, 1.74551487e-01f, -3.79128978e-02f, 6.43109232e-02f, 1.83068379e-03f,
  3.86898443e-02f, 9.48739797e-02f, 4.63917106e-03f, -2.12124869e-01f, -2.74472505e-01f, 1.54263377e-01f, 4.10747044e-02f, 3.48263383e-02f, 2.03420252e-01f, 6.35820851e-02f,
  1.65426061e-01f, 1.48637742e-01f, 3.63630265e-01f, 3.79729211e-01f, 7.52637908e-02f, 1.06292784e-01f, 4.66597416e-02f, -2.56399453e-01f, 1.27647355e-01f, -1.47240251e-01f,
  2.15197578e-01f, 1.55540332e-01f, 4.70906019e-01f, 1.07634470e-01f, -3.79775822e-01f, 1.49095297e-01f, -3.20156723e-01f, 5.42961061e-01f, 2.58275517e-03f, 6.33709282e-02f,
  -2.10754164e-02f, 1.40375674e-01f, -7.17406049e-02f, -5.12815379e-02f, -7.72736296e-02f, 2.66791433e-01f, 5.32797128e-02f, 1.28660247e-01f, 4.31630984e-02f, -1.45694390e-01f,
  2.13127621e-02f, 3.98725957e-01f, -8.35763142e-02f, 2.65350521e-01f, 8.91196206e-02f, 1.12729676e-01f, 1.71985865e-01f, -1.06342353e-01f, -2.95764178e-01f, -1.12439208e-01f,
  -2.11283006e-02f, 3.84433329e-01f, -1.82208151e-01f, 1.40793577e-01f, 2.34334245e-01f, 2.15216503e-01f, -2.98316181e-01f, -9.10200737e-03f, 1.82642907e-01f, -9.41966921e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 20)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 20;
const float L3_fan_Bp_bar_data[] = {
  2.15289190e-01f, -1.06357957e-05f, 1.88325882e-01f, -2.70735733e-02f, 1.14538699e-01f, 6.37107641e-02f, 1.85819015e-01f, -3.44527350e-03f, 1.46310598e-01f, 2.39537321e-02f,
  3.94634567e-02f, 1.42086610e-01f, 1.44425943e-01f, 1.20193660e-01f, 7.86588714e-02f, 1.84396319e-02f, 1.04286551e-01f, 8.04371908e-02f, 1.14409231e-01f, 1.19601404e-02f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -2.07913101e-01f, 3.98142152e-02f, -6.56143427e-02f, 1.24583237e-01f, -9.60849673e-02f, -1.64495885e-01f, -8.64093676e-02f, -5.52269332e-02f, -1.54646516e-01f, -2.43113473e-01f,
  1.27548706e-02f, -1.61796480e-01f, -2.20501319e-01f, 2.22009853e-01f, -4.17494893e-01f, 1.73015133e-01f, -4.48920786e-01f, 2.54256040e-01f, -4.12695855e-01f, -1.02499925e-01f,
  4.15471464e-01f, -4.60788220e-01f, 3.22762072e-01f, -2.90720105e-01f, -2.39342660e-01f, -4.15395826e-01f, -1.54392749e-01f, 1.88290775e-01f, 7.09092095e-02f, -3.45310509e-01f,
  1.05477244e-01f, 1.81314200e-01f, 1.27967194e-01f, 1.30243361e-01f, -2.23112211e-01f, -7.04755932e-02f, -1.95001662e-01f, 5.47678880e-02f, -8.21099505e-02f, 2.13891014e-01f,
  2.26715997e-01f, 1.37997508e-01f, 2.31242925e-01f, -1.73391387e-01f, 1.37781471e-01f, 2.70431519e-01f, -2.34874964e-01f, 1.86202675e-01f, -1.85872704e-01f, -3.93202513e-01f,
  2.02858254e-01f, -4.71573293e-01f, 7.35028908e-02f, -5.06884634e-01f, 1.95565015e-01f, 1.42470330e-01f, -2.06225172e-01f, 1.84418544e-01f, 2.93674707e-01f, 3.03232700e-01f,
  4.31583226e-02f, -3.70253980e-01f, -1.59975469e-01f, 2.42868334e-01f, -1.68241207e-02f, -1.02752119e-01f, -2.02249721e-01f, -1.22038163e-01f, 1.24718837e-01f, -2.11072221e-01f,
  1.00614406e-01f, 2.10190907e-01f, -7.90515020e-02f, 2.72599131e-01f, -2.35723332e-01f, 2.15558454e-01f, 1.37136979e-02f, 4.65227552e-02f, 1.96962059e-01f, -3.29643130e-01f,
  -2.73827881e-01f, -9.83521938e-02f, 1.88047782e-01f, -1.35250717e-01f, -3.27140898e-01f, 2.03461155e-01f, -4.20363933e-01f, 3.65334928e-01f, -5.47239542e-01f, 3.15249234e-01f,
  3.17199767e-01f, -9.49620530e-02f, 1.28925189e-01f, -1.74359292e-01f, -1.35151342e-01f, 9.00715217e-02f, 3.62325050e-02f, -7.98302889e-02f, 6.72625154e-02f, -1.00598253e-01f,
  -1.57610819e-01f, -9.56455171e-02f, -3.17058623e-01f, 1.28449112e-01f, 6.08491749e-02f, -2.75757372e-01f, 2.40211815e-01f, 3.03009674e-02f, -2.88241893e-01f, -6.32589519e-01f,
  -2.40996853e-01f, 6.21588640e-02f, 3.02902937e-01f, 2.02032119e-01f, -4.63361889e-01f, 3.60009134e-01f, -2.46331796e-01f, -4.80490327e-01f, -4.37493473e-01f, -1.18709706e-01f,
  2.88904518e-01f, 1.52612701e-01f, -4.11382258e-01f, 1.10437870e-01f, -2.56663740e-01f, 2.90063441e-01f, -1.46646366e-01f, -5.26164711e-01f, -1.78368241e-01f, -2.06487402e-02f,
  -8.23264793e-02f, -2.22828522e-01f, 8.01711902e-02f, 1.39881000e-01f, -2.51042306e-01f, -7.29695009e-03f, 2.46249661e-01f, 3.38666998e-02f, -1.43363804e-01f, -3.18599641e-02f,
  -3.54948759e-01f, 3.74393985e-02f, -5.38728356e-01f, 1.78042829e-01f, -3.51285666e-01f, 3.36658885e-03f, -3.92262101e-01f, 2.62757868e-01f, -2.39911564e-02f, 1.98143572e-01f,
  2.36239806e-01f, -6.50394619e-01f, 2.69984812e-01f, -2.58538783e-01f, 4.80944104e-03f, -2.32640356e-01f, -1.95929885e-01f, 2.18010738e-01f, 3.18956524e-01f, -3.78412396e-01f,
  1.99560463e-01f, -1.10044256e-01f, 2.07093135e-01f, 5.13198189e-02f, 1.60897166e-01f, -2.52332836e-02f, -3.21065664e-01f, -2.10721597e-01f, -4.66660596e-02f, -2.29333803e-01f,
  6.89623430e-02f, -1.40910983e-01f, 8.31770450e-02f, -5.16134128e-02f, 3.07398319e-01f, 4.66875508e-02f, -4.11032774e-02f, 1.23103157e-01f, 5.75229991e-03f, -1.94238529e-01f,
  3.48422766e-01f, -1.21568166e-01f, 3.73636186e-02f, 2.52922267e-01f, 1.25054896e-01f, -4.89897996e-01f, -3.16894919e-01f, -3.76446396e-01f, 3.30743715e-02f, -1.11002680e-02f,
  1.45843551e-01f, 2.32322201e-01f, -1.72738612e-01f, 2.64185220e-01f, 1.05461655e-02f, 4.96663526e-02f, 3.81047279e-02f, 1.76750258e-01f, 6.40368611e-02f, -6.10224232e-02f,
  4.24244672e-01f, -3.39918166e-01f, -9.36084539e-02f, 1.62642121e-01f, 2.29821339e-01f, 7.37720877e-02f, 9.24692973e-02f, -4.46753860e-01f, -5.89927733e-02f, -6.01024449e-01f,
  1.13718279e-01f, -4.96993512e-01f, -1.22001134e-01f, 3.35029125e-01f, -3.15678746e-01f, 3.12295228e-01f, 1.55818939e-01f, 1.01545103e-01f, -4.63440269e-01f, -2.44891569e-01f,
  -3.52955133e-01f, 2.00057268e-01f, -3.47441822e-01f, -8.51898566e-02f, -1.18821472e-01f, 9.13270339e-02f, -1.27978906e-01f, 1.13448821e-01f, -1.72702745e-01f, 8.80917534e-02f,
  -5.12857214e-02f, 9.32242628e-03f, -1.81074232e-01f, 2.04668753e-03f, -1.82101980e-01f, -9.64540895e-03f, -1.21890500e-01f, -2.36808285e-01f, -9.83531699e-02f, 3.01403433e-01f,
  2.88540035e-01f, 2.19876900e-01f, -2.44556129e-01f, 2.21830562e-01f, -4.08310592e-02f, -1.83852285e-01f, -4.04855311e-01f, -1.87890574e-01f, -2.44377047e-01f, -2.45243728e-01f,
  -1.13310374e-01f, 1.69474438e-01f, -2.94757694e-01f, -4.80719000e-01f, 2.37129897e-01f, 1.16703033e-01f, 6.73270077e-02f, -6.33070916e-02f, 2.05127522e-01f, -1.62929907e-01f,
  2.31711298e-01f, 4.98853140e-02f, -2.20431253e-01f, 9.00297537e-02f, -7.71106333e-02f, 2.06075817e-01f, -1.08441114e-01f, 1.57131106e-02f, -5.27207255e-01f, -2.31395766e-01f,
  1.77427724e-01f, 5.29281469e-03f, 3.49522382e-01f, -1.52193150e-02f, 1.16326660e-01f, -2.37741858e-01f, 4.21063334e-01f, 2.73480862e-01f, -2.58974135e-01f, 1.94023192e-01f,
  -1.93196669e-01f, -1.47205830e-01f, 2.48884276e-01f, 2.86691993e-01f, 5.52980974e-02f, -3.32119554e-01f, 2.86669880e-01f, -2.85363853e-01f, 2.30468482e-01f, -1.01760611e-01f,
  -8.28957707e-02f, 1.83307067e-01f, -1.44206896e-01f, -4.04374376e-02f, 3.89816821e-01f, 8.48395526e-02f, -1.44154042e-01f, 2.98467726e-01f, -9.11353230e-02f, -2.48480961e-02f,
  1.54443467e-02f, 1.46777645e-01f, -2.66927388e-02f, 1.73948497e-01f, -9.81198549e-02f, 7.49933571e-02f, 5.06543554e-02f, 8.67037177e-02f, -5.87382197e-01f, 1.52195603e-01f,
  -1.35415494e-01f, -2.58429915e-01f, 2.02667132e-01f, -9.99478921e-02f, 2.48165261e-02f, -2.08125547e-01f, -4.75400239e-01f, 2.85793304e-01f, -2.79057860e-01f, 1.24402769e-01f,
  1.87259674e-01f, 1.04967155e-01f, 1.39694124e-01f, 9.55170169e-02f, -2.07440495e-01f, 2.42235646e-01f, 3.40424895e-01f, -2.58854538e-01f, 2.36617386e-01f, 6.58372045e-02f,
  6.33096546e-02f, -7.30508119e-02f, 1.59345224e-01f, -3.40711504e-01f, -3.28129083e-01f, -1.71705291e-01f, 4.59151715e-01f, -1.32994382e-02f, 7.31106251e-02f, 2.45203953e-02f,
  -8.59367475e-02f, -1.20230436e-01f, 2.82007039e-01f, -1.60020784e-01f, -4.18990850e-01f, 2.94705629e-01f, 2.69862533e-01f, 3.87441993e-01f, 4.25027966e-01f, -8.94635767e-02f,
  -5.19032121e-01f, -3.58318478e-01f, -1.98310748e-01f, -8.89669806e-02f, -1.13632493e-01f, 1.48610532e-01f, 2.53937632e-01f, -7.15098828e-02f, 3.01675558e-01f, -5.57181388e-02f,
  -4.85585362e-01f, -9.89354253e-02f, -7.75630176e-02f, -3.06782991e-01f, 3.75744879e-01f, 2.40964442e-01f, 2.75907338e-01f, -6.06417358e-01f, -1.10234223e-01f, 2.72850573e-01f,
  1.04421787e-01f, -1.68704152e-01f, -3.94915253e-01f, -1.62269831e-01f, 1.02439612e-01f, -2.25016057e-01f, 4.57988940e-02f, -4.97067183e-01f, -2.25495268e-02f, -1.37409121e-01f,
  4.48561460e-01f, 1.87012523e-01f, -6.45642936e-01f, 1.58795550e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  1.04496494e-01f, 3.52891833e-02f, -1.19443439e-01f, 1.40840068e-01f, 9.17966589e-02f, 5.66605991e-03f, 8.44405144e-02f, 8.18977877e-02f, -5.21641895e-02f, -5.16651869e-02f,
  1.76209807e-01f, 1.46181226e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    