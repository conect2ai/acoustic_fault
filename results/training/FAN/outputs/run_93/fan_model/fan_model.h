/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.11591846e-01f, -2.04783976e-02f, 1.56314131e-02f, 2.05988213e-01f, -1.05878554e-01f, -3.62513751e-01f, -1.89989045e-01f, 3.54411528e-02f, -1.05441354e-01f, -1.61645517e-01f,
  -7.80401230e-02f, 2.87624955e-01f, -2.33539328e-01f, 1.07813515e-01f, -2.63376832e-01f, -1.98131576e-01f, -8.91646817e-02f, 2.27514263e-02f, 4.61276062e-02f, -4.33621965e-02f,
  2.98195854e-02f, 3.40696238e-03f, 5.21471314e-02f, 3.02281454e-02f, 6.87501654e-02f, 2.11579606e-01f, 1.39704525e-01f, 1.50335148e-01f, 1.22431181e-01f, 1.80684477e-01f,
  -8.00526291e-02f, 4.37321104e-02f, -3.14209387e-02f, 8.82031545e-02f, -1.00547627e-01f, -3.68349557e-03f, 2.22792383e-02f, 1.10155763e-02f, 3.05026006e-02f, 2.78583858e-02f,
  5.36663681e-02f, -1.11245383e-02f, 1.84798241e-02f, -6.28641322e-02f, 1.51453326e-02f, 1.67699046e-02f, 5.84713146e-02f, -2.01732367e-02f, 3.02978209e-03f, -3.02535184e-02f,
  5.54107465e-02f, 6.20425157e-02f, -1.18740564e-02f, 2.02812487e-03f, -8.86151195e-03f, 1.16471155e-02f, 3.34003754e-02f, 4.86423858e-02f, 2.05670968e-02f, -2.70130169e-02f,
  -6.44611344e-02f, 3.99284698e-02f, 9.53752697e-02f, 5.86950183e-02f, -2.88773458e-02f, 1.83605198e-02f, -5.25023267e-02f, 6.18814304e-02f, 5.38199730e-02f, -2.09904443e-02f,
  -3.13602723e-02f, 3.62796821e-02f, 2.19534375e-02f, -2.13722140e-02f, -7.55120022e-03f, 1.52368620e-02f, 7.83968251e-03f, 8.02817345e-02f, -6.74724430e-02f, 8.69784057e-02f,
  -6.37500808e-02f, 9.91717726e-03f, 2.18596011e-02f, 3.10876360e-03f, -3.04159690e-02f, -9.26375017e-03f, 5.75034991e-02f, -3.21043991e-02f, 1.29205128e-02f, 5.14943898e-03f,
  -1.77155852e-01f, -1.05741419e-01f, -4.44374792e-02f, 8.43810439e-02f, 4.05365638e-02f, -4.15191464e-02f, 2.49503441e-02f, 5.65305501e-02f, -2.16326546e-02f, -3.37347314e-02f,
  2.17487868e-02f, 3.37077328e-03f, -5.48179112e-02f, -3.23940925e-02f, 3.80663574e-02f, -9.51563641e-02f, -1.58169512e-02f, 4.04319353e-02f, 1.99006703e-02f, -2.10577846e-02f,
  -2.68827267e-02f, -1.00099258e-01f, 2.67380103e-02f, 3.24401073e-02f, 2.95692571e-02f, -2.84571704e-02f, 2.09149942e-02f, -1.85602661e-02f, -5.11601614e-03f, -5.09541249e-03f,
  -7.65582100e-02f, -6.18360676e-02f, 1.65387869e-01f, -2.34770536e-01f, -1.78601798e-02f, 1.13066256e-01f, 2.39461362e-01f, -2.05889791e-01f, -1.05747106e-02f, -8.26494955e-03f,
  -1.67340264e-01f, -1.27736758e-02f, 1.44316167e-01f, -1.93306774e-01f, -9.92971584e-02f, -5.62616177e-02f, -1.70103505e-01f, -6.64540902e-02f, -5.71262836e-02f, -8.73616897e-03f,
  -1.06976675e-02f, -2.11963594e-01f, -1.00481205e-01f, -1.09232068e-01f, 9.64774657e-03f, 5.23286387e-02f, -2.06257567e-01f, 1.74355060e-01f, -9.40261334e-02f, -3.69115770e-02f,
  -6.26476929e-02f, -3.23804766e-02f, -1.65872108e-02f, -8.65319148e-02f, 3.23724584e-03f, -1.28785279e-02f, -1.71927679e-02f, 1.20711438e-01f, 6.64749444e-02f, 6.92204712e-03f,
  6.38561547e-02f, -7.57903233e-02f, -4.39490564e-02f, -7.20471260e-04f, -3.06337196e-02f, 3.58837508e-02f, 6.01602793e-02f, 4.43876386e-02f, 3.67001519e-02f, 3.86738926e-02f,
  4.18077633e-02f, -2.43183840e-02f, 5.47920540e-02f, 4.33347793e-03f, 7.70732481e-03f, 1.16587467e-01f, 6.42722771e-02f, -1.82278100e-02f, -9.87394154e-02f, -8.96409526e-02f,
  -4.30994220e-02f, -1.67960897e-02f, -7.35868737e-02f, -2.79992204e-02f, 4.01524268e-02f, 4.61800303e-03f, -6.28167577e-03f, 6.33493066e-02f, 4.14804230e-03f, 3.16521525e-02f,
  -5.47235608e-02f, -1.02742240e-01f, -7.00557977e-02f, -3.05970609e-02f, -5.39296642e-02f, 2.47983937e-03f, 5.38646132e-02f, 1.10468734e-02f, 7.39438320e-03f, -9.07492936e-02f,
  -3.57268378e-02f, 5.76918805e-03f, -4.71694991e-02f, 7.12280646e-02f, -2.15910282e-02f, -1.62591022e-02f, -3.03702317e-02f, -1.73731940e-03f, 4.14196961e-02f, 6.12071902e-03f,
  1.07027320e-02f, -2.22110868e-01f, -1.28037473e-02f, 1.47715108e-02f, 9.47717726e-02f, -4.13278714e-02f, 2.94762291e-02f, 2.98060756e-02f, 4.37042899e-02f, -1.32932793e-02f,
  -9.00468379e-02f, 4.28913571e-02f, -1.28669096e-02f, 4.41181735e-04f, 2.86340639e-02f, 1.08116842e-03f, 7.69425258e-02f, 3.14407945e-02f, -1.12068549e-01f, -2.59740632e-02f,
  -7.04964204e-03f, 2.66281571e-02f, 5.31182513e-02f, -9.09032207e-03f, 3.73556558e-03f, 4.00974154e-02f, -2.86664385e-02f, -4.85585034e-02f, -6.10695668e-02f, -1.09288357e-01f,
  1.22156970e-01f, -2.36028105e-01f, -1.85080618e-01f, -2.40725446e-02f, -4.95117642e-02f, 7.66853616e-02f, 1.53247207e-01f, -1.73027545e-01f, -9.29986760e-02f, -3.73768844e-02f,
  8.55984017e-02f, 1.57545418e-01f, 4.93467525e-02f, -1.53690223e-02f, 2.91382879e-01f, 1.89243078e-01f, 3.73604707e-02f, 1.09668612e-01f, -8.54194164e-02f, -1.03185862e-01f,
  -1.60272997e-02f, 4.05217558e-02f, -1.76705867e-02f, -1.59428731e-01f, -2.08226040e-01f, -1.77427307e-01f, -6.49634888e-03f, -1.13976359e-01f, -1.30023211e-01f, 9.25910026e-02f,
  1.05237134e-01f, -4.59078401e-02f, -1.57878563e-01f, 7.89244249e-02f, -3.99973020e-02f, 3.48235131e-03f, 5.78591861e-02f, 1.27447799e-01f, -2.34008115e-02f, -1.08768549e-02f,
  8.16849694e-02f, -1.95996221e-02f, -4.08399068e-02f, 1.35375652e-02f, 9.18708276e-03f, -4.68025990e-02f, -7.56442323e-02f, -3.13577428e-02f, -1.79351456e-02f, 1.04296273e-02f,
  2.19620410e-02f, 6.75246939e-02f, 1.55421784e-02f, -9.07633919e-04f, -1.73775610e-02f, -3.84503826e-02f, 7.57744769e-03f, 1.58733558e-02f, 2.58064028e-02f, -1.09770484e-02f,
  1.67103633e-02f, -6.34830147e-02f, -2.52441354e-02f, -3.89001295e-02f, -2.23006532e-02f, -2.85846870e-02f, 3.08514182e-02f, -4.07641120e-02f, -1.55947926e-02f, 4.58076000e-02f,
  -6.59125373e-02f, -1.00428853e-02f, -1.23220086e-02f, 5.58109162e-03f, 2.09629349e-02f, -4.12708335e-02f, 1.88211945e-03f, 2.21669096e-02f, -2.26717480e-02f, -4.42843279e-03f,
  -2.39568553e-03f, 5.21964990e-02f, -2.68736854e-02f, 5.78245260e-02f, 2.68286653e-02f, -3.40264402e-02f, -6.27118796e-02f, 1.75217446e-02f, -4.08031866e-02f, -3.83629426e-02f,
  1.20469399e-01f, -1.59520730e-01f, -7.52669349e-02f, 4.68826061e-03f, -1.90883055e-02f, 6.35764375e-03f, 2.14059539e-02f, -8.34813714e-03f, -3.92776802e-02f, -6.20186515e-03f,
  -1.83250513e-02f, 3.98897938e-02f, 1.80235002e-02f, 5.26872724e-02f, 2.76563573e-03f, -6.18281960e-02f, 3.54586840e-02f, 2.38228980e-02f, 1.51918167e-02f, -1.45999696e-02f,
  3.14661418e-03f, -2.07706988e-02f, 3.28394286e-02f, -5.09420559e-02f, -3.22931306e-03f, 2.66985688e-02f, 5.90821356e-02f, -1.73588060e-02f, -2.92388834e-02f, 1.20199602e-02f,
  5.56591272e-01f, -2.35553727e-01f, -1.79294422e-01f, 8.81683379e-02f, 2.72617131e-01f, 1.58243239e-01f, 2.22395971e-01f, -9.58534516e-03f, 1.25925764e-01f, -2.04107404e-01f,
  1.61622390e-01f, -6.79977462e-02f, -5.90897836e-02f, -7.56102875e-02f, 2.06296459e-01f, -9.54711661e-02f, 7.45029822e-02f, -9.54403018e-04f, -3.78529318e-02f, 4.69790809e-02f,
  6.91389143e-02f, 3.58401202e-02f, -2.73408578e-03f, -1.28030002e-01f, 1.00784324e-01f, -2.16095168e-02f, 1.97301824e-02f, -4.66627926e-02f, -7.75295403e-03f, 6.00784197e-02f,
  1.28521770e-01f, -1.41982390e-02f, -1.59938764e-02f, -4.70518023e-02f, 2.85153445e-02f, 2.05728039e-02f, 9.19387341e-02f, 2.71808952e-02f, 6.38971403e-02f, 4.08004709e-02f,
  -2.11104527e-02f, 1.67535748e-02f, -1.54304029e-02f, 1.78597542e-03f, 1.53585169e-02f, -3.55305932e-02f, -1.14310700e-02f, -3.91261168e-02f, -5.91441281e-02f, -4.21021059e-02f,
  -3.17600965e-02f, -7.25350454e-02f, -1.82720497e-02f, -4.66872863e-02f, -5.31977080e-02f, -8.81723035e-03f, -4.74931598e-02f, -6.45522699e-02f, 4.37157415e-02f, -1.58966761e-02f,
  2.39569321e-02f, 1.34090707e-02f, -9.68808495e-03f, -3.20549756e-02f, 3.00991554e-02f, 6.14621527e-02f, 6.33248389e-02f, 2.09545903e-02f, 2.46840790e-02f, -1.26909418e-03f,
  7.14521632e-02f, 6.86576217e-02f, 8.48325640e-02f, -1.53463809e-02f, 5.41766547e-02f, 1.48367546e-02f, 5.23922704e-02f, -2.17064451e-02f, 1.66381784e-02f, 3.59771810e-02f,
  5.87695763e-02f, 9.43986699e-03f, -2.64370795e-02f, -2.47859806e-02f, 2.70028058e-02f, -3.61874676e-03f, -4.01492231e-02f, -4.90327589e-02f, 5.56228273e-02f, 6.32662210e-04f,
  -4.38442901e-02f, -9.31898132e-02f, -3.48991938e-02f, 2.22191401e-02f, -7.87890255e-02f, -1.02758743e-01f, -6.57311082e-02f, -3.56482193e-02f, -1.20747471e-02f, -1.49627794e-02f,
  2.08793264e-02f, -2.53622197e-02f, 3.34574804e-02f, -2.18238439e-02f, -6.21975632e-03f, 4.35223384e-03f, 3.71147916e-02f, 2.02579834e-02f, -6.14283932e-03f, -3.48714031e-02f,
  -5.52490167e-02f, 6.95117563e-02f, -6.35397360e-02f, 3.82498130e-02f, 1.90663021e-02f, 7.09136352e-02f, -6.06997237e-02f, -3.59382406e-02f, 2.11464867e-04f, -1.59321632e-02f,
  1.34440167e-02f, -1.14248857e-01f, 5.89677580e-02f, -1.26710832e-02f, -5.40746339e-02f, -9.55056623e-02f, 2.43984208e-01f, -1.69900835e-01f, 2.69782208e-02f, -7.06875101e-02f,
  -1.27706560e-03f, 8.83449093e-02f, 1.73872143e-01f, -2.76785225e-01f, 9.76514071e-02f, 6.66643158e-02f, -1.80839136e-01f, 1.05900075e-02f, 3.50715481e-02f, -1.40289158e-01f,
  -4.20770049e-02f, -1.61574528e-01f, -8.64950195e-03f, -2.05027342e-01f, -5.87397777e-02f, -8.64242390e-02f, -4.00427803e-02f, 8.77283141e-02f, -2.17518017e-01f, -2.12775897e-02f,
  -1.20879225e-02f, -7.97325298e-02f, 1.84102710e-02f, 2.09135003e-02f, -1.31238019e-03f, 1.02456491e-02f, 1.27979308e-01f, 7.76062384e-02f, -8.32452625e-03f, 8.12706538e-03f,
  1.02877915e-01f, 5.25831878e-02f, -1.48860915e-02f, -4.23955917e-03f, -7.01667815e-02f, -2.38191616e-02f, 4.46599722e-02f, -1.22409258e-02f, 7.58969039e-02f, -6.83268113e-03f,
  9.00687575e-02f, 1.40420198e-02f, -1.12403007e-02f, 1.38722826e-02f, -2.16267239e-02f, -4.32971492e-02f, 8.81337281e-03f, 7.98233151e-02f, -6.55053258e-02f, -1.69345681e-02f,
  -1.40015008e-02f, -2.38323230e-02f, 4.56271730e-02f, -3.25472727e-02f, -3.80658135e-02f, -4.48164018e-03f, -4.93413173e-02f, -4.44504246e-02f, 4.22413200e-02f, -5.56467809e-02f,
  6.42877596e-04f, -2.63375714e-02f, -2.94090086e-03f, -1.64401531e-02f, -1.64652113e-02f, -4.56660986e-02f, 7.30447397e-02f, -8.97482187e-02f, -1.57651193e-02f, 5.07588536e-02f,
  8.24024752e-02f, -3.60407941e-02f, 1.21814972e-02f, 7.47773275e-02f, 1.45756677e-02f, 2.77464967e-02f, -4.11327593e-02f, -2.48884242e-02f, -3.04392911e-02f, 6.01237714e-02f,
  -6.59689829e-02f, -1.66866884e-01f, 6.00460954e-02f, 3.47622521e-02f, 6.65962920e-02f, 8.50871857e-03f, -3.29548344e-02f, -1.06569670e-01f, 2.58177379e-03f, -4.75732461e-02f,
  -1.55117838e-02f, -9.73622277e-02f, -3.02788541e-02f, -9.99389663e-02f, 6.78731650e-02f, 3.66267599e-02f, -1.42733324e-02f, -2.84685008e-02f, -3.09117585e-02f, -1.97555386e-02f,
  -5.80909774e-02f, 3.28700095e-02f, 4.05015834e-02f, -1.83358546e-02f, -6.83376491e-02f, 4.44483198e-02f, 5.10442443e-03f, 3.64238806e-02f, -6.98158471e-03f, 5.40008023e-02f,
  3.92685421e-02f, 3.19966435e-01f, 2.26624161e-01f, 8.48638788e-02f, -1.55304834e-01f, -4.76387769e-01f, -2.27774411e-01f, 2.88407821e-02f, 8.56749192e-02f, -9.57556348e-03f,
  -9.61213186e-02f, 2.18942821e-01f, 1.37705743e-01f, -8.79146382e-02f, -1.87631860e-01f, -8.24374557e-02f, -6.12512641e-02f, -2.21156385e-02f, 7.13346973e-02f, 1.04711317e-01f,
  -7.95630272e-03f, -1.81717187e-01f, 7.42986351e-02f, -6.82481527e-02f, -6.60730153e-02f, 2.00888902e-01f, 4.33464348e-02f, 2.71638911e-02f, -6.60134340e-03f, -1.57553926e-01f,
  -1.37257680e-01f, 1.21520825e-01f, 8.21765140e-02f, -4.10851575e-02f, -1.74233634e-02f, -4.47648913e-02f, 3.83883491e-02f, -1.66652370e-02f, -7.75536057e-03f, 1.35546541e-02f,
  -3.43554132e-02f, 9.73290415e-04f, 2.38708295e-02f, -8.38985108e-03f, -3.39108706e-02f, -1.62106231e-02f, 5.28561920e-02f, 4.86408509e-02f, 8.72421265e-02f, 1.69208068e-02f,
  2.63515264e-02f, 7.54313245e-02f, -1.01987002e-02f, 4.17159647e-02f, -1.49775818e-02f, -2.36281361e-02f, -3.66400480e-02f, -1.00057165e-03f, -3.30748633e-02f, 5.47397556e-03f,
  -3.16939950e-02f, -1.86690371e-02f, -6.77145133e-03f, -3.48848924e-02f, 2.13319045e-02f, -7.74428919e-02f, -3.52976061e-02f, -9.01409835e-02f, 1.14166336e-02f, -6.27944097e-02f,
  -5.41083962e-02f, 1.78285092e-02f, 6.59897865e-04f, -3.33215967e-02f, 8.33084527e-03f, -1.98874120e-02f, 1.09401336e-02f, -2.86781304e-02f, -4.36344855e-02f, -4.01300117e-02f,
  3.25392745e-02f, 4.83271591e-02f, 7.32456381e-03f, 1.81452231e-03f, -2.11927537e-02f, 7.86659867e-02f, -2.73096077e-02f, 3.49787325e-02f, 5.95901608e-02f, -5.99562973e-02f,
  3.87035944e-02f, 1.86607346e-01f, -8.09808075e-03f, -2.52902731e-02f, 2.75950711e-02f, -7.11101592e-02f, 1.50061538e-03f, 2.50586700e-02f, 6.74929172e-02f, -6.04866557e-02f,
  2.96462774e-02f, -2.92137116e-02f, -5.19476309e-02f, -2.21232092e-03f, 3.11669149e-02f, 5.02597960e-03f, 3.41551788e-02f, 9.80281923e-03f, -2.23934185e-02f, -8.04875605e-03f,
  4.80069444e-02f, -7.96924233e-02f, 4.85679433e-02f, -8.87704939e-02f, -6.35136887e-02f, -2.25462727e-02f, -4.02961820e-02f, 8.30841996e-03f, -3.89156789e-02f, -1.58720091e-02f,
  3.44511956e-01f, -1.66817695e-01f, 2.56659508e-01f, -2.40392700e-01f, 1.22118354e-01f, -9.69603285e-02f, 8.47548619e-03f, -4.65442352e-02f, -5.00034280e-02f, -2.14382544e-01f,
  -9.56572145e-02f, 5.55591173e-02f, 3.47611643e-02f, -3.21149677e-01f, 1.29592657e-01f, -2.04863861e-01f, -1.95740074e-01f, -7.28720501e-02f, 2.52382234e-02f, -3.94731946e-02f,
  -5.97444288e-02f, -2.30126217e-01f, 9.87074524e-03f, -1.45173743e-01f, -1.00142933e-01f, -1.95681881e-02f, -2.98342183e-02f, 3.97739783e-02f, -1.92117438e-01f, 5.49839884e-02f,
  8.25366899e-02f, 1.99213833e-01f, 3.84572670e-02f, 4.57593463e-02f, 1.51785798e-02f, 9.94941518e-02f, -3.34358253e-02f, 9.72254947e-02f, 1.29617248e-02f, 2.21729111e-02f,
  9.77645442e-03f, 1.12181045e-02f, 3.08299176e-02f, -1.14870267e-02f, 4.45287582e-03f, -1.34482980e-02f, -4.15965356e-02f, -1.61002856e-02f, -2.14125738e-02f, -4.05962877e-02f,
  3.61199677e-02f, -3.79185081e-02f, -8.87941569e-02f, -3.10636032e-02f, 3.79324630e-02f, -9.68071893e-02f, -2.98809409e-02f, 3.55471298e-02f, 6.76597934e-03f, -1.34601351e-02f,
  -2.58798171e-02f, -1.67401768e-02f, -1.33419279e-02f, -9.15595703e-03f, 2.09848993e-02f, -3.84453908e-02f, -7.16737732e-02f, 2.01884881e-02f, -3.57832946e-02f, -6.48434162e-02f,
  -4.13405411e-02f, -2.90653203e-03f, -5.00179902e-02f, -5.87461554e-02f, -3.70784663e-02f, -5.35088629e-02f, 1.03960857e-02f, -3.46849598e-02f, -1.26803778e-02f, 4.14519943e-03f,
  1.23545546e-02f, -2.03542020e-02f, 1.09418491e-02f, -5.40985912e-02f, 1.80470739e-02f, -1.39360386e-03f, -3.19582447e-02f, -3.91829899e-03f, 2.13164333e-02f, 6.20214567e-02f,
  1.79626644e-02f, 3.90836596e-02f, -5.26192337e-02f, -3.51297595e-02f, 3.53249833e-02f, -3.85746919e-02f, -3.25761512e-02f, -4.64584120e-02f, 1.46571761e-02f, 8.54192302e-03f,
  -3.10940500e-02f, -1.11259772e-02f, 2.62844283e-02f, -4.06899825e-02f, -9.62054506e-02f, -3.78383957e-02f, 3.42365876e-02f, -2.61221509e-02f, -5.62385805e-02f, 2.17870306e-02f,
  -8.09293613e-02f, 2.20709760e-02f, 1.53527725e-02f, 2.90070102e-02f, -4.56955843e-02f, 3.47642298e-03f, 3.24897654e-02f, 2.20274851e-02f, 5.34020849e-02f, -3.99373695e-02f,
  -2.51218438e-01f, 2.57740803e-02f, -2.85693128e-02f, -2.58733809e-01f, 2.26336140e-02f, -1.89687572e-02f, -1.01736665e-01f, 4.27353084e-02f, -7.13452771e-02f, 6.85845092e-02f,
  -8.63139853e-02f, -1.08588964e-01f, -5.85943041e-03f, -3.01051646e-01f, -4.00852978e-01f, -1.41869470e-01f, -2.63422132e-01f, -1.17973641e-01f, -1.65439233e-01f, -4.32475805e-02f,
  -1.70357972e-01f, -1.29391193e-01f, -1.30577266e-01f, 3.97237437e-03f, 7.27135316e-02f, 4.39861864e-02f, 1.16808549e-01f, 7.57010207e-02f, 6.07359968e-02f, -2.40253266e-02f,
  4.14338754e-03f, -3.62390615e-02f, -1.19671924e-02f, 7.99697172e-03f, 5.88632822e-02f, 2.01228976e-01f, 6.83398917e-02f, 6.56744232e-03f, -4.17012386e-02f, -2.03755125e-02f,
  -1.00482034e-03f, 1.06772990e-03f, -6.83058947e-02f, 2.64702458e-02f, 1.89203192e-02f, -4.83143367e-02f, -4.25481722e-02f, 1.62842777e-02f, 1.01824012e-02f, -7.48358592e-02f,
  8.42407905e-03f, 4.57987227e-02f, 6.09597303e-02f, 1.70574039e-02f, -7.95717239e-02f, 1.85719728e-02f, 4.04214114e-02f, -5.77713698e-02f, 9.68801379e-02f, -2.27498859e-02f,
  -3.33519350e-03f, 1.43286427e-02f, 1.60557274e-02f, 5.30476309e-02f, -1.07662175e-02f, 5.32155074e-02f, 3.56219858e-02f, 1.46752167e-02f, -2.12281849e-03f, 5.77032380e-03f,
  -3.88140008e-02f, 1.52805233e-02f, -7.77577013e-02f, 9.88146942e-03f, 1.46136817e-03f, 1.85669269e-02f, 2.70500183e-02f, -1.40040489e-02f, -4.61633615e-02f, -6.44318089e-02f,
  1.44878514e-02f, -1.49216445e-03f, -1.27324462e-02f, 5.69481626e-02f, 1.43704237e-02f, 3.28957736e-02f, -3.32345888e-02f, 5.65553643e-02f, 4.06221561e-02f, -1.27523835e-03f,
  1.11477919e-01f, -2.33530048e-02f, -6.82045966e-02f, -1.65582076e-02f, -3.80464233e-02f, -4.81091440e-02f, -3.55705172e-02f, -7.98267964e-03f, 4.03023735e-02f, -6.02485389e-02f,
  1.04612559e-01f, -5.90091608e-02f, 1.33321315e-01f, 9.26350430e-03f, -1.23290103e-02f, 2.01627351e-02f, 2.64699687e-03f, -5.68418438e-03f, -4.89557208e-03f, -2.44855415e-02f,
  6.11844845e-02f, 4.42366339e-02f, -1.10165179e-01f, 2.95473803e-02f, 6.61176667e-02f, -7.85519276e-03f, -6.76154792e-02f, 1.79398283e-02f, -2.07204614e-02f, 1.96523611e-02f,
  1.16737880e-01f, -1.06349471e-03f, 5.86913861e-02f, -2.72133857e-01f, -1.94195300e-01f, 9.69212130e-02f, 1.11521527e-01f, -2.82672167e-01f, -3.26095037e-02f, -8.59555826e-02f,
  -1.78927965e-02f, -1.63152974e-04f, 2.82551408e-01f, -6.79454952e-02f, 9.19021219e-02f, 3.14875305e-01f, -1.65060937e-01f, 5.07370709e-03f, 7.05499128e-02f, -1.23512410e-01f,
  1.19972043e-02f, -1.92436561e-01f, 1.62980899e-01f, -1.23893037e-01f, -1.55959219e-01f, -4.61761430e-02f, -8.05360973e-02f, 3.11592575e-02f, -2.47046918e-01f, -9.06027481e-02f,
  -3.96288410e-02f, -3.00073847e-02f, -2.98425686e-02f, 4.96502183e-02f, 1.32476883e-02f, -3.86859402e-02f, -1.05263991e-03f, 6.51637418e-03f, -1.00916205e-03f, -1.46872248e-03f,
  3.50112729e-02f, -2.24901140e-02f, -3.45457643e-02f, -1.02111520e-02f, -5.36454841e-02f, -9.46170539e-02f, -3.03168520e-02f, 2.84065562e-03f, -3.86330076e-02f, 7.10535869e-02f,
  6.83625741e-03f, -3.35515030e-02f, 3.04620843e-02f, -2.73152739e-02f, 4.97810990e-02f, -3.72825004e-02f, 3.57369371e-02f, 1.45005807e-02f, 8.90583359e-03f, -4.67370041e-02f,
  -7.52170607e-02f, 7.30536431e-02f, 9.89967510e-02f, -5.80566972e-02f, 3.29431444e-02f, -2.70188861e-02f, 2.63114553e-03f, 7.27627277e-02f, -5.36531173e-02f, -3.83321121e-02f,
  -6.02422617e-02f, -3.82686853e-02f, -9.89164412e-03f, 2.56046783e-02f, 1.01143746e-02f, -1.49328290e-02f, 2.25176048e-02f, -2.12997235e-02f, -1.10455081e-02f, 1.21316174e-02f,
  -4.71730568e-02f, 3.54833491e-02f, -2.72410810e-02f, -6.00524768e-02f, 1.24299154e-02f, 3.10411081e-02f, -2.59104706e-02f, 9.36235767e-03f, 5.75725362e-02f, 6.10456318e-02f,
  1.14337364e-02f, -8.26155953e-03f, -4.43020836e-02f, -6.27082363e-02f, -5.44266850e-02f, -2.70280428e-03f, 4.71549630e-02f, -2.02663951e-02f, -2.76854355e-02f, -2.29544919e-02f,
  -5.44021875e-02f, 3.31528448e-02f, -1.00535564e-02f, 1.33807370e-02f, -1.92909539e-02f, 3.47958296e-03f, 6.29292950e-02f, -2.11600753e-04f, -7.10617006e-02f, -8.32056478e-02f,
  3.20945717e-02f, 2.76844297e-02f, 7.38589466e-03f, -6.85702264e-02f, -4.26891595e-02f, 5.31765074e-02f, -4.78195138e-02f, 8.52489769e-02f, -2.88885981e-02f, -1.01849074e-02f,
  4.50623557e-02f, 2.41043225e-01f, 8.12976882e-02f, -8.77087489e-02f, -2.50884295e-02f, -1.77935064e-01f, -2.52660632e-01f, 1.27553537e-01f, 1.25747547e-01f, 4.31771405e-05f,
  -1.45483628e-01f, -3.91909964e-02f, 4.78956513e-02f, -1.06219016e-01f, -2.68584400e-01f, 1.03024296e-01f, -2.95653433e-01f, -7.25491121e-02f, 1.13937914e-01f, -2.89529748e-02f,
  5.68031333e-02f, -2.32729509e-01f, -1.22804545e-01f, -5.92801347e-02f, -2.91839242e-02f, 6.53059557e-02f, -5.13224266e-02f, -1.36718089e-02f, -4.78402562e-02f, -5.63775375e-02f,
  1.76550988e-02f, 1.22738779e-01f, 5.59148639e-02f, 4.69810255e-02f, -2.04701591e-02f, 4.88933967e-03f, -8.14514309e-02f, -9.02459398e-02f, -7.67584145e-02f, 4.97618057e-02f,
  2.74518598e-02f, -4.58316281e-02f, -2.55589653e-03f, -3.74085866e-02f, 1.76678952e-02f, 1.24403864e-01f, -2.75976602e-02f, -6.56404272e-02f, -2.33796462e-02f, 1.06872246e-01f,
  5.18962182e-02f, 3.23047824e-02f, 5.82763553e-03f, -1.37639837e-02f, 6.41237497e-02f, -9.64315981e-03f, 2.39681751e-02f, 1.31357387e-01f, 9.98653471e-02f, 6.06926009e-02f,
  1.92392874e-03f, -2.02784445e-02f, -3.99039425e-02f, 5.48090003e-02f, -2.83211675e-02f, 3.27304602e-02f, 1.94037631e-02f, -2.68743522e-02f, 3.38973589e-02f, -4.86198328e-02f,
  3.65645215e-02f, 3.09723746e-02f, -6.38829544e-02f, 2.35243496e-02f, -1.66595038e-02f, 8.30663368e-02f, -6.51005805e-02f, 2.37048808e-02f, 1.71031468e-02f, 3.83384973e-02f,
  4.54371534e-02f, -7.81765059e-02f, 3.80061567e-02f, -2.97617950e-02f, 3.32421646e-03f, -4.98632379e-02f, 3.03136539e-02f, 8.25586915e-03f, 9.30359140e-02f, -1.58359781e-02f,
  -6.01451397e-02f, -4.58664820e-02f, 1.96757186e-02f, 3.93082276e-02f, 6.03429042e-02f, 1.67961568e-02f, -9.57496017e-02f, 2.42737308e-03f, 1.99403800e-02f, 4.71688583e-02f,
  -5.68799078e-02f, -1.80887580e-02f, -2.23129634e-02f, 2.31726039e-02f, -6.91542774e-02f, 8.40360858e-03f, -1.12965845e-01f, 3.52523513e-02f, -8.55392069e-02f, -4.18463675e-03f,
  -2.84355972e-02f, -1.94525030e-02f, 4.56450991e-02f, 3.64566408e-02f, -1.88869610e-02f, 3.26845236e-02f, 4.39237878e-02f, -2.94961110e-02f, 1.31839635e-02f, 2.08145920e-02f,
  8.09108187e-03f, -2.99713492e-01f, -1.94357887e-01f, -4.30692255e-01f, 4.02029529e-02f, -5.84171042e-02f, -1.92679077e-01f, -1.35603428e-01f, -7.49421790e-02f, 4.56001572e-02f,
  -7.28950128e-02f, -2.05860123e-01f, 1.19214840e-01f, -2.70635813e-01f, -1.37665853e-01f, 1.54194459e-01f, -1.56224087e-01f, -1.23912893e-01f, 9.42160413e-02f, -5.25136217e-02f,
  -1.05186179e-01f, -4.63053063e-02f, -6.89215660e-02f, 3.41518968e-02f, -2.34693453e-01f, -3.40732969e-02f, -1.04657076e-01f, 1.10029718e-02f, -2.46478811e-01f, -5.30983768e-02f,
  -2.43806117e-03f, 1.34006701e-03f, -4.55923714e-02f, -2.11711824e-02f, -2.32088100e-02f, 1.46412998e-02f, -2.63916496e-02f, 9.19985026e-03f, 1.53521337e-02f, -1.56808719e-02f,
  3.02505121e-03f, -1.79504082e-02f, -7.07990974e-02f, 1.20163463e-01f, -6.30822312e-03f, -2.40918268e-02f, 1.47703383e-02f, -1.89578030e-02f, -2.50481572e-02f, -1.06433555e-01f,
  -7.24666715e-02f, -8.41856189e-03f, -5.87377371e-03f, 2.94029415e-02f, -4.16451246e-02f, -4.13601436e-02f, -4.40993719e-02f, 2.48180367e-02f, -6.56381473e-02f, -9.71913687e-04f,
  -1.30315800e-03f, 5.77701852e-02f, 3.21693011e-02f, -4.42276150e-02f, -5.50038964e-02f, -1.86505411e-02f, -5.05386516e-02f, 2.33868975e-02f, 2.22316924e-02f, 4.72231321e-02f,
  -4.75453399e-02f, -5.53017594e-02f, -1.19028976e-02f, 4.82652411e-02f, -6.49752542e-02f, -6.30833255e-03f, 2.02070996e-02f, -5.32928854e-02f, -3.46636884e-02f, -4.05761860e-02f,
  7.57623464e-02f, -1.17042605e-02f, 2.63638736e-04f, -2.10632421e-02f, 4.97749373e-02f, 4.78432141e-02f, 6.16103113e-02f, 8.57651606e-03f, -6.69949409e-03f, 4.59185382e-03f,
  -2.25249499e-01f, -1.27505004e-01f, -3.44370492e-02f, 1.29509857e-02f, -3.88494506e-02f, 2.61259545e-02f, 4.45675850e-03f, 7.54666328e-02f, 3.48425508e-02f, 6.03964832e-03f,
  -3.81381065e-02f, 1.94937885e-02f, -2.86059529e-02f, 1.15902489e-02f, 3.01595981e-04f, -5.62627241e-02f, -9.19927210e-02f, -1.94659588e-04f, -5.06320894e-02f, 2.37121861e-02f,
  -6.81043342e-02f, 1.25042144e-02f, 3.29783671e-02f, 7.08456412e-02f, 7.53436089e-02f, 3.56090590e-02f, -5.51271327e-02f, -1.50288213e-02f, 2.54756808e-02f, -7.41986334e-02f,
  -1.08640930e-02f, -5.22649512e-02f, -1.47105277e-01f, 7.62492716e-02f, -9.80468541e-02f, -2.23562643e-01f, -8.30429494e-02f, -4.79910709e-02f, -4.10470292e-02f, -9.68112424e-02f,
  -9.78719071e-03f, -2.61661131e-02f, 4.75708246e-02f, 2.24871784e-01f, 3.43001038e-01f, 3.16854008e-02f, 1.69379637e-01f, -9.54862963e-03f, 5.54997660e-02f, 1.28839791e-01f,
  1.73248500e-02f, 1.99833021e-01f, 1.23867206e-01f, -1.22144319e-01f, -6.56204000e-02f, -8.33784044e-02f, 3.01704198e-01f, -1.05717622e-01f, 3.10429428e-02f, -4.34941193e-03f,
  6.96914867e-02f, -1.15376953e-02f, -1.41078904e-01f, -3.96597236e-02f, -6.69674128e-02f, -9.16732028e-02f, -3.62146907e-02f, -5.62229101e-03f, 3.56968865e-02f, -1.09521439e-02f,
  -4.26147543e-02f, -7.01270923e-02f, 4.02904600e-02f, 3.75445224e-02f, -1.08770907e-01f, -6.63634613e-02f, -2.51427162e-02f, -5.65522201e-02f, -7.94451684e-02f, -4.16991599e-02f,
  -1.47934288e-01f, -3.98303084e-02f, -6.06232509e-02f, 7.87746459e-02f, 5.78660183e-02f, -7.57350847e-02f, -2.24787239e-02f, 8.63294024e-03f, -1.24117196e-01f, -5.41212186e-02f,
  -1.24529831e-01f, 5.82626052e-02f, -3.99665944e-02f, 8.34714547e-02f, 3.25384066e-02f, -1.84860583e-02f, -6.14140071e-02f, 8.98023173e-02f, 7.04414863e-03f, 5.96311726e-02f,
  3.42292488e-02f, -7.49357231e-03f, -4.64213267e-02f, -4.32397313e-02f, -4.79395315e-02f, 3.02478708e-02f, 4.95074466e-02f, -2.49395315e-02f, -1.03360407e-01f, -4.22496237e-02f,
  2.50958800e-02f, -9.56307799e-02f, 1.86290182e-02f, 3.20653915e-02f, -5.00958636e-02f, 2.29253005e-02f, -1.63159892e-02f, -1.33715188e-02f, 4.40764315e-02f, 4.21084911e-02f,
  1.40219271e-01f, 1.08600050e-01f, 2.28970870e-02f, -3.02980915e-02f, 1.18009612e-01f, 3.24978828e-02f, 2.42411327e-02f, -7.63006061e-02f, 1.56846195e-02f, -2.06806771e-02f,
  -1.39701664e-02f, 6.39576018e-02f, 4.97077554e-02f, -2.73538884e-02f, -6.20690919e-02f, 5.14083207e-02f, 4.19364199e-02f, 7.99215678e-03f, 1.09310364e-02f, -2.59496309e-02f,
  1.03133414e-02f, 4.55328748e-02f, 1.24309026e-02f, -8.43249485e-02f, -8.35127532e-02f, 5.40543124e-02f, -3.33106443e-02f, -1.02891810e-01f, 1.40538421e-02f, 4.95733647e-03f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.33002713e-01f, -2.24021953e-02f, -2.98240691e-01f, -1.29244313e-01f, 1.16506495e-01f, -7.46235251e-02f, 4.55321148e-02f, 4.34068032e-02f, -1.61505282e-01f, 2.71627665e-01f,
  2.31196359e-01f, -1.55051962e-01f, 7.87788779e-02f, -2.67460853e-01f, -3.06971967e-01f, -2.92275399e-01f, -1.62029490e-01f, -1.22396640e-01f, -1.73293099e-01f, 7.69382119e-02f,
  -7.94150904e-02f, 8.33561644e-02f, -1.66360334e-01f, 2.88664490e-01f, 5.54494821e-02f, 8.31661820e-02f, 3.13048363e-01f, 1.97011098e-01f, 2.77577229e-02f, -5.72526716e-02f,
  8.95670801e-02f, 6.74423128e-02f, -2.13379301e-02f, -4.11123149e-02f, 8.61116499e-02f, 4.91358712e-02f, -1.79958791e-02f, -1.58430450e-02f, -1.08493991e-01f, -4.22750600e-02f,
  -8.12567100e-02f, -2.20363755e-02f, -8.54971558e-02f, -7.44471997e-02f, 8.76569562e-03f, -3.40266861e-02f, -4.99506593e-02f, -1.97364334e-02f, -3.74995768e-02f, -1.16188273e-01f,
  -5.69554977e-02f, -3.30722071e-02f, -1.77042577e-02f, -9.21138003e-02f, -1.85382701e-02f, 3.35274450e-02f, -1.83759269e-03f, 1.31511386e-03f, -1.17223943e-02f, -4.01758552e-02f,
  -1.22985002e-02f, 2.91338060e-02f, -3.99385281e-02f, -5.51023223e-02f, 2.94285659e-02f, -2.39161085e-02f, -9.19338837e-02f, 7.45900646e-02f, 3.06976438e-02f, 4.97829206e-02f,
  9.28068012e-02f, -1.93320177e-02f, 7.63713522e-03f, -3.18410695e-02f, 1.45054385e-02f, -3.79897468e-02f, 2.95177400e-02f, 8.29905644e-03f, 3.09941228e-02f, 2.71513388e-02f,
  -9.07552801e-03f, -3.00494526e-02f, 3.45242061e-02f, 4.80283871e-02f, -4.66677472e-02f, 5.19858580e-03f, 1.81295704e-02f, -6.54032081e-02f, -2.56144777e-02f, 8.18979964e-02f,
  1.95398360e-01f, 2.91398168e-01f, 3.09285447e-02f, -2.92412983e-03f, -5.41131618e-03f, -5.71685471e-02f, -4.29113731e-02f, -9.53857452e-02f, 3.37994695e-02f, -2.63158511e-03f,
  8.00646394e-02f, 1.00049436e-01f, 1.45037994e-01f, -1.42716303e-01f, 1.79275516e-02f, 2.93374564e-02f, 1.01663813e-01f, 8.49118978e-02f, 1.71472862e-01f, 2.85094734e-02f,
  5.51986545e-02f, 1.06618486e-01f, -3.85856219e-02f, 8.71760324e-02f, -1.02166822e-02f, 1.15000442e-01f, 5.37763573e-02f, 1.00167794e-02f, 3.02529112e-02f, 2.43050148e-04f,
  -2.98002303e-01f, 2.83684969e-01f, -5.55025637e-02f, 1.82118997e-01f, -1.36908397e-01f, 3.51448655e-01f, 2.78905183e-01f, 1.38713688e-01f, 4.06899422e-01f, 3.13201904e-01f,
  4.17151675e-02f, 2.67657369e-01f, 7.25113451e-02f, 1.36638269e-01f, 2.42267884e-02f, 2.04389080e-01f, 1.30740613e-01f, 1.18600905e-01f, 6.28539398e-02f, 6.18836917e-02f,
  -9.01022740e-03f, 1.92572747e-03f, -1.49660975e-01f, -1.17048226e-01f, -2.31575564e-01f, -1.60976738e-01f, -1.64907262e-01f, -4.86871488e-02f, -5.85639328e-02f, -3.28476727e-02f,
  -7.91276544e-02f, -6.91908691e-03f, -1.80767387e-01f, 3.28488126e-02f, 1.07951418e-01f, 1.69248171e-02f, -3.84698212e-02f, -3.97116244e-02f, -2.41859481e-02f, 8.42606798e-02f,
  7.64013007e-02f, 1.39321815e-02f, 7.70675838e-02f, -3.56488004e-02f, 2.33701188e-02f, -1.12626441e-02f, -3.54399532e-02f, -5.98478653e-02f, 5.48156723e-02f, -2.42428537e-02f,
  5.17417118e-02f, -3.25447731e-02f, -1.19380094e-02f, 6.95274100e-02f, -5.01967259e-02f, 4.14109342e-02f, 1.07488409e-01f, -4.42713387e-02f, 5.46869524e-02f, 1.31155431e-01f,
  1.20051429e-02f, 6.34541288e-02f, 4.95170848e-03f, -4.12645228e-02f, 1.43671371e-02f, -6.30919114e-02f, -3.54979374e-02f, -3.09224874e-02f, -6.69196807e-03f, -2.91715451e-02f,
  3.54618020e-02f, -9.29702818e-03f, 1.92993805e-02f, 7.00275749e-02f, 3.24917138e-02f, -2.50872448e-02f, -3.21507305e-02f, 2.41882224e-02f, 1.47972135e-02f, -1.45889167e-03f,
  2.10376270e-02f, 3.50639671e-02f, -6.60730451e-02f, -3.02190837e-02f, 5.63495159e-02f, 8.42038635e-03f, 7.59912515e-03f, -2.85932682e-02f, -3.89285758e-02f, -4.43423614e-02f,
  3.25050682e-01f, 2.89818972e-01f, 5.53750396e-02f, -1.43915853e-02f, 2.54870504e-02f, -3.62387858e-02f, -7.36194849e-02f, 2.82739867e-02f, 1.17573798e-01f, -5.62549159e-02f,
  -5.31552779e-03f, -4.13624570e-02f, -1.40238712e-02f, 2.12070346e-02f, 3.10481433e-02f, 7.69182071e-02f, 5.07730283e-02f, 3.01224198e-02f, 6.50844350e-02f, -2.68840995e-02f,
  -1.04859918e-01f, 2.25291215e-02f, -4.94524501e-02f, -2.66361400e-03f, 2.21739970e-02f, 1.82953384e-02f, 1.09473336e-02f, -3.41297127e-02f, -4.29344177e-02f, -2.43924581e-03f,
  2.79976815e-01f, -2.77714096e-02f, -1.74266875e-01f, 1.18194990e-01f, 1.25832167e-02f, 4.18905616e-02f, 3.32213379e-02f, -2.25258134e-02f, -2.02567294e-01f, 2.81186514e-02f,
  -2.70142946e-02f, -7.92984590e-02f, -1.97674725e-02f, 1.83027923e-01f, 6.76086545e-02f, -2.08806500e-01f, 4.11334969e-02f, 2.36141533e-02f, -9.10201594e-02f, 1.62410766e-01f,
  5.72992004e-02f, 3.40562135e-01f, -7.46268705e-02f, 2.64589012e-01f, 1.35673463e-01f, 7.88359493e-02f, 7.03886151e-02f, -1.01050794e-01f, 1.15786791e-01f, 9.30065364e-02f,
  8.58986601e-02f, 4.95438091e-02f, -5.71186319e-02f, -4.15273160e-02f, 9.38464403e-02f, 9.90418494e-02f, -4.68073227e-02f, -1.85717642e-02f, -2.44907532e-02f, -9.57202986e-02f,
  3.05806939e-02f, 1.52339274e-02f, 6.50139898e-02f, -2.82114297e-02f, 2.91439015e-02f, -1.23509966e-01f, -1.57877449e-02f, -3.92733738e-02f, -5.33109903e-02f, -2.53682919e-02f,
  -5.68974018e-02f, -5.48768006e-02f, 7.77319213e-03f, -3.17214429e-02f, 3.78414840e-02f, -3.75208184e-02f, 3.82254086e-03f, 8.90922826e-03f, -6.35385215e-02f, 1.42276920e-02f,
  2.77771931e-02f, 1.97813250e-02f, 5.17533794e-02f, 1.67870782e-02f, -3.85736935e-02f, 2.39607710e-02f, -5.22528179e-02f, -5.41332252e-02f, 4.10566851e-03f, -2.84839906e-02f,
  -5.90662733e-02f, -3.44856060e-03f, -1.03251033e-01f, 1.08353393e-02f, 5.21794632e-02f, 1.29271122e-02f, 5.86549798e-03f, -4.15441468e-02f, -5.02184704e-02f, -1.39253270e-02f,
  -1.14509203e-01f, 4.02203947e-02f, 8.09634198e-03f, -1.88314784e-02f, -4.99501964e-03f, 1.39566027e-02f, 9.79556814e-02f, -5.51579110e-02f, 1.55130671e-02f, 3.22852209e-02f,
  7.94789717e-02f, 6.86022416e-02f, -4.08013649e-02f, 7.55513310e-02f, -6.01449907e-02f, 6.26231432e-02f, 2.84285173e-02f, 9.82655585e-02f, 3.11395936e-02f, 8.96685869e-02f,
  -8.70049186e-03f, -2.48284061e-02f, 9.58013535e-03f, 1.88895706e-02f, 3.77796926e-02f, -1.49639631e-02f, 6.46898448e-02f, -6.21806346e-02f, -3.45016643e-02f, -6.16951697e-02f,
  5.42415679e-02f, 3.57890949e-02f, -6.55436441e-02f, -5.26502915e-02f, 1.99444387e-02f, 1.16962167e-02f, 4.75951582e-02f, 6.51949346e-02f, 7.42195686e-03f, -1.33585006e-01f,
  2.40342841e-01f, -4.97535057e-02f, -6.73061460e-02f, 2.19844013e-01f, -3.07289585e-02f, -1.29488811e-01f, -2.68205643e-01f, 4.41497155e-02f, -1.82348698e-01f, -1.63567573e-01f,
  1.16343806e-02f, -1.31964758e-01f, -4.94438410e-02f, 1.76862687e-01f, 2.72466600e-01f, -5.89925386e-02f, 1.11179188e-01f, -1.45921521e-02f, -1.64729506e-02f, 7.94070363e-02f,
  1.50034264e-01f, 2.02294216e-01f, 1.00214384e-01f, 1.83975264e-01f, 5.30266091e-02f, 1.27964839e-01f, 1.25858605e-01f, 1.37921544e-02f, 2.14151606e-01f, 2.32378282e-02f,
  7.09358528e-02f, 9.04693529e-02f, -4.33349758e-02f, 5.85005842e-02f, 2.49690358e-02f, -6.67333454e-02f, -4.21369337e-02f, 5.11038229e-02f, 2.84740366e-02f, 5.08615077e-02f,
  -3.63134742e-02f, 1.10202864e-01f, -2.37589935e-04f, 7.17993602e-02f, -3.76380496e-02f, 6.55894652e-02f, 1.99251622e-03f, -1.12767341e-02f, 3.84290852e-02f, -6.07317174e-03f,
  -3.06123514e-02f, 9.09157470e-02f, -1.45616848e-02f, 7.73065314e-02f, 2.82874983e-02f, 5.16564921e-02f, -3.14906500e-02f, -3.31453197e-02f, -2.51335073e-02f, 1.78088751e-02f,
  8.06852989e-03f, -5.50703667e-02f, -2.86137145e-02f, 2.04916764e-02f, 2.73118988e-02f, 1.18943257e-02f, -2.08046367e-05f, 4.19450812e-02f, -3.54811549e-02f, -2.43075229e-02f,
  4.86766510e-02f, -1.69941725e-03f, 2.83637270e-02f, -6.30978346e-02f, -1.14985928e-02f, -2.02878732e-02f, -5.48218843e-03f, 3.79877239e-02f, -1.08712003e-01f, -5.10496832e-02f,
  5.84805571e-02f, 1.34244142e-02f, -5.77672571e-03f, 4.00696474e-04f, 9.25538689e-02f, -7.90797174e-02f, 5.14456490e-03f, -4.35820259e-02f, -6.44171014e-02f, -3.95391583e-02f,
  8.25914741e-02f, 1.41284391e-01f, -6.24568872e-02f, 2.84256786e-02f, -4.43518907e-02f, 2.32477803e-02f, -3.56191695e-02f, 3.14748921e-02f, 5.00369780e-02f, -3.67625728e-02f,
  -1.79665200e-02f, -5.86187504e-02f, -5.01627326e-02f, -3.31620430e-03f, 6.18532449e-02f, -6.63871616e-02f, 3.84751186e-02f, -3.53367580e-03f, 2.67019812e-02f, 9.45089832e-02f,
  -5.89739950e-03f, -1.10241193e-02f, 7.63903409e-02f, 1.20838461e-02f, 2.84107812e-02f, 4.95401956e-02f, -3.89813744e-02f, -4.19092961e-02f, 1.22127980e-01f, -4.29446287e-02f,
  4.36376967e-02f, 5.48925400e-02f, 4.10817295e-01f, 9.44625027e-03f, 3.40638936e-01f, 2.82245874e-01f, 2.16987118e-01f, 2.00181037e-01f, 3.77580762e-01f, -1.84432298e-01f,
  -1.80441067e-01f, -2.63538629e-01f, -1.89143773e-02f, -1.84452608e-01f, 1.49750903e-01f, 1.44535989e-01f, 1.47416413e-01f, 4.29148450e-02f, 2.58085698e-01f, 3.78464386e-02f,
  1.15382515e-01f, -6.91896901e-02f, -7.87762087e-03f, -8.23211148e-02f, 2.52784993e-02f, -1.31146297e-01f, -2.74073243e-01f, 1.90681025e-01f, -2.65260041e-01f, 2.77650077e-02f,
  1.43633872e-01f, 2.50236616e-02f, -8.11542645e-02f, 2.02881547e-05f, -7.32650533e-02f, -3.22211236e-02f, -8.07712004e-02f, 1.76117495e-02f, 2.74034776e-02f, -4.26521115e-02f,
  -4.72828187e-02f, -2.04126537e-02f, 4.70008180e-02f, -1.30480463e-02f, 1.08850121e-01f, -2.21845414e-02f, 4.12659012e-02f, 4.99140583e-02f, 3.80425975e-02f, 7.01536089e-02f,
  -1.28471171e-02f, 3.63575146e-02f, 2.26684157e-02f, 5.51157407e-02f, 4.16244231e-02f, 7.45980740e-02f, 3.17295603e-02f, -8.27317499e-03f, -1.88724678e-02f, -2.07320768e-02f,
  -1.29759997e-01f, 6.46202266e-02f, -2.49503162e-02f, 2.55116038e-02f, 4.46180627e-02f, -3.37566882e-02f, -5.94271496e-02f, 7.89797679e-03f, 7.20277354e-02f, -2.36824770e-02f,
  -9.11580678e-03f, -1.84471849e-02f, 4.27317284e-02f, -3.93018536e-02f, 2.28584986e-02f, -2.00445950e-03f, -3.70420679e-03f, -2.78331805e-02f, -2.74482127e-02f, -9.26561188e-03f,
  -6.56926632e-02f, 5.23567982e-02f, 8.70270748e-03f, -1.89580545e-02f, 2.87204422e-02f, 4.04042378e-02f, -8.20048526e-02f, 2.37460174e-02f, -3.09289843e-02f, 5.93411690e-03f,
  1.78151240e-04f, 5.53249978e-02f, 2.13793106e-02f, -4.90963832e-02f, -7.26715836e-04f, -1.03518493e-01f, 1.62031054e-01f, -4.35106382e-02f, 8.19905326e-02f, 2.26522386e-02f,
  -3.12136840e-02f, -1.02063054e-02f, -2.46084463e-02f, 3.51937525e-02f, -3.45196649e-02f, 5.37732504e-02f, -5.95096201e-02f, -4.27073352e-02f, -1.27145216e-01f, -4.62160483e-02f,
  -1.58340000e-02f, -3.31654176e-02f, 2.51035928e-03f, -5.58148362e-02f, -6.73936754e-02f, -1.14117526e-01f, 2.04127505e-02f, 1.63233411e-02f, 3.43674310e-02f, 2.81167924e-02f,
  -4.00665551e-01f, 2.43199527e-01f, -2.38808170e-01f, 1.79684460e-01f, -1.05383851e-01f, 2.76803941e-01f, 2.79093862e-01f, -1.89356469e-02f, 6.37335749e-03f, 3.14721525e-01f,
  2.13631526e-01f, -9.60443839e-02f, 2.98797153e-02f, 3.54613125e-01f, -2.25918204e-01f, 1.46574706e-01f, 1.05666369e-01f, 1.90379292e-01f, -6.56252727e-02f, 1.97165925e-02f,
  -1.47562429e-01f, 2.05626264e-01f, 1.56698525e-02f, 4.06297520e-02f, 7.50182569e-02f, -1.04738094e-01f, -2.74630319e-02f, -1.55436188e-01f, 1.28089264e-01f, 2.67530829e-02f,
  9.87728834e-02f, 3.62918689e-03f, -2.36863792e-02f, -6.00660443e-02f, -2.62601450e-02f, 8.73688236e-03f, -1.51207317e-02f, -8.52692127e-02f, -4.71847057e-02f, 1.34399198e-02f,
  -1.18513452e-02f, -5.27720824e-02f, 6.60089776e-02f, -4.22221161e-02f, -3.28592584e-02f, -1.91485919e-02f, -9.28855781e-03f, 1.38357937e-01f, 3.49173211e-02f, -1.52555099e-02f,
  2.68601975e-03f, 1.01843439e-02f, 2.75025051e-02f, 3.70659791e-02f, 6.63271034e-03f, 9.22884643e-02f, 4.83028293e-02f, -8.19306448e-02f, 6.55256351e-03f, -4.48301733e-02f,
  -3.33230346e-02f, -7.69102946e-02f, 6.49610460e-02f, 5.46660759e-02f, -3.64719285e-03f, 3.17849778e-02f, 3.53591926e-02f, 8.61691590e-03f, -5.30022793e-02f, 4.41699736e-02f,
  3.49131674e-02f, -3.16917780e-03f, -1.70558877e-02f, -1.64756887e-02f, -2.72761434e-02f, -1.02395203e-03f, -5.23338206e-02f, 1.32180834e-02f, 5.14669642e-02f, -4.28421758e-02f,
  -1.21567072e-02f, -5.27086332e-02f, 5.34639396e-02f, 3.80778983e-02f, 9.95761808e-03f, -3.22939940e-02f, 4.92836982e-02f, 1.44648948e-03f, 7.58535191e-02f, 2.19930685e-03f,
  1.33827478e-01f, -4.84781340e-02f, 2.69639567e-02f, 1.93996299e-02f, 1.47882849e-02f, -1.69457365e-02f, 1.70716755e-02f, -2.11194288e-02f, -1.91634672e-03f, -4.33664881e-02f,
  -6.38029305e-03f, -2.29006726e-02f, -2.83129755e-02f, -4.82910983e-02f, -3.74041535e-02f, 5.54369465e-02f, 2.88544539e-02f, -7.15287030e-02f, -4.98192906e-02f, -6.89971894e-02f,
  2.15675011e-02f, 1.74339246e-02f, -6.35774359e-02f, -1.19693782e-02f, 2.12251954e-02f, -7.67628709e-03f, -6.90022781e-02f, -1.00911995e-04f, 3.13101374e-02f, 5.02892584e-02f,
  -7.55892813e-01f, 1.81401312e-01f, -1.76070660e-01f, -2.55997270e-01f, 5.17297648e-02f, -1.96527734e-01f, -9.29293260e-02f, -1.38668239e-03f, -1.88162960e-02f, 9.68426391e-02f,
  -3.08230333e-03f, -1.71800554e-02f, 2.18947098e-01f, -1.93016790e-02f, -2.15252876e-01f, 2.04424784e-01f, -2.79889941e-01f, -1.20136373e-01f, 1.69724151e-01f, -1.48333415e-01f,
  -1.29158661e-01f, -4.58223186e-02f, -1.25732392e-01f, 1.96895435e-01f, -1.82482049e-01f, -1.19774297e-01f, -1.08276375e-01f, 1.05845645e-01f, -1.99939996e-01f, 5.37273884e-02f,
  -2.56659299e-01f, -1.55997491e-02f, -1.88796505e-01f, -1.09210126e-01f, -8.32732022e-02f, -8.20846781e-02f, -5.84135391e-02f, 3.68854254e-02f, 2.53924616e-02f, 5.01085557e-02f,
  -7.55275274e-03f, -1.56639749e-03f, 1.70881990e-02f, 5.26918881e-02f, -3.32854837e-02f, -1.62222646e-02f, -1.67964643e-03f, -6.65086433e-02f, 2.23129075e-02f, -1.17379026e-02f,
  4.64032516e-02f, -4.12686430e-02f, -1.77173093e-01f, -5.46641313e-02f, -5.45559078e-02f, 4.86469418e-02f, -9.47600380e-02f, -4.75257188e-02f, -8.68418366e-02f, -4.70939614e-02f,
  2.67950241e-02f, -8.62486809e-02f, 5.86580746e-02f, 8.23436212e-03f, 5.85102178e-02f, 7.27970339e-03f, -5.00606857e-02f, 2.79072970e-02f, -2.29089567e-03f, -6.55891001e-02f,
  7.80942570e-03f, 1.91323385e-02f, 2.73549166e-02f, -3.96808200e-02f, 2.69537466e-03f, 1.83405243e-02f, -3.25900540e-02f, -9.39568877e-03f, -6.24512993e-02f, 1.92531347e-02f,
  4.02108207e-02f, 4.36724573e-02f, 2.87643559e-02f, -8.21607560e-02f, 4.43752632e-02f, 6.17639273e-02f, -5.43693416e-02f, 5.34275994e-02f, 2.57378463e-02f, -6.38049245e-02f,
  -3.97470295e-01f, -2.73550421e-01f, 6.86540529e-02f, 2.60057412e-02f, -2.65627094e-02f, -8.34387615e-02f, -8.21436942e-03f, -6.89994032e-03f, -7.22641451e-03f, -5.07821739e-02f,
  -1.39078572e-01f, -2.60046441e-02f, -1.61757112e-01f, 1.35327931e-02f, 4.08182666e-02f, -6.30534142e-02f, 2.17634235e-02f, -6.08054623e-02f, -7.57306144e-02f, -5.00898249e-02f,
  -5.02155647e-02f, 5.58089577e-02f, 2.35664356e-03f, 5.67999147e-02f, -5.03777936e-02f, -3.05651184e-02f, -7.67538399e-02f, 3.77048738e-02f, -2.43345406e-02f, -2.48763263e-02f,
  4.41206932e-01f, -1.31570699e-03f, 1.61957443e-01f, 3.90356034e-01f, 5.40545918e-02f, -1.13499321e-01f, 3.92672308e-02f, 6.80741593e-02f, 4.76686507e-01f, -1.91827826e-02f,
  -7.28453845e-02f, 1.43865138e-01f, -1.68032467e-01f, 1.53822422e-01f, -3.21017385e-01f, -2.41190106e-01f, 9.39997211e-02f, 2.59659905e-02f, 6.34650514e-02f, 1.48923874e-01f,
  7.41999373e-02f, -1.26553148e-01f, -1.27795726e-01f, -1.69323817e-01f, 1.31823927e-01f, 4.28369381e-02f, -2.39841029e-01f, -2.42115006e-01f, 3.34756672e-02f, -1.79922566e-01f,
  3.15650031e-02f, 8.25030431e-02f, 3.98288853e-02f, -6.00379258e-02f, 8.84935930e-02f, -6.79880157e-02f, -5.14940880e-02f, -8.69079307e-02f, 7.12483451e-02f, 5.17135821e-02f,
  -3.15712532e-04f, -2.45486032e-02f, 4.71151657e-02f, -6.05425835e-02f, 1.69745623e-03f, 4.54529226e-02f, 4.10848223e-02f, 1.63681075e-01f, 1.14082128e-01f, 6.92376718e-02f,
  9.56347883e-02f, 5.69653176e-02f, 9.27926302e-02f, -4.58581140e-03f, 6.57932460e-02f, 9.08875912e-02f, -3.09752207e-02f, -4.00538892e-02f, 1.13827819e-02f, 8.55073985e-03f,
  -7.03458935e-02f, -1.73666067e-02f, -1.72559414e-02f, 2.72478741e-02f, 1.84786487e-02f, 3.03325914e-02f, -3.68467160e-02f, -3.93118896e-02f, -1.30435480e-02f, 8.87661055e-03f,
  1.03145661e-02f, -7.86603242e-03f, 4.35759053e-02f, 4.76711104e-03f, 4.54882905e-02f, 4.21554921e-03f, -3.85705978e-02f, -2.26603192e-03f, 2.56107822e-02f, -8.29121657e-03f,
  -1.81846209e-02f, 3.22994851e-02f, -2.02298574e-02f, 3.57366204e-02f, -1.07680634e-03f, -1.36216618e-02f, -1.29160639e-02f, 7.22366795e-02f, 3.15640420e-02f, -6.98565915e-02f,
  2.18752176e-02f, -2.05503151e-01f, 5.24414517e-03f, 2.93706395e-02f, -3.18310820e-02f, 3.27190459e-02f, -1.85959991e-02f, 3.66915800e-02f, -4.93086912e-02f, -1.97515860e-02f,
  3.65486033e-02f, -8.53282306e-03f, -4.52488139e-02f, 1.74299739e-02f, -9.40671489e-02f, -3.86574742e-04f, 7.24505559e-02f, -5.97124398e-02f, -3.63915116e-02f, -5.17621897e-02f,
  6.46201521e-02f, -1.83606986e-02f, -1.42112179e-02f, 4.41825390e-02f, 1.37602049e-03f, -1.33823948e-02f, 7.19614178e-02f, -2.75511499e-02f, -7.68779442e-02f, -3.51038240e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  3.62038612e-02f, 8.27606469e-02f, 3.58478748e-03f, -1.80644035e-01f, 1.86507180e-01f, -9.00484025e-02f, 1.33255810e-01f, 1.11863457e-01f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -7.70270675e-02f, 7.88621679e-02f, -2.81823333e-02f, 2.98366230e-02f, 3.99967842e-02f, 1.44135281e-01f, 1.06374072e-02f, 4.61805351e-02f, -1.15459241e-01f, 1.19134262e-01f,
  1.72824472e-01f, 1.17807528e-02f, -1.70995027e-01f, 1.73338413e-01f, 1.21077783e-01f, 1.35593548e-01f, 2.41337586e-02f, -1.26602545e-01f, 1.09458305e-01f, 9.23959762e-02f,
  1.53409079e-01f, 2.17059404e-01f, 9.08112451e-02f, -6.66290075e-02f, -7.50308158e-03f, -3.43990251e-02f, -7.24812746e-02f, -6.84089810e-02f, 2.14970633e-01f, -2.70795733e-01f,
  -6.11800067e-02f, 2.21108675e-01f, 2.42293347e-02f, -1.90730169e-01f, 1.27893627e-01f, 1.07706241e-01f, -1.38258278e-01f, -2.44582489e-01f, -2.91815639e-01f, -5.39964624e-02f,
  1.15347491e-03f, -4.80232341e-03f, -1.05537593e-01f, -1.90120384e-01f, 3.21592838e-02f, -1.22150734e-01f, -2.61418596e-02f, -2.28247643e-01f, -2.27442697e-01f, -3.96798812e-02f,
  -2.81425357e-01f, 1.02055892e-01f, -2.33839855e-01f, -1.37203122e-02f, -7.56031126e-02f, 2.77228177e-01f, 5.38709685e-02f, -9.44760665e-02f, 2.12499574e-01f, 7.66415298e-02f,
  -3.74625921e-01f, 4.17782873e-01f, -4.34775501e-02f, -1.73878610e-01f, -2.57454608e-02f, -3.89474258e-02f, 7.22421780e-02f, 2.19850883e-01f, 1.50409654e-01f, -1.92950532e-01f,
  -5.23788519e-02f, -2.36337051e-01f, 8.55856910e-02f, -2.36838358e-03f, -6.05368847e-03f, -3.07145938e-02f, 8.93451869e-02f, 6.75504878e-02f, -7.91814327e-02f, -1.84737056e-01f,
  -9.72685963e-02f, -9.05382633e-02f, -1.53359026e-01f, 2.58648425e-01f, 1.27292220e-02f, 6.36237413e-02f, 1.63609341e-01f, -3.85463312e-02f, 1.95971981e-01f, -2.65778750e-01f,
  -1.72910810e-01f, -1.55720428e-01f, -2.06705734e-01f, 8.12795088e-02f, -6.10725507e-02f, -1.23368829e-01f, -9.30866897e-02f, 5.72119020e-02f, 5.68521470e-02f, -7.63646737e-02f,
  2.76434645e-02f, -1.45060439e-02f, 1.56111553e-01f, -2.07416341e-01f, 1.84768781e-01f, -4.96974513e-02f, 7.46446550e-02f, -6.85623884e-02f, 7.44254738e-02f, -1.26605615e-01f,
  -2.41699979e-01f, -1.40808433e-01f, -2.57776789e-02f, 1.95036128e-01f, -1.58609554e-01f, 4.79356311e-02f, -1.45470098e-01f, 9.51934829e-02f, -7.34377876e-02f, 3.42969503e-03f,
  3.69251780e-02f, 7.84367844e-02f, -1.12284184e-01f, 1.08337104e-01f, -3.76701318e-02f, -2.23849893e-01f, 6.03747778e-02f, 3.06364119e-01f, -9.15293172e-02f, -1.74044281e-01f,
  9.32805911e-02f, -3.95600460e-02f, -2.07076609e-01f, -1.04209319e-01f, -4.08417195e-01f, 1.73394710e-01f, -8.53837058e-02f, -1.03942238e-01f, -1.19759992e-01f, 1.43200094e-02f,
  9.14337859e-02f, -1.69607460e-01f, 3.95662248e-01f, 1.12457290e-01f, 1.60911709e-01f, -9.00577679e-02f, -9.29514691e-03f, 1.80621222e-02f, 1.18446365e-01f, -1.46567777e-01f,
  -1.47905558e-01f, 3.35554421e-01f, -7.89639130e-02f, -2.53154397e-01f, 4.12001461e-02f, 2.76670069e-01f, -3.01807940e-01f, 4.37255740e-01f, 1.29710078e-01f, -2.10673898e-01f,
  -7.77918920e-02f, 4.27675135e-02f, 1.07041761e-01f, 8.06338042e-02f, 2.08992332e-01f, -1.07960247e-01f, 3.77243496e-02f, -1.71964541e-01f, -7.24203363e-02f, -1.39391035e-01f,
  -6.65626442e-03f, 2.47520078e-02f, -4.80853282e-02f, -2.75390804e-01f, -4.28764559e-02f, 3.28396142e-01f, -3.25296700e-01f, 1.10215051e-02f, -1.04049956e-02f, 2.16292486e-01f,
  -3.76385987e-01f, 2.66443461e-01f, -1.88857257e-01f, -1.80773690e-01f, 3.61474276e-01f, -9.14687142e-02f, 1.61861241e-01f, 2.34931782e-01f, -6.92111626e-02f, -7.28184208e-02f,
  -4.00805026e-02f, 4.61694807e-01f, -2.38259315e-01f, -6.32883459e-02f, -3.54506373e-02f, 2.50207096e-01f, -1.54904917e-01f, -1.86774433e-01f, -1.66094810e-01f, 2.49245986e-01f,
  4.84673306e-02f, 5.66802323e-02f, -6.39983863e-02f, -9.28246975e-02f, 9.74611267e-02f, -1.39283046e-01f, -6.90632164e-02f, -7.84142315e-02f, -2.48053484e-02f, 3.15031171e-01f,
  -1.22162864e-01f, -1.86114788e-01f, -5.27838767e-02f, -4.12467532e-02f, -3.14074188e-01f, 1.55087009e-01f, -3.01233739e-01f, 3.14586163e-01f, 3.11258376e-01f, 2.53409147e-01f,
  -1.51455402e-01f, 1.07860062e-02f, -1.79415599e-01f, 1.06005765e-01f, -1.77668959e-01f, -8.51342529e-02f, 4.85260710e-02f, 2.33250171e-01f, -1.82171941e-01f, -6.75739869e-02f,
  -1.22444145e-03f, 9.35033932e-02f, -1.88741773e-01f, -1.76432773e-01f, -6.43991977e-02f, 1.10658102e-01f, -9.49300081e-02f, -3.86347547e-02f, 1.01198152e-01f, -1.36628095e-02f,
  -1.23973712e-01f, 1.99735947e-02f, -1.64705619e-01f, -7.48893321e-02f, 5.96471457e-03f, -1.88740090e-01f, -1.13971658e-01f, 2.48224214e-01f, -1.65711522e-01f, 3.72293949e-01f,
  1.99882895e-01f, 2.66440094e-01f, -4.63536941e-02f, 1.89568207e-01f, 4.07988839e-02f, -4.30614352e-01f, 1.55789956e-01f, -3.39883827e-02f, -1.89474270e-01f, -2.08794862e-01f,
  -1.11348577e-01f, -2.09844597e-02f, 1.75753236e-02f, 1.98323485e-02f, -6.67565838e-02f, 2.46023145e-02f, -4.51112911e-02f, 5.91439568e-02f, -7.28564188e-02f, 1.62550718e-01f,
  3.23544711e-01f, 4.30971831e-01f, 2.02361673e-01f, -7.74441063e-02f, 3.55797082e-01f, -9.61987749e-02f, 1.07643165e-01f, -2.21783325e-01f, 7.00111128e-03f, 4.74025495e-02f,
  1.84911098e-02f, -4.48182076e-01f, 1.20279454e-02f, -1.34303674e-01f, 5.14356457e-02f, -1.69615939e-01f, -3.53540123e-01f, 4.53761108e-02f, -1.17504597e-01f, -1.26324967e-01f,
  5.03401421e-02f, 2.91553717e-02f, -1.27897710e-01f, -1.27484769e-01f, 5.67400903e-02f, -2.30090186e-01f, 5.51994853e-02f, -9.18575376e-02f, 1.77798122e-02f, 1.24173678e-01f,
  -3.69713455e-02f, -1.82678908e-01f, 2.24996597e-01f, 3.34714323e-01f, -1.31233081e-01f, 9.57998112e-02f, 4.64910157e-02f, 8.20939988e-02f, -3.10005993e-01f, 1.31451026e-01f,
  -1.10942952e-01f, -7.75178149e-02f, 4.31901962e-01f, -4.39792164e-02f, 2.19871819e-01f, 2.15603873e-01f, -9.22874287e-02f, -2.16467112e-01f, -5.15367627e-01f, 2.50717551e-01f,
  -1.79957181e-01f, -1.19231343e-01f, 1.72826163e-02f, 1.71060741e-01f, 2.44684011e-01f, -1.69000030e-01f, -1.68908592e-02f, 5.28804548e-02f, 2.46426791e-01f, -1.09102532e-01f,
  -2.01957822e-01f, -1.56235844e-01f, 2.05148444e-01f, 7.68193183e-03f, -1.68173105e-01f, -5.04983187e-01f, -1.43017411e-01f, 4.33953851e-01f, -9.44868028e-02f, 2.67958999e-01f,
  -1.92904413e-01f, 2.44953930e-01f, 1.22473918e-01f, 6.34500338e-03f, 1.06556810e-01f, -1.41805977e-01f, -1.36585712e-01f, 1.21730462e-01f, -1.71852544e-01f, 4.64556254e-02f,
  1.60890177e-01f, 1.03053249e-01f, 8.38016495e-02f, 1.09675646e-01f, 8.55138972e-02f, -8.05167630e-02f, 4.28809077e-02f, 2.40766004e-01f, -4.06831577e-02f, -1.08486690e-01f,
  1.96307991e-02f, 3.20461839e-01f, 1.63434669e-01f, 2.60733634e-01f, -2.82044321e-01f, -1.17187396e-01f, -3.49371061e-02f, 1.38707265e-01f, -5.39599694e-02f, -3.20914865e-01f,
  -2.62695968e-01f, -3.26838344e-02f, 2.27128398e-02f, -2.03012571e-01f, 9.71541107e-02f, -1.84599534e-02f, 2.15637758e-01f, 2.89441288e-01f, 1.75574005e-01f, -1.79051474e-01f,
  2.37567365e-01f, 2.58441359e-01f, -1.97339311e-01f, -1.44004971e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.76668331e-01f, 3.36430013e-01f, 1.86427191e-01f, -1.10415019e-01f, 1.10479459e-01f, 2.13127062e-01f, 3.89829755e-01f, -1.74301565e-01f, -1.71227288e-02f, 2.46654794e-01f,
  2.59810865e-01f, 2.26425931e-01f, -7.05367029e-02f, 1.61793634e-01f, -1.69723883e-01f, 1.84309885e-01f, 1.08431771e-01f, -2.00673208e-01f, -6.32018894e-02f, 1.15915731e-01f,
  1.04659870e-01f, -1.18949868e-01f, 1.27361760e-01f, -9.17098448e-02f, 2.94826329e-01f, -1.48359209e-01f, -8.61124918e-02f, -3.14123571e-01f, 2.57764995e-01f, -1.31329551e-01f,
  -2.73083895e-01f, 2.50982225e-01f, 8.10354799e-02f, 2.22861066e-01f, 2.63574809e-01f, -1.25000784e-02f, 2.27550179e-01f, 4.70069081e-01f, -1.37933105e-01f, 2.47822449e-01f,
  1.26073703e-01f, 1.92240402e-01f, 1.72413558e-01f, 6.40779212e-02f, -5.33993781e-01f, -1.28298208e-01f, 1.71421066e-01f, -1.92685902e-01f, -4.49092761e-02f, -1.12477437e-01f,
  -1.66400269e-01f, -6.36552200e-02f, 3.44969511e-01f, 8.52177013e-03f, 1.06186450e-01f, 1.24069855e-01f, 9.07584727e-02f, 4.75322217e-01f, 1.16323553e-01f, -1.14374936e-01f,
  2.95103431e-01f, 5.40553689e-01f, 1.47824809e-01f, -1.96694031e-01f, 2.18014047e-01f, -5.68678603e-02f, 6.14752173e-02f, 9.54609271e-03f, 1.17859408e-01f, 1.39782652e-01f,
  4.23094109e-02f, -2.25831836e-01f, 1.45729512e-01f, 2.32104789e-02f, -8.51012021e-02f, 3.04959536e-01f, 9.69810318e-03f, 1.04654819e-01f, -1.37468353e-01f, -2.36174807e-01f,
  -6.50696829e-02f, 1.33419428e-02f, 1.03328288e-01f, 1.48625419e-01f, -1.91643670e-01f, 4.85415310e-02f, 2.31894433e-01f, -7.28157088e-02f, 5.32733858e-01f, -1.15557335e-01f,
  -1.55346781e-01f, -3.23588312e-01f, -1.47251368e-01f, -1.97016336e-02f, 1.25128269e-01f, -2.41410866e-01f, 1.77347422e-01f, 6.63340762e-02f, 2.48818055e-01f, -2.78664436e-02f,
  3.17494869e-01f, 2.18503997e-01f, 3.07172447e-01f, 1.00351281e-01f, 1.90953657e-01f, 1.08377934e-01f, -6.71232492e-02f, -1.48873582e-01f, 2.44568419e-02f, -7.38692954e-02f,
  -1.01825319e-01f, -1.00749612e-01f, 4.07595513e-03f, 1.25879264e-02f, 8.94226506e-02f, 2.16238216e-01f, -3.42229530e-02f, 2.52476573e-01f, 2.20155269e-01f, -3.58588129e-01f,
  2.55936801e-01f, 8.92211497e-02f, -8.83504376e-02f, -1.17520459e-01f, 3.49004358e-01f, -2.53038436e-01f, 3.31955254e-01f, 4.81798917e-01f, 1.97930858e-01f, 2.93078393e-01f,
  1.31217211e-01f, -9.54780169e-03f, -1.24646522e-01f, 2.60599971e-01f, 1.01431258e-01f, 2.56965339e-01f, 1.96023747e-01f, 2.84074754e-01f, 3.13679934e-01f, -6.35762000e-03f,
  -3.04689169e-01f, 1.97535589e-01f, 5.79725653e-02f, 2.30765209e-01f, 1.64927378e-01f, 1.89069491e-02f, 4.79901657e-02f, -2.11269736e-01f, 2.42784649e-01f, 8.38756636e-02f,
  2.32576430e-02f, -4.11295183e-02f, 9.71956775e-02f, 2.55094081e-01f, 1.38901830e-01f, -1.89948320e-01f, 4.59224850e-01f, -1.86880231e-01f, -1.48942351e-01f, 9.92788672e-02f,
  -2.64549498e-02f, -2.71645952e-02f, 1.40607223e-01f, 1.79933637e-01f, -4.60544378e-02f, -1.73955008e-01f, 3.22611034e-01f, -6.80745393e-02f, 1.67215206e-02f, -9.79173407e-02f,
  2.05016449e-01f, 1.56762395e-02f, 1.84852958e-01f, -2.56918252e-01f, -2.67852992e-01f, 1.60748109e-01f, -3.08378518e-01f, 1.05864763e-01f, -4.93494004e-01f, -1.18793517e-01f,
  -4.29253876e-01f, -1.06171049e-01f, -2.39184618e-01f, 3.74951750e-01f, 9.13023278e-02f, -9.73514393e-02f, 3.28000098e-01f, 1.32107213e-01f, -1.94901273e-01f, -6.41190074e-03f,
  -2.58889467e-01f, -1.87824279e-01f, -6.61004111e-02f, 1.59419030e-02f, 1.16661198e-01f, 5.76590478e-01f, 1.07850373e-01f, 2.14259341e-01f, -7.46820047e-02f, 2.79160440e-01f,
  1.22421443e-01f, -1.59628522e-02f, -2.09636703e-01f, -8.13197792e-02f, -6.95033595e-02f, 2.89720833e-01f, 9.98779610e-02f, -1.78569630e-01f, 2.69634038e-01f, 4.35329005e-02f,
  1.64785355e-01f, 1.89644337e-01f, 3.22454512e-01f, 2.60683924e-01f, -6.19823597e-02f, -2.30800360e-01f, -8.39783326e-02f, 2.19567955e-01f, -3.01472753e-01f, -2.27793798e-01f,
  2.56930202e-01f, 2.70150363e-01f, 6.21829331e-01f, -4.38483357e-02f, 1.98569655e-01f, -7.44283721e-02f, 2.77678013e-01f, 1.73344508e-01f, 8.11550990e-02f, -3.59529853e-02f,
  2.46216074e-01f, -1.10795707e-01f, 1.82875484e-01f, 1.28996834e-01f, -5.63164875e-02f, -5.07558770e-02f, 9.72872749e-02f, 5.13919396e-03f, -3.53946596e-01f, -3.61661553e-01f,
  -8.04491788e-02f, 1.11028872e-01f, -1.66525826e-01f, 1.22144721e-01f, -1.54062569e-01f, 1.26803845e-01f, 2.88388789e-01f, -5.51067404e-02f, 3.56256306e-01f, -2.16377735e-01f,
  -8.21796358e-02f, -3.18205096e-02f, -6.11556275e-03f, -2.03539103e-01f, 2.35650301e-01f, -1.11451693e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  1.12628825e-01f, 6.04957305e-02f, -5.33437394e-02f, 1.39257953e-01f, 1.58837125e-01f, 1.44578665e-01f, 1.44168556e-01f, 1.94373548e-01f
};

// L2_fan_Wp (Shape: 12 x 32)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -6.57086596e-02f, 1.49152696e-01f, -1.39230415e-01f, 2.22243577e-01f, -2.82170385e-01f, -1.31830825e-02f, 9.52985361e-02f, 8.56902897e-02f, 1.55380785e-01f, -2.92376280e-01f,
  2.65443802e-01f, -1.15375958e-01f, -3.53389718e-02f, -7.95738623e-02f, 1.16314843e-01f, -1.46078557e-01f, 5.78798130e-02f, -2.36322790e-01f, -2.46199846e-01f, -2.43784562e-02f,
  -9.46428254e-02f, -7.65255168e-02f, -2.33531967e-01f, 3.81083548e-01f, 2.93438077e-01f, 4.44808960e-01f, 7.82604292e-02f, 5.84026501e-02f, 2.02032134e-01f, -6.01046272e-02f,
  -1.09205991e-01f, -6.43270761e-02f, -7.45928362e-02f, -4.60977219e-02f, -3.74497958e-02f, -4.05992940e-02f, 1.26567975e-01f, 3.90077643e-02f, -2.19960302e-01f, -1.03109770e-01f,
  2.13130098e-02f, -5.87339438e-02f, -7.23358765e-02f, 1.65592462e-01f, 8.99921879e-02f, -2.46849924e-01f, 1.93234328e-02f, -1.59714326e-01f, -1.34134844e-01f, 5.19083254e-02f,
  -3.40412259e-01f, -3.54547501e-01f, 3.87521714e-01f, 1.08452089e-01f, -5.02103791e-02f, 2.85871863e-01f, 1.39185697e-01f, -2.38684434e-02f, 3.48248869e-01f, 1.94497183e-01f,
  -6.75272942e-02f, 6.77369907e-02f, -2.16607988e-01f, 2.34587535e-01f, 8.98919702e-02f, 1.00137718e-01f, -1.62233859e-01f, 8.62744823e-02f, -1.01486333e-01f, -1.83678627e-01f,
  -4.49326187e-02f, -4.60216030e-03f, 6.45005926e-02f, 1.51053354e-01f, 6.10270631e-03f, -1.98342606e-01f, 1.31772056e-01f, 2.09247917e-01f, -3.55288573e-02f, -2.25504220e-01f,
  2.04767868e-01f, 5.06031662e-02f, -1.97340444e-01f, 6.77940845e-02f, 1.11271992e-01f, 1.43670604e-01f, -1.88697711e-01f, 2.95139343e-01f, 3.57201040e-01f, 3.41805369e-01f,
  2.80961215e-01f, -1.07191607e-01f, 1.31871879e-01f, -1.01976924e-01f, -3.10424209e-01f, -1.08286768e-01f, 1.47328869e-01f, -1.33485841e-02f, 9.15314630e-03f, 2.29876842e-02f,
  -2.50482917e-01f, 1.33479133e-01f, 2.42622197e-01f, -1.05519496e-01f, 2.50156403e-01f, -6.23961799e-02f, 2.39534050e-01f, -1.02965474e-01f, 1.72823444e-01f, -1.65640309e-01f,
  -3.04363091e-02f, 2.83839405e-01f, -3.77821267e-01f, -6.44715428e-02f, 1.93137273e-01f, -6.13467991e-02f, -2.93013275e-01f, 2.89500821e-02f, -7.94353634e-02f, 9.80773270e-02f,
  1.18498124e-01f, 2.65806913e-01f, -3.71892661e-01f, 2.92971969e-01f, 7.00684786e-02f, -9.67545286e-02f, -1.59649849e-01f, -2.30569363e-01f, -1.41008589e-02f, 2.65801083e-02f,
  -2.03927740e-01f, -2.59623826e-02f, -1.71267748e-01f, 5.51173650e-02f, 7.20583200e-02f, -1.93302453e-01f, 1.36928305e-01f, 1.35892600e-01f, -2.60379724e-02f, -1.62531689e-01f,
  8.76731277e-02f, -9.74908397e-02f, -4.81636859e-02f, 2.01477371e-02f, -2.43207291e-01f, 2.83533990e-01f, 9.45727527e-02f, -2.04878509e-01f, 2.23425478e-01f, 2.84748644e-01f,
  -1.05926484e-01f, 2.79331524e-02f, 2.40637362e-01f, -2.20507428e-01f, 4.78302017e-02f, 3.04157473e-02f, -1.24253333e-02f, 1.91441938e-01f, -2.26574019e-01f, -1.64668530e-01f,
  5.77183031e-02f, -1.13468401e-01f, 1.19375929e-01f, -7.14881271e-02f, 2.01061815e-01f, -1.65367573e-01f, 7.29495436e-02f, 1.77323803e-01f, -1.85746655e-01f, -4.34211940e-02f,
  -2.52326876e-01f, 2.19004408e-01f, -1.42948881e-01f, 2.76697189e-01f, 2.87073795e-02f, -3.85291696e-01f, 5.06171227e-01f, -6.36389628e-02f, 1.45949408e-01f, 7.04376921e-02f,
  1.87822744e-01f, -2.31129736e-01f, -1.58583298e-02f, -7.63622746e-02f, -2.82235354e-01f, 2.00073421e-01f, -4.40432578e-02f, -9.00900513e-02f, -1.43549278e-01f, -2.14579508e-01f,
  1.72742352e-01f, -2.43101895e-01f, 4.79523558e-03f, 1.05241597e-01f, 7.45507777e-02f, -2.38823444e-01f, 7.34257773e-02f, 1.78309456e-02f, -1.80452839e-01f, 1.47506744e-01f,
  -1.93410620e-01f, -4.73598875e-02f, -1.92219049e-01f, 5.23979589e-02f, -2.02095225e-01f, 9.48318169e-02f, 2.54079342e-01f, -1.56614780e-01f, 3.01299710e-02f, -2.16067106e-01f,
  -2.64499754e-01f, 1.37555435e-01f, -4.95538935e-02f, -2.85571534e-02f, 1.87866554e-01f, 8.40256922e-03f, -1.09502962e-02f, -1.34379208e-01f, 2.41983354e-01f, -1.14624240e-01f,
  -3.11587691e-01f, 9.32696834e-02f, 2.31192648e-01f, 2.29766577e-01f, -1.68479294e-01f, -9.63996202e-02f, -1.80589214e-01f, -9.52288881e-02f, -3.84830348e-02f, -2.33919416e-02f,
  -2.17104673e-01f, 2.03184575e-01f, -1.67582899e-01f, -2.69763440e-01f, -1.14256799e-01f, -1.15109719e-01f, -1.88504711e-01f, -1.08768962e-01f, 4.57817601e-04f, 1.61544189e-01f,
  -1.58868596e-01f, -2.10239872e-01f, -2.28683800e-01f, -8.37497860e-02f, -1.96076423e-01f, -2.69765824e-01f, -5.01776263e-02f, 3.09038639e-01f, -1.38089836e-01f, 2.81547487e-01f,
  8.97618011e-02f, 1.95202813e-01f, -2.03358680e-02f, -4.20093328e-01f, -1.49908498e-01f, 1.73336744e-01f, -3.34347412e-02f, 8.41516554e-02f, 1.04427777e-01f, -1.08689465e-01f,
  1.23851225e-01f, 1.12244301e-01f, -2.09311038e-01f, 1.97774291e-01f, -2.29558721e-02f, -2.19206125e-01f, 1.61820784e-01f, 1.69811890e-01f, -1.95804939e-01f, -5.41294888e-02f,
  1.31065622e-01f, 6.06236793e-02f, 5.74617237e-02f, -1.84400618e-01f, -3.02109987e-01f, -9.46219340e-02f, -2.12005019e-01f, -1.46306038e-01f, 4.47513580e-01f, -1.70217395e-01f,
  -2.09119454e-01f, -1.40927255e-01f, 1.79410484e-02f, 2.14349195e-01f, -3.27094555e-01f, -7.94732049e-02f, 2.56748170e-01f, 2.73468524e-01f, 1.59140050e-01f, 7.01603517e-02f,
  -1.07613899e-01f, 6.24049343e-02f, -2.44759284e-02f, -2.85648499e-02f, 1.56666577e-01f, 1.48979381e-01f, 5.47714941e-02f, -8.76963288e-02f, 1.34272531e-01f, -1.96501806e-01f,
  -1.23898037e-01f, 1.15565978e-01f, -4.11326848e-02f, -2.89009437e-02f, 1.20195441e-01f, -3.05972509e-02f, 3.40700895e-01f, 2.97612190e-01f, -3.55781674e-01f, 4.08685170e-02f,
  -1.94930300e-01f, 1.13086186e-01f, -2.13931814e-01f, 1.33554250e-01f, -1.35294840e-01f, -6.06260821e-02f, -1.82319935e-02f, 7.59012997e-02f, 1.35541350e-01f, -2.42288947e-01f,
  -1.98835731e-01f, -4.70477715e-02f, -5.61267473e-02f, -1.05414987e-01f, 1.06752560e-01f, 8.15525949e-02f, -2.38276869e-01f, 1.47392629e-02f, -6.78233206e-02f, 2.28924617e-01f,
  -1.25245705e-01f, 6.06682897e-02f, -2.82995086e-02f, -1.71434790e-01f, -6.99882656e-02f, 1.75382197e-01f, -1.97358757e-01f, 1.71154663e-01f, -1.74771011e-01f, -1.57085627e-01f,
  1.89125180e-01f, 2.16102853e-01f, 3.25275034e-01f, -5.67230731e-02f, 2.23830506e-01f, -2.59631693e-01f, 1.66969448e-01f, 4.02703360e-02f, 1.54833853e-01f, 2.72538513e-01f,
  -1.98998138e-01f, 2.50885934e-01f, 2.03051820e-01f, 7.79508948e-02f, -3.28537337e-02f, -1.00188076e-01f, 9.07783359e-02f, 3.96632031e-02f, 2.84402162e-01f, 9.08681285e-03f,
  -1.28142923e-01f, 2.12112889e-01f, -5.29745854e-02f, -1.27769783e-01f, 6.78064302e-02f, 3.80007625e-02f, -1.30874664e-01f, -2.92338938e-01f, 4.72250134e-01f, -1.77478895e-01f,
  3.45425963e-01f, 1.65296808e-01f, 1.77732855e-01f, -2.05809489e-01f, -2.20174551e-01f, -2.40831047e-01f, -4.00749952e-01f, 2.51583964e-01f, -1.88732520e-01f, -1.02359124e-01f,
  1.50544360e-01f, -1.92196399e-01f, -3.35542485e-03f, -3.31092328e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 32)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  1.42180011e-01f, -1.01226702e-01f, 2.98528314e-01f, 2.37208784e-01f, 6.86552599e-02f, 5.32844514e-02f, 4.25161749e-01f, 4.25332785e-01f, -3.15014683e-02f, 1.78489089e-01f,
  -1.57887518e-01f, 3.08622390e-01f, 3.93326968e-01f, -5.78453064e-01f, -3.17789525e-01f, -9.27898958e-02f, -2.48174027e-01f, -4.08163607e-01f, -7.38045126e-02f, -2.84119785e-01f,
  1.15399241e-01f, -5.02009749e-01f, -2.04321672e-03f, -1.53851369e-02f, 2.86694080e-01f, 6.45633191e-02f, -5.02146930e-02f, 4.77748513e-01f, 4.01842147e-01f, -3.12301248e-01f,
  3.70717019e-01f, -6.56815171e-02f, 1.58132523e-01f, -1.72260880e-01f, -6.65777400e-02f, 2.55240649e-01f, 2.95438826e-01f, 1.87038288e-01f, 1.88643470e-01f, 3.95330727e-01f,
  -9.39003017e-04f, 1.59350231e-01f, -1.60800725e-01f, -8.53139255e-03f, 1.60455480e-01f, -5.21364272e-01f, -4.08185184e-01f, -1.07246764e-01f, -1.24866366e-01f, -4.24442053e-01f,
  -1.13250986e-02f, 8.04657638e-02f, 2.74886668e-01f, -3.94981086e-01f, -3.33851427e-01f, 3.07082653e-01f, 1.99659154e-01f, 1.73828214e-01f, -2.60396242e-01f, 9.18476135e-02f,
  4.54464078e-01f, -2.21921250e-01f, 1.92115858e-01f, -1.87898904e-01f, 2.79173665e-02f, -2.50029206e-01f, -2.25686774e-01f, 1.38949990e-01f, -3.15045387e-01f, 2.42601961e-01f,
  3.00622378e-02f, -3.38592440e-01f, 2.02024415e-01f, 2.92072177e-01f, 2.35442132e-01f, -3.13617170e-01f, 2.78901279e-01f, 1.02258667e-01f, -1.28447533e-01f, 2.74933457e-01f,
  -2.38353357e-01f, 5.54038286e-01f, 1.83351785e-01f, -8.91842544e-02f, 8.89571160e-02f, 3.00592780e-01f, -2.13925838e-01f, 9.93262604e-02f, 2.68321335e-01f, 1.99793905e-01f,
  -3.92482989e-02f, 2.45943815e-01f, 3.83122355e-01f, 1.89581662e-02f, -2.58758426e-01f, -5.12771718e-02f, -1.14474278e-02f, -7.51934620e-03f, -8.50477070e-03f, -8.93395767e-03f,
  -9.26803984e-03f, -3.18680075e-03f, -7.05170957e-03f, -9.03108716e-03f, -4.44249669e-03f, -6.05928525e-03f, 6.70047360e-04f, -1.43127830e-03f, -2.44296645e-03f, 2.68464303e-03f,
  7.67281163e-04f, 8.19140300e-03f, -6.42949762e-03f, 4.63302527e-03f, 6.36095321e-03f, -3.67232191e-04f, -2.31397292e-03f, 2.95720692e-03f, -1.29627599e-03f, -5.33862563e-04f,
  -9.10320692e-03f, -3.70404944e-02f, -1.04424777e-02f, -8.19050428e-03f, -1.61488056e-02f, -1.41473464e-03f, -1.71886701e-02f, -7.97313824e-03f, 1.98616296e-01f, 1.99837133e-01f,
  2.35554770e-01f, 7.04705939e-02f, 2.02393979e-01f, 2.08590731e-01f, -2.57209688e-02f, -5.06931404e-03f, 2.50246376e-01f, -1.62447020e-01f, 5.60078397e-02f, 9.09151435e-02f,
  1.77667335e-01f, -2.71350563e-01f, 3.29043835e-01f, 1.53777808e-01f, -3.48005056e-01f, 1.87523693e-01f, -4.33684766e-01f, -3.89911920e-01f, -1.34849533e-01f, -1.17088452e-01f,
  3.78379583e-01f, -1.94624931e-01f, 1.48881897e-01f, 4.45781499e-02f, 3.67186636e-01f, 4.90777224e-01f, -7.54916295e-02f, -2.11824760e-01f, 1.61041155e-01f, 4.02487695e-01f,
  1.35082036e-01f, 1.79933488e-01f, 3.82438600e-01f, 2.55294085e-01f, 3.91609609e-01f, 2.11060137e-01f, 7.14522377e-02f, 1.12745516e-01f, 1.12490632e-01f, 4.02912498e-01f,
  -8.11264142e-02f, 4.11254525e-01f, -1.38038561e-01f, 1.96029842e-02f, -1.69357926e-01f, 3.92180026e-01f, 3.56952757e-01f, 2.19113663e-01f, 1.25318646e-01f, 3.90322506e-02f,
  -8.54222775e-02f, -8.27988684e-02f, 4.65292811e-01f, -5.54914474e-01f, -1.05977923e-01f, -4.71175969e-01f, 1.49115667e-01f, 1.66671038e-01f, -3.65821809e-01f, 1.15502425e-01f,
  3.43448132e-01f, 9.16069597e-02f, 1.71514556e-01f, 8.54607597e-02f, 2.34383374e-01f, 1.40909374e-01f, 2.55302817e-01f, 7.86027908e-02f, -1.29445374e-01f, 1.05234124e-01f,
  1.28560945e-01f, 2.36098364e-01f, 1.28166646e-01f, 6.43860772e-02f, -3.19580466e-01f, 4.53265727e-01f, -3.68725896e-01f, 2.37423912e-01f, 1.04925990e-01f, 4.45464075e-01f,
  4.30547893e-01f, 3.41762036e-01f, -1.43338948e-01f, 3.56168926e-01f, -2.15525210e-01f, 2.39722338e-02f, -1.15947828e-01f, -1.36969045e-01f, -2.57565260e-01f, -4.43504661e-01f,
  -1.21400855e-01f, 6.54172778e-01f, -3.45226735e-01f, -2.19355579e-02f, 2.13691682e-01f, 2.79968828e-01f, 3.22761178e-01f, 4.00551289e-01f, -5.59561104e-02f, 1.30370364e-01f,
  1.85693577e-01f, 6.04308918e-02f, 2.81585276e-01f, -2.28089616e-02f, 4.05531913e-01f, -8.36293176e-02f, -1.47153333e-01f, 3.39814842e-01f, -2.24589542e-01f, -7.29119591e-03f,
  3.61356735e-01f, -4.18610163e-02f, 4.52061594e-01f, 5.51070333e-01f, -7.35399663e-01f, -1.22790337e-01f, -1.50764864e-02f, -1.05737066e-02f, -1.63769022e-01f, 5.82226813e-01f,
  -3.19485217e-01f, 2.87137572e-02f, -8.62697735e-02f, 2.30631500e-01f, 4.60891068e-01f, -2.01947466e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  4.26906884e-01f, 1.48861334e-01f, 1.06489137e-02f, -1.36863422e-02f, 1.52459145e-01f, 4.18881506e-01f, 7.71187469e-02f, 2.47536629e-01f
};

// L3_fan_Wp (Shape: 12 x 32)
const int L3_fan_Wp_rows = 12;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  1.76129878e-01f, -1.53516288e-04f, 1.58607569e-02f, 1.86111003e-01f, -6.69111907e-02f, 1.22545615e-01f, 1.72332183e-01f, -1.22481778e-01f, 1.13616511e-01f, 6.15101345e-02f,
  -1.13107681e-01f, -6.36227429e-02f, -2.75238842e-01f, -1.46022245e-01f, -3.64262164e-01f, -2.46144868e-02f, -3.46446425e-01f, 1.12319022e-01f, 2.20036898e-02f, 1.01291202e-01f,
  1.09576762e-01f, 1.11962296e-01f, 1.88290760e-01f, -1.24399610e-01f, 1.57578349e-01f, 3.89960892e-02f, -3.65076423e-01f, -1.23073040e-02f, -1.43893316e-01f, 3.37587863e-01f,
  4.00646105e-02f, 1.34316236e-01f, -1.00433223e-01f, 2.24518180e-01f, 4.95115854e-02f, 1.62498541e-02f, 1.17182292e-01f, 1.95899993e-01f, 3.67233545e-01f, 3.96344960e-02f,
  1.15539432e-01f, 1.77553728e-01f, 1.62331864e-01f, 1.54470876e-01f, 8.21035281e-02f, 1.91378161e-01f, 1.52850807e-01f, 2.78984994e-01f, 1.77904546e-01f, 1.75304189e-02f,
  -3.30328941e-01f, 1.15058040e-02f, -5.52704073e-02f, -1.08751372e-01f, -1.31770387e-01f, 1.35171130e-01f, 2.71563441e-01f, 2.35761389e-01f, -2.17930108e-01f, -6.06358144e-03f,
  -2.93355603e-02f, -2.70425469e-01f, -2.53482699e-01f, -1.40258804e-01f, 7.06243441e-02f, -6.63865283e-02f, 9.08981264e-02f, 2.55807489e-01f, 9.05658677e-02f, 2.13923454e-01f,
  -8.79212394e-02f, 1.47664556e-02f, 5.05919456e-02f, 1.10447209e-03f, 5.98627776e-02f, -1.97717115e-01f, -2.01083735e-01f, -9.62798148e-02f, -6.86959699e-02f, -2.21524745e-01f,
  -3.63057181e-02f, -1.69095874e-01f, 1.08098231e-01f, -1.30850807e-01f, -1.44942224e-01f, -7.10505992e-03f, 2.40124479e-01f, 1.22342125e-01f, 2.35521331e-01f, 2.08003134e-01f,
  -1.90500051e-01f, -4.14510723e-03f, -3.40645760e-01f, 3.48196179e-01f, 2.11796358e-01f, -3.42337519e-01f, 1.61045760e-01f, -1.05694905e-01f, -8.64877477e-02f, 1.46135628e-01f,
  -5.13675213e-02f, -1.16756350e-01f, -3.46862637e-02f, 4.21493836e-02f, -6.27929494e-02f, -5.14585041e-02f, -7.07982630e-02f, -1.96095452e-01f, -1.75429732e-01f, 1.72700346e-01f,
  -2.14447796e-01f, 1.59272760e-01f, -5.79576902e-02f, -1.43960789e-01f, 2.09782258e-01f, 2.45512240e-02f, 2.20343381e-01f, -3.22080433e-01f, 3.25065494e-01f, -2.34353125e-01f,
  -1.24503270e-01f, -4.35952432e-02f, 3.06315627e-02f, -2.47110939e-03f, 1.65025309e-01f, 1.55458689e-01f, 3.08924973e-01f, -1.93253800e-01f, 1.04486354e-01f, -1.44758299e-01f,
  -1.08107515e-01f, 1.51781589e-01f, -1.35234799e-02f, 5.90624288e-03f, -1.80482656e-01f, -5.24936318e-02f, -2.65979528e-01f, -4.54343557e-02f, 1.74415261e-01f, 3.16121206e-02f,
  3.08727056e-01f, -1.83367282e-02f, 4.38668758e-01f, -1.54160187e-01f, -2.45901849e-02f, 1.64126143e-01f, 1.04915932e-01f, 3.60859036e-02f, -4.25004274e-01f, 8.47647637e-02f,
  -3.20212513e-01f, 4.69840437e-01f, -1.42483145e-01f, 1.65336445e-01f, 1.55552000e-01f, -2.96730362e-02f, -1.65644810e-02f, -1.19945303e-01f, -7.73600489e-02f, 5.50924018e-02f,
  2.90187658e-03f, -8.51814523e-02f, -6.52574077e-02f, -1.23506837e-01f, -8.68980810e-02f, -2.83680618e-01f, 1.34481788e-01f, 6.71832040e-02f, 3.05432618e-01f, 1.73734263e-01f,
  -1.85421854e-01f, 3.95549797e-02f, -1.81424901e-01f, 1.50289118e-01f, -2.34961361e-01f, 7.95643255e-02f, 1.35873616e-01f, 7.72329122e-02f, 1.47151083e-01f, -6.82271197e-02f,
  4.58725452e-01f, -2.57267356e-01f, 3.30518812e-01f, -3.56574237e-01f, -5.38112074e-02f, -1.48128062e-01f, 6.71076402e-02f, 2.28924886e-03f, 1.54252738e-01f, 1.18696682e-01f,
  -2.82393336e-01f, 3.39280372e-03f, -1.62808105e-01f, 1.08323231e-01f, -1.26443192e-01f, 2.98838139e-01f, 5.90882301e-02f, -5.23468591e-02f, 1.93878055e-01f, 8.81759897e-02f,
  7.78064206e-02f, -5.29174618e-02f, -7.39528332e-03f, 6.03419617e-02f, 4.63369228e-02f, -1.69372231e-01f, 1.37681514e-01f, 1.91447198e-01f, -1.33306414e-01f, 3.98621559e-01f,
  -4.13534567e-02f, -8.34502466e-03f, -1.23618931e-01f, 2.00480461e-01f, -7.88306817e-02f, 3.96126151e-01f, -1.10162720e-01f, 1.44054433e-02f, -3.15048210e-02f, -6.61730347e-03f,
  -1.63557529e-01f, -1.09952949e-01f, -9.14110616e-02f, 2.92274624e-01f, 4.53688903e-03f, 1.00454226e-01f, -9.58857983e-02f, 1.14696147e-02f, -3.82139497e-02f, -2.25984901e-01f,
  -6.07262179e-03f, -5.66011965e-02f, 1.94303356e-02f, -2.69116700e-01f, 4.63200845e-02f, 1.28551960e-01f, 2.42056802e-01f, -2.56516367e-01f, 2.77297586e-01f, 6.57521263e-02f,
  2.11633444e-01f, 2.41923198e-01f, -2.20025152e-01f, -1.14311442e-01f, -2.26470456e-01f, 2.41582617e-01f, -2.93166935e-01f, 2.32208401e-01f, -1.85725719e-01f, 3.63391712e-02f,
  3.36330861e-01f, 4.86430712e-03f, -2.31189445e-01f, -7.31063932e-02f, -9.45954584e-03f, 1.91218585e-01f, 6.26141429e-02f, 5.55932373e-02f, 5.23446724e-02f, -1.57854900e-01f,
  3.34076434e-02f, 3.52598801e-02f, -1.17512017e-01f, -1.03355475e-01f, -3.97212170e-02f, -4.30470072e-02f, -4.86764684e-02f, -1.50919199e-01f, -2.33347327e-01f, 1.45623252e-01f,
  -2.10416675e-01f, -1.98947623e-01f, -2.32597291e-01f, -3.14489633e-01f, 1.33480072e-01f, -1.33671477e-01f, 2.78392255e-01f, -5.80723360e-02f, 1.34869203e-01f, -2.90522724e-01f,
  -1.08281389e-01f, -3.12991530e-01f, 9.60752368e-02f, -5.75987296e-03f, 2.79529244e-01f, 3.62274945e-01f, 2.29016021e-01f, -9.20900423e-03f, 2.94626385e-01f, 1.59482192e-02f,
  1.00976169e-01f, 1.01774256e-03f, -8.08767155e-02f, 8.97507146e-02f, 1.76357597e-01f, 1.19859837e-01f, 1.66604429e-01f, 1.34754837e-01f, 8.54321644e-02f, -6.06569164e-02f,
  -2.56931573e-01f, -2.34456342e-02f, -2.15832591e-01f, 3.74999037e-03f, -1.80396378e-01f, -2.20609494e-02f, 1.37239382e-01f, -9.63371992e-02f, 3.09804171e-01f, 4.51595224e-02f,
  1.61745995e-01f, -2.35223144e-01f, -4.06174622e-02f, -1.80606261e-01f, -1.07919127e-01f, -1.75527600e-03f, 2.82938391e-01f, 4.35743004e-01f, -9.74704027e-02f, 8.63272026e-02f,
  -1.35448113e-01f, 1.25123769e-01f, 1.11535676e-01f, -2.97469974e-01f, 1.57989606e-01f, -1.36891976e-01f, 2.97215223e-01f, -8.10760409e-02f, 3.33521247e-01f, 1.37928665e-01f,
  -1.36608928e-01f, 4.90890024e-03f, -2.22317398e-01f, -3.74119058e-02f, -4.07636285e-01f, 1.14020094e-01f, 7.31445700e-02f, -2.94146508e-01f, 5.16028181e-02f, 7.17782825e-02f,
  3.76109987e-01f, 5.61991483e-02f, 1.04398116e-01f, -5.24463534e-01f, -9.19693634e-02f, 1.93713848e-02f, -1.27695456e-01f, 2.49128658e-02f, 1.53911293e-01f, 1.06080242e-01f,
  2.05227405e-01f, 3.25690862e-03f, -7.57105425e-02f, -2.32643723e-01f, -3.55827101e-02f, -2.17617061e-02f, -1.52772918e-01f, -3.04946471e-02f, -1.28442734e-01f, -3.67332287e-02f,
  -1.29233301e-02f, 1.48754269e-01f, -2.12766126e-01f, -1.84551299e-01f, -5.84716089e-02f, 2.95995772e-01f, -1.08335309e-01f, -8.78903433e-04f, -5.15461303e-02f, -9.31123719e-02f,
  3.31460834e-01f, 2.17370376e-01f, 2.73229361e-01f, -2.94932067e-01f, 3.43552619e-01f, -2.34053031e-01f, -4.02751155e-02f, 2.19929218e-02f, 7.87327299e-04f, -3.54663655e-03f,
  2.29058072e-01f, 1.21343695e-01f, -2.79465884e-01f, -1.81445763e-01f
};

// L3_fan_Wp_bar (Shape: 8 x 32)
const int L3_fan_Wp_bar_rows = 8;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  2.46212423e-01f, 8.41173902e-03f, -2.66132690e-03f, 6.71562135e-01f, 2.72851646e-01f, 6.75136596e-02f, 5.01580596e-01f, 4.53227907e-01f, 2.03971744e-01f, 3.34415197e-01f,
  1.41556352e-01f, 2.67887674e-02f, 3.01885456e-01f, 5.46221793e-01f, 7.23878369e-02f, 4.00018364e-01f, 1.93590268e-01f, 3.47856224e-01f, 5.24709448e-02f, -3.99302036e-01f,
  3.32186073e-01f, -7.08211541e-01f, 2.95183271e-01f, 1.07477650e-01f, 5.76574743e-01f, 2.29308203e-01f, 7.66421854e-02f, -6.93542808e-02f, 6.91587210e-01f, 7.30289876e-01f,
  -4.65070367e-01f, -6.24286115e-01f, -3.41945052e-01f, -1.64584532e-01f, 1.21690951e-01f, 1.69056386e-01f, 9.08400565e-02f, 4.12768126e-01f, -4.41044122e-01f, -6.26854822e-02f,
  -4.12208349e-01f, 1.61399588e-01f, 1.40513450e-01f, -1.65801227e-01f, 2.26665735e-01f, 5.53806484e-01f, 3.87173951e-01f, -1.30932882e-01f, -3.71920049e-01f, -3.78210485e-01f,
  1.57758519e-01f, 7.10691810e-01f, -4.36706841e-01f, -5.71473651e-02f, 3.60950828e-02f, 2.02755973e-01f, 3.70225281e-01f, 6.16868138e-01f, -1.34484127e-01f, -2.46102028e-02f,
  3.04174453e-01f, -3.02205142e-03f, 2.31856527e-03f, -3.82089436e-01f, 4.59242761e-01f, 3.01011771e-01f, 4.51446533e-01f, 8.22500363e-02f, 1.15130961e-01f, 3.24905038e-01f,
  2.88103998e-01f, -4.21594501e-01f, -2.42251530e-02f, 3.87082994e-02f, 3.73027384e-01f, 2.41725221e-01f, -2.51495898e-01f, 2.94169664e-01f, -3.60774040e-01f, 3.10027916e-02f,
  -4.30404302e-03f, -4.63357985e-01f, -7.50643536e-02f, 3.22651863e-01f, 1.02645211e-01f, 4.07460928e-02f, 3.02617457e-02f, -7.36346543e-01f, 2.93718308e-01f, -4.67767790e-02f,
  -5.89263320e-01f, -8.04582261e-04f, 4.24639106e-01f, 3.98637712e-01f, 3.26843381e-01f, 1.73945755e-01f, -6.60511792e-01f, -1.72100544e-01f, 8.50848034e-02f, -2.08584100e-01f,
  -5.00798166e-01f, -6.19781971e-01f, 2.43667558e-01f, 8.50792900e-02f, 3.97152007e-01f, -2.35375449e-01f, -5.88541329e-01f, -1.27792373e-01f, -1.93829015e-01f, -4.35569227e-01f,
  2.57392257e-01f, 8.71051028e-02f, 3.96650173e-02f, 1.65114805e-01f, 1.73421040e-01f, 5.62339067e-01f, 1.11515179e-01f, 2.49702677e-01f, -5.72203621e-02f, 1.18590862e-01f,
  2.50631481e-01f, 7.83187300e-02f, 3.55131291e-02f, -1.91283710e-02f, 6.05546415e-01f, -3.17495555e-01f, -5.41971862e-01f, 5.39776087e-01f, 1.79332748e-01f, 4.26032692e-01f,
  2.85557777e-01f, 1.74924374e-01f, 4.78572100e-01f, 4.59646314e-01f, 4.31205451e-01f, 3.82328361e-01f, 2.13109523e-01f, 1.78497672e-01f, 3.20400923e-01f, 2.82790929e-01f,
  2.87789013e-03f, -5.36021888e-01f, -1.71045408e-01f, 1.75738022e-01f, -3.98726940e-01f, 2.90532738e-01f, -4.71772492e-01f, -5.91452479e-01f, 4.22202200e-02f, 5.39099097e-01f,
  -3.96347046e-01f, 3.71332169e-01f, 2.26167098e-01f, 3.96199197e-01f, -6.40248209e-02f, -6.39368296e-02f, -1.59812674e-01f, 5.64075470e-01f, 8.67500961e-01f, 1.06641757e+00f,
  -5.37373543e-01f, 1.46678209e-01f, 1.68860003e-01f, -5.62264584e-02f, -2.29161784e-01f, 1.74818173e-01f, 3.95269126e-01f, 1.10300332e-01f, 1.39440641e-01f, 2.97606409e-01f,
  5.74779883e-02f, 1.98436275e-01f, 8.62229466e-02f, 2.14793682e-01f, 1.42424256e-01f, 3.43708277e-01f, -2.91240931e-01f, 5.97652309e-02f, -1.50225207e-01f, 5.12339830e-01f,
  2.65356526e-02f, 1.95591729e-02f, -1.51600286e-01f, -1.32759392e-01f, 5.67142546e-01f, 4.17407632e-01f, -5.74041784e-01f, 6.04115613e-03f, -4.23082858e-02f, -5.67687988e-01f,
  -3.70239586e-01f, 1.90913975e-01f, -2.34018907e-01f, 3.08476806e-01f, 8.47307816e-02f, -9.83288646e-01f, 2.21918270e-01f, -1.14960529e-01f, -4.74750310e-01f, 2.44652018e-01f,
  4.55056168e-02f, 1.95830062e-01f, 2.42943048e-01f, 2.35444203e-01f, -1.60838023e-01f, 1.90437034e-01f, -7.55285770e-02f, 1.60930023e-01f, 3.63855630e-01f, -6.43326819e-01f,
  -4.41956490e-01f, 1.90127629e-03f, -2.33275041e-01f, 4.11604457e-02f, 4.15683836e-02f, -5.12895525e-01f, 6.62345171e-01f, 5.80042541e-01f, 9.20352042e-01f, 3.67996609e-03f,
  6.61796778e-02f, -1.65570498e-01f, -1.32774338e-01f, -2.41019145e-01f, 4.00151461e-01f, 4.68584783e-02f, 2.10127175e-01f, -1.19975597e-01f, -3.62358056e-02f, 4.82817739e-01f,
  -1.52167588e-01f, -9.22668427e-02f, -3.24641168e-01f, 2.66550452e-01f, 4.16577697e-01f, 1.44256800e-01f, 2.98964847e-02f, 5.71924560e-02f, -2.64550418e-01f, -2.57048875e-01f,
  -4.55961704e-01f, -1.50183693e-01f, 2.78991647e-02f, 5.51426671e-02f, -1.68194100e-02f, 6.61453456e-02f, -4.29674298e-01f, 1.92106515e-01f, 6.19188309e-01f, 3.86061370e-01f,
  -9.93034393e-02f, -1.23444172e-02f, 3.09080988e-01f, 5.06990552e-01f, -5.64027369e-01f, 7.03565776e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 8)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 8;
const float L3_fan_Bp_bar_data[] = {
  2.53135681e-01f, 4.76813549e-03f, 9.88736674e-02f, 1.66159943e-02f, 3.71859580e-01f, -1.49152903e-02f, 6.43582493e-02f, 1.38401240e-01f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -2.29164273e-01f, 2.53641397e-01f, -4.65504266e-02f, -2.52200335e-01f, 1.39883026e-01f, 2.79242903e-01f, -3.23625922e-01f, -1.96485788e-01f, -3.34219217e-01f, 2.10799992e-01f,
  2.09239841e-01f, -1.17318816e-01f, 4.07312036e-01f, 4.10041481e-01f, -3.45393240e-01f, -3.47044498e-01f, 2.15476528e-01f, -3.34729373e-01f, -1.60631821e-01f, 3.51953477e-01f,
  -2.57674277e-01f, -1.16161898e-01f, -2.01867983e-01f, -3.83924425e-01f, -2.30615690e-01f, -5.86690307e-01f, -2.33733088e-01f, 7.93141127e-01f, 6.21034764e-02f, 3.49625051e-01f,
  -5.85945666e-01f, -4.27932113e-01f, 4.71934259e-01f, 2.58563161e-01f, 1.71324298e-01f, 7.35376030e-02f, -3.77480298e-01f, -3.93452764e-01f, -5.02553344e-01f, -4.00235116e-01f,
  4.68532294e-01f, 2.51964629e-01f, 1.55958071e-01f, -2.24915817e-01f, -1.62793964e-01f, -2.20022529e-01f, -7.13626385e-01f, -5.60359478e-01f, 4.25811499e-01f, 5.15672453e-02f,
  2.59679645e-01f, -1.20002732e-01f, -3.88891250e-01f, -7.54729927e-01f, -7.16567039e-01f, 2.64957041e-01f, -2.88335830e-01f, -4.13623184e-01f, -5.06295502e-01f, -5.69833696e-01f,
  5.44633210e-01f, -3.99096698e-01f, -2.42395148e-01f, -5.43315828e-01f, 6.25991970e-02f, 9.57663450e-03f, 3.07888716e-01f, 3.98157746e-01f, 7.48804629e-01f, -3.75534534e-01f,
  1.74144015e-01f, 1.40492553e-02f, 1.70707032e-01f, 4.27836418e-01f, 2.40079746e-01f, -3.22924137e-01f, 6.27385139e-01f, -4.13582057e-01f, 5.35364091e-01f, 9.64155868e-02f,
  -1.07354019e-02f, -4.27951068e-01f, 3.40388328e-01f, 8.30303133e-01f, 7.25721598e-01f, 5.72031796e-01f, 7.57492125e-01f, 3.22014272e-01f, -5.54909885e-01f, -1.87595457e-01f,
  5.42572618e-01f, -1.99362457e-01f, 3.14531893e-01f, -2.89062679e-01f, -1.81890532e-01f, -6.06885195e-01f, 7.00277165e-02f, 7.52971275e-03f, 1.23044394e-01f, -3.99984509e-01f,
  2.18756318e-01f, 1.74648255e-01f, -3.33957106e-01f, -2.46958300e-01f, -2.80052662e-01f, -3.46319109e-01f, 2.27335677e-01f, -4.22416121e-01f, 1.11573480e-01f, -3.42164278e-01f,
  4.66101617e-02f, 4.25482951e-02f, -2.48031512e-01f, 2.56687790e-01f, -2.11379156e-01f, 3.31368268e-01f, -2.52384901e-01f, -1.77524567e-01f, 1.11269332e-01f, -2.19487220e-01f,
  1.58468485e-01f, 6.45784974e-01f, 3.68655384e-01f, -2.25345135e-01f, -6.93684936e-01f, -4.57741290e-01f, -5.93612134e-01f, 4.05994385e-01f, 9.28031951e-02f, -5.47897279e-01f,
  -4.25382741e-02f, 2.41556481e-01f, 1.44776963e-02f, 3.44270140e-01f, 1.21844999e-01f, -2.66378909e-01f, 5.20881712e-01f, 4.06297088e-01f, -1.17214911e-01f, 2.14953557e-01f,
  1.42476074e-02f, -1.35934576e-01f, -5.36245227e-01f, -3.15537453e-01f, -4.83718514e-01f, 1.23698339e-01f, -2.51931131e-01f, -3.27195525e-01f, -1.61854908e-01f, 6.64625645e-01f,
  6.28747702e-01f, 1.54144391e-01f, -1.69842586e-01f, 1.31952375e-01f, 3.61467898e-01f, 3.81130762e-02f, -2.58909374e-01f, 5.03273845e-01f, -3.65160196e-03f, 7.70554617e-02f,
  -3.46000195e-02f, -4.36416179e-01f, 1.60148442e-01f, -3.44406813e-01f, -2.09041551e-01f, -3.76484782e-01f, 2.17475325e-01f, -1.52482867e-01f, -2.41480559e-01f, 1.83142144e-02f,
  1.78315818e-01f, -3.70915830e-01f, -2.70538539e-01f, 4.06936318e-01f, 1.18277676e-01f, 2.76095331e-01f, 3.05248559e-01f, -5.98966852e-02f, 4.69622761e-01f, 5.77091932e-01f,
  -2.47227684e-01f, -3.24016690e-01f, -2.76139021e-01f, -2.30451524e-01f, -7.57882893e-01f, 1.44136935e-01f, -3.33211601e-01f, -9.52148438e-03f, 6.32597879e-02f, 7.10562244e-02f,
  3.42823058e-01f, 1.82648778e-01f, -4.42817718e-01f, -2.36718610e-01f, 3.43395650e-01f, 4.04946119e-01f, 6.15126714e-02f, 2.67700046e-01f, -4.37047184e-01f, 1.64061442e-01f,
  2.52315640e-01f, 5.40428385e-02f, 1.27686888e-01f, 1.32832393e-01f, -2.55413979e-01f, 3.40964824e-01f, 1.34116516e-01f, 1.32474855e-01f, 1.91399708e-01f, 1.58688486e-01f,
  -3.59789312e-01f, 6.62706047e-02f, -4.73935932e-01f, -3.35823923e-01f, -4.18111831e-01f, 5.39822757e-01f, 7.93360323e-02f, 1.60554975e-01f, -6.26641929e-01f, -2.28690550e-01f,
  -8.05778265e-01f, 4.19429243e-02f, 5.25545657e-01f, 1.37607986e-02f, -1.71027273e-01f, 2.07728758e-01f, 3.54808755e-02f, 1.61018535e-01f, 3.61174434e-01f, 3.04651707e-01f,
  2.22021326e-01f, 3.46931547e-01f, 2.52359331e-01f, -2.52580911e-01f, 4.44562823e-01f, 3.94514501e-01f, -1.82355717e-02f, 9.13499296e-02f, -1.50833242e-02f, -3.67076576e-01f,
  -1.42430723e-01f, 1.54961208e-02f, 3.63648236e-01f, -2.62279272e-01f, 2.57282436e-01f, -8.86373222e-02f, 3.44300084e-02f, -4.27465737e-01f, 1.97080925e-01f, -5.19188106e-01f,
  -2.71053407e-02f, -2.49537513e-01f, 1.97631419e-01f, -1.43019900e-01f, -7.33677089e-01f, 5.73541224e-01f, -5.27231216e-01f, -4.34179962e-01f, -2.83340663e-01f, -3.54212642e-01f,
  -7.72075057e-01f, 7.12102234e-01f, 3.12881440e-01f, 2.88814664e-01f, -4.82497603e-01f, -6.77124798e-01f, -5.85783005e-01f, 3.23908567e-01f, 5.95420152e-02f, -1.64318115e-01f,
  3.99143755e-01f, 6.93332911e-01f, -3.23135108e-01f, 5.28863296e-02f, 4.49393503e-02f, -7.04817474e-01f, -3.14735502e-01f, 1.53732017e-01f, -2.02486575e-01f, -7.57851005e-01f,
  -3.85696173e-01f, -1.35621622e-01f, 2.81639755e-01f, -2.22357973e-01f, 3.79967868e-01f, -2.67182469e-01f, -1.58924624e-01f, -6.04387879e-01f, 3.36364031e-01f, 1.70926765e-01f,
  -6.96169436e-01f, -1.36354370e-02f, -7.87332468e-03f, -3.84327114e-01f, 2.38473386e-01f, 2.67785907e-01f, -5.23333371e-01f, -2.06997022e-02f, -1.66349664e-01f, 3.70645851e-01f,
  -1.10806204e-01f, -5.64772844e-01f, 6.88041449e-01f, -4.15772408e-01f, 3.26379806e-01f, -4.00751770e-01f, 1.09710053e-01f, -2.14583680e-01f, 2.11476728e-01f, -3.37989181e-01f,
  -4.47957754e-01f, -3.63621145e-01f, 2.70640492e-01f, 3.79123658e-01f, -3.25937867e-01f, -9.06444013e-01f, -1.01000644e-01f, 3.43166620e-01f, -1.59191657e-02f, 7.10099488e-02f,
  -2.24995524e-01f, 2.80422896e-01f, -2.45135613e-02f, 1.51961043e-01f, 5.23249447e-01f, -3.33905160e-01f, 4.19405311e-01f, 2.48092756e-01f, 3.06430340e-01f, 2.28067294e-01f,
  3.70277613e-01f, -9.27088931e-02f, -6.56052351e-01f, 1.45729110e-01f, -4.28979874e-01f, 4.02895957e-01f, 3.81200872e-02f, 4.92321759e-01f, -4.05485064e-01f, -4.89008337e-01f,
  4.40199107e-01f, 5.10674596e-01f, 1.76971927e-01f, 3.93721551e-01f, 5.89699864e-01f, -9.44131762e-02f, -4.31279868e-01f, 5.47051132e-01f, -5.05799472e-01f, -3.05721462e-01f,
  -4.40354615e-01f, -2.45135903e-01f, 2.40664199e-01f, 1.20224684e-01f, 1.50191277e-01f, -8.67550746e-02f, -8.41145337e-01f, -3.79377335e-01f, -1.61200911e-01f, -4.02120143e-01f,
  -4.75459874e-01f, -2.62270629e-01f, -5.56493461e-01f, 2.33156517e-01f, 2.54199833e-01f, 4.79430556e-01f, -8.35915953e-02f, 3.26649606e-01f, 8.33096355e-02f, 1.45118505e-01f,
  -4.18848455e-01f, -3.05856496e-01f, 2.90623337e-01f, -1.35807857e-01f, 5.84801771e-02f, 4.85656589e-01f, 3.77860606e-01f, -7.01346159e-01f, 2.92861998e-01f, -4.84000325e-01f,
  -1.44708410e-01f, -3.82065713e-01f, 3.02554458e-01f, 6.07611910e-02f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -9.23872143e-02f, 7.26209208e-02f, -3.30670737e-02f, 4.19485010e-02f, -2.09637657e-01f, -8.15806463e-02f, -1.26526728e-01f, -2.60372549e-01f, 2.06315979e-01f, -2.63100147e-01f,
  2.53821880e-01f, -3.08953393e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    