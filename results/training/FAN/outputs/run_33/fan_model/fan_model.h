/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.56174564e-01f, -1.61847457e-01f, -3.33928950e-02f, -2.75447786e-01f, 1.96000859e-01f, 3.55374962e-01f, 2.56207645e-01f, -8.14259574e-02f, 2.41144657e-01f, -4.75058816e-02f,
  1.42225042e-01f, -1.93275064e-02f, 2.56947875e-02f, -1.25535309e-01f, -2.38690581e-02f, 1.41776294e-01f, -8.44386667e-02f, -4.65806276e-02f, -8.02340731e-03f, -4.06425521e-02f,
  -4.81935889e-02f, -1.44758448e-02f, -3.08894634e-01f, -2.48179123e-01f, -1.45731226e-01f, -1.85631141e-01f, -3.36717963e-01f, -5.57887889e-02f, -1.92093596e-01f, -6.38644071e-03f,
  -9.46711525e-02f, -1.92977693e-02f, -8.10938627e-02f, 7.80801028e-02f, 4.59269015e-03f, 5.75526431e-03f, 3.52257229e-02f, -8.57121646e-02f, 3.43584940e-02f, 1.42051475e-02f,
  -2.67300811e-02f, 2.58021262e-02f, -2.47748662e-02f, 5.82871921e-02f, -2.75074417e-04f, 1.74383335e-02f, -3.73500697e-02f, -5.59476577e-02f, -1.88586041e-02f, -2.57681180e-02f,
  5.41476719e-03f, 4.86650644e-03f, 8.55366662e-02f, -3.34512889e-02f, -4.02858220e-02f, 2.27924548e-02f, 6.25517517e-02f, 1.22996587e-02f, 9.30432603e-02f, -9.30115208e-03f,
  1.26229329e-02f, 2.09890381e-02f, 5.80305569e-02f, -6.72640726e-02f, 1.85356643e-02f, 3.27397846e-02f, -9.63932369e-03f, -3.23275030e-02f, 5.20693883e-02f, 1.07524935e-02f,
  2.01276578e-02f, -3.00588571e-02f, 9.05394629e-02f, 6.46854788e-02f, 1.33997211e-02f, 1.93442944e-02f, -2.74611525e-02f, -1.67048052e-02f, 1.43206294e-03f, -4.86673415e-03f,
  -6.53415825e-03f, 2.03495435e-02f, 1.87675636e-02f, -4.07730788e-02f, -2.88411453e-02f, 1.49385231e-02f, 1.61073115e-02f, 6.32920563e-02f, 8.11426435e-04f, -7.92096630e-02f,
  1.54187307e-01f, -5.47574013e-02f, 1.31351873e-02f, 1.39408966e-03f, -6.79189563e-02f, -1.75761674e-02f, -8.14643279e-02f, -4.72990470e-03f, -3.16082984e-02f, -1.88052654e-02f,
  2.62955334e-02f, -2.56620087e-02f, 4.40381393e-02f, -2.05131825e-02f, 1.04714464e-02f, -5.56593947e-02f, 4.93963510e-02f, 6.53177947e-02f, 4.25587706e-02f, -4.23923247e-02f,
  1.59321679e-03f, 1.22945253e-02f, -9.37234461e-02f, -4.79712076e-02f, 9.25777107e-03f, 4.78091910e-02f, 1.05689764e-02f, 6.78597158e-03f, -9.74846408e-02f, -3.99295166e-02f,
  3.34211975e-01f, -4.39483643e-01f, -2.07383767e-01f, -1.94681078e-01f, 2.51773715e-01f, 1.78100049e-01f, 1.20608518e-02f, -8.41808319e-02f, 1.90341230e-02f, -3.27658206e-01f,
  -8.95627886e-02f, -4.44802307e-02f, -1.07496586e-02f, -1.82879314e-01f, 4.37978834e-01f, -1.05461374e-01f, -3.80378999e-02f, -9.57618579e-02f, -9.81465057e-02f, -7.81933740e-02f,
  -3.86076421e-02f, -1.19796768e-01f, -1.23150982e-01f, 2.39553917e-02f, 8.55733175e-03f, -1.15965202e-01f, 1.27918972e-02f, 3.53883021e-02f, -1.16645597e-01f, 7.89096579e-02f,
  -1.13269269e-01f, -1.58470452e-01f, -1.63922515e-02f, -8.06494355e-02f, -2.16745809e-02f, 4.40659076e-02f, 3.73063609e-02f, 3.17529701e-02f, 4.58222106e-02f, -1.75263751e-02f,
  -2.57784082e-03f, 1.65418889e-02f, -4.15045358e-02f, 7.16665154e-03f, 6.26372769e-02f, 4.55507003e-02f, 4.40552039e-03f, -5.93127497e-02f, -5.62315248e-03f, -7.06545496e-03f,
  -5.95702305e-02f, -1.35476932e-01f, 2.32117418e-02f, -6.39645234e-02f, 4.19568922e-03f, -2.21660919e-02f, -3.34981754e-02f, 2.63953805e-02f, 8.78055021e-03f, 2.97044888e-02f,
  -1.57306064e-02f, 3.18650827e-02f, -1.82140581e-02f, -1.25229626e-03f, -2.26683170e-02f, -2.52289101e-02f, -1.07199382e-02f, 3.95997101e-03f, -1.40799768e-02f, -3.88441794e-02f,
  5.82838524e-03f, 9.24447831e-03f, -8.17318540e-03f, 5.11437617e-02f, -4.69394624e-02f, -3.16273272e-02f, 5.94606018e-03f, -5.08568622e-02f, -4.63769101e-02f, 2.21032724e-02f,
  -3.36062871e-02f, -1.96231119e-02f, -1.24769500e-02f, 1.45526510e-02f, 6.88847993e-03f, -2.31195595e-02f, -1.65947881e-02f, -2.65469793e-02f, -4.45277011e-03f, -8.70585069e-03f,
  4.49651964e-02f, -1.01937428e-02f, -6.44740984e-02f, -2.44357195e-02f, -1.67287644e-02f, -4.50480822e-03f, -2.56523341e-02f, 2.58235056e-02f, -3.01406533e-02f, 1.59783494e-02f,
  3.68019007e-02f, 2.17714775e-02f, 1.11274077e-02f, 2.26193685e-02f, -5.78726977e-02f, -7.95871168e-02f, -1.99413188e-02f, -3.41803879e-02f, -1.77905208e-03f, -1.51203405e-02f,
  4.08696346e-02f, 1.29146650e-01f, 1.65680647e-02f, 6.73406497e-02f, 3.79966535e-02f, -1.47868379e-03f, 9.59821716e-02f, -6.46551624e-02f, 1.77611988e-02f, -5.00725843e-02f,
  7.38734663e-01f, -4.53637280e-02f, 5.13735898e-02f, 2.33982503e-01f, 2.93637574e-01f, -4.36244830e-02f, -3.00024748e-01f, 2.92188883e-01f, 4.99073453e-02f, -1.24452353e-01f,
  8.12273547e-02f, -1.01725407e-01f, -1.69633463e-01f, 2.46590331e-01f, -4.75216843e-02f, -6.09485507e-02f, 3.01385671e-01f, 1.37210593e-01f, 1.23193614e-01f, 9.65105742e-02f,
  1.63090765e-01f, 3.33791226e-01f, 1.23208106e-01f, 1.52142450e-01f, 1.98530734e-01f, 9.56412181e-02f, 1.43653035e-01f, -1.63292050e-01f, 3.04743070e-02f, -5.21836020e-02f,
  1.28730655e-01f, 1.38767108e-01f, -1.34034138e-02f, -4.10207585e-02f, 4.89839315e-02f, -1.65628687e-01f, -8.72872919e-02f, -9.11893845e-02f, -3.03431470e-02f, -1.07994437e-01f,
  2.54255645e-02f, 1.05413698e-01f, 7.43141817e-03f, 1.04423344e-01f, 2.77330540e-02f, 1.64054520e-02f, 1.04304940e-01f, 3.81310880e-02f, 2.72683371e-02f, 3.04316338e-02f,
  -4.32319492e-02f, 1.13066606e-01f, 1.35681495e-01f, -3.91925424e-02f, 3.83262150e-02f, 4.47532982e-02f, -1.61017571e-02f, -1.43944725e-01f, 1.63860694e-02f, 2.63797976e-02f,
  6.28769919e-02f, -5.63648762e-03f, 3.27454880e-02f, 6.62989765e-02f, -2.06752978e-02f, 1.52978534e-03f, 5.50086647e-02f, 3.78165655e-02f, -4.30623107e-02f, -2.56743133e-02f,
  5.30715249e-02f, -8.35690740e-03f, 2.57721283e-02f, -1.54148480e-02f, 1.59988794e-02f, -8.63392651e-03f, 2.22431961e-02f, -3.84025984e-02f, -1.35646518e-02f, -1.10911822e-03f,
  1.92330703e-02f, -2.23396067e-02f, 7.20072014e-04f, -2.51900181e-02f, 4.85398099e-02f, -2.54151840e-02f, 5.51517271e-02f, -1.17436731e-02f, 1.50837023e-02f, -3.47594842e-02f,
  -1.57562792e-01f, -2.28745356e-01f, -7.65930768e-03f, -3.87483574e-02f, -5.00739217e-02f, 1.11628294e-01f, 1.87709164e-02f, 5.45653068e-02f, 6.97901892e-03f, 5.33765778e-02f,
  5.82558475e-03f, -7.46062025e-02f, 4.71818522e-02f, -1.38263032e-02f, -2.29282100e-02f, -1.09597277e-02f, -6.52272999e-02f, -1.91265922e-02f, -4.46791807e-03f, -7.05201086e-03f,
  1.34873549e-02f, -6.14693984e-02f, -2.30711997e-02f, 6.03199452e-02f, 1.27551556e-02f, -1.33957900e-02f, -2.30545606e-02f, 2.10955814e-02f, 3.84418480e-02f, -3.56524996e-02f,
  6.27321124e-01f, -1.82845205e-01f, 4.03962433e-01f, 4.18922044e-02f, 1.09405510e-01f, -1.66341856e-01f, 4.16920781e-02f, -4.35856134e-02f, 1.35156095e-01f, -2.63632894e-01f,
  -1.26235530e-01f, 2.11038008e-01f, -1.70456603e-01f, -4.56709228e-02f, 2.50894040e-01f, -1.94175020e-01f, 1.11819975e-01f, -6.34132773e-02f, 3.90199982e-02f, -8.55262130e-02f,
  1.31826386e-01f, -2.16731116e-01f, 1.89883500e-01f, -1.19713038e-01f, 9.51990634e-02f, 6.10995106e-02f, -2.37429608e-02f, 1.22996233e-02f, 2.66131163e-02f, 7.49374852e-02f,
  1.04949595e-02f, -9.41733196e-02f, 1.96715191e-01f, -3.19640487e-02f, 5.66302314e-02f, 1.16601186e-02f, -1.54467067e-02f, 9.42325965e-03f, 1.15523236e-02f, 1.27059380e-02f,
  1.62918284e-03f, 2.66694315e-02f, 4.87141497e-03f, -4.64019068e-02f, 4.13628295e-02f, 1.02778316e-01f, 6.95156977e-02f, -2.32606335e-03f, 2.35236492e-02f, -3.41515429e-02f,
  1.05005912e-01f, 7.12256730e-02f, 4.09618691e-02f, -1.06607033e-02f, 4.48369645e-02f, -7.16477856e-02f, 6.34434745e-02f, 9.03743729e-02f, -3.46783054e-04f, -6.97377184e-03f,
  -1.94364209e-02f, 3.09404768e-02f, -7.03437701e-02f, 4.27706614e-02f, -2.26063058e-02f, 9.86681320e-03f, -2.41696574e-02f, -3.53504494e-02f, 4.18782905e-02f, -1.59071758e-03f,
  1.65850390e-02f, 7.08632579e-04f, 2.39655073e-03f, 2.14768909e-02f, -7.83318747e-03f, -2.13639531e-02f, 2.34471522e-02f, 2.40212884e-02f, 2.26624534e-02f, 2.55890321e-02f,
  1.72718931e-02f, 4.69481163e-02f, -2.83623561e-02f, 2.61600711e-03f, -3.40004452e-02f, 5.23727834e-02f, -6.14747480e-02f, 4.90867309e-02f, 4.95064864e-03f, 2.80965772e-02f,
  -2.03321323e-01f, -1.42687455e-01f, -9.69804227e-02f, 9.40070227e-02f, 2.52836514e-02f, 6.21750194e-04f, -6.42413320e-03f, 2.20690910e-02f, 7.59083824e-03f, -2.43125502e-02f,
  -5.32899760e-02f, -1.24955904e-02f, 2.19257101e-02f, 5.01102209e-02f, 5.53976046e-03f, -5.75446673e-02f, -5.48280180e-02f, 4.65404540e-02f, 9.17030312e-03f, 1.71283018e-02f,
  -8.52295905e-02f, -3.73630226e-02f, -3.88498344e-02f, -1.19308392e-02f, -1.97165534e-02f, 9.59179923e-03f, -8.51703808e-03f, -2.72225924e-02f, -2.11973372e-03f, 7.18633309e-02f,
  -2.40440786e-01f, -3.74396503e-01f, -8.37895274e-02f, -4.02786255e-01f, -1.83786571e-01f, -2.44993344e-01f, -2.61119068e-01f, -5.19072562e-02f, -2.88915724e-01f, 4.45180573e-02f,
  -1.42067224e-01f, -3.49351689e-02f, 1.08959585e-01f, -2.46293470e-01f, -2.48148903e-01f, 7.09073804e-03f, -1.89167827e-01f, -4.35161851e-02f, -9.69239324e-02f, -9.96122658e-02f,
  -1.43498868e-01f, -2.08161086e-01f, -7.23464414e-02f, -6.87943446e-03f, -6.51302636e-02f, -7.25635365e-02f, 1.74911886e-01f, 5.11895157e-02f, -1.04157776e-01f, -1.58487737e-01f,
  -1.28537729e-01f, -8.97251293e-02f, -1.81965213e-02f, 5.15963174e-02f, -2.59995982e-02f, 5.70840053e-02f, 8.51012841e-02f, -5.06409891e-02f, 1.16021140e-02f, -5.21251634e-02f,
  3.89019549e-02f, 1.00228740e-02f, -1.09201722e-01f, 5.95149845e-02f, -9.71260108e-03f, -6.17408752e-02f, -6.70555830e-02f, -1.23196682e-02f, 7.71992200e-04f, 1.89925488e-02f,
  -3.78188565e-02f, -3.08789909e-02f, -1.13189621e-02f, -4.11460325e-02f, -6.78573996e-02f, -4.93302867e-02f, -2.24050563e-02f, -2.98719923e-03f, 4.87451069e-02f, -3.34974527e-02f,
  4.17360701e-02f, 5.99789210e-02f, 7.91476667e-02f, -2.54180077e-02f, -3.37734446e-02f, -4.86401804e-02f, 1.17683709e-02f, 6.72669988e-03f, -9.06435698e-02f, -2.37896964e-02f,
  -1.69378426e-02f, 7.93038681e-03f, -1.01725459e-02f, 1.29094152e-02f, -3.20861191e-02f, -1.11127952e-02f, -8.86217505e-03f, 1.21203503e-02f, -4.75139320e-02f, -6.15338758e-02f,
  -1.06618702e-02f, -2.33804323e-02f, 6.73040235e-03f, -2.94974446e-03f, -3.44643444e-02f, -2.81623583e-02f, 6.31575361e-02f, 2.15387009e-02f, 3.02108601e-02f, 4.67623733e-02f,
  -3.40715088e-02f, -1.28764007e-02f, -1.86988376e-02f, -8.43333751e-02f, 5.30684851e-02f, 2.27089431e-02f, -3.43322195e-02f, -4.16398756e-02f, 7.91420136e-03f, 4.88960780e-02f,
  9.38473195e-02f, -1.96460802e-02f, 6.98027685e-02f, -2.01770440e-02f, -7.43958307e-03f, 2.51563918e-02f, 1.11401491e-01f, -3.87494899e-02f, -8.17402918e-03f, -2.89388373e-02f,
  8.84162784e-02f, 8.72961804e-02f, 3.93182673e-02f, 4.68314178e-02f, 3.35015617e-02f, 5.91000691e-02f, -1.00535853e-02f, -4.71905395e-02f, -2.07341909e-02f, 5.79219358e-03f,
  3.89029714e-03f, -2.86144558e-02f, -1.75848871e-01f, 1.51426539e-01f, 1.17317900e-01f, -8.82707462e-02f, -2.25927547e-01f, 2.02145234e-01f, 1.06125839e-01f, -9.84466597e-02f,
  5.86494952e-02f, -3.44480067e-01f, -3.52700949e-02f, -3.63446511e-02f, 1.68896988e-01f, -1.46732435e-01f, 2.97548532e-01f, -1.16676472e-01f, 2.67288774e-01f, 1.97185710e-01f,
  1.39837474e-01f, 3.93364877e-01f, 2.72936616e-02f, 3.55823338e-01f, 5.53895347e-03f, 8.45948607e-02f, 1.54457882e-01f, -1.52026350e-02f, -1.18375629e-01f, -4.89261746e-02f,
  -1.85993820e-01f, 4.00617160e-03f, -5.33320792e-02f, 6.03724718e-02f, 9.69972983e-02f, -7.41633549e-02f, -7.01620877e-02f, -9.99251902e-02f, -9.82509032e-02f, -5.24549559e-02f,
  -7.20203966e-02f, -4.11686189e-02f, 8.12378824e-02f, 6.93965033e-02f, 7.51888081e-02f, -4.30677235e-02f, 1.92155968e-02f, 3.72153856e-02f, -7.49744251e-02f, -1.66130885e-02f,
  -1.22897461e-01f, 5.14628813e-02f, -4.97094803e-02f, -1.22297704e-02f, -1.02197202e-02f, -1.95840579e-02f, -7.79306442e-02f, -6.66659558e-03f, 1.40339425e-02f, 1.01774469e-01f,
  3.12027093e-02f, 8.65096822e-02f, -1.18979014e-01f, 7.24047273e-02f, -4.07790132e-02f, 4.74850759e-02f, -1.61064118e-02f, -3.47202346e-02f, -1.14748292e-02f, -5.26887067e-02f,
  1.02295592e-01f, 1.26417782e-02f, 7.72534907e-02f, -8.99770781e-02f, 2.79912278e-02f, -6.16365001e-02f, 5.55530265e-02f, -6.31004125e-02f, 2.84708887e-02f, 4.44316491e-02f,
  2.56051291e-02f, 2.07411684e-02f, -1.95175745e-02f, -2.11206032e-03f, -5.47238924e-02f, -2.03749221e-02f, -3.92156541e-02f, 1.96239762e-02f, 1.29726352e-02f, 7.45420232e-02f,
  2.62203217e-01f, 5.46424627e-01f, 4.98611480e-02f, -6.24164455e-02f, 6.08713217e-02f, 3.36690843e-02f, 6.03165925e-02f, 5.82463760e-03f, 1.21668212e-01f, 7.25025386e-02f,
  1.97818317e-02f, -3.08386609e-02f, -1.82811040e-02f, -1.49042755e-01f, -1.09454049e-02f, 5.87209761e-02f, 4.90012318e-02f, 6.44303709e-02f, 1.15675971e-01f, 3.88360880e-02f,
  2.13545207e-02f, -2.83520278e-02f, -4.45248969e-02f, 9.22862142e-02f, -3.65943126e-02f, 7.31409639e-02f, 3.29177314e-03f, 7.08569260e-03f, 1.56329852e-02f, -1.63143519e-02f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.25474745e-01f, -1.26285285e-01f, -2.97717869e-01f, -4.04534698e-01f, 3.07062957e-02f, -6.21775746e-01f, -4.93163377e-01f, -1.63346723e-01f, 1.10673144e-01f, -6.40713274e-02f,
  -6.29892424e-02f, 1.21297747e-01f, 1.13305919e-01f, -3.32968891e-01f, -1.10527217e-01f, 1.05937742e-01f, -5.71361840e-01f, -4.08844739e-01f, 1.35776743e-01f, -2.94984192e-01f,
  -7.43884295e-02f, -3.42162609e-01f, -2.95288265e-01f, 2.37343907e-02f, -4.04469162e-01f, 8.52494761e-02f, 1.98142052e-01f, 1.00115836e-01f, -3.18637937e-01f, 1.38403639e-01f,
  -1.25609115e-01f, 1.37224272e-01f, -5.95721602e-02f, -1.41719440e-02f, -1.60184935e-01f, -1.26501441e-01f, -1.32773042e-01f, 7.97279030e-02f, -7.16375411e-02f, -2.45653894e-02f,
  2.19555628e-02f, 7.86143541e-02f, -5.16957641e-02f, 1.16172709e-01f, -5.41453511e-02f, 6.05023019e-02f, 7.38088191e-02f, -6.85109273e-02f, -4.11768742e-02f, -1.36005819e-01f,
  -9.60905552e-02f, -1.60227373e-01f, -1.66458577e-01f, -1.40587687e-02f, 6.42763898e-02f, 6.39719069e-02f, -5.79454079e-02f, 4.96814884e-02f, 1.51037448e-03f, -5.07716499e-02f,
  -5.05804317e-04f, -9.98617560e-02f, -1.00291774e-01f, 2.17637178e-02f, -7.33635053e-02f, 5.96615896e-02f, -7.80178607e-02f, -3.82843683e-03f, 4.27420549e-02f, -4.08998206e-02f,
  -6.67448118e-02f, 2.26176400e-02f, 1.05009720e-01f, -1.97167009e-01f, -1.57225803e-02f, -3.42108756e-02f, 4.18791585e-02f, 1.19347274e-01f, -3.15531231e-02f, 3.76837887e-02f,
  4.26686257e-02f, -4.73584831e-02f, 4.20069620e-02f, -6.17470890e-02f, -6.53342456e-02f, 8.25347081e-02f, 6.78521069e-03f, -1.79036167e-02f, 4.98455763e-03f, -8.60737041e-02f,
  -3.55588719e-02f, -1.00453645e-01f, 6.44158870e-02f, 6.16555363e-02f, -5.25854202e-03f, 2.92802192e-02f, -5.08974865e-02f, -5.06662689e-02f, -1.04930028e-01f, -2.20219772e-02f,
  -1.14934176e-01f, -9.68302116e-02f, 9.61403362e-03f, 1.69002339e-02f, -3.05221081e-02f, 2.78607681e-02f, -4.50067855e-02f, 1.38547242e-01f, 4.67946082e-02f, 1.01892082e-02f,
  -1.00646773e-02f, 4.36444134e-02f, -2.21810453e-02f, -1.76534411e-02f, -3.07525694e-02f, -1.65724844e-01f, 1.55734839e-02f, 8.27815384e-03f, -7.35564949e-03f, 1.53712919e-02f,
  4.41257119e-01f, -9.76053998e-02f, 3.41071784e-01f, 4.11786586e-01f, 3.37489322e-02f, -5.39018571e-01f, 2.62043446e-01f, 5.11734523e-02f, -1.10524669e-01f, -2.65457422e-01f,
  7.62573853e-02f, -3.32328980e-03f, 1.99835464e-01f, -2.21911982e-01f, 4.11921412e-01f, 2.84424108e-02f, -4.06051949e-02f, -8.02662894e-02f, -4.40674555e-03f, 4.89027090e-02f,
  1.37127787e-01f, -2.27419548e-02f, 3.77506733e-01f, -1.11428976e-01f, 7.85921216e-02f, 1.38857231e-01f, 1.54602781e-01f, 7.47085810e-02f, -8.77765939e-02f, 1.65328812e-02f,
  -3.49206686e-01f, 7.49179628e-03f, 4.58978266e-02f, -2.01732107e-02f, -5.51329143e-02f, -3.15836668e-02f, -3.32855508e-02f, 7.79858753e-02f, -6.05435111e-02f, -2.76912972e-02f,
  -5.43223992e-02f, -5.10864817e-02f, 2.39031557e-02f, -6.18354902e-02f, 2.44185980e-02f, 3.00441030e-03f, 1.87646912e-03f, -7.20074028e-02f, 7.74641708e-02f, 2.03359965e-02f,
  -2.07496230e-02f, -2.41963603e-02f, -6.80514425e-02f, -7.17405155e-02f, 9.50104073e-02f, -9.08554047e-02f, -4.03368883e-02f, 3.21018882e-02f, -2.87096687e-02f, 2.66864598e-02f,
  4.03552689e-02f, -6.96206093e-02f, -1.18100932e-02f, -1.26344636e-01f, 1.03985660e-01f, -3.26751992e-02f, 2.89332513e-02f, -8.95921793e-03f, 7.85827190e-02f, -2.58181449e-02f,
  -2.05914397e-02f, 7.96212554e-02f, -7.64307454e-02f, -9.27938223e-02f, 2.24828888e-02f, -6.91148043e-02f, 8.17029029e-02f, -1.06848657e-01f, 1.45276971e-02f, 2.43783519e-02f,
  6.89736381e-03f, -5.67556880e-02f, -3.01038455e-02f, 6.82402328e-02f, -9.20124631e-03f, 7.52620995e-02f, 2.34605409e-02f, 2.11715233e-02f, -5.03324382e-02f, 3.26011516e-02f,
  -2.02590823e-01f, 9.10067633e-02f, -3.23631801e-02f, -7.12290630e-02f, -1.32315969e-02f, -6.52149171e-02f, 9.14683864e-02f, -3.18275057e-02f, 9.09326300e-02f, 2.68389359e-02f,
  -1.22488127e-03f, 7.53487572e-02f, -7.48159215e-02f, 3.88569161e-02f, -1.57970041e-02f, -1.65296197e-02f, 9.82580036e-02f, -2.70534195e-02f, -7.66786411e-02f, -6.92036143e-03f,
  -1.95753146e-02f, -3.13484333e-02f, -1.14799440e-02f, -8.32500588e-03f, 2.18744692e-03f, 9.33002867e-03f, -3.65805328e-02f, 1.58575587e-02f, -4.98630218e-02f, 4.81662191e-02f,
  -7.53747597e-02f, -1.90165430e-01f, -4.47368115e-01f, 2.30942741e-02f, -1.02990232e-01f, 4.42316234e-02f, -3.79050463e-01f, 1.84459938e-03f, -5.08528471e-01f, 8.41417238e-02f,
  7.54757151e-02f, 6.27037510e-02f, -3.93530935e-01f, 9.13362484e-03f, 2.53248721e-01f, -3.28261346e-01f, 3.02991658e-01f, 1.26467660e-01f, -1.50832593e-01f, 1.96372062e-01f,
  5.92227355e-02f, 4.57672805e-01f, 5.05018746e-03f, 3.42197806e-01f, 5.33987954e-02f, 8.80618244e-02f, 4.70010489e-01f, 5.00654355e-02f, 4.51878369e-01f, 2.73339093e-01f,
  -1.28908940e-02f, -1.61366552e-01f, -3.54357436e-02f, 6.09730510e-03f, 2.85422918e-03f, 6.73127994e-02f, 7.82376528e-02f, 2.92836595e-02f, -5.72586097e-02f, -2.91930116e-03f,
  -3.56151685e-02f, 1.30835664e-03f, 1.09323204e-01f, 5.05284183e-02f, -5.66765480e-02f, 2.40537878e-02f, -1.29713893e-01f, -9.31749567e-02f, -1.66322500e-01f, -1.38426786e-02f,
  -7.19364211e-02f, -1.01964474e-01f, -5.88575006e-02f, -4.68108803e-02f, -1.32865831e-01f, -7.12008157e-04f, -1.32340357e-01f, 1.37207108e-02f, 9.90671571e-03f, -1.42757883e-02f,
  5.15824445e-02f, -1.03119835e-01f, 4.66827899e-02f, -1.56289339e-01f, 7.92118609e-02f, -4.47643586e-02f, -2.95137223e-02f, -1.26256282e-02f, 2.84155309e-02f, 3.64697948e-02f,
  -1.53796347e-02f, -5.09484112e-02f, 2.45880950e-02f, -6.90757781e-02f, 3.34159061e-02f, -5.94052933e-02f, -8.74453411e-03f, 9.53103304e-02f, 4.80720075e-03f, -5.92236593e-02f,
  -5.98783903e-02f, 7.21016079e-02f, -4.45688106e-02f, -3.95070063e-03f, 3.88844572e-02f, -3.78705561e-02f, 2.03628093e-02f, -3.90078314e-02f, -4.88079246e-03f, 2.83022579e-02f,
  1.11473709e-01f, 1.81100085e-01f, 5.43430895e-02f, 7.22493157e-02f, 2.78245136e-02f, 1.31839141e-01f, -7.64153600e-02f, 2.21720058e-02f, 7.46426508e-02f, -4.79478501e-02f,
  1.36884719e-01f, 4.17251959e-02f, 1.38539268e-04f, -7.56740496e-02f, 1.67984799e-01f, 3.18577588e-02f, 5.52340224e-02f, 9.46606994e-02f, 1.42026767e-01f, 1.35954991e-01f,
  5.61508611e-02f, -2.95188464e-03f, 4.90741357e-02f, -9.35798362e-02f, 7.63568878e-02f, -7.11441636e-02f, 7.02479482e-02f, -3.98841649e-02f, -2.56900266e-02f, -3.20034213e-02f,
  -6.06046498e-01f, 4.99286801e-01f, 5.04486978e-01f, -6.21678829e-01f, 2.51135111e-01f, 6.24476820e-02f, -6.27418160e-01f, 2.65555352e-01f, -2.03881919e-01f, -2.93193877e-01f,
  -3.36040616e-01f, 8.66117552e-02f, 8.00375342e-02f, -3.35161686e-01f, -8.33047107e-02f, -1.03279634e-03f, -3.35189909e-01f, -2.93063134e-01f, 1.70736328e-01f, -8.49223137e-02f,
  4.32830565e-02f, -4.36898679e-01f, 1.09893881e-01f, 2.93289006e-01f, 1.46303803e-01f, 4.36705425e-02f, -1.36171505e-01f, 2.01707378e-01f, -4.00183685e-02f, 1.96922541e-01f,
  -2.91214257e-01f, -5.35807610e-02f, 6.99880719e-02f, 4.75165881e-02f, -7.78179690e-02f, 5.93634099e-02f, -1.20445073e-01f, 2.58772913e-02f, 3.13069001e-02f, 2.52430383e-02f,
  4.72041070e-02f, 5.39124496e-02f, 1.06805876e-01f, 9.71188098e-02f, -3.28473859e-02f, 1.73981309e-01f, 1.73991129e-01f, 3.57019380e-02f, 4.69792336e-02f, 1.03121281e-01f,
  2.36644968e-02f, 8.05306956e-02f, -3.77840921e-02f, -5.02099767e-02f, 1.39988914e-01f, -2.55112350e-02f, 6.00299947e-02f, 1.49098337e-01f, -3.02880369e-02f, -1.75415762e-02f,
  3.55796479e-02f, -7.66266584e-02f, 1.86910965e-02f, 3.60980490e-03f, -4.55355980e-02f, 6.52296171e-02f, -4.74070422e-02f, -6.65788352e-02f, 1.99978799e-02f, -1.27196312e-01f,
  -2.39826795e-02f, -7.15497956e-02f, -5.62029099e-03f, -5.61889298e-02f, -1.51482791e-01f, -2.94526313e-02f, -1.21584237e-02f, -3.41297910e-02f, -7.29927644e-02f, 1.21083213e-02f,
  2.90776007e-02f, -8.97956789e-02f, 6.78404868e-02f, -6.99369088e-02f, 3.30886766e-02f, 6.05910085e-02f, -3.46388742e-02f, 7.13861361e-02f, -9.06854216e-03f, -1.01197548e-01f,
  -7.13799655e-01f, -5.18868804e-01f, -8.82331207e-02f, -7.28626922e-02f, 9.84410942e-02f, 3.74966487e-02f, -1.14573268e-02f, 5.84652424e-02f, -3.39978524e-02f, -5.78567423e-02f,
  -7.72747397e-02f, 1.31783430e-02f, -4.75380383e-02f, -8.09957385e-02f, -7.11995829e-03f, -2.38573588e-02f, -1.86761156e-01f, -1.53905094e-01f, -1.85677469e-01f, 9.71847624e-02f,
  -4.35684733e-02f, -8.45909398e-03f, -1.08963214e-01f, 3.79994176e-02f, -6.37519581e-04f, -1.17429845e-01f, -8.94847885e-02f, -1.01681035e-02f, -4.42237817e-02f, -1.07741752e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  -3.15318137e-01f, 2.50712126e-01f, 7.38603547e-02f, 4.41344082e-01f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -2.57567793e-01f, 1.66553184e-01f, -1.13921175e-02f, 9.68712568e-02f, 2.73167849e-01f, -1.14978872e-01f, 5.31580150e-02f, 3.18778664e-01f, 2.53378034e-01f, 5.97174287e-01f,
  -1.86648592e-01f, -7.52186477e-02f, -6.27363563e-01f, 1.62102997e-01f, 7.25334361e-02f, 3.26524645e-01f, -2.61505544e-01f, 3.04214731e-02f, 2.94037968e-01f, 4.04986382e-01f,
  3.88564736e-01f, -2.34798819e-01f, 9.49474350e-02f, -5.74161112e-01f, -3.61388326e-01f, -3.07753775e-02f, 2.21248448e-01f, -2.63749901e-02f, -2.40357339e-01f, 3.99539918e-01f,
  -1.02781601e-01f, 1.70535624e-01f, 6.46284223e-01f, -1.49311528e-01f, 2.64573932e-01f, -3.45501661e-01f, 2.31575817e-01f, -1.97469935e-01f, 2.93585379e-02f, -1.10350358e+00f,
  -3.27024937e-01f, -4.87648472e-02f, 2.29236186e-01f, -4.60153371e-01f, -2.33188942e-01f, -2.22592443e-01f, -3.51832658e-01f, 1.61601245e-01f, -3.54212731e-01f, 5.21058679e-01f,
  -6.21993124e-01f, 3.63094568e-01f, -3.79172593e-01f, 4.06301260e-01f, -2.09491566e-01f, 5.51945925e-01f, 5.84033966e-01f, 1.11149974e-01f, -4.65471715e-01f, 3.95106405e-01f,
  5.94506226e-03f, -2.97370881e-01f, 2.51838148e-01f, 3.32746595e-01f, -4.21188533e-01f, -9.68167838e-03f, 1.05142541e-01f, 1.73532963e-01f, 4.03230011e-01f, -1.34327054e-01f,
  2.58800268e-01f, 1.20287038e-01f, 1.96064278e-01f, 4.16406602e-01f, -2.48000138e-02f, -1.38205856e-01f, -1.51880890e-01f, 4.38172251e-01f, -3.67125422e-01f, 1.50560543e-01f,
  1.00334615e-01f, 5.44751406e-01f, -2.70021677e-01f, -3.41401882e-02f, -2.24681422e-01f, 3.96181554e-01f, 4.14802164e-01f, 3.26533496e-01f, -2.25490555e-01f, -6.10205650e-01f,
  1.10384382e-01f, 2.69466996e-01f, 4.20457125e-01f, -2.17860430e-01f, -3.22913714e-02f, 2.11113334e-01f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  2.82807231e-01f, 1.43697530e-01f, 2.21543387e-01f, 1.61696540e-03f, 1.06376544e-01f, -2.54647225e-01f, -5.91235578e-01f, -1.03176212e+00f, 4.52682793e-01f, -1.08026803e-01f,
  3.15875530e-01f, -6.27392769e-01f, 1.18143070e+00f, -6.18835330e-01f, -5.19644558e-01f, 1.03378832e+00f, 1.73833579e-01f, 6.18213952e-01f, 2.28635505e-01f, 4.51436698e-01f,
  -2.10341901e-01f, -8.61327350e-02f, -3.05428505e-02f, 2.19005402e-02f, -4.67374831e-01f, -8.23794484e-01f, 8.71204019e-01f, 2.01891541e-01f, 2.12692395e-01f, -7.44918287e-01f,
  2.19363153e-01f, 5.90556741e-01f, -7.00570285e-01f, 1.59697890e-01f, -5.37760556e-01f, -7.15374574e-02f, -4.81594168e-02f, 1.08895205e-01f, 2.97871113e-01f, -1.94395170e-01f,
  1.33429849e+00f, 1.71016276e-01f, -9.64383066e-01f, 2.36017406e-01f, -2.15501890e-01f, 3.88857752e-01f, 6.23670399e-01f, -2.96880066e-01f, -4.58678633e-01f, 1.76589757e-01f,
  -1.61681414e-01f, 1.10632384e+00f, 2.75439303e-02f, -2.42490426e-01f, -3.03439707e-01f, -2.50500172e-01f, 7.83913791e-01f, -5.99812031e-01f, -7.80707523e-02f, 2.34069526e-01f,
  6.82242095e-01f, 4.15235639e-01f, 7.59143412e-01f, 1.59526497e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  2.84439027e-01f, 3.57821792e-01f, 1.10479422e-01f, 2.22886249e-01f
};

// L2_fan_Wp (Shape: 6 x 16)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  3.96098047e-01f, 2.24122077e-01f, 2.86551327e-01f, 2.61292934e-01f, 6.36276156e-02f, 3.66911799e-01f, 5.43376446e-01f, 8.55481863e-01f, 2.59671584e-02f, -3.97105664e-01f,
  1.02120602e+00f, -6.65310979e-01f, 7.71751180e-02f, -3.14227223e-01f, 2.23318383e-01f, -3.04449320e-01f, 1.53654858e-01f, -4.94721353e-01f, 5.23770601e-03f, 9.87736881e-02f,
  1.36118203e-01f, -1.66444876e-03f, 8.54046345e-01f, 5.20757496e-01f, -1.24726176e-01f, -3.54278386e-01f, 4.60340649e-01f, -8.04771960e-01f, 6.71297312e-02f, -5.72364569e-01f,
  2.95409143e-01f, -3.56778577e-02f, 1.42525747e-01f, 3.67372751e-01f, -1.20527230e-01f, -2.63259679e-01f, -9.14195850e-02f, 5.05583704e-01f, 9.99605477e-01f, 1.08912528e-01f,
  5.77614188e-01f, -1.97795004e-01f, 3.96411151e-01f, 3.62325668e-01f, 1.81760117e-01f, 1.11351535e-01f, -1.05459802e-01f, -4.07437861e-01f, 1.24459162e-01f, 6.97014451e-01f,
  -4.45503086e-01f, 6.88043684e-02f, 3.82829398e-01f, 8.62643048e-02f, -2.72842914e-01f, 3.10907736e-02f, 6.18938565e-01f, -4.76079643e-01f, -7.32818365e-01f, -9.15611982e-02f,
  7.85429925e-02f, 1.23167314e-01f, -4.91657972e-01f, -2.47763529e-01f, 3.85432728e-02f, -3.36097836e-01f, 4.51848865e-01f, 1.61871567e-01f, -2.41457894e-01f, 1.48938090e-01f,
  8.21079195e-01f, 3.61516476e-01f, -5.69439709e-01f, 1.39258489e-01f, 9.70884681e-01f, -3.32922310e-01f, 3.82146128e-02f, -3.07172686e-01f, 2.30492637e-01f, -3.14579725e-01f,
  1.48566768e-01f, 5.65243423e-01f, 3.31970811e-01f, -1.62891209e-01f, -1.30661055e-01f, 4.75409180e-01f, -3.25538009e-01f, 1.13869190e-01f, 1.89085543e-01f, -8.11371922e-01f,
  -4.69469339e-01f, -6.51611537e-02f, -2.62995750e-01f, 1.73037022e-01f, -4.14036453e-01f, -1.68651149e-01f
};

// L2_fan_Wp_bar (Shape: 4 x 16)
const int L2_fan_Wp_bar_rows = 4;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  7.57921159e-01f, -4.04615812e-02f, 1.44028544e+00f, 1.15517735e+00f, 9.28720012e-02f, -2.30725855e-02f, 2.51898587e-01f, 1.03319764e+00f, -1.19093871e+00f, 1.71795809e+00f,
  3.52207214e-01f, 1.45260572e+00f, -7.12350786e-01f, 1.05735910e+00f, 2.47785211e-01f, 5.68399370e-01f, 8.43837082e-01f, 4.07354265e-01f, -5.03112189e-02f, 4.78032738e-01f,
  9.07833517e-01f, 1.07708359e+00f, 1.45606041e+00f, 1.79153395e+00f, 5.98519087e-01f, -1.11558867e+00f, 1.37559545e+00f, -8.29359174e-01f, 1.93854466e-01f, -2.41009891e-01f,
  3.15086991e-01f, 6.66985512e-02f, -1.87855288e-01f, -2.01355770e-01f, -8.78996015e-01f, -1.36668393e-02f, 5.28937936e-01f, -7.92738497e-01f, 4.54170197e-01f, 2.08319083e-01f,
  8.82026136e-01f, 1.19492121e-01f, -1.64155021e-01f, -6.61076844e-01f, 2.08064628e+00f, 1.07185960e+00f, 1.88736349e-01f, 1.06453454e+00f, 6.94469661e-02f, 5.88242590e-01f,
  -9.89944160e-01f, -8.03686440e-01f, 5.98996043e-01f, 4.67552930e-01f, 6.16523206e-01f, -7.76318967e-01f, -9.35339153e-01f, 1.08827007e+00f, -7.35726282e-02f, -2.56913714e-02f,
  4.37905580e-01f, -9.45852816e-01f, 1.74515855e+00f, 8.80071461e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 4)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 4;
const float L2_fan_Bp_bar_data[] = {
  8.52827013e-01f, 1.12728000e+00f, -2.65610870e-02f, 5.66979229e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  1.07970548e+00f, 6.05342448e-01f, 7.08858848e-01f, -1.24458992e+00f, -1.37709284e+00f, -6.30832970e-01f, 3.68919998e-01f, -1.23934305e+00f, 1.11297321e+00f, 4.33924526e-01f,
  -1.05291641e+00f, 1.46522319e+00f, -9.67366278e-01f, 5.78013301e-01f, -3.04009486e-02f, -3.43902409e-01f, -2.41494700e-01f, 2.86466569e-01f, -1.13178916e-01f, 2.58219719e-01f,
  3.69070292e-01f, 4.48729157e-01f, -9.86338496e-01f, -1.43804824e+00f, -8.19825053e-01f, -8.10092866e-01f, -1.13085449e+00f, -7.97060132e-01f, 7.44882166e-01f, -1.84876931e+00f,
  -7.99777448e-01f, 4.80259746e-01f, 3.34283710e-01f, 4.04770732e-01f, 4.70561951e-01f, -3.88401568e-01f, 3.23129743e-01f, -3.21733683e-01f, -1.00586450e+00f, 1.33779585e+00f,
  -8.04991663e-01f, -9.37601030e-01f, -6.31359339e-01f, -6.07450485e-01f, -1.17264616e+00f, -3.19431126e-01f, -1.85707808e-01f, 6.60519242e-01f, -3.40083718e-01f, -5.70481718e-01f,
  6.05086923e-01f, -9.22028482e-01f, -6.67496145e-01f, 3.99747849e-01f, -8.88752878e-01f, 3.88714671e-01f, 2.18698278e-01f, 3.60682994e-01f, 5.79938412e-01f, -6.60236359e-01f,
  -1.29910505e+00f, -1.39694965e+00f, 8.35117877e-01f, -1.80763066e+00f, 8.87919009e-01f, 4.46513563e-01f, -7.15766191e-01f, 3.81700099e-01f, 6.78910613e-01f, 3.78515452e-01f,
  3.77430841e-02f, -8.43701005e-01f, 5.04566252e-01f, -1.13443278e-01f, -2.55974859e-01f, -1.39217007e+00f, 2.89684832e-01f, -1.64262623e-01f, 3.70357275e-01f, -7.44900823e-01f,
  7.33297050e-01f, 8.75927091e-01f, 4.13669676e-01f, 6.58840895e-01f, 1.54391253e+00f, 6.06780767e-01f, 1.24238968e+00f, -1.05574381e+00f, 5.01949072e-01f, 6.07849061e-01f,
  -3.01678449e-01f, 7.01431751e-01f, 9.41124737e-01f, 3.99745166e-01f, -1.63067579e+00f, -6.52018487e-01f, -1.59651384e-01f, 6.27388656e-01f, 5.67494452e-01f, -1.00712621e+00f,
  -9.73790288e-01f, -4.67525065e-01f, 7.98303246e-01f, 9.89685774e-01f, 8.35952699e-01f, -1.06087983e+00f, 9.27783132e-01f, -1.07327044e+00f, 2.51160532e-01f, -2.01083459e-02f,
  -1.81799066e+00f, 5.06829262e-01f, -5.07851660e-01f, -1.69581503e-01f, -1.93793654e-01f, 8.25968325e-01f, -1.33331239e-01f, -8.65148723e-01f, 6.16316311e-02f, -1.76135406e-01f,
  -8.49117279e-01f, -2.49691069e-01f, -3.13499868e-01f, 6.68557510e-02f, -9.21278179e-01f, -1.37228310e+00f, 4.90414262e-01f, 1.21379890e-01f, 1.21950753e-01f, -8.66453946e-01f,
  -1.30242562e+00f, -3.92093509e-01f, 1.18503913e-01f, -7.44628906e-01f, 3.22263837e-01f, -2.94993192e-01f, -5.51566958e-01f, 4.24035996e-01f, 1.09872472e+00f, 4.89447951e-01f,
  1.02141879e-01f, 1.73241332e-01f, -2.43593365e-01f, 2.15049461e-01f, -1.09530056e+00f, -1.70081005e-01f, -1.37342244e-01f, 8.82242262e-01f, -8.85785937e-01f, 6.37825549e-01f,
  -1.27334997e-01f, 1.35535085e+00f, 8.50959778e-01f, -8.99739563e-01f, 1.18263674e+00f, 1.20997620e+00f, -2.49549404e-01f, 1.04879129e+00f, -1.62707734e+00f, -1.21948755e+00f,
  -8.41664016e-01f, -7.07631111e-01f, 2.98329175e-01f, 2.67152011e-01f, -1.11803889e+00f, 2.18932733e-01f, -4.67903078e-01f, 5.98496377e-01f, -1.22431254e+00f, 9.18479860e-01f,
  -4.05984491e-01f, 9.35924411e-01f, 9.82297421e-01f, -1.46231747e+00f, -5.90584911e-02f, -1.59132624e+00f, -1.12081373e+00f, 7.06951246e-02f, -2.15183571e-01f, 1.60941884e-01f,
  1.05789459e+00f, 2.22112477e-01f, 3.99206400e-01f, 1.42003703e+00f, 3.74699652e-01f, 7.65467465e-01f, 6.90783441e-01f, -4.10929263e-01f, -1.58695841e+00f, 7.10206687e-01f,
  2.71953970e-01f, -2.99336702e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  6.39193535e-01f, 1.48306504e-01f, -3.49963933e-01f, -1.24401204e-01f, -4.51180845e-01f, 1.10432684e-01f, -2.80025661e-01f, -2.40889594e-01f, -5.49620628e-01f, 2.87408978e-01f,
  3.44073147e-01f, -3.51807177e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    