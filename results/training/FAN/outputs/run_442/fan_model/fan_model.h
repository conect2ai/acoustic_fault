/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.07577585e-01f, -5.67369938e-01f, 3.33705455e-01f, 2.28014886e-02f, 4.46621031e-02f, -1.12151027e-01f, -1.10677049e-01f, -1.73960045e-01f, -8.36213231e-02f, -4.37423825e-01f,
  8.08876287e-03f, -1.63842738e-01f, -1.18860193e-01f, -5.02690673e-02f, 5.03256738e-01f, 1.22980595e-01f, -5.41463234e-02f, -1.68666393e-01f, 4.63305190e-02f, -1.55502647e-01f,
  1.94937199e-01f, 1.65779726e-03f, 1.59144431e-01f, 6.23233169e-02f, -3.73444445e-02f, -6.78388923e-02f, 1.05353639e-01f, 1.00586005e-01f, -1.32799596e-01f, 1.02938466e-01f,
  -1.44521862e-01f, -7.74789155e-02f, 5.09308465e-02f, 3.30339931e-02f, -1.45182714e-01f, -1.26880500e-02f, -5.33088073e-02f, 6.31500110e-02f, 1.99611306e-01f, -1.31826729e-01f,
  8.70720856e-03f, -8.61049294e-02f, -3.84860067e-03f, -6.55053779e-02f, -1.27350599e-01f, -3.74932811e-02f, -1.10684507e-01f, -4.78159450e-02f, -7.21946955e-02f, 4.84801410e-03f,
  -1.60330031e-02f, -6.09252416e-02f, -8.29249062e-03f, -3.34951170e-02f, 1.23500906e-01f, 3.19704004e-02f, 3.15751322e-02f, 3.62568051e-02f, -1.46329343e-01f, -2.16764919e-02f,
  1.24232240e-01f, -2.32164506e-02f, 6.67318702e-02f, -9.63840038e-02f, 1.06276656e-02f, -2.14111041e-02f, -1.05240773e-02f, 3.23835537e-02f, 3.11551848e-03f, 6.61591301e-03f,
  -9.11781192e-02f, 1.03713557e-01f, -7.68900961e-02f, -5.83323352e-02f, 3.32612991e-02f, 5.14333136e-03f, 3.77346948e-02f, -1.05250590e-01f, -3.43111344e-02f, -1.44619001e-02f,
  1.38688157e-03f, -1.01667596e-03f, -4.81468253e-02f, 5.90381678e-03f, -1.81420967e-02f, 1.52107880e-01f, -5.54673523e-02f, -5.93397506e-02f, -7.32616112e-02f, 5.69879562e-02f,
  -3.08231801e-01f, -2.76447654e-01f, -3.16477045e-02f, -1.79679826e-01f, 7.26565579e-03f, -4.79818843e-02f, 1.68438554e-01f, -1.59609728e-02f, -9.12587941e-02f, 7.60215288e-03f,
  -1.38239667e-01f, -4.89742961e-03f, 7.71531509e-03f, 9.58959088e-02f, 1.54044375e-01f, 1.54505726e-02f, -5.81081063e-02f, -6.12885468e-02f, -2.91986521e-02f, -5.81492819e-02f,
  -4.15507751e-03f, -2.65432745e-02f, 5.33965342e-02f, 8.89648199e-02f, 1.79218538e-02f, -5.40459342e-02f, -9.41518247e-02f, 7.43168890e-02f, -1.37491885e-03f, -2.73861047e-02f,
  -5.07432878e-01f, -2.60544688e-01f, -3.64827275e-01f, -5.28812349e-01f, 9.59317684e-02f, 3.32518250e-01f, -8.62331167e-02f, 8.18423927e-02f, -5.73394060e-01f, 2.23852739e-01f,
  2.17221707e-01f, -4.10474360e-01f, -1.41452864e-01f, 2.30063006e-01f, -1.07277744e-01f, -5.90407960e-02f, 1.47018567e-01f, -6.68821409e-02f, -1.18174613e-01f, -1.60636976e-01f,
  -1.26146644e-01f, 3.31202030e-01f, 3.34098563e-02f, 2.09341258e-01f, -2.06558287e-01f, -1.46305889e-01f, 1.53035372e-01f, -7.30644912e-02f, 2.70385385e-01f, 7.62774423e-02f,
  1.66891113e-01f, -1.73633022e-03f, -7.59012764e-03f, -5.42883165e-02f, 9.94315415e-05f, 7.99293593e-02f, 6.60416409e-02f, 6.24334253e-02f, -9.30468366e-02f, -4.94451076e-02f,
  -4.99674268e-02f, 5.41679114e-02f, 3.06249992e-03f, -6.48328513e-02f, 1.11803778e-01f, -5.48772514e-02f, -5.86558916e-02f, -3.92131554e-03f, -1.11681670e-01f, -1.11803964e-01f,
  -1.08038627e-01f, -1.79847293e-02f, 2.70693842e-03f, 9.08288434e-02f, -3.85353379e-02f, 2.76410840e-02f, 5.71408384e-02f, -4.33968604e-02f, 4.86736782e-02f, -1.22633064e-02f,
  4.58026491e-02f, -1.71987489e-02f, -6.00610226e-02f, -6.00235835e-02f, -4.20845076e-02f, 2.54787016e-03f, -5.26358224e-02f, 4.20620069e-02f, -8.07747804e-03f, -1.25428941e-02f,
  2.57105380e-02f, 2.14237608e-02f, 1.03531703e-02f, -5.80384880e-02f, -7.00539052e-02f, 3.54948789e-02f, -5.34966551e-02f, -2.22123438e-03f, -1.90229702e-03f, -2.57681095e-04f,
  -4.43360507e-02f, 6.42146021e-02f, -1.00739151e-01f, 6.07890524e-02f, 1.08103417e-02f, -5.79692498e-02f, 1.67480893e-02f, -5.04278801e-02f, -1.13277383e-01f, -6.36337101e-02f,
  4.05881219e-02f, -1.17509551e-01f, -4.89055924e-02f, -2.61487402e-02f, -2.92044487e-02f, 5.27953841e-02f, -3.45685557e-02f, -3.03359162e-02f, -3.39593403e-02f, 1.65525137e-03f,
  5.70383146e-02f, -6.33585155e-02f, 6.67692870e-02f, 5.66320233e-02f, -7.59552792e-03f, 8.87394473e-02f, 8.84283055e-03f, 5.03057241e-02f, 5.68820797e-02f, 3.12044155e-02f,
  3.58486921e-02f, 1.60487425e-02f, 1.91016053e-03f, -9.90380184e-04f, 5.80088608e-02f, -2.16503330e-02f, -8.54485184e-02f, -3.48675181e-03f, 5.49889170e-02f, -4.53642383e-02f,
  5.44393361e-01f, 4.24935043e-01f, 1.44472301e-01f, 1.07871043e-02f, -5.00046425e-02f, 1.48279503e-01f, -4.39707525e-02f, 2.09955901e-01f, -1.22584261e-01f, 3.90241891e-01f,
  -2.07389146e-01f, 4.62014019e-01f, -1.96948439e-01f, 3.35406750e-01f, -5.54628521e-02f, -7.47040361e-02f, 2.02412605e-01f, 2.53940403e-01f, -5.29910140e-02f, 2.66672790e-01f,
  1.96611695e-02f, 2.29945883e-01f, -8.45215768e-02f, 3.83721036e-03f, 1.43522188e-01f, -5.02058305e-02f, 1.95215181e-01f, -1.75327599e-01f, 2.36582026e-01f, -8.95495564e-02f,
  -4.58480837e-03f, -9.44993086e-03f, -7.10261390e-02f, 3.06112971e-02f, 1.44558191e-01f, -6.15072548e-02f, 1.15578704e-01f, -2.07016304e-01f, -1.31584734e-01f, 6.70316741e-02f,
  1.24618880e-01f, -8.67734402e-02f, -7.15640336e-02f, -3.14266421e-02f, 2.74099223e-02f, -9.42615941e-02f, -9.61597562e-02f, 7.44176609e-03f, 8.63751099e-02f, 2.89683901e-02f,
  -3.14111300e-02f, -1.47266146e-02f, 2.56781671e-02f, 3.14077809e-02f, -5.77615798e-02f, -6.60091341e-02f, 4.64760773e-02f, 1.67718176e-02f, 5.41514568e-02f, -1.12016760e-02f,
  -5.12019172e-02f, -8.18573870e-03f, -6.89660152e-03f, -2.42778882e-02f, 6.20814227e-02f, -4.49755462e-03f, -2.43398808e-02f, 1.55963693e-02f, 1.10273641e-02f, 5.10808676e-02f,
  9.11384821e-02f, 2.93601137e-02f, -3.41939437e-03f, -1.30112739e-02f, 8.23999718e-02f, 2.08691731e-02f, 5.18371128e-02f, -5.65120019e-02f, 4.67080660e-02f, -7.39529282e-02f,
  4.63735126e-02f, 4.96393703e-02f, 5.85267544e-02f, -8.82991031e-03f, -6.37090802e-02f, 5.44903986e-02f, 4.52909954e-02f, 7.94373974e-02f, -1.10193498e-01f, 6.79094419e-02f,
  4.02798295e-01f, 4.20145214e-01f, -3.61513421e-02f, -8.87792930e-02f, -3.30661312e-02f, 4.69821803e-02f, -2.54473761e-02f, 7.55047575e-02f, 7.49201402e-02f, 1.70300957e-02f,
  -6.10037856e-02f, -2.87194420e-02f, 9.71016362e-02f, 5.12075908e-02f, 6.06831051e-02f, 3.26532014e-02f, 6.42445832e-02f, 9.07334089e-02f, 6.67062178e-02f, 4.78694541e-03f,
  -7.11654127e-03f, 5.05273864e-02f, -4.02210094e-02f, 3.33306380e-02f, 5.91067076e-02f, 3.56578492e-02f, 1.03193417e-01f, -5.54877333e-02f, -5.97171411e-02f, 8.56649429e-02f,
  -6.24394566e-02f, -7.84497499e-01f, -3.12149435e-01f, -5.28789401e-01f, 3.90857130e-01f, -3.05521935e-01f, -8.59437734e-02f, -2.46146634e-01f, -2.77782917e-01f, -2.01789826e-01f,
  1.66238531e-01f, -3.83822359e-02f, -1.75500810e-02f, -3.46115083e-01f, 2.95239270e-01f, -3.26949418e-01f, -1.28304452e-01f, -1.31601453e-01f, -5.94395623e-02f, -3.64553481e-02f,
  -6.59139454e-02f, 3.58013436e-02f, -8.94389227e-02f, 8.90226755e-03f, -3.19998860e-02f, -1.26059115e-01f, 1.44864559e-01f, 1.10220037e-01f, 1.93682481e-02f, 1.63075700e-01f,
  1.36862993e-01f, -1.21821240e-01f, -7.60901421e-02f, -3.81556265e-02f, 2.86208913e-02f, 1.01450309e-01f, 7.51328543e-02f, 2.04225719e-01f, 7.49132410e-02f, -1.72616038e-02f,
  -4.49561849e-02f, -3.76739427e-02f, 1.18188933e-02f, 5.00157587e-02f, -5.54555357e-02f, -2.35107969e-02f, -2.34762300e-02f, 5.35589084e-02f, -5.16172498e-02f, -1.89174823e-02f,
  6.60583936e-03f, 1.43450694e-02f, -8.12774077e-02f, 3.34209539e-02f, -1.00065432e-02f, -1.42368540e-01f, -4.25727554e-02f, 2.26260368e-02f, -1.04787782e-01f, -5.23825772e-02f,
  -1.00264631e-01f, 5.47419526e-02f, -6.84434175e-02f, 7.71672204e-02f, -3.89127620e-02f, 5.13244644e-02f, 1.02194352e-02f, 8.36488381e-02f, -1.73653457e-02f, -3.01657040e-02f,
  -1.71551313e-02f, -3.68892960e-02f, -4.78436649e-02f, -4.29930128e-02f, -1.56130632e-02f, -9.46544558e-02f, 6.60433695e-02f, -7.55614741e-03f, 1.24673545e-02f, 5.88386357e-02f,
  4.41430742e-03f, -1.88878309e-02f, -3.21828201e-02f, 3.20257545e-02f, -5.35477661e-02f, 1.10251464e-01f, -4.35257182e-02f, -3.34186032e-02f, 3.74330692e-02f, 7.49775693e-02f,
  -2.60511070e-01f, -5.25062442e-01f, -1.81092564e-02f, 4.86255698e-02f, -5.22116721e-02f, -3.41269374e-02f, 8.90089665e-03f, -1.64904609e-01f, -7.84872770e-02f, -3.80317047e-02f,
  2.69519836e-02f, -2.02759877e-02f, -6.87085614e-02f, 8.80141482e-02f, 8.62535927e-03f, -6.41945302e-02f, 3.12018786e-02f, 4.77180118e-03f, -1.81373972e-02f, 1.87640041e-02f,
  -4.48445464e-03f, -3.20385881e-02f, 7.97139779e-02f, -6.17433004e-02f, -5.94384910e-04f, 9.59952548e-02f, -8.89476836e-02f, -1.09233451e-03f, 4.93058637e-02f, -6.21083565e-02f,
  5.29652119e-01f, -1.44230589e-01f, 2.02246368e-01f, 2.56231219e-01f, -1.98863879e-01f, -1.91029981e-01f, 3.85536343e-01f, -3.51844341e-01f, -3.56133282e-02f, 1.56628832e-01f,
  7.24627152e-02f, 4.40871984e-01f, 3.18159685e-02f, 4.29967254e-01f, 3.71757686e-01f, 7.44189993e-02f, 3.87141943e-01f, 3.72981161e-01f, -1.55505568e-01f, 1.12937585e-01f,
  6.30257651e-02f, 4.69603278e-02f, 2.04966426e-01f, -4.83019024e-01f, -7.38743767e-02f, -2.47753888e-01f, -3.54216923e-03f, -2.06943646e-01f, 2.78303698e-02f, -8.95551518e-02f,
  1.12400629e-01f, -7.92882219e-03f, -1.08220456e-02f, -1.29445374e-01f, 2.67023854e-02f, 9.00447369e-02f, 4.62371521e-02f, 2.35764720e-02f, 6.31015077e-02f, -5.35805635e-02f,
  1.05497435e-01f, -3.36582698e-02f, -6.88366368e-02f, -9.94186699e-02f, 6.09907182e-03f, 1.68699492e-02f, 2.51246784e-02f, 5.36075830e-02f, 3.73853557e-02f, 1.23284176e-01f,
  1.13166813e-02f, 3.80442888e-02f, 1.33035108e-01f, 8.11112151e-02f, -5.38236136e-03f, 5.05818278e-02f, 3.02662570e-02f, -2.04728860e-02f, 1.85368536e-03f, 1.69144757e-02f,
  -5.41927060e-03f, -7.53332600e-02f, 9.77910534e-02f, -9.62834358e-02f, -3.72025035e-02f, 2.26030499e-02f, -8.16238485e-03f, 5.27398326e-02f, -8.24765041e-02f, 7.47926906e-02f,
  -5.24996519e-02f, 4.67188209e-02f, -2.92884372e-02f, -1.75410993e-02f, 7.06725121e-02f, 1.29900230e-02f, 6.26946464e-02f, 1.26837678e-02f, -8.33032057e-02f, 4.42826040e-02f,
  1.49192763e-02f, 5.64863719e-03f, -9.80805904e-02f, 3.87177654e-02f, -2.20125951e-02f, 2.56744307e-02f, -5.16811311e-02f, 3.99379842e-02f, 3.45222279e-02f, 5.87989725e-02f,
  -1.26839012e-01f, -1.68218568e-01f, -5.95127828e-02f, -1.13024831e-01f, 4.14832681e-02f, -7.06653446e-02f, 4.11043912e-02f, -1.36954244e-02f, -1.04582481e-01f, -2.77795084e-02f,
  -1.93829369e-02f, 7.10484684e-02f, -1.28710512e-02f, 3.55645902e-02f, -9.47916508e-03f, 3.16075347e-02f, 5.29105850e-02f, -1.11623365e-03f, -7.54771382e-02f, -1.13649704e-01f,
  1.78877823e-02f, -2.05938574e-02f, 5.49104856e-03f, -1.88159384e-02f, 5.04523702e-02f, 5.96602559e-02f, -2.64233332e-02f, -2.03887168e-02f, -2.03135869e-06f, -2.03143787e-02f,
  8.16829443e-01f, 5.10237142e-02f, 3.74880970e-01f, -2.53032714e-01f, 3.03759396e-01f, 5.49308896e-01f, -1.04258722e-02f, 1.28305808e-01f, 1.27381846e-01f, -3.23514283e-01f,
  -6.85971379e-02f, -1.77932262e-01f, -7.99411759e-02f, -1.47740915e-01f, 1.92442492e-01f, 1.83445290e-02f, -1.16204165e-01f, -1.29120156e-01f, 1.22808032e-01f, 5.00945523e-02f,
  1.05357431e-01f, -2.23195583e-01f, -3.09110861e-02f, 1.06637694e-01f, 1.13795951e-01f, 5.74246645e-02f, -3.12077790e-01f, 1.83989350e-02f, -5.91813587e-02f, 3.35977525e-02f,
  1.41443267e-01f, -4.34712023e-02f, 4.48995754e-02f, -1.10923663e-01f, 3.19701470e-02f, -7.15361610e-02f, -2.40201838e-02f, -7.63913766e-02f, 7.29868785e-02f, 3.81056368e-02f,
  -7.84428194e-02f, 4.09606397e-02f, -1.10906223e-02f, -1.29269557e-02f, 3.71559858e-02f, 2.33066571e-03f, 1.51294112e-01f, 4.11726683e-02f, 5.84115088e-02f, 8.54736194e-02f,
  9.80997309e-02f, 1.51876686e-02f, 4.47881361e-03f, -7.14793429e-02f, 6.49779439e-02f, -1.09170787e-02f, -4.12411941e-03f, 3.60631943e-02f, 2.18942780e-02f, -2.00942364e-02f,
  -1.64593086e-02f, -9.51122046e-02f, 1.01618536e-01f, -3.33999619e-02f, 8.58317092e-02f, -2.83018802e-03f, 2.53590588e-02f, -3.00204754e-02f, 1.09182626e-01f, 3.99906039e-02f,
  4.54054922e-02f, -1.70060769e-02f, -3.12444158e-02f, 3.51440385e-02f, -4.44119647e-02f, -4.60444167e-02f, 6.78972248e-03f, 3.79328430e-02f, -1.88631993e-02f, 9.24790353e-02f,
  -5.78960292e-02f, 3.88422795e-02f, -4.63295653e-02f, -4.73412462e-02f, -2.77939998e-02f, -7.36554991e-03f, -1.18155316e-01f, 8.17823187e-02f, 2.14831941e-02f, 6.44906983e-02f,
  -2.13117927e-01f, -3.17702234e-01f, -1.12264939e-01f, -2.05651149e-02f, -4.43886071e-02f, 9.95684415e-02f, 1.35719748e-02f, 1.33239165e-01f, -6.00391552e-02f, 4.36877199e-02f,
  3.23619284e-02f, 7.43731158e-03f, -3.90427001e-02f, 2.38181427e-02f, -6.27595335e-02f, 8.26982781e-02f, -1.05442859e-01f, -6.11409992e-02f, -1.79158330e-01f, -1.78501792e-02f,
  -2.92144194e-02f, 6.00208566e-02f, -4.60255705e-02f, -5.05465595e-03f, -7.63235912e-02f, 1.67116313e-03f, 2.85477042e-02f, -7.94103816e-02f, 2.38831379e-02f, -5.20686954e-02f,
  9.07980185e-03f, -2.32872367e-01f, 5.24024442e-02f, 3.27159554e-01f, 1.32344663e-01f, -6.20653272e-01f, 4.18132693e-02f, -1.08809099e-01f, 2.52324641e-01f, -3.62963140e-01f,
  -4.14836407e-02f, 6.29970059e-02f, 1.17816389e-01f, -4.41779733e-01f, 2.31608123e-01f, 1.10486917e-01f, -3.71254623e-01f, -2.28638649e-01f, 1.49082184e-01f, -6.13374151e-02f,
  9.99622196e-02f, -2.40306914e-01f, -9.74560808e-03f, -2.46507540e-01f, 5.93563169e-02f, -5.21489196e-02f, 7.42344037e-02f, 1.77643105e-01f, -4.29744095e-01f, -8.66791531e-02f,
  -2.11615369e-01f, 1.44508868e-01f, -9.29477811e-03f, -5.68359159e-02f, 3.10978498e-02f, -9.20158997e-02f, -3.11319400e-02f, 4.16202508e-02f, 7.76669383e-02f, -5.10602780e-02f,
  1.70176048e-02f, -8.43016803e-03f, -3.99039946e-02f, -7.15647498e-03f, 2.49075573e-02f, 4.18736786e-02f, 9.04591754e-02f, -3.22079435e-02f, 3.09511088e-02f, -6.66888654e-02f,
  9.65642780e-02f, -3.42573784e-02f, 9.02738329e-03f, -7.60373175e-02f, 1.31620154e-01f, 5.26109897e-02f, -7.84009974e-03f, -7.00882375e-02f, -1.01389565e-01f, -3.62027064e-02f,
  -6.35125563e-02f, -4.81221005e-02f, 2.45049577e-02f, -6.33826181e-02f, 1.47743272e-02f, 1.49947684e-02f, -4.35240613e-03f, -5.98011389e-02f, 3.98351289e-02f, 1.12480698e-02f,
  6.47021644e-03f, 5.10687307e-02f, 2.78386008e-03f, 2.53738575e-02f, -2.64676251e-02f, 2.77701635e-02f, 8.71430524e-03f, -7.41794258e-02f, -1.23408372e-02f, 1.73977725e-02f,
  1.18400401e-03f, 2.27826219e-02f, -1.33971171e-02f, -7.01311650e-03f, -1.17940700e-03f, 3.09435260e-02f, -2.44651474e-02f, 5.99115901e-03f, 5.28755672e-02f, -1.20599680e-02f,
  6.34229258e-02f, -5.78266457e-02f, 1.12642748e-02f, 5.61999381e-02f, -3.21148485e-02f, -4.00567390e-02f, -1.81990210e-02f, -5.67391999e-02f, -1.89602133e-02f, 6.37772158e-02f,
  -9.30263773e-02f, 3.41917425e-02f, -3.68167050e-02f, -4.05828804e-02f, 1.29463598e-02f, -7.76202902e-02f, -2.57792580e-03f, -1.37609849e-02f, -9.63989366e-03f, 5.13668023e-02f,
  -6.98824674e-02f, 4.36184322e-03f, 2.40008952e-03f, -4.76397434e-03f, -9.61522385e-02f, 9.04953927e-02f, -2.41577327e-02f, 2.43273191e-02f, -3.03144902e-02f, -2.36404571e-03f,
  -7.51801729e-01f, -8.08584318e-02f, 2.66193599e-01f, -2.80931860e-01f, -2.52427518e-01f, 4.42542583e-01f, 1.76319890e-02f, -2.10513368e-01f, -4.92351264e-01f, -6.44125417e-02f,
  -2.37614289e-01f, -1.65138149e-03f, -7.10918531e-02f, 6.57422841e-02f, 3.86093438e-01f, 8.29316154e-02f, -1.12781197e-01f, -5.76121621e-02f, -8.02042782e-02f, -9.22319368e-02f,
  -9.41820890e-02f, -4.91188578e-02f, 3.39957088e-01f, 7.05329031e-02f, -8.10876340e-02f, -1.01409301e-01f, 3.91687676e-02f, 6.57776743e-02f, 2.21766561e-01f, 1.57341927e-01f,
  1.48504851e-02f, -1.21783644e-01f, -5.31299859e-02f, 1.18938312e-01f, -5.04780002e-03f, 3.94924618e-02f, 1.76591019e-03f, 1.18699901e-01f, 1.37326233e-02f, -4.21646386e-02f,
  -4.34306487e-02f, 1.71377640e-02f, -1.29403016e-02f, 1.12111010e-02f, -9.47580561e-02f, -9.43434164e-02f, -5.80104180e-02f, 8.39589536e-03f, -3.95108871e-02f, 1.28176495e-01f,
  4.07388061e-02f, 6.80434406e-02f, -4.27763760e-02f, 3.12135443e-02f, -1.26347870e-01f, -4.24406724e-03f, 4.67181727e-02f, 9.03260633e-02f, 6.39793575e-02f, -3.63051631e-02f,
  3.75625938e-02f, -3.58393639e-02f, 7.27483863e-03f, -3.20929624e-02f, -6.85931146e-02f, -1.73336584e-02f, 2.75293682e-02f, 2.69344095e-02f, -6.56849295e-02f, 4.81846422e-04f,
  -1.21111408e-01f, -3.50127257e-02f, -3.82587053e-02f, -2.64911205e-02f, -6.60099313e-02f, -1.08069517e-01f, -3.55036855e-02f, -2.10417472e-02f, -5.57267256e-02f, -2.11552866e-02f,
  -2.86157019e-02f, 2.47696936e-02f, 8.39279126e-03f, -7.32893646e-02f, -1.39234327e-02f, -4.08605970e-02f, -3.26724090e-02f, -2.19510086e-02f, 4.57116365e-02f, 5.96096739e-02f,
  -2.12558925e-01f, -7.21932948e-02f, 4.77317348e-02f, -9.66888219e-02f, -1.29786006e-03f, 3.35133821e-02f, 5.80717660e-02f, -4.35660817e-02f, -3.28978989e-03f, -7.39000598e-03f,
  3.30304652e-02f, -3.41802016e-02f, 5.79415821e-02f, -4.02049944e-02f, 1.16784319e-01f, 5.99896871e-02f, 5.74291758e-02f, -1.32245362e-01f, -1.94770806e-02f, -3.11306398e-03f,
  -3.63189764e-02f, -5.07664867e-02f, 1.16126455e-01f, -8.38845968e-02f, 4.51627076e-02f, 1.32867154e-02f, -2.10718326e-02f, -4.78622876e-02f, -1.93597563e-02f, 1.25236377e-01f,
  -5.58722854e-01f, 2.88457125e-01f, -8.51429030e-02f, -1.21076263e-01f, -3.00923586e-01f, -4.43143249e-01f, -2.94385791e-01f, 3.64309028e-02f, -1.62982777e-01f, 3.57877910e-01f,
  1.28019929e-01f, -8.07926699e-04f, 3.46814007e-01f, 1.76054925e-01f, -4.94171470e-01f, 1.82898521e-01f, -1.73576817e-01f, -1.55597374e-01f, 1.29881784e-01f, -5.69528788e-02f,
  6.73981085e-02f, 9.56878662e-02f, 9.85062402e-03f, 6.00592904e-02f, -1.91720799e-01f, 3.12370695e-02f, -1.95539035e-02f, -1.29056916e-01f, -3.20891775e-02f, -8.50567594e-02f,
  8.20464455e-03f, 3.24865252e-01f, 9.02885646e-02f, 7.70696774e-02f, -2.42848415e-02f, -1.45255504e-02f, -1.66512821e-02f, -9.81394276e-02f, 3.14818956e-02f, 6.24670535e-02f,
  -4.67584245e-02f, -7.34830946e-02f, 1.35856673e-01f, 2.87320781e-02f, -2.91075781e-02f, 3.94612327e-02f, -1.66595308e-03f, 4.19738330e-02f, 1.17125705e-01f, -6.22593462e-02f,
  4.15230542e-02f, 2.49449760e-02f, -9.50312018e-02f, 6.98765591e-02f, 1.61433090e-02f, 5.48159517e-02f, -2.33379267e-02f, -8.25489163e-02f, -1.68434847e-02f, -1.19153872e-01f,
  -4.79470864e-02f, -8.00466724e-03f, -2.80490555e-02f, 2.61745881e-02f, -4.67807380e-03f, 6.76492304e-02f, 7.46730156e-03f, 6.04030341e-02f, -9.96548031e-03f, -8.06984666e-04f,
  -8.33587274e-02f, 1.88133325e-02f, -8.87273159e-03f, -7.84904957e-02f, -4.99336571e-02f, 4.51984629e-02f, -5.95340990e-02f, 1.19808316e-02f, -1.80892199e-02f, -2.37923618e-02f,
  -7.34242424e-03f, -1.27691001e-01f, 7.12975562e-02f, -1.63560938e-02f, 2.28804518e-02f, -3.84211466e-02f, 4.01673093e-02f, -1.86514184e-02f, 4.36111167e-02f, -1.49530143e-01f,
  -8.86608511e-02f, -5.53531907e-02f, 3.97250168e-02f, 1.90399196e-02f, -3.23516056e-02f, -6.76786602e-02f, 6.43296866e-03f, -2.29342561e-02f, -2.87848059e-03f, -3.82223427e-02f,
  -2.77962815e-02f, 7.09796697e-02f, -1.34526908e-01f, -5.02617694e-02f, -6.81673661e-02f, 1.42183704e-02f, 2.07562726e-02f, -3.86202559e-02f, -1.32610276e-01f, 3.23033482e-02f,
  -8.29139352e-02f, -1.94482747e-02f, 5.28885145e-03f, -2.67144367e-02f, 5.29501326e-02f, -1.62828655e-03f, -1.39564261e-01f, -9.57396533e-03f, -1.74891558e-02f, 5.77205382e-02f,
  3.32845420e-01f, 5.16083054e-02f, 3.21536452e-01f, 4.19680327e-01f, -2.25934163e-01f, 2.18773171e-01f, 3.46194148e-01f, 8.72717425e-02f, 1.06832735e-01f, -9.52326730e-02f,
  1.71854898e-01f, -8.03457201e-02f, -1.20019242e-01f, 3.72669101e-01f, 2.89674878e-01f, -1.14013046e-01f, 5.98599613e-01f, 6.31342083e-02f, -1.61524683e-01f, 1.54521719e-01f,
  5.94663098e-02f, 1.35584161e-01f, 2.38879561e-01f, -1.54546335e-01f, -6.26751408e-02f, -3.68890762e-02f, 1.36190936e-01f, -1.93116054e-01f, 2.87167370e-01f, -4.54144515e-02f,
  -5.75295766e-04f, -1.92618012e-01f, 1.68813914e-02f, -1.61709506e-02f, 1.09874204e-01f, 2.44787261e-02f, -1.11405216e-02f, 2.01198701e-02f, 7.91872200e-03f, 1.07914984e-01f,
  4.94234301e-02f, -3.18550467e-02f, 7.57106096e-02f, -1.35869071e-01f, -9.10137892e-02f, -2.67866440e-03f, -4.90837768e-02f, 8.46943632e-02f, -1.11658573e-01f, -2.60270499e-02f,
  8.60476494e-03f, 6.82283714e-02f, 1.00468256e-01f, 2.73412410e-02f, 5.73221408e-02f, -4.31610309e-02f, 9.16658267e-02f, 3.14650759e-02f, 1.27450377e-01f, -5.34481443e-02f,
  -1.04761953e-02f, -1.65642258e-02f, 3.78762744e-02f, -1.34891376e-01f, -1.73978880e-02f, -1.04301929e-01f, 6.78928792e-02f, -1.36064753e-01f, 3.20932479e-03f, -7.19402730e-02f,
  8.80430043e-02f, 8.05303603e-02f, -2.45346613e-02f, 5.99350147e-02f, 1.87962264e-01f, -5.18531213e-03f, 4.05054055e-02f, -2.94019356e-02f, 2.29426194e-02f, 5.66589423e-02f,
  -6.16464950e-02f, 1.69306304e-02f, 1.37729747e-02f, 2.51391530e-02f, -1.88356061e-02f, 1.78648941e-02f, -1.00447483e-01f, 2.03677341e-02f, 1.13907112e-02f, 1.61292762e-01f,
  2.09033996e-01f, 1.08984374e-01f, -2.04959288e-02f, -3.55200097e-02f, -4.64243889e-02f, -3.15207094e-02f, 7.34610409e-02f, -1.20299114e-02f, -3.33103091e-02f, -9.87821259e-03f,
  5.55573218e-03f, 2.55267788e-02f, -9.89071000e-03f, 3.72494310e-02f, 5.25165461e-02f, -6.57663308e-03f, 8.66234899e-02f, 1.25253126e-02f, 1.53964087e-01f, 2.20985170e-02f,
  6.69830106e-03f, -4.68519777e-02f, -1.07053950e-01f, -3.71662863e-02f, 3.76511067e-02f, 3.97661999e-02f, -3.89564480e-03f, -4.09344845e-02f, 2.45135911e-02f, 2.07049213e-02f,
  -4.04308826e-01f, 2.74684519e-01f, -3.88717443e-01f, -4.52013135e-01f, -2.41082162e-01f, 3.50204438e-01f, 1.65617853e-01f, -1.24000706e-01f, 4.06141542e-02f, 3.98361236e-01f,
  -2.37642378e-01f, 1.60918072e-01f, 9.45388004e-02f, -5.97270653e-02f, -1.16215430e-01f, 6.62160292e-02f, -2.58814603e-01f, 2.00091094e-01f, 1.22420758e-01f, -2.11321831e-01f,
  -1.63298711e-01f, -7.96988234e-02f, -1.80852443e-01f, -2.84331646e-02f, -1.44890144e-01f, -1.10882431e-01f, 2.19640449e-01f, -6.28501996e-02f, -6.48295805e-02f, 3.51739116e-02f,
  4.96075153e-02f, -2.08681464e-01f, -7.96883777e-02f, 1.71317056e-01f, -8.85138810e-02f, 1.25397831e-01f, 8.70541558e-02f, -5.22428378e-02f, -8.07603747e-02f, -1.24018351e-02f,
  3.18021543e-04f, -1.25901997e-01f, -7.47371912e-02f, -1.00482769e-01f, -1.44347046e-02f, 4.51886617e-02f, 2.44518202e-02f, -7.48926178e-02f, -1.63398832e-02f, -7.48064518e-02f,
  -3.93666103e-02f, -1.10231861e-01f, -1.48443626e-02f, -5.24246059e-02f, -1.83240268e-02f, -4.27756049e-02f, -9.66232046e-02f, -3.22451442e-02f, 4.60398868e-02f, 3.71194892e-02f,
  -5.96792251e-02f, 1.36709688e-02f, 5.82534224e-02f, -5.36542088e-02f, 5.81809580e-02f, -6.39114976e-02f, 2.30979715e-02f, 7.92116299e-03f, 4.76552658e-02f, 3.95415537e-02f,
  -1.26292631e-01f, 2.19219979e-02f, -6.88922927e-02f, -5.45196875e-04f, 3.88714597e-02f, 2.31775194e-02f, -6.95403591e-02f, -1.76880334e-03f, -4.77088615e-02f, -4.42679599e-03f,
  -6.91529736e-02f, 1.89661998e-02f, -5.01462966e-02f, -3.65752988e-02f, 3.40785496e-02f, 2.49711424e-02f, -9.31668282e-02f, -2.28800625e-02f, -5.58087835e-03f, 1.65705697e-03f,
  3.81873667e-01f, 2.98830032e-01f, 1.06119119e-01f, -3.00110932e-02f, 2.14770269e-02f, 3.52923921e-03f, -1.14529938e-01f, 3.13525312e-02f, 1.96720913e-01f, 1.70292240e-02f,
  1.06844805e-01f, 2.92548817e-02f, -4.26122509e-02f, -4.17166092e-02f, 7.32840672e-02f, 6.30818680e-02f, -7.18727661e-03f, 4.91461568e-02f, 4.90993187e-02f, 4.32156362e-02f,
  -5.82394041e-02f, 4.09891605e-02f, -2.86171306e-02f, -1.74370571e-03f, 7.38716200e-02f, 1.44295031e-02f, 3.76820639e-02f, -1.72270667e-02f, -6.56337589e-02f, 2.76312158e-02f,
  -2.39429012e-01f, -3.31075877e-01f, -1.65622309e-01f, -1.10681891e-01f, 2.86773920e-01f, 4.23887700e-01f, 1.22544535e-01f, 3.48888859e-02f, -2.40990177e-01f, -9.97031927e-02f,
  2.32875049e-01f, -5.60386479e-02f, -8.70469026e-03f, 1.89720988e-01f, 4.40917730e-01f, 2.36706138e-02f, 1.74681246e-01f, 7.25780725e-02f, -9.73922536e-02f, -6.83527887e-02f,
  5.52277341e-02f, 2.26960003e-01f, 2.16841370e-01f, -9.90939513e-02f, 2.25345865e-01f, -1.86866209e-01f, 1.28713429e-01f, -1.58391371e-01f, 1.18135817e-01f, 6.65454343e-02f,
  -7.16594085e-02f, -2.05957592e-01f, 5.88975959e-02f, -1.44969329e-01f, 9.46509540e-02f, 1.63457859e-02f, 1.19358778e-03f, -5.39917797e-02f, 4.96770665e-02f, 4.32871692e-02f,
  7.98259210e-03f, 2.37147454e-02f, 8.77848174e-03f, 6.24139747e-03f, -5.83066605e-02f, -7.01429546e-02f, 2.06819978e-02f, 7.62716830e-02f, -1.05662711e-01f, 8.56416374e-02f,
  1.71777885e-02f, 1.01314560e-01f, 9.24219117e-02f, 2.34023463e-02f, -2.60965489e-02f, -1.74998958e-02f, -4.89704758e-02f, 5.22320271e-02f, 4.88634221e-02f, -5.55250756e-02f,
  -4.04549669e-03f, -8.18184912e-02f, 1.01969010e-04f, -3.47628444e-02f, 1.51471775e-02f, -2.09368765e-02f, -3.59338783e-02f, -4.42436710e-02f, -2.95121465e-02f, 2.08579898e-02f,
  2.99873967e-02f, -2.72468422e-02f, 2.16922630e-02f, 3.50350514e-02f, 1.51338205e-02f, 2.94010192e-02f, 9.35524423e-03f, 2.80890390e-02f, 1.17720971e-02f, 9.96732414e-02f,
  -8.01390186e-02f, -1.34537322e-02f, 3.62442173e-02f, -3.45651829e-03f, 1.04584293e-02f, -1.36524048e-02f, -2.14854944e-02f, -7.99028650e-02f, -1.65606961e-02f, 2.50689182e-02f,
  -1.95741802e-01f, -1.93293616e-01f, -2.57829838e-02f, -1.34134414e-02f, -1.07259639e-01f, 1.11871734e-01f, -1.41686630e-02f, 5.45092821e-02f, -1.26900688e-01f, -2.83386875e-02f,
  1.19582517e-02f, -1.13907475e-02f, 1.86911393e-02f, 9.17355493e-02f, 3.92948613e-02f, 3.81873585e-02f, -7.22652301e-02f, -1.74181424e-02f, 1.35119542e-01f, 7.31862942e-03f,
  -5.79527020e-03f, 1.41332680e-02f, 1.29561787e-02f, -5.59018254e-02f, 9.06363651e-02f, 5.37123382e-02f, -2.10778881e-03f, -5.16600944e-02f, -7.67609396e-04f, -3.12585235e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.56737256e+00f, 5.77986181e-01f, 1.40188307e-01f, -8.13845754e-01f, -3.92407358e-01f, -8.73992741e-02f, -1.59042090e-01f, 2.82007247e-01f, 3.46271098e-01f, 5.66346586e-01f,
  -2.06615686e-01f, 5.12179285e-02f, 6.82794988e-01f, 1.16510494e-02f, -1.66659921e-01f, 8.07240963e-01f, -3.50300163e-01f, -6.84783608e-02f, 2.39795208e-01f, -1.70056373e-01f,
  -2.63708651e-01f, -2.24036887e-01f, -1.90445617e-01f, 1.66679531e-01f, -8.37147057e-01f, -3.73801678e-01f, -4.81929302e-01f, -2.28024386e-02f, -6.44593716e-01f, -1.12499177e-01f,
  -9.49953616e-01f, -1.03915818e-01f, -5.23016214e-01f, -2.21748427e-01f, -3.67522001e-01f, -2.62591600e-01f, -2.51515359e-01f, 1.02680782e-03f, -1.00762285e-01f, 6.03208765e-02f,
  1.50411010e-01f, -2.03607231e-02f, -4.27964553e-02f, 3.07542711e-01f, -1.30599188e-02f, 9.70393978e-03f, -7.80867860e-02f, -2.68497616e-01f, 3.75370532e-02f, 5.76927438e-02f,
  2.82301396e-01f, -4.40708473e-02f, -2.49607220e-01f, -2.77346484e-02f, -2.52743363e-01f, -7.45227337e-02f, 1.81852922e-01f, -1.75249338e-01f, -1.29636914e-01f, -1.69211984e-01f,
  2.60196149e-01f, -2.91042682e-02f, -1.16861358e-01f, -7.55758733e-02f, 3.37027490e-01f, -5.49772345e-02f, 2.76840422e-02f, -6.41320348e-02f, -5.21631949e-02f, -1.30542427e-01f,
  -9.91075635e-02f, -1.31024182e-01f, -5.89377806e-02f, -5.57932742e-02f, 6.92750216e-02f, 1.46515446e-03f, -5.55535126e-03f, -1.16743132e-01f, 7.82844499e-02f, -2.40708336e-01f,
  1.85796386e-03f, 7.19759846e-03f, -2.09420491e-02f, -9.80261266e-02f, -9.61253606e-03f, 5.67815490e-02f, -7.38599598e-02f, 1.36333751e-02f, -3.50846164e-02f, -3.37814279e-02f,
  -9.99082386e-01f, -5.65785646e-01f, -9.36240032e-02f, -1.98194906e-01f, -2.95952205e-02f, -2.85741817e-02f, 1.57445461e-01f, -1.26213506e-01f, -3.03672943e-02f, -4.07631099e-02f,
  -1.69031411e-01f, -1.20591044e-01f, -1.75946906e-01f, 1.72703788e-02f, 2.32765287e-01f, -3.76665220e-02f, -7.09198266e-02f, 3.04082576e-02f, -3.21465969e-01f, -1.10093780e-01f,
  -9.71532911e-02f, 1.03353828e-01f, 1.91154838e-01f, -6.71688840e-02f, -1.10365480e-01f, -2.51973838e-01f, 9.83475000e-02f, -1.86966988e-03f, -2.53355592e-01f, 2.03988716e-01f,
  -1.47175443e+00f, 9.25960898e-01f, -4.81808066e-01f, -3.94654572e-01f, 1.68559805e-01f, 2.13691480e-02f, 1.19016431e-01f, 1.25600502e-01f, -3.37270796e-01f, 8.13925922e-01f,
  6.29344046e-01f, -5.22650599e-01f, 6.71816111e-01f, 6.70226574e-01f, -5.50461531e-01f, 4.55972046e-01f, 4.32244353e-02f, 8.31243694e-02f, -1.32984489e-01f, -1.42655224e-01f,
  -3.95884037e-01f, 6.66778564e-01f, 1.12108491e-01f, 3.69636148e-01f, 2.11424261e-01f, -3.75560254e-01f, 5.55613577e-01f, -2.54810993e-02f, 2.12936044e-01f, 1.79209605e-01f,
  -5.88139482e-02f, -3.19329798e-01f, -3.68438214e-02f, -2.80144244e-01f, -1.34434151e-02f, -3.37136090e-02f, -1.81541085e-01f, -3.20286416e-02f, -1.64690271e-01f, -1.81864485e-01f,
  3.86401676e-02f, -8.11356381e-02f, -1.50593236e-01f, 4.24046367e-02f, -9.73452032e-02f, -8.60671178e-02f, 2.96975851e-01f, 3.85280214e-02f, 5.99735305e-02f, 9.96269062e-02f,
  1.50951862e-01f, -1.09742023e-01f, -5.59558459e-02f, 3.02287340e-02f, 3.57499137e-03f, 3.56085761e-03f, -1.32339627e-01f, 5.75213209e-02f, -1.78892791e-01f, -2.16776699e-01f,
  -1.37556627e-01f, -1.76647246e-01f, 2.47047365e-01f, 9.43257436e-02f, -2.02024300e-02f, 2.25805655e-01f, -3.64436470e-02f, 7.45574981e-02f, -2.35762432e-01f, 2.59173848e-02f,
  -1.05303250e-01f, -1.76628791e-02f, -6.07192852e-02f, -1.70370042e-01f, 4.99320440e-02f, -5.36688976e-02f, -1.32992849e-01f, -1.02205696e-02f, -7.55021572e-02f, 2.58852430e-02f,
  2.00080834e-02f, -3.12584899e-02f, 1.78567857e-01f, -1.33854188e-02f, -1.29688412e-01f, -1.05934106e-01f, 1.24701232e-01f, 8.05880874e-02f, 9.14421901e-02f, -4.85443622e-02f,
  -9.51605067e-02f, -4.39600080e-01f, 1.43144146e-01f, 4.63231206e-02f, 5.84003255e-02f, -4.89145285e-03f, -8.22315216e-02f, 3.38257737e-02f, -1.06354117e-01f, -5.79446219e-02f,
  -1.99149176e-01f, 7.02321604e-02f, -1.74218744e-01f, -1.74870491e-01f, -1.48495510e-01f, 2.00992018e-01f, -6.27073944e-02f, -1.74246624e-01f, -4.49671596e-02f, -1.00353837e-01f,
  -5.30161895e-02f, -1.34731119e-03f, -5.84843755e-02f, 7.01133832e-02f, -2.04582959e-01f, 1.16521902e-01f, -9.15938467e-02f, -1.36755139e-01f, 2.69166790e-02f, 1.05642691e-01f,
  1.77143723e-01f, 3.84228647e-01f, -2.96470135e-01f, 6.79189190e-02f, -2.61408627e-01f, 1.20289147e+00f, 1.31090295e+00f, -3.22146654e-01f, 3.21739882e-01f, 6.23373508e-01f,
  5.49371183e-01f, 2.83820242e-01f, 7.83283591e-01f, 5.77183425e-01f, 5.14087260e-01f, 7.63062716e-01f, 6.88889980e-01f, 6.29664600e-01f, -6.00131415e-02f, 1.21275559e-01f,
  3.27840708e-02f, 5.48248112e-01f, -1.93064213e-01f, -4.69100505e-01f, 1.39134258e-01f, -6.97680652e-01f, -5.84309936e-01f, -3.08506370e-01f, -4.14212167e-01f, 1.33435041e-01f,
  1.89790994e-01f, 9.77074578e-02f, -1.08238235e-01f, 4.76790965e-02f, -1.04423173e-01f, -1.16195753e-01f, 6.83539500e-03f, 8.15630779e-02f, -9.62719023e-02f, -1.77239496e-02f,
  3.16015370e-02f, -1.04579598e-01f, 2.00688064e-01f, -1.14035189e-01f, -1.41325504e-01f, -1.46882281e-01f, -1.79573894e-01f, -1.49616569e-01f, -8.03179517e-02f, 3.46116498e-02f,
  -1.80087909e-02f, -1.39725551e-01f, 7.11886361e-02f, -3.30939330e-02f, -9.11419690e-02f, 4.81952950e-02f, 9.78621468e-02f, 1.54356323e-02f, 3.30433846e-02f, -5.46323173e-02f,
  -1.06170751e-01f, 1.28754750e-01f, 1.64088115e-01f, -2.41798721e-02f, -4.69511822e-02f, -8.25977921e-02f, 1.56874694e-02f, 1.04850596e-02f, -5.25571145e-02f, 2.09018424e-01f,
  -7.60568529e-02f, -1.64601207e-02f, 4.16690893e-02f, 6.05268106e-02f, 2.02333126e-02f, -1.14840105e-01f, -2.65182722e-02f, 2.77285688e-02f, -1.15576647e-02f, -6.46876916e-02f,
  1.09382264e-01f, 8.99550170e-02f, -1.78459883e-02f, -1.63024440e-01f, 9.47379246e-02f, -1.22982547e-01f, 1.24531955e-01f, -1.46340793e-02f, 4.82678451e-02f, -1.41546829e-02f,
  2.19291776e-01f, 2.56184340e-01f, 1.01886109e-01f, 1.85517207e-01f, -1.32518172e-01f, -1.39629140e-01f, 1.42079651e-01f, 1.40679076e-01f, 4.74852808e-02f, 1.08235858e-01f,
  -1.42312512e-01f, -6.08965419e-02f, 2.20037147e-01f, -1.04184091e-01f, -1.11469850e-02f, 2.60782480e-01f, 1.56506956e-01f, -1.11753970e-01f, -5.87966181e-02f, -1.25608206e-01f,
  -1.09534308e-01f, 1.57022372e-01f, 1.45851851e-01f, -4.81458679e-02f, -4.99121733e-02f, 9.54829305e-02f, -1.58539355e-01f, -1.06201380e-01f, 1.90163907e-02f, 9.96739343e-02f,
  7.66169071e-01f, -2.68148988e-01f, -5.63971817e-01f, -8.29188764e-01f, -2.39386186e-01f, -5.60765862e-01f, -2.51748025e-01f, -6.99581623e-01f, -6.14761770e-01f, -2.88895935e-01f,
  -2.01366201e-01f, 9.20231044e-02f, 7.43340433e-01f, -4.41323966e-01f, 9.32185948e-01f, 5.50561011e-01f, -3.94903004e-01f, -2.41206944e-01f, -1.22997575e-01f, -2.80809879e-01f,
  1.07663363e-01f, -2.36389026e-01f, -2.16879323e-03f, -3.09617519e-01f, -3.05173099e-01f, -2.23007232e-01f, 2.99210966e-01f, -1.27947956e-01f, -5.95496356e-01f, 4.40496579e-03f,
  -9.19507742e-02f, -1.23695500e-01f, -2.87425399e-01f, -1.35241359e-01f, -2.78536119e-02f, 1.63235754e-01f, 6.59316331e-02f, 9.90768224e-02f, -7.29143992e-02f, -4.87334020e-02f,
  2.07332775e-01f, 2.47822374e-01f, -2.89480001e-01f, 1.00410223e-01f, 3.88848856e-02f, -1.74212292e-01f, -1.33267060e-01f, -1.37367338e-01f, -7.70586580e-02f, 1.65441051e-01f,
  -1.82509832e-02f, -8.34537819e-02f, -2.61862576e-01f, -1.46308258e-01f, -1.54224977e-01f, -1.78626046e-01f, 2.41215140e-01f, 2.39412010e-01f, -2.61583347e-02f, 7.19773769e-02f,
  1.25503227e-01f, 1.96538731e-01f, 6.26610890e-02f, -1.47489890e-01f, 5.44107631e-02f, -3.92071030e-04f, 7.65556097e-03f, 7.07469881e-02f, -1.09057501e-01f, -5.01643941e-02f,
  -1.97118819e-01f, -1.98821545e-01f, -1.48387864e-01f, -3.80892120e-02f, 8.99965465e-02f, 2.89767206e-01f, 1.97897583e-01f, 2.98416484e-02f, -2.53809601e-01f, -2.02129856e-01f,
  -5.75665012e-02f, 1.33292452e-01f, -1.15363054e-01f, 5.90597540e-02f, 1.87938884e-02f, -9.05835629e-02f, -1.56158969e-01f, 1.86369389e-01f, -1.77232593e-01f, 1.02004685e-01f,
  -8.25789198e-02f, -7.49399140e-02f, -2.00542852e-01f, -1.72788724e-01f, -1.91483088e-02f, -2.52974816e-02f, -1.55955657e-01f, -2.63242513e-01f, -1.16983660e-01f, -2.16462296e-02f,
  3.49901468e-02f, 3.48079503e-02f, -6.15822338e-02f, -1.50163546e-01f, -2.29676105e-02f, -2.21157372e-01f, 1.47175953e-01f, -9.52882543e-02f, -7.52317160e-02f, 5.34453019e-02f,
  -6.84457123e-02f, 2.45014906e-01f, 1.76700205e-01f, -2.05797076e-01f, -1.54967934e-01f, 3.20624709e-02f, 9.33412537e-02f, 1.22775128e-02f, 1.51706830e-01f, -2.94067502e-01f,
  -5.38020730e-01f, 1.67610586e-01f, 2.24314272e-01f, -4.54032086e-02f, -3.71066630e-01f, -5.66589952e-01f, -1.02545702e+00f, 1.74001798e-01f, -4.85404432e-01f, -4.66962278e-01f,
  -1.73398018e-01f, -2.21154571e-01f, -6.33674935e-02f, 3.68608534e-01f, 7.06918478e-01f, 3.99952680e-01f, 6.53595686e-01f, 7.92390481e-03f, 4.51963484e-01f, 5.65536797e-01f,
  6.08495176e-01f, 4.47288275e-01f, 7.95441687e-01f, 6.33947611e-01f, 1.13191098e-01f, 3.83434594e-01f, 6.62592471e-01f, -1.96037777e-02f, 4.29314047e-01f, 2.56974716e-02f,
  7.40330061e-03f, 3.94160338e-02f, 1.84734408e-02f, -4.33188379e-02f, 2.48496607e-01f, -2.36359254e-01f, -3.59161310e-02f, -1.62935197e-01f, -1.68126542e-03f, 3.37659568e-02f,
  -2.34938100e-01f, 8.80034789e-02f, 8.93506557e-02f, -6.28928170e-02f, -4.45060492e-01f, 3.46570313e-02f, 1.49006128e-01f, 5.16762845e-02f, 4.37960625e-02f, 1.03062570e-01f,
  5.18682972e-02f, -4.99272048e-02f, -5.91378696e-02f, 4.08814140e-02f, 4.53912579e-02f, -2.93081492e-01f, -1.77329481e-01f, 3.80808301e-02f, -4.34328094e-02f, -2.39000395e-02f,
  4.80546393e-02f, -8.51652771e-02f, -1.09249577e-01f, 9.51481089e-02f, -5.42544499e-02f, 6.71126842e-02f, 8.96396562e-02f, 2.02829298e-02f, 2.00809492e-03f, -3.24245505e-02f,
  -6.56480864e-02f, 3.86983715e-02f, -1.30911380e-01f, -1.66672975e-01f, 3.86498980e-02f, 4.02976796e-02f, 3.47912908e-02f, 2.13655606e-02f, -2.19178312e-02f, 1.83049649e-01f,
  -4.50175069e-03f, 1.63126998e-02f, 4.54988070e-02f, 3.86798158e-02f, 2.17253342e-02f, -5.99874184e-02f, 1.84147686e-01f, -1.70021039e-02f, 9.49185640e-02f, 8.04029480e-02f,
  2.91906923e-01f, 4.95387107e-01f, -5.70061579e-02f, -1.64702550e-01f, 6.07671440e-02f, -5.71500771e-02f, 7.51501247e-02f, 1.44295856e-01f, 7.29777887e-02f, 1.57582425e-02f,
  -7.18899071e-02f, -1.10386133e-01f, -9.88547727e-02f, -8.26703012e-02f, 2.29810953e-01f, 1.09293006e-01f, -3.16235349e-02f, -9.84366089e-02f, -1.76755488e-02f, 4.24986333e-01f,
  2.37524733e-02f, -2.10382819e-01f, 9.29722041e-02f, -1.04058698e-01f, -1.93844572e-01f, -3.68218534e-02f, -1.27708213e-02f, -7.75415525e-02f, 1.71468675e-01f, 2.99909506e-02f,
  2.06206888e-01f, 9.86100972e-01f, 6.17735445e-01f, -1.98226303e-01f, -5.57066202e-01f, -2.95524508e-01f, -4.97622401e-01f, -1.67107031e-01f, -5.23962416e-02f, 1.30414262e-01f,
  -4.39862639e-01f, 1.07454252e+00f, -7.36313164e-02f, -3.09889436e-01f, -8.06724310e-01f, -5.79179227e-01f, -6.18804216e-01f, -1.28476024e-01f, -1.79072991e-01f, -3.38509440e-01f,
  -4.29150939e-01f, -9.87338960e-01f, -2.53014952e-01f, -5.12904644e-01f, -2.28098221e-02f, 2.59417206e-01f, -6.89434528e-01f, -7.00256228e-02f, 1.80460438e-01f, 2.17661913e-02f,
  -7.09179640e-02f, -1.67866126e-01f, 2.49744743e-01f, 1.69571683e-01f, -2.51200676e-01f, 1.87511165e-02f, 1.62910178e-01f, 1.52367190e-01f, -1.58933520e-01f, 1.59288689e-01f,
  1.35113001e-01f, -3.34802717e-02f, 8.76745284e-02f, -7.72197470e-02f, 7.52457604e-02f, 2.22371727e-01f, 2.80787408e-01f, 2.66440921e-02f, 2.26716340e-01f, 2.14361742e-01f,
  2.54060298e-01f, 3.90853584e-01f, 2.43831007e-03f, 6.10133167e-03f, 3.86437550e-02f, 1.75772488e-01f, 2.13113204e-02f, 2.45951325e-01f, 1.86942518e-01f, -5.65866847e-03f,
  -1.17845349e-02f, -6.74382523e-02f, -1.44854367e-01f, 1.27740875e-01f, -1.17669553e-01f, -8.47819522e-02f, -8.06852728e-02f, 1.31358720e-05f, -5.10519296e-02f, 3.71493250e-02f,
  -1.47016961e-02f, 2.54268050e-01f, -2.35672906e-01f, -8.84958357e-02f, 3.65010612e-02f, -1.12595195e-02f, -4.72527966e-02f, 1.15791142e-01f, -9.48974639e-02f, 9.83318165e-02f,
  -5.83140515e-02f, -1.63611010e-01f, -9.18656290e-02f, -2.30664268e-01f, -2.03527898e-01f, 1.19473100e-01f, -2.59870905e-02f, 2.91694373e-01f, -6.46567121e-02f, -8.17328393e-02f,
  -6.08448386e-01f, -5.75767875e-01f, 4.83658724e-02f, 2.47692510e-01f, 1.07785240e-02f, 2.09910348e-02f, -4.23264839e-02f, 9.75400507e-02f, -4.10999656e-02f, -1.53628439e-01f,
  -1.28667772e-01f, -2.84020081e-02f, 5.59923388e-02f, 8.69154744e-03f, -1.06357887e-01f, -9.18147415e-02f, -2.96104193e-01f, -5.04452512e-02f, -8.46993029e-02f, 1.53905405e-02f,
  6.20079553e-03f, 3.60264303e-03f, -9.75126401e-03f, -1.32070616e-01f, -5.47733791e-02f, -6.67765597e-03f, -1.67239696e-01f, 2.40602508e-01f, 1.07696451e-01f, -1.02430745e-03f,
  -3.36008340e-01f, 9.07818079e-02f, -8.01634133e-01f, -2.64901400e-01f, 5.04630089e-01f, -4.77935016e-01f, -7.36444950e-01f, 3.30458879e-01f, -6.31287873e-01f, 4.72303450e-01f,
  6.01952553e-01f, -3.76359969e-01f, -1.60906181e-01f, -1.40851215e-01f, -6.77685082e-01f, -8.78069222e-01f, -1.18944317e-01f, -2.89319783e-01f, -4.17465746e-01f, 3.15532953e-01f,
  -3.69937003e-01f, 7.31048882e-01f, -5.19177794e-01f, 6.80451035e-01f, 4.07970250e-01f, 2.64225364e-01f, 8.48100960e-01f, 2.17915460e-01f, 5.98706424e-01f, 2.08031461e-01f,
  -3.04049641e-01f, -8.23058859e-02f, -1.56093329e-01f, -2.32080296e-01f, 9.17444080e-02f, 1.52153477e-01f, -8.38071480e-02f, -7.54684061e-02f, -1.43815339e-01f, -6.69924915e-02f,
  -3.19192739e-04f, 7.56526440e-02f, 5.07316329e-02f, -3.67054380e-02f, -9.59246382e-02f, -9.25187115e-03f, -2.15291411e-01f, -1.22104906e-01f, -2.03217208e-01f, -2.10512638e-01f,
  -3.01923484e-01f, -3.56767215e-02f, 8.16366971e-02f, -2.91909743e-02f, -1.99128613e-01f, -3.76655231e-03f, -5.82468398e-02f, 8.39659572e-02f, 1.37588814e-01f, -3.86625342e-02f,
  2.19717890e-01f, 3.97923253e-02f, -1.00585222e-01f, -1.01017304e-01f, -6.82477951e-02f, -9.43445414e-02f, -9.88139808e-02f, -3.79800126e-02f, -2.84095239e-02f, 3.75659838e-02f,
  1.09362505e-01f, -4.92636859e-02f, 1.53218089e-02f, 7.01102614e-02f, 4.00331430e-02f, -8.66969600e-02f, 6.95057446e-03f, 5.08307591e-02f, -1.88654318e-01f, -2.35590473e-01f,
  5.95626570e-02f, -4.16304991e-02f, -1.51831985e-01f, 5.02116643e-02f, -1.38502672e-01f, 1.37980834e-01f, 1.39531255e-01f, -6.41842932e-02f, -2.38023661e-02f, 1.38805792e-01f,
  1.01881303e-01f, 5.58403313e-01f, -1.10635683e-01f, 1.96349099e-02f, -5.26471846e-02f, 7.73329660e-02f, 1.61760990e-02f, 1.28883928e-01f, 1.63095564e-01f, -5.22107445e-02f,
  2.83624589e-01f, 4.31546867e-02f, 2.84353048e-01f, -8.72007087e-02f, 1.05722316e-01f, 1.97468162e-01f, 1.50240764e-01f, 1.05661176e-01f, 2.17076749e-01f, 1.86531350e-01f,
  4.93355095e-01f, 7.40266964e-02f, -5.14423661e-02f, 9.83257499e-03f, 2.02074513e-01f, 1.15384094e-01f, 2.51299769e-01f, 6.46388903e-02f, 4.67002541e-02f, 6.94832653e-02f,
  1.31068599e+00f, -8.40586126e-02f, -4.19549704e-01f, 6.47715271e-01f, 5.66463113e-01f, 1.92595750e-01f, -1.38836786e-01f, 5.95398068e-01f, 7.75821745e-01f, -1.87807754e-01f,
  8.22788775e-02f, -8.21609274e-02f, -1.01138258e+00f, 7.82120466e-01f, 2.94002354e-01f, -6.64843678e-01f, 7.27340579e-01f, 2.33229220e-01f, 2.03599229e-01f, 5.35211682e-01f,
  3.94419849e-01f, 8.07674825e-01f, -2.28528291e-01f, 4.04632360e-01f, 4.69503403e-01f, 3.07714986e-03f, -4.70602453e-01f, -7.80782521e-01f, 2.29424089e-01f, -1.29060820e-01f,
  1.12571992e-01f, 2.16723204e-01f, 1.89993635e-01f, -1.03975445e-01f, -3.10306605e-02f, -3.83251235e-02f, -2.21078619e-01f, -3.53924811e-01f, 2.93436330e-02f, -6.98886812e-02f,
  -1.37308761e-01f, 6.36253580e-02f, 2.68607229e-01f, -1.45467296e-01f, 3.52204233e-01f, 1.60897508e-01f, 1.01286054e-01f, 1.25965372e-01f, -4.43277769e-02f, 6.65745810e-02f,
  3.54134440e-02f, -8.64905715e-02f, 1.59912452e-01f, -2.74943292e-01f, -1.26444593e-01f, 1.35979638e-01f, -1.53577462e-01f, -1.70156032e-01f, 3.37645523e-02f, 2.89246589e-01f,
  2.75538303e-02f, -1.40275702e-01f, 6.40613260e-03f, -1.60900019e-02f, 1.47388145e-01f, 1.01116829e-01f, 8.18112269e-02f, -1.06284879e-01f, -1.92631204e-02f, -2.66868100e-02f,
  -3.81297469e-02f, 1.03152722e-01f, 4.57439832e-02f, 4.83992836e-03f, 1.70532465e-01f, 2.02128813e-01f, -2.54321486e-01f, -8.63296241e-02f, 6.10423088e-02f, -5.98495863e-02f,
  -1.49752587e-01f, 1.39815331e-01f, -1.27587914e-01f, -4.75614592e-02f, 6.34119809e-02f, -1.10281795e-01f, 9.88870412e-02f, 5.68874553e-02f, 2.95711197e-02f, -1.67045876e-01f,
  -3.75080295e-02f, -4.35035884e-01f, -4.77493033e-02f, -9.92016420e-02f, -1.25331715e-01f, 9.49083790e-02f, 1.37255725e-03f, 2.46621728e-01f, -1.10419273e-01f, 4.76627089e-02f,
  5.35607934e-02f, 1.58977397e-02f, 3.75281856e-03f, 2.79671531e-02f, -8.91131014e-02f, 4.18709703e-02f, -1.98290065e-01f, -6.43451437e-02f, 2.04938073e-02f, -1.12122543e-01f,
  -9.58738178e-02f, -6.17909469e-02f, 1.42359361e-01f, 2.53809541e-01f, 4.66693155e-02f, -1.57471791e-01f, 1.14570476e-01f, -4.81210575e-02f, -1.98025912e-01f, -9.21985731e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  7.88427055e-01f, 5.85868359e-01f, 9.20881987e-01f, 3.13356370e-01f, 4.25054878e-01f, 1.00996172e+00f, 1.21371448e+00f, 8.96940053e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -3.18669289e-01f, -4.77927417e-01f, 3.58111590e-01f, 2.61248238e-02f, -5.60778081e-01f, -9.88914728e-01f, -6.66285574e-01f, -3.47190768e-01f, -5.85886121e-01f, -3.79342526e-01f,
  -4.26702678e-01f, -9.51872021e-02f, -6.52143359e-02f, 6.84683025e-01f, -1.19589947e-01f, -7.08136141e-01f, 5.75632930e-01f, -1.21634352e+00f, -5.58142304e-01f, 8.44216347e-01f,
  9.77334023e-01f, 4.54809576e-01f, 1.14083830e-02f, 4.50639218e-01f, 2.68093765e-01f, 8.30952644e-01f, 5.31454086e-01f, -5.82627892e-01f, -2.31466871e-02f, -9.66138422e-01f,
  -9.25836980e-01f, -1.03656840e+00f, 1.87658504e-01f, -3.78472328e-01f, -7.42546618e-01f, 6.41006470e-01f, 3.12062413e-01f, -9.34163257e-02f, -8.80758524e-01f, -3.28182220e-01f,
  4.68047768e-01f, -8.40765890e-03f, 3.57817203e-01f, -1.12836826e+00f, -1.08636379e+00f, 1.20732975e+00f, 8.32284987e-01f, -4.47651476e-01f, 8.23711157e-01f, -1.26061570e-02f,
  -8.18260014e-01f, -7.09949672e-01f, -2.53620863e-01f, -2.34428167e-01f, 8.20031345e-01f, 4.81307179e-01f, -1.62558079e+00f, 3.62980008e-01f, 5.68805099e-01f, 6.79681182e-01f,
  -4.58909631e-01f, -1.23640573e+00f, 1.78137481e-01f, 4.78705525e-01f, -6.32467747e-01f, -5.83293259e-01f, 4.43453193e-01f, -2.82567322e-01f, -1.74454153e-01f, 7.28551745e-01f,
  5.55393659e-02f, 8.52854177e-02f, -4.80525672e-01f, -1.99904099e-01f, -5.06542265e-01f, -1.01328206e+00f, 8.83768857e-01f, 1.07173407e+00f, 3.55610669e-01f, 1.19641721e+00f,
  -3.23472351e-01f, -2.84044743e-01f, -9.64767694e-01f, 1.12806189e+00f, -7.77789891e-01f, 3.85202169e-01f, -7.93155789e-01f, 5.13348401e-01f, -7.80660331e-01f, -8.63021731e-01f,
  -9.50224519e-01f, -5.62550664e-01f, 1.26998022e-01f, -9.92203116e-01f, 4.05673832e-01f, 7.51233160e-01f, -5.56787610e-01f, 5.48265874e-01f, -3.33360255e-01f, 8.86620730e-02f,
  -3.46860796e-01f, -1.28658310e-01f, -3.22218686e-01f, 1.65835470e-02f, -1.57096410e+00f, -1.35607159e+00f, -5.28506517e-01f, -9.41273868e-01f, -3.11943382e-01f, 1.19486280e-01f,
  -6.91163123e-01f, 3.59231561e-01f, -1.94780156e-01f, -4.93109375e-01f, 8.56863141e-01f, -6.96659267e-01f, 4.77180123e-01f, -2.74151489e-02f, -3.62471282e-01f, -2.16814324e-01f,
  5.71698427e-01f, 7.35429585e-01f, -1.24506640e+00f, -6.60257041e-01f, -8.43326211e-01f, 1.57227129e-01f, 4.23274249e-01f, -7.13724315e-01f, 1.97938666e-01f, 4.90484208e-01f,
  -1.13830373e-01f, 4.94989306e-01f, 2.56526172e-01f, -1.36658952e-01f, 5.20182490e-01f, -7.08856225e-01f, 1.12837434e+00f, 8.75024855e-01f, 4.25913572e-01f, 4.86273408e-01f,
  8.04839432e-01f, 6.89766705e-01f, -1.06488597e+00f, -2.05634952e-01f, -1.49463832e+00f, 1.05686414e+00f, -1.68703794e-01f, 1.15390491e+00f, 5.73203444e-01f, -1.30017555e+00f,
  -1.71429768e-01f, 1.28569454e-01f, 6.58835173e-01f, 2.72833616e-01f, -5.67115843e-01f, -4.26554710e-01f, 7.03285694e-01f, 3.61433566e-01f, -1.37504828e+00f, -1.04288924e+00f,
  7.04759300e-01f, 5.03662646e-01f, 1.90931603e-01f, -1.20637953e+00f, 7.59648681e-01f, 9.28504646e-01f, 8.09120893e-01f, 2.97532290e-01f, 1.45124033e-01f, -6.62138537e-02f,
  4.83202815e-01f, 1.12466824e+00f, -6.76160455e-01f, -1.34843695e+00f, 9.09433544e-01f, -9.98027325e-01f, 4.18249011e-01f, -5.12368619e-01f, -1.38682246e-01f, -3.99812073e-01f,
  -5.96903503e-01f, 6.71250403e-01f, 1.11515260e+00f, -6.67696178e-01f, 5.17730474e-01f, -1.51057601e+00f, 7.84644365e-01f, -1.97702199e-01f, -6.13984108e-01f, -5.78670979e-01f,
  -1.15442610e+00f, -1.46231521e-02f, 5.26852846e-01f, -3.20064157e-01f, 2.90585458e-01f, 1.14610827e+00f, 1.57213435e-01f, -9.58367050e-01f, -1.63621113e-01f, 1.63445920e-01f,
  -9.61795002e-02f, 2.77056396e-01f, -7.73418546e-01f, 3.22704166e-01f, 9.98518646e-01f, -7.82977402e-01f, -7.22981811e-01f, 1.67158663e-01f, -5.02889395e-01f, 5.27793884e-01f,
  1.22359955e+00f, -1.50742149e+00f, -4.26305413e-01f, 3.28835160e-01f, -7.30924010e-01f, 1.61271870e-01f, -4.07550216e-01f, -8.52990508e-01f, -1.79224592e-02f, -5.96823812e-01f,
  -1.15717971e+00f, -6.93945765e-01f, -8.97103190e-01f, 1.21096241e+00f, 9.70331579e-02f, -3.62188220e-01f, -5.62348366e-01f, -4.04168814e-01f, 2.23642126e-01f, -1.49765924e-01f,
  -8.55234981e-01f, 5.05750105e-02f, -1.58619165e-01f, -9.81217027e-01f, -2.42307022e-01f, -2.60107905e-01f, 6.82036400e-01f, -3.69139135e-01f, 2.79173732e-01f, 7.77866721e-01f,
  -3.63985705e-03f, -6.68048859e-01f, 3.65644872e-01f, -3.95110220e-01f, 6.86298251e-01f, -4.39757466e-01f, 7.54319906e-01f, -2.88984954e-01f, 4.38835591e-01f, -1.03903151e+00f,
  -5.93246520e-01f, 8.12884092e-01f, 1.50902450e-01f, 2.58084267e-01f, -5.76861620e-01f, -1.00709629e+00f, 2.91108578e-01f, 3.99781764e-02f, -6.72893584e-01f, -3.75559598e-01f,
  1.30341858e-01f, -7.04174638e-01f, -1.26241058e-01f, 2.67929733e-01f, 1.82974741e-01f, -3.42633188e-01f, -9.02999714e-02f, 4.08301115e-01f, 4.98699844e-02f, -1.00456154e+00f,
  4.98840302e-01f, -4.81472790e-01f, -4.80805263e-02f, -5.78877151e-01f, 7.17222750e-01f, -3.74524817e-02f, 7.79332578e-01f, 5.54269016e-01f, -4.91335541e-01f, -6.56331241e-01f,
  -4.79701668e-01f, -3.86794150e-01f, -9.40754354e-01f, -5.03097534e-01f, 1.05593860e+00f, -9.54303682e-01f, 4.43182319e-01f, -2.03436658e-01f, -7.62196779e-01f, 6.30283058e-01f,
  3.05273384e-01f, -3.03813219e-01f, -5.64736605e-01f, 2.10276648e-01f, 1.52893648e-01f, 2.52107028e-02f, -7.11354554e-01f, 5.17183423e-01f, 3.87338430e-01f, -1.52048901e-01f,
  7.46488810e-01f, -8.71541381e-01f, -1.09030128e+00f, 1.57572901e+00f, 1.29818082e+00f, 8.66185188e-01f, 1.12726104e+00f, 1.19940400e+00f, -9.83927131e-01f, 4.44326043e-01f,
  -1.03356338e+00f, 8.63556981e-01f, -1.83365405e-01f, -4.49125081e-01f, 5.69221437e-01f, 5.50503016e-01f, -9.24303055e-01f, -1.02679342e-01f, -7.05536008e-01f, -1.22497141e+00f,
  -9.41109881e-02f, -2.21978351e-01f, 7.41948605e-01f, 1.20639645e-01f, -2.36124650e-01f, 4.74192053e-01f, 4.40203249e-01f, 4.58658934e-01f, 9.42018330e-01f, 1.88236132e-01f,
  2.58753985e-01f, 5.74000061e-01f, -7.94737279e-01f, 8.36081684e-01f, 4.96556997e-01f, 8.18179369e-01f, -7.33834743e-01f, -7.22630858e-01f, -3.76965255e-01f, -4.59449291e-01f,
  7.73886666e-02f, -9.36235666e-01f, 1.19119060e+00f, -8.64466906e-01f, -1.28636289e+00f, 1.00215994e-01f, -6.39623702e-01f, -2.36613825e-01f, -5.79420865e-01f, -4.11370039e-01f,
  1.10625601e+00f, -1.02185929e+00f, -2.01314986e-01f, -3.87777358e-01f, -1.53743729e-01f, -1.45291373e-01f, 5.17150700e-01f, 1.04472496e-01f, 2.57195327e-02f, 3.75967920e-01f,
  3.54015619e-01f, 4.52177376e-01f, 3.31416339e-01f, -4.64798473e-02f, -8.45310152e-01f, -7.06910014e-01f, 1.12009454e+00f, -6.12179518e-01f, 7.22211719e-01f, 5.99001408e-01f,
  -8.11160505e-01f, -3.64133537e-01f, 4.05629694e-01f, -2.67700106e-01f, -4.77428734e-01f, -5.03798962e-01f, -4.88037050e-01f, -6.84142947e-01f, -1.11682892e+00f, -6.23719394e-01f,
  -6.08373284e-01f, 1.19527984e+00f, -4.22314852e-01f, 1.88618377e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -2.59533435e-01f, -4.15706754e-01f, -7.56833404e-02f, -8.98923352e-03f, 2.62407541e-01f, -4.53872867e-02f, 1.87077358e-01f, -3.30887675e-01f, -3.84050548e-01f, 3.32995921e-01f,
  1.10708565e-01f, -9.50619504e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    