/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.49307144e-01f, -8.32611322e-02f, -1.46441966e-01f, -1.37285724e-01f, 8.87708291e-02f, -5.30733392e-02f, -1.78286776e-01f, -3.91457826e-02f, 3.22413631e-02f, -9.53921899e-02f,
  7.49120563e-02f, 2.10320473e-01f, 1.18654989e-01f, 1.90880522e-01f, -1.02297761e-01f, -1.00288220e-01f, -1.93531796e-01f, -1.93402842e-01f, 4.78568040e-02f, 1.22186333e-01f,
  3.72300930e-02f, -6.04509600e-02f, -2.43355945e-01f, -4.93155345e-02f, 1.48191620e-02f, -2.81945877e-02f, -3.77183966e-02f, -3.23258415e-02f, 4.08521155e-03f, -2.68737115e-02f,
  6.37394488e-02f, -1.76908478e-01f, -6.26475066e-02f, -1.03833340e-01f, 8.75991359e-02f, -5.90708526e-03f, -1.22436710e-01f, -8.97495747e-02f, 4.69629467e-02f, -1.42946795e-01f,
  -4.61895484e-03f, -7.86270201e-02f, 2.13281694e-03f, 3.53608392e-02f, -7.28848055e-02f, -4.21706960e-02f, -1.48925960e-01f, -1.67477608e-01f, -1.56929404e-01f, 8.16936884e-03f,
  -1.20218657e-01f, -9.68522951e-02f, -1.03287414e-01f, -4.93695736e-02f, -8.50408003e-02f, -3.87186632e-02f, 4.44780628e-04f, -5.78557104e-02f, -1.29897058e-01f, -1.51881902e-02f,
  5.48428260e-02f, 6.73456863e-02f, 1.62231967e-01f, 3.47686894e-02f, 6.07059672e-02f, 8.12403113e-02f, 2.82805283e-02f, 7.29768649e-02f, 7.96385705e-02f, 8.88415053e-02f,
  8.84830654e-02f, 6.64985180e-02f, 2.46465057e-02f, 1.98151860e-02f, 9.63476747e-02f, -2.53301989e-02f, -3.14614773e-02f, -4.80147861e-02f, 5.82632469e-03f, 1.91071387e-02f,
  3.48943509e-02f, 7.16044530e-02f, -2.65517831e-02f, -2.51978985e-03f, 3.64381373e-02f, -5.41569442e-02f, 3.74886878e-02f, 3.55187505e-02f, 3.46361883e-02f, 4.63273525e-02f,
  8.81194025e-02f, -1.72477931e-01f, -2.01593399e-01f, -1.47354707e-01f, -1.36280477e-01f, -9.97001603e-02f, -1.46443754e-01f, 8.09359364e-03f, 6.00009877e-03f, -1.02548815e-01f,
  -1.19506545e-01f, -1.16055906e-01f, -6.74719065e-02f, -5.44035658e-02f, 8.98879394e-03f, -2.47016773e-02f, -4.06185314e-02f, -3.96838263e-02f, -2.96386182e-02f, -1.82405502e-01f,
  -1.52236521e-01f, -1.01469263e-01f, -1.26706734e-01f, -1.37216821e-01f, -1.48924887e-01f, -1.14926055e-01f, -3.29974405e-02f, -1.58161357e-01f, -9.45767537e-02f, -2.49602169e-01f,
  4.25022483e-01f, -3.56260464e-02f, 1.57419473e-01f, 3.99283260e-01f, 2.13752255e-01f, 9.34353992e-02f, 2.04844438e-02f, 1.28318250e-01f, 4.61649485e-02f, -2.19859444e-02f,
  -6.12771735e-02f, 6.57049268e-02f, 5.66350296e-02f, -9.99312568e-03f, 1.26965806e-01f, 2.08732337e-02f, 1.18491530e-01f, 1.60560951e-01f, 2.26673454e-01f, 5.11976145e-02f,
  -2.66813152e-02f, 2.11926609e-01f, 2.04314232e-01f, -3.93930860e-02f, -4.37037125e-02f, -2.56480966e-02f, 6.21652231e-03f, 5.26087582e-02f, -5.06045632e-02f, -8.34643766e-02f,
  -1.06301203e-01f, 2.11164013e-01f, 1.24187460e-02f, -4.75916825e-02f, -6.04174584e-02f, -4.94044647e-02f, -9.82312136e-04f, -4.54864651e-02f, -6.27293959e-02f, -4.06028032e-02f,
  -1.12026162e-03f, -1.19249173e-01f, 1.08150743e-01f, -8.78663585e-02f, 3.49236131e-02f, 3.22130360e-02f, -1.07037239e-02f, 5.22959046e-02f, -4.53492329e-02f, -2.79509556e-02f,
  3.11631858e-02f, 8.82987306e-02f, 1.85056031e-01f, 3.02128531e-02f, -8.42401572e-03f, 8.95489007e-02f, -2.85886545e-02f, 3.88420634e-02f, -7.55531434e-03f, -5.58230542e-02f,
  -2.07673702e-02f, -7.12502673e-02f, -2.91428659e-02f, 5.87706082e-02f, -3.39630656e-02f, -1.03648655e-01f, 3.27179953e-02f, 3.50754755e-03f, -4.65147346e-02f, 4.89570983e-02f,
  -6.14885800e-02f, 4.56633121e-02f, -2.41139773e-02f, 1.24339551e-01f, 8.23297501e-02f, -4.05755751e-02f, -1.21473446e-01f, -2.28277850e-03f, -7.18118548e-02f, 9.19776689e-03f,
  6.30128458e-02f, -8.74782801e-02f, -5.82629628e-02f, -6.16818033e-02f, -2.97280401e-03f, 1.47176594e-01f, 2.24310625e-03f, 6.11222070e-03f, 4.84852269e-02f, 5.33451475e-02f,
  3.90669405e-02f, 1.06115632e-01f, -1.09350927e-01f, -1.36549156e-02f, -3.67545225e-02f, -4.04051580e-02f, 4.59837019e-02f, -1.94374435e-02f, 5.29710902e-03f, 5.83013371e-02f,
  -1.28499661e-02f, -1.31702721e-02f, 8.64132941e-02f, -4.30028290e-02f, -9.15911421e-02f, 1.98215023e-02f, -4.05587442e-02f, -3.71129401e-02f, 2.33380869e-02f, -8.25344846e-02f,
  -9.36974660e-02f, -5.91810467e-03f, 1.04367577e-01f, -8.16554725e-02f, 7.47467354e-02f, 1.07069649e-01f, -4.50033359e-02f, -3.20311002e-02f, -5.65636232e-02f, -1.19360290e-01f,
  6.70352876e-01f, 2.66155213e-01f, 1.66655347e-01f, 1.33645236e-01f, 1.35734379e-02f, 2.61139244e-01f, 2.58154154e-01f, 1.65516317e-01f, 1.61266014e-01f, 7.17001483e-02f,
  6.81081638e-02f, -5.90462647e-02f, 3.65113989e-02f, 2.63870861e-02f, 1.61422476e-01f, 1.21698253e-01f, 5.30867949e-02f, 1.81801930e-01f, 1.46038055e-01f, 1.34254292e-01f,
  -7.42235929e-02f, 1.81487665e-01f, 1.68644413e-01f, 4.55837362e-02f, -7.07584014e-03f, 5.99910915e-02f, -4.65343408e-02f, 5.78675531e-02f, -7.01648835e-03f, -1.81765072e-02f,
  5.19190319e-02f, 1.37863591e-01f, 1.17908783e-01f, 4.37974483e-02f, 1.02813646e-01f, 1.94724768e-01f, 1.29981086e-01f, 1.04889147e-01f, 1.30733162e-01f, 9.00221989e-02f,
  4.77195196e-02f, 1.43683359e-01f, 1.05000444e-01f, -6.54267967e-02f, 5.55598214e-02f, 3.97053808e-02f, -8.84877220e-02f, 1.42916471e-01f, 2.86465436e-02f, 4.83868048e-02f,
  4.17719074e-02f, 1.69430807e-01f, 1.17148414e-01f, 1.17552653e-01f, 2.74891350e-02f, 1.50683969e-01f, 1.13180965e-01f, 1.27182856e-01f, 9.83741358e-02f, 1.97614074e-01f,
  -1.70429386e-02f, 2.68665701e-02f, -1.07385404e-01f, -4.23115911e-03f, 8.90584216e-02f, -8.05815011e-02f, -1.29784895e-02f, 5.47139421e-02f, -3.57590020e-02f, -2.92402804e-02f,
  -6.76096156e-02f, 6.35992130e-03f, -5.03966287e-02f, -4.38862294e-03f, -9.42589864e-02f, -7.08542466e-02f, -4.21653539e-02f, -6.34862632e-02f, -2.17410438e-02f, 1.81547850e-02f,
  1.30721917e-02f, 1.13237342e-02f, 1.65481120e-03f, -2.27114335e-02f, -5.22834063e-03f, -4.88459393e-02f, -1.60096288e-02f, -2.41928641e-02f, -4.23234515e-02f, -7.99042657e-02f,
  2.09431410e-01f, -4.26745825e-02f, 2.61270553e-01f, 2.46332392e-01f, 1.19587526e-01f, 1.09945953e-01f, 1.55007765e-01f, 1.31056175e-01f, 2.03612804e-01f, 1.96197927e-01f,
  1.40724450e-01f, 1.66662395e-01f, 4.39571356e-03f, 3.99978310e-02f, 1.59383506e-01f, 3.58401798e-02f, 7.04310834e-02f, 8.70968327e-02f, 5.70205450e-02f, 1.57357201e-01f,
  3.45047675e-02f, 2.87639260e-01f, 2.47610644e-01f, 2.71482497e-01f, 2.02570975e-01f, 1.76189601e-01f, 1.79737896e-01f, 1.79708198e-01f, 1.90909520e-01f, 3.34502101e-01f,
  2.33465135e-01f, 1.38305023e-01f, 1.08639970e-01f, 4.17601503e-02f, -3.12386490e-02f, 2.30197385e-01f, 3.25414687e-01f, 2.68136740e-01f, -5.06454445e-02f, 2.64575630e-01f,
  -9.00074989e-02f, -1.29127339e-01f, -1.54915437e-01f, -8.45075995e-02f, 1.45769909e-01f, 2.55731702e-01f, 1.96819261e-01f, 1.26153097e-01f, 3.70055474e-02f, 1.51435286e-01f,
  1.04418658e-01f, -9.71743464e-03f, 1.66978016e-02f, -1.82975503e-03f, 1.27167717e-01f, -5.10315485e-02f, 7.41639780e-03f, -5.87727651e-02f, -1.27934024e-01f, -6.16372610e-03f,
  2.29530618e-01f, 1.24157436e-01f, 8.08534324e-02f, 3.38507406e-02f, 9.94555559e-03f, 4.10727449e-02f, 8.14163685e-02f, 3.24264057e-02f, -7.75600784e-03f, 8.41439962e-02f,
  -3.95549685e-02f, 3.11304387e-02f, -2.12980956e-02f, 7.00864643e-02f, 5.78756928e-02f, 1.67647332e-01f, 1.61946595e-01f, 5.72219826e-02f, 6.19093552e-02f, 2.18209326e-02f,
  -7.37799555e-02f, -4.96538281e-02f, -1.65700223e-02f, 2.91475933e-02f, -6.20724931e-02f, -1.02653414e-01f, 1.24728791e-02f, 4.56130505e-02f, -6.18951693e-02f, 2.05472894e-02f,
  -1.82544570e-02f, -3.96396890e-02f, -1.38357026e-03f, 1.35449655e-02f, 4.30503823e-02f, 3.07267476e-02f, 3.11605055e-02f, -8.59108660e-03f, 8.22881833e-02f, 1.23480195e-02f,
  -2.02333741e-02f, 4.83175553e-02f, -5.15223294e-02f, 6.72575086e-02f, 2.86310632e-02f, 4.93141077e-02f, -1.36983069e-02f, -1.70931797e-02f, 2.79546063e-02f, 4.04604673e-02f,
  -4.23513614e-02f, 1.71420109e-02f, 2.68094130e-02f, 3.35284672e-03f, 5.76800555e-02f, -1.80593822e-02f, 2.89303344e-02f, -4.55115270e-03f, -2.39965487e-02f, -2.81088124e-03f,
  -5.53919896e-02f, -1.90696999e-01f, 1.29126772e-01f, 5.05727157e-02f, 2.26614792e-02f, -5.11941239e-02f, 2.90366393e-02f, -5.98981418e-02f, -7.55913854e-02f, 4.48720641e-02f,
  6.67284355e-02f, 8.42540115e-02f, 6.38769791e-02f, 3.23923565e-02f, 1.03907615e-01f, 5.94518743e-02f, 5.82182817e-02f, -2.22421251e-02f, -1.04663968e-01f, -1.75722539e-02f,
  8.01790953e-02f, 6.98415264e-02f, -6.68975618e-03f, 1.18931653e-02f, 5.55001125e-02f, 6.86726645e-02f, 5.10382578e-02f, 4.22501825e-02f, 4.47391532e-02f, 2.25949273e-01f,
  -1.53773412e-01f, -3.48096974e-02f, -6.72580451e-02f, 1.06245033e-01f, -8.03817809e-02f, -5.38532734e-02f, -9.60969329e-02f, -1.05711177e-01f, -9.01143551e-02f, -1.03106335e-01f,
  -1.63653567e-01f, 1.30184248e-01f, 1.14612179e-02f, 1.41250849e-01f, 1.05835207e-01f, -5.37070297e-02f, 1.10407390e-01f, 2.05852389e-01f, 2.12850943e-01f, 1.49127305e-01f,
  1.01940714e-01f, 1.07705034e-01f, 1.39552936e-01f, 1.52966440e-01f, 2.36298606e-01f, 1.50816053e-01f, 1.27501767e-02f, 1.53716341e-01f, 5.96698858e-02f, 3.02839398e-01f,
  1.16669266e-02f, 8.77202302e-03f, 7.49290064e-02f, 1.02073513e-01f, 4.45973361e-03f, 6.29398087e-03f, 5.26346825e-03f, 5.68266436e-02f, 1.13109387e-01f, 7.47881606e-02f,
  1.14986658e-01f, 1.02823809e-01f, 1.64927900e-01f, 8.50805491e-02f, 1.27428859e-01f, 1.28051609e-01f, 1.07542805e-01f, 1.12433456e-01f, 2.19982751e-02f, 1.24402307e-01f,
  1.96471229e-01f, 1.13504969e-01f, 3.09621561e-02f, -7.10480884e-02f, 1.69725232e-02f, 5.02508432e-02f, 6.57096729e-02f, 1.58140302e-01f, 7.45301507e-03f, 6.11609071e-02f,
  3.06373555e-02f, 2.60397121e-02f, -6.72226697e-02f, -1.03896856e-02f, -1.31843677e-02f, -2.90815420e-02f, 9.00536925e-02f, 1.15344219e-01f, 9.77686867e-02f, 8.30340385e-02f,
  -2.19222978e-02f, -1.70993491e-03f, 8.83871049e-04f, 8.69376808e-02f, 2.17501670e-02f, 4.65791933e-02f, 8.84048417e-02f, -1.47803565e-02f, -1.71208717e-02f, 4.29243520e-02f,
  -2.85700504e-02f, 8.05447251e-03f, -7.06964955e-02f, 1.43712193e-01f, -1.86357228e-03f, 1.03957439e-02f, -2.25379616e-02f, -7.18941586e-03f, -9.29940958e-03f, -3.94712910e-02f,
  -1.10650070e-01f, -2.97294986e-02f, 1.47004593e-02f, 3.39706205e-02f, 5.94898202e-02f, -2.48670555e-03f, 7.80167803e-02f, -5.54189924e-03f, 4.13076431e-02f, -3.13981000e-04f,
  3.60435210e-02f, 3.74479592e-02f, 1.02819569e-01f, 6.11183718e-02f, 6.00633733e-02f, -5.11572286e-02f, -2.28472799e-02f, 8.43118131e-03f, 1.10987023e-01f, 2.41199601e-02f,
  5.78133506e-04f, -1.12545174e-02f, -7.70651177e-02f, -1.01965591e-02f, 8.13084934e-03f, -5.84828407e-02f, -1.38967261e-02f, -4.50320281e-02f, -3.80857587e-02f, -2.10326061e-01f,
  -1.96813866e-01f, 1.69488043e-02f, -6.67710751e-02f, -2.45579984e-03f, 1.83655471e-01f, -5.34664318e-02f, -5.95985539e-02f, -2.16904864e-01f, -1.22102466e-03f, 7.96895102e-02f,
  5.95562831e-02f, -7.63626695e-02f, -6.49387836e-02f, -9.16599780e-02f, -2.55009890e-01f, 1.71014369e-01f, -3.46396081e-02f, -1.93136558e-01f, -2.89381981e-01f, -1.27857983e-01f,
  7.38193169e-02f, 7.55997002e-02f, -1.15770981e-01f, -1.19662713e-04f, 2.55433589e-01f, 7.18269646e-02f, 1.00600451e-01f, 1.85381114e-01f, 1.80336490e-01f, 3.52843732e-01f,
  9.05598775e-02f, -1.30148321e-01f, -1.14065990e-01f, -5.44722974e-02f, 3.54767293e-02f, -8.61075968e-02f, -3.45403627e-02f, 2.19705887e-03f, -4.66840342e-02f, -9.45643410e-02f,
  -6.70261756e-02f, -1.25969633e-01f, -1.11508094e-01f, -1.48051575e-01f, -9.52479914e-02f, -9.78289470e-02f, -9.72625390e-02f, -1.50908068e-01f, -5.99880069e-02f, 1.38092991e-02f,
  -1.16584443e-01f, -1.07499331e-01f, 6.13321038e-03f, -1.60047397e-01f, -1.60969466e-01f, -2.36762226e-01f, -9.00158063e-02f, -3.50797176e-02f, -1.06190614e-01f, 2.29883403e-01f,
  5.31130731e-02f, 3.35373580e-02f, -1.53698670e-02f, -5.52289486e-02f, -5.86236222e-03f, 7.78184086e-02f, 3.87429930e-02f, 1.81778342e-01f, 6.01894688e-03f, 2.46135760e-02f,
  -2.43553780e-02f, -2.40984261e-02f, 4.12409529e-02f, 6.76979125e-02f, 1.85353890e-01f, 8.15275684e-02f, 1.89250354e-02f, 1.26298234e-01f, 9.40372199e-02f, 1.11721354e-02f,
  2.25439649e-02f, 5.69075439e-03f, 8.50837305e-02f, 2.43222862e-02f, 1.11010768e-01f, 9.70303267e-02f, 3.35469469e-02f, 4.26737480e-02f, 2.18572319e-02f, -4.89609316e-03f,
  1.36089334e-02f, -1.58433184e-01f, -4.48226407e-02f, -6.70406669e-02f, -3.74814793e-02f, 6.68999506e-03f, -3.15658227e-02f, -8.74105096e-02f, -1.11071713e-01f, -6.55203238e-02f,
  1.04695167e-02f, -8.57192948e-02f, -4.16135527e-02f, -4.45571020e-02f, -1.12903595e-01f, -5.39244078e-02f, 1.32511510e-02f, 3.44383121e-02f, -5.54421060e-02f, 6.37682825e-02f,
  -2.56114802e-03f, 4.16546613e-02f, -4.15600389e-02f, -4.55616042e-02f, -9.56736505e-02f, -1.04804695e-01f, 7.58049488e-02f, 9.54712182e-02f, -1.22459814e-01f, 6.87629879e-02f,
  -1.50889829e-01f, -2.34303907e-01f, 4.21111211e-02f, -8.56572092e-02f, -3.74348946e-02f, 3.34030837e-02f, -1.55478418e-01f, -1.41058192e-01f, -1.13490209e-01f, -9.62167829e-02f,
  1.04008563e-01f, 2.26291925e-01f, 1.51276007e-01f, 1.13467291e-01f, -3.42948027e-02f, -2.74510741e-01f, -3.06550264e-01f, -1.20323941e-01f, 6.13904037e-02f, -3.28717194e-02f,
  -7.55344555e-02f, -2.30572969e-01f, -1.71419561e-01f, -6.89082369e-02f, -8.73631313e-02f, -2.60643158e-02f, -5.24252988e-02f, -1.04135461e-01f, -4.02403772e-02f, -3.38336498e-01f,
  7.75944963e-02f, -8.35457817e-02f, 1.24196569e-03f, 2.63642631e-02f, -5.16615063e-02f, -8.58006030e-02f, -3.21034528e-02f, -9.01553407e-02f, -5.07666357e-02f, -1.51307970e-01f,
  -5.27941473e-02f, -4.17780504e-02f, -7.63448253e-02f, -6.76657632e-03f, -1.67250067e-01f, -1.43789232e-01f, -2.54016161e-01f, -1.47237256e-01f, -1.60474703e-01f, -5.71760982e-02f,
  -1.15162671e-01f, -2.39954758e-02f, -1.23158410e-01f, -1.74270511e-01f, -1.32151857e-01f, -3.69881764e-02f, -1.28746733e-01f, -5.47138490e-02f, -4.90376912e-02f, -3.29402924e-01f,
  -3.53010260e-02f, 7.95288086e-02f, 8.79221857e-02f, 1.70179885e-02f, 3.76317278e-02f, 1.28447011e-01f, 3.35868746e-02f, 2.81041972e-02f, 8.52011666e-02f, -6.97410405e-02f,
  1.46521002e-01f, 4.84679505e-04f, 1.18515410e-01f, 9.03566480e-02f, 1.42765447e-01f, 8.05460103e-03f, 1.47451162e-01f, -3.26704346e-02f, 8.92166495e-02f, 1.07501507e-01f,
  3.30733806e-02f, 1.16387963e-01f, 2.16226280e-02f, 1.24768272e-01f, 7.72384927e-02f, 8.75066668e-02f, -6.62487969e-02f, 5.84810823e-02f, 6.43437430e-02f, 8.32383409e-02f,
  -6.19112998e-02f, 8.19571391e-02f, -1.15472563e-01f, -2.05877915e-01f, -1.98773265e-01f, -1.32942647e-01f, -6.13181256e-02f, -5.12978733e-02f, -7.59913027e-02f, -1.45499900e-01f,
  -1.16833955e-01f, -1.78050578e-01f, -4.98665906e-02f, -1.19654424e-01f, -6.53062016e-02f, -1.21195115e-01f, -1.24115385e-01f, -1.12088904e-01f, -1.74213797e-01f, -2.42584944e-01f,
  -1.62992373e-01f, -2.04569742e-01f, -2.16147855e-01f, -6.00172244e-02f, -8.81725401e-02f, -1.39028966e-01f, -1.07223161e-01f, -1.48294225e-01f, -8.80447477e-02f, -3.35667282e-01f,
  -1.49967268e-01f, 5.65712005e-02f, 3.27662081e-01f, -1.33175552e-01f, 9.45734903e-02f, 1.61802322e-02f, 1.87630832e-01f, 1.42579237e-02f, -9.17608738e-02f, 2.68065953e-03f,
  -1.38268456e-01f, -1.47031531e-01f, -9.23877582e-02f, -6.78040236e-02f, 1.75699834e-02f, 1.78522632e-01f, 1.67543322e-01f, 1.10533439e-01f, 9.06900540e-02f, -5.86525388e-02f,
  -7.10692778e-02f, 9.44076926e-02f, 1.46766216e-01f, 8.39653686e-02f, 9.98755824e-03f, -1.02597088e-01f, 1.73653588e-01f, 2.70673454e-01f, 1.83096007e-01f, 6.63654655e-02f,
  -1.54447660e-01f, -2.36539617e-02f, -4.39768881e-02f, -1.24103352e-01f, 2.24646907e-02f, -3.28511670e-02f, -6.30080774e-02f, 6.49657547e-02f, -1.82948578e-02f, 1.00234924e-02f,
  1.26951665e-04f, -4.04270180e-02f, -8.01423565e-02f, -1.05940066e-02f, -1.08113373e-02f, -3.77284316e-03f, 3.85476239e-02f, 3.41156609e-02f, -7.05804117e-03f, -9.27432254e-02f,
  -7.92235509e-02f, 7.70970881e-02f, 4.46228571e-02f, -7.12938840e-03f, 4.37095389e-02f, 7.63889104e-02f, 5.50746508e-02f, -4.68241572e-02f, 6.70164004e-02f, -1.11438215e-01f,
  1.34593239e-02f, -3.84491049e-02f, -5.42036071e-02f, -1.20008625e-02f, -1.29611949e-02f, -1.45339772e-01f, -9.71558690e-02f, 3.24006826e-02f, 2.01435457e-03f, -8.88111293e-02f,
  -6.95434213e-02f, -9.57283229e-02f, -1.16025344e-01f, -9.90127325e-02f, 1.72737818e-02f, -9.16964933e-02f, -5.24594821e-02f, -6.53307587e-02f, 3.76034901e-02f, -7.06858188e-02f,
  5.84744848e-03f, -4.88737598e-02f, 2.01477129e-02f, -4.73708175e-02f, -1.49211008e-02f, -8.64051748e-03f, -9.63447616e-02f, -3.83866243e-02f, -5.88025898e-02f, 2.21161097e-02f,
  -2.61072874e-01f, 1.36424661e-01f, -1.82849228e-01f, -7.20801353e-02f, -1.00100981e-02f, -4.70687971e-02f, -8.96657780e-02f, -6.22946583e-02f, -1.20468639e-01f, -6.58562705e-02f,
  -8.75624344e-02f, -2.43428685e-02f, -7.79003277e-02f, 1.91352833e-02f, -1.17522918e-01f, -9.72661600e-02f, -4.45585474e-02f, -3.85536253e-02f, -4.99838963e-02f, -9.68350768e-02f,
  7.91734010e-02f, -1.28611133e-01f, -1.60967574e-01f, -8.18877816e-02f, -9.37465057e-02f, -1.34835541e-01f, 3.28190960e-02f, 6.91955350e-03f, -1.26898559e-02f, -1.49038330e-01f,
  -3.48057330e-01f, 3.76249552e-01f, 2.51392394e-01f, -2.53767431e-01f, 9.04857442e-02f, 1.14650354e-02f, 4.40926850e-02f, -2.80189008e-01f, -1.20380394e-01f, 9.80622768e-02f,
  1.52320430e-01f, -1.61500379e-01f, 5.94556518e-03f, -5.65893576e-02f, -1.68098450e-01f, 1.94925174e-01f, 1.27821788e-01f, -3.74438912e-02f, -2.61137694e-01f, -2.64900297e-01f,
  6.48575425e-02f, -9.34441015e-02f, -2.35530034e-01f, -1.18874073e-01f, 2.10343570e-01f, -1.18672527e-01f, 2.69363821e-01f, 1.21098593e-01f, 2.26910710e-01f, 3.46929431e-01f,
  3.54215503e-01f, 2.04796687e-01f, -6.34117126e-02f, 2.37714387e-02f, 9.94482189e-02f, -8.76999348e-02f, 6.77839369e-02f, 3.71185988e-02f, -1.27641419e-02f, 4.44793366e-02f,
  8.13035071e-02f, 2.27754731e-02f, 4.30918597e-02f, 6.00705855e-02f, 9.68044773e-02f, 5.59860691e-02f, 4.25443240e-02f, -5.09169251e-02f, 8.25906917e-03f, -1.48059558e-02f,
  1.32158890e-01f, 1.51207969e-01f, 7.04890043e-02f, 6.36357293e-02f, -6.86361417e-02f, -1.13102729e-02f, 9.09783393e-02f, -3.68346125e-02f, -2.41362546e-02f, 3.71300131e-02f,
  -6.18229657e-02f, 9.89090353e-02f, 6.51346706e-03f, 2.69063413e-02f, -6.88531026e-02f, -2.49615964e-03f, -5.44050103e-03f, 5.95942922e-02f, -3.52673344e-02f, -5.25256339e-03f,
  6.80791661e-02f, -2.21443307e-02f, -4.58058566e-02f, 4.40743305e-02f, -3.13690305e-02f, 9.85884070e-02f, -5.38953906e-03f, -1.85696986e-02f, 2.40158546e-03f, -9.58607625e-03f,
  -1.73076857e-02f, 2.21839808e-02f, 3.32932062e-02f, 2.02679262e-02f, 3.32129039e-02f, -1.23056136e-02f, 2.10387986e-02f, -4.29380871e-02f, -5.86416125e-02f, 1.98163930e-02f,
  -1.15894392e-01f, -3.10762227e-02f, 4.85129468e-02f, 1.03172921e-01f, 4.96314839e-02f, 3.85430492e-02f, 7.12142959e-02f, -1.19474242e-02f, -4.86328281e-05f, -1.40246609e-02f,
  1.65965185e-02f, -1.29240751e-01f, 7.65711069e-02f, 9.48414858e-03f, -3.75589803e-02f, -7.30378181e-02f, 1.17253639e-01f, -1.79748703e-02f, -4.84460928e-02f, 6.55670017e-02f,
  -4.21879701e-02f, -1.13657005e-01f, -9.25320834e-02f, -6.01964071e-02f, -6.40199780e-02f, -1.36743397e-01f, -8.49903822e-02f, -1.06518216e-01f, -3.05589922e-02f, -9.42537487e-02f,
  -2.30649129e-01f, 1.60303246e-02f, 4.03117716e-01f, -6.04545921e-02f, 2.07001224e-01f, 2.15103328e-01f, 2.32539952e-01f, -1.00094285e-02f, -1.23827253e-02f, -3.20403203e-02f,
  -3.53079997e-02f, -2.14999080e-01f, -7.90939406e-02f, -5.53614981e-02f, -1.74294990e-02f, 2.22944662e-01f, 1.52497739e-01f, -2.51558027e-03f, -9.14863274e-02f, -1.60160676e-01f,
  -2.05812939e-02f, 6.89810365e-02f, -1.78794544e-02f, 3.57377753e-02f, 8.59703682e-03f, -1.11101978e-01f, 1.46510065e-01f, 1.11485496e-01f, 6.46761805e-02f, 5.04994579e-02f,
  -1.98773324e-01f, -5.45083620e-02f, 1.47746935e-01f, -9.71916392e-02f, 1.00427315e-01f, 1.09908255e-02f, -3.95533517e-02f, 9.22177732e-02f, 1.30602270e-01f, -4.39445265e-02f,
  4.50977050e-02f, 5.44604622e-02f, -6.03380017e-02f, -3.96621861e-02f, 3.13745067e-02f, -5.05931303e-03f, 9.43504348e-02f, -6.65998878e-03f, 3.42604704e-02f, -1.62812732e-02f,
  2.50888243e-02f, -1.86198521e-02f, 1.50194451e-01f, 2.45653745e-02f, 1.25560328e-01f, 1.23292938e-01f, 3.13542373e-02f, 1.01841830e-01f, 9.51420292e-02f, 4.36687469e-02f,
  1.16402963e-02f, 7.45616853e-02f, 3.55093069e-02f, 8.63386244e-02f, -4.25109789e-02f, 2.90746558e-02f, 6.94078803e-02f, -3.04196458e-02f, -9.70593318e-02f, 2.92635597e-02f,
  2.62131002e-02f, 2.48248572e-03f, 6.11500740e-02f, -6.03163568e-03f, -3.62609029e-02f, 5.69935003e-03f, -4.26102467e-02f, 9.03945118e-02f, 3.84611562e-02f, 5.98440878e-02f,
  -7.94049501e-02f, 8.44026059e-02f, 3.40996720e-02f, -9.36852172e-02f, 9.52851847e-02f, 1.44242987e-01f, -4.43548970e-02f, 2.86236573e-02f, 1.17421657e-01f, 2.48868037e-02f,
  -2.12441772e-01f, 2.85311937e-01f, -3.20162512e-02f, 2.68991161e-02f, 4.11074944e-02f, -5.27499802e-02f, -1.85522507e-03f, 8.54002759e-02f, 6.38610497e-02f, -4.89791408e-02f,
  4.48440090e-02f, -6.31281314e-03f, -4.83379252e-02f, 5.47074936e-02f, 5.83535358e-02f, 3.91610898e-02f, 5.81825487e-02f, 5.49262986e-02f, 6.82498813e-02f, 4.80153672e-02f,
  6.55793324e-02f, 1.80171188e-02f, -1.17662378e-01f, 5.10413200e-02f, 3.10963355e-02f, -4.43166271e-02f, 6.38181120e-02f, -5.20879477e-02f, -2.49846615e-02f, -7.45937303e-02f,
  3.62743527e-01f, 1.46908626e-01f, -3.05402465e-02f, 3.43745321e-01f, 4.22099829e-02f, -1.46812201e-01f, 1.25110626e-01f, 6.60509616e-02f, 4.96074818e-02f, 9.64031145e-02f,
  9.90879238e-02f, 1.98572092e-02f, 1.90381110e-01f, 7.74423033e-02f, 4.01720367e-02f, 1.51586637e-01f, 2.09006563e-01f, 1.23376369e-01f, 1.29319832e-01f, 1.13729089e-01f,
  2.57877707e-01f, 1.86986089e-01f, 1.76156521e-01f, -3.70824970e-02f, 1.04602978e-01f, -5.75774536e-02f, 8.91033486e-02f, 6.19998761e-02f, 8.80857185e-03f, 1.51159316e-01f,
  4.59309258e-02f, -8.05804972e-03f, 6.59644753e-02f, 1.59837738e-01f, 1.16956390e-01f, -3.25555690e-02f, 1.68814603e-03f, 7.05634579e-02f, 1.85419228e-02f, 5.18480130e-02f,
  8.67425203e-02f, 1.25044212e-01f, 5.81977181e-02f, 9.45344195e-02f, 9.40084159e-02f, 1.34917155e-01f, -2.27357596e-02f, 1.33905813e-01f, 6.26636818e-02f, 5.86536601e-02f,
  4.80527356e-02f, -4.27329391e-02f, -3.20532806e-02f, 1.56803057e-02f, -6.65068626e-02f, 2.50725411e-02f, -2.27908734e-02f, 3.73566411e-02f, -1.14006385e-01f, 9.12247375e-02f,
  -1.85627257e-03f, 2.27465760e-02f, -6.13005422e-02f, -3.18523720e-02f, 9.89523977e-02f, 3.78397740e-02f, -3.30956504e-02f, 6.63190559e-02f, 2.79208813e-02f, 3.78438942e-02f,
  2.93414313e-02f, -1.11584682e-02f, 3.04400530e-02f, 9.66633707e-02f, -6.74974024e-02f, 3.97646427e-02f, -7.02229813e-02f, 2.61536576e-02f, -4.11615111e-02f, 3.82978059e-02f,
  9.62135345e-02f, -2.36044545e-03f, 5.96298985e-02f, -1.10230587e-01f, -1.01059124e-01f, -8.03796574e-03f, -5.53920269e-02f, 5.01480252e-02f, 8.04034323e-02f, -2.92592291e-02f,
  2.38279566e-01f, -1.58685401e-01f, 9.43358913e-02f, 2.25829408e-02f, 5.80762327e-03f, 6.56448230e-02f, 7.50458613e-02f, 7.36323968e-02f, 4.92238402e-02f, 8.19804296e-02f,
  9.06197429e-02f, 1.08717941e-01f, 8.67726430e-02f, -3.66425142e-02f, 7.52648637e-02f, 7.17222020e-02f, 8.28863680e-02f, 1.61690696e-03f, 4.13945802e-02f, -2.76086424e-02f,
  6.88721463e-02f, 1.67757049e-01f, 1.38383284e-01f, 1.61005706e-01f, 1.91081371e-02f, 9.64350402e-02f, 1.38659813e-02f, -4.55250181e-02f, -2.25862768e-02f, 2.46307597e-01f,
  -1.10379592e-01f, 4.17077504e-02f, -4.10084277e-01f, 1.34419963e-01f, -4.09006141e-02f, -1.69939488e-01f, -3.06106478e-01f, -8.32913667e-02f, 1.93304986e-01f, 9.04591531e-02f,
  1.80658638e-01f, 4.14371073e-01f, 1.65947661e-01f, 2.00182974e-01f, -2.16175765e-02f, -1.97647035e-01f, -2.66693532e-01f, -2.26879999e-01f, -1.36648238e-01f, 1.87031329e-02f,
  8.34759474e-02f, -1.77380312e-02f, 2.92994510e-02f, -2.49019787e-02f, 1.67702381e-02f, 1.14698686e-01f, -3.43665443e-02f, -6.18157834e-02f, 5.09730056e-02f, -1.86283849e-02f,
  -1.20142736e-02f, -5.12470608e-04f, 5.22179529e-02f, 1.48937792e-01f, 4.64235023e-02f, -4.88236472e-02f, -5.69961071e-02f, -4.49339524e-02f, 1.22159414e-01f, 2.05616448e-02f,
  3.73065546e-02f, 7.13197365e-02f, 7.21418038e-02f, 9.03906003e-02f, -4.84610759e-02f, 6.96780980e-02f, 4.90471683e-02f, -1.20012924e-01f, -3.53668258e-02f, 5.04969321e-02f,
  1.81086913e-01f, 9.57202241e-02f, -4.77658026e-02f, -2.23572645e-02f, -9.98262316e-03f, 1.23379506e-01f, -3.44004086e-03f, 7.98658803e-02f, 3.54279168e-02f, 1.20076209e-01f,
  -7.19439909e-02f, -6.94381893e-02f, -8.14672187e-02f, -2.31794138e-02f, -5.93605898e-02f, -5.64390868e-02f, -4.84298244e-02f, -1.23242950e-02f, 1.31332884e-02f, -1.05231889e-01f,
  -5.79788946e-02f, -7.57870004e-02f, -5.97169735e-02f, -1.32973760e-01f, -7.91500658e-02f, -7.73223788e-02f, -5.94417118e-02f, 5.26596904e-02f, 2.16658730e-02f, -6.31078705e-03f,
  8.88914708e-03f, -9.84024256e-02f, -4.03177477e-02f, 1.06053418e-02f, -1.50145069e-01f, -9.75629091e-02f, 6.26495928e-02f, 7.95734748e-02f, -1.48080051e-01f, -4.71220016e-02f,
  1.45532161e-01f, -1.67512614e-02f, 1.58264756e-01f, 1.78672686e-01f, 9.81437266e-02f, 9.53674540e-02f, 1.64231315e-01f, 1.97448373e-01f, 1.13757089e-01f, 1.51759267e-01f,
  8.21983442e-02f, -1.46815479e-02f, 3.72112915e-02f, 2.60072816e-02f, -2.81618792e-03f, 3.27427266e-03f, 1.79087728e-01f, 1.46201840e-02f, 5.91999255e-02f, 1.54066190e-01f,
  1.26857221e-01f, 1.00255623e-01f, 1.61200345e-01f, 7.76679888e-02f, 4.91870567e-02f, 2.06579834e-01f, 5.91482259e-02f, 1.07777789e-01f, 5.56159578e-02f, 4.38313931e-02f,
  -1.45150900e-01f, 2.56082028e-01f, -3.29778902e-02f, -1.07187301e-01f, -6.59512058e-02f, -2.67106950e-01f, -5.72680086e-02f, -1.28697515e-01f, -1.21430136e-01f, 8.56333748e-02f,
  -2.24927124e-02f, -1.03071988e-01f, -1.29356444e-01f, -5.82005121e-02f, -5.15137389e-02f, 1.36258975e-01f, 1.53453901e-01f, 5.26774190e-02f, -1.41407803e-01f, -9.20421407e-02f,
  3.04721519e-02f, 4.88401726e-02f, 1.07524820e-01f, -2.83661038e-02f, 1.10405900e-01f, -1.03739277e-01f, 1.24650814e-01f, 3.49888355e-02f, 9.07162353e-02f, 1.68733552e-01f,
  8.15923046e-03f, 1.87050506e-01f, -1.54317752e-01f, -2.18500337e-03f, -3.01819202e-02f, 2.27046870e-02f, -9.54423696e-02f, 1.07751472e-03f, -7.49879330e-02f, -6.14598207e-02f,
  -5.32074459e-02f, -2.51993053e-02f, -1.58191640e-02f, -9.18978974e-02f, -8.72381777e-02f, -4.57198322e-02f, 3.35607603e-02f, -3.35266441e-02f, -7.77245760e-02f, 4.00414914e-02f,
  6.35050759e-02f, -3.87451760e-02f, -6.54490888e-02f, -8.90840888e-02f, 1.62728224e-02f, -1.77415043e-01f, -1.10167950e-01f, -1.12500470e-02f, -8.07041973e-02f, -1.20186821e-01f,
  7.29701966e-02f, -9.30233672e-03f, 5.98715506e-02f, 1.28023988e-02f, 4.65815365e-02f, 7.04778433e-02f, 5.12329787e-02f, 5.69249876e-02f, -1.45552857e-02f, -2.06531864e-02f,
  8.18108916e-02f, 5.13024889e-02f, 9.51078534e-02f, 9.00476500e-02f, 6.92143738e-02f, 7.10773245e-02f, 2.74973605e-02f, 1.15214720e-01f, 9.24651474e-02f, 1.31828815e-01f,
  5.21917492e-02f, 7.22029060e-02f, 1.19564869e-02f, 1.12310715e-01f, 6.84411675e-02f, 1.23198196e-01f, 1.19255699e-01f, 8.46814439e-02f, 3.43915224e-02f, 6.75783455e-02f,
  -2.68357962e-01f, -4.69982401e-02f, -1.39714703e-01f, -1.21576771e-01f, -1.96422234e-01f, -1.03164427e-01f, 1.31769786e-02f, -6.67136237e-02f, -6.69616088e-02f, -4.12351489e-02f,
  -1.17678486e-01f, -1.85873229e-02f, -1.33250862e-01f, -5.15634418e-02f, -3.99272740e-02f, -8.11485201e-02f, 4.02416401e-02f, -9.89605561e-02f, -5.15034907e-02f, -1.21955194e-01f,
  -5.76929227e-02f, -1.99583799e-01f, -2.45958120e-01f, -1.27508849e-01f, -1.66232154e-01f, -3.27514321e-01f, -2.42841020e-01f, -1.93139076e-01f, -2.78367728e-01f, -2.02231064e-01f,
  2.04090104e-02f, 3.95726681e-01f, 1.34037603e-02f, 1.06851637e-01f, -3.01625337e-02f, -3.14713717e-01f, -1.18796512e-01f, -1.48624092e-01f, -8.81628916e-02f, 1.14419691e-01f,
  -1.15253791e-01f, -7.84914419e-02f, -4.32868637e-02f, -5.69085144e-02f, -1.88592657e-01f, 1.06097057e-01f, 2.17293113e-01f, 8.72806460e-02f, -1.93254858e-01f, -1.59670725e-01f,
  1.03795812e-01f, 1.68885991e-01f, 1.60539616e-02f, -1.28271133e-02f, 2.49305353e-01f, 1.02206327e-01f, 2.39334300e-01f, 9.65418220e-02f, 6.36257082e-02f, 3.57933402e-01f,
  2.53414720e-01f, -3.18589024e-02f, -1.32403851e-01f, 6.56259654e-04f, 1.39928788e-01f, -4.82349470e-03f, 1.30079240e-02f, 4.33836766e-02f, 1.42095024e-02f, -1.48290498e-02f,
  -6.46585319e-03f, 1.67476237e-02f, 5.17938882e-02f, 1.30939230e-01f, 9.39086545e-03f, -6.19687214e-02f, 9.62481946e-02f, -4.72163223e-02f, -5.40534630e-02f, -3.27888019e-02f,
  3.52125429e-02f, -9.18160155e-02f, -9.21948478e-02f, -4.98961769e-02f, -9.33917612e-03f, -6.84491023e-02f, -7.67801404e-02f, -8.64737257e-02f, -1.09787934e-01f, 1.59362823e-01f,
  -7.95070902e-02f, 2.95340829e-02f, -6.09097034e-02f, -1.30989095e-02f, -3.60980816e-02f, 1.39913484e-02f, -1.92808080e-02f, 1.20562837e-01f, 6.32856339e-02f, -1.74365733e-02f,
  -6.50061592e-02f, 3.97015624e-02f, 5.76977618e-03f, -3.62038128e-02f, 2.28987839e-02f, -5.08196354e-02f, -6.35632947e-02f, -5.53912371e-02f, -9.79328230e-02f, -3.23328897e-02f,
  -6.15427420e-02f, -5.57376854e-02f, 1.01430021e-01f, -3.49983759e-02f, 2.80216727e-02f, -8.17437544e-02f, -3.44632119e-02f, 5.15957884e-02f, -3.11145559e-02f, -1.53880805e-01f,
  2.02033326e-01f, -1.68256551e-01f, -8.45911261e-03f, -4.48630657e-04f, 7.08430856e-02f, 5.57203637e-03f, -5.50191726e-05f, 6.74200207e-02f, -4.34586452e-03f, 5.35857528e-02f,
  -1.66654680e-02f, 3.75794172e-02f, 1.07164592e-01f, 3.92955765e-02f, 3.71858217e-02f, -2.24337578e-02f, 1.16919160e-01f, -7.62644410e-02f, -2.14681961e-02f, 1.21864885e-01f,
  1.97434306e-01f, 7.27841929e-02f, 2.06599943e-02f, -2.78727096e-02f, 5.85765056e-02f, -8.93488228e-02f, 9.77434069e-02f, 1.18315518e-01f, -1.21878959e-01f, 2.48262689e-01f,
  -2.36981601e-01f, -4.88210469e-02f, 9.29089636e-02f, 1.54176420e-02f, 1.68230563e-01f, 1.78902164e-01f, 5.59224561e-02f, 7.12816492e-02f, -3.88524644e-02f, -3.31252106e-02f,
  2.13933140e-01f, 1.59550831e-01f, 1.14357010e-01f, 1.28067955e-01f, 1.40809074e-01f, 4.71462719e-02f, -4.95573133e-02f, 5.58644943e-02f, 6.36524111e-02f, 2.19432265e-01f,
  1.52822196e-01f, 4.02823426e-02f, 1.52237326e-01f, 4.65075076e-02f, -8.44743997e-02f, -5.06961308e-02f, 4.93428074e-02f, 3.25646810e-02f, 7.95979872e-02f, -1.54792294e-01f,
  3.40388454e-02f, 1.03314124e-01f, 1.04058169e-01f, 7.44075030e-02f, 1.29615426e-01f, 5.29985093e-02f, 1.62574016e-02f, 5.20168990e-02f, 1.50358006e-01f, 3.69256176e-02f,
  1.86102703e-01f, 1.77768558e-01f, 1.92753688e-01f, 1.18050121e-01f, 1.53173432e-01f, 1.72816306e-01f, 1.84355244e-01f, 2.07072988e-01f, 6.41774088e-02f, 1.61194295e-01f,
  2.55830288e-01f, 2.51049042e-01f, 2.80185759e-01f, 2.02807009e-01f, 1.15151718e-01f, 1.98219821e-01f, 9.84343365e-02f, 1.63249195e-01f, 3.31169330e-02f, -1.07152015e-01f,
  3.25906649e-03f, -1.11124188e-01f, -1.15593262e-01f, -7.01747835e-02f, -7.22265914e-02f, -1.21516868e-01f, -5.16228676e-02f, -6.34825975e-02f, -1.97298795e-01f, -9.71608385e-02f,
  -6.31071394e-03f, -1.16695367e-01f, -6.59248699e-03f, -9.66346115e-02f, -1.12297677e-01f, -6.43310547e-02f, -7.21438378e-02f, -1.41824529e-01f, -1.22357823e-01f, -1.58038363e-01f,
  -1.33262873e-01f, -1.02136336e-01f, -8.90114084e-02f, -1.00506857e-01f, -6.63341209e-02f, -9.38447416e-02f, -1.45858407e-01f, -1.12774402e-01f, -1.76054955e-01f, -1.14383891e-01f,
  -9.07366797e-02f, 1.67531773e-01f, 3.55436001e-03f, 1.67811900e-01f, 1.59452096e-01f, 3.58701907e-02f, 1.15741879e-01f, 1.60379738e-01f, 1.95666477e-01f, 7.88836628e-02f,
  1.65728092e-01f, 3.92079800e-02f, 1.10574514e-01f, 1.54033422e-01f, 2.74281532e-01f, 1.00932792e-01f, 1.80068001e-01f, 1.74136087e-01f, 9.96110514e-02f, 1.57589585e-01f,
  5.85735217e-02f, 9.88537297e-02f, 1.08141368e-02f, 6.59401342e-02f, 1.25044435e-01f, 5.82797453e-02f, 1.17553502e-01f, 1.15391776e-01f, -3.21478322e-02f, -6.14729375e-02f,
  1.71519083e-03f, -1.35169908e-01f, 4.70192246e-02f, -1.07876390e-01f, 1.33071378e-01f, 2.28117108e-01f, 2.27816924e-01f, 2.03327239e-01f, -7.01254047e-03f, -1.72368705e-01f,
  1.68681353e-01f, 2.35331163e-01f, 1.23967886e-01f, 1.27733126e-01f, 1.96874663e-01f, -8.82073343e-02f, -1.23847835e-01f, 1.59983829e-01f, 3.83667648e-01f, 2.29323149e-01f,
  5.97779006e-02f, -9.17460322e-02f, 6.77919239e-02f, -4.16703708e-02f, -2.78148234e-01f, -8.25696662e-02f, -1.91345394e-01f, 1.88984778e-02f, 5.47044948e-02f, -4.49880004e-01f,
  8.48135874e-02f, 4.32134010e-02f, 2.10070014e-01f, -3.69151793e-02f, 7.31908605e-02f, 3.06653883e-02f, 4.49084351e-03f, 2.05860082e-02f, -2.64157448e-02f, 2.20898837e-02f,
  2.42225500e-03f, 7.08561912e-02f, 1.20861836e-01f, -4.51262482e-02f, 8.09531659e-02f, 1.05959758e-01f, -2.29127370e-04f, 1.34071112e-01f, 6.19526766e-02f, 1.17487721e-01f,
  -3.91765162e-02f, 1.25971511e-01f, 2.48806596e-01f, 6.58013597e-02f, 1.31981969e-01f, 1.42863467e-01f, 1.09593518e-01f, 5.39500825e-02f, 5.33934422e-02f, -3.36955756e-01f,
  -4.51406129e-02f, -3.20057347e-02f, -1.99520290e-02f, 2.10422347e-03f, -7.70359188e-02f, 3.46978381e-02f, -1.22640610e-01f, -3.05276997e-02f, -5.99462464e-02f, -4.25102375e-02f,
  -1.90237407e-02f, -9.90829393e-02f, -1.11086667e-01f, 4.39970121e-02f, -6.22992665e-02f, -1.09392889e-02f, -2.46947259e-03f, -3.46452408e-02f, -4.03836519e-02f, -1.11102723e-01f,
  1.18668089e-02f, -2.12261081e-02f, -6.13360666e-02f, -3.20132496e-03f, -5.96848726e-02f, -1.07480504e-01f, 4.77126390e-02f, -9.82736237e-03f, 4.49534785e-03f, -1.09697850e-02f,
  3.13011259e-02f, 2.24910349e-01f, -7.55155161e-02f, 5.12448698e-03f, -6.32219762e-02f, 3.26962322e-02f, -1.87121741e-02f, -3.11724525e-02f, -3.07948906e-02f, 2.89244149e-02f,
  7.28370547e-02f, 2.05211081e-02f, 6.79055899e-02f, -2.62241941e-02f, 7.55292252e-02f, 3.59207653e-02f, 5.96010834e-02f, -4.13938463e-02f, -1.29485081e-04f, -2.21934859e-02f,
  3.69866379e-02f, 6.53961524e-02f, 1.51579350e-01f, 4.29667495e-02f, 4.51700529e-03f, 1.34278521e-01f, 3.06775626e-02f, 4.19837236e-02f, 1.92010120e-01f, -1.73900232e-01f,
  3.67067397e-01f, -1.77512299e-02f, 5.05629554e-02f, 2.85290480e-01f, 2.60533482e-01f, 7.63331028e-03f, 4.20867540e-02f, -4.37601432e-02f, -2.17781179e-02f, 4.20204997e-02f,
  -1.98775157e-01f, -6.06895760e-02f, -1.25979081e-01f, -9.69088227e-02f, -7.28875175e-02f, -5.42373136e-02f, 8.34804326e-02f, 1.59098774e-01f, 1.38354525e-01f, 2.15473965e-01f,
  2.70469338e-02f, 1.35521427e-01f, 1.50052562e-01f, 8.10197517e-02f, -6.23910911e-02f, -3.64802778e-02f, -1.95185300e-02f, 1.37004480e-01f, -8.45769420e-02f, -2.38358453e-02f,
  -1.06689900e-01f, 7.12280497e-02f, -2.86962986e-02f, 3.84169817e-02f, -2.57323356e-03f, -6.52537122e-02f, -4.53952001e-04f, -7.14223757e-02f, -4.52517793e-02f, -1.56993065e-02f,
  1.43673830e-02f, -5.23625426e-02f, 2.46554371e-02f, 1.52268214e-02f, 3.45250741e-02f, 2.48213974e-03f, 1.22314896e-02f, 4.58255261e-02f, -3.90388332e-02f, -3.96936871e-02f,
  5.57057895e-02f, 1.28813788e-01f, 1.11396879e-01f, -1.08351372e-01f, -7.68687278e-02f, -5.46372356e-03f, -4.18726578e-02f, -6.49559498e-02f, -5.54062724e-02f, -1.05231985e-01f,
  -8.02935436e-02f, -7.25249127e-02f, -1.32572213e-02f, -2.38353815e-02f, 2.30589230e-02f, -5.19075319e-02f, -1.76947564e-03f, 2.37328000e-02f, 5.52454963e-02f, -9.38164666e-02f,
  -5.11736162e-02f, -5.06916791e-02f, -8.48699883e-02f, -9.74651873e-02f, -1.03642970e-01f, -2.95759570e-02f, -7.22003505e-02f, -7.20548257e-02f, -9.41124037e-02f, -9.74578224e-03f,
  -8.03828314e-02f, 4.15257066e-02f, -5.62799498e-02f, -5.74293099e-02f, -1.22539990e-01f, -7.09192827e-02f, -7.80975968e-02f, 3.34516168e-02f, 8.01509432e-03f, 6.94148168e-02f,
  -2.59093076e-01f, -9.16241705e-02f, -5.89501448e-02f, -1.12914331e-01f, -4.95566651e-02f, -1.00805506e-01f, -1.56414464e-01f, -4.23015133e-02f, -5.41826747e-02f, -1.67637561e-02f,
  -5.64674102e-02f, -6.16483204e-02f, -8.81603435e-02f, -2.77985334e-02f, 4.17155959e-02f, -1.59028452e-02f, -7.44364923e-03f, 1.51049113e-02f, 6.97430689e-03f, -2.07407586e-03f,
  2.36300984e-03f, -4.39423360e-02f, 1.66071169e-02f, -5.31229973e-02f, -8.19333866e-02f, -6.93100318e-02f, -1.01895712e-01f, -1.48484021e-01f, -4.95641977e-02f, -1.15619309e-01f,
  8.53030384e-02f, 1.36050045e-01f, -9.31488797e-02f, 1.21725433e-01f, 1.58744916e-01f, 1.70582488e-01f, 1.14426754e-01f, 2.36037061e-01f, 2.91338712e-01f, 1.56270474e-01f,
  1.69997603e-01f, 2.84863472e-01f, 2.63430595e-01f, 1.17227636e-01f, 1.51983559e-01f, -1.01980165e-01f, -1.64628297e-01f, -1.13318048e-01f, 1.06520645e-01f, 6.85279965e-02f,
  1.20430209e-01f, 1.06144100e-02f, 7.78191537e-02f, 1.87324770e-02f, 6.32207394e-02f, 2.67690182e-01f, 8.63384232e-02f, -4.51431312e-02f, 1.05661182e-02f, -2.79151201e-01f,
  -1.51553139e-01f, 9.87271965e-02f, 1.26240149e-01f, 1.14409924e-01f, 7.14917928e-02f, 1.25949308e-01f, 1.74625590e-01f, 8.00934583e-02f, 1.73556298e-01f, 1.51663013e-02f,
  3.50281186e-02f, 2.69481353e-02f, 4.89028618e-02f, -5.02925599e-03f, -1.45410439e-02f, 7.43897632e-02f, 9.01005138e-03f, -1.47030326e-02f, -4.38600779e-02f, 3.35480869e-02f,
  1.21729910e-01f, 9.19814855e-02f, 5.96801043e-02f, 1.83245137e-01f, 1.08677320e-01f, 2.21948586e-02f, 1.58731267e-01f, -2.37374543e-03f, 6.53765351e-02f, 2.05939543e-02f,
  6.91433474e-02f, -2.91919280e-02f, -8.18766933e-03f, -4.95355614e-02f, 5.70096017e-04f, -5.87124415e-02f, -1.40769139e-01f, 2.02228595e-03f, 4.15941440e-02f, 6.29939605e-05f,
  -3.76980118e-02f, 3.68576357e-03f, 1.49222771e-02f, 8.50010291e-02f, 1.08808435e-01f, -1.91838818e-03f, -4.44189608e-02f, -2.61468608e-02f, 6.08051643e-02f, 8.83213282e-02f,
  -4.62149978e-02f, -2.78037619e-02f, -7.63316825e-03f, -2.75611375e-02f, -4.45570564e-03f, 4.13430221e-02f, -5.77051006e-02f, 3.91182974e-02f, -7.89825397e-04f, -3.87419797e-02f,
  3.11275065e-01f, 2.24497736e-01f, 4.05344963e-02f, 9.23126787e-02f, -1.56203005e-02f, 4.06373553e-02f, 8.96279737e-02f, 4.89001302e-03f, 8.56752172e-02f, 9.51019600e-02f,
  1.35497794e-01f, 8.53045657e-02f, 1.52202651e-01f, -7.19730044e-03f, 7.62128830e-02f, 5.41999564e-02f, 6.21685050e-02f, 1.22584868e-02f, 8.13202709e-02f, 5.00154495e-02f,
  6.97510689e-02f, 1.10072725e-01f, 2.05642134e-01f, 2.33220071e-01f, 7.42195100e-02f, 1.63631573e-01f, 1.98800221e-01f, 1.17036425e-01f, 1.50335073e-01f, 1.44843027e-01f,
  3.81910771e-01f, -1.95416898e-01f, 1.91640615e-01f, 1.27281919e-01f, -2.54457802e-01f, -2.08859473e-01f, -2.73662716e-01f, 6.71112463e-02f, -8.91320184e-02f, -1.79427922e-01f,
  -2.39100158e-01f, -1.04476772e-02f, -1.08236641e-01f, -1.12441637e-01f, 1.70995876e-01f, 1.96877634e-03f, 1.00700982e-01f, 3.26437563e-01f, 2.95363843e-01f, 3.18247341e-02f,
  -2.25671865e-02f, 1.69626802e-01f, 2.86309958e-01f, 1.16511114e-01f, -3.55632268e-02f, 6.29030466e-02f, 8.93743988e-03f, 2.20489111e-02f, -1.11688353e-01f, -2.36538649e-02f,
  -9.61271003e-02f, 1.30838796e-01f, 5.83425611e-02f, 1.45514160e-02f, -1.14920385e-01f, 3.81111614e-02f, -1.09651588e-01f, -9.08547360e-03f, -4.14055623e-02f, -4.73755412e-02f,
  3.33541706e-02f, 6.03701025e-02f, 3.84504348e-02f, -3.31574306e-02f, -3.63490847e-03f, 1.06639661e-01f, 4.58943918e-02f, 1.97563320e-01f, 7.00802058e-02f, -5.33302203e-02f,
  1.05928667e-02f, 2.16716882e-02f, 3.31181660e-02f, -2.35180892e-02f, -4.27000783e-02f, 1.08251475e-01f, 2.08208486e-02f, -7.17937108e-03f, 1.06202215e-01f, -6.98037893e-02f,
  -8.51868168e-02f, 1.23218745e-02f, -3.67938802e-02f, -8.88234749e-02f, -1.58375040e-01f, -8.97658989e-02f, -2.53307801e-02f, 7.11095287e-03f, 2.52933204e-02f, -8.64090770e-03f,
  -4.02822830e-02f, -8.96442775e-03f, -4.59638238e-02f, 2.60593500e-02f, -2.09351312e-02f, 8.75397585e-03f, -2.04813275e-02f, 1.61112677e-02f, -5.64265028e-02f, -1.38446288e-02f,
  -8.52079391e-02f, -2.72928476e-02f, -1.17765993e-01f, -1.05286492e-02f, 8.46413244e-03f, 2.79455204e-02f, -2.55181957e-02f, -9.55273211e-02f, 2.51882691e-02f, 5.16501106e-02f,
  -9.09082443e-02f, -1.17611825e-01f, -4.17906754e-02f, 1.25874400e-01f, 3.34031992e-02f, 1.00173019e-01f, -4.97056693e-02f, 9.71352980e-02f, 1.46752313e-01f, 1.03771009e-01f,
  3.37004885e-02f, 5.87335378e-02f, -1.70839038e-02f, 3.54751050e-02f, 1.07333055e-02f, -1.88445469e-04f, -3.31688300e-02f, 1.45297527e-01f, -3.34073277e-03f, -3.76880765e-02f,
  3.66346650e-02f, 8.49264115e-02f, 1.44998968e-01f, 6.20604791e-02f, -4.03989270e-06f, 1.47901997e-01f, 6.11004010e-02f, 8.23275745e-02f, 1.55780375e-01f, 6.97063580e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  5.10828018e-01f, -1.99548647e-01f, 4.04524282e-02f, 1.72119454e-01f, -3.70223746e-02f, -1.31137535e-01f, -2.12919220e-01f, -7.38210231e-03f, 1.37369454e-01f, 3.43493074e-02f,
  1.48995087e-01f, 3.11392754e-01f, 3.30163270e-01f, 2.62442857e-01f, 1.52219176e-01f, -3.65370661e-02f, -3.78545746e-02f, 2.70392686e-01f, 2.16932341e-01f, 1.93694770e-01f,
  1.03240378e-01f, 1.87077913e-02f, 1.91445902e-01f, -3.93820070e-02f, -1.63714796e-01f, 1.73950121e-01f, 3.79947312e-02f, -3.71561982e-02f, -2.78965547e-03f, -4.31589745e-02f,
  9.21429545e-02f, -1.24480776e-01f, 4.78528626e-02f, 9.29258093e-02f, -1.68009013e-01f, -1.40320078e-01f, -5.24334051e-02f, -9.03760716e-02f, -1.76005855e-01f, -3.18900496e-02f,
  -7.91893974e-02f, 8.38228315e-03f, 1.08163860e-02f, -1.29882336e-01f, -1.99817821e-01f, -2.79586148e-02f, -3.93871889e-02f, 6.34072199e-02f, -9.41303652e-03f, -1.53243579e-02f,
  7.86496177e-02f, -2.90181506e-02f, -4.21027234e-03f, -4.79857288e-02f, -4.91702370e-03f, 3.14890710e-03f, -7.29948059e-02f, 8.11495632e-03f, -2.46929098e-02f, -9.16567072e-02f,
  2.20878050e-01f, 6.04442693e-02f, 1.37532562e-01f, -1.09264970e-01f, -1.08722284e-01f, -1.12132942e-02f, 1.98523477e-02f, 6.38959408e-02f, 6.90700710e-02f, -1.67697715e-03f,
  1.35416955e-01f, 1.70448497e-01f, 4.44169454e-02f, -6.84954152e-02f, 5.38566001e-02f, -3.67640704e-02f, -5.23333885e-02f, 3.46832164e-02f, 4.53933813e-02f, 3.99307944e-02f,
  1.49731159e-01f, 1.25808075e-01f, 3.03900288e-03f, 9.06336680e-02f, 1.19682372e-01f, 9.01431739e-02f, 9.27449092e-02f, -7.83520341e-02f, -3.17489803e-02f, -8.86045843e-02f,
  -1.67603940e-01f, 2.38698110e-01f, 7.96108469e-02f, 6.53271526e-02f, -3.06904688e-02f, -2.54267883e-02f, -1.08785145e-01f, -9.52947065e-02f, -2.61999279e-01f, -9.65202823e-02f,
  -1.12012573e-01f, -3.17080133e-02f, -1.35750711e-01f, -1.11492589e-01f, -3.56164910e-02f, 5.71098588e-02f, 1.90391969e-02f, 7.58508518e-02f, 3.81398797e-02f, 3.96448299e-02f,
  -8.96191970e-03f, -1.90645289e-02f, 3.22553404e-02f, -5.05188778e-02f, -6.75573871e-02f, 2.55937371e-02f, 1.06907934e-02f, 2.30159778e-02f, -2.21231617e-02f, -3.65945846e-02f,
  -1.56185448e-01f, 1.94984332e-01f, 3.08358788e-01f, -1.47372112e-02f, 9.15636271e-02f, -2.59266403e-02f, 4.78372537e-02f, -6.49426430e-02f, -2.07093015e-01f, 5.07025272e-02f,
  9.79937240e-02f, -2.62451798e-01f, 2.10678317e-02f, -3.42569128e-02f, -1.14109635e-01f, 2.41866365e-01f, 1.43107712e-01f, 4.06547934e-02f, -3.21259379e-01f, -2.14554578e-01f,
  -1.35161743e-01f, -5.38519351e-03f, -6.67050853e-02f, -1.41016860e-02f, 3.72843258e-02f, -1.99416816e-01f, 1.00475594e-01f, 1.03533074e-01f, 6.25956059e-02f, 2.13757008e-01f,
  4.53594439e-02f, 1.93990350e-01f, 6.42496487e-03f, -9.86644849e-02f, 4.78557423e-02f, -9.01897922e-02f, -1.14634475e-02f, -1.02515489e-01f, 5.36235161e-02f, 2.49485485e-03f,
  3.33438553e-02f, 5.26692383e-02f, 8.79916102e-02f, -1.56230018e-01f, -1.08523816e-01f, -2.48593777e-01f, -1.79677203e-01f, -1.24089278e-01f, -5.21131344e-02f, -2.28758842e-01f,
  9.01375040e-02f, 2.76267398e-02f, 1.14862755e-01f, 6.51793703e-02f, 1.33372117e-02f, -3.85648757e-02f, 2.63014119e-02f, 2.70377728e-03f, -1.05428614e-01f, -5.26053384e-02f,
  -5.53946123e-02f, -1.70521252e-02f, 6.13642074e-02f, 1.65021289e-02f, 4.46333177e-02f, 1.74629539e-02f, 1.53849885e-01f, -1.18735410e-01f, -6.03093021e-02f, -1.61163852e-01f,
  -1.90550052e-02f, -1.05840303e-01f, -6.43263236e-02f, 1.61819905e-01f, -7.33957514e-02f, 3.56290862e-02f, 2.89169420e-02f, -4.34441045e-02f, 2.17319205e-02f, 6.86895102e-02f,
  -1.36132255e-01f, 1.01868451e-01f, 8.59251842e-02f, -1.47022575e-01f, 1.35341942e-01f, 7.23116621e-02f, -2.81541403e-02f, -6.74405023e-02f, 4.90026586e-02f, -4.99983691e-02f,
  -2.05172628e-01f, 5.37331216e-02f, 4.62677702e-02f, -6.30583167e-02f, -9.94488224e-02f, 9.75135248e-03f, 2.87603512e-02f, -7.47557590e-03f, 2.03610454e-02f, -1.95441139e-03f,
  5.03146648e-02f, 1.97119005e-02f, 1.94462240e-02f, -8.82760212e-02f, -1.22921303e-01f, -8.47985595e-02f, 2.79191299e-03f, -6.69748113e-02f, -1.19431898e-01f, -1.46439269e-01f,
  2.67543737e-02f, -3.22097957e-01f, -1.78796440e-01f, -1.90749280e-02f, -1.07319064e-01f, -1.48739979e-01f, -1.48414388e-01f, -2.11431190e-01f, -6.18742667e-02f, -1.42344162e-01f,
  -7.15500355e-01f, 8.33148733e-02f, -5.23027241e-01f, -3.00244302e-01f, 7.99373984e-02f, 1.84867531e-01f, 5.37987292e-01f, 3.21343631e-01f, -3.06449272e-02f, 7.52532780e-02f,
  -1.44817218e-01f, -1.26292914e-01f, -1.43704832e-01f, -4.35471646e-02f, 1.35052249e-01f, 1.60881639e-01f, -9.64910239e-02f, -2.98556864e-01f, 7.02160895e-02f, 3.08302164e-01f,
  3.95971537e-01f, 1.33449864e-02f, -1.81095406e-01f, 3.56976092e-02f, 2.02381499e-02f, 3.19020487e-02f, -2.33430684e-01f, -1.92287803e-01f, 3.70075591e-02f, -1.64688855e-01f,
  -3.79454255e-01f, -3.87993425e-01f, 1.23255499e-01f, -9.63755846e-02f, -1.88327953e-01f, -1.33028969e-01f, 7.90638924e-02f, -1.15120478e-01f, -9.97646302e-02f, -3.92770581e-02f,
  -2.60599613e-01f, -2.54502278e-02f, -2.65755743e-01f, 6.42953515e-02f, -3.91572379e-02f, 7.15129450e-02f, -9.38053280e-02f, -1.43161252e-01f, -2.74636418e-01f, -1.29308343e-01f,
  1.56665638e-01f, -1.47215158e-01f, -2.80400097e-01f, 1.10618196e-01f, -1.24732882e-01f, -2.41681024e-01f, 7.04827979e-02f, -6.70570284e-02f, -1.91537235e-02f, 2.49930900e-02f,
  1.00378051e-01f, -4.75312918e-02f, 7.57059157e-02f, 1.48618519e-01f, 1.93025842e-02f, -9.53060389e-02f, -7.34965280e-02f, -9.92763136e-03f, 4.83252518e-02f, -1.17661506e-01f,
  -5.35825528e-02f, 6.68365974e-03f, 1.55028217e-02f, -8.45521837e-02f, -3.63819278e-03f, -2.15094518e-02f, -3.76832820e-02f, 1.39484063e-01f, 1.09111276e-02f, 7.49242976e-02f,
  -3.76287326e-02f, -2.21046079e-02f, -4.40477543e-02f, 1.33727610e-01f, -2.95793302e-02f, -4.08840403e-02f, -5.94109995e-03f, 3.09820492e-02f, 5.58082201e-02f, -4.06015739e-02f,
  4.35822420e-02f, 5.55134565e-02f, -1.03739046e-01f, 1.33146122e-01f, -1.10689886e-01f, 4.19257296e-04f, -8.31563771e-02f, 2.84641571e-02f, -2.04012822e-02f, 7.04682618e-02f,
  1.28265277e-01f, 9.70824584e-02f, -1.26612246e-01f, 7.30674267e-02f, -7.13819191e-02f, 5.73030338e-02f, 1.23909153e-01f, -1.44417789e-02f, 1.79458000e-02f, 5.55557385e-02f,
  6.11967072e-02f, 9.28555205e-02f, -2.04530954e-02f, 1.03865661e-01f, 2.81944033e-02f, -5.01751229e-02f, 3.43248248e-02f, 1.75861612e-01f, 1.43134579e-01f, 5.24849951e-01f,
  2.72910833e-01f, -3.20216753e-02f, 1.91205755e-01f, 2.21797481e-01f, -3.33912581e-01f, -4.40283775e-01f, -5.33988416e-01f, -4.51933853e-02f, 2.15249017e-01f, -2.85482377e-01f,
  -2.37744316e-01f, -9.41317976e-02f, 8.45889449e-02f, -1.18029974e-01f, -2.48994902e-01f, -2.60726005e-01f, 3.97065133e-02f, -4.87358570e-02f, -2.86873937e-01f, -5.05438030e-01f,
  -2.11178899e-01f, 1.31275207e-01f, 2.01270640e-01f, 8.05395376e-03f, 4.14849259e-02f, 9.90782455e-02f, 2.86694974e-01f, 8.09589997e-02f, -1.00628428e-01f, 4.66044946e-03f,
  -8.51103738e-02f, -4.86247875e-02f, -2.31573150e-01f, -7.18312105e-03f, -5.01946593e-03f, -1.95450649e-01f, -2.94920385e-01f, 2.96433121e-02f, 3.01535800e-02f, -1.70532130e-02f,
  -1.49767950e-01f, -2.16868192e-01f, -9.18233767e-02f, -1.25061139e-01f, -8.30478370e-02f, -2.26184279e-01f, 1.63934991e-01f, 1.47679090e-01f, 1.21284619e-01f, -6.70639500e-02f,
  -2.29203761e-01f, -2.86888748e-01f, 3.12490929e-02f, 5.14114983e-02f, 6.41821772e-02f, -3.23440472e-04f, -5.93576729e-02f, 4.27694339e-03f, 1.31841719e-01f, 1.19891860e-01f,
  -1.33937165e-01f, -8.70893002e-02f, -1.10603951e-01f, 1.28132790e-01f, -1.31769236e-02f, 2.53587812e-02f, -4.83253933e-02f, -9.36882049e-02f, -1.38705462e-01f, -9.42143351e-02f,
  1.58758029e-01f, 8.60698223e-02f, 6.10621236e-02f, 4.45662215e-02f, 2.93187220e-02f, -1.13194473e-01f, -9.83537212e-02f, -9.57803279e-02f, 1.03713144e-02f, 2.21575759e-02f,
  2.60556433e-02f, -6.80830851e-02f, 3.56307365e-02f, 8.05612504e-02f, 4.99660242e-03f, -4.03026305e-02f, -3.15013193e-02f, 9.11782384e-02f, 3.19730006e-02f, -8.04325640e-02f,
  1.88482806e-01f, -3.19740102e-02f, -1.30733639e-01f, -1.56142443e-01f, -3.51812765e-02f, 9.53965485e-02f, -3.78042012e-02f, -4.63236198e-02f, 5.77292107e-02f, -1.71662703e-01f,
  -2.14093462e-01f, -1.86206505e-01f, 1.37843415e-01f, -7.22804293e-02f, -9.26962271e-02f, -4.58290614e-02f, -1.57644302e-01f, -1.11711346e-01f, -5.97892851e-02f, 5.89824319e-02f,
  1.19512685e-01f, -2.05255568e-01f, -5.56630827e-02f, 4.07329388e-02f, -3.25653031e-02f, -1.66182756e-01f, -4.51263040e-02f, 6.28200453e-03f, -6.41276613e-02f, 2.19683964e-02f,
  5.26798368e-01f, 7.61897936e-02f, 4.44089741e-01f, 3.34070623e-01f, 2.84323096e-01f, 1.65478110e-01f, 2.27189392e-01f, -2.69514658e-02f, -7.73161475e-04f, 1.53468251e-01f,
  2.78870255e-01f, 8.57035667e-02f, 5.38333505e-02f, 1.63678572e-01f, 1.45931214e-01f, -5.43828756e-02f, -3.99188101e-02f, 8.59880671e-02f, 1.98117793e-01f, 3.71999368e-02f,
  -1.15206741e-01f, -8.65140185e-03f, 1.34605989e-01f, 6.39185831e-02f, 2.37458032e-02f, 1.09016411e-01f, 7.30049014e-02f, 1.47917524e-01f, 1.49020895e-01f, -5.59788421e-02f,
  5.63629448e-01f, 2.73416936e-01f, -8.76941383e-02f, 2.60417294e-02f, -2.19898596e-02f, -1.75760463e-01f, 1.04947850e-01f, 9.69605707e-03f, -1.12165384e-01f, -9.54836234e-02f,
  -4.22245450e-02f, 4.29434627e-02f, -9.55512282e-03f, 2.73502618e-02f, -1.34404212e-01f, -7.02662095e-02f, -2.12081090e-01f, -5.68226054e-02f, 1.30250156e-01f, 8.07270259e-02f,
  -1.89751964e-02f, 4.12551574e-02f, 1.81679010e-01f, -1.04543909e-01f, 6.52240217e-02f, 1.00766830e-01f, 8.91431123e-02f, -1.21819237e-02f, 2.94378623e-02f, -3.76622453e-02f,
  2.75743902e-01f, -2.47977804e-02f, 1.58291236e-01f, 1.51853815e-01f, -5.56981750e-03f, -1.01239964e-01f, 9.72248614e-02f, -3.95382456e-02f, -3.99048850e-02f, -1.10280305e-01f,
  -4.57243733e-02f, 1.51538476e-01f, 1.40220642e-01f, 1.26019791e-01f, 1.46816060e-01f, 2.40457747e-02f, -6.19896688e-03f, 1.74033433e-01f, 7.47244880e-02f, 1.35145327e-02f,
  1.08340465e-01f, -1.88317485e-02f, 1.24334291e-01f, 7.58954231e-03f, 8.37943330e-02f, 5.03784195e-02f, 1.87458731e-02f, 8.89495835e-02f, -1.01568485e-02f, -1.08641893e-01f,
  1.10233046e-01f, 3.28508168e-01f, -2.01945491e-02f, 9.41656306e-02f, -3.99218202e-02f, -1.43591404e-01f, 1.13837853e-01f, 1.40577540e-01f, 2.53967587e-02f, 6.07682392e-02f,
  -2.17007995e-02f, 1.55885639e-02f, 4.94118445e-02f, -1.65554062e-02f, -1.06148481e-01f, -8.96284580e-02f, -4.92924750e-02f, 6.06164299e-02f, 1.44443050e-01f, -1.33665986e-02f,
  -1.46695659e-01f, -6.39017671e-02f, 1.42945454e-01f, 7.58375674e-02f, -2.53058877e-02f, 6.38500825e-02f, 5.03590666e-02f, -3.32420617e-02f, 1.32174730e-01f, -1.72765702e-01f,
  -5.89442551e-01f, 9.98915657e-02f, 5.51185571e-02f, 5.18470164e-03f, 4.44446392e-02f, 5.88444173e-02f, -4.36462536e-02f, 5.51504493e-02f, 3.52527723e-02f, 2.94562280e-02f,
  6.46790117e-02f, -8.20463076e-02f, -1.10214129e-01f, -5.24223931e-02f, 3.03139891e-02f, -1.95566919e-02f, -1.00127272e-02f, -5.35470806e-02f, -1.49866641e-01f, -6.68309182e-02f,
  -1.03604026e-01f, -1.77274402e-02f, -1.31786823e-01f, -1.22544859e-02f, -6.91017956e-02f, -1.39323130e-01f, -5.24003059e-02f, 1.32277176e-01f, 4.46051806e-02f, 5.08809127e-02f,
  3.49760115e-01f, 4.31260243e-02f, 4.74835820e-02f, 1.24807194e-01f, 9.43866745e-02f, 2.66285916e-03f, 4.96671312e-02f, -3.23115960e-02f, 8.00408050e-03f, 8.48071426e-02f,
  3.59086171e-02f, -5.18550351e-03f, -3.93659920e-02f, -2.14776583e-02f, 2.13332716e-02f, 9.59387049e-02f, 3.06806136e-02f, -8.02848767e-03f, 2.29516486e-03f, 8.99225697e-02f,
  2.15034131e-02f, 2.39627752e-02f, 5.55358417e-02f, 3.70751992e-02f, 4.27579917e-02f, 3.97615656e-02f, 1.01795346e-01f, -1.40626002e-02f, -5.05765108e-03f, -1.59316994e-02f,
  2.74159163e-02f, -1.38316050e-01f, 9.88268703e-02f, 1.20298944e-01f, -8.45944416e-03f, -1.28279552e-01f, 2.68266927e-02f, -6.65087700e-02f, -6.90124109e-02f, -7.98215941e-02f,
  9.10339598e-03f, -2.05934085e-02f, -2.36236416e-02f, 1.23368029e-03f, 1.32717967e-01f, 1.10752165e-01f, 2.51531340e-02f, 1.07345268e-01f, 8.65884647e-02f, -3.49041000e-02f,
  -1.35407802e-02f, -3.90050001e-02f, -8.13523307e-02f, -1.83661410e-03f, 6.59470335e-02f, 5.22703938e-02f, 3.22379321e-02f, 8.68984535e-02f, 5.83330318e-02f, 2.99387816e-02f,
  4.48402137e-01f, 3.12099177e-02f, -1.67691723e-01f, 6.96011111e-02f, 6.89485148e-02f, -4.59009083e-03f, -1.76981818e-02f, 1.77707732e-01f, 1.25781864e-01f, 1.28427133e-01f,
  1.48051158e-01f, -6.76121563e-02f, -2.79750936e-02f, 2.82253581e-03f, -2.09463425e-02f, 8.39649513e-03f, 5.87561615e-02f, 7.23889396e-02f, 1.05046928e-01f, 1.96015626e-01f,
  -2.22867611e-03f, 4.31506820e-02f, 1.22558810e-01f, 1.07365832e-01f, 4.68940586e-02f, 3.74917313e-02f, -6.45329505e-02f, -2.48002373e-02f, 6.90103993e-02f, -1.91322863e-01f,
  -1.18659243e-01f, 2.58236360e-02f, 3.42823192e-02f, -7.76515231e-02f, 2.86553711e-01f, -7.24988282e-02f, -2.92398810e-01f, -2.56333351e-01f, 1.02580473e-01f, 8.93270001e-02f,
  3.25132579e-01f, 2.13423342e-01f, -7.94327855e-02f, -1.97665229e-01f, -6.14095449e-01f, -4.18683261e-01f, -2.59753674e-01f, -3.58475804e-01f, -2.60920525e-01f, -6.42055646e-02f,
  1.93572491e-01f, -1.19480513e-01f, -1.84421644e-01f, 6.32735062e-03f, 1.83036238e-01f, 1.94491893e-01f, 1.71363965e-01f, 1.29278243e-01f, 1.77291706e-01f, 1.79204807e-01f,
  -7.57070631e-02f, 6.74379468e-02f, 2.99681202e-02f, 1.72274429e-02f, 1.08257897e-01f, -7.59139135e-02f, -1.81926321e-02f, -1.17363445e-02f, 1.29847661e-01f, 1.04275271e-02f,
  2.88320392e-01f, 6.36969879e-02f, 4.70325388e-02f, -2.84728166e-02f, -3.51777077e-02f, -2.00273886e-01f, -5.35497218e-02f, -2.84252018e-01f, -2.52580673e-01f, -5.31360246e-02f,
  5.78006916e-03f, 1.73979029e-01f, -6.78502843e-02f, -4.29185890e-02f, -2.40275204e-01f, 7.26511255e-02f, 4.03420068e-02f, -2.94971187e-03f, -4.59728576e-02f, -1.15838945e-01f,
  9.44495723e-02f, 1.55066093e-03f, 2.52966173e-02f, -1.58181898e-02f, -4.57693264e-02f, 1.17851153e-01f, 6.58548996e-02f, -5.28253354e-02f, 2.56352965e-03f, 2.53679231e-03f,
  -2.70505995e-02f, 1.71623766e-01f, -1.39363287e-02f, 1.95729965e-03f, 6.51418939e-02f, 2.34623868e-02f, 1.31708696e-01f, -1.55540675e-01f, -1.76907168e-03f, -1.88602637e-02f,
  -2.77556516e-02f, 7.54813896e-03f, 1.07549652e-01f, -1.29387766e-01f, 5.80886053e-03f, 3.69426943e-02f, 1.25268295e-01f, 8.57160464e-02f, -1.28886867e-02f, 5.07198125e-02f,
  -1.27759418e-02f, 8.79173651e-02f, 1.62864532e-02f, -2.27966443e-01f, -2.73642447e-02f, 9.54933986e-02f, 8.49985555e-02f, -5.36062196e-03f, 1.18403375e-01f, -1.70300841e-01f,
  -1.91370174e-02f, -2.17106771e-02f, 4.40163091e-02f, -9.99053121e-02f, 9.83755221e-04f, 9.11216587e-02f, -1.25998259e-01f, -1.39101129e-02f, -1.23266511e-01f, 6.55559227e-02f,
  -1.64419055e-01f, -1.96611896e-01f, -2.80030966e-01f, -1.13256633e-01f, -8.81513953e-03f, -1.04401268e-01f, -4.90908138e-02f, 1.15216933e-01f, -1.85554668e-01f, -2.65803427e-01f,
  -3.43974620e-01f, 1.84142262e-01f, 5.48584387e-03f, 1.96723536e-01f, 1.61340788e-01f, 2.41391957e-01f, 3.32544267e-01f, 3.27604026e-01f, 1.26490384e-01f, 1.88044552e-03f,
  1.22161917e-02f, 6.07736818e-02f, 1.20985046e-01f, 1.39905080e-01f, 1.01447143e-01f, 2.43794635e-01f, 2.24742949e-01f, 2.47788616e-02f, 3.80149409e-02f, 7.71868676e-02f,
  2.18507215e-01f, 1.38389438e-01f, -1.46078002e-02f, 8.14671069e-02f, 1.37839854e-01f, 4.89197671e-02f, 1.20399021e-01f, 1.28624484e-01f, 6.75968602e-02f, 2.75074542e-01f,
  -3.22997212e-01f, -8.65825862e-02f, -5.87781630e-02f, 5.70753776e-02f, -1.07891679e-01f, 6.26868496e-05f, 8.57751444e-02f, 1.06142880e-02f, -8.08877777e-03f, -6.97406568e-03f,
  -8.37776139e-02f, -4.97609824e-02f, 5.33109494e-02f, 4.26362529e-02f, -1.14789136e-01f, -1.35006651e-01f, 6.87117279e-02f, 2.32512623e-01f, 1.36978149e-01f, 6.36841804e-02f,
  5.10514900e-02f, 1.19871177e-01f, 7.36298785e-02f, 2.28235405e-02f, 6.39540628e-02f, -3.27263847e-02f, -1.79197602e-02f, 3.76563519e-02f, 6.47843182e-02f, 6.07495084e-02f,
  1.23557664e-01f, 1.34933339e-02f, -7.54008591e-02f, -7.85782933e-03f, 1.76324230e-02f, -9.25388653e-04f, -1.56633183e-01f, -5.85808158e-02f, -1.57316811e-02f, 4.07825857e-02f,
  9.86137688e-02f, 1.37473077e-01f, 7.51909092e-02f, -8.62318352e-02f, -2.34453037e-01f, 4.19838615e-02f, 5.66639528e-02f, -7.18048261e-03f, -8.97396058e-02f, -2.68174484e-02f,
  -7.30902031e-02f, 5.98970391e-02f, -4.92872596e-02f, 3.17524336e-02f, 2.61554820e-03f, 4.70064729e-02f, 3.85343581e-02f, 1.20156854e-01f, 3.22476402e-02f, -2.62855552e-02f,
  1.63715467e-01f, -4.86077406e-02f, -3.13989632e-02f, 9.63473767e-02f, -1.81842610e-01f, -1.95053220e-01f, -1.38786346e-01f, -1.66955702e-02f, 1.66182574e-02f, -1.55029539e-02f,
  -1.55542538e-01f, -2.04616398e-01f, -2.98029762e-02f, -3.45567539e-02f, -1.43817261e-01f, -2.66696841e-01f, -1.15550809e-01f, 6.50947914e-02f, 1.18400171e-01f, -3.68290506e-02f,
  4.29000258e-02f, -1.86246578e-02f, -3.56570892e-02f, 3.93374823e-02f, -1.05724394e-01f, -1.26399606e-01f, -1.58675730e-01f, -1.40771836e-01f, -6.74703121e-02f, 4.51973416e-02f,
  -7.04034150e-01f, 6.50346885e-03f, -3.13164979e-01f, -4.75543253e-02f, 3.22982550e-01f, 5.23138531e-02f, -8.01018924e-02f, -1.64814293e-01f, 8.16237852e-02f, 1.05445929e-01f,
  1.24549344e-01f, 2.82317162e-01f, 1.94744110e-01f, 2.43227363e-01f, -5.06385276e-03f, 1.20945267e-01f, 1.43964350e-01f, -5.72319478e-02f, -1.86359495e-01f, 1.53558448e-01f,
  2.08375946e-01f, -8.30005556e-02f, -4.39481884e-01f, -2.25459095e-02f, 7.63798505e-02f, -3.05434931e-02f, -5.99693367e-03f, -3.80564667e-02f, 9.33224037e-02f, 1.31516978e-01f,
  -4.49373238e-02f, -2.70566076e-01f, 1.78612784e-01f, 9.71964523e-02f, -9.82629061e-02f, -2.68030941e-01f, -9.88911986e-02f, -1.88666701e-01f, -2.83896830e-02f, -1.94975473e-02f,
  -3.93952914e-02f, -3.45455222e-02f, 9.90742594e-02f, -5.25823571e-02f, 7.29668699e-03f, -1.35938555e-01f, -3.74549702e-02f, -2.33061135e-01f, -2.32203692e-01f, -1.05479382e-01f,
  2.08056569e-01f, 2.94929147e-01f, -9.40244645e-02f, 2.97396332e-02f, -1.30943656e-01f, 5.78029715e-02f, -2.05928922e-01f, -1.74578711e-01f, -2.52563536e-01f, -2.53850251e-01f,
  -3.49958055e-02f, 2.42371671e-02f, -3.09842248e-02f, -7.28216246e-02f, 1.08621716e-02f, -7.80469133e-03f, 2.09614541e-02f, 1.66980565e-01f, 2.89008897e-02f, -1.07025549e-01f,
  -2.30187904e-02f, 7.91417137e-02f, 4.82001528e-03f, -9.64083476e-04f, -3.84995947e-03f, 3.04900133e-03f, -2.77809948e-02f, -1.17783457e-01f, -6.99960142e-02f, 6.55319691e-02f,
  1.10866249e-01f, 1.43899601e-02f, 1.34683624e-01f, -9.25441384e-02f, 1.33145065e-03f, 1.06471732e-01f, 5.52607467e-04f, -5.55065684e-02f, -1.32424459e-01f, -2.83162799e-02f,
  -1.06555268e-01f, 3.82559723e-03f, -5.64931333e-03f, -5.27114198e-02f, -1.01188071e-01f, -2.83370595e-02f, 9.37650353e-02f, 6.22863211e-02f, 8.43090117e-02f, -1.29799783e-01f,
  -1.20767944e-01f, -4.00149636e-02f, 2.11109146e-02f, 4.48556133e-02f, -1.26017192e-02f, 1.27484556e-02f, -4.11038697e-02f, 1.04913704e-01f, 6.27806634e-02f, -4.69130948e-02f,
  -1.78627506e-01f, -2.91645080e-02f, 8.09396151e-03f, -9.04342458e-02f, 4.22678255e-02f, -6.33805841e-02f, -6.90362602e-02f, -1.89250752e-01f, -2.34753758e-01f, -3.83388758e-01f,
  -4.27676201e-01f, 3.01480770e-01f, 2.02870026e-01f, -3.02730054e-01f, 1.42055675e-01f, 3.47008109e-01f, 4.16669160e-01f, 2.35420942e-01f, -1.85060814e-01f, -1.21109970e-02f,
  5.55714332e-02f, -2.44216636e-01f, -1.23429656e-01f, -6.59020469e-02f, 1.63381934e-01f, 3.05991679e-01f, 1.14570811e-01f, -1.16408944e-01f, -2.42823243e-01f, 9.20586437e-02f,
  2.19966676e-02f, -1.54966027e-01f, -2.85762489e-01f, -2.31633291e-01f, -8.65516439e-02f, -3.53939861e-01f, -5.72254546e-02f, 1.68999478e-01f, 2.36276895e-01f, -6.67685866e-02f,
  -1.48973837e-01f, 9.45377573e-02f, -6.35235459e-02f, -2.67561048e-01f, -1.74372289e-02f, -8.72179791e-02f, -2.29260772e-02f, -4.47058119e-02f, -8.02648589e-02f, 1.59177855e-02f,
  -6.19666502e-02f, -4.40865941e-02f, -1.81532018e-02f, -8.10207352e-02f, -1.00683812e-02f, 6.13138080e-03f, 2.67227907e-02f, 2.06610709e-02f, 5.42306639e-02f, -5.68569601e-02f,
  3.73617783e-02f, 1.70981437e-01f, 1.85672969e-01f, 1.61317989e-01f, 9.93733704e-02f, -1.24421723e-01f, 7.86842257e-02f, -8.98750871e-02f, 6.14420362e-02f, -1.77399263e-01f,
  1.73976440e-02f, -2.06326563e-02f, 1.11980990e-01f, -2.67563239e-02f, 2.04007402e-02f, -2.44032033e-02f, 2.45445408e-02f, 4.00387570e-02f, 6.21156767e-02f, 5.32611199e-02f,
  7.65966102e-02f, 3.18131633e-02f, 1.73819680e-02f, 1.06786206e-01f, -3.76324393e-02f, -9.41304769e-03f, 9.68708545e-02f, -6.14678375e-02f, 2.03159563e-02f, 4.17029411e-02f,
  -1.05848983e-02f, 5.24472557e-02f, -1.75384581e-02f, -5.48860282e-02f, 4.54219878e-02f, -3.55215510e-03f, -1.47487730e-01f, -5.25324140e-03f, -9.40415114e-02f, 5.34942150e-02f,
  -2.21920297e-01f, 3.62059504e-01f, -2.28428453e-01f, -2.88644200e-03f, 1.78552456e-02f, -2.68706623e-02f, 1.62249673e-02f, -4.68515716e-02f, 4.86675799e-02f, 3.02544665e-02f,
  1.81599353e-02f, 8.89264345e-02f, 8.17591324e-02f, -1.78309102e-02f, 2.82767881e-03f, -1.86980236e-04f, 5.03055379e-02f, 4.01937822e-03f, -5.14741540e-02f, -4.50421982e-02f,
  1.14215292e-01f, 5.78630976e-02f, -1.74245730e-01f, -4.13781358e-03f, 1.03897369e-02f, -1.34962305e-01f, -8.44505429e-03f, -6.97670579e-02f, -4.33554053e-02f, -2.95835674e-01f,
  1.20787501e-01f, 1.52824625e-01f, 9.08596069e-02f, 1.38210088e-01f, 2.64346391e-01f, 2.95778006e-01f, 4.63639289e-01f, 2.83309877e-01f, 1.53837204e-01f, 5.64236343e-02f,
  1.74633488e-02f, -1.68913782e-01f, -1.26697168e-01f, -1.18531004e-01f, 3.64663042e-02f, 1.19397501e-02f, 1.09524645e-01f, -5.66248931e-02f, -9.31621939e-02f, 1.03551678e-01f,
  1.44971624e-01f, 2.36622572e-01f, 1.12436906e-01f, 9.45158079e-02f, -2.70239357e-02f, -3.44673023e-02f, 1.22228391e-01f, -4.95363660e-02f, -6.24585226e-02f, -5.81686012e-02f,
  -4.37883943e-01f, 9.56234485e-02f, -1.51453525e-01f, -4.82103862e-02f, -1.29341230e-01f, 2.26049237e-02f, -2.18977244e-03f, -7.29330629e-02f, -7.52444938e-02f, 6.33784384e-02f,
  -4.89621051e-02f, -3.76173593e-02f, 1.81291308e-02f, 8.15107301e-02f, -3.51329297e-02f, -1.08318701e-01f, -5.19176535e-02f, 9.47707295e-02f, 1.09800071e-01f, -2.04088673e-01f,
  -7.80336931e-02f, 7.77487159e-02f, 1.07212715e-01f, 1.53443277e-01f, 6.72282651e-02f, -5.34902140e-02f, -5.12196533e-02f, -9.51169878e-02f, 9.17260349e-02f, 7.31028095e-02f,
  6.05609156e-02f, 4.01936769e-02f, 6.71364665e-02f, 1.20452523e-01f, 6.30187169e-02f, -7.95656070e-02f, -2.04385608e-03f, 8.64695460e-02f, 1.07137538e-01f, 1.48231611e-01f,
  1.78075433e-02f, 8.13329294e-02f, 1.48521423e-01f, 1.84027091e-01f, -7.73187447e-03f, -3.69218132e-03f, 6.07152432e-02f, -2.08716909e-03f, 3.10751144e-02f, 4.85812537e-02f,
  8.63892734e-02f, 1.54612660e-01f, 3.34610976e-02f, 7.84803480e-02f, 9.76857916e-02f, 1.28095448e-02f, 2.38166507e-02f, 1.11917071e-02f, 7.71926939e-02f, 1.38675526e-01f,
  1.46004662e-01f, 8.41101259e-02f, -1.07719332e-01f, -5.75558469e-03f, -2.15373747e-02f, -1.84611268e-02f, 5.75233772e-02f, -2.95973122e-02f, -6.51481524e-02f, 4.17258032e-02f,
  5.24331778e-02f, -3.14967632e-02f, 3.22594009e-02f, 1.22463055e-01f, 9.84001383e-02f, 5.23265917e-03f, -7.36265332e-02f, 6.77823846e-04f, -4.28892858e-02f, -1.28594995e-01f,
  1.77022293e-02f, 1.51925310e-01f, 1.78532943e-01f, 1.39560327e-01f, 1.59103069e-02f, -3.05722002e-02f, 4.44285162e-02f, -3.24482657e-02f, -9.78460349e-03f, 2.06919193e-01f,
  1.01169564e-01f, -3.87188524e-01f, -2.67424464e-01f, -1.14872679e-01f, -3.66955400e-01f, -2.10391298e-01f, -2.59992838e-01f, -3.45955160e-03f, 2.56884750e-02f, -4.23507541e-01f,
  -1.77550301e-01f, 7.06947595e-02f, 1.11536264e-01f, 1.56641677e-01f, 1.77107483e-01f, -3.24537247e-01f, -2.99086601e-01f, 1.39196515e-01f, 2.05465123e-01f, 1.44253839e-02f,
  -1.03339240e-01f, -1.18646175e-02f, 3.08278769e-01f, 1.97820067e-01f, -3.37218374e-01f, 1.12684434e-02f, -1.95211127e-01f, -1.06310412e-01f, -1.78718641e-01f, -4.09545749e-01f,
  -2.63702571e-01f, -1.06278524e-01f, 1.34927230e-02f, 2.15471283e-01f, -1.49534836e-01f, 8.28659758e-02f, -4.87879030e-02f, -1.40311569e-02f, -1.49434209e-01f, -5.78373410e-02f,
  -1.07298695e-01f, 2.15196237e-02f, 1.30701303e-01f, -4.23146263e-02f, -2.59201583e-02f, -4.12493832e-02f, -6.75027221e-02f, 1.13903284e-01f, 1.09056965e-01f, -8.75083730e-02f,
  -5.77498339e-02f, -1.12919711e-01f, 9.39328596e-02f, -3.25453691e-02f, 6.17551208e-02f, 3.90810221e-02f, -1.58390194e-01f, -2.55764067e-01f, -4.73001562e-02f, -4.08868164e-01f,
  -3.37948613e-02f, -8.41500610e-02f, -5.26415370e-03f, 3.45827341e-02f, 4.32929164e-03f, -5.37509918e-02f, -7.31250197e-02f, 5.56686372e-02f, 3.37939635e-02f, -4.99897636e-02f,
  2.54859086e-02f, -3.92081076e-03f, 4.59930263e-02f, -7.42811188e-02f, -7.97116607e-02f, 7.03705177e-02f, -4.41004382e-03f, 4.11577411e-02f, 3.96487415e-02f, -3.49141704e-03f,
  1.06276702e-02f, -1.57663412e-02f, -7.69027472e-02f, 4.95464243e-02f, -1.32055879e-02f, -4.24528904e-02f, -7.76629299e-02f, -2.71290652e-02f, 2.98409779e-02f, 2.95970403e-03f,
  2.12398946e-01f, 2.18726367e-01f, -1.20805882e-01f, 9.98703465e-02f, 7.31507614e-02f, 1.08265895e-02f, -2.37696078e-02f, 3.37836109e-02f, 6.16472103e-02f, -4.40295748e-02f,
  1.09402547e-02f, -8.71279016e-02f, 1.88014898e-02f, 2.43499856e-02f, -3.82427089e-02f, -4.12859917e-02f, -1.81896351e-02f, 1.75297111e-02f, -3.76425944e-02f, -1.12082876e-01f,
  9.50277299e-02f, -4.14565615e-02f, 6.71745390e-02f, -3.47382426e-02f, -3.83214429e-02f, 1.30563065e-01f, -1.10370547e-01f, -6.95137903e-02f, 4.10882868e-02f, -6.12510741e-02f,
  -2.22556107e-02f, 1.77792490e-01f, -3.87426347e-01f, 3.70724410e-01f, 3.19143236e-01f, -2.63475021e-03f, 1.47583568e-02f, -6.13273978e-02f, 4.79995348e-02f, 1.18133433e-01f,
  1.81525007e-01f, 1.58761397e-01f, 1.56334952e-01f, 1.40934423e-01f, -6.01661690e-02f, 9.66886729e-02f, 1.76577285e-01f, -1.80974439e-01f, -1.66220188e-01f, -7.99216330e-02f,
  3.08983624e-01f, 1.31355271e-01f, -1.82961509e-01f, -1.47688746e-01f, 8.87724757e-02f, 1.85518578e-01f, -2.99352724e-02f, 1.37262464e-01f, -3.66992354e-02f, 2.32547805e-01f,
  -2.13544995e-01f, -1.08368926e-01f, -1.44107997e-01f, 5.06841764e-02f, -2.30137005e-01f, -1.57282442e-01f, -1.54145271e-01f, -2.40588471e-01f, -1.92904472e-01f, -8.91918316e-02f,
  1.12145126e-01f, -1.78376615e-01f, 9.91724059e-02f, 7.21370876e-02f, -2.63540260e-02f, -3.71337421e-02f, -2.07042351e-01f, -2.30681926e-01f, -2.66018569e-01f, -3.24640185e-01f,
  2.11792275e-01f, -1.37457922e-02f, -1.79535314e-01f, -1.24395616e-01f, -2.49822915e-01f, -1.61818206e-01f, -1.92688406e-01f, -7.31461856e-04f, -3.54715288e-01f, -6.85608340e-03f,
  -5.63191101e-02f, -3.30379605e-02f, -7.92230070e-02f, -1.07261784e-01f, 1.08707219e-01f, 1.10364527e-01f, 8.57591853e-02f, 3.35310474e-02f, 3.12401708e-02f, -1.35316625e-01f,
  -4.51175869e-02f, 8.25522020e-02f, -9.62881297e-02f, -2.32512020e-02f, -4.70732413e-02f, 6.55249208e-02f, -1.01819247e-01f, -6.93942979e-02f, -1.50217399e-01f, -8.82333294e-02f,
  6.92405850e-02f, -3.65246236e-02f, -8.38942267e-03f, -1.28324509e-01f, -4.10855040e-02f, -4.93815616e-02f, 3.96520011e-02f, -5.59225073e-03f, 6.73711300e-02f, -8.01949129e-02f,
  2.60160029e-01f, -2.79239728e-03f, -1.32926956e-01f, 4.37841341e-02f, 3.59990895e-02f, -4.52494510e-02f, -2.93597784e-02f, -5.36314845e-02f, -1.36293005e-03f, -9.39858109e-02f,
  -1.14571534e-01f, 2.86733974e-02f, 1.86945736e-01f, -5.58875240e-02f, -3.61543037e-02f, 1.48626745e-01f, -2.85374019e-02f, -1.63749757e-03f, -3.20906169e-03f, -1.50469569e-02f,
  -2.04032492e-02f, 9.61914882e-02f, 2.71108504e-02f, 1.01830997e-01f, 7.80638084e-02f, 6.22798167e-02f, 9.93848965e-02f, -5.19294441e-02f, -1.31495565e-01f, 2.87033170e-02f,
  3.13875750e-02f, 2.94295430e-01f, -4.10798669e-01f, 1.73956171e-01f, 1.94996715e-01f, -1.56128570e-01f, 3.40161547e-02f, -1.34237021e-01f, -4.97207977e-02f, 1.41134197e-02f,
  -6.98657800e-03f, -2.35398263e-02f, 6.81847557e-02f, -2.06428859e-02f, -1.58210412e-01f, 7.55731314e-02f, 1.78434357e-01f, -1.48480549e-01f, -3.43748242e-01f, -1.17234051e-01f,
  2.37971127e-01f, 1.34449765e-01f, -1.66419566e-01f, -1.55637890e-01f, 1.72212601e-01f, -1.59284361e-02f, -4.98729162e-02f, 1.00781970e-01f, -8.07543546e-02f, 3.54270250e-01f,
  -2.32136011e-01f, -2.76234001e-01f, -2.38998890e-01f, 6.04408234e-02f, 4.62247841e-02f, 2.82317176e-02f, -4.11543110e-03f, -1.04524843e-01f, 3.69174741e-02f, -6.05522133e-02f,
  1.79579139e-01f, -5.05947284e-02f, 6.01582192e-02f, 4.89131324e-02f, -7.61318803e-02f, -3.66085134e-02f, 1.36093870e-01f, 2.10866928e-02f, -1.58462659e-01f, -5.62442839e-02f,
  2.92141378e-01f, -5.39397672e-02f, -1.88215867e-01f, -2.01646566e-01f, -3.16047698e-01f, -9.72714126e-02f, -1.35897145e-01f, -6.96736425e-02f, -3.73518139e-01f, 1.13518432e-01f,
  -3.56411003e-02f, -2.88523287e-02f, 1.53707713e-01f, 8.25105384e-02f, 9.80697945e-02f, 5.28779142e-02f, -1.00252926e-01f, 8.96674860e-03f, 8.13170746e-02f, -4.72538285e-02f,
  -5.52836154e-03f, -1.47552744e-01f, -9.73823369e-02f, -5.54510579e-02f, -2.56419741e-02f, -1.85060903e-01f, -6.66595204e-03f, -2.17394400e-02f, -4.06869724e-02f, 4.12339531e-03f,
  -6.49193972e-02f, -3.89849208e-02f, 4.62729186e-02f, 1.58031452e-02f, 8.25293176e-03f, 3.25923637e-02f, -6.61039650e-02f, 4.05644439e-02f, -2.30052583e-02f, -8.90118768e-04f,
  -1.11650238e-02f, -2.55007893e-01f, -3.20310257e-02f, -3.21098454e-02f, 7.81163201e-02f, 1.50969699e-02f, 7.50507228e-03f, 7.87690580e-02f, 6.11120537e-02f, -8.19772407e-02f,
  -1.35068903e-02f, -6.07567020e-02f, 1.64178491e-01f, 2.47507729e-02f, -7.36422241e-02f, -2.86985654e-02f, 1.75206691e-01f, 9.26417857e-02f, 4.09445819e-03f, 1.88987702e-02f,
  7.20524788e-02f, 1.20343506e-01f, 6.74869865e-02f, 8.65079239e-02f, 1.40280247e-01f, 7.11079240e-02f, -5.11210784e-02f, -1.12624779e-01f, -2.90693015e-01f, 6.21371791e-02f,
  -1.48795843e-01f, -3.24765891e-01f, 3.56390297e-01f, -1.36497214e-01f, -8.31574127e-02f, -1.23711033e-02f, 5.64111536e-03f, -2.58215964e-02f, -2.36711070e-01f, -4.37720455e-02f,
  3.41823809e-02f, 6.19214326e-02f, 1.85424164e-02f, 1.65645927e-01f, 5.65299019e-02f, 8.32176432e-02f, -6.82665333e-02f, 2.15882078e-01f, 2.40090623e-01f, -8.13039988e-02f,
  -8.50398168e-02f, -1.20780714e-01f, -1.10191517e-01f, -1.24030169e-02f, 4.79481705e-02f, 5.58595806e-02f, 8.15643519e-02f, -6.08918928e-02f, -4.10546958e-02f, 6.08630031e-02f,
  4.65153396e-01f, 6.43499345e-02f, 1.97401211e-01f, -1.22351311e-01f, 3.58844325e-02f, -1.29658431e-01f, 2.05033515e-02f, -1.61031634e-01f, -1.18532300e-01f, -2.02256203e-01f,
  5.06951734e-02f, -3.49084213e-02f, 2.41495278e-02f, -1.27771780e-01f, -1.15172096e-01f, -2.05958635e-02f, -1.21637434e-01f, -1.61625117e-01f, -1.54132530e-01f, 1.02501623e-01f,
  -2.04324439e-01f, -1.90426931e-01f, -4.23963070e-02f, -1.30870074e-01f, -9.61521715e-02f, -1.40011385e-01f, -1.29224166e-01f, -1.31455988e-01f, -5.31138778e-02f, -1.98709905e-01f,
  -2.71944348e-02f, -2.66829208e-02f, -5.92154562e-02f, -1.20209567e-01f, 2.22889464e-02f, -4.56245616e-02f, 6.41536014e-03f, -1.40383188e-02f, -1.23748653e-01f, -1.12762168e-01f,
  -1.01434775e-01f, 5.67219630e-02f, -2.30454486e-02f, 2.23924778e-02f, -4.35947813e-02f, -5.49523234e-02f, -6.33568987e-02f, -3.41620035e-02f, -7.56873097e-03f, 2.85811163e-02f,
  -2.92656608e-02f, -8.73977244e-02f, 8.52607656e-03f, 4.48394977e-02f, -2.92984513e-03f, 1.19657367e-02f, -3.36708538e-02f, -1.52673703e-02f, -1.16872706e-01f, -8.62247646e-02f,
  1.85728595e-01f, 1.66964129e-01f, 2.24572822e-01f, 1.26742408e-01f, 4.25918698e-02f, -3.14165070e-03f, 1.47980973e-01f, 9.76533443e-03f, 3.30483243e-02f, 9.51174572e-02f,
  1.68139767e-02f, 6.40625209e-02f, 6.22239113e-02f, -9.30301175e-02f, -2.02990212e-02f, -5.65249100e-02f, -2.78400537e-02f, 3.32306959e-02f, 7.77535141e-02f, -6.31252527e-02f,
  -8.64055306e-02f, -4.82510254e-02f, 1.99515566e-01f, 7.87973255e-02f, 1.00712009e-01f, 2.15240046e-01f, 2.80887693e-01f, 1.84405878e-01f, 2.31380165e-01f, 7.90483784e-03f,
  -2.39894576e-02f, -1.35030121e-01f, -2.62153149e-01f, 1.25566810e-01f, 1.90726906e-01f, -5.13137542e-02f, -2.68265456e-01f, -2.09188879e-01f, 3.22096087e-02f, -2.25908652e-01f,
  8.76142234e-02f, 2.30056152e-01f, -1.54666722e-01f, -2.46500388e-01f, -6.70777798e-01f, -5.98481834e-01f, -3.26359004e-01f, -3.88934731e-01f, -1.94370568e-01f, 1.37494326e-01f,
  2.32932776e-01f, -3.18738632e-02f, -1.72126547e-01f, -6.55356497e-02f, 2.57739455e-01f, 7.63521418e-02f, -1.44289397e-02f, 1.46497935e-01f, 1.34609669e-01f, 1.38900951e-01f,
  2.65194685e-03f, -6.03126250e-02f, 1.33276775e-01f, 1.09414279e-01f, 9.07289907e-02f, -6.76579550e-02f, -4.06240113e-02f, -2.87334528e-02f, 7.90373981e-02f, 9.61582828e-03f,
  2.07220301e-01f, 3.27716880e-02f, 2.22416386e-01f, 8.12842846e-02f, -1.08109741e-02f, -6.37971088e-02f, -1.00228712e-01f, -1.92849725e-01f, -1.57343209e-01f, -2.01115720e-02f,
  1.13216572e-01f, 1.30577192e-01f, -2.54832506e-02f, -9.44016129e-02f, -1.18187569e-01f, -2.20212489e-02f, -9.15926397e-02f, 9.69745070e-02f, -3.10375333e-01f, -4.09915410e-02f,
  5.24898618e-02f, -7.24768713e-02f, -4.09099869e-02f, -4.98429984e-02f, 3.42645571e-02f, 1.08464643e-01f, 9.14409310e-02f, -9.96694192e-02f, 1.24867717e-02f, 1.19472399e-01f,
  -1.66997358e-01f, 3.91562209e-02f, -1.49854156e-03f, -9.51576158e-02f, -1.18005112e-01f, 9.37563479e-02f, -8.69151484e-03f, -2.30580699e-02f, -1.63396239e-01f, -4.38642465e-02f,
  4.08002734e-02f, 6.05084449e-02f, -8.49355534e-02f, 5.90219609e-02f, -1.18696075e-02f, -1.31430700e-01f, 5.46744466e-02f, -8.52806717e-02f, -1.68595403e-01f, 5.92562184e-02f,
  5.02094477e-02f, -4.18660901e-02f, -4.89834137e-02f, -8.29838403e-03f, -1.95548199e-02f, -1.56135978e-02f, 1.28381979e-02f, -1.27324592e-02f, 7.32902884e-02f, -1.06298821e-02f,
  -1.06425956e-01f, -1.18769832e-01f, 5.68847172e-02f, 1.46353379e-01f, 2.63594724e-02f, 8.62014592e-02f, -8.53218585e-02f, 1.96636729e-02f, 3.74404690e-03f, 1.53307438e-01f,
  -1.25579819e-01f, -1.56787381e-01f, -1.86798155e-01f, -1.62950054e-01f, 1.03358217e-01f, -3.73813584e-02f, -1.72736853e-01f, 6.56070411e-02f, -2.56587535e-01f, -3.91347200e-01f,
  -6.86300278e-01f, 3.79507728e-02f, -1.64206520e-01f, -2.52098590e-01f, -1.01673156e-02f, -1.38996720e-01f, -8.02153647e-02f, -1.30718887e-01f, -1.82597175e-01f, -8.76618456e-03f,
  -1.71478279e-02f, 1.75390635e-02f, -1.53100580e-01f, -1.38187870e-01f, -1.19056985e-01f, -1.48880616e-01f, -2.81092554e-01f, -2.96475351e-01f, -2.48721927e-01f, -1.37891576e-01f,
  -1.66078046e-01f, -4.22633111e-01f, -3.54359061e-01f, -2.09476799e-01f, 2.50372235e-02f, -1.10619806e-01f, -4.90199551e-02f, -6.99492916e-02f, -1.50148213e-01f, -1.15819573e-01f,
  4.38435555e-01f, -5.57229035e-02f, -3.36735845e-02f, -2.06223540e-02f, 8.35759044e-02f, -7.39010125e-02f, -8.41548219e-02f, -2.49736253e-02f, 9.49951932e-02f, 8.18365961e-02f,
  7.28641078e-02f, 1.12268180e-01f, 3.23244780e-02f, 6.11175373e-02f, 1.79992706e-01f, 9.30662900e-02f, 1.72158509e-01f, 9.92988423e-02f, 9.78228077e-02f, 1.58775523e-01f,
  1.46815971e-01f, 7.96286110e-03f, 2.03750640e-01f, 1.75141290e-01f, 8.24393854e-02f, 7.50908107e-02f, 1.17087185e-01f, 7.33068883e-02f, 1.60026401e-01f, 1.94129676e-01f,
  -1.27424389e-01f, -4.30179760e-02f, 8.34957287e-02f, 1.32772833e-01f, 1.50406674e-01f, 2.83423997e-03f, 2.59258021e-02f, 2.83166580e-02f, 1.75866615e-02f, 4.97706886e-03f,
  1.23679087e-01f, 7.04807714e-02f, 1.35638863e-02f, -6.00133426e-02f, -1.39227109e-02f, -6.42917156e-02f, -3.99995968e-02f, 1.66965649e-01f, 1.28142700e-01f, -2.30710581e-02f,
  7.29964077e-02f, 5.17644249e-02f, -1.11564465e-01f, 3.28915492e-02f, 7.67451674e-02f, 1.61375508e-01f, 6.32802173e-02f, -1.39661562e-02f, 2.49453522e-02f, -1.01445407e-01f,
  3.40779960e-01f, -1.75504670e-01f, -2.12069694e-02f, -6.39945418e-02f, -5.85712343e-02f, -3.56750973e-02f, 3.48650366e-02f, -1.04145594e-02f, 1.14010654e-01f, 1.98795468e-01f,
  9.00825039e-02f, -2.20696349e-03f, 4.41915840e-02f, 5.91756729e-03f, -6.51162351e-03f, 3.57562080e-02f, 1.41851380e-01f, -9.33290124e-02f, -3.21742110e-02f, 1.72445059e-01f,
  3.91408578e-02f, 3.91197801e-02f, 1.40937790e-01f, 1.31849319e-01f, 1.23523334e-02f, -6.19045384e-02f, 1.58274233e-01f, 7.18499795e-02f, -4.02108505e-02f, 1.19182214e-01f,
  4.10688728e-01f, -5.86194098e-01f, 1.02417447e-01f, 1.66197628e-01f, 9.79308188e-02f, 2.79434621e-01f, 1.25545785e-01f, 1.55373057e-02f, 1.10051841e-01f, -4.06681821e-02f,
  -2.72978485e-01f, -2.68794060e-01f, -8.94229636e-02f, -7.84080178e-02f, -1.56544298e-01f, 1.12197576e-02f, 1.72692925e-01f, 1.61229670e-01f, 2.57592678e-01f, 7.89811984e-02f,
  -1.26424953e-01f, -4.81644049e-02f, 8.97292942e-02f, 2.00671088e-02f, -1.34308130e-01f, 6.71955049e-02f, -1.78450868e-01f, -2.90285666e-02f, -2.51439840e-01f, -2.79188156e-01f,
  -4.11713272e-02f, -6.14131019e-02f, -7.12142587e-02f, -1.15596555e-01f, -5.64238168e-02f, -1.39123350e-01f, -1.04062958e-02f, -3.95652838e-02f, -1.18670814e-01f, 2.03915611e-02f,
  -7.10036904e-02f, -5.15392274e-02f, 2.67861392e-02f, -2.58840155e-02f, 3.04539632e-02f, 2.98060626e-02f, -1.12439319e-01f, -1.02246255e-01f, -2.19322324e-01f, -1.81996062e-01f,
  -1.50821581e-01f, 5.49403690e-02f, 1.02957875e-01f, 4.70148027e-02f, -5.75700812e-02f, -5.78651093e-02f, -4.40138020e-02f, -2.10670708e-03f, -3.21960822e-02f, -4.45837080e-02f,
  -7.58491307e-02f, 6.06343821e-02f, -7.32704252e-02f, 1.16449416e-01f, 1.16846219e-01f, 9.66970548e-02f, 1.27881289e-01f, 2.48076469e-02f, 5.25328144e-02f, -1.76997527e-01f,
  8.24021362e-03f, -2.39398740e-02f, -6.49904907e-02f, 3.86549756e-02f, -1.36739686e-01f, -1.44209698e-01f, -6.40161112e-02f, 4.07724120e-02f, -1.01930715e-01f, -8.64390880e-02f,
  -1.25361800e-01f, -1.05295420e-01f, -6.55052513e-02f, -1.55881658e-01f, -8.07360262e-02f, -6.53380454e-02f, -6.25565797e-02f, -9.20454636e-02f, -1.28261954e-01f, 4.55104597e-02f,
  -1.67548686e-01f, 1.10751934e-01f, 1.54614583e-01f, -7.71669447e-02f, 8.45494717e-02f, -4.42100056e-02f, -1.42500540e-02f, -9.49775949e-02f, -2.23810989e-02f, 7.85946101e-02f,
  1.30885333e-01f, -3.63075919e-02f, -5.46532460e-02f, -1.49918169e-01f, 1.54930145e-01f, -4.76009287e-02f, -1.87857777e-01f, -7.24681653e-03f, -3.68068814e-02f, -1.59926608e-01f,
  -7.10383207e-02f, 1.45466313e-01f, 3.17513317e-01f, 5.49361631e-02f, 1.61795646e-01f, 1.67981610e-01f, 1.70167446e-01f, 1.48956820e-01f, 1.51192874e-01f, 1.66141152e-01f,
  -8.37990999e-01f, 2.19971649e-02f, -1.99135050e-01f, -2.45798379e-01f, 2.30991393e-01f, 1.87823758e-01f, 3.63090605e-01f, 5.76930605e-02f, -1.08163334e-01f, 3.27834859e-02f,
  -6.64842576e-02f, 6.31897599e-02f, 5.08420244e-02f, 1.55218571e-01f, 2.96493113e-01f, 4.14556384e-01f, 2.63839126e-01f, -1.00627348e-01f, -5.57323843e-02f, -5.87117346e-03f,
  2.56689221e-01f, -4.30485308e-02f, -2.94582754e-01f, -1.89114198e-01f, 1.32568508e-01f, 8.06797668e-02f, 5.21119237e-02f, 3.60591710e-02f, 1.15776077e-01f, 1.57175496e-01f,
  3.64883661e-01f, -3.03852588e-01f, 4.84867692e-02f, -1.46073774e-01f, 9.12656169e-03f, -1.49209440e-01f, -5.54092266e-02f, -2.06450194e-01f, -1.45972028e-01f, -3.09197269e-02f,
  -3.63227427e-02f, -1.00718811e-01f, -5.96239567e-02f, 4.71727960e-02f, -5.97375631e-03f, -1.02502041e-01f, -1.08836636e-01f, -1.73664819e-02f, 1.00500502e-01f, 4.97263893e-02f,
  9.65766832e-02f, -5.04601113e-02f, 3.04922760e-02f, 1.74197316e-01f, 1.05186924e-01f, 3.80364954e-02f, 1.11389913e-01f, -5.18358946e-02f, -9.96494368e-02f, -5.49951196e-02f,
  4.35513631e-02f, 1.88496977e-01f, -6.88249767e-02f, -9.68744382e-02f, -1.25203924e-02f, 8.51850882e-02f, 1.08328693e-01f, 1.05133325e-01f, 9.50476229e-02f, 1.26633868e-01f,
  3.58342342e-02f, 7.10904226e-03f, 5.68796024e-02f, 1.11632086e-02f, -9.90210548e-02f, 7.69384876e-02f, 2.77820602e-02f, -6.58747777e-02f, -1.30220950e-01f, -3.27835158e-02f,
  -4.84277792e-02f, 2.65956521e-02f, -1.81368977e-01f, -9.50990617e-03f, -7.82855526e-02f, -9.95815247e-02f, -3.60217206e-02f, -1.00252949e-01f, 9.61101279e-02f, 7.80986948e-03f,
  4.63272095e-01f, -9.16220099e-02f, 1.04371056e-01f, 1.02800302e-01f, -1.33054718e-01f, -8.05229619e-02f, -8.30728412e-02f, -1.98873237e-01f, -7.11368173e-02f, -6.00390844e-02f,
  -7.66766593e-02f, -1.69334739e-01f, 4.02880721e-02f, 5.29602244e-02f, 2.85741128e-03f, -5.21330833e-02f, 2.05608667e-03f, 1.15037091e-01f, 1.48733720e-01f, 5.29187582e-02f,
  -4.25328985e-02f, 9.16793942e-04f, 8.01374391e-02f, 2.25366786e-01f, 1.89398140e-01f, 1.09060258e-01f, 8.37249234e-02f, 4.31284495e-02f, 4.65979725e-02f, 1.22029819e-01f,
  4.94851798e-01f, 5.11888415e-02f, -5.62431887e-02f, 2.03333110e-01f, 4.36772965e-02f, -1.44207507e-01f, -6.05242811e-02f, -8.27436149e-02f, 8.56204107e-02f, 1.67521417e-01f,
  1.43832296e-01f, 2.23729759e-01f, 2.09594384e-01f, 1.82909042e-01f, -3.37409303e-02f, 6.58601224e-02f, 8.47234875e-02f, 1.39011249e-01f, -5.80151789e-02f, 9.24535841e-02f,
  1.45313978e-01f, 1.69884577e-01f, 8.59419233e-04f, 1.03950642e-01f, 2.58269787e-01f, 1.57799527e-01f, 7.37257302e-02f, 8.83965045e-02f, 1.00951895e-01f, 2.93635190e-01f,
  8.96067321e-02f, 3.24494004e-01f, 2.11734753e-02f, 6.99392185e-02f, 1.28280208e-01f, -1.96408965e-02f, 3.54303373e-03f, -1.24417983e-01f, -3.89933363e-02f, -1.54375330e-01f,
  -5.44631816e-02f, 1.17134072e-01f, 3.26987170e-02f, 8.80138278e-02f, -6.73393086e-02f, -3.45793664e-02f, 4.09453845e-04f, 3.94605324e-02f, 9.64226387e-03f, 4.82278643e-03f,
  6.44071549e-02f, 1.03065677e-01f, -1.06818691e-01f, -5.47391586e-02f, 2.09875796e-02f, 7.08667710e-02f, 6.43711090e-02f, 8.37540850e-02f, -1.61357913e-02f, 1.96424752e-01f,
  1.60035968e-01f, 2.12642148e-01f, 2.48461992e-01f, 1.66957691e-01f, 2.03257233e-01f, 4.89511751e-02f, 6.60655946e-02f, 6.34239241e-02f, 6.29280731e-02f, 1.77411556e-01f,
  -2.92536300e-02f, 1.74498130e-02f, 5.35719702e-03f, -2.65667737e-02f, -2.91117448e-02f, -7.41156004e-03f, 1.27366986e-02f, 1.28746098e-02f, -3.30513008e-02f, -1.02349129e-02f,
  2.09064763e-02f, -1.48536786e-01f, -5.76190203e-02f, 1.64327156e-02f, -1.08496130e-01f, 2.90918257e-02f, 1.04011662e-01f, -3.75768286e-03f, 4.84407954e-02f, 1.17976151e-01f,
  -5.03004730e-01f, -3.09828967e-02f, 1.40011281e-01f, -1.65704347e-03f, 1.13007076e-01f, -9.78411958e-02f, 5.81934005e-02f, -3.43309864e-02f, -3.54140662e-02f, -1.99185461e-01f,
  -6.45799935e-02f, 3.26994434e-02f, -2.99538802e-02f, -8.43138844e-02f, -1.03846066e-01f, -1.07413247e-01f, 3.25841308e-02f, -1.02612510e-01f, -2.23912269e-01f, -8.39373320e-02f,
  -1.10966772e-01f, -7.85131976e-02f, -1.93177849e-01f, -1.97800189e-01f, 3.71785276e-02f, 4.08045575e-02f, -9.90478247e-02f, -1.05186224e-01f, -1.65531501e-01f, -2.02406034e-01f,
  1.29858389e-01f, -5.23139715e-01f, 1.27261803e-02f, 2.19385728e-01f, 3.81347001e-01f, 4.20556694e-01f, 2.81290531e-01f, 2.37859383e-01f, 1.45210579e-01f, 6.37577176e-02f,
  -3.60865206e-01f, -3.90151024e-01f, -4.62540776e-01f, -2.65703976e-01f, -2.34280750e-01f, 8.54433849e-02f, 2.08484337e-01f, -1.79555230e-02f, 1.84095234e-01f, 1.69444248e-01f,
  1.72141686e-01f, 9.16095674e-02f, -3.73257534e-03f, -1.24215752e-01f, -1.73423290e-02f, 3.71050611e-02f, -9.37208608e-02f, -5.76084331e-02f, -2.29999647e-01f, -2.33335659e-01f,
  -1.00710038e-02f, -3.25856984e-01f, 1.01402916e-01f, -1.42642677e-01f, -5.60118519e-02f, -8.73144567e-02f, -3.19887251e-02f, -5.18395416e-02f, -1.20897241e-01f, -3.40192579e-02f,
  1.06644938e-02f, -1.33474514e-01f, -5.38268089e-02f, -5.07162400e-02f, 7.81337693e-02f, -1.07703833e-02f, -1.28480554e-01f, -1.17816396e-01f, -1.72004268e-01f, -1.35959778e-02f,
  -1.88094392e-01f, 2.40977295e-02f, 6.03109365e-04f, -5.45459474e-03f, -6.94863573e-02f, -6.93085268e-02f, -5.88925406e-02f, -5.09351566e-02f, -4.94571216e-02f, 5.70426472e-02f,
  -7.90313352e-03f, 5.24550453e-02f, 6.43495750e-03f, -7.27779348e-04f, 3.20154615e-02f, 6.17060438e-02f, -7.50302821e-02f, -1.01697305e-02f, 2.48312782e-02f, 4.05616984e-02f,
  -1.04327045e-01f, -3.16308327e-02f, -4.48456667e-02f, -3.25987265e-02f, -1.34439291e-02f, -4.22876813e-02f, 1.52767941e-01f, -5.78822270e-02f, -4.20614891e-02f, 8.71696696e-02f,
  -2.37560179e-02f, 1.52591616e-01f, 7.95466378e-02f, 7.69990869e-03f, 9.17233340e-03f, -2.50501558e-02f, 3.49005731e-03f, -1.16688855e-01f, -4.09733225e-03f, 7.50630647e-02f,
  3.92743014e-02f, -1.88721001e-01f, 2.06907898e-01f, -6.91794977e-02f, 3.09679378e-02f, -1.08928472e-01f, -2.91955441e-01f, -4.28945497e-02f, -4.76065986e-02f, -7.45071694e-02f,
  -1.58747174e-02f, -6.77326322e-02f, -1.14165917e-01f, -6.75222371e-03f, 1.52399406e-01f, 1.07450008e-01f, -6.80984138e-03f, 1.17638865e-02f, -3.91257815e-02f, -1.14256172e-02f,
  9.63198915e-02f, 6.39009625e-02f, 2.65142500e-01f, 1.16723299e-01f, -4.59559448e-02f, 1.60520718e-01f, 1.34696066e-01f, 7.04474151e-02f, 1.23963915e-01f, 3.04669499e-01f,
  -3.70526522e-01f, 5.04871607e-01f, 1.23287417e-01f, -2.39070177e-01f, 3.40913087e-01f, 3.70510280e-01f, 4.44634020e-01f, 2.27457508e-01f, -6.82394430e-02f, 7.35926628e-02f,
  2.26142272e-01f, -2.01571733e-01f, -1.06148109e-01f, -1.11150905e-01f, 4.18577716e-02f, 1.71954334e-01f, -3.94525081e-02f, -2.31422573e-01f, -3.14018697e-01f, -1.57052368e-01f,
  -1.54220372e-01f, -2.39189699e-01f, -2.94337153e-01f, -2.83184767e-01f, -9.82941538e-02f, -2.60502726e-01f, 1.21025495e-01f, 1.06903233e-01f, 3.00054997e-01f, -2.24991605e-01f,
  -1.61722139e-01f, 9.15395170e-02f, -2.91056514e-01f, -1.16985321e-01f, 1.16873085e-01f, -1.07423231e-01f, -1.63771614e-01f, -1.24247722e-01f, 6.71662539e-02f, -1.02297723e-01f,
  -6.17379323e-02f, -1.75166000e-02f, 3.23173478e-02f, 7.16898441e-02f, -7.21894577e-02f, -3.71840335e-02f, -4.94003333e-02f, -5.50570786e-02f, 1.65970046e-02f, 9.94944423e-02f,
  4.45249379e-02f, 4.87698913e-02f, 1.34072304e-01f, 1.45570338e-01f, 4.64383513e-02f, 4.90848199e-02f, 1.75223455e-01f, 1.02814764e-01f, 1.79734409e-01f, -4.73201163e-02f,
  -2.28558466e-01f, 6.90830052e-02f, 5.47771715e-02f, -9.65890661e-02f, 2.25362927e-02f, 3.04516535e-02f, -5.44912890e-02f, 1.60712237e-03f, 1.68808717e-02f, -1.32177016e-02f,
  2.89869774e-02f, -4.72669788e-02f, -8.23628008e-02f, -1.00019246e-01f, -1.79460511e-01f, 5.33273481e-02f, -2.11563800e-02f, -7.12590292e-02f, 1.13291375e-01f, -8.33768845e-02f,
  -8.74414816e-02f, -2.21785605e-02f, -5.78316301e-02f, 7.94410997e-04f, 2.79663689e-02f, -1.03150450e-01f, -7.55889863e-02f, 3.83777581e-02f, 2.82835658e-03f, -1.70121901e-02f,
  -2.87869632e-01f, 1.02641828e-01f, -2.43828923e-01f, 5.55471368e-02f, 9.61014032e-02f, 1.25671491e-01f, -4.92851064e-03f, 6.86015328e-03f, 3.32255964e-03f, -9.98050719e-02f,
  3.84408869e-02f, -1.27765357e-01f, -2.71097124e-02f, -5.67089114e-03f, -1.62584513e-01f, -1.02904446e-01f, 3.67553532e-02f, -3.43285166e-02f, 3.37233185e-03f, 8.21670741e-02f,
  1.28198341e-01f, -7.51354825e-03f, -7.82380402e-02f, -4.78895754e-02f, -2.26118211e-02f, -2.05862120e-01f, -6.91319630e-02f, -6.86492026e-02f, 1.10860638e-01f, -1.81250662e-01f,
  -6.24183834e-01f, 5.15658148e-02f, 1.40923962e-01f, -3.49812388e-01f, 2.56102942e-02f, -9.16783214e-02f, 1.85207054e-01f, -8.14135969e-02f, -2.45724082e-01f, 1.17386349e-01f,
  1.81504652e-01f, 8.38716626e-02f, -2.69223247e-02f, 1.28824264e-01f, -1.39252450e-02f, 7.64938891e-02f, -1.45767376e-01f, -8.18175524e-02f, 1.26477793e-01f, 1.89821154e-01f,
  -7.36787394e-02f, -1.81965590e-01f, -3.29141557e-01f, -1.88028276e-01f, 1.52322100e-02f, 4.09666039e-02f, 9.17605832e-02f, -1.07623249e-01f, 6.27936721e-02f, -6.62072524e-02f,
  4.73917246e-01f, -6.41849265e-02f, -1.60774097e-01f, -3.37241203e-01f, 3.56629342e-02f, -1.38386026e-01f, 1.42993601e-02f, -1.10330693e-01f, -5.49374633e-02f, -6.90691918e-02f,
  -1.93436891e-01f, -2.22877935e-02f, -5.41670509e-02f, 3.12332865e-02f, 2.45617814e-02f, -7.77451927e-03f, -1.17007367e-01f, -1.02819569e-01f, -2.58493219e-02f, 8.96394774e-02f,
  2.00000517e-02f, 4.56706621e-03f, -2.24025678e-02f, -1.15894177e-03f, 5.01234494e-02f, -3.35578397e-02f, 2.21001714e-01f, 2.82718409e-02f, -3.25143039e-02f, -8.32439924e-04f,
  -5.86413741e-02f, -4.72161584e-02f, 1.18377239e-01f, 1.26885874e-02f, -4.83775586e-02f, -3.02413595e-03f, 2.01204829e-02f, 3.45150679e-02f, 8.61094221e-02f, 6.68895151e-03f,
  -3.69043984e-02f, 9.03350189e-02f, 5.64502180e-03f, -1.67593643e-01f, -6.70586228e-02f, -1.27609819e-01f, 6.08329885e-02f, 1.93300527e-02f, -1.14807881e-01f, -4.54688221e-02f,
  -1.16038918e-01f, -1.00998588e-01f, -2.16350351e-02f, -5.68665825e-02f, -9.23055559e-02f, 5.37404381e-02f, -1.11302860e-01f, -1.09194420e-01f, -1.94443464e-02f, -9.07093212e-02f,
  1.20624922e-01f, -2.61518925e-01f, -2.55835801e-02f, -1.29194856e-01f, -5.25842644e-02f, -1.18370630e-01f, -9.49326977e-02f, -5.14727123e-02f, -7.78308287e-02f, -2.50672624e-02f,
  -1.09678939e-01f, 7.92145431e-02f, 2.60416567e-02f, 4.51690406e-02f, -7.76183605e-02f, 4.65951823e-02f, -1.04741700e-01f, 6.78427070e-02f, -4.86573465e-02f, -3.43538262e-02f,
  -9.96678248e-02f, -1.48958787e-02f, -4.20616521e-03f, 2.68757157e-02f, 4.00279947e-02f, 3.87890227e-02f, 2.42488965e-01f, -6.18223287e-03f, 1.58900857e-01f, 1.15077898e-01f,
  5.10311007e-01f, 1.15139209e-01f, -5.02528608e-01f, 3.87763185e-03f, -2.48661146e-01f, -1.10719979e-01f, -1.99014693e-02f, 1.02217756e-01f, 5.59909530e-02f, -8.98872763e-02f,
  -4.02193852e-02f, 3.17545772e-01f, 8.93804133e-02f, -5.03081791e-02f, 1.03045002e-01f, -3.57809961e-01f, -3.28715175e-01f, -7.25587457e-02f, 1.29799083e-01f, -3.71119520e-03f,
  1.33635569e-02f, -3.63317244e-02f, 1.66840687e-01f, -5.09399511e-02f, -8.82710665e-02f, 4.62990403e-02f, -2.51632720e-01f, -1.59319833e-01f, -3.18313062e-01f, -3.81880194e-01f,
  -2.81628847e-01f, -1.48504421e-01f, -9.36152488e-02f, 2.45391726e-01f, -1.80248041e-02f, 5.19586243e-02f, 1.26357228e-01f, 3.39257829e-02f, 1.67721733e-01f, -8.58347714e-02f,
  -2.17943899e-02f, 1.50418460e-01f, 1.51232541e-01f, 7.70224109e-02f, 2.26113573e-02f, 4.68125157e-02f, -3.69377807e-02f, -1.24808155e-01f, -6.40730262e-02f, -6.08047135e-02f,
  -4.70652953e-02f, -1.66888654e-01f, -9.16046649e-02f, -9.04882401e-02f, -2.28315875e-01f, -1.35543868e-01f, -2.27622643e-01f, -1.30336553e-01f, -1.61449164e-01f, -3.81643772e-02f,
  -1.14663213e-01f, -1.69844627e-02f, -5.07212617e-02f, 9.38218981e-02f, 1.55118033e-01f, 1.16337456e-01f, 9.13176909e-02f, 1.81483608e-02f, 6.44304976e-02f, -3.13306563e-02f,
  1.23111628e-01f, -8.11089203e-02f, -5.36206849e-02f, 5.70367575e-02f, -1.33093715e-01f, 4.50651813e-03f, -8.37087259e-03f, 9.94940698e-02f, 1.09972181e-02f, 2.19124146e-02f,
  8.05929303e-02f, 1.24503672e-02f, -1.20088616e-02f, 1.34401798e-01f, -1.00822195e-01f, 1.55249657e-02f, -1.45819798e-01f, 1.28487185e-01f, 7.12419525e-02f, -2.01989969e-04f,
  3.24046671e-01f, -1.44114211e-01f, -3.51581350e-02f, 1.10931024e-02f, -1.44484684e-01f, 4.98556420e-02f, -1.17567599e-01f, 9.72657204e-02f, 7.34065101e-02f, -1.60114486e-02f,
  -1.10651478e-02f, -2.22523380e-02f, 3.12679037e-02f, -9.18539390e-02f, 4.16350253e-02f, 3.85830663e-02f, 8.58373865e-02f, 2.47617308e-02f, 6.33139163e-04f, -4.83618528e-02f,
  8.82000998e-02f, 2.71354526e-01f, 2.27511242e-01f, 3.38304266e-02f, -1.26259744e-01f, 1.91659570e-01f, 5.93217239e-02f, -6.24238364e-02f, 7.48914033e-02f, 2.15542376e-01f,
  6.34839118e-01f, -1.96722701e-01f, 2.73447067e-01f, 2.52796769e-01f, 2.51734406e-01f, 2.26184040e-01f, 1.01645753e-01f, 7.23791048e-02f, 1.88033596e-01f, 8.05240571e-02f,
  9.56259817e-02f, 1.59451976e-01f, 6.28418475e-02f, 1.45392418e-01f, -8.68037995e-03f, -1.01560168e-01f, 1.60944574e-02f, 8.10875520e-02f, 1.49618849e-01f, 9.44568515e-02f,
  6.25114888e-02f, -3.04240314e-03f, 5.94425797e-02f, 4.72656898e-02f, -6.08660579e-02f, 6.35118112e-02f, -4.89503816e-02f, -5.39499260e-02f, -2.73996405e-02f, -2.64162153e-01f,
  2.45910883e-02f, -5.13519980e-02f, 1.62912279e-01f, -6.02556299e-03f, -2.05612928e-02f, -1.28608003e-01f, 8.77968147e-02f, -4.30634879e-02f, -2.24592146e-02f, 3.78645211e-02f,
  -4.69109192e-02f, -1.41890854e-01f, -1.79591492e-01f, -5.83596826e-02f, -7.62567446e-02f, 1.74022596e-02f, -9.06094164e-02f, 2.15949793e-03f, -2.80884653e-02f, 4.26754840e-02f,
  2.24413257e-02f, 7.00812787e-03f, 1.15167283e-01f, 1.42774582e-01f, 1.11334369e-01f, 6.77744951e-03f, 4.62130234e-02f, -4.09831628e-02f, 6.06328771e-02f, 8.10727552e-02f,
  1.88053846e-01f, 1.27531290e-01f, 1.60045817e-03f, -6.39290968e-03f, -6.40100166e-02f, 4.93833795e-02f, -3.40905935e-02f, 1.11457765e-01f, 5.43166809e-02f, -1.37670012e-02f,
  -1.69584990e-01f, 2.58571748e-03f, 1.23514555e-01f, 5.70891472e-03f, 9.07778442e-02f, -4.70103733e-02f, 7.14055216e-03f, 5.51791675e-02f, -1.56195134e-01f, -1.24516770e-01f,
  -4.52004969e-02f, -1.33409083e-01f, -1.03290029e-01f, -1.95125982e-01f, -7.92368725e-02f, -9.29261073e-02f, -8.41275454e-02f, -4.98662293e-02f, -1.60865188e-01f, -1.00577241e-02f,
  -1.76677108e-01f, 1.39081076e-01f, -3.39668468e-02f, -1.22729704e-01f, -3.79684083e-02f, -1.39284998e-01f, 8.50268751e-02f, 5.02885319e-03f, -4.29473668e-02f, -7.93614760e-02f,
  3.40814367e-02f, 8.98703411e-02f, -7.91958347e-02f, -6.34241700e-02f, 2.22259630e-02f, 8.57967585e-02f, -1.90166233e-04f, 4.13632654e-02f, 7.31432512e-02f, -8.06283802e-02f,
  2.59696152e-02f, 2.82750189e-01f, 2.72886783e-01f, 1.10421851e-01f, 1.27659425e-01f, 1.81374773e-01f, 1.10479869e-01f, 4.25631143e-02f, 6.83777034e-02f, 1.27760485e-01f,
  -5.01903772e-01f, -3.04296136e-01f, -2.76835889e-01f, -4.07572806e-01f, -2.14870483e-01f, 1.18857448e-03f, -2.00601444e-01f, 6.59140423e-02f, 3.20040919e-02f, -4.62519556e-01f,
  -1.17402799e-01f, 6.81894049e-02f, -1.02987647e-01f, -1.48448413e-02f, 6.07919730e-02f, -3.28255177e-01f, -4.12465394e-01f, 3.03638224e-02f, 2.47243211e-01f, 2.95933217e-01f,
  6.20738864e-02f, -1.68527991e-01f, -1.46452710e-02f, 1.12293184e-01f, -1.80641457e-01f, 1.88467966e-03f, -3.14721912e-01f, -1.09129019e-01f, 7.67232850e-02f, -3.59357655e-01f,
  -2.98594177e-01f, 2.05434170e-02f, 2.81778555e-02f, 7.55278841e-02f, -2.29663849e-01f, -3.06334514e-02f, -9.14597511e-02f, -1.03976406e-01f, -8.60890597e-02f, -8.48531649e-02f,
  -1.22397102e-01f, 2.17273623e-01f, -1.80542022e-02f, 3.49967629e-02f, -7.37932622e-02f, -1.27797248e-02f, -1.03694893e-01f, 3.62355774e-03f, -4.85685393e-02f, 9.92212724e-03f,
  -6.03318326e-02f, -7.15406537e-02f, -3.80539522e-02f, 1.85409635e-01f, 1.14156112e-01f, 1.10489555e-01f, 9.09319744e-02f, 1.72435746e-01f, 1.80594265e-01f, -2.55914181e-01f,
  -6.90107718e-02f, -2.82036625e-02f, -5.56453206e-02f, 1.42927468e-01f, 6.11332692e-02f, 3.49569507e-02f, 4.24945308e-03f, 9.35210437e-02f, 1.39154002e-01f, 2.17702501e-02f,
  -7.50871003e-02f, -4.42192070e-02f, 3.68705532e-03f, -6.73871934e-02f, -3.88863161e-02f, 3.09947487e-02f, -3.56398970e-02f, -5.91438636e-02f, 4.90947999e-02f, -7.89166912e-02f,
  1.84633415e-02f, 5.38934097e-02f, 2.13483609e-02f, 1.63862668e-02f, -8.73413458e-02f, -1.91629883e-02f, -2.77166832e-02f, 9.97500122e-02f, -2.31472813e-02f, 3.98858041e-02f,
  -1.83999106e-01f, 9.66061950e-02f, -2.14308843e-01f, 1.00492008e-01f, -7.38805979e-02f, 8.49928707e-02f, -1.73649210e-02f, 4.59420644e-02f, -9.66521427e-02f, -3.38993482e-02f,
  1.71305954e-01f, -2.48559844e-02f, -1.74499527e-01f, 9.70496237e-02f, -1.58457458e-02f, 3.16398926e-02f, 2.00115629e-02f, -2.11991929e-02f, 1.54186487e-01f, 4.86725569e-02f,
  3.00780963e-02f, -5.93957044e-02f, -1.25623882e-01f, 3.09605915e-02f, 1.22448638e-01f, 7.91074038e-02f, 2.03609131e-02f, -2.75648963e-02f, 1.59484342e-01f, -2.82892197e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  3.39510500e-01f, 2.41115421e-01f, 3.92624468e-01f, 3.20981264e-01f, 2.00411618e-01f, -3.44412208e-01f, 8.48204643e-02f, -6.08217940e-02f, 4.17968221e-02f, 2.36087725e-01f,
  1.36593387e-01f, 2.48165652e-01f, 8.91939029e-02f, 7.87570402e-02f, 1.46288812e-01f, -1.21801004e-01f, 3.37888077e-02f, 1.15893789e-01f, 2.87416905e-01f, 1.88377738e-01f,
  1.47264659e-01f, 3.51439893e-01f, 2.33075038e-01f, 1.05207145e-01f, -1.29586920e-01f, 1.91127643e-01f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  1.33000240e-01f, 3.51464376e-02f, 1.65800937e-02f, -2.35273466e-02f, -1.50263146e-01f, 1.58469509e-02f, -2.67674793e-02f, -9.30731297e-02f, 1.33837104e-01f, -1.29603714e-01f,
  -2.63104457e-02f, 8.17879736e-02f, 7.97785744e-02f, -6.30161315e-02f, -1.60460435e-02f, -4.16740291e-02f, -6.04924373e-02f, -6.36446923e-02f, -1.80205721e-02f, -1.69737622e-01f,
  2.09236611e-02f, -3.13982144e-02f, 1.35251015e-01f, -1.09709762e-01f, 1.51790902e-02f, -1.20365292e-01f, -1.26760513e-01f, -5.59945144e-02f, -1.48211747e-01f, 8.97277668e-02f,
  7.17404112e-02f, -1.47612800e-03f, 2.47242391e-01f, -1.47194564e-01f, -2.17622653e-01f, -6.13633357e-03f, -8.97373632e-02f, 3.12106255e-02f, -1.24933675e-01f, -7.14717209e-02f,
  2.40958437e-01f, 1.17307901e-02f, -2.21941561e-01f, -1.40116652e-02f, -2.09460318e-01f, 1.53910220e-01f, 6.79768920e-02f, -1.33705691e-01f, 8.69825706e-02f, -1.49597749e-01f,
  8.46074000e-02f, 2.41707280e-01f, -3.58619653e-02f, -1.89114481e-01f, -4.43760492e-02f, 1.72925472e-01f, 3.11753631e-01f, -8.23418647e-02f, 3.31904173e-01f, -9.16821733e-02f,
  -1.16366647e-01f, 1.69076815e-01f, -5.36765568e-02f, -3.62757772e-01f, 3.29921395e-02f, 1.84254587e-01f, 4.14145216e-02f, -5.64640425e-02f, 2.85529252e-02f, 1.23736588e-02f,
  -9.98789351e-03f, -3.41549180e-02f, -5.39339259e-02f, 5.03965989e-02f, -1.06966146e-03f, -1.39047652e-01f, 1.73142813e-02f, 4.95199151e-02f, -4.18657884e-02f, -5.96336238e-02f,
  2.10074320e-01f, 6.86747879e-02f, -4.59090620e-02f, -1.30611941e-01f, -9.05329287e-02f, 1.63774956e-02f, 1.23123601e-02f, -5.43021671e-02f, -1.24037765e-01f, 1.61083378e-02f,
  9.63166356e-02f, -6.44728262e-03f, 8.56212080e-02f, -1.83969866e-02f, -6.02377094e-02f, 4.53944840e-02f, -4.38913815e-02f, 4.19241823e-02f, 1.21097177e-01f, -1.08807646e-01f,
  7.66138360e-02f, 8.71766582e-02f, 3.01930285e-03f, 1.17636763e-01f, 1.98152065e-01f, 2.22508833e-01f, -1.65855587e-01f, 1.47421628e-01f, 1.05876792e-02f, 4.05092463e-02f,
  -9.39222574e-02f, 1.64888352e-01f, -7.32470080e-02f, 1.00614518e-01f, -2.56221294e-01f, -1.24821208e-01f, -1.74412340e-01f, 9.46442336e-02f, 1.93271399e-01f, -2.78673898e-02f,
  -2.15693966e-01f, -5.51284626e-02f, 3.12730335e-02f, -4.81345840e-02f, -1.70601457e-01f, 1.01443483e-02f, -5.66064194e-02f, 2.37617821e-01f, 1.67423993e-01f, -2.13330649e-02f,
  8.21006373e-02f, -6.18105680e-02f, 1.81978390e-01f, 7.44426297e-03f, 2.05849409e-02f, 2.65808124e-02f, 7.73509070e-02f, 5.95169403e-02f, 6.95405826e-02f, -4.70987745e-02f,
  8.70978758e-02f, -1.12278670e-01f, -2.66955253e-02f, -9.94123518e-03f, -5.58373705e-02f, 8.24039206e-02f, 1.06993601e-01f, -3.62670608e-02f, 2.48592138e-01f, 8.67076963e-02f,
  1.59996524e-02f, 6.13367110e-02f, -7.22521245e-02f, 1.08115777e-01f, 4.21670675e-02f, -1.58359066e-01f, -2.05941908e-02f, -2.55290698e-02f, -1.16692379e-01f, -5.91249578e-02f,
  -2.71675646e-01f, -5.14625162e-02f, 2.15585172e-01f, 1.11977598e-02f, -6.93122745e-02f, 6.54714108e-02f, 1.82168365e-01f, 1.25309929e-01f, -2.79154032e-01f, -4.00783168e-03f,
  -8.09263736e-02f, -7.96830431e-02f, -4.37745154e-01f, -6.01599291e-02f, -2.32276142e-01f, 9.57738310e-02f, 5.39874146e-03f, 1.58868536e-01f, -1.73729658e-01f, -1.86686456e-01f,
  4.82608005e-02f, -4.26384419e-01f, -1.92988291e-01f, 3.32283288e-01f, -1.29440144e-01f, 4.61387224e-02f, 1.57513738e-01f, -1.12162761e-01f, 5.04431315e-02f, 8.01613256e-02f,
  1.49970263e-01f, 6.05954900e-02f, -9.05365273e-02f, -1.85429096e-01f, 3.22006308e-02f, -2.28230152e-02f, -1.42993480e-01f, 1.04334196e-02f, -8.70691910e-02f, -4.76181321e-02f,
  1.28789157e-01f, -4.46401089e-02f, -5.30022755e-02f, 1.10454790e-01f, 6.00642385e-03f, -1.15610529e-02f, 5.10721542e-02f, -3.88059840e-02f, -5.31098247e-02f, -7.31167421e-02f,
  -1.11140341e-01f, -1.20015912e-01f, -1.38000458e-01f, -4.03124280e-03f, 2.90547721e-02f, -1.01208523e-01f, -4.83796410e-02f, -4.32464480e-02f, 3.56663167e-02f, 1.79918706e-01f,
  1.13715939e-01f, -5.85418567e-02f, -5.01507372e-02f, -4.93260399e-02f, 1.01513751e-01f, -4.26111072e-02f, -2.74793562e-02f, -4.93590580e-03f, 2.03340560e-01f, -1.33466974e-01f,
  -2.70948052e-01f, 2.23402038e-01f, 1.74420774e-01f, 8.87057930e-03f, -2.28897914e-01f, -5.04507981e-02f, -2.07651496e-01f, 7.52860755e-02f, -1.88500376e-03f, 8.68568346e-02f,
  5.44966236e-02f, -1.57529965e-01f, -3.12745869e-02f, 8.91655833e-02f, 1.33666126e-02f, -3.55757684e-01f, 6.01599477e-02f, -1.21328272e-01f, 2.17195660e-01f, 1.23852521e-01f,
  -1.54020593e-01f, 2.31291384e-01f, 1.53566644e-01f, -1.18099697e-01f, -1.67270929e-01f, -1.13405682e-01f, -3.42408270e-02f, -1.36474833e-01f, 3.39617357e-02f, 7.81944096e-02f,
  9.18311104e-02f, 7.41444379e-02f, 1.64474234e-01f, -4.17825207e-02f, 3.86145376e-02f, -5.74159808e-03f, 1.01859562e-01f, -2.49679554e-02f, 3.34447138e-02f, -9.30436142e-03f,
  -4.73017693e-02f, 1.13294005e-01f, -1.33931562e-01f, -6.29914775e-02f, 1.50887176e-01f, 9.30401608e-02f, 6.95967674e-02f, -1.01246476e-01f, -2.15757173e-02f, -5.62565885e-02f,
  -8.23954940e-02f, -7.10141659e-02f, 3.82990874e-02f, -1.15073331e-01f, 7.14688823e-02f, 3.07489112e-02f, -1.21729165e-01f, 1.33430541e-01f, -2.21209317e-01f, 5.89500628e-02f,
  1.33639961e-01f, -3.96832749e-02f, -6.95437789e-02f, 6.74092621e-02f, 5.01689017e-02f, 3.86090316e-02f, 1.50248542e-01f, -3.45955074e-01f, 4.18971889e-02f, 5.90254441e-02f,
  1.38978148e-02f, -1.16373740e-01f, -1.12682685e-01f, 1.41033053e-01f, 4.25123908e-02f, 9.37201455e-02f, -1.81425616e-01f, -3.69256198e-01f, 6.77959770e-02f, 4.45128465e-03f,
  1.46111578e-01f, 8.91488194e-02f, 9.39264446e-02f, -2.67408282e-01f, 2.89891064e-01f, 2.49029458e-01f, 1.49689227e-01f, -1.90494820e-01f, 1.09218724e-01f, 2.20047563e-01f,
  -1.01454332e-01f, 5.43642091e-03f, -1.71321109e-01f, 1.51701212e-01f, -1.34026796e-01f, -2.55606025e-02f, -1.15650050e-01f, 1.70137063e-01f, 5.50741367e-02f, -5.22217900e-02f,
  -4.30461131e-02f, -1.63982846e-02f, -8.40879790e-03f, 3.83382514e-02f, -1.81898735e-02f, 6.23214059e-02f, -8.92198607e-02f, 8.24579075e-02f, 2.01964192e-02f, 1.42813101e-01f,
  -1.09165877e-01f, -6.01617619e-02f, 4.76508662e-02f, -5.03882356e-02f, 3.83614525e-02f, -1.56489328e-01f, 1.21317022e-01f, 4.89606559e-01f, 1.77824333e-01f, -3.00576426e-02f,
  1.46656081e-01f, 6.42628595e-03f, 1.21945955e-01f, 7.75066316e-02f, -2.73609400e-01f, -1.52386976e-02f, -7.56107271e-02f, -3.04292534e-02f, -2.72112012e-01f, 9.36872140e-02f,
  1.02869302e-01f, -7.36170113e-02f, -5.67147359e-02f, 6.41370267e-02f, 1.35910824e-01f, 8.23279694e-02f, 8.21398944e-02f, 9.86529887e-02f, 3.13670710e-02f, -2.02400893e-01f,
  -1.18510187e-01f, 6.32275194e-02f, -1.93448097e-01f, 6.25829548e-02f, 6.23036325e-02f, -1.79276466e-01f, 2.64904976e-01f, 5.39256148e-02f, -2.77749635e-02f, 2.00599879e-01f,
  -6.64809998e-03f, -2.42168352e-01f, 1.14475392e-01f, -1.82229698e-01f, 1.21771179e-01f, 1.18450478e-01f, -4.85037640e-02f, -8.07651579e-02f, 3.67997773e-02f, 5.94797842e-02f,
  -1.22604907e-01f, -2.45276019e-02f, -2.90143806e-02f, -1.01843085e-02f, -4.02633250e-02f, -7.77145773e-02f, -1.42170414e-01f, -3.91316181e-03f, 1.73413772e-02f, -8.46893191e-02f,
  2.70005669e-02f, -2.71243434e-02f, -8.66748244e-02f, -1.06181046e-02f, 9.72696487e-03f, 1.41095385e-01f, 1.29760250e-01f, 1.30122518e-02f, 8.94411430e-02f, 6.30950835e-03f,
  -1.64916083e-01f, -3.88133973e-02f, -1.78948358e-01f, 1.63714871e-01f, -3.39327455e-02f, -1.06151186e-01f, -3.05901878e-02f, 3.22682299e-02f, 3.37103494e-02f, -1.08547203e-01f,
  -1.01768799e-01f, 7.03780353e-02f, 1.17944501e-01f, -3.29054669e-02f, -1.74949422e-01f, -9.35631767e-02f, -5.99266030e-02f, -7.51412511e-02f, -3.10714334e-01f, -3.87905315e-02f,
  -5.16603410e-01f, -3.19117814e-01f, -4.94725555e-02f, -6.62735254e-02f, -1.12975731e-01f, 1.06122550e-02f, 1.60818741e-01f, -2.20736727e-01f, -1.23067036e-01f, 6.69584721e-02f,
  -1.34093896e-01f, 1.52627891e-02f, 2.54002124e-01f, -2.87930042e-01f, -1.18993856e-02f, 9.37886015e-02f, 1.51607720e-02f, -6.05648980e-02f, -3.23126540e-02f, -4.23667282e-02f,
  -9.24995318e-02f, 8.52010548e-02f, 1.21856481e-01f, -1.37996599e-01f, 3.94962355e-02f, -1.44768981e-02f, 4.82114367e-02f, -5.81150241e-02f, -2.61874031e-02f, 2.40323264e-02f,
  2.11146131e-01f, 1.52382582e-01f, -5.54925501e-02f, 4.90474440e-02f, 6.03531972e-02f, -6.55400380e-02f, 9.34748203e-02f, 5.26081435e-02f, -1.31724432e-01f, 5.39412536e-03f,
  -7.18499571e-02f, 6.33450150e-02f, 1.02807626e-01f, -1.74650803e-01f, 5.17722331e-02f, 1.03281237e-01f, 9.93887112e-02f, 5.63813038e-02f, 3.09201386e-02f, 3.55164632e-02f,
  7.40961805e-02f, 2.37104088e-01f, -4.94198240e-02f, 1.38063639e-01f, -1.68841295e-02f, -1.57359734e-01f, -1.97174519e-01f, 4.51258644e-02f, 2.89869070e-01f, 1.92714483e-01f,
  -1.71456873e-01f, -1.33841589e-01f, 3.99059266e-01f, 7.42824450e-02f, 8.02373290e-02f, 2.93789983e-01f, 1.21111557e-01f, 5.62996464e-03f, 2.26987246e-02f, 1.38591662e-01f,
  -1.97892860e-01f, 3.42042089e-01f, -1.29352599e-01f, 2.27159457e-04f, 7.56492615e-02f, -9.44821388e-02f, 1.83785662e-01f, 4.29045498e-01f, 4.50830273e-02f, -9.95877385e-02f,
  1.12021796e-01f, 7.80071989e-02f, 7.76889781e-03f, -3.12534049e-02f, -2.64953617e-02f, -1.11624591e-01f, 4.35710624e-02f, 2.76346896e-02f, 3.56996320e-02f, -1.27824629e-02f,
  -4.62919176e-02f, -4.26018424e-02f, 7.58694932e-02f, -1.52473226e-01f, 3.23204026e-02f, -1.06124207e-01f, 7.53843517e-04f, -8.28021914e-02f, 1.68344118e-02f, -2.39928495e-02f,
  7.47697614e-03f, -9.10974517e-02f, 5.78388013e-02f, 6.42187074e-02f, 1.70291439e-01f, -6.10227771e-02f, 6.75008893e-02f, 1.07490253e-02f, 8.01635012e-02f, -3.86126488e-01f,
  -1.67480990e-01f, -9.35081672e-03f, 9.74661559e-02f, -2.18083978e-01f, -1.60671279e-01f, 1.95204481e-01f, 2.21921444e-01f, -3.15909609e-02f, 4.60890532e-02f, 1.18834928e-01f,
  8.17358270e-02f, -1.78293079e-01f, -5.12083918e-02f, 7.89569318e-02f, 1.85180768e-01f, 1.08715184e-01f, -8.22088718e-02f, 1.11438148e-01f, 1.15086511e-02f, -9.63164344e-02f,
  9.76446494e-02f, 1.70572564e-01f, -5.97281791e-02f, -2.38266900e-01f, -2.66674487e-03f, 7.56932497e-02f, 1.73346773e-01f, 4.30296883e-02f, -1.37134045e-01f, -2.93247309e-02f,
  -7.16190636e-02f, -5.70037253e-02f, -1.68609098e-02f, 1.24768659e-01f, 6.95094466e-02f, 2.22444415e-01f, 2.89017782e-02f, 7.34265670e-02f, -6.91684186e-02f, 1.15963377e-01f,
  3.98969054e-02f, -1.78088769e-02f, -6.70122281e-02f, 7.32640326e-02f, -7.38326386e-02f, -3.75592522e-02f, 2.49917004e-02f, 1.37794828e-02f, -1.12958681e-02f, 1.27301589e-01f,
  1.69795498e-01f, -1.01469278e-01f, 5.34095354e-02f, 2.93643996e-02f, 1.14635170e-01f, -5.31598590e-02f, -1.02083065e-01f, 2.00773731e-01f, 4.94296737e-02f, 2.94001810e-02f,
  5.88923097e-02f, 8.78931489e-03f, -2.28724524e-01f, -2.16570094e-01f, -2.77607918e-01f, 2.57130787e-02f, 1.76866829e-01f, -1.37590900e-01f, 1.30149409e-01f, -1.13160238e-01f,
  -2.72010677e-02f, 1.07784100e-01f, 1.05560478e-03f, 3.82201485e-02f, 1.93597212e-01f, -2.86487043e-01f, -1.78432152e-01f, 7.72199333e-02f, 2.53797825e-02f, 5.30537665e-02f,
  -1.15714669e-01f, -1.27722102e-03f, -1.44843474e-01f, -3.38671386e-01f, -1.35536164e-01f, 1.92833051e-01f, -1.61205349e-03f, -5.74828312e-03f, -3.98145653e-02f, 4.65115393e-03f,
  3.52306552e-02f, -1.57121047e-01f, -5.07102683e-02f, 1.09279558e-01f, -3.27780128e-01f, -1.90924600e-01f, 4.38157953e-02f, 2.74980426e-01f, 1.97110176e-01f, 3.09465453e-02f,
  -5.94975874e-02f, 6.08566850e-02f, -2.87846429e-03f, -5.33598773e-02f, 1.42295845e-02f, 7.62361148e-03f, -2.02348828e-02f, -6.39588237e-02f, -2.48229560e-02f, -1.07812263e-01f,
  1.07712321e-01f, -1.54701956e-02f, -1.03560634e-01f, -3.97046916e-02f, 1.40795456e-02f, -8.97258595e-02f, -2.16473699e-01f, -8.29025507e-02f, 2.15409040e-01f, -2.15484984e-02f,
  -3.14016432e-01f, 7.81134609e-03f, -6.73868805e-02f, 8.93677305e-03f, 1.37262926e-01f, 1.44206258e-02f, -8.46562833e-02f, -3.50542814e-01f, -1.68562785e-01f, 3.47802602e-02f,
  1.40805826e-01f, -1.27455704e-02f, 1.64360598e-01f, -1.40298337e-01f, 1.66224256e-01f, -7.52699152e-02f, 1.32860392e-01f, -9.73804668e-02f, -7.58035034e-02f, -2.08446547e-01f,
  3.92023288e-02f, 1.19261920e-01f, 3.02870162e-02f, 2.28980705e-02f, -4.98760603e-02f, 7.92200584e-03f, -1.73152894e-01f, -4.27112222e-01f, -1.15181677e-01f, -7.13581666e-02f,
  3.27565894e-02f, 1.13921791e-01f, 1.27614781e-01f, -3.03719025e-02f, 8.20999034e-03f, -4.12689522e-02f, 1.56445503e-01f, -2.28049636e-01f, 3.96106809e-01f, -1.66049644e-01f,
  7.91022554e-02f, 1.30709112e-01f, 1.00362971e-01f, -8.58084764e-03f, 9.43073854e-02f, -8.09686109e-02f, -5.87027613e-03f, 3.84719819e-02f, -1.06465876e-01f, -1.00818567e-01f,
  2.93022785e-02f, 1.04730371e-02f, 3.69460359e-02f, 1.42009826e-02f, -1.38308899e-02f, 1.75203666e-01f, 3.03342193e-02f, 1.27282813e-01f, 6.12271437e-03f, 6.58316836e-02f,
  7.04689994e-02f, -7.76028484e-02f, -1.10018618e-01f, -1.29995659e-01f, 1.40109599e-01f, 5.54334708e-02f, 6.68468028e-02f, -2.25908887e-02f, -7.77858794e-02f, -2.10462566e-02f,
  9.39925294e-03f, -3.12658489e-01f, -5.56618236e-02f, 9.84361991e-02f, -1.39894560e-01f, -2.33133137e-02f, -5.08086011e-02f, -9.38069448e-02f, -1.45375758e-01f, -6.69549406e-02f,
  4.82132994e-02f, 4.31011990e-02f, -3.01864631e-02f, -1.78930238e-01f, 7.59339854e-02f, 1.13715045e-01f, -3.40954177e-02f, 2.84203030e-02f, -3.36012691e-01f, 9.40829441e-02f,
  -2.63328642e-01f, -1.32230729e-01f, 1.93081319e-01f, 1.32886589e-01f, 2.04590783e-01f, 4.41569500e-02f, -1.73813939e-01f, -2.05322504e-01f, 5.72079606e-02f, 4.56327647e-02f,
  1.75790468e-04f, -3.35116051e-02f, 1.77196860e-01f, -4.11834210e-01f, -3.73498976e-01f, 2.17866972e-01f, 7.68318847e-02f, -1.63734481e-01f, 4.97957431e-02f, 8.22466761e-02f,
  -2.72138491e-02f, -2.94480715e-02f, 9.41207483e-02f, 5.26731499e-02f, 3.61638553e-02f, 4.91788350e-02f, 5.99445663e-02f, 9.01090167e-03f, 7.82312751e-02f, -1.30485790e-02f,
  -1.97344217e-02f, 2.34925766e-02f, 5.67239784e-02f, 4.84096147e-02f, -3.63020301e-02f, 3.23376916e-02f, 3.80801149e-02f, 5.62570505e-02f, 1.47652701e-01f, -3.03034438e-03f,
  2.11355790e-01f, 3.14749032e-01f, 1.50026202e-01f, -1.88423350e-01f, 8.90050158e-02f, 3.05361785e-02f, 8.54853392e-02f, 1.89947724e-01f, -2.56931216e-01f, 6.77488521e-02f,
  2.38111511e-01f, 4.48112898e-02f, -1.03028819e-01f, 1.59274548e-01f, -1.53763950e-01f, 5.77273108e-02f, -1.29275322e-01f, 1.41217783e-01f, 2.13344574e-01f, -2.25430787e-01f,
  1.81974005e-02f, -2.56076194e-02f, -2.07277596e-01f, -1.45226464e-01f, -1.62645817e-01f, 6.03357293e-02f, 3.52447405e-02f, -3.80645216e-01f, 9.38642025e-02f, 5.65438569e-02f,
  1.01438984e-01f, -1.37544498e-01f, 1.21622726e-01f, 2.68571138e-01f, -2.41570640e-02f, 1.34922236e-01f, 3.59874457e-01f, -1.08887911e-01f, 1.13150738e-01f, -2.58194685e-01f,
  -1.47292718e-01f, -1.95499256e-01f, -5.81963174e-02f, -1.59591213e-01f, -2.21997332e-02f, 1.48605376e-01f, -1.17961697e-01f, 1.44694269e-01f, 4.67089526e-02f, 5.45011573e-02f,
  9.66563001e-02f, 5.62086925e-02f, -3.14007439e-02f, 3.27389017e-02f, -1.20257428e-02f, -2.14153454e-02f, -9.34490710e-02f, -2.62015313e-02f, -9.72160921e-02f, 5.20209409e-02f,
  -7.65030012e-02f, -2.74672974e-02f, 1.27469018e-01f, 1.28829554e-01f, -2.48409864e-02f, 8.20626915e-02f, 2.05928892e-01f, -4.76400033e-02f, -8.96652490e-02f, 1.73553392e-01f,
  4.17138077e-02f, 4.26806323e-02f, 4.60643396e-02f, 2.90781818e-02f, 8.78899917e-02f, 5.78524359e-02f, -1.46450549e-01f, 1.92768678e-01f, -1.38271600e-01f, -9.95367244e-02f,
  2.54217740e-02f, 1.91337258e-01f, -1.11146696e-01f, -1.37687713e-01f, 1.48768961e-01f, 3.37815955e-02f, 2.60265708e-01f, -5.42460829e-02f, -6.27420098e-03f, -1.89184591e-01f,
  2.45578997e-02f, -3.09132457e-01f, 2.52322048e-01f, 2.62872905e-01f, 9.37040895e-02f, 1.85679525e-01f, -1.55831529e-02f, -1.19565688e-01f, 1.26300186e-01f, -3.37980650e-02f,
  2.99024279e-03f, -2.45646778e-02f, 3.06790788e-02f, -1.23497792e-01f, 1.43626034e-01f, -2.71390676e-01f, -7.50014279e-03f, 6.65228367e-02f, -4.43214960e-02f, 2.42778882e-02f,
  -6.13274612e-02f, 7.49264508e-02f, 3.20423320e-02f, 7.77513906e-03f, -8.78075231e-03f, 8.59498233e-02f, 8.64820853e-02f, 9.87575669e-03f, 5.16203605e-02f, -3.61475423e-02f,
  1.84340421e-02f, 6.79745972e-02f, 1.38578061e-02f, 3.90115827e-02f, 1.77765526e-02f, -2.03479186e-01f, 1.40829816e-01f, 6.57898262e-02f, 3.88033018e-02f, -1.42803833e-01f,
  3.93222533e-02f, -3.48429978e-02f, -1.34397382e-02f, -1.50833756e-01f, 1.42541140e-01f, -2.70755533e-02f, -1.90348655e-01f, -2.08121374e-01f, 1.94075942e-01f, -8.48266482e-02f,
  -1.99037895e-01f, 7.74129434e-03f, -1.43714696e-01f, 7.53445178e-02f, -1.62471220e-01f, 7.75330737e-02f, -3.63121063e-01f, 3.00859749e-01f, 1.74849063e-01f, 1.96304515e-01f,
  -8.74928907e-02f, 2.51710802e-01f, -4.17137474e-01f, -2.03707486e-01f, -4.68717627e-02f, 1.34584084e-01f, -3.16771030e-01f, 9.44987312e-02f, 9.87181142e-02f, -1.45485476e-01f,
  1.41382322e-01f, 1.17960617e-01f, -2.31679693e-01f, -6.98587745e-02f, 7.14512914e-02f, -2.24071518e-01f, -1.26055673e-01f, 3.58610004e-02f, 2.03780994e-01f, -3.07492137e-01f,
  5.81033016e-03f, -1.30095243e-01f, -7.10270628e-02f, -1.73279252e-02f, 1.26876682e-01f, 1.67770848e-01f, -3.61580774e-02f, -6.89984560e-02f, -4.97936755e-02f, -1.29952595e-01f,
  7.85000995e-02f, 6.94897696e-02f, -1.22275777e-01f, 9.52072367e-02f, 4.10631150e-02f, 1.06817275e-01f, -2.11939123e-02f, -4.98050787e-02f, -1.37780318e-02f, 1.55978903e-01f,
  -9.39985439e-02f, -1.73951581e-01f, -3.25329527e-02f, 2.46423092e-02f, -8.87796190e-03f, 1.40879154e-01f, 1.98859721e-02f, -2.01561615e-01f, 9.14682820e-02f, -8.58610775e-03f,
  -1.12620415e-02f, 3.04562948e-03f, -6.95071593e-02f, -1.42971217e-03f, 1.96451902e-01f, 6.12854445e-03f, 1.23219006e-01f, -7.02040046e-02f, -6.92213774e-02f, 2.86465306e-02f,
  2.39480764e-01f, 1.24303263e-03f, 1.87126547e-01f, -3.45272832e-02f, -1.16331100e-01f, 1.71893016e-01f, 2.61694252e-01f, 2.16833591e-01f, 4.27551754e-02f, 2.80459374e-01f,
  1.41776085e-01f, -1.43797994e-01f, -6.54270351e-02f, -2.05141217e-01f, -3.09369322e-02f, -1.65361255e-01f, 2.06236526e-01f, -2.06802756e-01f, -3.64096642e-01f, 2.30724692e-01f,
  6.81558400e-02f, 1.94869205e-01f, -1.37198791e-01f, 2.33040348e-01f, 1.16425026e-02f, -1.48389772e-01f, 2.29896568e-02f, -4.10981430e-03f, -3.05906720e-02f, 1.27815092e-02f,
  -2.47482751e-02f, 5.24729975e-02f, 5.74635155e-02f, 5.13621829e-02f, -1.22195423e-01f, 1.78515147e-02f, -1.13968916e-01f, 6.49233758e-02f, -4.98810373e-02f, 5.35079045e-03f,
  -1.08668827e-01f, 2.71569192e-02f, 1.07820310e-01f, 8.37306678e-02f, -6.81847781e-02f, -1.93664394e-02f, -3.30034690e-03f, -3.25346738e-02f, 2.42179241e-02f, 9.59021151e-02f,
  6.84870547e-03f, 2.05499917e-01f, 6.82094917e-02f, 4.56842333e-02f, 3.70774530e-02f, 4.27082144e-02f, -6.69104531e-02f, 9.34779719e-02f, 1.42953187e-01f, -2.84479428e-02f,
  -2.81582680e-02f, -1.20005697e-01f, -5.09772785e-02f, 6.72428906e-02f, 8.77480954e-02f, -3.02412063e-01f, -1.54386535e-01f, 1.34915411e-01f, -1.17159830e-02f, -1.39710769e-01f,
  4.66125667e-01f, 2.32789382e-01f, 7.71858990e-02f, -1.70307234e-01f, 3.89529616e-02f, -1.77216172e-01f, 6.24292605e-02f, -2.11955279e-01f, 2.25153342e-01f, -9.40933265e-03f,
  7.49840140e-02f, -1.02674045e-01f, -1.41055927e-01f, 2.00185522e-01f, 1.42456263e-01f, -2.55037725e-01f, 1.47153884e-01f, 2.59464961e-02f, -2.48107743e-02f, 6.04842491e-02f,
  -5.42715490e-02f, 1.67360883e-02f, -1.23298161e-01f, 2.17255820e-02f, 9.07342043e-03f, 2.34792568e-02f, 1.58416733e-01f, 9.08187851e-02f, -6.75683767e-02f, 1.17390398e-02f,
  6.70883581e-02f, -5.35223074e-02f, 8.18264037e-02f, -9.37523693e-02f, -9.82468650e-02f, 3.46717276e-02f, -6.00155033e-02f, 8.03981125e-02f, -9.95694101e-03f, -1.13167658e-01f,
  6.38433686e-03f, 9.43902582e-02f, 5.68683743e-02f, -6.51704520e-02f, 6.28218800e-02f, 5.77955067e-01f, 1.92893267e-01f, -1.60569966e-01f, -7.39171878e-02f, -4.77605611e-02f,
  6.24425784e-02f, 4.23072577e-02f, -2.87984908e-01f, 5.36329811e-03f, -1.01728365e-01f, -6.15266226e-02f, 1.76219549e-02f, 3.17916960e-01f, -1.92438692e-01f, 2.25172684e-01f,
  -1.32830858e-01f, -9.91991311e-02f, 6.41845092e-02f, 5.31325229e-02f, 6.85894862e-02f, 3.62145513e-01f, 4.13034968e-02f, -1.85410053e-01f, 1.46058336e-01f, 8.35996941e-02f,
  -1.08370796e-01f, 1.66760802e-01f, 1.00217126e-01f, -2.05133975e-01f, 5.16662598e-02f, 1.20491996e-01f, -3.88022840e-01f, 2.43376523e-01f, -9.09337252e-02f, -3.04674417e-01f,
  -5.03218994e-02f, -1.80122226e-01f, 7.10387230e-02f, 1.24337234e-01f, 2.35657562e-02f, 2.89959423e-02f, 1.30380183e-01f, 1.32646859e-01f, 8.26149359e-02f, -1.61046498e-02f,
  1.53531209e-01f, 5.34760067e-03f, 1.76910788e-01f, 1.29727855e-01f, 1.53609999e-02f, -9.81568396e-02f, 1.82950452e-01f, -4.25221287e-02f, 1.30285531e-01f, 4.16559875e-02f,
  6.02130778e-02f, 5.20024635e-02f, 7.82823339e-02f, -1.10884890e-01f, -9.09404159e-02f, 1.46608144e-01f, 2.96328738e-02f, -1.70315400e-01f, -6.92851096e-02f, 1.50606915e-01f,
  -3.79696488e-02f, 7.59881809e-02f, -1.26649275e-01f, 9.73561406e-02f, 2.01178968e-01f, 1.09646358e-01f, -9.25749093e-02f, 9.86855254e-02f, -1.91115901e-01f, 5.66512942e-02f,
  8.89641643e-02f, 2.83224553e-01f, -1.42144918e-01f, 7.19927624e-02f, -1.83409870e-01f, -2.85000671e-02f, -8.70369002e-02f, 1.49568599e-02f, 3.40438485e-02f, -6.85127974e-02f,
  -2.04158992e-01f, -2.02123761e-01f, 1.28952920e-01f, 3.15876693e-01f, 2.42960639e-02f, -1.24684386e-02f, -3.08971535e-02f, -5.13227247e-02f, 5.11142537e-02f, 1.37086168e-01f,
  4.21034545e-02f, 1.14908395e-02f, -2.01903552e-01f, -2.11231560e-01f, -3.85414660e-02f, -3.04353893e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -1.43173886e-02f, 3.05171777e-03f, 1.21277153e-01f, 9.59724039e-02f, -9.54853296e-02f, -6.77774027e-02f, -6.99317679e-02f, 1.66973919e-02f, -9.04959664e-02f, 2.59481333e-02f,
  8.86916593e-02f, 8.86467174e-02f, 8.84727091e-02f, 1.47549100e-02f, 1.40843958e-01f, 2.15604510e-02f, 1.79667115e-01f, 1.64071191e-02f, 1.93133038e-02f, -4.68333475e-02f,
  1.73903387e-02f, -3.64639536e-02f, -3.26551981e-02f, -6.80050300e-03f, 2.26662710e-01f, 5.31370528e-02f, 1.51481768e-02f, 1.87008053e-01f, 1.13053486e-01f, -2.64113327e-03f,
  1.34879261e-01f, -6.77475706e-02f, 1.94178196e-03f, 5.28018437e-02f, 1.75122954e-02f, 1.27664447e-01f, -4.64886762e-02f, -1.87782720e-02f, -1.67205572e-01f, 1.20367810e-01f,
  6.18876100e-01f, -2.36504883e-01f, 1.62031744e-02f, -7.86939412e-02f, 9.76770967e-02f, 6.26476780e-02f, 3.85724515e-01f, 2.21148521e-01f, 8.22224766e-02f, -6.36242181e-02f,
  1.32395402e-01f, 2.06525475e-01f, -2.33450346e-02f, 2.57970273e-01f, 7.70458505e-02f, -1.61162525e-01f, 1.53902650e-01f, -6.52436614e-02f, 3.35722536e-01f, 2.81493012e-02f,
  2.25054417e-02f, 6.07434995e-02f, -1.18555963e-01f, 7.54960179e-02f, -9.80408024e-03f, 2.06719473e-01f, 4.91851494e-02f, -6.96577551e-03f, 1.71726458e-02f, 1.65664315e-01f,
  1.70057014e-01f, 8.76901671e-02f, 9.68516693e-02f, 1.37987062e-01f, 9.13928375e-02f, 7.22278431e-02f, -3.15321498e-02f, 1.80058032e-01f, 3.29195224e-02f, 5.93953989e-02f,
  8.99031535e-02f, 1.08973235e-01f, -9.73717570e-02f, -5.65062501e-02f, 1.79404497e-01f, 1.78543292e-02f, -3.62391304e-03f, 1.25068754e-01f, 1.71742633e-01f, -1.80577844e-01f,
  1.90233558e-01f, -1.00965109e-02f, 1.35642529e-01f, 5.61930500e-02f, -1.36943385e-01f, 8.20741504e-02f, -3.95993739e-02f, -1.42583117e-01f, -1.51393279e-01f, 5.95467612e-02f,
  -1.58399016e-01f, 2.20264643e-01f, -3.40893343e-02f, 2.54081935e-01f, 2.62052149e-01f, -1.32296890e-01f, -2.06984449e-02f, 3.27598862e-02f, -1.80900723e-01f, 9.01563093e-02f,
  5.03029041e-02f, 2.50651032e-01f, 1.99200526e-01f, -2.03091010e-01f, -2.36186944e-02f, 1.12125330e-01f, -8.64586458e-02f, -1.49279892e-01f, -1.33064881e-01f, 6.62478581e-02f,
  2.13945195e-01f, -2.39429250e-01f, 5.01491547e-01f, 5.60651571e-02f, -4.86357091e-03f, -1.10008799e-01f, 4.74246368e-02f, 2.73907483e-02f, 8.13231617e-02f, 2.03758050e-02f,
  8.12449157e-02f, 5.65367900e-02f, 1.20657705e-01f, 1.27529055e-01f, 1.01302832e-01f, 1.86691910e-01f, 1.02704369e-01f, 1.32547915e-01f, 9.24156979e-02f, -5.29730469e-02f,
  1.47292987e-01f, 2.44874045e-01f, 7.22001195e-02f, 1.54496342e-01f, 8.36880356e-02f, 1.75555766e-01f, 1.07417531e-01f, -9.77908820e-02f, 1.18730091e-01f, -4.34502773e-02f,
  3.63351195e-04f, -1.03251375e-02f, -4.32578735e-02f, -1.25378460e-01f, 1.91534176e-01f, 9.23008770e-02f, 2.24498942e-01f, 9.44568440e-02f, -1.93508744e-01f, -2.00926512e-02f,
  -2.83120759e-02f, 1.39536873e-01f, 3.74224619e-03f, 1.11655429e-01f, -5.85422851e-02f, 1.65253766e-02f, -1.67241052e-01f, 1.72502667e-01f, 1.50765151e-01f, 2.34257188e-02f,
  5.40640987e-02f, 3.38546485e-02f, -4.26310487e-02f, 8.15874711e-02f, -1.46813735e-01f, 3.81336838e-01f, 2.60049194e-01f, -8.80257878e-03f, -1.09289646e-01f, -6.37546629e-02f,
  6.11065179e-02f, -1.91763103e-01f, 6.75505921e-02f, 2.16501608e-01f, 2.86176324e-01f, -3.96336764e-02f, 4.51525837e-01f, 2.61009574e-01f, 2.34629121e-02f, -2.87240773e-01f,
  -1.09626219e-01f, -1.49290636e-01f, 1.81272045e-01f, 1.54475152e-01f, -1.03749372e-02f, 1.43645266e-02f, 1.56492099e-01f, 3.71464551e-03f, 5.37344851e-02f, 1.11409262e-01f,
  1.19017482e-01f, 8.26967284e-02f, 4.81018052e-02f, -5.73453270e-02f, -1.11589722e-01f, -1.07121199e-01f, 6.78742826e-02f, 2.26529956e-01f, -1.20414510e-01f, 2.39605233e-01f,
  2.60273423e-02f, -2.04994202e-01f, 2.30714053e-01f, 2.02124447e-01f, 4.26871181e-02f, -1.38401939e-02f, -9.63575989e-02f, 4.76217270e-02f, -1.65981147e-02f, -3.79123092e-01f,
  1.85987297e-02f, -1.69061646e-01f, -2.18605418e-02f, -4.22689430e-02f, -1.84987318e-02f, 1.75830767e-01f, -5.27245216e-02f, -9.15846154e-02f, -8.14129710e-02f, 9.95031893e-02f,
  2.84178495e-01f, 2.37890780e-02f, -2.81913012e-01f, 2.70041883e-01f, 2.47853566e-02f, -2.01123342e-01f, 1.43262688e-02f, -1.77495167e-01f, -9.11174789e-02f, -8.02595317e-02f,
  1.20530076e-01f, 3.37530971e-01f, 9.78535861e-02f, -3.15998979e-02f, 9.87477414e-03f, 6.08147755e-02f, -1.80270687e-01f, 4.01036173e-01f, -1.07341684e-01f, 1.40170157e-01f,
  2.46376008e-01f, -3.27494442e-02f, -1.14497557e-01f, 2.21141860e-01f, 2.84857806e-02f, 1.86461911e-01f, -2.57366896e-02f, -4.22002487e-02f, -4.20972966e-02f, -7.52817653e-03f,
  9.53383092e-03f, 1.56886950e-01f, 1.13815032e-01f, 1.24309577e-01f, 1.44526079e-01f, 8.96568224e-02f, -1.04179151e-01f, 2.91893274e-01f, -5.57874516e-03f, -3.32660303e-02f,
  2.05527827e-01f, 1.48576170e-01f, 6.88750520e-02f, 2.14353547e-01f, 1.67586997e-01f, 1.71058819e-01f, -1.18825302e-01f, -1.03495076e-01f, 3.71617451e-02f, -1.64588876e-02f,
  5.07064313e-02f, 1.20701514e-01f, 7.90382102e-02f, 3.23730946e-01f, 1.13281749e-01f, -3.02063543e-02f, -3.36731747e-02f, 1.01136109e-02f, -1.25438243e-01f, 9.11051966e-03f,
  2.00164080e-01f, -1.87322237e-02f, 5.53085431e-02f, -1.41141757e-01f, 1.31024554e-01f, 1.19292483e-01f, -2.48210832e-01f, -1.46224266e-02f, 7.27856085e-02f, 9.71609950e-02f,
  4.46061194e-01f, -2.87605226e-01f, 2.35294312e-01f, 1.22465722e-01f, -1.01149864e-01f, -4.10190634e-02f, -7.41814300e-02f, -1.00288376e-01f, 1.12499319e-01f, 2.44348392e-01f,
  2.84345239e-01f, 6.80585578e-02f, -2.04549357e-01f, 1.46088094e-01f, -1.81083530e-01f, 4.12188560e-01f, 1.53938681e-01f, -2.41750270e-01f, -1.73586100e-01f, 7.06398934e-02f,
  -3.77446152e-02f, 9.13703963e-02f, 1.68399230e-01f, -1.80231463e-02f, 1.34122148e-01f, -1.65533330e-02f, 1.00989752e-01f, 1.06266670e-01f, 3.58761884e-02f, 5.94825521e-02f,
  2.02766389e-01f, 2.26525083e-01f, 6.18732683e-02f, -8.41038749e-02f, -3.13775800e-02f, 2.62926996e-01f, -2.07862347e-01f, 1.33258879e-01f, -1.29895443e-02f, -8.53933915e-02f,
  -5.45854196e-02f, 8.69877934e-02f, 5.00352262e-03f, -3.05227369e-01f, 1.39816418e-01f, -5.45213884e-03f, -6.91035166e-02f, 5.52979596e-02f, -6.60670996e-02f, -1.38280421e-01f,
  -5.09718135e-02f, -1.51386485e-01f, -2.14845743e-02f, -1.01515181e-01f, 1.81994379e-01f, 2.18215287e-02f, 6.29874840e-02f, 2.16480549e-02f, -1.56269029e-01f, 2.17135161e-01f,
  2.75252964e-02f, -5.55807017e-02f, 3.94168198e-02f, -2.19052657e-01f, -1.38266161e-02f, 6.79743588e-02f, -3.11293930e-01f, 2.03530490e-01f, 3.61499399e-01f, -5.05876355e-03f,
  4.68503945e-02f, -2.39818007e-01f, -6.09136187e-03f, -1.64670929e-01f, 2.74197217e-02f, 3.65016669e-01f, -2.41300575e-02f, 6.17437623e-02f, 3.44897449e-01f, 2.41917253e-01f,
  3.66282225e-01f, 1.79875135e-01f, 1.99776664e-02f, -8.88676643e-02f, 6.60676062e-02f, 1.39212176e-01f, -1.71504798e-03f, 1.45208865e-01f, 1.20890871e-01f, 2.19780236e-01f,
  2.81889234e-02f, 1.34323344e-01f, 2.65674353e-01f, 9.24043730e-02f, 1.26531094e-01f, 5.41676581e-02f, 6.63363561e-02f, 8.37941766e-02f, 2.46504337e-01f, 1.52466297e-01f,
  1.14649266e-01f, 2.82286644e-01f, 7.48611316e-02f, -1.55391078e-02f, 3.28858823e-01f, -4.57591191e-02f, -1.91189080e-01f, 2.10870191e-01f, -1.96452409e-01f, -1.55164124e-02f,
  1.86416611e-01f, 1.65237457e-01f, -3.95308286e-02f, 1.22912414e-01f, -4.49694842e-02f, 3.13620595e-03f, 1.06420375e-01f, 7.42407814e-02f, -3.36859152e-02f, 9.16429684e-02f,
  -6.75354153e-02f, 1.78468749e-01f, 2.67725766e-01f, 1.99978739e-01f, -5.55317342e-01f, 1.95015416e-01f, 2.32255787e-01f, 1.53553173e-01f, 1.97035819e-02f, -3.28463539e-02f,
  -8.73042718e-02f, 2.41726805e-02f, -8.29865113e-02f, 9.78043005e-02f, -2.86104623e-02f, 5.35055511e-02f, 2.43223265e-01f, 5.30733503e-02f, -1.16028108e-01f, -1.46167994e-01f,
  -1.08355753e-01f, 4.05276179e-01f, -3.86943847e-01f, -9.23486426e-02f, -2.01229349e-01f, -1.52042612e-01f, -2.95486208e-02f, -4.94850352e-02f, 6.26404881e-02f, 2.08436415e-01f,
  8.70463178e-02f, 6.93543032e-02f, 2.12294143e-02f, -1.10713392e-01f, -5.25628217e-03f, 1.71957925e-01f, 7.91959371e-03f, 3.48090380e-02f, -2.44646117e-01f, 7.10431933e-02f,
  -3.60632502e-02f, -5.35570458e-02f, -1.08551890e-01f, 1.81903616e-02f, 1.16532333e-01f, 4.89102006e-02f, 6.00573868e-02f, 5.56818768e-02f, -2.69031614e-01f, -1.38631463e-01f,
  5.35277724e-02f, -1.01705201e-01f, -3.77639905e-02f, 6.94499090e-02f, -4.80406508e-02f, 5.98348975e-02f, 1.13328755e-01f, -1.09167665e-01f, 1.04374781e-01f, -4.66209203e-02f,
  -8.14770833e-02f, 1.27778202e-01f, 1.49939224e-01f, 1.16243280e-01f, 8.47061127e-02f, -2.28249386e-01f, -3.52953747e-02f, 3.43837701e-02f, 7.75614381e-02f, 1.92843869e-01f,
  -1.95808172e-01f, -7.04823211e-02f, 3.57290804e-01f, -1.74389519e-02f, 4.61815029e-01f, 2.23241344e-01f, 1.36674538e-01f, 6.39383569e-02f, 2.71670818e-01f, 1.87387109e-01f,
  -3.36893350e-01f, 3.94650549e-01f, -5.94187453e-02f, 1.34108469e-01f, -2.66211759e-02f, 1.25403658e-01f, 1.75700691e-02f, 3.06009859e-01f, -1.79719049e-02f, 6.84678135e-03f,
  -3.10721248e-01f, 6.54085577e-02f, 1.14350602e-01f, -5.40386215e-02f, 1.63403228e-01f, 1.59314603e-01f, -2.25009784e-01f, 1.11235306e-01f, -4.07342464e-02f, 2.12566312e-02f,
  1.90319046e-01f, 1.24260560e-01f, 2.62936860e-01f, 7.91411772e-02f, 1.83617637e-01f, 2.98555136e-01f, 1.14594020e-01f, 2.50007659e-01f, 3.05119362e-02f, -9.54529271e-03f,
  1.26841158e-01f, -4.74473126e-02f, -8.60949904e-02f, 1.60218373e-01f, -5.74655691e-03f, -4.05863412e-02f, 7.93227032e-02f, -9.20976698e-02f, 9.39994026e-03f, 1.66869685e-01f,
  1.56215966e-01f, 1.90007851e-01f, -1.01870601e-03f, 1.51266634e-01f, 3.54015708e-01f, 4.36787382e-02f, -1.94713652e-01f, -3.83024625e-02f, -1.29665043e-02f, -1.69321343e-01f,
  -1.50360122e-01f, 1.92445651e-01f, 5.13384044e-01f, -1.05014786e-01f, -9.78465676e-02f, -1.21148854e-01f, -1.10678010e-01f, 1.71591027e-03f, 2.05320626e-01f, 2.43738160e-01f,
  1.72491401e-01f, -4.19138968e-02f, 1.42502695e-01f, 2.83359379e-01f, 2.33114123e-01f, -2.70731986e-01f, 1.15253836e-01f, -2.96767116e-01f, 4.52404976e-01f, 1.42714873e-01f,
  -2.11083978e-01f, 1.47880286e-01f, 4.13701952e-01f, 4.58141826e-02f, -2.79356271e-01f, -3.57600152e-02f, -1.18807159e-01f, -2.94400066e-01f, 1.12200581e-01f, 5.71249723e-02f,
  1.37319773e-01f, -4.75260355e-02f, 8.32461864e-02f, 1.13535084e-01f, -5.94392903e-02f, -8.87277350e-02f, 8.09704978e-03f, -7.42117465e-02f, 8.19579214e-02f, -1.05622003e-03f,
  9.10091624e-02f, 2.26135906e-02f, -3.18544246e-02f, 7.58355930e-02f, 1.11855892e-02f, -7.69158751e-02f, -5.82654923e-02f, 1.37895951e-03f, -7.27312863e-02f, 1.78936422e-01f,
  9.66685638e-02f, -3.14075612e-02f, 1.38996154e-01f, 4.30431478e-02f, 2.59945422e-01f, 8.40600133e-02f, 1.09369326e-02f, 7.96127766e-02f, -3.84432852e-01f, 9.92665738e-02f,
  2.50714391e-01f, 7.70384744e-02f, 7.59615656e-03f, -1.95081711e-01f, -2.21261010e-01f, 2.52316564e-01f, 4.78167504e-01f, -4.18169498e-01f, -1.60095617e-02f, 1.45040127e-02f,
  1.27779678e-01f, 9.34079960e-02f, 1.45504296e-01f, 4.38276827e-01f, 1.05450623e-01f, 4.91843894e-02f, 4.76290993e-02f, -2.22600605e-02f, -1.48283653e-02f, 6.19150028e-02f,
  -1.56393170e-01f, 5.99385425e-03f, 4.57245290e-01f, -8.27120692e-02f, 7.85164312e-02f, 4.29559469e-01f, 2.72593945e-01f, -1.83217391e-01f, -1.40222073e-01f, 2.76385069e-01f,
  -1.30118519e-01f, -2.83238478e-02f, 2.67671514e-02f, 2.90369857e-02f, -2.45706141e-02f, -3.50928716e-02f, 4.92289029e-02f, 8.27120095e-02f, 3.79239656e-02f, 1.92654766e-02f,
  5.52943051e-02f, 1.13373704e-01f, 9.17230844e-02f, 1.15803875e-01f, 8.14253464e-02f, 5.33403270e-02f, 1.63085118e-01f, 3.67378555e-02f, -8.87851715e-02f, 8.84309560e-02f,
  1.07044458e-01f, -1.70328751e-01f, -1.28660947e-01f, -1.34933367e-01f, -1.01947471e-01f, -6.48825467e-02f, 3.24280746e-02f, -1.15461601e-03f, 1.18469238e-01f, 7.58787990e-03f,
  -1.39511108e-01f, 9.90888029e-02f, -7.24662244e-02f, 1.52430952e-01f, 1.25062987e-01f, -6.30060285e-02f, 2.86659077e-02f, -9.99075398e-02f, -2.20268086e-01f, 3.05176616e-01f,
  1.79741517e-01f, 2.01075837e-01f, 1.11798272e-01f, 6.54049367e-02f, 1.14518687e-01f, 2.54110903e-01f, 2.38058597e-01f, 3.39045227e-01f, 7.78805837e-02f, 1.51968777e-01f,
  1.29316494e-01f, 6.94167763e-02f, -1.23116791e-01f, -5.78857958e-02f, 6.06242418e-02f, -2.16693893e-01f, 1.52989790e-01f, -2.56628335e-01f, -2.49817654e-01f, 3.69993478e-01f,
  -8.58410969e-02f, -7.22535178e-02f, -6.38096407e-02f, -7.72603303e-02f, 4.62270491e-02f, 1.07460264e-02f, 7.15096965e-02f, -2.09546071e-02f, 1.06530242e-01f, 1.53125316e-01f,
  2.79164284e-01f, -6.43891990e-02f, 2.80823000e-02f, -3.31853069e-02f, -1.11827450e-02f, 1.08618359e-03f, -1.04901372e-02f, 3.06611266e-02f, 3.26890945e-02f, 8.35158005e-02f,
  2.63861977e-02f, 1.78944290e-01f, -2.12436505e-02f, -1.65029109e-01f, 1.61001515e-02f, 9.95048061e-02f, -1.19401865e-01f, -4.83818799e-02f, -2.95599610e-01f, 1.96379155e-01f,
  -8.29880312e-02f, -1.29313841e-01f, 1.64869018e-02f, -5.41458093e-02f, 8.74929130e-02f, -9.30669829e-02f, -2.69629154e-02f, 1.41991954e-02f, 1.22271692e-02f, -5.39528206e-02f,
  2.34904396e-03f, 3.79466526e-02f, 2.70388186e-01f, 1.29340068e-01f, -3.90702844e-01f, 4.17240202e-01f, 1.64437398e-01f, -2.21894339e-01f, 5.10450415e-02f, 7.07506016e-02f,
  -2.89045423e-01f, -3.74813341e-02f, 1.93001762e-01f, 1.76138446e-01f, 1.37858644e-01f, -2.23043352e-01f, -9.49158594e-02f, -1.20745994e-01f, -1.84701920e-01f, 2.17390537e-01f,
  -2.35904947e-01f, 3.64200473e-01f, -1.32256821e-01f, 3.05311024e-01f, -6.07181564e-02f, 1.14350758e-01f, 4.80028219e-04f, -8.77901737e-04f, 3.85351181e-02f, 1.85334846e-01f,
  5.49720749e-02f, 1.18035875e-01f, 3.38052452e-01f, -1.16597585e-01f, -1.63620319e-02f, 5.67826666e-02f, -2.82764174e-02f, -3.45456079e-02f, 2.09570229e-01f, 1.25814766e-01f,
  1.83857530e-01f, 2.20658466e-01f, 1.02910921e-01f, 7.61424229e-02f, 1.01082318e-01f, -3.91571736e-03f, -2.51694117e-02f, 6.77697882e-02f, -1.86866075e-02f, -1.73018649e-01f,
  -2.78551817e-01f, 2.90775567e-01f, -1.03455298e-01f, 2.05688670e-01f, 3.02387446e-01f, -6.66802883e-01f, 4.25059237e-02f, 2.98230127e-02f, 6.90688938e-02f, 9.90490913e-02f,
  -2.95536011e-01f, 2.00913683e-01f, 4.05176610e-01f, -5.66142797e-02f, -1.69376493e-01f, 2.34129593e-01f, 5.28943539e-01f, -2.14424521e-01f, 2.38889739e-01f, -6.48089573e-02f,
  -6.48750812e-02f, -1.32521065e-02f, -4.70204391e-02f, -1.46845281e-01f, -7.17781112e-02f, 2.06420660e-01f, -2.64025211e-01f, 3.59127074e-01f, -3.33125681e-01f, -1.30611137e-01f,
  -1.18788355e-03f, -3.60444859e-02f, -1.41461492e-01f, 4.77829017e-02f, -2.29373291e-01f, -1.07988514e-01f, -9.15682241e-02f, -2.05341741e-01f, -2.78707668e-02f, 1.04474276e-01f,
  -2.95404017e-01f, 4.67915595e-01f, -6.34841025e-02f, -9.66390371e-02f, 9.83154774e-02f, -1.36889696e-01f, 1.10490546e-01f, -6.72428012e-02f, -3.37501876e-02f, 2.58017462e-02f,
  -2.07110316e-01f, 1.54258937e-01f, -1.31714121e-01f, 1.71374097e-01f, 3.71428356e-02f, -1.44790545e-01f, -2.35616285e-02f, 6.65636063e-02f, 5.94861843e-02f, 1.28978640e-01f,
  1.69665273e-02f, 1.39845058e-01f, -1.06829926e-01f, 1.79836124e-01f, 5.56631759e-02f, -1.47547657e-02f, -6.93809763e-02f, 1.40202552e-01f, -1.33862510e-01f, -2.92334743e-02f,
  -1.27111524e-01f, -3.38758193e-02f, 1.94124863e-01f, 6.04604445e-02f, -1.91659540e-01f, -5.35929427e-02f, 1.81133136e-01f, 1.13013320e-01f, 1.27970695e-01f, -2.11243723e-02f,
  1.08427569e-01f, 5.93777699e-03f, 2.42883042e-01f, -1.98441744e-01f, 4.51778434e-02f, -1.16343878e-01f, 1.31362200e-01f, 1.90168425e-01f, 3.44436258e-01f, 1.98232278e-01f,
  -9.57292169e-02f, 4.56350856e-02f, 1.79083169e-01f, 1.32102534e-01f, 2.04004999e-02f, 9.19829383e-02f, -1.15124993e-01f, -1.24302588e-01f, 3.95516098e-01f, 1.25251308e-01f,
  -1.91151559e-01f, 1.62072673e-01f, 1.03194900e-01f, 1.46123067e-01f, 5.35222003e-03f, 2.72057414e-01f, 1.04880445e-01f, 1.20785199e-01f, 1.81773096e-01f, 1.24184459e-01f,
  -1.38897777e-01f, 7.46785104e-02f, 1.14211373e-01f, 4.71666232e-02f, 2.89522082e-01f, 9.76122394e-02f, 1.42880365e-01f, 1.23859569e-01f, 4.77157868e-02f, 1.77817680e-02f,
  5.95650375e-02f, -4.43894491e-02f, 2.07769237e-02f, 9.05842558e-02f, 2.60196943e-02f, 1.00832745e-01f, 3.37470740e-01f, -1.52570277e-01f, -4.10382822e-02f, 1.15181990e-01f,
  -7.54445046e-02f, 8.07334185e-02f, 1.10737354e-01f, 6.21900618e-01f, 9.35220197e-02f, 4.66376822e-03f, -9.59599614e-02f, 6.60738125e-02f, -7.79112428e-02f, 3.95357907e-02f,
  2.65792068e-02f, 2.97038313e-02f, -6.60608485e-02f, 6.31176261e-03f, 6.69269338e-02f, 3.44762921e-01f, -2.89720029e-01f, 1.66853949e-01f, -1.80726498e-02f, 6.12326711e-02f,
  2.05735713e-01f, 3.75668146e-02f, 1.14192650e-01f, 2.16279000e-01f, -1.57803506e-01f, 8.08683559e-02f, 7.84639567e-02f, 2.25753173e-01f, 5.56638762e-02f, 7.73222372e-02f,
  -2.39904776e-01f, -1.41103059e-01f, -4.58423533e-02f, 1.31685227e-01f, -3.08241099e-01f, 3.44868541e-01f, -2.26317141e-02f, -1.91866562e-01f, -1.33040309e-01f, -9.02079940e-02f,
  3.74669470e-02f, 3.23607206e-01f, 1.83273375e-01f, 6.34979829e-02f, -1.58116624e-01f, -7.00267032e-02f, -5.62501587e-02f, 2.77356535e-01f, 1.12992436e-01f, 5.59447967e-02f,
  8.78082439e-02f, 1.62639916e-01f, -1.26456484e-01f, -1.01279221e-01f, 3.80879492e-02f, 1.19686410e-01f, 2.34300792e-02f, 1.49432737e-02f, 1.43051678e-02f, 8.89971703e-02f,
  -1.08416848e-01f, -3.63387680e-03f, -1.50608495e-01f, 2.57015347e-01f, 3.18824798e-01f, -7.37838075e-02f, 6.24727905e-02f, 3.06852072e-01f, -3.02879363e-01f, 1.40688466e-02f,
  3.44719708e-01f, -8.77815709e-02f, 2.98807710e-01f, 6.17554374e-02f, -3.00928742e-01f, 1.29945621e-01f, -4.31222431e-02f, 3.78403477e-02f, 1.19528882e-02f, 7.61715695e-02f,
  -4.30816300e-02f, 1.65163279e-01f, -4.15309630e-02f, -1.46644516e-02f, 1.98438153e-01f, -1.94692373e-01f, 4.73588035e-02f, -3.58417004e-01f, -1.23812631e-01f, -1.18415669e-01f,
  3.03372204e-01f, 3.09529364e-01f, 1.44513369e-01f, 3.26869428e-01f, 1.05519153e-01f, -9.48529616e-02f, 2.73281038e-01f, 3.07861239e-01f, 5.67432344e-02f, -1.63276345e-01f,
  1.15415730e-01f, 1.78353846e-01f, -2.17447013e-01f, -1.42004639e-01f, 5.90635427e-05f, -2.21798103e-02f, 5.88744842e-02f, 1.34957686e-01f, 2.06512809e-02f, 4.14723158e-02f,
  -8.40257257e-02f, 8.78376141e-02f, -3.81445289e-02f, 6.85653761e-02f, 1.39683723e-01f, -6.90936819e-02f, 3.11000962e-02f, 2.05280595e-02f, 1.09467573e-01f, -2.03983128e-01f,
  8.25276375e-02f, -1.49661362e-01f, -5.06194159e-02f, -1.18978964e-02f, 3.43738109e-01f, -9.41363201e-02f, 1.25436381e-01f, 2.29210109e-01f, 1.95486024e-01f, -1.13805182e-01f,
  3.09802033e-02f, 3.89635786e-02f, 7.07055852e-02f, 1.66760206e-01f, -2.14810312e-01f, 1.66288167e-01f, -7.54925907e-02f, 1.30091280e-01f, -5.41612692e-02f, 1.69460431e-01f,
  -4.70915474e-02f, -8.08532834e-02f, 5.04815727e-02f, 2.68552512e-01f, 1.39973655e-01f, -1.07497573e-01f, 1.96361974e-01f, 5.04828943e-03f, -1.89480931e-01f, 1.70881465e-01f,
  -3.29761989e-02f, 2.90390700e-01f, 3.37255031e-01f, -4.41353202e-01f, 1.26261175e-01f, 1.51296034e-01f, -1.98918551e-01f, -1.17024660e-01f, -8.94471556e-02f, 1.34225756e-01f,
  1.42571062e-01f, 2.89616823e-01f, 3.41669768e-01f, 1.89038455e-01f, -1.16413191e-01f, -7.62047768e-02f, -1.03103362e-01f, -5.93292773e-01f, 1.62559822e-02f, 1.91225559e-01f,
  -8.73809978e-02f, -2.25482639e-02f, -7.21955486e-03f, -2.02505775e-02f, -3.03646941e-02f, -2.68546510e-02f, -1.26569709e-02f, 6.38640998e-03f, 1.43623441e-01f, -1.98637322e-02f,
  2.13926882e-01f, -8.45585391e-02f, 5.97972125e-02f, 1.39423773e-01f, 2.13945374e-01f, 2.08923817e-01f, 4.57887538e-03f, -4.79015224e-02f, -1.69062167e-01f, 4.70978208e-02f,
  -1.11693494e-01f, -1.18582182e-01f, -2.89732754e-01f, 4.52197604e-02f, -9.24806893e-02f, -4.86873746e-01f, -5.02431132e-02f, -2.22988520e-03f, 2.03616381e-01f, -8.18156153e-02f,
  -3.03789936e-02f, -1.46701619e-01f, 1.30651146e-01f, -1.25004664e-01f, 1.20976023e-01f, 2.84167379e-02f, 2.45189071e-01f, -1.97872266e-01f, 1.91483140e-01f, 6.98045455e-03f,
  -1.90647840e-02f, -2.41700962e-01f, -1.29295573e-01f, 6.18859567e-02f, 8.97274911e-02f, -1.26778811e-01f, 1.38955101e-01f, 2.50856549e-01f, 2.39381060e-01f, -1.05601877e-01f,
  -1.28586620e-01f, -3.58570856e-03f, -2.15281382e-01f, 3.36563945e-01f, 1.19365416e-02f, 1.07380636e-02f, 4.56247814e-02f, -6.17966289e-03f, -2.41818745e-02f, 3.27661723e-01f,
  8.81473050e-02f, 2.53459424e-01f, 1.21822484e-01f, 2.40050405e-01f, 7.42630363e-02f, 5.50174415e-02f, -1.79534853e-02f, -4.30155220e-03f, 3.09482291e-02f, 6.17274158e-02f,
  1.57720640e-01f, 3.66802071e-03f, -3.75480503e-02f, 1.04409844e-01f, -1.20827816e-01f, -2.24471644e-01f, 1.90673638e-02f, -2.15433091e-02f, -1.55680940e-01f, 1.34665370e-02f,
  1.01156645e-01f, 2.09171660e-02f, 2.73057163e-01f, -9.16255042e-02f, 2.03707926e-02f, 1.36761025e-01f, 7.05163702e-02f, -1.03516340e-01f, -2.00083956e-01f, 2.83263087e-01f,
  -3.32067251e-01f, 2.21213475e-01f, 2.14859128e-01f, 1.91230163e-01f, 1.15025789e-01f, -2.86154561e-02f, -2.01610878e-01f, 1.56768888e-01f, -9.71989632e-02f, 2.49809660e-02f,
  2.51754761e-01f, 9.75617394e-02f, 6.45319447e-02f, -2.45847642e-01f, 3.13740317e-03f, 6.56563044e-03f, 6.27604499e-02f, -1.03016511e-01f, 1.54953629e-01f, -2.06714153e-01f,
  -1.22164115e-01f, -2.06748769e-01f, 2.56504744e-01f, 3.99733365e-01f, 1.16768435e-01f, 2.36748904e-01f, -2.21315056e-01f, -1.87597871e-01f, 4.55245882e-01f, 2.94960737e-01f,
  -1.53916895e-01f, -4.04381871e-01f, -6.67962879e-02f, 1.30931541e-01f, 1.71564162e-01f, -3.55724812e-01f, 1.73239806e-03f, -1.12547658e-01f, -4.13889922e-02f, 1.09851368e-01f,
  5.80323748e-02f, -6.18914664e-02f, -1.02128983e-01f, 1.15682827e-02f, -1.47222921e-01f, -1.54626533e-01f, -9.88417268e-02f, -1.85879335e-01f, 1.58132493e-01f, -1.17225297e-01f,
  6.54877201e-02f, 5.33320755e-02f, 7.84254894e-02f, 8.39979723e-02f, 9.06343684e-02f, -1.13939598e-01f, 6.59309002e-03f, -1.00481465e-01f, -1.09131277e-01f, 4.73898426e-02f,
  -3.75827798e-03f, 1.26894321e-02f, -1.53649449e-01f, -1.67791188e-01f, 2.79203989e-02f, 6.19586445e-02f, 6.46335557e-02f, 1.65342838e-01f, 5.30231819e-02f, 6.87226877e-02f,
  1.11272208e-01f, 2.78190345e-01f, -1.02569535e-01f, 4.85568903e-02f, 3.76685970e-02f, -1.16861612e-01f, -2.46592630e-02f, -1.76747099e-01f, 1.30250663e-01f, 2.08099067e-01f,
  -1.25998631e-01f, -3.53808366e-02f, 2.05617279e-01f, -2.61198841e-02f, -1.28499120e-01f, -2.99266516e-03f, -1.88835338e-02f, 4.34453189e-02f, -3.91435735e-02f, -4.93963249e-02f,
  1.07535794e-01f, 1.14084698e-01f, 1.94798619e-01f, -2.37140562e-02f, -1.20341986e-01f, -2.02192858e-01f, -2.63146967e-01f, 1.28677681e-01f, 3.39404553e-01f, -3.75179976e-01f,
  -4.36233692e-02f, 1.82246640e-02f, 8.46762210e-02f, 6.97537288e-02f, 1.11119464e-01f, -8.39728937e-02f, -4.84468155e-02f, 8.19973499e-02f, -1.34640262e-01f, -1.98872238e-02f,
  -7.55731165e-02f, 1.36120364e-01f, 1.57374695e-01f, 3.33475061e-02f, -1.92604735e-02f, 6.47170760e-04f, 8.36139079e-03f, 5.34112146e-03f, 1.85925841e-01f, 1.89148664e-01f,
  -1.26425177e-01f, -2.71909684e-02f, -5.37483469e-02f, 2.39333026e-02f, -7.50034628e-03f, 8.30655843e-02f, -6.87935352e-02f, -3.92866343e-01f, -1.61633506e-01f, -1.09482203e-02f,
  3.47256482e-01f, -3.01147457e-02f, -8.77832249e-02f, 1.38618216e-01f, 2.12767035e-01f, 1.02681592e-01f, 6.32456169e-02f, -4.00654599e-02f, 2.06554338e-01f, -1.17454387e-01f,
  3.45493406e-01f, 9.39982384e-02f, -8.98081111e-04f, -1.06713712e-01f, 1.90626800e-01f, -1.40507773e-01f, 2.44227365e-01f, -1.37152866e-01f, -4.91583161e-02f, 1.24154195e-01f,
  1.84763148e-01f, 1.67502791e-01f, -1.10114567e-01f, 1.31943390e-01f, 2.91275978e-01f, -2.75730461e-01f, 1.04302019e-02f, 1.05113514e-01f, -7.44239688e-02f, 6.94986358e-02f,
  2.07557172e-01f, 1.41980678e-01f, 3.66040021e-02f, 2.54801184e-01f, 7.40523338e-02f, 6.07186332e-02f, 5.09554558e-02f, 6.60152361e-02f, 9.10701752e-02f, 5.24876267e-02f,
  2.05328882e-01f, 1.52947724e-01f, 1.22577086e-01f, 1.32324144e-01f, 8.64676908e-02f, 1.59650430e-01f, 1.62549809e-01f, 1.26374260e-01f, 1.90094009e-01f, 2.04399899e-01f,
  5.25898598e-02f, 1.99792117e-01f, 1.32347047e-01f, 1.70746580e-01f, -2.94885904e-01f, -2.07005590e-01f, -9.79151726e-02f, -5.39068393e-02f, 2.43109949e-02f, -7.51170190e-03f,
  2.50124097e-01f, 1.61975414e-01f, 2.26742923e-02f, -1.20866925e-01f, 5.59993051e-02f, 1.77128851e-01f, 2.45784983e-01f, 1.82322726e-01f, -1.45229995e-01f, 4.23367843e-02f,
  1.78589195e-01f, -6.47146255e-02f, 1.69858843e-01f, 8.59400406e-02f, -1.12563990e-01f, 3.45482975e-01f, 9.59963650e-02f, 4.53039557e-02f, 3.75922710e-01f, -3.25499594e-01f,
  1.48438826e-01f, -7.38223270e-02f, -8.64968225e-02f, 1.11015923e-01f, -1.67252153e-01f, -1.15182221e-01f, 1.97808864e-03f, 3.75042826e-01f, 2.31652215e-01f, -1.48520187e-01f,
  -2.41452992e-01f, 8.86691585e-02f, -1.52675450e-01f, 3.20354342e-01f, 1.38746142e-01f, 1.16278462e-01f, -2.79360022e-02f, 2.20238324e-02f, 1.03757583e-01f, 1.68680921e-01f,
  -4.41433899e-02f, 6.54299483e-02f, -1.41865611e-01f, 5.68500869e-02f, 6.77180812e-02f, 1.13676466e-01f, 1.11160278e-01f, -6.44362792e-02f, 2.45251969e-01f, 1.23187996e-01f,
  3.09161954e-02f, 9.64456648e-02f, 7.08189830e-02f, 2.85617094e-02f, -5.75318597e-02f, 1.81860384e-03f, 1.21596172e-01f, 1.51347116e-01f, -1.85028523e-01f, 1.74963102e-01f,
  3.18369386e-03f, 2.33933367e-02f, 2.39803210e-01f, 6.94954619e-02f, -1.94912687e-01f, 1.96292907e-01f, -3.44244152e-01f, 1.65519357e-01f, 4.33925778e-01f, -1.47817671e-01f,
  3.01515043e-01f, -1.10144429e-01f, -1.67352453e-01f, -1.38251886e-01f, 2.64046304e-02f, -1.57218903e-01f, -5.66964224e-02f, -1.65445954e-01f, 3.69915105e-02f, -5.46680987e-02f,
  1.72153026e-01f, -8.01105872e-02f, 1.54622197e-01f, -1.86846796e-02f, -5.88606903e-03f, -3.14271033e-01f, 1.23442687e-01f, 4.17697504e-02f, 3.75652164e-01f, 3.91430378e-01f,
  1.63417667e-01f, 1.01163231e-01f, 5.04497625e-02f, -1.35289431e-01f, 3.54901880e-01f, 3.29731733e-01f, -7.26013705e-02f, -3.15761149e-01f, 3.12926978e-01f, 3.15679222e-01f,
  -2.22651273e-01f, -2.66655624e-01f, 2.13963032e-01f, -5.31182289e-02f, 1.27400339e-01f, 9.25167575e-02f, -1.46462277e-01f, -1.66592866e-01f, -2.02654712e-02f, 1.12922706e-01f,
  -4.80615795e-02f, 9.04514641e-02f, -6.02319539e-02f, 5.36831059e-02f, 6.91653639e-02f, 1.90668419e-01f, -5.99071644e-02f, 1.02830820e-01f, 1.65372148e-01f, 7.33258426e-02f,
  2.24190384e-01f, 6.40037507e-02f, -2.77530551e-01f, 7.23236948e-02f, -3.74345891e-02f, -1.00248910e-01f, 1.28349364e-01f, -1.06021366e-03f, -1.40669748e-01f, -3.52003157e-01f,
  -1.68733105e-01f, -1.92900281e-02f, 2.35209450e-01f, 1.29521206e-01f, 1.00308202e-01f, 6.35892677e-04f, 3.05763334e-02f, 3.05833444e-02f, 2.11299062e-01f, -1.36492908e-01f,
  -1.13663925e-02f, -8.16679522e-02f, 6.02821946e-01f, 3.60101536e-02f, -2.90482193e-01f, 6.77081421e-02f, 1.43656984e-01f, 6.17747977e-02f, 2.64576077e-01f, 2.05246136e-01f,
  -5.50709851e-02f, -2.27609295e-02f, 4.74861830e-01f, 2.92665571e-01f, -4.33830172e-01f, 3.03794861e-01f, 3.11289489e-01f, -1.68440804e-01f, 1.12111546e-01f, -2.33816318e-02f,
  6.17031492e-02f, 1.32100254e-01f, -1.28017530e-01f, 3.75939578e-01f, -5.61023392e-02f, 1.26950473e-01f, 2.53737003e-01f, 3.20005774e-01f, 2.00222135e-01f, 6.24518879e-02f,
  -4.84111067e-03f, 2.32367441e-01f, 5.68916602e-03f, 1.38127431e-01f, 3.26032668e-01f, 2.83682764e-01f, 2.93736786e-01f, 5.11285402e-02f, -3.54200564e-02f, 1.22630939e-01f,
  1.67961240e-01f, 1.18903242e-01f, 2.35389918e-01f, 6.00380003e-02f, 3.02793607e-02f, -4.00256850e-02f, 5.70088141e-02f, -2.05760896e-02f, 9.61012393e-02f, 4.42599431e-02f,
  1.16240419e-01f, -3.67356777e-01f, 4.56129499e-02f, 1.45998478e-01f, -6.64536059e-02f, 5.90858012e-02f, 7.21256584e-02f, 1.32622793e-01f, 3.42135459e-01f, -7.01359510e-02f,
  -6.57768786e-01f, 1.89460650e-01f, -1.53437376e-01f, 2.16629356e-01f, 1.56641752e-01f, 7.30327964e-02f, 2.52943963e-01f, 3.60458672e-01f, -1.35770410e-01f, -1.69710085e-01f,
  -3.64949135e-03f, 1.80876717e-01f, 2.00631514e-01f, -6.75674304e-02f, 5.48181273e-02f, 2.41438020e-02f, 1.63927108e-01f, 4.53884035e-01f, -3.22053075e-01f, 2.03160092e-01f,
  -1.15439206e-01f, -5.55317439e-02f, 9.33983102e-02f, 1.79450020e-01f, 1.30605981e-01f, -3.51603836e-01f, -2.54581541e-01f, 1.40030786e-01f, -2.38793239e-01f, -1.04115255e-01f,
  1.84343886e-02f, 9.30633619e-02f, -1.14088794e-02f, 9.71494392e-02f, 6.72655106e-02f, -3.51306498e-02f, 1.79448381e-01f, 2.70471722e-02f, 1.45727798e-01f, 7.18473047e-02f,
  1.06305629e-02f, 7.90010393e-02f, 2.56656587e-01f, -1.62312407e-02f, 6.42389953e-02f, 3.00706565e-01f, 2.58032344e-02f, 9.45877060e-02f, 1.56438917e-01f, -6.98721781e-02f,
  -1.68940589e-01f, 2.38400877e-01f, -1.13389947e-01f, -2.17061684e-01f, -1.76439688e-01f, -1.74237609e-01f, -4.06449065e-02f, -1.78629816e-01f, -2.59170920e-01f, 3.88928615e-02f,
  7.52874240e-02f, -3.64610963e-02f, 1.97302982e-01f, 2.18897909e-02f, -1.37930643e-02f, -1.58291548e-01f, 1.35311261e-01f, -1.78332910e-01f, 1.56062078e-02f, -3.96433547e-02f,
  1.19899191e-01f, 6.92375675e-02f, -9.02688205e-02f, -1.20681413e-01f, -1.52905315e-01f, -1.69746384e-01f, -2.04940349e-01f, -2.09871367e-01f, 2.09168777e-01f, 1.75928146e-01f,
  1.07059330e-01f, 1.23643614e-01f, 1.07664540e-01f, -2.24259168e-01f, 1.91290542e-01f, 1.81007504e-01f, 3.62024635e-01f, -1.32384539e-01f, 4.44418080e-02f, -2.87793845e-01f,
  2.10842997e-01f, 3.58885586e-01f, 5.51652610e-02f, -1.68056831e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  1.62373688e-02f, -5.37094921e-02f, 2.03177948e-02f, 9.08238143e-02f, 1.38272077e-01f, 2.24816233e-01f, 2.12158516e-01f, 1.27188981e-01f, -3.25399488e-02f, -2.13703960e-02f,
  7.45171979e-02f, 2.26467103e-01f, 1.88440636e-01f, -4.11796235e-02f, 2.82702327e-01f, 1.86036974e-01f, -2.41860282e-02f, 1.01957746e-01f, 1.12636849e-01f, -3.13620627e-01f,
  -6.50623888e-02f, 2.14636907e-01f, 1.35221690e-01f, 6.18397482e-02f, 7.66004995e-02f, 5.83684519e-02f
};

// L2_fan_Wp (Shape: 19 x 64)
const int L2_fan_Wp_rows = 19;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  1.10783421e-01f, -1.69526324e-01f, -9.86442193e-02f, -1.06079683e-01f, -1.09984100e-01f, 1.51325941e-01f, -1.98135860e-02f, -1.35680318e-01f, -1.11619323e-01f, -4.50671613e-02f,
  1.40410885e-01f, 1.10481352e-01f, 2.67984390e-01f, -1.58583134e-01f, -7.35468939e-02f, 1.59207568e-01f, -1.91413239e-01f, -4.75488082e-02f, -1.53800830e-01f, -4.09587175e-02f,
  -5.27509041e-02f, 1.47713879e-02f, -2.24293303e-02f, 2.73499824e-02f, 1.13142349e-01f, -9.21893641e-02f, 1.70327514e-01f, 7.45253218e-03f, 8.36371034e-02f, -2.16107637e-01f,
  -1.06979281e-01f, -6.56243861e-02f, -2.67975423e-02f, -1.12696681e-02f, -3.68796848e-02f, 7.53683131e-03f, 5.71429580e-02f, 4.28296149e-01f, 4.18165661e-02f, -5.96799180e-02f,
  -2.70804558e-02f, -6.17681034e-02f, 1.70244634e-01f, -1.24531634e-01f, 5.98072745e-02f, -3.54195433e-03f, -1.06255583e-01f, 2.04504520e-01f, 1.38719499e-01f, -7.02952817e-02f,
  3.01492691e-01f, 1.11839578e-01f, 2.07165778e-01f, -8.04601386e-02f, -1.36000976e-01f, -1.08509518e-01f, 7.49422982e-02f, -8.10909271e-02f, 1.02095872e-01f, 4.17725109e-02f,
  -4.25534397e-02f, 1.14386261e-01f, 5.27714416e-02f, -3.50624651e-01f, -8.22770968e-02f, 1.27353683e-01f, 1.30199522e-01f, 5.62163703e-02f, -1.44853741e-01f, -3.20800059e-02f,
  1.43499509e-01f, -5.97253814e-02f, 6.72190338e-02f, 1.18397050e-01f, 6.84585236e-03f, 4.40913215e-02f, -2.17745397e-02f, 1.37637034e-01f, -1.29153520e-01f, 1.77286997e-01f,
  -4.58080262e-01f, -1.89900286e-02f, -2.65386607e-02f, 1.67284712e-01f, 8.88788104e-02f, -1.34875506e-01f, 2.65453666e-01f, -8.24433342e-02f, 3.21414590e-01f, -1.43613428e-01f,
  1.02223270e-01f, -1.48324117e-01f, 4.92299758e-02f, -1.35022789e-01f, 1.03684561e-02f, -1.12977549e-01f, -8.39833319e-02f, 1.12020351e-01f, 8.32827985e-02f, -7.69972196e-03f,
  8.90677571e-02f, -1.79295316e-02f, -7.36035854e-02f, 2.60270350e-02f, -1.43608809e-01f, -1.86158627e-01f, -4.05961573e-02f, -1.46704942e-01f, 2.46394485e-01f, 8.80728709e-04f,
  2.71324992e-01f, 3.00674066e-02f, 4.03842553e-02f, 4.32966929e-03f, -6.20767847e-02f, 8.21033400e-03f, 2.04328910e-01f, 1.07352093e-01f, -3.02542560e-02f, -8.64318311e-02f,
  -3.75627168e-02f, -1.00106999e-01f, -1.88522950e-01f, -6.62582666e-02f, 9.33859721e-02f, -2.32485030e-02f, 1.60991833e-01f, 1.86268277e-02f, -1.46719158e-01f, -9.61449370e-02f,
  -3.42540473e-01f, -2.45378822e-01f, -2.00464785e-01f, -2.00402305e-01f, -1.33023396e-01f, -2.32523367e-01f, -2.80700117e-01f, -8.05104673e-02f, -1.39537916e-01f, -6.38342425e-02f,
  3.89489881e-03f, -2.55668938e-01f, -2.92130649e-01f, 3.10646351e-02f, -9.20359641e-02f, -2.15834871e-01f, -3.52376878e-01f, -7.02570900e-02f, 6.73307329e-02f, -1.38078826e-02f,
  4.57725465e-01f, -2.63408214e-01f, 1.81083649e-01f, -6.17416985e-02f, -1.40520662e-01f, 8.08146875e-03f, 6.17154948e-02f, -1.83120981e-01f, -1.54325962e-01f, -7.24269673e-02f,
  -3.38871300e-01f, 4.22434099e-02f, -1.33090839e-01f, -4.94614951e-02f, 1.11516165e-02f, -1.29096329e-01f, 7.19125643e-02f, -1.61435753e-01f, -2.06875712e-01f, 9.65251178e-02f,
  1.74498215e-01f, -6.16962537e-02f, -7.47740641e-02f, 1.51651070e-01f, -3.68905924e-02f, 1.18215017e-01f, -9.06642377e-02f, -4.25801538e-02f, -1.63650244e-01f, -3.70434336e-02f,
  -1.56027183e-01f, 1.38078034e-01f, -9.40319598e-02f, 1.58828035e-01f, 1.66318715e-01f, 1.81745559e-01f, 3.13504972e-02f, 1.43252313e-01f, 9.50477868e-02f, 5.98779172e-02f,
  -7.60737509e-02f, -1.98103040e-02f, 4.38765027e-02f, 1.54548705e-01f, 2.11867988e-01f, 1.73645124e-01f, 2.51024932e-01f, -8.94422829e-02f, -1.37949795e-01f, 1.26794711e-01f,
  5.27859405e-02f, 1.16455771e-01f, -1.60936594e-01f, -3.40330712e-02f, -1.64382845e-01f, 3.06672812e-01f, 2.18573764e-01f, -7.44315982e-02f, 1.55899361e-01f, 2.51242761e-02f,
  -2.61628386e-02f, 3.51484604e-02f, -5.77535853e-02f, 8.87641311e-02f, 7.71313161e-02f, -7.21969083e-02f, -2.08885834e-01f, -5.58648147e-02f, 5.18704541e-02f, 7.77477995e-02f,
  1.01363204e-01f, 4.49591614e-02f, 1.37355119e-01f, 2.61265840e-02f, 2.70069670e-02f, 6.59798086e-02f, 2.48380005e-01f, -1.15548313e-01f, -1.11578234e-01f, -2.34765559e-02f,
  -3.33296210e-02f, 8.39694068e-02f, 1.16954789e-01f, 9.96797439e-03f, -2.41517425e-01f, 2.33122051e-01f, -9.99677703e-02f, -1.54602483e-01f, 1.05852991e-01f, -7.47388750e-02f,
  1.37890741e-01f, 2.01888680e-01f, 2.20907331e-02f, -7.54757971e-02f, 5.24832495e-03f, -1.44814085e-02f, 1.87650412e-01f, 7.70857781e-02f, -6.83141574e-02f, 1.48780614e-01f,
  -1.76664159e-01f, -1.78252548e-01f, -2.40978822e-02f, -4.97387387e-02f, 2.81561837e-02f, 1.09743051e-01f, -1.79996267e-01f, 1.18529312e-01f, 2.22602546e-01f, 1.85302928e-01f,
  -2.25793511e-01f, 2.22721308e-01f, 6.05276227e-02f, 2.17406809e-01f, 1.41682014e-01f, 1.31173253e-01f, -1.97287336e-01f, 9.34085622e-02f, 6.19994178e-02f, 3.04817379e-01f,
  -7.17197135e-02f, 8.11460167e-02f, -1.40319914e-01f, 1.62687942e-01f, 3.00267905e-01f, 2.08910868e-01f, 2.34105334e-01f, -2.07932815e-01f, 1.65280610e-01f, -9.25107673e-02f,
  4.88697141e-02f, -8.18192214e-02f, 1.29086524e-01f, -1.08926855e-01f, -7.23895878e-02f, 2.58035362e-01f, -5.72741218e-03f, -5.72853386e-02f, 7.28185847e-03f, 1.43706188e-01f,
  -8.53384659e-03f, -2.11147040e-01f, -1.30922332e-01f, -2.96908200e-01f, 1.70217827e-02f, 1.17100365e-01f, 1.09783933e-01f, 5.46453632e-02f, -1.73686862e-01f, 1.19946912e-01f,
  -1.03293478e-01f, -1.49517030e-01f, 1.35796010e-01f, -1.17895760e-01f, 1.28504381e-01f, 1.29876779e-02f, -6.96234405e-03f, -1.37122154e-01f, -1.35352001e-01f, -8.73536896e-03f,
  9.54002663e-02f, 1.77388877e-01f, 9.50124264e-02f, -3.38066891e-02f, -1.27203539e-01f, 1.39445201e-01f, -4.19659875e-02f, -6.53310418e-02f, 9.94041413e-02f, 6.81664795e-02f,
  -1.10580616e-01f, 1.66453850e-02f, -3.20045352e-02f, -4.93678823e-02f, -8.80410224e-02f, -4.02073115e-02f, 2.80334651e-02f, 9.64363366e-02f, -1.47815635e-02f, 1.25689566e-01f,
  -9.70352888e-02f, 1.83613447e-04f, 8.53572860e-02f, -1.60249341e-02f, 1.47693560e-01f, -1.54564483e-02f, 1.08589619e-01f, -4.06738231e-03f, -1.46847665e-01f, 1.14625774e-01f,
  -2.05637470e-01f, -1.79039985e-01f, 1.67936608e-02f, -1.64300919e-01f, -2.63204366e-01f, -7.91926458e-02f, -8.16374645e-03f, -1.07056843e-02f, -1.66028127e-01f, 2.96103116e-02f,
  2.08095655e-01f, 1.23638518e-01f, -3.54750574e-01f, 1.93623960e-01f, 1.84609488e-01f, -1.78405851e-01f, -3.05444241e-01f, 1.05325365e-02f, 1.11320049e-01f, 1.72976226e-01f,
  1.34707540e-01f, -2.18813587e-02f, -2.61313826e-01f, 1.32740904e-02f, 3.55888507e-03f, -1.24670722e-01f, 5.31664491e-02f, -1.15345754e-01f, -2.39568558e-02f, 6.91495761e-02f,
  5.16741723e-02f, -9.69974473e-02f, 3.88300642e-02f, 2.43933380e-01f, 2.05699980e-01f, 1.65006202e-02f, -1.07986338e-01f, -2.47109443e-01f, -1.04924161e-02f, -8.02586973e-02f,
  1.78144038e-01f, 1.19416088e-01f, 3.23873490e-01f, 4.18302044e-02f, -7.68647492e-02f, 9.10136290e-03f, -2.00881705e-01f, -7.20398799e-02f, -9.68075842e-02f, 1.37051970e-01f,
  -2.69437760e-01f, -2.59190679e-01f, 1.05611660e-01f, 2.66008880e-02f, 4.36306261e-02f, 1.60927903e-02f, 2.12496333e-02f, -4.91904691e-02f, 9.26730502e-03f, -1.58947613e-02f,
  -3.94745842e-02f, -5.85249141e-02f, 3.13316956e-02f, 8.01037177e-02f, -8.93744268e-03f, -1.71853036e-01f, -2.33145118e-01f, -1.66682735e-01f, 1.78000107e-01f, 9.45365280e-02f,
  1.35089934e-01f, 3.23757483e-03f, -8.37315992e-02f, -2.20282674e-01f, -2.36602545e-01f, 1.20732486e-01f, 1.49379969e-01f, -9.52856168e-02f, -1.23238586e-01f, 3.62293161e-02f,
  1.98086604e-01f, -9.80314687e-02f, 1.02576446e-02f, -9.35285538e-03f, 3.76845300e-02f, -1.13553755e-01f, 1.70211092e-01f, 6.12008981e-02f, 1.57445520e-01f, 4.16946374e-02f,
  -8.24554414e-02f, -1.20365005e-02f, 6.00771457e-02f, 1.65191013e-02f, -2.25140184e-01f, 2.48340696e-01f, 1.38888359e-01f, -8.54465365e-02f, -3.27984504e-02f, -2.32402638e-01f,
  2.26553485e-01f, 2.65246809e-01f, -1.24625564e-01f, -5.80888353e-02f, -4.44160961e-02f, -1.87986568e-01f, -2.30418071e-01f, 5.03651612e-02f, 1.43436298e-01f, -8.03250074e-02f,
  -1.89662967e-02f, 1.26916513e-01f, 9.67577770e-02f, -9.94305834e-02f, -6.77712113e-02f, -2.69722026e-02f, 2.52323955e-01f, -1.22344039e-01f, 2.17363328e-01f, 7.78393000e-02f,
  -8.46997797e-02f, -1.58949792e-02f, 5.33977859e-02f, -1.09279994e-02f, 3.49965751e-01f, 1.52322799e-01f, 1.26713619e-01f, 1.92357581e-02f, 7.05785826e-02f, 3.49802077e-01f,
  -1.33658901e-01f, 8.68599266e-02f, 6.58049732e-02f, 1.37043282e-01f, 2.09386736e-01f, -2.67088134e-02f, -1.76323056e-01f, -2.00010717e-01f, 1.06928237e-01f, 1.00496098e-01f,
  -8.97939783e-03f, 1.71723291e-01f, 1.56498030e-01f, -2.06246406e-01f, 2.47101188e-01f, -9.32739452e-02f, -3.52527061e-03f, 6.10519722e-02f, -3.18087004e-02f, 7.04166293e-02f,
  1.72522947e-01f, -5.51569462e-02f, -7.83120990e-02f, 1.78335458e-01f, -6.33023083e-02f, 5.03185987e-02f, -8.20611864e-02f, 1.27355382e-01f, 8.53371993e-02f, -1.23425521e-01f,
  1.14999264e-01f, -2.08920270e-01f, -1.45295009e-01f, 8.18629190e-02f, -1.12239309e-01f, 5.70938475e-02f, -7.59496167e-02f, 1.74241394e-01f, -3.15664411e-01f, -2.92711798e-02f,
  3.27096321e-02f, 2.06225544e-01f, -2.27243230e-01f, -2.61768281e-01f, -5.67612872e-02f, 1.46224886e-01f, 1.93180442e-01f, 1.85666904e-01f, -1.52353346e-02f, -1.06697157e-01f,
  -4.44951579e-02f, 1.05612520e-02f, -2.13003494e-02f, -9.79831368e-02f, 1.26645416e-01f, 1.86343580e-01f, 6.03230372e-02f, 1.12389447e-02f, 1.65680677e-01f, 5.99157736e-02f,
  1.92518488e-01f, 3.41032058e-01f, -1.01889931e-01f, -5.61905876e-02f, -1.17837034e-01f, 1.35575861e-01f, -1.15239315e-01f, -3.66326086e-02f, 2.41762817e-01f, 1.08899511e-01f,
  1.63739040e-01f, 2.56345958e-01f, 1.69457629e-01f, -8.11502784e-02f, -1.38937071e-01f, 5.64611591e-02f, 1.88225850e-01f, 2.03609973e-01f, -2.19961286e-01f, -1.33922130e-01f,
  2.85859889e-04f, -1.10638119e-01f, -1.09183215e-01f, 8.87079090e-02f, -9.27205980e-02f, 7.81284645e-02f, 7.09944870e-03f, 1.05755858e-01f, 7.00487872e-04f, -1.07877418e-01f,
  -7.14979991e-02f, 1.55710936e-01f, -1.50331929e-01f, -2.03830287e-01f, -2.78287292e-01f, -7.25248829e-03f, 1.39807612e-01f, -7.80058131e-02f, -1.23041108e-01f, -5.89746386e-02f,
  9.40221027e-02f, 6.11138791e-02f, 1.86602697e-01f, 6.99547678e-02f, 9.71916541e-02f, 1.24731503e-01f, 7.58459568e-02f, -8.16060305e-02f, 1.54236227e-01f, 7.28094503e-02f,
  9.62480456e-02f, 6.01465488e-03f, 2.65412271e-01f, -4.59846668e-03f, 7.92404786e-02f, -8.29546899e-02f, 2.82414436e-01f, 7.02783316e-02f, 4.08740230e-02f, -2.03189388e-01f,
  8.50104615e-02f, 1.10405914e-01f, 3.13774273e-02f, 4.26903789e-05f, 3.46175060e-02f, -3.63691896e-01f, 1.39463171e-01f, 2.35651009e-04f, -1.95920765e-01f, -3.05773038e-02f,
  2.83785641e-01f, -8.48510936e-02f, -2.02444196e-01f, 5.97715005e-02f, 2.31629908e-01f, 2.20367372e-01f, -7.26476833e-02f, -1.05149433e-01f, 9.35248379e-03f, 1.45845190e-01f,
  -1.38049573e-01f, -1.80025756e-01f, 9.73812714e-02f, -1.91449881e-01f, -2.19168708e-01f, -1.95899606e-01f, -2.71626830e-01f, 6.38394952e-02f, 1.20002553e-01f, 1.86510663e-02f,
  1.29083604e-01f, 1.69302508e-01f, -1.08031683e-01f, -2.35551775e-01f, -6.43088296e-02f, 2.20687538e-01f, -1.51504323e-01f, 3.01802121e-02f, 1.01988502e-01f, 8.28301087e-02f,
  7.77828787e-03f, -1.81326382e-02f, 2.92572863e-02f, -7.45902061e-02f, -1.06758736e-02f, 1.16551042e-01f, 9.63415131e-02f, 8.30353275e-02f, 3.72913443e-02f, -9.23857316e-02f,
  -7.78294429e-02f, 1.45026609e-01f, 7.17448071e-02f, 5.18978462e-02f, -1.86158434e-01f, -1.92610621e-02f, 1.21075407e-01f, 2.81508356e-01f, -1.33377248e-02f, 6.55634655e-03f,
  -1.48785993e-01f, -8.25275779e-02f, 9.97114088e-03f, 1.93483710e-01f, 3.49994823e-02f, -7.75895566e-02f, -2.74419993e-01f, -1.38604060e-01f, -9.60091278e-02f, 2.92257369e-01f,
  -2.83289645e-02f, 6.21970445e-02f, 1.28533453e-01f, -3.76624130e-02f, -1.72663301e-01f, 7.08207935e-02f, -2.30576292e-01f, -8.00342634e-02f, 6.47644326e-02f, 1.86201215e-01f,
  1.59560814e-01f, 2.55504370e-01f, 1.08720221e-01f, -3.89107652e-02f, -7.74756968e-02f, -1.68766499e-01f, -2.10252270e-01f, 3.28369252e-02f, 5.90491341e-03f, 1.88889951e-01f,
  -3.80788296e-02f, 1.16005160e-01f, -3.32054108e-01f, 4.27265018e-02f, 5.35867140e-02f, -1.00528888e-01f, 5.53406775e-02f, -1.25488013e-01f, 1.57000124e-02f, -6.21377528e-02f,
  -3.68380845e-02f, 1.07944004e-01f, 3.58151272e-02f, 1.40845045e-01f, 6.55918941e-02f, 2.37698093e-01f, 1.14566363e-01f, 6.27809763e-02f, -1.00918815e-01f, -1.99261978e-01f,
  8.35903436e-02f, -6.93123937e-02f, 2.14471556e-02f, 1.85074121e-01f, -9.32292640e-02f, 1.76480651e-01f, -1.67571567e-02f, -5.13599673e-03f, -1.37909234e-01f, 7.70532563e-02f,
  1.55880988e-01f, -2.00681031e-01f, -1.66037790e-02f, -1.34870321e-01f, 1.22873291e-01f, 4.69098464e-02f, 3.21369283e-02f, -1.16054937e-01f, -1.11723430e-01f, -1.56739913e-02f,
  -2.51745433e-01f, -4.92917039e-02f, -1.31026313e-01f, 6.55238181e-02f, 1.29874051e-01f, 2.65215933e-01f, -6.97315037e-02f, 6.09506927e-02f, 2.71682262e-01f, 8.86692405e-02f,
  2.18943655e-01f, -4.54032384e-02f, -1.99098676e-01f, -1.43171176e-01f, 1.42073274e-01f, 1.48464233e-01f, -1.78352237e-01f, 4.28927392e-02f, -1.69183522e-01f, -1.29137993e-01f,
  1.71016499e-01f, 4.27788645e-02f, 9.16611403e-02f, 1.65016741e-01f, 2.28502944e-01f, 8.69968906e-02f, 1.11427836e-01f, 4.99801114e-02f, 2.65821129e-01f, -9.02975351e-02f,
  -1.10470131e-02f, 2.38544390e-01f, 5.25831394e-02f, 1.03746224e-02f, 1.35178059e-01f, -7.24045560e-02f, 2.23140381e-02f, -1.34228766e-01f, -1.11525469e-01f, -1.17417291e-01f,
  -9.34548303e-02f, -6.02212809e-02f, -5.25310636e-02f, 9.29442002e-04f, -1.87140360e-01f, -1.37401044e-01f, 1.27488822e-01f, -1.59031048e-01f, 3.70359905e-02f, -1.64905101e-01f,
  -4.84813675e-02f, 1.19440496e-01f, 1.17905559e-02f, -3.55150923e-02f, -9.12341252e-02f, 1.31366372e-01f, -1.33342013e-01f, -4.95826788e-02f, -5.39183319e-02f, -1.88866243e-01f,
  -2.37480551e-01f, 2.33139768e-02f, 2.94596106e-01f, -4.34464291e-02f, 3.62299979e-01f, -1.00653216e-01f, 1.49086908e-01f, 1.70772113e-02f, -2.43679315e-01f, 6.77647144e-02f,
  1.69164781e-02f, 3.58818972e-04f, -5.97922690e-02f, -1.57310545e-01f, -4.17832993e-02f, -9.40576717e-02f, -1.17700942e-01f, 2.25094751e-01f, -1.83586568e-01f, -7.06256256e-02f,
  8.83772448e-02f, -7.42404833e-02f, 1.04048692e-01f, 7.47324526e-02f, 1.41808111e-02f, -1.65373906e-01f, -1.67791203e-01f, -2.27701336e-01f, 2.28496101e-02f, 1.32201035e-02f,
  1.93548292e-01f, 1.52487233e-01f, -1.63905755e-01f, 8.61745328e-02f, -6.96418509e-02f, -7.22978413e-02f, -5.11790738e-02f, 2.71133453e-01f, -1.89542204e-01f, -2.59467261e-03f,
  7.77260959e-02f, 5.43931685e-02f, 1.54176950e-01f, 1.32352978e-01f, -1.01276830e-01f, -4.67914231e-02f, 1.44425973e-01f, -2.91881394e-02f, 2.45658755e-02f, -1.71478174e-03f,
  -2.85579771e-01f, 1.08472958e-01f, -9.84004512e-02f, -2.36661345e-01f, -6.46217763e-02f, 1.02338511e-02f, 6.14910685e-02f, -3.65296640e-02f, -1.97780401e-01f, -1.83864892e-01f,
  -3.17499459e-01f, -2.80362647e-02f, 7.43705854e-02f, -1.28489360e-01f, 2.70614978e-02f, -5.96844330e-02f, -1.18375257e-01f, 6.80613965e-02f, 3.24180752e-01f, 3.47667672e-02f,
  -1.31563321e-01f, 2.30455101e-02f, -3.80145013e-02f, 1.33412763e-01f, 2.34915297e-02f, -1.61715433e-01f, -3.14404741e-02f, -2.80815810e-02f, 1.44089013e-01f, 6.32169694e-02f,
  -1.46997981e-02f, -6.45473227e-02f, -1.06966242e-01f, 1.48294345e-02f, -3.48930717e-01f, -2.59700924e-01f, 8.42983052e-02f, -1.67671666e-01f, -1.50838047e-01f, 4.48650233e-02f,
  4.24274281e-02f, -1.30958959e-01f, -8.47567394e-02f, -5.03478460e-02f, -7.30668083e-02f, -1.05515188e-02f, 7.93770552e-02f, 1.81910530e-01f, -9.26501378e-02f, 7.57052600e-02f,
  1.15162455e-01f, 4.44215611e-02f, 1.32502317e-01f, 6.16589375e-02f, -6.28496110e-02f, -9.45057720e-02f, 1.20767402e-02f, 1.01318352e-01f, -9.10101533e-02f, 2.05442220e-01f,
  9.05546024e-02f, 1.26483098e-01f, 2.45389827e-02f, 2.56377906e-01f, -5.42592146e-02f, -1.09331548e-01f, -1.04207002e-01f, -3.48556846e-01f, -1.78325891e-01f, -1.15543403e-01f,
  -1.35938346e-01f, -1.43219128e-01f, -5.30312322e-02f, -2.97508031e-01f, -3.24610829e-01f, -1.22869126e-01f, -6.19413108e-02f, -5.73016927e-02f, -2.38431513e-01f, -4.28140722e-02f,
  -1.90335065e-01f, -7.92241916e-02f, -1.35716408e-01f, -1.36624739e-01f, -1.56545117e-01f, 9.37547628e-03f, 4.88066376e-04f, -9.48870257e-02f, 3.08444113e-01f, -2.64688224e-01f,
  8.02670345e-02f, -2.07814686e-02f, -1.67027012e-01f, 5.08273132e-02f, 1.61956206e-01f, -1.11011647e-01f, -1.93297818e-01f, 3.01770996e-02f, -1.86628282e-01f, -1.57969549e-01f,
  1.66003957e-01f, -6.37707338e-02f, 9.57798287e-02f, -1.36903509e-01f, -9.21835303e-02f, 2.54945327e-02f, -2.23994717e-01f, 3.72014381e-02f, 1.10043131e-01f, -1.43856972e-01f,
  -9.33610722e-02f, 2.92695999e-01f, -1.13828033e-01f, 4.30431291e-02f, 2.06306241e-02f, -3.23601440e-02f, -8.68910104e-02f, 1.60848081e-01f, -2.78127566e-02f, 1.19687527e-01f,
  1.09798387e-01f, 8.10337290e-02f, 7.01396465e-02f, 1.10451812e-02f, 6.26263162e-03f, 3.02031916e-02f, -1.82215601e-01f, 1.08009063e-01f, -1.96002826e-01f, -9.19638574e-02f,
  -5.23681082e-02f, 1.69258248e-02f, 1.23078771e-01f, 3.71501222e-02f, -1.84634045e-01f, 1.38832301e-01f, 8.08084905e-02f, 6.84367632e-03f, -4.24532294e-02f, -3.53194550e-02f,
  -1.70709530e-03f, 7.39364978e-03f, 3.43639613e-03f, -6.19625710e-02f, 3.09367701e-02f, -1.36545122e-01f, -9.51383710e-02f, -5.92214577e-02f, -1.00820854e-01f, 2.89465129e-01f,
  1.71669170e-01f, 4.22872715e-02f, -2.60777086e-01f, -1.12783693e-01f, 1.26741761e-02f, 5.23296669e-02f, 1.12034321e-01f, -1.62329227e-02f, -1.88522320e-02f, 1.61662817e-01f,
  6.48382753e-02f, 2.53077507e-01f, -1.36798443e-02f, 1.11396126e-01f, 1.46432012e-01f, -3.88442487e-01f, -1.41791046e-01f, -1.88455686e-01f, -8.77895728e-02f, -8.84763747e-02f,
  -1.67011142e-01f, 1.95950076e-01f, -4.60405611e-02f, 8.25202912e-02f, -1.97525978e-01f, 6.83446899e-02f, 9.84593555e-02f, 4.47283350e-02f, -1.97305679e-01f, -9.72064734e-02f,
  2.49245778e-01f, -3.34768780e-02f, -1.93730310e-01f, 6.43876120e-02f, 3.23177055e-02f, 8.22070539e-02f, 1.09052360e-02f, -5.46387024e-02f, 4.36850637e-02f, -9.63810682e-02f,
  -5.34897707e-02f, 1.10510796e-01f, -4.36392762e-02f, 1.39070302e-01f, -2.77771745e-02f, -1.20785408e-01f, 4.65719439e-02f, -2.74958685e-02f, -1.43576771e-01f, 8.64836872e-02f,
  8.60039368e-02f, -4.54804040e-02f, -8.97740871e-02f, 2.43849888e-01f, -2.20643044e-01f, 7.35773742e-02f, 2.25732654e-01f, -4.09890637e-02f, -8.59807283e-02f, -2.75575761e-02f,
  -1.43812805e-01f, -8.08459669e-02f, 7.05563277e-02f, 1.02803390e-02f, 9.27504450e-02f, -1.50995672e-01f, -3.98763902e-02f, 6.11547567e-02f, 1.81380957e-01f, -8.29674974e-02f,
  -1.59024615e-02f, 1.47882113e-02f, -1.35323882e-01f, 3.85287374e-01f, -8.70320275e-02f, -1.34890944e-01f, -2.53374316e-03f, -9.72127542e-02f, 1.54876247e-01f, 1.57776117e-01f,
  -9.10245702e-02f, -1.06429696e-01f, 4.55454811e-02f, -1.97302818e-01f, -3.06021143e-02f, 2.11059228e-02f, 1.34491831e-01f, -8.72109085e-02f, -1.80326819e-01f, -8.99182353e-03f,
  3.59695517e-02f, -9.85447243e-02f, -7.64717460e-02f, -2.13303030e-01f, 8.92151743e-02f, 4.26381119e-02f, -1.10106207e-01f, 1.61800340e-01f, -4.41703759e-02f, 7.88600594e-02f,
  -1.75993443e-01f, -2.14022130e-01f, 1.60587654e-01f, 7.09173754e-02f, -7.91505799e-02f, 1.72613397e-01f, -1.50236607e-01f, 8.97478014e-02f, -1.86107650e-01f, -1.87789246e-01f,
  1.46802925e-02f, -4.21310216e-03f, 5.70478402e-02f, -9.47504565e-02f, -1.20234318e-01f, -1.50591969e-01f, 1.71760563e-02f, -3.36686559e-02f, 1.04582338e-02f, -8.19021538e-02f,
  6.91587776e-02f, 2.30046377e-01f, -2.80950308e-01f, 4.93598171e-02f, -6.46687448e-02f, 5.27962521e-02f, -2.18625918e-01f, 1.73388511e-01f, 6.89625135e-03f, -2.34981533e-02f,
  1.55874372e-01f, 2.42195994e-01f, -2.10225910e-01f, -2.00727373e-01f, 2.04425246e-01f, -1.73580144e-02f, 5.17533347e-02f, -1.28601655e-01f, 1.30659774e-01f, -1.40205190e-01f,
  -3.91099066e-01f, -1.14249036e-01f, 7.80814588e-02f, 1.79877251e-01f, -1.95020974e-01f, 1.89220354e-01f, 4.89577502e-02f, 1.29032461e-02f, 6.60085157e-02f, -9.85835418e-02f,
  -3.26441377e-02f, 8.72066617e-02f, 1.28939942e-01f, -8.30203593e-02f, 2.11522505e-01f, 7.86473900e-02f, 1.03081666e-01f, -9.01592001e-02f, 2.22590461e-01f, -1.68583691e-01f,
  -7.91877322e-03f, -5.77752776e-02f, -1.57078907e-01f, 1.62808187e-02f, -3.92592028e-02f, 9.35682207e-02f, 9.88040939e-02f, 1.83945209e-01f, 5.11433072e-02f, -2.21117362e-02f,
  -1.02234028e-01f, 5.28741404e-02f, -1.07716650e-01f, 6.46303669e-02f, 1.13800876e-01f, -3.79367888e-01f, -6.52199090e-02f, -2.90665090e-01f, 5.54686785e-02f, -8.17868710e-02f,
  -1.57593295e-01f, 1.16189076e-02f, -4.45291772e-02f, 1.24186240e-01f, -8.64951909e-02f, -2.88403571e-01f, -3.41621220e-01f, 7.18606412e-02f, -2.29450032e-01f, -2.19548628e-01f,
  -2.91038871e-01f, -2.47633830e-01f, -2.99892902e-01f, 1.02426261e-01f, 2.17284411e-01f, -5.28119430e-02f, -2.70671453e-02f, -6.68293610e-02f, -1.94398567e-01f, -6.92976266e-02f,
  7.70929083e-02f, -1.09416865e-01f, -1.62118524e-01f, 1.98073164e-01f, 1.17971469e-02f, -1.13325812e-01f, -1.82560682e-02f, -3.06114778e-02f, -1.76016226e-01f, -5.80889452e-03f,
  -4.97496221e-03f, 1.27307549e-02f, -1.97907642e-01f, 2.91951820e-02f, -7.49630928e-02f, -3.10116895e-02f, -1.94406267e-02f, 1.30094036e-01f, 8.23863447e-02f, 7.91482404e-02f,
  -1.36432409e-01f, -1.49247766e-01f, 8.14628378e-02f, 1.69448406e-01f, -5.59017621e-02f, -7.78973475e-02f, -1.15095891e-01f, 5.25581837e-02f, 2.17188835e-01f, 1.87099978e-01f,
  1.06748953e-01f, -1.29843622e-01f, 1.03184246e-02f, 7.13485032e-02f, -1.59707472e-01f, 8.39194357e-02f
};

// L2_fan_Wp_bar (Shape: 26 x 64)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  1.23101674e-01f, -9.69891325e-02f, -1.30642474e-01f, 1.10974140e-01f, 1.26288399e-01f, 1.01124875e-01f, -2.92148352e-01f, -2.73043364e-01f, 2.59379923e-01f, 1.96083263e-01f,
  1.33674383e-01f, 1.64435849e-01f, 2.32291877e-01f, 1.04270689e-01f, 7.31690042e-03f, 2.42905065e-01f, 1.79303870e-01f, 2.35304520e-01f, 1.63734257e-01f, -4.44089353e-01f,
  1.98753893e-01f, -1.04869314e-01f, 2.04604003e-03f, -1.49817094e-01f, 2.01649398e-01f, -2.51814634e-01f, 2.10521027e-01f, -8.53378475e-02f, -2.47815952e-01f, -4.11638469e-01f,
  -3.23222309e-01f, -2.86799315e-02f, -2.69499928e-01f, -2.43575782e-01f, 3.00136209e-01f, 2.38373876e-02f, 3.46759677e-01f, 2.00945362e-01f, -1.57151334e-02f, -4.61462922e-02f,
  1.77223403e-02f, 9.30852816e-02f, 6.27356827e-01f, -1.51755571e-01f, 3.27176243e-01f, 2.66014010e-01f, -1.41855732e-01f, 1.01451300e-01f, 1.97588950e-01f, 1.36011511e-01f,
  2.12506756e-01f, -2.46991172e-01f, 3.09975237e-01f, 1.60799086e-01f, -8.18908438e-02f, -1.19831182e-01f, -4.11463916e-01f, -1.77994043e-01f, 1.02406675e-02f, 4.19453889e-01f,
  -1.41670033e-01f, -3.75582953e-03f, 5.97170480e-02f, -1.17381237e-01f, -1.46123385e-02f, -1.17997237e-01f, -1.73419282e-01f, -9.78531614e-02f, 1.19371563e-01f, 1.02730887e-02f,
  -2.37958916e-02f, 7.01602995e-02f, 9.17307436e-02f, 2.85055220e-01f, 2.44783476e-01f, 2.21037306e-02f, 7.11148009e-02f, -7.12879375e-02f, 1.40856683e-01f, 1.15400612e-01f,
  6.07375681e-01f, -1.25702575e-01f, 1.65020853e-01f, -2.26446614e-02f, 3.39783907e-01f, -8.67944956e-02f, -5.90946138e-01f, -5.32148667e-02f, -3.24317545e-01f, -7.40243122e-02f,
  1.89472325e-02f, 1.62837267e-01f, 9.56318751e-02f, 3.14951539e-01f, 3.03104460e-01f, -1.74682319e-01f, -4.37520333e-02f, -7.43831322e-02f, 4.76144850e-02f, -5.48492789e-01f,
  -1.84991598e-01f, -6.18421473e-02f, 7.95550197e-02f, 5.41756973e-02f, 8.49076509e-02f, 3.34443927e-01f, -1.38130207e-02f, -3.10110506e-02f, 2.91547924e-02f, 1.40699700e-01f,
  -3.13087344e-01f, -2.47314036e-01f, 5.75509109e-02f, 3.52972537e-01f, 3.25593740e-01f, -8.75671357e-02f, -1.40607923e-01f, -1.58898719e-02f, -2.74446290e-02f, 2.73617148e-01f,
  1.03290781e-01f, 2.60055333e-01f, 1.77302316e-01f, 1.61656722e-01f, -2.33278256e-02f, 5.81992455e-02f, 3.66315156e-01f, 2.33788550e-01f, 5.15989102e-02f, -3.01649839e-01f,
  -2.30938084e-02f, -1.19070997e-02f, 1.53601661e-01f, -2.34405696e-01f, -3.88736993e-01f, 8.36863741e-03f, -1.04824848e-01f, -4.36800383e-02f, -4.34740670e-02f, 3.08601884e-03f,
  -9.36840326e-02f, -1.67802081e-01f, 2.96382338e-01f, -2.06986278e-01f, 4.63260770e-01f, -2.29184013e-02f, 3.28077599e-02f, -3.37681383e-01f, -5.55660576e-02f, 9.91313532e-02f,
  6.79566786e-02f, 4.15907741e-01f, 3.73922065e-02f, 1.32656053e-01f, 4.48236205e-02f, 8.15729275e-02f, -2.52319366e-01f, -8.85120258e-02f, -2.46851057e-01f, -2.20489744e-02f,
  1.85541417e-02f, -2.80185848e-01f, 5.27712107e-01f, 3.07592005e-01f, 8.67404193e-02f, 1.94761485e-01f, 1.35375917e-01f, -1.34275132e-03f, 2.74779737e-01f, 1.48625508e-01f,
  1.74092636e-01f, 2.01324373e-01f, -1.59903448e-02f, 8.65792558e-02f, 1.12403464e-02f, 2.68128425e-01f, 3.02864492e-01f, 1.48875833e-01f, 2.15575650e-01f, 2.07555369e-01f,
  4.95635942e-02f, -2.58578897e-01f, 1.69316486e-01f, 1.91597462e-01f, 9.63761006e-03f, 9.13892761e-02f, 3.03558886e-01f, 1.04139626e-01f, 1.05141401e-01f, 7.38477428e-03f,
  -3.14412683e-01f, 1.19250827e-01f, 2.01236710e-01f, 3.76556575e-01f, 1.15813464e-01f, 1.38907239e-01f, -2.25397833e-02f, 1.74871802e-01f, 2.40134746e-01f, -5.01023643e-02f,
  1.52991548e-01f, 2.23621830e-01f, 3.85076855e-03f, 1.48075074e-01f, -2.30895847e-01f, 1.85273051e-01f, 3.65356386e-01f, 1.11091353e-01f, 6.05518632e-02f, 1.43792644e-01f,
  9.52304304e-02f, -2.04500839e-01f, -2.48485729e-01f, 2.30615944e-01f, -2.69965082e-01f, 2.23255664e-01f, 8.47676992e-02f, -4.54067215e-02f, -2.21015260e-01f, 4.01784293e-02f,
  8.61396734e-03f, -4.19828333e-02f, -2.19953656e-01f, 8.42434093e-02f, 5.86959004e-01f, 1.35069743e-01f, 4.55881767e-02f, 1.33150592e-01f, 3.23192298e-01f, 1.20754853e-01f,
  2.96704192e-02f, 6.01775646e-02f, -1.91844050e-02f, 3.35039377e-01f, 5.96018173e-02f, 2.42291972e-01f, 4.07357365e-01f, -9.46630761e-02f, 9.79427099e-02f, -2.26662189e-01f,
  5.70794120e-02f, 4.82521772e-01f, -8.95617679e-02f, 6.21120259e-02f, 3.53350908e-01f, 2.41125509e-01f, 4.00600314e-01f, -7.41540939e-02f, 2.27274612e-01f, -2.43458766e-02f,
  -6.00883067e-02f, 1.23345934e-01f, 2.72912234e-01f, -2.58741766e-01f, 4.35008183e-02f, 9.94514525e-02f, 1.42701820e-01f, 2.37118796e-01f, 3.09013665e-01f, 2.98870265e-01f,
  1.53307155e-01f, -1.08594842e-01f, 9.31833312e-02f, 1.56106085e-01f, 7.36914650e-02f, 9.19484198e-02f, 1.90994367e-01f, 2.67048180e-01f, 3.08949631e-02f, -1.54557958e-01f,
  -1.93496644e-01f, 1.93347737e-01f, -2.11823098e-02f, 1.14068754e-01f, 1.09055534e-01f, 2.84795731e-01f, -6.91468688e-03f, -9.97694954e-03f, 1.33623723e-02f, -9.44235772e-02f,
  8.80076066e-02f, -6.26163706e-02f, 3.31281275e-01f, -5.90982921e-02f, -1.12008221e-01f, -1.44087553e-01f, 2.90090591e-01f, -1.11611806e-01f, 4.66228276e-02f, 5.31273544e-01f,
  -3.09032917e-01f, -2.43300185e-01f, -1.06779084e-01f, -5.53629249e-02f, 1.37182683e-01f, 1.60802752e-01f, 3.33023548e-01f, 1.45795837e-01f, -4.62985247e-01f, 1.36112481e-01f,
  9.35124010e-02f, 1.04215927e-01f, 2.54965603e-01f, 2.43691906e-01f, 2.33366832e-01f, -4.64983135e-02f, -1.10884421e-01f, -6.38918504e-02f, 1.30061761e-01f, 1.82689987e-02f,
  2.05708012e-01f, 8.81633312e-02f, 1.28198087e-01f, 3.01120579e-02f, -1.46240070e-01f, -9.17106047e-02f, 1.72746442e-02f, 1.18171327e-01f, 5.36958575e-01f, 4.14625071e-02f,
  9.70669538e-02f, -1.76633429e-02f, 2.33033240e-01f, -1.76509112e-01f, 2.98091590e-01f, -2.38127336e-01f, 6.11954145e-02f, 1.80697650e-01f, -7.89266527e-02f, -1.24752596e-01f,
  1.03335492e-01f, -1.54260444e-02f, 1.86670825e-01f, -1.78028479e-01f, 5.90816140e-02f, 3.38031240e-02f, 3.71506602e-01f, 2.20445823e-02f, 2.69249529e-02f, -1.23875305e-01f,
  1.53571591e-01f, 2.79086649e-01f, -3.42119187e-01f, 3.90037224e-02f, -3.15169871e-01f, -2.56743312e-01f, 9.47297923e-03f, 7.60145709e-02f, 2.91345064e-02f, 4.96857651e-02f,
  3.40286911e-01f, -2.98330963e-01f, -2.58345127e-01f, 3.82330902e-02f, 1.39229789e-01f, -3.91738862e-01f, -4.00716096e-01f, -7.27652833e-02f, -1.31412998e-01f, -4.47995737e-02f,
  3.37511823e-02f, 1.80432305e-01f, -2.76924148e-02f, -1.53808924e-03f, 1.57238111e-01f, -1.92400351e-01f, -2.98704626e-03f, -5.14645576e-02f, -1.09086633e-02f, 2.87110597e-01f,
  4.68876600e-01f, 1.11391403e-01f, 7.21220002e-02f, -3.05659622e-01f, 1.68338478e-01f, 3.04176241e-01f, -1.19341776e-01f, -1.18407972e-01f, 2.49010008e-02f, 8.26905891e-02f,
  8.48320425e-02f, 1.51996300e-01f, -8.92091170e-02f, 1.44101202e-01f, 9.58219916e-02f, 9.25350189e-02f, 2.39734486e-01f, 4.31260526e-01f, 1.90533906e-01f, 1.37734905e-01f,
  -1.27771929e-01f, -3.51338610e-02f, 2.21087679e-01f, -1.44206017e-01f, -8.31898116e-03f, -1.14569396e-01f, 1.36907429e-01f, 2.30280563e-01f, -1.19209453e-03f, -8.13613534e-02f,
  -1.47395492e-01f, 1.12459496e-01f, 4.19671059e-01f, 4.30608988e-01f, 1.65176183e-01f, -1.87457148e-02f, 3.25923145e-01f, 1.21516258e-01f, -2.71079876e-02f, 3.40726972e-02f,
  5.67808688e-01f, -7.95377642e-02f, -2.25421593e-01f, 9.54831485e-03f, 5.96728884e-02f, -8.00960585e-02f, 1.68136239e-01f, -2.68162400e-01f, 2.22294927e-01f, 1.18962377e-01f,
  -3.59917022e-02f, -2.57647455e-01f, 2.50610262e-01f, 2.35359952e-01f, 2.75531560e-01f, -8.27902406e-02f, 1.63007945e-01f, 3.30007851e-01f, -2.96564996e-01f, 1.35209501e-01f,
  3.71478975e-01f, 4.99919504e-01f, 2.39557177e-01f, -1.71191603e-01f, -2.67445713e-01f, 2.44187295e-01f, -1.38874456e-01f, -9.08289701e-02f, 1.26400888e-01f, 9.39459726e-02f,
  -1.97897345e-01f, -1.89550415e-01f, 2.75211446e-02f, -3.25697958e-02f, 8.59883502e-02f, 3.27622652e-01f, -1.01696119e-01f, 2.03888342e-01f, -7.63141289e-02f, -1.34368110e-02f,
  7.84484968e-02f, 1.26177639e-01f, 1.33389547e-01f, 3.35644960e-01f, -1.18167214e-02f, 8.34741741e-02f, 8.76214653e-02f, 2.40480334e-01f, 8.11515842e-03f, -3.05150673e-02f,
  3.49430680e-01f, -1.96582824e-02f, -3.37569535e-01f, 2.33294033e-02f, -1.87946364e-01f, 2.53575027e-01f, 1.06455781e-01f, 6.24128938e-01f, -5.67580052e-02f, -4.85703558e-01f,
  1.88987538e-01f, -1.45785600e-01f, -2.27154016e-01f, -2.37735569e-01f, 3.91660392e-01f, -9.82836783e-02f, -5.54334372e-02f, -1.55393395e-03f, 6.84535876e-02f, -4.55013327e-02f,
  -5.26702404e-02f, -3.42440903e-01f, -6.67174160e-02f, 7.95908924e-03f, -4.24763888e-01f, -1.30693004e-01f, 2.60178328e-01f, 1.15558721e-01f, -3.90529744e-02f, -5.42861745e-02f,
  -1.16540473e-02f, -4.65646610e-02f, -1.89883560e-01f, -5.07367030e-03f, 5.38100123e-01f, 2.58564442e-01f, -8.32275003e-02f, 1.22743351e-02f, -1.04618303e-01f, 1.33187354e-01f,
  -3.52642745e-01f, 2.43558392e-01f, -1.23499982e-01f, 6.48482591e-02f, -3.09749637e-02f, -4.87593338e-02f, 1.33373469e-01f, -8.09634551e-02f, 2.73616046e-01f, 3.58761847e-01f,
  1.77461162e-01f, 2.21872747e-01f, -3.05774640e-02f, -2.50065148e-01f, -5.73683083e-02f, -3.30380529e-01f, 3.21696490e-01f, -1.45771757e-01f, -1.05499707e-01f, -9.57566276e-02f,
  -3.60848717e-02f, 1.16878711e-01f, 4.53000776e-02f, -7.91662484e-02f, 1.90366641e-01f, -2.19044060e-01f, 1.54826060e-01f, 5.47020510e-02f, 5.31852067e-01f, -3.64421755e-02f,
  -1.28853872e-01f, -5.82519732e-02f, 2.88698822e-01f, 9.99734253e-02f, -2.97662437e-01f, -9.38608497e-03f, -3.27363014e-01f, -1.78441301e-01f, 1.61434077e-02f, 6.48110807e-02f,
  1.66316509e-01f, 1.23848446e-01f, 1.96096033e-01f, -2.84275472e-01f, -2.09901944e-01f, 1.01496205e-02f, 1.80697739e-01f, -3.77596438e-01f, -3.80683124e-01f, 7.57065639e-02f,
  -9.83237475e-03f, 4.28521037e-02f, 7.95292854e-02f, 1.67961195e-01f, 3.76599059e-02f, 2.32423674e-02f, -3.22131179e-02f, 9.84495506e-03f, -1.30088523e-01f, -1.63251117e-01f,
  -3.53294797e-02f, 1.39539003e-01f, 4.58867937e-01f, 3.04015409e-02f, -9.40897539e-02f, -3.50650363e-02f, -1.18602246e-01f, 2.66345918e-01f, -4.38091792e-02f, 1.41429096e-01f,
  1.75194755e-01f, 1.55161977e-01f, 6.35852814e-02f, 9.37487632e-02f, 8.44329223e-02f, 3.47869068e-01f, -3.79506499e-02f, -2.94034123e-01f, -2.89925873e-01f, -1.44850209e-01f,
  -9.17506739e-02f, 5.15480749e-02f, -3.59317124e-01f, -1.80648476e-01f, -2.32031077e-01f, 3.25038955e-02f, 5.02298772e-02f, -7.72287995e-02f, 5.38160317e-02f, -1.50854036e-01f,
  -2.16009825e-01f, -2.40189478e-01f, -1.78091034e-01f, 2.54703406e-03f, 5.86549491e-02f, -1.27968770e-02f, -1.52956173e-01f, -3.42743605e-01f, 1.39640182e-01f, -2.17422917e-02f,
  8.61863047e-02f, 1.64457127e-01f, 8.98087174e-02f, 3.63433845e-02f, -1.84456989e-01f, 3.95336151e-02f, -2.06497908e-01f, 9.02981758e-02f, -1.10174879e-01f, -5.12912691e-01f,
  1.99678857e-02f, 6.31275415e-01f, 4.57931450e-03f, -8.20716023e-02f, 3.24029386e-01f, 5.48882037e-02f, -1.09050572e-02f, -1.32654101e-01f, 2.88685441e-01f, -7.87367895e-02f,
  1.50701581e-02f, 4.91025537e-01f, 1.75864980e-01f, 3.62808198e-01f, 1.56546831e-01f, -2.05069140e-01f, -7.97140002e-02f, 3.74756336e-01f, 8.15773532e-02f, 3.61772269e-01f,
  1.80163175e-01f, 3.45474258e-02f, 1.92114413e-01f, -2.11666944e-03f, 2.91051805e-01f, 2.71912152e-03f, 3.17023426e-01f, 4.08054858e-01f, 6.93279728e-02f, -3.13838899e-01f,
  2.17232034e-01f, 1.27216861e-01f, 2.49981448e-01f, 5.26122570e-01f, 1.87315494e-01f, 4.57165599e-01f, -2.07545087e-01f, 9.57185999e-02f, 4.24166113e-01f, 2.74109840e-01f,
  -8.11775997e-02f, 1.08675085e-01f, 3.22801679e-01f, 4.32781756e-01f, -1.13401264e-01f, 3.41191083e-01f, -1.24559596e-01f, 3.96829963e-01f, 4.73444521e-01f, -4.20790501e-02f,
  4.85743463e-01f, -4.66901034e-01f, 6.29790011e-04f, 1.58152014e-01f, 2.66335513e-02f, -3.58866900e-01f, 5.22992969e-01f, 1.71068922e-01f, -9.23047662e-02f, 4.02818620e-02f,
  -1.12255201e-01f, -2.40399286e-01f, -1.56701148e-01f, -1.09388947e-01f, 2.78027236e-01f, -5.53218350e-02f, 2.41941251e-02f, -1.79792285e-01f, 1.30019292e-01f, -1.07599813e-02f,
  5.57175279e-02f, -9.19352323e-02f, 2.93942899e-01f, 3.97953764e-02f, -8.87349993e-02f, 3.47615257e-02f, 2.14095965e-01f, 8.63785297e-02f, 1.54226616e-01f, 5.43977246e-02f,
  -1.21810630e-01f, 1.28656656e-01f, 1.36161476e-01f, 1.44398212e-01f, -2.94129193e-01f, -7.18167126e-02f, -9.51356962e-02f, -2.50710368e-01f, 1.98886529e-01f, 2.49121815e-01f,
  8.09641853e-02f, 1.77840903e-01f, 1.39883876e-01f, 5.16213849e-02f, -2.56819054e-02f, 1.58632368e-01f, 3.31649989e-01f, 2.18438983e-01f, 1.07973732e-01f, 4.37623682e-03f,
  5.44028804e-02f, 3.24406698e-02f, 1.33638456e-01f, -6.59162626e-02f, 1.04284517e-01f, 1.27868861e-01f, 2.09188849e-01f, -6.58096522e-02f, 2.71280468e-01f, 4.63386178e-02f,
  2.10279133e-02f, 2.35932171e-01f, -1.95484958e-03f, 4.57318546e-03f, -9.05530751e-02f, 1.79137245e-01f, 2.01235279e-01f, -9.10959486e-03f, 1.58800438e-01f, -2.33121544e-01f,
  3.48199695e-01f, -1.04859740e-01f, -1.33361816e-01f, -4.55281347e-01f, 9.04672220e-02f, -1.87589452e-01f, -6.03622902e-05f, 1.23388350e-01f, 3.40261132e-01f, -4.63785268e-02f,
  3.03605616e-01f, 2.74407059e-01f, -3.09701338e-02f, 1.39394194e-01f, 1.83597326e-01f, 1.87212229e-02f, -1.09016180e-01f, -1.26779661e-01f, 4.44973484e-02f, 7.79504701e-02f,
  3.21837872e-01f, 2.16555864e-01f, 1.81092009e-01f, -6.85850531e-02f, 4.32543486e-01f, -1.64922723e-03f, 3.57822686e-01f, 3.46122147e-03f, 2.78981514e-02f, 3.14227976e-02f,
  -5.85367158e-02f, -2.55960077e-01f, -6.12475462e-02f, -6.08146414e-02f, -6.94274381e-02f, -2.44727373e-01f, 2.11097628e-01f, -1.10168094e-02f, -2.81368643e-02f, -1.00364789e-01f,
  2.11824641e-01f, -4.09847051e-02f, 1.60231873e-01f, -2.46105775e-01f, -2.75961682e-02f, 2.68850406e-03f, -6.57183975e-02f, -8.36380795e-02f, -4.53837886e-02f, 1.34616897e-01f,
  2.25912884e-01f, -3.84515494e-01f, 2.67996132e-01f, 2.79270392e-03f, 2.42830947e-01f, 3.56143340e-02f, -3.00457776e-01f, -2.01306060e-01f, -9.40006152e-02f, 1.56410579e-02f,
  -1.21268190e-01f, 2.84634888e-01f, -1.28608555e-01f, -3.76820296e-01f, -6.17101714e-02f, 1.07433140e-01f, 1.35108382e-01f, -2.22524796e-02f, 2.77546030e-02f, -1.27307191e-01f,
  -9.29745138e-02f, -2.13422492e-01f, 3.02790165e-01f, 6.57090545e-02f, -4.21638161e-01f, 3.55062075e-02f, -1.13757089e-01f, -9.96810272e-02f, 3.25955711e-02f, 3.62222977e-02f,
  4.54305522e-02f, 2.14644715e-01f, 3.97736840e-02f, -1.13690436e-01f, 2.21280940e-02f, 1.19627640e-01f, -1.17501892e-01f, 2.11638257e-01f, 4.10402417e-01f, 1.83020473e-01f,
  1.05280094e-01f, -8.31996724e-02f, -3.11684702e-03f, 2.65080720e-01f, -6.46204278e-02f, -9.54383835e-02f, 1.49947539e-01f, -1.32310092e-02f, 1.78670496e-01f, 2.01118011e-02f,
  -1.99786171e-01f, 1.42811313e-01f, -3.24807107e-01f, 2.90483117e-01f, 3.35757077e-01f, 1.11734299e-02f, -7.98669383e-02f, -9.42946970e-02f, 9.41333398e-02f, 1.50476128e-01f,
  -9.13582668e-02f, -1.11786872e-01f, -5.48094846e-02f, -7.15695396e-02f, -3.71391445e-01f, 3.44686985e-01f, 1.51576987e-03f, -2.92777680e-02f, -3.30385983e-01f, 1.77771840e-02f,
  -2.07277581e-01f, 3.68910134e-02f, -2.43854225e-01f, 1.34251058e-01f, 2.82808751e-01f, -3.05685252e-01f, -2.82075644e-01f, 1.74391158e-02f, -2.12474108e-01f, -1.06439583e-01f,
  6.73484951e-02f, -2.48783261e-01f, 1.98876008e-01f, 2.91668862e-01f, -3.29487145e-01f, 1.65286034e-01f, -1.00218073e-01f, -2.79426992e-01f, 2.57897168e-01f, 2.99196899e-01f,
  8.26997682e-02f, 2.24503174e-01f, 9.29398760e-02f, 9.63814035e-02f, -3.70876461e-01f, 1.49545865e-02f, 1.31925911e-01f, -1.78222984e-01f, 1.14544310e-01f, -4.97347414e-02f,
  1.99165106e-01f, 5.26691712e-02f, 1.15756251e-01f, 6.43127263e-02f, 1.26122579e-01f, 3.07887364e-02f, 1.15406185e-01f, -2.91080195e-02f, 4.48360667e-02f, 1.88431606e-01f,
  -4.35395360e-01f, -2.29613557e-01f, -9.77186784e-02f, -2.46972740e-01f, 2.91553855e-01f, -1.71117991e-01f, -1.58198014e-01f, -2.90717632e-01f, 9.01756957e-02f, -4.58760411e-01f,
  -1.82600304e-01f, -2.82677263e-01f, 1.88022107e-01f, 6.43908456e-02f, -4.15721059e-01f, 3.37021761e-02f, 1.12288274e-01f, 1.09710962e-01f, -1.94053724e-01f, -5.64984679e-01f,
  5.14979847e-02f, -2.62091875e-01f, 3.97001088e-01f, 4.36058678e-02f, -3.14766347e-01f, -2.64507920e-01f, -5.51218748e-01f, 2.89000850e-02f, -2.97511965e-01f, 3.72702330e-01f,
  -2.08733499e-01f, 2.31401175e-02f, -2.74414331e-01f, 1.52549282e-01f, 2.26433218e-01f, 1.91139370e-01f, 1.09470198e-02f, -1.64496914e-01f, -1.77355483e-01f, -1.25299767e-01f,
  2.06973683e-02f, 1.28493756e-01f, -4.52239215e-01f, -9.81955081e-02f, 1.67586431e-01f, -1.95380792e-01f, -3.41692328e-01f, 2.36802727e-01f, -1.94660984e-02f, -5.54855168e-02f,
  -8.75432938e-02f, 2.77763885e-02f, -4.11095321e-01f, 2.63534784e-01f, -6.04159199e-02f, 9.10888612e-02f, 3.71374577e-01f, 2.51153171e-01f, -3.08973014e-01f, 1.07018225e-01f,
  2.07072571e-01f, 1.74187362e-01f, 2.64860485e-02f, -1.11492559e-01f, 1.68857679e-01f, 1.12317549e-02f, 6.80049360e-02f, 1.33253619e-01f, -2.75615215e-01f, -1.79385096e-02f,
  3.35126021e-03f, -2.32894331e-01f, -1.34364247e-01f, 6.15836270e-02f, 2.02600375e-01f, 3.52791131e-01f, -8.45371559e-02f, 5.71814775e-02f, 1.00418083e-01f, 2.60262430e-01f,
  2.49073617e-02f, -2.48676762e-02f, 3.52295488e-01f, 2.79404819e-01f, -2.36056387e-01f, 6.82177469e-02f, 2.52549127e-02f, 2.00319588e-01f, 2.10060105e-01f, 1.82839826e-01f,
  2.52729386e-01f, -3.82781088e-01f, 1.15042865e-01f, -2.48796105e-01f, -2.07684219e-01f, -1.94887027e-01f, 2.76664615e-01f, 4.18154337e-02f, -1.25972293e-02f, 2.11470231e-01f,
  -1.02718197e-01f, -2.11934358e-01f, -1.53312787e-01f, -4.38468814e-01f, 1.04089163e-01f, 2.14782190e-02f, -1.36664659e-01f, -9.61109698e-02f, 2.01936945e-01f, -7.76276961e-02f,
  -2.45700553e-01f, -1.48436412e-01f, 7.97638819e-02f, -1.31790757e-01f, -2.72388935e-01f, 2.53509015e-01f, 4.00295138e-01f, 7.73810446e-02f, 7.16110598e-03f, -1.09362230e-01f,
  5.99586181e-02f, 3.31926793e-02f, -1.76174998e-01f, 3.60292196e-01f, -2.27945805e-01f, 9.90187228e-02f, -5.05750068e-02f, -1.49021640e-01f, 1.70313358e-01f, 2.74567246e-01f,
  3.03289294e-01f, 3.46559703e-01f, 1.67302191e-01f, 2.50120699e-01f, 2.25421980e-01f, 3.26351047e-01f, 6.61405623e-02f, -7.67181301e-03f, 6.99521974e-02f, 1.53259654e-02f,
  3.63154829e-01f, 2.37950310e-01f, 1.75750718e-01f, 3.48650701e-02f, 1.57644600e-01f, 8.03362429e-02f, -6.37258962e-02f, 5.87390922e-02f, 5.92966750e-02f, 2.29276463e-01f,
  1.37501359e-01f, -6.07601367e-03f, 7.95668215e-02f, 4.27007824e-01f, -1.97272301e-01f, 2.96965033e-01f, -4.21587110e-01f, 1.09253146e-01f, -4.69037704e-02f, -2.86382753e-02f,
  1.50708377e-01f, -2.80878600e-02f, -5.20318821e-02f, 3.44425917e-01f, 3.42889160e-01f, 4.29369248e-02f, 3.26148868e-01f, 1.76998988e-01f, -4.54584330e-01f, -1.75069049e-01f,
  -4.30524737e-01f, -1.85716793e-01f, 2.13046646e-04f, 8.31607506e-02f, 5.17373569e-02f, 3.01905632e-01f, -1.26216099e-01f, 2.94128269e-01f, -1.21119149e-01f, -1.79050550e-01f,
  -1.29146144e-01f, -4.82290611e-02f, -2.08456725e-01f, 3.21051091e-01f, -2.22625539e-01f, -8.32274035e-02f, -2.35215202e-01f, 4.76172417e-02f, 2.52963394e-01f, 2.67938852e-01f,
  3.44796702e-02f, -9.24183056e-02f, -2.61936579e-02f, -9.27633122e-02f, 1.66941926e-01f, 4.39156070e-02f, -5.22937179e-02f, 3.57316464e-01f, 1.03797942e-01f, 4.47669119e-01f,
  1.00753769e-01f, 2.26133447e-02f, -3.10808808e-01f, 2.12885782e-01f, 3.91020954e-01f, 2.57017035e-02f, 1.99274510e-01f, 9.61373299e-02f, -2.78063715e-01f, 2.34633416e-01f,
  8.04298669e-02f, -1.41074955e-01f, 2.52119929e-01f, 1.19960248e-01f, -1.37781173e-01f, -2.19942018e-01f, -4.05000225e-02f, -1.24720633e-01f, -3.74643475e-01f, 1.59412280e-01f,
  -1.79044977e-01f, 4.39246386e-01f, 2.59639949e-01f, -8.34547821e-03f, -1.62535429e-01f, -2.40754917e-01f, 1.61656067e-01f, 2.47709733e-02f, -2.68445581e-01f, 2.39929080e-01f,
  4.60154146e-01f, -5.44527508e-02f, -2.77431995e-01f, 4.90563482e-01f, -2.38014013e-02f, -1.95451275e-01f, 2.66700275e-02f, -3.29883695e-02f, 1.92670003e-01f, 4.29237746e-02f,
  2.68778533e-01f, 2.27372482e-01f, -2.47701281e-03f, -3.25442195e-01f, 2.46223286e-01f, 2.85744011e-01f, -2.12112576e-01f, 3.65411788e-02f, -2.89229274e-01f, -5.20427562e-02f,
  1.73544690e-01f, 2.05641806e-01f, 2.15374336e-01f, -1.06378578e-01f, 5.00277281e-02f, -2.12857470e-01f, 7.62926117e-02f, 9.73712876e-02f, 3.15672100e-01f, -2.86348879e-01f,
  -3.63453291e-02f, 6.39892891e-02f, 1.17378153e-01f, 1.81394249e-01f, -2.51531005e-01f, 6.06194362e-02f, -1.71568662e-01f, 2.25017369e-01f, -3.51484716e-02f, 3.73798236e-02f,
  1.98605210e-01f, 1.40595809e-01f, -1.33597836e-01f, 9.94768068e-02f, 7.47762993e-02f, 2.76028603e-01f, 1.69751301e-01f, 8.70257095e-02f, -5.22071123e-02f, -2.95074493e-01f,
  2.70011336e-01f, 4.23161626e-01f, 1.02687322e-01f, 3.38642783e-02f, -1.23776319e-02f, 3.20358947e-02f, -1.77813292e-01f, 2.38398552e-01f, 1.22191690e-01f, 6.25043437e-02f,
  -3.44553709e-01f, 1.94776833e-01f, 2.96381321e-02f, 2.67686367e-01f, -6.24085516e-02f, -1.66291982e-01f, -4.55105975e-02f, -1.92023292e-02f, 1.51171893e-01f, -9.83892307e-02f,
  1.32847503e-01f, 2.84677204e-02f, 1.60164386e-01f, 1.07678711e-01f, 2.20827147e-01f, 3.08899075e-01f, -2.74464935e-01f, 5.12177423e-02f, 1.20274819e-01f, 9.04899929e-03f,
  -2.63692349e-01f, -2.21757382e-01f, -1.69685200e-01f, -6.49930611e-02f, -2.13043869e-01f, 1.60251722e-01f, -1.63132936e-01f, 1.92272440e-01f, -8.31836313e-02f, -1.57021046e-01f,
  -1.09196082e-01f, 3.20448354e-02f, 4.38132845e-02f, -7.46514499e-02f, -1.24036640e-01f, 2.99040407e-01f, 4.29394953e-02f, 2.83695370e-01f, 2.93545842e-01f, 3.13263565e-01f,
  3.28710824e-01f, 1.94311768e-01f, 3.10384959e-01f, 2.93997675e-01f, 2.54854172e-01f, 3.41845363e-01f, 2.29916871e-01f, 1.58147424e-01f, 4.77267504e-02f, 2.47033432e-01f,
  1.93721414e-01f, 3.82579356e-01f, 9.93520543e-02f, 1.86231405e-01f, -6.60280697e-03f, 2.50439364e-02f, 6.13621809e-02f, -3.48976731e-01f, -1.74925312e-01f, -4.45116729e-01f,
  1.30567867e-02f, -2.49117330e-01f, -1.43821806e-01f, -8.18113796e-03f, 4.59693044e-01f, 7.49332458e-02f, 1.18085667e-01f, -1.75511062e-01f, 1.67376295e-01f, 2.39614502e-01f,
  4.02131714e-02f, -1.99667454e-01f, 4.07716930e-02f, 1.08186439e-01f, -1.38690934e-01f, -5.99055104e-02f, -2.49398887e-01f, 5.82369938e-02f, 4.94641103e-02f, -2.55685627e-01f,
  3.50356340e-01f, -6.30633114e-03f, 1.79554045e-01f, -4.19482857e-01f, -9.56621766e-02f, -5.65279908e-02f, -5.62285557e-02f, 1.13127038e-01f, 3.95396560e-01f, 5.66047311e-01f,
  -7.03549534e-02f, 1.37682930e-01f, 4.20099527e-01f, 2.86944453e-02f, 7.41375610e-02f, 2.25346610e-01f, 4.13209260e-01f, 8.32278877e-02f, 5.08350432e-01f, 2.04317570e-01f,
  3.75478007e-02f, -2.85841733e-01f, 2.92822625e-02f, 6.86957091e-02f, 3.99679810e-01f, 1.51424110e-01f, -2.87134320e-01f, -9.17569324e-02f, -1.25271082e-01f, 2.39740804e-01f,
  2.05406353e-01f, -5.72326221e-03f, -6.17309771e-02f, 8.96481201e-02f, 3.29966098e-02f, 1.39898136e-01f, 5.84230781e-01f, 2.00113907e-01f, 5.08470163e-02f, -9.57154557e-02f,
  3.21368761e-02f, -3.06111097e-01f, -2.12171271e-01f, -2.37017304e-01f, -4.51363564e-01f, -2.27071673e-01f, 2.76861284e-02f, 1.51170045e-01f, 2.47485757e-01f, 1.43805832e-01f,
  6.70282617e-02f, -7.54309148e-02f, -1.14986487e-01f, -2.54491508e-01f, -6.75620660e-02f, -6.15377091e-02f, -1.94471091e-01f, -1.89795315e-01f, 2.19759699e-02f, -1.11656815e-01f,
  -1.53897271e-01f, 1.33859247e-01f, -2.53449269e-02f, -9.35794935e-02f, -1.03539815e-02f, 2.14219376e-01f, -3.10302645e-01f, -2.48410717e-01f, 8.98875743e-02f, 1.60922691e-01f,
  5.24887033e-02f, 1.54999509e-01f, -1.57407463e-01f, 1.47559196e-01f, -4.06809244e-03f, 1.24791428e-01f, 1.00546882e-01f, 1.69368073e-01f, 1.29986539e-01f, 1.24710836e-01f,
  2.07092538e-02f, 2.86133409e-01f, 1.80166423e-01f, -6.72591329e-02f, -8.55369419e-02f, 2.08691463e-01f, -1.97562233e-01f, -1.20129343e-02f, -2.67908603e-01f, 7.50665069e-02f,
  2.57588178e-01f, 1.40856460e-01f, 1.04482047e-01f, 1.09545387e-01f, -8.41212422e-02f, 1.43640250e-01f, 3.15870680e-02f, -1.16396509e-01f, -9.21170115e-02f, 7.98275992e-02f,
  -3.52947474e-01f, -2.72835404e-01f, 2.27386266e-01f, 3.88905525e-01f, -2.05271125e-01f, -6.40697181e-02f, -2.51783997e-01f, 7.32820481e-02f, 9.31949615e-02f, 1.81472972e-01f,
  -8.60138983e-02f, -1.01378411e-01f, 5.41784652e-02f, 2.22953409e-01f, 2.13316873e-01f, 1.32273227e-01f, 2.10951149e-01f, -7.09481761e-02f, -4.58625197e-01f, 1.72320232e-01f,
  -8.62815008e-02f, -4.95422892e-02f, 1.89574137e-01f, 2.11476699e-01f, 1.43376753e-01f, 1.05310336e-01f, -9.95217338e-02f, 8.21819454e-02f, -5.51543839e-04f, 1.11432552e-01f,
  7.97431394e-02f, 9.55877900e-02f, 6.55099330e-03f, -2.31761202e-01f, -3.86324942e-01f, 1.16256334e-01f, 5.36930561e-03f, 2.60317236e-01f, 2.63458043e-01f, 8.92964005e-02f,
  2.67480463e-01f, -1.20724536e-01f, -1.19400837e-01f, -1.38493061e-01f, 3.77067059e-01f, 1.89256653e-01f, 3.45955014e-01f, 1.25136077e-01f, 1.53838545e-01f, -2.72024035e-01f,
  8.49899426e-02f, 6.80892020e-02f, 2.16380820e-01f, -1.22277789e-01f, -2.31321514e-01f, 6.34114593e-02f, 5.06449454e-02f, 7.56000355e-02f, 2.01200634e-01f, -2.55447149e-01f,
  -1.42897621e-01f, 6.21583536e-02f, 7.10556656e-02f, 1.01860824e-04f, 3.00355583e-01f, 4.08508070e-02f, -1.02400385e-01f, -6.12420440e-02f, 3.64462018e-01f, 1.15871869e-01f,
  -1.25035062e-01f, -5.43297082e-02f, -5.03893644e-02f, 6.13338389e-02f, 1.86527774e-01f, 1.95272163e-01f, 1.54564887e-01f, 1.73940152e-01f, 2.11541072e-01f, -3.78062546e-01f,
  -3.15880150e-01f, -5.91161139e-02f, 1.60593227e-01f, -2.62804449e-01f, -2.33039185e-01f, -3.68623212e-02f, 7.94349909e-02f, 9.39743593e-02f, 7.94481952e-03f, 7.44369929e-04f,
  3.91365252e-02f, 5.70601895e-02f, -9.99358073e-02f, 1.27004787e-01f, -1.05252795e-01f, 4.36506495e-02f, 1.99112192e-01f, 2.17855617e-01f, 1.92879260e-01f, 1.84868887e-01f,
  -1.62328735e-01f, -2.91633874e-01f, -1.57354102e-01f, 2.39967957e-01f, -1.12663610e-02f, 3.80434766e-02f, 2.51238108e-01f, 1.16674572e-01f, -1.33953661e-01f, 3.59208852e-01f,
  -1.62303120e-01f, 9.06453729e-02f, -1.63787499e-01f, -2.37301528e-01f, -2.37584829e-01f, -3.37620765e-01f, 3.67690213e-02f, -4.74856608e-02f, -2.23237634e-01f, -3.00447226e-01f,
  -1.74357563e-01f, 3.05615831e-02f, 1.33766934e-01f, 9.26352218e-02f, 2.58100331e-01f, -2.57926524e-01f, 1.34014070e-01f, -1.69330120e-01f, 4.06158455e-02f, -1.11317798e-01f,
  6.00535870e-02f, -2.97193676e-01f, 2.19385073e-01f, -5.66791184e-03f, -1.30553260e-01f, 2.21274838e-01f, 1.89139724e-01f, 4.66173366e-02f, 2.07761303e-01f, 1.69939056e-01f,
  -2.66106397e-01f, 7.94463977e-02f, -1.22890353e-01f, -4.64655533e-02f, 5.99574938e-04f, 4.93870303e-02f, 4.50111330e-01f, 3.83298784e-01f, 1.17364347e-01f, 1.63414598e-01f,
  1.67989358e-01f, 1.68641225e-01f, 1.74768865e-01f, 1.16259523e-01f, 5.69431067e-01f, -6.42749518e-02f, 2.52900124e-01f, 4.04455870e-01f, -2.18457188e-02f, 1.78802505e-01f,
  3.26858968e-01f, 1.47608832e-01f, 3.64490122e-01f, 9.70668271e-02f, 2.77115226e-01f, 3.26473601e-02f, 3.08668017e-01f, 2.07667928e-02f, -1.81225672e-01f, 1.22284666e-01f,
  -2.69689038e-02f, 1.03964955e-01f, -1.53838053e-01f, -2.65686940e-02f, 8.77631903e-02f, -1.92452312e-01f, 2.01156780e-01f, -7.72891715e-02f, -1.97774723e-01f, 4.11797702e-01f,
  -6.51043504e-02f, 2.64675617e-01f, -3.93716432e-02f, -6.06338819e-03f, 1.59249857e-01f, 3.83746833e-01f, -2.82757699e-01f, -3.95409111e-03f, 5.84863499e-02f, 5.14696240e-01f,
  4.28727776e-01f, 2.52990961e-01f, -7.21389009e-03f, 8.27914923e-02f, 5.32727242e-01f, 7.48133734e-02f, 1.18202597e-01f, -9.61823538e-02f, 7.00090230e-02f, -3.85568067e-02f,
  -3.74506079e-02f, -5.35692647e-02f, 2.17395537e-02f, 1.22259995e-02f, -2.02872604e-01f, 3.32697004e-01f, -3.14294368e-01f, 3.19612503e-01f, 3.28630984e-01f, -1.68447077e-01f,
  1.14641562e-01f, 2.90831745e-01f, 4.41847384e-01f, -4.05619055e-01f, 1.82170663e-02f, 5.47523564e-03f, 1.74852178e-01f, 1.78506181e-01f, 2.32938528e-01f, 2.43481532e-01f,
  1.06538653e-01f, 5.60068637e-02f, -1.54615417e-01f, -1.42194614e-01f, 3.14980675e-03f, 8.04189295e-02f, -4.31258470e-01f, -2.60695934e-01f, -3.64112221e-02f, 2.90458143e-01f,
  1.75091147e-01f, -9.44237262e-02f, -2.36107409e-01f, -2.16529891e-02f, -1.11488603e-01f, 1.57292768e-01f, 1.70993745e-01f, 7.21813068e-02f, 2.59581092e-03f, -4.52648513e-02f,
  9.70733017e-02f, -5.79421408e-02f, 9.54459012e-02f, 5.03254652e-01f, -2.81942217e-03f, -4.94556092e-02f, -1.36371300e-01f, 3.16465318e-01f, 2.32473418e-01f, -4.10597734e-02f,
  1.57112926e-01f, -3.39014232e-02f, -2.44836807e-01f, 8.27897191e-01f, -1.64189279e-01f, -1.13360912e-01f, -2.17737943e-01f, 6.58483729e-02f, 3.98186654e-01f, 9.48020369e-02f,
  2.24809885e-01f, -6.27249852e-02f, 3.83054823e-01f, 1.19792677e-01f, 7.50967786e-02f, 2.41421480e-02f, 1.15117304e-01f, -1.50814578e-01f, -1.38169020e-01f, 9.06963721e-02f,
  6.58036247e-02f, 1.32567557e-02f, -2.19329461e-01f, -2.39968106e-01f, 3.69507596e-02f, -7.44186109e-03f, 1.84435666e-01f, -2.28252038e-01f, 1.40847877e-01f, 1.98450774e-01f,
  4.99864435e-03f, -2.03606278e-01f, 1.66473851e-01f, 3.21420372e-01f, -1.79575339e-01f, 1.69098139e-01f, 4.00277406e-01f, 1.76520899e-01f, 3.52326602e-01f, 2.89104898e-02f,
  -2.00272083e-01f, 2.39507630e-01f, -3.23033170e-03f, -9.55073610e-02f, -1.08638480e-01f, 3.14193480e-02f, -3.23543325e-02f, 6.48558587e-02f, 9.31053013e-02f, -2.82520615e-02f,
  -8.34813192e-02f, 3.14765573e-01f, -2.20168725e-01f, -3.57699208e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  5.02391420e-02f, 1.90995678e-01f, 9.41693783e-02f, 2.99235731e-01f, 2.15388194e-01f, 1.17328316e-01f, -7.04914406e-02f, -5.61075509e-02f, 2.66710445e-02f, -9.03188884e-02f,
  9.50560868e-02f, 2.26351731e-02f, -6.00421336e-03f, -7.31736748e-03f, 5.29300189e-03f, -1.39449790e-01f, -1.58273242e-02f, 1.91385552e-01f, 8.59612897e-02f, 2.23780483e-01f,
  4.99508679e-02f, 1.30611688e-01f, 4.30031642e-02f, 7.25572854e-02f, 1.62729338e-01f, 2.04593930e-02f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  -1.30022302e-01f, -4.03867751e-01f, 2.71730404e-02f, 9.16756094e-02f, -1.51836991e-01f, 6.58446103e-02f, -3.83949012e-01f, 1.55035881e-02f, 4.47449945e-02f, 1.42454013e-01f,
  -8.03850219e-03f, -1.77294817e-02f, 8.95321518e-02f, 9.43357274e-02f, -3.99523564e-02f, -2.08778307e-01f, -1.81581080e-01f, -1.95057228e-01f, -9.76842493e-02f, 2.28381544e-01f,
  -7.71540925e-02f, -9.98263136e-02f, -1.05361879e-01f, -2.56327868e-01f, 1.63303509e-01f, -3.23712081e-01f, 1.51959166e-01f, 1.73569530e-01f, -2.75682956e-01f, -2.27905601e-01f,
  -4.16757651e-02f, 2.84169149e-02f, -4.28491443e-01f, 4.64555211e-02f, 3.39967430e-01f, -2.27007031e-01f, -1.37601495e-01f, 3.04250389e-01f, 1.05635822e-01f, 3.22426632e-02f,
  1.51989520e-01f, -5.12564778e-01f, -4.18567032e-01f, -5.37977517e-02f, -1.60544112e-01f, 7.54708126e-02f, 1.04940973e-01f, 1.53659478e-01f, -1.57716628e-02f, -2.84136415e-01f,
  6.26735911e-02f, -1.34787545e-01f, 4.59663451e-01f, 1.13934197e-01f, -4.00082856e-01f, -2.77135611e-01f, -1.44592881e-01f, -2.33835861e-01f, 1.52064458e-01f, -3.14288020e-01f,
  1.27322853e-01f, 1.05437391e-01f, -2.09180042e-01f, -1.35968700e-01f, 1.98710725e-01f, -2.78409749e-01f, -3.41825522e-02f, -1.63329113e-02f, 3.28295767e-01f, 2.89693952e-01f,
  5.21880761e-03f, 5.27132899e-02f, 3.25640216e-02f, -1.91123828e-01f, 1.65245339e-01f, 2.32454669e-02f, -1.82850957e-01f, -1.21428691e-01f, 1.91084653e-01f, -6.81827366e-02f,
  1.87751967e-02f, 1.56026140e-01f, 1.91797867e-01f, -2.69282430e-01f, -1.61278054e-01f, 1.65069148e-01f, 1.09079875e-01f, -5.94059564e-02f, 1.79158181e-01f, 1.28969088e-01f,
  2.22165138e-01f, 2.48165607e-01f, 2.63497621e-01f, 8.37877691e-02f, -2.04891473e-01f, 2.25346953e-01f, 1.45233721e-01f, -1.45846486e-01f, -3.04461606e-02f, 4.61948924e-02f,
  -9.01099443e-02f, 2.71510690e-01f, -4.72666949e-01f, 1.98548168e-01f, 1.56027347e-01f, 1.55127496e-01f, -1.12577274e-01f, 3.04874897e-01f, -3.50651413e-01f, -6.75461531e-01f,
  1.65611640e-01f, -2.27146491e-01f, -5.42872250e-01f, -3.34749699e-01f, 2.76505679e-01f, -5.25404513e-02f, 3.62736344e-01f, -2.35380799e-01f, 1.59613356e-01f, -9.55393612e-02f,
  -1.75340235e-01f, 1.01419598e-01f, 4.82333563e-02f, -1.18263029e-01f, 1.97126225e-01f, 1.01253056e-04f, -3.24427158e-01f, -2.09836349e-01f, -1.27275005e-01f, 1.51300266e-01f,
  -3.99175793e-01f, 1.70415506e-01f, 2.00608656e-01f, -2.18293726e-01f, -1.91499889e-01f, -2.43662551e-01f, 2.87423640e-01f, 2.34946832e-01f, 2.40271181e-01f, 7.55339954e-03f,
  1.32750764e-01f, -1.26784846e-01f, -4.28093933e-02f, 2.34292507e-01f, 2.52911210e-01f, -8.70434195e-02f, -2.46482372e-01f, 3.30296487e-01f, 1.27853110e-01f, -1.88689396e-01f,
  4.31287102e-03f, 2.09848806e-01f, 4.77474146e-02f, -1.60659239e-01f, 2.69299448e-01f, 5.97898103e-02f, 1.75709650e-01f, -2.23678052e-01f, 3.27940792e-01f, -3.75768542e-01f,
  2.26138771e-01f, -4.07056510e-02f, -3.27594489e-01f, -5.10255158e-01f, 4.37852472e-01f, 4.23845053e-02f, 4.13289845e-01f, 1.41785294e-01f, -1.24954795e-02f, -1.25736728e-01f,
  -1.04732059e-01f, 2.82634377e-01f, -5.18676519e-01f, -5.12013733e-01f, 1.97717056e-01f, -3.78515840e-01f, 1.18783057e-01f, 4.52466011e-01f, 1.93506390e-01f, -2.78229505e-01f,
  -2.83058971e-01f, -1.03467219e-01f, -2.72339642e-01f, -5.72923005e-01f, -1.58498898e-01f, 4.96995337e-02f, -1.09522030e-01f, -5.55815399e-01f, 4.71190549e-02f, 2.68238217e-01f,
  -1.70809209e-01f, -5.63909948e-01f, -1.98085755e-01f, 1.51643500e-01f, -1.57053303e-02f, -1.85047671e-01f, -3.36697921e-02f, -7.82581717e-02f, -1.22017957e-01f, 2.65834946e-02f,
  3.79917771e-02f, 3.39911915e-02f, -2.93557167e-01f, -1.99903354e-01f, 8.79640058e-02f, -1.88973948e-01f, 3.03006209e-02f, 1.21122956e-01f, 1.13293506e-01f, -3.20371091e-01f,
  4.85315397e-02f, 1.63958386e-01f, 2.79385820e-02f, 1.98480248e-01f, -2.27127701e-01f, -9.33811069e-02f, -1.64660588e-01f, 1.57757416e-01f, 1.29881501e-01f, -3.81049275e-01f,
  -2.85485148e-01f, -1.99940756e-01f, 3.59227002e-01f, -2.07682699e-01f, 1.97474465e-01f, 2.27772847e-01f, 1.75349638e-02f, 2.34346926e-01f, 7.79063478e-02f, 6.87755346e-02f,
  6.05552234e-02f, -6.83269501e-01f, 1.06055411e-02f, -6.20511055e-01f, -2.59055585e-01f, -3.34803723e-02f, 3.31372917e-01f, 8.65154564e-02f, -3.96550566e-01f, 1.70666710e-01f,
  1.50748029e-01f, -2.00064704e-02f, -8.02152380e-02f, -7.17914343e-01f, -1.96975157e-01f, 8.53657573e-02f, -1.41877711e-01f, -1.58208415e-01f, 1.12486780e-01f, -6.94736540e-01f,
  -4.72381651e-01f, -1.17896639e-01f, 1.63504556e-01f, 1.79539323e-02f, -3.65610003e-01f, 3.99678528e-01f, 9.53497961e-02f, 1.44303784e-01f, 3.49922508e-01f, -1.17769577e-01f,
  -2.34224685e-02f, 2.18088970e-01f, 5.89837909e-01f, -1.24440320e-01f, 2.25081295e-02f, -3.03924680e-01f, -3.31956178e-01f, 1.02912270e-01f, -1.95906952e-01f, -2.58440703e-01f,
  1.29667610e-01f, 1.82495043e-01f, -1.02633044e-01f, 2.37706855e-01f, 1.84700713e-02f, 1.70638561e-01f, -1.79597378e-01f, 2.85022110e-01f, -3.22062910e-01f, 6.53678104e-02f,
  -3.17903042e-01f, -8.21388885e-02f, -3.90533693e-02f, 3.89623880e-01f, 2.46212810e-01f, -1.09686945e-02f, -3.09146643e-01f, 2.72605121e-01f, -4.40152176e-02f, 2.78532207e-01f,
  -6.99535012e-02f, 5.91765881e-01f, 1.52412280e-01f, -4.21550333e-01f, 2.63026267e-01f, -7.92279840e-02f, 2.63724905e-02f, 5.87397814e-02f, -2.60710746e-01f, -2.66281575e-01f,
  -7.14542642e-02f, -1.94846436e-01f, -2.21339300e-01f, 3.51592191e-02f, 2.17000470e-01f, -3.28744501e-01f, -4.35455680e-01f, 1.88094556e-01f, -2.63151377e-01f, 1.32036850e-01f,
  -4.19405073e-01f, -5.00558436e-01f, 9.66853946e-02f, -1.90001987e-02f, 2.33093854e-02f, -1.63188174e-01f, 6.02457160e-03f, 7.78603479e-02f, 4.58007663e-01f, 1.28956363e-01f,
  2.64825206e-02f, 1.30392432e-01f, 3.70699055e-02f, -8.54744688e-02f, -1.91932783e-01f, -2.26992443e-01f, -2.01916918e-01f, 1.70156717e-01f, -4.19814169e-01f, 2.16977105e-01f,
  4.07686606e-02f, 3.34851183e-02f, 1.27048969e-01f, -1.85091987e-01f, -5.34296595e-02f, -6.54184893e-02f, 2.02504799e-01f, -2.80743279e-02f, 2.89941859e-02f, -3.27646554e-01f,
  -3.08731347e-01f, -2.50049740e-01f, 2.27274910e-01f, 2.71237075e-01f, -2.39069760e-01f, -1.08232394e-01f, 1.54722288e-01f, -1.66910157e-01f, 6.32839724e-02f, 5.38668334e-02f,
  -1.19608149e-01f, 9.87322703e-02f, 1.94467828e-01f, -6.42668009e-02f, 6.65076897e-02f, 1.90699533e-01f, 3.97521891e-02f, -4.01928365e-01f, -2.50482291e-01f, 1.22867368e-01f,
  -1.92181334e-01f, -2.55910188e-01f, 1.12352841e-01f, 1.43362835e-01f, 1.84658244e-01f, 3.50901425e-01f, 1.02486961e-01f, -2.98301071e-01f, 1.81640387e-01f, -8.17538798e-02f,
  -4.83664079e-03f, 1.29088700e-01f, -3.89598757e-01f, 1.86156824e-01f, 1.25837132e-01f, -4.81656641e-01f, -6.90473393e-02f, 8.42256844e-02f, 9.16970670e-02f, -4.70151827e-02f,
  1.60061002e-01f, -3.27344984e-01f, -3.35138775e-02f, 3.67771238e-02f, 3.33625764e-01f, 5.33696525e-02f, -2.39950359e-01f, 3.68691385e-01f, 1.59919247e-01f, -3.08639139e-01f,
  3.25351268e-01f, 3.81512433e-01f, 1.81310385e-01f, 1.86541989e-01f, 1.27056807e-01f, -2.23051775e-02f, -1.03872502e-02f, -1.02541335e-01f, -2.63449758e-01f, 1.12235904e-01f,
  -3.19603294e-01f, -1.29372478e-01f, -4.69825715e-02f, -2.34098285e-02f, 2.54974782e-01f, -4.83033687e-01f, 2.58831263e-01f, 3.12415749e-01f, -1.25409484e-01f, 9.22276750e-02f,
  7.05499128e-02f, -1.89040273e-01f, 3.42839926e-01f, 3.93854737e-01f, 2.47796118e-01f, -2.68153191e-01f, -5.06621540e-01f, -1.15056716e-01f, -4.00269151e-01f, 1.60292923e-01f,
  -8.87017399e-02f, -2.41745666e-01f, -1.24392256e-01f, -1.66774571e-01f, -5.21437407e-01f, 2.54610598e-01f, 1.49366498e-01f, -1.67099088e-01f, -4.09285665e-01f, -4.26236659e-01f,
  -3.37119550e-01f, -5.30266225e-01f, -6.95991889e-02f, 9.39040035e-02f, -4.33999956e-01f, 9.86176357e-02f, -3.97567540e-01f, -4.65466946e-01f, 1.24925442e-01f, 2.18334511e-01f,
  -1.86050996e-01f, 2.96700299e-01f, -2.30795458e-01f, 1.14675269e-01f, -1.41730681e-01f, -1.85647190e-01f, -1.11195184e-02f, -1.87857732e-01f, 8.92930664e-03f, -2.23011941e-01f,
  6.69688582e-02f, -3.57299335e-02f, -4.93313745e-02f, 7.50696361e-02f, -2.71261901e-01f, -3.49433303e-01f, 5.51503338e-02f, -1.62705272e-01f, -6.03886619e-02f, -3.61373834e-02f,
  7.66090176e-04f, -4.18928191e-02f, 1.51448101e-01f, -2.22661749e-01f, -2.04468459e-01f, -3.60510200e-02f, 9.77979414e-03f, 6.86482340e-03f, 2.21238598e-01f, 2.80094475e-01f,
  2.09923223e-01f, -1.33488208e-01f, -2.92702485e-02f, 2.81410992e-01f, -3.38724554e-01f, -4.18865569e-02f, -2.42778599e-01f, 2.29029253e-01f, 1.00473478e-01f, -5.31321578e-02f,
  1.60071775e-01f, -5.24992906e-02f, -2.55267061e-02f, -3.48719418e-01f, -1.16512425e-01f, 3.70599747e-01f, -7.03882694e-01f, -1.58459559e-01f, 3.38928662e-02f, -8.55409577e-02f,
  2.27592990e-01f, -2.83676267e-01f, 1.23603709e-01f, 2.05872104e-01f, -9.50685665e-02f, 3.28521490e-01f, -4.89958197e-01f, 1.77301809e-01f, -2.83764482e-01f, -3.26468870e-02f,
  -1.45388797e-01f, -8.30003247e-02f, -2.99023598e-01f, -1.94801137e-01f, -2.24423021e-01f, -1.61736146e-01f, -1.98910385e-01f, 3.18672746e-01f, -1.19539015e-01f, 1.89250633e-01f,
  -3.30193132e-01f, -9.28808823e-02f, -1.30658373e-01f, -2.82446057e-01f, -8.22212994e-02f, 5.27807837e-03f, -2.40092203e-01f, -2.60588616e-01f, 8.02957714e-02f, -7.19757983e-03f,
  1.07807890e-01f, -1.09029710e-01f, -2.46810272e-01f, -2.57791698e-01f, 2.00057685e-01f, 1.57872051e-01f, -1.25359938e-01f, 2.34461531e-01f, 8.59811455e-02f, 3.97757217e-02f,
  -8.69312882e-02f, -2.69704133e-01f, -1.91162944e-01f, 8.28499869e-02f, 2.25234106e-01f, 2.02920184e-01f, 7.22329039e-03f, -1.50161341e-01f, 3.97421390e-01f, 2.44106323e-01f,
  -4.43914890e-01f, 3.39770794e-01f, 3.29896301e-01f, 1.94444403e-01f, -3.91412973e-01f, 2.00737610e-01f, 4.62314337e-01f, -2.61994034e-01f, -3.87730569e-01f, -8.25974792e-02f,
  -5.14560461e-01f, 9.94115323e-02f, -1.29653901e-01f, 8.17721263e-02f, 1.27494037e-01f, -7.32510490e-03f, 1.67389020e-01f, -7.97507465e-02f, -8.69671404e-02f, -2.69031882e-01f,
  -4.33414221e-01f, -9.88473892e-02f, -1.70097560e-01f, -1.65600017e-01f, -2.46292517e-01f, -4.75340992e-01f, 3.65528613e-01f, 2.42425710e-01f, 3.77126783e-01f, -5.64570308e-01f,
  -3.87555063e-01f, 3.09901804e-01f, -1.93496317e-01f, 1.69042423e-02f, 2.59746909e-01f, -9.31297392e-02f, -2.47611210e-01f, 1.49865985e-01f, 4.15752113e-01f, -1.47066385e-01f,
  -9.35014989e-03f, -8.10404122e-02f, -2.00825796e-01f, -1.02921482e-02f, 1.61888868e-01f, -1.58519790e-01f, 1.67681679e-01f, 9.27572101e-02f, -7.25305602e-02f, 3.03868264e-01f,
  3.04425329e-01f, -6.66538402e-02f, 2.85489887e-01f, 1.99554130e-01f, 1.71474963e-01f, 8.93907994e-02f, 2.45498314e-01f, 4.00522470e-01f, -3.77487123e-01f, -2.45256931e-01f,
  1.04918472e-01f, 3.08976531e-01f, -3.78715307e-01f, -1.80859774e-01f, 3.16016644e-01f, -1.25252426e-01f, -8.99340734e-02f, -2.42429480e-01f, 1.22687094e-01f, -2.62536138e-01f,
  -1.61574215e-01f, -1.25397235e-01f, -2.25038111e-01f, -1.56793684e-01f, 7.28688762e-02f, -2.06610803e-02f, -3.92199457e-01f, 9.85923335e-02f, -1.15842402e-01f, -1.93290904e-01f,
  -6.90358460e-01f, 2.92029046e-02f, -1.48046821e-01f, 2.66848028e-01f, 5.32836802e-02f, -1.62954554e-01f, -4.48909476e-02f, -9.07310367e-01f, -4.32665706e-01f, 9.78658199e-02f,
  -1.74520746e-01f, 1.89764634e-01f, -2.56121337e-01f, 2.33517528e-01f, 5.65715320e-02f, 1.76673010e-01f, -5.18189967e-01f, 4.87410314e-02f, 1.53982505e-01f, -9.02392507e-01f,
  -1.64263442e-01f, 1.37249812e-01f, 3.82544622e-02f, -5.58898449e-02f, -2.82344192e-01f, -1.27229750e-01f, 8.24821182e-03f, -3.02428305e-01f, -7.17447102e-02f, 3.74106131e-02f,
  1.36101097e-01f, -8.16954225e-02f, -4.94568460e-02f, 1.63809851e-01f, -1.88644379e-01f, 6.13993257e-02f, -2.00484172e-01f, -2.00942263e-01f, 1.10140936e-02f, -2.36841038e-01f,
  5.76892868e-02f, 2.06311405e-01f, 1.23418279e-01f, 1.48206443e-01f, 2.05576301e-01f, -7.65046254e-02f, -4.46737796e-01f, 2.55049020e-01f, -1.95088059e-01f, 2.09360987e-01f,
  -3.34569335e-01f, 2.33883098e-01f, -2.13831976e-01f, -2.79833395e-02f, 1.24648176e-01f, 3.86663347e-01f, 2.16659263e-01f, 3.16715032e-01f, -2.51603454e-01f, -6.87157631e-01f,
  -4.63860482e-02f, -3.88221182e-02f, -4.08638865e-01f, -1.00716613e-01f, 2.43644327e-01f, 4.03387815e-01f, -1.46165743e-01f, -9.07067060e-02f, 1.29545361e-01f, -8.96707922e-02f,
  2.16146350e-01f, -3.26768458e-01f, -3.63685191e-01f, 2.19073355e-01f, -3.78441326e-02f, 4.54265326e-01f, 2.59468943e-01f, -1.25309154e-02f, -7.42499888e-01f, 6.92351758e-02f,
  -3.46605450e-01f, -4.01701868e-01f, 1.40004709e-01f, 6.96985051e-02f, 1.88922390e-01f, 2.78047979e-01f, -1.07385851e-01f, -1.16125755e-01f, 3.07641886e-02f, 2.71902204e-01f,
  -7.45093375e-02f, 7.83189840e-04f, 1.08219467e-01f, 1.26260310e-01f, 1.27495617e-01f, -2.02254623e-01f, -6.44223839e-02f, 2.26590738e-01f, -1.73675697e-02f, -1.56564146e-01f,
  -8.98845643e-02f, 7.04854280e-02f, 8.41794908e-02f, 1.06621981e-01f, 2.37585101e-02f, -2.50302196e-01f, 2.20549107e-01f, -3.46730538e-02f, 1.50059953e-01f, 4.05173570e-01f,
  2.09234282e-01f, -1.43471584e-01f, -4.34464931e-01f, -4.40054446e-01f, 3.02958693e-02f, 2.42447481e-01f, -3.74340848e-03f, -9.36514139e-02f, -2.33760521e-01f, -1.23849869e-01f,
  -1.88718513e-01f, -1.73164397e-01f, 1.97094470e-01f, -4.28137183e-01f, 2.25324899e-01f, 1.66417032e-01f, 2.95680277e-02f, 1.66842770e-02f, 2.09977016e-01f, -3.12449694e-01f,
  -3.07199627e-01f, -1.79436222e-01f, 5.98975308e-02f, 2.11036727e-01f, 2.19209075e-01f, -6.85276568e-01f, -3.49943548e-01f, -4.79730934e-01f, -7.78603777e-02f, 2.26188108e-01f,
  -2.03421697e-01f, -3.45055282e-01f, -2.90892452e-01f, -2.22714975e-01f, -2.05823436e-01f, 1.67442858e-01f, 2.16724828e-01f, -6.28596023e-02f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -7.33773708e-02f, -2.96986774e-02f, -2.61784941e-02f, -5.80641478e-02f, -1.71864882e-01f, 4.66295443e-02f, 1.19546093e-01f, -1.10195495e-01f, -9.71333757e-02f, 5.77982552e-02f,
  -1.02381043e-01f, 5.66195399e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    