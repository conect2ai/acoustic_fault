/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -5.51461935e-01f, 1.17162079e-01f, 1.38491876e-02f, -1.62926629e-01f, 4.22957130e-02f, -3.24598014e-01f, -1.02885768e-01f, 5.52252233e-02f, -2.84091026e-01f, 1.18159376e-01f,
  1.35367122e-02f, -2.86793932e-02f, 1.18941978e-01f, -7.31759369e-02f, -1.12274073e-01f, -1.03355475e-01f, -5.82493655e-02f, 3.05473097e-02f, -1.45998999e-01f, 4.73008789e-02f,
  -9.31714848e-02f, 9.23461318e-02f, 9.49718654e-02f, 1.06871180e-01f, 1.37163019e-02f, 2.88052671e-02f, 1.64009497e-01f, 9.20112729e-02f, 6.39914498e-02f, 2.63729524e-02f,
  -1.74633220e-01f, -2.45275330e-02f, 5.41316569e-02f, -1.59481093e-02f, 2.13461053e-02f, 8.57259054e-03f, 5.07892435e-03f, 5.58254542e-04f, 4.78879064e-02f, -2.79415976e-02f,
  -2.46227365e-02f, 4.91688680e-03f, -7.79931843e-02f, 5.01031466e-02f, -4.96987216e-02f, 1.61495544e-02f, -5.35128824e-02f, -3.66512462e-02f, 1.21028861e-02f, -3.83160077e-02f,
  -6.86395019e-02f, 4.36834525e-03f, -3.19866277e-02f, 1.81980878e-02f, -2.30969377e-02f, -7.28837040e-04f, -2.89491173e-02f, 4.20703217e-02f, -5.91139123e-02f, -6.80885315e-02f,
  -1.46405222e-02f, 3.33105102e-02f, 2.43433546e-02f, 4.22523767e-02f, 9.61692911e-03f, 3.02559584e-02f, 1.06281098e-02f, -1.25459246e-02f, -1.54975094e-02f, 1.94025952e-02f,
  -1.83371585e-02f, 3.37947346e-02f, -3.13969739e-02f, 6.33589923e-03f, 2.27015419e-03f, 1.79568045e-02f, 9.18402895e-03f, 4.72013429e-02f, -6.94265366e-02f, -1.62432883e-02f,
  5.72040193e-02f, -9.94785689e-03f, -3.54335224e-03f, -5.74294804e-03f, 3.19004320e-02f, 1.68815590e-02f, 1.73500665e-02f, -1.24374703e-02f, -2.09684893e-02f, -2.54078135e-02f,
  5.45988455e-02f, 1.09027602e-01f, 1.50366845e-02f, 1.74168553e-02f, 2.66300235e-02f, -2.75640236e-03f, -3.67222279e-02f, -1.98673853e-03f, -3.12749599e-03f, 7.33059307e-04f,
  3.51478010e-02f, 2.75555272e-02f, 4.16178908e-03f, -5.62249869e-02f, -8.73172469e-03f, -8.12486373e-03f, 1.91811472e-02f, -2.48764325e-02f, 6.10553250e-02f, 3.53312641e-02f,
  1.40792858e-02f, -3.79547500e-03f, -1.28870830e-02f, -3.92567627e-02f, -1.00867674e-02f, 2.97037698e-02f, -1.97286811e-02f, -3.24512012e-02f, 3.15669589e-02f, 2.46574283e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.40363097e-01f, 1.26139089e-01f, -2.01566610e-03f, 3.37995552e-02f, -1.47523269e-01f, 1.06545024e-01f, 1.45656928e-01f, -8.07717890e-02f, -1.10180965e-02f, 3.10646072e-02f,
  9.93340909e-02f, -9.94562730e-02f, 8.67388323e-02f, 2.69581974e-01f, 3.93343903e-02f, 1.78875566e-01f, 1.96701542e-01f, 1.68792889e-01f, 7.84247294e-02f, 2.92401202e-02f,
  9.71198902e-02f, 1.23250134e-01f, 1.43899113e-01f, 9.49954763e-02f, 3.31104584e-02f, -2.35604737e-02f, 3.28599848e-02f, -1.21643126e-01f, 6.57132193e-02f, 8.73880461e-02f,
  5.26303425e-02f, -1.45584434e-01f, -8.99231713e-03f, -2.60884240e-02f, -6.31562769e-02f, -5.03549390e-02f, -3.00814044e-02f, -3.44616473e-02f, 1.07796583e-02f, -7.71049003e-04f,
  -8.57095048e-02f, 1.00160189e-01f, 3.85127291e-02f, -5.23464419e-02f, -5.53651452e-02f, -6.63836822e-02f, 5.19194175e-03f, -8.87666643e-03f, 7.83774778e-02f, 5.27337240e-03f,
  3.22970822e-02f, -1.00040995e-02f, -1.21563033e-03f, 4.42442149e-02f, -6.01589568e-02f, 6.82208538e-02f, 5.21931946e-02f, 1.65157169e-02f, -4.43932302e-02f, -7.62399808e-02f,
  1.43910237e-02f, -2.60630697e-02f, -4.85770451e-03f, 3.30220535e-02f, 1.32981511e-02f, 8.31255093e-02f, 7.36600012e-02f, -3.06421798e-02f, -1.16526531e-02f, 1.02476953e-02f,
  -1.30618483e-01f, 3.23779918e-02f, -9.08074901e-02f, -8.60745087e-03f, 3.01037636e-03f, 5.34626432e-02f, -8.76225457e-02f, -4.03328761e-02f, 6.14809319e-02f, 6.35864884e-02f,
  8.45969170e-02f, -1.61447302e-02f, 5.60972951e-02f, -1.70079116e-02f, -3.94832119e-02f, -3.97071354e-02f, 2.17162222e-02f, 4.22908179e-02f, 3.60849723e-02f, -1.14007629e-02f,
  1.04591236e-01f, -2.66491733e-02f, -6.12344816e-02f, -5.42610884e-02f, -1.13573886e-01f, -8.80899653e-02f, 4.03181984e-05f, 2.64145639e-02f, 3.81302573e-02f, -1.13791078e-01f,
  -1.14827059e-01f, 9.42504853e-02f, -5.46012074e-02f, 7.53448978e-02f, 7.92483464e-02f, 4.13898453e-02f, 4.81987968e-02f, -9.42342100e-04f, -6.24597780e-02f, -8.25856626e-02f,
  4.23779897e-02f, -1.12304296e-02f, 2.26814356e-02f, -5.19409329e-02f, -3.06183137e-02f, -4.81249727e-02f, -6.26390427e-02f, -9.73123312e-02f, -3.34705822e-02f, 5.37861415e-05f,
  -2.03163773e-01f, -2.77358200e-02f, 2.27095664e-01f, -4.04269919e-02f, 9.93958861e-02f, 1.82223499e-01f, 1.20739423e-01f, -1.00664003e-02f, -3.62284221e-02f, -1.21234141e-01f,
  -3.40414569e-02f, -9.38975364e-02f, 1.67733192e-01f, -9.99585688e-02f, 1.31313682e-01f, -1.14942407e-02f, -5.84119074e-02f, -1.39034092e-01f, -1.48544341e-01f, -6.30564690e-02f,
  -5.11732213e-02f, -1.37640655e-01f, -4.61733118e-02f, -6.02659620e-02f, -1.19086646e-01f, -1.13846652e-01f, -6.33880720e-02f, -7.26834759e-02f, -2.88689099e-02f, -1.08064033e-01f,
  -8.22086632e-02f, -4.33353409e-02f, 4.13104929e-02f, 4.44939919e-02f, -4.46105786e-02f, -2.85231303e-02f, 4.45778519e-02f, 6.41875416e-02f, -2.20893361e-02f, -6.55061007e-02f,
  8.59640762e-02f, -7.73102343e-02f, -3.29478830e-02f, 1.63119915e-03f, -1.88804679e-02f, 7.76583105e-02f, -7.67779723e-02f, 2.41105743e-02f, -6.11138195e-02f, 7.52567127e-02f,
  5.48318177e-02f, -8.15614767e-04f, -4.50451532e-03f, -1.03238942e-02f, 1.21747945e-02f, 7.73452446e-02f, 6.80104345e-02f, 2.29024631e-03f, 5.24162762e-02f, -3.90504934e-02f,
  -4.52499650e-02f, -6.87332451e-02f, 8.75403173e-03f, 6.29583746e-02f, -6.61188141e-02f, -6.29044846e-02f, 3.93597856e-02f, 1.12988977e-02f, -1.04082428e-01f, -9.79519337e-02f,
  2.07295176e-02f, 4.13777009e-02f, -6.31498992e-02f, -8.29162821e-02f, -4.06918153e-02f, 1.32434973e-02f, 7.67069981e-02f, -5.52029461e-02f, -3.14162932e-02f, -2.09058728e-02f,
  -1.14933610e-01f, -2.34279707e-02f, 1.67310797e-02f, 4.21417551e-03f, 5.46266418e-03f, -1.54857207e-02f, -9.57751367e-03f, -1.08527467e-01f, 3.70396907e-03f, 6.81618229e-02f,
  1.01149924e-01f, 4.00671326e-02f, -7.61057884e-02f, 1.06198853e-02f, 2.19679289e-02f, -9.12327133e-03f, -4.39622849e-02f, 3.05284522e-02f, -5.55850938e-03f, 5.12470715e-02f,
  3.33763584e-02f, 3.94965224e-02f, -5.67339621e-02f, -1.53196305e-02f, 2.15228684e-02f, -3.27679701e-02f, -5.56389652e-02f, -9.28433016e-02f, -6.54249918e-03f, -1.43307112e-02f,
  7.17560425e-02f, 7.92222619e-02f, -1.31080132e-02f, 2.56899428e-02f, -4.04672921e-02f, -9.48382616e-02f, 5.22473790e-02f, -3.49380970e-02f, -3.12387617e-03f, 1.36178974e-02f,
  2.53324062e-01f, -4.02669489e-01f, 2.65575498e-02f, 2.66202658e-01f, 3.10380995e-01f, 6.78972006e-02f, 1.52451441e-01f, -1.28694186e-02f, 1.72786281e-01f, -1.51042134e-01f,
  -5.31456321e-02f, -5.23609594e-02f, -2.14813948e-01f, 1.00382008e-01f, 1.58414900e-01f, -1.69693157e-01f, 1.27376929e-01f, 1.18809482e-02f, -1.66338980e-02f, 3.81145328e-02f,
  1.09714054e-01f, 6.84725344e-02f, -1.26448289e-01f, -1.72478393e-01f, 1.01958565e-01f, -7.45412931e-02f, -5.78786200e-03f, -1.08548984e-01f, 6.45256266e-02f, -1.32050812e-02f,
  5.38582131e-02f, -8.16672370e-02f, -1.57242686e-01f, -4.02238406e-02f, 3.65876406e-02f, 1.40420999e-02f, 1.91948749e-02f, -3.89875956e-02f, 7.89187402e-02f, -3.76486257e-02f,
  -3.08031179e-02f, 2.90706679e-02f, 5.02479598e-02f, -4.90344428e-02f, 4.71307198e-03f, -2.97244396e-02f, -2.86350343e-02f, 1.16161359e-02f, -7.03691021e-02f, -5.11907525e-02f,
  -5.39114252e-02f, -4.63411771e-02f, 1.47699267e-02f, -3.84063050e-02f, 2.92665008e-02f, 3.99343558e-02f, 6.76933676e-02f, -5.00123296e-03f, -4.64608520e-02f, -1.05950115e-02f,
  -1.82397395e-01f, 3.56966853e-02f, 4.36619781e-02f, -3.10487393e-02f, -3.02898157e-02f, 2.20492687e-02f, 3.11590116e-02f, 5.05891852e-02f, 6.65222853e-02f, 3.56829837e-02f,
  -4.19354513e-02f, 4.50467244e-02f, 1.48386098e-02f, 3.39323878e-02f, 5.42003363e-02f, 5.49180154e-03f, 1.27788141e-01f, -2.35110358e-03f, 3.43736932e-02f, 4.58913622e-03f,
  1.82171240e-02f, -2.67225746e-02f, 1.90780424e-02f, 7.46604009e-03f, 9.01983008e-02f, 1.85317397e-02f, 4.23220210e-02f, 1.84627413e-03f, 2.93014441e-02f, -2.30154786e-02f,
  7.52419326e-03f, -1.09362759e-01f, -2.03728732e-02f, 3.26650515e-02f, -4.16187681e-02f, -5.03783338e-02f, 7.83576071e-03f, 5.24388216e-02f, -4.71386388e-02f, -5.46075106e-02f,
  4.79660705e-02f, 6.80132881e-02f, 4.31263074e-02f, 5.60900085e-02f, 8.20467807e-03f, 8.63151625e-02f, 1.14456102e-01f, -4.08718688e-03f, -1.07416315e-02f, -7.68856779e-02f,
  -4.74043703e-03f, 1.02522075e-01f, -8.20479915e-03f, -1.76673047e-02f, 6.85118185e-03f, 9.05500446e-03f, 7.43286014e-02f, -3.11590582e-02f, 2.61377972e-02f, -3.72507796e-02f,
  3.13526899e-01f, -2.23557174e-01f, 1.61507085e-01f, 2.91199476e-01f, 3.25340517e-02f, -2.28684738e-01f, 4.67642490e-03f, 1.39119655e-01f, -1.21584833e-01f, -2.14422345e-01f,
  1.99112445e-02f, -2.06461996e-01f, -9.00218487e-02f, 5.69068380e-02f, 2.81366378e-01f, -6.38609305e-02f, -2.29379861e-03f, -5.29127382e-02f, -1.32796288e-01f, 1.17529491e-02f,
  2.00826079e-01f, 1.06218643e-01f, 2.30581120e-01f, 1.08960673e-01f, 1.54734194e-01f, 1.55801505e-01f, 2.17642263e-01f, -8.94886553e-02f, 1.48245066e-01f, -2.56627742e-02f,
  -2.48637572e-02f, -6.07224694e-03f, 6.51474446e-02f, -5.46159223e-02f, 2.42225416e-02f, 2.82311961e-02f, -3.25303115e-02f, -1.54931191e-02f, 4.03274335e-02f, -1.09820276e-01f,
  -5.22862747e-03f, -1.19343899e-01f, 9.33349878e-02f, 8.10337141e-02f, 4.12595980e-02f, 1.03992119e-01f, 3.73108592e-03f, 2.79747900e-02f, -2.56228484e-02f, -6.32067323e-02f,
  3.94598693e-02f, -1.33746704e-02f, 1.08437696e-02f, -5.61512038e-02f, 4.74936552e-02f, -6.93424791e-02f, -2.80739721e-02f, -1.26836896e-02f, -9.30132717e-02f, 3.54926363e-02f,
  3.91752385e-02f, -5.88019490e-02f, -2.92470492e-02f, -1.85130432e-03f, 9.31895990e-03f, -2.76842760e-03f, -3.06848367e-03f, -4.76044193e-02f, -1.70767587e-02f, -7.01044276e-02f,
  -1.05231823e-02f, 3.17457169e-02f, -4.62411717e-02f, -6.72963783e-02f, -2.99328975e-02f, -6.18101209e-02f, 3.75880040e-02f, -6.32848442e-02f, -1.95225347e-02f, 5.45389093e-02f,
  -4.79303375e-02f, 8.38620290e-02f, 6.17396869e-02f, 1.45533020e-02f, -6.22146130e-02f, 3.49896541e-03f, -1.29850106e-02f, -2.55743433e-02f, 3.28961834e-02f, 5.71309812e-02f,
  7.62944892e-02f, 7.85411224e-02f, -7.33555183e-02f, -1.03246398e-01f, -4.32523824e-02f, -3.59490328e-02f, 4.65406058e-03f, -9.70649999e-03f, 2.51902379e-02f, 5.29557019e-02f,
  8.40279646e-03f, 2.92542689e-02f, -1.22788019e-01f, 2.74497159e-02f, 9.08739641e-02f, 9.79589019e-03f, -4.29832563e-02f, -1.28385508e-02f, 2.30794307e-02f, 6.14020042e-02f,
  3.98285501e-02f, -6.08042218e-02f, -3.89852077e-02f, 2.48699803e-02f, 5.31928912e-02f, 1.25074491e-01f, 5.83999157e-02f, 6.76653069e-03f, 7.91774467e-02f, 4.61218581e-02f,
  3.24146897e-02f, 2.74266005e-01f, 2.14792639e-01f, 1.39568195e-01f, 1.35609031e-01f, 1.84236001e-02f, -6.11402467e-02f, 7.99650606e-03f, 2.03110546e-01f, -1.57511551e-02f,
  -1.15862481e-01f, 3.91970389e-02f, -1.84230655e-01f, -1.68178417e-02f, -1.85207799e-01f, -4.54766750e-02f, -1.09459817e-01f, -1.26161471e-01f, -2.98846941e-02f, -1.51713952e-01f,
  -1.39443740e-01f, -1.81888774e-01f, -4.63021453e-03f, -2.60075703e-02f, 3.11491843e-02f, -7.30789304e-02f, -2.51053810e-01f, -4.60388996e-02f, -2.00879723e-02f, -1.42143115e-01f,
  -8.75867605e-02f, -1.16014816e-01f, 1.52691111e-01f, 1.55907432e-02f, -1.25429168e-01f, 1.16021065e-02f, -7.08828717e-02f, -4.69150767e-02f, -5.33443363e-03f, 8.28420445e-02f,
  -3.38226780e-02f, 6.92696124e-03f, 6.15718588e-02f, 7.53583014e-02f, 6.67925701e-02f, -2.09142105e-03f, 2.93982681e-02f, 7.59950280e-02f, 1.62266821e-01f, 9.74839851e-02f,
  2.39044111e-02f, 6.80663064e-02f, 8.02719519e-02f, 7.61030847e-03f, -1.52352722e-02f, -6.34872466e-02f, -6.60214275e-02f, 5.11615872e-02f, -3.21930349e-02f, 4.81709018e-02f,
  1.00944033e-02f, -7.98427537e-02f, -7.27278087e-03f, 6.76881447e-02f, -5.35606854e-02f, -2.89870482e-02f, -1.22863799e-01f, 8.39060843e-02f, -3.95307466e-02f, -6.33721426e-02f,
  1.04981765e-01f, -3.02309208e-02f, -8.38774536e-03f, -1.99038293e-02f, -2.07293630e-02f, -8.89185444e-03f, -1.94999315e-02f, -3.94778773e-02f, 4.31990065e-02f, -3.43630873e-02f,
  -7.29821697e-02f, 4.08643521e-02f, 1.33854756e-02f, 1.07504338e-01f, 1.11862943e-02f, 1.18438434e-02f, 4.79816906e-02f, -1.61910593e-03f, 5.95636740e-02f, -1.68112386e-02f,
  -1.29947364e-01f, -2.42089450e-01f, -4.88949902e-02f, 8.75648335e-02f, -3.17963324e-02f, 3.34604345e-02f, 6.04747571e-02f, 9.64089707e-02f, -3.54142971e-02f, -1.06237710e-01f,
  9.32712853e-02f, -2.10072454e-02f, -2.16047019e-02f, 1.63341202e-02f, -3.17412056e-02f, -2.28755306e-02f, -2.87399553e-02f, 3.21300849e-02f, 7.15732388e-03f, -8.05938914e-02f,
  8.74055028e-02f, 3.18711363e-02f, -3.81162874e-02f, -4.53277491e-03f, 3.53031754e-02f, 1.45391766e-02f, -5.19735217e-02f, 1.95461847e-02f, 7.05579966e-02f, -5.19226752e-02f,
  1.17898099e-01f, -2.08272994e-01f, -2.73055494e-01f, 2.47521818e-01f, 5.51879741e-02f, -1.43407091e-01f, -2.32064426e-01f, 1.65961877e-01f, -1.85141593e-01f, 2.78667081e-02f,
  3.88628572e-01f, -8.48321840e-02f, -1.20779574e-01f, 2.24210843e-01f, 3.96034598e-01f, -2.40303472e-01f, 3.05144727e-01f, 1.16990373e-01f, -6.56442270e-02f, 1.55646607e-01f,
  2.01572016e-01f, 4.08743232e-01f, 1.88922003e-01f, 4.30140674e-01f, 2.07495734e-01f, 2.14696810e-01f, 4.64760780e-01f, -3.02388496e-03f, 4.69987601e-01f, 1.63137764e-01f,
  -2.71149445e-02f, -4.49492820e-02f, 2.63552722e-02f, -1.17222354e-01f, 1.06226623e-01f, 9.11532938e-02f, -4.22637686e-02f, 9.33049917e-02f, -1.57014001e-02f, 2.78130192e-02f,
  -2.50695087e-02f, 5.60494103e-02f, 6.22536279e-02f, -1.13800369e-01f, -2.17228383e-02f, 1.51094969e-03f, -3.86694185e-02f, 1.74968969e-02f, -4.42413278e-02f, -6.29464015e-02f,
  -9.53276008e-02f, -5.66106997e-02f, -2.64699869e-02f, -5.46612591e-02f, -2.94301845e-02f, -2.65741516e-02f, -4.60150875e-02f, -7.54411444e-02f, -3.70692089e-02f, 3.28361765e-02f,
  1.78706452e-01f, -7.69346207e-02f, -4.64409739e-02f, 2.89047640e-02f, 4.17698361e-02f, 8.06188360e-02f, -3.52547914e-02f, 2.32024007e-02f, -6.43558502e-02f, 5.86424135e-02f,
  2.44851969e-02f, 4.49958816e-02f, -1.72322690e-02f, 4.93964693e-03f, 8.62303004e-03f, -2.03096867e-03f, -7.37515315e-02f, 1.29877776e-01f, -1.70440832e-03f, 3.04954145e-02f,
  -2.21361406e-02f, 4.77929153e-02f, -3.12328781e-03f, -4.47702743e-02f, -2.99449041e-02f, -1.89942941e-02f, 2.37531513e-02f, 3.04469969e-02f, -7.74182379e-02f, 3.98060530e-02f,
  -4.19649333e-02f, 2.56288916e-01f, 1.19500386e-03f, -3.68441595e-03f, -3.62938554e-05f, 5.42549677e-02f, 2.07954329e-02f, 2.20297500e-02f, 7.59559497e-02f, -1.00524509e-02f,
  3.31968665e-02f, 5.97767066e-03f, -4.86709289e-02f, 3.01442295e-02f, -4.24355315e-03f, 3.36082540e-02f, 6.76746219e-02f, 1.98360234e-02f, 1.21018372e-01f, 1.46951839e-01f,
  2.51744278e-02f, -6.09024614e-02f, 1.18325464e-02f, -6.33794591e-02f, 9.44286410e-04f, -1.62308067e-02f, -6.92557171e-02f, -7.61708291e-03f, 3.22122909e-02f, -1.37233408e-02f,
  2.38174573e-01f, -3.35934997e-01f, 6.15874231e-02f, -1.35837803e-02f, 7.37257674e-02f, 1.49580836e-01f, 1.85862109e-01f, -7.83688352e-02f, -1.30264079e-02f, -1.69359595e-01f,
  -5.19602969e-02f, 4.43281941e-02f, 1.05054252e-01f, -1.29023537e-01f, 1.74347475e-01f, -9.76346061e-03f, 1.48251129e-03f, 1.14828035e-01f, -6.03100285e-02f, -2.97945607e-02f,
  -2.65813712e-02f, 8.77572447e-02f, -7.41670560e-03f, -1.05922937e-01f, 3.76992859e-02f, -4.22744341e-02f, 9.32190865e-02f, 7.56390567e-04f, -7.95457885e-02f, 4.01642993e-02f,
  -8.28503966e-02f, -7.80724734e-02f, 3.07939779e-02f, -1.31212115e-01f, -1.00887731e-01f, -3.61747816e-02f, 6.23356514e-02f, 5.97681589e-02f, -7.70724192e-02f, 6.64979219e-02f,
  1.02229252e-01f, 2.30202693e-02f, -7.44356737e-02f, 8.12101527e-04f, -2.23445473e-03f, 1.30631085e-02f, 3.99505310e-02f, -3.15781347e-02f, 9.87128615e-02f, -1.89416800e-02f,
  -6.51574135e-02f, -8.44667777e-02f, 5.91454038e-04f, 3.20320651e-02f, -2.28498988e-02f, 7.03977123e-02f, 4.63087969e-02f, 1.90059934e-02f, 2.62962598e-02f, 1.92163363e-02f,
  4.66838069e-02f, -3.14795785e-02f, 8.78314767e-03f, -7.63258934e-02f, 2.56291758e-02f, 1.07132249e-01f, 3.67830731e-02f, 1.76948588e-02f, -6.63061813e-02f, 3.39213014e-03f,
  3.44854221e-02f, 4.20831032e-02f, -1.14100508e-01f, 2.10124645e-02f, -1.77211277e-02f, 7.50985220e-02f, -2.88542267e-02f, -3.34062055e-02f, -7.28744715e-02f, -4.17442322e-02f,
  1.02266371e-01f, 1.60603621e-03f, -6.86398447e-02f, -7.21007288e-02f, -8.95416960e-02f, 2.93466430e-02f, 3.72620709e-02f, -4.38081808e-02f, 1.17888171e-02f, 6.14128821e-02f,
  -2.15510741e-01f, -3.22291516e-02f, -1.06794782e-01f, 1.10315373e-02f, -7.07213208e-02f, -8.51805732e-02f, -1.64308324e-02f, -6.22995906e-02f, 6.43646196e-02f, -1.04167126e-02f,
  -2.14807447e-02f, -8.71773064e-02f, 1.54077811e-02f, 2.39534918e-02f, -2.32595112e-02f, -3.73849110e-03f, -4.40654233e-02f, -8.41601416e-02f, 6.04329482e-02f, 6.73299804e-02f,
  -6.50061155e-03f, 6.45446032e-02f, 6.97011407e-03f, -9.58517380e-03f, -4.99478541e-02f, -4.83261384e-02f, -1.66052654e-02f, 4.43989523e-02f, -4.85905558e-02f, -3.75574864e-02f,
  -1.94507197e-01f, -5.48749030e-01f, -3.80694449e-01f, -2.35142201e-01f, -2.04996869e-01f, -2.51877785e-01f, -2.87076205e-01f, -1.83319613e-01f, -2.06577107e-01f, 1.23914085e-01f,
  -7.59824738e-03f, -1.49744555e-01f, 1.00941911e-01f, -1.94560811e-01f, -1.00821577e-01f, 1.05789602e-01f, -2.35232741e-01f, -5.27090877e-02f, 2.38766056e-02f, -5.80507815e-02f,
  -1.48542225e-03f, -7.22280592e-02f, -6.62368387e-02f, 1.09321121e-02f, -1.51199937e-01f, 7.20659047e-02f, 2.18730390e-01f, 6.24867901e-02f, -6.97474033e-02f, -1.35327280e-01f,
  1.49216056e-02f, 1.08740270e-01f, -1.27996370e-01f, -5.38798224e-04f, 5.65327443e-02f, 1.93272281e-04f, 5.07096760e-03f, 6.58386648e-02f, -5.21388894e-04f, 4.50048707e-02f,
  8.86974297e-03f, -4.36398722e-02f, -4.78564277e-02f, -4.55679372e-02f, 1.36675956e-02f, -8.18180144e-02f, -4.17030640e-02f, -2.82963775e-02f, -2.10513882e-02f, -3.52812894e-02f,
  -5.27888052e-02f, -7.13114887e-02f, -8.57517403e-03f, -2.50893682e-02f, -2.00699214e-02f, -3.67763415e-02f, -1.06519364e-01f, -7.01665878e-03f, 2.45941486e-02f, -4.29428704e-02f,
  1.45767648e-02f, 5.54520078e-02f, -9.25589935e-04f, 2.66715270e-02f, -1.38690295e-02f, 1.01567850e-01f, -8.73605907e-02f, 5.00743613e-02f, -1.39138484e-02f, 6.33102143e-03f,
  5.19981161e-02f, -4.77705263e-02f, 7.09199086e-02f, -2.79790070e-02f, -3.81795969e-03f, 5.25227785e-02f, 7.74984285e-02f, 9.31992941e-03f, -1.39440432e-01f, 4.78028394e-02f,
  4.02350836e-02f, 9.97301042e-02f, -2.12522801e-02f, 6.55335560e-03f, -1.47360964e-02f, 3.87683883e-02f, 1.08603714e-02f, -2.05263048e-02f, 5.03439866e-02f, 6.59001470e-02f,
  -1.17204584e-01f, -9.99382362e-02f, 4.40769233e-02f, -6.45852685e-02f, 3.70942168e-02f, -1.46816922e-02f, -1.92894265e-02f, -4.08419222e-02f, -6.82969168e-02f, -4.74016368e-02f,
  1.99207459e-02f, -4.81552957e-03f, 6.80537745e-02f, 6.31033033e-02f, -4.66759019e-02f, 3.54932658e-02f, 6.52992278e-02f, -1.04293711e-02f, 3.01236119e-02f, 8.18650424e-03f,
  4.27662805e-02f, 4.82544303e-02f, 2.67509930e-02f, -6.57817870e-02f, 3.23574208e-02f, 3.25921997e-02f, -7.15982020e-02f, 2.79028118e-02f, -2.67160013e-02f, -8.67946297e-02f,
  1.18843615e-01f, 2.13993400e-01f, 1.77927986e-01f, 2.04602152e-01f, -8.41464773e-02f, -2.94685781e-01f, -1.95281394e-02f, 2.66547762e-02f, 1.70091823e-01f, 9.29033607e-02f,
  -4.35556583e-02f, 1.61523417e-01f, -1.21675059e-01f, 1.65833496e-02f, -4.57516223e-01f, -2.12090969e-01f, -5.00053540e-02f, 5.18467166e-02f, 4.37435023e-02f, 4.35349159e-02f,
  -5.88817447e-02f, -2.15976924e-01f, -1.32086575e-01f, -2.09847149e-02f, 2.12549835e-01f, 2.43750870e-01f, -1.57589868e-01f, 2.50787623e-02f, 7.51995668e-02f, -9.08809304e-02f,
  8.12274814e-02f, 9.93069485e-02f, 3.29855308e-02f, 1.24986796e-02f, -3.93378548e-02f, 3.49174440e-02f, 5.96674792e-02f, -3.50780189e-02f, -5.88190928e-02f, 1.63285621e-02f,
  1.04986265e-01f, -2.12288603e-01f, 3.38965580e-02f, 6.54451922e-02f, 1.02247991e-01f, 6.37028962e-02f, 2.45324103e-03f, 3.52073973e-03f, 4.29768562e-02f, 5.09664789e-02f,
  8.67125914e-02f, -5.76701872e-02f, 7.76459789e-03f, -4.81908880e-02f, -5.92577755e-02f, 8.14158991e-02f, -3.90759017e-03f, -3.92258205e-02f, 5.00918850e-02f, -2.69068498e-02f,
  -5.48060867e-04f, -5.79650849e-02f, -2.57219691e-02f, 9.43135545e-02f, 4.54602279e-02f, 9.92895141e-02f, 3.01903132e-02f, -1.54440617e-02f, -4.15609106e-02f, -4.98068556e-02f,
  -1.52394939e-02f, 5.52790007e-03f, -7.74964923e-03f, -2.89454795e-02f, 1.02408882e-02f, 4.57685478e-02f, -2.30002347e-02f, -3.20925042e-02f, -6.26908615e-02f, 6.68479279e-02f,
  -8.38085171e-03f, -4.70460504e-02f, 1.27514720e-01f, -2.77387854e-02f, -4.41794097e-02f, 8.87234807e-02f, -3.80775519e-02f, 6.64041787e-02f, -2.04507634e-02f, -4.60099280e-02f,
  -1.39956877e-01f, -1.46221638e-01f, -3.70991491e-02f, -3.14998068e-02f, 3.94889675e-02f, -3.38356979e-02f, -6.73306882e-02f, 6.04585074e-02f, -2.20941268e-02f, -6.02835678e-02f,
  -9.33862105e-02f, -2.16879044e-02f, -8.40355307e-02f, 2.46709827e-02f, -7.37314895e-02f, -2.09665783e-02f, -9.58077833e-02f, -5.05792201e-02f, -1.49391368e-01f, 2.47463696e-02f,
  2.31319517e-02f, 5.89649342e-02f, 7.22588822e-02f, -4.62774634e-02f, 2.17034016e-02f, -4.05210927e-02f, 8.03289860e-02f, 7.82822371e-02f, -5.07268757e-02f, 9.13798867e-04f,
  -2.88322926e-01f, -1.95528895e-01f, -4.40122753e-01f, 7.72980675e-02f, 2.17776373e-01f, 2.89893299e-01f, -5.07834274e-03f, 3.66305448e-02f, -4.56825525e-01f, 1.86338410e-01f,
  1.20102063e-01f, -2.59507775e-01f, -1.89572647e-01f, 2.84181416e-01f, -1.15767516e-01f, -2.76845664e-01f, 2.65202552e-01f, 9.73974988e-02f, -1.62363976e-01f, 2.07825914e-01f,
  -5.84291294e-02f, 3.71859163e-01f, -1.76831022e-01f, 1.24994956e-01f, 2.25801378e-01f, -2.22624838e-02f, 2.85600573e-01f, -6.20116778e-02f, 3.88494730e-01f, 5.48539404e-03f,
  1.51414037e-01f, -1.48295999e-01f, -8.95715132e-02f, -8.26012641e-02f, 9.08648372e-02f, 8.92721191e-02f, 1.17280081e-01f, -6.67810813e-02f, -1.32948160e-01f, -7.11289281e-03f,
  -3.11719980e-02f, -8.09981301e-02f, -1.34661207e-02f, -1.57489337e-03f, 3.85685451e-02f, -4.23112400e-02f, -2.00754851e-02f, -7.30700493e-02f, -9.79109332e-02f, -1.34124672e-02f,
  -7.63105080e-02f, 1.13712046e-02f, 1.22129014e-02f, -4.30587539e-03f, -5.00681661e-02f, -1.73740704e-02f, 4.97713685e-02f, -4.97177690e-02f, 1.22692380e-02f, 8.01315606e-02f,
  6.95730075e-02f, 9.98577476e-02f, 6.94416836e-02f, -2.54195686e-02f, 5.20515218e-02f, 1.81462020e-02f, 5.18419407e-02f, -3.56024653e-02f, -5.95361516e-02f, 7.54273683e-02f,
  8.43571033e-03f, 3.99424918e-02f, 1.44515447e-02f, 8.29513669e-02f, 2.08245032e-02f, 3.17569785e-02f, 3.27586047e-02f, 2.63235327e-02f, -1.09502925e-02f, 2.26032250e-02f,
  -5.00928089e-02f, -2.31008250e-02f, 7.53949285e-02f, 1.13557801e-02f, -1.96408182e-02f, -3.64949442e-02f, 4.21973504e-02f, -4.52083796e-02f, 4.81440909e-02f, 3.93015798e-03f,
  9.50297564e-02f, 2.05035567e-01f, -6.32142648e-02f, 1.62705202e-02f, -5.24219237e-02f, 1.24971978e-01f, -4.99517843e-02f, 2.30447557e-02f, 6.36805370e-02f, 1.82833727e-02f,
  1.58576429e-01f, -1.51656466e-02f, 9.72511396e-02f, 7.32824393e-03f, 2.30950899e-02f, 1.60727367e-01f, 7.04555288e-02f, 6.34309426e-02f, 8.10124651e-02f, 6.48947209e-02f,
  1.09311990e-01f, 6.69905990e-02f, 8.05306807e-03f, 1.20982297e-01f, 6.32912591e-02f, 9.52484608e-02f, 6.40003756e-02f, 6.59698918e-02f, 8.30933824e-02f, -3.55525874e-02f,
  -4.87558156e-01f, 3.53126854e-01f, -8.76271203e-02f, 1.87838525e-01f, -2.40043640e-01f, 3.05532604e-01f, 3.75152946e-01f, -1.68986823e-02f, 3.07534039e-01f, 3.10734063e-01f,
  8.27507898e-02f, 1.62565246e-01f, 1.73851848e-01f, 3.21897238e-01f, 6.03224337e-02f, 3.25182259e-01f, 2.61333972e-01f, 1.68987826e-01f, -1.51086058e-02f, -8.91563520e-02f,
  -1.10522069e-01f, 3.95856276e-02f, -6.66177422e-02f, -1.06687710e-01f, -7.23300278e-02f, -1.70167863e-01f, -1.17367506e-01f, -9.55934003e-02f, 2.31069848e-02f, -1.52893588e-02f,
  7.03947619e-02f, -2.57485896e-01f, -1.92025378e-01f, 7.91593194e-02f, -3.78043763e-02f, -3.74591537e-02f, -2.09948123e-02f, -4.01190221e-02f, -2.25131903e-02f, -3.71790342e-02f,
  2.47559845e-02f, -1.56347603e-01f, 8.44065323e-02f, 3.66503792e-03f, 4.20195423e-02f, -7.65824690e-02f, -7.80313760e-02f, 5.11048771e-02f, 2.73542013e-02f, -2.91314032e-02f,
  -6.32225499e-02f, -4.61765416e-02f, -3.25527862e-02f, 8.80589709e-02f, -6.72234148e-02f, 5.27380221e-02f, 5.67175820e-02f, -6.01605438e-02f, 1.18220290e-02f, 6.72664568e-02f,
  -7.44314194e-02f, -4.96406704e-02f, -3.00634187e-03f, -3.25940922e-02f, 2.05048863e-02f, -6.33623451e-02f, -3.53873521e-02f, 5.15286215e-02f, -5.36080673e-02f, -3.57392319e-02f,
  -1.51539845e-02f, -7.16721918e-03f, -1.47647997e-02f, -5.40073961e-02f, 2.49165650e-02f, -4.64813970e-02f, 3.51186050e-03f, 1.70486718e-02f, 4.79903556e-02f, 2.44545918e-02f,
  6.04922585e-02f, -5.78182284e-03f, 4.61759605e-02f, 5.58609776e-02f, 5.67046143e-02f, -1.50308516e-02f, 3.99531350e-02f, -3.80375646e-02f, -3.57844718e-02f, -3.21398601e-02f,
  3.00000578e-01f, 2.51568854e-01f, 6.38879985e-02f, -3.37277688e-02f, 1.01623103e-01f, -3.09084170e-02f, 7.09495321e-03f, -2.75469143e-02f, 7.15051591e-02f, 1.04633505e-02f,
  -6.48382753e-02f, 1.80951674e-02f, -6.65307343e-02f, -1.85697284e-02f, -1.27306199e-02f, 1.16541497e-01f, 5.12547828e-02f, 8.27577803e-03f, 1.94006078e-02f, -5.68071306e-02f,
  -4.68426235e-02f, -4.70733270e-02f, 5.68826729e-03f, -1.27330244e-01f, 1.92825578e-03f, -4.43205237e-03f, -2.35486496e-02f, -9.51718539e-03f, 4.49190382e-03f, 2.29666587e-02f,
  -1.40912697e-01f, -6.21792078e-02f, -2.94563055e-01f, -1.13472119e-01f, -7.05484971e-02f, -3.79142880e-01f, -2.65530199e-01f, -1.51183084e-01f, 6.32610843e-02f, -9.57583413e-02f,
  -2.72128612e-01f, 5.72070256e-02f, -1.10497102e-02f, -2.76489854e-01f, -2.09157579e-02f, 7.62064382e-02f, -3.43534142e-01f, -5.28663807e-02f, 1.17532253e-01f, -2.91752487e-01f,
  2.12878063e-02f, -1.46576509e-01f, -1.78752363e-01f, -3.40382494e-02f, -2.40950108e-01f, -5.05522750e-02f, 1.65462643e-01f, -7.33311772e-02f, -2.76841167e-02f, 9.52023268e-02f,
  -1.29573062e-01f, -1.29718527e-01f, -2.23787110e-02f, -6.58331439e-03f, -1.61406457e-01f, -3.68609838e-02f, -4.11939016e-03f, -1.40191028e-02f, 1.24777351e-02f, -4.11324911e-02f,
  1.62448585e-02f, -2.29234584e-02f, -4.62145619e-02f, 2.50652134e-02f, -3.30942012e-02f, 7.53941154e-03f, 6.93239679e-04f, -3.47661041e-02f, -1.76864862e-01f, -4.40005213e-02f,
  -6.57140538e-02f, -9.38776881e-03f, -7.80626088e-02f, 3.34688909e-02f, -1.08424353e-03f, -4.45097946e-02f, 3.80271450e-02f, -2.43205614e-02f, 2.49055568e-02f, 8.67041498e-02f,
  -5.27156182e-02f, 4.68292758e-02f, -1.39854308e-02f, -3.53949368e-02f, -6.44490793e-02f, -1.45105198e-02f, 8.39550942e-02f, 7.69468248e-02f, 3.47875990e-02f, 6.00481741e-02f,
  -3.74860689e-02f, 5.27945235e-02f, 2.02283802e-04f, -5.66070958e-04f, -2.45751422e-02f, 3.40433754e-02f, -1.09486450e-02f, 3.99345085e-02f, 6.86862245e-02f, -3.73416990e-02f,
  1.36513077e-02f, -2.28871424e-02f, 1.49984816e-02f, -5.56007251e-02f, 2.69312263e-02f, 7.32843131e-02f, 3.57716839e-04f, 2.51793247e-02f, -4.72588092e-02f, 9.88658424e-03f,
  -4.67789806e-02f, -2.23029226e-01f, -6.91715330e-02f, 2.89101037e-03f, 1.38198899e-03f, -3.97194810e-02f, 1.24895573e-01f, -2.07873061e-02f, 6.02742620e-02f, -4.43156958e-02f,
  -7.03536198e-02f, 7.90851563e-03f, 4.48089652e-03f, 1.18834181e-02f, 8.28042179e-02f, -6.01632195e-03f, -1.67968087e-02f, 6.67166337e-02f, -6.43625483e-02f, 3.45813818e-02f,
  -2.25591715e-02f, -1.45737072e-02f, -3.88145284e-03f, 7.07870498e-02f, 3.38092446e-02f, -4.97503672e-03f, 4.25021909e-02f, -2.80960426e-02f, -1.67138607e-03f, 3.72123420e-02f,
  3.68375927e-01f, -4.47937429e-01f, 1.92613434e-02f, -1.30035967e-01f, 8.10676441e-02f, 1.38217717e-01f, 2.03726590e-01f, -3.49787086e-01f, -4.65518802e-01f, -2.16865391e-01f,
  -1.89718772e-02f, 3.63676585e-02f, -1.25993237e-01f, -5.26792221e-02f, 3.03435892e-01f, -6.18394054e-02f, 2.14570090e-02f, -9.23244690e-04f, -1.36913285e-01f, -1.00123420e-01f,
  -6.61411211e-02f, 1.17230281e-01f, 7.30353519e-02f, 4.02452536e-02f, 1.11270562e-01f, -2.29588989e-03f, 1.54230312e-01f, 1.00869298e-01f, 7.89785683e-02f, 2.00289786e-01f,
  -8.23301321e-04f, -2.29046777e-01f, 1.21818678e-02f, -7.35123903e-02f, -1.05968188e-03f, -4.80781905e-02f, 1.03027590e-01f, 2.06655234e-01f, -9.02387053e-02f, -9.83009413e-02f,
  1.09674726e-02f, 8.87172297e-03f, 6.50816318e-03f, 1.06019065e-01f, 1.67350750e-02f, -7.23673925e-02f, 3.77676226e-02f, -1.02055572e-01f, -5.10959998e-02f, 1.03015769e-02f,
  -5.70732281e-02f, -1.01888306e-01f, -8.72807018e-03f, 1.09482501e-02f, 1.52885485e-02f, -1.05725057e-01f, -5.39762117e-02f, 8.15630108e-02f, -6.24307171e-02f, -5.05014732e-02f,
  5.02599664e-02f, 1.10608593e-01f, -1.18456073e-02f, 3.99816744e-02f, 1.69923697e-02f, 4.68129814e-02f, 4.24798159e-03f, 2.57857665e-02f, 2.94765681e-02f, 4.11483552e-03f,
  -1.39507996e-02f, -4.75777946e-02f, -3.36141186e-03f, 2.78647561e-02f, -9.69093759e-03f, -6.58536889e-03f, 2.99398229e-02f, 3.65354344e-02f, -1.15939446e-01f, -5.67384204e-03f,
  1.44533962e-02f, 6.98137954e-02f, 5.39526455e-02f, 2.69858148e-02f, 4.64790687e-03f, 1.12199187e-01f, -3.47348861e-02f, -1.91711746e-02f, -1.81041714e-02f, 5.18987216e-02f,
  -1.68018803e-01f, -1.89632908e-01f, 2.84839068e-02f, 9.14114118e-02f, -3.36164832e-02f, 8.53434298e-03f, -1.81991421e-03f, 9.09838080e-03f, -2.12613288e-02f, -4.61937487e-02f,
  -3.86499465e-02f, -4.53571081e-02f, -1.41552370e-03f, 1.50734726e-02f, 1.82671268e-02f, -1.22297034e-01f, -1.56221557e-02f, 3.74692790e-02f, -3.09554171e-02f, -5.71355261e-02f,
  -2.47732326e-02f, 1.20565653e-01f, 8.57104063e-02f, -7.61708990e-02f, -1.27448253e-02f, 1.44461527e-01f, -5.59528396e-02f, 1.88924707e-02f, 6.23754784e-03f, -5.15272729e-02f,
  1.10338427e-01f, 3.56811993e-02f, 3.51120308e-02f, 1.49567664e-01f, 4.11329418e-02f, -1.15545364e-02f, -1.08498357e-01f, -4.99172062e-02f, -4.55661230e-02f, -5.06206192e-02f,
  5.39333373e-02f, -1.14254661e-01f, 1.60948951e-02f, 1.08997701e-02f, -6.73984410e-03f, -1.09968409e-01f, -2.61762477e-02f, -1.47103490e-02f, 3.06815505e-02f, 3.99763472e-02f,
  4.43526879e-02f, -7.61000142e-02f, 8.77854228e-02f, 4.29448001e-02f, 1.13121994e-01f, 8.36902484e-02f, 1.10141948e-01f, 8.27952325e-02f, 7.28154778e-02f, 6.23651966e-02f,
  -4.66486998e-02f, -5.12466170e-02f, -7.33770281e-02f, 6.27782801e-03f, 3.15664634e-02f, -1.20665492e-04f, -1.20254725e-01f, -1.70056447e-02f, 6.34548813e-02f, -2.34887516e-03f,
  -4.58355211e-02f, -8.43048394e-02f, 3.06469407e-02f, 3.62400152e-02f, -6.87602460e-02f, 6.94092214e-02f, -2.52055563e-03f, 6.84780627e-02f, -5.80271408e-02f, -3.82846855e-02f,
  -3.65320370e-02f, 3.49794850e-02f, -9.98852029e-03f, 4.07974608e-02f, -1.15320817e-01f, 7.74284378e-02f, 1.94704195e-03f, -9.73219648e-02f, 1.13513097e-02f, 1.33073647e-02f,
  -5.51029891e-02f, 5.78611009e-02f, 1.31225865e-02f, 1.18464202e-01f, 3.93140204e-02f, -9.27615985e-02f, -5.98146534e-03f, -1.79307163e-02f, -5.31359285e-04f, -5.35484776e-02f,
  7.59240193e-03f, 8.56886208e-02f, 6.15799986e-02f, -3.36375833e-02f, 6.84137410e-03f, -9.29241255e-03f, 7.63369724e-02f, 1.64064951e-02f, -2.65289601e-02f, 3.58333066e-03f,
  7.62103572e-02f, -6.85102195e-02f, 1.21549167e-01f, -3.99982817e-02f, 3.62349264e-02f, -3.80594209e-02f, -3.26190069e-02f, 1.11228833e-02f, 5.97010814e-02f, -9.92353037e-02f,
  -6.78778440e-02f, -1.19569739e-02f, 6.93995729e-02f, -2.06298064e-02f, 1.34202465e-02f, 6.01084568e-02f, -6.31425232e-02f, 3.67846787e-02f, -9.99451578e-02f, -1.03433602e-01f,
  -9.20669734e-02f, 4.53547128e-02f, 6.84699938e-02f, 2.45086290e-02f, 8.06081444e-02f, -2.52368543e-02f, -9.23542213e-03f, 1.93887223e-02f, 4.70913351e-02f, -1.07347228e-01f,
  -8.97681192e-02f, -1.68706387e-01f, 4.84838597e-02f, 3.80203016e-02f, -5.95640875e-02f, 2.62768846e-02f, -1.81237850e-02f, -1.86894089e-02f, 2.34136879e-02f, 9.19903535e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  9.16284416e-03f, 3.76438759e-02f, 2.80083083e-02f, 4.13355939e-02f, 2.42092699e-01f, 5.02754562e-02f, 6.95593432e-02f, 4.06142563e-01f, 2.46651486e-01f, 3.88236940e-01f,
  1.53027683e-01f, -3.43509726e-02f, 1.94568917e-01f, -1.17971458e-01f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  2.64399737e-01f, -5.98052084e-01f, -3.65473747e-01f, -1.53097451e-01f, 3.44949871e-01f, -8.06517154e-03f, -7.42187258e-03f, 6.04575686e-02f, 2.43546933e-01f, -2.78561980e-01f,
  -6.15441576e-02f, -2.75816143e-01f, 7.88652152e-02f, -1.35876164e-01f, 2.48595357e-01f, 2.62438059e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -5.75190037e-02f, -3.06204647e-01f, 7.23324716e-02f, -2.72484303e-01f, 3.13894361e-01f, -5.66391014e-02f, 4.52112496e-01f, -1.63380206e-01f, -1.16833791e-01f, 8.15765262e-02f,
  5.92069447e-01f, -3.57431799e-01f, 2.32270971e-01f, -1.19592715e-02f, -1.32057309e-01f, -1.59154356e-01f, -1.56105366e-02f, -2.11707175e-01f, -2.32041851e-01f, 1.75623149e-02f,
  2.07309142e-01f, 2.38183245e-01f, -2.12110311e-01f, 2.60874629e-01f, -1.03200428e-01f, 1.16800807e-01f, -8.86023045e-03f, 2.34842137e-01f, 3.21346700e-01f, -2.43056133e-01f,
  -3.50762799e-04f, 4.89968210e-02f, 3.26231539e-01f, -1.38960198e-01f, 1.13624088e-01f, 2.88647264e-02f, -2.55966485e-01f, -2.04072237e-01f, 5.22987507e-02f, 6.80538192e-02f,
  8.91470462e-02f, 4.14071470e-01f, -1.29712790e-01f, 5.97957850e-01f, 3.97240788e-01f, -1.67820722e-01f, 3.22668254e-01f, -2.68440902e-01f, 3.33001167e-01f, -3.34279388e-01f,
  -6.90873861e-02f, 2.13754296e-01f, -1.06670305e-01f, 1.43548638e-01f, -2.86014676e-02f, -3.09235901e-02f, 3.27881962e-01f, -5.41934557e-02f, -6.07952885e-02f, 4.72320095e-02f,
  3.52433906e-03f, -1.10209145e-01f, 4.88851041e-01f, -1.19265400e-01f, 3.84947181e-01f, -2.72227041e-02f, 1.60357386e-01f, 2.17873707e-01f, -1.43420398e-01f, 7.97947720e-02f,
  2.52050132e-01f, -1.73378244e-01f, 2.96253651e-01f, 3.82537574e-01f, 2.35498771e-01f, -3.09691638e-01f, -3.80042102e-03f, 6.66047454e-01f, 2.80732393e-01f, -1.08488351e-01f,
  1.54152155e-01f, 4.60763345e-04f, -6.73520565e-02f, -1.74350202e-01f, 2.07234740e-01f, 2.37013519e-01f, -1.62819713e-01f, 3.27121735e-01f, 2.57694364e-01f, -2.51092762e-01f,
  2.00599059e-01f, -1.70757577e-01f, -2.28597477e-01f, 1.51053704e-02f, -2.22519964e-01f, 6.74623484e-03f, 2.32291818e-01f, -4.61632721e-02f, 3.64270121e-01f, 3.57003361e-01f,
  -2.66712576e-01f, -1.42005816e-01f, 7.77728334e-02f, -4.46820520e-02f, -2.32541084e-01f, 6.45360053e-01f, -2.47796148e-01f, 5.92484951e-01f, 4.78149951e-01f, 3.91178548e-01f,
  6.41983049e-03f, -3.47241938e-01f, 7.77910873e-02f, 8.76330435e-02f, 4.77541573e-02f, -6.16535358e-02f, 4.53246199e-02f, -9.10901278e-02f, 3.26377153e-01f, 1.39735192e-01f,
  -1.44922016e-02f, -2.08977833e-01f, 3.37161839e-01f, -8.97293240e-02f, -1.66715622e-01f, -7.65242353e-02f, -7.18889460e-02f, -2.13733181e-01f, -4.67281826e-02f, -2.54895478e-01f,
  7.95072913e-02f, 2.45715007e-01f, -2.54384190e-01f, -1.48742333e-01f, 1.16908230e-01f, 3.26927334e-01f, 4.47807573e-02f, 2.50601262e-01f, -2.91472059e-02f, 5.76417506e-01f,
  3.60209316e-01f, 4.05127674e-01f, 2.66417801e-01f, -1.85995430e-01f, 7.29612485e-02f, 4.97659147e-02f, 2.19928727e-01f, 2.27266490e-01f, 1.09617151e-01f, -5.16898222e-02f,
  -2.55078495e-01f, -1.06286466e-01f, 1.81659967e-01f, 1.26405641e-01f, 9.44135487e-02f, -1.59220800e-01f, 2.92534441e-01f, -2.02902004e-01f, 9.16533098e-02f, -2.80555133e-02f,
  4.83535558e-01f, 6.51652575e-01f, -1.44555932e-02f, 3.27920355e-02f, -2.44146049e-01f, -4.97651882e-02f, 3.80470663e-01f, 6.02241278e-01f, -2.84269094e-01f, 5.18315911e-01f,
  5.69298744e-01f, 2.46148527e-01f, -1.36294514e-01f, 5.63299060e-01f, -1.48655444e-01f, -1.58315282e-02f, 6.76922917e-01f, -2.82329649e-01f, 1.28009915e-01f, 3.08626741e-01f,
  2.80450284e-01f, 6.80775762e-01f, 1.76650226e-01f, 1.05131209e+00f, 3.10267746e-01f, -2.64243543e-01f, -8.94113481e-02f, 5.27571976e-01f, -1.00300223e-01f, -2.11445838e-01f,
  7.06722677e-01f, 1.66682929e-01f, 5.35421610e-01f, -4.56160814e-01f, 3.54693621e-01f, 6.02043830e-02f, -1.32709801e-01f, -2.69351631e-01f, -9.18636937e-03f, 3.16295028e-01f,
  -1.76448449e-01f, 1.85146153e-01f, -3.02075714e-01f, 4.38791290e-02f, 8.35862458e-01f, 9.92290229e-02f, 2.73223817e-01f, -1.64701268e-01f, 2.11508051e-01f, -3.28358054e-01f,
  -2.53771871e-01f, 1.48969024e-01f, 2.07633510e-01f, 7.52877891e-02f, -2.97425181e-01f, -3.93089876e-02f, 2.68887311e-01f, -7.47282580e-02f, -1.97135419e-01f, -2.09994063e-01f,
  9.22970176e-02f, 1.44455219e-02f, 2.95530379e-01f, -2.06360161e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  4.69905376e-01f, -5.19000627e-02f, 3.37653458e-01f, 6.06554039e-02f, 1.04338810e-01f, -1.66222662e-01f, 3.41939032e-01f, -7.11237639e-02f, -7.52563030e-02f, -2.23247662e-01f,
  5.43560803e-01f, 9.23490822e-01f, 4.98157322e-01f, 3.84857552e-03f
};

// L2_fan_Wp (Shape: 1 x 16)
const int L2_fan_Wp_rows = 1;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -1.55183807e-01f, -3.79072666e-01f, 1.17244489e-01f, 1.71720892e-01f, -1.86889976e-01f, -2.16854781e-01f, 1.13008723e-01f, 2.58305296e-02f, -1.57969475e-01f, 4.10218798e-02f,
  9.97276157e-02f, -2.34261215e-01f, 2.99413830e-01f, -1.35350376e-01f, -3.25990170e-01f, -2.27561131e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 16)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  5.26286840e-01f, -1.09462924e-02f, 5.02732992e-01f, -3.22407454e-01f, -2.30216198e-02f, -7.20523074e-02f, -1.42784476e-01f, -2.12343484e-01f, -2.32883364e-01f, 2.54857421e-01f,
  -2.54686147e-01f, 1.34519070e-01f, 2.54258960e-01f, 7.30697811e-02f, 2.56492615e-01f, -1.26745954e-01f, -1.61756068e-01f, 3.46922934e-01f, 9.34673250e-02f, 9.60733593e-02f,
  -1.65089324e-01f, 1.76495835e-01f, 3.89329866e-02f, -1.03610329e-01f, -3.26626092e-01f, -2.62945503e-01f, 1.23351045e-01f, 8.81820917e-02f, -6.52182028e-02f, 6.17572129e-01f,
  1.96643308e-01f, 3.14665973e-01f, -5.77183403e-02f, -3.74160230e-01f, -3.94783169e-01f, 2.23487556e-01f, 3.34357262e-01f, -1.24339432e-01f, -2.65960544e-02f, 1.93859413e-01f,
  3.99276495e-01f, 7.12459162e-02f, 3.40887368e-01f, -2.31490761e-01f, 4.98212785e-01f, 6.30315185e-01f, 5.41805886e-02f, -1.41683623e-01f, -8.86674002e-02f, -9.95996445e-02f,
  -1.62012756e-01f, -2.47111730e-02f, -1.53401852e-01f, 1.03958964e-03f, 3.42929363e-01f, -1.39823511e-01f, 3.80742580e-01f, -4.25377078e-02f, 1.96527064e-01f, 9.93373916e-02f,
  -7.39445165e-02f, 5.25099970e-02f, 1.27698287e-01f, 2.59816218e-02f, 2.10393429e-01f, -6.20588839e-01f, -6.15837686e-02f, -1.35206938e-01f, -5.64452037e-02f, -3.39172691e-01f,
  2.54584610e-01f, -3.34939286e-02f, 4.17400479e-01f, 6.43359050e-02f, 2.80882150e-01f, -2.91914701e-01f, 8.12064707e-01f, 2.19893008e-01f, 2.33913228e-01f, -3.24328333e-01f,
  2.14007422e-01f, -4.62546885e-01f, -4.70829099e-01f, 1.70413673e-01f, 5.47685206e-01f, -8.29423070e-02f, -5.12307584e-01f, 8.42516497e-02f, 5.55894792e-01f, 1.15633979e-01f,
  3.55629683e-01f, -6.87285885e-02f, 3.81013483e-01f, 6.66628957e-01f, 5.04193187e-01f, -3.86674672e-01f, 4.62316871e-01f, 8.11453640e-01f, 2.78601736e-01f, 8.18890855e-02f,
  -2.35111848e-01f, 1.74687013e-01f, 1.76412895e-01f, 3.88580143e-01f, -5.62835157e-01f, 1.71856523e-01f, -4.58240449e-01f, -1.43829942e-01f, 2.37993941e-01f, 1.39306855e+00f,
  9.95188393e-03f, 1.91221580e-01f, -2.41066664e-02f, -1.46042123e-01f, -2.32395113e-01f, 2.73271829e-01f, 3.50481868e-01f, -1.02022052e-01f, -1.99827239e-01f, -7.97746032e-02f,
  -7.57779414e-03f, 1.70671180e-01f, 3.69791657e-01f, 4.78709340e-02f, -1.34315193e-01f, 7.35386834e-02f, 1.84348777e-01f, -2.37255797e-01f, 1.45028746e-02f, 3.44599754e-01f,
  2.34174386e-01f, 2.86126196e-01f, 1.10908151e-01f, -1.45988882e-01f, 3.26569468e-01f, -1.05147948e-02f, 3.26875836e-01f, 1.89962283e-01f, 7.11813122e-02f, 4.89677116e-02f,
  3.43946889e-02f, -2.19749659e-01f, 5.41546047e-01f, 5.49991913e-02f, 3.29072773e-01f, 6.57528266e-02f, -2.12380335e-01f, 1.20362900e-01f, 4.51849788e-01f, 3.66867036e-01f,
  2.27010220e-01f, -1.10688835e-01f, 3.84540528e-01f, -1.98860511e-01f, 1.53093085e-01f, 1.33055434e-01f, -3.06329131e-01f, 1.05777010e-01f, 4.44398701e-01f, 2.29744688e-01f,
  2.88837284e-01f, -4.95373130e-01f, 3.18307996e-01f, -3.23737979e-01f, 1.64085045e-01f, -2.38589924e-02f, 6.38284206e-01f, 4.25246768e-02f, 4.19305891e-01f, -1.38573587e-01f,
  -1.04308523e-01f, -2.57219523e-01f, 9.27175522e-01f, -3.19657356e-01f, -1.51126623e-01f, 2.60630231e-02f, 5.35158396e-01f, 5.68665683e-01f, 1.51686698e-01f, 2.56503314e-01f,
  3.68989438e-01f, 4.33440685e-01f, -4.35044989e-02f, -2.79541552e-01f, 3.91256213e-01f, -5.10227829e-02f, 2.51144201e-01f, 7.23597333e-02f, -3.70543957e-01f, 4.80523914e-01f,
  7.16258764e-01f, -9.31075960e-02f, -1.30551770e-01f, 1.16483271e-01f, -3.01071018e-01f, 1.01405948e-01f, 1.79707497e-01f, 1.94437355e-01f, 2.26551682e-01f, -6.48383237e-03f,
  2.37337202e-01f, -1.04225285e-01f, 2.95128077e-01f, -2.07231656e-01f, -1.01047151e-01f, 2.77360529e-01f, 2.84320325e-01f, 4.07532342e-02f, 1.46822169e-01f, -2.62294292e-01f,
  2.34272212e-01f, 2.68196881e-01f, -4.76081856e-02f, -2.69437045e-01f, 4.41452265e-02f, -8.06978941e-02f, -1.20669983e-01f, 2.87767351e-01f, -1.34411350e-01f, -2.30054379e-01f,
  2.34296322e-01f, 5.24259567e-01f, -2.61984229e-01f, -2.76718885e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  7.78404951e-01f, 4.25306298e-02f, -1.93011537e-01f, 8.28753859e-02f, 2.61857182e-01f, 5.33271804e-02f, 7.18462825e-01f, 1.49329066e-01f, -1.84363589e-01f, 6.80420250e-02f,
  7.20122039e-01f, 1.96812138e-01f, 1.32347003e-01f, 1.13920599e-01f
};

// L3_fan_Wp (Shape: 1 x 16)
const int L3_fan_Wp_rows = 1;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  -1.77601561e-01f, 9.21812281e-02f, -3.00085366e-01f, 1.62444040e-01f, 8.64645392e-02f, -1.39563173e-01f, 2.01397166e-01f, -1.60304338e-01f, -4.45437640e-01f, 1.15948871e-01f,
  -1.72075965e-02f, 8.37398991e-02f, 1.74905032e-01f, 2.80319035e-01f, -1.03360772e-01f, -1.91015676e-01f
};

// L3_fan_Wp_bar (Shape: 14 x 16)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  -1.04945309e-01f, -3.17746699e-01f, 1.61946669e-01f, -1.86507106e-01f, -1.42598420e-01f, 1.30845577e-01f, -1.99865587e-02f, 5.05346596e-01f, 8.41836631e-02f, 1.30236238e-01f,
  2.96243668e-01f, 3.67206261e-02f, -1.52427122e-01f, 6.89962268e-01f, 2.50106156e-01f, -1.35910451e-01f, -1.33883536e-01f, 1.25376344e-01f, -1.26869008e-01f, -3.29465754e-02f,
  3.83603014e-02f, -2.24607348e-01f, -3.87251601e-02f, 1.62427440e-01f, -5.37974276e-02f, 1.58031970e-01f, -1.90045953e-01f, 1.11942731e-01f, 1.59044653e-01f, -3.07461977e-01f,
  7.62693360e-02f, -1.70942172e-01f, 9.19908285e-01f, 3.43477100e-01f, 8.49509537e-01f, -1.87433347e-01f, 3.76762748e-02f, -2.74641693e-01f, 3.82304609e-01f, -2.79285461e-02f,
  6.32237554e-01f, -2.23755576e-02f, -3.19057077e-01f, -5.17396092e-01f, 7.13640511e-01f, -1.78647503e-01f, -5.65643191e-01f, 5.22242904e-01f, -1.04689352e-01f, -1.88076615e-01f,
  -6.92879111e-02f, -6.09310307e-02f, 3.17157865e-01f, -2.09489793e-01f, 1.29588112e-01f, 1.06300920e-01f, 2.20798880e-01f, -2.15847775e-01f, -4.24680561e-02f, -9.56252292e-02f,
  -9.21746865e-02f, -2.82030851e-01f, -1.09560959e-01f, 2.63596416e-01f, -2.64716715e-01f, -4.13077027e-01f, -7.37885982e-02f, -9.05136690e-02f, 3.52204889e-01f, 2.58417934e-01f,
  1.42395899e-01f, 5.02894938e-01f, -2.35343292e-01f, 3.24776769e-01f, 3.87746364e-01f, 6.57939315e-01f, -1.89062059e-01f, 7.11834073e-01f, 1.35025099e-01f, -3.97057652e-01f,
  2.00004771e-01f, 1.16255768e-01f, -1.49122044e-01f, 2.13123322e-01f, 1.20954096e-01f, -1.28681690e-01f, 1.17402136e-01f, 5.71994595e-02f, -2.13307902e-01f, 1.93412632e-01f,
  -2.82106567e-02f, 1.35868147e-01f, 4.62386876e-01f, -2.49762103e-01f, -7.89840743e-02f, -2.30815440e-01f, 3.04089010e-01f, -4.66820806e-01f, 4.86697614e-01f, 4.44440156e-01f,
  -2.84936428e-01f, -1.47387117e-01f, -6.05300702e-02f, -2.73723871e-01f, 1.39914441e+00f, -2.56949633e-01f, -2.56152779e-01f, 8.05592462e-02f, -7.82236829e-02f, 5.08739233e-01f,
  1.15206249e-01f, 4.80166972e-02f, -5.79453446e-02f, 1.11409999e-01f, 2.26434711e-02f, -2.22442895e-01f, 1.59659348e-02f, 2.26442412e-01f, 3.54902983e-01f, -5.88054180e-01f,
  -2.19613295e-02f, -2.92537481e-01f, 2.60349184e-01f, -2.98118234e-01f, 6.50801659e-01f, -2.29721412e-01f, -2.15510861e-03f, 5.26860207e-02f, 6.54154062e-01f, 2.56534934e-01f,
  2.22036526e-01f, -5.10586679e-01f, 5.79046488e-01f, 3.40006143e-01f, 1.03696465e+00f, 7.65258133e-01f, -5.04721105e-01f, -4.10031900e-02f, -1.53114006e-01f, -2.20547020e-02f,
  9.77162182e-01f, -1.36491209e-01f, 2.35459298e-01f, 1.47043049e-01f, 2.72540767e-02f, 5.36621585e-02f, 3.56669724e-02f, 1.89894766e-01f, 5.20527780e-01f, -2.34413832e-01f,
  3.62120688e-01f, 6.61399126e-01f, -2.74254799e-01f, 3.02631944e-01f, -3.47491980e-01f, 6.47904128e-02f, -1.59215212e-01f, 1.05857298e-01f, 2.66916871e-01f, 2.42103368e-01f,
  1.17782168e-01f, -1.57156989e-01f, 1.25688821e-01f, 1.46300763e-01f, 3.84232670e-01f, 1.08712770e-01f, 2.04914942e-01f, 4.02613968e-01f, -2.25786299e-01f, -6.79967692e-03f,
  1.27513498e-01f, -8.10737759e-02f, 4.81871143e-03f, 1.64778128e-01f, -1.12819046e-01f, 1.99212208e-01f, 6.55071288e-02f, 2.52897851e-02f, -3.14314812e-01f, 1.61075488e-01f,
  5.99005818e-01f, 1.96042433e-02f, 1.55801415e-01f, 5.08734524e-01f, 1.99815616e-01f, 5.54419495e-03f, -3.49638276e-02f, -3.41273725e-01f, -3.98745626e-01f, -2.63878822e-01f,
  -1.05499715e-01f, 2.61279762e-01f, 1.18280649e-02f, -3.18814278e-01f, -2.58345932e-01f, 5.20998120e-01f, 4.14223909e-01f, 2.76372042e-02f, -1.66919246e-01f, 1.55734703e-01f,
  1.03289378e+00f, 5.99385649e-02f, -3.78408462e-01f, 3.33425179e-02f, -1.60899714e-01f, 5.02446890e-01f, 2.18592510e-01f, 1.63554862e-01f, -1.33726075e-01f, -6.15943000e-02f,
  3.13569009e-01f, 2.33163938e-01f, -1.78219810e-01f, 2.33185172e-01f, 5.25974073e-02f, -9.95486006e-02f, -2.15968326e-01f, 4.45528068e-02f, 1.52590051e-01f, 2.44017452e-01f,
  -1.21734999e-01f, 3.74677390e-01f, 5.78233376e-02f, -2.18368158e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  8.75207782e-02f, -1.32797966e-02f, 5.02567887e-01f, 2.09407471e-02f, 1.90677062e-01f, 5.96015379e-02f, 4.85132635e-01f, -5.24262413e-02f, 6.31402493e-01f, -2.35544905e-01f,
  -2.71954805e-01f, -2.61686414e-01f, 9.45527852e-02f, 2.83116311e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  -1.05190724e-01f, 4.74949390e-01f, 2.12266579e-01f, -1.92242563e-01f, -6.41011834e-01f, -2.49027357e-01f, 6.02290630e-01f, -2.45250370e-02f, -8.61540496e-01f, 6.00093231e-02f,
  2.51223147e-01f, 3.98628920e-01f, 2.80477881e-01f, -2.01351523e-01f, -4.86213177e-01f, -2.33742911e-02f, -1.84197091e-02f, -7.91189447e-02f, 7.44718909e-02f, 2.45331883e-01f,
  -4.33847874e-01f, -1.78537637e-01f, 5.77849746e-01f, -2.71413606e-02f, -3.37818414e-01f, -2.77187705e-01f, -1.92951068e-01f, 4.12278622e-01f, -4.19870056e-02f, 3.98645699e-01f,
  3.32056850e-01f, -2.16584906e-01f, -6.84325874e-01f, 2.05872267e-01f, 1.01670615e-01f, 2.40044907e-01f, -4.20259893e-01f, -4.41839918e-02f, -9.67786238e-02f, 2.40053251e-01f,
  2.84576774e-01f, -7.02202022e-02f, -7.13748693e-01f, 5.63335001e-01f, 2.64904708e-01f, 2.06503808e-01f, 5.28496563e-01f, -3.15126061e-01f, 4.14875209e-01f, 7.41864443e-01f,
  -5.29651821e-01f, 2.16485053e-01f, 8.61604929e-01f, -1.09860852e-01f, -5.12555122e-01f, 3.76669556e-01f, -5.36030710e-01f, 3.04659903e-01f, 6.23399258e-01f, 3.44751999e-02f,
  -2.56191075e-01f, -1.32068530e-01f, -7.36809433e-01f, -1.34746581e-01f, 3.59756619e-01f, -3.95580471e-01f, 3.35141458e-02f, 3.78980450e-02f, 4.08640891e-01f, -2.78767318e-01f,
  -3.34830135e-02f, 1.88594833e-01f, 3.62908006e-01f, -4.17268544e-01f, 5.12603939e-01f, -3.30272093e-02f, 9.47365016e-02f, -5.02094030e-01f, -3.35254632e-02f, -8.58213753e-03f,
  6.91639960e-01f, -3.02574579e-02f, 6.66286469e-01f, 1.49175078e-02f, -3.93083036e-01f, 1.52936324e-01f, 5.55944622e-01f, -1.60637289e-01f, 3.23173374e-01f, 9.81348529e-02f,
  -5.80002606e-01f, -2.97046360e-02f, 6.33784160e-02f, -5.00005186e-01f, -1.01044841e-01f, 3.44363242e-01f, -1.42995119e-01f, -1.25833690e-01f, -8.98141563e-02f, -2.55659342e-01f,
  5.02656460e-01f, 7.38344528e-03f, -4.27531809e-01f, 1.48468345e-01f, 7.20508456e-01f, -9.29024071e-02f, -9.89693999e-01f, -3.97325099e-01f, -3.71290147e-01f, -9.22577232e-02f,
  5.58441162e-01f, -2.36490369e-01f, -3.56034607e-01f, 3.56437415e-01f, -2.23265022e-01f, -2.04545110e-01f, -2.82913238e-01f, -1.55181020e-01f, 3.96271870e-02f, 3.06930661e-01f,
  -6.17260695e-01f, 6.71600163e-01f, 7.09801674e-01f, 3.18746492e-02f, 1.57779947e-01f, -1.53323203e-01f, -2.37108186e-01f, -4.80243638e-02f, -5.05074084e-01f, -1.54920192e-02f,
  -8.29167739e-02f, 1.93680078e-01f, 3.60209376e-01f, 4.01225269e-01f, -4.85455662e-01f, -8.00694898e-02f, 1.70884773e-01f, -3.49051893e-01f, 8.06198269e-02f, 2.18323246e-01f,
  8.93896222e-02f, 5.48205078e-01f, 1.70777336e-01f, 8.80422667e-02f, -1.85616210e-01f, -3.06215703e-01f, 7.65647739e-03f, -2.00248644e-01f, -7.88341582e-01f, -4.65521291e-02f,
  2.74583071e-01f, 1.06246971e-01f, 6.56524777e-01f, -2.70637542e-01f, -8.96181047e-01f, -1.84393510e-01f, -3.38493884e-01f, -2.50326693e-01f, 6.50420189e-01f, -7.18238652e-02f,
  3.68878871e-01f, 2.83717185e-01f, -3.14637035e-01f, 2.74794251e-01f, 2.80317932e-01f, 1.56218484e-01f, -2.09731445e-01f, 2.09711179e-01f, -6.64226353e-01f, -4.78546917e-01f,
  6.19063556e-01f, 5.08429170e-01f, 2.71515340e-01f, 2.94675559e-01f, -2.75247395e-01f, -1.59462973e-01f, 1.17881633e-01f, -5.43590784e-01f, -3.25012714e-01f, 1.41701832e-01f,
  9.99888361e-01f, 1.43850818e-01f, -6.05167389e-01f, -1.39646798e-01f, 4.96601611e-01f, 2.39541814e-01f, 2.44495235e-02f, -3.37371051e-01f, -2.45588534e-02f, -1.48429960e-01f,
  -2.43123427e-01f, -1.83027890e-02f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -5.29843688e-01f, -3.60649258e-01f, -6.37181938e-01f, 4.13003862e-02f, 6.21555924e-01f, 5.68676293e-01f, 3.05272400e-01f, -2.96755880e-01f, -3.15886408e-01f, -8.36591199e-02f,
  -1.15128309e-01f, -1.65202674e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    