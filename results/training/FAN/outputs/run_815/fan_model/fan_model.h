/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.70485902e-01f, -7.14899004e-02f, -2.66642962e-02f, 3.73280615e-01f, 9.57155600e-02f, 1.79695994e-01f, 7.81210735e-02f, 1.40980065e-01f, 2.45169610e-01f, -3.05737406e-02f,
  1.57002717e-01f, 5.81372390e-03f, -1.16188399e-01f, -2.30869576e-01f, -4.01332676e-02f, -9.62385535e-02f, -2.35498369e-01f, -2.24104822e-01f, 3.35371457e-02f, 7.69891813e-02f,
  8.26398283e-03f, -8.68650898e-03f, 4.75189358e-04f, 1.35516534e-02f, -1.04882978e-01f, 1.08148120e-01f, -1.93829417e-01f, -1.22439869e-01f, -1.48794428e-01f, -6.81006491e-01f,
  -1.72864050e-01f, 1.61177758e-02f, 4.42975154e-03f, 2.86591891e-02f, -3.81808961e-04f, -8.57363548e-03f, 4.19570915e-02f, -2.88769212e-02f, 1.46877244e-02f, 1.55283231e-03f,
  -6.33964315e-02f, 1.64924096e-02f, -4.89047021e-02f, -1.60001684e-02f, -7.25482181e-02f, -4.38181944e-02f, 5.87639362e-02f, -8.33821073e-02f, -2.85750628e-02f, -8.91711041e-02f,
  -1.10632060e-02f, -1.01111546e-01f, 1.03636086e-02f, -2.57654535e-03f, -4.15726379e-02f, -6.28221557e-02f, 3.22710611e-02f, -1.37243539e-01f, -1.93752855e-01f, -1.85603872e-01f,
  -2.82675996e-02f, -2.37019435e-02f, -1.00423442e-02f, -2.02418249e-02f, 1.94226089e-03f, 6.09453730e-02f, -1.13816611e-01f, 3.75119559e-02f, 3.58919427e-02f, -2.31371680e-03f,
  7.03918398e-04f, 2.81778127e-02f, 1.89549159e-02f, 1.41273122e-02f, -7.56569877e-02f, 5.51814064e-02f, -5.37439622e-02f, -2.71237828e-02f, -5.85487969e-02f, -3.94910537e-02f,
  -1.83954984e-02f, -8.56093783e-03f, 3.78905162e-02f, -5.07169925e-02f, 3.67734246e-02f, -3.02402899e-02f, 4.91972752e-02f, 1.93667021e-02f, 6.35847077e-02f, 3.99918072e-02f,
  1.76550388e-01f, -1.39067233e-01f, -5.07291965e-02f, -7.18622282e-02f, 3.54677252e-02f, -3.34129520e-02f, 3.37819047e-02f, -5.19031882e-02f, -6.99422508e-03f, 3.25980075e-02f,
  9.62571651e-02f, -2.97035705e-02f, -1.38077205e-02f, -2.12648455e-02f, 8.91510695e-02f, 6.21863753e-02f, -1.53379580e-02f, 6.10001460e-02f, 2.76889224e-02f, 8.54208320e-02f,
  8.00708979e-02f, 1.51655450e-01f, 1.31707147e-01f, 4.11355831e-02f, 2.22353190e-02f, 6.04107492e-02f, 8.06518570e-02f, 7.45113641e-02f, 1.10626489e-01f, 2.35260442e-01f,
  4.31312978e-01f, -3.83925349e-01f, 6.11952841e-02f, 1.24263100e-01f, -2.66025931e-01f, 2.97675002e-03f, -3.46891224e-01f, -1.76516175e-02f, 8.78093913e-02f, -1.00996785e-01f,
  -7.19183162e-02f, 1.03784077e-01f, 8.68777782e-02f, 1.04929440e-01f, 1.50137991e-01f, -1.79842174e-01f, -2.60957181e-01f, 1.87792003e-01f, 4.84726578e-01f, -5.12415404e-03f,
  -2.26673633e-01f, 2.18353011e-02f, 2.55136997e-01f, 1.98368371e-01f, -4.06562775e-01f, 1.00694902e-01f, -5.05563356e-02f, -1.41499480e-02f, 8.14047530e-02f, -5.31338632e-01f,
  -1.64357631e-03f, -2.36225445e-02f, 4.00584415e-02f, 4.27271947e-02f, -7.90679008e-02f, 5.80790453e-02f, 1.15711079e-03f, 3.18261809e-05f, -3.52647416e-02f, 3.52647565e-02f,
  9.84117296e-03f, -2.10585259e-02f, 6.00399747e-02f, -7.57389935e-04f, -1.96195813e-03f, 1.49678774e-04f, -4.05845931e-03f, 2.44222693e-02f, 6.61493093e-02f, 3.76630649e-02f,
  -1.87256813e-01f, 3.34848912e-04f, -1.38013614e-02f, -5.40054329e-02f, 5.46525121e-02f, 6.19801506e-02f, -5.56597710e-02f, -1.81729760e-04f, 4.43075672e-02f, -6.01184852e-02f,
  -1.15138469e-02f, -1.88033003e-02f, -1.09618958e-02f, -3.09431297e-03f, -2.50926707e-02f, -2.13302486e-02f, 3.24784890e-02f, -2.80340612e-02f, -8.97561293e-03f, -3.54617136e-03f,
  1.17829675e-02f, 8.53143260e-03f, 5.70926117e-03f, 1.03860663e-03f, -3.02157295e-03f, -3.23647186e-02f, 1.65258811e-04f, 1.75330509e-02f, 2.54785363e-02f, -5.67664206e-02f,
  3.10269818e-02f, 2.97991373e-03f, -4.27352786e-02f, 1.56012848e-02f, -3.93185392e-02f, 2.41238456e-02f, -6.02084119e-03f, -5.39082587e-02f, 5.52384853e-02f, 1.42855421e-02f,
  -2.49516126e-02f, 1.08326949e-01f, 1.08691109e-02f, 6.54117391e-03f, 1.32879606e-02f, 3.71001288e-02f, -6.69263825e-02f, 4.09467518e-02f, 3.72163616e-02f, -3.79374661e-02f,
  -1.24934558e-02f, 5.54564036e-02f, -4.14996669e-02f, -2.09962614e-02f, 3.20540629e-02f, 1.24494163e-02f, -1.17197307e-02f, 1.71781741e-02f, -5.38176997e-03f, 3.24847996e-02f,
  -3.49237695e-02f, 9.54284519e-03f, 2.85442639e-02f, -6.42424216e-03f, 9.85006709e-03f, 4.64793220e-02f, -7.00751459e-03f, 1.15672946e-02f, 8.56782049e-02f, 1.40146911e-02f,
  -1.83507919e-01f, 7.97257293e-03f, -2.82039464e-01f, 1.64555833e-02f, -2.62652218e-01f, -1.97948888e-01f, -5.15368760e-01f, -9.90433991e-02f, 1.61867440e-01f, -1.69859171e-01f,
  8.31352025e-02f, 2.84810364e-01f, 3.02911580e-01f, 1.51221901e-01f, -1.64518058e-02f, -1.71180427e-01f, -6.14400692e-02f, -2.51607914e-02f, -6.25414625e-02f, -1.64072782e-01f,
  1.40691966e-01f, -7.35316426e-02f, 1.14824265e-01f, 1.17066965e-01f, -1.00784317e-01f, 2.55231708e-01f, -1.31648881e-02f, 1.09246178e-02f, 4.97793294e-02f, -5.11654206e-02f,
  -7.32154027e-02f, -2.81006634e-01f, 1.03478864e-01f, 5.80286384e-02f, 7.96267465e-02f, -4.53912467e-03f, -1.67839113e-04f, 6.84754699e-02f, 1.25695318e-01f, -5.04370518e-02f,
  1.01569727e-01f, 4.43548188e-02f, 2.98315063e-02f, 4.66030389e-02f, -3.81891690e-02f, -1.98769942e-03f, -7.65750743e-03f, -4.52884063e-02f, -4.09911200e-02f, -3.64278778e-02f,
  3.54371034e-02f, -1.32395932e-02f, -1.15391463e-01f, -8.39769840e-02f, -1.42978311e-01f, 4.11230251e-02f, -2.03516129e-02f, -1.22055419e-01f, 3.69700982e-04f, -1.31511251e-02f,
  2.36379262e-02f, -5.88287823e-02f, 5.40200099e-02f, -1.26694590e-02f, 3.50008681e-02f, -7.57973129e-03f, -4.82759468e-04f, 4.65238206e-02f, -2.09990107e-02f, -1.55879930e-03f,
  1.78738795e-02f, -5.84923401e-02f, 3.41747701e-02f, 7.51393801e-03f, 6.93273395e-02f, -5.89385889e-02f, -8.07295088e-03f, -6.16139546e-03f, -4.06251382e-03f, 2.98875757e-02f,
  2.83782128e-02f, -4.32421938e-02f, 3.82847302e-02f, 2.25606002e-02f, -9.40315723e-02f, 2.19373405e-02f, 2.32455265e-02f, -1.57334358e-02f, 1.24909766e-02f, -2.41712276e-02f,
  2.32296661e-01f, -1.55224297e-02f, 2.92835049e-02f, 1.53050041e-02f, -1.35593517e-02f, 5.75810336e-02f, 3.15216705e-02f, 2.16371305e-02f, -8.06520786e-03f, -1.22191710e-03f,
  -5.74089214e-02f, -3.00808437e-02f, -1.06802704e-02f, -4.66569960e-02f, 6.24551531e-03f, -3.46254967e-02f, 6.44850880e-02f, 5.15286401e-02f, -8.30696523e-03f, -7.69906789e-02f,
  4.00808677e-02f, -3.79079208e-02f, -6.69398531e-02f, 3.44209671e-02f, 3.45444195e-02f, -5.05626686e-02f, -2.36582384e-02f, -1.18273394e-02f, -5.04903533e-02f, 1.00251094e-01f,
  -2.42041185e-01f, 5.62832169e-02f, -3.71177167e-01f, 5.92757016e-02f, -1.70738474e-01f, -7.03958720e-02f, -2.61354119e-01f, 6.32806420e-02f, 9.42883193e-02f, -1.79001853e-01f,
  -9.50108394e-02f, -3.67717780e-02f, -6.13015182e-02f, -1.20291345e-01f, -1.36035338e-01f, -2.15975165e-01f, -1.71576917e-01f, -1.86588183e-01f, -2.29532316e-01f, -1.03606768e-01f,
  -8.21333658e-03f, 2.31152009e-02f, 6.95463866e-02f, 1.17068805e-01f, 1.32836625e-01f, 1.12426011e-02f, -5.17251305e-02f, 1.06375493e-01f, 1.10808536e-01f, 2.07148902e-02f,
  -2.54883200e-01f, 1.79013476e-01f, -2.45068017e-02f, 3.43298651e-02f, -5.81446365e-02f, 2.40137409e-02f, -3.18666399e-02f, -1.75445422e-03f, 6.53429627e-02f, -4.79646958e-02f,
  1.01093143e-01f, -2.11995211e-03f, 7.47731999e-02f, 1.19532429e-01f, 8.90854523e-02f, -3.83351161e-03f, 2.43330263e-02f, -1.08609477e-03f, -9.24166813e-02f, -8.38731974e-02f,
  -2.63471715e-02f, 1.14004061e-01f, 5.25867976e-02f, 1.12160295e-01f, 7.16934260e-03f, 4.12510298e-02f, 1.00683071e-01f, 1.36912838e-01f, 1.19824938e-01f, 1.25229312e-02f,
  -6.14785664e-02f, 1.58281426e-03f, -5.68965487e-02f, 3.33872586e-02f, 4.43976559e-02f, -4.64686193e-02f, 4.03412841e-02f, 3.95470439e-03f, -1.05699981e-02f, 1.18464939e-02f,
  -5.09040020e-02f, -4.41322140e-02f, -6.43063188e-02f, -5.06612845e-02f, 7.70452141e-04f, -1.57279242e-02f, 2.76700631e-02f, -3.47718075e-02f, 5.03037944e-02f, 8.86243433e-02f,
  -3.84844802e-02f, 6.03186339e-02f, -5.74102961e-02f, 1.20179094e-01f, -5.27680181e-02f, -1.44645339e-03f, -8.26343894e-03f, 5.01178345e-03f, 8.26402660e-03f, -4.74833995e-02f,
  1.32058099e-01f, -1.08915240e-01f, -4.16202396e-02f, 7.81101063e-02f, 5.27086705e-02f, -6.07673973e-02f, 2.59044231e-03f, -9.85758286e-03f, 9.65528712e-02f, 7.40003064e-02f,
  4.06717695e-02f, -2.73703900e-03f, -1.69602316e-02f, -1.41923046e-02f, 1.48695000e-02f, -2.10404769e-02f, -6.77198395e-02f, -3.83868907e-03f, 1.15664806e-02f, 3.70252281e-02f,
  -8.00181553e-02f, -4.23786491e-02f, 2.46933382e-02f, 4.30410504e-02f, 1.00988179e-01f, 1.60807092e-02f, -6.85369745e-02f, -5.11749135e-03f, -6.81147054e-02f, -2.15318844e-01f,
  -2.85626471e-01f, 7.22228587e-02f, 1.73241258e-01f, 2.49279235e-02f, 1.02440417e-01f, -1.15302242e-01f, -1.40060797e-01f, -2.10438386e-01f, 4.34027724e-02f, 7.53873773e-03f,
  8.16421676e-03f, 2.31743455e-02f, -1.67780500e-02f, -1.85886715e-02f, -2.22045764e-01f, -2.56348848e-02f, 7.83056989e-02f, 1.39862791e-01f, -2.66834106e-02f, -5.21403998e-02f,
  -4.67421208e-03f, -4.50730920e-02f, -1.03477435e-02f, -1.54406399e-01f, -7.95315281e-02f, -1.07476100e-01f, 5.40361553e-02f, 5.27591221e-02f, 8.26810971e-02f, 2.89562851e-01f,
  3.01097602e-01f, 6.26271367e-02f, -4.07487787e-02f, 1.13026686e-02f, 1.29374519e-01f, -3.88835855e-02f, 1.70199275e-02f, 8.61477330e-02f, 6.74451981e-03f, -2.83755530e-02f,
  5.57257533e-02f, -1.04230093e-02f, 1.89488139e-02f, 8.85005016e-03f, -1.93236005e-02f, -2.64066551e-02f, 5.96537627e-02f, -5.48865385e-02f, -1.16444295e-02f, 4.09165770e-02f,
  -9.57080629e-03f, 2.19665483e-01f, -2.42939946e-04f, -9.88113433e-02f, -6.35814443e-02f, 9.37257260e-02f, -1.04372539e-01f, -2.70412918e-02f, -7.73672611e-02f, -1.02911815e-01f,
  -5.64343259e-02f, -1.74063481e-02f, -1.19755054e-02f, -1.55158471e-02f, -1.58608928e-02f, -3.81778106e-02f, 2.91560721e-02f, -5.35812825e-02f, 8.11825693e-03f, -6.37060478e-02f,
  3.60605195e-02f, 4.99244593e-02f, -4.32109414e-03f, -2.21707933e-02f, 2.36114371e-03f, 7.32443556e-02f, -4.20680791e-02f, 1.20910788e-02f, 9.70611349e-03f, -2.08655223e-02f,
  -4.32138302e-04f, 1.90374516e-02f, 3.61825563e-02f, 2.25191470e-02f, 4.86423261e-02f, 8.35057646e-02f, 5.93121573e-02f, -4.79612611e-02f, -2.68987007e-02f, -1.96097558e-03f,
  -2.10028216e-01f, -1.22207545e-01f, -2.04701014e-02f, 8.57339520e-03f, -5.13140392e-03f, 8.36129934e-02f, 3.09313387e-02f, -2.23741159e-02f, 5.49708158e-02f, -2.21549887e-02f,
  -4.99438234e-02f, -1.03942724e-02f, 1.70470178e-02f, -5.75730279e-02f, -5.96481413e-02f, -6.62032068e-02f, -2.96202525e-02f, 1.71607640e-02f, 1.03408401e-03f, 1.58332866e-02f,
  -4.37078364e-02f, -9.82726216e-02f, -1.49092555e-01f, -5.77831417e-02f, -1.78693086e-02f, -9.93370339e-02f, -1.50878772e-01f, -4.48170789e-02f, -1.73784360e-01f, -3.28055084e-01f,
  1.29479393e-01f, -1.27179787e-01f, -1.38187960e-01f, -1.92482352e-01f, 8.42345059e-02f, -4.59363572e-02f, -1.11177504e-01f, -2.46325836e-01f, -8.13861713e-02f, -5.94384857e-02f,
  3.18414718e-01f, 1.64148644e-01f, 1.17792286e-01f, 2.04182342e-02f, -2.25124955e-02f, -3.12139153e-01f, -4.87182677e-01f, -2.00543776e-01f, -1.21111855e-01f, 6.82318881e-02f,
  -3.23134288e-02f, 2.24194247e-02f, 2.02140048e-01f, -4.04802039e-02f, -2.57080436e-01f, -3.08349561e-02f, -3.59763354e-02f, 1.51877841e-02f, 1.52702674e-01f, -2.68635184e-01f,
  2.10000902e-01f, -8.15881044e-02f, -9.61244553e-02f, 7.48827159e-02f, 7.85829276e-02f, -1.70041025e-02f, 5.16633354e-02f, -3.40051427e-02f, 1.93292033e-02f, 2.12814994e-02f,
  -2.73204260e-02f, 6.01957180e-02f, -6.71254992e-02f, 5.46229295e-02f, 1.10958302e-02f, -3.93132120e-02f, -9.52074975e-02f, -1.85310189e-02f, -4.89417128e-02f, 5.71795292e-02f,
  5.04317321e-02f, 1.22458287e-01f, 1.05368309e-01f, -3.21611725e-02f, 9.49278753e-03f, 8.88075754e-02f, 2.87269112e-02f, 3.14899092e-03f, -1.28738768e-02f, -1.32030144e-03f,
  3.40208560e-02f, 2.89169215e-02f, -1.98446568e-02f, 7.93166924e-03f, 3.33672240e-02f, -3.34846601e-02f, -3.51365842e-02f, 5.30872643e-02f, -6.67221919e-02f, 3.82579714e-02f,
  -7.22154006e-02f, 8.56062993e-02f, -6.15702718e-02f, -2.53550801e-02f, 1.09161381e-02f, -4.63734604e-02f, 4.70099896e-02f, 5.77857904e-02f, 4.42360304e-02f, 5.43246651e-03f,
  2.31255428e-04f, -1.44062797e-02f, -3.31696719e-02f, -5.37335537e-02f, -3.59371565e-02f, -4.64287065e-02f, 3.68831418e-02f, 9.07677859e-02f, 5.81415594e-02f, -1.95931662e-02f,
  -9.95317698e-02f, 1.58114120e-01f, -2.21965462e-02f, -9.45802778e-02f, -6.61522225e-02f, -3.78286429e-02f, -3.17810513e-02f, -2.50920113e-02f, 5.42106619e-03f, -8.10573343e-03f,
  1.84188876e-02f, -8.77606962e-03f, 3.11726369e-02f, -1.33165000e-02f, -2.71609016e-02f, -1.86783983e-03f, 5.42404642e-03f, -1.24718957e-01f, 1.02758380e-02f, 4.09350321e-02f,
  -6.10714778e-02f, -9.14167017e-02f, -5.53533845e-02f, -3.99550125e-02f, -7.44093908e-03f, -1.72201153e-02f, -1.88104305e-02f, -3.74137051e-02f, -1.56207159e-02f, -1.32453531e-01f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.82190970e-01f, 5.68891130e-03f, 2.79964898e-02f, -1.48389295e-01f, -1.21341027e-01f, 5.16241752e-02f, 6.94169402e-02f, -7.66374022e-02f, -9.57755372e-02f, 4.17381823e-02f,
  6.52562082e-02f, -4.21272926e-02f, -6.61787465e-02f, 7.17668375e-03f, 9.05364635e-04f, 8.73933360e-02f, -1.00677293e-02f, -2.66841762e-02f, -1.22741371e-01f, 2.75611337e-02f,
  -8.37310925e-02f, -3.63426358e-02f, -2.62658428e-02f, 1.40769854e-02f, -1.16931684e-01f, -5.35400808e-02f, -6.42807037e-02f, 6.81787403e-03f, 6.67553046e-04f, -1.38198484e-05f,
  6.33126171e-03f, -1.16334565e-01f, 2.25593913e-02f, -1.16174407e-02f, -7.17124641e-02f, 1.88726149e-02f, -4.27382020e-03f, -4.10454050e-02f, -3.50418687e-02f, -4.81051877e-02f,
  3.24558392e-02f, -9.27385911e-02f, -1.86724067e-02f, -8.72147095e-04f, -3.33278589e-02f, -5.20222411e-02f, -9.05523635e-03f, -1.01881050e-01f, -2.13860292e-02f, -5.75452782e-02f,
  -7.84636848e-03f, 1.10655720e-03f, -3.26005630e-02f, -4.55929376e-02f, -5.50209694e-02f, -2.57986076e-02f, 4.71612178e-02f, -2.19852701e-02f, 3.82440016e-02f, 9.03846547e-02f,
  -4.90120873e-02f, -8.22257176e-02f, -4.92922552e-02f, -3.56922261e-02f, -9.42446142e-02f, 3.79204825e-02f, -4.40533385e-02f, 3.44124027e-02f, -4.79979953e-03f, -1.04636282e-01f,
  3.37629393e-02f, -7.28244334e-02f, -1.92104541e-02f, -1.61413159e-02f, -7.67516196e-02f, 2.25903429e-02f, -3.12801600e-02f, -7.34169558e-02f, 2.45176675e-03f, 8.05627368e-03f,
  -7.65630156e-02f, 2.57404391e-02f, -1.03763074e-01f, 5.26406318e-02f, -2.49066614e-02f, -6.89470256e-03f, 1.27790775e-02f, 5.21935429e-03f, 1.13818108e-03f, 5.23737110e-02f,
  -5.99270649e-02f, 9.96211395e-02f, -3.34295332e-02f, -8.86486471e-03f, 3.72559354e-02f, -4.70570289e-02f, 3.41056623e-02f, 2.43128799e-02f, 3.04124281e-02f, -5.71085002e-05f,
  9.37785208e-02f, 3.35802846e-02f, -1.25877773e-02f, 8.70159790e-02f, -3.78266312e-02f, 4.71750740e-03f, 5.87061830e-02f, 1.69089250e-02f, -3.48215550e-02f, 2.20955238e-02f,
  1.02137633e-01f, 8.26376677e-02f, 3.30597088e-02f, 1.35224670e-01f, 6.15593232e-02f, 6.39144927e-02f, 1.55582070e-01f, 1.25336677e-01f, 1.36154443e-01f, 8.67008045e-02f,
  -4.08456951e-01f, -1.50499791e-01f, -2.15904787e-02f, -1.66439041e-01f, 1.03280060e-01f, 2.32480228e-01f, -1.70585379e-01f, 7.81301036e-02f, 3.39000896e-02f, -1.25144973e-01f,
  1.10726645e-02f, -8.53199214e-02f, -1.48142278e-01f, -1.09021574e-01f, -2.50358582e-01f, -1.47033781e-01f, -2.60369271e-01f, -3.23383868e-01f, -9.68679413e-03f, 1.56314477e-01f,
  -1.04942426e-01f, -3.43249798e-01f, -2.19586626e-01f, 1.40592426e-01f, 4.46231924e-02f, -3.49353254e-02f, 2.92341076e-02f, -1.83802307e-01f, 1.79273039e-01f, -3.51296663e-01f,
  1.19414851e-01f, 1.30918235e-01f, 1.01620015e-02f, -2.50173714e-02f, -6.52664155e-02f, 5.65910758e-03f, 1.97807644e-02f, -1.53756365e-01f, -2.26099528e-02f, 1.93048939e-02f,
  -3.26028001e-03f, 8.83575082e-02f, -2.04237979e-02f, -6.37292191e-02f, -2.05789674e-02f, 6.03719568e-03f, -9.15451795e-02f, -7.66049996e-02f, -3.13274972e-02f, 4.68431935e-02f,
  1.07090799e-02f, 2.79382374e-02f, 1.73701607e-02f, 1.59865782e-01f, 1.69360697e-01f, -4.24809866e-02f, 6.28343076e-02f, 2.12700143e-01f, 3.70384455e-02f, -7.14822188e-02f,
  8.42118040e-02f, 4.24623378e-02f, -4.38164249e-02f, 4.71422449e-02f, -3.99774723e-02f, 5.19722626e-02f, -4.70259832e-03f, -1.87022914e-03f, -5.74283563e-02f, 1.67376045e-02f,
  -7.38965115e-03f, 5.05031198e-02f, 1.64421815e-02f, -2.42033079e-02f, 4.80127666e-04f, -1.35856718e-02f, 1.79860480e-02f, 4.95022088e-02f, 5.18489582e-03f, -3.19794416e-02f,
  -3.73080410e-02f, 1.47831403e-02f, -7.32974634e-02f, 2.37493459e-02f, -4.20894735e-02f, -9.14110243e-03f, -3.50325182e-02f, 4.59321328e-02f, 8.25279020e-03f, 8.08948372e-03f,
  -2.71049917e-01f, 1.04605317e-01f, -2.23029740e-02f, -6.37701750e-02f, -2.29046736e-02f, -2.10196339e-02f, 1.15182204e-02f, 3.18591185e-02f, -1.36997020e-02f, -2.59632878e-02f,
  3.49518307e-03f, -1.68180689e-02f, -5.92514575e-02f, 5.38687557e-02f, -4.93460782e-02f, 4.40117382e-02f, -2.67490428e-02f, -1.16849571e-01f, 3.74289672e-03f, 9.42285657e-02f,
  -5.43983802e-02f, -1.16865054e-01f, -2.05426589e-01f, -1.30369127e-01f, -6.67228848e-02f, -1.08721308e-01f, -1.16337687e-01f, 9.52674821e-03f, -6.53226823e-02f, -2.95300752e-01f,
  6.01251721e-01f, 2.19046101e-01f, 1.54149592e-01f, 1.05263583e-01f, 2.31082905e-02f, -7.43732899e-02f, -1.13531619e-01f, -1.26184866e-01f, -2.72528250e-02f, 7.58966804e-02f,
  4.28672098e-02f, -1.24585778e-02f, -3.64225800e-03f, -1.11397460e-01f, -6.25880510e-02f, -1.10098474e-01f, -1.48978066e-02f, 1.14018992e-02f, -4.20413464e-02f, 2.82000713e-02f,
  8.70807990e-02f, 7.04240575e-02f, 2.77557909e-01f, 1.38065340e-02f, 1.51915357e-01f, -5.08628562e-02f, 4.25447300e-02f, 1.74227476e-01f, 1.45430610e-01f, 1.52993292e-01f,
  2.30698928e-01f, 2.84034252e-01f, -1.38796836e-01f, -5.39341867e-02f, 6.12728372e-02f, -3.37636955e-02f, 2.30657328e-02f, 6.56206459e-02f, 1.88129563e-02f, 7.64103094e-03f,
  1.17632523e-02f, 2.10384987e-02f, -6.50913408e-03f, -4.18528318e-02f, 5.06741032e-02f, 4.78902925e-03f, 7.82297924e-03f, 4.48535867e-02f, -5.39785586e-02f, 4.74274345e-02f,
  -9.30367112e-02f, 1.51460230e-01f, 2.21928433e-01f, -4.95474669e-04f, -3.39385532e-02f, 2.01988015e-02f, 1.58163503e-01f, 5.93985617e-02f, 1.12250470e-01f, 2.86128998e-01f,
  -1.21968435e-02f, -1.81303057e-03f, 9.05383378e-03f, 1.18545098e-02f, -5.00173755e-02f, -1.33893834e-02f, 2.90797763e-02f, -3.88898849e-02f, -4.56952676e-02f, 3.46803516e-02f,
  -2.37442795e-02f, -4.59548719e-02f, 1.35517254e-01f, 4.34535779e-02f, -5.43740727e-02f, 6.76408131e-03f, -6.94728866e-02f, -3.66514781e-04f, -1.24837216e-02f, -5.50972186e-02f,
  -1.89542081e-02f, -2.40151100e-02f, -1.05129126e-02f, 2.25579944e-02f, -2.45315135e-02f, -6.31535053e-02f, 3.16461399e-02f, -1.29671330e-02f, 2.04636827e-02f, 5.42180613e-02f,
  -4.84055560e-03f, -2.13953242e-01f, 7.03536719e-02f, 3.92467044e-02f, 6.18364429e-04f, 6.58932775e-02f, -1.27030294e-02f, 4.82666977e-02f, -2.58524138e-02f, 2.46276930e-02f,
  8.59938711e-02f, 8.99015367e-03f, -1.61322318e-02f, -2.87361443e-02f, 4.42722216e-02f, 4.77026030e-02f, 1.56955104e-02f, -6.11961400e-03f, -4.42841053e-02f, 8.92666578e-02f,
  -1.08608574e-01f, -4.30580527e-02f, 9.78270080e-03f, -7.16310441e-02f, 9.52363983e-02f, -1.99993849e-02f, 1.12311933e-02f, 4.64022532e-02f, -2.75993049e-02f, 4.41636182e-02f,
  -4.53277200e-01f, -3.05570543e-01f, 2.53398865e-01f, -2.36353204e-01f, 3.06072235e-02f, 2.14857742e-01f, 2.07874581e-01f, -1.23191930e-01f, -2.25900516e-01f, -5.22638969e-02f,
  2.78187376e-02f, -5.24348672e-03f, 1.62777007e-02f, 1.20134121e-02f, 3.11688986e-02f, 1.23438723e-01f, -6.67058378e-02f, 2.54728884e-01f, 3.61845136e-01f, 1.21024355e-01f,
  -3.48452255e-02f, -3.24656144e-02f, -1.21131517e-01f, 5.30843856e-03f, 1.75656681e-03f, 2.19848856e-01f, -6.08243793e-02f, -6.11616038e-02f, 2.73775365e-02f, -7.47217759e-02f,
  4.56231475e-01f, -3.12266231e-01f, 3.15747336e-02f, -1.24443024e-01f, -2.51430180e-02f, -1.55558541e-01f, 4.01875973e-02f, -6.87719211e-02f, -5.31733641e-03f, -2.92052794e-02f,
  -5.59066832e-02f, -6.89015761e-02f, 3.46257612e-02f, -5.34843765e-02f, -8.15768838e-02f, 7.63361482e-03f, -5.85957579e-02f, -1.76205635e-01f, -5.26578426e-02f, 5.28063364e-02f,
  1.52358029e-03f, 5.12014050e-03f, 1.99081346e-01f, 1.80820227e-02f, 6.71695247e-02f, 1.49183944e-01f, -3.69229503e-02f, -2.60910448e-02f, -3.55732739e-02f, -7.08402395e-02f,
  5.63268512e-02f, -1.11382676e-03f, 1.46283163e-02f, 3.44323143e-02f, 2.10099779e-02f, 3.09478436e-02f, -1.36821456e-02f, 9.48753580e-03f, -5.75522881e-06f, 2.96813268e-02f,
  -5.98848164e-02f, 5.39370812e-02f, 1.42505346e-03f, -7.60858804e-02f, -1.46671208e-02f, -6.67667091e-02f, 3.95976976e-02f, 2.58479919e-02f, -2.11463980e-02f, 2.44953372e-02f,
  2.12329463e-03f, -3.94261591e-02f, 5.24602644e-03f, 2.51038652e-02f, -1.03038780e-01f, -2.09886432e-02f, 3.44957560e-02f, 6.80341497e-02f, -7.05329031e-02f, -6.15911745e-02f,
  1.23236425e-01f, -2.71169066e-01f, 1.28592059e-01f, 1.95487170e-03f, -3.31997615e-03f, -3.67962196e-02f, 9.18253441e-04f, 2.31908318e-02f, -7.10025802e-02f, 7.73992762e-02f,
  2.76389886e-02f, 7.02849105e-02f, -6.38123369e-03f, -5.78644089e-02f, 6.58699870e-02f, 2.23390535e-02f, -6.70852885e-02f, 3.47644128e-02f, -1.33730322e-01f, -3.80146783e-04f,
  -1.39444292e-01f, 6.05490208e-02f, 2.67124176e-01f, 3.43023501e-02f, 4.07002307e-02f, 5.17080911e-02f, 3.16963196e-01f, 1.78661704e-01f, 6.46263286e-02f, 2.77244598e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  2.09801309e-02f, -2.60673523e-01f, 2.13730097e-01f, -1.24942675e-01f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -1.47763982e-01f, 1.37157068e-01f, -4.08654511e-01f, 1.25865731e-02f, 1.49324208e-01f, -6.08926117e-01f, 7.55637884e-03f, -1.97657943e-01f, -6.79539323e-01f, 7.38739893e-02f,
  2.07325965e-01f, -2.27504179e-01f, -1.44931287e-01f, -4.52777743e-01f, 2.42485642e-01f, -1.24622412e-01f, 1.16451934e-01f, -2.18842566e-01f, 1.07748248e-01f, 2.30575740e-01f,
  2.67699778e-01f, -3.44636261e-01f, -7.16661274e-01f, -4.62991148e-01f, -1.24853030e-01f, 5.00825457e-02f, 3.48878831e-01f, 8.60104263e-02f, 1.16271861e-01f, -1.55943334e-01f,
  1.78694904e-01f, -3.34983349e-01f, 1.42671272e-01f, -1.34625092e-01f, -4.35274959e-01f, 1.40609652e-01f, 3.39928746e-01f, -8.70027542e-02f, 3.59306000e-02f, 2.50835717e-01f,
  -3.52248669e-01f, -1.21614128e-01f, -4.16274332e-02f, -6.30866289e-02f, -2.66463816e-01f, -6.26025259e-01f, 7.58848013e-03f, 1.67425632e-01f, -3.48084837e-01f, 8.89816135e-02f,
  5.40286362e-01f, 5.58351651e-02f, -2.21540406e-01f, -1.73544273e-01f, -2.68885702e-01f, 4.07531351e-01f, 2.87234306e-01f, 6.88312948e-02f, 1.40756950e-01f, -3.18908930e-01f,
  1.72251701e-01f, -3.62474293e-01f, -2.24909782e-01f, -2.16650411e-01f, -4.95322682e-02f, 8.51081133e-01f, -1.66075706e-01f, 9.31618288e-02f, 3.93096581e-02f, 6.63453162e-01f,
  2.49913218e-03f, -2.58881390e-01f, -4.97152321e-02f, 1.07125670e-01f, 3.56696874e-01f, 2.35895768e-01f, -3.53376642e-02f, 3.18376005e-01f, 4.71757621e-01f, -4.39307660e-01f,
  4.02644157e-01f, 1.54634923e-01f, 5.63195383e-04f, 5.93927443e-01f, 1.07236847e-01f, 2.21966892e-01f, -3.64292443e-01f, -5.34722507e-01f, -1.69384792e-01f, -1.16606377e-01f,
  1.49302661e-01f, 1.90164410e-02f, 1.79260701e-01f, -6.84708208e-02f, -1.84247613e-01f, 1.57281101e-01f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -2.03605667e-01f, 5.43970168e-02f, -2.32023701e-01f, -3.42180789e-01f, -2.84452587e-01f, -2.77477503e-02f, -1.31246120e-01f, 1.88570499e-01f, 3.05652823e-02f, -1.42066956e-01f,
  -6.78788573e-02f, 1.71249360e-02f, -1.40597010e-02f, -1.93041712e-01f, 4.86499399e-01f, -1.34102730e-02f, -1.02816582e-01f, 3.26611578e-01f, -1.53458510e-02f, 2.76596755e-01f,
  1.09607615e-01f, 1.26427123e-02f, 2.54343003e-01f, -3.23028825e-02f, -3.73946697e-01f, -7.68106058e-02f, -7.10124448e-02f, 2.57107485e-02f, 2.62405962e-01f, 1.51747376e-01f,
  -8.08712468e-02f, 3.57149273e-01f, 3.94244134e-01f, -1.41193792e-01f, 2.12538749e-01f, -6.23308569e-02f, 3.72810066e-01f, 1.90722808e-01f, 2.81747103e-01f, 1.37969881e-01f,
  -7.48364106e-02f, 3.67253385e-02f, -7.64568895e-02f, 1.72441065e-01f, 1.68530449e-01f, -2.93058008e-01f, -4.55077648e-01f, 4.87587094e-01f, 2.16814980e-01f, -2.41929968e-03f,
  -5.11041693e-02f, 4.19568062e-01f, -4.24446836e-02f, 3.65942009e-02f, 1.44674629e-01f, -3.31328690e-01f, -6.93490580e-02f, -1.23941772e-01f, -9.44289099e-03f, 2.47818276e-01f,
  1.81515634e-01f, 8.35373774e-02f, -2.53138214e-01f, 3.90726924e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  -9.86199528e-02f, 3.35378908e-02f, 3.14230233e-01f, 2.67215371e-01f
};

// L2_fan_Wp (Shape: 6 x 16)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -3.73193175e-01f, 1.28992379e-01f, -8.13613385e-02f, 8.80316347e-02f, 6.34630620e-02f, 1.48096532e-01f, -4.53853965e-01f, -6.20305657e-01f, -1.65253118e-01f, 2.67883778e-01f,
  -2.17776760e-01f, -3.40681285e-01f, 1.90510482e-01f, -3.24118882e-01f, -6.23235144e-02f, -2.34233856e-01f, 2.12165892e-01f, -1.97964892e-01f, 2.41414517e-01f, -1.80317968e-01f,
  -3.73782784e-01f, -1.94430038e-01f, -1.29384892e-02f, 8.14569354e-01f, -5.18058753e-03f, -2.71953851e-01f, 2.29573604e-02f, 7.67064631e-01f, -2.19190031e-01f, 4.98862602e-02f,
  8.13577697e-02f, 3.14893693e-01f, 4.02791351e-01f, -2.35373020e-01f, 4.59161192e-01f, 1.63075719e-02f, 1.15511522e-01f, 2.62958348e-01f, 2.44938821e-01f, 2.65753567e-01f,
  3.24891120e-01f, 6.50070012e-01f, -2.82019675e-01f, 2.04445049e-01f, -2.47577235e-01f, -1.60183564e-01f, 2.80509912e-03f, -2.54117370e-01f, -2.88982481e-01f, 4.51493949e-01f,
  8.70455280e-02f, -3.68246824e-01f, -1.57904655e-01f, -1.36268198e-01f, -2.78356016e-01f, -3.23417008e-01f, -3.04263204e-01f, -2.81975210e-01f, -8.23395252e-02f, -4.66768146e-01f,
  -4.66887951e-02f, -2.98293293e-01f, -2.71023035e-01f, -1.26317188e-01f, -1.13031372e-01f, 1.29941955e-01f, 6.37701154e-02f, 4.91501808e-01f, -1.84021369e-01f, 3.40808988e-01f,
  -7.61960924e-01f, -9.38169360e-02f, -6.44749045e-01f, 5.33855557e-01f, 7.56529093e-01f, -2.44639739e-02f, 1.84793118e-02f, -1.81527615e-01f, -1.42994329e-01f, -2.93204207e-02f,
  -6.61044046e-02f, -3.85792643e-01f, -4.79280263e-01f, 1.37155995e-01f, -4.70332772e-01f, -1.54068083e-01f, -2.70371109e-01f, 1.57596007e-01f, -4.93671030e-01f, -1.52192026e-01f,
  8.74544561e-01f, 1.44717246e-01f, -3.29015732e-01f, 1.23301342e-01f, -6.32032931e-01f, -3.47290844e-01f
};

// L2_fan_Wp_bar (Shape: 4 x 16)
const int L2_fan_Wp_bar_rows = 4;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  1.77934706e-01f, 1.10312745e-01f, 1.79594994e-01f, 7.65591674e-03f, 2.03626603e-02f, 2.83450186e-01f, 4.61420327e-01f, 2.27544054e-01f, 2.15845257e-01f, 2.59307493e-02f,
  -1.29911721e-01f, 4.36477929e-01f, 4.33578864e-02f, -5.74901747e-03f, 2.09607273e-01f, -1.35226976e-02f, -2.16451377e-01f, 6.34342551e-01f, 3.47627908e-01f, 2.33148098e-01f,
  5.82657516e-01f, 2.16840088e-01f, -5.76116562e-01f, -7.62476981e-01f, -7.03998506e-02f, -2.08928645e-01f, 2.51803339e-01f, -4.18358326e-01f, -2.17815205e-01f, 1.55488610e-01f,
  4.85360682e-01f, 2.93235093e-01f, -4.08270322e-02f, 1.60025418e-01f, -5.25979139e-03f, -2.10001528e-01f, -9.17536318e-02f, -2.12501600e-01f, 1.59282655e-01f, 4.21998017e-02f,
  5.50370514e-02f, -4.25179489e-02f, 1.35026813e-01f, -8.99770856e-02f, -6.03030995e-03f, -2.12245565e-02f, -1.41647160e-02f, 1.28040269e-01f, -8.90323967e-02f, 2.64658481e-01f,
  5.30097485e-02f, -8.55559781e-02f, 2.08297580e-01f, -1.68416798e-01f, -1.26314104e-01f, -1.04956955e-01f, 2.28608511e-02f, -5.75531162e-02f, 2.66362607e-01f, 4.04811680e-01f,
  -2.16686651e-01f, 2.06890523e-01f, 2.20557362e-01f, 3.88464659e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 4)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 4;
const float L2_fan_Bp_bar_data[] = {
  2.65414774e-01f, 1.16685696e-01f, -2.83638656e-01f, 1.92796141e-01f
};

// L3_fan_Wp (Shape: 6 x 16)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  -4.64873165e-01f, -5.32590449e-01f, 2.88749158e-01f, 9.22346711e-02f, -2.32777804e-01f, -2.89426267e-01f, 5.25893033e-01f, 1.11196516e-02f, -8.87582242e-01f, 7.81808138e-01f,
  7.17927098e-01f, 7.14668930e-01f, -2.19816431e-01f, 9.65907238e-03f, -1.69145726e-02f, -2.26292491e-01f, 1.91007525e-01f, 2.64487833e-01f, 5.33732831e-01f, 1.58287361e-01f,
  -7.49974370e-01f, 6.58203304e-01f, -1.03620008e-01f, 3.83172184e-01f, -1.31061837e-01f, -2.00358659e-01f, 7.12144077e-01f, 1.24221027e+00f, -2.42763847e-01f, -1.79422811e-01f,
  -9.12649035e-02f, 1.11441702e-01f, 1.23731755e-01f, -2.85719752e-01f, 2.21740127e-01f, 1.77712217e-01f, -3.42105299e-01f, 3.05205286e-01f, 5.18790483e-01f, -5.51199257e-01f,
  7.21418625e-03f, 5.46257436e-01f, 4.58485216e-01f, 7.98952654e-02f, -4.77109939e-01f, 8.01774204e-01f, -9.45415199e-02f, 3.68640363e-01f, 4.10368502e-01f, -1.25153363e-02f,
  -1.10488310e-02f, -1.41999632e-01f, -5.80659151e-01f, 5.62051833e-01f, 3.27235609e-01f, -2.68586963e-01f, -4.58844662e-01f, 4.65903610e-01f, 9.96833920e-01f, 9.40546572e-01f,
  -2.56987572e-01f, 1.12147089e-02f, -1.67979017e-01f, -2.09664017e-01f, 1.67346165e-01f, -3.19762900e-02f, -2.31456786e-01f, -3.73284012e-01f, 3.69471729e-01f, 7.25485981e-01f,
  -6.14712834e-01f, 1.36497632e-01f, 9.09901381e-01f, -3.02994221e-01f, -9.09512341e-02f, -4.36918348e-01f, 1.37407050e-01f, -4.48554605e-01f, -1.37666062e-01f, -8.68297070e-02f,
  -7.77765289e-02f, -2.91468650e-02f, -1.87179819e-01f, 2.33822852e-01f, -3.55005056e-01f, 2.88240641e-01f, -4.12720650e-01f, 1.31041586e-01f, -1.54388174e-01f, 1.62660703e-01f,
  7.72667229e-01f, 1.15264869e+00f, -8.15545917e-02f, -6.33934557e-01f, -1.19239825e-03f, 5.23018353e-02f
};

// L3_fan_Wp_bar (Shape: 4 x 16)
const int L3_fan_Wp_bar_rows = 4;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  -2.09897444e-01f, -1.26741990e-01f, -1.19727328e-01f, 2.41838843e-01f, 8.47552866e-02f, -1.24777488e-01f, -1.22710019e-02f, 6.10910468e-02f, -3.08141470e-01f, -3.02042644e-02f,
  -2.39200145e-01f, 2.24023595e-01f, 1.51955321e-01f, -9.93171111e-02f, -1.86439499e-01f, 1.31602108e-01f, -1.54312357e-01f, 2.79356055e-02f, 3.91926169e-01f, 1.86323076e-01f,
  -1.76354274e-01f, 3.82907689e-01f, 6.41508162e-01f, -1.07217968e+00f, -5.71902990e-01f, 5.66299140e-01f, 4.81698722e-01f, -3.89342815e-01f, -1.75830185e-01f, 5.65250516e-01f,
  -1.84831515e-01f, -4.27733034e-01f, 1.61503255e-01f, -9.11826044e-02f, -3.45760822e-01f, -1.40829189e-02f, 3.44026715e-01f, 3.41010280e-02f, -3.00154090e-01f, 6.20060503e-01f,
  2.08774507e-01f, -2.15362176e-01f, 6.56821057e-02f, 2.49215081e-01f, 2.97471613e-01f, -1.00857228e-01f, -1.56477705e-01f, 2.15203211e-01f, 1.34351417e-01f, -4.36369330e-02f,
  -6.81114614e-01f, -2.83370197e-01f, 3.82900357e-01f, -1.61783546e-01f, -2.86040962e-01f, 5.35490453e-01f, 7.66467750e-01f, -7.18735158e-01f, 1.44759715e-01f, 1.02668986e-01f,
  2.52234429e-01f, -8.50179613e-01f, -1.81642145e-01f, -4.42861348e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 4)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 4;
const float L3_fan_Bp_bar_data[] = {
  7.10705444e-02f, 3.85654658e-01f, 5.33031411e-02f, 4.41101789e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  -6.35295212e-01f, 3.89022112e-01f, 1.25086784e-01f, -8.15214097e-01f, -5.39679766e-01f, 6.95669234e-01f, 9.02140200e-01f, 6.05006158e-01f, -8.24607491e-01f, -4.97523993e-02f,
  -1.87931716e-01f, -2.43510352e-03f, 1.68790370e-01f, 7.51401544e-01f, -1.68213814e-01f, -2.88288027e-01f, 9.05477166e-01f, 6.79833889e-01f, -9.41996723e-02f, 1.17080891e+00f,
  -1.28298223e-01f, -4.79075432e-01f, 2.12603733e-01f, -1.07846951e+00f, 1.77919835e-01f, 3.61917331e-03f, -4.46820669e-02f, -5.10902882e-01f, 1.93543628e-01f, 9.77558792e-01f,
  -2.82344460e-01f, -1.66081831e-01f, 2.78857321e-01f, -2.15287715e-01f, -1.69708822e-02f, 6.73857570e-01f, 9.87813234e-01f, 8.09419870e-01f, -1.10330904e+00f, 6.12017095e-01f,
  1.50427365e+00f, 2.60721415e-01f, 4.27942008e-01f, -3.16224754e-01f, -1.98490649e-01f, -1.24524683e-01f, -1.24231450e-01f, -5.79683959e-01f, 6.88414514e-01f, -4.35866147e-01f,
  3.30320418e-01f, -2.33099937e-01f, 1.11833900e-01f, -6.38363510e-03f, 1.07865143e+00f, 4.28988457e-01f, 9.40669715e-01f, 1.03549635e+00f, -1.11364782e+00f, 5.88139355e-01f,
  1.67256370e-01f, -5.89292467e-01f, 3.87474358e-01f, -3.84185493e-01f, 1.12698600e-01f, -5.65876365e-01f, -1.02361655e+00f, -7.68610179e-01f, -8.75444174e-01f, 7.03798890e-01f,
  1.26485503e+00f, 3.03456128e-01f, 7.83576429e-01f, 4.13825691e-01f, -5.90513408e-01f, 8.80223751e-01f, -7.12996274e-02f, 3.64302516e-01f, -3.46138299e-01f, -1.18428789e-01f,
  8.50595653e-01f, 1.62143677e-01f, -4.73255455e-01f, 1.32368624e-01f, 3.17560524e-01f, -7.27959797e-02f, -2.18364924e-01f, 1.06804740e+00f, -4.50315595e-01f, 8.97256851e-01f,
  -5.39460719e-01f, -1.08415198e+00f, -2.33813763e-01f, 7.19407737e-01f, -3.84385377e-01f, -3.16686869e-01f, -4.37079936e-01f, -8.89355782e-03f, 2.33470082e-01f, 9.31461096e-01f,
  -5.81335843e-01f, 4.56400327e-02f, -7.71044016e-01f, 4.09201920e-01f, -7.47418702e-01f, -5.31181991e-01f, 2.77957678e-01f, 7.11195230e-01f, -1.94870919e-01f, -1.20239429e-01f,
  3.96800309e-01f, 9.97555673e-01f, -6.69593692e-01f, -3.44245285e-01f, -4.43129718e-01f, -4.64863390e-01f, -5.73274612e-01f, -1.38927057e-01f, 4.95915473e-01f, -1.08925033e+00f,
  -8.53065729e-01f, -4.67413478e-02f, 2.79969841e-01f, -5.46695530e-01f, -4.35060039e-02f, -3.16735774e-01f, 2.53304958e-01f, 8.93435121e-01f, -1.12784791e+00f, 5.27308658e-02f,
  1.00249493e+00f, -9.94549453e-01f, 8.83749604e-01f, -7.12313056e-01f, 5.18087208e-01f, -8.11681449e-01f, 2.49930620e-01f, -7.64371991e-01f, 2.50863850e-01f, -1.05327792e-01f,
  -2.57963687e-01f, -9.38899145e-02f, -5.34632467e-02f, -3.70691061e-01f, 1.13653171e+00f, -3.85573924e-01f, 1.41015518e+00f, 7.26859987e-01f, 6.50086522e-01f, -5.45055680e-02f,
  -3.52368355e-01f, 1.06123008e-01f, -1.54477775e-01f, 3.54918480e-01f, 5.77977479e-01f, 6.09722316e-01f, -3.04028746e-02f, -6.28678501e-01f, 1.90063804e-01f, 4.09457505e-01f,
  -1.76507294e-01f, 5.36131978e-01f, -1.14652491e+00f, -1.60209790e-01f, -5.28972626e-01f, -1.20570898e+00f, -1.06419063e+00f, -5.21409631e-01f, 6.77224100e-01f, -7.70767152e-01f,
  -6.05147719e-01f, 1.72947451e-01f, 1.44204527e-01f, -2.24723086e-01f, -6.46710247e-02f, -3.86703879e-01f, -6.62703276e-01f, 7.77754784e-01f, 4.31576759e-01f, -4.34914798e-01f,
  -3.00250649e-01f, 9.45849597e-01f, -6.08748674e-01f, 1.60811633e-01f, -1.03314841e+00f, -1.21965539e+00f, 9.02225137e-01f, -3.50002855e-01f, 2.70703107e-01f, -5.65710843e-01f,
  1.25292823e-01f, -7.14512691e-02f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -4.70734358e-01f, -9.64709818e-02f, 3.45018893e-01f, 3.61552209e-01f, -2.15566177e-02f, -1.81230471e-01f, -4.31454599e-01f, -2.83405215e-01f, 9.24205184e-02f, 1.90598533e-01f,
  1.96425989e-01f, 1.70493692e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    