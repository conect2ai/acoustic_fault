/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -9.90680084e-02f, 1.11602388e-01f, 1.58281609e-01f, 2.21098647e-01f, 6.68689236e-02f, -2.87774861e-01f, -3.84490103e-01f, -2.03067407e-01f, 1.06121056e-01f, -3.16065140e-02f,
  -5.08341705e-03f, 6.10210486e-02f, -6.67111352e-02f, 4.89634648e-02f, -1.93405330e-01f, -8.49781260e-02f, 1.10269114e-02f, 4.40572537e-02f, -8.32644254e-02f, -4.45455946e-02f,
  6.07447810e-02f, 5.11593446e-02f, 1.93537995e-01f, 2.13912338e-01f, 3.38880122e-01f, 5.55467978e-03f, 1.68806985e-01f, 2.12557465e-01f, 1.54064804e-01f, 3.13228548e-01f,
  6.81610629e-02f, 1.77467600e-01f, -9.87903997e-02f, 4.74815555e-02f, 4.52977866e-02f, -9.36048978e-04f, 2.67022941e-02f, 1.31396249e-01f, 9.79944170e-02f, 3.57501954e-02f,
  1.27104566e-01f, 8.42991248e-02f, 1.89287979e-02f, 6.33085668e-02f, -1.45168267e-02f, 4.38364930e-02f, 1.24597751e-01f, 2.32582185e-02f, 6.79908544e-02f, 3.27214673e-02f,
  4.24294434e-02f, -2.91737239e-03f, -1.09984219e-01f, -9.31214616e-02f, 1.00798868e-01f, 3.26428027e-03f, 7.85972476e-02f, 1.28262401e-01f, -9.08753797e-02f, 3.31339762e-02f,
  1.34895802e-01f, -5.57905212e-02f, -1.08377203e-01f, 6.35827845e-03f, -1.50976017e-01f, -4.59542647e-02f, 2.11553182e-02f, -5.82628027e-02f, -7.87008926e-02f, -8.57067034e-02f,
  1.41102429e-02f, -1.16095699e-01f, -4.46256176e-02f, -4.93488237e-02f, 4.18577949e-03f, -1.24009691e-01f, 2.43411753e-02f, -5.46208769e-02f, -6.63142279e-02f, -7.44442195e-02f,
  -1.30783424e-01f, -7.04224110e-02f, -2.79990025e-02f, -5.38681261e-02f, -9.52808484e-02f, -5.93654774e-02f, -6.47745505e-02f, -1.51503026e-01f, -1.44514199e-02f, -7.90034458e-02f,
  -1.66569754e-01f, -1.36743441e-01f, -1.34136975e-02f, -6.38957024e-02f, 1.19560054e-02f, 9.18394849e-02f, 5.79184666e-02f, 3.16157751e-02f, 7.89952290e-04f, 3.25518698e-02f,
  1.21383425e-02f, -1.20045459e-02f, 5.52662238e-02f, 6.44233227e-02f, -6.91580921e-02f, 9.59543046e-03f, 5.36170613e-04f, -5.37094753e-03f, -4.41229455e-02f, 1.49446532e-01f,
  3.18776704e-02f, -1.63506091e-01f, -2.05975026e-01f, -1.05017111e-01f, -8.04112554e-02f, -2.09653988e-01f, -1.46878973e-01f, -1.23005062e-01f, -1.40475988e-01f, -9.78484228e-02f,
  4.03987288e-01f, 2.05479026e-01f, 2.33857691e-01f, 2.90580034e-01f, 1.94834918e-01f, 1.14921471e-02f, 1.07393160e-01f, -4.88543622e-02f, 6.42414913e-02f, 2.92237759e-01f,
  2.01554205e-02f, -3.63001749e-02f, 2.40452271e-02f, 3.73225100e-02f, -1.33364266e-02f, 3.29515070e-01f, 2.98233390e-01f, 1.11431167e-01f, -9.64557603e-02f, -4.12320606e-02f,
  1.01469040e-01f, 2.33490363e-01f, 1.48102120e-01f, 1.25538573e-01f, 2.04256535e-01f, 6.75026551e-02f, 1.28800422e-01f, 2.18548045e-01f, 1.79572195e-01f, 2.26582974e-01f,
  2.94815212e-01f, 7.82943219e-02f, -1.51482120e-01f, -1.16272969e-02f, -1.08103923e-01f, -1.45851569e-02f, -7.67110512e-02f, -1.70764551e-01f, -3.26637588e-02f, -7.36961365e-02f,
  1.85892191e-02f, -1.04990799e-03f, -1.10525824e-01f, -6.67181313e-02f, -3.78451906e-02f, -3.07636186e-02f, 5.19500747e-02f, 3.01046576e-02f, 1.09581025e-02f, -4.29190360e-02f,
  6.23538755e-02f, 1.09530635e-01f, -4.92630675e-02f, -1.69750959e-01f, -5.61954305e-02f, -8.64561349e-02f, 7.21152918e-03f, -7.49872997e-02f, -7.24272132e-02f, 2.72868760e-02f,
  -5.02732117e-03f, 6.73972294e-02f, 9.94231254e-02f, 1.08350171e-02f, -3.36262621e-02f, -6.80891648e-02f, 8.48951116e-02f, 1.43095218e-02f, -3.28990556e-02f, -9.37801078e-02f,
  -3.19948653e-03f, -2.79894546e-02f, 6.74952716e-02f, -1.22882589e-03f, -4.54803417e-03f, 2.87335850e-02f, -8.84628370e-02f, 7.98894241e-02f, -5.89031577e-02f, -1.25178978e-01f,
  2.43305080e-02f, -5.51503152e-02f, 2.53718030e-02f, -1.13694677e-02f, 5.86013719e-02f, 7.64577761e-02f, 2.72889920e-02f, -4.86364104e-02f, 3.28792818e-03f, 9.22193974e-02f,
  -1.04084015e-01f, -2.69621581e-01f, 3.64219360e-02f, -1.05345383e-01f, 4.26785424e-02f, -8.98608640e-02f, -5.61012141e-02f, -2.68048234e-02f, -1.14323519e-01f, 4.18038592e-02f,
  -1.54605672e-01f, 8.11219402e-03f, -9.26332623e-02f, -3.74320708e-02f, -7.42644966e-02f, -8.94839466e-02f, 6.16790541e-02f, 3.46507356e-02f, -1.71921238e-01f, 4.77194265e-02f,
  -2.79008113e-02f, -1.37565643e-01f, -6.89459126e-03f, -8.00047144e-02f, -4.32245247e-02f, -2.11855352e-01f, -1.47596091e-01f, -1.78794414e-01f, -7.76289850e-02f, 3.31562795e-02f,
  -3.98506075e-01f, -1.26775308e-02f, -2.09493905e-01f, 6.06017374e-02f, 3.10156256e-01f, 2.29152188e-01f, 3.97570372e-01f, 3.07807386e-01f, 1.05725944e-01f, -2.50562020e-02f,
  -1.38863683e-01f, -9.81291756e-02f, -6.12390153e-02f, -1.62220411e-02f, 2.00473494e-03f, 1.45921811e-01f, -8.21615309e-02f, -2.16551051e-01f, 8.43933821e-02f, 3.60498011e-01f,
  3.21007371e-01f, 2.03308955e-01f, -6.51144981e-02f, 1.18702851e-01f, 1.45973310e-01f, 6.41158968e-02f, -8.95238370e-02f, -4.30012941e-02f, -4.49100835e-03f, -1.93600982e-01f,
  -1.41131431e-01f, -1.13107286e-01f, 2.08375603e-01f, 2.96680033e-02f, -2.65774913e-02f, 3.10547817e-02f, 1.40966430e-01f, -1.80750750e-02f, 8.83087888e-02f, 2.88815573e-02f,
  -1.16882259e-02f, 8.33639950e-02f, 1.03230901e-01f, 1.33986324e-01f, 1.26623809e-01f, 1.12096794e-01f, 5.20059466e-02f, 2.78651882e-02f, 2.61082724e-02f, 1.97382011e-02f,
  1.54140741e-01f, -1.79480202e-02f, 2.35839970e-02f, 1.46628097e-01f, 1.20927030e-02f, 2.85685975e-02f, 2.66189091e-02f, 4.72061569e-04f, 9.09832194e-02f, 1.56336606e-01f,
  5.36938533e-02f, -1.97031751e-01f, -1.09930553e-01f, -1.06910624e-01f, -1.56555071e-01f, -1.46208912e-01f, -2.11647213e-01f, -1.23640954e-01f, -1.91525504e-01f, -6.80541173e-02f,
  -1.80582941e-01f, -1.72005266e-01f, -1.12552188e-01f, -1.32705599e-01f, -2.03268349e-01f, -2.19636053e-01f, -1.50471449e-01f, -1.42716736e-01f, -1.93067014e-01f, -1.46062359e-01f,
  -2.06083074e-01f, -1.90116212e-01f, -1.53159410e-01f, -1.65157244e-01f, -2.04590097e-01f, -2.09602132e-01f, -1.97319642e-01f, -1.13197729e-01f, -1.71582013e-01f, -1.65215924e-01f,
  2.88044393e-01f, -1.69312194e-01f, 5.50939329e-02f, 1.04505733e-01f, 1.05639972e-01f, 2.10873913e-02f, -3.34962904e-02f, 3.97354700e-02f, 7.24083334e-02f, 5.15414290e-02f,
  9.37009379e-02f, 3.35731544e-02f, 1.77904889e-02f, 5.65939695e-02f, 1.42871499e-01f, 1.18653044e-01f, 1.11239627e-01f, -4.57173586e-03f, 2.78414059e-02f, 1.28885806e-01f,
  8.34118947e-02f, 1.40839696e-01f, 1.07889898e-01f, 1.85347185e-01f, 1.89310953e-01f, 1.34012341e-01f, 1.07592255e-01f, 1.40123606e-01f, 1.58633560e-01f, 3.67547393e-01f,
  -6.48682892e-01f, 2.38080427e-01f, 3.49143241e-03f, -6.89869821e-02f, -5.08424193e-02f, -3.97840217e-02f, 1.76591754e-01f, 8.23280960e-02f, 3.69593152e-03f, 1.86696127e-01f,
  -6.73196232e-03f, -1.18705340e-01f, -8.18483382e-02f, 4.61546853e-02f, -6.52536452e-02f, 3.09974611e-01f, 1.30958676e-01f, -2.19975784e-02f, -6.40532896e-02f, 2.56029535e-02f,
  2.19872400e-01f, 4.01650881e-03f, -5.47704548e-02f, 6.03073463e-02f, 2.68153071e-01f, 1.51346496e-03f, 1.57563895e-01f, 4.48301323e-02f, 2.63908625e-01f, 3.67877364e-01f,
  5.31033985e-02f, -2.44805738e-02f, 4.80422303e-02f, 7.48890340e-02f, 1.69632614e-01f, 9.92842764e-02f, 1.40084550e-01f, 1.16617702e-01f, 1.56279832e-01f, 1.95250556e-01f,
  6.15702868e-02f, 6.95319474e-02f, 9.27685797e-02f, 2.02531844e-01f, 1.05701089e-01f, 6.34673834e-02f, 1.03505053e-01f, 1.02530599e-01f, 1.06559902e-01f, 1.64951518e-01f,
  1.74667671e-01f, 1.24914490e-01f, -4.73151393e-02f, 1.47745222e-01f, 2.06215173e-01f, -2.22416706e-02f, 8.46368670e-02f, 1.94611460e-01f, 1.12068325e-01f, 2.06093669e-01f,
  1.31860329e-02f, -1.33371994e-01f, -3.20752300e-02f, -3.47138159e-02f, -1.45071531e-02f, -3.83095369e-02f, 4.34358139e-03f, 7.19420314e-02f, 5.58255985e-02f, -8.67396072e-02f,
  -3.24462615e-02f, -8.68787616e-02f, -1.95974130e-02f, -7.76846781e-02f, 2.73928791e-02f, -2.60168593e-02f, 4.63978387e-03f, -2.35589836e-02f, -4.09574807e-03f, -7.25196898e-02f,
  1.24762282e-02f, -3.61672230e-02f, 1.88027024e-02f, 5.39384112e-02f, -2.08169110e-02f, 5.78775816e-03f, -1.59892328e-02f, -6.85088113e-02f, -6.75820857e-02f, -3.30413249e-03f,
  -1.78684533e-01f, -9.83708948e-02f, -1.69790592e-02f, 1.14539452e-01f, -3.78084648e-03f, 1.33243725e-01f, 6.61320910e-02f, 1.42892748e-01f, 3.33053782e-03f, 7.42707103e-02f,
  1.08217761e-01f, 1.36556122e-02f, 2.75907256e-02f, 1.45938173e-01f, 9.18373093e-02f, 1.62151411e-01f, -6.39017159e-03f, 5.87633476e-02f, 1.42660365e-01f, 1.27757892e-01f,
  2.29711309e-01f, -4.26078923e-02f, -1.42692298e-01f, 2.80755777e-02f, 1.08117685e-01f, -1.03639521e-01f, 4.28205729e-02f, -1.81897730e-02f, -3.42810936e-02f, 1.12970792e-01f,
  6.72990382e-02f, -2.92596389e-02f, -2.80589908e-01f, 1.28361642e-01f, 9.78669003e-02f, -1.07820056e-01f, -3.19722682e-01f, -2.49639764e-01f, 2.11681858e-01f, 6.55857176e-02f,
  2.90531516e-01f, 5.10453045e-01f, 3.67251366e-01f, 2.46826693e-01f, -1.03693083e-01f, -1.18166350e-01f, -1.28251836e-01f, -1.48123190e-01f, -1.41394094e-01f, -4.68023345e-02f,
  -8.15294776e-03f, -1.50360003e-01f, -2.07470462e-01f, 7.17458548e-03f, 1.17924124e-01f, 2.16331795e-01f, -2.17765182e-01f, 2.83674197e-03f, 4.52162791e-03f, 2.36912102e-01f,
  -4.37271334e-02f, -1.00923562e-03f, 6.53937012e-02f, 3.18399101e-01f, 8.29825476e-02f, 1.50347784e-01f, 1.00785032e-01f, 3.16233635e-02f, 1.11583896e-01f, 5.28429747e-02f,
  2.31488615e-01f, 1.68928742e-01f, 2.35415116e-01f, 6.89245760e-02f, 7.98237622e-02f, 2.52608880e-02f, 1.79816578e-02f, -8.92315432e-02f, -7.91560393e-03f, -1.08347815e-02f,
  2.23402143e-01f, 1.30236164e-01f, -3.55269834e-02f, -4.55213338e-02f, 2.44859029e-02f, 2.54117936e-01f, 6.04201928e-02f, 5.68108261e-02f, 1.45958085e-02f, -3.99363376e-02f,
  1.65509023e-02f, 1.18786320e-02f, -5.96261658e-02f, -1.77754015e-01f, -5.51806465e-02f, 1.49778845e-02f, -6.17324524e-02f, -6.19866848e-02f, -8.41638297e-02f, -1.40393466e-01f,
  -3.88115086e-03f, -8.29706192e-02f, -8.06472525e-02f, -5.61636761e-02f, -3.79493237e-02f, -2.76256464e-02f, -1.33679926e-01f, -8.56811330e-02f, -6.19630292e-02f, -7.57459700e-02f,
  2.51522604e-02f, -3.35182250e-02f, -6.39266893e-02f, -1.25246540e-01f, -3.02435253e-02f, -6.55977055e-02f, -9.74607468e-02f, -8.45897663e-03f, -3.78493965e-02f, -8.82051960e-02f,
  -4.08811085e-02f, 3.56820151e-02f, 1.57726780e-01f, 8.23001713e-02f, 8.45611468e-02f, 3.26096676e-02f, 3.72107849e-02f, 7.93938264e-02f, 2.34603673e-01f, 1.74820125e-02f,
  9.66085494e-02f, 4.58675027e-02f, 2.70700902e-02f, 2.76441015e-02f, -2.73426380e-02f, 1.07357435e-01f, -1.24727264e-02f, 3.69395576e-02f, 4.81382310e-02f, 7.87660852e-02f,
  -2.30011297e-03f, -7.68991653e-03f, 2.45449524e-02f, 1.96680576e-02f, 4.55975123e-02f, 1.32989645e-01f, -8.86380300e-02f, -3.05262185e-03f, 8.01275074e-02f, -2.19942912e-01f,
  7.46767581e-01f, 3.98561835e-01f, -5.01070730e-03f, 2.61413634e-01f, 2.41443008e-01f, 1.22096902e-02f, 8.12522471e-02f, -6.60237074e-02f, 2.08632618e-01f, 2.22589195e-01f,
  1.64874271e-02f, -1.32081928e-02f, -6.93162754e-02f, -1.70214146e-01f, -3.10964197e-01f, -1.94054586e-03f, 4.52870540e-02f, -3.04289144e-02f, -2.77952462e-01f, -6.86567724e-02f,
  1.42894924e-01f, 1.94294140e-01f, 9.80524197e-02f, -4.83491234e-02f, 1.95542946e-01f, -3.05478601e-03f, 1.24183401e-01f, 7.83023536e-02f, -6.70581162e-02f, 3.44554663e-01f,
  -4.01157625e-02f, 2.82674223e-01f, -5.63946888e-02f, 1.31180417e-02f, -6.68259934e-02f, 6.87928032e-03f, -6.67211935e-02f, -4.93997969e-02f, 6.71074837e-02f, 1.04199417e-01f,
  5.08648604e-02f, -2.71984264e-02f, 5.32223955e-02f, -4.60318960e-02f, 2.79129017e-02f, 4.64265682e-02f, -8.49147961e-02f, -6.02431633e-02f, -9.92271453e-02f, -1.04962505e-01f,
  -2.32165717e-02f, 1.67149976e-01f, 1.80617925e-02f, -3.20957974e-02f, -5.41003868e-02f, -1.01883644e-02f, 6.64040223e-02f, -1.48278615e-02f, 1.45160137e-02f, 6.70557842e-02f,
  3.53683531e-02f, -1.36754528e-01f, 5.08817881e-02f, 2.71887593e-02f, -6.17422117e-03f, 5.23477346e-02f, 8.60806555e-02f, 3.90639156e-02f, 1.95854306e-02f, -2.41270941e-02f,
  2.30204035e-02f, -4.04760428e-02f, -1.18935527e-02f, -9.92752239e-03f, -8.68468508e-02f, 3.12891640e-02f, 6.54030293e-02f, -8.42778683e-02f, 5.33757149e-04f, 1.04219634e-02f,
  -1.03675993e-02f, 3.98882776e-02f, 5.68588972e-02f, -1.18995324e-01f, 4.86283470e-03f, -9.20655355e-02f, 2.22677682e-02f, -5.88761866e-02f, 6.52009994e-02f, 8.97325948e-02f,
  -4.36169431e-02f, -1.16758130e-01f, 1.78512990e-01f, -6.70067072e-02f, 7.13884383e-02f, -4.47175130e-02f, 1.17322959e-01f, -3.48887965e-02f, -1.04478551e-02f, 6.36186153e-02f,
  9.02817920e-02f, -2.85777654e-02f, -1.09711541e-02f, 2.39425600e-02f, -1.77445430e-02f, -2.80486513e-02f, 2.02436559e-03f, 2.92713158e-02f, -8.66906345e-02f, -5.10118194e-02f,
  -2.07540076e-02f, 1.37185082e-01f, 1.10281900e-01f, -5.28774690e-03f, 1.03934489e-01f, 1.27271235e-01f, -7.07360581e-02f, 6.86602220e-02f, -4.24682982e-02f, 7.10922927e-02f,
  -5.85164189e-01f, 3.17542940e-01f, 2.54427940e-01f, -2.14507252e-01f, -1.32080868e-01f, 1.80225987e-02f, 3.75323266e-01f, -3.37343954e-04f, -1.21350244e-01f, 7.31218085e-02f,
  -2.21288100e-01f, -2.37161621e-01f, -1.07996359e-01f, 4.02195845e-03f, 1.49727330e-01f, 3.24563980e-01f, 2.98552990e-01f, 1.61288321e-01f, -9.68414694e-02f, -1.44718841e-01f,
  3.30616895e-04f, -9.43762138e-02f, -7.07190111e-02f, 3.93946059e-02f, 5.48708662e-02f, -1.39066637e-01f, 2.15254292e-01f, 2.88495198e-02f, 7.07267374e-02f, 3.33430171e-01f,
  -1.31078154e-01f, -1.07591316e-01f, -6.69272840e-02f, -1.21660255e-01f, 1.56768737e-03f, 2.61309207e-04f, -7.55294636e-02f, 6.86722901e-03f, -4.27065901e-02f, 6.65949136e-02f,
  -1.09487504e-01f, -4.16346379e-02f, -1.38741042e-02f, -5.57299219e-02f, 4.53364961e-02f, 4.97203693e-02f, 3.74660119e-02f, 2.22370699e-02f, 4.19859868e-03f, 7.06869513e-02f,
  1.26300499e-01f, -8.79945606e-02f, -9.57022682e-02f, -3.63492183e-02f, 4.76942882e-02f, -1.18246906e-01f, 2.75437795e-02f, -5.51206544e-02f, 2.44479766e-03f, 8.92302468e-02f,
  -6.38395175e-02f, -9.88239143e-03f, 4.65361364e-02f, 2.00524386e-02f, 1.60644781e-02f, -6.95345737e-03f, 5.68096228e-02f, -2.31242497e-02f, 7.39159994e-03f, 2.76320172e-03f,
  -2.16562785e-02f, -4.93919663e-03f, 5.42053662e-04f, 1.05298355e-01f, -2.41090413e-02f, -5.43884896e-02f, 2.39188783e-02f, 7.47081116e-02f, 3.41423117e-02f, 3.44943032e-02f,
  1.37700113e-02f, -9.11903381e-02f, -1.77947637e-02f, 7.87133798e-02f, 7.52315521e-02f, 6.54525831e-02f, -5.56218587e-02f, 2.33136155e-02f, 5.53667033e-03f, -6.50235265e-03f,
  -3.50949377e-01f, 1.95889566e-02f, 1.22731356e-02f, -1.78255417e-04f, -2.08745804e-02f, 8.86575654e-02f, -1.76842008e-02f, 1.18083850e-01f, -7.98695013e-02f, 3.80370095e-02f,
  -7.13250190e-02f, 7.13756830e-02f, 5.78202903e-02f, 9.85406935e-02f, -1.36949182e-01f, -1.18573857e-02f, 7.30616227e-02f, -7.37031400e-02f, 4.99075763e-02f, -2.94645242e-02f,
  1.09391727e-01f, -2.78609153e-03f, -1.70112342e-01f, 4.13260609e-02f, -1.41636357e-01f, -1.55739069e-01f, -4.21133377e-02f, -8.37768987e-03f, -1.36019140e-01f, 1.33774290e-03f,
  -4.73757535e-02f, -2.79344320e-02f, 1.48342997e-01f, 1.14675529e-01f, -6.19181357e-02f, 5.62092252e-02f, -2.67373789e-02f, -7.50374049e-02f, 6.91055581e-02f, 1.46179244e-01f,
  -2.66407132e-01f, -1.33979842e-01f, -2.73127444e-02f, -3.89192663e-02f, -1.78091809e-01f, 2.37410948e-01f, 2.13359296e-01f, 5.82523867e-02f, -5.07116914e-02f, 2.33592354e-02f,
  -1.15549013e-01f, -2.20666323e-02f, 3.81993465e-02f, -2.85789948e-02f, 2.94821352e-01f, 1.59857497e-01f, 1.56700373e-01f, 1.95100561e-01f, 2.51208544e-01f, 4.82357413e-01f,
  2.20910981e-01f, -1.01135291e-01f, -1.53890684e-01f, -2.44196296e-01f, 8.59573856e-03f, -6.45419117e-03f, 1.77833531e-02f, 5.26927831e-03f, -7.84338266e-02f, 5.18020317e-02f,
  -3.58925238e-02f, -1.17654085e-01f, -3.38887908e-02f, 3.35014462e-02f, 4.70604300e-02f, -8.44370723e-02f, -4.93155569e-02f, 6.60444573e-02f, 3.64186130e-02f, 2.77362415e-03f,
  -4.61097285e-02f, 4.48365919e-02f, 4.37530922e-03f, 4.22460400e-03f, 2.83179060e-02f, -2.94926427e-02f, 1.47039726e-01f, 1.40106767e-01f, 1.16080157e-01f, 2.52184540e-01f,
  -2.32792012e-02f, 1.03516974e-01f, 3.57266725e-03f, 2.95323078e-02f, 1.27778620e-01f, 1.05401300e-01f, 9.17725638e-03f, 3.70806530e-02f, 4.26384015e-03f, 8.00696388e-02f,
  -4.53805104e-02f, 4.19651382e-02f, 4.73961309e-02f, 9.66301840e-03f, 9.23781097e-02f, 1.04046287e-02f, 8.09617341e-03f, 8.47465992e-02f, 6.71459287e-02f, 3.01852766e-02f,
  -6.42433413e-04f, 1.24268942e-01f, 5.11008799e-02f, 9.52425599e-02f, -2.73755472e-02f, 5.46160154e-02f, -2.55352594e-02f, -1.12423770e-01f, -8.99955928e-02f, 1.70681216e-02f,
  -9.53975916e-02f, -3.37689787e-01f, 7.08968788e-02f, -4.55996692e-02f, -3.13038751e-02f, 2.63825003e-02f, -7.96960145e-02f, -2.91430335e-02f, -3.50945704e-02f, 2.05118135e-02f,
  -7.61723518e-02f, -3.33353020e-02f, -4.17328514e-02f, 8.36539082e-03f, -2.18486506e-02f, -1.27770249e-02f, -5.76397665e-02f, 2.33474914e-02f, -9.19490531e-02f, 1.66030619e-02f,
  2.48000231e-02f, -9.11589339e-02f, 3.56198326e-02f, -4.16465066e-02f, 2.69209892e-02f, -1.03756636e-01f, 1.06773183e-01f, 2.02424675e-01f, -8.46478194e-02f, 2.16784641e-01f,
  -6.54731631e-01f, 3.83809090e-01f, 4.98980016e-01f, -4.56666052e-01f, -4.38589305e-02f, 2.86211491e-01f, 3.76431406e-01f, 7.63916224e-02f, -2.84344018e-01f, 4.25579324e-02f,
  -5.48815802e-02f, -4.25787687e-01f, -2.94336200e-01f, -1.12880103e-01f, -1.12959323e-02f, 3.13715875e-01f, 2.49363557e-01f, 2.95399390e-02f, -2.18991831e-01f, -1.64441749e-01f,
  -8.45386237e-02f, -2.03290820e-01f, -1.76532120e-01f, -3.23581509e-03f, 5.75267561e-02f, -2.16047764e-01f, 2.42229626e-01f, 2.11923733e-01f, 3.04878354e-01f, 5.46488911e-02f,
  1.44180521e-01f, 1.62936598e-01f, -5.55374846e-02f, -2.50435859e-01f, -3.27051692e-02f, 6.36070268e-03f, -3.32546495e-02f, -1.81104969e-02f, -9.36512202e-02f, -3.25082242e-02f,
  -7.44837150e-02f, -4.79182154e-02f, -1.14886770e-02f, -4.23675552e-02f, 9.27363150e-03f, -4.92520221e-02f, -9.40242317e-03f, 7.19536841e-02f, -1.05863968e-02f, 9.19383541e-02f,
  -8.50201845e-02f, -1.30002236e-03f, 1.30065739e-01f, 7.70903826e-02f, 8.33083410e-03f, -1.87698066e-01f, 1.65897593e-01f, 1.12922221e-01f, 5.24788834e-02f, -6.36659786e-02f,
  -1.55861944e-01f, -5.26290201e-02f, 4.12992574e-02f, 5.86226918e-02f, 2.03510039e-02f, 3.10967043e-02f, 2.29873210e-02f, 4.02394868e-02f, -4.49862704e-02f, 2.40826737e-02f,
  7.00630024e-02f, 1.26414914e-02f, -1.23101808e-02f, 2.46917270e-03f, -3.46586891e-02f, 8.02226830e-03f, 4.62014647e-03f, 4.75694835e-02f, 8.28298554e-02f, 4.18280996e-02f,
  2.43672654e-02f, 1.13713212e-01f, 3.61495372e-03f, 2.29379591e-02f, 8.70689675e-02f, -1.10010542e-02f, -4.39314134e-02f, -9.88159887e-03f, -3.89496125e-02f, -2.04510652e-04f,
  -1.91067189e-01f, 1.36505559e-01f, -6.66633770e-02f, 3.28741744e-02f, 5.76627366e-02f, -9.57839191e-02f, 3.41904238e-02f, -1.46822734e-02f, -4.99301706e-04f, 2.47869398e-02f,
  -1.16916699e-02f, -3.96924727e-02f, 5.15467860e-03f, -8.38614628e-02f, -1.43709630e-01f, -1.03797667e-01f, -7.77875036e-02f, -1.44505516e-01f, -2.74873320e-02f, -7.45779052e-02f,
  -9.47089046e-02f, -1.46486014e-01f, -1.80343986e-01f, -9.02603939e-02f, 3.40177231e-02f, -1.82997823e-01f, -2.60914993e-02f, -5.57079576e-02f, -6.63278177e-02f, -1.15594603e-01f,
  5.44230580e-01f, 2.01214492e-01f, 2.82835603e-01f, 2.89717257e-01f, 1.02376379e-02f, -1.91089645e-01f, -2.93822259e-01f, -2.16322914e-01f, -3.97255197e-02f, 4.09036204e-02f,
  4.72626723e-02f, -8.81751701e-02f, 1.09627880e-01f, -1.09037548e-01f, -2.18053058e-01f, -7.67520294e-02f, 1.91657189e-02f, 4.98386808e-02f, -3.48869145e-01f, -4.06611502e-01f,
  -1.75081864e-01f, 5.93849495e-02f, 5.04807085e-02f, 7.18512386e-02f, 2.31275544e-01f, 1.77275389e-02f, 2.42652133e-01f, 3.10899824e-01f, 1.22478930e-02f, 2.39598185e-01f,
  4.82954532e-02f, 2.76972651e-01f, -2.26726457e-01f, -5.03924442e-03f, 8.65068845e-03f, -1.42916348e-02f, -5.30003347e-02f, 1.62673853e-02f, -2.05711368e-02f, -4.35475633e-02f,
  4.57061864e-02f, -5.66916764e-02f, 1.18628033e-01f, -1.32677838e-01f, 2.97858007e-02f, -9.00985077e-02f, -5.70725650e-02f, -6.91236183e-02f, -1.35421872e-01f, 1.03413146e-02f,
  -8.31021369e-02f, 5.17584011e-02f, 8.80388543e-02f, -2.04566956e-01f, 2.66843196e-02f, -4.06669043e-02f, -7.00923726e-02f, 5.56387827e-02f, -1.06160678e-01f, 2.50259787e-02f,
  -1.58552215e-01f, 8.67711902e-02f, -6.46679837e-04f, 6.35555834e-02f, -3.15868147e-02f, 1.11578628e-01f, 5.34534752e-02f, -4.96233478e-02f, -2.72649452e-02f, 7.53770620e-02f,
  -3.33136395e-02f, 4.05286662e-02f, 1.19861029e-03f, 5.36579005e-02f, 5.63087799e-02f, 9.40645784e-02f, -1.07027106e-02f, -1.98628381e-02f, 1.08962633e-01f, 1.82584614e-01f,
  5.42382197e-03f, 1.26111925e-01f, 7.52561092e-02f, -2.38709897e-02f, 5.15341349e-02f, -7.98892137e-03f, 2.30239984e-02f, -4.35261168e-02f, 3.10296565e-02f, 1.36270389e-01f,
  -2.56104916e-01f, -8.65011439e-02f, -4.22686432e-03f, -9.94824842e-02f, 6.59035742e-02f, -7.35478550e-02f, 5.55496477e-02f, -1.07935160e-01f, 7.64526352e-02f, -8.53196383e-02f,
  -9.16983262e-02f, 4.65903468e-02f, 6.35968372e-02f, -6.51643723e-02f, -7.45534077e-02f, -1.23466231e-01f, -7.20496327e-02f, -1.27096638e-01f, -1.07772335e-01f, -1.16968364e-01f,
  -5.98239377e-02f, -2.63839751e-01f, -2.36111313e-01f, -2.01996416e-01f, -2.31503695e-02f, -1.52992442e-01f, -1.15466148e-01f, -1.73365876e-01f, -1.91990331e-01f, -1.82525456e-01f,
  4.28522319e-01f, 3.47980380e-01f, -1.52064845e-01f, 2.74265260e-01f, -9.23852026e-02f, -1.46071732e-01f, -1.26790464e-01f, -9.23200324e-02f, 1.07274882e-01f, 1.95336744e-01f,
  -1.07119329e-01f, -2.20502049e-01f, -2.88285464e-01f, -3.37097168e-01f, -3.14487308e-01f, 1.42781109e-01f, -7.00293342e-03f, -3.23422432e-01f, -4.57856059e-01f, -2.24280536e-01f,
  -6.16902560e-02f, 2.92131096e-01f, 1.95440575e-01f, -6.30337521e-02f, 1.21273965e-01f, -1.19089723e-01f, 2.19846696e-01f, 1.95442557e-01f, -8.46928284e-02f, 1.75409064e-01f,
  2.17494797e-02f, 3.26295704e-01f, -2.85094351e-01f, -8.13276693e-02f, 1.29585247e-02f, 3.14585790e-02f, -7.01439753e-02f, 1.48748951e-02f, 1.11654466e-02f, 4.21297960e-02f,
  -3.35519761e-02f, -3.74653079e-02f, -8.01544860e-02f, -2.41150092e-02f, 4.33328263e-02f, -7.18053430e-02f, 2.68082973e-02f, -5.53241707e-02f, -5.82534261e-02f, 2.24233586e-02f,
  -8.50522146e-02f, 1.17718652e-02f, 8.61527456e-04f, -4.73317020e-02f, -1.09966263e-01f, -1.33375674e-01f, -9.32260230e-03f, -6.15836196e-02f, -1.20881870e-01f, 2.68292457e-01f,
  -3.95876430e-02f, -3.03478241e-02f, -5.71919084e-02f, 5.37724048e-02f, 1.25517128e-02f, 3.36817279e-02f, -3.84191312e-02f, 3.03485356e-02f, -1.63115617e-02f, 6.20967485e-02f,
  -9.12306979e-02f, -5.89198386e-03f, -7.74322136e-04f, 1.13523051e-01f, -1.55002195e-02f, 1.40949991e-02f, -1.52185755e-02f, 4.77596261e-02f, 3.73697802e-02f, 5.27924113e-02f,
  -1.76424198e-02f, 2.97235185e-03f, 1.04572766e-01f, 1.13703702e-02f, -4.59189340e-02f, -5.14836237e-02f, 2.23995019e-02f, -2.42076926e-02f, -1.58061553e-02f, 1.01421438e-01f,
  1.61510631e-01f, -2.03848705e-01f, 4.60282750e-02f, -1.47892341e-01f, 2.07220670e-02f, -5.95969297e-02f, -1.38819795e-02f, -5.19640595e-02f, -4.74827550e-02f, -8.24914500e-02f,
  -9.57888886e-02f, -6.56196624e-02f, 1.60872824e-02f, -2.40128692e-02f, -1.08290754e-01f, -1.58336256e-02f, -2.01796014e-02f, -8.38942602e-02f, -1.35758802e-01f, -1.77607983e-02f,
  1.40314456e-02f, -6.36561885e-02f, -1.31641552e-01f, -1.73856631e-01f, -4.64230180e-02f, -2.64474958e-01f, -8.77107307e-02f, -1.28699362e-01f, -1.95205495e-01f, 1.76281959e-01f,
  2.39471406e-01f, -4.78675365e-01f, 2.00317562e-01f, -2.40202039e-01f, -8.50401446e-02f, 2.69686311e-01f, 3.37418504e-02f, 6.51404113e-02f, -1.36564136e-01f, -1.70241445e-01f,
  -1.41738474e-01f, -7.42782131e-02f, -8.27835202e-02f, 1.31145567e-01f, 2.25090653e-01f, -1.08866669e-01f, -1.22980706e-01f, 4.27325636e-01f, 4.63380009e-01f, 3.02976161e-01f,
  -1.40927434e-01f, -5.53106889e-02f, 2.46389836e-01f, 1.19004011e-01f, -3.27864766e-01f, -1.38269946e-01f, -1.79793805e-01f, -9.90124196e-02f, 1.60383526e-02f, -3.66667300e-01f,
  -9.19233486e-02f, 5.28197698e-02f, 2.35414177e-01f, 1.53309871e-02f, -6.92046359e-02f, 7.10929334e-02f, 1.80395495e-04f, -2.76542027e-02f, 2.55142665e-03f, -4.15486768e-02f,
  -1.84749831e-02f, 7.71092102e-02f, -5.22090048e-02f, -5.24215959e-03f, -2.67940294e-02f, 9.94896051e-03f, 2.52770167e-02f, 8.45957324e-02f, -2.15100311e-02f, 1.06146922e-02f,
  -9.48648304e-02f, 1.65563487e-02f, 3.48119326e-02f, 1.15097612e-01f, 1.67355105e-01f, 1.16888262e-01f, 5.79665527e-02f, 9.43555236e-02f, 2.93703556e-01f, -2.35811308e-01f,
  7.02810138e-02f, -1.02559410e-01f, 3.35699990e-02f, -9.52594280e-02f, -7.08981464e-03f, -5.72139136e-02f, -8.49035233e-02f, -5.83030097e-02f, -5.12268804e-02f, -1.21980757e-01f,
  -1.20298322e-02f, 2.47521829e-02f, 1.48643674e-02f, -4.99069132e-02f, -7.83319473e-02f, -1.97130088e-02f, 6.96965754e-02f, -4.30550538e-02f, 3.27764242e-03f, -7.50588924e-02f,
  4.72513363e-02f, 5.88238090e-02f, -6.70696869e-02f, 1.83853647e-03f, 3.57021354e-02f, 2.17425972e-02f, -2.95411441e-02f, 1.21568292e-02f, -6.53359145e-02f, 5.30097559e-02f,
  -3.20752829e-01f, 3.77348989e-01f, -1.86043233e-01f, 7.06218928e-02f, -1.11911334e-01f, 7.32461736e-03f, -3.34615493e-03f, -1.94678381e-02f, 8.64299200e-03f, 2.97760088e-02f,
  1.73958242e-01f, 1.18665889e-01f, -6.53181598e-02f, -3.12099587e-02f, 1.02694370e-01f, 4.38894629e-02f, -4.15883623e-02f, -8.28905962e-03f, 5.85314594e-02f, -1.18759610e-02f,
  -5.86634725e-02f, 3.15342937e-03f, 7.49988779e-02f, -7.70577490e-02f, 1.57520012e-03f, 1.44929126e-01f, 1.98935196e-02f, -4.78586145e-02f, 1.47814125e-01f, -1.67744711e-01f,
  -5.64697608e-02f, 3.15939814e-01f, -9.12996978e-02f, 1.24420747e-01f, -1.86852455e-01f, -3.78846318e-01f, -3.58029842e-01f, -1.45509675e-01f, 1.99699685e-01f, 2.32843816e-01f,
  6.55450597e-02f, 6.42498881e-02f, 3.02080244e-01f, 6.51565269e-02f, -5.63081764e-02f, 1.56641990e-01f, 1.13240726e-01f, -9.53467339e-02f, -5.25781691e-01f, -3.77491534e-01f,
  -1.05612122e-01f, -1.16409346e-01f, -1.79183736e-01f, -8.27896893e-02f, 2.47572333e-01f, 1.67379647e-01f, 1.85572147e-01f, 8.04649889e-02f, 4.39554118e-02f, 3.94879252e-01f,
  3.19923878e-01f, 1.48863330e-01f, -3.14595774e-02f, 7.84211904e-02f, 1.61011830e-01f, 7.10212067e-02f, 3.83200794e-02f, 1.15406074e-01f, 5.25298491e-02f, 9.00210664e-02f,
  1.47698402e-01f, 1.44131154e-01f, 1.45460188e-01f, 1.47265598e-01f, 1.06422082e-01f, 8.60423967e-02f, 1.26765698e-01f, 2.75611710e-02f, 6.24138080e-02f, 5.78715652e-02f,
  1.66166872e-01f, -2.36724783e-02f, -3.87305133e-02f, -1.53714474e-02f, 8.97960439e-02f, 1.39155626e-01f, -3.60505655e-03f, 1.04083218e-01f, -1.49114514e-02f, 1.97316334e-01f,
  2.83079781e-02f, 2.78777461e-02f, -2.83436272e-02f, 1.10539429e-01f, -6.33876771e-02f, 2.86472701e-02f, -2.18960214e-02f, 4.52351347e-02f, -2.34902669e-02f, 2.88596116e-02f,
  -8.98012612e-03f, 5.41955344e-02f, -5.69097027e-02f, 3.06143556e-02f, -1.67856067e-02f, 1.14255324e-02f, -3.18875127e-02f, -4.48916778e-02f, 1.34903891e-02f, 5.43513382e-03f,
  1.99258681e-02f, -9.38308686e-02f, 1.43846303e-01f, -4.77297269e-02f, -3.51744558e-04f, 3.85932736e-02f, -5.25662163e-03f, -2.51361541e-02f, -2.10643038e-02f, -4.77103032e-02f,
  2.16934234e-01f, -1.28281847e-01f, 2.69714326e-01f, 1.05537027e-01f, 1.00675158e-01f, 1.05442218e-01f, 1.34711593e-01f, 5.98022640e-02f, 2.14639381e-01f, 2.73655001e-02f,
  -2.06400845e-02f, 9.83851328e-02f, 1.88421056e-01f, 8.79090503e-02f, -9.76115316e-02f, 3.62334810e-02f, 1.53779343e-01f, 5.84007129e-02f, 2.06496660e-02f, 9.85931307e-02f,
  9.50507149e-02f, -6.00183308e-02f, -9.28641036e-02f, 1.21272489e-01f, 1.29420921e-01f, -5.15745860e-03f, 1.45848051e-01f, 1.26534775e-01f, -7.27199316e-02f, 1.61946997e-01f,
  -3.98914903e-01f, -2.59551257e-01f, 2.28880242e-01f, -1.64469823e-01f, 5.77717349e-02f, -9.41194966e-03f, -2.99404472e-01f, -2.49045774e-01f, -1.60683706e-01f, -7.30014592e-02f,
  -1.06754594e-01f, 1.61341161e-01f, 2.14186728e-01f, 1.06433354e-01f, -6.73748255e-02f, 3.26750055e-02f, 3.53583694e-01f, 1.53116167e-01f, -1.64006464e-02f, -7.99356923e-02f,
  2.40598776e-04f, -3.04415002e-02f, -1.74096107e-01f, -1.57866508e-01f, 1.55885592e-01f, 1.88806221e-01f, 4.03088555e-02f, -8.82799085e-03f, -1.56111950e-02f, 3.92233908e-01f,
  1.96636274e-01f, -3.46487761e-01f, 4.01542382e-03f, -1.08225234e-01f, -6.53898641e-02f, -3.44769731e-02f, -6.10973686e-02f, -1.31456703e-01f, -5.97098246e-02f, -6.14576079e-02f,
  -5.85768484e-02f, -8.75330493e-02f, 6.02794997e-02f, 3.38385068e-02f, -3.87977771e-02f, -9.46370661e-02f, -1.07476115e-01f, -1.08543523e-01f, -2.85127815e-02f, -1.08984150e-01f,
  1.35976728e-02f, 3.37281488e-02f, -1.02635674e-01f, -7.49322399e-02f, -2.36322358e-01f, -1.09868739e-02f, -2.72107393e-01f, -1.60058007e-01f, -1.96611598e-01f, -1.74528107e-01f,
  1.35993809e-01f, 1.82567552e-01f, -4.86844480e-02f, 1.66792702e-03f, -3.66975293e-02f, 4.69362549e-02f, 6.61729127e-02f, 7.05913380e-02f, 9.51937120e-03f, -2.05008648e-02f,
  -1.94289945e-02f, -4.32781577e-02f, -9.44745466e-02f, -8.19231570e-02f, 2.25554053e-02f, 3.52180041e-02f, 2.34883744e-02f, -1.22507654e-01f, -2.61738244e-02f, -5.53249754e-02f,
  -8.62302408e-02f, -2.27950737e-02f, 5.37797846e-02f, -7.26482421e-02f, -5.78162968e-02f, -3.44824186e-03f, 4.24757153e-02f, 2.79880092e-02f, 4.38141823e-02f, 1.80038856e-03f,
  -1.60728887e-01f, -1.86991408e-01f, 9.71277878e-02f, -6.28931224e-02f, 1.06707476e-01f, -1.40823096e-01f, 1.46659380e-02f, -9.37357470e-02f, 1.08788358e-02f, -9.14057642e-02f,
  -1.08676583e-01f, -4.62957751e-03f, -2.81590223e-02f, -1.55653758e-02f, -3.94222215e-02f, -2.66681984e-02f, -4.38178256e-02f, 1.22186810e-01f, -8.36693421e-02f, -1.38554871e-02f,
  5.55235380e-03f, -3.46665718e-02f, 6.61020428e-02f, 2.28897780e-02f, -1.92558058e-02f, 2.32448086e-01f, 1.04009815e-01f, -7.03624412e-02f, 1.73638016e-02f, -6.90688044e-02f,
  2.14661226e-01f, -6.36539829e-04f, 1.46764100e-01f, 3.53751145e-02f, -1.56941846e-01f, 2.15423808e-01f, 3.98377597e-01f, 1.25274435e-01f, -3.50690261e-02f, 2.58501787e-02f,
  -2.22633496e-01f, -2.84863591e-01f, -1.48990959e-01f, 6.06535887e-03f, 2.15583116e-01f, 3.39195549e-01f, 2.51066744e-01f, 2.97588855e-01f, 8.25858638e-02f, -2.67054774e-02f,
  -1.03693999e-01f, -2.58078784e-01f, -3.21118310e-02f, 8.40359554e-02f, -2.90994346e-01f, -1.43600747e-01f, -2.07065076e-01f, -2.37369671e-01f, 1.41123578e-01f, 4.92594615e-02f,
  -2.04880446e-01f, 1.29438460e-01f, 1.51153147e-01f, 9.42360386e-02f, -1.95687056e-01f, 1.51402742e-01f, 1.54922739e-01f, 1.09544657e-01f, -1.93349477e-02f, 6.95052966e-02f,
  -3.80816199e-02f, -8.07450560e-04f, 1.98761504e-02f, 9.52729140e-04f, -7.24876747e-02f, 1.36769032e-02f, -3.60648148e-02f, 8.43966752e-02f, 7.04512075e-02f, -1.40817910e-02f,
  -3.56145427e-02f, 6.82143569e-02f, -4.06515002e-02f, -2.04435941e-02f, 2.03067720e-01f, 2.60575060e-02f, 1.21877305e-02f, 1.09293327e-01f, 3.99260931e-02f, -5.53827733e-02f,
  -4.42210957e-03f, 6.07757783e-03f, -3.97503115e-02f, 3.09271030e-02f, -7.34898001e-02f, -3.12056504e-02f, 3.88047993e-02f, -4.68769595e-02f, 2.73931343e-02f, -1.90417424e-01f,
  5.80035523e-03f, -2.50621866e-02f, 5.55331446e-02f, 3.83713958e-03f, -1.21987924e-01f, 5.45476703e-03f, -2.33769212e-02f, -4.94843349e-02f, -3.98236290e-02f, 6.18286543e-02f,
  -7.61947930e-02f, 4.35129702e-02f, -7.86851719e-02f, 1.99993770e-03f, 4.82753254e-02f, 6.97366195e-03f, -9.31592193e-03f, -1.18707187e-01f, -1.12220883e-01f, -5.56628779e-02f,
  -3.40461016e-01f, 2.63672292e-01f, -1.74042936e-02f, 8.60070139e-02f, 3.95932272e-02f, 3.31629701e-02f, 2.20233854e-03f, 1.96823254e-02f, 1.80301964e-02f, 7.19944388e-02f,
  1.07055165e-01f, 1.15467541e-01f, -3.14557962e-02f, -4.31248024e-02f, 9.74544883e-02f, 3.31728868e-02f, -7.79902935e-02f, 7.68333748e-02f, 1.21908233e-01f, -2.71308306e-03f,
  -1.54298348e-02f, 7.07321912e-02f, 7.17056096e-02f, 1.17658950e-01f, -2.71100011e-02f, 6.33844584e-02f, -6.12711236e-02f, -4.50158902e-02f, 2.36478999e-01f, 1.19396769e-01f,
  -6.28878057e-01f, -1.22159116e-01f, 8.29264522e-02f, -3.14578205e-01f, 6.75538881e-03f, -8.90186206e-02f, 1.07836481e-02f, -3.14451128e-01f, -4.19403523e-01f, -1.59363404e-01f,
  -8.50031748e-02f, 1.18404448e-01f, 1.13401212e-01f, -3.81470704e-03f, 3.69393677e-02f, 1.95846036e-02f, 8.96712318e-02f, 7.53515214e-02f, 6.61620647e-02f, -3.67733724e-02f,
  6.92493320e-02f, -3.44723389e-02f, -2.08765030e-01f, -8.77163559e-02f, -1.14469960e-01f, 6.74087331e-02f, -1.57875910e-01f, -4.17604558e-02f, 9.34020281e-02f, 1.60455897e-01f,
  2.55167574e-01f, -2.81904310e-01f, 1.74465701e-02f, -1.20666705e-01f, 2.47023371e-03f, -1.08407401e-01f, -4.68041264e-02f, -1.92130595e-01f, -1.25351593e-01f, -1.08144663e-01f,
  -5.17874844e-02f, -1.46501929e-01f, -6.32067472e-02f, -1.37307793e-01f, -1.11803778e-01f, -8.69484916e-02f, -1.48330450e-01f, -1.30608633e-01f, -1.15208320e-01f, -1.32473618e-01f,
  2.97250859e-02f, 9.68637783e-03f, -1.47703990e-01f, -1.03403635e-01f, -1.14564769e-01f, 3.18093486e-02f, -1.85599744e-01f, -2.26410478e-01f, -1.60025835e-01f, -2.35275462e-01f,
  1.70609634e-02f, 3.14488187e-02f, 1.25298113e-01f, 4.99276370e-02f, 3.00127678e-02f, 1.36039227e-01f, 6.12974539e-02f, 1.14257805e-01f, 2.02785507e-01f, 8.46577287e-02f,
  8.28847140e-02f, 8.20200443e-02f, -1.95732061e-02f, -5.39434813e-02f, 1.23743385e-01f, 7.17619583e-02f, 1.00111477e-01f, 4.22281735e-02f, 1.27886683e-01f, 1.37424739e-02f,
  1.04325965e-01f, 1.09836325e-01f, 4.82287705e-02f, 1.45893678e-01f, 1.50894821e-01f, 1.01005442e-01f, 1.93904825e-02f, 1.83588877e-01f, -3.14465049e-03f, 2.73493864e-02f,
  -2.40627632e-01f, 4.38807644e-02f, -3.00797839e-02f, -1.47391006e-01f, -1.51030123e-01f, -1.82864293e-01f, -1.29329175e-01f, -9.45435539e-02f, -7.46046603e-02f, -8.30918550e-02f,
  -2.65688989e-02f, -1.72769666e-01f, -3.95959131e-02f, -9.80674773e-02f, -9.18314308e-02f, -1.44248828e-01f, -5.86848147e-02f, -6.13903031e-02f, -1.71125025e-01f, -2.10905924e-01f,
  -2.20604450e-01f, -8.54852498e-02f, -1.47513062e-01f, -1.01038806e-01f, -9.64133590e-02f, -1.02226391e-01f, -7.28853047e-02f, -7.06580877e-02f, -1.70195043e-01f, -2.37444684e-01f,
  -6.05904534e-02f, 4.88686591e-01f, -4.63043958e-01f, 2.64453173e-01f, 1.14913255e-01f, -1.43483728e-01f, 1.05993159e-01f, 6.96096942e-02f, 2.18607232e-01f, 8.98238122e-02f,
  2.29583517e-01f, 1.63078353e-01f, 6.03670813e-02f, 6.16392121e-02f, -1.62640244e-01f, -2.56211180e-02f, 5.00399917e-02f, -3.48767787e-01f, -2.69050986e-01f, 8.79476517e-02f,
  3.95859331e-01f, 2.11502343e-01f, -3.56286541e-02f, 3.26038450e-02f, 3.85047555e-01f, 2.03411669e-01f, 2.55676974e-02f, 2.02099681e-01f, 6.95349574e-02f, 4.49308276e-01f,
  -2.80729800e-01f, 6.69629499e-02f, -1.30014345e-01f, 1.18029989e-01f, 7.19669275e-03f, 2.67389137e-02f, 6.16135113e-02f, 5.79233170e-02f, -2.65712123e-02f, 9.22672078e-02f,
  1.29836738e-01f, 1.52257636e-01f, 8.82622600e-02f, 4.43941541e-02f, 1.30264968e-01f, -1.81288570e-02f, 1.12962246e-01f, -5.12702740e-04f, 1.45706320e-02f, 9.09279212e-02f,
  3.01614970e-01f, 1.53460458e-01f, -8.17172676e-02f, 9.68824420e-03f, 2.33884044e-02f, 2.67850291e-02f, -3.61262783e-02f, 1.18232310e-01f, -6.41315058e-02f, 1.63833767e-01f,
  6.39061853e-02f, -6.28307015e-02f, -9.91708506e-03f, 4.08512168e-02f, 1.05541512e-01f, -3.16074938e-02f, 2.23173127e-02f, -4.68504094e-02f, 2.49197632e-02f, -6.91244975e-02f,
  -1.88895781e-02f, -1.82801355e-02f, -2.14228220e-02f, 3.97968516e-02f, -3.13103981e-02f, -6.31105825e-02f, -9.66405775e-03f, 1.83329545e-02f, -1.24526076e-01f, -5.00239432e-02f,
  -6.54515177e-02f, -8.68362561e-02f, -2.92566586e-02f, -6.08412400e-02f, -9.28512309e-04f, -8.07557106e-02f, 4.31899577e-02f, -6.81972206e-02f, -7.09862038e-02f, 1.15616899e-02f,
  1.23843230e-01f, -1.38964817e-01f, 7.15687871e-02f, 1.21207818e-01f, -5.08975461e-02f, 1.77659735e-03f, 4.71110828e-02f, -4.92095388e-03f, 1.45187955e-02f, -6.76760264e-03f,
  3.27456556e-02f, 5.28044254e-03f, 8.80111232e-02f, 1.68302376e-02f, 3.39044072e-02f, 8.04279968e-02f, 1.04660042e-01f, 2.70354133e-02f, 1.07632503e-01f, 1.09232068e-01f,
  1.13134429e-01f, 1.17802883e-04f, 1.24147655e-02f, -2.90941447e-02f, 7.73779452e-02f, -1.88938901e-02f, 2.09708288e-02f, -3.26051041e-02f, -1.64454043e-01f, 8.82007480e-02f,
  4.05015171e-01f, -2.61109084e-01f, 3.39946300e-01f, 5.41732125e-02f, -4.59096700e-01f, -1.84667841e-01f, -3.40473622e-01f, -5.41177690e-02f, 5.97106218e-02f, 1.34666068e-02f,
  -1.69023827e-01f, 2.70943269e-02f, 2.30899677e-01f, 1.74029484e-01f, 2.02738136e-01f, 9.60775539e-02f, 1.51688874e-01f, 2.78827429e-01f, 1.62900850e-01f, -2.03372240e-01f,
  -3.92629892e-01f, -1.04309492e-01f, 2.16300964e-01f, 2.11208710e-03f, -1.05034955e-01f, 1.35813551e-02f, 2.00783610e-01f, -7.31669888e-02f, -3.33236493e-02f, 5.10850884e-02f,
  2.87945598e-01f, -4.68575619e-02f, 4.37459387e-02f, -6.45895377e-02f, -8.23283792e-02f, 1.02855787e-01f, 9.96263102e-02f, 8.88429210e-02f, 1.57062267e-03f, 1.27853855e-01f,
  -7.98241198e-02f, 4.76424955e-02f, -1.65489819e-02f, -1.23961652e-02f, -2.97518168e-03f, 8.25696662e-02f, 1.20631829e-01f, 2.49834523e-01f, 2.14493841e-01f, 2.82278135e-02f,
  -2.14997977e-01f, -1.64904818e-01f, 7.20658004e-02f, -9.54531133e-03f, 1.32574201e-01f, 1.61664203e-01f, 5.27005307e-02f, 8.36724937e-02f, 2.79897541e-01f, 2.00545400e-01f,
  5.75445071e-02f, -1.37089327e-01f, -7.87571967e-02f, -1.67183634e-02f, -6.53624013e-02f, 3.94234397e-02f, -3.48842964e-02f, -1.14853457e-01f, -8.84077400e-02f, -6.47326261e-02f,
  1.69340204e-02f, -1.90013684e-02f, -6.23897947e-02f, -3.21488529e-02f, -6.71135783e-02f, -6.03176653e-02f, -5.96478134e-02f, -8.52153972e-02f, -1.09913938e-01f, -1.34187629e-02f,
  -5.21652587e-03f, 7.03296298e-03f, -6.58572614e-02f, -5.68977185e-02f, -5.97720742e-02f, -3.08015216e-02f, 2.20965710e-03f, -5.03713563e-02f, -1.39240958e-02f, -1.12505913e-01f,
  2.57130146e-01f, 9.86931473e-03f, 1.09347984e-01f, 1.58880889e-01f, -1.77026987e-02f, 6.25759214e-02f, -6.45464752e-03f, 8.61126781e-02f, -2.55937390e-02f, 3.88512909e-02f,
  5.82981296e-02f, 3.47349755e-02f, 5.23655526e-02f, -3.47207040e-02f, 5.43128047e-03f, -3.01978048e-02f, -1.26111999e-01f, 6.06198944e-02f, -3.84051166e-02f, -9.91018265e-02f,
  -3.93100008e-02f, 1.01090774e-01f, 1.37872115e-01f, 1.03944078e-01f, -2.28419993e-02f, 9.62571278e-02f, 1.66006416e-01f, 8.30810368e-02f, 2.66120166e-01f, 2.09053025e-01f,
  -2.46114030e-01f, 4.25688744e-01f, 4.36637223e-01f, -9.69592407e-02f, 1.34030923e-01f, 1.55991063e-01f, 3.98687243e-01f, 5.65395392e-02f, -3.11842650e-01f, 1.90825865e-01f,
  1.18164472e-01f, -2.98452616e-01f, 6.76105171e-02f, -4.01051156e-02f, 2.03531876e-01f, 4.63257641e-01f, 3.88470620e-01f, 2.47836381e-01f, -3.14008668e-02f, 1.80695730e-03f,
  -5.27175926e-02f, -1.40932009e-01f, -1.79494947e-01f, -8.91298503e-02f, -9.43982527e-02f, -1.05459958e-01f, 1.82230845e-01f, -2.70840432e-02f, 6.20375723e-02f, 2.16942847e-01f,
  4.35789019e-01f, 2.25669771e-01f, -2.25712694e-02f, -9.10546705e-02f, 1.92918628e-02f, -1.06242010e-02f, -5.08739054e-03f, 2.49292571e-02f, -7.03043714e-02f, 1.29368315e-02f,
  -4.38275784e-02f, -1.25276208e-01f, 2.53670067e-02f, -5.09340987e-02f, 4.25876230e-02f, -6.62000999e-02f, -1.15445694e-02f, 3.67925987e-02f, -2.60650925e-02f, 2.99773198e-02f,
  -7.58380769e-03f, 8.34235922e-02f, 8.62116069e-02f, 8.49107206e-02f, 1.28128156e-01f, -5.27669005e-02f, 3.98949906e-02f, -9.70570147e-02f, 6.45332783e-02f, -1.84134785e-02f,
  -4.36814949e-02f, -1.26136132e-02f, -6.22148626e-02f, -5.73721677e-02f, -1.14038639e-01f, -3.48034091e-02f, 4.20873910e-02f, -9.24340449e-03f, -5.12043722e-02f, -6.96754754e-02f,
  2.34905686e-02f, 7.57470205e-02f, -2.36342624e-02f, 9.66787115e-02f, 2.30084211e-02f, 3.99553496e-03f, -3.95575352e-02f, 3.89475934e-02f, -1.93213038e-02f, -3.12982611e-02f,
  -1.55652881e-01f, -4.72039506e-02f, -2.94921305e-02f, -2.11469233e-02f, 7.78969601e-02f, 8.77647400e-02f, -4.35817838e-02f, -3.08828596e-02f, -1.79572552e-02f, -9.41915214e-02f,
  -1.33861065e-01f, 1.17702380e-01f, 9.45592597e-02f, -1.64717231e-02f, 2.08409540e-02f, -6.92030862e-02f, 2.40968838e-02f, 3.58163826e-02f, -2.80072354e-03f, 7.02272281e-02f,
  2.76640779e-03f, 2.73294188e-02f, 8.96707103e-02f, 8.96062329e-02f, -4.74575497e-02f, -5.90858422e-03f, 2.55709570e-02f, -6.40197992e-02f, -4.99204136e-02f, -3.74586657e-02f,
  -7.83988908e-02f, -3.99280302e-02f, -3.93862166e-02f, -5.25268093e-02f, -5.52533120e-02f, -1.29291758e-01f, 7.11670294e-02f, -9.73013714e-02f, -1.14755854e-02f, 5.14548011e-02f,
  -7.04715669e-01f, 3.23932678e-01f, -4.57431078e-02f, -4.50163670e-02f, 1.07434236e-01f, 2.49547035e-01f, 4.46241856e-01f, 1.42618626e-01f, -7.92713240e-02f, 2.10171252e-01f,
  8.92438591e-02f, 3.87862027e-02f, 4.06930260e-02f, 8.54384601e-02f, 1.50714248e-01f, 2.71688670e-01f, 2.79293031e-01f, -1.76749840e-01f, -2.73671448e-01f, -8.45884606e-02f,
  1.18382603e-01f, -8.83223936e-02f, -3.38518471e-01f, -9.83269140e-02f, 5.50530106e-02f, 2.31545847e-02f, 1.16104335e-01f, -1.46454930e-01f, 4.59254943e-02f, -4.56200428e-02f,
  -1.74247056e-01f, -2.75466621e-01f, 2.63246894e-02f, -6.78117154e-03f, 2.19935980e-02f, -7.35194162e-02f, 1.79463457e-02f, -5.48481457e-02f, 3.57991345e-02f, -9.62527655e-03f,
  -7.26478128e-03f, -5.07059565e-04f, -2.69669797e-02f, 4.14605299e-03f, -3.68794031e-03f, -5.48479659e-03f, 3.36098373e-02f, 4.64268923e-02f, 9.09109320e-03f, -5.48808230e-03f,
  1.92995101e-01f, -7.62371495e-02f, -6.55356720e-02f, 1.58435449e-01f, 5.65651171e-02f, 5.81263453e-02f, 2.64664609e-02f, 2.27662213e-02f, 5.32497838e-02f, -1.01599237e-02f,
  1.56990469e-01f, -2.08832212e-02f, 2.88438741e-02f, -1.56521089e-02f, 4.22631763e-02f, -3.51617374e-02f, -9.57875047e-03f, -2.81988271e-03f, -1.06761336e-01f, 9.42890346e-03f,
  -7.76915103e-02f, -5.91817684e-02f, -1.32709250e-01f, -5.39077334e-02f, 1.42846266e-02f, -6.26455098e-02f, -5.60973119e-03f, 3.60306688e-02f, -5.05728610e-02f, -4.73285466e-02f,
  -1.43402889e-01f, -6.32557571e-02f, -4.79585417e-02f, 1.22822886e-02f, 1.17443260e-02f, -7.52231404e-02f, -6.55895323e-02f, -4.22113501e-02f, -8.58826339e-02f, -1.76520217e-02f,
  1.60571873e-01f, 1.06169596e-01f, -2.58522877e-03f, -5.34009635e-02f, -8.11069161e-02f, 5.02063148e-02f, 3.34359631e-02f, -4.18664031e-02f, 3.69463786e-02f, -9.57390014e-03f,
  -4.20659520e-02f, -3.03414427e-02f, 5.62509000e-02f, 7.32059255e-02f, 8.72105360e-02f, 3.39925215e-02f, 6.76310062e-02f, 5.57021312e-02f, 1.91574004e-02f, 7.46219978e-02f,
  1.66014031e-01f, 1.32715866e-01f, 6.16112500e-02f, 1.27326056e-01f, 1.23719186e-01f, 3.90075743e-02f, 1.03161931e-01f, 1.42567620e-01f, 7.36315548e-02f, 3.14603955e-01f,
  6.49402104e-03f, -3.22412163e-01f, 4.14609194e-01f, 2.13864028e-01f, -2.10562676e-01f, -1.41379535e-02f, 4.71000909e-04f, 1.61093220e-01f, 2.46185258e-01f, -1.59624279e-01f,
  -4.43953007e-01f, -4.22160089e-01f, -9.25554037e-02f, 6.67545013e-03f, 1.88987538e-01f, 3.10966074e-01f, 5.36025345e-01f, 3.11110675e-01f, 1.91957027e-01f, -3.26315343e-01f,
  -3.15001309e-01f, -3.44816074e-02f, 7.99448267e-02f, 1.96274728e-01f, 7.18259858e-03f, 4.88650165e-02f, 2.79353231e-01f, -1.07161269e-01f, -1.17096722e-01f, 1.38203949e-01f,
  -3.82460088e-01f, -1.87445849e-01f, 4.37341742e-02f, -1.82022601e-01f, -1.18670493e-01f, 8.37850571e-03f, -9.73723680e-02f, 6.31133914e-02f, 9.85032227e-03f, -2.38418998e-03f,
  -1.21010162e-01f, -1.76838696e-01f, -6.78223372e-02f, -1.20650105e-01f, -9.16706100e-02f, -1.74111035e-02f, 1.00690551e-01f, 1.21275306e-01f, 1.49281874e-01f, -1.38046056e-01f,
  -2.58015513e-01f, -1.47940829e-01f, -8.02790672e-02f, 1.03594072e-01f, 1.35177344e-01f, -6.81281760e-02f, -2.48198137e-02f, -2.66391505e-02f, 1.37064889e-01f, -5.21937013e-02f,
  -5.58064170e-02f, -4.18179529e-03f, -2.27362514e-02f, -8.30276404e-03f, 2.79251672e-02f, -2.99949590e-02f, -7.12753693e-03f, -6.07096069e-02f, 5.03019837e-04f, 4.27400321e-02f,
  6.39573708e-02f, -6.11524843e-02f, 2.70028710e-02f, -4.36500534e-02f, -7.58549422e-02f, -3.09394188e-02f, 1.89944673e-02f, 1.05017964e-02f, -4.49728826e-03f, -6.26809243e-03f,
  -5.93732744e-02f, 2.79523581e-02f, -1.30011057e-02f, 6.11762516e-02f, 2.54139546e-02f, 1.29633797e-02f, 2.14696061e-02f, -5.26315793e-02f, -1.39768049e-01f, -4.32731546e-02f,
  -1.90959424e-02f, 1.68898150e-01f, 1.33724008e-02f, 4.61411439e-02f, -2.00139750e-02f, 2.49933004e-02f, -5.70974648e-02f, 5.72318286e-02f, -3.42958830e-02f, -1.18819363e-02f,
  -1.50420994e-01f, -7.42307007e-02f, 1.77319787e-04f, 8.63428973e-03f, 6.37195483e-02f, -5.62144555e-02f, 2.53362861e-02f, 8.20975155e-02f, 5.27203679e-02f, -7.70539716e-02f,
  1.11633152e-01f, 5.68996035e-02f, 6.48642778e-02f, 1.23549245e-01f, 1.60614941e-02f, 1.51701257e-01f, -8.30031291e-04f, 5.48681580e-02f, 8.46441239e-02f, 9.51665938e-02f,
  7.19986439e-01f, -3.77768993e-01f, -3.10924351e-01f, 5.69371544e-02f, -3.39699954e-01f, -3.56093317e-01f, -4.66855019e-01f, 5.16404323e-02f, 8.16056579e-02f, -2.27144659e-01f,
  -4.02569436e-02f, 3.05592448e-01f, 2.28842393e-01f, 1.74884692e-01f, 2.65585870e-01f, -3.66247892e-01f, -2.01546654e-01f, 1.46542430e-01f, 3.59972417e-01f, 1.53797209e-01f,
  6.61046579e-02f, 1.20335139e-01f, 3.79734963e-01f, 9.57190692e-02f, -1.29422843e-01f, 3.17319892e-02f, -2.21935824e-01f, 1.33547829e-02f, -1.48852617e-01f, -1.73426121e-01f,
  -1.86018899e-01f, 2.53420454e-02f, -2.73696128e-02f, 4.11385223e-02f, -3.61665078e-02f, -4.38502766e-02f, -1.21716678e-01f, -2.31271833e-02f, -8.17444474e-02f, -3.89652215e-02f,
  -1.01247959e-01f, -5.84316663e-02f, 2.42393953e-03f, -7.62283504e-02f, -1.38101019e-02f, -9.63643268e-02f, 6.92064837e-02f, 1.78884625e-01f, 6.42530993e-02f, -5.16711324e-02f,
  -2.14452520e-01f, -1.57112971e-01f, -3.52871791e-02f, -7.09050745e-02f, -2.26248950e-02f, 8.48603323e-02f, -1.02811120e-01f, -2.05215160e-02f, -2.76307538e-02f, -1.18067615e-01f,
  -4.18084860e-02f, -3.85766700e-02f, -1.28889894e-02f, 7.48743769e-03f, 1.10691495e-01f, -5.79172038e-02f, 1.54101308e-02f, 4.52282317e-02f, 4.91378680e-02f, 1.00714080e-02f,
  -3.90253292e-04f, 3.50912241e-03f, 3.15638743e-02f, -2.66392697e-02f, 9.71497521e-02f, -1.93791892e-02f, -6.71909824e-02f, 6.28269464e-02f, 6.20632544e-02f, 3.78041677e-02f,
  9.83655229e-02f, 5.52791432e-02f, 5.44732586e-02f, 7.94945750e-03f, -3.81041970e-03f, 2.50058286e-02f, 5.46500310e-02f, 6.54413477e-02f, 5.30407541e-02f, 4.47127707e-02f,
  7.48101920e-02f, 1.15150101e-02f, -2.90851854e-02f, 8.94752145e-02f, -1.96653605e-01f, 1.99587196e-02f, -1.38199404e-01f, -6.93503916e-02f, -5.44781657e-03f, -4.11612578e-02f,
  6.53150380e-02f, 3.78248803e-02f, -6.09748028e-02f, -2.66096536e-02f, -6.30900338e-02f, -2.03595497e-02f, -7.72502795e-02f, -5.23056723e-02f, -4.16010730e-02f, -9.68300328e-02f,
  -1.24379322e-02f, -1.59964517e-01f, 3.11080683e-02f, -1.27020702e-01f, 8.97020102e-03f, -5.56737510e-03f, -7.15826377e-02f, -5.02755716e-02f, -1.04791755e-02f, -2.40747929e-01f,
  -3.60234588e-01f, 3.64788204e-01f, -3.43210548e-01f, -8.75116698e-03f, 8.66007060e-02f, 1.06482640e-01f, 3.42910975e-01f, 1.69283658e-01f, 5.92085831e-02f, 6.30626008e-02f,
  1.05153367e-01f, -1.36107251e-01f, -1.43777430e-01f, -2.49573141e-01f, -5.12019582e-02f, -9.72422138e-02f, -1.85729563e-01f, -3.91963840e-01f, -3.38977873e-01f, -1.45165861e-01f,
  4.48076166e-02f, -1.27298310e-01f, -3.47406298e-01f, -2.55688518e-01f, -2.98408624e-02f, -2.51394659e-01f, -2.13987082e-01f, -1.03699774e-01f, -1.39799193e-01f, -2.82725006e-01f,
  -4.11259294e-01f, 4.26413026e-03f, -3.52844179e-01f, -1.22952536e-01f, -1.44882068e-01f, -1.07794434e-01f, -1.42552093e-01f, -2.50280410e-01f, -7.60682151e-02f, -2.15736344e-01f,
  -1.13656737e-01f, -1.28605068e-01f, -1.18922681e-01f, -1.66352466e-02f, -9.07337070e-02f, -1.26160234e-01f, -8.34063739e-02f, -2.20597997e-01f, -2.46578693e-01f, -9.39909071e-02f,
  8.45197123e-03f, -9.36242417e-02f, -1.29697651e-01f, -1.83582120e-02f, -8.60338137e-02f, -1.75825506e-01f, -1.64589927e-01f, -2.87569195e-01f, -2.76284307e-01f, -3.33660275e-01f,
  -9.80733428e-04f, -6.31817952e-02f, 6.19825497e-02f, 7.94215128e-02f, -7.41355214e-03f, 8.24944973e-02f, 1.71935260e-02f, -2.96734739e-02f, 3.87469791e-02f, 6.96170330e-02f,
  -2.06278879e-02f, 6.84082732e-02f, 7.36785633e-03f, 2.31288448e-02f, -2.07691104e-03f, 5.15690409e-02f, -1.50994509e-02f, 4.61355634e-02f, 6.79790182e-03f, 5.77569492e-02f,
  1.74633451e-02f, -3.95234078e-02f, 3.14921103e-02f, -3.99289047e-03f, 7.01966509e-02f, 5.58912307e-02f, 7.95805901e-02f, 3.47615518e-02f, 1.18105471e-01f, 1.26900688e-01f,
  -4.37610708e-02f, -8.07542056e-02f, -1.24814682e-01f, -1.34874061e-01f, -7.58399889e-02f, -1.53957352e-01f, -1.51154414e-01f, -7.14387298e-02f, -1.87013119e-01f, -1.20004863e-01f,
  -8.90260339e-02f, -1.56207100e-01f, -4.90059182e-02f, -1.09390125e-01f, -1.62067726e-01f, -1.13432251e-01f, 8.57160166e-02f, -1.69939131e-01f, -1.06476568e-01f, -9.86097082e-02f,
  -1.66721437e-02f, -6.20127954e-02f, -2.52908260e-01f, -1.17419019e-01f, -1.13596581e-01f, -1.74604893e-01f, -2.05720484e-01f, -1.34597942e-01f, -1.94915429e-01f, -1.32000133e-01f,
  -7.93382153e-02f, -1.20099902e-01f, 1.51565596e-01f, -1.68856710e-01f, -5.53163216e-02f, 1.01976566e-01f, 3.13344836e-01f, 1.76673651e-01f, -8.76695067e-02f, 5.09683751e-02f,
  -3.06088477e-01f, -2.37263367e-01f, -9.51479822e-02f, -1.00353947e-02f, 2.52610236e-01f, 4.44043815e-01f, 3.19820225e-01f, 2.29078069e-01f, 2.96415180e-01f, 5.51029406e-02f,
  -5.75428382e-02f, 4.77776900e-02f, 1.60076261e-01f, 1.70724005e-01f, 5.62569089e-02f, 5.32276668e-02f, 2.69374698e-01f, 9.96955484e-02f, 1.52703434e-01f, 5.46852686e-02f,
  8.91948957e-03f, 7.88820311e-02f, -4.99790609e-02f, -1.80030942e-01f, -1.40942885e-02f, -7.71318749e-02f, 5.92922932e-03f, 5.44685591e-03f, -1.24503352e-01f, -9.64752808e-02f,
  -6.49479032e-02f, -8.04746747e-02f, 2.46080607e-02f, -2.48117950e-02f, -4.00403254e-02f, -6.41133357e-03f, -3.30536813e-02f, -3.49913202e-02f, 5.14918454e-02f, -6.52263463e-02f,
  -1.37353763e-01f, 3.87685373e-02f, -3.09539028e-03f, 4.93234321e-02f, -6.01936597e-03f, 3.68490294e-02f, 3.76891494e-02f, 8.46183226e-02f, 2.03090489e-01f, 2.14128345e-01f,
  1.02853868e-02f, 7.81369433e-02f, -1.52519643e-02f, -1.49294948e-02f, -3.27195227e-02f, -5.63133210e-02f, 3.09526529e-02f, -3.65024954e-02f, 7.92130902e-02f, 5.15337195e-03f,
  -5.91215454e-02f, 1.15218153e-02f, 7.57483486e-03f, 4.20707241e-02f, 7.38597885e-02f, 2.11429838e-02f, 3.84367742e-02f, -2.22162064e-02f, 2.66699493e-02f, 5.04955575e-02f,
  -5.52016348e-02f, -1.24008395e-01f, -7.63167068e-02f, -7.68449828e-02f, 3.32261762e-03f, 6.38314039e-02f, 2.13508420e-02f, -3.87294367e-02f, -1.77220069e-02f, -1.43485311e-02f,
  -3.25138211e-01f, -3.44065465e-02f, -6.28587976e-02f, 7.38533065e-02f, 4.37886873e-03f, -6.04815893e-02f, -1.04723580e-01f, -1.49079785e-03f, -7.08615258e-02f, -2.23179553e-02f,
  1.05033880e-02f, -5.23112416e-02f, -4.20334972e-02f, -1.63108073e-02f, 6.52607381e-02f, 1.87693145e-02f, -2.33233124e-02f, -2.75698826e-02f, 3.42297368e-02f, -9.79706272e-02f,
  -1.41829059e-01f, 7.09848776e-02f, -2.43277214e-02f, -9.43478271e-02f, 2.03730091e-02f, 4.88636503e-03f, 9.00155380e-02f, 1.40405623e-02f, 1.66759968e-01f, 1.03524968e-01f,
  -1.91592813e-01f, -6.96647679e-03f, 7.90256113e-02f, -2.70396858e-01f, 2.04798982e-01f, 4.68787611e-01f, 5.59140265e-01f, 7.00242147e-02f, -2.77443737e-01f, 4.81153205e-02f,
  1.07342191e-01f, -1.72809392e-01f, -2.05644384e-01f, -1.04077712e-01f, 1.45616367e-01f, 2.74372041e-01f, 2.59050488e-01f, 9.80488807e-02f, 1.19818762e-01f, 1.20475419e-01f,
  2.79720910e-02f, -1.26928404e-01f, -1.58502474e-01f, -1.34436443e-01f, -3.59354496e-01f, -1.19911693e-01f, -9.89684761e-02f, -1.31695092e-01f, 1.76320225e-01f, -2.08660409e-01f,
  2.40356103e-01f, -1.71952993e-01f, 4.58257571e-02f, -5.00439182e-02f, -9.27810296e-02f, -1.21110126e-01f, 9.47924852e-02f, -2.07339048e-01f, -1.01024985e-01f, 1.06272772e-02f,
  -1.07148722e-01f, -7.88860116e-03f, -1.25509113e-01f, -1.28974140e-01f, -9.79787633e-02f, -2.85126492e-02f, -9.72575992e-02f, -6.05439991e-02f, -1.26975954e-01f, -3.13525200e-02f,
  2.07539601e-03f, 7.41536841e-02f, -4.25131060e-02f, 6.78052157e-02f, -8.63254219e-02f, 4.32795249e-02f, -3.99964564e-02f, -1.83955804e-01f, 3.02114268e-03f, -5.48488609e-02f,
  1.10802203e-02f, 4.20280062e-02f, 5.51449880e-03f, -1.31080188e-02f, -4.95944843e-02f, -2.07295045e-02f, 4.04352359e-02f, 9.54193026e-02f, 7.77019013e-04f, 6.03269860e-02f,
  1.86349247e-02f, -3.43407830e-03f, -1.56157566e-02f, 1.67986937e-02f, -1.80964544e-02f, -3.15450840e-02f, 8.90154615e-02f, 1.87338237e-02f, -2.11179797e-02f, 9.35798232e-03f,
  -7.47975484e-02f, 7.82871544e-02f, -9.30853561e-02f, -5.01499511e-02f, -2.29917485e-02f, 5.62581979e-02f, -7.96551909e-03f, -7.71097988e-02f, -1.08353838e-01f, 6.88364506e-02f,
  -3.23377736e-02f, 2.03732833e-01f, 1.35601416e-01f, -2.54124925e-02f, -3.72575159e-04f, -6.08017109e-02f, -2.68652253e-02f, 1.95324179e-02f, -8.31036828e-03f, 1.06131405e-01f,
  -2.76056794e-03f, 4.03232314e-02f, -4.80889007e-02f, -2.68646330e-02f, 1.37772024e-01f, 3.31521481e-02f, -6.65310323e-02f, 1.71140581e-02f, -3.73627618e-02f, -9.64219198e-02f,
  -3.88570987e-02f, 1.99542999e-01f, 1.85011908e-01f, 1.32596672e-01f, -2.99280453e-02f, 8.83569196e-02f, 1.09375969e-01f, 1.22942209e-01f, 2.37096891e-01f, 2.28690431e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  9.90376294e-01f, -5.47157340e-02f, 3.45205843e-01f, 5.33859074e-01f, 1.98635280e-01f, 7.78264329e-02f, -5.50053753e-02f, 7.88201019e-02f, 2.47120559e-01f, 2.83649415e-01f,
  4.05997373e-02f, 1.67681903e-01f, 1.17470205e-01f, 1.76313877e-01f, 2.11576849e-01f, 2.22295269e-01f, 3.20719063e-01f, 3.33837360e-01f, 3.50298166e-01f, 3.91451627e-01f,
  2.15142295e-01f, 1.18988514e-01f, 2.00989872e-01f, 2.55805552e-01f, 3.20155650e-01f, 2.69412458e-01f, 3.99902239e-02f, 1.56022400e-01f, 1.66581303e-01f, 6.43235266e-01f,
  4.30907607e-01f, -1.31210923e-01f, 6.39686733e-02f, -8.49801302e-02f, -1.47655711e-01f, -6.01614416e-02f, 1.61117867e-01f, -2.15866819e-01f, -1.77500919e-01f, 3.89312580e-02f,
  -7.87653923e-02f, -9.11428779e-02f, 1.47386137e-02f, -2.17744391e-02f, -2.69545447e-02f, -7.52573013e-02f, -2.39168853e-02f, -8.35937783e-02f, 9.62376222e-03f, -5.22398986e-02f,
  -5.37974015e-03f, -9.17000100e-02f, -4.03087288e-02f, -5.93113713e-02f, -6.50841966e-02f, -1.53838070e-02f, -1.50335893e-01f, 4.49624807e-02f, -1.45663694e-01f, 1.94514990e-01f,
  2.31076360e-01f, 1.52452424e-01f, 2.92752385e-01f, 1.52739301e-01f, 9.75509360e-02f, 5.77913150e-02f, 4.91848215e-02f, -1.97494728e-03f, 6.51599988e-02f, 2.15983391e-01f,
  1.67090237e-01f, 1.26977846e-01f, -9.43456590e-02f, 9.46017951e-02f, -1.53881358e-02f, 1.06640033e-01f, 1.12516195e-01f, -1.12727322e-01f, -3.57418135e-03f, -2.21903771e-02f,
  1.04877017e-01f, -1.41802058e-02f, 1.49620384e-01f, -4.13290970e-02f, -2.02939007e-02f, 1.43594563e-01f, 1.70440122e-01f, -4.34455909e-02f, 7.74667561e-02f, -7.36114830e-02f,
  -6.27483308e-01f, -4.82746363e-01f, 3.16380799e-01f, -1.53269753e-01f, 1.61544736e-02f, -1.50579587e-01f, 2.88660601e-02f, -3.03850293e-01f, -2.66544908e-01f, -1.00635819e-01f,
  -1.04859821e-01f, 2.20067240e-03f, -2.25170121e-01f, -1.67836785e-01f, 3.73719335e-02f, -1.08459495e-01f, -2.89294720e-02f, -1.41360760e-01f, -2.13833332e-01f, -1.77863732e-01f,
  -1.35747269e-01f, -6.88255131e-02f, 2.15981435e-02f, -4.50876281e-02f, -4.28043008e-02f, -1.62604555e-01f, -9.40151140e-02f, -1.09904639e-01f, -1.30189583e-01f, -8.14065710e-02f,
  -1.21360791e+00f, 7.77510464e-01f, -3.64794910e-01f, -5.84047973e-01f, -4.44960177e-01f, -6.04305685e-01f, 3.69582027e-01f, -9.00590047e-02f, -3.55073065e-01f, 5.43265462e-01f,
  3.60432178e-01f, -3.35924447e-01f, 2.00944319e-01f, -3.69551815e-02f, -8.48231688e-02f, 4.69959676e-01f, 1.51857361e-02f, -6.16967440e-01f, -1.10600531e+00f, -6.10637248e-01f,
  -2.35854864e-01f, -7.30949342e-01f, -9.18520391e-01f, -4.43782389e-01f, 1.16602279e-01f, -2.45553419e-01f, 1.25058770e-01f, -3.10985833e-01f, -1.23025000e-01f, 1.34895146e-01f,
  4.59099710e-01f, -4.63956833e-01f, -1.88543871e-01f, -6.66284561e-02f, 1.32407648e-02f, -1.66763365e-02f, -4.35845144e-02f, -8.34984779e-02f, 6.09512739e-02f, 9.56652015e-02f,
  -1.83023781e-01f, -7.27854520e-02f, -2.25165471e-01f, -8.28478485e-02f, -2.96720266e-01f, -1.48399472e-01f, 4.34534550e-02f, -1.56689867e-01f, 3.61931026e-02f, 3.40546221e-01f,
  3.36634040e-01f, -3.58063988e-02f, 1.09614052e-01f, 2.75686860e-01f, 6.90394118e-02f, -1.08144440e-01f, 1.59003913e-01f, -8.87124892e-03f, 4.28787656e-02f, 4.39620852e-01f,
  1.48421675e-01f, 2.43581533e-01f, -5.12098037e-02f, -5.12986295e-02f, -3.79086323e-02f, 1.20256409e-01f, 3.93311381e-02f, 1.24224864e-01f, -1.10462070e-01f, 2.70799957e-02f,
  2.31284291e-01f, -4.46635857e-02f, -6.62407503e-02f, 5.20023666e-02f, -7.77274463e-03f, -1.21477343e-01f, 2.37117540e-02f, 1.45998284e-01f, 2.16668490e-02f, -8.21796432e-02f,
  -1.33444712e-01f, 9.76126641e-03f, -1.22689672e-01f, -7.62669593e-02f, 3.85851152e-02f, -4.71497476e-02f, -5.99051490e-02f, -6.95021600e-02f, -8.93293396e-02f, 6.21743221e-03f,
  1.91783950e-01f, -2.31141955e-01f, 2.69010723e-01f, -6.64224699e-02f, -3.16224061e-02f, 1.84991762e-01f, -3.51113528e-02f, -1.25619084e-01f, -1.68079093e-01f, -2.76359357e-02f,
  -9.42283422e-02f, 1.78526863e-02f, 9.20714531e-03f, 1.57773912e-01f, -2.20221162e-01f, -1.08741708e-01f, 2.03677133e-01f, 1.00332005e-02f, -8.27613175e-02f, 4.60000113e-02f,
  2.27812842e-01f, 1.71836704e-01f, 2.16528997e-01f, 2.97125489e-01f, 1.59890968e-02f, -1.11603022e-01f, 1.73484594e-01f, 6.94409832e-02f, 2.27113795e-02f, 4.45496023e-01f,
  -6.03228569e-01f, 3.45548362e-01f, -6.44904017e-01f, 1.74675509e-01f, 4.52176630e-01f, 4.73285556e-01f, 8.19722533e-01f, 3.57411534e-01f, 1.25854820e-01f, -7.16837402e-03f,
  -1.19750509e-02f, -5.33260256e-02f, -3.39567401e-02f, -7.42166489e-02f, 6.94113076e-02f, 1.83084488e-01f, 1.30739316e-01f, -3.96749735e-01f, -3.67067754e-01f, 7.19702691e-02f,
  3.43465477e-01f, 2.95700520e-01f, -2.27135614e-01f, -1.91126727e-02f, 1.61868840e-01f, 4.49210685e-03f, 5.48012890e-02f, 6.04402013e-02f, 1.21659696e-01f, -3.73270601e-01f,
  -9.87831354e-01f, -2.50421017e-01f, 7.80860335e-02f, 1.92282647e-01f, -2.32745498e-01f, -1.93497911e-01f, -1.78354070e-01f, -1.59550160e-01f, 2.15984825e-02f, -4.97117899e-02f,
  6.53342903e-03f, -6.04956225e-02f, 1.96872637e-01f, 7.22128674e-02f, 2.37988979e-01f, 1.13448560e-01f, 9.48439632e-03f, -2.50916392e-01f, -2.28569269e-01f, -2.37527400e-01f,
  2.04228818e-01f, 1.06678344e-01f, -1.77090645e-01f, 1.88042551e-01f, -1.35248661e-01f, -1.05190910e-01f, -8.24478120e-02f, -3.30310345e-01f, -1.86495289e-01f, -4.17547256e-01f,
  -9.31940321e-03f, -1.04974687e-01f, -7.26662437e-03f, -2.80961003e-02f, 6.78513348e-02f, -4.91684750e-02f, -6.17812872e-02f, -1.29450560e-01f, 1.09078228e-01f, 4.18222621e-02f,
  -4.38667415e-03f, -1.25893191e-01f, -2.29786545e-01f, -1.16113380e-01f, 9.08577666e-02f, 2.94387620e-02f, -5.11706732e-02f, 5.25331721e-02f, 1.81404017e-02f, 3.68621647e-02f,
  7.84300789e-02f, -9.09569412e-02f, -8.51580724e-02f, -1.51321925e-02f, -5.77870980e-02f, -2.07680255e-01f, -9.23309252e-02f, 8.25202912e-02f, -2.09444016e-03f, 1.71644092e-01f,
  4.02875215e-01f, 5.23730814e-01f, -1.65358678e-01f, 1.42497644e-01f, -1.86819971e-01f, 2.96725389e-02f, 7.59014115e-02f, -1.92406163e-01f, 6.27927706e-02f, -1.27208665e-01f,
  1.05090246e-01f, -1.31793141e-01f, 1.80486396e-01f, 1.79869041e-01f, -1.51682077e-02f, -1.28386661e-01f, -5.33777056e-03f, -1.00707121e-01f, 6.01452366e-02f, -1.71248466e-01f,
  2.01147422e-01f, 3.33063304e-02f, -2.30063960e-01f, -1.04303241e-01f, -5.35839759e-02f, -3.34185958e-02f, -1.50105521e-01f, -7.18217492e-02f, -1.37892351e-01f, 1.11178905e-01f,
  2.71103501e-01f, 4.47190255e-01f, 4.10771698e-01f, -3.31433713e-01f, 8.65450278e-02f, 5.07376730e-01f, 7.54076481e-01f, 2.59232402e-01f, -2.69534409e-01f, 2.79252708e-01f,
  4.87208843e-01f, -3.62398662e-02f, -3.15578878e-02f, 3.96879576e-02f, 3.49627376e-01f, 2.05773637e-01f, -1.29340142e-01f, -9.50043425e-02f, -8.58859345e-02f, -7.64273331e-02f,
  -8.75498950e-02f, -2.48965010e-01f, -2.67725408e-01f, -2.74864048e-01f, -2.82184929e-01f, -3.97053391e-01f, -1.39855836e-02f, 2.67462898e-02f, 3.11865330e-01f, -4.58915681e-01f,
  1.71648368e-01f, 3.14727485e-01f, -3.17242771e-01f, -6.22477606e-02f, 4.19085026e-02f, -2.16027722e-01f, -8.09257701e-02f, -1.83437392e-01f, -1.94190443e-02f, -1.48758724e-01f,
  -8.96347091e-02f, 3.80851068e-02f, 6.73504397e-02f, -5.82328020e-03f, 5.44396276e-03f, -1.64814182e-02f, -7.83814788e-02f, 4.01897952e-02f, 1.93126529e-01f, 2.19882190e-01f,
  1.62986368e-01f, 1.22597553e-01f, 2.14771941e-01f, 9.17526335e-02f, 3.17380369e-01f, -4.70003393e-03f, 5.17422631e-02f, 1.00193314e-01f, 9.67620388e-02f, -1.06928267e-01f,
  8.67690295e-02f, -1.67887914e-03f, 1.35940358e-01f, -6.91888556e-02f, 3.35057266e-02f, 2.86754780e-02f, -1.20317973e-01f, 9.08957496e-02f, 8.21356401e-02f, -8.93478841e-02f,
  -1.03383383e-03f, 8.15374553e-02f, -4.01914231e-02f, -5.60548380e-02f, -1.17345564e-01f, 1.20096780e-01f, 2.08121049e-03f, -5.31484000e-02f, 2.93864638e-01f, -2.77148411e-02f,
  2.13122852e-02f, 3.40391994e-02f, 6.28919574e-03f, 9.16412473e-02f, 1.34173185e-01f, 3.55389975e-02f, -4.78832684e-02f, 1.21023878e-01f, -7.51017779e-02f, -6.05316162e-02f,
  -8.19285810e-01f, 5.21126032e-01f, -2.02439964e-01f, -1.31589651e-01f, 6.57998072e-03f, -2.23337766e-02f, 1.00976974e-01f, -1.16303563e-01f, -1.05056375e-01f, -1.15801007e-01f,
  5.27895652e-02f, -5.75476065e-02f, 8.61113742e-02f, -2.33009886e-02f, -2.96288222e-01f, -1.17126904e-01f, 7.44715184e-02f, -7.57626742e-02f, 9.82079208e-02f, -7.89725631e-02f,
  3.81150842e-03f, -6.64355159e-02f, -1.69223875e-01f, -1.10809997e-01f, -1.23577602e-01f, -2.07270220e-01f, -4.86871041e-02f, -1.98551547e-02f, 2.13079557e-01f, -1.86156362e-01f,
  -1.37609458e+00f, -3.45320940e-01f, -5.15258491e-01f, -4.15782034e-01f, 6.83687449e-01f, -9.74062458e-02f, -5.57222605e-01f, -7.07168400e-01f, -3.35575312e-01f, -6.95076212e-02f,
  5.88445604e-01f, 5.12158036e-01f, 8.75495449e-02f, 1.63253739e-01f, -4.04057801e-01f, 7.36511946e-02f, 4.74347770e-01f, -9.01807174e-02f, -4.09717619e-01f, 5.08285165e-02f,
  5.72971582e-01f, -2.59103417e-01f, -4.33069319e-01f, -2.04485565e-01f, 2.81962186e-01f, 3.44896376e-01f, 1.31762713e-01f, 1.74898207e-01f, 2.42825165e-01f, 6.87793314e-01f,
  -3.31669450e-01f, -8.68203878e-01f, 1.31489664e-01f, 2.74876744e-01f, 3.34405988e-01f, -3.47520441e-01f, -1.17326014e-01f, -1.76644728e-01f, 2.50999302e-01f, -9.65795219e-02f,
  3.54828596e-01f, -9.40732807e-02f, 3.20424408e-01f, -3.93917412e-02f, -2.87794501e-01f, -3.42560112e-01f, -3.37566048e-01f, -4.79454935e-01f, -5.09075761e-01f, -2.78240263e-01f,
  7.60667741e-01f, 3.96112084e-01f, -5.45568049e-01f, 1.07409507e-02f, -1.99355781e-01f, 3.22729200e-01f, -1.58475161e-01f, -6.64994642e-02f, -3.48363727e-01f, -5.82918108e-01f,
  -1.91621799e-02f, -3.18416506e-02f, -1.11507170e-01f, -1.56624973e-01f, 3.58234346e-02f, 1.79806858e-01f, 1.99377134e-01f, 1.59871250e-01f, -2.77218921e-03f, -2.20200479e-01f,
  2.72191986e-02f, 2.11436464e-03f, -1.09701991e-01f, -8.57930630e-02f, 1.22503638e-01f, -1.76132657e-02f, 7.83881396e-02f, 1.33940682e-01f, -1.10336486e-02f, -3.91191952e-02f,
  8.35033134e-02f, 3.16322073e-02f, 1.06212378e-01f, -4.03082445e-02f, 1.18046038e-01f, -7.01135546e-02f, -3.35011221e-02f, 3.76631878e-02f, -3.20344597e-01f, -1.03932686e-01f,
  -6.31823063e-01f, 4.86764520e-01f, -2.80282974e-01f, 3.73327360e-02f, -9.35112238e-02f, 2.21044987e-01f, 1.27608091e-01f, 1.73255980e-01f, 1.05670117e-01f, -2.81027973e-01f,
  -1.97965950e-01f, -1.88784525e-01f, -5.89794889e-02f, -1.85475931e-01f, -1.77789435e-01f, -1.74440265e-01f, 1.06316142e-01f, -7.18275309e-02f, -1.89712808e-01f, 7.51629844e-02f,
  -5.44760637e-02f, -3.29413325e-01f, -7.21266687e-01f, -4.34118479e-01f, -1.68077603e-01f, -1.91910639e-01f, -3.84698898e-01f, -3.10071588e-01f, -5.41002989e-01f, -8.77677381e-01f,
  -6.30691767e-01f, 2.25803271e-01f, -1.24732399e+00f, -1.80764601e-01f, -4.89720464e-01f, -4.24290895e-01f, 3.19271505e-01f, 6.66293681e-01f, 2.74537094e-02f, 4.81719039e-02f,
  1.36995027e-02f, -3.11992228e-01f, -7.16542959e-01f, -2.16294959e-01f, -4.60310802e-02f, -1.55013084e-01f, -6.45685554e-01f, -9.32228148e-01f, -1.40060902e-01f, 8.02686214e-01f,
  4.05582398e-01f, 8.15556496e-02f, -3.83285210e-02f, -2.96332277e-02f, 7.34620169e-02f, -3.08161587e-01f, -6.47602618e-01f, -4.39894557e-01f, -3.12337577e-01f, -7.82315254e-01f,
  -1.75558269e-01f, -5.97979128e-01f, -1.81636095e-01f, -1.31942168e-01f, 8.28877673e-04f, 4.37172968e-03f, 1.69798136e-02f, -2.61274129e-01f, -1.64775867e-02f, -2.01494411e-01f,
  -2.66694248e-01f, 5.05405106e-02f, -2.43953660e-01f, -9.45267156e-02f, 6.85027391e-02f, -7.34581947e-02f, -2.63289839e-01f, -2.68559992e-01f, -3.93550485e-01f, -2.17346810e-02f,
  -6.40871972e-02f, -5.72713852e-01f, -6.15159988e-01f, -1.31804109e-01f, -2.61472970e-01f, -6.94408178e-01f, 9.80657488e-02f, -1.70878008e-01f, -6.02918088e-01f, 3.86643529e-01f,
  2.36599207e-01f, -5.30555695e-02f, 1.17845563e-02f, 4.15287726e-02f, 3.24106574e-01f, -1.35415286e-01f, -7.67992884e-02f, 1.23980865e-01f, -1.13271721e-01f, 6.48966879e-02f,
  7.17290640e-02f, 3.81724164e-02f, 6.35165572e-02f, -6.51570410e-02f, -2.19944179e-01f, -2.76635081e-01f, -5.79587892e-02f, 1.98250502e-01f, -7.91458935e-02f, -2.17357516e-01f,
  1.36167511e-01f, 2.73900386e-02f, -1.40635356e-01f, 3.49847376e-01f, -2.00094074e-01f, 1.33600021e-02f, -1.40430396e-02f, 1.79512560e-01f, -1.50296763e-02f, -2.17353046e-01f,
  4.85043198e-01f, -6.49073303e-01f, 1.42292008e-01f, 2.09563836e-01f, -1.09982938e-01f, 1.40778810e-01f, -2.18732327e-01f, 2.69119620e-01f, -1.49038032e-01f, 1.24795415e-01f,
  -2.00921874e-02f, 2.10074767e-01f, -1.84166983e-01f, 1.33906856e-01f, 7.60419816e-02f, -7.98605755e-02f, 1.08001739e-01f, -7.51440302e-02f, 8.82617831e-02f, 3.01984161e-01f,
  1.43328294e-01f, 9.39241052e-03f, 2.85089731e-01f, 1.31010965e-01f, 1.61529645e-01f, -1.43188968e-01f, 1.59673080e-01f, 5.06161392e-01f, -2.44808406e-01f, 1.07831037e+00f,
  6.61600055e-03f, -3.41586083e-01f, 2.05943227e-01f, 2.63012558e-01f, 4.23371345e-02f, -2.35004976e-01f, -3.41671795e-01f, -2.53742516e-01f, -1.18157333e-02f, 1.79132983e-01f,
  4.28550452e-01f, 5.56254089e-01f, 6.22842431e-01f, 4.30158973e-01f, 6.50002137e-02f, -1.63446277e-01f, -6.11198694e-02f, 1.68472260e-01f, 1.33434996e-01f, 4.79981937e-02f,
  -3.76040488e-02f, -1.25853688e-01f, -5.33605367e-02f, 8.69497210e-02f, 1.49832472e-01f, 3.81192565e-01f, -4.40527406e-03f, -1.07398525e-01f, 1.52498633e-02f, 1.24902405e-01f,
  5.14346063e-01f, -6.44635111e-02f, 2.61232555e-01f, 1.61444470e-01f, 7.77219608e-03f, -6.54353276e-02f, 4.43388596e-02f, -5.96767515e-02f, -1.05448931e-01f, -1.15806207e-01f,
  -1.92827266e-02f, 8.63292627e-03f, 1.28422920e-02f, -3.22689749e-02f, -1.17558815e-01f, -1.17586285e-01f, -2.23614514e-01f, -4.46933582e-02f, -3.75791155e-02f, 2.74928659e-02f,
  4.39444482e-02f, 4.40205522e-02f, 7.94845261e-03f, 9.11512747e-02f, 3.75889614e-02f, 1.04533553e-01f, 8.08576718e-02f, 6.04896508e-02f, 1.22936167e-01f, -7.23899156e-02f,
  2.36139849e-01f, 2.94144034e-01f, 3.51365715e-01f, 8.62963870e-02f, 7.77079388e-02f, 5.05029224e-02f, -3.01804785e-02f, -1.09265357e-01f, 1.55781470e-02f, -1.02094539e-01f,
  -3.88938189e-02f, 1.41274750e-01f, -7.32839108e-02f, -3.41528878e-02f, 2.97365487e-01f, 8.57013166e-02f, -2.23199073e-02f, 1.73581913e-02f, 1.21033736e-01f, 7.25437775e-02f,
  -1.55753065e-02f, -1.46299124e-01f, 1.24723939e-02f, -2.46533900e-02f, -7.90541619e-02f, 1.22804381e-01f, 1.23613793e-02f, -5.74266501e-02f, 3.99001986e-02f, -7.54604042e-02f,
  3.60377282e-02f, 2.61313140e-01f, 2.22990394e-01f, -1.01594232e-01f, -1.27382711e-01f, -9.53043252e-02f, 1.67910501e-01f, -1.58048123e-01f, -1.75172046e-01f, -2.25008458e-01f,
  -1.70813743e-02f, -3.43664289e-02f, -1.51040414e-02f, -7.82749057e-02f, 2.49376241e-02f, -4.90797050e-02f, -5.66976182e-02f, -5.31189889e-02f, -4.63248119e-02f, -5.47328293e-02f,
  -1.68497354e-01f, -1.50000781e-01f, 1.73935622e-01f, 9.88704264e-02f, -3.33864568e-03f, 2.24739864e-01f, 1.87922120e-01f, -4.69880253e-02f, 4.94914763e-02f, -3.95457819e-02f,
  1.06868315e+00f, -6.38861716e-01f, -6.81436718e-01f, -1.33082867e-01f, -3.25534374e-01f, -5.26049957e-02f, -1.39980018e-01f, 2.28860453e-02f, 8.16095844e-02f, -1.98269650e-01f,
  6.53048009e-02f, 4.57467377e-01f, 2.73097962e-01f, 2.16801018e-01f, 2.31976703e-01f, -2.91233987e-01f, -5.09166181e-01f, 3.75782959e-02f, 6.61411107e-01f, 3.73606414e-01f,
  1.43818691e-01f, 3.29058506e-02f, 3.26407880e-01f, -2.37669218e-02f, -4.47411805e-01f, 7.40905777e-02f, -5.11512458e-01f, -2.93274194e-01f, -3.83931160e-01f, -6.91633940e-01f,
  -1.73002899e-01f, 8.76468197e-02f, 1.06419913e-01f, 1.32041737e-01f, -6.90205023e-02f, 1.10866040e-01f, 2.58749984e-02f, -1.05053164e-01f, -1.18261238e-03f, 4.53060940e-02f,
  -1.04509152e-01f, 1.73533559e-02f, 4.74392474e-02f, -8.30274727e-03f, -5.93365170e-02f, 7.90766627e-02f, 5.10885343e-02f, 3.40048373e-02f, -4.26733829e-02f, -2.04867870e-01f,
  -1.21441416e-01f, 9.69588477e-03f, -4.78384607e-02f, 7.85731971e-02f, 4.38275337e-02f, 1.55223414e-01f, -5.41918271e-04f, 9.32872389e-03f, -6.27529714e-03f, 1.06280304e-01f,
  -6.59692958e-02f, 3.10475603e-02f, 3.26562859e-02f, 6.91089481e-02f, 2.03805372e-01f, 1.13898374e-01f, 2.51446362e-03f, 1.80518061e-01f, 1.87250257e-01f, 5.37883565e-02f,
  -3.63902859e-02f, -1.10100903e-01f, 1.98249463e-02f, 4.38721552e-02f, -2.80670393e-02f, -1.07766286e-01f, 6.40222058e-03f, 3.06305587e-02f, 1.56338699e-02f, -1.68383550e-02f,
  8.32534805e-02f, -7.82292783e-02f, -1.09511755e-01f, -1.40387386e-01f, -1.57680035e-01f, -1.04679428e-01f, -4.44076210e-02f, -8.50390345e-02f, 2.33512409e-02f, -1.46833301e-01f,
  3.08282375e-02f, 1.48632109e-01f, 1.49285316e-01f, 1.28758281e-01f, -1.84839815e-01f, -2.02569887e-01f, 2.01019179e-02f, -7.37476051e-02f, -1.40981391e-01f, -6.02789931e-02f,
  7.58943195e-03f, 5.72911017e-02f, -8.67261887e-02f, 7.00050369e-02f, 2.11085677e-01f, 7.70697594e-02f, 1.32959917e-01f, 1.62936689e-03f, -1.05826639e-01f, -2.91752011e-01f,
  -1.99872062e-01f, 1.04130045e-01f, 1.44006684e-01f, 1.38519421e-01f, 1.16120815e-01f, 2.65786499e-01f, 8.05644095e-02f, 7.49580562e-02f, 5.02017625e-02f, 1.78602964e-01f,
  3.29765379e-01f, 4.70807433e-01f, 1.36809021e-01f, 4.48809057e-01f, 5.09288847e-01f, 5.50463319e-01f, 7.76202679e-01f, 5.21215022e-01f, 2.44619936e-01f, 4.33182359e-01f,
  4.35492933e-01f, 1.80018008e-01f, 1.05668046e-01f, 8.54187533e-02f, 1.71987116e-01f, 2.33443618e-01f, -1.48892598e-02f, -2.86050856e-01f, -9.40464064e-03f, 1.32859439e-01f,
  1.47446737e-01f, 1.42759919e-01f, 2.18802206e-02f, -6.12741336e-03f, -1.07089495e-02f, -1.08980365e-01f, 1.72985733e-01f, 3.39752555e-01f, 1.26484975e-01f, -4.51606542e-01f,
  -3.25529724e-01f, 2.00917181e-02f, -2.07486287e-01f, -2.03003198e-01f, -4.56648953e-02f, -9.92325619e-02f, -3.74898240e-02f, 2.47586221e-02f, -5.64596988e-02f, -9.91516262e-02f,
  -7.38148913e-02f, -1.40876651e-01f, 1.55775333e-02f, -1.78298634e-02f, -2.45460663e-02f, 1.03252279e-02f, 2.36244518e-02f, 2.68021673e-02f, 1.11968040e-01f, -2.55965926e-02f,
  -7.23463390e-03f, 1.53971136e-01f, 7.79048055e-02f, 1.10346489e-02f, -9.12070274e-02f, -8.88740569e-02f, -2.34682579e-02f, -7.78022930e-02f, -1.56140700e-01f, -3.40799242e-02f,
  3.79216857e-02f, 5.10498472e-02f, 3.83477323e-02f, 8.78347829e-02f, 8.91984180e-02f, 6.32820055e-02f, 1.91311479e-01f, 2.52044648e-01f, 1.05937928e-01f, 3.71305905e-02f,
  -2.94310320e-02f, -3.63414958e-02f, 1.74624637e-01f, 1.04640566e-01f, -4.98682633e-02f, 5.30452244e-02f, -3.24603580e-02f, -4.08166870e-02f, -7.07453769e-03f, -3.99224944e-02f,
  -9.32620093e-03f, 2.68444559e-03f, -5.34792542e-02f, -6.62676245e-02f, 2.60607321e-02f, -7.09909722e-02f, -1.07134834e-01f, -5.00545651e-02f, 1.00408673e-01f, -9.21335295e-02f,
  3.21861058e-01f, -1.04265153e-01f, -3.95209789e-01f, -1.60652593e-01f, -1.78316946e-03f, -7.22780377e-02f, -8.10617115e-03f, -2.61858106e-02f, 5.77829918e-03f, -4.95989397e-02f,
  8.03014934e-02f, -1.37894869e-01f, 6.07635677e-02f, -4.35389904e-03f, -3.35248448e-02f, 2.27825735e-02f, 2.03131378e-01f, 1.55153364e-01f, 9.86908302e-02f, 7.27114230e-02f,
  1.20613193e-02f, 1.33389533e-01f, 1.58296525e-01f, -3.90837267e-02f, -2.01680581e-03f, -1.07863963e-01f, -1.06159583e-01f, -8.19391608e-02f, 7.41413534e-02f, 1.02659754e-01f,
  -1.20657337e+00f, -8.52179587e-01f, 4.31257337e-01f, -7.49223530e-02f, 3.47102255e-01f, 2.95440972e-01f, -2.39631999e-02f, -1.31906196e-01f, -1.94164544e-01f, -3.01216125e-01f,
  -3.61955106e-01f, -2.05423519e-01f, -2.11387835e-02f, 1.07798003e-01f, 4.40360270e-02f, 1.71259880e-01f, 5.06994009e-01f, 5.07331908e-01f, 5.04798651e-01f, 1.23452716e-01f,
  4.51439470e-02f, -1.08262803e-02f, -1.47750676e-02f, 9.26952213e-02f, -1.05130427e-01f, 2.31158599e-01f, 1.59636050e-01f, 8.69399160e-02f, 5.88109232e-02f, 6.98601231e-02f,
  3.11811566e-01f, -5.98500013e-01f, 2.39211470e-01f, -1.93842247e-01f, -8.88462439e-02f, -3.00264686e-01f, -8.39103758e-02f, -1.07160755e-01f, -2.07781985e-01f, -1.50479274e-02f,
  7.85442162e-03f, -1.00520767e-01f, -3.19986977e-02f, 2.37190835e-02f, -3.48785706e-02f, 1.32937310e-02f, -1.66409716e-01f, 1.56505201e-02f, -3.65961790e-02f, -1.28758386e-01f,
  2.41299928e-03f, 2.61048432e-02f, 1.81174994e-01f, 9.61118639e-02f, -3.63077559e-02f, 9.06414241e-02f, -1.37749031e-01f, -9.90368426e-02f, 1.84753891e-02f, -2.39945441e-01f,
  9.56812203e-02f, -7.35840425e-02f, -1.17891163e-01f, 6.54717684e-02f, 5.09792268e-02f, 4.62314710e-02f, 9.63289589e-02f, 1.30864531e-02f, 8.21154192e-02f, -2.83715148e-02f,
  1.27308771e-01f, 1.41807184e-01f, -1.62576954e-03f, -5.36205471e-02f, -1.47090703e-01f, -1.24678180e-01f, -2.65976582e-02f, -1.34619057e-01f, -6.83292598e-02f, -1.01729736e-01f,
  8.82621482e-03f, 9.37486887e-02f, -7.74685517e-02f, -3.28807123e-02f, 2.02849172e-02f, -4.07602265e-02f, -1.53536871e-02f, -8.26836005e-02f, -1.26920855e-02f, -7.38634868e-03f,
  2.07001820e-01f, 2.55796224e-01f, 1.60040576e-02f, -1.13251239e-01f, -3.22568528e-02f, -1.47275031e-01f, 1.70988627e-02f, -4.53063287e-02f, -4.85379994e-02f, 7.73038119e-02f,
  -1.26039600e-02f, 3.57477777e-02f, -2.75327396e-02f, 3.18066552e-02f, 2.04424560e-01f, 7.10718036e-02f, -1.94118142e-01f, 8.10411014e-03f, 7.18487427e-02f, -1.60213690e-02f,
  -1.46520466e-01f, 8.51869509e-02f, 2.05349401e-01f, 2.66493022e-01f, 4.06653546e-02f, 2.92377174e-01f, 2.85720915e-01f, 1.86559051e-01f, 1.26129061e-01f, 1.87023759e-01f,
  3.04117262e-01f, -7.29068696e-01f, -4.86120462e-01f, -4.09410119e-01f, -7.03679144e-01f, -5.46908498e-01f, -1.09905231e+00f, -1.22558691e-01f, 2.46029451e-01f, -8.08412015e-01f,
  -4.77937818e-01f, 2.38931164e-01f, 4.71577346e-01f, 5.79902418e-02f, -2.06035241e-01f, -8.85347128e-01f, -6.40910625e-01f, -3.38646054e-01f, -4.92861748e-01f, -9.83076811e-01f,
  -7.83613682e-01f, -5.29291689e-01f, -2.64624000e-01f, -1.16038345e-01f, -1.71021342e-01f, 9.75891948e-02f, -3.68737131e-02f, -2.02840641e-01f, -2.25817427e-01f, -1.80293456e-01f,
  -4.71443474e-01f, 3.62470657e-01f, 8.14846084e-02f, 2.51720279e-01f, -2.03721285e-01f, 3.24782163e-01f, -1.57299727e-01f, 3.75767797e-01f, 2.00480193e-01f, 5.89037091e-02f,
  1.21658735e-01f, -1.64710179e-01f, 3.15501153e-01f, -7.05651715e-02f, -4.02237296e-01f, -1.34370148e-01f, -4.16479595e-02f, -2.25822181e-01f, 1.33630753e-01f, -3.21088672e-01f,
  -6.22092128e-01f, -2.97552735e-01f, 1.91712007e-01f, 9.09520611e-02f, 3.56255949e-01f, 3.06160618e-02f, -1.96072869e-02f, 1.43937200e-01f, 1.95573717e-01f, -9.62541327e-02f,
  -3.62196743e-01f, 1.89530373e-01f, -2.01023906e-01f, 3.34877744e-02f, 9.88953840e-03f, 1.98800061e-02f, 1.68677494e-01f, 8.37928131e-02f, 9.29938108e-02f, -1.68411300e-01f,
  -2.07303047e-01f, -1.23275362e-01f, 6.19688444e-02f, 1.26584783e-01f, 1.08562924e-01f, -8.85844380e-02f, 1.54742934e-02f, -1.17169902e-01f, 1.78593770e-02f, -6.07327186e-02f,
  -1.11502998e-01f, 3.89740840e-02f, -3.72277908e-02f, 6.01928390e-04f, -7.23422468e-02f, -5.47741093e-02f, 4.04036418e-02f, -1.09628923e-01f, 6.58961758e-02f, -8.48648548e-02f,
  1.54500157e-01f, 2.32082736e-02f, 2.64812738e-01f, 3.76117200e-01f, -1.75668538e-01f, -5.73338009e-02f, 1.34070769e-01f, 2.92606391e-02f, 3.24102610e-01f, -3.38872403e-01f,
  -3.34419847e-01f, -1.50996059e-01f, 4.51995358e-02f, -1.07912801e-01f, -1.91263676e-01f, -1.12377465e-01f, -3.83555144e-01f, -2.87000895e-01f, -4.38287593e-02f, -2.55801439e-01f,
  -3.07704598e-01f, -2.18063012e-01f, 2.48988271e-02f, 7.26178735e-02f, 2.40338594e-02f, 2.76365787e-01f, 9.99278389e-03f, -1.50093794e-01f, 1.05308026e-01f, -4.76854175e-01f,
  -1.11757076e+00f, -3.18755299e-01f, 6.43511057e-01f, -4.77127701e-01f, 4.64171320e-01f, 4.47880328e-01f, -1.91964567e-01f, 2.66652051e-02f, 8.45249519e-02f, -2.87362546e-01f,
  2.04459578e-01f, -8.73117968e-02f, -1.99685171e-01f, -3.59293610e-01f, -6.35333121e-01f, -5.97758830e-01f, -2.81962603e-01f, -2.02046528e-01f, 4.37160581e-02f, -6.60158694e-02f,
  -1.93803504e-01f, -1.84063748e-01f, -7.38965943e-02f, -1.39206126e-01f, -4.14206177e-01f, -2.79382974e-01f, 1.04595505e-01f, -2.41760731e-01f, -2.15385690e-01f, -5.84203124e-01f,
  -3.47557694e-01f, 1.74651012e-01f, 4.67400610e-01f, -1.95816994e-01f, 2.49529675e-01f, -2.29403093e-01f, -8.55718181e-02f, 1.11348614e-01f, 3.34253833e-02f, -1.07299171e-01f,
  -6.25374317e-02f, -3.64676900e-02f, 5.36102708e-03f, 1.94744393e-01f, -2.51495913e-02f, -9.91719365e-02f, 1.93702608e-01f, 9.99980420e-02f, 2.40621254e-01f, 2.52889872e-01f,
  -2.73095459e-01f, -6.11564070e-02f, -2.32451305e-01f, 2.32062370e-01f, 1.25290886e-01f, -8.02886114e-03f, 3.07294339e-01f, -2.01862052e-01f, 7.47856274e-02f, -8.60365093e-01f,
  -1.42447148e-02f, 8.80551562e-02f, 3.40727240e-01f, 6.99052438e-02f, -1.81818292e-01f, 5.29230610e-02f, -2.55103230e-01f, -1.92247972e-01f, 1.20789528e-01f, -1.23367116e-01f,
  2.89072186e-01f, 8.07813853e-02f, 1.53279498e-01f, -2.29083017e-01f, -2.44770184e-01f, -5.59367388e-02f, -2.48416021e-01f, -2.43126079e-01f, -3.32069308e-01f, -2.32214350e-02f,
  -1.13872096e-01f, -4.00333339e-03f, -4.30522151e-02f, -3.46900150e-02f, 9.96447951e-02f, -4.88176085e-02f, 1.56479359e-01f, 2.69006908e-01f, 3.07663381e-01f, 6.42347336e-02f,
  -2.69779384e-01f, 3.39811414e-01f, -5.24655938e-01f, -1.47301123e-01f, -1.35517791e-01f, 1.54457614e-01f, -4.62544942e-03f, 9.38037038e-02f, -1.96484625e-02f, -1.24173574e-01f,
  2.10861340e-01f, -9.44313779e-02f, -8.18644688e-02f, 2.33545125e-01f, -2.26494372e-02f, -5.01454957e-02f, -3.71485144e-01f, -1.77632540e-01f, 5.68962749e-03f, 1.35560244e-01f,
  -1.24946371e-01f, -5.15450954e-01f, -9.55302715e-01f, -3.65307033e-01f, -3.64386827e-01f, -6.29146993e-01f, -5.26646912e-01f, -2.64876246e-01f, -6.01199269e-01f, -1.04989755e+00f,
  1.08971429e+00f, -3.31969798e-01f, -5.41010618e-01f, 4.67400372e-01f, 1.37788475e-01f, 1.04018591e-01f, 1.56805385e-02f, 1.98442459e-01f, 2.58142412e-01f, 1.56889752e-01f,
  -2.55068034e-01f, -5.59701957e-02f, -1.70270190e-01f, -7.29259253e-02f, -7.34966947e-03f, 1.80894639e-02f, 3.61644626e-02f, -4.60110269e-02f, 1.02012716e-01f, 1.41633481e-01f,
  1.85048208e-01f, 1.80203855e-01f, 9.92328748e-02f, -7.12906718e-02f, -2.10140154e-01f, 1.12984888e-01f, -2.17438743e-01f, -2.58390963e-01f, -2.81914890e-01f, -2.10189253e-01f,
  -6.21226311e-01f, -5.39568305e-01f, 1.73329990e-02f, 7.61451423e-02f, -1.13590971e-01f, -1.27499253e-02f, 1.10524535e-01f, -1.02943681e-01f, 7.58905709e-02f, 8.63459334e-02f,
  -5.39632142e-02f, -5.89228682e-02f, -1.41576767e-01f, -1.72217697e-01f, -2.63413284e-02f, -6.65356964e-02f, -2.04031721e-01f, -1.75361112e-01f, 1.75164896e-03f, -1.39796183e-01f,
  -8.62095803e-02f, -5.66947572e-02f, -1.00248270e-01f, 1.19178109e-01f, 2.96930373e-02f, 1.06717214e-01f, -2.50841498e-01f, -1.51085645e-01f, -1.09322004e-01f, 6.70151338e-02f,
  9.91531312e-02f, 1.01339541e-01f, -1.64134186e-02f, -6.45829365e-02f, 1.04364604e-01f, 1.61832631e-01f, 3.62808891e-02f, -3.31043899e-02f, 8.71665105e-02f, -9.50523242e-02f,
  6.09456329e-03f, 9.99337211e-02f, 3.73325571e-02f, 7.16396347e-02f, -4.12267633e-02f, -3.45751606e-02f, 2.69159339e-02f, -1.39538258e-01f, -6.93765432e-02f, 7.70376399e-02f,
  1.03591874e-01f, 6.09345771e-02f, 4.24600486e-03f, -1.02797166e-01f, -1.29160568e-01f, -1.25635922e-01f, -2.72062477e-02f, -1.14976779e-01f, 2.04996280e-02f, 1.07797258e-01f,
  5.47473840e-02f, -1.18406489e-01f, 1.53396502e-01f, -8.68978128e-02f, -6.25204667e-02f, -1.04184501e-01f, -1.18229352e-01f, -1.30769119e-01f, 6.96365386e-02f, -7.62059470e-04f,
  -2.39290535e-01f, -9.13254842e-02f, -1.59900814e-01f, 5.34667857e-02f, 1.84889615e-01f, 3.48972231e-02f, 7.84428790e-02f, -2.86165550e-02f, 1.13058671e-01f, -1.90769359e-02f,
  1.29627272e-01f, 3.39303970e-01f, 4.09529984e-01f, 2.06487030e-01f, 1.37275741e-01f, 2.91162759e-01f, 8.05952102e-02f, 1.16109118e-01f, 2.56385863e-01f, 5.31497419e-01f,
  4.21560079e-01f, 5.49375415e-01f, 1.16597734e-01f, 2.95238465e-01f, -2.85801589e-01f, -2.02097535e-01f, 1.77818034e-02f, 3.66096109e-01f, 3.41302395e-01f, 2.01140448e-01f,
  -6.05482273e-02f, 1.63241819e-01f, 3.14651757e-01f, 2.63003320e-01f, 4.28061664e-01f, 5.19550622e-01f, 4.34150159e-01f, 3.38816524e-01f, 1.38321966e-02f, -3.14563289e-02f,
  2.85818517e-01f, 3.09242040e-01f, 2.81736910e-01f, 3.01123738e-01f, 2.05586627e-01f, 2.40671039e-01f, 1.82125822e-01f, -4.91262786e-03f, 1.58176437e-01f, 6.85303032e-01f,
  -1.77147925e-01f, -1.03049263e-01f, 1.49532288e-01f, 7.59818256e-02f, -1.57881126e-01f, 1.51035011e-01f, 5.55452667e-02f, 2.33485829e-02f, -5.78884035e-02f, -1.06422193e-01f,
  -1.02171311e-02f, -7.57431686e-02f, -1.76809449e-02f, -6.39997274e-02f, -2.61425883e-01f, -2.39508972e-01f, -2.80657709e-02f, 1.08878696e-02f, 1.19181633e-01f, -3.92540321e-02f,
  -1.30427033e-01f, -2.63980955e-01f, -3.38939667e-01f, -2.40373641e-01f, -4.14191857e-02f, -9.54289138e-02f, -1.99188367e-01f, -1.19129658e-01f, -1.27897218e-01f, 1.92367323e-02f,
  4.26382832e-02f, 8.44636336e-02f, -2.93187820e-03f, -6.40482828e-02f, -1.49394199e-01f, -1.67294696e-01f, -1.11861482e-01f, -1.05082810e-01f, -4.00284417e-02f, -3.80861685e-02f,
  -2.11950496e-01f, -3.17106806e-02f, -8.43381286e-02f, -8.68059918e-02f, -5.22302873e-02f, 6.56457916e-02f, -7.95803666e-02f, -1.92865923e-01f, -3.49425793e-01f, -2.09761951e-02f,
  -5.90636283e-02f, -5.27646169e-02f, -1.44276276e-01f, -3.11632734e-02f, -1.98598895e-02f, -1.14408448e-01f, -3.62141989e-02f, -4.76775914e-02f, -2.74759606e-02f, 4.41866890e-02f,
  2.53045559e-01f, -3.25989842e-01f, 1.90179363e-01f, 3.23212296e-01f, 4.14953902e-02f, -2.86867172e-02f, 5.12902476e-02f, -6.69013187e-02f, -4.55682501e-02f, 9.72640235e-03f,
  2.99108890e-03f, 9.85204577e-02f, 2.86712777e-02f, 2.79134009e-02f, -1.08342260e-01f, -2.45116368e-01f, 6.62818104e-02f, 1.46207899e-01f, 1.75210789e-01f, 1.44395277e-01f,
  2.32131928e-01f, -7.96309412e-02f, -4.27898578e-02f, -1.08848065e-01f, 7.42455497e-02f, 1.41770886e-02f, -2.86067963e-01f, -1.13087043e-01f, -1.16305642e-01f, -7.22194314e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  5.21997571e-01f, 6.25746191e-01f, 7.73621261e-01f, 1.04970014e+00f, 7.53795743e-01f, 5.85490286e-01f, 7.02385426e-01f, 6.27301276e-01f, 7.54104197e-01f, 1.25365353e+00f,
  1.92049190e-01f, 3.74420017e-01f, 1.00724614e+00f, 3.80018860e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -2.05629811e-01f, -2.17983872e-01f, -2.00467467e-01f, -1.15406431e-01f, -5.11279404e-02f, -4.09427404e-01f, -5.91178119e-01f, -5.90666652e-01f, 3.03375155e-01f, 2.11471170e-01f,
  4.13072184e-02f, 5.50194085e-02f, -3.85386229e-01f, -2.74243712e-01f, -1.63184419e-01f, 2.95108967e-02f, -9.98105928e-02f, -2.62797922e-01f, -9.46720302e-01f, 5.59668392e-02f,
  -2.08398506e-01f, -6.02293909e-01f, -5.61900213e-02f, -3.15730572e-01f, -1.32773921e-01f, 2.74291052e-03f, 1.48123890e-01f, 4.30247694e-01f, 9.63480920e-02f, 2.22289547e-01f,
  8.15212578e-02f, -3.93194675e-01f, -9.01926756e-02f, -5.28013766e-01f, -4.18481231e-01f, -5.04092097e-01f, 8.39799345e-01f, -5.82334697e-01f, -4.84617233e-01f, -1.24961041e-01f,
  -1.65648088e-01f, 3.00172091e-01f, -2.97797203e-01f, 1.67729020e-01f, -2.35044226e-01f, -1.74432501e-01f, 6.22624218e-01f, -3.26158442e-02f, 1.84569761e-01f, -2.59763747e-01f,
  -1.90398470e-01f, -4.28733021e-01f, 1.54993087e-01f, -6.04757071e-01f, -5.93359321e-02f, 5.82278967e-01f, -1.98827088e-01f, 6.57340050e-01f, -3.57435733e-01f, -6.22650325e-01f,
  3.52622755e-02f, 2.98601687e-01f, -5.52931964e-01f, -2.12279394e-01f, -7.33883083e-02f, -3.21037501e-01f, 8.78782719e-02f, -4.00722325e-01f, 3.16372551e-02f, 2.15557411e-01f,
  -3.52949947e-01f, -1.89048320e-03f, -4.63619113e-01f, 1.07411966e-01f, 5.60931582e-03f, -1.16910860e-02f, 6.43506274e-02f, 2.00878754e-01f, 1.50834814e-01f, -2.89282687e-02f,
  6.43526018e-02f, -1.47659123e-01f, -2.34038413e-01f, 8.56057480e-02f, 1.64818719e-01f, -5.31929910e-01f, 1.18044108e-01f, 1.29500240e-01f, 1.86998665e-01f, -2.06991524e-01f,
  4.70642895e-02f, -1.72628865e-01f, -3.51177752e-01f, 4.58001316e-01f, -3.43714029e-01f, -5.03636539e-01f, -4.10891742e-01f, -3.52263749e-01f, -1.62031293e-01f, -6.71746731e-01f,
  6.05058730e-01f, -1.46618262e-01f, 1.60949454e-01f, 2.39890710e-01f, -8.32378864e-02f, -2.28872463e-01f, 3.42366397e-01f, -1.16388651e-03f, -1.83279172e-01f, -1.11561857e-01f,
  6.10862672e-01f, -8.20942968e-02f, -3.05350363e-01f, 1.91778064e-01f, 3.63984793e-01f, -5.11880457e-01f, -3.67731631e-01f, 4.38355595e-01f, -1.53172636e+00f, -4.93124604e-01f,
  2.22084910e-01f, 4.92203474e-01f, 1.43569568e-02f, -3.33489746e-01f, 8.98268223e-01f, -9.25751090e-01f, 3.57608080e-01f, 2.83905007e-02f, 2.66239107e-01f, 3.81784409e-01f,
  5.97118028e-02f, 2.69761473e-01f, 4.52929325e-02f, 1.62034675e-01f, 2.72022665e-01f, 2.86352873e-01f, 1.80147141e-01f, 4.45228457e-01f, 1.06239609e-01f, -1.26531705e-01f,
  9.71079171e-02f, -8.71824026e-02f, 1.54106572e-01f, 6.14463054e-02f, 1.34978928e-02f, 1.95440635e-01f, 1.98785752e-01f, 2.25683562e-02f, -1.79200694e-01f, -2.80842245e-01f,
  6.26354851e-03f, 3.08022857e-01f, 4.71558049e-02f, 3.49584281e-01f, -4.76049334e-02f, -2.48583466e-01f, -1.92844614e-01f, -1.78730667e-01f, -8.10974717e-01f, 4.19798404e-01f,
  -2.07186833e-01f, 1.61094859e-01f, 1.07331306e-01f, -5.99049449e-01f, 7.73608625e-01f, -2.79666632e-01f, 1.21048845e-01f, -5.68674095e-02f, 4.63860810e-01f, -6.66755736e-01f,
  2.63108999e-01f, -3.93676490e-01f, -2.50338376e-01f, 7.27690935e-01f, 5.86372375e-01f, -4.35760707e-01f, 1.71108216e-01f, -5.48665881e-01f, -5.16378999e-01f, -7.40756452e-01f,
  -6.60626233e-01f, -8.02502632e-01f, 6.38222218e-01f, -1.43340874e+00f, 4.52507854e-01f, 1.66232139e-01f, -9.02480364e-01f, 3.33608925e-01f, -3.50717098e-01f, 5.80484569e-01f,
  -4.16392893e-01f, 8.18707887e-03f, -4.18559909e-01f, -2.11037159e-01f, -1.50047123e-01f, -2.26004254e-02f, -3.28049690e-01f, -8.67649078e-01f, -1.53424025e-01f, -2.75346458e-01f,
  -8.18854988e-01f, 4.00450408e-01f, -1.82440057e-02f, -1.86145455e-02f, -8.84952545e-02f, -6.27415106e-02f, 1.51651308e-01f, -2.21028805e-01f, -6.75886869e-02f, -1.69632718e-01f,
  5.37690520e-01f, -2.23940387e-01f, -1.10604011e-01f, -3.78859580e-01f, -4.72223721e-02f, 1.44246474e-01f, 1.09642975e-01f, -2.10780025e-01f, 8.09006542e-02f, 1.07457362e-01f,
  3.18584144e-01f, -1.78813145e-01f, -2.12392896e-01f, 9.57181633e-01f, -2.13909019e-02f, 1.10114597e-01f, -4.80769515e-01f, -7.34623671e-01f, 5.74007750e-01f, -3.32383960e-01f,
  8.42676461e-02f, 6.73091233e-01f, 6.52744249e-02f, 2.17745807e-02f, -2.13897899e-01f, 3.88675988e-01f, 8.59184802e-01f, -1.91862419e-01f, -8.27731311e-01f, 1.44737333e-01f,
  2.75921393e-02f, 1.51983309e+00f, -6.92740321e-01f, 5.45046031e-01f, -2.04388291e-01f, 1.09917784e+00f, 4.00084943e-01f, -1.02606960e-01f, -8.84475589e-01f, -1.07393527e+00f,
  -1.11205673e+00f, -7.08756177e-03f, -1.95306554e-01f, 3.19435894e-01f, -8.28690678e-02f, -8.55856836e-01f, 3.29961360e-01f, 1.59333840e-01f, 1.80712402e-01f, -1.38168335e-01f,
  -1.02288648e-01f, 3.49516004e-01f, 1.56405881e-01f, 1.59797490e-01f, -7.47249946e-02f, -7.02197969e-01f, -9.35338587e-02f, -3.09420735e-01f, 1.67391628e-01f, -1.41765982e-01f,
  -2.74032921e-01f, 8.18113014e-02f, -3.58566195e-02f, 1.66058749e-01f, 4.30484682e-01f, 2.53668129e-01f, 1.60924857e-03f, 3.61274660e-01f, -1.01513065e-01f, -2.74631709e-01f,
  -7.20840022e-02f, 2.80746311e-01f, -5.98772049e-01f, -1.41517699e-01f, 7.35362247e-02f, 2.34774023e-01f, -1.28961787e-01f, -2.51030713e-01f, -1.88176081e-01f, 5.76649308e-01f,
  7.09444165e-01f, 5.05638838e-01f, -8.39375675e-01f, 3.26536506e-01f, -1.97280809e-01f, -4.72013712e-01f, -2.98990428e-01f, -6.96750805e-02f, -7.94860944e-02f, -6.83733582e-01f,
  5.83344437e-02f, -2.19762838e-03f, -2.92694509e-01f, 1.25903087e-02f, -2.89147478e-02f, -8.26555252e-01f, -6.36236250e-01f, 5.40476143e-01f, -6.36762381e-01f, -6.15643144e-01f,
  -6.85293823e-02f, -2.60069400e-01f, 1.28008246e-01f, -8.37901056e-01f, 2.26059526e-01f, -3.79348457e-01f, 3.69254827e-01f, 3.41800481e-01f, -8.04066658e-01f, 1.42494559e-01f,
  3.43628317e-01f, 3.11717689e-01f, 7.11154118e-02f, 4.55266573e-02f, 1.86836030e-02f, -4.50976640e-02f, 3.63647819e-01f, 3.02969754e-01f, 4.16591495e-01f, 3.87333661e-01f,
  9.59393848e-03f, 1.15729846e-01f, 1.38201416e-02f, -2.19232127e-01f, 1.29331276e-01f, 2.41913013e-02f, 1.10316768e-01f, 2.99172550e-01f, -5.22743240e-02f, 2.77631879e-02f,
  1.76712558e-01f, 4.34521705e-01f, -6.26259670e-02f, -5.48146106e-02f, 3.22809130e-01f, -2.39072815e-01f, -3.77082169e-01f, 1.10555790e-01f, -4.30371970e-01f, -3.05300325e-01f,
  5.36859095e-01f, -3.49225640e-01f, -2.10589260e-01f, -4.12487358e-01f, -1.05442226e-01f, 8.93541455e-01f, -8.73633087e-01f, 2.57159561e-01f, -2.86390901e-01f, -2.99522370e-01f,
  -3.92954201e-01f, 3.91563147e-01f, -1.61010418e-02f, -2.47739539e-01f, 3.47600281e-01f, 1.54448673e-01f, 4.19131935e-01f, 2.07661957e-01f, -3.17637950e-01f, 5.70829473e-02f,
  -2.88300902e-01f, 2.01861262e-01f, 6.82779789e-01f, -8.11114788e-01f, -9.25569534e-01f, 8.21487129e-01f, -5.96995592e-01f, -1.10812254e-01f, 1.71106815e-01f, -5.60806990e-01f,
  -9.25800726e-02f, -1.00742531e+00f, 6.09946430e-01f, 1.73243403e-01f, -2.39664242e-01f, -5.64638197e-01f, -2.61224657e-01f, 4.78969961e-02f, 1.75616547e-01f, 1.21574536e-01f,
  1.47624448e-01f, -6.77879974e-02f, 4.10601795e-02f, -2.41721004e-01f, -1.33991420e-01f, 3.20812255e-01f, -7.41142631e-02f, 3.75609040e-01f, 4.84571159e-01f, 2.72979856e-01f,
  3.26119035e-01f, 2.52891004e-01f, 2.81604141e-01f, -3.39552164e-01f, 2.00580209e-01f, 2.05313936e-01f, 9.20875296e-02f, -1.56628087e-01f, -2.48905614e-01f, 2.58101285e-01f,
  1.78580105e-01f, -3.40239674e-01f, 2.25217938e-01f, -2.80871153e-01f, 4.49531615e-01f, 5.26478767e-01f, 5.89046061e-01f, 2.35658467e-01f, 1.97628081e-01f, 7.33165622e-01f,
  -1.24172801e-02f, 3.85289550e-01f, -4.48123254e-02f, 3.56855392e-01f, -7.04112649e-02f, 1.26032516e-01f, 7.20922232e-01f, 5.52171230e-01f, -4.32881564e-01f, 4.80066419e-01f,
  7.28251457e-01f, -4.22576874e-01f, 5.81633151e-01f, -5.63290715e-01f, 6.14677250e-01f, -7.81681299e-01f, -1.23020554e+00f, -2.82633722e-01f, -6.26688719e-01f, -6.05187118e-01f,
  -7.04799294e-01f, -5.55491805e-01f, -3.95817488e-01f, -1.39473093e+00f, -7.22381055e-01f, -1.11773777e+00f, -4.68309551e-01f, 5.84732592e-01f, 9.16434973e-02f, -2.70209372e-01f,
  5.57640307e-02f, -2.52715111e-01f, -4.90330979e-02f, 2.03238521e-02f, -7.74528980e-01f, -3.09478138e-02f, -6.47024587e-02f, 8.81726146e-02f, -1.55283943e-01f, -2.29213327e-01f,
  -1.12357587e-01f, -2.62009948e-01f, -1.34503335e-01f, -1.21707655e-01f, -3.58678788e-01f, -2.41397053e-01f, -5.80322742e-02f, -4.28042561e-01f, -7.72558451e-02f, -2.14540616e-01f,
  -1.73957244e-01f, -2.43546218e-02f, -9.44492593e-02f, 7.66361952e-02f, 8.53950456e-02f, 1.55916363e-01f, 2.31967598e-01f, 2.28500158e-01f, -2.05951072e-02f, 3.50011587e-01f,
  -1.05655178e-01f, 2.05625027e-01f, 7.93425143e-02f, -1.56497344e-01f, -3.48649353e-01f, 3.45476210e-01f, 3.39493275e-01f, 3.37240607e-01f, 1.50017992e-01f, 3.16536762e-02f,
  -3.05883437e-01f, 1.00780055e-01f, 6.25576675e-01f, 3.44482094e-01f, -6.94113910e-01f, 4.30910736e-01f, 6.78706914e-02f, -9.43953916e-02f, -2.58657455e-01f, -4.83228147e-01f,
  5.88851988e-01f, -3.80746841e-01f, 6.14986479e-01f, -2.66969025e-01f, 9.48555470e-02f, -1.09076238e+00f, 7.84135014e-02f, 4.20681298e-01f, -4.55950826e-01f, -2.21506193e-01f,
  -7.35183582e-02f, 1.50027275e-01f, -1.13808168e-02f, 2.20853016e-01f, 8.07868168e-02f, 2.16352403e-01f, -7.61789680e-02f, 1.37520716e-01f, 2.06449062e-01f, 1.25542209e-01f,
  9.21951979e-02f, -2.93497294e-01f, 2.79548675e-01f, -5.76794259e-02f, 3.90726067e-02f, 1.84648827e-01f, -3.65208089e-01f, 7.15700770e-03f, 8.08718652e-02f, -1.74691603e-02f,
  2.92204678e-01f, 1.40536636e-01f, -2.07321942e-01f, 9.00902450e-02f, -1.20189488e-01f, 7.97975808e-02f, -7.10129082e-01f, -2.33503446e-01f, -1.00560948e-01f, 4.26499099e-01f,
  6.46450743e-02f, -4.82644707e-01f, 5.69509685e-01f, -5.12254471e-03f, 5.20989776e-01f, -2.43007183e-01f, -2.66594052e-01f, -2.76026517e-01f, 6.25740886e-01f, -3.11259508e-01f,
  -9.73124802e-03f, 7.74369121e-01f, -1.50381327e-01f, -2.67644912e-01f, 7.39270076e-02f, 1.35059888e-02f, -5.21305501e-02f, 5.67914248e-01f, -8.43631446e-01f, -2.16313004e-01f,
  6.01272821e-01f, 4.48434234e-01f, 2.56589442e-01f, -9.69846010e-01f, -6.60793809e-03f, -5.61079144e-01f, -4.81229097e-01f, -3.61978501e-01f, -2.59131759e-01f, -8.47021192e-02f,
  4.07138281e-03f, 7.73173869e-01f, -7.99851239e-01f, -5.07816255e-01f, 8.15561175e-01f, -5.23389816e-01f, -6.68388426e-01f, 6.96996674e-02f, -6.85501918e-02f, 9.50203314e-02f,
  -3.32768083e-01f, 1.42193243e-01f, 1.72526449e-01f, 4.31499034e-02f, 1.00363530e-01f, -1.99263483e-01f, -7.60714114e-02f, 8.28465223e-02f, 5.79420403e-02f, -2.05951661e-01f,
  -4.08528864e-01f, -8.92227516e-02f, -1.52470529e-01f, 1.61824659e-01f, -1.22438418e-02f, 1.53799400e-01f, -1.72318533e-01f, 4.07777935e-01f, 1.58232987e-01f, 1.06268980e-01f,
  -5.33084087e-02f, 1.25085384e-01f, 4.11830217e-01f, -3.00549537e-01f, 1.84606209e-01f, 7.15495884e-01f, 8.48762393e-01f, -5.45672953e-01f, 5.95355581e-04f, -6.50516093e-01f,
  3.50816488e-01f, 7.50896513e-01f, -8.89181972e-01f, 4.50752109e-01f, 5.73594809e-01f, -9.19672072e-01f, 1.83069319e-01f, 7.39093363e-01f, -6.31756842e-01f, -4.75273579e-01f,
  -4.63040859e-01f, -8.71483684e-01f, 1.69387415e-01f, -3.44254784e-02f, -9.74468708e-01f, -4.03219163e-01f, 2.12362185e-01f, -8.11686635e-01f, -5.56137681e-01f, -7.37196207e-01f,
  9.30198371e-01f, -5.52564383e-01f, 2.26640999e-01f, -4.83823925e-01f, -4.89170969e-01f, 1.75459117e-01f, -3.85243237e-01f, -1.38269514e-01f, -5.81302345e-01f, 6.52461201e-02f,
  -1.43554434e-01f, -1.61211994e-02f, -4.88725342e-02f, 2.93174516e-02f, 2.07956046e-01f, -6.55595884e-02f, 1.89527452e-01f, -7.56874755e-02f, 2.03407258e-01f, -2.28202298e-01f,
  1.39528409e-01f, -4.96480092e-02f, -1.15040772e-01f, 3.33421916e-01f, 1.18999250e-01f, -1.05982505e-01f, 1.55195370e-01f, -2.31122330e-01f, 4.28128660e-01f, -1.08069733e-01f,
  -1.03203885e-01f, 8.46287608e-02f, -1.28475964e-01f, 3.28889012e-01f, -1.70209780e-02f, -1.38414428e-01f, -1.88753560e-01f, 1.83183417e-01f, 5.08096628e-02f, -1.63007140e-01f,
  -6.58537149e-01f, -1.42196745e-01f, 1.84922859e-01f, 3.40078413e-01f, -4.55357492e-01f, -5.70644438e-01f, -4.94194925e-01f, 4.48029667e-01f, 6.52864039e-01f, -5.90609908e-01f,
  2.17481285e-01f, -2.87615716e-01f, 3.10593456e-01f, 6.41050398e-01f, 3.73433501e-01f, -3.45026672e-01f, -4.26911622e-01f, -1.38150277e-02f, -3.13584417e-01f, 6.35458410e-01f,
  -4.81298327e-01f, 3.40028524e-01f, -1.50986295e-02f, -8.76817346e-01f, -8.45305502e-01f, 6.70780361e-01f, 2.49930650e-01f, -1.18421458e-01f, -6.89214110e-01f, 8.12356234e-01f,
  -2.79669344e-01f, -9.75225627e-01f, -1.11288190e+00f, -5.02992868e-01f, 4.41510044e-02f, 1.55412704e-01f, 1.81116328e-01f, 1.44960865e-01f, 1.79811537e-01f, -2.26073667e-01f,
  3.52530867e-01f, 2.10447758e-01f, 6.80224448e-02f, -9.17355865e-02f, 1.16853474e-03f, 2.93891460e-01f, 9.11958441e-02f, -2.39463806e-01f, 8.01827665e-03f, -2.25454830e-02f,
  2.93607526e-02f, 1.57572731e-01f, -4.54648525e-01f, 3.03745598e-01f, 2.87737221e-01f, 1.43375501e-01f, 1.84801057e-01f, -1.40556231e-01f, 3.30481052e-01f, -7.63983354e-02f,
  7.65720531e-02f, -2.32184380e-01f, -2.39159986e-01f, -2.94541985e-01f, 3.13707441e-01f, 3.95694710e-02f, -1.85911983e-01f, 4.61187929e-01f, 3.20873320e-01f, 4.71044898e-01f,
  5.55081010e-01f, -2.73448259e-01f, -6.24210000e-01f, 4.12433803e-01f, -2.37197295e-01f, 8.48032385e-02f, -2.39175320e-01f, 3.31435800e-01f, -1.42690986e-01f, -4.62644219e-01f,
  -5.65033615e-01f, 3.86273444e-01f, 1.99599862e-01f, 3.82789820e-01f, -3.02573502e-01f, -6.26476228e-01f, 4.72587675e-01f, 1.30823255e+00f, -1.00457191e+00f, -7.52587676e-01f,
  -7.74859309e-01f, -5.79728961e-01f, 5.38189113e-01f, -6.91733718e-01f, -3.00795168e-01f, 1.23560101e-01f, -1.21978927e+00f, -2.26562604e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  2.82676332e-02f, -2.49844879e-01f, 3.82468194e-01f, -3.91114920e-01f, 1.97852090e-01f, -1.21733159e-01f, 2.27197960e-01f, -1.69431582e-01f, -8.62998739e-02f, 2.92557567e-01f,
  -4.81979474e-02f, 3.35883230e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    