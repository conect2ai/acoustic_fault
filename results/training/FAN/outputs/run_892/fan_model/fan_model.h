/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.78337142e-01f, 1.07546616e-02f, -9.71937925e-02f, -1.59213945e-01f, -1.02909520e-01f, -5.33857383e-02f, -1.90697372e-01f, -7.13868439e-02f, 2.05654725e-02f, -1.23291910e-01f,
  7.60779157e-02f, 2.45320401e-03f, 7.88895413e-03f, -3.50599997e-02f, -1.44306749e-01f, -2.00513825e-01f, -2.14790508e-01f, -1.29648671e-01f, 4.05708654e-03f, 1.18116386e-01f,
  -1.66033451e-02f, -5.50715402e-02f, -3.96972299e-02f, 1.58657040e-02f, -2.81793717e-02f, 6.66646436e-02f, -6.57684058e-02f, -1.35216536e-02f, 1.02004543e-01f, 1.13591321e-01f,
  1.22597165e-01f, 6.57550395e-02f, -6.85555339e-02f, 8.82355198e-02f, -1.70869902e-02f, 8.38468671e-02f, 1.82210363e-03f, -4.50288616e-02f, 4.14864626e-03f, -2.81049274e-02f,
  7.70748453e-03f, -4.18683887e-02f, -9.94043872e-02f, 9.14964303e-02f, -5.51725216e-02f, 3.10128760e-02f, 1.63069217e-05f, 1.73416846e-02f, -4.19936813e-02f, 6.81881756e-02f,
  2.84980536e-02f, 3.11564151e-02f, 1.39658675e-02f, 1.07683884e-02f, 1.44262332e-02f, -1.27610723e-02f, 3.83806303e-02f, 3.85025889e-02f, -1.34934168e-02f, 4.96881045e-02f,
  -5.60645387e-02f, 8.53706151e-03f, -8.35956782e-02f, -3.70203443e-02f, -5.62579930e-02f, 6.33439329e-03f, -4.12011315e-04f, -7.68392114e-03f, -6.01771958e-02f, 5.45733348e-02f,
  1.36415642e-02f, -1.54407388e-02f, -1.92113873e-03f, 5.16730584e-02f, -3.74718979e-02f, -2.56422348e-02f, -4.32223380e-02f, -6.98120520e-02f, 4.05841172e-02f, 6.65003285e-02f,
  2.60744393e-02f, -2.60732286e-02f, 5.07463217e-02f, -2.25309152e-02f, 2.87625864e-02f, 6.79474100e-02f, -3.99137773e-02f, 3.34426053e-02f, 3.65937650e-02f, 2.31484864e-02f,
  -5.98551743e-02f, -5.06283017e-04f, -6.45447820e-02f, -5.98901510e-02f, 7.05637271e-04f, 3.87778766e-02f, -2.25023441e-02f, -3.58091071e-02f, 7.44525045e-02f, -3.21161970e-02f,
  1.29089773e-01f, 3.16396542e-02f, 6.67596459e-02f, -2.24351417e-02f, 1.86659433e-02f, 9.85679105e-02f, 3.68985571e-02f, -6.94075748e-02f, 4.46952395e-02f, 5.56917414e-02f,
  -6.78806752e-03f, -4.69755642e-02f, 3.40726180e-03f, -1.33366557e-02f, -9.08015892e-02f, 3.28426436e-02f, 6.91008344e-02f, 5.29476330e-02f, -1.20930955e-01f, -7.02523589e-02f,
  -1.19096324e-01f, -2.38451734e-01f, 5.87880462e-02f, -9.70876515e-02f, 1.06055848e-01f, 1.50196508e-01f, 5.77723235e-02f, 5.54791465e-02f, -9.78085473e-02f, -8.96621421e-02f,
  -3.70602906e-02f, -1.45672604e-01f, 3.54222092e-03f, -4.51177778e-03f, 5.09018488e-02f, -2.04276592e-02f, -3.05170361e-02f, 1.73888490e-01f, 3.43086183e-01f, 1.29167393e-01f,
  -2.16091909e-02f, 6.08175360e-02f, -7.65958130e-02f, 4.84235473e-02f, -1.48906901e-01f, 1.19679421e-01f, -1.63360294e-02f, -1.62162390e-02f, 6.45311251e-02f, -2.83160418e-01f,
  -7.70383105e-02f, -1.24826111e-01f, 1.88912570e-01f, -6.71833232e-02f, -1.31296385e-02f, 1.64775755e-02f, 7.31355418e-03f, -3.67448851e-02f, -1.56866267e-01f, -6.28690869e-02f,
  -2.63221599e-02f, -1.34987399e-01f, -7.76673779e-02f, -8.65239576e-02f, -2.84479056e-02f, -3.80128659e-02f, -1.09210424e-01f, -9.15224701e-02f, -3.14662568e-02f, -1.07892957e-02f,
  -6.78394511e-02f, 1.73096173e-02f, 5.34081236e-02f, 2.77676024e-02f, 1.12799391e-01f, 8.51160213e-02f, 7.37399235e-02f, -5.24359271e-02f, 1.53103441e-01f, -6.26387522e-02f,
  6.90708682e-02f, 6.73658252e-02f, 4.47686482e-03f, 4.63654893e-03f, 1.95430666e-02f, 1.29656075e-02f, -2.63531115e-02f, -1.44124199e-02f, 8.90948847e-02f, -7.06643835e-02f,
  3.26895304e-02f, 7.49840736e-02f, -6.96155503e-02f, -3.15857902e-02f, -5.20113148e-02f, 3.56951393e-02f, -1.07691588e-03f, -4.63709012e-02f, -4.34302427e-02f, -5.16068824e-02f,
  1.05860427e-01f, -4.11884673e-03f, -3.76148224e-02f, -2.81314310e-02f, -5.10185994e-02f, -3.42252012e-03f, -3.96630839e-02f, 5.00321761e-02f, 1.01755381e-01f, 2.13765968e-02f,
  -1.12559542e-01f, 1.11354485e-01f, -2.26892084e-02f, -6.82870075e-02f, 3.94207127e-02f, -5.19940183e-02f, -6.92605898e-02f, 3.96243557e-02f, -4.60761320e-03f, -5.52775823e-02f,
  2.20165160e-02f, 6.49409518e-02f, -5.16859218e-02f, 8.66877064e-02f, 6.74318373e-02f, 4.25320119e-03f, 2.19792165e-02f, 1.16406575e-01f, 9.55192521e-02f, -2.16519204e-03f,
  -3.17596756e-02f, 7.59633109e-02f, 1.44423202e-01f, 5.46775572e-02f, 3.90919261e-02f, 2.01153040e-01f, 1.50011823e-01f, 5.92912063e-02f, 1.22270599e-01f, 1.01304956e-01f,
  -1.30780950e-01f, 3.06880832e-01f, 3.48643363e-02f, 2.43211947e-02f, 5.32985106e-03f, -8.00200999e-02f, -8.79347399e-02f, -6.54247850e-02f, 3.33416201e-02f, 1.98936462e-01f,
  8.34406018e-02f, -1.55708894e-01f, -7.99908713e-02f, -1.23756498e-01f, -1.00155748e-01f, 1.22569432e-03f, 6.82234317e-02f, -1.73137605e-01f, -3.53338689e-01f, -1.58981025e-01f,
  3.33771557e-02f, 2.49434840e-02f, 3.48910093e-02f, -1.11010835e-01f, 1.63012072e-01f, -1.45153686e-01f, 1.79736048e-01f, 1.77747369e-01f, 1.44569263e-01f, 4.01059389e-01f,
  2.20586695e-02f, 2.45706081e-01f, -1.40058577e-01f, -3.76402475e-02f, 5.40944561e-02f, 3.06612812e-02f, -7.47206295e-03f, 3.46989371e-02f, -4.11419608e-02f, 4.97672670e-02f,
  4.69422527e-02f, 3.26139145e-02f, 9.42239910e-03f, -1.90009531e-02f, -7.42292702e-02f, 4.85747345e-02f, 7.16978759e-02f, -1.15091735e-02f, 6.34242967e-02f, -1.37557061e-02f,
  6.61657304e-02f, 7.99487606e-02f, 8.54060948e-02f, 2.78579202e-02f, -3.57344821e-02f, -2.99658324e-03f, -4.72993543e-03f, 1.69812784e-01f, -1.53864548e-02f, 1.88874125e-01f,
  -2.31271866e-03f, 7.69577399e-02f, 3.20552802e-03f, 4.02431190e-02f, -1.03027888e-01f, -2.87888497e-02f, 3.10628265e-02f, -4.65641320e-02f, 3.54286954e-02f, -5.34659773e-02f,
  1.01936366e-02f, 3.38455774e-02f, -4.50970456e-02f, 1.94395315e-02f, -5.08293137e-02f, 7.72501156e-02f, -3.13976826e-03f, -1.72586273e-02f, 2.04409715e-02f, -3.29407677e-02f,
  9.73692164e-03f, -8.07523821e-03f, 1.67122111e-02f, 2.41636694e-03f, 8.91475379e-02f, -5.98406494e-02f, -6.99023716e-03f, 1.23945009e-02f, 8.79632011e-02f, 2.17818692e-02f,
  -2.00679213e-01f, 1.05547858e-02f, 4.47423905e-02f, 3.19810584e-02f, -2.16046479e-02f, -1.10545168e-02f, 1.98426936e-02f, 3.90095240e-03f, 5.17090643e-03f, 7.75074307e-03f,
  7.92944431e-03f, -1.02136716e-01f, 6.27956763e-02f, 5.23626506e-02f, -8.29687938e-02f, -1.32822961e-01f, 5.97507060e-02f, -2.96706129e-02f, -1.03434548e-02f, 8.43304843e-02f,
  -1.09838815e-02f, -5.18044382e-02f, -1.46342069e-01f, -6.88734790e-03f, 7.51936212e-02f, -1.54233769e-01f, -7.79611170e-02f, -5.22965118e-02f, -1.83479652e-01f, -1.47812366e-01f,
  -7.38956854e-02f, -1.26909882e-01f, -1.49864346e-01f, 3.15726064e-02f, 2.18934655e-01f, 2.54053265e-01f, 1.74354926e-01f, 1.40048191e-01f, 1.58844173e-01f, -5.31481244e-02f,
  -7.12087601e-02f, -5.97044379e-02f, -9.95711312e-02f, 4.74579558e-02f, -7.75798261e-02f, -6.76245913e-02f, -2.56725736e-02f, -1.18242867e-01f, 9.50590149e-02f, 2.59566128e-01f,
  1.76107869e-01f, -3.59486137e-03f, -1.03104889e-01f, -3.70149501e-02f, -6.52325824e-02f, 7.54329786e-02f, -1.01143472e-01f, -9.28318128e-02f, -6.16232716e-02f, -2.08857849e-01f,
  -2.48072907e-01f, -1.83462560e-01f, -1.38682844e-02f, -7.43694976e-02f, -1.62155136e-01f, -5.84788620e-03f, 3.04175401e-03f, 1.16237393e-02f, 3.69789414e-02f, -8.31570476e-02f,
  -2.66982671e-02f, 7.47966673e-03f, -6.23214953e-02f, -2.46395217e-03f, -2.23600622e-02f, -2.01096330e-02f, 2.64306907e-02f, -7.53059983e-02f, 3.77929956e-02f, 3.44213843e-02f,
  1.56342648e-02f, -6.02759458e-02f, -8.38414133e-02f, -3.07230577e-02f, -5.82298301e-02f, -9.40467268e-02f, -5.69945276e-02f, -1.25160381e-01f, -2.13875398e-02f, 5.98631985e-03f,
  5.06391041e-02f, 2.52078823e-03f, 4.03959937e-02f, -1.07981134e-02f, 2.25060601e-02f, -7.95170590e-02f, 2.52772886e-02f, -9.85440910e-02f, 7.98097774e-02f, -4.65765446e-02f,
  4.24827337e-02f, -7.94564560e-02f, 2.40677036e-02f, -3.67696173e-02f, -4.28681597e-02f, -9.02420953e-02f, 8.18913132e-02f, 4.07124870e-03f, -1.52748572e-02f, -3.47494222e-02f,
  -3.81265283e-02f, -7.21368268e-02f, -7.70464092e-02f, -8.60297529e-04f, -5.26094958e-02f, -1.84620880e-02f, 2.19345409e-02f, 8.73182267e-02f, 6.15880489e-02f, 5.60118407e-02f,
  1.31429866e-01f, -1.18280187e-01f, -2.96145515e-03f, -2.10998841e-02f, -7.40827993e-02f, -3.84444743e-02f, -8.55369791e-02f, 2.57497327e-03f, -1.52462898e-02f, 1.01540722e-01f,
  1.54470988e-02f, -4.08739634e-02f, -5.09148464e-02f, -2.12071855e-02f, 2.38124374e-02f, 6.57882541e-02f, 1.36620011e-02f, 4.02257293e-02f, -2.26694942e-02f, -1.81206223e-02f,
  7.82588031e-03f, 1.05946928e-01f, 6.33115172e-02f, 5.68089448e-02f, -5.31230010e-02f, 1.41149610e-01f, 1.06652059e-01f, 1.58622131e-01f, 1.41576439e-01f, 1.79493472e-01f,
  -2.70874631e-02f, -5.60222194e-03f, -1.79770380e-01f, -4.98382635e-02f, -1.04890496e-01f, -1.85767084e-01f, -1.99591592e-01f, 9.94187891e-02f, 1.48949340e-01f, -1.94583848e-01f,
  2.35096179e-02f, 6.41656891e-02f, 2.05846224e-02f, -4.04630229e-02f, 6.97026029e-03f, -3.28110844e-01f, -2.42265865e-01f, -1.16494969e-01f, -7.40218237e-02f, -1.82130877e-02f,
  4.56724726e-02f, -4.23473567e-02f, 9.16461200e-02f, 1.55817345e-01f, 6.54456392e-02f, -1.14307133e-02f, -1.32405953e-02f, -4.47840132e-02f, 3.25010531e-02f, -1.79430917e-01f,
  -2.77212381e-01f, 7.11023211e-02f, -5.00596017e-02f, -5.82695417e-02f, -4.31637801e-02f, 8.36641714e-02f, 1.80901890e-03f, 2.39961222e-03f, 7.06367046e-02f, -3.66316698e-02f,
  2.80726012e-02f, 6.45649210e-02f, 2.19917633e-02f, 2.45990455e-02f, 3.49161252e-02f, 2.01931279e-02f, 1.72895622e-02f, 2.92958375e-02f, 3.12285349e-02f, -5.37961163e-02f,
  -6.96721524e-02f, -3.33416872e-02f, -4.17948551e-02f, 4.92312089e-02f, 2.55678426e-02f, 7.19736442e-02f, 1.28689915e-01f, 1.08613022e-01f, 1.57253161e-01f, -3.28601487e-02f,
  -2.12619714e-02f, 4.48671766e-02f, 2.36090068e-02f, 3.07981353e-02f, -9.03234759e-04f, -2.17673313e-02f, -4.21758890e-02f, -7.77739435e-02f, -6.31337380e-03f, 2.78264340e-02f,
  1.99770853e-02f, -7.55949393e-02f, 6.92935362e-02f, -4.13386114e-02f, -8.40146244e-02f, -1.17742363e-02f, -5.10442443e-03f, -2.16365624e-02f, 2.00474188e-02f, 4.97295111e-02f,
  3.65693867e-02f, 5.30377477e-02f, -1.36598572e-02f, 7.41268769e-02f, -3.41731962e-03f, -3.66233774e-02f, -1.94758959e-02f, 4.38561775e-02f, -4.31979559e-02f, 7.66286403e-02f,
  -2.50332989e-02f, -5.33418870e-03f, 2.41032857e-02f, 5.67418747e-02f, 4.52864058e-02f, -9.20976326e-03f, 4.86553507e-03f, -5.07874340e-02f, 3.57212201e-02f, 6.98714629e-02f,
  3.67932543e-02f, 7.58118033e-02f, -4.95669842e-02f, 5.29586300e-02f, -2.54838187e-02f, 2.21967157e-02f, -2.43283827e-02f, 3.51824909e-02f, -9.48821427e-04f, -6.14333265e-02f,
  -7.34925568e-02f, 2.24634036e-02f, -6.89013749e-02f, 7.17473961e-03f, 4.85071056e-02f, 2.39220355e-02f, -8.18832144e-02f, -4.56212834e-03f, -2.34028660e-02f, -1.65972903e-01f,
  1.41525641e-01f, 1.49202555e-01f, -3.93889248e-02f, 3.60652283e-02f, 6.18504733e-03f, -1.64537922e-01f, -1.06800728e-01f, -2.19955910e-02f, -3.24924141e-02f, 1.14536278e-01f,
  1.41083539e-01f, 3.82179730e-02f, 8.02947953e-02f, 1.10076614e-01f, 4.13793027e-02f, 5.70630804e-02f, -9.64188148e-05f, 6.21258654e-02f, -9.35547277e-02f, -6.53522238e-02f,
  7.60317668e-02f, 4.84459326e-02f, 4.50318679e-02f, 9.07507725e-03f, 1.77772745e-01f, 9.03858170e-02f, -1.43172517e-02f, 1.04910554e-02f, 4.98160347e-02f, 1.90827921e-01f,
  -4.32596691e-02f, -3.97003163e-03f, -2.72058533e-03f, -2.65657809e-02f, -6.94776326e-02f, -1.63868964e-02f, -2.33549066e-03f, 6.75606430e-02f, 5.02089635e-02f, 1.21426634e-01f,
  1.08563816e-02f, 1.29126474e-01f, -5.81928641e-02f, 1.15517946e-03f, 7.39264712e-02f, -1.00847840e-01f, -6.17098585e-02f, -7.18256012e-02f, -1.12535357e-01f, 2.93588564e-02f,
  9.34603885e-02f, 3.77104282e-02f, -5.64586706e-02f, -1.07509844e-01f, 3.39299366e-02f, -8.06771666e-02f, 2.74620689e-02f, 2.53443271e-02f, -2.58011054e-02f, 5.45092113e-02f,
  -4.30739522e-02f, -6.75274339e-03f, 8.37844163e-02f, 4.58233431e-03f, 1.19859301e-01f, -2.01644860e-02f, 7.02306675e-03f, -8.32156613e-02f, 4.16841954e-02f, -4.26502666e-03f,
  -1.91010404e-02f, -8.93818289e-02f, -4.35919724e-02f, -1.96399633e-02f, 5.30788861e-02f, -4.24225740e-02f, 5.13438545e-02f, 7.54221752e-02f, -3.91028523e-02f, 5.22761159e-02f,
  3.35911959e-02f, -8.39881152e-02f, -3.60322557e-02f, -1.09047703e-01f, 4.63786460e-02f, 3.26069742e-02f, -4.02576029e-02f, -5.35337217e-02f, 6.14023097e-02f, 1.02590233e-01f,
  -6.19876161e-02f, -5.66280447e-02f, 2.65576616e-02f, 2.00892016e-02f, -1.94216594e-02f, -6.44289376e-03f, -5.65820150e-02f, -4.76161838e-02f, 5.47789596e-02f, -4.70796749e-02f,
  -2.88388971e-02f, 6.71181679e-02f, 7.45845065e-02f, 4.51914556e-02f, -1.07847854e-01f, -1.69374365e-02f, 4.49491516e-02f, -9.85934064e-02f, -9.88254696e-02f, -6.18424714e-02f,
  -2.31283475e-02f, -1.68874457e-01f, -1.64219409e-01f, -2.29529701e-02f, 5.40831068e-04f, -8.44735578e-02f, -1.34766772e-01f, -1.25370678e-02f, -1.58601716e-01f, -5.56026846e-02f,
  -3.40605587e-01f, 3.40805128e-02f, -1.73437431e-01f, -5.27083762e-02f, 8.10604542e-02f, -2.87551135e-02f, -4.14558314e-02f, 5.88591546e-02f, 1.73186973e-01f, -3.34543474e-02f,
  1.70493245e-01f, 2.95412034e-01f, 1.77780077e-01f, 6.47380501e-02f, -1.27827581e-02f, -1.69122964e-01f, -8.86346325e-02f, -2.02695668e-01f, -1.02833435e-02f, 1.35976493e-01f,
  1.23741567e-01f, -3.43791731e-02f, -1.45183563e-01f, 1.84893347e-02f, -2.79327240e-02f, 2.08559766e-01f, -7.27551132e-02f, -9.35342163e-02f, 1.55839726e-01f, -1.97279006e-02f,
  -2.49774903e-02f, -1.60070568e-01f, 4.22087274e-02f, 2.90456880e-02f, -2.77079400e-02f, -6.05053417e-02f, 5.29576354e-02f, -1.24392495e-01f, 2.75981296e-02f, -4.79659475e-02f,
  8.42900723e-02f, -2.30418574e-02f, 7.73188397e-02f, -1.15704047e-03f, -8.97876546e-02f, -4.21784408e-02f, -3.17148529e-02f, -1.14118896e-01f, -1.07999273e-01f, -5.46398573e-02f,
  6.33566231e-02f, 3.75121199e-02f, -1.01261437e-01f, 4.25526425e-02f, 3.80616412e-02f, 6.47872537e-02f, -4.42410149e-02f, -3.07421405e-02f, 6.15091063e-02f, -4.36286479e-02f,
  -3.35769355e-02f, -3.70972119e-02f, -3.11261415e-02f, 5.19543216e-02f, 1.65978540e-02f, -2.36933283e-03f, -9.49596092e-02f, 9.26701352e-02f, -6.18081354e-02f, -6.76316908e-03f,
  3.25566580e-05f, 4.11658771e-02f, -5.68581857e-02f, 4.87037376e-03f, 3.32872644e-02f, -4.35328223e-02f, 7.57272402e-03f, 6.58263336e-04f, 2.98872441e-02f, -6.96530379e-03f,
  5.15766107e-02f, -7.41838571e-03f, -4.42937613e-02f, -2.49732495e-03f, 3.53464223e-02f, -4.29933146e-03f, -7.08473846e-04f, 4.78707366e-02f, 7.57258460e-02f, -1.06721021e-01f,
  4.09746245e-02f, -9.46011860e-03f, -6.31386936e-02f, 2.58325711e-02f, 4.68956120e-02f, 4.41941693e-02f, 9.54497382e-02f, 5.18642319e-03f, 1.57180130e-02f, -1.90660506e-02f,
  3.70893069e-02f, -3.97383273e-02f, 5.75913973e-02f, 2.56396644e-02f, -7.87471682e-02f, -1.34079205e-02f, 9.32888985e-02f, -8.87730122e-02f, -4.70222309e-02f, 4.24212366e-02f,
  -4.26505618e-02f, 8.25642492e-04f, -3.31431776e-02f, -2.11707558e-02f, -7.04985065e-03f, 1.18172273e-01f, 3.57540138e-02f, -4.81509976e-02f, -2.48157214e-02f, -1.12505585e-01f,
  5.09857237e-01f, 2.54057813e-02f, 2.30906218e-01f, 3.12209353e-02f, -6.38829246e-02f, -1.55827357e-02f, 1.42615885e-02f, -3.86062562e-02f, 1.82502549e-02f, -7.28361234e-02f,
  5.56899011e-02f, -8.81713629e-02f, -3.11467629e-02f, 7.95627385e-02f, 1.75600007e-01f, -1.32865012e-01f, -7.74586797e-02f, -2.04655305e-02f, 1.35896921e-01f, 5.89766838e-02f,
  -2.04476088e-01f, -4.85873781e-03f, 5.68419844e-02f, -1.18118636e-01f, -3.04002315e-01f, -1.98693126e-01f, 1.34821003e-03f, -3.06345895e-02f, -1.69596955e-01f, -3.43559444e-01f,
  1.31735593e-01f, 1.72182888e-01f, 8.15134272e-02f, 4.28986587e-02f, 6.61556656e-03f, 2.33406387e-02f, -3.09294369e-02f, 8.57730675e-03f, 1.74131338e-02f, 6.16616989e-03f,
  -1.70712527e-02f, -1.95859708e-02f, 2.60261577e-02f, -8.73473734e-02f, 1.00410886e-01f, -1.53873079e-02f, 1.53812068e-02f, 7.69957677e-02f, 1.37340382e-01f, -4.45145555e-02f,
  -1.62747622e-01f, -7.36671016e-02f, 1.43770641e-02f, 4.35870253e-02f, 6.11094944e-02f, 3.93584743e-02f, -4.45260778e-02f, 2.03586668e-02f, 1.30509539e-02f, -1.48383886e-01f,
  -3.72399688e-02f, -9.54594649e-03f, 3.97687592e-02f, 1.13209449e-02f, -3.97913642e-02f, -3.71204480e-03f, -6.68792203e-02f, -2.68908534e-02f, 8.80818069e-02f, -3.64547484e-02f,
  9.15235188e-03f, 7.72113167e-03f, -5.77087700e-02f, -7.35172406e-02f, -9.39047113e-02f, -5.21844774e-02f, 1.21312933e-02f, -2.01398730e-02f, -6.21631742e-02f, 6.03555702e-02f,
  1.25611693e-01f, 8.99889246e-02f, -7.37357838e-03f, -1.54400841e-04f, -1.52819669e-02f, -5.29480726e-02f, 1.17334444e-02f, -7.50561878e-02f, -2.57894900e-02f, -1.22456141e-02f,
  4.71034981e-02f, 1.36464238e-01f, -9.49384570e-02f, 7.78533816e-02f, 1.93623453e-02f, 4.41385917e-02f, 5.92523739e-02f, 1.63464819e-03f, -6.66948641e-03f, 2.37797592e-02f,
  1.22509733e-01f, 9.79215726e-02f, 8.37421343e-02f, 7.64982253e-02f, -1.72576646e-03f, -2.82752644e-02f, -5.69935404e-02f, -2.60265474e-03f, -3.20412777e-02f, -4.67833392e-02f,
  -2.69024447e-02f, 2.41807550e-02f, -1.88001581e-02f, -7.48893479e-03f, -1.18090669e-02f, 4.86596711e-02f, -1.30632753e-02f, 5.73810413e-02f, 1.61742732e-01f, 4.97134356e-03f,
  -1.72487885e-01f, 7.21739233e-02f, 1.35973096e-01f, -1.01611324e-01f, 1.48479510e-02f, -1.00117922e-02f, -1.20959589e-02f, -8.16365555e-02f, 8.95757880e-03f, 3.19373794e-02f,
  6.48642052e-03f, 1.95339490e-02f, 5.54304905e-02f, 4.94441390e-02f, 1.39787272e-01f, 8.57828557e-02f, 2.75925584e-02f, 4.17813733e-02f, 4.45179045e-02f, 1.65419858e-02f,
  8.52133930e-02f, 6.05284907e-02f, -1.60021484e-02f, 5.40225022e-02f, -8.71526599e-02f, 3.49108987e-02f, 2.62327213e-02f, -2.00759922e-03f, 9.97914895e-02f, -1.31888054e-02f,
  2.99785405e-01f, -2.60962062e-02f, 9.57501531e-02f, 4.05120477e-02f, 3.63658033e-02f, -3.09462287e-02f, -5.21100163e-02f, 7.60952360e-04f, 4.44627777e-02f, -3.89002785e-02f,
  -7.11764619e-02f, -5.89504018e-02f, 5.06355055e-02f, 4.11862582e-02f, 6.05879799e-02f, -2.59586051e-02f, -1.12928357e-02f, 3.09852995e-02f, -8.75871852e-02f, -5.32581545e-02f,
  -7.10194632e-02f, 1.28877070e-02f, -4.03626002e-02f, -4.02922556e-02f, -8.65223557e-02f, 3.69296037e-02f, 3.80164124e-02f, 3.03814281e-03f, -7.76298046e-02f, -5.03145941e-02f,
  -3.11773345e-02f, -8.61659944e-02f, 1.37174800e-02f, -2.83878818e-02f, 3.82702760e-02f, -1.31273298e-02f, 8.13057050e-02f, -1.65391471e-02f, 7.22105382e-03f, -1.87837519e-02f,
  -1.45848850e-02f, -1.72767602e-02f, 1.57191660e-02f, 3.89319472e-02f, 2.84597687e-02f, -5.35709336e-02f, -2.21635327e-02f, -2.01333351e-02f, -6.13548420e-02f, -7.07884207e-02f,
  -1.11585613e-02f, -1.92593001e-02f, -2.45217811e-02f, 4.81693633e-02f, 1.47134764e-04f, -2.54799034e-02f, 2.13305261e-02f, 1.61262844e-02f, 3.30136642e-02f, -9.11128670e-02f,
  1.59662470e-01f, 1.67548191e-02f, -2.89933942e-02f, -1.67064536e-02f, 3.59168574e-02f, -6.71926066e-02f, 1.39456289e-02f, -3.80093642e-02f, -1.49770640e-02f, 2.77367197e-02f,
  -1.16240922e-02f, 3.50550674e-02f, 5.19861355e-02f, -3.73331481e-03f, 8.83839652e-03f, -2.49987375e-02f, -3.16259414e-02f, 5.06969690e-02f, 3.07227112e-02f, -1.04857989e-01f,
  -3.99357192e-02f, -1.06892455e-02f, 8.18867832e-02f, 2.93995366e-02f, 3.01271491e-02f, 9.27435458e-02f, 9.02961493e-02f, 6.00669086e-02f, -1.54826008e-02f, 1.79644022e-02f,
  -3.40565920e-01f, 1.39948828e-02f, 5.57818823e-02f, -2.30755106e-01f, 5.88787384e-02f, 6.70328364e-02f, -7.58673325e-02f, 2.09603645e-02f, -8.73398334e-02f, 5.21208532e-02f,
  3.43665890e-02f, 1.50039017e-01f, 4.61213328e-02f, 7.44092464e-02f, -7.49771446e-02f, -1.62024468e-01f, -1.50656685e-01f, -5.74165657e-02f, -1.22407779e-01f, -6.42416030e-02f,
  -1.98002234e-02f, -2.42142320e-01f, -1.85401529e-01f, 1.07329590e-02f, -6.28488362e-02f, 2.36211345e-02f, -3.82452868e-02f, -1.12165652e-01f, 2.85634547e-02f, -1.51351869e-01f,
  -2.55923215e-02f, -4.15845141e-02f, 4.88276295e-02f, 1.68572576e-03f, 7.46867154e-03f, 8.18606243e-02f, 1.47688882e-02f, 2.90693790e-02f, 5.28894998e-02f, 5.27818538e-02f,
  7.80336559e-02f, 6.90088496e-02f, 9.53107104e-02f, 1.00391574e-01f, -1.41912505e-01f, 1.01642618e-02f, -9.42536816e-02f, -1.64366648e-01f, -9.64201391e-02f, 4.23621088e-02f,
  4.07428481e-02f, -9.24652144e-02f, -1.85260419e-02f, 3.38291377e-02f, 2.76593529e-02f, 4.35957611e-02f, 1.93138001e-03f, -1.18079875e-02f, 3.92236710e-02f, -1.50389209e-01f,
  4.23078835e-02f, 7.26291314e-02f, 1.03407674e-01f, -2.61159111e-02f, -4.00996432e-02f, 1.67352688e-02f, -7.46259745e-03f, -5.16295806e-02f, -5.65621480e-02f, -4.38038111e-02f,
  6.95790946e-02f, -5.26385196e-02f, 1.72219196e-04f, -8.49762559e-02f, 3.37035395e-02f, -1.93199795e-02f, 6.78073764e-02f, -9.58582328e-04f, 6.45955801e-02f, -6.55653849e-02f,
  -4.24874127e-02f, 4.43878211e-02f, -1.15528668e-03f, -2.85844505e-02f, -7.49490177e-03f, 6.92410246e-02f, 4.15166244e-02f, -3.06962691e-02f, 1.68208368e-02f, -3.81172001e-02f,
  -9.04572308e-02f, 2.26770982e-01f, -6.56167343e-02f, -6.13971539e-02f, 3.53763476e-02f, 7.98467696e-02f, 9.05897189e-03f, 3.06736166e-03f, 1.48667181e-02f, -7.53383264e-02f,
  -5.95972277e-02f, 1.28418964e-03f, -3.78008597e-02f, -6.21367572e-03f, -2.02637985e-02f, -9.44719985e-02f, 1.19257495e-02f, -6.79635033e-02f, -3.09505407e-03f, -6.98720617e-03f,
  -1.27949854e-02f, 8.45468044e-03f, 3.46643967e-04f, 5.86801767e-02f, 2.03801673e-02f, 6.72248751e-02f, -8.90054554e-02f, -9.11305994e-02f, 7.47475922e-02f, -8.98797363e-02f,
  -1.57299906e-01f, 1.59094781e-01f, 1.26942173e-01f, -7.76273310e-02f, 2.16724485e-01f, 2.19052508e-01f, 3.28549445e-01f, -6.17943592e-02f, -1.39366999e-01f, 1.27398685e-01f,
  -6.54188320e-02f, -2.67648339e-01f, -2.62377888e-01f, -1.83148235e-01f, -1.20157801e-01f, 1.82049125e-01f, 1.76209137e-01f, -1.76061746e-02f, -1.04955696e-01f, 5.31094931e-02f,
  9.41051766e-02f, -4.89088558e-02f, -1.41938359e-01f, -1.15948483e-01f, 8.23200345e-02f, -1.04373302e-02f, -1.36528593e-02f, 9.88847688e-02f, 4.56094667e-02f, 2.88386077e-01f,
  6.25347644e-02f, -7.48671517e-02f, -1.53131271e-02f, -3.38787735e-02f, -1.15823641e-01f, 5.75910928e-03f, -8.09033882e-05f, -5.38659766e-02f, -3.76981609e-02f, 4.69650663e-02f,
  5.33359982e-02f, -3.96167748e-02f, 3.51982526e-02f, -1.04138605e-01f, -4.89067994e-02f, 2.83162538e-02f, -8.61323625e-02f, -5.54109178e-02f, -1.58018023e-01f, -9.24439356e-02f,
  3.50391082e-02f, 5.12261353e-02f, 6.21541077e-03f, 1.01606548e-02f, -2.39762869e-02f, 9.50991549e-03f, 2.50512026e-02f, -6.68630525e-02f, -1.40099287e-01f, -2.15911418e-02f,
  2.11602282e-02f, 5.99046703e-03f, 4.41798344e-02f, 2.35855225e-02f, -1.62189044e-02f, -1.59673728e-02f, -3.31857391e-02f, 3.34376693e-02f, -1.91368517e-02f, 4.76461323e-03f,
  -7.82588497e-02f, -4.49239239e-02f, 2.61188112e-03f, -4.18703817e-02f, 1.70108844e-02f, -4.21723723e-03f, 3.55046242e-02f, -2.46618222e-02f, -3.45707238e-02f, -1.31691284e-02f,
  -9.22942767e-04f, 2.43293084e-02f, -9.29446053e-03f, 2.36245468e-02f, 1.91614907e-02f, 3.60471830e-02f, 2.13240683e-02f, -5.58805987e-02f, -5.63603602e-02f, 3.50832529e-02f,
  -2.34337330e-01f, -1.29824057e-01f, 3.30296122e-02f, -4.94544841e-02f, -3.27551737e-02f, -1.35642933e-02f, -6.15377575e-02f, -3.89092751e-02f, -2.26286948e-02f, -1.05406875e-02f,
  -5.36432583e-03f, 5.89418365e-03f, -1.02920167e-01f, 7.23038092e-02f, 1.22696720e-02f, 6.76297620e-02f, 3.84614319e-02f, -2.08703186e-02f, 1.18829319e-02f, 4.30847518e-02f,
  -9.47122090e-03f, 1.09436080e-01f, -7.85956532e-03f, 7.58847073e-02f, -6.93067908e-02f, 1.64344478e-02f, 4.58778441e-02f, 5.39178513e-02f, -6.47252053e-02f, -1.94074698e-02f,
  4.51237470e-01f, -5.27300313e-02f, 2.78498739e-01f, -4.94026802e-02f, -6.70852661e-02f, -3.57054397e-02f, 1.31623000e-02f, 1.00573422e-02f, -8.68341327e-02f, -1.53868431e-02f,
  -1.67460412e-01f, -2.75333822e-01f, -1.42277181e-01f, -1.57285124e-01f, -5.42578427e-03f, 1.24730185e-01f, 1.14755832e-01f, 1.28957108e-01f, -6.95297644e-02f, -1.26279742e-01f,
  -2.64205605e-01f, 5.03440425e-02f, 2.23293528e-01f, 4.33497950e-02f, -1.72610000e-01f, -1.64578065e-01f, 1.32354721e-02f, -3.51677276e-02f, -7.15435743e-02f, -7.28996471e-02f,
  -4.32059504e-02f, 1.17981307e-01f, -3.99383083e-02f, -1.94349084e-02f, -1.02313911e-03f, 8.32933858e-02f, 5.12022935e-02f, 1.39619499e-01f, 2.69792657e-02f, 7.23421723e-02f,
  -1.40904775e-02f, -4.08475548e-02f, -7.69008994e-02f, -4.32351418e-02f, 2.12983843e-02f, -2.61745602e-02f, 1.45042971e-01f, 1.87186822e-01f, 2.01389734e-02f, -9.70998555e-02f,
  -1.49323985e-01f, 2.74518337e-02f, 1.14460953e-01f, 4.31269519e-02f, 1.71928238e-02f, 4.30663899e-02f, 7.11104348e-02f, -2.52417941e-02f, 1.77051704e-02f, -6.80591688e-02f,
  -4.07568663e-02f, -2.96486579e-02f, 3.84509825e-04f, 2.71176174e-02f, 1.95940230e-02f, -2.27206778e-02f, -4.08184789e-02f, 1.69684906e-02f, -7.01165497e-02f, 8.96909609e-02f,
  -9.68033448e-02f, 3.37121598e-02f, -7.22297281e-02f, 9.66097191e-02f, -3.79216112e-02f, -6.51475191e-02f, 1.95843093e-02f, -3.55902314e-03f, 3.62570472e-02f, -5.02577110e-04f,
  3.89097184e-02f, 6.71375617e-02f, -7.75985420e-02f, 9.48990788e-03f, 5.72375841e-02f, 4.26207632e-02f, -9.85071436e-02f, -1.81708764e-02f, -4.69235294e-02f, 3.81463319e-02f,
  -1.67848438e-01f, 1.72793075e-01f, -2.47634239e-02f, 2.18605716e-02f, 1.11443559e-02f, -3.64726409e-02f, -8.00116360e-02f, 4.35034418e-03f, -1.74725372e-02f, 1.26339030e-02f,
  -3.88920456e-02f, 2.93718949e-02f, 5.34845740e-02f, 2.35238019e-02f, -1.82793997e-02f, 1.21145537e-02f, -5.56431524e-02f, -3.69254015e-02f, 1.86975840e-02f, -2.77275555e-02f,
  -3.47049162e-02f, -3.00907437e-03f, 3.42465453e-02f, -3.04372460e-02f, 3.99219105e-03f, -2.40217429e-02f, 3.97139154e-02f, 2.41182111e-02f, 5.55216260e-02f, -1.80022214e-02f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.53231542e-02f, 9.13101807e-02f, 6.75224066e-02f, 5.51340394e-02f, 1.27290159e-01f, 6.44071922e-02f, 5.76679371e-02f, 9.78769660e-02f, 8.21402948e-03f, -6.40831962e-02f,
  -6.74355635e-03f, 3.74571197e-02f, -1.36886742e-02f, 3.37001942e-02f, 1.21746786e-01f, 2.42609978e-02f, 2.17602290e-02f, 1.35992477e-02f, 2.58047618e-02f, -1.02960225e-02f,
  2.46181563e-02f, -7.84420073e-02f, -2.06406731e-02f, 5.19110300e-02f, 9.04761851e-02f, 4.77988971e-03f, 3.84249426e-02f, 2.61701234e-02f, -1.64261498e-02f, 1.55720226e-02f,
  4.89264093e-02f, -5.95093966e-02f, 7.86342695e-02f, -1.08701289e-01f, -5.31602241e-02f, -3.54502276e-02f, -1.68813020e-02f, -8.69047493e-02f, -6.71573728e-02f, -3.41946743e-02f,
  2.99910153e-03f, 5.00021987e-02f, -8.81285686e-03f, 6.53388277e-02f, 4.54029925e-02f, 6.02432117e-02f, -4.78411354e-02f, -4.20073271e-02f, 7.09410980e-02f, -2.51257606e-03f,
  9.40172095e-03f, 3.28310169e-02f, -8.76629353e-03f, -3.74086946e-02f, -6.41474947e-02f, -3.40182474e-03f, -5.15462756e-02f, 1.01789562e-02f, 6.04815707e-02f, 8.30099266e-03f,
  5.24318181e-02f, 2.02843659e-02f, -5.86016662e-02f, -2.60937959e-02f, -7.74561465e-02f, -1.43854786e-02f, -7.77942315e-02f, -6.91879690e-02f, 1.22311246e-02f, 3.18658277e-02f,
  4.76814769e-02f, -6.75789863e-02f, 6.54991269e-02f, 3.96467485e-02f, -6.36656731e-02f, 3.67339179e-02f, -5.30132800e-02f, 9.24452469e-02f, -2.85762884e-02f, 5.02657145e-02f,
  -4.24758904e-02f, -5.29370531e-02f, -1.16986912e-02f, -3.47918868e-02f, -5.49611682e-03f, 1.96945556e-02f, 4.85137664e-02f, 4.62822095e-02f, -5.93080446e-02f, -9.27646980e-02f,
  1.96899306e-02f, 6.77917972e-02f, 3.17177968e-03f, -6.42913207e-02f, 8.35682675e-02f, -5.40427193e-02f, 7.33890831e-02f, -5.77020086e-02f, -7.52713606e-02f, 1.25199594e-02f,
  4.08418812e-02f, 4.89494279e-02f, -4.56082039e-02f, 5.40903956e-02f, 6.53504506e-02f, -2.14348137e-02f, 3.04768793e-02f, -4.97580096e-02f, -3.57069215e-03f, 4.43684943e-02f,
  -7.31988698e-02f, -3.09398975e-02f, 6.24066368e-02f, -8.47488269e-03f, 7.57370591e-02f, 6.70094788e-02f, 1.06027676e-02f, 4.77436669e-02f, 7.72582658e-04f, -9.45509821e-02f,
  9.56478417e-02f, -2.01604757e-02f, 1.00859776e-01f, 9.68874618e-02f, 1.47801936e-01f, 1.03157789e-01f, 4.01019230e-02f, 1.04102142e-01f, 1.46908253e-01f, 1.54558659e-01f,
  1.77796051e-01f, 8.30102861e-02f, 1.75634176e-01f, 1.36739030e-01f, 1.26070708e-01f, -6.74029589e-02f, 6.74067251e-03f, -8.10286328e-02f, 4.18731980e-02f, 1.00596532e-01f,
  -6.41586855e-02f, -2.63759048e-05f, -7.16861859e-02f, 6.33489043e-02f, 6.83691427e-02f, 6.88346922e-02f, -2.10565403e-02f, 4.46957164e-03f, 4.54518981e-02f, -8.77593830e-02f,
  5.41807041e-02f, 5.57167232e-02f, -7.20160902e-02f, 2.95260884e-02f, 3.89888212e-02f, -5.34084514e-02f, 4.67494167e-02f, 3.40864621e-02f, -3.46591845e-02f, -9.96712819e-02f,
  6.82879686e-02f, 7.91190937e-02f, 3.36324200e-02f, -1.08788840e-01f, 2.20809206e-02f, -6.08452484e-02f, 7.43731111e-02f, -1.92641467e-02f, 1.00971088e-01f, 6.67899027e-02f,
  -4.50518280e-02f, 3.87720787e-03f, -3.09879556e-02f, -1.81102508e-03f, 6.71766773e-02f, -4.80223298e-02f, -5.07914387e-02f, -9.64879058e-03f, 5.26858941e-02f, -5.16317859e-02f,
  4.39433530e-02f, 9.14775431e-02f, 3.00953630e-02f, 8.24678689e-02f, 9.38627720e-02f, -5.04604094e-02f, -7.79292807e-02f, -7.89707974e-02f, 1.54144131e-04f, 2.23312769e-02f,
  1.14532106e-01f, -3.89475413e-02f, 1.41736362e-02f, -5.78739159e-02f, 5.87697467e-03f, 4.88755666e-03f, 4.88297194e-02f, -6.54478893e-02f, -3.40520926e-02f, 3.53045128e-02f,
  1.95704587e-03f, -4.75619100e-02f, 2.49257218e-02f, 1.66007485e-02f, 6.98825791e-02f, 1.15446463e-01f, -6.95076212e-02f, -5.76522648e-02f, -2.05337983e-02f, 3.70130651e-02f,
  -5.81862107e-02f, 3.25008016e-03f, 2.87968777e-02f, -7.58942738e-02f, 4.62599508e-02f, -2.23138072e-02f, 7.86710456e-02f, -8.76534656e-02f, -1.12854302e-01f, 1.64652597e-02f,
  2.93371752e-02f, -6.87461048e-02f, -2.25387346e-02f, 1.75213702e-02f, 3.84771712e-02f, 7.80348852e-02f, 6.15027025e-02f, 6.73671737e-02f, 3.82201448e-02f, -3.34863015e-03f,
  -5.86288832e-02f, 1.63001250e-02f, -5.06235585e-02f, -4.65477817e-02f, -7.16320053e-02f, 3.88704762e-02f, 4.99873841e-03f, -1.21960305e-01f, 8.47977102e-02f, 2.41728146e-02f,
  -1.48735151e-01f, 6.41395524e-02f, -3.14213410e-02f, -6.56816661e-02f, -3.61309126e-02f, 3.94954979e-02f, -2.31505893e-02f, -4.48004380e-02f, 3.69535685e-02f, 2.61329245e-02f,
  -6.26772121e-02f, -6.17991537e-02f, 9.17882919e-02f, 1.34081085e-04f, -2.71167955e-03f, -1.50055764e-03f, 6.92016706e-02f, 1.01083167e-01f, 7.03280196e-02f, -4.08490561e-02f,
  7.61667383e-04f, 1.00436375e-01f, -7.63057023e-02f, -5.35633266e-02f, -3.46996170e-03f, -7.83022270e-02f, -1.58492699e-02f, 6.71522096e-02f, 8.43126252e-02f, 1.00453421e-01f,
  6.61439970e-02f, -6.18968420e-02f, -4.97330725e-02f, -6.10888675e-02f, 8.63778666e-02f, -4.56601754e-02f, -3.18932422e-02f, 5.66894300e-02f, 2.40819044e-02f, 6.51188614e-03f,
  -8.38458762e-02f, -5.74318022e-02f, -5.54281361e-02f, -7.21215010e-02f, -4.00907435e-02f, 2.85163447e-02f, 2.92785093e-02f, -5.71205933e-03f, -6.42705113e-02f, 2.52779555e-02f,
  8.09407309e-02f, 9.79342833e-02f, 1.19175827e-02f, -3.71509194e-02f, 7.40601197e-02f, 6.45585582e-02f, 2.21365392e-02f, -2.43614446e-02f, -6.69801012e-02f, 5.90436347e-02f,
  -5.50037920e-02f, -9.79840159e-02f, -5.25587611e-02f, 1.35033168e-02f, -8.33810493e-02f, 6.05736598e-02f, -7.29553849e-02f, 2.40697805e-02f, -4.92471494e-02f, 6.69816583e-02f,
  1.12719713e-02f, -3.69510497e-03f, -7.31582269e-02f, -6.65096343e-02f, -5.89651614e-02f, -6.89237937e-02f, -5.02193011e-02f, 4.20449376e-02f, -7.21863955e-02f, 7.31733516e-02f,
  3.65273245e-02f, -3.35992463e-02f, 6.52518496e-02f, 1.14075430e-01f, 5.82785532e-02f, -6.17965199e-02f, 6.03059642e-02f, -4.73948717e-02f, -3.45113799e-02f, -4.25062105e-02f,
  1.41148299e-01f, 6.28952160e-02f, 1.39677264e-02f, 2.45645903e-02f, -3.77498474e-03f, 5.95133677e-02f, -7.33907968e-02f, 2.44836352e-04f, -5.61216921e-02f, 1.72793064e-02f,
  -3.76916714e-02f, 5.74953407e-02f, 7.55541995e-02f, 4.12159972e-02f, -7.13872463e-02f, 5.46958633e-02f, -8.73203352e-02f, 9.95998085e-03f, 2.23155953e-02f, -2.44553555e-02f,
  2.29852516e-02f, 1.12274967e-04f, 1.15040569e-02f, -4.29309253e-03f, 4.92411666e-02f, -1.67377982e-02f, 6.06496558e-02f, 1.11230619e-01f, -3.17033231e-02f, -5.59916981e-02f,
  2.30048653e-02f, -1.16655573e-01f, 1.66355833e-01f, 3.94784883e-02f, -1.48764744e-01f, -3.31187814e-01f, -2.65617341e-01f, -9.87753496e-02f, -6.43508285e-02f, -2.16450263e-02f,
  -1.02336474e-01f, 2.20887121e-02f, 1.21858984e-01f, 9.59779471e-02f, 8.79461616e-02f, -3.63160968e-02f, 2.30323542e-02f, 2.52658457e-01f, 9.09185186e-02f, -7.77534172e-02f,
  2.24367045e-02f, 1.55779228e-01f, 1.81171745e-01f, 1.04551606e-01f, -7.05474988e-02f, -8.55537802e-02f, 1.12902895e-01f, 1.09379992e-01f, 3.44388373e-02f, 1.21495180e-01f,
  2.59560924e-02f, -7.41687864e-02f, -9.60267894e-03f, 1.62411761e-02f, 5.89414015e-02f, 1.00059673e-01f, -1.51531883e-02f, 1.19746380e-01f, -8.21015164e-02f, -4.13743518e-02f,
  4.62325364e-02f, 6.71209360e-04f, -5.57956211e-02f, 8.68599862e-02f, 6.51693866e-02f, -5.07750697e-02f, 1.11627877e-01f, 1.04605995e-01f, 1.24098703e-01f, 4.07596380e-02f,
  -7.79370666e-02f, -1.64741352e-02f, -1.09446190e-01f, -8.43905434e-02f, -5.96356317e-02f, -5.23833930e-02f, 4.45089191e-02f, -6.78752884e-02f, 2.48381160e-02f, 9.84592084e-03f,
  4.29339111e-02f, 1.09093137e-01f, -4.98941652e-02f, 8.29457045e-02f, -7.18017295e-02f, -2.78111752e-02f, -2.50328295e-02f, -1.11576985e-03f, 5.90464920e-02f, -5.69566935e-02f,
  5.96956015e-02f, 5.16577885e-02f, -3.72887403e-02f, -8.75156298e-02f, -6.70340890e-03f, -9.74446721e-03f, 4.58605327e-02f, -3.16112116e-02f, -2.44377123e-04f, 4.86192480e-02f,
  -9.34309512e-03f, -2.33731829e-02f, 2.76265163e-02f, -6.98015466e-02f, -2.82777119e-02f, 1.13613307e-01f, 4.92895469e-02f, 1.72157642e-02f, 3.71161513e-02f, 4.75399941e-02f,
  4.98727784e-02f, 7.62931556e-02f, 2.05876250e-02f, -4.64771222e-03f, -5.99004235e-03f, -1.82611123e-02f, -3.70314009e-02f, 4.71910909e-02f, -5.72116636e-02f, -3.25276293e-02f,
  -1.14430383e-01f, -5.48117273e-02f, -6.78270683e-02f, -8.22246969e-02f, -7.80545250e-02f, -2.08210144e-02f, -1.30655421e-02f, -2.59098038e-02f, -4.74236235e-02f, -1.82525944e-02f,
  -7.82589018e-02f, -1.44638404e-01f, -8.64084885e-02f, -1.53389186e-01f, -1.05474927e-01f, -6.18846761e-03f, 3.15248556e-02f, -1.37569517e-01f, -3.75503600e-02f, -1.16926178e-01f,
  1.65830150e-01f, 3.76123004e-02f, -8.30585063e-02f, 5.09538911e-02f, -8.90338048e-02f, -1.71832964e-01f, -7.10307732e-02f, 1.10158384e-01f, 1.70654133e-01f, 5.43002971e-02f,
  6.18629009e-02f, 1.85974836e-02f, -6.62474483e-02f, -2.55907904e-02f, -3.69277224e-02f, -7.77331144e-02f, -1.80353567e-01f, -1.67002529e-01f, -1.58708289e-01f, -1.94696203e-01f,
  -7.30481893e-02f, -4.85775955e-02f, 1.79192546e-04f, 3.94037925e-02f, 1.48779349e-02f, -1.36380613e-01f, -1.18698739e-01f, -6.44765273e-02f, -2.29101524e-01f, -1.62110552e-01f,
  -9.10265073e-02f, 8.46807286e-02f, -9.48507860e-02f, 6.83340384e-03f, 4.66734543e-02f, 9.27203298e-02f, 5.10043800e-02f, 9.26728472e-02f, 7.41341487e-02f, 1.19637668e-01f,
  9.28545892e-02f, 5.58856949e-02f, 1.02355890e-01f, -8.50273296e-02f, 7.59330392e-02f, 3.43148150e-02f, 6.01719171e-02f, -5.75957559e-02f, 6.26930371e-02f, 1.33456051e-01f,
  5.47790639e-02f, -1.61775779e-02f, -7.01461956e-02f, -1.01038404e-02f, -7.63115752e-03f, -6.09516576e-02f, -1.96041483e-02f, 7.15496484e-03f, -8.81185532e-02f, 5.73019311e-02f,
  -1.01334676e-02f, -6.86608180e-02f, 2.43905075e-02f, 2.13686619e-02f, 3.58301699e-02f, 9.13832188e-02f, 5.26310643e-03f, -7.57928565e-02f, 5.08299135e-02f, 1.20343380e-01f,
  8.33377987e-02f, -3.58174331e-02f, -4.40240651e-02f, 1.30821345e-02f, 3.29766013e-02f, -6.08008690e-02f, -7.81191364e-02f, 3.85419242e-02f, -6.73882514e-02f, -6.07524700e-02f,
  1.44710243e-02f, -1.07945755e-01f, 7.81948343e-02f, 1.75983150e-04f, -8.95633548e-02f, 4.65547200e-03f, -8.75698850e-02f, 6.83855787e-02f, 9.46450233e-02f, 3.20621906e-03f,
  8.42263624e-02f, -7.33680427e-02f, -2.12676916e-02f, -1.20123588e-01f, -9.62176695e-02f, 1.05945870e-01f, -7.41564669e-03f, 3.30688432e-02f, -3.68646905e-02f, -9.49522387e-03f,
  -7.40764886e-02f, 3.52017879e-02f, 4.00441103e-02f, -2.30871979e-03f, -1.54045746e-02f, 9.25213397e-02f, 7.88855180e-02f, -4.45072465e-02f, -1.77394168e-03f, 1.25467584e-01f,
  6.26675636e-02f, 9.14106220e-02f, 3.19285542e-02f, 7.22846761e-02f, 4.60877307e-02f, -4.93579581e-02f, -2.49046851e-02f, -1.34570319e-02f, -2.52814908e-02f, 1.09011121e-01f,
  4.46692482e-02f, -2.04309255e-01f, -7.01171765e-03f, -6.34426773e-02f, -1.55847117e-01f, 2.51649953e-02f, -1.11983448e-01f, -3.01683843e-02f, -3.33519690e-02f, -5.64922765e-02f,
  -5.62420934e-02f, -1.08939447e-01f, -4.69269454e-02f, 4.65784520e-02f, -3.90187055e-02f, -8.09939653e-02f, -1.08846575e-01f, -6.49023755e-03f, 1.37964934e-01f, -6.94426894e-02f,
  -8.52584094e-02f, 8.77287835e-02f, 1.47597685e-01f, 1.21999547e-01f, 2.95324177e-02f, 1.31435305e-01f, 6.54395372e-02f, 4.49837856e-02f, -1.48983886e-02f, -1.79108158e-01f,
  -3.04844920e-02f, -7.94100910e-02f, 9.01028067e-02f, 1.76011994e-02f, -9.98164043e-02f, 2.73971092e-02f, -5.08901775e-02f, -6.09279983e-02f, -9.34115052e-02f, 2.83380225e-02f,
  -5.50798923e-02f, 2.49199979e-02f, 3.45759019e-02f, -1.03693418e-01f, -3.85240614e-02f, -9.81882960e-02f, 2.50950996e-02f, 2.49652825e-02f, -1.04913190e-02f, -1.16321474e-01f,
  -1.67488113e-01f, -1.31141201e-01f, -7.33393878e-02f, -4.82878722e-02f, -1.27590867e-02f, 3.80875617e-02f, -1.04924887e-01f, -2.79406086e-02f, 5.43484204e-02f, 3.88863645e-02f,
  -1.67429000e-02f, -2.80011967e-02f, -4.76383418e-02f, 1.78815536e-02f, -6.47751689e-02f, 8.04594234e-02f, -6.02265075e-02f, 3.75244468e-02f, -8.56675282e-02f, 5.82184196e-02f,
  9.60614905e-03f, 5.46398349e-02f, 6.03703186e-02f, 1.94110200e-02f, -7.26296827e-02f, -5.20523936e-02f, 8.12901556e-02f, 1.11649521e-02f, -6.36231620e-03f, 7.80907795e-02f,
  -1.91236734e-02f, 4.58020996e-03f, -3.04312129e-02f, 1.62518618e-03f, 3.98881882e-02f, 2.50762030e-02f, -3.34789930e-03f, 2.87074894e-02f, -6.80789798e-02f, 6.17667008e-03f,
  1.00597732e-01f, -7.26752728e-02f, 2.61509698e-02f, 6.09632544e-02f, 7.49255717e-03f, -1.93380918e-02f, -7.96400458e-02f, 3.20189968e-02f, -2.67878473e-02f, -6.07853569e-02f,
  3.17295305e-02f, 2.18488127e-02f, -9.69812125e-02f, -5.58231026e-02f, 1.47059364e-02f, 9.44956914e-02f, -5.08371778e-02f, 8.26175511e-02f, -5.02087995e-02f, 5.68206310e-02f,
  -1.26770260e-02f, 1.10115178e-01f, 5.65666221e-02f, 1.11215256e-01f, -5.33785932e-02f, 2.84690056e-02f, -7.46247619e-02f, -8.97360407e-03f, 1.14751078e-01f, 1.95150986e-01f,
  -6.03684857e-02f, 1.34481326e-01f, 4.26150374e-02f, -3.14595290e-02f, 2.81955469e-02f, 2.02620298e-01f, 3.13471496e-01f, 4.37486582e-02f, -4.34605740e-02f, 1.19065046e-01f,
  9.41255242e-02f, -1.30618185e-01f, -5.44720218e-02f, -1.01727687e-01f, 1.07996643e-01f, 1.30432621e-01f, 5.92376031e-02f, 3.19973938e-02f, -4.85566221e-02f, 1.01509936e-01f,
  -1.19272046e-01f, -5.80226146e-02f, -1.34988129e-02f, -1.68049447e-02f, -5.08855656e-02f, -1.19446263e-01f, -1.06686726e-02f, 3.48330773e-02f, 3.48519869e-02f, -4.25969101e-02f,
  -4.19098400e-02f, 2.04737708e-01f, -1.10080428e-01f, -6.59044385e-02f, -2.49608699e-02f, -5.50895818e-02f, -2.89813913e-02f, -4.39906120e-02f, -6.57680705e-02f, -9.35517102e-02f,
  -3.13051306e-02f, -8.37961808e-02f, -3.63718346e-02f, 3.48951407e-02f, 6.47251680e-02f, 2.24715453e-02f, -2.12856214e-02f, -6.78241858e-03f, -3.24525870e-02f, 6.30641133e-02f,
  9.22775194e-02f, 2.07608566e-02f, -2.62136832e-02f, -2.75973650e-03f, -8.69388320e-03f, 3.61987064e-03f, 3.08553297e-02f, -3.32757980e-02f, 5.11654988e-02f, -8.16881359e-02f,
  3.11620138e-03f, 5.15673347e-02f, -1.15923574e-02f, 8.16324651e-02f, -7.04585686e-02f, -7.94822425e-02f, 7.79125169e-02f, 3.06328703e-02f, -2.28744559e-02f, -1.44743333e-02f,
  3.28430943e-02f, 7.80692324e-02f, -4.22662683e-02f, 9.40867215e-02f, -3.29422094e-02f, 5.07931560e-02f, -4.42375913e-02f, -1.15067679e-02f, 4.14137915e-02f, -4.43549454e-02f,
  -3.60883437e-02f, 3.02618160e-03f, -2.59599127e-02f, 9.90981050e-03f, 1.02699280e-01f, 2.05355920e-02f, -4.04252708e-02f, -3.84795181e-02f, 3.77761163e-02f, 1.15710283e-02f,
  -2.29830131e-01f, 9.33803841e-02f, -1.23350628e-01f, 2.28266083e-02f, -9.03608277e-03f, -1.37134671e-01f, 5.43599389e-02f, 5.74254571e-03f, -6.71665594e-02f, 7.92119280e-02f,
  3.63743156e-02f, 3.68415564e-02f, -2.69521680e-02f, -6.76976219e-02f, -5.86819388e-02f, 3.25414576e-02f, -7.52936155e-02f, -2.66115293e-02f, -1.50796100e-02f, -1.33905321e-01f,
  -1.84560139e-02f, -2.83563547e-02f, -8.93831626e-02f, -4.80610952e-02f, -1.13702947e-02f, -3.12125050e-02f, -8.08421969e-02f, -8.03257152e-02f, -7.45814443e-02f, -1.48016527e-01f,
  2.11029779e-02f, -1.87965818e-02f, 1.46546274e-01f, 3.59800421e-02f, 1.61843956e-01f, 9.91838425e-03f, 3.38538662e-02f, 1.61848888e-01f, 9.28955451e-02f, -1.89572591e-02f,
  4.20248955e-02f, -7.61247128e-02f, -1.62446406e-02f, 5.16313165e-02f, 1.07972942e-01f, -1.56204705e-03f, 9.43429023e-02f, 4.92652366e-03f, 9.74978805e-02f, 1.31088262e-02f,
  -2.75268173e-03f, 4.35265675e-02f, 1.02877244e-01f, 5.67132421e-02f, -2.76028235e-02f, 7.60594755e-02f, 6.37854114e-02f, 1.34639427e-01f, 8.28381162e-03f, 7.62434378e-02f,
  5.63515462e-02f, 1.05227321e-01f, -1.27237076e-02f, -8.39820430e-02f, 2.12272927e-02f, 8.62770155e-03f, 4.19023484e-02f, -4.97395135e-02f, -5.83268851e-02f, 6.53124079e-02f,
  3.04424111e-02f, -6.82539269e-02f, 6.35962710e-02f, -8.72770548e-02f, -6.60341233e-02f, -2.73891794e-03f, 2.80075539e-02f, 6.68800920e-02f, -1.66331995e-02f, -4.45780456e-02f,
  -2.42495257e-02f, 6.04332872e-02f, 8.20748508e-02f, 5.45805506e-02f, 6.53141439e-02f, 7.67701343e-02f, -7.75671452e-02f, 5.01478277e-02f, -9.37540904e-02f, -2.53902264e-02f,
  7.93300569e-02f, 9.75078866e-02f, 5.74280648e-03f, -4.36933450e-02f, -6.03244938e-02f, -2.49477159e-02f, 9.68561694e-02f, -6.55308217e-02f, 3.15822810e-02f, 1.75241586e-02f,
  5.78707680e-02f, -6.83997869e-02f, -6.84625581e-02f, -3.72308865e-02f, 4.65590023e-02f, 4.62922379e-02f, -1.31604550e-02f, 1.15697440e-02f, -8.98068026e-02f, -4.54559810e-02f,
  2.90498231e-02f, 4.90742922e-02f, 5.42414282e-03f, 2.98216250e-02f, 7.22682402e-02f, 3.64138894e-02f, -1.47339283e-02f, 7.18798265e-02f, -1.44673837e-02f, -4.57115099e-02f,
  -9.08566415e-02f, 2.54635587e-02f, -4.88282964e-02f, -6.00548089e-02f, 3.31369117e-02f, 6.52026013e-02f, -1.13727590e-02f, -4.44502868e-02f, 4.85386066e-02f, 1.97123885e-02f,
  -7.36323446e-02f, -4.34723087e-02f, -6.95666596e-02f, 4.89435717e-02f, -6.44729808e-02f, -2.28167251e-02f, -9.11955759e-02f, 2.99924482e-02f, -7.45114610e-02f, 5.96217886e-02f,
  -1.76787172e-02f, 7.52858669e-02f, -3.72089408e-02f, 1.81869455e-02f, 4.21997756e-02f, -3.52895893e-02f, 6.22984432e-02f, 3.06191575e-02f, 2.72978451e-02f, -5.55348434e-02f,
  -2.19526321e-01f, 7.48475194e-02f, -1.16117269e-01f, -1.36303201e-01f, 8.66342559e-02f, 1.43098876e-01f, 3.67648453e-02f, -1.02888839e-02f, -5.14432564e-02f, -1.43849608e-02f,
  -7.31226057e-02f, 9.01083350e-02f, 4.59465459e-02f, 1.16670363e-01f, 6.58514351e-02f, -8.94516334e-02f, -1.89683232e-02f, 5.63722365e-02f, -1.30398367e-02f, 8.34956542e-02f,
  8.41559395e-02f, -6.69823885e-02f, -1.99651886e-02f, -9.44490135e-02f, 8.00987259e-02f, -8.18404406e-02f, -1.55552924e-01f, -1.10688485e-01f, 6.53003454e-02f, 3.22652198e-02f,
  -1.28771693e-01f, 3.54324616e-02f, 3.95133197e-02f, 9.57918018e-02f, -6.98207971e-03f, -5.47208376e-02f, -5.75764850e-02f, 8.05576369e-02f, -5.51108420e-02f, -2.55428012e-02f,
  1.21769365e-02f, 1.07704774e-01f, -8.76965970e-02f, -4.19631191e-02f, 2.37891451e-02f, -3.01397219e-03f, -1.21216387e-01f, -9.60416943e-02f, -1.07846268e-01f, -6.95978627e-02f,
  -3.40952463e-02f, 7.32946815e-03f, 1.34099554e-02f, -1.43777870e-03f, -8.56853276e-03f, 3.58316004e-02f, -1.02519490e-01f, -6.42933697e-02f, -6.21653311e-02f, -6.13861606e-02f,
  6.80103302e-02f, 2.56651752e-02f, -1.56043656e-02f, 3.84233668e-02f, 6.70236116e-03f, 1.03679132e-02f, 6.01763129e-02f, 1.45090148e-01f, -7.28137046e-02f, 2.60164589e-02f,
  7.93051496e-02f, 2.76717599e-02f, 1.29675604e-02f, -7.30116442e-02f, 7.81836659e-02f, -1.42308604e-02f, 6.35604262e-02f, -5.02884984e-02f, 4.61813621e-03f, 8.40005726e-02f,
  -1.10448515e-02f, -3.08650937e-02f, -2.78954562e-02f, -4.20167372e-02f, -2.26933286e-02f, -3.21437442e-03f, 4.11530361e-02f, -8.38311091e-02f, -1.33274332e-01f, 1.79242250e-02f,
  -2.36067697e-01f, 7.90269375e-02f, -6.20207265e-02f, -2.40011252e-02f, -3.71600538e-02f, 2.20756680e-02f, -3.81974056e-02f, 4.28932086e-02f, -4.00184356e-02f, -6.19550124e-02f,
  -3.30176130e-02f, -8.37345570e-02f, -4.03629988e-02f, 9.49934183e-04f, 5.41487187e-02f, -2.41299663e-02f, -4.22682576e-02f, 1.50838224e-02f, -4.99244034e-02f, 4.65264340e-04f,
  -1.72586497e-02f, -1.33606225e-01f, -9.04102903e-03f, -1.44334704e-01f, -1.04594648e-01f, -3.49085256e-02f, -5.10690324e-02f, -1.09189793e-01f, -1.17732771e-01f, -1.18942708e-01f,
  -1.50270447e-01f, -2.98582353e-02f, -8.62107519e-03f, -1.03796013e-02f, 4.33444716e-02f, -4.39069234e-02f, -1.05024621e-01f, 7.40251783e-03f, 5.65698174e-05f, -4.60325144e-02f,
  2.00937912e-02f, 5.70573583e-02f, -9.44712535e-02f, -8.95259529e-02f, -1.75156415e-01f, -2.37052385e-02f, -1.79374278e-01f, -9.63061675e-02f, -7.66242817e-02f, -3.00381240e-02f,
  -3.56202461e-02f, -6.89504668e-02f, -1.39404656e-02f, 5.49496599e-02f, -3.48723568e-02f, 6.86707348e-02f, -7.11151287e-02f, -6.41594529e-02f, -6.26415983e-02f, -5.35354018e-02f,
  1.91782825e-02f, 1.80593058e-02f, -9.14282873e-02f, -2.73091085e-02f, 8.23965147e-02f, -3.74314561e-02f, -7.44555444e-02f, 3.50894183e-02f, 8.72653723e-03f, -5.57607487e-02f,
  6.04054146e-03f, -1.14908274e-02f, -7.58731663e-02f, -5.58439549e-03f, 5.91677316e-02f, -1.12670287e-02f, -1.06872007e-01f, -6.18053926e-03f, -7.98544288e-02f, 5.20194545e-02f,
  -5.58993872e-03f, -1.05542699e-02f, -1.17837824e-01f, 1.88113358e-02f, -5.23275807e-02f, -7.95136765e-02f, -9.01791900e-02f, -1.96847599e-02f, -4.34661843e-02f, 1.32361325e-02f,
  9.17681232e-02f, -3.40142213e-02f, -4.75303158e-02f, 6.20771423e-02f, 8.85675382e-03f, -3.02642584e-02f, 3.06399260e-02f, 4.51649912e-02f, -1.67163387e-02f, -1.64797828e-02f,
  4.59655114e-02f, 4.44755889e-02f, -7.94833675e-02f, 4.44841497e-02f, -6.67888150e-02f, 4.46779020e-02f, -4.81156334e-02f, -2.73278169e-02f, -2.62016547e-03f, 6.19272031e-02f,
  -2.48122681e-02f, 3.29268426e-02f, 1.68690421e-02f, -5.80301732e-02f, -9.86766964e-02f, -3.38086151e-02f, 1.57062095e-02f, -5.37017286e-02f, -1.00383751e-01f, -1.41267572e-02f,
  8.28289613e-02f, -6.49084225e-02f, 4.67128567e-02f, 8.27266276e-03f, -1.56021006e-02f, 1.48765007e-02f, 2.51122862e-02f, -2.30812375e-02f, -3.14852074e-02f, -8.28903839e-02f,
  -4.34231497e-02f, -3.10014151e-02f, -4.54768836e-02f, 7.05011413e-02f, 7.68678337e-02f, -5.13079169e-04f, -3.73829678e-02f, -7.63330758e-02f, 2.03668140e-02f, -7.03117475e-02f,
  2.66647059e-02f, -9.25818011e-02f, -1.15390621e-01f, -3.50891501e-02f, 3.83867696e-02f, -4.03894624e-03f, 5.04807904e-02f, -6.25705197e-02f, -5.66176772e-02f, 4.26383242e-02f,
  -1.17225595e-01f, 2.51799021e-02f, 9.37706232e-02f, -1.03139229e-01f, -1.15712114e-01f, 4.33701538e-02f, -3.51150036e-02f, 4.58879732e-02f, -8.48466083e-02f, -8.67870301e-02f,
  -1.53907984e-02f, -5.87967336e-02f, 1.14434518e-01f, 1.23712115e-01f, -3.89908552e-02f, 4.35880609e-02f, 3.13570760e-02f, 1.02956310e-01f, 8.53892863e-02f, -6.65593296e-02f,
  -3.85687463e-02f, -1.41221005e-02f, -1.08783573e-01f, 5.70629500e-02f, -1.49238676e-01f, -6.75445944e-02f, 3.39374654e-02f, -4.70268168e-02f, -2.84303129e-02f, -4.94502708e-02f,
  1.55867800e-01f, -1.02398135e-01f, 2.66556386e-02f, -2.02086195e-02f, -4.11427654e-02f, 4.89819907e-02f, 1.16792344e-03f, 1.43286427e-02f, -6.41088635e-02f, -8.23843405e-02f,
  6.03951961e-02f, -5.20959646e-02f, -1.15849590e-02f, 1.21288626e-02f, -6.51246235e-02f, -3.66564021e-02f, -7.90508930e-03f, -7.64942244e-02f, 4.29646261e-02f, 2.47809924e-02f,
  -9.26188454e-02f, -9.62757766e-02f, 1.47574088e-02f, -8.15589353e-02f, 7.67595544e-02f, -6.29518973e-03f, 6.52459497e-03f, 3.81023027e-02f, -2.25090282e-03f, -3.59085575e-02f,
  -6.06241487e-02f, -2.86006983e-02f, -2.47388650e-02f, -8.19466040e-02f, -2.84042992e-02f, -3.24783358e-03f, -1.95161682e-02f, -4.76407632e-02f, -2.39656437e-02f, -7.28487596e-02f,
  -5.02687283e-02f, -8.72209296e-03f, 8.30048174e-02f, -7.38741681e-02f, 4.69226316e-02f, -2.12763250e-02f, -4.79025692e-02f, -2.56537460e-02f, -4.72039580e-02f, 8.07891488e-02f,
  -3.04049533e-02f, -1.81670524e-02f, -8.10505524e-02f, 1.49824133e-03f, -1.48574319e-02f, 7.66370818e-02f, 3.18718776e-02f, -1.51272016e-02f, -3.66636403e-02f, 5.73745854e-02f,
  3.59205343e-02f, 1.10038750e-01f, 4.54897583e-02f, -8.56009424e-02f, -1.01087965e-01f, -1.20942844e-02f, 4.66716178e-02f, -2.04988271e-02f, -6.53065518e-02f, -5.20362295e-02f,
  -5.43441717e-03f, 1.52095286e-02f, -4.36098129e-02f, 3.19040082e-02f, -8.40825215e-03f, -9.00194049e-03f, 4.33797352e-02f, -1.95797663e-02f, 5.91203608e-02f, 3.44366580e-02f,
  -9.10877809e-02f, -8.65439922e-02f, 7.80411288e-02f, -5.74013069e-02f, -8.45177099e-03f, -9.86700878e-03f, -2.13200711e-02f, 3.70847248e-02f, -5.68817779e-02f, -3.80607881e-02f,
  -1.47773385e-01f, -1.92154162e-02f, 6.02223314e-02f, -1.03921711e-01f, 2.57781032e-03f, -5.92679670e-03f, 2.53971107e-02f, -6.00505285e-02f, -2.15140730e-02f, 7.22340215e-03f,
  3.54761034e-02f, -5.01937680e-02f, 5.97876459e-02f, 1.47316344e-02f, -6.70062453e-02f, 2.91268658e-02f, 4.19249684e-02f, -4.04989719e-02f, 9.45373327e-02f, 1.11400113e-01f,
  3.89628112e-02f, 4.41015651e-03f, -1.10743962e-01f, 5.49668781e-02f, -5.91518823e-03f, -5.37919030e-02f, -6.64477125e-02f, 8.12438428e-02f, 9.16965902e-02f, 1.03826813e-01f,
  2.26403952e-01f, -7.37473667e-02f, -3.13790441e-02f, -1.32346913e-01f, 2.09795288e-03f, 4.67048250e-02f, -9.22082216e-02f, 3.12542953e-02f, -8.22868049e-02f, -3.93109396e-02f,
  -8.93019140e-02f, -1.10898670e-02f, -1.12261828e-02f, -7.51920789e-02f, -5.65834641e-02f, 6.39164895e-02f, -3.57974647e-03f, 3.88107114e-02f, 4.63423282e-02f, -1.85157638e-02f,
  -4.26742248e-02f, -5.56646027e-02f, 3.90663035e-02f, 5.06860390e-03f, 3.24371271e-02f, 7.54827783e-02f, 5.99764250e-02f, 3.28563415e-02f, -5.18068112e-02f, -1.02594057e-02f,
  3.72669101e-02f, 6.06042035e-02f, 5.88447340e-02f, 4.21437994e-02f, -7.89991915e-02f, -6.00647815e-02f, -6.52446821e-02f, -2.92433705e-02f, -6.95090517e-02f, 8.90101120e-03f,
  -8.99277776e-02f, -6.42193928e-02f, -5.94874769e-02f, 4.42573540e-02f, 4.86710254e-04f, -1.87916569e-02f, 7.83659220e-02f, 6.00587465e-02f, 4.15375605e-02f, 4.05090638e-02f,
  6.24334365e-02f, 7.50316009e-02f, -2.97761429e-02f, -3.64062004e-02f, -2.37526675e-03f, 8.35674722e-03f, 7.02512264e-02f, -3.72547284e-02f, -2.89093871e-02f, 3.17411614e-04f,
  9.38793570e-02f, -1.20371155e-01f, 5.03072254e-02f, -4.08287346e-02f, 2.93184817e-02f, 3.47760096e-02f, 8.84760842e-02f, -7.14752749e-02f, -1.14408033e-02f, 9.52433646e-02f,
  6.48339763e-02f, 1.18593378e-02f, 6.73933476e-02f, 9.18877944e-02f, -5.77580482e-02f, 8.22950080e-02f, -1.03398338e-02f, 2.17062701e-02f, -4.94891021e-04f, 1.18747912e-01f,
  5.42980693e-02f, 4.96579222e-02f, 1.78464893e-02f, 1.34506702e-01f, 7.29632974e-02f, 2.41579339e-02f, 1.75804570e-01f, 2.08544787e-02f, 1.04872502e-01f, 8.24521184e-02f,
  -1.90864503e-01f, -8.27410445e-02f, 4.08911593e-02f, -3.81049402e-02f, -5.68984821e-02f, 6.32228255e-02f, -1.93540994e-02f, 7.22321644e-02f, 4.28315327e-02f, -1.32612780e-01f,
  -1.81495603e-02f, -5.01797013e-02f, -4.67389748e-02f, -2.11110692e-02f, 4.02491912e-02f, -7.26159066e-02f, 1.14726378e-02f, -1.07505701e-01f, 7.76147321e-02f, -5.08764051e-02f,
  -6.56933337e-02f, -1.52674586e-01f, -6.84548989e-02f, 5.71418069e-02f, -1.04310408e-01f, -1.00625157e-01f, -1.25653520e-01f, -5.27269728e-02f, 6.86910525e-02f, -1.75451964e-01f,
  -2.91446503e-02f, -6.91883918e-03f, 7.53658637e-02f, 1.16201555e-02f, -4.94587123e-02f, -6.30172044e-02f, 4.05725241e-02f, 2.87239905e-02f, -4.29051742e-02f, 3.17569524e-02f,
  4.97446731e-02f, -3.11448462e-02f, -8.96516144e-02f, 1.23640308e-02f, 2.87075266e-02f, 4.85008508e-02f, -4.22856137e-02f, -3.91192734e-02f, -8.12515151e-03f, 1.10355221e-01f,
  5.91268875e-02f, 8.65470544e-02f, 9.67422351e-02f, 2.47700997e-02f, 4.96824086e-03f, 6.10354990e-02f, -2.72642989e-02f, -1.32295061e-02f, 9.54476185e-03f, -1.37748867e-01f,
  1.20947789e-02f, -3.40828039e-02f, 7.30287507e-02f, 4.50886041e-03f, -4.76928949e-02f, 7.03733340e-02f, -5.34254983e-02f, -6.26552254e-02f, 3.58150937e-02f, -4.02753316e-02f,
  -3.04358881e-02f, 4.69334945e-02f, -6.88589513e-02f, -1.75947025e-02f, -7.84126052e-04f, -1.41232368e-02f, 7.52002224e-02f, 3.14573087e-02f, 2.28944942e-02f, 6.77493438e-02f,
  8.09033439e-02f, -8.70402679e-02f, -5.99446297e-02f, 8.13598037e-02f, 7.53195956e-02f, 1.63529869e-02f, -4.33167852e-02f, 7.49948472e-02f, 7.68830255e-02f, 9.72468555e-02f,
  -1.53000966e-01f, 6.25013560e-02f, -9.77758877e-03f, -5.70619740e-02f, -5.12887202e-02f, 2.55405717e-02f, -5.82744777e-02f, 4.60590273e-02f, 2.23542638e-02f, 6.70751333e-02f,
  -6.46945275e-03f, 5.98696992e-02f, -8.13355744e-02f, -6.92519397e-02f, 2.14460772e-02f, 5.60673513e-02f, 5.53090423e-02f, -8.71579126e-02f, 1.14310116e-01f, 1.13968633e-01f,
  -3.91395278e-02f, -4.85259853e-02f, 2.82936879e-02f, -4.48586904e-02f, -4.40016575e-02f, -8.09671953e-02f, -3.23930718e-02f, -7.12772012e-02f, -2.64466275e-02f, -1.99421346e-01f,
  1.19144127e-01f, 1.33537166e-02f, -5.09562343e-02f, -3.66059579e-02f, -1.26105398e-01f, -7.76249766e-02f, 8.81532114e-03f, -5.68519607e-02f, -1.10776033e-02f, 8.43644664e-02f,
  8.68991315e-02f, 4.88295928e-02f, -3.34930494e-02f, 1.31298348e-01f, 9.55970585e-02f, -6.22562617e-02f, -2.91500743e-02f, 1.11949272e-01f, -1.77097600e-02f, -1.76030863e-02f,
  9.51765105e-02f, 3.56507152e-02f, 1.70558602e-01f, 1.81075986e-02f, 3.00436635e-02f, 9.89028737e-02f, 1.20926037e-01f, -3.83639671e-02f, 8.16909596e-02f, 1.47722870e-01f,
  1.32248908e-01f, -5.60666714e-03f, 5.28385118e-02f, 3.54900882e-02f, 1.20495716e-02f, 1.72544513e-02f, -5.35480157e-02f, 3.26303653e-02f, 2.14360598e-02f, -2.00707614e-02f,
  1.20417885e-02f, 2.04489976e-02f, -4.76577282e-02f, 4.16154824e-02f, 5.00868857e-02f, -6.62743300e-02f, -4.61912639e-02f, 7.01778755e-02f, 7.94376014e-04f, -3.35389450e-02f,
  -2.45178845e-02f, 3.75936925e-02f, 3.28670181e-02f, -5.11211157e-02f, 8.02950584e-04f, -4.04101834e-02f, 4.01874781e-02f, 5.09436727e-02f, 9.47071146e-03f, 7.94137120e-02f,
  2.16550729e-03f, 6.83428943e-02f, -3.52189615e-02f, 2.03213319e-02f, 3.32882144e-02f, -8.65359381e-02f, 9.57086161e-02f, -1.97383761e-02f, 6.93112891e-03f, 5.93770705e-02f,
  -1.97996870e-02f, 1.41689554e-02f, 8.06266591e-02f, -6.05265647e-02f, -7.16637298e-02f, 7.76815638e-02f, -5.34733990e-04f, 8.80124420e-02f, 1.23990409e-01f, 4.20722626e-02f,
  7.73279965e-02f, 9.43585336e-02f, -4.05469397e-03f, 1.06079597e-03f, 8.05223063e-02f, -7.17413099e-03f, 1.14934325e-01f, -2.57441439e-02f, 7.32287616e-02f, -1.47988843e-02f,
  -6.93058670e-02f, 3.93488035e-02f, 2.46459544e-02f, 2.05550697e-02f, 5.34895882e-02f, 6.72399700e-02f, -7.99715146e-02f, 1.21602956e-02f, -7.20284134e-02f, -1.20604010e-02f,
  8.39027017e-03f, -4.03015576e-02f, -9.33857858e-02f, 6.34073466e-02f, 3.25409621e-02f, 7.11571723e-02f, 3.83426324e-02f, 6.37289062e-02f, 5.45866452e-02f, -4.10591736e-02f,
  -7.89553151e-02f, -9.68662053e-02f, -5.96612282e-02f, -5.05438447e-02f, -1.75198633e-02f, 3.53703368e-03f, -4.54368740e-02f, -4.30666432e-02f, 8.48118663e-02f, 1.72833819e-02f,
  5.84839284e-02f, -1.00611463e-01f, -1.28297880e-01f, -1.07476711e-01f, -2.40571517e-03f, -1.21501580e-01f, -6.83574975e-02f, -2.91303918e-02f, 3.33827399e-02f, -1.53419897e-01f,
  -8.62367004e-02f, 2.00006436e-03f, -1.36510935e-02f, 7.31574222e-02f, 1.67957768e-02f, -1.09259903e-01f, -1.37912169e-01f, -4.01112959e-02f, 1.47634163e-03f, 2.19591707e-02f,
  6.05923943e-02f, -4.96291071e-02f, 6.48813322e-02f, 8.73901546e-02f, -9.57983721e-04f, 9.53049064e-02f, -1.46156717e-02f, -8.99010524e-02f, 1.65748820e-02f, -1.38815895e-01f,
  1.45426625e-02f, -4.86098714e-02f, 8.69124848e-03f, 2.38197278e-02f, 3.13569643e-02f, -1.41176512e-03f, -2.12912895e-02f, 1.89355835e-02f, 2.55437884e-02f, -1.01807587e-01f,
  -1.92839447e-02f, -2.38587596e-02f, 7.16977790e-02f, 8.79480168e-02f, 1.70066096e-02f, -8.00051168e-03f, -3.64865474e-02f, -2.89458651e-02f, -5.19700460e-02f, 1.80710107e-02f,
  -8.44958872e-02f, -2.22984459e-02f, 3.25385742e-02f, 2.87306421e-02f, 1.05070360e-01f, -1.24408007e-02f, 3.43268961e-02f, 3.43744233e-02f, -1.09101944e-02f, 1.46455187e-02f,
  -1.14401123e-02f, 2.50174329e-02f, 8.95704329e-02f, 1.37342131e-02f, 7.52954185e-03f, 2.79692840e-02f, 5.68215214e-02f, 3.14166956e-02f, 5.03701828e-02f, -5.66002401e-03f,
  -6.63305968e-02f, -3.88241485e-02f, -4.47340421e-02f, 8.96380320e-02f, 7.82122314e-02f, -5.95441498e-02f, -5.82026131e-02f, 4.73148897e-02f, -1.76893640e-02f, -3.01640872e-02f,
  -4.45302427e-02f, -5.89108691e-02f, -1.74874458e-02f, 1.19875565e-01f, 1.84913501e-02f, 6.92160353e-02f, -9.89392027e-02f, -1.42335743e-02f, 4.10505198e-03f, -6.54239878e-02f,
  1.63897112e-01f, -9.42507312e-02f, -5.12061045e-02f, -1.38407769e-02f, -3.14231999e-02f, -4.17135954e-02f, -5.01841605e-02f, 8.73454958e-02f, 1.12763969e-02f, 1.37272142e-02f,
  3.02943978e-02f, 3.60374786e-02f, 8.75494033e-02f, 1.94908790e-02f, -2.97210440e-02f, -9.38716829e-02f, -5.70105128e-02f, -5.48508912e-02f, 5.90069368e-02f, 3.38386558e-02f,
  1.58903860e-02f, -9.11735222e-02f, -3.15456837e-03f, 3.54801156e-02f, 9.48288590e-02f, -3.62678468e-02f, 5.95195740e-02f, -6.09541871e-02f, -4.69686314e-02f, 3.25346664e-02f,
  -5.96988276e-02f, -2.59306461e-01f, 1.83908250e-02f, -3.14263888e-02f, 1.03044778e-01f, 1.25606611e-01f, -4.89027565e-03f, -2.69312002e-02f, -3.56182121e-02f, -2.62886398e-02f,
  -1.26264900e-01f, -1.01178735e-01f, 1.97587274e-02f, 2.10975148e-02f, -1.21597581e-01f, 7.64849335e-02f, 1.19253546e-02f, 1.50587246e-01f, 1.72475204e-01f, 6.24161912e-03f,
  -3.11816465e-02f, 3.84510309e-03f, -5.45709804e-02f, -5.81597798e-02f, -6.47591427e-02f, -3.77211608e-02f, 5.35849407e-02f, -4.47330549e-02f, 6.75810734e-03f, -1.07310988e-01f,
  2.67440915e-01f, -9.42583457e-02f, 1.87398233e-02f, -1.35429546e-01f, 6.10348815e-03f, 6.29229331e-03f, -6.65565138e-04f, -5.85968494e-02f, -6.86411038e-02f, 6.44008294e-02f,
  -7.42529705e-02f, 1.73462369e-02f, -3.28205191e-02f, -1.66746601e-02f, -2.43658926e-02f, 1.74507182e-02f, -2.27714851e-02f, -1.35698438e-01f, -1.33179203e-01f, -1.02562865e-03f,
  -2.08636016e-01f, 1.44878896e-02f, 4.16608863e-02f, 5.20902649e-02f, 1.67884789e-02f, -9.40034017e-02f, -1.82752982e-02f, 6.66720932e-03f, 1.71213895e-02f, 2.96566505e-02f,
  -9.74886678e-03f, 6.69865459e-02f, 2.28238348e-02f, 2.09964216e-02f, -1.37593318e-02f, 7.21661001e-02f, 9.04934332e-02f, -8.36376660e-03f, 5.16805910e-02f, 6.34483993e-02f,
  -7.87792727e-03f, 5.23974225e-02f, 1.94737855e-02f, 4.45845425e-02f, -4.13833782e-02f, -1.62739474e-02f, -2.14926247e-02f, -6.75234422e-02f, -3.35256271e-02f, -1.54334288e-02f,
  1.11304345e-02f, 3.51454988e-02f, -7.06604868e-02f, -7.71492161e-03f, -1.14054726e-02f, 2.10924055e-02f, 4.37239483e-02f, -6.66647255e-02f, -3.38176414e-02f, -1.36229265e-02f,
  1.89174801e-01f, -5.81543446e-02f, 8.46665427e-02f, -2.10031662e-02f, 1.12454660e-01f, -3.74033339e-02f, 5.93281724e-02f, -6.41939044e-02f, -9.64233745e-03f, 8.60979222e-03f,
  -2.55609471e-02f, 6.28249794e-02f, -9.26428586e-02f, 4.59500542e-03f, 1.23601146e-01f, 7.17084110e-02f, -7.88469315e-02f, -3.45452465e-02f, -3.52842361e-02f, -5.77329770e-02f,
  -5.62206954e-02f, 1.57197982e-01f, 1.07604884e-01f, 1.53773010e-01f, 2.95617115e-02f, 1.25542805e-01f, 1.10541925e-01f, 1.38119474e-01f, 1.13108464e-01f, 2.07151651e-01f,
  -1.20008759e-01f, -1.15781933e-01f, -1.21068265e-02f, -8.95984992e-02f, 1.75509788e-02f, -6.40169308e-02f, -1.03943616e-01f, 8.45975336e-03f, -3.54695739e-03f, -6.04095943e-02f,
  5.72663918e-02f, 4.46569994e-02f, -9.99990851e-02f, -5.60314208e-02f, -1.29150063e-01f, -1.52023092e-01f, -2.09155768e-01f, -5.57221062e-02f, -8.84086639e-02f, -1.05647981e-01f,
  -1.06970854e-01f, -4.23205458e-02f, -1.31462321e-01f, -1.11281276e-01f, 2.04342734e-02f, 4.06315811e-02f, -5.54727670e-03f, -1.38833791e-01f, -2.25773025e-02f, -9.99468490e-02f,
  -1.06228769e-01f, 1.46806434e-01f, 1.58730596e-02f, -4.29579709e-03f, 1.42824021e-03f, 4.54727001e-02f, -8.28422010e-02f, -3.80248055e-02f, -2.30167769e-02f, 5.33325821e-02f,
  2.10451782e-02f, 4.43134736e-03f, -6.62511587e-02f, 6.30461723e-02f, -1.02954097e-01f, -5.27694523e-02f, 2.37715784e-02f, 1.15955807e-02f, -4.73366678e-03f, 1.45130185e-02f,
  4.77120988e-02f, -9.51766223e-02f, 3.76442708e-02f, 1.00967623e-02f, -2.78677568e-02f, -6.58062473e-02f, -4.64285873e-02f, 3.78559902e-02f, -7.41668344e-02f, -2.99554802e-02f,
  -1.06284805e-02f, 5.78412451e-02f, 5.23007009e-03f, 7.35529698e-03f, 7.59013593e-02f, -1.07515818e-02f, -8.22818652e-02f, -4.56955731e-02f, 1.72443818e-02f, 7.16172950e-03f,
  1.52010033e-02f, 3.60070285e-03f, -2.11073570e-02f, -9.34540257e-02f, 3.38629186e-02f, -7.40162283e-02f, -2.58945525e-02f, -4.05736715e-02f, -4.92974333e-02f, -7.56545179e-03f,
  -3.43062058e-02f, 5.57509400e-02f, -5.94703481e-02f, -1.65211596e-02f, -3.92390937e-02f, -1.07150987e-01f, -8.92261341e-02f, -8.38237628e-02f, -5.34126423e-02f, -1.37779647e-02f,
  -1.94039289e-02f, 6.15877286e-02f, 1.27116200e-02f, -3.21126394e-02f, 5.10208793e-02f, -8.44107717e-02f, 6.96056858e-02f, -1.55907096e-02f, 3.30747105e-02f, 9.15002972e-02f,
  -2.38394588e-02f, -6.22392353e-03f, -7.33801723e-02f, 3.68182510e-02f, 6.08028658e-02f, 2.40299478e-02f, -1.65946409e-02f, 6.19037226e-02f, -9.01312605e-02f, -2.13259663e-02f,
  -1.12536512e-01f, -5.81217073e-02f, 3.20734223e-03f, 2.70841941e-02f, 6.59140712e-03f, -5.57311215e-02f, -7.28194565e-02f, 4.18339148e-02f, -9.08873102e-04f, -1.62724629e-01f,
  -7.77179226e-02f, -1.31014273e-01f, 6.27287030e-02f, -1.56921695e-03f, -1.49432153e-01f, -1.29314691e-01f, -2.07103580e-01f, 3.32698748e-02f, 2.29757484e-02f, -6.82267249e-02f,
  -1.32533953e-01f, -3.41691114e-02f, -2.83278134e-02f, -2.32438222e-02f, -3.98981720e-02f, -1.31957561e-01f, 1.84885673e-02f, -6.74670236e-03f, -3.43362056e-02f, -9.24338847e-02f,
  2.41227672e-02f, 3.15065160e-02f, 4.71672937e-02f, -1.73805282e-02f, 1.47303920e-02f, 5.46406917e-02f, 1.68380756e-02f, 3.04546282e-02f, 6.95277080e-02f, -7.81799015e-03f,
  -1.83895066e-01f, -6.82206526e-02f, 4.70663346e-02f, -2.01655161e-02f, -5.07148914e-02f, -5.28683849e-02f, 3.28853913e-02f, 7.62119293e-02f, -4.49799448e-02f, 1.83097720e-02f,
  6.08424656e-02f, -4.55941334e-02f, -5.53041622e-02f, -5.01614511e-02f, -7.37451911e-02f, 5.69130257e-02f, 1.22045521e-02f, 1.20116852e-01f, 7.38074630e-02f, 4.94874381e-02f,
  -1.99031867e-02f, -7.27627724e-02f, 1.02011278e-01f, 2.51825061e-02f, 6.75905198e-02f, 1.71615593e-02f, 1.11673720e-01f, 7.00876024e-03f, 8.10345858e-02f, -6.01799935e-02f,
  -7.69501505e-03f, -7.01154843e-02f, 6.70138970e-02f, -2.92673055e-02f, -2.98993494e-02f, 3.72649953e-02f, -7.11028045e-03f, 5.05736507e-02f, 7.02544078e-02f, -4.60601449e-02f,
  9.38288122e-02f, 6.53629825e-02f, 5.89924119e-02f, -4.41786163e-02f, -1.42036350e-02f, 5.15750311e-02f, 3.99363600e-02f, -9.53542590e-02f, -7.34362230e-02f, -9.37035365e-04f,
  -4.74249944e-02f, 8.62652622e-03f, -1.95865314e-02f, -3.44725966e-04f, 4.95982065e-04f, 3.66388471e-03f, 7.32091954e-03f, -4.67155166e-02f, -9.48055089e-03f, 2.10132487e-02f,
  1.73479002e-02f, 1.77760065e-01f, -3.66838165e-02f, 5.61656663e-03f, 1.18396282e-02f, -2.65891291e-02f, -7.99887776e-02f, 8.58696625e-02f, -1.55661837e-03f, -1.03534542e-01f,
  -2.93701962e-02f, -4.01241556e-02f, -5.52081363e-03f, -5.72317056e-02f, -2.43176837e-02f, -2.70015677e-03f, -2.10425891e-02f, -8.97623040e-03f, 4.28608544e-02f, -1.37866719e-03f,
  7.58283213e-02f, -1.22395761e-01f, 3.68042700e-02f, -7.47494027e-02f, -5.67699932e-02f, -4.89567593e-02f, -8.04802328e-02f, 8.38320181e-02f, 2.73643844e-02f, -5.99077381e-02f,
  -7.46867135e-02f, -1.80278327e-02f, -2.80545764e-02f, 1.04055353e-01f, -7.58937821e-02f, -5.39118648e-02f, -2.24952146e-01f, -5.15661389e-03f, -1.55404815e-02f, 2.06449477e-04f,
  -3.93040404e-02f, -7.22121596e-02f, 3.33475508e-02f, -6.27190024e-02f, -2.43498147e-01f, -1.32601306e-01f, -9.41952318e-02f, -2.17486113e-01f, -1.65237650e-01f, -1.48362905e-01f,
  -2.65858620e-02f, -7.95388967e-02f, -6.94752038e-02f, -5.50713530e-03f, 2.59270873e-02f, 1.09307677e-01f, 7.02865096e-03f, -8.20930756e-04f, 2.46208534e-03f, -7.00086169e-03f,
  -3.62065509e-02f, -4.02573496e-02f, -4.30310592e-02f, -1.18879028e-01f, -6.35817945e-02f, 3.31004001e-02f, 1.08651733e-02f, 3.24449055e-02f, 5.34423906e-03f, 7.56703243e-02f,
  -2.68487763e-02f, 5.95257729e-02f, -6.36373460e-02f, -8.02716315e-02f, 4.47263047e-02f, -3.40413861e-02f, -1.15932070e-01f, -1.30125538e-01f, 3.07278074e-02f, -8.60497430e-02f,
  -4.22713719e-02f, -9.44985971e-02f, -2.42701694e-02f, -6.04224913e-02f, 3.61190625e-02f, 2.51745917e-02f, -6.23930339e-03f, -4.78836504e-04f, -8.96464586e-02f, 1.19253814e-01f,
  6.82933023e-04f, 6.60793483e-02f, -6.43203035e-02f, 1.74784139e-02f, -8.30771327e-02f, -7.11281039e-03f, -8.77595786e-03f, -1.95972808e-02f, 3.48260216e-02f, -6.41851948e-05f,
  1.48344422e-02f, 4.00614031e-02f, 2.85694711e-02f, 5.57304174e-02f, -3.61143202e-02f, 6.76725656e-02f, -6.25672638e-02f, 2.64470256e-03f, -1.83150601e-02f, -1.85456276e-02f,
  -9.08986703e-02f, 5.07540070e-03f, -2.37466376e-02f, 7.56218210e-02f, -9.49789360e-02f, -6.22295551e-02f, 7.45400935e-02f, -1.35746419e-01f, 2.23881844e-02f, -1.36720195e-01f,
  2.04918742e-01f, -1.94801301e-01f, -5.23435324e-02f, 4.54059951e-02f, 5.23226745e-02f, 5.14701307e-02f, 8.79866257e-02f, 2.90233064e-02f, 5.88420220e-02f, 1.74352545e-02f,
  -5.03456257e-02f, -6.13642670e-02f, 4.80368454e-03f, -7.05744848e-02f, 2.63009896e-03f, -9.75329280e-02f, -4.10335734e-02f, -1.14928586e-02f, 2.70328633e-02f, 4.72815447e-02f,
  -1.02598062e-02f, -5.41393273e-02f, 2.91880500e-02f, -4.19826098e-02f, 1.72448345e-02f, -6.15608282e-02f, 2.30270158e-03f, 2.76730303e-02f, -6.13526106e-02f, -5.48793301e-02f,
  5.39871454e-01f, -6.35775402e-02f, -3.89382273e-01f, 1.65207833e-01f, -6.46550730e-02f, -2.09274352e-01f, -2.03229830e-01f, 1.97773222e-02f, 1.61640376e-01f, -5.96306436e-02f,
  -1.83043331e-01f, -7.62644969e-03f, -2.13383548e-02f, -8.59982595e-02f, -5.40449470e-03f, -1.26727596e-01f, -1.21450976e-01f, -1.77791551e-01f, -7.48489648e-02f, -1.34850547e-01f,
  -1.01935476e-01f, 9.74240080e-02f, 1.35335580e-01f, -3.34388614e-02f, -7.98374265e-02f, -9.62048844e-02f, -8.09676647e-02f, -9.24805254e-02f, -1.61080956e-01f, -2.08063215e-01f,
  -3.66762936e-01f, -4.55753133e-02f, 5.73931634e-02f, 1.57974064e-02f, -9.81887057e-02f, 1.17927544e-01f, -4.86858673e-02f, 5.08262031e-02f, 9.13257673e-02f, -4.28254828e-02f,
  -6.67524114e-02f, -5.60632162e-02f, -1.52682913e-02f, -5.68002127e-02f, -3.81766148e-02f, -8.55823606e-03f, 6.02169186e-02f, -2.85474956e-02f, -6.50525391e-02f, -1.02788590e-01f,
  -7.66374767e-02f, -1.15961827e-01f, 5.31522781e-02f, -1.18323669e-01f, -4.62669581e-02f, -1.85119342e-02f, -5.51946908e-02f, -1.03360310e-01f, -1.14030831e-01f, -5.34995943e-02f,
  -4.33983989e-02f, -1.33676559e-03f, -3.57670300e-02f, 2.83461306e-02f, 8.19030032e-02f, 2.57987659e-02f, -3.19998898e-02f, 4.45984788e-02f, 1.70661453e-02f, -3.93645326e-03f,
  3.96966524e-02f, -6.91431910e-02f, -8.80029723e-02f, 4.93353233e-02f, 2.60264724e-02f, 3.12135350e-02f, -1.02977837e-02f, -1.38060562e-02f, 2.41847546e-03f, 5.99001311e-02f,
  6.93133175e-02f, -1.78384259e-02f, 1.37966834e-02f, -7.42560476e-02f, -2.80882493e-02f, -2.93492544e-02f, -1.81207154e-02f, -7.21982792e-02f, 7.76200369e-02f, 4.65826839e-02f,
  1.94320276e-01f, -9.98702347e-02f, 1.02900460e-01f, 8.91611502e-02f, 8.52729846e-03f, -3.06038540e-02f, -4.49170619e-02f, 3.82517017e-02f, -6.95976019e-02f, -3.93220522e-02f,
  -1.28795445e-01f, 1.09524922e-02f, 7.03854635e-02f, -1.40996024e-01f, 2.83632092e-02f, 6.32672161e-02f, 2.27055997e-02f, 1.81805100e-02f, 1.36350989e-02f, -3.16178724e-02f,
  1.43718356e-02f, 1.57944784e-01f, 2.19451398e-01f, 1.24067329e-01f, 1.00567713e-02f, 1.96223885e-01f, 7.31190965e-02f, 2.20930725e-02f, 1.02750041e-01f, 3.00155520e-01f,
  1.10488579e-01f, 2.94741876e-02f, 6.41379580e-02f, -6.57741204e-02f, -1.22929320e-01f, -1.71261519e-01f, 5.36963867e-04f, -7.14717107e-03f, 5.77853695e-02f, -1.97838973e-02f,
  -9.91058126e-02f, -1.48224831e-02f, -4.46261023e-04f, -2.94930805e-02f, 1.31259844e-01f, -5.45231476e-02f, 3.15016247e-02f, 1.52420193e-01f, 2.58992873e-02f, -3.94788794e-02f,
  -2.51684431e-02f, 5.87226935e-02f, 5.36434166e-02f, 6.12599701e-02f, -1.11008389e-02f, 1.11237150e-02f, -5.79074584e-02f, 1.26616526e-02f, 5.01012988e-03f, 1.00038990e-01f,
  -8.11987221e-02f, 9.59344953e-02f, 1.86057808e-03f, -7.23254830e-02f, -2.26667859e-02f, 2.36737039e-02f, 5.93857802e-02f, 8.37437212e-02f, 7.84893632e-02f, 1.93902738e-02f,
  -6.13803715e-02f, -4.94315997e-02f, 5.43689691e-02f, -1.52869085e-02f, 1.43769253e-02f, -6.81720451e-02f, 6.06957562e-02f, 6.24810234e-02f, 7.16172531e-02f, -3.01716762e-04f,
  5.07838055e-02f, 3.70732322e-02f, -2.99966559e-02f, 5.39843850e-02f, 6.78551942e-02f, -5.87569401e-02f, -7.36931488e-02f, -5.71312122e-02f, 2.29780725e-03f, -4.61726487e-02f,
  6.96624517e-02f, 5.58816902e-02f, 2.85865143e-02f, 5.33390008e-02f, 8.33042245e-03f, 7.45471241e-03f, -2.50816327e-02f, -7.46541172e-02f, -1.00499783e-02f, 5.30975834e-02f,
  -8.18425342e-02f, 5.95466867e-02f, 4.57108095e-02f, -2.31332313e-02f, -2.09404957e-02f, -3.85551415e-02f, 6.45335689e-02f, 1.32105441e-03f, 3.99866886e-02f, 8.39595217e-03f,
  -4.99571674e-02f, -6.12080237e-03f, -7.31855780e-02f, -3.59405316e-02f, 5.51222451e-02f, 6.91352487e-02f, -2.92862975e-03f, 7.81820342e-02f, 3.28936167e-02f, -6.32268488e-02f,
  4.90625128e-02f, -5.67864776e-02f, -4.87220399e-02f, 6.82295114e-02f, -8.33161697e-02f, 9.24417898e-02f, 2.39955764e-02f, 6.84301555e-02f, -8.25542212e-03f, -2.41592843e-02f,
  -1.17979459e-01f, -5.31174652e-02f, 6.36813939e-02f, 5.28068431e-02f, 2.20523980e-02f, 1.85603779e-02f, 1.82772987e-02f, 9.69752204e-03f, 3.19534950e-02f, -7.42315799e-02f,
  -8.08252692e-02f, -3.33331712e-02f, -5.76753281e-02f, -1.58960447e-02f, -7.96243697e-02f, 1.56257991e-02f, -2.93370169e-02f, -9.48124975e-02f, -8.46875980e-02f, 1.04892934e-02f,
  1.16262659e-01f, -3.78505774e-02f, 1.30922139e-01f, 5.42260259e-02f, -1.17302518e-02f, -4.89680767e-02f, -5.12168892e-02f, 8.13738927e-02f, -2.84896996e-02f, 9.02861655e-02f,
  1.81607023e-01f, 3.33468802e-02f, 7.18000010e-02f, 8.01117271e-02f, 1.38117895e-01f, 5.38078323e-02f, -9.92490947e-02f, -9.03842272e-04f, 9.76543874e-02f, 1.01817183e-01f,
  4.76624072e-02f, 2.31691785e-02f, -5.34272147e-03f, -2.03073043e-02f, -2.25759260e-02f, -3.74059565e-02f, 6.30772784e-02f, -9.63860832e-04f, 1.72212571e-02f, -1.15645416e-01f,
  7.46232644e-02f, -5.73037844e-03f, 9.54795331e-02f, -8.88185762e-03f, -5.36976978e-02f, -8.10627043e-02f, 8.44043773e-03f, 1.33128362e-02f, -8.72868970e-02f, 2.36006733e-02f,
  -5.03050610e-02f, 3.79842781e-02f, -5.39509654e-02f, -8.91459584e-02f, -3.25595625e-02f, 1.87771656e-02f, -1.06233455e-01f, 7.12645426e-02f, 4.88150516e-04f, 6.89838901e-02f,
  5.72358556e-02f, -5.72849438e-02f, -9.54977516e-03f, -8.70466083e-02f, 4.46270742e-02f, 7.57829547e-02f, 2.55478229e-02f, -6.22818188e-04f, 7.02886581e-02f, -1.07488848e-01f,
  4.77244966e-02f, -6.75093904e-02f, 8.14283863e-02f, -8.10665116e-02f, -7.42474273e-02f, -3.28517035e-02f, 5.70585858e-03f, 6.78312182e-02f, -3.99138443e-02f, -4.65908572e-02f,
  -2.29282002e-03f, 1.20322956e-02f, 2.43196245e-02f, 1.15902731e-02f, 3.77790555e-02f, 2.63400329e-03f, -7.86485150e-02f, -4.85805124e-02f, -2.45570275e-03f, 3.49922031e-02f,
  -4.11809795e-02f, -8.96144062e-02f, 1.18439281e-02f, -5.01343869e-02f, -7.05959201e-02f, 6.06587753e-02f, -1.00388832e-01f, -2.44286135e-02f, -2.62957532e-02f, -1.69609711e-02f,
  -1.69120915e-02f, 1.71070501e-01f, 1.56970490e-02f, -6.81045651e-02f, -9.34971794e-02f, 7.92963207e-02f, 6.73892200e-02f, 3.24903578e-02f, 8.16262141e-02f, 7.28349462e-02f,
  2.75379494e-02f, 5.28528579e-02f, -9.46331993e-02f, -5.78280985e-02f, 5.42491116e-02f, -3.45722511e-02f, 1.27529129e-02f, -3.62522230e-02f, -2.16575861e-02f, 6.35307953e-02f,
  -9.23643541e-03f, -2.69691106e-02f, -5.02927676e-02f, 7.58048370e-02f, -2.16756910e-02f, -3.22300270e-02f, 4.36148457e-02f, 1.06687397e-02f, 2.32149083e-02f, 5.53963752e-03f,
  -8.32283124e-02f, -1.47392713e-02f, 3.12775001e-02f, -1.75762370e-01f, -2.05536351e-01f, -1.23654217e-01f, -1.13632806e-01f, -6.03274144e-02f, -8.02331641e-02f, -7.55525678e-02f,
  1.06379896e-01f, 2.39089951e-01f, 1.86748266e-01f, 2.57130653e-01f, 1.11835539e-01f, 2.22295728e-02f, -1.23936445e-01f, 1.38991132e-01f, 2.37226233e-01f, -5.96047454e-02f,
  -1.88635029e-02f, -6.69407696e-02f, 6.28391802e-02f, 6.97763860e-02f, -9.68570560e-02f, 1.09285802e-01f, -3.03895096e-03f, -8.55142400e-02f, 7.52641335e-02f, -5.58313839e-02f,
  2.02707618e-01f, -2.53464673e-02f, 1.37727126e-01f, -5.23688621e-04f, -4.71089996e-04f, -5.04096299e-02f, 3.70321497e-02f, 4.02480550e-02f, -2.32103840e-02f, 1.51737398e-02f,
  5.13090240e-03f, 4.08530980e-03f, -1.32584758e-02f, -1.81569569e-02f, -1.00242674e-01f, 4.00392199e-03f, -2.93519162e-02f, 3.67482975e-02f, -2.14570612e-02f, 8.06815028e-02f,
  -1.07493468e-01f, 6.14029635e-03f, 1.31172255e-01f, 6.72517940e-02f, -3.72675359e-02f, 7.57276118e-02f, 9.88371670e-02f, 6.43966570e-02f, 3.83759732e-03f, -1.00179821e-01f,
  -6.54965825e-03f, 8.26421455e-02f, 1.06265239e-01f, 1.60491932e-02f, -2.82651633e-02f, 3.20361108e-02f, -2.66330857e-02f, 4.66120709e-03f, 3.43009681e-02f, -2.04540063e-02f,
  8.73612911e-02f, -1.24220308e-02f, 4.14184816e-02f, -1.28620667e-02f, 5.00750951e-02f, -2.11434104e-02f, -7.62100667e-02f, 4.29826155e-02f, 6.86039776e-02f, -2.50071250e-02f,
  5.25615960e-02f, 7.15469792e-02f, -4.32960875e-02f, 3.54197696e-02f, 1.87839326e-02f, -5.43678515e-02f, -1.46173062e-02f, 5.40633053e-02f, -1.38865039e-01f, -3.77193876e-02f,
  -8.63898993e-02f, 1.76072821e-01f, -5.36728241e-02f, 1.02366731e-01f, -1.18687056e-01f, 3.04533113e-02f, -5.61185414e-03f, 5.59622385e-02f, -1.27655029e-01f, 3.65258604e-02f,
  -5.45971617e-02f, -1.32669777e-01f, 1.55944368e-02f, -4.12032641e-02f, -3.23343650e-02f, -1.65549573e-02f, -5.17593995e-02f, -5.70214447e-03f, 6.43346012e-02f, 9.81243234e-03f,
  -3.39528807e-02f, -8.41930956e-02f, 6.86128363e-02f, 6.58885986e-02f, -5.94633678e-03f, 7.38499761e-02f, 7.81722963e-02f, 5.28415963e-02f, 1.00140467e-01f, -5.10659218e-02f,
  3.72529067e-02f, 3.28446948e-03f, -1.21987068e-05f, 1.29534796e-01f, -1.56425387e-02f, -2.81787254e-02f, -1.31900692e-02f, 1.02377035e-01f, 8.76528397e-02f, 2.30446961e-02f,
  -3.27624381e-02f, 6.12016469e-02f, 5.94655722e-02f, 9.61981043e-02f, 1.60563588e-02f, -2.56916769e-02f, 1.61830336e-01f, -5.92802372e-03f, -6.73722029e-02f, -4.34283651e-02f,
  8.45668390e-02f, 1.51472911e-01f, 1.17369451e-01f, 1.37041628e-01f, 1.42161503e-01f, 5.81758060e-02f, 5.09216972e-02f, 4.95540388e-02f, 1.07202634e-01f, 1.66281581e-01f,
  5.87773062e-02f, -5.87128140e-02f, 6.50391653e-02f, 1.25273271e-02f, 2.83316057e-02f, -1.71562694e-02f, 1.78446136e-02f, 6.26359358e-02f, -6.12295978e-03f, 7.06950128e-02f,
  -5.13507873e-02f, -2.63287406e-02f, -6.63927570e-03f, -1.02194831e-01f, -1.06096275e-01f, -1.22622319e-01f, 4.52108756e-02f, -2.63187103e-02f, -1.94221307e-02f, 2.27935985e-03f,
  2.42391489e-02f, -5.20323366e-02f, 2.98704114e-03f, -5.60784750e-02f, -9.37362015e-03f, 1.08069666e-02f, 4.39335927e-02f, -8.51392150e-02f, -1.09614909e-01f, -6.85918033e-02f,
  6.96058273e-02f, -3.25981006e-02f, 5.55876195e-02f, -6.80078613e-03f, -4.03248966e-02f, -5.77248575e-04f, 1.01574726e-01f, -2.35130126e-03f, -3.95119973e-02f, -8.64172056e-02f,
  -8.83362740e-02f, 2.60489378e-02f, -1.96369886e-02f, 4.03691567e-02f, -8.99064988e-02f, 6.23399653e-02f, -5.94638549e-02f, 2.86100991e-02f, -3.40581760e-02f, -7.75213987e-02f,
  -7.45730773e-02f, 6.31702766e-02f, -3.75915356e-02f, 8.75138715e-02f, -6.45335540e-02f, -3.15465555e-02f, -3.68168764e-02f, -8.10756385e-02f, 4.65464592e-02f, 8.67387932e-03f,
  5.57100028e-02f, -6.11532852e-02f, 6.75765499e-02f, 3.96765582e-02f, 1.16271950e-01f, -1.45115228e-02f, -4.33970205e-02f, -6.25733659e-02f, 2.36109849e-02f, -7.46039599e-02f,
  6.73864558e-02f, 6.84996471e-02f, -1.84763095e-03f, 3.94568518e-02f, -5.92630841e-02f, 2.26372816e-02f, 5.07924110e-02f, 8.27819854e-02f, 2.62115244e-02f, -5.10588363e-02f,
  1.69752967e-02f, -2.31297202e-02f, -6.43398762e-02f, -1.06008641e-01f, 3.14772241e-02f, 2.98476722e-02f, -9.89846513e-02f, 3.33564281e-02f, -1.07540816e-01f, -4.94535118e-02f,
  4.12893087e-01f, 5.83913773e-02f, 7.98743218e-02f, 1.33877710e-01f, 1.06898107e-01f, 1.70804843e-01f, 1.50745839e-01f, 9.88211334e-02f, -2.17255913e-02f, -6.82198326e-04f,
  1.43531561e-01f, 5.58605567e-02f, 3.78106087e-02f, -7.77840093e-02f, 1.43335938e-01f, -1.07015269e-02f, -1.68899849e-01f, 3.79731469e-02f, 2.21641175e-02f, -4.90954407e-02f,
  -8.44457000e-02f, -2.41958983e-02f, 1.60855845e-01f, -9.69941169e-02f, -6.17819540e-02f, -1.35069937e-01f, 7.08955154e-02f, -4.92286496e-02f, -9.42564979e-02f, -1.88064232e-01f,
  -6.08466938e-02f, 2.68309474e-01f, -1.26789019e-01f, -5.13176955e-02f, 2.55390611e-02f, -7.68974945e-02f, 2.83823572e-02f, -8.31569135e-02f, 9.57813412e-02f, -6.68411627e-02f,
  -4.01853696e-02f, 1.04951914e-02f, 5.70184849e-02f, 4.08733413e-02f, 5.28507084e-02f, -4.13622633e-02f, -5.87223321e-02f, -1.23378588e-03f, -6.78978637e-02f, -4.43978049e-02f,
  2.07692739e-02f, -9.40268952e-03f, 1.44375548e-01f, -3.74674462e-02f, 1.20368905e-01f, -6.75988570e-02f, 1.75739937e-02f, 7.30333924e-02f, 3.00578251e-02f, -7.04971701e-02f,
  -3.43923224e-03f, -3.53729874e-02f, 5.99044263e-02f, 7.13179260e-02f, -5.11178263e-02f, -1.40483966e-02f, 8.08917731e-03f, -4.13429216e-02f, 5.55265648e-03f, -6.92849010e-02f,
  -1.39257610e-02f, 2.20853873e-02f, 7.47157335e-02f, -3.34564112e-02f, -7.19248727e-02f, 4.94028516e-02f, -2.33544614e-02f, -4.23335092e-04f, 4.35642973e-02f, 6.94839135e-02f,
  2.25166697e-02f, -4.02068421e-02f, -1.67238060e-02f, -5.76696582e-02f, 3.22956853e-02f, -9.31044072e-02f, 2.32415702e-02f, 2.98559815e-02f, 5.46115227e-02f, -1.44196777e-02f,
  -9.14652720e-02f, 1.65865168e-01f, -9.87817124e-02f, -3.20720603e-03f, 3.96545231e-03f, -5.10866567e-03f, 5.98108694e-02f, 4.18510251e-02f, 1.67622071e-04f, 1.34243127e-02f,
  7.95633495e-02f, -1.38331740e-03f, 4.65365686e-02f, 1.32111441e-02f, 2.33807955e-02f, -4.99691628e-02f, 4.08728719e-02f, 2.87398393e-03f, -1.98416058e-02f, -3.48927453e-02f,
  -9.17986855e-02f, 7.51381889e-02f, 6.14027940e-02f, -9.55445319e-03f, -5.29838279e-02f, 8.23905170e-02f, 6.45809099e-02f, -5.70287518e-02f, -3.54798813e-03f, 3.63232121e-02f,
  -2.28072271e-01f, 1.72115769e-02f, 5.26184216e-03f, -1.61533773e-01f, -2.75119543e-02f, -1.41948909e-01f, 1.46779735e-02f, -8.85465071e-02f, -1.00174444e-02f, -1.16375513e-01f,
  -5.55614941e-02f, 7.13639185e-02f, 3.32219340e-02f, 3.28579992e-02f, -3.67596857e-02f, -4.99427766e-02f, -1.08636850e-02f, 2.49499381e-02f, -6.19414216e-03f, 7.37061426e-02f,
  4.13407050e-02f, 3.60019617e-02f, -6.25759661e-02f, 6.94399551e-02f, -9.51132085e-03f, -2.58302651e-02f, 4.92563881e-02f, -1.27415881e-02f, 1.76406801e-02f, -8.79472792e-02f,
  2.37786308e-01f, -1.37613237e-01f, -9.45594832e-02f, 6.80026263e-02f, 2.97485031e-02f, -4.41043116e-02f, 1.08607906e-04f, -5.85938543e-02f, -6.58206195e-02f, -3.56430672e-02f,
  5.59512116e-02f, 6.50233552e-02f, 7.94331431e-02f, -1.63906310e-02f, -1.53428586e-02f, -5.63918464e-02f, -5.11753820e-02f, 4.62893322e-02f, -2.86848452e-02f, -4.82158512e-02f,
  3.24222110e-02f, -6.31756410e-02f, -2.49270257e-02f, -5.66775501e-02f, 6.67697340e-02f, 3.87575179e-02f, 1.33289276e-02f, 1.35959238e-02f, 8.88214111e-02f, -2.16899477e-02f,
  -9.69495345e-03f, 2.77108531e-02f, 1.09971697e-02f, -5.11340387e-02f, -5.42136747e-03f, -3.28346342e-02f, 4.10820618e-02f, -1.79419741e-02f, 1.31863297e-03f, -6.63296282e-02f,
  7.32903406e-02f, 8.18860754e-02f, -7.80893862e-02f, 3.30779217e-02f, 6.79908767e-02f, -1.07536919e-03f, 3.14086191e-02f, 6.95290267e-02f, 2.81959027e-02f, 2.11784262e-02f,
  -2.86052823e-02f, 3.07293143e-02f, 2.11785603e-02f, 2.15019993e-02f, -6.39858991e-02f, -9.42768827e-02f, -9.62039158e-02f, -1.81127209e-02f, -3.33850570e-02f, 6.98040146e-03f,
  1.63967848e-01f, -6.47536591e-02f, -5.45436051e-03f, 3.67074311e-02f, -4.40089703e-02f, -1.88834034e-02f, 1.28217954e-02f, 9.39215645e-02f, 6.20671846e-02f, 1.05802808e-03f,
  5.57614528e-02f, 6.03877902e-02f, 7.76945278e-02f, -3.69493552e-02f, 1.05653666e-01f, -1.05613843e-02f, 1.00046329e-01f, 7.64155164e-02f, 3.86955147e-03f, 7.31564090e-02f,
  -6.46549016e-02f, 9.36170220e-02f, -1.32741760e-02f, 1.40548259e-01f, -7.40151405e-02f, 7.99141377e-02f, 8.95944387e-02f, 8.46749768e-02f, 8.30552727e-02f, 1.72873542e-01f,
  -1.82590395e-01f, -1.54232562e-01f, -1.08127162e-01f, -1.43343538e-01f, -1.22214526e-01f, -2.27118898e-02f, -1.01788081e-01f, -4.22722064e-02f, -5.72954528e-02f, -4.12471555e-02f,
  -1.15264550e-01f, -3.16179655e-02f, -1.32573079e-02f, -1.52002145e-02f, 4.58879210e-02f, -1.83750957e-01f, -8.63036290e-02f, -7.76819214e-02f, 1.57377943e-01f, 4.40847240e-02f,
  1.59085989e-02f, -7.04931468e-02f, 1.80843286e-02f, 6.22143149e-02f, -1.07518405e-01f, 9.68959369e-03f, -6.78868890e-02f, -1.01684861e-01f, 1.48720969e-03f, -1.75687969e-01f,
  -5.82341217e-02f, 4.31938395e-02f, 6.63925856e-02f, -8.22872594e-02f, 3.09998114e-02f, 2.69331597e-02f, -1.11580074e-01f, 2.14440804e-02f, 8.29460919e-02f, 1.83044001e-02f,
  -6.02688529e-02f, -3.08448495e-03f, -7.14340955e-02f, -6.62498474e-02f, -2.06520632e-02f, 6.51769638e-02f, -6.48195595e-02f, 3.80050614e-02f, -7.11871497e-03f, 3.50947753e-02f,
  5.21036088e-02f, -6.72281608e-02f, 1.45593416e-02f, 9.75979343e-02f, 5.38131362e-03f, -8.32374580e-03f, 8.01251910e-04f, -3.56107503e-02f, 1.70902442e-02f, -6.94362894e-02f,
  2.52689756e-02f, -1.75957419e-02f, -4.26017493e-02f, 1.14400033e-02f, -4.72696079e-03f, 4.39915955e-02f, 6.42623305e-02f, -6.87314942e-02f, -5.72716519e-02f, -1.92035921e-02f,
  6.35483908e-03f, -3.01936306e-02f, 4.44583893e-02f, -4.16521765e-02f, 2.40048077e-02f, -9.38110277e-02f, 1.33302594e-02f, -2.03752387e-02f, -3.46262045e-02f, -2.16078535e-02f,
  4.21240292e-02f, -4.64258492e-02f, -7.06484094e-02f, 5.58431372e-02f, 9.99707822e-03f, 4.62595485e-02f, 3.74779329e-02f, 2.26639844e-02f, 4.79261838e-02f, 1.05074979e-01f,
  -2.75496691e-02f, 1.13340355e-01f, -1.17946751e-01f, -4.96580778e-03f, -9.98490304e-02f, -6.93524396e-03f, -3.85439210e-02f, 4.54764180e-02f, -1.26696248e-02f, -6.53063580e-02f,
  -3.87325021e-03f, 5.18590324e-02f, 4.22749333e-02f, 5.68798801e-04f, -3.36203761e-02f, 3.16019766e-02f, -9.39025581e-02f, 5.92771466e-05f, 5.01572601e-02f, 1.78607926e-03f,
  -8.84219557e-02f, 1.72933412e-03f, -6.48814142e-02f, -1.02072547e-03f, 4.48202267e-02f, -2.86356490e-02f, -4.30048630e-02f, -9.30195898e-02f, 7.22008571e-02f, -4.95931245e-02f,
  -3.59984413e-02f, 7.03138113e-02f, -1.18894018e-01f, 1.90490380e-01f, 2.18471855e-01f, 1.51783049e-01f, 2.37460569e-01f, 4.94598113e-02f, 1.66797251e-01f, 1.03629626e-01f,
  9.64956135e-02f, 1.11729056e-01f, 7.92214200e-02f, -1.91675350e-02f, 5.42885736e-02f, 1.63561508e-01f, 1.11081466e-01f, 2.78349989e-03f, 1.08909816e-01f, 1.33085519e-01f,
  1.49118140e-01f, -2.65554693e-02f, -1.17753884e-02f, -1.88771263e-02f, 1.69675112e-01f, 1.65318280e-01f, 4.51664701e-02f, 9.29990634e-02f, -3.08934730e-02f, -2.32795514e-02f,
  -2.01382503e-01f, -1.41522557e-01f, 1.03734560e-01f, 1.02826223e-01f, -9.30387229e-02f, -7.91582018e-02f, 6.75504059e-02f, -4.70692813e-02f, -3.64791900e-02f, 3.97431813e-02f,
  1.52167287e-02f, -9.24521461e-02f, -7.29348063e-02f, 4.04196195e-02f, -7.47270659e-02f, -9.01334137e-02f, -5.86112961e-03f, -8.73469561e-03f, 5.61743975e-02f, -1.22300901e-01f,
  1.58148259e-02f, -9.92962196e-02f, -8.10913593e-02f, -2.85494160e-02f, -7.65289143e-02f, 3.10629234e-02f, 3.88093591e-02f, 4.70612049e-02f, -1.03628017e-01f, -6.57183677e-02f,
  3.09690349e-02f, -1.00370146e-01f, 5.80256246e-02f, 4.33109812e-02f, -3.26451659e-02f, 4.81950939e-02f, 1.11610051e-02f, -1.19279064e-02f, 4.94795479e-02f, 2.73149945e-02f,
  5.66134043e-02f, 6.83660060e-02f, 1.06806429e-02f, -8.53384435e-02f, -4.30309074e-03f, -2.85407584e-02f, -3.38243060e-02f, 2.61111762e-02f, -2.26308443e-02f, 3.52984965e-02f,
  -1.44309849e-02f, 1.77665036e-02f, 2.07545199e-02f, 9.74957459e-03f, 2.21864618e-02f, 4.65182588e-02f, -4.94154245e-02f, 5.04312925e-02f, -2.75750384e-02f, -1.11742655e-03f,
  5.56351356e-02f, 6.12586252e-02f, 5.55830300e-02f, -2.19728183e-02f, 2.00450961e-02f, -7.69452378e-02f, -4.03020903e-02f, -3.31021585e-02f, 3.13038868e-03f, -3.30256261e-02f,
  -7.12075084e-02f, -6.24355972e-02f, -6.21126890e-02f, 2.83697341e-02f, 7.21762180e-02f, -1.48838814e-02f, -6.60692081e-02f, -5.08516468e-03f, 6.48718178e-02f, -3.37419100e-02f,
  7.27664977e-02f, -5.10732681e-02f, 9.61990096e-03f, -3.06752715e-02f, 1.12967357e-01f, 6.09187782e-02f, 4.88227904e-02f, -4.83722724e-02f, -9.83928815e-02f, -2.71758605e-02f,
  1.82397619e-01f, -7.63398632e-02f, 1.32796913e-01f, 3.74647975e-02f, 3.40272486e-02f, 6.41143844e-02f, 6.33218214e-02f, -6.38124943e-02f, -5.90688512e-02f, 1.15652699e-02f,
  -6.12809397e-02f, -1.13837339e-01f, 1.39933964e-02f, 1.26077468e-02f, -3.63293961e-02f, 3.53091769e-03f, -3.18893939e-02f, 9.23792720e-02f, -6.72635762e-03f, 1.31368816e-01f,
  8.37685689e-02f, 8.58673453e-02f, 4.15032618e-02f, 7.52856806e-02f, 7.73734525e-02f, 2.22602058e-02f, 3.52775156e-02f, 5.36901951e-02f, -9.22801048e-02f, 1.76161211e-02f,
  -8.23334232e-02f, 1.49531260e-01f, 3.20739262e-02f, -3.02208178e-02f, -8.68272595e-03f, 3.57056893e-02f, -5.87168559e-02f, 1.21923178e-01f, -5.71147203e-02f, -1.88605040e-02f,
  9.93140880e-03f, 1.17594205e-01f, 7.38113560e-03f, -1.17222723e-02f, 6.60743341e-02f, -2.12224256e-02f, 1.38141019e-02f, -9.15416237e-03f, -8.53468776e-02f, 9.66232419e-02f,
  -1.32431462e-01f, 4.49862257e-02f, 1.86845493e-02f, 2.74782553e-02f, -5.67899570e-02f, 5.19725531e-02f, -3.22725140e-02f, -8.52093939e-03f, -4.13455106e-02f, -3.41968276e-02f,
  -8.68952367e-04f, 5.73421642e-02f, -1.12044215e-02f, -1.05641559e-02f, -2.32098978e-02f, -3.99537720e-02f, -8.52015987e-02f, 4.09824075e-03f, -6.11573495e-02f, -7.80892745e-02f,
  2.93100588e-02f, 1.74203310e-02f, 5.78227639e-03f, -9.25682038e-02f, -7.54741058e-02f, -4.96522821e-02f, -3.85759398e-03f, -6.07196577e-02f, 1.34553919e-02f, -6.43820986e-02f,
  -4.10938598e-02f, 5.30689247e-02f, 4.68829982e-02f, -4.63571167e-03f, 2.57951524e-02f, 3.76919918e-02f, -1.36899957e-02f, 2.88053025e-02f, -5.05694672e-02f, -2.22925153e-02f,
  2.34135762e-02f, -6.28134748e-03f, -1.16895132e-01f, -9.51957554e-02f, 4.63102423e-02f, 2.12145224e-02f, -8.16303119e-02f, 7.67119112e-04f, -1.07582234e-01f, -2.96211652e-02f,
  -5.05461581e-02f, 5.63383549e-02f, 5.10750227e-02f, -9.83754843e-02f, -6.06378168e-02f, 5.38124293e-02f, -7.20753223e-02f, 2.14249804e-03f, -5.73394932e-02f, -3.71759608e-02f,
  1.60498321e-02f, 3.58207081e-03f, 2.52451673e-02f, -6.40342571e-03f, 8.81793424e-02f, -9.70738158e-02f, 1.08647496e-01f, 4.87312451e-02f, 8.15637931e-02f, 1.03647634e-01f,
  2.39157900e-02f, -1.10466875e-01f, -7.35924169e-02f, 1.98264122e-01f, 1.22213162e-01f, -1.93582371e-01f, -3.58989567e-01f, -1.74999088e-01f, 7.86040276e-02f, -4.92173433e-02f,
  -3.78372520e-02f, 2.39725504e-02f, 3.36223803e-02f, 1.38337258e-03f, -2.03166440e-01f, -1.80234700e-01f, -1.24056444e-01f, -7.38787502e-02f, -1.11640908e-01f, -6.62789494e-02f,
  9.98368836e-04f, 5.08406535e-02f, -1.99600458e-02f, 3.27354111e-03f, 1.55071273e-01f, 1.41562238e-01f, 1.41539976e-01f, 1.61519080e-01f, 1.45986015e-02f, 2.38080129e-01f,
  1.27964661e-01f, 5.94431348e-02f, 4.27174978e-02f, 4.64382768e-02f, 6.82405904e-02f, -6.69767484e-02f, -7.93604180e-02f, 5.39659057e-03f, -7.51542524e-02f, 7.22218007e-02f,
  7.66577721e-02f, 2.45325193e-02f, 3.92958634e-02f, 5.62755093e-02f, -7.03099146e-02f, -1.10468686e-01f, 3.44454572e-02f, -1.32878721e-02f, -7.60840029e-02f, -1.03631698e-01f,
  -1.04394384e-01f, -3.89877446e-02f, -4.43930589e-02f, -7.49166906e-02f, -4.26609106e-02f, 7.51267374e-02f, 9.70901083e-03f, 1.30110472e-01f, 6.44757077e-02f, 4.71631363e-02f,
  8.54369812e-03f, -3.14335190e-02f, 6.61910549e-02f, -9.19550061e-02f, -4.62703854e-02f, 2.88927518e-02f, 6.61377907e-02f, -2.27083359e-02f, 7.88034499e-03f, -7.85382688e-02f,
  -2.50771735e-02f, -3.44121940e-02f, 5.28704636e-02f, 5.21666072e-02f, 2.52526323e-03f, 3.57713215e-02f, -5.64650111e-02f, -7.41982013e-02f, 3.49849239e-02f, 1.01245511e-02f,
  1.46618346e-02f, -5.24236914e-03f, -3.74405901e-03f, -1.54929329e-03f, 1.05820224e-02f, 3.33000533e-02f, 2.89926156e-02f, -4.09879796e-02f, -5.69172613e-02f, 1.22059351e-02f,
  1.07150123e-01f, -1.52297363e-01f, 6.55703843e-02f, -3.10349204e-02f, 5.11952788e-02f, 2.56436076e-02f, 7.29877278e-02f, 4.55313697e-02f, 9.02783778e-03f, -6.92770556e-02f,
  -7.91684017e-02f, -5.24163619e-02f, -2.93659400e-02f, -7.00896382e-02f, -1.41516188e-02f, -5.90002276e-02f, -1.19718626e-01f, -6.23434298e-02f, -5.36350533e-02f, -2.94947112e-03f,
  -6.95076138e-02f, -7.37039894e-02f, -1.11522697e-01f, -1.09353125e-01f, -6.83897138e-02f, -1.33538336e-01f, -9.45884511e-02f, -4.74941470e-02f, -1.75700665e-01f, -1.23300150e-01f,
  3.56711447e-01f, 2.07537804e-02f, 9.93987545e-02f, 8.34594145e-02f, 1.13072678e-01f, 1.36295944e-01f, 2.33668432e-01f, 9.31597874e-02f, -4.03519124e-02f, 8.31698254e-02f,
  7.87516087e-02f, -3.92295569e-02f, -3.74496393e-02f, -8.34019184e-02f, -5.88315167e-02f, -2.93926839e-02f, -2.18082368e-02f, 4.12552059e-02f, 1.64574552e-02f, -2.11923569e-02f,
  -8.83114487e-02f, -3.44070978e-02f, 1.13927096e-01f, -9.72172804e-03f, -2.35226899e-02f, -1.19519904e-02f, 3.75995412e-02f, -4.95465621e-02f, -7.84126297e-02f, -4.45233062e-02f,
  -5.74925989e-02f, 9.15826559e-02f, -1.30728837e-02f, 2.74318416e-04f, 3.86058278e-02f, -7.77187049e-02f, -2.10475866e-02f, -7.45114386e-02f, -2.89799608e-02f, -5.69613911e-02f,
  1.78844575e-02f, -1.85294934e-02f, 3.45089845e-02f, -8.93552974e-03f, 3.23018171e-02f, 4.62614046e-03f, -9.74013433e-02f, 5.50471470e-02f, 2.47622654e-02f, -8.66485238e-02f,
  -9.95345935e-02f, 4.57018468e-04f, 9.18735564e-02f, 7.24117532e-02f, 7.55840689e-02f, 6.09433204e-02f, -6.66789860e-02f, -3.28322537e-02f, -5.24809733e-02f, -4.21826281e-02f,
  -8.66467282e-02f, 6.26493171e-02f, 5.27096726e-03f, -1.17009431e-02f, -2.67654583e-02f, 5.43931611e-02f, -8.25096220e-02f, -5.29162325e-02f, 8.04467406e-03f, 4.88091558e-02f,
  -5.41381352e-02f, 8.37576017e-03f, -6.41863197e-02f, 8.21311250e-02f, 5.93244620e-02f, 3.65320705e-02f, -2.63419971e-02f, 6.45332411e-02f, 2.81922147e-02f, 1.62304826e-02f,
  -6.73049241e-02f, 6.77399039e-02f, 1.00894645e-01f, -4.32075523e-02f, 8.75382870e-03f, 4.08054888e-02f, -4.33657505e-03f, -2.19191015e-02f, 4.81519029e-02f, 6.76553473e-02f,
  -1.13287546e-01f, -3.60967102e-03f, 7.36670941e-02f, -6.73372746e-02f, 3.65532711e-02f, 3.64377722e-02f, 7.61476206e-03f, -7.02960044e-02f, 5.43710925e-02f, -5.01747653e-02f,
  5.10307588e-02f, -3.60424556e-02f, 5.38576581e-02f, 6.07549958e-02f, 1.53501211e-02f, 5.95683306e-02f, -1.05849557e-01f, 4.95272456e-03f, -4.08167094e-02f, 7.79110491e-02f,
  2.97225397e-02f, -2.49202717e-02f, 1.36468902e-01f, 8.12412873e-02f, 7.03790411e-02f, -7.32928813e-02f, -1.65325738e-02f, -3.55797298e-02f, 1.00724176e-01f, -1.78527012e-02f,
  1.32420301e-01f, 3.93532924e-02f, -6.28618076e-02f, 7.19464272e-02f, -7.73167908e-02f, -1.32999141e-02f, 5.81182539e-04f, -3.61869484e-02f, 7.52913505e-02f, -1.88703742e-02f,
  -1.25265839e-02f, -6.66474598e-03f, -5.25227524e-02f, -1.06319956e-01f, 2.72581410e-02f, 1.83057487e-02f, 3.44817042e-02f, -2.28954740e-02f, 8.24166834e-02f, -9.00092497e-02f,
  5.75035475e-02f, 9.37255919e-02f, -2.57772463e-03f, 2.30661919e-03f, -4.73213606e-02f, -8.97676647e-02f, 3.05903647e-02f, -7.68027753e-02f, -7.75957629e-02f, -9.45282951e-02f,
  6.40862286e-02f, 1.32117420e-01f, -5.28021064e-03f, -4.15489636e-02f, -1.62059034e-03f, 8.53248239e-02f, 3.90819274e-02f, 5.63009307e-02f, -8.55884328e-03f, 1.69864595e-02f,
  -5.31299599e-02f, -2.98609156e-02f, 3.91723625e-02f, -3.08136232e-02f, 8.71418789e-02f, 8.44288468e-02f, 7.58968443e-02f, -9.75224897e-02f, 2.33279299e-02f, -3.23544294e-02f,
  -2.24821176e-03f, 6.06665350e-02f, 1.47326738e-02f, -2.36878544e-02f, -1.54373562e-02f, 1.94517300e-02f, -3.68688372e-03f, 2.80355755e-02f, 6.67311475e-02f, 9.68391914e-03f,
  -8.00853968e-02f, 5.79460561e-02f, -7.81623125e-02f, -2.49642264e-02f, 4.35587764e-02f, -7.95904100e-02f, 3.64549011e-02f, 3.71582732e-02f, -1.19529337e-01f, -4.79709283e-02f,
  -6.48252070e-02f, -5.06343991e-02f, -1.02327071e-01f, 9.42993611e-02f, -6.33607209e-02f, -9.66587216e-02f, 2.80604921e-02f, 6.85995594e-02f, 8.43121484e-02f, -2.08468046e-02f,
  8.48979503e-02f, -8.66345465e-02f, 1.60142872e-02f, 2.14055157e-03f, 5.42160869e-02f, -3.12863253e-02f, 6.97982237e-02f, 7.76681006e-02f, 1.80868916e-02f, -3.81280743e-02f,
  7.10536316e-02f, 8.13010111e-02f, -7.70965815e-02f, -4.99291010e-02f, 6.28686249e-02f, 7.38018602e-02f, 2.30084956e-02f, -4.73896787e-02f, 1.01811104e-01f, -2.33067144e-02f,
  -7.26911351e-02f, -2.40413863e-02f, -2.53598467e-02f, -5.19843772e-02f, -6.16173819e-03f, 5.85009232e-02f, 2.11391151e-02f, -9.09330025e-02f, 3.01141422e-02f, 6.50791302e-02f,
  -7.08976686e-02f, 2.10726447e-02f, 3.17289345e-02f, 8.49580020e-02f, 3.46454512e-03f, -3.84298414e-02f, 5.54051138e-02f, -2.51940787e-02f, 2.28279736e-02f, 3.89409065e-02f,
  -2.70928919e-01f, -9.29697976e-02f, 1.45432435e-03f, -2.81959206e-01f, -1.38867393e-01f, 1.93495750e-02f, -1.62816867e-01f, -5.78377321e-02f, -1.21158242e-01f, -6.00538142e-02f,
  -2.94670183e-02f, -3.16493995e-02f, -7.83214122e-02f, 9.66599956e-02f, 1.28667019e-02f, -9.16421488e-02f, -6.87288195e-02f, 8.52279086e-03f, 1.12895250e-01f, -3.44405957e-02f,
  -9.90029573e-02f, -1.43781379e-01f, -7.17017055e-02f, 1.98061951e-02f, -1.17521569e-01f, -1.28360267e-03f, -1.01433814e-01f, -5.09190075e-02f, -3.21772546e-02f, -2.35921606e-01f,
  -1.51382565e-01f, 2.04293244e-02f, 3.07604447e-02f, -1.28759265e-01f, -9.77854803e-02f, 7.85667971e-02f, -9.23023373e-03f, -3.68840643e-03f, 3.75983045e-02f, 7.26124346e-02f,
  3.50663699e-02f, 7.52201602e-02f, -7.35390931e-02f, -3.91489938e-02f, -3.93602811e-02f, -5.45889437e-02f, 6.67667314e-02f, -1.03802718e-02f, 6.52249083e-02f, -2.63824053e-02f,
  4.50805835e-02f, 1.92975197e-02f, -9.90925916e-03f, 1.64020993e-02f, 2.27301605e-02f, 9.71985832e-02f, 7.93984681e-02f, 9.95066389e-02f, 3.36285643e-02f, -2.89054140e-02f,
  -1.72614846e-02f, 2.24575656e-03f, -1.81239489e-02f, 3.44204670e-03f, -8.86370465e-02f, 6.17538430e-02f, -6.45345151e-02f, -7.87496194e-02f, 7.65020326e-02f, -5.06639071e-02f,
  9.45628658e-02f, -5.66660613e-02f, -5.35828527e-03f, -6.43738359e-03f, -2.74402816e-02f, 3.25096063e-02f, -4.61867265e-02f, 1.41405333e-02f, 2.17439532e-02f, 2.47653443e-02f,
  4.17189300e-02f, -3.73661555e-02f, 5.35370782e-02f, 3.02772759e-03f, 1.98866073e-02f, -7.64551908e-02f, 8.00022036e-02f, 7.60097355e-02f, 4.23966460e-02f, 8.08903575e-02f,
  -8.24799836e-02f, 1.06265388e-01f, -1.03368305e-01f, 5.58174811e-02f, -7.79704005e-02f, -8.55539646e-03f, -7.16537312e-02f, 4.98891473e-02f, -7.58854970e-02f, -7.01267123e-02f,
  -1.68120544e-02f, -7.62744322e-02f, 4.92235795e-02f, -3.56668420e-02f, -5.66785932e-02f, 5.94019331e-03f, -1.30116916e-03f, -1.10894851e-01f, 1.37504116e-02f, 6.07917011e-02f,
  -1.49539849e-02f, -2.28075963e-03f, 3.55410762e-02f, -4.69068028e-02f, -3.50266695e-02f, -8.21229517e-02f, 9.06445086e-02f, -1.54346405e-02f, -2.14658678e-02f, -6.92497715e-02f,
  -1.88140962e-02f, -6.36536628e-02f, -1.25392929e-01f, -3.77088636e-02f, -2.29506362e-02f, -6.66978955e-02f, -1.52856484e-01f, 5.55336662e-02f, 5.47666382e-03f, -1.84379116e-01f,
  6.40991181e-02f, 1.46646099e-02f, 2.17180084e-02f, 3.85601819e-02f, 6.86383015e-03f, -1.58757746e-01f, -1.41931683e-01f, -1.28864691e-01f, 1.49263004e-02f, 8.50951970e-02f,
  -3.61092873e-02f, 5.05128987e-02f, -7.58767268e-03f, 9.27359387e-02f, -3.54485773e-02f, -5.44507317e-02f, -5.81345074e-02f, -3.22713852e-02f, -8.84569287e-02f, -1.59984976e-01f,
  -1.21367283e-01f, 5.47867231e-02f, 1.34225726e-01f, 4.83553000e-02f, 6.62849769e-02f, 6.52432442e-02f, 1.61603633e-02f, 1.09212413e-01f, 2.45529190e-02f, -6.47168010e-02f,
  2.34732684e-02f, 1.78575993e-03f, -3.48298438e-02f, 7.48503581e-02f, -5.96760847e-02f, 1.09445071e-02f, 2.10905429e-02f, -7.23395422e-02f, -6.65244134e-03f, -5.25913872e-02f,
  -1.38600515e-02f, -2.59017386e-03f, -9.27039012e-02f, -8.02526623e-02f, 2.99632717e-02f, -5.82468919e-02f, -1.51015632e-02f, 9.05958042e-02f, 1.86324175e-02f, -4.70549092e-02f,
  -1.13448933e-01f, 4.27491441e-02f, -9.48874503e-02f, 1.55104408e-02f, -3.35220657e-02f, -4.43312600e-02f, 1.75632164e-02f, -8.51263627e-02f, 3.28023285e-02f, 4.58064899e-02f,
  -5.69040105e-02f, 4.60102931e-02f, -4.89601158e-02f, -8.95496011e-02f, 5.05330525e-02f, 4.78858799e-02f, 6.72039241e-02f, -1.40217664e-02f, 1.08226892e-02f, 3.44897546e-02f,
  -5.30439913e-02f, 8.37942585e-02f, 5.63924015e-02f, 1.54713467e-02f, -6.69549331e-02f, -8.12930018e-02f, -9.02660340e-02f, -1.02086633e-01f, -6.33368492e-02f, 3.68687585e-02f,
  -7.99645390e-03f, 2.34520026e-02f, -2.02698838e-02f, 4.85107973e-02f, 9.90937650e-02f, 7.81392902e-02f, -7.53171816e-02f, -6.94359615e-02f, 3.76515649e-02f, 7.46518597e-02f,
  -2.46023554e-02f, -5.52168414e-02f, -5.71125820e-02f, -4.62416001e-03f, 5.01084775e-02f, 5.87687418e-02f, -9.76121947e-02f, 6.60002828e-02f, -1.34634171e-02f, -6.73262924e-02f,
  -6.78784698e-02f, -7.88561776e-02f, -5.68995066e-02f, -1.12480894e-01f, -2.39910856e-02f, -8.15264434e-02f, -1.16565101e-01f, -5.17957322e-02f, 9.50270891e-03f, -2.07147181e-01f,
  2.07102418e-01f, 1.28040493e-01f, 9.33064744e-02f, -4.29201871e-02f, 5.26781119e-02f, -8.69509652e-02f, 1.37302250e-01f, 5.18431477e-02f, -1.24250263e-01f, 5.13392538e-02f,
  -9.39892009e-02f, -8.39709770e-03f, -9.51303467e-02f, -9.94723439e-02f, 1.25805646e-01f, 5.84613048e-02f, -6.17087539e-03f, -3.56516428e-03f, -7.00382963e-02f, -1.14111677e-01f,
  -5.97471092e-03f, 2.33793054e-02f, 5.91088049e-02f, 1.00384513e-02f, 1.77204367e-02f, -9.96475145e-02f, 2.41500027e-02f, -3.37364860e-02f, -9.31400955e-02f, 8.59171301e-02f,
  3.35853659e-02f, 1.82254434e-01f, -1.39774233e-01f, 8.22264925e-02f, -5.10505727e-03f, 9.19371173e-02f, 3.20101753e-02f, -1.56399943e-02f, 6.89957887e-02f, 5.18617481e-02f,
  1.08673181e-02f, 2.16442086e-02f, -5.18909991e-02f, 3.54806557e-02f, -2.08700616e-02f, -7.42362905e-03f, 5.97551018e-02f, -7.48405978e-03f, 4.59602773e-02f, 6.82084188e-02f,
  6.64096177e-02f, -4.60836738e-02f, 1.24448970e-01f, -6.72946721e-02f, -7.38955587e-02f, -1.05109029e-01f, 7.41306990e-02f, 1.25295008e-02f, 4.93813381e-02f, 1.25339450e-02f,
  -1.65673047e-02f, -6.17833138e-02f, 4.72808182e-02f, -1.24120852e-02f, -4.65479121e-03f, -7.43945595e-03f, -8.76260772e-02f, 4.52503487e-02f, 1.14640594e-02f, 8.36921334e-02f,
  -4.89083417e-02f, -2.59280037e-02f, -2.29276922e-02f, -3.16914618e-02f, -8.68847966e-02f, 5.51205315e-02f, -5.32768220e-02f, -1.29515976e-02f, -8.55309330e-03f, 7.76114389e-02f,
  -8.15402567e-02f, -6.09208085e-02f, -2.88218632e-03f, -5.80948703e-02f, 7.56796217e-03f, 1.36746746e-02f, 3.66314538e-02f, -5.09712324e-02f, -5.83178438e-02f, -4.37468812e-02f,
  -1.10827118e-01f, -8.12807381e-02f, 5.99221438e-02f, 8.60395581e-02f, 3.36913182e-03f, 4.72330637e-02f, -3.54154482e-02f, 8.02979153e-03f, 6.14623800e-02f, 9.70448032e-02f,
  3.54505628e-02f, 2.28180178e-02f, -1.03066936e-02f, -3.10753454e-02f, -5.57511039e-02f, -1.49908336e-02f, 3.98812070e-02f, -3.09917633e-03f, 5.75762540e-02f, 7.74070919e-02f,
  -3.89332138e-02f, -7.24661350e-02f, -6.12532683e-02f, -1.79233029e-02f, -4.09311689e-02f, 4.58216704e-02f, -2.83595603e-02f, -1.90056656e-02f, -2.83893291e-02f, 2.73862705e-02f,
  4.95211296e-02f, -1.10286877e-01f, -1.85356915e-01f, 5.31074777e-02f, -5.17048575e-02f, 3.32880206e-02f, -2.61081010e-02f, -6.19186722e-02f, 2.48866864e-02f, 2.20714714e-02f,
  -5.64756989e-02f, -7.61201233e-03f, -2.45207231e-02f, 3.74457659e-03f, -9.60443243e-02f, -2.25896955e-01f, -1.94188967e-01f, -7.40250573e-02f, -6.20725751e-03f, 4.43042479e-02f,
  -3.43230343e-03f, -9.39126834e-02f, -5.41422181e-02f, -4.97729592e-02f, 2.23334655e-02f, 7.22827464e-02f, -6.48727566e-02f, -5.31755760e-02f, 3.84955332e-02f, -2.12791841e-02f,
  -2.63355561e-02f, 8.51114914e-02f, 3.64944153e-02f, 3.67141366e-02f, -7.73017630e-02f, -4.34070639e-02f, -8.00045133e-02f, -1.59346424e-02f, 1.57706067e-02f, -6.18990436e-02f,
  4.31272574e-02f, 2.43055951e-02f, 2.05425210e-02f, 1.08146898e-01f, 5.12949266e-02f, -1.17244916e-02f, 7.66903311e-02f, 2.70568598e-02f, -5.26454933e-02f, -8.05565938e-02f,
  3.90735678e-02f, -1.02904871e-01f, -8.75681192e-02f, 8.63646641e-02f, -4.40151133e-02f, -8.63862336e-02f, -2.61866320e-02f, 9.07244086e-02f, 1.19186938e-02f, 1.82010438e-02f,
  8.25072676e-02f, 6.42910227e-02f, 8.71295705e-02f, 7.32868984e-02f, -6.53180480e-02f, 5.98593876e-02f, -1.75580836e-03f, 1.47925187e-02f, 4.59738597e-02f, 3.10723837e-02f,
  -2.97454633e-02f, -2.23771725e-02f, -3.92360240e-03f, 9.85794663e-02f, -4.76172566e-02f, -3.03253196e-02f, -2.04748549e-02f, 1.10456273e-02f, 3.76430713e-02f, -4.71614040e-02f,
  -4.90761511e-02f, 9.64691639e-02f, 5.06859943e-02f, 2.50702500e-02f, -5.06855659e-02f, 5.93930334e-02f, 7.86794722e-02f, 1.04406022e-01f, 8.52032974e-02f, 8.26015621e-02f,
  1.31897300e-01f, -2.64486652e-02f, -5.26461117e-02f, -4.52746749e-02f, -1.69060640e-02f, -4.15502414e-02f, -1.42388912e-02f, -2.84040496e-02f, 6.69565126e-02f, -5.16730361e-02f,
  1.07206650e-01f, 4.37790900e-02f, -5.86947463e-02f, -4.91744839e-02f, 2.53173499e-03f, -6.00841828e-02f, -4.32917997e-02f, -3.93449701e-02f, 1.60231385e-02f, 5.32100573e-02f,
  -8.99108052e-02f, -1.37969824e-02f, -6.10029139e-02f, -6.44333661e-02f, 1.01472497e-01f, -3.13851684e-02f, 2.70164069e-02f, 6.24365360e-03f, 4.70977239e-02f, -1.40112201e-02f,
  1.55025214e-01f, -2.00799163e-02f, -1.03236791e-02f, 4.46957946e-02f, -3.43529880e-02f, -4.53071371e-02f, -4.80481274e-02f, -6.58357292e-02f, 5.59524260e-02f, -1.29944198e-02f,
  4.10692394e-02f, 1.26283988e-01f, 1.21723250e-01f, 9.57243368e-02f, 4.05929796e-03f, -8.28323588e-02f, -1.11568153e-01f, -2.64415927e-02f, 1.39212459e-01f, -3.64944898e-02f,
  -6.32277876e-02f, -2.88703274e-02f, 2.68515926e-02f, 5.01934299e-03f, -5.86861968e-02f, 1.12904556e-01f, 7.77368341e-03f, 5.69161251e-02f, -7.41443858e-02f, 1.77939683e-02f,
  -7.22490326e-02f, 6.25194386e-02f, 1.42705008e-01f, 9.47074965e-02f, -5.31501323e-02f, -3.85862030e-02f, -2.68144347e-02f, -1.94782969e-02f, 7.06137624e-03f, 5.43696508e-02f,
  -2.55412236e-02f, -3.17816585e-02f, 1.35035953e-03f, -4.61005606e-02f, -4.43767197e-02f, -1.37556521e-02f, -3.50957401e-02f, 1.13360777e-01f, 9.51523185e-02f, -1.57070195e-03f,
  6.14220016e-02f, 2.97470149e-02f, 8.58446956e-02f, 2.74401754e-02f, 1.35644879e-02f, 1.67890247e-02f, -1.28651578e-02f, -2.92062163e-02f, 5.28591610e-02f, -3.40761640e-03f,
  1.26655092e-02f, -6.77387118e-02f, 3.85219441e-03f, -3.58092822e-02f, -3.61851417e-02f, -3.82695794e-02f, 9.46726352e-02f, 1.03894696e-01f, -8.10578987e-02f, -1.47241810e-02f,
  6.85590599e-03f, -7.40818083e-02f, 1.17575556e-01f, 4.82941158e-02f, -4.40824553e-02f, -9.71150696e-02f, -6.87259361e-02f, 4.25245194e-03f, 1.49974134e-02f, -5.52402101e-02f,
  -6.53218105e-02f, 7.22552743e-03f, -3.36205331e-03f, 3.08185276e-02f, -7.48472437e-02f, 4.30809334e-02f, 2.14894246e-02f, 4.61557582e-02f, 2.46385243e-02f, -5.71271740e-02f,
  -7.82809779e-02f, 1.47119433e-01f, 1.01808496e-01f, -1.41691249e-02f, -2.50965971e-02f, 2.88462657e-02f, -2.37459447e-02f, -8.28744248e-02f, 4.17054370e-02f, 4.46286192e-03f,
  4.94879670e-02f, 6.92193806e-02f, 1.38165988e-02f, -7.10059553e-02f, -4.22460819e-03f, -4.58209850e-02f, -1.01160318e-01f, 1.47107258e-01f, 8.38744938e-02f, -5.66070005e-02f,
  -1.05113581e-01f, 2.52404250e-02f, 1.55119672e-01f, 1.11422122e-01f, 9.61861089e-02f, 1.31824019e-03f, -8.37661326e-02f, -1.15782255e-02f, 1.21658087e-01f, -2.82526966e-02f,
  -2.81206131e-01f, -5.38771488e-02f, -2.77117223e-01f, -1.08521897e-02f, 1.90142944e-01f, 1.49261668e-01f, 3.28851528e-02f, 1.34190843e-01f, 6.37095347e-02f, -4.76131625e-02f,
  8.93207826e-03f, -9.70071007e-04f, -6.49545416e-02f, 2.88289431e-02f, -7.00346529e-02f, 1.02024218e-02f, -9.46874022e-02f, -2.10379392e-01f, 1.86729003e-02f, 8.24582800e-02f,
  1.47786751e-01f, -7.68430978e-02f, -7.30699375e-02f, -7.85729513e-02f, 1.16046809e-03f, -3.94178107e-02f, -6.92525133e-02f, 5.53077320e-03f, 1.07263483e-01f, -2.80034891e-03f,
  -1.21563531e-01f, -3.18040587e-02f, -6.28565252e-02f, -1.65273733e-02f, -6.72312500e-03f, -1.17891781e-01f, 2.22283490e-02f, -4.98817973e-02f, 2.52456758e-02f, 7.63038993e-02f,
  -7.49952048e-02f, -2.77096219e-03f, -7.55705684e-02f, 6.48657233e-02f, 4.40281294e-02f, -5.17676510e-02f, -1.23418309e-01f, -1.50487527e-01f, -7.65079632e-02f, -1.00860894e-01f,
  2.90582459e-02f, 7.44393095e-02f, -1.51193947e-01f, -1.14136003e-01f, -4.24176157e-02f, -7.26648346e-02f, -1.05860503e-02f, 3.79740372e-02f, -8.87188017e-02f, -1.04376562e-01f,
  6.73314780e-02f, -2.99705137e-02f, -1.58504210e-02f, 3.70049067e-02f, 2.49053608e-03f, 4.79821824e-02f, -1.99206732e-02f, 3.89914364e-02f, 7.71891028e-02f, -4.80895415e-02f,
  -7.59938583e-02f, 2.58288416e-03f, 6.63025677e-02f, -2.59592179e-02f, -3.72366086e-02f, -4.28568088e-02f, 1.04139306e-01f, -3.13448235e-02f, -1.02724314e-01f, -5.05409017e-02f,
  4.35477272e-02f, -2.66478714e-02f, -3.91949303e-02f, -4.44634398e-03f, 6.29330650e-02f, 2.02293843e-02f, 4.64450456e-02f, -8.90935510e-02f, -5.99993020e-02f, -4.51699318e-03f,
  -1.22029066e-01f, -6.64267689e-02f, 2.17972267e-02f, 6.65731803e-02f, -4.70306771e-03f, 1.98180173e-02f, 2.25309376e-02f, 2.37883329e-02f, -3.58691290e-02f, 4.61673737e-03f,
  -2.85736490e-02f, 2.98568816e-03f, 1.63933262e-02f, -2.06359266e-03f, 5.96865593e-03f, -4.56646383e-02f, -4.48497906e-02f, 5.09283394e-02f, -3.54957134e-02f, -5.53509556e-02f,
  -6.69318438e-02f, 4.22645360e-02f, -1.32502969e-02f, -5.58969975e-02f, 1.76741313e-02f, -4.49688360e-02f, -5.84882759e-02f, -7.05001652e-02f, -1.48647308e-01f, -1.80031464e-01f,
  -2.46833667e-01f, -1.05771139e-01f, -2.34129369e-01f, -3.84908080e-01f, 2.38352572e-03f, 7.79647827e-02f, 1.03546590e-01f, 6.96061179e-02f, -1.33785754e-01f, -6.03302866e-02f,
  4.02601957e-02f, 3.42384540e-02f, -5.36217317e-02f, 3.35646830e-02f, 7.96988681e-02f, -6.75438568e-02f, -2.12087587e-01f, -1.02539472e-01f, 1.75164685e-01f, 2.18140468e-01f,
  1.11931741e-01f, -1.63615584e-01f, -2.47662514e-02f, -7.81774223e-02f, -1.85774669e-01f, -5.78189380e-02f, -2.88350046e-01f, -2.05073178e-01f, -1.77811086e-03f, -3.03602606e-01f,
  -5.84496222e-02f, 9.00140218e-03f, 8.31170976e-02f, 9.47008431e-02f, -3.19594890e-02f, -4.08211872e-02f, 2.72826552e-02f, -8.98039937e-02f, 6.73590824e-02f, 8.07077333e-04f,
  -4.69639041e-02f, 4.96533792e-03f, -7.77352601e-03f, 3.23257558e-02f, -6.84258491e-02f, 7.40016997e-02f, -2.23791730e-02f, 1.16169907e-01f, 2.50089578e-02f, 7.51961470e-02f,
  3.54237929e-02f, 1.11470401e-01f, 8.39054361e-02f, 5.92300072e-02f, 1.06423765e-01f, 4.37169075e-02f, 7.32608363e-02f, 1.37336761e-01f, 6.83711395e-02f, -7.54254982e-02f,
  -1.21904537e-01f, 5.89112099e-03f, 8.77315253e-02f, -2.23002601e-02f, 5.67742847e-02f, -2.38742307e-02f, 5.24151847e-02f, -4.63604964e-02f, 8.75871256e-02f, -1.84027739e-02f,
  -3.15596350e-02f, 4.43738997e-02f, -2.11134870e-02f, 3.04018781e-02f, -7.71935582e-02f, -1.19602412e-03f, -7.55249709e-02f, -4.32975627e-02f, -5.46167642e-02f, -4.83136773e-02f,
  -8.22680711e-04f, 4.27103415e-02f, -7.58183375e-02f, 5.21646962e-02f, 5.34682162e-02f, 7.84051884e-03f, 2.20854823e-02f, 6.08249232e-02f, -5.47328629e-02f, 2.26366669e-02f,
  -8.60695243e-02f, 8.32125396e-02f, -3.33895683e-02f, 3.67412418e-02f, 4.22174111e-02f, -6.78684115e-02f, -8.29754025e-02f, 1.05705678e-01f, -6.18705302e-02f, 2.77171414e-02f,
  3.11711039e-02f, -2.08829697e-02f, -1.09866589e-01f, -2.29595858e-03f, 8.73121247e-02f, 3.88680436e-02f, 1.67447757e-02f, 1.65730547e-02f, 4.43719253e-02f, -2.74245795e-02f,
  -9.88851339e-02f, 7.75553957e-02f, 3.80186662e-02f, 7.89595842e-02f, -2.07062773e-02f, -2.06807833e-02f, -5.69570735e-02f, 6.51526898e-02f, 2.23023240e-02f, -8.77342746e-02f,
  4.42337571e-03f, -7.60069815e-03f, -1.62892908e-01f, -4.61159647e-02f, 6.33997321e-02f, -2.75499187e-02f, 1.24637280e-02f, -1.04416143e-02f, -7.82813206e-02f, 6.69257343e-02f,
  4.30229539e-03f, 4.32631699e-03f, 2.70929188e-02f, 6.89770281e-02f, -6.57293871e-02f, 4.94463071e-02f, -5.05272411e-02f, -1.29122213e-01f, -5.37144300e-03f, 1.00181945e-01f,
  -1.08015714e-02f, -1.19399987e-01f, -8.90155882e-02f, 4.80109304e-02f, -8.75502229e-02f, -1.07487217e-01f, -7.31466413e-02f, -9.08023939e-02f, -4.98125749e-03f, -9.05629024e-02f,
  -6.96618557e-02f, -3.40232700e-02f, -5.15897050e-02f, -3.63436341e-02f, -8.99282247e-02f, -5.41572645e-02f, -2.58384459e-02f, -1.72300413e-02f, -5.32261357e-02f, -1.13131441e-02f,
  -8.71041343e-02f, 6.29971623e-02f, -7.07181469e-02f, -1.82202477e-02f, -1.94320884e-02f, -2.90472060e-02f, -5.88151105e-02f, -4.92721982e-02f, 5.79727069e-02f, 8.39710757e-02f,
  9.64073539e-02f, -3.58387232e-02f, 5.50657697e-02f, -3.98903824e-02f, -4.75850068e-02f, -4.56803516e-02f, 5.86671680e-02f, 1.05728641e-01f, 4.26264629e-02f, 9.02440399e-02f,
  -5.22828326e-02f, 1.24661147e-03f, -8.65014270e-02f, 5.13528436e-02f, -1.54990312e-02f, -2.00075191e-03f, -4.49719504e-02f, -4.46089730e-02f, -3.07599939e-02f, -3.77498455e-02f,
  -2.84938496e-02f, -4.76441197e-02f, 9.58698839e-02f, -8.71464238e-02f, -5.82264178e-02f, 2.52892766e-02f, -4.71750200e-02f, -4.17903997e-02f, 5.93848377e-02f, 4.76634130e-02f,
  -4.16837521e-02f, 7.30468631e-02f, -6.35282397e-02f, 5.64674027e-02f, 1.32389385e-02f, -8.32879916e-02f, 4.93472442e-02f, 8.35807472e-02f, 2.48245783e-02f, -4.10282277e-02f,
  -1.09573498e-01f, 5.65648526e-02f, -7.23966584e-02f, -5.09302951e-02f, 3.60192135e-02f, 2.16205269e-02f, 1.21597918e-02f, -2.26277206e-02f, 7.40132630e-02f, -6.19454905e-02f,
  -2.37826332e-02f, 3.62343080e-02f, 3.67851891e-02f, -6.21271357e-02f, 1.07820472e-02f, -4.95984592e-02f, -1.61313359e-02f, 8.27436149e-02f, -4.95505705e-02f, -6.13909848e-02f,
  4.19723503e-02f, -6.03034161e-02f, -1.01297135e-02f, 6.06252588e-02f, 5.16253896e-02f, 6.39774278e-02f, 5.60294762e-02f, 4.70987223e-02f, -5.44671342e-02f, 4.34210785e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  8.36002976e-02f, 4.62654270e-02f, 8.41053668e-03f, 1.87185168e-01f, 1.73971012e-01f, 2.07609564e-01f, 2.13580132e-01f, 4.64335307e-02f, 1.13449551e-01f, 1.49891675e-01f,
  -5.83206723e-03f, -6.63837930e-03f, -1.37469219e-02f, 1.60055272e-02f, 3.74438912e-02f, 1.08770020e-01f, 4.49216664e-02f, 1.15481459e-01f, -6.97342257e-05f, 1.67954028e-01f,
  6.51595443e-02f, 1.32986203e-01f, 2.58199185e-01f, 1.14711765e-02f, 2.06556186e-01f, 1.20250531e-01f, 1.20344140e-01f, 7.33216107e-02f, -2.26996318e-02f, 1.05201408e-01f,
  1.36741057e-01f, 4.06898931e-02f, 2.44642049e-01f, 6.30170926e-02f, 4.69011739e-02f, 1.33017916e-02f, -1.23671275e-02f, 1.28411219e-01f, 1.53625593e-01f, 2.37653814e-02f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -9.57004428e-02f, 6.16967008e-02f, -1.11197747e-01f, -3.45634632e-02f, 5.63651398e-02f, -8.12508017e-02f, 7.15725943e-02f, -8.08692873e-02f, -7.22993761e-02f, -4.52641584e-02f,
  1.61944497e-02f, -1.21080495e-01f, 1.19380444e-01f, -5.13957478e-02f, 1.13771684e-01f, -7.72876516e-02f, -6.00848533e-02f, -2.46310439e-02f, 1.85417801e-01f, -1.35902151e-01f,
  6.46607392e-03f, 9.25804004e-02f, -5.53756952e-02f, 5.08481124e-03f, -5.51976822e-02f, -1.42007262e-01f, -2.85329088e-03f, 1.04220696e-01f, -4.03587408e-02f, -3.18703391e-02f,
  -1.65276229e-01f, -6.85075223e-02f, 3.12794857e-02f, 1.36322036e-01f, 5.15792344e-04f, 1.73840433e-01f, 8.37699994e-02f, 1.19021442e-02f, 5.81830107e-02f, 8.07111487e-02f,
  1.16547838e-01f, -4.30177199e-03f, -4.49932292e-02f, -1.41665816e-01f, -1.48001954e-01f, -3.30804475e-02f, 6.16876855e-02f, 2.31921244e-02f, -3.56387794e-02f, 1.78129911e-01f,
  4.31683809e-02f, -2.08754167e-01f, 6.15195259e-02f, 4.89701107e-02f, -1.99231490e-01f, 2.73272730e-02f, 8.84886459e-02f, 6.78935423e-02f, 1.00841060e-01f, 5.58273345e-02f,
  1.46798700e-01f, -8.88308883e-02f, 1.47826165e-01f, 7.11137205e-02f, -8.54469091e-02f, 1.02873527e-01f, -1.34500533e-01f, 6.64952844e-02f, 9.88826305e-02f, 1.58766564e-02f,
  -1.90721732e-02f, 9.24511328e-02f, 3.53062525e-02f, -5.15491562e-03f, -9.76742283e-02f, 5.14123924e-02f, 4.10657898e-02f, 2.48361647e-01f, -1.61014080e-01f, -1.48173779e-01f,
  -2.58264840e-02f, -5.94761074e-02f, -1.39883488e-01f, 2.35533893e-01f, -1.15239352e-01f, 1.04149759e-01f, -1.27785340e-01f, 3.13919783e-01f, -8.77382159e-02f, -1.82811059e-02f,
  -1.00571923e-01f, 7.36179501e-02f, -1.02548994e-01f, 9.97521356e-02f, 1.47638440e-01f, -3.79091613e-02f, -1.89443901e-01f, -1.08512439e-01f, -1.25394035e-02f, 7.32847210e-03f,
  -8.03135186e-02f, 6.37259334e-02f, 7.84033909e-02f, 7.68358633e-02f, -8.31111446e-02f, 8.90545398e-02f, -1.69186473e-01f, 1.14132330e-01f, -4.57577184e-02f, 1.85122162e-01f,
  1.83935016e-01f, -5.33425307e-04f, 2.24077731e-01f, -1.10318854e-01f, -5.24195097e-02f, 2.44233496e-02f, 6.35736436e-02f, -9.82201472e-02f, 2.24721685e-01f, 3.15633346e-03f,
  -2.91580800e-02f, 7.99372643e-02f, 9.79711413e-02f, -1.32606164e-01f, 2.33544797e-01f, -2.43681014e-01f, -1.93443328e-01f, -5.81264198e-02f, -1.03186458e-01f, 1.12780772e-01f,
  4.24086116e-02f, -4.85471450e-02f, -1.25460148e-01f, 1.66899115e-02f, -5.55019528e-02f, 3.86630073e-02f, 4.31395434e-02f, 2.00691428e-02f, -8.57449397e-02f, -6.75196201e-02f,
  2.11869046e-01f, -1.46226333e-02f, 5.23937307e-02f, -3.93669605e-02f, 1.34840190e-01f, 5.16891070e-02f, 1.71511799e-01f, -2.05138266e-01f, 6.62620813e-02f, 3.84512059e-02f,
  -1.89603463e-01f, -1.02831356e-01f, 2.74339248e-03f, -9.40554142e-02f, 7.15726539e-02f, 1.58348009e-01f, 5.77451251e-02f, -6.00599386e-02f, -2.16100737e-01f, -1.46795571e-01f,
  -2.06221938e-02f, -3.44911553e-02f, -9.27557200e-02f, -6.83549494e-02f, 1.07593022e-01f, 2.12017377e-03f, 5.89430220e-02f, -1.16324171e-01f, 7.16952160e-02f, 1.78526878e-01f,
  1.56997859e-01f, 3.36334743e-02f, 1.30204484e-01f, -2.78851073e-02f, 5.10874353e-02f, 1.84774026e-01f, -1.71802640e-01f, -1.40568286e-01f, 1.76917836e-01f, 7.46626332e-02f,
  -1.12060465e-01f, 1.36094853e-01f, -1.73284948e-01f, -1.36528879e-01f, -1.69117004e-02f, 2.21481070e-01f, -3.25360596e-02f, 2.13091537e-01f, -4.65289317e-03f, 1.75946519e-01f,
  -3.02130487e-02f, 7.70860985e-02f, 5.30155823e-02f, -5.82459532e-02f, 7.45554268e-02f, -6.01561628e-02f, 2.29569867e-01f, 1.15714490e-01f, -1.82886515e-02f, 1.71485841e-01f,
  -2.48255953e-02f, -6.18645884e-02f, 6.10083677e-02f, 1.64214790e-01f, 8.47874209e-02f, -7.33928457e-02f, 9.04801637e-02f, -1.08339772e-01f, -1.38040364e-01f, 1.33473322e-01f,
  1.23271719e-01f, -9.14103612e-02f, 1.34153768e-01f, -1.49270803e-01f, 2.76816964e-01f, -1.60510615e-01f, 1.30476981e-01f, 1.99535742e-01f, 1.95983313e-02f, -1.39448345e-01f,
  -1.50914237e-01f, -2.09604114e-01f, 6.88207373e-02f, 7.51939565e-02f, 9.01869312e-02f, 8.91369283e-02f, 1.38478100e-01f, 1.06057338e-01f, 5.58916889e-02f, -4.80506234e-02f,
  -1.28975764e-01f, 4.64258678e-02f, 6.44119754e-02f, -1.23843148e-01f, -1.24891475e-01f, -3.18265736e-01f, -1.32196024e-01f, 1.55817792e-01f, 1.16652966e-01f, 1.14338644e-01f,
  9.30124894e-02f, 2.54116524e-02f, -5.07660173e-02f, 9.04439390e-02f, -5.57739660e-02f, -1.02744415e-01f, -1.82831492e-02f, -1.13479495e-01f, 7.70198693e-03f, -1.89679861e-01f,
  -3.88624296e-02f, 6.72761276e-02f, -7.52362758e-02f, 2.34309528e-02f, 4.70796898e-02f, 9.49027110e-03f, 2.82898522e-03f, 7.63574466e-02f, 1.19746864e-01f, 2.57331673e-02f,
  2.02296913e-01f, 5.81516623e-02f, 1.30633852e-02f, 5.92882521e-02f, -4.14924137e-02f, -3.46512273e-02f, 2.28405185e-02f, -9.35922116e-02f, 5.21950275e-02f, -5.70798963e-02f,
  4.55980860e-02f, -2.59789288e-01f, 6.08616211e-02f, 1.37638777e-01f, -6.98631555e-02f, 2.04027489e-01f, 1.61488017e-03f, -1.44171104e-01f, -2.15185131e-03f, 2.04947203e-01f,
  9.02664140e-02f, -6.05764091e-02f, -5.39604947e-02f, 1.54175818e-01f, 7.54873604e-02f, -1.68792456e-01f, 2.03532085e-01f, -5.77288195e-02f, 1.17000625e-01f, -1.29837900e-01f,
  1.20440274e-01f, -6.17033206e-02f, 1.27322122e-01f, 6.81993067e-02f, -7.33737350e-02f, -2.20201850e-01f, -2.27897055e-02f, 1.40460536e-01f, -1.04803778e-01f, -1.92368120e-01f,
  -4.11146618e-02f, -8.87160972e-02f, 5.98548912e-02f, -2.97885537e-02f, 1.93553567e-01f, -3.22073027e-02f, -8.61991756e-03f, -1.57693461e-01f, -4.13486771e-02f, -4.48770169e-03f,
  -1.67835038e-02f, -3.44173945e-02f, -4.70649116e-02f, -9.18125138e-02f, 1.22059725e-01f, -9.48826075e-02f, 8.03009346e-02f, -5.50709479e-02f, -7.76642263e-02f, -3.17131914e-02f,
  -6.28806278e-02f, -9.21285823e-02f, 7.35224336e-02f, -1.73979402e-02f, 5.22017144e-02f, 3.56129594e-02f, -1.61271647e-01f, 7.48962313e-02f, -1.23270284e-02f, 1.87262937e-01f,
  7.92146102e-02f, -6.34368062e-02f, -1.71814919e-01f, 1.16599523e-01f, -2.08300054e-01f, 1.43894181e-01f, 2.26286184e-02f, -1.68085068e-01f, -7.96105191e-02f, 1.68819036e-02f,
  -9.64573622e-02f, 3.44557427e-02f, 1.77893937e-01f, 1.50459975e-01f, -5.71007095e-02f, -8.08773786e-02f, 3.83998565e-02f, -2.24504173e-01f, 7.34745488e-02f, 1.99125081e-01f,
  1.93729103e-01f, 1.01362094e-01f, -6.15734830e-02f, -3.10714040e-02f, -4.38663438e-02f, -1.30088001e-01f, 5.35030179e-02f, -1.77398399e-01f, 5.87731600e-03f, 1.65636078e-01f,
  1.69815402e-02f, 4.96451482e-02f, -1.26127275e-02f, 1.21684462e-01f, -1.53262690e-01f, -6.02962598e-02f, -2.63365030e-01f, -1.05529822e-01f, -3.92938480e-02f, 6.16334714e-02f,
  -1.08149067e-01f, 2.18530744e-01f, 7.72212818e-02f, -1.91935971e-01f, -1.11331912e-02f, 1.36440799e-01f, 3.47287767e-02f, -7.31490105e-02f, 4.35503498e-02f, 7.67130032e-02f,
  -1.37376636e-01f, 1.16037987e-01f, -7.91803300e-02f, -6.93929419e-02f, -7.39334747e-02f, -2.17087388e-01f, 2.12417264e-02f, -1.55600801e-01f, -6.04856499e-02f, -6.07030140e-03f,
  -3.36476341e-02f, 1.27605364e-01f, -4.20692228e-02f, -2.05567237e-02f, 9.82139707e-02f, 8.94610435e-02f, 8.67005512e-02f, -9.87678021e-02f, 3.01572144e-01f, -8.35159570e-02f,
  1.40040830e-01f, 1.29464060e-01f, 2.02255026e-01f, -2.01321661e-01f, 8.71368572e-02f, 7.60721043e-02f, -7.39326477e-02f, -1.43757895e-01f, -1.10208802e-01f, -9.25595760e-02f,
  -5.37331626e-02f, 1.78966016e-01f, -7.69881606e-02f, -1.92376953e-02f, -1.95666060e-01f, 9.90054235e-02f, 6.76610693e-02f, 1.03460833e-01f, 8.54048207e-02f, -7.78832764e-05f,
  7.30743483e-02f, 1.90872967e-01f, 1.68175809e-02f, 2.55837794e-02f, 1.32918069e-02f, 1.84767187e-01f, 1.70613274e-01f, -2.78150231e-01f, 1.11481227e-01f, -1.12248167e-01f,
  3.43363453e-03f, 1.82588860e-01f, -2.36963347e-01f, -1.99955940e-01f, 5.63587882e-02f, -2.99791098e-02f, 1.24330103e-01f, 3.42379004e-01f, -1.66798055e-01f, -2.35014409e-02f,
  1.30314484e-01f, 2.09492907e-01f, -1.58659369e-01f, 1.44131422e-01f, 2.86968797e-02f, 4.45701182e-02f, 5.59408516e-02f, 3.71212959e-02f, 5.01853563e-02f, -2.84063965e-02f,
  2.93119401e-02f, 7.56005943e-03f, 2.63380021e-01f, 2.18485910e-02f, -4.90946099e-02f, 3.79550308e-02f, 3.64424735e-02f, -9.37815681e-02f, 9.91615131e-02f, 1.07324354e-01f,
  1.13410167e-01f, -1.08075738e-01f, 3.13781708e-01f, -1.69286817e-01f, 1.95909981e-02f, -1.12264827e-01f, -2.02299744e-01f, -1.57836840e-01f, 2.53634024e-02f, -2.02234104e-01f,
  1.89511418e-01f, 2.65814774e-02f, -8.10361430e-02f, -5.54076323e-05f, 1.18626542e-01f, 1.24530219e-01f, 8.42429549e-02f, -4.21288945e-02f, 7.99020529e-02f, -1.07466122e-02f,
  7.35334679e-02f, 1.00821890e-01f, -6.64697960e-02f, -5.69431409e-02f, -5.38808815e-02f, -5.19580394e-02f, -1.77420810e-01f, 1.89202689e-02f, 1.00202627e-01f, -9.57103595e-02f,
  -8.75921026e-02f, -8.88620242e-02f, -3.25556612e-03f, -6.27019703e-02f, -8.91703069e-02f, -8.65066424e-02f, -9.76257920e-02f, -4.35539931e-02f, -1.60739139e-01f, -6.05733283e-02f,
  9.77249593e-02f, 1.32969558e-01f, 1.68096088e-02f, 1.51397008e-02f, -8.69663879e-02f, -1.73209891e-01f, 1.16568334e-01f, 3.10771298e-02f, -1.74025536e-01f, 9.66686755e-03f,
  -9.17290002e-02f, 1.07955262e-01f, 5.26298769e-02f, -1.96980447e-01f, 4.78811674e-02f, -1.12607762e-01f, 4.90196198e-02f, -2.34971885e-02f, -4.42767031e-02f, 3.22343782e-02f,
  3.94303538e-02f, -5.33935279e-02f, 2.92777619e-03f, -2.24116161e-01f, -2.17573836e-01f, 2.62807086e-02f, 9.14766118e-02f, 1.54110983e-01f, -2.09761724e-01f, 6.00084513e-02f,
  -3.59116584e-01f, 1.67945102e-01f, -1.66371435e-01f, -2.22440466e-01f, 3.66359770e-01f, 2.40881041e-01f, -1.27479183e-02f, -1.69005953e-02f, -9.43919420e-02f, -2.27233067e-01f,
  1.63789038e-02f, -8.71017799e-02f, 2.22742081e-01f, 6.75071105e-02f, -3.25854942e-02f, -1.74063817e-01f, 2.10425835e-02f, 2.02654838e-03f, -2.18420383e-02f, -9.34320912e-02f,
  -1.15101941e-01f, 1.11881673e-01f, -1.80146217e-01f, 1.32534551e-02f, -1.88199729e-01f, 1.02762170e-01f, 2.74612792e-02f, -1.29275620e-01f, -3.84606868e-01f, 5.63613549e-02f,
  2.11289212e-01f, -1.58267409e-01f, -1.90140828e-01f, -3.60447988e-02f, 1.22449733e-01f, -1.88033447e-01f, 7.73863047e-02f, 4.14951853e-02f, -1.60215214e-01f, -8.18054825e-02f,
  2.04809591e-01f, -1.32176742e-01f, -1.42020404e-01f, 2.14076731e-02f, -1.11058645e-01f, 2.04380732e-02f, 1.07173815e-01f, -1.86718762e-01f, 4.97271828e-02f, -1.33422092e-02f,
  2.97048986e-01f, -1.84182286e-01f, -9.25861374e-02f, 1.78997368e-01f, -2.44510341e-02f, -1.24733537e-01f, -1.81783009e-02f, -2.14198604e-02f, -3.54322023e-03f, -5.46234474e-02f,
  1.78424761e-01f, 8.72302055e-02f, -2.03656450e-01f, 3.53724845e-02f, -2.05891877e-01f, -2.16840193e-01f, 5.71560934e-02f, -8.21135286e-03f, 4.03137207e-01f, 1.87573522e-01f,
  7.28224739e-02f, -1.19135991e-01f, 1.23167306e-01f, -7.20480233e-02f, -8.18752274e-02f, -5.82527108e-02f, -4.12987033e-03f, 9.92205217e-02f, -7.34420866e-03f, 1.47256330e-01f,
  -5.33960201e-02f, 1.24066629e-01f, -5.08197509e-02f, -1.53869480e-01f, -2.44086571e-02f, 1.61174208e-01f, -1.21913478e-01f, -4.18728702e-02f, 5.36364838e-02f, -6.47798255e-02f,
  4.76700050e-04f, -1.95010960e-01f, -1.63268939e-01f, 1.10074617e-01f, -2.41933584e-01f, 9.17375311e-02f, -1.27458557e-01f, 2.17559226e-02f, 8.93671438e-02f, 3.84835489e-02f,
  -1.54817849e-01f, -1.11588404e-01f, 5.40701933e-02f, -1.62694141e-01f, 1.49892941e-01f, -1.22788042e-01f, -1.16095193e-01f, 4.92779203e-02f, -1.78456604e-01f, 4.34969030e-02f,
  -7.30408803e-02f, 8.46044067e-03f, 2.82739587e-02f, -1.55307204e-01f, 1.46811372e-02f, -1.22294381e-01f, -6.44458234e-02f, -1.20002508e-01f, 1.06492601e-01f, -4.72356379e-02f,
  8.88264030e-02f, -7.99058825e-02f, 6.27880692e-02f, -2.81663775e-01f, 3.27516496e-01f, -3.37251350e-02f, 1.37205288e-01f, 6.65554106e-02f, 1.49602324e-01f, -1.58496514e-01f,
  -2.51069758e-02f, 5.50830700e-02f, 2.03918248e-01f, -3.66364829e-02f, -1.24002434e-01f, -1.92972589e-02f, -8.36439505e-02f, -2.44152602e-02f, 1.84779435e-01f, -1.14101104e-01f,
  1.04839295e-01f, -1.11878194e-01f, 2.53483653e-01f, -4.70400043e-02f, -8.73757824e-02f, -2.13690445e-01f, 1.42913535e-01f, 1.52343258e-01f, -1.36668712e-01f, -3.13774467e-01f,
  9.43981577e-03f, -5.45168146e-02f, -1.18777797e-01f, -1.54721528e-01f, -1.06710918e-01f, -1.82224680e-02f, -2.73517877e-01f, 1.21867128e-01f, -4.15118149e-04f, -2.57581830e-01f,
  3.90053801e-02f, 9.41717476e-02f, -1.58570975e-01f, -1.45313358e-02f, -5.68679534e-02f, -1.50372297e-01f, 1.25349537e-01f, -3.11036929e-02f, 1.50947317e-01f, 4.23043147e-02f,
  -1.74068630e-01f, 3.05458844e-01f, 1.33918092e-01f, -3.15281115e-02f, 1.11361347e-01f, -5.30794896e-02f, 2.80883834e-02f, 1.10470325e-01f, 7.86418542e-02f, 2.24274379e-04f,
  -8.57539102e-03f, 1.11492485e-01f, -5.92970150e-03f, -7.01144561e-02f, 8.53505805e-02f, -1.23377338e-01f, -7.96123520e-02f, 8.25003535e-02f, -1.82740122e-01f, 6.70579672e-02f,
  -1.66979641e-01f, -1.00055583e-01f, -1.71883583e-01f, 7.18032941e-02f, 1.54984385e-01f, -4.32255752e-02f, -3.46349142e-02f, 1.19948648e-01f, 2.82535143e-02f, -6.21431367e-03f,
  5.53950630e-02f, 1.27646059e-01f, -1.59620404e-01f, 6.82515092e-03f, -1.72595661e-02f, 3.10408953e-03f, 2.50456836e-02f, 5.55925211e-03f, 4.51067500e-02f, 2.50151586e-02f,
  -1.10090218e-01f, 1.37596419e-02f, -5.93050905e-02f, -6.00934289e-02f, 7.31081190e-03f, 3.69827822e-02f, -1.66353643e-01f, -1.33823231e-01f, -1.54359359e-02f, 1.39629304e-01f,
  5.95512092e-02f, 4.64058667e-02f, 1.06354430e-01f, 1.02897167e-01f, 5.06843626e-02f, -1.18102394e-01f, 7.54388198e-02f, -8.99086446e-02f, 1.57159746e-01f, -8.61535221e-02f,
  9.38426256e-02f, 1.16746826e-02f, 1.50658339e-02f, -6.39825761e-02f, 2.75058746e-02f, 5.60754910e-02f, 7.93129131e-02f, 9.24519170e-03f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -1.09852906e-02f, 1.43410519e-01f, -9.78180841e-02f, 7.96480626e-02f, -1.05492845e-01f, -8.34528953e-02f, 7.99981877e-03f, 5.92350552e-04f, 2.06719851e-03f, 8.36420506e-02f,
  -7.78314518e-03f, -5.96880354e-02f, -3.27657200e-02f, 1.07231081e-01f, 8.41218326e-03f, -4.49859500e-02f, -7.76169226e-02f, -4.91841836e-03f, -6.36679530e-02f, -5.00797816e-02f,
  7.00426772e-02f, 1.52535606e-02f, -7.61554688e-02f, -1.15853965e-01f, -6.25306144e-02f, -6.05207421e-02f, 1.08757183e-01f, 4.63901535e-02f, -5.96423540e-03f, 7.06383586e-02f,
  -9.17580649e-02f, -4.79931347e-02f, 3.52627877e-03f, 9.10867080e-02f, 6.41225874e-02f, 5.60558885e-02f, 9.24106166e-02f, -6.30110726e-02f, 5.19957170e-02f, 6.78079426e-02f,
  8.50643814e-02f, 2.60522850e-02f, -9.54350457e-02f, -5.47869802e-02f, 4.95294575e-03f, -9.39317942e-02f, 1.19982690e-01f, 2.36999784e-02f, -9.55406800e-02f, 4.81910445e-02f,
  -5.07855974e-03f, -1.14059538e-01f, -8.69123116e-02f, -2.84720715e-02f, -1.24352179e-01f, 1.03679292e-01f, 2.96490286e-02f, 1.38639454e-02f, 3.24300192e-02f, -2.61127818e-02f,
  8.41997191e-02f, 8.50823224e-02f, 1.83612511e-01f, 8.92273933e-02f, 9.11916122e-02f, 1.38352454e-01f, 1.57002583e-01f, 3.98246348e-02f, 1.62754595e-01f, 2.41667926e-01f,
  4.46492136e-02f, 2.68077761e-01f, -2.14448608e-02f, 1.17868438e-01f, 1.28170967e-01f, 7.69486837e-03f, -1.07911162e-01f, 7.48200119e-02f, -2.54529238e-01f, 7.19702393e-02f,
  1.00143529e-01f, -3.01799607e-02f, 8.68421942e-02f, 1.81890771e-01f, 8.78986996e-03f, 3.94511595e-02f, -3.10322762e-01f, 8.32093507e-02f, -4.78422120e-02f, 2.08645873e-02f,
  -2.24817153e-02f, 5.95222786e-02f, 2.08165869e-01f, 2.39634261e-01f, 7.75651932e-02f, 1.02198437e-01f, 5.98838590e-02f, 5.35357706e-02f, 1.02826901e-01f, -1.05499305e-01f,
  -6.59659803e-02f, 7.89923146e-02f, 1.87843010e-01f, 2.76405420e-02f, -6.23085685e-02f, -7.21765030e-03f, 6.97454065e-02f, 3.10954154e-01f, 1.00731172e-01f, 8.14731941e-02f,
  7.04086870e-02f, -6.13822974e-03f, 7.72245675e-02f, 8.45054239e-02f, 1.27592042e-01f, -2.24282201e-02f, 1.08788013e-01f, -9.02637839e-02f, -7.69459829e-02f, 1.56351358e-01f,
  1.38556942e-01f, -1.77081507e-02f, -5.06375283e-02f, 1.99040724e-03f, 3.95637974e-02f, -2.00950012e-01f, -1.27283558e-01f, 7.77511522e-02f, 1.36719331e-01f, 1.77055970e-02f,
  1.74011197e-02f, -1.74830493e-03f, 3.04356832e-02f, -6.93071494e-03f, 5.94841689e-02f, 3.32903191e-02f, 9.63714719e-02f, 2.75677174e-01f, -8.73695686e-02f, 1.89412888e-02f,
  -1.24736480e-01f, 1.43218068e-02f, -2.36017793e-01f, 2.29444101e-01f, 9.96480417e-03f, -9.53572541e-02f, 1.03501789e-01f, 1.11391120e-01f, -7.36355186e-02f, -2.97854245e-02f,
  -9.88719314e-02f, -8.60627554e-03f, -5.38848080e-02f, 1.56879008e-01f, -4.88768443e-02f, -1.30700111e-01f, 7.63565600e-02f, 2.33418405e-01f, 1.45156803e-02f, -4.66108173e-02f,
  -8.84505063e-02f, 1.06509537e-01f, -1.90208226e-01f, -8.84640291e-02f, -9.71991122e-02f, 1.00801364e-01f, 1.78625107e-01f, 5.64489048e-03f, -2.24133302e-02f, 1.11288860e-01f,
  6.86774403e-02f, 3.73681724e-01f, -1.11166183e-02f, 5.83565012e-02f, -6.39021173e-02f, -1.02235310e-01f, 1.08060062e-01f, 1.20078310e-01f, -4.24599946e-02f, 2.22440109e-01f,
  3.05062570e-02f, 9.01239291e-02f, 1.51366740e-01f, -4.01347578e-02f, -2.25129090e-02f, 3.04055028e-02f, -9.69259883e-04f, 1.34366870e-01f, 9.88205820e-02f, 6.21509179e-03f,
  -1.11713320e-01f, -1.07602803e-02f, -8.37076157e-02f, 3.24104317e-02f, -9.36725289e-02f, 4.63473238e-02f, 3.34607363e-02f, -9.07852501e-02f, -8.64307135e-02f, 6.33016005e-02f,
  4.88239564e-02f, 5.70307449e-02f, -6.49535730e-02f, -9.37378556e-02f, 2.17811987e-02f, 5.69916479e-02f, -1.24695249e-01f, 6.84960037e-02f, -7.81761203e-03f, -2.46098917e-02f,
  -2.79018632e-03f, 6.62275776e-02f, -4.90587130e-02f, 8.16812664e-02f, 3.55437361e-02f, -1.37565717e-01f, -8.59768465e-02f, -8.23545270e-03f, -5.98586202e-02f, 7.35694468e-02f,
  -1.27446979e-01f, 1.69564504e-02f, 3.80187146e-02f, -1.30886108e-01f, 8.41218382e-02f, -7.56137148e-02f, 7.69034252e-02f, -5.19681014e-02f, -7.34678581e-02f, 1.07958749e-01f,
  -7.85529688e-02f, -4.51559797e-02f, 1.27074301e-01f, -8.32013339e-02f, -3.94216962e-02f, 4.95528989e-02f, 4.72478904e-02f, 5.37472256e-02f, -2.49962211e-02f, -5.44322841e-02f,
  -8.30733124e-03f, 6.62954301e-02f, 7.99034685e-02f, -1.27370119e-01f, 1.10478727e-02f, -1.65096521e-02f, -9.28144082e-02f, 4.60569710e-02f, 1.59070209e-01f, -3.49222235e-02f,
  3.24847922e-02f, -5.41200815e-03f, 8.94564670e-03f, 7.61039555e-02f, 2.06723914e-01f, -1.33981481e-02f, 1.42115485e-02f, -2.21258458e-02f, 1.94658451e-02f, 6.40143156e-02f,
  2.21008569e-01f, 1.82627253e-02f, 8.11346024e-02f, 1.34574533e-01f, 2.25831047e-02f, -1.55628681e-01f, 1.30414382e-01f, 2.96105957e-03f, -3.31981890e-02f, 4.56797406e-02f,
  1.35866106e-01f, -1.74379617e-01f, 9.51070860e-02f, 7.07278997e-02f, -2.31888648e-02f, 4.71456051e-02f, 1.12394267e-03f, 3.57127115e-02f, 1.65200815e-01f, 1.71656132e-01f,
  7.21455142e-02f, 6.16300814e-02f, 1.42347485e-01f, 1.51442498e-01f, -6.53786510e-02f, -6.88278750e-02f, 2.02964306e-01f, 1.27156839e-01f, 1.83537468e-01f, -8.85722972e-03f,
  1.44646332e-01f, -1.73552521e-03f, 9.30104032e-02f, -5.30957542e-02f, -2.45890021e-02f, -1.17861204e-01f, 2.77206022e-02f, 1.61546037e-01f, -7.95931891e-02f, -2.06651166e-01f,
  1.19279698e-01f, -8.20275173e-02f, 1.42004058e-01f, 9.47302580e-02f, 3.53969820e-02f, 9.96995419e-02f, 8.80131349e-02f, -1.87295511e-01f, -5.51540256e-02f, -8.34108219e-02f,
  -3.51981670e-02f, 1.07486114e-01f, 1.58257931e-01f, 9.77727324e-02f, 2.07263641e-02f, -1.06483191e-01f, -5.80041334e-02f, -7.49749616e-02f, 5.17598577e-02f, -4.53278199e-02f,
  1.80483967e-01f, 2.54923403e-01f, 1.41232491e-01f, 1.82743043e-01f, 1.39357626e-01f, 2.43951991e-01f, 5.99512421e-02f, 2.67052591e-01f, 1.97708644e-02f, 4.56673726e-02f,
  1.93444803e-01f, 9.51436013e-02f, -3.64467204e-02f, 1.21534958e-01f, -8.90253671e-03f, -1.60959400e-02f, 5.53894714e-02f, -8.49730056e-03f, 2.25500520e-02f, 1.50268704e-01f,
  4.87566553e-02f, 1.14209682e-01f, -2.43248641e-01f, -1.77137069e-02f, 2.43424028e-02f, 7.31881186e-02f, -3.15516256e-02f, 1.74546152e-01f, 5.93951494e-02f, 1.69118792e-01f,
  -9.19024423e-02f, -4.56186756e-02f, -3.03693153e-02f, 1.07599735e-01f, -3.66832577e-02f, -1.21724196e-01f, 4.88200923e-03f, -6.86149150e-02f, 4.94409278e-02f, 7.41416067e-02f,
  9.67039540e-02f, 1.74017072e-01f, 1.09725885e-01f, 1.29166290e-01f, 2.87024099e-02f, -2.86826547e-02f, 2.91557536e-02f, 6.17033951e-02f, 1.40464991e-01f, 1.07997738e-01f,
  9.12210867e-02f, -4.21047993e-02f, 2.31879167e-02f, 3.10820881e-02f, -8.92822742e-02f, 8.91679525e-02f, 2.23593965e-01f, 1.60467833e-01f, 8.11511874e-02f, 7.02771991e-02f,
  -6.43392801e-02f, -8.34816620e-02f, 1.82521090e-01f, 1.20924599e-01f, 8.13227743e-02f, 2.56820083e-01f, 3.29457112e-02f, 2.08689958e-01f, 4.53415923e-02f, 1.16385028e-01f,
  1.08983248e-01f, 5.79424612e-02f, -1.69955939e-02f, 1.26566455e-01f, 1.42548025e-01f, 1.57995462e-01f, -2.32766811e-02f, 1.60489082e-01f, -6.39126673e-02f, 9.52239260e-02f,
  5.12108728e-02f, -1.23426557e-01f, 2.98698902e-01f, -1.19747244e-01f, 6.13424256e-02f, 2.22674295e-01f, -2.16037165e-02f, -2.23073229e-01f, 1.17339455e-01f, -7.99608529e-02f,
  1.61231771e-01f, -1.13716863e-01f, -5.71922436e-02f, -6.19132631e-02f, 5.62675670e-03f, 9.92984604e-03f, 1.77039891e-01f, 1.36946872e-01f, -3.54003571e-02f, -1.50626609e-02f,
  2.25622147e-01f, 2.55216472e-02f, 4.53059375e-02f, -9.14034713e-03f, 6.58074841e-02f, -3.34316120e-02f, -4.09712121e-02f, -7.85867870e-02f, -5.37137948e-02f, 4.32255417e-02f,
  1.68897092e-01f, -2.59651355e-02f, -1.39989704e-01f, 2.32565433e-01f, 6.76848441e-02f, 1.53869569e-01f, -1.31720632e-01f, 3.51518206e-02f, -1.29605725e-01f, -1.49145499e-01f,
  2.53239840e-01f, 4.09048274e-02f, -1.24198668e-01f, 7.55992755e-02f, 6.60200492e-02f, 9.60403234e-02f, 3.95140946e-01f, 6.16076961e-02f, 9.75581780e-02f, 6.40475824e-02f,
  7.33481348e-02f, 1.55706435e-01f, -1.05127759e-01f, 1.14814468e-01f, 1.76759786e-03f, -6.10999241e-02f, 3.93800391e-03f, 4.89769541e-02f, 7.05544204e-02f, 1.27637297e-01f,
  -1.50582388e-01f, -8.76934975e-02f, 8.38394836e-03f, 1.66101366e-01f, -1.15667857e-01f, -2.02890690e-02f, 1.25727534e-01f, 2.11106129e-02f, 3.37111279e-02f, -1.74526423e-01f,
  6.11108579e-02f, -1.12679049e-01f, 1.31859183e-01f, 8.05027410e-03f, -5.75591698e-02f, 7.73049332e-03f, 1.15872033e-01f, 2.82233562e-02f, 7.94185773e-02f, 1.36294812e-01f,
  -2.22904589e-02f, -5.90588637e-02f, -4.03188467e-02f, -1.22677498e-01f, -6.10588156e-02f, -5.94502836e-02f, -6.53765351e-02f, 3.18885855e-02f, 6.45994172e-02f, -1.38854623e-01f,
  -1.02402605e-01f, 2.87480503e-01f, -8.02366361e-02f, -1.30871281e-01f, -1.67206511e-01f, 1.83548644e-01f, -1.01589505e-02f, 5.60554415e-02f, -1.59181938e-01f, 2.10947394e-01f,
  -2.43256567e-03f, 5.44434525e-02f, 1.49312764e-01f, 1.16258429e-03f, 2.87225861e-02f, -9.92467441e-03f, -1.53607118e-03f, -8.22186023e-02f, 1.04053080e-01f, 1.97495177e-01f,
  1.16779201e-01f, 1.04666546e-01f, 2.78242469e-01f, 1.76495045e-01f, 1.86371982e-01f, -3.73352729e-02f, 3.33514243e-01f, 9.01685208e-02f, 1.00390092e-01f, 2.38493890e-01f,
  1.38610825e-01f, 1.72219664e-01f, 1.58470586e-01f, 1.27257839e-01f, -1.76132187e-01f, -2.18400121e-01f, 2.93899447e-01f, -2.93166071e-01f, -4.60305922e-02f, 1.68302998e-01f,
  -3.70138973e-01f, 1.31612405e-01f, -3.28565314e-02f, -3.57621729e-01f, -1.02954600e-02f, 3.40666175e-01f, 9.44338664e-02f, -1.69005580e-02f, 6.67800531e-02f, 3.11824739e-01f,
  1.29460692e-01f, -2.86641605e-02f, 7.13985786e-02f, 1.87496305e-01f, 7.07916841e-02f, 9.16713011e-03f, -8.03086385e-02f, -8.40279534e-02f, -1.24561541e-01f, 8.09021071e-02f,
  -1.34699987e-02f, 1.10377610e-01f, 3.41518708e-02f, 7.64427334e-02f, 3.59605961e-02f, 3.35121572e-01f, 1.45669147e-01f, 1.20110482e-01f, -2.40828037e-01f, 1.31965384e-01f,
  1.31773725e-01f, -1.46243840e-01f, -5.32743968e-02f, 8.12959522e-02f, 1.65596247e-01f, 1.64114594e-01f, 2.57212669e-01f, 7.86557421e-02f, -1.02087736e-01f, -8.03549960e-02f,
  2.27096558e-01f, 3.83332558e-02f, 1.69501845e-02f, -1.21112995e-01f, -2.89933950e-01f, 1.75878294e-02f, -1.65287126e-02f, -4.37058061e-02f, 1.17828459e-01f, 4.22826931e-02f,
  -1.56301066e-01f, 8.11070129e-02f, 4.10035476e-02f, -5.72442748e-02f, 4.66369354e-04f, 1.41496196e-01f, -1.48440823e-01f, 2.39655674e-02f, -1.18196078e-01f, -8.96591023e-02f,
  6.89582080e-02f, -8.71499255e-03f, -5.99606596e-02f, 5.59791587e-02f, 5.84475026e-02f, 5.50454520e-02f, -6.59346059e-02f, 8.37873202e-03f, 1.20051824e-01f, 1.99551601e-03f,
  4.83133607e-02f, 1.04127988e-01f, -5.91452941e-02f, -2.20364500e-02f, 9.81784388e-02f, 2.21775305e-02f, 5.31825013e-02f, 3.89895104e-02f, -3.11665609e-02f, 1.21999666e-01f,
  -8.95553157e-02f, -6.40782565e-02f, -7.04101026e-02f, -3.71996984e-02f, -6.16907664e-02f, 2.99029946e-02f, -7.73274526e-02f, -1.23554468e-01f, 1.04510866e-01f, 1.02043547e-01f,
  3.30748148e-02f, -5.05830569e-04f, 9.90409926e-02f, 1.44232184e-01f, 6.89807832e-02f, 5.19044586e-02f, 1.77895324e-03f, 2.22307205e-01f, -5.41885979e-02f, -1.98201798e-02f,
  4.55503389e-02f, 3.22390907e-02f, -3.16374339e-02f, 9.27325804e-03f, -8.83985534e-02f, 1.29860893e-01f, -4.65432033e-02f, -1.72079988e-02f, 9.87420678e-02f, -3.39231230e-02f,
  -1.61000621e-02f, 2.51682173e-03f, 2.17152312e-01f, 6.82263672e-02f, 1.68308958e-01f, 1.82813272e-01f, 1.07230790e-01f, 2.40856081e-01f, 1.11136898e-01f, 3.33311707e-02f,
  1.07068829e-01f, 8.58692527e-02f, 1.52573347e-01f, -2.53993213e-01f, 1.49210647e-01f, -1.03004733e-02f, 1.49436593e-01f, 7.94153512e-02f, 1.08264878e-01f, -1.04552872e-01f,
  -6.43407479e-02f, -8.96087438e-02f, -1.82226121e-01f, -2.21550256e-01f, -1.07869864e-01f, -4.70591486e-02f, 1.74396373e-02f, 2.94554621e-01f, 1.03976816e-01f, 1.53240383e-01f,
  -2.47304723e-01f, 1.71390343e-02f, -7.00194538e-02f, 2.42837798e-02f, -5.76548232e-03f, -1.06126353e-01f, -9.51814502e-02f, 1.92683369e-01f, 6.09822571e-03f, -2.48999409e-02f,
  8.45857561e-02f, -3.83802466e-02f, 1.99131429e-01f, 1.81172267e-01f, -1.98466778e-02f, -1.19057246e-01f, -6.25773668e-02f, 3.44043188e-02f, -2.02055484e-01f, 6.77744765e-03f,
  1.21854708e-01f, -3.10354270e-02f, 1.00265473e-01f, 3.56232256e-01f, -8.12677592e-02f, -9.31029692e-02f, -5.27881570e-02f, -5.72198033e-02f, -7.00727254e-02f, 1.19876444e-01f,
  -6.05398044e-02f, -8.87182280e-02f, -1.67934775e-01f, 7.79478857e-03f, -2.67889313e-02f, 2.01430451e-02f, 3.88940610e-02f, -9.47106332e-02f, -1.33902486e-02f, -5.05260527e-02f,
  -1.18771782e-02f, -1.35619983e-01f, 8.77870098e-02f, -1.16446279e-01f, -7.16757551e-02f, 1.11582227e-01f, 6.07247315e-02f, -8.04602280e-02f, -1.06855981e-01f, 6.77995235e-02f,
  8.55661780e-02f, -1.01427259e-02f, -1.05453864e-01f, 7.30713606e-02f, -2.27524135e-02f, 4.10412699e-02f, -6.41973168e-02f, 1.13466948e-01f, 4.61522788e-02f, -1.01127356e-01f,
  8.48800093e-02f, -1.14352383e-01f, -9.17889848e-02f, -7.18567893e-02f, 1.23520173e-01f, -8.16655681e-02f, 5.34329377e-03f, 4.79657985e-02f, 2.26579816e-03f, -8.72373804e-02f,
  -1.63562391e-02f, 1.07912216e-02f, -5.79753667e-02f, -2.82449704e-02f, -1.93004087e-02f, 7.44202510e-02f, -5.97134605e-02f, 8.85481909e-02f, 3.23647223e-02f, -4.43666540e-02f,
  -2.04863921e-02f, 8.74531865e-02f, 2.73419693e-02f, -7.21490085e-02f, 5.43107092e-02f, -4.13246416e-02f, -2.15140060e-02f, -1.37897298e-01f, -4.08791415e-02f, 6.70450553e-02f,
  8.24945867e-02f, 7.64754117e-02f, -1.18776530e-01f, 8.78500789e-02f, -7.56630301e-02f, 1.24829700e-02f, 4.86658700e-02f, -1.16472609e-01f, 3.89668159e-02f, 1.20649077e-01f,
  4.65082377e-02f, -2.99714729e-02f, -6.08806871e-02f, -1.43267605e-02f, 2.28400007e-02f, -8.74803737e-02f, -1.32215321e-01f, 5.46356365e-02f, -2.42672786e-02f, -9.29249749e-02f,
  1.93668604e-02f, -2.22433079e-02f, -6.90416321e-02f, 1.25727594e-01f, -1.19622231e-01f, 5.07049449e-02f, -1.08189695e-01f, 1.12595268e-01f, -6.72186241e-02f, 4.28461395e-02f,
  -5.82163269e-03f, 8.06885213e-02f, 1.46357929e-02f, 6.79774359e-02f, 5.64375520e-02f, -7.98248872e-02f, 2.24298742e-02f, -3.39081511e-02f, -3.79306562e-02f, 3.10865045e-02f,
  -3.52077857e-02f, -2.04197802e-02f, 6.36782199e-02f, 8.41161683e-02f, -8.90499428e-02f, -4.90115471e-02f, 3.95483524e-02f, 6.86209351e-02f, -1.17563404e-01f, 4.24561016e-02f,
  6.13619164e-02f, 8.16961974e-02f, -1.20853014e-01f, 8.14059675e-02f, -6.44688010e-02f, -3.11487429e-02f, -4.06037867e-02f, 3.60517460e-03f, 2.01730318e-02f, 1.81681812e-02f,
  6.77871257e-02f, -7.50123560e-02f, 1.15859464e-01f, 8.35871026e-02f, -9.14857760e-02f, 7.54301250e-02f, 1.17979012e-01f, -3.96951698e-02f, -8.11067671e-02f, 2.23411974e-02f,
  5.98335005e-02f, 6.84142709e-02f, 7.20758317e-03f, -9.52613503e-02f, -1.00864505e-03f, 1.01592310e-01f, -1.12112269e-01f, -6.12816401e-02f, 4.32795770e-02f, 1.18987180e-01f,
  1.92078128e-01f, 2.11475253e-01f, 1.30416512e-01f, 1.14861257e-01f, 2.18855157e-01f, -2.28606343e-01f, 1.80506349e-01f, 5.20683900e-02f, 2.58277237e-01f, 4.46127094e-02f,
  1.22711502e-01f, -1.09911114e-01f, -1.92657664e-01f, 1.82195887e-01f, -7.92017132e-02f, -2.14542344e-01f, -1.53259367e-01f, 9.41554736e-03f, 2.78549399e-02f, -2.07383960e-01f,
  3.47911298e-01f, 2.58097313e-02f, -1.34547144e-01f, 1.92711148e-02f, -6.68272227e-02f, 2.77147174e-01f, -6.66924268e-02f, 1.44578397e-01f, 7.31621161e-02f, 4.27156053e-02f,
  4.97544631e-02f, -6.19845651e-02f, 2.77548611e-01f, -5.44429608e-02f, 3.39230090e-01f, 2.58852005e-01f, -1.21231481e-01f, -9.29119736e-02f, -1.31278872e-01f, -1.27032906e-01f,
  -1.11854501e-01f, 1.16395419e-02f, -2.77554430e-02f, 8.23965743e-02f, -1.36274412e-01f, 3.46123248e-01f, 7.36427605e-02f, 3.49225551e-02f, 3.93675566e-02f, 1.63749292e-01f,
  -2.59252004e-02f, 9.17935073e-02f, -1.19077541e-01f, 1.25588074e-01f, 4.19956557e-02f, 4.22499739e-02f, 1.64206237e-01f, 1.65652588e-01f, 1.08436793e-02f, 1.43580467e-01f,
  2.39023361e-02f, 4.48846482e-02f, 1.14646628e-02f, 1.28579497e-01f, 9.65152904e-02f, 1.14022218e-01f, 7.53639340e-02f, -6.98339492e-02f, -4.64589819e-02f, 6.09532604e-03f,
  -2.76177704e-01f, 1.64853424e-01f, -3.95917892e-03f, -7.09562302e-02f, 4.03031744e-02f, 8.36222693e-02f, 7.17402473e-02f, -3.66820358e-02f, -1.07384302e-01f, 5.89206256e-02f,
  9.85642970e-02f, -9.49953720e-02f, -6.95884451e-02f, 9.32262763e-02f, -1.21682301e-01f, 4.79420945e-02f, -1.03896670e-01f, 6.55515492e-02f, -9.41402763e-02f, 4.48571630e-02f,
  1.17584392e-01f, 7.42059350e-02f, -6.28458112e-02f, 2.22216286e-02f, 6.32917956e-02f, 1.99188694e-01f, -7.78130516e-02f, 5.81298172e-02f, -1.01731978e-01f, -1.17628668e-02f,
  -5.89391179e-02f, 5.32344915e-02f, 9.18798447e-02f, -1.29417121e-01f, -2.86717545e-02f, 1.57773439e-02f, 9.35459286e-02f, -7.13982731e-02f, -4.93134484e-02f, -1.22214377e-01f,
  1.10316187e-01f, -2.02296451e-02f, 1.53754026e-01f, -9.37349647e-02f, 3.81034873e-02f, -8.13831910e-02f, 7.36837387e-02f, -5.02806790e-02f, 8.28197896e-02f, 9.03808028e-02f,
  -7.78075829e-02f, 5.37289344e-02f, -5.02898842e-02f, -4.12818119e-02f, -4.11784425e-02f, 6.51646778e-02f, 3.39964032e-02f, -1.85075030e-02f, -8.53428915e-02f, -1.15921553e-02f,
  -2.78783180e-02f, -4.87622321e-02f, 8.79979581e-02f, -1.06488891e-01f, 5.16879074e-02f, -6.69531375e-02f, -6.65266812e-02f, -5.27740456e-02f, 5.40286861e-03f, 1.16715357e-01f,
  1.17227193e-02f, 7.20889047e-02f, -3.19802910e-02f, -4.51562144e-02f, 5.43080457e-02f, 4.52223010e-02f, -4.72060218e-02f, -6.55900910e-02f, -6.69831112e-02f, -7.99743310e-02f,
  -8.28526020e-02f, -4.63518612e-02f, -3.90778817e-02f, -5.51840179e-02f, -4.21261303e-02f, -2.85336711e-02f, 9.82724428e-02f, 2.61855498e-03f, 4.00077552e-02f, -7.69652873e-02f,
  8.49568248e-02f, -1.03651159e-01f, -4.03520800e-02f, 4.80307415e-02f, 4.19397056e-02f, 5.19351568e-04f, -2.20407862e-02f, -5.25900759e-02f, 3.66099104e-02f, 8.56431276e-02f,
  -2.86896760e-03f, -1.21060111e-01f, -8.45375806e-02f, -4.47208025e-02f, -6.05327263e-03f, 6.11612462e-02f, 8.72741118e-02f, -2.31464785e-02f, 5.74083291e-02f, -1.38924895e-02f,
  -1.04075715e-01f, 8.41610208e-02f, -2.53393874e-02f, -2.18711933e-03f, -8.55809450e-02f, 7.16642737e-02f, 1.48894591e-03f, 1.37936488e-01f, -3.73469666e-02f, 7.81970099e-03f,
  6.49858564e-02f, 6.81040585e-02f, -5.50514311e-02f, -4.82770652e-02f, -1.07874893e-01f, 2.43241470e-02f, -4.98380288e-02f, 1.15074731e-01f, -8.95840749e-02f, -8.81197006e-02f,
  1.02314949e-01f, 5.64499870e-02f, 3.58564816e-02f, 1.93627253e-01f, -3.12742516e-02f, 7.83047974e-02f, -4.39981371e-02f, -8.02467391e-02f, 4.11364175e-02f, 1.96338385e-01f,
  -1.07466979e-02f, 6.37723505e-02f, -8.38764310e-02f, -4.70040441e-02f, 1.28001809e-01f, 1.50272459e-01f, 5.33772185e-02f, -1.02564760e-01f, 8.19214806e-02f, -1.08952105e-01f,
  6.85591623e-02f, 2.85938028e-02f, 2.04029009e-02f, -7.39135593e-03f, -2.88785552e-03f, -8.63065645e-02f, -6.98632300e-02f, 1.00808637e-02f, 6.89486116e-02f, 1.36359602e-01f,
  1.75196320e-01f, -3.14759053e-02f, 1.04260810e-01f, -1.63722202e-01f, 1.10746115e-01f, -3.59485038e-02f, 9.27731991e-02f, -9.96463895e-02f, 1.56511962e-01f, 7.71510066e-04f,
  1.60043195e-01f, -7.21920729e-02f, 5.22557013e-02f, 7.05859736e-02f, 1.33613199e-01f, -1.10818222e-01f, 8.47065374e-02f, -8.95055979e-02f, 1.85661599e-01f, -6.89439103e-02f,
  5.14945425e-02f, -3.55538353e-02f, 7.76210800e-02f, -1.12281457e-01f, 4.73236330e-02f, 1.45221397e-01f, 1.68571934e-01f, -1.46681190e-01f, 2.33168170e-01f, 8.62139314e-02f,
  5.23927100e-02f, -8.69311914e-02f, 1.54723614e-01f, -1.66143715e-01f, 9.09981728e-02f, -2.30903346e-02f, -1.64606228e-01f, -1.75647780e-01f, 1.33039150e-02f, -1.32720843e-01f,
  -2.32806411e-02f, 4.58694175e-02f, 1.89514216e-02f, 1.43871620e-01f, 9.08449590e-02f, 9.08171535e-02f, 9.16081220e-02f, 1.04420692e-01f, -1.86094850e-01f, 1.37299865e-01f,
  -9.43709612e-02f, 7.90243149e-02f, 4.77051511e-02f, 1.20505840e-01f, 7.56708905e-02f, 1.60548791e-01f, -1.01806611e-01f, 2.86790803e-02f, 3.42498487e-03f, 4.31035943e-02f,
  1.21640220e-01f, -3.85992900e-02f, 1.25837371e-01f, -2.12448109e-02f, -1.12557851e-01f, -6.93866517e-03f, 5.45909218e-02f, 9.74540338e-02f, -9.73102730e-03f, -4.45321463e-02f,
  1.53706387e-01f, 1.47107825e-01f, -6.98733777e-02f, 5.95325343e-02f, -1.27313137e-02f, -6.04457855e-02f, 1.28544569e-01f, -8.91050696e-02f, -4.42186557e-02f, 3.91636007e-02f,
  -2.27756158e-01f, -1.81461629e-02f, 1.46246225e-01f, 1.28242314e-01f, 1.98000669e-01f, 4.06665094e-02f, 8.03281739e-02f, 1.62560433e-01f, 4.18411531e-02f, -5.95976114e-02f,
  4.53480557e-02f, 4.44251411e-02f, 1.17475078e-01f, 1.49675652e-01f, -9.56490934e-02f, -6.69478253e-02f, -1.22384138e-01f, 7.98293874e-02f, 2.72566497e-01f, -6.83127530e-03f,
  -8.41679797e-03f, -1.58898048e-02f, -2.14018896e-01f, 8.72059837e-02f, -2.98179090e-01f, 1.66066051e-01f, 7.68073648e-02f, 1.81002542e-01f, -7.97684342e-02f, -2.27797441e-02f,
  2.73344338e-01f, 5.15095443e-02f, -1.24575637e-01f, -1.07960822e-03f, -1.43905848e-01f, 3.80852260e-02f, -8.25510696e-02f, -1.91086993e-01f, 1.17366873e-01f, -1.16284497e-01f,
  1.29558155e-02f, -2.84454465e-01f, 1.41948342e-01f, 2.40049362e-01f, -5.18018864e-02f, 2.97394931e-01f, 1.05767243e-01f, 1.47410199e-01f, 2.68025808e-02f, -1.40837535e-01f,
  1.06214032e-01f, 8.96049850e-03f, 6.41509071e-02f, 3.14840488e-02f, -9.47876945e-02f, 1.39576852e-01f, 1.86251383e-02f, -2.55783256e-02f, 2.05912933e-01f, 7.24956542e-02f,
  4.16295975e-02f, 4.92294542e-02f, 1.93923533e-01f, -7.29474723e-02f, -1.11125819e-01f, -9.51391533e-02f, -6.91322535e-02f, 2.81546749e-02f, -2.64400411e-02f, -5.71635514e-02f,
  3.73889618e-02f, 8.64716321e-02f, 5.08909188e-02f, -2.67598070e-02f, -3.13153565e-02f, 1.51461884e-02f, -3.66913117e-02f, -7.73987249e-02f, -3.13812904e-02f, 7.70770535e-02f,
  -4.97534350e-02f, -5.89412376e-02f, 1.22565739e-02f, 6.16621971e-02f, -1.12794936e-01f, 7.25084469e-02f, -3.82055491e-02f, -9.31564793e-02f, -4.85112444e-02f, -1.13690145e-01f,
  2.26311963e-02f, 2.07431428e-03f, -1.03340395e-01f, 3.07489019e-02f, 7.49629661e-02f, -6.69065192e-02f, -3.66139449e-02f, 2.57721380e-03f, -5.34503981e-02f, 7.39325657e-02f,
  1.19407639e-01f, -1.29975623e-03f, 1.17463171e-01f, -1.06410474e-01f, -8.31260979e-02f, 9.25226063e-02f, -6.63719978e-03f, 1.04426637e-01f, 8.89748931e-02f, 1.02201337e-02f,
  -5.12372963e-02f, 1.37118250e-01f, 1.19285390e-01f, 7.44831422e-03f, 4.04417776e-02f, 8.92666504e-02f, 4.45949137e-02f, 7.53005594e-02f, 9.93458834e-03f, 1.59821454e-02f,
  -1.04764067e-01f, -6.53647855e-02f, -3.21087427e-02f, -2.84358729e-02f, 5.20707220e-02f, -1.10527329e-01f, 1.33208603e-01f, -3.46766375e-02f, -9.03414637e-02f, -1.62779465e-02f,
  5.03796786e-02f, -5.77563979e-02f, 1.34834275e-01f, -5.27267903e-03f, -5.75910993e-02f, -6.48543462e-02f, 1.34864211e-01f, -3.96804102e-02f, 1.08815603e-01f, -4.58792523e-02f,
  -7.87922144e-02f, 1.72404379e-01f, 1.88550763e-02f, -1.26666620e-01f, -8.12457874e-02f, 3.01145539e-02f, 5.33205718e-02f, 1.09591290e-01f, 5.67758195e-02f, -7.93980956e-02f,
  -1.27413064e-01f, 6.63062185e-02f, -7.44634718e-02f, -6.43957108e-02f, -8.45034719e-02f, 6.96023330e-02f, -4.98176925e-02f, -1.07840307e-01f, 2.06791237e-01f, -4.65396680e-02f,
  -1.09690681e-01f, 6.96420623e-03f, -4.79117371e-02f, -7.22935498e-02f, -5.26528917e-02f, 2.72001605e-03f, -5.22972979e-02f, -8.41474440e-03f, 8.00305083e-02f, -8.34912211e-02f,
  -3.82206514e-02f, -1.04958817e-01f, 8.23305696e-02f, 1.72941118e-01f, -6.63463548e-02f, -9.63321030e-02f, -1.31168619e-01f, -3.20631899e-02f, 8.35101679e-02f, 6.86263517e-02f,
  5.08166254e-02f, -5.65160811e-02f, 7.32447580e-02f, 7.17305467e-02f, -1.63621567e-02f, 4.88596782e-02f, -7.44410679e-02f, 1.25746883e-03f, 3.71717513e-02f, -1.00109242e-02f,
  8.61543268e-02f, -1.08004898e-01f, 1.09404273e-01f, 1.32451758e-01f, 2.29592651e-01f, -2.76343264e-02f, 1.85032889e-01f, 7.80858248e-02f, 2.57933468e-01f, -2.52598319e-02f,
  5.60910963e-02f, 2.71700740e-01f, 1.82305481e-02f, 1.38125896e-01f, 2.41699398e-01f, 1.79880559e-01f, 5.32056950e-02f, -2.38764450e-01f, 1.69530883e-01f, -1.60875633e-01f,
  8.76696259e-02f, 1.19779274e-01f, -2.65562236e-01f, 1.71010986e-01f, 1.60518959e-01f, -2.18924701e-01f, 2.30497401e-02f, 1.97338179e-01f, 9.87045467e-02f, -1.45163788e-02f,
  3.24143097e-02f, 1.52169347e-01f, 1.96690112e-01f, 2.88872421e-02f, -1.78177655e-02f, -3.93057466e-02f, -1.95309997e-01f, -4.86062244e-02f, 1.19537383e-01f, -1.88775547e-02f,
  -1.55535370e-01f, 1.01067081e-01f, 6.52267262e-02f, 1.45076439e-01f, 7.02322349e-02f, 1.11232176e-01f, 3.97218242e-02f, -9.93375573e-03f, 4.21550013e-02f, 1.26377761e-01f,
  -3.81455421e-02f, -9.41123664e-02f, 1.42357364e-01f, 3.40000540e-02f, -8.10611621e-02f, -6.31149262e-02f, 2.34024692e-02f, 2.21267655e-01f, -2.45401897e-02f, 5.99345937e-02f,
  -1.06493039e-02f, 5.03111333e-02f, 1.89098401e-03f, 6.19244762e-02f, -1.29006892e-01f, -1.11466512e-01f, -2.76351303e-01f, -5.98846972e-02f, 1.12439260e-01f, 4.12345044e-02f,
  5.24342945e-03f, 5.48525415e-02f, 7.16389716e-02f, -3.64884697e-02f, 4.23204899e-02f, 2.42423303e-02f, 1.20707221e-01f, -2.42640041e-02f, -6.25977963e-02f, 1.28735214e-01f,
  1.13716528e-01f, 1.16221160e-01f, 6.18576854e-02f, -1.05131790e-01f, 1.04643524e-01f, -5.39425910e-02f, 4.02519219e-02f, 1.47182971e-01f, 1.34528965e-01f, 3.78620840e-04f,
  -1.93730250e-01f, 4.22126316e-02f, 1.21122964e-01f, 1.33506358e-01f, -3.69887031e-03f, 1.97354019e-01f, -1.64342821e-01f, -4.69787158e-02f, 7.51336664e-02f, -6.93541067e-03f,
  1.10232852e-01f, -3.92672531e-02f, 9.61811170e-02f, -9.42078009e-02f, 1.22312769e-01f, -4.06807736e-02f, 6.71214908e-02f, 1.23279035e-01f, 1.69209391e-01f, 1.52901515e-01f,
  -8.67689848e-02f, -1.38775870e-01f, -1.92279276e-02f, 1.51047984e-03f, 1.45998836e-01f, 3.84700038e-02f, -4.08630259e-02f, 3.29270363e-02f, 1.49074391e-01f, -1.23570926e-01f,
  -1.16864391e-01f, 7.66256079e-02f, 3.96222137e-02f, -4.22722399e-02f, 4.18615378e-02f, 2.20865868e-02f, 2.90811295e-03f, -8.48735273e-02f, 5.54022528e-02f, 9.70983654e-02f,
  1.09583646e-01f, -4.38134000e-02f, -8.87534171e-02f, 9.18416902e-02f, -1.66666768e-02f, 1.09442703e-01f, -1.08312018e-01f, 1.55282003e-04f, 1.05678335e-01f, -1.69885196e-02f,
  1.64062798e-01f, -1.02941711e-02f, -5.12280203e-02f, 4.02934514e-02f, -1.39387175e-01f, -7.61894137e-02f, -1.13701262e-01f, 1.11027844e-01f, -1.31425411e-01f, -4.17051055e-02f,
  -8.52371007e-03f, -1.01786420e-01f, 1.31801054e-01f, 8.36603120e-02f, 5.89698330e-02f, -2.09929630e-01f, 1.35849386e-01f, 6.30765036e-02f, 5.97341992e-02f, -1.43410444e-01f,
  -6.00364953e-02f, -6.00712337e-02f, 4.99689654e-02f, 1.67132184e-01f, 7.42693916e-02f, -1.59672778e-02f, 1.24252684e-01f, 6.40363246e-02f, -2.46515647e-02f, -9.51387137e-02f,
  7.55254924e-02f, -7.56796375e-02f, 1.45215001e-02f, 9.32526067e-02f, 2.36014114e-03f, -8.53951350e-02f, -1.16926461e-01f, 1.29385009e-01f, 1.84248850e-01f, 1.09583348e-01f,
  1.45092430e-02f, 1.06438480e-01f, 1.47688061e-01f, 2.76144058e-01f, -1.12834364e-01f, -8.74055624e-02f, -5.36790937e-02f, 9.41955000e-02f, 5.08021051e-03f, -4.27023359e-02f,
  -1.53937108e-05f, 2.13217791e-02f, 1.78484455e-01f, 2.13418111e-01f, 1.35022104e-01f, -3.47668640e-02f, 9.09308568e-02f, 1.12180397e-01f, -7.36025348e-02f, -9.25367549e-02f,
  6.61703274e-02f, 2.76877582e-02f, -3.56858745e-02f, -4.96057756e-02f, -2.95189675e-02f, -2.01761182e-02f, -4.65208367e-02f, 8.73244777e-02f, 3.65908779e-02f, -1.13166489e-01f,
  4.58591580e-02f, -9.62988436e-02f, -5.38690500e-02f, 1.28578087e-02f, -4.25291508e-02f, 8.81344639e-03f, -1.17841877e-01f, 4.65906858e-02f, -4.52888780e-04f, -4.68354151e-02f,
  1.89815909e-02f, -2.93718260e-02f, -1.39407534e-02f, 1.60834879e-01f, -1.11658022e-01f, 2.84724571e-02f, -7.06721619e-02f, 7.31816962e-02f, 9.90038663e-02f, -1.13020122e-01f,
  -3.02777309e-02f, -3.30004506e-02f, 4.27490287e-02f, 7.98588544e-02f, 2.62159891e-02f, -6.39048517e-02f, -5.48367687e-02f, 4.88598049e-02f, -3.11357323e-02f, -8.72063730e-03f,
  1.40312374e-01f, 8.57696757e-02f, 5.80259636e-02f, -1.33771040e-02f, -1.11426570e-01f, -8.78012106e-02f, 2.47378983e-02f, -1.04499727e-01f, -3.49009223e-02f, -1.44987665e-02f,
  -6.08159713e-02f, -5.63125797e-02f, -9.50971544e-02f, 3.44762281e-02f, 9.71068908e-03f, -2.65082195e-02f, -1.05305880e-01f, -1.09290041e-01f, -6.23338260e-02f, 1.15469389e-01f,
  -3.17408070e-02f, -2.34376676e-02f, 4.94045652e-02f, 9.48593989e-02f, -1.82521436e-02f, 4.35890853e-02f, 5.51541569e-03f, -6.29934072e-02f, -6.74078241e-02f, 2.62332316e-02f,
  1.27913607e-02f, 1.49266616e-01f, -9.23715681e-02f, 1.09583467e-01f, -8.89096856e-02f, 1.44984528e-01f, -5.73054701e-02f, -1.82312876e-01f, 4.15258929e-02f, -1.07698618e-02f,
  -2.93310564e-02f, 1.49803668e-01f, -2.35656220e-02f, 1.33954138e-01f, 9.42720994e-02f, 1.00856638e-02f, -3.55808213e-02f, -4.43227813e-02f, -8.45550150e-02f, 4.51450050e-02f,
  1.59075845e-03f, -6.18538633e-02f, 1.43048555e-01f, -7.53847808e-02f, -5.59110269e-02f, 1.92232728e-01f, 2.93426104e-02f, -4.20178063e-02f, 7.97427222e-02f, 2.20702320e-01f,
  1.13559611e-01f, -1.11702040e-01f, 6.34122118e-02f, -1.88830405e-01f, 9.37653556e-02f, 3.16159874e-02f, 4.63615805e-02f, 6.78262338e-02f, -6.34925738e-02f, 1.07975021e-01f,
  1.00301832e-01f, 7.30353445e-02f, -5.26706837e-02f, -3.10511943e-02f, -7.41179893e-03f, -4.38286886e-02f, 6.91890791e-02f, -1.26964554e-01f, -1.21016681e-01f, -1.03335790e-01f,
  -6.80129454e-02f, 8.96612406e-02f, 9.77197383e-03f, 1.12181857e-01f, -1.06464699e-01f, -9.56398323e-02f, 4.36817594e-02f, 3.65241468e-02f, 1.15791962e-01f, 9.90293771e-02f,
  -1.02853179e-01f, 1.04790322e-01f, 7.64600188e-02f, -5.73479980e-02f, 8.19013491e-02f, -7.27694621e-03f, -1.36016449e-02f, 3.88300642e-02f, -5.68581978e-04f, -2.26634964e-02f,
  -9.27262008e-02f, 9.78490934e-02f, 8.02896172e-02f, 5.76820709e-02f, 3.45430411e-02f, 2.13946365e-02f, 3.56065705e-02f, -3.98271903e-02f, 8.85591935e-03f, 1.07105404e-01f,
  1.13394424e-01f, -9.01337713e-02f, 4.85394970e-02f, 9.90801528e-02f, -1.07563831e-01f, -9.61302817e-02f, 4.72901091e-02f, 1.75410882e-02f, 1.25990063e-01f, 9.44869444e-02f,
  -2.33624931e-02f, 2.91533489e-02f, -2.55166255e-02f, -7.81901646e-03f, 9.52181127e-03f, -5.15773334e-02f, -6.26584664e-02f, -7.86859393e-02f, -9.00302678e-02f, -1.16605327e-01f,
  3.88280712e-02f, -8.49856436e-02f, 5.34466244e-02f, 3.51280682e-02f, -6.03382662e-02f, 1.36514366e-01f, 1.17512323e-01f, -1.18114613e-01f, 6.26364946e-02f, 2.75146049e-02f,
  3.97131685e-03f, -5.62249012e-02f, 8.12342763e-02f, -1.15324244e-01f, -1.16705425e-01f, -6.76908121e-02f, -5.56318946e-02f, -1.27403617e-01f, -2.37359316e-03f, -1.41995708e-02f,
  1.29517451e-01f, 1.39758155e-01f, -3.18881101e-03f, 3.47539522e-02f, -4.29131165e-02f, -4.80078645e-02f, 1.61244750e-01f, 2.00768247e-01f, -3.13853249e-02f, 2.01332364e-02f,
  -2.54490529e-03f, -5.91852702e-02f, -5.69714867e-02f, 1.85913041e-01f, -6.34014457e-02f, 8.76636356e-02f, 4.34551798e-02f, -3.00876535e-02f, -2.02662349e-01f, -3.89177003e-03f,
  -1.13178819e-01f, 1.19519066e-02f, 5.92446923e-02f, 1.10716246e-01f, 2.85721216e-02f, -5.36497273e-02f, -1.42701706e-02f, -7.19879270e-02f, -5.08307666e-02f, -1.04306243e-01f,
  1.53191939e-01f, -5.67299649e-02f, -1.34894744e-01f, -8.81126896e-02f, -5.25468886e-02f, -4.35982384e-02f, 1.50639072e-01f, -1.37762994e-01f, 1.12767570e-01f, -1.53502505e-02f,
  -1.00751333e-01f, 2.51342207e-01f, 1.34704486e-01f, -7.24418312e-02f, -1.19009346e-01f, 1.48005471e-01f, 1.98836327e-01f, 1.41647821e-02f, -6.87018707e-02f, 6.74288571e-02f,
  2.68896092e-02f, 5.17814830e-02f, -9.29451641e-03f, -7.96620455e-03f, -6.07012995e-02f, -3.83785479e-02f, -5.38899973e-02f, 7.77267069e-02f, 1.46113738e-01f, 1.75667614e-01f,
  5.84390238e-02f, 1.54379189e-01f, -7.16796666e-02f, -3.93819995e-02f, -8.93923417e-02f, 8.64247326e-03f, 8.93378034e-02f, 1.21176846e-01f, 3.09738647e-02f, 3.39664556e-02f,
  1.34549448e-02f, 8.13221373e-03f, -7.66185969e-02f, -7.26704299e-02f, -9.26357284e-02f, 6.26331866e-02f, -1.19600423e-01f, 2.03714166e-02f, 1.10099867e-01f, 5.20360144e-03f,
  8.09027702e-02f, 2.03090180e-02f, 1.00912631e-01f, 8.55595395e-02f, -7.76027516e-02f, -1.73319839e-02f, -3.14529575e-02f, 7.07989782e-02f, 5.94637096e-02f, 7.91131854e-02f,
  -6.03765845e-02f, 6.48358837e-03f, 1.00166880e-01f, -8.42838585e-02f, -8.96720514e-02f, 7.42592588e-02f, 5.50937913e-02f, -8.58578011e-02f, -1.09258488e-01f, 8.67336094e-02f,
  7.78718889e-02f, 2.19874140e-02f, -1.00727953e-01f, 7.44507760e-02f, 7.94688687e-02f, 2.29639728e-02f, 1.53449131e-03f, 1.37369171e-01f, 1.57759562e-01f, 3.33130844e-02f,
  3.71333510e-02f, -6.74780980e-02f, 8.56972411e-02f, 5.52433208e-02f, 5.12112677e-03f, -1.21878207e-01f, -5.34064658e-02f, 6.92279637e-02f, 5.23589626e-02f, -9.37286615e-02f,
  1.12513542e-01f, -5.64494394e-02f, -1.24834673e-02f, 6.66465312e-02f, 1.11542381e-01f, -1.02352947e-01f, -7.64027238e-02f, 4.53650840e-02f, 1.08433068e-01f, 1.49922684e-01f,
  -5.77505492e-03f, 1.31808132e-01f, 4.51734886e-02f, -1.95146911e-02f, 1.54078856e-01f, -4.51533198e-02f, 6.28472343e-02f, 1.69312693e-02f, -3.90062109e-02f, -1.34224102e-01f,
  1.21822685e-01f, -8.44501331e-02f, 2.58598360e-03f, 1.45785704e-01f, 1.73220277e-01f, -1.56319924e-02f, -1.25158459e-01f, -1.75982397e-02f, 1.41480818e-01f, -2.67954599e-02f,
  1.35475010e-01f, 2.16502659e-02f, 7.91679770e-02f, -1.39223352e-01f, 8.23498294e-02f, -9.01698545e-02f, 7.07725510e-02f, 1.01287074e-01f, 7.25255758e-02f, 1.30789891e-01f,
  -3.57556678e-02f, 1.23781018e-01f, 3.95149998e-02f, -3.97241674e-02f, 1.82102825e-02f, -1.27091214e-01f, 1.46056369e-01f, 4.56837900e-02f, 2.50691734e-02f, -1.05772018e-01f,
  -5.89073300e-02f, 3.78163941e-02f, -1.11095868e-01f, 1.47258371e-01f, -5.33102313e-03f, -1.30616441e-01f, 1.22799255e-01f, 1.69154659e-01f, 1.01530157e-01f, 1.59941778e-01f,
  -9.64812040e-02f, -6.76365197e-02f, -6.19637128e-03f, 1.88983381e-01f, 6.31513521e-02f, 1.11677155e-01f, 4.66496311e-02f, 1.43629238e-01f, 2.07766771e-01f, 1.18308291e-01f,
  2.51076389e-02f, 9.43801180e-02f, 3.80061977e-02f, -4.08882052e-02f, -7.42422715e-02f, 1.56906378e-02f, -4.87865061e-02f, -3.45664844e-02f, -2.30224151e-02f, 1.22033335e-01f,
  1.13870554e-01f, -3.57581191e-02f, 5.63833788e-02f, -7.67175406e-02f, 9.35937837e-02f, 4.78469627e-03f, 5.09706773e-02f, 1.13306865e-01f, 1.65602621e-02f, -1.43950552e-01f,
  -7.35966787e-02f, 6.12816513e-02f, -1.30733937e-01f, 6.75103664e-02f, -6.59766421e-02f, -1.45776775e-02f, 2.54281424e-03f, 1.46556094e-01f, 6.75351992e-02f, 8.27914998e-02f,
  3.06233577e-02f, -9.82624665e-02f, 1.17436685e-01f, -1.16663456e-01f, 1.13745734e-01f, -6.92247320e-03f, -5.41833863e-02f, -5.99553511e-02f, 9.36761349e-02f, -6.24049120e-02f,
  5.63259684e-02f, 4.23259474e-02f, -7.34008029e-02f, -2.37680133e-02f, 1.08608659e-02f, 3.24498452e-02f, 9.60182473e-02f, -8.85864198e-02f, 3.33952717e-02f, -1.12916222e-02f,
  -9.02876183e-02f, 6.21109977e-02f, -6.84521496e-02f, 6.38066009e-02f, -9.15671438e-02f, -4.38111015e-02f, -5.70595786e-02f, -1.29958736e-02f, -5.65563701e-02f, -1.20000705e-01f,
  -2.36956589e-02f, 2.02222764e-02f, -9.09193903e-02f, 1.62266064e-02f, -7.67527148e-02f, 7.01746196e-02f, -7.52345026e-02f, -6.83798734e-03f, -7.26048052e-02f, -9.43261140e-04f,
  -1.09690689e-02f, 1.03141166e-01f, -3.28715034e-02f, 8.15227181e-02f, -1.03661813e-01f, -4.25786413e-02f, 1.30025774e-01f, 1.02358170e-01f, -5.74217923e-02f, 1.65529296e-01f,
  -9.66820270e-02f, -2.97380947e-02f, 1.50018528e-01f, 7.61519372e-02f, 7.08274469e-02f, 5.12154512e-02f, 7.39768744e-02f, -1.44633517e-01f, 1.17080189e-01f, 9.83113889e-03f,
  4.56898771e-02f, -6.57238215e-02f, -5.14834225e-02f, 6.93569556e-02f, -7.87502006e-02f, -2.41564624e-02f, 5.99651784e-02f, -4.08861460e-03f, 3.42793465e-02f, 6.42910376e-02f,
  1.48085877e-01f, 4.00841124e-02f, 5.17507456e-02f, -4.92369644e-02f, 1.58152748e-02f, 5.93250468e-02f, -1.16651788e-01f, -8.80140215e-02f, 1.09144516e-01f, -9.46494564e-02f,
  1.40560687e-01f, 2.91459784e-02f, 3.93114751e-03f, -4.49913591e-02f, 8.95332620e-02f, -9.07558054e-02f, -6.95689097e-02f, -8.84407386e-02f, 6.76809698e-02f, -2.53236536e-02f,
  9.77661014e-02f, 1.37879461e-01f, -1.16277032e-01f, -5.09076640e-02f, -1.03122041e-01f, 1.60789952e-01f, 1.36134207e-01f, 9.87196937e-02f, 1.80595919e-01f, 1.91529170e-01f,
  3.65470424e-02f, 1.83483824e-01f, 1.16116822e-01f, 2.56698132e-01f, 8.57454240e-02f, 1.65800348e-01f, 9.21639279e-02f, 3.58692199e-01f, 9.60893929e-02f, -2.89949737e-02f,
  -8.55619460e-02f, 2.98723072e-01f, -4.47338253e-01f, 2.05359250e-01f, -1.05440937e-01f, -1.53583214e-01f, 7.08030686e-02f, 3.88916045e-01f, 8.63642469e-02f, 1.21579714e-01f,
  -2.26957455e-01f, 1.78518683e-01f, 7.81759471e-02f, 1.31531984e-01f, -7.25112334e-02f, -1.15649402e-01f, 1.32721558e-01f, 2.68086642e-01f, 7.55418539e-02f, 1.13588005e-01f,
  -1.03009492e-01f, -7.71551952e-02f, 7.91527703e-02f, -2.72524208e-02f, -2.05317698e-02f, -1.17488839e-01f, 6.72304854e-02f, 2.07815155e-01f, 7.95849040e-02f, 9.29698721e-02f,
  6.55708369e-03f, 4.72149134e-01f, -1.47418734e-02f, 1.94889791e-02f, -3.83654609e-02f, -1.21890314e-01f, 3.21192175e-01f, -7.97775164e-02f, 1.52950659e-01f, 1.15531646e-01f,
  1.38475239e-01f, -1.03661492e-01f, 2.30130240e-01f, 8.80798325e-03f, 9.72556472e-02f, -1.86440106e-02f, -1.37457460e-01f, 1.51906207e-01f, 9.38134640e-02f, -8.26971754e-02f,
  1.19089104e-01f, -3.42798345e-02f, -4.37692367e-02f, 8.13017040e-02f, -4.32461984e-02f, 1.07981481e-01f, -2.97911558e-02f, 9.50246491e-03f, 1.06089838e-01f, -6.40144572e-02f,
  1.23576805e-01f, 4.93269712e-02f, 1.42958209e-01f, 1.68548882e-01f, 1.21830404e-01f, -2.14500725e-02f, 4.97445874e-02f, -9.93290842e-02f, 1.44368425e-01f, 2.74521187e-02f,
  2.20099360e-01f, -9.23949480e-02f, -1.98103078e-02f, 2.55930305e-01f, -4.77608480e-02f, -7.22277239e-02f, -3.99329774e-02f, 1.37227073e-01f, -7.10756406e-02f, -3.67632695e-02f,
  2.26116404e-01f, -7.55157992e-02f, 8.36851355e-03f, -8.81657228e-02f, -7.06067961e-03f, 4.65445183e-02f, 1.12458326e-01f, -9.73289981e-02f, 1.63634807e-01f, -1.10558815e-01f,
  1.00219861e-01f, 8.63013938e-02f, 2.52720326e-01f, 8.46879557e-02f, 2.63164729e-01f, 6.69523329e-02f, -1.49140894e-01f, 4.43312414e-02f, -6.10685423e-02f, -5.57275377e-02f,
  -1.97687708e-02f, 1.05112858e-01f, 7.84583837e-02f, 7.18813837e-02f, -4.28164527e-02f, 8.81277248e-02f, -9.47829336e-02f, 8.00793841e-02f, 1.69504061e-01f, -3.48504749e-03f,
  -4.20670845e-02f, 2.13317335e-01f, 2.85892915e-02f, 2.03668490e-01f, -1.81199815e-02f, -5.33987805e-02f, -1.79751832e-02f, 3.83789130e-02f, 3.65194194e-02f, -1.34858666e-02f,
  -1.22792378e-01f, 9.30858403e-02f, 3.82449385e-03f, -1.01697691e-01f, -5.16720600e-02f, -3.35837714e-02f, -1.38062760e-01f, 8.90685394e-02f, -9.73133966e-02f, -2.45899223e-02f,
  5.49385548e-02f, 6.77815899e-02f, -4.14284542e-02f, -1.02909625e-01f, -9.00891200e-02f, -9.77163538e-02f, 5.57673424e-02f, -8.98043066e-02f, 2.95512620e-02f, -3.32590449e-03f,
  9.22041684e-02f, -2.48184893e-02f, 7.37009048e-02f, -3.06496210e-02f, 6.86351359e-02f, -1.24085575e-01f, -3.45064960e-02f, 6.36474937e-02f, 4.84350249e-02f, -4.45840508e-02f,
  -3.08368858e-02f, 3.70791480e-02f, 5.87685071e-02f, 7.00690523e-02f, -8.58185813e-02f, 1.47043355e-02f, 8.17784965e-02f, -2.79224664e-02f, -7.39517584e-02f, -7.84538090e-02f,
  7.25595132e-02f, -9.15014297e-02f, -3.74269061e-04f, 2.10208707e-02f, -2.77125388e-02f, 8.24890435e-02f, -1.23299427e-01f, 5.36669195e-02f, -1.19819656e-01f, -2.62359604e-02f,
  -2.91603338e-02f, -1.00486934e-01f, -1.20565005e-01f, -1.26739010e-01f, -9.87548009e-02f, 1.15896158e-01f, -7.96567053e-02f, 5.54796681e-02f, 4.59943991e-03f, -1.24185659e-01f,
  1.50061667e-01f, 1.27913356e-02f, 1.28475949e-01f, 1.95685327e-01f, 2.49356851e-02f, 1.38715118e-01f, 3.43748070e-02f, 5.92899024e-02f, 1.46911621e-01f, -9.34066623e-02f,
  -5.31867966e-02f, 1.50465012e-01f, 5.27193882e-02f, 7.68056512e-02f, 1.15402609e-01f, 4.46981080e-02f, 1.92329884e-01f, 2.48764642e-02f, -3.08629274e-02f, -2.02107430e-02f,
  -7.49144107e-02f, 1.93514168e-01f, -2.98674367e-02f, 4.36298065e-02f, -9.53871906e-02f, -6.14216737e-02f, -4.69358489e-02f, 1.70682281e-01f, 1.09470978e-01f, -7.43481666e-02f,
  -7.16150412e-03f, -4.72295918e-02f, 1.82164654e-01f, 1.28904477e-01f, 2.84602959e-02f, 1.01336710e-01f, 1.80873618e-01f, 4.64739092e-02f, -1.84999537e-02f, -9.93143544e-02f,
  -3.07392813e-02f, 1.03769802e-01f, -6.01982698e-02f, 4.13477086e-02f, 1.01452796e-02f, 2.53060292e-02f, 1.35586709e-01f, -7.43026882e-02f, -7.04934597e-02f, 8.07791278e-02f,
  -3.09110731e-02f, 3.43808942e-02f, -6.42537624e-02f, -1.42635559e-04f, -9.70490500e-02f, -7.20303655e-02f, 2.20961884e-01f, 4.64160368e-03f, 6.86438978e-02f, 1.64609849e-02f,
  -4.21145335e-02f, -7.74281621e-02f, 7.93230906e-03f, 1.24048784e-01f, 3.92259285e-02f, -4.00058087e-03f, 3.67211290e-02f, -5.35230003e-02f, 8.27607736e-02f, -4.50551957e-02f,
  -6.36153296e-02f, 2.20493190e-02f, 4.89339652e-03f, -5.81460297e-02f, 5.73543180e-03f, -8.96227732e-02f, 1.39237577e-02f, 6.66929781e-02f, 2.24221908e-02f, 2.80078826e-03f,
  1.05130672e-01f, -4.27809395e-02f, 3.44617176e-03f, -1.16392635e-01f, -3.66682303e-03f, 5.31292409e-02f, -1.80349555e-02f, -4.53727059e-02f, -3.53886932e-02f, 1.27091423e-01f,
  1.40727773e-01f, -9.63206440e-02f, -7.55262375e-02f, 2.72482429e-02f, -1.17534801e-01f, 5.76000847e-02f, 7.35512823e-02f, -1.07554302e-01f, -6.68560266e-02f, 9.72921327e-02f,
  -8.34772810e-02f, -7.04199746e-02f, 9.30777416e-02f, 1.07347354e-01f, -3.13851540e-03f, -6.76466450e-02f, -1.55747402e-02f, 1.25382310e-02f, 3.98023315e-02f, 1.74721912e-01f,
  -4.73940447e-02f, 3.51261208e-03f, 9.24481377e-02f, 1.04364701e-01f, -6.62728325e-02f, -9.78771225e-02f, 1.25183120e-01f, -3.93317379e-02f, 1.80191454e-02f, 1.16070889e-01f,
  1.16651561e-02f, 6.95718005e-02f, 1.17537215e-01f, -4.76643667e-02f, 1.05653852e-01f, -3.46352831e-02f, -1.10773489e-01f, -1.18391275e-01f, 1.53270096e-01f, 5.87083474e-02f,
  1.50681846e-02f, 1.34478986e-01f, 1.48837566e-01f, 2.70190579e-03f, 2.17578635e-01f, 1.94535792e-01f, 3.59749906e-02f, -1.86507516e-02f, 2.22250372e-01f, 1.53153926e-01f,
  1.87478051e-01f, -2.34391302e-01f, 2.03381896e-01f, -3.32281083e-01f, 1.51856720e-01f, -3.45900543e-02f, -1.14484476e-02f, 9.82308462e-02f, -9.21393111e-02f, 3.15426402e-02f,
  2.64532324e-02f, 9.73741189e-02f, -7.15166554e-02f, 1.69620633e-01f, 3.78011703e-03f, 2.05052450e-01f, -4.71949577e-02f, -1.82811409e-01f, 1.35404974e-01f, 1.50191411e-01f,
  1.81055255e-02f, 3.84315802e-03f, -3.92931737e-02f, -9.11455676e-02f, 1.34381235e-01f, 1.46987304e-01f, -1.27767369e-01f, -1.94585994e-01f, 1.53667346e-01f, 1.03373483e-01f,
  -5.69517352e-02f, -1.33582160e-01f, 6.75422177e-02f, 1.85414515e-02f, 6.41968548e-02f, 2.45099738e-02f, 2.42507711e-01f, -1.47959292e-01f, 6.24847822e-02f, -1.62109379e-02f,
  4.75289188e-02f, 4.66354340e-02f, -6.99518062e-03f, 9.36905369e-02f, 8.15968588e-02f, 1.29914582e-01f, 1.02583461e-01f, -4.09038700e-02f, -1.66819450e-02f, -1.06098756e-01f,
  9.33138207e-02f, 1.40747800e-01f, 9.98332351e-02f, 2.66660720e-01f, 6.48196638e-02f, 1.02042347e-01f, -8.66069794e-02f, 2.13324904e-01f, 1.99775975e-02f, -5.68189472e-02f,
  8.20214022e-03f, 1.85377702e-01f, 1.17123291e-01f, 2.47810811e-01f, 2.55247474e-01f, 8.94140005e-02f, -1.48530275e-01f, 1.53575554e-01f, 1.69758320e-01f, -5.45929261e-02f,
  1.80059895e-01f, 6.74408451e-02f, 3.86222526e-02f, 1.96304768e-01f, -1.49098694e-01f, -1.68937281e-01f, 3.69905643e-02f, 1.28511608e-01f, 1.06194057e-01f, -1.30867615e-01f,
  6.96601272e-02f, 2.00867411e-02f, 6.25326410e-02f, 9.49169137e-03f, 3.12760651e-01f, 1.40116870e-01f, 1.13445804e-01f, -2.97156926e-02f, 1.70445517e-01f, -2.12126914e-02f,
  1.25332817e-01f, -1.41296729e-01f, 1.47036478e-01f, 7.43209422e-02f, -7.86551610e-02f, -5.60165644e-02f, 2.12652907e-02f, 3.78279574e-02f, 1.29527137e-01f, 5.19648492e-02f,
  3.39298323e-03f, -3.58683132e-02f, 1.61324337e-01f, -1.84031576e-02f, -2.95042824e-02f, 1.17601000e-01f, 1.46109322e-02f, -9.47222784e-02f, 3.81501973e-01f, 2.85203606e-01f,
  2.58544218e-02f, 1.47396401e-01f, -7.16955308e-03f, 2.55119532e-01f, 3.49635571e-01f, 2.03751683e-01f, 4.89158407e-02f, -8.55972841e-02f, 9.71801803e-02f, 1.28051236e-01f,
  -1.11993060e-01f, -2.04515737e-02f, 1.54752597e-01f, -5.50817791e-03f, 1.48731349e-02f, -1.59438215e-02f, -9.39314626e-03f, -7.99822584e-02f, -9.30769369e-02f, 2.92677060e-02f,
  3.46959047e-02f, 3.67046632e-02f, 1.05528636e-02f, -9.77354497e-02f, -2.50912663e-02f, 1.15195245e-01f, -8.59223977e-02f, 1.00916192e-01f, -1.17674641e-01f, -1.71236843e-02f,
  2.09529269e-02f, 7.89409429e-02f, -5.69036789e-02f, 1.70221692e-03f, -1.02592014e-01f, 1.09775208e-01f, 9.48877856e-02f, -2.89324149e-02f, -9.25146451e-04f, -1.86270643e-02f,
  -1.07866535e-02f, -9.06618685e-02f, 2.39129569e-02f, -5.29596508e-02f, 4.65204045e-02f, -3.99048105e-02f, 4.97554652e-02f, -1.62366796e-02f, -1.01590581e-01f, 1.63754046e-01f,
  -4.96054627e-02f, 5.79554588e-03f, 5.77452853e-02f, 1.35158494e-01f, 1.71087295e-01f, -7.94779882e-02f, -5.79781905e-02f, -4.90776226e-02f, 1.27048999e-01f, -8.69750679e-02f,
  -6.86657727e-02f, 1.29641250e-01f, -8.57693106e-02f, -3.98715585e-02f, -1.81380380e-02f, -5.75238615e-02f, 4.15686658e-03f, -6.01575971e-02f, 8.25490803e-02f, -6.44085556e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  -7.73851275e-02f, 3.53887416e-02f, 3.29823345e-02f, -2.45395713e-02f, 6.54113889e-02f, 8.09479356e-02f, 2.64768243e-01f, -4.29706983e-02f, 2.80610353e-01f, 1.36792198e-01f,
  1.05285011e-01f, 1.27788521e-02f, -6.68022558e-02f, 2.11121445e-03f, 1.53031826e-01f, -5.87126538e-02f, -1.23225888e-02f, 1.31193489e-01f, -7.56155103e-02f, -9.00792852e-02f,
  1.68094501e-01f, 6.62560090e-02f, 5.25014624e-02f, -8.26836377e-03f, 2.05432661e-02f, 4.74730767e-02f, -5.98330982e-02f, 1.40226230e-01f, -1.01693474e-01f, 9.19537097e-02f,
  -2.27573514e-02f, 1.08867418e-02f, 1.60721004e-01f, 7.94899315e-02f, -8.30432400e-03f, -5.58066219e-02f, -1.01859763e-01f, 1.39820293e-01f, 1.48924097e-01f, -5.91419116e-02f
};

// L2_fan_Wp (Shape: 12 x 64)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -3.38069834e-02f, -2.41637845e-02f, -6.90621138e-02f, 9.07185227e-02f, 6.47566393e-02f, -9.28301215e-02f, -1.45044222e-01f, 1.41040295e-01f, 7.66041083e-03f, 2.15737328e-01f,
  1.33310139e-01f, 1.63689367e-02f, -2.83923652e-03f, -1.94999084e-01f, -1.36636540e-01f, 9.38488394e-02f, -9.82605740e-02f, -8.62511620e-02f, 3.37289460e-02f, 9.55329910e-02f,
  2.20890775e-01f, -2.90249847e-03f, 1.60374671e-01f, -3.71595174e-02f, -1.52872773e-02f, -1.99138314e-01f, 9.81570035e-02f, 4.05652747e-02f, -1.02417067e-01f, -1.16540380e-01f,
  5.16122840e-02f, 7.73575455e-02f, 1.58165812e-01f, 1.14701651e-02f, 9.45041925e-02f, -9.88183990e-02f, 4.11078008e-03f, 4.60822880e-02f, -1.42678112e-01f, 1.20799154e-01f,
  2.19095908e-02f, 1.46391958e-01f, -1.89543739e-01f, -4.28787656e-02f, 8.11824203e-02f, 2.24376824e-02f, -1.50212735e-01f, 1.90983675e-02f, 2.53359322e-03f, 1.26307845e-01f,
  -8.42488259e-02f, -3.76651697e-02f, -3.41490097e-02f, 8.07028860e-02f, -9.45915207e-02f, 3.65485847e-02f, -1.62226528e-01f, -7.40549937e-02f, 1.62469864e-01f, -1.37216628e-01f,
  -6.54863715e-02f, -1.99362151e-02f, -2.49904335e-01f, 9.42005292e-02f, 6.39062971e-02f, 1.44692063e-01f, -4.43310961e-02f, -1.58325713e-02f, 9.94306654e-02f, 8.07523355e-02f,
  5.49122281e-02f, 2.98042018e-02f, 9.49352011e-02f, 1.56482905e-01f, -1.03318803e-01f, 7.79921412e-02f, -7.61240870e-02f, 2.23445278e-02f, -1.86048329e-01f, -1.31817220e-03f,
  -1.19981289e-01f, 1.68440565e-01f, -1.45098865e-01f, 5.43753244e-02f, 2.97936112e-01f, 3.77919599e-02f, 1.06498875e-01f, 7.30593950e-02f, -3.63002494e-02f, 5.28389029e-02f,
  -8.51579197e-03f, -9.81627628e-02f, -1.44190311e-01f, -4.38955799e-02f, -1.16424352e-01f, 1.97559476e-01f, 2.73547173e-01f, 1.37912989e-01f, 2.02298560e-03f, -3.58688757e-02f,
  6.11449480e-02f, 1.97391980e-03f, -1.51520774e-01f, 1.97753087e-02f, -2.00049803e-01f, -6.27324209e-02f, -7.07349181e-02f, -5.12948520e-02f, 5.46091758e-02f, 2.05024824e-01f,
  -1.40447468e-01f, -9.41563621e-02f, 6.99877292e-02f, -1.07120968e-01f, -7.04088211e-02f, 4.58554067e-02f, -1.16850749e-01f, 1.10028749e-02f, -7.00211823e-02f, -3.84101123e-02f,
  -2.63132174e-02f, 6.14993200e-02f, -9.17412490e-02f, -4.37497869e-02f, 3.00808456e-02f, -1.70911610e-01f, -2.46928617e-01f, 3.99392918e-02f, -6.59320951e-02f, 8.45545977e-02f,
  1.62481263e-01f, -8.85010734e-02f, 1.35978386e-01f, -4.10931706e-02f, 1.73587784e-01f, 6.26489297e-02f, 1.62865028e-01f, -6.15691468e-02f, -5.46774566e-02f, -1.03421278e-01f,
  -2.64904890e-02f, -8.31071585e-02f, -1.04375165e-02f, -5.23002520e-02f, 6.78312220e-03f, 2.65933517e-02f, 1.75616115e-01f, -1.07662305e-01f, -7.19703212e-02f, -2.17964258e-02f,
  -1.22784130e-01f, 1.35127634e-01f, 1.01732872e-01f, 1.10106416e-01f, -5.35918400e-02f, 6.50382340e-02f, 2.80560590e-02f, 1.80089995e-01f, 1.67784691e-01f, -6.73995465e-02f,
  -6.32183775e-02f, -3.75956818e-02f, 1.42730949e-02f, 9.71642211e-02f, 4.93319109e-02f, -2.74820745e-01f, 1.24638490e-02f, -8.31543729e-02f, -1.01321779e-01f, -1.43535644e-01f,
  2.07021553e-02f, 1.43465893e-02f, -8.98127630e-02f, -1.46453604e-01f, -2.51953341e-02f, 4.66876663e-02f, -1.95848588e-02f, 6.41190484e-02f, 6.30488694e-02f, -5.40884249e-02f,
  4.62759547e-02f, -1.01199329e-01f, -7.96543621e-03f, 3.29235904e-02f, 1.40774161e-01f, -1.02344424e-01f, 8.92612338e-02f, 3.36109810e-02f, -7.96683133e-02f, 1.01420179e-01f,
  -9.59218293e-03f, 4.98325415e-02f, 1.10962316e-01f, 6.24164790e-02f, 4.53837775e-02f, 6.15672097e-02f, 1.30487531e-01f, 1.21803053e-01f, 1.76695541e-01f, 1.68101750e-02f,
  8.85747373e-02f, 5.46731539e-02f, -1.56415738e-02f, -3.15224603e-02f, -8.26388672e-02f, 1.44155160e-01f, -8.42959061e-02f, -7.83065483e-02f, 1.25772178e-01f, 8.87887776e-02f,
  -1.18176587e-01f, 7.71059543e-02f, -1.22081228e-01f, -6.13060892e-02f, -2.60908097e-01f, -5.08113857e-03f, 2.92025004e-02f, 1.49456322e-01f, -1.22823678e-01f, 3.36102694e-02f,
  1.52795529e-02f, 1.36705130e-01f, -6.84497207e-02f, -6.27648309e-02f, 2.32479721e-01f, -1.04915500e-01f, -1.13090470e-01f, 1.06155425e-01f, -1.18201822e-01f, -9.04953703e-02f,
  5.37821203e-02f, 7.03019798e-02f, -4.37776223e-02f, 1.29328951e-01f, 5.76686710e-02f, -3.52029204e-02f, -1.04751237e-01f, 1.14768788e-01f, 2.12923102e-02f, 4.01391611e-02f,
  6.23821951e-02f, -1.69648081e-02f, 1.10023431e-01f, -4.69089933e-02f, 6.33493140e-02f, -1.49033263e-01f, 2.08438225e-02f, -7.47111440e-02f, 9.86457765e-02f, -1.45570621e-01f,
  -1.12475350e-01f, 7.44039640e-02f, -1.40256107e-01f, 1.15467988e-01f, -4.85600233e-02f, -1.76921524e-02f, -8.08989853e-02f, 1.47418991e-01f, 2.50204802e-02f, 1.52279049e-01f,
  2.91517600e-02f, 1.19740844e-01f, 1.10684313e-01f, 7.41182193e-02f, -5.39010316e-02f, 1.14579171e-01f, -5.67098558e-02f, 1.39945731e-01f, -1.34087145e-01f, 1.57689989e-01f,
  -2.77916044e-01f, -1.16081052e-01f, -1.06559366e-01f, 6.50447458e-02f, -1.67510301e-01f, 1.29143167e-02f, 3.62034515e-02f, 1.01792524e-02f, -2.44244456e-01f, 1.32867619e-02f,
  -7.84669910e-03f, 1.75678566e-01f, 1.08082602e-02f, -6.86384663e-02f, 1.34769008e-01f, 2.72512175e-02f, -8.35735500e-02f, 3.00468449e-02f, 5.25224283e-02f, -5.50992638e-02f,
  -1.02237754e-01f, 1.17136603e-02f, 8.92584547e-02f, -2.73570329e-01f, 3.27239521e-02f, -5.22989929e-02f, -3.86320017e-02f, 2.02134941e-02f, -1.08267769e-01f, -7.30076134e-02f,
  -1.17862619e-01f, -2.11402141e-02f, -3.54821309e-02f, -4.84313853e-02f, 1.21964909e-01f, -2.67163292e-02f, 2.63724197e-02f, -9.95136499e-02f, 2.37330813e-02f, -2.01975048e-01f,
  -7.64248818e-02f, 1.35309950e-01f, 3.14190894e-01f, -2.15300381e-01f, 1.09498933e-01f, -2.58120466e-02f, 3.22203077e-02f, -1.29942447e-01f, 4.65715043e-02f, -1.06749386e-01f,
  6.53817281e-02f, 7.56297186e-02f, 1.63738653e-01f, 1.28011212e-01f, 1.75498679e-01f, 5.13456687e-02f, 1.60881862e-01f, -3.04485690e-02f, 2.31806725e-01f, 8.84536877e-02f,
  -1.54017713e-02f, 3.47112701e-03f, -1.26440316e-01f, 1.15300797e-01f, -1.20210044e-01f, -3.56972106e-02f, 1.39124244e-01f, 5.87919727e-02f, -2.05321878e-01f, 8.68736394e-03f,
  2.05356732e-01f, 1.36492476e-01f, -2.47221977e-01f, 1.28508866e-01f, -1.02134384e-01f, 9.73856673e-02f, 6.87491894e-02f, -1.12998731e-01f, -1.16347000e-01f, 1.01717241e-01f,
  -2.26054758e-01f, 1.35704130e-01f, 2.04175428e-01f, -1.99562311e-02f, 1.46403268e-01f, 9.77400318e-02f, 1.97708467e-03f, -1.61576077e-01f, 1.41744569e-01f, 6.73903525e-02f,
  7.33889490e-02f, -1.46096479e-03f, 1.24263097e-04f, 1.57762095e-01f, -7.44611025e-02f, 2.88181692e-01f, -1.41098604e-01f, 4.43042740e-02f, -4.82211299e-02f, 1.86826941e-02f,
  -4.05749418e-02f, 1.09989651e-01f, 1.00381076e-01f, -1.64846584e-01f, -1.02269482e-02f, -5.78803904e-02f, 2.30540797e-01f, -3.20179276e-02f, -9.11775753e-02f, -1.53083066e-02f,
  1.16294265e-01f, -6.78258985e-02f, -2.94382274e-01f, 5.37180416e-02f, -4.87383716e-02f, -1.22283362e-01f, 2.27998942e-02f, 9.64348838e-02f, 1.86364111e-02f, 7.56463385e-04f,
  -1.17238641e-01f, -1.32994771e-01f, -1.42275542e-01f, 2.31219362e-02f, -1.60793513e-01f, -4.89978530e-02f, 8.41111839e-02f, -4.66551557e-02f, 1.16284549e-01f, 9.41667706e-03f,
  -3.70938294e-02f, -2.75427755e-02f, 2.43410647e-01f, -1.39573619e-01f, -6.43096343e-02f, 1.18562356e-01f, 1.50147736e-01f, -9.31690261e-02f, 8.02712739e-02f, -1.60206720e-01f,
  -1.25476837e-01f, 7.04050139e-02f, 1.75312590e-02f, 8.32509845e-02f, 1.36032254e-01f, -1.78815410e-01f, -3.21635962e-01f, -2.73275468e-02f, 1.12539470e-01f, -6.55174069e-03f,
  -8.58694464e-02f, 1.06196836e-01f, -5.23364022e-02f, 1.65776722e-02f, 1.20428614e-01f, 5.10763042e-02f, -1.80827036e-01f, 1.05202191e-01f, 3.23524177e-02f, -8.20191726e-02f,
  5.72934523e-02f, 1.27151888e-02f, -1.14069218e-02f, 1.40162542e-01f, 9.11611095e-02f, -8.52968618e-02f, 1.18274502e-01f, 1.12427145e-01f, 8.33033770e-02f, 8.35586637e-02f,
  -1.38488904e-01f, -7.15389475e-02f, 3.74079198e-02f, 1.15620978e-02f, 9.97123793e-02f, 1.97346769e-02f, 1.90107733e-01f, -1.12158477e-01f, 1.99453887e-02f, -7.16623589e-02f,
  7.15199634e-02f, -9.59626734e-02f, 1.03641286e-01f, 1.30359560e-01f, -7.81581104e-02f, 7.45963082e-02f, -4.73789684e-03f, -6.15951344e-02f, -3.63165587e-02f, 6.14512973e-02f,
  1.51956514e-01f, -1.42131165e-01f, 6.10976517e-02f, 1.09183313e-02f, -9.18707177e-02f, -3.49232182e-02f, 1.95185959e-01f, -2.26982579e-01f, -2.37404987e-01f, -2.58035541e-01f,
  -7.90712237e-02f, -3.76723334e-02f, 6.15758374e-02f, 1.62485704e-01f, 8.07978660e-02f, 1.06659241e-01f, -3.23779657e-02f, 2.12505996e-01f, 2.49944091e-01f, 3.63131566e-03f,
  -3.37164491e-01f, -1.41429022e-01f, 4.45286483e-02f, -5.80806471e-02f, -1.13032289e-01f, -2.70217266e-02f, 5.98333627e-02f, 1.80649366e-02f, -1.32356957e-01f, -1.21351860e-01f,
  2.93738663e-01f, 2.58961623e-03f, -4.15546522e-02f, -2.05263585e-01f, -1.42179457e-02f, 2.60745622e-02f, -1.10727057e-01f, -1.37943849e-01f, -2.96185818e-03f, -7.25973165e-03f,
  8.18651244e-02f, -9.50654745e-02f, -1.03531688e-01f, 9.34650302e-02f, 9.78210121e-02f, 9.92840752e-02f, 9.11760107e-02f, 2.00368717e-01f, -9.74144638e-02f, -1.41448289e-01f,
  1.88596174e-01f, 1.56562589e-02f, -1.29724488e-01f, -1.97555527e-01f, -9.53889936e-02f, 9.88468900e-03f, -9.69598368e-02f, 2.87026521e-02f, 3.07575613e-02f, -2.42294986e-02f,
  -2.46162668e-01f, -1.67256162e-01f, -1.50506124e-01f, 6.47828169e-03f, 4.78283800e-02f, 1.21333241e-01f, -5.01323156e-02f, 7.50919851e-03f, -5.39869219e-02f, -1.08177094e-02f,
  6.72246292e-02f, -1.58120260e-01f, -6.15859888e-02f, -2.49322988e-02f, -4.96746637e-02f, 7.49567524e-02f, -3.23280096e-02f, 5.98663203e-02f, -4.48399559e-02f, 2.02546213e-02f,
  2.43765619e-02f, -3.98371965e-02f, 1.15814127e-01f, -2.21272275e-01f, -1.69088647e-01f, -1.59906596e-01f, -5.30418903e-02f, 1.04941525e-01f, 2.28777360e-02f, -4.18983437e-02f,
  1.34401798e-01f, 1.24359377e-01f, -2.09132712e-02f, -1.52300805e-01f, 1.14736922e-01f, -1.18796892e-01f, 6.57757968e-02f, 6.35313690e-02f, 1.77187249e-01f, 8.16390365e-02f,
  -1.79165564e-02f, 5.81511557e-02f, -4.04995456e-02f, -1.34733945e-01f, 1.32636309e-01f, -3.76824550e-02f, 3.75654288e-02f, -5.53552210e-02f, 2.27738954e-02f, -1.54463453e-02f,
  -5.94897866e-02f, 1.44648999e-01f, -8.05344135e-02f, -6.75351024e-02f, 1.24990135e-01f, -2.58840229e-02f, -1.16823718e-01f, -5.48900850e-02f, 1.87393874e-02f, -3.88365202e-02f,
  -1.98495518e-02f, 1.64846450e-01f, 5.64432098e-03f, -6.11208193e-02f, -1.03739746e-01f, -1.46450505e-01f, -3.78981978e-02f, -7.02770194e-03f, -3.46155614e-02f, 3.41034192e-03f,
  2.81628817e-02f, 2.15631947e-01f, -4.22748439e-02f, -1.33315310e-01f, -7.45255128e-02f, -1.86138287e-01f, -2.84873128e-01f, -1.66471779e-01f, 1.03899114e-01f, 1.32184282e-01f,
  1.39295831e-01f, -8.57902169e-02f, 7.70091563e-02f, 1.51539803e-01f, -4.13521938e-02f, 9.74782743e-03f, 1.43761903e-01f, 5.43220676e-02f, -1.96694031e-01f, -7.12829009e-02f,
  -1.17095143e-01f, 1.23221815e-01f, -7.94835538e-02f, -2.03209862e-01f, 4.81908256e-03f, -1.13000453e-01f, 1.41696692e-01f, -1.06965780e-01f, -1.07869931e-01f, 8.03301409e-02f,
  -1.12881409e-02f, -3.92652862e-02f, 7.73765519e-02f, 1.41754717e-01f, 5.57914674e-02f, 1.22283876e-03f, 8.26314688e-02f, -7.75291100e-02f, 8.47873539e-02f, -6.11632839e-02f,
  6.02515452e-02f, -7.80656785e-02f, 1.77565604e-01f, 5.76320775e-02f, 1.14773646e-01f, 1.08083278e-01f, -1.08544320e-01f, -5.76042160e-02f, 7.91875795e-02f, -7.00618699e-02f,
  -8.37487355e-02f, -2.88349148e-02f, 1.41601386e-02f, 7.58176297e-02f, -6.62254682e-03f, -1.29403040e-01f, 1.08186670e-01f, -7.03184456e-02f, 6.74643144e-02f, 1.60092324e-01f,
  1.64650858e-03f, 2.64139529e-02f, -6.75790980e-02f, 1.13387227e-01f, 5.42231761e-02f, -1.47388354e-01f, 1.45129208e-03f, 6.96792454e-02f, -5.95001765e-02f, 7.90406764e-02f,
  2.19649062e-01f, -1.54959001e-02f, -1.37585774e-01f, 3.46356295e-02f, 4.52507753e-03f, 8.76779035e-02f, 1.91712871e-01f, -1.05603859e-01f, -1.15390979e-01f, -8.36114213e-02f,
  -1.64405093e-01f, 2.39979066e-02f, 2.16969073e-01f, 4.71737236e-02f, 1.33677974e-01f, 4.95758280e-02f, 2.36155335e-02f, 4.98523638e-02f, -1.07545711e-01f, -1.02973782e-01f,
  -3.87313701e-02f, -2.03402825e-02f, 1.67091623e-01f, 7.80637562e-02f, 3.87629345e-02f, 3.57582383e-02f, -1.00422435e-01f, 3.20927799e-02f, -4.04686667e-02f, -1.04586117e-01f,
  8.65513738e-03f, 1.09620564e-01f, -1.31918982e-01f, 3.01157590e-02f, -2.06692647e-02f, -1.16441257e-01f, -8.54929312e-05f, -7.63435960e-02f, 6.96458369e-02f, -1.32412121e-01f,
  -4.74767871e-02f, -1.21083759e-01f, -1.54624298e-01f, 7.90169928e-03f, -2.95259021e-02f, -1.85026318e-01f, 4.28631008e-02f, -5.87051511e-02f, 8.64026994e-02f, -9.96394455e-03f,
  -3.77595797e-02f, 4.99046966e-02f, -1.33967936e-01f, -2.06482768e-01f, -2.71551870e-02f, -1.36682525e-01f, -6.64048120e-02f, -9.85920802e-02f, -7.01703085e-03f, -1.33579420e-02f,
  -1.38604552e-01f, 9.80714113e-02f, 4.55416739e-02f, -1.35324866e-01f, -2.09547982e-01f, -7.40612969e-02f, -1.49424464e-01f, -2.00832665e-01f, 1.05343252e-01f, 1.57902054e-02f,
  1.74965844e-01f, 4.46805730e-02f, -2.06281230e-01f, -7.62514696e-02f, 6.84280507e-03f, 1.12387575e-01f, -3.37183475e-01f, 1.97108075e-01f, 1.09253816e-01f, 3.17030996e-02f,
  -3.27827185e-02f, 3.12476635e-01f, 6.85671866e-02f, -6.73565939e-02f, -7.16384128e-02f, 4.20324020e-02f, -5.13029937e-03f, 2.67821494e-02f, -5.67300105e-03f, -1.97894126e-01f,
  -5.93140200e-02f, 2.00323477e-01f, 1.51155014e-02f, 1.40256472e-02f, 1.49607405e-01f, 5.42034768e-02f, 3.46516967e-02f, -3.29877138e-02f, 1.31687149e-02f, -7.91189224e-02f,
  1.91951990e-01f, 2.50989556e-01f, 4.73973341e-02f, -8.50750059e-02f, 1.07649758e-01f, -1.21989533e-01f, 7.03055933e-02f, 4.54413928e-02f
};

// L2_fan_Wp_bar (Shape: 40 x 64)
const int L2_fan_Wp_bar_rows = 40;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  2.08149515e-02f, -1.02455914e-03f, 5.26637919e-02f, 1.07778370e-01f, -2.06642542e-02f, 9.72729176e-02f, -2.58314461e-02f, 6.67792559e-02f, -1.00539990e-01f, -4.70911488e-02f,
  1.51726589e-01f, 5.83755933e-02f, 1.52683809e-01f, -1.07810043e-01f, 1.15250796e-01f, 1.12157628e-01f, 2.30780259e-01f, -1.76241785e-01f, 1.73157528e-02f, 2.65599191e-02f,
  -1.74399152e-01f, -5.26655354e-02f, 6.39686808e-02f, -2.67569013e-02f, -8.64250287e-02f, 3.32103819e-02f, 4.29645218e-02f, -1.56940203e-02f, 1.89941272e-01f, 1.57840043e-01f,
  5.91749605e-03f, -4.54175211e-02f, 1.56810388e-01f, -6.78834617e-02f, 1.78707242e-01f, 7.11087659e-02f, -4.00061645e-02f, 1.00454919e-01f, 1.72224008e-02f, -4.53409972e-03f,
  2.99275247e-03f, -3.06839794e-02f, 4.13382389e-02f, 4.27825525e-02f, -8.70953500e-02f, 2.20226288e-01f, -6.28600344e-02f, 1.83064560e-03f, -1.01886228e-01f, 7.58347809e-02f,
  1.83129944e-02f, -1.44229203e-01f, 4.24398147e-02f, 6.62053153e-02f, -2.71973312e-02f, -5.29318228e-02f, -4.22573984e-02f, 1.44296721e-01f, 3.63648236e-02f, 4.60378639e-02f,
  1.12348609e-01f, 9.56829488e-02f, 7.41971135e-02f, 1.57987146e-04f, -1.34265842e-02f, 2.12840736e-01f, -2.55123898e-02f, 1.12854019e-01f, 1.30309284e-01f, 8.06522742e-02f,
  2.77420968e-01f, -1.00751277e-02f, 1.59943998e-01f, 1.92461923e-01f, 9.32955518e-02f, 2.07671653e-02f, -2.34061643e-01f, 6.01088256e-02f, -1.34840488e-01f, -5.53941764e-02f,
  -2.47449741e-01f, 2.13297650e-01f, -2.33172715e-01f, -1.87060639e-01f, 2.83587813e-01f, 5.53127266e-02f, -1.68991819e-01f, 6.43894300e-02f, 8.69100094e-02f, 1.26560673e-01f,
  2.72717744e-01f, 5.78964688e-02f, -3.58393453e-02f, 2.34175771e-01f, 1.54107332e-01f, 7.01976493e-02f, 8.91689584e-02f, 1.59311727e-01f, 4.09594811e-02f, -1.06728174e-01f,
  -2.63220146e-02f, -9.25962254e-02f, 2.08267599e-01f, -6.86635599e-02f, -7.50755072e-02f, -1.58340842e-01f, -1.19860405e-02f, -1.16355002e-01f, 5.77560998e-02f, -8.40915069e-02f,
  -1.04734324e-01f, 5.46393991e-02f, -3.23338509e-02f, 2.41831783e-02f, 1.02281675e-01f, 2.93199290e-02f, -2.37014201e-02f, -3.52809019e-02f, 9.03595015e-02f, 7.75536075e-02f,
  3.76398504e-01f, 3.52275372e-02f, 1.21383101e-01f, 5.64098023e-02f, -7.13797361e-02f, -2.40376428e-01f, 1.83847710e-01f, -2.04275530e-02f, -5.44580957e-03f, -6.75756782e-02f,
  6.07190616e-02f, -3.98354456e-02f, 6.32760897e-02f, 1.32575333e-01f, 6.12292998e-02f, -9.57773179e-02f, -2.10634079e-02f, -1.39132932e-01f, 3.51001024e-02f, 1.09811723e-01f,
  -1.81622934e-02f, -5.54286875e-02f, -2.21124310e-02f, 4.19866443e-02f, 6.04035147e-03f, 8.25477615e-02f, 3.84004712e-02f, -1.08310521e-01f, -7.24588335e-02f, -3.37972753e-02f,
  1.97695896e-01f, 3.18231992e-02f, -2.97627375e-02f, 4.20701616e-02f, -7.41962045e-02f, -3.40169594e-02f, -1.03836916e-01f, 5.87585084e-02f, 2.59227380e-02f, 7.37721026e-02f,
  -1.30331010e-01f, 1.08862020e-01f, -7.17042461e-02f, 1.42816082e-01f, -2.17791949e-03f, 2.07998067e-01f, -6.85462207e-02f, 8.17350820e-02f, 1.70348272e-01f, 1.25870286e-02f,
  -8.57541263e-02f, -4.84916493e-02f, 7.56200925e-02f, -1.05174601e-01f, 2.64882129e-02f, 9.65808928e-02f, 1.11318171e-01f, -5.43424934e-02f, -7.81563744e-02f, 1.72627643e-01f,
  -8.10681954e-02f, 2.12457731e-01f, -7.12533891e-02f, -5.64285628e-02f, -5.98170832e-02f, 1.59453735e-01f, -8.38671178e-02f, 1.24339171e-01f, 1.19115971e-01f, 5.04503176e-02f,
  2.51221120e-01f, 7.51871616e-02f, 2.80523878e-02f, -7.87167028e-02f, -5.43065295e-02f, -8.07902813e-02f, -8.80415142e-02f, 6.88100234e-02f, -2.48249242e-04f, -1.50930673e-01f,
  -1.16966814e-01f, -1.74847245e-01f, 3.27583849e-02f, 6.49690330e-02f, 5.12674488e-02f, 6.41048327e-02f, 4.52680662e-02f, 4.14974913e-02f, -2.89000547e-03f, -1.30485147e-01f,
  -8.28464031e-02f, -1.49514750e-01f, -1.15072489e-01f, -1.41631156e-01f, 7.99536780e-02f, 6.45171255e-02f, -1.26470365e-02f, 1.23437949e-01f, -4.23418991e-02f, 2.23556291e-02f,
  -1.56855676e-02f, 8.51635486e-02f, 5.34340665e-02f, 5.09622246e-02f, 2.98406072e-02f, -3.72741483e-02f, 3.30527965e-03f, -3.38604450e-02f, 2.33127866e-02f, -1.77798912e-01f,
  8.62922221e-02f, 9.07056332e-02f, 1.08101614e-01f, -8.46245661e-02f, -2.20311191e-02f, 5.04004769e-02f, -9.80526581e-02f, 1.36904735e-02f, 1.11277901e-01f, -5.04997224e-02f,
  -4.96214721e-04f, 2.09542625e-02f, 5.27595580e-02f, 1.25490963e-01f, 1.10791735e-01f, -5.33886515e-02f, 3.16956490e-02f, 6.87884241e-02f, 3.22990157e-02f, -1.25768483e-01f,
  -3.39959152e-02f, 2.51780786e-02f, 1.20093882e-01f, 1.07346661e-01f, 1.37630999e-01f, 2.72600818e-02f, -7.03013912e-02f, 1.98846962e-03f, 1.07345693e-01f, -1.43682957e-01f,
  2.60614809e-02f, 9.34626684e-02f, 1.03211112e-01f, -8.63583982e-02f, 1.65909305e-01f, -2.53479838e-01f, -8.85153040e-02f, -1.47233522e-02f, -1.54641747e-01f, 1.28974080e-01f,
  -4.73561212e-02f, -1.67810228e-02f, -8.42496380e-02f, -8.23830515e-02f, -8.91431794e-02f, -2.52867281e-01f, -1.33833219e-03f, -1.90127447e-01f, -1.19069077e-01f, -7.71678612e-02f,
  -7.91133493e-02f, 1.66516483e-01f, 2.45689496e-01f, -1.24335326e-02f, -2.65973777e-01f, 1.97385594e-01f, 3.83739024e-02f, 1.40987396e-01f, -3.64048108e-02f, -3.63612883e-02f,
  -1.50034372e-02f, -7.37173110e-02f, -6.70739189e-02f, 2.96072685e-04f, -7.27475956e-02f, -4.07288708e-02f, 1.16807416e-01f, -2.16558367e-01f, 1.80773139e-01f, 5.72881401e-02f,
  1.69340238e-01f, -2.07107618e-01f, -4.75607291e-02f, 6.77633658e-02f, 4.17118594e-02f, -1.48172274e-01f, 8.57849568e-02f, 1.87178761e-01f, 1.10906146e-01f, 4.09589931e-02f,
  4.82716858e-02f, -5.84553406e-02f, 2.92969853e-01f, -4.63278443e-02f, 3.08781527e-02f, -1.37486860e-01f, -1.97261497e-02f, -1.89818725e-01f, 2.23548904e-01f, -3.63066271e-02f,
  8.45754594e-02f, -1.89738926e-02f, 8.94394331e-03f, 9.29418430e-02f, 1.20717749e-01f, -1.23641780e-02f, -1.16245024e-01f, 9.81969684e-02f, -1.38847470e-01f, -5.36073484e-02f,
  -3.19581777e-02f, 5.46162715e-03f, 5.44572175e-02f, -6.87386468e-02f, -3.31956008e-03f, 6.64568171e-02f, 1.40891830e-02f, -8.54758695e-02f, -6.11137114e-02f, -3.26782116e-04f,
  -1.98231250e-01f, -6.55369014e-02f, 1.00369960e-01f, 1.06611446e-01f, 9.14942101e-02f, -1.17079161e-01f, -9.36079323e-02f, 7.81228170e-02f, 1.41608447e-01f, -2.73933988e-02f,
  1.95557237e-01f, -7.13347495e-02f, 2.02125814e-02f, 4.58498113e-02f, -1.04664780e-01f, 1.37195379e-01f, -9.93254259e-02f, 9.46225300e-02f, -7.30712041e-02f, 3.82498018e-02f,
  1.17802903e-01f, -1.33456647e-01f, 5.04872613e-02f, -8.55485816e-03f, -8.78140256e-02f, -1.30071804e-01f, 1.66777432e-01f, 2.14728206e-01f, -3.62215936e-02f, -8.55929554e-02f,
  -9.47905779e-02f, -2.43152473e-02f, 6.01278134e-02f, 1.06013827e-01f, 5.21023422e-02f, 1.34750247e-01f, 1.24913320e-01f, 1.61366016e-01f, 7.61000663e-02f, -8.35071877e-02f,
  9.44464132e-02f, 1.70986503e-01f, 3.00935477e-01f, -7.81379566e-02f, 4.18379381e-02f, 5.73490076e-02f, 7.90407807e-02f, -8.44973624e-02f, -1.27646979e-02f, 5.00225350e-02f,
  -1.10114887e-01f, -9.90122557e-02f, -3.61764990e-02f, -3.32117230e-02f, 1.20688036e-01f, 1.24119623e-02f, 7.54281506e-02f, -1.07418127e-01f, 7.82477260e-02f, -5.54644205e-02f,
  -1.42276868e-01f, -2.45828122e-01f, 1.22236945e-01f, -8.88483673e-02f, -3.77688706e-01f, -2.08504349e-01f, -1.47614375e-01f, 7.19495788e-02f, 1.35488153e-01f, 1.75825730e-01f,
  1.52851999e-01f, -3.62642705e-02f, -1.50391906e-01f, 2.86352009e-01f, 2.21780568e-01f, -8.12655613e-02f, -6.66828081e-02f, 4.72225621e-02f, 3.68195504e-01f, 6.03616470e-04f,
  3.34225013e-03f, 2.66706049e-01f, -5.63438758e-02f, -1.00336134e-01f, -7.39326254e-02f, 5.48002943e-02f, 5.44833615e-02f, -9.31265801e-02f, -2.53125057e-02f, 1.08199194e-01f,
  1.03730425e-01f, -1.47540316e-01f, -1.60707813e-02f, -1.73828512e-01f, -2.75705811e-02f, -1.15533015e-02f, 1.76088866e-02f, -2.88140997e-02f, 1.09083951e-01f, -1.14779100e-01f,
  7.74714649e-02f, 1.45778149e-01f, 5.27879819e-02f, 8.22239593e-02f, 3.46879102e-02f, -1.41800558e-02f, 2.31819257e-01f, -7.53852203e-02f, -1.27360821e-01f, -9.58418399e-02f,
  2.90837344e-02f, -5.16161695e-02f, -6.68246970e-02f, 1.20922469e-01f, 1.00322135e-01f, 1.43022547e-02f, 2.55850311e-02f, -2.14012086e-01f, 1.60129488e-01f, 8.91253576e-02f,
  -1.35102376e-01f, 2.75885403e-01f, -1.12378888e-01f, -7.20343143e-02f, 2.40560770e-01f, -5.27078891e-03f, -4.05661650e-02f, -1.99696809e-01f, -4.44777869e-02f, -1.39171615e-01f,
  -1.65812597e-01f, 8.04649442e-02f, 1.77237261e-02f, 1.22620955e-01f, 9.58928764e-02f, 7.01147839e-02f, -6.56185998e-03f, 1.05292633e-01f, -6.80798143e-02f, -1.62171379e-01f,
  4.00545299e-02f, 3.47291236e-03f, -1.20322324e-01f, 2.20948737e-02f, 2.74762940e-02f, -1.14662558e-01f, 8.04814175e-02f, -3.72383855e-02f, 1.64321616e-01f, -8.74665529e-02f,
  2.76744932e-01f, 5.30191362e-02f, -1.32058367e-01f, -8.99885222e-02f, 1.81211710e-01f, -4.34908047e-02f, 6.14322424e-02f, -5.72319776e-02f, 3.06194136e-03f, 8.56303200e-02f,
  5.31950593e-03f, 5.30965719e-03f, 1.39533520e-01f, 3.89451720e-02f, 1.74697429e-01f, -1.90463569e-02f, 2.63333134e-02f, 1.75043438e-02f, -1.47837952e-01f, 2.47405186e-01f,
  1.30957186e-01f, 5.95341027e-02f, -1.25909802e-02f, 3.51943858e-02f, 5.02998531e-02f, 1.04873165e-01f, -1.03874482e-01f, 1.59076855e-01f, 6.65384382e-02f, 5.11079878e-02f,
  -1.07033253e-01f, 9.11308229e-02f, -4.21520472e-02f, 6.12042286e-02f, -3.01075839e-02f, -1.39602005e-01f, -1.19895134e-02f, 9.76350158e-02f, -6.95387945e-02f, 4.11868207e-02f,
  -6.34574369e-02f, -7.87945241e-02f, -3.55962999e-02f, -8.99031311e-02f, 1.56764418e-01f, 8.64408389e-02f, -1.00616969e-01f, -3.59470583e-02f, 2.91516026e-03f, 6.33558035e-02f,
  5.32982051e-02f, 3.67620364e-02f, 1.22013599e-01f, 3.34035568e-02f, 6.05523698e-02f, -1.31342877e-02f, -1.42778248e-01f, 7.53580639e-03f, -6.45882562e-02f, -5.71413059e-03f,
  -8.23327303e-02f, 5.48884645e-02f, -8.06729868e-02f, 4.96733412e-02f, 1.05154999e-01f, -1.24634765e-01f, 7.48446956e-02f, -1.96216796e-02f, -2.39421781e-02f, -7.79240113e-03f,
  -7.23959580e-02f, 1.04562394e-01f, -2.88134739e-02f, 8.17285776e-02f, -6.09223209e-02f, -7.02815950e-02f, 2.94213630e-02f, 6.11550659e-02f, -6.49812892e-02f, -5.49329370e-02f,
  7.56391734e-02f, -2.30703689e-02f, -5.35160005e-02f, 6.35840148e-02f, -1.40923914e-02f, -4.88793664e-02f, -2.46176105e-02f, 1.71423808e-01f, 5.57792820e-02f, -4.93450207e-04f,
  1.18400514e-01f, 2.47514248e-01f, 1.66255981e-01f, 1.30666226e-01f, 2.21990138e-01f, 1.07592709e-01f, 1.00046836e-01f, 8.43315721e-02f, -1.71611190e-01f, 2.17088506e-01f,
  -2.56818116e-01f, 4.62216213e-02f, 1.01246640e-01f, 3.86080183e-02f, -1.24896035e-01f, 3.12051177e-01f, 1.80975243e-01f, 3.84800173e-02f, 9.62412208e-02f, -2.52325740e-02f,
  -1.03317283e-01f, -1.08997442e-01f, 8.45363946e-04f, 2.15638336e-02f, 1.54459521e-01f, 3.01259924e-02f, -2.08012685e-01f, 8.88559297e-02f, 6.80560887e-01f, 6.15589879e-02f,
  1.85197536e-02f, 1.20054863e-01f, -3.58172767e-02f, -1.39955297e-01f, -8.78847688e-02f, 1.04144506e-01f, 1.69982761e-01f, 2.32691914e-01f, -5.37288897e-02f, 3.51329073e-02f,
  1.22950144e-01f, 3.54517728e-01f, 9.31995511e-02f, -1.63872093e-01f, -3.04726586e-02f, 5.19756898e-02f, -8.17545652e-02f, 6.80181012e-02f, -2.15857364e-02f, 3.50563899e-02f,
  -6.66644052e-02f, -2.71598808e-02f, 7.15698898e-02f, -2.19001517e-01f, -7.12633729e-02f, -3.37578878e-02f, -8.92909840e-02f, 3.38784933e-01f, -7.24499226e-02f, 1.58552930e-01f,
  -5.79072796e-02f, 5.77901267e-02f, 1.65582418e-01f, 1.11643761e-01f, 1.17928639e-01f, -2.88641863e-02f, -5.06193191e-02f, 1.65756568e-01f, -1.15931608e-01f, 2.21196249e-01f,
  -1.27919599e-01f, 1.81907751e-02f, 1.37169451e-01f, 4.73345742e-02f, 1.34102419e-01f, 1.44021884e-01f, 1.24117091e-01f, 1.45859888e-03f, 2.37383723e-01f, 8.34637359e-02f,
  -3.49987060e-01f, -9.68599133e-03f, -1.03766367e-01f, 7.88235515e-02f, 2.94735990e-02f, 1.49721235e-01f, -1.12810701e-01f, -9.30072814e-02f, 6.76039280e-03f, 1.55747160e-01f,
  1.61970593e-03f, -1.25440150e-01f, 3.15793790e-02f, -5.63847497e-02f, 2.06018746e-01f, -8.33805278e-02f, -7.60476887e-02f, 1.14776567e-02f, -9.37930716e-04f, 6.49497434e-02f,
  -1.14449508e-01f, 9.05779079e-02f, 7.97747262e-03f, 8.84081796e-02f, -1.50290504e-01f, 2.30734438e-01f, 1.45576492e-01f, -2.48585232e-02f, 8.84945691e-02f, 1.02214448e-01f,
  5.89132197e-02f, -2.15040952e-01f, 9.92806256e-03f, -7.37547800e-02f, -5.05183153e-02f, -1.40167577e-02f, -4.14972240e-03f, 1.99241400e-01f, -7.69144446e-02f, 2.99658962e-02f,
  -4.44553867e-02f, -3.74437235e-02f, -1.66420769e-02f, -1.07708508e-02f, 7.71006271e-02f, 1.61536381e-01f, 2.19892561e-01f, 7.80194206e-03f, -4.90632728e-02f, -7.66465738e-02f,
  -3.18494439e-03f, -3.87664139e-02f, 2.18760192e-01f, 1.15982473e-01f, -2.44951565e-02f, 8.08099881e-02f, 7.84028098e-02f, -1.01599731e-01f, -1.50528448e-02f, 2.36600060e-02f,
  -9.43890959e-03f, -1.50538459e-01f, 8.62992778e-02f, 1.32167898e-02f, -2.21435189e-01f, -1.20242998e-01f, -1.39117822e-01f, 4.62780260e-02f, 2.94770859e-02f, -1.90802235e-02f,
  -4.96976264e-02f, 8.20681974e-02f, 1.33965462e-02f, 1.22886002e-01f, -1.48112714e-01f, 1.35290384e-01f, 2.44297475e-01f, -5.72246909e-02f, 1.29513472e-01f, -2.53586285e-02f,
  -1.18739337e-01f, 2.44121566e-01f, 1.68166310e-02f, 7.84681812e-02f, -3.56420167e-02f, -1.57423485e-02f, 1.20702550e-01f, 3.43303159e-02f, 8.72844532e-02f, 1.80484876e-02f,
  -9.91619751e-02f, 2.23386828e-02f, -6.19561598e-02f, -3.65427807e-02f, -1.08805157e-01f, -5.14708739e-03f, -2.53791623e-02f, 1.79857109e-02f, -1.05351180e-01f, -2.47644708e-02f,
  -1.41800433e-01f, -1.87464450e-02f, 2.52744630e-02f, 1.33747131e-01f, 8.05097446e-02f, 7.87996426e-02f, -1.57564819e-01f, 8.71292725e-02f, 2.20735461e-01f, -4.41037901e-02f,
  2.19123065e-02f, 9.92251560e-02f, 2.64476597e-01f, 1.00217469e-01f, -7.69824982e-02f, 1.20349556e-01f, -6.02418603e-03f, 2.01099291e-01f, 2.09646240e-01f, 1.85329825e-01f,
  2.56836209e-02f, -4.21904117e-01f, 2.64558613e-01f, 1.19120665e-01f, -1.55413926e-01f, -1.18876494e-01f, 3.01940203e-01f, 4.74323593e-02f, -3.17809105e-01f, -7.61458725e-02f,
  3.81803066e-01f, -1.62510231e-01f, 9.63898748e-02f, -1.93610057e-01f, -1.29793003e-01f, 1.34185208e-02f, -7.24287471e-03f, 2.77604759e-02f, 2.83973962e-01f, 1.84261650e-01f,
  -1.58841953e-01f, 8.03881362e-02f, 1.60377786e-01f, -5.49967475e-02f, -8.28178376e-02f, 2.34252110e-01f, -1.09467171e-01f, -6.00926615e-02f, 5.46937399e-02f, -1.08506002e-01f,
  -1.10828541e-01f, 6.64713383e-02f, 2.68913638e-02f, -2.36904293e-01f, -6.14897721e-02f, 2.32949600e-01f, -4.78340238e-02f, 5.61513230e-02f, -7.17680827e-02f, 2.43868172e-01f,
  4.16276418e-02f, 3.30183983e-01f, 6.26559630e-02f, 2.14095205e-01f, -2.12505862e-01f, 2.49412596e-01f, 1.44320250e-01f, 1.87659219e-01f, -2.20890809e-03f, 1.48308352e-01f,
  3.58637244e-01f, -3.93603221e-02f, -5.40911965e-02f, -7.52725899e-02f, 6.43479731e-03f, 1.14214830e-01f, -3.96357402e-02f, -1.20944250e-02f, -1.20257944e-01f, -2.62440275e-02f,
  -1.15824409e-01f, -2.19413247e-02f, -1.10744126e-01f, 9.66791511e-02f, -2.72134393e-02f, -2.70548370e-02f, 9.54110995e-02f, -8.94626006e-02f, -6.10882230e-02f, -5.95963709e-02f,
  -1.02249466e-01f, 2.85961498e-02f, 2.66356785e-02f, -2.40194034e-02f, 7.88998902e-02f, -3.72621752e-02f, 1.14594825e-01f, 1.13633700e-01f, 1.10349961e-01f, -5.91138080e-02f,
  -8.92863199e-02f, 1.24844052e-02f, 6.35797158e-02f, -1.17026150e-01f, -1.20585233e-01f, 1.17435306e-01f, -1.10574044e-01f, -2.37685954e-03f, -1.10478066e-01f, -7.53087550e-02f,
  -7.16527402e-02f, -1.73072498e-02f, 3.38644460e-02f, -9.33165178e-02f, -7.91974738e-02f, 1.19821252e-02f, 1.05440572e-01f, -1.04562998e-01f, 3.95242348e-02f, -5.57193235e-02f,
  3.66219208e-02f, -1.03595965e-01f, 6.24291636e-02f, -9.76946354e-02f, -4.55312571e-03f, -1.56120062e-02f, 7.65314996e-02f, -2.80773523e-03f, -1.14398897e-01f, -1.23830795e-01f,
  3.71515304e-02f, 9.04996470e-02f, -5.93091361e-03f, -1.14415281e-01f, -7.98749849e-02f, -1.71443485e-02f, -1.24615312e-01f, 8.26576445e-03f, -1.08900256e-01f, -1.13907218e-01f,
  -8.98052454e-02f, -1.86836682e-02f, 5.56440130e-02f, 1.58398692e-02f, -5.78099601e-02f, 7.71003664e-02f, -3.65671404e-02f, 1.05390958e-01f, -5.41296937e-02f, -7.93377459e-02f,
  2.68581621e-02f, 5.84558025e-02f, 3.18513950e-03f, -1.45904571e-02f, -1.31193465e-02f, -5.84620424e-02f, 2.27018967e-02f, 1.32148182e-02f, -1.10400014e-01f, 1.48816220e-02f,
  -3.00510135e-02f, -7.52856582e-02f, -7.69896731e-02f, 1.16783686e-01f, 1.04878850e-01f, 7.65443742e-02f, 2.86291186e-02f, -2.62243338e-02f, -8.26639906e-02f, 1.00886889e-01f,
  -1.30837575e-01f, -1.13629691e-01f, 1.18174069e-01f, 7.72780031e-02f, -3.01744808e-02f, -9.86087099e-02f, -1.15114681e-01f, 7.21663088e-02f, -3.56882554e-03f, 2.59899814e-02f,
  2.72013396e-02f, 6.80679455e-02f, -6.09323150e-03f, 2.87710708e-02f, 1.02356471e-01f, 2.08888333e-02f, -1.74815077e-02f, -6.37850389e-02f, 1.08067401e-01f, 7.55981505e-02f,
  7.75091536e-03f, -1.15895346e-01f, -1.14273004e-01f, 2.82985205e-03f, -5.44133596e-02f, -2.81569567e-02f, 2.14837585e-03f, -3.72564048e-03f, -8.35027173e-02f, 4.53997366e-02f,
  -1.05004430e-01f, -2.38720626e-02f, 4.92752232e-02f, 3.95908356e-02f, -9.11601409e-02f, -8.85893255e-02f, 4.32840325e-02f, 4.66537140e-02f, -8.34398270e-02f, 7.91140944e-02f,
  -7.70787429e-03f, 2.13309657e-02f, 6.69787126e-03f, 6.56405240e-02f, -9.13793370e-02f, 1.03299476e-01f, -1.02310158e-01f, 1.23671740e-01f, 1.13916203e-01f, 1.02264665e-01f,
  -6.92174817e-03f, -4.26364802e-02f, 1.23860590e-01f, 9.66884047e-02f, 7.39541575e-02f, -8.97602811e-02f, -1.71233602e-02f, -5.86214736e-02f, 4.40344959e-02f, -1.08587090e-02f,
  1.47828504e-01f, -6.80508539e-02f, -1.06952861e-01f, -9.86233801e-02f, 5.53069264e-02f, 1.25661954e-01f, -6.19168431e-02f, -3.14834304e-02f, 7.59192780e-02f, -3.05434279e-02f,
  3.51117961e-02f, 6.36569858e-02f, 5.49362153e-02f, -9.17446837e-02f, -6.04823753e-02f, -1.46750674e-01f, 7.77046457e-02f, -3.50306816e-02f, 1.14515632e-01f, 8.63674581e-02f,
  -1.19864881e-01f, 1.70704257e-03f, 8.76126066e-02f, -5.47582172e-02f, -7.00876638e-02f, -1.02523208e-01f, -1.39500350e-01f, 5.80603406e-02f, -5.22250310e-02f, -4.75562960e-02f,
  6.50394410e-02f, 9.68392417e-02f, 3.77754644e-02f, 1.16350181e-01f, 2.92434804e-02f, -1.94441080e-01f, -9.48543549e-02f, -1.19923174e-01f, -1.40123233e-01f, 1.72732219e-01f,
  1.89139433e-02f, -1.47505552e-01f, -3.67715396e-02f, -1.60313472e-01f, -8.95005465e-02f, 7.70394430e-02f, -1.43714279e-01f, 6.62739128e-02f, 4.08923998e-02f, -5.24080656e-02f,
  1.28762200e-01f, 8.52661114e-03f, -1.98051676e-01f, -9.20684356e-03f, -6.60360232e-03f, -2.06561446e-01f, 1.15183875e-01f, 1.69856697e-01f, -8.21908489e-02f, 3.41635086e-02f,
  -5.50299361e-02f, -4.92672026e-02f, 1.37442634e-01f, 1.25467256e-01f, 2.04697385e-01f, 1.13708518e-01f, -3.00414506e-02f, -5.03067160e-03f, -2.39560530e-01f, -5.57352835e-03f,
  -4.51366529e-02f, 5.41338027e-02f, 2.94830110e-02f, 9.10278857e-02f, 5.70769459e-02f, -1.83190003e-01f, 2.20959738e-01f, 6.14322983e-02f, -1.04363836e-01f, -1.34109154e-01f,
  1.34084702e-01f, 1.43919483e-01f, 5.74876368e-02f, -1.26822770e-01f, -3.54504399e-02f, 5.65233901e-02f, 5.22651710e-02f, 1.40280977e-01f, -4.93074432e-02f, -1.22901052e-02f,
  2.39317641e-01f, 8.83758664e-02f, 2.47365367e-02f, 8.38666260e-02f, -8.12867507e-02f, 2.10333675e-01f, 2.91216940e-01f, 1.33100092e-01f, 1.45239845e-01f, -1.38826877e-01f,
  -2.02703755e-02f, -9.55880135e-02f, 1.05254725e-01f, 1.50395960e-01f, 1.09951282e-02f, -1.37225436e-02f, -1.12630323e-01f, -7.02931210e-02f, 4.35490683e-02f, 1.76945165e-01f,
  6.73832074e-02f, -1.09244652e-01f, 1.45831823e-01f, 5.52495867e-02f, -2.51288782e-03f, 3.16990763e-02f, 9.46687311e-02f, -2.26082101e-01f, -3.00870001e-01f, -2.24303320e-01f,
  9.46551561e-02f, -1.07975692e-01f, 7.84260556e-02f, 1.27445891e-01f, 9.44874138e-02f, -4.19389829e-02f, -2.34344508e-02f, 2.28108093e-01f, 2.18811616e-01f, 1.04509287e-01f,
  -1.97185099e-01f, -5.46924658e-02f, 6.17090575e-02f, 1.32534996e-01f, -6.41900173e-04f, 3.89923513e-01f, -1.42855465e-01f, 6.94960281e-02f, 1.55892387e-01f, -7.06923008e-02f,
  6.53318912e-02f, -1.78660676e-02f, 1.78133607e-01f, -4.32494022e-02f, -2.73342449e-02f, 9.60107893e-02f, -8.70850831e-02f, 9.86069590e-02f, -6.14016093e-02f, 9.16879475e-02f,
  -8.54823887e-02f, 2.31313989e-01f, -1.81129407e-02f, -3.31558697e-02f, 1.69020027e-01f, 3.45038682e-01f, -1.15476690e-01f, 1.11556463e-01f, -8.78659487e-02f, 9.62429792e-02f,
  4.05173391e-01f, 4.22878042e-02f, 1.78766727e-01f, 1.91431537e-01f, 3.30522925e-01f, 2.08734602e-01f, 2.71684468e-01f, 9.98655707e-02f, 3.23392063e-01f, 7.25522637e-02f,
  1.00232147e-01f, 2.58545846e-01f, -9.30497870e-02f, 1.26582608e-01f, 9.55562964e-02f, -1.31604284e-01f, 1.22518085e-01f, 3.22777539e-01f, 3.60271931e-02f, -3.02201379e-02f,
  1.11417606e-01f, 1.32897705e-01f, -3.84552598e-01f, 1.41000435e-01f, 1.93653658e-01f, 1.79495156e-01f, -9.22668651e-02f, 1.13002434e-01f, -1.97313428e-01f, 5.23460545e-02f,
  9.56564397e-02f, 1.09624593e-02f, 3.89824629e-01f, 3.51652689e-02f, -1.08942255e-01f, -1.01420879e-01f, -6.61523417e-02f, 6.84052482e-02f, 7.07865879e-02f, -2.50718594e-01f,
  1.83182403e-01f, -1.15452930e-01f, -4.31111641e-02f, -1.42604047e-02f, -2.39653647e-01f, 4.02633883e-02f, -1.60600543e-01f, -5.60345948e-02f, 1.14135548e-01f, 2.40616336e-01f,
  1.19744115e-01f, 2.06455052e-01f, -1.12417869e-01f, -1.18849650e-01f, 1.00708246e-01f, 1.87111512e-01f, 1.29326820e-01f, 1.05631039e-01f, -1.58853568e-02f, -6.77073747e-02f,
  -7.08297044e-02f, 1.13679312e-01f, -3.00509725e-02f, -4.08137403e-02f, 1.23071194e-01f, -1.53299585e-01f, 4.02153097e-02f, 6.50794283e-02f, 2.18139291e-01f, -2.25083325e-02f,
  2.34888978e-02f, 1.21576764e-01f, 7.75816143e-02f, 1.84321925e-01f, -1.22659244e-01f, 1.84785321e-01f, 9.61071998e-03f, -1.97050720e-02f, -2.15676391e-05f, 1.02483518e-01f,
  9.45000201e-02f, 2.18468085e-01f, 1.65978894e-01f, -1.91971704e-01f, 6.74828514e-02f, 6.45485669e-02f, -1.95637837e-01f, -2.33571887e-01f, -1.30663872e-01f, 1.24765366e-01f,
  5.18907718e-02f, 1.66871697e-01f, -1.71356708e-01f, 2.72553414e-02f, 6.80689067e-02f, 1.52163923e-01f, 4.87211859e-03f, -1.56526893e-01f, 6.25319704e-02f, -5.83048724e-02f,
  -2.13457495e-02f, 1.18055688e-02f, -3.44253518e-02f, -1.45934939e-01f, -3.79418023e-02f, 4.69162837e-02f, 1.52614236e-01f, 8.22265521e-02f, -8.13676417e-02f, 2.73868144e-02f,
  4.82068099e-02f, 2.47850999e-01f, 7.84415007e-02f, -1.22021168e-01f, 1.04809321e-01f, -6.02777442e-03f, -3.84918898e-02f, -2.00114936e-01f, -1.01178266e-01f, 4.90980893e-02f,
  4.80981693e-02f, -1.19441062e-01f, 7.79398307e-02f, 6.77438006e-02f, -1.08045690e-01f, 8.03479329e-02f, -1.74353063e-01f, 2.69698918e-01f, -5.95122017e-03f, 8.35859701e-02f,
  2.23910585e-01f, 2.84464389e-01f, 2.12960988e-01f, 1.85614958e-01f, 2.23558158e-01f, 3.89279090e-02f, -1.98866472e-01f, 1.80852011e-01f, 2.49730989e-01f, 1.88641444e-01f,
  3.07675838e-01f, 1.56040609e-01f, -7.90898800e-02f, -4.93290052e-02f, 2.72897005e-01f, -2.09406793e-01f, 1.57956645e-01f, -3.15007240e-01f, 4.86061066e-01f, 2.24215314e-01f,
  -3.26321661e-01f, -1.99267924e-01f, 5.63795641e-02f, -9.76662934e-02f, -1.27267033e-01f, 1.96236119e-01f, -8.00635517e-02f, -1.16792835e-01f, 1.36296406e-01f, 2.01297611e-01f,
  -1.71916783e-01f, -1.26214296e-01f, 2.96028197e-01f, -1.82976201e-01f, 5.41652977e-01f, -1.26018420e-01f, 8.46711323e-02f, 2.56519735e-01f, -1.24494508e-01f, -1.31905630e-01f,
  4.94707562e-02f, 3.81119758e-01f, 2.86924452e-01f, -7.22051412e-02f, 1.47879049e-01f, 3.50830197e-01f, 5.39941229e-02f, -2.58986831e-01f, 9.74215716e-02f, -2.01845676e-01f,
  -1.26844585e-01f, 1.07261643e-01f, 9.09956098e-02f, 9.78025049e-02f, 1.26892120e-01f, -7.04129860e-02f, -2.44018525e-01f, 5.38553037e-02f, -1.38471484e-01f, 1.40444309e-01f,
  1.85937956e-02f, 3.33046317e-01f, -1.40233994e-01f, -7.30917081e-02f, 1.39335915e-01f, 6.56124949e-02f, 3.43986973e-02f, 2.02647433e-01f, 6.33372292e-02f, 1.03010334e-01f,
  1.12617522e-01f, 2.55572684e-02f, -1.22660287e-01f, 1.08207114e-01f, 1.18877172e-01f, 1.51902869e-01f, -1.13108985e-01f, 1.60789862e-01f, -2.95723706e-01f, -7.43097812e-02f,
  1.02025524e-01f, 3.00754339e-01f, -1.85589433e-01f, -4.06289846e-03f, 1.94824681e-01f, -3.95197235e-02f, -1.49247229e-01f, 1.30940661e-01f, 2.08521523e-02f, 4.46246229e-02f,
  8.28503892e-02f, -9.41545963e-02f, -5.22406846e-02f, 1.91879228e-01f, -6.90454468e-02f, -7.04348683e-02f, 2.43739575e-01f, 5.18131778e-02f, -1.82827264e-01f, -5.35413437e-02f,
  -7.76581764e-02f, 5.89066942e-04f, 3.46215349e-03f, -7.37278163e-02f, -7.71741048e-02f, 9.65779647e-03f, -6.72937408e-02f, -2.19299383e-02f, -4.49744053e-02f, 7.20795989e-02f,
  -1.24765009e-01f, -1.28433704e-01f, 1.03786737e-01f, 1.04251266e-01f, -7.98592046e-02f, 5.74081466e-02f, -3.41592878e-02f, -1.22084051e-01f, 5.44521734e-02f, -9.02300924e-02f,
  2.75863111e-01f, -6.95467219e-02f, 9.26488042e-02f, -1.26520768e-01f, -9.36223865e-02f, 3.44573483e-02f, -1.09633747e-02f, -4.16184627e-02f, 4.75061797e-02f, 7.86648095e-02f,
  1.14448052e-02f, -5.54511957e-02f, -7.14226365e-02f, 1.54172093e-01f, 3.29344086e-02f, -5.63388132e-02f, -6.91054463e-02f, -6.32407740e-02f, -1.21158510e-02f, 1.41872376e-01f,
  5.34720533e-02f, 1.66994184e-01f, 3.38839963e-02f, 5.20058982e-02f, -1.12483175e-02f, 1.57938879e-02f, -1.49793088e-01f, 4.15761396e-02f, 3.29543948e-02f, 8.89620036e-02f,
  2.94785611e-02f, 3.79955806e-02f, 1.29950702e-01f, -3.06623094e-02f, -5.95441163e-02f, 1.60271283e-02f, 2.16052935e-01f, 1.02253646e-01f, 1.16749205e-01f, 4.95580547e-02f,
  2.21100748e-02f, 5.44396751e-02f, -1.56546548e-01f, 6.78605288e-02f, -1.24383695e-01f, -1.04915589e-01f, -3.97209637e-02f, 6.06908500e-02f, 3.33983935e-02f, -1.08011425e-01f,
  -3.40681039e-02f, -1.28971085e-01f, -5.65172061e-02f, -2.42842194e-02f, 7.50667304e-02f, 4.81509827e-02f, -2.42726132e-02f, 8.21631476e-02f, 5.24404831e-02f, 3.85959372e-02f,
  1.09463207e-01f, -1.77291986e-02f, 1.22775272e-01f, -8.21762905e-03f, 2.85793599e-02f, -1.15288734e-01f, 9.36212093e-02f, 6.31570444e-02f, 3.55869941e-02f, 1.21854052e-01f,
  1.65410951e-01f, -8.32400918e-02f, 5.38511090e-02f, 6.10694513e-02f, 1.27720490e-01f, 1.08587012e-01f, -4.58080657e-02f, 2.76196599e-02f, -9.95945744e-03f, -3.76278441e-03f,
  -7.58997574e-02f, -5.83814308e-02f, 2.59415686e-01f, 9.33466181e-02f, -9.14363265e-02f, -1.52669832e-01f, 2.99575296e-03f, -6.09337958e-03f, 1.60292745e-01f, -6.86429590e-02f,
  -2.08278485e-02f, 8.97116587e-02f, 6.65236041e-02f, -2.24254236e-01f, -1.46613689e-03f, -3.83703597e-02f, -3.60751495e-04f, 1.58493966e-01f, -5.84980734e-02f, -9.66413841e-02f,
  4.62870896e-02f, -3.86557057e-02f, 3.44826132e-02f, -4.04698513e-02f, -5.60092647e-03f, 1.63449626e-03f, 1.33011207e-01f, -1.25820681e-01f, 1.07534982e-01f, 2.62349904e-01f,
  -6.94244057e-02f, 1.06638484e-01f, -1.35563910e-01f, -1.17810294e-01f, 1.68740332e-01f, -1.13046557e-01f, 1.84977576e-01f, 1.37819365e-01f, -1.50124460e-01f, -8.78249854e-02f,
  -1.28616557e-01f, -1.63263917e-01f, -3.65216434e-02f, 1.06404625e-01f, -4.48386148e-02f, 1.88923791e-01f, 5.81438234e-03f, -4.52186204e-02f, 5.77170625e-02f, -3.88353392e-02f,
  1.17038719e-01f, 9.69577432e-02f, 5.32964244e-02f, 1.84316590e-01f, 1.94576353e-01f, -1.38522446e-01f, 3.54670659e-02f, 3.32206711e-02f, 5.77545688e-02f, 1.21129021e-01f,
  -3.73580679e-02f, 6.86687380e-02f, -9.88005251e-02f, 2.12881252e-01f, -5.94482571e-02f, 1.47455096e-01f, 1.61629230e-01f, -9.22423527e-02f, 1.68971211e-01f, -1.68514922e-01f,
  1.59511194e-02f, -4.98475209e-02f, -1.54712778e-02f, 1.15287051e-01f, 1.46276549e-01f, -1.09277755e-01f, -2.44405508e-01f, -1.94539532e-01f, 1.51935309e-01f, -3.15923579e-02f,
  -1.03665814e-02f, 1.60760828e-03f, -5.30753583e-02f, 6.34170398e-02f, 1.76729411e-01f, 2.40978539e-01f, 8.47686529e-02f, -1.47463366e-01f, -1.45251870e-01f, -7.73689076e-02f,
  7.91832879e-02f, 1.66175421e-03f, -9.96608287e-02f, 8.46119672e-02f, 1.19084232e-01f, -1.68743043e-03f, 9.38786715e-02f, 8.13301932e-03f, 2.34719574e-01f, 3.71967778e-02f,
  -3.67821939e-02f, -1.44021019e-01f, -2.48139091e-02f, -1.30008236e-01f, -8.39857161e-02f, -3.99561822e-02f, -8.37133303e-02f, -7.91403949e-02f, -8.37904364e-02f, 8.37082192e-02f,
  -1.15564950e-01f, 7.29113594e-02f, 1.28856748e-01f, 1.77200988e-01f, -1.29507147e-02f, 2.57984608e-01f, -7.23184124e-02f, 5.52899875e-02f, 2.08060622e-01f, -9.01939124e-02f,
  -1.93459578e-02f, 3.51854563e-02f, -6.75548464e-02f, 1.11148925e-02f, 9.50427204e-02f, 7.74171250e-03f, -1.54307649e-01f, 1.17511917e-02f, -6.06537946e-02f, 6.97218552e-02f,
  1.66297197e-01f, -1.11190192e-01f, -1.90865889e-01f, 1.07173450e-01f, 2.81508137e-02f, -3.25185090e-01f, -1.38001665e-01f, 2.46107385e-01f, -2.71648645e-01f, -1.79944634e-01f,
  9.05307829e-02f, -1.97492808e-01f, -3.84573728e-01f, -5.79354391e-02f, -7.60870427e-02f, 3.20924878e-01f, 3.25211674e-01f, -1.50256887e-01f, -2.00887680e-01f, 3.64338569e-02f,
  -1.38451844e-01f, 1.45347357e-01f, 2.29134157e-01f, 1.26551688e-01f, 2.02844277e-01f, -3.75096388e-02f, -4.14497852e-02f, 1.60118058e-01f, 2.96799745e-02f, -4.52556722e-02f,
  8.52808058e-02f, 3.97754535e-02f, 3.48597348e-01f, -1.11097552e-01f, 1.28773674e-01f, 4.10478488e-02f, -7.69691691e-02f, 1.07100448e-02f, 9.74811539e-02f, -1.64101273e-01f,
  8.97512063e-02f, 1.13353722e-01f, -1.35904830e-02f, 3.43948007e-02f, 3.27615812e-02f, -1.11932583e-01f, 3.21193546e-01f, 2.33568288e-02f, 4.97220978e-02f, 4.08498086e-02f,
  6.51392713e-02f, -5.39863184e-02f, -1.38002634e-01f, 1.49205318e-02f, 3.24191973e-02f, -4.20215875e-02f, 1.50922267e-02f, 1.13223150e-01f, 1.03047341e-01f, 9.43094492e-02f,
  1.35343760e-01f, 1.85872614e-01f, -7.32966289e-02f, -6.39223903e-02f, -1.26184940e-01f, 1.36846095e-01f, -3.44530344e-02f, 3.09753984e-01f, -2.62483656e-01f, -1.24809675e-01f,
  -1.90190688e-01f, 1.79349825e-01f, -3.44872952e-01f, -2.54128397e-01f, 2.11310878e-01f, -1.53763488e-01f, -1.71081424e-01f, 8.24750885e-02f, 9.62258056e-02f, 3.87661576e-01f,
  2.06643462e-01f, -8.63549933e-02f, -1.40153185e-01f, 2.37968221e-01f, 1.01329401e-01f, 4.49641288e-04f, 8.09332505e-02f, 1.51544693e-03f, 3.73425484e-02f, -6.48514554e-02f,
  4.16349359e-02f, -1.34742677e-01f, 2.90965468e-01f, 8.25621411e-02f, -7.55174085e-02f, -1.46957189e-01f, 7.57423118e-02f, -1.13739841e-01f, -3.15225087e-02f, 1.60741776e-01f,
  3.86275910e-02f, -1.48874015e-01f, -1.39919996e-01f, 8.05083662e-02f, 7.21910149e-02f, 1.08284637e-01f, -1.04044020e-01f, -1.37393579e-01f, -1.00134864e-01f, 4.78497893e-02f,
  6.63272798e-01f, 1.04896732e-01f, 1.75869334e-02f, -1.32822514e-01f, -1.03129700e-01f, -9.85190123e-02f, 8.00039992e-03f, 2.19583213e-02f, 9.80344042e-02f, -6.13573641e-02f,
  -9.18846875e-02f, -1.25999555e-01f, 5.24644479e-02f, -3.58761996e-02f, 7.75352344e-02f, -1.65611948e-03f, 1.30637586e-02f, -5.42206168e-02f, -7.18375295e-02f, -8.86938274e-02f,
  1.37771949e-01f, -2.72334348e-02f, 5.94865810e-03f, -6.32307008e-02f, 7.53747150e-02f, -6.12425283e-02f, 6.50398135e-02f, -7.32984692e-02f, 5.92707060e-02f, -4.21523228e-02f,
  2.40947325e-02f, 5.17180525e-02f, 4.28403951e-02f, 5.29512390e-02f, -2.22490579e-02f, -1.95726231e-02f, -7.11690113e-02f, 8.87345970e-02f, 1.28284067e-01f, -9.46993083e-02f,
  6.86363801e-02f, -5.33130579e-02f, -4.90280166e-02f, -5.52797653e-02f, -8.30711573e-02f, 3.13661024e-02f, -8.75791535e-02f, -8.90901461e-02f, 4.93798144e-02f, 4.26485799e-02f,
  -1.03832074e-01f, 9.70763993e-03f, -3.25353667e-02f, -5.46141702e-04f, -9.97825563e-02f, 1.30787700e-01f, 3.87192778e-02f, 1.22537956e-01f, 9.93074849e-02f, -1.29568219e-01f,
  7.74561912e-02f, -6.03128299e-02f, -9.34079140e-02f, 1.24457613e-01f, 1.66799175e-03f, -8.46581310e-02f, 9.56615731e-02f, -9.36434194e-02f, 1.02090925e-01f, 2.00941563e-02f,
  3.03385276e-02f, 2.60810535e-02f, -6.44834563e-02f, -1.29471496e-01f, -1.09101437e-01f, 6.63121268e-02f, 3.97900343e-02f, -1.29495785e-01f, 1.36991143e-02f, 7.00377002e-02f,
  6.79002004e-03f, -1.41062737e-01f, 1.02590613e-01f, 7.70467371e-02f, 1.52154993e-02f, 3.96956801e-02f, -4.70450930e-02f, 1.00354381e-01f, -4.56182621e-02f, -3.09260469e-02f,
  -8.99303257e-02f, -7.23483860e-02f, 1.28201675e-03f, 6.24621660e-02f, 1.34753644e-01f, 9.34428498e-02f, -4.52051684e-02f, -1.42907873e-01f, -2.55128555e-02f, 1.70734134e-02f,
  -1.75743853e-03f, 4.72153835e-02f, -1.03120022e-01f, -7.95742348e-02f, 7.86647052e-02f, 1.07828535e-01f, -3.12096793e-02f, -9.25033912e-02f, 7.53667355e-02f, 8.80821422e-02f,
  -4.83054519e-02f, -8.44458789e-02f, 3.53023335e-02f, -7.69030228e-02f, -9.72686708e-02f, -4.77128252e-02f, 4.85178363e-03f, -8.51718634e-02f, 1.19101152e-01f, 7.07321614e-02f,
  1.05572425e-01f, 9.34911519e-02f, 1.10232733e-01f, -1.87287573e-02f, 8.33518244e-03f, -9.45856571e-02f, 1.00742467e-01f, -1.15262806e-01f, 7.21942782e-02f, -1.29002957e-02f,
  -9.29467082e-02f, -1.48577504e-02f, 4.05422151e-02f, -1.20850913e-01f, -1.01530366e-01f, -1.40517727e-02f, 7.52641410e-02f, 2.02282503e-01f, 1.56250104e-01f, 3.02784443e-01f,
  1.81620240e-01f, 1.62821293e-01f, 2.50158191e-01f, 1.30777612e-01f, 1.56205744e-02f, 3.96066606e-01f, 1.12936132e-01f, 1.69423357e-01f, -1.28733024e-01f, -1.93894371e-01f,
  -7.20786974e-02f, 2.17327148e-01f, -2.94675585e-02f, 9.83710065e-02f, 9.41850524e-03f, 2.74992827e-02f, -3.88209522e-02f, 8.37379768e-02f, 2.72787418e-02f, -4.24606316e-02f,
  -3.86688560e-02f, -6.91488534e-02f, -4.66646161e-03f, -7.27197528e-02f, 1.18759975e-01f, 1.03977822e-01f, 9.95261818e-02f, 6.78457841e-02f, 3.40957105e-01f, -2.46512257e-02f,
  -8.96155983e-02f, 3.47113386e-02f, 1.30018875e-01f, -1.31577566e-01f, -3.56723629e-02f, -9.97341946e-02f, -1.67452753e-01f, 9.95613933e-02f, -1.98187176e-02f, 8.13650340e-02f,
  -1.23980880e-01f, 1.46096528e-01f, -1.22552244e-02f, -2.67197797e-03f, 3.05006988e-02f, -3.99627946e-02f, -5.73376864e-02f, 5.90566732e-02f, 1.37022128e-02f, 1.07573815e-01f,
  8.08654502e-02f, 1.08384058e-01f, 3.37078311e-02f, -4.92588319e-02f, -6.77419081e-02f, 9.07124281e-02f, 5.88382175e-03f, -1.27016213e-02f, -8.28915909e-02f, -1.59503713e-01f,
  7.76130054e-03f, -2.40099709e-02f, -1.13476895e-01f, -3.10203508e-02f, -9.16132703e-02f, -4.99087572e-02f, -7.85024762e-02f, -1.06796391e-01f, -4.11154702e-02f, -4.47856151e-02f,
  2.34225690e-02f, -1.88039131e-02f, -8.57355818e-02f, 4.20819893e-02f, 1.88467018e-02f, -4.95151244e-02f, 6.38834909e-02f, 1.10877797e-01f, -1.04720235e-01f, -1.01102516e-02f,
  -4.77718413e-02f, -1.20595075e-01f, 1.04988262e-01f, 1.04441479e-01f, -5.46921082e-02f, -1.61718708e-02f, -1.25280812e-01f, -5.21555953e-02f, -3.05078421e-02f, -1.21984817e-01f,
  -1.80481356e-02f, 1.10076636e-01f, -6.05034903e-02f, 2.49527441e-03f, -4.05509118e-03f, -6.23698123e-02f, 7.03040287e-02f, 3.55158187e-02f, -4.36169514e-03f, 6.83696195e-02f,
  8.40298906e-02f, 7.36670941e-02f, 1.19770579e-01f, 1.26694366e-02f, 1.03804976e-01f, 5.48784295e-03f, 4.86698039e-02f, 9.76578593e-02f, 9.86443982e-02f, 9.17562172e-02f,
  -3.39438580e-02f, 7.63212889e-02f, 8.47890042e-03f, 9.70221013e-02f, 7.48770908e-02f, 2.95141921e-03f, 5.89463376e-02f, -2.42966935e-02f, -9.57080722e-02f, -3.46643999e-02f,
  1.03844978e-01f, -4.44032587e-02f, -1.11100741e-01f, 7.12910369e-02f, 1.37619123e-01f, 1.00523703e-01f, 1.08315209e-02f, -2.42725592e-02f, -7.93421827e-03f, 9.86950845e-03f,
  -8.81301686e-02f, 1.96557939e-01f, -3.84556986e-02f, 1.41781941e-01f, -9.92501676e-02f, -9.60153267e-02f, -3.49335931e-02f, 1.30190104e-01f, -1.84628889e-01f, -9.84486192e-02f,
  1.39358342e-02f, 2.08034873e-01f, -1.31074697e-01f, 1.00810304e-01f, 1.31955370e-01f, 8.99188817e-02f, 4.26646620e-02f, 4.80007455e-02f, -6.77083731e-02f, 4.51672152e-02f,
  8.58600140e-02f, 2.06496827e-02f, 5.77967614e-03f, 6.62977668e-03f, -1.34375870e-01f, -5.20372344e-03f, 2.53845491e-02f, -9.27097276e-02f, -1.66082636e-01f, -4.38232385e-02f,
  4.30489741e-02f, -1.45113654e-02f, 5.83086051e-02f, 1.05082452e-01f, -9.21156853e-02f, 4.74719144e-02f, -6.22759163e-02f, 3.98654230e-02f, -1.18310973e-01f, 8.71237069e-02f,
  -8.77375156e-02f, 3.19545977e-02f, -1.24711886e-01f, 1.40697420e-01f, -1.31735522e-02f, -3.56259905e-02f, -8.00735205e-02f, 6.61687702e-02f, 2.46773902e-02f, 4.38493751e-02f,
  2.36552581e-01f, -1.34090468e-01f, -4.80829328e-02f, -1.35646358e-01f, -1.16789518e-02f, -7.39637017e-02f, -5.71679324e-02f, -5.93022779e-02f, 6.59893751e-02f, 1.77092761e-01f,
  -1.09233834e-01f, 1.92845821e-01f, -7.15204626e-02f, 1.84789091e-01f, -1.02266751e-01f, 1.81318507e-01f, -5.38609289e-02f, 1.46961033e-01f, -1.85351700e-01f, 5.65507496e-03f,
  1.52356848e-01f, -2.72016414e-02f, -5.31144179e-02f, 2.00865176e-02f, -3.02129358e-01f, 8.12363401e-02f, -9.30172727e-02f, -2.01593503e-01f, -6.71314672e-02f, -1.56404972e-01f,
  -1.74876794e-01f, 9.82585084e-03f, -6.28447682e-02f, 8.54433030e-02f, 9.15092826e-02f, 4.01433855e-02f, -2.92024259e-02f, 1.88422456e-01f, 3.07414800e-01f, -1.25294253e-01f,
  -2.90310830e-01f, -1.31771620e-02f, 1.25851408e-01f, 3.91750038e-02f, 9.20317248e-02f, 2.63224721e-01f, 2.47184098e-01f, -5.51692247e-02f, -1.19453430e-01f, -7.84691498e-02f,
  -1.47681922e-01f, 1.21034654e-02f, -1.19990312e-01f, 2.78400201e-02f, 1.25716746e-01f, 9.90576018e-03f, -8.65955055e-02f, 8.82968530e-02f, -2.36266367e-02f, -4.28808369e-02f,
  -9.83530357e-02f, -9.41782519e-02f, 6.20478652e-02f, 1.41554207e-01f, 2.42068261e-01f, 4.71095368e-02f, -1.33299872e-01f, -8.50187913e-02f, 7.03780353e-03f, -1.69537127e-01f,
  2.48538330e-01f, -1.55653581e-02f, 1.28798857e-01f, 1.19415782e-01f, -6.91333041e-02f, 1.77982166e-01f, 1.38381362e-01f, -6.17864393e-02f, 2.18277983e-02f, 3.92921902e-02f,
  3.87951657e-02f, 1.51652873e-01f, 1.86936617e-01f, 1.32526934e-01f, 1.33317545e-01f, 9.76862609e-02f, -4.27525258e-03f, -1.12967305e-01f, 2.22875997e-01f, -1.71868607e-01f,
  8.29189047e-02f, 1.99952379e-01f, -3.90765369e-02f, -1.12190597e-01f, 1.25368267e-01f, -6.22011013e-02f, -3.49199958e-02f, 3.63629721e-02f, -1.65808022e-01f, -7.73965195e-02f,
  3.86696830e-02f, 1.33349597e-01f, -1.04091190e-01f, -7.65780285e-02f, 3.37081194e-01f, -8.99957344e-02f, 2.91397661e-01f, 1.32917995e-02f, 1.30455762e-01f, 1.80507913e-01f,
  -1.42897129e-01f, 1.08221963e-01f, 2.83082779e-02f, 2.34048635e-01f, 1.54093400e-01f, -8.80474746e-02f, 6.59446865e-02f, 1.72645912e-01f, 1.33068472e-01f, -1.46585956e-01f,
  1.31606553e-02f, -7.53865317e-02f, -9.26388800e-02f, -1.22568592e-01f, -2.34490074e-02f, -5.17287105e-02f, 7.88097456e-03f, -3.49587612e-02f, -2.05987841e-01f, 1.62598327e-01f,
  -4.67902534e-02f, 1.59585819e-01f, -5.50555475e-02f, 2.75457054e-01f, 6.23627044e-02f, 4.75914776e-02f, 3.17490436e-02f, 3.56534459e-02f, -6.95864670e-03f, 7.30689317e-02f,
  -1.10553697e-01f, -9.70247686e-02f, -1.04874052e-01f, 4.09038328e-02f, -4.92751636e-02f, -1.68736532e-01f, 8.18580389e-02f, 1.04411393e-01f, -4.67178710e-02f, -8.44079480e-02f,
  5.32467179e-02f, 6.29839450e-02f, 8.31321701e-02f, -7.17819333e-02f, -6.28695041e-02f, -5.28716817e-02f, 6.00991696e-02f, -4.99396659e-02f, 1.00223467e-01f, -7.34444857e-02f,
  8.74475390e-02f, -6.84567168e-02f, 1.03725113e-01f, 1.21938266e-01f, -1.14950784e-01f, -7.83191770e-02f, 2.92860437e-02f, 1.09584583e-02f, -1.07862707e-02f, -1.13678031e-01f,
  8.48502070e-02f, -1.32017164e-02f, -7.68414289e-02f, 8.64476897e-03f, -9.43429098e-02f, -5.69057697e-03f, -1.36290202e-02f, -1.22498125e-01f, -5.73471449e-02f, -7.06224144e-02f,
  -4.27546725e-02f, -4.51608263e-02f, -1.26814200e-02f, -6.69986084e-02f, -9.17888209e-02f, 1.66423852e-03f, -8.57641026e-02f, 1.68097746e-02f, 8.11933875e-02f, 4.17455845e-02f,
  1.20146327e-01f, 8.28514472e-02f, -3.18249390e-02f, -9.79073532e-03f, 5.21983840e-02f, -2.21558437e-02f, 9.05925706e-02f, -6.65749237e-02f, 1.72802478e-01f, -8.28661472e-02f,
  5.08357659e-02f, -1.39135659e-01f, -6.27653599e-02f, -9.29451808e-02f, -9.34778806e-03f, 1.11762956e-01f, -4.08978462e-02f, -1.68684348e-01f, 4.56397608e-02f, -1.75890416e-01f,
  -1.22487068e-01f, 8.04219618e-02f, 5.73877420e-04f, 1.49904549e-01f, -1.16231881e-01f, 6.53518364e-02f, 1.03642404e-01f, -1.29006654e-01f, -5.83592383e-03f, -8.52410868e-03f,
  -4.96803187e-02f, -5.14483787e-02f, -7.80153871e-02f, -1.18082128e-02f, -1.00956768e-01f, 7.04487553e-03f, 7.90895894e-02f, 2.33132374e-02f, -1.30500898e-01f, 6.58066347e-02f,
  -1.06564879e-01f, -1.13690458e-01f, 2.09860038e-02f, 7.62645677e-02f, -1.17183566e-01f, -4.77464544e-03f, 2.19782591e-02f, -2.20111292e-02f, -7.03475848e-02f, 1.25690028e-01f,
  1.00538388e-01f, -9.56436172e-02f, 1.59062356e-01f, 1.62392284e-03f, -1.60595533e-02f, -1.12807587e-01f, 4.75734994e-02f, -1.03991270e-01f, -6.48599863e-02f, -5.95169999e-02f,
  -2.18594372e-02f, 1.43936187e-01f, -1.87932830e-02f, 4.63652834e-02f, 3.10017187e-02f, 5.78505062e-02f, 1.83194235e-01f, -9.18324292e-02f, -6.58483664e-03f, -7.13486746e-02f,
  -7.85498172e-02f, 1.59787953e-01f, 1.38111040e-01f, -8.19221954e-04f, -4.20343727e-02f, -4.58760075e-02f, -3.37220132e-02f, -1.31086677e-01f, -3.11939735e-02f, -5.45323417e-02f,
  -1.06235512e-01f, 2.84021758e-02f, 1.21782094e-01f, 9.53240320e-02f, -7.57825747e-02f, 1.23489998e-01f, -6.03094995e-02f, -1.02420375e-01f, -3.88119183e-02f, -6.29804656e-02f,
  -7.04865977e-02f, -9.21210181e-03f, -7.13477731e-02f, -8.91591012e-02f, -8.80102366e-02f, -1.42301589e-01f, 1.41880542e-01f, 6.14375323e-02f, -1.17809996e-01f, -7.47319758e-02f,
  -1.00140117e-01f, 8.54298696e-02f, -5.06382771e-02f, 9.66042280e-02f, -6.39738292e-02f, 1.11239955e-01f, -8.21406543e-02f, 3.66498679e-02f, -5.18390425e-02f, -5.01973229e-03f,
  1.05593614e-01f, 1.69193432e-01f, -1.07619151e-01f, -2.01372299e-02f, -3.61016355e-02f, -4.33840491e-02f, 7.43796676e-02f, -2.05929726e-02f, 1.51891857e-01f, -1.19513847e-01f,
  4.63703834e-02f, 1.73789918e-01f, -3.78582701e-02f, -4.16347086e-02f, -3.64392959e-02f, 1.13434240e-01f, 1.24985442e-01f, 8.34891573e-02f, 4.44220155e-02f, 7.30099007e-02f,
  9.49918777e-02f, 1.30773947e-01f, -5.13562337e-02f, -4.01513204e-02f, -7.20606670e-02f, 1.45603538e-01f, 3.83251868e-02f, -3.14344689e-02f, -1.46001985e-03f, -1.27136797e-01f,
  -9.62170400e-03f, -2.41166409e-02f, -1.03556529e-01f, 1.83346532e-02f, -9.32341442e-02f, -9.27551612e-02f, -4.79414612e-02f, -2.18567550e-01f, 1.41700702e-02f, 6.43152073e-02f,
  4.74051721e-02f, -6.66956091e-03f, -6.49713948e-02f, -1.31602898e-01f, 4.38409969e-02f, -5.80955371e-02f, 2.19624303e-03f, -1.71073392e-01f, -9.17568512e-04f, -3.97078544e-02f,
  -1.02007382e-01f, -1.03971094e-01f, -8.93877149e-02f, 3.59705687e-02f, 9.35976952e-02f, 9.27123651e-02f, -1.38942793e-01f, 5.97212017e-02f, -7.50018135e-02f, -5.74443825e-02f,
  -5.21224067e-02f, -6.85133561e-02f, -1.28736347e-02f, -2.28796005e-02f, 8.29440206e-02f, -4.72043827e-02f, -8.77922624e-02f, -1.35980146e-02f, 8.24295282e-02f, -1.47560447e-01f,
  1.19422957e-01f, -1.21903025e-01f, 5.28048947e-02f, -3.01528852e-02f, -3.84024940e-02f, 1.18342735e-01f, 9.45086628e-02f, -5.55334836e-02f, -3.70020904e-02f, -9.45795327e-03f,
  -6.03915425e-03f, 1.34488875e-02f, 1.03773624e-01f, 1.20549455e-01f, 1.74865827e-01f, -8.58755037e-02f, 4.52079438e-02f, 1.25502095e-01f, -1.17970221e-01f, -2.76494157e-02f,
  1.28486827e-01f, 2.47965138e-02f, 1.15817338e-01f, -4.44625951e-02f, 1.01762369e-01f, 3.53062674e-02f, -7.00869039e-02f, -1.10517874e-01f, 7.31709003e-02f, -9.73312035e-02f,
  1.00687943e-01f, -7.54016638e-02f, -9.37051177e-02f, 3.54125984e-02f, -8.84257182e-02f, -1.19923703e-01f, 8.05380866e-02f, 1.33083671e-01f, -8.58489722e-02f, -9.48541239e-02f,
  1.00587513e-02f, 1.44941777e-01f, -8.42123553e-02f, 9.57710445e-02f, 6.22634143e-02f, 1.00214027e-01f, -9.61516276e-02f, -1.29878461e-01f, -9.27834958e-03f, 6.20918535e-02f,
  1.13129169e-01f, -1.25974089e-01f, 6.07802905e-02f, 1.33889183e-01f, 1.33145064e-01f, 1.50622711e-01f, -1.16865039e-02f, 3.62732112e-02f, 7.93568939e-02f, -4.81228046e-02f,
  4.33270410e-02f, 3.67688350e-02f, -2.46023629e-02f, 9.19261575e-02f, -1.12961635e-01f, 8.72018188e-02f, 1.30160496e-01f, 1.98945645e-02f, 8.04146156e-02f, 1.20000295e-01f,
  1.31426498e-01f, -6.84105307e-02f, -2.78616678e-02f, -2.13036761e-02f, 6.61003366e-02f, 6.49600103e-02f, 1.09278532e-02f, 3.20394821e-02f, 7.29229003e-02f, 3.65204830e-03f,
  9.32808444e-02f, -1.16279893e-01f, -5.11773229e-02f, 6.35887682e-02f, -4.12073731e-02f, -1.12556435e-01f, 6.57910388e-03f, -4.00327519e-03f, -6.61352724e-02f, -4.22397368e-02f,
  2.79974584e-02f, 5.02243936e-02f, 9.73827392e-03f, 1.16676256e-01f, 2.51358934e-02f, 1.65905356e-01f, 4.07045931e-02f, -6.16509430e-02f, -2.00071737e-01f, 2.10878383e-02f,
  8.10604636e-03f, -1.03274830e-01f, -2.27332115e-01f, 3.13206077e-01f, -1.54033214e-01f, -1.60423350e-02f, 1.50712207e-01f, -6.81110248e-02f, -2.36305252e-01f, -9.56753418e-02f,
  -1.36301935e-01f, 2.52062470e-01f, 2.95961469e-01f, 3.87938693e-02f, -2.21301973e-01f, 7.98562840e-02f, 6.17087036e-02f, 2.00968534e-01f, -3.50481421e-02f, 9.52997208e-02f,
  3.81601565e-02f, -2.98905969e-02f, 4.16815467e-02f, 1.11694053e-01f, -7.81257451e-03f, 9.54552218e-02f, -5.74803352e-02f, 1.08070098e-01f, 2.18582079e-01f, 4.21332307e-02f,
  2.48770043e-03f, 3.58560868e-02f, -1.00441940e-01f, 1.66399125e-02f, -1.47163486e-02f, -2.97668763e-02f, -4.79079038e-02f, -4.31218706e-02f, 4.05904204e-02f, 3.27707790e-02f,
  -6.40324652e-02f, -9.95068178e-02f, 3.44737560e-01f, 7.74445385e-02f, -1.00826539e-01f, 9.12515000e-02f, 6.49022907e-02f, -1.03794925e-01f, -8.58731419e-02f, 1.50197729e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 40)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 40;
const float L2_fan_Bp_bar_data[] = {
  -3.55473235e-02f, 4.05401140e-02f, 1.09985374e-01f, -1.40136322e-02f, -6.20015077e-02f, 1.25973716e-01f, 5.33080474e-02f, 8.92238319e-02f, -8.46090689e-02f, 1.65344551e-01f,
  1.50603894e-02f, -4.92817089e-02f, 2.13721380e-01f, -2.71246321e-02f, 8.42967927e-02f, 6.69064820e-02f, 1.08827852e-01f, -2.02082451e-02f, 1.01380602e-01f, 1.29216416e-02f,
  -2.63857991e-02f, -2.31992211e-02f, 4.25464697e-02f, 1.50569439e-01f, 5.86413667e-02f, 4.17161770e-02f, 1.42794371e-01f, 6.93412945e-02f, -9.75054726e-02f, 9.37541500e-02f,
  -1.76055487e-02f, 1.49852291e-01f, 1.53919205e-01f, -6.45106286e-02f, -8.01710710e-02f, 7.44178146e-02f, 1.23829722e-01f, -1.19598275e-02f, 1.01180032e-01f, 3.57054435e-02f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  -1.08740352e-01f, -1.93132207e-01f, -1.19255655e-01f, -1.07469398e-03f, -9.72047746e-02f, -2.42783025e-01f, -2.96513140e-01f, 1.26292966e-02f, -6.06422238e-02f, -7.64466543e-03f,
  -1.67129532e-01f, -1.49911940e-01f, 1.58979446e-01f, 7.79445693e-02f, -1.22392438e-01f, -3.78024906e-01f, -1.97604790e-01f, -1.84080303e-01f, 1.89884022e-01f, 9.31571424e-02f,
  1.26605734e-01f, 3.33989481e-03f, -1.37523636e-01f, 3.03189009e-02f, -3.91051769e-02f, 1.18259437e-01f, 2.60635227e-01f, 6.32273033e-02f, 2.97849417e-01f, 1.93041876e-01f,
  1.77337810e-01f, 1.44490853e-01f, -6.40316382e-02f, -2.71934420e-01f, -3.24879795e-01f, -2.32964784e-01f, 3.02281290e-01f, 1.02592669e-01f, -5.39499037e-02f, -9.31141153e-02f,
  3.07092071e-01f, 3.55634749e-01f, -4.35793638e-01f, -4.69692856e-01f, -2.33497813e-01f, -1.19770288e-01f, 4.89313947e-03f, 1.45091623e-01f, 1.45730585e-01f, -3.74619174e-03f,
  -1.57980900e-02f, 3.74587439e-02f, -4.88750916e-03f, -4.98027265e-01f, -3.66017744e-02f, -7.79047459e-02f, 3.19506735e-01f, -1.58790559e-01f, 1.93310484e-01f, 5.26458248e-02f,
  6.63572028e-02f, 2.68691987e-01f, 9.59668830e-02f, -1.64944623e-02f, -1.15883827e-01f, 9.99746099e-02f, -1.38939247e-01f, -1.69406578e-01f, 1.42000437e-01f, -2.08105475e-01f,
  -1.44427434e-01f, 8.62824265e-04f, -7.49021024e-02f, -1.02600113e-01f, 1.59131959e-01f, -9.29898322e-02f, 2.32393727e-01f, -2.78346062e-01f, 1.02557987e-01f, 1.75692573e-01f,
  2.75219679e-01f, 2.34528542e-01f, -2.55519211e-01f, -1.43482521e-01f, 2.28320211e-01f, 4.14727837e-01f, -2.97916979e-02f, 2.32527077e-01f, -1.69723794e-01f, 1.13173597e-01f,
  1.36858895e-01f, 2.56276369e-01f, 5.22915542e-01f, 3.64403650e-02f, 8.96927342e-02f, 5.61392963e-01f, -5.58311902e-02f, 8.14796016e-02f, -1.00574441e-01f, 3.57582942e-02f,
  -4.27522689e-01f, 6.88375905e-02f, 9.32304114e-02f, 9.95150432e-02f, 3.82770389e-01f, 2.07617834e-01f, -1.19689249e-01f, 1.93168014e-01f, -4.50522304e-01f, -8.86438563e-02f,
  3.57752480e-02f, -1.93682969e-01f, -1.62721127e-01f, 3.12330574e-01f, 3.91694009e-01f, -6.23422563e-02f, 9.58236083e-02f, -3.22924852e-01f, -3.27764116e-02f, -2.15980202e-01f,
  -1.71384767e-01f, -3.32185626e-01f, -6.07760549e-02f, 3.36974949e-01f, 9.53124091e-02f, 2.81305969e-01f, 1.41469389e-02f, 1.27989143e-01f, -2.19533846e-01f, 4.08893786e-02f,
  -4.11653779e-02f, -2.63259143e-01f, 2.80641526e-01f, 1.55888587e-01f, 1.45716667e-01f, 1.11492470e-01f, 1.41706631e-01f, 1.11939862e-01f, 1.10659800e-01f, 1.32325605e-01f,
  -3.21381718e-01f, -3.22872281e-01f, 1.73444659e-01f, -1.06671620e-02f, 1.26808370e-02f, 1.14688903e-01f, -1.50884196e-01f, 5.54911554e-01f, 9.98318493e-02f, -5.98744638e-02f,
  -3.94130349e-02f, -3.43151659e-01f, 1.42626464e-01f, -1.48951203e-01f, -2.44308650e-01f, 1.50091708e-01f, -2.68449754e-01f, 1.86828412e-02f, 1.66017920e-01f, 2.94331044e-01f,
  -4.77456003e-02f, -9.71719772e-02f, 3.68454337e-01f, -9.80354548e-02f, -2.17996448e-01f, -3.58921252e-02f, 1.05269112e-01f, -1.26152471e-01f, 5.14644757e-02f, -1.37550339e-01f,
  1.11037403e-01f, 2.92992800e-01f, 5.46747506e-01f, -8.71168897e-02f, 1.01834036e-01f, -7.00140074e-02f, 2.52676696e-01f, 1.70645744e-01f, 5.53368889e-02f, 2.33458020e-02f,
  -9.76475999e-02f, 3.81313637e-02f, 1.39066465e-02f, -1.12554029e-01f, -1.53971031e-01f, 2.60202438e-01f, -8.65352899e-02f, -1.03123538e-01f, -2.46369600e-01f, 3.24425474e-02f,
  -2.32660905e-01f, -7.23941326e-02f, -1.66118816e-01f, -2.71595091e-01f, -1.86662242e-01f, 1.12135783e-01f, -1.12447347e-02f, -1.00235872e-01f, -1.57890037e-01f, -2.65829742e-01f,
  8.05527866e-02f, -1.19666429e-02f, -4.01524663e-01f, 1.38334766e-01f, 8.31019133e-02f, -1.69636041e-01f, 1.58062428e-01f, -6.47799894e-02f, -4.07916456e-02f, -2.69905537e-01f,
  2.97586054e-01f, -4.90735881e-02f, 1.92339465e-01f, 1.83495089e-01f, -1.06132135e-01f, 1.22979626e-01f, 2.63391342e-02f, -2.47619092e-01f, 2.77305692e-01f, 5.82568869e-02f,
  -2.51150399e-01f, 2.81688929e-01f, -1.94912627e-01f, -2.57124146e-03f, 9.44029167e-02f, -3.49818617e-01f, 7.96041936e-02f, -3.18316072e-02f, 4.95586157e-01f, 3.17895077e-02f,
  6.49670139e-02f, 2.36780375e-01f, 2.27542803e-01f, 3.07570010e-01f, 4.70753700e-01f, 1.54802993e-01f, -3.61458100e-02f, -1.21312529e-01f, 1.92395881e-01f, -3.21231447e-02f,
  4.27661836e-01f, -5.71656108e-01f, -2.75683433e-01f, -7.99984932e-02f, 2.24157628e-02f, -2.39318460e-02f, -6.02108426e-02f, -2.93255839e-02f, 7.63905644e-02f, -8.09894577e-02f,
  -1.11560815e-03f, -1.34619161e-01f, 1.46928474e-01f, -4.89065163e-02f, 5.96715622e-02f, -2.92284966e-01f, 6.34504557e-02f, 1.96913127e-02f, -1.17863275e-01f, 2.02522621e-01f,
  -2.09596977e-01f, 1.10648252e-01f, 1.49275064e-01f, -2.58650452e-01f, 1.91806424e-02f, 2.67994329e-02f, -8.17389116e-02f, -1.15281351e-01f, -9.21467692e-02f, -2.41836101e-01f,
  -3.55603725e-01f, -5.87262027e-02f, -2.29978025e-01f, -5.35602570e-01f, 2.23385081e-01f, 1.33837402e-01f, 1.05204299e-01f, -1.47654071e-01f, -6.63932338e-02f, 4.20079470e-01f,
  2.06124976e-01f, -3.99198472e-01f, 1.32227570e-01f, -2.13365063e-01f, -2.43987575e-01f, 8.72698054e-02f, 8.50832164e-02f, -1.31306708e-01f, -4.36168462e-02f, -3.07467788e-01f,
  2.66137689e-01f, 7.54027590e-02f, 1.37869507e-01f, 3.80845815e-02f, -5.73673397e-02f, -2.86538508e-02f, -5.86076416e-02f, 3.61115515e-01f, -5.06838202e-01f, 1.36341467e-01f,
  4.09829438e-01f, -1.49604633e-01f, -1.89063817e-01f, 6.13636449e-02f, 2.25057498e-01f, 2.77584881e-01f, -2.45757356e-01f, -5.88781536e-02f, -7.94739202e-02f, -2.48947948e-01f,
  1.16153188e-01f, 2.15645544e-02f, 1.98199004e-01f, 3.20333660e-01f, -5.52979670e-02f, -1.54938266e-01f, 1.23794220e-01f, -8.40398669e-02f, -9.91611369e-03f, 1.18908733e-01f,
  -5.42419292e-02f, 1.40822798e-01f, -2.92198472e-02f, -3.65252085e-02f, 8.58221874e-02f, -7.64096454e-02f, -1.95255265e-01f, -8.07765201e-02f, -4.34343703e-02f, 1.08589008e-01f,
  -1.24780230e-01f, 1.22206010e-01f, -1.97335571e-01f, 2.26158410e-01f, -2.47869417e-02f, 5.43896556e-02f, 1.07890934e-01f, -1.33069336e-01f, 5.29418103e-02f, 4.36725914e-01f,
  -2.57077783e-01f, -2.58749783e-01f, 1.56781659e-01f, 1.93391398e-01f, -1.25131205e-01f, 3.69888276e-01f, -4.46363054e-02f, -1.80074677e-01f, 2.71083355e-01f, -3.56778413e-01f,
  1.65590182e-01f, -1.12080187e-01f, -9.78356507e-03f, -1.45394847e-01f, -1.50197417e-01f, 2.52449811e-01f, -1.13992326e-01f, -1.24473805e-02f, 1.19082138e-01f, 1.04251929e-01f,
  -1.62211120e-01f, 1.20349951e-01f, -2.30979294e-01f, -1.07078210e-01f, 2.53528357e-01f, 4.05838750e-02f, -2.61766374e-01f, 2.48434439e-01f, 7.20950365e-02f, 5.74388266e-01f,
  2.22033143e-01f, -3.85577232e-02f, 7.95858726e-02f, 9.21216011e-02f, 2.47516036e-02f, 3.26015800e-02f, -1.44958647e-03f, -9.06526968e-02f, 6.27710745e-02f, -1.43845677e-01f,
  7.70825967e-02f, 1.82542950e-02f, -8.93205777e-02f, 4.19794828e-01f, 1.16108051e-02f, 1.90554008e-01f, 1.10490017e-01f, -2.02342287e-01f, 2.60482848e-01f, -1.16158418e-01f,
  -1.42813346e-03f, -6.37780726e-02f, -1.52157918e-01f, -4.08923849e-02f, 1.66007251e-01f, -2.23759949e-01f, 8.30481425e-02f, 1.71211109e-01f, -2.05796342e-02f, 1.11028470e-01f,
  8.42109397e-02f, 1.87584862e-01f, -2.69685686e-01f, -4.51949596e-01f, -1.71820432e-01f, -2.68736273e-01f, 1.64402723e-01f, -2.11499318e-01f, 1.16183549e-01f, -1.83283508e-01f,
  -2.32352301e-01f, 1.04561448e-01f, -3.11783217e-02f, -3.22349429e-01f, -3.04689676e-01f, -4.10346799e-02f, -7.14352950e-02f, 5.69141686e-01f, -1.32260448e-03f, 3.07759821e-01f,
  -3.48691314e-01f, 1.14157796e-01f, -2.99166236e-02f, 2.50204317e-02f, -3.36611152e-01f, -5.97666383e-01f, 1.08053349e-01f, 2.19947353e-01f, 6.35580838e-01f, -1.38104051e-01f,
  -7.29545504e-02f, -4.44397368e-02f, -3.78916442e-01f, -2.23883197e-01f, -5.07358789e-01f, -8.21019635e-02f, -1.04161790e-02f, 2.77301192e-01f, 6.55572191e-02f, -1.89535424e-01f,
  -1.62651956e-01f, 2.88282424e-01f, -6.33713454e-02f, -7.61500150e-02f, 7.75644183e-02f, -4.93550636e-02f, 1.45006195e-01f, -3.20091516e-01f, 2.60350615e-01f, 1.55013666e-01f,
  2.60638297e-01f, 4.08215731e-01f, 1.92861483e-01f, 2.50539690e-01f, 3.09161663e-01f, 2.86532611e-01f, 6.56518340e-02f, 2.24074692e-01f, 1.64373383e-01f, 2.78744400e-01f,
  3.70160609e-01f, 1.68281510e-01f, 1.21487137e-02f, -1.22046374e-01f, -1.05498895e-01f, 2.01093592e-02f, -1.41919330e-01f, -3.26810172e-03f, -2.26836115e-01f, 1.47942916e-01f,
  -3.06444038e-02f, 1.15976319e-01f, -9.24995840e-02f, 1.47335187e-01f, 1.80772498e-01f, 1.14729732e-01f, -5.89425676e-02f, 2.54646927e-01f, -3.54532987e-01f, -1.52451873e-01f,
  1.67108029e-01f, 1.25657329e-02f, -2.97433555e-01f, -2.13182732e-01f, 5.86543500e-01f, -4.56889570e-02f, 9.54508856e-02f, -5.32976873e-02f, 1.50544539e-01f, 5.66095300e-02f,
  4.76634592e-01f, -2.24639222e-01f, -3.54938775e-01f, -2.28527352e-01f, 7.02795163e-02f, -3.65715623e-02f, -2.03511015e-01f, -1.42780960e-01f, -3.39571089e-01f, 5.82352430e-02f,
  1.07391536e-01f, 3.62996161e-01f, -4.80472036e-02f, -1.16851598e-01f, -1.71805710e-01f, -3.46008033e-01f, -5.78777120e-02f, 1.19119152e-01f, 1.88434243e-01f, 7.56044537e-02f,
  1.81167632e-01f, -1.50310586e-03f, 1.25069752e-01f, -8.01683664e-02f, 1.56924307e-01f, -1.28921643e-02f, -2.79469699e-01f, -3.65721554e-01f, -1.09757587e-01f, 2.78749168e-01f,
  5.88141009e-02f, -4.08922732e-02f, 1.18654780e-01f, 5.32696247e-02f, 1.14543214e-01f, 3.60129505e-01f, 1.21440040e-02f, 1.53230220e-01f, 3.28320175e-01f, -1.36719588e-02f,
  -1.49961218e-01f, -3.58828157e-01f, -6.45775199e-02f, -1.80571392e-01f, 3.26363534e-01f, -3.25971493e-03f, -4.25949544e-01f, 4.74825442e-01f, 1.42565658e-02f, -7.08158035e-03f,
  -4.39562723e-02f, -2.16933176e-01f, -4.49959815e-01f, -1.13799721e-01f, 8.99524912e-02f, 1.86513931e-01f, -1.24595895e-01f, -1.55666053e-01f, -4.39103961e-01f, -4.17144485e-02f,
  -8.41772333e-02f, 1.89573746e-02f, -2.28481695e-01f, -3.73863459e-01f, -8.28550756e-02f, -1.89013317e-01f, -6.54444635e-01f, 4.13772523e-01f, -3.08397226e-02f, -4.73700851e-01f,
  -1.27526358e-01f, 3.42567086e-01f, 5.95693350e-01f, -7.90648088e-02f, -3.13636325e-02f, 1.58041567e-01f, -1.72381029e-02f, 4.54221398e-01f, 1.45642594e-01f, -3.07632864e-01f,
  -2.17195041e-02f, -1.35939956e-01f, -1.55464500e-01f, -1.64494693e-01f, 7.57099828e-04f, 4.10490036e-01f, 2.26915821e-01f, 3.11729491e-01f, 4.89128567e-02f, 1.85741484e-01f,
  -1.93654686e-01f, 4.42274183e-01f, 2.07764417e-01f, 4.53250676e-01f, -1.05596662e-01f, 7.91074932e-02f, 4.72072251e-02f, 2.05798343e-01f, 2.69591480e-01f, -8.37135315e-02f,
  -2.75065213e-01f, -3.27853300e-02f, -3.04119051e-01f, 2.16837917e-02f, 2.60194466e-02f, -2.77357727e-01f, -2.21193492e-01f, -1.55795023e-01f, 2.91568581e-02f, -3.13828379e-01f,
  9.16248336e-02f, -4.89234328e-01f, -2.29964796e-02f, -1.45588294e-01f, -3.07890058e-01f, 1.54840544e-01f, 2.83495575e-01f, -3.39575857e-01f, -7.85144940e-02f, 1.17647462e-01f,
  1.63830236e-01f, 2.84840316e-01f, 4.48318481e-01f, 6.68674856e-02f, 3.50097939e-02f, 8.11409131e-02f, -3.13769221e-01f, 9.13418643e-03f, 1.81763664e-01f, 1.22665547e-01f,
  6.18355930e-01f, -2.99467295e-01f, -1.81751296e-01f, 5.88047467e-02f, -1.25117749e-01f, -3.06693852e-01f, -4.06087846e-01f, 9.54349488e-02f, -3.15984264e-02f, 5.44363968e-02f,
  -9.78046805e-02f, 5.45335710e-02f, -3.42661053e-01f, 2.54918754e-01f, -3.76348235e-02f, -4.09285128e-02f, 5.42890020e-02f, 1.11687779e-01f, 1.71637274e-02f, -3.78067911e-01f,
  -9.03491154e-02f, 3.50270979e-02f, -1.30118102e-01f, -3.20987660e-03f, -1.24062367e-01f, 1.27541244e-01f, 1.25250276e-02f, -3.76672238e-01f, 1.03279829e-01f, -8.55067819e-02f,
  -2.37559363e-01f, 3.94076146e-02f, -2.31820494e-01f, -1.50060505e-01f, 1.99814662e-01f, 6.85784519e-02f, 3.17375660e-01f, 1.97882459e-01f, 2.31012806e-01f, 2.40598872e-01f,
  3.34799439e-01f, 3.50884527e-01f, -1.97550654e-01f, 2.72248536e-01f, -3.92562523e-02f, 2.81894833e-01f, -1.06260061e-01f, 3.28849256e-02f, 1.28004337e-02f, 7.39558637e-02f,
  2.62799412e-01f, -8.81573781e-02f, 2.22795308e-02f, -4.80491281e-01f, 2.87851840e-01f, -1.44437209e-01f, -2.08932802e-01f, -2.58963145e-02f, -6.32526949e-02f, 7.75999352e-02f,
  1.50061874e-02f, 2.48407815e-02f, 4.97948676e-01f, 2.81320184e-01f, -5.18316925e-01f, 7.47726532e-03f, -3.06797456e-02f, -1.34232834e-01f, 4.55048960e-03f, -2.74697274e-01f,
  4.16495860e-01f, 9.49874148e-02f, -5.59165888e-02f, 1.13166697e-01f, -5.38338535e-02f, 5.56246415e-02f, 5.83283663e-01f, -3.57156992e-01f, 8.56714994e-02f, -1.57368660e-01f,
  -1.04408398e-01f, -1.59958992e-02f, -1.61206037e-01f, -8.01521689e-02f, 8.62692669e-03f, 4.74857353e-02f, -2.68935971e-03f, -1.20139621e-01f, 3.69390845e-02f, -1.39536649e-01f,
  -3.05954576e-01f, -4.18328568e-02f, -9.80669353e-03f, 8.99737552e-02f, 8.07175785e-02f, -3.39119047e-01f, 6.59961030e-02f, 2.69148946e-01f, -2.51036108e-01f, 1.42333165e-01f,
  1.87189892e-01f, 3.02087486e-01f, -1.93809390e-01f, -3.78174782e-01f, -1.84116930e-01f, -2.21042231e-01f, 5.90883866e-02f, -3.88593435e-01f, 2.85890866e-02f, 8.29798952e-02f,
  -1.32348746e-01f, 7.85781723e-03f, -2.06494570e-01f, 5.42791560e-02f, -4.13428038e-01f, 2.12288871e-01f, 9.50497836e-02f, 6.90204859e-01f, -2.26490572e-01f, -1.51018098e-01f,
  -5.30273020e-01f, 6.74367696e-02f, -2.18316372e-02f, -8.08601826e-02f, 2.65316933e-01f, -3.09667885e-01f, -2.86445588e-01f, 2.56555319e-01f, -2.44374111e-01f, 4.37076658e-01f,
  1.74959674e-01f, 2.39662096e-01f, -1.98421150e-01f, 7.01357275e-02f, 2.33719587e-01f, -9.43007097e-02f, -8.71692300e-02f, 2.34984770e-01f, -1.03627548e-01f, 1.61665395e-01f,
  -3.95375848e-01f, 1.09210894e-01f, -1.22190900e-02f, 7.20154122e-02f, 6.72459602e-02f, -2.86026369e-03f, -1.12376243e-01f, -1.12636961e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.12985477e-01f, 5.13227582e-02f, -5.59221953e-02f, -7.30986521e-02f, -1.20120265e-01f, 2.41994653e-02f, 1.95069924e-01f, 1.09337427e-01f, 9.51076895e-02f, 1.20190859e-01f,
  8.93501565e-02f, -3.66094075e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    