/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.00644760e-01f, 3.47952102e-03f, 7.77674373e-03f, 1.36195188e-02f, 8.46558437e-02f, 4.10330556e-02f, -2.95398962e-02f, -7.27452263e-02f, -5.68112582e-02f, -7.98938200e-02f,
  -7.29933195e-03f, -9.22094882e-02f, -1.72175299e-02f, 4.40625846e-02f, -2.09056120e-02f, -1.23807728e-01f, -1.87767632e-02f, -5.16209640e-02f, -3.31258588e-02f, -5.26877046e-02f,
  1.08715510e-02f, 5.67220189e-02f, -6.85762390e-02f, 6.20552003e-02f, 1.15256712e-01f, -7.71861582e-04f, 3.26509885e-02f, 7.97086880e-02f, 4.77114841e-02f, 2.85760444e-02f,
  3.94445807e-02f, -3.43903378e-02f, 2.14754902e-02f, 7.55925551e-02f, -1.75570957e-02f, 6.78246394e-02f, -1.36218255e-03f, 3.30599025e-02f, 3.87374721e-02f, -2.08451077e-02f,
  -1.87060926e-02f, 3.17914523e-02f, 8.46807882e-02f, -4.20697331e-02f, -1.88219622e-02f, -6.38724789e-02f, 8.45847428e-02f, 2.72230944e-04f, 1.47132305e-02f, 1.79515667e-02f,
  -5.48225716e-02f, -6.44748146e-03f, -2.66775396e-02f, -6.73659742e-02f, -2.11932492e-02f, 4.07531895e-02f, -1.72240939e-02f, -4.14654501e-02f, 2.68264599e-02f, -2.89471000e-02f,
  -1.19892359e-01f, -4.89910059e-02f, 9.92696956e-02f, 8.72384384e-02f, 6.13913983e-02f, 3.58597152e-02f, 4.76696454e-02f, 1.19736968e-02f, -1.05517814e-02f, -1.16306171e-02f,
  5.77379717e-03f, 6.90271799e-03f, -3.33748981e-02f, 7.02778473e-02f, 8.60271789e-03f, 1.05364667e-02f, 2.06467696e-02f, -1.30944671e-02f, -6.19305717e-03f, -3.19788158e-02f,
  -5.16324975e-02f, -4.30814102e-02f, -7.73488544e-03f, -3.95390391e-02f, -1.74338110e-02f, -8.94757584e-02f, 2.35622339e-02f, -3.02676968e-02f, -7.32181594e-02f, 2.42937803e-02f,
  9.48326439e-02f, 2.85932571e-02f, 6.29919907e-03f, -2.66401060e-02f, 7.06591606e-02f, -1.53838415e-02f, 2.34954096e-02f, -6.89206719e-02f, 2.10351441e-02f, -2.14003790e-02f,
  2.88779270e-02f, 5.92782386e-02f, 9.13322717e-03f, 1.40070850e-02f, 3.53455991e-02f, -1.73096191e-02f, -6.25212267e-02f, -2.21490432e-02f, -3.63933109e-02f, 3.66014466e-02f,
  4.12826315e-02f, -1.60534848e-02f, -1.25567177e-02f, 7.65729398e-02f, -9.97521132e-02f, -5.71124330e-02f, 1.63135082e-02f, -3.88824567e-02f, -3.17343138e-02f, 2.27942392e-02f,
  -1.98266625e-01f, -2.11112857e-01f, 9.75010172e-02f, 5.07175103e-02f, -8.12546462e-02f, -2.83767078e-02f, 2.30378527e-02f, -1.76776260e-01f, -1.39811203e-01f, -7.38928020e-02f,
  -3.44360620e-02f, 9.31154266e-02f, -2.73295268e-02f, 4.55507226e-02f, 1.30486354e-01f, -2.96379719e-02f, -7.68621787e-02f, -4.49580625e-02f, -4.71285097e-02f, -1.27643868e-01f,
  -2.43353005e-02f, 3.42784189e-02f, 1.77088469e-01f, -7.18663186e-02f, -3.77453007e-02f, -7.23180473e-02f, 1.49305305e-02f, 2.50944495e-02f, 2.90352143e-02f, 9.66782682e-03f,
  7.67235011e-02f, 1.78467091e-02f, 7.66175240e-02f, -6.99323788e-02f, 1.32838788e-03f, -2.28970945e-02f, -1.51007688e-02f, 2.48224568e-02f, 4.20042127e-02f, 1.24263065e-02f,
  1.02079939e-02f, 1.88410804e-02f, -5.21408813e-03f, -4.40485962e-02f, -1.05587812e-02f, -2.00317781e-02f, 4.06852886e-02f, 6.10275045e-02f, 3.48788016e-02f, 7.01200739e-02f,
  1.89779326e-02f, 1.35614751e-02f, 1.99663248e-02f, -1.61254518e-02f, 2.17250045e-02f, 1.95679050e-02f, 6.64196461e-02f, 1.07213678e-02f, 4.45076078e-02f, -4.73855212e-02f,
  -3.67725454e-02f, -6.91621676e-02f, 3.16685922e-02f, -5.75122144e-03f, 8.19664001e-02f, 5.66013483e-03f, 3.51846358e-03f, 1.03360742e-01f, -2.50517558e-02f, -7.94153288e-03f,
  -1.32562984e-02f, 9.11122635e-02f, -3.39935943e-02f, -3.11874524e-02f, -4.41382825e-02f, 3.74482609e-02f, 7.60186650e-03f, -5.07199802e-02f, -1.05046913e-01f, 4.32674773e-02f,
  -1.82389058e-02f, -5.56616262e-02f, -3.40922317e-03f, 2.91236229e-02f, 4.32951795e-03f, 5.70262261e-02f, -6.27313107e-02f, -9.18929523e-04f, 2.27526240e-02f, -1.96077917e-02f,
  -3.72332066e-01f, -1.66486830e-01f, 2.14698855e-02f, 2.67751329e-02f, 1.46000618e-02f, -4.07093344e-03f, -4.74669673e-02f, -4.73111384e-02f, -1.10605419e-01f, -6.95478823e-03f,
  -8.03913996e-02f, 8.25742073e-03f, -9.87585932e-02f, -2.72594448e-02f, -3.58465506e-04f, -6.30854396e-03f, 3.58827859e-02f, -6.10134602e-02f, 2.43831258e-02f, -2.79399026e-02f,
  -2.08257418e-02f, -3.23256454e-03f, -2.83748955e-02f, -5.18332468e-03f, -3.77186537e-02f, 1.24954795e-02f, -8.62568691e-02f, -1.04996962e-02f, 1.61042549e-02f, -2.04225536e-02f,
  -7.88582742e-01f, 8.08426142e-02f, 1.01527996e-01f, -1.29594192e-01f, -1.91478610e-01f, 1.38884699e-02f, 2.07080767e-01f, -4.83772680e-02f, 1.84863489e-02f, 1.34589672e-01f,
  1.13262884e-01f, 3.76713066e-03f, 1.59736365e-01f, 5.81892654e-02f, -5.26639707e-02f, 6.37191236e-02f, -3.61035690e-02f, -9.47042480e-02f, 3.57454941e-02f, -1.72625277e-02f,
  -9.56777707e-02f, -2.18017343e-02f, 7.77191073e-02f, -6.35951236e-02f, -3.14546451e-02f, -3.00770365e-02f, -7.51983188e-03f, 5.23799509e-02f, -5.69925942e-02f, -2.67205760e-02f,
  -5.12674861e-02f, -5.79085164e-02f, 2.18150541e-02f, 6.51358739e-02f, -1.55253513e-02f, 3.49778682e-02f, -2.36299308e-03f, -1.76031818e-03f, -2.29745805e-02f, -7.99962413e-03f,
  -3.47839762e-03f, -4.01985049e-02f, -1.16826585e-02f, -4.14091200e-02f, 4.71428595e-02f, 2.53169686e-02f, 5.20923315e-03f, 8.56589675e-02f, 5.35986684e-02f, 1.42066628e-02f,
  8.48321170e-02f, -2.31041089e-02f, -3.53852869e-03f, 3.19306776e-02f, 1.22447554e-02f, 2.09202282e-02f, 3.45396958e-02f, -5.03617898e-02f, -2.96086967e-02f, -6.23576567e-02f,
  1.84361171e-02f, -8.98654480e-03f, 4.70474809e-02f, 3.60792577e-02f, 1.40912244e-02f, -2.43071672e-02f, 2.08283272e-02f, -1.69011578e-02f, 1.02962246e-02f, -8.89587030e-03f,
  -3.13257165e-02f, 5.94039774e-03f, -2.21045315e-02f, 3.14048231e-02f, -4.18544039e-02f, 1.46271754e-03f, -3.31393369e-02f, 5.23798401e-03f, -7.88772665e-03f, 3.17929010e-03f,
  -3.47086117e-02f, 5.94477467e-02f, -3.62220146e-02f, 2.67418902e-02f, -1.55898673e-03f, -1.64874755e-02f, 2.79846154e-02f, 3.48842703e-02f, 5.82498498e-02f, 3.27131562e-02f,
  6.67126253e-02f, 5.65216690e-02f, -2.40986962e-02f, -1.15586845e-02f, 2.03548484e-02f, -4.01223451e-03f, -1.41684562e-02f, 1.12566408e-02f, 3.18965465e-02f, 4.01918143e-02f,
  -6.44297758e-03f, -3.09900120e-02f, -4.76503521e-02f, 5.17952777e-02f, -2.29203645e-02f, 2.49394998e-02f, 6.00748695e-03f, -2.85980720e-02f, -5.35263121e-02f, 4.75695543e-03f,
  -9.30414163e-03f, -1.60829499e-02f, 1.33305194e-03f, -6.15778007e-02f, -5.00065982e-02f, 9.77358501e-03f, -5.53829633e-02f, 1.33005856e-02f, -7.40122749e-03f, 3.12209092e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.48052499e-01f, 6.38335720e-02f, -1.36386603e-01f, -4.47765179e-02f, -5.00110686e-02f, -6.32482022e-02f, -6.92928806e-02f, -3.64510529e-02f, -1.90400019e-01f, -1.05544634e-01f,
  -4.83535044e-02f, -1.01319976e-01f, 3.22757885e-02f, 8.67685024e-03f, 9.05571505e-02f, -2.74077095e-02f, -4.95155081e-02f, 6.41409606e-02f, 1.31036997e-01f, 3.83272059e-02f,
  9.75020453e-02f, 2.61956695e-02f, -2.60540331e-03f, 1.71809644e-01f, -7.99541920e-02f, 3.31401974e-02f, 4.48745750e-02f, 5.01261353e-02f, -1.72764771e-02f, -1.15434378e-01f,
  -2.37773210e-02f, -4.49633785e-02f, -7.29344506e-03f, -4.90812324e-02f, -9.41024497e-02f, -1.94275044e-02f, 1.42892646e-02f, 5.86412475e-02f, -1.11041684e-02f, -2.99717411e-02f,
  8.50779470e-03f, -5.41968830e-03f, -8.23008195e-02f, 1.00154668e-01f, -4.38325293e-02f, 7.48355116e-04f, 8.58518779e-02f, -4.51247171e-02f, 2.13821195e-02f, 5.90310916e-02f,
  1.20654501e-01f, 1.13168567e-01f, -2.97330879e-02f, -7.18118697e-02f, -6.48679733e-02f, 4.03029546e-02f, -8.04597363e-02f, -5.55847120e-03f, 9.73818526e-02f, 6.21515885e-02f,
  -5.35156159e-03f, -2.16217488e-02f, 6.44240808e-03f, 3.33499094e-03f, 2.48593166e-02f, 2.18877755e-02f, 1.06590763e-02f, -1.14845652e-02f, 8.28883722e-02f, -2.76914537e-02f,
  2.57747038e-03f, -4.78548296e-02f, -7.85463303e-02f, 2.42590737e-02f, -2.35666372e-02f, -5.90050071e-02f, 5.64357899e-02f, -1.88806653e-02f, -8.00392404e-03f, 9.22080781e-03f,
  9.02275592e-02f, 1.63641963e-02f, 2.07711589e-02f, -6.20747656e-02f, 7.26132840e-02f, 9.79050323e-02f, -6.36682883e-02f, 7.03953132e-02f, 5.59618045e-03f, -2.37307604e-02f,
  -7.52865598e-02f, -5.82676753e-02f, -5.12609258e-02f, 1.06244180e-02f, -4.19457722e-03f, 1.21060684e-01f, 1.55538553e-02f, 1.18713826e-02f, -7.53638968e-02f, 7.00616390e-02f,
  4.15499182e-03f, -4.72919606e-02f, 1.01518072e-01f, -8.68434645e-03f, 1.09174021e-01f, 1.34200091e-02f, -2.86281686e-02f, 4.67794351e-02f, 6.80360049e-02f, -3.10355760e-02f,
  1.37358429e-02f, -3.89169790e-02f, -5.94094722e-03f, -7.86028504e-02f, -5.31502403e-02f, -2.79765222e-02f, -6.22473322e-02f, 4.52475995e-02f, -1.85591895e-02f, 3.75298075e-02f,
  7.91420564e-02f, 4.42154929e-02f, 2.12842703e-01f, 2.23097742e-01f, -5.04694805e-02f, 5.80157861e-02f, 2.72035636e-02f, 5.26606105e-02f, 2.96550632e-01f, 3.24102747e-03f,
  -1.61038727e-01f, 1.06201194e-01f, 1.54090417e-03f, 1.13061458e-01f, 5.53862453e-02f, 7.45177194e-02f, 1.29503891e-01f, 6.91194087e-02f, 1.18998513e-01f, -2.42717518e-03f,
  -7.25991698e-03f, -6.08251356e-02f, 9.04780552e-02f, 1.85081307e-02f, -3.80967837e-03f, -1.46850161e-02f, -1.72393501e-01f, 3.16198741e-04f, -5.19929826e-02f, -8.40936676e-02f,
  -1.01873465e-01f, 4.09128815e-02f, -3.13963294e-02f, 7.10873008e-02f, 6.23982735e-02f, 3.34623866e-02f, 6.72695786e-02f, 6.40185177e-02f, 1.06763951e-01f, 4.51796055e-02f,
  9.21369437e-03f, -5.10964990e-02f, 6.50321916e-02f, -5.04123643e-02f, 4.14458476e-02f, -6.70772605e-03f, 3.76289152e-02f, 4.72439639e-02f, 4.84951492e-03f, -2.59264037e-02f,
  1.05733043e-02f, -8.86900127e-02f, 5.06726764e-02f, 7.10145384e-02f, 1.95348635e-02f, 9.03868377e-02f, 8.02214071e-02f, -3.99095230e-02f, -3.85507904e-02f, 4.53358740e-02f,
  6.46802932e-02f, 1.02598332e-01f, 2.48060841e-02f, 6.26355708e-02f, 2.09107492e-02f, -5.14651127e-02f, -3.17037641e-03f, -5.19037582e-02f, 7.76349846e-03f, -3.30519527e-02f,
  -8.89215097e-02f, 1.01360530e-02f, -1.11591229e-02f, 7.36388043e-02f, -1.62360054e-02f, 2.43563801e-02f, 5.73525690e-02f, -3.43457684e-02f, -3.74357849e-02f, 1.51027655e-02f,
  -5.94697334e-02f, 7.07227318e-03f, -7.74007514e-02f, 3.79803032e-02f, -2.69734510e-03f, -9.66022070e-03f, -8.68987367e-02f, -6.02844693e-02f, 6.06604666e-02f, -2.27942355e-02f,
  -8.92282575e-02f, 9.10158232e-02f, 2.35294234e-02f, 2.34903358e-02f, -4.89345156e-02f, 1.37039674e-02f, 4.15685400e-02f, -3.34087983e-02f, 7.86228701e-02f, 6.27679378e-02f,
  -1.16112772e-02f, 1.09004162e-01f, 1.45475538e-02f, -3.75329964e-02f, 1.28357857e-02f, -2.20878702e-02f, 3.01992241e-02f, -2.87943594e-02f, 9.04168487e-02f, 3.53176594e-02f,
  -3.11138630e-02f, 7.37998337e-02f, -3.18757333e-02f, -5.73016852e-02f, -2.90959664e-02f, -3.80024388e-02f, 4.59936857e-02f, 7.13929534e-02f, 5.30159473e-02f, 5.96915632e-02f,
  3.80734587e-03f, -2.64787511e-03f, -2.11934641e-01f, 2.19074800e-03f, -5.26695326e-02f, 8.67423695e-03f, -1.83808133e-01f, 6.26056269e-02f, -3.04822885e-02f, 4.57280725e-02f,
  1.92920372e-01f, -3.70221492e-03f, -3.09140179e-02f, 4.79198843e-02f, 1.14861600e-01f, -6.13961816e-02f, 1.21202998e-01f, 1.19142883e-01f, -4.15058807e-03f, 3.03716250e-02f,
  2.73401961e-02f, 2.36827061e-01f, -7.74705261e-02f, 1.48614421e-01f, 1.32653445e-01f, 7.97821432e-02f, 1.99035391e-01f, -1.39972746e-01f, 2.33580902e-01f, -1.43796075e-02f,
  3.00412681e-02f, 7.00684413e-02f, -1.41903535e-02f, -3.98475863e-02f, 1.01402782e-01f, -8.56387522e-03f, 5.91449477e-02f, -8.26202780e-02f, -1.26116350e-01f, -6.20279759e-02f,
  5.23353145e-02f, -3.19415121e-03f, 4.78479406e-03f, 2.79166885e-02f, 6.02252930e-02f, -3.92261371e-02f, -5.71773015e-02f, -6.17196858e-02f, -8.90577659e-02f, -5.84721528e-02f,
  -6.68562353e-02f, 1.18223689e-02f, 9.15722102e-02f, 3.16174068e-02f, -6.17975704e-02f, 2.62404587e-02f, -1.53852841e-02f, -2.01482493e-02f, 1.08237706e-01f, -4.13208045e-02f,
  5.60808480e-02f, 5.34892753e-02f, -3.85337584e-02f, -5.87280355e-02f, 1.89504039e-03f, 9.39537305e-03f, -3.56323011e-02f, -8.26483145e-02f, -4.09107506e-02f, -4.63217590e-03f,
  -5.15317135e-02f, -6.64698556e-02f, -1.58521961e-02f, 3.95525396e-02f, 7.68645778e-02f, -5.82040213e-02f, 4.77016307e-02f, 3.34001034e-02f, -6.02179356e-02f, -2.36633681e-02f,
  3.69865857e-02f, -4.13661934e-02f, -3.79041694e-02f, 8.01087692e-02f, -6.26212638e-03f, -4.91621811e-03f, 9.46218818e-02f, -7.34727783e-03f, 1.84244718e-02f, 4.84836735e-02f,
  9.14187133e-02f, 1.35111496e-01f, -4.66068611e-02f, 6.28604665e-02f, 2.88447961e-02f, 2.98573710e-02f, 4.04326022e-02f, 4.87953164e-02f, 1.51922135e-02f, 2.53231041e-02f,
  1.06467724e-01f, -1.62245240e-02f, 2.68789753e-02f, 4.49512042e-02f, -3.80073972e-02f, 9.92274061e-02f, 9.08885747e-02f, -7.57732149e-03f, 6.80481941e-02f, 4.20644954e-02f,
  2.21618060e-02f, -2.47927755e-02f, 5.84912524e-02f, -2.13833842e-02f, -2.83145383e-02f, 1.04525611e-01f, 2.21642060e-03f, 7.75806280e-03f, 6.07260391e-02f, 9.65274498e-02f,
  6.09549470e-02f, 1.54745325e-01f, 8.77401382e-02f, 1.27370253e-01f, -1.52715921e-01f, -2.39639089e-01f, -1.42684877e-01f, -5.00853956e-02f, 2.83700339e-02f, -8.22065473e-02f,
  -4.84004132e-02f, 1.25533551e-01f, 5.13244383e-02f, 1.17490329e-01f, -2.92049646e-02f, -1.96539820e-03f, 1.35073587e-02f, 5.48817068e-02f, 5.65438829e-02f, -1.44413514e-02f,
  7.62708187e-02f, 2.01640632e-02f, 1.91043034e-01f, 8.26924592e-02f, 4.33393605e-02f, 3.07672601e-02f, 9.81550515e-02f, -5.21228798e-02f, 2.58087963e-02f, 5.70816956e-02f,
  -2.00235238e-03f, 1.13814458e-01f, 1.21680625e-01f, -2.66543962e-02f, 4.11373451e-02f, -1.51999819e-04f, 4.49052937e-02f, -4.33892384e-02f, 1.06517255e-01f, 4.32262756e-02f,
  2.16210596e-02f, -4.60854694e-02f, -8.90861899e-02f, 4.08644825e-02f, 4.76159267e-02f, -6.41816631e-02f, 2.94092856e-02f, -2.39110515e-02f, 5.60063906e-02f, -2.31186263e-02f,
  -2.75610890e-02f, 5.80194825e-03f, -5.75892217e-02f, 7.67814666e-02f, 8.74228477e-02f, 9.43385139e-02f, -2.24027578e-02f, 9.67401490e-02f, 9.15321335e-02f, -4.53396104e-02f,
  5.59340464e-03f, -2.90364008e-02f, -1.26763238e-02f, -1.76700354e-02f, -6.98103681e-02f, 6.23467676e-02f, 3.67246456e-02f, -9.44189448e-03f, -2.64251195e-02f, 4.37809564e-02f,
  -5.16690798e-02f, 2.49320809e-02f, -7.72185847e-02f, 1.85735393e-02f, -2.20448207e-02f, 7.45040998e-02f, -4.40478139e-03f, -1.05210565e-01f, 4.25241776e-02f, -1.64575893e-02f,
  -4.17784788e-02f, -6.23985976e-02f, 5.94153889e-02f, -6.78292513e-02f, 3.20209935e-02f, -9.22782645e-02f, -1.38658248e-02f, 2.43169740e-02f, -5.06161600e-02f, 3.42682526e-02f,
  1.46521196e-01f, 1.06383860e-01f, 4.39049639e-02f, 3.72146405e-02f, -3.12902369e-02f, 2.38632429e-02f, -8.16069916e-03f, 4.16837372e-02f, -2.43390705e-02f, -7.71944970e-02f,
  2.75931470e-02f, -3.94232161e-02f, 1.48589360e-02f, -6.65717619e-03f, -3.03504039e-02f, 5.60791306e-02f, 2.84951404e-02f, 2.92321481e-02f, 1.05370544e-01f, -3.57829444e-02f,
  -1.80972759e-02f, -1.17165074e-02f, -1.32889226e-02f, -6.00568578e-02f, 7.15836585e-02f, 3.33152674e-02f, -7.12871179e-02f, 1.79094169e-03f, 1.67818367e-03f, 1.16965607e-01f,
  3.11501592e-01f, -8.69038105e-02f, 2.22970486e-01f, 4.06364173e-01f, 7.65201896e-02f, 6.52983040e-02f, 1.38715148e-01f, 1.36615604e-01f, 2.47999206e-01f, -2.23758891e-01f,
  -1.13165583e-02f, -8.83422717e-02f, 2.21259035e-02f, 1.28161192e-01f, -3.27722877e-02f, -5.38568199e-03f, 8.49329457e-02f, 5.28851412e-02f, 7.42980912e-02f, 6.95934594e-02f,
  1.18865371e-01f, -1.58413142e-01f, 1.13443449e-01f, -2.03515947e-01f, 1.82927456e-02f, -9.77833383e-03f, -1.55817494e-01f, -2.26562545e-02f, -1.09984942e-01f, -1.50455475e-01f,
  -1.12612419e-01f, 9.09312591e-02f, -8.49732105e-03f, -5.26696071e-03f, 7.03635737e-02f, 4.24181260e-02f, -7.01019391e-02f, -2.63081603e-02f, -5.29867038e-02f, -5.09047881e-02f,
  2.02709213e-02f, -1.12738021e-01f, -5.65986075e-02f, -2.62220148e-02f, 5.61633743e-02f, -2.73506436e-02f, 6.27987385e-02f, 4.67369482e-02f, 3.16437222e-02f, 8.45221356e-02f,
  9.93871465e-02f, 6.90217223e-03f, -2.15567742e-02f, -1.72588527e-01f, -1.15620103e-02f, -1.40642608e-02f, -8.30189139e-02f, -9.35028419e-02f, -6.83761165e-02f, -7.44189993e-02f,
  -6.23199949e-03f, -2.98085995e-02f, 3.61152962e-02f, 5.25994040e-02f, 3.95292789e-02f, 5.91255091e-02f, 4.62047867e-02f, -4.98399511e-03f, 8.53265375e-02f, 1.32700102e-02f,
  8.45065154e-03f, -2.92643849e-02f, -1.03234425e-02f, 1.02039184e-02f, -2.15986110e-02f, 7.67135024e-02f, -8.26307833e-02f, 5.04356101e-02f, 9.19592287e-03f, 5.56477122e-02f,
  -1.12190405e-02f, 7.26091936e-02f, -1.65104531e-02f, -9.31276754e-03f, -1.83532536e-02f, 3.15402970e-02f, 1.82641530e-03f, 4.39379290e-02f, 4.24591377e-02f, -5.34515176e-03f,
  -1.18971229e-01f, -1.97617501e-01f, -9.00896341e-02f, -4.81272377e-02f, -1.76818622e-03f, -6.84817061e-02f, 1.48359938e-02f, -2.57701986e-03f, -5.16103916e-02f, -7.62636438e-02f,
  -3.51045839e-02f, 5.86489215e-03f, -5.54107167e-02f, -4.49362071e-03f, -1.21248886e-02f, 1.48175741e-02f, -3.91317569e-02f, -3.45320143e-02f, -1.14546716e-01f, 4.62891534e-03f,
  4.76591699e-02f, -3.23300250e-02f, 8.04089680e-02f, 7.62939127e-03f, -2.13498566e-02f, -3.55177857e-02f, -2.70550344e-02f, -5.22340909e-02f, -5.92999682e-02f, -1.57238860e-02f,
  5.04718795e-02f, -1.16071582e-01f, 2.99790017e-02f, 2.39920020e-02f, 3.81569155e-02f, -1.54234305e-01f, -5.84073216e-02f, 9.60826129e-03f, 9.01469961e-02f, -1.15509935e-01f,
  -1.47373766e-01f, 2.18974017e-02f, -5.72230816e-02f, -5.75466640e-02f, 9.41007063e-02f, -2.05178037e-02f, -7.54721761e-02f, -4.91852686e-02f, 1.01250865e-01f, 8.19257870e-02f,
  4.83755991e-02f, -2.49271635e-02f, 7.33063649e-03f, -6.60546571e-02f, -7.43691251e-03f, 4.66786623e-02f, -5.96685335e-03f, 2.47858595e-02f, 5.35812899e-02f, 8.17735028e-03f,
  -6.54668212e-02f, 4.99269255e-02f, -4.46573924e-03f, -7.26697594e-02f, -1.79350004e-02f, -9.00837481e-02f, -5.09296358e-02f, 6.44414872e-02f, -2.58739176e-03f, 4.00889255e-02f,
  -2.83749364e-02f, 4.02463488e-02f, 3.74500938e-02f, -3.97287384e-02f, -2.86402926e-02f, 2.19159741e-02f, -2.49256380e-03f, 6.46591261e-02f, -5.70817105e-03f, -6.00151345e-02f,
  -3.04686688e-02f, -2.87140273e-02f, 7.43015185e-02f, 9.96042229e-03f, -5.31010032e-02f, -9.05488804e-02f, -1.14018871e-02f, 5.05421013e-02f, 5.52826785e-02f, 6.88211545e-02f,
  -1.07824951e-01f, 1.99802872e-02f, 2.78215557e-02f, 3.83069832e-03f, 1.86497793e-02f, 4.39158678e-02f, 3.85969244e-02f, -3.97707000e-02f, 6.99207038e-02f, -1.00996420e-01f,
  -1.93746388e-02f, -6.19628914e-02f, -4.38435636e-02f, -5.40835969e-02f, 5.19478135e-02f, -7.52197504e-02f, 2.23085769e-02f, 3.59990969e-02f, -8.21127295e-02f, 2.70188991e-02f,
  -5.82655370e-02f, -9.69107300e-02f, 5.05455919e-02f, 5.79570383e-02f, 4.79694037e-03f, 9.91632640e-02f, -5.82356714e-02f, 4.09833789e-02f, 7.10950345e-02f, 1.43637499e-02f,
  -2.80873440e-02f, 2.83649489e-02f, 4.09610011e-02f, 3.70800979e-02f, -3.42528895e-02f, 4.88271788e-02f, 9.42614079e-02f, 4.84134704e-02f, 9.23302472e-02f, 8.16224515e-02f,
  -4.21077982e-02f, 2.56867800e-02f, -7.60446489e-03f, 8.98621827e-02f, 2.60792188e-02f, -8.59323144e-02f, -4.62522544e-02f, -2.12674998e-02f, -2.89040301e-02f, 3.61877009e-02f,
  -1.02507107e-01f, 3.25897746e-02f, 2.14100480e-02f, 6.69589778e-03f, -4.81953174e-02f, 5.38489083e-04f, 7.32264668e-02f, 2.00334843e-02f, -1.48892577e-03f, 2.46793944e-02f,
  -2.97232121e-01f, 6.06954545e-02f, 2.52320260e-01f, -5.64332455e-02f, 7.75051564e-02f, 2.18257368e-01f, 5.14723137e-02f, 4.50846665e-02f, -1.03722356e-01f, 2.33407561e-02f,
  6.75828978e-02f, -1.49939939e-01f, 4.77025472e-02f, 7.97794685e-02f, -7.95756951e-02f, 1.30841732e-02f, 5.45812137e-02f, 1.26844654e-02f, 1.07606938e-02f, -7.32189044e-02f,
  -6.84497654e-02f, -1.33018225e-01f, 1.43223628e-01f, 6.11946099e-02f, 1.51606664e-01f, -4.86141704e-02f, -9.73086283e-02f, 7.31144026e-02f, 2.40436215e-02f, 1.21318141e-03f,
  -1.20475300e-01f, -1.90350860e-01f, -8.55080225e-03f, 7.11276159e-02f, 6.80942833e-02f, 1.04010282e-02f, 7.11523229e-03f, 4.82896455e-02f, 2.58741118e-02f, 5.38151376e-02f,
  -1.59304254e-02f, -3.15859802e-02f, -3.32012028e-02f, -8.61051008e-02f, 6.61861524e-03f, 2.21451931e-02f, 6.62056089e-04f, -4.47198842e-03f, -1.53226554e-02f, 1.46143492e-02f,
  7.59479217e-03f, -8.60171393e-03f, 6.64555356e-02f, -2.08216328e-02f, 9.17555392e-03f, 1.01808287e-01f, 3.66410986e-03f, 4.11291085e-02f, -3.35989930e-02f, 7.96459988e-03f,
  8.41892213e-02f, 2.48538554e-02f, 6.54264679e-03f, 6.91844597e-02f, 9.84144360e-02f, 5.94787896e-02f, -3.04511562e-02f, -2.07428653e-02f, 7.16327950e-02f, -5.09120943e-03f,
  -8.17579329e-02f, -2.81148832e-02f, 2.54966458e-03f, -5.49364947e-02f, -1.58317331e-02f, 1.75489932e-02f, 9.70755368e-02f, 4.64048684e-02f, 1.34118080e-01f, -3.81471142e-02f,
  -7.60273039e-02f, -4.30660285e-02f, 1.00272603e-01f, 3.72352675e-02f, -1.38186887e-02f, -6.53307736e-02f, 2.79786624e-02f, -2.74228137e-02f, -1.06317185e-01f, 4.89800423e-02f,
  -1.26147717e-01f, -2.08201841e-01f, 5.97046129e-03f, 6.34320229e-02f, 8.75947848e-02f, -2.07660105e-02f, -6.06730208e-02f, -4.25732397e-02f, 3.43128517e-02f, -6.53300509e-02f,
  6.16288744e-02f, 6.99404776e-02f, -6.31387606e-02f, 3.20648625e-02f, 4.24492620e-02f, 3.73488031e-02f, -1.51729526e-03f, 5.10650733e-03f, -2.15193722e-02f, -2.51538493e-02f,
  -1.60685778e-02f, 6.03525620e-03f, -1.64261255e-02f, -1.62378512e-02f, 8.29092562e-02f, -4.03537303e-02f, -1.29594123e-02f, -7.78315365e-02f, 1.02989348e-02f, -4.88919169e-02f,
  -2.36766353e-01f, -1.71881747e-02f, -6.33624122e-02f, -2.72344444e-02f, -2.06379339e-01f, -1.46177083e-01f, -2.60345131e-01f, 4.80166543e-03f, 2.46020518e-02f, 4.27536033e-02f,
  -1.41101167e-01f, 1.07284822e-01f, 3.39066014e-02f, -1.31192550e-01f, 2.34460961e-02f, 4.57516350e-02f, -2.31717661e-01f, -4.57604565e-02f, -6.15810528e-02f, -1.46769866e-01f,
  -1.24574326e-01f, -1.11953847e-01f, -1.23643771e-01f, -1.40832346e-02f, -1.97799951e-01f, 6.26391992e-02f, -8.76515824e-03f, -4.78204191e-02f, -3.15268897e-02f, 8.98306370e-02f,
  -1.06454484e-01f, 1.00136086e-01f, -1.00341052e-01f, -7.14007989e-02f, -4.80906963e-02f, -1.59190688e-02f, 1.69564616e-02f, -3.86978611e-02f, -3.27904359e-03f, -8.81859213e-02f,
  5.69526553e-02f, 7.28009315e-03f, 2.04096790e-02f, -3.60655561e-02f, -2.45669298e-02f, 2.61783712e-02f, -2.78584845e-02f, -6.55957758e-02f, -3.74931693e-02f, 6.03942340e-03f,
  6.44791797e-02f, 4.47478555e-02f, -1.05069868e-01f, 5.63290389e-03f, -7.69010037e-02f, -7.49958232e-02f, 6.87722191e-02f, -2.36402750e-02f, -6.36530444e-02f, -1.64886527e-02f,
  -3.31411995e-02f, 9.82517260e-04f, -8.70554373e-02f, -5.67051359e-02f, -1.53153483e-02f, 7.25300610e-02f, 2.53324341e-02f, 1.13848306e-01f, 1.38056208e-03f, 1.22897066e-02f,
  7.79001834e-03f, -5.01541421e-02f, 5.29326461e-02f, -6.11861944e-02f, -7.86343589e-02f, -7.41908178e-02f, -5.11884056e-02f, 3.80640924e-02f, -2.65396722e-02f, -9.64798629e-02f,
  4.70739417e-02f, 7.76030449e-03f, 2.61272006e-02f, 7.54652619e-02f, -7.50359073e-02f, 1.41135044e-02f, -2.59415936e-02f, 6.14752136e-02f, -8.34671482e-02f, -1.10920891e-01f,
  -9.26982984e-02f, -6.57719895e-02f, -4.61507700e-02f, -1.24529585e-01f, -6.45524077e-03f, -5.63806258e-02f, 1.85484532e-02f, -1.78478251e-03f, 3.67821828e-02f, -5.48197562e-03f,
  -8.37061778e-02f, -1.94164105e-02f, 5.76324090e-02f, 9.37644299e-03f, 4.23362851e-02f, 5.52623309e-02f, 3.96041535e-02f, -4.89487350e-02f, -4.61564399e-02f, -9.29329097e-02f,
  -4.39157942e-03f, 2.52648499e-02f, 4.08549458e-02f, 5.38845211e-02f, -4.82102707e-02f, -9.63622257e-02f, 7.01354444e-02f, 6.94784373e-02f, -3.86205092e-02f, -8.26854929e-02f,
  1.75522864e-01f, -9.35329124e-02f, -4.54463735e-02f, 2.24513695e-01f, 5.96304461e-02f, -2.13140950e-01f, -2.10760981e-01f, 2.31410056e-01f, -8.49759113e-03f, -1.33813947e-01f,
  -8.46899971e-02f, -1.26490071e-01f, -1.72801033e-01f, -3.70219424e-02f, 1.85070075e-02f, -2.92308718e-01f, 1.57462418e-01f, -7.78855383e-02f, -1.37870550e-01f, -1.04386685e-02f,
  1.39179841e-01f, 1.06960185e-01f, 6.15799688e-02f, 2.89731950e-01f, 1.66655675e-01f, 2.61869431e-01f, 2.40230218e-01f, -1.24958064e-02f, 2.48949602e-01f, 2.31594350e-02f,
  -4.86872718e-02f, 6.36889227e-03f, 4.65264730e-02f, -2.79783178e-02f, 8.52519050e-02f, 1.19602092e-01f, -2.11031102e-02f, -1.27957668e-02f, 2.58629341e-02f, -2.80238688e-03f,
  3.89306620e-02f, -3.93787362e-02f, -1.86212698e-03f, -1.71623416e-02f, 8.78186077e-02f, -4.36839387e-02f, -1.37576750e-02f, -3.93335987e-03f, 1.74514856e-03f, -7.25926682e-02f,
  -4.63424958e-02f, -4.03774865e-02f, -3.41659002e-02f, 2.60691042e-03f, -1.02180997e-02f, -3.34349684e-02f, 4.28591259e-02f, 3.72441113e-02f, 5.02673797e-02f, -6.69252034e-03f,
  7.68143823e-03f, -2.36246269e-02f, 3.02008800e-02f, -2.06172671e-02f, 1.65285394e-02f, -1.20568015e-02f, 2.54235137e-03f, -2.04337891e-02f, -2.84631476e-02f, -4.23619971e-02f,
  8.53193775e-02f, 5.00747189e-02f, -8.34643282e-03f, -2.43022963e-02f, 2.95025781e-02f, -1.01984210e-01f, 1.87090579e-02f, -1.30005376e-02f, -2.69968398e-02f, 1.78562328e-02f,
  -6.64424524e-02f, 6.55769408e-02f, -5.41749261e-02f, 5.83736598e-02f, -6.75683916e-02f, 7.30338097e-02f, -5.56906275e-02f, -5.64385299e-03f, 8.70181918e-02f, 1.03816232e-02f,
  -6.34005060e-04f, 2.37559881e-02f, -3.13464440e-02f, -1.76292844e-02f, -4.50277179e-02f, 2.20219847e-02f, -5.42553049e-03f, -1.03042331e-02f, 1.06774285e-01f, 1.13448143e-01f,
  7.93528929e-02f, 4.97256406e-02f, 4.02588360e-02f, 6.21810555e-02f, 1.36415094e-01f, -5.16884215e-02f, 3.45820636e-02f, 7.94355348e-02f, 5.07796891e-02f, -2.40933392e-02f,
  7.81412497e-02f, 6.55210614e-02f, 7.61306360e-02f, 4.66572493e-03f, -2.76931953e-02f, 3.74740586e-02f, 1.74898356e-02f, 2.78205480e-02f, -1.32269766e-02f, 2.61801761e-02f,
  1.25899523e-01f, -3.12276147e-02f, -4.83478867e-02f, -1.36837170e-01f, 3.59786674e-02f, -4.51419614e-02f, 1.02649942e-01f, -3.54548134e-02f, -6.33440316e-02f, -1.19835874e-02f,
  8.21878240e-02f, 8.37773492e-04f, 7.24839047e-02f, -1.09537043e-01f, -7.58325458e-02f, 1.31297139e-02f, 2.33799182e-02f, 3.96565609e-02f, 3.36282626e-02f, 7.61282668e-02f,
  2.74437782e-03f, -1.47368396e-02f, 4.42097802e-03f, 5.47211505e-02f, -3.02451123e-02f, 5.11813462e-02f, -1.32438960e-03f, 1.14742510e-01f, 7.65179247e-02f, -2.37606484e-02f,
  -1.41464090e-02f, 7.66427442e-02f, 1.91111472e-02f, 2.99256202e-03f, 3.93359773e-02f, 3.22992355e-02f, 7.26076141e-02f, -2.07780283e-02f, 3.98143083e-02f, 2.80956477e-02f,
  2.79100100e-03f, -5.51144183e-02f, 2.02718758e-04f, -6.34607971e-02f, 2.69200411e-02f, -2.31352206e-02f, -2.11038766e-03f, 6.22506402e-02f, -5.11253960e-02f, -8.19330569e-03f,
  -5.23951910e-02f, -3.71932378e-03f, 2.53870990e-02f, 5.45869768e-02f, -6.68476336e-03f, 5.86418472e-02f, -1.85583849e-02f, -4.76519205e-02f, -7.96262249e-02f, -5.10115586e-02f,
  -4.89016473e-02f, 4.32175174e-02f, -6.32258365e-04f, -8.14721063e-02f, -5.10735810e-02f, 8.28819945e-02f, -1.10202722e-01f, -7.17950463e-02f, -9.08893123e-02f, 4.45236862e-02f,
  3.35370773e-03f, -8.32663625e-02f, -7.05032004e-03f, -1.43872574e-02f, 4.48902771e-02f, 9.40828994e-02f, 3.07025518e-02f, 7.19727501e-02f, -3.17942537e-02f, -3.78585532e-02f,
  6.12703562e-02f, 3.94983497e-03f, 9.78428647e-02f, -3.88508625e-02f, 5.39193340e-02f, 4.94166603e-03f, -6.09011352e-02f, -5.38107529e-02f, -2.61300672e-02f, -5.15180752e-02f,
  1.10352173e-01f, 1.64189059e-02f, 3.46242893e-03f, 2.00352222e-02f, 3.35488096e-02f, -9.35829654e-02f, 3.64895575e-02f, -3.89965586e-02f, -6.48023710e-02f, 1.15394155e-02f,
  -5.80678806e-02f, 2.15252396e-02f, -2.92764902e-02f, 4.98811714e-02f, 1.94214806e-02f, -4.18711640e-02f, -4.77533378e-02f, 5.24949506e-02f, 7.42682070e-02f, 2.54713111e-02f,
  5.46194352e-02f, 7.60506317e-02f, 1.36523070e-02f, 4.57284786e-02f, 1.94950514e-02f, -1.19387675e-02f, 5.36928214e-02f, 1.06709734e-01f, 5.33286668e-02f, -9.03859735e-02f,
  -6.90021142e-02f, 5.24731204e-02f, -1.66104868e-01f, 2.18473170e-02f, -1.14729293e-01f, -1.10997230e-01f, -2.09061578e-01f, -1.14993833e-01f, -5.27345799e-02f, 1.08957700e-02f,
  5.69831952e-02f, -1.06995225e-01f, 2.24221796e-02f, -2.05815494e-01f, 8.33406001e-02f, 3.66166569e-02f, -6.04785271e-02f, 1.94202010e-02f, -1.14922293e-01f, 1.43062323e-02f,
  7.34463036e-02f, -1.08062051e-01f, -8.05696473e-02f, -3.80056817e-03f, -1.56734362e-01f, -7.16387331e-02f, 4.45898362e-02f, -4.28444520e-02f, 3.40922512e-02f, -5.28039485e-02f,
  -5.49614988e-02f, -4.08822000e-02f, -1.06910571e-01f, -1.34742968e-02f, -2.06086459e-03f, 2.30317321e-02f, -1.03416229e-02f, 1.96825787e-02f, -4.29636240e-02f, 8.09122548e-02f,
  3.87862734e-02f, 6.79603592e-02f, -5.26054949e-02f, 3.96000929e-02f, -7.40353987e-02f, -4.73174639e-02f, -3.85784544e-02f, 5.29521005e-03f, -7.34863505e-02f, -5.36352582e-02f,
  -1.09461114e-01f, -3.97712030e-02f, -7.52756149e-02f, 5.28427437e-02f, -7.04016834e-02f, -5.74569441e-02f, 1.81899499e-02f, -1.72204841e-02f, -5.78537397e-02f, -7.94993564e-02f,
  1.54590189e-01f, 3.30735482e-02f, 1.30445492e-02f, 9.13843699e-03f, -5.62975183e-02f, 4.45393063e-02f, 9.96307842e-03f, 4.65013161e-02f, 2.74959635e-02f, -4.96788286e-02f,
  4.87061962e-02f, 4.41802926e-02f, 1.57278702e-02f, 7.85106197e-02f, 1.23501025e-01f, 4.70961779e-02f, -2.27873046e-02f, 6.51182905e-02f, -4.71951552e-02f, 1.16316542e-01f,
  -1.87600944e-02f, -6.08237796e-02f, 3.56084965e-02f, -2.24719513e-02f, -5.38046807e-02f, -4.07463759e-02f, -1.12873882e-01f, 3.09604332e-02f, 1.01409787e-02f, -2.33039148e-02f,
  4.53839302e-02f, -9.99004692e-02f, -8.31717327e-02f, -4.98419628e-03f, 5.01530420e-04f, -4.35246807e-03f, -4.23481800e-02f, -7.80948773e-02f, -7.53645226e-02f, -7.59250447e-02f,
  1.01937400e-02f, 2.98822261e-02f, -5.48290685e-02f, 4.38528769e-02f, 4.76796515e-02f, -2.17913613e-02f, -5.92308752e-02f, 2.82402672e-02f, 9.83917341e-03f, 3.74248810e-02f,
  -1.09821990e-01f, -6.67545795e-02f, 6.97296038e-02f, -1.20976416e-03f, -2.06386149e-02f, 6.14082068e-02f, 1.15903257e-03f, 7.01880604e-02f, -6.98856637e-02f, 5.78319281e-03f,
  3.59830797e-01f, -3.02737467e-02f, -1.02361098e-01f, 7.31844604e-02f, 7.57498294e-02f, -1.52032912e-01f, -1.71263978e-01f, 1.06783874e-01f, -3.78512293e-02f, -2.96445768e-02f,
  2.59202242e-01f, -1.35232419e-01f, -8.21873844e-02f, 2.43208334e-01f, 2.55671531e-01f, -1.35815144e-01f, 1.32899314e-01f, 1.01332627e-01f, -4.21017744e-02f, 2.26223707e-01f,
  1.76343754e-01f, 1.95828944e-01f, 2.39602663e-02f, 1.12577841e-01f, 9.94042382e-02f, -1.06216455e-03f, 7.64420554e-02f, -1.90933272e-01f, 2.04443738e-01f, 4.96977521e-03f,
  -1.04294762e-01f, 4.18859795e-02f, 2.82235760e-02f, -2.18000077e-02f, 1.11681949e-02f, 1.85336103e-03f, -1.42969489e-01f, -5.07243164e-02f, -2.93359463e-03f, 3.45963566e-03f,
  -8.08826983e-02f, 1.14058696e-01f, 5.21670654e-02f, -2.94847395e-02f, -4.40382175e-02f, 5.28219678e-02f, 4.88860495e-02f, 2.46032532e-02f, -7.93116614e-02f, -2.50493847e-02f,
  -1.02428243e-01f, 1.81276370e-02f, -5.31335846e-02f, -3.79106402e-02f, -4.89911027e-02f, 4.23132069e-02f, -6.64834008e-02f, -6.18807711e-02f, -1.61556359e-02f, 2.58349702e-02f,
  9.33619589e-02f, -7.80941397e-02f, 7.69627169e-02f, 3.10376696e-02f, 9.75345373e-02f, -5.10480590e-02f, 6.33899122e-02f, 1.07923262e-02f, -2.96374075e-02f, 2.77117677e-02f,
  6.72736466e-02f, -5.74363545e-02f, 3.57327797e-02f, 2.36370880e-02f, -2.29552444e-02f, -3.81041020e-02f, -1.57726705e-02f, 9.14738979e-03f, -2.77469363e-02f, 3.92384194e-02f,
  -2.09519826e-02f, -6.04763441e-03f, 6.80166706e-02f, -7.93823451e-02f, -4.18896899e-02f, 4.32895124e-02f, 7.07705244e-02f, -3.64839844e-02f, -9.05895904e-02f, 7.25493282e-02f,
  4.64008413e-02f, 2.04412818e-01f, -7.91601930e-03f, -5.31743020e-02f, -5.50600551e-02f, 1.14582092e-01f, -8.77145156e-02f, 1.37733802e-01f, 6.63656816e-02f, 4.26108874e-02f,
  3.69658433e-02f, -9.77740064e-02f, 2.77637653e-02f, 8.48576427e-02f, -2.17706226e-02f, 1.31163046e-01f, 2.09972393e-02f, -6.96104094e-02f, 4.69881780e-02f, 8.06717351e-02f,
  -8.42600130e-03f, -6.52857050e-02f, -2.86358912e-02f, 7.00303689e-02f, 8.59190226e-02f, -7.57132918e-02f, 4.45589758e-02f, -2.01745443e-02f, -2.16714647e-02f, 5.51382126e-03f,
  -3.69611502e-01f, -1.71586648e-02f, -4.81734797e-02f, -1.06359676e-01f, -2.25207180e-01f, -3.91801037e-02f, -1.44436834e-02f, -1.06900275e-01f, -6.99287131e-02f, -3.62277031e-02f,
  -1.68790057e-01f, -1.33814350e-01f, 8.68964791e-02f, 7.47485831e-02f, 5.37860654e-02f, 1.75314888e-01f, 1.78096011e-01f, 8.43716189e-02f, -4.96666785e-03f, -7.64805079e-02f,
  1.18163131e-01f, -1.96527746e-02f, 5.94560243e-02f, -3.69373411e-02f, -1.06314747e-02f, 7.47005716e-02f, 5.64156882e-02f, 5.77084050e-02f, 9.39703584e-02f, -8.41605887e-02f,
  -1.70799270e-01f, -2.11389348e-01f, -1.00603230e-01f, -1.13724202e-01f, 3.80395278e-02f, 3.20926197e-02f, 2.83786207e-02f, -9.20147225e-02f, 1.80804692e-02f, 3.18156891e-02f,
  3.24707516e-02f, -3.37231457e-02f, 2.72858683e-02f, -3.00172577e-03f, -3.92780937e-02f, 1.71474963e-02f, 3.41643319e-02f, -4.15530875e-02f, -6.36248961e-02f, -1.13213770e-02f,
  -3.18084396e-02f, 4.33930531e-02f, -6.43324405e-02f, 8.54969695e-02f, 3.64343151e-02f, 3.43341799e-03f, -8.26292187e-02f, 5.24524599e-02f, 8.42852797e-03f, -5.08080469e-03f,
  -1.75400302e-02f, -5.01196086e-02f, 2.11826861e-02f, -1.21582717e-01f, -4.85491268e-02f, -7.57360533e-02f, -4.04120535e-02f, -7.10103661e-02f, -6.49508238e-02f, -1.94742922e-02f,
  -2.16090418e-02f, -4.89182770e-02f, -3.58766615e-02f, 7.90466890e-02f, -4.61241715e-02f, 4.31338325e-02f, -3.51287834e-02f, -5.78098893e-02f, 7.30668940e-03f, 7.72085637e-02f,
  7.09064677e-02f, 8.15530308e-03f, 2.72457730e-02f, -1.01521596e-01f, -1.74010023e-02f, 6.15018867e-02f, 3.00557283e-03f, -9.06932205e-02f, 6.22199699e-02f, 3.68497707e-02f,
  -1.10162415e-01f, -1.30603448e-01f, -6.54866993e-02f, -1.58814237e-01f, -5.74924611e-02f, 2.05228329e-02f, 3.09846159e-02f, 6.07761070e-02f, 4.27283207e-03f, -2.56463494e-02f,
  1.35032656e-02f, -2.95781326e-02f, 2.11200938e-02f, -4.55744378e-03f, -2.48504188e-02f, -3.25478353e-02f, -2.93555390e-02f, 2.98253056e-02f, -1.12791872e-02f, 5.87961487e-02f,
  8.63439515e-02f, -8.80082995e-02f, 4.15729061e-02f, 2.07825899e-02f, 2.88582146e-02f, 1.79958567e-02f, 6.09104149e-03f, -1.95442643e-02f, 2.23320387e-02f, 1.01302423e-01f,
  1.39341010e-02f, 2.21616238e-01f, 1.26421392e-01f, 7.36856908e-02f, -2.33798519e-01f, -2.94986784e-01f, -2.20744997e-01f, 1.00384690e-02f, -9.74144936e-02f, -3.06801833e-02f,
  -3.73801775e-02f, 2.32904121e-01f, 2.41330219e-03f, 2.91905794e-02f, 1.69240423e-02f, -1.25815436e-01f, 2.07223203e-02f, 1.14073381e-02f, 8.38868394e-02f, 1.51224822e-01f,
  1.71422794e-01f, -6.21534996e-02f, 2.65377223e-01f, -4.43486050e-02f, 4.39696461e-02f, 1.41112596e-01f, 1.36470139e-01f, -4.04755771e-03f, 1.40636265e-01f, -4.69723977e-02f,
  -4.17281687e-03f, 3.91412675e-02f, 1.83577444e-02f, 2.41442528e-02f, 4.63557988e-02f, 2.18740907e-02f, 3.71588074e-04f, -9.47952271e-02f, 4.94231842e-02f, -7.46776685e-02f,
  -1.28594134e-03f, -1.61371622e-02f, -6.76475838e-03f, -6.48474460e-03f, -1.40384734e-02f, 5.74613512e-02f, 3.95671688e-02f, 8.44036713e-02f, -2.39758403e-03f, 1.44172400e-01f,
  1.41778126e-01f, -2.24475935e-02f, -2.34370735e-02f, 3.31498347e-02f, 9.66669247e-02f, -3.40559818e-02f, 1.38270790e-02f, 1.13543950e-01f, 3.21039185e-02f, -5.37839765e-03f,
  -3.01543046e-02f, -1.44588724e-02f, 4.27937694e-02f, 3.95951010e-02f, 7.45552182e-02f, 4.09180410e-02f, 5.90501539e-02f, -1.34845022e-02f, -3.76891438e-03f, -7.63200670e-02f,
  -4.27678898e-02f, 8.58522113e-03f, -6.33872896e-02f, -2.44880226e-02f, 1.55207328e-02f, 9.16015059e-02f, -3.57363978e-03f, -3.82446535e-02f, -8.93293843e-02f, 1.37642249e-02f,
  4.32040431e-02f, 5.66619821e-02f, 5.92454299e-02f, -6.32002577e-02f, -4.91035171e-02f, 4.08389978e-02f, 7.14798318e-03f, 2.39828024e-02f, 2.72486508e-02f, -5.09969294e-02f,
  4.90863807e-02f, 2.32631236e-01f, -2.25861277e-02f, -1.11458868e-01f, -4.10888903e-02f, -2.66641211e-02f, -4.04138044e-02f, 4.03415971e-02f, 2.34768409e-02f, -1.09454999e-02f,
  -1.44974794e-02f, 1.81327090e-02f, 3.80478054e-02f, -5.35224043e-02f, -2.68720705e-02f, 3.44032049e-02f, 4.71345522e-02f, 2.07682122e-02f, 5.02197668e-02f, 6.92459866e-02f,
  8.28275532e-02f, -7.14941919e-02f, -2.82807611e-02f, 1.50242234e-02f, -6.73872903e-02f, -7.03111663e-02f, 2.97176950e-02f, -1.66690499e-02f, -2.97532640e-02f, -2.77628228e-02f,
  2.51913685e-02f, 3.37466672e-02f, -1.03503913e-02f, 1.07641622e-01f, -1.07119493e-01f, 1.01707149e-02f, 5.59576638e-02f, 4.24658991e-02f, 9.67544019e-02f, 1.58667728e-01f,
  2.64719734e-03f, 8.53120014e-02f, -1.20139597e-02f, -6.08324930e-02f, 1.09172044e-02f, 9.77641158e-03f, -1.71805799e-01f, -3.18462551e-02f, -6.19045943e-02f, -1.36213243e-01f,
  -1.16381183e-01f, -1.26938269e-01f, -1.85018986e-01f, -7.63388574e-02f, -1.65961087e-01f, 1.50450328e-02f, -5.60700409e-02f, -3.20469774e-02f, 2.22841688e-02f, 2.17494089e-02f,
  9.37879384e-02f, 1.87956199e-01f, 1.16769448e-01f, -8.64838716e-03f, 3.97949368e-02f, -1.31351184e-02f, -1.12751676e-02f, 1.04419507e-01f, 1.78472642e-02f, 4.38228324e-02f,
  -2.16263793e-02f, 6.83301780e-03f, -2.72103641e-02f, -9.67139751e-03f, -9.31148678e-02f, -6.90694293e-03f, 3.47752869e-02f, -3.29190493e-02f, -3.58656794e-02f, -8.13799798e-02f,
  -1.46900028e-01f, -7.28938729e-02f, -4.05033715e-02f, -2.74209771e-02f, -2.02810690e-02f, 1.31399101e-02f, 6.45217970e-02f, 7.16138957e-03f, -2.73195859e-02f, 5.32172918e-02f,
  3.44130001e-03f, 1.30797774e-02f, -1.17353974e-02f, -3.20346057e-02f, 7.35374168e-02f, 3.47076021e-02f, -9.45985988e-02f, 3.40668261e-02f, -2.53217816e-02f, 3.60420393e-03f,
  3.01615614e-02f, -5.64085878e-03f, 8.25610245e-04f, -4.60396744e-02f, -6.15221933e-02f, -4.03535664e-02f, -3.35540660e-02f, 2.48092115e-02f, -4.22779791e-04f, -7.42235556e-02f,
  1.28063140e-02f, -1.45550258e-02f, 4.82956357e-02f, 3.84268202e-02f, -3.38628748e-03f, 2.46068239e-02f, -9.96433198e-02f, -6.22992292e-02f, 5.11659272e-02f, 2.37312429e-02f,
  2.32482739e-02f, 2.64789492e-01f, 8.00772160e-02f, 7.31208771e-02f, 9.11912918e-02f, 2.00515687e-02f, -6.32826164e-02f, -2.19215509e-02f, 4.60747583e-03f, 2.56112218e-02f,
  -4.25014272e-02f, 1.91480722e-02f, -3.95843089e-02f, -7.49128908e-02f, -5.98946065e-02f, 1.27261236e-01f, 5.08000776e-02f, 3.15133855e-02f, 3.78659926e-04f, -5.17798401e-02f,
  -8.53168815e-02f, 4.21154648e-02f, 4.48896624e-02f, 2.91795954e-02f, 8.50818828e-02f, 5.77332976e-04f, -2.80469246e-02f, 1.58531256e-02f, 1.96545869e-02f, 7.17457309e-02f,
  2.95377560e-02f, 8.42228308e-02f, 1.15008391e-01f, -2.09709723e-03f, 9.65455361e-03f, -9.04557705e-02f, -5.11664785e-02f, -1.39736419e-03f, 9.02409852e-02f, 5.11270463e-02f,
  -4.32002172e-02f, 1.85242131e-01f, 6.50953427e-02f, -4.33306396e-03f, -2.55757004e-01f, -1.03163004e-01f, -6.82695210e-02f, -8.93952325e-02f, -8.78277645e-02f, 2.18553524e-02f,
  4.27902490e-02f, -4.54085506e-02f, -1.18815981e-01f, 5.58846481e-02f, -8.98989756e-03f, 1.13100871e-01f, 2.44716853e-02f, 7.31197521e-02f, 3.34246457e-02f, 1.34099405e-02f,
  -1.16267629e-01f, 1.17462158e-01f, -5.43371774e-03f, 4.82863449e-02f, 7.98265189e-02f, -5.02782017e-02f, 5.98184057e-02f, 1.27078127e-02f, -1.40471139e-03f, 7.99386427e-02f,
  -7.48682618e-02f, 6.28229603e-02f, -1.63446385e-02f, 2.32141968e-02f, 1.12415440e-01f, 3.35445702e-02f, 8.93906876e-02f, 6.42668158e-02f, 9.30682197e-02f, 4.21765447e-02f,
  2.02593599e-02f, 3.31085138e-02f, -5.79777770e-02f, -6.28631115e-02f, 4.22153063e-02f, 8.72458518e-03f, 6.88507408e-02f, 5.97081520e-02f, -4.53262180e-02f, -5.16023226e-02f,
  1.65678523e-02f, 7.19697103e-02f, -3.24718617e-02f, -1.92402012e-03f, -2.05232995e-03f, 9.78718176e-02f, -5.99092543e-02f, 5.68889547e-03f, -2.27582976e-02f, -4.82813269e-02f,
  -7.29671866e-02f, -3.51523273e-02f, -3.52758132e-02f, 3.51992389e-03f, 3.11429314e-02f, -6.42237961e-02f, 5.19122817e-02f, 7.95463938e-03f, -4.51274328e-02f, -7.20305927e-03f,
  -2.40698289e-02f, -8.70337263e-02f, 3.35726589e-02f, 3.29001844e-02f, -1.14786737e-02f, -4.87899743e-02f, -3.46710272e-02f, 1.30724728e-01f, 5.77195324e-02f, -1.59343034e-01f,
  -4.89182100e-02f, -1.02594100e-01f, 6.07102364e-02f, 1.11824766e-01f, 1.09243460e-01f, -4.09514979e-02f, -3.04255318e-02f, 4.34931852e-02f, -3.45424935e-02f, 2.28864066e-02f,
  4.72784042e-02f, 1.72315538e-02f, -3.04036438e-02f, -8.91125482e-03f, -1.82529073e-02f, -1.98461711e-02f, 6.35408983e-02f, 4.72748727e-02f, -1.52149554e-02f, -3.93415429e-03f,
  6.52094036e-02f, -1.33361882e-02f, 4.97391298e-02f, -4.10113931e-02f, -3.58334593e-02f, -1.00768674e-02f, -5.83664812e-02f, -2.04429794e-02f, 6.07150979e-02f, -4.04323936e-02f,
  5.18385805e-02f, 1.90239951e-01f, -3.59950550e-02f, -2.73762420e-02f, 5.97381890e-02f, -2.06744611e-01f, 2.61620199e-03f, -7.98240211e-03f, 3.07960790e-02f, 1.04027644e-01f,
  6.33192295e-03f, 2.44926125e-01f, -7.46633932e-02f, -1.14864528e-01f, -3.05572033e-01f, -2.19614804e-01f, 5.14054159e-03f, 1.25669017e-01f, 1.15189642e-01f, -1.09869773e-02f,
  -1.15558319e-01f, -1.69585899e-01f, -9.07816365e-02f, -1.83240194e-02f, -6.68033864e-03f, 1.58377483e-01f, -1.55537995e-02f, 1.68831512e-01f, 4.79346663e-02f, 7.55218491e-02f,
  -7.35161230e-02f, 1.37270898e-01f, 1.07247636e-01f, -3.62452157e-02f, -7.63592124e-02f, -1.04568459e-01f, -1.61282010e-02f, 3.22438516e-02f, 3.75932641e-03f, 7.84295704e-03f,
  -1.39673217e-03f, -2.91588958e-02f, -5.52091002e-02f, 4.66339551e-02f, 7.90670663e-02f, 7.68432468e-02f, -1.00748137e-01f, -8.05558711e-02f, 9.08013433e-02f, -3.20267677e-02f,
  2.89447550e-02f, -4.95171845e-02f, -6.20450303e-02f, 1.10887857e-02f, -3.25941034e-02f, 4.74996865e-02f, -1.15813976e-02f, 2.07647607e-02f, 8.25354159e-02f, 4.90466692e-03f,
  -5.12052141e-03f, 3.00167669e-02f, 3.55736986e-02f, 6.83956444e-02f, 3.36720794e-02f, -5.45320511e-02f, 2.82656774e-02f, 4.74020466e-02f, 9.34296325e-02f, 1.75819118e-02f,
  -8.02756473e-03f, 8.99931416e-02f, -1.96424918e-03f, 4.26106341e-02f, -1.38697233e-02f, 3.50785553e-02f, -6.33012652e-02f, 2.95327939e-02f, -3.07046343e-02f, 5.78111373e-02f,
  3.71719599e-02f, -4.21599895e-02f, 2.13643592e-02f, 4.05170163e-03f, -8.15006271e-02f, -2.34239250e-02f, 6.96294429e-03f, -1.11190252e-01f, 3.93719189e-02f, -2.65626572e-02f,
  2.50453223e-02f, -7.54200155e-03f, -8.20537210e-02f, 5.26290871e-02f, 7.66239688e-02f, -8.91725868e-02f, -1.37148693e-03f, 4.33596075e-02f, -4.48835529e-02f, 9.91239026e-03f,
  5.52974157e-02f, 2.63760220e-02f, -1.45886242e-01f, 1.42679989e-01f, -8.31713229e-02f, -3.36887389e-02f, -8.40351731e-02f, -1.46358714e-01f, 1.10120056e-02f, 2.33901553e-02f,
  2.89783273e-02f, -4.29563485e-02f, -6.17479943e-02f, -5.19948900e-02f, -9.14635435e-02f, 6.54721037e-02f, 1.02462195e-01f, 7.59684071e-02f, -1.31878629e-02f, -2.48441454e-02f,
  5.77256978e-02f, -2.08357684e-02f, 1.90126553e-01f, 4.10004944e-01f, -9.43730772e-02f, -2.73961216e-01f, -2.54721314e-01f, -2.23896969e-02f, -1.57748863e-01f, -9.28303674e-02f,
  8.61830488e-02f, 5.02592288e-02f, -3.53265591e-02f, 1.16921864e-01f, 1.53466329e-01f, 1.91529805e-03f, -1.18613066e-02f, -1.44979030e-01f, 9.52178892e-03f, 6.34364411e-02f,
  1.07811190e-01f, 1.28763884e-01f, 3.28520536e-01f, 2.58243054e-01f, -1.78959426e-02f, 3.55854779e-01f, 3.34208131e-01f, 1.87326521e-01f, 2.92637706e-01f, 1.38586193e-01f,
  -7.57663697e-02f, -4.07262007e-03f, -3.21860961e-03f, -3.97578031e-02f, 1.43845249e-02f, -4.96860072e-02f, 4.38498817e-02f, 5.42487018e-02f, 9.00859460e-02f, 3.03422548e-02f,
  -7.57981911e-02f, -2.02716123e-02f, -1.18555790e-02f, 3.61779556e-02f, -1.51016582e-02f, 8.59240368e-02f, -2.61777453e-02f, 5.19603118e-02f, 7.63975317e-03f, -1.50214015e-02f,
  1.37234926e-02f, 4.50856090e-02f, 5.59820645e-02f, 7.83519894e-02f, 3.95431817e-02f, 1.69397369e-02f, -4.02065441e-02f, 7.35212723e-03f, -8.29397589e-02f, 4.60730083e-02f,
  1.60419270e-02f, -3.06942295e-02f, -7.12443963e-02f, 5.67946881e-02f, 8.82653426e-03f, 6.06962964e-02f, -5.83298430e-02f, 4.66983803e-02f, 4.27810922e-02f, 5.10690212e-02f,
  1.62846241e-02f, 4.18262295e-02f, 3.34374011e-02f, -4.75443266e-02f, -3.39984298e-02f, -3.97423096e-02f, 2.54699793e-02f, 7.90426042e-03f, 5.18367626e-02f, -2.79609468e-02f,
  -3.07805510e-03f, 1.66401733e-02f, -1.87891081e-03f, -4.95278127e-02f, 4.78833131e-02f, 9.05591249e-03f, 2.89011151e-02f, 4.94227698e-03f, 3.98408249e-02f, -1.63939800e-02f,
  -6.78829178e-02f, 3.61999795e-02f, 9.01876017e-02f, -5.17731020e-03f, 9.03770849e-02f, -1.89405195e-02f, 4.83284928e-02f, -5.66807948e-02f, -4.71368479e-03f, -5.39111644e-02f,
  -3.36202346e-02f, 7.30054602e-02f, -8.35373998e-02f, 2.58394852e-02f, 5.04013188e-02f, -3.54388393e-02f, 1.21118538e-02f, 3.04133259e-02f, -2.08887411e-03f, 1.26923293e-01f,
  9.90177691e-02f, -4.08542417e-02f, 7.55445138e-02f, -2.88373344e-02f, -3.38854045e-02f, 1.43644679e-02f, 4.32580337e-02f, 4.91230469e-03f, 4.44316529e-02f, 3.79877910e-02f,
  -2.09458321e-01f, 1.33122206e-01f, -1.11461900e-01f, -1.79793924e-01f, 1.49804637e-01f, -2.92334944e-01f, -2.27965206e-01f, 7.81173632e-03f, -2.12052196e-01f, 1.62087336e-01f,
  5.57301417e-02f, -1.67323783e-01f, 1.09582506e-01f, -3.10292065e-01f, -5.23764789e-01f, -2.63471574e-01f, -3.96881163e-01f, -1.27922788e-01f, -3.54157202e-02f, 1.32497009e-02f,
  -1.22163013e-01f, 7.03265369e-02f, -1.48713052e-01f, 2.66982883e-01f, 6.75125569e-02f, 1.68228239e-01f, 1.98584706e-01f, 3.35339606e-01f, 8.69571883e-03f, -2.62167826e-02f,
  -1.14855759e-01f, -4.69678901e-02f, -6.19123541e-02f, -4.43937220e-02f, 7.40964059e-03f, 5.79366721e-02f, 4.20455448e-02f, -6.48852289e-02f, -2.20189858e-02f, -1.38926716e-03f,
  4.86065708e-02f, 6.60186335e-02f, -1.07358865e-01f, 2.08317041e-02f, 2.58805174e-02f, 4.78529893e-02f, 1.57865149e-03f, -4.51093577e-02f, -1.43940793e-02f, -4.81951199e-02f,
  -6.94134384e-02f, -1.90688651e-02f, 9.58085153e-03f, 3.43259498e-02f, -2.71521248e-02f, 2.36510616e-02f, -2.80145388e-02f, 1.75902117e-02f, 3.53273191e-02f, -7.36416727e-02f,
  3.36995348e-02f, -5.48530929e-03f, 1.51773337e-02f, -1.97007339e-02f, 7.46189132e-02f, 4.35481220e-02f, 7.80741405e-03f, 7.12176599e-03f, 5.57981655e-02f, -1.62338046e-03f,
  2.60532014e-02f, -1.92487128e-02f, -2.51949672e-03f, -1.90197083e-04f, -6.20161146e-02f, 4.21810895e-03f, -6.42505195e-03f, -3.67251560e-02f, -5.52752875e-02f, -1.85641069e-02f,
  1.60301141e-02f, -6.35169074e-02f, -2.09938232e-02f, -1.50910150e-02f, -2.90790088e-02f, 1.02277622e-01f, -2.63699740e-02f, -6.04583621e-02f, 4.49484661e-02f, 1.05236308e-03f,
  -5.81032131e-03f, 4.23756056e-02f, 5.33963740e-02f, 4.74723801e-02f, 9.96602816e-04f, -3.70365754e-02f, -1.54826298e-01f, -4.10412438e-02f, -5.54613629e-03f, -4.74289246e-03f,
  6.24874383e-02f, -3.84535901e-02f, 5.40506467e-02f, 4.16641794e-02f, 1.03538856e-02f, -7.93337375e-02f, 7.67627731e-02f, 4.31385264e-03f, 1.25312852e-02f, 5.41952625e-02f,
  6.28473982e-02f, -4.32216637e-02f, 8.43500942e-02f, 4.81797718e-02f, 4.01277654e-02f, -1.96356773e-02f, -1.05327601e-02f, -2.85665039e-02f, -9.38074384e-03f, 1.06139407e-02f,
  -9.12505090e-02f, -2.70898908e-01f, 1.92350671e-02f, -1.47385404e-01f, -7.71517977e-02f, -2.11039796e-01f, -2.60864437e-01f, -7.26766745e-03f, 1.22370578e-01f, 1.29140630e-01f,
  -9.64874029e-03f, -8.47339928e-02f, 6.37029633e-02f, -1.09029472e-01f, 2.83933319e-02f, 3.43728438e-03f, -2.62036830e-01f, -1.48569405e-01f, -6.41586110e-02f, -9.30429846e-02f,
  -1.06417045e-01f, -1.09609939e-01f, -4.27623205e-02f, -4.18528095e-02f, -1.43662348e-01f, 5.51188290e-02f, 1.78508267e-01f, -6.13841303e-02f, -2.98892837e-02f, -5.10342382e-02f,
  -4.14021648e-02f, 1.08508013e-01f, 1.63369486e-03f, 1.33659810e-01f, 4.01831791e-02f, -3.09211258e-02f, -6.87923729e-02f, 3.83350323e-03f, 8.06779116e-02f, 8.17997195e-03f,
  6.83544204e-02f, 4.06476818e-02f, 4.24075201e-02f, 5.49893361e-03f, -7.82011598e-02f, -6.72506168e-02f, -1.04845511e-02f, 3.95487919e-02f, 5.89085137e-03f, 1.08419266e-02f,
  2.57522222e-02f, -2.98800468e-02f, 5.04334047e-02f, 1.07145436e-01f, 3.94001640e-02f, -5.06537184e-02f, 3.97559181e-02f, 1.25861555e-01f, -1.53580690e-02f, 4.65625636e-02f,
  -3.85989472e-02f, -4.78304289e-02f, -4.26124558e-02f, 7.29785264e-02f, 8.22970718e-02f, -6.50558760e-03f, 1.29953668e-01f, -7.52601475e-02f, -5.12807854e-02f, -5.88390641e-02f,
  3.17864455e-02f, -4.69358228e-02f, 3.68966013e-02f, 4.92613483e-03f, -6.99245930e-02f, -8.23008791e-02f, -1.00157689e-02f, 6.44245073e-02f, -7.52516910e-02f, 7.65867904e-02f,
  5.63655049e-02f, 7.99547788e-03f, -3.98652777e-02f, -1.15634978e-01f, 7.19734281e-02f, 8.79700556e-02f, 6.99744150e-02f, -3.14393006e-02f, 1.40596647e-03f, -3.51252928e-02f,
  -1.24863289e-01f, 4.47478853e-02f, 2.43746173e-02f, 6.85476139e-02f, -5.05395643e-02f, -6.04261979e-02f, -7.36702383e-02f, -5.53034954e-02f, -1.04860514e-01f, -1.08590290e-01f,
  2.67840885e-02f, 2.08102772e-03f, -3.62497792e-02f, 8.53972733e-02f, 4.08620834e-02f, -1.94356889e-02f, -1.01224527e-01f, -8.66274014e-02f, -4.10519727e-02f, 4.39040624e-02f,
  -1.02803461e-01f, -1.83283836e-02f, 6.42345697e-02f, -4.52367440e-02f, 3.13237985e-03f, 7.06945062e-02f, -5.44885322e-02f, -3.37702148e-02f, -9.91572663e-02f, -2.65288781e-02f,
  2.40872398e-01f, 1.60327733e-01f, 1.79362550e-01f, 1.99821815e-01f, -2.18410298e-01f, -4.12514955e-01f, -1.46812648e-01f, -1.80992857e-01f, 4.68282439e-02f, 1.06362820e-01f,
  -2.70294607e-01f, 4.70456183e-01f, -1.20192856e-01f, -6.43458664e-02f, -3.30768317e-01f, -1.06336243e-01f, -1.93257004e-01f, 4.17414540e-03f, -1.40338782e-02f, 7.17721358e-02f,
  -8.71361792e-02f, -1.97453991e-01f, -4.43709306e-02f, -2.45346371e-02f, 8.56918097e-02f, 2.68547714e-01f, -1.61362495e-02f, -1.11978479e-01f, 1.18718348e-01f, -1.31547570e-01f,
  -7.96306133e-02f, 6.89169690e-02f, 2.21681017e-02f, 4.40917164e-02f, -1.47199452e-01f, 1.33546636e-01f, 9.76816714e-02f, -5.20779490e-02f, 2.06075590e-02f, 3.84902880e-02f,
  1.31241530e-01f, 5.71105769e-03f, -6.31301701e-02f, -1.62371788e-02f, 9.31076054e-03f, 1.03157178e-01f, 1.06165960e-01f, 3.79408337e-02f, 3.50036751e-03f, 1.75192405e-03f,
  -1.43289492e-02f, 6.89917244e-03f, 5.32039590e-02f, 2.92590968e-02f, -9.12652835e-02f, 4.71761599e-02f, -3.74602862e-02f, -1.56499911e-02f, 6.00097738e-02f, 4.90283966e-02f,
  -9.68280211e-02f, -5.53996563e-02f, 1.27168754e-02f, 3.96399796e-02f, -3.54200751e-02f, -2.18456909e-02f, -1.73619017e-02f, -2.93331183e-02f, 6.41821101e-02f, -6.32366166e-02f,
  3.65936868e-02f, 4.91814688e-02f, -6.34995997e-02f, 3.84559222e-02f, 3.13764885e-02f, 2.75283530e-02f, 2.61158571e-02f, -5.87740866e-03f, -2.50743404e-02f, 5.33293560e-02f,
  -1.13272034e-01f, -6.74794391e-02f, 8.93248096e-02f, 5.40973470e-02f, -9.02244672e-02f, -2.35371082e-03f, 4.62124608e-02f, 1.10070735e-01f, -9.00584832e-02f, 8.60087425e-02f,
  -1.18722664e-02f, -1.09351821e-01f, 7.91899301e-03f, 3.94508764e-02f, 1.57568920e-02f, 6.48409221e-03f, -9.08829719e-02f, -4.44045402e-02f, -1.72966123e-02f, -6.61308020e-02f,
  -4.26576659e-02f, 1.42094791e-02f, 2.24022772e-02f, -6.30547032e-02f, -3.52572612e-02f, 1.92151684e-03f, 1.72832888e-02f, 2.22328585e-02f, -6.18198179e-02f, 6.24070410e-04f,
  4.06825468e-02f, 6.40400052e-02f, 1.54661257e-02f, 3.38381864e-02f, 1.17170006e-01f, -4.94147025e-05f, 2.16876250e-03f, 1.76936276e-02f, -3.34995463e-02f, -2.42812969e-02f,
  -4.16084707e-01f, 1.39754072e-01f, -2.64359593e-01f, -3.12141478e-01f, 1.71990201e-01f, -1.77538186e-01f, -4.59480286e-01f, 9.68136638e-03f, -2.42275611e-01f, -2.41087988e-01f,
  -1.80152640e-01f, -1.43069709e-02f, 1.33843655e-02f, -2.42151573e-01f, 4.71204966e-02f, 1.24425501e-01f, -3.01249325e-01f, -2.39093110e-01f, 1.76941723e-01f, -1.80947691e-01f,
  2.80951150e-02f, -7.26792663e-02f, 1.25260442e-01f, 2.04816058e-01f, -1.21498354e-01f, -1.51273042e-01f, -5.36423437e-02f, 6.05913326e-02f, -7.40206838e-02f, 3.96789014e-02f,
  -1.60140507e-02f, -1.03768960e-01f, -5.61895333e-02f, -4.13456671e-02f, -1.13762483e-01f, -4.55415137e-02f, -5.73651493e-02f, -2.86215916e-03f, -7.60246534e-03f, -2.15760134e-02f,
  -9.27688628e-02f, 2.66338866e-02f, -2.39525028e-02f, 6.40029982e-02f, -9.28616431e-03f, -4.05202657e-02f, 7.88299516e-02f, 4.23440114e-02f, 5.80162257e-02f, 8.90062824e-02f,
  2.27535591e-02f, -4.05174010e-02f, -2.66788676e-02f, -1.22563057e-01f, 1.03415214e-02f, 1.71908196e-02f, -4.53150868e-02f, -1.37488879e-02f, 9.47658718e-03f, -5.28496802e-02f,
  2.29145978e-02f, -6.50117025e-02f, -6.98033208e-03f, 1.38837118e-02f, -5.49810119e-02f, -2.51157079e-02f, -6.26273379e-02f, -5.21281874e-03f, 1.27012748e-03f, 8.46686363e-02f,
  -4.56695966e-02f, 6.12614937e-02f, 2.46155891e-04f, -5.58938012e-02f, -2.10568029e-03f, 2.95471251e-02f, 2.31873039e-02f, 1.02328965e-02f, -1.65613201e-02f, 2.64938660e-02f,
  -3.76067832e-02f, -2.22202968e-02f, -3.92121635e-02f, -5.49607584e-03f, 1.38211977e-02f, 5.12446612e-02f, 1.17573747e-02f, 2.48309616e-02f, 5.50966300e-02f, 7.31980149e-03f,
  1.27960006e-02f, -1.92123264e-01f, 5.20213284e-02f, 6.85157850e-02f, 4.81930152e-02f, 3.83424312e-02f, -1.45838351e-03f, 1.89610347e-02f, -5.89104518e-02f, -7.43485196e-03f,
  -2.21064351e-02f, 1.83631591e-02f, -3.21852006e-02f, -8.79558772e-02f, 4.51264009e-02f, -4.65532802e-02f, -6.52948618e-02f, -6.60149306e-02f, -1.20571479e-01f, 6.58884794e-02f,
  3.56559269e-02f, 3.90052013e-02f, -1.23380776e-02f, 1.10707441e-02f, 2.54502278e-02f, -4.90423068e-02f, -5.54191396e-02f, -3.90295172e-03f, 5.74473524e-03f, -7.55594764e-03f,
  5.10750636e-02f, -3.14396054e-01f, -2.89793760e-02f, 8.70870650e-02f, 1.36873662e-01f, 1.36953399e-01f, 6.32284507e-02f, -4.35946174e-02f, -2.41426170e-01f, -1.66083410e-01f,
  -6.40638843e-02f, -4.80039865e-02f, -9.60651711e-02f, -3.22070085e-02f, 4.77511659e-02f, -1.31888255e-01f, -7.87355825e-02f, -1.85249466e-02f, 1.43770399e-02f, 2.08872613e-02f,
  -3.52042913e-02f, 4.47995104e-02f, 2.96003800e-02f, -5.75721413e-02f, -8.30978155e-03f, -4.56817262e-02f, 5.94112761e-02f, 1.65171653e-01f, 1.72085688e-02f, 8.79309103e-02f,
  9.46514234e-02f, -9.72921923e-02f, -2.31732540e-02f, -1.27470761e-03f, -5.24347983e-02f, -2.46509071e-03f, 4.90787067e-02f, -1.06884716e-02f, -3.52617502e-02f, -1.25289783e-01f,
  5.14646247e-02f, -4.94724780e-04f, 6.10462278e-02f, 7.56573603e-02f, 1.70065463e-02f, 6.97337091e-02f, -4.93656732e-02f, -9.74460095e-02f, -5.56502864e-02f, -7.10816085e-02f,
  -4.23905216e-02f, -7.14643598e-02f, -3.70641164e-02f, 1.71499569e-02f, -1.39424410e-02f, -3.21241692e-02f, -7.37784505e-02f, -1.58459786e-03f, -5.55655397e-02f, 2.49385964e-02f,
  5.31512983e-02f, 2.70260423e-02f, 1.64721701e-02f, 1.02722511e-01f, -3.06722503e-02f, -5.74335456e-02f, -1.89637933e-02f, 2.14684894e-03f, 2.59312168e-02f, -3.45877884e-03f,
  -1.08802736e-01f, -2.48234197e-02f, 4.35521081e-02f, 2.76758615e-02f, -1.40543059e-02f, -1.98071264e-02f, -8.22556466e-02f, 3.42238173e-02f, -2.42823176e-02f, -7.02050179e-02f,
  -6.85862973e-02f, -6.72492757e-02f, 4.09009159e-02f, -3.63890789e-02f, -6.25622598e-03f, -5.74744828e-02f, 2.00316440e-02f, 6.44098744e-02f, 6.00233078e-02f, 1.55345090e-02f,
  1.74932107e-02f, -3.44619825e-02f, -6.59955889e-02f, 1.29697651e-01f, -4.28555533e-02f, -1.20690122e-01f, -1.00790085e-02f, 7.60973766e-02f, -8.40633810e-02f, -2.26537455e-02f,
  -1.07947877e-02f, 1.70143638e-02f, 9.22833681e-02f, 5.59246093e-02f, -2.27986239e-02f, 1.14935646e-02f, 7.50734564e-03f, 3.19204554e-02f, 6.01413380e-03f, 5.34689054e-02f,
  -6.94084093e-02f, -4.40763570e-02f, -6.74943924e-02f, -4.43596914e-02f, 8.83365422e-02f, -2.99760979e-02f, 3.66372941e-03f, 1.03931658e-01f, -6.17142171e-02f, -9.72453579e-02f,
  -1.22869611e-02f, -7.99684450e-02f, -3.19841877e-02f, 6.10375851e-02f, 7.26423487e-02f, 1.57374844e-01f, 1.33761123e-01f, 6.29635602e-02f, 9.30919051e-02f, 5.61643727e-02f,
  1.24916518e-02f, 7.57905990e-02f, -6.45345747e-02f, 2.94522978e-02f, 2.78590545e-02f, 1.04373232e-01f, -1.99043695e-02f, 1.15566943e-02f, 1.57967228e-02f, 8.91739428e-02f,
  -5.80932237e-02f, -7.43496940e-02f, -1.35409206e-01f, 7.45313568e-03f, 3.02184522e-02f, -8.36617276e-02f, -3.00827306e-02f, 2.75233220e-02f, -1.27510838e-02f, -3.93282473e-02f,
  1.41991064e-01f, 1.73605993e-01f, 3.66930962e-02f, -1.50498725e-03f, -9.14163962e-02f, -4.07527015e-02f, -2.06720941e-02f, -5.45090474e-02f, 9.05804932e-02f, -1.46563472e-02f,
  3.33137736e-02f, 1.40383877e-02f, 1.01546615e-01f, 7.01839849e-02f, 4.99443570e-03f, -5.44657558e-02f, -8.63117203e-02f, 5.22218421e-02f, -7.52311423e-02f, -8.34900215e-02f,
  -1.74868815e-02f, 9.47426539e-03f, -8.69578794e-02f, 9.43500400e-02f, -3.15749720e-02f, 9.57515761e-02f, 1.71266478e-02f, 2.78846864e-02f, -6.86562732e-02f, 2.55656410e-02f,
  -4.40857448e-02f, -8.28686878e-02f, 3.29117328e-02f, -6.54407069e-02f, 8.68532807e-02f, -5.96959749e-03f, -1.17321201e-01f, 3.48567888e-02f, 3.17571647e-02f, 5.79326004e-02f,
  -4.37474065e-03f, 4.05696221e-02f, 6.51635751e-02f, -3.34714656e-03f, 6.32688850e-02f, -3.28962132e-02f, -5.47522977e-02f, 6.30304124e-03f, 5.59341256e-03f, 1.82232261e-02f,
  1.50043694e-02f, 2.49400400e-02f, -7.97938854e-02f, -5.95170110e-02f, 1.01850182e-01f, -5.29545471e-02f, 2.14885417e-02f, -5.20157777e-02f, -9.20805931e-02f, 7.10514039e-02f,
  1.37598380e-01f, 3.79082300e-02f, -1.49666183e-02f, -2.91491766e-02f, 7.26133361e-02f, -5.37043996e-02f, 7.95649141e-02f, -7.11078644e-02f, 2.92802379e-02f, -4.11906317e-02f,
  -1.97065007e-02f, -1.64586455e-02f, 9.52163637e-02f, 2.45622210e-02f, -2.83728912e-02f, -2.83785965e-02f, -1.07877003e-02f, 1.27185598e-01f, -2.40846314e-02f, -1.49495574e-02f,
  -1.62655059e-02f, 7.33267069e-02f, -4.52629924e-02f, 1.72932539e-02f, -6.20148592e-02f, -7.08100898e-03f, 5.09060770e-02f, -3.05709187e-02f, 7.82692730e-02f, 2.35724058e-02f,
  -4.58010808e-02f, -2.88812429e-01f, -7.09193572e-02f, 7.66706793e-03f, -1.00575291e-01f, -6.07893653e-02f, 2.39332050e-01f, -2.78314114e-01f, -5.33717349e-02f, 1.22895621e-01f,
  1.08511165e-01f, 4.82612625e-02f, 7.72744045e-02f, 9.28488895e-02f, 5.81500381e-02f, 9.79814529e-02f, 2.06413627e-01f, 9.92920101e-02f, -1.20885700e-01f, 1.40272640e-02f,
  -7.08652362e-02f, 4.29555699e-02f, 5.25103137e-02f, -3.84003520e-02f, 7.81727508e-02f, -1.96741968e-01f, 1.15015395e-01f, -3.59942503e-02f, 1.98966078e-02f, 7.34498352e-02f,
  3.58820148e-02f, -1.08283669e-01f, 4.34346031e-03f, 6.91372380e-02f, -1.50424559e-02f, -3.38429883e-02f, 1.20988376e-01f, 1.20133244e-01f, 1.98680386e-02f, -1.07763365e-01f,
  -3.74515839e-02f, 2.34135538e-02f, -7.23343864e-02f, 8.62296894e-02f, -1.26380071e-01f, -8.38275105e-02f, 1.61402915e-02f, -1.11464679e-01f, 1.40641844e-02f, 1.73722934e-02f,
  -4.96994928e-02f, -4.92596254e-02f, -6.39708266e-02f, -3.09279971e-02f, -4.34129052e-02f, -6.48713633e-02f, 2.76450124e-02f, 6.11941740e-02f, -9.19069350e-02f, -9.00528058e-02f,
  -6.36602193e-03f, 1.47133321e-01f, -8.01780969e-02f, -7.82713294e-03f, -9.26190615e-02f, 5.24091907e-02f, 6.28122687e-02f, -4.29458022e-02f, 4.24790233e-02f, 6.02958389e-02f,
  2.36089323e-02f, -1.45466914e-02f, -3.69052887e-02f, 8.19070563e-02f, 7.02563673e-02f, 6.27363548e-02f, 3.46521363e-02f, 3.06790527e-02f, 7.33888075e-02f, -5.06496802e-03f,
  4.49558608e-02f, 2.88197789e-02f, 5.62578216e-02f, 4.26496938e-02f, 1.65281631e-02f, -3.24742757e-02f, 3.24700400e-02f, -1.83275398e-02f, -6.63709939e-02f, -2.84890551e-02f,
  -9.01648495e-03f, -1.82288691e-01f, -3.00449487e-02f, -2.36284342e-02f, 2.88004391e-02f, -4.15631495e-02f, -5.21891527e-02f, -5.41412979e-02f, -7.40552247e-02f, -9.59024280e-02f,
  4.22701351e-02f, 3.88210900e-02f, 2.95195561e-02f, -4.39045317e-02f, 7.57759288e-02f, -4.35338467e-02f, -8.82879347e-02f, 3.65066379e-02f, -8.01871419e-02f, -5.07538803e-02f,
  7.59129748e-02f, -9.30716246e-02f, 6.37124181e-02f, -3.49565223e-02f, 1.01556266e-02f, -5.11803478e-02f, -1.20445492e-03f, -5.61044365e-02f, -2.23248173e-02f, 7.95431212e-02f,
  -1.30495746e-02f, 9.09609720e-03f, -1.28271088e-01f, -1.73253015e-01f, 5.45085035e-02f, 1.33398725e-02f, -7.52295479e-02f, 7.12842867e-02f, -2.81757265e-01f, 1.28767267e-01f,
  1.33873731e-01f, -8.99192616e-02f, -7.12152049e-02f, -8.41986090e-02f, 6.55771419e-02f, -1.35309488e-01f, -7.84232747e-03f, -6.83557838e-02f, -1.09769985e-01f, 1.59602731e-01f,
  -6.94992542e-02f, 2.17337072e-01f, -9.60205048e-02f, 1.04903348e-01f, 2.65792031e-02f, -1.80307366e-02f, 2.91337967e-01f, 8.00444707e-02f, 1.94775268e-01f, 5.90797607e-03f,
  -6.84355348e-02f, 1.18836753e-01f, -6.87858760e-02f, -7.16312975e-02f, 9.65409949e-02f, 9.44357142e-02f, 6.67374507e-02f, -7.85162300e-03f, 1.46648427e-02f, -8.79021585e-02f,
  -4.11948301e-02f, -6.94572628e-02f, -8.14014375e-02f, -1.79722700e-02f, -5.17634414e-02f, -4.38898094e-02f, -5.77923935e-03f, -1.28213940e-02f, -5.56254871e-02f, -1.77043620e-02f,
  -1.24152750e-02f, 1.47339739e-02f, 2.31808866e-03f, -7.58141978e-03f, -3.28141749e-02f, 4.29469012e-02f, 4.17309767e-03f, 8.87949020e-02f, -5.60587756e-02f, 5.47047053e-03f,
  1.05735898e-01f, 5.63768530e-03f, -3.17581892e-02f, -3.10683325e-02f, -1.03454962e-02f, 9.52622369e-02f, -4.31957468e-02f, 6.01769313e-02f, 3.26900966e-02f, 3.60569805e-02f,
  -6.39378056e-02f, -5.14689600e-03f, 2.12466307e-02f, -2.36061774e-02f, -1.92007944e-02f, 1.93480682e-02f, 1.69316754e-02f, 1.96067728e-02f, -5.12903258e-02f, 2.22228058e-02f,
  7.08742952e-03f, -6.11381745e-03f, 1.08178668e-02f, -2.62354407e-02f, -3.56004834e-02f, -7.30276341e-03f, -3.88687328e-02f, 6.73397556e-02f, -7.26376176e-02f, -3.62507477e-02f,
  1.22019120e-01f, 1.61869720e-01f, -7.14003816e-02f, 2.25995034e-02f, -5.32592088e-02f, 9.13101211e-02f, -3.28967087e-02f, 3.60985808e-02f, 4.87574711e-02f, 7.76342526e-02f,
  7.67707154e-02f, 2.25927290e-02f, 1.54678807e-01f, -6.04416840e-02f, -5.16275726e-02f, 7.50484131e-03f, -4.15662723e-03f, -3.28092203e-02f, 9.99287702e-03f, 4.56336848e-02f,
  7.67019317e-02f, 2.62323562e-02f, -6.95336517e-03f, 3.03596146e-02f, -9.22169164e-03f, 3.08474700e-04f, 2.12639570e-02f, -2.08672583e-02f, 8.62123631e-03f, -6.36749938e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  8.01406801e-02f, 7.03452900e-02f, 1.88421726e-01f, 3.41511481e-02f, 3.28121990e-01f, -1.96602475e-03f, 1.16239026e-01f, 3.01978618e-01f, 7.22914876e-04f, -3.56181934e-02f,
  -2.28563766e-03f, -3.99893858e-02f, 2.21183285e-01f, 8.45561922e-02f, 2.42017303e-02f, 7.38651007e-02f, 9.38473120e-02f, -1.57273382e-01f, 7.73754120e-02f, -5.24445921e-02f,
  1.17560022e-01f, 1.85830310e-01f, -4.67487983e-03f, -2.13982165e-02f, 5.31978607e-02f, 2.22286671e-01f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  2.06795901e-01f, 1.94441825e-01f, -5.09856977e-02f, -1.65598869e-01f, -8.21652114e-02f, 1.09473974e-01f, -2.65246127e-02f, 2.56351709e-01f, 1.90954786e-02f, 1.80820704e-01f,
  1.33385971e-01f, 5.10409176e-02f, 1.66033566e-01f, 4.17159908e-02f, 5.40646426e-02f, -1.94809996e-02f, 1.63011625e-01f, -2.39409953e-01f, 2.84201771e-01f, 5.64791914e-03f,
  2.18812138e-01f, -1.31944284e-01f, 2.85011623e-02f, 2.20163986e-02f, -4.42887783e-01f, 8.32208246e-02f, -1.64454550e-01f, 1.38946131e-01f, -1.36489822e-02f, 8.24771598e-02f,
  6.07929900e-02f, -5.39436936e-02f, 2.07426667e-01f, 2.27429986e-01f, 1.46536008e-01f, -6.68674111e-02f, -2.38959774e-01f, -2.35159136e-03f, 5.04544005e-02f, 8.91992301e-02f,
  3.63379493e-02f, 1.44752279e-01f, -1.17645420e-01f, -4.15455662e-02f, 4.54411209e-02f, 2.73725148e-02f, -1.55769303e-01f, 8.25391412e-02f, 2.75152791e-02f, 1.62386969e-01f,
  -1.02405213e-01f, 2.33746156e-01f, 1.30185008e-01f, -1.04843900e-01f, -7.85867497e-02f, -7.48331994e-02f, -3.35344933e-02f, 2.58997411e-01f, 2.29244053e-01f, -4.16680165e-02f,
  -1.99750662e-01f, 1.69924200e-01f, -6.08676635e-02f, -1.66698750e-02f, 3.71152386e-02f, 1.96974412e-01f, 3.52135338e-02f, -1.19693115e-01f, -3.77051294e-01f, -3.26399297e-01f,
  -4.47735786e-02f, 2.28420764e-01f, -1.95393085e-01f, 8.80734902e-03f, 3.35710704e-01f, 9.01922137e-02f, 5.81484325e-02f, 5.86307794e-02f, -1.46009535e-01f, 5.66610508e-02f,
  2.31865067e-02f, -2.59315789e-01f, -5.80115430e-03f, -2.14355409e-01f, -2.13466734e-02f, 1.46952391e-01f, 2.60118037e-01f, -3.46177638e-01f, 3.32237214e-01f, 2.06073493e-01f,
  2.67914534e-01f, 9.81681198e-02f, 1.14481542e-02f, 5.71936294e-02f, -3.22425008e-01f, -2.27901056e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  2.69508332e-01f, 2.91057289e-01f, 3.96853805e-01f, 2.14899346e-01f, -2.52711535e-01f, -2.69503240e-02f, 2.60837883e-01f, 5.61598465e-02f, -1.25486434e-01f, 2.47963425e-02f,
  -5.68323806e-02f, 3.85972373e-02f, 1.32812783e-01f, 3.17894936e-01f, -1.53198540e-01f, -7.77589306e-02f, 1.89361528e-01f, -1.74861357e-01f, 1.86716557e-01f, 1.06190369e-01f,
  1.65121973e-01f, 2.33533606e-01f, 3.14483911e-01f, -3.63404602e-02f, 2.28078246e-01f, 2.16638297e-01f, 3.81240726e-01f, 5.38329780e-01f, -1.14837037e-02f, 1.67939097e-01f,
  -2.83282757e-01f, 1.84922263e-01f, 1.56714559e-01f, 1.09838687e-01f, 1.70574069e-01f, 5.37067950e-02f, -1.81672156e-01f, -2.14247331e-01f, 1.51698619e-01f, -5.83399534e-02f,
  1.80375054e-01f, 1.79329202e-01f, -2.09573917e-02f, 3.58982803e-03f, -1.31033525e-01f, -7.55759552e-02f, 3.88525128e-01f, 1.11521883e-02f, 6.87025189e-02f, 3.01037937e-01f,
  2.46531069e-02f, 1.54992819e-01f, -2.23152265e-01f, -2.96630692e-02f, -1.87285781e-01f, 3.53444189e-01f, 2.12808415e-01f, 3.32476832e-02f, 2.29940221e-01f, -1.57806769e-01f,
  -7.26003870e-02f, -2.32331797e-01f, -3.42998020e-02f, 3.23095441e-01f, 3.07383180e-01f, 2.84878343e-01f, -2.94608504e-01f, -7.90619627e-02f, 2.51123279e-01f, 5.73585868e-01f,
  3.10506493e-01f, -8.27925578e-02f, 1.38882220e-01f, 4.07963246e-02f, -1.61716547e-02f, 1.06500223e-01f, 3.54670852e-01f, 5.06503224e-01f, -3.17736864e-01f, -2.18376607e-01f,
  2.40329430e-01f, -2.98667014e-01f, 4.99780387e-01f, -4.95649762e-02f, -5.72816618e-02f, 1.80774145e-02f, -9.04911831e-02f, 3.41090709e-02f, -2.49721542e-01f, 4.49965596e-01f,
  1.14040948e-01f, 5.72977066e-01f, -8.59432369e-02f, -2.50101924e-01f, 8.28656331e-02f, -1.18689746e-01f, -2.75353137e-02f, -4.60023135e-02f, -3.82250771e-02f, -2.02016830e-02f,
  1.44530892e-01f, -1.30549952e-01f, -1.45408764e-01f, -2.98204701e-02f, 1.27232820e-01f, -6.47091419e-02f, -1.01531602e-01f, 9.55873355e-02f, -1.33645207e-01f, 5.78690134e-02f,
  -5.07699400e-02f, -1.55781046e-01f, -1.67822778e-01f, 4.57623526e-02f, 9.93319377e-02f, -1.16251163e-01f, -8.70088413e-02f, 5.26477545e-02f, 4.32048142e-02f, 1.71208143e-01f,
  -1.29410222e-01f, 1.18437834e-01f, -3.26052792e-02f, 4.66763750e-02f, -1.07223332e-01f, -5.17737046e-02f, -3.89562845e-02f, -1.14578053e-01f, 3.63900214e-01f, 1.55317441e-01f,
  4.24733371e-01f, -7.40018673e-03f, -2.80241370e-01f, 9.55825225e-02f, 9.35942307e-02f, -1.24216914e-01f, 2.55866408e-01f, -9.09192413e-02f, -1.75642565e-01f, -1.91498011e-01f,
  1.16200171e-01f, -1.53719902e-01f, -6.84603080e-02f, -3.04188970e-02f, -9.73229855e-02f, 3.18610579e-01f, -1.15770973e-01f, -4.22862209e-02f, 6.72704354e-02f, 6.39226064e-02f,
  1.68180138e-01f, 1.04920559e-01f, 4.96642083e-01f, -4.76302207e-03f, 1.32087544e-01f, 2.13750884e-01f, 4.52268161e-02f, -8.86499509e-02f, 8.00428260e-03f, 2.81148106e-01f,
  -7.02072009e-02f, -5.01600727e-02f, 8.11338308e-04f, 5.93854003e-02f, -2.41116155e-02f, 2.74864197e-01f, -4.13868837e-02f, -1.19651780e-01f, -1.06948234e-01f, 2.01880299e-02f,
  1.22857682e-01f, -1.23353608e-01f, 2.81441808e-01f, 2.11019620e-01f, -1.08911596e-01f, 1.78658620e-01f, 7.72832781e-02f, 6.52477220e-02f, 7.04602003e-02f, -2.84262765e-02f,
  1.84429288e-01f, 1.75931871e-01f, 1.28383383e-01f, 7.58177117e-02f, 1.99296892e-01f, 2.06729844e-01f, -1.36264816e-01f, 3.00997198e-01f, 1.52534068e-01f, -1.28133461e-01f,
  -8.10533948e-03f, 5.48013039e-02f, 3.84153891e-03f, 3.59331399e-01f, 2.29745492e-01f, -1.40958235e-01f, -3.16174179e-01f, -4.19073075e-01f, -1.62870079e-01f, 9.46230143e-02f,
  -2.19964042e-01f, 1.86187595e-01f, 4.27526265e-01f, 9.22240987e-02f, -1.60799727e-01f, 8.18782225e-02f, 8.90068859e-02f, -1.14192866e-01f, 2.12397143e-01f, 1.83706954e-01f,
  2.32319832e-02f, 2.55605340e-01f, 1.55803844e-01f, 2.28376701e-01f, 2.85498142e-01f, 3.26488428e-02f, -3.64447199e-02f, -6.32329807e-02f, 4.02535200e-01f, -2.89688185e-02f,
  -2.07543075e-01f, -1.47112355e-01f, -1.29972711e-01f, -1.60177127e-01f, 1.53659359e-01f, 2.82099210e-02f, 5.30654080e-02f, 1.24357782e-01f, 1.17568793e-02f, -2.13779390e-01f,
  -4.73137340e-03f, -1.06139153e-01f, -6.83420599e-02f, 6.47903606e-02f, 5.98087497e-02f, 3.50556755e-03f, 1.61581919e-01f, -7.64768869e-02f, 2.12609962e-01f, -5.54481708e-02f,
  -1.43796220e-01f, -3.55703905e-02f, 6.79418221e-02f, 1.86523199e-01f, 7.29865357e-02f, 1.76187366e-01f, -8.92526209e-02f, 2.43950412e-01f, -4.80577722e-02f, -1.29410415e-04f,
  3.37543190e-01f, -4.93543968e-02f, 2.20723435e-01f, -1.96754754e-01f, 8.32860097e-02f, -5.53653948e-02f, 9.08108726e-02f, 6.70594126e-02f, 2.66207039e-01f, -5.88987395e-02f,
  9.01619941e-02f, -2.04420358e-01f, 1.69711173e-01f, -1.32156581e-01f, -1.71832219e-02f, -1.38814896e-01f, 1.76041141e-01f, -6.80623017e-03f, 4.07769643e-02f, 8.87520611e-02f,
  -7.65081961e-03f, 1.41400158e-01f, -2.00483333e-02f, 1.94667101e-01f, 3.69265233e-03f, 1.32085830e-01f, 5.24984226e-02f, -3.35000567e-02f, -1.28684014e-01f, 2.28073150e-01f,
  1.36386588e-01f, -7.84583986e-02f, -5.32437749e-02f, 6.11196794e-02f, 2.25953296e-01f, -5.75480834e-02f, 2.17205554e-01f, 4.05487455e-02f, -6.28328416e-03f, 1.21738717e-01f,
  -6.39347062e-02f, 1.95337553e-02f, 9.43944603e-02f, 1.85137942e-01f, -1.43124774e-01f, -7.63451234e-02f, -1.56711742e-01f, -1.47813171e-01f, 1.39841303e-01f, -1.31731346e-01f,
  1.92334160e-01f, 8.67934451e-02f, -1.09856993e-01f, -1.53681427e-01f, -8.15834776e-02f, -3.19012403e-02f, 1.16718680e-01f, 1.00990936e-01f, -1.21472977e-01f, -6.88680038e-02f,
  -3.48010659e-02f, -4.30482514e-02f, 1.40026376e-01f, 7.41083175e-02f, 8.27109069e-02f, -7.71467760e-02f, -1.41969308e-01f, 4.09144461e-02f, -1.17459700e-01f, -9.20183286e-02f,
  1.30473346e-01f, 1.44594267e-01f, -1.33949379e-02f, -4.86699827e-02f, 2.93531001e-01f, 1.86724499e-01f, 1.67804673e-01f, -8.08283538e-02f, -1.62378788e-01f, 3.33115049e-02f,
  1.17960870e-01f, 8.14908445e-02f, 1.62037402e-01f, 1.62389353e-02f, -1.76970772e-02f, -7.54788294e-02f, -5.98761290e-02f, -3.75587344e-02f, 1.83961630e-01f, -1.30632535e-01f,
  -1.46848261e-01f, -7.83197507e-02f, -9.90390703e-02f, 1.18180856e-01f, -5.83742447e-02f, 1.30555192e-02f, -1.91449717e-01f, -9.21134353e-02f, 1.29988313e-01f, 3.09115928e-02f,
  2.70828068e-01f, -1.65509805e-01f, 1.04027607e-01f, 3.17280181e-02f, -1.31446254e-02f, -1.79653019e-01f, -9.03555155e-02f, 1.69683099e-02f, -1.55884027e-01f, 2.66068652e-02f,
  -1.16568319e-01f, -2.43735500e-02f, 2.71929186e-02f, -9.31767300e-02f, -1.52205020e-01f, -1.55624896e-01f, 1.15920626e-01f, 1.08211353e-01f, -1.16632454e-01f, -1.00553259e-01f,
  -9.71889030e-03f, -1.81726173e-01f, 8.97513889e-03f, -6.17279224e-02f, -4.36514057e-02f, -1.61681727e-01f, -1.33184671e-01f, -1.71755418e-01f, 2.38378290e-02f, 1.03847183e-01f,
  1.68582380e-01f, 1.32853463e-01f, 2.08498344e-01f, 1.81693211e-01f, 1.18140370e-01f, 2.97090225e-02f, 1.78652778e-01f, -8.16856176e-02f, -2.22805575e-01f, -1.45926565e-01f,
  1.88658446e-01f, 2.38404185e-01f, 1.39138803e-01f, 1.65887892e-01f, -3.03925294e-02f, 1.10757627e-01f, 1.85366664e-02f, 2.52127379e-01f, -5.26989065e-03f, 4.80539836e-02f,
  1.94267765e-01f, -1.49324611e-01f, 1.07958898e-01f, 3.45338941e-01f, 2.58350015e-01f, 2.23981030e-02f, -3.44091817e-03f, 8.18907022e-02f, -2.42628708e-01f, 2.34465897e-01f,
  2.81405091e-01f, 2.44602516e-01f, -9.49900895e-02f, 6.01443537e-02f, -1.06950566e-01f, -1.32268250e-01f, -2.53556166e-02f, 1.61112472e-01f, -6.66843280e-02f, -9.20099616e-02f,
  -1.04461089e-01f, 1.45398721e-01f, 2.94851419e-02f, 3.69755588e-02f, 2.99749374e-01f, 2.64765561e-01f, 6.97260648e-02f, -1.12708332e-02f, -1.13665052e-01f, 8.91467631e-02f,
  -5.24520874e-02f, 4.36287262e-02f, 9.79241282e-02f, 3.09020370e-01f, 7.97243640e-02f, 2.12687328e-01f, 4.58971523e-02f, -1.67274863e-01f, -8.42940584e-02f, 2.27001011e-01f,
  -1.98091537e-01f, 3.40238661e-02f, -4.39962186e-02f, -5.17697632e-02f, 1.06179021e-01f, 2.23682895e-02f, 1.37711585e-01f, 2.61251330e-01f, 3.36284757e-01f, 2.53765434e-01f,
  4.29253876e-01f, 1.04437530e-01f, -2.30134234e-01f, -1.63784161e-01f, -9.01863500e-02f, 3.31828855e-02f, 1.36616588e-01f, 2.13528067e-01f, 2.82669485e-01f, -1.90847024e-01f,
  -1.22863151e-01f, 1.93590090e-01f, 5.64437471e-02f, -1.39671907e-01f, 1.48210689e-01f, -1.11965768e-01f, -9.17175636e-02f, 2.59975642e-01f, -1.35960028e-01f, 2.59475559e-01f,
  3.32395643e-01f, -1.89776286e-01f, 4.36567903e-01f, 1.49929762e-01f, 3.53375971e-01f, 3.99368465e-01f, -2.46475577e-01f, -1.89871807e-02f, -1.57548279e-01f, 6.25515953e-02f,
  1.89096272e-01f, -2.22321954e-02f, 1.26164317e-01f, 1.18493177e-01f, 1.88889712e-01f, -3.05984795e-01f, -1.54926434e-01f, 2.62281626e-01f, -1.61991194e-01f, 1.04816042e-01f,
  2.68201321e-01f, 9.24076736e-02f, 1.19969204e-01f, -9.43580270e-02f, 7.50510469e-02f, -1.03391439e-01f, -1.44461310e-02f, 1.11846365e-01f, -1.27093773e-02f, -1.50310501e-01f,
  2.28642859e-02f, 8.51106793e-02f, 1.31024450e-01f, 1.92525491e-01f, -1.86321750e-01f, -1.77940857e-02f, 2.34824106e-01f, -1.59853607e-01f, 2.15554446e-01f, 1.66404560e-01f,
  -1.01921976e-01f, -2.16557533e-01f, -1.25588223e-01f, 1.38400376e-01f, -1.19754538e-01f, 1.38578236e-01f, 1.50709763e-01f, 1.45716190e-01f, 1.76270396e-01f, 1.41136035e-01f,
  -1.33638933e-01f, 4.29233760e-02f, 8.79732594e-02f, 5.42217754e-02f, 1.80619091e-01f, -3.38962264e-02f, -1.09292135e-01f, -5.00285774e-02f, -1.59732759e-01f, -2.60763709e-02f,
  -5.82781760e-03f, -1.37873664e-01f, 1.63579270e-01f, 3.88838276e-02f, 2.17179447e-01f, -6.61388785e-02f, 1.57829851e-01f, -1.15129210e-01f, -1.58799171e-01f, 2.10826442e-01f,
  -7.47389197e-02f, 8.04294571e-02f, -9.71417055e-02f, 5.78181408e-02f, 8.42905119e-02f, -2.89257336e-02f, -2.09563002e-01f, -1.66002855e-01f, -1.58946052e-01f, 1.21432794e-02f,
  1.30837888e-01f, 2.80672405e-03f, -1.70537576e-01f, -7.69764781e-02f, -4.16656807e-02f, -1.43654570e-01f, -1.18002810e-01f, 1.08912103e-02f, -8.88637081e-02f, 5.01138577e-03f,
  5.84486723e-02f, -1.31961897e-01f, 1.11386761e-01f, -1.32908925e-01f, -5.51064722e-02f, -5.56347780e-02f, 1.08681925e-01f, -1.54227749e-01f, -8.80246386e-02f, 1.50486946e-01f,
  -7.29768723e-02f, -1.23280175e-01f, 1.31637320e-01f, -1.21467993e-01f, 3.20804678e-02f, 9.85722169e-02f, 5.55462465e-02f, -6.79255500e-02f, 2.06461638e-01f, -2.76517570e-02f,
  -9.04722437e-02f, 1.97183698e-01f, 1.72857419e-01f, 1.13380119e-01f, 1.48464208e-02f, 1.51477039e-01f, -6.38268366e-02f, 1.24730818e-01f, -1.49610162e-01f, 1.73133284e-01f,
  9.04158056e-02f, 1.67646080e-01f, 1.12633824e-01f, 6.55224994e-02f, -6.49363175e-02f, 2.13086218e-01f, -2.77626980e-02f, 8.51362795e-02f, -3.70752551e-02f, -1.35548934e-01f,
  2.28737265e-01f, 1.46819443e-01f, -5.52661344e-02f, -6.49085641e-02f, -1.18533678e-01f, 9.32448655e-02f, -1.02731576e-02f, 2.50987619e-01f, -1.90961972e-01f, 6.81525469e-02f,
  -2.59683840e-02f, -1.48318391e-02f, 3.93751040e-02f, -1.28932014e-01f, 7.83822592e-03f, -6.27276301e-02f, -1.43243641e-01f, 1.37093782e-01f, -1.35133773e-01f, 7.17174634e-02f,
  -1.20013438e-01f, -5.32867908e-02f, -1.28664345e-01f, 1.40187040e-01f, 1.46339700e-01f, 9.95749682e-02f, -3.29952600e-04f, 8.45792368e-02f, -1.84280127e-01f, 9.60647091e-02f,
  -1.20806485e-01f, -1.58570021e-01f, -9.97651070e-02f, 1.19530469e-01f, -3.73029746e-02f, 6.44153282e-02f, -5.24493493e-02f, 9.28670317e-02f, -9.70861167e-02f, -4.35287766e-02f,
  1.64523140e-01f, 1.68176085e-01f, -2.22567432e-02f, 9.38971061e-03f, 2.01293811e-01f, -2.88162291e-01f, -5.46695739e-02f, 1.81898534e-01f, 8.03986117e-02f, 1.60874218e-01f,
  2.09960639e-01f, 9.49816629e-02f, -9.92749110e-02f, 1.52698830e-02f, 2.22801223e-01f, 6.40933635e-03f, -5.08622304e-02f, 9.44660977e-02f, -4.24691513e-02f, 1.93379611e-01f,
  -1.15349427e-01f, -1.41185373e-01f, -1.85024932e-01f, 3.04296672e-01f, -4.99144830e-02f, -6.29488379e-02f, -6.51768520e-02f, 2.42024269e-02f, 1.14874225e-02f, 6.99889800e-03f,
  2.60421559e-02f, 5.84237091e-02f, 2.36920148e-01f, 4.01533805e-02f, 1.93643287e-01f, -1.41945317e-01f, -1.03308177e-02f, -2.80179232e-02f, -1.06736749e-01f, 2.53897369e-01f,
  -9.39042196e-02f, 3.91036645e-02f, 3.16433251e-01f, 1.31977588e-01f, 2.32585985e-02f, 1.21723697e-01f, 1.18038759e-01f, -1.34800255e-01f, 4.67678905e-03f, -2.42939051e-02f,
  -2.29993672e-03f, 1.54567912e-01f, -4.83068489e-02f, -5.06531335e-02f, 1.56431273e-01f, 2.85442352e-01f, -2.54454494e-01f, -1.64049610e-01f, 3.33776623e-01f, -1.65795654e-01f,
  2.84049548e-02f, 1.63736716e-01f, 1.22493818e-01f, -6.18487857e-02f, 1.36290997e-01f, 3.12124994e-02f, 3.94469380e-01f, 1.67763785e-01f, -2.16485262e-01f, 7.57314637e-02f,
  -1.42809927e-01f, -6.79669976e-02f, 1.33579209e-01f, -7.51724746e-03f, 2.08404422e-01f, -8.18230119e-03f, -4.06186096e-02f, 9.36377496e-02f, 1.33706123e-01f, 5.28144576e-02f,
  1.71699807e-01f, 6.98566437e-02f, 1.87086254e-01f, -4.66356054e-02f, 2.31149480e-01f, 7.42560104e-02f, 6.41713738e-02f, -2.16959178e-01f, -1.45624191e-01f, 1.58384517e-01f,
  1.65097229e-02f, 1.74529627e-01f, -1.41090795e-01f, 1.97268233e-01f, 8.57040845e-03f, 1.55101597e-01f, -6.02876768e-02f, 6.16397597e-02f, 3.45350988e-02f, 5.03900163e-02f,
  1.79649323e-01f, -2.23994240e-01f, 1.10672794e-01f, 1.75245717e-01f, 2.54300028e-01f, -2.40819026e-02f, 1.03635222e-01f, 1.69295430e-01f, -1.15068845e-01f, -1.68620914e-01f,
  3.38541746e-01f, -5.33724427e-02f, 1.28882125e-01f, 2.56333500e-01f, -2.46071140e-03f, 1.00161862e-02f, -1.41361803e-01f, -4.78501916e-02f, -1.15748160e-01f, 3.03361744e-01f,
  -1.08811215e-01f, 1.00382514e-01f, -1.42589375e-01f, -1.43991098e-01f, 1.16438240e-01f, -4.02022004e-02f, 2.89452095e-02f, -1.23820629e-03f, 9.89223868e-02f, 1.16155110e-01f,
  4.26622070e-02f, -2.52782144e-02f, -4.58677970e-02f, -2.15699226e-01f, 4.29266319e-02f, 8.27818513e-02f, -1.52610451e-01f, 1.27996400e-01f, 1.98227718e-01f, 5.52031323e-02f,
  -8.33550617e-02f, -3.80267128e-02f, 1.13632746e-01f, 1.37495890e-01f, -1.76843226e-01f, -3.37811969e-02f, -1.12701915e-01f, 1.80948675e-01f, -3.58259194e-02f, 1.38468623e-01f,
  -6.69118091e-02f, 2.26570174e-01f, -2.07402587e-01f, 1.41740695e-01f, 2.21643269e-01f, -1.78567231e-01f, -1.22274138e-01f, -7.85327405e-02f, -9.94676575e-02f, -1.55102119e-01f,
  2.74159878e-01f, 3.54798920e-02f, 2.57749051e-01f, -8.48563537e-02f, 2.39682406e-01f, -2.98660159e-01f, -1.38934731e-01f, 2.91270241e-02f, 1.53478354e-01f, -1.77398533e-01f,
  3.23911339e-01f, 4.25882451e-02f, 1.13308378e-01f, -9.31150392e-02f, 3.37716907e-01f, -5.95655553e-02f, -1.94227602e-02f, 7.80638903e-02f, 1.42319696e-02f, -1.48534760e-01f,
  -1.94903955e-01f, 2.28308365e-02f, 2.81169247e-02f, 1.77829102e-01f, 2.59451419e-01f, 5.97657934e-02f, -1.03711218e-01f, -5.13402335e-02f, 2.51342773e-01f, 4.05815542e-02f,
  1.67704582e-01f, 1.29293233e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  1.90438196e-01f, 2.67720014e-01f, 3.81562203e-01f, 2.17623301e-02f, 2.62017190e-01f, -2.37335730e-02f, 1.98173225e-01f, 9.41272601e-02f, 2.72372544e-01f, 1.34076402e-01f,
  2.36124963e-01f, 2.42714137e-01f, 2.25672692e-01f, 2.50512958e-01f, 7.69594759e-02f, 1.64327413e-01f, -2.59167198e-02f, -2.27488309e-01f, 6.37345463e-02f, -1.01916231e-01f,
  -3.08790784e-02f, 5.87375239e-02f, 3.43362093e-01f, 1.87883675e-01f, 2.70040929e-01f, 2.11518466e-01f
};

// L2_fan_Wp (Shape: 3 x 32)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  1.81230217e-01f, -4.16209828e-03f, -1.85421109e-01f, -1.89624891e-01f, -2.02918231e-01f, 7.97640979e-02f, -1.08782105e-01f, 1.80789083e-01f, 1.13029994e-01f, 8.97879079e-02f,
  -3.08776107e-02f, 1.68664157e-01f, 2.22941488e-01f, 2.16980472e-01f, -1.37534648e-01f, 4.91423048e-02f, -7.06289038e-02f, -1.32739365e-01f, 7.14705186e-03f, -2.34510958e-01f,
  1.70748338e-01f, 3.75203304e-02f, 1.12131998e-01f, 4.72057462e-02f, -1.77873388e-01f, 1.32910654e-01f, 1.64200380e-01f, 2.15577379e-01f, -2.55119771e-01f, -4.31496724e-02f,
  1.86949596e-01f, 2.14109048e-01f, -1.43662453e-01f, -3.82883511e-02f, 5.93218580e-02f, -5.58402762e-02f, -1.35496691e-01f, 2.17945352e-01f, 2.31937721e-01f, -1.66038200e-02f,
  3.57850671e-01f, -4.33090329e-03f, -2.72599161e-01f, 1.67702332e-01f, 6.53427020e-02f, -2.56104004e-02f, -9.56372023e-02f, 1.12052336e-01f, -9.11159441e-03f, -1.61047593e-01f,
  2.56655961e-01f, -1.24716185e-01f, -1.31258294e-01f, 8.87996107e-02f, 4.26678769e-02f, 1.66906398e-02f, -1.73173577e-01f, 2.01232769e-02f, 5.12524974e-03f, 2.40877573e-03f,
  -9.58115906e-02f, -8.18512738e-02f, -4.66667525e-02f, -5.17311655e-02f, 7.62793571e-02f, -1.30102575e-01f, -2.97537565e-01f, -3.93343344e-02f, 1.05533628e-02f, 3.50302726e-01f,
  9.43726972e-02f, 9.45993364e-02f, -9.04353261e-02f, 1.22568198e-01f, -7.86820054e-02f, -1.85008511e-01f, 3.29684675e-01f, 1.33179933e-01f, 9.11530480e-02f, -1.26608297e-01f,
  -1.43801764e-01f, -5.99014238e-02f, -9.35598090e-02f, -9.66025218e-02f, 2.43130475e-01f, 1.55547336e-01f, -1.05937950e-01f, 1.69024587e-01f, -2.02371478e-01f, 1.57884821e-01f,
  5.05058430e-02f, 2.36809745e-01f, -2.73148686e-01f, -1.01966798e-01f, 2.89613068e-01f, 4.84411092e-03f
};

// L2_fan_Wp_bar (Shape: 26 x 32)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  2.00903594e-01f, 2.94559330e-01f, -2.84854583e-02f, -9.26192254e-02f, -5.40963411e-02f, -1.71890914e-01f, 2.38707930e-01f, 2.81241030e-01f, -1.13855787e-01f, -3.24749500e-02f,
  4.65583563e-01f, 5.91013245e-02f, -2.74019986e-01f, 8.78673606e-03f, 2.68640190e-01f, -1.04258627e-01f, 9.38336831e-03f, -1.59584448e-01f, -2.39955187e-01f, 2.46833693e-02f,
  1.32153824e-01f, -1.70345474e-02f, -2.22995616e-02f, 6.98300600e-02f, 1.06306329e-01f, -4.74198796e-02f, -1.14250153e-01f, -1.38641968e-01f, 5.67128882e-03f, 2.04787970e-01f,
  -2.20761403e-01f, 3.30215961e-01f, 3.27948630e-01f, 1.99645400e-01f, 1.92203447e-01f, -1.61692023e-01f, 3.60221118e-02f, -3.36365223e-01f, -8.49718750e-02f, 4.70113218e-01f,
  -2.40421623e-01f, 1.40673742e-01f, 6.58766627e-02f, -8.20524842e-02f, 1.83682680e-01f, 1.84974462e-01f, 1.91612318e-01f, -7.25846589e-02f, -1.10686749e-01f, -6.57506660e-03f,
  1.32481620e-01f, 3.75176549e-01f, 9.97690260e-02f, 2.28148594e-01f, -6.96216896e-02f, 6.34847060e-02f, 1.20793365e-01f, -1.80076733e-01f, 4.17321324e-01f, 1.99262366e-01f,
  -7.59817660e-02f, 2.41227284e-01f, 1.87005654e-01f, 1.43161476e-01f, -1.48619503e-01f, -1.52245283e-01f, 9.88234505e-02f, 6.15211502e-02f, -1.55197829e-02f, -7.73834735e-02f,
  1.39357984e-01f, 2.67443031e-01f, -1.31294653e-01f, 1.10017799e-01f, -7.60758892e-02f, 3.21181417e-02f, 3.29648882e-01f, 7.04659820e-02f, -1.30076751e-01f, -4.79233153e-02f,
  3.46862227e-02f, 9.29708499e-03f, 3.36549133e-01f, 7.88870752e-02f, 1.95680246e-01f, 2.88234409e-02f, -2.05573723e-01f, 2.00942717e-02f, 8.02155025e-03f, -1.12729430e-01f,
  2.19197422e-01f, 2.09060922e-01f, 2.34264899e-02f, 1.94822073e-01f, 3.62304412e-02f, 9.68923494e-02f, 2.51692031e-02f, 4.73076571e-03f, 9.46313962e-02f, -8.86757895e-02f,
  -1.08577602e-01f, 2.08306815e-02f, -1.21443339e-01f, -7.60727450e-02f, -1.23405725e-01f, -1.69348970e-01f, -6.87588975e-02f, -1.07357763e-02f, 6.46618530e-02f, 7.76265264e-02f,
  -5.81141897e-02f, -3.10674105e-02f, 3.64966169e-02f, 1.15068123e-01f, -7.49979168e-02f, 8.64787325e-02f, 8.02610368e-02f, -1.20586991e-01f, 1.73794776e-01f, -5.42354845e-02f,
  -4.01214473e-02f, -8.15919265e-02f, -1.55467167e-01f, -9.16873068e-02f, -1.66676636e-03f, -5.65228350e-02f, -2.34093815e-02f, 1.22306377e-01f, 9.98892188e-02f, 6.19739108e-02f,
  2.48659290e-02f, 1.42517045e-01f, 2.75746852e-01f, 1.91093847e-01f, 1.33045733e-01f, -7.27887899e-02f, -1.10144734e-01f, -2.92776600e-02f, 1.93635166e-01f, 6.45919815e-02f,
  8.70801881e-02f, 6.28134385e-02f, -7.16752559e-02f, -9.02468637e-02f, -8.59961957e-02f, 5.41864820e-02f, 4.06177416e-02f, 1.22707762e-01f, -3.58563289e-02f, -3.58375199e-02f,
  -4.26893979e-02f, 1.65065810e-01f, 1.35327548e-01f, -4.49147262e-02f, -1.65138215e-01f, -7.51004294e-02f, 1.75385952e-01f, -7.97261223e-02f, 2.05323279e-01f, -1.00081272e-01f,
  -2.50020176e-02f, -1.96860999e-01f, 3.32685187e-02f, 3.22551936e-01f, 7.38144591e-02f, 3.57065558e-01f, 2.64550090e-01f, 1.14045337e-01f, 3.48102450e-01f, -1.13038376e-01f,
  -2.46584564e-01f, -1.85918078e-01f, 1.88150808e-01f, 5.14708459e-02f, 1.53346658e-01f, -1.01135686e-01f, -2.23827779e-01f, -3.29606682e-02f, 4.88539010e-01f, 1.60320267e-01f,
  7.25424290e-02f, 2.03301385e-01f, 6.94361180e-02f, -1.49357498e-01f, -4.67096753e-02f, 6.26835376e-02f, 1.14966400e-01f, 7.47593939e-02f, 2.01018468e-01f, -1.24535643e-01f,
  1.77406818e-01f, -1.52812108e-01f, -2.57353205e-02f, -2.25768480e-02f, 1.74120888e-01f, -7.30790794e-02f, 9.26235840e-02f, -1.30417794e-01f, 4.61936265e-01f, 3.00719291e-01f,
  4.24291521e-01f, -4.95173875e-03f, 3.32978934e-01f, 2.82858133e-01f, -2.17786357e-02f, -1.88849330e-01f, 6.49718344e-02f, -6.46687672e-02f, -1.68945312e-01f, -1.37310540e-02f,
  2.77997643e-01f, 4.62489240e-02f, 2.98975796e-01f, -2.81325281e-01f, -3.38191465e-02f, 4.76185754e-02f, 2.12097153e-01f, 6.49692714e-02f, -1.48707077e-01f, -1.88506037e-01f,
  6.71919957e-02f, 8.69720206e-02f, -1.71419531e-01f, 2.88149733e-02f, -5.34249134e-02f, 8.38619918e-02f, -9.22664553e-02f, 5.34342751e-02f, -8.65359325e-03f, 2.91783065e-01f,
  1.30293757e-01f, -3.82733867e-02f, -1.38961062e-01f, 1.18562512e-01f, -1.00838142e-02f, 3.79605815e-02f, -2.43021152e-03f, -1.84859186e-01f, -1.52191788e-01f, 1.15326606e-01f,
  9.54755582e-03f, -1.53731823e-01f, 9.49400365e-02f, 9.31417048e-02f, 1.64086409e-02f, 9.14500281e-02f, 4.52815853e-02f, -3.01776230e-02f, -9.94623899e-02f, 7.76651055e-02f,
  -1.00209348e-01f, 3.33172642e-02f, -1.04941741e-01f, 1.53892413e-01f, 1.36271909e-01f, 3.32756490e-02f, 1.27807483e-01f, 2.97268033e-01f, 2.46736318e-01f, 3.43106985e-01f,
  1.13751888e-01f, -2.30125561e-01f, 2.09357053e-01f, -2.30695084e-01f, 9.12629068e-01f, 6.11776821e-02f, -9.18408018e-03f, 2.81527966e-01f, -1.17580794e-01f, -1.00152098e-01f,
  -8.51459801e-02f, 2.40574598e-01f, 1.65322632e-01f, 8.30397476e-03f, 2.20337629e-01f, 2.45303079e-01f, 5.66278994e-02f, -1.88843220e-01f, -2.64246333e-02f, -1.10688448e-01f,
  1.57898255e-02f, -1.02557190e-01f, 2.94171972e-03f, 2.92422585e-02f, 1.69451535e-01f, -1.63047671e-01f, -1.06220596e-01f, -2.18211457e-01f, 1.26388045e-02f, 9.28609520e-02f,
  -1.38995722e-01f, -2.04415262e-01f, 5.23624904e-02f, -4.31172140e-02f, -1.18396401e-01f, 2.14365602e-01f, -1.36299534e-02f, 1.05719268e-01f, 1.81141883e-01f, 6.91469908e-02f,
  -1.81464031e-02f, -3.87364887e-02f, -1.05532715e-02f, -8.13237652e-02f, -6.69471696e-02f, 1.05383970e-01f, 2.73766425e-02f, 2.01358661e-01f, 3.54369245e-02f, 8.31319764e-02f,
  -2.42886823e-02f, -9.08871591e-02f, 1.09236449e-01f, -4.98062745e-02f, 1.80943519e-01f, 5.67771345e-02f, 1.81568444e-01f, -7.47998133e-02f, -4.26671207e-02f, -6.15590923e-02f,
  -9.86379534e-02f, -6.30045608e-02f, -1.44062135e-02f, 3.14733982e-02f, 4.93424349e-02f, -6.44963607e-03f, 2.69899070e-01f, -9.22874063e-02f, 4.95487228e-02f, -4.63823229e-02f,
  -1.24767676e-01f, 1.89192921e-01f, 5.00284098e-02f, -4.48761135e-03f, -7.89407454e-03f, 1.24991842e-01f, 5.24354652e-02f, 3.52987610e-02f, 1.36132464e-01f, -1.61399573e-01f,
  -4.20058779e-02f, -1.40180007e-01f, -1.06873026e-03f, 1.00220092e-01f, 8.22253700e-04f, -9.92345884e-02f, 1.65460128e-02f, -1.76204979e-01f, 1.53553560e-01f, 7.35368133e-02f,
  -6.39694780e-02f, -1.62768230e-01f, -4.23724949e-02f, 1.39119744e-01f, -1.15218788e-01f, 2.01079577e-01f, 1.50267020e-01f, 2.48622775e-01f, 1.34899110e-01f, -9.42866877e-02f,
  -1.65740058e-01f, 1.13371154e-02f, -7.50477985e-02f, -1.31136760e-01f, 3.64092797e-01f, 1.58342853e-01f, 3.93395834e-02f, 8.65284950e-02f, -5.12031391e-02f, 3.27940546e-02f,
  2.45573908e-01f, -3.11268754e-02f, 2.35551983e-01f, 1.79464012e-01f, -1.89986676e-01f, 1.12827003e-01f, 1.35744512e-01f, -1.37851492e-01f, -4.93390486e-02f, 1.41450420e-01f,
  -8.15338120e-02f, -9.02520344e-02f, 2.40412921e-01f, -2.12027505e-02f, 4.05453965e-02f, -3.31812203e-02f, 3.91764194e-02f, 2.00488314e-01f, -1.82782650e-01f, 4.67813574e-02f,
  1.75792485e-01f, -1.99279562e-02f, -7.65586346e-02f, -1.54049248e-01f, 2.49408428e-02f, 1.89157590e-01f, -1.34209976e-01f, 8.76918584e-02f, 1.78004980e-01f, -2.58885790e-02f,
  1.00327797e-01f, 1.76181450e-01f, -1.41963437e-01f, -5.37317544e-02f, 1.49779901e-01f, 1.69850677e-01f, 9.11411047e-02f, -3.41447517e-02f, 4.86759096e-02f, -1.01649985e-02f,
  1.29779503e-01f, 7.76249841e-02f, 6.27005696e-02f, -1.22426115e-01f, -1.04617834e-01f, -2.96481438e-02f, -4.01944928e-02f, -2.20623743e-02f, 1.02292381e-01f, 2.63475943e-02f,
  2.53933251e-01f, 5.63537441e-02f, 2.62419552e-01f, -1.40309244e-01f, 3.92914385e-01f, 7.30248168e-02f, -2.82852668e-02f, 9.78357717e-02f, 1.65677577e-01f, 8.27648193e-02f,
  7.06124231e-02f, -1.31413758e-01f, -1.12940446e-01f, -1.58567682e-01f, 2.49304935e-01f, -2.06874916e-03f, 2.12067619e-01f, -3.47730815e-02f, 1.30793035e-01f, -7.92277753e-02f,
  1.09129757e-01f, 1.04172595e-01f, -1.57099470e-01f, 7.34850615e-02f, 2.23886311e-01f, -1.55538753e-01f, 9.28942859e-02f, -8.90927203e-03f, 1.64898425e-01f, 2.79631861e-03f,
  -1.63888738e-01f, -1.45499125e-01f, -7.48462379e-02f, 1.87203661e-01f, 6.49125054e-02f, 6.07549027e-03f, -1.87749974e-02f, 6.38171285e-03f, -4.50352468e-02f, 9.59068388e-02f,
  6.40079752e-02f, 9.92806070e-03f, -5.58205396e-02f, 1.12737924e-01f, 1.04730837e-01f, -2.53951717e-02f, -3.19159143e-02f, -1.50470018e-01f, -1.75843835e-02f, -1.48042455e-01f,
  1.16717339e-01f, 8.19919184e-02f, 3.70308943e-02f, 1.54023305e-01f, -4.28756215e-02f, -1.89830810e-01f, 1.41217694e-01f, -4.43011001e-02f, -9.55022350e-02f, 1.05792508e-01f,
  2.83512712e-01f, 1.29173957e-02f, -1.98933288e-01f, -3.62430252e-02f, 2.52164245e-01f, 4.03397262e-01f, 2.00347409e-01f, 1.90200925e-01f, -1.84163973e-01f, 1.49916649e-01f,
  4.34579700e-01f, -9.02921036e-02f, 3.13360125e-01f, 1.78788841e-01f, 5.18326461e-02f, 4.06910554e-02f, -5.12260199e-02f, -4.24113311e-02f, 1.70663856e-02f, 4.63306755e-02f,
  5.72587073e-01f, -1.85369924e-01f, -1.18925404e-02f, 1.48348333e-02f, 1.72239482e-01f, 4.24911529e-02f, -1.53580084e-01f, 1.88543826e-01f, 5.62582277e-02f, -9.12274420e-02f,
  -4.80622659e-03f, -8.78350660e-02f, 2.28655472e-01f, 2.77135521e-01f, 2.58605599e-01f, 5.15706204e-02f, -4.44578379e-02f, -1.27038956e-01f, 7.38841817e-02f, 2.73012996e-01f,
  -2.77148813e-01f, -6.26214519e-02f, 2.86785096e-01f, -6.78613409e-02f, -1.62446380e-01f, -3.46038565e-02f, 3.25195849e-01f, 1.14841238e-02f, 1.28379047e-01f, 7.86403492e-02f,
  2.58154031e-02f, 1.80651955e-02f, -9.95223746e-02f, 2.26259753e-02f, 1.50646633e-02f, -1.69646129e-01f, 5.38990386e-02f, -1.01415791e-01f, 2.85049707e-01f, 3.21134254e-02f,
  1.28303126e-01f, 5.07455468e-02f, 6.68082163e-02f, 2.92820036e-01f, 1.37747094e-01f, 4.50398773e-01f, 2.80222207e-01f, 2.40307331e-01f, 1.94955040e-02f, 2.14329839e-01f,
  -8.38471651e-02f, 3.11578184e-01f, -2.30467200e-01f, -6.57848492e-02f, 1.16827123e-01f, -2.47466251e-01f, 3.37106884e-01f, 1.90770507e-01f, 1.43294111e-01f, 7.90490061e-02f,
  3.38111259e-02f, 2.50003278e-01f, -1.22573361e-01f, -9.70531255e-02f, -6.39784038e-02f, 4.00523156e-01f, -1.71371415e-01f, -1.77374825e-01f, -2.01494500e-01f, -2.22146571e-01f,
  7.14922994e-02f, 3.82366717e-01f, 2.06055194e-01f, 2.68821299e-01f, 5.11305928e-02f, 4.47979450e-01f, -1.12265060e-02f, -9.11197066e-02f, -7.65038207e-02f, 1.47500232e-01f,
  -1.13569610e-01f, 1.90396085e-01f, -3.23551223e-02f, -1.14576563e-01f, 1.74998760e-01f, -3.75969186e-02f, 1.57387123e-01f, 7.29327723e-02f, 5.00989817e-02f, -3.10477633e-02f,
  -3.54607664e-02f, -3.74448858e-02f, -9.33235064e-02f, -1.75424665e-01f, 9.29380953e-02f, 4.73613068e-02f, -3.93197462e-02f, 2.10885163e-02f, 1.09863833e-01f, 1.48247510e-01f,
  8.57418403e-03f, 5.28478734e-02f, -7.47514591e-02f, 1.01925902e-01f, -3.56738754e-02f, -4.69054058e-02f, -1.06772691e-01f, -1.53765813e-01f, 2.26842724e-02f, 2.56910920e-01f,
  2.93525815e-01f, 3.26763391e-01f, 8.81560370e-02f, 9.54216123e-02f, 6.72872961e-02f, -1.38812512e-01f, 5.08133709e-01f, -9.56467818e-03f, -1.85073644e-01f, 8.12370479e-02f,
  3.68381031e-02f, -9.81697887e-02f, -1.24002755e-01f, 1.53530762e-01f, 2.32018217e-01f, 6.52879551e-02f, 1.84994966e-01f, -2.26468872e-02f, -3.99015956e-02f, 1.48582876e-01f,
  7.77395368e-02f, -6.93581672e-03f, -6.09629117e-02f, -2.24821065e-02f, 8.68185684e-02f, 1.08675055e-01f, 2.23319069e-01f, -1.34701416e-01f, -7.47623146e-02f, 7.34108686e-02f,
  2.40942046e-01f, 3.00280362e-01f, 1.32235944e-01f, 2.78545946e-01f, -1.59991816e-01f, -3.09797138e-01f, 9.83906537e-02f, -3.74538563e-02f, 5.33918977e-01f, 1.09256543e-01f,
  -2.01742798e-01f, 4.15254198e-03f, -2.73051769e-01f, 2.19021112e-01f, 2.12292463e-01f, 8.68506059e-02f, 3.15995097e-01f, -9.47809070e-02f, -4.40620407e-02f, -8.80186260e-02f,
  -3.13331425e-01f, -4.53740358e-02f, 1.03262767e-01f, -3.99395004e-02f, 1.47198007e-01f, -2.97769383e-02f, 2.90039256e-02f, 1.47679850e-01f, 3.35162953e-02f, 2.08236247e-01f,
  1.14559397e-01f, 2.53655791e-01f, 1.05536990e-01f, 2.64084250e-01f, 8.16093609e-02f, -4.41675670e-02f, 2.02686220e-01f, 3.80216241e-02f, -1.48894846e-01f, 2.17802420e-01f,
  -1.87318489e-01f, 7.76545564e-03f, -4.26854566e-02f, -1.75888285e-01f, 1.99358881e-01f, 1.51842475e-01f, 8.38969871e-02f, -5.08403145e-02f, -1.32222682e-01f, -8.92700627e-02f,
  -2.58401744e-02f, 2.38106042e-01f, -5.22349104e-02f, -9.33666006e-02f, -1.28439277e-01f, -1.96918324e-02f, -1.50274053e-01f, 8.24106336e-02f, 2.93088883e-01f, -9.01795402e-02f,
  1.59593895e-01f, 2.02614874e-01f, 1.79644316e-01f, 1.04627587e-01f, 3.77697051e-01f, 2.63861984e-01f, -1.73215061e-01f, -1.44924954e-01f, 4.11698282e-01f, 7.02335179e-01f,
  6.86129034e-01f, -2.69577559e-02f, -4.11598571e-03f, -1.89804122e-01f, 3.77114087e-01f, 3.78211141e-02f, 4.09802169e-01f, -5.18249460e-02f, -1.30532468e-02f, 6.03919365e-02f,
  -3.18369120e-01f, 2.69476771e-02f, 2.72145659e-01f, -1.31264329e-01f, 6.03994608e-01f, -1.01341717e-01f, -7.10666925e-02f, -1.54810697e-01f, 9.06486139e-02f, 1.36741117e-01f,
  -3.10522947e-03f, -3.96060348e-02f, 3.20375800e-01f, -2.60426015e-01f, -6.99078217e-02f, 1.05736434e-01f, 2.10751161e-01f, 1.02811038e-01f, -1.59300402e-01f, -7.92154446e-02f,
  -7.76133463e-02f, 2.88053930e-01f, 1.47816017e-01f, -1.94237962e-01f, -3.09712104e-02f, -1.21576502e-03f, -3.97061072e-02f, 7.85923228e-02f, 2.88814187e-01f, 1.10874392e-01f,
  -8.30496475e-02f, 1.54227361e-01f, -7.68289044e-02f, 1.11603446e-01f, 1.43855453e-01f, -4.80910540e-02f, 3.17486823e-01f, 1.38044283e-01f, 1.62289947e-01f, 3.26305553e-02f,
  -2.79249381e-02f, 9.18573365e-02f, -9.24412832e-02f, 2.10149139e-01f, 4.43575568e-02f, -7.74447322e-02f, 1.13565192e-01f, 1.30438268e-01f, 1.72623485e-01f, 2.26236850e-01f,
  1.50062833e-02f, 7.30340928e-02f, -8.84200633e-02f, -3.04323345e-01f, -8.90893489e-02f, 1.12439632e-01f, 2.77946472e-01f, 1.30774587e-01f, 3.95296849e-02f, -1.40090540e-01f,
  3.39415781e-02f, 2.52709776e-01f, 1.12372346e-01f, -1.25339553e-01f, 8.08011591e-02f, 1.63106129e-01f, 4.46359115e-03f, 1.20074965e-01f, -1.82760015e-01f, 2.24815622e-01f,
  -1.42809659e-01f, -1.43730283e-01f, -1.94457963e-01f, -1.65986121e-01f, 2.11744010e-01f, -1.22585511e-02f, -1.48270637e-01f, 1.44382387e-01f, 2.10414931e-01f, 1.55528903e-01f,
  2.37135068e-01f, 1.11422524e-01f, -5.53235784e-02f, 1.45696998e-01f, -9.59120542e-02f, 4.12495196e-01f, 4.64754492e-01f, -2.03987420e-01f, 9.98275876e-02f, -3.39712203e-02f,
  1.41624331e-01f, 1.31187573e-01f, 2.31321566e-02f, 5.82979620e-02f, 8.95300284e-02f, 6.01211265e-02f, -6.21774904e-02f, 8.21836665e-02f, 6.85433075e-02f, -1.65383667e-01f,
  3.93475175e-01f, -2.80671511e-02f, 1.34693280e-01f, -6.86108619e-02f, 1.00062020e-01f, -1.23221546e-01f, -1.09519929e-01f, -8.76486301e-02f, 3.87716573e-04f, -1.91872194e-01f,
  4.38015200e-02f, 1.39820755e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  -9.30760149e-03f, 2.38177087e-02f, -2.00914126e-02f, 5.43262288e-02f, 1.19586214e-02f, -4.45546806e-02f, 2.12604120e-01f, 1.80144995e-01f, 9.18924659e-02f, 5.04186004e-02f,
  -1.52880549e-01f, 1.65605322e-01f, 4.21462394e-02f, -1.76434685e-02f, 7.24493340e-02f, 2.56570578e-01f, 6.31480440e-02f, 4.10912246e-01f, -4.88977991e-02f, 3.22880894e-01f,
  3.08666617e-01f, 7.99138565e-03f, 3.65989715e-01f, -3.23244371e-02f, 1.43866464e-01f, -5.78144081e-02f
};

// L3_fan_Wp (Shape: 3 x 32)
const int L3_fan_Wp_rows = 3;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  3.19631636e-01f, 3.92261744e-01f, 3.49541306e-01f, 2.20059022e-01f, 1.54047206e-01f, 1.74768001e-01f, -5.77215441e-02f, 1.49359211e-01f, -3.31963822e-02f, 1.06525898e-01f,
  -1.99744433e-01f, -5.07075042e-02f, -1.38330504e-01f, 1.19852006e-01f, -3.53202894e-02f, -8.32178071e-03f, -1.48189321e-01f, 7.34814554e-02f, 8.62008035e-02f, 1.15387039e-02f,
  1.84892163e-01f, 4.76474278e-02f, 6.00685598e-03f, 3.69868390e-02f, -7.41017535e-02f, 2.32660964e-01f, 2.19394431e-01f, 2.12928027e-01f, -2.10544854e-01f, -1.59485370e-01f,
  2.61223227e-01f, -7.98467472e-02f, -2.41385967e-01f, -3.20165128e-01f, -1.64505765e-01f, -2.91522026e-01f, -2.49162503e-03f, -9.52499583e-02f, -5.20166829e-02f, -7.46127218e-02f,
  3.69157866e-02f, -5.39467111e-02f, 1.69426426e-01f, 2.12428495e-01f, 1.39172614e-01f, 1.50703326e-01f, -1.63731396e-01f, 1.01649836e-01f, -1.09201744e-01f, 1.62292346e-01f,
  -7.96434507e-02f, 7.48754442e-02f, -5.51892892e-02f, 2.82009304e-01f, -4.71689031e-02f, -1.06481202e-01f, 3.68392020e-02f, -1.17734047e-02f, -6.63634986e-02f, -1.37715563e-01f,
  9.74889770e-02f, -1.45994782e-01f, -1.94869086e-01f, -5.18465489e-02f, -1.33683980e-02f, -3.94448414e-02f, 1.28527433e-01f, -1.18939303e-01f, 3.05167407e-01f, -1.90853089e-01f,
  -7.86264911e-02f, -1.28522530e-01f, 1.39054507e-01f, -1.75093472e-01f, 4.53491658e-02f, 1.99870661e-01f, -1.42040566e-01f, 1.22484844e-02f, 2.57491529e-01f, -1.00251175e-02f,
  1.15056083e-01f, 4.97765243e-02f, -1.05518810e-01f, 2.18317121e-01f, -4.65864539e-02f, -1.23539381e-01f, -2.00599834e-01f, 1.89608578e-02f, -3.38678285e-02f, 1.91480279e-01f,
  -1.44759431e-01f, -1.99458167e-01f, 1.95176378e-02f, -6.87113106e-02f, 5.15872687e-02f, 1.39278635e-01f
};

// L3_fan_Wp_bar (Shape: 26 x 32)
const int L3_fan_Wp_bar_rows = 26;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  1.34432837e-01f, 2.90707260e-01f, 2.02818271e-02f, 1.71095818e-01f, 1.93714246e-01f, 1.74002618e-01f, -7.69643709e-02f, 2.89154947e-01f, -7.91627690e-02f, -1.23441657e-02f,
  -1.32753193e-01f, 2.23927557e-01f, -2.10826486e-01f, 1.92900509e-01f, 5.55482358e-02f, -1.91823572e-01f, -2.47417260e-02f, 1.60268858e-01f, 1.71504319e-02f, -8.08373988e-02f,
  -1.72526002e-01f, -1.85685411e-01f, 1.03781946e-01f, 3.82838219e-01f, -3.40872328e-03f, 2.07597628e-01f, 2.13925898e-01f, 1.55594693e-02f, 6.62207231e-02f, -9.91059840e-02f,
  -1.33006908e-02f, -8.97498727e-02f, -3.96685041e-02f, -2.88773477e-02f, -1.39988557e-01f, -1.26974165e-01f, 8.24248269e-02f, -7.40576312e-02f, -1.34201273e-01f, 1.23943031e-01f,
  -3.25883515e-02f, 6.59800395e-02f, 1.39640318e-02f, -1.74601411e-03f, -4.41844612e-02f, -9.02041644e-02f, -9.67998058e-02f, -8.34376588e-02f, -6.81849718e-02f, -2.16456950e-02f,
  7.28882030e-02f, -1.12935632e-01f, 1.32696494e-01f, 2.94211321e-03f, -1.31172687e-03f, -2.30748653e-02f, 4.64308672e-02f, 1.64009988e-01f, 1.42189100e-01f, -1.50821060e-01f,
  -1.21813037e-01f, -8.83853510e-02f, 4.09399942e-02f, -3.94466482e-02f, -2.93277558e-02f, 2.60695051e-02f, -9.73464921e-02f, -2.58756708e-02f, 8.20319057e-02f, -4.44142194e-03f,
  -2.23146826e-01f, -1.45108718e-02f, 4.78320792e-02f, 1.09919012e-01f, 8.68256092e-02f, 2.68825352e-01f, -5.11907227e-02f, -6.76335320e-02f, 5.63404411e-02f, -6.56024041e-03f,
  1.63803533e-01f, 1.02625832e-01f, 1.46984011e-01f, 2.53128141e-01f, -8.61158967e-02f, -4.15895134e-02f, -5.71672395e-02f, 9.34221745e-02f, -7.18014734e-03f, 1.31303206e-01f,
  1.85981661e-01f, -8.13882872e-02f, 2.02838883e-01f, -7.80538619e-02f, 1.51988581e-01f, 7.90193975e-02f, 1.07939593e-01f, 1.21875286e-01f, -1.04316622e-01f, 1.45857614e-02f,
  2.18393594e-01f, -2.08502457e-01f, -1.74197420e-01f, 2.85640005e-02f, 1.96989268e-01f, -3.82155762e-03f, 5.88371232e-02f, 2.50941008e-01f, 2.18726620e-01f, -9.62853879e-02f,
  5.03000200e-01f, -8.44310895e-02f, -1.27744600e-01f, -1.03703067e-01f, 1.54917642e-01f, 7.17346296e-02f, 9.27189458e-03f, -2.26763904e-01f, -1.27439752e-01f, -2.12504584e-02f,
  8.75816196e-02f, 2.02794924e-01f, 1.09429978e-01f, 1.25762001e-01f, -5.61064482e-02f, -2.00659350e-01f, 6.14567772e-02f, -1.39785677e-01f, 7.32266828e-02f, 9.74317044e-02f,
  -2.97693163e-01f, 3.28958273e-01f, 7.00845271e-02f, 2.18749225e-01f, 2.75060739e-02f, 1.06064677e-01f, 2.43093163e-01f, -7.96418861e-02f, -1.87769175e-01f, 1.29781976e-01f,
  -1.94177210e-01f, -1.45787016e-01f, -2.27955356e-01f, -1.99455410e-01f, 3.38904746e-02f, -1.84215959e-02f, 1.89971745e-01f, -7.67899025e-03f, -1.32922113e-01f, 1.68613017e-01f,
  -1.13509577e-02f, 3.71778399e-01f, -9.80660170e-02f, 7.98077211e-02f, 1.85165793e-01f, 5.51445261e-02f, -1.77251846e-01f, 3.07460725e-01f, 2.96314776e-01f, -1.16413347e-02f,
  1.10287383e-01f, -1.52010545e-01f, -4.00866009e-02f, 5.39165549e-02f, 1.37469515e-01f, -6.74163476e-02f, 6.22143261e-02f, -1.37095407e-01f, 6.21519377e-03f, 1.66103914e-01f,
  1.52150720e-01f, 2.58634597e-01f, -2.05310751e-02f, -7.54309520e-02f, -1.69318974e-01f, -1.39462814e-01f, 7.06325099e-02f, 1.18681081e-01f, -9.02066156e-02f, 2.28398919e-01f,
  -2.68593244e-02f, 1.59301132e-01f, -7.30531737e-02f, 6.41016231e-04f, -5.93197308e-02f, 1.59585923e-01f, -2.47010365e-01f, -6.42766654e-02f, 3.95959944e-01f, 8.16943347e-02f,
  -2.26971820e-01f, -1.04158279e-02f, 5.46157956e-02f, -1.49257839e-01f, -3.06133658e-01f, -1.95191190e-01f, -2.76777923e-01f, 2.19031140e-01f, -4.14092541e-02f, 2.78659523e-01f,
  1.85870677e-01f, 1.27509758e-02f, -4.81024757e-02f, 1.91404045e-01f, 2.49130934e-01f, -1.79874316e-01f, -2.25163639e-01f, 8.11359659e-02f, 2.35964861e-02f, 1.70021623e-01f,
  4.66254242e-02f, 1.99260145e-01f, -1.06664531e-01f, 4.78779495e-01f, 3.98982316e-02f, -6.05455935e-02f, 5.81504367e-02f, -2.60620534e-01f, -1.99979424e-01f, 1.83130860e-01f,
  4.16129500e-01f, -4.83442917e-02f, -2.32569963e-01f, -1.68170240e-02f, 1.76186655e-02f, 2.23019853e-01f, 1.26899466e-01f, 5.29306494e-02f, -1.46707132e-01f, -2.09639698e-01f,
  2.31543392e-01f, 2.93987468e-02f, 1.12089299e-01f, -5.51939681e-02f, -1.65384814e-01f, -1.24251150e-01f, -3.41926534e-05f, -7.42638633e-02f, -6.84870631e-02f, -1.23389393e-01f,
  -1.59726977e-01f, 1.09191127e-01f, 4.20838874e-03f, 5.97434398e-03f, -1.83207169e-01f, 1.03061467e-01f, 5.43230511e-02f, 2.65856057e-01f, -1.66322842e-01f, -3.88212455e-03f,
  1.21521309e-01f, -4.21583578e-02f, -8.97237808e-02f, -7.15655163e-02f, 1.76910847e-01f, -3.89257446e-02f, 8.74757469e-02f, -5.39646074e-02f, -1.76875386e-02f, 1.41475871e-01f,
  2.08483711e-01f, -7.91329890e-02f, 3.68303657e-01f, -1.39290065e-01f, -1.79530516e-01f, 1.37942716e-01f, -8.98748934e-02f, -1.57600388e-01f, 4.61035728e-01f, -1.22448958e-01f,
  -3.81626450e-02f, 8.51290002e-02f, 1.26903668e-01f, -1.06209397e-01f, 2.17547104e-01f, -9.24597215e-03f, 1.13140620e-01f, 3.20815980e-01f, 1.53372690e-01f, -2.95342207e-01f,
  -6.82134032e-02f, -1.43511981e-01f, -1.75818205e-01f, -1.32416353e-01f, 3.76308382e-01f, 1.08296610e-01f, -5.75272366e-02f, 3.00064564e-01f, -1.79796562e-01f, -1.38914362e-01f,
  -1.60791412e-01f, 3.39303970e-01f, -5.34160957e-02f, 3.05434287e-01f, 1.43634766e-01f, 1.49190336e-01f, -2.41528358e-02f, -1.16901472e-01f, -3.66151817e-02f, -1.16961561e-01f,
  1.64769381e-01f, 1.31075578e-02f, -2.78786927e-01f, -2.86076795e-02f, -9.10626724e-02f, 8.41517299e-02f, -1.21586621e-01f, 5.54775260e-02f, 1.99961051e-01f, 1.43010885e-01f,
  -4.13743220e-02f, -4.32458781e-02f, -1.50442526e-01f, -1.89924195e-01f, -1.85841694e-01f, 1.05829872e-01f, 3.51117313e-01f, 1.60834491e-02f, 5.21412976e-02f, 2.40765050e-01f,
  4.60922346e-02f, 2.41366774e-01f, -2.95699507e-01f, 2.65706331e-01f, -2.01922227e-02f, 3.15101981e-01f, -1.38651565e-01f, -7.23548606e-02f, 1.50761262e-01f, -1.39539003e-01f,
  1.05738126e-01f, 2.49992862e-01f, -2.49492139e-01f, 5.60182184e-02f, -1.89821884e-01f, 6.30540699e-02f, 1.28721565e-01f, 2.72822887e-01f, 4.92220558e-02f, 1.81759492e-01f,
  3.90363373e-02f, 3.28933686e-01f, -1.53222680e-01f, 2.42314190e-01f, -9.28139091e-02f, -9.21550915e-02f, -1.37437090e-01f, -1.63924098e-02f, 3.85905594e-01f, 3.64653379e-01f,
  -8.08012486e-02f, 3.28841180e-01f, -1.89585105e-01f, 1.06929973e-01f, -1.11261994e-01f, 1.77385673e-01f, 3.58783565e-02f, -1.19280711e-01f, 4.49367203e-02f, 2.75772303e-01f,
  1.46387801e-01f, -1.11812003e-01f, -1.63384695e-02f, -1.63843736e-01f, 8.67998973e-02f, -1.41428197e-02f, 2.05494598e-01f, 1.51928484e-01f, -6.54741675e-02f, -1.18669212e-01f,
  1.51625887e-01f, 7.09110051e-02f, -1.66338593e-01f, -8.29766914e-02f, 1.70477316e-01f, 1.69440359e-01f, -9.00075063e-02f, -8.35621655e-02f, 1.83923617e-01f, 7.75924549e-02f,
  -2.49479383e-01f, -6.84282407e-02f, 2.49751508e-01f, -1.72051877e-01f, -1.91461891e-02f, -2.46983208e-02f, 1.26261622e-01f, 1.17190019e-03f, -2.78739393e-01f, -1.71801001e-01f,
  3.56619716e-01f, 4.40428197e-01f, 1.99931234e-01f, -9.53838155e-02f, -2.12868210e-03f, -1.51008695e-01f, 2.59460598e-01f, -2.08553672e-01f, -7.51248300e-02f, 1.06456466e-01f,
  1.27703631e-02f, -1.53777987e-01f, -1.80949584e-01f, -1.67895481e-03f, -1.66205570e-01f, 1.59653738e-01f, 1.83528259e-01f, 8.88602156e-03f, 1.61495712e-02f, -2.83476084e-01f,
  1.25751004e-01f, 2.33092010e-01f, -1.55779541e-01f, -2.40513772e-01f, 1.77163631e-01f, -9.24427733e-02f, -2.17426345e-02f, -1.04337251e-02f, -1.10014476e-01f, 8.24914277e-02f,
  1.90760061e-01f, 1.05687171e-01f, -2.52059788e-01f, 1.27540648e-01f, 1.11331977e-01f, -3.99359167e-02f, -5.28454483e-02f, 2.94328839e-01f, 6.27997518e-02f, -9.77447852e-02f,
  7.75345117e-02f, -1.17295645e-01f, -1.23083219e-01f, 1.01435564e-01f, 2.57462915e-02f, 2.99536705e-01f, -9.08788890e-02f, -3.12649645e-02f, -3.53856385e-02f, -5.50757721e-02f,
  3.25187892e-02f, 2.56990790e-01f, 2.33644560e-01f, -1.24457851e-01f, 7.17602745e-02f, -3.04393936e-02f, 2.45619327e-01f, 6.07996583e-02f, 4.06645447e-01f, 3.46250415e-01f,
  2.67403781e-01f, -1.36869429e-02f, -3.83395344e-01f, 3.33534867e-01f, -6.04764419e-03f, 5.04002631e-01f, 2.36491695e-01f, -6.88732490e-02f, 7.28096813e-02f, -7.43013397e-02f,
  -1.32132517e-02f, -3.29506770e-02f, -4.18729305e-01f, 2.02610791e-01f, -5.65990284e-02f, 2.52855241e-01f, -1.98514163e-02f, -1.96066901e-01f, -1.16674624e-01f, 4.51470941e-01f,
  3.92526120e-01f, 6.94464386e-01f, -1.94107994e-01f, -2.10408047e-02f, -2.66532809e-01f, 3.55088919e-01f, 4.91068244e-01f, 5.07702753e-02f, 6.76542446e-02f, -1.31549239e-01f,
  1.30828574e-01f, -2.02972278e-01f, -2.11453572e-01f, 1.32721954e-03f, 3.90757382e-01f, -1.85136363e-01f, -2.91182965e-01f, -2.49378055e-01f, 8.02356377e-02f, -1.26793310e-01f,
  1.08486243e-01f, 3.16471219e-01f, 4.61015046e-01f, 1.34692769e-02f, 6.97759449e-01f, -9.40557569e-02f, 1.83103979e-01f, 9.16914716e-02f, -1.38081357e-01f, 2.32420266e-01f,
  -1.59516469e-01f, 1.44836992e-01f, -3.71366680e-01f, -3.59849066e-01f, 1.78621575e-01f, 2.98641413e-01f, 8.03450793e-02f, -2.60090947e-01f, 2.97524691e-01f, 2.41355985e-01f,
  -1.89261716e-02f, 9.24613476e-02f, 1.17246352e-01f, 1.18503258e-01f, 8.18702132e-02f, -3.66328657e-02f, 2.46048093e-01f, 3.59457284e-01f, -9.60214660e-02f, -4.02336657e-01f,
  5.75280190e-02f, 4.10818756e-02f, 2.35932082e-01f, 3.19667488e-01f, 3.36734384e-01f, 2.29171842e-01f, -1.23546366e-02f, -1.01662546e-01f, 1.09505460e-01f, 2.12031275e-01f,
  1.24385968e-01f, 3.82362068e-01f, 5.80085106e-02f, 3.71383846e-01f, -3.55091065e-01f, -3.17130387e-01f, 2.29525894e-01f, 2.13753283e-02f, -3.08206081e-01f, 2.89867893e-02f,
  8.52359593e-01f, 1.57143369e-01f, -3.35040957e-01f, 5.51155865e-01f, -2.45579667e-02f, -1.73141390e-01f, -1.88769400e-01f, 1.37094691e-01f, -1.20450407e-01f, 9.26610529e-02f,
  5.73615842e-02f, 7.11849779e-02f, -1.03454344e-01f, -6.56679273e-02f, -1.09413959e-01f, 7.28313029e-02f, -1.48016602e-01f, 1.62543938e-01f, -4.46961895e-02f, -8.27319399e-02f,
  -5.35813943e-02f, -1.12904340e-01f, 3.87769900e-02f, 1.74404815e-01f, -1.68110758e-01f, -1.29917771e-01f, 1.15258798e-01f, 1.66951157e-02f, -7.77260214e-03f, -4.32709940e-02f,
  -3.13211046e-02f, -8.93612579e-02f, -4.57374416e-02f, 1.61070809e-01f, 1.55981153e-01f, 1.18880734e-01f, -5.25888652e-02f, 7.72039816e-02f, 1.21163413e-01f, -6.68635741e-02f,
  -1.87964868e-02f, 7.65463933e-02f, -1.45748049e-01f, -1.46216691e-01f, -7.89228305e-02f, -1.74120203e-01f, 1.42584816e-01f, -4.58368734e-02f, -2.89471924e-01f, 6.37379065e-02f,
  -2.20195334e-02f, -3.78807448e-02f, -1.36457682e-01f, 2.28432953e-01f, 1.01054452e-01f, 3.48902047e-02f, 1.92465435e-03f, 7.53053501e-02f, 1.03026904e-01f, 2.75933862e-01f,
  8.85045007e-02f, 2.21734852e-01f, -7.55175296e-03f, 5.81105165e-02f, 2.59425253e-01f, 2.05559015e-01f, -5.73358648e-02f, 1.65034473e-01f, -1.02349684e-01f, -9.17575732e-02f,
  -1.31951258e-01f, -3.84737998e-02f, -1.43096656e-01f, -3.97514030e-02f, 1.14520118e-01f, 2.81815827e-01f, 1.84111580e-01f, -1.71467870e-01f, 9.85375494e-02f, 1.52013361e-01f,
  6.67962432e-02f, 5.90890609e-02f, -1.20325781e-01f, -8.61782581e-02f, 5.04462533e-02f, -7.58510828e-02f, -1.26305372e-01f, -7.44933821e-03f, 9.58018154e-02f, 1.14074357e-01f,
  1.76094204e-01f, 8.10112134e-02f, 1.10374071e-01f, -1.50904968e-01f, 1.94710661e-02f, 1.74875651e-02f, -1.68448716e-01f, -1.18073441e-01f, 9.41268448e-03f, -2.18127415e-01f,
  -4.34172563e-02f, -1.50439695e-01f, -9.57773402e-02f, 1.47207171e-01f, -1.54429868e-01f, -1.63641740e-02f, 3.29904370e-02f, 1.35511488e-01f, -6.43466488e-02f, -1.29601017e-01f,
  -8.29944536e-02f, -1.03375398e-01f, -2.64117196e-02f, -4.02569436e-02f, -1.03989758e-01f, -1.28426002e-02f, -5.97053766e-02f, -7.30291754e-02f, -1.15237042e-01f, -1.32733211e-01f,
  -6.73453277e-03f, -1.37753919e-01f, -5.77306375e-03f, 1.28625378e-01f, -1.94861852e-02f, -1.46200493e-01f, 3.69422622e-02f, 3.78056914e-02f, -1.60937995e-01f, -9.90970805e-02f,
  1.44529492e-01f, 9.43268612e-02f, -1.39594108e-01f, -4.45004962e-02f, -2.50078499e-01f, 1.31746093e-02f, 1.62515596e-01f, 8.93744454e-02f, 1.13205120e-01f, -3.58618647e-02f,
  1.88851625e-01f, -1.33317977e-01f, -1.54323861e-01f, 9.85773727e-02f, 8.18730220e-02f, 1.98071241e-01f, -2.50588149e-01f, -1.52018769e-02f, -5.88123873e-02f, -7.47273490e-02f,
  1.28682196e-01f, -1.31868973e-01f, 7.48585239e-02f, 2.79486209e-01f, 4.83436808e-02f, 2.05658361e-01f, 1.00127317e-01f, 6.51295483e-02f, -1.66034043e-01f, -1.26522221e-02f,
  4.85565811e-02f, 1.18748575e-01f, 1.02547064e-01f, 6.35269359e-02f, 1.04766324e-01f, 4.62543964e-01f, 2.67134726e-01f, 1.40800878e-01f, -1.40397668e-01f, -9.63686332e-02f,
  2.05447525e-01f, -1.61805168e-01f, -2.39628255e-01f, 8.80379006e-02f, 1.92216843e-01f, -3.33246887e-01f, 9.15084630e-02f, 1.60956770e-01f, -1.61759555e-01f, -1.90653890e-01f,
  4.40219790e-02f, -9.23446640e-02f, 1.30054146e-01f, -9.96135175e-02f, -8.43939111e-02f, 2.66214728e-01f, 8.43225420e-02f, 2.49407977e-01f, -1.22218486e-02f, -1.21992983e-01f,
  -1.36618897e-01f, 3.32387909e-02f, 3.32648754e-01f, 1.55762091e-01f, -2.31386311e-02f, 8.99824798e-02f, -7.64233321e-02f, -2.35945582e-01f, -7.83316419e-02f, -7.77964965e-02f,
  1.15666635e-01f, -3.79500501e-02f, 7.22661763e-02f, -6.52554585e-03f, -9.86922979e-02f, 2.14005094e-02f, 3.09487917e-02f, 9.23916772e-02f, 2.88887843e-02f, -2.22149808e-02f,
  7.17086270e-02f, 1.18273109e-01f, -2.85707787e-02f, -1.00746214e-01f, -1.37790769e-01f, 5.22228070e-02f, 1.28951058e-01f, 1.35597512e-01f, 4.58364412e-02f, -1.09324008e-01f,
  -8.59182701e-02f, 8.50969180e-03f, -1.24185100e-01f, -1.13190107e-01f, 3.98322552e-01f, -1.13932133e-01f, 1.64779592e-02f, 1.73682764e-01f, -1.05501600e-01f, -2.40833778e-03f,
  1.91873923e-01f, -1.45496681e-01f, -8.91114324e-02f, 9.31589454e-02f, -4.78695100e-03f, -1.66869998e-01f, 1.34827733e-01f, -1.03021279e-01f, -2.24325135e-02f, 2.88888395e-01f,
  2.38424957e-01f, 2.94432547e-02f, -2.98140403e-02f, 1.03197992e-01f, 1.39524907e-01f, 1.59289882e-01f, 1.68205366e-01f, -1.08561516e-02f, 7.48101696e-02f, 4.64236811e-02f,
  1.31254911e-01f, -1.42624572e-01f, 3.52910757e-02f, -2.80464347e-02f, 1.52778983e-01f, -7.64527991e-02f, 1.05370350e-01f, 1.64135814e-01f, -1.84021696e-01f, 3.60807963e-02f,
  4.72848028e-01f, 1.43633410e-01f, 6.89413249e-01f, -2.80724555e-01f, -5.24063483e-02f, -3.10990185e-01f, 3.71071517e-01f, -7.41911381e-02f, -2.39769369e-01f, 3.59211080e-02f,
  -1.11852080e-01f, -1.94764152e-01f, 4.00710881e-01f, -1.68532461e-01f, 5.27816594e-01f, -6.78240880e-02f, -1.23730794e-01f, -3.78356427e-01f, 1.31259099e-01f, 1.94555342e-01f,
  -9.13079083e-02f, -1.78147852e-02f, 3.16400498e-01f, 1.90887228e-01f, -7.68931657e-02f, 4.79482263e-01f, 5.72502196e-01f, -1.08773418e-01f, 6.90049902e-02f, -3.01574260e-01f,
  6.83104545e-02f, 1.86493501e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 26)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 26;
const float L3_fan_Bp_bar_data[] = {
  4.54360209e-02f, -1.16568580e-01f, -1.07958987e-01f, 2.35646710e-01f, -3.48609798e-02f, -2.86317077e-02f, -1.48742437e-01f, 2.70836920e-01f, -1.37145922e-01f, 2.26992685e-02f,
  -1.07784815e-01f, -6.25268137e-03f, 1.87859416e-01f, 7.61510357e-02f, 2.59674728e-01f, 7.50419125e-02f, -9.68479514e-02f, 2.81697046e-03f, 1.43100843e-01f, -9.32013057e-03f,
  1.68014672e-02f, 1.14349060e-01f, 3.73076171e-01f, -1.92016885e-01f, 1.81555860e-02f, 3.40273023e-01f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  2.62185745e-02f, 2.13694990e-01f, 2.63276491e-02f, 4.98670697e-01f, -7.77685270e-02f, 6.36809289e-01f, 8.83041993e-02f, -1.13732077e-01f, 4.65594605e-02f, 5.03820419e-01f,
  -2.74026543e-01f, -2.25148007e-01f, -6.72732592e-02f, 8.81981552e-02f, -3.00383896e-01f, -8.49902853e-02f, -2.31113732e-01f, 2.05971867e-01f, 3.28360721e-02f, 2.57102847e-01f,
  -6.45181060e-01f, 5.48536658e-01f, -6.15684271e-01f, -1.06978409e-01f, -1.02123357e-01f, 8.25457647e-02f, -1.53121412e-01f, -1.05221100e-01f, -2.96995342e-01f, -2.17061535e-01f,
  -1.34852171e-01f, 6.16106868e-01f, 4.69739139e-01f, 5.85673273e-01f, 3.67914706e-01f, 3.08920145e-01f, -2.31472537e-01f, -4.99538541e-01f, -3.20111573e-01f, -2.31521055e-01f,
  -1.67396188e-01f, -1.34865105e-01f, -4.10779327e-01f, -2.50763476e-01f, 1.10993102e-01f, 9.30133387e-02f, -1.02575927e-03f, -1.39018640e-01f, -4.32008564e-01f, -2.01713502e-01f,
  4.10872608e-01f, -8.56255144e-02f, 7.13600397e-01f, -4.01016563e-01f, -4.61610496e-01f, -1.92326337e-01f, -3.89488041e-02f, -2.20352691e-02f, -1.16761655e-01f, -2.01224953e-01f,
  4.30201322e-01f, 1.36815295e-01f, -1.86438307e-01f, 3.42452615e-01f, -5.70000112e-01f, -3.10625106e-01f, -4.03352261e-01f, 1.69617653e-01f, -5.61210573e-01f, -6.37049317e-01f,
  2.75713384e-01f, -1.36493474e-01f, -2.38979518e-01f, -2.99208581e-01f, 2.71629542e-01f, -1.92191035e-01f, -4.00663674e-01f, 2.78778881e-01f, -2.59837389e-01f, 3.74569595e-02f,
  -4.51769441e-01f, 4.05074030e-01f, 6.14774764e-01f, -2.26232335e-01f, 3.02153826e-01f, -2.85124481e-01f, -4.32232112e-01f, 1.34600084e-02f, -2.84956425e-01f, 2.31541798e-01f,
  2.39550918e-01f, 9.61258635e-03f, -2.12320432e-01f, 4.27482016e-02f, -2.33627051e-01f, -1.12873189e-01f, -4.14133608e-01f, -2.80488104e-01f, -3.24106365e-01f, -7.46978998e-01f,
  3.24122280e-01f, 4.03637946e-01f, -1.51346579e-01f, 5.05968593e-02f, -1.68095380e-01f, -3.13148797e-01f, -9.51057971e-02f, 3.25006736e-03f, -1.88601658e-01f, -2.75680155e-01f,
  5.64674556e-01f, 2.60574073e-01f, 2.71102607e-01f, 6.79841191e-02f, -1.29111901e-01f, -1.62838608e-01f, -5.94984233e-01f, 2.13198930e-01f, 6.68689907e-01f, 8.58030003e-03f,
  -2.05782503e-02f, 1.76015440e-02f, 1.15760192e-01f, 9.32973064e-03f, 1.98218524e-01f, 2.73865998e-01f, 2.77686100e-02f, -5.48847113e-03f, 5.04815340e-01f, 3.65460098e-01f,
  -3.76208812e-01f, -1.94578648e-01f, 2.72368938e-01f, 1.51595756e-01f, -6.15292080e-02f, -1.25897050e-01f, 2.15344310e-01f, 3.44861820e-02f, -9.60552990e-02f, -7.94766694e-02f,
  -4.44346160e-01f, -2.86010742e-01f, 1.86040998e-01f, -2.44217038e-01f, -1.97814181e-01f, -5.81409745e-02f, 4.26558368e-02f, 3.85888517e-02f, -5.06449461e-01f, 5.34905255e-01f,
  4.65409935e-01f, 7.31742904e-02f, -1.63251180e-02f, 8.15497637e-02f, 7.66028538e-02f, -1.59469694e-01f, -2.52157837e-01f, 1.65695623e-01f, 1.44217923e-01f, 4.40326035e-01f,
  7.66249895e-01f, 4.96753067e-01f, 2.21033633e-01f, 2.37921283e-01f, 3.59347969e-01f, 6.50114477e-01f, 2.51659721e-01f, -7.10167214e-02f, 3.54184173e-02f, -1.11211449e-01f,
  -2.36999944e-01f, 1.79516569e-01f, -2.09102333e-01f, -4.50881012e-02f, -3.67917299e-01f, -3.71888191e-01f, 1.79153398e-01f, -2.62054801e-01f, -1.22849017e-01f, 7.35657737e-02f,
  3.20939988e-01f, 6.52814060e-02f, 6.38600409e-01f, -6.45362586e-02f, 2.80536771e-01f, -1.54026359e-01f, -3.08337454e-02f, 2.13872921e-02f, 6.91012070e-02f, -5.28947152e-02f,
  1.09642841e-01f, 7.05914991e-03f, -4.40257490e-02f, 2.91174382e-01f, 3.87248516e-01f, 2.27449775e-01f, -4.14236575e-01f, -4.99639779e-01f, 2.93614835e-01f, -1.55837789e-01f,
  -4.88242740e-03f, -2.58410752e-01f, 3.22273552e-01f, -1.14038110e-01f, -9.05860290e-02f, -6.00262471e-02f, -2.99957603e-01f, 2.93075114e-01f, 4.50297356e-01f, -2.62132972e-01f,
  -4.38973606e-01f, 4.14778851e-02f, 6.09501123e-01f, -4.30253595e-01f, -2.06631422e-01f, -7.75407627e-03f, 2.37639353e-01f, -1.38107622e-02f, -2.78278664e-02f, 2.32422307e-01f,
  2.83358127e-01f, -1.90554947e-01f, -7.42028579e-02f, -5.58692634e-01f, -6.83513582e-01f, -8.92807961e-01f, -1.61263362e-01f, -2.72820950e-01f, 9.11568031e-02f, -5.02437472e-01f,
  -2.00100899e-01f, 1.55248344e-01f, 2.69024163e-01f, 1.52500823e-01f, 1.07979536e-01f, 2.39642337e-01f, 8.68380070e-02f, -7.17312321e-02f, 1.00844651e-02f, -8.21226537e-02f,
  9.96681899e-02f, -1.83444144e-03f, 1.18857637e-01f, 3.36332142e-01f, -4.67639536e-01f, 5.15609980e-01f, 4.14439946e-01f, 6.15018345e-02f, -1.32293373e-01f, 2.50300318e-02f,
  1.92612872e-01f, -1.24101639e-01f, -4.27118570e-01f, 2.81318873e-01f, 2.53104180e-01f, -7.46750236e-02f, -2.42513046e-01f, -2.47861333e-02f, -2.77339697e-01f, 1.35742217e-01f,
  -1.65525243e-01f, -1.41898632e-01f, 7.46733649e-03f, -6.97958544e-02f, -1.11177243e-01f, -7.27863684e-02f, 1.46188796e-01f, -1.94488376e-01f, 5.48194051e-01f, -1.10147893e-01f,
  -9.90671664e-02f, 4.19812620e-01f, 7.80250877e-02f, 1.04532719e-01f, 2.62903422e-01f, 6.91526532e-02f, 4.05618846e-01f, -3.46800387e-01f, -3.22069108e-01f, 1.61602981e-02f,
  -1.67423695e-01f, 3.49918753e-01f, 6.68795779e-02f, 2.80981362e-01f, -2.65377492e-01f, -8.45999196e-02f, 1.17560126e-01f, -6.13449872e-01f, -2.67887712e-01f, 2.08313495e-01f,
  7.89423347e-01f, 5.92145920e-01f, -5.31074643e-01f, -8.68239477e-02f, 3.57200295e-01f, 6.82549030e-02f, 4.67529930e-02f, 6.39463635e-03f, 2.67138660e-01f, -2.05845490e-01f,
  -4.26967829e-01f, 2.48121634e-01f, -2.06261382e-01f, -2.53144592e-01f, -1.61883200e-03f, 8.76173973e-02f, 2.00327812e-03f, 1.73279896e-01f, -7.20294118e-02f, -4.92342323e-01f,
  -4.95822728e-01f, 4.79638651e-02f, 1.87625200e-01f, -1.75099149e-01f, -1.95274260e-02f, -9.72602591e-02f, 1.60396084e-01f, -5.90454787e-02f, 1.07364086e-02f, 7.12638855e-01f,
  3.63751858e-01f, -1.29150823e-02f, 4.83276583e-02f, -6.74164414e-01f, 1.82235733e-01f, -2.07214206e-01f, -2.45741159e-01f, 1.24493696e-01f, -7.33920857e-02f, -2.05960810e-01f,
  -1.90298975e-01f, 1.93328351e-01f, 3.09686571e-01f, 3.90538312e-02f, 4.77772623e-01f, 3.42218250e-01f, -3.20216897e-03f, -1.76729500e-01f, -1.55961961e-02f, -2.73849934e-01f,
  1.08880810e-01f, -4.04556334e-01f, 1.61430329e-01f, 1.01181772e-02f, -3.44581380e-02f, -2.17060700e-01f, 1.29529968e-01f, 1.94073498e-01f, 3.74872088e-01f, 2.30722353e-01f,
  1.19629219e-01f, 1.45292208e-01f, -5.80123328e-02f, -4.26708758e-01f, 2.69101989e-02f, -4.84483182e-01f, 2.97016561e-01f, 3.01738769e-01f, 4.01365338e-03f, 1.69753246e-02f,
  1.44825712e-01f, -8.02655146e-02f, 2.76848674e-01f, 1.57446817e-01f, 3.19935739e-01f, 1.07311876e-02f, -2.70663500e-02f, 2.06025437e-01f, 5.84039748e-01f, -1.00190327e-01f,
  -2.63322175e-01f, 1.88731998e-01f, -8.27625170e-02f, 1.70025229e-01f, 2.41198644e-01f, 1.77635193e-01f, 2.21439317e-01f, 9.43177268e-02f, 4.51346077e-02f, 1.72548935e-01f,
  -5.01557812e-02f, 1.76430345e-01f, -5.93303107e-02f, -8.06677401e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  3.54595780e-01f, 2.22756103e-01f, 5.96053302e-02f, -4.66755927e-01f, 1.15273744e-01f, 2.51974165e-01f, 1.27266943e-01f, -5.79554260e-01f, -2.59142786e-01f, 6.29909158e-01f,
  -2.65412420e-01f, -4.84913260e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    