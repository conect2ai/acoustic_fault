/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.71509433e-01f, 4.39891130e-01f, 1.75652653e-02f, -2.87720948e-01f, 2.29755461e-01f, 1.41805723e-01f, 3.33030134e-01f, -1.79249942e-02f, -1.82982728e-01f, 2.06940517e-01f,
  6.58780262e-02f, -2.20743731e-01f, -1.20059147e-01f, -8.06546882e-02f, -1.99517965e-01f, 2.51086414e-01f, 1.98621377e-01f, -6.11765943e-02f, -4.69030052e-01f, -1.53167427e-01f,
  3.27291079e-02f, -4.50391024e-02f, -1.78206474e-01f, -1.95474714e-01f, 1.85704470e-01f, -1.19481601e-01f, 1.01622969e-01f, 1.36812612e-01f, 2.25142330e-01f, 5.98822176e-01f,
  1.30129248e-01f, 5.91076314e-02f, -1.09440245e-01f, -6.37209192e-02f, -3.06389220e-02f, -3.05786654e-02f, 1.50299091e-02f, -4.48957570e-02f, -2.07384620e-02f, -6.93581253e-02f,
  -5.05989678e-02f, -4.51993123e-02f, -7.19439313e-02f, -1.50259351e-02f, 1.27474722e-02f, -4.56296876e-02f, -5.82276471e-02f, -1.40700247e-02f, -1.10843763e-01f, 5.41273281e-02f,
  1.27873898e-01f, 1.28852025e-01f, 9.08767655e-02f, -1.11941844e-02f, -4.51823622e-02f, -4.42879610e-02f, 1.72864590e-02f, -1.36199477e-03f, -2.64840201e-02f, 1.76170677e-01f,
  1.89365279e-02f, -7.19059110e-02f, -1.31622758e-02f, 5.12441397e-02f, 1.40054654e-02f, 2.55084317e-02f, -5.51883271e-03f, -7.00283004e-03f, -2.30875649e-02f, -1.01815984e-02f,
  -1.41584110e-02f, 4.66125049e-02f, 5.42258695e-02f, 2.70813331e-02f, -1.86862060e-04f, 6.47795275e-02f, 1.26326382e-02f, -3.39934900e-02f, 1.13007734e-02f, 1.18428409e-01f,
  -4.59962226e-02f, 2.34438702e-02f, 3.01285889e-02f, -3.87634970e-02f, 1.13661163e-01f, -2.99696345e-02f, -1.40848244e-02f, 1.03214951e-02f, -5.81270456e-02f, 3.50186639e-02f,
  -1.40466794e-01f, -1.28886616e-02f, -1.70447715e-02f, 1.02003224e-01f, -9.21472535e-03f, -1.99502427e-02f, 2.88875829e-02f, 1.03879720e-01f, -8.55029281e-03f, 7.32335681e-03f,
  -7.28920847e-02f, -1.27001658e-01f, -2.33319886e-02f, 4.60079778e-03f, -9.85076427e-02f, -3.07187252e-02f, 3.30994911e-02f, -3.19169015e-02f, 6.69426918e-02f, 3.72251160e-02f,
  2.80948402e-03f, 5.81412241e-02f, -1.26476124e-01f, 5.17112538e-02f, 1.27748176e-01f, -1.16820276e-01f, 5.12977736e-03f, -6.15147464e-02f, -1.13772713e-02f, 2.55994722e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.27151024e-02f, 5.36803126e-01f, -2.81170577e-01f, -4.11986150e-02f, 1.67119056e-01f, -5.78126162e-02f, 2.42407948e-01f, -2.78065443e-01f, -2.87829816e-01f, 1.30249679e-01f,
  1.08123749e-01f, 1.81519929e-02f, -1.64663382e-02f, 8.15217346e-02f, -1.16706952e-01f, 2.67849475e-01f, 2.46992528e-01f, 1.63919777e-02f, -3.96404713e-01f, -1.22572873e-02f,
  4.41895127e-01f, -1.86079033e-02f, -3.44512731e-01f, -2.28983879e-01f, 2.15109721e-01f, -1.87218398e-01f, -2.58768380e-01f, -1.47216925e-02f, 7.08005624e-03f, 7.25566149e-01f,
  2.04975724e-01f, 1.01276949e-01f, -2.26648226e-01f, -1.29217744e-01f, -1.43036366e-01f, -1.41962739e-02f, 3.96816805e-02f, -1.25362109e-02f, -1.79761410e-01f, 3.75175886e-02f,
  1.33635983e-01f, 1.25665605e-01f, 1.48009777e-01f, -9.26731969e-04f, -3.02587181e-01f, -1.78889781e-01f, -3.19477677e-01f, -1.03311595e-02f, -2.13714212e-01f, -1.18170328e-01f,
  4.32603270e-01f, 9.78728235e-02f, -4.13070712e-03f, -2.39698470e-01f, -9.17944387e-02f, -2.31830969e-01f, -1.70633733e-01f, -9.03166607e-02f, -3.56203318e-01f, 3.85025032e-02f,
  -1.01394393e-01f, 1.32174581e-01f, -1.41216889e-01f, 6.75445348e-02f, 1.35866394e-02f, 8.40981957e-03f, 2.49076441e-01f, 1.26221152e-02f, 9.82230529e-02f, -2.00323742e-02f,
  -2.22491726e-01f, -3.72407064e-02f, -3.23183089e-02f, 1.30406454e-01f, -9.50429589e-02f, -1.43401191e-01f, -2.38070805e-02f, -3.20826285e-02f, -4.57531363e-02f, -7.41424561e-02f,
  -1.51495129e-01f, -1.25340775e-01f, -5.94867058e-02f, -5.26846126e-02f, 2.67137550e-02f, 3.55349965e-02f, -3.43425684e-02f, -7.79107586e-02f, 4.22712788e-02f, 1.07439987e-01f,
  -2.05659360e-01f, -3.60974699e-01f, 8.42638612e-02f, -1.10992931e-01f, -4.84405011e-02f, -1.44876957e-01f, -7.03883618e-02f, -8.26573074e-02f, 3.73598933e-02f, -7.45824650e-02f,
  -1.11681461e-01f, 1.77917108e-01f, -1.14545822e-02f, -1.16270296e-01f, -2.25551829e-01f, -7.91626871e-02f, -8.55834503e-03f, -5.41575961e-02f, -1.94065437e-01f, -1.02318503e-01f,
  -8.65394846e-02f, -1.60483360e-01f, -2.19102666e-01f, -8.05486217e-02f, -1.33676231e-01f, -1.86898604e-01f, -3.09529334e-01f, -2.73053169e-01f, -3.66796762e-01f, -1.54789925e-01f,
  1.17045307e+00f, -3.28489393e-01f, -6.01499081e-01f, 3.80835503e-01f, -2.00528232e-03f, 1.91704899e-01f, -6.37160894e-03f, 2.56605387e-01f, 3.51448894e-01f, 1.83862984e-01f,
  -5.77796660e-02f, 1.41505316e-01f, 1.92840278e-01f, -4.70886081e-02f, 1.62740558e-01f, 2.58292165e-02f, -1.00708731e-01f, 2.52759457e-02f, 1.96176291e-01f, 2.30788272e-02f,
  -7.42085949e-02f, -2.12639775e-02f, 8.44684318e-02f, 1.03381030e-01f, -2.41293386e-01f, 8.26926008e-02f, -1.93535849e-01f, -3.49461317e-01f, -2.00832650e-01f, -3.53536695e-01f,
  -6.28637820e-02f, -1.73028290e-01f, 8.05875659e-02f, 7.75132999e-02f, -1.99073911e-01f, 6.97444305e-02f, -1.77449062e-02f, -1.68672204e-01f, -1.75939649e-01f, -1.08573824e-01f,
  -8.25919360e-02f, -9.94805470e-02f, -6.39016321e-03f, -1.50040060e-01f, -1.19760178e-01f, -6.51824102e-02f, -2.35076934e-01f, -1.60813406e-01f, -6.08528703e-02f, -1.60417885e-01f,
  -2.34466642e-01f, -4.08897698e-01f, -2.11128429e-01f, -2.52502829e-01f, -1.83684036e-01f, 8.39059986e-03f, -4.71839607e-01f, -3.23067874e-01f, -3.56521457e-01f, -8.55887532e-02f,
  -3.89681198e-02f, -1.22609690e-01f, 1.26255304e-02f, 3.76169011e-02f, 3.00919488e-02f, 4.63669002e-02f, -4.58089896e-02f, -6.59510726e-03f, -2.98253186e-02f, 6.42936444e-03f,
  -2.34544016e-02f, 7.42577389e-02f, 4.47656261e-03f, -1.18196212e-01f, 7.01158866e-02f, 4.96495701e-02f, 4.99390140e-02f, 6.03279136e-02f, -2.55009830e-02f, 1.65060505e-01f,
  -3.26572023e-02f, -7.81193050e-03f, 5.36839254e-02f, 1.38379959e-03f, 2.96304394e-02f, -9.38596353e-02f, 7.61880167e-03f, -9.88637563e-03f, 1.09616503e-01f, 8.17426369e-02f,
  3.50510806e-01f, -2.07535364e-03f, 3.78662109e-01f, 9.59203318e-02f, 6.67590275e-02f, 1.03353947e-01f, 3.33220176e-02f, -7.49126300e-02f, 4.88179689e-03f, -1.30571024e-02f,
  -1.08615095e-02f, 1.33512646e-01f, -6.03797585e-02f, -3.85827646e-02f, -3.86928394e-02f, 8.32485110e-02f, 4.35770079e-02f, 2.63629854e-01f, 1.00890718e-01f, 4.83136475e-02f,
  2.78878734e-02f, 1.91187516e-01f, 3.26069593e-01f, 3.16699803e-01f, 8.50835443e-02f, 3.70702624e-01f, 1.25172928e-01f, 8.09017643e-02f, 2.71253437e-01f, 5.50333023e-01f,
  2.49837845e-04f, -7.08216429e-02f, -3.00583273e-01f, 4.80796874e-01f, -1.19627398e-02f, -7.65751824e-02f, -5.42830527e-01f, 9.36899707e-02f, 5.97127080e-01f, -1.64238900e-01f,
  -2.52576232e-01f, -7.01312199e-02f, -2.54420578e-01f, -5.11910915e-01f, -8.20780694e-01f, -7.45978355e-01f, -1.99457601e-01f, -4.33922917e-01f, -5.83530307e-01f, -3.42165202e-01f,
  -1.33326218e-01f, -7.99316987e-02f, -2.57975366e-02f, 1.84949547e-01f, 2.11771861e-01f, 8.47109482e-02f, 1.18488885e-01f, -2.52890661e-02f, -1.91693231e-01f, -3.21623057e-01f,
  -4.91026253e-01f, -7.85935447e-02f, -2.32566446e-01f, 8.14501122e-02f, -7.48254731e-02f, -9.68068391e-02f, -2.26968423e-01f, -8.32078829e-02f, 1.54775515e-01f, -8.64022076e-02f,
  1.54158413e-01f, 1.36290133e-01f, 6.41242042e-02f, 6.25889674e-02f, -1.53439343e-01f, -2.18134131e-02f, 1.93963125e-01f, -2.30746523e-01f, -9.15450528e-02f, -2.17107400e-01f,
  1.58030540e-01f, -3.38252902e-01f, -3.77649277e-01f, -6.10338673e-02f, -1.31613016e-01f, -1.11208491e-01f, -8.06618780e-02f, -5.48563786e-02f, -5.89871556e-02f, 7.67218545e-02f,
  2.08993942e-01f, -1.12338275e-01f, -1.04575485e-01f, 1.31093469e-02f, -7.40491673e-02f, 1.22519014e-02f, -9.41562280e-02f, -5.49011566e-02f, -4.19521928e-02f, 4.39388230e-02f,
  -1.60097759e-02f, -4.66387309e-02f, 9.07653123e-02f, 1.03668243e-01f, -2.45181136e-02f, 1.55002065e-02f, -7.78574944e-02f, -1.24947608e-01f, -1.01079769e-01f, -3.42726111e-02f,
  4.20542881e-02f, -7.31679127e-02f, 7.58421570e-02f, -5.31051541e-03f, -4.83667217e-02f, 1.41904622e-01f, -2.10186150e-02f, -2.71129329e-02f, 9.20229107e-02f, 5.47526553e-02f,
  1.58091053e-01f, -2.88996190e-01f, -7.59765282e-02f, -8.98128599e-02f, 7.96712562e-02f, -2.82027554e-02f, 1.27816752e-01f, 1.88104153e-01f, 1.23597883e-01f, 3.09759211e-02f,
  -1.00234531e-01f, 1.74121574e-01f, 8.85863379e-02f, 8.59274268e-02f, -1.34574041e-01f, 7.19877928e-02f, 8.81938562e-02f, 3.16590746e-03f, -7.13495687e-02f, 1.17532603e-01f,
  1.87022254e-01f, -6.07601516e-02f, -3.26687902e-01f, -1.52017862e-01f, -1.40085081e-02f, -4.94029015e-01f, -1.85225293e-01f, -1.15680195e-01f, -2.29507372e-01f, 1.18864365e-01f,
  -5.96866235e-02f, -4.79317427e-01f, 1.69650584e-01f, 4.63854969e-01f, 6.40682757e-01f, 7.54792571e-01f, 6.89755559e-01f, 3.14025134e-01f, 2.28437632e-01f, 1.24536470e-01f,
  -5.97310290e-02f, -1.03792965e-01f, -1.23068936e-01f, -2.84635335e-01f, -1.54028699e-01f, 2.39190057e-01f, 3.58466476e-01f, 2.17950698e-02f, 2.11257502e-01f, 1.21838756e-01f,
  7.36785159e-02f, 5.90116642e-02f, -1.84165925e-01f, -5.55755831e-02f, 8.40866789e-02f, 1.02161720e-01f, 7.20819533e-02f, -1.17761202e-01f, -6.20178394e-02f, -2.25340337e-01f,
  -7.30107665e-01f, -1.08356111e-01f, 2.46169671e-01f, -1.63418446e-02f, -1.24754667e-01f, -1.90094545e-01f, -1.32105902e-01f, -1.66498140e-01f, -6.64641932e-02f, -7.93199092e-02f,
  -1.02231734e-01f, -2.43110910e-01f, 1.98061038e-02f, -1.18307792e-01f, -9.75965187e-02f, 1.07198944e-02f, -1.74130574e-01f, -1.19545072e-01f, -1.10162966e-01f, -9.38490033e-02f,
  4.43901420e-02f, 3.24459933e-02f, 4.93419953e-02f, 8.86552185e-02f, -1.17807528e-02f, 4.88635823e-02f, -7.53707662e-02f, -3.43268551e-02f, -2.39471979e-02f, -1.12012707e-01f,
  1.71568513e-01f, 1.21263508e-02f, -1.62106249e-02f, 1.11857198e-01f, 4.46111448e-02f, 4.64854129e-02f, 8.03335235e-02f, -8.30253512e-02f, 7.92589709e-02f, -3.06692757e-02f,
  -6.50192425e-02f, -2.80880909e-02f, -8.05866048e-02f, 2.62222998e-02f, -2.53008194e-02f, 2.54856097e-03f, -4.97046188e-02f, -1.85870621e-02f, -7.11610615e-02f, -6.01763688e-02f,
  -6.22941405e-02f, -1.29536852e-01f, -1.74440984e-02f, -9.06289965e-02f, 6.54397532e-02f, -1.39950737e-02f, 1.15654700e-01f, -8.51562340e-03f, 2.49357074e-02f, 1.19579136e-02f,
  -2.42071748e-01f, 7.12641180e-02f, -5.99221438e-02f, -2.04752252e-01f, -2.70715266e-01f, -2.50024378e-01f, -5.30534312e-02f, -2.22853884e-01f, -9.18896720e-02f, -8.62295367e-03f,
  3.46877575e-02f, -1.22726649e-01f, -5.19119501e-02f, -7.25317225e-02f, 1.07802369e-01f, 2.50174534e-02f, -9.86379758e-02f, 1.09951057e-01f, -9.06921104e-02f, -1.70861572e-01f,
  -6.48698285e-02f, 1.69112608e-01f, 5.45840971e-02f, 9.11834240e-02f, 6.71105506e-03f, 2.12869585e-01f, 3.93222049e-02f, 3.98651324e-02f, 9.07541960e-02f, 1.66707680e-01f,
  -4.68754083e-01f, -1.93897158e-01f, -5.52113771e-01f, -4.07621980e-01f, -5.81397474e-01f, 1.85407177e-02f, -4.00746167e-01f, 2.26701230e-01f, 3.41784507e-01f, -2.89339989e-01f,
  -4.17288661e-01f, -3.35291117e-01f, -2.79076695e-01f, 1.05978973e-01f, 1.27554148e-01f, -2.29902416e-01f, -1.53411686e-01f, -1.65164709e-01f, 7.19280839e-02f, 1.18603572e-01f,
  3.69817093e-02f, -2.66208261e-01f, 4.60668840e-02f, 7.42291957e-02f, -4.25747156e-01f, -4.19806808e-01f, -3.63075882e-01f, -3.08556646e-01f, -1.12236425e-01f, -8.87928307e-01f,
  -4.81399417e-01f, -2.38861859e-01f, -1.48740828e-01f, -3.52356094e-03f, -4.45928276e-01f, -1.01279076e-02f, -1.38170421e-01f, -2.80951142e-01f, 1.31884754e-01f, -1.54859358e-02f,
  -3.58293653e-01f, -1.43631324e-01f, -7.71243125e-02f, -6.69272691e-02f, -1.07424051e-01f, 5.58436550e-02f, 1.25037298e-01f, 7.10414872e-02f, 8.85074437e-02f, 1.22498296e-01f,
  -8.29688646e-03f, 9.26280841e-02f, -2.85369158e-02f, 2.71964312e-01f, 1.64698914e-01f, 1.07006334e-01f, -4.67561856e-02f, 1.14155352e-01f, 1.68425459e-02f, -2.56383449e-01f,
  3.47110545e-05f, -1.72270507e-01f, -9.46855173e-02f, 8.96521378e-03f, 1.02135457e-01f, 1.07049517e-01f, -7.59102330e-02f, -1.08976781e-01f, -3.38817723e-02f, -1.85670480e-01f,
  -1.50265153e-02f, -1.67030189e-02f, 7.15465993e-02f, -4.66217622e-02f, -6.77992851e-02f, -4.13753130e-02f, 6.03580400e-02f, 2.70354934e-02f, 8.59693885e-02f, 4.73250225e-02f,
  -5.02685644e-02f, 5.27695231e-02f, 6.03519566e-03f, 6.89601004e-02f, -6.57875836e-02f, 1.94581803e-02f, 5.32068685e-02f, 9.90357101e-02f, 2.98636779e-02f, -9.53544378e-02f,
  -2.58930743e-01f, 1.09255850e-01f, -2.56880403e-01f, -1.09826446e-01f, -9.18715671e-02f, 1.70481652e-02f, 2.09229141e-02f, 1.45994108e-02f, 4.12312895e-02f, -8.06825235e-02f,
  -6.11740015e-02f, -5.59614673e-02f, -5.28513379e-02f, -5.78278974e-02f, -1.81368336e-01f, -6.41819462e-02f, -1.96136106e-02f, -2.35015288e-01f, 6.41543120e-02f, 6.17166981e-02f,
  9.43286344e-02f, 1.70305729e-01f, -2.70583183e-02f, 5.68348877e-02f, 2.53938228e-01f, -5.01710689e-03f, -1.48040205e-01f, -9.68319699e-02f, 2.20085625e-02f, -3.75831164e-02f,
  8.96904647e-01f, 1.46488309e-01f, 7.43375659e-01f, 3.61291945e-01f, 5.13037026e-01f, 5.74567318e-01f, 6.83864534e-01f, 3.38202119e-01f, -1.27365673e-02f, 2.10206464e-01f,
  1.14260130e-01f, -4.55199927e-01f, -4.37001497e-01f, -4.77459580e-01f, -1.51533648e-01f, 1.13770373e-01f, 1.79539546e-02f, -1.11184478e-01f, 7.18156770e-02f, 1.11155875e-01f,
  -1.04636714e-01f, 1.38864011e-01f, 1.46097407e-01f, -7.82417804e-02f, -1.47117451e-02f, -3.15892279e-01f, 1.12164542e-01f, 7.18660429e-02f, -2.51729101e-01f, -3.95399421e-01f,
  -4.78332341e-01f, 4.50818211e-01f, -3.14897776e-01f, -2.78606623e-01f, -3.65268835e-03f, -1.29396856e-01f, -2.51580086e-02f, -7.42918327e-02f, 2.44057700e-02f, -7.11894929e-02f,
  -3.53589728e-02f, -2.51114070e-02f, 2.91304700e-02f, -3.04959901e-02f, 1.14714116e-01f, 2.54462492e-02f, 4.14502174e-02f, -4.61325422e-02f, -4.20100950e-02f, -1.75828502e-01f,
  -1.22868292e-01f, 2.15498954e-01f, 2.52063513e-01f, -2.59376690e-02f, 3.40250395e-02f, -5.80727868e-02f, 8.24505314e-02f, -5.76243624e-02f, 1.47813037e-01f, -1.05048276e-01f,
  -1.73201934e-01f, 9.33064818e-02f, -1.42295629e-01f, 1.09779738e-01f, 1.02041297e-01f, -9.63642001e-02f, 3.29618086e-03f, -8.09755325e-02f, 3.96405198e-02f, 1.10937431e-01f,
  -7.96282589e-02f, -1.08816579e-01f, -6.21898137e-02f, 5.06087840e-02f, -3.12446393e-02f, 4.71462198e-02f, 9.85747427e-02f, 4.16073799e-02f, -1.34064451e-01f, -1.13274403e-01f,
  8.88947472e-02f, 1.06385358e-01f, 1.37692004e-01f, -7.63593316e-02f, 1.34808183e-01f, -3.40815783e-02f, 4.77343984e-02f, -7.44829513e-03f, 1.82850170e-03f, 1.03096709e-01f,
  -5.30580878e-01f, 1.12635344e-02f, -3.22140068e-01f, -8.20319578e-02f, 5.95496707e-02f, -6.09594956e-03f, -4.85018045e-02f, -2.63042678e-03f, 1.46566825e-02f, -5.19178696e-02f,
  6.58421442e-02f, 5.71488701e-02f, 1.01406291e-01f, 1.23054653e-01f, 1.32753730e-01f, 1.87922344e-02f, -8.10524300e-02f, 1.83892087e-03f, -1.21736206e-01f, -1.64912805e-01f,
  -2.05982830e-02f, 1.22288391e-01f, 4.38472070e-02f, 1.00647636e-01f, -7.72663578e-02f, -6.17062747e-02f, 2.14138236e-02f, 2.38219276e-03f, 1.50574416e-01f, 8.70241225e-02f,
  -2.40201414e-01f, -8.39792550e-01f, 4.40892249e-01f, -1.98200628e-01f, 3.43148738e-01f, 4.17081267e-01f, 6.14154816e-01f, 5.67884743e-03f, -2.41250321e-01f, -1.34775445e-01f,
  -2.92778254e-01f, -2.79229492e-01f, -2.63225257e-01f, -1.42683089e-01f, -1.56500507e-02f, 2.47834027e-01f, 5.18386588e-02f, 1.39612719e-01f, 5.68653584e-01f, 2.51906008e-01f,
  -1.96539789e-01f, -1.03069000e-01f, -3.59648079e-01f, -2.86522627e-01f, -8.88116006e-03f, -2.44324096e-02f, -5.67495562e-02f, -7.05461055e-02f, -2.57595807e-01f, -2.28222951e-01f,
  7.23859787e-01f, -1.17608666e-01f, 2.00102001e-01f, -2.37913564e-01f, 4.69613671e-02f, -1.32102549e-01f, 4.40882705e-02f, -5.80546446e-02f, -8.36419761e-02f, 2.92155985e-03f,
  -4.71162945e-02f, 4.08169255e-03f, 1.48232117e-01f, 5.40824160e-02f, 1.18565038e-01f, -4.50940244e-02f, -1.90647721e-01f, -2.77864575e-01f, -1.13708831e-01f, 7.71464827e-03f,
  -2.77488619e-01f, -1.49091445e-02f, 2.49840870e-01f, -4.32425849e-02f, -9.44700465e-02f, -7.29682669e-02f, -1.21205039e-01f, -1.70093730e-01f, -2.03052983e-01f, -1.50783226e-01f,
  -3.28898849e-03f, 3.90439630e-02f, 3.23586650e-02f, -1.10293373e-01f, 1.34059591e-02f, -3.71504612e-02f, -3.28050740e-03f, -1.66434422e-02f, -7.96864852e-02f, 1.87719986e-02f,
  -9.20922905e-02f, -4.33313800e-03f, -1.65736582e-02f, -9.47869569e-02f, -8.47529322e-02f, 4.19409424e-02f, 1.20115269e-03f, -8.12731087e-02f, -1.36051208e-01f, 1.34061547e-02f,
  -6.34035245e-02f, 2.18293313e-02f, -9.51342136e-02f, -7.42947161e-02f, -1.34367391e-01f, -4.12649065e-02f, -4.90105264e-02f, -1.31051540e-01f, -7.09803179e-02f, 3.58309560e-02f,
  2.34630153e-01f, -2.14901477e-01f, 1.54809654e-01f, -5.56177944e-02f, 7.38544986e-02f, -1.50618494e-01f, -4.96034212e-02f, -5.10384962e-02f, -6.11573085e-02f, 4.48535047e-02f,
  -5.59918694e-02f, 2.38845963e-02f, -8.09903592e-02f, -1.50438741e-01f, 8.88180360e-02f, -2.82210857e-02f, -2.25293487e-01f, 3.76696251e-02f, -1.80747434e-01f, 1.63884070e-02f,
  -9.13559273e-02f, 1.33937582e-01f, 2.56655097e-01f, 1.26520604e-01f, 9.91811082e-02f, 2.51074731e-01f, 2.83048213e-01f, 2.24192902e-01f, 1.96808606e-01f, 2.22266525e-01f,
  -2.48959094e-01f, 1.27286047e-01f, -1.69381231e-01f, -1.43932521e-01f, -3.56133759e-01f, -2.18625501e-01f, 1.18488453e-01f, -4.45334315e-02f, 5.27968183e-02f, 2.80052394e-01f,
  -1.33332685e-01f, -1.71374947e-01f, 1.83449522e-01f, -5.75160123e-02f, -5.30193225e-02f, 3.03498715e-01f, 1.30810097e-01f, -1.54628247e-01f, -3.31206530e-01f, -3.61240596e-01f,
  -2.78885402e-02f, 5.98152019e-02f, -1.38723224e-01f, -1.05572343e-01f, 1.56032398e-01f, 6.81588203e-02f, 1.54280528e-01f, -2.19172180e-01f, -2.84206361e-01f, -2.03535020e-01f,
  2.27061242e-01f, -4.21795398e-01f, -1.73799187e-01f, -3.16592187e-01f, 2.59099565e-02f, 3.78077738e-02f, -8.56721103e-02f, 6.67785481e-02f, 6.47772551e-02f, 8.70371461e-02f,
  -8.78779739e-02f, -9.01404247e-02f, 2.66795848e-02f, 1.79041289e-02f, 9.70155671e-02f, 2.97720265e-02f, -4.89317626e-03f, -1.31931528e-01f, -2.70606261e-02f, 1.56313002e-01f,
  1.59351885e-01f, -2.27773234e-01f, 6.27719157e-04f, -1.74762625e-02f, -1.57332882e-01f, -2.02131376e-01f, 2.84186993e-02f, -2.56461084e-01f, -3.87446970e-01f, 1.85355723e-01f,
  -1.07024731e-02f, 1.11156672e-01f, 1.15294054e-01f, 2.18867809e-02f, 1.48180991e-01f, 1.51022732e-01f, -2.52843872e-02f, 1.53081492e-01f, 4.86719869e-02f, 3.88319492e-02f,
  -1.64332315e-02f, 8.36954936e-02f, 1.33331632e-02f, 6.19940013e-02f, 1.14465533e-02f, -8.50183293e-02f, -1.97171960e-02f, 1.60833821e-01f, -7.35962614e-02f, 9.34246704e-02f,
  -2.60237530e-02f, -1.69367284e-01f, 4.19092029e-02f, -1.60476625e-01f, -1.74919561e-01f, 2.81665418e-02f, -8.71802419e-02f, 7.66841471e-02f, 8.06060508e-02f, -8.57599974e-02f,
  4.65455711e-01f, -4.83252764e-01f, 3.43119442e-01f, -8.17494690e-02f, -9.91279110e-02f, 5.52619323e-02f, 5.77004477e-02f, -1.52571976e-01f, 9.07761529e-02f, 1.64452253e-03f,
  -1.42202392e-01f, 1.44566670e-01f, 4.46996391e-02f, -2.71049142e-02f, 1.34890210e-02f, -7.51028210e-02f, 1.78788543e-01f, -2.05834564e-02f, -1.50806218e-01f, 7.75050074e-02f,
  1.35617092e-01f, 1.85052052e-01f, 1.63668975e-01f, 2.05665454e-01f, 7.06261098e-02f, -6.52317132e-04f, 2.69630939e-01f, 1.73947111e-01f, -1.29460886e-01f, 8.03469896e-01f,
  3.46797079e-01f, 2.82163829e-01f, -3.38782102e-01f, 2.40649119e-01f, 3.29899281e-01f, -1.22562796e-01f, 1.05119355e-01f, -2.04122081e-01f, -7.79185146e-02f, 8.03294629e-02f,
  1.58953279e-01f, 2.73953617e-01f, 6.99446499e-02f, 1.89040434e-02f, -7.71668330e-02f, 6.44314289e-02f, 1.82257310e-01f, -1.12806588e-01f, -2.70493358e-01f, 4.54773009e-02f,
  4.89119589e-01f, 2.19739422e-01f, -2.16332152e-01f, -2.35293005e-02f, 4.75213677e-01f, 4.02122289e-02f, -1.33432850e-01f, 1.21063039e-01f, 2.17312500e-01f, 8.26414764e-01f,
  1.59611493e-01f, 9.17298645e-02f, -2.54960775e-01f, 3.94186601e-02f, 1.47605270e-01f, 1.22624878e-02f, 2.95872893e-02f, -1.43575668e-01f, 8.10344741e-02f, -1.67172000e-01f,
  2.10064337e-01f, 6.28258511e-02f, 2.25205868e-01f, 3.23865861e-02f, 3.56478654e-02f, 5.22636948e-03f, 7.79253058e-03f, -1.76776752e-01f, -2.98767656e-01f, 1.81820486e-02f,
  3.45708728e-01f, -2.63640611e-03f, -6.31091371e-02f, -9.84981954e-02f, 2.93603800e-02f, 1.78294346e-01f, -4.35335711e-02f, 4.83983010e-02f, -2.39482805e-01f, 9.98202115e-02f,
  -1.70757715e-02f, 1.94106132e-01f, 1.33682594e-01f, 9.31839198e-02f, 2.23062426e-01f, -5.71092870e-03f, 2.84270290e-02f, -3.84453200e-02f, 8.19456652e-02f, 6.56072497e-02f,
  -9.28657427e-02f, -5.87193184e-02f, -1.81410462e-01f, -1.61516473e-01f, -8.23319033e-02f, 1.30734086e-01f, 2.09905088e-01f, 2.06524059e-02f, -4.22784835e-02f, -1.18594021e-01f,
  1.55534297e-01f, 4.84729558e-02f, 4.36369590e-02f, -2.92325653e-02f, -1.57449637e-02f, 4.76915501e-02f, 1.45788386e-01f, 1.14247082e-02f, -2.51773484e-02f, 4.77984697e-02f,
  -4.08210754e-01f, -4.48406339e-01f, 2.98842132e-01f, -2.13142838e-02f, 7.85400718e-02f, -7.31273443e-02f, 1.52773768e-01f, -6.85808435e-02f, 7.38120228e-02f, 2.62760166e-02f,
  -1.41146332e-01f, -4.42916155e-02f, -7.58672655e-02f, -1.92998871e-01f, -2.47211866e-02f, -6.61909804e-02f, 1.80492163e-01f, 5.92751391e-02f, -1.74563751e-01f, -1.31237537e-01f,
  -8.74507725e-02f, -3.15689623e-01f, -2.00588509e-01f, -7.22221797e-03f, 9.48467031e-02f, -5.48986308e-02f, -1.73566133e-01f, -1.22179605e-01f, -3.60500813e-01f, -2.85752267e-01f,
  -3.83923173e-01f, 3.14379811e-01f, 2.04747349e-01f, 1.94487080e-01f, 4.08527523e-01f, 4.11476165e-01f, 8.14443409e-01f, 4.74322468e-01f, -6.51905090e-02f, 1.31132558e-01f,
  2.58994937e-01f, 3.48877087e-02f, -1.15366988e-01f, -1.03466049e-01f, 2.26590246e-01f, 4.83488679e-01f, 1.34951442e-01f, -1.10207364e-01f, -1.83895111e-01f, -5.26027530e-02f,
  2.66793706e-02f, -2.22731367e-01f, -4.17184949e-01f, -2.63834745e-01f, -3.58838215e-02f, -2.25487456e-01f, -7.38814399e-02f, 1.15408942e-01f, 7.68988580e-02f, -4.01378237e-02f,
  -6.38022050e-02f, 1.55481994e-01f, -1.72740445e-01f, -1.42095327e-01f, -5.38320951e-02f, -2.72425324e-01f, -2.51158565e-01f, -1.22340798e-01f, -3.69181968e-02f, -5.67812286e-02f,
  -1.88148208e-02f, -1.05350278e-01f, 1.25127420e-01f, 2.22917087e-02f, 1.48879923e-02f, -7.19955862e-02f, -5.44502549e-02f, 2.50497848e-01f, 1.22403465e-01f, -4.23150836e-03f,
  8.68249163e-02f, 1.14922583e-01f, 3.59009504e-01f, 1.93711668e-01f, 2.46474326e-01f, -1.05077334e-01f, -5.36670722e-03f, 2.27673794e-04f, 1.76456511e-01f, -7.40663856e-02f,
  -1.34669721e-01f, 1.50758639e-01f, 1.03254989e-01f, -2.26694364e-02f, -4.47045192e-02f, -2.77092122e-03f, -7.25331232e-02f, 6.49242178e-02f, 7.70484954e-02f, -1.07474312e-01f,
  7.73244398e-03f, 1.98638439e-01f, 8.21493343e-02f, 2.49032602e-02f, -4.10723425e-02f, 7.57762417e-02f, 7.58643774e-03f, 1.63835824e-01f, -6.70624450e-02f, -5.75767644e-02f,
  1.66497715e-02f, 1.53904587e-01f, -1.13095909e-01f, 1.50238022e-01f, 2.43853014e-02f, 4.06174697e-02f, 5.35469428e-02f, -1.05385436e-02f, 6.91891313e-02f, -6.46773577e-02f,
  4.96954471e-03f, 3.82394165e-01f, -1.24361455e-01f, 4.89696600e-02f, 5.83117679e-02f, -2.55737454e-01f, -1.91827528e-02f, 2.25925688e-02f, -6.63392572e-03f, 1.41173871e-02f,
  -6.03323951e-02f, -2.52711568e-02f, 8.28269944e-02f, 5.23840310e-03f, -5.74937128e-02f, -1.75999373e-01f, 1.01926569e-02f, 5.94138801e-02f, 1.37353763e-01f, -3.32562290e-02f,
  9.26916599e-02f, 2.14449107e-03f, 2.60908697e-02f, 1.06407143e-01f, -4.55284156e-02f, -2.09918946e-01f, -8.97045285e-02f, -1.59149304e-01f, 7.91274160e-02f, -3.20354283e-01f,
  -1.26959395e+00f, -3.20010096e-01f, -1.97274104e-01f, -6.00500166e-01f, 1.97150990e-01f, 4.20779318e-01f, 2.32666731e-01f, 2.24986255e-01f, 2.58978829e-03f, 9.57819354e-03f,
  9.09461826e-02f, -1.88804567e-01f, -3.55115771e-01f, -1.01459183e-01f, -1.40440896e-01f, -2.04255044e-01f, -2.88973361e-01f, -3.64591479e-01f, -1.95659533e-01f, 2.62295961e-01f,
  1.74526982e-02f, -4.86363947e-01f, -4.50875819e-01f, -2.25579485e-01f, -7.32263699e-02f, -1.13582991e-01f, -3.43981504e-01f, -2.96623617e-01f, 2.39087507e-01f, 4.39302213e-02f,
  -4.49378379e-02f, -8.28523636e-02f, 1.31763071e-01f, 5.72982244e-03f, -1.81982536e-02f, -1.97410677e-02f, -1.04897488e-02f, -1.96558043e-01f, 9.44958255e-02f, 1.35730863e-01f,
  -7.13966265e-02f, 1.37667760e-01f, -1.90778881e-01f, 3.90391015e-02f, -4.01196256e-02f, 1.81716785e-01f, -1.15188852e-01f, -2.19389901e-01f, 1.06903374e-01f, 1.48451805e-01f,
  1.87304273e-01f, 9.09470320e-02f, -4.93261330e-02f, 1.62906915e-01f, 7.92601928e-02f, 4.67995144e-02f, 1.00449890e-01f, 3.68554235e-01f, 2.33914733e-01f, 1.56801660e-02f,
  3.12368516e-02f, -2.66704876e-02f, 7.45668486e-02f, -6.28191009e-02f, -3.21926214e-02f, 8.78270774e-04f, -1.93713099e-01f, -1.05282366e-02f, 3.47510315e-02f, -1.61861658e-01f,
  1.38567388e-01f, 6.55495226e-02f, -2.55848318e-02f, -6.03730306e-02f, 2.41414122e-02f, 1.55912456e-03f, -9.17998981e-03f, 7.21361339e-02f, 1.29101992e-01f, 2.80097257e-02f,
  -2.07092222e-02f, 2.81210523e-02f, -8.78613591e-02f, 6.81849867e-02f, 4.74113524e-02f, -1.93498526e-02f, 1.28067091e-01f, 1.68675035e-01f, -5.83059303e-02f, 1.09295569e-01f,
  -4.79677826e-01f, -1.22729436e-01f, -1.33938134e-01f, 1.23043239e-01f, -1.39279314e-03f, 9.70131718e-03f, -2.27091275e-02f, -8.87884945e-02f, -5.62774688e-02f, 9.83012393e-02f,
  1.39143944e-01f, -3.20005743e-03f, -1.35269508e-01f, 7.67444074e-02f, 6.54113144e-02f, 2.11595863e-01f, 1.20691128e-01f, -1.66952118e-01f, 1.00809850e-01f, 1.73468783e-01f,
  2.85856742e-02f, 1.42297879e-01f, -2.94956595e-01f, 4.35079448e-02f, -7.22165555e-02f, -2.13021010e-01f, -7.19377622e-02f, 7.04981610e-02f, 2.47972552e-03f, -4.22409594e-01f,
  6.31661296e-01f, -3.36405247e-01f, 2.63729900e-01f, 3.29599202e-01f, 1.04976639e-01f, 2.82731146e-01f, 1.09455191e-01f, 1.33586302e-01f, 1.79400221e-01f, 1.29937693e-01f,
  2.32899055e-01f, 2.54087538e-01f, 2.38374099e-01f, 1.15114421e-01f, 1.00672528e-01f, 4.71734144e-02f, 8.17440171e-03f, 8.76574889e-02f, 3.14469218e-01f, 9.66916531e-02f,
  7.11275870e-03f, -1.13142170e-01f, -1.96955368e-01f, -1.86650872e-01f, -1.84542567e-01f, 1.64355934e-01f, -1.54931128e-01f, -1.35869384e-01f, -8.42969567e-02f, -3.35882038e-01f,
  2.72109836e-01f, -6.80805463e-03f, 2.57174045e-01f, 3.83351631e-02f, -1.56282350e-01f, -4.36343029e-02f, 4.20310423e-02f, -3.21788117e-02f, -6.15830198e-02f, 5.57697602e-02f,
  -1.21639356e-01f, -1.75658390e-01f, -1.81329012e-01f, 2.61854776e-03f, -7.60069191e-02f, -3.08953337e-02f, -1.34753749e-01f, 1.79149911e-01f, 1.88382745e-01f, -2.24380977e-02f,
  -3.98906730e-02f, -3.37800793e-02f, 2.32641641e-02f, 9.12819132e-02f, -3.28493752e-02f, 2.96984836e-02f, -4.00209837e-02f, 6.15884177e-02f, 1.97015330e-01f, 6.05790354e-02f,
  2.20472738e-01f, 6.77419752e-02f, -5.42611778e-02f, 1.93225034e-02f, -4.92809527e-02f, 1.28539056e-01f, 2.72065364e-02f, -1.01527117e-01f, 4.14335839e-02f, -2.53150165e-01f,
  1.07695013e-01f, 1.85281515e-01f, 1.03205092e-01f, 1.05048388e-01f, 2.06643366e-03f, -1.93256691e-01f, -1.13444068e-01f, -3.37534025e-02f, -1.10333391e-01f, 4.67614569e-02f,
  1.82950664e-02f, -8.94908980e-03f, -3.13709937e-02f, -1.72642618e-01f, 5.54433987e-02f, 1.02322370e-01f, -5.48950455e-04f, -5.88669442e-02f, -1.33947328e-01f, -6.85988963e-02f,
  9.76810902e-02f, 2.08194658e-01f, 1.35792866e-01f, -6.33298010e-02f, -4.59612273e-02f, -1.81647837e-01f, 1.35247126e-01f, 3.29283513e-02f, -1.17697865e-01f, 1.93227641e-02f,
  -7.32421651e-02f, -1.10826835e-01f, -1.43296972e-01f, -1.35391951e-01f, -2.87519693e-02f, -3.47659700e-02f, -1.27751976e-01f, 1.11236088e-01f, -4.48737666e-02f, -7.83817321e-02f,
  -1.34678170e-01f, 7.09243417e-02f, 3.02237481e-01f, 7.41136149e-02f, 1.10077821e-01f, 1.80093259e-01f, 6.74431175e-02f, -1.18291430e-01f, 8.70579109e-02f, 1.57854363e-01f,
  -5.98923802e-01f, -4.57419574e-01f, -1.39098257e-01f, -3.68648358e-02f, 3.21822464e-01f, 2.60710359e-01f, -2.33605653e-01f, -3.51466298e-01f, -3.10650561e-02f, -4.66930382e-02f,
  2.22568691e-01f, 1.88001215e-01f, 7.43498057e-02f, 1.45645201e-01f, -3.39124084e-01f, -2.59797834e-02f, 2.97484100e-01f, -3.69574502e-02f, -1.71082824e-01f, -1.83039382e-01f,
  2.57245094e-01f, -1.50141492e-01f, -3.14740151e-01f, -2.11137563e-01f, -1.04447931e-01f, 6.72442690e-02f, 1.15649059e-01f, 1.17731228e-01f, 1.32983938e-01f, 3.39954942e-01f,
  4.07258213e-01f, -3.98419082e-01f, 1.90168515e-01f, -1.90797038e-02f, 7.65723363e-02f, -1.19949892e-01f, -4.58363183e-02f, -1.07328668e-01f, 1.47614544e-02f, 7.86507037e-03f,
  1.12940975e-01f, -4.12101820e-02f, -4.19409899e-03f, 5.24170399e-02f, -2.01885149e-01f, -2.12134883e-01f, -2.63891011e-01f, -3.73707950e-01f, -3.44672501e-01f, -2.65860200e-01f,
  1.59529567e-01f, 2.17566699e-01f, -9.37238485e-02f, 5.21337315e-02f, -2.09835187e-01f, 2.61825085e-01f, -3.54110688e-01f, -8.03868696e-02f, -1.61510363e-01f, -3.66418719e-01f,
  -1.34545460e-01f, 1.16339922e-01f, 7.79272020e-02f, -8.43588263e-02f, 2.48394981e-02f, 3.70135047e-02f, 1.34548768e-01f, 9.72670168e-02f, -6.70085251e-02f, -8.76707956e-02f,
  3.97446044e-02f, 7.63681158e-02f, -6.68273792e-02f, -8.94254074e-02f, 6.33121049e-03f, 1.57137036e-01f, 5.66434162e-03f, 1.91852506e-02f, -5.23908325e-02f, -3.02935373e-02f,
  -4.75767218e-02f, 1.27003327e-01f, 6.43204078e-02f, -1.47017568e-01f, -5.70523143e-02f, -3.60126458e-02f, 1.75000019e-02f, -1.45696536e-01f, -7.44600743e-02f, -4.30861861e-02f,
  1.10573642e-01f, 5.37328780e-01f, 4.38941680e-02f, -1.34885758e-01f, 1.69871062e-01f, -7.09222723e-03f, 7.28745162e-02f, 7.49701262e-03f, -1.05603918e-01f, -2.18027681e-01f,
  -3.22513245e-02f, -1.72199756e-01f, 2.24048458e-02f, 1.60070673e-01f, -4.44919206e-02f, -8.95471498e-02f, 1.21151164e-01f, -1.62366964e-02f, -3.06273252e-02f, -1.29004456e-02f,
  -1.49495259e-01f, -3.39833617e-01f, -2.02652127e-01f, -2.62018234e-01f, -1.10528611e-01f, 2.39167307e-02f, -1.22844309e-01f, -1.99339285e-01f, -2.70661145e-01f, -7.01130092e-01f,
  4.18477893e-01f, -4.49519008e-01f, -6.53922081e-01f, -2.14431643e-01f, -5.43509483e-01f, -2.32869640e-01f, -4.20585543e-01f, -1.50191216e-02f, -2.04904005e-03f, -3.49736720e-01f,
  -5.17862849e-02f, 5.59670508e-01f, 3.24556679e-01f, 2.21713290e-01f, 1.78054929e-01f, -4.42641586e-01f, -5.94578862e-01f, -1.25732705e-01f, 4.34813559e-01f, 1.83043435e-01f,
  1.09538831e-01f, -4.16650660e-02f, 1.27373248e-01f, 7.60215372e-02f, -2.07976520e-01f, 1.28464475e-01f, -4.17110860e-01f, -2.15609357e-01f, -1.98639393e-01f, -6.99231744e-01f,
  1.23688199e-01f, -1.32982254e-01f, 7.04707876e-02f, -4.48083729e-02f, -1.90392435e-01f, 5.08134812e-02f, 1.06643356e-01f, -7.13124573e-02f, 8.28377530e-02f, -1.40860140e-01f,
  1.97928920e-02f, -1.72758102e-02f, 1.25751734e-01f, 3.13036307e-03f, -6.37393910e-03f, 2.26432718e-02f, -5.65968342e-02f, -1.09277196e-01f, -8.66434574e-02f, -3.90266813e-02f,
  1.78241096e-02f, -5.73127680e-02f, 6.46229237e-02f, -3.27401534e-02f, 1.22621410e-01f, 2.41361409e-02f, -7.58410543e-02f, 7.77118206e-02f, 2.18179580e-02f, -1.04260005e-01f,
  -8.57857764e-02f, 4.49237488e-02f, 1.58623353e-01f, -8.77135321e-02f, 1.02775291e-01f, 1.06115855e-01f, 4.83902991e-02f, 1.02072135e-01f, 1.24403387e-01f, 2.29280833e-02f,
  -3.84728722e-02f, 1.11430809e-02f, 1.14232242e-01f, 7.99029414e-03f, -1.12537161e-01f, -2.64217835e-02f, 3.73384207e-02f, -1.23074628e-01f, -4.15600091e-03f, 6.92498758e-02f,
  4.31725308e-02f, -3.97241749e-02f, -8.80053267e-02f, -3.16306055e-02f, -1.88689828e-01f, -3.30391750e-02f, -3.50112021e-02f, 1.43359648e-02f, 8.71880329e-04f, -1.12865202e-01f,
  3.76133114e-01f, -3.35698962e-01f, -8.00960790e-03f, 9.96396244e-02f, -2.71141133e-03f, -7.18015209e-02f, -1.16786972e-01f, 1.30232563e-02f, -3.24073210e-02f, -6.28122538e-02f,
  -8.42296705e-02f, 9.81645361e-02f, -1.90183409e-02f, 1.72469988e-02f, 1.10965282e-01f, -1.01669598e-02f, -8.86977613e-02f, 1.56187685e-02f, 1.31385932e-02f, -7.99134597e-02f,
  -1.22336373e-01f, 1.06642231e-01f, 2.68143445e-01f, 1.24616325e-01f, 4.79154363e-02f, 1.33644298e-01f, 1.55870631e-01f, 6.40245378e-02f, 8.07218850e-02f, 8.02149922e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  1.73856199e-01f, 3.86938751e-01f, 3.51107270e-01f, 2.60848939e-01f, 3.06083381e-01f, 1.70979798e-01f, 2.38011479e-01f, 1.41138732e-01f, 2.49018177e-01f, -8.81758481e-02f,
  -1.13111272e-01f, -5.60813323e-02f, 3.71534616e-01f, 2.38868788e-01f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -2.72400677e-01f, -6.30657017e-01f, -1.31235361e-01f, 1.37256220e-01f, 7.46857300e-02f, -1.87485754e-01f, 2.90529821e-02f, 7.36038014e-02f, -1.62552193e-01f, -4.37615484e-01f,
  -4.58631143e-02f, -6.31818473e-02f, -1.92884132e-02f, 3.69009882e-01f, -1.53261110e-01f, 4.67147678e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  2.66450405e-01f, 7.21907094e-02f, -4.18481439e-01f, 7.68458903e-01f, 4.29363281e-01f, 3.64181519e-01f, -1.75678253e-01f, 3.89635623e-01f, 5.82197547e-01f, 1.13989398e-01f,
  7.51608387e-02f, 1.68526307e-01f, 2.32179463e-02f, 1.24403566e-01f, -3.47015530e-01f, 2.31832147e-01f, 2.31594369e-01f, 4.76017073e-02f, 8.42779875e-02f, 3.60134423e-01f,
  5.02910852e-01f, 4.08808470e-01f, 4.90182459e-01f, -3.10999662e-01f, -1.53429925e-01f, 9.07650515e-02f, 1.95315287e-01f, -9.71831903e-02f, 5.41306198e-01f, -1.79922059e-01f,
  7.56361246e-01f, 3.28676909e-01f, -4.30964053e-01f, -6.08855844e-01f, -1.65582955e-01f, 7.55925655e-01f, -3.87906171e-02f, 3.00672174e-01f, 3.65191609e-01f, -3.38043839e-01f,
  2.71335304e-01f, -6.24563813e-01f, 5.18032126e-02f, 2.91794837e-01f, 3.91541384e-02f, 2.64375985e-01f, -2.86210060e-01f, 4.66553003e-01f, 5.64221084e-01f, -3.38079304e-01f,
  -5.36714345e-02f, 6.10073566e-01f, 1.34493709e-02f, 5.16837299e-01f, 2.43117288e-01f, -2.10045613e-02f, 5.22081852e-01f, 7.03549385e-01f, -2.53624439e-01f, -5.41628361e-01f,
  -4.52994555e-01f, -7.47509003e-02f, -1.27714574e-01f, 3.41211587e-01f, -9.01573747e-02f, 3.32846880e-01f, 2.76264727e-01f, -1.92067847e-02f, -2.43638933e-01f, -2.92983919e-01f,
  2.53106147e-01f, 6.34376705e-03f, 6.46526039e-01f, -1.30284071e-01f, 1.63098082e-01f, 5.20622671e-01f, 3.92609328e-01f, 2.16673389e-01f, -9.99919027e-02f, 5.59027076e-01f,
  8.25672925e-01f, 1.16697468e-01f, 6.19071769e-04f, 5.73112905e-01f, 1.87620267e-01f, 4.28734213e-01f, -3.14737707e-02f, -9.51235443e-02f, 2.62113571e-01f, 6.80624485e-01f,
  -4.89865392e-01f, -3.10759038e-01f, -4.68318760e-01f, -1.64292663e-01f, -3.25269974e-03f, 2.38098577e-01f, 3.05153757e-01f, 4.92591918e-01f, 4.61011320e-01f, 3.09109807e-01f,
  2.00593546e-01f, 5.69121480e-01f, -5.42352200e-01f, 2.65861452e-01f, 3.74469906e-02f, -2.36776426e-01f, 6.68449342e-01f, 2.88795471e-01f, 6.14593811e-02f, -1.16078809e-01f,
  -1.47489518e-01f, -1.99271172e-01f, 4.38311547e-01f, 4.98662502e-01f, 2.79219240e-01f, -9.69323888e-02f, -3.15284818e-01f, 1.78730980e-01f, -9.37124431e-01f, 3.42155755e-01f,
  8.53106081e-01f, 5.34785651e-02f, -9.37746987e-02f, 5.21899045e-01f, 1.95808530e-01f, -3.14790875e-01f, -1.34675696e-01f, 2.99261957e-01f, 1.13278937e+00f, 1.47214979e-01f,
  9.37471509e-01f, 5.88257015e-01f, 4.39295948e-01f, -2.19803303e-01f, -3.61608714e-02f, -2.57177949e-01f, 8.26791227e-02f, -7.98936784e-02f, 3.84962916e-01f, -3.00534517e-01f,
  -4.99108911e-01f, -1.70733586e-01f, -1.07481033e-01f, 4.75197911e-01f, 2.55070925e-01f, 2.69600809e-01f, 2.19580859e-01f, -5.06883323e-01f, 4.06310648e-01f, -7.09540322e-02f,
  2.64599293e-01f, -5.97936809e-01f, 9.26161557e-02f, -2.77323276e-01f, 5.12743175e-01f, 7.12875335e-04f, 7.39007950e-01f, -5.07337928e-01f, 5.83040535e-01f, -1.90263063e-01f,
  -1.30657060e-03f, -1.65713012e-01f, -3.16963606e-02f, 5.10613084e-01f, 4.05185401e-01f, 4.86307144e-01f, -4.58800942e-02f, 4.96039063e-01f, -2.27926783e-02f, 1.69330642e-01f,
  -5.53037487e-02f, 7.92744458e-02f, -1.39173374e-01f, 2.61416018e-01f, 1.53928157e-03f, 1.81547984e-01f, 4.26525623e-01f, 2.40439191e-01f, 5.72375953e-01f, 1.34060025e-01f,
  2.30068013e-01f, 5.31504869e-01f, -6.31033182e-01f, 7.80375898e-01f, 5.32517910e-01f, -5.19906104e-01f, 4.28535759e-01f, -4.94578034e-02f, -1.90482199e-01f, -1.44393742e-01f,
  -4.79763389e-01f, -3.19828928e-01f, -1.96364433e-01f, 5.52517891e-01f, 2.56242931e-01f, -3.69656742e-01f, -8.74043480e-02f, 3.77268612e-01f, 2.02297598e-01f, -6.98688179e-02f,
  -5.61079010e-03f, 3.21349800e-02f, 4.20353591e-01f, 4.58208412e-01f, 4.01386321e-01f, -1.82637319e-01f, 8.67915303e-02f, 6.00199997e-02f, 3.68167460e-01f, -8.63524601e-02f,
  9.83125356e-05f, 3.97917628e-01f, 7.56239951e-01f, 5.81997633e-01f, 4.38521653e-01f, -9.50399265e-02f, -7.74727762e-01f, 1.10272981e-01f, -4.01273631e-02f, -4.51030023e-02f,
  1.44911855e-01f, 4.86671664e-02f, 4.30508167e-01f, 9.41004157e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  2.00741813e-01f, 4.20733541e-01f, -1.79716408e-01f, 1.02079690e-01f, 3.50135922e-01f, 3.27944130e-01f, 2.04688087e-01f, 1.82252273e-01f, 6.02221906e-01f, 3.20704311e-01f,
  -1.74316451e-01f, 3.79855335e-02f, -1.66798934e-01f, 2.30663449e-01f
};

// L2_fan_Wp (Shape: 1 x 16)
const int L2_fan_Wp_rows = 1;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -2.48849362e-01f, -1.07310908e-02f, -2.61727720e-01f, 7.89643452e-02f, -2.19620645e-01f, 1.87572744e-02f, -2.12310389e-01f, 1.61293577e-02f, 1.01744002e-02f, -4.45130616e-02f,
  -2.97484696e-01f, 1.90871269e-01f, -7.27594271e-02f, 1.85472354e-01f, 2.84682125e-01f, 2.70486593e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 16)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  -3.99795085e-01f, 2.13826492e-01f, 3.67745310e-01f, 1.17574900e-01f, 3.43373477e-01f, 7.03673720e-01f, -1.22803248e-01f, 6.74840093e-01f, 4.12441462e-01f, 9.76132154e-01f,
  2.51366764e-01f, -3.79916072e-01f, 1.93231732e-01f, 1.78589731e-01f, 5.08154094e-01f, 8.70632827e-02f, -7.62157381e-01f, -1.21600375e-01f, -3.79536331e-01f, 5.99346995e-01f,
  -6.71636701e-01f, -1.32481560e-01f, 1.18492275e-01f, -1.07477114e-01f, 2.50563562e-01f, -6.33092672e-02f, 2.98220903e-01f, 5.99957407e-01f, -2.26239443e-01f, -6.46119937e-02f,
  3.24499160e-01f, 4.87289101e-01f, 1.09699643e+00f, -2.28454739e-01f, -4.07335103e-01f, 3.93292129e-01f, -6.14497483e-01f, -4.82589692e-01f, 1.57999992e-01f, 6.62530540e-04f,
  4.43141341e-01f, -6.03758335e-01f, 2.39005879e-01f, 6.58430338e-01f, -6.75628603e-01f, -7.71517381e-02f, 3.16622794e-01f, 1.80622116e-02f, -1.21996641e+00f, -6.10805042e-02f,
  2.34696027e-02f, 4.39520329e-01f, 6.24095559e-01f, -1.40682235e-01f, -1.18439540e-03f, -6.83278367e-02f, -1.89097807e-01f, -1.84437037e-01f, 3.23651522e-01f, 2.39492476e-01f,
  -3.01566452e-01f, -1.34135649e-01f, -4.81324308e-02f, 4.05006170e-01f, 4.76205260e-01f, -5.25244653e-01f, -3.44874412e-01f, -1.22657843e-01f, -6.55011714e-01f, -4.39225465e-01f,
  -2.12771520e-01f, -1.67501897e-01f, 3.54453206e-01f, 2.69013703e-01f, 1.02896261e+00f, 3.25716168e-01f, -3.35235238e-01f, 2.54895300e-01f, 1.41220361e-01f, -2.39759654e-01f,
  1.22701013e+00f, 5.13245583e-01f, 1.70060188e-01f, 2.97861248e-01f, -6.34751439e-01f, 1.29855976e-01f, -1.16303253e+00f, 5.00715494e-01f, -2.00891808e-01f, -6.32009745e-01f,
  -2.17017382e-01f, 2.56521553e-01f, 1.56344607e-01f, -5.14723599e-01f, -2.32281268e-01f, 5.26115119e-01f, 2.47265205e-01f, 3.33297253e-01f, -1.19102150e-01f, 2.30874076e-01f,
  -4.23578732e-02f, 4.85304952e-01f, -3.72546725e-02f, 6.14964545e-01f, -6.03804410e-01f, 4.05959666e-01f, 5.53872645e-01f, -1.60539970e-01f, -1.87454760e-01f, -1.55273950e+00f,
  -6.32298708e-01f, 1.52947918e-01f, 1.43993469e-02f, -9.28034037e-02f, -1.82836831e-01f, -5.52163601e-01f, -6.26071036e-01f, -1.11976504e+00f, 1.08476862e-01f, -4.62861866e-01f,
  6.05296314e-01f, 5.16714096e-01f, 4.03845906e-01f, -9.06273909e-03f, 7.21669197e-03f, 5.09650409e-01f, 1.08476661e-01f, 1.13589726e-01f, 1.95377529e-01f, 2.65757293e-01f,
  2.76727349e-01f, 1.67225010e-03f, 4.29232568e-02f, 6.09005749e-01f, -4.53114986e-01f, 4.31403041e-01f, 1.01807959e-01f, -6.75910562e-02f, 5.51114917e-01f, -9.06323716e-02f,
  3.05669516e-01f, 1.88857675e-01f, -4.59029764e-01f, 4.31127369e-01f, -2.07335204e-01f, 5.66319656e-03f, 3.26472789e-01f, 5.12249172e-01f, -2.26236526e-02f, 5.42538948e-02f,
  1.36783600e-01f, -8.87581035e-02f, 5.04738763e-02f, -6.04776919e-01f, -1.09120473e-01f, 5.25260866e-01f, 1.56113774e-01f, -1.38600171e-01f, 2.81373650e-01f, 2.74600774e-01f,
  -2.22885713e-01f, 2.98769921e-01f, 1.65344626e-01f, -1.14764139e-01f, 3.06569844e-01f, 3.66305411e-02f, 8.85884985e-02f, 2.76688695e-01f, 4.21180487e-01f, 7.61761189e-01f,
  -1.56762734e-01f, -2.34118283e-01f, 4.35544830e-03f, 3.31163742e-02f, 4.07694966e-01f, -3.45602751e-01f, 1.39121079e+00f, -6.14537671e-02f, 3.15387428e-01f, -1.25904962e-01f,
  -5.14572799e-01f, 2.77280569e-01f, 5.15804738e-02f, 2.87539274e-01f, 2.50911593e-01f, 2.77002692e-01f, -1.51028559e-02f, 1.65269315e-01f, 2.28555694e-01f, 4.02110279e-01f,
  -1.36117712e-01f, 1.03822380e-01f, -7.56987572e-01f, 6.32522702e-01f, 3.37143451e-01f, 3.66276711e-01f, 4.92151916e-01f, 5.39869927e-02f, 1.61869362e-01f, -2.70477355e-01f,
  3.32445204e-01f, -2.55462110e-01f, -3.91880386e-02f, 4.00345743e-01f, 2.62644142e-01f, 1.16472542e-01f, 1.34831250e-01f, 5.59053719e-01f, 4.94831294e-01f, -4.24136817e-01f,
  3.07104886e-01f, -2.61811316e-01f, -4.12134588e-01f, 4.79841918e-01f, 3.24108332e-01f, 3.09057295e-01f, -1.35221213e-01f, 1.06276488e+00f, 3.49448137e-02f, -2.99453408e-01f,
  -2.09845334e-01f, 3.17767560e-01f, 1.71361759e-01f, -9.23713982e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  -3.86414170e-01f, -1.08957991e-01f, 4.39732701e-01f, -3.60208303e-01f, 1.28729180e-01f, 5.31610727e-01f, 5.33207715e-01f, 4.05528605e-01f, 2.78659761e-01f, 3.69956344e-01f,
  2.22859550e-02f, 7.57602811e-01f, -3.32007021e-01f, 3.33735734e-01f
};

// L3_fan_Wp (Shape: 1 x 16)
const int L3_fan_Wp_rows = 1;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  1.21942563e-02f, 2.16161832e-01f, -2.36949064e-02f, -1.29122600e-01f, -3.38664353e-02f, 2.53976047e-01f, 3.07684094e-01f, 3.74495760e-02f, 3.91542554e-01f, -2.75454581e-01f,
  1.22079425e-01f, 2.30653182e-01f, -1.50342375e-01f, -2.53635436e-01f, -8.85133967e-02f, -1.22596994e-01f
};

// L3_fan_Wp_bar (Shape: 14 x 16)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  -3.84485155e-01f, 6.84627950e-01f, 4.57394004e-01f, 6.97625875e-01f, 1.32602334e-01f, 3.13773304e-01f, -4.58541185e-01f, -1.36774063e-01f, -7.18056023e-01f, -4.11376916e-02f,
  2.31872112e-01f, 5.44645898e-02f, -7.74653479e-02f, 2.33115852e-01f, 4.49991859e-02f, 1.21412963e-01f, 2.71702915e-01f, -2.76176423e-01f, 1.43379644e-01f, -3.27342719e-01f,
  4.06064957e-01f, -4.70085144e-01f, -1.48716420e-01f, 9.30875301e-01f, 2.89696574e-01f, 8.46623257e-02f, 1.84734881e-01f, 4.27897386e-02f, -1.68847721e-02f, 5.99341512e-01f,
  -2.30550081e-01f, 3.24872047e-01f, -1.05362311e-01f, 1.08527064e+00f, 2.32247621e-01f, 3.71693939e-01f, 6.72304034e-01f, -2.53785998e-01f, -2.78244559e-02f, -5.84009178e-02f,
  -1.71656489e-01f, -3.88890266e-01f, -6.02104068e-01f, 2.58648545e-01f, 1.63968280e-01f, 3.52778323e-02f, 2.39359871e-01f, 1.00761004e-01f, 5.56936502e-01f, 3.85952443e-01f,
  -1.67559907e-01f, 1.26751795e-01f, 6.82374239e-01f, -3.96690339e-01f, 8.82081151e-01f, 4.82988864e-01f, 2.76978195e-01f, 4.49731469e-01f, 3.59149218e-01f, -1.47201940e-01f,
  -3.19152206e-01f, 5.58348000e-01f, -1.82737544e-01f, -5.88235855e-01f, -1.33473739e-01f, -9.90411639e-01f, 3.91911805e-01f, -5.55811405e-01f, -4.29628104e-01f, -1.45026535e-01f,
  -2.39019528e-01f, -2.56167710e-01f, 7.62720883e-01f, -2.35076264e-01f, 3.17251474e-01f, 1.45772593e-02f, -1.23138852e-01f, 5.49497679e-02f, -1.34583011e-01f, 9.82057378e-02f,
  9.82771754e-01f, 7.24744871e-02f, 3.32316607e-02f, 4.95904163e-02f, 7.63667822e-01f, -9.65056717e-01f, 7.83075511e-01f, -1.46458939e-01f, -6.12960875e-01f, 6.62512302e-01f,
  -4.98943061e-01f, -4.27763224e-01f, 2.86696136e-01f, 2.41431475e-01f, -1.03918165e-01f, 1.75820887e-01f, -7.16364563e-01f, 3.13473880e-01f, 1.42390028e-01f, 2.79630512e-01f,
  -2.70162672e-01f, 1.87682658e-01f, -5.43183327e-01f, 1.34519294e-01f, -1.28463149e-01f, -9.49466042e-03f, 4.27927464e-01f, 7.28634894e-02f, -6.46462515e-02f, -3.37106250e-02f,
  4.57556635e-01f, 6.92854151e-02f, -3.18418264e-01f, 2.44570598e-01f, -7.93494843e-03f, 6.41878426e-01f, 4.82044786e-01f, 3.09833944e-01f, 5.79634607e-01f, -6.39932379e-02f,
  -3.65516692e-01f, -2.71379296e-02f, -2.36130193e-01f, 3.70046377e-01f, -5.59793301e-02f, -3.19333166e-01f, 2.62704521e-01f, 2.04093270e-02f, -2.23972082e-01f, 1.56311020e-01f,
  6.08711123e-01f, 8.90973657e-02f, -4.14056301e-01f, 1.18792601e-01f, -3.42199147e-01f, -6.50679588e-01f, -1.43358111e-01f, 3.92929077e-01f, 7.82202929e-02f, -4.50258613e-01f,
  6.56882107e-01f, 1.28399104e-01f, 1.30314633e-01f, 3.40600997e-01f, -4.45178717e-01f, -1.66550472e-01f, -8.98010805e-02f, -1.60310000e-01f, 6.24191761e-02f, 3.43577206e-01f,
  -7.54763067e-01f, 1.03695142e+00f, 7.62955666e-01f, -1.64223492e-01f, 1.42116711e-01f, 7.60974288e-01f, 1.35477502e-02f, 2.96685457e-01f, 5.72490096e-01f, -3.29320192e-01f,
  -2.82447249e-01f, -4.71648306e-01f, 3.22118878e-01f, 1.89151093e-01f, 3.00430417e-01f, 4.77026701e-01f, 3.03671479e-01f, -1.93444505e-01f, -5.03356040e-01f, 3.46944064e-01f,
  2.95233995e-01f, 3.80041152e-01f, -2.40710061e-02f, 2.27675214e-02f, 5.76218247e-01f, -4.29069668e-01f, 2.65949398e-01f, 7.26966619e-01f, -7.44385123e-01f, 4.61962104e-01f,
  6.34761512e-01f, 1.57670513e-01f, 7.32995421e-02f, 7.54365742e-01f, 1.07284054e-01f, -5.36208153e-01f, -1.19895078e-01f, 7.15263903e-01f, -6.94511831e-01f, 9.89529490e-02f,
  2.77555764e-01f, -1.27895808e+00f, -2.87292331e-01f, -4.99893218e-01f, 5.01492143e-01f, 3.86277474e-02f, -4.59513098e-01f, 2.48189926e-01f, -3.21918488e-01f, -2.66860068e-01f,
  7.65039504e-01f, 3.85661155e-01f, 9.21425894e-02f, 7.55821690e-02f, 3.38808358e-01f, -4.72579449e-02f, 2.09675044e-01f, 2.72782803e-01f, 4.93134499e-01f, 7.79092550e-01f,
  2.38908455e-01f, 2.42454886e-01f, 2.79172271e-01f, -5.00841320e-01f, -1.30509049e-01f, 6.32721782e-01f, -5.67656830e-02f, -2.86585510e-01f, 3.44565988e-01f, -7.45784193e-02f,
  4.85372432e-02f, 5.08604109e-01f, -3.49885821e-01f, 5.77074707e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  -4.09391612e-01f, 5.54053724e-01f, -1.23850210e-02f, 5.65398097e-01f, 3.20481151e-01f, 4.56669867e-01f, -9.19828773e-01f, -6.18840992e-01f, -3.28620344e-01f, 4.73221421e-01f,
  2.33763784e-01f, 6.15883648e-01f, -4.66256291e-01f, 2.71496743e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  -9.52978209e-02f, -5.01698256e-01f, 1.85297951e-01f, -4.10398543e-01f, -3.32758486e-01f, -8.50186765e-01f, -2.69500762e-01f, -4.44615752e-01f, 3.47266376e-01f, 1.44775718e-01f,
  -7.60628641e-01f, 3.04734975e-01f, 2.29695439e-01f, 1.72650754e-01f, 4.90156077e-02f, -5.36633432e-01f, -9.37716663e-02f, -3.41567546e-02f, 6.21838914e-03f, -5.80094866e-02f,
  -3.00265551e-01f, -1.04561853e+00f, 3.70593816e-01f, 1.44550636e-01f, 1.44770086e-01f, -5.51412523e-01f, 1.09699756e-01f, 3.29321474e-01f, 2.35495940e-01f, -6.29775941e-01f,
  3.29808325e-01f, -8.23820353e-01f, -6.92928195e-01f, 6.04475260e-01f, -1.21238554e+00f, 3.09218615e-01f, -1.45755127e-01f, 1.37127906e-01f, -3.09173107e-01f, -1.35615647e+00f,
  -8.34201455e-01f, -5.71158707e-01f, -1.40417486e-01f, 5.96878231e-01f, -1.88572139e-01f, 6.56158566e-01f, -4.35449958e-01f, 3.56172234e-01f, -8.61634970e-01f, 6.41542017e-01f,
  3.89660388e-01f, -6.73265934e-01f, 6.34018898e-01f, -3.49610358e-01f, -9.29928064e-01f, -6.64417028e-01f, -2.32302651e-01f, 1.23243064e-01f, -4.30533946e-01f, -8.82916078e-02f,
  1.65574729e-01f, 2.46155754e-01f, -5.11511981e-01f, -3.72366667e-01f, 5.24572194e-01f, -6.16317382e-03f, 9.06125009e-02f, 2.14516744e-01f, 3.91363829e-01f, -1.39553130e-01f,
  -7.31369555e-01f, 1.81315616e-01f, 2.65392751e-01f, -1.51384979e-01f, -1.89028718e-02f, 2.80709326e-01f, -1.53900847e-01f, 2.80302674e-01f, -2.16118425e-01f, 4.50535953e-01f,
  7.21308663e-02f, -2.81964183e-01f, -8.68033767e-02f, 4.43763644e-01f, -1.17968634e-01f, 3.33232284e-01f, 2.57766902e-01f, -2.70699233e-01f, 1.66982591e-01f, -6.13908231e-01f,
  -3.80653083e-01f, 3.70782852e-01f, -1.78517532e-02f, -4.26176548e-01f, -3.30913290e-02f, 2.36417845e-01f, 5.00425816e-01f, -8.19996119e-01f, -8.50037038e-01f, 2.62127548e-01f,
  -4.19884235e-01f, 4.30706263e-01f, 2.51859333e-02f, 6.00778759e-01f, -9.84966829e-02f, -1.19084328e-01f, -5.26286364e-01f, 1.79188490e-01f, 2.89765030e-01f, -1.16009665e+00f,
  -7.59727061e-01f, 3.84488434e-01f, -5.74319996e-02f, -3.80750239e-01f, 3.12629193e-01f, -7.14833438e-01f, 5.08711517e-01f, -1.17851920e-01f, -2.10432649e-01f, 3.29673402e-02f,
  1.11684926e-01f, 4.32885200e-01f, 1.11987792e-01f, -1.93312019e-01f, 2.23373041e-01f, -7.19355226e-01f, 9.35548320e-02f, -1.62897885e-01f, -2.33088866e-01f, -6.70522571e-01f,
  5.48006415e-01f, 8.03386942e-02f, -1.43153727e-01f, -5.36007822e-01f, 1.78272173e-01f, -3.92895341e-01f, 2.00654581e-01f, -4.02927659e-02f, 3.74321133e-01f, -5.04961133e-01f,
  -2.84456581e-01f, -2.77962089e-01f, -8.77289400e-02f, 5.27771950e-01f, 2.81652033e-01f, 3.68651688e-01f, 6.58704787e-02f, -4.87658083e-01f, -8.70314240e-02f, 3.51647764e-01f,
  4.86082703e-01f, 1.19674057e-01f, -8.26652646e-01f, 1.79534003e-01f, -6.99540019e-01f, -5.74171782e-01f, 3.34735245e-01f, 2.11493060e-01f, -5.05961597e-01f, 5.19340634e-02f,
  3.47238302e-01f, 7.83922136e-01f, -2.76171654e-01f, 1.57668844e-01f, 6.88414574e-02f, -6.74157441e-01f, 5.45761108e-01f, -6.76203430e-01f, -4.10437971e-01f, 7.00681284e-02f,
  1.98229894e-01f, 1.03235142e-02f, -1.38658202e+00f, -1.06545568e+00f, 3.04087430e-01f, 4.47668940e-01f, -6.44688070e-01f, -4.55733746e-01f, 4.81567346e-02f, -2.46983673e-03f,
  -1.06476378e+00f, -1.75355151e-01f, -3.39116663e-01f, 5.02003372e-01f, -8.00767839e-01f, -7.00360417e-01f, 3.06710511e-01f, -7.80423224e-01f, -3.62399630e-02f, -6.19178832e-01f,
  1.68970346e-01f, 2.82046974e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -8.75006542e-02f, 1.86366439e-01f, 5.26805222e-01f, -1.44326955e-01f, -3.72582436e-01f, -2.47252449e-01f, 5.64974189e-01f, -9.79338437e-02f, -2.25692168e-01f, 2.58184940e-01f,
  -2.07358986e-01f, 3.64181995e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    