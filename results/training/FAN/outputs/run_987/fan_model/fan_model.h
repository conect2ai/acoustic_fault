/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -7.27429748e-01f, -2.45956972e-01f, 3.48053008e-01f, -3.12022924e-01f, -1.13627680e-01f, -4.42562029e-02f, -1.30824327e-01f, -1.32498935e-01f, -2.90783316e-01f, -7.83430263e-02f,
  9.83911008e-02f, 9.70006883e-02f, -3.80171835e-02f, 2.11989686e-01f, -5.79700284e-02f, -3.92442085e-02f, 1.62992626e-01f, 9.81652439e-02f, 6.22456782e-02f, -4.57124934e-02f,
  -6.61723688e-02f, -2.30256453e-01f, -1.92135870e-01f, -2.72587817e-02f, -9.32606980e-02f, -8.52632821e-02f, 1.17377996e-01f, 2.67320573e-02f, 1.12124585e-01f, 4.13854748e-01f,
  2.99750209e-01f, -2.31756759e-03f, 1.19709231e-01f, 9.82486736e-03f, 1.01657435e-01f, 3.05425860e-02f, 8.97309259e-02f, 1.21588126e-01f, 1.63433782e-03f, 4.39645760e-02f,
  5.60700223e-02f, 4.53602336e-02f, 3.36319059e-02f, -4.42871591e-03f, 3.26189250e-02f, 1.31189883e-01f, -3.39600407e-02f, -3.64204161e-02f, 8.87871813e-03f, 7.13700801e-02f,
  5.93247041e-02f, 9.72603783e-02f, 6.76853210e-02f, 9.16757286e-02f, 1.19550653e-01f, 6.69201910e-02f, 8.08759313e-03f, 1.39421955e-01f, 2.19562307e-01f, 3.17863449e-02f,
  -1.12775654e-01f, 2.16673687e-02f, 2.28022784e-02f, -4.80961576e-02f, -3.94831039e-02f, -4.76625413e-02f, 3.07494644e-02f, -5.73820621e-02f, -2.12556347e-02f, -8.39880407e-02f,
  2.22950149e-02f, 4.13789600e-02f, -4.45843153e-02f, -9.95217562e-02f, -1.76384207e-02f, -7.15568736e-02f, 9.06545110e-03f, 2.19842065e-02f, 6.60711676e-02f, -4.88529028e-03f,
  6.73520118e-02f, 3.39073762e-02f, -2.84754508e-03f, 4.03290652e-02f, -7.00724125e-03f, 3.21898274e-02f, -2.09904090e-02f, -1.75426491e-02f, -1.34737968e-01f, -6.38237819e-02f,
  -2.87915230e-01f, 8.83050039e-02f, 1.13645710e-01f, 3.70267294e-02f, 1.73714887e-02f, 2.97373850e-02f, 5.55312745e-02f, 5.38476519e-02f, -4.37494144e-02f, 2.11454779e-02f,
  1.98724493e-02f, -9.75816250e-02f, -4.40940484e-02f, 4.44746055e-02f, 4.33842614e-02f, 2.72432994e-02f, -3.43798622e-02f, 8.87965187e-02f, 6.62396662e-03f, -6.21599890e-02f,
  -1.23584136e-01f, -1.39120013e-01f, -1.69924587e-01f, -4.03386690e-02f, -7.78842121e-02f, -6.13736100e-02f, -6.53582513e-02f, -4.16324101e-02f, -5.26913255e-02f, -3.13789755e-01f,
  3.32928061e-01f, 1.69120416e-01f, 1.94288671e-01f, -4.91756313e-02f, 2.17472225e-01f, 3.72228861e-01f, 3.52696806e-01f, 5.52137084e-02f, -1.65223166e-01f, 5.24773523e-02f,
  3.20004642e-01f, 5.82080008e-03f, 3.81206758e-02f, -2.86391936e-02f, 6.88145310e-02f, 1.34327695e-01f, -3.85237299e-03f, -2.82528624e-02f, 9.05630067e-02f, -8.81857499e-02f,
  -1.92633554e-01f, -5.93896434e-02f, -1.14803925e-01f, -9.62546244e-02f, -6.05253689e-02f, 1.04109682e-01f, 1.48441821e-01f, 7.24750981e-02f, 1.80783093e-01f, -2.93579578e-01f,
  7.43567720e-02f, -1.28749222e-01f, 1.99438352e-02f, 2.32018195e-02f, 1.04751877e-01f, 2.06613466e-02f, 3.04199825e-03f, -5.45457453e-02f, 9.86386687e-02f, 2.95582488e-02f,
  1.18378974e-01f, -3.86669561e-02f, -1.71218254e-02f, -2.29057465e-02f, -1.22692317e-01f, -2.96292156e-02f, 3.36110182e-02f, -4.75905612e-02f, 7.62352571e-02f, -1.22796549e-02f,
  4.56102975e-02f, 1.32315665e-01f, 3.35407794e-01f, -1.01969399e-01f, -6.68273792e-02f, -3.05887945e-02f, 6.72014430e-02f, 4.45520878e-02f, 1.42854363e-01f, 7.90004209e-02f,
  -4.88295406e-02f, 1.82398736e-01f, 4.18801941e-02f, 1.68243144e-02f, 1.39890209e-01f, 3.65474895e-02f, 4.18159366e-02f, 1.26460657e-01f, -1.10428669e-01f, 1.16415180e-01f,
  -7.14902505e-02f, 3.52657698e-02f, 6.54785559e-02f, 4.83942740e-02f, -3.41127329e-02f, 4.20792773e-02f, 1.42870545e-01f, 3.79099175e-02f, -5.31250201e-02f, -4.61651422e-02f,
  8.49068686e-02f, 5.26765957e-02f, 1.31617606e-01f, -6.10667048e-04f, 3.12757911e-04f, -1.13591038e-01f, -9.11820680e-02f, 1.12051249e-01f, 8.11922327e-02f, -4.22566524e-03f,
  3.57246981e-03f, 1.79935291e-01f, -3.06827221e-02f, -1.41802445e-01f, -1.37188090e-02f, 5.44644408e-02f, -7.91788008e-03f, -1.27692193e-01f, 3.29903103e-02f, 6.00255886e-03f,
  6.58571050e-02f, 3.91801484e-02f, -3.55463624e-02f, -1.03928922e-02f, -1.25968963e-01f, -1.24867067e-01f, 7.21948892e-02f, -9.98676103e-03f, -2.90538855e-02f, 7.19742626e-02f,
  9.98484865e-02f, 7.67716691e-02f, 2.80918121e-01f, 1.31784186e-01f, 5.65025210e-02f, 1.62595317e-01f, 1.41808525e-01f, 1.10599041e-01f, 3.33250344e-01f, 3.66740763e-01f,
  5.82656920e-01f, -3.59566122e-01f, -4.40390795e-01f, 3.64132851e-01f, -1.58233359e-01f, -2.63787974e-02f, -4.40452635e-01f, 1.09532878e-01f, 2.49545112e-01f, -1.92367017e-01f,
  9.98787023e-03f, 1.99711919e-01f, 1.24760918e-01f, -8.91011301e-03f, 7.10253716e-02f, -3.97681743e-01f, -3.95453811e-01f, -3.63742597e-02f, 3.34796220e-01f, 2.26842448e-01f,
  -1.20400479e-02f, 6.14075027e-02f, 1.44886851e-01f, 1.10928781e-01f, 1.64995808e-02f, 1.73804164e-01f, -1.70844197e-01f, 6.82706013e-02f, -1.88390955e-01f, -6.14160120e-01f,
  -2.03107193e-01f, -5.97598962e-02f, -1.65542644e-02f, 1.30837351e-01f, -2.51279026e-02f, 1.95409078e-02f, -8.64052214e-04f, 1.57280490e-02f, 7.22877830e-02f, -6.68074936e-02f,
  2.06824075e-02f, 1.51976068e-02f, 1.12209477e-01f, -8.97086598e-03f, 2.44799331e-02f, -4.10946906e-02f, -3.35706188e-03f, 7.93459080e-03f, -5.19433692e-02f, -6.89590722e-02f,
  -6.73621818e-02f, -1.03258081e-01f, -3.23076509e-02f, -2.61013918e-02f, 1.28564209e-01f, 1.35715157e-01f, -1.15738243e-01f, -2.93478137e-03f, -9.80535671e-02f, -3.00095975e-01f,
  1.22236265e-02f, -4.76923734e-02f, 9.96132661e-03f, 1.25106759e-02f, 1.28899077e-02f, -5.82998898e-03f, -3.11815348e-02f, 1.00590463e-03f, 1.71995834e-02f, 1.68103464e-02f,
  -6.94312900e-03f, -5.65846311e-03f, 1.06130717e-02f, -1.36996163e-02f, 7.52445310e-03f, -4.63354252e-02f, -3.37401591e-02f, -3.45468372e-02f, 2.44151410e-02f, -1.78239718e-02f,
  6.40985966e-02f, -3.10578439e-02f, -1.57305580e-02f, -3.64420190e-02f, -7.32386950e-03f, -2.19776332e-02f, -3.15587893e-02f, -6.27221242e-02f, 1.04049422e-01f, -2.71034315e-02f,
  2.40153089e-01f, -1.00727312e-01f, -1.32319715e-03f, -2.73695961e-02f, 2.00264575e-03f, 6.70664310e-02f, -5.48784882e-02f, 5.44923125e-03f, -1.27956234e-02f, -2.73421314e-02f,
  -1.51702168e-03f, 3.89315113e-02f, -4.33276147e-02f, -1.08275153e-01f, 5.69424517e-02f, 1.88101884e-02f, 4.03115600e-02f, 1.07944198e-02f, -5.97863644e-02f, 5.26616722e-03f,
  -4.32257913e-02f, 2.85236854e-02f, 6.78413063e-02f, -6.16511889e-02f, 2.12867539e-02f, 8.05346444e-02f, -3.25849317e-02f, 4.63784374e-02f, 1.24299489e-01f, 4.74684760e-02f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.85157105e-01f, 4.41881686e-01f, 5.18196411e-02f, 1.05252609e-01f, 3.53640690e-03f, -2.06332058e-01f, -1.48841500e-01f, -4.18934792e-01f, -1.67587116e-01f, 1.66619316e-01f,
  -1.23379000e-01f, -2.16288734e-02f, 1.09226294e-02f, -9.42782499e-03f, -1.95218727e-01f, 1.01179510e-01f, 4.71673280e-01f, 8.47927853e-02f, -5.36336601e-01f, -3.06886047e-01f,
  2.72565782e-01f, 1.96163863e-01f, -6.06341809e-02f, -1.81630388e-01f, 3.07121873e-01f, -1.48675114e-01f, 1.35441080e-01f, 4.17678088e-01f, 2.85220474e-01f, 1.04073966e+00f,
  1.04896821e-01f, 3.73569936e-01f, -1.87769070e-01f, 1.60031002e-02f, 3.98509167e-02f, 1.89714029e-01f, 1.57704681e-01f, 6.69852272e-02f, -9.75784287e-02f, -5.55690266e-02f,
  1.72930881e-01f, 8.66486803e-02f, 1.67009175e-01f, 5.31461760e-02f, -1.45051479e-01f, -3.63820523e-01f, 6.77578598e-02f, -8.70646536e-02f, -1.77828982e-01f, -1.54621854e-01f,
  3.01428169e-01f, 1.02598920e-01f, -1.96259081e-01f, -3.10217232e-01f, -8.57798830e-02f, -1.16917677e-01f, -2.48142704e-01f, -4.17080801e-03f, -3.24869215e-01f, 8.25005695e-02f,
  -5.71331009e-02f, 5.71004003e-02f, 5.09709790e-02f, 5.90499602e-02f, 1.36801869e-01f, 2.22248927e-01f, 1.45282164e-01f, -1.53011009e-02f, 4.10565697e-02f, 1.78832397e-01f,
  -1.75834596e-02f, -1.22689836e-01f, -5.21921441e-02f, 4.48229723e-02f, 1.20033873e-02f, 1.15047447e-01f, -8.99039879e-02f, -4.48412374e-02f, 3.44360285e-02f, 1.35894341e-03f,
  -5.62384771e-03f, 1.25144988e-01f, 2.22372189e-02f, -6.60249125e-03f, 9.12139043e-02f, 1.07348904e-01f, 1.12373762e-01f, -1.45746648e-01f, -7.02251717e-02f, -1.58754159e-02f,
  -4.42763597e-01f, 7.97662791e-03f, 1.27444401e-01f, -1.08173661e-01f, -9.47047845e-02f, 4.52735601e-03f, -2.19279267e-02f, -4.71676849e-02f, -1.48376927e-01f, -1.62229627e-01f,
  -1.29759848e-01f, -1.28609449e-01f, 1.78977802e-01f, -4.75575998e-02f, -2.32462704e-01f, 1.47410296e-02f, 2.67518423e-02f, -1.76343709e-01f, -5.54418340e-02f, -9.35278088e-02f,
  -7.44416714e-02f, -5.51787555e-01f, -5.06729186e-01f, -2.92640001e-01f, -1.77527323e-01f, -4.18677181e-01f, -3.17271918e-01f, -5.71723104e-01f, -7.63678372e-01f, -5.43528080e-01f,
  1.04183829e+00f, -4.31587130e-01f, 2.78152227e-01f, 3.84178519e-01f, 3.13882798e-01f, 3.37342739e-01f, 5.95714003e-02f, 7.49471365e-03f, 1.90241233e-01f, -7.94437304e-02f,
  6.73994496e-02f, 1.31165788e-01f, 1.12037174e-01f, 1.62315607e-01f, 4.48003784e-02f, -1.15475878e-01f, 3.74403782e-02f, 2.49900952e-01f, 2.97858536e-01f, 3.49990055e-02f,
  -1.82310119e-01f, -2.02051461e-01f, -4.36268970e-02f, -4.53077294e-02f, -2.04252064e-01f, 3.47393826e-02f, -7.06886500e-02f, -1.66521072e-01f, -1.43408880e-01f, -3.83938700e-01f,
  7.42340609e-02f, 3.34708750e-01f, 3.06030989e-01f, 1.44479930e-01f, -5.63038364e-02f, -2.40713879e-02f, 2.70227082e-02f, -1.16216496e-01f, -6.76593259e-02f, -6.48675710e-02f,
  -1.04791634e-02f, -4.94983941e-02f, 9.51779857e-02f, -1.12131573e-01f, -6.70444146e-02f, 3.63685638e-02f, -1.82662606e-01f, -1.30905524e-01f, -2.75361538e-02f, 6.77794963e-03f,
  -1.02070896e-02f, 5.17828912e-02f, 2.09122464e-01f, 1.08377948e-01f, 5.38779162e-02f, 1.72583863e-01f, -2.96654236e-02f, 1.52206905e-02f, 1.02072628e-03f, -1.32528156e-01f,
  2.31895953e-01f, 5.77840209e-02f, 1.81681857e-01f, 8.00854266e-02f, 1.19691873e-02f, 3.04802079e-02f, 6.46524951e-02f, -5.12496494e-02f, 7.03748837e-02f, -1.20488562e-01f,
  -8.00796002e-02f, 1.44342661e-01f, 6.71459660e-02f, 9.33886915e-02f, -1.60895940e-02f, 2.63536423e-02f, -3.66957337e-02f, 1.02542900e-02f, -2.89900992e-02f, 3.76872383e-02f,
  1.74764376e-02f, -4.40124609e-02f, 2.40690857e-02f, -1.62284538e-01f, -2.33819913e-02f, 2.79946085e-02f, 5.09447008e-02f, -6.10100180e-02f, -1.04988381e-01f, -1.04454540e-01f,
  -2.12807804e-01f, 6.40145838e-01f, 1.30471244e-01f, -1.69150472e-01f, -1.17839769e-01f, -1.53453082e-01f, 7.47144148e-02f, -5.80261014e-02f, -1.61934614e-01f, 1.85537040e-01f,
  9.80688408e-02f, -4.56997491e-02f, -7.27401748e-02f, -4.27027009e-02f, 8.28553066e-02f, -2.91264895e-02f, -9.78986323e-02f, 4.86126579e-02f, 3.98975564e-03f, -8.82170051e-02f,
  -1.20470382e-01f, 1.79819494e-01f, 1.70415923e-01f, 1.06830947e-01f, 5.17007150e-02f, 2.70031393e-01f, -8.10726658e-02f, -3.80746089e-02f, 2.72774637e-01f, -5.23920320e-02f,
  -2.59660482e-01f, 2.29020089e-01f, -1.11913371e+00f, -8.48939642e-02f, -6.52594030e-01f, -3.20647061e-01f, -3.40350688e-01f, 3.13163139e-02f, 1.58891171e-01f, -1.35705426e-01f,
  -4.06008959e-01f, -4.17702228e-01f, -4.23730940e-01f, -3.35490704e-01f, -4.73311990e-01f, -2.77710527e-01f, -3.71146470e-01f, -7.52426267e-01f, -6.24022126e-01f, 1.43919261e-02f,
  -4.55069616e-02f, -4.35171068e-01f, -1.40211359e-01f, 4.01253700e-02f, 2.00101137e-01f, -1.21272616e-01f, -2.12115869e-01f, -3.44964504e-01f, 1.44748524e-01f, -3.91718835e-01f,
  -5.11778772e-01f, -8.12971443e-02f, -7.52454698e-02f, -1.47836208e-01f, -7.67397583e-02f, 1.65995255e-01f, -1.86555963e-02f, -3.44255090e-01f, 8.23586956e-02f, 1.51568994e-01f,
  -8.44047964e-02f, 2.10469067e-01f, -1.83046646e-02f, -1.26373693e-01f, -1.72245607e-01f, -7.38828629e-02f, -8.67013633e-02f, -2.03357100e-01f, -6.05218373e-02f, -1.31661473e-02f,
  -1.95859894e-02f, -2.83263087e-01f, -1.08182885e-01f, 6.47700392e-03f, -5.19152954e-02f, -3.30663890e-01f, 2.36311391e-01f, 8.67682919e-02f, -1.89442933e-02f, 2.94560939e-01f,
  -7.22660944e-02f, 5.36606684e-02f, -2.53254957e-02f, 2.88134903e-01f, 1.26337767e-01f, -3.88884395e-02f, 7.65298158e-02f, 1.96074713e-02f, 1.19486570e-01f, 1.17163721e-03f,
  -1.51872888e-01f, 1.44204206e-03f, 7.43935928e-02f, 3.88333434e-03f, -3.98482792e-02f, -9.10845026e-02f, 1.50893200e-02f, 2.03428179e-01f, 2.75129676e-02f, -8.46867785e-02f,
  -1.75611153e-01f, 1.63608402e-01f, -8.93783569e-02f, 6.03658855e-02f, -7.46955797e-02f, -2.21087318e-02f, -1.80553086e-02f, -3.00086173e-03f, -5.50617501e-02f, 1.56039314e-03f,
  -1.52679235e-02f, -1.91023290e-01f, 3.59804183e-01f, 1.25756785e-01f, -1.53585732e-01f, -1.45936031e-02f, 8.93408209e-02f, 1.98024288e-01f, -5.39175607e-02f, 1.45642355e-01f,
  -3.55878845e-02f, 3.78648681e-03f, -1.01441182e-01f, 1.09757610e-01f, -3.96620035e-02f, 5.20443469e-02f, 2.12009043e-01f, -6.81799501e-02f, 1.46445736e-01f, 3.21951509e-01f,
  1.84758112e-01f, 7.29391575e-02f, 1.73162967e-01f, 3.34219374e-02f, -1.03579182e-02f, -3.22399735e-01f, 2.85127982e-02f, 1.21558958e-03f, -6.02480210e-02f, 5.10823786e-01f,
  2.19754398e-01f, -4.83799458e-01f, 3.01149935e-01f, -4.28885043e-01f, -3.84571075e-01f, -1.15810253e-01f, -5.12372434e-01f, -2.75680739e-02f, 1.02458209e-01f, -5.08732140e-01f,
  -3.99432480e-01f, 2.40957871e-01f, 5.52136339e-02f, 2.17972413e-01f, 5.59440911e-01f, -2.95429796e-01f, -1.85053930e-01f, 6.02317810e-01f, 7.44264960e-01f, 2.79789269e-01f,
  -2.29719207e-01f, -1.19537853e-01f, 5.31761110e-01f, 3.31961036e-01f, -3.61923277e-01f, 1.78217486e-01f, -3.22163254e-01f, -1.58648819e-01f, -5.42905880e-04f, -1.66593835e-01f,
  1.26313167e-02f, -1.29096076e-01f, 1.27279267e-01f, -6.70427158e-02f, -2.11802304e-01f, 7.33906850e-02f, -1.18476622e-01f, -8.61420576e-03f, 6.98046163e-02f, 8.04774370e-03f,
  -3.19907159e-01f, 1.64240271e-01f, 5.19544445e-02f, 1.32719338e-01f, -6.36627674e-02f, -5.26458351e-03f, 1.68465823e-01f, 2.57967472e-01f, -2.32060328e-02f, -9.41166505e-02f,
  -3.14639419e-01f, -1.03426315e-01f, -6.94841752e-03f, 8.42339844e-02f, 1.90439627e-01f, 8.17646235e-02f, 4.31491323e-02f, 3.58469665e-01f, 2.87952602e-01f, -1.23811506e-01f,
  -5.52375987e-02f, 1.56854242e-02f, -5.71801588e-02f, -3.92114781e-02f, 5.93629479e-02f, -6.24073260e-02f, 1.07030064e-01f, -4.65766452e-02f, 6.62704185e-02f, 4.43721525e-02f,
  1.41609591e-02f, -2.78361011e-02f, -5.54105174e-03f, 5.62505834e-02f, 3.29112560e-02f, -9.81122255e-02f, -4.86694053e-02f, -2.71452982e-02f, 4.89386469e-02f, 4.68113907e-02f,
  6.54686093e-02f, 3.26167233e-02f, -9.48497728e-02f, 1.90393310e-02f, -1.86224785e-02f, 1.00617029e-01f, -2.11684182e-02f, 3.22887227e-02f, -2.81919609e-03f, 7.98122361e-02f,
  -3.47904116e-01f, 2.43918657e-01f, -1.46496221e-01f, 1.39296830e-01f, -5.22733852e-02f, 3.62013020e-02f, -2.12900490e-01f, 1.11600384e-02f, -4.41504866e-02f, -4.20648381e-02f,
  4.15998325e-02f, 8.81582871e-02f, -9.55019668e-02f, -5.07114418e-02f, -1.92103330e-02f, -9.64068919e-02f, -1.02043688e-01f, -5.25263883e-03f, 1.66694690e-02f, -7.77928829e-02f,
  4.18094471e-02f, -1.73336357e-01f, -2.35900260e-03f, -4.39241640e-02f, -1.22860610e-01f, 1.24478266e-02f, -1.79630160e-01f, -2.45020956e-01f, -4.51954976e-02f, -3.38336498e-01f,
  1.48150891e-01f, -8.55564356e-01f, 5.67546546e-01f, -1.74801245e-01f, -4.29948680e-02f, 1.19707240e-02f, -1.61410328e-02f, -1.92634866e-01f, -3.00896335e-02f, 6.73709437e-05f,
  2.04611104e-02f, 1.34519890e-01f, 1.57487497e-01f, 8.23987648e-02f, 6.11445308e-02f, -1.02056064e-01f, -8.45240280e-02f, 4.16117966e-01f, 6.21720612e-01f, 3.03016752e-01f,
  -1.24968253e-01f, -7.50654712e-02f, 7.33386800e-02f, 1.34696528e-01f, -1.69551983e-01f, 1.53100163e-01f, -1.51545862e-02f, -2.01330423e-01f, -1.62520155e-01f, -3.55843484e-01f,
  4.22073722e-01f, -4.34689373e-01f, 3.75330299e-01f, -1.08079821e-01f, -2.99184714e-02f, -4.57929373e-02f, 7.96844140e-02f, -5.96928336e-02f, -2.06339002e-01f, -1.27204880e-01f,
  -2.16435101e-02f, -1.28913345e-02f, -2.03534085e-02f, 2.25135498e-02f, -4.09694649e-02f, 8.27972218e-02f, -1.07091881e-01f, -4.77039106e-02f, -8.88187289e-02f, -1.62296463e-02f,
  -1.14977501e-01f, -3.17402296e-02f, -2.33207922e-02f, -3.74647416e-02f, 5.10930419e-02f, 9.68958586e-02f, -5.70783503e-02f, -5.51809594e-02f, 9.55716819e-02f, -4.91744317e-02f,
  1.80815738e-02f, 5.20504564e-02f, -7.12544322e-02f, 8.40175152e-02f, 1.11651868e-01f, -2.34760140e-04f, -1.04216546e-01f, 7.01496750e-02f, 9.91622061e-02f, 4.58778180e-02f,
  -8.78208652e-02f, 8.83876234e-02f, 8.42184126e-02f, -4.09154631e-02f, 3.28317843e-02f, -1.02687120e-01f, -1.24734705e-02f, -6.26594797e-02f, -8.22031987e-04f, -2.92990636e-02f,
  7.12396763e-03f, 2.33409572e-02f, -1.97622366e-02f, 9.50662792e-03f, -1.26815960e-01f, -3.59950098e-03f, -2.35766526e-02f, 6.65734559e-02f, -4.75326665e-02f, -6.55234158e-02f,
  -1.09060645e-01f, 1.41960487e-01f, 1.30071744e-01f, 5.37242554e-02f, -1.46519646e-01f, -1.18313342e-01f, 6.15133867e-02f, 6.86009927e-03f, -8.16792175e-02f, -1.81958824e-02f,
  -2.65821014e-02f, 5.42060286e-03f, -1.20659687e-01f, -1.21688493e-01f, 1.59368560e-01f, 1.10633215e-02f, -1.93138435e-01f, 1.06468275e-01f, -1.03638105e-01f, -4.57114615e-02f,
  -1.38579756e-01f, 1.40694022e-01f, 2.27425277e-01f, 1.35027319e-01f, 5.75515553e-02f, 2.28400007e-01f, 2.37253308e-01f, 1.27060160e-01f, 1.22958340e-01f, 2.75053028e-02f,
  4.81904835e-01f, -6.83954537e-01f, 2.59730965e-01f, -1.30134206e-02f, -3.80316786e-02f, -1.20754473e-01f, 7.56868720e-02f, -2.28772715e-01f, -1.83213614e-02f, -1.81570306e-01f,
  -4.80537325e-01f, -3.35427463e-01f, 4.66703437e-02f, -2.25672364e-01f, -4.65967096e-02f, 2.50812799e-01f, 1.13790780e-01f, 3.07713598e-01f, 2.86494732e-01f, 2.47165989e-02f,
  -8.39903429e-02f, 2.34028593e-01f, 1.05486423e-01f, -2.14176010e-02f, -1.77880097e-02f, 1.78854063e-01f, 6.10243082e-02f, -1.93975657e-01f, -2.99955547e-01f, -4.20470210e-03f,
  3.12064409e-01f, -4.78347301e-01f, 1.60147324e-01f, -2.19525948e-01f, -1.89448833e-01f, 2.83233579e-02f, 5.28241955e-02f, 5.38051091e-02f, 4.85817939e-02f, 1.68816924e-01f,
  -1.77119911e-01f, -1.44791380e-01f, -6.96012378e-02f, 8.75200853e-02f, 1.09782495e-01f, -2.90539628e-03f, -1.61601007e-02f, -1.67487562e-02f, -2.95345068e-01f, -1.07226275e-01f,
  -3.02094489e-01f, -2.03504026e-01f, 2.60954872e-02f, -2.27282524e-01f, -3.13835979e-01f, -8.69828165e-02f, -3.34279031e-01f, -2.86386847e-01f, -3.70179504e-01f, 5.52287400e-02f,
  -7.53350034e-02f, 2.36814380e-01f, -1.47720531e-01f, 4.31467928e-02f, -6.17817752e-02f, 2.65911855e-02f, -4.34244499e-02f, 5.56006543e-02f, -1.08796746e-01f, 1.06839709e-01f,
  -6.19179718e-02f, -4.20707986e-02f, 4.32199687e-02f, -8.41090009e-02f, -7.05466792e-02f, -7.89209232e-02f, 3.10888346e-02f, -4.52552922e-02f, -8.82267654e-02f, 1.38756663e-01f,
  -5.23582883e-02f, 3.71518987e-03f, 1.12247452e-01f, -9.51787904e-02f, -1.55956686e-01f, -2.03014277e-02f, 6.71126321e-02f, -7.80343115e-02f, 1.09238878e-01f, -6.39960915e-03f,
  2.18786150e-01f, -3.92898351e-01f, 4.30971861e-01f, -4.14343551e-02f, -4.66452679e-03f, -5.93582839e-02f, -1.45353332e-01f, -2.06111372e-01f, 6.04628883e-02f, 5.06647155e-02f,
  -2.35396609e-01f, 3.77868675e-02f, 7.17880875e-02f, -1.64695591e-01f, 2.01223388e-01f, -7.69909620e-02f, -9.15633813e-02f, 1.60950989e-01f, -1.14723265e-01f, 2.11449750e-02f,
  -1.48228118e-02f, 1.41109869e-01f, 2.69296378e-01f, 1.79573357e-01f, 1.80035625e-02f, 3.40135247e-01f, 1.85334906e-01f, 2.45758355e-01f, 1.73392534e-01f, 6.22885287e-01f,
  -8.93992543e-01f, -3.33204418e-01f, -4.91136134e-01f, 4.30386096e-01f, 5.67185819e-01f, 4.18156266e-01f, 4.72231567e-01f, 2.91867226e-01f, 2.22124621e-01f, 7.12227672e-02f,
  -3.56773347e-01f, -3.50666940e-02f, -6.79023489e-02f, 3.65087688e-02f, 9.20045152e-02f, 4.91091490e-01f, 6.77539110e-01f, -2.31019855e-02f, -1.58526167e-01f, 3.16040218e-02f,
  3.27634513e-01f, 8.65614787e-02f, -3.95848542e-01f, 6.12218231e-02f, 7.40863681e-02f, -2.32322421e-02f, 2.28849035e-02f, 1.27258897e-01f, -6.84745908e-02f, 2.16921717e-01f,
  -6.92332327e-01f, -1.80920318e-01f, 2.35416934e-01f, -6.21164851e-02f, -2.06991613e-01f, -2.11074531e-01f, -2.93774884e-02f, 1.47254504e-02f, 8.82208906e-03f, 1.62478000e-01f,
  -3.98565046e-02f, -1.56781986e-01f, -7.76080322e-03f, -1.72496438e-02f, -1.28312781e-01f, -6.21616319e-02f, -8.38836282e-02f, -1.84694212e-02f, 4.26695570e-02f, -4.38527614e-02f,
  1.69358894e-01f, 1.33638931e-02f, 6.98929951e-02f, 6.11637235e-02f, 5.62095940e-02f, 4.59617674e-02f, -2.22377360e-01f, -5.44543602e-02f, -8.84289891e-02f, 1.21585801e-02f,
  5.87462448e-02f, -4.87436866e-03f, -1.48085997e-01f, -8.41036513e-02f, -3.72259505e-02f, 7.01092258e-02f, 1.50817961e-01f, 5.42934090e-02f, 4.60019223e-02f, 3.45173366e-02f,
  7.90648535e-02f, 3.52222174e-02f, 3.94008420e-02f, 1.49764828e-02f, -1.99435223e-02f, -3.67703550e-02f, 2.33319346e-02f, -6.69548335e-03f, -8.30077827e-02f, -5.00333607e-02f,
  -1.12190135e-01f, 5.92420204e-03f, -6.45238385e-02f, -8.09792057e-02f, 1.80720426e-02f, -1.11938931e-01f, -7.55212083e-02f, -1.43384933e-01f, 3.81544754e-02f, 1.47909924e-01f,
  2.27139458e-01f, -5.90532646e-02f, -1.01010669e-02f, 1.67500805e-02f, -2.57904995e-02f, -6.27684370e-02f, -7.05508366e-02f, -7.00745434e-02f, -7.51590542e-03f, 1.14543721e-01f,
  -8.17262605e-02f, -3.06076378e-01f, -6.80096298e-02f, 2.40060338e-03f, -1.32720232e-01f, -7.25949556e-02f, -5.37421964e-02f, 1.02210119e-01f, 2.04630077e-01f, -8.92300755e-02f,
  7.43269995e-02f, 2.26038143e-01f, 1.67571604e-01f, 8.55988562e-02f, 1.86405450e-01f, 2.06245124e-01f, -9.60705057e-03f, 8.35570544e-02f, 2.08478794e-03f, 1.80507854e-01f,
  -5.74123979e-01f, -4.03282225e-01f, -8.19427595e-02f, 1.84928387e-01f, 3.52182835e-01f, 3.92053604e-01f, -3.16463739e-01f, 9.18415841e-03f, 3.47742289e-02f, -1.80532448e-02f,
  2.80682892e-01f, 2.70125896e-01f, 7.15143755e-02f, 1.08361050e-01f, -3.07834655e-01f, -1.37757212e-01f, -9.04702097e-02f, -7.81853423e-02f, 2.16303095e-01f, 5.11905372e-01f,
  4.10987496e-01f, -5.22992127e-02f, -2.82452852e-01f, -1.65773228e-01f, -3.62456471e-01f, 5.50923683e-02f, -3.30812424e-01f, -2.57951766e-01f, 1.04209162e-01f, -3.26483548e-01f,
  8.47131163e-02f, -2.93927610e-01f, 2.39076346e-01f, -2.23712325e-02f, 1.93667281e-02f, -1.25951767e-01f, -2.06153795e-01f, -2.63193965e-01f, -2.31896237e-01f, -2.34128460e-02f,
  1.00611281e-02f, 7.39677548e-02f, 1.53513864e-01f, 1.24537103e-01f, -2.04261560e-02f, 3.36124897e-02f, -7.00610504e-02f, -2.93220341e-01f, -4.14236844e-01f, -3.09445441e-01f,
  2.24070042e-01f, 1.81703195e-01f, -6.02639794e-01f, -3.47951725e-02f, -9.58997458e-02f, -1.70826256e-01f, -4.88000721e-01f, -2.30573416e-01f, -3.04474533e-01f, -6.22987092e-01f,
  8.17652643e-02f, 1.96293995e-01f, 5.17316647e-02f, -6.72615021e-02f, -4.54988843e-03f, 1.35136545e-01f, -1.56617258e-02f, 1.53485751e-02f, -1.68066509e-02f, -1.41048461e-01f,
  6.66710809e-02f, 2.69570630e-02f, -7.13496581e-02f, -3.72869447e-02f, -5.38952835e-02f, -8.86290744e-02f, 1.20813467e-01f, -1.09940499e-01f, -5.45309223e-02f, 2.27125436e-02f,
  -1.04142772e-02f, -7.76075199e-02f, 8.33298266e-02f, -3.02970521e-02f, 1.36357546e-03f, -6.23390079e-02f, 1.15454666e-01f, 1.27648428e-01f, 3.88475433e-02f, 2.93689538e-02f,
  -2.17013404e-01f, 2.89621204e-01f, -2.51917765e-02f, -1.48537040e-01f, -1.30961537e-01f, 8.12625140e-02f, -9.54967737e-02f, 1.69660464e-01f, -8.81309509e-02f, -1.50044128e-01f,
  -8.06770325e-02f, -2.74324983e-01f, -4.62640915e-03f, -1.44498333e-01f, -2.10191272e-02f, -1.43993214e-01f, -3.76531556e-02f, 1.18775539e-01f, -9.18585509e-02f, -8.62359852e-02f,
  8.76745209e-03f, -1.74443066e-01f, -3.57817441e-01f, -3.80601704e-01f, -2.32515857e-01f, -1.80118427e-01f, -2.97430664e-01f, -7.23961815e-02f, -3.89233112e-01f, -8.19198608e-01f,
  8.19894612e-01f, 2.55056899e-02f, 6.41217709e-01f, 1.07982799e-01f, 4.06270444e-01f, 4.61543083e-01f, 5.72892189e-01f, 2.46460721e-01f, -3.88838612e-02f, 1.60915017e-01f,
  -2.93218344e-02f, -3.34693104e-01f, -4.26639587e-01f, -3.25791270e-01f, -5.48488237e-02f, 1.15421219e-02f, -3.07654105e-02f, 2.06134468e-02f, 2.89242983e-01f, 1.73602596e-01f,
  -1.63225576e-01f, 1.73350215e-01f, 1.68669522e-01f, -5.68308979e-02f, -6.98721185e-02f, -2.29580626e-01f, 3.64997759e-02f, 1.85084581e-01f, -5.43285012e-02f, -3.80279332e-01f,
  -2.90918872e-02f, 3.59995544e-01f, -1.75159380e-01f, -1.46648332e-01f, -1.72278043e-02f, -1.53818026e-01f, -5.69620244e-02f, -5.92612512e-02f, -1.09682754e-01f, -6.60362318e-02f,
  -3.34825702e-02f, -2.55358908e-02f, 3.63533236e-02f, 6.56996667e-02f, 2.08696470e-01f, 6.28618523e-02f, 5.51052354e-02f, 9.57864448e-02f, 1.23576485e-02f, 2.19405238e-02f,
  -1.74048528e-01f, 1.89088538e-01f, 2.40112290e-01f, 1.67117581e-01f, 4.64976132e-02f, -5.43954559e-02f, 1.03629045e-01f, -4.83042467e-03f, 1.51081547e-01f, -6.67756125e-02f,
  -9.35630277e-02f, 6.20687157e-02f, 3.09737399e-02f, -7.49872252e-02f, 4.99472171e-02f, -1.19734453e-02f, 6.51229098e-02f, 1.95401944e-02f, 3.10420562e-02f, 1.01979136e-01f,
  -1.00264966e-01f, 2.63897534e-02f, -5.44934347e-02f, -1.69208609e-02f, 2.45158537e-03f, 7.00118914e-02f, 3.62065919e-02f, -1.14697821e-01f, 4.65965085e-02f, 1.94214506e-03f,
  8.12993795e-02f, -1.32840639e-02f, 3.90821695e-02f, 2.53485627e-02f, 2.27676425e-02f, 8.86984542e-02f, 8.70779250e-03f, -2.10803729e-02f, 3.88139449e-02f, 1.42146563e-02f,
  -5.31574249e-01f, 1.72769651e-01f, -2.05099598e-01f, -1.28250763e-01f, 1.38510466e-01f, -1.58975691e-01f, -1.61212198e-02f, -6.91720247e-02f, -1.12410404e-01f, -1.65921569e-01f,
  5.40457778e-02f, -7.62481317e-02f, 7.95713738e-02f, 9.73025113e-02f, 3.36772613e-02f, -7.52138719e-02f, -1.87807065e-02f, -5.73411770e-02f, -1.09872460e-01f, -1.19327061e-01f,
  -1.12377636e-01f, 7.24043176e-02f, -9.56821442e-02f, -3.19782645e-02f, -4.73272726e-02f, -1.37880564e-01f, -1.36637509e-01f, 1.92723833e-02f, 7.95567259e-02f, -5.31764105e-02f,
  -7.96953082e-01f, 1.72506988e-01f, 2.95541942e-01f, 1.02917150e-01f, -4.16265018e-02f, -2.15950623e-01f, -7.27903187e-01f, -2.73096770e-01f, 2.24354818e-01f, -1.33485317e-01f,
  1.50317237e-01f, 3.60929906e-01f, 4.14605528e-01f, -1.03244573e-01f, -6.01776302e-01f, -4.81066108e-01f, -3.19244832e-01f, -4.06552136e-01f, -3.62810135e-01f, -5.40314555e-01f,
  -4.69129473e-01f, -4.42545563e-01f, -3.23802769e-01f, 5.84836863e-02f, 3.19630533e-01f, 2.56105989e-01f, 3.78772169e-01f, 1.60138115e-01f, 2.20929757e-02f, -8.85843709e-02f,
  2.24061310e-01f, 2.86836594e-01f, -2.96265244e-01f, -2.50184059e-01f, 4.68802564e-02f, -1.29278347e-01f, -6.57807887e-02f, 6.23511598e-02f, 1.48060337e-01f, 1.42795846e-01f,
  -4.42370912e-03f, -9.12187174e-02f, 1.76416859e-01f, 1.46096751e-01f, -6.94374740e-02f, -1.67792827e-01f, 2.09262952e-01f, -1.45979270e-01f, 1.05810031e-01f, 2.11994156e-01f,
  2.35180750e-01f, 1.15848740e-03f, 1.47457108e-01f, 6.47701770e-02f, -9.48327407e-03f, -6.17409907e-02f, 2.28281632e-01f, 8.83496031e-02f, -1.21812196e-02f, 1.32714376e-01f,
  -1.01649307e-01f, 4.27066162e-02f, -1.34359702e-01f, 1.45280082e-03f, -1.69576351e-02f, 6.10459745e-02f, 9.59819779e-02f, -3.32006887e-02f, -1.50421381e-01f, 9.63944476e-03f,
  1.49656326e-01f, 1.86387021e-02f, -6.22959137e-02f, 1.53855570e-02f, 4.26837653e-02f, 1.19875662e-01f, -5.33786602e-02f, -1.22995197e-03f, 1.16032168e-01f, -9.31968391e-02f,
  1.92295462e-02f, -1.79235321e-02f, 9.71875489e-02f, 2.97918487e-02f, -1.60961315e-01f, 1.10072598e-01f, 1.08069830e-01f, -1.26498371e-01f, -3.23160775e-02f, -1.49736984e-03f,
  1.48965091e-01f, -1.71411529e-01f, -2.54958998e-02f, 7.62309358e-02f, 1.87867358e-01f, 1.04470700e-01f, 2.71536142e-01f, -4.19050381e-02f, 1.53443158e-01f, 3.08613479e-02f,
  -9.69521478e-02f, -6.45962581e-02f, 5.16625866e-02f, 3.92121039e-02f, -1.95037633e-01f, -1.63452595e-01f, -5.62212840e-02f, 8.57922882e-02f, -6.73585683e-02f, 1.73345566e-01f,
  -2.90756319e-02f, -1.32408753e-01f, -1.44169956e-01f, 5.65439425e-02f, 6.48239926e-02f, -1.39878109e-01f, 3.80081832e-02f, 1.70237184e-01f, -2.86600292e-01f, -2.23514944e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  6.06799304e-01f, 1.68600738e-01f, 1.13417351e+00f, 3.88284177e-01f, 3.38695288e-01f, 7.23169684e-01f, 3.74475658e-01f, 4.58285719e-01f, 2.73248386e-02f, 5.36638618e-01f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -1.28172100e-01f, 2.00670913e-01f, 2.03853086e-01f, -5.56652900e-03f, 4.20554355e-02f, 8.79291371e-02f, 4.07494530e-02f, 7.43813738e-02f, -1.66880772e-01f, -5.39020121e-01f,
  -2.71443486e-01f, -1.51005447e-01f, 1.48133889e-01f, 1.44041739e-02f, 1.62292942e-01f, 1.13661692e-01f, 4.09160107e-02f, 8.89547393e-02f, 1.06810285e-02f, -2.44991958e-01f,
  1.81204677e-01f, 4.41096932e-01f, 3.14051300e-01f, 1.89419597e-01f, -9.03625935e-02f, -3.77560407e-01f, -2.04888567e-01f, 2.15262458e-01f, -3.02097768e-01f, -3.69699627e-01f,
  3.27826947e-01f, 1.31210551e-01f, -6.72633722e-02f, -4.14035805e-02f, 1.19932547e-01f, 6.98714107e-02f, -5.97324185e-02f, -3.90308797e-01f, 1.10139418e-03f, -3.03221315e-01f,
  2.18174364e-02f, -2.86584854e-01f, -1.17089316e-01f, -2.91218042e-01f, -1.31633624e-01f, -1.26359656e-01f, 2.43942097e-01f, -2.86627524e-02f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -6.87208325e-02f, 3.76794487e-02f, 1.04274583e+00f, -4.22878116e-01f, 1.81955516e-01f, 4.28704947e-01f, 3.57263803e-01f, -3.86185437e-01f, -5.89210205e-02f, -9.17947412e-01f,
  6.08729959e-01f, 9.54855502e-01f, 7.83789083e-02f, -1.32616222e-01f, -3.03943343e-02f, 4.43907738e-01f, -1.85060017e-02f, 1.84548981e-02f, -4.03515905e-01f, -4.80262935e-01f,
  2.32851282e-01f, 1.04836988e+00f, -7.82863319e-01f, -1.25166997e-01f, 5.69545865e-01f, 1.53463751e-01f, -3.60530555e-01f, 2.21276179e-01f, -8.64839479e-02f, 5.89392066e-01f,
  -1.89545184e-01f, -1.44876748e-01f, 2.53016293e-01f, 2.36105144e-01f, -7.99419731e-03f, -1.53481930e-01f, 2.91697025e-01f, 7.49287903e-01f, -1.54778868e-01f, 3.78809273e-01f,
  6.32989168e-01f, 6.31352961e-01f, 6.05847180e-01f, 7.39714801e-02f, 2.91916817e-01f, 4.40109491e-01f, 8.00583959e-01f, 1.56541616e-01f, 3.16393465e-01f, 1.51085824e-01f,
  6.48597121e-01f, -1.74364179e-01f, 2.55200952e-01f, 5.28821200e-02f, 6.49602056e-01f, -6.43060505e-02f, 1.38936594e-01f, -1.29643783e-01f, 1.17269762e-01f, 7.59585083e-01f,
  -1.62471578e-01f, -1.95136726e-01f, 8.41417253e-01f, 2.22895041e-01f, -1.26275703e-01f, 3.50420997e-02f, 6.17310524e-01f, -2.26412028e-01f, 4.34650064e-01f, 8.77826035e-01f,
  3.36963803e-01f, -5.56438088e-01f, 5.21690011e-01f, -6.15440428e-01f, 1.48244649e-01f, 1.71186671e-01f, -3.07689726e-01f, 6.48048043e-01f, -7.89386868e-01f, 7.27928519e-01f,
  3.83411139e-01f, 1.64382413e-01f, 8.67506564e-01f, 4.86833632e-01f, -7.61494935e-01f, -1.18081152e+00f, 7.22020924e-01f, -2.17658803e-01f, -3.59470993e-02f, 8.76635671e-01f,
  -4.49951202e-01f, 2.74547845e-01f, -8.44345391e-02f, 3.15164365e-02f, -2.59236127e-01f, -2.43118629e-01f, 1.25396043e-01f, -1.94989026e-01f, 2.98042923e-01f, 5.63539386e-01f,
  -1.40809789e-01f, -7.95601845e-01f, -2.13022083e-01f, -6.23621106e-01f, 3.37491423e-01f, 5.83003908e-02f, 4.05334532e-01f, -4.89094593e-02f, 3.44306380e-01f, 3.87451053e-01f,
  -5.40654838e-01f, 4.23131645e-01f, 2.23389864e-01f, 6.06920719e-02f, 3.72328728e-01f, 2.67029345e-01f, -4.80400138e-02f, -2.65563458e-01f, 1.43029302e-01f, 2.77590245e-01f,
  1.51213408e-01f, 8.54408741e-01f, 5.61680675e-01f, -1.56824470e-01f, -6.35592222e-01f, 6.39329612e-01f, -5.62473595e-01f, 5.74719548e-01f, -2.96304107e-01f, 1.77655429e-01f,
  4.64146942e-01f, -1.52957082e-01f, -1.33910671e-01f, 6.95102736e-02f, 4.21191335e-01f, -2.79602259e-01f, 3.69329512e-01f, -7.63052940e-01f, -4.85320330e-01f, 2.60764390e-01f,
  4.69493330e-01f, 1.30923599e-01f, -6.43483102e-01f, -4.67249870e-01f, -2.89717857e-02f, -1.30381614e-01f, 1.45255506e-01f, 2.11616337e-01f, -1.09571517e-01f, -1.38708502e-01f,
  4.36414361e-01f, -2.00851895e-02f, 4.78691697e-01f, -9.04538572e-01f, -2.08077580e-01f, -6.92863107e-01f, 6.85505211e-01f, 8.71506512e-01f, -4.29008573e-01f, 5.65639377e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  1.94956705e-01f, 3.25681329e-01f, 7.20428675e-03f, 4.45645213e-01f, 5.92778385e-01f, 3.26968580e-01f, 9.62928757e-02f, 1.17822178e-01f, 5.55323720e-01f, 2.12682381e-01f
};

// L2_fan_Wp (Shape: 3 x 16)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -2.28979781e-01f, -3.51550579e-01f, -4.34456095e-02f, 3.40761304e-01f, 3.78792316e-01f, 5.72872400e-01f, -4.42964226e-01f, 5.30806422e-01f, 1.51819021e-01f, -7.72059262e-02f,
  -1.14763111e-01f, 3.86956811e-01f, -1.75622284e-01f, -2.07944363e-01f, 1.91455171e-01f, -5.59915155e-02f, 7.55595863e-02f, -1.11899249e-01f, -1.06058434e-01f, -7.90949389e-02f,
  1.40616015e-01f, 5.04156172e-01f, -5.16744077e-01f, 7.44973719e-02f, -3.85642424e-02f, -3.35026443e-01f, -2.57129937e-01f, 2.91745842e-01f, 2.75156736e-01f, 1.46100610e-01f,
  1.74838901e-02f, 1.77982315e-01f, -2.37248257e-01f, -1.43784761e-01f, 4.38192308e-01f, -5.68652928e-01f, 7.09760934e-02f, 3.11767578e-01f, 7.24110231e-02f, 9.49903578e-02f,
  2.87715614e-01f, 2.31499210e-01f, -2.69515187e-01f, 1.79232270e-01f, 3.58647928e-02f, -1.53882593e-01f, -4.79866564e-01f, -2.19840124e-01f
};

// L2_fan_Wp_bar (Shape: 10 x 16)
const int L2_fan_Wp_bar_rows = 10;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  -1.93780527e-01f, 8.31246316e-01f, -1.58949769e+00f, -5.82063377e-01f, 6.99909031e-02f, -1.03442788e+00f, 7.58991778e-01f, 4.66623336e-01f, 6.68468416e-01f, 1.40107527e-01f,
  1.42497241e-01f, -4.55476850e-01f, -4.00632434e-02f, 2.67555237e-01f, -6.65747166e-01f, -3.71418685e-01f, -8.73177201e-02f, 1.10884500e+00f, -2.53037065e-01f, -5.49929023e-01f,
  3.35115157e-02f, -5.40521562e-01f, 1.12690735e+00f, 4.15788829e-01f, 2.76230276e-01f, 3.16458270e-02f, 5.19495606e-01f, -8.39963198e-01f, -4.56677191e-02f, -4.13632095e-01f,
  1.64940372e-01f, -3.41217697e-01f, -4.17481393e-01f, -9.26680207e-01f, -1.30954787e-01f, 7.82575831e-02f, -4.04630929e-01f, 5.91385067e-01f, -6.22970283e-01f, 3.45803738e-01f,
  5.17282225e-02f, -2.81752378e-01f, 2.29036048e-01f, -2.40120590e-01f, 8.01150501e-01f, 3.56435657e-01f, -4.24777567e-02f, 5.54729402e-01f, 3.89166892e-01f, 5.51024914e-01f,
  2.80202746e-01f, 7.93059170e-01f, 4.30297136e-01f, 2.50782013e-01f, 2.16626599e-01f, 3.63568962e-02f, 2.74852514e-01f, 7.36801624e-01f, -4.65340585e-01f, 6.16829157e-01f,
  -9.22691107e-01f, -5.70298970e-01f, 3.75980645e-01f, 9.11066413e-01f, 3.67645144e-01f, 8.23997408e-02f, 9.87347305e-01f, -1.34179330e+00f, -7.95939863e-01f, 4.49825406e-01f,
  6.29074991e-01f, -6.35068357e-01f, -6.17831886e-01f, -8.45598895e-03f, 2.72828907e-01f, 1.24467409e+00f, 4.42796916e-01f, 5.63171208e-01f, 6.32300004e-02f, 2.50453241e-02f,
  -1.21185131e-01f, -4.69374776e-01f, -6.54973626e-01f, -6.04660690e-01f, -3.94707412e-01f, -8.49477053e-01f, -4.82818812e-01f, 4.68145519e-01f, 4.57684636e-01f, -6.71817809e-02f,
  7.78004885e-01f, 1.87933519e-01f, 6.40636325e-01f, 1.03585970e+00f, -6.60743594e-01f, 4.58024859e-01f, 5.91724753e-01f, 6.22605503e-01f, 6.90638423e-01f, -3.27891529e-01f,
  8.43160033e-01f, 1.85874313e-01f, 3.86912555e-01f, -1.61610514e-01f, -8.99773836e-01f, 4.89066029e-03f, -4.10714447e-01f, 8.73559952e-01f, -3.46226245e-01f, -3.80206168e-01f,
  8.14295948e-01f, 4.65952575e-01f, 2.32376948e-01f, 1.88102648e-01f, 7.09741950e-01f, 9.79273319e-01f, -1.65215433e-01f, -2.80740499e-01f, 4.83900398e-01f, 6.29554093e-01f,
  -2.40179881e-01f, -1.65190056e-01f, 8.29182267e-01f, 8.48964229e-02f, 2.75743335e-01f, -2.66686678e-01f, 1.56240952e+00f, 1.03595781e+00f, 1.15511410e-01f, 8.11105847e-01f,
  5.35423875e-01f, 6.78682864e-01f, 1.07424009e+00f, 2.32383862e-01f, 1.10399866e+00f, -2.74575174e-01f, 1.25369549e-01f, 8.62906694e-01f, 4.43176419e-01f, -5.01639135e-02f,
  -1.56686798e-01f, -1.64173812e-01f, -5.78873575e-01f, 2.70112464e-03f, 6.36885881e-01f, 6.80970907e-01f, 5.99792838e-01f, -5.92941701e-01f, 4.92103428e-01f, -1.10204425e-02f,
  7.60149837e-01f, -1.02315426e+00f, -1.76901966e-01f, 3.13419759e-01f, -1.80318132e-01f, 8.44507098e-01f, -1.38641790e-01f, 5.04238129e-01f, -5.08284211e-01f, -5.64170241e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 10)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 10;
const float L2_fan_Bp_bar_data[] = {
  -1.39117762e-01f, 1.24108598e-01f, 7.43447691e-02f, 3.81260484e-01f, 2.26500571e-01f, 3.01708102e-01f, 5.00545442e-01f, -1.07264541e-01f, 3.52737546e-01f, 4.71952349e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  2.91221023e-01f, -1.75179377e-01f, -1.93347424e-01f, 3.35537225e-01f, 4.23558593e-01f, -2.75797963e-01f, -5.27818985e-02f, 2.20550522e-01f, 5.31475008e-01f, -8.59547019e-01f,
  -1.19660974e+00f, 2.07392171e-01f, -3.49371105e-01f, -6.41822070e-03f, -9.75429177e-01f, -5.43807805e-01f, 3.88396949e-01f, -6.87961996e-01f, 9.28957835e-02f, -3.88434589e-01f,
  -9.48341310e-01f, 8.37773561e-01f, 6.69720352e-01f, 2.50023812e-01f, -5.47885239e-01f, -1.96082309e-01f, -1.05895591e+00f, 3.91699344e-01f, -2.25225672e-01f, -6.73642397e-01f,
  -1.88382685e-01f, -5.19510150e-01f, 4.56372112e-01f, 2.81896323e-01f, 2.92409062e-02f, -3.78464252e-01f, 5.83624423e-01f, 3.92681986e-01f, 3.70791182e-02f, -6.75587893e-01f,
  -5.36395490e-01f, -6.37488604e-01f, 8.21272731e-01f, 3.62826884e-01f, -8.52647245e-01f, -1.44972885e+00f, -7.01861858e-01f, 5.81404686e-01f, 6.11801088e-01f, -9.60490555e-02f,
  -4.72304597e-02f, -4.91557598e-01f, 4.42075253e-01f, -1.00449753e+00f, -1.28751945e+00f, -8.01966846e-01f, 1.80835128e-01f, -5.37562788e-01f, 2.79541790e-01f, 3.40405941e-01f,
  -7.71513700e-01f, 2.18514994e-01f, -9.38486814e-01f, -1.04526973e+00f, -1.36927760e+00f, 3.24303001e-01f, -8.17596138e-01f, -2.77227402e-01f, -8.97135854e-01f, 2.75668204e-01f,
  -4.37466204e-01f, -2.56388653e-02f, -1.43539533e-01f, -2.11685061e-01f, -6.67107105e-02f, 2.47794479e-01f, -4.55347180e-01f, 5.55377565e-02f, 2.83721507e-01f, -5.50437868e-01f,
  7.97448575e-01f, -3.42454880e-01f, 4.11837995e-01f, 3.89021814e-01f, -6.81144297e-02f, -5.45827329e-01f, -1.55518189e-01f, 5.16880929e-01f, -6.82420254e-01f, 7.68259466e-02f,
  -9.50172365e-01f, -3.90236884e-01f, -8.35122287e-01f, 5.75192511e-01f, 7.20309839e-02f, -6.54987335e-01f, 2.38197386e-01f, 3.23191911e-01f, 6.84384227e-01f, 5.75524449e-01f,
  6.14256918e-01f, 6.44296408e-01f, -6.55571818e-02f, -2.37945050e-01f, 2.49745831e-01f, 9.50412974e-02f, 4.30601597e-01f, -6.19395554e-01f, 8.33041072e-01f, -1.17744446e+00f,
  -1.21854275e-01f, 7.43066847e-01f, -2.33224258e-01f, -3.12437653e-03f, -5.59330881e-01f, 2.93416023e-01f, 2.54739225e-01f, -3.07763517e-01f, 1.80489346e-01f, -4.70203161e-01f,
  -1.17917180e-01f, 4.51752841e-01f, -4.64623302e-01f, -4.72989768e-01f, 8.34645391e-01f, 4.23633933e-01f, -8.10539603e-01f, -7.21684635e-01f, -4.48546082e-01f, -2.34990194e-01f,
  -6.26362443e-01f, -5.42038977e-01f, 6.08264565e-01f, -3.08342911e-02f, 3.20795983e-01f, 3.09164405e-01f, 2.96976138e-02f, 4.33933496e-01f, -4.79751915e-01f, -8.17198038e-01f,
  -8.52548599e-01f, -5.20536065e-01f, -5.98451607e-02f, 7.13856876e-01f, 2.15624347e-01f, 4.03990299e-01f, 3.95202458e-01f, -1.24741405e-01f, 3.73652458e-01f, -1.23405397e+00f,
  -2.35687450e-01f, -9.09852326e-01f, -1.21766126e+00f, -2.33041435e-01f, 4.82884228e-01f, 1.08938858e-01f, 6.34823367e-02f, 1.47898167e-01f, -8.21241438e-02f, 2.89560974e-01f,
  -1.10058558e+00f, 4.11293879e-02f, 6.54427350e-01f, 3.73958319e-01f, -1.17293008e-01f, 6.47709489e-01f, -9.00943764e-03f, 4.45287138e-01f, -7.80195653e-01f, -1.29715157e+00f,
  7.36259580e-01f, -2.67440319e-01f, -1.19400668e+00f, -2.20117927e-01f, 3.43611538e-01f, 3.54440272e-01f, 3.00006807e-01f, 2.40257099e-01f, -5.38125157e-01f, 8.20645750e-01f,
  -1.09984732e+00f, 1.57796428e-01f, -1.07399035e+00f, -1.07008541e+00f, -1.25992012e+00f, 7.26344645e-01f, -6.45249546e-01f, -1.04432654e+00f, -5.55332363e-01f, -9.42485392e-01f,
  6.57266915e-01f, 3.19166601e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.66439027e-01f, -6.20090105e-02f, 3.82317960e-01f, -3.26351039e-02f, -9.56086516e-02f, 3.12358290e-01f, 4.32441801e-01f, -1.90192938e-01f, -3.74832422e-01f, -2.11662352e-01f,
  -3.61755103e-01f, 3.76402110e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    