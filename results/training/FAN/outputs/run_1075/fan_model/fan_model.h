/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.37224633e-01f, 1.04166120e-01f, 3.65863204e-01f, -1.48316085e-01f, -3.22205983e-02f, 2.02548444e-01f, 2.20213234e-01f, 1.60299614e-01f, -9.40158144e-02f, 7.72308558e-03f,
  -2.76055117e-03f, 6.05440233e-04f, 1.06424496e-01f, 1.65970922e-02f, 1.51987448e-01f, 1.19128563e-01f, -1.46837994e-01f, 1.31309927e-01f, 1.93986684e-01f, -3.47233415e-02f,
  -1.09798111e-01f, -1.17565043e-01f, 8.69438797e-02f, -1.03365043e-02f, -1.52093604e-01f, -1.11136861e-01f, -5.06776199e-03f, -1.03285879e-01f, -2.21561547e-02f, -2.92721629e-01f,
  1.70467913e-01f, 2.21643537e-01f, 7.21050799e-02f, -5.62207364e-02f, 2.78133564e-02f, 4.66782562e-02f, 4.27750647e-02f, 2.42742915e-02f, -5.41083552e-02f, 2.61111427e-02f,
  4.86443378e-02f, -6.24640658e-02f, -9.73986462e-02f, 3.03960312e-02f, 4.63692918e-02f, 8.18117633e-02f, 1.04919240e-01f, 6.47231936e-02f, 1.42762244e-01f, -4.25468907e-02f,
  -1.32098487e-02f, -9.94110927e-02f, 1.97661653e-01f, 1.32128522e-01f, 3.95420976e-02f, 1.02715716e-01f, -3.59933563e-02f, 2.11564489e-02f, 1.34825334e-01f, -3.47393751e-02f,
  -4.64125834e-02f, 6.00457974e-02f, 1.53875006e-02f, -3.98226231e-02f, -1.86507441e-02f, -1.30791282e-02f, 2.51373630e-02f, -8.74805376e-02f, 6.09505642e-03f, -4.53252383e-02f,
  6.71472400e-02f, 4.33735549e-02f, 2.44209915e-02f, 5.10165244e-02f, 1.05094649e-02f, 6.80846572e-02f, -3.11014950e-02f, 1.89171024e-02f, -4.04741354e-02f, -1.33311395e-02f,
  3.16253752e-02f, 7.43585899e-02f, -8.69803876e-02f, -6.25575334e-03f, 4.24863473e-02f, -1.35902539e-02f, 5.27321324e-02f, 3.09295189e-02f, 6.86705559e-02f, 7.86924921e-03f,
  2.53222398e-02f, 8.08112472e-02f, 1.26294224e-02f, 3.66583988e-02f, 2.28706133e-02f, -3.53640839e-02f, 3.68298334e-03f, 5.62155209e-02f, 9.98944715e-02f, 7.98260793e-02f,
  -1.17211789e-02f, -7.26809166e-03f, 4.78868969e-02f, -8.87280926e-02f, 8.84846132e-03f, 5.06987236e-02f, 5.23223775e-03f, 4.96014766e-02f, 8.00247118e-02f, 4.80470955e-02f,
  1.67400744e-02f, 8.36278871e-02f, 6.93540797e-02f, 1.74682602e-01f, 4.98167239e-02f, 1.75025418e-01f, 6.97307801e-03f, 9.72641185e-02f, 2.41847336e-01f, 4.23414260e-02f,
  -1.12991892e-01f, -2.89733082e-01f, -1.00866906e-01f, 6.54850528e-02f, 3.23762149e-02f, -1.21396393e-01f, -2.99463272e-01f, -7.72855133e-02f, 9.56676602e-02f, -1.07746631e-01f,
  -5.10733537e-02f, 1.86233863e-01f, 3.18548866e-02f, 1.52297691e-01f, -6.34341165e-02f, 2.91039012e-02f, 1.83506787e-01f, 1.59860834e-01f, 2.27669835e-01f, 1.90638110e-01f,
  1.79062933e-01f, 1.04235604e-01f, 4.27529737e-02f, 7.18899369e-02f, 1.59425467e-01f, 1.19473062e-01f, -9.74960700e-02f, 1.08556964e-01f, 7.51341283e-02f, 3.08686793e-01f,
  4.49961275e-02f, -1.28352642e-01f, 1.52779639e-01f, 9.76867154e-02f, 7.22603649e-02f, 8.35908279e-02f, 3.40875648e-02f, 1.35018304e-01f, 7.58863911e-02f, -1.87418703e-02f,
  4.45347354e-02f, 1.41614407e-01f, 1.53425500e-01f, 9.39972773e-02f, 7.42386654e-02f, 2.37771329e-02f, 8.96361694e-02f, 1.44033998e-01f, 7.03192726e-02f, 1.12244174e-01f,
  6.88422471e-02f, 1.27112627e-01f, -1.05472319e-01f, 8.09792895e-04f, -4.74004559e-02f, 7.04868734e-02f, -7.18160868e-02f, 1.80438049e-02f, 2.27703694e-02f, 1.08935073e-01f,
  2.94550676e-02f, -1.07992992e-01f, -1.10867089e-02f, -9.27559137e-02f, -3.52680348e-02f, -7.38073140e-02f, 1.95605960e-02f, -1.21171735e-01f, 2.63796784e-02f, -2.71304362e-02f,
  2.69729272e-03f, -5.37570417e-02f, -1.30071282e-01f, -1.97126139e-02f, -1.39840040e-02f, -9.76292193e-02f, -4.99272011e-02f, -7.89444596e-02f, -8.09556395e-02f, -1.07144028e-01f,
  -7.40710739e-03f, -1.33442376e-02f, -1.05018847e-01f, 4.91526015e-02f, -3.42832459e-03f, -1.19009102e-02f, -5.46391234e-02f, -4.77694385e-02f, -4.95874099e-02f, -1.40831381e-01f,
  -1.31874263e-01f, -5.74165657e-02f, -6.68650318e-04f, 5.23910746e-02f, 2.08516587e-02f, 4.59742695e-02f, 5.71125075e-02f, 9.46925208e-02f, -5.13386801e-02f, 2.54779644e-02f,
  -7.75042325e-02f, -3.24541926e-02f, -4.56511416e-02f, 1.59021780e-01f, 1.39133707e-01f, -1.68955233e-02f, 5.61148934e-02f, 1.45836368e-01f, 4.81121615e-02f, -2.01170426e-03f,
  4.50281687e-02f, 6.05700258e-03f, -1.01985522e-01f, -5.26301153e-02f, -2.40759291e-02f, 9.77183357e-02f, -2.66576968e-02f, 2.39383802e-03f, -2.00395342e-02f, -8.44046399e-02f,
  2.08400622e-01f, 1.21290900e-01f, 1.49130568e-01f, 1.34413466e-01f, 1.38453975e-01f, 1.18978411e-01f, 2.14216024e-01f, -6.38097199e-03f, -1.59756064e-01f, 2.73866449e-02f,
  -1.25845581e-01f, -3.45478475e-01f, -2.46220097e-01f, -3.14688772e-01f, -1.14436455e-01f, 1.42823920e-01f, 4.49872054e-02f, -2.97019035e-02f, -2.05971479e-01f, -1.32146236e-02f,
  -1.42113402e-01f, 6.53803572e-02f, -1.36791900e-01f, -6.25211895e-02f, 3.86947840e-02f, -2.91233003e-01f, -2.84852944e-02f, 5.25059439e-02f, -4.94773081e-03f, -3.73514891e-02f,
  -1.85461909e-01f, 1.47830948e-01f, -1.44999892e-01f, -1.78572074e-01f, -2.42277477e-02f, -1.19486950e-01f, 7.46471714e-03f, -1.15218200e-01f, -6.43240586e-02f, 1.08788535e-02f,
  1.19916275e-02f, -9.92502123e-02f, -1.03937447e-01f, -2.73336880e-02f, 5.97261079e-02f, -8.32216442e-02f, -2.80474480e-02f, -5.11182286e-02f, -5.80406711e-02f, -9.43115801e-02f,
  -2.56232489e-02f, 1.46004707e-01f, 1.47187456e-01f, -1.55935034e-01f, -3.88189591e-02f, -1.05528623e-01f, -8.69394764e-02f, -5.02916500e-02f, -2.23787278e-02f, -5.57921417e-02f,
  8.41397140e-03f, -2.53974600e-03f, 4.23729569e-02f, -1.73174962e-02f, -8.35104845e-03f, -4.00436781e-02f, 8.16568360e-03f, 1.25574637e-02f, 4.39005606e-02f, 2.63072201e-03f,
  -5.72108664e-02f, 2.86180805e-03f, 3.29145826e-02f, 2.30189003e-02f, 7.75092188e-03f, 5.72056547e-02f, 1.19645819e-02f, 8.06173310e-03f, 1.05080239e-01f, -2.00699400e-02f,
  -1.91797893e-02f, 7.33356038e-03f, 2.40343884e-02f, 1.42969536e-02f, 5.49717881e-02f, 7.71543756e-02f, 5.29118516e-02f, 2.96725798e-02f, -1.40783153e-02f, 1.25785887e-01f,
  -2.14374587e-01f, -2.18831617e-02f, -1.31163806e-01f, -1.41132236e-01f, -6.60957545e-02f, -7.13675991e-02f, -9.34756845e-02f, -9.10134465e-02f, -5.07021658e-02f, -8.74870867e-02f,
  -9.88808647e-02f, -4.18129712e-02f, -2.87458133e-02f, -2.44184341e-02f, -6.71902001e-02f, -4.74284068e-02f, -1.04325555e-01f, -7.96697140e-02f, -1.56131744e-01f, -3.78560945e-02f,
  -1.65065415e-02f, 7.75519535e-02f, -5.69438748e-02f, -7.53791854e-02f, -8.50394815e-02f, -1.61062568e-01f, -1.34943828e-01f, -1.52945131e-01f, -1.53728470e-01f, -1.51005939e-01f,
  -4.59234446e-01f, 1.59463778e-01f, -3.56703728e-01f, -6.30450845e-02f, 2.08747596e-01f, 1.16101347e-01f, 2.17186242e-01f, 1.88476041e-01f, 5.06038032e-02f, 9.53390971e-02f,
  2.03205943e-02f, 1.90254860e-02f, -9.10398439e-02f, -9.54463333e-02f, 7.73070194e-03f, 8.76437500e-02f, -2.13428903e-02f, -2.44131431e-01f, -2.13475019e-01f, 1.89770669e-01f,
  1.81350335e-01f, 1.25924990e-01f, -1.22312807e-01f, 1.20820336e-01f, 1.86268389e-01f, -4.42141145e-02f, 3.37800644e-02f, 1.56592838e-02f, 1.09562300e-01f, -1.52954832e-01f,
  -4.13704395e-01f, -1.26766339e-01f, -4.02684361e-02f, -2.65646446e-02f, -3.43376510e-02f, 2.17476580e-02f, -5.19548096e-02f, -3.15635502e-02f, 5.07705770e-02f, 7.11784512e-03f,
  -2.23772619e-02f, 6.62593637e-03f, -1.83552895e-02f, -4.17978503e-03f, -8.27369392e-02f, 5.17509915e-02f, 9.32134222e-03f, -3.25646549e-02f, -1.13128625e-01f, 7.21648857e-02f,
  9.96565968e-02f, 1.49483820e-02f, -1.11910172e-01f, 6.80340007e-02f, -1.73216425e-02f, -2.60934681e-02f, -4.50732447e-02f, 7.83366561e-02f, 5.41689508e-02f, -3.11746988e-02f,
  8.98385346e-02f, -1.07171061e-02f, 2.85539459e-02f, 3.07499189e-02f, 5.95201626e-02f, 6.27222359e-02f, -1.98458117e-02f, 8.28178823e-02f, 2.21002046e-02f, 4.20179255e-02f,
  4.99640442e-02f, -6.04347587e-02f, 4.50774319e-02f, 4.98365564e-03f, 4.89629433e-03f, 3.52618843e-02f, -3.09918728e-03f, 4.10635732e-02f, -3.68034691e-02f, 2.09487043e-04f,
  5.46716303e-02f, 5.23274718e-03f, -1.78054813e-02f, -3.56262326e-02f, 1.02554500e-01f, 2.05629673e-02f, 8.80184844e-02f, 5.12942225e-02f, 5.87662272e-02f, -7.70128332e-03f,
  8.58557597e-02f, -3.84279862e-02f, -1.29296362e-01f, 5.66230752e-02f, -3.87813784e-02f, 1.35164419e-02f, -2.29967926e-02f, -2.66173971e-03f, -3.58369909e-02f, -5.06229624e-02f,
  -1.51331052e-02f, -1.33244209e-02f, -4.90699038e-02f, 1.84184108e-02f, 3.40357237e-02f, 6.01068921e-02f, 1.01103954e-01f, -1.85250044e-02f, 6.52947351e-02f, 9.88963619e-03f,
  1.72866553e-01f, -2.51752604e-02f, 2.46449020e-02f, 4.77688201e-02f, 9.90033820e-02f, -8.34182724e-02f, -7.68993199e-02f, -2.22429130e-02f, -1.18104801e-01f, 1.77426055e-01f,
  3.37571025e-01f, -2.34094232e-01f, -7.92612284e-02f, 2.77585715e-01f, 4.18024398e-02f, -1.36243224e-01f, -1.53176516e-01f, 4.74218987e-02f, 1.85279995e-01f, -6.36572540e-02f,
  -1.49795324e-01f, 2.22775638e-02f, -1.50238983e-02f, 2.55011283e-02f, 1.22773893e-01f, -9.74043086e-02f, 1.65527105e-01f, 2.63157874e-01f, 2.00277388e-01f, 9.96269882e-02f,
  2.32793897e-01f, 2.76973277e-01f, 3.09881657e-01f, 2.27979392e-01f, 1.42894223e-01f, 2.27755949e-01f, -4.31132615e-02f, 1.92349218e-02f, -6.89028529e-03f, 2.37897366e-01f,
  -1.29190013e-01f, -1.43713921e-01f, 1.71442360e-01f, 1.33024335e-01f, 2.84647662e-02f, 9.43166241e-02f, -1.48112634e-02f, 7.70916492e-02f, 1.40712589e-01f, 5.02679124e-02f,
  9.77107435e-02f, 2.23368406e-03f, 3.81585211e-02f, 1.61733374e-01f, 1.27530411e-01f, 3.02047972e-02f, 8.37678313e-02f, 1.88678727e-01f, 1.43999234e-01f, -6.56346530e-02f,
  -1.55988019e-02f, -7.50354305e-02f, -6.40016198e-02f, -2.29635611e-02f, 1.06503822e-01f, 1.14055999e-01f, -3.10099814e-02f, 1.27097797e-02f, 6.97433725e-02f, 1.60496727e-01f,
  1.90782342e-02f, -3.12409643e-02f, -4.71292250e-02f, 9.25084502e-02f, 2.43113819e-03f, 3.65748033e-02f, 4.77363029e-03f, 2.18493715e-02f, 3.26353721e-02f, 9.94965155e-03f,
  -6.43827766e-02f, 4.87213209e-03f, 1.11966291e-02f, 7.93296436e-04f, 6.97618276e-02f, 2.34656651e-02f, -6.68441085e-03f, -2.17914376e-02f, 5.90939447e-02f, -5.11514209e-02f,
  -2.85235401e-02f, -6.60208985e-02f, -1.21267019e-02f, -4.10917066e-02f, 3.97300720e-02f, -2.03648694e-02f, 7.89223686e-02f, 3.71467099e-02f, 1.20330723e-02f, 8.23306143e-02f,
  1.48347184e-01f, -4.61999467e-03f, 1.53966159e-01f, 6.60838038e-02f, -1.85079519e-02f, 6.00871304e-03f, -2.77749747e-02f, 4.93841767e-02f, 2.69469321e-02f, 9.00623426e-02f,
  9.16871950e-02f, 1.24386147e-01f, 7.28977029e-04f, 5.44448197e-02f, 1.15801848e-01f, 1.31551921e-01f, 4.20291871e-02f, -6.93257898e-03f, 1.00007780e-01f, 8.81055892e-02f,
  3.34865064e-04f, 6.73431680e-02f, 3.38734016e-02f, 6.14653453e-02f, 1.54775381e-01f, 1.41352311e-01f, 1.13993123e-01f, 1.26680240e-01f, 4.52875905e-02f, 1.66233122e-01f,
  3.47212076e-01f, -2.97900498e-01f, 2.05234699e-02f, 8.54308680e-02f, -1.65730879e-01f, -2.08833575e-01f, -3.21868509e-01f, -2.27316558e-01f, -1.44314859e-02f, -1.66829392e-01f,
  3.92724983e-02f, 3.59889686e-01f, 3.12271953e-01f, 1.86739773e-01f, 8.16519111e-02f, -2.85097450e-01f, -2.15842947e-01f, 2.49123067e-01f, 1.91583872e-01f, 6.36822060e-02f,
  -1.26934767e-01f, -3.63576971e-02f, 2.40452513e-01f, 1.27458081e-01f, -1.53686628e-02f, 1.34962246e-01f, -6.24960810e-02f, -7.63272196e-02f, -1.25587448e-01f, 6.48368057e-03f,
  2.26599023e-01f, -1.74583703e-01f, 1.13117173e-01f, 3.77034694e-02f, 1.23198824e-02f, 5.31729236e-02f, 2.70148795e-02f, -3.30686718e-02f, 4.13521901e-02f, -2.70404126e-02f,
  2.42087673e-02f, 3.76586355e-02f, 3.83955315e-02f, -7.46587738e-02f, -3.79589424e-02f, -4.44672368e-02f, 3.65008526e-02f, -6.50794134e-02f, 7.78902695e-02f, -1.33823175e-02f,
  4.25998010e-02f, -1.38227716e-01f, -4.91724536e-02f, -7.83676729e-02f, 3.86006460e-02f, 7.67779276e-02f, -7.20210373e-02f, -8.48930553e-02f, -2.72178799e-02f, -9.62690935e-02f,
  8.55261832e-02f, 7.16720289e-03f, -4.69244011e-02f, 9.50425211e-03f, -1.51740061e-02f, -1.39332982e-02f, 1.73576754e-02f, -5.95240407e-02f, 2.42852718e-02f, 9.39198863e-03f,
  -8.37925728e-03f, 3.64880823e-02f, -2.14109402e-02f, -1.82962101e-02f, -1.96049400e-02f, -4.02734280e-02f, -3.28976102e-02f, 1.76495016e-02f, -3.31745483e-02f, -1.04799695e-01f,
  7.59527385e-02f, 4.70243208e-02f, -1.80228725e-02f, 8.94622970e-03f, -1.35629717e-02f, 2.45937593e-02f, -6.66529639e-03f, 4.12327275e-02f, -6.23730849e-03f, 1.59395766e-02f,
  -1.13358228e-02f, -1.86376665e-02f, 3.88020463e-02f, -1.05224596e-02f, 1.33047029e-02f, -9.00773518e-03f, 4.36401181e-02f, 3.95541452e-03f, -4.17471081e-02f, -1.93778845e-03f,
  -4.96874936e-02f, 3.27428579e-02f, 2.48968545e-02f, 3.38376686e-02f, 2.70810574e-02f, 4.76667285e-02f, -1.21247090e-01f, 8.41468126e-02f, -2.26324089e-02f, -7.99866859e-03f,
  -4.51860540e-02f, -1.98341478e-02f, 3.85894887e-02f, 3.10406573e-02f, -2.74397396e-02f, 2.06622370e-02f, 8.60081092e-02f, 8.64282846e-02f, 2.04926394e-02f, 8.17624107e-02f,
  -1.82650402e-01f, -4.82534692e-02f, 1.65778920e-01f, -2.76683066e-02f, 2.01361537e-01f, 2.61499941e-01f, 1.80309191e-01f, 1.03248112e-01f, -6.46529645e-02f, 1.21421859e-01f,
  1.03198767e-01f, 9.47642252e-02f, 1.20678060e-01f, 1.20660484e-01f, 5.59157021e-02f, 2.10799411e-01f, 2.54835188e-01f, 5.47666587e-02f, 9.05248672e-02f, 6.87562227e-02f,
  1.15307935e-01f, -7.82164708e-02f, -1.66114699e-02f, 1.23715419e-02f, 6.05771281e-02f, -3.43270972e-03f, -6.58278018e-02f, 1.09918021e-01f, 1.52330324e-01f, 1.13517828e-01f,
  1.83211550e-01f, 7.93373585e-02f, 2.51858924e-02f, 1.19575590e-01f, -5.67387827e-02f, 1.68685094e-02f, 6.55964091e-02f, 2.43346691e-02f, 5.90547314e-03f, 3.36654931e-02f,
  -3.57209444e-02f, 1.17679439e-01f, 9.16238800e-02f, 1.05625510e-01f, -8.47255532e-03f, -2.13462859e-02f, 7.90373608e-02f, 2.86331531e-02f, 2.25564428e-02f, 6.55033812e-02f,
  2.17995699e-02f, -4.42458643e-03f, 8.54925588e-02f, 9.85945016e-02f, 1.47994980e-01f, 5.69913648e-02f, -1.98290590e-02f, 7.42256343e-02f, -3.60516086e-02f, 4.53697927e-02f,
  1.15212034e-02f, -1.02550695e-02f, 2.77317241e-02f, 5.90411127e-02f, 3.43051478e-02f, 9.61334929e-02f, 1.16481371e-01f, 1.11649912e-02f, 1.17366455e-01f, 3.90081741e-02f,
  6.31363019e-02f, 7.73948804e-02f, 3.94572206e-02f, 8.00960436e-02f, 5.15592806e-02f, 6.37262613e-02f, 3.70253250e-02f, 1.30680636e-01f, -4.27914858e-02f, -5.49335778e-02f,
  1.73030850e-02f, 1.48503572e-01f, 4.39305045e-02f, -4.26503783e-03f, 1.50117904e-01f, 1.13229439e-01f, 5.10691777e-02f, -4.20755660e-03f, 5.21514751e-02f, 2.53593214e-02f,
  -2.21395135e-01f, -7.77866244e-02f, 6.07213117e-02f, 2.12901752e-04f, 6.83463141e-02f, -3.94972563e-02f, -2.86499280e-02f, -7.57464617e-02f, 1.24713546e-02f, 1.20269760e-01f,
  3.78626063e-02f, 1.01304591e-01f, -1.26930745e-02f, -1.68953147e-02f, 1.05966128e-01f, 4.30800505e-02f, 2.33282559e-02f, 7.32094347e-02f, 7.06751421e-02f, 2.00350657e-02f,
  5.07905968e-02f, 8.94927904e-02f, 6.69013243e-03f, 1.87263489e-02f, 1.88837796e-02f, 1.29573971e-01f, 8.21972638e-02f, 3.61910537e-02f, 8.19995254e-02f, -8.17264989e-02f,
  -1.99624017e-01f, 7.00152218e-02f, 1.85030282e-01f, -5.46031259e-02f, -9.85947717e-03f, -9.08341780e-02f, -3.54675837e-02f, -5.88324219e-02f, -2.85258498e-02f, 8.05895403e-02f,
  1.80617601e-01f, 1.99180469e-01f, 2.06432045e-01f, 3.22621912e-01f, 1.80355847e-01f, -1.72955282e-02f, -5.12853935e-02f, 1.59890633e-02f, 1.29407570e-01f, -6.51251897e-03f,
  -2.86323819e-02f, -9.43526179e-02f, -6.49654269e-02f, 1.33305505e-01f, 1.09022580e-01f, 1.48098975e-01f, 1.12111658e-01f, 1.09129198e-01f, 1.00226328e-01f, 3.28563969e-03f,
  2.05740049e-01f, 8.46829787e-02f, 2.49903128e-01f, 2.16339812e-01f, 1.55357420e-01f, 9.83097404e-02f, 1.28897697e-01f, 1.24471255e-01f, 1.58415899e-01f, 1.36044949e-01f,
  2.47852191e-01f, 1.46089435e-01f, 1.06543407e-01f, 1.33864835e-01f, 6.39098063e-02f, 1.02444343e-01f, 1.76460400e-01f, 9.57110897e-02f, 2.82180965e-01f, 1.86224565e-01f,
  2.46832788e-01f, 1.09269038e-01f, 3.69158685e-02f, 2.33955979e-01f, 2.31647015e-01f, 1.59877405e-01f, 2.38627955e-01f, 2.05455959e-01f, 7.11891875e-02f, 1.30297709e-02f,
  -4.47433144e-02f, -4.50702570e-02f, -1.32144362e-01f, -1.78540677e-01f, -9.66092870e-02f, -6.35833293e-02f, -2.13569086e-02f, -7.79313222e-02f, -9.35552344e-02f, -6.00227527e-02f,
  -4.90413979e-02f, -1.17347315e-01f, 4.13725227e-02f, -1.30034432e-01f, -3.62677872e-02f, -1.35013402e-01f, -5.18466756e-02f, -7.93646425e-02f, -5.65928258e-02f, -1.80049345e-01f,
  -6.15619831e-02f, -9.00055468e-02f, -1.16042629e-01f, -9.63610485e-02f, -1.54851586e-01f, -8.65432173e-02f, -1.60364389e-01f, -1.11861467e-01f, -1.54615372e-01f, -9.23246145e-02f,
  1.34822771e-01f, 3.07020038e-01f, 1.55291453e-01f, 1.50418863e-01f, 2.05515534e-01f, 1.77273914e-01f, 1.38388053e-01f, 2.07281753e-01f, 1.12343252e-01f, 1.92747965e-01f,
  1.79889187e-01f, 1.65970519e-01f, 1.39008954e-01f, 1.78505108e-01f, 1.37942895e-01f, 2.01514512e-01f, 1.28664941e-01f, 1.27647728e-01f, 1.23984963e-01f, 1.69111729e-01f,
  9.71888229e-02f, 2.72740535e-02f, 1.05235681e-01f, 7.94711411e-02f, 8.20063576e-02f, 5.46239205e-02f, 9.80106294e-02f, 2.12400764e-01f, 5.54680414e-02f, -6.46959916e-02f,
  3.83403420e-01f, 2.08356902e-01f, 1.60843939e-01f, 2.95238227e-01f, 8.50571617e-02f, 2.08768472e-01f, 3.26668024e-01f, 1.01038955e-01f, 1.36603892e-01f, 2.24168926e-01f,
  -5.07567264e-02f, 3.30609679e-02f, 5.48643023e-02f, 1.54807553e-01f, 2.49292940e-01f, 3.58093470e-01f, 3.52652341e-01f, 1.93684638e-01f, 1.56653658e-01f, 5.31778783e-02f,
  1.62149534e-01f, 1.93327531e-01f, 1.66238189e-01f, 1.06661171e-01f, 1.13939427e-01f, 7.96407312e-02f, 5.76925091e-02f, 1.74679473e-01f, 4.17469797e-04f, 1.71040237e-01f,
  2.93773055e-01f, 1.23667248e-01f, 6.17314596e-03f, 4.48325127e-02f, 1.40849933e-01f, 8.54373798e-02f, 7.19052777e-02f, 8.17408264e-02f, 4.00723852e-02f, 7.20857009e-02f,
  2.37565357e-02f, 7.95028135e-02f, 1.07765079e-01f, 6.95860386e-02f, 1.01947933e-01f, 1.06134184e-01f, 3.67656387e-02f, 6.74692616e-02f, 4.58026417e-02f, 1.42782912e-01f,
  2.54208315e-03f, 6.37804940e-02f, 1.42228365e-01f, 7.32249692e-02f, 1.94693729e-02f, 6.76077530e-02f, 9.07650441e-02f, 7.98786283e-02f, 7.07414448e-02f, 2.03408852e-01f,
  5.26026040e-02f, -2.09794506e-01f, -1.53978541e-01f, -2.35847816e-01f, -1.82562590e-01f, -1.97935522e-01f, -1.98273197e-01f, -2.06369266e-01f, -1.97830975e-01f, -9.49257463e-02f,
  -1.88707784e-01f, -1.84807062e-01f, -1.99018940e-01f, -1.80759430e-01f, -1.18116938e-01f, -1.73745006e-01f, -1.90035328e-01f, -1.61910743e-01f, -3.00681204e-01f, -1.91883817e-01f,
  -2.00296789e-01f, -1.80490986e-01f, -2.32278600e-01f, -2.47144461e-01f, -2.81503290e-01f, -1.81149408e-01f, -2.57811457e-01f, -2.23739997e-01f, -1.72427207e-01f, -1.56878188e-01f,
  1.68593928e-01f, -1.81625169e-02f, 2.18578637e-01f, 1.63520455e-01f, 1.12196378e-01f, 6.49560243e-02f, 5.20276837e-02f, 1.46082476e-01f, 1.82379317e-02f, 1.39593065e-01f,
  4.49077003e-02f, 1.13357514e-01f, 9.09419954e-02f, 1.15812249e-01f, 1.16838321e-01f, 1.00554973e-01f, 1.08123355e-01f, 1.33821756e-01f, 1.23600811e-01f, 1.58235475e-01f,
  1.69371381e-01f, 1.14282973e-01f, 2.02337906e-01f, 1.12870440e-01f, 1.71168745e-01f, 1.17675856e-01f, 1.29339829e-01f, 1.55723602e-01f, 2.25799203e-01f, 1.97295159e-01f,
  4.93823528e-01f, -2.00217783e-01f, 3.86121690e-01f, 3.47166598e-01f, 1.50175363e-01f, 1.31787986e-01f, -2.56977141e-01f, -8.82582143e-02f, 1.07761398e-01f, -6.20519854e-02f,
  7.27057829e-02f, 1.85238898e-01f, 9.75363106e-02f, 1.86939418e-01f, -6.54416755e-02f, -1.31043464e-01f, 4.84003201e-02f, 2.83136755e-01f, 3.30820441e-01f, 1.87829375e-01f,
  7.72237033e-02f, 7.92632774e-02f, 1.15796573e-01f, 3.00152600e-02f, 1.53651923e-01f, 4.25855182e-02f, -7.55866617e-02f, 2.07338214e-01f, 3.15267057e-03f, 2.06331670e-01f,
  2.88608551e-01f, 1.30917013e-01f, 1.72856659e-01f, 6.27173483e-02f, 1.07737027e-01f, 2.15910990e-02f, 1.23589355e-02f, 8.50625560e-02f, -6.35977741e-03f, 7.79177472e-02f,
  2.12576032e-01f, -1.07806027e-02f, 1.91535965e-01f, 7.72412568e-02f, 1.19860440e-01f, 9.17021334e-02f, 3.12508270e-02f, 1.22007273e-01f, 6.75858855e-02f, 6.77077845e-02f,
  7.20894858e-02f, 2.52369761e-01f, 1.96836874e-01f, 1.13422319e-01f, 1.48894265e-01f, 1.13692850e-01f, 1.41484648e-01f, 1.93015769e-01f, 5.63150421e-02f, 1.12178251e-01f,
  -4.31782380e-02f, 4.90030050e-02f, -7.73079544e-02f, -1.09001860e-01f, -8.21267217e-02f, -7.51859099e-02f, -9.57619306e-03f, 7.21525634e-03f, -9.11295861e-02f, -7.19555244e-02f,
  -1.51945218e-01f, -1.65224485e-02f, -6.73652217e-02f, -9.78688970e-02f, -6.79169819e-02f, -1.32439872e-02f, 6.50801435e-02f, -1.12730868e-01f, -1.61621515e-02f, -2.23391280e-02f,
  -1.55193182e-02f, -3.77834542e-03f, -2.51858924e-02f, -8.99376124e-02f, -6.69722185e-02f, 5.61665790e-03f, 3.27751860e-02f, -9.31163579e-02f, -2.72636525e-02f, -4.33631651e-02f,
  -2.39581689e-01f, 7.48027787e-02f, 1.20129287e-01f, 6.28367513e-02f, 1.78330600e-01f, 9.83622521e-02f, 1.02039628e-01f, 4.80909795e-02f, 1.65713564e-01f, 1.13986894e-01f,
  9.64840874e-02f, 1.52647018e-01f, -1.08917560e-02f, 5.35388365e-02f, 8.06209594e-02f, 1.74948215e-01f, 2.87860632e-03f, 1.29405499e-01f, 8.88689160e-02f, 8.62344801e-02f,
  -2.90155262e-02f, -4.92392108e-03f, 1.64088219e-01f, 5.66588603e-02f, 2.07940534e-01f, 1.10451497e-01f, -2.71843909e-03f, 8.74968469e-02f, 9.51636136e-02f, -6.35335222e-02f,
  2.56410614e-02f, -2.79968470e-01f, -1.86440945e-01f, -8.71017501e-02f, -2.62934774e-01f, -1.42199308e-01f, -2.55644679e-01f, -1.10179596e-01f, 1.20253220e-01f, -4.58570197e-02f,
  -1.42542988e-01f, 1.95556898e-02f, -7.88429603e-02f, 1.37274936e-02f, -1.10723995e-01f, -1.44951746e-01f, -5.49558513e-02f, -1.39116988e-01f, -1.39035061e-01f, -1.86599717e-01f,
  -1.17793523e-01f, -7.06860796e-02f, 5.09555787e-02f, -4.10108082e-02f, -1.84469037e-02f, -6.56516105e-02f, -2.84576211e-02f, -8.30598399e-02f, -1.35059252e-01f, -2.18513653e-01f,
  -3.58197093e-01f, -1.44933626e-01f, -7.02768622e-04f, -3.57445851e-02f, -6.93005696e-02f, -4.82541993e-02f, -5.27061485e-02f, -3.74022871e-02f, 7.91505948e-02f, -1.23989724e-01f,
  -7.89344609e-02f, -1.06855519e-01f, 3.93541194e-02f, -1.14722595e-01f, -1.92161370e-02f, -1.08774029e-01f, 6.81184977e-02f, 1.74299777e-02f, -3.51642556e-02f, -1.16470955e-01f,
  -1.36824265e-01f, -1.06237359e-01f, -2.29620095e-02f, -1.00961262e-02f, -1.14541389e-02f, -9.72734168e-02f, -4.76320274e-02f, -5.46138175e-02f, -9.43211722e-04f, 8.10012147e-02f,
  -2.85353791e-02f, 1.84429243e-01f, 1.74530491e-01f, 1.33295015e-01f, 1.10792451e-01f, 1.20733820e-01f, 2.26249285e-02f, 7.76420906e-02f, 8.10787603e-02f, 1.98381856e-01f,
  7.14715570e-02f, 1.10986136e-01f, 1.25731140e-01f, 1.68475181e-01f, 6.76740184e-02f, 1.36527792e-01f, 7.79163316e-02f, 1.46042943e-01f, 1.14441089e-01f, 1.16498135e-01f,
  1.00541599e-01f, 1.66256696e-01f, 2.16461062e-01f, 8.85466710e-02f, 2.16787994e-01f, 1.29153252e-01f, 7.91371837e-02f, 1.54088736e-01f, 1.41175315e-01f, 1.16830930e-01f,
  -8.53684247e-02f, -5.01523688e-02f, -1.21514037e-01f, -5.47476187e-02f, -7.13449866e-02f, 4.22029458e-02f, -3.74985896e-02f, -3.62887559e-03f, -1.68785080e-02f, -1.26059666e-01f,
  -8.90391693e-02f, 7.46158836e-03f, -1.16853096e-01f, -3.10945809e-02f, -9.89256501e-02f, -7.22457096e-02f, -2.32767295e-02f, -4.78747375e-02f, 8.95643048e-03f, 2.20054761e-02f,
  -4.18871492e-02f, 2.03464963e-02f, -5.91290630e-02f, 4.12911288e-02f, 6.13889545e-02f, 3.20237875e-02f, -9.86814648e-02f, -4.32126895e-02f, 7.55032757e-03f, -4.29884046e-02f,
  -2.82954127e-01f, -1.33340672e-01f, -5.03677055e-02f, -1.84573218e-01f, 1.79644525e-01f, 2.01904967e-01f, 2.01044902e-01f, 1.35663211e-01f, -1.01848051e-01f, -1.43545645e-03f,
  -1.08720466e-01f, -1.67139351e-01f, -6.17081560e-02f, -5.46578169e-02f, -1.12688858e-02f, 1.45279989e-01f, -2.38699801e-02f, -6.87010139e-02f, 1.92988589e-01f, 2.53317297e-01f,
  1.00061290e-01f, 4.63652285e-03f, -1.49917290e-01f, 1.39639815e-02f, -1.75771732e-02f, -3.06465197e-02f, -3.14970538e-02f, -1.84331968e-01f, -3.56201231e-02f, -2.20076114e-01f,
  -6.72622472e-02f, -2.66514957e-01f, 1.05041355e-01f, -5.89294732e-02f, -7.44596794e-02f, -1.94187239e-02f, 2.80530397e-02f, -9.00737271e-02f, -1.15290888e-01f, -1.78590175e-02f,
  1.18611206e-03f, -1.44744694e-01f, -1.31637588e-01f, -1.04496650e-01f, -6.31033108e-02f, -9.27331150e-02f, -1.85699970e-01f, -1.06399164e-01f, -5.99644482e-02f, -4.95564602e-02f,
  -2.61543747e-02f, -7.36385118e-03f, 3.41935381e-02f, 1.20395776e-02f, -8.84154439e-02f, -9.10961032e-02f, -3.01078577e-02f, -3.56915444e-02f, 7.38988444e-02f, -9.39562842e-02f,
  -4.58252355e-02f, 7.93757383e-03f, -6.01065978e-02f, 1.74670611e-02f, 7.28652403e-02f, -1.13483546e-02f, -8.39621667e-03f, -8.81280750e-03f, -7.57134659e-03f, -2.44735205e-03f,
  -3.46499905e-02f, -1.80577412e-02f, -8.27154797e-03f, -6.08933344e-02f, -1.88495461e-02f, -3.57963629e-02f, 2.30792966e-02f, -1.81856733e-02f, -7.12592155e-02f, 4.46288995e-02f,
  -2.65775844e-02f, -4.77021448e-02f, -5.12295552e-02f, -5.86903282e-02f, -8.88230745e-03f, 4.02357504e-02f, -5.17280437e-02f, 3.63577250e-03f, -1.15972295e-01f, -1.14395590e-02f,
  2.48853806e-02f, 5.37587609e-03f, 3.51456553e-02f, 2.20460091e-02f, -8.43985453e-02f, -1.32463753e-01f, -5.66222481e-02f, -8.27673748e-02f, -3.72876935e-02f, 6.71108812e-02f,
  -2.51599345e-02f, -7.75618758e-03f, -7.27825165e-02f, 4.67431583e-02f, 1.41543686e-01f, 8.72842446e-02f, -3.19012739e-02f, 2.69373297e-03f, 1.16271479e-02f, 5.27221225e-02f,
  2.40696198e-03f, 5.39795496e-02f, 3.19619514e-02f, 4.28785533e-02f, -2.04818342e-02f, 1.99852824e-01f, 1.25508979e-01f, -2.62833806e-03f, 1.87733427e-01f, 1.94030628e-01f,
  -2.97652662e-01f, 6.69843405e-02f, 2.38740206e-01f, -1.04024626e-01f, 3.42701599e-02f, -2.76931450e-02f, 9.18561891e-02f, -1.98848471e-01f, -2.35869154e-01f, -3.33744027e-02f,
  -2.73272753e-01f, -3.57099444e-01f, -2.22747341e-01f, -2.69629389e-01f, -2.29314566e-01f, 9.43571106e-02f, 1.12946875e-01f, 5.06292321e-02f, -2.07073778e-01f, -2.02852905e-01f,
  -2.50158697e-01f, -1.74423918e-01f, -1.14038892e-01f, -1.06569722e-01f, -8.34270790e-02f, -5.76387234e-02f, 5.06549403e-02f, 9.00962278e-02f, -2.95344740e-02f, 2.30855808e-01f,
  4.86190356e-02f, -3.81880067e-02f, -2.07965612e-01f, -1.46706000e-01f, -1.56630203e-01f, -1.63997471e-01f, -1.66017890e-01f, -6.55751601e-02f, -1.14264339e-01f, -7.91528001e-02f,
  -1.60855040e-01f, -1.82249188e-01f, -3.77998911e-02f, -1.08854137e-01f, -1.01840295e-01f, -1.12795457e-01f, -7.05614835e-02f, -1.53668016e-01f, -1.44039780e-01f, -1.98831350e-01f,
  -1.76700592e-01f, -1.82035670e-01f, -1.67475924e-01f, -1.82047963e-01f, -7.68851861e-02f, -1.32481694e-01f, -6.45848662e-02f, -9.71965939e-02f, -1.44172516e-02f, 3.71498726e-02f,
  1.46709129e-01f, 2.04826161e-01f, 1.31836951e-01f, 1.87769070e-01f, 1.41091228e-01f, 2.07062468e-01f, 1.93135887e-01f, 1.90193266e-01f, 1.29625410e-01f, 5.65187521e-02f,
  9.99080017e-02f, 8.15550834e-02f, 1.81987345e-01f, 7.83157498e-02f, 1.06039174e-01f, 1.84276327e-01f, 1.01721965e-01f, 9.84507725e-02f, 3.96420807e-02f, 1.34001881e-01f,
  1.64649442e-01f, 2.09167555e-01f, 1.36367366e-01f, 6.74123168e-02f, 1.55417964e-01f, 2.31607020e-01f, 1.11054294e-01f, 4.24475297e-02f, 1.10927589e-01f, 2.17119515e-01f,
  -9.69089568e-02f, -2.35693932e-01f, -6.61447272e-02f, -2.18947366e-01f, -1.23511672e-01f, -1.67147338e-01f, -1.26892373e-01f, -1.66204602e-01f, -9.72982794e-02f, -1.34395227e-01f,
  -1.18040241e-01f, -9.32719558e-02f, -1.59757391e-01f, -1.89842701e-01f, -1.10681631e-01f, -1.18194051e-01f, -8.15380290e-02f, -1.11364916e-01f, -6.57094344e-02f, -1.95346087e-01f,
  -1.33037925e-01f, -4.21616584e-02f, -2.03671381e-01f, -1.53509974e-01f, -8.00789446e-02f, -2.65683115e-01f, -7.11862668e-02f, -1.90115809e-01f, -1.47296816e-01f, -1.08315967e-01f,
  4.36632514e-01f, 4.07492518e-02f, 2.32293129e-01f, 1.98612764e-01f, -6.03213347e-02f, -1.45385027e-01f, -1.21425092e-01f, -1.71069607e-01f, -2.46191043e-02f, 9.69190374e-02f,
  7.67168850e-02f, 1.55749977e-01f, 5.07936403e-02f, -3.64784747e-02f, -4.00750153e-02f, -1.09571449e-01f, 2.55443361e-02f, 1.70085981e-01f, -8.82222503e-02f, -1.94694057e-01f,
  -1.33273974e-01f, -6.21295208e-03f, 1.27485812e-01f, 1.03172868e-01f, -9.73377079e-02f, 1.74710881e-02f, 1.02144562e-01f, 8.06973204e-02f, -9.14443657e-02f, 9.99890342e-02f,
  3.74240786e-01f, 2.73954362e-01f, -6.21958785e-02f, -1.15467410e-03f, 3.03480942e-02f, 8.71161968e-02f, 1.07732557e-01f, 1.62361309e-01f, 3.58244255e-02f, 3.13374586e-02f,
  1.43025354e-01f, 8.44232515e-02f, 4.31087241e-02f, -6.30290732e-02f, -8.30332935e-03f, -2.00720672e-02f, -8.77984706e-03f, 3.20987590e-02f, 4.99152094e-02f, 8.92086551e-02f,
  -7.39882812e-02f, 4.42776792e-02f, 9.74338949e-02f, -1.23822756e-01f, -1.20381780e-01f, 4.29526754e-02f, 4.00310196e-02f, -7.82881677e-02f, -1.05325552e-02f, 1.47474915e-01f,
  -7.54660740e-02f, 1.48993403e-01f, -5.66979386e-02f, 1.72975753e-02f, -8.23212713e-02f, 4.37224917e-02f, 3.72121856e-02f, -7.69649893e-02f, 3.66702699e-03f, -1.42569616e-02f,
  5.25449961e-02f, 2.81101428e-02f, -4.16333862e-02f, 1.32620335e-01f, -3.77282267e-03f, 2.08373610e-02f, 2.39190459e-02f, 4.46338914e-02f, 3.01692281e-02f, 2.87041888e-02f,
  8.90144035e-02f, 7.02948123e-02f, 9.43957046e-02f, -3.65475379e-02f, -5.31791821e-02f, -4.03519208e-03f, 1.82861742e-02f, -5.17073534e-02f, -2.53171138e-02f, 5.47295921e-02f,
  1.85242191e-01f, -8.72063730e-03f, 2.65010983e-01f, 9.01799202e-02f, 1.26284063e-01f, 3.51382443e-03f, 1.50251746e-01f, 1.12197131e-01f, 1.58702627e-01f, 7.89846331e-02f,
  1.07467873e-02f, 7.29689673e-02f, 8.43934417e-02f, -2.57330295e-02f, 9.43557993e-02f, 6.24618866e-02f, 3.18739936e-02f, 1.09675586e-01f, -1.80061962e-02f, -8.16804916e-03f,
  -1.09667763e-01f, -4.41762842e-02f, 1.76697627e-01f, 1.15838088e-01f, 8.81976099e-04f, 1.13588005e-01f, 1.35019824e-01f, -4.53066565e-02f, 7.58478269e-02f, 2.66043972e-02f,
  1.31152958e-01f, 3.62815738e-01f, -8.55574533e-02f, 1.18450798e-01f, 7.59632960e-02f, 8.11577067e-02f, 2.59432614e-01f, 1.61363557e-01f, 4.63814922e-02f, 1.40787005e-01f,
  -1.49179436e-03f, -2.71269262e-01f, -1.79459453e-01f, -2.03995302e-01f, -1.26758412e-01f, 2.37571523e-01f, 3.63521948e-02f, -1.31720901e-01f, -2.50034630e-01f, -2.51296796e-02f,
  1.48666084e-01f, 1.45878464e-01f, -8.62424597e-02f, 7.43916538e-03f, 1.02749884e-01f, -8.97843018e-02f, 9.32744220e-02f, 7.71502256e-02f, -1.55836977e-02f, 4.98336963e-02f,
  -7.98966587e-02f, 3.78932618e-02f, -4.65822406e-02f, -2.80460007e-02f, -3.37635651e-02f, -1.91916265e-02f, 1.36514865e-02f, -3.93884741e-02f, -1.07657444e-03f, -3.15959193e-02f,
  -6.71049133e-02f, -3.77190821e-02f, 3.84794995e-02f, -4.74305882e-04f, 4.30443622e-02f, 3.68047655e-02f, 3.43279820e-03f, -1.06703304e-01f, -6.18439615e-02f, 1.27845192e-02f,
  1.76706584e-03f, 1.00272916e-01f, 5.56661226e-02f, 1.09916357e-02f, 1.18413260e-02f, -1.51199088e-01f, -3.47054563e-02f, -1.26377027e-02f, -3.83583531e-02f, 1.07780956e-01f,
  2.22367290e-02f, -3.51448655e-02f, -4.12363596e-02f, 6.16719760e-02f, -6.52653724e-02f, -7.42969364e-02f, -2.37210952e-02f, 4.21940396e-03f, -7.76960403e-02f, 9.12256464e-02f,
  -6.77713752e-02f, 3.63304541e-02f, -5.16636744e-02f, 5.30968271e-02f, -4.27572057e-02f, 5.16333841e-02f, 3.42295468e-02f, 4.37094308e-02f, 3.82467769e-02f, -2.63657346e-02f,
  -6.84198365e-02f, -2.93142651e-03f, -2.36921459e-02f, -3.71497637e-03f, 1.17686894e-02f, -7.50134215e-02f, 4.64718752e-02f, -3.28976698e-02f, -4.57710773e-03f, -6.94307461e-02f,
  1.91083163e-01f, -1.39313146e-01f, 8.59216526e-02f, 4.80289273e-02f, 8.22387561e-02f, 2.22978834e-02f, 5.51115014e-02f, -2.88406871e-02f, -5.88816293e-02f, -3.76098510e-03f,
  -3.60263884e-03f, 5.81796616e-02f, 1.29450828e-01f, 4.41228896e-02f, 2.69576460e-02f, -4.64678966e-02f, 1.50321364e-01f, -1.34147471e-02f, -1.47792827e-02f, 3.78758572e-02f,
  1.38723969e-01f, 1.06722742e-01f, 9.71157700e-02f, 4.07517776e-02f, -5.55823185e-03f, 3.78023870e-02f, 1.61103696e-01f, 9.90989432e-02f, 4.08302955e-02f, 3.08553725e-01f,
  1.14468016e-01f, 2.99007535e-01f, 8.18432588e-03f, 4.95447181e-02f, 5.05365357e-02f, -5.20818271e-02f, -6.98457882e-02f, -1.66041076e-01f, -8.11391696e-02f, 8.65448266e-02f,
  -9.09563079e-02f, -3.34314071e-02f, -6.81899395e-03f, -1.67434500e-03f, -1.03779674e-01f, 4.82623652e-03f, 7.46274740e-02f, -5.27123921e-02f, -2.41304308e-01f, -1.24239042e-01f,
  -1.16931446e-01f, 1.46729941e-03f, 3.68383080e-02f, -3.10171358e-02f, 7.91252777e-02f, -4.21460532e-02f, 7.17647523e-02f, 1.70590468e-02f, 2.29122024e-03f, 7.57237300e-02f,
  -3.16401944e-02f, 1.32532626e-01f, -1.09950729e-01f, -3.50662842e-02f, 1.42143473e-01f, -5.72145395e-02f, 2.14874689e-02f, -3.03937751e-03f, -3.92046794e-02f, 4.37720753e-02f,
  1.30084857e-01f, 5.20715527e-02f, 9.66639593e-02f, 4.80694026e-02f, 4.56064194e-02f, -3.03908698e-02f, 2.80714408e-02f, 6.94472194e-02f, 1.37272347e-02f, -6.64907768e-02f,
  3.72989252e-02f, 9.58263576e-02f, 9.92722288e-02f, -6.88003600e-02f, -6.24614432e-02f, -4.58157845e-02f, -1.23089412e-02f, 6.39105588e-02f, 1.68706942e-02f, -1.34234857e-02f,
  -1.04504481e-01f, 3.04597914e-02f, -7.99554959e-02f, -2.46994887e-02f, -5.05872145e-02f, 2.47894973e-02f, -1.92061700e-02f, 2.93400064e-02f, -1.24993175e-01f, -8.21475014e-02f,
  3.95716690e-02f, -3.50865759e-02f, -1.36009892e-02f, 9.19243973e-03f, -1.31389156e-01f, 7.97158033e-02f, -1.31182829e-02f, -1.43741425e-02f, -4.24110219e-02f, 1.15620520e-03f,
  -8.73980597e-02f, -5.18145934e-02f, -6.01119623e-02f, -2.97272876e-02f, 2.32148468e-02f, -8.62220228e-02f, -1.20930418e-01f, -1.09438365e-02f, -1.12141408e-02f, 1.54479397e-02f,
  1.33838877e-01f, -6.08126856e-02f, 2.20914260e-02f, 3.70149985e-02f, -3.37636396e-02f, 2.32251342e-02f, -6.69250265e-03f, 1.64310110e-03f, 1.05597645e-01f, -2.64352676e-03f,
  -4.56186756e-02f, 6.20928183e-02f, 1.67249832e-02f, -1.03798313e-02f, -1.12737983e-01f, -8.56761858e-02f, -4.48042620e-03f, 1.04534365e-01f, 6.23207614e-02f, 7.60411397e-02f,
  -3.81580740e-02f, 1.35088032e-02f, -8.48478451e-02f, -6.65364116e-02f, -2.10797954e-02f, -1.45783380e-01f, -5.70472255e-02f, -1.35375485e-01f, -2.75351107e-02f, -1.09727889e-01f,
  4.93265361e-01f, 4.54220809e-02f, -1.52532205e-01f, 1.53370053e-01f, -2.31247202e-01f, -2.53397286e-01f, -2.67871410e-01f, -1.34278923e-01f, 3.98419388e-02f, -8.36061314e-02f,
  1.03494786e-02f, 2.23183334e-01f, 5.33520840e-02f, 7.76527673e-02f, -4.45420407e-02f, -2.43672013e-01f, -2.21331671e-01f, 3.99441039e-03f, 3.00140604e-02f, 5.28641827e-02f,
  4.54202667e-02f, 1.54439747e-01f, 2.30113491e-01f, 9.39119607e-02f, -4.80494127e-02f, -5.75677268e-02f, -1.58703864e-01f, -2.85174120e-02f, -1.54398680e-02f, 7.07989708e-02f,
  3.27666886e-02f, 2.60069847e-01f, -8.83060973e-03f, 1.71913147e-01f, 7.34802475e-03f, 6.06953306e-03f, 6.74511269e-02f, -2.56142841e-04f, 5.71262538e-02f, 5.22952788e-02f,
  6.35337904e-02f, 1.34932891e-01f, 1.13575123e-01f, -4.09654062e-03f, 2.24918127e-02f, 1.05164357e-01f, 6.41985144e-03f, 1.22136503e-01f, 3.91471013e-02f, -2.79273521e-02f,
  9.07267109e-02f, 2.90372930e-02f, -2.42079403e-02f, -6.60053343e-02f, 2.82460339e-02f, -2.46845447e-02f, -6.60905838e-02f, 1.23633623e-01f, -9.26428512e-02f, 1.08266525e-01f,
  -1.61591661e-03f, 2.27839174e-03f, -7.11465180e-02f, -1.52669642e-02f, -4.46804985e-02f, -3.68266664e-02f, -5.65239973e-02f, -5.50665744e-02f, 3.07516679e-02f, -9.79793165e-03f,
  -3.38837318e-02f, -4.16449383e-02f, 5.43797053e-02f, -2.60826945e-02f, -1.30676646e-02f, 3.31944972e-02f, 7.80542055e-03f, 9.48994234e-03f, 2.28387043e-02f, -4.60531446e-04f,
  3.90062220e-02f, -6.40594512e-02f, 1.14803556e-02f, 3.40711363e-02f, 4.91254255e-02f, 1.75873898e-02f, -2.03852747e-02f, -2.71750148e-02f, -7.00370595e-02f, -7.17466278e-03f,
  4.27911654e-02f, 4.19161133e-02f, 4.23369929e-03f, 7.71697462e-02f, 1.36999274e-02f, 2.20441613e-02f, 2.88462937e-02f, 3.72901112e-02f, 2.32226700e-02f, 4.07351330e-02f,
  4.18664850e-02f, -1.67754071e-04f, 5.82606010e-02f, -6.76318705e-02f, 1.49494344e-02f, -4.62168716e-02f, -2.29955669e-02f, -1.05078397e-02f, -1.82693712e-02f, 6.45536184e-02f,
  5.50252236e-02f, -1.36428043e-01f, -1.20132349e-01f, -3.83060761e-02f, -8.47004913e-03f, 2.56539974e-02f, -1.02014951e-01f, 1.57417823e-03f, -6.43197373e-02f, -1.64790124e-01f,
  5.19689083e-01f, -3.31194490e-01f, -1.68774694e-01f, 1.95144847e-01f, -2.71661915e-02f, 5.36780991e-02f, -2.65866481e-02f, 9.04353708e-03f, 1.57744244e-01f, -9.09393057e-02f,
  -1.97129294e-01f, 8.92671719e-02f, 4.90316488e-02f, -6.80254102e-02f, -1.78034641e-02f, -1.48729384e-01f, -2.03564525e-01f, 1.27121508e-01f, 2.81100571e-01f, 2.16355354e-01f,
  4.88492660e-02f, 9.45343375e-02f, 1.53861597e-01f, -3.84787470e-02f, -8.27843249e-02f, 4.82711866e-02f, -3.43972862e-01f, -1.31392717e-01f, -1.94057658e-01f, -1.88900247e-01f,
  -2.31059149e-01f, -1.16265364e-01f, 9.72879231e-02f, -2.31618192e-02f, -1.44511908e-01f, 4.26563211e-02f, -3.03399507e-02f, -6.61367923e-02f, -5.36680892e-02f, -3.33439037e-02f,
  -7.79875973e-03f, -2.24478152e-02f, 5.82565963e-02f, -1.34682253e-01f, -7.33682737e-02f, -8.42236653e-02f, -1.11098044e-01f, -1.03108041e-01f, -4.17096168e-02f, -5.76429591e-02f,
  -7.07754716e-02f, -3.85863744e-02f, -6.13187924e-02f, -6.42969459e-02f, -3.19777653e-02f, 9.48930532e-02f, -1.01191230e-01f, 8.45438987e-03f, -1.14417061e-01f, -3.47635634e-02f,
  6.21391572e-02f, 8.68868176e-03f, 2.14579739e-02f, -3.97696123e-02f, 3.82407643e-02f, 2.29374636e-02f, -1.95963234e-02f, 7.73750469e-02f, 1.11864042e-02f, -1.43595841e-02f,
  -5.26707293e-03f, -1.21807596e-02f, 1.88403465e-02f, 2.30639763e-02f, 4.06111479e-02f, -8.74453876e-03f, -7.16308947e-04f, 2.73197703e-02f, 3.35118198e-03f, -2.07670443e-02f,
  -5.98001294e-03f, 5.18898927e-02f, -1.86675563e-02f, -1.43079432e-02f, -5.36262989e-02f, 4.99872528e-02f, 1.52167231e-02f, -4.36908146e-03f, -4.63721305e-02f, -7.80472830e-02f,
  1.36574311e-02f, -2.43286863e-02f, 2.74574067e-02f, -5.75127266e-02f, 8.45285133e-03f, -4.77906056e-02f, -1.63259339e-02f, -2.05677338e-02f, -3.80294919e-02f, -6.94770515e-02f,
  -1.97254624e-02f, 8.12713150e-03f, -1.39810607e-01f, -5.31764515e-02f, 4.90853079e-02f, 2.65678857e-02f, -1.03151433e-01f, 1.02862390e-02f, -1.44885844e-02f, -5.94801605e-02f,
  -1.08739518e-01f, 1.01361707e-01f, 1.66491568e-01f, 2.56267004e-02f, -2.06689723e-03f, 1.40011087e-01f, -2.60559726e-03f, 7.38201439e-02f, 1.39087930e-01f, 2.81545194e-03f,
  -3.60262394e-01f, -3.57997119e-01f, -1.09796956e-01f, -3.63694787e-01f, -3.05831552e-01f, -1.09648213e-01f, -1.58539876e-01f, -1.61490574e-01f, -1.25679463e-01f, -3.46951097e-01f,
  -2.44564086e-01f, -3.70895378e-02f, -1.89634904e-01f, -1.09065011e-01f, -3.90866064e-02f, -1.95570856e-01f, -1.99922979e-01f, -1.10194504e-01f, -8.78524780e-03f, -1.78250193e-03f,
  -1.83420941e-01f, -2.46764794e-01f, -1.14635788e-01f, -1.16442829e-01f, -1.53593928e-01f, -7.93791041e-02f, -1.84650704e-01f, -2.35725820e-01f, -6.36407062e-02f, -2.62146324e-01f,
  -5.64238578e-02f, -2.86816031e-01f, 2.32835915e-02f, -9.42474529e-02f, -1.91822723e-01f, -1.16980799e-01f, -9.99206156e-02f, -1.19150467e-01f, -7.35956952e-02f, -1.83887824e-01f,
  -1.99974358e-01f, -1.65064573e-01f, -1.07158720e-01f, -9.31262001e-02f, -2.16861680e-01f, -2.35849731e-02f, -1.26948684e-01f, -1.49754241e-01f, -1.52491212e-01f, -1.38575867e-01f,
  -1.72018766e-01f, -9.48554501e-02f, -1.01872593e-01f, 3.57249342e-02f, -1.78372879e-02f, -1.19119668e-02f, -6.34601563e-02f, -9.52731520e-02f, 4.97665405e-02f, -1.24175116e-01f,
  3.03803422e-02f, 1.63451031e-01f, 1.40825480e-01f, 1.34493753e-01f, 1.39552414e-01f, 1.72387809e-01f, 6.60020187e-02f, 1.10714927e-01f, 9.93633494e-02f, 1.81853682e-01f,
  2.02262308e-02f, 9.59215388e-02f, 5.58126755e-02f, 1.82235185e-02f, 3.60881127e-02f, 1.49741516e-01f, 9.38339010e-02f, 1.00870319e-01f, 6.65218830e-02f, 6.06235489e-02f,
  1.11929655e-01f, 1.45889431e-01f, -4.92019067e-03f, 1.36781558e-01f, 2.92678270e-02f, 4.69563045e-02f, 1.25787079e-01f, 7.81369731e-02f, 6.22676201e-02f, 2.41886713e-02f,
  -1.28533393e-01f, -3.54751886e-04f, -1.21775605e-01f, -1.56123070e-02f, -8.35600644e-02f, 2.03264896e-02f, -1.73587471e-01f, 1.60027146e-02f, -5.78999370e-02f, -1.41799912e-01f,
  -7.45133236e-02f, -1.17561080e-01f, -1.49262682e-01f, -4.12350446e-02f, 8.82591773e-03f, -1.39407977e-01f, -1.90732107e-01f, -3.04412991e-02f, -9.40642208e-02f, 1.29232267e-02f,
  -1.30549401e-01f, 6.62043244e-02f, 1.24159545e-01f, -2.28924472e-02f, -3.17792990e-03f, -5.18797040e-02f, 3.56989950e-02f, 2.24881601e-02f, 5.59875108e-02f, -5.39716370e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.57943624e-01f, -7.74877965e-02f, 4.97740149e-01f, 1.08308699e-02f, -6.07807457e-01f, -3.50696743e-01f, -2.89035231e-01f, 6.46123961e-02f, -9.61878523e-02f, -2.87082475e-02f,
  -4.09418494e-01f, -2.20193297e-01f, -4.33036238e-02f, 2.31397793e-01f, 4.27078187e-01f, 1.81538150e-01f, 3.69532764e-01f, 5.42629778e-01f, 3.07086885e-01f, 5.19960858e-02f,
  -1.34760097e-01f, 1.07624553e-01f, 3.89306724e-01f, 1.49625108e-01f, -9.29028075e-03f, -4.34712730e-02f, 8.84919390e-02f, 3.58926319e-02f, 1.88294053e-02f, 1.91376865e-01f,
  -1.03184052e-01f, -1.83354132e-02f, -1.69568092e-01f, -1.25751719e-01f, -3.80044207e-02f, 1.61210954e-01f, 9.72713903e-02f, 2.52017260e-01f, -1.03595942e-01f, 4.44047898e-02f,
  -8.12363103e-02f, -1.93878766e-02f, -1.19137250e-01f, -5.42795546e-02f, -2.01073438e-01f, -1.51637688e-01f, 1.97973698e-01f, 3.44291449e-01f, 2.07064062e-01f, -1.91765130e-02f,
  -1.83380112e-01f, -2.41024703e-01f, -1.60180375e-01f, -1.52246058e-01f, 7.21506588e-03f, -1.47506341e-01f, -1.40979871e-01f, -2.64925659e-02f, -9.22773629e-02f, 8.39229897e-02f,
  -1.26486763e-01f, 2.74538156e-03f, 3.90021391e-02f, 1.08971521e-01f, -2.27730349e-02f, -5.95507473e-02f, 1.21835530e-01f, -1.36413341e-02f, 4.28915247e-02f, 1.27564251e-01f,
  2.45705824e-02f, 2.40766793e-03f, 1.16717644e-01f, 3.32343988e-02f, -9.69165564e-02f, 7.91934058e-02f, -9.57347546e-03f, 1.08816102e-01f, -7.48379976e-02f, -4.48896885e-02f,
  -9.93804038e-02f, -1.24642719e-02f, 7.61221275e-02f, 7.81900287e-02f, 1.85431223e-02f, 1.77685544e-01f, -6.22885264e-02f, 3.61642428e-02f, -7.95510486e-02f, -1.41020074e-01f,
  -1.70006454e-01f, -1.91278487e-01f, -1.33547159e-02f, 8.40059742e-02f, -1.10507635e-02f, -1.49511978e-01f, -1.76088922e-02f, -5.57291433e-02f, -2.21279562e-02f, -6.51156604e-02f,
  -5.22604324e-02f, 2.20543183e-02f, -1.75886303e-02f, -1.75519846e-02f, 2.12134533e-02f, -1.59321025e-01f, 7.26709887e-03f, 4.49545681e-03f, 6.52145669e-02f, -7.13974461e-02f,
  1.03457691e-02f, -3.14748257e-01f, -4.73588169e-01f, -3.75673532e-01f, -3.86933446e-01f, -4.19060022e-01f, -2.20608279e-01f, -1.94691837e-01f, -3.15007925e-01f, -2.10687444e-01f,
  -4.28213030e-01f, -4.18737978e-01f, -4.06831741e-01f, -2.67518729e-01f, -1.72397673e-01f, 1.11785531e-02f, -1.05122760e-01f, 3.57371233e-02f, -2.54589948e-03f, -2.78275341e-01f,
  -2.12081030e-01f, -9.83700901e-02f, -3.26505482e-01f, -1.81628913e-01f, -1.82594776e-01f, -4.03955817e-01f, -4.36050802e-01f, -2.94125050e-01f, 3.02405983e-01f, 4.45281178e-01f,
  2.25223616e-01f, -3.18269543e-02f, 1.18985526e-01f, 1.20529406e-01f, -2.24474818e-01f, -1.31993741e-01f, -3.37279528e-01f, -2.04669416e-01f, -2.20081896e-01f, -4.95807141e-01f,
  -3.87210757e-01f, -8.45924765e-02f, 2.30903640e-01f, 1.26567379e-01f, -1.43282786e-01f, 8.90345648e-02f, 7.18073845e-02f, -8.02158341e-02f, 2.15505920e-02f, -1.30782038e-01f,
  1.04579739e-02f, 2.48575538e-01f, -3.19854431e-02f, 9.94518399e-02f, 4.29908521e-02f, 9.72416997e-02f, 5.68212867e-02f, 9.41914096e-02f, -1.18909813e-01f, 6.82813721e-03f,
  -7.85679370e-02f, -1.61276430e-01f, -1.42355263e-01f, 8.10464919e-02f, 2.99384892e-01f, 3.05352584e-02f, 1.55981392e-01f, 2.38675058e-01f, 4.97155637e-02f, -3.66521597e-01f,
  1.92984263e-03f, -1.40411586e-01f, -1.99160129e-02f, 5.83692417e-02f, 2.78110411e-02f, -7.36745670e-02f, -1.21626846e-01f, -1.58143304e-02f, 1.02888390e-01f, -6.60144761e-02f,
  8.45290720e-02f, 2.75552329e-02f, 1.07073292e-01f, -4.37737405e-02f, -3.77230532e-02f, -5.12829386e-02f, 1.01239271e-02f, -1.20801851e-01f, 5.29895611e-02f, -9.99885052e-03f,
  2.36398131e-02f, -1.66588500e-02f, 3.06393864e-04f, 7.03044385e-02f, -4.75776382e-02f, -1.71851355e-03f, -4.55912612e-02f, 1.61416277e-01f, 6.12889118e-02f, 8.09996277e-02f,
  -2.17315659e-01f, -1.22143924e-01f, -3.36916924e-01f, 1.33066580e-01f, -3.41393575e-02f, -4.30703536e-02f, -9.05546322e-02f, 6.22068830e-02f, -3.95525694e-02f, 1.28047511e-01f,
  2.53472239e-01f, 9.85935107e-02f, -4.32617962e-02f, 1.00902669e-01f, 1.34898365e-01f, 8.85457247e-02f, 6.32432476e-02f, -5.27857691e-02f, 2.73973290e-02f, 1.69161260e-01f,
  1.86605416e-02f, -1.03855796e-01f, -2.59758472e-01f, -2.29515299e-01f, 8.18302557e-02f, -1.13677390e-01f, -2.00857282e-01f, -1.32630438e-01f, -2.12709874e-01f, -3.60552222e-01f,
  4.58741307e-01f, 8.87029991e-02f, 7.19145965e-03f, 2.30988219e-01f, -2.74298638e-01f, -5.32532454e-01f, -5.49332738e-01f, -3.25893819e-01f, 1.30223989e-01f, 9.68770087e-02f,
  2.42877677e-02f, 1.33955568e-01f, 1.43836588e-01f, -1.17253549e-01f, -2.64730006e-01f, -1.10571340e-01f, 3.30205075e-02f, -1.55563178e-02f, -3.11506301e-01f, -4.66668487e-01f,
  -1.51724100e-01f, 1.06106192e-01f, 4.79599088e-02f, 7.63282031e-02f, 1.94672540e-01f, 8.83529559e-02f, 1.23701565e-01f, 1.20529598e-02f, -4.35581692e-02f, 4.81325030e-01f,
  1.48751140e-01f, 1.40350297e-01f, -1.05563089e-01f, 1.47912443e-01f, 8.61049891e-02f, 7.54532740e-02f, -8.30333009e-02f, 9.00412127e-02f, -6.90744782e-04f, -1.17346503e-01f,
  -1.01616252e-02f, 1.09915212e-02f, -3.72726507e-02f, 2.98111327e-02f, -9.30851474e-02f, -1.30113423e-01f, 1.42039703e-02f, -6.60750940e-02f, 4.01068432e-03f, -3.55857462e-02f,
  6.05179928e-03f, -1.27516344e-01f, -9.09058079e-02f, -2.35455006e-01f, -2.31016815e-01f, -4.55710804e-03f, -1.60651609e-01f, -8.40453282e-02f, -8.17982107e-02f, 6.82883263e-02f,
  -3.27958345e-01f, -4.17455435e-02f, -1.07295409e-01f, -1.98425174e-01f, -1.24196179e-01f, -3.26989889e-02f, -8.23314860e-02f, -1.85879335e-01f, -1.21204197e-01f, -7.11968690e-02f,
  -5.17337732e-02f, 2.25352477e-02f, -6.86640069e-02f, 1.14500737e-02f, 1.00718401e-02f, -5.70468754e-02f, -4.76779453e-02f, -8.92159268e-02f, -9.52904150e-02f, 9.20961786e-04f,
  -7.96512067e-02f, -1.15815133e-01f, 8.02687258e-02f, -7.11641982e-02f, 4.49216813e-02f, -3.93647999e-02f, 2.68405932e-03f, -1.54992014e-01f, -3.81806716e-02f, 2.75579616e-02f,
  1.98587894e-01f, -1.00082615e-02f, 1.70189232e-01f, 2.44764388e-02f, 5.97130656e-02f, 1.49786502e-01f, 2.03837574e-01f, -1.17818620e-02f, 8.86564702e-02f, 4.59094793e-02f,
  -8.04343000e-02f, -9.65950824e-03f, 6.32857531e-02f, 6.39120582e-03f, -1.04686886e-01f, 3.64325903e-02f, -2.32825484e-02f, 5.71886413e-02f, -2.78742611e-02f, 1.92115888e-01f,
  1.99258309e-02f, -1.05141014e-01f, -2.33885273e-02f, 1.02838706e-02f, -8.77252892e-02f, -2.95724180e-02f, -1.54383466e-01f, -5.14146872e-03f, -5.29923961e-02f, -7.52853528e-02f,
  7.27636397e-01f, 2.16018930e-01f, 1.22625209e-01f, 3.87372226e-02f, -1.74126551e-01f, -9.25953779e-03f, -1.26631549e-02f, 2.98271850e-02f, -7.36818882e-03f, 9.03357342e-02f,
  -7.67359063e-02f, -6.95390208e-03f, 3.38654444e-02f, 4.77939211e-02f, 7.32303858e-02f, -4.44157608e-02f, 6.50016740e-02f, 8.46258029e-02f, 6.07235543e-02f, 4.92409477e-03f,
  -8.29376578e-02f, 1.24431342e-01f, 1.79053426e-01f, 1.30462393e-01f, -2.55887210e-02f, -1.51232645e-01f, 7.06299813e-03f, 4.09531221e-02f, 1.15048118e-01f, 1.29774109e-01f,
  1.61630601e-01f, 3.63074571e-01f, -1.25351464e-02f, -6.28181100e-02f, 4.56881858e-02f, 4.90994602e-02f, 1.05959876e-02f, 3.73399965e-02f, -7.96729922e-02f, -1.41097754e-01f,
  -9.08037275e-03f, 1.34526685e-01f, 9.23553333e-02f, 1.20975487e-01f, 1.20751508e-01f, 1.20048076e-02f, 1.48334995e-01f, 7.91929886e-02f, 8.00421238e-02f, 6.52672052e-02f,
  8.54808539e-02f, 1.05076144e-02f, -1.01366974e-01f, 3.40818912e-02f, 1.39654785e-01f, 5.44253876e-03f, 1.27463043e-01f, 1.45351663e-01f, 2.74262633e-02f, -6.85974443e-03f,
  8.42783749e-02f, -2.96387896e-02f, 2.63786465e-02f, 7.05836788e-02f, 1.76578775e-01f, 1.46314234e-01f, -5.82328700e-02f, -2.21513882e-02f, 6.70084953e-02f, 1.32712573e-01f,
  3.72079909e-02f, -2.01190785e-02f, 1.02733828e-01f, 4.73053828e-02f, 1.53465495e-01f, 2.21489400e-01f, 1.21758282e-02f, 2.56220941e-02f, 2.06317678e-02f, 7.23446608e-02f,
  1.64478421e-01f, -4.46177125e-02f, 1.50978252e-01f, 1.57670185e-01f, 8.08763504e-02f, 8.99516642e-02f, 3.61322463e-02f, -1.48082906e-02f, 7.38231689e-02f, 1.58929557e-01f,
  -4.59752440e-01f, 2.39357561e-01f, 1.61068402e-02f, 1.40561331e-02f, 4.61538583e-02f, -1.83694456e-02f, -1.38225108e-02f, -6.99327067e-02f, -1.88786030e-01f, -4.23673987e-02f,
  -7.24339783e-02f, 4.25323062e-02f, 8.13269466e-02f, 1.45192638e-01f, -4.47204523e-02f, -6.34707883e-02f, -6.85419440e-02f, -9.17246118e-02f, -8.45463350e-02f, -7.98262507e-02f,
  -9.17080939e-02f, -1.58641458e-01f, -2.42990166e-01f, -8.95113051e-02f, -5.25788330e-02f, -9.68695655e-02f, -1.55013585e-02f, -2.97584869e-02f, -1.17723398e-01f, -6.07802793e-02f,
  -4.34716731e-01f, 7.66550526e-02f, 3.08735132e-01f, 2.66436756e-01f, 4.98229682e-01f, 6.70792907e-03f, -2.98045099e-01f, -4.49707568e-01f, -4.43183072e-02f, 4.52570654e-02f,
  2.49636963e-01f, 2.02890083e-01f, 3.22086096e-01f, 4.59234081e-02f, -2.22763747e-01f, -2.20447928e-01f, 1.53217480e-01f, 1.15569331e-01f, -1.20729364e-01f, -1.41219929e-01f,
  1.06037728e-01f, 2.15918273e-01f, 4.34513688e-02f, -1.36849806e-01f, 3.10392287e-02f, 1.22890003e-01f, 2.77303666e-01f, 3.24510843e-01f, 1.06392922e-02f, -9.04899091e-02f,
  -5.17140143e-02f, -1.28106356e-01f, 2.18968183e-01f, 4.11715098e-02f, 2.34352946e-01f, -2.68227547e-01f, -2.65911311e-01f, -8.01854953e-02f, -1.78469881e-01f, -2.01440364e-01f,
  3.93507779e-01f, -2.35602632e-02f, 8.73663425e-02f, 2.89995912e-02f, -8.89170021e-02f, -2.01406002e-01f, -3.99196632e-02f, -2.50480890e-01f, -2.30104581e-01f, -3.54923159e-01f,
  1.58347785e-01f, 2.74589568e-01f, 2.54707243e-02f, -1.61062330e-01f, -3.93824488e-01f, 2.74729252e-01f, -6.50348738e-02f, -1.70854986e-01f, -2.20194280e-01f, -5.85527539e-01f,
  3.46072316e-02f, 1.52578518e-01f, 1.51128531e-01f, 5.52188838e-03f, -7.02914000e-02f, 2.20622104e-02f, 2.72076763e-03f, 5.55930547e-02f, 5.00957631e-02f, 7.86275044e-02f,
  4.47554328e-02f, -5.21357991e-02f, -5.30935377e-02f, 4.11663912e-02f, 7.13091195e-02f, 2.85791308e-02f, -1.62367851e-01f, -5.48223630e-02f, 8.39123204e-02f, 4.37604785e-02f,
  1.16639942e-01f, -4.92935777e-02f, 1.69282153e-01f, -1.87579840e-01f, 4.02818583e-02f, 1.69774055e-01f, -8.94251466e-02f, -1.50024578e-01f, 7.36704916e-02f, -5.00739925e-02f,
  8.13890100e-02f, 5.63006580e-01f, -1.90506935e-01f, -1.32207140e-01f, 6.91391714e-03f, -3.77254225e-02f, 4.96067032e-02f, 1.27684902e-02f, -2.20117420e-02f, -2.29025751e-01f,
  -8.55988637e-02f, -1.24358553e-02f, 4.95501496e-02f, -4.27380539e-02f, -1.14572965e-01f, 8.60564485e-02f, -5.99018149e-02f, 8.51632655e-02f, -6.62581399e-02f, -1.37344509e-01f,
  -1.28001079e-01f, -1.89260051e-01f, -1.95317149e-01f, -1.81833267e-01f, -9.16955769e-02f, 1.15896180e-01f, -7.77185634e-02f, -5.98784685e-02f, -7.93261528e-02f, -4.85739440e-01f,
  -3.16657056e-03f, -2.77684689e-01f, -1.60357073e-01f, 2.95006841e-01f, 1.52461737e-01f, -2.48597786e-01f, -5.31962097e-01f, -5.06835997e-01f, 1.26488537e-01f, 1.09123915e-01f,
  1.90433741e-01f, 3.16680610e-01f, 6.78972602e-02f, -1.53535046e-02f, -3.77359271e-01f, -3.67085814e-01f, -1.53906703e-01f, -1.69631302e-01f, -1.97860882e-01f, -8.66136774e-02f,
  2.18170151e-01f, 5.11133857e-02f, -9.83697362e-03f, -7.28052408e-02f, 2.73503900e-01f, 2.26360664e-01f, -7.09967166e-02f, 2.12363660e-01f, -1.75942667e-02f, 2.73233205e-01f,
  2.34016702e-01f, -1.98703974e-01f, 3.87309156e-02f, 1.80986345e-01f, 1.86865583e-01f, -2.96234488e-02f, -4.78841402e-02f, 5.61888516e-02f, 2.42389459e-02f, 5.15005551e-02f,
  2.04002187e-01f, 4.57493961e-02f, 1.53416604e-01f, 3.85911651e-02f, 1.36330172e-01f, 1.94774717e-02f, -1.26543179e-01f, -3.00237685e-01f, -1.43604735e-02f, 6.55350983e-02f,
  1.43911302e-01f, 2.39475146e-01f, -1.35797232e-01f, -1.81002676e-01f, -1.46184742e-01f, 1.91307977e-01f, -1.07125133e-01f, -6.50055036e-02f, -2.45894328e-01f, -1.88873008e-01f,
  -5.92963882e-02f, 9.87661332e-02f, 9.26983356e-02f, 8.15061387e-03f, -2.34519616e-02f, 2.18742806e-02f, 1.22731224e-01f, 2.69244313e-02f, -1.98176689e-02f, 7.71237025e-03f,
  -3.70541327e-02f, 5.88657856e-02f, 5.90151772e-02f, 8.15662369e-03f, 1.71938047e-01f, 1.71646811e-02f, -1.80639774e-02f, 7.25439936e-03f, -2.39439849e-02f, 1.39621764e-01f,
  4.40643616e-02f, -1.08760558e-01f, 1.70510009e-01f, -3.99942845e-02f, -4.55003120e-02f, -2.54255701e-02f, 1.06819980e-01f, 9.64251533e-02f, 7.65073672e-02f, 2.97399741e-02f,
  1.69078693e-01f, -1.41562358e-01f, 5.84872812e-02f, -7.01576248e-02f, 9.49675068e-02f, 6.30516261e-02f, 1.53666347e-01f, 3.94074731e-02f, 1.99113458e-01f, 4.67362739e-02f,
  1.66083768e-01f, 1.10351956e-02f, -2.79581584e-02f, 2.55375803e-02f, 9.28016286e-03f, 1.35075882e-01f, 1.24334387e-01f, -1.64972804e-02f, -2.27635074e-02f, 1.03933379e-01f,
  -2.14244965e-02f, -1.71550050e-01f, -2.22094208e-01f, -2.21909225e-01f, -5.49459085e-02f, -5.46385609e-02f, -1.16858974e-01f, -5.44712357e-02f, -1.83492959e-01f, -2.49214530e-01f,
  -8.00262094e-01f, 3.49751443e-01f, 4.00952607e-01f, -5.89411557e-01f, -1.89319611e-01f, 6.29467964e-02f, 3.42896730e-01f, -1.29406601e-01f, -3.76560718e-01f, 5.92791289e-02f,
  2.25468829e-01f, -1.40921116e-01f, 1.30027188e-02f, 4.22121882e-02f, -2.02488229e-02f, 1.52951062e-01f, -2.99576018e-02f, -1.36004418e-01f, -2.58380264e-01f, -1.59792066e-01f,
  -1.93693399e-01f, -4.09528494e-01f, -4.79173362e-01f, -1.77969187e-01f, -1.47776246e-01f, -2.06760123e-01f, 1.37053549e-01f, -1.48775384e-01f, 2.46531427e-01f, -1.18484698e-01f,
  4.05468762e-01f, 5.37311919e-02f, 1.18396003e-02f, -2.00970322e-01f, -8.17255303e-03f, -1.40929893e-01f, -8.58348086e-02f, -1.45451963e-01f, -7.03480318e-02f, -1.10047758e-01f,
  -1.40144363e-01f, -1.88886467e-02f, -2.21853312e-02f, 2.92766057e-02f, -9.04146060e-02f, -5.36518916e-02f, -1.02063887e-01f, -5.50877154e-02f, 7.07512423e-02f, 2.18399152e-01f,
  1.11865662e-01f, 1.93311330e-02f, 1.69411466e-01f, 1.89843401e-01f, 1.09606631e-01f, -1.46842748e-02f, 2.12839752e-01f, -5.28345332e-02f, 1.76860467e-02f, -7.23196641e-02f,
  4.32404317e-02f, 1.36742461e-02f, 1.79373485e-04f, -3.38792205e-02f, 7.35047832e-03f, -1.07839275e-02f, -1.47021592e-01f, 5.90745592e-04f, -5.93272485e-02f, -5.63318245e-02f,
  -7.99681339e-03f, 7.78438151e-02f, 3.51127684e-02f, -8.38354006e-02f, -2.97254957e-02f, -1.48066934e-02f, 7.61989355e-02f, -6.17940575e-02f, 1.79935694e-02f, -8.64949673e-02f,
  -7.16602653e-02f, -3.22777256e-02f, -7.34707639e-02f, -2.38087326e-02f, 1.28071338e-01f, -1.43461108e-01f, 4.88268696e-02f, 1.69611517e-02f, -7.10884631e-02f, -6.46897480e-02f,
  -2.05781534e-01f, 1.74094826e-01f, -4.34132479e-02f, -1.04394138e-01f, -6.90886155e-02f, 6.79037794e-02f, 7.36528039e-02f, -1.70893334e-02f, -2.93603018e-02f, 6.60161627e-03f,
  1.37833431e-02f, 7.94815570e-02f, 1.40002286e-02f, 1.50529528e-02f, -1.06817797e-01f, -4.79491726e-02f, -1.12639228e-03f, -9.50930268e-02f, 2.11812928e-02f, 1.04236066e-01f,
  2.46249419e-02f, 1.45354103e-02f, -7.94045180e-02f, 7.61130974e-02f, 1.72963999e-02f, -7.61925727e-02f, 1.90336078e-01f, 5.12925573e-02f, 1.14878565e-01f, -1.27796642e-02f,
  7.60199785e-01f, -1.49398129e-02f, -1.10859172e-02f, 2.54408777e-01f, 1.32039785e-01f, -2.17870134e-03f, -7.46092722e-02f, 1.01521574e-01f, 1.97022110e-01f, 1.55818850e-01f,
  3.69453034e-03f, 2.93827541e-02f, -5.02198637e-02f, -1.18097425e-01f, 1.26853716e-02f, -1.13161378e-01f, -4.34623510e-02f, -6.57184888e-03f, 6.30852133e-02f, 9.74440575e-02f,
  -2.58285739e-02f, -5.55840619e-02f, 1.59945816e-01f, 8.72346573e-03f, -1.71698391e-01f, -2.09007729e-02f, -8.44396502e-02f, -1.51023477e-01f, -2.75380254e-01f, -1.83725402e-01f,
  -1.15736619e-01f, 4.41381745e-02f, 3.07736635e-01f, 1.65491000e-01f, 1.31463498e-01f, 1.74300045e-01f, 2.15869144e-01f, 6.21786937e-02f, -1.14626810e-02f, 8.07211027e-02f,
  7.73596019e-02f, 3.20778377e-02f, -4.66592722e-02f, -4.15604450e-02f, 4.37008888e-02f, 8.39195177e-02f, -7.70540312e-02f, -1.31394893e-01f, -1.72904074e-01f, -2.02528816e-02f,
  1.24643696e-02f, -5.24372384e-02f, 2.96124327e-03f, -7.93689489e-02f, -1.36471689e-01f, 5.80090694e-02f, -2.64956970e-02f, 2.60016862e-02f, -2.49199420e-02f, 4.69471700e-02f,
  -4.98771332e-02f, -7.14273527e-02f, 8.23621377e-02f, -8.62546265e-02f, -3.75386477e-02f, -2.45276112e-02f, -1.93662699e-02f, -1.81033716e-01f, -5.01034558e-02f, 3.51484143e-03f,
  -2.69128233e-02f, 7.94970896e-03f, 2.48966366e-02f, 8.31503198e-02f, 7.49932304e-02f, 2.65978910e-02f, -3.04921810e-02f, -6.94156950e-03f, -2.05733418e-03f, -3.97732295e-02f,
  1.03605449e-01f, -1.02478936e-01f, -1.34055540e-02f, -1.30237877e-01f, -2.38207802e-02f, -5.14706261e-02f, -5.30442558e-02f, -7.41288066e-02f, -4.25445810e-02f, -9.46181566e-02f,
  -5.59271462e-02f, 1.65296048e-01f, 2.35321388e-01f, -2.80845296e-02f, 5.85789569e-02f, 2.92473007e-02f, 7.23564029e-02f, 8.44920203e-02f, -2.79054642e-02f, -5.97955883e-02f,
  -8.76011774e-02f, 2.15294063e-02f, 1.24148661e-02f, -3.00440262e-03f, 1.43401250e-01f, 8.91357213e-02f, 1.31394356e-01f, 2.57354975e-02f, -1.28701836e-01f, -2.21642498e-02f,
  1.09264977e-01f, 1.03436559e-01f, 1.25190049e-01f, 1.60154551e-01f, 5.38723283e-02f, 3.33174393e-02f, 1.05310127e-01f, 1.00937478e-01f, 4.04235236e-02f, 1.42436862e-01f,
  -2.03066930e-01f, -6.20994493e-02f, 1.88688457e-01f, 1.00040294e-01f, 2.66703404e-02f, -4.36443873e-02f, -1.06318062e-02f, -3.15668508e-02f, 8.43140632e-02f, 5.26502877e-02f,
  1.95760354e-01f, 3.30802351e-01f, 3.36339056e-01f, 2.58056283e-01f, 1.85744837e-01f, 9.40911621e-02f, 4.30469625e-02f, 2.03341573e-01f, 1.84310526e-01f, 9.29213092e-02f,
  2.19906177e-02f, -4.66321632e-02f, -7.73709640e-02f, 4.75140326e-02f, 3.58226039e-02f, 9.78021026e-02f, 1.38095722e-01f, -8.25316384e-02f, 9.53185633e-02f, 6.80497661e-02f,
  5.55336416e-01f, -8.64581391e-03f, 1.96436763e-01f, 8.33639726e-02f, 4.49341442e-03f, -1.36121541e-01f, 1.20097816e-01f, 1.01284403e-02f, -4.77373675e-02f, 4.41870764e-02f,
  -4.84428406e-02f, 1.46153308e-02f, 1.38958991e-02f, -5.04107065e-02f, -6.91059679e-02f, -1.13187343e-01f, -1.95021853e-01f, 8.65478963e-02f, 2.66901422e-02f, 1.36590078e-01f,
  -7.30668604e-02f, 1.19560715e-02f, 1.08260952e-01f, 1.20011024e-01f, -2.38228980e-02f, 8.58015269e-02f, 9.29523483e-02f, -5.97258434e-02f, 4.04347628e-02f, -8.28990415e-02f,
  2.68065780e-01f, 5.25993817e-02f, 1.30291447e-01f, 1.11969687e-01f, -1.24665521e-01f, 4.39436845e-02f, -3.24982367e-02f, -7.22133368e-02f, 6.60102591e-02f, -2.04924464e-01f,
  4.22157384e-02f, 4.06032205e-02f, 1.34219825e-01f, 1.19271703e-01f, 1.23642147e-01f, 7.60010257e-02f, -3.05917580e-02f, 4.50045355e-02f, 3.14394198e-02f, -9.10163205e-03f,
  -3.11118830e-02f, -2.96594203e-03f, -4.10281755e-02f, 1.50050474e-02f, -1.82047561e-02f, 1.62971038e-02f, 5.45806326e-02f, 2.16875523e-02f, -4.60890718e-02f, -1.30919106e-02f,
  3.46565157e-01f, 2.75117427e-01f, 9.06304568e-02f, -8.82106423e-02f, -1.09573439e-01f, -1.36116311e-01f, 8.66076499e-02f, -7.52492342e-03f, 5.18552540e-03f, 5.73981144e-02f,
  -5.18350787e-02f, -1.20118313e-01f, -1.91084146e-01f, -1.96451977e-01f, -1.47263408e-01f, -1.28061399e-01f, -1.28135771e-01f, -4.33265753e-02f, 1.15024231e-01f, 7.14248568e-02f,
  -8.05836078e-03f, -4.77385484e-02f, 7.72080421e-02f, 1.61043152e-01f, 2.92398017e-02f, 1.80796608e-01f, 9.92625058e-02f, -7.11868750e-03f, 3.98802571e-02f, 1.66241340e-02f,
  -6.45993292e-01f, 3.76873523e-01f, -3.16202730e-01f, -2.06438124e-01f, 3.23768854e-01f, 1.63479745e-01f, 2.92428315e-01f, -1.45000085e-01f, -5.17646931e-02f, 1.16243377e-01f,
  2.53578395e-01f, 1.22253336e-01f, 5.18321581e-02f, 9.15918052e-02f, -1.61334455e-01f, 1.95241645e-01f, 1.47840619e-01f, -2.89454103e-01f, -4.23340321e-01f, -2.55542714e-02f,
  3.41248512e-01f, -1.37425646e-01f, -4.23395336e-01f, -1.66883901e-01f, 1.37048125e-01f, -5.66381924e-02f, -1.28715992e-01f, 8.16488340e-02f, 1.88751727e-01f, 2.86717534e-01f,
  -1.52803704e-01f, -2.31447548e-01f, 4.14037630e-02f, 1.17963336e-01f, -2.08940934e-02f, -2.47690231e-01f, 3.95539775e-02f, -4.33105007e-02f, 2.14817733e-01f, -8.91417488e-02f,
  5.46094179e-02f, 1.61220640e-01f, 2.25968108e-01f, -3.96015570e-02f, -2.06271559e-01f, -1.09851986e-01f, -2.67744571e-01f, -2.47772843e-01f, -3.71764868e-01f, -3.33065331e-01f,
  4.34219569e-01f, 2.56649911e-01f, -2.34495550e-01f, -7.25173801e-02f, -1.19719066e-01f, -7.75838420e-02f, -1.23099267e-01f, -3.01066130e-01f, -3.39107007e-01f, -3.92280877e-01f,
  2.94805467e-02f, 4.63679200e-03f, 8.66466016e-02f, -1.43125001e-02f, -4.13326547e-02f, 7.73561448e-02f, 1.50156245e-01f, 1.46817103e-01f, 8.14848468e-02f, -8.33073035e-02f,
  1.14389554e-01f, -3.70961684e-03f, 3.48448404e-03f, -1.25991721e-02f, -3.63261364e-02f, 8.96325186e-02f, 9.91065055e-02f, -7.82181397e-02f, -8.98465663e-02f, -1.51600400e-02f,
  2.71291882e-02f, -9.37830061e-02f, 4.15322632e-02f, 7.10828379e-02f, 1.74829185e-01f, 4.79392335e-02f, 5.67537285e-02f, -8.40250105e-02f, -8.92922953e-02f, -3.78825217e-02f,
  -4.51982856e-01f, 3.12952176e-02f, -1.47692278e-01f, 1.32046148e-01f, 1.34878665e-01f, -9.52036232e-02f, 1.11306787e-01f, 6.08958527e-02f, 1.87676176e-01f, -1.04752839e-01f,
  -7.92293772e-02f, -3.40124406e-02f, -8.77015963e-02f, 7.88030475e-02f, -1.45903885e-01f, -1.76728684e-02f, 3.35064940e-02f, 5.87674342e-02f, 1.16976030e-01f, -3.45047051e-03f,
  -7.56825805e-02f, -1.80130884e-01f, -2.32743308e-01f, -1.35441050e-01f, -6.17034249e-02f, -1.06855623e-01f, -1.63665116e-01f, -1.50132179e-01f, -2.97081113e-01f, -4.76282001e-01f,
  -5.83560467e-01f, 2.56371070e-02f, 2.08060339e-01f, -5.61958909e-01f, -1.70893818e-02f, 5.61945699e-02f, 6.77944347e-02f, -2.86495406e-02f, -6.46292567e-02f, 4.39789109e-02f,
  2.19880372e-01f, -9.32141840e-02f, -4.97064888e-02f, -4.43516970e-02f, -2.22954154e-01f, 2.11627595e-02f, -1.85199693e-01f, -1.58270985e-01f, -8.24382305e-02f, -7.29488432e-02f,
  -8.78611133e-02f, -3.31541598e-01f, -3.87760580e-01f, -1.63693443e-01f, -3.74545872e-01f, -4.17745620e-01f, -1.26779899e-01f, -3.03502113e-01f, -5.68187088e-02f, -3.49293470e-01f,
  2.21628934e-01f, 5.35024181e-02f, 3.54599088e-01f, -5.42144179e-02f, 8.70424435e-02f, -5.15054166e-02f, -6.46070158e-03f, 8.15392211e-02f, 1.08368076e-01f, -2.96858251e-02f,
  -7.36150369e-02f, 1.35030657e-01f, -6.62148669e-02f, -3.41630802e-02f, 2.74118123e-04f, -1.09839790e-01f, 3.62632014e-02f, -9.56853256e-02f, -1.13188989e-01f, 1.54001683e-01f,
  -1.42778948e-01f, -1.75418630e-01f, -1.64450556e-01f, 3.27269249e-02f, 5.42252064e-02f, -2.46354014e-01f, -9.31867138e-02f, -1.74377739e-01f, -1.26061052e-01f, -3.95154953e-01f,
  2.09864639e-02f, 8.99091959e-02f, 1.74446121e-01f, 1.96533445e-02f, -1.38355672e-01f, 8.33430812e-02f, -7.66515061e-02f, -1.35805428e-01f, -9.37608778e-02f, -6.68778718e-02f,
  9.11972970e-02f, -1.17974430e-02f, 5.31020910e-02f, -1.83181554e-01f, -6.73062876e-02f, -1.39619902e-01f, -5.05433306e-02f, -2.97181066e-02f, -8.97716358e-02f, -3.53448763e-02f,
  -7.68892467e-02f, 2.68080831e-02f, -5.08892424e-02f, -1.58585623e-01f, -3.01196985e-02f, -1.11133888e-01f, 1.26585802e-02f, 8.10590014e-02f, -9.09136888e-03f, 1.09293245e-01f,
  -1.98865741e-01f, 1.86495572e-01f, -6.26078248e-02f, 1.81764513e-01f, 7.63813406e-02f, 5.43780588e-02f, 3.22511373e-03f, 9.30332020e-02f, 1.51186809e-02f, 6.36894032e-02f,
  1.63990408e-01f, -1.43828899e-01f, -7.01926202e-02f, 5.87785989e-02f, 3.57370712e-02f, 1.89792532e-02f, -8.96116644e-02f, -1.64570585e-01f, -5.60810342e-02f, -2.28051886e-01f,
  -3.25818479e-01f, -2.65797824e-01f, -4.17644352e-01f, -3.03904265e-01f, -2.46286914e-01f, -3.27037781e-01f, -2.35464767e-01f, -1.23633169e-01f, -1.23854920e-01f, -5.81499517e-01f,
  6.95485771e-01f, -4.45368230e-01f, -3.89413118e-01f, -3.93586271e-02f, -1.99179754e-01f, -1.09861955e-01f, -4.11457509e-01f, -2.44542789e-02f, 3.87186222e-02f, -4.38020140e-01f,
  2.94676106e-02f, 4.63164210e-01f, 3.27695906e-01f, 2.24682689e-01f, 2.49700770e-01f, -5.62569857e-01f, -3.54146868e-01f, 2.64082074e-01f, 4.87383366e-01f, 6.69525340e-02f,
  -1.58003598e-01f, -4.93678041e-02f, 3.63946766e-01f, 5.58768287e-02f, -2.74651408e-01f, 3.06933280e-02f, -3.95075142e-01f, -1.13769710e-01f, -2.26501450e-01f, -4.90828097e-01f,
  -3.16210806e-01f, 8.07705373e-02f, 1.78511262e-01f, 1.98173836e-01f, -5.76066375e-02f, -5.06489119e-03f, -7.21929297e-02f, 5.21233641e-02f, 2.49775555e-02f, 5.40002994e-03f,
  -1.66242570e-02f, 7.04693347e-02f, 7.04739094e-02f, -6.08726405e-02f, -1.55681074e-01f, 4.38083783e-02f, -1.26375154e-01f, 7.92338401e-02f, 9.54729989e-02f, -1.23394281e-01f,
  -4.41811197e-02f, 2.98235752e-02f, -2.18568835e-02f, -1.69617325e-01f, 2.17104089e-02f, 2.52889961e-01f, -2.25944668e-01f, -3.17340121e-02f, 6.17776997e-02f, -4.97439206e-01f,
  6.15612939e-02f, -1.92759652e-02f, 4.50402871e-02f, 5.33329546e-02f, 3.55240167e-03f, 4.51174527e-02f, -1.15513625e-02f, 4.14195377e-03f, 1.11924959e-02f, -1.04357637e-02f,
  -1.42940658e-03f, -6.54666275e-02f, 6.53204769e-02f, -9.11033824e-02f, -2.09198166e-02f, 1.61796566e-02f, 2.73038913e-02f, -3.55084389e-02f, 1.99850630e-02f, 6.76924214e-02f,
  1.08762130e-01f, 3.17208953e-02f, -8.76204390e-03f, 6.59543201e-02f, -1.76243356e-03f, -8.99034645e-03f, 7.87956119e-02f, 5.19044735e-02f, 5.27536087e-02f, 5.98557554e-02f,
  -7.94068053e-02f, 3.01097691e-01f, -1.32515848e-01f, 1.07682176e-01f, -4.43923892e-03f, 6.21434450e-02f, -1.27348276e-02f, 2.43762901e-04f, 9.84522253e-02f, 3.71281318e-02f,
  1.39217805e-02f, -2.07008887e-02f, -7.33232647e-02f, -1.46587238e-01f, -5.00161946e-02f, 6.31849421e-03f, -1.07573956e-01f, 8.68015550e-03f, 5.14755249e-02f, -1.32598832e-01f,
  -9.63883027e-02f, 2.99078710e-02f, 5.34209497e-02f, -6.94231316e-02f, -1.33440942e-02f, 1.83545306e-01f, -2.04303265e-01f, -1.78628936e-01f, 1.35848224e-01f, -4.15816873e-01f,
  6.29332662e-01f, 4.40084219e-01f, -8.23721409e-01f, 5.47200382e-01f, -3.27659279e-01f, -4.64963406e-01f, -1.70827389e-01f, 2.51701057e-01f, 5.47586024e-01f, 3.25936764e-01f,
  -2.84719262e-02f, -9.07733887e-02f, -1.36280030e-01f, -2.12927729e-01f, -4.84041393e-01f, -1.12975784e-01f, -3.08322847e-01f, -6.11673832e-01f, -8.87531221e-01f, -3.86651427e-01f,
  1.34929540e-02f, 1.44552499e-01f, 5.72430789e-02f, -2.05687180e-01f, 1.70747787e-01f, -1.65629685e-01f, 1.16899319e-01f, -1.73127621e-01f, -3.97786260e-01f, 1.03161260e-01f,
  -3.89211804e-01f, -1.52530625e-01f, -4.10037518e-01f, 1.53926954e-01f, -5.23222424e-02f, -3.53191048e-02f, -3.95614654e-03f, -8.33739042e-02f, 6.91265240e-02f, 1.86532512e-02f,
  -9.88763496e-02f, -1.37954444e-01f, -1.83700398e-01f, -5.92314266e-02f, -1.59242883e-01f, -1.26492023e-01f, -3.69746573e-02f, -1.65983677e-01f, -9.67876539e-02f, 4.44543920e-03f,
  2.13753730e-02f, -3.64985168e-01f, -3.70750755e-01f, -6.27185255e-02f, -3.43497127e-01f, -3.28154892e-01f, -2.01889068e-01f, -2.21028119e-01f, -3.37457001e-01f, 5.37302792e-01f,
  1.74615383e-01f, -2.51739994e-02f, -6.24506287e-02f, 1.63410723e-01f, 1.73598677e-01f, -8.33541825e-02f, -1.01445513e-02f, 3.40254642e-02f, -9.19831321e-02f, 6.30657896e-02f,
  1.96871478e-02f, -1.50863198e-03f, -7.24389479e-02f, 7.03001991e-02f, -1.61078677e-01f, -1.20658830e-01f, -3.45573016e-02f, 2.06747055e-02f, 3.45523022e-02f, 1.30404169e-02f,
  -8.76392871e-02f, -2.61950176e-02f, 3.65239643e-02f, -4.99296263e-02f, -4.26417291e-02f, -9.53136981e-02f, -1.03723355e-01f, 2.13978924e-02f, 3.12713087e-02f, 4.77633774e-02f,
  3.73302609e-01f, -3.89799058e-01f, 2.24183440e-01f, -9.58928391e-02f, -1.20348006e-01f, -9.92936343e-02f, 1.12076864e-01f, 6.28936440e-02f, -1.80165861e-02f, 6.10441454e-02f,
  -2.06542313e-01f, 6.69336468e-02f, 1.70983020e-02f, -2.38600932e-02f, -6.82559088e-02f, -7.20349103e-02f, 8.07191432e-02f, -7.95737803e-02f, -6.43677637e-02f, 1.11605339e-01f,
  3.05059284e-01f, 1.84656888e-01f, 7.08053857e-02f, 1.89768881e-01f, 6.26134872e-02f, -1.74722895e-01f, -6.57278225e-02f, -2.21274309e-02f, -2.41257533e-01f, 5.69987476e-01f,
  -6.63814723e-01f, 6.79138526e-02f, 9.31305289e-02f, -8.76832474e-03f, -9.30616036e-02f, -1.88107833e-01f, -5.17765321e-02f, -1.61776587e-01f, -4.74228337e-03f, 6.56008124e-02f,
  1.65558264e-01f, 1.01977207e-01f, 1.20454289e-01f, -3.57516017e-03f, -8.09935406e-02f, -3.99773605e-02f, -9.23208073e-02f, -2.49898955e-01f, -2.90138274e-01f, -2.06565455e-01f,
  -8.07006285e-02f, -1.79768205e-01f, -3.17608744e-01f, -1.75084874e-01f, 1.14269577e-01f, 6.65224344e-02f, 1.12685293e-01f, -6.83137476e-02f, 2.26923097e-02f, 1.46886021e-01f,
  6.15192294e-01f, -9.07419343e-03f, -5.02653345e-02f, -7.40005150e-02f, 7.64743462e-02f, -8.31443910e-03f, 9.06299055e-03f, -4.03040312e-02f, -2.42968034e-02f, 6.65424541e-02f,
  1.77015376e-03f, -2.54522562e-02f, -8.67733061e-02f, 9.37393531e-02f, -4.62348908e-02f, 5.44575304e-02f, 6.62471950e-02f, 1.60366818e-01f, 1.32214487e-01f, 1.77097321e-01f,
  -8.82926583e-03f, -5.45954518e-02f, 1.58000261e-01f, 1.02093212e-01f, 4.40685898e-02f, -2.13185679e-02f, 1.76109865e-01f, 1.18498616e-01f, 1.14407279e-01f, 1.54027030e-01f,
  -1.67769447e-01f, 1.10463522e-01f, 6.84129074e-02f, 3.47505547e-02f, 4.21420019e-03f, 3.54595296e-02f, 4.06759307e-02f, 5.68197928e-02f, -2.39850208e-02f, -1.83882769e-02f,
  -8.12381785e-03f, 1.64952129e-02f, -4.17274572e-02f, 2.51738150e-02f, 3.32524218e-02f, 4.05748747e-02f, -8.01279023e-02f, 8.83326903e-02f, 8.90407637e-02f, 3.69511582e-02f,
  3.01037543e-02f, -2.32502595e-02f, -1.07868202e-02f, 4.02666479e-02f, 1.02900192e-01f, 1.06120028e-01f, -1.18494621e-02f, 3.22955772e-02f, -1.22638606e-02f, -6.68521002e-02f,
  5.68390489e-01f, -2.51314014e-01f, 4.27761599e-02f, 4.26670872e-02f, -9.74137858e-02f, 1.30255911e-02f, -3.84254344e-02f, 2.23240033e-02f, -7.18810335e-02f, 4.03319374e-02f,
  1.18730357e-02f, -1.32195219e-01f, -4.76323441e-02f, 5.18260524e-02f, -1.63611770e-01f, -8.07172880e-02f, 7.57917985e-02f, 5.61261140e-02f, 5.59918471e-02f, 1.80844963e-01f,
  6.44698516e-02f, 8.99898484e-02f, 1.35617927e-01f, 1.99033812e-01f, -8.49792957e-02f, 7.34718293e-02f, 1.10716857e-01f, 1.35439962e-01f, 1.04338750e-01f, 6.56618085e-03f,
  2.75458135e-02f, -1.17076449e-01f, -6.43789172e-01f, -4.68597203e-01f, -4.87962127e-01f, -3.26512009e-01f, -2.83972323e-01f, -1.31578460e-01f, -3.41656715e-01f, -3.37257117e-01f,
  1.28952101e-01f, 5.87817609e-01f, 2.88380742e-01f, 2.95808315e-01f, 4.34822202e-01f, -2.32212022e-01f, -5.19627631e-01f, -5.08349277e-02f, 3.14984113e-01f, 2.56944299e-01f,
  -5.75385848e-03f, -1.51917532e-01f, 4.30302955e-02f, -3.67331281e-02f, -1.91154763e-01f, 1.67668566e-01f, -5.53958118e-01f, -2.94856578e-01f, -8.42543691e-02f, -4.58606184e-01f,
  4.14171189e-01f, -4.00743961e-01f, -2.17701852e-01f, 6.83958828e-03f, -8.00680220e-02f, 1.05623625e-01f, 1.12756886e-01f, -2.61118710e-01f, 6.45861700e-02f, -1.64324388e-01f,
  -6.02519698e-02f, 2.76713669e-02f, 7.15605915e-02f, 2.89991777e-03f, -2.28792522e-02f, 7.28804916e-02f, -1.08463831e-01f, -1.70043245e-01f, -9.40137804e-02f, 1.96912661e-02f,
  -8.41061771e-03f, -1.59649029e-01f, -1.21341765e-01f, -6.69872686e-02f, -5.47536090e-02f, -7.04071894e-02f, -1.46650393e-02f, -1.58445731e-01f, -6.46268278e-02f, -1.77569702e-01f,
  -1.26878053e-01f, -2.32766494e-02f, 6.23312220e-02f, -9.88123566e-02f, 6.85357749e-02f, 6.40982995e-03f, 1.63292214e-02f, 5.00031225e-02f, -4.71772766e-03f, 1.39369771e-01f,
  2.79550049e-02f, -6.62913993e-02f, 1.08376473e-01f, -2.65017245e-02f, -6.92845955e-02f, -1.15423575e-01f, -2.94434093e-03f, -9.00535472e-03f, 5.62354550e-02f, -1.36702344e-01f,
  -3.51757668e-02f, -5.17701954e-02f, -8.97325724e-02f, 6.10993356e-02f, -1.26141071e-01f, -2.71314979e-02f, -1.12486549e-01f, 1.16764113e-01f, 2.45486293e-02f, -1.11667305e-01f,
  5.68909049e-01f, -2.09196508e-01f, 2.19531566e-01f, 7.33275563e-02f, -1.40429303e-01f, -1.66131034e-01f, -9.86397043e-02f, -6.45965114e-02f, -6.03338741e-02f, 7.39551662e-03f,
  -9.32858288e-02f, 1.20308049e-01f, 9.10807308e-03f, 1.42269321e-02f, 2.95533277e-02f, 6.20900095e-02f, 1.02410309e-01f, 6.70814812e-02f, -1.32847264e-01f, -6.79209605e-02f,
  -6.58133104e-02f, 1.07858461e-04f, 2.83579707e-01f, 7.21167400e-02f, -9.01772827e-03f, 1.77941397e-01f, 1.77192286e-01f, 1.32662714e-01f, 1.87343627e-01f, 3.13897252e-01f,
  3.67206447e-02f, -2.44497508e-01f, 1.75754666e-01f, 1.67603686e-01f, -3.28154042e-02f, -2.45903730e-01f, -5.23571789e-01f, -5.91983236e-02f, 1.89079776e-01f, -2.35520825e-01f,
  -1.39420837e-01f, -2.67268628e-01f, -6.87185079e-02f, -2.09648252e-01f, -4.77510929e-01f, -4.33805287e-01f, -1.82363868e-01f, -2.83859938e-01f, -3.48330528e-01f, -3.22069734e-01f,
  -2.49467000e-01f, -2.77716935e-01f, -7.06086010e-02f, -4.60968427e-02f, 3.59212548e-01f, 1.19083926e-01f, 2.42884651e-01f, 1.59369677e-01f, -7.36208260e-02f, 2.28978157e-01f,
  -2.57998984e-02f, 4.02270943e-01f, -7.65955523e-02f, 2.48397235e-02f, -9.26672444e-02f, -3.73649076e-02f, -1.38500243e-01f, 9.97249037e-02f, -5.56349307e-02f, 6.69932365e-02f,
  5.57354726e-02f, 4.52329665e-02f, 8.81648734e-02f, -6.82349317e-03f, -1.08610421e-01f, 6.66033477e-02f, 2.20862683e-02f, -1.18155042e-02f, -1.15142249e-01f, 3.04956641e-03f,
  -4.20093328e-01f, -1.89618304e-01f, 1.68797374e-02f, 1.78526044e-01f, 2.33536318e-01f, -1.94345608e-01f, 2.62890249e-01f, 2.67897755e-01f, 1.02653518e-01f, 2.01929733e-01f,
  4.50631008e-02f, -4.02168781e-02f, 4.97838948e-03f, 1.52442791e-02f, -1.15301222e-01f, 1.48349404e-01f, 4.59172018e-02f, -8.38959217e-02f, 7.92977307e-03f, -1.01208035e-02f,
  7.42276907e-02f, -6.21542148e-02f, 1.10279717e-01f, 9.25057828e-02f, 7.93519020e-02f, -8.18242729e-02f, -4.55383062e-02f, -1.01961710e-01f, -3.38783227e-02f, -2.41706781e-02f,
  -8.18200707e-02f, 8.85781124e-02f, -8.27453434e-02f, -8.17715377e-03f, -1.62707176e-02f, 3.72981690e-02f, -3.09959203e-02f, -1.89335361e-01f, -9.44309756e-02f, 3.93314920e-02f,
  -4.45291921e-02f, -2.46043518e-01f, -3.97130996e-02f, -6.20098412e-02f, -8.97913873e-02f, -1.92532931e-02f, -6.93322644e-02f, -1.94961146e-01f, 1.27128556e-01f, -1.98595911e-01f,
  -2.18930021e-02f, -1.15553245e-01f, -8.83537997e-03f, -1.95455030e-01f, -2.04036653e-01f, 1.02002665e-01f, -5.88776886e-01f, -2.48374254e-01f, -1.51454896e-01f, -6.15820624e-02f,
  -3.10166299e-01f, -3.41499805e-01f, -4.54875708e-01f, -1.99335203e-01f, -4.89767864e-02f, -4.28632468e-01f, -2.11392388e-01f, 1.09236902e-02f, -3.86412919e-01f, -6.37139142e-01f,
  5.53040683e-01f, 1.66257992e-01f, -1.22455515e-01f, 1.44643843e-01f, -1.13833688e-01f, -2.07518697e-01f, -4.17270601e-01f, -2.78365970e-01f, -6.65920153e-02f, 1.14225700e-01f,
  1.50241092e-01f, 7.21349195e-02f, -4.75824811e-03f, -1.42968884e-02f, -1.68564707e-01f, -9.31689441e-02f, 3.13917175e-02f, 2.22321674e-02f, -1.35651812e-01f, 1.50153890e-01f,
  2.15453044e-01f, 8.64242911e-02f, 1.03376880e-02f, -1.33479536e-01f, 2.90623546e-01f, 6.12014011e-02f, -7.97214825e-03f, 1.89089715e-01f, 1.68583453e-01f, 5.45388341e-01f,
  4.09574389e-01f, -3.87348197e-02f, -1.08095072e-01f, 1.43477827e-01f, -9.04733606e-04f, 1.55089676e-01f, 4.18231599e-02f, -5.00543900e-02f, 4.47235024e-03f, 6.33146018e-02f,
  1.38249710e-01f, 1.64663106e-01f, 4.36583795e-02f, -7.54307657e-02f, 2.94248643e-03f, -1.18904114e-01f, 4.19353321e-02f, -6.36794493e-02f, -1.22851677e-01f, 8.84740129e-02f,
  1.41357347e-01f, 1.03636533e-01f, -9.86018926e-02f, -2.60508865e-01f, -1.52563557e-01f, 3.42916884e-02f, 1.92204192e-02f, 1.66060366e-02f, -2.08553493e-01f, 1.94309697e-01f,
  1.29127666e-01f, 5.31141199e-02f, 1.19456463e-01f, 4.52306159e-02f, 4.89975065e-02f, -8.31972733e-02f, 7.66098425e-02f, -1.12502917e-03f, -2.02160887e-03f, 2.14095321e-02f,
  -2.23898739e-02f, 4.43014279e-02f, -1.89005323e-02f, -2.28536446e-02f, 6.21657027e-03f, 8.06500688e-02f, 4.45011184e-02f, 3.15044634e-02f, -1.07298009e-01f, -3.05149741e-02f,
  -1.61428358e-02f, -5.17798215e-02f, -4.11000624e-02f, -3.03849466e-02f, 6.14538975e-02f, 5.29312156e-02f, 7.92848840e-02f, 1.07045352e-01f, 7.91381449e-02f, 2.49133296e-02f,
  -2.25283921e-01f, -4.50973898e-01f, 2.44720027e-01f, 2.72304546e-02f, 8.77512470e-02f, -1.06679097e-01f, 1.02964099e-02f, -4.11240011e-02f, -1.36970375e-02f, -5.28331436e-02f,
  -9.27127805e-03f, -3.57554033e-02f, -1.27854556e-01f, -4.87645492e-02f, -1.04538612e-01f, 7.10229110e-03f, 1.73607375e-02f, 4.25412459e-03f, -8.98188651e-02f, 1.41798779e-02f,
  -1.33349597e-01f, -1.50976107e-01f, -1.86042383e-01f, -2.57459968e-01f, -6.52285144e-02f, -8.61387327e-02f, -9.50836986e-02f, 8.31420906e-03f, -6.55241013e-02f, -7.36974701e-02f,
  -8.19581509e-01f, -3.00716013e-01f, -1.97520927e-01f, 6.75064474e-02f, 3.48143816e-01f, 5.13622575e-02f, -2.17949048e-01f, -2.96991587e-01f, -1.11356892e-01f, -2.30208710e-01f,
  -5.24868183e-02f, 1.07196391e-01f, 1.65128544e-01f, 9.47336033e-02f, -1.61764145e-01f, 9.12382975e-02f, 3.80697131e-01f, 1.77606046e-01f, 1.65935054e-01f, 1.38129294e-01f,
  4.19460952e-01f, 2.74466962e-01f, -1.03214160e-01f, 7.90251195e-02f, 2.19521970e-01f, 3.00753325e-01f, 1.44434735e-01f, 2.50549376e-01f, 1.26288593e-01f, 3.12949866e-01f,
  -5.56592345e-01f, -5.62178135e-01f, 2.91662008e-01f, 1.01599731e-01f, 1.62297130e-01f, -2.89245546e-02f, -4.41042222e-02f, 9.79848579e-02f, 8.21561664e-02f, 2.85312235e-02f,
  1.13722406e-01f, -9.77948755e-02f, 1.46246523e-01f, 2.08380371e-02f, -3.12596411e-02f, -1.27841711e-01f, 5.84006198e-02f, -5.41106574e-02f, -1.50572911e-01f, -8.65355507e-02f,
  4.54471081e-01f, 2.16063038e-01f, -2.09400669e-01f, -4.65071946e-02f, -1.59202725e-01f, 2.17327386e-01f, -1.20060988e-01f, -2.42250159e-01f, -3.50512415e-01f, -2.83577740e-01f,
  -5.82607053e-02f, -6.16086759e-02f, -2.62098368e-02f, -7.62555301e-02f, -3.55890915e-02f, -3.89225483e-02f, -5.37222400e-02f, -1.11345671e-01f, 4.30553146e-02f, 9.74946469e-03f,
  -3.32882218e-02f, -3.03227622e-02f, -8.35302398e-02f, -1.75681189e-01f, -3.39049962e-03f, 1.07325852e-01f, -7.75335310e-03f, -3.08924131e-02f, -1.21361725e-01f, -7.13448748e-02f,
  -1.00468650e-01f, -8.71842876e-02f, -6.90179840e-02f, 4.26013917e-02f, 1.10659160e-01f, -1.72661096e-01f, -8.34142324e-03f, 5.80349565e-02f, -7.80405998e-02f, -1.39872590e-02f,
  -8.46897662e-02f, 4.00481671e-01f, -1.68813795e-01f, -1.66819617e-01f, -7.88365230e-02f, 3.18850763e-02f, -1.60446446e-02f, -8.88621360e-02f, -2.33544201e-01f, -9.93540660e-02f,
  -2.88310379e-01f, -3.90658736e-01f, -1.49771661e-01f, 1.29771352e-01f, 5.15277646e-02f, -1.78289637e-01f, -2.42579542e-02f, 8.55646208e-02f, 8.17938000e-02f, 2.63925437e-02f,
  7.53243044e-02f, -7.42853731e-02f, -1.79998130e-01f, -6.05006032e-02f, -5.83652547e-03f, 9.60425064e-02f, -5.67526184e-02f, -1.49484366e-01f, -1.84545264e-01f, -2.79035717e-01f,
  1.45055637e-01f, 8.38668495e-02f, 1.13926053e-01f, 1.44376025e-01f, -6.56529516e-02f, -4.16312963e-01f, -5.72041273e-01f, -2.64728159e-01f, 1.09621331e-01f, -6.32935092e-02f,
  -4.56318632e-02f, 5.19772246e-03f, 1.11882009e-01f, -6.76454157e-02f, -2.55128354e-01f, -3.40382271e-02f, 1.09119281e-01f, -2.75399089e-02f, -2.93285310e-01f, -2.74496645e-01f,
  -1.70432866e-01f, 1.10623077e-01f, 8.89967829e-02f, -8.20275247e-02f, 2.35224009e-01f, 9.35930908e-02f, 2.96272725e-01f, 1.71729088e-01f, 1.05706967e-01f, 3.61172378e-01f,
  2.26011544e-01f, 2.88565755e-02f, -8.61176252e-02f, 6.45197555e-02f, 1.31945565e-01f, 4.17348854e-02f, -9.04298872e-02f, 2.04821900e-01f, -3.27259712e-02f, 1.22629412e-01f,
  -6.07250491e-03f, -7.72357807e-02f, 1.19122127e-02f, -8.94790441e-02f, -4.88221012e-02f, -2.91521698e-01f, 1.05278239e-01f, -2.23571789e-02f, -3.35437283e-02f, -1.03146061e-01f,
  -2.22075328e-01f, -9.02919397e-02f, -1.35818094e-01f, -1.09884337e-01f, 2.63953898e-02f, 7.91170150e-02f, -7.11740479e-02f, 3.13472711e-02f, 3.78810056e-02f, 1.94039732e-01f,
  -2.61245929e-02f, -6.62186667e-02f, 2.77772862e-02f, 5.33854179e-02f, 3.41469646e-02f, -1.30411587e-03f, 1.10776760e-01f, 1.25052417e-02f, -9.48040858e-02f, -8.98504443e-03f,
  1.19817704e-02f, 1.73423037e-01f, 4.58438098e-02f, 3.57910767e-02f, 8.37566555e-02f, 5.96859008e-02f, -5.82525097e-02f, 6.44000322e-02f, -1.94600485e-02f, 6.95742294e-02f,
  -7.69510493e-02f, -8.26078430e-02f, 1.82310835e-01f, -7.05244467e-02f, 3.92997861e-02f, 6.44498179e-03f, -2.53625847e-02f, 9.62072089e-02f, 1.16015524e-01f, 1.70681439e-02f,
  1.06217824e-01f, -1.80975229e-01f, 5.17729297e-02f, -1.07528679e-02f, 1.40057206e-01f, 9.46384743e-02f, 9.75080505e-02f, 1.12117091e-02f, 6.60321787e-02f, -1.21634334e-01f,
  -1.87022805e-01f, -2.87678726e-02f, 1.72392562e-01f, -3.15568820e-02f, -1.22565404e-01f, 9.40135028e-03f, -2.58456096e-02f, -4.45088856e-02f, -2.01071829e-01f, 1.56143401e-02f,
  3.62037751e-03f, -3.09606582e-01f, -2.38263652e-01f, -1.86784774e-01f, 4.24361601e-02f, -1.44457757e-01f, -5.75483497e-03f, -8.42379630e-02f, -2.08143055e-01f, -1.36591598e-01f,
  7.76798904e-01f, -5.19285858e-01f, -2.78546721e-01f, 1.85532838e-01f, 9.04571861e-02f, 1.86167017e-01f, 4.66640666e-02f, 1.30366370e-01f, 2.41710961e-01f, -5.90836257e-02f,
  -2.21326709e-01f, -3.01501472e-02f, -1.40262350e-01f, -8.47543627e-02f, 4.61705476e-02f, -1.67789266e-01f, -1.67139038e-01f, 6.54628277e-02f, 2.96071976e-01f, 1.44724876e-01f,
  3.30630392e-02f, 1.67380095e-01f, 2.07457244e-01f, -5.40175959e-02f, -3.16409528e-01f, -7.88851380e-02f, -3.60467643e-01f, -1.80310592e-01f, -2.12459818e-01f, -2.85625219e-01f,
  -2.88505465e-01f, -1.95466951e-01f, 1.13248460e-01f, -1.03991762e-01f, -7.91529939e-02f, 5.61503135e-02f, 2.78483611e-02f, -8.17354396e-02f, 5.51791042e-02f, -7.85951689e-02f,
  -1.51384681e-01f, 3.12518366e-02f, 3.28729525e-02f, -5.60732074e-02f, 1.41300395e-01f, 6.64295852e-02f, -1.15118854e-01f, 5.84189408e-02f, -4.87679429e-02f, -1.37104541e-01f,
  -1.59073532e-01f, -5.23033626e-02f, 3.21447328e-02f, -7.23460317e-02f, -1.25607818e-01f, 5.07381074e-02f, -9.48459879e-02f, -6.03385642e-02f, -5.27545698e-02f, 1.12887345e-01f,
  1.18551947e-01f, -6.88662156e-02f, -1.26054019e-01f, -2.28354633e-02f, 8.84609390e-03f, 8.43223184e-02f, 6.37842417e-02f, 5.49299195e-02f, -6.42831102e-02f, -8.71335268e-02f,
  7.29532316e-02f, -2.16373298e-02f, -9.41169560e-02f, -9.54833776e-02f, -8.49946216e-02f, -1.01113617e-01f, 7.22900331e-02f, -1.35873586e-01f, -1.17433913e-01f, 1.73282713e-01f,
  5.65647669e-02f, -9.49983820e-02f, 1.32334968e-02f, -1.39087364e-01f, -1.43078521e-01f, -1.04946084e-02f, -1.37417629e-01f, -5.81216849e-02f, 2.57404260e-02f, -1.35353655e-02f,
  8.95261988e-02f, 5.49848489e-02f, 5.24444797e-04f, 3.79751436e-02f, -5.62542491e-02f, -1.01723686e-01f, -6.48280308e-02f, -6.68580979e-02f, -8.61526430e-02f, -5.93059435e-02f,
  -8.42239037e-02f, -3.00071649e-02f, -1.37483597e-01f, -7.28857368e-02f, 1.16447471e-01f, 2.66224612e-02f, 1.86321028e-02f, 8.06909613e-03f, -1.91425849e-02f, -4.71254811e-02f,
  -1.61155269e-01f, 1.36688545e-01f, 2.95812279e-01f, 1.88420147e-01f, 5.77455498e-02f, 1.53722867e-01f, -4.22216766e-02f, 8.42931420e-02f, 1.52031884e-01f, 3.01952422e-01f,
  4.62287404e-02f, -1.29324779e-01f, -1.00466777e-02f, 2.49370411e-01f, 1.97052479e-01f, 1.37983531e-01f, -7.38784969e-02f, 1.81626990e-01f, 3.19040895e-01f, 1.66287512e-01f,
  2.62960583e-01f, 4.37400103e-01f, 2.82010555e-01f, 2.88681537e-01f, 7.55120218e-02f, 8.64569694e-02f, 1.62329972e-01f, 8.75661820e-02f, 8.54028575e-03f, 1.97427243e-01f,
  2.02012241e-01f, 1.98371112e-02f, -1.32850721e-01f, 9.17708576e-02f, 8.19149613e-02f, 1.56568632e-01f, 4.56320718e-02f, 4.23295908e-02f, 1.15624657e-02f, 1.90394759e-01f,
  2.55264249e-02f, -7.15476945e-02f, 3.97354327e-02f, -1.46078523e-02f, -1.06736407e-01f, -1.77018046e-01f, 4.18553054e-02f, -7.70371705e-02f, -2.16980442e-01f, -1.27291560e-01f,
  -4.61646616e-02f, -2.77708210e-02f, 1.01570431e-02f, -5.08374274e-02f, -1.98351368e-01f, -1.17612891e-01f, -7.10130632e-02f, -3.24439630e-02f, 9.98634696e-02f, 6.19309098e-02f,
  1.21101685e-01f, -4.51631993e-02f, -5.17897047e-02f, 1.23885386e-01f, 1.56288296e-01f, 2.95205396e-02f, -6.45370930e-02f, -6.03189394e-02f, 6.21761270e-02f, 7.28027597e-02f,
  2.54786074e-01f, 2.14744210e-01f, 2.28641272e-01f, 1.75288260e-01f, 1.25526473e-01f, 6.17651157e-02f, 2.95945853e-02f, 6.97066784e-02f, 1.58474103e-01f, -3.14801410e-02f,
  -3.67548391e-02f, 1.99966624e-01f, 2.20730435e-02f, 7.30553409e-04f, 1.56300083e-01f, -4.36662510e-03f, -7.30919838e-02f, -6.86878860e-02f, 6.74624816e-02f, -6.86256960e-02f,
  6.37293756e-02f, -1.79039165e-01f, -1.49401531e-01f, -2.88506746e-02f, -4.96984757e-02f, 1.09344855e-01f, 5.07118553e-02f, 9.62270796e-02f, -9.15567763e-03f, 1.99108534e-02f,
  3.64686809e-02f, 1.41423300e-01f, 1.45355433e-01f, 8.51313919e-02f, -2.05331698e-01f, -5.29438891e-02f, 2.01632664e-01f, -5.69587573e-02f, -2.51476586e-01f, -6.45786375e-02f,
  -1.24714104e-04f, 8.01218301e-03f, -5.72332330e-02f, -7.69151822e-02f, 2.91726813e-02f, -8.15495551e-02f, 7.92527050e-02f, 3.34834307e-02f, -1.17840024e-03f, 5.19189686e-02f,
  -7.01908171e-02f, 1.09208204e-01f, 1.39449790e-01f, 2.15009619e-02f, 5.03385672e-03f, 3.59514169e-02f, 5.55839539e-02f, -9.51031148e-02f, -7.88303837e-02f, -4.69494378e-03f,
  2.34352782e-01f, 5.45429647e-01f, -4.71967980e-02f, 2.20954582e-01f, 3.78557563e-01f, 5.83409108e-02f, 1.76276729e-01f, -1.88156471e-01f, 4.94313724e-02f, 1.29228905e-01f,
  2.82736450e-01f, 7.01214671e-02f, -1.32297069e-01f, -1.40674695e-01f, -1.43962592e-01f, -6.16679490e-02f, 5.97837556e-04f, -2.34578028e-01f, -2.69524843e-01f, 9.26004797e-02f,
  1.71508893e-01f, 1.48606777e-01f, -9.04221460e-02f, -1.87263936e-01f, 3.69114578e-01f, 8.50682929e-02f, 3.59377079e-02f, 4.30982351e-01f, 1.81830510e-01f, 2.12369844e-01f,
  2.88058639e-01f, 3.09655100e-01f, -4.52453494e-01f, 9.24938172e-02f, 1.29493669e-01f, -2.25502864e-01f, -1.17972516e-01f, -7.36339614e-02f, 1.43334949e-02f, -2.46855363e-01f,
  2.26550117e-01f, 1.02395609e-01f, 9.40078199e-02f, 2.24559344e-02f, 1.51128629e-02f, -5.54676279e-02f, -1.16419189e-01f, -2.37870127e-01f, -2.00390771e-01f, -6.63297772e-02f,
  1.44374922e-01f, 2.42358461e-01f, 1.55378625e-01f, -1.48379192e-01f, -1.16228446e-01f, 1.11933546e-02f, 7.92759135e-02f, -1.08360033e-02f, -2.62071073e-01f, -4.72065955e-02f,
  -9.86193344e-02f, 3.88507023e-02f, -1.20169530e-02f, -2.92647071e-03f, 4.92135622e-02f, -6.03931397e-02f, 2.57980414e-02f, 9.70850885e-02f, -1.14504369e-02f, 6.28864169e-02f,
  -7.58708194e-02f, -3.81877795e-02f, -1.21294223e-01f, -1.65064156e-01f, -1.29233882e-01f, -7.95537457e-02f, -4.61039133e-03f, -2.76918635e-02f, -1.69918593e-02f, -6.63197339e-02f,
  1.16383970e-01f, -4.66627292e-02f, -2.26337686e-02f, -5.10529540e-02f, -9.69853476e-02f, -9.63482857e-02f, -1.49500608e-01f, -1.30760625e-01f, -5.53469993e-02f, 1.51055604e-02f,
  -2.04744339e-01f, -2.59305179e-01f, -1.37924016e-01f, -3.06351911e-02f, 1.29608586e-01f, 2.55760979e-02f, 1.31606907e-01f, 3.45111713e-02f, 3.45210396e-02f, -3.72710638e-02f,
  6.61028642e-03f, -4.67261411e-02f, -4.22015898e-02f, -1.43128633e-01f, 1.43885203e-02f, -8.13322514e-02f, 1.16521515e-01f, 5.54327145e-02f, -1.30460113e-01f, 1.09889589e-01f,
  -7.46036768e-02f, -2.10050389e-01f, -1.07278600e-01f, -2.23597303e-01f, -1.99781761e-01f, -3.73563826e-01f, -1.80362210e-01f, -1.47174269e-01f, -2.91409254e-01f, -3.46920818e-01f,
  7.01394260e-01f, 5.52699745e-01f, 2.74931312e-01f, 3.35461825e-01f, 2.21895456e-01f, 2.64091671e-01f, 3.19864482e-01f, 3.01764458e-01f, 1.48931742e-01f, 1.82615533e-01f,
  1.80402741e-01f, 2.14788169e-01f, 2.43293494e-01f, 2.27762565e-01f, 2.37735420e-01f, 2.32909650e-01f, 1.38857156e-01f, 2.56568432e-01f, 1.15675613e-01f, 1.38361976e-01f,
  4.22201790e-02f, 1.64933205e-01f, 1.44913822e-01f, 2.37725809e-01f, 1.31917015e-01f, 8.94431993e-02f, 1.22383513e-01f, 2.48895228e-01f, 2.81072497e-01f, 2.63641238e-01f,
  -1.27228528e-01f, 1.58734024e-01f, -1.59285322e-01f, -9.41362828e-02f, 1.58690885e-02f, -6.58152103e-02f, -5.04514240e-02f, 1.99066922e-02f, -4.19735573e-02f, -7.59237781e-02f,
  -1.09208887e-02f, -1.56990569e-02f, -1.47070721e-01f, -6.87285811e-02f, -7.25347400e-02f, -5.05502261e-02f, -9.02967528e-02f, 5.59056923e-02f, -3.44622135e-02f, 8.71014744e-02f,
  -9.63937417e-02f, 7.49252588e-02f, 3.72406654e-02f, -1.10451587e-01f, 1.74536780e-02f, -6.92096725e-02f, 5.56903481e-02f, -5.07683605e-02f, 2.71422006e-02f, -1.14450261e-01f,
  2.98448894e-02f, 1.51341081e-01f, 2.39558294e-02f, -1.27677694e-01f, -4.77559716e-02f, -1.58639371e-01f, -1.44872889e-01f, -3.97611000e-02f, -2.49417238e-02f, -8.00109357e-02f,
  -2.01860607e-01f, -1.67828221e-02f, -1.12885706e-01f, -4.31305952e-02f, 2.81892642e-02f, 1.01759076e-01f, -5.97916804e-02f, -7.45248497e-02f, -1.46354541e-01f, -1.92918926e-02f,
  -2.98179518e-02f, -2.68132333e-02f, -2.01541297e-02f, -3.47677544e-02f, -1.89765051e-01f, 6.55376411e-04f, -8.22937489e-02f, 3.58250625e-02f, 4.02202234e-02f, -5.68540245e-02f,
  -3.55050623e-01f, 2.11600903e-02f, 3.73139232e-03f, 1.25421315e-01f, 1.12134159e-01f, -4.76299524e-02f, 1.07098222e-01f, -2.01713257e-02f, -7.56559670e-02f, -6.68919086e-02f,
  -5.84754050e-02f, -3.94038670e-02f, 8.05631429e-02f, -1.13405071e-01f, -2.14019164e-01f, -9.68615338e-02f, -1.29123516e-02f, -4.38439958e-02f, 2.76376326e-02f, -8.41789022e-02f,
  4.77841459e-02f, -4.20186706e-02f, -1.25652760e-01f, -1.63614213e-01f, -1.47039875e-01f, -1.93706125e-01f, -8.83201510e-02f, -1.22512490e-01f, -1.23810031e-01f, -2.43066460e-01f,
  3.52129042e-02f, 4.14895974e-02f, 9.83360112e-02f, 2.83543319e-01f, 1.01089910e-01f, -6.39955923e-02f, 1.86124109e-02f, 4.09216657e-02f, 1.55909374e-01f, 1.07128941e-01f,
  4.66391668e-02f, 9.55000073e-02f, 1.71191052e-01f, 2.19350219e-01f, 1.29134700e-01f, 8.35492611e-02f, 2.19858244e-01f, 1.87450945e-01f, 1.70872524e-01f, 1.11378059e-01f,
  1.00868545e-01f, -1.28719583e-01f, -4.52092402e-02f, 8.30604583e-02f, 2.14448780e-01f, 4.67098206e-02f, 4.37329933e-02f, 1.86533108e-02f, -6.37016967e-02f, 2.50224322e-01f,
  -8.34026467e-03f, -1.05704375e-01f, 9.03572738e-02f, 1.85466197e-03f, -8.74535218e-02f, -1.06775060e-01f, -4.22540605e-02f, -4.13719900e-02f, -1.01248749e-01f, 2.23250985e-02f,
  -3.81177180e-02f, -8.64685252e-02f, -4.51944470e-02f, -2.86357477e-02f, -1.71649352e-01f, 1.21131362e-02f, 2.76903342e-02f, 6.64652810e-02f, 4.89298105e-02f, 3.18494774e-02f,
  1.18633620e-01f, -1.30714491e-01f, -4.40138988e-02f, 5.14261052e-02f, 2.43212730e-02f, 1.26273148e-02f, 1.68312881e-02f, -2.36115158e-02f, -1.23921543e-01f, 5.01699075e-02f,
  1.16813734e-01f, -1.05983362e-01f, 4.66349535e-02f, 4.93903346e-02f, 1.71915188e-01f, 8.68505985e-02f, 1.16046742e-01f, 2.96177585e-02f, 9.92045850e-02f, 8.59727785e-02f,
  1.41631588e-01f, 1.20586038e-01f, 5.61811216e-03f, 8.95923227e-02f, 3.05572823e-02f, -3.03153181e-03f, 9.15380344e-02f, 9.76412669e-02f, -3.69516574e-02f, -2.01849863e-01f,
  4.44337949e-02f, 3.85629684e-02f, -9.62863266e-02f, 1.36928543e-01f, -2.91366819e-02f, -1.43307094e-02f, -2.81955954e-03f, -2.69452948e-02f, -1.58349931e-01f, -1.45648137e-01f,
  -4.05257553e-01f, -3.12440485e-01f, 2.23996818e-01f, 6.44584820e-02f, -1.66136920e-01f, -1.24922566e-01f, -7.72374272e-02f, -1.62783861e-01f, -1.94909841e-01f, -1.82821769e-02f,
  -1.26696467e-01f, -2.07728031e-03f, -7.31269345e-02f, -9.62169170e-02f, -4.76525202e-02f, -7.91557580e-02f, 1.93682360e-03f, -1.10626994e-02f, -1.49866268e-01f, -1.16975136e-01f,
  6.14857115e-02f, -1.41680598e-01f, -1.24718077e-01f, 7.03440905e-02f, 6.13754317e-02f, -7.27896690e-02f, -1.15600109e-01f, -1.43134356e-01f, -9.89801809e-02f, -7.22802281e-02f,
  -1.26343593e-01f, 5.45655787e-02f, 3.58270973e-01f, -1.44349977e-01f, 2.42725238e-01f, 3.36352021e-01f, 3.16581607e-01f, 1.30016103e-01f, -2.61467010e-01f, 7.72124231e-02f,
  8.84167821e-05f, -2.49836564e-01f, -1.64815411e-01f, -2.60126233e-01f, -6.53629377e-02f, 8.39176551e-02f, 5.30535132e-02f, 4.90647368e-02f, 3.25928479e-02f, -7.83758909e-02f,
  -2.15673327e-01f, 8.47252756e-02f, 8.89030006e-03f, -1.34374663e-01f, 4.14450355e-02f, -1.38901725e-01f, 1.55313000e-01f, 1.11972153e-01f, 1.11663923e-01f, -2.12166592e-01f,
  1.76236317e-01f, -7.69979786e-03f, -1.25460386e-01f, -3.00431877e-01f, 6.82139024e-02f, -8.70053023e-02f, 1.39668792e-01f, 1.28033713e-01f, -8.64287931e-03f, 4.94359434e-02f,
  7.75400177e-02f, 1.64810847e-02f, 4.18613516e-02f, 2.58194637e-02f, 1.85583577e-01f, -3.13617773e-02f, -1.42849237e-01f, -6.41011819e-02f, -6.22572899e-02f, -5.97278848e-02f,
  -1.34921044e-01f, 7.06334561e-02f, 1.27365828e-01f, 9.91807207e-02f, -8.65138136e-03f, -1.32084310e-01f, -5.62160611e-02f, -8.88254717e-02f, 2.64849365e-02f, -9.43269879e-02f,
  -2.67473590e-02f, 1.22341409e-01f, 1.35266036e-01f, 2.11209744e-01f, 1.65180087e-01f, 1.33140832e-01f, 5.43050282e-02f, 1.13118239e-01f, 1.75036713e-01f, 1.54599637e-01f,
  1.01086512e-01f, 1.98769465e-01f, 2.91496098e-01f, 2.26904303e-01f, 5.59514854e-03f, 8.91213790e-02f, 2.09400773e-01f, 9.53148007e-02f, 5.80229536e-02f, 2.65006125e-02f,
  1.63147505e-02f, 6.03062846e-02f, 3.14565450e-02f, 6.62167370e-02f, 4.33461368e-02f, 1.40806437e-01f, 1.22056633e-01f, 9.52648968e-02f, 9.82881933e-02f, 6.51131794e-02f,
  1.90415472e-01f, 1.02874905e-01f, -4.71615195e-02f, -1.63219512e-01f, 7.04299882e-02f, -1.07166722e-01f, 2.26996597e-02f, -3.55863757e-02f, 1.27263471e-01f, 9.68938544e-02f,
  1.82723999e-02f, -2.29428802e-02f, 1.84663698e-01f, 1.01217531e-01f, 8.63446668e-02f, 1.11628696e-01f, -1.41554788e-01f, -1.08686849e-01f, -1.78246424e-01f, -6.76854327e-02f,
  -2.02802807e-01f, -7.10021630e-02f, 7.77905285e-02f, 5.41281216e-02f, 1.82276219e-02f, -7.07194507e-02f, 1.25064343e-01f, 8.52266327e-02f, 2.76928805e-02f, 1.14868060e-01f,
  -4.68359828e-01f, -5.11921823e-01f, 3.82164985e-01f, 7.17506036e-02f, 3.14758897e-01f, 3.84342551e-01f, 1.59855202e-01f, -4.46791714e-03f, 6.36934787e-02f, -7.63935372e-02f,
  -2.18993530e-01f, -1.82946026e-01f, -1.55219555e-01f, -5.43864518e-02f, 5.37877418e-02f, 2.40191549e-01f, 2.91911632e-01f, 3.33637118e-01f, 3.65295649e-01f, 2.50878662e-01f,
  -7.41929263e-02f, -1.27043470e-03f, -1.68560565e-01f, -5.57481982e-02f, -6.96323141e-02f, 8.70013759e-02f, 1.05446011e-01f, 7.31711686e-02f, -3.56878974e-02f, 1.30216386e-02f,
  2.63723433e-01f, -2.84888417e-01f, 1.05252087e-01f, -1.49413764e-01f, -1.02061331e-01f, -7.60794431e-02f, 1.62001029e-02f, -6.92436174e-02f, -1.05660269e-02f, -4.71121892e-02f,
  -3.45905731e-03f, -7.23129734e-02f, -6.58316091e-02f, -1.11686774e-01f, -8.71854872e-02f, -3.35075520e-02f, -1.53425455e-01f, -1.09817632e-01f, -9.56466272e-02f, -2.56329253e-02f,
  -2.52150506e-01f, 1.36678359e-02f, 1.47697732e-01f, 8.29188677e-04f, 1.28576029e-02f, 9.81780887e-02f, -1.19644567e-01f, -6.96391016e-02f, -5.64787872e-02f, -1.42097756e-01f,
  7.42410049e-02f, -2.90882923e-02f, -3.82037349e-02f, 3.71773206e-02f, 7.99171701e-02f, 4.24754545e-02f, 7.08039626e-02f, 7.60126933e-02f, 2.30222996e-02f, 4.81862947e-02f,
  4.98814555e-03f, 4.92701866e-02f, -2.59543173e-02f, 7.60846883e-02f, -1.45109072e-01f, -3.05544250e-02f, 1.10297278e-03f, -2.46694982e-02f, -5.54646775e-02f, -1.14885941e-01f,
  -7.54134804e-02f, 1.50172234e-01f, -2.05875505e-02f, 4.80271243e-02f, -3.39092389e-02f, 1.70038342e-02f, -4.11547981e-02f, -1.10327318e-01f, -4.34577726e-02f, -1.01127960e-01f,
  1.03363581e-01f, -7.12233558e-02f, 1.89211532e-01f, -1.56228105e-02f, -4.89835553e-02f, -1.47886604e-01f, -8.17197468e-03f, -2.10245587e-02f, -2.43049338e-02f, 1.00360803e-01f,
  2.49393992e-02f, 7.64744729e-02f, 1.06728671e-03f, -1.03469446e-01f, 1.12139985e-01f, 1.03860516e-02f, -1.89673662e-01f, 7.37528875e-02f, -1.10020023e-03f, 8.75157788e-02f,
  6.42589014e-03f, 1.54361382e-01f, 1.87363535e-01f, 2.04044774e-01f, 1.66688934e-01f, 2.85872489e-01f, 1.18092224e-01f, 1.81460008e-01f, 2.08485886e-01f, 1.38454556e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  2.93650925e-01f, 1.09979682e-01f, 2.94870257e-01f, 3.72827023e-01f, 2.66308039e-01f, 2.34497994e-01f, 4.45284188e-01f, 1.08578257e-01f, 1.42461099e-02f, 2.25681588e-01f,
  1.19740017e-01f, 2.54972845e-01f, 3.85842860e-01f, -7.67288506e-02f, 5.05301952e-01f, 1.67213753e-01f, 6.91136569e-02f, 3.39659989e-01f, 2.40697011e-01f, 4.69968259e-01f,
  1.68273970e-01f, 1.39063954e-01f, 4.39905614e-01f, 1.06897257e-01f, 4.09822702e-01f, 2.51190543e-01f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  5.47184274e-02f, -7.61604868e-03f, 1.51543677e-01f, 1.32437140e-01f, 8.03242102e-02f, -1.56686708e-01f, -1.26820564e-01f, -1.18529191e-03f, 1.25326082e-01f, 2.35769041e-02f,
  -3.34444601e-04f, 7.63649717e-02f, -4.27268669e-02f, -1.50041297e-01f, -7.92777762e-02f, -2.08433419e-02f, 5.49596585e-02f, 3.63192409e-02f, -7.58588547e-03f, -7.03254193e-02f,
  7.41580129e-02f, -1.23671882e-01f, 8.06726962e-02f, 4.68141548e-02f, 1.62260801e-01f, -1.13234013e-01f, 1.03224153e-02f, 5.97901456e-02f, -8.64886194e-02f, -3.45599242e-02f,
  5.48928604e-03f, -6.12766929e-02f, -9.35563445e-02f, -1.42392926e-02f, -3.23581472e-02f, 1.70409679e-01f, 3.20023566e-01f, 1.33740390e-02f, -3.37845176e-01f, -5.04642092e-02f,
  3.71539630e-02f, -5.60796894e-02f, 2.01107353e-01f, 1.54020593e-01f, -1.30596146e-01f, -1.81667358e-01f, -1.23652197e-01f, 1.11448132e-01f, -3.40903074e-01f, 4.48101968e-01f,
  7.80561939e-02f, -4.97693680e-02f, 2.76018351e-01f, -2.48255327e-01f, 3.41091268e-02f, 3.03181618e-01f, -1.36073112e-01f, 4.92846258e-02f, 8.37387890e-02f, 1.29934296e-01f,
  -7.69254938e-02f, 2.07601219e-01f, 3.73752303e-02f, -3.63485187e-01f, 1.40365899e-01f, 5.48586920e-02f, 1.65729597e-01f, 8.96823332e-02f, 1.69923883e-02f, 1.30122811e-01f,
  2.26303432e-02f, -3.33270393e-02f, 1.91784769e-01f, -6.92595690e-02f, -4.44870330e-02f, -1.38964042e-01f, 3.87775339e-02f, -3.55305313e-03f, 6.75716326e-02f, -4.80546914e-02f,
  -1.08443476e-01f, -2.79426612e-02f, 2.16727361e-01f, -2.19557077e-01f, 9.70686898e-02f, -2.25366633e-02f, 2.49257740e-02f, -5.77417277e-02f, -1.38814539e-01f, -1.24176025e-01f,
  -3.10190469e-02f, -6.79575652e-02f, -2.09657252e-01f, 4.53464240e-02f, 3.80075201e-02f, 9.85155851e-02f, 1.41878679e-01f, 1.29442379e-01f, 5.89266568e-02f, -3.28761071e-01f,
  -9.17330906e-02f, 4.19641249e-02f, 1.82489857e-01f, -1.41064242e-01f, 2.07280800e-01f, -2.77568877e-01f, -1.52733862e-01f, 2.43762091e-01f, 4.66869213e-02f, -7.29939491e-02f,
  1.23590812e-01f, 1.02855161e-01f, 5.74123561e-02f, -3.49836290e-01f, 3.23173165e-01f, 1.02790520e-01f, -2.28981018e-01f, -2.61225589e-02f, 1.18859559e-01f, 3.08650196e-01f,
  3.39179039e-01f, 2.94810231e-03f, 2.55876277e-02f, -1.13725215e-01f, -7.11030811e-02f, -9.35507938e-03f, 4.16580867e-03f, 3.72611433e-01f, -1.79781482e-01f, -1.61340863e-01f,
  -6.87855631e-02f, -9.25665647e-02f, -1.24511262e-02f, -1.80744767e-01f, -1.46496713e-01f, 3.61841060e-02f, -2.17895880e-02f, 9.09803137e-02f, -2.02079751e-02f, -2.13433802e-02f,
  4.50383574e-02f, -2.48842547e-03f, -1.93806365e-01f, 6.02660850e-02f, -2.06236597e-02f, -7.74417445e-02f, 7.51421377e-02f, -8.60021263e-02f, 5.87141439e-02f, -1.37319073e-01f,
  -6.33704811e-02f, -2.93391515e-02f, 1.04449011e-01f, -5.66838942e-02f, 2.87535191e-02f, -3.62064652e-02f, 7.75927082e-02f, 2.46787444e-02f, -2.51525372e-01f, 3.41636501e-02f,
  -1.47402197e-01f, -2.05488682e-01f, -4.81174774e-02f, -6.62500560e-02f, -7.95713514e-02f, -3.06629017e-02f, -2.20058430e-02f, 1.25920266e-01f, 1.15570419e-01f, -1.29625157e-01f,
  3.18783782e-02f, 1.77198038e-01f, -1.40820563e-01f, -1.89194009e-01f, -8.05867314e-02f, 6.85956702e-02f, -9.20731872e-02f, 2.24859565e-01f, 8.79207626e-02f, 9.98763964e-02f,
  -2.36080125e-01f, 1.16373710e-01f, -2.49411494e-01f, 3.69743437e-01f, 1.79239243e-01f, -5.78429876e-03f, 2.26348862e-01f, -1.13765568e-01f, -2.08243310e-01f, 2.10777879e-01f,
  -2.46298030e-01f, -1.76765248e-01f, 4.83128913e-02f, -1.21541202e-01f, 1.09637389e-02f, 8.71687084e-02f, -3.42046656e-02f, 5.47370985e-02f, -5.33504672e-02f, 4.63804565e-02f,
  1.87934358e-02f, -3.26875634e-02f, 1.24167137e-01f, -2.64156666e-02f, 8.75683725e-02f, 3.08486819e-02f, -1.69234812e-01f, -1.81844868e-02f, 4.51001301e-02f, -1.90247390e-02f,
  1.55723214e-01f, -1.35107651e-01f, -3.90052944e-02f, 2.99088750e-02f, 1.49179548e-01f, -3.15522030e-02f, -1.91984892e-01f, 2.91191898e-02f, 1.52513444e-01f, -8.67756829e-02f,
  -1.18400201e-01f, 3.19719128e-02f, -9.06598717e-02f, -8.36511794e-03f, -3.48447636e-02f, 1.73372477e-01f, -3.14147882e-02f, -2.08086930e-02f, -1.78548336e-01f, -3.52885835e-02f,
  6.01909310e-02f, -9.58492830e-02f, 1.53240755e-01f, 1.65074572e-01f, -9.11704525e-02f, 2.33980954e-01f, 9.69740599e-02f, -1.33362055e-01f, -7.26420358e-02f, 2.60108113e-01f,
  1.58783775e-02f, -4.24196690e-01f, 3.05115044e-01f, -2.38505065e-01f, -1.73949137e-01f, 2.25047208e-03f, 2.12149099e-01f, 9.94353667e-02f, 2.18945533e-01f, -1.05588444e-01f,
  -8.97904858e-02f, 2.64060106e-02f, 1.18848234e-01f, -1.60224795e-01f, 1.03797071e-01f, -2.53098667e-01f, 4.44624349e-02f, 8.83341283e-02f, 1.18866526e-01f, -1.14236027e-01f,
  1.41124323e-01f, 9.43535566e-02f, -1.07357502e-01f, -6.18271157e-02f, 3.81110981e-02f, -1.44995421e-01f, 8.97981375e-02f, 3.84308435e-02f, -4.80515249e-02f, 1.81555837e-01f,
  1.25729963e-01f, 5.49210683e-02f, -1.01567924e-01f, 1.58089086e-01f, 7.61044621e-02f, 7.71502703e-02f, 8.73921514e-02f, -6.39533177e-02f, -3.16511877e-02f, -9.33687687e-02f,
  1.99642256e-02f, 4.70411032e-03f, 2.11626440e-02f, 1.83700189e-01f, 8.59025028e-03f, -9.61065814e-02f, 4.56289500e-02f, 6.25475263e-03f, 5.14150336e-02f, 6.89899474e-02f,
  5.06593063e-02f, -7.17279837e-02f, 5.79595231e-02f, -1.49738505e-01f, -2.06426326e-02f, -2.26575196e-01f, -4.51137722e-02f, -1.31854992e-02f, -1.49527341e-01f, -4.55768444e-02f,
  -5.64599894e-02f, -4.55394872e-02f, 9.03692767e-02f, -1.41836749e-02f, -1.84036419e-01f, -1.47408396e-01f, 1.03342626e-02f, -1.67850330e-01f, 1.76752791e-01f, -2.91914105e-01f,
  2.37967715e-01f, -5.05052172e-02f, 2.67814249e-02f, 2.31282055e-01f, 2.91893315e-02f, 1.94802850e-01f, 2.51399219e-01f, -1.71786081e-02f, -1.87845882e-02f, 2.26055294e-01f,
  8.53355527e-02f, 1.40332421e-02f, 9.00996104e-02f, 2.06867129e-01f, -8.37178752e-02f, -3.92335020e-02f, -1.63688101e-02f, -5.08590676e-02f, 7.46470969e-03f, -5.42432480e-02f,
  2.17545331e-02f, -5.73113039e-02f, 6.59193695e-02f, -6.42042235e-03f, 2.77627762e-02f, 4.53640744e-02f, 2.19902739e-01f, -2.20678821e-01f, 5.84724508e-02f, 7.82147720e-02f,
  -1.93122298e-01f, -2.06620190e-02f, -5.39456978e-02f, -3.58946510e-02f, 1.19369887e-01f, -1.18460424e-01f, -2.66206637e-02f, -3.23053598e-02f, 1.84193607e-02f, 9.50841233e-02f,
  1.49320424e-01f, -1.45010026e-02f, -1.51767591e-02f, 2.84257755e-02f, -1.13813937e-01f, -8.12638551e-02f, 5.74811064e-02f, 1.75072163e-01f, -1.76831827e-01f, -3.03210348e-01f,
  1.08663455e-01f, -2.77243316e-01f, 4.81325746e-01f, -1.38453498e-01f, 2.53073454e-01f, 2.93338984e-01f, 7.23419487e-02f, 2.25146562e-01f, -3.49610113e-02f, 6.31142110e-02f,
  3.28679569e-02f, 1.53436005e-01f, -1.25025157e-02f, -2.82981962e-01f, -2.50729054e-01f, -6.02640063e-02f, 5.41540049e-02f, 9.44065899e-02f, 2.13289261e-02f, -7.24226460e-02f,
  -1.78483352e-01f, 2.38524494e-03f, 6.33463487e-02f, -3.13076144e-03f, -1.87851250e-01f, 4.01068013e-03f, -2.05757413e-02f, 1.81766078e-02f, 1.03721023e-01f, 9.86039564e-02f,
  -1.05862282e-02f, -3.29631455e-02f, -7.14903623e-02f, -1.61094014e-02f, 1.22381993e-01f, 1.06960855e-01f, -4.81497832e-02f, 2.57666945e-03f, 1.13664299e-01f, -2.33376082e-02f,
  -5.67613542e-02f, 1.62606850e-01f, -7.18024652e-03f, -4.17798385e-02f, 1.14877164e-01f, -2.51921713e-01f, 4.66202572e-02f, 2.67964136e-02f, 1.08544648e-01f, 7.47561678e-02f,
  5.75047694e-02f, -4.17573266e-02f, 3.40044722e-02f, 9.94837359e-02f, -1.01991102e-01f, -2.52858430e-01f, -8.96653384e-02f, -1.44352868e-01f, -2.90129427e-02f, 1.89701363e-01f,
  2.49757260e-01f, -2.13397685e-02f, -6.60712793e-02f, 2.47451201e-01f, -3.63443866e-02f, 1.54417649e-01f, 4.51614223e-02f, 2.40361080e-01f, -1.33363694e-01f, -7.44932564e-03f,
  -9.59508028e-03f, -2.81073302e-01f, -1.09855711e-01f, 3.62725705e-01f, 1.13200709e-01f, -1.87313229e-01f, 6.87641725e-02f, 3.76201794e-02f, -1.48248687e-01f, 3.97321358e-02f,
  -2.44398415e-01f, 1.63924042e-02f, 2.14911267e-01f, -3.05122375e-01f, 2.43504774e-02f, 2.96771955e-02f, -7.37642497e-02f, -2.07893938e-01f, -8.43229890e-02f, -4.46262136e-02f,
  -2.09497586e-01f, 4.97133564e-03f, -1.13178149e-01f, -7.73552507e-02f, -5.98604232e-02f, -8.81307423e-02f, -8.38097259e-02f, -5.66512626e-03f, -1.10395186e-01f, -1.70446709e-01f,
  -3.90751008e-03f, -3.38833290e-03f, -1.05322376e-01f, -2.83131115e-02f, -3.35167907e-02f, -2.57326849e-02f, -7.64869060e-03f, -6.85253069e-02f, -1.09782070e-01f, 6.33091778e-02f,
  -7.25077838e-03f, -2.48330161e-01f, -7.29394630e-02f, -4.57051471e-02f, 1.23422131e-01f, -9.91500542e-02f, -9.24859717e-02f, 2.92961057e-02f, -1.88782275e-01f, 1.91207036e-01f,
  1.15582682e-01f, 3.21174301e-02f, 4.31872196e-02f, -9.99452993e-02f, -2.32564852e-01f, -2.07832213e-02f, -2.89485782e-01f, -2.16925681e-01f, 1.63856875e-02f, -8.40360820e-02f,
  2.83411086e-01f, -1.01367421e-01f, 1.71264499e-01f, 3.98386791e-02f, 1.20082632e-01f, 2.20367506e-01f, 2.20622554e-01f, -3.99411350e-01f, 5.13434410e-03f, 1.79049566e-01f,
  -1.68461695e-01f, 1.44146189e-01f, -7.17622647e-03f, -1.80533886e-01f, 2.78768837e-01f, -3.71736228e-01f, -1.00297250e-01f, 4.73500401e-01f, -1.61138531e-02f, 7.79914930e-02f,
  -4.35787030e-02f, 1.45733297e-01f, -2.09371254e-01f, -1.93027526e-01f, 5.07944711e-02f, -1.22780353e-01f, 7.77499825e-02f, -1.14747703e-01f, -1.75502211e-01f, -8.65389928e-02f,
  1.91464629e-02f, -1.26953050e-01f, 2.49521807e-02f, -1.48243010e-01f, 2.56156586e-02f, 3.67255472e-02f, -1.39696062e-01f, -2.92454963e-04f, -8.55019987e-02f, 5.39051257e-02f,
  4.01512384e-02f, -1.95498735e-01f, 3.14659998e-02f, 8.12949911e-02f, 2.37497583e-01f, -7.18620494e-02f, -2.72482932e-01f, 9.79567133e-03f, -8.56368393e-02f, -1.08419955e-01f,
  -4.98104766e-02f, -6.09784983e-02f, -6.59143999e-02f, -5.19154668e-02f, 2.60528289e-02f, 1.28698051e-01f, 1.21762924e-01f, -1.04256451e-01f, -1.11310706e-01f, -7.80709237e-02f,
  -2.00994745e-01f, -3.14530045e-01f, 2.70119339e-01f, 1.63080871e-01f, 3.82818580e-02f, 8.52253009e-03f, 1.29797205e-01f, -1.09099597e-01f, -6.76672459e-02f, 2.85561413e-01f,
  -2.81175133e-02f, -4.64057744e-01f, 2.31776237e-01f, -5.00335582e-02f, -3.77563834e-01f, 1.63609698e-01f, 1.97721481e-01f, -1.52052134e-01f, 9.37529802e-02f, -4.67734188e-02f,
  -1.24992682e-02f, -1.80547629e-02f, 2.05001429e-01f, 3.04963943e-02f, 1.39836036e-02f, -1.12203471e-02f, -2.51749856e-03f, 1.76713690e-01f, -2.31925622e-02f, -1.15540745e-02f,
  5.05910926e-02f, -6.81441650e-02f, -1.11065498e-02f, 7.86367506e-02f, 2.17835344e-02f, 4.83552404e-02f, 7.75368437e-02f, 1.78454388e-02f, -5.48314229e-02f, -5.87452091e-02f,
  -3.39807644e-02f, 1.76442623e-01f, -1.64690334e-02f, -9.98422205e-02f, -1.88571569e-02f, 1.25704095e-01f, 1.73796326e-01f, -2.07881868e-01f, 4.77174707e-02f, -1.41119808e-01f,
  4.63327505e-02f, 4.23466191e-02f, 1.54971570e-01f, -4.49184701e-02f, 1.67400613e-01f, 1.32145295e-02f, 1.61979087e-02f, 4.71706614e-02f, -4.68404181e-02f, -3.36187452e-01f,
  6.39236718e-02f, -9.39313769e-02f, 4.06962261e-02f, 4.12328318e-02f, 1.08945556e-01f, 1.02905571e-01f, -2.15038449e-01f, -1.11158870e-01f, 7.60820210e-02f, -4.07206535e-01f,
  9.71788839e-02f, 1.05389617e-01f, 1.69642687e-01f, 1.10048279e-01f, 1.99797407e-01f, 3.16867650e-01f, -4.74078804e-01f, -3.68393697e-02f, 3.49193633e-01f, -8.25691596e-02f,
  -1.50040329e-01f, 1.92171723e-01f, -2.39628464e-01f, -7.31636956e-02f, -7.76911229e-02f, -3.56570661e-01f, 3.96596530e-04f, 7.85472170e-02f, -8.52724165e-03f, 2.47666836e-01f,
  1.59128644e-02f, 6.33434504e-02f, 5.03706485e-02f, 1.42987728e-01f, 8.58867243e-02f, 3.74408788e-03f, -2.77223736e-02f, 4.37833183e-02f, 1.88311078e-02f, 2.34625358e-02f,
  3.39118093e-02f, 1.55553043e-01f, -5.62288389e-02f, -1.45392612e-01f, 4.19875421e-02f, -3.31438519e-02f, -1.49280420e-02f, -1.29732460e-01f, -8.52456037e-03f, 2.37751249e-02f,
  -5.80867566e-02f, -1.57417461e-01f, 1.47643015e-01f, -3.86036038e-02f, 1.51215596e-02f, -1.84348077e-01f, 1.17916852e-01f, -2.10214674e-01f, -1.67030260e-01f, 4.97861281e-02f,
  -6.41647205e-02f, -2.03692034e-01f, 1.67857483e-02f, 3.88148203e-02f, -3.25425677e-02f, -3.00223939e-02f, 7.62565667e-03f, 1.60005149e-02f, -1.28139228e-01f, 1.39755875e-01f,
  2.50770263e-02f, 4.19716947e-02f, -2.09204152e-01f, 2.37613454e-01f, 1.59396023e-01f, 5.55388294e-02f, -3.21684927e-02f, 1.72284655e-02f, 1.70567766e-01f, 4.70054507e-01f,
  1.38230771e-01f, 2.48808004e-02f, 1.94892138e-01f, -7.84847364e-02f, -1.75588608e-01f, 2.39784807e-01f, -6.04522713e-02f, 1.68404937e-01f, -1.61404386e-01f, 2.60686036e-02f,
  -1.96055233e-01f, -2.04209611e-01f, -6.10518269e-02f, -2.41425946e-01f, 4.59964499e-02f, 2.08093166e-01f, 4.51248772e-02f, -3.26497890e-02f, -1.53212294e-01f, 3.36229615e-02f,
  4.06308919e-02f, -8.65852684e-02f, -2.23991454e-01f, 1.75572857e-02f, 4.30537201e-03f, 3.94876972e-02f, -6.13578893e-02f, 2.11917371e-01f, -1.26174744e-03f, 3.69886532e-02f,
  -8.88273213e-03f, -9.58490372e-02f, 2.00287960e-02f, 1.66947559e-01f, -4.38594259e-02f, 3.14535089e-02f, 4.56478596e-01f, -5.03879413e-02f, -4.88992274e-01f, 1.01555914e-01f,
  -1.90347463e-01f, 1.39392182e-01f, -6.86217695e-02f, 3.69488187e-02f, 2.13501826e-01f, 7.78660923e-02f, -8.21110085e-02f, 1.63231850e-01f, -1.98267668e-01f, 6.39564474e-04f,
  2.91019008e-02f, 1.66717544e-03f, -3.17116361e-03f, 2.06657767e-01f, -5.64334691e-02f, 1.90044027e-02f, 9.03549865e-02f, -9.78930369e-02f, -1.26287742e-02f, 1.64980859e-01f,
  -6.78167567e-02f, 2.55466253e-02f, 1.87224135e-01f, -2.04019085e-01f, 2.09263280e-01f, 1.24057062e-01f, -3.43201786e-01f, 5.27447127e-02f, -1.56666189e-01f, 1.00539155e-01f,
  -3.07696462e-01f, 2.11736977e-01f, -1.30306818e-02f, 4.34825718e-02f, -1.40299305e-01f, -2.33317494e-01f, 5.02650067e-03f, -5.91152487e-03f, -3.96915190e-02f, -8.05754587e-02f,
  -2.46384982e-02f, -1.81437150e-01f, -1.29552810e-02f, 1.77835390e-01f, 8.22316483e-03f, -1.91771686e-02f, -1.19400345e-01f, 2.28143986e-02f, 1.60310250e-02f, -2.45576888e-01f,
  -1.23445340e-01f, -6.37107193e-02f, -1.57538727e-01f, 4.19554189e-02f, -1.91790879e-01f, 6.24674037e-02f, -2.59998180e-02f, -2.20467821e-01f, -3.09192250e-03f, 6.33971617e-02f,
  4.19539183e-01f, -4.73098345e-02f, -3.68646920e-01f, -4.33991887e-02f, -2.05232147e-02f, 5.18304892e-02f, -7.51595348e-02f, -7.52104595e-02f, 1.84259901e-03f, -2.78920196e-02f,
  -2.03152582e-01f, 1.17185600e-01f, 1.61013782e-01f, 1.66278094e-01f, -2.36795604e-01f, -1.97012976e-01f, -5.34510277e-02f, 2.60828435e-01f, 1.20474003e-01f, 1.45984709e-01f,
  -3.08677852e-01f, -8.23944062e-02f, 8.42396617e-02f, 7.07080662e-02f, 1.05460234e-01f, 9.79714841e-02f, 1.80513203e-01f, -3.67856354e-01f, 1.19368821e-01f, 2.13877670e-02f,
  -2.82704115e-01f, 2.61380911e-01f, 1.74231902e-01f, 3.43600735e-02f, 1.07788205e-01f, -1.13951005e-01f, 8.57263282e-02f, 2.13284329e-01f, -8.14360976e-02f, -1.22184483e-02f,
  -9.94474962e-02f, -9.78850871e-02f, 5.21811917e-02f, 2.39743423e-02f, 3.53976600e-02f, 2.42631938e-02f, 2.42421366e-02f, -1.42385634e-02f, 9.25483927e-03f, -6.81472942e-02f,
  -3.51561904e-02f, -7.14916037e-03f, 1.53546631e-01f, -4.09301370e-03f, 1.01078674e-01f, -8.03302154e-02f, -7.57598281e-02f, -1.40125463e-02f, -9.30428505e-02f, 6.54570311e-02f,
  -4.68714461e-02f, 1.43059909e-01f, -1.47506475e-01f, 3.81817073e-02f, 1.02115296e-01f, 6.33734092e-02f, -3.26610476e-01f, -1.40949234e-01f, -1.38737494e-02f, 5.75514808e-02f,
  -2.43837222e-01f, 2.83356234e-02f, 2.61387646e-01f, -4.68430519e-02f, -1.88569158e-01f, 1.40969038e-01f, 1.78525727e-02f, -1.86528549e-01f, 4.51216213e-02f, 1.24104433e-01f,
  -1.83996204e-02f, -4.29227576e-02f, -2.39319831e-01f, 7.61826858e-02f, 1.16154261e-01f, -1.78417459e-01f, 2.40742549e-01f, -6.00234931e-03f, -2.84320675e-02f, 1.16664007e-01f,
  6.68196455e-02f, -3.43684494e-01f, -5.23291975e-02f, -1.17236622e-01f, -1.52051160e-02f, -2.49717355e-01f, -1.31120771e-01f, 3.39099139e-01f, -1.49131969e-01f, 1.64167598e-01f,
  -2.11285353e-01f, 1.28995739e-02f, -2.20266823e-02f, 6.32807165e-02f, 3.81052159e-02f, 2.64813632e-01f, -1.53639242e-01f, -1.32870272e-01f, 2.70654690e-02f, 7.00017735e-02f,
  1.17927780e-02f, -6.70831129e-02f, 1.40721053e-01f, -1.25666022e-01f, 4.62184809e-02f, 1.98547659e-03f, 1.12064086e-01f, -7.02560917e-02f, 8.86235759e-02f, -4.32777731e-03f,
  7.91257806e-03f, -3.89264822e-02f, -4.97116782e-02f, -7.58482423e-03f, 2.20743194e-01f, -9.84454229e-02f, 5.08389249e-02f, -5.22329435e-02f, 1.12768531e-01f, -1.18136175e-01f,
  -1.36365443e-01f, 7.39388540e-02f, 1.15897655e-01f, -2.42610946e-01f, 1.31505087e-01f, -1.26852140e-01f, 2.15964764e-02f, -5.87475970e-02f, -4.82059419e-02f, -1.45296618e-01f,
  -1.17149740e-01f, -4.85400707e-02f, -1.74664304e-01f, -6.96854666e-02f, -1.94264308e-01f, 1.02174766e-01f, 1.03710406e-01f, -1.44864738e-01f, 1.71543881e-01f, 1.59852549e-01f,
  5.51636755e-01f, -1.52359456e-01f, -5.16366735e-02f, 3.75475913e-01f, 6.56439438e-02f, -3.06774020e-01f, -1.76252887e-01f, 9.05292481e-02f, -2.54602909e-01f, -9.61261168e-02f,
  1.27596900e-01f, 2.16018096e-01f, 9.93500426e-02f, -1.96196437e-01f, -1.19801693e-01f, 1.27322957e-01f, -1.04254425e-01f, -4.77364883e-02f, 1.97150167e-02f, 2.55336970e-01f,
  1.51303142e-01f, 1.05675355e-01f, -3.22554968e-02f, 5.36246188e-02f, -4.16030027e-02f, -8.22385326e-02f, 1.56808980e-02f, -4.48176749e-02f, -7.19878152e-02f, -5.94665855e-02f,
  2.25886535e-02f, -7.37082260e-03f, 1.50962949e-01f, 3.64827923e-03f, -3.32886018e-02f, -1.02302559e-01f, 5.49459457e-02f, -9.13078487e-02f, -8.18661321e-03f, 6.09867498e-02f,
  -8.28147605e-02f, 4.59350757e-02f, 2.88562495e-02f, -7.44652897e-02f, -1.97527066e-01f, 6.20728433e-02f, 1.00337669e-01f, 1.22295007e-01f, -4.22795527e-02f, -1.06007375e-01f,
  6.18699864e-02f, 5.15564233e-02f, 8.39540809e-02f, 1.49831697e-01f, -6.18051179e-02f, -2.53005087e-01f, 1.07908741e-01f, 9.35546905e-02f, 1.18393842e-02f, -2.31660038e-01f,
  -1.07882768e-01f, 5.11111319e-02f, -6.48021474e-02f, 6.29297495e-02f, 3.53596509e-01f, -1.00681975e-01f, -1.27701059e-01f, 7.38592520e-02f, 1.09918371e-01f, -5.50005019e-01f,
  1.03141265e-02f, 8.50430317e-03f, -1.71565458e-01f, 4.43716906e-02f, 1.63821459e-01f, 1.10939987e-01f, 2.50238478e-02f, -4.33779061e-02f, -2.83160985e-01f, 1.34641722e-01f,
  -6.92285672e-02f, -1.23399571e-02f, 1.23903036e-01f, 3.37958753e-01f, 1.59070656e-01f, 8.90763178e-02f, 2.04056725e-01f, 1.68969873e-02f, -4.58335690e-02f, 1.55771077e-01f,
  1.19048983e-01f, -9.01512727e-02f, 1.51017271e-02f, 9.34751555e-02f, 5.28642200e-02f, -6.65508509e-02f, 1.12146974e-01f, 1.40025929e-01f, 9.61379781e-02f, 5.52844554e-02f,
  -9.14288759e-02f, -3.41267474e-02f, -4.29756567e-02f, -1.62119009e-02f, 9.22055170e-02f, -1.41724288e-01f, -1.95412487e-01f, 2.16533095e-01f, 4.58204418e-01f, -7.30282292e-02f,
  1.13383800e-01f, -5.87266199e-02f, 5.80569096e-02f, 3.77599150e-02f, 6.67055398e-02f, 4.43763398e-02f, -8.84816423e-02f, -1.78828388e-01f, 4.12654020e-02f, 7.67120123e-02f,
  4.55029905e-02f, 1.07424468e-01f, 2.29579702e-01f, 7.15928301e-02f, 9.87601429e-02f, 8.70709643e-02f, -7.69321993e-02f, -1.89682215e-01f, 1.06378965e-01f, -5.27944416e-02f,
  2.16202006e-01f, -2.60410428e-01f, 9.44133848e-02f, 2.81962782e-01f, -3.91899586e-01f, -8.30775872e-03f, 2.78132379e-01f, -1.32470965e-01f, -1.54448882e-01f, -1.77151963e-01f,
  -6.43674508e-02f, -8.48118365e-02f, 3.53040807e-02f, -2.45918080e-01f, -1.88803878e-02f, 1.34355854e-02f, -4.18316051e-02f, 4.82808873e-02f, 7.10090250e-02f, -1.22537510e-02f,
  -3.60465273e-02f, 4.94827293e-02f, 3.31914127e-02f, -6.71023577e-02f, -7.05345860e-03f, 9.36151575e-03f, 4.62251343e-03f, 1.56624168e-01f, 1.06335282e-02f, -1.14493081e-02f,
  1.00477122e-01f, 2.16069054e-02f, 4.36189063e-02f, 1.14233807e-01f, 4.34889533e-02f, -6.15109541e-02f, 1.34943053e-01f, 7.16431439e-02f, 6.88799983e-03f, 1.71554424e-02f,
  -3.95891488e-01f, 1.16410125e-02f, 2.74843603e-01f, -4.28530760e-02f, 1.52759803e-02f, 1.10588998e-01f, 3.01029384e-01f, -4.76567037e-02f, -1.50568888e-01f, 2.05109596e-01f,
  1.55740365e-01f, -1.32567123e-01f, -7.36649754e-03f, -8.13621730e-02f, -7.37050101e-02f, -7.18119368e-02f, 1.46442518e-01f, -2.99592048e-01f, 1.38561437e-02f, 1.32434055e-01f,
  3.55761617e-01f, -1.01422176e-01f, 3.89950201e-02f, -1.37002155e-01f, 3.30107696e-02f, -1.54759243e-01f, -6.07832074e-02f, 7.49769807e-02f, -2.99263060e-01f, -3.69400345e-02f,
  1.32674709e-01f, -2.11730057e-05f, -2.83409450e-02f, -6.08530976e-02f, 1.36548311e-01f, -3.40961069e-02f, 6.07933775e-02f, 1.58493012e-01f, 1.14295274e-01f, -2.16085222e-02f,
  1.82343394e-01f, 2.21862295e-03f, -3.06445570e-03f, 1.48362607e-01f, -1.26424506e-01f, -2.86827013e-02f, -9.84135568e-02f, -8.32366869e-02f, -5.28389812e-02f, -1.28108308e-01f,
  1.62531789e-02f, 3.63404192e-02f, -6.52011484e-02f, 1.15086706e-02f, -3.67194675e-02f, 7.10008591e-02f, 1.71111375e-01f, -3.77689488e-02f, -5.60252629e-02f, -5.44235669e-02f,
  -8.38926062e-02f, 5.37429005e-02f, -3.10193817e-03f, -6.99264258e-02f, 2.48908266e-01f, 1.87645145e-02f, -1.00019090e-01f, -9.85501036e-02f, -1.37013093e-01f, -9.72080603e-02f,
  -8.19377527e-02f, 1.23497238e-02f, -4.94792089e-02f, -1.50163859e-01f, -6.80553317e-02f, -5.94058260e-02f, -1.13477640e-01f, 3.89254466e-02f, 2.35138655e-01f, 7.38149732e-02f,
  1.16187878e-01f, 3.85999262e-01f, -1.07471637e-01f, -1.42255314e-02f, -2.02935845e-01f, -2.37641469e-01f, -1.58685684e-01f, 8.60809982e-02f, 1.54671162e-01f, -1.69690266e-01f,
  1.27709210e-01f, 1.38082728e-01f, -1.65660344e-02f, 8.75185430e-02f, 6.76683942e-03f, 1.70840934e-01f, -2.10518271e-01f, -3.38120431e-01f, -3.08535159e-01f, 9.06753689e-02f,
  6.77079111e-02f, -1.61126360e-01f, -2.99711209e-02f, -7.03528449e-02f, -2.11069688e-01f, 2.20358282e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -6.92549646e-02f, -2.84461472e-02f, 1.56683430e-01f, -4.44886601e-03f, 1.53110653e-01f, 1.24835223e-01f, 1.47930503e-01f, 2.22431690e-01f, 4.11408842e-02f, -8.29544663e-02f,
  2.33939718e-02f, 1.05314068e-01f, 7.71769211e-02f, 2.07247123e-01f, 1.44769534e-01f, 1.40578955e-01f, 7.86971301e-02f, -1.52701335e-02f, 3.94092919e-03f, -9.36664045e-02f,
  1.87140733e-01f, 8.50250013e-03f, -1.67488903e-01f, 4.97554950e-02f, 3.12919319e-01f, -1.79404482e-01f, -1.86729115e-02f, -1.28212899e-01f, 3.55112791e-01f, 3.47812884e-02f,
  -7.48933181e-02f, -2.42073029e-01f, 1.70879632e-01f, -2.54157454e-01f, -2.61191148e-02f, 2.78833687e-01f, 3.43565792e-02f, -2.03630492e-01f, 2.25794345e-01f, 2.54828274e-01f,
  6.37075901e-01f, 5.42762838e-02f, 1.25294164e-01f, 3.64138365e-01f, -5.63622177e-01f, 8.90943408e-02f, 4.05547246e-02f, -2.91894823e-01f, -8.74432102e-02f, 5.60417831e-01f,
  2.61034936e-01f, -1.87020928e-01f, 2.75912851e-01f, 3.21962357e-01f, 6.16489232e-01f, -6.34169728e-02f, 4.01126117e-01f, 1.53722167e-01f, 6.45999834e-02f, 1.78909525e-01f,
  -2.09006239e-02f, 1.66650102e-01f, -1.66044399e-01f, -2.53245384e-01f, 1.49386004e-01f, 1.22396402e-01f, 5.43866074e-04f, 1.09150007e-01f, -1.64293293e-02f, 1.77336216e-01f,
  1.44933835e-01f, 2.81614035e-01f, 1.87034234e-01f, 6.58053579e-03f, -8.95202998e-03f, 1.44297108e-01f, 8.42041895e-03f, 1.08346201e-01f, -5.32979816e-02f, 9.09836367e-02f,
  1.78624853e-01f, -2.28474177e-02f, 6.40652189e-03f, -2.69395839e-02f, -1.37642637e-01f, -1.88513845e-01f, 1.67971939e-01f, -1.34893119e-01f, -9.10890698e-02f, -2.00455576e-01f,
  2.37648711e-02f, -3.98886465e-02f, -3.24712902e-01f, 1.42917350e-01f, 1.13159664e-01f, -1.17375776e-01f, 1.87476166e-02f, 1.85758755e-01f, -1.74023673e-01f, -1.76623031e-01f,
  1.33755635e-02f, 6.55048117e-02f, -3.85173082e-01f, 4.39897746e-01f, -1.68296739e-01f, -3.32332939e-01f, -7.32763588e-01f, 1.37454331e-01f, 4.53409523e-01f, 1.11150712e-01f,
  -1.59413934e-01f, 3.37725848e-01f, 2.25887865e-01f, 4.68779594e-01f, 7.43959963e-01f, 1.81140140e-01f, 9.28826630e-01f, 3.50245684e-02f, 7.17901587e-02f, -3.39029022e-02f,
  1.09904706e-01f, 5.88238388e-02f, 7.61400238e-02f, -3.39924991e-01f, -3.46701443e-01f, 4.73074280e-02f, -8.06461796e-02f, -1.17008954e-01f, 8.59151855e-02f, 6.40292764e-02f,
  2.88108885e-01f, 2.12213024e-01f, 2.70618498e-01f, 1.07155539e-01f, 2.43793815e-01f, -5.56054106e-03f, 2.74686247e-01f, 1.72355473e-01f, 4.90631759e-02f, 1.75092623e-01f,
  7.67136291e-02f, 1.39430165e-01f, 2.88986862e-01f, 9.92110223e-02f, 7.04936087e-02f, 2.16724068e-01f, 1.26017720e-01f, -3.16551387e-01f, 6.70372248e-02f, -3.25040102e-01f,
  8.81608203e-03f, 2.13249162e-01f, 4.82433110e-01f, -1.36127010e-01f, 4.45668027e-03f, -3.17269973e-02f, -2.52514035e-01f, 9.79165956e-02f, 1.35462135e-01f, -9.02828202e-02f,
  -6.88640475e-02f, 7.60946132e-04f, -1.35580987e-01f, -3.49096186e-03f, 3.57397169e-01f, 1.29500911e-01f, -1.48791462e-01f, 1.62118748e-01f, -5.83497658e-02f, -5.18361526e-03f,
  5.08521676e-01f, 4.66572702e-01f, -2.25660592e-01f, 1.04690656e-01f, -7.25326538e-02f, 1.54579386e-01f, -2.30929330e-01f, 1.53775215e-01f, 3.16442251e-01f, -3.12222093e-02f,
  5.76511741e-01f, -2.92375326e-01f, 8.05955753e-03f, 7.37043262e-01f, 9.50524062e-02f, 5.66288948e-01f, -2.04888318e-04f, -1.12844527e-01f, -2.19998822e-01f, -1.43115669e-02f,
  1.51194140e-01f, 2.40049258e-01f, 2.18589395e-01f, 1.14010893e-01f, -3.46542150e-02f, 2.03366175e-01f, -1.58413500e-02f, 1.57095790e-01f, 1.49744809e-01f, 4.12846506e-02f,
  2.03875359e-02f, 3.25131536e-01f, -4.76097055e-02f, 1.51308984e-01f, 7.01601356e-02f, 5.48722148e-02f, 2.12138165e-02f, 6.86128587e-02f, 3.22268099e-01f, 2.41943732e-01f,
  -3.49767134e-02f, 1.97304532e-01f, -7.34396726e-02f, -3.12861145e-01f, 2.42138028e-01f, -6.81290105e-02f, 2.34016702e-02f, -2.10752431e-02f, 2.18786478e-01f, -4.81612347e-02f,
  -2.56797612e-01f, 1.18475869e-01f, 2.07760528e-01f, -7.15831220e-02f, -4.84402627e-02f, -2.70784348e-02f, -1.02261335e-01f, -4.33422513e-02f, -1.49475828e-01f, 3.29591155e-01f,
  8.88729617e-02f, 4.50637460e-01f, -1.73666149e-01f, 1.37962729e-01f, 5.26314750e-02f, -1.11864477e-01f, 7.60814667e-01f, -5.65914214e-02f, 6.21872023e-02f, 4.85430993e-02f,
  5.69435358e-01f, 3.08058232e-01f, -2.54966199e-01f, 2.75136799e-01f, 5.25062919e-01f, 3.79509419e-01f, -2.85519928e-01f, 7.58923516e-02f, -1.08133890e-01f, -2.40917072e-01f,
  -1.88083649e-01f, -3.49337697e-01f, 1.00024931e-01f, -8.59576911e-02f, 6.90319762e-02f, -3.44115227e-01f, 1.65223405e-01f, 3.18803899e-02f, 1.15770973e-01f, 2.04169735e-01f,
  1.44376203e-01f, 2.60397851e-01f, 4.50931340e-02f, 1.41343966e-01f, 1.98314086e-01f, 7.10085705e-02f, 3.58687043e-02f, 2.48720367e-02f, 2.07520992e-01f, 3.14585209e-01f,
  8.52594972e-02f, 4.83348817e-02f, 2.65887827e-01f, 3.08403671e-01f, 1.27525598e-01f, -8.04731529e-03f, 4.82273288e-02f, 3.05269033e-01f, -1.91054121e-01f, -1.44526392e-01f,
  5.49788177e-02f, -1.62757352e-01f, 4.19167243e-02f, -1.09092429e-01f, 1.08757056e-01f, 6.94060028e-02f, -3.77372682e-01f, 2.01632231e-01f, 3.96732360e-01f, 5.61731271e-02f,
  1.84769958e-01f, 2.40589440e-01f, -2.79442668e-01f, -2.53572557e-02f, 1.48342207e-01f, -2.46348247e-01f, 5.63708544e-01f, 9.39924642e-02f, 2.58691192e-01f, 5.29938757e-01f,
  -4.18105125e-02f, -1.74938425e-01f, -1.27778441e-01f, 2.71018688e-02f, -1.16391033e-01f, -8.05953592e-02f, 4.78462130e-01f, 1.90406397e-01f, -2.24581316e-01f, 3.71032000e-01f,
  4.74817425e-01f, 1.99708089e-01f, 5.82474589e-01f, -2.38729879e-01f, -8.42032582e-02f, 6.15786791e-01f, 3.50178033e-02f, -2.57383525e-01f, 2.95633525e-01f, -3.05213153e-01f,
  8.96127373e-02f, 7.49071613e-02f, 1.94628656e-01f, -9.92920920e-02f, -2.06955243e-02f, 1.30100176e-01f, 4.96899784e-02f, 1.68988839e-01f, 1.16002142e-01f, 6.39161691e-02f,
  3.73867676e-02f, 1.48579493e-01f, -8.25867280e-02f, 2.38945093e-02f, 7.44352639e-02f, 2.56666571e-01f, 3.90008166e-02f, 7.35348612e-02f, -5.55938594e-02f, -3.06350198e-02f,
  -2.82857399e-02f, 9.46647152e-02f, 7.68092554e-03f, 9.93786827e-02f, 9.94135216e-02f, -1.24456562e-01f, -2.86177605e-01f, 3.49866338e-02f, -1.48022473e-01f, -7.72254867e-03f,
  -2.03758538e-01f, -3.44812460e-02f, 1.23605832e-01f, 3.53157520e-02f, -1.56843215e-02f, 2.02452876e-02f, 2.34908402e-01f, 1.62126511e-01f, 3.93910587e-01f, -3.85449231e-02f,
  2.15644911e-01f, -1.73172802e-01f, -3.18457693e-01f, 2.14761104e-02f, -2.79896468e-01f, 1.65016547e-01f, -6.58511445e-02f, -4.47380394e-01f, 9.03425086e-03f, 1.31513566e-01f,
  7.81612039e-01f, -8.99407789e-02f, 1.15063965e-01f, 7.85351321e-02f, 1.02288991e-01f, -2.72998184e-01f, 2.47814834e-01f, 2.39042237e-01f, 6.22739829e-02f, -1.33574307e-01f,
  3.87647063e-01f, 9.58241522e-02f, -8.63573328e-03f, -2.15203851e-01f, -6.27256259e-02f, -1.63533110e-02f, 2.18769670e-01f, 6.04727753e-02f, 1.40548021e-01f, 5.09165786e-02f,
  -1.78733431e-02f, 5.30214086e-02f, 1.17357150e-01f, 3.06311637e-01f, 7.54546598e-02f, 1.97586179e-01f, 6.35887757e-02f, -1.05399065e-01f, -3.29753533e-02f, 1.50698796e-01f,
  9.91104320e-02f, 1.13530509e-01f, 4.38450463e-02f, -2.52624415e-03f, 1.83404431e-01f, 2.05093324e-01f, -2.13126466e-01f, 1.74524978e-01f, -6.88058883e-02f, 1.12834893e-01f,
  -5.23673706e-02f, 9.22832359e-03f, 3.30192685e-01f, -3.89322490e-02f, 3.57281603e-02f, 2.30812449e-02f, 1.83022290e-01f, 4.67119701e-02f, -5.78436814e-02f, 3.02879456e-02f,
  3.75602275e-01f, -1.15991183e-01f, 5.89805067e-01f, 2.61186600e-01f, 2.19573319e-01f, 3.14852864e-01f, -6.00118116e-02f, 3.17921676e-02f, -4.10098076e-01f, -3.09768394e-02f,
  -1.39184773e-01f, 8.15383419e-02f, -1.15591183e-01f, 4.49937195e-01f, -1.93954855e-01f, -3.06250006e-01f, 1.85323730e-01f, 1.24527933e-02f, 3.01902384e-01f, 1.83841497e-01f,
  -1.25838220e-01f, 2.58677036e-01f, -2.11195946e-02f, 2.97054708e-01f, 8.75176340e-02f, 4.75600660e-01f, 2.90010899e-01f, 2.25953057e-01f, -1.45065516e-01f, -8.02119523e-02f,
  1.92721575e-01f, 8.48121010e-03f, 1.20580748e-01f, 1.39653340e-01f, 2.04685435e-01f, 7.31720403e-02f, 1.56835660e-01f, 1.24914899e-01f, 3.47479075e-01f, 7.33167380e-02f,
  1.42109990e-01f, -1.17551744e-01f, -1.06391586e-01f, -4.52336892e-02f, 5.44660576e-02f, 1.04302160e-01f, 7.31327608e-02f, -2.14050859e-01f, 4.13806111e-01f, 1.87479332e-02f,
  -5.86620644e-02f, 9.87595171e-02f, -1.99895561e-01f, -3.97756184e-03f, 3.07621121e-01f, 5.79628050e-02f, 6.80924626e-03f, -3.23039480e-02f, -2.35933200e-01f, 3.34488750e-01f,
  -3.10048074e-01f, -4.76322293e-01f, 2.36622952e-02f, -1.89054664e-02f, -4.44514513e-01f, -3.75732072e-02f, 5.56718767e-01f, 4.24986541e-01f, -1.56143889e-01f, 2.12838858e-01f,
  1.26563400e-01f, 2.88050503e-01f, 4.32552993e-01f, -3.17390859e-01f, -2.66741574e-01f, 5.61973989e-01f, 3.26931953e-01f, 2.35479683e-01f, -3.29436451e-01f, -3.90442042e-03f,
  -4.11920846e-02f, 1.94626987e-01f, 2.19139457e-01f, 5.66932082e-01f, 1.62477762e-01f, -4.65614349e-01f, 7.11103976e-02f, -5.19582955e-03f, -1.59583718e-01f, 3.24689835e-01f,
  -1.78693503e-01f, 2.31266126e-01f, 1.37901127e-01f, 2.08772361e-01f, 1.41377971e-01f, -1.26772866e-01f, 1.43798441e-01f, 9.05151293e-02f, 3.37632507e-01f, 1.07091337e-01f,
  1.70465648e-01f, -7.69130280e-03f, 1.89200699e-01f, 2.74555445e-01f, -4.03529257e-02f, -8.26582685e-02f, 1.18705504e-01f, -3.04449517e-02f, 5.87721206e-02f, 1.30689353e-01f,
  -2.31438875e-01f, 7.77089037e-03f, 8.59526917e-02f, -1.38786525e-01f, 3.11463505e-01f, -7.26975873e-02f, -1.64452925e-01f, -9.81656536e-02f, 2.10021749e-01f, -1.85350075e-01f,
  -4.19096887e-01f, -9.76790022e-03f, 2.94066817e-01f, -1.50151387e-01f, -3.43106061e-01f, 4.89603914e-02f, -1.37157470e-01f, -5.03803492e-02f, -1.38836190e-01f, 8.22753087e-02f,
  -1.44626692e-01f, 3.36491436e-01f, -3.59371811e-01f, -2.17812285e-01f, -1.00621976e-01f, -3.30386102e-01f, 6.45218313e-01f, -2.01737672e-01f, 2.14680761e-01f, 6.13558471e-01f,
  3.24332654e-01f, 1.70822833e-02f, -1.56298634e-02f, 1.05724312e-01f, 4.67871457e-01f, -9.43576768e-02f, -1.38861179e-01f, 2.83981115e-01f, -5.03918946e-01f, -1.25048891e-01f,
  -7.39810930e-04f, 1.38890937e-01f, 1.89627320e-01f, -9.95231271e-02f, 4.79540303e-02f, 1.92033648e-01f, 3.09352390e-02f, -1.21367559e-01f, 2.31662109e-01f, 2.41293013e-01f,
  3.96742427e-04f, 9.54062641e-02f, -4.75431681e-02f, -3.27501260e-02f, -3.67053151e-02f, 2.65978962e-01f, -1.06710836e-01f, 4.97979745e-02f, -7.99507424e-02f, 5.67634851e-02f,
  8.54142606e-02f, 2.41050482e-01f, 1.01004519e-01f, 6.87621683e-02f, 4.26672250e-02f, -1.53213173e-01f, 3.48483846e-02f, -2.18987927e-01f, 5.41157313e-02f, 2.40549538e-02f,
  4.50763494e-01f, 2.76588723e-02f, -1.55072669e-02f, -1.29048035e-01f, 2.60136515e-01f, 3.61663196e-03f, -2.67883897e-01f, -1.81777850e-01f, 9.54799801e-02f, -3.91145021e-01f,
  8.88583437e-02f, 3.07093322e-01f, 4.39157970e-02f, 8.23139772e-02f, 1.83552958e-03f, 5.04027843e-01f, 3.88567209e-01f, -6.82710856e-02f, 3.76619816e-01f, 3.97813261e-01f,
  -2.04149649e-01f, 2.55464345e-01f, -3.36542241e-02f, 2.23102868e-02f, 1.15506947e-01f, 5.31199455e-01f, 3.46842587e-01f, 8.91473666e-02f, 9.42470971e-03f, 4.60567236e-01f,
  3.08423489e-01f, -6.64397478e-02f, 2.61038154e-01f, 1.85043439e-02f, 1.14539266e-01f, 5.37906624e-02f, 1.74588896e-02f, -3.24240513e-02f, -3.46613884e-01f, -3.00514579e-01f,
  3.23563486e-01f, 2.02981740e-01f, 2.18308657e-01f, 2.12551877e-01f, -1.18126899e-01f, 9.91068557e-02f, 7.99925104e-02f, 3.82780321e-02f, -3.21803540e-02f, 1.39453545e-01f,
  -1.25691742e-01f, 2.20354304e-01f, 1.51319057e-01f, 2.43256867e-01f, -2.16178149e-01f, 1.19745754e-01f, 1.26167297e-01f, -1.81806460e-01f, 1.30373731e-01f, 2.62119591e-01f,
  6.06294721e-02f, 4.71786223e-02f, -2.99398124e-01f, 1.48583680e-01f, -1.61668137e-01f, 5.96279949e-02f, 2.84721982e-02f, 7.66007304e-02f, 1.57758176e-01f, 1.37510926e-01f,
  -1.18074253e-01f, -2.61378754e-02f, 1.35256276e-01f, -1.58393923e-02f, -1.96086317e-01f, -2.23423287e-01f, -5.90415224e-02f, 3.34373862e-01f, 6.58201933e-01f, 5.73668294e-02f,
  1.98834136e-01f, 1.92561716e-01f, -1.39630944e-01f, -2.31642857e-01f, 4.16492224e-01f, -3.54553275e-02f, -2.20508382e-01f, -1.18371762e-01f, 2.67760217e-01f, -1.17677100e-01f,
  -3.27178210e-01f, -1.48527905e-01f, -2.17781454e-01f, 4.19860423e-01f, -2.86023349e-01f, -1.79338872e-01f, 2.59942740e-01f, 1.09582983e-01f, 2.02269200e-02f, -2.32760370e-01f,
  -4.24157977e-02f, 8.93123914e-03f, 2.04206645e-01f, 3.24340552e-01f, -1.43522322e-01f, -2.00886019e-02f, 2.33087033e-01f, 9.56791490e-02f, 6.42976686e-02f, 5.53842448e-02f,
  -2.12759033e-01f, 5.47845252e-02f, 4.32778411e-02f, 2.29949683e-01f, -1.38427570e-01f, 2.40613580e-01f, -3.10391895e-02f, 9.57246423e-02f, -3.88900340e-02f, 1.15734152e-01f,
  2.43825093e-01f, -7.13610202e-02f, -4.45697121e-02f, 2.18366440e-02f, 7.06543848e-02f, -5.28685153e-02f, 1.05655581e-01f, -1.63902119e-01f, 5.91630489e-02f, -4.90516759e-02f,
  1.54278398e-01f, -1.69590503e-01f, -2.61901822e-02f, 2.08997324e-01f, -7.98107777e-03f, -1.66209430e-01f, 6.27332404e-02f, -1.72767475e-01f, -2.67047361e-02f, -6.44987673e-02f,
  -2.17167884e-01f, 1.88422967e-02f, -4.51077044e-01f, 7.03553110e-02f, -1.25838563e-01f, 7.39454664e-03f, 4.25750971e-01f, 3.09986949e-01f, 4.82192338e-01f, -2.17698470e-01f,
  1.99232742e-01f, 4.63209689e-01f, 3.32183748e-01f, 3.05691123e-01f, -1.36830553e-01f, 1.75558329e-01f, 1.51148066e-01f, 1.82691514e-01f, 6.98468834e-02f, 2.40835667e-01f,
  3.47919613e-02f, -1.51556835e-01f, 5.00776947e-01f, 1.02720685e-01f, 1.70809925e-01f, 7.65085220e-02f, -1.54591978e-01f, 2.53046870e-01f, 5.92232235e-02f, -2.83529982e-02f,
  -1.72397897e-01f, 1.40101820e-01f, 1.81194022e-01f, 9.30491537e-02f, 8.36902764e-03f, 1.27396673e-01f, 1.78052545e-01f, 2.07299054e-01f, 3.49976830e-02f, -3.61255696e-03f,
  -1.73724461e-02f, 1.08482853e-01f, 2.88245976e-01f, 4.73616496e-02f, -8.88584554e-02f, 1.47732735e-01f, -1.80168115e-02f, 1.19138211e-01f, -1.82824314e-01f, 1.26030132e-01f,
  -1.72292486e-01f, -2.77316689e-01f, -8.56741071e-02f, 1.46987498e-01f, -4.68820333e-02f, 1.81249797e-01f, 5.96549101e-02f, -1.13961488e-01f, -1.62306800e-01f, 4.78916168e-02f,
  1.93956912e-01f, 2.26220846e-01f, 2.72765279e-01f, 1.20985746e-01f, -2.37980038e-01f, -2.42892921e-01f, -2.39717454e-01f, -3.62761080e-01f, 5.26959933e-02f, 2.28049949e-01f,
  2.56487802e-02f, 4.11163047e-02f, 2.57551014e-01f, -8.59300420e-02f, -8.98489431e-02f, 6.39017001e-02f, -1.79904893e-01f, 2.03790069e-01f, 3.44078273e-01f, -3.03727269e-01f,
  7.14353859e-01f, 1.03501625e-01f, 4.60393578e-02f, -2.27183327e-01f, -1.82163909e-01f, -1.10868094e-02f, 9.00622904e-02f, 5.85697532e-01f, 4.20618087e-01f, 2.80769825e-01f,
  1.55215636e-01f, -1.92408040e-01f, -1.92296922e-01f, 1.15041658e-01f, 1.94684818e-01f, 1.99583784e-01f, 1.55089289e-01f, -3.25971805e-02f, -4.51798132e-03f, 2.83882786e-02f,
  -1.04450896e-01f, 7.65799955e-02f, -5.84872160e-03f, -1.33756831e-01f, -2.87285782e-02f, 1.09963030e-01f, 3.21697481e-02f, 1.43368952e-02f, 6.64159730e-02f, 1.73479885e-01f,
  -1.05753001e-02f, -1.19723389e-02f, 1.88071549e-01f, -1.40638113e-01f, 1.14459552e-01f, 1.04184754e-01f, 9.75292251e-02f, 5.96302226e-02f, 1.76181197e-01f, -2.16783956e-01f,
  2.53865626e-02f, 1.75915480e-01f, 7.59340897e-02f, -2.07525343e-01f, -1.04602389e-01f, -2.46481985e-01f, -6.75577223e-02f, 1.68310568e-01f, -9.58548933e-02f, -5.49411699e-02f,
  -1.13000803e-01f, 4.62093145e-01f, 2.14892551e-01f, 1.25905946e-02f, 4.89655048e-01f, 4.04534459e-01f, -3.19181494e-02f, 1.38406128e-01f, 1.46052539e-01f, 1.51763290e-01f,
  1.98574618e-01f, 2.62243718e-01f, -3.25127169e-02f, 6.48852885e-02f, -2.98628211e-01f, 3.51946682e-01f, 2.42116436e-01f, 4.13951397e-01f, 2.94378102e-01f, 3.53851798e-03f,
  -1.59471571e-01f, 8.48066509e-02f, -4.05641675e-01f, -7.02947751e-02f, -8.08077231e-02f, 8.63279626e-02f, 2.64500119e-02f, 1.35973379e-01f, -7.71411881e-02f, 2.98288405e-01f,
  1.17625587e-01f, 6.43892959e-02f, 1.05114259e-01f, -7.35012665e-02f, 1.18872292e-01f, 2.97186881e-01f, -1.14696145e-01f, 1.00953929e-01f, 6.21437393e-02f, 9.42609757e-02f,
  3.83871160e-02f, 1.52326614e-01f, 1.88992739e-01f, 5.89238405e-02f, -1.79469690e-01f, 4.62122977e-01f, -2.53965080e-01f, 1.86805084e-01f, -1.57134995e-01f, 1.31473318e-02f,
  -2.61817575e-01f, 1.50453657e-01f, 1.10187970e-01f, 3.49622406e-02f, 1.21371269e-01f, -1.35838181e-01f, 2.81717777e-01f, 3.34233651e-03f, 1.18322015e-01f, 1.38744310e-01f,
  5.95859718e-03f, -3.02064121e-02f, 2.03192562e-01f, 5.16272299e-02f, -2.55624712e-01f, 1.94484770e-01f, -1.17581472e-01f, 2.31289148e-01f, 1.08196326e-01f, -3.73851776e-01f,
  7.00056732e-01f, -2.12737814e-01f, -1.05511576e-01f, 2.15709820e-01f, 2.26993248e-01f, 2.40032747e-01f, -4.64400023e-01f, -1.87375575e-01f, 4.21445549e-01f, -2.85873175e-01f,
  -3.41256738e-01f, -2.77722955e-01f, -6.17597163e-01f, 3.57605904e-01f, 3.71574834e-02f, 3.25531155e-01f, 2.62647927e-01f, -4.52937372e-02f, 5.04717648e-01f, 2.35826954e-01f,
  1.52585879e-01f, 2.62686700e-01f, 1.36490196e-01f, 1.72969446e-01f, 2.88368831e-03f, 1.87225133e-01f, 7.59075806e-02f, 1.99650139e-01f, 1.01629265e-01f, 1.25152305e-01f,
  4.05117311e-02f, 1.14926428e-01f, 1.13391288e-01f, 5.14783859e-02f, 2.05750749e-01f, 1.13630950e-01f, 1.79840639e-01f, 1.96170792e-01f, 2.16777641e-02f, -2.46144727e-01f,
  -1.07540712e-01f, -1.88441068e-01f, 6.23899043e-01f, 6.49185702e-02f, -4.17445689e-01f, -1.06872357e-01f, -7.98926968e-03f, -1.29490599e-01f, -5.14819384e-01f, 1.02268539e-01f,
  1.01367325e-01f, -1.77997753e-01f, -2.46849388e-01f, 5.46122074e-01f, -1.64575875e-01f, -1.32985562e-01f, -2.39352714e-02f, 1.89762637e-01f, -3.63256842e-01f, 1.87726304e-01f,
  4.56149615e-02f, -2.99560428e-01f, 2.00279132e-01f, 3.39144051e-01f, 3.41821373e-01f, -1.23085424e-01f, -2.51260877e-01f, 4.45946962e-01f, 2.35093802e-01f, -4.95515049e-01f,
  8.88397276e-01f, 4.47336920e-02f, 1.67845711e-01f, 1.10636055e-01f, 1.56171724e-01f, 3.10467035e-01f, 1.86860468e-02f, -1.27001628e-01f, 2.22663403e-01f, 1.38342855e-02f,
  -2.32904926e-02f, 1.75056588e-02f, 8.95323977e-02f, -3.90060663e-01f, 5.38105369e-02f, 2.14097887e-01f, 8.13931152e-02f, 1.53035939e-01f, -1.04160449e-02f, 2.41138980e-01f,
  4.80060242e-02f, 2.56994218e-01f, 4.73864786e-02f, 1.00508504e-01f, 1.67090558e-02f, 1.85998961e-01f, -9.51169897e-03f, 1.10819831e-01f, 1.05787605e-01f, 1.36526123e-01f,
  2.29391232e-01f, -4.95400764e-02f, 2.37064883e-02f, 3.79589237e-02f, -7.85742402e-02f, -1.70328781e-01f, -1.46799043e-01f, 1.24367746e-02f, 4.04140770e-01f, -9.18544158e-02f,
  -2.34489828e-01f, 7.42279515e-02f, 1.32413149e-01f, -1.00258477e-01f, 1.00192107e-01f, -4.48808782e-02f, 1.46578386e-01f, 2.43103743e-01f, -2.07063481e-01f, -1.21833704e-01f,
  2.57441461e-01f, 5.26763173e-03f, -3.87682736e-01f, 2.26489484e-01f, 1.48770642e-02f, -7.58514181e-02f, 1.86499104e-01f, 4.12534356e-01f, -2.96040714e-01f, 1.41665667e-01f,
  3.87897491e-02f, 1.84712000e-03f, -1.59309879e-01f, 3.33574057e-01f, 2.40478188e-01f, -7.01512322e-02f, 5.08813977e-01f, 7.85829872e-02f, 2.69730687e-01f, 1.16484769e-01f,
  -7.40982816e-02f, 4.10621226e-01f, 4.10244405e-01f, -4.81617972e-02f, -9.65508148e-02f, 2.40494877e-01f, 1.26091957e-01f, 1.74366340e-01f, 3.07280630e-01f, 4.29548658e-02f,
  1.36847645e-01f, 3.21454048e-01f, 6.90182224e-02f, 8.13497454e-02f, 2.06914738e-01f, 3.98075543e-02f, 5.07813022e-02f, 2.99197882e-01f, 1.12520285e-01f, 3.48899007e-01f,
  1.62414223e-01f, 1.57580271e-01f, -1.02159873e-01f, 2.57255286e-01f, 3.76380444e-01f, 9.17811245e-02f, 9.84792188e-02f, 9.26962942e-02f, -1.73430473e-01f, 1.51025683e-01f,
  3.51904064e-01f, -1.69301018e-01f, -5.38897216e-01f, 5.66147491e-02f, 1.12288028e-01f, -1.30075261e-01f, -1.22620806e-01f, 7.60774165e-02f, -1.59515683e-02f, 3.70735340e-02f,
  -4.55765069e-01f, 1.54579636e-02f, -1.38348222e-01f, -1.21904112e-01f, -2.32289582e-01f, 1.67621091e-01f, -2.91971359e-02f, 4.40852702e-01f, -8.46719369e-03f, 2.20313724e-02f,
  6.40971065e-01f, -1.03788175e-01f, 4.99931574e-01f, -1.38423175e-01f, -3.79308850e-01f, 7.33589053e-01f, 5.19905746e-01f, 7.26566315e-02f, 2.59229511e-01f, -2.16105595e-01f,
  -3.89193803e-01f, 3.99063706e-01f, -5.95481098e-01f, 4.45847988e-01f, 3.63593251e-02f, -3.50213856e-01f, -1.52698427e-01f, 1.90293089e-01f, 2.45774597e-01f, -3.05173069e-01f,
  3.17215294e-01f, -2.12942332e-01f, 2.63671815e-01f, -1.50918188e-02f, 1.65573686e-01f, 7.03459010e-02f, -2.26888195e-01f, 3.98253173e-01f, 1.89059749e-01f, 5.55307269e-02f,
  6.26580864e-02f, 2.24290028e-01f, 5.97126000e-02f, 8.92951787e-02f, 4.47251312e-02f, 2.11267486e-01f, 9.85391513e-02f, 1.09861583e-01f, 7.24723861e-02f, 1.84116766e-01f,
  2.72627532e-01f, -3.04022908e-01f, 3.04165930e-01f, -1.78522557e-01f, -1.06805295e-01f, 2.15663582e-01f, 7.30654672e-02f, -1.15353398e-01f, 9.30049196e-02f, -6.19579852e-02f,
  1.66879177e-01f, 1.66266993e-01f, -3.30974668e-01f, -4.17933706e-03f, 4.30418998e-02f, -2.06373811e-01f, 3.24544795e-02f, 1.45374268e-01f, -3.16205353e-01f, 1.71423271e-01f,
  6.00917578e-01f, 1.41898811e-01f, 3.60764295e-01f, 1.19802549e-01f, -6.78143203e-02f, 3.21511656e-01f, -1.54405281e-01f, -2.10841328e-01f, -1.90455198e-01f, -4.38532501e-01f,
  2.40442336e-01f, -4.89386963e-03f, 1.67521939e-01f, 4.20630649e-02f, -3.73584181e-01f, 6.14651859e-01f, 1.95943862e-01f, 1.18282892e-01f, 3.07411551e-01f, -3.21126759e-01f,
  2.74592899e-02f, -1.05418079e-01f, 4.45883200e-02f, -1.10586472e-01f, -1.98910549e-01f, -1.84143633e-01f, 4.10469137e-02f, -5.56620210e-02f, 7.74102584e-02f, -2.42330711e-02f,
  8.28983560e-02f, 3.82141918e-02f, 1.10226914e-01f, 1.51494712e-01f, 8.25564712e-02f, 2.95014083e-01f, 1.35838717e-01f, 1.32299392e-02f, -9.14172009e-02f, -2.49769967e-02f,
  8.88845101e-02f, 7.98262507e-02f, -4.94168214e-02f, -4.63836603e-02f, 1.09207248e-02f, -6.09715022e-02f, 2.78445691e-01f, 7.50890970e-02f, 5.29125445e-02f, 1.60308018e-01f,
  -1.12304032e-01f, 9.22031179e-02f, 4.26961593e-02f, -5.01058809e-02f, 4.87702489e-02f, 2.69256365e-02f, 9.37288031e-02f, 1.37965679e-01f, -2.71008462e-01f, 1.59613594e-01f,
  1.67743564e-01f, -5.35967872e-02f, 8.72905552e-03f, -1.51719540e-01f, 4.68907744e-01f, -1.22306086e-02f, -1.04125626e-01f, 2.00248659e-02f, -2.47938232e-03f, -3.28081042e-01f,
  -3.42156626e-02f, 1.24503627e-01f, 1.45336673e-01f, 5.68530150e-02f, -2.29697913e-01f, 2.31630147e-01f, -1.84862599e-01f, 4.36138436e-02f, -5.09678006e-01f, 1.96393952e-01f,
  -1.64510787e-01f, 7.91552812e-02f, -3.80406454e-02f, 1.54184438e-02f, 1.25647530e-01f, -1.52417704e-01f, 2.33608186e-01f, 2.00859338e-01f, -2.11718604e-01f, 2.24746928e-01f,
  -6.51179329e-02f, 1.22829163e-02f, 2.22589508e-01f, 1.57830399e-02f, 1.23017594e-01f, 1.67211726e-01f, -8.14964995e-02f, 1.07350998e-01f, 1.50361866e-01f, -1.77967697e-02f,
  8.22160318e-02f, 2.57029772e-01f, -6.50819167e-02f, 4.28389609e-02f, 2.19876736e-01f, 2.49515265e-01f, 1.89078331e-01f, -7.46355578e-02f, 1.35974482e-01f, -2.36091152e-01f,
  3.79551835e-02f, 2.44165555e-01f, -4.61768918e-02f, 2.94706643e-01f, -9.08724070e-02f, 6.51183277e-02f, -1.97921216e-01f, 1.69954868e-03f, 2.64124751e-01f, -1.73035070e-01f,
  2.62971483e-02f, 1.95510209e-01f, 8.74976218e-02f, 2.38314554e-01f, 2.03367062e-02f, -3.07606328e-02f, 1.06035084e-01f, -1.13936491e-01f, 2.86552280e-01f, -3.53173733e-01f,
  3.48289698e-01f, -1.28175899e-01f, 1.74991801e-01f, 3.74906182e-01f, -4.66987640e-01f, 3.86318825e-02f, 9.46111381e-02f, 4.43681955e-01f, -3.38884681e-01f, 1.20807759e-01f,
  5.77647567e-01f, -1.58479899e-01f, 7.87404478e-02f, -1.41441092e-01f, 5.73744833e-01f, 3.49815607e-01f, 2.52537251e-01f, 5.06709814e-01f, 2.89414406e-01f, 1.98544964e-01f,
  4.97937538e-02f, 3.62570912e-01f, 2.72259295e-01f, 4.25282091e-01f, 2.39168629e-01f, -7.53537461e-04f, -7.72798508e-02f, 2.20623463e-01f, 4.04661857e-02f, -4.57606949e-02f,
  7.87930563e-02f, 1.61658511e-01f, 7.54794851e-02f, 1.06070206e-01f, -4.60441709e-02f, 1.85637876e-01f, -1.28365578e-02f, 1.85082048e-01f, 1.54425159e-01f, 8.45552757e-02f,
  -1.76201353e-03f, -1.35752469e-01f, -2.43384540e-01f, 3.20338368e-01f, -3.30712199e-01f, -5.56047820e-02f, -2.26341844e-01f, -2.61739612e-01f, 1.65457606e-01f, -1.02145784e-01f,
  2.07691528e-02f, -2.52768658e-02f, 9.84770358e-02f, 1.14276052e-01f, -3.99149731e-02f, -1.96828544e-01f, 3.16777319e-01f, -1.15977094e-01f, 1.09757796e-01f, 1.30721226e-01f,
  -1.46483341e-02f, -8.58082622e-02f, 1.85700446e-01f, -8.72602127e-03f, 3.19203794e-01f, 1.73947856e-01f, -2.35330880e-01f, -1.97439000e-01f, 5.15372336e-01f, 1.81658324e-02f,
  -1.33105382e-01f, -5.26942201e-02f, 1.02490202e-01f, 3.97242069e-01f, -2.95072109e-01f, -3.86524945e-02f, 4.56837624e-01f, 4.57127899e-01f, 1.87737197e-01f, -6.28816783e-01f,
  -1.62881259e-02f, -1.45866305e-01f, -5.76333283e-03f, 5.21344185e-01f, 2.95513272e-01f, 2.06603095e-01f, -1.41826674e-01f, -2.89757669e-01f, 1.49105206e-01f, -1.61043126e-02f,
  -2.45992020e-02f, 9.26681086e-02f, 1.84908047e-01f, 1.03732966e-01f, 1.38762996e-01f, -1.63837392e-02f, 1.04016490e-01f, 4.96256985e-02f, 5.60444742e-02f, 2.20193252e-01f,
  1.77737430e-01f, 8.67547616e-02f, 2.13967964e-01f, 1.71556115e-01f, 2.48746052e-01f, 2.15995952e-01f, 1.70860529e-01f, 4.81033251e-02f, -1.58117265e-01f, -3.68745364e-02f,
  -1.21073782e-01f, -5.36034591e-02f, 1.37813345e-01f, -1.25509292e-01f, 7.18625486e-02f, -2.99059600e-02f, -3.73749644e-01f, 8.97459313e-02f, -3.09291452e-01f, -6.16967492e-02f,
  1.36523932e-01f, -7.43907783e-03f, 4.13361639e-02f, -3.70710306e-02f, -1.38505325e-01f, 1.36125132e-01f, 2.67022341e-01f, -2.88217008e-01f, 1.85486406e-01f, 2.56795973e-01f,
  3.34950954e-01f, 3.41599911e-01f, 9.42954049e-02f, 5.30154370e-02f, -2.55967956e-02f, -3.01225334e-01f, -7.35845044e-02f, -2.76645213e-01f, 4.09681052e-01f, 1.21400453e-01f,
  1.53938219e-01f, 1.44901365e-01f, -1.93953902e-01f, 1.97722465e-02f, 5.29309392e-01f, -8.71140584e-02f, -2.41868675e-01f, 1.96225658e-01f, 3.47398043e-01f, -3.13197613e-01f,
  2.58902103e-01f, -1.84008643e-01f, 2.19297156e-01f, 3.12991261e-01f, 2.47254856e-02f, 1.92845598e-01f, 1.38253167e-01f, 8.22903290e-02f, 1.30401418e-01f, 1.74561646e-02f,
  2.17576548e-01f, 1.67932346e-01f, 1.45089626e-01f, 8.03354904e-02f, 1.47105649e-01f, 2.01447606e-01f, 3.11852604e-01f, 1.33754000e-01f, -6.12502545e-02f, 5.32401390e-02f,
  2.60419864e-02f, 1.47902519e-01f, -2.01055519e-02f, -1.30947128e-01f, -2.30356336e-01f, 8.94949511e-02f, 3.98390472e-01f, 4.22860719e-02f, -2.18445994e-02f, 8.19685981e-02f,
  1.86221242e-01f, -7.57258311e-02f, 3.02450895e-01f, -4.47804704e-02f, 1.36231482e-01f, -1.08300410e-01f, -1.90358281e-01f, -1.90805390e-01f, 1.25028089e-01f, 2.87421525e-01f,
  6.04137540e-01f, -3.12719554e-01f, 1.27924874e-01f, 2.66157418e-01f, -1.84826136e-01f, -3.62863719e-01f, 5.89960590e-02f, 2.48717703e-02f, -2.93287467e-02f, -5.48349321e-01f,
  -2.23744046e-02f, 4.39292848e-01f, -6.72204375e-01f, -7.82109946e-02f, 4.46820885e-01f, 1.05047986e-01f, -1.65548220e-01f, -8.03026035e-02f, 6.45656139e-02f, 3.69367480e-01f,
  1.92669228e-01f, -2.75707066e-01f, -1.29129842e-01f, 3.78142536e-01f, 1.58719942e-01f, 2.01117203e-01f, 2.62082666e-01f, 2.18503714e-01f, -1.96879432e-02f, 1.88251942e-01f,
  1.37786850e-01f, 2.08028600e-01f, 6.38957322e-02f, 1.89120304e-02f, 4.91187274e-02f, 2.07525551e-01f, 1.08833849e-01f, 2.28011725e-03f, -1.24722630e-01f, 2.09186018e-01f,
  1.10702246e-01f, 1.70702994e-01f, 9.27455798e-02f, 2.00021327e-01f, 3.99906635e-02f, 2.52715379e-01f, -1.13964625e-01f, 2.10838526e-01f, -3.57992887e-01f, 2.50609927e-02f,
  2.32350722e-01f, -9.63374451e-02f, -2.15424061e-01f, -1.06135651e-01f, 1.98711827e-01f, -3.55681144e-02f, -1.64115652e-01f, -2.35462538e-03f, 2.47275159e-01f, -5.39013967e-02f,
  1.06744111e-01f, 2.92649746e-01f, 2.65271753e-01f, -1.95338354e-01f, 5.98969996e-01f, -1.71457261e-01f, 3.07110459e-01f, 4.04770881e-01f, 1.13162607e-01f, 1.34798005e-01f,
  -1.76005751e-01f, 8.82744268e-02f, -1.88002139e-01f, -5.17368376e-01f, -2.10514933e-01f, 5.18611729e-01f, 2.22853705e-01f, -4.14590597e-01f, 8.70401636e-02f, -1.82174668e-01f,
  4.17899072e-01f, -3.70788395e-01f, -1.02126218e-01f, 3.78599107e-01f, 1.08238176e-01f, 1.62719592e-01f, 3.40189666e-01f, 7.33384639e-02f, 1.57787919e-01f, -9.89728495e-02f,
  2.16385528e-01f, 1.28108367e-01f, 2.26711988e-01f, 2.93520093e-01f, 2.04574719e-01f, 2.35372558e-01f, 8.08177292e-02f, -3.43036465e-02f, 1.08368836e-01f, 2.08385766e-01f,
  1.08173884e-01f, 1.97922960e-01f, 1.77955166e-01f, 1.99268460e-01f, 2.93126144e-02f, 4.80645783e-02f, 1.15404405e-01f, 1.47775143e-01f, 1.55320153e-01f, -7.12936744e-03f,
  7.46390894e-02f, -2.01776087e-01f, -1.16766162e-01f, 3.14424723e-01f, 2.46166810e-01f, 4.42217011e-03f, 7.76732946e-03f, -2.01975182e-02f, 1.23304896e-01f, 1.27432853e-01f,
  1.29712641e-01f, -2.47796029e-02f, -1.01394735e-01f, 2.25011632e-02f, -1.21689141e-02f, 6.85564578e-02f, 2.68533945e-01f, 1.80443257e-01f, 7.47501194e-01f, 2.93716043e-01f,
  -4.48621251e-02f, 1.21104904e-01f, 2.55949706e-01f, 1.20622069e-02f, -2.94258237e-01f, 1.75957784e-01f, 6.88646035e-03f, -5.25097013e-01f, -1.27013877e-01f, 4.02352750e-01f,
  1.59288451e-01f, -2.88863212e-01f, 1.72552302e-01f, -2.12859884e-01f, -3.20803553e-01f, 3.54361147e-01f, -3.04873548e-02f, 4.92637783e-01f, -2.62679815e-01f, -4.92229730e-01f,
  -6.33094832e-02f, -1.31415889e-01f, 1.17524020e-01f, 2.22365573e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  1.53482243e-01f, 9.34074223e-02f, 1.29151613e-01f, 1.96773827e-01f, 2.43286207e-01f, 1.24146029e-01f, 2.32210681e-01f, 2.10219637e-01f, 2.97637731e-01f, 6.96294978e-02f,
  2.61594176e-01f, 1.70348465e-01f, 2.21902668e-01f, 2.89929546e-02f, 2.02720612e-01f, 2.35019907e-01f, 2.99765263e-02f, 2.14961082e-01f, 1.59769133e-01f, 2.61995494e-01f,
  2.00831145e-01f, 1.17125865e-02f, 1.85804561e-01f, 2.42344171e-01f, 2.26607069e-01f, 2.08485544e-01f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  3.44462216e-01f, 1.14845157e-01f, 1.00239338e-02f, 3.57909709e-01f, -3.66432995e-01f, -4.12504315e-01f, -6.84647918e-01f, -7.84393996e-02f, -5.95486104e-01f, -4.31493521e-02f,
  7.50264600e-02f, 2.63350667e-03f, -2.24611923e-01f, -2.40658790e-01f, 1.40080199e-01f, -4.66321379e-01f, 1.13658868e-01f, -3.30287665e-01f, -3.93020123e-01f, 2.46611357e-01f,
  -4.64425117e-01f, 4.18185115e-01f, -4.63650107e-01f, -3.30311209e-01f, -3.07396889e-01f, 1.81977034e-01f, -6.98437631e-01f, 8.61362889e-02f, 3.87859680e-02f, 1.59260720e-01f,
  -7.96112716e-02f, 2.03819573e-02f, 1.43586742e-02f, 1.27784923e-01f, -7.54334778e-02f, 2.09846646e-01f, 2.90557090e-02f, -5.26163615e-02f, -3.61396708e-02f, 2.67606974e-01f,
  1.44644812e-01f, 2.26045594e-01f, -4.84879315e-01f, -1.35979503e-01f, 1.19838893e-01f, 8.41333345e-02f, 1.35982245e-01f, 2.35978678e-01f, -5.59818506e-01f, -2.30818138e-01f,
  -3.25759619e-01f, 2.14959532e-01f, -2.70106569e-02f, 1.46789411e-02f, 6.56137317e-02f, -2.73208003e-02f, 9.71862674e-02f, -5.94172217e-02f, -6.39985800e-01f, -6.91996068e-02f,
  -2.51742125e-01f, -4.04698491e-01f, -3.19755942e-01f, 1.00888954e-02f, -3.67476225e-01f, 3.91769744e-02f, -1.28847778e-01f, -4.83147055e-01f, 9.47732627e-02f, -4.44560349e-02f,
  -3.13544780e-01f, 5.66808656e-02f, -2.99784094e-01f, 2.92014331e-01f, -3.63552988e-01f, -5.14530949e-02f, -3.71087909e-01f, -2.35318914e-01f, -3.61396849e-01f, -5.83893776e-01f,
  -1.77126929e-01f, -4.23152670e-02f, 5.49503118e-02f, 3.65847081e-01f, -5.69653392e-01f, -1.04748070e-01f, -4.28350955e-01f, -1.46043777e-01f, 4.56671029e-01f, 3.65728587e-01f,
  9.69505608e-02f, 2.12417647e-01f, 5.76131523e-01f, -2.32925177e-01f, -4.34735179e-01f, -6.79638684e-02f, -5.00455320e-01f, -2.66152263e-01f, -1.16396405e-01f, 3.14875990e-01f,
  2.18662232e-01f, 4.24028605e-01f, 1.65341258e-01f, 1.11914426e-01f, -5.94592355e-02f, -1.21858999e-01f, -4.77463484e-01f, 6.90328553e-02f, 1.00872353e-01f, -4.32962775e-01f,
  -1.62910566e-01f, 6.99424595e-02f, -2.24357888e-01f, 8.08036849e-02f, 2.80454218e-01f, -1.17342509e-01f, 2.17861056e-01f, -5.37049592e-01f, 1.34545878e-01f, -8.19716632e-01f,
  -2.87999511e-01f, 1.30374357e-01f, -2.10657530e-03f, 1.70365155e-01f, -3.47807258e-01f, 1.52665526e-01f, 3.94291312e-01f, 4.85214293e-02f, 2.14838549e-01f, 4.16271426e-02f,
  7.43442550e-02f, 1.32473364e-01f, 3.62612873e-01f, 1.76676020e-01f, -8.48179981e-02f, -3.31012130e-01f, -1.67053699e-01f, -8.45535398e-02f, 2.65938759e-01f, -1.76064610e-01f,
  -2.12885827e-01f, 1.63969636e-01f, 1.20531181e-02f, -2.39241183e-01f, -1.36703238e-01f, -2.09305659e-01f, -1.62874833e-01f, 2.73675114e-01f, 4.25491594e-02f, 4.55981255e-01f,
  1.99954391e-01f, -3.75454664e-01f, -9.98368710e-02f, 4.21902724e-02f, -3.74212898e-02f, -4.61440742e-01f, 4.08815444e-01f, 2.52246410e-01f, -1.74965411e-01f, -2.20716506e-01f,
  -1.69420540e-01f, 1.40978182e-02f, -2.36178696e-01f, 3.66704077e-01f, 1.14028528e-01f, -3.61027837e-01f, 9.07187816e-03f, -4.81668323e-01f, 1.99542418e-01f, 1.58293098e-01f,
  -7.86712170e-02f, -2.07970783e-01f, -4.90629002e-02f, 2.98080593e-01f, -5.80043375e-01f, 4.02660370e-02f, 4.11772668e-01f, -2.41912708e-01f, -9.18371141e-01f, 1.88738495e-01f,
  -4.77009177e-01f, -7.16441393e-01f, -1.98307335e-01f, 2.31703117e-01f, 2.53922373e-01f, 5.42791076e-02f, -2.09948733e-01f, -2.92199016e-01f, 1.39818251e-01f, 2.40586415e-01f,
  7.12614059e-02f, 4.14432228e-01f, -1.52161002e-01f, -7.91608691e-02f, 2.30448216e-01f, -1.63922265e-01f, -2.40063630e-02f, 3.83900665e-02f, 2.58711725e-01f, 1.18161432e-01f,
  1.96953505e-01f, 1.34862736e-01f, -1.39088616e-01f, -2.55217880e-01f, -3.37178037e-02f, -1.28907636e-01f, -4.24175471e-01f, 7.69676566e-02f, 1.25272602e-01f, 5.14454162e-03f,
  9.23400372e-02f, -1.91482425e-01f, 1.71902534e-02f, -2.82907277e-01f, 3.30955148e-01f, -1.81878041e-02f, 2.28040352e-01f, -2.39679694e-01f, -2.33761445e-02f, -5.15319444e-02f,
  4.87179160e-01f, 6.39944673e-02f, 3.42324376e-01f, 3.07191730e-01f, 5.96704245e-01f, 1.36110738e-01f, 4.59553957e-01f, 1.42028436e-01f, -2.60181397e-01f, 1.73364326e-01f,
  -8.93869400e-01f, 1.68222845e-01f, -3.98555517e-01f, 2.82462150e-01f, -5.92438042e-01f, -8.40442836e-01f, -5.11515975e-01f, 3.34426224e-01f, 4.34898823e-01f, -2.22748339e-01f,
  3.93035322e-01f, 1.60795599e-01f, -6.08144581e-01f, -1.04004502e-01f, 2.44659856e-01f, 2.51584440e-01f, -7.80168474e-01f, 3.37275594e-01f, -5.25426380e-02f, -5.94807193e-02f,
  -6.65215194e-01f, -9.70356017e-02f, -4.04001266e-01f, -1.59460887e-01f, -2.08692670e-01f, -3.97314519e-01f, -8.59593693e-03f, -3.08719296e-02f, 3.64538550e-01f, 1.18306227e-01f,
  -3.74392539e-01f, 3.38399485e-02f, 2.21971110e-01f, 3.62136811e-02f, 2.55302101e-01f, -2.59407982e-03f, -2.52487093e-01f, 2.92914033e-01f, 2.81143114e-02f, -1.43704474e-01f,
  2.98721075e-01f, 5.39965391e-01f, -1.72434226e-01f, 3.40175480e-01f, 3.25483650e-01f, -6.47821724e-01f, 2.81418830e-01f, 3.35249484e-01f, -7.44900778e-02f, -2.41367310e-01f,
  -1.42220333e-01f, 2.20205113e-01f, 4.64541972e-01f, -1.79418921e-01f, -3.26277196e-01f, 3.46819371e-01f, 3.08412135e-01f, 1.07659929e-01f, -2.41867453e-01f, 6.40861571e-01f,
  -3.38081717e-02f, -2.16308624e-01f, -1.59829780e-01f, 1.77892476e-01f, -1.73968196e-01f, 9.94257163e-03f, -3.84664774e-01f, 1.20440803e-01f, 2.42715001e-01f, 5.71705736e-02f,
  -7.28767574e-01f, -1.22272976e-01f, -2.04649076e-01f, 1.59190461e-01f, 2.69511759e-01f, 2.52827466e-01f, -1.30336225e-01f, -7.59020001e-02f, -5.81760943e-01f, 2.16974497e-01f,
  -7.39037171e-02f, 1.33018970e-01f, 3.17936152e-01f, -5.14505729e-02f, -2.14739248e-01f, 1.12714045e-01f, 2.62069046e-01f, -1.88815087e-01f, -4.65411067e-01f, -4.79431003e-01f,
  -1.73089430e-01f, 5.78128323e-02f, 1.94332257e-01f, 3.58975738e-01f, 1.16422839e-01f, 1.88999102e-01f, 3.39445770e-02f, 9.10839438e-02f, 1.73906490e-01f, 3.02878991e-02f,
  -2.14659572e-01f, -4.69994843e-02f, 4.12528604e-01f, 2.14995921e-01f, -1.63160577e-01f, 1.93776369e-01f, 3.09571892e-01f, -3.42474692e-02f, 3.01741660e-02f, 2.46256456e-01f,
  1.17138579e-01f, -4.40725237e-01f, 1.00384101e-01f, 8.16834271e-02f, 1.13779664e-01f, 3.88588876e-01f, -3.84315461e-01f, -4.64964807e-01f, -6.62831545e-01f, 1.65484041e-01f,
  3.75782847e-01f, -3.49341691e-01f, 1.55036375e-01f, -4.47727293e-01f, -4.14763540e-01f, -1.46931842e-01f, -2.90803522e-01f, -1.22211590e-01f, -1.21823087e-01f, 1.67032376e-01f,
  3.03849071e-01f, -2.37951398e-01f, 6.32816553e-02f, 2.72653371e-01f, -2.02042505e-01f, -6.05581939e-01f, -1.14393726e-01f, -1.21655211e-01f, -6.90499902e-01f, -3.47932339e-01f,
  -1.62803810e-02f, -2.07893863e-01f, -2.86289603e-01f, 4.15686578e-01f, 1.72350369e-02f, -1.80973709e-02f, -5.06833531e-02f, -2.29408965e-04f, 1.07249141e-01f, -3.56375813e-01f,
  3.32958668e-01f, -2.04038426e-01f, 1.18847735e-01f, 1.47054374e-01f, -2.09249049e-01f, 3.12274806e-02f, 1.22313909e-01f, -2.13599075e-02f, -3.43648419e-02f, -5.91670275e-01f,
  1.20254271e-01f, 1.22070394e-01f, 4.53940481e-02f, 3.10895825e-03f, -2.01611549e-01f, -9.24024656e-02f, -6.51787519e-02f, -1.99013531e-01f, 1.14164306e-02f, 7.29593486e-02f,
  2.06138790e-01f, -5.65826595e-02f, -3.62050012e-02f, -6.01449370e-01f, 1.74526751e-01f, -2.92451143e-01f, 2.05933690e-01f, 1.68341547e-01f, 1.87252134e-01f, -1.22300722e-01f,
  -1.18577100e-01f, 2.76052356e-01f, -4.45951492e-01f, -3.44795048e-01f, 2.83104777e-02f, 3.54822010e-01f, -2.41214469e-01f, -3.20579320e-01f, -3.56559306e-02f, 7.40035772e-02f,
  5.87601587e-02f, -2.82098025e-01f, 2.16834590e-01f, -4.67977494e-01f, -7.73834467e-01f, -3.49639773e-01f, 1.30282626e-01f, 3.45652223e-01f, 1.81722850e-01f, 1.79467335e-01f,
  -3.58359605e-01f, -5.79158030e-02f, 2.72280842e-01f, -6.95772707e-01f, -1.27626255e-01f, -2.60736436e-01f, -7.45982766e-01f, -5.18211246e-01f, -3.44164044e-01f, -9.10534978e-01f,
  3.28088373e-01f, 1.48793355e-01f, 7.68101588e-02f, 2.25891918e-01f, 8.24060813e-02f, 4.74468656e-02f, 3.07659179e-01f, 2.54066326e-02f, 3.66182663e-02f, -2.84543991e-01f,
  -6.39870316e-02f, 9.90438391e-04f, -1.51819006e-01f, -1.08917333e-01f, 3.24612553e-03f, -1.83076590e-01f, -2.46865377e-01f, -1.65397152e-01f, -1.14183828e-01f, 2.65590072e-01f,
  2.14992970e-01f, -1.33292377e-01f, 7.48519227e-02f, 1.29257292e-01f, -2.68043578e-01f, 4.53970343e-01f, -2.37392768e-01f, 4.52966362e-01f, -7.19631314e-02f, 4.21682477e-01f,
  4.17171061e-01f, 2.60860801e-01f, -4.77904677e-01f, -4.91748959e-01f, 5.00561781e-02f, 6.15646169e-02f, -1.90156568e-02f, -4.54118669e-01f, -1.68765217e-01f, 3.81926268e-01f,
  2.97112435e-01f, 9.62373465e-02f, -2.02843711e-01f, -2.40703538e-01f, -1.05178263e-02f, -1.35590124e-03f, -2.70812511e-01f, -5.72789311e-01f, -1.01721913e-01f, -1.52703837e-01f,
  -2.03676477e-01f, -1.06624722e-01f, 4.25471775e-02f, 3.72338176e-01f, 3.07012737e-01f, -3.60072583e-01f, -4.86267388e-01f, 2.81121671e-01f, -1.59904901e-02f, -1.47940442e-01f,
  -1.04792856e-01f, 1.80481285e-01f, -3.28433439e-02f, 2.17299342e-01f, -4.39324141e-01f, 2.34193161e-01f, 2.02019826e-01f, -1.71189204e-01f, -3.55644882e-01f, -2.21360058e-01f,
  -4.89661336e-01f, -3.08424026e-01f, -2.58337031e-03f, -1.40222594e-01f, -2.81643808e-01f, -1.13893740e-01f, -8.78347382e-02f, -9.16300341e-02f, 3.28567892e-01f, 8.93964395e-02f,
  9.25441012e-02f, 5.02370149e-02f, 2.87969857e-01f, -1.57344043e-02f, -1.22740917e-01f, -8.22537765e-02f, 3.40623796e-01f, 4.01423544e-01f, 2.30102092e-01f, 1.17174640e-01f,
  6.79962710e-02f, -5.68162322e-01f, 3.16011429e-01f, -1.02896146e-01f, -3.36032838e-01f, 2.42664188e-01f, 2.58828342e-01f, -3.94079447e-01f, -3.67688298e-01f, -2.01934144e-01f,
  2.69281477e-01f, -3.13558936e-01f, 4.32460576e-01f, -4.92066562e-01f, 6.99387014e-01f, -2.28873700e-01f, 6.78669155e-01f, -1.54566482e-01f, 1.56833917e-01f, 1.26759216e-01f,
  -1.56312674e-01f, -1.45536155e-01f, 1.44273221e-01f, -5.63130915e-01f, -4.02532429e-01f, -1.77336574e-01f, 2.76459247e-01f, -2.11257324e-01f, -5.18089771e-01f, -6.05538070e-01f,
  5.22776008e-01f, -2.24507049e-01f, -2.48476624e-01f, -9.40885022e-02f, 2.96728224e-01f, -3.55303109e-01f, 2.30718091e-01f, -2.10413173e-01f, -1.13796957e-01f, -1.75557360e-02f,
  3.45162570e-01f, -6.33777797e-01f, -6.02355063e-01f, 3.67271304e-01f, 5.85332736e-02f, 2.84351498e-01f, -9.08720270e-02f, -3.93178403e-01f, 1.71259642e-01f, -3.19950849e-01f,
  2.10052859e-02f, -8.60178620e-02f, 8.78065675e-02f, -1.63326681e-01f, 1.80079266e-01f, -1.12119094e-02f, 1.93058401e-01f, -3.37486714e-01f, -6.14297530e-03f, -2.09931463e-01f,
  1.92931294e-02f, -1.88637692e-02f, 1.55540332e-01f, -2.00315230e-02f, -2.64367640e-01f, 2.47167304e-01f, 2.73038566e-01f, -6.16297266e-03f, 6.11760691e-02f, 5.99075966e-02f,
  -5.04089594e-01f, 2.08437983e-02f, 3.60295594e-01f, 4.05563384e-01f, -1.11378305e-01f, 4.46185321e-02f, -5.56379382e-04f, 2.44213715e-01f, -2.61716604e-01f, 3.58137429e-01f,
  -2.55500019e-01f, -1.13195188e-01f, 3.79821993e-02f, 2.91515112e-01f, 3.37025106e-01f, -4.66694593e-01f, 5.26051000e-02f, -5.80668151e-01f, 3.33136678e-01f, -2.67135590e-01f,
  1.09795313e-02f, 2.06181988e-01f, -8.12907040e-01f, 2.17464373e-01f, -7.53497481e-01f, 9.81310979e-02f, -1.00781530e-01f, 3.16491425e-01f, -3.66175175e-01f, -2.14668304e-01f,
  -2.35115644e-02f, -3.08281183e-01f, 8.98975506e-02f, -4.48592454e-01f, 2.29506552e-01f, -1.39619425e-01f, -3.98847200e-02f, -5.51895618e-01f, 4.16980572e-02f, -3.54606688e-01f,
  1.05252810e-01f, 8.00220668e-02f, -1.11708619e-01f, 4.48268373e-03f, -9.17659253e-02f, -1.00330420e-01f, 6.24792241e-02f, 9.85022038e-02f, -2.40213126e-01f, -3.42923164e-01f,
  1.53925627e-01f, 2.07251012e-01f, -5.59922354e-03f, 1.00861877e-01f, 1.39855996e-01f, 1.83088735e-01f, -4.38318402e-01f, 1.02215506e-01f, 6.17075711e-02f, -2.24543035e-01f,
  2.14643285e-01f, -6.00135289e-02f, -3.14032346e-01f, 3.18831682e-01f, 2.69458592e-01f, -3.28841448e-01f, 3.11576605e-01f, -3.33190441e-01f, 2.68927604e-01f, 4.16239321e-01f,
  -5.20119548e-01f, -4.58773077e-01f, 1.80099428e-01f, 4.14645910e-01f, 4.05810773e-01f, 2.91816920e-01f, 4.82228905e-01f, -2.92197049e-01f, -4.11614150e-01f, 2.81407058e-01f,
  1.63362831e-01f, 2.95482934e-01f, -2.62253940e-01f, -3.56459260e-01f, -6.25329673e-01f, -2.05327958e-01f, 2.12517232e-01f, -6.01172507e-01f, -1.59062341e-01f, 9.55202505e-02f,
  2.71148592e-01f, -5.33657491e-01f, 1.89555749e-01f, 4.67527471e-02f, 4.01277728e-02f, -4.05441314e-01f, -1.68343067e-01f, -8.58377695e-01f, -4.71441865e-01f, 2.58682936e-01f,
  2.36108750e-01f, 4.12217975e-01f, -5.62787354e-01f, -2.16961935e-01f, 2.27512732e-01f, 2.70731837e-01f, -2.96042383e-01f, 9.94128883e-02f, 4.39720694e-03f, 1.20422967e-01f,
  1.26876205e-01f, 3.36638950e-02f, 1.33937329e-01f, 1.17299482e-01f, 2.40988925e-01f, 2.61963397e-01f, -6.77715801e-03f, 2.75240779e-01f, 1.17894895e-01f, 2.11536780e-01f,
  1.84590910e-02f, 1.47513235e-02f, 1.34351164e-01f, -4.80382949e-01f, -4.69908923e-01f, -2.57554442e-01f, 4.43946719e-01f, 6.69258609e-02f, -2.82426864e-01f, -4.26960081e-01f,
  2.72506118e-01f, 4.16991949e-01f, -4.30835307e-01f, -3.56485784e-01f, 1.36965215e-01f, 6.14219606e-02f, 2.83402056e-01f, 6.10619672e-02f, 3.04260552e-01f, -3.68553370e-01f,
  3.97664905e-01f, -2.77293324e-01f, -2.18222067e-01f, -5.74901164e-01f, -5.74541986e-01f, 1.19842902e-01f, 2.50871181e-01f, -2.52489477e-01f, 1.96092073e-02f, -3.56561631e-01f,
  -3.30485916e-03f, -4.00936365e-01f, 1.08151868e-01f, -2.07054645e-01f, 3.22132230e-01f, -3.84817570e-01f, 4.44263697e-01f, -2.56383628e-01f, -3.82646680e-01f, 4.55087632e-01f,
  -2.16357365e-01f, -2.87363350e-01f, -1.92808136e-01f, 3.43098789e-01f, 3.86895210e-01f, -3.24774802e-01f, 2.40919217e-01f, -3.38325590e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -5.69648817e-02f, 1.94853507e-02f, 1.99307594e-02f, -9.02373791e-02f, -1.22109637e-01f, 3.68087403e-02f, -4.75726500e-02f, 6.21785223e-02f, 8.91965907e-03f, -1.11105390e-01f,
  -1.42196149e-01f, 1.71116114e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    