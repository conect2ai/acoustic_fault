/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.06993276e-01f, -1.25318363e-01f, -7.89789185e-02f, 3.45064816e-03f, 9.44376513e-02f, -1.88327923e-01f, -1.05949640e-01f, 5.80414273e-02f, -9.07860845e-02f, -7.70448670e-02f,
  -7.84181431e-02f, -1.97980553e-01f, -1.92691728e-01f, -1.63467839e-01f, -1.18033171e-01f, -2.27475211e-01f, -6.47484064e-02f, -4.90990691e-02f, -5.91272376e-02f, -1.05096074e-02f,
  7.56194070e-02f, 9.51704010e-03f, -7.39795789e-02f, 1.57729253e-01f, 1.03967004e-01f, 1.13819942e-01f, 1.57270968e-01f, 7.16971280e-03f, 5.60030900e-02f, -4.87539247e-02f,
  1.91655345e-02f, -9.68689099e-02f, 3.70919220e-02f, -3.83293442e-02f, -1.99937783e-02f, 6.99859932e-02f, 5.64092435e-02f, -4.52407934e-02f, -1.97747406e-02f, -6.07960299e-02f,
  -9.45113078e-02f, -9.29755121e-02f, 2.62021786e-03f, 4.60420996e-02f, -1.00458469e-02f, -7.86553845e-02f, 1.40824972e-03f, 6.27264902e-02f, -5.63941263e-02f, -4.57563885e-02f,
  1.61876634e-03f, -3.59792151e-02f, -2.36050561e-02f, -5.51270097e-02f, 2.90473327e-02f, -5.73674552e-02f, -6.93473220e-02f, -2.00757459e-02f, -5.78305796e-02f, -3.39496732e-02f,
  7.46034225e-03f, -1.49140917e-02f, 4.08113785e-02f, 3.10660005e-02f, 1.33134583e-02f, 8.50043595e-02f, -7.35020638e-02f, -5.02461903e-02f, 6.01207204e-02f, -3.46558951e-02f,
  3.25840637e-02f, -2.52641719e-02f, -3.09891962e-02f, -3.79347950e-02f, 2.04538684e-02f, 2.13116966e-02f, 5.41405380e-03f, -3.01384050e-02f, -8.10517184e-03f, 1.76018139e-03f,
  -2.02557240e-02f, -3.60185504e-02f, 2.08151806e-02f, 1.66172571e-02f, -7.40180165e-02f, 3.49260261e-03f, -1.62546169e-02f, 7.99106900e-04f, 1.19397300e-03f, -1.32198511e-02f,
  -1.19219832e-01f, -2.68747471e-02f, -4.74756546e-02f, -6.68154098e-03f, -2.04313211e-02f, -3.42782401e-02f, -5.63509874e-02f, 8.78680274e-02f, -3.61852683e-02f, 2.64118407e-02f,
  6.07402027e-02f, 6.56085610e-02f, 2.81165708e-02f, -5.28687015e-02f, -5.20997085e-02f, 3.91323604e-02f, -7.80107901e-02f, 1.78608000e-02f, 6.44021258e-02f, 2.09553856e-02f,
  2.18471978e-03f, -5.06464243e-02f, 5.27503958e-04f, 6.73518777e-02f, -1.82517769e-03f, -2.85436735e-02f, 3.94647047e-02f, -2.33895928e-02f, 2.79376358e-02f, -2.62123216e-02f,
  2.28963524e-01f, -2.11657092e-01f, 2.48318464e-01f, -8.10524747e-02f, 6.92070127e-02f, -1.76328123e-01f, -1.37815952e-01f, -1.16395846e-01f, -2.31994674e-01f, -3.55479807e-01f,
  -1.33062690e-01f, -1.05193280e-01f, -7.69506469e-02f, -2.66759694e-01f, 1.78279921e-01f, -1.99057087e-01f, -7.53675997e-02f, -1.28536433e-01f, 3.43871303e-02f, -6.40742183e-02f,
  1.49769885e-02f, -1.03621505e-01f, 1.52845290e-02f, 7.27438927e-02f, -1.86325982e-02f, 5.35639040e-02f, 6.88473880e-02f, 2.26747662e-01f, -5.48959970e-02f, 6.95419163e-02f,
  -9.29211359e-03f, -1.36017233e-01f, 7.30935410e-02f, 5.45196943e-02f, 7.88139924e-02f, 8.83611739e-02f, 7.59457722e-02f, 8.73933360e-02f, 2.21188907e-02f, 2.01119967e-02f,
  8.59910101e-02f, -1.66519880e-02f, -1.63353868e-02f, 7.70956650e-03f, 3.62715125e-02f, 1.09241664e-01f, -5.29524311e-02f, -1.02017531e-02f, -3.55909579e-02f, -6.22870773e-03f,
  1.24297757e-02f, 3.34434099e-02f, -5.74448332e-03f, -3.40004526e-02f, 2.51509249e-02f, -6.52188957e-02f, -5.95316626e-02f, 8.54073539e-02f, 1.39673715e-02f, -3.89536805e-02f,
  4.82762866e-02f, -6.10294659e-03f, 6.68807328e-02f, -1.65317580e-02f, 1.45359710e-02f, 3.51205431e-02f, -1.01265535e-01f, 2.12487541e-02f, 5.59915602e-02f, -1.80674810e-02f,
  -2.33833818e-03f, -5.21172211e-02f, -4.19526286e-02f, -2.90758871e-02f, -1.87773630e-02f, -4.76896949e-02f, 2.41584089e-02f, 1.94844492e-02f, -2.73761638e-02f, -1.25072096e-02f,
  -1.70196909e-02f, -2.47700401e-02f, -1.65334120e-02f, 1.80389285e-02f, -1.10081844e-02f, 2.93858559e-03f, 5.91604365e-03f, -4.98532355e-02f, 3.76686081e-03f, 5.02635650e-02f,
  -1.17010370e-01f, -1.52643621e-01f, -1.24974847e-01f, -1.23979729e-02f, 5.95390284e-03f, 3.88202704e-02f, 5.97067475e-02f, 2.17779074e-02f, -2.81284004e-02f, 1.17659029e-02f,
  -4.19259258e-03f, -8.28267448e-03f, 2.84252241e-02f, 2.24260464e-02f, 2.34413128e-02f, -5.67989498e-02f, 4.77602631e-02f, 3.17139402e-02f, -3.04642785e-02f, -2.35712007e-02f,
  -5.61577128e-03f, -4.94679958e-02f, 9.62831452e-03f, 5.58931753e-02f, -5.43334857e-02f, 4.62457165e-03f, 1.81431174e-02f, -2.60544382e-02f, 4.78787124e-02f, -1.09984457e-01f,
  -3.01177204e-01f, -1.84524417e-01f, -1.73815116e-01f, -1.54040694e-01f, 1.97878033e-02f, 1.07512087e-01f, 7.18201548e-02f, -5.72994873e-02f, -1.36239424e-01f, 1.96203496e-02f,
  8.87692049e-02f, -1.77506432e-01f, -2.85567492e-02f, -2.13578194e-01f, -7.24447817e-02f, -3.15986983e-02f, -1.31943464e-01f, -9.47329104e-02f, -1.11503974e-01f, -4.03897949e-02f,
  -4.14558202e-02f, 5.84626459e-02f, -1.10020787e-01f, 1.39827967e-01f, -2.19079256e-02f, 3.78548801e-02f, 6.69273287e-02f, 5.47431856e-02f, -3.21176648e-02f, 1.48236966e-02f,
  7.75379017e-02f, -6.22629710e-02f, -2.84553855e-03f, -3.89576107e-02f, 2.25841142e-02f, 4.34851088e-02f, -9.48831718e-03f, 1.67050585e-02f, 6.05078749e-02f, 3.87690738e-02f,
  1.82070043e-02f, 3.19357007e-03f, -6.30974621e-02f, -6.11212812e-02f, -9.25845467e-04f, -7.50065297e-02f, -8.44484568e-03f, -2.27628704e-02f, -2.32208055e-02f, 1.07500411e-03f,
  1.55690964e-02f, -2.36367956e-02f, 5.46084046e-02f, 1.88585743e-02f, -7.56011391e-03f, -1.23044094e-02f, 6.52083680e-02f, -5.04889386e-03f, 6.08286122e-03f, 3.12238354e-02f,
  9.43673961e-03f, -2.43189000e-02f, -3.46168056e-02f, -5.42101189e-02f, 6.69091241e-03f, 4.45525646e-02f, -2.44957563e-02f, 5.23571745e-02f, 1.19456192e-02f, -2.20460747e-03f,
  1.85310878e-02f, 2.04679333e-02f, -6.08433911e-04f, -2.27873605e-02f, 3.84427384e-02f, -8.14351216e-02f, -5.78342266e-02f, 2.54363921e-02f, 1.50961308e-02f, -2.78408155e-02f,
  -4.48087463e-03f, -4.68138419e-02f, 5.64370230e-02f, 3.92276794e-02f, -1.97173711e-02f, 3.32235061e-02f, -2.24904157e-02f, 2.61611789e-02f, 1.09277805e-02f, 3.66870947e-02f,
  9.03744530e-03f, -1.30186761e-02f, 9.01926979e-02f, 5.36205508e-02f, 2.37604287e-02f, -5.12650013e-02f, -7.44326189e-02f, -4.69962414e-03f, 1.62932891e-02f, -1.22842845e-02f,
  2.51611844e-02f, 3.50122973e-02f, -8.73867143e-03f, 3.31945010e-02f, 4.44759205e-02f, 3.59541103e-02f, 2.99054440e-02f, -1.88778378e-02f, -1.81138162e-02f, -1.54789258e-02f,
  -3.42190638e-02f, 4.27369587e-02f, -1.04469236e-03f, -1.62721593e-02f, 2.94817463e-02f, 1.45006611e-03f, -7.33601581e-03f, -5.32978866e-03f, 3.49256955e-03f, 5.13649620e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.39354271e-01f, 7.18117654e-02f, -1.88200444e-01f, -1.10547215e-01f, -3.35653462e-02f, -4.76367712e-01f, -2.41232589e-01f, 6.39701560e-02f, 9.66014341e-02f, 1.21494934e-01f,
  -5.45659438e-02f, 6.72054067e-02f, 1.68561637e-01f, -9.82055161e-03f, -2.21363470e-01f, 1.35679409e-01f, -3.11163068e-01f, -1.97941348e-01f, 8.59214589e-02f, -1.71183005e-01f,
  -1.02900684e-01f, -7.44173825e-02f, -5.99847622e-02f, 7.23212361e-02f, -1.34452641e-01f, 1.12821087e-02f, 5.12027256e-02f, 1.20100938e-01f, -1.78308427e-01f, -3.00176069e-02f,
  -7.31613636e-02f, 7.34744892e-02f, 6.68335333e-02f, -8.82545661e-04f, -1.77919030e-01f, -1.43536493e-01f, -9.29917246e-02f, 3.82609405e-02f, -5.22430334e-03f, -4.73426096e-02f,
  -3.45743746e-02f, -3.05680875e-02f, -5.37744686e-02f, 1.56559907e-02f, -2.07124650e-02f, 3.95194441e-02f, 1.18190303e-01f, -5.64879291e-02f, 1.19247325e-02f, 2.08724514e-02f,
  6.80547440e-03f, 8.54108203e-03f, 1.31982192e-03f, -4.93960530e-02f, -7.42569864e-02f, 4.64397073e-02f, -1.34757312e-03f, 1.59810055e-02f, -1.76468611e-01f, -8.77805278e-02f,
  -4.11915928e-02f, -8.32878128e-02f, 5.24385273e-02f, 2.22429708e-02f, -7.73120439e-04f, 5.36348205e-03f, -2.48948787e-03f, 2.41546258e-02f, -4.38527651e-02f, 1.72194894e-02f,
  -7.56926686e-02f, 2.94168852e-02f, 1.80961043e-02f, -7.58032873e-02f, -1.11617401e-01f, -8.60923380e-02f, -1.74979642e-02f, 5.16861826e-02f, -7.13929534e-02f, 9.94522218e-03f,
  9.38211083e-02f, 2.27870420e-02f, -3.69379087e-03f, 1.63012147e-02f, -9.04180780e-02f, -3.63778435e-02f, -6.47974084e-04f, 4.50088829e-02f, 5.09084761e-02f, -7.23108202e-02f,
  -1.70424983e-01f, -4.88478504e-02f, 1.31467223e-01f, 7.93558732e-02f, 3.33193652e-02f, 2.34173890e-02f, 4.64974009e-02f, -2.89612468e-02f, 2.06566043e-02f, -1.14091476e-02f,
  -4.25799191e-02f, -5.46474233e-02f, -1.18944287e-01f, 3.72758284e-02f, -7.10269660e-02f, -3.55400331e-02f, 7.58554926e-03f, -4.25796509e-02f, -1.00672886e-01f, 1.81098618e-02f,
  -1.61937736e-02f, -5.25009222e-02f, 3.99621651e-02f, -9.97124799e-03f, -9.77989659e-02f, -1.24994898e-02f, -1.42298773e-01f, 2.36489009e-02f, -4.23699915e-02f, -6.91606626e-02f,
  -1.02243744e-01f, 2.15300888e-01f, -1.34621963e-01f, 6.09490573e-02f, 6.60426691e-02f, 2.77446628e-01f, 2.84316212e-01f, 1.09477922e-01f, 1.50034931e-02f, 2.40188837e-01f,
  2.43078247e-01f, -1.21736944e-01f, 5.22825755e-02f, 2.82537103e-01f, 4.67477590e-02f, 6.17897511e-02f, 1.87897176e-01f, 1.28870428e-01f, -1.32945970e-01f, 8.26876834e-02f,
  -1.61368266e-01f, 1.96447089e-01f, -8.18591341e-02f, -1.40721589e-01f, 4.07967493e-02f, -2.32948333e-01f, 8.06670189e-02f, -1.86875120e-01f, 1.14490949e-01f, 2.47817952e-02f,
  8.55146796e-02f, -5.70656322e-02f, -1.05014153e-01f, -1.09501578e-01f, -2.14951653e-02f, -6.46605790e-02f, 9.19293985e-03f, -7.65895769e-02f, -2.44434197e-02f, -2.96319574e-02f,
  6.04172871e-02f, -7.46959820e-02f, 3.19221951e-02f, -8.91142562e-02f, -8.52311775e-03f, 1.24666421e-02f, 6.03749081e-02f, 1.15562472e-02f, 5.01303263e-02f, -6.36179745e-02f,
  3.72585282e-02f, 2.77158804e-02f, 8.73309672e-02f, -1.39278527e-02f, 9.39402916e-03f, -4.87846769e-02f, -1.99623220e-02f, -3.01601272e-02f, 6.87396601e-02f, 1.22604324e-02f,
  5.96859865e-02f, -1.44002616e-01f, 5.41601516e-02f, -3.88036519e-02f, -5.39786480e-02f, 9.02574435e-02f, 6.75001964e-02f, 1.39326286e-02f, -1.56952161e-02f, 4.80886362e-02f,
  3.11642839e-03f, 1.39305487e-01f, 1.89248305e-02f, -6.07609749e-02f, 3.76919955e-02f, 1.96124557e-02f, 1.53103620e-02f, -4.21737367e-03f, -3.66361835e-03f, 1.72470659e-02f,
  -5.58353476e-02f, -7.06677213e-02f, -4.20605540e-02f, -6.66570738e-02f, -3.70484181e-02f, -4.68017980e-02f, -8.93978693e-04f, -1.83734018e-02f, 2.26286873e-02f, 1.90912727e-02f,
  1.18694402e-01f, 4.24072444e-02f, 4.67484891e-02f, -4.02798317e-02f, 7.25797713e-02f, 6.20088466e-02f, -3.96380685e-02f, -4.26623300e-02f, -1.37226284e-01f, 3.44569832e-02f,
  -1.75911328e-03f, -3.48048210e-02f, -8.52975920e-02f, -3.98680903e-02f, -7.62310922e-02f, 1.02888912e-01f, 3.43345967e-03f, -3.70673463e-02f, 5.77533841e-02f, -3.71302217e-02f,
  3.36720012e-02f, 5.95984682e-02f, -1.20885916e-01f, -1.83856282e-02f, 2.54552718e-02f, -3.39719467e-02f, -9.48321000e-02f, -3.92729416e-03f, -2.94473153e-02f, -2.80921645e-02f,
  1.68282270e-01f, 2.66391654e-02f, -3.29589337e-01f, -8.89945589e-03f, 1.19054452e-01f, 5.41761033e-02f, -1.82775125e-01f, -9.93883237e-02f, -1.19808681e-01f, 1.49508879e-01f,
  5.05668931e-02f, -2.72963438e-02f, -2.01454967e-01f, 1.15284070e-01f, 1.29690796e-01f, -2.53761709e-01f, 1.52758360e-01f, 3.81032517e-03f, 1.23116272e-02f, 5.59565574e-02f,
  1.46762580e-01f, 3.75023007e-01f, -1.28124475e-01f, 2.55889088e-01f, 2.16619402e-01f, -3.74265946e-02f, 2.55803466e-01f, -1.41761616e-01f, 2.27080569e-01f, 1.52171180e-01f,
  -4.51579764e-02f, 1.46310434e-01f, -1.09521091e-01f, 1.45104490e-02f, 1.02791153e-01f, 7.21138492e-02f, 6.03751987e-02f, -6.47793040e-02f, 2.09336635e-02f, 1.53973587e-02f,
  8.54459330e-02f, 1.54402107e-02f, 2.94618700e-02f, 1.51376188e-01f, 5.05578518e-02f, 5.11990227e-02f, -4.99270372e-02f, 2.16355268e-03f, -1.14045508e-01f, 3.87526900e-02f,
  -1.16870709e-01f, 1.62078924e-02f, 2.04971917e-02f, 3.23551707e-02f, -1.33514836e-01f, 1.06975600e-01f, 4.91066230e-03f, 6.59913942e-02f, 3.44073065e-02f, 8.75331089e-03f,
  8.92813876e-02f, 1.06592081e-01f, -8.24011937e-02f, -7.80362710e-02f, -2.42246743e-02f, -1.46397334e-02f, -2.80728545e-02f, 5.87469200e-03f, -2.32143961e-02f, 1.85565017e-02f,
  -3.50283808e-03f, -1.00499660e-01f, 5.82549013e-02f, -1.53159248e-02f, 9.31556448e-02f, -1.67196896e-02f, 3.40135433e-02f, 9.74799599e-03f, -4.48492281e-02f, -8.35569203e-02f,
  1.43806422e-02f, 1.74252484e-02f, 2.63247602e-02f, 2.61881407e-02f, 2.41559241e-02f, 3.26484665e-02f, 5.71644641e-02f, -2.65871845e-02f, -9.86533985e-02f, -9.00279060e-02f,
  5.32716960e-02f, 3.34858298e-02f, -5.42653427e-02f, -4.02189158e-02f, 2.73671653e-02f, 1.37081981e-01f, 7.48200938e-02f, 4.97217178e-02f, 1.04639931e-02f, 1.15043782e-02f,
  1.05168030e-01f, -8.51766020e-02f, 6.13853298e-02f, 1.80440824e-02f, 6.55842498e-02f, -5.19118942e-02f, -5.09398757e-03f, 8.10947269e-02f, 4.18624543e-02f, 4.40465607e-04f,
  7.60979876e-02f, 6.79508820e-02f, 1.14357851e-01f, -8.95834342e-02f, 6.37115464e-02f, 6.63055778e-02f, 8.25673342e-02f, -3.83111229e-03f, 4.68614846e-02f, -3.47079895e-02f,
  1.04938291e-01f, 1.67729676e-01f, -3.76967452e-02f, 1.03067696e-01f, 2.21652314e-02f, 2.93255419e-01f, 2.94286370e-01f, 1.18812196e-01f, 3.05582494e-01f, 1.26308471e-01f,
  -5.10455035e-02f, 9.32827443e-02f, -7.42727816e-02f, 4.60662507e-02f, 1.08758539e-01f, 4.85159867e-02f, 1.91131234e-01f, 8.25446919e-02f, 5.08420914e-02f, 5.55598363e-02f,
  -1.01295719e-02f, 7.09192008e-02f, -1.41640574e-01f, -1.19565643e-01f, -6.94643855e-02f, -2.06412897e-02f, -2.09507272e-01f, -5.89925647e-02f, -4.14719656e-02f, 4.09080461e-02f,
  4.66814041e-02f, 3.06579488e-04f, -1.05512276e-01f, -1.83198024e-02f, -3.64628737e-03f, -4.58843186e-02f, -1.11792468e-01f, -3.10090408e-02f, -9.50358361e-02f, -3.36515182e-03f,
  -1.59118567e-02f, 2.50982493e-02f, 1.30706206e-01f, 5.43484837e-02f, 5.42411655e-02f, -7.57455155e-02f, -3.39880735e-02f, -1.86669771e-02f, 3.25289220e-02f, -1.02166906e-01f,
  -1.26632512e-01f, 1.67779457e-02f, 7.34562054e-02f, 3.13701890e-02f, -4.61573480e-03f, -1.05614858e-02f, 1.15705229e-01f, 3.83964591e-02f, -3.10366321e-02f, 7.07803993e-03f,
  -1.05942152e-02f, 4.14500497e-02f, 1.60834529e-02f, -2.66677588e-02f, 3.52537230e-04f, -3.99435610e-02f, -3.98290902e-02f, 3.05503700e-02f, 1.21397510e-01f, -2.18501855e-02f,
  9.89590287e-02f, 5.99261839e-03f, -1.36099039e-02f, -2.68116519e-02f, 2.32898053e-02f, -3.40309441e-02f, 2.94487516e-04f, -5.78587465e-02f, -5.67933265e-03f, -7.29870126e-02f,
  1.37776276e-02f, -1.01942476e-02f, -4.71970215e-02f, -1.20445020e-01f, -1.62448380e-02f, 2.26790179e-02f, -1.06544541e-02f, -7.88915381e-02f, -1.08281203e-01f, 3.91741060e-02f,
  8.89253616e-02f, 1.83346987e-01f, 3.04053407e-02f, 1.91963501e-02f, 8.20543524e-03f, 3.51927541e-02f, 9.86555442e-02f, 4.61144596e-02f, 1.22556858e-01f, 3.95113304e-02f,
  -1.19249644e-02f, 7.02015013e-02f, 3.63206565e-02f, 3.75699066e-02f, -3.42980549e-02f, -8.98376014e-03f, 9.28815734e-03f, -1.80504993e-02f, 3.04590203e-02f, -1.29837543e-01f,
  -1.33976370e-01f, -8.11493397e-03f, 3.01794950e-02f, 2.21599755e-03f, -4.82193747e-04f, -8.97363350e-02f, 1.13745895e-03f, -4.84276190e-02f, -7.24488795e-02f, 7.32526109e-02f,
  -5.88938706e-02f, 1.80443466e-01f, 5.05597629e-02f, -1.81642756e-01f, -2.42617521e-02f, -2.30768248e-01f, -2.02861264e-01f, 9.22653973e-02f, -7.54537643e-04f, 2.00039163e-01f,
  8.78358185e-02f, 1.55164719e-01f, -3.01662851e-02f, -1.32431388e-01f, -4.97817039e-01f, -3.33859503e-01f, -2.43533537e-01f, -1.03699051e-01f, -7.46113211e-02f, -1.08565008e-02f,
  -2.01560780e-01f, -2.30853096e-01f, -2.57765561e-01f, -3.32039185e-02f, 3.09399180e-02f, 1.07005544e-01f, -5.85041903e-02f, -7.62335816e-03f, 3.93081456e-02f, -6.48312494e-02f,
  -2.03500278e-02f, 1.29179537e-01f, 6.59482777e-02f, 5.46777770e-02f, -1.74710620e-02f, 9.10554081e-02f, 5.53200692e-02f, 3.50163989e-02f, -4.58208136e-02f, -3.12087941e-03f,
  6.03793301e-02f, -1.51526034e-02f, 6.30174130e-02f, -7.24982023e-02f, 3.24489586e-02f, 8.32043737e-02f, 8.22225958e-02f, 1.21018067e-01f, 3.40930782e-02f, 1.61840450e-02f,
  1.28079588e-02f, 7.74151906e-02f, -5.42640761e-02f, -5.26090041e-02f, -4.82945107e-02f, -2.22011376e-02f, -3.62577364e-02f, -3.18877846e-02f, -4.12932690e-03f, -7.13818297e-02f,
  6.02461882e-02f, -3.50453949e-04f, -1.73386842e-01f, 1.21627934e-01f, -4.86580245e-02f, 1.26322776e-01f, -2.14109719e-02f, 1.18970342e-01f, -1.87609233e-02f, -2.56028306e-02f,
  4.04558256e-02f, 8.23991820e-02f, -3.16993631e-02f, -7.74442405e-02f, -1.65199768e-02f, 6.05108775e-02f, -5.08761145e-02f, 1.19852731e-02f, -1.42147178e-02f, -4.82861772e-02f,
  1.39961382e-02f, -8.63410681e-02f, 4.70245555e-02f, -2.88779940e-02f, 2.43027771e-05f, -5.23238070e-02f, 1.26077943e-02f, -6.08202219e-02f, 3.10630053e-02f, -3.59227657e-02f,
  8.65161270e-02f, -4.43921285e-03f, 1.23581506e-01f, 3.87417376e-02f, 5.74740916e-02f, -4.59101470e-03f, -2.92998087e-02f, 3.80317345e-02f, -1.98669136e-02f, -5.37747256e-02f,
  9.78841539e-03f, -1.95340607e-02f, 5.96631831e-03f, -3.98213975e-02f, -1.04314074e-01f, -4.67480998e-03f, -5.70742972e-02f, -4.39547710e-02f, 1.18837757e-02f, 5.95746264e-02f,
  6.50349706e-02f, 6.13573901e-02f, -3.94638926e-02f, -3.59955207e-02f, -2.48708446e-02f, 7.78618976e-02f, 3.47684808e-02f, 8.89314413e-02f, 2.50922386e-02f, 4.38777469e-02f,
  -2.35679671e-01f, -2.36649230e-01f, 9.08963010e-02f, -2.11618498e-01f, -9.55167338e-02f, -1.07279666e-01f, 1.01385601e-02f, -1.91167086e-01f, -6.60211667e-02f, -1.44034758e-01f,
  -1.76612884e-01f, 4.84473333e-02f, 2.70356208e-01f, -1.14123315e-01f, 2.02488825e-01f, 3.39426488e-01f, -1.92093655e-01f, 3.55803152e-03f, -1.31319603e-02f, -1.97623506e-01f,
  -7.06947371e-02f, -1.97321758e-01f, 2.14751512e-01f, -1.91855803e-01f, -1.42466903e-01f, -1.94058225e-01f, 1.29543589e-02f, -4.08113375e-02f, -1.84136882e-01f, 2.42937654e-02f,
  -1.39156237e-01f, -1.08917682e-02f, 8.61152783e-02f, 8.07678401e-02f, 9.48836561e-03f, -4.17913729e-03f, 1.14355572e-01f, 6.80955276e-02f, -1.04015209e-02f, -3.62905562e-02f,
  -3.69438762e-03f, -7.23156184e-02f, -9.16761607e-02f, 4.03355360e-02f, -8.53123330e-03f, -8.34015757e-02f, 2.58012582e-02f, 3.08884168e-03f, -6.78218678e-02f, 6.77427799e-02f,
  1.95891559e-02f, -2.20355019e-02f, -4.79552196e-04f, -7.26638734e-03f, 4.27973345e-02f, -1.01346172e-01f, 5.13376072e-02f, 3.17491591e-02f, 1.39822820e-02f, -9.41337049e-02f,
  -2.10663807e-02f, -5.40961362e-02f, 2.15397216e-02f, -2.39802282e-02f, -1.03840031e-01f, -9.64611117e-03f, -2.60391198e-02f, 4.98539209e-02f, -1.90325975e-02f, -5.14726192e-02f,
  -8.58940110e-02f, -2.88456883e-02f, 6.75398111e-02f, -1.31462319e-02f, -9.23621207e-02f, 2.85127033e-02f, 8.23712125e-02f, -4.02295627e-02f, -5.05679063e-02f, -7.55917951e-02f,
  9.10233706e-03f, 2.12232564e-02f, 1.00512601e-01f, 2.42294837e-02f, -1.60950683e-02f, 9.11519900e-02f, 2.52330564e-02f, 8.37354660e-02f, 5.50393425e-02f, 9.92597118e-02f,
  -7.74297267e-02f, -1.40359491e-01f, -4.90757695e-04f, -5.67320324e-02f, -6.42939657e-03f, -1.46065354e-02f, 3.36853564e-02f, -8.01962391e-02f, 4.99731768e-03f, -1.19013516e-02f,
  -2.42247735e-03f, 6.78050518e-02f, -7.41058141e-02f, 3.24833468e-02f, -7.95239210e-02f, -2.75874287e-02f, -1.96216796e-02f, -6.33502081e-02f, 1.47763891e-02f, -1.15534052e-01f,
  -2.43927650e-02f, -4.65221740e-02f, 6.40589520e-02f, 4.20719432e-03f, 2.44513564e-02f, -5.72918616e-02f, -9.10469964e-02f, -1.12566268e-02f, -3.55596840e-02f, -1.28803467e-02f,
  2.45503962e-01f, 4.41415191e-01f, 2.08071709e-01f, 1.96514457e-01f, -2.37537488e-01f, -2.59373963e-01f, -1.50922373e-01f, 4.23780754e-02f, 5.66899637e-03f, 1.44636661e-01f,
  -5.88485152e-02f, 2.58952677e-01f, -5.57190627e-02f, 2.09490314e-01f, -4.46201749e-02f, -2.12770015e-01f, 1.57943264e-01f, 4.03811783e-03f, -9.37408134e-02f, 1.24098063e-01f,
  1.49930567e-01f, 6.38282970e-02f, 2.08786249e-01f, 5.51805645e-02f, 6.83483034e-02f, 1.64829850e-01f, 7.43306987e-03f, -2.59924345e-02f, 9.85955447e-02f, -7.53033310e-02f,
  -1.10669337e-01f, 9.64733139e-02f, 8.87750089e-02f, -1.63109917e-02f, 2.54702792e-02f, 7.67861754e-02f, 2.07120813e-02f, -5.64492531e-02f, -6.98320791e-02f, -2.05003116e-02f,
  1.14515543e-01f, 1.34465555e-02f, -6.20662514e-03f, -8.45552757e-02f, -5.49121127e-02f, 3.97576354e-02f, -2.77742693e-05f, -1.51282242e-02f, 1.59908645e-02f, 1.12365179e-01f,
  1.36545584e-01f, 2.85389945e-02f, 1.17813744e-01f, -7.86088128e-03f, 2.57452540e-02f, -2.96459328e-02f, 2.08647959e-02f, 2.21811440e-02f, -5.74062727e-02f, -2.02316809e-02f,
  -4.45030630e-02f, -6.20793998e-02f, 1.65739786e-02f, 8.72075483e-02f, -7.77075021e-03f, -1.03940018e-01f, 5.03588431e-02f, 1.84312055e-04f, -1.69933606e-02f, -2.80500874e-02f,
  -1.01343431e-02f, 2.84678303e-02f, -1.50497844e-02f, -1.45340078e-02f, 5.12550250e-02f, -2.06335951e-02f, 1.69930067e-02f, -1.61157548e-01f, -5.51886521e-02f, 2.18263213e-02f,
  -8.40249360e-02f, 7.66079202e-02f, 1.51341185e-02f, 1.54994288e-02f, -1.16023511e-01f, 1.32975206e-02f, -5.92189794e-03f, -6.02269322e-02f, -7.46229384e-03f, 6.14481308e-02f,
  -2.04775650e-02f, 1.87414303e-01f, 2.90924236e-02f, -5.62341474e-02f, -1.72165651e-02f, 2.96499301e-03f, -8.70281532e-02f, 6.20458387e-02f, 6.03082329e-02f, -3.43403406e-02f,
  -3.20628956e-02f, 7.88695831e-03f, -4.59889546e-02f, 2.57777460e-02f, 3.07921097e-02f, 8.39298889e-02f, -4.47633350e-03f, 4.07236535e-03f, 4.46777530e-02f, 9.09824446e-02f,
  1.02937207e-01f, -5.37891462e-02f, -8.27626418e-03f, 1.87117402e-02f, 2.97316182e-02f, -3.25493440e-02f, 2.40647737e-02f, -3.83472294e-02f, 8.44937488e-02f, -1.74958855e-02f,
  -3.86413366e-01f, 4.56845909e-01f, -2.02353626e-01f, 9.51332897e-02f, -7.15032443e-02f, 2.65995920e-01f, 1.85226500e-01f, 3.50760035e-02f, 1.47695899e-01f, 9.50693935e-02f,
  2.72611231e-02f, -8.52708647e-04f, 7.18476996e-02f, 1.46284357e-01f, 4.04782146e-02f, 2.13931322e-01f, 1.80976540e-01f, 9.53283384e-02f, 1.98068202e-01f, 4.44008708e-02f,
  9.36002508e-02f, 1.60989642e-01f, 2.49478184e-02f, 7.57153854e-02f, -1.25129772e-02f, -1.39114693e-01f, -1.61625922e-01f, -6.71184137e-02f, -4.82998006e-02f, 2.47819000e-03f,
  -2.65257023e-02f, -2.29457572e-01f, -6.75147846e-02f, -7.28313252e-02f, -9.39308777e-02f, -1.83974534e-01f, -2.01924834e-02f, -2.01035850e-02f, -1.00090452e-01f, 4.01197523e-02f,
  7.16086328e-02f, -2.76214033e-02f, 2.72431448e-02f, -6.56521097e-02f, 1.15089893e-01f, -3.66369709e-02f, 2.12783534e-02f, 6.55183569e-02f, 7.32753240e-03f, -3.77577841e-02f,
  2.55125482e-02f, 4.02105972e-02f, -9.03688818e-02f, 6.23836890e-02f, -1.97228659e-02f, -1.32783707e-02f, -2.94188038e-02f, -1.67191215e-03f, 3.43229212e-02f, 3.72323431e-02f,
  5.84290437e-02f, -1.91669539e-02f, -2.07891166e-02f, -1.81685612e-02f, 1.71036609e-02f, 4.16411459e-03f, -7.01692849e-02f, -5.35296872e-02f, 6.87194690e-02f, -1.57878045e-02f,
  1.53882697e-01f, -4.21898365e-02f, -7.18956143e-02f, 8.96433070e-02f, -3.18093151e-02f, -1.27567267e-02f, -1.75462384e-03f, 2.43206276e-03f, 6.37949109e-02f, 3.26167457e-02f,
  9.67155304e-03f, -2.53360644e-02f, -1.16567668e-02f, 2.15998888e-02f, -5.30680232e-02f, 2.43538860e-02f, 2.92335823e-02f, 6.90065771e-02f, 4.71169241e-02f, -9.54864267e-03f,
  1.68274760e-01f, -2.63988357e-02f, -3.03595625e-02f, 9.56099778e-02f, 8.96275938e-02f, 9.63280126e-02f, 5.97661808e-02f, -1.97045375e-02f, 1.03592433e-01f, 2.80102193e-02f,
  -6.10669665e-02f, -8.08305070e-02f, 6.89422479e-03f, -2.21578218e-03f, 1.94549188e-02f, 1.15732528e-01f, 7.66766965e-02f, 5.72321117e-02f, 8.54046196e-02f, -1.41134402e-02f,
  -1.90481246e-02f, 2.37453356e-02f, -5.04956283e-02f, 1.34917647e-02f, -7.26942122e-02f, -2.57029515e-02f, -3.05308407e-04f, -8.65762122e-03f, -1.94281377e-02f, -2.66105104e-02f,
  -6.48148656e-01f, 1.58888653e-01f, 1.51051819e-01f, -7.38762841e-02f, -4.91939969e-02f, 2.79552341e-01f, 1.30767196e-01f, 5.92720620e-02f, -1.88900903e-01f, 1.75770582e-03f,
  -3.61368433e-02f, -1.68604657e-01f, 4.95529473e-02f, 2.18247935e-01f, 1.37045041e-01f, 1.77309975e-01f, 6.92038834e-02f, 1.90732162e-02f, 4.20457013e-02f, -1.42208114e-01f,
  6.48947731e-02f, 4.24128436e-02f, 2.12102816e-01f, 3.73954549e-02f, 2.26529650e-02f, -1.33321285e-01f, -1.13127872e-01f, 9.68966261e-02f, 5.42460680e-02f, 2.27881614e-02f,
  -1.23240396e-01f, -2.79199719e-01f, -1.54473051e-01f, -8.78633708e-02f, -9.25972909e-02f, -5.06154634e-03f, 4.89005400e-03f, -2.94666141e-02f, -1.25910878e-01f, 7.45569868e-03f,
  -1.19185649e-01f, 7.78554454e-02f, 1.28326099e-02f, 5.60193881e-02f, -6.02958389e-02f, 2.06109695e-02f, 2.65215505e-02f, 9.36981887e-02f, 1.05267733e-01f, 7.59560391e-02f,
  1.37543231e-01f, 7.45847523e-02f, 4.95873876e-02f, 2.19997112e-02f, 5.43221496e-02f, 3.68346460e-02f, 2.64699887e-02f, 4.13176902e-02f, -8.01931024e-02f, -1.14084873e-02f,
  -8.00302401e-02f, 2.66101807e-02f, 2.11792085e-02f, -1.43548260e-02f, 3.46951112e-02f, 5.93685219e-03f, 3.36705782e-02f, 5.06197549e-02f, -7.40272626e-02f, 2.20222101e-02f,
  -5.07544987e-02f, 1.53578713e-03f, -6.72302917e-02f, -4.01280597e-02f, -6.28993213e-02f, 1.00636296e-02f, -7.15628415e-02f, -9.05357972e-02f, 5.86694665e-02f, 2.47179400e-02f,
  -3.77318971e-02f, 3.57317738e-02f, 4.02988493e-03f, 2.10938118e-02f, -4.27230597e-02f, 1.41968066e-03f, -1.14257075e-01f, 2.91293953e-03f, -1.27126634e-01f, 6.33550202e-03f,
  -2.34695256e-01f, -2.92616576e-01f, 1.29501219e-03f, -7.12751746e-02f, -3.60349789e-02f, -6.55251928e-03f, -1.33508223e-03f, 4.07986045e-02f, -1.08229682e-01f, -3.18037271e-02f,
  -5.30805923e-02f, -4.20911834e-02f, -3.86339016e-02f, -9.31447186e-03f, 1.16293058e-01f, 8.75311997e-03f, -4.38218154e-02f, -7.98032731e-02f, -6.85074255e-02f, 4.04024348e-02f,
  -4.18383703e-02f, -1.17459543e-01f, -3.13001685e-02f, -3.71584333e-02f, 4.68151793e-02f, -1.83230713e-02f, -1.39533132e-01f, 3.51322815e-02f, 4.84856144e-02f, 2.97065154e-02f,
  -6.63954020e-01f, 1.83830395e-01f, 7.03707039e-02f, -1.01972483e-01f, -6.42443001e-02f, 1.24155087e-02f, -2.51205452e-02f, 2.19442658e-02f, -9.84215364e-02f, 5.00599034e-02f,
  9.07822922e-02f, -4.34713177e-02f, 1.08487280e-02f, 2.10921988e-01f, -2.32027426e-01f, 5.03932126e-02f, -4.38763984e-02f, -9.57484808e-05f, 2.87646931e-02f, -6.53630495e-02f,
  7.28252530e-02f, 6.14743382e-02f, 1.19662099e-01f, 1.50888488e-01f, 5.41730337e-02f, 6.08400516e-02f, -1.50305495e-01f, 4.11186852e-02f, 1.73507750e-01f, 2.46849563e-02f,
  -2.36725256e-01f, -2.76172638e-01f, -1.86751619e-01f, -2.90812310e-02f, -2.34112758e-02f, -9.16943327e-02f, -8.77829045e-02f, -6.72858506e-02f, -7.55782472e-03f, -2.79148798e-02f,
  -9.48466212e-02f, -3.50544741e-03f, 6.50192872e-02f, 3.38550401e-03f, 1.62278358e-02f, -1.35993427e-02f, 2.43885256e-02f, 1.62899122e-02f, 2.02587266e-02f, -2.35107932e-02f,
  1.91907566e-02f, -3.12153585e-02f, 5.28658647e-03f, 7.28671206e-03f, 7.49057457e-02f, -4.15818533e-03f, -4.08959426e-02f, -9.57777575e-02f, 3.23065482e-02f, 2.15752684e-02f,
  3.20743956e-02f, 6.77088201e-02f, -4.28222716e-02f, 2.53769150e-03f, -4.03296063e-03f, 4.36166897e-02f, -6.90929443e-02f, -5.19390292e-02f, 4.73815873e-02f, 5.90910986e-02f,
  -9.05890167e-02f, -9.27355662e-02f, -1.08311370e-01f, -7.15845823e-02f, 1.39500098e-02f, -9.68892351e-02f, 3.35170366e-02f, 7.00333016e-03f, 1.19626649e-01f, 9.82951187e-03f,
  -6.23471215e-02f, -2.80494615e-02f, 4.69251983e-02f, -3.29137631e-02f, -3.19963507e-02f, -2.21084990e-03f, 8.63150656e-02f, -6.94947392e-02f, 8.35580472e-03f, -6.76015615e-02f,
  -2.62621015e-01f, -2.34567389e-01f, -8.78922548e-03f, -1.13300323e-01f, -8.09292346e-02f, -1.17937438e-01f, 3.15165557e-02f, 6.69716597e-02f, -6.77006599e-03f, 1.37610231e-02f,
  7.50630908e-03f, -1.02962047e-01f, -1.27172992e-02f, 9.22978893e-02f, 1.77987944e-02f, 9.89803746e-02f, -1.01550519e-01f, 7.19569549e-02f, 1.38116758e-02f, -2.81826276e-02f,
  1.42454933e-02f, -1.07711971e-01f, 4.60812300e-02f, 9.91300680e-03f, -1.71308964e-02f, -3.27984840e-02f, -9.12988260e-02f, -4.68122102e-02f, -2.83326022e-02f, 5.27857468e-02f,
  8.59051049e-02f, -3.33262414e-01f, -1.28714055e-01f, 1.41183317e-01f, 3.25822532e-01f, 2.21255273e-01f, 1.24017991e-01f, 3.82573269e-02f, 3.08853295e-02f, -1.99015006e-01f,
  2.69024968e-02f, -4.98478003e-02f, -2.02411354e-01f, 2.37032384e-01f, 3.18110943e-01f, -1.69819742e-01f, 1.96237296e-01f, 6.61227480e-02f, -4.43992987e-02f, -5.59573099e-02f,
  2.42485795e-02f, 2.31712982e-01f, -3.38986143e-02f, -5.24131907e-03f, 2.99393461e-04f, -1.40137732e-01f, -7.29556158e-02f, -7.97436312e-02f, 1.15772843e-01f, 1.40303627e-01f,
  1.02182604e-01f, -1.32221505e-01f, 6.29189983e-02f, -9.35563724e-03f, -1.16080031e-01f, -5.94063327e-02f, 4.64317463e-02f, 2.02683713e-02f, 5.54199778e-02f, -1.37316901e-02f,
  -2.33816672e-02f, 6.93659708e-02f, 4.10197079e-02f, 3.42641175e-02f, 6.75802305e-03f, -1.51845617e-02f, 4.88133729e-03f, -9.26126912e-02f, 2.88191382e-02f, -4.24712636e-02f,
  -6.49151504e-02f, 4.19141240e-02f, -8.75404757e-03f, 1.95800457e-02f, 1.03873005e-02f, 3.14305834e-02f, -6.11156411e-02f, -1.90013368e-02f, -5.13932807e-03f, -2.02395786e-02f,
  -4.57293354e-02f, -6.60976321e-02f, -1.11747414e-01f, -2.24498324e-02f, -4.96430742e-03f, 6.10048175e-02f, -3.33108637e-03f, 2.50513889e-02f, -3.28542925e-02f, 4.78518941e-03f,
  6.59976825e-02f, -2.87217256e-02f, 8.19462817e-03f, 8.01168978e-02f, 1.19877839e-03f, -6.14000484e-02f, -2.46296991e-02f, -6.23705331e-03f, -5.27563468e-02f, 9.78282914e-02f,
  1.14349667e-02f, 2.88458616e-02f, 8.91827338e-04f, 3.64893936e-02f, 6.25234172e-02f, 2.66669840e-02f, 1.01194782e-02f, -2.85124611e-02f, -3.41548189e-03f, -6.76705912e-02f,
  -7.12775439e-02f, -2.36644387e-01f, 3.64949331e-02f, 1.49146870e-01f, -1.97295155e-02f, -5.71957091e-03f, -3.00111957e-02f, 4.50363718e-02f, -2.16631442e-02f, -1.37219978e-02f,
  5.09555340e-02f, -1.85407035e-03f, -4.10330780e-02f, -1.76025182e-02f, 3.52400355e-02f, -3.91036421e-02f, -8.72024372e-02f, 1.45384222e-02f, 5.00703491e-02f, 2.09738072e-02f,
  -7.54631534e-02f, 2.68316246e-03f, -1.01835169e-02f, 2.92059202e-02f, -2.88123246e-02f, 3.54677178e-02f, 3.76880132e-02f, 2.03123707e-02f, -5.87431714e-02f, -2.22535785e-02f,
  4.89506364e-01f, -2.13292867e-01f, 6.33937940e-02f, 3.21707249e-01f, 1.20922916e-01f, -9.25834030e-02f, 1.87969897e-02f, 1.08263142e-01f, 3.75298917e-01f, -1.22229390e-01f,
  8.49222243e-02f, -1.15441650e-01f, -1.37910828e-01f, -3.00675035e-02f, 4.67381999e-02f, -1.37028381e-01f, 3.36492956e-02f, -2.52392683e-02f, 9.96964052e-02f, 5.10131791e-02f,
  2.49870583e-01f, -1.50555030e-01f, -1.31488383e-01f, -6.00419901e-02f, 5.56974262e-02f, 7.61294216e-02f, -6.67655021e-02f, -8.75910148e-02f, -1.40051261e-01f, -1.58363998e-01f,
  3.72435898e-02f, -3.91372368e-02f, -4.30176780e-02f, -6.89796954e-02f, -4.55691852e-02f, -4.73323204e-02f, -7.47090131e-02f, -1.26776546e-01f, 2.79141180e-02f, -6.63400739e-02f,
  -1.19022794e-01f, -1.02930591e-02f, 6.74485741e-03f, 2.79911570e-02f, 1.00962885e-01f, 9.09195542e-02f, 5.26009724e-02f, 9.04022679e-02f, 7.83076510e-04f, -3.00306231e-02f,
  6.40026107e-02f, -8.91298894e-03f, 7.74768591e-02f, -1.07844055e-01f, 7.55181462e-02f, 5.81598543e-02f, -8.90497863e-02f, -1.84352562e-01f, -2.61327233e-02f, -2.37637721e-02f,
  -9.66238379e-02f, -7.98749104e-02f, 1.78121328e-02f, 1.17400832e-01f, 1.56107480e-02f, 4.84176762e-02f, 6.24615960e-02f, 7.61748105e-02f, 7.76334330e-02f, 3.99779491e-02f,
  3.99254858e-02f, 2.52775345e-02f, 4.77168560e-02f, 4.32857722e-02f, -1.26243010e-01f, 1.03229098e-01f, -1.84580516e-02f, -1.96498018e-02f, 8.10116604e-02f, 5.81745952e-02f,
  4.39144811e-03f, -3.85754183e-02f, -1.07339405e-01f, 8.27651024e-02f, -6.01540087e-04f, -6.29039183e-02f, 2.10103653e-02f, 5.21851629e-02f, -3.23254056e-02f, 3.34668085e-02f,
  -8.67435038e-02f, -2.88527817e-01f, -4.82527576e-02f, 2.72174962e-02f, -2.67507695e-02f, 4.19815294e-02f, 4.90470715e-02f, -3.53189446e-02f, -1.11301273e-01f, 1.24489749e-02f,
  -3.11012566e-02f, 8.70575607e-02f, -4.27504219e-02f, 4.35442217e-02f, -1.06185958e-01f, 2.45633870e-02f, -4.30812761e-02f, -3.53401713e-02f, -6.01204252e-03f, -9.70943794e-02f,
  -2.11733580e-02f, -6.39777556e-02f, 4.06086631e-02f, -3.01585905e-02f, 6.87949732e-02f, -8.41548964e-02f, -4.33719978e-02f, -7.34773465e-03f, 2.79952493e-02f, -2.64574178e-02f,
  2.86782801e-01f, -9.71566364e-02f, 4.34818864e-02f, 3.56049061e-01f, 9.30663347e-02f, -1.73336402e-01f, -1.69917434e-01f, 2.32692212e-01f, 9.20895189e-02f, -1.57848507e-01f,
  1.92451611e-01f, -3.35759148e-02f, -1.48791596e-01f, 2.64617592e-01f, 2.97407448e-01f, -6.62906021e-02f, 2.37990469e-01f, 6.38332032e-03f, 5.84778041e-02f, 1.74201056e-01f,
  2.60024220e-01f, 2.71116585e-01f, 2.41599277e-01f, 2.21003711e-01f, 9.72979814e-02f, 1.99410528e-01f, 1.90880954e-01f, -7.53199309e-02f, 2.40697265e-01f, 4.79598232e-02f,
  1.16994837e-02f, 4.03058827e-02f, 1.09315221e-03f, -7.96600655e-02f, 3.45589630e-02f, -1.00200079e-01f, -1.61891237e-01f, -6.35758042e-02f, 6.90082684e-02f, -1.23527441e-02f,
  -1.39435664e-01f, 5.76976016e-02f, 1.07928969e-01f, -1.03654020e-01f, -2.65576914e-02f, 9.83482450e-02f, 3.31464298e-02f, 8.85598082e-03f, -6.01946842e-04f, 1.40127325e-02f,
  -6.75985292e-02f, -8.53434727e-02f, -2.16088984e-02f, -1.67010876e-03f, 9.91968364e-02f, 9.89837013e-03f, -6.27941219e-03f, -3.06427423e-02f, 9.59821511e-03f, 5.85802905e-02f,
  2.65531261e-02f, -9.41595957e-02f, 7.55883288e-03f, 1.78259648e-02f, 6.51729703e-02f, 8.71138647e-02f, -8.10257345e-02f, -5.54506946e-03f, -2.90350243e-02f, 3.90877612e-02f,
  7.55990595e-02f, 1.16179869e-01f, -7.39638135e-03f, -4.07388173e-02f, -5.47946692e-02f, -1.11381166e-01f, -2.86015067e-02f, 1.44092366e-02f, 5.81508055e-02f, 3.06878574e-02f,
  -7.10016266e-02f, 7.51946270e-02f, -2.08653025e-02f, -5.54299429e-02f, 2.92375982e-02f, 5.53302467e-03f, 2.91590067e-03f, -3.10399849e-02f, 1.67723931e-02f, 1.17877750e-02f,
  -1.53152630e-01f, 1.24602504e-02f, 2.03787647e-02f, 2.16356013e-03f, 1.30550005e-02f, -6.60202792e-03f, 2.31763953e-03f, 3.50103900e-02f, 4.87200683e-03f, -6.62396243e-03f,
  -2.63297744e-02f, -1.28461216e-02f, -1.15835577e-01f, 6.68575317e-02f, 5.33785187e-02f, -4.96346243e-02f, 1.14631578e-01f, 6.93277409e-03f, 3.26292552e-02f, 8.33955109e-02f,
  7.18771107e-03f, -4.35064249e-02f, -6.90409727e-03f, 5.35333939e-02f, 6.16093054e-02f, -5.28310202e-02f, 4.01816592e-02f, -1.70666985e-02f, -4.29892652e-02f, -2.05995236e-02f,
  3.65649253e-01f, 1.56226218e-01f, 2.09459513e-01f, 2.55659312e-01f, 6.02869764e-02f, 4.20559943e-02f, 2.37342030e-01f, 8.89897794e-02f, 3.31805527e-01f, -1.38325855e-01f,
  -1.47197261e-01f, 1.67737722e-01f, -4.16176654e-02f, 6.78639188e-02f, -9.18537602e-02f, -3.62358848e-03f, 2.08574384e-01f, 1.49334073e-01f, 1.80047140e-01f, 7.89436102e-02f,
  1.50072277e-01f, -2.34698400e-01f, -1.61330834e-01f, -3.22724015e-01f, 7.82214478e-02f, -2.29777694e-02f, -4.33271110e-01f, -8.89627784e-02f, -1.84777305e-01f, -1.06181353e-01f,
  5.06178439e-02f, 1.08936608e-01f, 6.43509850e-02f, 7.43455738e-02f, -2.47615948e-02f, -5.60294278e-02f, -6.73795789e-02f, -9.12286341e-02f, 2.46653077e-03f, -7.44536221e-02f,
  6.91208765e-02f, -4.30116653e-02f, -5.13947662e-03f, -7.94189796e-02f, 6.42795563e-02f, -1.36098480e-02f, 7.50159472e-02f, 7.65794963e-02f, 2.75619496e-02f, 1.09086059e-01f,
  5.08383177e-02f, 9.87001136e-02f, -1.53224850e-02f, -2.04815380e-02f, 9.12074670e-02f, 3.02691292e-02f, -6.30080923e-02f, -1.92611646e-02f, 3.46017666e-02f, 2.48137917e-02f,
  1.51609331e-01f, 5.99695966e-02f, -1.22423984e-01f, -1.23574682e-01f, -3.29578556e-02f, 6.84966445e-02f, -3.03187389e-02f, -9.93665680e-02f, -2.00148150e-02f, -2.61628255e-02f,
  1.04975784e-02f, -7.37011209e-02f, 1.27843572e-02f, -4.44089100e-02f, 9.65308324e-02f, -2.16269363e-02f, -8.40977207e-02f, 5.16346330e-03f, 3.44357975e-02f, 2.97166817e-02f,
  -8.54479820e-02f, -1.23405252e-02f, -6.22678213e-02f, -6.46211430e-02f, -6.36010170e-02f, -4.68739569e-02f, -1.41033158e-02f, 1.33132264e-02f, 1.60596464e-02f, -1.76545493e-02f,
  3.83870932e-03f, -7.34915808e-02f, 8.25451240e-02f, 1.67877860e-02f, -5.10707265e-03f, -1.47963732e-01f, -4.32458147e-02f, 4.21383418e-02f, -5.64236529e-02f, -1.04178376e-02f,
  7.03235250e-03f, -9.43660885e-02f, -5.35494126e-02f, -4.68420144e-03f, 2.14437973e-02f, -1.25833526e-01f, 1.72955487e-02f, 4.08923924e-02f, -5.77296577e-02f, -3.76390927e-02f,
  3.66423302e-03f, -3.63655649e-02f, 5.88522386e-03f, -4.95691933e-02f, -1.52941253e-02f, -6.83118924e-02f, 3.61066274e-02f, 9.00222063e-02f, -1.06851391e-01f, 3.00866440e-02f,
  7.76271448e-02f, -3.13149154e-01f, -7.78096318e-02f, 5.71313053e-02f, 3.26396167e-01f, 2.74166077e-01f, 1.59392208e-01f, -1.10854268e-01f, -2.75256485e-01f, -1.93117619e-01f,
  1.74251646e-01f, -1.21540157e-02f, -1.18333519e-01f, 1.72143430e-01f, 3.11984658e-01f, -1.98085949e-01f, 1.48954034e-01f, 8.93608406e-02f, -1.24692567e-01f, -9.27115381e-02f,
  3.15006380e-03f, 3.00991714e-01f, -1.00501385e-02f, 4.91704559e-03f, 1.17536098e-01f, -1.47888750e-01f, -3.02194413e-02f, 7.62953013e-02f, 1.47333771e-01f, 1.60689086e-01f,
  1.03969388e-01f, -1.27307385e-01f, 3.12203486e-02f, -1.64147150e-02f, 6.14148974e-02f, 6.24267831e-02f, 3.00110541e-02f, 5.60252741e-02f, 3.84850763e-02f, -4.68151309e-02f,
  4.38382514e-02f, 1.04596959e-02f, 5.08615002e-02f, -3.42204771e-03f, -6.85084984e-02f, 5.00662066e-02f, 7.74320506e-04f, -5.46368258e-03f, -5.29096462e-02f, 1.81862037e-03f,
  -3.30849066e-02f, -8.54784846e-02f, -3.76093984e-02f, -1.00338887e-02f, 4.94422670e-03f, -6.23250827e-02f, -7.60553479e-02f, 1.93540901e-02f, 2.36761682e-02f, 1.08146425e-02f,
  3.90651301e-02f, 5.55189289e-02f, -5.00021391e-02f, 9.96212512e-02f, -1.00309066e-02f, -9.37564299e-04f, -4.06737924e-02f, -1.25425244e-02f, -4.73498665e-02f, -2.68515060e-03f,
  -1.23347558e-01f, 2.29422431e-02f, -2.01272313e-02f, 5.79499174e-03f, 3.18925902e-02f, -6.59862021e-03f, -1.54308965e-02f, -4.67912778e-02f, -5.55258468e-02f, 1.93120015e-03f,
  -2.56120898e-02f, -7.47873038e-02f, -3.44977900e-02f, -7.41527975e-02f, 1.52985919e-02f, -8.45461711e-03f, -1.44908559e-02f, -3.21514122e-02f, -3.20826210e-02f, 8.96821171e-03f,
  5.31229600e-02f, -1.73483446e-01f, -4.07979116e-02f, 8.30537528e-02f, -3.25496867e-02f, 9.03500095e-02f, 7.67684653e-02f, 1.59032382e-02f, -1.02055050e-01f, -3.94061208e-02f,
  6.16096780e-02f, 3.66931490e-04f, 3.50426324e-02f, 4.15975377e-02f, 3.94924954e-02f, -1.00100171e-02f, -8.87077227e-02f, 5.53203449e-02f, -8.52242485e-02f, 6.48348068e-04f,
  6.29040077e-02f, -6.79847971e-02f, 2.63092108e-02f, 8.63077492e-02f, 6.82199895e-02f, -3.26514579e-02f, -3.42079923e-02f, 7.91252777e-03f, -2.68864892e-02f, -2.04459410e-02f,
  -7.02570900e-02f, 3.92884910e-02f, -1.11984968e-01f, -1.78904653e-01f, -4.53602523e-02f, -2.36872926e-01f, -3.07115912e-01f, 4.09410521e-02f, 1.57836620e-02f, 3.28089446e-02f,
  8.07836279e-02f, -5.83456829e-03f, 1.70881916e-02f, -3.34102660e-01f, -2.16019765e-01f, -1.59144357e-01f, -3.06819439e-01f, -4.18689586e-02f, 1.94662698e-02f, -1.12741932e-01f,
  -2.07934156e-02f, -9.39276889e-02f, -1.38000190e-01f, 1.31073678e-02f, -1.39065683e-01f, 6.28808066e-02f, 2.78655022e-01f, 6.41406626e-02f, -4.70251404e-02f, 9.83503740e-03f,
  -7.17312396e-02f, -7.59089598e-03f, 4.38757390e-02f, -2.03691050e-02f, -5.91168404e-02f, -4.45624755e-04f, -2.21892260e-02f, -4.59610373e-02f, 8.25806335e-02f, -8.09957683e-02f,
  -3.18502542e-03f, 1.83773208e-02f, -3.20961848e-02f, 5.82491234e-02f, -3.70320049e-03f, 6.76136985e-02f, -2.69696824e-02f, 3.19987796e-02f, 5.92270531e-02f, -7.80702084e-02f,
  -1.05002098e-01f, -3.39419246e-02f, -4.49950919e-02f, -6.35600910e-02f, 3.10254432e-02f, 2.54232194e-02f, -3.96176130e-02f, -1.04853120e-02f, 1.77381597e-02f, -5.22309495e-03f,
  -6.84650661e-03f, -2.77407821e-02f, -1.12489231e-01f, 1.80663373e-02f, 1.31814247e-02f, 7.53831342e-02f, -1.22291036e-02f, 5.95089793e-02f, 5.30357882e-02f, 4.27724756e-02f,
  -5.20676337e-02f, -3.37869897e-02f, -4.48370948e-02f, 3.51582712e-05f, -7.43922638e-03f, 6.02602921e-02f, -6.00093380e-02f, 2.07487699e-02f, -8.51055905e-02f, 2.62872893e-02f,
  1.17753930e-01f, -8.76598731e-02f, -1.28424400e-02f, 5.25586568e-02f, -9.91101637e-02f, -4.91417805e-03f, -5.17129600e-02f, -2.82044839e-02f, 9.25201029e-02f, 5.25726229e-02f,
  1.24049306e-01f, 1.72954887e-01f, -4.38573882e-02f, 8.40169638e-02f, 9.06419381e-02f, -3.23600508e-02f, -5.13078794e-02f, -5.58725074e-02f, 2.85687926e-03f, -3.89085822e-02f,
  -3.40414308e-02f, 2.53170319e-02f, 1.29232794e-01f, 3.78470644e-02f, 4.16882411e-02f, 6.01856783e-02f, -2.88472828e-02f, 8.04173201e-02f, -6.27607224e-04f, 1.51684821e-01f,
  6.43731505e-02f, 6.00106940e-02f, 4.40903101e-03f, -8.06930512e-02f, 1.86282163e-03f, -2.21587382e-02f, 7.91692585e-02f, -4.12597060e-02f, 8.44084993e-02f, 8.17863718e-02f,
  -1.66195463e-02f, 2.19372332e-01f, 3.10195208e-01f, 3.25916052e-01f, -2.59719074e-01f, -3.97228032e-01f, -2.41371781e-01f, 4.07644100e-02f, -4.03383970e-02f, -4.61071283e-02f,
  3.26377004e-02f, 1.35754213e-01f, -6.84948266e-02f, 2.39674062e-01f, 1.60938799e-01f, -1.76689159e-02f, 1.27460048e-01f, 4.85774688e-03f, 1.19999915e-01f, 1.95811495e-01f,
  7.71018341e-02f, 1.29266568e-02f, 4.08005774e-01f, 5.68535253e-02f, 1.02830179e-01f, 1.10703200e-01f, 2.49993622e-01f, 1.82394646e-02f, 2.02542469e-01f, 3.91443856e-02f,
  -1.42702729e-01f, 4.31580469e-02f, 5.93202263e-02f, -5.27198836e-02f, -3.37962573e-03f, -4.30340432e-02f, 2.04936862e-02f, 4.41238284e-02f, 6.05609789e-02f, 1.01998217e-01f,
  -7.37174600e-02f, -2.78311745e-05f, 5.12673371e-02f, -3.46571580e-03f, -8.42512697e-02f, 4.39948961e-02f, 1.58974174e-02f, -6.46485910e-02f, -3.20465788e-02f, 4.01484892e-02f,
  3.10565010e-02f, 2.45912820e-02f, -2.00611427e-02f, 2.93667689e-02f, 7.80359656e-02f, -3.69632095e-02f, -1.30073968e-02f, 7.40657672e-02f, -2.68419599e-03f, 5.90171739e-02f,
  -4.50829677e-02f, -1.04870290e-01f, -2.71300059e-02f, 6.43238574e-02f, 4.41737995e-02f, -3.66175955e-04f, -3.81182646e-03f, -3.69803049e-02f, -1.45769883e-02f, -2.85727642e-02f,
  -5.05726133e-03f, -9.13567375e-03f, 6.44867250e-04f, -6.16341755e-02f, -4.34148498e-02f, -8.22732076e-02f, 8.12953860e-02f, 7.05001205e-02f, 3.51242796e-02f, 1.32094687e-02f,
  -9.34451353e-03f, -3.01401615e-02f, 6.44034594e-02f, -4.65313671e-03f, -7.41592050e-02f, 7.43971020e-02f, 8.02814122e-03f, -5.70171811e-02f, 3.01386137e-02f, 2.97968183e-02f,
  -1.09233528e-01f, 1.58512384e-01f, 3.78946662e-02f, -3.73454951e-02f, 2.63577024e-03f, -2.86570657e-02f, 4.13598195e-02f, 1.41972965e-02f, 6.23462796e-02f, -2.72163767e-02f,
  -5.62450960e-02f, 9.56657529e-02f, -1.15339473e-01f, 6.20429106e-02f, -2.13650577e-02f, 1.72974877e-02f, -8.52116384e-03f, -4.99131754e-02f, 8.05024356e-02f, 4.68839295e-02f,
  2.70527601e-02f, -2.73153763e-02f, 6.80247843e-02f, -4.15989570e-02f, -3.65679860e-02f, -7.51727298e-02f, -5.60473558e-03f, 2.72235647e-02f, 3.79591696e-02f, 4.68502194e-03f,
  -5.89856267e-01f, 4.74849492e-02f, -2.12978452e-01f, -2.27571368e-01f, 4.74492349e-02f, -1.74145833e-01f, -1.81522176e-01f, -2.72155460e-02f, -6.82836622e-02f, 1.15001321e-01f,
  3.83213088e-02f, -2.62559712e-01f, 1.38111874e-01f, -1.39174536e-01f, -4.24715996e-01f, -3.67536880e-02f, -1.75808609e-01f, -9.88226756e-02f, 1.88909359e-02f, -3.56208496e-02f,
  -8.70451555e-02f, 1.26036644e-01f, -1.76263168e-01f, 3.12023222e-01f, -1.08135320e-01f, 7.26798475e-02f, -9.02132038e-03f, 2.10465804e-01f, -5.50284125e-02f, -3.86535563e-02f,
  -1.27269253e-01f, 8.17623734e-02f, -1.28621385e-02f, -8.24735034e-03f, -5.62251136e-02f, -2.35200729e-02f, -1.01815522e-01f, -3.49068791e-02f, -2.96433903e-02f, -6.92389086e-02f,
  -1.00201853e-02f, 1.30977426e-02f, -4.30819541e-02f, 8.10639411e-02f, 9.03703179e-03f, -5.39590418e-02f, -4.73932661e-02f, -5.20238765e-02f, 3.34416237e-03f, -8.37598741e-02f,
  -9.15654644e-04f, 2.26493627e-02f, -8.10204893e-02f, 4.99793515e-02f, -4.04424258e-02f, -1.06712133e-02f, -8.65021423e-02f, -2.69682538e-02f, -4.04870920e-02f, -2.56909057e-02f,
  5.93634769e-02f, 3.80008705e-02f, 7.16311857e-02f, -3.41867916e-02f, 4.96241041e-02f, 3.51414606e-02f, -3.31315137e-02f, -4.11155783e-02f, 4.88396399e-02f, -2.57584564e-02f,
  -1.58452839e-02f, -3.40553783e-02f, 8.31283852e-02f, 9.78024956e-03f, -2.33155731e-02f, 4.93792780e-02f, 3.09900511e-02f, -4.47082007e-03f, -1.23489127e-01f, -3.96856144e-02f,
  -4.85516433e-03f, 9.94657911e-03f, 1.35590108e-02f, 2.79776976e-02f, 7.22921416e-02f, 3.86162326e-02f, 5.63830435e-02f, 5.78740686e-02f, -7.29563609e-02f, -1.64408647e-02f,
  -1.03614673e-01f, -3.76752727e-02f, 3.91583964e-02f, 1.11225531e-01f, -2.95996871e-02f, -2.14433577e-03f, -9.24956985e-03f, -4.72182706e-02f, -2.49515753e-02f, 6.44729137e-02f,
  6.20432757e-02f, 6.81219697e-02f, -6.32992238e-02f, -4.09225635e-02f, 4.01180498e-02f, 1.91886108e-02f, 4.23378590e-03f, -1.14011625e-02f, -1.49158575e-02f, -6.75775781e-02f,
  -3.39462720e-02f, 7.65197873e-02f, 7.31750950e-02f, 9.66965482e-02f, 4.21110205e-02f, -8.40923935e-02f, -5.81595600e-02f, 5.20240068e-02f, -5.34421206e-03f, -7.42113292e-02f,
  1.29682735e-01f, 3.06081742e-01f, 1.08370982e-01f, 3.20691839e-02f, -1.32899791e-01f, -3.33672941e-01f, -2.08706737e-01f, -1.03414215e-01f, 4.88814525e-02f, 1.41782850e-01f,
  -2.07264751e-01f, 2.95548886e-01f, -6.05063550e-02f, 1.05512299e-01f, -2.54038543e-01f, -1.71634778e-01f, -2.43176222e-02f, -6.12196513e-02f, -8.06943104e-02f, 1.16792377e-02f,
  -6.06568605e-02f, -1.22131288e-01f, -7.26437643e-02f, 7.37068728e-02f, 4.64463793e-02f, 1.54657528e-01f, 8.96059424e-02f, -1.26236618e-01f, 1.38645053e-01f, 4.99049155e-03f,
  -1.13975413e-01f, 1.79380514e-02f, 3.74165364e-02f, 3.29902023e-02f, -1.01383962e-03f, -6.95648883e-03f, -7.16663664e-03f, -7.45900497e-02f, -4.68552597e-02f, 4.13178802e-02f,
  8.85895491e-02f, 1.58751197e-02f, -3.70130464e-02f, -1.11236036e-01f, 5.62300757e-02f, 2.96270587e-02f, 9.49039310e-02f, 1.12717874e-01f, 1.03234008e-01f, -8.30333605e-02f,
  5.63337952e-02f, 2.75816843e-02f, 1.20494209e-01f, 3.17273661e-02f, 8.79626069e-03f, 2.51649357e-02f, 5.69829997e-03f, 4.86564450e-02f, 9.86080244e-02f, 2.23597828e-02f,
  -1.17756002e-01f, 2.11037137e-02f, 7.45026022e-02f, 4.08027060e-02f, 1.44867711e-02f, -8.82767737e-02f, 5.82693284e-03f, 1.27936213e-03f, -6.70788018e-03f, 3.94421220e-02f,
  2.25917827e-02f, 3.99005152e-02f, -6.33280072e-03f, 9.11931880e-03f, 3.06075178e-02f, 6.91623054e-03f, 6.56042174e-02f, 5.58735020e-02f, -1.63798649e-02f, -1.24995774e-02f,
  -6.16933815e-02f, -1.45346345e-02f, 1.40007129e-02f, 8.89490321e-02f, -4.14673313e-02f, 1.57839581e-02f, 7.89872482e-02f, 8.29954073e-02f, -4.44309339e-02f, -2.13634204e-02f,
  -7.41739795e-02f, 9.80009958e-02f, 2.09253822e-02f, 3.28372195e-02f, 4.65897173e-02f, 3.06588057e-02f, -1.72127988e-02f, 4.32936139e-02f, -3.89985517e-02f, -7.00110793e-02f,
  1.08826287e-01f, -3.06910947e-02f, 5.85168526e-02f, -6.61318749e-02f, 1.73090100e-02f, 2.46901605e-02f, 1.00641094e-01f, 7.15618804e-02f, 4.44439054e-02f, -1.70156620e-02f,
  3.84654962e-02f, -2.99332403e-02f, 5.33315092e-02f, 5.01124524e-02f, -4.18972000e-02f, 5.13848811e-02f, 3.77867669e-02f, 4.79869358e-02f, -1.48032038e-02f, -3.19584757e-02f,
  -1.15636699e-01f, -9.35659185e-02f, -1.03010327e-01f, -2.39883468e-01f, 8.83511640e-03f, -2.25992903e-01f, -2.18894944e-01f, -8.64994060e-03f, 9.10678804e-02f, -1.07113980e-01f,
  -1.57376722e-01f, 1.11457728e-01f, 9.18797553e-02f, -1.71883583e-01f, 1.18569501e-01f, 2.20267788e-01f, -2.07143426e-01f, -1.43769562e-01f, 6.60284236e-02f, -1.38945416e-01f,
  -3.66467759e-02f, -1.53170839e-01f, -4.13867682e-02f, -1.61178499e-01f, -8.38205740e-02f, -1.20313376e-01f, 7.25886598e-02f, 3.83701622e-02f, -1.24169670e-01f, 8.58122110e-02f,
  -1.06712438e-01f, -1.77654088e-01f, -1.70122594e-01f, -6.07010126e-02f, -4.39434946e-02f, 2.13800720e-03f, -8.98819938e-02f, 9.81797371e-03f, -7.31039941e-02f, -3.23476270e-03f,
  6.86823651e-02f, -1.19030990e-01f, -4.70577478e-02f, 3.11581288e-02f, -3.33216302e-02f, 2.46295538e-02f, -4.94495220e-02f, -4.82044853e-02f, -1.08866967e-01f, 6.22997321e-02f,
  -5.29475324e-02f, -6.10864768e-03f, -8.16370547e-02f, -5.31745590e-02f, 1.41753927e-01f, -5.56353107e-02f, -8.70557353e-02f, 6.78144395e-02f, -4.58545471e-03f, -5.16033405e-03f,
  7.86855817e-02f, 3.05982064e-02f, 2.81619132e-02f, 8.84547234e-02f, -9.44219008e-02f, 4.59645949e-02f, -2.75330171e-02f, 5.24161384e-02f, -9.99084637e-02f, -9.15839598e-02f,
  2.26553413e-03f, -1.23411780e-02f, -1.09813316e-02f, -5.31224273e-02f, -7.86974747e-03f, 4.70726080e-02f, -1.30707808e-02f, -2.44651102e-02f, -2.32455432e-02f, -1.99038000e-03f,
  -1.43879965e-01f, 3.09639201e-02f, -1.74425624e-03f, -1.27941832e-01f, -9.75632668e-02f, -3.19242179e-02f, -6.03560656e-02f, 7.70850945e-03f, 1.12797674e-02f, 1.23199886e-02f,
  -1.42595306e-01f, -2.68506289e-01f, -7.21004978e-02f, -1.64868325e-01f, -6.23410605e-02f, -3.83701399e-02f, -1.44104064e-02f, 5.69054782e-02f, -7.27311894e-02f, 5.46098202e-02f,
  -3.68547961e-02f, 1.16415061e-02f, -7.26587847e-02f, -5.30056767e-02f, -2.63840728e-03f, -1.05015330e-01f, -6.44391626e-02f, -1.77172963e-02f, -4.10547107e-02f, -7.08744749e-02f,
  -8.72928351e-02f, -1.80084668e-02f, 3.09072789e-02f, 6.68734536e-02f, 3.20150964e-02f, 2.51153056e-02f, 1.68183586e-03f, -7.15603754e-02f, -2.48655528e-02f, -8.05358286e-04f,
  1.02486625e-01f, 3.92821580e-02f, -3.16659093e-01f, 1.65497120e-02f, -2.40356475e-01f, 1.27925247e-01f, 8.39041024e-02f, -1.75887376e-01f, -5.41490018e-02f, 2.87997544e-01f,
  8.92785862e-02f, 3.82578000e-02f, 1.31327018e-01f, 3.44154924e-01f, 5.97166121e-02f, 2.03646943e-01f, 1.99972808e-01f, 1.63784042e-01f, -4.80766185e-02f, 1.63800284e-01f,
  -5.12000211e-02f, 2.12040693e-01f, -5.47278747e-02f, 4.29056771e-02f, 1.03083365e-02f, -1.75627932e-01f, -8.68855566e-02f, -2.38823876e-01f, 4.76998240e-02f, 4.43541503e-04f,
  3.72533314e-02f, -5.28456457e-03f, 5.53329661e-02f, 6.57124119e-03f, 7.98207372e-02f, 5.58502674e-02f, 2.48198444e-03f, 1.41142225e-02f, -9.93360803e-02f, -3.13260779e-02f,
  -3.34922485e-02f, -5.98544441e-02f, 1.60737690e-02f, -4.74629849e-02f, -9.80669111e-02f, -6.08977713e-02f, -4.21192311e-02f, -4.34892140e-02f, -8.60025510e-02f, 6.95020258e-02f,
  -6.09661341e-02f, -5.24514429e-02f, -1.45251276e-02f, 1.02201197e-02f, -1.92560151e-03f, 4.56349887e-02f, 1.37702907e-02f, -1.09668694e-01f, 1.70917006e-03f, -7.38995224e-02f,
  2.52271574e-02f, -1.75923426e-02f, -5.18843457e-02f, 4.49300632e-02f, -2.99139433e-02f, 3.09600979e-02f, -3.86039689e-02f, -2.36394312e-02f, 6.66033998e-02f, 5.34138829e-02f,
  1.98930446e-02f, -8.32799003e-02f, 3.26198190e-02f, -1.53157720e-02f, 5.91761759e-03f, 1.39594283e-02f, -7.19692335e-02f, -1.24986600e-02f, 1.79228820e-02f, 2.97010336e-02f,
  4.03245315e-02f, 1.03233277e-03f, 2.46512145e-02f, 6.43858388e-02f, 2.66309213e-02f, -6.25924580e-03f, 6.87774792e-02f, -3.40938475e-03f, 4.29323986e-02f, -7.26816580e-02f,
  1.26575351e-01f, 4.58183549e-02f, 2.51185410e-02f, 3.03467028e-02f, 2.71089859e-02f, 4.13851766e-03f, 9.43316333e-03f, 3.75560634e-02f, 6.24816380e-02f, -3.72500159e-04f,
  5.38763702e-02f, -3.32034454e-02f, -5.90299293e-02f, 2.69986242e-02f, -9.01140086e-03f, 3.80137227e-02f, 2.03341804e-02f, 8.77169799e-03f, 2.26119477e-02f, -3.15255895e-02f,
  2.24035233e-02f, -5.13462769e-03f, 8.37299675e-02f, -1.06394081e-03f, 1.09579861e-02f, -3.90211456e-02f, 6.83898553e-02f, -9.24613252e-02f, -6.05087588e-03f, 3.39931808e-02f,
  1.38002679e-01f, -3.14137697e-01f, -7.80494660e-02f, -1.47302017e-01f, -8.36455524e-02f, -2.61585772e-01f, -3.86319049e-02f, -3.08172137e-01f, -7.86452740e-02f, -3.52030724e-01f,
  -7.64136463e-02f, 1.15130879e-01f, 2.52067000e-01f, -2.91709363e-01f, 4.59904373e-01f, 2.51391649e-01f, -1.87098131e-01f, -6.94268793e-02f, 1.75629869e-01f, -1.65347070e-01f,
  2.45360546e-02f, -2.41528988e-01f, 4.04945426e-02f, -4.19147491e-01f, -1.88987896e-01f, -2.07825139e-01f, 4.82404046e-02f, -2.97544952e-02f, -2.69940048e-01f, 4.43453342e-02f,
  -6.37574047e-02f, 2.59215254e-02f, -5.99997910e-03f, -3.65737490e-02f, -9.45803151e-02f, -3.06960549e-02f, -7.13041937e-03f, 1.34756491e-01f, 4.65259515e-02f, 1.61572099e-02f,
  6.72246814e-02f, -8.25141650e-03f, -1.00656956e-01f, -8.06092378e-03f, -1.07647985e-01f, -9.43229422e-02f, 5.51831871e-02f, 7.46211410e-02f, -6.56479448e-02f, 5.41273393e-02f,
  4.94405851e-02f, 1.20085068e-01f, 1.06245456e-02f, -6.85242340e-02f, 6.44380748e-02f, -4.21484374e-02f, 2.81578787e-02f, 1.01313159e-01f, -1.79198552e-02f, -2.65950076e-02f,
  -6.07426427e-02f, 9.55598056e-02f, -2.23502368e-02f, -3.87889147e-02f, 1.11663491e-02f, -3.61646637e-02f, -2.40499843e-02f, 7.75041133e-02f, 7.50375614e-02f, -4.51665632e-02f,
  6.89432696e-02f, 2.25243606e-02f, -5.18052280e-03f, -3.82366069e-02f, -2.01176908e-02f, 1.11584906e-02f, 3.74720395e-02f, 1.40924370e-02f, 5.16746268e-02f, 3.36555429e-02f,
  1.25310468e-02f, 5.63680232e-02f, -2.62632631e-02f, 3.30669945e-03f, 2.56276336e-02f, 9.77184325e-02f, -2.89165620e-02f, -1.92368887e-02f, 1.86828878e-02f, 9.05553438e-03f,
  -9.96674299e-02f, -1.55240223e-01f, -6.35489151e-02f, 8.33728909e-03f, 2.18524672e-02f, -2.11057384e-02f, -3.06631271e-02f, -8.89300108e-02f, -6.85172230e-02f, -6.32182276e-03f,
  -7.15789720e-02f, -3.11288256e-02f, -6.90775141e-02f, -6.27118163e-04f, -3.63589860e-02f, -7.29807392e-02f, -1.00761699e-02f, 3.32172066e-02f, -6.45673051e-02f, -5.94713092e-02f,
  -8.20471570e-02f, -2.37645824e-02f, 3.50950398e-02f, -9.95504335e-02f, -1.87079161e-01f, 1.15061365e-01f, -7.77851697e-03f, 2.80417502e-02f, 3.10734436e-02f, -2.77461810e-03f,
  1.35314479e-01f, 4.52687591e-02f, -1.76101789e-01f, 4.40921076e-02f, -7.13964850e-02f, 1.69049963e-01f, 1.28320783e-01f, -1.58416897e-01f, -1.21679619e-01f, 6.65564686e-02f,
  1.17404766e-01f, -1.54062703e-01f, 9.78756025e-02f, 2.81574726e-01f, 2.11625956e-02f, 1.40556306e-01f, 2.14490429e-01f, 2.00559393e-01f, -6.59282357e-02f, -4.80656400e-02f,
  -4.40864787e-02f, 3.07276577e-01f, -3.13631259e-02f, 2.05922648e-02f, 8.88558328e-02f, -9.74225253e-02f, 8.64932910e-02f, -1.12640493e-01f, 8.55596066e-02f, -2.84997150e-02f,
  1.34111255e-01f, 9.58242454e-03f, 4.65907641e-02f, -3.32688242e-02f, -2.29646582e-02f, 6.56336406e-03f, -6.58178050e-03f, 1.58225913e-02f, -4.27837763e-03f, -1.04994878e-01f,
  -5.20749241e-02f, 8.43586102e-02f, 1.68964360e-02f, -1.14131548e-01f, -8.32274929e-02f, -4.17069271e-02f, 2.67476737e-02f, -3.46000260e-03f, -5.42960130e-02f, 2.25533843e-02f,
  -2.17350852e-02f, 2.07103901e-02f, -2.57684477e-02f, -1.20371925e-02f, -1.30332991e-01f, 1.86434910e-02f, -2.71816514e-02f, -4.33861986e-02f, -9.19108391e-02f, -6.02938384e-02f,
  2.85668541e-02f, -6.35228083e-02f, 9.12864730e-02f, 6.48193508e-02f, 8.36735517e-02f, 4.77343798e-02f, 4.77723517e-02f, 6.57618716e-02f, -9.61568207e-02f, 1.12130225e-01f,
  -4.35174927e-02f, 5.01913484e-03f, 3.34769301e-02f, 2.42682397e-02f, 2.08107773e-02f, 1.00023091e-01f, 4.71449271e-03f, -3.68581042e-02f, -4.23986316e-02f, 9.28264484e-03f,
  4.33831252e-02f, -8.71781483e-02f, -4.02036496e-02f, 7.04185590e-02f, 1.99573878e-02f, -1.32319391e-01f, 5.18397754e-03f, -1.26582868e-02f, -1.61327943e-02f, 5.78474924e-02f,
  -7.92234857e-03f, -1.70053303e-01f, -5.26067317e-02f, 3.02215349e-02f, -3.30779515e-02f, 2.21419632e-02f, -5.23125157e-02f, 1.96918305e-02f, -7.15702176e-02f, -3.84198911e-02f,
  6.48997650e-02f, 5.23089953e-02f, -2.38907766e-02f, -9.07705799e-02f, -1.06539503e-01f, -4.99166287e-02f, -3.89560461e-02f, 5.09634428e-02f, -4.80562623e-04f, 3.57030258e-02f,
  8.19492899e-03f, 1.97389023e-03f, -2.89776493e-02f, 5.53384162e-02f, 7.43590221e-02f, -1.35153774e-02f, -8.33222941e-02f, -7.94525966e-02f, 2.82512465e-03f, 1.32273138e-02f,
  2.44489968e-01f, -1.56051833e-02f, 7.46094510e-02f, 2.04454854e-01f, 1.92512393e-01f, 3.34629416e-01f, 3.98046821e-01f, 4.05177884e-02f, 2.45446295e-01f, -3.16643603e-02f,
  -1.01276375e-01f, -2.64286548e-02f, -1.63806360e-02f, 3.28619480e-02f, 9.40059051e-02f, 6.41550347e-02f, 2.20862001e-01f, 5.85992262e-02f, -1.97732467e-02f, -6.90769777e-02f,
  -6.32156208e-02f, -5.60339764e-02f, -6.82450607e-02f, -2.05531538e-01f, 8.75325873e-02f, -1.04792781e-01f, -1.91471413e-01f, -5.42346351e-02f, -1.09101430e-01f, 1.15221053e-01f,
  1.02881223e-01f, 1.41389249e-02f, -8.35427120e-02f, -3.84022333e-02f, -1.85458288e-02f, -7.62809291e-02f, -4.86057805e-04f, 6.25851303e-02f, -2.08991040e-02f, 4.26883064e-02f,
  2.36248244e-02f, 3.81351076e-02f, -1.90347880e-02f, 3.71223986e-02f, -6.35770634e-02f, 2.86805928e-02f, 3.60688791e-02f, 1.47306565e-02f, -1.42396446e-02f, 2.62760837e-02f,
  -3.10723558e-02f, 2.55650673e-02f, 2.06225272e-02f, 5.70626706e-02f, 6.82871640e-02f, 6.98308125e-02f, 2.73430981e-02f, 2.32063476e-02f, 2.50829011e-02f, 8.98220167e-02f,
  -7.78559819e-02f, -3.15905623e-02f, 5.81085077e-03f, 2.70203818e-02f, 3.36407088e-02f, 4.67443876e-02f, -8.48621037e-03f, -8.96008611e-02f, 5.33070527e-02f, -1.64526328e-02f,
  -2.71645226e-02f, 2.71180365e-02f, 3.56232934e-02f, 1.01167914e-02f, -3.88343795e-03f, 1.13749560e-02f, 1.99152585e-02f, 4.77940403e-02f, 1.05996989e-02f, 5.63081028e-03f,
  1.22028161e-02f, 5.65924458e-02f, 7.79690668e-02f, 2.26610806e-02f, -6.11942485e-02f, -4.76499349e-02f, -9.01219770e-02f, 7.06003308e-02f, -3.87445539e-02f, -6.48597162e-03f,
  8.13950598e-02f, -8.56291596e-03f, 4.35887761e-02f, -8.20607767e-02f, -1.17180735e-01f, -8.52411315e-02f, 1.62791144e-02f, 3.96760516e-02f, 8.78427103e-02f, 3.04852407e-02f,
  -5.73660946e-03f, 9.59931836e-02f, -7.68065602e-02f, -2.37809755e-02f, -6.88051060e-02f, 5.46503812e-02f, -2.58399770e-02f, -1.91586129e-02f, -7.93169998e-03f, -1.66001637e-02f,
  -8.75272453e-02f, 1.47089669e-02f, 5.23342974e-02f, 2.47793179e-02f, -5.46829775e-02f, -5.75770363e-02f, -4.94310930e-02f, -2.69709574e-03f, 3.63268070e-02f, 3.26381102e-02f,
  2.08000526e-01f, -1.32470489e-01f, -9.34041440e-02f, 1.00271657e-01f, 1.71643514e-02f, -6.80397525e-02f, -4.35766540e-02f, -3.67505923e-02f, 2.02500120e-01f, -2.14155223e-02f,
  -3.41231115e-02f, -7.31153265e-02f, 5.67262955e-02f, -1.34288788e-01f, -2.54772771e-02f, 4.44601960e-02f, -2.57456481e-01f, -2.19485134e-01f, 2.25454718e-02f, -1.84884489e-01f,
  1.57964956e-02f, 7.14520589e-02f, 2.17775087e-04f, 1.23786002e-01f, 1.94455404e-02f, 1.95383001e-02f, -1.16652109e-01f, -5.63526899e-02f, -1.94158226e-01f, -8.49428251e-02f,
  -7.77862370e-02f, 1.78317666e-01f, 1.03422161e-02f, 9.89554152e-02f, 5.59584424e-02f, 1.11775257e-01f, -7.51587898e-02f, -1.09194648e-02f, 7.62822405e-02f, 6.71315566e-02f,
  -9.99847054e-02f, 2.61798855e-02f, -1.20168282e-02f, 1.00487933e-01f, 1.82363674e-01f, 3.17288637e-02f, -4.07131063e-03f, -8.38675424e-02f, -8.83319527e-02f, -6.56288676e-03f,
  7.76519105e-02f, -1.32990956e-01f, -3.86418439e-02f, -3.69934961e-02f, -2.83371639e-02f, -1.48099149e-03f, -1.37377873e-01f, -1.34444669e-01f, -1.06548563e-01f, 5.30821756e-02f,
  -5.16265295e-02f, 1.88442934e-02f, 1.10788360e-01f, 1.03007153e-01f, 8.49518180e-02f, 4.86053638e-02f, -1.83078051e-02f, -3.08938567e-02f, 1.21172387e-02f, -5.82519546e-02f,
  -2.33440455e-02f, 1.25790127e-02f, 1.01494320e-01f, -1.70607530e-02f, -8.51964206e-02f, 6.56227674e-03f, -4.52055931e-02f, -1.39322728e-01f, -3.66256312e-02f, -1.09612636e-01f,
  -4.40304587e-03f, -1.61871985e-02f, 9.37011614e-02f, -7.03415722e-02f, -1.88483447e-02f, 9.32401493e-02f, 8.90214071e-02f, -5.00466749e-02f, -5.60784433e-03f, -8.48221108e-02f,
  -1.22900642e-01f, 1.17151840e-02f, 5.27525358e-02f, 1.27388872e-02f, -3.51726301e-02f, 9.18688327e-02f, 3.53538827e-03f, 2.04142369e-03f, 5.20651080e-02f, 1.58351392e-01f,
  -8.87704268e-02f, -6.24868134e-03f, -6.01063035e-02f, -2.02579536e-02f, -1.22158788e-01f, 3.25839408e-02f, -1.61498666e-01f, -5.35882190e-02f, -1.22206859e-01f, -1.27123669e-01f,
  -3.92615385e-02f, 3.21676619e-02f, 5.96616939e-02f, 1.35718748e-01f, -6.59918562e-02f, -1.27577290e-01f, -2.55529638e-02f, -2.30306666e-03f, -2.88208015e-02f, -6.46546185e-02f,
  3.39779168e-01f, -8.51985812e-02f, -2.29405671e-01f, 1.47232600e-02f, 1.03595247e-02f, -6.01231009e-02f, -1.24668911e-01f, 1.70693651e-01f, -7.93419331e-02f, 1.53456302e-03f,
  5.36344759e-02f, -1.16890416e-01f, -1.85626045e-01f, 1.25926375e-01f, 1.30883321e-01f, -1.32679775e-01f, 2.56858587e-01f, -4.17164564e-02f, -4.19579297e-02f, 7.92167848e-04f,
  1.13232881e-01f, 3.06662798e-01f, 6.04363643e-02f, 1.34529904e-01f, 2.13310987e-01f, 5.66615909e-02f, 2.86545515e-01f, -1.21842861e-01f, 1.86879277e-01f, 1.28839791e-01f,
  7.93072730e-02f, 5.29862791e-02f, -3.74730043e-02f, -1.42902821e-01f, -3.20055964e-03f, -1.02760874e-01f, -1.20877691e-01f, 6.56439131e-03f, -3.71638201e-02f, 7.47445673e-02f,
  -3.18642519e-02f, -5.22810109e-02f, 2.87289489e-02f, 6.84416816e-02f, 1.66654319e-01f, -8.47832412e-02f, 4.31157299e-04f, -3.04618310e-02f, -5.12531511e-02f, -6.86203167e-02f,
  -4.92502190e-02f, 8.59671682e-02f, 4.71817777e-02f, -4.26952168e-02f, -8.08194503e-02f, 5.80234267e-02f, -3.70951518e-02f, -5.05637005e-02f, -1.88858528e-02f, 1.83341661e-04f,
  4.53176647e-02f, 1.55219259e-02f, 6.11380152e-02f, 2.04721726e-02f, -8.42781216e-02f, 6.93845190e-03f, 3.05550899e-02f, -3.23253218e-03f, -1.97069515e-02f, -1.03644185e-01f,
  3.68389301e-02f, -9.22899228e-03f, -1.00108720e-02f, 1.67308040e-02f, -1.42464298e-03f, 8.02326947e-02f, 2.68824454e-02f, 4.29322571e-02f, -9.79769677e-02f, 1.80547009e-04f,
  -4.18165587e-02f, 5.30434996e-02f, -3.19362767e-02f, 9.71028283e-02f, -3.79412528e-03f, 1.11297914e-03f, 1.54314479e-02f, -4.94508073e-03f, -1.18240444e-02f, 1.44210383e-02f,
  -1.18445083e-02f, -3.07835322e-02f, -7.95496330e-02f, 4.93293516e-02f, -2.05992281e-01f, -1.35723636e-01f, -3.52847390e-02f, 7.63554778e-03f, -6.51990715e-03f, 1.05213962e-01f,
  1.45921921e-02f, 1.23626497e-02f, 1.17150359e-01f, 6.09252136e-03f, 9.17952210e-02f, -1.59502365e-02f, 1.90332718e-02f, -6.58491924e-02f, 1.52244329e-01f, -2.39280947e-02f,
  -2.35048821e-03f, 3.60031575e-02f, 1.39143867e-02f, -4.49890979e-02f, 3.36873978e-02f, -3.96943558e-03f, -1.12746591e-02f, -5.28844930e-02f, 4.03057635e-02f, -2.17961688e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.25613526e-01f, 1.26818582e-01f, 2.33089089e-01f, 1.26873806e-01f, 1.90257907e-01f, 2.12942436e-01f, 2.25517675e-01f, 2.22181648e-01f, 1.88950986e-01f, 2.70184934e-01f,
  9.12468731e-02f, 2.11877719e-01f, 2.56257951e-01f, 3.69523376e-01f, 2.18959451e-01f, 2.18256742e-01f, 6.92334622e-02f, 2.60731995e-01f, 2.01607406e-01f, 2.02418536e-01f,
  1.12871304e-01f, 2.64162272e-01f, 5.05549908e-02f, 3.43093157e-01f, 1.92116037e-01f, 4.68191244e-02f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  1.65903986e-01f, 4.45165485e-02f, -1.12746581e-02f, 1.02464661e-01f, 1.23385794e-01f, -1.95624819e-03f, 3.33537072e-01f, -1.55189678e-01f, 2.06935741e-02f, -1.06934980e-01f,
  2.37798139e-01f, 1.24276042e-01f, 1.90742463e-01f, -7.20231161e-02f, 7.36630112e-02f, 2.12934047e-01f, -2.41703205e-02f, -2.14881301e-01f, -1.14912927e-01f, -2.53800869e-01f,
  2.75313035e-02f, 2.13960007e-01f, 1.86694100e-01f, 3.01754743e-01f, 9.46491435e-02f, 2.00138554e-01f, -4.43100668e-02f, -1.18222222e-01f, -9.01134908e-02f, -1.87911153e-01f,
  -1.06007494e-01f, -8.92378315e-02f, 7.50841126e-02f, 1.01781234e-01f, -1.06217116e-01f, 5.37087396e-02f, 1.63072258e-01f, 1.25732627e-02f, -3.34711641e-01f, -1.57304481e-01f,
  -2.35787556e-01f, 1.35253564e-01f, -7.56328478e-02f, -1.71416789e-01f, 6.72680093e-04f, -1.58062160e-01f, -8.43460613e-04f, -1.21783815e-01f, -8.81103892e-03f, 2.55619019e-01f,
  -2.53465138e-02f, 2.21048594e-01f, -1.46056935e-01f, -4.06122953e-02f, -2.10798830e-02f, -1.24602698e-01f, 3.47358622e-02f, 2.11941730e-03f, -1.21431537e-01f, -5.43503948e-02f,
  -1.06583469e-01f, 8.37304518e-02f, -3.51104513e-02f, -7.14000016e-02f, -1.47256002e-01f, 2.61069983e-02f, 1.79945335e-01f, -3.23788464e-01f, 1.61730766e-01f, 1.00279070e-01f,
  -1.82325587e-01f, 7.77907744e-02f, -4.84451316e-02f, -5.48031032e-02f, -1.60508811e-01f, 8.61319155e-02f, -2.63869375e-01f, 6.35472089e-02f, 2.75662631e-01f, 9.67895389e-02f,
  1.25791833e-01f, -1.59978241e-01f, 2.22864170e-02f, -8.81647095e-02f, 1.81702688e-01f, -1.42942667e-01f, -1.19708404e-01f, -2.93297082e-01f, -1.99725896e-01f, -1.97047591e-02f,
  1.50408879e-01f, 8.62584114e-02f, 1.19396448e-01f, 1.34915769e-01f, -1.52804986e-01f, 2.03065593e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -1.19620681e-01f, -2.93638647e-01f, 5.07913716e-02f, -2.82202184e-01f, -3.60545635e-01f, 4.30909544e-03f, 6.55894130e-02f, 4.19531822e-01f, 1.17051519e-01f, -3.04915179e-02f,
  -2.34330334e-02f, 1.25962466e-01f, 1.10536233e-01f, 1.73042193e-01f, 1.38220638e-01f, 2.05714181e-01f, -1.82481945e-01f, -2.17520401e-01f, 1.23894317e-02f, -1.68375671e-01f,
  1.32208047e-02f, -2.22787619e-01f, -1.11134164e-01f, 4.23247367e-02f, -1.20940730e-01f, -1.96039811e-01f, 3.72554511e-01f, -1.02998041e-01f, 4.15643811e-01f, 1.34122446e-01f,
  -3.41137266e-03f, 2.38538429e-01f, -1.10046826e-02f, -2.39712596e-01f, 3.41393381e-01f, -3.32159162e-01f, -3.03579658e-01f, 5.26143461e-02f, 9.66461077e-02f, 3.12344521e-01f,
  1.51483163e-01f, 2.69570708e-01f, -1.24776997e-01f, 1.40868932e-01f, 5.17584682e-02f, 1.69723257e-01f, 9.14232880e-02f, 1.22888103e-01f, -1.85186684e-01f, -1.93585336e-01f,
  -5.46447262e-02f, 7.96552226e-02f, -3.71762365e-03f, -2.80013829e-01f, -2.10953146e-01f, -7.22048953e-02f, -7.43810013e-02f, 1.59960426e-02f, 4.02121484e-01f, 9.08402503e-02f,
  3.06915641e-01f, 1.39527291e-01f, 5.54619431e-02f, 2.18896210e-01f, 2.01938018e-01f, 4.12949234e-01f, 2.32941899e-02f, 1.19994581e-01f, 1.18244998e-01f, 2.08401412e-01f,
  -1.87742729e-02f, -1.30015463e-02f, 2.12292284e-01f, -8.23765621e-02f, 2.02783480e-01f, 5.92944622e-02f, -2.81410255e-02f, -6.81634694e-02f, 7.77676236e-03f, 1.98062733e-01f,
  7.42967352e-02f, 7.30972691e-03f, 2.26694681e-02f, -6.48038313e-02f, 1.93107948e-01f, 3.07256430e-01f, -1.13354415e-01f, 3.76989126e-01f, 1.19650327e-01f, 2.03824177e-01f,
  -2.90460765e-01f, 1.99082226e-01f, -1.11458108e-01f, 3.58161293e-02f, 8.43956470e-02f, -1.60128027e-02f, 1.55730307e-01f, 6.52977377e-02f, 1.41764343e-01f, 1.99858710e-01f,
  -2.37386778e-01f, -1.62082732e-01f, -1.84146106e-01f, 1.14022873e-01f, 1.96817726e-01f, 3.08062851e-01f, -9.51337516e-02f, -1.81525484e-01f, 2.44655624e-01f, 2.78386652e-01f,
  -2.02113405e-01f, -2.26604924e-01f, 4.48781401e-02f, 4.38102752e-01f, 1.21419817e-01f, 4.26275313e-01f, 1.06185876e-01f, -1.32629380e-01f, -1.64509684e-01f, -1.08177595e-01f,
  1.40346318e-01f, -7.29010105e-02f, 1.12909868e-01f, -2.67323907e-02f, -3.46123129e-02f, 3.08138788e-01f, 3.23695391e-01f, 1.03382394e-01f, 1.69323072e-01f, 2.56692052e-01f,
  1.69536710e-01f, 1.23111717e-01f, 3.03086877e-01f, -1.72466695e-01f, -9.82292965e-02f, 7.07216263e-02f, -1.54606983e-01f, -6.75158128e-02f, 1.55533075e-01f, -2.37943474e-02f,
  3.06837887e-01f, -2.17722923e-01f, -4.57662232e-02f, 2.05497071e-02f, 2.85359146e-03f, 6.36213347e-02f, 2.12351933e-01f, 2.05218375e-01f, 9.09931064e-02f, -3.23943309e-02f,
  3.24007392e-01f, -1.01991206e-01f, 1.99477389e-01f, -7.22095445e-02f, 7.75982812e-02f, 8.63912553e-02f, -5.23502380e-02f, 6.42295554e-02f, -1.54530227e-01f, 3.29903811e-02f,
  -7.08549619e-02f, -4.51117717e-02f, 2.18480423e-01f, 8.97242650e-02f, -1.74234048e-01f, -7.61768594e-02f, -9.63289291e-02f, 2.87841380e-01f, 3.17707747e-01f, 1.05350830e-01f,
  -1.94984272e-01f, -1.37549862e-01f, -3.03291101e-02f, 2.65413761e-01f, 3.82497571e-02f, 7.16065317e-02f, 6.10060915e-02f, 9.63069499e-02f, 3.00315559e-01f, -6.29838109e-02f,
  1.91901892e-01f, -1.23428352e-01f, -1.46777615e-01f, -1.42384753e-01f, -5.46710901e-02f, -1.57231376e-01f, 9.69945565e-02f, -1.13036774e-01f, 1.41806677e-01f, -4.85570095e-02f,
  1.81012854e-01f, 3.06216627e-01f, 2.45791256e-01f, 3.88349771e-01f, -1.24471299e-01f, 4.22267824e-01f, 2.53171951e-01f, 1.18651330e-01f, -1.04559742e-01f, 1.12903014e-01f,
  2.27010608e-01f, -4.16488200e-02f, 2.78578848e-01f, -1.01067863e-01f, 1.63288131e-01f, -1.57572255e-01f, -1.66584566e-01f, 4.34759334e-02f, -5.40856905e-02f, -4.44991626e-02f,
  -1.03202604e-01f, -6.17075302e-02f, 1.39999077e-01f, 1.22063175e-01f, -9.86684486e-03f, 2.68449694e-01f, 2.34627262e-01f, -8.13474283e-02f, -1.55771658e-01f, -2.41735339e-01f,
  1.00198962e-01f, -1.52286813e-01f, -2.78512031e-01f, 2.67433692e-02f, 1.49278015e-01f, 1.46916166e-01f, 2.81546921e-01f, 1.34848624e-01f, 3.39136690e-01f, 5.32231815e-02f,
  -2.31600609e-02f, 2.22471014e-01f, 6.37472644e-02f, -7.18782237e-03f, -1.21348768e-01f, -2.47995462e-02f, -3.75805870e-02f, -1.37505651e-01f, 1.84129387e-01f, -2.63093989e-02f,
  5.46327651e-01f, 4.23064083e-01f, 3.27155769e-01f, 9.75212306e-02f, 4.19699967e-01f, 6.31667003e-02f, 7.95727298e-02f, -4.77066897e-02f, -2.41973177e-01f, 4.67232764e-02f,
  -1.87713161e-01f, 2.93436706e-01f, 8.59416574e-02f, 1.39485434e-01f, 1.78116277e-01f, 2.09675372e-01f, 3.31103832e-01f, 1.44039944e-01f, 4.08545732e-01f, -2.01664478e-01f,
  2.58964658e-01f, 1.80809777e-02f, 1.85062706e-01f, 2.40100399e-01f, 1.98113829e-01f, -3.86522971e-02f, 1.72125846e-01f, 4.16405350e-01f, 1.60315722e-01f, 1.42242670e-01f,
  3.41942191e-01f, 2.91910619e-01f, 1.97826132e-01f, -1.10294307e-02f, 2.41468102e-01f, 1.16362581e-02f, 4.26159889e-01f, 2.00070813e-01f, 2.69109786e-01f, 8.53607729e-02f,
  2.32804939e-02f, 1.60710335e-01f, 8.11836347e-02f, 4.60364908e-01f, 1.08197071e-01f, 7.39507675e-02f, -2.74612512e-02f, 2.38936245e-01f, -6.59544021e-02f, 1.11693047e-01f,
  1.76365271e-01f, -1.60444662e-01f, -1.68803543e-01f, -2.70525038e-01f, -1.54592499e-01f, -7.23770782e-02f, -6.93963235e-03f, 3.73709708e-01f, -3.80397588e-02f, 2.01740749e-02f,
  3.21018785e-01f, 1.26376212e-01f, -1.39827669e-01f, -1.23396985e-01f, -4.65430096e-02f, 2.39179358e-02f, 7.79701630e-03f, 4.22028244e-01f, -2.48114750e-01f, -7.13981688e-02f,
  2.37549961e-01f, -1.34394303e-01f, 2.73443878e-01f, -8.76956135e-02f, 1.13631442e-01f, -5.46036512e-02f, -1.68752953e-01f, 3.20465922e-01f, -2.27089394e-02f, -1.02824055e-01f,
  2.45312333e-01f, 1.64923772e-01f, -1.04567170e-01f, 2.22726434e-01f, 3.04354858e-02f, -1.37193263e-01f, 8.22645351e-02f, -5.68889780e-03f, -2.78023481e-02f, -1.17818847e-01f,
  2.21914619e-01f, -1.29851595e-01f, 3.55784088e-01f, 1.02802478e-02f, -1.47146642e-01f, 1.76652417e-01f, -2.11774796e-01f, 4.22529466e-02f, 1.98711112e-01f, 1.33409396e-01f,
  -5.18195815e-02f, 7.35377073e-02f, 2.46296808e-01f, 2.50388533e-01f, 2.21472800e-01f, -6.72861561e-02f, -1.05290502e-01f, -8.83663967e-02f, -3.61553691e-02f, -1.43710762e-01f,
  -8.28295425e-02f, 1.12507949e-02f, 3.23541462e-02f, 2.70320207e-01f, -6.21169880e-02f, 2.14958519e-01f, -1.62599862e-01f, 1.87541649e-01f, 3.70378137e-01f, -2.50767730e-03f,
  3.33705872e-01f, -1.10170551e-01f, 1.23062730e-01f, 8.35509449e-02f, -6.18617572e-02f, -7.09776953e-02f, -2.30489448e-01f, 1.27644300e-01f, -9.69161913e-02f, -3.62676084e-02f,
  -1.10098787e-01f, -3.88575494e-01f, -5.42631410e-02f, 3.68645340e-01f, -1.91103444e-01f, 4.50119883e-01f, 7.82243088e-02f, 3.46673280e-01f, -2.37600654e-02f, 1.61714911e-01f,
  -1.31962970e-01f, -2.16287911e-01f, 1.17932625e-01f, -4.22383063e-02f, 1.46932617e-01f, 2.24728137e-01f, 2.67422229e-01f, 7.37121478e-02f, -1.21545032e-01f, -2.56675124e-01f,
  -2.07140505e-01f, 5.14525101e-02f, -8.81210417e-02f, 4.05666530e-01f, -4.42414917e-02f, 2.44178139e-02f, 2.71191418e-01f, 2.28122145e-01f, -1.80469200e-01f, -1.30985543e-01f,
  4.86019254e-02f, 2.20378608e-01f, -1.06980242e-02f, 3.97926062e-01f, -6.00193925e-02f, -2.09443584e-01f, -9.14147720e-02f, -1.97603479e-01f, 1.47232652e-01f, -1.12805478e-01f,
  1.86165214e-01f, 1.38150334e-01f, -1.76017359e-02f, 4.69865233e-01f, 2.75976926e-01f, 2.26871427e-02f, 3.07438195e-01f, 3.97561193e-02f, 3.58679563e-01f, -1.65985763e-01f,
  1.75678171e-02f, 2.17190012e-01f, 2.98767239e-01f, 5.29077612e-02f, -5.87159954e-02f, -1.85874268e-01f, 1.39758572e-01f, 2.49906853e-01f, -1.96593046e-01f, 1.75619110e-01f,
  3.43931973e-01f, 2.41187289e-01f, -4.29871567e-02f, -1.18471481e-01f, -1.03580795e-01f, -2.02895433e-01f, 2.81107854e-02f, 3.43415588e-01f, -1.25394994e-02f, 2.83718586e-01f,
  -5.26293889e-02f, 2.05467179e-01f, -7.65287429e-02f, 3.06861520e-01f, 4.76590917e-02f, 5.11207059e-02f, 2.29093745e-01f, -1.02787144e-01f, 3.36140543e-01f, 3.47429551e-02f,
  2.80569077e-01f, -2.14496091e-01f, 2.88048327e-01f, -5.47613688e-02f, 4.80017327e-02f, 3.16739142e-01f, 2.09416002e-01f, -4.99452129e-02f, -7.44238943e-02f, 4.34060246e-01f,
  9.40302312e-02f, -6.29121140e-02f, 1.83302149e-01f, 2.61710258e-03f, 2.83685744e-01f, 5.81960268e-02f, 3.07444870e-01f, -6.29623327e-03f, 3.19402874e-01f, 2.25667536e-01f,
  3.52799445e-01f, -2.85949349e-01f, 2.02031001e-01f, 2.92517543e-01f, 6.05145097e-02f, 5.44413209e-01f, 1.99039921e-01f, 2.07367674e-01f, -9.52442959e-02f, 2.48602599e-01f,
  1.19356960e-01f, 8.80206078e-02f, -2.16281246e-02f, 7.31794089e-02f, 1.72538310e-01f, -9.82672647e-02f, 2.93792132e-03f, 7.24648067e-04f, -8.07361379e-02f, -2.67263707e-02f,
  8.13589916e-02f, 1.67609915e-01f, 1.48979843e-01f, -2.38628730e-01f, -7.90776387e-02f, -9.05717239e-02f, 1.65451858e-02f, 1.97102249e-01f, 1.89608127e-01f, 1.68111786e-01f,
  -2.09052805e-02f, 9.85779390e-02f, 1.13917969e-01f, -1.13138616e-01f, 9.68141779e-02f, 2.75182307e-01f, -1.34183317e-01f, 3.30898166e-01f, -7.39787742e-02f, 7.25369677e-02f,
  -2.09692642e-02f, 5.35623357e-02f, 6.81871176e-02f, -2.12764755e-01f, 1.05757602e-01f, 1.02847017e-01f, -2.52425134e-01f, 5.55577576e-02f, 1.73071206e-01f, 2.90772557e-01f,
  4.22136635e-01f, 5.83782867e-02f, -1.26064599e-01f, -1.81465521e-01f, 1.40904292e-01f, 1.45589337e-01f, 5.37009761e-02f, 8.60659927e-02f, 1.59052044e-01f, 1.39205344e-03f,
  2.84687489e-01f, -3.17953229e-01f, 1.95403665e-01f, -4.68548536e-02f, 1.21171050e-01f, 8.39408413e-02f, 5.34086190e-02f, -1.64273694e-01f, 3.07065934e-01f, -5.47804199e-02f,
  3.15696895e-01f, -1.51991574e-02f, 1.20417513e-01f, 2.97235161e-01f, 1.10280126e-01f, 1.86791644e-01f, -1.01501942e-01f, 6.91597536e-02f, -3.05089280e-02f, -2.26696700e-01f,
  -9.15466771e-02f, -5.87795824e-02f, -6.27104416e-02f, -6.42085448e-02f, 2.28027835e-01f, -7.76980668e-02f, 1.97646797e-01f, -2.06704155e-01f, -1.28686950e-01f, -1.10458352e-01f,
  -6.78400025e-02f, 2.56541342e-01f, 2.06090733e-01f, 3.98137420e-01f, -1.44621909e-01f, -1.18161738e-01f, 2.41906315e-01f, -7.91683421e-02f, 2.93757766e-01f, -1.99533608e-02f,
  1.68615475e-01f, -1.08823553e-01f, 7.32799899e-03f, 1.06059857e-01f, -1.48974434e-01f, 1.73075311e-02f, -3.16734123e-03f, 1.86946243e-02f, -1.60864875e-01f, 1.15285136e-01f,
  1.27879888e-01f, -1.40020773e-01f, 3.90814506e-02f, -6.04129338e-04f, 1.14020362e-01f, -1.11328572e-01f, 1.01664901e-01f, -1.61717102e-01f, 1.35037974e-01f, -1.44990236e-01f,
  -2.58526299e-02f, -8.86992365e-03f, 2.44464353e-01f, 1.42281249e-01f, 4.45213258e-01f, 1.30844966e-01f, 4.21281122e-02f, 5.08654751e-02f, 4.55142528e-01f, -1.07062366e-02f,
  9.48092490e-02f, -1.22200437e-01f, 1.65653571e-01f, -1.89698219e-01f, -2.62837652e-02f, -1.47540867e-01f, -1.53484389e-01f, 1.79027319e-01f, 2.73334831e-01f, 4.30203795e-01f,
  2.33409718e-01f, 2.48735338e-01f, 1.01559855e-01f, -6.83867186e-02f, -7.80604258e-02f, -8.58147219e-02f, -2.44138092e-02f, 9.22963470e-02f, 2.34506354e-01f, -2.66607374e-01f,
  2.81687498e-01f, -7.86803663e-02f, 1.09791616e-02f, 1.29749715e-01f, -8.70161653e-02f, 1.71994671e-01f, 1.31049663e-01f, 2.67087013e-01f, 1.19271909e-03f, 1.65317118e-01f,
  2.00752050e-01f, 2.67692000e-01f, 8.44396725e-02f, -6.29875064e-02f, 1.55563215e-02f, -2.44735077e-01f, 8.58885422e-03f, 8.54019597e-02f, 1.18895166e-01f, -1.32715702e-02f,
  3.41398716e-01f, 3.09680194e-01f, 2.42522895e-01f, 5.48915155e-02f, 1.81584418e-01f, 1.75194725e-01f, 1.74770445e-01f, -2.86747292e-02f, -1.74543604e-01f, -5.57959974e-02f,
  3.72834682e-01f, 1.64264962e-01f, 1.35586327e-02f, -3.38291973e-02f, 1.64320573e-01f, 2.51492530e-01f, 5.55100925e-02f, 2.03278586e-02f, -1.24908514e-01f, 6.36501238e-02f,
  1.70262173e-01f, 1.21065475e-01f, -1.26968995e-01f, 8.33631530e-02f, 4.95955646e-02f, 2.52446771e-01f, -1.20077655e-01f, 2.41190985e-01f, 3.93971242e-02f, 1.01725809e-01f,
  3.92061658e-02f, -1.72432765e-01f, 3.27843606e-01f, 2.31798977e-01f, 2.57353932e-01f, -2.32651010e-01f, -2.69089282e-01f, -2.02945367e-01f, 1.91809639e-01f, -5.59251383e-02f,
  1.18912766e-02f, 1.00673050e-01f, 3.51396829e-01f, 6.34001195e-02f, 3.99704695e-01f, 3.07596117e-01f, 2.85918564e-01f, 3.21873754e-01f, -3.96710150e-02f, -1.85180798e-01f,
  5.81184924e-02f, 1.68963552e-01f, -1.31363392e-01f, -1.65107343e-02f, 1.63353711e-01f, 3.10833454e-01f, 2.62065500e-01f, -4.77327481e-02f, -1.63879171e-01f, -3.80640060e-01f,
  -1.98199645e-01f, 4.78462949e-02f, 9.47058573e-02f, -2.38160893e-01f, -6.52551427e-02f, -2.16735993e-02f, 1.95390452e-02f, 4.63097803e-02f, -3.05986684e-02f, -6.41035149e-03f,
  5.58952577e-02f, 1.39033407e-01f, 2.39283353e-01f, -7.49637280e-03f, -1.39922693e-01f, -2.74126530e-02f, 2.33102798e-01f, -2.34314147e-02f, -9.00369696e-03f, -1.79351531e-02f,
  2.76759684e-01f, -1.02559008e-01f, 3.42697829e-01f, -2.15812981e-01f, 1.96626991e-01f, 1.32018253e-01f, 4.29747850e-01f, -1.47797391e-02f, -9.19576269e-03f, -1.15185447e-01f,
  1.15859089e-03f, 3.13139521e-02f, -2.28714887e-02f, -8.22834894e-02f, -1.30499527e-01f, 3.41155499e-01f, 2.36695379e-01f, 1.91027507e-01f, 3.20538223e-01f, -2.79846042e-01f,
  -1.21192805e-01f, 1.98241472e-01f, 3.30177665e-01f, -1.60728917e-01f, -2.10304111e-01f, 5.03080152e-02f, 3.89745623e-01f, 1.87085658e-01f, -1.08087771e-01f, 2.99895614e-01f,
  4.69535977e-01f, 4.63984430e-01f, -4.82614487e-02f, -1.43349826e-01f, -1.28515452e-01f, -3.66756204e-03f, 2.72718202e-02f, 9.33988988e-02f, -3.29039618e-02f, 3.13443840e-01f,
  2.02071056e-01f, 2.23831803e-01f, 1.30612850e-02f, -1.25208989e-01f, 7.64287487e-02f, -2.68745050e-02f, 1.11121595e-01f, -2.99837291e-01f, 2.24828407e-01f, 1.93008557e-01f,
  -6.86662793e-02f, 2.52339602e-01f, 7.58604556e-02f, 3.55545729e-02f, 2.07232177e-01f, -2.74166577e-02f, 1.46953195e-01f, -7.01925829e-02f, 2.46516794e-01f, 4.48330380e-02f,
  1.37669459e-01f, -9.20102298e-02f, -2.72022396e-01f, 5.54471985e-02f, -2.09961496e-02f, 2.69815713e-01f, -2.65070144e-02f, 1.51953474e-01f, -1.34978577e-01f, 1.64409474e-01f,
  -2.27247290e-02f, 3.68218094e-01f, 3.07466149e-01f, 2.75790960e-01f, -2.42693812e-01f, 2.17316553e-01f, -1.02396503e-01f, -5.81561550e-02f, 1.90905571e-01f, 5.82059957e-02f,
  -2.05798093e-02f, -2.41593234e-02f, 1.01659000e-01f, 1.13805182e-01f, 3.31233442e-02f, -6.74193278e-02f, -5.35461903e-02f, 2.98419185e-02f, 2.23207027e-01f, -1.77918766e-02f,
  -2.02397346e-01f, -2.03844845e-01f, -4.00424898e-02f, -6.37103245e-02f, -3.80023010e-02f, -1.28708035e-01f, 3.27933878e-01f, 4.31336641e-01f, 4.19210017e-01f, 5.81020340e-02f,
  3.17909658e-01f, -1.30943254e-01f, -2.06397008e-02f, -7.60924071e-02f, -6.00499660e-02f, -9.08554122e-02f, -4.06322144e-02f, 6.56735618e-03f, 1.54388860e-01f, 1.82237387e-01f,
  2.98847347e-01f, 3.26318771e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  2.11528152e-01f, 3.15301716e-01f, 1.36434108e-01f, 2.64969260e-01f, 1.89604685e-01f, 9.97574925e-02f, 1.31150424e-01f, 1.69418499e-01f, 2.77503282e-01f, 1.91872880e-01f,
  4.04696763e-02f, 2.05230206e-01f, 2.79239357e-01f, 3.37262958e-01f, 2.95807570e-01f, 1.99614149e-02f, 9.90962759e-02f, 1.27856746e-01f, 6.06449731e-02f, 4.19396013e-01f,
  3.43351066e-01f, 4.18700784e-01f, 5.60259968e-02f, 2.31605127e-01f, 8.63235667e-02f, 1.54724519e-04f
};

// L2_fan_Wp (Shape: 3 x 32)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -1.95749938e-01f, 8.40858519e-02f, -1.23847492e-01f, 4.96383309e-02f, -4.51890007e-02f, -7.64638558e-02f, -2.58210152e-01f, -2.80354202e-01f, 1.17108956e-01f, -1.13994917e-02f,
  8.58807862e-02f, -9.81845111e-02f, 1.87927522e-02f, 1.94580361e-01f, -3.27542350e-02f, 1.03832036e-01f, 1.33795455e-01f, 1.56328037e-01f, 1.47088664e-02f, 1.05760455e-01f,
  4.87774238e-02f, 2.51254644e-02f, -3.93653773e-02f, 2.05871440e-03f, 6.82098269e-02f, 6.16386458e-02f, 6.41347468e-02f, 1.04242839e-01f, 4.67363782e-02f, -2.77469568e-02f,
  1.49406269e-01f, 1.18901327e-01f, -2.22251996e-01f, -7.48224631e-02f, -1.36406079e-01f, -1.02667093e-01f, 1.08517170e-01f, -1.35986000e-01f, -2.97401518e-01f, -1.65362582e-01f,
  1.44336328e-01f, 5.20825274e-02f, 2.51921825e-02f, -2.76786666e-02f, -1.83493625e-02f, -1.03831254e-01f, 1.32725060e-01f, 9.83558670e-02f, 1.16709419e-01f, 9.09830257e-02f,
  -1.80787385e-01f, -1.01507962e-01f, -1.62309427e-02f, 1.35686219e-01f, -1.74203873e-01f, 1.64204240e-01f, 1.68863028e-01f, 6.90255240e-02f, 1.18823256e-03f, 9.66608245e-03f,
  7.58711100e-02f, -4.76951785e-02f, 2.66622931e-01f, 1.51916504e-01f, 1.24879489e-02f, -3.90521586e-02f, 1.97384059e-01f, -5.61394840e-02f, 1.07694224e-01f, 1.34937316e-01f,
  4.60460559e-02f, 5.54640703e-02f, -1.22121386e-01f, 1.21037707e-01f, -7.91361369e-03f, 2.12022942e-02f, -7.22894520e-02f, 1.02738291e-01f, -6.04232289e-02f, -7.22721126e-03f,
  -2.17133313e-01f, -1.66801393e-01f, 1.44096926e-01f, -1.15408622e-01f, 1.26259625e-02f, -3.77468579e-02f, 1.73838392e-01f, 4.29543890e-02f, -6.46141693e-02f, -9.76580977e-02f,
  4.01325151e-02f, -1.58261418e-01f, -7.31951073e-02f, 6.55836686e-02f, -1.47756338e-01f, 1.94479227e-01f
};

// L2_fan_Wp_bar (Shape: 26 x 32)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -4.31657815e-03f, 3.70815163e-03f, 1.89058945e-01f, -1.72844052e-01f, -1.27777383e-02f, -1.27869239e-02f, 2.35259250e-01f, 1.58307463e-01f, -1.20617151e-01f, 3.04125816e-01f,
  -3.41967233e-02f, 2.24661365e-01f, -2.52359752e-02f, -4.07412648e-02f, -6.60802200e-02f, 2.60031551e-01f, -2.91422219e-03f, -2.30470276e-03f, 3.28581899e-01f, 7.48024276e-03f,
  5.64856594e-03f, -4.20666002e-02f, 1.35707095e-01f, -3.14363949e-02f, -3.53103690e-02f, 3.40870246e-02f, -1.20467111e-01f, 2.29709715e-01f, 7.98757002e-03f, -1.16563305e-01f,
  1.76417343e-02f, -6.55946415e-03f, 1.19574532e-01f, 8.97036940e-02f, 2.74707156e-04f, -1.76096167e-02f, 1.54830031e-02f, 2.78064370e-01f, 1.61372706e-01f, 1.17603920e-01f,
  -1.94010995e-02f, -1.27767231e-02f, 1.78490102e-01f, 6.45776391e-02f, -1.70272231e-01f, 2.98113734e-01f, 4.51277137e-01f, -1.30767465e-01f, -9.64606255e-02f, -2.22097635e-01f,
  -2.04969682e-02f, 2.15791583e-01f, 4.99890000e-01f, 3.12584788e-01f, 1.31131470e-01f, -5.03557036e-04f, 1.01433359e-01f, -7.63875842e-02f, 1.92038447e-01f, -2.29388982e-01f,
  1.67311907e-01f, -3.60118560e-02f, -4.40540947e-02f, 1.63691640e-01f, -1.53078899e-01f, 3.77974585e-02f, 3.72941047e-02f, -3.79551351e-02f, 1.60341561e-02f, -1.69185400e-01f,
  -2.98166145e-02f, 4.81790490e-02f, -2.27376763e-02f, 1.92272455e-01f, 1.55477107e-01f, 2.10494921e-01f, 7.23760203e-02f, 3.10754120e-01f, 5.94421178e-02f, -9.61457938e-03f,
  2.67801374e-01f, -1.35248810e-01f, 2.56357402e-01f, -1.46478891e-01f, 3.05535048e-01f, 1.22082971e-01f, 1.81421742e-01f, 1.74348235e-01f, 1.63868159e-01f, 1.43892691e-01f,
  -1.21782035e-01f, 8.07724893e-02f, 2.50525236e-01f, -2.31516376e-01f, 1.78701840e-02f, 3.09431314e-01f, 1.02318026e-01f, 1.32112443e-01f, 5.74482270e-02f, -3.06472421e-01f,
  1.55846491e-01f, 1.63131803e-01f, 3.19141857e-02f, 7.40217566e-02f, 9.73222330e-02f, 3.54677379e-01f, 2.86367745e-03f, 1.06017061e-01f, -1.57540113e-01f, 4.54500347e-01f,
  2.06520066e-01f, 4.28051576e-02f, -1.64616555e-01f, -1.70129463e-01f, 4.45811272e-01f, 1.22656211e-01f, 2.20195726e-01f, 1.10102698e-01f, -1.07802689e-01f, -8.12841207e-02f,
  -1.87748790e-01f, -2.78202053e-02f, 1.89114064e-01f, -2.65455306e-01f, -2.17438325e-01f, -3.04065887e-02f, 5.61784022e-02f, 1.69249877e-01f, -4.84525831e-03f, 1.57012343e-01f,
  1.90154731e-01f, -1.54249281e-01f, -2.16130484e-02f, -1.87667221e-01f, -9.19492170e-02f, 1.21471532e-01f, 1.34567037e-01f, 2.97157854e-01f, 3.71435881e-02f, 6.37279376e-02f,
  1.48313725e-02f, 1.90655421e-02f, -1.69008262e-02f, 1.17248915e-01f, -2.21424513e-02f, 3.65024418e-01f, 3.01013529e-01f, 2.05333352e-01f, -1.00103736e-01f, 2.82979887e-02f,
  -7.01115951e-02f, -1.27242515e-02f, -2.18720540e-01f, 9.66170430e-02f, 2.99589872e-01f, 3.08963418e-01f, -1.75023705e-01f, 3.37642610e-01f, 3.03490639e-01f, 5.38427010e-02f,
  -1.04095303e-02f, 3.14236321e-02f, 5.03050052e-02f, -1.65965348e-01f, -5.36110587e-02f, 1.19313039e-01f, 3.01134884e-01f, 4.00081843e-01f, -6.16230480e-02f, 3.29046994e-01f,
  -3.12191453e-02f, 1.22326292e-01f, -1.30058154e-01f, -8.41312781e-02f, 2.15218589e-01f, 8.63405913e-02f, -1.28864318e-01f, 3.38762486e-03f, 1.74693570e-01f, -8.68511666e-03f,
  1.89186424e-01f, 1.62474848e-02f, 7.46282637e-02f, -1.15058288e-01f, -1.77485391e-01f, -3.72481830e-02f, 5.92853203e-02f, -1.21003024e-01f, -3.47615071e-02f, -1.68910041e-01f,
  8.89799278e-03f, 1.70282319e-01f, -6.68491200e-02f, 3.29295918e-02f, -4.45803069e-02f, 1.13475695e-01f, -1.02811143e-01f, -1.80592060e-01f, -2.44748935e-01f, -2.57316053e-01f,
  3.25899065e-01f, 2.83872280e-02f, 4.15071920e-02f, -9.26375091e-02f, 2.39071563e-01f, -2.62103025e-02f, 2.23699391e-01f, -6.24873526e-02f, 2.22236380e-01f, 2.54562587e-01f,
  -3.43760587e-02f, 1.96681991e-01f, 1.69797063e-01f, 1.66381553e-01f, -1.68744802e-01f, 7.74311200e-02f, -4.08240408e-02f, 2.41053849e-01f, 3.30622494e-01f, 2.40806729e-01f,
  -1.23078503e-01f, 3.03825051e-01f, 2.34200716e-01f, -3.61891724e-02f, 2.43033916e-01f, 1.03269503e-01f, 8.68708938e-02f, 1.66928917e-01f, -2.77990133e-01f, 3.08150232e-01f,
  1.33479163e-01f, 1.96554661e-01f, 2.38540888e-01f, -2.35399708e-01f, -5.99392317e-02f, -3.16175967e-02f, 4.72187158e-03f, -8.19987953e-02f, 3.08543861e-01f, -1.88877493e-01f,
  -9.89022702e-02f, 1.99246258e-01f, -6.99652806e-02f, 3.69225979e-01f, 2.09470257e-01f, -1.09921679e-01f, -4.17638533e-02f, -1.77989334e-01f, -2.29161829e-01f, 8.24525729e-02f,
  3.02090913e-01f, 2.39467800e-01f, -1.19443782e-01f, 3.70046169e-01f, -4.41054348e-03f, -1.26199096e-01f, 1.58901468e-01f, -2.40343243e-01f, -6.31403271e-03f, 1.23071805e-01f,
  -3.18155885e-01f, 1.99483976e-01f, 3.56966794e-01f, 1.74354464e-01f, 1.77046463e-01f, -7.48195797e-02f, -1.91997334e-01f, 2.88383424e-01f, -1.65407807e-01f, 7.00261816e-02f,
  2.25158289e-01f, -3.31626177e-01f, -8.00286978e-02f, 1.34515226e-01f, -3.07073772e-01f, 3.91675383e-01f, 1.44445434e-01f, -4.60947677e-02f, 3.64524007e-01f, -2.02402413e-01f,
  -4.79179733e-02f, -4.98573482e-02f, 1.48436829e-01f, 1.87782109e-01f, -1.17606454e-01f, 3.87952805e-01f, 1.87028512e-01f, 1.18404381e-01f, -4.57446352e-02f, 1.75169721e-01f,
  3.84923480e-02f, -1.85148254e-01f, 4.33285832e-01f, -1.01345479e-01f, -1.33724645e-01f, 8.72695148e-02f, -1.65239930e-01f, 4.46931839e-01f, 2.86512345e-01f, -9.94669870e-02f,
  -1.33403642e-02f, 8.46016104e-04f, -6.68043345e-02f, 4.40540850e-01f, 1.68207273e-01f, -3.17208827e-01f, 5.45861423e-01f, -2.91199744e-01f, 5.16578294e-02f, 1.91580564e-01f,
  -2.12511405e-01f, 5.02511859e-01f, 1.22047160e-02f, 3.94986004e-01f, 1.17696099e-01f, 1.43717617e-01f, -2.72232533e-01f, -7.45709315e-02f, 1.60617739e-01f, 1.14640318e-01f,
  3.35388750e-01f, 4.81940538e-01f, 1.76803350e-01f, -1.02342553e-01f, 1.42929759e-02f, 4.15026724e-01f, -2.76611716e-01f, 1.77894905e-01f, -2.10620016e-02f, 5.64083606e-02f,
  1.15645356e-01f, -1.78812310e-01f, -2.57506877e-01f, 1.51273578e-01f, 1.77774534e-01f, 2.72563457e-01f, -1.97874531e-01f, -2.45142296e-01f, 2.32426479e-01f, 3.14247936e-01f,
  9.43809673e-02f, -1.74532816e-01f, -4.26628828e-01f, -1.05869338e-01f, -2.63504893e-01f, 3.18198390e-02f, 1.43288910e-01f, 1.68965742e-01f, -1.45978540e-01f, 2.53231943e-01f,
  -3.80357474e-01f, -2.16552347e-01f, -2.38748416e-02f, -1.92655981e-01f, -5.03941886e-02f, -3.34557205e-01f, -2.85544425e-01f, 2.28742063e-01f, 3.12198430e-01f, 3.98446470e-01f,
  -1.95323288e-01f, 8.80915020e-03f, -1.59020022e-01f, 8.58320519e-02f, -2.82230377e-01f, -1.49765328e-01f, 2.32064560e-01f, 5.26244417e-02f, 7.23928213e-02f, 1.17215151e-02f,
  6.09131008e-02f, 2.83549666e-01f, -1.27975762e-01f, -1.97040007e-01f, 1.39685214e-01f, -5.87298349e-02f, -9.56308842e-02f, 1.85523331e-02f, 1.21579021e-01f, 3.98508191e-01f,
  -4.66187485e-02f, 4.12247419e-01f, -2.80679986e-02f, -7.13328272e-02f, 8.84663686e-02f, -1.47074088e-01f, 1.52641572e-02f, 2.66758408e-02f, -8.43792260e-02f, 2.26751640e-01f,
  2.07447812e-01f, 2.27013409e-01f, 1.83237374e-01f, -9.10774097e-02f, 7.46119628e-03f, 1.52668893e-01f, -1.30223006e-01f, 2.30995715e-01f, 3.76749307e-01f, -2.32171208e-01f,
  -1.38731390e-01f, 1.37683332e-01f, -1.77749246e-01f, 1.25381798e-01f, 3.67742121e-01f, 2.54572213e-01f, 1.47534385e-01f, -1.11710034e-01f, -2.15502158e-02f, -3.06345105e-01f,
  9.30906236e-02f, -2.96776235e-01f, 1.04336634e-01f, -1.34031028e-02f, 1.51007384e-01f, 9.14861709e-02f, 2.40017653e-01f, 3.69353741e-01f, -9.75095332e-02f, 3.53068918e-01f,
  -1.31171465e-01f, 6.06279112e-02f, -1.53213516e-01f, 1.10659450e-02f, 7.30311275e-02f, -2.02350408e-01f, 3.23363990e-01f, -1.71994902e-02f, 1.58267915e-01f, -1.88141316e-02f,
  3.89067650e-01f, 1.23737991e-01f, 8.06655809e-02f, -2.09449753e-01f, -8.32876787e-02f, -2.22714376e-02f, 4.81386393e-01f, 9.02065709e-02f, -4.07738127e-02f, 2.47077093e-01f,
  3.36980999e-01f, 1.32076461e-02f, 8.75619352e-02f, 1.99306495e-02f, 3.12129885e-01f, 5.41669242e-02f, -1.52010955e-02f, -9.12852660e-02f, 1.10078096e-01f, 1.80395484e-01f,
  -7.57552907e-02f, 3.35590184e-01f, 9.84260067e-02f, -1.78444818e-01f, 1.67999808e-02f, -1.22023657e-01f, 1.05266206e-01f, 1.24910519e-01f, 3.92843008e-01f, -8.40302855e-02f,
  2.60438740e-01f, -1.24483481e-01f, 8.83682370e-02f, 2.39602730e-01f, 3.63121152e-01f, -1.42363295e-01f, 5.26018515e-02f, -2.47380003e-01f, 2.03393474e-02f, 1.97440330e-02f,
  9.59769636e-02f, 2.74612367e-01f, 3.63548726e-01f, 3.33288580e-01f, 7.86909461e-02f, 2.84258157e-01f, 1.15974165e-01f, -1.03269760e-02f, 1.31725267e-01f, -1.10285118e-01f,
  2.89605677e-01f, 2.39739180e-01f, 7.61547536e-02f, -2.86676101e-02f, -1.16001047e-01f, 2.12732434e-01f, -8.55682604e-03f, 6.94731325e-02f, -7.87915848e-03f, -5.53532094e-02f,
  -1.26719056e-02f, 7.30609149e-02f, -9.20941010e-02f, 3.38284642e-01f, 1.54246792e-01f, -6.06034547e-02f, -2.01248109e-01f, -2.96206057e-01f, -1.13075338e-02f, 5.71738258e-02f,
  2.63929605e-01f, -9.04750749e-02f, -6.44580498e-02f, -1.55305713e-01f, 2.66483370e-02f, -1.95150282e-02f, 1.89750910e-01f, 7.78144076e-02f, 2.56953780e-02f, 1.52542844e-01f,
  -1.47242919e-01f, 8.55010077e-02f, 4.89817597e-02f, 9.21947882e-02f, -1.19618811e-01f, -1.33369220e-02f, -1.90915197e-01f, 1.23285338e-01f, 1.43606022e-01f, 7.39989802e-02f,
  1.03125945e-01f, 2.86225900e-02f, 1.06024891e-01f, 8.95978063e-02f, 6.38764258e-03f, 2.74965703e-01f, 1.66931733e-01f, -1.09248899e-01f, 4.34915274e-02f, 1.07686603e-02f,
  2.43380498e-02f, 1.46371666e-02f, 3.51466864e-01f, 2.23703459e-02f, 2.71160662e-01f, -1.37842670e-01f, 2.32730612e-01f, 2.74088010e-02f, -4.30867188e-02f, -6.15760498e-02f,
  3.75305206e-01f, -1.95076913e-01f, -5.25928801e-03f, 1.97482228e-01f, 1.37469456e-01f, 1.83530241e-01f, -6.84988201e-02f, 3.92671734e-01f, 8.42702687e-02f, -2.02280864e-01f,
  -2.63612181e-01f, -2.23602772e-01f, 1.54274866e-01f, 6.58715665e-02f, 2.91309178e-01f, -1.90296739e-01f, 4.59430516e-01f, 3.33737671e-01f, 1.93019867e-01f, -8.43833759e-02f,
  1.28916696e-01f, 1.34832123e-02f, 8.71099085e-02f, 2.20357269e-01f, 4.11201656e-01f, 2.55415916e-01f, -5.74929640e-02f, 1.55322313e-01f, 4.48129401e-02f, 1.20977737e-01f,
  2.27466017e-01f, -1.83221564e-01f, 5.80613166e-02f, -2.47527491e-02f, 1.42615438e-01f, 1.11167300e-02f, 1.25169411e-01f, -4.62567210e-02f, 1.13953650e-02f, -6.48910627e-02f,
  -2.02179328e-01f, 1.95640534e-01f, 4.16080445e-01f, 2.49811649e-01f, -1.42780423e-01f, -1.64842427e-01f, 1.82554480e-02f, 9.42924470e-02f, -2.38575593e-01f, -6.98671341e-02f,
  3.30434322e-01f, -7.77623355e-02f, 3.88282835e-02f, 2.35004839e-03f, -2.66182367e-02f, 2.02863351e-01f, 2.48982072e-01f, -4.58571166e-02f, 2.19272554e-01f, -8.74652341e-02f,
  2.44335905e-02f, 3.45277116e-02f, 1.35400623e-01f, 1.78840131e-01f, 1.85095578e-01f, 3.61399561e-01f, -1.39646679e-01f, -6.03395812e-02f, 1.67406321e-01f, 2.40288317e-01f,
  1.72615632e-01f, 3.43951195e-01f, -1.66893721e-01f, -2.15078816e-01f, -1.80360928e-01f, -2.51154363e-01f, 1.27211660e-01f, 6.04510121e-02f, 1.57539889e-01f, -1.94605738e-02f,
  3.38863879e-01f, -9.05803293e-02f, 1.73359543e-01f, 3.35551389e-02f, 2.06572607e-01f, 1.33778214e-01f, -3.49961803e-04f, 8.32991377e-02f, -1.41396001e-01f, -1.59359828e-01f,
  7.26730824e-02f, 1.83680147e-01f, 1.07515059e-01f, 4.52985376e-01f, 1.27505109e-01f, 4.39209998e-01f, -1.02338940e-02f, 2.17247128e-01f, 4.63404413e-03f, -1.04991920e-01f,
  1.54161584e-02f, -1.94764182e-01f, -1.49261162e-01f, -1.67660177e-01f, -1.50536403e-01f, 2.71820296e-02f, 2.84871548e-01f, 1.90459073e-01f, 3.63832042e-02f, -1.58119574e-02f,
  -8.79358277e-02f, 1.60269767e-01f, -7.39852861e-02f, -3.61329615e-02f, 2.24811882e-01f, -2.61535615e-01f, -4.19090688e-02f, 1.87186733e-01f, -1.05809852e-01f, 1.59875691e-01f,
  3.84804308e-01f, 1.96718842e-01f, 3.60739440e-01f, -4.40865234e-02f, 2.51120627e-02f, -3.14436227e-01f, 4.88298610e-02f, -1.41067445e-01f, 8.39023143e-02f, 1.47086695e-01f,
  2.79146612e-01f, 8.02520066e-02f, -2.21946806e-01f, 1.09036565e-01f, 1.81201696e-01f, 1.06221408e-01f, -1.08428694e-01f, -2.62309253e-01f, -7.77131468e-02f, 6.64610565e-02f,
  2.46534199e-01f, 3.22956353e-01f, 7.93793276e-02f, 3.28353286e-01f, 2.66702801e-01f, 4.07738268e-01f, 1.35883659e-01f, -1.90615669e-01f, 9.47790518e-02f, 2.80371517e-01f,
  2.76463125e-02f, -6.37539327e-02f, -3.35375294e-02f, -3.66956294e-02f, 3.28346521e-01f, 3.83909978e-02f, 2.16553986e-01f, 2.54942596e-01f, -8.15802440e-02f, -2.31059700e-01f,
  1.89842492e-01f, -3.36532801e-01f, 2.73809969e-01f, 4.60393399e-01f, -1.01221845e-01f, 1.77951351e-01f, 6.58208877e-02f, 2.19819143e-01f, -2.05996886e-01f, -2.11494759e-01f,
  -2.06401780e-01f, -1.85016140e-01f, 3.94642472e-01f, -2.39957888e-02f, -1.59892797e-01f, 2.71796938e-02f, 3.13497543e-01f, -1.89552400e-02f, 6.42188266e-02f, -1.52244151e-01f,
  -7.31933955e-03f, 4.54245031e-01f, -1.31589070e-01f, 3.08522910e-01f, -3.49440649e-02f, -6.61495477e-02f, -9.82915983e-03f, -7.33871153e-03f, -1.33014753e-01f, 1.30164668e-01f,
  2.74986625e-01f, 2.16140673e-02f, -6.32830858e-02f, 2.57097423e-01f, 3.47310960e-01f, -9.30689648e-02f, -1.12464121e-02f, 4.69576716e-02f, 2.11776882e-01f, -2.31244668e-01f,
  -1.06821895e-01f, -2.76275817e-02f, 1.70163304e-01f, 3.39072108e-01f, -5.93236275e-02f, 3.36126089e-01f, -1.33113831e-01f, 2.48356044e-01f, -3.29775251e-02f, 1.18552566e-01f,
  6.78737387e-02f, 9.90844220e-02f, -6.22029640e-02f, -5.10885343e-02f, 2.66050577e-01f, -1.37649879e-01f, 1.71091959e-01f, -9.37532857e-02f, 2.81923890e-01f, 7.00852741e-03f,
  1.88478995e-02f, 7.96155185e-02f, -2.21208617e-01f, -6.86580641e-03f, 1.85887441e-01f, -1.97696760e-01f, -7.77125135e-02f, 1.37122869e-01f, -5.44487834e-02f, 2.16676062e-03f,
  -4.20507304e-02f, -5.72754294e-02f, 2.28733476e-02f, 1.28648460e-01f, -6.66403323e-02f, -7.98013359e-02f, -3.65060521e-03f, 1.36844888e-01f, 1.58061445e-01f, 2.24563807e-01f,
  -9.87308696e-02f, 4.83456016e-01f, 2.31349364e-01f, -3.24884653e-02f, -6.93402216e-02f, -1.20120004e-01f, -4.91758995e-02f, -8.38230997e-02f, 1.15384609e-01f, 7.09866956e-02f,
  2.23618895e-01f, -6.50653467e-02f, 2.29444370e-01f, 1.55326888e-01f, -1.40612096e-01f, -2.55683333e-01f, 2.47351483e-01f, -2.73177892e-01f, 5.13757877e-02f, 3.33338231e-01f,
  2.21928537e-01f, 2.82774940e-02f, 3.02145660e-01f, -2.11474150e-01f, -2.05663398e-01f, -3.53877954e-02f, 2.86158979e-01f, 3.45234603e-01f, -1.96311668e-01f, 2.42216244e-01f,
  1.35362335e-02f, 2.19644845e-01f, -8.61226246e-02f, -3.20291072e-01f, -3.76048647e-02f, 3.15612882e-01f, -7.65020400e-02f, -1.59532111e-02f, 3.43139291e-01f, 6.66461810e-02f,
  6.57465011e-02f, -6.45669550e-02f, 2.93755084e-01f, -1.82746034e-02f, -1.20354265e-01f, 4.98351790e-02f, -2.33919233e-01f, 3.05477470e-01f, 1.63239054e-02f, -8.46102834e-02f,
  -9.73823071e-02f, -1.68153614e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  4.54972796e-02f, 1.79985777e-01f, 1.29873142e-01f, 2.36448854e-01f, 6.01110011e-02f, 1.38069078e-01f, 1.46310866e-01f, 2.89406210e-01f, 1.78895563e-01f, 2.42611632e-01f,
  3.34117055e-01f, 1.10902525e-01f, 3.74345221e-02f, 6.91749826e-02f, 2.07987458e-01f, 7.34705850e-02f, 3.31043042e-02f, 2.50811726e-01f, 1.97030216e-01f, 2.12738767e-01f,
  -1.45132169e-01f, 1.19156718e-01f, 3.03836465e-02f, 2.18665361e-01f, -1.85018424e-02f, 1.51042596e-01f
};

// L3_fan_Wp (Shape: 3 x 32)
const int L3_fan_Wp_rows = 3;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  -8.51196796e-02f, -8.69110152e-02f, 1.53799877e-01f, 6.52208328e-02f, 1.55557645e-02f, -4.26898897e-02f, -5.58277369e-02f, 4.09402959e-02f, -9.69676599e-02f, -1.39603093e-01f,
  1.23515420e-01f, -1.24206595e-01f, 1.14940599e-01f, 9.66462195e-02f, 5.39497584e-02f, 3.11488926e-01f, 7.96019211e-02f, 1.01683132e-01f, 1.02399014e-01f, 1.35230720e-01f,
  5.28248772e-02f, -4.02735472e-02f, -6.65368140e-02f, -6.55867308e-02f, -5.07865213e-02f, -1.56117156e-01f, 2.38347799e-02f, -1.98789075e-01f, 8.70407596e-02f, 1.59548633e-02f,
  -5.07748537e-02f, -1.29753398e-02f, 7.57392049e-02f, 1.00637026e-01f, 9.38637927e-02f, -6.59108534e-02f, -8.84543359e-02f, 1.19576678e-01f, 4.64902930e-02f, -1.26940697e-01f,
  4.86113392e-02f, 1.93898715e-02f, 4.51234803e-02f, -7.59829730e-02f, -7.62375146e-02f, 8.84522405e-03f, 2.32719392e-01f, -8.87876675e-02f, -8.28408897e-02f, 5.90047762e-02f,
  4.73349430e-02f, -1.58450931e-01f, -7.85409436e-02f, 1.25979856e-01f, 2.45621968e-02f, -2.06173599e-01f, 5.02969511e-02f, 9.55138803e-02f, 2.16978937e-02f, 1.57965302e-01f,
  -1.33616939e-01f, 1.18304022e-01f, 7.99200907e-02f, 1.27155870e-01f, -1.30446613e-01f, 3.85452099e-02f, -3.33371684e-02f, -1.46830887e-01f, 3.96663621e-02f, 6.80280151e-03f,
  5.16556837e-02f, 1.50486007e-01f, 4.30265516e-02f, 3.41874473e-02f, -1.34652227e-01f, 1.31303653e-01f, -9.32276994e-02f, 6.82051927e-02f, -1.10078380e-01f, -1.76905364e-01f,
  -1.40300393e-01f, 1.04556955e-01f, 4.76320609e-02f, -1.37117624e-01f, 2.58640144e-02f, 2.66870167e-02f, 1.81936473e-01f, 6.29853979e-02f, 6.59162253e-02f, 1.88408345e-02f,
  -5.57611138e-02f, 2.43830960e-02f, -2.51250029e-01f, -2.02098861e-02f, 1.51118234e-01f, 6.33769557e-02f
};

// L3_fan_Wp_bar (Shape: 26 x 32)
const int L3_fan_Wp_bar_rows = 26;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  2.69660242e-02f, -3.73446345e-02f, 1.15079224e-01f, -1.10030703e-01f, -1.44497693e-01f, -4.33700830e-02f, 5.25474995e-02f, 1.14510663e-01f, 2.04559758e-01f, -1.82976961e-01f,
  -2.30034813e-01f, 6.39244467e-02f, -1.59458682e-01f, 2.75039971e-02f, 1.59250438e-01f, -3.36497962e-01f, -3.57336178e-02f, 6.16036244e-02f, 4.79876958e-02f, 3.71669084e-01f,
  1.74425349e-01f, 9.82619300e-02f, 3.07475567e-01f, -6.44806549e-02f, 3.35576564e-01f, 8.43180194e-02f, 2.25483134e-01f, 5.36487699e-02f, -6.56352714e-02f, 1.74299091e-01f,
  1.39118388e-01f, 2.05176592e-01f, -1.57822538e-02f, -9.09525994e-03f, 8.15122128e-02f, -8.53230134e-02f, -1.80754483e-01f, 1.19577982e-01f, -2.64033556e-01f, 2.66117036e-01f,
  -1.81649089e-01f, -1.84699195e-03f, -5.36480397e-02f, -1.47674173e-01f, -1.35045588e-01f, 2.76297867e-01f, 3.38371754e-01f, -7.80798942e-02f, 3.00741673e-01f, 4.23441529e-01f,
  3.54818851e-02f, 9.20654982e-02f, -1.31633267e-01f, 2.03823075e-01f, 1.79731399e-02f, 8.79371241e-02f, 1.71946049e-01f, -5.59195057e-02f, -3.47834639e-02f, -2.83380359e-01f,
  2.23148242e-02f, -1.83848321e-01f, -8.06316882e-02f, -1.49319023e-01f, 3.60398740e-01f, 2.97355771e-01f, 3.05577219e-01f, -1.47162676e-01f, -4.17595506e-01f, 1.11526147e-01f,
  3.11059475e-01f, 2.17374857e-03f, -1.16699994e-01f, 3.42777580e-01f, 2.81977713e-01f, 2.55995005e-01f, -1.79525003e-01f, 3.26469868e-01f, -1.17459550e-01f, 1.45713419e-01f,
  7.09028542e-01f, 1.93770543e-01f, -6.89169174e-05f, 1.83553845e-01f, 2.44391169e-02f, 1.80881083e-01f, -5.33993058e-02f, -1.38563877e-02f, 5.64584062e-02f, 4.58890013e-02f,
  -1.92055464e-01f, -2.14686185e-01f, -7.91057423e-02f, 2.45884970e-01f, -2.91299999e-01f, 4.34625834e-01f, -2.73112748e-02f, -8.16825628e-02f, -5.89837618e-02f, 8.03091750e-02f,
  1.94557205e-01f, -1.33542627e-01f, 1.13210373e-03f, 1.78924456e-01f, 3.99530441e-01f, 1.10153995e-01f, -6.88360780e-02f, 2.92918775e-02f, 1.03969932e-01f, -2.27881953e-01f,
  2.57950183e-02f, 3.87120724e-01f, -2.77340889e-01f, -1.14155099e-01f, 2.34659836e-02f, 2.18025550e-01f, 1.84146717e-01f, -1.21082015e-01f, 1.77565023e-01f, 2.58720011e-01f,
  -1.02063939e-01f, 2.03228638e-01f, 6.09919988e-02f, 4.33131993e-01f, -1.03020914e-01f, 1.10762112e-01f, 1.56939670e-01f, -1.51998118e-01f, -9.55030695e-02f, -2.71243639e-02f,
  -4.25768420e-02f, 9.18712467e-02f, 1.02026880e-01f, -4.91248481e-02f, -3.95095721e-02f, -2.21848875e-01f, -5.86659759e-02f, -1.56303957e-01f, 3.84634703e-01f, -1.72148079e-01f,
  3.59098971e-01f, 2.78247863e-01f, 3.08491349e-01f, -7.62132928e-02f, -6.38619661e-02f, 1.79465145e-01f, -2.06181593e-02f, -5.85062578e-02f, -2.10063718e-02f, -1.60183102e-01f,
  -1.44346893e-01f, 1.99600548e-01f, -8.05228651e-02f, 2.42050186e-01f, 1.45365400e-02f, 9.07527208e-02f, 3.89576167e-01f, -4.61114384e-02f, -1.41398355e-01f, -1.45607278e-01f,
  -1.10931046e-01f, -1.55648235e-02f, -1.38931349e-03f, -1.29432142e-01f, 1.33063301e-01f, 1.91583216e-01f, 7.21392334e-02f, 2.81959891e-01f, 1.97817430e-01f, 4.26419020e-01f,
  -8.49759579e-02f, 1.63037509e-01f, -4.27860431e-02f, 1.69387516e-02f, -2.77413484e-02f, 1.54030770e-01f, 1.41593125e-02f, 8.60476866e-02f, 1.56308860e-01f, -7.98805654e-02f,
  -1.84158862e-01f, 1.05579697e-01f, 2.38473102e-01f, 2.28606816e-02f, 9.48573425e-02f, -3.18267107e-01f, 2.76068479e-01f, 1.29654229e-01f, -1.69012129e-01f, 2.16323227e-01f,
  2.40526766e-01f, 4.97229993e-02f, 2.40088224e-01f, 1.25565439e-01f, 1.25103801e-01f, -4.62727994e-02f, -2.47317508e-01f, 1.20315060e-01f, 1.06404051e-01f, -1.21611999e-02f,
  -6.34857714e-02f, 4.68695983e-02f, 1.84460711e-02f, 1.54346183e-01f, 1.37733981e-01f, 2.97701627e-01f, 2.57971287e-01f, -1.27834016e-02f, 4.14193690e-01f, 4.51498151e-01f,
  -1.94886923e-01f, 3.00427759e-03f, 5.93707524e-03f, 2.02904686e-01f, 2.46346164e-02f, -2.75421709e-01f, 2.96840131e-01f, 2.71984994e-01f, -1.48577347e-01f, -1.65349916e-01f,
  9.20311660e-02f, 5.31026311e-02f, -5.97384162e-02f, 2.69458443e-01f, 5.73351681e-02f, 9.56576038e-03f, 7.33748898e-02f, -1.42429814e-01f, -7.77802756e-03f, 8.27740729e-02f,
  1.77348211e-01f, 1.57271028e-01f, 2.76395291e-01f, 1.85341373e-01f, 4.99447621e-02f, 2.56169021e-01f, 5.51256053e-02f, -1.99188128e-01f, -2.40175977e-01f, 5.31522155e-01f,
  1.50009185e-01f, -5.03225438e-02f, -7.02504739e-02f, 2.42723048e-01f, 1.66986331e-01f, -1.12181701e-01f, 1.12187535e-01f, 1.05149515e-01f, -1.13340924e-02f, -8.72842669e-02f,
  1.24225371e-01f, 8.30504671e-02f, -1.49460703e-01f, 2.64644831e-01f, -4.05827388e-02f, 4.11906958e-01f, 1.68251485e-01f, -1.31263118e-02f, 4.65322733e-02f, 1.51058570e-01f,
  -3.32895406e-02f, -1.27457708e-01f, -1.12487674e-01f, 2.95557320e-01f, -2.22529083e-01f, 2.19048306e-01f, 9.26094502e-02f, 6.85938522e-02f, 2.96825737e-01f, 9.42586660e-02f,
  -8.19960237e-03f, 3.44003916e-01f, 2.63288915e-01f, -2.71280915e-01f, 1.45488486e-01f, 1.53876454e-01f, 2.27340385e-01f, 8.08807164e-02f, -1.63252622e-01f, 4.36401635e-01f,
  -1.18472479e-01f, 8.03887844e-02f, 6.65090084e-02f, -2.53302723e-01f, -8.08661431e-02f, -3.26420009e-01f, -2.07067028e-01f, -1.57732487e-01f, -2.16068223e-01f, -3.14217299e-01f,
  -7.32262507e-02f, -2.60212183e-01f, 2.08460838e-01f, 4.44670171e-02f, 1.62609324e-01f, 1.89953148e-01f, 1.43010840e-02f, 9.40944478e-02f, -3.64351794e-02f, 2.91896045e-01f,
  -2.80529633e-02f, 1.83039337e-01f, 4.16558266e-01f, -3.03793579e-01f, -5.29051840e-01f, -1.53196119e-02f, 5.25587976e-01f, -1.39219210e-01f, -2.27665827e-01f, -8.86739269e-02f,
  2.15432495e-01f, -8.99790600e-02f, 7.64824152e-02f, -2.55191803e-01f, 4.34575200e-01f, 2.06304505e-01f, 9.36225876e-02f, 1.80234373e-01f, 6.97045028e-03f, -1.60896089e-02f,
  1.32036209e-01f, 1.89162806e-01f, -1.79324131e-02f, 2.09638432e-01f, 2.10762080e-02f, -6.24520630e-02f, -9.04396698e-02f, 3.62961620e-01f, 1.20258331e-01f, 2.74724156e-01f,
  3.46125141e-02f, -1.22014582e-02f, -9.51341470e-04f, 2.38595791e-02f, 9.09556299e-02f, -3.01486582e-01f, 1.18829370e-01f, -3.28373551e-01f, 3.74108672e-01f, 3.28854233e-01f,
  -4.95788306e-02f, 2.16600314e-01f, 2.43579254e-01f, 3.62646610e-01f, -1.47106558e-01f, -1.88406542e-01f, 9.26953033e-02f, 2.46413589e-01f, 3.44407797e-01f, -1.20663144e-01f,
  1.65658057e-01f, -2.79205590e-01f, 2.69263387e-01f, 2.98461877e-02f, 2.35765904e-01f, 2.57638196e-04f, -2.34734073e-01f, -1.82123348e-01f, 7.97353089e-02f, 1.98772237e-01f,
  1.42052127e-02f, -1.77613586e-01f, -2.09162802e-01f, -4.57920544e-02f, -1.03367321e-01f, 2.01851323e-01f, 4.74223830e-02f, -6.70910403e-02f, 2.50361919e-01f, 1.03063416e-02f,
  3.91658954e-02f, 4.33315665e-01f, 3.69861692e-01f, 1.76697105e-01f, 2.38877714e-01f, -4.19355789e-03f, 2.01835945e-01f, 2.58166969e-01f, -4.43442427e-02f, -1.46108195e-01f,
  -2.80484855e-01f, 1.05315879e-01f, -9.06302407e-02f, 1.98006451e-01f, -4.89425212e-02f, 7.05207735e-02f, -4.06256057e-02f, 8.64089504e-02f, 7.51695260e-02f, -5.41200154e-02f,
  -1.70097034e-02f, 4.32857685e-02f, 2.56605357e-01f, 2.20797896e-01f, 1.07045442e-01f, -3.52611206e-02f, 8.24076235e-02f, -1.44615456e-01f, -2.43618548e-01f, 5.10562658e-01f,
  8.63364190e-02f, -1.45587564e-01f, -1.97201371e-01f, 7.29713067e-02f, 3.27583671e-01f, -8.77487510e-02f, -1.04268610e-01f, 2.86590695e-01f, -2.16586441e-01f, 2.33474314e-01f,
  -2.71872103e-01f, 1.72673166e-01f, -3.85583043e-02f, -4.27772626e-02f, 3.49968076e-02f, -5.50413877e-02f, -3.45381200e-02f, -1.58820555e-01f, 6.43380657e-02f, -2.47880399e-01f,
  -9.90146119e-03f, 9.00117531e-02f, -8.25049356e-02f, 2.84843892e-01f, -9.61651653e-02f, 1.77408766e-03f, -1.42138839e-01f, 1.86963364e-01f, 1.45556286e-01f, 2.42977589e-01f,
  4.84156370e-01f, -4.53785628e-01f, -1.36308476e-01f, 3.33397776e-01f, 4.58837569e-01f, 9.08065587e-02f, -3.79481852e-01f, 2.14454785e-01f, 6.76284581e-02f, -1.02580756e-01f,
  3.72759789e-01f, -9.95813310e-02f, 4.73760575e-01f, -2.99145374e-02f, -2.59269830e-02f, 1.72712013e-01f, 8.51764753e-02f, 9.08832066e-03f, -2.27261007e-01f, -1.67099312e-01f,
  3.68482107e-03f, -2.91503631e-02f, 1.42473787e-01f, -2.46070437e-02f, -1.29509196e-01f, -9.23688896e-03f, -2.48416007e-01f, -1.98611647e-01f, 3.10864300e-01f, -1.63701192e-01f,
  2.77580857e-01f, 2.14207485e-01f, 3.77674878e-01f, -3.67353797e-01f, -1.88700706e-01f, 4.32350963e-01f, 2.20495671e-01f, -5.64435273e-02f, -2.25350603e-01f, -1.62980542e-01f,
  -1.80730686e-01f, 3.76454145e-02f, 2.43123084e-01f, 1.16777152e-01f, 2.61901528e-01f, -1.65997773e-01f, 3.72546136e-01f, -1.43909410e-01f, -2.61215478e-01f, 1.46656632e-01f,
  5.75679988e-02f, -9.48307756e-03f, 1.36971503e-01f, 1.08743705e-01f, -1.01133168e-01f, -2.20959145e-03f, -2.79695541e-01f, 1.53708354e-01f, -2.41421491e-01f, 9.50869396e-02f,
  3.73236313e-02f, -2.32789703e-02f, 1.47060975e-01f, 3.98053020e-01f, 2.21337825e-01f, -2.08283812e-01f, 2.11821049e-01f, -2.24219859e-02f, 3.18012208e-01f, 1.35469109e-01f,
  -1.07229687e-01f, 2.63896435e-01f, 1.70271799e-01f, 1.74689680e-01f, 2.50770777e-01f, -9.03362334e-02f, 6.74457699e-02f, -1.10900141e-01f, 9.62937549e-02f, -2.69471467e-01f,
  -8.98987651e-02f, -2.16005743e-01f, 7.06808418e-02f, 9.87404957e-02f, -1.42098144e-02f, 8.18290636e-02f, 3.90436612e-02f, -1.99258983e-01f, -3.28200310e-02f, -9.72497836e-02f,
  4.37291041e-02f, -3.46056461e-01f, 2.10627705e-01f, -1.57391787e-01f, 3.25667262e-01f, 2.98912168e-01f, 1.51174396e-01f, 1.77694894e-02f, -2.18111975e-03f, 1.77189335e-01f,
  -2.02504307e-01f, 9.55969989e-02f, 3.57642800e-01f, -1.30986094e-01f, -4.26474661e-02f, 2.18495622e-01f, 8.36725309e-02f, 4.58557785e-01f, -1.72608167e-01f, 1.43898875e-01f,
  3.72530282e-01f, -8.93543735e-02f, -1.31455496e-01f, -5.11695147e-02f, 1.57488927e-01f, 1.07521795e-01f, 7.13924542e-02f, -9.74303782e-02f, -1.16096854e-01f, 2.19743416e-01f,
  2.18665257e-01f, 3.47984247e-02f, 2.68128097e-01f, 3.06731105e-01f, 3.09449047e-01f, 2.89884984e-01f, -1.07958853e-01f, -2.15649188e-01f, 9.67321079e-03f, 3.28866690e-01f,
  -3.10353842e-02f, -5.96947037e-03f, -2.46662691e-01f, -3.62204760e-01f, -1.56860709e-01f, 8.11359361e-02f, 4.63114120e-02f, -1.01939082e-01f, -1.27391919e-01f, -3.38128321e-02f,
  -1.78689986e-01f, 3.03373426e-01f, -9.64148268e-02f, 3.32993686e-01f, 1.75208539e-01f, 2.36657336e-01f, -7.62429833e-02f, 7.13517964e-02f, -1.35899752e-01f, 1.31026462e-01f,
  1.40714258e-01f, -2.13330820e-01f, -3.11170314e-02f, -3.34156901e-01f, 9.62372050e-02f, -2.18963325e-01f, 3.22457403e-01f, -1.07337236e-01f, 3.85532171e-01f, 1.37773886e-01f,
  -7.24101961e-02f, 1.38978615e-01f, -2.95307636e-01f, -8.48323330e-02f, -1.66268542e-01f, -1.20204613e-02f, 4.51174378e-01f, -1.89139172e-01f, -2.58250907e-02f, 1.99344859e-01f,
  -1.70338288e-01f, 4.14008021e-01f, -2.79320665e-02f, 2.73444712e-01f, 2.59066910e-01f, -2.13284716e-02f, -9.42512006e-02f, -1.06306046e-01f, 1.93840265e-01f, -5.09184077e-02f,
  1.46996543e-01f, -1.09832659e-01f, -2.35055342e-01f, 7.80988634e-02f, 7.09148049e-02f, 1.83837384e-01f, -7.00707883e-02f, 1.47100285e-01f, 4.55322638e-02f, 8.77904296e-02f,
  4.44738641e-02f, 3.80234063e-01f, 2.22576022e-01f, 4.48559038e-02f, 4.87462729e-01f, 4.70612854e-01f, 3.63044925e-02f, 3.24232392e-02f, -8.31706449e-02f, 9.56374779e-02f,
  -2.63374988e-02f, -1.74503341e-01f, 4.34576899e-01f, 6.00443743e-02f, 6.69245273e-02f, -3.29911381e-01f, -1.25926331e-01f, -8.98864567e-02f, -2.29483932e-01f, 2.08367482e-01f,
  -3.68843935e-02f, -6.62708357e-02f, -4.41097245e-02f, -1.11164339e-01f, -4.48378697e-02f, 4.23959307e-02f, 7.17080832e-02f, 3.49449098e-01f, 2.25183710e-01f, 1.39464429e-02f,
  -1.86827809e-01f, 2.14119762e-01f, -2.18052551e-01f, -7.92901292e-02f, 1.49082601e-01f, -1.10349320e-01f, -1.30174816e-01f, 1.09610455e-02f, -2.27255691e-02f, 8.83938223e-02f,
  1.24404833e-01f, 2.18893145e-03f, 2.18196854e-01f, 3.04107331e-02f, 1.63667262e-01f, -1.26240700e-01f, 1.64172471e-01f, 2.69495100e-01f, -1.51739374e-01f, 2.88620621e-01f,
  3.21642995e-01f, 1.80059180e-01f, -6.88950568e-02f, 8.96406472e-02f, -3.65050621e-02f, -7.11101368e-02f, 5.82758617e-03f, 1.55054495e-01f, 2.25291267e-01f, 1.78634584e-01f,
  8.38507563e-02f, 2.09945604e-01f, 1.20805196e-01f, 1.96857199e-01f, -2.59977639e-01f, -1.71502650e-01f, 5.01590371e-02f, 2.38232225e-01f, 1.06328884e-02f, 7.04171956e-02f,
  3.54828611e-02f, -2.18838304e-01f, -1.15480632e-01f, 8.72726515e-02f, 8.73340443e-02f, -3.16723548e-02f, 1.88131556e-01f, -1.39371872e-01f, 1.32729247e-01f, 1.58162042e-01f,
  -2.09045678e-01f, 3.05999786e-01f, 1.46072181e-02f, 3.15475017e-01f, 1.63417637e-01f, 2.40328312e-01f, -1.58723369e-02f, 1.65118620e-01f, -1.55081496e-01f, -1.59034833e-01f,
  -1.71656683e-01f, 3.65822375e-01f, 2.31128141e-01f, 2.46749133e-01f, -2.37575129e-01f, -8.14200938e-02f, 7.36902878e-02f, 1.12734921e-01f, 9.82239991e-02f, -3.22609723e-01f,
  2.79405028e-01f, -2.94019401e-01f, 1.79036677e-01f, 1.69026077e-01f, -6.54569268e-02f, 3.41042817e-01f, 3.04529667e-01f, 1.89570338e-01f, 6.34575635e-03f, 1.36329293e-01f,
  -1.38053149e-01f, 4.00804907e-01f, -1.72647424e-02f, 6.23684339e-02f, 3.97749215e-01f, -2.76090622e-01f, 1.13558307e-01f, 2.04980701e-01f, 4.88569029e-02f, 2.03915223e-01f,
  -3.91195938e-02f, -1.82569116e-01f, -6.19397759e-02f, -6.50940835e-02f, -2.28202760e-01f, -6.21172003e-02f, 1.36660218e-01f, -8.04795846e-02f, 1.41940907e-01f, 3.49858820e-01f,
  1.95520103e-01f, -3.02332163e-01f, -3.48481871e-02f, -2.36980513e-01f, 2.16107164e-02f, 7.02663809e-02f, -1.46790162e-01f, -4.03973162e-02f, -1.77570861e-02f, 2.47482762e-01f,
  -8.01257566e-02f, 2.69016027e-01f, -2.52523795e-02f, 2.04680935e-01f, 3.09029758e-01f, -5.32496311e-02f, -1.34570569e-01f, -2.00842805e-02f, -3.64702940e-02f, 1.98771313e-01f,
  -3.97385024e-02f, 1.80077374e-01f, 2.06616729e-01f, -2.39843711e-01f, -1.80069596e-01f, 1.82722002e-01f, 5.65798767e-02f, 2.82208204e-01f, -1.83174476e-01f, -2.19497960e-02f,
  7.18894228e-02f, -2.86470763e-02f, -1.31972983e-01f, 7.36395922e-03f, -8.44836980e-02f, -3.76431018e-01f, 8.67351964e-02f, 1.99939460e-01f, 1.68307498e-01f, 2.12498412e-01f,
  1.26572818e-01f, 3.29323024e-01f, -1.69391111e-01f, 1.46341473e-01f, -2.44124886e-02f, 2.48083636e-01f, 1.33843377e-01f, 1.59084991e-01f, 2.00204849e-01f, -3.59527946e-01f,
  -1.63511753e-01f, -9.33726206e-02f, -4.20577191e-02f, 1.82197496e-01f, 2.05690652e-01f, -2.02986166e-01f, -1.33727118e-01f, 2.88511842e-01f, 2.16240853e-01f, -7.95501620e-02f,
  -2.47953400e-01f, -4.82107848e-02f, 1.63378060e-01f, -8.22129995e-02f, -2.91142851e-01f, 2.34412923e-02f, -1.82885006e-02f, -3.81525487e-01f, 1.69863269e-01f, 4.71526712e-01f,
  2.30350181e-01f, 4.36987393e-02f, 1.39310911e-01f, 3.79512340e-01f, -2.30438411e-02f, 1.87385291e-01f, -9.17243713e-04f, -1.44715814e-04f, 7.73726851e-02f, -1.12051494e-01f,
  1.42959073e-01f, -2.36283928e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 26)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 26;
const float L3_fan_Bp_bar_data[] = {
  -1.16650546e-02f, 1.14469267e-01f, 2.66107708e-01f, -9.45408363e-03f, -1.94748919e-02f, -2.58167181e-02f, 9.92801189e-02f, 1.28305107e-01f, 8.53793696e-03f, 2.11206358e-02f,
  9.54917744e-02f, 1.71494782e-01f, 6.57647243e-03f, -1.20274886e-01f, 1.09027676e-01f, 7.18851313e-02f, 1.09379575e-01f, 1.45604327e-01f, 1.44184783e-01f, 1.37503669e-01f,
  1.04137637e-01f, 1.13360606e-01f, 1.51574671e-01f, 9.60543677e-02f, 3.32273208e-02f, -4.38427776e-02f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -1.42138034e-01f, -1.56578645e-01f, -1.36009872e-01f, 6.29311204e-02f, 1.08663134e-01f, 2.74819076e-01f, 1.51449263e-01f, 3.15375268e-01f, -3.82353887e-02f, -3.85281205e-01f,
  -1.92275658e-01f, 1.38386652e-01f, 1.13116033e-01f, -2.18921259e-01f, -4.15591359e-01f, 3.80685002e-01f, -5.14448524e-01f, 6.95301965e-02f, -3.78455073e-02f, 2.86172897e-01f,
  2.49837756e-01f, 1.83783948e-01f, -1.77324697e-01f, -2.27180630e-01f, -2.11838469e-01f, 2.00467795e-01f, 1.13796972e-01f, 1.28940508e-01f, -4.04388219e-01f, -1.69622257e-01f,
  -2.16370553e-01f, -5.31475991e-02f, -1.38805524e-01f, -1.64930254e-01f, -2.78237015e-01f, -3.48235369e-01f, -3.91276851e-02f, 2.88883783e-02f, 2.49646217e-01f, -3.98009241e-01f,
  -4.27468792e-02f, -6.59035519e-02f, 6.93547130e-02f, 1.64754495e-01f, 7.15610059e-03f, 7.71092474e-02f, -1.68329477e-01f, 4.12716210e-01f, -2.17815027e-01f, 1.41098335e-01f,
  -2.61344671e-01f, 3.16565633e-01f, -4.54963923e-01f, -2.84541935e-01f, -1.10311240e-01f, 1.67945549e-01f, -2.77328417e-02f, -1.08969323e-01f, 1.71140298e-01f, 1.69716418e-01f,
  2.44428813e-02f, 7.70762041e-02f, -1.93371847e-01f, -4.79304671e-01f, -1.89031661e-01f, -1.68860540e-01f, -3.32310200e-02f, -9.39963460e-02f, 1.86505958e-01f, -1.70374587e-01f,
  1.43883243e-01f, -6.21346086e-02f, -4.87776130e-01f, 1.37159007e-03f, -1.14851467e-01f, 3.08687650e-02f, -3.26429725e-01f, -1.36014178e-01f, -3.85327697e-01f, 7.66288266e-02f,
  1.17223918e-01f, 1.54437199e-01f, -2.54013628e-01f, 1.18115976e-01f, -9.48987454e-02f, -3.62041816e-02f, -2.79371768e-01f, -6.91851825e-02f, -3.88737321e-01f, -5.27205408e-01f,
  2.13181227e-01f, 1.14129335e-01f, 2.56642073e-01f, -1.66035399e-01f, 3.29492956e-01f, 1.45090520e-01f, -3.12827677e-01f, 1.09937280e-01f, 5.00064529e-02f, -3.68951857e-02f,
  7.35466704e-02f, 6.34281561e-02f, -1.57855913e-01f, 5.77248335e-02f, -2.36522809e-01f, -2.95159549e-01f, 3.01700145e-01f, -1.06053330e-01f, 2.84389943e-01f, -7.53083676e-02f,
  -1.83974862e-01f, -4.63269325e-03f, -2.96561122e-01f, -5.32712758e-01f, -2.96451151e-01f, 2.51133829e-01f, 3.14342827e-01f, 4.76128310e-02f, 1.93331361e-01f, -8.27442948e-03f,
  1.66318879e-01f, -1.65882241e-02f, -5.31990156e-02f, 3.73946913e-02f, -5.24256587e-01f, -4.19166777e-03f, -4.52730805e-01f, -4.29496765e-01f, -4.98281838e-03f, 2.22056910e-01f,
  1.91987276e-01f, 1.12849995e-01f, 3.17031890e-01f, -3.12589228e-01f, 1.04379207e-01f, 3.18292856e-01f, 2.10048497e-01f, -3.06399524e-01f, -6.09890856e-02f, -3.97537827e-01f,
  3.22965503e-01f, -4.06918526e-01f, 5.97712733e-02f, -3.98290783e-01f, -7.56490976e-02f, 2.31536999e-01f, -2.70169862e-02f, 1.39276445e-01f, 1.49424225e-02f, 2.65135646e-01f,
  9.93279442e-02f, -1.81039900e-01f, -3.41900140e-01f, 2.34877914e-01f, -2.70142138e-01f, -3.73413026e-01f, 2.05032825e-01f, 6.78454116e-02f, -2.46822983e-01f, -2.82981157e-01f,
  2.05993727e-01f, 1.13449536e-01f, 1.71880662e-01f, 2.13813096e-01f, 3.85393351e-01f, 2.00539187e-01f, -7.33835530e-03f, -5.84851056e-02f, 4.88898516e-01f, -2.95988113e-01f,
  -1.64051279e-01f, 5.24620861e-02f, 2.16895282e-01f, 2.74254173e-01f, -2.05464974e-01f, -4.05206561e-01f, -4.37715858e-01f, 1.91472709e-01f, -3.04452032e-02f, -2.41094500e-01f,
  -2.84460843e-01f, -1.03772298e-01f, -1.53613746e-01f, 2.32881784e-01f, -2.14042112e-01f, 5.66766225e-02f, 1.21922694e-01f, 3.00184518e-01f, -2.74058640e-01f, -1.79946527e-01f,
  -3.51707220e-01f, -1.42742723e-01f, 6.34863973e-02f, 1.99144125e-01f, 1.48924053e-01f, -8.12377036e-02f, 1.26371160e-01f, 2.98785716e-01f, -4.05004650e-01f, -1.30582273e-01f,
  -2.26458117e-01f, 3.19664896e-01f, -6.71667280e-03f, 2.36625135e-01f, -3.17647666e-01f, 4.77794372e-02f, -1.55970398e-02f, 1.90260988e-02f, -2.20169462e-02f, -4.31898147e-01f,
  4.65813756e-01f, -4.11555439e-01f, -1.18865371e-01f, -3.21822137e-01f, -3.09485584e-01f, 2.85530329e-01f, -1.79659367e-01f, -3.64015281e-01f, 1.13672219e-01f, 1.98981613e-01f,
  1.85046822e-01f, -9.80229080e-02f, 1.81963295e-01f, -1.53810084e-01f, -9.74547341e-02f, -1.34474903e-01f, -8.66728872e-02f, -2.53089238e-02f, -1.11726359e-01f, -3.06406319e-02f,
  -1.07859045e-01f, -3.24325971e-02f, -2.88062811e-01f, -7.15629682e-02f, 1.48748934e-01f, 6.46537961e-03f, -4.13308442e-01f, -6.64184161e-04f, 2.07404077e-01f, 3.94581944e-01f,
  1.71261430e-01f, -2.03458533e-01f, -2.13708356e-01f, 2.01377109e-01f, 2.62650967e-01f, 2.10310683e-01f, -1.04068890e-01f, -1.40674323e-01f, -2.20766485e-01f, -1.68453455e-01f,
  2.24906281e-02f, 1.15946326e-02f, -1.63003370e-01f, 6.82765767e-02f, -2.68600322e-02f, 1.67191401e-01f, 1.33849785e-01f, 3.20741534e-02f, 7.72334263e-02f, -4.05198224e-02f,
  -8.44101086e-02f, 1.79599062e-01f, 3.60203534e-01f, -4.75686155e-02f, -2.28642941e-01f, 2.68471301e-01f, -3.20479006e-01f, -1.79938793e-01f, -1.84100106e-01f, 1.32466480e-01f,
  -1.33804634e-01f, -2.54487872e-01f, -1.06561482e-01f, 3.08874130e-01f, 1.46152377e-01f, -3.12713087e-01f, -4.31758724e-02f, -3.13519448e-01f, 5.65598011e-02f, -3.08771729e-01f,
  -2.11902075e-02f, -1.38171509e-01f, 1.96603999e-01f, -7.65618533e-02f, 1.31726652e-01f, -2.57294178e-01f, -5.69581520e-03f, 3.13080072e-01f, 9.42827091e-02f, 1.82708487e-01f,
  8.72646943e-02f, 5.97239733e-02f, -1.88844442e-01f, 3.05604190e-01f, 3.91297825e-02f, 1.08059645e-01f, 1.88888237e-01f, -3.03817749e-01f, -5.35279810e-01f, 1.63304925e-01f,
  -9.34647024e-03f, -2.93075405e-02f, 3.50720644e-01f, -1.90052554e-01f, 1.66846737e-01f, 1.16791040e-01f, -5.16374260e-02f, 1.66442305e-01f, -4.48814034e-01f, 2.39156097e-01f,
  -4.54795152e-01f, -3.07985187e-01f, -2.60954380e-01f, 4.39604335e-02f, -5.71258701e-02f, -7.68428594e-02f, 1.94761544e-01f, -1.06877849e-01f, 1.35257080e-01f, 1.39058203e-01f,
  3.66771370e-01f, 1.80844262e-01f, 8.24109763e-02f, 2.68392354e-01f, -2.42099211e-01f, -3.28773439e-01f, -1.11923300e-01f, -4.52704012e-01f, -2.27342799e-01f, -5.23083471e-02f,
  1.51608735e-01f, -2.67466098e-01f, -1.17307879e-01f, -5.37312388e-01f, 1.53736835e-02f, -3.25336426e-01f, 1.80259049e-01f, -1.59613073e-01f, 5.14680054e-04f, -3.48347664e-01f,
  7.98217431e-02f, 2.93353312e-02f, 2.30921954e-01f, -1.20515324e-01f, 2.95188189e-01f, -6.09539568e-01f, -1.08819000e-01f, -4.30264473e-02f, 1.07906051e-01f, 3.58509392e-01f,
  2.91778207e-01f, 3.06817442e-02f, -1.60268396e-01f, -1.01784684e-01f, -1.64363608e-01f, -2.74051772e-03f, -1.55962005e-01f, -2.75579631e-01f, -3.45348358e-01f, -1.11975200e-01f,
  -2.07597930e-02f, 2.59166747e-01f, -2.39134617e-02f, -3.24142098e-01f, -1.50589362e-01f, 1.41921982e-01f, 3.15808833e-01f, -8.83277953e-02f, -3.53942454e-01f, 1.49851203e-01f,
  2.95082390e-01f, -7.88309872e-02f, -4.93350536e-01f, -3.13846409e-01f, 1.64852709e-01f, -1.17412485e-01f, 2.53922522e-01f, -3.69651914e-02f, -4.82179642e-01f, -8.98360237e-02f,
  -4.50879306e-01f, -1.99544147e-01f, 1.37864590e-01f, 2.75243193e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -9.20325741e-02f, -1.00647978e-01f, -1.80687398e-01f, -1.38319820e-01f, 3.04492358e-02f, 2.18620539e-01f, 8.12440440e-02f, -6.84289634e-02f, -1.66277573e-01f, -8.02351013e-02f,
  2.22219322e-02f, 2.29024906e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    