/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  5.82295954e-01f, 1.15943894e-01f, -6.84239566e-02f, 3.54683250e-01f, 3.70076358e-01f, -3.73225033e-01f, -3.05047873e-02f, 2.12821588e-01f, 9.08259973e-02f, -2.63520405e-02f,
  1.38651699e-01f, 1.39554217e-01f, -1.76424570e-02f, 1.32701725e-01f, 2.58725613e-01f, -9.45341140e-02f, 1.67874306e-01f, 9.83571708e-02f, -2.28510592e-02f, 2.56033301e-01f,
  1.15115434e-01f, 2.18501806e-01f, 4.82267849e-02f, 2.52529257e-03f, 2.57039592e-02f, -1.08409047e-01f, 1.12878680e-01f, -7.46015012e-02f, -1.12534165e-01f, 7.68391788e-02f,
  -5.36487326e-02f, 1.41833946e-01f, -1.10968776e-01f, -1.41604955e-03f, -1.62437640e-03f, -6.96285591e-02f, -8.75843875e-03f, -7.75101110e-02f, 7.70738795e-02f, -6.15145490e-02f,
  -4.04723585e-02f, -5.21232672e-02f, -2.20488776e-02f, -3.40771936e-02f, -6.86318055e-02f, -1.25865433e-02f, -9.59271342e-02f, -4.53157024e-03f, 2.02142354e-02f, -2.20299382e-02f,
  2.62839720e-02f, -2.74043214e-02f, 7.07174689e-02f, -1.10829864e-02f, 5.81066161e-02f, 4.24925378e-03f, -7.07130358e-02f, 2.16751508e-02f, -7.26287663e-02f, 5.70607334e-02f,
  -3.05700954e-02f, 1.15380641e-02f, 3.75271589e-02f, 2.43830159e-02f, 1.14186620e-02f, 2.90198997e-03f, -1.25018153e-02f, 6.51156390e-03f, -3.59866805e-02f, -7.56069599e-03f,
  -2.83326972e-02f, 5.19814529e-02f, 1.28262397e-02f, -9.27683935e-02f, 5.93650155e-03f, 1.26579264e-02f, -5.71658136e-03f, 6.09861407e-03f, 1.71171874e-02f, 7.12026376e-03f,
  -1.97283942e-02f, -1.96115393e-02f, 3.78263742e-02f, -4.52319421e-02f, 4.23315242e-02f, 3.49208079e-02f, -2.20820177e-02f, -1.29724154e-02f, 4.77704816e-02f, -3.86249423e-02f,
  1.14763834e-01f, 4.46622491e-01f, 5.86012118e-02f, 5.12581319e-02f, 3.11325714e-02f, 3.42026353e-02f, 9.56556003e-04f, -1.39076943e-02f, -1.43057138e-01f, 3.65931005e-03f,
  -1.45887211e-02f, 9.10143852e-02f, 4.24128808e-02f, 7.72359297e-02f, 5.39323967e-03f, -5.54986931e-02f, 5.94550595e-02f, 2.69661495e-03f, 3.65908407e-02f, 1.94722023e-02f,
  -4.76985760e-02f, -3.81514132e-02f, -2.46009305e-02f, 1.12758785e-01f, -2.81748530e-02f, -3.70962024e-02f, 1.08897373e-01f, -2.69863568e-02f, 2.42332295e-02f, -4.72290106e-02f,
  -2.49204952e-02f, 9.52312712e-06f, 1.97919592e-01f, 2.95547843e-01f, -1.70298845e-01f, -2.62113094e-01f, -5.09091496e-01f, 1.31767571e-01f, 1.20916672e-01f, -3.15025270e-01f,
  -2.42981866e-01f, 2.31704101e-01f, -3.97379488e-01f, 1.32174060e-01f, -9.29362923e-02f, -2.13502258e-01f, 1.08675011e-01f, 4.45049396e-03f, 6.19486198e-02f, 1.43672395e-02f,
  7.32249990e-02f, -5.10690361e-02f, 4.36526351e-02f, 1.78404022e-02f, 6.18118187e-03f, 2.28286594e-01f, -5.17410636e-02f, -3.66676636e-02f, 2.10775495e-01f, 4.51497398e-02f,
  -1.31968511e-02f, 4.23069671e-02f, 9.86957103e-02f, 9.15863663e-02f, -3.41584645e-02f, -5.18679842e-02f, 1.10531617e-02f, -4.39148173e-02f, 1.37922140e-02f, 1.61402300e-02f,
  -4.25673202e-02f, 5.42556942e-02f, 4.02717553e-02f, -3.07131931e-02f, 6.93145022e-02f, 5.56954369e-02f, 6.50041625e-02f, 3.28709036e-02f, -2.38073543e-02f, -5.25025092e-02f,
  -1.95563771e-02f, 1.62531494e-03f, -2.86529474e-02f, -1.46363871e-02f, 1.74395535e-02f, 6.06194958e-02f, -3.05467602e-02f, 3.03695295e-02f, 5.66348210e-02f, 2.68664602e-02f,
  -1.70378610e-02f, -4.36435789e-02f, -4.93561514e-02f, 1.26474099e-02f, -2.72330176e-02f, 2.48901248e-02f, -4.72497055e-03f, -6.66491613e-02f, 2.32749823e-02f, -8.08978081e-02f,
  -2.15823110e-02f, 7.12547544e-03f, -1.30127417e-02f, 3.44856568e-02f, -2.92093195e-02f, 3.21860462e-02f, -3.95044014e-02f, -3.41761671e-02f, 5.65514341e-03f, 3.50685194e-02f,
  -8.31451043e-02f, 2.38838289e-02f, -3.70085575e-02f, -3.60179543e-02f, -5.12228720e-02f, 5.91705274e-03f, -2.76606139e-02f, 1.62992664e-02f, -1.05947014e-02f, -8.01564455e-02f,
  1.13879191e-02f, -2.56080143e-02f, -4.73426133e-02f, 1.57693643e-02f, 3.42723057e-02f, 2.17443635e-03f, 1.50232445e-02f, 5.99353462e-02f, 7.43111446e-02f, -5.96621223e-02f,
  5.55475205e-02f, -4.27615307e-02f, 3.56907435e-02f, 6.43240884e-02f, -2.11363882e-02f, -6.05610088e-02f, -2.81549096e-02f, 1.70375258e-02f, 5.43309525e-02f, 9.16322246e-02f,
  1.44660287e-02f, -3.44225802e-02f, 1.02389148e-02f, -1.95177477e-02f, -3.23420502e-02f, -9.68210697e-02f, 1.44119203e-01f, 4.24805433e-02f, -1.00822728e-02f, 2.79933251e-02f,
  8.05991709e-01f, -7.57652670e-02f, -6.41720146e-02f, 2.16356024e-01f, -4.01599286e-03f, 4.71711069e-01f, 3.00705463e-01f, -7.16306418e-02f, 2.82396793e-01f, -2.85413256e-03f,
  -3.97140421e-02f, 2.35192358e-01f, -1.11038968e-01f, 1.19082361e-01f, 2.91944474e-01f, 1.48629704e-02f, 2.26409003e-01f, 1.41518191e-01f, 3.51595022e-02f, -2.39316504e-02f,
  8.48602131e-02f, 8.12736601e-02f, -1.11679643e-01f, -2.52167992e-02f, 9.59014595e-02f, 5.15529793e-03f, -1.98725954e-01f, -6.49430975e-02f, -1.41791537e-01f, 2.37716106e-03f,
  -3.48310582e-02f, 4.60610613e-02f, -5.36044240e-02f, -3.07671223e-02f, 2.99632680e-02f, 1.76440030e-02f, 7.54254684e-03f, -3.61786759e-03f, 2.11435985e-02f, 4.69180476e-03f,
  6.99103028e-02f, -4.48811091e-02f, 1.28045902e-01f, -1.85351186e-02f, 1.49420112e-01f, -2.97634397e-02f, 4.45962399e-02f, -1.53118204e-02f, -5.18342033e-02f, 2.68802177e-02f,
  2.29029125e-03f, -3.04311048e-02f, -2.21515987e-02f, 4.04648706e-02f, 2.80161574e-03f, 1.18845403e-02f, -1.62718439e-04f, 2.45192740e-02f, 5.20233922e-02f, 1.39497399e-01f,
  5.50173000e-02f, 4.25245166e-02f, -1.42312264e-02f, -1.06787272e-01f, 1.24152787e-02f, -6.09577224e-02f, -4.10593003e-02f, 1.47538558e-02f, 3.85677740e-02f, 2.80694421e-02f,
  6.21315800e-02f, 3.42885479e-02f, 1.35717932e-02f, 4.08722125e-02f, 5.17572388e-02f, -2.19285209e-02f, 1.98461264e-02f, 1.04343810e-03f, 7.13010579e-02f, 1.74682774e-02f,
  -1.62255261e-02f, 3.71626243e-02f, -3.90451550e-02f, 2.61522811e-02f, -1.29113160e-02f, 1.68539304e-02f, 2.59287208e-02f, 1.67388022e-02f, -6.97732344e-02f, 7.75218010e-03f,
  3.35984007e-02f, -7.49952346e-02f, 8.23550019e-03f, 1.54424030e-02f, -6.00027619e-03f, 7.50592947e-02f, 5.11480533e-02f, 4.11073305e-02f, 1.43600337e-03f, 5.48893772e-03f,
  -1.00034242e-02f, 1.00590609e-01f, -6.01078309e-02f, 3.46691683e-02f, -1.16565684e-02f, 1.54358642e-02f, -5.76712079e-02f, 4.27677743e-02f, 1.05399705e-01f, -2.96932161e-02f,
  -2.63602156e-02f, 6.31055832e-02f, 5.51149361e-02f, -3.64878215e-02f, 1.19974546e-01f, 4.11167666e-02f, 3.65535431e-02f, -5.12990409e-05f, 9.21629719e-04f, -6.57877401e-02f,
  -7.72132277e-02f, -1.28737420e-01f, -4.80883643e-02f, 7.71726519e-02f, -1.72319457e-01f, -9.43609402e-02f, 2.03743920e-01f, 4.20318991e-02f, -2.33939111e-01f, 2.04585314e-01f,
  2.05163226e-01f, 5.06386980e-02f, 3.13953348e-02f, 5.10022283e-01f, 2.54463434e-01f, 2.03447547e-02f, 2.25981772e-01f, 2.93593537e-02f, -1.82446316e-01f, -2.03845855e-02f,
  2.16426142e-02f, 2.88514256e-01f, 2.40175009e-01f, 1.45179883e-01f, 7.94511065e-02f, -1.52557522e-01f, 2.36121207e-01f, -5.02755381e-02f, 2.28537947e-01f, 1.34960279e-01f,
  1.60986975e-01f, 1.58663429e-02f, 3.52779217e-02f, 7.20454054e-03f, -6.59469515e-02f, 7.72903115e-03f, 1.81056261e-02f, 5.72001562e-02f, -1.23755885e-02f, -9.69755128e-02f,
  -6.34586215e-02f, 7.86728039e-02f, -4.42137830e-02f, -2.31690276e-02f, -1.53475376e-02f, -4.49314602e-02f, -2.42202040e-02f, -2.12656744e-02f, 3.30574019e-03f, -5.23481332e-02f,
  -1.63206294e-01f, -1.48032252e-02f, -4.65779006e-03f, 2.54154876e-02f, 7.84027739e-04f, -5.49785979e-02f, 2.09774598e-02f, -1.40296211e-02f, -1.40683847e-02f, -3.17267627e-02f,
  6.93178996e-02f, -2.79245595e-03f, -2.70861872e-02f, 5.01587726e-02f, 4.89004254e-02f, 2.32921299e-02f, -1.97915118e-02f, 3.74875329e-02f, -7.05873445e-02f, 2.66814623e-02f,
  -3.53970453e-02f, -1.04858242e-02f, -3.42258960e-02f, -1.03620933e-02f, 4.87600220e-03f, -7.51025453e-02f, 1.44331623e-02f, 3.74665670e-02f, -1.45453922e-02f, 9.30165872e-03f,
  5.44367433e-02f, -3.33470106e-02f, 6.29520193e-02f, 1.14502601e-01f, 8.04136973e-03f, 8.40085652e-03f, 8.30813423e-02f, 2.25948654e-02f, -1.02430321e-01f, 5.44200987e-02f,
  5.85485948e-03f, -2.99186353e-02f, 1.45752663e-02f, 7.68704936e-02f, 1.66191987e-03f, -2.46552899e-02f, -5.52601460e-03f, -1.67945437e-02f, 2.22814623e-02f, 3.75669599e-02f,
  4.90392707e-02f, -3.03101037e-02f, 5.68510108e-02f, 3.33100297e-02f, 6.30471259e-02f, 7.28729442e-02f, 5.87982796e-02f, -5.99117912e-02f, 2.50099637e-02f, 4.79255356e-02f,
  1.84310123e-03f, 1.01716993e-02f, 6.95481002e-02f, -3.94187681e-02f, 2.24645082e-02f, -7.94101283e-02f, -2.09154990e-02f, -2.94965040e-02f, 7.59736598e-02f, 5.92723154e-02f,
  -2.50232011e-01f, 3.66891501e-03f, 2.08331883e-01f, 2.37683225e-02f, -4.22051549e-01f, -2.13125959e-01f, 4.29294735e-01f, -3.11799020e-01f, 1.32643133e-01f, 7.58344084e-02f,
  -2.69871920e-01f, 3.54961514e-01f, 1.12579837e-01f, -1.95799358e-02f, -4.73533645e-02f, 2.18595862e-01f, -2.89089903e-02f, 2.80235820e-02f, 1.07869864e-01f, -1.49160385e-01f,
  -7.95328394e-02f, -2.90206522e-01f, 4.36878204e-02f, -2.87247270e-01f, -1.36518210e-01f, -1.41786322e-01f, -2.48753354e-01f, 2.46630665e-02f, -2.15460166e-01f, 1.85305141e-02f,
  -1.01454318e-01f, -6.65898919e-02f, 3.01457010e-02f, 8.29141513e-02f, -1.28680140e-01f, 2.66528279e-02f, 8.71064588e-02f, 4.58071791e-02f, 1.14322782e-01f, 7.00712502e-02f,
  7.57863596e-02f, -5.93322627e-02f, -4.41655563e-03f, 1.57865509e-03f, 8.42494965e-02f, 2.09812764e-02f, -1.68947112e-02f, -2.49259062e-02f, 8.04610327e-02f, 1.53434770e-02f,
  5.36703914e-02f, -2.54392866e-02f, 8.11516494e-02f, 1.05149455e-01f, 7.72370622e-02f, 1.52459368e-02f, 6.51067644e-02f, 7.59615228e-02f, -5.25928363e-02f, 1.51564050e-02f,
  3.82638201e-02f, 5.58054335e-02f, 3.76500678e-03f, -8.87093320e-03f, -2.42853686e-02f, -2.84306929e-02f, 3.01904716e-02f, 2.59571783e-02f, 6.12539314e-02f, 2.57958542e-03f,
  -1.41623691e-01f, 5.64961694e-02f, 2.50114966e-02f, -2.35606208e-02f, 3.73311117e-02f, 4.18819897e-02f, 9.54087079e-03f, -6.16948120e-02f, 2.66791172e-02f, 1.35035478e-02f,
  3.44408527e-02f, 1.47869028e-02f, -4.02475009e-03f, 5.78371733e-02f, 3.89120588e-03f, 8.41018334e-02f, -2.80291215e-02f, 1.92253396e-03f, -6.52030157e-03f, -3.38542834e-02f,
  3.91231179e-02f, -1.04046166e-01f, -1.25993486e-03f, 2.82929447e-02f, 5.75014465e-02f, -9.62604284e-02f, 3.86612155e-02f, 5.54449577e-03f, -6.18892126e-02f, -8.93324092e-02f,
  -5.47843389e-02f, 3.94898765e-02f, -1.04889683e-01f, -5.06172664e-02f, -3.23871486e-02f, -5.02435081e-02f, 1.64742358e-02f, -1.08235134e-02f, -1.10587284e-01f, -5.60899116e-02f,
  -6.52417168e-02f, -4.51167412e-02f, -3.74065228e-02f, -9.54916403e-02f, -6.45920262e-02f, -2.38768328e-02f, -1.09731667e-01f, -1.28686819e-02f, -2.48988606e-02f, 1.19702689e-01f,
  -8.55942629e-03f, -3.84775251e-02f, -9.05578062e-02f, -9.45161507e-02f, 4.88577962e-01f, 2.24849612e-01f, 1.25265718e-01f, 2.06686601e-01f, 2.12535247e-01f, -9.89750028e-03f,
  2.26221636e-01f, -2.76292056e-01f, -9.07879993e-02f, 7.02716783e-02f, -3.20962131e-01f, -8.03446099e-02f, 6.26363559e-03f, -1.19537316e-01f, 1.63734585e-01f, 1.25416458e-01f,
  8.41642767e-02f, 1.47817031e-01f, -1.87447339e-01f, 2.77779549e-01f, 1.56894043e-01f, 5.55767193e-02f, -4.63396944e-02f, -2.41079647e-02f, -6.22902736e-02f, 7.70413354e-02f,
  1.45991698e-01f, 7.70933330e-02f, -4.21931818e-02f, 9.27741230e-02f, 3.60888615e-02f, -1.53738791e-02f, 1.17658349e-02f, 4.27195579e-02f, -1.00337744e-01f, -3.13429646e-02f,
  -8.02017748e-02f, -3.26143578e-02f, 3.49709131e-02f, -3.80400419e-02f, 7.37736300e-02f, 3.40606552e-03f, -1.37741473e-02f, 2.00355947e-02f, 1.35298520e-02f, -3.29047814e-02f,
  -8.82564038e-02f, 7.18989819e-02f, 4.36697528e-02f, 3.84154320e-02f, 1.13839373e-01f, 6.17983714e-02f, 4.52026576e-02f, 8.01458210e-03f, 1.14156380e-02f, 4.15235385e-02f,
  8.66771936e-02f, 1.45556539e-01f, -5.29749468e-02f, -3.32175791e-02f, 9.15842131e-03f, 4.80804853e-02f, -5.78571460e-04f, 2.76173186e-02f, 9.39810742e-03f, 5.93247451e-02f,
  -6.59988821e-02f, 1.73183549e-02f, 5.82114272e-02f, 4.10815887e-02f, 8.86822701e-04f, -5.66335879e-02f, -5.58475144e-02f, 2.70722862e-02f, 4.35791574e-02f, -2.33424529e-02f,
  4.79540080e-02f, 1.32851321e-02f, -4.72027715e-03f, 2.43736412e-02f, 1.28311992e-01f, -5.76104410e-02f, 4.30268124e-02f, -8.67117196e-02f, 3.33295278e-02f, -3.93746868e-02f,
  1.30904004e-01f, 2.39092857e-01f, 1.31964058e-01f, 5.60045689e-02f, -9.29701701e-02f, -7.61980191e-02f, 2.60510333e-02f, -5.69958314e-02f, 6.74872622e-02f, 3.58412601e-02f,
  -2.15808880e-02f, -4.26540561e-02f, 8.17832202e-02f, -9.98484716e-02f, -3.71158496e-02f, 8.55383128e-02f, -4.03867383e-03f, 1.22624137e-01f, -8.35682452e-02f, -2.05522235e-02f,
  -6.58474639e-02f, -3.85357402e-02f, -4.38458659e-02f, -4.99430709e-02f, -6.22298978e-02f, -3.88246700e-02f, -5.37184440e-02f, -2.01765951e-02f, -1.26479283e-01f, 4.53924090e-02f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  5.25497831e-02f, 6.99723780e-01f, 1.97668999e-01f, 3.35200340e-01f, -3.90379541e-02f, -8.27441692e-01f, -6.07583597e-02f, 3.12452376e-01f, -2.29118317e-01f, 4.65243697e-01f,
  -1.67643890e-01f, 1.37650281e-01f, 9.81209725e-02f, -4.86418784e-01f, -8.63414526e-01f, -6.21942639e-01f, -4.45917606e-01f, -2.78516293e-01f, -1.32915869e-01f, 2.04776272e-01f,
  -6.49148375e-02f, -3.17984581e-01f, -3.34288925e-01f, 3.48820865e-01f, 4.87925082e-01f, 6.86019182e-01f, 4.25246269e-01f, 3.21694881e-01f, 2.45648280e-01f, -2.26466537e-01f,
  -5.26303887e-01f, -3.08125420e-03f, 2.18011692e-01f, -2.52039228e-02f, -2.04518568e-02f, 2.59281516e-01f, 1.30418420e-01f, -1.37363464e-01f, -8.08179937e-03f, 5.41828722e-02f,
  3.82289849e-02f, -1.41204685e-01f, -7.54429400e-02f, -6.75387904e-02f, 5.58765456e-02f, 8.27230886e-02f, 8.61267522e-02f, -1.80427209e-02f, -3.66782546e-02f, -2.13087611e-02f,
  -1.48009568e-01f, -4.67313305e-02f, 2.04792202e-01f, 5.76080382e-02f, -7.51243979e-02f, 2.21092510e-03f, -1.25978485e-01f, -4.04350348e-02f, 6.16818704e-02f, 1.50025196e-04f,
  3.58898640e-02f, 9.25556868e-02f, -7.27843121e-02f, -1.74221635e-01f, -7.06594065e-02f, -9.81863663e-02f, -3.07207555e-03f, -4.54724766e-02f, -6.29551113e-02f, -1.02546982e-01f,
  5.85033894e-02f, 1.58355579e-01f, -1.26020595e-01f, 1.53861372e-02f, 3.38549130e-02f, 3.43631878e-02f, -4.52212729e-02f, -3.90369110e-02f, -1.12523800e-02f, -5.41541986e-02f,
  1.17742859e-01f, -2.26686336e-02f, -4.93660308e-02f, 1.03480823e-01f, -4.65651937e-02f, 2.87549235e-02f, 1.32232487e-01f, 5.95147125e-02f, -2.51841005e-02f, 9.16056149e-03f,
  1.67345941e-01f, 4.89699513e-01f, 1.15607902e-01f, -6.71917796e-02f, -2.89283190e-02f, -2.53370404e-01f, -2.54873484e-01f, 2.53834222e-02f, 1.11736692e-01f, -8.73518661e-02f,
  8.91417712e-02f, 9.77938399e-02f, 7.12012202e-02f, -1.92448497e-02f, 5.77696227e-03f, -3.71291004e-02f, 4.01202077e-03f, 5.22375200e-03f, 2.95754522e-01f, 1.57535970e-01f,
  2.56796867e-01f, -5.94164990e-02f, -1.12935923e-01f, 5.51400185e-02f, 1.39876753e-01f, 1.39339641e-01f, 5.81261478e-02f, -6.41174763e-02f, 2.03731731e-02f, 9.38831922e-03f,
  -1.08011164e-01f, -3.94916348e-03f, -2.04032272e-01f, 4.54870611e-02f, -1.00407273e-01f, -7.91752219e-01f, -6.60633326e-01f, -2.09750488e-01f, 1.63345292e-01f, 3.36425513e-01f,
  -3.70223820e-01f, 4.39319581e-01f, -6.38421699e-02f, -3.92240256e-01f, -9.42802727e-01f, -1.51952073e-01f, -5.05673230e-01f, 4.47008573e-02f, 5.29422425e-02f, -2.41448149e-01f,
  -4.10805196e-01f, -4.92701530e-01f, -2.08143994e-01f, -4.56215143e-01f, -3.38099420e-01f, 1.54102236e-01f, 1.04654253e-01f, -3.17182273e-01f, 8.60887319e-02f, -1.25277027e-01f,
  -8.73855725e-02f, 2.53097057e-01f, 8.30374435e-02f, 2.79931743e-02f, -1.01394229e-01f, -7.05454051e-02f, -4.06013429e-02f, -3.23754661e-02f, 1.20181069e-01f, -5.92888072e-02f,
  2.16172859e-01f, -1.95231996e-02f, 4.23421599e-02f, -9.67291966e-02f, -1.40750140e-01f, 2.82386094e-02f, 1.40137494e-01f, 1.99017674e-01f, 2.44542003e-01f, -8.57189223e-02f,
  3.14702950e-02f, -2.60284059e-02f, 1.05665484e-02f, 2.69155174e-01f, -1.52269527e-01f, -8.71180966e-02f, 1.67260300e-02f, -2.13866457e-02f, 1.20077051e-01f, 1.04029462e-01f,
  -7.50865638e-02f, -1.24242105e-01f, 5.56460097e-02f, -4.83559892e-02f, 3.17770690e-02f, -1.13452449e-02f, 1.38365244e-02f, 3.86864319e-02f, 1.28493071e-01f, -1.38095379e-01f,
  7.19340667e-02f, 1.12792710e-02f, -9.39215273e-02f, 2.34167967e-02f, -1.08859271e-01f, 1.80171132e-01f, -5.04776537e-02f, 7.08574727e-02f, -7.48233274e-02f, -1.59755722e-01f,
  2.33261567e-02f, -8.42658803e-03f, 1.16899602e-01f, -8.86078775e-02f, -8.92969146e-02f, 6.59705773e-02f, -1.10088140e-01f, 1.01504177e-01f, 3.46105546e-02f, -1.42427415e-01f,
  -8.08876306e-02f, -2.21108958e-01f, 3.98615263e-02f, -9.69705358e-02f, 1.35843888e-01f, -1.13232732e-01f, -1.53735131e-01f, -4.89561930e-02f, -1.52607754e-01f, -1.83872983e-01f,
  -2.73910075e-01f, 1.29557475e-01f, -1.08823158e-01f, 2.81891115e-02f, 7.75069743e-02f, -1.53855562e-01f, -1.06423549e-01f, 5.36405481e-02f, -6.74791485e-02f, 8.59743655e-02f,
  5.02436347e-02f, 1.14285178e-01f, 9.06407610e-02f, -2.06896607e-02f, -6.94847247e-03f, 7.98198059e-02f, 1.08424313e-01f, 1.04246832e-01f, 1.01961046e-02f, -4.89351153e-02f,
  -8.37754607e-01f, 1.97479814e-01f, -4.50237125e-01f, -4.07086641e-01f, 1.26389995e-01f, -4.77080107e-01f, -3.87691200e-01f, 8.53178725e-02f, 2.46336889e-02f, -8.23190156e-03f,
  -1.46605119e-01f, 1.03558160e-01f, 3.85133058e-01f, -4.56941217e-01f, 1.17931873e-01f, -1.59482639e-02f, -6.01423204e-01f, -5.44133961e-01f, 1.81453943e-01f, -2.83569008e-01f,
  -6.51626959e-02f, -2.44486362e-01f, -2.40713447e-01f, 3.98372084e-01f, -2.77133316e-01f, -5.90959676e-02f, -4.01683450e-01f, 3.96107078e-01f, -4.33078021e-01f, -1.31093320e-02f,
  -1.32635638e-01f, 4.20601726e-01f, -1.35650784e-01f, -1.56427041e-01f, -2.37048298e-01f, -2.65887808e-02f, -3.01948339e-01f, 9.47489813e-02f, 5.88623919e-02f, 1.22049920e-01f,
  -6.44530728e-03f, 5.33941761e-02f, -6.02589771e-02f, 2.78009385e-01f, -9.91540626e-02f, 3.78331263e-03f, -6.20522015e-02f, -2.75841951e-01f, 5.43294623e-02f, 1.17881745e-01f,
  3.31061594e-02f, -2.87931245e-02f, -1.63915768e-01f, -1.52945712e-01f, -1.68860748e-01f, -5.60958870e-02f, -1.34279504e-01f, -9.44207534e-02f, -1.98146313e-01f, -1.62543580e-01f,
  -2.58558057e-02f, -4.55821380e-02f, -4.48070131e-02f, -1.75121669e-02f, -4.84774411e-02f, -1.32672012e-01f, 5.80248088e-02f, -1.23796381e-01f, -5.37440591e-02f, -1.05870232e-01f,
  -4.30520736e-02f, -1.44693509e-01f, -1.55597311e-02f, -1.48358643e-01f, -1.98533045e-04f, -1.22685969e-01f, -6.84286430e-02f, -1.02088191e-01f, -1.49805723e-02f, -4.83550169e-02f,
  5.55771925e-02f, -1.72732890e-01f, 6.65100291e-02f, -1.36809272e-03f, -5.22130877e-02f, 6.48715571e-02f, 8.25213715e-02f, -2.27437187e-02f, -8.89437571e-02f, 4.97443974e-02f,
  -4.53341454e-01f, -2.42569104e-01f, 7.91788399e-02f, 1.32833347e-01f, -2.81193554e-02f, 8.87907296e-02f, -2.99600735e-02f, -1.58011056e-02f, -6.77159652e-02f, -2.73440927e-02f,
  2.24703681e-02f, -5.17136939e-02f, -1.67723835e-01f, 2.02008914e-02f, 1.73563827e-02f, 1.68764070e-02f, -9.34764147e-02f, -1.09568544e-01f, -9.10539478e-02f, -1.23580657e-02f,
  3.36650871e-02f, 7.03323111e-02f, 3.28262262e-02f, 6.12392463e-02f, 5.95314093e-02f, -8.19571316e-02f, -4.45161164e-02f, -3.45742889e-02f, 1.04396090e-01f, -2.79345177e-02f,
  1.03233933e+00f, -5.31803966e-01f, 5.08273184e-01f, 8.96464884e-01f, 6.41563952e-01f, -2.61440217e-01f, 3.33737135e-01f, 6.30074069e-02f, 4.66868699e-01f, -5.60765803e-01f,
  3.90434563e-02f, -1.23234592e-01f, -2.31081501e-01f, 5.88332582e-03f, 2.65222818e-01f, -2.36449108e-01f, -2.92523857e-03f, -1.59784943e-01f, 3.95526774e-02f, 1.43202037e-01f,
  2.19307527e-01f, -3.12578753e-02f, 3.23397517e-01f, -2.33225301e-01f, 2.47248292e-01f, 4.70336974e-02f, 2.35108137e-01f, 6.01288266e-02f, 1.35415852e-01f, -3.35820951e-02f,
  -1.50964111e-01f, 2.57171422e-01f, 7.88172185e-02f, -1.48168713e-01f, -9.15169418e-02f, -4.04701270e-02f, -1.17920816e-01f, 8.09973758e-03f, 1.02839343e-01f, -4.10145931e-02f,
  -1.16637414e-02f, 3.22262873e-04f, 1.99067108e-02f, -6.95974156e-02f, 1.27357796e-01f, 6.24127127e-02f, 1.17259711e-01f, 5.55387288e-02f, 1.01208918e-01f, 6.60492778e-02f,
  -5.57350963e-02f, 1.05067991e-01f, 2.89946795e-02f, -2.87156552e-02f, 4.29074876e-02f, 1.73911937e-02f, 1.94586292e-02f, -3.19389254e-02f, -5.96748292e-02f, -5.03619611e-02f,
  8.94532073e-03f, -9.11426321e-02f, -5.69337904e-02f, 4.37562494e-03f, 3.59321497e-02f, 6.97279572e-02f, -1.69068351e-02f, 6.28928989e-02f, 3.88893187e-02f, 5.34906797e-02f,
  -4.82058600e-02f, 7.96815455e-02f, 4.93431911e-02f, 2.32000854e-02f, -4.18333672e-02f, 3.27581502e-02f, -5.77033404e-03f, -6.09129258e-02f, -9.37176961e-03f, 2.98530553e-02f,
  1.09062530e-01f, 1.94964223e-02f, -1.19819082e-01f, 8.15165713e-02f, 1.35938292e-02f, 3.50545198e-02f, 6.29181266e-02f, 4.46956754e-02f, 6.80401400e-02f, -3.11591029e-02f,
  -1.12535310e+00f, -7.25171208e-01f, -3.60690244e-02f, 7.56112114e-02f, 3.43500674e-02f, -1.56584550e-02f, 8.72967765e-03f, 7.93650821e-02f, -1.77758306e-01f, 1.22364812e-01f,
  2.97256083e-05f, -5.26416581e-03f, -1.19372606e-01f, 1.60337284e-01f, -3.79590839e-02f, -5.98090477e-02f, -3.54993865e-02f, -7.52423331e-02f, -1.40071556e-01f, 4.76772524e-03f,
  -4.98034172e-02f, -7.38409609e-02f, -1.00910077e-02f, 2.27732174e-02f, -5.26616536e-03f, -6.80695102e-02f, -2.59153452e-02f, -1.93663165e-02f, -1.05858445e-01f, 2.48799343e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  9.54159081e-01f, 6.18734881e-02f, 4.28820044e-01f, 6.67698860e-01f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -1.16693147e-01f, 1.16321273e-01f, 2.02049181e-01f, 3.76987644e-02f, -2.41561122e-02f, 6.97172731e-02f, -2.01169088e-01f, 1.42959893e-01f, -9.04524997e-02f, -5.12534797e-01f,
  2.71982774e-02f, -2.93296129e-01f, -7.17035383e-02f, -4.37391430e-01f, -1.26756951e-01f, 6.40367091e-01f, 3.44322979e-01f, -1.82041556e-01f, -1.74417809e-01f, 4.97806638e-01f,
  3.98300499e-01f, -5.12367964e-01f, -2.78440177e-01f, 2.56114185e-01f, 7.02828407e-01f, -4.77668852e-01f, 1.12758529e+00f, -4.72002290e-02f, -2.40350202e-01f, 1.93549305e-01f,
  3.03194731e-01f, 1.41009033e-01f, -1.15003265e-01f, 8.36706221e-01f, -5.11065722e-01f, 4.40566570e-01f, 3.37824263e-02f, -1.70692325e-01f, 1.11457787e-01f, -1.07796840e-01f,
  2.64219016e-01f, -3.32700044e-01f, -3.13037753e-01f, 9.70008075e-01f, -1.60047263e-01f, 1.94553912e-01f, 4.86405104e-01f, -3.18750948e-01f, 4.33151945e-02f, -2.01353073e-01f,
  -2.77022690e-01f, 2.09254533e-01f, 1.58361688e-01f, -2.22119734e-01f, 2.07694545e-01f, 1.01961541e+00f, 4.21688855e-01f, -5.98991156e-01f, 9.25499797e-02f, 3.56685370e-01f,
  1.03196703e-01f, 2.86564291e-01f, 2.95461953e-01f, 1.38819143e-01f, 4.52705145e-01f, 3.79939467e-01f, -5.05445838e-01f, 5.10573983e-01f, 3.87126096e-02f, -2.79050678e-01f,
  -2.67553538e-01f, -8.48066568e-01f, 2.08586946e-01f, -1.06767213e+00f, 1.99673370e-01f, 4.58998054e-01f, 4.25258949e-02f, -4.84779954e-01f, 5.92409410e-02f, 1.16094999e-01f,
  3.89285237e-01f, -2.11612731e-01f, -7.55669594e-01f, -1.46689251e-01f, -2.83250809e-01f, 6.05274998e-02f, 8.78726304e-01f, 3.17296922e-01f, 4.56625700e-01f, 6.60231560e-02f,
  8.19371268e-02f, 3.17330837e-01f, 5.77969313e-01f, -6.91603273e-02f, -5.63185662e-02f, -4.97740567e-01f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  9.63439941e-01f, 6.57045543e-01f, 9.69858110e-01f, 9.63032663e-01f, 1.10324597e+00f, 5.39482355e-01f, -8.95998299e-01f, 4.45806086e-01f, -1.47377804e-01f, -1.11022472e+00f,
  1.81589377e+00f, 8.79992545e-01f, 2.74909616e-01f, 1.61150551e+00f, 1.56142437e+00f, -3.78659040e-01f, -1.27575898e+00f, 1.22841966e+00f, -9.46690559e-01f, 7.08702266e-01f,
  6.14712417e-01f, 1.09312320e+00f, 2.77138539e-02f, -3.70135337e-01f, -1.28555059e+00f, -1.45022130e+00f, -8.58774483e-01f, 1.16331661e+00f, 8.43594551e-01f, -5.59677482e-01f,
  6.01428330e-01f, 3.52585733e-01f, 1.11396325e+00f, 1.29070687e+00f, -1.86574683e-02f, 9.72055912e-01f, -4.48819458e-01f, 2.00161082e-03f, 1.76951265e+00f, -1.20936346e+00f,
  2.26763487e+00f, -5.14516413e-01f, -9.64174792e-02f, 2.19848454e-01f, -3.60016584e-01f, -8.34431171e-01f, 1.00728408e-01f, 9.26094294e-01f, 5.47091722e-01f, -2.33963698e-01f,
  3.36863011e-01f, -3.57555479e-01f, -3.62017125e-01f, 3.56291711e-01f, 6.71828449e-01f, 1.37438095e+00f, 3.09932791e-02f, -4.23878372e-01f, -1.25871277e+00f, 6.10402226e-01f,
  1.51215386e+00f, 2.76726484e-02f, -8.34814012e-01f, 9.39593613e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  1.04437709e+00f, 4.24208581e-01f, 9.82238054e-01f, 3.90482634e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  1.13622200e+00f, 9.72065806e-01f, 7.00584054e-01f, -5.06824434e-01f, 1.25889862e+00f, 3.19375783e-01f, -9.70197201e-01f, 7.38515854e-01f, -2.04399776e+00f, -1.88911664e+00f,
  -1.29044497e+00f, -1.49868822e+00f, 3.84994805e-01f, -1.42565823e+00f, -1.16517925e+00f, -1.65619707e+00f, 1.01801002e+00f, 3.51961292e-02f, 6.65996015e-01f, 7.32404113e-01f,
  1.24398601e+00f, 1.03694999e+00f, -4.64640915e-01f, -1.69257963e+00f, 1.52027440e+00f, -1.72043955e+00f, -2.70099461e-01f, 6.04746759e-01f, -2.11730957e+00f, 1.31237000e-01f,
  7.89805532e-01f, -4.09965992e-01f, -1.19428349e+00f, 1.11222863e+00f, 1.31555349e-01f, -1.66291907e-01f, -8.66882317e-03f, 4.10922021e-01f, 8.66357625e-01f, -1.01652253e+00f,
  -9.15263891e-01f, 1.69636655e+00f, -1.37591791e+00f, 2.17345774e-01f, -1.75141084e+00f, -1.77914381e+00f, 2.82658249e-01f, 9.77915347e-01f, -1.35282528e+00f, 1.02396682e-02f,
  -9.60232258e-01f, -1.50740480e+00f, 9.54601634e-03f, 1.29833326e-01f, -3.02347004e-01f, 8.51159990e-01f, -3.52396846e-01f, 8.75433013e-02f, -1.54358909e-01f, 1.71012414e+00f,
  3.87483954e-01f, 9.43454385e-01f, -1.43357134e+00f, -9.00245428e-01f, 8.17364275e-01f, 4.75528508e-01f, 3.41228932e-01f, 1.37641573e+00f, 3.72450501e-01f, -1.73951161e+00f,
  1.39492285e+00f, 3.85935992e-01f, 1.68098152e+00f, -1.19559951e-02f, 7.61610389e-01f, -1.43666208e+00f, 3.39630216e-01f, 7.04470694e-01f, -1.07670546e+00f, -1.42804229e+00f,
  1.19743216e+00f, -4.78685051e-01f, 4.57606822e-01f, 3.51363689e-01f, -3.61668974e-01f, 1.43228996e+00f, 2.41169274e-01f, 1.15498221e+00f, 1.59948564e+00f, 1.45441091e+00f,
  9.55304146e-01f, 6.34843588e-01f, 2.60163784e-01f, -9.16394413e-01f, 4.46589082e-01f, -8.03539813e-01f, -8.94207895e-01f, 2.98726499e-01f, 9.52923298e-02f, -1.28345978e+00f,
  -1.12006652e+00f, -4.01977211e-01f, -7.75131822e-01f, 3.92830700e-01f, 5.17947972e-01f, 5.93024194e-01f, 8.80775690e-01f, -5.58103859e-01f, -1.40628469e+00f, 9.79547143e-01f,
  5.19079089e-01f, 1.93818375e-01f, -1.41859233e+00f, -7.22483337e-01f, -3.64392310e-01f, -1.02724087e+00f, -1.21646643e+00f, 3.19448858e-01f, -5.16840935e-01f, -1.09098613e-01f,
  8.40165973e-01f, 3.94836903e-01f, -8.08850408e-01f, -7.25310385e-01f, 9.03554320e-01f, -1.39482486e+00f, -1.06093502e+00f, -1.32828212e+00f, 6.21556103e-01f, -6.10305607e-01f,
  -1.05739570e+00f, 5.21933973e-01f, -1.48451138e+00f, -1.03772208e-01f, 3.25678855e-01f, -4.72147554e-01f, -1.11527157e+00f, 8.88014436e-01f, -1.04294086e+00f, 7.07652092e-01f,
  -1.32809603e+00f, 6.23360932e-01f, -1.44975626e+00f, 8.46570075e-01f, -1.06539917e+00f, -4.05907631e-01f, -1.60475269e-01f, 1.06215942e+00f, -3.44261944e-01f, -1.58391511e+00f,
  1.44248033e+00f, 8.75984192e-01f, -1.86925578e+00f, -1.35320508e+00f, 1.05920911e+00f, -8.49680781e-01f, -3.68299812e-01f, -1.27451098e+00f, 9.44559455e-01f, -6.78222537e-01f,
  -4.97993175e-03f, -7.67579615e-01f, 5.63091874e-01f, 8.54970753e-01f, 1.47343606e-01f, -1.69911757e-01f, -1.22133040e+00f, -1.61845422e+00f, 1.77687550e+00f, 1.57839283e-01f,
  1.63412583e+00f, 1.11325395e+00f, -1.63127817e-02f, 5.13727307e-01f, -1.80155444e+00f, 4.00634021e-01f, -9.12218615e-02f, 3.77778322e-01f, 3.51387292e-01f, -8.96194935e-01f,
  2.73618430e-01f, 1.64038569e-01f, 1.36029735e-01f, 1.08892369e+00f, -1.57227683e+00f, 1.06898499e+00f, -4.47722912e-01f, 1.18756354e+00f, 4.44054484e-01f, -1.03470266e+00f,
  -1.31276405e+00f, 6.65973186e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  9.64705944e-01f, 2.19205618e-01f, 1.51008248e-01f, -8.74083877e-01f, 2.85110027e-01f, -2.71596134e-01f, -4.94447082e-01f, 2.55924225e-01f, 3.19065750e-01f, 3.28409702e-01f,
  -6.39635146e-01f, -4.12445128e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    