/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  6.59633219e-01f, 9.19377580e-02f, 4.46393639e-01f, 5.32211922e-02f, 1.03360847e-01f, -1.60898522e-01f, -1.63220167e-01f, 9.02308449e-02f, -2.10978985e-01f, -2.07581013e-01f,
  -2.07710534e-01f, -8.40135440e-02f, -4.91871759e-02f, -2.90642917e-01f, -1.37417302e-01f, -2.34538794e-01f, -1.60134360e-01f, -2.24505395e-01f, 9.33639780e-02f, 3.49415652e-02f,
  -8.58028140e-03f, -1.17555402e-01f, 5.44651970e-02f, 4.11129817e-02f, 1.79885536e-01f, 2.67356366e-01f, 1.86134428e-01f, 1.99141443e-01f, 4.19737585e-02f, -1.57837197e-02f,
  -3.90933268e-02f, -1.24448717e-01f, 1.77884903e-02f, 8.13985020e-02f, 2.63893250e-02f, 9.97692868e-02f, 9.11499336e-02f, -3.90777625e-02f, 3.40727121e-02f, -8.40049312e-02f,
  -2.26976871e-02f, -8.11473466e-03f, -1.78861097e-02f, 2.59622056e-02f, 3.06678726e-03f, 8.92820954e-02f, 4.14387062e-02f, 3.09797339e-02f, 6.34535030e-02f, -2.79978290e-02f,
  6.89346492e-02f, -3.67112830e-02f, 1.04952693e-01f, 6.15208112e-02f, 6.07315600e-02f, -7.75061250e-02f, -1.25213014e-02f, -7.40399808e-02f, -1.66248903e-02f, 2.81323884e-02f,
  2.67455950e-02f, 7.67843425e-02f, 4.48059253e-02f, 2.11495198e-02f, -1.14202127e-03f, 8.01913217e-02f, 3.37378271e-02f, -1.85643639e-02f, 6.16956688e-02f, 5.82712218e-02f,
  -4.83759828e-02f, 5.66684455e-02f, -3.32540497e-02f, 1.71648655e-02f, 4.99982163e-02f, -3.13434601e-02f, 1.96651425e-02f, 6.24819808e-02f, 3.76231894e-02f, -5.93315102e-02f,
  -4.70576622e-02f, 1.80538073e-02f, 8.77601281e-03f, 1.58183053e-02f, -3.00758984e-02f, 2.41985247e-02f, -1.50613915e-02f, 5.29246405e-02f, -1.36727421e-02f, 6.29027607e-03f,
  -1.66067183e-01f, 1.40582370e-02f, -1.42691538e-01f, -1.83541067e-02f, -4.13526595e-02f, -3.26780528e-02f, -9.06103477e-02f, 3.72481383e-02f, -8.59365314e-02f, 3.94541537e-03f,
  1.13365263e-01f, -4.52895686e-02f, 8.86093304e-02f, 4.02332135e-02f, -7.12386295e-02f, -4.64805365e-02f, 3.51707935e-02f, -8.28399789e-03f, -1.37337416e-01f, 7.26934103e-03f,
  4.61766981e-02f, 3.55546959e-02f, -1.08334355e-01f, 4.37003896e-02f, -1.72144361e-02f, 1.47720665e-01f, -1.53182424e-04f, 6.73024431e-02f, 2.46556532e-02f, -1.20047731e-02f,
  3.43925446e-01f, -3.88529718e-01f, 2.17616111e-01f, -2.19042808e-01f, 1.16792619e-02f, -2.01224804e-01f, 1.21895701e-01f, -1.27690509e-01f, 1.91520944e-01f, -1.80505648e-01f,
  -6.05384223e-02f, 1.38791412e-01f, 6.69872239e-02f, -1.10892139e-01f, -5.85891567e-02f, -7.23323673e-02f, -3.99209671e-02f, 8.99950713e-02f, 1.29232883e-01f, -1.01826787e-01f,
  -4.03394848e-02f, -1.34538502e-01f, -4.35641110e-02f, -6.96985424e-02f, -1.54271666e-02f, -2.06632912e-03f, -1.68180451e-01f, -1.18072711e-01f, -1.78420335e-01f, 3.31335515e-02f,
  4.09198664e-02f, 3.16269457e-01f, 1.77831590e-01f, 1.43933505e-01f, -1.17703769e-02f, 4.79605980e-02f, -3.56046744e-02f, 9.22511593e-02f, 2.67121550e-02f, 3.47399935e-02f,
  7.02223275e-03f, 1.91294923e-02f, 9.42923650e-02f, 4.08143587e-02f, 8.28243734e-04f, 1.19905852e-01f, -4.01992500e-02f, -4.20388170e-02f, 2.37418599e-02f, -5.40077277e-02f,
  1.17031587e-02f, -1.03694290e-01f, -1.14778623e-01f, 9.26916227e-02f, 6.20422186e-03f, 1.04058370e-01f, -2.09832508e-02f, 4.29710075e-02f, -1.03247181e-01f, 1.28177844e-03f,
  7.33779743e-03f, 7.85065666e-02f, -9.11864564e-02f, 2.77527869e-02f, -2.00135987e-02f, -4.19982634e-02f, -6.53524846e-02f, -8.50400478e-02f, 2.12014373e-02f, -1.29546508e-01f,
  -1.84532583e-01f, -1.21578239e-02f, -4.37804498e-02f, -3.86907719e-02f, -4.27726842e-02f, 1.35944504e-02f, 2.21647769e-02f, 1.53213153e-02f, -3.69925536e-02f, -1.32444445e-02f,
  -3.35236229e-02f, -7.59278983e-02f, -1.05731472e-01f, -1.41388560e-02f, 4.21841815e-03f, 5.58675230e-02f, -1.40363611e-02f, 2.40762569e-02f, -8.30473844e-03f, -3.50178517e-02f,
  8.40886384e-02f, -1.71718467e-02f, 2.23452561e-02f, -4.13407013e-02f, -8.38635955e-03f, -4.15324792e-02f, 5.31035885e-02f, -1.37685075e-01f, -6.13230765e-02f, 3.16418000e-02f,
  3.48309949e-02f, 5.06715477e-02f, -9.02601704e-02f, -4.91523072e-02f, -4.95039150e-02f, -1.82073414e-02f, -8.04073438e-02f, 6.15748726e-02f, -3.30148786e-02f, 1.94684565e-02f,
  -4.93047051e-02f, 4.37386297e-02f, 1.47164449e-01f, 1.04075238e-01f, -4.67442870e-02f, -1.70271806e-02f, -2.39853747e-02f, -6.32249340e-02f, 2.89989915e-02f, -2.19858233e-02f,
  2.32385695e-01f, -6.66651502e-02f, -7.52791688e-02f, 1.31704256e-01f, 4.46108542e-02f, 2.70827711e-01f, 9.51738879e-02f, 7.76266307e-02f, -5.31743541e-02f, -3.72979306e-02f,
  2.09553301e-01f, -9.85143632e-02f, -6.54375181e-02f, 2.19184458e-01f, 1.99718773e-01f, 1.59457438e-02f, 1.52000815e-01f, 4.46776040e-02f, 3.34844925e-02f, -8.44993815e-02f,
  -2.59749480e-02f, 1.03129804e-01f, 1.16803125e-02f, -5.36807738e-02f, 1.14985347e-01f, -4.94175442e-02f, 2.51139496e-02f, -1.08109213e-01f, 1.32353738e-01f, 1.31151110e-01f,
  2.17243180e-01f, -3.11772618e-03f, 1.42946765e-02f, -3.51226404e-02f, 4.98077273e-02f, -1.30419880e-02f, -1.34064304e-02f, 7.11985603e-02f, -5.54106645e-02f, -6.82325475e-03f,
  2.65855007e-02f, -8.13830702e-04f, 6.66517317e-02f, -8.90065357e-02f, -1.79982581e-03f, 9.54909995e-02f, -1.09697308e-03f, 1.03610508e-01f, -8.06020126e-02f, -1.65746850e-03f,
  -4.32669185e-02f, -2.14677732e-02f, -6.63513914e-02f, -1.44656569e-01f, 2.51483675e-02f, 8.35289285e-02f, 9.23502725e-03f, -3.74344029e-02f, 4.87113930e-02f, 7.63249211e-03f,
  -1.73218548e-02f, -6.94058239e-02f, 9.55364257e-02f, -1.38248550e-03f, 5.72756492e-02f, 2.42827809e-03f, -9.48801711e-02f, -1.17179984e-02f, -5.91974631e-02f, -9.74886194e-02f,
  2.81201466e-03f, 6.31900728e-02f, -1.40253222e-02f, -5.23142442e-02f, -1.77192632e-02f, -2.25285646e-02f, 5.88489883e-02f, 8.98172855e-02f, 3.12093757e-02f, 2.89270631e-03f,
  -1.94943741e-01f, -1.30575069e-03f, 2.89542340e-02f, 6.56332970e-02f, 6.41051754e-02f, -8.27362314e-02f, -8.70763734e-02f, 8.10320899e-02f, -4.02732287e-03f, 2.97105424e-02f,
  -2.16578878e-02f, -1.27192199e-01f, -4.94537093e-02f, 3.32471356e-02f, 7.57122552e-03f, 5.14420122e-02f, -4.13767248e-02f, -5.11926301e-02f, -7.14720041e-02f, 1.13597609e-01f,
  5.17194457e-02f, 2.24980097e-02f, -5.10221906e-02f, -2.66208071e-02f, 1.53381005e-01f, -2.86405114e-03f, -6.89537525e-02f, -4.98577431e-02f, -6.61229268e-02f, 2.19608098e-02f,
  2.77241860e-02f, 3.87579538e-02f, -3.45047191e-02f, 1.43489942e-01f, -6.16296791e-02f, -1.31735532e-02f, -1.71345081e-02f, -9.92157962e-03f, -3.07634771e-02f, -1.16134845e-01f,
  2.08010510e-01f, -5.82348146e-02f, 1.15362078e-01f, 1.26907468e-01f, -4.81874533e-02f, 3.23744863e-01f, 2.45216176e-01f, 5.99248987e-03f, 2.23775413e-02f, -2.01945305e-02f,
  -5.43978103e-02f, -2.35207621e-02f, -1.59840658e-01f, 1.51578367e-01f, -4.04977351e-02f, 5.29388078e-02f, 2.88528740e-01f, 1.66259363e-01f, -7.82549381e-02f, 1.32433519e-01f,
  3.27080339e-02f, 2.86800172e-02f, 1.29374400e-01f, -4.48953658e-02f, 1.12094752e-01f, -2.79341359e-02f, -1.60330221e-01f, -7.06330836e-02f, 3.23632509e-02f, -3.99800278e-02f,
  1.06277049e-01f, 2.06781253e-01f, -2.28032861e-02f, 6.79837093e-02f, 7.64950067e-02f, -5.66800945e-02f, 2.03914698e-02f, -6.80140108e-02f, 6.67062923e-02f, -3.42676528e-02f,
  -4.38462384e-02f, -7.47560635e-02f, 5.03901988e-02f, -5.85611425e-02f, -5.45130335e-02f, 1.46639748e-02f, -9.60602388e-02f, -3.87675390e-02f, -2.26714760e-02f, -5.95796481e-02f,
  4.05404791e-02f, 2.06721853e-02f, 7.36081675e-02f, 5.15079722e-02f, 5.31802401e-02f, 1.06591920e-04f, 1.00369267e-01f, -3.28883566e-02f, -7.83275347e-03f, 1.25214800e-01f,
  1.36202537e-02f, -1.22984853e-02f, -4.14377116e-02f, -2.13998556e-02f, -9.38312733e-04f, -4.21965122e-02f, 1.53901789e-03f, -7.36607704e-03f, -3.40476036e-02f, -2.34419312e-02f,
  2.89926659e-02f, -3.14841904e-02f, -2.43050959e-02f, 8.14850554e-02f, -2.25324426e-02f, 1.26274109e-01f, -6.01075264e-03f, -8.18372071e-02f, 3.74118537e-02f, 4.36782166e-02f,
  5.96171012e-03f, 6.07163906e-02f, -4.32113484e-02f, -2.74893437e-02f, 6.03916794e-02f, 3.99605408e-02f, -7.89963156e-02f, -6.82950318e-02f, 4.06243019e-02f, -1.68266352e-02f,
  1.77218951e-02f, 7.85020739e-02f, -4.42340858e-02f, -4.12406921e-02f, -4.39865468e-03f, 3.59223709e-02f, -1.38481399e-02f, 9.01802815e-03f, 5.62666990e-02f, 9.64889675e-02f,
  3.33594643e-02f, 1.92969460e-02f, -6.37060106e-02f, 4.38735448e-02f, -3.30453105e-02f, -1.39412526e-02f, 3.31727006e-02f, 7.27729723e-02f, 1.26677707e-01f, -6.20983057e-02f,
  -1.09795012e-01f, -2.73644645e-03f, -5.41969016e-02f, 9.49780047e-02f, 9.89905745e-03f, -1.17744571e-02f, 1.87129881e-02f, 9.13369376e-03f, 1.88797992e-02f, -1.85699959e-03f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.35027421e+00f, 5.40068420e-03f, 2.21147880e-01f, -1.91043243e-01f, -7.59742856e-02f, 2.28231803e-01f, 1.78411588e-01f, 1.01695411e-01f, 5.66871092e-02f, 3.32792580e-01f,
  7.05875829e-02f, 5.40534146e-02f, 8.79496038e-02f, 2.54529059e-01f, -4.19585556e-02f, 1.69140682e-01f, -1.27969654e-02f, -6.80145575e-03f, -4.30232324e-02f, -1.90031052e-01f,
  -1.35924399e-01f, -6.01185719e-03f, 1.85006648e-01f, -6.45629317e-02f, -1.15406431e-01f, -1.60699144e-01f, -1.28337205e-03f, -5.59941158e-02f, 7.56171569e-02f, 4.82205525e-02f,
  -1.09345503e-01f, -1.34448797e-01f, 6.22441918e-02f, 4.68503609e-02f, -2.31388509e-02f, -3.60593982e-02f, 5.77430688e-02f, 1.17018484e-01f, -2.74480972e-03f, -1.68883055e-02f,
  -7.38813058e-02f, -7.50415325e-02f, -1.90095580e-03f, 9.73136630e-03f, -1.07133582e-01f, 6.16038628e-02f, 1.09489657e-01f, 7.97545016e-02f, 8.66406038e-02f, 1.62967011e-01f,
  9.19825435e-02f, -9.18447152e-02f, -3.61068994e-02f, 2.63724048e-02f, 4.91290763e-02f, -5.79204001e-02f, 8.21364224e-02f, -3.55097987e-02f, -4.10984196e-02f, 3.87961464e-03f,
  -1.10711575e-01f, 1.55941155e-02f, 7.47854039e-02f, 7.60504454e-02f, -5.42233847e-02f, 1.00118946e-03f, 3.39727825e-03f, 3.73810790e-02f, -4.78191860e-02f, -9.60394740e-02f,
  1.96814556e-02f, 2.29227208e-02f, 2.09617149e-02f, 2.75989566e-02f, -2.89059300e-02f, -7.66472518e-02f, -1.54557794e-01f, -4.66885120e-02f, -2.88225850e-03f, -3.93046699e-02f,
  3.31023522e-02f, -6.26184717e-02f, 3.54757831e-02f, -4.25360799e-02f, -5.88310435e-02f, 5.30252010e-02f, 2.27771122e-02f, -3.19348611e-02f, 4.71493695e-03f, -5.94638400e-02f,
  -5.05014598e-01f, -2.72053182e-01f, -2.73726936e-02f, -2.55135335e-02f, -7.07000121e-02f, -3.82327568e-03f, -6.42379895e-02f, 1.24290597e-03f, -4.85755838e-02f, 5.26304394e-02f,
  2.82736979e-02f, 1.21142305e-02f, -2.84793247e-02f, 1.42605742e-02f, -1.86581481e-02f, 1.81578860e-01f, -1.10000350e-01f, -1.08159237e-01f, -8.37126076e-02f, -1.05037130e-01f,
  -1.03717580e-01f, -5.35200089e-02f, -1.94610376e-02f, 1.16528399e-01f, 1.23256696e-02f, -3.90117541e-02f, -2.35824540e-01f, 2.83543915e-02f, 6.51843473e-02f, -2.09637079e-03f,
  -9.07114744e-01f, -7.96945989e-02f, 2.82580554e-01f, -5.51598847e-01f, -2.46561751e-01f, -9.09143463e-02f, 3.39180321e-01f, -4.63854820e-01f, -3.09061497e-01f, -8.49123076e-02f,
  -9.92971286e-02f, -2.37694979e-02f, 5.20706892e-01f, -2.32841685e-01f, 7.27931201e-01f, 5.38806260e-01f, 1.60011217e-01f, 9.53888986e-03f, -1.95133537e-02f, -2.52989709e-01f,
  -1.15706012e-01f, -4.52882886e-01f, 3.01967323e-01f, -6.50509059e-01f, -2.48652875e-01f, -2.22342148e-01f, -2.10560691e-02f, 1.43674120e-01f, -3.68328601e-01f, 1.51652887e-01f,
  -1.37140080e-01f, -2.22982675e-01f, -1.98579535e-01f, -4.02632020e-02f, -8.22074339e-02f, 1.60584599e-02f, 8.32095295e-02f, 1.94442943e-01f, -3.92575115e-02f, 5.63979633e-02f,
  5.00185005e-02f, -5.81495874e-02f, -7.06693903e-02f, -3.06238662e-02f, -7.00375363e-02f, -1.03299744e-01f, -2.30799317e-02f, -1.14699453e-02f, -6.92330524e-02f, 1.78240195e-01f,
  7.84605742e-02f, -3.09747122e-02f, -4.20576446e-02f, -3.81946824e-02f, 9.68367830e-02f, -5.17388023e-02f, 7.95763731e-02f, 1.96956530e-01f, -6.80928156e-02f, -1.22749485e-01f,
  7.23097473e-02f, 1.05943404e-01f, 9.78405625e-02f, -2.05323622e-01f, -5.65415770e-02f, -1.05170608e-01f, -1.04240760e-01f, 3.71358506e-02f, -6.61396459e-02f, -7.26356804e-02f,
  -1.82124361e-01f, -1.20357135e-02f, -3.45356800e-02f, -3.68970595e-02f, 7.86853582e-02f, -2.17609014e-02f, 1.04980245e-02f, -1.19982302e-01f, 2.43246742e-02f, -8.91153440e-02f,
  -5.84430769e-02f, 1.42299738e-02f, 5.74714458e-03f, 6.60114437e-02f, 1.00183273e-02f, 4.87577096e-02f, -6.24781176e-02f, -5.97599754e-03f, 7.05344304e-02f, 1.00559801e-01f,
  -2.64995754e-01f, -2.04609960e-01f, -9.24934521e-02f, -1.82423323e-01f, -1.00226127e-01f, 3.19465622e-03f, 1.47119775e-01f, -1.62833240e-02f, -4.23573218e-02f, 2.11177126e-01f,
  -1.26451418e-01f, -3.59263681e-02f, 9.65316817e-02f, 4.29121293e-02f, 1.57169908e-01f, -1.30655572e-01f, -1.66023355e-02f, -4.19075936e-02f, -1.24368906e-01f, -1.07854791e-02f,
  -8.77394453e-02f, 4.60894704e-02f, 3.57731991e-02f, -3.65978256e-02f, -1.02023877e-01f, -1.63287014e-01f, -9.20994207e-02f, -2.85278242e-02f, 1.12812236e-01f, 9.58445817e-02f,
  4.47773308e-01f, 6.22816086e-01f, 4.20344383e-01f, 6.68846786e-01f, -2.19990388e-01f, 1.75721813e-02f, 1.34938702e-01f, 2.78392434e-02f, 2.27756500e-01f, 2.01484442e-01f,
  -3.20531726e-01f, 3.92415494e-01f, -1.45195097e-01f, 3.45480412e-01f, -2.03540027e-01f, 2.84491573e-02f, 5.41527390e-01f, 2.93224633e-01f, -7.58777559e-03f, 9.48057175e-02f,
  7.00922087e-02f, -9.05875489e-02f, 3.01819257e-02f, -3.01957935e-01f, 1.59133062e-01f, 9.69118066e-03f, -3.77339482e-01f, -3.42898190e-01f, 6.53163716e-02f, -1.13200225e-01f,
  -1.41315565e-01f, 1.50725633e-01f, 1.96367994e-01f, 3.74831446e-02f, -5.03764786e-02f, 6.63006771e-03f, 1.71084940e-01f, -4.77955602e-02f, -1.04232639e-01f, -1.14372512e-02f,
  6.98877573e-02f, 4.87311631e-02f, 8.20458382e-02f, 3.06273531e-02f, 2.01247614e-02f, -1.19608128e-03f, 3.82301994e-02f, 1.56844229e-01f, 3.14154141e-02f, 3.02350223e-02f,
  1.52286177e-03f, 2.82448493e-02f, 8.82735401e-02f, -6.33502379e-02f, -2.51465617e-03f, 9.09779668e-02f, 1.14356369e-01f, -1.20596774e-02f, 3.82196694e-03f, 8.26435164e-03f,
  3.74613963e-02f, 7.06078485e-02f, 2.53467727e-02f, -1.16634637e-01f, 5.30509427e-02f, -1.34090632e-01f, 7.67628923e-02f, -7.41569251e-02f, -3.71058024e-02f, -6.06008805e-02f,
  -1.07348049e-02f, -1.06922099e-02f, -7.76079595e-02f, 3.51752378e-02f, 9.29030105e-02f, -4.18160036e-02f, -1.65139690e-01f, 2.15873905e-02f, 5.33694960e-02f, -2.16001458e-02f,
  1.63203459e-02f, 2.95176785e-02f, -3.12006287e-02f, -2.36922763e-02f, -5.18720038e-02f, -6.23720735e-02f, 4.92524132e-02f, 2.26437151e-02f, -4.22028899e-02f, -1.35398312e-02f,
  1.59909070e-01f, 1.47000760e-01f, -3.98519449e-02f, -7.36275390e-02f, -2.54902951e-02f, -1.67825129e-02f, 1.73419844e-02f, 1.56208009e-01f, 9.29092541e-02f, 4.03578356e-02f,
  4.08153869e-02f, -4.59927972e-03f, 2.16263328e-02f, -7.59054907e-03f, -1.67231113e-02f, -6.17689714e-02f, 1.03962542e-02f, -5.60023896e-02f, 9.29492805e-03f, -5.30182645e-02f,
  -3.76587547e-03f, -4.35187668e-02f, 1.57394577e-02f, 3.61453071e-02f, 8.16249996e-02f, -9.70409438e-02f, -1.04079284e-01f, 9.18965414e-03f, 1.63710658e-02f, 1.03654124e-01f,
  2.12151825e-01f, 1.18125461e-01f, -1.68076143e-01f, 4.68512505e-01f, -2.76625544e-01f, -5.60151488e-02f, -3.03643078e-01f, 1.40504181e-01f, -3.38505000e-01f, -3.02557573e-02f,
  3.06113750e-01f, -1.05768837e-01f, 5.43060713e-02f, 6.53333068e-01f, 3.32026154e-01f, 1.48838267e-01f, 5.09036958e-01f, 2.30036303e-01f, -4.28336533e-03f, 3.51725876e-01f,
  1.89801469e-01f, 6.97240472e-01f, 3.07920605e-01f, 3.21095943e-01f, 3.02608371e-01f, 1.69389620e-01f, 2.87391692e-01f, -5.57210781e-02f, 2.02632293e-01f, 1.54534191e-01f,
  1.33445397e-01f, 9.86478925e-02f, -1.85576850e-03f, -5.07129543e-02f, 3.22135724e-02f, 1.37357324e-01f, 4.90700938e-02f, 1.37672406e-02f, -1.20701186e-01f, -2.63479427e-02f,
  -6.43330887e-02f, 2.02273242e-02f, -5.78247346e-02f, -2.75547411e-02f, 7.51916412e-03f, -1.35934465e-02f, -1.10646866e-01f, -5.44920266e-02f, -2.16820404e-01f, 4.46228720e-02f,
  -1.31192759e-01f, 4.05587591e-02f, 8.46693516e-02f, 7.34666511e-02f, -8.31765309e-02f, -1.92487463e-02f, -6.61037117e-03f, -5.91260120e-02f, -1.45117551e-01f, 7.01996014e-02f,
  1.06687322e-01f, 6.73657376e-03f, -2.58237440e-02f, -6.64799707e-03f, -7.48623013e-02f, -1.46937981e-01f, 6.81718960e-02f, -3.55875492e-02f, -5.69133740e-03f, 1.33715477e-02f,
  -1.14849441e-01f, -4.59783711e-02f, -7.38987848e-02f, -3.00153997e-03f, 2.28214804e-02f, -8.93126726e-02f, -2.59496272e-02f, 7.02915043e-02f, -1.59059390e-01f, -1.13816589e-01f,
  6.48571029e-02f, 7.08327442e-02f, -2.91573871e-02f, 1.37278572e-01f, 8.73542503e-02f, -3.77082303e-02f, 7.56243318e-02f, -4.44281921e-02f, -6.04525767e-02f, 4.69741002e-02f,
  -1.90147292e-02f, 9.61641893e-02f, -1.23834357e-01f, -2.30220035e-02f, -2.12929212e-02f, -2.59508733e-02f, 1.76643774e-01f, -3.70756015e-02f, 1.07495837e-01f, 7.04383925e-02f,
  4.25234847e-02f, -3.89402285e-02f, 6.61327839e-02f, 3.63173545e-03f, 4.26291414e-02f, -2.37148758e-02f, 1.16741933e-01f, -4.24656086e-02f, 6.70032203e-02f, -6.40740469e-02f,
  5.82352728e-02f, -1.19818553e-01f, 1.40510015e-02f, -8.55713785e-02f, 1.22397535e-01f, 2.91014239e-02f, -4.26989421e-02f, -1.17414566e-02f, 1.42232433e-01f, 1.28168399e-02f,
  -2.09708035e-01f, -2.93956310e-01f, 3.84956270e-01f, 3.24775763e-02f, 1.80957720e-01f, 3.02622080e-01f, 2.14400351e-01f, 2.56011579e-02f, -3.18847835e-01f, -6.95838034e-01f,
  -1.92098588e-01f, -2.37177655e-01f, -2.48755008e-01f, -1.08622409e-01f, 5.59223592e-01f, -1.98389709e-01f, 4.72793654e-02f, -2.20441908e-01f, -9.93442163e-02f, -1.45495012e-01f,
  6.67815730e-02f, 5.01325987e-02f, 1.75511688e-01f, 2.55388431e-02f, 7.90760890e-02f, -3.31618711e-02f, -1.21029082e-03f, 1.52737945e-01f, 8.18948224e-02f, 2.84695774e-01f,
  3.13816726e-01f, -3.49293679e-01f, 7.66852647e-02f, 2.81818006e-02f, -8.48833099e-02f, 5.67674674e-02f, 3.23829874e-02f, 1.08636864e-01f, 3.97645645e-02f, 1.08948518e-02f,
  1.67375728e-01f, 1.64214000e-01f, -8.44601169e-02f, 1.30539179e-01f, -1.03326678e-01f, 1.74175501e-02f, -4.96809185e-02f, 5.63019700e-02f, 1.04767919e-01f, -1.03552364e-01f,
  -4.01354171e-02f, 8.71419907e-02f, 4.56560496e-03f, -9.85168219e-02f, -1.15523830e-01f, 5.98972850e-02f, 1.50062880e-02f, 4.43039387e-02f, 2.05634534e-02f, 1.16671361e-01f,
  -7.65472203e-02f, 4.32878360e-03f, -1.57439500e-01f, -1.11993171e-01f, 2.18496528e-02f, -7.53418282e-02f, -3.69693488e-02f, -8.84021819e-03f, -7.79030547e-02f, 6.62402958e-02f,
  -7.97501020e-03f, -1.79592296e-01f, -1.30619839e-01f, -5.65118752e-02f, -1.21295147e-01f, -1.24070540e-01f, 2.26505403e-03f, 1.91419795e-02f, -8.91516078e-03f, -7.94710442e-02f,
  -1.29217599e-02f, -3.73655111e-02f, -1.93713382e-01f, 2.81456169e-02f, 6.79891184e-02f, 2.81753810e-03f, 8.85291100e-02f, 1.41915670e-02f, -1.04132444e-01f, -1.86432116e-02f,
  -1.41284138e-01f, -5.11277974e-01f, -1.04055591e-01f, 8.78859684e-02f, 9.54889620e-05f, -5.62409051e-02f, 1.81027260e-02f, 1.24659784e-01f, -2.52021570e-03f, -2.15649158e-01f,
  -9.80395824e-03f, 4.80283350e-02f, 1.08872773e-02f, -4.06220481e-02f, 7.45524913e-02f, 2.36814097e-02f, -8.80435929e-02f, 3.08944285e-02f, 1.09117851e-01f, 4.21596840e-02f,
  6.23957105e-02f, -1.55681044e-01f, -2.51868181e-02f, -1.40679598e-01f, -3.76687050e-02f, 2.60206796e-02f, -1.84799343e-01f, -3.69670577e-02f, 8.54779594e-03f, -6.56789318e-02f,
  -9.66947794e-01f, 1.08128026e-01f, 1.40198931e-01f, 1.59021821e-02f, -3.37663829e-01f, 1.22413456e-01f, 2.52165675e-01f, -1.85628548e-01f, -2.27073088e-01f, 9.87785086e-02f,
  -1.73609942e-01f, -1.65033415e-01f, 2.20009051e-02f, 2.03671873e-01f, 1.01503819e-01f, 3.00572664e-01f, 1.87131569e-01f, 1.10230066e-01f, 3.69734876e-02f, -9.50864479e-02f,
  -3.72681916e-02f, -3.35542560e-02f, 3.45576942e-01f, 2.65201982e-02f, 7.19503239e-02f, -1.18024006e-01f, 1.78198218e-01f, -1.11499272e-01f, 3.79290283e-02f, -1.34637862e-01f,
  1.25655115e-01f, -3.58768463e-01f, 1.08995281e-01f, -9.55487788e-02f, -7.19525144e-02f, -1.31101280e-01f, 1.83666090e-03f, -7.20695704e-02f, 2.08593477e-02f, -1.23450257e-01f,
  -4.61323224e-02f, 2.16989163e-02f, -2.73327231e-02f, 6.68111369e-02f, 7.87739456e-02f, -1.82888713e-02f, 1.46200180e-01f, 8.35029781e-02f, 1.35932460e-01f, 5.69292083e-02f,
  6.22106902e-02f, 1.53369471e-01f, 1.66188762e-01f, 6.58208430e-02f, 6.67246357e-02f, 6.42942041e-02f, 1.22150168e-01f, -6.05878755e-02f, 6.12864122e-02f, 4.63763112e-03f,
  -1.32282048e-01f, 2.82100700e-02f, -6.63316622e-02f, -1.24289840e-02f, -1.18017793e-02f, 9.47640911e-02f, 6.57176450e-02f, -4.62011509e-02f, -1.42738065e-02f, -3.31653282e-02f,
  4.99652959e-02f, -1.75180938e-02f, 4.52579707e-02f, 2.46150363e-02f, 1.19555406e-01f, 1.38484165e-01f, 2.20526271e-02f, 7.69719062e-03f, 7.28392527e-02f, 5.65522909e-03f,
  9.85302404e-03f, 3.68267298e-02f, -1.73311576e-01f, 5.68393385e-03f, 4.41822736e-03f, -9.27280486e-02f, -7.99809545e-02f, 7.32422322e-02f, 1.87624432e-02f, 1.55274216e-02f,
  -9.04612541e-02f, -2.77496457e-01f, 1.41626015e-01f, 1.66770872e-02f, 9.14704949e-02f, -1.35534659e-01f, 5.77799492e-02f, -1.20893583e-01f, -1.11523435e-01f, -1.60064641e-03f,
  1.93468574e-02f, 1.30616426e-01f, -9.81012136e-02f, 2.92481184e-02f, 6.08248860e-02f, -7.43672848e-02f, -1.33694917e-01f, -1.03687003e-01f, -2.20604539e-02f, 2.25500837e-02f,
  1.11439630e-01f, -7.27263317e-02f, 4.78352159e-02f, -7.98532367e-02f, -1.79279204e-02f, 1.24386482e-01f, -2.00141165e-02f, -5.19540161e-02f, -9.69938710e-02f, 6.47944678e-03f,
  4.11464959e-01f, -7.43354023e-01f, 3.15508284e-02f, 3.81197691e-01f, 4.22404706e-01f, -1.40655085e-01f, 3.75000387e-01f, -1.98125586e-01f, 9.84475985e-02f, -4.52429116e-01f,
  3.79367769e-02f, 1.33684114e-01f, -2.80467808e-01f, -2.85675470e-02f, 4.29122120e-01f, -1.14412233e-01f, -2.64719054e-02f, 8.91785920e-02f, -3.12641896e-02f, -6.61793947e-02f,
  2.34535083e-01f, 1.44326210e-01f, 6.14940487e-02f, -2.69509226e-01f, 6.67560548e-02f, 1.29544251e-02f, 1.88901320e-01f, -1.15004197e-01f, 4.69320789e-02f, 1.32847562e-01f,
  -4.47789989e-02f, 8.44936259e-03f, 7.98751116e-02f, -1.53686091e-01f, -1.22497283e-01f, -1.16914539e-02f, -6.72130436e-02f, 1.03509910e-01f, 6.58449680e-02f, -7.58555625e-03f,
  -7.98112750e-02f, -9.01201516e-02f, 4.51065674e-02f, 8.77442881e-02f, 3.74584720e-02f, -2.41110120e-02f, 1.31472126e-01f, -5.71628585e-02f, -1.36695713e-01f, -3.67614403e-02f,
  -6.07478283e-02f, -3.10577322e-02f, 7.16812834e-02f, -7.87029490e-02f, 1.08173519e-01f, -3.70854884e-02f, 1.02661319e-01f, 2.33326890e-02f, -9.23758745e-02f, -7.37228338e-03f,
  7.19544515e-02f, 1.22861259e-01f, 6.63712546e-02f, -3.86997238e-02f, -5.72064854e-02f, 1.34713084e-01f, 5.32319658e-02f, 7.11051002e-02f, -1.30597660e-02f, -7.14911595e-02f,
  2.49763224e-02f, 5.16196899e-02f, -4.65397201e-02f, 1.25083163e-01f, 3.07847764e-02f, -2.98243109e-02f, -1.74104333e-01f, -2.39694472e-02f, 3.35490815e-02f, -3.29825468e-02f,
  7.12225139e-02f, 4.66971584e-02f, -1.15987860e-01f, -9.24768746e-02f, -4.52591442e-02f, 5.18938266e-02f, -7.13716447e-02f, -8.97533223e-02f, 6.55587646e-04f, -4.90158983e-03f,
  -8.34978044e-01f, -6.15397632e-01f, -4.23227996e-02f, -2.28154324e-02f, -1.55770957e-01f, -1.06960006e-01f, -1.18199438e-02f, 1.45554096e-02f, -8.86922330e-02f, 2.49173529e-02f,
  -9.10977796e-02f, 5.34931198e-03f, 1.77019730e-03f, -3.43851373e-02f, 3.95927625e-03f, -3.44442986e-02f, -5.45237064e-02f, -9.14208964e-02f, 9.36271250e-03f, 2.86376085e-02f,
  -4.41633686e-02f, -1.71122216e-02f, 5.67971282e-02f, 1.08845070e-01f, 1.31688341e-01f, 5.19580841e-02f, 5.08360267e-02f, -7.05247670e-02f, 2.15832274e-02f, 1.44389436e-01f,
  -2.02468410e-01f, -2.82030344e-01f, 2.75974900e-01f, 2.17300400e-01f, -4.90949601e-02f, -3.20096552e-01f, -3.95920455e-01f, 1.54132009e-01f, -6.56915963e-01f, -1.25001132e-01f,
  -1.03831284e-01f, 2.07759410e-01f, -5.76769769e-01f, -3.03666860e-01f, -1.36013418e-01f, -6.25532627e-01f, 9.21341684e-03f, 1.56778112e-01f, -1.88103884e-01f, 5.74409701e-02f,
  7.77380690e-02f, -8.39868113e-02f, 5.92103124e-01f, 2.76442856e-01f, 1.56761512e-01f, 5.89556932e-01f, 6.10653460e-01f, 1.84984118e-01f, 5.33485234e-01f, -6.57637790e-03f,
  -2.61163384e-01f, -2.29237214e-01f, 7.69694448e-02f, 9.66103468e-03f, 2.37279788e-01f, 2.26023585e-01f, 1.50084540e-01f, -7.90244713e-02f, 1.52398780e-01f, 1.83907598e-02f,
  8.80719125e-02f, 1.25272421e-03f, -8.06061253e-02f, -1.22262919e-02f, 6.24940544e-02f, -2.77618729e-02f, 7.31774718e-02f, 2.06958815e-01f, 7.86173567e-02f, 1.70073435e-01f,
  1.20601699e-01f, -3.00890412e-02f, 1.24870986e-01f, 7.38022923e-02f, 4.55343723e-02f, 2.94519253e-02f, -7.23401606e-02f, 2.45188043e-01f, 1.77824274e-01f, -3.22418511e-02f,
  -6.90054819e-02f, -7.09845573e-02f, -9.08288434e-02f, -1.74899653e-01f, -4.26255688e-02f, -1.91512242e-01f, -8.60712528e-02f, 3.53414044e-02f, -1.51897185e-02f, -3.53454612e-02f,
  -1.19827548e-02f, 1.07947811e-01f, -1.79055288e-01f, 9.17829424e-02f, 1.60068527e-01f, 8.15407094e-03f, 1.56959251e-01f, 7.05837533e-02f, 1.81239605e-01f, 3.14252228e-02f,
  -1.57599062e-01f, 1.87252164e-02f, -1.32789686e-02f, -6.81985840e-02f, -7.46527240e-02f, 2.15754807e-02f, -2.65865978e-02f, -1.65608466e-01f, 5.18361218e-02f, -5.60654178e-02f,
  7.05576837e-02f, 1.70910075e-01f, 1.76868632e-01f, 2.35549249e-02f, -1.91488519e-01f, 1.82036217e-02f, -1.19949944e-01f, 9.08835456e-02f, 1.99281983e-02f, -1.66397408e-01f,
  1.98605999e-01f, 1.79416776e-01f, -6.42262623e-02f, -1.30215824e-01f, 7.25717619e-02f, -4.42939661e-02f, 1.14205265e-02f, 1.02642745e-01f, 2.26501316e-01f, 2.27763578e-01f,
  2.96855695e-04f, -6.61073579e-03f, -1.85047183e-02f, -7.00032860e-02f, -1.65290665e-02f, -2.92928033e-02f, 1.15741529e-01f, 4.22224663e-02f, 2.12288667e-02f, -8.62768888e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  1.26052752e-01f, 2.80420125e-01f, 2.04306975e-01f, 6.10229522e-02f, 2.06430197e-01f, -2.04910323e-01f, 1.40571192e-01f, 4.64348942e-01f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -2.20251963e-01f, 1.57610863e-01f, 1.74112186e-01f, 3.72843534e-01f, -5.54403290e-02f, -6.66853905e-01f, -3.57215315e-01f, -8.83362219e-02f, 5.02294719e-01f, -1.41460091e-01f,
  3.65830153e-01f, 2.92294145e-01f, -2.81909723e-02f, 2.16517910e-01f, -6.85884655e-01f, -9.20658410e-02f, 2.54120618e-01f, 1.64683592e-02f, -7.25357533e-02f, 5.41246355e-01f,
  -3.91759157e-01f, -5.04131019e-01f, 5.40086687e-01f, 6.28778636e-01f, 1.74829885e-01f, 1.54758900e-01f, -1.89168360e-02f, 3.89226496e-01f, 2.81230628e-01f, 1.44881949e-01f,
  1.07058540e-01f, -2.46554632e-02f, -3.52000356e-01f, -7.54359961e-02f, -1.77626655e-01f, -1.05384495e-02f, -1.80997942e-02f, -7.77416006e-02f, 7.81278610e-01f, 5.84702194e-01f,
  1.28010288e-01f, -3.37773979e-01f, -3.27924550e-01f, -3.14616472e-01f, 2.48814061e-01f, -8.98399204e-02f, 5.42323112e-01f, -2.22865000e-01f, 1.42329070e-03f, 4.30830210e-01f,
  1.28213495e-01f, 1.65040120e-01f, -3.51366177e-02f, 1.30242050e-01f, -5.47929220e-02f, 3.13974947e-01f, -2.89745539e-01f, -9.56600755e-02f, 4.14368540e-01f, -6.42945945e-01f,
  -4.13624896e-03f, -3.26018035e-01f, 1.76852159e-02f, -5.11179306e-02f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -3.16200405e-01f, 2.84602851e-01f, 2.50306576e-01f, 7.03890979e-01f, 4.08222497e-01f, -9.70970169e-02f, 2.42244765e-01f, -4.02679481e-03f, -1.75927967e-01f, -7.41394341e-01f,
  6.37130320e-01f, 3.79152566e-01f, 3.00473660e-01f, -4.61239457e-01f, 3.68198007e-01f, 5.10607481e-01f, 3.97155523e-01f, 1.06896140e-01f, 2.14820147e-01f, 5.52341640e-01f,
  6.84897780e-01f, -1.51926652e-01f, -6.57578647e-01f, -7.87268877e-01f, -3.28851283e-01f, -3.22288364e-01f, 1.78240359e-01f, 7.51143917e-02f, -7.69042969e-02f, 1.62435785e-01f,
  -3.85981202e-01f, 9.15339530e-01f, -1.40109167e-01f, -2.29980856e-01f, -1.64767951e-01f, 1.34949178e-01f, -8.30570385e-02f, -1.62786648e-01f, 3.97414595e-01f, 1.71943262e-01f,
  2.58746684e-01f, 1.19322583e-01f, -1.32890865e-01f, 6.22458935e-01f, 5.51048338e-01f, 3.02657276e-01f, 2.43556947e-01f, 9.27127451e-02f, -2.90775239e-01f, 1.33316919e-01f,
  1.03671819e-01f, 6.96003675e-01f, 6.03364594e-02f, -1.25748381e-01f, 1.34260371e-01f, 3.01505417e-01f, 8.24945047e-02f, -2.52851136e-02f, 3.18474174e-01f, 3.96788627e-01f,
  3.38340610e-01f, 3.62906605e-01f, 2.40560308e-01f, 3.70909184e-01f, 9.89060521e-01f, -1.71366170e-01f, 9.27496850e-02f, -1.89769100e-02f, 7.63061941e-02f, 2.14782760e-01f,
  -3.40340912e-01f, -6.45168245e-01f, 2.57225633e-01f, 4.50409025e-01f, -8.71831059e-01f, 6.75161034e-02f, 6.89627349e-01f, 1.60291538e-01f, 6.47659540e-01f, 2.83775926e-01f,
  6.26236558e-01f, 2.51592755e-01f, 4.79135811e-01f, 1.35472149e-01f, -3.53110164e-01f, 6.05452836e-01f, -4.50831026e-01f, -2.41336733e-01f, 5.41712493e-02f, 6.56686604e-01f,
  2.46934488e-01f, -4.23590422e-01f, 2.66033888e-01f, -8.66290107e-02f, 5.29288948e-01f, 2.38462552e-01f, -1.88965455e-01f, 5.44389524e-02f, 5.11343658e-01f, 3.44797492e-01f,
  -5.35340369e-01f, -4.22748446e-01f, -2.76712924e-01f, 2.83880569e-02f, 8.69973779e-01f, 4.87124950e-01f, -1.27413288e-01f, -3.55643816e-02f, 3.54380697e-01f, 7.35069454e-01f,
  -4.05996740e-01f, -3.29071194e-01f, -5.81484318e-01f, -5.82506619e-02f, 1.91244900e-01f, 8.72927979e-02f, -8.33805352e-02f, -1.96913779e-02f, 9.93089452e-02f, 5.92562318e-01f,
  1.16070852e-01f, 1.36917889e-01f, 1.03099179e+00f, 4.06984746e-01f, 2.91206479e-01f, 1.11059159e-01f, 1.60837799e-01f, -1.41708896e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  -1.60499215e-01f, 1.77300021e-01f, -1.19623542e-01f, 2.73964733e-01f, 5.53890049e-01f, 4.74958956e-01f, 9.92241129e-02f, 3.32079440e-01f
};

// L2_fan_Wp (Shape: 4 x 16)
const int L2_fan_Wp_rows = 4;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -2.50082403e-01f, -1.57824263e-01f, 2.15614602e-01f, -1.59101889e-01f, -1.33590102e-01f, -9.02700871e-02f, 8.60884339e-02f, -7.33824745e-02f, -2.61912256e-01f, -6.05538845e-01f,
  3.07180941e-01f, 2.26895824e-01f, 4.59120899e-01f, 9.70276222e-02f, -1.67594954e-01f, 6.83891699e-02f, -3.59038621e-01f, -3.54079008e-02f, 5.49402386e-02f, -5.39729774e-01f,
  -1.20263469e+00f, -3.28359365e-01f, 2.04294041e-01f, -8.92084837e-02f, -1.72625065e-01f, -1.76368594e-01f, 3.87843549e-02f, -9.84599814e-02f, 5.58258668e-02f, 3.05203676e-01f,
  -2.34854445e-01f, -8.59401524e-02f, 5.96366107e-01f, 8.24427381e-02f, 4.34150219e-01f, -5.23592174e-01f, 3.89984787e-01f, -2.53434870e-02f, -5.81405044e-01f, 1.60938233e-01f,
  -1.91034704e-01f, 1.86198458e-01f, 2.66306326e-02f, 1.38284460e-01f, -5.26955664e-01f, 5.31634837e-02f, 3.25835615e-01f, 1.50696740e-01f, 8.03843141e-02f, 2.08981022e-01f,
  -1.94353431e-01f, -2.24345073e-01f, 9.89780724e-02f, -2.19509050e-01f, 3.12716663e-01f, 1.25810876e-01f, 4.01624441e-01f, -1.61891043e-01f, 7.28923678e-02f, 1.45563394e-01f,
  -2.31756255e-01f, -2.62490392e-01f, -3.56034726e-01f, 1.91146091e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 16)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  4.95394200e-01f, -1.54890046e-01f, 6.26575828e-01f, -5.08930255e-03f, 3.13685507e-01f, 9.10906196e-01f, -9.39596415e-01f, 4.79980975e-01f, -5.50828040e-01f, -4.29060578e-01f,
  2.98382640e-01f, 1.43185630e-01f, 7.81923681e-02f, 6.91060603e-01f, 8.54554474e-01f, 4.75517452e-01f, -1.80747315e-01f, 1.77489728e-01f, 5.82787037e-01f, 4.28381711e-01f,
  -1.07724035e+00f, -3.26813132e-01f, 2.89648622e-01f, -7.94841826e-01f, -3.12138468e-01f, 2.23793853e-02f, 2.75590479e-01f, -2.39650503e-01f, 8.32177460e-01f, 5.05761683e-01f,
  -4.72264364e-02f, -1.82288177e-02f, 1.45151317e-01f, -3.91236514e-01f, 1.32616147e-01f, 1.28194883e-01f, 3.99477035e-01f, 1.84270650e-01f, -9.25102085e-02f, -1.52397051e-01f,
  9.52359021e-01f, 8.82541418e-01f, 6.45302951e-01f, 9.50149000e-01f, 2.93140084e-01f, -2.98873186e-01f, 3.48806709e-01f, 3.44831496e-01f, 1.34763673e-01f, -1.66649923e-01f,
  5.47907591e-01f, 4.78275210e-01f, 4.29567337e-01f, 6.92363739e-01f, -3.20608228e-01f, -7.68584311e-01f, -5.17852724e-01f, -5.19044399e-02f, 2.68144906e-01f, 3.22638363e-01f,
  3.23346525e-01f, -4.33379598e-02f, 7.40269363e-01f, 2.15257272e-01f, -1.74304675e-02f, -3.83613616e-01f, 5.20320117e-01f, 2.18702361e-01f, -2.34629244e-01f, 5.33257246e-01f,
  3.84278417e-01f, 6.42049089e-02f, -1.83048993e-01f, -3.27177763e-01f, 6.29637480e-01f, 4.81049865e-01f, 6.51791215e-01f, 1.61198884e-01f, 3.46771896e-01f, 2.42503107e-01f,
  5.07797956e-01f, 3.18635553e-01f, 2.13208854e-01f, 5.28384984e-01f, 1.85993508e-01f, -6.61733389e-01f, -8.84812355e-01f, -7.58121312e-01f, -5.69276989e-01f, 3.26149553e-01f,
  -1.15406118e-01f, -2.75386781e-01f, 9.44068193e-01f, 4.48629409e-01f, 2.90786952e-01f, -9.30293262e-01f, 2.69939750e-01f, 5.28523207e-01f, 2.70503014e-01f, 2.15349987e-01f,
  2.76191920e-01f, 3.51722509e-01f, -7.34950364e-01f, 1.30786645e+00f, 2.56034791e-01f, 5.71292162e-01f, -5.25421798e-01f, 8.09095949e-02f, -9.81863886e-02f, 8.06324005e-01f,
  -2.61722565e-01f, 2.65634596e-01f, 1.64145425e-01f, 1.62421361e-01f, 5.98809347e-02f, 5.09437621e-01f, -1.02577591e+00f, 3.23614120e-01f, 3.47561002e-01f, -2.61969436e-02f,
  2.34358963e-02f, -4.41135513e-03f, -8.13719928e-02f, 7.90368468e-02f, 8.22013557e-01f, 7.01241255e-01f, -3.65414560e-01f, -4.87628467e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  4.34862643e-01f, 2.84579635e-01f, 1.86022311e-01f, 4.47152108e-01f, 2.40699366e-01f, 1.79258883e-01f, 4.26071107e-01f, 4.85647708e-01f
};

// L3_fan_Wp (Shape: 4 x 16)
const int L3_fan_Wp_rows = 4;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  -7.81150666e-05f, -3.79845917e-01f, 3.92274894e-02f, -5.03127696e-04f, -1.59776360e-01f, -7.00612128e-01f, 2.21580863e-01f, -1.95867829e-02f, 2.97501292e-02f, -3.34677666e-01f,
  -2.21433435e-02f, 1.35906432e-02f, -1.52443409e-01f, 3.24911088e-01f, 3.96403760e-01f, 2.48989742e-02f, 2.37975314e-01f, 4.60756809e-01f, -1.28075555e-01f, -2.24373370e-01f,
  2.60744661e-01f, 9.56290066e-02f, 2.87260357e-02f, 2.66422898e-01f, 2.67059132e-02f, -3.31421196e-01f, 6.54699579e-02f, 2.74027526e-01f, 8.44683647e-02f, -5.64193055e-02f,
  -1.67747930e-01f, -2.19638303e-01f, -2.77466718e-02f, 6.77319288e-01f, -3.36573690e-01f, -2.67145932e-01f, 5.02648175e-01f, 6.29870743e-02f, 7.33144209e-02f, -3.28901857e-01f,
  3.56635034e-01f, 2.44393647e-02f, -2.16414869e-01f, 3.18725780e-02f, -1.74203947e-01f, 1.00333571e-01f, 2.19396189e-01f, 2.49186367e-01f, -1.44742979e-02f, -8.76097918e-01f,
  2.79967993e-01f, -4.25571650e-01f, -5.23181081e-01f, 3.14853072e-01f, -6.43393248e-02f, -7.48566464e-02f, -3.56734991e-02f, 2.03985840e-01f, 7.82468915e-02f, -2.46660650e-01f,
  -2.74123251e-01f, 2.90765524e-01f, -1.44312844e-01f, 1.19423263e-01f
};

// L3_fan_Wp_bar (Shape: 8 x 16)
const int L3_fan_Wp_bar_rows = 8;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  -6.26142144e-01f, -9.92182434e-01f, 3.80390316e-01f, 3.48784685e-01f, -5.56316078e-01f, -4.75589126e-01f, 5.98729789e-01f, 7.33151674e-01f, -1.09978013e-01f, -6.52106881e-01f,
  9.84228671e-01f, 1.91357493e-01f, 1.64798871e-01f, -2.12578271e-02f, 4.57205415e-01f, -5.50113916e-01f, 7.70438850e-01f, 3.60462487e-01f, 3.80382568e-01f, 3.34375083e-01f,
  3.62570673e-01f, -1.24545775e-01f, 3.69197249e-01f, -8.47728789e-01f, 9.89827871e-01f, 3.36580932e-01f, -3.32896829e-01f, 8.66667151e-01f, 2.61650652e-01f, 1.02945960e+00f,
  9.09369290e-02f, 1.00789331e-01f, 1.58964723e-01f, 4.68902558e-01f, -5.60566723e-01f, 8.17628026e-01f, 1.04041541e+00f, 7.17241466e-02f, 2.03460187e-01f, 7.87318528e-01f,
  7.70274639e-01f, -1.18488304e-01f, 2.20870227e-01f, 3.48365635e-01f, 9.00110900e-01f, -1.20726705e+00f, 1.17638864e-01f, -6.04990497e-02f, -7.76994526e-01f, 4.10487652e-01f,
  -3.08335088e-02f, 3.76189849e-03f, 5.00793457e-01f, 1.27055192e+00f, -1.08437228e+00f, 3.52197021e-01f, -4.70624790e-02f, 6.89451516e-01f, 4.58372921e-01f, 1.48972675e-01f,
  3.99970561e-01f, -3.81558836e-01f, -4.86765653e-01f, 7.55117476e-01f, 3.25374663e-01f, 1.38313383e-01f, 3.55085760e-01f, 1.96761310e-01f, 7.02133060e-01f, 5.22351742e-01f,
  -6.14009678e-01f, 2.74289876e-01f, -1.20169662e-01f, 3.98573846e-01f, -2.90052086e-01f, -2.08008409e-01f, -2.04064503e-01f, 1.44814685e-01f, -5.57804108e-02f, 2.35469326e-01f,
  -9.52225029e-02f, 1.01096004e-01f, 8.48583639e-01f, -3.92362386e-01f, -9.94363844e-01f, 8.93851519e-02f, -6.06184304e-01f, -5.26374578e-01f, -1.63887255e-02f, 8.09869707e-01f,
  3.75270937e-03f, 9.84589569e-03f, 2.06254318e-01f, 1.41922748e+00f, 4.51152265e-01f, 1.00635922e+00f, -4.45089519e-01f, 3.70058954e-01f, -1.13453650e+00f, 5.68871737e-01f,
  -2.82160521e-01f, -7.04810977e-01f, 2.90571004e-01f, -6.56765342e-01f, 5.53835869e-01f, -4.84643847e-01f, 2.60954440e-01f, -1.67375311e-01f, -2.05962017e-01f, -3.98899734e-01f,
  1.07763708e+00f, 5.10718264e-02f, 1.98078632e-01f, 1.63772851e-02f, 7.12778628e-01f, -2.68481791e-01f, 3.10678959e-01f, -4.66691971e-01f, 7.75903404e-01f, -3.24828595e-01f,
  4.30408567e-01f, -2.87493262e-02f, 4.53719646e-01f, 7.40069389e-01f, 3.05052191e-01f, 7.76583016e-01f, -7.24962533e-01f, -6.52119040e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 8)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 8;
const float L3_fan_Bp_bar_data[] = {
  3.57110232e-01f, 3.67732316e-01f, 1.76382467e-01f, -7.84124881e-02f, 2.25615963e-01f, -9.36124399e-02f, 2.31604025e-01f, 5.65957315e-02f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  -6.95658207e-01f, -1.90579206e-01f, 2.23096564e-01f, 1.23870850e-01f, -8.06505144e-01f, -3.59209150e-01f, 9.52435076e-01f, 5.50897539e-01f, -2.79078484e-01f, 2.38505676e-01f,
  2.62903452e-01f, -1.05783284e-01f, -1.78547472e-01f, -8.98291767e-01f, -2.04933867e-01f, 3.75491202e-01f, 4.37688798e-01f, -5.24894118e-01f, -1.04413718e-01f, -6.52761281e-01f,
  -7.09473854e-03f, 6.55656815e-01f, -1.37979996e+00f, -8.99533629e-01f, 5.08462846e-01f, -2.13485420e-01f, 2.71742404e-01f, -6.00826442e-01f, -4.02776092e-01f, -1.14440012e+00f,
  -5.51414549e-01f, 4.41392094e-01f, -4.07744825e-01f, -4.46609139e-01f, -2.73509443e-01f, 1.43082127e-01f, -2.77215213e-01f, 4.57271367e-01f, -6.33121014e-01f, -2.31845900e-01f,
  6.81107193e-02f, -7.51519918e-01f, -1.63240023e-02f, 4.60792005e-01f, -1.98503816e+00f, 1.78498179e-01f, -1.18560338e+00f, 1.03115141e-01f, -1.75425202e-01f, 1.22262418e-01f,
  -6.04170024e-01f, -2.74607420e-01f, 5.31919539e-01f, -2.50248581e-01f, -2.03301385e-01f, 6.83796525e-01f, -1.07056701e+00f, 3.66719663e-01f, -8.34324181e-01f, -1.43421853e+00f,
  -1.25557840e-01f, 4.49943125e-01f, -3.54994833e-01f, 3.38610470e-01f, 2.97915637e-01f, 3.37335885e-01f, 2.16419131e-01f, 2.18223482e-01f, -1.38755560e-01f, 7.17165649e-01f,
  -3.17959398e-01f, -9.76342618e-01f, -1.23793252e-01f, 2.32650861e-01f, -6.50337413e-02f, -4.23867404e-01f, -6.93627417e-01f, 1.06222123e-01f, -5.45300841e-01f, 3.40875596e-01f,
  3.68916802e-02f, 2.80762404e-01f, -3.98316830e-01f, -3.22294354e-01f, 8.15992177e-01f, 6.80297241e-02f, 6.31073475e-01f, -1.12133875e-01f, -2.81393230e-01f, 3.40748280e-01f,
  4.31721240e-01f, -1.07935750e+00f, -4.21717227e-01f, -6.45862520e-01f, 6.22423470e-01f, -1.83996662e-01f, 9.46533978e-02f, 4.33331668e-01f, 7.80363679e-02f, 5.82903743e-01f,
  -5.57078779e-01f, -4.94239926e-01f, 7.91404188e-01f, -7.52023995e-01f, -4.23617661e-01f, -1.61657169e-01f, 4.19039696e-01f, 6.98669627e-02f, 1.41716659e-01f, 1.13423824e-01f,
  2.32499927e-01f, -1.05870998e+00f, 3.81792367e-01f, -3.21077853e-01f, 1.83265120e-01f, -1.14839382e-01f, 6.15978897e-01f, -3.30234766e-01f, 3.39673869e-02f, -1.00802094e-01f,
  -6.38797820e-01f, 3.28356564e-01f, -8.10026288e-01f, -1.34056300e-01f, 7.97654331e-01f, 4.62826252e-01f, -1.01231778e+00f, -7.83097982e-01f, 2.56398499e-01f, -4.76023778e-02f,
  -2.24637806e-01f, 3.34871948e-01f, 7.13315725e-01f, 6.93846941e-01f, -4.65129346e-01f, 2.09822312e-01f, 7.30651617e-01f, -1.01378953e+00f, -3.09736460e-01f, -2.92081267e-01f,
  -6.82132393e-02f, -2.64054716e-01f, -1.13784589e-01f, 1.38937995e-01f, -4.41877693e-01f, -6.16444111e-01f, 2.52358317e-02f, -5.19335270e-01f, -4.16207522e-01f, 2.22601622e-01f,
  8.17812160e-02f, 1.03786469e+00f, -8.61454666e-01f, 2.54432857e-01f, 5.79657853e-02f, 4.79834601e-02f, -7.55147398e-01f, 3.03423911e-01f, -6.54777586e-01f, -3.08491796e-01f,
  -4.14427102e-01f, -2.40832880e-01f, -7.86107853e-02f, 1.38713434e-01f, 1.05395325e-01f, -4.09700722e-01f, 4.90428954e-01f, 5.30062914e-01f, 3.53839338e-01f, 8.29423815e-02f,
  -1.01656306e+00f, -4.45630103e-01f, -4.30881709e-01f, 3.09549659e-01f, 2.37313181e-01f, -4.56547797e-01f, -2.13634491e-01f, 2.55397111e-01f, 2.04393581e-01f, 3.28731626e-01f,
  -1.19229786e-01f, -4.26814169e-01f, 6.15747988e-01f, -9.09342766e-02f, 4.29207534e-01f, -8.09274197e-01f, -1.46256655e-01f, -8.81908357e-01f, -2.25644097e-01f, -4.22398686e-01f,
  9.33098018e-01f, -9.52500463e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -2.59179145e-01f, 2.49988154e-01f, 3.54381762e-02f, 8.50595161e-02f, -5.06251790e-02f, 1.68092638e-01f, 4.38309401e-01f, -1.58806115e-01f, -1.02750640e-02f, -5.01884699e-01f,
  1.15470015e-01f, 1.29892483e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    