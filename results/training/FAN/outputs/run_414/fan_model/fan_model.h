/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.74053246e-01f, -2.11319730e-01f, -5.37915453e-02f, -2.51047522e-01f, 1.86976284e-01f, -1.55274525e-01f, -1.00090593e-01f, -5.83807826e-02f, -1.02503210e-01f, -2.74177730e-01f,
  -4.11674939e-02f, -4.64929920e-03f, 5.88948932e-03f, -1.76515266e-01f, 1.36856675e-01f, -1.93659768e-01f, -6.43304065e-02f, -4.55036759e-02f, 7.23724961e-02f, 5.10796756e-02f,
  3.68311442e-02f, -1.01762868e-01f, -7.62359947e-02f, -2.60328408e-02f, -6.43379688e-02f, -1.47741893e-02f, -1.38296917e-01f, -7.22975731e-02f, -2.66495440e-02f, 1.16533274e-02f,
  1.31033227e-01f, 3.86716127e-02f, -6.23372532e-02f, -4.38634567e-02f, 2.94904150e-02f, 1.64478626e-02f, 2.34338995e-02f, -1.07716538e-01f, 5.46399392e-02f, 5.78654604e-03f,
  -5.80590740e-02f, 5.14092781e-02f, -8.08464922e-03f, -5.34801409e-02f, 1.83743127e-02f, -2.25148425e-02f, -6.16688980e-03f, -4.50732745e-02f, -1.01014480e-01f, 1.61894073e-03f,
  4.34878245e-02f, -3.80273536e-02f, -9.13536847e-02f, -2.37818547e-02f, 1.38556724e-02f, -1.14076491e-02f, -1.98121890e-02f, 2.80929245e-02f, 7.55968243e-02f, 4.79651690e-02f,
  -1.72535330e-02f, 1.31982928e-02f, -1.40009017e-03f, 6.94785789e-02f, 3.86265144e-02f, 6.70955852e-02f, -4.87066023e-02f, 1.15863211e-03f, 4.71419021e-02f, -5.44877630e-03f,
  2.28744056e-02f, 1.81212220e-02f, -1.29499044e-02f, -4.61398214e-02f, -1.36053720e-02f, 2.22720148e-04f, -1.87842976e-02f, -4.38452661e-02f, -7.29369745e-02f, 5.90157919e-02f,
  -4.50430289e-02f, -1.44200120e-02f, -3.28883566e-02f, -1.97937768e-02f, 5.15798368e-02f, -8.33867770e-03f, -1.07916459e-01f, 1.20282755e-03f, -2.84678750e-02f, -4.11450006e-02f,
  8.99717361e-02f, 2.00177915e-02f, 1.86286226e-04f, -1.28509784e-02f, 5.58619909e-02f, 7.23459944e-03f, -3.72338034e-02f, 7.68290162e-02f, 2.65280344e-02f, -5.13805542e-03f,
  -6.97980402e-03f, -9.92414914e-03f, 5.11859357e-02f, 1.64545272e-02f, 3.23407352e-02f, -4.51718830e-02f, 1.24408572e-03f, 1.35539775e-03f, -3.71999629e-02f, 1.17980674e-01f,
  -3.09746191e-02f, 1.20352834e-01f, -1.24327810e-02f, 2.85391952e-03f, 2.82532517e-02f, -4.96194586e-02f, 2.03997567e-02f, -1.74443293e-02f, 6.14044815e-02f, -7.39114583e-02f,
  4.43522111e-02f, -2.17627026e-02f, -1.76831365e-01f, -2.85970569e-01f, -1.90452173e-01f, -3.92675251e-01f, -3.09338897e-01f, -1.41438410e-01f, -5.41239716e-02f, 1.25804013e-02f,
  -2.15554073e-01f, -4.30724397e-02f, -4.43911552e-02f, -3.61536980e-01f, -5.68478823e-01f, -1.58742845e-01f, -3.29963565e-01f, -1.22584201e-01f, -7.57587026e-04f, -1.43060600e-02f,
  -1.56071931e-01f, -3.29232663e-01f, -2.40301743e-01f, 4.73780856e-02f, 1.19493283e-01f, 1.99155167e-01f, 6.34634495e-02f, -6.03563059e-03f, 3.72968130e-02f, -8.44938159e-02f,
  -9.15405601e-02f, -5.67434467e-02f, 1.11804279e-02f, -1.56836193e-02f, 6.39416371e-03f, 1.21096976e-01f, 9.27571505e-02f, -5.65784648e-02f, -7.26568550e-02f, 5.62627846e-03f,
  -1.71013903e-02f, -2.38277987e-02f, -7.73468614e-02f, 2.43176240e-02f, 6.16462789e-02f, 5.91027513e-02f, 1.31591437e-02f, 7.66213164e-02f, -7.74668995e-03f, -3.95124629e-02f,
  -2.00593788e-02f, 7.60332048e-02f, -2.13038200e-03f, 2.23333668e-02f, 7.00100651e-03f, -3.60431597e-02f, 2.36045979e-02f, 1.34431347e-01f, -7.68779265e-03f, 1.42223090e-02f,
  4.69580702e-02f, 9.65863392e-02f, -3.04950178e-02f, 5.64804953e-03f, -5.26192673e-02f, 6.27163891e-03f, -6.78392649e-02f, -4.06919457e-02f, 3.11376341e-02f, -8.05733576e-02f,
  -2.12373538e-03f, -5.10990657e-02f, -1.34599907e-02f, -3.82776223e-02f, 4.22323402e-03f, -4.61714156e-02f, 2.40433384e-02f, 3.51265930e-02f, -5.89581877e-02f, -6.00236580e-02f,
  3.99406590e-02f, -1.04215898e-01f, 2.52714893e-03f, 1.85550570e-01f, -7.06519559e-02f, -2.87562776e-02f, 2.54085846e-02f, 3.63964178e-02f, 6.46576136e-02f, -7.78004900e-02f,
  -1.00424036e-01f, -1.92926321e-02f, -2.89853401e-02f, 1.31383147e-02f, -1.59547143e-02f, -2.32792385e-02f, -5.86063303e-02f, -6.19885838e-03f, -1.01032136e-02f, -2.06887908e-02f,
  9.03095827e-02f, -1.45554617e-02f, 6.18468598e-02f, 2.42730957e-02f, -2.90868175e-03f, -7.88459554e-02f, -4.10408974e-02f, 1.00572864e-02f, 1.63471159e-02f, 5.12138754e-02f,
  7.95233399e-02f, -1.87278595e-02f, -2.94770836e-03f, -2.99977008e-02f, 4.91927788e-02f, 5.64104505e-02f, -1.84725784e-02f, -4.76041846e-02f, 8.80103335e-02f, -1.61142542e-03f,
  -2.99462434e-02f, 3.33427519e-01f, -2.33516470e-01f, -5.50698005e-02f, 1.27214640e-01f, -1.75046638e-01f, -2.12354213e-01f, 2.92832460e-02f, 1.21418692e-01f, 1.83590323e-01f,
  -1.11247241e-01f, 1.12040401e-01f, -1.17252767e-01f, 8.19834992e-02f, -4.11063135e-01f, -5.14137074e-02f, -1.72821015e-01f, 3.27457786e-02f, 4.21361215e-02f, -8.65484253e-02f,
  -6.42081052e-02f, 5.39649837e-02f, -2.30050877e-01f, 1.64511278e-01f, -4.02013585e-02f, 1.19662873e-01f, -2.83796817e-01f, 3.72684672e-02f, -9.34882089e-03f, 1.03488617e-01f,
  -2.71552559e-02f, 1.82376668e-01f, 7.54703432e-02f, 4.16854722e-03f, -4.54154797e-02f, -4.18816507e-02f, -9.66940671e-02f, -9.98400990e-03f, 3.20518091e-02f, 1.08030159e-02f,
  -6.33685589e-02f, 9.41965878e-02f, -6.37414167e-03f, 4.59621847e-02f, 9.79813039e-02f, 9.89471152e-02f, 9.80168134e-02f, -1.68872364e-02f, 1.26364604e-02f, 5.13167605e-02f,
  -1.99345108e-02f, 1.39008230e-02f, -3.89562249e-02f, 2.10468136e-02f, 3.36936899e-02f, 2.91097481e-02f, -2.74332203e-02f, -4.53303792e-02f, 1.81129307e-03f, 6.89362511e-02f,
  3.79024372e-02f, 1.50674786e-02f, 4.24662828e-02f, 3.90166529e-02f, 2.81678550e-02f, 5.44734970e-02f, 2.48364173e-02f, 6.16362095e-02f, 5.28131705e-03f, 3.34432162e-02f,
  4.00183583e-03f, 2.79904529e-02f, 9.21643823e-02f, -1.00962438e-01f, 8.91920552e-02f, -3.83083476e-03f, -4.35979292e-02f, 8.96656066e-02f, -2.86093559e-02f, -1.05070561e-01f,
  5.71808498e-03f, -6.09856173e-02f, 8.94576535e-02f, -7.71983862e-02f, 3.95687968e-02f, 4.16420959e-02f, 3.44227031e-02f, 1.01782829e-01f, -1.17572442e-01f, -9.20548961e-02f,
  -1.06986135e-01f, -8.64063874e-02f, -3.99170294e-02f, 6.00625351e-02f, -1.31453555e-02f, -1.56924557e-02f, -3.83400321e-02f, 7.22270384e-02f, -5.79129569e-02f, -5.73534966e-02f,
  -1.99952237e-02f, -1.03303559e-01f, -9.10556689e-02f, 1.19309044e-02f, -3.59930620e-02f, -4.01309207e-02f, -7.84443542e-02f, -8.12249165e-03f, -1.64924473e-01f, -5.21690324e-02f,
  9.97559261e-03f, 2.29012361e-03f, -3.20372544e-02f, -3.17428447e-02f, -2.20964774e-02f, -5.59399948e-02f, -5.97114116e-02f, 1.09187998e-01f, -3.01389340e-02f, -6.48259372e-02f,
  2.77341902e-01f, -2.68259823e-01f, 1.14037067e-01f, -4.80479419e-01f, 1.79193035e-01f, -2.37025529e-01f, -2.47414857e-01f, -1.59587408e-03f, 2.66727768e-02f, -2.92327404e-01f,
  -8.66531804e-02f, -1.62298847e-02f, -3.51597965e-02f, -3.55528742e-01f, -3.68103175e-03f, -4.75754626e-02f, -3.37682694e-01f, -1.74454868e-01f, 5.00029474e-02f, -2.14927673e-01f,
  3.06786206e-02f, -3.11760902e-01f, 6.42170012e-02f, 1.45702614e-02f, -2.73889350e-03f, 8.14614370e-02f, 1.84130613e-02f, 9.09728482e-02f, 7.07066059e-03f, 3.40147950e-02f,
  -2.33057663e-02f, 2.69798469e-02f, 7.14984350e-03f, 2.73167472e-02f, -3.98938917e-02f, -2.66870335e-02f, -5.07162884e-02f, -3.72035652e-02f, 7.50451386e-02f, 1.16673335e-02f,
  -6.80906884e-03f, 5.42506836e-02f, -5.02303392e-02f, 2.42106691e-02f, 1.56015223e-02f, 5.43002635e-02f, 5.99968433e-02f, 1.59894302e-02f, 1.86300073e-02f, 4.33674902e-02f,
  2.70470921e-02f, 6.11090474e-03f, -1.76775921e-02f, -1.94589868e-02f, 7.41374716e-02f, -6.72200471e-02f, -7.19706267e-02f, 3.93694751e-02f, -1.40670575e-02f, -2.18785293e-02f,
  -3.12366318e-02f, -4.94338162e-02f, -9.82640684e-03f, 2.84284931e-02f, -3.61433029e-02f, 2.33407319e-02f, -6.16453551e-02f, -2.47017411e-03f, 1.27661007e-03f, -6.30340129e-02f,
  -3.78147960e-02f, -1.14665432e-02f, 1.62091348e-02f, 4.87916113e-05f, -5.70745096e-02f, -5.33298440e-02f, 1.55254258e-02f, -5.22051100e-03f, -1.46905957e-02f, 4.37056087e-02f,
  1.12627889e-03f, -3.01436763e-02f, 6.50259573e-03f, -1.12928441e-02f, 3.29107093e-03f, 8.75469819e-02f, 1.29565913e-02f, 6.00724295e-03f, 4.81214710e-02f, -6.93203509e-03f,
  -1.35516480e-01f, -2.92272061e-01f, -2.20039040e-02f, 9.91826411e-03f, -1.83049857e-03f, 4.97766398e-02f, 1.49898008e-02f, 5.35786077e-02f, -9.71715450e-02f, -1.94933154e-02f,
  -9.53029003e-03f, -9.84836295e-02f, 4.23296951e-02f, -4.39606160e-02f, -4.00024727e-02f, -1.99629064e-03f, -8.66959766e-02f, -3.44971940e-02f, -7.11471662e-02f, -2.36790162e-02f,
  -5.96740507e-02f, -2.53574252e-02f, -9.94294882e-03f, 1.07777175e-02f, -6.40817285e-02f, -1.94891505e-02f, 5.08396234e-03f, -5.19963093e-02f, 4.36400026e-02f, -4.84486185e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.76458210e-02f, -1.63747534e-01f, -4.27620709e-01f, -2.24554390e-01f, -1.01266257e-01f, 3.18060875e-01f, 1.26863882e-01f, -1.04933396e-01f, -4.80014771e-01f, 2.18462095e-01f,
  1.76281080e-01f, -3.98519695e-01f, 3.69724408e-02f, 3.82970273e-01f, -1.59717694e-01f, 3.54064822e-01f, 2.99053073e-01f, 1.58529997e-01f, -6.84595853e-02f, 7.48759508e-02f,
  -2.41874065e-03f, 5.53424418e-01f, 2.98417360e-02f, 2.90532708e-01f, 2.00118497e-01f, -1.51497170e-01f, 7.48674572e-02f, -8.50991383e-02f, 2.43156001e-01f, -5.55243455e-02f,
  1.86000571e-01f, -5.96528389e-02f, -2.42095310e-02f, -5.23102917e-02f, 3.56714078e-03f, 1.17756017e-01f, 7.18178926e-03f, 3.26479063e-03f, -6.92318752e-02f, -7.66875148e-02f,
  -8.31321031e-02f, -6.88460395e-02f, 5.08519486e-02f, -1.13580219e-01f, -6.96281493e-02f, -1.82635590e-01f, -1.18284360e-01f, -1.01635374e-01f, -7.35904723e-02f, 1.12134866e-01f,
  -7.16303736e-02f, -8.96920562e-02f, -3.57436873e-02f, -1.48874834e-01f, -1.01566553e-01f, -2.05032490e-02f, 6.20906539e-02f, -1.66903600e-01f, -3.85765620e-02f, -3.30824405e-02f,
  8.50471407e-02f, 7.86316767e-03f, 1.77020893e-01f, -1.38078146e-02f, 3.09919454e-02f, 1.56663969e-01f, 2.90263910e-02f, -1.38070555e-02f, -1.61741704e-01f, 1.44594938e-01f,
  -8.85998011e-02f, -5.72738387e-02f, 2.97093000e-02f, 9.41408798e-02f, 1.03938282e-01f, 8.49980339e-02f, 1.32711917e-01f, -2.08654143e-02f, -2.63897795e-02f, -4.38541472e-02f,
  -6.18995316e-02f, -2.81946454e-02f, -5.14985882e-02f, -9.36417188e-03f, 7.69948959e-02f, 6.04595952e-02f, -1.33642955e-02f, 1.61721371e-02f, 5.35242632e-02f, 4.85645384e-02f,
  -2.38276962e-02f, -8.23174566e-02f, -2.79044323e-02f, -7.99534917e-02f, -4.95882407e-02f, 4.38538827e-02f, 2.33952813e-02f, 8.97552967e-02f, -1.36893033e-03f, 3.90973203e-02f,
  6.72439635e-02f, -7.15233311e-02f, -2.01956537e-02f, 1.18239382e-02f, -6.04723096e-02f, 1.26450986e-01f, 1.83323726e-01f, -1.48619160e-01f, -1.30692422e-01f, -8.78992155e-02f,
  5.61163984e-02f, 3.06755714e-02f, -1.24825448e-01f, -7.58969598e-03f, -1.86748896e-02f, 4.35243808e-02f, -2.38053456e-01f, -9.31925178e-02f, -8.80783796e-02f, -5.87690845e-02f,
  3.30091625e-01f, -8.82794037e-02f, 5.41384444e-02f, 6.27375185e-01f, -2.00114056e-01f, -4.89356935e-01f, -5.45406580e-01f, 7.10864067e-02f, -1.22912057e-01f, -2.20839456e-01f,
  3.17684785e-02f, -1.28717974e-01f, -1.34516090e-01f, 2.74551302e-01f, 6.19552016e-01f, -1.89066112e-01f, 2.62568951e-01f, 2.04715226e-03f, -5.69131002e-02f, 1.54835433e-01f,
  2.89562076e-01f, 6.24428570e-01f, 4.21135962e-01f, 3.61630350e-01f, 2.22754151e-01f, 3.62095624e-01f, 5.98659217e-01f, -1.03183500e-01f, 4.37559843e-01f, 1.03217281e-01f,
  -1.15570359e-01f, 2.85525173e-02f, 5.82887083e-02f, 3.41615230e-02f, 1.37621790e-01f, -2.31244974e-02f, -9.69591215e-02f, -1.22250468e-02f, -1.12568311e-01f, 5.53305121e-03f,
  -1.34382322e-01f, 1.70576517e-02f, 1.29730389e-01f, 2.32279181e-01f, -1.74944457e-02f, 5.03162481e-02f, -2.12873109e-02f, -1.31655455e-01f, -2.24780351e-01f, -1.40865315e-02f,
  2.81038247e-02f, -3.91289182e-02f, -7.04816282e-02f, 4.91237007e-02f, 7.96736106e-02f, 6.12924322e-02f, -1.26755238e-01f, -2.74906904e-02f, -5.49651869e-02f, 4.97467257e-02f,
  8.26521069e-02f, -4.19346057e-02f, 4.16743942e-02f, -4.68903892e-02f, 6.73925206e-02f, 2.34663449e-02f, 4.54225056e-02f, -1.63609162e-01f, 1.38433948e-01f, 3.14710997e-02f,
  3.52912061e-02f, 1.76423028e-01f, 5.84474020e-02f, -1.74950466e-01f, 2.06791274e-02f, -8.21455196e-02f, 2.63087060e-02f, 1.25689045e-01f, 2.41942070e-02f, -1.48835257e-01f,
  -9.54550505e-02f, 5.15495334e-03f, 5.80355152e-02f, 2.46867742e-02f, 4.24121395e-02f, 1.22032896e-01f, 1.28689691e-01f, -4.03986545e-03f, -6.63979203e-02f, -9.07845795e-02f,
  1.26263499e-01f, 2.30941027e-01f, -1.38181835e-01f, -1.49323987e-02f, -8.69914666e-02f, 4.08522226e-02f, 3.95822758e-03f, 1.50084853e-01f, 1.60666391e-01f, -1.59371849e-02f,
  -4.91255037e-02f, -6.86584786e-02f, -7.88398460e-02f, 1.52951218e-02f, 1.30237147e-01f, 7.72774220e-02f, 2.50596777e-02f, 5.39228134e-02f, 2.12740779e-01f, 7.03136101e-02f,
  4.20469865e-02f, -7.02670664e-02f, -4.28952686e-02f, -9.20703113e-02f, -4.74424101e-02f, -5.69743887e-02f, -1.01908945e-01f, -1.24290157e-02f, 1.31905138e-01f, -6.72091171e-03f,
  -1.19509447e+00f, 6.76167548e-01f, -2.67447442e-01f, 1.44850656e-01f, -8.64119921e-03f, 7.15282977e-01f, 2.50391215e-01f, 2.12553814e-01f, 1.44529924e-01f, 2.52640009e-01f,
  -3.45714986e-02f, 6.86357636e-03f, 1.46037400e-01f, 2.76832908e-01f, -3.11667044e-02f, 4.19840515e-01f, 3.21432203e-01f, 8.99979100e-02f, 2.48983189e-01f, -5.55573590e-02f,
  4.60110158e-02f, 9.95944068e-02f, -8.66262242e-02f, 2.11084619e-01f, -2.04493523e-01f, -2.48429924e-01f, -2.37312034e-01f, 1.14748618e-02f, -1.53062314e-01f, 6.03427775e-02f,
  3.06579843e-02f, -2.10008636e-01f, -1.73726603e-01f, 3.02921585e-03f, 9.85809835e-04f, -1.13551266e-01f, -3.58841196e-02f, -1.33746564e-01f, -6.28698543e-02f, 9.25660953e-02f,
  -7.90917203e-02f, 2.11142097e-03f, 1.41101316e-01f, -1.51757197e-02f, -1.97853167e-02f, -6.80151433e-02f, -3.37493443e-03f, 2.31826473e-02f, 3.09197791e-02f, -5.83987609e-02f,
  -8.56787637e-02f, -1.42014837e-02f, -4.59080413e-02f, 1.83078428e-05f, -3.63770835e-02f, 3.25079113e-02f, 2.89023407e-02f, -6.27524853e-02f, 5.91808781e-02f, 7.31794015e-02f,
  -1.34086549e-01f, 5.32030724e-02f, -7.17120692e-02f, -3.24406549e-02f, -3.83958295e-02f, -8.59443247e-02f, -7.88648725e-02f, -4.55392897e-02f, -3.61421295e-02f, -3.46675627e-02f,
  5.27756428e-03f, -2.05183234e-02f, -7.77049437e-02f, -4.30171676e-02f, -4.44079302e-02f, -6.92292303e-02f, -5.71226999e-02f, -1.39083480e-02f, 6.67625368e-02f, -3.78947295e-02f,
  2.46321298e-02f, 1.10567652e-01f, 1.88377108e-02f, 9.82054397e-02f, 4.24504541e-02f, 6.87258616e-02f, -9.30693001e-03f, -2.67852563e-02f, -6.32188171e-02f, 5.18317753e-03f,
  3.57584625e-01f, 1.50425225e-01f, 3.64255346e-02f, 4.61437590e-02f, 5.70172183e-02f, 2.24106777e-02f, -8.55840929e-03f, -2.86743380e-02f, 1.88118383e-01f, -4.94500110e-03f,
  -6.37904853e-02f, -2.17001755e-02f, 1.98006108e-02f, -7.29259253e-02f, 3.21691446e-02f, 1.19791277e-01f, 2.62811482e-02f, 6.35225177e-02f, -1.38428360e-02f, -3.24794501e-02f,
  -3.85296196e-02f, -2.56010480e-02f, -8.55090097e-02f, 2.47457903e-03f, 5.94700910e-02f, -1.22398227e-01f, -6.58218786e-02f, -1.79116707e-02f, -6.00968152e-02f, -2.00331900e-02f,
  -2.05788836e-01f, -3.64557534e-01f, -3.65814060e-01f, -5.65564871e-01f, 6.26387000e-02f, -4.99099374e-01f, -4.42816556e-01f, -2.63738960e-01f, -9.26908925e-02f, 1.89750001e-01f,
  -3.62743288e-02f, -1.51472107e-01f, 4.02166933e-01f, -4.99516964e-01f, -2.25638375e-01f, 1.26665935e-01f, -5.52778721e-01f, -2.05534548e-01f, 9.58282724e-02f, -2.75586993e-01f,
  -6.11167103e-02f, -1.89219251e-01f, -2.49161586e-01f, 2.24549770e-01f, -4.66058254e-01f, -3.68239582e-02f, 4.11980182e-01f, 1.86497003e-01f, -2.43185312e-01f, 4.71770484e-03f,
  -1.80326998e-01f, -6.82722852e-02f, -1.52839154e-01f, -4.11479771e-02f, -1.67227879e-01f, 5.33317327e-02f, -1.06531521e-02f, -3.45493965e-02f, -2.35338807e-02f, -7.18509480e-02f,
  -3.21980976e-02f, 2.60248519e-02f, -1.20738819e-01f, 1.72687158e-01f, 2.93762498e-02f, 3.27486508e-02f, -1.17913485e-01f, -4.59277108e-02f, -5.58526255e-02f, -1.51106372e-01f,
  -1.71408713e-01f, -6.89154938e-02f, 5.44954324e-03f, -4.49862108e-02f, -5.67213558e-02f, 8.31491500e-03f, -6.57022446e-02f, 2.27944162e-02f, -1.28597841e-01f, -6.91480264e-02f,
  6.25454038e-02f, 1.10031724e-01f, 1.22840926e-02f, 6.66192845e-02f, -4.57574613e-02f, 4.37287651e-02f, 4.85054627e-02f, 7.35363588e-02f, 8.27734545e-02f, -2.58130429e-04f,
  4.70278449e-02f, -6.56469464e-02f, 1.00559779e-01f, -7.07271174e-02f, -1.57990903e-01f, -3.73722836e-02f, -8.63425247e-03f, 1.71161983e-02f, -4.86142561e-02f, -1.04044117e-01f,
  -5.27137751e-03f, -9.38559324e-03f, -9.07928031e-03f, 1.20195923e-02f, -6.11849539e-02f, 6.77067786e-02f, 1.14039548e-01f, 3.05133709e-03f, 9.87573061e-04f, 3.69565599e-02f,
  -9.25812870e-02f, 1.08827293e-01f, -1.76527463e-02f, 2.72693913e-02f, 3.15732285e-02f, -3.35635059e-02f, -6.41268790e-02f, -1.19939215e-01f, -3.24913040e-02f, 1.88923385e-02f,
  6.28293008e-02f, 7.30102882e-02f, -3.36547270e-02f, -7.25512505e-02f, -1.01454994e-02f, -8.42888355e-02f, 6.42880946e-02f, -8.10816064e-02f, 1.22215878e-02f, 5.64664695e-03f,
  3.35042961e-02f, 2.71807574e-02f, -3.82268941e-03f, -3.29309553e-02f, -4.88703605e-03f, -3.50936316e-02f, -1.37745757e-02f, -2.02765875e-02f, -5.81122050e-03f, 5.45566529e-02f,
  -8.60988319e-01f, -2.53686130e-01f, 4.00869399e-01f, -4.37485754e-01f, 1.21247798e-01f, 2.28707075e-01f, 4.90245491e-01f, -1.81964040e-01f, -5.46845973e-01f, -1.02963485e-01f,
  6.15406036e-02f, -1.07986040e-01f, 4.41916972e-01f, -2.17292667e-03f, 3.84392351e-01f, 4.51789171e-01f, -1.27924634e-02f, -6.33470118e-02f, -5.62170194e-03f, -3.63012940e-01f,
  -1.72428489e-02f, 1.44442469e-01f, 5.84472716e-01f, -1.98079109e-01f, -7.34992698e-02f, -2.91372418e-01f, 1.21434055e-01f, 2.11941794e-01f, -2.00687289e-01f, 2.40247086e-01f,
  -2.38506317e-01f, -2.96410024e-01f, -1.14454880e-01f, 3.34576108e-02f, -3.45203206e-02f, -3.22315767e-02f, 1.40957132e-01f, 4.27312180e-02f, 5.57025289e-03f, 3.59610021e-02f,
  3.51636708e-02f, -3.54727097e-02f, -1.89859256e-01f, 5.71583100e-02f, -1.23485141e-01f, -3.79266180e-02f, -5.94364144e-02f, 1.50496897e-03f, 4.43817452e-02f, 1.25602365e-01f,
  7.97087327e-02f, 8.59167874e-02f, -8.92957952e-03f, 2.97559556e-02f, 1.38851047e-01f, 4.81619826e-03f, 6.85034990e-02f, 1.93576261e-01f, 2.58359332e-02f, -1.82587773e-01f,
  5.10748513e-02f, -4.60477471e-02f, 4.60995063e-02f, -6.27070218e-02f, -1.75582170e-02f, 1.26414793e-03f, 5.57557456e-02f, 5.98434210e-02f, 5.30773327e-02f, 6.70191944e-02f,
  -8.35504085e-02f, 3.34500894e-02f, -7.48280883e-02f, -1.23866915e-03f, -7.76436031e-02f, -9.31401998e-02f, 6.10959753e-02f, -2.55401935e-02f, 1.51017429e-02f, -2.14647818e-02f,
  1.90330762e-03f, 3.04388050e-02f, -2.47499235e-02f, 7.12446645e-02f, -1.12034408e-02f, 8.05907324e-02f, -1.14565767e-01f, 3.72983851e-02f, -3.08369435e-02f, 9.89360735e-02f,
  -4.22933728e-01f, -4.94680613e-01f, -8.84562433e-02f, -9.89313424e-02f, -2.15818249e-02f, -6.89992756e-02f, -6.42120317e-02f, -2.98203994e-02f, -6.92134649e-02f, -7.99702257e-02f,
  -1.22282475e-01f, -2.64166128e-02f, -6.17489517e-02f, -1.13102846e-01f, -7.98948761e-03f, -9.29951295e-03f, -4.31841873e-02f, -5.90990670e-02f, -2.94245295e-02f, -1.28907822e-02f,
  -9.88306105e-02f, -1.43447042e-01f, 2.31008697e-02f, -1.13367178e-01f, 4.30450663e-02f, -1.60905607e-02f, -1.53651386e-01f, -8.68227184e-02f, 2.76101101e-02f, 9.80935320e-02f,
  -7.91258588e-02f, -2.53842413e-01f, -5.90551198e-01f, 1.32296070e-01f, 3.91742676e-01f, 2.56673038e-01f, -1.20171510e-01f, 9.73426402e-02f, -1.39142841e-01f, 3.01276773e-01f,
  6.41298369e-02f, -1.52841911e-01f, -2.67710537e-01f, 4.85113114e-01f, 2.57839680e-01f, -1.76597759e-02f, 3.95618916e-01f, 1.75535753e-01f, 5.25679663e-02f, -2.08774567e-01f,
  8.93946439e-02f, 4.02166575e-01f, -6.68549836e-02f, 3.66953723e-02f, 7.61819333e-02f, -1.84635848e-01f, 2.71448374e-01f, -3.13695878e-01f, 2.55468994e-01f, 1.38295650e-01f,
  4.12416048e-02f, -2.72846669e-01f, -1.67692840e-01f, 6.03333116e-02f, -1.88866928e-02f, -1.87217861e-01f, 2.37948075e-02f, -7.50081241e-02f, -1.62007697e-02f, -7.67992139e-02f,
  -2.24607624e-02f, -2.29507983e-02f, -5.08733727e-02f, -7.01780766e-02f, 5.71988709e-02f, 7.43297637e-02f, 3.13185230e-02f, -3.61411162e-02f, 3.19893770e-02f, -1.60434078e-02f,
  -1.24499843e-01f, -5.65754548e-02f, 5.21667581e-03f, -2.85240542e-03f, -3.94975021e-02f, 5.98652847e-03f, 3.65121998e-02f, -9.65740755e-02f, 2.90347617e-02f, -4.97752130e-02f,
  3.16348076e-02f, -2.74352521e-01f, -5.10017723e-02f, 1.38245719e-02f, -1.60268098e-01f, 5.30167222e-02f, 2.31206906e-03f, 2.50732284e-02f, -7.21732453e-02f, 4.69087176e-02f,
  -5.70101589e-02f, 9.45986137e-02f, 7.12388307e-02f, 3.73647884e-02f, -5.35298288e-02f, 4.47358005e-02f, -1.55479237e-02f, -7.74982618e-03f, -6.73599914e-02f, 1.69959515e-01f,
  3.49825360e-02f, -4.79259305e-02f, -1.37201166e-02f, 1.46822840e-01f, 2.52728146e-02f, -5.09292148e-02f, 6.55711368e-02f, -9.48850662e-02f, 1.03806434e-02f, -2.23626830e-02f,
  5.16055385e-03f, -1.40817076e-01f, -9.67851877e-02f, 9.78492424e-02f, -1.89918466e-02f, 1.12669893e-01f, 2.40214244e-02f, 3.08044422e-02f, 2.50406377e-02f, -1.11021027e-01f,
  3.83412662e-05f, -9.74020138e-02f, 3.64429876e-02f, 2.97949724e-02f, -1.06030375e-01f, -1.47722196e-02f, -7.11480975e-02f, 1.32853925e-01f, 1.63330436e-01f, 6.04660287e-02f,
  -9.74752754e-02f, -3.30416689e-04f, -6.30028173e-02f, 1.92677733e-02f, 1.80689916e-01f, -6.88498914e-02f, -4.67341915e-02f, -1.08965062e-01f, 5.72541021e-02f, 6.10801280e-02f,
  4.96123821e-01f, -2.06115752e-01f, 1.84078947e-01f, 4.39118057e-01f, 6.34657621e-01f, 2.45359004e-01f, 6.02808654e-01f, 3.74167144e-01f, 5.82951427e-01f, -3.89081836e-01f,
  -1.08982138e-01f, -4.79486138e-01f, -8.13354552e-02f, -4.08391729e-02f, 2.30024084e-01f, 1.23941243e-01f, 4.26422447e-01f, 1.72535256e-01f, 3.82985353e-01f, 4.59590666e-02f,
  3.45923752e-01f, 1.14934579e-01f, 7.12412596e-02f, -6.69242665e-02f, 1.42702579e-01f, 5.20705478e-03f, -1.63982004e-01f, 6.51746914e-02f, -3.53568971e-01f, 8.69553611e-02f,
  2.68504843e-02f, 1.08226627e-01f, -5.99021055e-02f, -8.84090364e-02f, 4.08613682e-02f, -7.78314173e-02f, -3.27816941e-02f, -3.01490054e-02f, -6.78844228e-02f, -9.02298465e-02f,
  -1.08704582e-01f, -7.97647163e-02f, -6.78973123e-02f, -1.53065607e-01f, 1.90418869e-01f, 3.16228643e-02f, 6.20236322e-02f, 5.31462841e-02f, 9.96229723e-02f, -3.73383313e-02f,
  -4.93011884e-02f, -6.70562387e-02f, 2.00693365e-02f, -1.43813968e-01f, 6.85700923e-02f, 1.48734469e-02f, 3.52092572e-02f, -7.07635209e-02f, 7.59614855e-02f, 2.31043752e-02f,
  7.73282871e-02f, 2.09053800e-01f, 1.91397239e-02f, -1.30721733e-01f, 3.03701591e-02f, 1.50531493e-02f, -5.52527346e-02f, -8.15950781e-02f, 4.20721993e-02f, -3.37699540e-02f,
  3.70010547e-02f, -1.89654529e-01f, 2.01660752e-01f, 8.09833407e-02f, 8.08375049e-03f, 1.87912341e-02f, 1.38077326e-02f, -1.32633895e-01f, 8.34153965e-02f, -5.04817776e-02f,
  -8.34787637e-03f, 6.69876412e-02f, -2.82403547e-02f, 3.38691883e-02f, -7.45506063e-02f, -8.16691294e-03f, 3.40555720e-02f, -3.39470804e-02f, 1.04195155e-01f, 4.54689376e-02f,
  -2.06864476e-01f, 8.20872113e-02f, -1.00038581e-01f, -9.19096097e-02f, -1.43237799e-01f, 1.42649356e-02f, 5.27047329e-02f, -3.90389487e-02f, 6.60467297e-02f, -1.46619696e-03f,
  3.45993713e-02f, -5.98939508e-02f, -5.91651350e-02f, -6.40668795e-02f, -5.28656989e-02f, 4.75359755e-03f, -3.68019082e-02f, -7.87696615e-03f, -5.17304949e-02f, -3.69726233e-02f,
  -1.36428595e-01f, 3.87686640e-02f, -6.55374676e-02f, 3.72027494e-02f, -6.66087791e-02f, -6.52280897e-02f, -1.71699394e-02f, -5.81438392e-02f, -1.42340243e-01f, -8.24493542e-02f,
  -2.22002015e-01f, -6.57795429e-01f, -4.90514785e-01f, -7.80043826e-02f, 4.14460927e-01f, 3.65444958e-01f, -2.19124146e-02f, -7.02429637e-02f, -4.23621804e-01f, -6.61300495e-02f,
  6.04700334e-02f, -1.64221510e-01f, -4.56477821e-01f, -1.33897632e-01f, 1.33451328e-01f, -3.83244753e-01f, 1.62431657e-01f, 5.09913405e-03f, -2.37701580e-01f, -2.77682170e-02f,
  -6.61462918e-02f, 7.87243992e-02f, -1.50072083e-01f, 5.89668639e-02f, 1.52157053e-01f, 1.66818351e-02f, 3.27275068e-01f, 9.08193737e-02f, 3.01905870e-01f, 1.67326152e-01f,
  5.35908900e-02f, -2.54985571e-01f, -8.76977071e-02f, -1.19959846e-01f, -5.01481295e-02f, 1.45760253e-01f, 1.46437719e-01f, 1.75615385e-01f, 4.22537327e-02f, -5.69994114e-02f,
  1.18937008e-02f, 2.98596509e-02f, 5.34220831e-03f, 1.45666469e-02f, 4.46022302e-03f, -8.15582636e-04f, -1.59006491e-02f, -7.47568235e-02f, -6.63600042e-02f, -9.10062268e-02f,
  -1.76817477e-01f, 2.39208341e-02f, -2.84168050e-02f, -7.17237592e-02f, -2.55340356e-02f, -7.97557160e-02f, -1.37911811e-02f, 8.12852904e-02f, 2.06133965e-02f, 3.00847795e-02f,
  3.64485718e-02f, 1.39018580e-01f, -1.39418095e-02f, -6.58786818e-02f, -9.17121395e-03f, -2.88981125e-02f, -1.21433623e-01f, 8.82043783e-03f, -1.37716189e-01f, 2.47780215e-02f,
  -3.24295573e-02f, -4.72898893e-02f, -1.32029727e-01f, 2.72815339e-02f, 5.54560199e-02f, -1.32618517e-01f, 3.43554989e-02f, 3.75980847e-02f, 9.05200019e-02f, -1.00292474e-01f,
  -6.08371496e-02f, 6.25839755e-02f, 3.25441808e-02f, -4.37072776e-02f, -9.40974578e-02f, 7.49459192e-02f, 6.06309697e-02f, -2.14696378e-02f, 2.20256802e-02f, 1.21767752e-01f,
  5.83948344e-02f, 6.97488263e-02f, 1.76587068e-02f, 5.30030020e-02f, -2.25955769e-02f, 1.38430828e-02f, -1.22352645e-01f, -7.56849498e-02f, -1.51795521e-02f, 1.53558915e-02f,
  1.95736915e-01f, 1.23957999e-01f, 1.08944036e-01f, -6.03053682e-02f, 1.15014546e-01f, 4.42209467e-02f, 5.71033452e-03f, 8.08758810e-02f, 4.67309058e-02f, 4.85228077e-02f,
  6.99844211e-02f, 2.01994274e-02f, 2.22637728e-02f, -2.96651153e-04f, 2.25952603e-02f, 7.05420300e-02f, 8.52428824e-02f, 3.60649601e-02f, -6.69435635e-02f, -1.18787155e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  2.95556188e-01f, -1.51880398e-01f, 5.95485687e-01f, 1.21803202e-01f, 2.71851748e-01f, 2.38851786e-01f, 3.31009239e-01f, 1.87455788e-01f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  3.77100438e-01f, -8.05669799e-02f, -3.38232994e-01f, 8.21576834e-01f, -3.18323433e-01f, 3.26074123e-01f, 4.13954586e-01f, 2.16742814e-01f, -1.25158876e-01f, -4.76131588e-01f,
  -3.64666194e-01f, -1.31648242e-01f, 2.29701132e-01f, -2.80647099e-01f, -2.03572124e-01f, 1.87319353e-01f, -3.09907109e-01f, -3.77924085e-01f, 2.07824677e-01f, -2.50032414e-02f,
  5.58703303e-01f, 1.12214625e-01f, -3.85461450e-01f, -1.80778086e-01f, -1.69689342e-01f, -1.57344863e-01f, -5.76726317e-01f, 9.80981216e-02f, 2.72695087e-02f, 4.11013067e-01f,
  -4.99583185e-02f, 3.27803224e-01f, 4.86194044e-02f, -5.50679564e-01f, 6.45285249e-01f, 2.71152467e-01f, 3.92879337e-01f, 2.49345154e-01f, 1.59497693e-01f, -5.75238764e-01f,
  1.71855818e-02f, -1.42593771e-01f, 7.72861671e-03f, 3.60374391e-01f, -4.29113477e-01f, 4.04589683e-01f, -1.19477540e-01f, 4.57964748e-01f, 2.80327439e-01f, -8.68030936e-02f,
  -4.98875797e-01f, 2.94679910e-01f, -3.94883394e-01f, -1.51291341e-01f, -1.30852148e-01f, 1.49913087e-01f, -7.34089166e-02f, 2.77819693e-01f, -4.99961376e-02f, -1.95734516e-01f,
  9.48611721e-02f, -6.65022612e-01f, 3.70895356e-01f, -4.94563699e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  8.45676064e-01f, 2.48702951e-02f, 6.21406317e-01f, 4.06625003e-01f, -2.65311331e-01f, -7.09604442e-01f, -1.77531809e-01f, -4.38244075e-01f, -4.11426336e-01f, 7.53527164e-01f,
  4.36624676e-01f, -8.08396935e-01f, -9.14873719e-01f, -5.52207381e-02f, 1.25413382e+00f, -2.92835921e-01f, -7.88145661e-02f, -3.57552528e-01f, 7.02891946e-01f, -2.80059934e-01f,
  4.19965088e-01f, -1.37773305e-01f, 6.01660833e-02f, -2.72919238e-01f, 7.13042915e-01f, 2.56281585e-01f, 4.26127017e-01f, 9.42909598e-01f, -1.39568225e-01f, 7.22406566e-01f,
  -5.12326181e-01f, 8.70233059e-01f, 6.29815340e-01f, -3.01739633e-01f, -8.04482177e-02f, 6.31763101e-01f, 1.39098614e-01f, 6.55233264e-01f, 6.75856411e-01f, 2.49400824e-01f,
  1.45131439e-01f, -2.62086064e-01f, 9.74100083e-02f, 7.92672634e-01f, -2.52437800e-01f, 6.80315197e-01f, 2.22537220e-02f, 4.42140758e-01f, -3.58940780e-01f, 8.62434208e-01f,
  3.25561702e-01f, -4.63612348e-01f, -7.14371145e-01f, -4.05036241e-01f, -2.57595003e-01f, -6.62289679e-01f, 5.97662508e-01f, 1.01431189e-02f, 1.09046471e+00f, -5.81307858e-02f,
  3.72486591e-01f, -4.48811017e-02f, -2.62137115e-01f, -5.49080670e-01f, -1.98064327e-01f, 2.20093325e-01f, 3.84186059e-01f, 3.88737977e-01f, 2.24686414e-01f, -3.17020088e-01f,
  -4.74857718e-01f, -3.18173617e-02f, 6.39180303e-01f, 7.12798774e-01f, 2.74272144e-01f, -8.30810592e-02f, 9.32353199e-01f, 5.38066208e-01f, -2.87082698e-02f, 8.17280591e-01f,
  -4.07650843e-02f, 2.56939262e-01f, -8.08523118e-01f, -6.51562154e-01f, 6.88878670e-02f, -2.85307579e-02f, 4.78630692e-01f, 3.48363012e-01f, -3.49396355e-02f, 1.34143513e-02f,
  5.35453618e-01f, 8.96054029e-01f, 3.04548144e-01f, -9.47922766e-02f, -3.04353654e-01f, -7.34487534e-01f, 7.63715804e-01f, 4.15385693e-01f, 2.36510098e-01f, 1.22924817e+00f,
  1.18934900e-01f, -1.35457411e-01f, 7.86353350e-02f, 1.29036617e+00f, 7.49813989e-02f, -5.79897463e-01f, 2.91613668e-01f, -1.29131749e-01f, 9.51029539e-01f, -4.37561512e-01f,
  4.52488422e-01f, -3.50151211e-02f, 2.61887193e-01f, -1.01906650e-01f, -8.17436073e-03f, 2.96615958e-01f, 6.27473518e-02f, -4.58231390e-01f, -3.56549650e-01f, 5.87791502e-02f,
  -1.33230448e-01f, 9.90969181e-01f, -6.99210167e-01f, -1.87849909e-01f, 2.01599658e-01f, 3.47694159e-01f, 1.07819000e-02f, 5.38963437e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  6.04070008e-01f, 2.50404537e-01f, 6.20812654e-01f, 5.83910882e-01f, 5.42029202e-01f, 3.63664836e-01f, 4.97510612e-01f, 6.16972484e-02f
};

// L2_fan_Wp (Shape: 4 x 16)
const int L2_fan_Wp_rows = 4;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  4.05510873e-01f, -1.97993413e-01f, -5.39057612e-01f, 7.44640008e-02f, -3.59879613e-01f, 4.93394226e-01f, -3.65169287e-01f, -3.50901395e-01f, -1.66520812e-02f, -5.89180849e-02f,
  -1.99608840e-02f, -4.15906578e-01f, 1.69816852e-01f, -3.66484076e-01f, 4.06142861e-01f, -7.55576715e-02f, 2.93901801e-01f, 2.14603826e-01f, 3.10014337e-01f, -1.96412504e-02f,
  -7.65477359e-01f, -2.96993613e-01f, -1.35702506e-01f, 2.65016288e-01f, 2.92978585e-01f, 2.44308308e-01f, -4.60781425e-01f, 3.64181936e-01f, 6.09710924e-02f, 2.50643104e-01f,
  -2.51262724e-01f, -3.15355450e-01f, -3.18160444e-01f, -2.49791462e-02f, -1.82065696e-01f, 1.79508179e-01f, 2.74415761e-01f, -2.60204561e-02f, 2.71111876e-01f, -2.70007044e-01f,
  8.50216225e-02f, -1.22510515e-01f, 3.99942577e-01f, -4.46803540e-01f, -3.67811546e-02f, 3.19084704e-01f, -1.92686021e-01f, 1.42054781e-01f, 2.52542436e-01f, -3.90079230e-01f,
  4.25981246e-02f, -8.23817328e-02f, -7.99132809e-02f, 9.02580544e-02f, 9.85700190e-02f, 1.15421638e-01f, 1.65861915e-03f, -1.08349137e-01f, 2.97581345e-01f, -5.38774073e-01f,
  -4.91786934e-02f, 4.54160005e-01f, 2.01652139e-01f, -8.84868801e-02f
};

// L2_fan_Wp_bar (Shape: 8 x 16)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  9.44747850e-02f, 4.74552810e-02f, -9.54624534e-01f, -1.35924652e-01f, -5.50482571e-01f, 1.20924926e+00f, 2.63728052e-01f, -1.06567752e+00f, 7.96705857e-02f, 8.57033551e-01f,
  1.80392906e-01f, -6.24491930e-01f, 5.02429426e-01f, -4.64195758e-01f, -3.99737209e-01f, 9.05893743e-01f, -5.47215819e-01f, -3.60922784e-01f, -9.77428630e-02f, 4.99721855e-01f,
  -6.56731188e-01f, -1.02558410e+00f, 3.09248954e-01f, -3.97764921e-01f, 3.22901756e-01f, 6.89067721e-01f, -4.73061502e-01f, 1.23725367e+00f, 4.14973021e-01f, -3.58776629e-01f,
  -2.95063108e-01f, -7.49130130e-01f, 8.82278204e-01f, 6.60800278e-01f, 1.65538713e-01f, 6.01250291e-01f, 1.41659498e+00f, -2.93989360e-01f, -8.18781316e-01f, 1.02964655e-01f,
  -6.37010217e-01f, 6.72414303e-02f, 5.04467845e-01f, 7.81517029e-01f, 6.89293981e-01f, -4.88478690e-01f, 1.18936312e+00f, -4.92721647e-01f, 4.77230012e-01f, 5.83458424e-01f,
  1.16675544e+00f, 1.10169685e+00f, 3.85372043e-01f, -9.08029735e-01f, 8.76690984e-01f, 4.52802241e-01f, 1.00956953e+00f, -3.52960378e-01f, 6.63342535e-01f, 1.13520138e-01f,
  -7.04880655e-01f, 5.05152762e-01f, 3.66407096e-01f, -8.93001556e-01f, 3.90041769e-01f, -7.08568513e-01f, 4.78573501e-01f, 5.11298954e-01f, -7.20432103e-01f, -8.53535533e-01f,
  -3.48128915e-01f, -2.41240755e-01f, -1.94534678e-02f, -9.10169780e-02f, -3.40051919e-01f, 8.96369100e-01f, 9.89639480e-03f, 1.13614416e+00f, 1.82508692e-01f, -8.36269736e-01f,
  8.15221846e-01f, 6.33726954e-01f, 7.72426546e-01f, 4.49786574e-01f, -3.93895030e-01f, -3.18043649e-01f, -7.74837852e-01f, 9.86651659e-01f, 9.70144928e-01f, -4.04101491e-01f,
  -2.84154594e-01f, -7.80592412e-02f, 3.36760998e-01f, -4.67997909e-01f, 1.03945673e+00f, 4.71495390e-01f, -8.65630880e-02f, 2.76539266e-01f, -6.62155449e-01f, 6.11307612e-03f,
  -7.20393062e-01f, 4.09059197e-01f, 6.61218107e-01f, -6.18668795e-01f, -5.05487740e-01f, 1.11516058e+00f, 1.06171930e+00f, 4.40015107e-01f, 2.74414659e-01f, 1.10894549e+00f,
  -4.30845648e-01f, -2.15050861e-01f, -2.56856471e-01f, 2.00416043e-01f, 2.01152936e-01f, 2.82307088e-01f, -9.77573454e-01f, -1.85511038e-01f, 3.05680096e-01f, 4.95915830e-01f,
  9.89882231e-01f, 2.87482888e-01f, -7.16601074e-01f, 2.44136840e-01f, 6.10929132e-01f, -4.02816176e-01f, -6.60140753e-01f, 1.07016528e+00f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  3.60236615e-01f, -6.03118986e-02f, 5.19543946e-01f, 8.39406729e-01f, -1.85218811e-01f, 4.82689351e-01f, 2.01160580e-01f, 1.26251504e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  -2.80013770e-01f, 9.47513208e-02f, -7.07563818e-01f, -2.48358980e-01f, -6.16326593e-02f, -2.42201596e-01f, 3.58038366e-01f, 4.18890119e-01f, -1.06470585e+00f, 3.13825309e-01f,
  2.80270398e-01f, -1.20284164e+00f, 6.30742550e-01f, -7.62324691e-01f, 1.12791918e-01f, 2.88736932e-02f, -2.40642071e-01f, -7.97311604e-01f, 3.78671318e-01f, -4.60825086e-01f,
  -7.76895881e-01f, 4.68159616e-01f, -9.28524017e-01f, 3.69675979e-02f, 6.88312948e-02f, 5.03230691e-01f, -1.95890278e-01f, -8.10544670e-01f, -6.78112864e-01f, -5.55954278e-01f,
  3.74775380e-01f, 1.44836560e-01f, -2.92528480e-01f, 3.59456509e-01f, -2.63898492e-01f, 4.44310814e-01f, 1.25903940e+00f, -4.36205357e-01f, 3.15532506e-01f, -5.67108512e-01f,
  5.19159079e-01f, -3.13118547e-01f, -1.01000118e+00f, -5.93538344e-01f, -1.12588175e-01f, -3.94331247e-01f, 1.57218337e-01f, 3.87101263e-01f, -3.14622074e-01f, 3.87633920e-01f,
  1.83761306e-02f, -7.46591866e-01f, -1.03623903e+00f, -3.45787466e-01f, 5.70484161e-01f, 3.60639900e-01f, -1.06127167e+00f, -4.66098875e-01f, -5.37078492e-02f, 5.44475734e-01f,
  2.25213766e-01f, -1.09880459e+00f, 5.27985573e-01f, -3.94575566e-01f, 6.73337042e-01f, -4.35070723e-01f, -1.51944488e-01f, 4.67069715e-01f, 8.84646833e-01f, 9.64188814e-01f,
  -1.23027354e-01f, -1.64074957e-01f, -4.67357874e-01f, 5.79684973e-03f, 4.53974307e-01f, -2.17135802e-01f, 6.74706340e-01f, 3.35233480e-01f, -2.50008732e-01f, -8.90073657e-01f,
  1.41003743e-01f, -5.80212414e-01f, 1.82812531e-02f, -4.13632423e-01f, -3.99461001e-01f, -4.88381714e-01f, -5.32279134e-01f, -9.58723545e-01f, -9.03301358e-01f, 4.11852181e-01f,
  -5.35583258e-01f, 4.51221347e-01f, 4.19744670e-01f, 6.52686954e-02f, -4.29545999e-01f, 2.67139435e-01f, -4.76906657e-01f, 7.09750727e-02f, 1.59284193e-02f, 2.18183309e-01f,
  1.00950563e+00f, 9.99811113e-01f, -3.48664135e-01f, 9.77519006e-02f, -5.49123168e-01f, -9.48867500e-01f, -3.18202317e-01f, 4.94973302e-01f, -7.90491521e-01f, 6.51718259e-01f,
  -1.17071772e+00f, 2.51206040e-01f, -1.07439337e-02f, 3.56758863e-01f, -4.12012517e-01f, -4.52197969e-01f, -3.95671010e-01f, -3.17852110e-01f, 2.47142732e-01f, 1.41061708e-01f,
  4.87478822e-01f, -3.92831713e-01f, -1.60154474e+00f, -4.05073494e-01f, -1.88972309e-01f, -4.61611062e-01f, 8.15072834e-01f, -6.40686929e-01f, -1.69035286e-01f, -2.06656456e-01f,
  3.08442980e-01f, -4.20312762e-01f, -1.09056807e+00f, 5.61287999e-01f, -3.39353025e-01f, -4.37303245e-01f, -7.53676370e-02f, -2.99885660e-01f, -1.11729360e+00f, -8.12069356e-01f,
  -5.97053111e-01f, 3.64516199e-01f, -6.22410476e-01f, 7.00316370e-01f, -6.18098795e-01f, 5.23243666e-01f, 1.04919150e-01f, 4.80867058e-01f, 3.25480402e-01f, -9.61747885e-01f,
  -8.21040750e-01f, -3.76207829e-01f, 1.64180830e-01f, -1.18570948e+00f, 9.45962250e-01f, -8.50353956e-01f, -1.08629143e+00f, 5.10302663e-01f, -5.17309308e-01f, -4.87940192e-01f,
  3.18630040e-01f, -9.00278687e-02f, 3.65442514e-01f, 5.77920437e-01f, 1.25670612e+00f, -6.96540236e-01f, 7.33328521e-01f, 7.12558568e-01f, 6.09757721e-01f, -4.91170555e-01f,
  5.13073325e-01f, -5.78679800e-01f, -3.71540666e-01f, -9.61004019e-01f, 2.47652188e-01f, -8.98376405e-01f, 6.38487697e-01f, 6.10795081e-01f, 6.55077577e-01f, 6.05142713e-01f,
  -7.24303305e-01f, -9.31855977e-01f, 9.34241652e-01f, 4.22549874e-01f, -7.66624093e-01f, -7.52142012e-01f, 4.69970882e-01f, 9.87613618e-01f, -1.13484931e+00f, 1.13664001e-01f,
  -8.78638923e-01f, -1.31493664e+00f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.69682667e-01f, 6.00501634e-02f, -3.55725922e-02f, 2.99951226e-01f, -6.31439760e-02f, -8.24705064e-02f, -4.56308126e-02f, -1.42621368e-01f, -1.41528502e-01f, 1.06797125e-02f,
  2.22100064e-01f, 5.37768483e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    