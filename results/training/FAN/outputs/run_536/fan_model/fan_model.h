/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 38 x 120)
const int L0_fan_Wp_rows = 38;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.99493521e-01f, 1.56843185e-01f, -4.45333868e-01f, -3.38334590e-01f, -4.35395017e-02f, 1.40061110e-01f, -1.32500827e-02f, 3.04511823e-02f, -1.29529685e-01f, 3.65011901e-01f,
  1.60653695e-01f, -2.72813082e-01f, 2.49741003e-01f, -1.32938117e-01f, -4.06411141e-01f, 1.17794149e-01f, 8.93769115e-02f, 1.15979157e-01f, -1.07180960e-01f, -2.03594677e-02f,
  -1.36180907e-01f, 2.28278965e-01f, -2.48888001e-01f, 9.77749228e-02f, -1.11910336e-01f, -1.00191124e-01f, 1.11282848e-01f, -7.87039846e-02f, 2.81217750e-02f, -5.92479706e-02f,
  -3.46178338e-02f, -3.74721214e-02f, -4.89221141e-02f, -4.51914892e-02f, 1.39973521e-01f, 4.87242639e-02f, 3.66810709e-02f, -1.27203703e-01f, -1.67131200e-01f, 2.36539412e-02f,
  3.66472639e-02f, -6.11496381e-02f, 1.98689699e-02f, -5.39623164e-02f, -4.00277264e-02f, -9.04548615e-02f, -4.66705374e-02f, 3.52874286e-02f, -1.09143965e-01f, 3.03517133e-02f,
  1.27771422e-02f, 9.36078727e-02f, 1.30152088e-02f, 2.32515335e-02f, -1.53644219e-01f, -3.93064171e-02f, -4.38739024e-02f, 1.95896924e-02f, -1.03226211e-02f, 4.41570207e-02f,
  8.26934576e-02f, 6.78075776e-02f, -2.49613822e-02f, -3.26178558e-02f, -4.13203947e-02f, 3.78887095e-02f, 9.81319509e-03f, 3.43080238e-02f, -9.18481797e-02f, 9.10911988e-03f,
  1.78857110e-02f, -4.80117574e-02f, 6.95091113e-02f, 5.34256622e-02f, 4.07883245e-03f, -4.32364922e-03f, 1.83750317e-02f, 5.96469715e-02f, 5.59576787e-02f, 2.41889730e-02f,
  -1.10384468e-02f, -1.54006556e-02f, -2.21256763e-02f, 2.59943139e-02f, 7.68023282e-02f, 1.78878829e-02f, 1.66074634e-02f, -1.08461268e-02f, 1.40565420e-02f, -3.12797120e-03f,
  1.32608771e-01f, 1.93445802e-01f, 2.15564165e-02f, 1.03284083e-02f, 1.76718254e-02f, 6.19130805e-02f, -1.06780622e-02f, 4.47890311e-02f, -8.65461156e-02f, 1.51400808e-02f,
  5.29287159e-02f, 4.83273305e-02f, 2.90881749e-02f, 5.45415245e-02f, -8.64541233e-02f, 8.73479843e-02f, 6.77421838e-02f, -7.29403598e-03f, 9.09495875e-02f, 2.88354885e-02f,
  5.29014179e-03f, 8.38648900e-03f, -8.42269138e-03f, 4.54221107e-02f, 7.20268190e-02f, 4.63466309e-02f, -1.90568157e-03f, -2.16643303e-03f, 4.25253548e-02f, -2.97102667e-02f,
  -3.84268202e-02f, 9.57098007e-02f, -1.48059815e-01f, 1.24019636e-02f, 1.18676655e-01f, -5.32772541e-02f, 1.64453611e-01f, 7.89071321e-02f, -2.99327612e-01f, 1.89827979e-01f,
  2.47693047e-01f, -3.84598792e-01f, 1.29867435e-01f, 1.48334935e-01f, -2.44570926e-01f, -1.44333676e-01f, 1.38722077e-01f, -9.07861721e-03f, -2.03867793e-01f, 1.32279932e-01f,
  -1.58201396e-01f, 2.99223036e-01f, 2.33109266e-01f, 3.91240753e-02f, 3.55242491e-01f, -8.65047947e-02f, 4.00856048e-01f, 9.43860132e-03f, 1.51289850e-01f, -3.90961953e-02f,
  7.29074478e-02f, 6.71183094e-02f, -7.64817884e-03f, -1.79557502e-01f, 8.59328881e-02f, 5.25825657e-02f, -1.23845674e-02f, -4.46646772e-02f, -1.97022669e-02f, 3.44082750e-02f,
  -1.51192013e-03f, -4.16186191e-02f, -1.27094403e-01f, 2.01539719e-03f, -1.07093956e-02f, -1.34573858e-02f, 7.58447945e-02f, 7.98280016e-02f, -1.25703678e-01f, 1.04307532e-01f,
  1.65437325e-03f, -5.82462642e-03f, -3.71317714e-02f, -7.65610486e-02f, -1.11435317e-02f, -7.58753642e-02f, -5.43473065e-02f, 4.81361747e-02f, -5.80175174e-03f, -6.62625879e-02f,
  -1.16346665e-02f, -1.26340268e-02f, 1.83379073e-02f, 6.24131747e-02f, -4.80780564e-02f, 3.47837768e-02f, -5.86844273e-02f, 7.19328374e-02f, -4.09097299e-02f, -1.03656482e-02f,
  6.31746873e-02f, -1.81241613e-02f, 3.37889902e-02f, 8.60430226e-02f, 6.50190637e-02f, -6.25286847e-02f, -4.93681505e-02f, -2.53106598e-02f, -3.22366506e-02f, 4.78048772e-02f,
  7.45199099e-02f, -1.60625670e-02f, -7.99978524e-03f, 5.57173342e-02f, -6.26540631e-02f, 6.12091739e-03f, 2.43496206e-02f, 2.22789645e-02f, 1.03787854e-01f, -1.96621884e-02f,
  -1.20010465e-01f, -1.20116267e-02f, -6.57462627e-02f, -2.13746056e-02f, -2.12287940e-02f, 3.34604234e-02f, 3.46666351e-02f, 1.01570180e-02f, -8.86864588e-02f, -3.20367590e-02f,
  -9.14982334e-03f, 7.50330761e-02f, -5.28186597e-02f, 7.35367322e-03f, -6.19327314e-02f, 3.85167599e-02f, 6.34153897e-04f, -5.20149730e-02f, 7.92530552e-02f, -3.88627462e-02f,
  1.18137375e-01f, -1.12909954e-02f, -4.28487770e-02f, 2.13574637e-02f, 1.91839039e-02f, 1.47764627e-02f, -1.00950070e-01f, -8.60900357e-02f, 4.61763963e-02f, -1.02334609e-02f,
  -1.62553653e-01f, -5.94930686e-02f, -2.49173611e-01f, -1.11320846e-01f, -4.87941578e-02f, -2.56799281e-01f, -2.78943330e-01f, 1.08043086e-02f, -3.25419903e-01f, 3.61768723e-01f,
  1.18914202e-01f, 5.94660044e-02f, 6.05445132e-02f, 4.13133800e-02f, -2.37545967e-01f, -2.37681538e-01f, -1.72376007e-01f, -5.04777320e-02f, -2.09796607e-01f, -5.40660359e-02f,
  -1.23472460e-01f, 1.89750627e-01f, -1.66946426e-01f, 2.02932253e-01f, -1.79799553e-02f, 4.33679111e-02f, 3.07016999e-01f, -1.09511450e-01f, 2.33712390e-01f, 8.21122527e-03f,
  1.12507390e-02f, 8.22449327e-02f, 1.09939668e-02f, -7.74656385e-02f, -6.60527498e-02f, -2.44825203e-02f, 6.14319108e-02f, -3.81246693e-02f, -2.90298294e-02f, -4.74734344e-02f,
  5.06954007e-02f, 8.28630850e-02f, 1.44162038e-02f, -1.76375210e-02f, 5.99496532e-03f, 8.23320895e-02f, -9.00219977e-02f, 1.78995579e-02f, 6.57413751e-02f, -1.28692806e-01f,
  -5.10445572e-02f, -3.66609567e-03f, -5.71708083e-02f, 7.69800395e-02f, -6.07317388e-02f, -5.33207096e-02f, -9.02523324e-02f, -2.55719796e-02f, -6.35799393e-02f, -3.78628336e-02f,
  8.22130740e-02f, -9.74028185e-02f, 7.67488405e-03f, 3.76314111e-02f, -1.72428470e-02f, 1.62671786e-02f, 1.85699947e-02f, 8.53974149e-02f, -8.69060680e-02f, 4.37073037e-02f,
  1.12161431e-02f, -2.25878730e-02f, -8.03916622e-03f, -9.89990076e-04f, 3.85519080e-02f, 3.27400975e-02f, 3.40459272e-02f, 7.94322975e-03f, -3.98381986e-02f, -1.38436386e-03f,
  1.07988119e-02f, -2.43449155e-02f, -3.74125689e-02f, 8.16629529e-02f, -6.05856255e-02f, -2.77526062e-02f, 1.07246883e-01f, -3.10767666e-02f, -4.19921018e-02f, 2.19921465e-03f,
  -7.90962055e-02f, -1.48849413e-01f, -2.63542216e-02f, 6.61576092e-02f, 3.89433540e-02f, 1.08476274e-01f, -2.95116380e-02f, 1.81696806e-02f, -5.59681915e-02f, -2.14185212e-02f,
  7.66501203e-02f, 8.36960152e-02f, 7.35920891e-02f, -4.14874479e-02f, 3.09840981e-02f, -2.78821252e-02f, 4.90469523e-02f, -2.74307206e-02f, -4.85683344e-02f, 7.76444823e-02f,
  1.06979639e-03f, 5.59450462e-02f, 6.31534979e-02f, 2.58914493e-02f, 7.40732476e-02f, 7.66982809e-02f, 7.90123120e-02f, -4.05566096e-02f, 8.68605524e-02f, -5.02210371e-02f,
  2.65119851e-01f, -2.99328238e-01f, 1.04490370e-02f, 6.77498654e-02f, 2.39165559e-01f, 2.70119816e-01f, 5.28881103e-02f, 1.32219583e-01f, -7.50981867e-02f, -1.16076156e-01f,
  1.59682170e-01f, -2.41493881e-01f, -7.95607269e-02f, 2.14837841e-03f, 2.89438814e-01f, -2.13902995e-01f, 2.71569937e-01f, 9.10978615e-02f, -1.07958764e-01f, 2.54893184e-01f,
  1.21019520e-02f, 1.38718769e-01f, 4.67216894e-02f, 1.42852604e-01f, 2.57683516e-01f, 2.85506994e-02f, 1.52172014e-01f, -2.54855435e-02f, 1.51640117e-01f, -2.94503644e-02f,
  2.53201369e-02f, -6.52660728e-02f, 4.22806032e-02f, -9.16171703e-04f, 2.29905814e-01f, 1.80432778e-02f, 1.08568653e-01f, -1.69527903e-02f, 6.51035160e-02f, -5.96923158e-02f,
  5.04250601e-02f, -1.61622185e-02f, -1.88410375e-02f, -7.69661069e-02f, 3.09840068e-02f, -3.19559574e-02f, -4.50941250e-02f, 1.30830050e-01f, -8.48716646e-02f, -5.42366430e-02f,
  -9.15525034e-02f, -1.63432248e-02f, 3.97471897e-02f, -2.21675280e-02f, -1.83543544e-02f, 1.82374695e-03f, -4.16619256e-02f, 5.09608909e-03f, 1.25256823e-02f, 9.76930093e-03f,
  5.82615808e-02f, 7.79807940e-02f, 1.49207879e-02f, 6.06615213e-04f, 6.60531148e-02f, 2.19119880e-02f, -2.77130175e-02f, -4.65483777e-02f, -7.17242733e-02f, 3.34740356e-02f,
  7.19427988e-02f, -8.03973526e-02f, -4.55355160e-02f, -3.13331522e-02f, 3.46922353e-02f, 1.03296982e-02f, 5.83354831e-02f, -4.24190536e-02f, 4.52712476e-02f, 3.67720425e-02f,
  -2.47475021e-02f, 4.03202660e-02f, -4.40867841e-02f, 2.08054744e-02f, 5.85331917e-02f, -5.56559749e-02f, -9.34922621e-02f, -5.75231723e-02f, 2.27233730e-02f, 8.32803771e-02f,
  1.30938485e-01f, 1.54602811e-01f, -1.80540103e-02f, -8.46361462e-03f, -6.28686398e-02f, 2.07965337e-02f, -3.74902785e-02f, -5.01492843e-02f, -1.22432122e-02f, 1.17256477e-01f,
  4.73213643e-02f, 3.53494510e-02f, 9.43218768e-02f, -6.77932873e-02f, 6.52560890e-02f, 1.28894942e-04f, 1.07902691e-01f, -4.28368077e-02f, 1.37895226e-01f, 7.45666726e-03f,
  1.44488156e-01f, 6.15088940e-02f, 3.19245718e-02f, 2.98574846e-02f, 2.64769457e-02f, -2.78031081e-03f, 1.27619699e-01f, -1.16313584e-01f, 5.24776056e-02f, 2.87802722e-02f,
  3.29040825e-01f, -3.31353247e-01f, 1.19306847e-01f, -2.48101056e-01f, 1.99599266e-01f, 8.04907382e-02f, -1.53738141e-01f, -3.96258980e-02f, 2.00609397e-02f, -2.54889429e-01f,
  -1.52886987e-01f, -6.50734361e-03f, -1.20735206e-01f, -3.55484873e-01f, 8.46491307e-02f, -2.96397418e-01f, -2.49052554e-01f, -9.42110270e-02f, -1.80167109e-02f, 6.50250912e-02f,
  7.74658397e-02f, -2.05184788e-01f, -1.54896483e-01f, 8.85849632e-03f, 2.59971414e-02f, 8.19904879e-02f, 1.24926027e-02f, 2.04544235e-02f, -1.84962183e-01f, -1.88392140e-02f,
  1.31787911e-01f, 6.96423501e-02f, 1.10928155e-01f, 9.59797949e-02f, -4.35831817e-03f, 1.05570637e-01f, 4.32995334e-02f, 2.57166792e-02f, 2.51348261e-02f, 2.21662447e-02f,
  1.92979984e-02f, 7.19708428e-02f, -4.42434102e-02f, 5.74397929e-02f, -2.37755268e-03f, -5.65734273e-03f, -7.11441562e-02f, -1.96716487e-02f, -1.18240621e-02f, -5.89702800e-02f,
  -9.29209590e-02f, -2.21740678e-02f, 2.87283342e-02f, -2.85045262e-02f, 2.47802809e-02f, -8.68633613e-02f, 4.09024134e-02f, 5.74471503e-02f, 7.30293849e-03f, 8.43240842e-02f,
  4.58236597e-02f, 2.96590198e-02f, 1.63466465e-02f, -5.84424511e-02f, 1.42856557e-02f, 6.67987438e-03f, -3.79672833e-02f, -2.60794163e-02f, -4.11979035e-02f, -2.69011222e-02f,
  -9.85300541e-03f, -6.38073832e-02f, 5.94853535e-02f, -1.60707738e-02f, -2.80095562e-02f, 7.21550956e-02f, 3.50464298e-03f, -2.72602048e-02f, -1.61340144e-02f, 3.11457962e-02f,
  -4.39081937e-02f, 1.83493400e-03f, -1.01029374e-01f, 7.37430230e-02f, 2.71202978e-02f, -1.22813415e-02f, -4.57154866e-03f, -3.67568508e-02f, 5.74261695e-02f, 4.17317413e-02f,
  2.01092977e-02f, -2.91781966e-02f, -4.81939204e-02f, -1.42202014e-02f, -2.81726592e-03f, -2.89163664e-02f, 6.42083585e-02f, 2.10599750e-02f, -5.51234260e-02f, 2.21605562e-02f,
  7.04679340e-02f, -1.61896981e-02f, 1.22487172e-01f, -1.36541128e-02f, 3.63427156e-04f, -5.43472052e-05f, 2.48068362e-03f, 1.96407046e-02f, 4.62580025e-02f, -8.51541385e-03f,
  1.24239763e-02f, 3.95811256e-03f, -6.04528114e-02f, -2.18162742e-02f, 3.42958607e-02f, 2.14352552e-03f, 8.40105638e-02f, -2.95013357e-02f, -7.03802481e-02f, -6.75474703e-02f,
  5.23895435e-02f, -2.62786031e-01f, 2.65649050e-01f, 2.54708380e-01f, 3.59659316e-03f, -3.63296010e-02f, 2.70149082e-01f, -8.54076445e-02f, -9.06568989e-02f, -2.02222511e-01f,
  1.10768922e-01f, -1.56098038e-01f, 5.90893328e-02f, -3.64978835e-02f, 3.02169263e-01f, 1.24709561e-01f, -5.67441694e-02f, -3.28218900e-02f, 1.29366172e-02f, -6.66032210e-02f,
  8.24459940e-02f, -9.56057087e-02f, 3.93383235e-01f, -1.97528705e-01f, 9.62264016e-02f, 9.40859541e-02f, 1.14140615e-01f, 1.84477530e-02f, -1.38221094e-02f, 8.33836850e-03f,
  -5.33795767e-02f, 4.22844738e-02f, 9.75090787e-02f, -4.09034230e-02f, 2.93737277e-02f, -3.29864887e-03f, 5.89176156e-02f, 7.68867657e-02f, 1.24083124e-01f, 4.48798835e-02f,
  -2.75434330e-02f, -8.70480575e-03f, 1.27077727e-02f, -7.62103051e-02f, -2.53627338e-02f, -4.68437374e-03f, -2.69587226e-02f, 6.92852363e-02f, 9.05342400e-03f, 1.95627719e-01f,
  1.20673746e-01f, 1.11785270e-01f, 6.49566129e-02f, 3.70023586e-02f, 1.08150132e-02f, 8.20095465e-02f, 5.69077320e-02f, 3.77599522e-02f, -6.62184358e-02f, 4.51089162e-03f,
  5.35282120e-02f, -5.74042574e-02f, 7.51751382e-03f, 8.30448046e-03f, -2.48428844e-02f, 2.20885221e-03f, 1.39286323e-02f, 9.97612998e-03f, -1.67366117e-02f, -2.07846593e-02f,
  -2.43909657e-02f, -1.93333030e-02f, -4.10367036e-03f, 6.55629337e-02f, 1.55142099e-02f, 2.25209538e-02f, 1.09762706e-01f, -1.12032145e-01f, 3.89436558e-02f, 3.93922776e-02f,
  1.44725638e-02f, -2.34064944e-02f, -9.61491093e-02f, 1.99238602e-02f, -9.54982173e-03f, 4.76873331e-02f, -6.12814613e-02f, 3.65181789e-02f, 7.03710169e-02f, 5.96473776e-02f,
  -3.19116652e-01f, -3.78063083e-01f, 1.96116865e-02f, -3.25854085e-02f, -6.15459727e-03f, 5.01450524e-03f, -1.44296810e-02f, -4.90528084e-02f, -1.15171216e-01f, -4.83130515e-02f,
  -5.53974807e-02f, 2.04042718e-02f, -9.82709825e-02f, 2.31317263e-02f, -6.54341877e-02f, -3.62764485e-03f, -6.81672171e-02f, -8.08176845e-02f, -8.19555297e-02f, -1.05543457e-01f,
  9.69419349e-03f, 2.62848777e-03f, 3.77931446e-02f, -3.36918682e-02f, -3.70303504e-02f, 9.75597128e-02f, -9.31886882e-02f, 5.73000535e-02f, -3.35760526e-02f, -6.03900030e-02f,
  8.44773874e-02f, -3.58942300e-01f, 3.02219480e-01f, 1.10453434e-01f, 7.75497258e-02f, 8.33843835e-03f, 1.18599698e-01f, -1.55252784e-01f, 5.62093705e-02f, -3.89413029e-01f,
  -1.03230342e-01f, -1.45100743e-01f, -1.99526265e-01f, 1.23572703e-02f, 2.83776700e-01f, 1.16804659e-01f, -1.38467088e-01f, -2.23648045e-02f, 2.24589743e-02f, -1.05121151e-01f,
  7.80743361e-02f, -1.25554847e-02f, 1.33728474e-01f, -6.69701248e-02f, -1.17910299e-02f, 1.17345437e-01f, -9.39665139e-02f, 1.30534455e-01f, -4.34643663e-02f, 1.03513010e-01f,
  -3.54936942e-02f, -8.68168101e-02f, -9.21763033e-02f, -4.57581468e-02f, -4.58171330e-02f, -6.21512346e-02f, 1.37240710e-02f, 7.24867880e-02f, 6.73044547e-02f, 2.60874685e-02f,
  -5.13241291e-02f, 9.76053849e-02f, 8.85429904e-02f, 8.79402608e-02f, -8.20404813e-02f, 3.96449380e-02f, -1.34179713e-02f, 1.00411801e-02f, -8.38875845e-02f, 4.10572402e-02f,
  7.55000103e-04f, -1.43688833e-02f, -5.13059124e-02f, -4.48564179e-02f, 6.52744696e-02f, 1.97984297e-02f, 1.09313995e-01f, 5.25488220e-02f, -1.00908831e-01f, 5.75126149e-02f,
  1.33687064e-01f, -5.47831468e-02f, -8.21253806e-02f, -1.77979842e-02f, -6.16890118e-02f, 3.98176536e-03f, -7.94480518e-02f, -1.27001517e-02f, 1.66761242e-02f, -6.35811388e-02f,
  5.48077747e-02f, -1.32218795e-02f, -4.32880484e-02f, 4.99537773e-02f, -1.43035157e-02f, -5.66726876e-03f, 5.67583330e-02f, -6.88717961e-02f, 3.54543664e-02f, 4.28590849e-02f,
  -7.58829787e-02f, 2.52150744e-02f, -8.88257623e-02f, 7.80309513e-02f, -5.40342480e-05f, -7.01791514e-03f, -7.88323730e-02f, -1.72150489e-02f, -3.20851454e-03f, 1.12184687e-02f,
  -2.63249546e-01f, -1.38080671e-01f, -4.92704771e-02f, -5.62092401e-02f, -3.81838121e-02f, -4.62134592e-02f, 8.70751441e-02f, -4.65829158e-03f, -1.09841302e-01f, -7.23463669e-02f,
  -4.42080237e-02f, 2.93267537e-02f, -6.38591945e-02f, 7.48172924e-02f, -4.16514352e-02f, -2.52907630e-02f, -5.23853637e-02f, -1.01446480e-01f, -1.26648918e-01f, -1.30977392e-01f,
  -1.45177066e-01f, -6.37349039e-02f, 9.81819406e-02f, 2.90500131e-02f, 5.07294796e-02f, -4.56762649e-02f, -9.01885852e-02f, 1.44032547e-02f, 1.27182901e-01f, -6.68595284e-02f,
  -1.21916637e-01f, -4.74129558e-01f, 9.52852890e-02f, -1.54898360e-01f, 1.22919515e-01f, 4.45348114e-01f, 1.78868204e-01f, 4.72806990e-02f, -1.96016937e-01f, -2.42126152e-01f,
  7.78969675e-02f, -3.36640805e-01f, -7.89525583e-02f, -3.56649876e-01f, 3.24063241e-01f, -3.14296857e-02f, -1.35244448e-02f, -1.35149524e-01f, -1.05768256e-01f, -1.82283930e-02f,
  5.85396253e-02f, -3.46486807e-01f, 6.30484670e-02f, -1.07354164e-01f, -1.01162620e-01f, -4.32851240e-02f, 2.66984832e-02f, 1.44234374e-01f, -1.90906096e-02f, 2.15054434e-02f,
  2.94862166e-02f, -1.79080039e-01f, 4.82485741e-02f, -1.01681396e-01f, 1.46730497e-01f, 1.19516537e-01f, 9.66927409e-02f, 1.64115764e-02f, -1.52693186e-02f, -2.88862139e-02f,
  -9.12846923e-02f, -6.56548515e-02f, -6.37754798e-02f, -6.17186539e-02f, -1.83726456e-02f, -2.18700301e-02f, 5.90996109e-02f, 5.82787767e-02f, 2.09418288e-03f, -3.71299088e-02f,
  5.92267178e-02f, 5.48896827e-02f, 6.64042681e-02f, -9.70977843e-02f, 6.64336309e-02f, -6.26455024e-02f, 3.39751020e-02f, 4.39538360e-02f, 2.39809770e-02f, -1.58058554e-02f,
  -7.21684918e-02f, -1.29746556e-01f, 3.45372744e-02f, -6.73926696e-02f, -2.54152771e-02f, 1.19856082e-01f, -6.05056947e-03f, 5.68429343e-02f, -2.21039448e-02f, 5.34735098e-02f,
  5.97316585e-02f, 5.60456514e-02f, -1.36621315e-02f, -1.36711216e-02f, -9.46237892e-03f, 4.62417454e-02f, 7.18514174e-02f, -1.09278314e-01f, 1.30337372e-01f, 4.88156490e-02f,
  -1.08300172e-01f, -1.38623603e-02f, 5.17018512e-02f, 6.97539076e-02f, -1.81159154e-02f, -7.20749958e-04f, -7.95886442e-02f, 8.32202379e-03f, -1.26103647e-02f, 2.92015634e-02f,
  2.02380344e-02f, -2.67466545e-01f, 2.28386745e-02f, 6.88708499e-02f, -4.99740541e-02f, 1.33401230e-01f, -8.75637680e-02f, 2.71910932e-02f, -3.68377082e-02f, -1.71870235e-02f,
  -6.44860091e-03f, 3.70859019e-02f, -7.13316053e-02f, -3.22785452e-02f, 4.64356467e-02f, -2.63376012e-02f, -1.59190983e-01f, -3.11882049e-02f, 1.01032466e-01f, 3.52399200e-02f,
  -4.20456193e-02f, -3.49856168e-02f, 1.22805960e-01f, 6.64476529e-02f, 1.91189200e-02f, 9.52962507e-03f, -7.80236647e-02f, 5.66451922e-02f, -1.63809787e-02f, -6.81178346e-02f,
  3.92465830e-01f, -1.49568710e-02f, 3.42998803e-02f, 3.10227543e-01f, 1.14279874e-02f, 1.38029456e-01f, 2.05467686e-01f, 9.76598337e-02f, -3.79054397e-02f, -1.36023223e-01f,
  9.24138501e-02f, 7.43792132e-02f, -5.19494899e-02f, 2.95416951e-01f, 3.84932160e-01f, -8.34566280e-02f, 2.55179286e-01f, 1.14990242e-01f, -1.06717609e-01f, 1.30339488e-01f,
  1.21718384e-01f, 1.79082990e-01f, 1.52456835e-01f, -9.63495597e-02f, 2.37843052e-01f, -1.61390871e-01f, -4.76855151e-02f, -7.56069198e-02f, 1.42992213e-01f, 1.01736888e-01f,
  7.62195885e-02f, 1.11441374e-01f, 1.91422012e-02f, -2.47355946e-03f, 4.76982370e-02f, -5.01639284e-02f, -3.99145596e-02f, 4.50685360e-02f, -6.08309284e-02f, -2.55885031e-02f,
  -5.46777546e-02f, 1.67044643e-02f, -3.35640111e-03f, 7.08146580e-03f, 3.00995670e-02f, -3.51672508e-02f, 2.62885485e-02f, 3.61989103e-02f, 5.73132038e-02f, 6.63160607e-02f,
  7.17991069e-02f, -3.90498247e-03f, 7.69024193e-02f, -4.18623872e-02f, 1.14127314e-02f, 1.84168275e-02f, -4.28926162e-02f, -6.72420114e-02f, -5.41079752e-02f, 6.30763769e-02f,
  9.67075825e-02f, -5.57241216e-02f, 2.34144442e-02f, 2.36026365e-02f, 4.90332507e-02f, 2.79884785e-02f, -3.74574177e-02f, -3.37926485e-03f, -3.50897945e-02f, 2.60764323e-02f,
  -8.69201310e-03f, 5.19087873e-02f, -8.06004833e-03f, -6.15416327e-03f, 5.91173815e-03f, 5.32327294e-02f, 6.08963710e-05f, 1.62397921e-02f, -3.83160375e-02f, 2.00369433e-02f,
  -5.90489730e-02f, -6.42113201e-03f, -9.32313651e-02f, 2.44305450e-02f, 1.06026679e-02f, -1.72473621e-02f, -4.10717763e-02f, 4.23921607e-02f, -7.42281228e-02f, 4.47993241e-02f,
  -4.60737236e-02f, -6.87827319e-02f, -7.08094314e-02f, -5.03317378e-02f, -1.53189870e-02f, -4.68754163e-03f, 7.66000673e-02f, 2.65868567e-02f, 2.56718416e-02f, 4.46395054e-02f,
  5.48806973e-02f, -3.44408005e-02f, -1.04053415e-01f, 2.95732860e-02f, -1.68953999e-03f, 6.32387474e-02f, -3.55358236e-02f, -1.12954676e-01f, -4.48910929e-02f, 3.68285477e-02f,
  -4.80415020e-03f, -9.90610011e-03f, -1.24922814e-02f, -8.83228052e-03f, 2.54222229e-02f, -1.95019525e-02f, 5.90445474e-02f, -2.65325662e-02f, 3.02465595e-02f, -9.32986066e-02f,
  4.37731475e-01f, 3.00800830e-01f, 8.70020986e-02f, -7.50104012e-03f, 2.43187621e-02f, 2.45733663e-01f, 6.30601123e-02f, 2.24954218e-01f, 2.59266853e-01f, -9.53654721e-02f,
  -1.75267577e-01f, 2.38246754e-01f, -5.66856973e-02f, -6.38160408e-02f, 2.59393096e-01f, -1.61620751e-02f, 3.53765637e-02f, 2.99047511e-02f, 3.11760930e-03f, 1.97374761e-01f,
  1.34782597e-01f, -1.72629431e-01f, -6.47101030e-02f, 9.57184192e-03f, 1.64961204e-01f, 5.67789599e-02f, -1.51674047e-01f, -1.22819722e-01f, -9.03519019e-02f, -2.59025805e-02f,
  1.68613419e-01f, 6.77163675e-02f, 5.52326208e-03f, 9.05251317e-03f, 6.65299501e-03f, -1.01418920e-01f, 9.45558678e-03f, -6.77463263e-02f, -5.59336394e-02f, -8.71150289e-03f,
  2.96426541e-03f, 2.09794622e-02f, -3.02926134e-02f, -1.02967583e-01f, 1.50143877e-01f, -1.57407636e-03f, 1.12740118e-02f, -7.78513029e-04f, 1.60761122e-02f, 5.13643492e-03f,
  5.95186390e-02f, 5.90229183e-02f, 6.59812018e-02f, 2.07902603e-02f, 6.47296011e-02f, -4.36349623e-02f, -3.23518552e-02f, 4.70006242e-02f, 6.52728155e-02f, 9.09565017e-02f,
  4.23000678e-02f, -6.32397272e-03f, 2.93351710e-03f, 2.90762279e-02f, 5.47850542e-02f, -3.64133976e-02f, -5.59969582e-02f, 3.10700643e-03f, -1.71822938e-03f, 5.72665520e-02f,
  2.15804465e-02f, 3.22687551e-02f, 1.06135877e-02f, -1.99227594e-02f, -1.75896324e-02f, 4.12143581e-02f, -3.01268548e-02f, 4.66443785e-02f, 5.17348014e-02f, -1.34895165e-02f,
  -1.82072725e-02f, 6.76141158e-02f, 2.43911170e-03f, 3.29416059e-02f, -8.03712290e-03f, 9.11030024e-02f, -1.80655885e-02f, 2.87179351e-02f, -3.61375399e-02f, -3.06712445e-02f,
  2.83546746e-01f, 2.28429303e-01f, 1.12043293e-02f, -4.21376564e-02f, -9.94014787e-04f, 1.91985313e-02f, -8.38279352e-02f, 5.34748733e-02f, 8.04189444e-02f, 9.72990256e-06f,
  -4.89208624e-02f, -4.57461216e-02f, 6.11857399e-02f, 1.62800234e-02f, 2.70142080e-03f, 4.50142734e-02f, -6.93955049e-02f, -1.87881254e-02f, 4.91556302e-02f, -2.95050722e-03f,
  -6.30528927e-02f, -5.66749759e-02f, -8.02301690e-02f, -4.74225469e-02f, -5.81093915e-02f, 7.80344103e-03f, 6.51117563e-02f, 1.19041055e-02f, -3.56385559e-02f, -1.03895657e-01f,
  -3.14532727e-01f, 6.51274547e-02f, -1.33654311e-01f, 1.64716840e-02f, 1.47423074e-01f, -3.47644776e-01f, -2.27172419e-01f, 1.44731849e-01f, 1.39828295e-01f, 1.78678468e-01f,
  4.37478498e-02f, -2.33652294e-01f, 6.04455918e-02f, -3.21349025e-01f, -4.80589122e-01f, -1.36860460e-01f, -4.23323423e-01f, -2.09190309e-01f, 7.03532398e-02f, 3.98173705e-02f,
  2.50827484e-02f, 7.92153999e-02f, -9.93172899e-02f, 2.40087092e-01f, 7.14756697e-02f, 2.37250775e-01f, 1.98942423e-01f, 1.26481697e-01f, -2.74941958e-02f, -1.24280751e-01f,
  -3.72176543e-02f, 2.03400582e-01f, 8.30223691e-03f, -4.33121771e-02f, -3.68370265e-02f, 5.40923066e-02f, -8.83093849e-02f, -4.38707210e-02f, -7.98121188e-03f, -1.01562003e-02f,
  -6.45060614e-02f, -3.01572140e-02f, -4.43599261e-02f, 5.55434451e-02f, 7.16065168e-02f, 1.48438746e-02f, -5.35677709e-02f, -4.29387912e-02f, 1.67030878e-02f, -1.58135891e-01f,
  -9.30595398e-03f, -8.41462389e-02f, -8.53141248e-02f, -3.07502095e-02f, -3.16206329e-02f, -4.53674905e-02f, -3.62320021e-02f, -1.13466226e-01f, -4.92253155e-02f, -2.13242844e-02f,
  4.97239567e-02f, 4.28611133e-03f, 1.28283387e-03f, 1.06362753e-01f, 2.80234739e-02f, 9.10367370e-02f, 6.96112681e-03f, 1.29437121e-02f, 4.52922843e-02f, -1.44417007e-02f,
  -1.29377767e-02f, 4.00626659e-02f, 6.55117407e-02f, 5.59904166e-02f, 1.00693479e-02f, 1.12719648e-02f, -9.35832933e-02f, -1.05620744e-02f, 4.06597741e-02f, 3.12227476e-02f,
  4.47445475e-02f, -6.55760616e-02f, 2.10810639e-02f, -3.49226333e-02f, -5.39892428e-02f, 5.80208823e-02f, 8.50048140e-02f, 8.03578738e-03f, 5.16479090e-02f, -2.94957515e-02f,
  -1.43637314e-01f, -4.27995324e-02f, 8.81693736e-02f, 4.25340235e-02f, 3.08573376e-02f, -4.33894154e-03f, -5.55206090e-02f, -8.78438447e-03f, -3.20211910e-02f, 2.63355039e-02f,
  3.23214978e-02f, 4.40975130e-02f, 4.43576574e-02f, -9.59171634e-03f, -7.80865327e-02f, -8.84784106e-03f, -2.79918667e-02f, 6.02807365e-02f, -2.83465497e-02f, 5.28084189e-02f,
  -3.30790579e-02f, 3.07861436e-02f, 1.91630367e-02f, 4.39309888e-02f, 6.05720095e-02f, -2.39004400e-02f, -3.28352563e-02f, 8.43634456e-02f, -1.90932304e-02f, -5.14411069e-02f,
  -1.45311236e-01f, 2.47411847e-01f, -1.96207583e-01f, -5.08182384e-02f, -1.71728775e-01f, 7.99476504e-02f, 2.28116646e-01f, -9.17089507e-02f, -9.26637650e-02f, 2.93493629e-01f,
  2.24378720e-01f, -1.31355658e-01f, 1.51736364e-01f, 1.87977359e-01f, 1.99862421e-01f, 1.42442971e-01f, 1.98942527e-01f, 8.32461491e-02f, -5.04398681e-02f, 1.14140965e-01f,
  -1.49327338e-01f, 2.80348182e-01f, 3.92991230e-02f, -3.11107747e-02f, -1.13637242e-02f, -1.44883052e-01f, 2.61507452e-01f, -6.18488677e-02f, 8.52357000e-02f, -1.94932986e-02f,
  4.24192995e-02f, 1.03866253e-02f, -9.49389338e-02f, -3.83031964e-02f, -1.85745321e-02f, -7.63571914e-03f, -1.86750740e-02f, 7.97355995e-02f, 9.58454981e-03f, 1.96357686e-02f,
  2.08672732e-02f, -8.58574584e-02f, -4.72777076e-02f, 3.75032388e-02f, -8.51130933e-02f, -1.20052144e-01f, -7.88045377e-02f, -8.61463472e-02f, -1.91025622e-02f, -1.02260299e-01f,
  -6.18051142e-02f, -8.33059326e-02f, -4.97418642e-02f, -3.30817737e-02f, -8.47653896e-02f, -8.25472027e-02f, -8.59760270e-02f, -4.08747653e-03f, -6.16981229e-03f, -7.02969804e-02f,
  6.43007606e-02f, -4.67700399e-02f, 2.84419414e-02f, -1.37769198e-02f, 3.15913819e-02f, -1.54007003e-02f, -2.72365175e-02f, 4.88790162e-02f, 4.85402532e-03f, 2.14442704e-02f,
  2.13524252e-02f, -3.56691331e-02f, -2.52450537e-02f, -5.27134128e-02f, -3.27271177e-03f, 1.77354030e-02f, -2.33785361e-02f, 2.82307696e-02f, -6.03583381e-02f, -2.14394815e-02f,
  -1.57673273e-03f, 1.00749945e-02f, 5.04900999e-02f, 8.18432588e-03f, 1.39063969e-02f, 5.89266270e-02f, -3.42144109e-02f, -2.93032285e-02f, 3.05529181e-02f, 3.63964513e-02f,
  2.20982417e-01f, 2.65432745e-01f, -3.01698316e-03f, -8.55298806e-03f, 1.47640795e-01f, 4.67831939e-02f, -7.13031599e-03f, -3.38352062e-02f, 1.36552140e-01f, 4.99901734e-03f,
  -8.57139751e-03f, -2.74800807e-02f, 1.17701655e-02f, -2.03188118e-02f, 1.04748130e-01f, 1.66116599e-02f, 6.95470050e-02f, 6.60665333e-02f, 1.18168360e-02f, 2.33965833e-02f,
  7.25379810e-02f, -1.17531661e-02f, -2.71559414e-02f, -6.84941635e-02f, -3.87064330e-02f, -3.89449336e-02f, -3.69218849e-02f, -6.51600361e-02f, -3.95310596e-02f, 6.33889735e-02f,
  1.38555661e-01f, -1.74600363e-01f, 1.59959957e-01f, 2.53518790e-01f, -5.45148412e-03f, 5.56286685e-02f, 8.77367929e-02f, 7.56067783e-02f, 2.70046651e-01f, -2.56448358e-01f,
  -2.76013702e-01f, 2.67553274e-02f, -1.10216394e-01f, -1.31912708e-01f, -2.69361325e-02f, 1.65361643e-01f, 6.09426275e-02f, 9.02203470e-02f, 1.75961673e-01f, -2.07706273e-01f,
  2.04029277e-01f, -3.42092842e-01f, -4.95579131e-02f, -1.29632115e-01f, -6.17839247e-02f, 5.84137067e-02f, -1.30841658e-01f, -3.76094654e-02f, -2.00174108e-01f, -1.24203101e-01f,
  -4.73157428e-02f, 2.62601431e-02f, 6.55055717e-02f, 3.09519190e-02f, 6.69074152e-03f, -3.06353550e-02f, 5.31974696e-02f, -4.26711887e-02f, -2.51459070e-02f, -3.91234793e-02f,
  1.16262473e-02f, 3.99597324e-02f, -3.10917199e-02f, 1.15315281e-01f, 1.44130945e-01f, 6.35231361e-02f, 3.42049599e-02f, -7.77240796e-03f, 4.86316979e-02f, 2.85576023e-02f,
  5.23078516e-02f, 6.55462518e-02f, 1.08020186e-01f, 1.55099127e-02f, -9.04831011e-03f, 3.23104709e-02f, 6.15580156e-02f, 6.89203888e-02f, -6.68787435e-02f, 9.42539275e-02f,
  7.60534108e-02f, 6.02786839e-02f, -3.04714460e-02f, -7.20804706e-02f, -4.52378765e-02f, -9.78395864e-02f, 1.82009675e-02f, -1.20286360e-01f, 9.05475989e-02f, -3.07355188e-02f,
  -7.07744434e-02f, 1.89649258e-02f, 6.75619245e-02f, 1.65030718e-01f, -6.86860681e-02f, 3.79783586e-02f, -2.55304463e-02f, -5.88261075e-02f, 1.00424580e-01f, 7.19974712e-02f,
  1.79199632e-02f, 1.35654323e-02f, -2.92002968e-02f, -2.87702796e-03f, 7.89278839e-03f, -2.67501641e-02f, 3.27559421e-04f, 2.88542863e-02f, 1.71622471e-03f, -5.64973466e-02f,
  -2.12335452e-01f, -2.91436911e-01f, 4.40865345e-02f, -4.48055752e-03f, -7.64667988e-02f, -1.01625994e-02f, 1.20078437e-01f, 6.38281927e-02f, -2.75213625e-02f, -1.08810581e-01f,
  -1.09230196e-02f, -3.34952921e-02f, -9.14089978e-02f, 1.94462314e-02f, 2.51823366e-02f, -3.05822417e-02f, -1.09876625e-01f, 1.07640743e-01f, -1.56457555e-02f, -1.10674441e-01f,
  -8.97241905e-02f, -1.37146696e-01f, -3.79201844e-02f, 4.86440025e-03f, 3.07418518e-02f, -8.21741000e-02f, -3.09428237e-02f, 1.75204664e-01f, -2.47357935e-02f, -2.03332249e-02f,
  -1.64789602e-01f, 4.06144589e-01f, 1.75438449e-01f, -1.53195649e-01f, -7.48494864e-02f, -2.36178622e-01f, -2.94014126e-01f, 1.97180230e-02f, -1.95769556e-02f, -9.31007639e-02f,
  -1.81374490e-01f, 3.29884529e-01f, 1.89682722e-01f, -3.23611468e-01f, -3.06040496e-01f, 6.00282326e-02f, -3.22281063e-01f, -1.02143757e-01f, 1.14657126e-01f, 3.02645359e-02f,
  -7.47697279e-02f, -3.07496130e-01f, 8.41164663e-02f, 8.85541141e-02f, -5.35199838e-03f, 2.45107323e-01f, -1.00490607e-01f, 2.68094987e-01f, -2.45648064e-02f, -3.19209583e-02f,
  -4.06845994e-02f, -3.11673786e-02f, 2.75300629e-02f, 8.33648294e-02f, -8.92685577e-02f, -1.28841922e-02f, -1.11260833e-02f, -1.95217365e-03f, 2.24840790e-02f, 6.37612073e-03f,
  -3.16207819e-02f, 3.66000198e-02f, -2.01894362e-02f, 2.72877477e-02f, 3.39561403e-02f, 4.69862036e-02f, 8.47037137e-02f, -3.26648280e-02f, 9.60599855e-02f, 6.70890138e-02f,
  6.78639635e-02f, -1.89971160e-02f, -4.20378800e-03f, 6.27012998e-02f, -3.78458053e-02f, 1.88279357e-02f, 6.93894997e-02f, 6.88092113e-02f, 3.13390754e-02f, -1.09424731e-02f,
  -1.97698604e-02f, 1.75635368e-02f, 8.68359208e-02f, 1.09983556e-01f, 6.04996756e-02f, 3.45166363e-02f, -4.87116054e-02f, 2.54519507e-02f, 5.36192954e-02f, 4.47912700e-02f,
  -2.84822062e-02f, 3.28367315e-02f, -2.55238526e-02f, 1.19112022e-02f, -3.28059420e-02f, 3.86175215e-02f, 1.91511139e-02f, -7.59931654e-03f, 1.79590192e-02f, -2.09031701e-02f,
  5.16347475e-02f, -3.32273655e-02f, 7.76694417e-02f, -4.53178398e-02f, 2.67044529e-02f, -4.00791205e-02f, 3.49994227e-02f, 8.20332095e-02f, -1.78908296e-02f, -5.56057058e-02f,
  -1.55830950e-01f, 3.38027999e-02f, 2.58992389e-02f, 5.79832047e-02f, 1.68657191e-02f, 4.83594760e-02f, 2.73559857e-02f, 4.48381305e-02f, 3.18092965e-02f, -5.48174903e-02f,
  -2.43189018e-02f, 3.87948565e-02f, 1.10155335e-02f, -9.44636995e-04f, -2.87602507e-02f, -2.15767119e-02f, -8.21333602e-02f, -1.51263829e-02f, -9.46940705e-02f, -3.42847444e-02f,
  -3.46855819e-02f, -1.42047675e-02f, -4.10513729e-02f, 5.49911940e-03f, -4.06826138e-02f, -8.60592052e-02f, -4.27823998e-02f, 4.56975494e-03f, -6.12022281e-02f, -4.48999461e-03f,
  -4.12644088e-01f, 1.82404388e-02f, 6.78305849e-02f, 1.04205288e-01f, -1.50122553e-01f, 1.50569389e-02f, 6.77817911e-02f, -6.60634413e-02f, -1.28458515e-01f, 1.87296748e-01f,
  1.75325200e-01f, 1.85499609e-01f, -7.85285980e-03f, 1.14944950e-01f, -2.65435338e-01f, -1.75813451e-01f, 6.39937893e-02f, 1.62540883e-01f, -1.08833715e-01f, -2.09794059e-01f,
  -2.22691178e-01f, -5.94164878e-02f, -1.44338354e-01f, 1.87961459e-02f, -2.98200212e-02f, 1.68794528e-01f, 2.03397959e-01f, 2.30342552e-01f, 2.93114841e-01f, 3.79391983e-02f,
  -1.63049418e-02f, -8.01834166e-02f, -8.59861076e-03f, 1.18212335e-01f, 2.45581541e-05f, -6.43075258e-03f, 1.50628731e-01f, 5.68402708e-02f, -2.94068791e-02f, 1.46372952e-02f,
  1.15284391e-01f, -3.59332301e-02f, 1.48366481e-01f, -2.85028070e-02f, -2.93752272e-02f, 2.09822673e-02f, -5.71568310e-03f, -5.02491966e-02f, -6.45293680e-04f, -1.34763762e-01f,
  -2.60787774e-02f, -7.54113421e-02f, 2.77564712e-02f, 1.00511253e-01f, -5.92058003e-02f, 2.39630006e-02f, -2.46038586e-02f, -6.15761206e-02f, 7.81583600e-03f, -5.83541207e-02f,
  2.89738807e-03f, 7.04932958e-02f, -8.30933601e-02f, -5.15967049e-02f, 5.65981725e-03f, -1.96953267e-02f, 1.32826734e-02f, 8.85800198e-02f, -7.63833569e-03f, 4.71334718e-03f,
  6.79790154e-02f, -8.87577608e-02f, -3.31015065e-02f, -2.77935676e-02f, -4.78579402e-02f, -4.76113744e-02f, -1.20260470e-01f, 1.30534679e-01f, -1.01353057e-01f, -4.54052873e-02f,
  5.73666878e-02f, 1.61456726e-02f, 3.16227041e-02f, 1.23338096e-01f, -5.05856872e-02f, -9.56951752e-02f, 7.37695992e-02f, -7.58161321e-02f, 1.12864815e-01f, -3.31645906e-02f,
  6.08415343e-02f, 1.29431024e-01f, 5.90227060e-02f, 9.24281552e-02f, 1.58734936e-02f, -1.65145054e-01f, -1.92133076e-02f, 6.58225780e-03f, 8.48134086e-02f, -7.83066079e-02f,
  4.10546735e-02f, 1.06325671e-01f, 1.55815229e-01f, 4.66662925e-03f, 6.16869666e-02f, -1.58082560e-01f, 6.19225688e-02f, 1.71679892e-02f, -2.47954973e-03f, -5.00595123e-02f,
  2.90850103e-02f, 6.17699586e-02f, 6.94504976e-02f, 4.30224054e-02f, 5.76318540e-02f, 1.61242615e-02f, -9.16585773e-02f, -3.27499807e-02f, -7.21338168e-02f, 3.52014452e-02f,
  -3.18386704e-01f, 3.77660990e-01f, 1.23466492e-01f, -1.49699152e-01f, -1.88041836e-01f, -3.60960066e-01f, -3.64808351e-01f, -1.15972176e-01f, -1.48838181e-02f, 1.45085678e-02f,
  -1.03647694e-01f, 5.48445955e-02f, 2.47310083e-02f, -1.88565284e-01f, -4.98352110e-01f, 4.73228768e-02f, -2.66481519e-01f, -2.86214761e-02f, 9.27447975e-02f, -1.20012209e-01f,
  -1.00003809e-01f, -2.47827515e-01f, -1.04558632e-01f, 1.31867886e-01f, -5.31746075e-02f, 1.30692497e-01f, -6.30983636e-02f, 9.06060711e-02f, -1.89942867e-02f, -5.99485114e-02f,
  -7.57572055e-02f, -9.90408137e-02f, 4.79822904e-02f, 7.01790750e-02f, -9.42848027e-02f, -4.15723734e-02f, -2.71886238e-03f, 5.17840236e-02f, -4.06001545e-02f, -1.96501892e-02f,
  3.86404023e-02f, 5.78752011e-02f, -8.62397719e-04f, 7.49325603e-02f, 8.06531459e-02f, 3.08449455e-02f, 7.53503060e-03f, 1.37006715e-01f, 5.54917045e-02f, 8.62228572e-02f,
  2.77816653e-02f, 5.84035851e-02f, -4.59827520e-02f, 1.16403801e-02f, 6.48093922e-03f, -2.63308603e-02f, 6.44930527e-02f, 1.12734728e-01f, 8.22011754e-03f, -1.39542129e-02f,
  -1.01822458e-01f, 6.34549856e-02f, 6.56137839e-02f, -5.77878319e-02f, -2.04401165e-02f, -3.85811701e-02f, 4.92766984e-02f, 6.48598373e-02f, 9.67195854e-02f, -2.71564778e-02f,
  -7.60250911e-02f, 4.47061732e-02f, -9.75610539e-02f, -9.65763628e-02f, -4.09628041e-02f, -2.22158451e-02f, 6.05684035e-02f, -5.00536636e-02f, 3.91691327e-02f, -4.13856953e-02f,
  -6.25965232e-03f, -3.28501202e-02f, 6.23695515e-02f, 9.40722525e-02f, -4.68456633e-02f, -4.16742116e-02f, 2.48918422e-02f, 7.05253854e-02f, -3.29070091e-02f, -6.17696717e-02f,
  -1.59903392e-01f, -1.90453723e-01f, -5.33046685e-02f, -3.82798761e-02f, 5.02541363e-02f, 1.50565505e-02f, 9.50159598e-03f, 5.51510081e-02f, -1.14656553e-01f, -7.81844556e-02f,
  -5.15160225e-02f, -3.11138257e-02f, -6.18835399e-03f, 6.40141070e-02f, -2.02605836e-02f, -5.99338599e-02f, -9.94912833e-02f, 3.54473442e-02f, -1.32180884e-01f, 2.72354763e-02f,
  3.58026684e-03f, 6.19616918e-02f, 2.74772719e-02f, 2.49391627e-02f, -6.93869889e-02f, -5.95643409e-02f, -6.38796091e-02f, 2.93520521e-02f, -2.93675344e-02f, 7.82228783e-02f,
  3.11010569e-01f, 2.08407149e-01f, 8.72983485e-02f, 3.71423885e-02f, 2.22367570e-01f, 1.75332174e-01f, -1.27453759e-01f, 1.98351100e-01f, 1.73075184e-01f, -1.90835744e-01f,
  -1.37483567e-01f, 1.11529008e-01f, -2.64269024e-01f, -1.87345427e-02f, -8.14549178e-02f, -2.43331566e-01f, -1.82943419e-02f, -3.47440541e-02f, 1.10012546e-01f, 3.38799357e-02f,
  9.31257084e-02f, 1.42183855e-01f, -1.41857952e-01f, 2.28134170e-01f, 1.99329242e-01f, 1.34624198e-01f, -3.37143004e-01f, 1.11849584e-01f, 6.81045726e-02f, 1.76516566e-02f,
  1.76062196e-01f, 1.68036342e-01f, 4.31175195e-02f, 5.27147315e-02f, 4.14073989e-02f, -8.81230682e-02f, 1.09281251e-02f, -1.00412026e-01f, 4.99704964e-02f, 1.60126835e-01f,
  2.94926605e-04f, 1.01843663e-01f, 5.18520288e-02f, -4.64419893e-04f, 1.43589064e-01f, 8.92254859e-02f, 1.18096899e-02f, -4.59328368e-02f, 4.93921824e-02f, 4.50506881e-02f,
  1.37221196e-03f, 1.41750686e-02f, -2.95703467e-02f, -6.94669187e-02f, -3.67476568e-02f, 2.59877611e-02f, -6.82335123e-02f, -5.47170378e-02f, 1.61791630e-02f, 1.13684714e-01f,
  -5.86512946e-02f, -1.90544482e-02f, -2.84160767e-02f, 1.01282477e-01f, -1.37065314e-02f, 5.13302125e-02f, -3.57120633e-02f, -2.04288010e-02f, -4.37843949e-02f, 4.82283309e-02f,
  5.82370050e-02f, 2.53953692e-02f, 5.07562347e-02f, -4.80333343e-02f, -3.53383459e-02f, 3.52226309e-02f, -1.36791766e-01f, 5.60265891e-02f, 2.00839085e-03f, 3.01997550e-02f,
  -8.94768536e-03f, -5.78405336e-03f, 8.37308075e-03f, -6.27613068e-03f, 3.87977660e-02f, 2.67411955e-02f, 5.50950877e-02f, -2.18879543e-02f, 4.98301582e-03f, -6.22862652e-02f,
  -6.58544451e-02f, -2.45062739e-01f, 1.98658053e-02f, 1.33389995e-01f, -2.04820675e-03f, 3.80834751e-02f, -5.38662709e-02f, 4.82534654e-02f, -4.13456820e-02f, -6.45341724e-02f,
  -1.11313254e-01f, 3.09908167e-02f, -2.72719972e-02f, -8.06879997e-03f, 1.16095843e-03f, -4.39590886e-02f, -6.68433085e-02f, -4.62174118e-02f, -7.10164150e-03f, 8.03800076e-02f,
  -1.02307480e-02f, 2.16130335e-02f, -7.16619566e-02f, 6.48245439e-02f, -2.83597093e-02f, -1.51803512e-02f, 6.55708760e-02f, 4.98274677e-02f, -4.18233015e-02f, 1.81284118e-02f,
  4.67798293e-01f, 1.93035662e-01f, 2.14009255e-01f, 3.62348795e-01f, -6.19680211e-02f, 3.29899671e-03f, 3.55313510e-01f, 6.76298663e-02f, 3.43389601e-01f, -7.68196136e-02f,
  6.27717227e-02f, 1.47512570e-01f, 1.41557455e-01f, 1.91354439e-01f, 1.67744920e-01f, 1.40156314e-01f, 1.18325420e-01f, 8.38142484e-02f, 7.74890184e-02f, 1.16970725e-01f,
  9.61905718e-02f, -1.00807033e-01f, 2.25712344e-01f, -1.51429757e-01f, 1.93464160e-01f, 7.64873484e-03f, -2.33239621e-01f, -1.38491720e-01f, -1.50403798e-01f, -1.46418855e-01f,
  5.09056412e-02f, 1.13637902e-01f, 3.73927280e-02f, 1.11902636e-02f, 6.86195642e-02f, -8.24986175e-02f, -6.45189406e-03f, -7.93328974e-03f, 6.42970055e-02f, 6.76322579e-02f,
  5.10211401e-02f, -2.67597511e-02f, -4.62615080e-02f, 2.48235390e-02f, 4.95946370e-02f, 5.98151907e-02f, 7.83675686e-02f, 7.07141310e-03f, -2.27867682e-02f, 1.28768131e-01f,
  1.72992572e-01f, 6.77667856e-02f, 3.72989960e-02f, -8.92749727e-02f, -2.31332723e-02f, 7.00751469e-02f, -5.45395762e-02f, -4.56928164e-02f, -2.26677042e-02f, 6.20178990e-02f,
  -2.84492895e-02f, 2.27370206e-02f, -4.34441380e-02f, 2.82079005e-03f, 3.67417261e-02f, -1.35377841e-02f, -3.19000259e-02f, -9.93084721e-03f, 8.89608357e-03f, 1.36554679e-02f,
  -2.78606750e-02f, 2.67708953e-02f, -1.72852576e-02f, 5.92189245e-02f, 2.34315675e-02f, 5.54764979e-02f, -6.07653670e-02f, -7.45258778e-02f, 5.84489815e-02f, 8.20071697e-02f,
  5.21122217e-02f, -4.84613031e-02f, 6.91410005e-02f, -1.73095912e-02f, -6.54090568e-02f, 3.57136130e-02f, -3.61797214e-02f, 1.24909207e-01f, 7.26566243e-04f, -1.05670840e-02f,
  -4.98823784e-02f, -1.22593030e-01f, 7.10753500e-02f, -3.85791212e-02f, -7.03787506e-02f, 3.25373895e-02f, -3.25371437e-02f, 4.65146042e-02f, -3.76727656e-02f, -1.66788138e-02f,
  -9.76164415e-02f, 1.82235967e-02f, -5.26511297e-02f, -1.10079244e-01f, -4.89791222e-02f, -1.54347550e-02f, -1.63286477e-02f, -6.09692968e-02f, -8.81119147e-02f, -6.93287104e-02f,
  -9.23398659e-02f, 1.49144065e-02f, 1.23060206e-02f, 5.31138927e-02f, -5.23904189e-02f, -3.92942643e-03f, 8.00491124e-03f, -2.04057954e-02f, -7.36261532e-02f, -4.45949621e-02f,
  1.49485737e-01f, -3.00266713e-01f, -1.78243622e-01f, 4.10095423e-01f, 3.50234769e-02f, -6.06097393e-02f, 1.62762210e-01f, -8.67500752e-02f, -1.32350519e-01f, -9.24909711e-02f,
  3.68793637e-01f, -2.03977838e-01f, -3.61310951e-02f, 3.08930010e-01f, 1.27461001e-01f, 1.07754849e-01f, 2.01982319e-01f, 1.57743633e-01f, -1.65935144e-01f, 1.52746513e-01f,
  4.47197221e-02f, 2.68725991e-01f, 2.76056707e-01f, -7.24690259e-02f, 1.28848717e-01f, -2.18656868e-01f, 2.52080619e-01f, -1.77131668e-01f, 1.65215433e-01f, -1.02881148e-01f,
  8.78481567e-02f, -5.19086979e-03f, -9.41208843e-03f, -2.07602642e-02f, 3.66981998e-02f, 2.76336465e-02f, -3.31256837e-02f, 4.36406024e-02f, -5.41053265e-02f, -5.33980690e-02f,
  -7.95924515e-02f, 2.29939502e-02f, -7.90441558e-02f, -8.04007128e-02f, 1.51585862e-02f, 1.18514718e-02f, 4.79808003e-02f, 2.40978450e-02f, -5.81760183e-02f, 2.59701815e-02f,
  7.84716234e-02f, 4.76048291e-02f, 1.78306103e-02f, -2.25239638e-02f, -8.81329328e-02f, -2.43786220e-02f, 9.39957984e-03f, -1.25670237e-02f, -8.09585676e-03f, -1.12997042e-02f,
  -9.15536191e-03f, 5.27347215e-02f, 6.45925244e-03f, 9.17775407e-02f, 7.40401400e-03f, 6.69532828e-03f, 1.40078841e-02f, -1.12653794e-02f, -6.02896698e-02f, 6.26499280e-02f,
  5.32769077e-02f, 1.03113696e-01f, 3.36305834e-02f, 1.78122278e-02f, 4.74595763e-02f, 1.39808962e-02f, 2.12648995e-02f, -4.17083455e-03f, -4.53056432e-02f, 1.39417589e-01f,
  -5.26872603e-03f, -2.65026893e-02f, 5.46417683e-02f, 3.99054699e-02f, 1.41880989e-01f, -6.79354444e-02f, 2.35783327e-02f, -5.41983433e-02f, 4.24567610e-02f, -7.67190307e-02f,
  -4.28196304e-02f, -2.28331849e-01f, -9.33220014e-02f, -5.40789925e-02f, -3.96292247e-02f, 6.64186245e-03f, 9.06409323e-02f, -1.31363526e-01f, -7.54205137e-02f, 4.89108786e-02f,
  -4.93047126e-02f, 5.51398955e-02f, 3.55625190e-02f, 5.12695946e-02f, 7.73747712e-02f, -3.46614160e-02f, 4.51108143e-02f, -6.54169545e-02f, -1.24470750e-02f, 2.10531279e-02f,
  9.64746401e-02f, -2.00342499e-02f, 2.37676799e-02f, -2.33562570e-02f, -7.30862701e-03f, -9.70437133e-04f, -5.67544205e-03f, -7.08555058e-02f, 9.01862979e-02f, 1.75112505e-02f,
  2.98990518e-01f, -2.93224305e-01f, 5.11075146e-02f, 1.44163877e-01f, 4.21393290e-02f, 3.86932679e-02f, 3.96332815e-02f, -7.38278851e-02f, -3.40758175e-01f, -2.55707446e-02f,
  -8.93781781e-02f, 2.99694449e-01f, -2.32044235e-01f, 9.23883729e-03f, 3.21733147e-01f, -2.94132173e-01f, 5.70256785e-02f, 1.18781477e-01f, -1.79702014e-01f, 2.02250928e-01f,
  8.06362182e-03f, 2.06511095e-01f, 2.14374989e-01f, -3.93556282e-02f, 2.40602821e-01f, 8.54196623e-02f, 2.11885124e-01f, -1.26015574e-01f, 2.48454288e-01f, -1.22543769e-02f,
  -3.44538465e-02f, -8.53860304e-02f, 1.86191201e-02f, -8.04197192e-02f, 3.26634645e-02f, 8.64711255e-02f, 4.07738872e-02f, -2.02419292e-02f, -1.33688316e-01f, -1.21374950e-02f,
  -3.18661109e-02f, 1.13135226e-01f, -4.98425402e-02f, -6.94801584e-02f, -1.15135908e-02f, -6.32365281e-03f, 7.61070102e-02f, -4.51972485e-02f, -4.00606021e-02f, 4.20130379e-02f,
  6.32767845e-03f, 6.62211329e-03f, -8.36155191e-02f, -1.43745476e-02f, 4.51091537e-03f, -4.35809307e-02f, 4.43959013e-02f, 1.24008685e-01f, -2.10787673e-02f, 5.63827828e-02f,
  1.00859717e-01f, -9.64019671e-02f, -1.23570906e-02f, -1.13895349e-01f, 1.07555110e-02f, -1.51240490e-02f, -1.13990076e-01f, 1.08911857e-01f, -5.14292270e-02f, 5.39822355e-02f,
  -6.26059324e-02f, -2.47589573e-02f, -1.11005589e-01f, 7.37126311e-03f, 6.85164258e-02f, 9.40076113e-02f, 9.26574245e-02f, -5.03514297e-02f, 8.74286667e-02f, 1.02524772e-01f,
  -6.75480291e-02f, -1.23405486e-01f, 7.01755984e-03f, 7.09500723e-03f, -4.19009477e-02f, 8.61749351e-02f, -9.97223035e-02f, 4.65178397e-03f, 2.31167097e-02f, 8.17168355e-02f,
  -8.63298327e-02f, -7.01103136e-02f, -8.75795931e-02f, -4.92457226e-02f, -2.72175539e-02f, -1.19085680e-03f, -7.84308463e-02f, 3.99341248e-02f, 4.48609106e-02f, -2.24200916e-03f,
  2.57418677e-02f, 3.23227346e-02f, 1.02279529e-01f, -5.83239198e-02f, -2.16060039e-02f, 6.25465065e-02f, 6.15427122e-02f, 9.90080088e-03f, 8.71024430e-02f, 1.48011297e-02f,
  9.44246724e-03f, 1.24597780e-01f, 4.33639437e-02f, 1.63656905e-01f, 1.16076231e-01f, 8.94230045e-03f, 1.02813793e-02f, -5.83134475e-04f, 6.10437840e-02f, -2.31420267e-02f,
  1.96908787e-01f, -2.54891247e-01f, 3.78946304e-01f, 1.11324549e-01f, -3.20816189e-02f, 3.41937214e-01f, 1.27263814e-01f, -7.41697699e-02f, 2.01100498e-01f, -2.65284866e-01f,
  -1.79923758e-01f, 7.96903968e-02f, -4.74089719e-02f, -1.76123857e-01f, 2.89095134e-01f, 1.60137370e-01f, -4.15716991e-02f, -4.49187756e-02f, 1.06391057e-01f, -3.11846435e-02f,
  2.03604400e-01f, -2.17385262e-01f, 1.68386266e-01f, -2.43043348e-01f, -1.93046153e-01f, -2.17973515e-02f, -2.15519756e-01f, 1.72698468e-01f, -9.64800194e-02f, -7.77587574e-03f,
  1.72457900e-02f, 2.70275082e-02f, -9.36639979e-02f, 8.03227946e-02f, -2.83012316e-02f, -8.16774461e-03f, 1.16151266e-01f, 5.60069345e-02f, -3.17957029e-02f, -2.26933211e-02f,
  4.17112969e-02f, -4.07799222e-02f, -4.58945185e-02f, -5.88788651e-02f, 4.07210849e-02f, 8.86656716e-03f, -5.08405082e-02f, 3.57629582e-02f, 3.81865762e-02f, 1.63780198e-01f,
  6.15785345e-02f, 4.41911928e-02f, 3.44456434e-02f, -5.52296499e-03f, 3.43053825e-02f, 3.29857618e-02f, 1.61936641e-01f, 6.82066232e-02f, 3.24636847e-02f, -1.24809248e-02f,
  -2.80614104e-02f, 5.11801243e-02f, -6.79156557e-02f, -4.62062173e-02f, -3.32542993e-02f, -8.92787948e-02f, 1.07716024e-03f, -1.95882618e-02f, 1.08602433e-03f, -5.82688546e-04f,
  -6.04600571e-02f, -3.52956057e-02f, -3.87175567e-02f, -1.91727076e-02f, -3.55040617e-02f, 1.91902798e-02f, 4.70960662e-02f, -3.81651670e-02f, -4.57255961e-03f, -5.89655191e-02f,
  -6.09757612e-03f, 8.64134356e-02f, -6.50328994e-02f, 5.91308288e-02f, 3.60062867e-02f, 4.13367199e-03f, 9.47408900e-02f, 8.10989290e-02f, 2.83093955e-02f, 6.05008677e-02f,
  -1.84374183e-01f, -1.41063720e-01f, -9.20097008e-02f, -1.02239080e-01f, -1.15204126e-01f, -1.78596377e-02f, 8.83304104e-02f, -5.82922772e-02f, -8.64636712e-03f, 1.99908428e-02f,
  -7.79185221e-02f, -2.69742813e-02f, -1.88556071e-02f, 5.50135672e-02f, -9.10404138e-03f, 2.09780447e-02f, 6.55171797e-02f, -1.20417088e-01f, -1.61570653e-01f, -7.10524842e-02f,
  -1.28156289e-01f, 5.78832626e-02f, 5.40384129e-02f, -4.72732894e-02f, 5.19635528e-02f, -1.21107757e-01f, -1.36461749e-03f, 1.03735588e-02f, -7.85492510e-02f, 8.85751855e-04f,
  2.49274775e-01f, -3.95660669e-01f, -1.60516635e-01f, 2.19226871e-02f, -1.79127902e-01f, -2.97360867e-01f, -2.34176796e-02f, -1.55789956e-01f, -1.71912670e-01f, -1.89301506e-01f,
  -6.01344444e-02f, 5.54120988e-02f, -7.53959343e-02f, -1.59677342e-01f, 1.37909085e-01f, -2.45413512e-01f, -1.60639957e-02f, -1.55621301e-02f, -6.90909922e-02f, 6.53286353e-02f,
  9.02330652e-02f, 5.78032583e-02f, -4.67133932e-02f, -9.97078419e-02f, -5.36552223e-04f, 1.92223206e-01f, 2.82133192e-01f, 1.64069645e-02f, -1.06568038e-02f, -5.63819893e-02f,
  8.97263363e-02f, -9.14966315e-02f, 2.78548035e-03f, -2.38792133e-02f, -3.51165049e-02f, 1.20917365e-01f, 2.75319186e-03f, -1.18699297e-03f, -3.23855481e-03f, -6.70710877e-02f,
  -5.36257662e-02f, -4.50441940e-03f, 4.40521128e-02f, -2.24296767e-02f, 1.57104097e-02f, -9.91937239e-03f, -1.14839971e-01f, -6.39822483e-02f, -1.77184746e-01f, -8.01016986e-02f,
  -1.17880076e-01f, -9.06698480e-02f, -7.31646083e-03f, -3.49200778e-02f, 3.92421670e-02f, -4.65862267e-02f, 5.96876554e-02f, 5.44212013e-03f, 1.89173892e-02f, -1.55372368e-02f,
  4.98055853e-02f, 1.06232166e-02f, -7.27415606e-02f, -6.46564290e-02f, 3.60991843e-02f, 4.26580496e-02f, -2.36190343e-03f, 3.69565450e-02f, 6.34700879e-02f, -4.50694598e-02f,
  6.43660594e-03f, 4.05031405e-02f, -7.83515871e-02f, -2.30144002e-02f, 5.37875816e-02f, 7.65344501e-03f, 4.53610979e-02f, -2.08892543e-02f, 3.93569991e-02f, 1.21420743e-02f,
  -7.35067949e-02f, -6.21660938e-03f, -1.85796432e-02f, 4.46110172e-03f, -8.60558078e-02f, -2.30667461e-02f, 5.88863902e-02f, -6.81006908e-02f, -1.13273822e-02f, 3.60070877e-02f,
  -3.00979968e-02f, 1.77034974e-01f, -5.54863587e-02f, -5.54715097e-02f, 5.29616438e-02f, -1.22077405e-01f, 6.53971955e-02f, 1.93740427e-02f, -3.55184712e-02f, -7.77703971e-02f,
  8.77776369e-02f, -2.35280935e-02f, 4.27042805e-02f, 3.70606482e-02f, 1.25083774e-02f, -8.26588199e-02f, 3.38661186e-02f, 5.46741560e-02f, 6.17015474e-02f, 1.15605652e-01f,
  7.29906932e-02f, 9.79329795e-02f, 3.74369929e-03f, -5.21217361e-02f, 7.68406913e-02f, 5.48228286e-02f, 5.65376021e-02f, 9.00794417e-02f, -5.40483370e-02f, -2.35309731e-02f,
  2.65981585e-01f, -7.57379308e-02f, 2.58019507e-01f, 4.65398341e-01f, -1.10281527e-01f, -3.39097381e-01f, -8.81088898e-02f, 9.66325775e-02f, 3.68828088e-01f, -2.48163819e-01f,
  -1.61337838e-01f, 2.47756764e-01f, -2.75434047e-01f, 7.94846117e-02f, 4.95977551e-02f, -2.60024637e-01f, 1.89724967e-01f, 1.08974949e-01f, 1.88262209e-01f, 1.04984507e-01f,
  1.41589969e-01f, -3.16665098e-02f, 5.86789921e-02f, 8.59918725e-03f, -5.13701253e-02f, 2.54235029e-01f, -5.48188798e-02f, -1.30211636e-01f, 3.96881159e-03f, -1.15191266e-01f,
  -2.18225215e-02f, -5.71613712e-03f, 1.69568155e-02f, 5.02554700e-03f, -1.60871390e-02f, -2.28923350e-03f, -3.73010859e-02f, -4.19473313e-02f, 6.73993751e-02f, 3.57976221e-02f,
  1.32598849e-02f, -2.09829994e-02f, 1.05151944e-01f, 1.16646320e-01f, 1.98317003e-02f, 5.31854406e-02f, -4.26526368e-02f, -1.35139897e-01f, 5.11855520e-02f, -2.10699085e-02f,
  -4.74860631e-02f, -1.98492911e-02f, 2.24585440e-02f, -4.72867601e-02f, 7.58019090e-03f, 1.24299534e-01f, -2.46098526e-02f, -5.39290123e-02f, -4.17121761e-02f, -2.80478131e-02f,
  -5.59922606e-02f, 1.51549326e-02f, -1.05669595e-01f, 7.33744726e-02f, -5.58313653e-02f, 6.95265085e-02f, -3.60531509e-02f, -2.92917043e-02f, 1.03087388e-01f, -2.34264284e-02f,
  7.30882911e-03f, 1.20750973e-02f, 3.12945284e-02f, 2.39896718e-02f, 7.84923062e-02f, 3.02978009e-02f, 3.24435346e-02f, -8.32822826e-03f, 1.09343924e-01f, 1.97636541e-02f,
  -2.26627383e-02f, 3.65827046e-02f, -2.32635699e-02f, -1.26448303e-01f, -1.11687392e-01f, 6.12035617e-02f, 1.74867343e-02f, 6.78950083e-03f, 6.58252388e-02f, -1.29692927e-01f,
  -5.98776974e-02f, -8.65212604e-02f, 3.55745070e-02f, 5.69089986e-02f, 2.00852752e-02f, -2.65783966e-02f, -3.61082144e-02f, 3.59231718e-02f, 5.45583628e-02f, -2.22327188e-03f,
  7.50608370e-02f, 3.79942171e-02f, -5.34344018e-02f, -6.99100792e-02f, 1.45611400e-02f, -1.43180355e-01f, 1.17290318e-01f, 2.94637661e-02f, 6.95765167e-02f, 4.17385856e-03f,
  1.25114266e-02f, 2.23941077e-02f, 5.47393151e-02f, -1.25001650e-02f, 2.92134751e-02f, -3.07054278e-02f, 1.95925459e-02f, 7.88630024e-02f, -1.15679622e-01f, 8.25334862e-02f,
  -3.61938655e-01f, 2.77743638e-01f, 1.08088292e-01f, -3.51256430e-01f, -4.08692956e-02f, -2.92900831e-01f, -2.61205614e-01f, 1.64454225e-02f, -1.65443286e-01f, 7.85643049e-03f,
  -8.03162083e-02f, 1.83930844e-01f, 1.78802297e-01f, -3.69841248e-01f, -1.54936031e-01f, 7.74487853e-02f, -3.22613984e-01f, -2.41670117e-01f, 3.85540500e-02f, -3.23632173e-02f,
  -1.34318277e-01f, -1.69861540e-01f, 9.72203165e-02f, 8.40710327e-02f, -7.82973841e-02f, 1.33371681e-01f, 1.89527407e-01f, 2.48243466e-01f, -1.91348642e-01f, 1.41909125e-03f,
  -1.19901821e-01f, -3.72580322e-03f, 2.94234231e-02f, -1.67369321e-02f, -1.39509216e-01f, -7.45894993e-03f, 3.99734341e-02f, 2.54767928e-02f, -8.07818584e-03f, 2.91080996e-02f,
  2.55940035e-02f, 7.39822611e-02f, -8.75765681e-02f, 7.90215507e-02f, -7.36413673e-02f, 4.95643727e-02f, -1.73703842e-02f, -1.01310676e-02f, 4.61620763e-02f, 7.12518692e-02f,
  -1.20846089e-02f, -7.50691816e-02f, -6.99979886e-02f, 8.08824843e-04f, 2.51462776e-02f, -4.09480333e-02f, -3.18344496e-02f, 3.33434679e-02f, -6.97406530e-02f, -8.84038676e-03f,
  8.62077177e-02f, -3.45031805e-02f, 2.06325706e-02f, 3.61654237e-02f, 2.31921114e-02f, 1.67279337e-02f, -2.79141795e-02f, 2.79564299e-02f, -2.37718094e-02f, 2.20201090e-02f,
  -3.74551676e-02f, 3.22659872e-02f, -1.32673727e-02f, -3.17401960e-02f, -6.19639196e-02f, -6.20911568e-02f, 2.91814879e-02f, 4.67542447e-02f, -1.30449861e-01f, 5.30444197e-02f,
  5.12996539e-02f, -6.05156235e-02f, 3.89757045e-02f, -2.13509779e-02f, -2.99603622e-02f, 7.75726512e-02f, -1.31660216e-02f, -6.21840032e-03f, -4.48634923e-02f, -1.87811386e-02f,
  4.69504595e-02f, 2.20384955e-01f, 1.50473928e-02f, -2.40708143e-02f, 8.46585408e-02f, 5.07857315e-02f, -9.17746797e-02f, 6.83068708e-02f, 6.34851772e-03f, -4.07419167e-02f,
  -8.97478312e-02f, -5.78732304e-02f, 3.39624775e-03f, -8.50719959e-02f, -1.00384420e-02f, 2.45034788e-02f, -2.91255414e-02f, -4.71100584e-02f, -5.71673550e-02f, -5.80478506e-03f,
  7.01341927e-02f, 3.68456468e-02f, 4.57406417e-02f, -8.92015845e-02f, -8.03567320e-02f, -2.12728828e-02f, 4.54758480e-02f, -6.21291921e-02f, 7.34698251e-02f, -5.52363619e-02f,
  4.76164609e-01f, 1.40981078e-01f, 3.08683783e-01f, 1.30327657e-01f, -1.39199659e-01f, -4.30641882e-02f, 1.31501734e-01f, 2.57495224e-01f, 1.51285052e-01f, -1.57559946e-01f,
  -2.77260058e-02f, 1.66417807e-01f, 2.91544385e-02f, 9.37601924e-02f, 1.23224452e-01f, -2.12827474e-01f, 3.22038718e-02f, 1.25893652e-01f, 1.63953542e-03f, 2.77101308e-01f,
  -6.52034627e-03f, -1.97306722e-01f, 1.84867848e-02f, -1.45315588e-01f, 2.31419712e-01f, 1.22190319e-01f, -8.86659324e-02f, -4.52089906e-02f, 7.05166012e-02f, -7.11498931e-02f,
  -1.38405967e-03f, 2.57465333e-01f, 8.66546258e-02f, 8.04824978e-02f, 8.85788649e-02f, 7.02801496e-02f, 3.48473303e-02f, 6.01816503e-03f, -1.30511178e-02f, 1.88691951e-02f,
  -2.04109177e-02f, -4.61017601e-02f, 5.72698563e-02f, -1.12761065e-01f, 2.99917292e-02f, 5.28648049e-02f, -9.13162231e-02f, -8.50450099e-02f, 9.86524150e-02f, -3.62568982e-02f,
  5.80546856e-02f, -2.84568872e-03f, 2.97502661e-03f, -1.83511730e-02f, -6.62375614e-02f, -6.82791248e-02f, -4.24649119e-02f, 7.05155209e-02f, 5.81171513e-02f, 8.16287659e-03f,
  4.39278744e-02f, -4.27749380e-02f, -6.60595074e-02f, 4.62417677e-02f, -1.77078694e-02f, -1.12913027e-01f, 1.48623185e-02f, -6.25412315e-02f, -9.29458663e-02f, -5.11951968e-02f,
  -8.58935043e-02f, 1.27430007e-01f, -1.23118004e-03f, 2.41493732e-02f, -4.91827391e-02f, -3.55263911e-02f, 2.63524745e-02f, 9.23122000e-03f, 1.04893679e-02f, -7.99731091e-02f,
  9.34945941e-02f, 5.09732626e-02f, -1.90162901e-02f, -4.96935993e-02f, -2.58000125e-03f, 5.30506484e-02f, -3.07472572e-02f, -7.00158905e-03f, 3.01030856e-02f, 9.11207777e-03f,
  1.63760558e-01f, 2.75559485e-01f, -2.50998884e-02f, -9.63663496e-03f, -7.59949088e-02f, -7.06794634e-02f, -7.46559650e-02f, -4.22227988e-03f, -1.17334723e-02f, 3.73148061e-02f,
  3.23199038e-03f, -2.69504916e-03f, 7.26555139e-02f, 2.25744466e-03f, -4.84679975e-02f, -4.62441184e-02f, 2.90961992e-02f, 7.16141844e-03f, 1.34742493e-02f, 1.34606371e-02f,
  1.46290045e-02f, 1.93151198e-02f, -2.07183156e-02f, -6.51037768e-02f, 1.50405169e-02f, -3.18120047e-03f, 7.80000910e-02f, 2.12468430e-02f, -6.74080849e-02f, 3.41957472e-02f,
  -7.28780404e-02f, 4.12814081e-01f, 3.41794282e-01f, 1.19857952e-01f, 1.94778398e-01f, 2.66808152e-01f, -4.80332114e-02f, 2.27613345e-01f, -1.25137478e-01f, -8.25394690e-03f,
  4.25237305e-02f, 2.60491908e-01f, 7.85161704e-02f, 1.94929615e-01f, 1.92955896e-01f, -2.83304211e-02f, 1.37925029e-01f, 2.82796752e-02f, -7.29716271e-02f, 1.33751258e-01f,
  -1.16903605e-02f, 1.35974586e-01f, 1.98205888e-01f, 4.38515916e-02f, 7.95917809e-02f, -7.68943653e-02f, -1.61644205e-01f, -5.16246930e-02f, 1.51570305e-01f, 8.46560672e-02f,
  -6.24049194e-02f, 4.71139997e-02f, -2.12598722e-02f, -2.64136499e-04f, 7.24257082e-02f, -1.40263155e-01f, -1.17032886e-01f, -1.00897431e-01f, -1.93477888e-02f, 1.02406800e-01f,
  8.18292648e-02f, 4.97347079e-02f, 1.08102724e-01f, -9.43720061e-03f, 6.69730082e-02f, 2.91164368e-02f, 1.24961190e-01f, -1.24550713e-02f, 1.38277173e-01f, 7.53143951e-02f,
  8.03233087e-02f, 1.13659136e-01f, 4.66663111e-03f, 2.95119174e-02f, 3.90619487e-02f, 5.67172579e-02f, -1.09980047e-01f, 4.22111563e-02f, 5.52039482e-02f, 2.70612743e-02f,
  -8.43097717e-02f, -9.14745554e-02f, 8.29657763e-02f, -3.77020612e-02f, 9.08318684e-02f, -1.05671823e-01f, -7.58766681e-02f, 1.23561963e-01f, 3.31042558e-02f, 1.51265875e-01f,
  -9.51342843e-03f, 6.68576956e-02f, -4.48606163e-02f, -2.99397856e-02f, -1.00344688e-01f, -1.77109867e-01f, 3.31568830e-02f, -1.16985485e-01f, -6.76720683e-03f, -2.72939578e-02f,
  -1.97328761e-01f, 3.11020594e-02f, -3.25457342e-02f, -1.34634465e-01f, -5.22546507e-02f, 2.05031354e-02f, 1.12413600e-01f, 7.95525536e-02f, -4.25782539e-02f, -9.41188112e-02f,
  9.05771703e-02f, 1.19934507e-01f, -4.19101194e-02f, 1.05316438e-01f, -4.03962880e-02f, -3.46086770e-02f, -6.82811067e-02f, 6.15924150e-02f, 6.79188147e-02f, 8.92925709e-02f,
  3.76650435e-03f, -9.76005346e-02f, -8.74907598e-02f, 7.31804147e-02f, 2.09826306e-02f, 2.70469161e-03f, -2.36241911e-02f, -5.88409975e-02f, 5.12956828e-02f, 5.74252419e-02f,
  -3.09171565e-02f, 4.38800491e-02f, 1.52473040e-02f, 7.52105266e-02f, 3.09159942e-02f, -9.70487017e-03f, -9.99325141e-02f, 1.58505663e-02f, -5.71409352e-02f, 4.73327227e-02f,
  -2.61845291e-01f, 8.20711628e-02f, -1.79263622e-01f, -2.99222201e-01f, 7.37781525e-02f, -1.26651421e-01f, -3.54226142e-01f, 2.02860564e-01f, -1.86662242e-01f, 1.91128612e-01f,
  1.90027326e-01f, -3.12704712e-01f, 3.50688100e-01f, -1.13319159e-01f, -1.85561344e-01f, 9.43689495e-02f, -3.18568289e-01f, -3.15690577e-01f, 3.50153297e-02f, -1.87929757e-02f,
  5.15283681e-02f, 1.02717981e-01f, -5.12796827e-02f, 2.14581266e-01f, -8.58682469e-02f, -6.25674650e-02f, 1.95684075e-01f, 1.87212676e-01f, -1.72393173e-01f, -5.27154133e-02f,
  1.67829007e-01f, 2.72717401e-02f, -9.02270824e-02f, 8.68603494e-03f, 1.33345677e-02f, 6.83718547e-02f, -2.80226693e-02f, 5.88845946e-02f, -4.08978289e-04f, -4.30989452e-02f,
  -1.41812757e-01f, 2.68971780e-03f, -4.23658155e-02f, -1.75118204e-02f, 3.39870946e-03f, -3.51041462e-03f, 5.66050969e-03f, -8.19709226e-02f, -5.08344248e-02f, 5.49321715e-03f,
  -3.59170735e-02f, -1.28312200e-01f, -1.15552247e-01f, -1.18401974e-01f, -8.45473260e-02f, -4.06129174e-02f, -4.22292352e-02f, -9.72780585e-02f, 2.88748592e-02f, -1.42907172e-01f,
  -2.77174022e-02f, -2.89170500e-02f, -1.20829521e-02f, 2.45799460e-02f, 3.31924297e-02f, 5.60982041e-02f, -3.00722825e-03f, 5.35427146e-02f, -1.96428094e-02f, 7.98710361e-02f,
  -4.96018725e-03f, 2.39639729e-02f, -6.25855010e-03f, 5.58568984e-02f, -7.72917569e-02f, 3.23719415e-03f, -9.09912139e-02f, -7.01875146e-03f, 3.91291715e-02f, -2.93012913e-02f,
  2.95702610e-02f, -2.40710750e-02f, -2.64126118e-02f, 5.12940064e-02f, -2.01885756e-02f, 4.52927016e-02f, 1.36648685e-01f, 1.39332972e-02f, -7.84904696e-03f, -5.08731045e-03f,
  2.10866153e-01f, 7.41341785e-02f, 1.63649172e-02f, 2.94185011e-03f, -6.68553337e-02f, 1.98755357e-02f, -7.16586858e-02f, 1.28166154e-02f, 9.06734541e-02f, 4.33314182e-02f,
  -3.34358811e-02f, 3.99918156e-03f, 9.67025198e-03f, -1.28802657e-03f, -1.58507079e-01f, 1.84041858e-01f, -4.57121804e-03f, -1.16340742e-02f, 4.05362761e-03f, 5.66725582e-02f,
  -7.24208280e-02f, 6.07895292e-03f, 1.57006215e-02f, 7.17801377e-02f, -6.76598325e-02f, -4.35383990e-02f, -7.48000517e-02f, -4.14651074e-02f, 7.18199741e-03f, -1.74086783e-02f,
  -1.99072465e-01f, -9.50911790e-02f, 2.79352516e-01f, 4.04846780e-02f, -2.92013556e-01f, -2.39036709e-01f, -8.37220773e-02f, -1.73016950e-01f, -7.60846287e-02f, -1.23354353e-01f,
  -9.22512636e-02f, 2.00446501e-01f, 2.25838378e-01f, 5.17235138e-02f, 2.25053504e-01f, 3.41781646e-01f, -9.37824547e-02f, 4.59833294e-02f, 1.03702128e-01f, -1.54669434e-01f,
  7.69451484e-02f, -3.54765862e-01f, 1.26356602e-01f, -3.91841233e-01f, -2.20625177e-01f, -7.08625987e-02f, -6.01952039e-02f, 1.32434024e-02f, -1.18241027e-01f, 6.54727444e-02f,
  -1.24554016e-01f, 8.01563635e-02f, -5.51402569e-02f, 1.63997754e-01f, -1.31614655e-01f, -6.39988407e-02f, -7.29917502e-03f, 1.67197421e-01f, 8.00933540e-02f, 6.17938265e-02f,
  3.51777300e-02f, 2.98189223e-02f, -4.20558453e-02f, -3.16546783e-02f, -1.00852989e-01f, 3.11920159e-02f, 2.72415392e-03f, -3.14712413e-02f, -1.57878324e-02f, 1.18499562e-01f,
  1.05479188e-01f, 1.05285317e-01f, -3.76844555e-02f, 4.80479077e-02f, 1.10033579e-01f, 2.47604605e-02f, 4.25391085e-02f, 6.13002665e-02f, 1.50325918e-03f, -1.52556062e-01f,
  2.66016573e-02f, -7.13040307e-02f, -4.57467958e-02f, 3.53847928e-02f, 2.26820596e-02f, 3.61124724e-02f, -5.31017706e-02f, -1.10176774e-02f, 9.32997651e-03f, -4.67997119e-02f,
  -8.16955119e-02f, -4.47860286e-02f, -1.22139212e-02f, -2.66493317e-02f, -4.60920297e-02f, -4.82864212e-03f, 3.30059964e-04f, -3.91530842e-02f, -9.46627036e-02f, -3.77441086e-02f,
  7.17982501e-02f, -1.15112677e-01f, -2.67736278e-02f, -1.67136751e-02f, 4.77647632e-02f, 5.41138314e-02f, -1.83195213e-03f, 7.18404911e-03f, 1.66804697e-02f, -3.36757824e-02f,
  -3.03801894e-01f, -1.45173818e-01f, -4.30176556e-02f, -1.02022648e-01f, 1.66088697e-02f, -4.21958156e-02f, 1.83852427e-02f, -4.44846377e-02f, 3.47961411e-02f, -3.66880633e-02f,
  -3.48813124e-02f, 2.31632330e-02f, -7.15319514e-02f, -9.24663767e-02f, -2.25423481e-02f, -1.87571682e-02f, 1.47787761e-02f, -2.07204670e-02f, -1.13154709e-01f, -9.58921947e-03f,
  -1.38696149e-01f, -2.15936564e-02f, -2.56040972e-02f, -1.44607514e-01f, -2.60641258e-02f, -1.53671382e-02f, -9.07349512e-02f, 2.47875769e-02f, -6.20280998e-03f, 3.36522311e-02f,
  3.71884286e-01f, -9.39480960e-02f, 3.58574688e-01f, 5.15005738e-02f, 1.37955278e-01f, -4.05852437e-01f, -1.48648560e-01f, -8.19980428e-02f, 1.06610142e-01f, -4.12062168e-01f,
  -1.72956854e-01f, 5.61160520e-02f, -3.83255146e-02f, -3.54761988e-01f, -2.58856922e-01f, -2.13070452e-01f, -3.67947459e-01f, -1.32842720e-01f, 1.40167236e-01f, 3.20630744e-02f,
  4.44413051e-02f, -4.51753050e-01f, 3.27790789e-02f, -1.56847656e-01f, 4.22600210e-02f, 1.15001880e-01f, -2.24380553e-01f, 1.54769272e-01f, -2.84643471e-01f, -1.32626995e-01f,
  -2.41970010e-02f, 8.21035281e-02f, 9.57883745e-02f, 3.34577784e-02f, 3.50246318e-02f, 4.66492660e-02f, -2.09869863e-03f, 1.05802670e-01f, 6.56610280e-02f, 2.38464531e-02f,
  2.65074801e-02f, 5.84220476e-02f, -8.03456903e-02f, -3.13508287e-02f, 6.01388067e-02f, 4.16833274e-02f, 8.08181390e-02f, -1.03636971e-02f, 2.37142537e-02f, 5.91653287e-02f,
  9.04749259e-02f, -3.70196961e-02f, 4.52038599e-03f, -6.93427175e-02f, 6.96583465e-02f, 1.76277552e-02f, -5.10727689e-02f, -2.98526906e-03f, -9.49021149e-03f, 5.17218793e-03f,
  -1.21832704e-02f, -9.86611545e-02f, -2.02249140e-02f, -1.12748239e-02f, 1.84830297e-02f, 5.68306372e-02f, -6.01358190e-02f, -4.15474325e-02f, 7.54433349e-02f, -3.46103311e-02f,
  2.62006614e-02f, 5.59261218e-02f, -2.50434391e-02f, -2.95874123e-02f, -4.16320078e-02f, -1.06702000e-02f, 3.34550925e-02f, -5.65793626e-02f, -2.82524787e-02f, 3.52854095e-02f,
  -2.06655730e-02f, -2.11673249e-02f, -7.44120963e-03f, 8.60854518e-03f, -7.63394013e-02f, -1.03525259e-02f, -3.43962945e-02f, 6.95912987e-02f, -3.33810635e-02f, -4.34257351e-02f,
  -2.03848898e-01f, -3.37685525e-01f, -6.82451874e-02f, -3.39916954e-03f, -2.19249222e-02f, -1.10525135e-02f, 2.80753747e-02f, -7.18056411e-02f, -2.08591577e-02f, 2.16152286e-03f,
  2.99399905e-02f, -4.49317992e-02f, 2.86245253e-02f, 4.16049436e-02f, -8.07236731e-02f, -9.86485090e-03f, -1.10032894e-01f, -9.09626135e-04f, -1.54483333e-01f, -7.30021670e-02f,
  -1.77500974e-02f, 3.18533704e-02f, 1.42349284e-02f, 6.12255670e-02f, -6.10173121e-02f, 3.14224511e-02f, 5.32068014e-02f, 8.13260749e-02f, -2.93727722e-02f, -7.22499043e-02f,
  -1.06811017e-01f, 1.08509511e-01f, -4.99874316e-02f, 2.21082240e-01f, 1.27619326e-01f, 3.85099977e-01f, -2.09231041e-02f, 1.95063919e-01f, 1.51932210e-01f, -3.58556397e-02f,
  1.05695494e-01f, -3.32521707e-01f, -3.05125386e-01f, 1.95608005e-01f, 1.64349243e-01f, 8.11189935e-02f, 3.28258812e-01f, 3.50737907e-02f, 1.99419513e-01f, -9.77995396e-02f,
  1.22792095e-01f, 2.00466290e-01f, 3.50351371e-02f, 6.95077255e-02f, 6.94664791e-02f, -1.34909628e-02f, -3.30848843e-02f, -1.00172706e-01f, 2.17869908e-01f, 1.32440656e-01f,
  1.65342435e-01f, -1.18149385e-01f, -8.10800344e-02f, -1.62704527e-01f, 2.43149679e-02f, -4.33005914e-02f, 2.94424575e-02f, -9.97786447e-02f, -7.43084624e-02f, -1.59152001e-02f,
  -1.67559922e-01f, -8.75527412e-02f, 5.59984073e-02f, -5.21853892e-03f, -1.38075259e-02f, -2.73143891e-02f, -1.52798202e-02f, 4.15560827e-02f, -9.08498317e-02f, -9.16325599e-02f,
  -6.35172278e-02f, 8.35025609e-02f, 3.94297279e-02f, 5.46464659e-02f, 6.52412092e-03f, 8.54957700e-02f, 8.48653391e-02f, -2.36306973e-02f, 5.63677549e-02f, 8.90211836e-02f,
  6.04396276e-02f, 4.96311001e-02f, -5.14909513e-02f, -4.76655848e-02f, 4.27314751e-02f, 1.35009870e-01f, -1.05122095e-02f, 3.59217487e-02f, 2.88615711e-02f, 6.10932559e-02f,
  9.50938910e-02f, -7.30074663e-03f, 1.21258430e-01f, -4.75287512e-02f, 3.64743173e-02f, 5.22874705e-02f, -3.32466550e-02f, 8.99933558e-03f, 5.43521903e-02f, -2.32467651e-02f,
  -1.51055055e-02f, 5.50354496e-02f, -4.42346297e-02f, -2.04309560e-02f, 3.63990664e-02f, -6.12812825e-02f, 4.29865196e-02f, 4.79866937e-02f, -1.51961306e-02f, -2.55401041e-02f,
  2.04322770e-01f, 1.69038147e-01f, -5.35599440e-02f, -7.24793039e-03f, -7.03608477e-03f, -2.69840863e-02f, 5.86537682e-02f, 1.66071299e-02f, 1.06659964e-01f, -1.64017212e-02f,
  3.59471552e-02f, -3.11236531e-02f, -8.20873007e-02f, -2.38422491e-02f, 1.24929540e-01f, 1.60684325e-02f, 9.89676453e-03f, 6.54930174e-02f, 1.40648708e-01f, 4.81572151e-02f,
  -1.35821402e-01f, -1.06188410e-03f, -6.46491572e-02f, 8.05609580e-03f, 7.51646003e-03f, -4.97294366e-02f, -2.62822257e-03f, 6.26397952e-02f, 5.14834328e-03f, 5.55412145e-03f,
  -2.44936854e-01f, 3.73683497e-02f, 2.00667337e-01f, -1.00750931e-01f, -2.89802492e-01f, 8.73339325e-02f, 9.79031026e-02f, -3.28867584e-01f, -1.96722031e-01f, 1.01444550e-01f,
  -1.54161751e-01f, 3.78808081e-01f, 1.74126685e-01f, 1.27542540e-01f, -2.66225599e-02f, 2.82539338e-01f, -1.88832372e-01f, 7.63794705e-02f, 5.69043541e-03f, -2.09687054e-01f,
  -1.15010984e-01f, -3.08784962e-01f, 2.28815228e-01f, -2.45877549e-01f, -1.11023806e-01f, -8.44364762e-02f, -1.73190609e-01f, 1.18155502e-01f, -5.36665916e-02f, 3.83162238e-02f,
  -7.97765404e-02f, -6.97438866e-02f, 9.74815041e-02f, 6.77453801e-02f, -1.09120712e-01f, 8.97796527e-02f, 9.06117037e-02f, 8.34151879e-02f, 6.70307875e-02f, 2.38088444e-02f,
  8.07453021e-02f, -2.70486660e-02f, -1.25886023e-03f, 2.88442858e-02f, 4.51013781e-02f, 4.65815812e-02f, 5.28713763e-02f, 7.34777078e-02f, 5.19540869e-02f, 3.27901691e-02f,
  5.62113337e-02f, 1.22064009e-01f, -1.99009781e-03f, 5.48962578e-02f, -5.71722798e-02f, 4.23858725e-02f, 6.87550977e-02f, 5.05394936e-02f, 7.45340902e-03f, -4.00500074e-02f,
  -6.98758066e-02f, -5.40377200e-02f, 1.20503023e-01f, -3.32671553e-02f, -5.46662956e-02f, -1.05567658e-02f, 8.56324732e-02f, 3.73063385e-02f, 7.92970955e-02f, 3.21523063e-02f,
  -5.57318255e-02f, -1.62114240e-02f, -5.00454046e-02f, 2.36107036e-02f, -3.67080956e-03f, -3.27143967e-02f, 6.70124441e-02f, 2.87855882e-03f, -1.22278444e-01f, -3.49253304e-02f,
  -4.33283485e-03f, -1.09076910e-01f, 8.49667117e-02f, -7.13638868e-03f, 4.20315824e-02f, -4.14916016e-02f, -2.38922536e-02f, -9.60891694e-03f, 4.24640179e-02f, -7.05707297e-02f,
  -2.57330418e-01f, -3.55394661e-01f, -3.79373841e-02f, 5.84702082e-02f, 4.29869108e-02f, 9.27634817e-03f, 1.50373923e-02f, -2.18707174e-02f, 3.27864364e-02f, -4.11651470e-02f,
  -7.00624064e-02f, -2.84394659e-02f, -8.45694467e-02f, 4.75291116e-03f, -2.09691022e-02f, -8.08838382e-03f, 5.11467271e-02f, -9.90263820e-02f, -1.11492850e-01f, -6.19989820e-02f,
  -5.46844527e-02f, -4.03116941e-02f, -7.15657277e-03f, -9.33103114e-02f, -5.63793406e-02f, -5.74794272e-03f, -1.21169649e-01f, 3.44251320e-02f, 2.03665113e-03f, 4.92993481e-02f,
  1.26462534e-01f, -3.09941202e-01f, -1.98111460e-01f, -2.40229428e-01f, 3.61022711e-01f, 2.52551675e-01f, 1.06807221e-02f, -1.22135818e-01f, -2.27389827e-01f, -2.93163598e-01f,
  5.54602742e-02f, -2.03082055e-01f, -9.99558195e-02f, -1.37239024e-01f, 3.71314764e-01f, -1.54701918e-01f, 1.19775444e-01f, -7.87847862e-02f, -4.25828584e-02f, 8.31440985e-02f,
  -1.50842564e-02f, 3.06738824e-01f, 3.17609347e-02f, 2.25471467e-01f, 1.08371206e-01f, -2.40885969e-02f, 1.28953636e-01f, 1.33358076e-01f, 1.41603425e-01f, 1.35083050e-01f,
  -8.89227688e-02f, -1.15726180e-01f, -5.72155975e-02f, -7.54797552e-03f, 4.99064215e-02f, 1.90687757e-02f, 1.17427520e-01f, 2.40952373e-02f, -1.68162212e-02f, -6.07506298e-02f,
  -4.25871136e-03f, -3.80600593e-03f, -7.88457692e-02f, 8.31647718e-04f, 9.06038880e-02f, -2.39391979e-02f, -4.86293063e-02f, 8.85153860e-02f, -1.35062054e-01f, -3.35366651e-02f,
  -3.99360945e-03f, -2.24806853e-02f, 6.19728006e-02f, -1.51654622e-02f, -2.91628540e-02f, -8.19525719e-02f, -8.10972527e-02f, 7.38894641e-02f, 2.28992719e-02f, -4.08202149e-02f,
  1.07497305e-01f, -8.22653715e-03f, 7.97726307e-03f, 7.39501230e-03f, 2.61293128e-02f, -3.22891353e-03f, 1.30566750e-02f, 6.65833279e-02f, 1.65122356e-02f, 2.15493236e-02f,
  1.85833126e-02f, -1.04902722e-01f, 4.21149889e-03f, -1.05439648e-02f, -1.50482962e-02f, -3.74392569e-02f, 3.86355557e-02f, -4.10129363e-03f, -5.63222729e-02f, 2.44127195e-02f,
  -2.41178479e-02f, 8.58288631e-02f, -4.59570177e-02f, 3.31393927e-02f, 2.26607583e-02f, -3.50837931e-02f, -2.69154459e-02f, -1.10997789e-01f, -4.50069783e-03f, 8.64187777e-02f,
  1.20262623e-01f, 9.20447893e-03f, -9.73226488e-05f, 5.67996800e-02f, -1.43939063e-01f, 1.02719285e-01f, -1.38366101e-02f, 3.22329141e-02f, 3.71872112e-02f, 6.48237690e-02f,
  1.06234409e-01f, -2.00174768e-02f, 2.79375426e-02f, 2.12334525e-02f, -2.77333166e-02f, -4.77023497e-02f, 8.31731185e-02f, -6.82153627e-02f, 1.22967526e-01f, 9.81191359e-03f,
  4.04324196e-02f, 2.09562872e-02f, -8.35383981e-02f, 7.34323934e-02f, 1.49509721e-02f, 5.25157638e-02f, 1.09789588e-01f, -1.80877849e-01f, 9.42984074e-02f, -7.93871935e-03f,
  -1.42533258e-01f, -3.18977863e-01f, 6.64802566e-02f, 8.32465440e-02f, 7.27910921e-02f, 2.29006991e-01f, -1.01310164e-01f, 5.96159957e-02f, -1.41272783e-01f, -2.28159130e-01f,
  1.11194141e-01f, -3.04697812e-01f, -7.48880580e-02f, 1.81752563e-01f, 3.20174009e-01f, -1.26667535e-02f, 1.94364816e-01f, -2.19828747e-02f, 1.31035492e-01f, 9.65845361e-02f,
  1.69866636e-01f, 1.70259491e-01f, 2.36574218e-01f, 1.88826531e-01f, 1.47000745e-01f, 1.90352499e-02f, 7.29942620e-02f, -1.90766193e-02f, 1.15894772e-01f, -2.74251564e-03f,
  5.20938188e-02f, -5.96653000e-02f, 3.03565003e-02f, -3.80355939e-02f, 1.33319259e-01f, -5.26822098e-02f, -4.52883221e-04f, -6.18915856e-02f, 5.01091070e-02f, 5.92701510e-02f,
  -3.99004035e-02f, 1.54464813e-02f, 1.63976382e-02f, -6.03469200e-02f, -3.01089119e-02f, 6.53985664e-02f, 5.63022448e-03f, 9.37260687e-02f, -1.49233462e-02f, 7.42548332e-03f,
  -2.73236688e-02f, -4.36774502e-03f, 6.39445335e-02f, 9.26503073e-03f, -6.46610409e-02f, -9.26798116e-03f, -6.91240840e-03f, -9.15821120e-02f, -3.07141356e-02f, -9.24783573e-02f,
  -7.74044767e-02f, 1.59515776e-02f, 8.52945969e-02f, 4.44368012e-02f, -1.61064463e-03f, 3.44923772e-02f, -1.23386802e-02f, 3.92045602e-02f, -4.79827374e-02f, -2.97345482e-02f,
  5.07825464e-02f, 2.27381941e-03f, 4.86684684e-03f, -5.13086431e-02f, 1.32844606e-02f, -4.09665704e-03f, 7.97858983e-02f, -4.37145419e-02f, 2.65298132e-02f, 1.55486003e-01f,
  -7.10541829e-02f, 9.09749568e-02f, 1.53301153e-02f, 9.42917774e-04f, -3.92916948e-02f, 3.31638381e-02f, 4.34912741e-02f, 1.68593377e-02f, 1.76637977e-01f, -4.36491333e-02f,
  1.70644391e-02f, -2.06233442e-01f, -1.52237769e-02f, -5.22675514e-02f, -2.83240955e-02f, 4.48013283e-02f, 3.56993405e-03f, 8.29487443e-02f, -6.50918856e-02f, 3.45235765e-02f,
  1.84881184e-02f, 4.94365406e-04f, 1.42328544e-02f, 8.03387538e-02f, 2.82801781e-02f, -4.95738126e-02f, 8.72544851e-03f, -1.50391022e-02f, 7.28988573e-02f, -7.37113804e-02f,
  7.71897566e-03f, 3.82851548e-02f, -8.36975127e-02f, 1.36292517e-01f, 3.58313061e-02f, -3.56604680e-02f, -1.23417005e-02f, -3.96063067e-02f, -1.20546308e-03f, -5.36550470e-02f,
  -2.25721896e-01f, 3.14940721e-01f, 3.17087293e-01f, -4.10186499e-02f, -3.53844196e-01f, -1.99250206e-01f, 1.05913155e-01f, -1.58387020e-01f, 7.14359581e-02f, 3.00222576e-01f,
  -1.27180234e-01f, 2.29974166e-01f, 6.42212406e-02f, 6.86835870e-02f, -2.84241378e-01f, 2.21426591e-01f, -8.78608692e-03f, 5.69476038e-02f, 1.76723301e-02f, -1.16985679e-01f,
  -6.31414503e-02f, -3.34615618e-01f, 5.06330654e-02f, -1.28550500e-01f, -1.19788684e-01f, 9.69866514e-02f, -2.49845564e-01f, 5.42838238e-02f, -1.02454700e-01f, -1.42978299e-02f,
  -1.34774938e-01f, 6.10655472e-02f, 7.29612410e-02f, 1.23109423e-01f, -1.30827725e-01f, 2.53918990e-02f, 5.46854874e-03f, 6.06150627e-02f, 7.90215749e-03f, -1.08594296e-03f,
  6.49352148e-02f, -1.26691833e-01f, 3.86236981e-02f, 9.44050476e-02f, -3.93273719e-02f, -6.83433795e-03f, -3.29428464e-02f, -1.44506190e-02f, 2.96889953e-02f, 2.96784323e-02f,
  8.21935609e-02f, 2.25650929e-02f, 9.34939086e-02f, 3.99174448e-03f, 8.11641919e-04f, -4.79378067e-02f, 1.02454543e-01f, 8.43737721e-02f, -6.44704327e-02f, -3.19156200e-02f,
  -4.22374010e-02f, 5.68066314e-02f, 8.20596144e-02f, -3.21918316e-02f, 1.35371147e-03f, -1.00692762e-02f, 3.72555256e-02f, 4.86062327e-03f, 1.63836423e-02f, -6.32764250e-02f,
  -3.38418260e-02f, 3.00629605e-02f, -9.10556540e-02f, 4.85954918e-02f, 5.99433808e-03f, 2.30936985e-02f, 3.98793332e-02f, -2.13379674e-02f, -2.40661185e-02f, -6.34735972e-02f,
  1.09205758e-02f, -1.77066531e-02f, 2.52058897e-02f, -2.48988252e-02f, -5.18452702e-03f, 4.47155312e-02f, 3.65536660e-02f, 8.33382159e-02f, -4.22220975e-02f, -9.20902044e-02f,
  -1.38688147e-01f, 2.87100265e-04f, 2.36221142e-02f, -6.04740456e-02f, 2.01691948e-02f, -2.56915782e-02f, 1.53228268e-02f, -6.49619196e-03f, 1.25350235e-02f, -5.88472113e-02f,
  -5.67287058e-02f, 4.03863229e-02f, -6.68716133e-02f, 2.60441341e-02f, -1.59583222e-02f, -3.58614177e-02f, 5.27356146e-03f, -1.30096572e-02f, -1.06261961e-01f, -3.85353826e-02f,
  -4.94811162e-02f, -5.23416400e-02f, -1.57286096e-02f, -1.63963307e-02f, 2.73458045e-02f, -1.37591669e-02f, -9.54060927e-02f, 8.33876282e-02f, -4.80775572e-02f, 2.96310131e-02f,
  -1.47242844e-01f, 7.16951266e-02f, 1.34575829e-01f, -2.23269030e-01f, 1.10284239e-01f, -3.04350168e-01f, -2.56417185e-01f, -5.20490371e-02f, -1.07251570e-01f, -2.61179388e-01f,
  1.26771312e-02f, -1.63674075e-02f, 2.45211139e-01f, -2.53930300e-01f, -7.95552284e-02f, 1.82393447e-01f, -3.07622790e-01f, -2.56451756e-01f, 1.18271671e-01f, -1.07855044e-01f,
  -1.97335035e-02f, -3.21106374e-01f, 9.59112346e-02f, -3.30058001e-02f, -8.21168870e-02f, 4.11883108e-02f, -1.24663047e-01f, 1.18090279e-01f, -1.59034833e-01f, -5.54608367e-02f,
  -1.44982830e-01f, -1.83312560e-03f, 3.24490592e-02f, -9.44692641e-02f, -5.06550372e-02f, -4.45419252e-02f, 5.07699419e-03f, 1.35161683e-01f, -1.85282889e-03f, -1.31090954e-02f,
  6.79326355e-02f, -4.64182580e-03f, -6.24420345e-02f, 3.24259102e-02f, -1.96896568e-02f, 3.82947437e-02f, 7.45004117e-02f, 4.10920456e-02f, 6.65638298e-02f, 2.91093644e-02f,
  4.55298722e-02f, 1.17258213e-01f, -8.62967875e-03f, 3.04245502e-02f, 1.37951016e-01f, -2.80301310e-02f, 3.76406014e-02f, 9.56837684e-02f, 3.25556323e-02f, -7.62531385e-02f,
  -5.17189316e-02f, -4.06773202e-03f, 9.03272107e-02f, 5.21170790e-04f, -9.45208669e-02f, 1.00553371e-02f, -3.55684459e-02f, 2.69341911e-03f, -8.43251776e-03f, 2.35418277e-03f,
  -7.45489746e-02f, 5.04538044e-02f, 1.34868883e-02f, -7.28945881e-02f, 6.76070293e-03f, -6.68749511e-02f, 4.28620614e-02f, -3.22960429e-02f, 5.05124666e-02f, 6.94053024e-02f,
  -1.78200137e-02f, -4.10863832e-02f, 5.94898574e-02f, 7.68013448e-02f, -1.10158296e-02f, -4.39858697e-02f, 1.71015167e-03f, -4.89604101e-03f, 6.24022558e-02f, -1.13021024e-03f,
  -3.22447449e-01f, -2.75302410e-01f, -3.76136601e-02f, -2.18368266e-02f, -1.62635297e-01f, -5.45117594e-02f, -4.12387028e-02f, 7.32492507e-02f, -6.34504184e-02f, -3.65797989e-02f,
  1.27485972e-02f, -6.92133680e-02f, 6.99889241e-03f, -4.33272012e-02f, -7.60792047e-02f, -5.62724844e-02f, -2.99771577e-02f, -6.93574324e-02f, -1.17371090e-01f, -1.19877353e-01f,
  -9.12841186e-02f, -9.94618386e-02f, 2.69858651e-02f, -4.72113267e-02f, -1.23651750e-01f, -4.14382517e-02f, -7.77564868e-02f, 7.53617613e-03f, -1.72433406e-02f, -8.72861408e-03f,
  -9.10899863e-02f, 2.32792616e-01f, 3.33293617e-01f, 4.79714796e-02f, 1.95647180e-01f, 1.34293154e-01f, -3.55276972e-01f, 2.89953470e-01f, -2.86607385e-01f, -6.09983057e-02f,
  -3.93587649e-01f, -9.28470865e-03f, -2.85904020e-01f, -7.85264894e-02f, -5.44959567e-02f, -2.33462632e-01f, -8.93973466e-03f, -1.46349117e-01f, -1.04313709e-01f, 5.26421033e-02f,
  6.36291653e-02f, -8.64777714e-02f, 1.50022715e-01f, 2.55037218e-01f, 1.72505360e-02f, 1.27705306e-01f, -2.42752153e-02f, 3.99378389e-02f, 1.11084417e-01f, -6.01061843e-02f,
  1.58440337e-01f, -1.17040440e-01f, 5.59207834e-02f, 2.74302587e-02f, 1.03807919e-01f, 5.65002151e-02f, -5.59482053e-02f, -1.30153880e-01f, -5.41085899e-02f, 1.08703844e-01f,
  -3.43978815e-02f, 9.99915227e-02f, 3.67102516e-03f, -9.54110846e-02f, 5.49098998e-02f, 1.15421489e-01f, 5.60634881e-02f, -3.26207764e-02f, 3.90079319e-02f, 3.42779653e-03f,
  -6.77133426e-02f, 5.80611825e-02f, -6.63391799e-02f, -2.65550558e-02f, -2.69112065e-02f, -3.44693437e-02f, -3.97056788e-02f, -7.99822882e-02f, 5.56410663e-02f, 7.03240186e-02f,
  -4.90312167e-02f, 4.05260781e-03f, -2.01091804e-02f, 7.94693977e-02f, -4.46908884e-02f, -1.74263921e-02f, -6.00375177e-04f, 6.39204755e-02f, 6.14661388e-02f, 4.39735055e-02f,
  -2.04917472e-02f, -9.39454840e-05f, -3.91282700e-02f, -8.53556395e-03f, -9.40625519e-02f, -3.91319022e-02f, 9.84726101e-03f, -6.45274743e-02f, -1.23883031e-01f, -2.09058952e-02f,
  -1.44736931e-01f, -1.10079207e-01f, -1.25286773e-01f, -2.00296082e-02f, 1.68404747e-02f, 5.57206757e-03f, -1.75619107e-02f, 4.42452207e-02f, 2.32404731e-02f, -2.11045630e-02f,
  1.66280240e-01f, 1.46570904e-02f, -2.00531613e-02f, 8.11566133e-03f, -1.32590225e-02f, 2.52998732e-02f, 1.34312501e-02f, -2.61081643e-02f, 1.45565987e-01f, -4.85195294e-02f,
  1.51706040e-01f, 6.83269724e-02f, 1.78234100e-01f, -1.18837379e-01f, -3.80909741e-02f, 2.16931049e-02f, -1.43158585e-01f, -7.37999231e-02f, -2.68130712e-02f, 7.61372447e-02f,
  3.55500840e-02f, 5.45800701e-02f, 1.01383537e-01f, 7.65545666e-02f, 1.16325341e-01f, -7.94148818e-02f, 2.67186500e-02f, -5.71036488e-02f, 5.33406399e-02f, 1.00152679e-01f,
  3.45915169e-01f, -1.44790545e-01f, 2.13653550e-01f, -2.68562771e-02f, 1.11144811e-01f, 2.80318171e-01f, 2.48187780e-01f, -1.50831297e-01f, 7.41090765e-03f, 9.35001522e-02f,
  -3.48187536e-02f, 8.20143148e-02f, -8.06340799e-02f, -1.25992388e-01f, -5.03728800e-02f, -1.58739880e-01f, 1.32824004e-01f, 2.56662905e-01f, -1.03798181e-01f, 1.23475085e-03f,
  7.24180266e-02f, -1.76116183e-01f, -4.90879901e-02f, -2.36041337e-01f, 1.59316942e-01f, -3.51420939e-02f, 9.21793631e-04f, -6.99546328e-03f, 4.76448387e-02f, -6.24238998e-02f,
  1.03047691e-01f, 1.63482264e-01f, 3.05455104e-02f, 1.33730263e-01f, 1.19532362e-01f, 1.06831811e-01f, 1.49545610e-01f, -7.81103224e-02f, -7.31735677e-02f, -4.21275161e-02f,
  1.25718623e-01f, -7.29653612e-02f, -1.51532203e-01f, -4.58553731e-02f, 8.47287476e-02f, 1.29623383e-01f, 3.32863294e-02f, 3.28655727e-02f, -4.48783347e-03f, 1.24748617e-01f,
  5.55897839e-02f, -2.91784797e-02f, 1.29730344e-01f, 3.13058756e-02f, 1.09769486e-01f, 4.36527804e-02f, -1.21793000e-03f, 3.07826120e-02f, 1.80283785e-01f, 6.84710890e-02f,
  1.65972393e-02f, 6.08991720e-02f, 9.52802822e-02f, 7.46682938e-03f, -4.70696837e-02f, -9.42675397e-03f, 1.74718425e-02f, -4.98098396e-02f, -2.67724451e-02f, 3.01372763e-02f,
  -2.71977168e-02f, -1.67519611e-03f, 3.17369923e-02f, 1.51453391e-01f, -6.47748038e-02f, 6.25569075e-02f, 2.63441391e-02f, 1.44028500e-01f, -6.20151423e-02f, 5.11649922e-02f,
  -8.72219261e-03f, -4.65536639e-02f, -7.62685239e-02f, -1.10545456e-01f, 4.33581322e-02f, -6.69134557e-02f, -1.06716663e-01f, -1.57160535e-02f, 7.36050829e-02f, -2.14509722e-02f,
  3.10860068e-01f, 3.23996335e-01f, -4.75734356e-04f, 1.42371252e-01f, -3.55813131e-02f, 3.29657495e-02f, -1.08109549e-01f, -9.22893919e-03f, 1.37166843e-01f, 4.69191298e-02f,
  9.17334631e-02f, 3.85947935e-02f, -3.81265245e-02f, 8.08710828e-02f, 8.38335138e-03f, -7.93441162e-02f, 5.93064949e-02f, 1.33409575e-01f, 1.50040776e-01f, -9.75696370e-03f,
  7.97407106e-02f, -3.02075427e-02f, -1.00318203e-02f, -9.67250578e-03f, 4.43279967e-02f, 6.03834279e-02f, 4.45271209e-02f, 5.89910476e-03f, 9.99710783e-02f, -4.02991213e-02f,
  3.55831265e-01f, -4.08749372e-01f, 1.16762318e-01f, 1.70663595e-02f, -5.39955050e-02f, -8.87984782e-02f, -6.00345470e-02f, -2.23613143e-01f, -2.61087835e-01f, -2.27476105e-01f,
  -1.55788377e-01f, 3.27931680e-02f, -1.89462036e-01f, -2.22445562e-01f, -2.83354707e-02f, -3.46731305e-01f, -9.57436338e-02f, -2.82662790e-02f, -1.39394209e-01f, -2.14284107e-01f,
  -3.68062407e-02f, -3.06248754e-01f, 3.28178518e-02f, -2.73753285e-01f, 4.06777114e-02f, 1.23441992e-02f, -1.40736513e-02f, -6.36803210e-02f, 9.25314873e-02f, 1.41820209e-02f,
  9.48750898e-02f, -7.24946633e-02f, -9.10147652e-03f, 6.89380765e-02f, 1.20179743e-01f, 1.43987358e-01f, 1.70562446e-01f, 3.53634804e-02f, 3.52218300e-02f, 2.12989431e-02f,
  3.30003873e-02f, -2.11101435e-02f, -1.59536228e-02f, -1.08378502e-02f, 4.49128486e-02f, 4.48073149e-02f, 2.83048674e-02f, 1.65031150e-01f, -8.46376866e-02f, 3.42849120e-02f,
  5.76111339e-02f, 9.98540595e-02f, 1.13977738e-01f, -7.35681830e-03f, -1.35342944e-02f, -3.50685269e-02f, 4.86587510e-02f, 4.79310155e-02f, 1.40752119e-03f, -4.79302742e-02f,
  6.15636166e-03f, -3.32324468e-02f, 7.12971436e-03f, 6.70249462e-02f, -6.31535351e-02f, 4.13899682e-02f, -2.30463091e-02f, 2.15530749e-02f, 2.43297797e-02f, -1.49776451e-02f,
  -1.05505274e-03f, 4.24946100e-02f, 1.20447008e-02f, 2.54013911e-02f, 1.13125397e-02f, 8.26458782e-02f, 6.56769127e-02f, 5.43891499e-03f, 6.63620159e-02f, 1.30438671e-01f,
  -2.25414652e-02f, -1.39162745e-02f, -2.27542780e-02f, 9.11898315e-02f, -5.13301278e-03f, 1.07423775e-02f, -5.73797338e-02f, 2.62440927e-02f, 2.07658149e-02f, 4.92415130e-02f,
  -2.71686763e-01f, -3.48188132e-01f, -5.39099798e-02f, -8.00071564e-03f, -4.95884344e-02f, -3.38542871e-02f, -4.79599349e-02f, -3.20905000e-02f, -1.00109681e-01f, -6.34416416e-02f,
  6.90957308e-02f, 5.05444705e-02f, 3.28753218e-02f, 2.03599203e-02f, 6.03108853e-02f, -3.24260071e-02f, -9.46698990e-03f, 5.36685251e-03f, -2.43167933e-02f, -2.12488323e-02f,
  2.79485956e-02f, -8.19646865e-02f, 1.02778915e-02f, -5.09801582e-02f, 6.80674314e-02f, 7.20217079e-02f, -1.19842373e-01f, -3.42715047e-02f, 3.15348096e-02f, 4.80235415e-03f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.73812434e-01f, 7.48193497e-03f, -2.01232702e-01f, -2.28050962e-01f, 1.69100240e-01f, -8.19879398e-02f, -1.83983371e-02f, -1.21146098e-01f, -7.24037811e-02f, 3.15611333e-01f,
  -1.30652962e-02f, -6.60991743e-02f, 1.16134770e-01f, -5.03642321e-01f, -7.41485298e-01f, -4.93669152e-01f, -4.75792050e-01f, -2.54793346e-01f, -1.23255782e-01f, -7.07234144e-02f,
  -2.55016208e-01f, -2.08280027e-01f, -2.36451015e-01f, 8.81135389e-02f, 1.51357442e-01f, 3.06058705e-01f, 3.16556215e-01f, 3.77548337e-01f, -8.49400833e-03f, -1.13734335e-01f,
  -1.29701808e-01f, -9.18902308e-02f, 1.42068148e-01f, -1.95630714e-02f, 3.52338366e-02f, 2.06138313e-01f, 2.02529095e-02f, -1.14335127e-01f, -3.76575477e-02f, -1.08231246e-01f,
  1.94079563e-01f, -6.16214275e-02f, -7.39357620e-02f, -1.08808979e-01f, 1.59732059e-01f, 2.06994787e-02f, -1.07253544e-01f, 7.77404234e-02f, 9.42131579e-02f, -1.78368136e-01f,
  1.39747746e-02f, 6.14364669e-02f, 3.62330005e-02f, 6.96534431e-03f, 1.17523540e-02f, 6.58774329e-03f, -1.05237834e-01f, -7.56604876e-03f, 5.90629205e-02f, -1.00326061e-01f,
  -7.16916844e-03f, 1.87579274e-01f, 1.27202839e-01f, -4.09655757e-02f, -6.88609257e-02f, -2.68677063e-02f, 7.74116069e-02f, -4.76850681e-02f, 2.09133029e-01f, -2.50912532e-02f,
  6.19084053e-02f, 4.10387442e-02f, -8.54358301e-02f, -1.98283349e-03f, 5.28779887e-02f, -1.22890491e-02f, -2.33556312e-02f, -1.89513341e-02f, -1.26929851e-02f, -1.18122213e-02f,
  1.37099409e-02f, -2.12734099e-02f, -8.32787529e-02f, 1.12542778e-01f, -1.68304667e-01f, 6.58525303e-02f, 5.62690273e-02f, -7.56192356e-02f, -9.70931128e-02f, 1.58083495e-02f,
  5.27987666e-02f, 9.75371748e-02f, -1.11924550e-02f, -8.64792168e-02f, -3.33173834e-02f, -1.26334454e-03f, -7.26602599e-02f, -1.93369374e-01f, 1.17211333e-02f, -4.13453877e-02f,
  7.84843490e-02f, 9.29849222e-02f, 1.67193085e-01f, -1.65672392e-01f, 1.60913542e-02f, -7.30887353e-02f, 1.02102570e-01f, 1.42276287e-01f, 6.76811561e-02f, 9.34045911e-02f,
  1.05836816e-01f, 2.16628209e-01f, -6.08939352e-03f, 8.98425803e-02f, 1.95405409e-01f, 8.82295817e-02f, 1.28170311e-01f, 1.67862922e-02f, 8.81868675e-02f, 3.29564773e-02f,
  3.13780427e-01f, 3.48925412e-01f, 1.64925143e-01f, 4.57227051e-01f, -2.45653510e-01f, -4.02269751e-01f, -1.57125905e-01f, -4.58884947e-02f, 5.93405962e-01f, -7.26338848e-02f,
  -2.34175846e-01f, 3.59258026e-01f, -2.78821923e-02f, -1.36364773e-01f, 3.94151956e-01f, 7.99270347e-02f, 6.60864934e-02f, -1.02644637e-01f, 1.96236238e-01f, 3.30043063e-02f,
  3.32374394e-01f, -2.73519278e-01f, -8.28409288e-03f, -2.12057531e-01f, -3.81246388e-01f, 1.99251011e-01f, -6.97187036e-02f, -2.08429113e-01f, -2.25644991e-01f, -1.52553067e-01f,
  -1.52775139e-01f, 2.23102406e-01f, -2.69108489e-02f, 1.55355990e-01f, 5.97484894e-02f, -2.09912270e-01f, 1.02859236e-01f, -5.08507639e-02f, 8.22973475e-02f, 1.35244951e-01f,
  8.17295015e-02f, 3.84465158e-02f, 1.54623538e-01f, -3.47574279e-02f, 2.06482299e-02f, 4.86808345e-02f, 7.77120963e-02f, -5.92951030e-02f, 1.85821066e-03f, -5.22591881e-02f,
  -1.06661893e-01f, 1.10062025e-03f, 2.83406507e-02f, 2.04250395e-01f, 2.19277933e-01f, 1.11632302e-01f, 2.68301442e-02f, 1.23965396e-02f, -9.61035565e-02f, 1.50008857e-01f,
  3.96375498e-03f, 9.45623890e-02f, -4.83228453e-03f, -1.23533599e-01f, -1.05132632e-01f, 1.44955218e-02f, 1.37301460e-01f, -7.21752122e-02f, 1.27714857e-01f, -5.59714064e-02f,
  7.19524594e-03f, 1.05171859e-01f, -4.86739166e-02f, 2.40397323e-02f, 1.99946426e-02f, 5.81182577e-02f, 1.81695335e-02f, 6.74251691e-02f, 4.62002754e-02f, -8.56656507e-02f,
  -4.29880358e-02f, -6.35959432e-02f, -5.91392703e-02f, -2.63158619e-01f, -9.93923992e-02f, 8.82907063e-02f, 1.21752557e-03f, 5.24780974e-02f, -1.25183493e-01f, -1.42006561e-01f,
  8.23146626e-02f, 3.35869610e-01f, 5.34668714e-02f, 5.73471822e-02f, 5.84563985e-02f, 5.52921407e-02f, 1.40661791e-01f, 1.23849183e-01f, 1.80286601e-01f, -3.22554111e-02f,
  4.82886052e-03f, -1.04802586e-01f, -2.33087894e-02f, -7.33575523e-02f, 5.97256720e-02f, 8.10241848e-02f, 2.21438542e-01f, 1.85988784e-01f, 1.10630848e-01f, -2.41090190e-02f,
  -9.76689309e-02f, 9.72269177e-02f, 1.01124994e-01f, -3.39393038e-03f, 4.31680307e-02f, 1.19817935e-01f, -2.19415836e-02f, 4.10672054e-02f, 1.97307765e-02f, 1.40447110e-01f,
  -7.18247831e-01f, -1.48301825e-01f, -2.93091416e-01f, -8.83905292e-02f, -1.61798596e-01f, 3.22091252e-01f, 2.76258200e-01f, -1.15518451e-01f, -2.71702528e-01f, 2.11208552e-01f,
  2.79863775e-01f, -2.36265808e-01f, 9.15980563e-02f, 5.72497785e-01f, 1.58314198e-01f, 3.72044086e-01f, 4.01946694e-01f, 3.38299006e-01f, -4.61947406e-03f, -2.07213029e-01f,
  2.84740273e-02f, 4.15346682e-01f, 2.27436125e-01f, 8.54292139e-02f, 1.82503983e-01f, -2.72449017e-01f, 2.04141542e-01f, -1.85633108e-01f, 4.03990120e-01f, 3.10637057e-01f,
  -9.95428264e-02f, -4.15883720e-01f, -1.20792575e-01f, -2.90996283e-02f, 2.11610254e-02f, -6.70942739e-02f, 6.25901073e-02f, 3.53850890e-03f, -1.52547643e-01f, -4.55988571e-02f,
  2.78811413e-03f, -2.61506718e-02f, 1.38587579e-02f, -8.56767595e-02f, -6.75428733e-02f, -1.51536232e-02f, 6.56307340e-02f, 6.05687797e-02f, -4.82712425e-02f, -9.82927084e-02f,
  -7.15475604e-02f, 1.17446303e-01f, 9.15216655e-02f, 1.66209206e-01f, -1.20513365e-02f, 6.18327968e-02f, 7.12950081e-02f, 1.11453654e-03f, 7.61795938e-02f, 3.62041802e-03f,
  6.09830208e-02f, 3.24238501e-02f, 2.67840512e-02f, 8.46977234e-02f, -5.03688492e-02f, 1.15522884e-01f, 7.07648844e-02f, 1.67408556e-01f, -2.51633823e-02f, 1.25918789e-02f,
  -3.25666331e-02f, 4.26134607e-03f, -4.77484576e-02f, -1.77256279e-02f, 2.68708430e-02f, 1.12457923e-03f, 6.06289716e-04f, -3.13319825e-02f, 6.45428747e-02f, 8.04416314e-02f,
  -7.96613619e-02f, -4.53133136e-02f, 5.79685578e-03f, 1.15970649e-01f, -1.93640068e-02f, -7.55602717e-02f, -4.52461280e-03f, -2.38005747e-03f, -4.35185358e-02f, 2.22200551e-03f,
  -2.60914594e-01f, -5.20468473e-01f, -8.09345916e-02f, -1.26345921e-02f, -2.81914640e-02f, -6.51610643e-03f, 1.89428329e-02f, -5.10926396e-02f, -5.56766689e-02f, -7.53937736e-02f,
  -4.38171551e-02f, 5.53310998e-02f, -1.02776997e-01f, -7.26272538e-02f, 9.20861289e-02f, -9.17332619e-02f, -5.91304572e-03f, -8.05789456e-02f, 6.43216595e-02f, -6.00251295e-02f,
  -9.54497606e-02f, -7.61114955e-02f, 3.61602940e-02f, 3.00202928e-02f, 1.70719728e-01f, 4.10866626e-02f, -1.70178592e-01f, 7.32565746e-02f, 1.11184157e-01f, 1.57751571e-02f,
  2.16134921e-01f, 2.88730383e-01f, 4.18503016e-01f, -1.44424394e-01f, -5.95484488e-02f, 9.41615626e-02f, -1.72259510e-01f, -8.45421553e-02f, -1.74257830e-01f, 3.12905073e-01f,
  -1.36177674e-01f, 3.97859424e-01f, -1.21822640e-01f, -1.99141875e-01f, -4.00298804e-01f, -3.85348499e-01f, -2.25818366e-01f, 1.48834869e-01f, -2.40658090e-01f, 2.00307056e-01f,
  -1.29832074e-01f, -3.70409310e-01f, -2.10122347e-01f, -2.10328549e-01f, 3.05644542e-01f, 2.79486239e-01f, -1.19895488e-01f, 1.12307638e-01f, 3.24029595e-01f, -2.48621449e-01f,
  1.95543356e-02f, -6.75034225e-02f, 2.08086967e-01f, 1.50180250e-01f, 9.80890542e-02f, 1.37188837e-01f, 1.83187276e-01f, -4.31709178e-02f, -8.61113667e-02f, -7.71702034e-03f,
  7.71285594e-02f, -7.90000856e-02f, 7.68796429e-02f, -9.27828103e-02f, 4.02838774e-02f, 3.79522070e-02f, 1.96785796e-02f, 2.86872029e-01f, 8.07198137e-02f, 1.09921560e-01f,
  1.31185055e-01f, 2.85080224e-01f, -8.23886320e-03f, -1.73268653e-03f, 1.18934810e-02f, -4.72189933e-02f, 2.01474875e-01f, 3.40875000e-01f, -3.38593610e-02f, 1.28798829e-02f,
  4.57581431e-02f, 6.50115833e-02f, -3.24830785e-02f, -8.78368020e-02f, -1.18739188e-01f, -1.95516080e-01f, -6.09480478e-02f, -1.43455848e-01f, -3.28729972e-02f, 1.65427122e-02f,
  5.34136556e-02f, 1.06893472e-01f, -9.07581821e-02f, 4.33589891e-02f, -4.42373529e-02f, 7.99704120e-02f, 3.75349843e-03f, 1.24449581e-01f, 6.78556189e-02f, 4.20501567e-02f,
  -2.27038696e-01f, -7.51034543e-02f, -8.94767642e-02f, 2.13931985e-02f, -4.54208627e-02f, 4.08335291e-02f, -3.26606520e-02f, 6.08217604e-02f, -4.80763875e-02f, 2.59334221e-02f,
  1.11221731e-01f, -1.62201263e-02f, 2.76855864e-02f, 3.58831920e-02f, 3.84845887e-03f, 2.34944895e-01f, -1.08050808e-01f, -6.37085438e-02f, 2.69036889e-02f, -7.02944994e-02f,
  1.29386887e-01f, 9.56732035e-02f, 1.33692995e-01f, -3.43385413e-02f, -1.80760100e-01f, 7.94795007e-02f, -1.02746263e-01f, 5.38433064e-03f, -8.13724194e-03f, 1.22182049e-01f,
  8.44276547e-02f, 8.55610296e-02f, -1.51724160e-01f, 1.45002352e-02f, 7.15418719e-03f, 1.32219508e-01f, 1.75352246e-01f, 1.39736265e-01f, 8.99115205e-02f, 7.25705773e-02f,
  1.34187818e-01f, -6.83873966e-02f, 2.62931347e-01f, 4.57876828e-03f, 3.40665758e-01f, 1.68410853e-01f, 6.86497763e-02f, 1.94374591e-01f, 8.38565752e-02f, -2.25434124e-01f,
  -1.19956005e-02f, -3.92982811e-01f, -3.65777239e-02f, 1.06913932e-02f, -3.27094913e-01f, -9.55587327e-02f, -2.78475225e-01f, -2.43133634e-01f, 2.13127825e-02f, -2.95312461e-02f,
  -3.05712223e-02f, 4.57479320e-02f, 1.39898822e-01f, 9.00212377e-02f, 3.18219274e-01f, 2.82446798e-02f, -1.94866776e-01f, -1.01742940e-02f, -1.92979351e-01f, -2.22364161e-02f,
  2.27176026e-01f, 2.21649185e-01f, 3.27681929e-01f, 1.03859201e-01f, 2.77160034e-02f, 3.96677703e-02f, -6.31495714e-02f, 4.18167450e-02f, 1.55050293e-01f, 4.22569215e-02f,
  -1.05674051e-01f, -3.07411365e-02f, -1.02940924e-01f, -1.02148764e-02f, 2.09312737e-01f, 1.26029104e-01f, 2.35727355e-01f, 1.89013153e-01f, -1.34305768e-02f, 7.31291994e-02f,
  1.13902591e-01f, -1.03463151e-01f, -6.54554293e-02f, -1.28435075e-01f, -4.80313338e-02f, -6.22452833e-02f, -1.90286547e-01f, -1.31314695e-01f, -1.73170175e-02f, -6.53988644e-02f,
  -7.57323951e-02f, -1.67416617e-01f, 4.22177874e-02f, 1.75990209e-01f, 7.03764930e-02f, 1.13974728e-01f, -8.46307427e-02f, -3.74233839e-03f, -1.12299286e-02f, -7.96925277e-02f,
  2.64323056e-02f, -1.01070255e-02f, 7.61992633e-02f, 3.34794447e-02f, -2.48649847e-02f, 1.18564162e-02f, -3.46380249e-02f, -3.00237965e-02f, -9.96058136e-02f, 2.72848941e-02f,
  -5.56976832e-02f, -1.05928086e-01f, 1.10602915e-01f, 8.95008892e-02f, -5.28306758e-04f, -8.36310610e-02f, 7.06402771e-03f, 1.93263724e-01f, 1.87146887e-01f, -1.66534141e-01f,
  -2.42714137e-02f, -3.37820143e-01f, 8.05628151e-02f, 3.50840800e-02f, 7.83869475e-02f, 7.79660046e-02f, 1.29165664e-01f, -7.99878612e-02f, -9.50174481e-02f, 4.89077345e-03f,
  -6.65339455e-02f, 8.22564438e-02f, -7.00458959e-02f, 5.53859305e-03f, -1.42467603e-01f, 7.79159889e-02f, -1.50638252e-01f, -1.06811345e-01f, -5.05921431e-02f, -2.19474509e-01f,
  -8.36402997e-02f, -9.44819525e-02f, -1.45564452e-01f, -9.93152335e-02f, -1.69542015e-01f, -1.11561969e-01f, -7.47300088e-02f, -1.03080548e-01f, -1.80618182e-01f, -4.63020056e-02f,
  -4.99536723e-01f, 3.43263626e-01f, -6.52283788e-01f, -3.54762405e-01f, 4.41617876e-01f, 7.15434700e-02f, -9.11072791e-02f, 1.16192974e-01f, -3.54020059e-01f, 3.57570767e-01f,
  2.70344466e-01f, -2.11191237e-01f, -2.00107023e-01f, -5.36713302e-02f, -5.45342386e-01f, -4.26519126e-01f, -8.72731432e-02f, 2.61714831e-02f, -3.13472062e-01f, 8.37433264e-02f,
  -2.29240194e-01f, 2.09482312e-01f, -4.48873669e-01f, 3.71658921e-01f, 2.22956091e-01f, 8.96139443e-03f, 3.10569018e-01f, 2.13962253e-02f, 2.77267605e-01f, 1.26164585e-01f,
  -8.81007537e-02f, -1.48172110e-01f, -1.83984339e-01f, -9.15279910e-02f, -1.83343440e-02f, 6.59404472e-02f, -9.16193984e-03f, -1.35031953e-01f, -5.22578396e-02f, -9.19029415e-02f,
  8.07297975e-03f, -3.33412215e-02f, 3.44706401e-02f, 1.11714676e-02f, 7.53580853e-02f, 1.97619591e-02f, -7.38816569e-03f, -1.14597067e-01f, 7.46443421e-02f, -1.64344534e-01f,
  -2.04527080e-01f, -7.99281821e-02f, -4.94291782e-02f, -6.48388416e-02f, -2.02443466e-01f, 8.27328265e-02f, -1.68971494e-01f, 4.45768535e-02f, 1.07939892e-01f, 1.66873187e-02f,
  1.59397081e-01f, 9.17063877e-02f, -8.52778479e-02f, -1.40123680e-01f, -1.62424073e-01f, 7.78973177e-02f, 1.20606609e-01f, 5.36678173e-02f, -7.61504620e-02f, 7.08171725e-02f,
  2.35572550e-02f, 5.23355491e-02f, 5.05835265e-02f, -3.59383188e-02f, -2.17876568e-01f, -1.88993532e-02f, 6.71242084e-03f, 1.11964554e-01f, -3.41289826e-02f, -5.74235916e-02f,
  -8.46498907e-02f, -1.11780636e-01f, -2.11874750e-02f, 5.12059890e-02f, -2.33729929e-03f, -1.04713261e-01f, 4.58488502e-02f, -4.20326069e-02f, -5.36281317e-02f, 1.35329887e-02f,
  1.26057595e-01f, -2.91938260e-02f, -7.81043544e-02f, 1.26345813e-01f, -4.38683592e-02f, 1.60745271e-02f, -1.29876792e-01f, 9.80245471e-02f, -7.89179876e-02f, -1.26511967e-02f,
  2.17727129e-03f, 1.18737273e-01f, 9.33715925e-02f, -2.48031821e-02f, 1.21441290e-01f, 9.38104317e-02f, 1.13919154e-01f, -3.21718752e-02f, 1.53865874e-01f, 2.21536644e-02f,
  1.69180334e-01f, 1.60527036e-01f, -4.62313145e-02f, 8.53870958e-02f, 1.26302302e-01f, 1.23882972e-01f, 1.01739869e-01f, -1.68585423e-02f, 5.57454117e-02f, -4.39532809e-02f,
  -1.94828779e-01f, -1.43716410e-01f, 3.37537646e-01f, -2.86289424e-01f, -1.23295695e-01f, 3.06616336e-01f, 3.27466637e-01f, -1.76994219e-01f, -1.99511498e-01f, -2.56238788e-01f,
  -3.21253359e-01f, 2.55253375e-01f, 3.51612985e-01f, -2.60324538e-01f, 6.24107778e-01f, 3.91237020e-01f, -1.80490971e-01f, -8.12768787e-02f, -1.61560908e-01f, -9.82008055e-02f,
  -6.15674630e-02f, -3.51929158e-01f, 8.13452676e-02f, -2.85499454e-01f, -2.90582746e-01f, -2.63958126e-01f, -1.08080797e-01f, 1.12620920e-01f, -2.63353258e-01f, -4.18060906e-02f,
  -5.38042597e-02f, -1.94963947e-01f, -7.22742602e-02f, -5.69009259e-02f, -1.03871785e-01f, 7.15847984e-02f, 5.89083061e-02f, 2.21513703e-01f, 9.58785489e-02f, 1.06019363e-01f,
  9.92880687e-02f, 1.00398347e-01f, -2.05721125e-01f, 1.16262630e-01f, -5.86364456e-02f, -2.18955547e-01f, -1.12618685e-01f, -1.15528904e-01f, -8.74643028e-02f, -3.25266570e-02f,
  -6.98788464e-03f, -4.23017666e-02f, -2.31798023e-01f, -5.70834167e-02f, -4.25328501e-02f, -2.38952383e-01f, 1.43494770e-01f, 1.45242989e-01f, -1.07762598e-01f, -1.94449890e-02f,
  -3.42593193e-02f, 2.19869204e-02f, -9.52981412e-03f, -1.54158575e-02f, -9.18337554e-02f, -2.05233753e-01f, 5.84639683e-02f, -5.46143577e-02f, -1.34378567e-01f, -2.01642081e-01f,
  1.14371870e-02f, 2.43665017e-02f, -2.07111482e-02f, -1.08277105e-01f, -2.20764741e-01f, -4.12764922e-02f, 6.41427487e-02f, -4.75104488e-02f, -3.45125347e-02f, -1.09515943e-01f,
  3.51409167e-02f, -1.22347416e-03f, 4.02055122e-02f, -1.14489369e-01f, 4.62343963e-03f, 3.15457545e-02f, -8.78443420e-02f, 3.91240492e-02f, -5.49302325e-02f, 5.15626073e-02f,
  6.87395502e-03f, -5.79910204e-02f, -1.47929907e-01f, -5.04466370e-02f, 1.99079942e-02f, 3.20116542e-02f, 8.35468471e-02f, -1.99875966e-01f, 1.59879550e-02f, -5.32940309e-03f,
  -1.96766421e-01f, -4.72096615e-02f, 9.06822160e-02f, -8.36589932e-03f, 6.46351427e-02f, -8.03139508e-02f, 1.24413602e-01f, 9.16030332e-02f, 1.07158504e-01f, -1.40016556e-01f,
  -7.61751458e-02f, 1.00213446e-01f, -6.46170154e-02f, -4.50228639e-02f, -1.40887916e-01f, -1.23432964e-01f, 1.03105910e-01f, -1.10332340e-01f, 3.12086605e-02f, 6.57793730e-02f,
  3.08935434e-01f, 4.24639493e-01f, -7.99809396e-02f, 3.63742679e-01f, -2.25993350e-01f, 4.45947170e-01f, 4.26822305e-01f, 6.88117370e-02f, 2.60509968e-01f, 4.19361502e-01f,
  6.26284778e-02f, 3.63405436e-01f, -1.87035248e-01f, 4.58865345e-01f, -1.64316520e-01f, 1.17389455e-01f, 4.53328073e-01f, 4.11707520e-01f, -3.75514999e-02f, 1.59773633e-01f,
  -3.31070600e-03f, 5.79515398e-02f, -1.23640567e-01f, -2.20279142e-01f, 1.59443542e-01f, -5.71507365e-02f, -3.47810119e-01f, -3.04709554e-01f, 7.96691328e-02f, -1.25670373e-01f,
  1.45724967e-01f, 7.93859959e-02f, 9.14950110e-03f, -4.75071184e-02f, -2.27617230e-02f, -6.35650232e-02f, 6.57232776e-02f, -5.82430996e-02f, -1.08462468e-01f, 1.02539621e-02f,
  6.13025799e-02f, -7.99151510e-02f, 1.21379644e-01f, 5.71542978e-03f, -3.01547255e-02f, -3.02004367e-02f, 1.17215617e-02f, 3.43294479e-02f, 7.96652585e-02f, 7.05903098e-02f,
  1.77680448e-01f, 8.17943066e-02f, 1.03339359e-01f, 3.86251020e-03f, -9.43057835e-02f, -3.32016721e-02f, 9.47454423e-02f, 1.62079707e-02f, 2.03644186e-01f, 1.90097447e-02f,
  5.01814745e-02f, 7.06232935e-02f, -2.70168371e-02f, -3.90642905e-04f, -6.05656318e-02f, -1.54867247e-01f, -1.49186598e-02f, -9.48552340e-02f, 1.72035694e-02f, -2.54508872e-02f,
  3.46134193e-02f, 6.54013306e-02f, -6.88640110e-04f, 1.32938474e-01f, 9.70189944e-02f, 5.09638563e-02f, -9.00190398e-02f, -1.72720701e-02f, 1.31169587e-01f, 3.58539596e-02f,
  -6.07595518e-02f, 1.45357512e-02f, 2.89927386e-02f, -8.50957446e-03f, -3.81393777e-03f, -9.59622785e-02f, 7.60952309e-02f, -5.42113371e-03f, -1.41085051e-02f, -9.36533883e-02f,
  1.71710834e-01f, 1.14422597e-01f, 6.33348301e-02f, -9.19144079e-02f, -6.17895536e-02f, 5.71153983e-02f, 4.59711300e-03f, 1.30771905e-01f, -1.03924731e-02f, 7.46227801e-02f,
  -2.89062355e-02f, 2.68028062e-02f, 4.33565676e-02f, -1.28589971e-02f, -5.06460182e-02f, 1.05509110e-01f, -6.37481548e-03f, 2.48352345e-03f, 3.09695546e-02f, 5.58002144e-02f,
  -4.64007817e-02f, 1.02675498e-01f, -1.75336078e-02f, 3.31580788e-02f, 3.06868348e-02f, -2.70522814e-02f, 2.41464954e-02f, -1.18022971e-01f, -2.24908683e-02f, -2.76544993e-03f,
  -1.07390404e-01f, 3.17301065e-01f, 3.49598855e-01f, -1.65542245e-01f, 2.20041141e-01f, -3.05593878e-01f, 6.41768351e-02f, 3.09018344e-01f, 2.65099734e-01f, 2.89651901e-01f,
  -2.30151936e-01f, 7.90092573e-02f, 1.93174724e-02f, -1.88605547e-01f, -5.32141984e-01f, -4.46148127e-01f, -4.24760044e-01f, -3.44562978e-01f, -9.62833613e-02f, -2.14543670e-01f,
  -1.87457249e-01f, -3.06915075e-01f, -7.05471858e-02f, 2.19317898e-01f, 3.39603484e-01f, 3.95872027e-01f, -3.00496221e-01f, 1.74885496e-01f, -1.46407142e-01f, -1.18583255e-01f,
  -1.01218902e-01f, 2.79647142e-01f, 2.96145588e-01f, 6.38890490e-02f, -2.06146315e-02f, -2.94348728e-02f, 1.25228881e-03f, 1.50949704e-02f, 4.15435508e-02f, 1.65869296e-02f,
  4.46967818e-02f, 9.52127948e-02f, -4.04121466e-02f, 2.29625311e-02f, 2.23469749e-01f, 1.28366590e-01f, 9.28369444e-03f, 9.60097015e-02f, 1.38674006e-01f, 7.60235861e-02f,
  8.65826607e-02f, -1.98959187e-02f, 3.17027122e-02f, -1.93036586e-01f, 1.07279338e-01f, 1.11582108e-01f, -2.53843237e-02f, 2.58616414e-02f, 6.58195317e-02f, 1.03515133e-01f,
  -1.61539987e-02f, -1.46335319e-01f, -3.22043113e-02f, 6.11517914e-02f, -5.77342249e-02f, 1.19425550e-01f, -4.81067225e-02f, -7.06857368e-02f, -4.20747511e-03f, -3.68321724e-02f,
  2.57646060e-03f, 3.96348685e-02f, 1.14332862e-01f, -2.55895243e-03f, -3.66770625e-02f, 1.26230374e-01f, -9.65621974e-03f, -8.08368772e-02f, -9.38560516e-02f, 1.42584536e-02f,
  6.12469576e-02f, -7.14542270e-02f, 1.83351189e-02f, 4.88271788e-02f, 1.03933048e-02f, 2.13563088e-02f, -1.13604926e-01f, 3.41500565e-02f, -5.45688085e-02f, -1.80330276e-01f,
  -3.53056639e-01f, -3.00070524e-01f, 1.43007472e-01f, 9.53707993e-02f, -4.85044196e-02f, -5.88889197e-02f, -1.86729245e-02f, 1.19194843e-01f, -1.61476016e-01f, -3.55725922e-02f,
  1.57402866e-02f, 6.67558834e-02f, -1.57838047e-01f, -4.87837233e-02f, -9.94965360e-02f, -9.59556028e-02f, -5.44914939e-02f, -5.43003790e-02f, 4.48010005e-02f, -4.47607040e-02f,
  6.02587648e-02f, -1.10618494e-01f, -6.46221340e-02f, 5.27866594e-02f, -1.67015009e-02f, -3.37725468e-02f, -7.37195984e-02f, 1.12274542e-01f, -1.30834818e-01f, -4.92212214e-02f,
  4.14500952e-01f, -1.94379613e-01f, -2.55279005e-01f, 4.77486879e-01f, 3.56818944e-01f, 4.64189976e-01f, 6.67402327e-01f, 3.46509904e-01f, 6.81726813e-01f, -5.33995852e-02f,
  1.20808013e-01f, -2.02982768e-01f, -3.11060995e-02f, 1.73290789e-01f, 2.71420658e-01f, 5.31388149e-02f, 3.30897003e-01f, 2.57181287e-01f, 2.05986544e-01f, 1.12272948e-01f,
  3.25142860e-01f, 2.87074268e-01f, -2.00288102e-01f, -2.34355494e-01f, 3.34345773e-02f, -3.12648863e-01f, -2.80057073e-01f, -1.23823121e-01f, -2.96897292e-01f, 7.97930658e-02f,
  7.61386007e-02f, 1.53606057e-01f, -6.69794306e-02f, 5.96974324e-03f, -2.12721415e-02f, -2.19420646e-03f, -7.38588944e-02f, 2.78026890e-02f, 1.98375545e-02f, 8.00922811e-02f,
  -1.38374921e-02f, 9.91729926e-03f, 1.15340717e-01f, -1.78607758e-02f, 8.14445317e-02f, -1.00112103e-01f, -9.35607180e-02f, -3.36881690e-02f, -1.05847210e-01f, -8.28171298e-02f,
  -8.75730589e-02f, -1.16295211e-01f, 1.10858586e-02f, -2.58328468e-02f, -1.24243721e-01f, 7.13509619e-02f, 1.29367076e-02f, -1.42680019e-01f, -2.71301437e-02f, 5.49682379e-02f,
  8.88933167e-02f, 1.12355702e-01f, 8.09380040e-03f, -3.47558931e-02f, 7.70982653e-02f, -8.58826414e-02f, 7.47055858e-02f, -6.00866089e-03f, 5.27882650e-02f, -1.56275377e-01f,
  5.79435527e-02f, 1.26118194e-02f, 1.80306546e-02f, 1.81813519e-02f, 1.81100711e-01f, 6.28518313e-02f, 1.07843041e-01f, -9.75143015e-02f, 7.15847686e-02f, 4.65167745e-04f,
  1.09000809e-01f, 2.89429780e-02f, -1.00914843e-01f, 2.54973155e-02f, 3.55928726e-02f, -1.20838778e-02f, 7.47813806e-02f, -8.69382322e-02f, -4.02207188e-02f, 1.06579676e-01f,
  1.59414619e-01f, 1.87679991e-01f, -7.21121058e-02f, -1.00345448e-01f, -1.34827495e-01f, 1.08123437e-01f, 3.13283578e-02f, -4.53933422e-03f, 1.29444912e-01f, 1.18331276e-01f,
  9.89002883e-02f, 1.05676517e-01f, -6.87825233e-02f, -1.29838601e-01f, -1.80377826e-01f, 1.10290393e-01f, -2.06555775e-03f, 4.50290740e-02f, 1.25748232e-01f, -5.02913184e-02f,
  -6.03767894e-02f, 4.95720282e-02f, 4.50176839e-03f, 1.97085902e-01f, 4.61207936e-03f, -1.40717879e-01f, 1.12667240e-01f, -1.38046682e-01f, -8.42419416e-02f, 5.55248819e-02f,
  -7.02328458e-02f, -1.77101523e-01f, 2.72700340e-01f, 4.25447941e-01f, 5.59615716e-03f, -4.08566236e-01f, -4.36459750e-01f, -2.94216946e-02f, -3.71360071e-02f, -4.54907417e-01f,
  -9.51872841e-02f, 1.48635715e-01f, -3.86015438e-02f, 8.82989243e-02f, 5.50573111e-01f, 9.69306529e-02f, 4.98986279e-04f, -1.31033599e-01f, 1.28540128e-01f, 8.39483365e-02f,
  3.93512428e-01f, 3.84488523e-01f, 4.14406180e-01f, 2.68504739e-01f, 1.39061525e-01f, 1.14944771e-01f, 3.27424616e-01f, 1.91791415e-01f, 1.19453482e-01f, 1.63532823e-01f,
  -2.73322016e-01f, 4.17245664e-02f, 1.40975595e-01f, -6.35077581e-02f, -5.03416806e-02f, -1.27652034e-01f, -1.25140339e-01f, 9.21977535e-02f, 5.27492687e-02f, -8.62717107e-02f,
  -1.01324953e-01f, -2.06072535e-02f, 2.70479340e-02f, 1.49245650e-01f, -2.57255226e-01f, 8.35007727e-02f, -5.82137285e-03f, -6.21742941e-02f, -7.26574361e-02f, 1.13017755e-02f,
  -2.70103221e-03f, -2.64674821e-03f, -7.96734318e-02f, 1.02940060e-01f, 3.58949453e-02f, -9.38724056e-02f, 8.34328122e-03f, -2.59992480e-02f, -3.19504403e-02f, 8.66256207e-02f,
  -7.74299875e-02f, 9.94314998e-02f, 7.63106570e-02f, 7.90395886e-02f, -7.05469847e-02f, -5.48975319e-02f, -2.49118172e-02f, -4.97455103e-03f, 9.79453549e-02f, -1.61409557e-01f,
  -8.30442309e-02f, 2.24336833e-02f, 7.88840055e-02f, -1.28950670e-01f, -7.19539896e-02f, -3.00342590e-03f, 1.32964998e-01f, 6.79150000e-02f, -3.78954485e-02f, 3.19222249e-02f,
  -2.92365234e-02f, -3.16767506e-02f, -2.27649836e-03f, 4.66155410e-02f, -6.06324673e-02f, 1.95712540e-02f, -4.33317646e-02f, -5.64776361e-02f, 1.00225262e-01f, 1.76569939e-01f,
  -1.99570850e-01f, 1.59221411e-01f, 4.28759418e-02f, -3.83858159e-02f, 6.42911270e-02f, -7.97086023e-03f, 6.49789348e-02f, -8.23790058e-02f, -9.49734598e-02f, 8.62265155e-02f,
  -9.57296863e-02f, 5.75679913e-02f, -5.66054359e-02f, -3.52689587e-02f, 5.08626364e-02f, -8.63754675e-02f, -3.66119631e-02f, 1.95701187e-03f, 1.60126492e-01f, -1.29694387e-01f,
  1.25750005e-02f, 1.02266027e-02f, 9.18820500e-02f, 7.93223232e-02f, -3.71983610e-02f, 1.46574462e-02f, -7.44691817e-03f, -7.27943331e-02f, 1.19338706e-01f, -1.49783874e-02f,
  -7.06453800e-01f, -2.98174202e-01f, -2.29699939e-01f, 3.15713912e-01f, -2.00439587e-01f, -2.11968988e-01f, -5.03990389e-02f, 1.23432808e-01f, -3.01841855e-01f, 2.88053334e-01f,
  3.37476879e-01f, -3.31021249e-01f, -2.68931072e-02f, 4.98787522e-01f, 1.93743542e-01f, 1.22069761e-01f, 3.79756898e-01f, 2.47864529e-01f, -1.22482562e-02f, 2.09992930e-01f,
  2.63504595e-01f, 2.36610308e-01f, 2.15259641e-01f, 2.53272861e-01f, -3.94588448e-02f, 1.75688669e-01f, 4.42914158e-01f, 8.06592032e-03f, 4.47792143e-01f, -1.69307724e-01f,
  9.33346599e-02f, -6.11665435e-02f, 1.11658677e-01f, -9.96944606e-02f, 8.34708661e-02f, 1.13484576e-01f, 1.98805314e-02f, 2.42402833e-02f, -1.46245509e-02f, 1.01705655e-01f,
  -1.21629506e-01f, -4.54847291e-02f, -1.06650628e-01f, -2.16723338e-01f, -1.46379948e-01f, -1.34870291e-01f, -1.00317352e-01f, -4.75051962e-02f, -3.76445055e-02f, -3.02549992e-02f,
  -1.85154080e-01f, 3.05097103e-02f, 5.21212593e-02f, -5.01384363e-02f, -9.70033407e-02f, -5.24397604e-02f, 6.18982362e-03f, -7.26587251e-02f, -3.83342095e-02f, -2.01235916e-02f,
  -1.78614795e-01f, -1.12680113e-02f, 3.86488140e-02f, 3.89234722e-02f, 1.14457190e-01f, 1.53202161e-01f, -1.15989204e-02f, 4.40276563e-02f, 3.29035968e-02f, 1.80453006e-02f,
  1.73348799e-01f, 2.50488631e-02f, 2.07472164e-02f, 4.89052348e-02f, 6.14970252e-02f, -8.42556357e-02f, -8.27745944e-02f, 3.12621966e-02f, -7.01451972e-02f, 1.26636416e-01f,
  1.45073980e-02f, -5.12515306e-02f, -1.04400009e-01f, 1.91548821e-02f, 5.16270362e-02f, -6.16186783e-02f, 9.81709585e-02f, -6.11474831e-03f, 8.13760087e-02f, 1.37870628e-02f,
  1.20006144e-01f, 2.97087077e-02f, 2.21794713e-02f, -5.04459701e-02f, 1.41601577e-01f, 1.03411444e-01f, -1.24170154e-01f, -1.20274730e-01f, 1.58658456e-02f, -1.00187458e-01f,
  6.18483638e-03f, 7.20501989e-02f, 6.81056902e-02f, -4.97523285e-02f, 5.13758473e-02f, 7.12239649e-03f, -4.10366468e-02f, -2.80665699e-02f, -6.11090250e-02f, 7.64466748e-02f,
  -5.91736063e-02f, 5.38207218e-02f, -5.19542694e-02f, -9.85898897e-02f, 5.56255393e-02f, 7.63372984e-03f, -9.27978978e-02f, -2.89455894e-02f, 8.81653428e-02f, 6.85441196e-02f,
  -3.91995460e-01f, 4.68251556e-01f, -1.98152646e-01f, -8.81194174e-02f, -3.04373503e-01f, 6.63163602e-01f, 4.85353798e-01f, -1.58057567e-02f, 4.17913012e-02f, 3.34687412e-01f,
  2.18806639e-01f, -2.86447674e-01f, 2.71295756e-01f, 3.15704495e-01f, 1.88661113e-01f, 3.74153167e-01f, 5.01661360e-01f, 3.42070967e-01f, -1.95410922e-01f, -3.33465114e-02f,
  -1.12605184e-01f, 4.53802139e-01f, 1.35029922e-03f, -5.29810041e-02f, -1.25660613e-01f, -3.66711408e-01f, -2.44496167e-01f, -3.39112341e-01f, -3.43303904e-02f, 9.94722545e-02f,
  7.57491887e-02f, -1.11896195e-01f, -9.53360274e-02f, 1.45177215e-01f, 8.18671212e-02f, -1.01040220e-02f, -7.42344037e-02f, -1.27010858e-02f, -3.24147731e-01f, -2.06876080e-02f,
  -5.31442165e-02f, -1.67881206e-01f, 3.14333700e-02f, -1.54799387e-01f, 1.89174935e-02f, -1.50628343e-01f, -6.21815585e-02f, 3.04995887e-02f, 1.88329555e-02f, -9.14776176e-02f,
  -7.57534280e-02f, 7.65426084e-02f, -5.78413829e-02f, 2.17801526e-01f, -5.31299561e-02f, 8.85561183e-02f, 1.23498604e-01f, -9.07092839e-02f, 2.71871313e-02f, 4.84972931e-02f,
  5.97799234e-02f, 6.43847883e-02f, 1.73748448e-01f, 1.41194593e-02f, 1.06935993e-01f, -6.52742535e-02f, 6.75488403e-03f, 5.58721423e-02f, -4.12365459e-02f, 1.46061331e-01f,
  -2.47341935e-02f, -1.26433790e-01f, -9.52104628e-02f, 1.49761885e-01f, 3.57622914e-02f, 5.61284311e-02f, -1.09800272e-01f, -1.13999166e-01f, -2.86984518e-02f, 1.54750913e-01f,
  1.21988449e-02f, 8.27345476e-02f, 9.04313326e-02f, 3.32760662e-02f, 8.89192626e-04f, 3.43847349e-02f, 1.36064496e-02f, -2.26191990e-02f, -9.49473865e-03f, 3.75382905e-03f,
  1.67233601e-01f, 2.20459431e-01f, 2.81959791e-02f, 9.86558646e-02f, 1.27246454e-01f, -4.53565754e-02f, 1.53309762e-01f, 1.03511378e-01f, 4.16948721e-02f, 4.06223722e-02f,
  -5.89087531e-02f, 2.08206959e-02f, 1.85852736e-01f, -1.20316043e-01f, -4.35374454e-02f, 1.72029123e-01f, 1.38688773e-01f, -7.09766373e-02f, 8.94214883e-02f, -6.02727644e-02f,
  4.56218421e-02f, 3.04769399e-03f, -9.40747838e-03f, 1.39427364e-01f, 3.75804715e-02f, 4.25359011e-02f, 5.87275699e-02f, -1.85662732e-01f, 6.13576686e-03f, 4.20079455e-02f,
  -7.62170255e-02f, -3.06712121e-01f, 6.14359267e-02f, 1.17924906e-01f, -4.61402684e-01f, -1.19754933e-01f, 1.51410103e-01f, -2.27589577e-01f, 1.93447351e-01f, 1.20412536e-01f,
  -2.19538242e-01f, 2.59209156e-01f, 3.31659496e-01f, -1.31732717e-01f, 3.10081631e-01f, 5.83767653e-01f, 6.83450103e-02f, 3.67944300e-01f, -7.65103027e-02f, -7.66117126e-02f,
  -1.47172317e-01f, -1.97082534e-01f, -9.98773947e-02f, -2.57416993e-01f, -4.51557726e-01f, -2.51248091e-01f, -6.00588024e-02f, -2.00117335e-01f, -1.85903683e-01f, -2.60088682e-01f,
  -5.07515967e-01f, -3.19310933e-01f, -7.81927034e-02f, -5.35074733e-02f, -1.58951387e-01f, -1.12930266e-02f, 7.72185698e-02f, 6.19860142e-02f, -2.64057033e-02f, 4.63196337e-02f,
  1.39934361e-01f, 3.11039295e-03f, -8.02171454e-02f, 1.33930251e-01f, -6.06953129e-02f, -6.52517974e-02f, -1.47806510e-01f, -1.95045352e-01f, -1.74326584e-01f, -1.07862525e-01f,
  -1.29857346e-01f, -1.33720115e-01f, -2.25267649e-01f, 7.45427310e-02f, -1.48632631e-01f, -1.56130955e-01f, 4.08464149e-02f, 2.95207314e-02f, -9.81190130e-02f, -1.84396327e-01f,
  2.75283027e-02f, 1.40010118e-01f, 6.14183471e-02f, 1.65234320e-02f, 5.14873005e-02f, -7.53678009e-02f, 8.12484920e-02f, 4.57155034e-02f, -1.39643205e-02f, -5.42439297e-02f,
  1.70919690e-02f, -5.84068801e-03f, 3.32840160e-02f, 1.86219253e-02f, 9.63597149e-02f, 1.26674294e-01f, 7.23302141e-02f, 5.88210486e-03f, -5.66410553e-03f, -7.23685846e-02f,
  -9.50105563e-02f, -1.80994906e-02f, -7.37272575e-02f, 4.32868488e-02f, -1.95687674e-02f, -1.05138369e-01f, -1.48510814e-01f, -3.43355746e-03f, 7.92569369e-02f, -1.49966672e-01f,
  -3.21559936e-01f, -6.83433190e-02f, -1.05677515e-01f, -8.18193555e-02f, 9.13116243e-03f, -1.44851729e-01f, 1.35147795e-01f, 2.60816850e-02f, -1.38852075e-01f, 6.47843257e-02f,
  -1.68470386e-02f, 6.16524108e-02f, -2.62410734e-02f, 1.90289050e-01f, 4.14692052e-02f, -8.03012326e-02f, 9.04209539e-03f, 2.45230701e-02f, 1.70362517e-02f, -5.10016717e-02f,
  3.75287444e-03f, 7.59354467e-03f, 8.37242045e-03f, -3.96283120e-02f, 2.66673975e-02f, -9.23562348e-02f, -6.24805577e-02f, -6.21875711e-02f, -6.53296113e-02f, 6.96862563e-02f,
  -8.36024106e-01f, 4.18381542e-01f, 3.24772894e-01f, -3.21418703e-01f, -4.37906682e-01f, 2.85021335e-01f, 2.95044780e-01f, 1.44778177e-01f, 2.28553355e-01f, 4.04222697e-01f,
  -2.34530017e-01f, 6.63903728e-02f, 4.47286785e-01f, 5.20629063e-02f, -9.13811624e-02f, 5.90017676e-01f, 4.54254448e-02f, 1.23108536e-01f, -5.21284677e-02f, -3.30477506e-02f,
  -7.51523823e-02f, -3.04633826e-01f, -7.25362152e-02f, 2.53751613e-02f, -2.77935177e-01f, -1.97935253e-01f, -4.18098688e-01f, -5.15709743e-02f, -1.86315700e-01f, -1.24677598e-01f,
  -6.02228165e-01f, -2.84763187e-01f, -2.13860497e-01f, 4.93079750e-03f, -6.98428228e-02f, 4.01363820e-02f, -2.94008292e-02f, -1.25759214e-01f, -6.81449324e-02f, 4.27167565e-02f,
  1.41607150e-01f, -4.02968451e-02f, -5.46184890e-02f, 8.00573826e-02f, -6.32070526e-02f, -9.71407294e-02f, -5.44129349e-02f, -1.18831731e-01f, -1.41732648e-01f, 1.39799295e-02f,
  1.08046390e-01f, 4.20651305e-03f, -1.30271971e-01f, -2.33328138e-02f, -1.88254014e-01f, -1.15464941e-01f, 1.75680444e-01f, -1.13362446e-01f, -1.21553272e-01f, -1.09601438e-01f,
  4.32278141e-02f, -8.00858140e-02f, -2.76021212e-02f, -3.24485451e-02f, 2.09438682e-01f, -3.42111960e-02f, 6.30199388e-02f, -3.52228284e-02f, 3.14590782e-02f, 3.79992500e-02f,
  -6.05579317e-02f, -4.35148403e-02f, -1.01052143e-01f, 7.54913141e-04f, 5.13281748e-02f, 2.14456588e-01f, -2.98933801e-03f, -1.18380681e-01f, 1.63828775e-01f, -1.69782326e-01f,
  -9.56515819e-02f, -5.10491058e-02f, -4.17434387e-02f, 2.69806851e-02f, -6.21203566e-03f, 3.15586366e-02f, -6.34603426e-02f, -2.35981587e-03f, -1.12427719e-01f, -8.38546008e-02f,
  -4.05099362e-01f, -1.82968020e-01f, -2.53942847e-01f, -1.57687172e-01f, 2.33862549e-02f, -3.54503095e-02f, 2.65201982e-02f, -1.10106960e-01f, 6.92397309e-03f, 4.36304845e-02f,
  1.23499572e-01f, 1.44943848e-01f, -6.16486557e-02f, -6.31956682e-02f, 1.96481347e-01f, -5.67954630e-02f, 5.94482198e-02f, 3.92587855e-02f, -2.11848333e-01f, -8.40056911e-02f,
  -5.93629368e-02f, 2.44477410e-02f, 1.73009023e-01f, -1.42265871e-01f, -4.58105877e-02f, -1.66908279e-01f, -1.56967059e-01f, -8.05026013e-03f, -1.84902489e-01f, 1.03759794e-02f,
  4.22050476e-01f, -2.51080424e-01f, -4.25694883e-01f, -9.03338864e-02f, 3.73278737e-01f, 3.53561074e-01f, -3.80402982e-01f, 6.97414801e-02f, -1.56640708e-01f, -2.43198290e-01f,
  1.39994651e-01f, -8.29315260e-02f, -4.97845203e-01f, 4.40588951e-01f, 4.61345464e-01f, -1.84390977e-01f, 3.47137839e-01f, 1.83932781e-01f, 1.79357678e-01f, 1.75847322e-01f,
  2.56826341e-01f, 5.79080760e-01f, -2.19225302e-01f, 3.28424811e-01f, 1.60463884e-01f, -1.21365860e-01f, -4.22962643e-02f, -3.04229379e-01f, 1.98556766e-01f, 2.54033506e-01f,
  1.36730939e-01f, 9.51550677e-02f, -1.22248687e-01f, -4.60720174e-02f, -1.02898054e-01f, 1.05515132e-02f, -1.46460548e-01f, -3.92463207e-02f, -1.52895488e-02f, -7.45040178e-02f,
  -3.61720212e-02f, 9.26488563e-02f, 1.12009622e-01f, 3.67565602e-02f, 6.97773844e-02f, -5.85621484e-02f, -4.86181537e-03f, -6.61346763e-02f, -1.17943458e-01f, 1.75349470e-02f,
  -1.32266134e-01f, 5.04569076e-02f, 3.96136567e-02f, 6.20180974e-03f, -4.45081741e-02f, 1.02278553e-01f, -1.67072974e-02f, -9.15986001e-02f, -1.79812443e-02f, 2.60377000e-03f,
  -2.02923082e-02f, 2.38195118e-02f, 4.49078418e-02f, 2.36824751e-02f, -4.89757583e-02f, -5.81484511e-02f, 6.75772130e-02f, 1.88043620e-02f, -1.07643850e-01f, 9.11707245e-03f,
  -1.22432046e-01f, 3.25176446e-03f, 8.11142251e-02f, -6.59599006e-02f, 1.31882668e-01f, 1.11882731e-01f, 1.14117051e-02f, 7.71166459e-02f, -8.39831159e-02f, -5.42942546e-02f,
  -7.90399387e-02f, 1.46756694e-01f, -7.25436211e-02f, -1.19810738e-02f, 1.30168021e-01f, -1.02032825e-01f, 9.40269083e-02f, 1.20895589e-02f, -1.31432069e-02f, -5.96086048e-02f,
  -3.12847607e-02f, -2.80126244e-01f, -1.10458978e-01f, 7.30136558e-02f, -1.06609538e-01f, 1.49572521e-01f, -2.17639562e-02f, 1.32023960e-01f, -2.86574345e-02f, 6.24521403e-03f,
  1.81431379e-02f, -5.38942292e-02f, 2.93455664e-02f, 4.17393595e-02f, 2.24185195e-02f, -6.54608291e-03f, -9.21835378e-02f, -8.10485035e-02f, -1.02628253e-01f, 1.47028556e-02f,
  -4.82912473e-02f, 6.59653172e-02f, -4.95674275e-02f, -6.49792491e-04f, 1.35230601e-01f, -4.21320312e-02f, 1.08704299e-01f, -9.47197229e-02f, 3.44631560e-02f, 1.87524315e-02f,
  -6.99491858e-01f, 6.05259418e-01f, 3.00799787e-01f, -2.34336272e-01f, 1.95182115e-01f, 1.24588884e-01f, 1.02626972e-01f, 1.88870013e-01f, 3.40301022e-02f, 1.37833580e-01f,
  -1.59537252e-02f, -6.22778721e-02f, 3.50163490e-01f, 8.69871005e-02f, -3.21472913e-01f, 1.40212640e-01f, -2.46622711e-01f, -1.90151975e-01f, 2.70923138e-01f, -3.60759720e-02f,
  -9.35274214e-02f, 6.14372119e-02f, -7.16934167e-03f, 2.49422088e-01f, 5.57818413e-02f, -4.49788459e-02f, -3.04133385e-01f, 3.59378725e-01f, -1.89150304e-01f, 2.22725287e-01f,
  -3.07388276e-01f, -2.26958334e-01f, -3.19633335e-01f, -1.11550681e-01f, -1.71989426e-01f, -2.04311326e-01f, -1.76522732e-01f, 9.19391459e-05f, -2.66140141e-02f, -1.43044796e-02f,
  1.22021258e-01f, 6.68884963e-02f, 1.27946679e-02f, 7.10542798e-02f, -7.33581558e-02f, 2.92457286e-02f, 1.91060796e-01f, 1.48751801e-02f, 6.68343380e-02f, 8.42522681e-02f,
  1.03613243e-01f, -2.75122318e-02f, -1.18316054e-01f, -1.66396603e-01f, 3.24839563e-03f, 3.77000379e-03f, -3.92368585e-02f, -1.36068463e-01f, -1.13711782e-01f, -6.78989813e-02f,
  1.11435331e-01f, -1.45654321e-01f, -1.43943811e-02f, -6.17949441e-02f, 5.44471443e-02f, 1.05166323e-02f, -3.42754945e-02f, -1.21683199e-02f, -2.18565809e-03f, 8.20735693e-02f,
  -8.93854126e-02f, -1.68615907e-01f, -1.63970366e-02f, -8.06378275e-02f, 9.51354429e-02f, 3.56650278e-02f, -3.09450738e-02f, 1.94377750e-02f, 5.70501685e-02f, -3.84527794e-03f,
  3.48199438e-03f, -7.00547844e-02f, -4.56884550e-03f, -1.06261179e-01f, -4.21977676e-02f, 9.15378258e-02f, 7.81958625e-02f, -2.97825299e-02f, 8.27720203e-03f, 2.81874202e-02f,
  -6.29226804e-01f, -4.31446344e-01f, -9.74083692e-02f, -1.72279447e-01f, -7.29313269e-02f, -5.13116010e-02f, 5.55493571e-02f, -3.18687707e-02f, -1.42503260e-02f, -6.85536042e-02f,
  2.69958694e-02f, -3.48865166e-02f, -5.46484850e-02f, -2.40553892e-03f, 5.60829639e-02f, -9.96197388e-02f, -9.06758755e-02f, -6.98092878e-02f, -2.16877669e-01f, -6.74507543e-02f,
  -8.90045986e-02f, 7.39561543e-02f, 4.35539745e-02f, -1.38945291e-02f, -1.43912002e-01f, -2.87244096e-02f, -1.23358175e-01f, -1.92037728e-02f, -2.77263485e-02f, 8.74906704e-02f,
  -5.95230579e-01f, 2.61609823e-01f, -5.16297281e-01f, 4.83546481e-02f, -1.07738703e-01f, -1.49351254e-01f, 2.07927585e-01f, 5.35586551e-02f, 9.23629403e-02f, 5.29053926e-01f,
  4.12193209e-01f, -1.35788545e-01f, 4.68444020e-01f, 5.49495816e-01f, -5.07799447e-01f, 4.41334277e-01f, 6.41128793e-02f, 8.25454816e-02f, -4.41387668e-02f, 1.42423540e-01f,
  -2.67110258e-01f, 4.89814430e-01f, 2.62529850e-02f, 1.88798249e-01f, -1.19387291e-01f, -3.07787329e-01f, 1.63575858e-01f, 7.24022910e-02f, -8.92604049e-03f, -2.84305792e-02f,
  3.88411507e-02f, 2.61030018e-01f, -3.00551788e-03f, -1.37102783e-01f, -2.00481057e-01f, -1.43106431e-01f, -4.14973423e-02f, -1.33360788e-01f, -2.63726227e-02f, 3.12935188e-02f,
  -3.08018085e-02f, 2.29576658e-02f, -4.56968043e-03f, 2.10604351e-02f, -3.76138762e-02f, 1.21485321e-02f, -5.78692779e-02f, -1.27855420e-01f, 4.45868969e-02f, -1.12704542e-02f,
  -6.90068305e-02f, -9.48332548e-02f, -9.08406526e-02f, 1.08182400e-01f, -7.53274336e-02f, 1.06525585e-01f, -9.01884660e-02f, -2.37169471e-02f, -1.74193382e-01f, -1.76693782e-01f,
  -1.07339449e-01f, -9.20936838e-02f, 5.87632693e-02f, 6.91186264e-02f, 6.59741461e-02f, 6.71906248e-02f, 7.35159963e-02f, 3.35800126e-02f, -3.45509574e-02f, 3.31028029e-02f,
  -1.50773749e-02f, 1.26816602e-02f, 1.33201882e-01f, -5.95271625e-02f, 2.39934977e-02f, -6.04714043e-02f, -1.36974705e-02f, -4.86687338e-03f, -1.35065794e-01f, -4.43315990e-02f,
  4.61223982e-02f, -5.20399492e-03f, 2.58441623e-02f, 5.56352101e-02f, 4.18690518e-02f, -1.17161069e-02f, 3.55523229e-02f, -2.14256477e-02f, 7.11147785e-02f, -9.88242701e-02f,
  8.86950344e-02f, 8.68757889e-02f, 1.84504732e-01f, 9.52247903e-02f, 4.70016375e-02f, -3.61385457e-02f, -7.41759082e-04f, -6.12563267e-02f, 8.91606584e-02f, -5.99029101e-02f,
  -1.18926145e-01f, -2.87868250e-02f, -2.03943506e-01f, 2.12155115e-02f, -1.30201578e-01f, 1.27331465e-01f, 1.03209287e-01f, -6.54878169e-02f, 7.73125961e-02f, -8.91524032e-02f,
  8.16105679e-02f, 1.10093527e-01f, -3.31754275e-02f, 1.39209814e-02f, 1.81311723e-02f, 4.15832326e-02f, -2.73553301e-02f, 4.34791446e-02f, -3.09095345e-02f, 8.37401375e-02f,
  -5.59664726e-01f, 5.58634818e-01f, 6.00565709e-02f, -2.52830356e-01f, 5.10279417e-01f, 1.48077637e-01f, 1.88238651e-01f, 4.58028048e-01f, 4.43506896e-01f, -2.02845380e-01f,
  -1.71734810e-01f, 1.05457976e-01f, 1.81939602e-01f, -1.83565512e-01f, -3.50695819e-01f, -4.39137369e-02f, -2.21940741e-01f, -1.94610268e-01f, 5.05209625e-01f, -1.14779398e-02f,
  3.10950186e-02f, -1.97824195e-01f, -2.02056989e-01f, 2.10372329e-01f, -1.16855249e-01f, 5.19115701e-02f, -3.77177030e-01f, 4.14891630e-01f, -3.54986638e-01f, 2.20089793e-01f,
  -5.86515404e-02f, 1.27833471e-01f, 3.90194282e-02f, -3.10475193e-02f, -2.62507141e-01f, -2.26491038e-02f, -8.12952369e-02f, 9.43541303e-02f, -1.01737296e-02f, 7.85723105e-02f,
  -5.99138066e-02f, -5.00904471e-02f, -6.16174899e-02f, 1.79703861e-01f, 1.71306252e-01f, 6.98717907e-02f, 6.71163350e-02f, 2.41127983e-02f, 1.31697923e-01f, 8.84910524e-02f,
  -5.90849109e-02f, 9.08267591e-03f, -1.50236130e-01f, -1.72233973e-02f, 8.14766362e-02f, -8.06029513e-03f, -1.36100546e-01f, -1.04714576e-02f, -5.32209836e-02f, -4.05480079e-02f,
  2.25376263e-01f, 1.47672996e-01f, 1.33989483e-01f, 5.70396595e-02f, 1.30845785e-01f, -7.97070935e-02f, -1.51330739e-01f, -1.62998870e-01f, 5.10627478e-02f, -6.76735565e-02f,
  -7.12236464e-02f, 7.77079687e-02f, -2.81092357e-02f, -7.32683614e-02f, -2.38086861e-02f, 9.80080068e-02f, -1.35144442e-01f, -2.25167256e-02f, 2.01128349e-02f, -1.01832440e-02f,
  1.46972954e-01f, -2.00210251e-02f, -5.78121133e-02f, -1.02240294e-01f, 3.24621499e-02f, 5.32078184e-03f, -2.19243504e-02f, -4.55953516e-02f, 1.74451232e-01f, 2.58436445e-02f,
  -3.10936630e-01f, -2.42270827e-01f, 1.05198234e-01f, 5.62240593e-02f, 5.19055687e-02f, -7.39688128e-02f, 3.33651574e-03f, -3.10332961e-02f, -1.60218729e-03f, 1.03654526e-01f,
  2.23327447e-02f, -1.35294795e-01f, -1.99009970e-01f, 1.63579658e-02f, 6.21194057e-02f, -2.41033584e-01f, -2.03316405e-01f, -5.65875433e-02f, -1.50690630e-01f, 8.91306177e-02f,
  -5.35253175e-02f, -9.48639587e-02f, -7.80236796e-02f, 9.60442529e-04f, -1.57949805e-01f, -1.36932984e-01f, -4.79907654e-02f, 1.05566762e-01f, -3.97713594e-02f, -1.11449160e-01f,
  3.13847452e-01f, -3.45812052e-01f, -1.26625329e-01f, -2.72925138e-01f, 2.16247719e-02f, 5.20266891e-01f, 4.36064690e-01f, -3.82920861e-01f, -5.63130736e-01f, -3.05814035e-02f,
  -2.49742344e-02f, 3.13896954e-01f, 1.32185891e-01f, -8.62205774e-02f, 6.03844583e-01f, 6.65996596e-02f, -1.29889986e-02f, 1.19983777e-01f, -3.70571166e-01f, 5.60758449e-02f,
  -1.24856710e-01f, 2.88702577e-01f, 2.56632045e-02f, -1.14753850e-01f, 2.75347948e-01f, -2.01105177e-01f, 1.32516518e-01f, 1.59614235e-01f, 1.79989096e-02f, 2.52821058e-01f,
  6.23854510e-02f, -1.09555587e-01f, -1.29136696e-01f, -3.06356717e-02f, -3.69138680e-02f, 1.41943187e-01f, 2.70420998e-01f, 2.86957741e-01f, -2.35181767e-02f, 2.84228697e-02f,
  2.91872948e-01f, -1.36800762e-02f, -3.65384594e-02f, 1.23256162e-01f, -8.46627578e-02f, -1.73059300e-01f, -1.17110662e-01f, -1.09999157e-01f, 4.00529988e-02f, 7.78786540e-02f,
  -1.54042080e-01f, -9.38263312e-02f, -4.82912250e-02f, -4.73239683e-02f, -1.04019746e-01f, -9.30143595e-02f, -9.91548132e-03f, 1.51544049e-01f, 1.23533279e-01f, 6.16423339e-02f,
  1.04809277e-01f, 1.31967962e-01f, 1.21178158e-01f, -1.34248957e-01f, 4.18504700e-02f, -1.25242785e-01f, 3.67054604e-02f, -5.61208688e-02f, -2.85107605e-02f, -4.35640058e-03f,
  -2.93047614e-02f, -4.09766883e-02f, -1.79835662e-01f, -3.43403267e-03f, 5.19439243e-02f, -1.36496454e-01f, 1.53132111e-01f, 6.59549888e-03f, -1.48385048e-01f, -1.31453902e-01f,
  -5.83579056e-02f, -8.80789291e-03f, 5.45268506e-02f, -1.31065339e-01f, -3.29153682e-03f, 1.02035850e-01f, -5.36994077e-02f, -8.31654295e-02f, -1.76053628e-01f, 1.91218883e-01f,
  2.47567315e-02f, -3.34528573e-02f, -4.80696969e-02f, 1.23659419e-02f, -5.74571593e-03f, 9.01765935e-03f, 4.53143641e-02f, -1.26633883e-01f, 4.26330790e-02f, 7.67235383e-02f,
  3.83501984e-02f, -1.51273562e-02f, -4.58776690e-02f, 3.62929218e-02f, -2.75751483e-02f, -4.62478027e-02f, 1.16656251e-01f, -7.03993142e-02f, -2.35276204e-02f, -4.93141562e-02f,
  -8.35830867e-02f, -3.58452313e-02f, 8.66333470e-02f, -4.97469492e-02f, -1.08834743e-01f, 9.15823597e-03f, -3.65707986e-02f, 7.56155029e-02f, 9.06766281e-02f, -3.24821286e-02f,
  1.43109605e-01f, 2.82169819e-01f, 4.57244545e-01f, 4.05062139e-01f, -2.25850835e-01f, -3.34958673e-01f, -2.65968084e-01f, 1.46708593e-01f, 8.09518248e-02f, -1.86181962e-01f,
  -3.01075965e-01f, 4.29494143e-01f, -4.00429398e-01f, 1.97208747e-01f, -1.09687746e-01f, -2.44549975e-01f, 8.16620514e-02f, -5.62672205e-02f, 3.70759107e-02f, 3.23125631e-01f,
  1.95812210e-01f, -1.52147919e-01f, 2.21120492e-01f, 8.36975798e-02f, 1.68308750e-01f, 2.89754748e-01f, 1.88853785e-01f, -1.92819238e-02f, 3.48569244e-01f, -5.93174398e-02f,
  -8.64705145e-02f, 8.86698812e-02f, 2.10873380e-01f, -3.35765667e-02f, 9.02135223e-02f, 2.70816404e-02f, -3.00315837e-03f, -1.02459855e-01f, -1.81341358e-03f, -9.15644243e-02f,
  2.93941461e-02f, -2.28484720e-02f, -2.04450078e-02f, -5.22215031e-02f, -3.70465629e-02f, 1.99988723e-01f, 6.35981262e-02f, 6.98043359e-03f, 7.67984241e-02f, 1.28175944e-01f,
  2.14442298e-01f, -2.87526511e-02f, 5.20697720e-02f, 9.19536874e-02f, 8.10815394e-02f, 8.57137665e-02f, -3.65126841e-02f, 6.14918396e-02f, 9.59895924e-03f, 1.09915353e-01f,
  1.05494671e-01f, -7.75743797e-02f, -1.60033226e-01f, -6.12154640e-02f, -1.40028656e-01f, 3.08950953e-02f, -7.99195692e-02f, -7.37769976e-02f, -9.58504304e-02f, -8.53862390e-02f,
  5.54303080e-02f, 8.98790918e-03f, -3.63801382e-02f, -5.78815341e-02f, 1.01623036e-01f, 5.54745458e-02f, 1.02306698e-02f, -1.24288701e-01f, 3.94013152e-02f, 9.57191139e-02f,
  2.02912018e-02f, -1.41743124e-01f, -2.62430068e-02f, -4.71112430e-02f, -1.67228475e-01f, -7.00536817e-02f, -4.29523624e-02f, -3.72622907e-02f, 8.18798493e-04f, 4.80011366e-02f,
  -8.81250426e-02f, 1.47137120e-01f, 5.13230311e-03f, -4.00896929e-02f, -3.99604887e-02f, -6.73136190e-02f, 3.66213582e-02f, 9.92490277e-02f, 3.41481082e-02f, -9.04891640e-02f,
  1.59929797e-01f, -5.54161612e-03f, 1.56491604e-02f, -6.32246258e-03f, -3.11785704e-03f, -1.95397045e-02f, -1.24507599e-01f, -2.05181558e-02f, 8.85054767e-02f, 6.57057762e-02f,
  4.18882631e-02f, -7.84431174e-02f, -1.69852525e-02f, 4.37433831e-02f, 4.23056968e-02f, -3.23968530e-02f, 1.81452688e-02f, 3.40638533e-02f, 5.33504970e-02f, 8.66524503e-03f,
  2.96155423e-01f, -3.75007898e-01f, -2.63683915e-01f, -2.45106034e-02f, -2.10523997e-02f, -3.43768477e-01f, -1.13668270e-01f, -3.06873530e-01f, 1.74993545e-01f, -2.36403689e-01f,
  1.72121257e-01f, 1.28278732e-01f, 3.31967890e-01f, -2.25804508e-01f, 2.97808081e-01f, 3.42272639e-01f, -3.37810814e-01f, -8.91831666e-02f, 9.96816903e-02f, -1.54878244e-01f,
  1.22571483e-01f, -1.89969718e-01f, -5.47921099e-02f, -3.08501929e-01f, -1.45369425e-01f, -2.08798468e-01f, 1.38132721e-01f, -2.97067240e-02f, -2.68406570e-01f, 8.59032124e-02f,
  -1.16699561e-01f, 8.03442672e-02f, 3.97935584e-02f, -6.51438162e-02f, -7.66167790e-02f, -1.37488633e-01f, 3.99581939e-02f, 8.80224034e-02f, 2.25255325e-01f, -5.85694686e-02f,
  4.16198373e-02f, -1.53826708e-02f, -6.82084784e-02f, 5.00888377e-02f, -6.66040555e-02f, -7.60705248e-02f, -3.20665874e-02f, 3.73980105e-02f, -4.66097482e-02f, 5.21561578e-02f,
  -7.98512921e-02f, -3.48133482e-02f, 1.64666876e-01f, -9.05865356e-02f, 1.47009134e-01f, -6.51576519e-02f, -3.10222134e-02f, 2.94858087e-02f, -1.01048380e-01f, -1.00873590e-01f,
  -3.15893441e-02f, 9.79246870e-02f, 9.11252350e-02f, 6.98388442e-02f, 1.42116810e-03f, 4.31722701e-02f, -1.00370847e-01f, 5.71482331e-02f, 2.91640069e-02f, 3.58112715e-02f,
  -2.12652348e-02f, -3.47067565e-02f, 6.14382774e-02f, -6.13672063e-02f, 5.35974130e-02f, 3.20005566e-02f, -5.99964634e-02f, -6.26511872e-02f, 4.43424582e-02f, -3.61561701e-02f,
  -8.55143219e-02f, -4.37436029e-02f, 4.56557190e-03f, -2.55043041e-02f, -5.69152199e-02f, 7.70525485e-02f, 2.90724728e-02f, -4.96216416e-02f, 7.68937618e-02f, -1.62713211e-02f,
  -3.33491974e-02f, -3.49581331e-01f, -6.15906231e-02f, -9.68375877e-02f, -1.60787374e-01f, -1.21544473e-01f, -5.77572025e-02f, -6.60104817e-03f, 1.41888834e-03f, -1.42273754e-01f,
  -1.25627920e-01f, -5.86035522e-03f, -2.91765854e-02f, 6.44062310e-02f, 5.98099269e-03f, -5.28617091e-02f, 9.90963504e-02f, 1.27630636e-01f, -2.08718386e-02f, -8.72505903e-02f,
  -7.64750987e-02f, -1.27777964e-01f, 3.94619964e-02f, -6.21292181e-02f, -1.18210837e-01f, -2.61403602e-02f, -8.82826820e-02f, 2.34934501e-02f, 2.28203125e-02f, -4.92725745e-02f,
  2.55889267e-01f, -3.80325764e-01f, -1.06424913e-02f, -1.82059526e-01f, 2.72279475e-02f, -1.91663299e-02f, 8.13166872e-02f, -3.16475749e-01f, -4.02483910e-01f, -3.36504370e-01f,
  -9.29672569e-02f, 9.20077860e-02f, 2.58493185e-01f, -4.35139358e-01f, 2.92332649e-01f, 1.83594134e-02f, -3.87803197e-01f, -1.16698623e-01f, -5.16612791e-02f, -8.84392858e-02f,
  1.11331092e-02f, -3.71578276e-01f, 4.58025187e-02f, -3.66064757e-01f, -1.63346946e-01f, -1.70007691e-01f, 1.90291300e-01f, 2.16710284e-01f, -2.77020276e-01f, 4.90902700e-02f,
  -6.24097660e-02f, -1.88137934e-01f, 6.72231847e-03f, -7.62523785e-02f, 5.59357218e-02f, 4.76787575e-02f, 1.71842545e-01f, 1.45385310e-01f, -1.98226981e-02f, 1.18949777e-02f,
  1.15128167e-01f, 9.92252827e-02f, -2.77324736e-01f, 1.16878606e-01f, -1.22615553e-01f, -9.49531645e-02f, -2.71120351e-02f, -8.99377838e-03f, -9.12658945e-02f, 1.23534799e-01f,
  -6.13817992e-03f, -1.07625676e-02f, 3.20757404e-02f, -2.15473231e-02f, 7.94597343e-02f, 2.48526148e-02f, 9.13644657e-02f, 2.29307026e-01f, -3.98549512e-02f, 9.46930237e-03f,
  -1.19341776e-01f, 2.11007055e-02f, -1.29417432e-02f, -6.39916286e-02f, -1.05599277e-02f, 6.66074604e-02f, -1.13216445e-01f, -6.80976175e-03f, 1.06654301e-01f, 9.73730981e-02f,
  -1.04544424e-01f, -4.74117547e-02f, -1.32058308e-01f, -9.11466405e-02f, 7.76178623e-03f, -3.42788547e-02f, 7.44937286e-02f, -1.73765719e-02f, 5.66619774e-03f, -2.38015875e-02f,
  -9.80181736e-04f, -2.53523123e-02f, 1.84356666e-03f, 6.75143255e-03f, -3.92958224e-02f, -5.02500776e-03f, -6.92812502e-02f, 7.36287385e-02f, 3.57348472e-02f, 8.44959915e-02f,
  6.01897351e-02f, -2.89910793e-01f, -1.45744517e-01f, -1.30296186e-01f, 3.25237215e-02f, 4.02903743e-02f, -1.05909914e-01f, -2.38112554e-01f, 3.74249257e-02f, -1.00681834e-01f,
  5.02294824e-02f, 3.12337559e-02f, -3.94413210e-02f, -2.85507608e-02f, -5.40904403e-02f, -2.79023740e-02f, 3.48709943e-03f, 3.53472903e-02f, -2.31887884e-02f, -9.45998915e-03f,
  5.84376194e-02f, 2.27706451e-02f, 3.37507874e-02f, -1.27056718e-01f, -1.64818451e-01f, 5.22912219e-02f, 6.05457351e-02f, 7.55105913e-02f, -2.47464143e-03f, -9.93489251e-02f,
  -4.36055005e-01f, 6.17871523e-01f, 2.12121204e-01f, 3.21599990e-01f, -1.17355794e-01f, -4.41767931e-01f, -2.85305619e-01f, 1.93377286e-01f, -6.11326210e-02f, 8.69472772e-02f,
  8.12751823e-04f, 4.21606123e-01f, -1.60041466e-01f, 2.80620635e-01f, -3.80755305e-01f, -2.50858426e-01f, -6.78706244e-02f, 1.17437422e-01f, 2.87348800e-03f, 2.03758068e-02f,
  -1.68503836e-01f, -4.44245599e-02f, 1.10569425e-01f, 1.55010015e-01f, 2.09535152e-01f, 1.63798332e-01f, -3.10808986e-01f, 1.18895069e-01f, 2.42496952e-01f, 2.31651254e-02f,
  -2.98153818e-01f, 2.33316988e-01f, -1.00926057e-01f, -5.03487512e-02f, -1.96762443e-01f, -2.03510985e-01f, -1.50966942e-01f, -1.46364138e-01f, -1.19343847e-01f, -4.08566073e-02f,
  -1.17940694e-01f, 5.15898801e-02f, 1.31616846e-01f, 4.30198014e-02f, -3.16196531e-02f, 1.61668301e-01f, 5.89054972e-02f, -1.16796112e-02f, 9.53706279e-02f, 1.08605914e-01f,
  1.25641719e-01f, 1.23104952e-01f, -9.34680924e-02f, 1.39348060e-02f, -3.85442302e-02f, -4.02118750e-02f, 1.18336156e-02f, 6.85255229e-02f, 1.41896173e-01f, 7.46636046e-03f,
  -4.92974184e-02f, -9.28562433e-02f, 2.88320668e-02f, 7.91725591e-02f, 2.45802496e-02f, 7.70615935e-02f, 1.45995766e-01f, 9.96419787e-03f, -1.71643347e-02f, -1.74830303e-01f,
  -6.60256222e-02f, 2.25440040e-01f, -1.79394260e-02f, -4.41617966e-02f, 3.37722823e-02f, 6.03886619e-02f, -1.98915061e-02f, -1.64992630e-03f, -9.65640321e-03f, 7.47888908e-02f,
  4.65934277e-02f, -1.16861269e-01f, 5.28821833e-02f, -2.62928177e-02f, -9.05936733e-02f, -7.27249756e-02f, -1.27911652e-02f, 1.29060343e-01f, -1.18492275e-01f, -1.70144022e-01f,
  -4.69928741e-01f, -1.13585763e-01f, -1.72336191e-01f, 7.74259039e-04f, -7.20168874e-02f, -7.88212419e-02f, -9.84081626e-02f, -3.50044039e-03f, -2.64339417e-01f, -4.91815843e-02f,
  -2.07010716e-01f, -1.53669029e-01f, -2.78529644e-01f, -8.20718184e-02f, -1.85091444e-03f, -7.51812458e-02f, -6.35600165e-02f, -1.87781066e-01f, -1.38768211e-01f, 7.85592869e-02f,
  1.07615069e-01f, -1.12490475e-01f, -9.11208093e-02f, -9.51300040e-02f, -1.31833270e-01f, -1.38482168e-01f, 4.01550485e-03f, 6.95360601e-02f, -2.00467501e-02f, 1.49974152e-01f,
  5.32376468e-01f, -4.93770927e-01f, -4.28723007e-01f, 9.56637412e-02f, 3.98628116e-01f, 3.86165440e-01f, 2.45662451e-01f, -9.42856167e-03f, -1.38510868e-01f, -2.36552805e-01f,
  3.31010938e-01f, -1.06180795e-01f, -2.73362726e-01f, 3.79363447e-01f, 4.01394933e-01f, -2.51809776e-01f, 2.40803048e-01f, 1.64158463e-01f, -8.61305967e-02f, 1.75758135e-02f,
  1.61695078e-01f, 4.65782344e-01f, -5.53128868e-02f, 1.27312578e-02f, 2.82354414e-01f, -2.10533425e-01f, -9.79891270e-02f, -2.88372427e-01f, 1.84383109e-01f, 1.65660083e-01f,
  4.87939231e-02f, 4.85050268e-02f, 1.70661043e-02f, -7.65522011e-03f, 4.13929895e-02f, 1.56714991e-01f, -1.46578569e-02f, 2.66833007e-02f, 1.10926844e-01f, -7.99538121e-02f,
  -1.28754646e-01f, 4.64470871e-02f, 1.16295025e-01f, 5.52847087e-02f, 1.25523448e-01f, 6.82076216e-02f, -2.70328410e-02f, -5.43138981e-02f, -1.69519201e-01f, 1.09918550e-01f,
  -1.08478010e-01f, -1.09913729e-01f, 6.86973473e-03f, -5.08036278e-02f, -8.90518725e-02f, -8.19127634e-02f, -1.19452000e-01f, -1.47927433e-01f, -6.19374402e-02f, 2.06173770e-02f,
  -5.27095562e-03f, -6.09241091e-02f, 4.21467088e-02f, 4.49118055e-02f, 3.78921777e-02f, 4.79430072e-02f, 3.34495828e-02f, -1.55781321e-02f, -6.40986934e-02f, 6.71579910e-04f,
  6.48659244e-02f, 4.57970239e-02f, 8.99396986e-02f, 6.83520436e-02f, 2.89188214e-02f, -1.05487600e-01f, -2.95417048e-02f, -1.50050009e-02f, 3.35321240e-02f, -1.70482006e-02f,
  -2.43028887e-02f, 2.58810446e-02f, -4.53696437e-02f, -5.69438823e-02f, 1.12671135e-02f, 1.82422996e-02f, -5.54580707e-03f, -3.12675908e-02f, -4.49907966e-02f, 6.99258596e-02f,
  -8.64572152e-02f, -3.98321778e-01f, -5.17056026e-02f, 2.44611744e-02f, -3.87629531e-02f, 6.75206557e-02f, -3.03605534e-02f, 1.68170978e-03f, -9.55214575e-02f, 5.60348295e-02f,
  -2.91712321e-02f, -6.47964701e-02f, 4.51944657e-02f, 9.95106921e-02f, -4.13234308e-02f, 1.11239128e-01f, -8.84287208e-02f, 1.55733172e-02f, 6.33949190e-02f, -2.17801109e-02f,
  5.99000463e-03f, -3.70318703e-02f, 7.49143139e-02f, 2.19979156e-02f, -2.92128753e-02f, 5.48104644e-02f, -6.41605854e-02f, -4.88848239e-03f, 2.66970247e-02f, -1.47061273e-01f,
  3.95923495e-01f, -6.35385036e-01f, 1.95646614e-01f, 4.06728417e-01f, 2.96489388e-01f, 1.83337212e-01f, 3.90543342e-01f, -2.23543942e-01f, -3.97529034e-03f, -4.52767342e-01f,
  -1.34559095e-01f, -1.98006064e-01f, -3.30990523e-01f, -7.38194492e-03f, 4.91624057e-01f, -1.79053411e-01f, 8.78174007e-02f, 5.49553558e-02f, 1.29823461e-01f, -5.99945337e-02f,
  3.36966723e-01f, 2.46262386e-01f, 2.31788054e-01f, -1.49576306e-01f, -4.95635271e-02f, -9.20045748e-02f, 1.81876170e-03f, 5.36901690e-02f, 6.41488135e-02f, 1.62676111e-01f,
  -2.59099901e-01f, -8.08832049e-02f, 3.60491052e-02f, 6.80440366e-02f, -6.82728291e-02f, -4.28601615e-02f, 9.29015130e-02f, 7.85435662e-02f, 2.07423508e-01f, 1.33558335e-02f,
  -1.05690457e-01f, 1.18329428e-01f, 1.21091112e-01f, 5.45926988e-02f, -6.16887100e-02f, -4.60991226e-02f, 6.20287098e-02f, -1.04295887e-01f, 2.43669637e-02f, -6.68488964e-02f,
  -2.87117045e-02f, -4.47783135e-02f, 3.09118573e-02f, -8.56322721e-02f, 1.57194942e-01f, -2.53584748e-03f, 6.40170798e-02f, 1.19472379e-02f, -1.59915723e-02f, 8.80171433e-02f,
  1.24627575e-01f, 9.55367759e-02f, -1.44611269e-01f, -8.41025412e-02f, -1.94915477e-02f, 7.73050562e-02f, -4.95595858e-02f, 3.17838900e-02f, -2.96463799e-02f, 2.77865417e-02f,
  1.26314566e-01f, 5.59733436e-02f, 6.60122782e-02f, 2.17622370e-02f, 6.64025098e-02f, -2.46797819e-02f, -5.44174388e-02f, -8.10699258e-03f, -7.66529217e-02f, -1.61957052e-02f,
  2.73529720e-02f, 7.27321953e-02f, -1.31186262e-01f, 4.42799330e-02f, -1.41144246e-01f, 1.24255028e-02f, -5.01114912e-02f, -1.29643455e-01f, 3.87676023e-02f, 1.23011760e-01f,
  -7.22565472e-01f, -5.87473989e-01f, 9.53898951e-02f, -2.67092884e-02f, -4.63998877e-02f, -2.48720795e-01f, 7.32631534e-02f, -1.73011906e-02f, -1.24476634e-01f, 4.42820378e-02f,
  -8.56857151e-02f, -5.00634052e-02f, -3.85388248e-02f, 3.68266180e-02f, 9.90719125e-02f, -1.03156036e-02f, -2.64529772e-02f, -1.06918946e-01f, -8.36381689e-03f, -4.93388064e-02f,
  4.57563251e-03f, -2.36020293e-02f, 5.67856580e-02f, 9.59655941e-02f, 9.83317848e-03f, -4.24452424e-02f, -9.23966840e-02f, 6.86757863e-02f, -2.49748714e-02f, -3.07596903e-02f,
  -4.92458493e-01f, 2.48822942e-02f, 1.54995888e-01f, -2.44841471e-01f, 2.85706613e-02f, -3.81917395e-02f, -2.80521184e-01f, 2.98342526e-01f, -3.09581041e-01f, 9.96428309e-04f,
  -7.85850175e-03f, -5.03911376e-01f, 2.47446314e-01f, -4.34825808e-01f, -2.06299201e-01f, -1.03439607e-01f, -9.65974703e-02f, -2.83849746e-01f, -3.24996375e-02f, 2.13077486e-01f,
  1.62726790e-01f, 5.66839240e-02f, 1.01303905e-01f, 3.66144687e-01f, 9.28213969e-02f, 1.70653358e-01f, 2.45690286e-01f, 2.77251571e-01f, 7.58624151e-02f, -8.53030086e-02f,
  -2.18535736e-01f, 9.27691013e-02f, 4.76861745e-03f, -2.72435267e-02f, 2.29985908e-01f, -3.39637697e-02f, 4.38585281e-02f, -1.11650571e-01f, -3.82129215e-02f, -1.13073001e-02f,
  -1.14970289e-01f, -2.45957021e-02f, -1.01004519e-01f, -5.86590283e-02f, -9.20801759e-02f, -9.16834921e-03f, -9.07215029e-02f, 6.77509187e-03f, 2.71031577e-02f, 6.46422245e-03f,
  -3.08869779e-02f, -7.62819871e-02f, 6.27805218e-02f, 6.78988770e-02f, -1.12471320e-02f, -8.05784948e-03f, -7.80893192e-02f, -3.26253921e-02f, 2.75181071e-03f, -1.10407710e-01f,
  8.03823993e-02f, 1.07395470e-01f, -6.89346716e-02f, -6.22376762e-02f, -6.16626516e-02f, 5.99802136e-02f, 3.58663462e-02f, -5.32041341e-02f, 6.35517687e-02f, -5.04965335e-02f,
  1.44738093e-04f, -3.71638872e-02f, 7.76489172e-03f, 4.22814526e-02f, -2.10546795e-03f, -2.06510559e-01f, 8.80880952e-02f, -6.30234852e-02f, 7.95567632e-02f, 7.96972215e-02f,
  -3.14013995e-02f, -2.37720683e-02f, -3.68337072e-02f, 1.57863218e-02f, -3.40946466e-02f, 3.33533548e-02f, 1.01544164e-01f, -1.04463594e-02f, 8.26342925e-02f, 2.28259370e-01f,
  2.21059769e-01f, 4.10350412e-01f, 1.23126879e-01f, -3.82778272e-02f, 5.29836453e-02f, 3.25349072e-04f, 5.72364964e-02f, -2.08975859e-02f, 9.70175937e-02f, 1.36984270e-02f,
  1.36894763e-01f, -3.36843878e-02f, 1.16932116e-01f, -3.42621803e-02f, 5.32607846e-02f, 1.56731457e-01f, 8.87670889e-02f, 2.35891715e-02f, 9.97569934e-02f, 1.43045321e-01f,
  1.92296699e-01f, -1.48018741e-03f, -3.20534222e-02f, 5.21899313e-02f, -4.52962145e-02f, 2.60801744e-02f, 6.51862025e-02f, -9.70190167e-02f, 1.58161551e-01f, 5.41785508e-02f,
  3.55447024e-01f, -3.55989933e-02f, -3.48468214e-01f, -2.85293534e-02f, -5.90924807e-02f, 3.40577841e-01f, 2.16821492e-01f, 2.77757980e-02f, -2.03878090e-01f, 1.41882658e-01f,
  1.72648594e-01f, 6.05159514e-02f, 1.20917726e-02f, 4.20072913e-01f, 4.61170524e-01f, 1.85591832e-01f, 2.93555647e-01f, 1.69973105e-01f, -2.14274853e-01f, 1.49303883e-01f,
  -2.68990248e-02f, 3.39350909e-01f, 5.57408966e-02f, 1.40984384e-02f, 4.01578903e-01f, -2.94035524e-01f, 2.53272265e-01f, -9.10123810e-02f, 2.94657618e-01f, 2.95166582e-01f,
  1.01719141e-01f, 5.60291409e-02f, -1.84236486e-02f, -9.28054377e-02f, 4.85594720e-02f, -2.37631705e-02f, -3.95084433e-02f, 7.78852850e-02f, 1.95162036e-02f, 1.21294251e-02f,
  1.11395746e-01f, 3.06398291e-02f, 6.08737506e-02f, 1.18693216e-02f, 3.91619056e-02f, -5.21755964e-02f, -2.48853080e-02f, -1.40472248e-01f, -4.67539728e-02f, 1.05142407e-01f,
  -3.77053395e-02f, -1.42963335e-01f, -3.69261317e-02f, -3.62661593e-02f, 2.68384442e-03f, 4.28997306e-03f, -3.03357635e-02f, 3.21449004e-02f, -4.95312326e-02f, -1.35225095e-02f,
  1.28995091e-01f, -7.75662484e-03f, -4.31487057e-03f, -4.99316957e-03f, -2.63445415e-02f, -2.61818264e-02f, 6.36015311e-02f, -1.01473413e-01f, 1.38874520e-02f, 5.75931072e-02f,
  -9.73967165e-02f, -1.74663542e-03f, -1.73224621e-02f, 3.13006788e-02f, 9.57354307e-02f, 1.39399106e-03f, -1.53289642e-02f, 3.20408531e-02f, -9.37122703e-02f, -1.22148000e-01f,
  -7.91546032e-02f, -2.21476471e-03f, -1.44278584e-02f, 1.00149373e-02f, 2.51405388e-02f, 9.45101678e-03f, 4.58014049e-02f, 5.72527759e-02f, -4.98619303e-03f, 4.43740264e-02f,
  1.17575582e-02f, 2.74329722e-01f, -2.10239924e-02f, 2.35582795e-02f, -1.04989439e-01f, 4.97395964e-03f, 1.52887544e-02f, 1.24898329e-01f, 3.47579047e-02f, 1.13565780e-01f,
  -1.39104584e-02f, -1.56567350e-01f, -9.30775236e-03f, 9.92092863e-03f, -8.89605060e-02f, 2.64578480e-02f, 4.22206111e-02f, -1.24353796e-01f, 4.63597476e-02f, 3.63640807e-04f,
  4.89548482e-02f, 8.69513825e-02f, 3.31660360e-02f, -1.53380170e-01f, 5.01382956e-03f, 9.74545330e-02f, 3.79503705e-02f, -2.29645725e-02f, 9.89256725e-02f, 1.17750205e-02f,
  2.23155871e-01f, -3.66273560e-02f, 3.90336901e-01f, 5.17765284e-01f, -4.84682582e-02f, -3.03178400e-01f, -3.42418365e-02f, -4.77139503e-02f, 1.62384078e-01f, -3.50710958e-01f,
  -1.32943690e-01f, 1.19038954e-01f, -3.62233341e-01f, 1.56982660e-01f, 3.81186187e-01f, -9.92679298e-02f, 3.35745722e-01f, -1.03670489e-02f, 6.10184595e-02f, 1.20735176e-01f,
  1.88242972e-01f, 1.24918662e-01f, 2.76503682e-01f, 5.29640913e-03f, 1.49597585e-01f, 2.87185252e-01f, 2.81595141e-01f, 3.60777937e-02f, 1.92697853e-01f, 1.15108378e-01f,
  -5.37098162e-02f, 7.67689869e-02f, 1.90147553e-02f, -3.25563625e-02f, 6.50356561e-02f, -3.28202173e-02f, 2.59714387e-02f, 5.04831551e-04f, 1.60024658e-01f, -2.98889466e-02f,
  -1.08275004e-01f, -6.10076822e-03f, -2.45641526e-02f, -6.82488382e-02f, 2.17153337e-02f, 1.26084134e-01f, -6.88012922e-03f, -1.25244439e-01f, 9.07857195e-02f, -6.59544617e-02f,
  8.43880847e-02f, -8.94740447e-02f, 7.24611152e-03f, 5.38343415e-02f, 1.80732965e-01f, 1.77066565e-01f, 5.12127541e-02f, 6.80769682e-02f, 2.00019721e-02f, 1.26746893e-01f,
  8.44698399e-02f, -5.74406423e-02f, -6.28151596e-02f, -9.91536081e-02f, 5.90726100e-02f, 9.07109603e-02f, 8.80871564e-02f, -7.07256570e-02f, -4.73485142e-02f, 6.35144636e-02f,
  7.64700696e-02f, 9.02407169e-02f, -2.23350469e-02f, 1.09775672e-02f, 5.09693734e-02f, 4.47857343e-02f, -1.49614394e-01f, -1.79926530e-01f, 1.12241497e-02f, 1.25913450e-03f,
  3.81437666e-03f, -3.33721680e-03f, 1.62739027e-02f, 9.23649147e-02f, 6.39998913e-02f, -9.29862112e-02f, 7.92276263e-02f, 1.26949768e-03f, -8.28765184e-02f, 5.51989563e-02f,
  1.89468101e-01f, 2.74059623e-01f, 2.79045086e-02f, -2.79760789e-02f, 1.54688135e-01f, -1.07412159e-01f, 5.66573665e-02f, 4.67010736e-02f, 2.57259876e-01f, -1.07023045e-02f,
  -8.75489116e-02f, -8.88093933e-02f, -5.37794419e-02f, 2.05207560e-02f, -6.76845480e-03f, 1.37233019e-01f, 5.93634993e-02f, 1.50191218e-01f, 1.33616298e-01f, 1.66933017e-03f,
  1.43679306e-02f, -1.27366260e-01f, 7.22238719e-02f, 2.93681398e-02f, -2.11716481e-02f, 5.13647050e-02f, -6.59370273e-02f, 9.02607106e-03f, 6.92281947e-02f, 1.13788918e-01f,
  -7.29123473e-01f, 4.16659445e-01f, 1.75324053e-01f, -5.81487238e-01f, 5.80012277e-02f, 1.16501041e-01f, -4.74770606e-01f, 1.44056246e-01f, 2.95402054e-02f, -2.36555915e-02f,
  -3.78566831e-02f, -1.08367816e-01f, 4.03209358e-01f, -4.77005169e-02f, 1.23264708e-01f, 3.01594883e-01f, -2.30374545e-01f, -2.86556751e-01f, 3.55450017e-03f, -2.30757415e-01f,
  1.09146923e-01f, -3.12891603e-01f, 1.86304793e-01f, 6.15486242e-02f, -2.14324310e-01f, -2.39958569e-01f, -3.48703802e-01f, -4.99690771e-02f, -2.30455518e-01f, -1.06948487e-01f,
  -2.54923433e-01f, -1.29797921e-01f, 1.86698556e-01f, 1.01189166e-01f, -5.57206348e-02f, -2.25430131e-02f, -9.17855129e-02f, 6.46718368e-02f, -1.40736163e-01f, -5.20125255e-02f,
  -2.57724822e-01f, -2.72962693e-02f, -7.53208697e-02f, 6.44056574e-02f, -4.52492125e-02f, 9.40566733e-02f, 5.93356863e-02f, -9.76888314e-02f, 1.01387560e-01f, 1.41891718e-01f,
  1.91120133e-01f, 1.64701104e-01f, 8.70435387e-02f, -6.27634451e-02f, -8.11550766e-03f, -4.51653711e-02f, 3.06577291e-02f, 9.64151621e-02f, 3.46059278e-02f, -2.68990789e-02f,
  1.05095685e-01f, 9.18998420e-02f, -2.48051994e-02f, -7.79425204e-02f, -5.99333160e-02f, -1.36720808e-02f, 3.64159644e-02f, -8.28057230e-02f, -1.00858018e-01f, -7.11871982e-02f,
  -1.07294112e-01f, 8.00715983e-02f, -1.20253205e-01f, -1.26864910e-01f, -2.81687289e-01f, -1.94164380e-01f, -8.84827822e-02f, -5.34183607e-02f, -5.96928746e-02f, 9.85902175e-03f,
  4.58227433e-02f, 6.26535937e-02f, 6.39929846e-02f, -2.58419048e-02f, 9.29179490e-02f, -8.77696499e-02f, -1.02258287e-01f, 1.79881658e-02f, 8.64332095e-02f, -3.79743166e-02f,
  -3.33928913e-01f, -2.83816069e-01f, -7.09739700e-03f, -8.08404759e-02f, -6.07468374e-02f, 6.49848133e-02f, 3.68825458e-02f, -2.60735359e-02f, -1.65811852e-01f, -6.29690140e-02f,
  -3.56216840e-02f, -1.45670980e-01f, -1.41552001e-01f, -8.96969587e-02f, -6.42415211e-02f, -6.20189868e-02f, -2.09242538e-01f, -1.90225542e-01f, -1.46266103e-01f, -3.86239812e-02f,
  6.35951385e-03f, 3.66944186e-02f, 1.87895838e-02f, -1.14997283e-01f, 9.02844742e-02f, -1.38245091e-01f, -7.26588443e-02f, 2.05242038e-01f, -5.41893654e-02f, 1.46094292e-01f,
  -3.01953852e-01f, -3.34441274e-01f, 2.18891323e-01f, -4.72447157e-01f, 2.44699836e-01f, 5.28116286e-01f, 4.29466367e-01f, -1.91188887e-01f, -5.64756453e-01f, 5.69612198e-02f,
  1.21867023e-01f, 1.42428949e-01f, 2.94291675e-01f, -1.78651273e-01f, 4.03902262e-01f, -2.36356892e-02f, -2.66052514e-01f, 2.20625736e-02f, -2.24655926e-01f, -3.74065936e-02f,
  -1.26374930e-01f, -7.40841031e-02f, 1.56471521e-01f, -1.96592733e-01f, 5.47710545e-02f, -3.60432826e-02f, 4.66939136e-02f, 3.38151902e-01f, -1.12165250e-02f, 2.15142742e-01f,
  9.66966003e-02f, -1.46505356e-01f, -3.49984951e-02f, 8.83101895e-02f, 2.03894936e-02f, 1.14739493e-01f, 2.59898007e-01f, 1.13101207e-01f, -5.65984771e-02f, -3.49626243e-02f,
  -4.10680324e-02f, 1.40912170e-02f, -1.19909652e-01f, -5.59183173e-02f, -1.77445099e-01f, -5.44315651e-02f, -8.46499428e-02f, -9.91012678e-02f, -4.74351943e-02f, 8.87912884e-02f,
  4.25063334e-02f, -9.29343104e-02f, -1.25868931e-01f, -1.08640797e-01f, 6.07562140e-02f, -6.82983473e-02f, 2.98433509e-02f, 2.48405382e-01f, -5.85785769e-02f, -1.17169924e-01f,
  2.36582644e-02f, 7.12086037e-02f, 3.84907238e-02f, 1.58665758e-02f, -1.55901536e-02f, 2.19399426e-02f, -4.20871899e-02f, 5.35777118e-03f, 2.35588606e-02f, -7.43347853e-02f,
  -9.92934257e-02f, 4.31947410e-02f, -1.19076133e-01f, -3.12661417e-02f, 1.02913044e-01f, -5.16264401e-02f, 2.74533927e-01f, 7.42048351e-03f, -5.22272512e-02f, -3.11109722e-02f,
  -5.58349527e-02f, -2.57128607e-02f, 1.49306089e-01f, 3.89427841e-02f, -1.19532913e-01f, 8.46935809e-02f, -8.82826000e-02f, -3.40651795e-02f, -9.75244567e-02f, 1.82097793e-01f,
  1.57521099e-01f, -7.70502537e-02f, 7.91184083e-02f, -1.16545103e-01f, 1.44742563e-01f, -8.99567327e-04f, 2.80178105e-03f, -2.51724515e-02f, -1.55999690e-01f, -2.64885165e-02f,
  -6.58419775e-03f, -4.28778604e-02f, -7.93480594e-03f, 5.10322861e-02f, 7.20614418e-02f, 1.20315909e-01f, -2.17658579e-02f, -8.54608938e-02f, -2.14600544e-02f, 4.42234538e-02f,
  6.72351867e-02f, -6.00327156e-04f, -1.25976607e-01f, -1.99570224e-01f, -6.93920776e-02f, 1.36327505e-01f, -7.57056773e-02f, -7.00729713e-02f, -1.27712102e-03f, -1.19154990e-01f,
  9.19559300e-01f, -4.20621276e-01f, 3.27061594e-01f, 4.62628365e-01f, 2.68120855e-01f, -8.33694488e-02f, 4.03176844e-01f, -1.89482331e-01f, -1.10437632e-01f, -4.89072740e-01f,
  3.59834470e-02f, 2.42161915e-01f, -5.60519360e-02f, -5.84161328e-03f, 8.34948476e-03f, -2.45185688e-01f, -1.76247865e-01f, 9.92496386e-02f, 4.49475944e-02f, 1.28150105e-01f,
  1.01388566e-01f, -2.61998892e-01f, 9.87413377e-02f, -4.69492823e-01f, 3.77881825e-01f, 6.16527386e-02f, -3.45637739e-01f, 4.47973050e-02f, -1.83187604e-01f, 8.83468054e-03f,
  5.41974567e-02f, 2.21898109e-01f, 9.65841115e-02f, -6.78093433e-02f, 2.83517176e-03f, 1.23428904e-01f, 8.62170309e-02f, 9.67948958e-02f, 2.87973266e-02f, -1.15026664e-02f,
  1.11956447e-01f, -6.52896911e-02f, -3.01247612e-02f, 3.44673544e-02f, 6.13302700e-02f, -2.09366679e-02f, 6.99297935e-02f, 1.48168981e-01f, 7.38719255e-02f, 2.40971297e-01f,
  1.27745867e-01f, 6.44695088e-02f, 6.84031919e-02f, -7.48449042e-02f, 1.31692952e-02f, 2.02508457e-02f, -7.50417784e-02f, 7.34899789e-02f, 1.72381606e-02f, -6.72109574e-02f,
  -1.46643281e-01f, -1.45994768e-01f, 1.18637539e-01f, 2.31778678e-02f, 2.12786421e-02f, 2.27801651e-01f, 6.09853640e-02f, 9.06279087e-02f, 6.65540695e-02f, 5.65316454e-02f,
  9.87544190e-03f, 1.17941640e-01f, -1.21542558e-01f, -6.27316758e-02f, 4.30750437e-02f, -5.37077896e-02f, 8.28200579e-02f, -3.35044563e-02f, 2.19574245e-03f, 1.12502210e-01f,
  -4.76424918e-02f, -1.39591042e-02f, 7.00628683e-02f, 2.58716755e-02f, -1.06384434e-01f, 2.57462021e-02f, 5.49969077e-02f, 4.00882587e-02f, -3.48640382e-02f, 4.17695828e-02f,
  -4.95759338e-01f, -4.88617659e-01f, -1.05033331e-01f, -1.69875566e-02f, -1.36051802e-02f, -5.73627949e-02f, -1.77541357e-02f, -9.04174149e-02f, -1.97321057e-01f, 9.43497475e-03f,
  -7.24918693e-02f, 1.24669418e-01f, -2.03863740e-01f, -1.46101124e-03f, -9.49387550e-02f, -1.68974578e-01f, 3.65231447e-02f, -6.85205534e-02f, 4.18682173e-02f, -1.49867594e-01f,
  8.74014050e-02f, -4.47648913e-02f, 8.64382237e-02f, 3.38802338e-02f, -1.91475954e-02f, 2.88370457e-02f, -7.40885884e-02f, -5.63235246e-02f, -9.05823112e-02f, -1.53400347e-01f,
  -1.92568257e-01f, -2.58637458e-01f, -5.86208291e-02f, -5.13306633e-03f, -4.08049226e-02f, -1.25382975e-01f, -3.50487411e-01f, 6.53193891e-02f, -3.27195019e-01f, -2.36893147e-01f,
  -1.95646174e-02f, -2.25751996e-01f, -2.07727805e-01f, -8.41688141e-02f, 2.64639795e-01f, -3.05851728e-01f, 2.97052085e-01f, 6.91631660e-02f, 4.97114100e-02f, 3.08375567e-01f,
  3.54417205e-01f, 3.86949986e-01f, 3.16616178e-01f, 5.10294080e-01f, 1.80453882e-01f, 3.88336211e-01f, 3.26211065e-01f, 2.93577164e-01f, 4.10081387e-01f, 1.44663677e-01f,
  -1.97341487e-01f, -3.66426259e-02f, 4.98131849e-03f, 6.91497559e-03f, 2.40186200e-01f, -7.58022219e-02f, 1.09500423e-01f, 9.44640934e-02f, -5.58683313e-02f, 8.07438642e-02f,
  2.35028844e-02f, 1.47101626e-01f, -6.60924315e-02f, -6.26941174e-02f, 5.61167747e-02f, -7.54767358e-02f, -1.48852812e-02f, -2.33560279e-02f, -9.85685065e-02f, -5.10607213e-02f,
  -1.59938797e-01f, -3.93692888e-02f, -3.27739865e-02f, 1.65819768e-02f, 2.23614518e-02f, 8.01174417e-02f, -1.87868085e-02f, -5.83181642e-02f, -9.18588862e-02f, -2.13681571e-02f,
  4.66040783e-02f, 5.18121757e-02f, -4.40742867e-03f, -1.71242595e-01f, -1.08742617e-01f, -1.01030499e-01f, -1.38747869e-02f, -8.53542536e-02f, -3.83943245e-02f, -1.00919344e-01f,
  4.52597328e-02f, 7.47885369e-03f, -7.41191953e-02f, -4.14984338e-02f, 8.03164840e-02f, -2.90510431e-02f, -4.13813395e-03f, 1.06354374e-02f, 1.80382058e-02f, -9.88616347e-02f,
  -4.95697185e-02f, 4.74049039e-02f, 2.38132924e-02f, 7.59454370e-02f, -1.80092037e-01f, 4.73418869e-02f, -8.37823260e-04f, -9.64815915e-02f, 1.30953891e-02f, 1.34518251e-01f,
  7.15823993e-02f, 1.88455209e-01f, 5.24867214e-02f, 1.99357420e-02f, -1.33406505e-01f, 2.86979247e-02f, -1.74610817e-03f, 2.75225881e-02f, 1.61892354e-01f, -3.07429247e-02f,
  9.74076539e-02f, 1.02997847e-01f, 2.57198345e-02f, -4.96394746e-02f, 6.39582351e-02f, 2.92899180e-02f, 1.09677233e-01f, -1.56806298e-02f, -5.68443462e-02f, 1.94327876e-01f,
  5.25499359e-02f, 2.59773228e-02f, 7.95111358e-02f, -1.49624040e-02f, -3.39374058e-02f, -2.49813288e-03f, -4.53221723e-02f, -1.10395458e-02f, -2.05081999e-02f, -1.45007400e-02f,
  9.66176018e-02f, -3.75691026e-01f, -2.16300830e-01f, -1.08791001e-01f, 3.22167091e-02f, -3.09561670e-01f, -1.27677590e-01f, -1.27576709e-01f, 1.34722173e-01f, -4.29358840e-01f,
  -8.83051455e-02f, 1.99728720e-02f, 9.93443727e-02f, -3.63715082e-01f, 5.59282660e-01f, 1.10984288e-01f, -2.20878318e-01f, -1.56667769e-01f, 1.65855020e-01f, -1.20839246e-01f,
  -3.61135826e-02f, -1.50361240e-01f, -1.72967091e-01f, -2.99429864e-01f, -2.67729223e-01f, -1.72384918e-01f, 1.54599547e-01f, -5.40089868e-02f, -2.41248637e-01f, 6.88653588e-02f,
  -1.17769174e-01f, -3.96107994e-02f, -2.00246908e-02f, -1.02544740e-01f, 1.36839040e-02f, -7.21103512e-03f, -6.20029233e-02f, 8.50356743e-02f, 1.34381494e-02f, -4.42192256e-02f,
  1.73550714e-02f, 9.22493413e-02f, -7.58463889e-02f, 8.64677355e-02f, -1.58986196e-01f, -8.37663189e-02f, 4.91698980e-02f, -4.33175564e-02f, -8.18021446e-02f, -7.02456459e-02f,
  -7.87284076e-02f, 2.71174256e-02f, -1.05244853e-02f, 9.72277224e-02f, 1.30384877e-01f, 8.31567720e-02f, 1.20798893e-01f, 1.11837320e-01f, 9.26476493e-02f, 1.07214943e-01f,
  -4.31341194e-02f, 1.22139327e-01f, -4.44766134e-02f, 6.60365000e-02f, -2.31012776e-02f, -6.67633712e-02f, -3.45963016e-02f, 3.49343680e-02f, 4.03763577e-02f, -7.60591701e-02f,
  3.63178588e-02f, -8.25333819e-02f, 2.91008912e-02f, -3.34574468e-02f, 3.02664246e-02f, 1.62815049e-01f, -6.72785416e-02f, 5.70833869e-02f, 4.77183461e-02f, -4.55736332e-02f,
  8.01980272e-02f, 7.94755854e-03f, -8.56353194e-02f, 1.29066154e-01f, -3.60657857e-03f, 1.62218139e-02f, -1.88139856e-01f, -6.01716600e-02f, 5.86512275e-02f, -7.67321065e-02f,
  4.29417416e-02f, -2.41162822e-01f, -4.82646748e-02f, -1.41775422e-02f, 3.64741161e-02f, 1.15601681e-02f, -7.34762996e-02f, -1.20394658e-02f, -2.01288298e-01f, -1.96223147e-02f,
  -1.16513772e-02f, -6.76832199e-02f, 7.28104264e-02f, 5.72112091e-02f, -1.59381479e-02f, -1.91398114e-01f, 5.33980280e-02f, 1.12931803e-01f, 9.95299816e-02f, 4.45575360e-03f,
  4.87739453e-03f, 4.78599146e-02f, 8.10225308e-02f, -4.93105762e-02f, -2.70166732e-02f, 1.66652828e-01f, 2.10318521e-01f, -6.80086762e-02f, 1.32364646e-01f, -1.94814187e-02f,
  -7.58151531e-01f, 1.35382771e-01f, 2.98631281e-01f, -3.58900428e-01f, -2.16362819e-01f, 6.52454257e-01f, 3.11619431e-01f, 3.95681709e-02f, -1.37945727e-01f, 1.82022616e-01f,
  -3.87804513e-03f, -3.99645060e-01f, 2.50800163e-01f, 2.82449573e-02f, 3.74784559e-01f, 3.54532212e-01f, 2.22729206e-01f, 7.94162452e-02f, -2.18185559e-01f, -3.67295176e-01f,
  -1.65951282e-01f, -1.69011667e-01f, 1.86672300e-01f, -3.60030919e-01f, -2.07930490e-01f, -3.47977519e-01f, -1.37946144e-01f, -1.72381878e-01f, -1.12172469e-01f, -3.17310803e-02f,
  -8.10557902e-02f, -3.38270605e-01f, 1.57688407e-03f, 6.52417243e-02f, -2.26622596e-02f, 6.11947291e-02f, -7.46314079e-02f, -5.49124666e-02f, -1.34239167e-01f, -5.93851972e-03f,
  -1.12466618e-01f, 1.81185659e-02f, -1.19250491e-01f, -2.86229998e-02f, -1.13738038e-01f, -3.88375185e-02f, 8.23919922e-02f, 1.52472928e-01f, 7.11931288e-02f, 8.04951116e-02f,
  2.75557697e-01f, 1.22035161e-01f, 1.41672850e-01f, 4.37425338e-02f, 9.91048887e-02f, 1.04962796e-01f, 1.54397115e-01f, 5.75514399e-02f, 5.59687726e-02f, -1.57197341e-02f,
  -8.79759192e-02f, -6.30338863e-02f, 1.77811369e-01f, -4.72006053e-02f, -9.61778685e-02f, -7.24566951e-02f, -1.07921939e-03f, -5.36294580e-02f, -6.50753304e-02f, 1.00952379e-01f,
  -1.09296717e-01f, -4.04009707e-02f, -1.02722198e-01f, 1.08498685e-01f, -5.57632893e-02f, -7.23800212e-02f, -2.78501976e-02f, -1.04115248e-01f, -2.99019124e-02f, 1.43967345e-01f,
  4.66655493e-02f, -3.76582257e-02f, -5.57869412e-02f, 9.48142186e-02f, 8.08177739e-02f, 1.27899662e-01f, -3.05242352e-02f, 1.63699344e-01f, 7.34162331e-02f, -1.11728936e-01f,
  -8.75052139e-02f, -3.04943383e-01f, -1.25089437e-01f, -1.29255280e-01f, -1.23877659e-01f, -4.14274074e-02f, -2.20960211e-02f, 4.33963649e-02f, -4.57674935e-02f, -3.59845497e-02f,
  -6.92064911e-02f, 5.62809259e-02f, -4.49047200e-02f, -1.41459912e-01f, -2.69381311e-02f, 9.94671434e-02f, -5.19964546e-02f, -1.19522788e-01f, -6.71540350e-02f, -8.93393382e-02f,
  -5.74184246e-02f, -1.45155817e-01f, 1.27804786e-01f, 5.41757001e-03f, -5.00860810e-02f, -3.85264261e-03f, -2.07605332e-01f, -1.27085298e-01f, 1.03367366e-01f, 1.21293552e-01f,
  3.34824562e-01f, -1.96151391e-01f, 2.98512369e-01f, 2.34984085e-01f, 2.23956898e-01f, 4.26395923e-01f, 4.09583867e-01f, 1.21748626e-01f, 5.56633592e-01f, -2.32509032e-01f,
  -4.34405029e-01f, 1.65816247e-01f, -1.58674106e-01f, -3.37893032e-02f, 3.43255162e-01f, 1.89225167e-01f, 3.06221515e-01f, 2.09254220e-01f, 1.01276435e-01f, 7.75737911e-02f,
  5.05134240e-02f, -7.66108707e-02f, -2.88208395e-01f, -1.12621523e-01f, -2.41405398e-01f, -2.14287207e-01f, -2.86888063e-01f, 3.23967822e-02f, -2.59250641e-01f, 1.30232826e-01f,
  -3.58802918e-03f, -1.29406855e-01f, -7.42724240e-02f, -6.29201233e-02f, 1.09556876e-01f, 1.91612896e-02f, -6.79165274e-02f, 1.27795428e-01f, -2.10267399e-02f, -3.16388934e-04f,
  5.13124801e-02f, 7.57269561e-02f, -1.55541506e-02f, -1.39364181e-02f, 1.41137809e-01f, 4.03046049e-02f, 2.21071895e-02f, -7.84614086e-02f, -1.42077971e-02f, 2.98094358e-02f,
  2.86132633e-03f, 3.07141766e-02f, -1.94872990e-02f, -2.06029555e-03f, -1.64006669e-02f, 1.43566178e-02f, 7.37995058e-02f, 4.02745195e-02f, 3.38845178e-02f, 1.19579785e-01f,
  -2.13749722e-01f, 3.80262621e-02f, 7.89850578e-02f, -6.80546537e-02f, 7.33756125e-02f, -9.44508519e-03f, 3.09474505e-02f, -4.31064740e-02f, 1.46796539e-01f, -5.75932600e-02f,
  -8.61550740e-04f, -3.26336585e-02f, 4.46468033e-02f, -6.69413283e-02f, -1.30914330e-01f, -2.92862523e-02f, 1.14239857e-03f, 2.32394710e-02f, 6.64847866e-02f, 2.87904162e-02f,
  -4.74303216e-02f, 6.19781166e-02f, -8.02717283e-02f, -7.78781325e-02f, 1.74909085e-02f, -3.85083966e-02f, -1.13694191e-01f, 4.20470499e-02f, -1.69605553e-01f, -5.52664250e-02f,
  2.06967682e-01f, 1.88503593e-01f, -1.70421451e-01f, -1.21830322e-01f, -4.02473770e-02f, -5.96146099e-02f, 9.82140452e-02f, 9.79794711e-02f, 1.13269284e-01f, -6.65349439e-02f,
  -8.96185189e-02f, -7.35392943e-02f, 2.91140378e-02f, 2.49952767e-02f, -4.81790565e-02f, -3.04894112e-02f, 4.68223467e-02f, 1.94979191e-03f, 4.23012264e-02f, -7.25087821e-02f,
  -7.20495507e-02f, -2.64866576e-02f, 7.32585490e-02f, -1.29874283e-02f, -8.23371783e-02f, 1.90023165e-02f, 8.35947245e-02f, -6.72652423e-02f, -1.12396337e-01f, 4.48997803e-02f,
  -2.84425961e-03f, 5.28697848e-01f, 2.17870265e-01f, 6.00796863e-02f, -2.51436949e-01f, -2.86815137e-01f, -4.58202511e-01f, 4.41657454e-02f, -2.64680833e-01f, -1.79354325e-01f,
  -2.07992122e-01f, 2.11692840e-01f, 1.82129130e-01f, 6.47143647e-02f, 4.75042433e-01f, 3.61502230e-01f, 7.06446841e-02f, -3.69086899e-02f, 4.08934474e-01f, 3.65710348e-01f,
  2.78902322e-01f, 1.00163147e-01f, 4.74212378e-01f, 2.88522065e-01f, 2.06025198e-01f, 1.91383392e-01f, 2.43432567e-01f, 1.57111600e-01f, -1.45379771e-02f, -7.03847781e-02f,
  -1.40063390e-01f, -8.63932073e-02f, 2.51506940e-02f, -1.31145790e-01f, -2.84337047e-02f, -2.67787814e-01f, 9.05574560e-02f, 6.05249591e-02f, -1.83203667e-01f, -4.56509106e-02f,
  6.88104481e-02f, 4.37522568e-02f, -6.51568100e-02f, -6.30105659e-02f, -4.08872515e-02f, 2.00906731e-02f, 2.90220857e-01f, -1.11388727e-04f, 3.92582230e-02f, 9.50489789e-02f,
  2.36121044e-01f, 4.88749929e-02f, 6.66077286e-02f, 6.31805584e-02f, 2.23396301e-01f, -1.78338408e-01f, -1.09161362e-01f, -4.90012839e-02f, 1.16814654e-02f, 4.52704169e-02f,
  -4.82491478e-02f, -1.50686085e-01f, -8.75113308e-02f, -1.69604905e-02f, -2.97434386e-02f, -9.95288342e-02f, 1.17284946e-01f, 1.56475056e-03f, 3.40913348e-02f, 1.48768052e-02f,
  -9.74260718e-02f, 6.27658442e-02f, -8.37499723e-02f, -1.50579140e-01f, -4.16426826e-03f, -1.29110977e-01f, -3.80311385e-02f, 3.72504033e-02f, 5.83099946e-02f, 2.39537898e-02f,
  -8.87570083e-02f, 4.23021279e-02f, -4.95511517e-02f, 7.45512545e-02f, -2.28271767e-01f, 1.32369949e-02f, 1.59755930e-01f, -1.62781198e-02f, 1.21670570e-02f, 2.35797375e-01f,
  1.38070006e-02f, 3.65672290e-01f, 9.58571618e-04f, -1.21779914e-03f, 1.15960047e-01f, 1.10435218e-01f, 4.65063602e-02f, 1.24893859e-01f, 1.18346080e-01f, 2.02722084e-02f,
  4.48978692e-02f, -1.18700095e-01f, -4.54795994e-02f, 5.40981106e-02f, 1.88102890e-02f, 8.39265659e-02f, -5.99640757e-02f, -1.21743619e-01f, 1.05649643e-01f, 1.92115441e-01f,
  2.12567613e-01f, 7.01713655e-03f, 1.12001911e-01f, 3.71880755e-02f, 2.77297758e-03f, 3.52528170e-02f, -2.68449262e-02f, -1.66258328e-02f, 1.57652050e-01f, -7.31585398e-02f,
  -7.24094272e-01f, 9.52612087e-02f, 1.74078643e-01f, -3.24599087e-01f, -1.11965239e-01f, 1.05866641e-01f, 3.30594569e-01f, -3.17623675e-01f, -1.51359320e-01f, 1.77654475e-01f,
  3.64907652e-01f, -1.04768485e-01f, 3.93973947e-01f, 2.55438417e-01f, -1.55690104e-01f, 4.60228831e-01f, -5.51955327e-02f, 1.18817054e-01f, -1.33717684e-02f, -2.22233012e-01f,
  -1.87597260e-01f, 2.01715127e-01f, 4.05297220e-01f, -1.20794967e-01f, -7.30207711e-02f, -1.71132177e-01f, 4.15339060e-02f, 2.40152851e-01f, -1.37542889e-01f, 1.77401438e-01f,
  -3.93065274e-01f, -3.59575540e-01f, 6.04266375e-02f, -1.48699209e-01f, -5.94058186e-02f, 1.69230048e-02f, 5.23058809e-02f, 1.88179284e-01f, 1.85561310e-02f, -1.03159361e-01f,
  -3.39492187e-02f, -1.89124256e-01f, -1.46572903e-01f, 3.62293981e-02f, -2.35553801e-01f, -7.62481466e-02f, 5.61066531e-02f, -8.90067592e-02f, 9.22001451e-02f, -1.28546348e-02f,
  5.75512201e-02f, -8.02601203e-02f, -1.68623663e-02f, 1.32753983e-01f, 6.58289790e-02f, -6.72103986e-02f, -4.05189246e-02f, -9.59470347e-02f, -2.35943615e-01f, -1.83879569e-01f,
  4.17735651e-02f, 4.60382849e-02f, -2.07550135e-02f, -2.78633088e-02f, 6.30625635e-02f, -5.02293445e-02f, 3.97156850e-02f, 5.25663458e-02f, 2.77775098e-02f, 8.28510076e-02f,
  -1.35837525e-01f, -2.07200274e-01f, -3.50866169e-02f, -4.16496061e-02f, -1.66218206e-01f, 3.84510271e-02f, 7.39130080e-02f, 9.93011333e-03f, 2.07865820e-03f, -4.23529651e-03f,
  2.60964893e-02f, -4.73388731e-02f, 3.64901638e-03f, 2.64693312e-02f, 3.68266664e-02f, 1.00323111e-01f, 6.37035742e-02f, 1.69266723e-02f, 8.33518058e-02f, 4.35641147e-02f,
  -5.64443707e-01f, -5.69878817e-01f, 6.87279627e-02f, -1.04138121e-01f, -3.66065986e-02f, -1.74562231e-01f, 1.05784358e-02f, -1.84433281e-01f, -1.55571610e-01f, -3.63339148e-02f,
  -1.20402724e-01f, -2.97695561e-03f, -1.19281955e-01f, 1.34309724e-01f, -8.02764222e-02f, -1.18949115e-02f, 1.33019432e-01f, 1.08124033e-01f, 5.74525036e-02f, -1.06675312e-01f,
  4.18487675e-02f, 7.18062446e-02f, 1.65483341e-01f, -5.63413254e-04f, -3.98344807e-02f, -2.51031071e-02f, -1.43317148e-01f, -5.16595840e-02f, -1.61308438e-01f, 5.34593090e-02f,
  4.45964158e-01f, 3.00582767e-01f, 3.07587504e-01f, 6.03923798e-01f, -4.73988242e-02f, 1.86117530e-01f, 2.98044503e-01f, 1.04263663e-01f, 4.69381660e-01f, 1.49617895e-01f,
  -2.33300030e-01f, 7.77674019e-02f, -2.36553088e-01f, 4.10424620e-01f, -4.21193212e-01f, 2.10004505e-02f, 3.22096348e-01f, 1.81427464e-01f, 8.34210068e-02f, 1.39555812e-01f,
  2.19709113e-01f, -3.89690995e-01f, -1.82190955e-01f, -3.25071782e-01f, 1.42529204e-01f, 1.99686572e-01f, -3.95618469e-01f, -2.40228981e-01f, -2.96898726e-02f, -2.06713721e-01f,
  1.79420680e-01f, 1.27393290e-01f, -1.40298363e-02f, 8.39315802e-02f, 1.43128797e-01f, -8.93374681e-02f, 5.28962016e-02f, -1.81539878e-01f, 2.41892356e-02f, 6.08228371e-02f,
  7.28523284e-02f, -1.78246610e-02f, 1.33062676e-01f, -1.54044330e-01f, 5.74115813e-02f, 3.49343009e-02f, 1.17617227e-01f, 2.08897844e-01f, 1.10002294e-01f, -3.53671648e-02f,
  1.65402025e-01f, 2.09415197e-01f, 1.05291829e-01f, 8.64556152e-03f, 5.12645133e-02f, 9.05183554e-02f, 9.33590680e-02f, -2.48312932e-02f, 1.41478255e-01f, 9.25982669e-02f,
  -1.53360009e-01f, 9.09322500e-02f, -2.26982180e-02f, 1.05629779e-01f, -1.55897820e-02f, -4.39398773e-02f, 5.13509139e-02f, -6.11801678e-03f, 2.79404167e-02f, 4.31906097e-02f,
  7.86155611e-02f, -3.76351364e-02f, 3.32969852e-04f, -1.62208658e-02f, 5.83087057e-02f, 7.78144673e-02f, -3.52516323e-02f, 1.27377227e-01f, 1.06655031e-01f, -3.80777381e-02f,
  -1.48547858e-01f, 6.48751156e-03f, -1.06648035e-01f, 1.13047054e-02f, 5.39254285e-02f, -5.16054146e-02f, 3.72365639e-02f, 1.18616760e-01f, 5.24369441e-02f, -1.42766029e-01f,
  -1.28019974e-02f, -2.72710800e-01f, 1.52335158e-02f, 9.54769626e-02f, 9.74333137e-02f, -4.44926471e-02f, 7.31974542e-02f, 4.14568186e-02f, -7.53319338e-02f, 2.51120124e-02f,
  9.46551785e-02f, 1.50555208e-01f, -3.72832678e-02f, -9.59127918e-02f, -7.05949217e-02f, 3.53654735e-02f, 5.64694181e-02f, -8.47370774e-02f, -2.09385857e-01f, -1.48194164e-01f,
  -3.43318507e-02f, 2.43498459e-02f, 6.15843087e-02f, 6.35707378e-02f, 6.12314045e-02f, -1.14269406e-01f, 4.70301509e-03f, -6.63568825e-02f, -1.36650443e-01f, -4.15291786e-02f,
  -1.94515705e-01f, -1.28530785e-01f, 1.12171166e-01f, 1.96621314e-01f, -1.24676138e-01f, -2.28140756e-01f, -3.48243117e-01f, 9.68228618e-04f, -1.31321564e-01f, -2.74058342e-01f,
  -2.00989515e-01f, 1.67509004e-01f, -4.16721791e-01f, 1.45257205e-01f, -1.54134378e-01f, -4.48762566e-01f, 5.45907244e-02f, 9.00104828e-03f, -3.57469916e-02f, 1.17460795e-01f,
  1.17267221e-01f, 9.60366577e-02f, 1.33058459e-01f, 2.91031539e-01f, 1.31427422e-01f, 3.44768465e-01f, 2.83963650e-01f, 8.37086514e-02f, 4.11544949e-01f, 2.29484349e-01f,
  -1.32314593e-01f, -1.91367175e-02f, -1.81167033e-02f, 2.93036699e-02f, 2.41987649e-02f, 1.19486772e-01f, 8.68992880e-02f, 4.24706079e-02f, -3.43525261e-02f, 1.37553319e-01f,
  2.83471420e-02f, 1.15442157e-01f, 1.86962172e-01f, 3.99168953e-02f, 1.02651671e-01f, 1.36724919e-01f, 1.09426089e-01f, -2.69337073e-02f, 4.81830612e-02f, -3.42725255e-02f,
  8.71871877e-03f, -8.31627026e-02f, 1.56415880e-01f, -9.27757937e-03f, 3.32399420e-02f, 1.31083755e-02f, 1.55987963e-01f, 9.58707258e-02f, 1.59826249e-01f, 1.34889528e-01f,
  -1.31202355e-01f, 5.46964351e-03f, 1.12720139e-01f, 8.60201716e-02f, 3.95210162e-02f, 3.16347219e-02f, -2.01893551e-03f, -1.41729275e-02f, 2.87699997e-02f, -6.03461266e-02f,
  3.27289477e-02f, 4.12724400e-03f, 4.59926389e-02f, 7.56944865e-02f, 1.89922880e-02f, -9.57230777e-02f, 4.32804078e-02f, 8.86881426e-02f, 8.19831491e-02f, -7.66108930e-02f,
  -7.93594271e-02f, -3.13907191e-02f, 3.19641852e-03f, 1.33753773e-02f, 1.56164765e-02f, -1.69056538e-03f, 8.99164677e-02f, -2.69085658e-03f, 5.38309216e-02f, 3.45259607e-02f,
  -1.54836938e-01f, 7.32271373e-02f, 1.02141155e-02f, -3.31526250e-02f, -2.68291999e-02f, 2.81409547e-02f, -1.05414696e-01f, -1.07961856e-02f, 2.91450005e-02f, -1.62437126e-01f,
  -1.25002116e-02f, 1.21703170e-01f, -3.56549285e-02f, -9.69624426e-03f, 3.06372419e-02f, -1.37595788e-01f, 3.06261778e-02f, 8.15130547e-02f, 7.51299635e-02f, 6.71176091e-02f,
  5.72293438e-03f, -7.56828785e-02f, 1.25703380e-01f, 7.72721693e-02f, -9.18045342e-02f, -6.59448206e-02f, 8.43558758e-02f, 4.81065875e-03f, -2.62976848e-02f, -3.18791317e-05f,
  3.52896303e-01f, -2.80488312e-01f, 4.29077595e-01f, 3.14069927e-01f, 4.62716103e-01f, 2.86244482e-01f, 4.61924583e-01f, 1.48471147e-01f, 4.31690216e-01f, -5.65127015e-01f,
  -2.90356338e-01f, -1.29697308e-01f, 2.62776405e-01f, -2.64101505e-01f, 4.09077913e-01f, 1.96487471e-01f, 2.00076923e-01f, 1.72860041e-01f, 3.25412124e-01f, 8.41273814e-02f,
  -4.20017866e-03f, -2.26299539e-01f, 5.92173189e-02f, -2.80939847e-01f, 2.35850438e-02f, -1.06414773e-01f, -3.24354351e-01f, 2.11118877e-01f, -4.85264301e-01f, 9.28991362e-02f,
  -8.06428585e-03f, 1.37512371e-01f, -9.98139307e-02f, -1.33016944e-01f, -1.27420695e-02f, 2.51571611e-02f, -7.13699311e-02f, 7.36300498e-02f, 2.86709517e-01f, -1.20509475e-01f,
  -6.97981939e-02f, -1.23737760e-01f, 6.76788203e-03f, -7.70794600e-02f, 6.54025152e-02f, -1.39308989e-01f, 6.37738928e-02f, -1.17551880e-02f, 2.14534160e-02f, 5.67916818e-02f,
  1.08275637e-01f, -3.79779190e-02f, 3.28408293e-02f, -2.18573019e-01f, 8.31169412e-02f, 1.87793970e-02f, -2.01147590e-02f, 4.99880537e-02f, -6.96301907e-02f, 3.09080016e-02f,
  5.52699044e-02f, 1.34890780e-01f, -1.11508675e-01f, -4.14033234e-03f, -4.49303985e-02f, -1.14727393e-02f, -1.26780674e-01f, -1.17663972e-01f, 1.29087180e-01f, -9.07917158e-04f,
  4.66669649e-02f, -9.67247710e-02f, 1.80614725e-01f, 1.12269945e-01f, 7.70230517e-02f, -4.54367809e-02f, 5.27618732e-03f, -6.79031536e-02f, 6.96476847e-02f, 3.59014720e-02f,
  6.83145225e-02f, -3.61272469e-02f, -3.36988308e-02f, 5.18244728e-02f, 2.67721359e-02f, 1.26168534e-01f, -1.14757799e-01f, -1.26497382e-02f, 1.45341709e-01f, 5.50075583e-02f,
  1.19589485e-01f, -1.43326998e-01f, -1.59179363e-02f, -3.22359830e-01f, 2.91324425e-02f, -1.65134355e-01f, -5.40885665e-02f, -7.78291300e-02f, 8.03271756e-02f, 4.45091771e-03f,
  -1.82356074e-01f, -1.73874032e-02f, -2.77875811e-02f, -2.99837328e-02f, -3.37617807e-02f, -8.17475915e-02f, -6.51015434e-03f, -1.32040428e-02f, 2.32468415e-02f, -1.56676009e-01f,
  -1.24305256e-01f, 6.31098896e-02f, -7.53185973e-02f, -1.17700458e-01f, -1.25427529e-01f, -1.09622255e-01f, -7.32316636e-03f, -5.99381216e-02f, 3.07628997e-02f, 2.71626469e-02f,
  -4.97804470e-02f, 1.78971693e-01f, -1.77080557e-01f, -4.72223870e-02f, -2.84331918e-01f, -2.27327302e-01f, -2.19310358e-01f, -8.14842954e-02f, 1.23510152e-01f, 2.01994032e-01f,
  -2.10699990e-01f, 1.09453045e-01f, 1.95445329e-01f, -3.48138750e-01f, 6.02958631e-03f, 9.93652046e-02f, 3.28927301e-02f, -2.11098149e-01f, -3.39610167e-02f, 1.33620337e-01f,
  -7.70964613e-03f, -6.18293919e-02f, -2.95960784e-01f, -7.69448057e-02f, -2.05580562e-01f, -1.52009383e-01f, 2.37885505e-01f, -2.43934169e-01f, -1.85857803e-01f, -2.11518839e-01f,
  -6.33503497e-02f, 5.40275089e-02f, 9.19926632e-03f, 1.88733861e-02f, 4.77901697e-02f, -5.51591925e-02f, -1.54142693e-01f, 4.23722900e-02f, -1.57783940e-01f, 8.73266906e-02f,
  1.77023664e-01f, 1.17180079e-01f, 9.34596807e-02f, -1.39687518e-02f, 3.77773531e-02f, -7.93038383e-02f, -2.19681561e-02f, -1.14568911e-01f, 1.88947469e-02f, -1.08502328e-01f,
  -1.42357588e-01f, -9.20192376e-02f, 1.92206316e-02f, 4.51892577e-02f, 1.32941047e-03f, 2.13100053e-02f, 1.85275767e-02f, -3.27646243e-03f, 1.87035531e-01f, 4.62122746e-02f,
  -1.82013994e-03f, 8.56609270e-02f, -1.07164718e-01f, -7.89273679e-02f, -6.84514567e-02f, -2.29767691e-02f, 8.46720412e-02f, 1.96397435e-02f, 3.04849707e-02f, 3.06583513e-02f,
  -5.90915233e-02f, -6.63309917e-02f, -6.86557638e-03f, -3.31022143e-02f, 1.68521285e-01f, -2.20516906e-03f, -3.99611183e-02f, -3.98783125e-02f, 4.31587882e-02f, 1.34910613e-01f,
  -5.19330613e-02f, 9.38823912e-03f, 1.05413841e-02f, 2.89066285e-02f, -1.26080424e-01f, 4.55764821e-05f, 6.63097650e-02f, -1.31251488e-03f, -4.46662353e-03f, 7.50163645e-02f,
  4.64719534e-02f, 3.62864286e-01f, 2.98962574e-02f, -8.48546922e-02f, 9.38578472e-02f, 1.77093595e-02f, -9.16519538e-02f, 7.77092725e-02f, 2.21618973e-02f, 5.91662787e-02f,
  5.94615228e-02f, 1.23437710e-01f, 3.25592123e-02f, -1.51491608e-03f, 1.42259300e-01f, 9.47888419e-02f, 2.14122370e-01f, 1.27080888e-01f, 6.32196218e-02f, 2.38199923e-02f,
  -8.85829329e-03f, 2.02652335e-01f, 1.39854342e-01f, -1.79129634e-02f, 2.21541137e-01f, 6.15747869e-02f, 1.15447856e-01f, 7.81196356e-02f, 1.84690431e-01f, 8.70575085e-02f,
  -4.38328624e-01f, -4.12941635e-01f, 4.16163534e-01f, -4.37311947e-01f, 2.71242559e-01f, 5.12393355e-01f, 2.20194086e-01f, -8.35609660e-02f, -4.23413873e-01f, -2.86766112e-01f,
  -1.37203991e-01f, -2.29839712e-01f, 1.56786498e-02f, -3.19666117e-01f, 4.32482302e-01f, -1.55509263e-01f, -2.47931436e-01f, -1.04729697e-01f, -9.44291055e-02f, -6.61650524e-02f,
  9.93209146e-03f, -1.49049893e-01f, 3.19451630e-01f, -7.75743797e-02f, -1.81865804e-02f, -1.17558509e-01f, -7.66112655e-02f, 3.82703781e-01f, -4.23668958e-02f, 1.78439796e-01f,
  1.64774597e-01f, -3.97588342e-01f, 6.35799095e-02f, 6.93381280e-02f, 5.84941469e-02f, 1.20150588e-01f, 1.02410764e-01f, 1.20293036e-01f, 6.85740337e-02f, -2.10652072e-02f,
  -3.54616381e-02f, 1.41521528e-01f, -1.36953712e-01f, 8.86842161e-02f, 4.93562967e-02f, -7.69606158e-02f, 1.65899247e-01f, 5.95333762e-02f, 1.44952297e-01f, 1.44097745e-01f,
  1.45754099e-01f, 9.04412270e-02f, 3.28319483e-02f, -1.26435742e-01f, 6.29830062e-02f, 8.65851641e-02f, 3.01185362e-02f, 1.77936763e-01f, -4.19027843e-02f, -4.34531718e-02f,
  -2.45678574e-02f, 8.65998268e-02f, 6.52201697e-02f, -1.72969569e-02f, -6.87950104e-03f, -1.07920311e-01f, 6.36099698e-03f, 2.32981797e-02f, 8.44665058e-03f, -1.21366873e-01f,
  2.72887964e-02f, 5.45418262e-02f, -6.22109883e-02f, 9.38347280e-02f, 5.21387793e-02f, -1.88991800e-01f, 2.66129691e-02f, 1.47520900e-02f, -1.66238938e-02f, 2.10978109e-02f,
  -1.30611137e-01f, 3.50728109e-02f, -4.33072411e-02f, -7.28163794e-02f, 4.12819311e-02f, 1.38375670e-01f, 3.14862542e-02f, 1.23582177e-01f, -1.13604099e-01f, -1.77816525e-02f,
  -2.46072803e-02f, -3.15699875e-01f, -6.75023720e-02f, 8.94797444e-02f, 1.95278581e-02f, -2.58364491e-02f, -1.04540005e-01f, -1.01475278e-02f, 5.18711507e-02f, -7.68425763e-02f,
  6.01140633e-02f, -4.07902785e-02f, 1.99158373e-03f, 7.33919889e-02f, 1.13395676e-01f, -2.80148014e-02f, -6.16234727e-03f, 2.55835745e-02f, 1.13392167e-01f, 4.28699190e-04f,
  -3.96091305e-02f, 1.05675124e-02f, -9.53338146e-02f, -1.00577325e-01f, -8.82592574e-02f, 4.83024865e-03f, -1.96627975e-01f, 1.38613265e-02f, 4.09746245e-02f, 9.02521014e-02f,
  -2.48141989e-01f, -1.33364409e-01f, 4.33306962e-01f, -4.85881567e-02f, 3.63926321e-01f, 4.89536285e-01f, 5.53343296e-02f, 4.59876567e-01f, 4.15552378e-01f, -2.73599863e-01f,
  -1.09150102e-02f, -4.55108106e-01f, -1.89611971e-01f, 2.50376612e-02f, 3.70785952e-01f, 9.99109522e-02f, 8.84259418e-02f, -1.95320874e-01f, 1.00534759e-01f, -1.61295950e-01f,
  -3.25385248e-03f, -2.71267086e-01f, -1.37081118e-02f, -1.20175280e-01f, -2.59940187e-03f, -2.18669567e-02f, -2.83654600e-01f, -5.03619947e-02f, -1.89801037e-01f, 9.50067341e-02f,
  -2.18527004e-01f, -5.08402176e-02f, -1.39135003e-01f, 5.08431606e-02f, 1.89778730e-02f, -1.04402993e-02f, -7.67535120e-02f, -9.61766317e-02f, -4.66168439e-03f, 3.62112373e-02f,
  -2.23825336e-01f, 3.57492752e-02f, 5.36068864e-02f, -2.78720148e-02f, 7.47215142e-03f, 7.79912472e-02f, 1.09690897e-01f, 8.74272212e-02f, 2.32316460e-02f, 1.96524605e-01f,
  2.52258386e-02f, 1.26198187e-01f, 1.65899292e-01f, 8.69001448e-02f, 4.87641729e-02f, 1.52944863e-01f, -1.82331800e-02f, 3.06710824e-02f, 1.40361428e-01f, 5.84567077e-02f,
  1.04522727e-01f, -4.26846631e-02f, -8.22180212e-02f, -2.36542951e-02f, -2.17905678e-02f, 3.67580839e-02f, 4.72802445e-02f, -4.98973392e-02f, 3.82424779e-02f, -2.52379775e-02f,
  5.07886112e-02f, -3.56225446e-02f, 1.13883369e-01f, 1.26480639e-01f, -1.24693818e-01f, -4.84682173e-02f, -1.10518284e-01f, -1.24406153e-02f, 2.25476734e-02f, -1.15711147e-04f,
  -1.01995483e-01f, -2.53223203e-04f, -3.47295590e-02f, -3.79254296e-02f, -1.82905402e-02f, -3.40034775e-02f, 1.53858168e-02f, 2.02845752e-01f, 9.20907035e-03f, -5.34102321e-02f,
  -5.13946593e-01f, -3.14487785e-01f, -1.83579326e-01f, -1.09747529e-01f, -1.34165466e-01f, -1.29846022e-01f, -5.85039556e-02f, 1.58325016e-01f, -9.97322723e-02f, 3.42859216e-02f,
  -5.97367249e-02f, 1.91492438e-02f, -5.16204573e-02f, 3.89153287e-02f, -1.00851364e-01f, 1.54598594e-01f, -1.82624072e-01f, -9.77824852e-02f, -1.05830178e-01f, -1.15495669e-02f,
  -6.23781532e-02f, -6.83472082e-02f, 1.30902603e-02f, 5.47093153e-02f, 3.38496156e-02f, -6.05200604e-02f, -4.98549640e-02f, 5.65172732e-02f, 7.15613877e-03f, -6.63852543e-02f,
  5.25053620e-01f, 8.33426937e-02f, 3.01868934e-02f, 3.96283627e-01f, 1.72961593e-01f, -2.28998661e-01f, 1.04697518e-01f, 2.21804351e-01f, 1.16002761e-01f, 2.58076862e-02f,
  2.53052427e-03f, 6.13880111e-03f, -3.00294518e-01f, 1.35579109e-01f, -1.61820456e-01f, -5.45761406e-01f, 2.77354598e-01f, -1.24380819e-01f, -5.32995351e-02f, 3.94611299e-01f,
  1.27188012e-01f, 8.28017443e-02f, 1.76389754e-01f, 2.73527633e-02f, 4.66184974e-01f, 3.04512978e-01f, 1.91798046e-01f, -1.98166057e-01f, 1.03884935e-01f, -3.69217783e-01f,
  -1.07416101e-02f, 6.73654452e-02f, 1.41251639e-01f, -7.25540221e-02f, 1.30333349e-01f, 2.28452876e-01f, 1.15112669e-03f, -2.12981969e-01f, -5.98323271e-02f, -1.20411664e-01f,
  3.80537030e-03f, 6.11609370e-02f, -1.87363744e-01f, -1.83038637e-01f, 1.64491266e-01f, 2.29619071e-02f, 8.93285684e-03f, 3.62621732e-02f, 3.53020206e-02f, 1.46884546e-01f,
  8.16199183e-02f, 4.21076417e-02f, 5.28952144e-02f, -1.72567979e-01f, -1.35324495e-02f, 3.93928103e-02f, -3.73005867e-02f, 1.07718132e-01f, -1.48006469e-01f, 1.38867646e-01f,
  -2.05233134e-02f, 1.89111512e-02f, -1.61652490e-02f, -9.59203169e-02f, -5.83209470e-03f, 5.82742542e-02f, -2.44305432e-01f, -2.08594441e-01f, -1.05223387e-01f, 1.37882844e-01f,
  -7.53991082e-02f, 6.02442436e-02f, -1.28649861e-01f, -8.30444843e-02f, 1.03740901e-01f, 1.45215616e-01f, -8.37294683e-02f, -9.59438905e-02f, 1.20670378e-01f, -2.27885172e-02f,
  -1.24656975e-01f, -3.70998979e-02f, 1.90368257e-02f, -2.62921657e-02f, -1.20256014e-01f, 9.24268086e-03f, 4.95291390e-02f, 7.60950819e-02f, 2.53800359e-02f, -2.36968715e-02f,
  -2.08106712e-02f, 4.26065996e-02f, 2.04327088e-02f, -1.18692741e-01f, -1.13480479e-01f, 1.00872837e-01f, -7.99028948e-02f, -5.90850934e-02f, -8.39627236e-02f, -5.77529073e-02f,
  3.08956295e-01f, 5.41625060e-02f, -8.76599550e-02f, 8.11535418e-02f, -1.73542723e-01f, 3.18447798e-02f, -3.92885040e-03f, -2.12334525e-02f, 9.68910679e-02f, 9.88611206e-02f,
  1.08959019e-01f, 1.09894305e-01f, 8.46983865e-02f, 8.52643847e-02f, 5.42028844e-02f, -6.98456317e-02f, -8.05005059e-02f, 9.88231152e-02f, 2.90166074e-03f, -8.29735100e-02f,
  1.88441560e-01f, -3.45667630e-01f, -2.30050847e-01f, 1.11495040e-01f, 2.42913201e-01f, -4.32830691e-01f, -1.29568623e-02f, -2.09295619e-02f, 4.06773657e-01f, -1.42012045e-01f,
  -4.77977395e-02f, -9.41921547e-02f, 1.57760188e-01f, -3.40339482e-01f, 6.68829605e-02f, 2.44293332e-01f, -3.50374073e-01f, -2.56760120e-01f, 2.26554528e-01f, -2.92950064e-01f,
  1.12848029e-01f, -2.04023972e-01f, -4.74783359e-03f, -2.67725378e-01f, -1.29204318e-01f, -4.94775996e-02f, -9.24183801e-02f, 1.04905739e-01f, -3.84725004e-01f, 2.47159544e-02f,
  -1.67680830e-02f, 2.79360026e-01f, -4.35720868e-02f, -2.51638470e-03f, -4.25729044e-02f, -8.60032812e-02f, -2.67334878e-01f, 4.45587113e-02f, 1.74736798e-01f, 8.51301849e-02f,
  -4.64545302e-02f, 9.52697825e-03f, -1.19696846e-02f, 1.15986288e-01f, 3.74728739e-02f, -3.14220414e-02f, 8.83907005e-02f, -1.30170539e-01f, 1.82285644e-02f, -1.17801495e-01f,
  7.45500177e-02f, -7.89233521e-02f, -5.56710884e-02f, -4.71469387e-02f, 5.67611530e-02f, 9.58429128e-02f, -1.79489374e-01f, -1.63361520e-01f, -1.10723898e-01f, 1.88065879e-02f,
  -7.49995857e-02f, -1.81874130e-02f, 8.69524293e-03f, 5.91059290e-02f, 1.58547908e-02f, 5.57716489e-02f, 3.20396852e-03f, -1.08850352e-01f, 5.80131717e-04f, 4.04166542e-02f,
  6.51300251e-02f, 1.06450550e-01f, 1.02728531e-01f, 9.73983258e-02f, 4.07814421e-02f, 8.91849697e-02f, -2.21169796e-02f, 4.41798121e-02f, 1.81287620e-02f, 3.94893624e-02f,
  1.29795909e-01f, 5.38622402e-02f, 1.03294626e-01f, 6.68184459e-02f, -4.10978450e-03f, 1.98800430e-01f, -2.07995344e-02f, -3.80563959e-02f, 7.27897361e-02f, -7.48271942e-02f,
  -1.21317528e-01f, -1.29396409e-01f, 1.29189566e-01f, 3.45099159e-02f, -1.08898357e-01f, -8.71965364e-02f, -1.08416840e-01f, -1.33654952e-01f, 1.56542007e-02f, 5.17982841e-02f,
  -1.80661544e-01f, 6.38883561e-02f, -1.94176793e-01f, -1.93198118e-02f, -9.61369872e-02f, -6.36897236e-02f, -2.79606637e-02f, -1.43944487e-01f, -1.68629717e-02f, -1.12676248e-01f,
  -1.05512887e-01f, 1.11654382e-02f, 6.17031343e-02f, 1.74817115e-01f, -8.64962488e-02f, -5.86749539e-02f, -9.99645516e-02f, 4.76586446e-02f, -3.51383560e-03f, -2.85572540e-02f,
  2.74672687e-01f, 2.81385601e-01f, -2.71610409e-01f, 3.93059045e-01f, -1.47588760e-01f, 3.84593934e-01f, 3.97960514e-01f, -8.36360175e-03f, 4.02514815e-01f, 2.44258642e-01f,
  5.38502097e-01f, -1.13519542e-01f, 1.27189741e-01f, 6.83413506e-01f, -2.10405402e-02f, 4.04445559e-01f, 3.38320762e-01f, 3.78302246e-01f, -6.68079630e-02f, 2.88956463e-01f,
  8.92584324e-02f, 3.90581638e-01f, -1.11877784e-01f, -2.79144347e-01f, 1.98061958e-01f, -3.57152671e-01f, -3.16449285e-01f, -2.61263490e-01f, 8.76158476e-02f, -1.84803560e-01f,
  3.90149793e-03f, 2.87569940e-01f, -1.66569036e-02f, -1.73881371e-02f, -3.88412662e-02f, -7.55841732e-02f, -1.20715700e-01f, -2.11042359e-01f, -2.14722961e-01f, -2.14023292e-02f,
  1.32478056e-02f, -9.18119177e-02f, 9.41634271e-03f, -6.84596449e-02f, -2.11493894e-02f, -1.75448507e-01f, 1.08378366e-01f, 7.57314637e-02f, -4.97509986e-02f, 3.15338969e-02f,
  2.91692116e-03f, 6.11039484e-03f, 5.41399792e-02f, -7.06080869e-02f, -9.06515587e-03f, 8.19690824e-02f, -4.86123152e-02f, -4.61283177e-02f, -1.37812579e-02f, 6.35466129e-02f,
  4.28501256e-02f, 5.20330369e-02f, 9.19645503e-02f, 1.00516371e-01f, 3.32445763e-02f, -7.25630438e-04f, 1.01528794e-01f, -1.03192829e-01f, -8.84029269e-02f, 1.82802808e-02f,
  -9.74282175e-02f, -6.77354038e-02f, 1.03665039e-01f, 3.50654051e-02f, 1.28051937e-01f, 5.43717965e-02f, -4.77358513e-02f, 6.69804215e-02f, 2.13644765e-02f, 1.37750925e-02f,
  -7.69829750e-02f, 4.99022529e-02f, 9.27244723e-02f, -2.10682884e-01f, -9.33305994e-02f, -1.24404980e-02f, 1.44590333e-01f, 1.72233075e-01f, 1.00422343e-02f, -1.12123914e-01f,
  1.52678981e-01f, 1.66844681e-01f, 1.10384829e-01f, -4.10626456e-02f, -1.64575234e-01f, 1.62664741e-01f, 1.14200011e-01f, 1.47213973e-02f, -1.09750032e-01f, 4.85888645e-02f,
  3.14588100e-02f, 7.04126507e-02f, -8.45994949e-02f, 3.25285979e-02f, -1.36061208e-02f, 4.29878198e-02f, 7.85710588e-02f, -5.53283021e-02f, -1.39399573e-01f, -7.68973604e-02f,
  -5.49978539e-02f, 1.07541300e-01f, -8.77019018e-02f, -3.77432518e-02f, -3.25122960e-02f, 4.49013188e-02f, 1.58978440e-02f, 7.04656243e-02f, -4.42424603e-02f, 6.34257570e-02f,
  2.51126856e-01f, 3.50092560e-01f, -1.94848359e-01f, -2.42663115e-01f, -2.75912285e-01f, 5.45030892e-01f, 1.52238403e-02f, -2.88249329e-02f, -1.16496451e-01f, 1.28047317e-01f,
  -1.52859986e-01f, -1.94586724e-01f, 1.34544134e-01f, -1.38714314e-02f, 3.95968169e-01f, 3.70513499e-01f, 7.76554346e-02f, -1.74969524e-01f, -2.76131369e-02f, -1.41975120e-01f,
  -1.42229751e-01f, -6.40206486e-02f, -2.68934548e-01f, 5.02247587e-02f, -2.23523319e-01f, -8.71531144e-02f, -3.43393624e-01f, -2.04349443e-01f, -1.64749101e-01f, -1.20579645e-01f,
  1.36962265e-01f, 6.30879626e-02f, 2.66501028e-02f, 8.34115446e-02f, 2.82870568e-02f, -2.73486320e-02f, -1.88613743e-01f, -6.15708902e-02f, -1.03839681e-01f, 1.30755911e-02f,
  6.05132356e-02f, 1.10339098e-01f, 2.57392973e-02f, -4.43536928e-03f, -1.15736730e-01f, 4.14305367e-03f, 5.31670451e-02f, 1.32997213e-02f, -6.68148370e-03f, 7.95576721e-02f,
  -6.27954677e-02f, 7.04807863e-02f, -2.14066640e-01f, 2.95663942e-02f, -1.93134621e-01f, -1.15173563e-01f, 1.36756852e-01f, -5.41136675e-02f, -1.24664024e-01f, 1.26352593e-01f,
  2.35097203e-03f, 1.80628076e-02f, 9.93678272e-02f, -2.43345499e-02f, 1.94642290e-01f, 4.56257313e-02f, 4.26904252e-03f, -9.38134491e-02f, 4.66001891e-02f, 9.74671990e-02f,
  -6.12759367e-02f, -1.31556332e-01f, -1.71164162e-02f, -2.67235506e-02f, 1.90728586e-02f, 9.21305940e-02f, 2.97542196e-03f, -1.30099192e-01f, -7.58914128e-02f, -9.02341492e-03f,
  -1.80268556e-01f, -4.63580154e-02f, -1.34483919e-01f, -1.44778118e-01f, 1.26360327e-01f, -9.40137208e-02f, -9.89890024e-02f, -8.41045380e-02f, -8.16160589e-02f, -7.49943629e-02f,
  1.04305103e-01f, 8.64471793e-02f, 3.35712954e-02f, 3.00670471e-02f, -2.28601284e-02f, 1.46141559e-01f, 7.13161007e-02f, 9.82604455e-03f, -5.19411974e-02f, 1.07821219e-01f,
  3.11333518e-02f, -1.07467286e-01f, -1.31500755e-02f, -3.41813713e-02f, -7.98937455e-02f, 1.24580324e-01f, -9.24395323e-02f, -1.48204327e-01f, -7.26874322e-02f, -2.22017895e-02f,
  -5.53859137e-02f, -4.96576168e-02f, 8.57784450e-02f, -3.33471745e-02f, -1.40819907e-01f, -1.81583371e-02f, 1.52468190e-01f, -4.52137701e-02f, -9.40388292e-02f, -1.33391678e-01f,
  -4.13236499e-01f, 4.62477118e-01f, 4.82210726e-01f, 8.68742913e-02f, -3.78749222e-01f, 3.52693647e-01f, 5.33927798e-01f, -2.51302630e-01f, 1.46173969e-01f, 1.54886216e-01f,
  -2.57198215e-01f, 3.07665646e-01f, 1.71196461e-01f, -2.05919072e-02f, -1.62327066e-01f, 3.42049509e-01f, 2.67957360e-01f, 2.99389899e-01f, 1.14439510e-01f, -3.15858349e-02f,
  -4.67347503e-02f, -3.38152438e-01f, 7.65601844e-02f, -1.93767652e-01f, -7.27494853e-03f, 1.43927217e-01f, -3.64824176e-01f, 1.24391921e-01f, -9.47931334e-02f, 1.18970253e-01f,
  7.85321817e-02f, -7.13461218e-03f, 1.43586352e-01f, 1.80642724e-01f, -3.77192646e-02f, 9.09163579e-02f, 5.74649237e-02f, 1.66082174e-01f, 7.16136545e-02f, 4.98495549e-02f,
  -1.18338224e-02f, -1.08347416e-01f, -3.17728966e-02f, 3.41168512e-03f, -8.55573118e-02f, -2.77892873e-02f, -4.15664501e-02f, 1.39986603e-02f, 9.26701501e-02f, -7.15490570e-03f,
  2.64900345e-02f, 5.76298945e-02f, 3.24680321e-02f, 6.05101027e-02f, -9.63541958e-03f, 1.79498389e-01f, 3.86628695e-02f, 2.58606207e-02f, 1.28489941e-01f, 1.00084551e-01f,
  -1.59200773e-01f, 5.57614826e-02f, -9.88279134e-02f, 5.48366345e-02f, -1.35494351e-01f, 7.38534182e-02f, -9.15227011e-02f, -2.33016640e-01f, 8.44681934e-02f, -7.16321543e-02f,
  -2.85416637e-02f, 1.15958182e-02f, 8.61077756e-02f, 9.06024594e-03f, -1.38078317e-01f, -7.02688769e-02f, 9.37108174e-02f, 8.45624506e-02f, -1.58432033e-02f, 3.25931720e-02f,
  -2.21186634e-02f, 1.70800880e-01f, -1.30690495e-02f, -7.98133295e-03f, 1.24885730e-01f, -5.63267991e-02f, -2.50166096e-02f, -3.63947637e-02f, 1.04059935e-01f, 9.21351016e-02f,
  2.47501597e-01f, 2.02408940e-01f, 1.40385941e-01f, 1.56462535e-01f, 1.59605637e-01f, -7.08980411e-02f, 2.52876407e-03f, -7.24733621e-02f, -1.71169899e-02f, -5.62786199e-02f,
  -1.96471944e-01f, 1.40240654e-01f, -6.74927011e-02f, -2.00995430e-02f, 6.92218356e-03f, 4.76201177e-02f, 8.57430249e-02f, -6.09719083e-02f, 1.49655687e-02f, -8.96991342e-02f,
  1.31071731e-02f, 7.10412487e-02f, -4.32485249e-03f, -3.36370468e-02f, 3.14020342e-03f, 3.78454588e-02f, -6.62530139e-02f, 8.30059648e-02f, -2.80730356e-03f, 1.51155919e-01f,
  2.10656792e-01f, -1.68777868e-01f, -4.21091139e-01f, -1.17440321e-01f, -1.31718814e-01f, -4.48415697e-01f, -1.69431299e-01f, -1.01790875e-01f, 2.18034551e-01f, 6.12827130e-02f,
  7.89157487e-03f, -1.19631499e-01f, 3.14633906e-01f, -2.35087797e-01f, -1.69793889e-01f, 2.32252091e-01f, -5.64096987e-01f, -2.65397877e-01f, 9.60367694e-02f, -4.30305004e-02f,
  -8.95490795e-02f, 2.26744786e-02f, -3.16447616e-01f, -5.15901856e-02f, -1.34732306e-01f, 2.68922816e-03f, 3.51317525e-02f, -3.29500623e-02f, -4.09347355e-01f, -4.54843268e-02f,
  -1.87948287e-01f, 1.79633915e-01f, -1.49026141e-01f, 4.17551473e-02f, -8.53424240e-03f, 6.81454316e-02f, -7.37994686e-02f, -1.10167652e-01f, -1.61654148e-02f, -1.36844683e-02f,
  5.30977361e-02f, 2.58955985e-01f, 7.90903941e-02f, 4.74812575e-02f, 1.24935642e-01f, -5.49742579e-02f, -1.98534708e-02f, -2.09491074e-01f, -3.36814336e-02f, 2.13327408e-02f,
  3.12654376e-02f, -1.62919909e-02f, 3.41209285e-02f, -2.77858712e-02f, -8.11499730e-02f, -1.49853434e-02f, -8.66774991e-02f, -2.00658917e-01f, -4.28007096e-02f, -5.02318814e-02f,
  -3.68862934e-02f, 5.84789701e-02f, 1.10363305e-01f, 3.47948261e-02f, 5.87711371e-02f, -6.73556924e-02f, -2.33140029e-02f, 2.89385729e-02f, 1.45048559e-01f, -4.06897850e-02f,
  -6.86970493e-03f, -4.73360680e-02f, 3.50258909e-02f, -3.33851799e-02f, -1.22298680e-01f, 1.28658816e-01f, -3.55731547e-02f, -2.85010915e-02f, -9.00403485e-02f, -1.66894600e-01f,
  5.43558039e-02f, -1.69441495e-02f, 9.25607979e-02f, -8.32566917e-02f, -1.77419886e-01f, 9.04913545e-02f, 2.09007296e-03f, -5.94344437e-02f, 5.48879504e-02f, 6.46711811e-02f,
  -1.06576771e-01f, -1.33962631e-01f, 4.63033691e-02f, 9.80755463e-02f, -2.37603765e-02f, 3.50476578e-02f, -1.00013375e-01f, -1.01164587e-01f, -6.91081062e-02f, 2.67620403e-02f,
  -8.14144984e-02f, 9.60317478e-02f, -1.28514603e-01f, 8.28968734e-02f, -7.37227574e-02f, -7.81356543e-02f, -1.11654535e-01f, 9.31693912e-02f, -1.75676420e-01f, -3.78056392e-02f,
  6.25678822e-02f, 2.11475804e-01f, 1.02712616e-01f, 9.40626040e-02f, 3.41529176e-02f, -9.22103971e-02f, -6.20757565e-02f, -6.00856729e-02f, 3.00506447e-02f, -6.93868026e-02f,
  1.33956715e-01f, 2.07134858e-01f, -2.13614002e-01f, -3.52867723e-01f, -1.78396896e-01f, -3.59387062e-02f, -3.30243766e-01f, -2.05156744e-01f, -3.53197843e-01f, -1.16819024e-01f,
  -2.91936249e-01f, -1.64309651e-01f, 1.44280165e-01f, -1.04808174e-01f, 3.61912936e-01f, 3.12146693e-01f, 1.12905353e-01f, -3.86792719e-02f, 2.33467653e-01f, -3.47033478e-02f,
  9.75880772e-02f, 1.55620519e-02f, 2.15111583e-01f, 2.30140358e-01f, -2.09058553e-01f, -5.48619814e-02f, 9.21501070e-02f, -2.07157969e-01f, -6.57373248e-03f, -5.81103452e-02f,
  1.45334110e-01f, -8.37236494e-02f, -9.83165503e-02f, -7.93517902e-02f, 1.18832186e-01f, -3.99262123e-02f, -8.60125944e-02f, -7.06409812e-02f, -2.07737982e-01f, -1.42025188e-01f,
  -8.52379799e-02f, 9.33099166e-02f, -4.40083928e-02f, 4.73442152e-02f, -2.19049752e-01f, -6.83270842e-02f, 1.72796592e-01f, -5.33783995e-02f, -4.13019881e-02f, 1.73899636e-01f,
  -5.37942424e-02f, 1.20182205e-02f, -4.03030738e-02f, 1.82199568e-01f, -7.07286894e-02f, -8.30235705e-02f, 1.15202665e-01f, -1.11384571e-01f, -6.58914680e-03f, 3.27038988e-02f,
  4.22773734e-02f, 1.14912026e-01f, 1.00850932e-01f, -1.17240690e-01f, -2.43621785e-02f, 7.13899881e-02f, -1.24877514e-02f, 5.52869774e-02f, -6.26560822e-02f, 1.26863763e-01f,
  -4.72531691e-02f, -4.26058844e-02f, -1.93212423e-02f, 1.51136611e-03f, 2.03930333e-01f, 1.61209807e-01f, -5.83717450e-02f, -6.44568577e-02f, -9.68394428e-02f, 1.79911461e-02f,
  -9.40860361e-02f, -5.54810129e-02f, -7.18564764e-02f, -5.66340648e-02f, 1.01122320e-01f, 5.52196987e-03f, -6.77082315e-02f, 1.23512978e-02f, 9.80823115e-02f, 4.60329317e-02f,
  1.74255639e-01f, 2.17982545e-01f, 7.58234933e-02f, -7.45151713e-02f, 1.65023595e-01f, 7.40660578e-02f, 2.35060211e-02f, -5.36382385e-02f, 4.17077318e-02f, -5.10530099e-02f,
  -6.04658481e-03f, -7.43197352e-02f, 6.97405264e-02f, -7.90955722e-02f, -1.25613110e-02f, 7.44519159e-02f, -1.09606124e-01f, -1.95572595e-03f, -4.82741594e-02f, 9.78193954e-02f,
  -5.28088212e-02f, -5.63874431e-02f, -5.35313301e-02f, -8.00296888e-02f, -1.55349314e-01f, -1.45302996e-01f, 8.83152708e-02f, 8.28763545e-02f, 4.81428020e-02f, -3.34675536e-02f,
  -2.23556787e-01f, -4.43200529e-01f, -1.72692865e-01f, 1.55941367e-01f, 1.72627077e-01f, -1.99161008e-01f, -2.99489290e-01f, -2.46852666e-01f, -3.68742615e-01f, -2.07515225e-01f,
  4.55599427e-02f, 9.50508863e-02f, -4.55553412e-01f, 4.78592545e-01f, 6.07447326e-01f, -2.25675061e-01f, 2.29475781e-01f, 1.31164208e-01f, -5.74430637e-02f, -1.71720967e-01f,
  3.90091054e-02f, 1.93410903e-01f, 1.71117276e-01f, 1.43694296e-01f, 1.50552988e-01f, 1.73321098e-01f, 3.55010927e-01f, 7.14506879e-02f, 5.60928404e-01f, 4.64896142e-01f,
  -7.44931549e-02f, 5.05576506e-02f, -1.41395777e-01f, 1.17164999e-01f, -1.04180627e-01f, -2.25294679e-02f, -3.25290225e-02f, 2.38735378e-01f, 1.93019241e-01f, -1.22442897e-02f,
  -6.18999936e-02f, 2.79933363e-01f, 1.67807311e-01f, 7.70783052e-02f, -7.32224435e-02f, -4.31766957e-02f, -7.69016370e-02f, -1.28032073e-01f, -1.38488993e-01f, -1.77731708e-01f,
  -1.53106451e-01f, -1.11972570e-01f, 2.32596807e-02f, 7.60348514e-02f, -1.82271730e-02f, -8.26977938e-02f, -1.38936654e-01f, -6.66435584e-02f, 9.20469165e-02f, 5.38329892e-02f,
  2.89677959e-02f, -8.14855248e-02f, -1.36064351e-01f, -8.53342656e-03f, -8.44459683e-02f, 3.24951746e-02f, -5.66843599e-02f, 4.58543077e-02f, 1.02840371e-01f, -2.68160757e-02f,
  -6.74730400e-03f, -1.02610122e-02f, -3.15977708e-02f, -2.02152366e-03f, -9.18135494e-02f, -1.27009049e-01f, -5.35562709e-02f, 1.18932441e-01f, -1.29900903e-01f, 4.92590740e-02f,
  4.74268049e-02f, 1.43269584e-01f, -9.99351367e-02f, -5.59039004e-02f, -1.06266454e-01f, 5.74568361e-02f, 1.05886564e-01f, 5.14156856e-02f, -9.58869085e-02f, 2.22369749e-02f,
  1.51962936e-01f, 1.36761859e-01f, 3.82046513e-02f, 7.83029124e-02f, 2.94417106e-02f, -1.39051108e-02f, 1.42956227e-01f, 5.35252690e-02f, 6.64098710e-02f, -1.10595919e-01f,
  7.70113096e-02f, 3.83133739e-02f, -5.48187867e-02f, 2.33499762e-02f, 1.62400976e-01f, -4.47982065e-02f, -4.68916027e-03f, 2.78548207e-02f, 3.76291014e-02f, 3.29807289e-02f,
  6.87855110e-02f, -1.20847993e-01f, 6.03960268e-02f, -5.28765842e-02f, 1.31437972e-01f, -7.78689086e-02f, -1.06973127e-02f, -9.32408571e-02f, 7.14197233e-02f, 6.97185695e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  3.92823905e-01f, 5.14394820e-01f, 2.67685711e-01f, 4.80102986e-01f, 3.46620709e-01f, 5.09684026e-01f, 2.82899231e-01f, 5.05710483e-01f, 4.69274253e-01f, 3.73404056e-01f,
  3.07670534e-01f, 3.99442345e-01f, 3.79248023e-01f, 3.36126357e-01f, 3.63351762e-01f, 2.38959104e-01f, 2.21962035e-01f, 3.16053480e-01f, 3.95698577e-01f, 4.00910407e-01f,
  3.89823109e-01f, 2.93529689e-01f, 4.21562195e-01f, 5.41835129e-01f, 2.75164783e-01f, 2.70186067e-01f, 4.99543577e-01f, 3.32265526e-01f, 3.21354657e-01f, 2.79433489e-01f,
  4.60505038e-01f, 4.05259818e-01f, 4.04737920e-01f, 3.41292322e-01f, 3.20540398e-01f, 4.30771112e-01f, 3.00670266e-01f, 2.91885287e-01f, 5.02515554e-01f, 2.93400109e-01f,
  4.49428380e-01f, 3.26945812e-01f, 4.52735305e-01f, 3.14332455e-01f, 5.41801155e-01f, 3.96655053e-01f, 4.00500685e-01f, 2.24391758e-01f, 4.25559580e-01f, 3.54869336e-01f,
  2.78549761e-01f, 1.88923612e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -1.59500122e-01f, -1.76632684e-02f, 1.06365070e-01f, 2.57175174e-02f, -4.57278758e-01f, 3.78091261e-02f, -1.58431157e-02f, 4.13217209e-02f, 8.89526531e-02f, -1.63253158e-01f,
  1.06845215e-01f, -1.94254726e-01f, 8.30933526e-02f, 2.47451607e-02f, 3.22631635e-02f, 6.25847429e-02f, -4.15395439e-01f, 1.11540921e-01f, -1.08761258e-01f, 7.57813454e-02f,
  -8.20549205e-02f, -4.40344587e-02f, -1.49957448e-01f, -7.62837939e-03f, -1.96718588e-01f, 6.37353286e-02f, -2.97941491e-02f, -3.34482864e-02f, -2.26093143e-01f, -3.89024876e-02f,
  -1.11183606e-01f, -2.34591961e-02f, -4.06233557e-02f, -6.86652958e-02f, 8.90949517e-02f, -1.37985200e-01f, -8.62567127e-02f, -1.63547485e-03f, 2.25777432e-01f, 3.69638264e-01f,
  1.24909647e-01f, -1.84494480e-01f, -1.85638249e-01f, 1.96047902e-01f, -3.64328884e-02f, -1.27411261e-01f, -4.68337759e-02f, -4.22480613e-01f, -6.15705699e-02f, 2.19283357e-01f,
  -4.04357957e-03f, -2.76100278e-01f, 3.54370117e-01f, 1.16959333e-01f, -2.80847341e-01f, 9.70727503e-02f, 3.28211516e-01f, -1.55202687e-01f, -7.34346062e-02f, -7.76312426e-02f,
  -7.90784210e-02f, -2.26140797e-01f, -2.79123187e-01f, -1.31546885e-01f, 5.94980828e-02f, 2.31858656e-01f, -1.38763309e-01f, 1.46349281e-01f, 3.05347323e-01f, -3.50310266e-01f,
  1.69539079e-01f, 3.61012787e-01f, -1.06020585e-01f, -2.11128220e-01f, -1.13148049e-01f, 2.86727957e-02f, -2.44607970e-01f, -4.27028269e-01f, 5.06465495e-01f, -1.58989221e-01f,
  2.02537887e-02f, 4.78211790e-02f, -2.15729326e-01f, 1.82494596e-01f, -2.86131024e-01f, -1.78889900e-01f, -2.63489276e-01f, 4.55772310e-01f, 3.70639324e-01f, 2.39878550e-01f,
  3.00426424e-01f, -4.58721757e-01f, 3.60260881e-03f, 4.74702239e-01f, -5.89019656e-01f, -2.47387037e-01f, -3.00612837e-01f, -4.30109575e-02f, -3.32988620e-01f, 8.62715170e-02f,
  -2.91259706e-01f, -1.22675233e-01f, -2.38380238e-01f, -8.00345615e-02f, -1.63148001e-01f, 4.50771581e-03f, 2.21973117e-02f, -1.70957237e-01f, -3.23967695e-01f, -3.14187527e-01f,
  3.49200010e-01f, -4.80908751e-01f, -3.40691298e-01f, 4.17620927e-01f, 2.10628718e-01f, -2.85802782e-01f, -5.06843865e-01f, -1.02149636e-01f, -3.63645941e-01f, -2.01346725e-01f,
  -2.07431152e-01f, -2.05559939e-01f, 1.97911486e-01f, -7.87136517e-03f, 2.69772351e-01f, -2.60200709e-01f, 3.19595747e-02f, -2.09726185e-01f, 2.20080093e-01f, 1.20123826e-01f,
  8.98139551e-02f, -9.07165259e-02f, -7.66456798e-02f, 1.42918350e-02f, 1.71761721e-01f, -4.21294346e-02f, -1.70784846e-01f, 7.65019357e-02f, -2.63814013e-02f, -1.35892093e-01f,
  -1.71121553e-01f, -1.36181623e-01f, -1.10491872e-01f, -2.13038340e-01f, 1.77880570e-01f, 9.54054520e-02f, -1.46257610e-03f, 1.90062851e-01f, 7.67184272e-02f, 7.32487859e-03f,
  1.80991426e-01f, 3.18626016e-02f, 1.03214473e-01f, -2.36455664e-01f, -4.47327234e-02f, -1.50891826e-01f, -2.69414991e-01f, -7.02808648e-02f, -3.55383754e-02f, 6.64706677e-02f,
  3.79419364e-02f, 3.27375345e-02f, -1.28848389e-01f, 2.59043742e-02f, 8.12946483e-02f, -1.03522301e-01f, 3.96068692e-01f, 3.07473034e-01f, 1.50120184e-01f, 2.57557958e-01f,
  -2.80983478e-01f, -3.59267354e-01f, -4.03397322e-01f, -9.64488164e-02f, 4.00937796e-01f, 3.57207865e-01f, -2.54611045e-01f, 3.21715802e-01f, -3.20095181e-01f, -1.67758450e-01f,
  -2.20378861e-01f, -1.34187028e-01f, 5.01229800e-02f, 7.97809660e-02f, 2.96404868e-01f, 3.50793839e-01f, -4.50214595e-01f, -1.70464978e-01f, -3.46645981e-01f, -1.86725318e-01f,
  1.07664958e-01f, 1.96721777e-01f, 1.54777005e-01f, -4.52495366e-01f, -5.79672195e-02f, 2.34002233e-01f, -2.39134625e-01f, 3.67965043e-01f, 1.00555815e-01f, -4.45905685e-01f,
  -1.83078587e-01f, -7.38494024e-02f, 1.52720481e-01f, -2.85822242e-01f, -3.37824374e-01f, -4.62739497e-01f, 2.05512360e-01f, -1.25437424e-01f, -9.02652442e-02f, 3.13291252e-01f,
  -4.23596799e-01f, 2.69667000e-01f, -3.33845288e-01f, 3.12133133e-01f, -4.45418984e-01f, -5.34710363e-02f, 2.85378128e-01f, -6.06303394e-01f, -7.00200558e-01f, 5.35027325e-01f,
  -5.02671301e-01f, 1.92614138e-01f, -3.72529387e-01f, 2.88535625e-01f, -4.31840092e-01f, 3.82837206e-02f, 1.05488789e-03f, -9.98027697e-02f, 4.46634680e-01f, -3.73396069e-01f,
  -2.75070518e-01f, 4.55480546e-01f, -1.74714580e-01f, -4.70343411e-01f, 7.46009573e-02f, -3.38238440e-02f, -3.54749262e-02f, -1.67397350e-01f, -8.54133740e-02f, 3.19754407e-02f,
  4.07601148e-02f, -2.68005461e-01f, -1.87262654e-01f, -4.72857714e-01f, -4.66900408e-01f, -5.05495146e-02f, -3.99166882e-01f, -8.49391744e-02f, 2.20241576e-01f, -1.13529503e-01f,
  2.80577451e-01f, 2.08743274e-01f, -3.61996591e-01f, 7.91448355e-02f, 2.19830647e-01f, -5.29434457e-02f, 7.38532236e-03f, -2.56565828e-02f, 6.18042499e-02f, -7.74566308e-02f,
  -3.69476154e-02f, 5.72061650e-02f, -1.02032222e-01f, 1.07733645e-01f, -3.30421031e-02f, -6.80731088e-02f, -9.51736495e-02f, 1.15384057e-01f, 8.82842615e-02f, -1.01617634e-01f,
  -2.33351886e-02f, -1.61272347e-01f, -6.98867515e-02f, -8.14383477e-02f, -2.02609941e-01f, -1.94201902e-01f, 1.16188508e-02f, -4.63153496e-02f, -1.29299030e-01f, -1.51219845e-01f,
  -7.42606670e-02f, 5.22052385e-02f, -1.31392300e-01f, -1.74349137e-02f, 3.87789719e-02f, -1.51312485e-01f, 5.85843213e-02f, -2.02602953e-01f, -2.43574336e-01f, -1.48456573e-01f,
  -1.39233947e-01f, -1.09063171e-01f, 9.99279544e-02f, 7.32492507e-02f, -3.39195311e-01f, -1.42903745e-01f, 2.23711908e-01f, 2.01100633e-01f, 1.01639986e-01f, 2.25016043e-01f,
  3.36685419e-01f, 1.14891700e-01f, 1.85515091e-01f, -3.07965666e-01f, -1.59695372e-01f, -2.03754097e-01f, -7.57272243e-02f, -2.03484088e-01f, 1.40388638e-01f, -6.73744902e-02f,
  1.75765216e-01f, -2.43841484e-01f, 1.21190526e-01f, 6.20686263e-02f, -4.69415896e-02f, 2.84576327e-01f, 2.81671226e-01f, -2.34519497e-01f, -1.24796815e-01f, -1.45330757e-01f,
  -1.96999729e-01f, 1.58959487e-03f, -1.95208699e-01f, 1.98794693e-01f, -1.47940397e-01f, 1.73658699e-01f, 1.97793886e-01f, -1.34735182e-01f, -1.26724720e-01f, 1.61931962e-01f,
  -1.79864690e-01f, 3.50825429e-01f, -1.40420601e-01f, -2.01787174e-01f, 3.38897437e-01f, -2.55658716e-01f, -2.71044020e-03f, 2.02961847e-01f, -2.72361845e-01f, -3.36101949e-01f,
  -8.55365917e-02f, -1.16718322e-01f, 1.69682592e-01f, 2.35848919e-01f, -3.62410635e-01f, -6.33852705e-02f, -2.11744934e-01f, 5.05658031e-01f, -1.86528400e-01f, -4.30518866e-01f,
  -2.94148684e-01f, 1.25041585e-02f, 4.85244691e-02f, -1.26460284e-01f, -2.99207419e-01f, 9.42407176e-02f, 3.85169089e-01f, 4.07522827e-01f, -2.33648792e-01f, 1.91709269e-02f,
  1.54514953e-01f, -1.98573664e-01f, -1.23923101e-01f, -1.17070757e-01f, 2.60279894e-01f, 1.15324438e-01f, -3.49718601e-01f, -2.21387539e-02f, -3.46135736e-01f, -2.27650702e-01f,
  -2.26583496e-01f, 3.41442406e-01f, -4.48792160e-01f, -2.57223874e-01f, 1.34784997e-01f, -1.25962291e-02f, -9.65371206e-02f, -3.93900841e-01f, -4.03415561e-01f, -1.91342458e-01f,
  -2.79662549e-01f, -3.18301648e-01f, -1.68162003e-01f, 5.24339497e-01f, 1.27115427e-03f, 1.01522923e-01f, -1.26788393e-01f, -1.82529211e-01f, 9.96459946e-02f, -4.79362421e-02f,
  -7.86622241e-02f, -9.81745869e-02f, -1.52934432e-01f, -1.77897960e-01f, -4.09039766e-01f, 4.54073437e-02f, 6.26266673e-02f, -1.18749835e-01f, 4.23475020e-02f, -2.75766253e-01f,
  8.64127353e-02f, 7.36190379e-02f, -1.10653304e-01f, -1.75953999e-01f, -1.86269563e-02f, 1.01275504e-01f, 6.02697246e-02f, -2.65122741e-01f, -1.10617146e-01f, 1.31620944e-01f,
  -1.68377921e-01f, 2.21946046e-01f, -6.93163797e-02f, -1.31535932e-01f, 6.56627119e-02f, 3.29273157e-02f, -1.69056922e-01f, 2.38432270e-02f, -2.00623661e-01f, -1.67631311e-03f,
  -2.21075267e-01f, 9.52510163e-03f, 1.20374382e-01f, -4.17750552e-02f, 2.70469308e-01f, -3.33049119e-01f, -1.02056488e-01f, -2.59560585e-01f, -7.62280375e-02f, -4.75936085e-01f,
  -1.16540276e-01f, -2.24798754e-01f, 1.28567517e-01f, -7.62096420e-02f, -1.62611574e-01f, 1.56835958e-01f, 1.43561721e-01f, -1.95038933e-02f, 2.09004149e-01f, -2.42691398e-01f,
  -1.12869903e-01f, -2.46103704e-01f, -2.21415624e-01f, -2.86890745e-01f, -1.15613252e-01f, 1.59717962e-01f, -1.33380309e-01f, -1.99790969e-01f, 1.68257743e-01f, -1.76979795e-01f,
  1.91129282e-01f, -3.39757442e-01f, 1.33136168e-01f, -2.85687834e-01f, -2.34264761e-01f, 2.76794195e-01f, 2.13622659e-01f, -1.85298830e-01f, -3.59767407e-01f, -3.04133862e-01f,
  2.10321695e-01f, -4.67918366e-02f, -2.96119273e-01f, -1.30148888e-01f, 2.17015535e-01f, 3.03798318e-01f, -1.74669012e-01f, -3.49123716e-01f, 4.37865019e-01f, -1.99729189e-01f,
  7.13433921e-02f, -3.56578201e-01f, -5.47333479e-01f, -2.54771948e-01f, 4.58106063e-02f, -1.24158837e-01f, 4.90727246e-01f, 5.07340193e-01f, 4.38501567e-01f, -3.21482360e-01f,
  -1.86284155e-01f, 6.71174657e-03f, -3.63227427e-01f, 4.01986688e-01f, -2.44534358e-01f, -1.62614211e-01f, 1.34452835e-01f, -2.05600485e-01f, -2.42741868e-01f, 2.13375449e-01f,
  -7.71358609e-02f, -4.48305532e-02f, -3.73760790e-01f, -1.45715982e-01f, -4.45722252e-01f, -3.65084469e-01f, -1.15789942e-01f, 3.26144785e-01f, -4.81508225e-01f, -1.79934517e-01f,
  -2.11711690e-01f, 9.75277927e-03f, -3.42437893e-01f, -5.42087793e-01f, -4.26324815e-01f, 2.84565032e-01f, -1.27930775e-01f, -2.45072842e-01f, -4.59284633e-02f, 2.94886798e-01f,
  -3.00633371e-01f, 2.07644887e-03f, 2.57474929e-01f, 1.00651555e-01f, 7.04060122e-02f, -4.33849581e-02f, -2.76893377e-02f, 2.32192293e-01f, 9.89552140e-02f, 8.87474120e-02f,
  1.74938917e-01f, 4.01895121e-02f, 3.47890556e-01f, 1.40290931e-01f, 5.55049852e-02f, 1.82105571e-01f, 4.34150659e-02f, 1.87441841e-01f, 1.40627772e-01f, 2.48727679e-01f,
  -1.40927266e-02f, -4.83787321e-02f, 5.87116070e-02f, -2.04532087e-01f, 3.08356229e-02f, 1.93222880e-01f, -6.85470626e-02f, -4.60478850e-02f, 2.48266056e-01f, 6.94267824e-02f,
  2.72982657e-01f, 1.04686558e-01f, 4.99107763e-02f, -1.00503102e-01f, -7.44054234e-03f, -1.01573132e-02f, -8.94254670e-02f, 3.65508860e-03f, 1.71420258e-02f, 1.99599192e-01f,
  -7.44637288e-03f, -1.74961612e-01f, -3.04681748e-01f, -7.23929927e-02f, -1.57900438e-01f, 1.72901317e-01f, 2.26052925e-01f, 4.39938545e-01f, -2.58182496e-01f, -6.59571867e-03f,
  -7.26592764e-02f, -1.47627249e-01f, 9.54138562e-02f, 3.68835002e-01f, -1.05302997e-01f, 3.18699867e-01f, 9.86835733e-02f, -2.64232904e-02f, -3.30105782e-01f, -1.11208320e-01f,
  3.27608883e-01f, -2.90239424e-01f, -3.50062191e-01f, 3.99874955e-01f, -2.71136492e-01f, 2.96535224e-01f, 3.01787227e-01f, 2.59006500e-01f, 8.98085609e-02f, 1.80560380e-01f,
  3.12638819e-01f, 8.13358799e-02f, 2.73154020e-01f, 5.56863956e-02f, 3.33005220e-01f, 3.88333261e-01f, -3.24573755e-01f, -1.16888486e-01f, -2.68862903e-01f, -3.37692261e-01f,
  1.09925002e-01f, 5.23335561e-02f, 2.92637199e-01f, -2.82075107e-01f, 1.63123995e-01f, -3.47520918e-01f, 6.89818859e-02f, -6.12130821e-01f, 1.10507861e-01f, -8.56250301e-02f,
  -3.23090367e-02f, -2.50488669e-01f, 2.56670386e-01f, 5.40332869e-03f, 4.19835389e-01f, -2.93050736e-01f, 2.08866134e-01f, -1.08931124e-01f, -1.18196316e-01f, -4.76465940e-01f,
  -9.38195884e-02f, 1.24071717e-01f, -4.00178730e-01f, -1.18536994e-01f, 2.27417052e-01f, -3.05980295e-01f, -3.35728854e-01f, 4.29565609e-01f, 2.84705609e-01f, -4.89043385e-01f,
  2.53617048e-01f, -2.20932394e-01f, 3.91574383e-01f, -3.24186347e-02f, 3.97609681e-01f, 1.25607789e-01f, -1.80419490e-01f, -2.30582774e-01f, 2.84695178e-02f, -2.73583859e-01f,
  4.20832902e-01f, 4.91222322e-01f, -3.48214716e-01f, -2.21450076e-01f, -3.35643470e-01f, 1.80622935e-01f, 1.59981757e-01f, -3.78301442e-01f, 3.25913578e-01f, -1.70517027e-01f,
  1.61403924e-01f, 1.27616758e-02f, -2.49461383e-01f, 1.72921300e-01f, 2.61086583e-01f, 5.29010706e-02f, 1.11806959e-01f, 2.02177316e-01f, 1.95847735e-01f, -3.92585434e-02f,
  -2.36049499e-02f, 1.75339401e-01f, 8.47365335e-02f, 2.66913742e-01f, 1.04083577e-02f, 2.56030500e-01f, 5.77253997e-02f, -2.44586244e-02f, 2.31542841e-01f, -1.02701426e-01f,
  1.63504049e-01f, 1.19592361e-01f, 1.54624462e-01f, 1.40108645e-01f, 7.10674822e-02f, 2.24412665e-01f, -4.75032963e-02f, 2.27611020e-01f, 1.67688385e-01f, -1.38885945e-01f,
  1.81910574e-01f, 5.21358736e-02f, 2.15623185e-01f, 2.41979152e-01f, 5.91683493e-04f, 1.70845956e-01f, -2.87363566e-02f, -7.63536915e-02f, -7.43174106e-02f, -5.16543031e-01f,
  -3.56745511e-01f, 3.59908119e-02f, -1.40013516e-01f, -3.31242740e-01f, -1.84072498e-02f, -3.67365003e-01f, 8.82548653e-03f, 2.43659705e-01f, -2.78252512e-01f, 2.60967433e-01f,
  2.07723007e-01f, -1.57864377e-01f, 7.77789354e-02f, -3.56539249e-01f, -1.59576759e-02f, 1.89728752e-01f, -3.14843178e-01f, -2.30186865e-01f, 3.28089446e-01f, -9.38145071e-02f,
  3.11544925e-01f, -2.89431095e-01f, 2.94172257e-01f, 2.09054515e-01f, -2.33473793e-01f, -6.05204590e-02f, -4.88712043e-01f, 1.33764848e-01f, -1.24935366e-01f, -2.07354188e-01f,
  -2.54321694e-01f, 1.63895473e-01f, -4.60311055e-01f, -2.19497874e-01f, 1.87972501e-01f, -3.76016319e-01f, -1.90349489e-01f, 3.83065939e-01f, -4.68233109e-01f, -7.25421384e-02f,
  -4.41697001e-01f, -4.69100207e-01f, 2.08148539e-01f, 2.63303816e-01f, -6.12592995e-01f, 3.29875827e-01f, -1.88942418e-01f, -4.16736573e-01f, 2.03618661e-01f, 3.27957928e-01f,
  2.58655220e-01f, -3.77260387e-01f, -7.27093592e-02f, -1.23104468e-01f, 1.90660596e-01f, 3.50134484e-02f, -1.03474244e-01f, -3.51614773e-01f, -4.65490520e-01f, -1.85658157e-01f,
  -5.27664781e-01f, -1.81620538e-01f, -2.23582834e-01f, -7.61616006e-02f, 2.51588821e-01f, -4.41711918e-02f, -1.26989305e-01f, -6.09380186e-01f, -1.77754924e-01f, -2.23181844e-01f,
  -8.27527866e-02f, 4.19939458e-01f, -5.33244712e-03f, -3.31109315e-01f, 2.53630280e-01f, -1.62052915e-01f, 2.56881833e-01f, 2.19654262e-01f, -2.76666373e-01f, -3.42407189e-02f,
  -2.53757268e-01f, -1.21336430e-01f, 1.36423528e-01f, 1.94507584e-01f, 4.31358755e-01f, 1.08758762e-01f, -2.86811125e-02f, -6.13574013e-02f, -4.13417704e-02f, -1.43097676e-02f,
  -1.54606819e-01f, -2.56022811e-02f, 6.10837750e-02f, -1.11561462e-01f, -1.41009971e-01f, 6.67762831e-02f, 1.98740363e-02f, 3.80933541e-03f, 5.72081655e-02f, -1.30563796e-01f,
  -2.45021924e-01f, -3.06036137e-02f, -2.93488223e-02f, 4.42006066e-02f, -1.48529246e-01f, -2.84892589e-01f, -3.91624831e-02f, 3.55360843e-02f, -1.50951609e-01f, 1.16739407e-01f,
  -1.87822178e-01f, -2.87064731e-01f, 1.10495940e-01f, 4.10122946e-02f, -5.73343895e-02f, 3.57755367e-03f, -1.17128834e-01f, 1.44209757e-01f, -4.11138125e-02f, 1.44891292e-01f,
  5.01091592e-02f, -7.18526468e-02f, 2.00191259e-01f, -1.65882349e-01f, 3.41724791e-02f, 1.16079018e-01f, -2.74599284e-01f, 4.76026833e-02f, -1.69501439e-01f, 2.20507532e-01f,
  3.32271218e-01f, 3.92345428e-01f, 3.24928045e-01f, 3.20064396e-01f, 2.08544672e-01f, 1.58484399e-01f, 2.05469206e-01f, -3.56526762e-01f, 2.63099074e-01f, -1.82627812e-01f,
  -4.30892378e-01f, -2.78577358e-01f, 1.82073280e-01f, 2.42690861e-01f, 1.27508566e-01f, 2.38008518e-02f, 1.78381041e-01f, 2.62229219e-02f, 3.00955564e-01f, -1.98405206e-01f,
  2.98127830e-01f, -1.39821500e-01f, 1.11326918e-01f, -1.66205257e-01f, 3.70477200e-01f, 2.59929091e-01f, -3.50374371e-01f, 2.82857325e-02f, 3.31913769e-01f, -2.98574835e-01f,
  1.04542129e-01f, -5.87245356e-03f, -3.77438888e-02f, 2.78292388e-01f, 3.29846814e-02f, 2.15327725e-01f, -4.35159564e-01f, -4.62135285e-01f, 3.80878240e-01f, -2.78854698e-01f,
  -4.05601054e-01f, -1.79773178e-02f, 2.26877451e-01f, 3.83811414e-01f, 2.54074857e-02f, -1.96335614e-01f, -4.22096431e-01f, -1.08209699e-01f, -4.27416563e-01f, 1.78676188e-01f,
  -1.35637432e-01f, -3.05967182e-01f, 6.78420216e-02f, -5.16160965e-01f, -8.41379166e-03f, 1.21590264e-01f, -2.78427660e-01f, -3.66044968e-01f, 3.15325052e-01f, 3.27728361e-01f,
  -1.30305022e-01f, -2.90937513e-01f, 7.20442459e-02f, -2.09152982e-01f, -6.46038413e-01f, 3.83028388e-01f, -1.31822482e-01f, 9.16223079e-02f, -2.43729115e-01f, 2.55913675e-01f,
  -3.03080767e-01f, -5.82527220e-01f, 3.38445991e-01f, -2.46180788e-01f, 3.85910004e-01f, -2.86473900e-01f, -1.35854155e-01f, 4.07789916e-01f, 4.17406768e-01f, 3.43083471e-01f,
  2.40265012e-01f, -1.24662869e-01f, -4.36769098e-01f, 1.10897124e-01f, -3.14639926e-01f, -6.54953182e-01f, 3.53140607e-02f, -1.99129596e-01f, 5.81584238e-02f, -2.12870717e-01f,
  -1.14189787e-02f, 7.37722889e-02f, 4.03489135e-02f, -1.65733293e-01f, -2.51885623e-01f, 2.82958243e-02f, 7.70380646e-02f, 1.34273758e-02f, 9.41759720e-03f, -4.85130586e-02f,
  -9.99656245e-02f, -1.07656218e-01f, -4.44498211e-02f, -9.74881649e-02f, -7.30753317e-02f, -2.19521932e-02f, -5.46243042e-03f, -6.87421784e-02f, -1.37344673e-01f, -8.76399130e-02f,
  4.92062233e-02f, -2.36363545e-01f, -4.29821499e-02f, -2.01070055e-01f, 3.23086344e-02f, -7.26132914e-02f, -7.29900301e-02f, 4.73488346e-02f, -1.37923032e-01f, -3.21079418e-02f,
  -2.40623847e-01f, 2.50938553e-02f, 5.07239103e-02f, -5.69628850e-02f, 7.72537962e-02f, -2.69145250e-01f, 1.86504394e-01f, -2.33862162e-01f, 2.25233987e-01f, -5.78019693e-02f,
  9.72935781e-02f, -9.69947726e-02f, -1.88712761e-01f, -7.05582872e-02f, 1.65244386e-01f, -1.30965114e-01f, 1.80162728e-01f, 1.44698739e-01f, -1.65254489e-01f, 1.42554939e-01f,
  -2.08362624e-01f, -3.56337577e-02f, -2.03436837e-01f, -2.60936208e-02f, 6.53695092e-02f, 1.69813424e-01f, -1.68111045e-02f, 1.93658352e-01f, -2.18942881e-01f, -7.76994228e-02f,
  1.09192565e-01f, 1.82447538e-01f, 6.00077920e-02f, -2.15154231e-01f, 5.96052594e-02f, -1.54962495e-01f, -1.76391423e-01f, 1.89991686e-02f, 8.61517414e-02f, -9.66046154e-02f,
  -1.07950345e-01f, 2.57716328e-01f, 2.13895943e-02f, 3.40795338e-01f, -8.38749483e-03f, -1.14196919e-01f, -2.77084321e-01f, -3.00082266e-01f, 2.74799615e-01f, -2.82306552e-01f,
  -2.82461107e-01f, -1.83277115e-01f, 2.57365555e-01f, -2.04882935e-01f, -2.41197318e-01f, 4.15366948e-01f, 4.83155809e-03f, 4.68220301e-02f, -3.10303152e-01f, -3.00102115e-01f,
  -9.58759859e-02f, -1.27730876e-01f, -5.56928385e-03f, 3.80541593e-01f, 2.39848629e-01f, -2.39245370e-01f, -3.69303614e-01f, -1.97453216e-01f, -1.67837173e-01f, -2.74346620e-01f,
  -1.43085241e-01f, 3.28532040e-01f, -1.40209138e-01f, -3.26593369e-01f, -1.04000665e-01f, 4.66802120e-01f, 9.39202905e-02f, -1.29041269e-01f, 2.53716856e-01f, -2.20895231e-01f,
  -2.97442406e-01f, -1.60859339e-03f, -9.24304947e-02f, 2.39734218e-01f, -1.35056704e-01f, -6.33340850e-02f, -2.92053312e-01f, 3.40752274e-01f, -1.64084822e-01f, 1.28496617e-01f,
  -3.62036258e-01f, 3.42562705e-01f, 2.71510035e-01f, 9.71329510e-02f, -1.09577350e-01f, -1.11988395e-01f, 8.09462816e-02f, 4.89885472e-02f, 5.11551127e-02f, -5.28612472e-02f,
  4.22075242e-02f, -1.33235514e-01f, -7.14185685e-02f, 4.99533303e-02f, 5.92363216e-02f, -1.58147171e-01f, -1.12602562e-01f, 1.43456841e-02f, -3.49084362e-02f, -4.70282622e-02f,
  1.05395392e-01f, 2.34580636e-02f, -6.72738105e-02f, -4.36284877e-02f, -4.12085578e-02f, 1.04057305e-02f, -1.31981805e-01f, 6.32562488e-02f, -1.27228066e-01f, -5.59245273e-02f,
  1.40978009e-01f, 8.96693319e-02f, 6.71759024e-02f, 1.32529870e-01f, -1.25619605e-01f, -8.00320059e-02f, -1.28463417e-01f, -2.75959279e-02f, 4.26386632e-02f, 4.50230017e-02f,
  -2.36562509e-02f, -1.20194979e-01f, -2.33920485e-01f, 1.82373703e-01f, -6.34276718e-02f, 1.76268384e-01f, -2.62911320e-01f, 4.03301651e-03f, -1.49543315e-01f, -1.86221033e-01f,
  1.11505903e-01f, 1.02086842e-01f, 2.80847326e-02f, 2.35827789e-01f, -1.76551908e-01f, 1.58112466e-01f, -4.77627106e-02f, -1.00919224e-01f, -2.30950996e-01f, 1.27826780e-01f,
  1.77678213e-01f, 1.38829082e-01f, -9.67244208e-02f, 2.27927223e-01f, 2.20805928e-01f, 2.51864463e-01f, 2.95045465e-01f, 2.53824234e-01f, 6.10870719e-02f, 1.55833125e-01f,
  -6.82000369e-02f, 1.53848022e-01f, -1.97899282e-01f, -3.15535627e-02f, 1.79849729e-01f, 9.22187231e-03f, -1.67549655e-01f, 2.65626401e-01f, -1.22084036e-01f, -2.04909667e-01f,
  -3.55316997e-01f, 3.96384627e-01f, -3.79476875e-01f, -1.03861839e-01f, -3.17062110e-01f, -3.53967607e-01f, -1.50091544e-01f, -1.21683054e-01f, -3.27526361e-01f, -1.97726130e-01f,
  4.62742150e-01f, 3.74087453e-01f, -2.96852916e-01f, -2.66317636e-01f, -1.91390440e-01f, -3.63803923e-01f, -2.35561058e-01f, -1.43377921e-02f, -2.63565421e-01f, -2.39904940e-01f,
  3.28085780e-01f, -1.32035717e-01f, -2.42017761e-01f, 2.51216203e-01f, -4.79570627e-01f, -2.74222821e-01f, 3.33273202e-01f, 8.19540769e-02f, 4.01854694e-01f, -2.16690619e-02f,
  -1.91024899e-01f, -1.74169272e-01f, 2.73677677e-01f, -1.90534800e-01f, -2.26372749e-01f, -3.44527006e-01f, 5.23932636e-01f, -1.34773508e-01f, -1.25255853e-01f, 2.90475070e-01f,
  -1.63954198e-01f, 2.17783272e-01f, -3.08980405e-01f, -3.07012856e-01f, 3.41689378e-01f, -1.52392194e-01f, -9.01723057e-02f, -1.72107622e-01f, -2.95981348e-01f, -2.67867774e-01f,
  1.03771061e-01f, 2.50589311e-01f, -1.14030682e-01f, 1.53699261e-03f, -4.80604731e-02f, 1.38109997e-01f, 3.88646382e-03f, -2.68846810e-01f, -9.33042467e-02f, -1.57321826e-01f,
  3.03221643e-02f, 4.49317284e-02f, -1.88005194e-01f, 1.16672352e-01f, 1.17470838e-01f, 6.46688268e-02f, 1.69143025e-02f, -4.97784056e-02f, 1.10144064e-01f, 5.79771213e-02f,
  1.01766884e-01f, 1.08165972e-01f, -1.46614477e-01f, 1.21930420e-01f, 1.19526135e-02f, 1.80640861e-01f, 1.21304572e-01f, 5.27769029e-02f, 1.10923511e-03f, -1.20152913e-01f,
  1.11393355e-01f, 1.74805939e-01f, -8.14647824e-02f, -8.30891579e-02f, 6.78994134e-02f, 1.83859300e-02f, 1.64881349e-01f, 5.24310954e-02f, 6.99538291e-02f, -1.03267334e-01f,
  -1.72542349e-01f, -2.76293084e-02f, -1.71422929e-01f, 2.31274739e-01f, 2.18163446e-01f, 1.89469159e-01f, 2.20953658e-01f, 1.57355547e-01f, 1.35637119e-01f, -1.01965949e-01f,
  -3.19118261e-01f, -2.74798833e-02f, 1.49095794e-02f, -8.98992568e-02f, 2.60126330e-02f, -2.55744666e-01f, -3.18809062e-01f, 2.54676759e-01f, 2.30214849e-01f, 2.91467100e-01f,
  1.72652870e-01f, 2.62409925e-01f, -1.43807858e-01f, -5.24116047e-02f, 1.02646664e-01f, -1.56238750e-01f, -2.34003797e-01f, 3.22427839e-01f, 1.94768086e-01f, -3.26780289e-01f,
  3.37501317e-01f, 3.25985730e-01f, 2.51597837e-02f, -4.43209521e-02f, 2.23771811e-01f, -2.97219455e-01f, 1.89194292e-01f, 2.94744641e-01f, -3.21957879e-02f, -2.66368806e-01f,
  -6.05722927e-02f, -4.01965436e-03f, -2.07912892e-01f, -3.24099690e-01f, 4.56889331e-01f, -4.76869643e-01f, -4.64866519e-01f, -9.56550911e-02f, 1.57540843e-01f, -2.20085695e-01f,
  -1.13874562e-01f, 2.12540522e-01f, -1.62090406e-01f, -4.59537536e-01f, -6.58158213e-02f, -2.18393296e-01f, -2.45274425e-01f, 4.42766935e-01f, -3.45874816e-01f, 2.37963825e-01f,
  4.55479473e-01f, -3.36175233e-01f, 3.43303792e-02f, 3.57687563e-01f, -3.46229225e-01f, 7.50510544e-02f, -1.12653069e-01f, -2.31254011e-01f, 5.14410198e-01f, 3.14993799e-01f,
  -2.11978450e-01f, 2.41491586e-01f, 9.17653069e-02f, 1.69346094e-01f, -1.69131458e-01f, 2.86205769e-01f, -5.83818734e-01f, -2.50962943e-01f, 2.96522528e-01f, -2.46569887e-01f,
  3.78103524e-01f, -1.88273922e-01f, -4.96047705e-01f, 6.35683984e-02f, -4.59249228e-01f, -2.50497431e-01f, 1.90269977e-01f, -1.21938974e-01f, -3.28750730e-01f, 5.24190813e-02f,
  -2.17609808e-01f, 1.07294239e-01f, -5.89159168e-02f, 1.88976333e-01f, 7.17092901e-02f, -9.19914618e-03f, 1.61409471e-03f, 9.49149504e-02f, -8.08979794e-02f, 1.95945457e-01f,
  -8.38311836e-02f, 7.98726752e-02f, 4.75995354e-02f, 1.78743288e-01f, 4.37437892e-02f, 2.02126965e-01f, 1.77725300e-01f, -2.15671107e-01f, 1.28120482e-01f, 1.94577381e-01f,
  -7.41834461e-04f, 1.75569966e-01f, -5.29577918e-02f, 1.01947896e-01f, 1.91808194e-01f, -5.74260876e-02f, 4.55625094e-02f, -1.38418019e-01f, 3.59016135e-02f, 1.19237311e-01f,
  4.19772752e-02f, 1.67019710e-01f, 1.60202771e-01f, 1.81712478e-01f, 1.53647542e-01f, 7.81179741e-02f, 1.76187515e-01f, 1.79660365e-01f, 3.50532502e-01f, 2.14100808e-01f,
  3.04025143e-01f, 3.39957416e-01f, 3.06218356e-01f, -2.03888729e-01f, -2.29404867e-01f, 3.31144184e-01f, -3.88455778e-01f, -2.26901323e-01f, 3.13444108e-01f, -1.57133676e-02f,
  -2.37789944e-01f, -7.85085112e-02f, 3.24480921e-01f, 1.09362908e-01f, -1.68513119e-01f, -3.43740404e-01f, -2.67405003e-01f, 8.37196484e-02f, -3.66766363e-01f, 1.95784733e-01f,
  -2.10471630e-01f, 2.03593448e-01f, -1.80343717e-01f, -1.77792460e-01f, 3.96931052e-01f, -3.18147212e-01f, -7.65677243e-02f, -5.11110425e-02f, -4.18747634e-01f, 3.64332259e-01f,
  -1.14644706e-01f, -2.77343184e-01f, -8.90719071e-02f, 2.09101453e-01f, 3.69782388e-01f, 1.16119184e-01f, 5.63326001e-01f, -3.37366462e-01f, -1.78821877e-01f, 2.95741588e-01f,
  -1.32187605e-01f, 5.30238271e-01f, -2.39588365e-01f, -2.16335982e-01f, 4.53929268e-02f, -7.27789178e-02f, -3.54049087e-01f, 2.17393428e-01f, -9.64468904e-03f, -2.45576277e-01f,
  -4.32138085e-01f, -2.86555350e-01f, -5.02929926e-01f, -1.33655638e-01f, -3.49779725e-01f, 5.33312112e-02f, -7.11699352e-02f, -3.13867331e-01f, 1.49928048e-01f, -4.73496258e-01f,
  -1.86520621e-01f, -3.17005903e-01f, 4.75552827e-01f, -2.78918236e-01f, -3.48258317e-01f, -5.03804088e-01f, 3.35769176e-01f, -2.75243253e-01f, 2.37607673e-01f, 5.17747141e-02f,
  -1.38026714e-01f, -2.53063411e-01f, -3.32856685e-01f, -2.61355996e-01f, -2.88481951e-01f, 1.92796811e-01f, -2.99263656e-01f, 1.81155458e-01f, 1.99726969e-01f, -2.76069850e-01f,
  1.84842527e-01f, -3.57067406e-01f, -4.06832784e-01f, -2.24933445e-01f, -1.62190720e-01f, -3.80732976e-02f, -2.29842648e-01f, -2.57336050e-02f, 3.72832008e-02f, 3.94621976e-02f,
  1.18575558e-01f, 1.58144459e-01f, 1.43088326e-01f, 1.74835995e-01f, 1.40817791e-01f, 2.72618216e-02f, 1.77426085e-01f, 1.77910756e-02f, 1.23158582e-01f, -1.08423516e-01f,
  9.18334797e-02f, -1.81996301e-01f, 1.26162171e-01f, -3.76078896e-02f, -4.52754088e-02f, -5.93679771e-02f, -2.03280933e-02f, 1.50022447e-01f, 1.75580055e-01f, -1.93365924e-02f,
  5.75467851e-03f, 1.57056585e-01f, -9.58665609e-02f, -5.48332520e-02f, -1.31504834e-01f, 4.77059595e-02f, -8.91021490e-02f, 2.36177854e-02f, -3.68393846e-02f, -7.39912987e-02f,
  4.96297032e-02f, -1.56942010e-01f, 1.89046599e-02f, -5.69409132e-02f, 1.33638591e-01f, -5.51443808e-02f, -2.59765774e-01f, -1.17104344e-01f, 2.48428620e-03f, -2.31485710e-01f,
  3.26227210e-02f, -1.47738587e-02f, -1.94479674e-01f, -2.25976378e-01f, 5.83792813e-02f, 2.29852468e-01f, -4.56832349e-03f, -1.82913885e-01f, 2.01711968e-01f, 3.36717784e-01f,
  9.11650658e-02f, 3.97120774e-01f, 2.70466596e-01f, 2.72014022e-01f, -1.44758612e-01f, 1.76463395e-01f, 8.59205425e-02f, -1.56996697e-02f, 3.23453903e-01f, 9.95464325e-02f,
  3.28075349e-01f, 9.42710936e-02f, -3.60677898e-01f, 7.02084824e-02f, 2.78493851e-01f, -3.45803410e-01f, 2.95334965e-01f, -3.42503965e-01f, -3.24073553e-01f, 2.96683192e-01f,
  6.83535784e-02f, 2.67384648e-01f, 2.90133923e-01f, 3.67604643e-01f, 1.62990689e-01f, 2.82253116e-01f, -2.17216209e-01f, 4.35862720e-01f, 9.36071351e-02f, -5.66783659e-02f,
  -2.89324194e-01f, 3.43547136e-01f, 3.51209670e-01f, -4.96824771e-01f, -3.16216677e-01f, -2.84116954e-01f, -4.23931181e-01f, 3.41088814e-03f, -6.43286407e-02f, -2.56331116e-01f,
  -2.87761632e-02f, -4.07236397e-01f, 8.22238550e-02f, -1.17137618e-01f, 4.08283144e-01f, -2.31050536e-01f, -8.95999223e-02f, 5.02431691e-01f, -1.46556810e-01f, -3.78265530e-01f,
  -4.69333678e-01f, -2.87624002e-01f, -1.53326392e-01f, -8.65861923e-02f, -1.45409420e-01f, 3.54963392e-01f, -3.73698026e-01f, -2.86584765e-01f, -2.90325701e-01f, -8.85104388e-02f,
  8.11503083e-02f, -3.62106174e-01f, 5.13738632e-01f, 2.41069421e-01f, -1.59843281e-01f, -7.85950720e-02f, -1.96990803e-01f, -2.66324252e-01f, 3.47612679e-01f, -2.65323728e-01f,
  -1.38381541e-01f, -2.62824535e-01f, 2.67191082e-01f, -2.47674987e-01f, -2.83224732e-01f, -3.36525053e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -8.17153454e-02f, 4.11682716e-03f, -3.48402164e-03f, -6.06831945e-02f, 5.13195321e-02f, 3.38697396e-02f, -2.45641004e-02f, -9.93669219e-03f, -8.74121115e-03f, -1.22164927e-01f,
  8.99463668e-02f, -3.16065401e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 38, 52
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    