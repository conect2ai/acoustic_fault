/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.55548447e-01f, 3.55913818e-01f, 3.28465939e-01f, 1.43340498e-01f, -2.31208354e-02f, 2.63485253e-01f, 5.74411869e-01f, 5.98955341e-02f, 1.76640563e-02f, 2.40921840e-01f,
  -1.47568211e-01f, -4.62757915e-01f, -3.30236465e-01f, -3.56043667e-01f, -3.13928463e-02f, 4.37812120e-01f, 3.78554970e-01f, -1.44323453e-01f, -3.13050836e-01f, -1.76220760e-01f,
  -2.00814575e-01f, -3.89032625e-02f, -1.36642858e-01f, -1.59901097e-01f, 2.41280809e-01f, -1.05797447e-01f, 1.07381478e-01f, 4.93321754e-03f, -2.11302117e-02f, 7.43395314e-02f,
  -1.74215005e-03f, 2.72837520e-01f, -1.90845490e-01f, -1.67641431e-01f, -9.54439938e-02f, 6.77695125e-02f, 5.11327311e-02f, 4.68167141e-02f, -5.08085713e-02f, 9.35186371e-02f,
  -5.27497716e-02f, -6.09703511e-02f, -1.27274558e-01f, 2.50174869e-02f, 8.48514885e-02f, 3.70931514e-02f, 6.78722113e-02f, 4.12278213e-02f, 1.31268695e-01f, -1.57313626e-02f,
  -1.10604241e-01f, -7.09187388e-02f, 8.69534090e-02f, 5.17907776e-02f, 5.65169528e-02f, -8.92919078e-02f, 1.12957075e-01f, 5.74173220e-02f, 6.40815422e-02f, 2.18621761e-01f,
  2.20126705e-03f, -2.88207475e-02f, -1.08995559e-02f, 4.81757373e-02f, 5.36314538e-03f, -5.84364077e-03f, -9.94940661e-03f, -1.94122959e-02f, -4.09571528e-02f, 5.31807877e-02f,
  -3.42786573e-02f, 7.61233121e-02f, -6.02044500e-02f, 1.04246616e-01f, -9.51512381e-02f, 8.09314102e-02f, 4.01613005e-02f, -2.49385051e-02f, -3.54861617e-02f, 6.57060742e-02f,
  2.04754318e-03f, -7.38823041e-02f, -1.16254725e-02f, -4.30322625e-02f, 2.13856604e-02f, 5.64660579e-02f, 2.80950498e-03f, -3.83676328e-02f, 3.17513221e-03f, 9.00341272e-02f,
  -3.30155827e-02f, -1.57536164e-01f, 1.03937417e-01f, -1.37389889e-02f, 3.18369679e-02f, -4.74556983e-02f, -5.40592857e-02f, -2.99439523e-02f, 1.41114173e-02f, 4.46331017e-02f,
  -3.89759317e-02f, -5.80511848e-03f, 3.59793268e-02f, -4.81009409e-02f, -4.81614359e-02f, 4.36318815e-02f, 7.89809823e-02f, -6.94838688e-02f, -1.79841146e-02f, 1.26022324e-01f,
  1.76734235e-02f, 7.87627548e-02f, 1.89454481e-02f, 6.28647804e-02f, -1.81423742e-02f, 2.76555307e-03f, 2.53766272e-02f, 7.69508034e-02f, 5.92096932e-02f, 2.69974411e-01f,
  5.71927011e-01f, 6.17467985e-02f, -6.43123984e-01f, 2.59353787e-01f, -2.41872966e-01f, -1.90960601e-01f, 6.88372701e-02f, 2.89911985e-01f, 7.20842928e-02f, -2.99124382e-02f,
  -2.21304223e-01f, 2.97097415e-02f, -1.55961961e-01f, -1.00271208e-02f, 2.87304729e-01f, -3.50883370e-03f, 3.56832370e-02f, 5.99882640e-02f, 2.42137864e-01f, 2.57105142e-01f,
  3.37499946e-01f, 2.15469509e-01f, 2.37750486e-01f, 2.14468464e-01f, -9.47834551e-02f, -1.79037184e-01f, -3.79669607e-01f, -1.12198479e-01f, -7.40841776e-02f, 1.89198166e-01f,
  -3.22441161e-01f, 1.38931558e-01f, 7.56631568e-02f, 7.45494589e-02f, -1.71916783e-01f, 1.99905951e-02f, 1.96382161e-02f, -1.15052769e-02f, -7.32213855e-02f, 2.77051385e-02f,
  -2.70161182e-02f, 4.33135517e-02f, 5.23723587e-02f, 4.13365848e-02f, 4.52948846e-02f, 7.97754005e-02f, 2.98650786e-02f, 1.83247656e-01f, 4.36391048e-02f, -1.21796630e-01f,
  -8.31300020e-03f, 2.65266392e-02f, -6.10810369e-02f, 5.87072549e-03f, 6.16457276e-02f, -7.48855236e-04f, -5.72737567e-02f, 8.35335404e-02f, -1.30793840e-01f, 8.37740228e-02f,
  -1.77312996e-02f, -3.90803367e-02f, 1.07097365e-02f, 3.65971848e-02f, 4.30805311e-02f, -9.22482163e-02f, -1.39934896e-02f, 1.14242416e-02f, 5.74342534e-02f, -1.29384105e-03f,
  7.14281481e-03f, -5.02319261e-02f, 1.36452923e-02f, 2.85661630e-02f, -3.42794461e-03f, 3.79937235e-03f, 6.36068583e-02f, 2.37471499e-02f, -1.65358707e-02f, 4.15595919e-02f,
  6.32681996e-02f, -2.74198800e-02f, -1.04779623e-01f, 3.16479765e-02f, 3.99064198e-02f, 2.82418970e-02f, 8.26408621e-03f, 2.19517555e-02f, -4.18333150e-02f, 1.65440384e-02f,
  -8.19079354e-02f, -9.15524811e-02f, 7.90029317e-02f, 9.71552730e-02f, -3.37803289e-02f, -6.11431934e-02f, -6.40440639e-03f, -1.24714170e-02f, -5.25996052e-02f, -4.27349750e-03f,
  4.49509680e-05f, 5.63187487e-02f, -6.66352361e-02f, 3.56679149e-02f, 3.24218757e-02f, -5.71046360e-02f, 1.82629619e-02f, -3.72789986e-02f, 1.64711643e-02f, -7.91712329e-02f,
  -3.32777537e-02f, 1.03766181e-01f, 3.40210944e-02f, -2.59688143e-02f, -1.18342545e-02f, -2.48351209e-02f, -2.02758119e-01f, -9.23288018e-02f, -6.80957409e-03f, 8.30249786e-02f,
  -7.42091984e-02f, 1.39599547e-01f, 9.75786299e-02f, 3.72091495e-02f, 4.54688929e-02f, -1.72451045e-02f, -1.09746762e-01f, -1.45718735e-02f, 5.28308712e-02f, 4.63710465e-02f,
  2.49339134e-01f, 2.26222742e-02f, -9.19247791e-02f, -6.12799488e-02f, -1.64187551e-01f, -1.18659206e-01f, -2.60977328e-01f, -2.79229701e-01f, -1.23187855e-01f, 7.66417310e-02f,
  5.78400157e-02f, -7.71706551e-02f, 1.30924121e-01f, -5.34839137e-03f, -5.57736680e-02f, -1.95134431e-01f, 4.79961112e-02f, 1.98434785e-01f, 4.51010689e-02f, -1.94866568e-01f,
  1.80160150e-01f, 1.75261959e-01f, -1.68935463e-01f, 4.41033728e-02f, 1.00825846e-01f, -3.95373851e-02f, -1.97245367e-02f, 5.86182401e-02f, 3.50084864e-02f, -9.82563850e-03f,
  7.39980564e-02f, 4.96313311e-02f, -6.16984777e-02f, 7.89713115e-02f, 3.92431580e-02f, 1.40445298e-02f, 9.65230763e-02f, 6.44831061e-02f, 3.55110355e-02f, 1.56701446e-01f,
  5.59989139e-02f, 1.68822780e-01f, 8.52996111e-03f, 1.50578052e-01f, 1.15658768e-01f, -2.24801060e-02f, 1.42591685e-01f, 6.07063435e-02f, -5.87771821e-04f, -9.74907503e-02f,
  3.73893939e-02f, -9.35566202e-02f, -4.22647805e-04f, -1.33630438e-02f, -4.52448092e-02f, 4.10634205e-02f, -4.05316129e-02f, -3.36481854e-02f, -3.67618613e-02f, 3.15052420e-02f,
  -4.64634188e-02f, 6.82438090e-02f, -8.10444169e-03f, -2.94833798e-02f, -1.89287681e-02f, 8.17913786e-02f, -2.05452743e-04f, -3.30201723e-02f, 1.79336742e-02f, 7.38274679e-02f,
  -1.16312876e-03f, -1.20278105e-01f, 6.06795363e-02f, -2.17668526e-02f, 4.31765765e-02f, -8.79906304e-03f, -3.53269130e-02f, 6.41317666e-02f, 3.22242826e-02f, -1.22256270e-02f,
  -6.71021640e-02f, 1.01058325e-02f, -6.72679320e-02f, -7.24600581e-03f, 2.63368420e-05f, 8.62730071e-02f, 4.30576727e-02f, 6.26593158e-02f, 1.53848259e-02f, -4.74145599e-02f,
  2.78712567e-02f, -8.67492110e-02f, -1.12951756e-03f, 1.88803654e-02f, 1.45621952e-02f, -2.00883299e-02f, 6.16135374e-02f, -4.63889837e-02f, -9.84065235e-03f, 1.76685542e-01f,
  5.26344702e-02f, -9.02521461e-02f, -1.61789060e-01f, -1.82030797e-01f, -5.35241961e-02f, -2.03307807e-01f, -1.85210466e-01f, -1.01916648e-01f, -2.03381225e-01f, -3.38196874e-01f,
  1.43365592e-01f, 2.48502623e-02f, 3.37158918e-01f, 3.25005323e-01f, 1.70822889e-01f, -1.69867009e-01f, -1.97626084e-01f, -3.67979765e-01f, 1.01097360e-01f, 1.85928624e-02f,
  -1.85316429e-01f, -4.30633798e-02f, 5.04921079e-02f, -1.12226725e-01f, -2.59652734e-01f, 8.37863833e-02f, 2.86481649e-01f, 1.71626493e-01f, -8.45138282e-02f, -2.90190399e-01f,
  6.72709569e-02f, 1.13379337e-01f, 1.30562514e-01f, -5.34986481e-02f, 3.27096909e-01f, 1.93765953e-01f, 1.20452993e-01f, 1.16939411e-01f, 2.21581236e-02f, 6.32811129e-01f,
  2.39190251e-01f, 3.34238000e-02f, -1.43694595e-01f, -3.64864734e-03f, 2.34922916e-02f, -5.66082075e-02f, 9.77609656e-04f, 4.03259248e-02f, -4.51292023e-02f, 2.14222185e-02f,
  7.15817586e-02f, -1.99082140e-02f, 6.37423843e-02f, -9.24691744e-03f, -6.33675326e-03f, -9.00784135e-03f, 4.88403738e-02f, -5.17829657e-02f, -4.50384617e-02f, -6.05170503e-02f,
  7.99342319e-02f, 2.33608201e-01f, 1.24964386e-01f, 5.67602478e-02f, -8.71792436e-02f, -4.91398685e-02f, -8.51974264e-02f, -5.29331379e-02f, -1.59519836e-01f, 1.80249587e-01f,
  -3.69680598e-02f, 1.19631566e-01f, -3.22902873e-02f, -7.46267885e-02f, -7.75540806e-03f, -4.93995892e-03f, 5.43483831e-02f, 2.41348892e-02f, -1.04932869e-02f, 6.70559481e-02f,
  -4.58018817e-02f, -2.43579578e-02f, -1.97722483e-02f, 5.87415211e-02f, 7.00106770e-02f, 4.12979238e-02f, 7.57926628e-02f, 2.97322609e-02f, 1.01342415e-02f, -8.83767940e-03f,
  -6.33899197e-02f, -7.81415682e-03f, 3.29862386e-02f, 8.16558227e-02f, -2.66188812e-02f, 8.13593250e-03f, 1.57001689e-02f, -8.68746266e-02f, -6.94812089e-02f, -7.30985850e-02f,
  1.43153826e-02f, -9.88714620e-02f, 2.04095170e-01f, -6.09428957e-02f, 8.42749923e-02f, -8.38475898e-02f, 1.08035713e-01f, 7.45839579e-03f, -5.82529232e-03f, 4.89942841e-02f,
  -8.67781192e-02f, 3.53404647e-03f, 6.54760003e-02f, -8.47976878e-02f, 2.72652656e-02f, -9.82955471e-02f, -5.38900010e-02f, 1.12988904e-01f, -8.49662349e-03f, 5.35100475e-02f,
  -5.06282859e-02f, 1.22338505e-02f, -3.76004982e-03f, 8.34296495e-02f, -2.75261160e-02f, 1.01459123e-01f, -8.77034850e-03f, -1.31420895e-01f, -1.39392480e-01f, -1.40676901e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.42472243e-01f, 3.06814164e-01f, -3.75275612e-01f, 1.62596330e-01f, -3.05214263e-02f, -3.86427753e-02f, 4.85344142e-01f, 1.45308167e-01f, 4.18828838e-02f, 1.29609376e-01f,
  -5.38529865e-02f, -1.14578485e-01f, 6.43531904e-02f, -6.47516805e-04f, 4.20332141e-02f, 2.65041590e-01f, 2.62989163e-01f, -2.87144035e-01f, -2.81620443e-01f, -9.29427668e-02f,
  2.86989421e-01f, 2.98641145e-01f, 2.92655546e-02f, -2.71416735e-02f, 8.65739360e-02f, -2.06364202e-03f, 1.38772652e-01f, -7.50105232e-02f, -1.84741080e-01f, 2.51929425e-02f,
  -8.78348947e-02f, -5.15939474e-01f, -3.51500139e-02f, -8.28494579e-02f, -8.36013779e-02f, -4.66029532e-02f, -2.38443241e-02f, -6.64030388e-02f, -6.08398914e-02f, 7.11834729e-02f,
  -1.75186098e-01f, -1.20504245e-01f, -1.95626840e-01f, 1.82240382e-02f, 5.42858103e-03f, -1.02910966e-01f, -6.52217343e-02f, -1.37558177e-01f, -5.48918322e-02f, -1.27420008e-01f,
  1.79043896e-02f, -2.62414694e-01f, -2.57876843e-01f, -1.27548436e-02f, -2.53211826e-01f, -3.24607491e-01f, -1.08817674e-01f, -2.56028801e-01f, -3.32467645e-01f, 1.89895853e-01f,
  4.12773341e-02f, -5.17937588e-03f, -3.81033458e-02f, -3.80908581e-03f, 5.21331169e-02f, 4.47738953e-02f, 4.75063585e-02f, 7.91989192e-02f, 7.23871514e-02f, 4.21739183e-02f,
  2.48179436e-02f, -9.92518738e-02f, 3.91477011e-02f, 3.80921364e-02f, 5.79311745e-03f, -2.94142626e-02f, -3.29098441e-02f, 1.61077872e-01f, -7.96736106e-02f, 1.36595834e-02f,
  -5.57658263e-02f, -9.54387411e-02f, 6.28952235e-02f, 6.07454553e-02f, -1.12633131e-01f, -6.67069778e-02f, 1.04146767e-02f, -4.57528047e-02f, 8.08042474e-03f, -5.48682287e-02f,
  7.57469356e-01f, -4.17534083e-01f, 1.15262277e-01f, 4.35377210e-02f, -1.90841383e-03f, -4.52095196e-02f, 2.26666238e-02f, -1.24438137e-01f, -2.99267266e-02f, 4.63380292e-02f,
  -1.76880106e-01f, -3.59329842e-02f, 7.95724988e-02f, 5.68879284e-02f, 7.65376762e-02f, 2.78614666e-02f, 1.30769923e-01f, 3.39642279e-02f, -3.25011201e-02f, 4.45647687e-02f,
  1.74444482e-01f, 2.41875768e-01f, 2.27206826e-01f, 1.80985481e-01f, 6.54579028e-02f, -3.27310339e-02f, 2.32844457e-01f, 1.21198177e-01f, 5.71540035e-02f, 8.94888639e-01f,
  -1.67079851e-01f, -1.84376873e-02f, 1.90221563e-01f, 1.57537162e-01f, -2.60164142e-01f, -5.13027728e-01f, -5.65322638e-01f, -2.18881696e-01f, -8.14851001e-02f, -8.76553431e-02f,
  -1.74372122e-01f, 5.72769940e-02f, 1.13317646e-01f, 1.45355210e-01f, 1.32601172e-01f, 1.15129493e-01f, 2.21763566e-01f, 4.45394397e-01f, 1.59856752e-01f, 9.53128710e-02f,
  2.30472803e-01f, 2.73990750e-01f, 2.81684756e-01f, 1.56625614e-01f, 3.12470227e-01f, 2.00354621e-01f, 7.33216926e-02f, 1.29627421e-01f, 3.45476754e-02f, 5.54022193e-01f,
  1.33572686e-02f, -1.82665497e-01f, 1.70946494e-02f, 1.43622821e-02f, -4.72058244e-02f, 6.36771601e-03f, -1.11555077e-01f, 1.21504620e-01f, -7.08555356e-02f, -1.41815059e-02f,
  -5.49620613e-02f, 4.21338677e-02f, 1.29753560e-01f, 2.88175270e-02f, -1.33202538e-01f, -1.38246238e-01f, 1.26544312e-01f, 1.75948039e-01f, 1.00083113e-01f, -1.04842909e-01f,
  3.70671824e-02f, -1.30176395e-01f, -1.88854441e-01f, -1.99183121e-01f, -2.19942862e-03f, -2.40087025e-02f, -6.43813610e-02f, -1.04746856e-01f, -9.49993953e-02f, 6.97700754e-02f,
  6.07187452e-04f, -6.91747153e-03f, -8.21215585e-02f, 2.95570716e-02f, 5.85812554e-02f, 1.81581434e-02f, 2.46850271e-02f, -9.96427424e-03f, -6.44030701e-03f, 3.33296210e-02f,
  -1.83438826e-02f, 2.38107461e-02f, -1.26851760e-02f, -4.10056487e-03f, 7.75701851e-02f, -5.20072021e-02f, -8.54228530e-03f, 5.28894551e-02f, 1.40651204e-02f, -5.04402258e-02f,
  -1.82591111e-03f, 2.61212308e-02f, -2.90204734e-02f, 1.05598032e-01f, -9.71660763e-03f, -1.24408994e-02f, 6.15814440e-02f, -5.56304753e-02f, -4.98843342e-02f, 6.18380755e-02f,
  -2.12419227e-01f, -2.32769430e-01f, -1.26977339e-01f, 4.63441722e-02f, -3.24343964e-02f, 3.71680334e-02f, -3.01928483e-02f, -6.69667050e-02f, 1.49160000e-02f, -1.07830286e-01f,
  -1.37536883e-01f, -4.82209139e-02f, -7.04007596e-02f, 5.81131969e-03f, -6.57132268e-02f, -1.98821411e-01f, -1.04603641e-01f, 3.11553646e-02f, -5.22201583e-02f, -6.52684867e-02f,
  1.08280079e-02f, -2.63105959e-01f, -3.85253251e-01f, -2.73820132e-01f, -1.84172615e-01f, -3.11834067e-01f, -2.85624206e-01f, -1.88521668e-01f, -3.96368325e-01f, -2.90802389e-01f,
  -8.06957126e-01f, -5.40401876e-01f, -3.63298990e-02f, -3.53816301e-01f, -5.79479150e-03f, 2.77439207e-01f, 1.07414126e-01f, 1.21440351e-01f, -1.77493021e-01f, -2.37001494e-01f,
  -3.06681395e-01f, -1.85020059e-01f, -1.27479658e-01f, 4.22854312e-02f, 1.58640757e-01f, -1.16570368e-02f, 1.70813993e-01f, 3.32364976e-01f, 3.36951077e-01f, 2.70162761e-01f,
  1.50104523e-01f, -3.84030654e-03f, 1.05377831e-01f, 1.16072394e-01f, -1.49208412e-01f, -4.30952981e-02f, 3.28235403e-02f, -3.79998833e-02f, 5.76744415e-02f, -2.50102967e-01f,
  -5.11896610e-01f, -4.48546261e-01f, 2.23813221e-01f, 2.49606576e-02f, -4.77174409e-02f, -7.82532394e-02f, -5.82753979e-02f, -2.17728820e-02f, -1.40850702e-02f, -8.26429650e-02f,
  -6.49694428e-02f, -1.00465126e-01f, -8.48571882e-02f, 5.52683324e-02f, -4.34073247e-02f, -6.28007501e-02f, 1.67857051e-01f, 9.43795145e-02f, 6.84635937e-02f, -3.03177778e-02f,
  6.11509718e-02f, -1.11696705e-01f, -9.43236724e-02f, 1.68173358e-01f, 7.14358538e-02f, 7.96736628e-02f, -1.36155551e-02f, -7.67899156e-02f, 5.62569238e-02f, -3.01426232e-01f,
  3.46466899e-02f, 3.31994407e-02f, -7.64451455e-03f, -4.25806604e-02f, -1.80879169e-06f, -2.21985881e-03f, -4.20489386e-02f, 6.39327094e-02f, -1.65298507e-02f, 2.00439314e-03f,
  2.98456345e-02f, 3.62694189e-02f, 1.55747039e-02f, -4.28642444e-02f, -3.71807590e-02f, 3.80685623e-03f, 7.48483688e-02f, -1.25909019e-02f, 6.35944083e-02f, -2.04242971e-02f,
  -7.38560036e-03f, -3.23301852e-02f, -6.28458336e-02f, 5.58970906e-02f, 7.13841096e-02f, 6.71389699e-02f, 1.00302640e-02f, -1.36048412e-02f, -1.02481276e-01f, -2.92944927e-02f,
  -3.79041851e-01f, 4.08530414e-01f, -3.15746009e-01f, -1.22262605e-01f, -4.53661978e-02f, 3.11413519e-02f, -7.44661316e-02f, -6.83123246e-02f, -1.35110319e-01f, 1.45286079e-02f,
  -1.95400883e-02f, -5.99440113e-02f, -9.58631486e-02f, 7.72589892e-02f, 7.58290291e-02f, -1.69771761e-02f, -1.96438264e-02f, -7.43875578e-02f, 8.61129761e-02f, 1.08636590e-02f,
  -1.85250174e-02f, -7.36482739e-02f, -2.83916891e-01f, -3.48609798e-02f, -1.18675977e-01f, -1.77373797e-01f, -2.57752150e-01f, -6.85556680e-02f, -1.02104373e-01f, -2.71785080e-01f,
  -8.64510834e-01f, 2.03250989e-01f, 2.74088442e-01f, -1.89836487e-01f, 4.50089455e-01f, 4.55277860e-01f, 5.03025949e-01f, 1.27328839e-02f, -4.40531522e-02f, 1.99731141e-01f,
  -7.45546632e-03f, -2.43242383e-01f, -1.42024189e-01f, -1.35215789e-01f, -1.04257263e-01f, 3.80986810e-01f, 4.48545069e-01f, -1.38161689e-01f, -1.72407538e-01f, -9.15219411e-02f,
  -3.75804398e-03f, -2.60633856e-01f, -4.93116826e-01f, -2.25871071e-01f, 5.02963774e-02f, -6.17660806e-02f, -2.09792908e-02f, 1.30302098e-03f, 2.14506179e-01f, 1.84556857e-01f,
  7.95845091e-02f, -2.79880732e-01f, -8.99506211e-02f, -1.62764221e-01f, 4.21025716e-02f, -1.66840985e-01f, 7.47870654e-03f, -1.80809513e-01f, -2.60091648e-02f, 2.16688886e-02f,
  2.56107561e-02f, -1.08344354e-01f, 1.33209340e-02f, 2.07622908e-02f, -1.22209050e-01f, -7.45379478e-02f, -1.10549778e-01f, -2.56393969e-01f, -9.74835157e-02f, -9.31836367e-02f,
  4.53214236e-02f, 4.71724980e-02f, -5.99513873e-02f, -5.86186768e-03f, -1.35858849e-01f, -1.38293460e-01f, -7.87212104e-02f, -7.31759295e-02f, -9.39685851e-02f, -2.86040992e-01f,
  4.57695685e-02f, -5.13345711e-02f, 5.75196259e-02f, -9.80004594e-02f, 2.99468320e-02f, -3.73566942e-03f, 4.15038830e-03f, 1.04642035e-02f, -4.20505330e-02f, -1.90342423e-02f,
  -1.99776720e-02f, -1.52376564e-02f, -2.61678696e-02f, -6.03173710e-02f, 1.90553498e-02f, -1.35145467e-02f, 3.30856852e-02f, 5.08216433e-02f, 8.73744488e-03f, -1.87478606e-02f,
  -9.97121558e-02f, 3.14370357e-02f, -9.89829004e-02f, -3.40920165e-02f, 1.28606230e-01f, -6.94137579e-03f, 1.23377994e-01f, -5.88034168e-02f, 4.50497642e-02f, 3.92225273e-02f,
  -3.70059013e-01f, -1.81138050e-02f, -2.02559065e-02f, -1.49597242e-01f, 5.10739498e-02f, 7.37443846e-03f, 2.37258859e-02f, 2.25728471e-02f, 2.63023959e-03f, -8.42834041e-02f,
  4.86703627e-02f, -7.48257786e-02f, -5.14702983e-02f, -4.66794819e-02f, -2.37529296e-02f, 3.74583043e-02f, 9.34438407e-02f, 1.32722110e-02f, 6.12867717e-03f, 8.73938128e-02f,
  1.87571287e-01f, 1.75734937e-01f, 1.68996479e-03f, 5.35551421e-02f, 2.19443813e-02f, -4.28419188e-02f, 1.50301931e-02f, -3.22549557e-03f, 1.96980480e-02f, 1.83077753e-02f,
  -8.23425412e-01f, -1.56077996e-01f, -2.79604495e-01f, -9.12502766e-01f, -3.68419260e-01f, 8.34984556e-02f, 2.42732152e-01f, -1.19301580e-01f, -2.99794197e-01f, -2.72579014e-01f,
  8.27241093e-02f, 1.33439884e-01f, 2.74618976e-02f, 6.17051311e-02f, 1.37804136e-01f, -7.56344199e-02f, -3.23361427e-01f, -9.33425725e-02f, 1.54708296e-01f, 1.69262484e-01f,
  -9.15499777e-03f, -3.51815194e-01f, -3.01838428e-01f, -2.02416644e-01f, -2.57410556e-01f, -7.55670145e-02f, -3.81294101e-01f, -2.20816478e-01f, -4.61019054e-02f, -3.08073163e-01f,
  4.05936837e-01f, -2.77806640e-01f, 1.59340806e-03f, 2.99459882e-02f, -1.44357935e-01f, 7.20618712e-03f, 2.09621750e-02f, -1.68329999e-01f, -1.21186845e-01f, -1.90203097e-02f,
  -1.74300969e-01f, -2.07504872e-02f, -6.70919642e-02f, 6.68447232e-04f, -9.77943689e-02f, -5.52359037e-02f, -1.02446929e-01f, -2.04623416e-01f, -3.27456072e-02f, 5.37783615e-02f,
  2.62633655e-02f, -1.84189118e-02f, -8.00581276e-02f, 5.71298562e-02f, 4.36996371e-02f, 3.88789224e-03f, 3.55367064e-02f, -5.09671727e-03f, -6.12145178e-02f, -1.28077045e-01f,
  -2.76764240e-02f, 6.23595901e-02f, 7.96729997e-02f, 1.51810031e-02f, 7.55375251e-02f, -5.67715243e-02f, 4.17797342e-02f, 5.14865248e-03f, 6.67646453e-02f, 5.48120849e-02f,
  -3.84824835e-02f, -9.77245439e-03f, -4.27975133e-02f, -1.82711054e-02f, -2.48520132e-02f, -6.78651705e-02f, 1.08143501e-02f, 3.63698183e-03f, 2.16683727e-02f, -4.83031645e-02f,
  -2.84267515e-02f, 4.16692207e-03f, -1.30208090e-01f, 1.15925670e-01f, -2.19517630e-02f, -1.04010247e-01f, -3.08093913e-02f, 1.76966235e-01f, -6.56545982e-02f, -3.86489034e-02f,
  2.02815235e-01f, 8.48682448e-02f, 8.69594589e-02f, 9.79445949e-02f, -1.27841815e-01f, -1.12317286e-01f, 3.33659351e-02f, -4.78046834e-02f, -3.09801241e-03f, 5.86939119e-02f,
  9.93549079e-02f, 7.76789263e-02f, -5.45445308e-02f, 5.78698376e-03f, 4.71409084e-03f, 9.55610629e-03f, -7.05445856e-02f, -8.40380937e-02f, 8.82076914e-04f, 9.43456311e-03f,
  -8.48403350e-02f, 2.50590574e-02f, 9.41788033e-02f, 6.36899024e-02f, 3.67535651e-02f, 8.30479786e-02f, 2.19875157e-01f, 2.60547716e-02f, 1.60620332e-01f, 3.48671549e-03f,
  5.28140843e-01f, -8.03758442e-01f, 1.58913776e-01f, 2.68118858e-01f, 3.55262429e-01f, 2.28339568e-01f, -8.77044424e-02f, -2.01610643e-02f, 3.97376567e-01f, 5.94682954e-02f,
  -2.49813318e-01f, -5.50780119e-03f, 7.32523575e-02f, 3.11963335e-02f, -1.17894001e-01f, 9.21237189e-03f, 1.70937851e-01f, 3.31776053e-01f, 4.89134878e-01f, 1.94771215e-01f,
  9.56906155e-02f, -8.02512094e-02f, 3.38110849e-02f, 9.58159659e-03f, -5.65210357e-02f, 9.12814215e-02f, -1.11584663e-01f, -2.44349182e-01f, -1.33790180e-01f, 1.17737576e-01f,
  1.11506246e-01f, -1.83844998e-01f, 4.02715772e-01f, -1.05825819e-01f, -1.53879210e-01f, -2.25889347e-02f, 6.32518455e-02f, -3.09016602e-03f, -1.00519106e-01f, 1.55615471e-02f,
  -6.86710402e-02f, -5.64080551e-02f, -4.38942797e-02f, -9.37707201e-02f, 9.00814682e-02f, 2.38047373e-02f, -1.10928535e-01f, -1.09843895e-01f, -1.00032147e-02f, -1.15264244e-01f,
  -1.73346519e-01f, 9.54433307e-02f, -1.23450467e-02f, -1.24597639e-01f, -1.08770542e-01f, 1.78908214e-01f, -1.90959200e-01f, -4.16332521e-02f, -2.64099557e-02f, -1.61318388e-02f,
  6.52924851e-02f, 2.67508887e-02f, 1.03019387e-01f, -7.20474645e-02f, 9.87875238e-02f, 7.86952600e-02f, 7.79590905e-02f, -7.75369164e-03f, 2.91455090e-02f, 3.72205339e-02f,
  1.11150585e-01f, 7.51547813e-02f, 1.83883179e-02f, 4.98356204e-03f, 7.86865428e-02f, -7.48179480e-02f, 1.10454790e-01f, -1.00212388e-01f, -4.77285013e-02f, 6.80414885e-02f,
  1.11627050e-01f, -7.81565458e-02f, -5.27935755e-03f, -6.62087426e-02f, -3.65811698e-02f, 1.13381015e-03f, 9.18377861e-02f, -4.23176214e-02f, -6.45919004e-03f, -5.84270880e-02f,
  -1.73853099e-01f, -5.46616763e-02f, 2.25293726e-01f, 4.96020317e-02f, -1.08573791e-02f, -1.06544852e-01f, -1.20285496e-01f, -1.51300177e-01f, -1.09928079e-01f, -9.27009732e-02f,
  -2.20138401e-01f, -9.37576815e-02f, -1.35213137e-01f, -7.20414594e-02f, 1.19955719e-01f, 7.84879830e-03f, -8.34885165e-02f, 9.07482877e-02f, -1.04119577e-01f, -1.20665841e-01f,
  -2.33386859e-01f, 3.50663215e-01f, 4.37533945e-01f, 1.69767737e-01f, -5.83525114e-02f, 3.90390158e-01f, 5.77420257e-02f, 1.48881227e-01f, 1.25997141e-01f, 1.17980883e-01f,
  9.02483240e-02f, -1.74614549e-01f, -8.35049570e-01f, 4.06418473e-01f, 7.53935799e-02f, -3.02576065e-01f, -5.85978389e-01f, -2.05508590e-01f, 3.74218315e-01f, 1.06969297e-01f,
  1.41490474e-01f, 7.39554539e-02f, -1.91967085e-01f, -2.81891912e-01f, -6.83443666e-01f, -5.78743279e-01f, -5.56023061e-01f, -7.43092358e-01f, -6.89746678e-01f, -1.30514771e-01f,
  8.96333382e-02f, -6.45207316e-02f, -3.18317205e-01f, -1.35155663e-01f, 4.57760900e-01f, 2.37765521e-01f, 1.04135104e-01f, 4.23191115e-02f, -1.00693502e-01f, 1.75756201e-01f,
  -2.02234939e-01f, -1.44885063e-01f, -4.25566174e-02f, 1.75814718e-01f, 3.41917612e-02f, -2.72956695e-02f, -7.35531375e-02f, -4.45564017e-02f, 6.10399153e-03f, -1.51588963e-02f,
  9.26218405e-02f, 3.42738591e-02f, 1.58856511e-02f, -6.48212712e-03f, -1.17106915e-01f, -2.04436168e-01f, -8.36006105e-02f, -3.95262480e-01f, -2.42418081e-01f, -1.27429739e-01f,
  1.15610421e-01f, -1.11952879e-01f, -3.15364689e-01f, -3.61077078e-02f, -1.46456167e-01f, -1.43099844e-01f, -9.96298268e-02f, 5.41714318e-02f, -2.08847061e-01f, 1.29078031e-01f,
  1.82211790e-02f, 2.57372446e-02f, -3.74510372e-03f, 9.74589512e-02f, -2.18013395e-02f, 8.75534117e-02f, -6.60225600e-02f, 3.54512371e-02f, -5.82246259e-02f, 3.33387591e-02f,
  -3.32552344e-02f, 1.42803174e-02f, -3.92681845e-02f, -3.22151370e-02f, 1.28696188e-02f, -1.40265478e-02f, 2.59134769e-02f, -7.17248321e-02f, -1.18603311e-01f, -2.11209198e-03f,
  -6.03765212e-02f, -1.08823282e-04f, 3.99727970e-02f, -3.89636979e-02f, -1.55683234e-02f, -2.75004916e-02f, 4.33066525e-02f, 7.56501332e-02f, 4.06151004e-02f, 8.17205608e-02f,
  3.04120809e-01f, -5.12535036e-01f, 6.80226982e-02f, -8.53563994e-02f, -1.16294762e-03f, -3.19377817e-02f, 1.43883631e-01f, -7.44351074e-02f, 9.59774926e-02f, -5.28064854e-02f,
  -7.48815462e-02f, -5.66026606e-02f, 3.84253226e-02f, 1.56924631e-02f, -4.37986590e-02f, 2.11316571e-02f, 1.03572004e-01f, -1.08521342e-01f, -9.49116051e-02f, 7.40849301e-02f,
  4.70031314e-02f, -1.80266321e-01f, -2.89948374e-01f, -1.29463121e-01f, 5.39402477e-02f, -2.21344650e-01f, -2.39160806e-01f, -6.64400831e-02f, -3.41384351e-01f, -9.72978622e-02f,
  3.66527624e-02f, 3.96469474e-01f, 1.64218932e-01f, 3.40616584e-01f, 6.27784729e-01f, 4.94345754e-01f, 5.67660511e-01f, 2.22006291e-01f, 5.13712466e-02f, 2.57413566e-01f,
  4.79857296e-01f, 1.92122832e-01f, 9.94508117e-02f, -3.66523266e-02f, 8.59819055e-02f, 7.91790560e-02f, 1.68121420e-02f, -1.52393833e-01f, -9.97608081e-02f, -2.60500889e-02f,
  1.70450360e-01f, 1.12818852e-02f, -3.70611716e-03f, -2.24936157e-02f, 1.20500592e-03f, -6.00354038e-02f, 4.87279631e-02f, 2.62631983e-01f, 1.70345455e-01f, -1.23391367e-01f,
  -1.92141384e-02f, 4.00754839e-01f, -1.47704586e-01f, -4.77828421e-02f, 7.01286048e-02f, -3.43517989e-01f, -3.23252343e-02f, -2.79760450e-01f, -8.37206617e-02f, -1.84385672e-01f,
  3.51994485e-02f, -2.15772942e-01f, 1.03046000e-01f, -1.67110920e-01f, -9.39330235e-02f, -1.49585441e-01f, -1.18574373e-01f, -2.32878819e-01f, -9.66015011e-02f, -8.26523006e-02f,
  1.47956118e-01f, 1.84901461e-01f, 1.74398735e-01f, -1.40832579e-02f, 1.49903670e-01f, -7.19601586e-02f, 9.14086998e-02f, -1.89592317e-02f, -7.36598447e-02f, -2.65280843e-01f,
  -4.75533307e-03f, 4.42842655e-02f, 6.84340745e-02f, 1.54175400e-03f, 7.05201775e-02f, 2.48133708e-02f, -3.18088615e-03f, 1.00692265e-01f, 5.14593534e-02f, 3.21183242e-02f,
  -2.28383616e-02f, 6.21752776e-02f, -2.99130455e-02f, -3.45963277e-02f, -7.03651235e-02f, 8.81026387e-02f, 1.47627667e-04f, -7.87622109e-02f, 8.51752236e-02f, -2.52363253e-02f,
  -1.20033026e-02f, 8.97891149e-02f, -4.23621945e-02f, 3.06493919e-02f, -6.55194446e-02f, -7.71011366e-03f, -6.77705854e-02f, 5.54886386e-02f, 1.84610337e-02f, -3.59563567e-02f,
  -1.47733644e-01f, 2.99201250e-01f, -5.61080240e-02f, -1.38093621e-01f, 1.16315834e-01f, -3.04666646e-02f, 1.05813935e-01f, -1.30469084e-01f, 1.66520420e-02f, -8.56901035e-02f,
  1.90846100e-01f, -2.60668490e-02f, 1.14351444e-01f, 4.51396070e-02f, -6.79087192e-02f, -9.13079828e-02f, 5.38131371e-02f, 4.18198146e-02f, 8.26993212e-02f, -6.54127747e-02f,
  5.34382798e-02f, -1.10934049e-01f, -1.53873071e-01f, -6.01083823e-02f, 1.22289807e-02f, -5.95473172e-03f, -1.07216209e-01f, -1.47706434e-01f, -1.13152564e-01f, -4.06272620e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  7.44258702e-01f, 4.09331441e-01f, 4.45139170e-01f, 7.31762648e-01f, 4.58738148e-01f, 4.24112201e-01f, 4.80487704e-01f, 2.18796581e-01f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -1.15137279e+00f, 3.28880727e-01f, -3.59917641e-01f, -8.73678684e-01f, 6.29297048e-02f, 4.10941184e-01f, 4.36924472e-02f, -1.40193269e-01f, -4.78859842e-01f, -2.19954774e-01f,
  5.40543437e-01f, -8.93226027e-01f, 4.61479872e-01f, -3.20283324e-01f, 8.37392867e-01f, -1.78310812e-01f, 4.38663065e-01f, 4.71973240e-01f, 2.03915372e-01f, 3.21818829e-01f,
  -1.10366464e+00f, 2.55001068e-01f, -8.61125112e-01f, -9.91751909e-01f, -5.60682118e-01f, -3.94223958e-01f, -4.14287955e-01f, -7.84449399e-01f, 6.30827785e-01f, 7.92074561e-01f,
  -2.24578157e-01f, 7.35387385e-01f, -4.57485110e-01f, 5.78882217e-01f, 1.16687998e-01f, 5.14224648e-01f, -1.03591561e+00f, -2.10497618e-01f, 1.46984756e-01f, 5.15892208e-01f,
  -4.34816152e-01f, 7.06629157e-01f, 1.17362857e+00f, -4.03431326e-01f, -3.94328833e-01f, -2.51549304e-01f, -6.67284489e-01f, -6.50939167e-01f, 7.00367102e-03f, -2.47941613e-01f,
  -2.19674885e-01f, -6.44316614e-01f, -5.58425337e-02f, -6.09113336e-01f, 6.09259427e-01f, -3.77998829e-01f, -2.93687820e-01f, -4.05239046e-01f, 6.41845763e-01f, 9.82518196e-01f,
  7.57240355e-01f, 2.06369869e-02f, -4.21152264e-01f, -1.14903748e-01f, 8.90796408e-02f, -7.50584602e-01f, -6.46776259e-01f, 6.69966459e-01f, -1.06054574e-01f, -1.03854871e+00f,
  3.33971292e-01f, -6.40684605e-01f, -3.30154598e-01f, -2.06798151e-01f, -5.74563742e-01f, -9.41404626e-02f, -2.74532765e-01f, 2.04286888e-01f, 1.36794376e+00f, -1.52097151e-01f,
  5.69581449e-01f, 5.98454237e-01f, 5.28263748e-01f, 4.71963257e-01f, 6.17914021e-01f, 8.72615874e-01f, -4.17689353e-01f, -6.53960347e-01f, 1.29563570e+00f, -4.52149689e-01f,
  -2.63081342e-01f, -4.89912778e-01f, -3.83698851e-01f, -2.63421297e-01f, 6.66116834e-01f, 1.96782723e-02f, 8.16055834e-01f, -2.49311417e-01f, 5.68301976e-01f, -4.43315387e-01f,
  8.48903954e-01f, 7.71354556e-01f, 1.15020633e-01f, 1.02186191e+00f, -3.39861423e-01f, 1.11888325e+00f, -3.92846912e-01f, -5.47387660e-01f, -4.50055808e-01f, -6.20450526e-02f,
  -7.45559275e-01f, -4.12894070e-01f, 7.27108121e-02f, -5.25537848e-01f, -4.77632850e-01f, -1.84016347e-01f, 4.89512123e-02f, 3.02069664e-01f, -3.80170941e-01f, 3.26461554e-01f,
  8.20928216e-01f, 2.04077467e-01f, 5.49932480e-01f, 7.47129619e-01f, -3.06078970e-01f, -1.38811365e-01f, -2.41931200e-01f, 4.99289811e-01f, -5.48863590e-01f, 4.58356202e-01f,
  -2.90872633e-01f, 1.60623506e-01f, 8.45025539e-01f, -3.00292671e-01f, -7.96138585e-01f, 4.25117999e-01f, 1.56330973e-01f, -4.01090920e-01f, 1.64513990e-01f, 4.93809104e-01f,
  -5.89312375e-01f, 1.35547280e+00f, -1.96619049e-01f, -4.13822889e-01f, -2.15091277e-02f, 2.43600041e-01f, 8.63321722e-02f, -7.83982217e-01f, -1.02512431e+00f, -2.77719200e-02f,
  3.55807543e-01f, 8.33742261e-01f, -4.83501196e-01f, 6.93416417e-01f, -4.95328516e-01f, 4.27998006e-02f, -8.60859156e-01f, 2.37109959e-01f, 9.33762968e-01f, 2.07442448e-01f,
  2.67836511e-01f, -8.81935596e-01f, 1.15335539e-01f, 1.56443894e-01f, -1.49928838e-01f, -7.26209581e-01f, -3.85787576e-01f, -2.09313110e-01f, 9.14762020e-01f, -3.44807237e-01f,
  -2.47813717e-01f, 9.70355496e-02f, 9.49224532e-01f, -1.65180296e-01f, -8.49297404e-01f, -1.74379110e-01f, -2.30859742e-01f, 4.15839434e-01f, 5.02130985e-01f, 5.37099063e-01f,
  8.95889282e-01f, -9.37602669e-02f, 4.66580987e-01f, -1.52436756e-02f, -5.50116241e-01f, -5.04464447e-01f, -2.24470183e-01f, 1.68522537e-01f, -2.34069496e-01f, -8.79065335e-01f,
  -4.39619571e-01f, 1.21838963e+00f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -4.86061186e-01f, 7.20323503e-01f, 9.30132940e-02f, -8.49918202e-02f, -1.28372863e-01f, 2.66023707e-02f, 7.16414675e-02f, -6.71281040e-01f, -1.27486914e-01f, -1.15464211e-01f,
  -4.01394129e-01f, 2.21927196e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    