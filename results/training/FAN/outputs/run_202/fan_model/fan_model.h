/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -9.99424532e-02f, -1.04146980e-01f, -1.26695797e-01f, 8.62745792e-02f, 3.32075119e-01f, 5.24520874e-01f, 1.57576635e-01f, 2.47609630e-01f, 2.90423781e-01f, -3.38148586e-02f,
  1.32655531e-01f, -1.05275847e-01f, -1.93772137e-01f, 2.33594045e-01f, 1.58542335e-01f, 5.74682914e-02f, 2.84403473e-01f, 3.08782458e-02f, 8.08898509e-02f, 3.89434509e-02f,
  1.24094956e-01f, 2.17030957e-01f, -7.48625100e-02f, 1.14670999e-01f, 4.81305160e-02f, -1.10582821e-01f, -1.42341465e-01f, -1.56463966e-01f, -3.95073406e-02f, 4.45369706e-02f,
  -9.34723094e-02f, -1.14592098e-01f, 5.05472440e-03f, -2.14102981e-03f, 4.73409481e-02f, 1.31498603e-02f, -6.07206337e-02f, -6.49190843e-02f, -6.72830194e-02f, -1.56614985e-02f,
  -4.61543761e-02f, -1.09720509e-03f, 7.71821067e-02f, 1.18667341e-03f, 7.07449093e-02f, 9.50325653e-03f, 1.54434582e-02f, -8.27173796e-03f, 1.22304866e-02f, -3.20224874e-02f,
  2.32779719e-02f, 3.30037847e-02f, 2.97507066e-02f, 1.46916602e-02f, 2.75793648e-03f, 3.40543464e-02f, -2.35355478e-02f, -9.38975811e-03f, 3.99829261e-02f, 7.08695129e-02f,
  -1.22908438e-02f, 1.01112574e-02f, -2.38083154e-02f, -2.43017096e-02f, -2.22557858e-02f, -3.06844655e-02f, -1.87371764e-02f, 5.66843944e-03f, -3.38338800e-02f, 3.20531353e-02f,
  6.83185011e-02f, -2.43162904e-02f, 9.37550813e-02f, 3.97823118e-02f, -9.64015315e-04f, 2.72681788e-02f, -3.55868377e-02f, 1.24364235e-02f, 7.00928047e-02f, 7.18482817e-03f,
  -1.05992015e-02f, 5.84172308e-02f, -1.79675035e-02f, -5.84398173e-02f, 3.51620726e-02f, -9.35914274e-03f, 7.03797862e-02f, -1.11411558e-02f, -6.15169900e-03f, 1.14598079e-02f,
  4.01616655e-03f, 1.00974634e-01f, 8.49792138e-02f, 1.23177737e-03f, -4.72694896e-02f, 5.26346490e-02f, 5.15895821e-02f, 3.57375443e-02f, 3.27604525e-02f, 5.20327836e-02f,
  6.06765635e-02f, -3.61463614e-02f, -2.40573380e-02f, -4.65009660e-02f, -4.60399948e-02f, 9.31387488e-03f, -1.37857965e-03f, 4.02309671e-02f, 9.82865468e-02f, -3.51773924e-03f,
  -5.76629974e-02f, -4.55099344e-02f, -2.36576423e-02f, 2.74189785e-02f, 3.40393595e-02f, 9.03333165e-03f, 2.84973215e-02f, 2.38617565e-02f, -2.71662120e-02f, 5.84617406e-02f,
  -5.92067182e-01f, -3.21797788e-01f, -2.50101030e-01f, -4.88723814e-01f, -6.21780306e-02f, 1.10705150e-02f, -8.53065215e-03f, -2.29275331e-01f, -2.83542067e-01f, 1.41664757e-03f,
  2.57573649e-02f, -1.26275912e-01f, 4.76033203e-02f, -2.82667518e-01f, -1.89263988e-02f, -7.89620541e-03f, -1.36892602e-01f, -9.67823863e-02f, -1.42201707e-01f, -2.43586838e-01f,
  -1.18192799e-01f, -1.15787454e-01f, -2.04451159e-02f, -7.71348774e-02f, -6.90715834e-02f, -1.84754685e-01f, 8.00247341e-02f, 2.59612855e-02f, -2.14189775e-02f, 7.84937143e-02f,
  4.85741682e-02f, -1.22089967e-01f, -6.20580465e-02f, -2.85627358e-02f, 4.37635276e-03f, 7.80047625e-02f, 7.32567236e-02f, 4.87115122e-02f, -4.27558385e-02f, -2.82178875e-02f,
  1.64440330e-02f, 1.26923658e-02f, -2.15474088e-02f, -1.45334695e-02f, -5.07403687e-02f, -7.21372291e-02f, -1.56972911e-02f, 1.31086819e-02f, -2.98586208e-02f, 3.66087332e-02f,
  -2.30313726e-05f, 2.81651523e-02f, -1.72606818e-02f, 3.73471454e-02f, 7.27574388e-03f, -6.07034266e-02f, 3.44280973e-02f, 9.47943255e-02f, -2.26083081e-02f, -2.06104852e-02f,
  2.32709572e-02f, -9.89205204e-03f, -2.20145509e-02f, 1.31699266e-02f, -4.30007651e-02f, 3.11514605e-02f, -5.03925867e-02f, 4.44457009e-02f, -3.86986993e-02f, 2.92945057e-02f,
  -3.11604980e-02f, -6.63497597e-02f, -2.98190508e-02f, -7.38094375e-03f, -1.06743220e-02f, -4.31241980e-03f, -1.80842746e-02f, 3.23800221e-02f, -2.86658555e-02f, 3.03299865e-03f,
  1.46815255e-02f, -2.33359467e-02f, -3.50181339e-03f, 4.81343567e-02f, 1.21301804e-02f, 2.34420691e-02f, -9.66525823e-03f, 4.58898209e-03f, -2.44835131e-02f, 4.60128151e-02f,
  6.24586195e-02f, -5.82476482e-02f, 1.38851516e-02f, -1.28281340e-02f, -1.06951427e-02f, 1.88607965e-02f, -4.38710637e-02f, -3.94921936e-02f, 9.42846091e-05f, -2.16130307e-03f,
  4.10944074e-02f, -4.47152518e-02f, 2.65131872e-02f, 8.30951892e-03f, -1.73483957e-02f, 4.17366885e-02f, 3.17057199e-03f, 1.49994576e-02f, 1.12192659e-02f, -1.98727306e-02f,
  1.60778388e-02f, 1.47464813e-03f, 1.09080933e-02f, -5.71307354e-03f, -8.51167180e-03f, 6.98092952e-02f, -2.37655677e-02f, -2.53679212e-02f, 5.72496317e-02f, -6.11574296e-03f,
  1.09290201e-02f, -2.91431308e-01f, -2.61029810e-01f, -1.34835495e-02f, 2.90199220e-01f, 2.70372778e-01f, 9.68420431e-02f, 3.13694105e-02f, -2.06036732e-01f, 9.31303296e-03f,
  2.67808110e-01f, -2.71477818e-01f, -1.05242059e-01f, 2.12156162e-01f, -4.91902381e-02f, -1.64047137e-01f, 1.30934775e-01f, -4.22651395e-02f, -5.31488918e-02f, 3.96668091e-02f,
  2.20451131e-02f, 2.74837077e-01f, 6.30210191e-02f, 1.62171885e-01f, 1.79145440e-01f, -1.24681249e-01f, 1.53099909e-01f, 3.11476551e-02f, 1.55960709e-01f, -2.77410895e-02f,
  1.33615375e-01f, -3.10922116e-02f, 1.60283335e-02f, -9.06929076e-02f, 5.46663776e-02f, 2.51712315e-02f, 4.63542007e-02f, 5.93054779e-02f, 6.53668568e-02f, -3.47252600e-02f,
  -1.15427570e-02f, 1.30474307e-02f, -1.93147901e-02f, -1.88498143e-02f, 4.87618186e-02f, 8.71854182e-03f, 3.77320163e-02f, 3.80655602e-02f, -3.15157659e-02f, 3.61819366e-05f,
  -1.95830353e-02f, 5.85911470e-03f, 7.29095265e-02f, -5.49133681e-02f, -1.66290067e-02f, 1.58696380e-02f, -3.22801135e-02f, -6.18893579e-02f, -9.50217843e-02f, -5.51162548e-02f,
  3.14364918e-02f, -3.88326868e-02f, 2.37013996e-02f, 1.98107865e-02f, 2.99506169e-02f, 4.13286798e-02f, 6.95533380e-02f, -3.23681859e-03f, -4.33088131e-02f, 3.78762968e-02f,
  2.52481047e-02f, 5.55520505e-03f, 2.22725384e-02f, -1.08887339e-02f, 2.82074849e-04f, -1.96625255e-02f, 4.08464763e-03f, -7.82443658e-02f, -2.21196134e-02f, 2.38004830e-02f,
  -5.76361082e-04f, -2.10822020e-02f, -7.84602761e-03f, 3.25845517e-02f, -1.82723477e-02f, -4.41222563e-02f, -3.15248631e-02f, -4.28743549e-02f, 2.75670290e-02f, 6.90112785e-02f,
  -1.98537088e-03f, -2.58457989e-01f, -6.99301362e-02f, 5.63604161e-02f, -3.26819606e-02f, 2.28224508e-02f, -2.03943346e-02f, -2.47258805e-02f, -5.03465161e-02f, 2.03586556e-02f,
  4.51323837e-02f, 1.16086835e-02f, -2.69163623e-02f, 5.88015504e-02f, -1.19590806e-02f, 1.03235329e-02f, -3.34870964e-02f, 8.62700306e-03f, 3.89274061e-02f, 2.35179178e-02f,
  4.50988598e-02f, 4.19195443e-02f, -1.06484637e-01f, 1.57660786e-02f, 1.30886296e-02f, 3.70171182e-02f, 9.31268837e-03f, -4.71025258e-02f, 5.32831736e-02f, -2.76838373e-02f,
  -4.85695451e-01f, 4.77155149e-02f, -1.40329808e-01f, -3.42834145e-01f, -2.42561698e-01f, 1.66336253e-01f, 2.66437441e-01f, -1.78340256e-01f, -1.10434860e-01f, 2.87008286e-01f,
  1.12116612e-01f, -2.11723924e-01f, 2.78982371e-01f, -6.13416284e-02f, -1.47707626e-01f, 3.07489842e-01f, 6.94927573e-03f, -4.92659491e-03f, -1.10980608e-01f, -1.35867119e-01f,
  -2.02193245e-01f, 1.71029970e-01f, -6.12876676e-02f, 1.57454275e-02f, -1.23176180e-01f, -1.94267571e-01f, -8.35776329e-02f, 1.14832306e-02f, -1.01582021e-01f, 4.88158874e-02f,
  3.22681069e-02f, 5.79671003e-02f, -1.01388209e-01f, 2.80485116e-02f, -1.86250955e-02f, -5.76213561e-03f, -1.83359329e-02f, 6.01144088e-03f, -9.47152451e-02f, 2.08333768e-02f,
  3.16014439e-02f, 8.57207552e-03f, 4.36106464e-03f, -8.74228962e-03f, -4.45943587e-02f, -5.76226264e-02f, -5.63105494e-02f, -5.25497161e-02f, -1.62083842e-02f, 9.12244245e-03f,
  6.32976368e-03f, -1.43526737e-02f, -4.45009395e-02f, 7.27106035e-02f, -5.83689250e-02f, -2.92931516e-02f, 2.63417773e-02f, -7.15057505e-03f, -1.84964426e-02f, -5.78962080e-02f,
  5.96371144e-02f, 1.66694019e-02f, 1.99071877e-02f, 6.03746995e-03f, -2.56593060e-02f, 1.13935617e-03f, -1.02985865e-02f, 1.51049858e-02f, -4.16329950e-02f, 3.90471183e-02f,
  -2.27647759e-02f, -5.36960512e-02f, 5.75586571e-04f, 1.47412308e-02f, -1.60816673e-03f, 6.08096737e-03f, 6.27469365e-03f, 2.04728041e-02f, -5.80901047e-03f, -6.64551929e-02f,
  1.39776776e-02f, -2.42629442e-02f, 9.47602466e-03f, 2.53762826e-02f, 4.57270928e-02f, -1.95425991e-02f, -5.57000237e-03f, -2.04602666e-02f, -2.79594772e-02f, 3.86325568e-02f,
  8.32676515e-02f, 5.73093109e-02f, -2.19638459e-03f, -1.06861442e-02f, 2.03851182e-02f, -1.02213891e-02f, 4.35637049e-02f, -4.97630648e-02f, 3.54884937e-02f, 2.30546910e-02f,
  -3.22009958e-02f, -3.12794186e-02f, 1.01360669e-02f, -8.13235343e-03f, -3.65653709e-02f, 4.13850732e-02f, 6.56994730e-02f, -3.50557007e-02f, -2.94007584e-02f, -5.09962291e-02f,
  -1.43571459e-02f, 3.33656222e-02f, -1.51124252e-02f, -3.25803086e-02f, 2.55301921e-03f, 4.45152521e-02f, -7.50719979e-02f, 7.05146603e-03f, 1.09917428e-02f, 4.46902141e-02f,
  -8.60042498e-02f, -1.65762916e-01f, 2.22871173e-02f, 1.73838481e-01f, -2.80793637e-01f, -6.40685707e-02f, 3.91621798e-01f, -2.71973968e-01f, 1.96864158e-01f, -6.09192699e-02f,
  7.71174729e-02f, 1.89710274e-01f, 1.55983686e-01f, 1.21570863e-01f, 5.24045467e-01f, 3.39064389e-01f, 2.65835017e-01f, 1.11207210e-01f, 2.33282223e-02f, -1.02151809e-02f,
  8.40958431e-02f, -5.72370961e-02f, 1.53017670e-01f, -3.34852219e-01f, -2.51252085e-01f, -2.07678154e-01f, -7.13554174e-02f, -9.75789651e-02f, -1.73522025e-01f, 5.85708814e-03f,
  1.91946719e-02f, -8.99130702e-02f, -3.12405527e-02f, 4.55218181e-02f, -8.90107080e-03f, -2.88225953e-02f, 9.39547922e-03f, 2.03411337e-02f, 4.06549871e-02f, 3.71988327e-03f,
  4.42217402e-02f, -1.90426894e-02f, -3.51628941e-03f, -2.84360945e-02f, -4.35549989e-02f, 9.22097918e-03f, -3.07526924e-02f, -3.83068472e-02f, -3.71764489e-02f, -3.16179730e-02f,
  1.62623990e-02f, 9.16547235e-03f, 5.22308936e-03f, 3.80344763e-02f, 3.67303938e-02f, 1.83466282e-02f, 1.78098883e-02f, -2.27804575e-02f, -3.54770944e-02f, -5.56571111e-02f,
  -2.99934763e-02f, -1.52895832e-03f, 2.17241868e-02f, -3.78682949e-02f, 8.88161920e-03f, -4.19096947e-02f, 2.59472169e-02f, 3.76951625e-03f, -1.98438298e-02f, -1.00971451e-02f,
  -1.33709182e-04f, 4.19255905e-03f, -6.14003325e-03f, -1.78396981e-02f, 2.83852164e-02f, -3.18903960e-02f, 3.87229621e-02f, -2.76682619e-02f, 3.94066237e-02f, -8.92383512e-03f,
  1.58641413e-02f, -4.14360408e-03f, 7.77899893e-03f, -2.94529777e-02f, 6.39622100e-03f, 9.46654473e-03f, -6.42546564e-02f, -5.47617786e-02f, -1.27000473e-02f, 1.43872723e-02f,
  1.47173315e-01f, 5.98474033e-02f, 1.29363006e-02f, -3.74519303e-02f, 2.55280267e-02f, -1.74239632e-02f, 5.08127995e-02f, -3.71771753e-02f, 2.08594222e-02f, -1.47917438e-02f,
  -7.98604712e-02f, 2.26580771e-03f, -5.22067286e-02f, -2.04678997e-02f, 1.87039115e-02f, -2.72708163e-02f, 6.77273795e-02f, 2.98038032e-02f, 3.32951806e-02f, -1.73699562e-04f,
  -3.41304950e-02f, -1.45800319e-02f, 1.70323197e-04f, -6.14789464e-02f, -4.58142720e-02f, 5.10394247e-03f, -9.71930381e-03f, 1.54024679e-02f, 2.33485494e-02f, 5.90154082e-02f,
  8.42836857e-01f, -3.84682924e-01f, -7.08063692e-02f, 1.50672883e-01f, 2.16477588e-01f, 3.01583875e-02f, 9.31891501e-02f, 9.02564730e-03f, 1.08712047e-01f, -2.01019660e-01f,
  1.34920165e-01f, -5.16214967e-02f, -2.91392822e-02f, -1.69808403e-01f, 4.31192935e-01f, -9.69785377e-02f, 2.08710823e-02f, -1.82845090e-02f, -2.47532688e-02f, 2.70845667e-02f,
  1.67645156e-01f, 8.95215943e-03f, -1.35509698e-02f, -4.42541242e-02f, 3.98291536e-02f, 4.31474932e-02f, 9.68352780e-02f, -4.64104190e-02f, -7.17577264e-02f, 3.87869067e-02f,
  5.23271039e-02f, 6.89118132e-02f, -8.52992237e-02f, -1.44596095e-03f, 8.62529278e-02f, 5.51793613e-02f, 6.77942066e-03f, -1.66518416e-03f, 8.03119037e-03f, 3.68679920e-03f,
  -3.41759808e-02f, 3.25465314e-02f, -5.17536467e-03f, -5.21757044e-02f, -1.83358695e-02f, 3.59427044e-03f, -2.05076188e-02f, -5.24756908e-02f, -6.58735633e-02f, -1.12189800e-02f,
  -6.53351247e-02f, 1.11683812e-02f, -1.77924335e-02f, 6.29656762e-03f, 2.79688686e-02f, -3.46038747e-03f, 2.87714805e-02f, 1.97414681e-02f, -2.57882737e-02f, 6.44806772e-02f,
  1.05057150e-01f, 1.09487541e-01f, -6.65715411e-02f, 3.83403189e-02f, -5.13118245e-02f, 7.08759874e-02f, -6.06208630e-02f, 4.86324169e-02f, 3.75445088e-04f, 5.32258712e-02f,
  5.48840836e-02f, -2.45440137e-02f, 4.51370701e-02f, -1.67671253e-03f, 2.81071989e-03f, 2.61030979e-02f, -3.05466056e-02f, 4.64646444e-02f, -3.43313925e-02f, 5.28597198e-02f,
  1.78779457e-02f, -1.13923941e-02f, -3.20974030e-02f, 2.44864747e-02f, 6.18418269e-02f, 9.03279148e-03f, 8.36352352e-03f, -1.36614451e-02f, -3.61657999e-02f, 5.26534021e-02f,
  5.02685867e-02f, 3.01821828e-01f, 7.16530718e-03f, 2.72071641e-02f, -7.16360360e-02f, -5.85628301e-02f, -2.21926160e-03f, -2.12505423e-02f, -3.50881442e-02f, 5.97011074e-02f,
  1.14092184e-02f, 2.21103057e-03f, 7.40854517e-02f, 6.02536974e-03f, -8.84012226e-03f, 4.50745299e-02f, 6.68030931e-03f, -7.22451927e-03f, 7.27734417e-02f, -2.68064276e-03f,
  4.66741957e-02f, -1.08555406e-02f, 4.76349816e-02f, 1.93261784e-02f, 1.47408303e-02f, 4.52197343e-02f, -1.28385406e-02f, -4.83937636e-02f, 6.58943579e-02f, -8.21990445e-02f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.24764013e-01f, 6.07932732e-03f, -3.48082840e-01f, -4.12346512e-01f, 4.18379456e-02f, -7.05191374e-01f, -5.44817626e-01f, -5.53237349e-02f, 1.45458415e-01f, -2.11047351e-01f,
  -2.00792268e-01f, -2.43069991e-01f, 3.06105614e-01f, -4.75844294e-01f, -7.47916624e-02f, 2.01008156e-01f, -6.21537626e-01f, -4.82872546e-01f, 2.95332521e-01f, -3.15824211e-01f,
  -2.64377147e-03f, -1.00306325e-01f, -8.95213708e-02f, 1.83188826e-01f, -2.87491858e-01f, 8.85128081e-02f, 1.71119213e-01f, 2.99080729e-01f, -3.02536160e-01f, 1.30020171e-01f,
  -7.25379661e-02f, 2.42571443e-01f, -8.10213536e-02f, -2.66512539e-02f, -1.39367059e-01f, -2.28047609e-01f, -1.54557541e-01f, 6.20794017e-03f, 5.40901087e-02f, -4.39979360e-02f,
  -1.01207219e-01f, 2.83562150e-02f, -8.33883062e-02f, 1.30892828e-01f, -6.55819988e-03f, -9.21701826e-03f, 4.05107439e-02f, -3.35525232e-03f, -7.72528816e-03f, -7.51524344e-02f,
  -1.08624876e-01f, -1.25958994e-01f, -1.98173568e-01f, -2.47692801e-02f, -3.40933502e-02f, -3.93349398e-03f, -1.37545750e-01f, -5.60522787e-02f, -9.41551998e-02f, -7.02060908e-02f,
  2.40940470e-02f, 9.31601040e-03f, -5.58739826e-02f, 7.06492662e-02f, -6.27713874e-02f, 1.29055679e-02f, -2.73857713e-02f, 2.06554364e-02f, 5.93577400e-02f, -6.16065525e-02f,
  -6.39934242e-02f, 1.65060982e-02f, 5.93542717e-02f, -1.52834177e-01f, -1.57401208e-02f, -1.30507518e-02f, -1.60760246e-02f, -2.74186791e-03f, -5.19114397e-02f, -2.16529630e-02f,
  5.05020022e-02f, -5.57063632e-02f, 3.56774777e-02f, 4.65291776e-02f, -4.22228798e-02f, 3.67404409e-02f, -2.83327978e-02f, -2.03273017e-02f, 2.28625108e-02f, 8.38154578e-04f,
  -7.83752054e-02f, -1.20855652e-01f, 2.77456846e-02f, 3.52347791e-02f, -3.84771475e-03f, -9.42788199e-02f, -5.91178797e-02f, -6.25428855e-02f, -6.91337213e-02f, 1.45066222e-02f,
  -1.15477748e-01f, -5.40749133e-02f, -6.83471709e-02f, -2.09379126e-03f, 3.00474409e-02f, -1.83288436e-02f, -7.73893297e-02f, -3.95558439e-02f, -8.11939910e-02f, -4.90839481e-02f,
  -7.13619404e-03f, -2.80605629e-03f, -6.68005599e-03f, 4.69973348e-02f, -7.34077170e-02f, -1.18653893e-01f, 2.17200350e-02f, 3.05003747e-02f, -2.80632507e-02f, -2.76720785e-02f,
  1.56955570e-01f, -1.11563452e-01f, -6.97836578e-01f, 2.00496957e-01f, -1.72420800e-01f, -1.21813059e-01f, -2.77059108e-01f, 2.06476878e-02f, -5.35856307e-01f, 2.12476686e-01f,
  3.63458097e-01f, -8.25723559e-02f, -1.44619107e-01f, 8.78231287e-01f, 4.81778264e-01f, 1.52992234e-01f, 6.62372053e-01f, 3.69520813e-01f, -5.75972274e-02f, 1.33856520e-01f,
  2.36572683e-01f, 9.09982562e-01f, 3.36470097e-01f, 3.82676214e-01f, 2.60451347e-01f, 1.16883703e-02f, 5.02183557e-01f, -3.20035219e-01f, 5.53340852e-01f, 2.79764175e-01f,
  1.07476510e-01f, 1.78512800e-02f, -1.53640583e-01f, -1.14664756e-01f, -1.43502383e-02f, -1.85851268e-02f, -1.14095509e-01f, -1.68483481e-02f, -8.31411406e-02f, -9.46826562e-02f,
  -1.26513645e-01f, 3.89864668e-02f, 1.81724615e-02f, -4.81572486e-02f, -6.05124086e-02f, -3.65975015e-02f, -7.03500211e-02f, -7.81514123e-02f, -1.41477868e-01f, -8.93109664e-02f,
  -2.42097452e-01f, 2.64228359e-02f, -9.90795195e-02f, 2.61549186e-02f, -1.25560760e-01f, -1.30121941e-02f, -2.70770341e-02f, -4.98525612e-02f, -3.03493775e-02f, -5.22973295e-03f,
  1.31073102e-01f, -5.68728708e-02f, 6.44438416e-02f, 3.13187540e-02f, 8.81481916e-02f, 6.79422589e-03f, 6.32362291e-02f, 2.34178286e-02f, -3.07194646e-02f, 5.84631227e-02f,
  -1.04993470e-02f, 6.77582109e-03f, -1.63339954e-02f, 5.11729065e-03f, 2.29290910e-02f, 1.64817995e-03f, 4.75773960e-02f, 1.15809523e-01f, -1.14152081e-01f, 2.07618158e-02f,
  3.11988182e-02f, 2.31769178e-02f, -1.46824028e-02f, 5.98266767e-03f, 1.94670781e-02f, 1.39414053e-02f, 1.31559208e-01f, 2.41262317e-02f, -6.68724999e-02f, -3.93166505e-02f,
  6.71049431e-02f, 1.49317026e-01f, -1.05890490e-01f, -7.03799799e-02f, 1.74658038e-02f, 4.04860787e-02f, 4.69814911e-02f, 3.60086001e-02f, 6.18310608e-02f, -3.63847874e-02f,
  1.05171483e-02f, -6.99616522e-02f, 9.77602135e-03f, 3.95120941e-02f, -8.73329060e-04f, 4.31043620e-04f, 7.20383823e-02f, -1.41396830e-02f, 9.70952809e-02f, 1.27720937e-01f,
  2.56317556e-02f, -8.38867277e-02f, 4.97433506e-02f, -8.36917311e-02f, 7.34204873e-02f, -1.80853810e-02f, -4.39939648e-02f, -8.68662223e-02f, 3.87130529e-02f, 8.31052754e-03f,
  -4.29751307e-01f, -1.53350815e-01f, -8.00956562e-02f, 4.80746180e-02f, 8.49636912e-04f, -1.33067235e-01f, -2.81367064e-01f, -8.91852751e-02f, -3.85099411e-01f, -5.44903893e-03f,
  6.76999148e-03f, -2.89154589e-01f, -1.81548879e-01f, -2.12213084e-01f, -1.53241783e-01f, -3.78654182e-01f, -1.36355624e-01f, -1.11083888e-01f, -2.91366547e-01f, 2.53327459e-01f,
  1.08178481e-01f, 5.92410415e-02f, 1.21648289e-01f, 3.11040401e-01f, 9.13749337e-02f, 5.15079558e-01f, 6.73478663e-01f, 2.81760037e-01f, 4.86966550e-01f, 1.16690442e-01f,
  -3.22645575e-01f, -2.11513236e-01f, -1.39008403e-01f, -9.53489020e-02f, 1.19270205e-01f, -2.54512411e-02f, 1.42168775e-01f, -4.48366739e-02f, -2.39551850e-02f, -2.51769815e-02f,
  -8.17234069e-03f, -1.90418493e-02f, -2.58702338e-02f, -4.11663838e-02f, -6.73110187e-02f, 3.41012403e-02f, -1.63457189e-02f, -1.69827174e-02f, -8.80540833e-02f, -1.55149370e-01f,
  -1.67052746e-01f, 5.91079704e-03f, 7.16008469e-02f, 1.05024360e-01f, 1.01646125e-01f, 7.79535016e-03f, 1.94614455e-02f, 1.15344569e-01f, 6.17159642e-02f, -1.21782739e-02f,
  8.39108601e-02f, 6.45342991e-02f, 1.82662588e-02f, -1.05380058e-01f, 5.06150275e-02f, -8.27818830e-03f, -5.78620611e-03f, 1.66338570e-02f, 2.14646738e-02f, 4.99238865e-03f,
  6.03168122e-02f, 2.46865265e-02f, -7.09771514e-02f, 4.94976342e-02f, 7.15996251e-02f, -6.32708594e-02f, -3.59771326e-02f, 5.55588938e-02f, 4.89422157e-02f, -3.11755743e-02f,
  -5.19545414e-02f, 1.75326411e-02f, 4.86413948e-02f, 6.14335462e-02f, -1.04311652e-01f, 5.34491390e-02f, 6.76861405e-02f, -5.64050525e-02f, -1.98148359e-02f, 6.00617155e-02f,
  2.47924849e-01f, 6.97899103e-01f, 2.60502882e-02f, -5.18307537e-02f, -5.62688522e-02f, -2.42404523e-03f, -2.77057998e-02f, -4.50191163e-02f, 1.49909124e-01f, -7.27111176e-02f,
  1.85619310e-01f, 4.27322648e-02f, 8.30132365e-02f, -3.64663601e-02f, 2.26405803e-02f, 3.18517946e-02f, 2.01051325e-01f, 1.69902727e-01f, 1.80365577e-01f, 1.47148043e-01f,
  1.39503598e-01f, 2.48915702e-02f, -1.51607534e-03f, 8.41005594e-02f, 5.92017360e-02f, 6.06795885e-02f, 8.66935551e-02f, 8.44157785e-02f, 4.31336388e-02f, -2.41430160e-02f,
  -5.73207177e-02f, -1.01111197e+00f, 3.50131959e-01f, -1.65058613e-01f, 3.26050431e-01f, 3.11901510e-01f, 3.29197496e-01f, -2.28881210e-01f, -4.36127663e-01f, -7.93070257e-01f,
  -1.56344593e-01f, -1.12702958e-01f, -1.25633497e-02f, -1.16164029e-01f, 8.55415523e-01f, 7.22569227e-03f, -1.10937051e-01f, -1.33136868e-01f, 1.53230438e-02f, -3.27170551e-01f,
  9.58890170e-02f, -9.61766243e-02f, 3.78451645e-01f, -8.47003087e-02f, 2.07462301e-03f, -1.23373009e-01f, 1.08591013e-01f, 2.48144448e-01f, -3.88739333e-02f, 3.63233358e-01f,
  -1.97238550e-01f, -4.14399147e-01f, -4.96037789e-02f, -9.94594246e-02f, -8.68221596e-02f, -6.76070899e-02f, 6.65562227e-02f, 3.18103075e-01f, 1.82685107e-02f, -4.75505739e-02f,
  -2.69702189e-02f, 4.90207896e-02f, 2.86556277e-02f, 4.86827083e-02f, -9.12077501e-02f, -5.09997335e-05f, 1.08391687e-01f, -3.53874341e-02f, 6.59495443e-02f, 8.16582516e-02f,
  -6.98118331e-03f, 1.85611788e-02f, -9.15271044e-02f, -6.30034357e-02f, 4.47806455e-02f, -2.83647608e-02f, 2.86892746e-02f, 8.72748643e-02f, -7.64201134e-02f, -3.19805034e-02f,
  4.90799472e-02f, 4.75617833e-02f, -2.94758379e-02f, 1.03998417e-02f, 2.02801432e-02f, 1.09484745e-02f, -8.13498348e-03f, -6.88688736e-03f, 5.36273010e-02f, -1.89621076e-02f,
  -9.74546280e-03f, -2.74928175e-02f, 1.92509256e-02f, -2.42685638e-02f, -4.67940830e-02f, -2.38202810e-02f, 6.70378134e-02f, -3.76283638e-02f, 7.05280453e-02f, 3.55857946e-02f,
  -3.06119528e-02f, 8.24691355e-03f, -5.14438413e-02f, -1.17279019e-03f, -3.18551771e-02f, 5.15468717e-02f, 1.56094246e-02f, -1.07774725e-02f, 3.99473980e-02f, 9.38009247e-02f,
  -6.52098000e-01f, -8.54906082e-01f, -1.36125356e-01f, -8.45601335e-02f, -2.72878576e-02f, -3.20413038e-02f, -3.07507701e-02f, -1.08813845e-01f, -1.24168299e-01f, -7.61584262e-04f,
  -8.02129656e-02f, 4.34074439e-02f, -1.02126986e-01f, 1.08723706e-02f, -2.62950361e-02f, -1.52546227e-01f, -1.71752855e-01f, -8.55669007e-02f, -1.51875973e-01f, -7.87938014e-02f,
  -8.30869228e-02f, -7.38131702e-02f, 1.29306361e-01f, -1.82339019e-04f, -8.04957747e-03f, 8.04634579e-03f, -1.13272280e-01f, 7.61321560e-02f, 1.67019088e-02f, -3.07553005e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  4.50028002e-01f, 4.90884542e-01f, 3.59765798e-01f, 6.88568711e-01f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  3.57120812e-01f, 3.38789344e-01f, 5.16144097e-01f, -8.32995772e-01f, -4.28967863e-01f, -9.45854187e-01f, 5.96993148e-01f, 6.94487512e-01f, 5.15837610e-01f, 5.85122347e-01f,
  7.85563469e-01f, -1.03680623e+00f, -4.85157728e-01f, 7.98279822e-01f, -4.73229319e-01f, -2.33364731e-01f, -1.12361598e+00f, 3.93793322e-02f, 1.16619710e-02f, 6.76323533e-01f,
  3.26763123e-01f, 6.07993186e-01f, 1.57971948e-01f, 1.44120857e-01f, 8.86954725e-01f, 5.83030581e-01f, -4.44209486e-01f, 6.20832384e-01f, -2.48494640e-01f, 1.15163755e+00f,
  -4.87728685e-01f, -7.28188336e-01f, -2.67169714e-01f, 2.79337801e-02f, -8.04383457e-01f, -5.98858953e-01f, -3.57087165e-01f, -4.84390140e-01f, 4.79067951e-01f, -2.46684000e-01f,
  1.05203234e-01f, -5.34947634e-01f, -3.33459646e-01f, 4.40848947e-01f, -3.39102447e-01f, 7.58838117e-01f, 2.91492224e-01f, 7.32383788e-01f, 2.07154974e-02f, 3.07136804e-01f,
  4.50238556e-01f, -6.12214133e-02f, -6.02165520e-01f, -7.19655573e-01f, -8.81899118e-01f, 4.91740465e-01f, -3.76779974e-01f, 7.19217837e-01f, -9.52514708e-01f, -3.14633012e-01f,
  1.05623865e+00f, -6.10503078e-01f, -1.49268001e-01f, -6.36040568e-01f, 8.79465044e-01f, 3.42138290e-01f, 1.26913935e-01f, 3.76514107e-01f, 1.36704648e+00f, -6.27070367e-02f,
  3.62571299e-01f, 5.62246799e-01f, -1.09276235e-01f, 6.59004867e-01f, -4.15013403e-01f, -1.13217294e+00f, 2.96631008e-01f, -3.90542746e-01f, -3.26128840e-01f, 8.26514959e-01f,
  -4.04399276e-01f, 6.86003745e-01f, 3.27057689e-01f, 6.78885341e-01f, -3.87288183e-01f, 6.78110003e-01f, 1.01084995e+00f, -8.92295837e-01f, -1.09517503e+00f, 6.52283788e-01f,
  1.45227981e+00f, -1.84058864e-02f, -3.16878825e-01f, -3.03998142e-01f, 2.07298517e-01f, -5.23684442e-01f, -5.79001486e-01f, -9.60290506e-02f, 4.57956672e-01f, -4.74345416e-01f,
  4.16934907e-01f, -3.29457134e-01f, 9.85054255e-01f, -1.20202971e+00f, 6.30671620e-01f, -9.26203668e-01f, -2.21368507e-01f, 1.24534357e+00f, 1.72992140e-01f, -8.40657890e-01f,
  -4.64965940e-01f, 8.53915393e-01f, -5.97857714e-01f, -7.73384154e-01f, -1.01520479e+00f, -1.92165986e-01f, 2.29548901e-01f, 3.20985377e-01f, -4.03473705e-01f, 2.72499591e-01f,
  -5.00323474e-01f, 2.66741395e-01f, 5.85466504e-01f, -1.47445165e-02f, 1.16847968e+00f, 1.30596817e-01f, -3.12467843e-01f, 1.92499667e-01f, 1.92463338e-01f, -9.36289728e-01f,
  1.77504614e-01f, -5.88374376e-01f, 4.99591082e-02f, -1.09059168e-02f, -7.27277935e-01f, -6.25965297e-01f, -3.69085491e-01f, -6.93219364e-01f, 1.85548440e-01f, 6.72351956e-01f,
  1.14294097e-01f, 6.66817248e-01f, 8.24614346e-01f, -6.23318672e-01f, 4.61511195e-01f, 2.03999355e-01f, -2.62852907e-01f, 1.13840267e-01f, -4.48684096e-01f, 1.66907668e-01f,
  -5.23842454e-01f, 5.84175050e-01f, 4.38581407e-02f, 3.68497223e-02f, 9.39911485e-01f, 8.00066531e-01f, -3.82719100e-01f, -5.78945041e-01f, -2.22932249e-01f, 1.34664500e+00f,
  2.86448210e-01f, -1.88560501e-01f, 1.84370577e-01f, 3.02794933e-01f, -4.68730748e-01f, 6.22408569e-01f, -4.80538815e-01f, 9.57004368e-01f, 6.49685025e-01f, -1.66992620e-01f,
  -6.44992292e-01f, 3.79022062e-01f, -6.50925711e-02f, -5.29948413e-01f, 1.26843679e+00f, -5.16889513e-01f, 2.06144065e-01f, 1.94200084e-01f, 2.24037189e-02f, -1.07793957e-01f,
  4.68944371e-01f, 4.89754826e-01f, -1.09979415e+00f, -1.34498608e+00f, -1.13877451e+00f, -1.29606164e+00f, -1.09824181e+00f, -8.91919911e-01f, -3.81147951e-01f, -5.57526171e-01f,
  2.05586310e-02f, -3.43151212e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  1.09383635e-01f, -2.11802706e-01f, -6.99338913e-01f, -1.74860377e-02f, 6.16139024e-02f, 8.34684074e-01f, 3.26655358e-01f, -3.77914429e-01f, -5.52788734e-01f, -4.14953887e-01f,
  -4.84289937e-02f, 6.00605309e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    