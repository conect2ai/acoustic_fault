/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -8.43085289e-01f, 5.12762308e-01f, -5.85249392e-03f, -3.15797001e-01f, 1.54859975e-01f, 1.17992066e-01f, 2.60494232e-01f, -1.17811859e-01f, -2.57804245e-01f, 1.79404300e-02f,
  3.86060387e-01f, 3.04682314e-01f, 1.99363351e-01f, 1.80109859e-01f, -7.95907993e-03f, 2.20256403e-01f, 1.94494084e-01f, -1.07722357e-01f, -3.66724163e-01f, -1.27578795e-01f,
  7.91266710e-02f, -3.31407785e-01f, -5.60329556e-01f, -2.32400432e-01f, 4.97791637e-03f, 1.44101456e-01f, 4.91027022e-03f, 7.27398247e-02f, 2.52207249e-01f, 2.37051964e-01f,
  2.78770268e-01f, -4.56605144e-02f, -4.49194238e-02f, -6.45423308e-02f, 4.86819372e-02f, -1.15210190e-01f, 3.77016813e-02f, -7.73669109e-02f, -3.20813358e-02f, -2.40948256e-02f,
  3.42453644e-02f, 6.72048889e-03f, 2.82990839e-02f, 7.48899207e-02f, -5.18842302e-02f, -4.40338030e-02f, -1.30679190e-01f, -8.91008601e-02f, 1.06573135e-01f, 6.46705106e-02f,
  1.15052298e-01f, 1.08405963e-01f, 8.71303398e-03f, -2.89444383e-02f, -1.65498834e-02f, -1.01829525e-02f, -2.21969951e-02f, -7.40673691e-02f, -9.04893577e-02f, -1.07744798e-01f,
  8.99751782e-02f, -2.13877074e-02f, 4.91890572e-02f, 1.02915764e-01f, 4.02222537e-02f, -1.87030099e-02f, 1.28191514e-02f, 2.61000283e-02f, -4.34584282e-02f, -4.41539735e-02f,
  2.34416146e-02f, 1.08864903e-01f, -7.53099695e-02f, 3.62111554e-02f, 4.40077251e-03f, 4.12019007e-02f, -6.20366409e-02f, 2.33798381e-02f, 1.05461448e-01f, -5.19143939e-02f,
  4.55431417e-02f, -7.71271512e-02f, -3.03718578e-02f, 9.76796076e-03f, 8.26876685e-02f, 5.39861023e-02f, 2.02521924e-02f, 3.20732035e-02f, -5.02472408e-02f, -1.15831487e-01f,
  -1.00686774e-01f, 6.34900779e-02f, 8.54406040e-03f, -9.20797065e-02f, -3.36949117e-02f, -6.37679324e-02f, 7.09991455e-02f, 3.62285823e-02f, 8.61832872e-02f, -1.58425290e-02f,
  -8.58294964e-02f, -1.15591325e-01f, -4.02076505e-02f, 7.15964213e-02f, -7.07292035e-02f, -5.22487611e-02f, 3.21168862e-02f, 1.10066272e-01f, -1.74871795e-02f, 5.73569462e-02f,
  2.96738092e-02f, -7.08376011e-03f, 4.43741307e-02f, 1.26395300e-01f, 4.79854941e-02f, 8.37465748e-02f, 8.18217248e-02f, 2.20787097e-02f, 7.04944879e-02f, -1.74822435e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.54484895e-02f, -1.17890932e-01f, 2.42447034e-01f, 2.82746911e-01f, -5.55756330e-01f, -6.85374498e-01f, -5.13068795e-01f, -2.48672500e-01f, -1.95189193e-01f, -2.73750067e-01f,
  -7.39300311e-01f, -3.88881028e-01f, -2.85137035e-02f, 1.94236204e-01f, 3.38909358e-01f, 4.28409010e-01f, 7.90850043e-01f, 9.24324811e-01f, 5.17778218e-01f, -5.90264201e-02f,
  1.01063766e-01f, 4.44642395e-01f, 4.99449492e-01f, 4.82235044e-01f, 3.14952254e-01f, 2.98625492e-02f, 4.16624360e-02f, -8.19063571e-04f, 7.67195597e-02f, 8.68380308e-01f,
  -9.95667577e-02f, -3.08226377e-01f, -2.99718201e-01f, -2.43101612e-01f, -2.49636248e-01f, 3.21003497e-01f, -9.64898169e-02f, 1.95120618e-01f, -5.80852926e-02f, 3.60104680e-01f,
  -2.08955407e-01f, 1.54527977e-01f, -1.36644125e-01f, 5.28111868e-02f, -3.47814053e-01f, -4.31571156e-01f, 3.93779308e-01f, 3.95445347e-01f, 2.93912113e-01f, -4.17194031e-02f,
  7.79929087e-02f, -3.89839202e-01f, -6.23275340e-01f, -4.05594766e-01f, -6.84090406e-02f, 1.71735913e-01f, -2.41756678e-01f, -8.82073343e-02f, -3.65286201e-01f, 1.91708967e-01f,
  -2.17693582e-01f, 1.02149747e-01f, 3.64697911e-02f, 1.50719911e-01f, 1.82323217e-01f, 6.05581142e-02f, 1.14388488e-01f, 5.04542468e-03f, 1.06506281e-01f, 2.84432396e-02f,
  1.44197896e-01f, 1.29308775e-01f, 1.21415677e-02f, -1.46246418e-01f, -4.14940007e-02f, -1.39668331e-01f, 5.95401563e-02f, 1.25707209e-01f, -2.61973180e-02f, -7.97114298e-02f,
  -4.85618552e-03f, -8.95883963e-02f, -6.42727017e-02f, 3.10725480e-01f, -6.75143227e-02f, -1.32422835e-01f, 1.41007572e-01f, -1.79490730e-01f, 1.01515688e-01f, -1.60068840e-01f,
  -6.50814056e-01f, -3.53103012e-01f, 1.75064206e-02f, 1.25964448e-01f, 1.49177620e-02f, -2.06925109e-01f, -1.03021145e-01f, 8.48773122e-02f, -2.34609410e-01f, 3.46064605e-02f,
  -2.61738420e-01f, -4.29641418e-02f, -1.12911507e-01f, 5.67202643e-02f, -1.74743965e-01f, -4.05171067e-01f, 9.52727441e-03f, 1.86206043e-01f, 7.39890337e-02f, -6.39613494e-02f,
  2.14489698e-01f, -2.13655233e-01f, -6.03228211e-01f, -4.13930804e-01f, -4.58750039e-01f, -3.30655217e-01f, -3.07709694e-01f, -3.52220267e-01f, -7.18225718e-01f, -3.98364186e-01f,
  1.50377846e+00f, 8.42271328e-01f, 6.09478891e-01f, 5.00334203e-01f, -1.61991343e-01f, 1.30058788e-02f, 2.33301610e-01f, 3.46009135e-02f, -2.79174685e-01f, 4.51218307e-01f,
  4.55929667e-01f, -6.15373030e-02f, -9.47989374e-02f, -5.93683086e-02f, 1.30326167e-01f, 1.09149396e-01f, -3.07449043e-01f, 5.68331406e-02f, -5.50713725e-02f, 1.39413610e-01f,
  1.10590132e-04f, 3.25400233e-01f, 3.96946341e-01f, 9.70750526e-02f, 2.40738079e-01f, -1.89662442e-01f, 6.41872361e-02f, 3.62483531e-01f, 3.01219553e-01f, 2.94624090e-01f,
  6.11587703e-01f, 8.94555926e-01f, -6.80237710e-01f, -2.43797019e-01f, 5.92452064e-02f, -1.32972943e-02f, 1.23422116e-01f, -2.77359057e-02f, 3.86402151e-03f, -1.08732700e-01f,
  -4.01121117e-02f, 1.84496850e-01f, 1.09813362e-01f, 2.39279885e-02f, 8.59760642e-02f, -1.69401944e-01f, -2.76336726e-02f, 1.06795408e-01f, -1.41804233e-01f, 1.35835245e-01f,
  -4.22852710e-02f, 3.22439969e-01f, 6.05010614e-02f, -2.62778848e-01f, 1.66525304e-01f, -1.47492796e-01f, 9.50469971e-02f, 1.29818693e-01f, 2.56001074e-02f, 3.59504908e-01f,
  -7.72205472e-04f, 2.45641202e-01f, 3.01963717e-01f, 1.79345429e-01f, 1.69085249e-01f, 8.15764591e-02f, 2.02649422e-02f, 4.77399118e-02f, 1.97103210e-02f, 6.70450106e-02f,
  -2.62182467e-02f, 8.56192112e-02f, 8.54676813e-02f, -6.29389584e-02f, -2.05376133e-01f, 7.10769668e-02f, -8.39576572e-02f, -1.09350786e-01f, 2.09333058e-02f, -2.00234652e-01f,
  1.87528417e-01f, -1.84792012e-01f, -6.38172850e-02f, -6.72122389e-02f, -4.98731174e-02f, 7.67776668e-02f, 2.60784458e-02f, 1.55100614e-01f, 1.45751998e-01f, 5.88451163e-04f,
  -9.09996808e-01f, -2.65143752e-01f, -1.19022250e-01f, -8.59266743e-02f, 4.42162082e-02f, -8.80878344e-02f, 1.05807669e-01f, -4.67135310e-02f, -1.92430437e-01f, -1.32684475e-02f,
  1.62707955e-01f, 1.62882060e-01f, 1.73783734e-01f, -8.50573629e-02f, -2.31595576e-01f, -1.48988754e-01f, -2.33860612e-02f, -2.25576743e-01f, -1.37549818e-01f, -5.81656955e-02f,
  -1.49196535e-01f, -4.21936274e-01f, -3.20347130e-01f, -5.28600633e-01f, -2.17679545e-01f, -3.36837888e-01f, -2.84461379e-01f, -2.30748340e-01f, -2.98640221e-01f, -1.99340940e-01f,
  -5.70610106e-01f, -2.80615926e-01f, -3.52476954e-01f, 2.10349143e-01f, 3.64969790e-01f, 3.51248533e-01f, 3.57076079e-01f, 2.94206679e-01f, 4.67735797e-01f, 2.20720053e-01f,
  2.18704402e-01f, 4.70575720e-01f, 4.13272440e-01f, 4.34218854e-01f, 2.36107439e-01f, 4.54201937e-01f, 4.26324069e-01f, 4.84525971e-02f, 1.10692658e-01f, 3.56049031e-01f,
  4.58610713e-01f, 1.21758379e-01f, -1.54048264e-01f, 1.48064375e-01f, 1.38028026e-01f, 4.85968143e-01f, 1.44024968e-01f, 8.22899193e-02f, 1.34363770e-01f, -3.88903474e-03f,
  -5.42426884e-01f, -3.73019576e-01f, 1.56956002e-01f, 1.35959163e-01f, -1.97197050e-01f, -2.18525603e-01f, 4.22559641e-02f, -1.95367128e-01f, -2.40328461e-01f, 8.99939090e-02f,
  -4.93018702e-02f, -1.46404713e-01f, -1.70865372e-01f, -9.99179333e-02f, -4.46384512e-02f, -6.95703402e-02f, -6.14454709e-02f, 3.24826837e-02f, 1.74935177e-01f, 8.16696957e-02f,
  2.72279289e-02f, -1.11940488e-01f, -7.89799821e-03f, 1.55599743e-01f, 8.10283944e-02f, 3.29285599e-02f, -8.78655016e-02f, -3.30157615e-02f, -1.39704719e-02f, -3.26568959e-03f,
  1.68889239e-01f, 7.63405263e-02f, -1.49817001e-02f, 1.37108341e-01f, 6.90393746e-02f, 4.73827310e-02f, -6.27742661e-03f, 1.00344129e-01f, 1.64574549e-01f, -4.61430140e-02f,
  -3.23456936e-02f, 1.01423204e-01f, 2.99754124e-02f, 1.04286164e-01f, 8.53158310e-02f, -7.68667459e-02f, -1.99604094e-01f, -5.60111031e-02f, -1.34207934e-01f, -1.88975081e-01f,
  -6.73531145e-02f, 3.07368636e-02f, -2.51775682e-01f, -9.51361284e-02f, 5.73145337e-02f, 1.11476876e-01f, 9.97467563e-02f, 3.30739506e-02f, 6.38218299e-02f, -6.58711568e-02f,
  3.31421494e-01f, 1.95745915e-01f, 9.75214913e-02f, -1.12823173e-01f, -1.50058568e-01f, -2.70257711e-01f, -6.27947673e-02f, -2.38244236e-01f, -3.48490477e-01f, -1.01802960e-01f,
  -9.02553648e-02f, -2.44583860e-01f, -1.54992148e-01f, -8.58722031e-02f, -1.58741713e-01f, -1.01940736e-01f, -3.34817879e-02f, 5.59969917e-02f, 8.75339583e-02f, -1.25218734e-01f,
  1.84026845e-02f, 9.77589414e-02f, 7.21530467e-02f, 2.68248409e-01f, 1.38225973e-01f, 1.85158610e-01f, -1.21954091e-01f, -3.69940139e-02f, -5.43581787e-04f, 7.32174665e-02f,
  5.24133801e-01f, 2.74391361e-02f, -9.16971684e-01f, -4.68634933e-01f, -4.72380698e-01f, 3.67078348e-04f, 5.45843005e-01f, -6.17920682e-02f, -3.13907683e-01f, 2.09390342e-01f,
  3.31820101e-02f, -6.22996509e-01f, -7.16411293e-01f, -2.08552778e-01f, 2.45260149e-01f, 4.88065273e-01f, 3.08632761e-01f, -8.64322186e-02f, -2.79984444e-01f, 7.00835660e-02f,
  1.57905206e-01f, -6.53271377e-02f, -1.02558509e-01f, -8.14397335e-02f, -5.58883488e-01f, -5.64359784e-01f, -5.15959024e-01f, -4.44810688e-01f, 1.20705985e-01f, -2.72492975e-01f,
  -4.75239992e-01f, -5.19038200e-01f, 5.79586923e-02f, 2.17929602e-01f, -2.34966055e-01f, 1.08875446e-01f, 8.39856490e-02f, -4.83063400e-01f, -1.05777599e-01f, -3.16530168e-02f,
  -3.53206605e-01f, -1.66673198e-01f, -4.52088594e-01f, -3.79391879e-01f, -3.18500310e-01f, -2.81882053e-03f, -1.50672793e-02f, -2.73620665e-01f, -1.59846112e-01f, -1.83953792e-02f,
  5.03185578e-03f, -6.07549660e-02f, -1.96905062e-01f, -1.20012000e-01f, -2.71497577e-01f, -3.67302224e-02f, -4.66623038e-01f, -4.24518228e-01f, -1.14647351e-01f, -5.70486672e-02f,
  3.54149491e-01f, -1.90729111e-01f, -6.69684932e-02f, 4.12656069e-02f, 2.20806494e-01f, -5.87310344e-02f, 3.79229002e-02f, 1.01762051e-02f, -1.48675352e-01f, -1.48952127e-01f,
  7.49066984e-03f, 1.73633710e-01f, -8.99679288e-02f, 5.48213460e-02f, 1.31266359e-02f, -1.12096891e-01f, 2.39036486e-01f, 1.83232561e-01f, 1.52544547e-02f, 1.57952085e-01f,
  -6.09007590e-02f, -1.47491589e-01f, -2.21982583e-01f, 7.66956359e-02f, 1.48086399e-01f, 1.13315225e-01f, 1.72264174e-01f, 1.82361603e-01f, 3.14367339e-02f, 7.86413178e-02f,
  -7.53630251e-02f, 3.47140938e-01f, 1.82464078e-01f, 8.95747915e-02f, -1.07667699e-01f, -8.33260044e-02f, -6.88918214e-03f, 1.64442956e-01f, -9.86604914e-02f, 1.41490057e-01f,
  -9.28627625e-02f, -5.67691168e-03f, -2.46902823e-01f, -1.09033473e-01f, -7.86884576e-02f, 6.68771416e-02f, 4.23063844e-01f, 6.32064715e-02f, 9.87888724e-02f, 7.60688446e-03f,
  2.63900518e-01f, 5.54604173e-01f, 4.97315198e-01f, 1.44522995e-01f, 4.38464321e-02f, 4.31274086e-01f, 3.82543653e-02f, 1.22894973e-01f, 5.88630259e-01f, 6.97373092e-01f,
  -6.65217459e-01f, -7.14263678e-01f, -8.36038738e-02f, -3.79133701e-01f, 3.11833143e-01f, 6.32261187e-02f, -7.84062803e-01f, -4.25753564e-01f, 1.55386534e-02f, -5.36011159e-01f,
  2.44245619e-01f, 3.74038905e-01f, -4.39975888e-01f, -4.85610217e-01f, -1.42736518e+00f, -1.44424057e+00f, -1.08928573e+00f, -8.21416557e-01f, -2.49361679e-01f, 2.10577369e-01f,
  1.72391877e-01f, -8.31445307e-02f, -3.32602412e-01f, -1.95926487e-01f, -8.03731680e-02f, 6.30118549e-02f, -7.30697066e-02f, -9.19505805e-02f, -1.33926526e-01f, -4.47550952e-01f,
  -3.93665075e-01f, -4.93636308e-03f, 3.83982718e-01f, 5.46565428e-02f, 1.22846708e-01f, -1.32437214e-01f, 1.01415381e-01f, 1.11131512e-01f, 1.59943640e-01f, -3.73188585e-01f,
  1.14025630e-01f, 7.53769800e-02f, 2.09173590e-01f, 1.27256632e-01f, -5.60663715e-02f, -1.07160345e-01f, -1.02638625e-01f, -2.21942961e-01f, -4.11717594e-01f, 2.46828020e-01f,
  4.14868057e-01f, 4.51188050e-02f, -4.08743739e-01f, -1.47503972e-01f, -2.70510972e-01f, 2.50381492e-02f, 1.43379822e-01f, 3.71442549e-02f, -2.85616726e-01f, -7.16168463e-01f,
  9.00435746e-02f, 3.02597205e-03f, 1.75139919e-01f, 5.62746078e-03f, -1.61685258e-01f, 2.14080021e-01f, 2.99568400e-02f, -1.10149533e-01f, 1.50847718e-01f, -1.14907056e-01f,
  -6.52294308e-02f, 2.14245066e-01f, -3.99682224e-02f, -1.12095952e-01f, 1.32121043e-02f, -3.97455133e-02f, -4.13840525e-02f, -2.70691663e-01f, -1.87870134e-02f, -2.26890877e-01f,
  -1.62752330e-01f, -1.34864775e-02f, 8.64565894e-02f, -7.40125254e-02f, 1.52942568e-01f, -2.36226499e-01f, 1.65172070e-01f, 2.41391107e-01f, 5.81813045e-02f, -7.45631978e-02f,
  -6.13403201e-01f, 1.43362731e-01f, -4.42076117e-01f, -1.24800719e-01f, -2.31635392e-01f, 2.04226866e-01f, 1.81436300e-01f, -3.55673139e-03f, 6.20667003e-02f, -3.76764908e-02f,
  -1.02440757e-03f, -2.07746312e-01f, -1.72678292e-01f, 7.01613948e-02f, -1.46231037e-02f, -6.14200495e-02f, -4.52940941e-01f, -7.38464966e-02f, -1.74702808e-01f, 2.84816295e-01f,
  -2.74769217e-01f, -6.60959423e-01f, -8.97585988e-01f, -5.33398271e-01f, -4.28849280e-01f, -4.72554028e-01f, -3.47082734e-01f, -3.89280289e-01f, -8.14433813e-01f, -1.18377316e+00f,
  -1.20351529e+00f, -3.68255734e-01f, -4.67681080e-01f, -8.87290686e-02f, 2.24595413e-01f, -9.36993808e-02f, -2.57744402e-01f, -2.22322375e-01f, -1.29468039e-01f, -3.31421167e-01f,
  4.54185642e-02f, 3.54302041e-02f, -1.10590458e-01f, 7.89389014e-02f, -4.49802764e-02f, -2.12176248e-01f, -4.24300209e-02f, 2.08062142e-01f, 3.41888547e-01f, 3.98303241e-01f,
  5.12837172e-01f, 4.82621312e-01f, 3.06550711e-01f, 1.45480826e-01f, 7.13274553e-02f, 3.00020099e-01f, 3.81022394e-02f, 2.21291989e-01f, 1.84847787e-01f, -2.07826942e-01f,
  -4.82881665e-01f, -7.94234574e-01f, 6.95042824e-03f, 3.28801185e-01f, 1.10825069e-01f, -6.95621729e-01f, -7.05520809e-02f, -3.56240422e-01f, -1.65008515e-01f, -1.55790061e-01f,
  4.13381606e-02f, 7.11868256e-02f, 1.49251983e-01f, 1.26809090e-01f, 2.40082547e-01f, -2.57796794e-01f, 5.10991598e-03f, -3.40621680e-01f, -5.11102736e-01f, -1.90410897e-01f,
  5.82732797e-01f, 3.75926226e-01f, -6.10467136e-01f, -1.95783719e-01f, -4.21929747e-01f, 3.85998577e-01f, -6.43403903e-02f, -1.87629059e-01f, -1.89973846e-01f, -3.02340627e-01f,
  1.70193613e-02f, 4.11967523e-02f, -5.28715253e-02f, -5.23206405e-02f, 3.67354184e-01f, -1.38295248e-01f, 1.29173994e-01f, 1.70054555e-01f, 1.20933048e-01f, -1.53850451e-01f,
  6.46948293e-02f, 9.88306478e-02f, -5.76298088e-02f, -2.70287246e-01f, 7.57564083e-02f, -1.10454157e-01f, -1.48819730e-01f, 1.25030607e-01f, -7.00182142e-03f, -8.95236656e-02f,
  1.31382361e-01f, -7.31732771e-02f, 2.49581024e-01f, -7.20933005e-02f, -1.05450399e-01f, -3.59111950e-02f, -2.41222873e-01f, 1.57112554e-01f, 1.17072828e-01f, 3.54006840e-03f,
  3.08444679e-01f, 5.14554560e-01f, -5.30769289e-01f, -1.64208770e-01f, -6.06567319e-03f, 1.23605467e-01f, -2.13796999e-02f, 2.57454216e-02f, -4.46892157e-02f, -5.24206795e-02f,
  7.05706775e-02f, -1.22772954e-01f, -1.12909172e-03f, 1.03859127e-01f, 1.19674280e-01f, -7.88614899e-02f, 7.25844204e-02f, -2.44093910e-01f, -1.83568627e-01f, 5.15492223e-02f,
  1.07619539e-01f, -1.74737666e-02f, -3.68323684e-01f, -3.70311290e-01f, -1.43377617e-01f, 6.35013133e-02f, -5.51637542e-03f, -2.46136963e-01f, -3.99893910e-01f, -5.72491527e-01f,
  -1.18212950e+00f, -3.66231710e-01f, 1.41123962e+00f, -8.58808160e-01f, -4.22230251e-02f, 2.84479141e-01f, 1.22347318e-01f, -2.12896720e-01f, -4.24055964e-01f, 2.97903061e-01f,
  -3.76210034e-01f, -6.28217876e-01f, -6.42103255e-02f, -2.29696333e-02f, -2.31229454e-01f, 6.02487028e-01f, 4.42322522e-01f, 3.14281583e-01f, 2.28058130e-01f, -1.43168613e-01f,
  -5.56858301e-01f, -5.60074389e-01f, -5.24554968e-01f, -1.27555624e-01f, 4.89537604e-02f, 5.52030131e-02f, 5.30246317e-01f, -1.83376014e-01f, 7.58102238e-02f, 2.13913143e-01f,
  6.18881583e-01f, -5.22908866e-01f, 1.06878638e-01f, -5.47639906e-01f, 6.34091944e-02f, -1.09343655e-01f, 3.94017585e-02f, 1.63804933e-01f, -1.60204157e-01f, 2.05647394e-01f,
  -3.43008786e-01f, -7.85168111e-02f, -2.34107703e-01f, 1.23585910e-01f, -2.42445663e-01f, -1.27331406e-01f, 8.23859870e-02f, 2.32735842e-01f, 1.75223559e-01f, 3.74903500e-01f,
  -8.86489749e-02f, -1.45301193e-01f, 1.94743693e-01f, 3.06277096e-01f, -1.26771256e-02f, -2.32829466e-01f, 1.25613540e-01f, -1.70605421e-01f, 2.73969620e-01f, 1.78108543e-01f,
  1.31326139e-01f, 2.62147963e-01f, -1.78829879e-01f, 1.10618539e-01f, 7.09878057e-02f, -1.45594887e-02f, -5.00274524e-02f, -3.17229517e-02f, 5.19935861e-02f, -6.66414648e-02f,
  1.99597269e-01f, 4.31006216e-02f, 5.67858666e-02f, 1.12259857e-01f, 6.98445216e-02f, -9.13445950e-02f, -1.59241602e-01f, -7.32340962e-02f, 2.70011514e-01f, -1.28070742e-01f,
  -1.09219432e-01f, -9.67830196e-02f, 5.70375770e-02f, 4.26370464e-02f, 1.09504066e-01f, 1.12824373e-01f, 4.48975638e-02f, -5.02287187e-02f, 2.50891168e-02f, 1.52739182e-01f,
  -1.78020984e-01f, 1.18125327e-01f, -8.22382942e-02f, -4.48366143e-02f, -8.55438933e-02f, -2.02347748e-02f, -2.04561561e-01f, 2.05310415e-02f, -1.22060135e-01f, 6.49325848e-02f,
  -1.63415581e-01f, -1.68888092e-01f, -3.25233601e-02f, 3.97370420e-02f, 1.24666736e-01f, -2.71213911e-02f, -2.37234861e-01f, -4.20492701e-03f, -1.28091751e-02f, 8.82027764e-03f,
  -1.12064004e-01f, 2.76556797e-02f, -1.39871836e-01f, 1.65841803e-01f, -1.34824917e-01f, -8.84897485e-02f, 2.57619113e-01f, 9.28070862e-03f, 1.16967540e-02f, 2.25607440e-01f,
  7.19437718e-01f, -5.58750570e-01f, 6.92948699e-01f, 2.17631966e-01f, 4.25136745e-01f, 5.78722775e-01f, 3.66293401e-01f, 1.45798683e-01f, -3.02936547e-02f, -1.13388836e-01f,
  -2.57949620e-01f, -4.22864497e-01f, -3.38556379e-01f, -3.15106273e-01f, -8.65342170e-02f, -1.23157546e-01f, -5.09716161e-02f, 3.47673237e-01f, 4.61654931e-01f, 1.31275311e-01f,
  -3.62694174e-01f, 1.23273507e-01f, 2.33077526e-01f, -6.85572773e-02f, -3.15061629e-01f, -2.68898845e-01f, -6.27199560e-02f, 7.84092303e-03f, -6.11370690e-02f, -5.45084596e-01f,
  -3.36072981e-01f, 1.07555613e-01f, 5.44861667e-02f, -4.22746241e-01f, -3.26802544e-02f, -1.57077029e-01f, 1.25557771e-02f, -1.18247695e-01f, -1.19499885e-01f, -7.69601092e-02f,
  -1.23414127e-02f, -4.03752252e-02f, 4.78443131e-03f, -9.24583338e-03f, 1.86581746e-01f, 4.38461006e-02f, 2.92181112e-02f, 1.30640902e-02f, -1.97288632e-01f, -1.92347050e-01f,
  -2.44069353e-01f, 2.01448262e-01f, 2.49912441e-01f, 5.90708144e-02f, 1.39790937e-01f, 1.08283848e-01f, 7.71490624e-03f, -4.70435880e-02f, 3.77905965e-02f, -2.16413304e-01f,
  4.06700484e-02f, 2.46643517e-02f, 2.59900000e-02f, 6.15604632e-02f, 3.30138505e-02f, 1.03065819e-01f, 5.22277020e-02f, -7.12623820e-03f, 1.59300059e-01f, 8.01433623e-02f,
  8.04076567e-02f, 1.65068790e-01f, 2.25374848e-01f, 1.42337784e-01f, -7.39875063e-02f, 1.01987943e-02f, -2.60073226e-03f, -7.53627568e-02f, 1.31276250e-02f, -1.62420422e-03f,
  1.40146196e-01f, 5.21797352e-02f, -1.96866300e-02f, -1.29951879e-01f, -3.15580852e-02f, -2.07038336e-02f, -6.36800975e-02f, -1.13067746e-01f, -7.16388822e-02f, 4.14114892e-02f,
  -4.00978982e-01f, 5.74814856e-01f, -7.55693167e-02f, -1.03490517e-01f, 8.37537646e-02f, -6.11591898e-03f, -2.59422610e-04f, -7.20212981e-02f, -2.39325196e-01f, -8.33325237e-02f,
  5.87847307e-02f, 5.84571622e-03f, 3.72955129e-02f, 5.12546413e-02f, 2.89258957e-01f, 2.02426687e-01f, -8.06261376e-02f, 3.15927379e-02f, -8.60523880e-02f, -1.53825492e-01f,
  -1.66620865e-01f, 1.46555230e-01f, 1.87534869e-01f, 2.29112357e-01f, 8.57417732e-02f, 2.59577125e-01f, 1.38810501e-01f, 1.04786970e-01f, 1.82634220e-01f, -1.04580894e-02f,
  -1.08147240e+00f, -6.75466835e-01f, -8.87633026e-01f, -1.33564472e+00f, -7.98957288e-01f, -1.19737595e-01f, -9.08245370e-02f, -9.65347216e-02f, -6.35034025e-01f, -9.34821129e-01f,
  1.70683414e-01f, 8.20540905e-01f, 2.55909860e-01f, 6.12054169e-01f, 8.99699628e-01f, -5.30332565e-01f, -8.58796179e-01f, 7.28368014e-02f, 7.94573128e-01f, 6.40976191e-01f,
  1.83882758e-01f, -3.33976060e-01f, -1.48630917e-01f, 1.30790517e-01f, -6.60493731e-01f, -1.62932217e-01f, -9.32502329e-01f, -4.53470349e-01f, 7.79132321e-02f, -8.81667137e-01f,
  4.40097123e-01f, -6.75606787e-01f, 3.40104252e-01f, 1.94602847e-01f, -2.48966813e-01f, 2.58758396e-01f, 6.31227121e-02f, -2.05097169e-01f, 9.67223383e-03f, -1.14379533e-01f,
  -2.74119794e-01f, 2.15978801e-01f, -3.24631669e-02f, 1.32484749e-01f, -1.17452800e-01f, 8.31181630e-02f, -2.33713478e-01f, -2.36930385e-01f, -3.84784698e-01f, -7.48319849e-02f,
  1.96158513e-01f, -9.90064666e-02f, -7.86411464e-02f, 1.85781643e-01f, -1.14762494e-02f, -8.42850134e-02f, -1.46526918e-01f, -2.45602857e-02f, 1.21605797e-02f, -4.99496222e-01f,
  1.49312705e-01f, -1.01343974e-01f, -1.08135708e-01f, -5.31727001e-02f, 1.75790071e-01f, 1.55012647e-03f, -6.96853697e-02f, 7.82970786e-02f, -1.46326888e-02f, 9.74758789e-02f,
  -4.79721874e-02f, -1.70182437e-01f, 1.16500027e-01f, 1.22387568e-02f, -1.99515559e-02f, -2.34241784e-01f, 2.66279466e-02f, 1.01531476e-01f, -4.21959683e-02f, -1.97985739e-01f,
  -8.62491429e-02f, -5.64983524e-02f, -1.24339320e-01f, 1.35365635e-01f, -1.11679815e-01f, -4.80711050e-02f, -3.34348008e-02f, 2.03549922e-01f, 1.57829933e-02f, -1.37900382e-01f,
  3.71767491e-01f, 4.12421882e-01f, -3.37167196e-02f, 2.07664177e-01f, -4.08358872e-01f, -2.33496949e-01f, -1.54182076e-01f, -7.73382261e-02f, -1.30988538e-01f, 3.13287899e-02f,
  2.88629960e-02f, 4.57636593e-03f, -1.19336493e-01f, 2.98574343e-02f, 1.15047209e-01f, 1.26464993e-01f, -1.52072133e-02f, -7.53434598e-02f, 3.37498002e-02f, -3.32046688e-01f,
  -1.78713471e-01f, 7.39091039e-02f, 2.39993289e-01f, 1.92757547e-01f, 4.74715047e-02f, 2.38720849e-01f, 1.73804834e-01f, 2.58054525e-01f, 2.63006687e-01f, -6.71722814e-02f,
  5.50475836e-01f, -6.78157091e-01f, 2.82316327e-01f, -2.13283285e-01f, -2.06783205e-01f, -4.09706146e-01f, -9.45775926e-01f, -6.14850760e-01f, -2.31937349e-01f, -4.28174525e-01f,
  3.25789720e-01f, 9.94085729e-01f, 8.76766980e-01f, 7.02656090e-01f, 7.00831950e-01f, -5.08833468e-01f, -2.34898999e-01f, 9.53004122e-01f, 7.90823638e-01f, -1.07097611e-01f,
  -3.53079706e-01f, -1.74664289e-01f, 2.69178957e-01f, -1.59869060e-01f, -4.47617531e-01f, 3.91007274e-01f, -2.37351686e-01f, -6.01841249e-02f, 4.54711728e-02f, -1.87010139e-01f,
  4.72974598e-01f, -6.51462257e-01f, 2.98563480e-01f, 2.72273213e-01f, 2.89240181e-01f, -1.12681882e-02f, -1.49473473e-01f, -1.30931474e-02f, 1.05452105e-01f, -3.19889873e-01f,
  4.39650267e-02f, -7.00078532e-02f, 1.70660347e-01f, -2.61374027e-01f, -4.44903523e-01f, -2.17899799e-01f, -2.44742855e-01f, -3.19381468e-02f, -9.13979039e-02f, -2.67761767e-01f,
  -1.77885935e-01f, 5.25116064e-02f, 6.05928861e-02f, -2.94810385e-01f, -2.07832530e-02f, 5.40915132e-01f, -1.53570592e-01f, -6.22997768e-02f, -3.07572726e-02f, -5.89698493e-01f,
  -5.65801114e-02f, 1.24115072e-01f, 1.46664865e-02f, -5.18687405e-02f, 9.53141376e-02f, -7.56800128e-03f, -7.32340068e-02f, -4.02195379e-02f, -6.70197904e-02f, -6.73068091e-02f,
  -1.42185781e-02f, 8.86533186e-02f, 2.37635691e-02f, -3.96931209e-02f, 8.90190899e-02f, -1.91149879e-02f, -2.49686372e-02f, -5.05462550e-02f, 7.86813051e-02f, 1.26002980e-02f,
  1.95283160e-01f, 1.00713491e-01f, 4.89725918e-02f, -1.79569628e-02f, 4.83608171e-02f, 1.96593970e-01f, 1.74279846e-02f, 8.16943720e-02f, 1.45200491e-01f, -3.02997716e-02f,
  -8.97420794e-02f, 5.35190880e-01f, -9.16278809e-02f, 1.24611758e-01f, -1.18989117e-01f, 1.05452269e-01f, -1.03435688e-01f, 5.77470027e-02f, -2.99406657e-03f, -9.72621441e-02f,
  8.68440568e-02f, 1.87412158e-01f, -1.13724642e-01f, -1.75320625e-01f, 3.95629853e-02f, -1.76865831e-01f, 4.70135640e-03f, 2.94117808e-01f, -1.37572391e-02f, -1.48185179e-01f,
  -2.12502584e-01f, -1.59202129e-01f, 3.33043903e-01f, 1.62996892e-02f, -1.88252971e-01f, 3.42244625e-01f, 1.07028849e-01f, 1.35498673e-01f, 3.28162491e-01f, -2.98762500e-01f,
  -1.11228287e+00f, 8.24599087e-01f, 4.55137104e-01f, -6.31963253e-01f, 6.59150004e-01f, 8.84301245e-01f, 1.32122779e+00f, 4.03475165e-01f, -3.27590138e-01f, 3.34103137e-01f,
  3.68589580e-01f, -5.27060330e-01f, -3.10667068e-01f, -1.84056535e-01f, 1.02788776e-01f, 6.80234373e-01f, 3.48227710e-01f, -2.45660782e-01f, -3.65539879e-01f, 1.45636082e-01f,
  9.12046582e-02f, -2.86641896e-01f, -7.97021329e-01f, -3.95239502e-01f, -9.27426517e-02f, -4.54401314e-01f, -2.89543495e-02f, -7.82449450e-03f, 5.71610808e-01f, -8.09411108e-02f,
  -1.59827083e-01f, 1.02439642e-01f, -2.34158874e-01f, -3.78880650e-01f, 1.18059926e-01f, -4.18639988e-01f, -1.96502462e-01f, -4.84118193e-01f, 1.64690241e-01f, 1.45072695e-02f,
  -2.77632941e-02f, -1.68391038e-02f, 1.52960345e-01f, 1.27502173e-01f, 1.78309172e-01f, 9.07509327e-02f, -1.48749143e-01f, -2.80796379e-01f, -1.69642314e-01f, 1.67716831e-01f,
  2.89733171e-01f, 2.37253845e-01f, 2.31934339e-01f, 3.15388501e-01f, 1.71889082e-01f, -3.40919852e-01f, 3.24427724e-01f, 2.60207821e-02f, -7.48761520e-02f, -5.02209187e-01f,
  -2.20191598e-01f, -1.89207178e-02f, 2.97883898e-01f, -1.91253707e-01f, 1.99777703e-03f, 4.06811349e-02f, 9.25739110e-03f, 1.25703529e-01f, 1.63281158e-01f, -3.23296264e-02f,
  4.50391090e-03f, 6.57268316e-02f, -5.64287417e-02f, -6.75789714e-02f, -2.58642197e-01f, 1.38513058e-01f, 2.66137451e-01f, 3.54248807e-02f, 6.53378889e-02f, -3.48281562e-02f,
  -5.99608347e-02f, 8.21389630e-02f, -2.30893016e-01f, 1.64749667e-01f, 6.87703565e-02f, -1.27622128e-01f, -2.20951781e-01f, 3.68465297e-02f, -3.34232301e-01f, -2.10886579e-02f,
  -8.54710221e-01f, 5.94265461e-01f, -5.28469682e-01f, -1.15176015e-01f, 3.02999094e-02f, -4.02081013e-02f, -9.42356512e-02f, -2.83096693e-02f, 7.06085050e-03f, -2.21672252e-01f,
  2.89765716e-01f, 4.96092029e-02f, 2.15143248e-01f, -1.02880441e-01f, -7.02056214e-02f, -1.48312598e-01f, 1.16004489e-01f, -2.38145903e-01f, 1.01263560e-01f, -5.28353006e-02f,
  1.39062136e-01f, -1.17179565e-02f, -5.36932051e-01f, -2.48326525e-01f, -3.07816476e-01f, -8.03047061e-01f, -2.25163504e-01f, -3.14638883e-01f, 9.62175876e-02f, -4.15082157e-01f,
  2.56514490e-01f, -7.71311998e-01f, 1.80340275e-01f, 2.75364041e-01f, 2.00805068e-01f, 2.17641681e-01f, 3.00864577e-01f, 5.23950420e-02f, 2.86406986e-02f, 1.71588659e-01f,
  -3.32547069e-01f, -1.54121652e-01f, -7.28440136e-02f, -2.67422825e-01f, -3.11304092e-01f, 2.42165387e-01f, 1.92013025e-01f, 2.92126443e-02f, 3.12727630e-01f, 9.49316472e-02f,
  3.05627510e-02f, 1.82655036e-01f, -3.80071551e-02f, -9.53006521e-02f, -2.60989685e-02f, 1.11543909e-01f, 5.28647862e-02f, -1.13792174e-01f, -3.46231937e-01f, -1.78399116e-01f,
  4.74816024e-01f, -6.20882332e-01f, 3.38381119e-02f, -3.90611529e-01f, -3.28781724e-01f, -1.44954160e-01f, -4.10173275e-02f, -1.95923254e-01f, -9.60667357e-02f, -3.33946757e-02f,
  -2.30845943e-01f, -9.61175263e-02f, -1.65990263e-01f, -1.66144758e-03f, 8.67547467e-02f, -2.75186263e-02f, -2.24995822e-01f, -2.82120705e-01f, -3.83499146e-01f, -2.08407328e-01f,
  -4.05966133e-01f, -3.79904568e-01f, -1.11594796e-01f, -2.14724824e-01f, -3.72077703e-01f, -1.13850467e-01f, -1.69413462e-01f, -2.87086070e-01f, -1.52984679e-01f, 1.28292069e-01f,
  -1.14858085e-02f, 2.55124085e-02f, -8.26671422e-02f, 8.08814764e-02f, 5.25468811e-02f, 1.45658880e-01f, 1.22791104e-01f, 5.58567680e-02f, -9.14395154e-02f, 1.58845857e-02f,
  -1.56582579e-01f, -1.47768781e-01f, 1.70869213e-02f, 7.20174909e-02f, -8.34486932e-02f, -1.42407656e-01f, -8.75586867e-02f, 2.71075256e-02f, -3.67664434e-02f, -6.37092628e-03f,
  -9.66716558e-02f, -8.48780796e-02f, 2.79569700e-02f, -3.33373882e-02f, -1.74297333e-01f, -2.34012544e-01f, 5.85795268e-02f, -1.49982169e-01f, 1.04837336e-01f, -1.88961506e-01f,
  5.63027740e-01f, -4.09441471e-01f, 3.30878228e-01f, -1.19949706e-01f, -9.81895179e-02f, -3.01968783e-01f, -6.71845600e-02f, -1.30857661e-01f, -1.45128578e-01f, 4.14428348e-03f,
  -1.38221145e-01f, 1.86288655e-01f, 1.23812430e-01f, -1.24453068e-01f, 2.87196994e-01f, 1.58427224e-01f, -1.32760689e-01f, 4.02645469e-02f, -6.76090717e-02f, -5.09721674e-02f,
  -8.16809684e-02f, 2.39891157e-01f, 5.13998866e-01f, 3.48930329e-01f, -2.64834519e-02f, 3.46977264e-01f, 3.26530933e-01f, 2.95518398e-01f, 3.34537715e-01f, 6.77923679e-01f,
  -3.91596377e-01f, 5.07933140e-01f, -1.00954108e-01f, 1.61028817e-01f, 5.26682258e-01f, -5.44884324e-01f, -9.17741537e-01f, -7.85827100e-01f, 9.44854319e-02f, 4.79330689e-01f,
  6.14355385e-01f, 1.21711396e-01f, 1.74150020e-01f, -2.02877894e-01f, -8.22627425e-01f, -5.58129102e-02f, 1.76427707e-01f, -7.37001359e-01f, -1.05940628e+00f, -8.29007566e-01f,
  2.09091902e-02f, -3.21551859e-01f, -5.31662464e-01f, -2.72693694e-01f, 7.06997514e-01f, 5.08637130e-01f, 5.40736496e-01f, 3.50948185e-01f, 4.11760360e-01f, 8.98831129e-01f,
  3.28745276e-01f, -1.02113590e-01f, -3.64617199e-01f, 2.01923430e-01f, 3.51696879e-01f, -2.72522002e-01f, -3.66000861e-01f, -1.28785837e-02f, -4.27127928e-02f, 8.33583344e-03f,
  3.16886395e-01f, 1.99113544e-02f, 1.91659302e-01f, -9.02216211e-02f, -9.64920223e-02f, -5.21370292e-01f, -1.90565810e-01f, -8.12521875e-01f, -5.26099026e-01f, -2.72699654e-01f,
  3.45404238e-01f, 1.66487992e-01f, -2.72172272e-01f, -3.79161477e-01f, -3.87038708e-01f, -9.08144633e-04f, -5.04674092e-02f, -3.16118896e-01f, -3.32938224e-01f, 1.55926168e-01f,
  -1.71406016e-01f, -6.69389367e-02f, -6.33040294e-02f, -3.30810919e-02f, 3.22184749e-02f, 1.43861368e-01f, 2.14465439e-01f, 7.77214020e-02f, 9.11791530e-03f, -6.13426492e-02f,
  -2.83070486e-02f, -1.64348409e-02f, -1.28993213e-01f, -6.23889230e-02f, -5.53266406e-02f, -5.88847622e-02f, -2.25496180e-02f, -8.28990266e-02f, -1.08964786e-01f, -1.10751977e-02f,
  -7.83262104e-02f, -8.28367099e-03f, 2.73011148e-01f, -2.10867852e-01f, 6.14273287e-02f, -9.12019312e-02f, 5.02387099e-02f, -7.45184496e-02f, -1.36721626e-01f, 1.92618430e-01f,
  2.66509280e-02f, -3.10732096e-01f, 2.43025780e-01f, -6.92991689e-02f, 1.66890994e-01f, 2.07041770e-01f, 1.77675262e-01f, -6.27505556e-02f, 9.55413282e-02f, -2.96167165e-01f,
  -1.37827545e-01f, -1.37340993e-01f, 2.75235921e-01f, -2.41152629e-01f, -2.06723332e-01f, 2.13837530e-02f, 2.04037771e-01f, -3.86883169e-02f, -2.27033600e-01f, 6.08772188e-02f,
  1.74579337e-01f, -4.36335921e-01f, -1.54845536e-01f, -1.86688796e-01f, -4.66407202e-02f, -2.42427483e-01f, -1.92721218e-01f, -1.65163755e-01f, -5.23110867e-01f, -2.29682252e-01f,
  3.15943241e-01f, 6.12824559e-01f, -1.21388793e+00f, 4.96567547e-01f, -8.02471042e-01f, -8.28256547e-01f, 1.77148819e-01f, 7.76862562e-01f, 7.60756493e-01f, 5.50259411e-01f,
  -3.78819406e-02f, -3.34173709e-01f, -1.00802571e-01f, -3.38017076e-01f, -6.63464129e-01f, -1.87292174e-01f, -4.21161830e-01f, -1.13040292e+00f, -1.21416259e+00f, -4.40749347e-01f,
  -1.45778149e-01f, -4.05887477e-02f, -2.51771331e-01f, -1.76584303e-01f, 8.52074400e-02f, -5.14065087e-01f, -1.64108440e-01f, -4.23435241e-01f, -8.82237077e-01f, -8.32871437e-01f,
  -6.71714664e-01f, -3.07346731e-01f, -5.42898715e-01f, -4.48749810e-02f, 1.27362698e-01f, -1.36602372e-01f, -1.75412491e-01f, -1.41012728e-01f, 4.52413931e-02f, 8.45761821e-02f,
  -4.12122250e-01f, -9.46893916e-02f, 2.20773183e-02f, -3.17535669e-01f, -1.01638421e-01f, -2.73736537e-01f, 1.54748216e-01f, -5.14888763e-01f, -2.93862849e-01f, -9.33405608e-02f,
  -2.87305832e-01f, -9.01033759e-01f, -5.72430551e-01f, 5.03663309e-02f, -1.69854552e-01f, -7.09301651e-01f, -2.62684196e-01f, -4.25364405e-01f, -8.20673347e-01f, 4.03599352e-01f,
  2.98030764e-01f, -1.16177849e-01f, 1.57743409e-01f, 2.71772951e-01f, 2.82737911e-01f, 7.86345378e-02f, 2.98320651e-02f, 1.54693201e-02f, -5.77188879e-02f, 2.05798849e-01f,
  2.53043979e-01f, 4.67307344e-02f, 1.56558186e-01f, 1.18227869e-01f, -1.73394874e-01f, -6.49100617e-02f, -6.68803137e-03f, 1.87149644e-01f, 9.86992344e-02f, 3.94678339e-02f,
  -1.65855780e-01f, -2.08340138e-01f, -9.22919959e-02f, 2.45471731e-01f, -4.60868031e-01f, -2.92411875e-02f, 8.14571753e-02f, 2.22715721e-01f, 1.38215125e-01f, 5.59900627e-02f,
  6.91077411e-01f, -4.25615430e-01f, 2.19517365e-01f, -1.85287058e-01f, -6.35985360e-02f, -4.64139320e-02f, 1.25069574e-01f, 1.03512496e-01f, -4.00426090e-02f, -6.40297979e-02f,
  -2.61144280e-01f, 2.41006259e-02f, 2.05648199e-01f, 3.04294713e-02f, -1.42611817e-01f, -1.69085428e-01f, 3.05845201e-01f, -3.76489788e-01f, -2.82482952e-01f, -4.22797613e-02f,
  4.44052041e-01f, 1.02790438e-01f, 2.77839720e-01f, 1.18373796e-01f, 1.67711917e-02f, -3.58312190e-01f, -1.20389424e-02f, 1.29583284e-01f, -5.09346902e-01f, 1.06677902e+00f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  8.93864155e-01f, 8.61937046e-01f, 5.12474179e-01f, 8.76054764e-01f, 4.26171601e-01f, 6.16173387e-01f, 1.89445043e+00f, 9.27471876e-01f, 5.65385282e-01f, 9.19019401e-01f,
  5.14111698e-01f, 1.44769800e+00f, 6.20702624e-01f, 8.73110354e-01f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -5.05615532e-01f, -1.15929449e+00f, -2.28604153e-01f, -3.48864734e-01f, -5.17346382e-01f, -2.48797879e-01f, 5.24604678e-01f, 6.51945472e-01f, -1.49640036e+00f, -6.06179722e-02f,
  6.98568642e-01f, -6.13209128e-01f, -9.44267094e-01f, -7.73357332e-01f, -1.22906280e+00f, 2.30794579e-01f, 1.42767102e-01f, 2.47378603e-01f, -3.97366673e-01f, 3.64228606e-01f,
  2.06650645e-01f, 3.77052188e-01f, -5.66358507e-01f, -1.23302460e+00f, -2.01906848e+00f, 2.53202528e-01f, 9.44514871e-01f, 1.31535184e+00f, -8.00964117e-01f, -1.38548806e-01f,
  -1.86141479e+00f, -3.04822177e-01f, -2.93529183e-01f, -1.08051026e+00f, 7.05214858e-01f, -1.37559903e+00f, -8.90488803e-01f, -1.11665082e+00f, 2.05671936e-02f, 1.02805185e+00f,
  4.66047287e-01f, 5.57792127e-01f, -4.91692036e-01f, 1.39466083e+00f, -6.85293138e-01f, -1.12608421e+00f, -6.95849657e-01f, -1.08697140e+00f, -7.82932460e-01f, 8.61423314e-01f,
  -3.93210471e-01f, -7.60248005e-01f, -4.64035928e-01f, 7.23625302e-01f, 4.24940372e-04f, -2.17237368e-01f, 8.28709781e-01f, -4.96850431e-01f, 2.32875988e-01f, -1.03871691e+00f,
  1.30787170e+00f, -1.23423684e+00f, -3.83193567e-02f, -3.94443929e-01f, 9.42971528e-01f, 1.04289699e+00f, -1.22644496e+00f, -2.98415154e-01f, 3.38941425e-01f, -8.59960079e-01f,
  3.92925590e-01f, -9.06721413e-01f, 8.24835122e-01f, -6.13929808e-01f, -8.15692484e-01f, -8.40622663e-01f, -1.11357653e+00f, -7.35483646e-01f, 1.13418722e+00f, 5.20344496e-01f,
  8.57231855e-01f, -9.72681820e-01f, -7.95310736e-02f, -2.31244847e-01f, 2.85109222e-01f, 9.06998515e-01f, -1.16644323e+00f, 5.45974612e-01f, -1.34657514e+00f, -9.14384484e-01f,
  -5.26805818e-01f, -1.32590473e+00f, -1.18110216e+00f, 4.57260311e-01f, -9.09004807e-02f, 1.07314086e+00f, -7.19040513e-01f, -1.10762489e+00f, 1.25438249e+00f, 8.51823211e-01f,
  -1.11923230e+00f, -3.04914922e-01f, -1.56489933e+00f, -8.66592288e-01f, -1.11207381e-01f, -9.93428230e-01f, -3.31841171e-01f, -8.89467180e-01f, -1.24283326e+00f, -1.61344722e-01f,
  -3.98244321e-01f, -9.62528288e-01f, -8.68506312e-01f, 9.07208264e-01f, 3.01286191e-01f, -7.60137379e-01f, 5.04676223e-01f, -9.68760490e-01f, -7.67644465e-01f, 3.00319105e-01f,
  -6.34741932e-02f, -9.12162423e-01f, -6.49601400e-01f, -1.32735670e+00f, 9.64699805e-01f, 4.18235250e-02f, 5.32364249e-01f, -4.03062135e-01f, -2.90260732e-01f, -2.41560847e-01f,
  2.16312945e-01f, -8.02581787e-01f, -8.88695270e-02f, 2.51752257e-01f, -5.75667322e-01f, -8.13366532e-01f, 4.79254335e-01f, 8.35681081e-01f, -1.48313046e+00f, -8.72528851e-02f,
  2.21214443e-01f, 9.96285856e-01f, -6.63365424e-01f, -1.06641304e+00f, 6.77246094e-01f, 7.05037057e-01f, -1.21289477e-01f, 4.78593171e-01f, -5.30748487e-01f, -7.50473380e-01f,
  4.16633457e-01f, 4.78734344e-01f, -1.57773829e+00f, -1.71214116e+00f, -1.21418476e+00f, 7.60790527e-01f, -7.70567238e-01f, -4.56365168e-01f, 1.14120638e+00f, -7.37789452e-01f,
  -6.34828329e-01f, 9.33312953e-01f, -6.67235970e-01f, -4.79670465e-01f, -3.32527369e-01f, -5.88085949e-01f, -1.14155078e+00f, -3.93638849e-01f, 8.55890393e-01f, -9.67382610e-01f,
  8.08702052e-01f, 4.36667323e-01f, -6.10668063e-01f, 5.88961482e-01f, -4.31679457e-01f, -1.30902588e-01f, 1.39133930e-01f, 5.47043860e-01f, -9.49893475e-01f, 7.70314217e-01f,
  -8.37617755e-01f, -8.20719376e-02f, -5.46817720e-01f, -3.58897783e-02f, -4.78110939e-01f, 5.76715052e-01f, -2.92428099e-02f, -2.96842515e-01f, 1.47359276e+00f, -6.36619687e-01f,
  5.43053299e-02f, -6.46541774e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  1.29232466e-01f, 5.38248956e-01f, 3.31644088e-01f, -1.48882306e+00f, 8.19589645e-02f, 3.83180171e-01f, 4.36246842e-01f, -8.17277670e-01f, -9.35628951e-01f, 1.68141559e-01f,
  -1.41970289e+00f, -7.72727907e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    