/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.15695179e-01f, -2.62984484e-01f, 2.18909442e-01f, -4.17174727e-01f, -2.13221014e-01f, 2.74132431e-01f, 2.56640941e-01f, 2.01942220e-01f, -5.65175265e-02f, -3.34569097e-01f,
  -2.73854434e-01f, -2.04049081e-01f, -1.22572787e-01f, 4.28884476e-02f, 3.57925296e-01f, 1.48497686e-01f, 2.93858498e-01f, 4.77745861e-01f, 4.93608057e-01f, 2.90068537e-01f,
  -2.06098892e-02f, -1.34118423e-01f, 5.77979982e-02f, 1.54963896e-01f, -2.52937734e-01f, -3.00962366e-02f, -7.74525478e-02f, -1.66906565e-01f, 7.43077844e-02f, -2.10361853e-01f,
  -1.03886098e-01f, -5.56155592e-02f, 4.89070565e-02f, -8.81720632e-02f, -1.93371460e-01f, 3.18639576e-02f, -5.15772812e-02f, -6.20981976e-02f, -5.46672568e-02f, 4.49339487e-02f,
  -1.19258463e-01f, -3.94167118e-02f, 5.60606569e-02f, -5.60014062e-02f, -3.33279930e-02f, -6.58114180e-02f, 4.91295457e-02f, 1.78426251e-01f, 5.22457696e-02f, -1.38592683e-02f,
  -1.87124014e-01f, 2.82616764e-02f, -1.37583772e-02f, 1.23432137e-01f, 2.10708186e-01f, 8.00257400e-02f, 1.84703488e-02f, 1.09774403e-01f, 1.00079410e-01f, -9.96474400e-02f,
  -4.25641367e-04f, -9.24305059e-03f, 6.00844622e-03f, 4.33863923e-02f, -5.34015819e-02f, -4.69666943e-02f, 7.85290375e-02f, -4.89363223e-02f, 5.34338467e-02f, 2.64907461e-02f,
  1.65642928e-02f, 2.51274537e-02f, 1.43225789e-02f, 4.57413085e-02f, -6.07624874e-02f, 3.29016075e-02f, 7.96806440e-02f, 5.71098477e-02f, 1.36022819e-02f, -1.04211764e-02f,
  4.00046498e-04f, 5.61042503e-03f, -4.50779684e-02f, 7.92867038e-03f, 9.02323425e-02f, 1.14608273e-01f, -3.77418324e-02f, 5.85347973e-02f, 4.07642350e-02f, 1.22943390e-02f,
  -2.68969357e-01f, 1.25947103e-01f, -1.56028301e-01f, 4.52847481e-02f, -1.14396550e-02f, -6.00063093e-02f, -5.55459820e-02f, 1.80404913e-02f, -4.57184501e-02f, -9.15175583e-03f,
  6.65717497e-02f, 5.07430136e-02f, -9.09166336e-02f, -2.35332288e-02f, 3.01368013e-02f, -1.87290255e-02f, -2.77219284e-02f, -7.52071664e-02f, 5.31466380e-02f, -1.03560925e-01f,
  -3.20042819e-02f, -4.18339446e-02f, 2.40178965e-02f, -1.17713936e-01f, -4.34967726e-02f, 2.36354489e-02f, -1.00122057e-01f, -7.21746907e-02f, 1.47439614e-01f, -2.23495156e-01f,
  -5.07973909e-01f, 3.23103875e-01f, 6.95997894e-01f, -2.24098682e-01f, 2.04626452e-02f, -3.19062360e-02f, 2.06969708e-01f, -8.56208131e-02f, -1.15032852e-01f, 1.19216256e-01f,
  -5.93951717e-02f, -2.88074434e-01f, -8.58640820e-02f, -1.11979013e-02f, -1.11210592e-01f, 3.09883475e-01f, 3.67081046e-01f, 2.18786210e-01f, -2.02641711e-01f, -2.82636493e-01f,
  -1.13455005e-01f, -5.59372939e-02f, -7.69059956e-02f, -1.72154129e-01f, -3.78875285e-02f, -2.07668036e-01f, 4.10815537e-01f, 9.89286508e-03f, 3.64200808e-02f, 4.84080404e-01f,
  7.97662660e-02f, 1.09530307e-01f, 1.04396958e-02f, -1.43483192e-01f, 2.95768417e-02f, -7.01006725e-02f, -6.53602406e-02f, 4.25885655e-02f, -5.66204078e-02f, 6.23481311e-02f,
  -6.04625838e-03f, 2.62936018e-03f, -1.20146908e-01f, -1.03381583e-02f, -4.20158841e-02f, 4.20245230e-02f, 7.43194297e-02f, 1.07571721e-01f, -2.46923487e-03f, 7.68529922e-02f,
  5.72253354e-02f, 8.72297809e-02f, 7.74321035e-02f, 1.05121776e-01f, -1.99481216e-03f, 1.22898847e-01f, 1.02979779e-01f, -8.39663495e-04f, 3.16830166e-03f, 3.88156511e-02f,
  -4.48765233e-02f, 1.86674818e-02f, 2.64130183e-03f, 8.38844758e-03f, -3.61210816e-02f, -4.86268662e-02f, -1.44528914e-02f, -3.76821645e-02f, -2.49160510e-02f, -5.25116399e-02f,
  5.22098057e-02f, -2.00238302e-02f, -2.78011872e-03f, -1.27533115e-02f, 1.08985156e-02f, 1.39260925e-02f, -8.65155656e-04f, -1.61734652e-02f, 2.20388360e-02f, -1.47920167e-02f,
  -2.96142548e-02f, 7.69955516e-02f, -3.94072644e-02f, 1.38910338e-02f, 4.69570793e-02f, 1.31450361e-02f, 3.59491110e-02f, -6.91947415e-02f, -8.39357898e-02f, -1.59247126e-02f,
  -2.11735338e-01f, 1.63971797e-01f, -5.21437302e-02f, 4.30519804e-02f, 4.84099798e-02f, -2.32091843e-04f, 5.95562533e-02f, -2.90130749e-02f, -1.34304389e-02f, 1.13874553e-02f,
  3.18515045e-03f, -6.94497526e-02f, 6.32800534e-02f, 5.16684800e-02f, -4.17232364e-02f, -6.40996471e-02f, -8.84949490e-02f, -7.39903376e-02f, 3.48533061e-03f, 4.03132435e-04f,
  1.40641741e-02f, -3.32869925e-02f, -1.21376902e-01f, -2.45707873e-02f, -3.92195471e-02f, -6.59412295e-02f, 1.16839632e-02f, -3.90651822e-02f, 2.59530861e-02f, -1.53621152e-01f,
  -1.48004174e-01f, 2.55589604e-01f, -4.73861784e-01f, 2.10371539e-01f, 8.04579258e-02f, -1.50401086e-01f, -1.16796397e-01f, 1.23973399e-01f, 2.27088228e-01f, -2.78766882e-02f,
  7.62633607e-02f, 3.28890868e-02f, -5.91606312e-02f, 1.01307459e-01f, -1.16039440e-01f, -6.64171278e-02f, 1.76696360e-01f, -2.24690989e-01f, -5.20100117e-01f, -1.93482772e-01f,
  8.52731243e-02f, 7.87143633e-02f, -1.44877667e-02f, -3.59946750e-02f, 1.26734212e-01f, -1.80411294e-01f, -4.11019325e-02f, 1.40828863e-01f, 8.58877450e-02f, 1.85059503e-01f,
  -3.65615457e-01f, 1.30201355e-01f, -1.13730960e-01f, 5.59644736e-02f, -7.13177845e-02f, -9.48977023e-02f, -1.43273979e-01f, 1.42843137e-02f, -5.80929704e-02f, -3.82480510e-02f,
  1.11224568e-02f, 1.69612020e-02f, -7.39022270e-02f, -1.94281910e-03f, -4.26805466e-02f, -6.99013621e-02f, 3.75047922e-02f, -1.52572775e-02f, -2.20178813e-02f, -5.28323092e-02f,
  9.07213986e-02f, 6.78491518e-02f, 1.26777990e-02f, 2.83816643e-02f, -5.39870141e-03f, 1.63582899e-02f, -2.06513200e-02f, 6.25121891e-02f, -1.18844835e-02f, 4.25279252e-02f,
  7.08408654e-02f, -1.29762990e-03f, -4.00865823e-02f, 3.78027707e-02f, 2.88158678e-03f, 6.48681521e-02f, -5.54614365e-02f, -9.24394000e-03f, 2.82500070e-02f, -8.94491002e-02f,
  9.42250192e-02f, -1.20540425e-01f, 2.57882848e-02f, -3.27194110e-02f, 5.60418107e-02f, 2.66853571e-02f, -6.42450005e-02f, 1.56719293e-02f, 4.01895717e-02f, 6.59027845e-02f,
  7.60319456e-02f, 1.30624473e-02f, 9.40118451e-03f, -3.33159752e-02f, 9.11210477e-02f, -4.01641876e-02f, 2.80537102e-02f, -5.11696236e-03f, -1.61953606e-02f, 3.72589305e-02f,
  -8.14223140e-02f, 8.60940814e-02f, -6.14672117e-02f, -4.29811813e-02f, -1.86415426e-02f, 4.07181047e-02f, -1.23458840e-02f, 8.83423351e-03f, -7.60821402e-02f, -5.98661937e-02f,
  9.04209260e-03f, -1.14695460e-01f, -4.84916847e-03f, -4.75311972e-05f, -1.21246897e-01f, -3.93251777e-02f, 4.07936089e-02f, -1.10080555e-01f, 1.07833724e-02f, -6.45697676e-03f,
  8.27174038e-02f, -5.19952998e-02f, -1.11685097e-01f, -8.36471245e-02f, -1.79163255e-02f, -4.24337573e-02f, -1.03866979e-01f, -1.15089528e-01f, -4.97345775e-02f, -1.78808942e-01f,
  1.17085814e+00f, -7.52755627e-02f, -4.66995873e-03f, 3.60789448e-01f, -1.44681126e-01f, 1.48900766e-02f, -7.10522830e-02f, -7.33654201e-02f, 1.69018075e-01f, 3.93254757e-02f,
  -6.32744953e-02f, -6.28142357e-02f, -1.57725066e-01f, -2.58787334e-01f, -8.25608969e-02f, 9.33986306e-02f, -8.44277889e-02f, 6.55799806e-02f, -3.94917727e-02f, -8.41530338e-02f,
  -1.45716697e-01f, 1.35161161e-01f, 3.24295223e-01f, -1.31864175e-01f, 5.62551767e-02f, -1.42480418e-01f, 7.36225322e-02f, 1.30970687e-01f, -1.78941488e-01f, 5.04717045e-02f,
  3.01429003e-01f, 2.59298861e-01f, -8.43393952e-02f, -4.50339466e-02f, 1.56434495e-02f, 1.15053572e-01f, 4.51419614e-02f, 1.00470126e-01f, 6.34302665e-03f, 8.62025768e-02f,
  2.68651126e-03f, 4.45757844e-02f, -4.92906459e-02f, -4.52980064e-02f, 5.92263564e-02f, 4.98207547e-02f, -8.99848565e-02f, 4.12578620e-02f, -7.78377801e-03f, -1.46930972e-02f,
  -6.59925118e-02f, 3.09505090e-02f, 7.93746784e-02f, -1.00688487e-01f, -5.92870004e-02f, -5.83298132e-02f, -4.45990674e-02f, -5.31070828e-02f, -1.85727850e-01f, 1.03920631e-01f,
  7.52757629e-03f, 5.07017076e-02f, -1.77379921e-02f, 4.39478792e-02f, -3.71968038e-02f, 5.16634099e-02f, 8.02302286e-02f, 1.31998928e-02f, -6.13709539e-02f, 9.10337865e-02f,
  -9.70383957e-02f, 4.57352735e-02f, -8.03255886e-02f, 7.84690827e-02f, -2.14652922e-02f, 4.37717810e-02f, 3.21180485e-02f, -2.95466352e-02f, -6.83057457e-02f, -8.11895262e-03f,
  -2.60123629e-02f, -1.35944393e-02f, 1.79605391e-02f, -5.60477749e-02f, -3.94007154e-02f, -1.31462822e-02f, 3.08115296e-02f, -5.55858463e-02f, 1.41870603e-02f, 4.84029530e-03f,
  1.06833197e-01f, -2.74622858e-01f, 2.52329916e-01f, -3.18683758e-02f, 3.63487117e-02f, -3.28698903e-02f, -1.54463407e-02f, -2.50657517e-02f, 4.84705493e-02f, 6.70134556e-04f,
  -8.30740407e-02f, 3.88476513e-02f, 1.15303118e-02f, -9.24587175e-02f, 9.13438480e-03f, -1.93495154e-02f, 2.97291041e-03f, -4.32803817e-02f, -9.13510472e-03f, 7.98690990e-02f,
  -4.28115539e-02f, 3.26549299e-02f, 1.25806928e-01f, -4.91707996e-02f, 5.68957739e-02f, 7.04584643e-02f, 2.72998121e-02f, 6.62668124e-02f, -1.09166121e-02f, 1.21093936e-01f,
  7.40292072e-02f, 6.27589524e-02f, -5.86826243e-02f, -6.09206893e-02f, 1.33923471e-01f, 2.65017867e-01f, 5.45856118e-01f, 1.39766559e-01f, -5.75048402e-02f, 4.65325341e-02f,
  1.41197369e-01f, -9.01505053e-02f, -1.13750227e-01f, -1.69170797e-01f, 2.40046233e-02f, 1.76730886e-01f, -6.14913329e-02f, -1.18118323e-01f, -5.79905920e-02f, -3.10522988e-02f,
  -1.28965452e-01f, -6.69562370e-02f, -2.65139103e-01f, -1.73331097e-01f, -1.77282944e-01f, -1.88932344e-01f, -3.25349718e-02f, 2.36033686e-02f, 1.36046307e-02f, -4.40500379e-01f,
  -1.44945353e-01f, -4.11525108e-02f, 2.75730435e-02f, -8.93887132e-02f, -8.49848613e-02f, -7.07508177e-02f, 1.89476758e-02f, -7.84086511e-02f, -6.41000867e-02f, -1.05766617e-02f,
  -3.66609059e-02f, -5.91120981e-02f, 3.16083618e-03f, -8.63097701e-03f, 1.54921282e-02f, 3.13785970e-02f, -1.89055204e-02f, -1.32539988e-01f, -1.39316633e-01f, 4.30614613e-02f,
  -3.91244553e-02f, -7.80222118e-02f, 3.40032876e-02f, -3.63625819e-03f, 1.50900171e-03f, -1.35865867e-01f, -1.42462626e-01f, -1.65848032e-01f, -1.15609713e-01f, -1.55622423e-01f,
  -5.21453209e-02f, 9.09583718e-02f, -3.04507390e-02f, 2.61757411e-02f, 6.94126785e-02f, 9.32899415e-02f, -5.46237640e-02f, 7.09362775e-02f, -6.11197464e-02f, 5.46240620e-02f,
  -1.68362204e-02f, 7.92593509e-02f, 4.01543602e-02f, 4.88137528e-02f, -7.42030069e-02f, -3.90678942e-02f, 2.23474838e-02f, -1.79217309e-02f, -1.73975527e-02f, -1.94973797e-02f,
  8.26060325e-02f, 4.90885824e-02f, -4.50081716e-04f, -1.75067072e-03f, -1.29238768e-02f, 2.74182409e-02f, 7.26873353e-02f, 4.18287143e-02f, 6.58503361e-03f, 6.60082996e-02f,
  7.26974308e-02f, 7.20141456e-02f, 1.58799789e-03f, -2.01582666e-02f, 4.45766142e-03f, -5.54041304e-02f, 2.44598705e-02f, -1.89111996e-02f, 3.80939990e-02f, -8.86478648e-03f,
  6.08365200e-02f, 3.44499797e-02f, 4.81641516e-02f, 3.98994125e-02f, 9.63327587e-02f, 1.02952309e-02f, 7.08162114e-02f, 1.15193091e-02f, 1.25950836e-02f, -2.49995477e-02f,
  2.08520740e-02f, 7.15003386e-02f, 4.35155779e-02f, 1.27878234e-01f, 3.84009518e-02f, 4.72855903e-02f, 9.11387876e-02f, 1.02822758e-01f, 1.35547549e-01f, 2.70999104e-01f,
  -5.39297819e-01f, -1.36591224e-02f, 2.00664639e-01f, -3.22852731e-01f, 4.20320064e-01f, 3.53033721e-01f, 4.56957638e-01f, -3.37035507e-02f, -8.94882753e-02f, 5.63117154e-02f,
  -1.89004362e-01f, -1.11740328e-01f, -1.23635918e-01f, -1.31454259e-01f, -3.01381975e-01f, 2.80765235e-01f, 2.06002474e-01f, -2.85206527e-01f, 2.90203467e-02f, 2.13705122e-01f,
  1.63600281e-01f, -1.91420056e-02f, -5.44926643e-01f, -2.29442492e-01f, 1.91196099e-01f, 2.50703394e-01f, 1.03843294e-01f, -5.43893017e-02f, -1.16575755e-01f, 7.18005328e-03f,
  5.83341345e-02f, -1.51807874e-01f, -3.47950272e-02f, -2.34474048e-01f, 8.62423480e-02f, -7.35107660e-02f, 4.90416586e-02f, -1.35893136e-01f, -8.82631261e-03f, -4.02221605e-02f,
  -1.53513417e-01f, -9.74442959e-02f, -4.28473130e-02f, -7.73819089e-02f, -5.44393882e-02f, 1.43038305e-02f, -1.04269989e-01f, -1.68221146e-01f, -1.43470719e-01f, 3.84671018e-02f,
  1.68370530e-01f, 3.38893719e-02f, -1.96152367e-02f, 4.24596705e-02f, -7.41624087e-02f, -4.86499183e-02f, -1.17370375e-01f, -1.60404414e-01f, -1.01962604e-01f, -8.99380818e-03f,
  -2.38825325e-02f, 3.96530814e-02f, 5.93326055e-02f, -1.76839232e-02f, 8.15889388e-02f, -1.15219401e-02f, 5.31519204e-02f, 2.00728085e-02f, 6.35003895e-02f, 6.97034746e-02f,
  -2.13539172e-02f, 8.59628152e-03f, -4.62758169e-02f, 5.06065041e-03f, -6.42544590e-03f, -2.09813062e-02f, 5.95680960e-02f, -5.80457710e-02f, -4.44951244e-02f, -2.74974108e-02f,
  -6.28980920e-02f, -4.81821336e-02f, 3.69475526e-03f, -3.98165807e-02f, -1.66043799e-04f, -6.96554333e-02f, -6.06579147e-03f, 3.78581844e-02f, 5.75842783e-02f, 2.95474799e-03f,
  -8.71191770e-02f, -1.29278764e-01f, -2.54816338e-02f, -8.82836804e-02f, -3.57706286e-02f, -5.30368164e-02f, -6.90702870e-02f, -9.67447907e-02f, -1.26141042e-01f, -1.93112195e-02f,
  -4.76598479e-02f, -4.06671241e-02f, -2.09444351e-02f, 3.73003185e-02f, 6.28890023e-02f, 5.49146207e-03f, -3.80330570e-02f, 4.08672504e-02f, -8.79642814e-02f, 2.69952565e-02f,
  -2.57523172e-03f, 1.48594445e-02f, 1.22783050e-01f, 3.84219806e-03f, 5.15096523e-02f, 3.66562307e-02f, 1.62113041e-01f, 1.43992081e-01f, 2.42547542e-02f, 2.00073063e-01f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  9.79019582e-01f, 7.37209260e-01f, 5.93595266e-01f, 2.73994327e-01f, -2.30740290e-02f, 3.69753480e-01f, 7.41251588e-01f, 3.57365459e-01f, -2.38428432e-02f, 1.97078943e-01f,
  -1.58625655e-02f, -4.34977651e-01f, -1.77746370e-01f, -2.99326152e-01f, 3.30431387e-02f, -3.75620127e-02f, -3.23505729e-01f, -1.72098398e-01f, -1.26052588e-01f, 2.68956125e-02f,
  -2.31931299e-01f, 7.78468177e-02f, 2.05031876e-03f, -1.98186971e-02f, 5.49181029e-02f, -1.45832360e-01f, 1.15132205e-01f, -4.89425426e-03f, 7.02519789e-02f, -9.71167833e-02f,
  3.00941795e-01f, 5.51138222e-01f, -4.26955253e-01f, -3.28325510e-01f, 1.26019478e-01f, -1.52221665e-01f, -5.42823710e-02f, -6.00673407e-02f, -1.21162288e-01f, -4.57398705e-02f,
  -1.75136432e-01f, 9.74335894e-03f, 3.23063321e-02f, 1.33814320e-01f, 1.25326157e-01f, 6.38153180e-02f, 1.19173653e-01f, 1.17703632e-01f, 6.59345165e-02f, 1.99717879e-01f,
  -7.22205192e-02f, 4.45117801e-02f, 1.36148944e-01f, -2.08837050e-03f, 1.36116251e-01f, -1.73127502e-01f, 1.73949808e-01f, 1.44759908e-01f, 1.59560829e-01f, 2.48285100e-01f,
  -1.57335684e-01f, 3.46492939e-02f, -3.54658184e-03f, 6.66364748e-03f, 1.60531610e-01f, -4.26904522e-02f, -9.17368308e-02f, 4.02073748e-02f, 3.21248882e-02f, 7.35694766e-02f,
  -6.74712285e-02f, 1.26964837e-01f, 2.78474465e-02f, 4.73068655e-02f, -1.27297580e-01f, 8.34456161e-02f, -2.81563681e-02f, -5.26859872e-02f, 5.29634096e-02f, -6.35744557e-02f,
  3.51655483e-02f, 2.01631915e-02f, 5.53817786e-02f, 1.90485045e-01f, 1.09572681e-02f, 2.56707948e-02f, -2.97675859e-02f, 6.73897490e-02f, -7.20761195e-02f, 1.63681284e-02f,
  -4.64301348e-01f, 4.16954532e-02f, 4.80742659e-03f, -6.78843558e-02f, -2.32670531e-02f, -8.54167249e-03f, -1.46998847e-02f, -1.09378323e-01f, -1.50663763e-01f, 6.17633276e-02f,
  2.91285701e-02f, -5.33920061e-03f, 1.49453729e-01f, 1.17829956e-01f, -1.16369791e-01f, -1.69385895e-01f, -5.68931177e-02f, 2.74453480e-02f, -8.07602778e-02f, -6.26211539e-02f,
  -1.32588327e-01f, -2.10172907e-01f, -2.67891079e-01f, -1.27801254e-01f, -2.14911550e-01f, -4.32925373e-01f, -2.02124536e-01f, -1.59784317e-01f, -1.08908631e-01f, -2.32240278e-03f,
  -1.61453366e-01f, 1.82799071e-01f, 1.10760935e-01f, 3.36389303e-01f, -2.69771162e-02f, -4.38202620e-01f, -4.73084003e-01f, -4.03413951e-01f, 3.52355875e-02f, 7.88971856e-02f,
  -2.00294912e-01f, 1.87012836e-01f, 1.52133137e-01f, 5.64655103e-02f, -1.77614883e-01f, 2.07731396e-01f, 7.29362249e-01f, 3.52529287e-01f, -4.58663434e-01f, -4.62233484e-01f,
  3.33932638e-01f, 1.54422268e-01f, -4.38514166e-02f, -9.36473534e-02f, 2.52442598e-01f, -2.01447383e-01f, 7.13964030e-02f, 1.08422237e-02f, -7.01031312e-02f, 1.06446648e+00f,
  2.48231366e-01f, 9.78547931e-02f, -7.34978989e-02f, 3.13408114e-03f, -6.99831620e-02f, 1.11564882e-01f, 1.84782371e-02f, 3.62231582e-02f, -1.42561972e-01f, 1.75475143e-02f,
  1.70475453e-01f, 2.20146421e-02f, 2.11535767e-01f, 5.89179881e-02f, 9.46613494e-03f, -1.03940368e-01f, 4.76634242e-02f, 1.33927152e-01f, 3.25886980e-02f, -2.01179013e-01f,
  3.14380914e-01f, -1.27897263e-01f, -2.61076868e-01f, -6.74454197e-02f, -9.11888182e-02f, 2.39481688e-01f, -4.12606835e-01f, 9.44361016e-02f, -1.96809351e-01f, 9.46702957e-02f,
  -9.22904909e-02f, 9.25093424e-03f, 1.10742718e-01f, 1.05662689e-01f, 5.66229708e-02f, 2.86659878e-02f, 1.96472809e-01f, -9.77539569e-02f, 1.41949192e-01f, -9.83233228e-02f,
  1.72643084e-02f, 4.72755358e-03f, 8.05503055e-02f, 5.14058694e-02f, -1.03300489e-01f, 1.68795079e-01f, -7.32118310e-03f, -3.08238342e-02f, -2.18408909e-02f, -4.19148207e-02f,
  4.10871729e-02f, -4.84714992e-02f, 1.58899486e-01f, 5.58066741e-03f, -1.73574667e-02f, 1.99956015e-01f, 8.02870244e-02f, -2.44276803e-02f, 6.60246797e-03f, 4.20017615e-02f,
  -4.17596906e-01f, 4.36760224e-02f, 2.11247474e-01f, -1.48083016e-01f, 6.18032925e-02f, -9.35329273e-02f, 1.76445007e-01f, -9.48065985e-03f, 1.03043690e-01f, -1.66769132e-01f,
  -1.73441142e-01f, 1.17378742e-01f, 1.96882579e-02f, 1.26771918e-02f, -1.68269858e-01f, 7.23595694e-02f, 5.97832389e-02f, 1.54728256e-03f, -7.33175054e-02f, -3.37833837e-02f,
  -1.46129027e-01f, -3.91098708e-01f, -5.37428439e-01f, -9.02615339e-02f, -7.79591799e-02f, -3.10811877e-01f, -2.88014501e-01f, -3.54714602e-01f, -5.04255474e-01f, -7.43426800e-01f,
  1.09468377e+00f, -7.48187363e-01f, 2.27719516e-01f, 1.82605118e-01f, -2.39421770e-01f, -3.13100293e-02f, -4.71478909e-01f, -1.50981411e-01f, 6.34722635e-02f, -2.83409506e-01f,
  -2.88127027e-02f, 1.44397482e-01f, 2.60279357e-01f, 1.72901750e-01f, 3.03422570e-01f, -1.69377148e-01f, -2.01663658e-01f, 4.87297833e-01f, 5.44722855e-01f, -1.84913296e-02f,
  -1.59685358e-01f, -1.57134473e-01f, 3.72873783e-01f, 1.80395216e-01f, -2.80707419e-01f, 2.44462207e-01f, -1.84708208e-01f, -2.22002357e-01f, -2.10665807e-01f, -3.74412894e-01f,
  -6.72223559e-03f, -1.11640520e-01f, 1.80318668e-01f, -2.68519055e-02f, -6.71573728e-02f, 1.02708876e-01f, 1.70205198e-02f, -7.54102692e-02f, -4.03515883e-02f, -3.74191739e-02f,
  -1.76213533e-02f, 1.49929672e-02f, 9.66874808e-02f, -8.19853470e-02f, -6.61600158e-02f, -2.11123899e-02f, 2.05051638e-02f, 1.23442419e-01f, 2.23233271e-02f, -3.20722200e-02f,
  -2.31602445e-01f, -7.67405853e-02f, -4.82437154e-03f, 9.36871395e-03f, 2.17220023e-01f, 1.07768528e-01f, -1.72322452e-01f, -3.27870026e-02f, 1.16552383e-01f, -2.44866572e-02f,
  -3.55220139e-02f, 6.10041134e-02f, 8.38983953e-02f, -7.79390782e-02f, 1.47724986e-01f, -2.42602471e-02f, -4.03179415e-03f, -1.05006285e-02f, 8.19019824e-02f, 1.32203558e-02f,
  -1.24389358e-01f, 4.54890169e-02f, -1.56850517e-02f, -8.97808187e-03f, 8.78305212e-02f, -1.19913155e-02f, -4.84421328e-02f, -4.47568931e-02f, 1.93535388e-02f, -7.55654415e-03f,
  1.47220805e-01f, -3.96314077e-02f, -6.77221939e-02f, 2.86178477e-02f, -1.76451489e-01f, 5.26084676e-02f, 1.39467508e-01f, -4.06751521e-02f, -1.90044455e-02f, -7.35191777e-02f,
  -3.11283857e-01f, 3.97963136e-01f, 1.05940886e-01f, 5.53675881e-03f, -2.95231491e-02f, -2.82469764e-02f, 7.55390748e-02f, 1.13200524e-03f, -1.62185118e-01f, -1.08525895e-01f,
  -4.10619192e-02f, 3.84408720e-02f, -3.37380841e-02f, 2.00659502e-02f, 9.75870416e-02f, 8.17870349e-02f, -4.30159010e-02f, 3.34409513e-02f, 1.53524354e-02f, -1.99783042e-01f,
  -4.03120443e-02f, 7.24912584e-02f, 6.79811761e-02f, 1.44464254e-01f, 2.46682577e-02f, 1.96728587e-01f, -2.25432012e-02f, -9.87917408e-02f, 1.44959018e-01f, -2.74725169e-01f,
  -5.35194159e-01f, -2.69948356e-02f, 5.12647033e-01f, -3.92983228e-01f, 3.39518249e-01f, 4.79060978e-01f, 2.04748258e-01f, 3.10327917e-01f, -1.62932187e-01f, -1.35835335e-01f,
  5.00269592e-01f, -3.21151733e-01f, -6.41340137e-01f, -2.93119073e-01f, -1.51620016e-01f, 7.14424998e-02f, -4.28238600e-01f, -4.60082442e-01f, 1.70754284e-01f, 5.18032372e-01f,
  -2.35439409e-02f, -4.40227777e-01f, -2.62154847e-01f, -5.79011850e-02f, -3.80177706e-01f, -5.63680053e-01f, -5.65096796e-01f, -3.35795403e-01f, 3.61171551e-02f, -9.82305050e-01f,
  9.38102379e-02f, 3.98072958e-01f, 1.76427409e-01f, -3.11390013e-01f, 4.03969772e-02f, 6.77801669e-02f, 3.77604932e-01f, -3.46089415e-02f, 3.78827900e-02f, -4.20679934e-02f,
  7.07511455e-02f, 4.06754106e-01f, -1.27775773e-01f, 1.35041699e-01f, -6.57794671e-03f, 2.86316544e-01f, 7.07859546e-02f, 1.74033478e-01f, -2.75824219e-01f, 3.70284796e-01f,
  -9.88762081e-02f, -6.64808750e-02f, 4.47908491e-02f, 3.86674225e-01f, 3.10986459e-01f, -1.90161005e-01f, 1.68280035e-01f, 9.34714749e-02f, 1.47110224e-01f, -6.51441276e-01f,
  -3.16653997e-02f, 3.95569541e-02f, 1.46721616e-01f, 9.35095027e-02f, -1.06826402e-01f, 6.30361736e-02f, 4.91505563e-02f, -2.72499416e-02f, 3.97444665e-02f, -1.00876942e-01f,
  -1.73847470e-02f, 9.17120352e-02f, 5.08886296e-03f, 6.35317191e-02f, -1.67748585e-01f, 1.69592023e-01f, 5.24719432e-02f, -3.17606449e-01f, 7.57062435e-03f, -6.09818436e-02f,
  3.61796804e-02f, -2.78864726e-02f, 3.49477604e-02f, 2.83133268e-04f, 6.24188669e-02f, -9.65492129e-02f, 5.39498925e-02f, 9.34459791e-02f, -5.15912883e-02f, 1.62962168e-01f,
  -4.86564219e-01f, 4.08022366e-02f, -3.24681938e-01f, 6.17961138e-02f, -1.43486913e-02f, -9.57252234e-02f, -2.08729059e-01f, 7.12750405e-02f, -9.72755775e-02f, -4.88312803e-02f,
  1.96486726e-01f, 9.69052538e-02f, -1.11611493e-01f, -1.82830673e-02f, -1.07179932e-01f, 5.97789586e-02f, -4.09454964e-02f, -2.64640033e-01f, 1.35666430e-01f, 1.84319377e-01f,
  -4.64386754e-02f, -3.10538709e-01f, -5.57320356e-01f, -1.01640157e-01f, -3.04688811e-01f, -4.76020783e-01f, -4.42681193e-01f, -1.82101995e-01f, -3.14568937e-01f, -1.16188943e+00f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  4.89516616e-01f, 8.61761391e-01f, 8.11700284e-01f, -1.81276247e-01f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  1.41063720e-01f, -5.28128147e-01f, -5.67934811e-01f, 5.17272294e-01f, 2.29910687e-02f, 2.22206250e-01f, -3.93841900e-02f, -6.48042202e-01f, -1.77266642e-01f, -3.72886479e-01f,
  1.79768771e-01f, -9.70610976e-02f, -3.09310704e-01f, -5.03905654e-01f, 3.99785280e-01f, -1.64414523e-03f, 2.76729465e-01f, -3.14803608e-02f, -2.38871500e-01f, -2.31575489e-01f,
  4.92025405e-01f, -5.76946139e-01f, 4.52515781e-01f, -3.18925679e-01f, -1.75794899e-01f, 2.46586516e-01f, 4.09993529e-01f, 7.67367840e-01f, 2.57851005e-01f, -2.36366376e-01f,
  2.39119306e-01f, -3.88331562e-01f, 5.98657615e-02f, 3.26990902e-01f, -1.80538058e-01f, 4.08707231e-01f, 3.59919906e-01f, 3.26043308e-01f, -1.03931334e-02f, 7.05514178e-02f,
  -5.12762256e-02f, -5.99196672e-01f, 1.69296071e-01f, 7.29351461e-01f, -4.51618433e-01f, 2.10759062e-02f, -1.44656360e-01f, 1.86546713e-01f, -2.29538724e-01f, -5.27613223e-01f,
  -1.15846373e-01f, 3.77174407e-01f, 3.67261283e-02f, -3.83698009e-02f, -8.14687908e-02f, -2.14988366e-01f, 2.29901299e-01f, -6.81417942e-01f, -2.97470987e-01f, -5.08253515e-01f,
  -1.08098835e-01f, -6.21603206e-02f, 3.10253710e-01f, 2.34406233e-01f, -5.40939629e-01f, 3.03398520e-01f, -5.00900865e-01f, -6.01186454e-01f, -1.96683004e-01f, -3.15471776e-02f,
  -4.94765133e-01f, 2.98057288e-01f, 8.30173016e-01f, -5.87366939e-01f, -2.75634915e-01f, 5.88141084e-01f, 2.08382115e-01f, 1.68034598e-01f, -6.44244179e-02f, 2.82841980e-01f,
  1.27544373e-01f, -7.39822984e-01f, 4.73190278e-01f, -4.34361547e-01f, -2.70698555e-02f, -1.00061573e-01f, 1.32779554e-01f, -5.13964951e-01f, 1.65876523e-01f, -2.37894151e-02f,
  2.34484505e-02f, -3.36126119e-01f, 2.86305606e-01f, -4.91884500e-01f, 5.33703625e-01f, 1.81956083e-01f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  3.32557112e-01f, 1.52376622e-01f, 6.99845314e-01f, -4.55486536e-01f, 7.36639082e-01f, 6.56318963e-02f, 1.03114569e+00f, 1.08296573e+00f, 1.24418950e+00f, -4.76767361e-01f,
  2.02959180e-01f, -4.41191643e-01f, 2.41285846e-01f, 3.45156640e-01f, -1.16356421e+00f, 1.26553524e+00f, -8.80902559e-02f, 9.20481831e-02f, 8.57785285e-01f, 9.91284609e-01f,
  5.96030653e-01f, 1.04466617e+00f, -1.25940442e+00f, -8.01267982e-01f, 8.85599375e-01f, 1.29359293e+00f, 4.60287720e-01f, -1.11958194e+00f, 7.72063375e-01f, 4.05743837e-01f,
  -4.63649541e-01f, -2.05770717e-03f, 7.36060977e-01f, 2.07342997e-01f, 4.47560430e-01f, 1.82659775e-01f, 5.11146784e-01f, -5.98899014e-02f, 8.97205770e-01f, 1.64370820e-01f,
  -7.00036108e-01f, 5.49432337e-01f, 2.78423112e-02f, -7.49010324e-01f, 1.17226779e+00f, -1.97142005e-01f, 1.04682148e+00f, 6.99148560e-03f, 1.78032190e-01f, 2.39774108e-01f,
  5.61422467e-01f, -4.04335231e-01f, -4.62373383e-02f, -1.11905374e-01f, 8.11823756e-02f, 3.72044683e-01f, 3.96929473e-01f, 7.84345448e-01f, -4.54598010e-01f, -8.74413669e-01f,
  -5.64832449e-01f, 1.74921596e+00f, 5.18206716e-01f, -1.21349204e+00f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  8.48232150e-01f, 9.20340344e-02f, -1.30078077e-01f, 5.19777536e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  7.73770750e-01f, -6.98911905e-01f, 6.98287711e-02f, -1.53504574e+00f, 4.64604408e-01f, -1.63493657e+00f, 1.57183254e+00f, -7.77248800e-01f, 4.86833125e-01f, 8.71757567e-01f,
  1.91837400e-01f, 1.39149201e+00f, 5.99714100e-01f, -2.62502223e-01f, -8.01488087e-02f, -2.60516763e-01f, -2.03145161e-01f, -2.08192572e-01f, -1.55723184e-01f, -1.88569836e-02f,
  -8.77903819e-01f, -1.07057762e+00f, 3.29427347e-02f, 4.54438031e-01f, -7.65768468e-01f, 1.30404150e+00f, 9.86731231e-01f, 1.02072328e-01f, -1.31967723e+00f, 1.48359865e-01f,
  9.15829360e-01f, -2.09065035e-01f, 1.00369170e-01f, -1.53494656e-01f, 8.31324041e-01f, -7.32372463e-01f, 6.69954419e-02f, 1.99896872e-01f, -8.62034261e-01f, -8.80004346e-01f,
  5.87050021e-02f, 1.59784555e+00f, -4.91130412e-01f, -3.80637348e-01f, -1.22448958e-01f, -1.41887736e+00f, 2.58803159e-01f, 7.04398215e-01f, -7.23284602e-01f, 1.19394936e-01f,
  -5.28747737e-01f, 7.36924052e-01f, -2.62146384e-01f, 1.22045767e+00f, -1.46624112e+00f, 2.08140671e-01f, 5.16217910e-02f, -8.97538885e-02f, 5.80334887e-02f, 4.43594366e-01f,
  9.79992568e-01f, -1.88326180e+00f, -8.79261196e-01f, -1.47873747e+00f, 3.28751773e-01f, -9.38810587e-01f, -8.41153115e-02f, 6.97350800e-01f, -4.51858163e-01f, 5.48937023e-01f,
  -1.23467231e+00f, -1.66465603e-02f, 4.65088934e-01f, 1.25403750e+00f, 7.22850561e-01f, -1.25162435e+00f, 1.83999017e-01f, 7.40210474e-01f, -3.95953864e-01f, -7.44620860e-01f,
  1.01317585e+00f, 5.39753973e-01f, 7.70890653e-01f, 2.82648742e-01f, -9.60333943e-02f, 6.15902007e-01f, 4.04867858e-01f, -8.84109437e-02f, 6.60555586e-02f, -5.91027796e-01f,
  -9.37400877e-01f, 1.29591656e+00f, -7.25868583e-01f, 1.12192678e+00f, -6.11804008e-01f, -4.22103345e-01f, -3.58945727e-01f, 3.57542366e-01f, -1.75587857e+00f, -1.45546585e-01f,
  4.24600124e-01f, 9.83963490e-01f, 1.11244154e+00f, -5.70929646e-01f, -5.59025228e-01f, -8.74245465e-01f, 1.78094015e-01f, 1.12542830e-01f, -2.65466452e-01f, -3.43136907e-01f,
  1.48629963e-01f, 4.93695617e-01f, -4.35077161e-01f, 1.21561766e+00f, 1.18205917e+00f, 3.51799160e-01f, -8.07517350e-01f, -7.65538573e-01f, 5.37254035e-01f, 3.60431075e-01f,
  -7.78320208e-02f, -8.38421762e-01f, 1.39747411e-01f, 2.54347338e-03f, 4.27759618e-01f, -5.65744042e-01f, -7.52656281e-01f, 4.83600408e-01f, 2.18739092e-01f, -1.30925512e+00f,
  1.05609047e+00f, -1.14317107e+00f, -8.68635118e-01f, 9.83599186e-01f, 5.28821826e-01f, 5.92372060e-01f, 1.73969865e-01f, -1.83657920e+00f, -9.16074216e-01f, 4.09926295e-01f,
  -5.40761828e-01f, -6.50259256e-01f, 5.31941533e-01f, -3.75337780e-01f, -6.80534065e-01f, -9.33491349e-01f, 9.77524698e-01f, 3.15232068e-01f, 2.27194205e-01f, -7.41244912e-01f,
  -9.60089803e-01f, -2.22433656e-01f, -1.09733224e+00f, -5.11028051e-01f, 5.50833941e-01f, -7.28601873e-01f, -9.44667101e-01f, 7.11795092e-01f, -1.14750290e+00f, 6.31823480e-01f,
  6.38342977e-01f, 9.40517664e-01f, -1.70437348e+00f, 2.42989764e-01f, 8.21385682e-01f, -2.49115586e-01f, 1.34611678e+00f, 7.34691858e-01f, 1.30575001e+00f, -1.48231089e+00f,
  -1.10542107e+00f, -1.96011949e+00f, -6.55362308e-01f, -2.48317495e-01f, -1.08202291e+00f, -1.68095756e+00f, -1.15063536e+00f, 6.05774939e-01f, -1.07288420e+00f, -3.65373999e-01f,
  2.70613164e-01f, 2.09706515e-01f, -6.65956497e-01f, 5.09828269e-01f, -7.70946920e-01f, -5.03600180e-01f, 7.41474330e-01f, 1.00340104e+00f, 2.22451895e-01f, 5.37966967e-01f,
  3.47441971e-01f, -1.33511174e+00f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  4.02596951e-01f, -1.91011146e-01f, -3.32788676e-01f, -2.32994497e-01f, 4.57144380e-01f, -2.83035755e-01f, -2.76579410e-01f, 7.39399612e-01f, 3.86588752e-01f, -2.89570153e-01f,
  7.23251343e-01f, -8.40859830e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    