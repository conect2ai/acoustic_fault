/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.39593825e-01f, -4.13570881e-01f, -7.05539137e-02f, -1.27739444e-01f, -2.36391351e-02f, 1.92556456e-01f, -3.30306664e-02f, 7.01636821e-02f, -1.17048420e-01f, -2.59127498e-01f,
  -5.35146520e-02f, 1.20740063e-01f, 6.15290701e-02f, 2.09335670e-01f, 2.93066889e-01f, -8.13830420e-02f, -2.13480309e-01f, 2.54965663e-01f, 4.40351963e-01f, 2.36755326e-01f,
  2.42632832e-02f, -7.61239827e-02f, 5.99474786e-03f, 5.16530350e-02f, -3.34968060e-01f, 3.10370233e-02f, -3.06700796e-01f, -1.72768146e-01f, -5.14098331e-02f, -3.57248813e-01f,
  -3.89242992e-02f, -1.38430193e-01f, 2.63273716e-01f, 6.96602613e-02f, 5.16323932e-03f, 2.03138012e-02f, 7.96721876e-02f, -1.53404027e-01f, 6.83295578e-02f, -1.12942457e-01f,
  5.17938286e-02f, 1.63399186e-02f, 8.84928480e-02f, -7.69026503e-02f, -7.22894445e-02f, -2.24247277e-02f, -1.32056817e-01f, -2.57664844e-02f, 6.65868372e-02f, -1.26989603e-01f,
  2.39225924e-02f, -6.74554631e-02f, 1.37679139e-02f, -5.48630860e-03f, 2.70705335e-02f, 1.69620216e-01f, -6.01396225e-02f, -2.17907839e-02f, 1.65727913e-01f, -1.18098974e-01f,
  1.22648075e-01f, -4.11008811e-03f, 6.50744736e-02f, -4.73735854e-02f, -5.69361337e-02f, -4.95731235e-02f, -4.12954986e-02f, 1.45331081e-02f, 1.03847701e-02f, -1.39661595e-01f,
  4.13553677e-02f, -6.35627285e-02f, 3.81067321e-02f, -4.76906262e-02f, -4.26890813e-02f, 9.50712711e-03f, 5.65960072e-02f, -6.71309307e-02f, -8.36069975e-03f, -7.87871629e-02f,
  9.60789155e-03f, 2.29968280e-02f, -1.14411898e-01f, -3.44210118e-02f, -2.90422644e-02f, -3.41633223e-02f, -5.60454950e-02f, -6.24260753e-02f, 3.12693720e-03f, -1.16321084e-03f,
  -4.35669646e-02f, 2.34571069e-01f, -1.15193918e-01f, 2.09574997e-02f, -5.82095189e-03f, -1.43247303e-02f, -7.56771164e-03f, 1.14834629e-01f, -7.77021721e-02f, 4.46015745e-02f,
  5.88101894e-02f, 8.85613114e-02f, -1.14025241e-02f, 5.96532710e-02f, 7.44060278e-02f, -1.30162099e-02f, -4.64075059e-02f, 4.13174368e-02f, 1.63110513e-02f, -2.24058032e-02f,
  3.77639905e-02f, 2.21632645e-02f, 1.34454578e-01f, 3.58527228e-02f, 2.05112323e-02f, 1.28949925e-01f, 3.86436358e-02f, 4.07620929e-02f, 2.28262186e-01f, -1.02389172e-01f,
  -4.53455210e-01f, -3.98041725e-01f, 6.25234991e-02f, 1.68642700e-01f, 8.10674429e-02f, -2.22882673e-01f, -3.69163096e-01f, -1.12908974e-01f, 1.70133606e-01f, -1.92383975e-01f,
  -5.79672195e-02f, 2.63336688e-01f, 1.07894756e-01f, 5.71563691e-02f, -2.66376048e-01f, -3.28740627e-01f, -5.28122224e-02f, -2.31365301e-03f, -8.61565471e-02f, -1.44369721e-01f,
  5.49061149e-02f, -8.31271932e-02f, -4.73330170e-02f, -7.18890131e-03f, 1.51842296e-01f, 8.61407071e-02f, -1.47996709e-01f, -4.87268232e-02f, -1.26515597e-01f, 4.35929969e-02f,
  -2.18548551e-02f, -4.48569059e-02f, 6.47154003e-02f, -6.47011548e-02f, 3.00836489e-02f, -7.25910515e-02f, -7.08727539e-02f, 4.60627638e-02f, 8.99921954e-02f, 2.68211216e-02f,
  1.03334635e-01f, 2.42064651e-02f, 1.04432993e-01f, 8.50133821e-02f, 7.24585215e-03f, 3.65684144e-02f, 1.70379058e-02f, -2.72102263e-02f, 9.13365651e-03f, -8.54355469e-02f,
  -3.93220782e-02f, -1.33212894e-01f, -1.16492666e-01f, 5.64922486e-03f, -9.61116888e-03f, 2.60221548e-02f, -7.72498399e-02f, 3.84094864e-02f, -1.67602837e-01f, -1.49681523e-01f,
  5.64777739e-02f, -1.10032642e-02f, 5.34184910e-02f, -1.89989600e-02f, -8.88935104e-02f, 1.67224859e-03f, -7.90023431e-03f, -3.10757477e-02f, -3.91520746e-03f, -4.29942198e-02f,
  8.47467259e-02f, -2.25901511e-02f, 9.49884653e-02f, -6.46288181e-03f, 3.31662484e-02f, -2.52972431e-02f, -3.58408870e-04f, -2.92905373e-03f, 6.80422634e-02f, 1.15421023e-02f,
  2.51582433e-02f, -6.07314073e-02f, 2.03587916e-02f, -3.05592585e-02f, 5.17535163e-03f, 2.38629561e-02f, -9.63686872e-03f, 4.45767120e-02f, 4.93761376e-02f, 4.40723300e-02f,
  1.06510930e-01f, -3.24903824e-03f, 1.44388145e-02f, -9.05758962e-02f, -2.18645278e-02f, 2.32488271e-02f, 1.26009490e-02f, -4.39448133e-02f, 8.58366117e-02f, -8.64256639e-03f,
  2.92875879e-02f, -1.92133561e-02f, -6.16063587e-02f, 3.37827345e-03f, -2.31584869e-02f, 5.42751886e-03f, -7.17568472e-02f, 9.36569367e-03f, -2.65808161e-02f, 3.50814569e-03f,
  -8.49487260e-02f, -1.19441815e-01f, -1.25991523e-01f, -9.97371301e-02f, 7.51182018e-03f, -9.05385315e-02f, -6.90422654e-02f, -9.49040875e-02f, -1.59513593e-01f, -3.45567852e-01f,
  -4.47232693e-01f, -1.04130037e-01f, 9.60362181e-02f, -2.16264963e-01f, -1.13859139e-01f, -2.31189698e-01f, -1.93295956e-01f, -2.16501400e-01f, -1.19302325e-01f, -1.06636517e-01f,
  -2.73328125e-01f, -2.70042177e-02f, -2.65342053e-02f, 3.17671560e-02f, -3.54673015e-03f, 6.84923157e-02f, 1.88975960e-01f, 2.51518399e-01f, -7.90720880e-02f, -5.04826009e-02f,
  -2.94737238e-03f, -1.81612037e-02f, -3.98418829e-02f, 3.45172808e-02f, 1.29960716e-01f, 3.32919285e-02f, 1.67124346e-01f, 1.02233114e-02f, 9.78286862e-02f, 3.45996559e-01f,
  1.36462331e-01f, -2.69386649e-01f, -1.15817279e-01f, -2.23629251e-01f, -1.30478531e-01f, -1.55599058e-01f, -9.93390009e-02f, -1.17299221e-01f, -1.61300421e-01f, -4.62288335e-02f,
  -1.42550781e-01f, -1.07702248e-01f, -1.17728412e-01f, -3.71983461e-02f, -1.04282379e-01f, -1.51161075e-01f, -1.66569903e-01f, 1.83354896e-02f, -3.19723375e-02f, -7.73963705e-02f,
  -1.27200618e-01f, -5.32174073e-02f, -8.29925165e-02f, -6.21807054e-02f, -7.02485666e-02f, -9.88290161e-02f, -1.56694695e-01f, -1.20656475e-01f, 1.59396045e-02f, -6.97454214e-02f,
  -2.12534182e-02f, 4.92034853e-02f, 1.53529868e-02f, 7.81684816e-02f, 7.16085080e-03f, -2.26656720e-02f, 1.08495392e-02f, 5.65989278e-02f, -1.76483188e-02f, -1.57916266e-02f,
  1.11499038e-02f, 4.28421497e-02f, 3.65247689e-02f, 5.45932129e-02f, 1.06504001e-01f, 3.23504061e-02f, 8.34703967e-02f, 4.64474894e-02f, 8.27316046e-02f, 5.40622175e-02f,
  3.45060751e-02f, 5.70357554e-02f, 4.51389626e-02f, 1.56718165e-01f, 8.27031881e-02f, 1.12318054e-01f, -2.76448787e-03f, -7.00697377e-02f, -2.39953026e-02f, -5.20238616e-02f,
  -2.14413106e-01f, -1.35097176e-01f, -5.71359545e-02f, -3.46926078e-02f, -1.17148966e-01f, 3.35222036e-02f, -5.12850471e-02f, -2.58722454e-02f, -5.23631759e-02f, 4.25491657e-04f,
  -9.18661058e-02f, -6.60584196e-02f, -1.09118678e-01f, -8.04946199e-02f, -1.60544857e-01f, -1.00692295e-01f, -1.23036161e-01f, -8.22956488e-02f, -3.24436165e-02f, -1.16475642e-01f,
  -1.39577121e-01f, -7.00537190e-02f, -8.34003761e-02f, -1.65503174e-01f, -1.36172041e-01f, -1.61526073e-02f, -3.99255082e-02f, -1.62841026e-02f, -2.53362413e-02f, -5.74568734e-02f,
  5.05743563e-01f, 5.43193400e-01f, -1.30128860e-01f, 9.97048840e-02f, -2.09195688e-01f, -2.32766569e-01f, -8.28475039e-03f, -5.36197722e-02f, 6.25667125e-02f, 2.56507486e-01f,
  2.27491215e-01f, -7.83949792e-02f, 1.96283162e-02f, -1.76747255e-02f, 2.13370845e-02f, 2.19365880e-01f, 1.35169066e-02f, -1.49978980e-01f, -5.27510285e-01f, -4.01267886e-01f,
  -5.97930290e-02f, 9.33805034e-02f, 1.96225300e-01f, -3.63083594e-02f, 2.14403450e-01f, -1.01408146e-01f, 2.56312877e-01f, 1.69178605e-01f, 1.60237774e-02f, 3.42339724e-01f,
  7.71459192e-02f, 3.07341188e-01f, -2.24322230e-01f, 5.24971560e-02f, 1.27086699e-01f, 6.21356182e-02f, 2.04941519e-02f, 1.70890227e-01f, 1.02475816e-02f, 9.64217186e-02f,
  1.57242715e-02f, 2.38491297e-02f, -4.30586971e-02f, 3.24393176e-02f, 9.71694365e-02f, -4.78167906e-02f, 8.12450275e-02f, 2.22357754e-02f, 4.43419032e-02f, 1.46966025e-01f,
  4.78666462e-02f, 3.45519558e-02f, 2.50292476e-02f, -6.55570328e-02f, -1.27114773e-01f, -1.28770173e-01f, 2.07791924e-02f, -8.25814307e-02f, -1.62983954e-01f, 2.14051083e-01f,
  5.12517020e-02f, 2.71879956e-02f, -5.79347499e-02f, 1.96291991e-02f, -1.16024487e-01f, 7.26322690e-03f, -1.57750864e-02f, 1.70531925e-02f, -7.70341530e-02f, 1.61663517e-02f,
  -9.15027931e-02f, 1.03548877e-02f, -3.69694456e-02f, 7.98532143e-02f, -1.25233838e-02f, 2.38664728e-02f, -2.04194319e-02f, 1.58265866e-02f, 1.52696036e-02f, -2.89910682e-03f,
  -5.41167185e-02f, -5.83642051e-02f, 1.86192878e-02f, -6.88540637e-02f, -7.77540579e-02f, -2.43143253e-02f, -2.73412857e-02f, -8.42256248e-02f, -1.06760245e-02f, -4.65692692e-02f,
  1.51547715e-01f, -1.46678463e-01f, 2.71600842e-01f, 5.28734066e-02f, 6.93954760e-03f, 5.30057214e-02f, 1.01556905e-01f, -8.53071734e-02f, 1.17875695e-01f, 7.44027421e-02f,
  -7.77591690e-02f, 4.24378179e-02f, 1.12060919e-01f, -6.66207459e-04f, -1.18674137e-01f, -6.19866364e-02f, 7.31372908e-02f, -6.10308014e-02f, 7.15288380e-03f, 1.92261059e-02f,
  9.26772356e-02f, -7.22827464e-02f, -4.43406664e-02f, -2.81633865e-02f, 4.42277528e-02f, -3.35466564e-02f, 1.98566858e-02f, 1.88041367e-02f, -1.26104787e-01f, 2.10032657e-01f,
  -3.65626693e-01f, -4.62623388e-02f, -4.16381121e-01f, -4.77249831e-01f, -3.74924362e-01f, -1.42696261e-01f, -1.45488769e-01f, -1.14449494e-01f, -1.59168571e-01f, -1.01324931e-01f,
  1.48015171e-01f, 6.78706095e-02f, -5.74851148e-02f, 6.14350885e-02f, 2.24855598e-02f, -2.67030180e-01f, -2.63242900e-01f, -1.93730205e-01f, -1.37984499e-01f, 8.62760562e-03f,
  4.29057628e-02f, -2.48951182e-01f, -2.08772123e-01f, -2.60139070e-03f, -5.68991527e-02f, 7.47455433e-02f, -2.59647101e-01f, -7.32802525e-02f, 7.18275234e-02f, -6.44398332e-02f,
  -9.22665596e-02f, -1.43699795e-01f, 7.01352954e-02f, 8.17311108e-02f, -4.92241085e-02f, 3.89693119e-02f, -7.32799023e-02f, -9.06547811e-03f, 7.89806992e-02f, -2.49449760e-02f,
  1.68505143e-02f, 6.25875071e-02f, -8.09847414e-02f, 1.26183238e-02f, -4.48108539e-02f, 6.16779318e-03f, 6.34702519e-02f, -3.16521935e-02f, -8.56525078e-02f, 5.15003130e-02f,
  5.08123115e-02f, 2.23359317e-02f, -7.33235255e-02f, 3.88182849e-02f, 3.50945927e-02f, -7.33307609e-03f, 1.27088383e-01f, 7.32048675e-02f, 1.17036896e-02f, -3.37943919e-02f,
  -5.65149728e-03f, 4.17171307e-02f, -1.01149352e-02f, 2.21638437e-02f, 2.54750568e-02f, 6.31305873e-02f, -1.23185767e-02f, 3.98769677e-02f, 2.86328401e-02f, 5.62378671e-03f,
  -1.89780667e-02f, -6.69858158e-02f, -1.92087404e-02f, -1.20549135e-01f, -3.44158523e-02f, 9.70967114e-03f, 2.67221332e-02f, 4.79200408e-02f, 6.73406050e-02f, 1.20112197e-02f,
  3.97071615e-03f, 8.70047882e-02f, -9.41545516e-02f, -3.40503827e-02f, -6.88446984e-02f, -7.41389170e-02f, -1.07886298e-02f, 4.04343978e-02f, -7.25381449e-02f, 3.48461457e-02f,
  7.46049136e-02f, 6.18987344e-02f, -3.85770425e-02f, 6.56962916e-02f, -3.36014815e-02f, 3.69863734e-02f, 3.02128140e-02f, 4.82010320e-02f, 1.60599016e-02f, 2.29004840e-03f,
  4.41526026e-02f, 1.82085354e-02f, -2.83895116e-02f, 5.45158088e-02f, -6.15718588e-02f, -2.12204214e-02f, 9.75019671e-03f, 3.30184847e-02f, 6.21665008e-02f, 7.42839947e-02f,
  6.67953342e-02f, 3.72923650e-02f, 9.18116644e-02f, 1.75069589e-02f, -1.45373093e-02f, 7.18934685e-02f, 7.72699714e-02f, 8.73310342e-02f, 6.95029274e-02f, 3.38727944e-02f,
  3.09097439e-01f, -2.39740774e-01f, -2.31807902e-01f, -3.98411274e-01f, -4.08825763e-02f, 2.38884240e-03f, -1.04220249e-01f, -1.06926352e-01f, -1.37165144e-01f, -1.79989740e-01f,
  -2.26242244e-02f, 1.03564173e-01f, -3.59397829e-02f, -4.19998579e-02f, 1.19950853e-01f, -3.76219451e-01f, -3.06193829e-01f, -8.01577792e-02f, 1.65607795e-01f, 2.01121181e-01f,
  1.34117557e-02f, 1.47071511e-01f, 2.79247850e-01f, 9.06120315e-02f, -2.76510954e-01f, -8.49731117e-02f, -2.73991376e-01f, -1.15890212e-01f, -6.62694406e-03f, -3.95425022e-01f,
  -2.41432160e-01f, 1.50071561e-01f, -2.96726846e-03f, 1.34908989e-01f, 8.11556950e-02f, -3.78323644e-02f, 2.30935179e-02f, 1.49038807e-02f, 7.71881491e-02f, -5.51469997e-02f,
  -6.19123206e-02f, 7.16523901e-02f, -9.64503288e-02f, -6.46620989e-02f, -3.13937962e-02f, -1.34016857e-01f, -1.67630181e-01f, -8.29717889e-02f, -1.45175578e-02f, -1.21076584e-01f,
  -1.45922666e-02f, 9.49368700e-02f, 1.61586818e-03f, -6.95034713e-02f, 5.23554310e-02f, -8.17793384e-02f, 2.24095136e-02f, -7.54228607e-02f, -5.45164105e-03f, -2.03009963e-01f,
  -1.07475743e-01f, 4.85831760e-02f, 9.35632735e-02f, 1.64862685e-02f, 1.40463158e-01f, 6.47447929e-02f, 4.22827266e-02f, 4.19877060e-02f, 7.48438016e-02f, 5.09903114e-03f,
  2.34388188e-02f, 8.64049345e-02f, 1.52982801e-01f, 1.17203206e-01f, 1.29513204e-01f, 7.80532956e-02f, 5.71038388e-02f, 9.26327482e-02f, 1.13335513e-01f, 1.38456285e-01f,
  7.88621008e-02f, 1.07199535e-01f, 7.07258657e-03f, 3.56787890e-02f, 9.96682122e-02f, -5.97456992e-02f, 5.18514812e-02f, 9.15592089e-02f, -1.40437875e-02f, 9.96884778e-02f,
  -1.26505032e-01f, 2.22031295e-01f, -1.81106150e-01f, -2.08932579e-01f, -1.00475505e-01f, 2.04119142e-02f, -1.05232671e-01f, -1.41771426e-02f, 6.00716509e-02f, -6.53658360e-02f,
  6.89393356e-02f, -8.45375210e-02f, -7.13848397e-02f, -5.13379686e-02f, -8.84839892e-03f, 2.28257589e-02f, -1.12586338e-02f, -1.44565523e-01f, 6.72552660e-02f, -9.62657854e-02f,
  -2.92080715e-02f, -6.20897152e-02f, -1.30729631e-01f, -5.56256808e-02f, -3.52451205e-02f, 1.46820173e-02f, -1.34007171e-01f, -8.72823447e-02f, 6.94426522e-02f, -2.01570064e-01f,
  -4.78763223e-01f, 1.97648689e-01f, 1.99296743e-01f, -9.31820795e-02f, -1.46170303e-01f, -1.21977404e-01f, 8.20945427e-02f, -2.22890049e-01f, -1.52438030e-01f, 5.95253743e-02f,
  -2.28254244e-01f, -3.24498355e-01f, -2.90334970e-01f, -2.11773440e-01f, -1.29815817e-01f, 2.25596443e-01f, 3.30240160e-01f, 1.00086227e-01f, -2.26758406e-01f, -3.14100385e-01f,
  1.89268794e-02f, 5.05123027e-02f, -1.03891768e-01f, -1.94090717e-02f, 9.46780294e-02f, 1.59537550e-02f, 3.00117016e-01f, 1.12111330e-01f, 2.05525264e-01f, 5.09274840e-01f,
  -2.23643720e-01f, -2.73517698e-01f, -1.91737652e-01f, -1.15764454e-01f, -1.70031697e-01f, -1.11522026e-01f, -9.25013870e-02f, -1.41913503e-01f, -2.05893934e-01f, -3.28513654e-03f,
  -1.69124886e-01f, -1.10476278e-01f, -1.19998015e-01f, -1.58820823e-01f, -2.04090357e-01f, -1.65690362e-01f, -2.01320518e-02f, -1.24479219e-01f, -9.77885947e-02f, -1.23466194e-01f,
  -1.38481975e-01f, -1.65658623e-01f, -2.17870966e-01f, -6.62607625e-02f, -1.92971841e-01f, -1.74644649e-01f, -1.06412664e-01f, -1.30250901e-01f, 3.37034687e-02f, 1.06554255e-01f,
  -3.32520669e-03f, 3.26760882e-03f, 4.52997014e-02f, 7.81488270e-02f, 9.12383758e-03f, 5.35296202e-02f, 3.70995663e-02f, 8.58437829e-03f, 1.13368575e-02f, 3.13480943e-02f,
  9.38693900e-03f, 1.05733432e-01f, 1.03712395e-01f, 1.28153814e-02f, 1.31720185e-01f, 8.90923366e-02f, 2.77578458e-03f, 1.16522849e-01f, 1.71201059e-03f, 8.53846371e-02f,
  -8.46800879e-02f, 2.10307669e-02f, 1.04592346e-01f, 5.71093969e-02f, 6.57320395e-02f, 3.72353345e-02f, -2.77969446e-02f, 6.07768558e-02f, 2.54809819e-02f, 4.50964458e-02f,
  -1.53910473e-01f, -1.01590276e-01f, -9.06665102e-02f, -1.69279426e-01f, -8.52732882e-02f, -6.25102967e-02f, -5.07100224e-02f, -2.39981469e-02f, -1.15589134e-01f, -7.32631236e-02f,
  -1.39396161e-01f, -9.48150530e-02f, -9.81152803e-02f, -4.58150320e-02f, -9.84077156e-02f, -1.16630517e-01f, -1.19333789e-01f, -1.09645218e-01f, -5.06009124e-02f, -1.42126828e-01f,
  7.08923023e-03f, -1.01300158e-01f, -2.74439275e-01f, -1.28463060e-01f, -1.15460813e-01f, -2.41050869e-01f, -1.17204219e-01f, -7.00278804e-02f, -2.15057224e-01f, -3.70125622e-02f,
  2.62287576e-02f, 4.20711517e-01f, 9.12227035e-02f, 8.24981257e-02f, 1.56871259e-01f, 1.62493456e-02f, 1.29087284e-01f, -6.79994300e-02f, 1.75799187e-02f, 8.83188024e-02f,
  2.47189756e-02f, -2.76214600e-01f, -1.47105142e-01f, -1.05695561e-01f, -1.93661600e-01f, 6.71978593e-02f, 1.55830532e-01f, -1.05350360e-01f, -2.39943713e-01f, -2.23444756e-02f,
  5.79412505e-02f, 1.25287667e-01f, 6.43193945e-02f, 8.14109519e-02f, 1.23207584e-01f, -1.37245795e-02f, 8.11884329e-02f, 2.40724027e-01f, 1.68608487e-01f, 2.61382848e-01f,
  -1.04657181e-01f, 2.50074565e-01f, -1.44478410e-01f, 8.55283961e-02f, 5.47825806e-02f, -8.17350298e-02f, -6.17938377e-02f, -8.44352841e-02f, 4.29241918e-02f, 2.79200934e-02f,
  4.00330834e-02f, 6.97373226e-02f, -6.32696822e-02f, -9.17541683e-02f, 6.41053319e-02f, -3.09608737e-03f, 2.90055480e-03f, 6.78829709e-03f, -1.13072269e-01f, -9.74295195e-03f,
  3.23562175e-02f, 2.08670527e-01f, 1.38132304e-01f, 1.24485105e-01f, -4.80177663e-02f, 6.91913739e-02f, 1.10417001e-01f, 9.57272872e-02f, -4.37708013e-02f, 1.79035068e-01f,
  -3.76992002e-02f, 6.43054768e-02f, -2.17171330e-02f, 1.09249549e-02f, -2.74745654e-03f, -8.69244337e-02f, 2.18990110e-02f, -2.84067616e-02f, -1.64640509e-02f, 1.70102771e-02f,
  1.81487221e-02f, -7.74874389e-02f, -1.41444867e-02f, -3.54018547e-02f, 3.67395952e-02f, 4.81917616e-03f, -5.53936325e-02f, -6.14928119e-02f, 3.94673012e-02f, 1.24570755e-02f,
  -6.51565790e-02f, -3.55387256e-02f, -6.89186156e-02f, -5.10211177e-02f, 2.09486000e-02f, 3.60179953e-02f, 2.87940800e-02f, -2.97538061e-02f, 5.97974705e-03f, 3.09831146e-02f,
  -1.98792309e-01f, -1.87166020e-01f, -5.80908097e-02f, -6.22429289e-02f, 2.35439129e-02f, -4.82055126e-04f, 5.41782901e-02f, 6.79382533e-02f, -7.57208094e-03f, 5.41012622e-02f,
  -3.08787054e-03f, -9.42710489e-02f, -9.20844451e-03f, -4.77982797e-02f, 4.84896004e-02f, 2.20899284e-02f, 1.88348591e-02f, 3.39479260e-02f, -1.15535976e-02f, 6.55543506e-02f,
  3.13494615e-02f, 4.60458174e-02f, -8.46670493e-02f, 3.55404220e-04f, -3.25075947e-02f, -7.51816481e-02f, -4.50437926e-02f, 1.48568442e-02f, -7.81363696e-02f, 7.76070589e-03f,
  -3.75276297e-01f, 1.91846892e-01f, 1.63760662e-01f, 5.28833680e-02f, 3.59253064e-02f, 1.18829429e-01f, 1.03610232e-01f, 1.19731069e-01f, 1.77013744e-02f, 1.36131793e-01f,
  1.37828633e-01f, -2.76877463e-01f, -8.63954872e-02f, -2.49439180e-01f, -2.73374707e-01f, -3.97579977e-04f, -3.40878442e-02f, -1.59607545e-01f, -2.30279863e-01f, -7.56005794e-02f,
  -1.48370191e-01f, -1.03934728e-01f, -2.07509309e-01f, -9.75402743e-02f, -1.99330971e-01f, -3.14076900e-01f, 1.04993666e-02f, 2.72968486e-02f, -2.56360114e-01f, -3.07316601e-01f,
  -6.13744110e-02f, -2.29901113e-02f, -1.60944447e-01f, -2.66881138e-01f, -1.23582222e-01f, -1.27683893e-01f, -1.27402842e-01f, -1.83019012e-01f, -2.17633113e-01f, -1.54984832e-01f,
  -1.07828915e-01f, -9.28178951e-02f, -2.44223937e-01f, -1.67784303e-01f, -1.26119494e-01f, -1.84002534e-01f, -1.40603498e-01f, -1.56691387e-01f, -2.11685389e-01f, -1.38365686e-01f,
  -1.83670133e-01f, -2.91918337e-01f, -1.91758350e-01f, -1.71215877e-01f, -6.07662983e-02f, -2.96928376e-01f, -8.05128440e-02f, -2.66033053e-01f, -2.41267771e-01f, -2.31221408e-01f,
  1.44710047e-02f, 1.45961210e-01f, 3.48675102e-02f, 1.52480543e-01f, 6.50229976e-02f, 1.69057965e-01f, -9.82857868e-03f, 8.87836292e-02f, 7.92782083e-02f, 1.23746032e-02f,
  7.77247325e-02f, 1.47711232e-01f, 1.66644216e-01f, 5.89841865e-02f, 4.05448750e-02f, 7.72207230e-02f, 8.28148648e-02f, 6.35721162e-02f, 4.03396785e-02f, 1.91106182e-02f,
  1.03141204e-01f, 2.12418474e-02f, 1.02569498e-01f, 1.49533793e-01f, 1.17772155e-01f, 1.45900369e-01f, 9.95194912e-02f, 6.28486648e-02f, 1.51064262e-01f, 7.63427317e-02f,
  6.25532940e-02f, -2.18869030e-01f, -1.57615185e-01f, -1.76357940e-01f, -8.09821114e-02f, -1.37143061e-01f, -7.79218897e-02f, -4.10017110e-02f, -3.86769399e-02f, -9.37492847e-02f,
  -9.33081955e-02f, -1.46868050e-01f, -7.77892098e-02f, -3.05951592e-02f, -1.13209091e-01f, -6.61342070e-02f, -1.41517934e-03f, -1.02481559e-01f, -1.44532815e-01f, -3.42777092e-03f,
  -3.57611328e-02f, -1.69239521e-01f, -1.22746602e-01f, -1.22381948e-01f, -1.98286608e-01f, -2.46311545e-01f, -9.13604870e-02f, -1.13817126e-01f, -2.80277491e-01f, 8.63354132e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -7.36490905e-01f, 1.43905923e-01f, -9.09462795e-02f, -3.75172496e-01f, -5.18957138e-01f, -4.23582852e-01f, -2.47684307e-02f, -2.31215045e-01f, -2.24132523e-01f, 1.71252936e-01f,
  2.22019449e-01f, 3.62247884e-01f, 4.42586035e-01f, 2.58263469e-01f, 2.70233542e-01f, 7.58206248e-02f, -1.45827323e-01f, 2.69324072e-02f, 8.72898381e-03f, -4.34983009e-03f,
  -3.80826183e-02f, -1.50597498e-01f, -3.73169541e-01f, -6.37983531e-02f, 1.07504278e-01f, 2.45834634e-01f, 1.46893933e-02f, -2.64573753e-01f, 2.70515792e-02f, 1.40322343e-01f,
  4.20003295e-01f, -3.64898324e-01f, -1.26916334e-01f, -2.10734650e-01f, 7.54007846e-02f, -5.51562198e-02f, 1.10770918e-01f, 4.97565530e-02f, 5.62760308e-02f, 2.99453195e-02f,
  -1.49525940e-01f, -5.22244684e-02f, -1.59743261e-02f, -1.31070577e-02f, -1.22048400e-01f, -8.52914900e-02f, -2.30676860e-01f, -3.41569372e-02f, -1.49945021e-01f, -7.40130758e-03f,
  -4.70958203e-02f, -1.17498353e-01f, -1.88362971e-01f, 1.35057956e-01f, 2.33191885e-02f, -2.37180050e-02f, 3.15684825e-02f, 3.48786004e-02f, 6.91400543e-02f, 9.55166966e-02f,
  -2.64741816e-02f, 4.88975085e-02f, -1.87837750e-01f, 7.13399351e-02f, 1.47188559e-01f, -5.05850883e-03f, 1.60907120e-01f, 7.05767125e-02f, 6.02986701e-02f, 9.84340012e-02f,
  4.25520167e-02f, -1.42931985e-02f, 1.51662126e-01f, 2.73487214e-02f, 4.09286432e-02f, -1.42876267e-01f, -3.62603925e-02f, 5.49334325e-02f, 1.40390441e-01f, 1.94701944e-02f,
  -7.39035383e-02f, -1.03596397e-01f, -1.37949079e-01f, 1.83781356e-01f, -1.34519890e-01f, 1.63039789e-02f, -6.21349029e-02f, 5.49369939e-02f, -3.40883210e-02f, -1.54013410e-01f,
  3.28049153e-01f, -2.37859264e-01f, 2.04373211e-01f, 4.95702475e-02f, -1.79942444e-01f, -1.44048676e-01f, -2.70067472e-02f, -9.18437690e-02f, -1.37804091e-01f, 1.97374240e-01f,
  -1.31670281e-01f, 4.04002555e-02f, 7.80996755e-02f, -1.14914544e-01f, -6.78277202e-03f, 2.30790284e-02f, -2.32507542e-01f, -7.14215934e-02f, 3.09879705e-02f, -9.58316475e-02f,
  -2.42865741e-01f, -1.11019850e-01f, -9.15300921e-02f, 2.48191565e-01f, -1.85032859e-02f, 1.26983404e-01f, 2.38115236e-01f, 6.15684316e-02f, 1.38948470e-01f, 1.76001728e-01f,
  3.93394262e-01f, 2.26762787e-01f, 3.07058811e-01f, 3.40271235e-01f, 3.64263833e-01f, 4.70251679e-01f, 5.83982587e-01f, 3.60455573e-01f, 1.28103927e-01f, 1.22977652e-01f,
  -2.87173707e-02f, -1.28343821e-01f, -6.25636950e-02f, -2.59341928e-03f, 2.41389386e-02f, 1.11182056e-01f, 7.88369626e-02f, 2.04651207e-02f, 1.38116017e-01f, 7.93040767e-02f,
  -1.00310273e-01f, -8.41662213e-02f, 3.49092074e-02f, -1.41598731e-01f, -5.10111488e-02f, -9.56550986e-03f, 1.37911394e-01f, 1.41386077e-01f, 1.49819255e-01f, -3.52626331e-02f,
  1.44018799e-01f, 2.84482837e-01f, -1.10155068e-01f, -2.17691123e-01f, -1.58775747e-01f, -8.27233046e-02f, -4.22832817e-02f, -1.32953867e-01f, -5.12111895e-02f, -2.16881149e-02f,
  -9.18601975e-02f, -1.91703424e-01f, -3.28222737e-02f, -3.28451358e-02f, 1.38489410e-01f, -6.69319779e-02f, -4.47723754e-02f, 1.53059170e-01f, 1.14311613e-01f, -3.25062238e-02f,
  -1.54562727e-01f, -7.32773636e-03f, 3.56047124e-01f, 2.00764135e-01f, 2.00847521e-01f, 7.16354698e-02f, -7.99840987e-02f, 8.52862895e-02f, 9.80927125e-02f, 5.35105616e-02f,
  1.13086767e-01f, 7.82086104e-02f, -8.01357999e-03f, 8.80865660e-03f, 4.34141941e-02f, 1.35477856e-01f, 9.75237191e-02f, 1.15614668e-01f, 7.41233602e-02f, -1.09716922e-01f,
  8.93881619e-02f, 2.14598492e-01f, 1.06162898e-01f, -2.49363929e-02f, -2.17403471e-01f, -9.36591327e-02f, 1.45639375e-01f, -5.12094498e-02f, 4.23178673e-02f, 1.09605633e-01f,
  1.41782686e-01f, 6.05150536e-02f, -1.51215913e-02f, -2.36324444e-02f, 2.48830207e-02f, 3.45522948e-02f, 1.05383515e-01f, -1.24965392e-01f, -4.15174775e-02f, -4.90361871e-03f,
  8.40616897e-02f, 1.31333575e-01f, 9.30459723e-02f, -1.11394387e-03f, -1.73221854e-03f, -6.56423271e-02f, -2.31970917e-04f, -9.86511558e-02f, 1.05498813e-01f, 1.23446092e-01f,
  7.43015707e-02f, -4.54989634e-02f, -1.09596029e-01f, -7.20396936e-02f, -9.15356800e-02f, -7.92354252e-03f, -1.81782410e-01f, 1.00754544e-01f, 3.92679460e-02f, -9.49917268e-03f,
  -2.03933522e-01f, 1.51651189e-01f, 2.47599632e-01f, 7.67638832e-02f, 1.40105084e-01f, 1.28723443e-01f, 7.31137097e-02f, -1.14850225e-02f, 1.71347201e-01f, -2.12146431e-01f,
  -3.59014988e-01f, -3.80203813e-01f, -4.79134351e-01f, 2.90026695e-01f, 2.49097377e-01f, -4.61052358e-02f, -6.72798097e-01f, 1.52403906e-01f, 4.28920358e-01f, -3.35154504e-01f,
  3.28371227e-02f, 3.00949812e-01f, -4.41254303e-02f, -1.91680357e-01f, -4.99878794e-01f, -6.72252119e-01f, -4.15638357e-01f, -3.58166307e-01f, 1.92661151e-01f, 3.61984342e-01f,
  3.95553887e-01f, 1.90698594e-01f, 1.82541758e-01f, 2.77290344e-01f, 1.84377149e-01f, 9.99893099e-02f, 3.50121385e-03f, 2.21430529e-02f, -3.56942296e-01f, -5.49724460e-01f,
  -4.27789569e-01f, -2.92271096e-02f, 3.75194773e-02f, 4.29769829e-02f, 2.55772650e-01f, -8.77001509e-02f, -3.79514173e-02f, 5.19459844e-02f, 1.22176386e-01f, -1.91290051e-01f,
  1.15408607e-01f, 7.13921711e-02f, 7.92971551e-02f, 1.15454197e-01f, 2.29986217e-02f, 7.11843595e-02f, 5.67411520e-02f, -8.06884393e-02f, -1.19788744e-01f, 1.12651944e-01f,
  -3.33940350e-02f, -2.40699291e-01f, -3.56206715e-01f, -5.02610877e-02f, -2.14343160e-01f, -1.70528814e-01f, 6.58956636e-03f, -3.15331966e-02f, -2.29872301e-01f, -5.34707785e-01f,
  -4.75857854e-02f, -3.28719197e-03f, 6.67116791e-02f, -6.80797026e-02f, 6.16148412e-02f, -1.70615818e-02f, -1.77841902e-01f, -1.55170694e-01f, 1.94421783e-01f, -1.35057762e-01f,
  1.33879766e-01f, -3.76006626e-02f, 1.20749734e-01f, -7.16273859e-02f, -1.59271881e-01f, -1.13154665e-01f, -1.34576559e-01f, -9.84353423e-02f, -8.58874097e-02f, -4.11244705e-02f,
  -1.65163763e-02f, -1.15717143e-01f, 3.23342420e-02f, 2.95208059e-02f, -1.36774465e-01f, -1.16110913e-01f, 1.82069466e-02f, 1.96968298e-02f, 8.99796747e-03f, -1.94212750e-01f,
  2.95514256e-01f, 3.02420706e-01f, -1.47998542e-01f, -1.98138833e-01f, 4.07771952e-02f, 1.22943401e-01f, 8.07314180e-03f, -6.79815263e-02f, -1.22653365e-01f, 3.51059288e-02f,
  1.39845163e-01f, -2.71587949e-02f, -8.31593201e-03f, 5.88507717e-03f, -6.25595078e-03f, 5.83127923e-02f, -1.82997122e-01f, -1.49153486e-01f, -1.44325927e-01f, 2.88228273e-01f,
  -2.99098678e-02f, -3.46815556e-01f, -3.77964318e-01f, -4.99902368e-01f, -1.29793927e-01f, -2.22992703e-01f, -1.47344708e-01f, -2.22401336e-01f, -3.47828835e-01f, -3.94994974e-01f,
  1.09693623e+00f, -3.59778821e-01f, 1.07069276e-01f, 1.99212492e-01f, -4.06244755e-01f, -3.52622479e-01f, -4.31340247e-01f, -2.21202999e-01f, 9.58215594e-02f, -1.50242209e-01f,
  -1.60202026e-01f, 3.28899235e-01f, 3.88415158e-01f, 3.16919893e-01f, 2.56471634e-01f, -2.26550162e-01f, -3.83319519e-02f, 5.15070558e-01f, 3.66329700e-01f, -2.43389234e-01f,
  -2.96053439e-01f, -2.43058518e-01f, 1.53402805e-01f, 7.81403184e-02f, -3.84017587e-01f, -3.12585831e-02f, -1.65409848e-01f, -1.76965222e-01f, -2.64256239e-01f, -4.23661107e-03f,
  2.31039241e-01f, 2.51870066e-01f, 2.47165263e-01f, 1.34650201e-01f, -8.27646032e-02f, 9.69849527e-02f, -3.25719849e-03f, -6.24299468e-03f, -3.99103723e-02f, -6.54532760e-02f,
  -6.30454496e-02f, -9.09859873e-03f, 2.97032786e-03f, -4.48579751e-02f, -6.97767064e-02f, -3.77655681e-03f, -1.22023724e-01f, 7.47307613e-02f, 4.65807877e-02f, -2.95100324e-02f,
  -1.60025805e-01f, -6.97868243e-02f, -2.28921827e-02f, 5.32579795e-02f, 9.85327065e-02f, 2.14345098e-01f, -6.27127662e-02f, -6.83955755e-03f, 7.39404112e-02f, 6.19057566e-02f,
  4.01838310e-02f, -3.91182266e-02f, -8.84813219e-02f, 7.36910552e-02f, -8.45642586e-04f, 4.14305814e-02f, 5.60771790e-04f, -5.35420813e-02f, 2.52990779e-02f, 2.90703159e-02f,
  -3.32613066e-02f, 1.49540221e-02f, 8.96495581e-02f, 2.25740205e-02f, -3.44534442e-02f, -5.29671237e-02f, -5.82609810e-02f, -7.74721652e-02f, 2.99157891e-02f, 8.38870108e-02f,
  1.26032904e-01f, 2.21748017e-02f, -6.30358374e-03f, -1.51076749e-01f, -1.75754219e-01f, 8.43772814e-02f, 1.32074039e-02f, -9.69624892e-02f, -1.93474546e-01f, -1.08187586e-01f,
  -1.00078464e-01f, 4.46034670e-01f, 1.83413297e-01f, -7.00185746e-02f, 1.75554154e-03f, -7.20338076e-02f, 6.56709895e-02f, 5.42035624e-02f, -9.35316645e-03f, 5.92206279e-03f,
  -7.20095783e-02f, 2.59595942e-02f, 3.13034803e-02f, -9.54660550e-02f, 1.36020267e-02f, 8.16335678e-02f, -5.99126779e-02f, 8.13647881e-02f, 4.97206906e-03f, -1.08435363e-01f,
  -9.33616906e-02f, 1.26226783e-01f, 2.06032500e-01f, 1.26808211e-01f, 1.67366415e-02f, 2.71563828e-01f, 1.99571121e-02f, -1.71918981e-02f, 1.70363918e-01f, -8.20693672e-02f,
  1.41894341e-01f, -3.17038924e-01f, -7.61592329e-01f, -3.92467529e-01f, -5.41977048e-01f, -3.13753873e-01f, -3.63600791e-01f, 2.36485660e-01f, 9.50766876e-02f, -4.85445023e-01f,
  -3.12275231e-01f, -2.22770069e-02f, -3.49340051e-01f, -3.32770318e-01f, -2.05576599e-01f, -6.92198753e-01f, -7.44707882e-01f, -4.08681303e-01f, -3.84455994e-02f, 1.69197485e-01f,
  -7.81731382e-02f, -1.65652722e-01f, -1.04668468e-01f, -1.77496240e-01f, -2.16941208e-01f, -1.77761257e-01f, -6.68015897e-01f, -4.20661390e-01f, -2.52980918e-01f, -6.89463794e-01f,
  -5.98981440e-01f, 2.17568368e-01f, -1.47842914e-02f, 1.12967782e-01f, -1.97066799e-01f, 1.92383751e-01f, 3.02599017e-02f, -3.41973715e-02f, 1.28172683e-02f, -5.07748649e-02f,
  -1.09210916e-01f, 8.85631442e-02f, 1.66809469e-01f, 7.35466182e-02f, 4.77564558e-02f, 1.65167287e-01f, -1.11357979e-01f, -3.76204960e-02f, -8.34235698e-02f, 1.85759738e-01f,
  -1.31966278e-01f, -1.91429108e-01f, -1.27357289e-01f, 7.66003951e-02f, 2.06687719e-01f, -6.73334580e-03f, 5.63815497e-02f, 2.42674664e-01f, -4.76418138e-02f, -1.22962639e-01f,
  -1.87471688e-01f, 1.16313528e-02f, -6.35780115e-03f, 1.32034659e-01f, 1.55547857e-01f, -1.78279250e-03f, -4.96516470e-03f, 7.79210106e-02f, 1.29134819e-01f, -2.75503825e-02f,
  -3.71769182e-02f, -2.19015535e-02f, 8.03298354e-02f, -6.01324625e-02f, -1.16065502e-01f, -1.22002423e-01f, -7.98233598e-03f, 6.52559623e-02f, -6.12508990e-02f, 3.23736593e-02f,
  -3.05409078e-02f, -3.25518250e-02f, -5.98202497e-02f, 3.26719843e-02f, -1.97469294e-01f, -8.55127424e-02f, -4.00011837e-02f, -7.38918269e-03f, 3.86339836e-02f, 1.32735129e-02f,
  -8.67867097e-02f, -1.84308425e-01f, -1.64983243e-01f, 1.04180828e-01f, -1.72226623e-01f, -2.09368601e-01f, -1.18739821e-01f, 1.85443535e-02f, 7.98436031e-02f, 1.89317778e-01f,
  9.54412967e-02f, -3.71682309e-02f, -1.64509937e-02f, 2.53701359e-02f, 6.80288449e-02f, 7.86763206e-02f, -1.32996008e-01f, -2.01494433e-03f, -5.25212623e-02f, 1.16584174e-01f,
  -1.17012575e-01f, 9.68366191e-02f, 1.22917995e-01f, -4.72993851e-02f, 1.91596851e-01f, -1.13257263e-02f, -8.36159512e-02f, 7.07541257e-02f, 1.16133995e-01f, -1.51348719e-02f,
  1.56206330e-02f, -5.07775009e-01f, 1.14450477e-01f, -3.27437781e-02f, 3.42864305e-01f, 4.37821358e-01f, 5.25094986e-01f, 1.17665216e-01f, -5.16785309e-02f, -1.03051104e-02f,
  -3.62978250e-01f, -5.98546028e-01f, -5.24019361e-01f, -4.09918666e-01f, -3.60757589e-01f, 2.88924873e-01f, 1.25379726e-01f, 8.76881927e-02f, 2.62623757e-01f, 2.30539963e-01f,
  1.23733923e-01f, 2.06905857e-01f, -6.09333776e-02f, -1.46309167e-01f, -1.01658270e-01f, -1.65514991e-01f, 6.55859883e-04f, -1.69779003e-01f, -2.66249806e-01f, -2.41372600e-01f,
  -2.93571298e-04f, -3.89560908e-01f, -3.23876627e-02f, -2.48353899e-01f, -1.06708534e-01f, -1.52855456e-01f, 5.82120791e-02f, -1.39297277e-01f, -8.02277867e-03f, 7.33276010e-02f,
  -1.26892030e-01f, -8.63371193e-02f, -9.72218439e-02f, -7.84572139e-02f, 1.50006965e-01f, 5.97633496e-02f, -1.05025619e-01f, -2.11052760e-01f, -3.30441445e-01f, -9.81154665e-02f,
  -1.81942791e-01f, -9.75660384e-02f, 8.93173665e-02f, -1.12226404e-01f, -1.64000615e-01f, -1.55140236e-01f, -4.95803952e-02f, -2.37218708e-01f, -1.70591071e-01f, 6.46704212e-02f,
  1.34163767e-01f, 4.39085290e-02f, -1.10939585e-01f, 8.72854218e-02f, 1.31993070e-01f, 9.22336057e-02f, 4.58045397e-03f, -8.48325938e-02f, 9.88691673e-02f, 3.29859741e-02f,
  4.83388128e-03f, -5.08675762e-02f, -2.11156067e-03f, 4.74715456e-02f, -5.99348284e-02f, -1.12887174e-01f, -2.31259372e-02f, -6.25496591e-03f, -7.87790045e-02f, 1.72384568e-02f,
  -4.32822183e-02f, -5.63561395e-02f, 6.06213212e-02f, -4.33884114e-02f, -1.38105527e-01f, -2.70374455e-02f, 3.14348377e-02f, -8.76431242e-02f, -6.29564151e-02f, -1.71882231e-02f,
  2.27654114e-01f, -2.50470519e-01f, 2.55964249e-01f, -4.91158925e-02f, 1.55057302e-02f, -1.25018552e-01f, -2.39455625e-02f, -1.28750607e-01f, -8.95068496e-02f, 2.45807916e-02f,
  -1.59249440e-01f, 7.33864605e-02f, 1.53422542e-02f, 7.18173087e-02f, 3.19514602e-01f, 1.70806289e-01f, 5.97817153e-02f, 1.20876159e-03f, -9.90237948e-03f, 5.26800342e-02f,
  1.33453816e-01f, 2.13201031e-01f, 2.48067454e-01f, 9.68890041e-02f, -3.19572985e-02f, 1.88865364e-01f, 2.38503203e-01f, 2.31798217e-01f, 1.41042054e-01f, 5.97332597e-01f,
  -4.42132354e-02f, 5.34998834e-01f, 7.17515528e-01f, -3.51859063e-01f, -1.09652549e-01f, 9.82054770e-02f, 5.89550436e-01f, 1.20661326e-01f, -4.78270203e-01f, 6.86561316e-02f,
  -2.42194504e-01f, -5.88856459e-01f, -2.92023212e-01f, -1.07787557e-01f, 2.16485038e-01f, 3.98952603e-01f, 3.15818191e-01f, 2.45754451e-01f, -5.24267443e-02f, -5.09265959e-02f,
  -7.71616325e-02f, -1.89068150e-02f, 1.26281783e-01f, 1.84187680e-01f, -1.80442762e-02f, -4.14880276e-01f, 9.94914398e-02f, 8.12736228e-02f, 2.13201985e-01f, 1.85036793e-01f,
  -6.77867159e-02f, 2.95103312e-01f, -2.92436093e-01f, -3.18173826e-01f, 2.13367343e-02f, 8.44554305e-02f, 1.07424974e-01f, -4.83887866e-02f, -1.42614052e-01f, 8.43038708e-02f,
  3.42451595e-02f, 5.63177951e-02f, -2.26010289e-03f, 9.07336622e-02f, 1.17189638e-01f, 7.79193938e-02f, 1.89218655e-01f, 3.30560297e-01f, 1.29572943e-01f, 1.04108259e-01f,
  -7.77761936e-02f, -1.49332568e-01f, -1.05723192e-03f, 4.36655395e-02f, 2.74609894e-01f, -3.65944892e-01f, 9.86687317e-02f, 9.00806636e-02f, 8.69225860e-02f, -8.37811902e-02f,
  -1.47519946e-01f, -5.84886000e-02f, 9.38229710e-02f, 3.03319953e-02f, -5.56818629e-03f, -1.15161449e-01f, 5.08067757e-03f, -3.85703370e-02f, -3.08040902e-02f, 4.69963849e-02f,
  -2.01615058e-02f, 4.82742526e-02f, 7.28750527e-02f, 6.97906241e-02f, -1.57835826e-01f, 1.88855212e-02f, 6.42995387e-02f, -4.14078385e-02f, 7.97153264e-02f, -1.51479794e-02f,
  -2.16663122e-01f, 2.35313028e-02f, -7.97564685e-02f, 1.82564050e-01f, -9.74383391e-03f, -1.06971346e-01f, -3.65135036e-02f, -3.28072160e-02f, -1.90346748e-01f, -1.18293189e-01f,
  -3.69639724e-01f, 1.16565503e-01f, -1.43064886e-01f, 1.14778273e-01f, -1.16248243e-02f, 4.40536551e-02f, 8.13652109e-03f, -4.44146842e-02f, -5.64371422e-02f, 4.34190333e-02f,
  1.15864478e-01f, 7.21269697e-02f, 1.32315177e-02f, 1.05569728e-01f, -1.34349121e-02f, -2.33597867e-02f, -1.10527664e-01f, 6.78572943e-03f, 5.26096933e-02f, -1.43781910e-02f,
  5.20154759e-02f, -5.79111241e-02f, -5.54760993e-01f, -3.47378194e-01f, -3.35660964e-01f, -6.61463678e-01f, -1.72490850e-01f, -1.47740960e-01f, -1.12974338e-01f, -2.90892839e-01f,
  8.90903771e-01f, 1.93722069e-01f, -2.88019150e-01f, 1.70279235e-01f, -1.40177146e-01f, -1.04189254e-01f, -2.14513451e-01f, 5.11273593e-02f, 1.43227056e-01f, 2.62989819e-01f,
  3.41064006e-01f, 4.25659657e-01f, 2.85116315e-01f, 1.68644428e-01f, 8.70434046e-02f, -8.49870294e-02f, -2.68542826e-01f, -5.78906648e-02f, 1.33584142e-01f, 1.79171979e-01f,
  1.87251866e-02f, 7.05524534e-02f, 1.85092375e-01f, -2.55016470e-03f, 6.92914948e-02f, 2.55824983e-01f, 8.37417766e-02f, 4.42187674e-02f, 3.57982554e-02f, -8.35778937e-03f,
  1.14185348e-01f, 3.15106630e-01f, -1.14563191e-02f, 2.92625967e-02f, -1.37847811e-01f, 2.93851960e-02f, 5.81776686e-02f, -7.60875121e-02f, -1.87728420e-01f, -1.17742971e-01f,
  -5.23446538e-02f, 7.54541606e-02f, -2.55989544e-02f, -1.42414704e-01f, -5.10097146e-02f, -1.02045774e-01f, 6.83953473e-03f, -2.51632463e-02f, -1.17581129e-01f, -1.03332698e-02f,
  -4.95972708e-02f, -3.14308517e-02f, -9.11442414e-02f, -8.46086070e-02f, 6.04160018e-02f, -4.85678762e-02f, -6.93836734e-02f, 1.55869544e-01f, 4.58668061e-02f, 2.47865692e-01f,
  -4.37630937e-02f, 2.39993669e-02f, 1.33088142e-01f, 1.49589106e-01f, 2.28090495e-01f, 1.78533443e-03f, 5.39008714e-02f, 3.82549874e-02f, -4.26318496e-02f, 8.75421567e-04f,
  2.19760593e-02f, 1.45067628e-02f, -1.69238344e-01f, 1.31856680e-01f, 1.15317062e-01f, -9.54419523e-02f, -3.73355970e-02f, -3.46295461e-02f, -5.26351258e-02f, -7.11155608e-02f,
  8.05385932e-02f, -1.15499265e-01f, -4.25526015e-02f, -8.48671570e-02f, -1.07117742e-02f, 4.56484295e-02f, -3.08522880e-02f, 9.30769295e-02f, 1.71304151e-01f, 1.99255925e-02f,
  -5.83221689e-02f, -2.59107053e-01f, 2.39491925e-01f, 5.04093897e-03f, -1.20641395e-01f, -3.54617946e-02f, 7.27312267e-02f, -8.35256949e-02f, -3.35680306e-01f, -7.17376396e-02f,
  4.45544487e-03f, 1.97775036e-01f, 2.23887991e-02f, -4.10427377e-02f, 1.05023906e-02f, 1.52635667e-02f, 1.05033800e-01f, -7.38910362e-02f, -1.07440688e-01f, -1.95751831e-01f,
  -9.34181362e-02f, -7.85361454e-02f, 4.88481112e-03f, -1.46336064e-01f, 5.41612804e-02f, 2.85634305e-02f, -2.13637371e-02f, 7.46404827e-02f, 3.96902040e-02f, 2.35996440e-01f,
  -1.28544593e+00f, -1.71932235e-01f, 2.37863049e-01f, -7.76244879e-01f, -9.17117968e-02f, 1.88681245e-01f, 1.31744280e-01f, -1.23875096e-01f, -3.46957296e-01f, -9.78108589e-03f,
  1.33813322e-01f, -1.23642899e-01f, 8.75116605e-03f, -7.22686052e-02f, -4.34708118e-01f, 2.03786299e-01f, -2.78880119e-01f, -5.94384015e-01f, -5.31904042e-01f, -2.53824234e-01f,
  -1.84450984e-01f, -6.77408278e-01f, -8.51152241e-01f, -4.34081852e-01f, 4.21212725e-02f, -2.84675695e-02f, 1.20615825e-01f, -1.41016126e-01f, 1.53760582e-01f, -4.99766227e-03f,
  4.26658064e-01f, -2.37071328e-02f, 4.07960638e-02f, -2.08158866e-01f, 1.43111378e-01f, -1.09931536e-01f, 1.82523616e-02f, -2.43191933e-03f, -3.63325104e-02f, 1.27354786e-01f,
  -9.07437578e-02f, -5.90459742e-02f, -6.73819929e-02f, 7.83763453e-02f, -1.00872524e-01f, -6.70486391e-02f, -5.30262701e-02f, -6.17372356e-02f, 1.03477225e-01f, 3.83272499e-01f,
  2.30303198e-01f, 1.59256216e-02f, 1.42930269e-01f, 3.00066024e-01f, 2.24368796e-01f, -3.55832241e-02f, 2.79665262e-01f, 8.95097777e-02f, 1.51899204e-01f, 7.52643943e-02f,
  8.01367909e-02f, 4.42889109e-02f, 2.08446709e-03f, -3.92165519e-02f, 7.36854179e-03f, 2.32118294e-02f, -8.89583826e-02f, -5.80188259e-02f, -9.31577682e-02f, -1.53786009e-02f,
  3.54903378e-02f, 4.72552516e-02f, 4.70541455e-02f, -2.21498460e-02f, -2.91808993e-02f, -8.18016976e-02f, -6.35545626e-02f, 2.30920408e-02f, 3.16704251e-02f, -2.37994157e-02f,
  -7.21562235e-03f, 8.81074071e-02f, -1.19355321e-01f, 1.07055873e-01f, 3.82712856e-02f, -1.39521584e-01f, -6.41609635e-03f, -3.37191895e-02f, 2.75500980e-03f, -4.67982143e-02f,
  6.93244021e-03f, -6.59796521e-02f, 4.56299335e-02f, -9.81585756e-02f, 4.78721596e-02f, 3.33722942e-02f, 5.81327043e-02f, -6.64302036e-02f, 1.70342233e-02f, 1.27734253e-02f,
  8.03488493e-03f, -6.72380626e-02f, 1.22664971e-02f, 6.11553118e-02f, -8.68922547e-02f, -3.05434037e-02f, -1.08475592e-02f, -4.91716824e-02f, 8.53978023e-02f, 1.19452648e-01f,
  9.49820280e-02f, -2.87250765e-02f, -5.68109415e-02f, 1.62528321e-01f, 1.06368393e-01f, -1.28124848e-01f, 1.17860012e-01f, 1.16634443e-01f, 8.18740856e-03f, 1.59935711e-03f,
  -9.27742779e-01f, -1.34545878e-01f, -1.67397037e-01f, 1.62046283e-01f, 4.67880189e-01f, 1.05757810e-01f, -7.66350999e-02f, -2.86558002e-01f, 4.14758287e-02f, -5.40678017e-02f,
  6.45754859e-02f, 9.12406370e-02f, 7.46457726e-02f, 8.03076997e-02f, -1.76716104e-01f, 1.02563605e-01f, 3.57966810e-01f, -1.53689086e-02f, -1.36773005e-01f, -1.07781991e-01f,
  2.56482333e-01f, -4.19697650e-02f, -3.70011210e-01f, -6.38923496e-02f, 3.95370811e-01f, 2.15437800e-01f, 1.17021101e-03f, -7.86372200e-02f, 5.90986870e-02f, 4.33046937e-01f,
  -1.69454977e-01f, -4.12118077e-01f, 6.94430098e-02f, -1.02438495e-01f, -3.26993689e-02f, -2.90281653e-01f, -8.94587860e-02f, -2.86450982e-02f, 6.79715201e-02f, 1.03168515e-02f,
  2.16470703e-01f, -1.99766923e-02f, 2.64336795e-01f, 7.49430880e-02f, -8.53863358e-02f, -6.42675236e-02f, -8.35512280e-02f, -1.42374843e-01f, -2.44384483e-01f, -7.05548599e-02f,
  4.20744061e-01f, 3.00412983e-01f, -1.27447560e-01f, 1.21738352e-02f, -1.78897008e-01f, -2.82283928e-02f, -2.52347320e-01f, -8.09508786e-02f, -5.36639035e-01f, -4.61785853e-01f,
  5.75745851e-02f, 3.22932564e-02f, -5.94490282e-02f, -4.60018292e-02f, -5.29334098e-02f, 2.78073251e-01f, 1.47640526e-01f, 7.34120384e-02f, -2.54310500e-02f, -1.43147975e-01f,
  -1.93300802e-04f, 5.53984568e-02f, -2.24394873e-02f, 6.40868815e-03f, -3.96094918e-02f, -1.00975474e-02f, 7.15374798e-02f, -1.15664620e-02f, -3.14347818e-03f, -1.81208417e-01f,
  1.65608168e-01f, 1.52389295e-02f, 2.21995451e-02f, 6.29305616e-02f, 1.85771864e-02f, -1.52512386e-01f, 1.30523939e-03f, -1.42491683e-01f, -2.44739324e-01f, -1.53928787e-01f,
  -1.88414708e-01f, -1.36296093e-01f, 5.35563268e-02f, 5.30947708e-02f, -8.58115479e-02f, 4.06241007e-02f, -7.26917312e-02f, -5.45454733e-02f, 5.62151801e-03f, -9.10209715e-02f,
  -1.39245063e-01f, -6.57723397e-02f, -5.61872162e-02f, 5.23554869e-02f, -6.71350677e-03f, 4.81207408e-02f, 1.20563759e-02f, 1.85466394e-01f, -8.94919597e-03f, 4.78086211e-02f,
  7.62568787e-02f, -9.58609805e-02f, -3.37620139e-01f, -9.87757221e-02f, 1.16152182e-01f, -1.51181638e-01f, -1.60251901e-01f, -8.43198225e-02f, -3.54226351e-01f, -4.14144367e-01f,
  3.23448867e-01f, 2.60303110e-01f, 1.73531860e-01f, 3.04483354e-01f, 2.10646302e-01f, -4.46163625e-01f, -6.81145072e-01f, -6.94949567e-01f, -1.16166048e-01f, 1.18736990e-01f,
  2.84859270e-01f, 9.14314166e-02f, 3.49311419e-02f, -2.12594524e-01f, -4.18638676e-01f, -1.44388184e-01f, 2.39323769e-02f, -1.35164529e-01f, -5.40366650e-01f, -3.39633286e-01f,
  -5.66288717e-02f, 6.03811853e-02f, -1.22088857e-01f, -2.00828239e-01f, 2.60904253e-01f, 2.26559360e-02f, 3.17191303e-01f, 2.88719237e-01f, 2.36584499e-01f, 5.95470786e-01f,
  5.84259033e-01f, 3.21593970e-01f, -2.36685082e-01f, 5.99570870e-02f, 3.84449482e-01f, -1.31581714e-02f, 5.17152436e-02f, 1.97739094e-01f, 1.02413930e-01f, 1.62427090e-02f,
  3.62116039e-01f, -5.42031974e-03f, 1.51823625e-01f, 1.68530531e-02f, -5.27237728e-02f, -3.01304102e-01f, -2.55522698e-01f, -3.09908062e-01f, -9.72610638e-02f, 8.91218148e-03f,
  1.21694669e-01f, 1.35955736e-01f, 2.80608460e-02f, -1.77765429e-01f, -9.09894034e-02f, 5.03237285e-02f, -1.11734204e-01f, 1.02939673e-01f, -9.82300937e-02f, 1.88571826e-01f,
  -1.69147059e-01f, 1.02564745e-01f, 1.18559441e-02f, 7.12452382e-02f, -7.95189887e-02f, 7.45146573e-02f, 1.99238844e-02f, 4.65809703e-02f, 1.69695280e-02f, -3.86805385e-02f,
  -1.76887900e-01f, 6.66345283e-02f, 6.42073993e-03f, -4.76176962e-02f, -9.23539773e-02f, 1.41587213e-01f, 3.10138315e-02f, -5.31491153e-02f, -9.78157371e-02f, 2.83505935e-02f,
  -8.69931206e-02f, 5.22203296e-02f, 3.12142789e-01f, -7.58257136e-02f, -4.60107736e-02f, -6.96938261e-02f, 1.62265196e-01f, -4.27773148e-02f, -1.50236469e-02f, 6.64145574e-02f,
  -1.69547006e-01f, -2.57789135e-01f, 2.09202528e-01f, -2.27393270e-01f, 2.71687269e-01f, -3.13763022e-02f, 2.84192413e-01f, -6.04866929e-02f, 1.24546140e-01f, -1.22648284e-01f,
  -1.15892954e-01f, -3.51216756e-02f, 1.61399111e-01f, -7.77962878e-02f, -7.64966458e-02f, 2.10592747e-02f, -7.65204579e-02f, -1.23155467e-01f, -1.25660911e-01f, 1.06824599e-01f,
  -1.76903322e-01f, -4.73676592e-01f, -3.54184270e-01f, -2.81225860e-01f, -6.99434504e-02f, -2.34454527e-01f, -1.71819240e-01f, -1.74604788e-01f, -2.64220715e-01f, -4.30275261e-01f,
  -2.19846908e-02f, -3.18631738e-01f, 4.47952807e-01f, 3.17133486e-01f, -1.42490556e-02f, -2.79558748e-01f, -4.76345897e-01f, -2.87842959e-01f, 4.18568542e-03f, -1.65884629e-01f,
  -1.57874733e-01f, 2.18040809e-01f, 3.09041113e-01f, 3.12999576e-01f, 1.60653934e-01f, 5.03909923e-02f, 4.79427487e-01f, 4.69668090e-01f, 4.32699382e-01f, 1.43499330e-01f,
  3.15535307e-01f, 1.76942885e-01f, 1.84428111e-01f, 4.13335949e-01f, 3.17676306e-01f, 3.80360246e-01f, 6.17742278e-02f, 2.03127846e-01f, 1.18517522e-02f, 5.32516360e-01f,
  -1.54115796e-01f, -1.88119888e-01f, 2.49940664e-01f, 1.95997991e-02f, 4.10832763e-02f, -1.19771250e-01f, -6.65867850e-02f, -1.16228908e-01f, -3.57386433e-02f, -9.76103395e-02f,
  -8.55049193e-02f, -1.50968194e-01f, 3.29571515e-02f, -4.02804726e-04f, -1.54103994e-01f, -1.12488039e-01f, 6.19588643e-02f, 9.27011445e-02f, -2.94144582e-02f, 3.32772033e-03f,
  1.41711861e-01f, 1.61383562e-02f, -1.33053824e-01f, -5.14294654e-02f, -4.83568385e-02f, 2.15598181e-01f, -4.33358923e-02f, 5.72904907e-02f, -1.75735250e-01f, -5.95024191e-02f,
  -3.08948308e-02f, 4.71700057e-02f, 5.17150424e-02f, 1.45397484e-01f, -1.39595931e-02f, 3.79794836e-02f, 1.62491158e-01f, -3.08054523e-03f, 1.16245411e-01f, 1.40322849e-01f,
  8.18739086e-02f, -1.40780108e-02f, -3.68776955e-02f, 7.73770586e-02f, 7.59521946e-02f, 3.43495817e-03f, 3.71723436e-03f, -6.72594011e-02f, 1.04127698e-01f, -5.67578860e-02f,
  1.20761961e-01f, -1.82784516e-02f, 5.53404391e-02f, 1.81883842e-01f, 1.60893813e-01f, 5.44438772e-02f, 1.13236718e-01f, -1.27780223e-02f, -1.11577706e-02f, -1.19003437e-01f,
  -6.59431517e-01f, 1.05603695e-01f, 1.52520940e-01f, -1.22194327e-02f, 5.66842826e-03f, 1.25441793e-02f, 1.10649161e-01f, -6.18808996e-03f, -2.36074664e-02f, 2.39110831e-02f,
  -2.01564342e-01f, 1.38093596e-02f, -9.89645720e-02f, 1.21192401e-02f, 1.29668295e-01f, -6.38069883e-02f, -1.78580433e-02f, 9.26308855e-02f, -3.41795571e-02f, -5.58312945e-02f,
  -3.41110080e-02f, -1.86478645e-01f, -2.22185567e-01f, -1.05128780e-01f, -1.09464355e-01f, -1.34826839e-01f, -1.27262443e-01f, -2.61004120e-01f, -2.88194537e-01f, -3.86778474e-01f,
  -9.19901252e-01f, 5.91083765e-01f, 2.99535275e-01f, -4.83242422e-01f, 3.50445211e-01f, 5.10269165e-01f, 7.21986234e-01f, 8.33944604e-02f, -2.80993253e-01f, 2.56418824e-01f,
  4.79757488e-01f, -1.82463929e-01f, -8.47025961e-02f, -1.19151443e-01f, 1.45730795e-03f, 3.94976169e-01f, 1.90142184e-01f, -4.07205164e-01f, -3.78246188e-01f, -1.35609418e-01f,
  1.75113350e-01f, -3.63498241e-01f, -5.40025175e-01f, -3.15980136e-01f, -1.80943519e-01f, -2.33589873e-01f, 1.42795980e-01f, 2.25905236e-02f, 3.68277669e-01f, -1.89119041e-01f,
  -1.59939736e-01f, 5.56211472e-02f, -2.63311509e-02f, -1.58365831e-01f, 1.13614187e-01f, -1.61809683e-01f, -5.10095097e-02f, -2.67290264e-01f, 2.09892206e-02f, 3.16346814e-05f,
  1.18472110e-02f, 5.91032654e-02f, -4.10551392e-02f, 9.01427399e-03f, 1.02346465e-02f, -1.63661957e-01f, -2.63152700e-02f, -2.97958612e-01f, -1.20307244e-01f, 6.45612180e-02f,
  2.05538005e-01f, 1.80162981e-01f, 1.03740327e-01f, 3.23303670e-01f, 2.59740204e-01f, 1.96545422e-02f, 2.32094795e-01f, -6.22631870e-02f, 1.15872519e-02f, -3.52250159e-01f,
  -1.09813131e-01f, 1.19931616e-01f, 1.64361387e-01f, 4.41673063e-02f, -7.69499615e-02f, 3.65318544e-02f, -8.49296078e-02f, 1.11196563e-01f, 9.42011923e-02f, -1.44624770e-01f,
  5.25472090e-02f, -5.11400141e-02f, -7.86137357e-02f, -2.46824510e-02f, -2.71796156e-02f, -7.28065297e-02f, -3.46990339e-02f, -7.00103864e-02f, 3.30239795e-02f, 9.63206068e-02f,
  -8.52965564e-02f, 5.43113984e-02f, -1.47338444e-02f, -1.98209688e-01f, 6.95331618e-02f, 7.73177017e-03f, -3.50717530e-02f, 6.28313050e-02f, -1.64286438e-02f, 9.15597752e-02f,
  -5.15232444e-01f, 4.61478412e-01f, -2.32392132e-01f, -3.94231454e-02f, 1.42813604e-02f, -5.96046634e-03f, 2.93758214e-02f, 9.72021967e-02f, 2.97716744e-02f, -1.00529708e-01f,
  1.68210447e-01f, -6.67052940e-02f, 1.10775173e-01f, -6.41463697e-02f, -8.22445303e-02f, 1.10280044e-01f, 2.93228254e-02f, -1.41601890e-01f, -1.07152145e-02f, 1.78394597e-02f,
  -4.82602939e-02f, -1.60818949e-01f, -3.90556604e-01f, -1.76821172e-01f, -1.29422143e-01f, -2.42195636e-01f, -1.80952027e-01f, -1.80692822e-01f, 2.94250753e-02f, -4.99939144e-01f,
  -5.24358273e-01f, -5.20656347e-01f, 3.95042211e-01f, -2.10196957e-01f, 3.95297408e-02f, 9.59240496e-02f, 1.43741714e-02f, -2.32410822e-02f, -1.83245972e-01f, -8.31411406e-02f,
  -2.00479835e-01f, -1.45421281e-01f, -5.51121868e-02f, 8.04180950e-02f, 3.35438810e-02f, 1.64994046e-01f, 2.59674519e-01f, 2.29025215e-01f, 2.69474715e-01f, 1.63564488e-01f,
  -6.19370025e-04f, 2.98874713e-02f, -1.32044792e-01f, -7.29929358e-02f, 1.40800318e-02f, 2.03117028e-01f, 4.96703647e-02f, 8.69933143e-03f, 3.41091566e-02f, 1.85025170e-01f,
  5.77824950e-01f, -8.68281573e-02f, 1.22634247e-01f, -9.47964266e-02f, 2.02025026e-02f, -3.76937725e-02f, 6.85699284e-02f, -2.72268746e-02f, -6.08734153e-02f, 4.18269150e-02f,
  2.43093027e-03f, -3.75929400e-02f, 6.92069763e-03f, -9.24130678e-02f, -4.42897193e-02f, -3.00352671e-03f, -1.18166260e-01f, -9.88017544e-02f, 1.52537040e-02f, -3.20558362e-02f,
  -1.46746948e-01f, -1.17108539e-01f, -3.92412990e-02f, -1.52849704e-01f, -1.21061809e-01f, -8.50318372e-02f, -1.50182202e-01f, -1.63917348e-01f, -1.52518675e-01f, -1.69276714e-01f,
  7.76062394e-03f, 3.71371172e-02f, -5.18325083e-02f, -4.47488111e-03f, -1.40996888e-01f, 3.33460071e-03f, 1.06270239e-01f, 3.07024922e-02f, -9.85249802e-02f, -1.00990653e-01f,
  -1.27166778e-01f, -7.19455555e-02f, -1.75186545e-01f, -6.97220489e-02f, -1.07149333e-02f, -1.39395878e-01f, -7.58375004e-02f, 2.85836239e-03f, -2.33260930e-01f, -1.95565537e-01f,
  -1.49153814e-01f, 8.47575739e-02f, -4.61462475e-02f, -2.87181716e-02f, -2.07002819e-01f, -1.29272223e-01f, 2.24156957e-02f, -1.83461756e-01f, -5.98300509e-02f, 5.26133440e-02f,
  1.89658463e-01f, -6.17696233e-02f, 1.68633893e-01f, 3.81070115e-02f, 7.21460804e-02f, -1.41600952e-01f, 2.99863424e-03f, 9.99922231e-02f, -1.75942257e-02f, 1.21420339e-01f,
  -2.86320727e-02f, 8.72610360e-02f, -8.99110511e-02f, -6.20777793e-02f, 1.08504131e-01f, 1.99344177e-02f, -1.27653256e-01f, 1.35893166e-01f, -3.87861356e-02f, 1.22823834e-01f,
  -1.31746873e-01f, 8.86648744e-02f, 1.00323208e-01f, 1.13737568e-01f, -1.59982010e-03f, 2.39325330e-01f, 1.62326813e-01f, 1.62098631e-01f, 1.67309806e-01f, -4.66913246e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  5.40564537e-01f, 2.41513968e-01f, 5.42564809e-01f, 3.88175756e-01f, 4.76314008e-01f, 7.09208965e-01f, 8.80827546e-01f, 5.30063808e-01f, 2.61647105e-01f, 1.67709902e-01f,
  3.56966734e-01f, 7.60330379e-01f, 7.60080099e-01f, 6.52141571e-02f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -9.23062041e-02f, 1.07651114e-01f, -8.18984956e-03f, 8.97979066e-02f, -1.91356726e-02f, 1.02455474e-01f, -5.39322086e-02f, -5.76763749e-02f, -6.93346746e-03f, 2.81076133e-01f,
  -7.73606747e-02f, 3.24608944e-02f, -1.96472302e-01f, -7.44812936e-02f, -9.63134021e-02f, -2.84011930e-01f, -2.02576712e-01f, -9.55631025e-03f, -2.08627686e-01f, 2.19523221e-01f,
  1.98676348e-01f, 1.73157722e-01f, 2.12595165e-01f, -1.36708803e-02f, -2.38715708e-01f, -5.68153337e-02f, -1.67956874e-01f, -1.64524227e-01f, -1.14692971e-01f, 6.75459206e-02f,
  -3.71690065e-01f, 6.62090704e-02f, -3.57325189e-02f, 2.68434696e-02f, -3.19334753e-02f, -9.69293863e-02f, -6.26097098e-02f, 1.85632899e-01f, -8.43917951e-02f, -9.36269108e-03f,
  -1.70715526e-01f, -3.31315994e-01f, -2.31758833e-01f, 8.69201869e-03f, 4.94688481e-01f, 6.78142384e-02f, 8.24875757e-02f, -7.52397627e-02f, 5.61146401e-02f, 7.49504641e-02f,
  -4.26839478e-02f, -1.20208271e-01f, -1.63923234e-01f, -1.03376575e-01f, 1.58765197e-01f, -2.79727846e-01f, 2.77662635e-01f, 4.53833580e-01f, 1.44581020e-01f, -6.03264630e-01f,
  3.32215405e-03f, -1.99288025e-01f, -1.71857998e-01f, -1.39424041e-01f, -2.98808008e-01f, -1.68134309e-02f, -1.90441966e-01f, 5.35869822e-02f, 1.05589069e-01f, -1.83983713e-01f,
  -1.84035391e-01f, -7.34149516e-02f, -1.01077229e-01f, -3.12175512e-01f, 1.09135486e-01f, -3.62461060e-02f, 1.69515878e-01f, 2.37168565e-01f, -1.02140419e-01f, -1.08674325e-01f,
  1.12032004e-01f, 1.02380395e-01f, -9.95416194e-02f, 5.71834929e-02f, 5.07967472e-02f, 7.41657019e-02f, 2.06056777e-02f, -5.74479103e-01f, -3.84342849e-01f, -5.11804000e-02f,
  3.59718502e-02f, 3.69101733e-01f, 3.76573414e-01f, 9.11344290e-02f, -1.89669371e-01f, -1.04525179e-01f, 5.38228974e-02f, 1.01369917e-01f, -8.22322676e-04f, 1.36936456e-01f,
  -1.59882624e-02f, 1.36881799e-01f, 1.99786544e-01f, 2.67689735e-01f, -1.78442150e-02f, -5.78819737e-02f, 4.26428691e-02f, 8.42137635e-02f, 3.28872263e-01f, 7.88099132e-03f,
  1.02489911e-01f, 1.89458698e-01f, -1.37762755e-01f, -6.32616431e-02f, 7.41417706e-02f, -1.89410537e-01f, 1.35597125e-01f, 3.18401545e-01f, 9.94171649e-02f, -2.57769167e-01f,
  -1.81895509e-01f, -3.03166755e-03f, -2.64779538e-01f, 9.21981782e-02f, 1.23778053e-01f, 3.26329678e-01f, -5.55425763e-01f, 3.96288559e-03f, 4.96044345e-02f, -1.38329074e-01f,
  3.20827961e-02f, -7.67588615e-02f, -1.13187760e-01f, 1.58529412e-02f, -2.72181302e-01f, 2.16239870e-01f, -9.39582810e-02f, 1.58322081e-01f, -1.23004742e-01f, -6.53055459e-02f,
  -7.66926035e-02f, 2.15155527e-01f, 2.93641035e-02f, -1.67138278e-01f, 7.45560527e-02f, 2.14719623e-02f, -1.91358675e-03f, 2.25894898e-02f, 2.94284105e-01f, -1.26717076e-01f,
  1.57235742e-01f, 2.10879952e-01f, -4.13444266e-02f, 8.10870677e-02f, -1.38507724e-01f, -3.73822570e-01f, -3.57535243e-01f, -1.66665971e-01f, 5.17095886e-02f, -2.45956555e-01f,
  -2.20675748e-02f, 1.65977955e-01f, -1.36533111e-01f, -1.60091568e-03f, -2.25394681e-01f, 1.13075316e-01f, 3.09001599e-02f, -3.96984667e-02f, 1.56731158e-02f, 3.20706964e-01f,
  -1.75510257e-01f, -1.66634277e-01f, 1.35804892e-01f, 2.23857034e-02f, 1.03138881e-02f, -1.23264872e-01f, -2.62302876e-01f, 1.06484078e-01f, -2.67069310e-01f, 1.96859613e-01f,
  -5.62099591e-02f, 8.51576403e-02f, 2.89337814e-01f, -3.28602880e-01f, 1.48087934e-01f, 1.50240332e-01f, 2.60762852e-02f, -3.89148921e-01f, -2.86398619e-01f, -1.85735554e-01f,
  2.20522493e-01f, -1.72689244e-01f, -1.01455294e-01f, 8.20311066e-03f, -1.10700049e-01f, -1.16155364e-01f, -2.67695077e-02f, -8.00765082e-02f, -2.04247937e-01f, 9.66492593e-02f,
  8.30166265e-02f, 2.81578600e-01f, 1.63579673e-01f, 3.34259984e-03f, -3.34537566e-01f, 5.37699759e-02f, -1.89713407e-02f, -1.47125825e-01f, -5.10002077e-02f, 1.07719027e-01f,
  2.28315264e-01f, 1.17677651e-01f, 1.95884153e-01f, 9.13077518e-02f, 2.57900730e-02f, -4.93932515e-01f, -2.27431238e-01f, -1.00293986e-01f, 2.27621913e-01f, 3.60077508e-02f,
  -4.60527629e-01f, 9.23523903e-02f, 3.00664872e-01f, -2.91934371e-01f, -5.81392273e-02f, -1.11852102e-01f, -1.36966646e-01f, 3.33196670e-01f, -1.04119360e-01f, -1.42484037e-02f,
  -6.97537661e-02f, 1.29685059e-01f, 4.75156307e-02f, -4.88230735e-01f, 2.26998135e-01f, -3.63526046e-02f, 3.36454660e-01f, -1.90001309e-01f, -1.38308853e-01f, 5.29813319e-02f,
  2.14803547e-01f, -2.46399179e-01f, -2.05611780e-01f, -3.34250703e-02f, -1.41717449e-01f, -6.31579533e-02f, -1.01300292e-01f, -3.29952627e-01f, 3.39198858e-01f, 1.28677174e-01f,
  6.31739711e-03f, 2.07153305e-01f, 2.35412300e-01f, -5.85516356e-02f, -1.91356063e-01f, -4.47586060e-01f, 9.90386754e-02f, -2.47830033e-01f, -7.76741505e-02f, -2.49310657e-01f,
  1.61052912e-01f, 4.25841473e-02f, 1.68230131e-01f, 1.49538904e-01f, -5.99841215e-03f, 9.83388256e-03f, 1.90741017e-01f, -2.99044102e-02f, -2.68707663e-01f, 1.65811196e-01f,
  1.71719983e-01f, -1.03167474e-01f, 8.76033008e-02f, 2.82035097e-02f, -1.39993876e-01f, 2.30458882e-02f, 5.72572470e-01f, -2.84137875e-01f, 2.42213219e-01f, 2.22495228e-01f,
  -3.23567331e-01f, -2.73829270e-02f, -2.74592638e-01f, 1.39850572e-01f, -4.17638384e-02f, 8.39084908e-02f, 4.57700416e-02f, -1.94939315e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.90636843e-01f, 7.35498741e-02f, 1.60051748e-01f, -1.49313048e-01f, -2.33930930e-01f, -3.56357992e-01f, -9.30348784e-02f, 1.92310527e-01f, -1.94313318e-01f, 2.26738006e-01f,
  2.62063026e-01f, -1.85243055e-01f, -7.53143787e-01f, -2.24273577e-01f, -1.88310370e-01f, -1.69668291e-02f, 1.09613433e-01f, 1.91027999e-01f, 1.00005078e+00f, -3.82636189e-01f,
  4.16832477e-01f, -1.17380321e+00f, 1.91159785e-01f, 1.80685043e-01f, -1.71267509e-01f, -1.16310097e-01f, 4.77278560e-01f, 7.95676589e-01f, -6.62596345e-01f, 2.84658343e-01f,
  6.71872437e-01f, 3.55689406e-01f, 2.06016779e-01f, -3.66932191e-02f, 1.18285365e-01f, 4.76260036e-01f, 2.92136222e-01f, 6.08104348e-01f, 3.85560989e-01f, 2.66892999e-01f,
  -4.33082618e-02f, -3.65740001e-01f, -2.49823675e-01f, 3.14093024e-01f, 2.17326283e-01f, 4.79348540e-01f, -4.19160336e-01f, 1.72008172e-01f, -2.42107347e-01f, -1.73383176e-01f,
  6.24953628e-01f, -3.51604491e-01f, 5.50743565e-02f, -4.57891673e-01f, -1.16632648e-01f, 6.02873743e-01f, -3.19992304e-01f, -8.43294635e-02f, 5.25829196e-01f, 6.25002664e-03f,
  4.13778096e-01f, 1.36023583e-02f, -1.67350724e-01f, 2.98707545e-01f, 2.88722306e-01f, -1.20717818e-02f, 1.59610480e-01f, 1.51289701e-01f, -5.12539782e-02f, 4.06795964e-02f,
  1.99395348e-03f, 1.88248158e-01f, 3.65826130e-01f, 7.41912946e-02f, -3.46922636e-01f, -4.92175251e-01f, -3.61138940e-01f, -1.53768316e-01f, 3.04113597e-01f, -1.55437768e-01f,
  3.69864911e-01f, 1.07376188e-01f, -8.16043139e-01f, 6.34296954e-01f, 1.38716012e-01f, -5.08893132e-01f, 2.26213098e-01f, 3.22856635e-01f, 5.42857885e-01f, -4.24924791e-01f,
  7.31159687e-01f, 7.31357753e-01f, -1.45102501e-01f, -2.50890136e-01f, 1.46983898e+00f, 6.72692209e-02f, 6.63583159e-01f, 1.83343858e-01f, 1.96301833e-01f, 3.93728435e-01f,
  3.39757979e-01f, 2.43125141e-01f, 5.70963025e-01f, 2.20219329e-01f, 1.47241140e-02f, -5.78640640e-01f, 1.11867748e-01f, -2.13473931e-01f, 1.52394998e+00f, 3.32290322e-01f,
  3.32031161e-01f, -4.03450817e-01f, 3.82419586e-01f, -1.16763741e-01f, -1.69273421e-01f, -1.62958309e-01f, 6.29176676e-01f, -4.84082073e-01f, 7.45687842e-01f, 1.87876761e-01f,
  -4.11255300e-01f, 5.55075407e-01f, -2.96128273e-01f, -8.98922905e-02f, 5.93930960e-01f, 6.21454120e-02f, -1.56555399e-01f, -3.88997138e-01f, 2.96584278e-01f, 4.33408409e-01f,
  5.06396592e-01f, 3.03190559e-01f, 5.43812327e-02f, 4.14942533e-01f, 3.69177073e-01f, 4.43576753e-01f, 4.24141437e-01f, -1.82787731e-01f, -4.32681471e-01f, -1.03823557e-01f,
  9.84651893e-02f, -5.00960290e-01f, -4.48334627e-02f, 2.15625286e-01f, 5.85361779e-01f, -2.57366806e-01f, -4.44584399e-01f, 2.12332144e-01f, 1.48566872e-01f, 1.21989965e-01f,
  -2.25398503e-02f, 1.02142084e+00f, 1.03137708e+00f, -1.02430329e-01f, -8.58163476e-01f, -9.94513854e-02f, 4.66867983e-01f, 5.12218475e-01f, 3.92764062e-01f, 8.25147480e-02f,
  3.53219271e-01f, 4.02113318e-01f, 3.35673302e-01f, 5.02326787e-01f, -2.10492257e-02f, 1.39358595e-01f, 3.36167127e-01f, 5.10376513e-01f, 3.86195093e-01f, 9.20535147e-01f,
  -1.84126019e-01f, -4.56931263e-01f, -4.95183319e-01f, 9.79355797e-02f, -1.04357950e-01f, -4.09078985e-01f, -5.41317046e-01f, 3.95726748e-02f, 4.79062498e-01f, 9.51445699e-02f,
  7.99997225e-02f, -2.39582002e-01f, 5.85762143e-01f, 1.12825608e+00f, -3.69019717e-01f, 3.12652737e-01f, -1.42363727e-01f, -6.92403242e-02f, -8.42449546e-01f, 4.36304122e-01f,
  -8.92039657e-01f, 1.01999171e-01f, 1.58350736e-01f, 3.48993301e-01f, 3.22820157e-01f, 9.76838171e-02f, 3.21154892e-01f, 3.71427163e-02f, 9.75835323e-02f, 2.98471719e-01f,
  3.79952282e-01f, 5.18161535e-01f, 4.52389628e-01f, 4.62295234e-01f, -5.23571074e-01f, -4.26278263e-01f, 2.96949074e-02f, 1.54197976e-01f, -1.20159596e-01f, -3.76077920e-01f,
  2.95949489e-01f, -6.56872034e-01f, 1.02934875e-01f, 3.96586418e-01f, -2.82815564e-02f, 8.93896297e-02f, 4.55335349e-01f, -2.38249555e-01f, -3.89245123e-01f, 5.26121616e-01f,
  3.42176467e-01f, 1.08253050e+00f, 3.14650446e-01f, 2.25619033e-01f, -3.08344036e-01f, -5.99477828e-01f, 8.52760393e-03f, -1.16511382e-01f, -1.01098590e-01f, 1.73683614e-02f,
  -1.13205276e-01f, 4.73598856e-03f, -3.02105248e-01f, -5.97102940e-01f, 3.39539140e-01f, 5.81340156e-02f, -1.37600213e-01f, 1.14222087e-01f, 5.63355582e-03f, -2.06466705e-01f,
  2.79405534e-01f, -7.80154392e-02f, -3.22466463e-01f, -1.35252371e-01f, 6.79900765e-01f, -4.19708073e-01f, 3.91646206e-01f, -4.57098871e-01f, -4.37209725e-01f, 7.08670840e-02f,
  2.02205032e-01f, 3.58874234e-03f, 4.80332315e-01f, -4.70174849e-02f, -2.29943678e-01f, -1.11792035e-01f, 1.55923083e-01f, -2.91651022e-02f, 7.24744871e-02f, 3.42056483e-01f,
  4.95892107e-01f, 3.08922172e-01f, 3.90966505e-01f, 3.32193673e-01f, 1.80229947e-01f, -1.58757091e-01f, 6.22646213e-01f, 1.01841904e-01f, -6.71748996e-01f, 1.23351142e-01f,
  2.69156635e-01f, 1.81386679e-01f, 9.30293351e-02f, -5.56056984e-02f, 8.50211605e-02f, -1.97614864e-01f, 8.02520588e-02f, -2.40724728e-01f, -9.99773741e-02f, -4.72449839e-01f,
  7.97825038e-01f, -5.30493915e-01f, 5.01745284e-01f, 5.26890099e-01f, 6.05879605e-01f, 3.66799712e-01f, 8.98402810e-01f, -3.50647599e-01f, -3.42479557e-01f, -4.41779494e-01f,
  1.31744802e-01f, 6.67188525e-01f, 4.99332696e-01f, -2.62255847e-01f, 2.09646657e-01f, 1.72805384e-01f, -1.42532483e-01f, -4.81438577e-01f, 6.07718289e-01f, 6.24221377e-03f,
  4.26157683e-01f, 5.12315810e-01f, -1.95778117e-01f, -3.17561507e-01f, 5.49589097e-01f, -1.50497839e-01f, 2.33366445e-01f, -1.35732353e-01f, 3.83483618e-01f, -8.43053281e-01f,
  3.07097912e-01f, -2.34513342e-01f, -1.04070592e+00f, 3.26244146e-01f, 7.57399248e-03f, 7.71257102e-01f, 6.63227737e-01f, 2.27247357e-01f, -9.42452624e-02f, 1.71895191e-01f,
  4.38035965e-01f, 4.19752955e-01f, 1.31888151e-01f, 7.11779475e-01f, 2.54288554e-01f, 2.24402279e-01f, 8.44995826e-02f, 3.47842097e-01f, -9.68460068e-02f, 9.84756947e-01f,
  2.50309139e-01f, -1.58839300e-02f, -2.64844626e-01f, 3.50181788e-01f, 3.91257107e-01f, -3.61189961e-01f, -9.30781066e-01f, 2.16426149e-01f, 6.12233162e-01f, -5.95240057e-01f,
  7.43197083e-01f, -3.94828357e-02f, 5.26589692e-01f, -6.52556270e-02f, 5.04195169e-02f, 2.31353000e-01f, -1.13832548e-01f, -3.80324215e-01f, -7.23539948e-01f, 1.99737608e-01f,
  -2.33697549e-01f, -2.57632077e-01f, 8.75042796e-01f, 2.02606991e-01f, 1.71143353e-01f, 1.12412833e-01f, 7.30540037e-01f, 6.22427285e-01f, 5.14186084e-01f, 7.67237067e-01f,
  -1.14457726e-01f, 1.65953949e-01f, 1.92636520e-01f, -4.12651673e-02f, 4.35126007e-01f, 5.29348969e-01f, 4.34879631e-01f, 1.65485144e-01f, 2.58971155e-01f, 6.74936771e-02f,
  -3.24057043e-01f, -6.16422832e-01f, 3.92372370e-01f, -1.39312103e-01f, 1.76996201e-01f, 1.46859616e-01f, -1.30517274e-01f, -4.79770094e-01f, 1.86499462e-01f, -1.69847205e-01f,
  1.92041665e-01f, 2.76064664e-01f, 5.41491270e-01f, -4.39714640e-01f, -8.89728591e-02f, 9.89823937e-02f, 1.79872721e-01f, 4.26740617e-01f, -2.49425247e-01f, -6.89597055e-02f,
  -2.70811945e-01f, 2.67028004e-01f, 9.05034170e-02f, 7.12235153e-01f, 4.19799685e-02f, -2.24294871e-01f, -3.95063698e-01f, 1.31511152e-01f, 3.43742669e-01f, -2.21049562e-01f,
  -4.39892352e-01f, -6.23205900e-02f, 2.85755172e-02f, 1.35672256e-01f, 5.85342586e-01f, 4.09016460e-01f, 7.92268455e-01f, -5.85355639e-01f, -2.29670197e-01f, 4.74547684e-01f,
  1.44685268e-01f, 2.76959300e-01f, -5.12391090e-01f, 5.31539857e-01f, 5.64555414e-02f, -2.02442139e-01f, 8.58993590e-01f, 2.56278634e-01f, 1.58713579e-01f, 3.25074941e-01f,
  -1.61997676e-02f, 6.52847826e-01f, 4.27917212e-01f, 4.19844478e-01f, -1.51128903e-01f, -6.05638623e-01f, -4.77404445e-01f, -7.66331851e-02f, 1.16666627e+00f, 7.99739420e-01f,
  -7.62100145e-02f, 2.26524457e-01f, 1.15381971e-01f, 2.11854294e-01f, 6.05612755e-01f, -2.67599732e-01f, -8.40304121e-02f, -2.76049972e-01f, -6.89753965e-02f, 3.92123222e-01f,
  1.48218304e-01f, 1.10569715e-01f, 6.76407158e-01f, -2.04421967e-01f, 2.44499177e-01f, -6.39545381e-01f, 7.01681852e-01f, -2.41209835e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  1.06417678e-01f, 3.58835280e-01f, 2.51554132e-01f, 4.13202494e-01f, 5.81328750e-01f, 2.73013443e-01f, 2.45248675e-01f, 1.59774035e-01f, 6.68476298e-02f, 1.41351014e-01f,
  4.74320650e-01f, 4.53907013e-01f, 2.29935288e-01f, 4.85912055e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -6.89916015e-01f, -3.91047210e-01f, -4.53542210e-02f, -6.39584437e-02f, -5.81088662e-01f, -2.93792486e-01f, -1.11144221e+00f, -3.89603347e-01f, 9.55165774e-02f, 1.95390925e-01f,
  -2.58582652e-01f, 3.41356099e-01f, -3.55869643e-02f, 5.67175925e-01f, 3.70126426e-01f, 9.61254686e-02f, 6.56915009e-02f, -3.14604402e-01f, 4.65202719e-01f, -4.76973474e-01f,
  1.44234538e-01f, 8.63170251e-02f, -8.38710785e-01f, -1.04195647e-01f, -5.54359257e-01f, 4.82546031e-01f, -6.08773947e-01f, 2.48659134e-01f, 3.30532104e-01f, 9.32106189e-03f,
  3.41130704e-01f, -6.27347529e-01f, -7.09732652e-01f, 8.29980671e-01f, 2.24313706e-01f, -1.29857153e-01f, 4.62565571e-01f, -4.85282868e-01f, 3.79030049e-01f, 2.69405425e-01f,
  8.33344534e-02f, 7.61746943e-01f, 2.05260903e-01f, -4.68892530e-02f, 4.42110658e-01f, 2.92445093e-01f, 5.31996071e-01f, 5.38873971e-01f, -2.88448393e-01f, -7.77105212e-01f,
  -8.91467869e-01f, -8.30546916e-01f, -5.97754359e-01f, -5.12552299e-02f, -1.70753092e-01f, 4.54658836e-01f, 6.21779449e-02f, -5.72402835e-01f, -8.20195377e-01f, -4.55531031e-01f,
  5.54136515e-01f, -6.00954294e-01f, 5.93481362e-01f, -7.49273002e-01f, 2.37736821e-01f, -4.45357442e-01f, -1.28777862e-01f, -6.05881214e-01f, 1.30799979e-01f, -1.15555152e-02f,
  1.42413348e-01f, 5.29267371e-01f, -2.16487899e-01f, 7.36246333e-02f, -5.21726429e-01f, -2.22830981e-01f, 1.53098777e-01f, -7.61643052e-01f, -3.78188968e-01f, 4.53916937e-01f,
  -5.93316138e-01f, 7.89036274e-01f, -4.85168666e-01f, -1.14938483e-01f, -9.75663900e-01f, -4.65423644e-01f, -2.56704353e-02f, -4.52020168e-01f, 5.24347484e-01f, -7.14087710e-02f,
  4.58938718e-01f, -8.16809177e-01f, 4.93578464e-01f, 7.69685209e-01f, 2.31540695e-01f, -9.48330760e-01f, -8.35141838e-02f, -2.89243996e-01f, -5.42609811e-01f, -6.03640139e-01f,
  6.72968090e-01f, -1.02629937e-01f, -4.41021591e-01f, -1.56217799e-01f, 2.01045200e-01f, -4.62325901e-01f, -4.52402025e-01f, -6.35676146e-01f, 5.03440976e-01f, 3.53711903e-01f,
  7.01423809e-02f, 8.01180825e-02f, -4.81217712e-01f, 5.57391234e-02f, 3.26940060e-01f, -1.47188246e-01f, 4.56059694e-01f, -3.90378326e-01f, -8.29589963e-01f, -5.10126948e-01f,
  -1.41311586e-01f, -1.75276399e-01f, 4.06769663e-01f, -5.23925841e-01f, -1.35199398e-01f, 3.05216074e-01f, -1.78632304e-01f, 3.79264385e-01f, 5.94031036e-01f, -3.02275270e-01f,
  -1.49935007e-01f, 4.68017787e-01f, -7.18785450e-02f, 1.17653802e-01f, 3.22940946e-01f, 5.73040545e-01f, -7.05716074e-01f, -5.32351494e-01f, 4.38234538e-01f, 9.36389685e-01f,
  -7.45242596e-01f, 5.11553474e-02f, -5.12700856e-01f, 7.34042943e-01f, 1.73694596e-01f, 4.46489125e-01f, -1.18118018e-01f, 5.29736638e-01f, 4.23600934e-02f, 1.25063255e-01f,
  -1.76874086e-01f, -8.66810679e-01f, -8.00897300e-01f, 4.01299000e-01f, 1.49267688e-01f, 5.50073266e-01f, -1.43516615e-01f, 2.60709852e-01f, 4.44847606e-02f, 4.09826338e-01f,
  8.76903057e-01f, 1.23183675e-01f, 4.06493336e-01f, 5.59823096e-01f, -2.50584006e-01f, 7.24764764e-01f, 4.75754470e-01f, 2.98133612e-01f, 5.09007573e-01f, -1.05194807e-01f,
  6.70281351e-01f, -4.17321920e-01f, 5.62121272e-01f, 4.99197066e-01f, 6.12161636e-01f, -4.77949142e-01f, -4.07666743e-01f, 8.72424424e-01f, -3.55248809e-01f, 2.16637656e-01f,
  -3.82166713e-01f, 6.54997647e-01f, 1.41731754e-01f, -1.11257955e-02f, -7.74859130e-01f, -1.22670636e-01f, -1.16848326e+00f, -2.60395229e-01f, 1.98657423e-01f, 5.01340628e-01f,
  -1.96598232e-01f, 7.74252057e-01f, 2.03064173e-01f, -1.09825633e-01f, 4.37678277e-01f, -9.75065082e-02f, -4.20618176e-01f, 6.04221642e-01f, -4.53247756e-01f, -6.65310442e-01f,
  -3.62128109e-01f, -4.04350430e-01f, 6.54305339e-01f, 5.68366423e-02f, 6.36384010e-01f, -5.02401292e-01f, -6.57737970e-01f, -3.21023434e-01f, 2.39802539e-01f, -9.91248071e-01f,
  -9.78318632e-01f, -4.65985239e-01f, -1.26239741e+00f, 2.43502036e-01f, 6.09046161e-01f, -5.67393720e-01f, 5.51807046e-01f, -5.40906549e-01f, 1.41744062e-01f, -1.12810290e+00f,
  -7.86008954e-01f, -9.12287593e-01f, -5.23932636e-01f, -4.14557695e-01f, -4.03022110e-01f, -4.83252347e-01f, 1.79495573e-01f, 3.40755850e-01f, -4.08996433e-01f, -5.35597742e-01f,
  4.42256421e-01f, -6.90385818e-01f, -2.92884290e-01f, -1.68642461e-01f, -4.81851399e-01f, 3.24152827e-01f, -5.23503125e-01f, -1.62587374e-01f, -2.10926995e-01f, 2.41950989e-01f,
  -7.24359155e-02f, 9.69830304e-02f, 7.22666740e-01f, -3.38840067e-01f, 5.73711157e-01f, -7.43825376e-01f, -7.56122842e-02f, -5.79407774e-02f, 5.25978133e-02f, -2.11896852e-01f,
  2.20492542e-01f, 3.10740739e-01f, -6.91390872e-01f, -8.76746893e-01f, -1.45798251e-01f, -9.05969739e-01f, -1.53697774e-01f, -4.40712899e-01f, -8.97617817e-01f, 1.49715379e-01f,
  4.08382207e-01f, 3.26469123e-01f, -7.04084754e-01f, -5.70927858e-02f, 5.33080220e-01f, 3.10690850e-01f, -6.70369864e-01f, -5.43779969e-01f, -2.47111246e-01f, 3.77116233e-01f,
  -3.70613515e-01f, -4.54171836e-01f, -3.97259444e-01f, 1.63019374e-01f, -2.56006479e-01f, 3.69039714e-01f, 1.71781957e-01f, -7.21125245e-01f, 4.09929752e-01f, 7.02917457e-01f,
  1.63856242e-02f, -1.55215546e-01f, -3.55238020e-01f, -3.10141593e-01f, -1.01860440e+00f, -1.07875921e-01f, -5.82629502e-01f, -5.99683046e-01f, 2.13097870e-01f, 4.00617301e-01f,
  1.27541229e-01f, -6.29757047e-01f, -5.94161868e-01f, -9.16473344e-02f, -1.16858497e-01f, -5.58785684e-02f, 2.85443276e-01f, 2.17343956e-01f, -5.18307030e-01f, 7.28617132e-01f,
  2.77493447e-01f, 6.67006522e-02f, -4.48734045e-01f, -4.30784047e-01f, 6.72544837e-01f, 8.22505534e-01f, -7.29026794e-01f, -3.36505234e-01f, -8.85802031e-01f, 7.80185699e-01f,
  -2.85921603e-01f, -4.57343012e-01f, 2.62098938e-01f, 1.62939295e-01f, 1.58248588e-01f, 1.15916538e+00f, -1.01732039e+00f, 3.10305238e-01f, -3.17981899e-01f, -2.92142212e-01f,
  1.11430809e-02f, 1.82864591e-01f, -2.69318610e-01f, -9.30396318e-02f, 1.42868273e-02f, -9.02264416e-02f, -2.54888505e-01f, -5.14636636e-01f, -1.43096700e-01f, -2.59876579e-01f,
  2.18152151e-01f, -2.27757320e-01f, -2.98150986e-01f, 3.50006856e-02f, -5.39834678e-01f, -1.84147671e-01f, -1.63481414e-01f, -5.66548347e-01f, 8.02271783e-01f, 6.78035080e-01f,
  -5.36162674e-01f, -1.11168087e+00f, -6.66537046e-01f, 3.49780113e-01f, -5.19147396e-01f, -5.72852135e-01f, -4.57767814e-01f, -8.36409405e-02f, 3.01330954e-01f, -5.45768559e-01f,
  -8.94221842e-01f, 5.46999216e-01f, -2.29945686e-02f, 2.86080360e-01f, -1.10528901e-01f, -1.59411430e-01f, 8.94317329e-01f, -2.95989394e-01f, -1.63563043e-01f, 4.09223557e-01f,
  3.03460538e-01f, -8.20431635e-02f, 7.29952753e-01f, -6.95579171e-01f, -7.72084653e-01f, -2.32023269e-01f, 8.18481922e-01f, -9.69504863e-02f, 5.99210441e-01f, -3.89581442e-01f,
  -9.92882431e-01f, -9.00931358e-01f, 6.43845797e-01f, 2.18761131e-01f, 2.19288886e-01f, -7.33040094e-01f, -4.98223364e-01f, -2.39049092e-01f, 5.20393908e-01f, -1.72862157e-01f,
  -3.86407912e-01f, -1.61470026e-01f, -9.26102877e-01f, 3.71962041e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  9.31593552e-02f, 5.14844880e-02f, 5.38608581e-02f, -2.75186121e-01f, 9.47583318e-02f, 3.09709787e-01f, 3.31809729e-01f, -2.68347204e-01f, -3.21021765e-01f, 1.15822501e-01f,
  -2.46080264e-01f, -7.67559186e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    