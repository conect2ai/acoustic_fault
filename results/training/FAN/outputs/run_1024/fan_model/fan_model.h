/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  6.08216226e-01f, 3.07316542e-01f, 4.53715324e-01f, -7.79015012e-03f, -1.75920501e-01f, 5.37538119e-02f, 1.84548900e-01f, 4.98420112e-02f, -1.18451171e-01f, -2.78050452e-02f,
  -2.13622719e-01f, -1.31742239e-01f, 6.54345155e-02f, 5.11215925e-02f, 2.28078574e-01f, 1.45755082e-01f, 1.94432572e-01f, 3.82797092e-01f, 1.93414450e-01f, 1.47538170e-01f,
  -7.64191849e-03f, 6.78613707e-02f, 2.17663065e-01f, 3.64913717e-02f, -1.58711674e-03f, -4.72986288e-02f, 3.13402116e-02f, 4.38524000e-02f, -5.28665930e-02f, -8.66434053e-02f,
  3.85744125e-01f, 1.97663754e-01f, 4.62902039e-02f, -1.61985047e-02f, 6.53908402e-02f, 4.54217494e-02f, 6.68006092e-02f, 6.75274953e-02f, 1.13108702e-01f, 8.65981951e-02f,
  -7.31199160e-02f, 1.18628973e-02f, -1.08374566e-04f, -2.13716235e-02f, 8.45149681e-02f, 2.73432117e-02f, 7.83649273e-03f, 1.72892362e-01f, 4.37434725e-02f, 5.98614514e-02f,
  -1.27344966e-01f, 4.20900062e-02f, 1.16745889e-01f, 8.19103345e-02f, 1.93135113e-01f, -3.42403017e-02f, 1.41008317e-01f, 1.32436827e-01f, 6.49601221e-02f, 1.44632667e-01f,
  -1.12722382e-01f, 3.61247063e-02f, -8.04326758e-02f, 8.33030418e-02f, -2.98619568e-02f, -3.89726460e-02f, -1.87061671e-02f, 1.25801307e-03f, 8.98922682e-02f, 3.54319476e-02f,
  -5.90222888e-02f, -3.39198299e-02f, -3.14903706e-02f, 5.72059751e-02f, -5.39586134e-02f, 3.53746898e-02f, 4.12812904e-02f, -2.26175822e-02f, -3.08486540e-03f, -4.65348773e-02f,
  -9.74912103e-03f, 6.77715316e-02f, -9.03981030e-02f, 4.40502316e-02f, -4.07821536e-02f, 6.31803274e-02f, 4.01660316e-02f, -1.07649555e-02f, 2.69127917e-02f, -1.36479801e-02f,
  -5.45097105e-02f, -6.65684324e-03f, 5.95041588e-02f, 1.74458101e-02f, 3.01544406e-02f, -4.62468714e-02f, 2.42533945e-02f, 4.86195236e-02f, 6.78767562e-02f, 1.69526726e-01f,
  1.01077624e-01f, 1.38119742e-01f, 4.94073108e-02f, 5.99223468e-03f, 5.17256884e-03f, -2.95899250e-03f, 1.86127890e-02f, 2.72436030e-02f, 3.40248719e-02f, 2.00910121e-02f,
  -1.49497939e-02f, 3.37079018e-02f, 1.19810253e-01f, 3.76777947e-02f, 1.01792522e-01f, 1.29158739e-02f, 2.05575123e-01f, 2.19077487e-02f, 8.05648491e-02f, 1.95213631e-01f,
  -3.64412814e-01f, 3.66240114e-01f, 2.96742260e-01f, -1.05278164e-01f, 1.91746086e-01f, 3.63956243e-02f, 4.89559174e-02f, -9.33877006e-02f, -1.33442715e-01f, 8.16439837e-02f,
  1.49069563e-01f, -1.26335427e-01f, -8.79416689e-02f, -5.08867428e-02f, -1.80005789e-01f, 2.12206885e-01f, 1.46454781e-01f, 7.25013856e-03f, -2.39715338e-01f, -8.58158618e-02f,
  2.71746628e-02f, -8.81672464e-03f, -1.16327792e-01f, -1.98447686e-02f, 1.87288657e-01f, -4.51996960e-02f, 1.45471990e-01f, 1.47464558e-01f, 1.70919314e-01f, 2.01080263e-01f,
  2.98667729e-01f, 5.61433695e-02f, -7.87381679e-02f, -4.44991514e-02f, 2.66015112e-01f, 1.22318439e-01f, 2.79628076e-02f, 1.14600532e-01f, 1.38501331e-01f, 1.06998689e-01f,
  1.70163617e-01f, 8.41498524e-02f, 1.02418020e-01f, 4.79535908e-02f, 8.63240734e-02f, 8.55159909e-02f, 4.49339263e-02f, 4.55075316e-02f, 1.24510027e-01f, 1.16039217e-01f,
  2.64726460e-01f, 6.12334497e-02f, 1.48724690e-02f, -1.31042106e-02f, 8.59295353e-02f, 3.37979160e-02f, 1.27536580e-01f, 1.41883761e-01f, -1.33871194e-03f, 3.14518474e-02f,
  9.74717457e-03f, -1.06782131e-02f, -1.82763562e-02f, -1.08232729e-01f, -2.24334840e-02f, -3.73066664e-02f, -2.43264791e-02f, -8.22035819e-02f, -6.40418306e-02f, -4.43602689e-02f,
  -1.85649674e-02f, -9.11010802e-02f, 9.64569300e-03f, -1.03523716e-01f, -7.20512643e-02f, -4.70745452e-02f, -3.56802568e-02f, -1.57293350e-01f, -9.44820493e-02f, -4.76071350e-02f,
  -2.80909203e-02f, -1.00391254e-01f, -7.12435693e-02f, -4.54265960e-02f, -1.16762519e-01f, -9.91183519e-03f, -2.92627644e-02f, -4.43057381e-02f, -1.76823035e-01f, -6.94114193e-02f,
  -1.04589149e-01f, -2.02578474e-02f, -9.66461003e-02f, -2.97935829e-02f, 2.11992543e-02f, 3.96154672e-02f, 4.67725284e-02f, 4.78823036e-02f, 3.82994153e-02f, 8.29445720e-02f,
  5.01103178e-02f, 4.24317867e-02f, 4.55223173e-02f, 1.51209518e-01f, -8.15430004e-03f, -7.62042627e-02f, 2.96837781e-02f, 2.72153821e-02f, -4.44023730e-03f, 1.11212596e-01f,
  1.24776155e-01f, -8.55699256e-02f, -7.64513388e-02f, 1.12731345e-02f, 2.84473654e-02f, -1.44436374e-01f, 1.00663617e-01f, -7.81133324e-02f, -8.43666494e-02f, 2.93231886e-02f,
  -4.60337847e-01f, 2.76190877e-01f, 4.29741681e-01f, -1.00169472e-01f, 2.79642344e-01f, 1.75507560e-01f, 2.76563734e-01f, 1.38289798e-02f, -3.95021439e-02f, -4.73907217e-02f,
  1.39309824e-01f, -1.98932797e-01f, -3.77353616e-02f, 1.54056419e-02f, -1.46525875e-01f, 2.39773259e-01f, 1.74665913e-01f, 6.78178668e-02f, -9.85313505e-02f, -4.23618592e-02f,
  2.23778989e-02f, -1.57024816e-01f, -1.37817785e-01f, -3.48037970e-03f, -1.24264788e-02f, -1.30401313e-01f, 2.45174672e-02f, -4.30978946e-02f, 1.21579871e-01f, 1.03024743e-01f,
  1.53590562e-02f, 1.11013375e-01f, 4.10248078e-02f, 6.50422052e-02f, 1.02354527e-01f, -4.96726669e-02f, -1.04804710e-02f, 3.22218724e-02f, 2.98105273e-02f, 8.41420665e-02f,
  9.58323572e-03f, 6.89027831e-02f, 1.02271780e-01f, 2.03594156e-02f, 6.40568063e-02f, -5.99225387e-02f, 8.22100937e-02f, 8.49214345e-02f, 1.30450279e-01f, 3.31201479e-02f,
  1.38352945e-01f, 1.75865263e-01f, 1.06232665e-01f, 8.67988095e-02f, 1.12129770e-01f, -1.41201327e-02f, 1.30386233e-01f, -3.30421031e-02f, -4.46379324e-03f, -1.97481513e-01f,
  3.45504433e-02f, 1.33608684e-01f, -2.17113085e-02f, 2.51788143e-02f, -1.10335574e-01f, -1.12674655e-02f, -6.83064237e-02f, -1.40862940e-02f, 7.80240633e-04f, -7.12115765e-02f,
  4.20151763e-02f, -2.44163368e-02f, 4.56565917e-02f, -1.68165080e-02f, -6.18952289e-02f, 9.51005071e-02f, 8.16740934e-03f, -6.87007792e-03f, -1.41734499e-02f, -3.93915996e-02f,
  -5.83484136e-02f, 1.73985194e-02f, -4.83785048e-02f, 2.44112965e-02f, -2.32738517e-02f, 3.84473540e-02f, -7.48888329e-02f, -3.88966314e-02f, -2.96140066e-03f, -1.41675556e-02f,
  -2.58762568e-01f, 8.87152553e-02f, -8.68752077e-02f, -3.13649178e-02f, 7.06050247e-02f, 6.37344923e-03f, 3.14582586e-02f, -3.72573966e-03f, 8.38804021e-02f, 1.26679987e-02f,
  7.85905346e-02f, -1.18424103e-01f, -2.65649036e-02f, 6.81551769e-02f, -1.31071238e-02f, 4.52152304e-02f, -3.46357524e-02f, -1.94134377e-02f, 2.06558891e-02f, 9.16455686e-02f,
  1.06493883e-01f, -8.78385007e-02f, -1.57155767e-01f, -4.04238515e-02f, -6.78745955e-02f, -1.03591628e-01f, -1.01733536e-01f, -2.95589734e-02f, -1.38591781e-01f, -2.92663723e-01f,
  -6.12390935e-02f, 8.13147351e-02f, -2.58180231e-01f, -1.00648671e-01f, 7.21239895e-02f, 2.82527119e-01f, 3.96603972e-01f, 2.03566104e-01f, -5.55377007e-02f, -5.65634817e-02f,
  1.46761715e-01f, 8.65175501e-02f, -7.56052136e-02f, 4.27646190e-02f, 2.42639452e-01f, 3.96519294e-03f, -1.42012790e-01f, -2.65678186e-02f, 2.06092715e-01f, 1.18624821e-01f,
  7.60979131e-02f, -9.27321240e-03f, 2.32839063e-02f, -8.33189581e-03f, -8.12993795e-02f, -4.28088158e-02f, -2.73887417e-04f, -7.38681853e-02f, 1.10978987e-02f, -2.37414420e-01f,
  -3.95481557e-01f, -1.15789048e-01f, 1.38449401e-01f, 3.19973342e-02f, -4.73441817e-02f, -1.64183769e-02f, 2.20247414e-02f, -5.57815172e-02f, 1.44664766e-02f, -5.05105443e-02f,
  4.17685509e-03f, -1.89351402e-02f, -5.41189052e-02f, -1.96600109e-02f, 3.32661420e-02f, 3.57357636e-02f, -3.57509181e-02f, -1.27417356e-01f, -1.58203710e-02f, -5.43874614e-02f,
  4.84293178e-02f, 8.16115811e-02f, -3.58564071e-02f, -1.41804591e-02f, 6.60644248e-02f, 3.03334668e-02f, 9.16448236e-02f, 5.62870465e-02f, 6.83524311e-02f, -2.74437934e-01f,
  4.99228984e-02f, -1.24303363e-01f, 2.09468063e-02f, 4.47007688e-03f, 4.01761441e-04f, -1.00133039e-01f, -2.50897519e-02f, -1.41775534e-01f, -5.50709292e-02f, -7.23150969e-02f,
  1.85502488e-02f, -3.92997824e-02f, -5.81080541e-02f, -6.93343654e-02f, -8.79255757e-02f, -5.52730300e-02f, -4.52485085e-02f, -5.27034178e-02f, -6.19888566e-02f, -4.84940745e-02f,
  -9.97378770e-03f, -5.58067374e-02f, -6.93638101e-02f, -9.59429070e-02f, -1.46980081e-02f, -5.90344258e-02f, -1.00384150e-02f, -1.80945080e-02f, -1.18403755e-01f, -5.43842465e-02f,
  3.71145178e-03f, 3.44475597e-01f, -5.88082746e-02f, 7.72569329e-02f, 1.97878503e-03f, -5.38621191e-03f, 7.12653622e-02f, -1.49646113e-02f, 1.99157149e-02f, 4.26083505e-02f,
  3.16305608e-02f, 1.33288965e-01f, 7.01719299e-02f, -2.81099044e-03f, 7.47558102e-02f, 9.50514106e-04f, 8.77492502e-02f, 6.51865527e-02f, 3.44718099e-02f, 2.94482354e-02f,
  6.64480701e-02f, 8.01490024e-02f, -3.34958136e-02f, -2.01261863e-02f, -1.29189249e-02f, 1.50818974e-01f, 9.44310576e-02f, 2.04923265e-02f, 1.52916819e-01f, 1.38652265e-01f,
  -2.44976297e-01f, -4.20668095e-01f, -2.67079528e-02f, -1.01097763e-01f, -7.44000226e-02f, -3.41122746e-01f, -5.27758896e-01f, -2.39280209e-01f, -7.18795508e-02f, -1.91096738e-01f,
  1.15952089e-01f, 1.04873806e-01f, 4.63977121e-02f, -1.62867457e-02f, -1.32635638e-01f, -3.35909456e-01f, -2.76977271e-01f, -7.02341050e-02f, -3.65189053e-02f, -1.48575619e-01f,
  2.79234722e-03f, 1.24499043e-02f, 4.02763560e-02f, -1.33181170e-01f, 1.12857923e-01f, 1.24796636e-01f, -6.32300740e-03f, -6.92974500e-05f, -1.01747304e-01f, 1.59607932e-01f,
  2.59558201e-01f, 3.16320434e-02f, -1.51247382e-01f, -8.31992105e-02f, -3.52935144e-03f, -6.02067672e-02f, -7.26549551e-02f, -6.50229082e-02f, -3.29974107e-02f, -1.18127065e-02f,
  -1.06679825e-02f, -4.15083095e-02f, -5.27106673e-02f, -4.37590554e-02f, -3.48113943e-03f, -6.14561290e-02f, -6.79310262e-02f, -6.41259924e-02f, -6.74993098e-02f, -6.00722134e-02f,
  -5.25360703e-02f, 4.34234254e-02f, -4.79997061e-02f, -2.09272683e-01f, 8.04606453e-03f, -1.28521144e-01f, -6.33518919e-02f, 4.71746363e-02f, -3.88897024e-02f, -7.53998058e-03f,
  -3.96873094e-02f, 5.72137162e-02f, 6.00522645e-02f, 5.54302782e-02f, 1.32195586e-02f, 9.50712413e-02f, 5.24229966e-02f, 5.43659963e-02f, -5.88046713e-03f, 8.26933607e-02f,
  8.88456106e-02f, 5.26827164e-02f, 5.87664917e-02f, 1.49259344e-02f, 1.21024482e-01f, 4.60840799e-02f, 1.04089439e-01f, 2.52891947e-02f, 6.77127540e-02f, 7.48107880e-02f,
  9.80926007e-02f, 7.16326237e-02f, 1.36927113e-01f, 6.72859773e-02f, 7.13132471e-02f, 7.78860897e-02f, 1.27206266e-01f, 7.06671700e-02f, 6.84051588e-02f, -7.96531048e-03f,
  -1.30453438e-01f, -2.88531840e-01f, -2.36444753e-02f, -2.81275082e-02f, -7.08943158e-02f, -1.23751096e-01f, -3.29316035e-02f, -1.01402871e-01f, -2.29978245e-02f, -1.29118472e-01f,
  -5.24112172e-02f, -1.07741460e-01f, -1.42454624e-01f, -1.05492845e-01f, -1.19351029e-01f, -8.85165930e-02f, -1.59935951e-01f, -1.60761863e-01f, -1.06729694e-01f, -4.72425856e-02f,
  -2.43177056e-01f, -2.52815723e-01f, -1.98698163e-01f, -1.93569168e-01f, -1.48124114e-01f, -1.46615893e-01f, -2.08301887e-01f, -1.99048698e-01f, -2.32801616e-01f, -4.58574086e-01f,
  4.22537560e-03f, 2.11718395e-01f, 1.57846939e-02f, 5.36619313e-02f, -1.14769861e-01f, -5.58281951e-02f, -3.31539586e-02f, 1.72317579e-01f, 1.03105947e-01f, -6.03210367e-02f,
  1.37635797e-01f, 6.41283244e-02f, 1.17351234e-01f, 4.53367345e-02f, -9.87345353e-03f, -5.61273284e-02f, -1.74096152e-01f, -1.15316221e-02f, -2.98562087e-02f, 2.37042885e-02f,
  1.41804768e-02f, -1.04055196e-01f, -6.11370504e-02f, -2.83471979e-02f, -7.82556981e-02f, -1.97745681e-01f, -1.90808401e-01f, -5.04474901e-02f, -1.40387967e-01f, -2.08009169e-01f,
  1.74004380e-02f, 1.52777165e-01f, 1.00900747e-01f, 3.94271016e-02f, 2.05758736e-01f, 9.22773629e-02f, 2.02335060e-01f, 1.00039259e-01f, 1.04728945e-01f, 1.71697885e-01f,
  6.35475218e-02f, 8.00509453e-02f, 7.84064978e-02f, 1.14973687e-01f, -2.01541763e-02f, 8.51600245e-03f, 1.49907798e-01f, 7.65643418e-02f, 1.06128611e-01f, 1.76702961e-01f,
  1.09925978e-01f, 1.07452851e-02f, 1.43818885e-01f, 1.65315121e-01f, 1.62634328e-01f, 6.81130961e-02f, 8.94136578e-02f, 5.70525192e-02f, -4.43920568e-02f, -2.34126914e-02f,
  -1.41596138e-01f, -4.11042534e-02f, -1.83961436e-01f, -1.55951262e-01f, -6.81359246e-02f, -4.90219109e-02f, -1.79961741e-01f, -1.56200126e-01f, -9.92723107e-02f, -1.18231319e-01f,
  -5.53201027e-02f, -9.84608531e-02f, -3.72354463e-02f, -1.69013947e-01f, -1.76428080e-01f, -1.09097585e-01f, -1.12551533e-01f, -8.63422826e-02f, -1.35710195e-01f, -1.47146165e-01f,
  -1.42009616e-01f, -6.65712506e-02f, -1.46488100e-01f, -1.11154705e-01f, -1.39872923e-01f, -1.00690179e-01f, -1.13670707e-01f, -2.68430728e-02f, -2.57152691e-02f, -1.18343383e-01f,
  1.53088287e-01f, 1.90325141e-01f, 4.02198657e-02f, 8.66525099e-02f, 2.28495467e-02f, 2.11125150e-01f, 1.01059519e-01f, 1.26474589e-01f, 1.71559736e-01f, 1.42983943e-01f,
  9.71399322e-02f, 1.76766232e-01f, 1.65058151e-01f, 1.03391185e-01f, 8.61108080e-02f, 5.87800033e-02f, 5.11369593e-02f, 8.30378477e-03f, 6.35465607e-02f, 1.21879779e-01f,
  1.69214666e-01f, 6.29747957e-02f, 8.19920972e-02f, 6.24560304e-02f, 1.07968636e-01f, 9.11753774e-02f, 1.59784049e-01f, 3.69012952e-02f, 4.61945273e-02f, 9.27692056e-02f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -8.82941246e-01f, -2.05856234e-01f, -1.04723848e-01f, -1.71184182e-01f, -4.62518185e-02f, 3.44973169e-02f, 9.65915173e-02f, -1.00971740e-02f, 1.44307045e-02f, 1.28026024e-01f,
  1.43427297e-01f, 2.36475185e-01f, 3.60150784e-01f, 3.64118457e-01f, 2.87054211e-01f, 2.72800952e-01f, 2.46030644e-01f, 8.59665349e-02f, 1.08089037e-01f, -1.01197436e-02f,
  1.22258432e-01f, -1.19628355e-01f, -2.25951269e-01f, -8.36487785e-02f, 1.74410362e-02f, 1.82168201e-01f, -1.85468849e-02f, -7.13973586e-03f, 3.72345187e-02f, 1.14320852e-01f,
  4.07142282e-01f, -3.29654545e-01f, 1.47626877e-01f, -7.95900298e-04f, -6.61264285e-02f, -2.04229549e-01f, -7.08926097e-02f, -1.52919292e-01f, -1.07920587e-01f, -5.08310087e-02f,
  -1.04124635e-01f, -1.64526671e-01f, -1.37188762e-01f, -2.06371397e-01f, -1.85259506e-01f, -6.21024370e-02f, -9.86026824e-02f, -1.97125617e-02f, 1.40842393e-01f, 1.09247617e-01f,
  5.49830869e-03f, -1.31352305e-01f, -1.49093466e-02f, 1.58373594e-01f, 4.81194817e-02f, 1.38428241e-01f, -1.05705842e-01f, -4.45848778e-02f, -4.29899357e-02f, -1.88524723e-01f,
  4.32257168e-02f, 1.14569413e-02f, -9.56807882e-02f, -5.64082563e-02f, 1.38616234e-01f, 3.41136456e-02f, 2.51129712e-03f, 5.74937277e-02f, 4.23387513e-02f, -1.04105055e-01f,
  5.08530363e-02f, 1.28718972e-01f, 9.91777168e-04f, 2.93162223e-02f, 1.17039144e-01f, -1.57839537e-01f, -1.75421700e-01f, 2.45932993e-02f, 1.63475983e-02f, -2.92357821e-02f,
  8.35017487e-03f, -5.00959605e-02f, -2.06882372e-01f, 1.02738442e-04f, -9.21375677e-02f, 8.02323048e-04f, -1.56906381e-01f, -1.04087152e-01f, -5.01189455e-02f, -9.62194204e-02f,
  2.97404826e-01f, -2.53283326e-02f, 1.41194925e-01f, 6.80172443e-02f, -1.23902209e-01f, 7.12682784e-04f, 7.70622864e-02f, -1.14398240e-03f, 3.61274220e-02f, 1.31581634e-01f,
  -7.15368846e-03f, -6.40228912e-02f, -5.24131134e-02f, -9.33365598e-02f, -1.24331594e-01f, -3.21889333e-02f, -2.55774660e-03f, 1.38925957e-02f, 1.29016519e-01f, -5.65172080e-03f,
  -4.97833453e-02f, 3.94719094e-02f, 8.32869112e-02f, 1.27201736e-01f, 6.48657307e-02f, 1.54237270e-01f, 1.95513703e-02f, 4.62795720e-02f, 4.72722538e-02f, -2.38186307e-03f,
  -5.34925938e-01f, -1.02584518e-01f, 4.38147008e-01f, -6.01188064e-01f, 7.86392316e-02f, 3.46657336e-01f, 8.28578919e-02f, -1.97306976e-01f, -3.43796343e-01f, -1.05159037e-01f,
  3.33506875e-02f, -3.82090271e-01f, -2.69980907e-01f, -2.80416906e-01f, 5.85020594e-02f, 1.34845257e-01f, 1.28676966e-01f, 2.08719924e-01f, 5.55798858e-02f, -2.09480509e-01f,
  -1.92156926e-01f, -1.37561724e-01f, 1.24166235e-02f, -7.40060955e-02f, -4.74204957e-01f, -3.45319390e-01f, 6.60174936e-02f, -8.38730037e-02f, 1.90549240e-01f, -2.58861125e-01f,
  -2.49391735e-01f, -1.04141176e-01f, 1.11797437e-01f, -4.40803580e-02f, 3.13661769e-02f, -9.06095877e-02f, -4.32770066e-02f, -7.08564669e-02f, 2.54256595e-02f, 6.54329136e-02f,
  -2.43939888e-02f, 7.04072863e-02f, -7.68534765e-02f, -3.21566574e-02f, -5.21061942e-02f, -9.98957232e-02f, 1.39004350e-01f, 1.93114370e-01f, 1.65947422e-01f, 3.57630011e-03f,
  2.96810623e-02f, 1.41110569e-01f, 1.90362260e-01f, 8.57235715e-02f, 1.53170481e-01f, 1.89352393e-01f, 6.50165454e-02f, 2.81680617e-02f, 2.37730503e-01f, -1.39392555e-01f,
  1.28737882e-01f, -9.97886341e-03f, -8.45902562e-02f, 6.69092238e-02f, 1.47890076e-01f, 1.90186724e-01f, -1.49911255e-01f, -1.47892609e-01f, -3.62262502e-02f, 2.93613654e-02f,
  4.45825281e-03f, 7.24044666e-02f, 1.50063515e-01f, -2.27975566e-02f, 4.44433503e-02f, -5.44920042e-02f, 8.51904154e-02f, 1.85395759e-02f, -4.90448661e-02f, -9.81515180e-03f,
  1.28014907e-02f, 7.77581707e-02f, -1.19705070e-02f, 2.38558762e-02f, 1.88961953e-01f, -3.30643654e-02f, 1.15766965e-01f, 3.88407260e-02f, 1.30850393e-02f, 1.03070378e-01f,
  -5.09280324e-01f, 2.80227989e-01f, -3.18552166e-01f, -7.69151375e-02f, -6.11983985e-02f, 1.19106723e-02f, -3.25479895e-01f, 7.26230145e-02f, -2.89493520e-02f, -7.73108453e-02f,
  -8.58273953e-02f, -1.60331473e-01f, -7.69159049e-02f, -7.65278265e-02f, -1.00715190e-01f, 4.65648621e-02f, 4.33931537e-02f, -4.69204746e-02f, 1.10650949e-01f, -6.35050908e-02f,
  3.74343731e-02f, 2.22962145e-02f, -6.35473579e-02f, -6.20847121e-02f, 5.41690849e-02f, 1.25347883e-01f, 6.17953166e-02f, -8.39812607e-02f, 1.45816058e-01f, -2.98362613e-01f,
  -8.22747529e-01f, -6.49355352e-01f, -4.48408537e-02f, -1.33256271e-01f, 3.89575548e-02f, -1.81954846e-01f, -5.31809092e-01f, 8.02407563e-02f, 1.58999845e-01f, -3.52566183e-01f,
  -1.99147075e-01f, 1.77140549e-01f, -7.10552633e-02f, 4.69515771e-02f, -1.98353335e-01f, -4.96394426e-01f, -2.48635888e-01f, -5.33447117e-02f, 5.49179614e-01f, 2.53401428e-01f,
  4.11732309e-02f, 1.77808195e-01f, 1.81346491e-01f, 1.54569954e-01f, -3.67632389e-01f, -6.59105107e-02f, -2.27010772e-01f, -2.81585246e-01f, -2.86998510e-01f, -7.62942791e-01f,
  -4.77167398e-01f, -2.96737641e-01f, 2.70909011e-01f, 2.08901279e-02f, 2.14255862e-02f, -7.15581626e-02f, -2.03793943e-02f, 1.82022646e-01f, -1.08999133e-01f, -1.10281549e-01f,
  -8.70654732e-02f, 7.05545023e-02f, 8.00290555e-02f, 5.07718734e-02f, -7.26341158e-02f, -6.45502508e-02f, 1.30728871e-01f, 5.64351678e-02f, -3.20352502e-02f, -4.09017093e-02f,
  -2.70735919e-01f, -1.78914681e-01f, -2.18198061e-01f, -1.32833183e-01f, -6.13102913e-02f, 1.13911837e-01f, 2.44697407e-02f, -1.50921047e-01f, -3.32317203e-01f, -8.56158614e-01f,
  -7.44448751e-02f, 2.29520798e-02f, 1.38695523e-01f, 9.14516374e-02f, -5.37032075e-02f, -8.26621950e-02f, -2.83845235e-02f, -4.51874621e-02f, 1.21699579e-01f, -1.09160542e-02f,
  8.33475366e-02f, 4.06454317e-02f, 7.18010068e-02f, -1.16483197e-01f, 2.17240807e-02f, 1.57017894e-02f, -2.25371972e-01f, -1.11852363e-01f, 4.58922125e-02f, 4.04826552e-03f,
  6.53103739e-02f, 4.04412812e-03f, -8.00468996e-02f, 1.80017967e-02f, -8.37482810e-02f, -6.90273419e-02f, -1.26027286e-01f, 5.93273900e-02f, -1.08497672e-01f, -1.20555341e-01f,
  -7.40476027e-02f, 2.27768108e-01f, -3.40849549e-01f, -1.44846037e-01f, 9.23373550e-02f, -1.01395294e-01f, -2.60282397e-01f, 1.46527603e-01f, -3.93953137e-02f, 6.19246587e-02f,
  -8.00194070e-02f, -6.03194870e-02f, -2.14375108e-01f, 5.75014250e-03f, 5.43190315e-02f, -1.59380340e-03f, -8.80595818e-02f, -6.78520203e-02f, -1.45139188e-01f, 6.57268986e-02f,
  -1.72862083e-01f, -2.43195429e-01f, -4.17862177e-01f, -3.89115542e-01f, -7.18976781e-02f, -1.83061197e-01f, -2.30599582e-01f, -1.61131337e-01f, -2.59533435e-01f, -6.51085556e-01f,
  -2.81340957e-01f, -1.61686346e-01f, -5.95959648e-02f, 2.18643621e-01f, 4.27331239e-01f, 3.16589594e-01f, 3.72701466e-01f, 3.67270678e-01f, 3.30654651e-01f, 2.98215598e-01f,
  2.60604322e-01f, 3.26452255e-01f, 3.65138590e-01f, 2.64008611e-01f, 1.49038807e-01f, 3.16907138e-01f, 2.72920042e-01f, 6.35707080e-02f, 1.15675621e-01f, 3.10873538e-01f,
  1.98981196e-01f, 1.66258007e-01f, -5.63502721e-02f, 4.32064198e-02f, 9.41659287e-02f, 1.33647531e-01f, 1.44358590e-01f, 2.56999861e-02f, 1.24489099e-01f, 7.10299835e-02f,
  -8.77224877e-02f, -1.21112071e-01f, 1.07343309e-01f, 3.31651815e-03f, -1.22385003e-01f, -2.15412945e-01f, -6.05129786e-02f, -5.77764213e-02f, -1.19922116e-01f, -9.05991346e-02f,
  -1.09506706e-02f, -1.05702449e-02f, 2.01229788e-02f, -1.08522326e-01f, -1.18955329e-01f, -1.29416704e-01f, 8.08310881e-03f, 1.62720278e-01f, 5.88053465e-02f, -3.18640321e-02f,
  5.83089180e-02f, 8.13008994e-02f, 7.28110671e-02f, 8.12772065e-02f, -2.57879272e-02f, 1.37547553e-01f, -9.00088400e-02f, -1.05698165e-02f, 7.99990166e-03f, -8.79461318e-02f,
  2.86788911e-01f, 1.54386833e-01f, 2.75471304e-02f, 1.40452519e-01f, 2.93579120e-02f, 6.32988736e-02f, -4.40159105e-02f, 7.24672386e-03f, 1.42998621e-01f, -6.78389296e-02f,
  5.94930239e-02f, 9.95705500e-02f, 9.44969207e-02f, -3.70704122e-02f, 5.10080978e-02f, -6.17984273e-02f, -1.85989171e-01f, -7.33027384e-02f, -1.23348869e-01f, 7.23847700e-03f,
  -7.15225786e-02f, 5.20772226e-02f, -1.20711863e-01f, -8.38474929e-02f, 4.40252498e-02f, 8.16857517e-02f, -2.30189599e-02f, 5.92512041e-02f, 2.82666925e-02f, -7.90491179e-02f,
  1.50355980e-01f, 2.28458628e-01f, 7.34873936e-02f, -3.45809199e-02f, -1.22374646e-01f, -2.07599074e-01f, -1.10741228e-01f, -2.17361033e-01f, -1.70794353e-01f, -1.35808975e-01f,
  -2.70238630e-02f, -2.59124398e-01f, -1.54175222e-01f, -2.00972743e-02f, -7.02743456e-02f, -2.41185259e-02f, -5.39852269e-02f, 1.37776956e-01f, 3.73016484e-02f, 1.30663700e-02f,
  -4.05301014e-03f, 1.05565608e-01f, -1.16994455e-02f, 4.63374667e-02f, 8.00011083e-02f, 1.19190969e-01f, -1.73189119e-01f, -7.62425642e-03f, -3.45983692e-02f, -8.24679062e-02f,
  -2.88737863e-01f, -4.91661370e-01f, -2.83390760e-01f, -7.38456666e-01f, -4.65237767e-01f, -6.59202635e-02f, -3.05191517e-01f, -1.49298236e-01f, -3.29280227e-01f, -3.66322637e-01f,
  -7.80950189e-02f, 4.95862871e-01f, 2.89064020e-01f, 4.48448688e-01f, 6.07493818e-01f, -5.21007895e-01f, -4.95960206e-01f, 3.24708641e-01f, 8.37280273e-01f, 3.44898582e-01f,
  6.25974387e-02f, -2.64829826e-02f, 1.80410922e-01f, 8.51580277e-02f, -5.98817825e-01f, 2.12210640e-02f, -4.73085344e-01f, -3.63366574e-01f, -1.20818019e-01f, -8.31159353e-01f,
  -1.44495293e-02f, -3.20390135e-01f, 9.00330171e-02f, 2.62226403e-01f, -1.81109071e-01f, 5.64028844e-02f, -2.28353329e-02f, -1.18416928e-01f, -2.07809974e-02f, -1.93781748e-01f,
  -7.86624700e-02f, 6.73443675e-02f, 1.11430280e-01f, 1.15376756e-01f, -1.21676043e-01f, 3.73039991e-02f, -1.96065858e-01f, -1.00493379e-01f, -1.57193258e-01f, -1.22279547e-01f,
  -3.07632666e-02f, -6.60346448e-02f, -2.98464391e-02f, -9.52253211e-03f, 3.65577675e-02f, 1.55511111e-01f, -1.19719347e-02f, -8.54427218e-02f, 1.94866374e-01f, -4.54831481e-01f,
  -2.72546280e-02f, -7.10086748e-02f, -5.23511805e-02f, 4.68767881e-02f, 3.90162095e-02f, -2.19124509e-03f, -3.24821752e-03f, 4.70023341e-02f, 4.00650799e-02f, -4.05939482e-02f,
  5.19399568e-02f, -6.08762540e-02f, 1.04138613e-01f, -1.05551131e-01f, -9.47825983e-02f, -5.37312105e-02f, -2.79325303e-02f, -6.45041019e-02f, 1.47029879e-02f, -9.97485891e-02f,
  7.27197528e-02f, -1.41155109e-01f, -4.81760837e-02f, 7.43496567e-02f, 1.26370937e-02f, 5.62855899e-02f, -3.37326564e-02f, 2.17319846e-01f, 1.18939847e-01f, -2.37907674e-02f,
  1.46112248e-01f, 2.18150884e-01f, -2.01703459e-01f, 9.87046883e-02f, -1.20432593e-01f, 1.56229939e-02f, -8.24268814e-03f, 1.28535014e-02f, 3.94777842e-02f, 9.15316045e-02f,
  3.67715806e-02f, 9.00788680e-02f, -2.36491542e-02f, -4.04726528e-02f, 1.24470949e-01f, 3.04385517e-02f, -3.08332574e-02f, 2.08535343e-02f, 7.49331713e-03f, -1.39204219e-01f,
  -9.01606604e-02f, 1.60653871e-02f, 1.58769146e-01f, 2.86561530e-02f, -7.24834576e-02f, 2.94727355e-01f, 5.73312491e-02f, -4.88295816e-02f, 2.52589524e-01f, -2.76463628e-01f,
  5.07477343e-01f, -3.69827539e-01f, -5.70421755e-01f, 4.06890392e-01f, 4.11579251e-01f, 3.25336039e-01f, -2.30996348e-02f, 2.35568523e-01f, 3.21093202e-01f, -1.08117297e-01f,
  -2.33584717e-01f, -1.43869385e-01f, -3.89249921e-01f, -3.54814321e-01f, -3.80146086e-01f, -4.00227964e-01f, -2.60290205e-01f, -1.86451733e-01f, 1.62084773e-01f, 5.06514966e-01f,
  3.86095375e-01f, 3.63014132e-01f, 1.75098777e-01f, 1.49905775e-02f, 1.39905080e-01f, 2.06618473e-01f, -2.99569845e-01f, -3.51941027e-03f, -1.92470923e-01f, -2.17818648e-01f,
  -3.64652008e-01f, -8.29466358e-02f, 1.83985695e-01f, -5.46261407e-02f, 3.93028595e-02f, 1.96064953e-02f, 4.22095880e-02f, 1.02990746e-01f, 2.22214237e-01f, 6.92477450e-02f,
  2.47258749e-02f, 7.60027673e-03f, 1.63296591e-02f, 9.37592611e-02f, 2.01164424e-01f, -2.89712250e-02f, -3.22253145e-02f, 4.58790269e-03f, -4.71660346e-02f, -1.62682280e-01f,
  -7.15993643e-02f, 5.90543747e-02f, -6.33854195e-02f, -1.31215841e-01f, -1.32574096e-01f, -2.31387336e-02f, -1.06410921e-01f, -9.85593423e-02f, -1.32079303e-01f, -3.58927622e-02f,
  -1.74697697e-01f, -2.76857037e-02f, -8.23278874e-02f, 3.74023877e-02f, 6.89723417e-02f, 1.03718534e-01f, 8.69525596e-03f, 3.16496976e-02f, -2.27105878e-02f, 1.18620526e-02f,
  5.34857325e-02f, -1.07615434e-01f, -4.46745977e-02f, -2.26342008e-02f, -9.80247110e-02f, -4.71030623e-02f, 7.10152015e-02f, -1.32223979e-01f, -1.22326851e-01f, 7.33954832e-02f,
  -4.89514321e-02f, 8.82194564e-03f, 4.75453772e-02f, 4.61647240e-03f, -1.84397958e-02f, -1.04984671e-01f, -9.88837034e-02f, -8.61839429e-02f, 7.70973042e-02f, 9.02917888e-03f,
  1.00180477e-01f, -3.22981328e-01f, -8.15467816e-03f, -2.55928189e-01f, -6.54734224e-02f, -1.64461717e-01f, -2.95868367e-01f, -9.97858047e-02f, 5.76615632e-02f, 3.10622193e-02f,
  4.34516836e-03f, -8.31969529e-02f, -9.57921967e-02f, 1.11770295e-01f, 3.37671340e-01f, 4.98229042e-02f, -9.93446931e-02f, 1.07106613e-02f, 4.12993468e-02f, 1.71079323e-01f,
  -2.77777612e-02f, 1.05439186e-01f, 1.60045132e-01f, 1.88350081e-02f, 1.32885799e-01f, 4.28525470e-02f, 1.48293646e-02f, 7.96339139e-02f, -6.75529540e-02f, 2.93862015e-01f,
  -6.76756501e-01f, -5.15922666e-01f, 3.08795482e-01f, -5.32132387e-01f, -7.73018552e-03f, 2.06138328e-01f, 2.84407645e-01f, -1.16653427e-01f, -3.82013977e-01f, -1.46160141e-01f,
  -2.20478475e-01f, -1.98092207e-01f, -2.49668777e-01f, -7.28380680e-02f, -1.49859652e-01f, 2.01651126e-01f, 1.28131911e-01f, 1.07362621e-01f, 1.90042526e-01f, -2.83793882e-02f,
  -2.23660320e-01f, -1.96305439e-01f, -4.51826721e-01f, -3.54796320e-01f, -2.44115323e-01f, -1.36279136e-01f, -1.47311941e-01f, -1.20506026e-01f, -1.62526488e-01f, -3.34878474e-01f,
  5.24835706e-01f, -3.87329280e-01f, 4.67233825e-03f, -2.85939813e-01f, -1.36398971e-01f, -9.31776688e-02f, 1.67641826e-02f, -9.54783484e-02f, -7.13024363e-02f, -4.41851355e-02f,
  -1.21108212e-01f, -1.41049474e-01f, -5.60729429e-02f, 2.48213187e-02f, 3.67542058e-02f, -3.67089547e-02f, -9.62299556e-02f, -1.70432672e-01f, -2.18423188e-01f, -2.97970939e-02f,
  -7.06902072e-02f, -2.33809110e-02f, 1.06613658e-01f, -7.57717043e-02f, -7.94898253e-03f, -1.25058200e-02f, -1.72852930e-02f, -5.80264442e-03f, -6.12216964e-02f, 5.55362068e-02f,
  1.94606692e-01f, 6.73048198e-02f, -9.59484428e-02f, 1.17114969e-01f, -1.40647683e-02f, 8.74757171e-02f, -1.22349970e-02f, -5.20964675e-02f, 3.21197463e-03f, -7.36938715e-02f,
  -6.94985390e-02f, 2.04329416e-02f, -4.41039726e-02f, -1.09212689e-01f, -1.12450339e-01f, -8.92820954e-02f, -4.04313914e-02f, -6.35611638e-02f, -4.93042693e-02f, -1.45125881e-01f,
  -1.65764362e-01f, -7.41568431e-02f, -1.43988931e-03f, -6.27782643e-02f, -5.96958660e-02f, -5.32093719e-02f, -1.05940558e-01f, -5.41913062e-02f, 7.50824958e-02f, -1.40262321e-01f,
  1.43300518e-01f, -5.58134727e-02f, 1.49808243e-01f, -9.97288004e-02f, 2.27757916e-02f, -1.56254306e-01f, -1.14799887e-01f, 3.75860706e-02f, -9.48173851e-02f, 3.84459309e-02f,
  -8.52892622e-02f, 1.42151147e-01f, -1.46687673e-02f, -2.87682819e-03f, 1.50700659e-01f, 1.26632020e-01f, -1.25515476e-01f, -2.38547120e-02f, 2.65479926e-03f, 9.14835706e-02f,
  -4.94876057e-02f, 2.01564178e-01f, 2.64809996e-01f, 1.92564636e-01f, 1.62639067e-01f, 3.06832224e-01f, 2.60201991e-01f, 2.45099500e-01f, 1.62692383e-01f, 2.56338716e-01f,
  8.34285140e-01f, 2.46224105e-01f, 7.48215735e-01f, 2.78905660e-01f, 7.21160695e-02f, 3.04009795e-01f, 3.49926084e-01f, 2.48170033e-01f, -9.68635231e-02f, 8.39563366e-03f,
  -6.89285994e-02f, -2.61821449e-01f, -3.94616365e-01f, -2.20951825e-01f, 2.80639250e-02f, 1.79416656e-01f, 8.16164911e-02f, 3.48615408e-01f, 2.26931110e-01f, 1.68083653e-01f,
  -1.25242040e-01f, 1.80805519e-01f, 3.42137128e-01f, 4.60773483e-02f, 2.52326224e-02f, -1.54498369e-01f, 1.35013804e-01f, 6.29586503e-02f, 4.04950343e-02f, 1.66717336e-01f,
  3.48611385e-01f, 3.90543014e-01f, -3.69398206e-01f, -2.74170130e-01f, -6.54997453e-02f, -4.13820855e-02f, 1.03666540e-02f, 2.32863482e-02f, -1.14116348e-01f, 2.34313179e-02f,
  3.49074695e-03f, -1.07975807e-02f, 9.79755074e-02f, -3.79804941e-03f, 1.71121031e-01f, -7.71977752e-02f, 1.18806539e-02f, 7.48646185e-02f, -1.16458908e-02f, -1.99644510e-02f,
  -2.43218645e-01f, 1.29278511e-01f, 2.35626563e-01f, 3.75152146e-03f, 1.51513770e-01f, -7.43920952e-02f, 1.27361920e-02f, 1.20797545e-01f, 4.98975478e-02f, 1.71137929e-01f,
  3.09449881e-02f, 1.28506809e-01f, 1.02207951e-01f, 1.41918927e-01f, 1.05619922e-01f, -3.91889438e-02f, 2.48645805e-02f, 5.38653985e-04f, 4.86614518e-02f, 9.64682698e-02f,
  -3.47908810e-02f, 1.08760491e-01f, 3.59124094e-02f, 6.33258075e-02f, -1.92037717e-01f, 3.32495272e-02f, -3.16532664e-02f, -2.18131915e-02f, -3.88945416e-02f, -2.00935472e-02f,
  9.15980041e-02f, -1.43795535e-02f, -2.91127190e-02f, 4.96315733e-02f, -1.50589243e-01f, 1.85909290e-02f, 1.56003668e-03f, -1.47978887e-02f, 4.59057428e-02f, -6.22772425e-02f,
  -3.40089768e-01f, -1.98515266e-01f, -2.07641616e-01f, -1.02088504e-01f, -2.67774821e-03f, -8.23745281e-02f, -1.32250026e-01f, -9.07718539e-02f, -9.34326500e-02f, -1.26136929e-01f,
  -7.72607252e-02f, 9.23341662e-02f, -4.86549437e-02f, -7.17003942e-02f, 2.61028558e-02f, -1.51920125e-01f, -1.44378275e-01f, -9.79848802e-02f, -1.61500335e-01f, -3.15420963e-02f,
  -2.03761905e-01f, -3.46998237e-02f, 2.58478336e-02f, -1.64076954e-01f, -1.80955753e-01f, -1.43220425e-01f, -1.31750375e-01f, 1.04061114e-02f, 2.19206065e-02f, -1.93734504e-02f,
  7.81597674e-01f, -4.92207408e-01f, 2.93760952e-02f, 3.30683202e-01f, 1.60427183e-01f, 1.56249151e-01f, -1.19911715e-01f, 1.30996913e-01f, 2.79087812e-01f, -3.02228751e-03f,
  -5.15626073e-02f, 2.53599048e-01f, 1.01229511e-01f, 1.28311545e-01f, 5.63119538e-02f, -1.78676233e-01f, 8.44432786e-03f, 2.70249188e-01f, 3.29961717e-01f, -6.40121102e-02f,
  -2.59012759e-01f, -1.73792526e-01f, 9.22386944e-02f, -1.51130125e-01f, -3.25430721e-01f, 7.08276033e-02f, -1.48827448e-01f, -1.71573207e-01f, -1.96403295e-01f, -4.24374878e-01f,
  -1.65251434e-01f, 4.24985886e-02f, 1.70736164e-02f, -5.08955978e-02f, -2.20460191e-01f, 1.91495288e-02f, 3.81583944e-02f, -1.40301093e-01f, -4.64924574e-02f, -1.08811773e-01f,
  -1.09703742e-01f, 1.31273679e-02f, 1.39872385e-02f, -5.38181961e-02f, -1.98238313e-01f, -7.16557279e-02f, -1.03337303e-01f, -5.04565286e-03f, -1.27466828e-01f, -1.73365638e-01f,
  -1.68128058e-01f, -1.90456472e-02f, 1.50134087e-01f, 4.47285138e-02f, 8.50901082e-02f, 9.85680744e-02f, -1.60211384e-01f, -9.46727321e-02f, -3.20163160e-03f, -6.23108819e-02f,
  -1.23832777e-01f, 5.78827076e-02f, 7.12784752e-02f, 6.38864860e-02f, 1.96636319e-01f, 6.39070794e-02f, 6.59847260e-03f, -6.45110682e-02f, 1.41098812e-01f, -9.02645662e-02f,
  -1.16044112e-01f, 1.12621740e-01f, 5.01677245e-02f, -1.38990562e-02f, 4.51724371e-03f, 6.16162829e-03f, 5.38874194e-02f, -1.69859841e-01f, -8.56772531e-04f, 3.52339409e-02f,
  6.94207028e-02f, -3.01304888e-02f, -9.36317518e-02f, -1.64571255e-01f, -1.42166197e-01f, -5.09206504e-02f, -4.59360033e-02f, -3.53708304e-02f, -4.87547331e-02f, 2.08897833e-02f,
  -6.96850270e-02f, 2.54195899e-01f, 6.75149187e-02f, -3.98207530e-02f, 1.73998866e-02f, -1.67030379e-01f, 7.18991011e-02f, -1.18581258e-01f, -1.88607723e-01f, 2.51999567e-03f,
  -3.21012475e-02f, 2.92296410e-02f, -2.18439774e-04f, -1.21320307e-01f, 8.03762004e-02f, 9.79167446e-02f, -6.56335279e-02f, 4.46159542e-02f, -1.00886919e-01f, -1.90773502e-01f,
  -3.08614280e-02f, 2.45222971e-01f, 2.57977694e-01f, 2.71878213e-01f, 1.51698053e-01f, 3.84040445e-01f, 3.51483398e-03f, 1.32347032e-01f, 2.37031877e-01f, 9.02909413e-02f,
  7.27519244e-02f, -2.90952086e-01f, 7.56230876e-02f, 1.81485951e-01f, 2.50130504e-01f, 3.11966598e-01f, 4.85941589e-01f, 4.25645448e-02f, -8.38597864e-02f, 7.32281283e-02f,
  -5.32923579e-01f, -7.12642372e-01f, -5.33729732e-01f, -3.91888857e-01f, -9.09356177e-02f, 3.71810347e-01f, 3.13083559e-01f, 2.09359378e-02f, 1.61972284e-01f, 1.95974141e-01f,
  5.08076847e-02f, 4.35991496e-01f, 2.16720358e-01f, -1.35692507e-01f, -1.10154212e-01f, -1.17192902e-02f, 4.69395109e-02f, -3.48780081e-02f, -1.57458365e-01f, -1.82531103e-01f,
  -2.71761362e-02f, -5.32009840e-01f, 3.49415839e-02f, -3.71000558e-01f, -4.82787900e-02f, 4.12326641e-02f, 1.00452505e-01f, 9.31767374e-02f, -1.90858766e-01f, 1.44528210e-01f,
  -1.34300083e-01f, -2.15231225e-01f, -2.17924148e-01f, -8.87094364e-02f, 1.50550127e-01f, -4.87823449e-02f, 1.00459154e-04f, -2.10953385e-01f, -2.29542166e-01f, -2.51212448e-01f,
  -2.64021397e-01f, -1.12142786e-01f, -1.32470980e-01f, -5.91263212e-02f, -2.28191271e-01f, -2.32336581e-01f, -1.61921561e-01f, -3.43425959e-01f, -2.08195955e-01f, 1.04436435e-01f,
  5.20285815e-02f, 1.65218934e-02f, 9.50534770e-04f, 2.90251262e-02f, 1.79608527e-03f, -1.22712748e-02f, -3.93099673e-02f, 8.82189535e-03f, 4.92252670e-02f, 1.44109204e-01f,
  -3.30526903e-02f, -9.35216062e-03f, -2.83650085e-02f, 5.80352470e-02f, -5.61163910e-02f, -9.07714665e-02f, 2.65360177e-02f, -4.82012443e-02f, -9.98107269e-02f, 5.76379299e-02f,
  -3.32958326e-02f, -1.09136708e-01f, 1.63109303e-02f, -5.40670007e-02f, -6.29617944e-02f, -1.05390541e-01f, 4.82485183e-02f, -7.56688714e-02f, -2.60505341e-02f, 4.41154577e-02f,
  2.14417979e-01f, -3.82284373e-01f, 2.12246299e-01f, -5.59378751e-02f, 5.00568608e-03f, -1.46390572e-01f, -1.09232828e-01f, -1.01324998e-01f, -8.35972875e-02f, -5.31436689e-02f,
  -2.27533475e-01f, -9.92255211e-02f, -1.73353717e-01f, -1.13858841e-01f, 1.40955716e-01f, 1.33716747e-01f, 1.17866611e-02f, 2.95571331e-02f, 3.18075046e-02f, 1.49278641e-01f,
  1.74683109e-01f, 2.25790054e-01f, 3.69184822e-01f, 1.23147428e-01f, -3.61121371e-02f, 1.23608321e-01f, 2.31060013e-01f, 1.82932466e-01f, 2.49470379e-02f, 6.84513986e-01f,
  -8.07073772e-01f, -4.74991441e-01f, -2.60115683e-01f, -4.77688193e-01f, -3.68568629e-01f, -1.68319777e-01f, -6.03363812e-01f, -5.00119384e-03f, 9.39421877e-02f, -4.25167322e-01f,
  -1.50232494e-01f, 1.08375251e-01f, -1.24276713e-01f, -1.29388556e-01f, -4.06838387e-01f, -6.23142362e-01f, -4.26929712e-01f, -5.00056326e-01f, -3.69226128e-01f, -2.60966897e-01f,
  -5.45946658e-01f, -6.49757266e-01f, -4.82142836e-01f, -1.28760427e-01f, -1.41737178e-01f, -5.47363199e-02f, -1.26246899e-01f, -2.61969149e-01f, -6.18973821e-02f, -2.83454627e-01f,
  -4.15989757e-01f, 1.68296561e-01f, 1.92739248e-01f, -2.88703889e-02f, -7.30789155e-02f, 8.35360363e-02f, -3.20719332e-02f, 6.27179295e-02f, 1.72556236e-01f, 4.27013673e-02f,
  4.69450792e-03f, 9.79731604e-03f, -1.24121360e-01f, 5.55984862e-02f, -6.22594170e-02f, -2.19592173e-02f, 6.18484020e-02f, -8.55693072e-02f, 1.59444943e-01f, 9.21343043e-02f,
  -2.08997764e-02f, -6.36797994e-02f, 2.60654837e-02f, 1.89733624e-01f, 4.16147679e-01f, 1.85136090e-03f, 1.74300268e-01f, 2.77765572e-01f, 3.42940271e-01f, 1.01193205e-01f,
  3.49067822e-02f, 1.11279171e-02f, -3.88264991e-02f, 7.48025477e-02f, 9.89637058e-03f, 1.02729183e-02f, -4.39230353e-02f, -4.73653674e-02f, 4.22579562e-03f, -1.99476153e-01f,
  6.53153062e-02f, 7.10731447e-02f, 1.37082431e-02f, -1.70851916e-01f, 3.24787758e-03f, -4.10052985e-02f, -7.90761337e-02f, -1.76840536e-02f, -2.43056677e-02f, 3.88565436e-02f,
  -2.11884361e-02f, 1.25780270e-01f, 3.82843800e-02f, -5.14193922e-02f, -1.01970881e-01f, -6.25380874e-02f, 1.73976622e-03f, 8.40944871e-02f, 8.09771791e-02f, 7.22198281e-03f,
  -2.45938495e-01f, 1.08813934e-01f, -2.52985805e-01f, 9.99457464e-02f, 6.47865310e-02f, 1.49741650e-01f, 6.45178258e-02f, 1.13234341e-01f, 4.30506095e-02f, -4.95813154e-02f,
  1.36141777e-01f, -1.90965291e-02f, -1.35770351e-01f, 9.88960117e-02f, -1.90155786e-02f, 1.76109046e-01f, -1.04738273e-01f, -2.77733207e-02f, 1.63256675e-01f, 1.36033386e-01f,
  3.45456451e-02f, -6.17940165e-03f, -1.24211438e-01f, -2.43529752e-02f, 1.41735464e-01f, -1.77226976e-01f, -7.38213956e-02f, 6.27023205e-02f, 1.36964256e-02f, -1.63835078e-01f,
  -2.34323442e-01f, 3.32940876e-01f, 2.53789306e-01f, 1.44615695e-01f, 1.80693075e-01f, -2.15032458e-01f, -3.01401585e-01f, -3.51548463e-01f, -6.77726641e-02f, 4.93507721e-02f,
  1.13797851e-01f, 3.84488739e-02f, 1.10550284e-01f, -9.19289812e-02f, -4.24043864e-01f, 6.01132140e-02f, 2.80400962e-01f, -1.81090087e-01f, -5.53278446e-01f, -4.48344707e-01f,
  -4.42003272e-02f, -1.32962108e-01f, -2.87568927e-01f, -2.56690562e-01f, 3.79186064e-01f, 2.36079842e-03f, 2.32036471e-01f, 2.19593346e-01f, 1.51182851e-02f, 5.65552890e-01f,
  3.45685571e-01f, 2.37140983e-01f, -3.21681589e-01f, -4.26241308e-02f, 2.71383405e-01f, -1.40536785e-01f, -7.66137429e-03f, -1.77325890e-03f, 1.17085189e-01f, 8.59987959e-02f,
  2.34611332e-01f, -1.89600699e-02f, 2.63198644e-01f, 2.69301469e-03f, -1.50343537e-01f, -3.69419783e-01f, -2.53063858e-01f, -3.38482976e-01f, -4.11387593e-01f, -1.38442710e-01f,
  8.31848904e-02f, 1.90308616e-01f, 1.68847099e-01f, -2.11573780e-01f, -2.15593323e-01f, -3.59398648e-02f, -9.11535174e-02f, -1.00569166e-01f, -2.72597134e-01f, 2.88794059e-02f,
  -1.12534687e-01f, -9.55491513e-02f, 7.44895265e-02f, 1.45467281e-01f, -7.68804625e-02f, 1.48312271e-01f, 7.95051605e-02f, -1.19222067e-02f, -1.89812910e-02f, -9.99354795e-02f,
  -1.73262302e-02f, 7.39873946e-02f, 2.40383372e-02f, 5.45370567e-04f, -1.66059762e-01f, 6.16574325e-02f, -1.12880066e-01f, -1.38331383e-01f, -3.95639762e-02f, -3.26870568e-03f,
  -4.38283831e-02f, -1.14331208e-01f, 1.54128492e-01f, -1.67835206e-01f, -2.57705636e-02f, -6.76942468e-02f, 5.95844276e-02f, -1.02235794e-01f, -7.07953125e-02f, -8.22674576e-03f,
  -6.83907270e-02f, -1.84953600e-01f, 9.81085449e-02f, -2.35971346e-01f, 2.74516223e-03f, 7.43025914e-02f, 6.46593422e-02f, -8.97353664e-02f, 1.25667378e-01f, -1.82396024e-01f,
  -1.43076822e-01f, 1.85720865e-02f, 2.69082278e-01f, -2.67524630e-01f, -2.72914469e-01f, 2.21586619e-02f, -4.75163758e-02f, -1.08239420e-01f, -2.78249174e-01f, -4.49450687e-02f,
  -1.72985226e-01f, -3.82593423e-01f, -1.62496343e-01f, -1.78075016e-01f, -1.56491533e-01f, -2.60214031e-01f, -2.14763939e-01f, -2.81066358e-01f, -2.78979450e-01f, -4.74222183e-01f,
  -4.52566773e-01f, 5.24358153e-01f, 2.20205233e-01f, -4.92864043e-01f, 4.68813717e-01f, 6.43425107e-01f, 9.19015348e-01f, 3.40135127e-01f, -2.49040037e-01f, 1.92154899e-01f,
  2.26849064e-01f, -4.92074579e-01f, -2.84888953e-01f, -2.98819989e-01f, 1.63971618e-01f, 4.19854492e-01f, 1.06746390e-01f, -3.21447700e-01f, -1.86839774e-01f, 2.26212978e-01f,
  1.46290451e-01f, -2.28322223e-01f, -2.71506548e-01f, -2.22443312e-01f, -3.18083704e-01f, -4.93838966e-01f, -1.12633944e-01f, -4.20495458e-02f, 3.97987336e-01f, -3.13815594e-01f,
  -2.97826082e-01f, 1.49792612e-01f, -1.10819019e-01f, -2.52473235e-01f, 7.73167238e-02f, -1.16124386e-02f, 2.35609114e-02f, -2.64390886e-01f, 7.01692179e-02f, 1.96669791e-02f,
  -1.00113258e-01f, 5.25617898e-02f, 9.92567539e-02f, 3.04144192e-02f, 1.20876528e-01f, 1.41064212e-01f, -7.83335976e-03f, -1.27807513e-01f, -1.75836354e-01f, 2.43638322e-01f,
  5.08999452e-02f, 1.39233500e-01f, 1.29452482e-01f, 3.21181089e-01f, 1.12322196e-01f, -3.76909584e-01f, 1.61136657e-01f, -2.25182939e-02f, 1.32601619e-01f, -2.67534405e-01f,
  -9.03751552e-02f, -9.02924780e-03f, 2.49067575e-01f, 3.09517817e-03f, -5.26625402e-02f, -6.98224530e-02f, 8.25048834e-02f, 1.28862277e-01f, 8.80346596e-02f, -7.74050131e-02f,
  9.17894207e-03f, 2.66494006e-02f, -1.27660157e-02f, 1.17630453e-03f, -1.13729440e-01f, -4.29040715e-02f, 7.40684420e-02f, -7.05877617e-02f, 5.90333045e-02f, 8.27701837e-02f,
  -1.25306016e-02f, 5.33133969e-02f, -7.20110759e-02f, -5.38616329e-02f, 4.03188355e-02f, -1.28827691e-01f, -1.57680139e-01f, 2.97220238e-02f, -1.42669171e-01f, -2.43683327e-02f,
  -4.24484193e-01f, 3.38273466e-01f, -2.81484336e-01f, -8.16483051e-02f, -6.64610341e-02f, -7.39181563e-02f, -3.29575501e-02f, -5.30819744e-02f, 4.32717577e-02f, -1.19435862e-01f,
  1.51692152e-01f, -6.19709976e-02f, -1.20745590e-02f, 6.23369180e-02f, -5.52012846e-02f, -8.07374716e-02f, 1.75169840e-01f, -2.15662301e-01f, 4.08312026e-03f, 5.97522315e-03f,
  -4.69361842e-02f, 3.86498608e-02f, -3.42318743e-01f, -1.33217618e-01f, -1.66822597e-01f, -4.98086780e-01f, -1.47262543e-01f, -1.74075410e-01f, 8.76471996e-02f, -1.53650582e-01f,
  1.04333138e+00f, 2.20441103e-01f, -1.07973981e+00f, 4.18167531e-01f, -5.63975394e-01f, -6.70634985e-01f, -2.10987002e-01f, 3.30750295e-03f, 2.25511402e-01f, -6.25718245e-03f,
  -3.76735479e-02f, 1.12653799e-01f, -1.01803266e-01f, -1.81530580e-01f, -4.68446523e-01f, -3.48062038e-01f, -4.22077715e-01f, -6.08358502e-01f, -7.11547971e-01f, -4.13367599e-01f,
  9.25403982e-02f, 6.00534715e-02f, 4.15950604e-02f, -1.44565031e-01f, -4.53607775e-02f, -2.47565284e-01f, -4.30681378e-01f, -3.07074487e-01f, -4.37150449e-01f, -1.67225972e-01f,
  -6.05184674e-01f, -2.66507328e-01f, -1.76358342e-01f, 2.79091984e-01f, -7.46857598e-02f, 1.05033070e-01f, -1.52696654e-01f, 3.16932835e-02f, 2.18819827e-01f, -1.05775341e-01f,
  -2.25008056e-01f, -8.69607702e-02f, 4.74366359e-02f, -1.73311681e-01f, -2.89710850e-01f, -9.25104693e-02f, 5.28422855e-02f, -1.89597055e-01f, 4.55848984e-02f, -1.38118133e-01f,
  1.49699941e-01f, -1.85249180e-01f, -3.15243363e-01f, -1.24263316e-01f, -3.90894771e-01f, -7.10189268e-02f, -3.85685474e-01f, -4.76431578e-01f, -4.43925887e-01f, 1.27638042e-01f,
  1.30442426e-01f, 1.62726700e-01f, 6.99271858e-02f, 5.71602210e-02f, 2.24869207e-01f, 2.42716772e-03f, -2.36255992e-02f, -1.47753775e-01f, 9.85936634e-03f, -3.98711152e-02f,
  4.11114916e-02f, 3.51234786e-02f, 6.22351728e-02f, -2.33574654e-03f, -8.23791474e-02f, -1.08220719e-01f, 1.24592055e-02f, 5.27678467e-02f, -1.65235624e-02f, -7.50816911e-02f,
  4.71619815e-02f, -3.00785974e-02f, -4.07294892e-02f, 6.81756884e-02f, -9.40999463e-02f, -5.42249270e-02f, -3.26016545e-02f, 7.73953423e-02f, 1.12023897e-01f, -3.56279649e-02f,
  2.76083589e-01f, -1.01969138e-01f, 4.40332741e-02f, -6.93873093e-02f, -9.50027555e-02f, 2.57309526e-02f, 4.67857569e-02f, 1.37511194e-01f, 1.66508019e-01f, -8.98976624e-02f,
  -2.00040579e-01f, 6.43846840e-02f, 6.97484910e-02f, -6.37234077e-02f, -1.05663963e-01f, -9.74386707e-02f, 1.33469969e-01f, -1.18990708e-02f, 9.08656865e-02f, 8.86789411e-02f,
  2.38876715e-01f, 1.53921902e-01f, 3.18741709e-01f, 4.12415192e-02f, 1.28633216e-01f, 2.59161860e-01f, -1.28136724e-01f, -2.05741093e-01f, -3.84674333e-02f, 5.28333843e-01f,
  4.64567751e-01f, -1.83766186e-01f, 2.73747981e-01f, 3.47544491e-01f, 4.17689532e-01f, 3.14233631e-01f, 1.30539507e-01f, 7.10903555e-02f, 1.38293564e-01f, 8.43888447e-02f,
  1.76587239e-01f, 1.17890462e-02f, 4.59930189e-02f, -1.68633275e-02f, -1.35107145e-01f, -1.67345315e-01f, -5.36072440e-02f, 1.12330787e-01f, 2.95243561e-01f, 2.42067412e-01f,
  1.27661511e-01f, 4.55435067e-02f, 9.68716517e-02f, 3.58501226e-02f, 9.39269587e-02f, 1.77202433e-01f, 1.20163411e-01f, 2.11131305e-01f, 1.23115905e-01f, -1.61192015e-01f,
  -1.66100383e-01f, 1.37454852e-01f, 9.52358767e-02f, 4.38383222e-02f, 4.93080020e-02f, -5.11797480e-02f, 3.03565506e-02f, -1.38636380e-01f, -8.11618716e-02f, -1.87762216e-01f,
  -1.33248819e-02f, -1.58119686e-02f, -1.19409794e-02f, 5.34847565e-02f, 7.19260722e-02f, -6.16007997e-03f, -3.23163420e-02f, -1.56338274e-01f, -1.11882672e-01f, -1.82252988e-01f,
  -9.52656865e-02f, 2.21972421e-01f, 1.23514630e-01f, -5.64260222e-02f, 3.29313837e-02f, 2.58459866e-01f, 3.92699018e-02f, -3.01009063e-02f, 8.98417979e-02f, -3.07125188e-02f,
  3.15304041e-01f, 3.38126689e-01f, 1.54784948e-01f, -4.61319312e-02f, -1.12901270e-01f, -8.48582364e-04f, 7.54127651e-02f, -1.38633894e-02f, 1.83269233e-01f, 1.62667766e-01f,
  1.20784909e-01f, 1.26901835e-01f, 5.87770380e-02f, 1.69126913e-01f, 1.37303486e-01f, 1.79744586e-01f, 8.92542899e-02f, 1.05606411e-02f, 7.04705194e-02f, -6.50136471e-02f,
  6.26428276e-02f, 6.34359270e-02f, 1.97809592e-01f, -8.29996467e-02f, 1.91556007e-01f, 7.78623447e-02f, 1.71855971e-01f, 8.33776891e-02f, 1.01176083e-01f, 1.73633844e-01f,
  -3.16411555e-01f, 3.27486098e-01f, 3.83787304e-02f, -5.67575451e-03f, 2.00984813e-02f, 1.79786030e-02f, 1.01182394e-01f, -1.01916999e-01f, -1.71332285e-01f, -1.31265029e-01f,
  -7.56723359e-02f, -1.09863561e-02f, 9.86209810e-02f, -9.31660309e-02f, 4.37782556e-02f, 3.93272601e-02f, -4.12351154e-02f, -1.27469286e-01f, -2.62531340e-01f, -1.71939373e-01f,
  -2.13413108e-02f, 1.26216218e-01f, 4.31616940e-02f, -1.19615927e-01f, -3.61315869e-02f, 2.11711079e-01f, -1.84744690e-02f, -1.53522389e-02f, 2.26172451e-02f, -9.48431790e-02f,
  -2.74938047e-01f, 1.11847911e-02f, -6.41383827e-01f, -5.93590178e-02f, -2.23394111e-01f, -2.35032558e-01f, -1.75271109e-01f, 3.04918326e-02f, 1.81184024e-01f, 2.35921443e-01f,
  2.86113530e-01f, 2.16520786e-01f, 8.31101276e-03f, -8.16545486e-02f, -4.82063025e-01f, -2.53674060e-01f, -5.91582835e-01f, -8.04111481e-01f, -4.86154288e-01f, 2.61603862e-01f,
  4.24016446e-01f, 2.34273896e-01f, 2.61653624e-02f, -1.64801016e-01f, 2.52308428e-01f, 2.46203691e-01f, 7.86122307e-02f, 9.69222188e-02f, -1.06712312e-01f, -1.04537249e-01f,
  1.02297030e-01f, -3.36866155e-02f, -6.18380755e-02f, -1.16764441e-01f, 1.28067404e-01f, -2.56852806e-03f, 1.18710399e-01f, -1.64782867e-01f, -3.35271396e-02f, 7.93431476e-02f,
  -7.05358684e-02f, 1.16627246e-01f, -2.19841808e-01f, 1.04454584e-01f, 9.88183096e-02f, 9.30880383e-02f, -6.24199025e-02f, -2.64288992e-01f, -1.45464003e-01f, 9.48515087e-02f,
  9.54263203e-04f, -1.57146722e-01f, -3.20311219e-01f, -3.58009562e-02f, -1.73703674e-02f, -1.67572051e-02f, 2.43199438e-01f, 1.63005084e-01f, -1.46357656e-01f, 2.48736098e-01f,
  3.44068184e-03f, 4.97479551e-02f, 1.16496906e-01f, -3.31105813e-02f, 1.97150469e-01f, -8.75265747e-02f, -2.94738002e-02f, 5.01521491e-02f, 1.71296850e-01f, -4.23692875e-02f,
  -1.04052991e-01f, 4.28473726e-02f, 1.34029448e-01f, -5.83607368e-02f, 6.82838634e-02f, -3.35781164e-02f, 4.29620817e-02f, 1.55970156e-01f, -1.76165894e-01f, -5.50753763e-03f,
  -7.58885965e-02f, 7.26980120e-02f, 1.33372396e-01f, 8.45698193e-02f, -9.85591188e-02f, -1.53878361e-01f, -4.59602214e-02f, 1.91727370e-01f, 7.13486895e-02f, 3.67524996e-02f,
  3.62770170e-01f, -2.15646088e-01f, 9.49963480e-02f, 1.97955668e-02f, -1.04082391e-01f, 3.65235545e-02f, -7.95443654e-02f, -9.94774327e-02f, -5.89046404e-02f, 1.32223636e-01f,
  5.56851402e-02f, 2.80852001e-02f, -5.36389314e-02f, 1.64128661e-01f, -1.36000635e-02f, 4.70260829e-02f, -6.58589602e-02f, -1.21696174e-01f, -2.27119058e-01f, 1.58638299e-01f,
  -7.25164413e-02f, -1.78659752e-01f, -2.85346985e-01f, -1.87087059e-02f, 8.18101913e-02f, -4.83786464e-02f, 1.03763819e-01f, 1.84446752e-01f, -4.71135080e-02f, 1.72577545e-01f,
  -6.80999517e-01f, -2.46815965e-01f, 1.46493033e-01f, 2.31721431e-01f, 3.37074339e-01f, -1.73240006e-01f, -4.81869757e-01f, -5.46470284e-01f, -1.98651239e-01f, -1.24315262e-01f,
  -1.24762043e-01f, 1.03733644e-01f, 2.58157194e-01f, 8.67897794e-02f, -4.34733033e-02f, 1.97626632e-02f, 5.07478416e-01f, 3.45380843e-01f, -2.86263647e-03f, -1.03007764e-01f,
  2.36193553e-01f, 1.40700504e-01f, -5.01283072e-02f, 8.28524753e-02f, 1.79206207e-01f, 1.13657348e-01f, 1.76490381e-01f, 1.62362486e-01f, 1.91347569e-01f, 5.33188820e-01f,
  -1.49061561e-01f, -6.65243328e-01f, 1.40719607e-01f, 2.62385666e-01f, 2.46725455e-01f, -8.53475928e-02f, -2.07124755e-01f, -9.85356048e-02f, -1.39094979e-01f, -2.03765079e-01f,
  1.75909951e-01f, -1.42386019e-01f, 1.51047438e-01f, 7.48749599e-02f, -1.11885726e-01f, -3.27518731e-01f, -1.45998165e-01f, -1.85207888e-01f, -2.19413146e-01f, -2.87632018e-01f,
  4.14325178e-01f, 2.00943992e-01f, -2.63741076e-01f, -1.21104434e-01f, -3.28657806e-01f, 3.74741226e-01f, -2.68060386e-01f, -1.60121739e-01f, -4.14610833e-01f, -4.20483351e-01f,
  -1.44617945e-01f, -3.10312118e-02f, 1.00404248e-01f, 8.04615840e-02f, 1.03669176e-02f, 7.23930523e-02f, 1.60939038e-01f, 2.87834872e-02f, 2.46499985e-01f, -4.19657379e-02f,
  3.10673919e-02f, 1.42390840e-02f, -1.31674007e-01f, -2.30197757e-01f, 7.08572268e-02f, -5.10418415e-02f, -1.37850363e-02f, -3.23984660e-02f, -1.20577086e-02f, -5.28718270e-02f,
  1.76124960e-01f, 2.66139731e-02f, -6.98970025e-03f, -1.01694770e-01f, -3.78356352e-02f, -9.77330274e-05f, -1.64985377e-02f, 1.34381607e-01f, 3.77123803e-03f, -8.79908428e-02f,
  -1.84091404e-01f, 3.85283470e-01f, -1.65314227e-01f, -2.36342456e-02f, -1.08698398e-01f, 4.70300168e-02f, 4.51697707e-02f, 5.52220084e-02f, 6.18517050e-04f, -1.91936195e-01f,
  -1.22956760e-01f, -3.38166505e-02f, 1.34813157e-03f, -3.46680209e-02f, -1.07505344e-01f, -1.02896184e-01f, 2.51540184e-01f, 7.36731663e-02f, 6.34791926e-02f, -2.29507536e-02f,
  1.08855419e-01f, -4.68402505e-02f, -1.13419548e-01f, -1.41670793e-01f, -3.06660682e-02f, -7.71740079e-02f, -2.18297079e-01f, -5.27755916e-02f, -2.04156876e-01f, -3.48241180e-01f,
  -5.23533151e-02f, 3.38176161e-01f, -4.64086905e-02f, 2.96005189e-01f, 1.71738222e-01f, 1.24674454e-01f, 1.77134067e-01f, 2.48850822e-01f, 1.89788848e-01f, 7.20576048e-02f,
  -5.25391512e-02f, 1.22230954e-01f, 9.77721363e-02f, 1.31938234e-01f, 1.39238551e-01f, 3.11107367e-01f, 3.71416748e-01f, 1.73205599e-01f, 4.18499075e-02f, 1.36182413e-01f,
  3.58215302e-01f, 2.78717935e-01f, 1.41101256e-01f, 1.99637309e-01f, 2.83885807e-01f, 3.90577577e-02f, 1.30913928e-01f, 1.03523843e-01f, 1.43431798e-01f, 4.77925748e-01f,
  -6.31634653e-01f, -1.17944740e-01f, -7.41122141e-02f, -5.60903922e-02f, -6.47101626e-02f, 4.57190089e-02f, 7.57909194e-02f, -9.01229456e-02f, -5.63047305e-02f, 7.72434250e-02f,
  -1.11307383e-01f, -1.16827324e-01f, 2.27229390e-02f, 3.76005769e-02f, 7.95787107e-03f, -5.19303977e-02f, 9.28311646e-02f, 1.38177797e-01f, 4.39667068e-02f, -1.78549975e-01f,
  1.07405685e-01f, -5.37067838e-02f, -1.57843694e-01f, -1.35833651e-01f, 1.62224974e-02f, -1.19522765e-01f, -1.08076617e-01f, -2.79139597e-02f, -1.58958927e-01f, 7.70094469e-02f,
  1.91621661e-01f, -3.30498107e-02f, -6.19312339e-02f, 3.02425593e-01f, 2.07846582e-01f, 1.02976501e-01f, 1.12874776e-01f, -1.69990480e-01f, 1.18692346e-01f, 1.18737124e-01f,
  -1.67861730e-02f, -1.24784186e-01f, -1.06042325e-01f, -4.46731858e-02f, -2.21160501e-02f, 3.87367979e-03f, 5.43967299e-02f, -5.79483211e-02f, -5.13123795e-02f, -6.40245378e-02f,
  8.97314865e-03f, -4.15760837e-02f, -9.58627239e-02f, 9.75288004e-02f, -4.93541285e-02f, 4.93054017e-02f, 2.38472447e-02f, 2.37540789e-02f, 4.84575443e-02f, 6.69164956e-02f,
  -3.32989365e-01f, -5.05779624e-01f, 9.71630216e-02f, 1.25040844e-01f, -2.08627671e-01f, -1.24004044e-01f, -1.38443738e-01f, -1.59220248e-01f, -1.48475647e-01f, -8.55684876e-02f,
  -2.01240167e-01f, -9.70466360e-02f, 2.21363567e-02f, 9.73847229e-03f, 5.45813851e-02f, -7.94033408e-02f, 7.08534047e-02f, 3.48009373e-04f, -5.00879958e-02f, -1.63704649e-01f,
  6.44622743e-02f, -8.08123797e-02f, -2.46755466e-01f, -9.67772081e-02f, -3.46618369e-02f, -2.56953955e-01f, -2.97577560e-01f, -1.77430481e-01f, -2.38700464e-01f, -1.20922625e-01f,
  7.09116936e-01f, -4.38622832e-01f, -3.37127924e-01f, 4.81689796e-02f, -2.40884066e-01f, -2.08309576e-01f, -3.36181074e-01f, -2.59629153e-02f, 9.16225314e-02f, -2.28041887e-01f,
  -7.48365279e-03f, 1.59995124e-01f, 2.86016744e-02f, 8.56285095e-02f, 8.49346351e-03f, -5.40935159e-01f, -3.69231224e-01f, -1.11358166e-01f, 1.83977693e-01f, 2.06739306e-01f,
  -2.30839103e-02f, -3.13938712e-03f, 9.54985917e-02f, 1.01845928e-01f, -1.88871518e-01f, -1.10948518e-01f, -2.61979610e-01f, -2.63362944e-01f, -2.69582927e-01f, -4.21443582e-01f,
  -3.40058506e-01f, 2.95033425e-01f, 1.26600385e-01f, 2.09298953e-01f, 9.15077627e-02f, 3.08436491e-02f, 9.68564302e-02f, 1.90452058e-02f, 5.58072105e-02f, -7.47326538e-02f,
  -1.39363408e-02f, 6.75873980e-02f, 2.15662234e-02f, 7.14983642e-02f, 6.17230386e-02f, 1.39039844e-01f, 1.18660390e-01f, -1.93987656e-02f, -2.75351647e-02f, 1.34063035e-03f,
  -3.65002900e-02f, 1.72344163e-01f, 4.95269848e-03f, 1.88441977e-01f, 1.08053431e-01f, 1.08199120e-01f, 2.07739994e-02f, 2.12482855e-01f, 1.75696850e-01f, 1.01813242e-01f,
  9.35092941e-02f, -1.13357520e-02f, 1.63902253e-01f, 2.46815503e-01f, 7.15804622e-02f, 1.91179831e-02f, -2.25338247e-02f, -1.46123961e-01f, 6.81191310e-02f, 1.45634999e-02f,
  -8.36545527e-02f, -7.50972033e-02f, 1.80511892e-01f, -6.91102445e-02f, 1.28433602e-02f, 1.92676689e-02f, 3.00042108e-02f, 8.36631376e-03f, 3.11622303e-02f, 2.49974709e-02f,
  1.05401471e-01f, -1.90877780e-01f, -1.41051739e-01f, 7.59349531e-03f, -6.29185364e-02f, 3.36993635e-02f, 1.32329669e-02f, 6.77791312e-02f, -9.73502472e-02f, -4.65431623e-02f,
  8.38271827e-02f, 3.48578691e-01f, -5.71368635e-02f, -3.98374386e-02f, -1.42494768e-01f, -4.48725522e-02f, 4.67288047e-02f, -6.32819831e-02f, -8.17193612e-02f, -1.24281757e-01f,
  -1.59220751e-02f, 9.38736200e-02f, -4.96284440e-02f, -6.06314205e-02f, -5.20360805e-02f, 1.00786880e-01f, 6.77295104e-02f, -2.74776369e-02f, -1.37928203e-01f, -1.62493214e-01f,
  -4.09576297e-02f, 6.43083304e-02f, 1.85634866e-01f, 8.07466079e-03f, 9.31360796e-02f, 5.54989427e-02f, 3.77386510e-02f, -4.85001951e-02f, 6.27907272e-03f, -2.06420105e-02f,
  9.28017914e-01f, -4.38318431e-01f, 5.17008185e-01f, 6.80964813e-02f, -4.08203363e-01f, -3.50208193e-01f, -6.05685472e-01f, -2.76136458e-01f, -4.86745574e-02f, -1.84060559e-01f,
  -2.72960454e-01f, -8.01897049e-03f, 1.68089330e-01f, 2.02956244e-01f, 2.84285575e-01f, -8.77220482e-02f, 8.87625366e-02f, 5.64220130e-01f, 5.03002882e-01f, 5.71070351e-02f,
  -1.96500510e-01f, 1.93431959e-01f, 5.11884809e-01f, 3.19595724e-01f, -1.00476116e-01f, 3.64252962e-02f, -1.74968205e-02f, 4.98368368e-02f, 1.12488233e-02f, 2.64883757e-01f,
  1.50131106e-01f, -4.28524129e-02f, 1.20817661e-01f, 6.40701428e-02f, 8.00698325e-02f, 6.04131073e-02f, 5.74941933e-02f, 4.70368229e-02f, -4.70668525e-02f, -7.81087279e-02f,
  3.46900746e-02f, -1.75158344e-02f, -3.27275731e-02f, -1.54796734e-01f, -1.72608495e-01f, -3.70890051e-02f, 8.75073224e-02f, 1.37751818e-01f, 1.13014847e-01f, 4.01133113e-02f,
  -1.56790838e-01f, -1.99907035e-01f, -1.77970663e-01f, -2.11118206e-01f, 7.79839158e-02f, 1.27170622e-01f, -7.35757351e-02f, -2.51101106e-02f, 4.88993451e-02f, -5.07212151e-03f,
  1.51496261e-01f, 1.02736518e-01f, 1.10334173e-01f, -7.89532810e-02f, 5.44829108e-02f, -8.69909972e-02f, -2.77493577e-02f, -1.31028324e-01f, 5.01970686e-02f, 4.53548804e-02f,
  -1.51321650e-01f, -7.53707206e-03f, -6.89247251e-02f, -8.38384256e-02f, 1.33233517e-01f, -5.48681393e-02f, -3.80900688e-02f, -6.26040772e-02f, 2.60906164e-02f, -2.10140273e-03f,
  8.25977847e-02f, -7.71498168e-03f, -1.89779345e-02f, 2.11432427e-02f, -7.28575662e-02f, 8.57883319e-03f, 4.47396040e-02f, -6.28549755e-02f, -1.11580431e-01f, -4.02591974e-02f,
  -4.97895390e-01f, 2.55097389e-01f, 2.23491818e-01f, 1.95948660e-01f, 3.43365036e-02f, 9.14305970e-02f, 3.47915366e-02f, -1.01465313e-02f, -1.27401933e-01f, -8.05040821e-02f,
  -5.09464405e-02f, 1.49828121e-01f, -6.86140433e-02f, 6.37278035e-02f, 8.94043818e-02f, -3.60849015e-02f, -1.07881203e-02f, -6.73322082e-02f, -7.22402558e-02f, -6.42078072e-02f,
  -5.66301942e-02f, -1.35712534e-01f, -6.62355274e-02f, -1.67783737e-01f, -1.97899759e-01f, 8.59959424e-02f, -1.86017491e-02f, -2.80768573e-02f, 3.73147079e-04f, -1.29231393e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  5.39590359e-01f, 6.46751821e-01f, 5.32003641e-01f, 1.75677657e-01f, 5.11736572e-01f, 5.07417619e-01f, 6.00495696e-01f, 6.33774400e-01f, 5.38562536e-01f, 4.30153430e-01f,
  3.21320802e-01f, 4.97319311e-01f, 6.29237294e-01f, 6.06995702e-01f, 7.08283186e-02f, 6.45360649e-01f, 4.59889144e-01f, 3.79897267e-01f, -1.56523287e-01f, 7.36639559e-01f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -7.75876269e-02f, 1.93841513e-02f, -1.02251038e-01f, 1.85666353e-01f, -2.33263541e-02f, 3.09648275e-01f, -3.03303242e-01f, -1.51033914e-02f, -5.02301902e-02f, -2.87204571e-02f,
  -4.30227704e-02f, 2.67058015e-02f, -5.17646521e-02f, -1.28212795e-01f, -1.14231929e-01f, -1.22075796e-01f, -1.40285000e-01f, -1.51136279e-01f, -1.36268273e-01f, -2.87374169e-01f,
  -2.48740599e-01f, -9.75445807e-02f, -2.34980211e-01f, 3.08884829e-01f, 3.78032820e-03f, 4.27472629e-02f, 2.17056140e-01f, -6.66986182e-02f, 5.09096622e-01f, 1.52752355e-01f,
  2.00526804e-01f, 3.16932723e-02f, 2.66033178e-03f, -1.91692740e-01f, -4.22929414e-02f, -1.00688152e-01f, -6.03403896e-02f, 3.01836152e-02f, -1.75867125e-01f, -1.34917438e-01f,
  1.29007041e-01f, -1.16618298e-01f, -1.26864105e-01f, 3.82037200e-02f, 2.08325729e-01f, 2.15025440e-01f, -9.77967829e-02f, 6.97315633e-02f, -5.83666146e-01f, -2.33586878e-01f,
  1.37892082e-01f, -3.57150465e-01f, -4.12450552e-01f, -2.73160577e-01f, 1.34813190e-01f, 2.69333899e-01f, 3.72828752e-01f, -4.54567671e-02f, 9.76066366e-02f, 1.00016430e-01f,
  2.55876631e-01f, 8.66017714e-02f, -1.34312481e-01f, -3.35509270e-01f, 9.23931897e-02f, -1.61728058e-02f, -8.71836245e-02f, -1.50441036e-01f, -1.85897693e-01f, 7.52920359e-02f,
  -9.94548351e-02f, 1.77979156e-01f, 2.32660219e-01f, 1.96879730e-02f, 1.02976002e-01f, -1.45907346e-02f, -3.41485478e-02f, 2.71922469e-01f, 2.62833595e-01f, 5.66385351e-02f,
  -2.17215866e-01f, -3.85401994e-02f, -2.50315785e-01f, -1.69473395e-01f, -3.91740978e-01f, -2.92001992e-01f, 2.06970826e-01f, 5.99348471e-02f, 2.65814096e-01f, -1.54637218e-01f,
  -1.13899253e-01f, 1.36043608e-01f, 2.67957956e-01f, 5.89363985e-02f, 1.66842803e-01f, 1.71733961e-01f, 1.37460768e-01f, 3.67263507e-04f, 1.28379300e-01f, 2.60870278e-01f,
  -4.07569744e-02f, 1.65541887e-01f, 7.09841400e-02f, 1.18268970e-02f, 3.17087844e-02f, 1.77957006e-02f, -3.97551022e-02f, 1.33435592e-01f, 6.80429488e-02f, -1.18518896e-01f,
  2.88473338e-01f, 9.55521762e-02f, 3.98525566e-01f, 3.14244211e-01f, -4.17081118e-01f, -1.89195815e-02f, 1.89107046e-01f, -2.29433045e-01f, 2.58666705e-02f, -4.19226028e-02f,
  -1.04452200e-01f, 1.56838328e-01f, 1.48794994e-01f, 3.68996039e-02f, 1.06840424e-01f, -1.29374117e-01f, 3.13529164e-01f, -7.61924908e-02f, -6.51185289e-02f, -9.52942371e-02f,
  -3.28156762e-02f, -1.11187980e-01f, 7.25348890e-02f, 4.82318364e-03f, 2.78905213e-01f, 5.31744771e-02f, 2.00838014e-01f, -2.80481458e-01f, 3.04287583e-01f, 6.91166222e-02f,
  -2.75336392e-02f, 1.48563877e-01f, -3.22713286e-01f, -2.05458581e-01f, -2.57430196e-01f, -1.88424259e-01f, 6.23293221e-03f, 3.57420355e-01f, 6.17504977e-02f, -5.13553023e-01f,
  1.89682066e-01f, 4.63557065e-01f, -4.57857437e-02f, 6.72220066e-02f, 8.71976018e-02f, -7.50841722e-02f, -2.88725883e-01f, -2.36627217e-02f, -2.41006240e-01f, 4.23187762e-01f,
  1.36517704e-01f, -1.82236031e-01f, -9.80985835e-02f, -2.57999320e-02f, -4.02962863e-02f, -3.33245277e-01f, -1.48076624e-01f, 1.26653731e-01f, 6.24589063e-02f, -1.50988102e-01f,
  1.50214553e-01f, 1.18800834e-01f, 9.95382518e-02f, -6.05088249e-02f, 1.09904446e-01f, -2.49076530e-01f, -5.53490460e-01f, -5.23052774e-02f, -1.87096819e-01f, 4.17277664e-02f,
  -1.47811994e-01f, -2.44203210e-01f, 2.45322183e-01f, 2.67328709e-01f, -3.79570961e-01f, 6.53375089e-02f, -5.49917929e-02f, 1.39396220e-01f, -2.52162784e-01f, 3.38244766e-01f,
  -1.13225617e-01f, 1.06936723e-01f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  7.27314875e-02f, 9.41119492e-02f, -3.93295363e-02f, -5.48405722e-02f, 2.77436942e-01f, 3.28805387e-01f, 1.79244548e-01f, 6.61412701e-02f, -2.29696646e-01f, 2.23173544e-01f,
  -3.89235198e-01f, 2.08557118e-02f, 5.56469798e-01f, 1.63639277e-01f, 7.15645477e-02f, -7.65958205e-02f, 6.63300633e-01f, 9.85942334e-02f, 8.84432048e-02f, -3.82555157e-01f,
  -3.23214442e-01f, 5.40504277e-01f, -6.73303753e-02f, -6.34621739e-01f, 5.11969328e-01f, 3.24013680e-01f, -1.43491924e-01f, 4.90018159e-01f, 2.75134623e-01f, 4.90183830e-01f,
  -2.77476199e-02f, -6.76380157e-01f, -7.85638317e-02f, 1.36095351e-02f, 7.62349367e-02f, 9.09054130e-02f, 2.26290837e-01f, -1.60519689e-01f, 4.73017283e-02f, 2.32610200e-02f,
  1.42450124e-01f, -8.29320028e-02f, 4.77031693e-02f, -2.28309020e-01f, 4.30440396e-01f, -5.03023565e-01f, -5.46030581e-01f, 2.85804033e-01f, -4.04763341e-01f, -3.84308666e-01f,
  -1.26922101e-01f, 2.98234105e-01f, 9.15532187e-02f, -1.09740846e-01f, -1.81439474e-01f, 1.47688732e-01f, -2.05822676e-01f, -4.49176461e-01f, 8.75400379e-02f, -5.51539481e-01f,
  -9.56989378e-02f, 5.97677827e-01f, -1.92391738e-01f, 3.94620091e-01f, 8.01249146e-02f, 2.28882819e-01f, 3.50428708e-02f, 2.75103092e-01f, 1.93396017e-01f, 1.09384239e-01f,
  -2.20273927e-01f, 3.12399939e-02f, 4.06165153e-01f, 5.60554564e-01f, -2.34282836e-01f, 7.26822615e-02f, 2.53799576e-02f, 6.96965039e-01f, 7.67114818e-01f, 1.68235272e-01f,
  -4.60551798e-01f, -1.04179405e-01f, 1.25555368e-02f, -1.24378234e-01f, -4.81552660e-01f, -1.07809290e-01f, 1.47797570e-01f, 5.14419973e-01f, 1.14745581e+00f, 1.54539332e-01f,
  4.70358804e-02f, 4.51185465e-01f, 6.49070144e-01f, 2.11127121e-02f, 1.20353717e-02f, -3.28080595e-01f, 2.24243522e-01f, 3.13188106e-01f, 1.09163359e-01f, 1.42368793e-01f,
  1.01021007e-01f, 5.07202148e-01f, -1.66577213e-02f, 1.09472968e-01f, 3.02721977e-01f, -3.46393049e-01f, 2.56434649e-01f, -2.85816997e-01f, 1.63447723e-01f, 1.38330892e-01f,
  -9.47752520e-02f, -4.52688009e-01f, -3.18678796e-01f, 2.61618406e-01f, 6.16335928e-01f, 1.21282883e-01f, -2.83905178e-01f, 7.70300508e-01f, -4.88216132e-01f, 7.26181805e-01f,
  8.80547911e-02f, 1.78084388e-01f, 1.81239143e-01f, 2.25191072e-01f, 1.15125382e+00f, 2.01008484e-01f, -4.08283733e-02f, 2.41703093e-01f, -8.65030289e-02f, 2.71925747e-01f,
  1.63286388e-01f, 1.20230377e-01f, 3.04040164e-01f, -1.23218395e-01f, -2.30509683e-01f, 4.63965178e-01f, 3.79552841e-01f, -1.97300930e-02f, -1.77206900e-02f, 1.25012785e-01f,
  9.53613669e-02f, 6.38290823e-01f, 1.96805000e-01f, 4.23555486e-02f, -6.15765810e-01f, -5.04634500e-01f, 3.88938934e-01f, 2.16437519e-01f, -2.63307631e-01f, -2.29303196e-01f,
  5.87705255e-01f, 6.51197672e-01f, 7.92271495e-01f, 1.42377511e-01f, 1.50345087e-01f, 4.67390656e-01f, -4.61448729e-01f, -2.29021281e-01f, -2.94086456e-01f, -7.57757306e-01f,
  2.44343355e-01f, 1.47512674e-01f, 1.45570055e-01f, 2.67624259e-01f, 6.58480525e-02f, 9.79349762e-02f, 1.59945209e-02f, -3.34849685e-01f, -1.44055083e-01f, -2.33133808e-01f,
  2.36649707e-01f, -3.32308821e-02f, -1.25133514e-01f, -5.26200533e-01f, 4.54516202e-01f, 6.70025423e-02f, -6.61153316e-01f, 9.12173867e-01f, 1.91896826e-01f, -3.57974976e-01f,
  5.08128777e-02f, 7.68819869e-01f, 2.17584684e-01f, -2.46527256e-03f, -3.28632474e-01f, 5.77510774e-01f, 4.73498315e-01f, 7.15016901e-01f, 6.69921219e-01f, -2.27294877e-01f,
  1.27487198e-01f, -7.98481181e-02f, 2.08840236e-01f, 9.40091014e-02f, 1.91685885e-01f, -4.67815697e-02f, 1.73784584e-01f, 3.46210748e-01f, 2.84399331e-01f, -1.18442245e-01f,
  6.87395558e-02f, 2.04775617e-01f, -7.53049925e-02f, 1.12395920e-01f, 4.14568454e-01f, 4.58739281e-01f, 4.89029855e-01f, -1.83760658e-01f, 1.21592569e+00f, -1.25099927e-01f,
  3.28220218e-01f, -3.14392559e-02f, -1.58313941e-02f, -4.43227701e-02f, 1.44158691e-01f, -3.34302992e-01f, 6.69257522e-01f, -3.55637342e-01f, -4.03509811e-02f, 6.88355118e-02f,
  2.60629088e-01f, -2.46358484e-01f, -2.45585188e-01f, 1.52996540e-01f, 3.70236486e-01f, 2.11428721e-02f, -2.89344907e-01f, 3.67314249e-01f, 2.58932620e-01f, 1.49329424e-01f,
  -2.12532386e-01f, 1.29288092e-01f, 3.02130114e-02f, 1.84517562e-01f, -4.29260194e-01f, 1.61777601e-01f, 5.08750200e-01f, 4.76210564e-01f, -3.38131845e-01f, 2.95147598e-01f,
  1.67170521e-02f, 1.32602200e-01f, 4.90059853e-02f, 7.26960748e-02f, 6.47768855e-01f, 6.74853444e-01f, 7.69030377e-02f, 1.18602857e-01f, 3.77617180e-01f, 3.20478141e-01f,
  6.04329407e-01f, -3.06140929e-01f, -3.31813246e-02f, 1.12372927e-01f, -1.16384305e-01f, -1.41025737e-01f, 1.96000665e-01f, -1.68271646e-01f, 2.95563996e-01f, 1.06159851e-01f,
  -8.75547603e-02f, 2.11070795e-02f, -2.11498648e-01f, 6.94540888e-02f, 2.66010433e-01f, -2.14511871e-01f, 3.37686576e-02f, -1.49881542e-01f, 2.10854128e-01f, 1.53795868e-01f,
  7.15149641e-01f, 2.43675202e-01f, 4.59074974e-01f, 3.16169634e-02f, -1.71772003e-01f, 1.64632425e-01f, -1.12339361e-02f, -8.07332337e-01f, 3.04171205e-01f, 1.52593672e-01f,
  -4.17275459e-01f, -1.13833614e-01f, 1.21571027e-01f, -1.28824189e-01f, 4.49668974e-01f, 1.15871578e-01f, 5.99210203e-01f, 2.89714396e-01f, 7.55591840e-02f, 2.00077817e-01f,
  4.45250303e-01f, 1.71609387e-01f, 3.30975950e-02f, -1.28819004e-01f, 2.64994115e-01f, -2.61364412e-02f, -5.29941404e-03f, -5.23792088e-01f, 3.10097754e-01f, -9.06186178e-02f,
  3.98499161e-01f, 1.24102190e-01f, 2.86650628e-01f, -2.72235036e-01f, 5.66118658e-01f, -3.87165919e-02f, 1.94659919e-01f, 2.88978338e-01f, -5.22163093e-01f, -3.16766165e-02f,
  1.95256397e-01f, -7.52611607e-02f, -8.18562090e-01f, -2.82568753e-01f, -3.07151169e-01f, 2.40034014e-01f, 1.09887928e-01f, 2.73279577e-01f, 1.22171849e-01f, 6.76397681e-01f,
  4.21000980e-02f, -5.22071980e-02f, 7.73707181e-02f, 4.96258922e-02f, 2.55851716e-01f, 9.86386240e-02f, 2.79891461e-01f, 8.13903809e-02f, 1.14565656e-01f, -9.60274935e-02f,
  -1.73509121e-01f, -3.36066097e-01f, 6.95660189e-02f, -3.45392190e-02f, -4.98246312e-01f, 3.89355004e-01f, -4.10384566e-01f, -2.31710657e-01f, -7.54480585e-02f, 1.03816487e-01f,
  1.52593985e-01f, -5.50666928e-01f, -5.19339681e-01f, 3.70308012e-01f, 6.31839335e-01f, 6.49061128e-02f, -2.66568035e-01f, -4.26429033e-01f, 2.07312539e-01f, 4.95857656e-01f,
  -6.47426769e-02f, -5.28760403e-02f, 2.02734634e-01f, -1.91539139e-01f, -8.90098587e-02f, 8.45783874e-02f, 1.05104052e-01f, -2.49360710e-01f, -1.70774877e-01f, 1.56598613e-01f,
  1.92465335e-01f, -3.16552669e-01f, -7.63872713e-02f, 6.23049363e-02f, 6.84013426e-01f, 2.66785920e-01f, 2.15222269e-01f, 1.90767080e-01f, -2.26997063e-02f, -3.12490344e-01f,
  1.70262098e-01f, -4.02420610e-01f, 3.91622901e-01f, -1.58507794e-01f, 4.41548884e-01f, 4.30235267e-01f, -6.48539420e-03f, 1.00558259e-01f, -1.42814308e-01f, -1.46875799e-01f,
  6.80416048e-01f, 1.66918218e-01f, -6.61840141e-02f, -3.32002640e-01f, 3.92787278e-01f, 3.78890753e-01f, 7.92713836e-02f, 2.17390507e-01f, 4.72730696e-01f, 2.22011343e-01f,
  -1.09247997e-01f, -8.04650262e-02f, -2.16691524e-01f, 3.60311568e-02f, -4.06579137e-01f, 4.11009669e-01f, 3.12296718e-01f, 2.28448436e-01f, -1.70415670e-01f, -1.90336719e-01f,
  3.56207490e-01f, -8.58965278e-01f, 3.98633748e-01f, -2.35314816e-01f, 1.68126389e-01f, 3.99029076e-01f, 1.78891748e-01f, -9.04327035e-02f, -1.06974602e-01f, 2.82601416e-01f,
  -2.34207381e-02f, 2.86507398e-01f, 5.75368991e-03f, -3.78960831e-04f, -3.76276463e-01f, -5.41353673e-02f, 3.20315927e-01f, 1.37096524e-01f, 3.53047132e-01f, -3.78449522e-02f,
  1.80669148e-02f, 2.45111927e-01f, -3.03833932e-02f, -5.57553321e-02f, -2.84297079e-01f, -2.04890519e-01f, 2.98438698e-01f, -1.21246222e-02f, 8.31086785e-02f, -3.63594562e-01f,
  4.50386666e-02f, -1.35786517e-03f, -1.28752008e-01f, 6.46365464e-01f, -5.56440413e-01f, 2.33939677e-01f, 1.62723973e-01f, -4.37373102e-01f, 1.15355961e-01f, 5.07047534e-01f,
  -9.67513680e-01f, 1.10403633e+00f, -6.62402948e-03f, 4.98510778e-01f, 5.17952204e-01f, 4.81355101e-01f, 2.35499322e-01f, 7.85288990e-01f, 1.70157194e-01f, 1.78339124e-01f,
  1.36326775e-01f, 3.38623524e-01f, 2.87454277e-01f, 6.90272227e-02f, 2.65465826e-01f, -1.25683740e-01f, -3.85303378e-01f, 1.10558726e-01f, -2.14332491e-01f, -3.58111322e-01f,
  -3.33049595e-01f, 5.53146563e-02f, 1.40359281e-02f, 1.25176599e-02f, 2.34406844e-01f, 6.24104738e-01f, 4.75439988e-02f, 3.51864785e-01f, 6.17842257e-01f, 8.45839679e-01f,
  1.38674140e-01f, -2.78170109e-01f, 3.90563637e-01f, 3.51431817e-01f, 1.15162972e-02f, -1.95669398e-01f, -2.00789616e-01f, 2.45965958e-01f, 9.21219066e-02f, 9.12741125e-02f,
  3.82269979e-01f, -3.02752703e-02f, 2.54875988e-01f, 1.16962463e-01f, 1.00728370e-01f, 5.02857491e-02f, 1.92207500e-01f, -1.87876504e-02f, -2.56549686e-01f, 6.73723454e-03f,
  1.90270636e-02f, 9.69267860e-02f, 7.57723927e-01f, -2.24828441e-02f, -2.12676108e-01f, 3.59789044e-01f, 5.74701667e-01f, 2.08701909e-01f, 4.27785039e-01f, -3.00941795e-01f,
  -1.93490550e-01f, 6.60927415e-01f, 1.66833416e-01f, 8.29443932e-02f, 9.26103666e-02f, 1.66143492e-01f, 2.68129800e-02f, 5.28695524e-01f, 4.21907872e-01f, 2.14750499e-01f,
  -3.43786657e-01f, -6.04910195e-01f, 1.61258444e-01f, 3.29609662e-02f, 9.08555984e-02f, 8.43376368e-02f, 1.09379858e-01f, 1.83419883e-01f, -1.53304517e-01f, 1.05653301e-01f,
  5.39823212e-02f, 1.04141802e-01f, -5.77156730e-02f, 3.06124315e-02f, -1.16424561e-01f, 3.85945231e-01f, 1.89496979e-01f, 4.27727848e-02f, 3.25297862e-01f, -1.08186632e-01f,
  1.17653243e-01f, 1.24622397e-01f, 5.60903072e-01f, 1.36370242e-01f, 7.97436535e-02f, -4.38564867e-01f, -3.41169208e-01f, -2.50134856e-01f, 4.59148526e-01f, -7.60189414e-01f,
  2.87973195e-01f, -5.98649792e-02f, 1.51242279e-02f, 5.13745487e-01f, 7.89226443e-02f, -1.67079821e-01f, -1.25863880e-01f, -2.89488826e-02f, 6.63151219e-02f, 4.82029393e-02f,
  -2.95942903e-01f, 1.37980087e-02f, 1.57879312e-02f, 3.91850650e-01f, -4.09728885e-02f, 2.48634264e-01f, -6.19480796e-02f, 3.05821717e-01f, 4.00504410e-01f, 1.47587489e-02f,
  5.99660039e-01f, 1.22039795e-01f, -5.45016587e-01f, -2.59523213e-01f, 3.61573070e-01f, -9.06356052e-02f, 4.60719168e-01f, -2.99270988e-01f, 5.30505896e-01f, 7.56332457e-01f,
  4.34524147e-03f, 3.47064048e-01f, -6.06288433e-01f, 1.59538224e-01f, 4.35206652e-01f, -2.49820814e-01f, 1.74428642e-01f, 1.95833340e-01f, 1.16895400e-01f, 1.38903737e-01f,
  3.36767644e-01f, 1.94411382e-01f, 1.84149593e-01f, 7.45699257e-02f, 2.30757177e-01f, 1.84746578e-01f, -3.52591164e-02f, -1.09988853e-01f, 2.40907185e-02f, 6.97156310e-01f,
  3.78757298e-01f, -2.71335155e-01f, 1.06484461e+00f, -3.21868777e-01f, 2.14625865e-01f, 4.52061623e-01f, 3.92958105e-01f, -2.41896406e-01f, 2.03737348e-01f, -2.06248000e-01f,
  7.49996006e-01f, -3.91146988e-01f, 1.39860854e-01f, -4.16388810e-01f, 3.91655900e-02f, -1.59977823e-01f, 3.96807641e-02f, 5.50957382e-01f, 2.34606490e-02f, 1.11263424e-01f,
  2.97085643e-01f, 1.10543594e-01f, 6.26187921e-02f, 1.97642669e-01f, 4.73964095e-01f, 2.34462097e-01f, 1.64093658e-01f, -5.26141487e-02f, -1.72468677e-01f, -2.88859338e-01f,
  -1.87811300e-01f, 3.07008982e-01f, -1.04853702e+00f, -1.24409616e-01f, -5.01526415e-01f, 3.48376423e-01f, 3.44186068e-01f, 6.86994910e-01f, -1.43901473e-02f, 4.47053730e-01f,
  -6.13111198e-01f, 5.80717683e-01f, 8.35857034e-01f, -6.80168450e-01f, 3.09418619e-01f, -1.81979556e-02f, -2.68591344e-01f, 2.34681278e-01f, -2.60886014e-01f, 5.75947881e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  -2.01430187e-01f, 2.66568571e-01f, 3.70710611e-01f, 3.53207350e-01f, 4.29181963e-01f, 2.43982002e-01f, -2.68722534e-01f, 1.86489373e-01f, 1.17858417e-01f, 1.92010939e-01f,
  4.10496891e-01f, 8.47976357e-02f, 8.73111784e-02f, 5.69725871e-01f, -3.92990001e-02f, 1.56525299e-01f, 8.63221064e-02f, -1.26779363e-01f, -1.05428159e-01f, 1.59040496e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -5.61002254e-01f, -1.38091296e-01f, -2.24779457e-01f, 3.57733816e-01f, -7.14739203e-01f, -3.68897840e-02f, 5.43890893e-01f, -6.39658332e-01f, 1.28418028e-01f, -4.77036387e-01f,
  -3.45185488e-01f, -7.29573444e-02f, 2.77988553e-01f, -5.22018313e-01f, 4.14854437e-02f, -7.43511021e-01f, -7.32952729e-02f, 1.47420198e-01f, 3.06139797e-01f, -7.82913685e-01f,
  2.65305102e-01f, 1.46570802e-01f, -5.14924109e-01f, -3.07836086e-01f, -3.21956396e-01f, -1.61815390e-01f, -1.15790039e-01f, -6.77696243e-02f, -4.18537140e-01f, 3.98174852e-01f,
  -4.93722111e-02f, -3.36251557e-01f, 1.80111304e-01f, -2.90756017e-01f, 1.88271463e-01f, -5.07727563e-01f, 1.11884668e-01f, -1.12176716e-01f, -3.36153358e-01f, -9.47598889e-02f,
  -5.90274036e-01f, -4.86947536e-01f, 3.15468818e-01f, -4.27289963e-01f, -1.39125839e-01f, 2.98180491e-01f, -9.48701560e-01f, -9.62125242e-01f, -8.38629842e-01f, -2.10626259e-01f,
  2.40001366e-01f, 1.67025074e-01f, 1.83995739e-01f, -8.09457153e-02f, 9.56442952e-03f, 2.28731871e-01f, 2.38684952e-01f, -5.45231178e-02f, 3.30367759e-02f, -1.78137973e-01f,
  3.78676802e-01f, 3.39705020e-01f, 3.52637380e-01f, -1.96102224e-02f, -1.31086469e-01f, -1.45565674e-01f, -3.09978183e-02f, -3.19241136e-01f, 3.63627300e-02f, -4.94666062e-02f,
  5.02192378e-01f, -3.03373665e-01f, 5.35104871e-01f, 3.26180726e-01f, -4.03543562e-01f, -3.26913357e-01f, -6.98413610e-01f, -7.43929386e-01f, 7.67281428e-02f, 4.12153214e-01f,
  -6.44561350e-01f, -9.57496744e-03f, 3.65328521e-01f, -5.48415840e-01f, 3.08130771e-01f, 3.06198686e-01f, -4.17312473e-01f, -1.52486309e-01f, -1.17003277e-01f, -2.37002760e-01f,
  -1.23491883e-01f, -6.51713669e-01f, 4.53555554e-01f, -3.00689548e-01f, 5.01208663e-01f, -4.07688558e-01f, 9.18433350e-03f, -7.80611098e-01f, -4.24740463e-01f, -2.15162560e-01f,
  3.81876305e-02f, 1.81117848e-01f, -7.97057338e-03f, 2.67656177e-01f, 7.57610798e-02f, 1.57775313e-01f, 1.88330233e-01f, -2.87659988e-02f, 1.62895337e-01f, -6.22547865e-01f,
  4.14156765e-01f, -2.80407071e-01f, 4.11180645e-01f, -3.17947567e-01f, 4.64490056e-01f, 4.79562618e-02f, -3.23257536e-01f, -3.97139907e-01f, -6.10764086e-01f, 1.24196008e-01f,
  1.97186917e-01f, -1.65961576e+00f, -5.60215354e-01f, -5.05985133e-02f, -1.56304121e-01f, 4.03435417e-02f, 4.47036207e-01f, -3.07855070e-01f, 6.17488742e-01f, 3.61039370e-01f,
  1.94210052e-01f, -4.41336483e-01f, 3.09289157e-01f, -5.40289342e-01f, -9.32325184e-01f, 1.08156765e+00f, 3.73592377e-01f, 3.98503523e-03f, 4.68587220e-01f, 7.70363748e-01f,
  -6.06821179e-01f, -1.02024890e-01f, 2.95917958e-01f, -3.76101911e-01f, 5.68153679e-01f, 2.38709271e-01f, -2.56278634e-01f, -1.46980584e-01f, 2.19907433e-01f, 1.61162451e-01f,
  1.25880048e-01f, 3.61374646e-01f, 5.30774742e-02f, -1.06514595e-01f, -5.23455799e-01f, -1.60625391e-02f, -5.90653904e-02f, -3.37631516e-02f, -5.15309155e-01f, -4.72382128e-01f,
  2.08583981e-01f, 3.76647711e-01f, 3.38073313e-01f, -5.97367406e-01f, -5.69222011e-02f, 6.25588596e-01f, -2.19336897e-01f, -5.97687483e-01f, -2.89453864e-01f, 4.24002528e-01f,
  -5.93851566e-01f, -3.88014287e-01f, 3.19118857e-01f, -1.47951037e-01f, -7.38205984e-02f, -2.23954961e-01f, -2.88505256e-01f, 3.84693146e-01f, -6.83902264e-01f, 6.83360696e-02f,
  -4.32262987e-01f, -3.22813064e-01f, -8.83890912e-02f, -1.95769176e-01f, 3.42183203e-01f, 1.22685224e-01f, 4.16476697e-01f, 1.21515453e-01f, -3.39562893e-01f, 2.06932917e-01f,
  -1.41451466e+00f, -3.50950986e-01f, 5.85420668e-01f, 6.36846945e-02f, 2.47775495e-01f, 5.04744053e-01f, -3.59769940e-01f, -2.06539594e-02f, 4.13476348e-01f, -6.71534657e-01f,
  1.89302832e-01f, -5.88909864e-01f, 5.78726232e-02f, 5.29721618e-01f, -6.78506121e-02f, 2.80210346e-01f, -6.63099349e-01f, 3.05915534e-01f, -5.55163324e-01f, -7.75157452e-01f,
  -2.02282459e-01f, -7.62174726e-01f, -1.12690322e-01f, 4.17976201e-01f, 1.98741481e-01f, -7.68748462e-01f, -2.49556646e-01f, 3.08434039e-01f, -1.02924377e-01f, -8.82574856e-01f,
  -1.78738236e-01f, -3.98932509e-02f, -9.36498046e-02f, 4.99058783e-01f, -4.26843584e-01f, -4.00610089e-01f, 8.68894383e-02f, 1.56689852e-01f, 3.55533123e-01f, 1.37359694e-01f,
  7.39300698e-02f, 2.71280736e-01f, 1.55228779e-01f, -5.02801165e-02f, -3.00560862e-01f, -4.19219106e-01f, 3.05307388e-01f, 1.26144469e-01f, 2.02443376e-01f, 2.54660457e-01f,
  -1.57057881e-01f, -2.95210809e-01f, -1.59130141e-01f, 1.70642987e-03f, 3.27154808e-02f, -8.60090911e-01f, 3.68060797e-01f, 6.00204706e-01f, -3.62985313e-01f, -5.37208557e-01f,
  -4.06915367e-01f, 2.70100981e-01f, -2.14289010e-01f, -6.17991090e-01f, -5.90214849e-01f, -2.21770927e-01f, -3.03919137e-01f, -4.52398390e-01f, -1.83323637e-01f, 4.44161355e-01f,
  5.31097017e-02f, -4.55520093e-01f, -1.43426329e-01f, -1.09919235e-01f, -1.00935914e-01f, 3.47996950e-01f, -4.35537845e-01f, 9.44074616e-03f, -4.68894750e-01f, -1.37695447e-01f,
  -2.94558585e-01f, 3.68464231e-01f, -3.48664880e-01f, 3.14517289e-01f, -1.28351450e-01f, 2.46967226e-01f, -3.98346364e-01f, -3.22003782e-01f, -4.76613969e-01f, -2.26490825e-01f,
  -2.21379459e-01f, -8.42183709e-01f, 4.54426646e-01f, 6.47051036e-02f, 2.62071341e-01f, -8.22291970e-01f, -3.18370521e-01f, 4.23921227e-01f, -3.41329187e-01f, 5.97343147e-01f,
  4.60840076e-01f, 5.87755181e-02f, 2.50129104e-01f, 2.90179521e-01f, 4.38543528e-01f, 5.24391055e-01f, 3.68871838e-01f, 6.16645992e-01f, 7.46071398e-01f, 4.56824660e-01f,
  -7.59880364e-01f, -2.46182427e-01f, -1.15344133e-02f, 6.13755405e-01f, -3.78671438e-01f, 5.35410404e-01f, -7.92399466e-01f, -1.59806550e-01f, 3.17615159e-02f, 2.12060306e-02f,
  -2.04952717e-01f, -1.99292810e-03f, -3.44157130e-01f, 4.62175786e-01f, -9.53888714e-01f, -2.46320143e-01f, -8.97493884e-02f, -5.06679177e-01f, -8.23294163e-01f, 7.30600348e-03f,
  -1.37873664e-01f, 1.87451988e-01f, -3.01746368e-01f, 2.84377277e-01f, -8.66476446e-02f, -1.92930788e-01f, -2.49720573e-01f, -3.14465553e-01f, -5.56973934e-01f, -2.09183097e-01f,
  -9.43222791e-02f, -3.56680602e-01f, 5.73322415e-01f, -5.82929730e-01f, -8.11874509e-01f, 1.35864705e-01f, -7.96008259e-02f, -1.79295987e-01f, 6.44313753e-01f, -3.18188071e-01f,
  -3.76327246e-01f, 5.86253464e-01f, -6.20503306e-01f, -1.45610254e-02f, 5.53510845e-01f, -1.05210531e+00f, -5.36014199e-01f, 6.46763265e-01f, -6.37430549e-01f, -5.93683898e-01f,
  -1.35996118e-01f, -3.67407352e-01f, 2.40424067e-01f, 3.87810975e-01f, 2.21890360e-01f, 1.22897379e-01f, -9.79008228e-02f, 1.94705743e-03f, 2.06483677e-01f, 3.11679214e-01f,
  1.87376797e-01f, 1.22763328e-01f, 4.71529722e-01f, -5.36766350e-01f, -4.59369242e-01f, -2.15564296e-01f, 4.86988693e-01f, 9.91789401e-02f, 5.57938755e-01f, -7.70501494e-01f,
  -7.23265186e-02f, 1.30095938e-03f, -2.48947471e-01f, -9.46842670e-01f, 1.57148466e-01f, -9.73390400e-01f, -4.82600540e-01f, -6.27815902e-01f, 2.42107641e-02f, -4.89954561e-01f,
  -1.45733967e-01f, -3.72617841e-02f, 3.60026568e-01f, 5.17108858e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -3.48621994e-01f, -2.28670046e-01f, 3.80773209e-02f, -2.99751729e-01f, -1.66002940e-02f, 7.70146549e-02f, 3.11934650e-01f, -7.69973099e-02f, -1.85065016e-01f, 1.64759427e-01f,
  1.71623677e-01f, 6.09355196e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    