/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.68967861e-01f, -3.09577002e-03f, 2.11772751e-02f, -1.88916847e-01f, 2.72704899e-01f, 4.24282998e-01f, 5.05280137e-01f, 1.47003368e-01f, -1.13373481e-01f, 3.67388614e-02f,
  4.75625843e-02f, -1.17719844e-01f, -3.83500680e-02f, -6.97696730e-02f, 6.09511770e-02f, 1.45239562e-01f, 1.66607071e-02f, -1.15734160e-01f, 2.55109183e-02f, 8.11632201e-02f,
  -5.71177937e-02f, -1.08806953e-01f, -8.63480121e-02f, -1.34393349e-01f, -7.46954978e-02f, -1.22612625e-01f, 5.98544367e-02f, 6.04282208e-02f, 3.68203372e-02f, -2.12461755e-01f,
  -1.86950326e-01f, -4.04919647e-02f, 8.57464448e-02f, -8.82501304e-02f, 3.08521464e-02f, -1.37906328e-01f, -3.64592299e-02f, -1.46595493e-01f, 1.16785550e-02f, -3.70979570e-02f,
  -8.57545733e-02f, 2.01031454e-02f, 1.03205875e-01f, 4.34750207e-02f, 7.69959986e-02f, -2.94862520e-02f, 1.78182423e-02f, -8.21289271e-02f, -6.36096345e-03f, -1.15184650e-01f,
  -1.00663360e-02f, 1.39547661e-01f, 1.18107341e-01f, 8.97009298e-02f, -3.05597624e-03f, -2.61958987e-02f, 1.39634358e-02f, 3.86863872e-02f, 5.79271279e-02f, -5.48584200e-02f,
  -2.27462128e-02f, -4.71667498e-02f, 4.98771593e-02f, -3.85113433e-02f, 1.25466604e-02f, -1.13126915e-03f, -4.77483077e-03f, 5.93544822e-03f, -1.55532302e-03f, 9.28519107e-03f,
  -5.05153509e-03f, 3.47729027e-03f, -2.14790013e-02f, -7.08406866e-02f, -5.53802811e-02f, 1.14992619e-01f, -7.96771701e-03f, 1.53962318e-02f, 8.61682463e-03f, 4.56064902e-02f,
  2.34563723e-02f, 9.30086151e-02f, -3.20919938e-02f, -3.15792207e-03f, 6.09526299e-02f, -6.36822879e-02f, -3.74363642e-03f, -5.07850870e-02f, 1.16103394e-02f, -2.30810978e-02f,
  -1.48213983e-01f, 2.55395889e-01f, -1.68783456e-01f, 4.05336656e-02f, -1.25406086e-02f, -4.43776920e-02f, -1.87545037e-03f, 1.40351336e-02f, -2.26980541e-02f, -2.11046357e-02f,
  1.51890265e-02f, -4.27253395e-02f, -3.33768576e-02f, -2.06005201e-02f, -5.75071312e-02f, 4.17949818e-02f, -2.76949443e-02f, -7.24434629e-02f, -2.61667892e-02f, 3.01835872e-02f,
  1.37337036e-02f, 3.80806327e-02f, 5.46608083e-02f, -7.10881501e-03f, -2.01841053e-02f, -1.11227399e-02f, 7.96974972e-02f, -3.25401537e-02f, 1.74537808e-01f, -8.12426805e-02f,
  1.24433406e-01f, -1.65536657e-01f, -2.35602409e-01f, -1.69326887e-02f, -9.45059024e-03f, 3.03388783e-03f, -1.59393638e-01f, 7.80202895e-02f, 2.86872070e-02f, -2.27290634e-02f,
  4.08651792e-02f, 2.48968631e-01f, 1.51639864e-01f, 4.66236323e-02f, -6.26455471e-02f, -1.72473654e-01f, -2.47541994e-01f, -1.58863783e-01f, 3.95767689e-02f, -5.26402667e-02f,
  -5.17993830e-02f, -9.92651284e-02f, -1.12637959e-01f, -5.39054945e-02f, -7.73412138e-02f, 1.30717531e-01f, -4.40786481e-02f, -5.24014980e-02f, -9.47882310e-02f, -1.21713504e-01f,
  -1.02300614e-01f, 5.81195913e-02f, 1.12027325e-01f, 1.33498743e-01f, -3.75951752e-02f, -3.76079120e-02f, 3.09859328e-02f, 2.92404052e-02f, 6.99703321e-02f, 6.21687099e-02f,
  5.87706314e-03f, -6.65546255e-03f, 6.42220154e-02f, 2.49804873e-02f, -5.54007366e-02f, 6.14714138e-02f, -9.65753496e-02f, 7.49724451e-03f, 9.79278609e-03f, -9.65291932e-02f,
  3.04635335e-02f, -2.59708054e-02f, -8.54471996e-02f, 4.17944714e-02f, -5.03747426e-02f, 9.08498242e-02f, -5.70096672e-02f, -2.53272597e-02f, -6.94471970e-02f, -1.54531598e-01f,
  4.29917611e-02f, -5.51414350e-03f, -1.78632587e-02f, -1.66229345e-02f, 6.57204762e-02f, 8.28105435e-02f, 3.22928578e-02f, 9.70183406e-03f, -8.24321359e-02f, -2.42675357e-02f,
  -4.27041389e-02f, 2.29127277e-02f, -6.72003329e-02f, -5.80024645e-02f, -9.72956512e-03f, 3.64369154e-02f, 9.50058922e-03f, -4.93287481e-02f, -5.29601565e-03f, 9.00462642e-02f,
  4.84315529e-02f, -5.39390184e-02f, 2.06339993e-02f, 4.74249870e-02f, -2.18484830e-02f, -7.87102506e-02f, 6.50294423e-02f, -1.07625155e-02f, -4.01623957e-02f, 7.34729273e-03f,
  9.43005309e-02f, 1.27734676e-01f, 4.65905294e-02f, 3.82222496e-02f, -3.32984179e-02f, 6.08939305e-02f, -5.06000221e-02f, 8.77399445e-02f, 9.29124770e-04f, 1.55148162e-02f,
  2.57610548e-02f, -4.25253958e-02f, -2.39440519e-02f, 4.38030949e-03f, 1.47474082e-02f, 8.22971016e-02f, -4.12640497e-02f, -5.05825467e-02f, 2.96645798e-02f, -9.34261456e-03f,
  -5.93613461e-02f, -1.21543547e-02f, 1.89593260e-03f, -4.10039499e-02f, -3.49499173e-02f, 1.45991389e-02f, -3.89679074e-02f, 1.74357444e-02f, 3.73675637e-02f, -1.50872454e-01f,
  -2.87284672e-01f, 1.62638023e-01f, -2.73605704e-01f, -9.26769897e-03f, 5.90359904e-02f, -5.08861765e-02f, 4.25244384e-02f, 7.03200139e-03f, 8.34975988e-02f, 6.20405152e-02f,
  2.80052185e-01f, 9.90752429e-02f, -4.05594483e-02f, -4.98010553e-02f, -2.20253825e-01f, -1.77476704e-01f, -1.90758079e-01f, -3.79064322e-01f, -3.77134711e-01f, -1.60275996e-01f,
  1.79888238e-03f, -8.56049955e-02f, -9.87770483e-02f, -5.29443957e-02f, 2.00638026e-02f, 5.35004251e-02f, -5.54246493e-02f, -8.75499845e-02f, 1.05377138e-01f, -3.20887901e-02f,
  -2.05914780e-01f, -9.90259126e-02f, -3.81780826e-02f, -4.78520244e-02f, 4.08409759e-02f, -5.09818234e-02f, -8.19563493e-03f, -9.14886370e-02f, 6.93307668e-02f, 1.38691235e-02f,
  1.25026598e-03f, -6.88512484e-03f, -1.13224611e-02f, 3.88357341e-02f, -2.69629844e-02f, -4.55680117e-02f, -4.65177111e-02f, -9.53704417e-02f, -3.39028910e-02f, -5.87443896e-02f,
  9.63561460e-02f, 1.72388479e-02f, -1.25378489e-01f, 5.77010475e-02f, 4.66467664e-02f, -8.79470333e-02f, 3.62200551e-02f, 5.50190881e-02f, -1.22396059e-01f, 8.02550316e-02f,
  2.37029288e-02f, -3.10833454e-02f, 2.83692051e-02f, 3.24428417e-02f, 2.77426355e-02f, 9.30090174e-02f, -1.64438952e-02f, -2.10827645e-02f, 1.26323681e-02f, 7.83092715e-03f,
  8.90986174e-02f, -4.67608571e-02f, 2.13126261e-02f, -3.66144106e-02f, -3.49606089e-02f, -3.83702293e-02f, 2.76066717e-02f, 7.51256617e-03f, 1.55777922e-02f, 2.40307488e-02f,
  -3.98851298e-02f, 1.11988392e-02f, 8.64405092e-03f, -2.81923823e-02f, 5.42236352e-03f, -6.93546385e-02f, 9.39061213e-03f, 8.36596936e-02f, -2.28956025e-02f, -4.54168580e-02f,
  5.44139855e-02f, -7.13929385e-02f, 1.52241839e-02f, -6.64673597e-02f, -1.05323661e-02f, 1.25380725e-01f, 9.67131853e-02f, 8.64390749e-03f, 2.20727790e-02f, -4.46640663e-02f,
  7.86645785e-02f, -1.64201800e-02f, 2.23109801e-03f, -8.41038860e-03f, -3.29951271e-02f, 1.19213108e-02f, 1.37812287e-01f, -5.36404215e-02f, 2.37483867e-02f, 1.33847684e-01f,
  1.66941106e-01f, 8.70039240e-02f, -2.60546468e-02f, 3.08609977e-02f, 1.93397445e-03f, -3.08952983e-02f, 3.19560915e-02f, -4.15849723e-02f, -8.44288096e-02f, 1.04021080e-01f,
  -5.19072935e-02f, -2.07708195e-01f, -2.05113426e-01f, 1.90981001e-01f, 8.59177113e-02f, -3.25662643e-02f, -3.09333742e-01f, -1.29177511e-01f, 1.83363363e-01f, -7.66000599e-02f,
  9.63151380e-02f, 1.94604129e-01f, 6.90009668e-02f, 1.13942355e-01f, -1.30023524e-01f, -2.16210619e-01f, -1.03714935e-01f, -9.99535695e-02f, -5.76542355e-02f, 1.09682279e-03f,
  1.35364845e-01f, -4.16131876e-02f, -7.78182819e-02f, -2.97365393e-02f, 6.85211867e-02f, 2.03956902e-01f, 2.60664299e-02f, 4.82510179e-02f, 5.50193749e-02f, 7.75412172e-02f,
  -9.06902403e-02f, -1.70404091e-02f, 4.14626151e-02f, 1.05548382e-01f, 9.77915376e-02f, -9.64873061e-02f, -1.04519829e-01f, -7.73591176e-02f, -7.92622864e-02f, -1.03160441e-01f,
  3.30006145e-02f, 6.05564564e-02f, -3.68715241e-03f, 3.51398662e-02f, -2.60030478e-02f, -4.83637601e-02f, -1.01771206e-01f, -7.52362460e-02f, 4.27832492e-02f, -4.47311923e-02f,
  -1.85290966e-02f, 8.58531073e-02f, -3.83630842e-02f, 2.35629380e-02f, -7.15170577e-02f, 2.47269161e-02f, 6.19217008e-02f, 9.63511020e-02f, 7.14602396e-02f, 3.91089581e-02f,
  5.36780879e-02f, 1.50006544e-02f, 6.92193210e-02f, 5.68716079e-02f, 7.84476567e-03f, 4.09704521e-02f, 2.62432266e-02f, 2.11223699e-02f, -2.14472320e-02f, -3.42472754e-02f,
  -3.78349274e-02f, 4.62749135e-03f, -2.61890679e-03f, -2.96150334e-02f, 7.54085928e-02f, -4.14800979e-02f, -3.26722339e-02f, -9.17356636e-04f, -7.64139146e-02f, -1.86900710e-04f,
  3.76642421e-02f, 5.44620156e-02f, -4.81819324e-02f, 3.97614315e-02f, -4.92262915e-02f, -3.28287743e-02f, -2.33224221e-03f, 6.93482952e-03f, -3.79674695e-02f, 4.88940179e-02f,
  8.42069685e-02f, -4.70650047e-02f, -3.91070247e-02f, -1.29325151e-01f, -1.59050338e-02f, 2.74027772e-02f, 6.47656247e-02f, -4.94271331e-02f, 5.52596599e-02f, -9.58145633e-02f,
  1.70746055e-02f, -1.21593148e-01f, 6.47598319e-03f, 2.53063515e-02f, -1.52136118e-03f, -1.11188442e-01f, -6.97797537e-02f, -6.68446242e-04f, 1.22501627e-02f, -9.56776738e-02f,
  -6.10559154e-03f, -8.21586177e-02f, -1.15580998e-01f, -1.50344968e-01f, 2.42718980e-02f, -5.20856455e-02f, -8.30292776e-02f, -3.26289423e-02f, -8.41828138e-02f, -1.96349740e-01f,
  2.04384044e-01f, -1.25503074e-02f, 2.23758444e-01f, -5.85195869e-02f, 1.91018999e-01f, 2.20672712e-01f, 2.93829829e-01f, 1.21568562e-02f, -3.52820940e-02f, 1.18614152e-01f,
  3.94006632e-02f, -1.72741085e-01f, -5.64827286e-02f, -1.18478931e-01f, 5.79449683e-02f, 9.08260196e-02f, -2.11687032e-02f, 5.24379499e-02f, 2.46289186e-03f, -6.70490600e-03f,
  -1.27297625e-01f, -1.95334285e-01f, -4.89653088e-02f, 1.74838642e-03f, -8.20467472e-02f, -1.27568439e-01f, 2.90238969e-02f, 2.48232465e-02f, 5.09361140e-02f, -1.99225798e-01f,
  1.15965843e-01f, 5.32897636e-02f, 6.06396496e-02f, -1.05415517e-02f, 5.17247654e-02f, -3.51078957e-02f, 7.39059970e-02f, -1.98335610e-02f, 3.33030149e-02f, -8.64956230e-02f,
  -2.19442062e-02f, -2.95659117e-02f, -3.49227674e-02f, -8.38854238e-02f, -4.22815181e-04f, 1.31056067e-02f, -5.52929379e-02f, -3.82887572e-02f, -1.49414800e-02f, 4.43672054e-02f,
  -1.26679540e-01f, -1.13137718e-02f, 1.74516007e-01f, 2.60199141e-02f, 2.07513236e-02f, 8.28916356e-02f, 1.27851710e-01f, -8.27632174e-02f, 5.27109466e-02f, -1.19390674e-01f,
  -3.36333341e-03f, 2.82055624e-02f, 6.96245208e-03f, -4.53622304e-02f, 1.04010636e-02f, -1.66220684e-02f, -4.19606157e-02f, -1.24921817e-02f, 1.55000137e-02f, -9.01226699e-02f,
  7.58961309e-03f, 1.41433142e-02f, -2.69215107e-02f, 2.85535567e-02f, 2.84719691e-02f, 8.39385670e-03f, -4.72697094e-02f, -2.85299029e-02f, -4.32812376e-03f, 3.17057781e-02f,
  -2.31375359e-02f, 7.90186226e-02f, 9.18112136e-03f, 2.63311677e-02f, -5.65846032e-03f, 2.02186145e-02f, -6.55774027e-02f, 4.40558679e-02f, -9.29994285e-02f, 7.56719261e-02f,
  -1.39574990e-01f, 2.82655388e-01f, 3.89947859e-03f, -3.12013756e-02f, -4.27166671e-02f, 2.94067524e-03f, 7.17600808e-02f, -4.89505939e-02f, 6.31324714e-03f, 8.83140881e-03f,
  7.09586591e-02f, 1.19511606e-02f, 2.99407262e-02f, -3.70811811e-03f, -1.75439101e-02f, -6.54074103e-02f, -5.06602519e-04f, 4.78624292e-02f, 5.99707253e-02f, 1.48478206e-02f,
  -8.40941593e-02f, 7.33715147e-02f, 5.55160157e-02f, 8.65762755e-02f, 4.95108292e-02f, 1.40846074e-01f, -2.00754218e-02f, -4.83255535e-02f, 1.19600482e-01f, -5.33053502e-02f,
  -7.08178341e-01f, -2.10375071e-01f, 4.67057079e-02f, -2.23075256e-01f, -4.75913845e-02f, 1.53922308e-02f, -9.63620543e-02f, -9.06948373e-02f, 1.05447404e-03f, -3.47564854e-02f,
  -2.18192185e-03f, 4.70468104e-02f, 1.50470749e-01f, 4.55442443e-02f, -1.46964435e-02f, 3.57693732e-02f, -4.98893559e-02f, -1.59080047e-02f, 5.99780492e-02f, -7.45637044e-02f,
  3.59534696e-02f, -1.44351587e-01f, -2.31396914e-01f, -2.90804580e-02f, 5.11094816e-02f, -4.84716520e-03f, 8.50604996e-02f, -1.04446814e-03f, 1.44113777e-02f, -1.30338505e-01f,
  -3.32415886e-02f, -2.12871060e-01f, 1.23485930e-01f, -1.02602199e-01f, 7.98134729e-02f, -7.05894679e-02f, -5.91608658e-02f, 1.27038732e-02f, -2.55540833e-02f, -4.80702110e-02f,
  1.55696329e-02f, 3.44854151e-03f, -4.00200188e-02f, 3.34804505e-03f, -8.77534896e-02f, -5.54336570e-02f, 1.72958262e-02f, 3.25823389e-02f, -2.35186629e-02f, 1.66206565e-02f,
  6.34029657e-02f, -4.41705175e-02f, 9.98909352e-04f, 8.32737982e-02f, 6.26658723e-02f, 8.55409130e-02f, 7.94442147e-02f, 6.57240450e-02f, 8.13692138e-02f, -2.26786450e-01f,
  -6.47478849e-02f, 6.31254725e-03f, 1.68402574e-03f, 9.04552452e-03f, -3.80081590e-04f, -2.28364766e-02f, 4.62283567e-02f, 3.90611379e-03f, -1.08284261e-02f, -7.22274563e-05f,
  2.04374678e-02f, -3.62060443e-02f, 4.02653441e-02f, -4.05011922e-02f, 1.60375249e-03f, 5.37094893e-03f, -2.24076235e-03f, 4.72226478e-02f, 3.91692445e-02f, -5.75937964e-02f,
  1.41359139e-02f, -5.03820321e-03f, -8.71586893e-03f, 1.33418320e-02f, 8.87890160e-02f, 5.83730824e-02f, -2.94354148e-02f, -4.81351502e-02f, 9.33773722e-03f, 1.87461562e-02f,
  -9.36057121e-02f, 1.62099019e-01f, -8.70388001e-02f, 2.32280791e-02f, 5.63748926e-02f, -2.20470279e-02f, -2.54738070e-02f, -1.48788486e-02f, 7.33498037e-02f, -6.12752102e-02f,
  1.88525841e-02f, -3.03079728e-02f, 4.48163338e-02f, -2.35624262e-03f, 8.77502281e-03f, 3.98640707e-03f, -1.16574252e-02f, 1.75125548e-03f, 9.38976929e-02f, -6.27997518e-02f,
  4.28520292e-02f, -7.72590488e-02f, -1.41926199e-01f, -1.25868442e-02f, 9.35544074e-02f, -9.55535192e-03f, -5.52954599e-02f, 1.86622199e-02f, -4.45349999e-02f, -2.59327382e-01f,
  -7.94659276e-03f, 1.35989934e-02f, 1.35533229e-01f, -1.47079170e-01f, 1.04232505e-01f, 9.57572311e-02f, 1.87586755e-01f, 6.64059864e-03f, -7.16242865e-02f, 3.04577332e-02f,
  -2.12628674e-02f, -6.28240183e-02f, -1.50815636e-01f, -1.97521344e-01f, -4.34054397e-02f, 3.86647694e-02f, -1.39994472e-01f, -2.44122520e-01f, -2.08089873e-01f, -8.41720849e-02f,
  -6.73661232e-02f, -1.59262270e-01f, -1.61745176e-01f, -1.70938089e-01f, -9.68057662e-02f, -1.55563712e-01f, -8.80864710e-02f, -4.52107051e-03f, -5.16118575e-03f, -1.71222806e-01f,
  1.48953259e-01f, 9.45020989e-02f, -4.75438610e-02f, -9.95931700e-02f, 6.17343150e-02f, -7.10597262e-02f, -4.85670827e-02f, 7.36547187e-02f, 5.50466925e-02f, -6.21300302e-02f,
  -5.21802753e-02f, -8.48657712e-02f, -1.34944618e-01f, 3.11506614e-02f, -5.03753982e-02f, 1.13291955e-02f, -5.74214421e-02f, -4.15498167e-02f, -1.82895716e-02f, 1.25093669e-01f,
  -2.86110421e-03f, 7.31092095e-02f, 1.47671297e-01f, 3.72438394e-02f, 1.26320586e-01f, -3.33168730e-02f, 1.03754617e-01f, 1.20091721e-01f, 5.12386952e-03f, 1.30124182e-01f,
  -7.78248832e-02f, 2.11560773e-03f, 2.37202588e-02f, 3.05018257e-02f, 1.46236606e-02f, 4.99872752e-02f, -8.76672938e-02f, -4.66700085e-02f, 2.40934286e-02f, 4.92223203e-02f,
  -6.95810234e-03f, -9.13791358e-03f, 4.14479114e-02f, -1.08602848e-02f, -5.62322438e-02f, -6.65579662e-02f, 2.98236590e-02f, -8.64108577e-02f, 2.54644733e-02f, -4.50412333e-02f,
  7.35889077e-02f, 5.38021838e-03f, 2.18529701e-02f, 7.01553151e-02f, -8.13694745e-02f, 1.98216010e-02f, -6.51584193e-02f, 8.65044668e-02f, -1.25291487e-02f, 4.18044813e-02f,
  -1.54692121e-02f, -4.48702909e-02f, -5.06232753e-02f, 1.17672596e-03f, 6.90951757e-03f, -2.58627273e-02f, 4.30390052e-02f, -2.41454989e-02f, -6.64922222e-02f, 3.42550054e-02f,
  -1.52668431e-02f, -7.42836371e-02f, 1.62102003e-02f, 2.51077376e-02f, -3.70839192e-03f, 2.67342967e-03f, -7.12743178e-02f, 2.11287849e-02f, -1.18261956e-01f, 5.58288358e-02f,
  6.29080981e-02f, 8.03645551e-02f, 1.15123749e-01f, 3.35016400e-02f, 1.99997406e-02f, -1.26472741e-01f, -1.98257826e-02f, 9.22231078e-02f, 3.58840190e-02f, 1.64367810e-01f,
  1.12308584e-01f, 1.19938076e-01f, 2.50921845e-01f, -9.28273648e-02f, -5.18957861e-02f, 1.68910727e-01f, 1.80092588e-01f, 1.31984040e-01f, -4.23192643e-02f, -2.76291072e-02f,
  9.49723125e-02f, -9.64832902e-02f, 1.69875696e-02f, 2.12731715e-02f, 1.60811275e-01f, 9.42981020e-02f, 5.75353093e-02f, 1.24920398e-01f, -2.82363594e-02f, 4.96523157e-02f,
  -1.78502738e-01f, -1.07490838e-01f, 6.15331670e-03f, -1.34292701e-02f, -2.28696868e-01f, -2.81116903e-01f, -1.61629766e-02f, -5.46116680e-02f, 1.36728326e-04f, -3.17211181e-01f,
  -1.83083296e-01f, 2.22584471e-01f, -6.42482191e-02f, -3.66762318e-02f, -4.05867659e-02f, -3.71593237e-02f, 2.10401844e-02f, 8.34007710e-02f, 5.32799289e-02f, 1.07066102e-01f,
  5.66853061e-02f, -1.44516872e-02f, -4.46719751e-02f, -8.26849192e-02f, 6.89706802e-02f, 5.41749783e-02f, 4.22797725e-03f, 1.06537916e-01f, 5.63797019e-02f, -8.32876598e-04f,
  -3.83501090e-02f, -7.90539458e-02f, 2.43361015e-02f, 1.22643948e-01f, 7.65660703e-02f, -2.44926661e-02f, 2.93108840e-02f, -9.13799834e-03f, 1.22825123e-01f, -1.13262892e-01f,
  -8.49876180e-03f, 4.62616161e-02f, -8.63985159e-03f, 2.92866398e-02f, -2.67204363e-02f, -1.70741361e-04f, -8.85748491e-02f, 2.06168144e-04f, -4.64457534e-02f, 2.00303439e-02f,
  1.73751358e-02f, 7.77828507e-03f, 4.86119241e-02f, 2.54876148e-02f, -8.66525173e-02f, 3.40451188e-02f, 8.48066236e-04f, -1.48775680e-02f, -3.72841284e-02f, 3.01187355e-02f,
  -4.72365879e-02f, 4.95667197e-02f, -9.16626900e-02f, 5.89115806e-02f, 2.12067440e-02f, -1.59722958e-02f, -7.87875950e-02f, 3.33092324e-02f, 2.71052290e-02f, 1.65718049e-02f,
  -2.02896997e-01f, 1.87865794e-01f, -3.33267115e-02f, 4.92856428e-02f, -1.61991781e-03f, 1.94217283e-02f, -4.00585569e-02f, 3.84248421e-02f, -4.07084413e-02f, -7.75701031e-02f,
  5.09849489e-02f, 4.21731435e-02f, 5.54210767e-02f, 1.49109121e-02f, 5.28252963e-03f, 3.05671655e-02f, 2.47807615e-02f, -1.00970283e-01f, 1.43588623e-02f, 1.47810187e-02f,
  3.24327797e-02f, -3.30596790e-02f, -1.53738469e-01f, -4.73618396e-02f, -1.28249139e-01f, -9.02178958e-02f, -1.73307344e-01f, -8.81313607e-02f, -9.45648551e-02f, -2.11314932e-01f,
  4.26411122e-01f, 4.11047451e-02f, 2.05611035e-01f, 3.44863921e-01f, 2.38424003e-01f, 2.27706701e-01f, 1.50751904e-01f, 1.20273709e-01f, 5.87020442e-02f, 2.32075714e-02f,
  -4.31036390e-03f, -8.14959332e-02f, 5.76682463e-02f, 6.63599446e-02f, 9.82550681e-02f, 9.49811116e-02f, 2.05932289e-01f, 1.56054080e-01f, 2.73140818e-01f, 1.55620679e-01f,
  1.37968048e-01f, 1.41266987e-01f, 2.20528051e-01f, 1.40523136e-01f, 7.92899355e-02f, 7.17102289e-02f, -1.53803797e-02f, 6.53190687e-02f, 6.31591231e-02f, -2.52196728e-03f,
  -1.35194764e-01f, 2.10572690e-01f, -3.69672701e-02f, 4.92569953e-02f, 9.49137509e-02f, -3.34193818e-02f, -4.02937718e-02f, -2.72342749e-02f, -2.95809191e-02f, -6.56424761e-02f,
  2.88954657e-02f, 7.40130618e-02f, -4.44736071e-02f, -2.06232108e-02f, 1.68384872e-02f, 5.44564165e-02f, 2.66721263e-03f, 4.27247621e-02f, -1.78937893e-02f, -4.25366424e-02f,
  -9.69625413e-02f, 4.53708693e-02f, 6.91641346e-02f, -2.01679487e-03f, -3.11192162e-02f, 4.38008942e-02f, 5.91213554e-02f, 1.67995077e-02f, 5.32690957e-02f, 1.15190330e-03f,
  -2.53080986e-02f, -8.48243982e-02f, 2.91864877e-03f, -1.75356865e-02f, 8.02503228e-02f, -9.54091921e-02f, -2.22867317e-02f, -4.35326360e-02f, 2.82394141e-02f, -3.52392602e-03f,
  -5.17681008e-03f, 1.03930989e-02f, -4.95591499e-02f, -1.68839339e-02f, -4.19400744e-02f, 1.20770358e-01f, -7.35221058e-02f, 2.76237889e-03f, -5.33406027e-02f, 6.52289717e-03f,
  4.95783165e-02f, -6.99749663e-02f, 5.38247973e-02f, -8.21846873e-02f, 1.51484776e-02f, 3.17339264e-02f, -1.52845904e-02f, 1.24825817e-02f, 9.10464488e-03f, 4.65280898e-02f,
  -1.10349931e-01f, 6.60596937e-02f, -1.47502080e-01f, -3.76066868e-03f, -6.74328394e-03f, -1.10530868e-01f, -7.34454626e-03f, 7.55699165e-03f, -1.40248495e-03f, 2.07311474e-02f,
  1.85374636e-02f, -1.17436573e-01f, 2.27695014e-02f, -4.57888618e-02f, 6.54093921e-02f, 3.43060642e-02f, -5.18254787e-02f, 4.07512598e-02f, -3.42682898e-02f, -5.69158159e-02f,
  -5.79548776e-02f, 5.83914779e-02f, 1.99774187e-02f, -1.25047430e-01f, -1.26998425e-02f, 1.05035333e-02f, -5.07678352e-02f, -6.98559806e-02f, -2.17334516e-02f, -1.55298144e-01f,
  2.16693655e-01f, -1.19577751e-01f, 2.60060459e-01f, 7.19073936e-02f, -9.03518219e-03f, 2.59773601e-02f, -1.08404800e-01f, -3.19773257e-02f, -4.01012972e-02f, -1.04727335e-01f,
  -2.05839928e-02f, -1.41649351e-01f, -1.12572825e-03f, -5.68789653e-02f, 1.61079422e-01f, 6.16209283e-02f, -3.55619565e-03f, 9.87175852e-02f, 3.28123495e-02f, -5.64452186e-02f,
  -1.27813354e-01f, 7.00373948e-02f, 1.69970885e-01f, -2.22714841e-02f, -9.02182981e-02f, -1.16153561e-01f, 5.15268790e-03f, 9.93310139e-02f, -2.79333368e-02f, -7.48281702e-02f,
  -2.15523015e-03f, 2.49633014e-01f, -7.59096816e-02f, -1.00605391e-01f, -5.59551641e-02f, -3.95622030e-02f, -1.11403633e-02f, 5.46883307e-02f, -5.26879728e-02f, 2.32469160e-02f,
  -9.33400244e-02f, 1.30122587e-01f, -5.05880788e-02f, -2.19193418e-02f, 5.47347143e-02f, 2.19904389e-02f, 1.09013554e-03f, 1.85582325e-01f, 1.15032144e-01f, 1.17926657e-01f,
  -8.87250528e-02f, 5.93798794e-02f, 1.08409084e-01f, 3.95810828e-02f, 5.91921099e-02f, -4.28855279e-03f, -5.43634892e-02f, 2.19577402e-02f, 1.44695535e-01f, -2.03209314e-02f,
  -4.18706648e-02f, 8.06330815e-02f, 5.57908230e-02f, 7.24492371e-02f, 1.65248327e-02f, -8.16450715e-02f, 3.41503434e-02f, -3.56413983e-02f, -3.20680626e-02f, 4.60329391e-02f,
  -6.55124411e-02f, -1.49810323e-02f, -4.59091589e-02f, 9.10257027e-02f, -8.80279988e-02f, 4.39413413e-02f, 8.47101328e-04f, 1.85666536e-03f, 1.04245804e-01f, 3.40818614e-02f,
  5.39644547e-02f, 7.58470818e-02f, 1.13118850e-02f, 1.72069091e-02f, -7.87374470e-03f, 3.27051021e-02f, 4.42616567e-02f, -1.08480476e-01f, -1.75610073e-02f, 5.21711074e-02f,
  -1.57676473e-01f, 1.71161398e-01f, -1.22283682e-01f, -2.05916725e-03f, 1.91133525e-02f, -5.34583675e-03f, -6.89752027e-02f, 6.75971955e-02f, 2.10330691e-02f, -4.52347733e-02f,
  5.05313911e-02f, 1.56306215e-02f, 5.96286845e-04f, -1.02088759e-02f, -1.18934527e-01f, -8.04946721e-02f, -4.29067314e-02f, 1.51832318e-02f, -3.09689716e-02f, -8.08420405e-02f,
  4.08897325e-02f, -2.44632140e-02f, 8.48187599e-03f, -1.19307160e-01f, -1.13559745e-01f, -1.34428730e-02f, -1.20616175e-01f, -1.69481680e-01f, -6.38236925e-02f, -2.19935447e-01f,
  -1.82953462e-01f, -1.34519234e-01f, -2.88882237e-02f, -1.58441663e-01f, -1.42771397e-02f, 2.42421314e-01f, 1.12737544e-01f, 1.67656600e-01f, -9.63693708e-02f, -4.57947105e-02f,
  5.25444262e-02f, -2.35938895e-02f, 5.13551719e-02f, 1.56173125e-01f, 2.13255465e-01f, 1.65711138e-02f, 9.99871269e-02f, 8.13777559e-03f, 2.60547370e-01f, 1.34663939e-01f,
  -5.68708517e-02f, -9.65671092e-02f, -3.26380283e-02f, -6.08596206e-02f, -8.14085156e-02f, 1.37924939e-01f, 2.71733594e-03f, -9.06032920e-02f, -8.69941991e-03f, -2.30697215e-01f,
  -9.86112803e-02f, -1.67430699e-01f, 1.33300468e-01f, -6.63707331e-02f, -1.01689756e-01f, 2.79235118e-03f, 2.77245939e-02f, -1.04570083e-01f, -6.84139654e-02f, -7.88724646e-02f,
  -6.98432699e-02f, -1.83379762e-02f, -4.46597226e-02f, -1.16862804e-01f, -1.31306633e-01f, -7.18097016e-02f, -1.51559278e-01f, -4.13548723e-02f, 2.89107207e-02f, -1.34002447e-01f,
  -1.09604485e-01f, -6.49704635e-02f, 3.59223038e-02f, 7.65726417e-02f, -1.49227027e-02f, 7.82179460e-02f, 5.99362850e-02f, 1.40174683e-02f, 9.62424949e-02f, -5.67419007e-02f,
  -4.73163975e-03f, -6.08153380e-02f, 4.64560315e-02f, -2.24677715e-02f, 3.02774962e-02f, 5.69291562e-02f, 4.59110783e-03f, 4.00591046e-02f, -3.43483547e-03f, 5.82573656e-03f,
  5.84253967e-02f, -1.62555706e-02f, -1.58513598e-02f, 8.37232098e-02f, -9.99004208e-03f, -1.93707738e-02f, -1.66738164e-02f, 2.75286864e-02f, -2.17124764e-02f, -4.75493148e-02f,
  4.61850837e-02f, 8.00333335e-04f, -4.20056023e-02f, -1.97445806e-02f, -2.89863180e-02f, -6.19689142e-03f, 4.72763553e-02f, 2.28781290e-02f, -3.66640911e-02f, -8.15684348e-03f,
  7.32355714e-02f, 9.06506181e-02f, 4.60459888e-02f, -8.56943196e-04f, 5.11253346e-03f, -5.82501199e-03f, -2.95775756e-02f, 3.83839086e-02f, 3.17825451e-02f, -1.06424149e-02f,
  6.37044683e-02f, -1.63549930e-02f, -5.09534702e-02f, 2.73700282e-02f, 2.69160960e-02f, 2.56086942e-02f, -4.89552915e-02f, 9.90235582e-02f, 8.32817107e-02f, -9.82393920e-02f,
  5.95606342e-02f, 1.29410893e-01f, 1.61421925e-01f, 1.54050738e-01f, -1.84790939e-02f, 1.23410113e-01f, 2.00401932e-01f, 1.20741859e-01f, 2.01118812e-01f, 1.71517178e-01f,
  -3.27459365e-01f, 2.18803465e-01f, 2.34866336e-01f, -2.77178615e-01f, -1.52036771e-01f, 5.48754893e-02f, 2.28706822e-01f, 5.79166599e-02f, -1.21032029e-01f, 3.15581448e-02f,
  -1.72140058e-02f, -2.26895854e-01f, -1.60406619e-01f, 6.10125391e-03f, 8.91287997e-02f, 2.37009689e-01f, 1.29261374e-01f, -1.49146318e-02f, 1.21768573e-02f, -8.42427462e-02f,
  -1.47688031e-01f, -5.49237095e-02f, -1.32520106e-02f, 4.05144356e-02f, 4.90417778e-02f, -2.59025991e-02f, 1.29372939e-01f, 3.58944274e-02f, 7.17777908e-02f, 1.01216547e-01f,
  -3.38445380e-02f, 1.20983258e-01f, -7.18502104e-02f, -1.03616036e-01f, 2.93020103e-02f, -8.18288624e-02f, 1.41315013e-02f, 1.48451552e-02f, -4.19482365e-02f, -4.60701957e-02f,
  -5.55591658e-03f, 2.02845372e-02f, -1.14026479e-02f, 3.37032340e-02f, -2.50386843e-03f, 1.89261679e-02f, 1.16770171e-01f, 3.69678475e-02f, 8.76255333e-02f, 6.29589930e-02f,
  -9.19822678e-02f, 5.36742620e-03f, 1.96617376e-02f, 6.06746785e-02f, 1.91917419e-01f, -4.96538542e-02f, 1.65519804e-01f, 1.74934074e-01f, 1.58228725e-01f, 3.22575904e-02f,
  -1.15699591e-02f, -3.33943893e-03f, 9.85012483e-03f, 3.32224183e-02f, -1.38358464e-02f, -2.81476788e-02f, 2.54638530e-02f, 1.42436437e-02f, -5.20654172e-02f, 4.81332392e-02f,
  5.41156754e-02f, 2.12960523e-02f, -1.58978198e-02f, -1.54235261e-02f, -2.64591333e-02f, -1.68781951e-02f, -2.02707741e-02f, 5.32408729e-02f, -6.73961043e-02f, -3.85588109e-02f,
  -1.93249602e-02f, 7.26247579e-02f, -6.23990037e-02f, -2.64722314e-02f, 4.11592014e-02f, -2.36708131e-02f, 3.86537910e-02f, -8.97532403e-02f, -7.49768987e-02f, -1.76654123e-02f,
  -1.53081343e-01f, 6.16567209e-02f, -1.47383317e-01f, 8.74997154e-02f, -5.00700288e-02f, 1.33676138e-02f, -5.98131828e-02f, -7.23757073e-02f, 1.88524229e-03f, 2.21095569e-02f,
  -1.76160634e-02f, -4.20389883e-02f, 6.45120349e-03f, 4.72843610e-02f, 1.24477339e-03f, -8.06171745e-02f, 3.81744839e-02f, 2.15175375e-02f, 1.10332118e-02f, -2.65725292e-02f,
  4.81145084e-02f, -1.07769474e-01f, -1.22702517e-01f, -6.58320338e-02f, 1.90157946e-02f, -8.55391547e-02f, 5.06124832e-02f, 1.21539896e-02f, 1.95402615e-02f, -1.75190046e-01f,
  -4.28672671e-01f, 1.86212748e-01f, 2.01254804e-02f, 8.28595890e-04f, 1.90606639e-01f, 2.77566276e-02f, 2.13153377e-01f, 7.08221737e-03f, -7.03887120e-02f, 1.86757609e-01f,
  7.35115185e-02f, -1.65363178e-01f, -8.72867648e-03f, -1.54460117e-01f, -5.83182126e-02f, 1.73274070e-01f, 6.82672784e-02f, -1.27891690e-01f, -2.92147279e-01f, -2.89665852e-02f,
  -5.20312339e-02f, -1.64602678e-02f, -1.25717416e-01f, -1.42186865e-01f, 1.46061406e-01f, 9.23434049e-02f, 1.71806008e-01f, -1.95400137e-02f, 1.60683632e-01f, 1.71065360e-01f,
  5.57163134e-02f, -4.06627692e-02f, -2.63735428e-02f, -8.44315812e-02f, 2.22620498e-02f, -6.59634918e-02f, -1.00571103e-02f, 2.39885896e-02f, -5.11216596e-02f, 6.35046437e-02f,
  7.77431428e-02f, 1.52233010e-02f, -4.88540158e-02f, -3.74199415e-04f, 2.62585152e-02f, 3.97493178e-03f, -7.67765045e-02f, -8.35804269e-02f, -7.96234384e-02f, 3.34134325e-02f,
  9.58196670e-02f, 5.32671846e-02f, 5.19558974e-02f, -3.29813138e-02f, -5.51552959e-02f, 2.10892577e-02f, 8.33353773e-02f, -8.59073773e-02f, -8.75891745e-02f, 1.64038744e-02f,
  -1.42481085e-03f, -1.05620222e-02f, -4.26623859e-02f, 4.38370073e-04f, -3.49405110e-02f, -1.33996354e-02f, 3.32683772e-02f, -1.66894905e-02f, -1.91704389e-02f, 2.53639277e-02f,
  -2.69711800e-02f, 4.25745063e-02f, -5.85069582e-02f, 1.02811921e-02f, 6.99058990e-04f, 8.32292587e-02f, -5.17494753e-02f, 7.41047934e-02f, -5.05363345e-02f, 2.65403762e-02f,
  -1.99656747e-03f, -4.09428254e-02f, 5.90859242e-02f, 4.56287973e-02f, 7.15570897e-03f, 5.40605141e-03f, -6.50891215e-02f, 1.49112358e-03f, -7.24118054e-02f, 1.81928873e-02f,
  -1.73103120e-02f, -6.30944520e-02f, -2.07587108e-02f, -4.16915603e-02f, 5.54991961e-02f, 7.86038861e-02f, 5.61719351e-02f, -1.83945373e-02f, 1.13442928e-01f, 3.45800854e-02f,
  -7.00886622e-02f, -2.73023285e-02f, -1.77120157e-02f, -4.39050421e-02f, -8.29558298e-02f, 4.23665829e-02f, 1.03386797e-01f, 6.28360268e-03f, -4.85887518e-03f, 4.09591272e-02f,
  7.71356076e-02f, -5.16355969e-02f, -1.49403557e-01f, 2.84455996e-02f, 1.94320120e-02f, -1.18374296e-01f, -8.37561861e-03f, 1.53111927e-02f, -7.86412135e-02f, 8.13939571e-02f,
  2.93575227e-01f, -2.08185822e-01f, -1.30749941e-01f, -6.95475377e-03f, -1.08565465e-01f, 5.90282194e-02f, -1.21376351e-01f, 5.02319708e-02f, 3.51022705e-02f, -6.58487007e-02f,
  3.09681762e-02f, 1.71724841e-01f, 4.33780178e-02f, 2.77883261e-02f, 9.82052926e-03f, -2.37132192e-01f, -2.71505952e-01f, -5.50658666e-02f, 2.08182454e-01f, 1.41535103e-01f,
  -3.73915248e-02f, 2.11416539e-02f, 4.25355993e-02f, -6.69052824e-03f, -1.77263945e-01f, 3.03369761e-02f, -1.78454608e-01f, -3.67155485e-02f, -3.42137367e-03f, -2.34677210e-01f,
  2.10495815e-01f, 3.75436768e-02f, 2.60984879e-02f, 1.84888039e-02f, 2.85961479e-02f, 1.01991355e-01f, 7.65136117e-03f, 5.87886088e-02f, -3.39709893e-02f, -2.82892361e-02f,
  -9.00490396e-03f, -2.73782518e-02f, 1.24807572e-02f, -7.49002174e-02f, -1.38677750e-02f, -2.47869939e-02f, -4.65710387e-02f, -8.74141902e-02f, 4.82154377e-02f, 4.10717689e-02f,
  -1.16734199e-01f, -6.59512356e-02f, 6.96970895e-02f, -8.58636424e-02f, -8.75158831e-02f, -1.76763590e-02f, 2.36245114e-02f, -3.31743108e-03f, 5.16685247e-02f, -1.10931858e-01f,
  -3.97738535e-03f, 3.16030085e-02f, -3.95091157e-03f, -1.32570751e-02f, -2.47088578e-02f, -2.48450898e-02f, -4.95568896e-03f, -2.17709057e-02f, -2.53230352e-02f, -1.83776934e-02f,
  1.11591378e-02f, -3.52999158e-02f, 8.92692432e-03f, 4.31089401e-02f, -4.75126989e-02f, -1.80019103e-02f, -5.89465350e-03f, 7.14654289e-03f, 1.44880498e-02f, -9.01012868e-03f,
  -4.38289009e-02f, 5.10709174e-02f, -1.04005972e-03f, -1.22250915e-02f, -3.11987195e-02f, -5.06875776e-02f, -1.84015706e-02f, -7.08576813e-02f, -6.98530721e-03f, -5.18942699e-02f,
  2.59425282e-01f, -4.24789963e-03f, 1.30261033e-04f, 3.48795801e-02f, -1.65021587e-02f, 3.28679085e-02f, -1.98353697e-02f, -1.97986364e-02f, 3.71716321e-02f, -2.45718937e-02f,
  9.37601998e-02f, 1.41424432e-01f, -3.13849971e-02f, 2.56170146e-02f, 3.18641849e-02f, -1.01118321e-02f, -2.79672928e-02f, 8.72979686e-02f, -3.74568403e-02f, 1.41978227e-02f,
  -6.26535937e-02f, -1.65688135e-02f, 2.30750039e-01f, 9.55212414e-02f, 1.41652331e-01f, 2.03426480e-01f, 1.69047773e-01f, 4.79425862e-02f, 1.85060501e-01f, 9.96895134e-02f,
  3.36497724e-01f, 6.77269176e-02f, -2.70623207e-01f, 1.58282310e-01f, -5.14914282e-03f, -2.97332436e-01f, -2.63283044e-01f, -7.28396624e-02f, 1.02405749e-01f, 1.09411851e-01f,
  6.34876788e-02f, 2.24229068e-01f, 5.90404272e-02f, 6.17640726e-02f, 5.77874966e-02f, -1.53384671e-01f, 3.77661698e-02f, -9.06277969e-02f, -1.66647062e-01f, -7.63216242e-02f,
  4.95866351e-02f, 7.05211535e-02f, 1.31327868e-01f, 3.16076428e-02f, 1.26991332e-01f, 7.78005943e-02f, -6.93480968e-02f, 9.26879868e-02f, -9.23927128e-02f, 9.40144062e-02f,
  -1.06498599e-01f, 9.95854475e-03f, -9.86022875e-02f, 1.76121388e-02f, -4.25600037e-02f, 7.21162260e-02f, 3.09309587e-02f, -6.69786427e-03f, 5.93717955e-02f, -1.70257315e-02f,
  1.81305837e-02f, 5.53845614e-02f, 1.32885044e-02f, 2.93401666e-02f, -5.59328608e-02f, 6.47463873e-02f, 9.77312848e-02f, -4.62075099e-02f, -3.18807401e-02f, -7.94923231e-02f,
  -1.46027515e-03f, -9.18857083e-02f, -1.14940472e-01f, -1.72489375e-01f, 2.02518655e-03f, 1.85778122e-02f, -7.60198906e-02f, 4.30297628e-02f, -1.30011246e-01f, 7.88099393e-02f,
  -1.35510881e-02f, -1.84204075e-02f, -4.14567515e-02f, -4.11044508e-02f, 2.59103253e-02f, -4.57816459e-02f, -7.14023709e-02f, 2.32431870e-02f, 5.09814639e-03f, -5.22166416e-02f,
  5.25616035e-02f, -2.14627422e-02f, 5.20693921e-02f, -2.10046843e-02f, 4.75375243e-02f, -7.66171142e-02f, -5.55158593e-02f, 2.18361430e-02f, 1.58714945e-03f, 2.40079835e-02f,
  -5.03791263e-03f, -3.92959677e-02f, -7.44878650e-02f, -1.19483296e-03f, 4.45441827e-02f, 5.83611466e-02f, 4.16505150e-02f, 1.31065520e-02f, 4.69200872e-02f, -1.35277631e-02f,
  1.37489319e-01f, -1.61927760e-01f, 1.30923823e-01f, 1.34022636e-02f, -6.50847622e-04f, -2.10519787e-02f, 6.59684017e-02f, -2.19723079e-02f, 3.91894206e-02f, 1.53231909e-02f,
  -4.66805175e-02f, -4.21559922e-02f, 2.58008838e-02f, -5.74343093e-02f, 2.77360491e-02f, -8.20219442e-02f, 2.50084717e-02f, 5.96566685e-02f, 1.04753617e-02f, 9.47600976e-02f,
  3.57963331e-02f, -4.86997031e-02f, 7.08036050e-02f, 2.26225220e-02f, 1.83644649e-02f, -8.18915069e-02f, -4.70657796e-02f, -1.65248592e-03f, -5.41645810e-02f, 9.97706354e-02f,
  -3.49440463e-02f, -5.19969985e-02f, -7.49763474e-02f, -7.38308057e-02f, -7.59585435e-03f, -1.11109197e-01f, -1.08939230e-01f, -7.98757076e-02f, -4.94883815e-03f, -2.21264195e-02f,
  4.04028073e-02f, -1.55845275e-02f, 9.62660164e-02f, 8.92184973e-02f, 7.11149871e-02f, -4.89938147e-02f, 9.19074491e-02f, 3.93058807e-02f, 1.20100871e-01f, -7.38252886e-03f,
  5.73386773e-02f, 1.97900105e-02f, 4.77853715e-02f, 1.05777971e-01f, -6.83091879e-02f, 9.95483156e-03f, -3.46582197e-02f, -5.68605810e-02f, 6.46309033e-02f, -4.36014645e-02f,
  -1.45336300e-01f, 1.35703702e-02f, -1.16119506e-02f, 1.30858377e-01f, 2.23319735e-02f, -4.26170230e-03f, 1.79302634e-03f, 7.40998015e-02f, 7.07590580e-02f, 4.32294756e-02f,
  -1.80394016e-03f, 3.74930501e-02f, 6.11913092e-02f, 4.52353656e-02f, -6.36612251e-02f, 2.97451150e-02f, 2.06316411e-02f, 3.12993415e-02f, 9.05952752e-02f, -6.17197268e-02f,
  2.12918259e-02f, 9.36294906e-03f, -4.56316136e-02f, -7.13064073e-05f, 1.65131420e-01f, 1.61349788e-01f, -5.09964749e-02f, 1.22023948e-01f, 1.32730901e-01f, -8.26170743e-02f,
  -3.20939869e-02f, -2.33621076e-02f, -4.85586971e-02f, -4.82393466e-02f, -1.25063332e-02f, 3.49460877e-02f, 3.10627166e-02f, -4.17784713e-02f, -4.15667845e-03f, -2.44447403e-02f,
  2.79074181e-02f, -4.34636101e-02f, 5.87840788e-02f, 1.74514912e-02f, -3.82059291e-02f, 5.51526994e-02f, -7.76687562e-02f, 1.86469369e-02f, -2.11715046e-02f, 6.67406842e-02f,
  -3.13488729e-02f, -2.17279587e-02f, -3.13911848e-02f, -1.60127934e-02f, 8.74857679e-02f, -3.24975587e-02f, -2.15200265e-03f, 4.85811643e-02f, -2.77502239e-02f, -2.60207467e-02f,
  -2.82542855e-01f, 2.05412507e-01f, 2.91567924e-03f, 4.10045609e-02f, 4.44887094e-02f, 2.16911975e-02f, -3.97830866e-02f, 6.34899810e-02f, 7.63180479e-02f, -7.92175531e-02f,
  8.14892948e-02f, 2.51991358e-02f, -8.76037329e-02f, -1.13339014e-02f, -1.52371721e-02f, -4.61646952e-02f, 2.35521141e-02f, -2.79804617e-02f, -1.17463181e-02f, 6.71709925e-02f,
  -2.30043996e-02f, -2.65421234e-02f, -6.52519837e-02f, 1.02534276e-02f, 6.00968599e-02f, 1.93730241e-03f, -4.78887223e-02f, -9.04168859e-02f, -7.71477968e-02f, -1.88988134e-01f,
  1.47125423e-01f, 3.84410083e-01f, 1.18469089e-01f, -2.05242969e-02f, -7.69631797e-03f, -1.60421476e-01f, -6.74080523e-03f, -1.03383563e-01f, -2.75455173e-02f, 1.64720237e-01f,
  6.09319508e-02f, -1.84170038e-01f, -5.80414608e-02f, -5.96114695e-02f, -3.17084938e-02f, 7.00029284e-02f, 2.06741113e-02f, -1.35080248e-01f, -3.35074872e-01f, -3.06461424e-01f,
  -1.41317800e-01f, 8.16294849e-02f, 2.11623646e-02f, 3.16082388e-02f, 1.57614842e-01f, -2.89124846e-02f, 2.05727413e-01f, 2.04434350e-01f, 1.47674024e-01f, 1.41198725e-01f,
  -1.66671872e-02f, 1.54189318e-01f, -9.69817787e-02f, -5.61575368e-02f, 1.16717100e-01f, 6.56452402e-02f, -6.09066635e-02f, 8.87716711e-02f, 1.63384378e-02f, -1.34626764e-03f,
  4.94352393e-02f, -3.80830131e-02f, 2.38636993e-02f, -1.66001648e-03f, 3.97625417e-02f, -1.13115728e-01f, 9.33085531e-02f, -2.68484689e-02f, -2.20200904e-02f, -3.71336378e-02f,
  -1.98876206e-03f, -6.20520767e-03f, -4.47333641e-02f, -4.92844135e-02f, 2.57279724e-02f, -1.75842568e-01f, 1.20795287e-01f, 5.99634508e-03f, -1.95986442e-02f, 1.77557573e-01f,
  -2.24785190e-02f, 4.10333984e-02f, 1.09913098e-02f, 6.39977008e-02f, -5.46227656e-02f, 7.94735476e-02f, -3.01251449e-02f, 6.09569661e-02f, -1.13779157e-02f, 6.41258731e-02f,
  -6.10785745e-02f, 9.86746885e-03f, 1.32004377e-02f, 2.40929611e-02f, -5.83185926e-02f, 3.28849815e-02f, -2.56164428e-02f, -1.74776632e-02f, -2.28300542e-02f, -5.13627976e-02f,
  -5.06687276e-02f, -7.13136047e-03f, 1.67207215e-02f, -6.20285720e-02f, 9.97408293e-03f, 1.63908768e-02f, -1.77998133e-02f, -6.72102794e-02f, 3.57729085e-02f, 2.38945186e-02f,
  -5.39718233e-02f, -6.32622391e-02f, -5.15325516e-02f, -7.78318942e-02f, -2.18585506e-02f, -3.34637687e-02f, -6.89340755e-03f, -3.91763672e-02f, 3.35033387e-02f, -6.39163107e-02f,
  -2.49924473e-02f, 1.87083725e-02f, 5.32787815e-02f, -2.33621597e-02f, -1.18073940e-01f, -3.83020453e-02f, 1.67911444e-02f, -6.48806021e-02f, -1.33166835e-01f, 9.36798344e-04f,
  2.11524088e-02f, -1.31045654e-01f, -2.31264532e-01f, -1.06885739e-01f, -6.81658164e-02f, -2.04544559e-01f, -1.10901438e-01f, -9.31385010e-02f, -2.19695628e-01f, -1.77719269e-03f,
  4.68643188e-01f, -2.34996397e-02f, -9.03898031e-02f, 1.73815146e-01f, 3.09622250e-02f, -2.54943278e-02f, 3.01700886e-02f, 5.52933328e-02f, 1.32401034e-01f, -1.58655774e-02f,
  -1.00929745e-01f, -9.64658409e-02f, 1.41111072e-02f, 3.33769247e-02f, -4.32744846e-02f, 9.85480323e-02f, 5.63017093e-02f, 1.04422010e-01f, 7.40084723e-02f, 1.94747299e-02f,
  2.38941573e-02f, 9.28830206e-02f, 2.00447902e-01f, 9.51576903e-02f, 4.76653986e-02f, 4.24404182e-02f, -1.00722268e-01f, -9.50513314e-03f, -8.34467188e-02f, -1.24782406e-01f,
  -1.77285433e-01f, 9.41997468e-02f, 6.05659597e-02f, 3.84213962e-02f, -1.01871649e-02f, 4.85261306e-02f, 1.05797185e-03f, -4.86009568e-02f, -5.81175834e-02f, -6.54565170e-02f,
  2.59601362e-02f, -6.36716411e-02f, 3.64439115e-02f, -7.48282373e-02f, 1.20576821e-01f, 8.58815238e-02f, 1.74724273e-02f, 9.02619287e-02f, 5.90791069e-02f, 7.31837079e-02f,
  3.89384432e-03f, -2.09120219e-03f, -8.07633996e-03f, 1.50715029e-02f, 3.38905342e-02f, -6.67796209e-02f, -7.33614266e-02f, 5.84888086e-02f, 3.22878957e-02f, 9.02248919e-03f,
  -2.61134114e-02f, 6.05112268e-03f, -2.21052859e-03f, -1.78678203e-02f, -1.56555381e-02f, -1.71439573e-02f, -6.17965125e-02f, -1.71503071e-02f, 7.70722330e-02f, 2.90111247e-02f,
  5.34664430e-02f, 2.83234250e-02f, -2.09601000e-02f, -4.92397808e-02f, -5.09698270e-03f, -2.49838736e-02f, 4.86337356e-02f, 7.13621872e-03f, 2.65033226e-02f, -2.58384086e-02f,
  9.05267969e-02f, 1.03142532e-02f, 6.88368827e-02f, 6.84393644e-02f, -6.89721033e-02f, -9.38328803e-02f, 1.80990454e-02f, 1.61648244e-02f, -1.33630149e-02f, 9.99251232e-02f,
  2.08262075e-02f, -8.17084610e-02f, -2.11881436e-02f, 1.55859506e-02f, 3.48131061e-02f, -2.13562045e-02f, 8.20419565e-02f, -4.94064502e-02f, -3.37872654e-02f, 2.80185584e-02f,
  4.37472425e-02f, -5.82661144e-02f, -1.04307560e-02f, 7.39086792e-02f, 3.25772688e-02f, -4.28703129e-02f, -1.48613974e-02f, 4.34826240e-02f, 1.08472906e-01f, -5.14996611e-03f,
  1.17533408e-01f, 1.48158386e-01f, 2.22397014e-01f, 1.97438300e-02f, 2.67457310e-02f, 8.65109339e-02f, -6.33636713e-02f, -2.46503614e-02f, 3.95505726e-02f, 1.95290446e-01f,
  1.18443340e-01f, 1.72661588e-01f, 1.81387678e-01f, 9.10836086e-02f, 8.77662078e-02f, 5.12039736e-02f, 2.55314261e-01f, 6.58601075e-02f, -3.05482745e-02f, -1.34687014e-02f,
  -1.31118789e-01f, -1.64778277e-01f, -1.40674546e-01f, -1.10294513e-01f, 6.74506575e-02f, 1.82773709e-01f, 1.37527302e-01f, 7.95796886e-02f, 2.99318321e-02f, -8.29915553e-02f,
  8.41289386e-02f, 4.23795469e-02f, -3.93358283e-02f, 2.00924017e-02f, 2.59014536e-02f, -9.01126415e-02f, 7.31760487e-02f, -5.18845804e-02f, 2.45191585e-02f, 1.66424081e-01f,
  -4.32629809e-02f, 5.23764603e-02f, 6.50956109e-03f, -1.00700773e-01f, -9.15843472e-02f, -1.69928782e-02f, -2.85126530e-02f, -1.24442996e-02f, -4.67109010e-02f, 1.12159610e-01f,
  -1.80040002e-02f, -5.58792427e-02f, 1.03321504e-02f, -3.05867698e-02f, 4.54754941e-02f, -1.36567317e-02f, 4.96383803e-03f, 3.51972133e-02f, -4.65839095e-02f, -7.02634677e-02f,
  -5.79257384e-02f, -2.55063139e-02f, -9.16825011e-02f, -7.58686885e-02f, 4.09618318e-02f, -8.20469558e-02f, -1.27360180e-01f, 9.75774880e-03f, -1.57953396e-01f, 1.30394444e-01f,
  2.34717317e-02f, -1.44223841e-02f, -2.91717090e-02f, 4.26633134e-02f, 6.76808655e-02f, 1.88138653e-02f, 5.83559200e-02f, -4.57579643e-02f, -6.07722206e-03f, -2.17541214e-02f,
  -2.07197592e-02f, 4.26806174e-02f, 1.89900380e-02f, -1.53316492e-02f, -3.78896110e-02f, -1.40363825e-02f, 6.05495498e-02f, -5.23752682e-02f, 1.60302334e-02f, 2.72547302e-04f,
  -3.50962169e-02f, 7.13165402e-02f, -2.82104276e-02f, -4.62945737e-02f, 6.75617233e-02f, -5.57392389e-02f, -1.25894099e-02f, -7.72234499e-02f, -2.60971580e-03f, -7.05941406e-04f,
  -1.64256208e-02f, -1.76091835e-01f, 9.25040171e-02f, -1.54466266e-02f, -1.08631747e-02f, -7.95179680e-02f, 3.31710577e-02f, 1.77403819e-02f, -3.84953097e-02f, 6.78830780e-03f,
  -4.44008522e-02f, -1.71946771e-02f, 1.45896655e-02f, 5.77336317e-03f, 1.01937383e-01f, 5.94673716e-02f, 5.11151366e-02f, 1.06872609e-02f, -3.17374505e-02f, 5.49338534e-02f,
  8.74698684e-02f, 7.00444803e-02f, 7.75370374e-02f, -1.48059186e-02f, -7.94245005e-02f, 5.20758182e-02f, 6.55050427e-02f, -8.10586661e-03f, 5.67879528e-03f, 2.25672334e-01f,
  -2.73773849e-01f, 1.37349203e-01f, 2.10189715e-01f, -1.46252379e-01f, 6.65648729e-02f, 1.09496042e-01f, 2.87418932e-01f, 9.52453017e-02f, -1.29686505e-01f, 6.99821711e-02f,
  -1.04645990e-01f, -1.07550539e-01f, -1.56789884e-01f, -8.78656190e-03f, 1.21304803e-01f, 2.52521485e-01f, 2.11481214e-01f, 1.13129981e-01f, -7.16705620e-02f, -1.59818158e-02f,
  4.75632548e-02f, -2.25523971e-02f, -1.05845727e-01f, -7.72135481e-02f, 1.20397605e-01f, 2.98516266e-02f, 1.00467563e-01f, 1.08804100e-03f, -2.21044738e-02f, 9.37990248e-02f,
  1.30110696e-01f, -3.31397215e-03f, -5.61896041e-02f, -8.00957996e-03f, -4.08000275e-02f, 6.53202757e-02f, -5.84509037e-02f, -4.94065545e-02f, -9.94142294e-02f, 1.13429234e-03f,
  -6.87333196e-02f, 2.68205837e-03f, -6.14098571e-02f, -5.22245914e-02f, 7.53637478e-02f, 6.07925169e-02f, -8.53690505e-03f, 4.93672639e-02f, 9.47262421e-02f, 4.46168259e-02f,
  5.12993559e-02f, -2.57285982e-02f, 1.97038539e-02f, 6.51220232e-02f, -3.59631889e-02f, -9.40480754e-02f, 8.37236196e-02f, 2.16068309e-02f, -3.81200276e-02f, 4.12748866e-02f,
  5.42528592e-02f, -4.66851369e-02f, 3.28632668e-02f, -1.73126697e-03f, -7.46702822e-03f, 9.78125166e-03f, -1.14940088e-02f, 9.18454602e-02f, -6.67090202e-03f, -3.15497182e-02f,
  9.01767146e-03f, -1.88931283e-02f, -9.99083742e-03f, 2.40402706e-02f, -1.75407995e-03f, 5.21052964e-02f, 3.72689702e-02f, 1.74388923e-02f, 1.93146728e-02f, 1.69653296e-02f,
  -7.20781386e-02f, 3.99060920e-03f, 7.52648339e-02f, -4.56508435e-02f, -6.85494673e-03f, 6.42809123e-02f, 1.16248867e-02f, -1.30276540e-02f, -3.34641151e-02f, -9.63404402e-02f,
  -1.40781060e-01f, -1.54343039e-01f, 3.95345762e-02f, 5.29281609e-02f, 7.20209163e-03f, -5.07170074e-02f, -3.24156582e-02f, 8.32915865e-03f, -1.03462569e-01f, -1.37864705e-02f,
  2.11363472e-02f, -1.28396358e-02f, 2.64813863e-02f, -2.39131209e-02f, 2.05289982e-02f, -9.69234202e-03f, 3.52910012e-02f, -9.44967475e-03f, -1.25404960e-03f, 5.08380197e-02f,
  -7.83508085e-03f, 9.18260738e-02f, 1.84777863e-02f, 4.07529771e-02f, 5.59841357e-02f, -1.04725048e-01f, 4.50138710e-02f, -4.00181971e-02f, -2.80410927e-02f, 1.99121442e-02f,
  1.71189308e-01f, 5.53257614e-02f, -8.51266757e-02f, 1.64317340e-01f, -4.19077463e-02f, -7.55516812e-02f, -1.25085488e-01f, -1.39481425e-01f, -1.56974196e-02f, 8.24638680e-02f,
  -9.79310349e-02f, -6.97686747e-02f, 2.02280600e-02f, 6.52084779e-03f, -3.78809404e-03f, 3.27869039e-03f, 1.41237006e-01f, 1.44769132e-01f, -3.47187109e-02f, -1.79834198e-02f,
  3.11358273e-02f, 1.20971926e-01f, 9.84474197e-02f, -7.56916590e-03f, 4.69197929e-02f, -3.76300998e-02f, 3.31444815e-02f, 4.89976667e-02f, 5.63178770e-03f, 7.16138110e-02f,
  -2.13301722e-02f, -5.30039966e-02f, -7.16448873e-02f, 6.92654476e-02f, -6.77550957e-02f, -8.19448829e-02f, 3.43680345e-02f, 3.02951597e-02f, -4.62653898e-02f, 5.57180792e-02f,
  -6.53991774e-02f, 2.62622591e-02f, -3.15426290e-02f, 6.11403286e-02f, 5.57835698e-02f, -2.70131994e-02f, 4.09781300e-02f, 5.71769429e-03f, -7.85267651e-02f, -1.55910943e-02f,
  7.99031034e-02f, 1.86149124e-02f, -1.53452316e-02f, -2.53536329e-02f, -1.77985188e-02f, 3.50049138e-02f, 7.88855087e-03f, -1.38955906e-01f, -8.38134065e-02f, 2.10139155e-02f,
  5.58259115e-02f, -6.66281059e-02f, 6.19057799e-03f, -1.04672993e-02f, -6.48530480e-03f, 7.76522532e-02f, -2.46735439e-02f, 6.15570182e-03f, -7.64663815e-02f, 1.03413649e-01f,
  -6.60144016e-02f, 3.18813697e-02f, -2.62176003e-02f, -4.01922166e-02f, -1.21209668e-02f, 5.92150018e-02f, -1.03802951e-02f, 1.87639631e-02f, -2.63821962e-03f, -2.34593693e-02f,
  -1.45973507e-02f, 9.23255272e-03f, -1.02200443e-02f, 3.99246402e-02f, -6.66140839e-02f, -4.22385633e-02f, -5.18561639e-02f, -2.29046941e-02f, 6.91677779e-02f, 5.39956056e-02f,
  6.90100193e-02f, 2.42149606e-02f, 2.00102497e-02f, -8.30016937e-03f, 5.62514365e-02f, -3.45046222e-02f, 1.67974215e-02f, 1.41760160e-03f, 6.67842925e-02f, -4.29801270e-02f,
  2.28473358e-02f, 3.15776691e-02f, 5.17885499e-02f, -3.51030119e-02f, 5.58212660e-02f, 8.49064812e-03f, 1.11551002e-01f, 7.53363520e-02f, 2.50421315e-02f, -2.55297702e-02f,
  8.33756402e-02f, -3.40651497e-02f, 8.44637081e-02f, -7.69641548e-02f, 2.96158362e-02f, 8.56047422e-02f, -1.32896751e-02f, -6.66870922e-02f, -9.16640833e-02f, 1.32155627e-01f,
  3.57350618e-01f, -1.47160769e-01f, 7.43516535e-03f, 1.31686497e-02f, -1.54274464e-01f, 1.45248875e-01f, 1.75932944e-02f, 4.86689918e-02f, -2.67467052e-02f, -4.61415462e-02f,
  -9.78647619e-02f, -1.36959389e-01f, -5.41501753e-02f, 1.47126568e-02f, 1.79763392e-01f, 6.29271334e-03f, -6.91542253e-02f, 1.72205076e-01f, 2.67724931e-01f, 7.78276995e-02f,
  -2.79975533e-02f, 1.96592715e-02f, 1.78946778e-01f, 1.19573399e-01f, -1.64415732e-01f, -1.42723173e-01f, -9.25429836e-02f, -1.22361414e-01f, -2.17256323e-02f, -3.00431341e-01f,
  -2.35591292e-01f, -2.91005126e-03f, 5.73473535e-02f, -7.02298433e-02f, -7.42134079e-02f, 7.54437596e-02f, -2.06471086e-02f, -2.49988157e-02f, 2.51164082e-02f, 1.21761272e-02f,
  -6.00878559e-02f, 6.57575876e-02f, -8.84698927e-02f, 1.70771182e-02f, -6.12719059e-02f, 6.53460100e-02f, 3.23906355e-02f, 1.33906469e-01f, -3.51226926e-02f, 1.46991573e-02f,
  -1.82850212e-01f, 8.62952974e-03f, 7.80188441e-02f, -9.77322925e-03f, 1.11031488e-01f, 5.38697988e-02f, -1.73421036e-02f, 4.34066877e-02f, 3.69280353e-02f, -1.63283870e-02f,
  2.60021351e-02f, -4.58380990e-02f, 2.03899462e-02f, 5.66294342e-02f, -2.94083562e-02f, 4.79327738e-02f, 4.58855256e-02f, -5.98361120e-02f, -1.96260680e-02f, -7.14929821e-03f,
  -2.27189977e-02f, 3.98130268e-02f, -3.30600441e-02f, 1.36478106e-03f, -2.71142721e-02f, -3.57775413e-03f, 3.74172963e-02f, -3.43398154e-02f, -4.57113460e-02f, 3.35429385e-02f,
  -5.09509593e-02f, 1.00992061e-02f, -2.75499690e-02f, 3.03487983e-02f, 1.11265313e-02f, 2.69980803e-02f, -1.95592530e-02f, -4.03541960e-02f, -3.95461209e-02f, 1.76310614e-02f,
  -1.49743825e-01f, 1.15059577e-01f, -2.37410516e-02f, 5.45535944e-02f, -2.90820729e-02f, 9.04148538e-03f, 2.72685271e-02f, -7.32651353e-02f, -4.20541354e-02f, -2.00829785e-02f,
  -8.11629668e-02f, -3.32279541e-02f, 1.00870514e-02f, -9.37953517e-02f, 5.67553081e-02f, 2.32512206e-02f, -7.90963918e-02f, -3.70892021e-03f, 4.75777872e-02f, -9.14218351e-02f,
  -6.39950857e-02f, 1.03264175e-01f, 3.85505147e-02f, -1.56516843e-02f, -1.49412518e-02f, 3.47106606e-02f, -1.98167358e-02f, 6.86023459e-02f, 1.72234014e-01f, -1.45139797e-02f,
  -3.47189665e-01f, 7.17924302e-03f, 1.78340495e-01f, -1.80949718e-01f, 8.64622891e-02f, 1.11954235e-01f, 2.15173990e-01f, 9.18656737e-02f, -4.07866649e-02f, 1.01905204e-02f,
  1.15083233e-01f, -1.79935135e-02f, -6.51613623e-02f, 7.59359747e-02f, 5.35956360e-02f, 5.41247502e-02f, -5.54053858e-03f, -2.02599466e-01f, 3.74320187e-02f, 1.03707775e-01f,
  -1.24877594e-01f, -2.09029287e-01f, -1.47797972e-01f, -7.80372918e-02f, -1.12098619e-01f, 1.18496139e-02f, -5.34638800e-02f, 4.87888120e-02f, 5.38330385e-03f, -1.33235306e-01f,
  2.26614967e-01f, 5.00656888e-02f, 7.70826116e-02f, -6.19001240e-02f, 7.86319301e-02f, -1.26282752e-01f, -1.81463752e-02f, -4.53486061e-03f, 4.84179631e-02f, 3.71030755e-02f,
  -6.13629594e-02f, -5.61305583e-02f, -7.22426549e-02f, 7.74563402e-02f, -6.33339807e-02f, -2.53634341e-02f, 3.03253364e-02f, -1.00879766e-01f, -2.50370335e-02f, 8.79393220e-02f,
  2.51478311e-02f, 1.83371641e-02f, 5.98705709e-02f, 8.83096308e-02f, -9.42587107e-03f, -2.35155169e-02f, 5.67494817e-02f, -1.30253760e-02f, 1.09800324e-01f, -1.18811123e-01f,
  -2.97574140e-02f, 9.63357929e-03f, 9.63619724e-03f, 1.27090057e-02f, 2.82512940e-02f, 4.93526570e-02f, -5.67617863e-02f, -2.76141260e-02f, 5.18450513e-02f, -6.85506165e-02f,
  9.73711908e-03f, 6.28724545e-02f, -1.14804655e-02f, -1.67290848e-02f, 5.64885549e-02f, -1.93172190e-02f, -3.37915234e-02f, -3.00880130e-02f, 3.00883967e-02f, 1.37326028e-02f,
  -8.27040970e-02f, 5.56574836e-02f, -7.14824796e-02f, -3.37151811e-02f, 3.13081890e-02f, -4.60818484e-02f, -4.41548005e-02f, 7.98711851e-02f, 6.78964481e-02f, 5.46396896e-02f,
  4.85636815e-02f, 1.17347296e-02f, -1.07366875e-01f, -3.29895467e-02f, 2.16331463e-02f, -9.94544998e-02f, 9.30573270e-02f, -6.11248389e-02f, -1.11611038e-02f, 2.07253620e-02f,
  9.47521031e-02f, -7.55759403e-02f, 4.78170775e-02f, 2.51635779e-02f, -6.00271039e-02f, 2.64700726e-02f, -3.13219987e-02f, -3.48973386e-02f, 3.45896333e-02f, 2.29463167e-02f,
  -2.93654501e-02f, -1.52868982e-02f, -4.96962946e-03f, 5.17703816e-02f, -8.33444763e-03f, -1.23615470e-02f, 1.35500059e-01f, 5.33833988e-02f, 6.20632507e-02f, -4.97393049e-02f,
  -1.75535098e-01f, -8.86823311e-02f, -6.82561696e-02f, -2.93436218e-02f, -2.15466656e-02f, -5.76504692e-02f, -1.61152840e-01f, -7.85382465e-02f, -3.21657658e-02f, -4.80470657e-02f,
  -5.55097051e-02f, -6.75744414e-02f, -7.31387436e-02f, -6.02990948e-02f, 2.68495604e-02f, -3.25071514e-02f, -4.58127819e-02f, -8.58670324e-02f, 2.54850481e-02f, -8.46047103e-02f,
  -9.67339277e-02f, -4.14821096e-02f, 1.78644247e-02f, -8.91364217e-02f, -3.93256126e-03f, 3.23662646e-02f, -1.00750081e-01f, -5.72442859e-02f, 3.19029018e-02f, -9.23687294e-02f,
  -1.99530214e-01f, -6.14555106e-02f, -3.51187848e-02f, 9.94981080e-02f, 1.62647106e-02f, -8.57706890e-02f, 6.58159656e-03f, 1.08709924e-01f, 6.83713481e-02f, 3.88196893e-02f,
  2.76917722e-02f, 8.82349238e-02f, 2.83468347e-02f, -6.70529604e-02f, -2.81349123e-02f, 5.26833721e-02f, -5.07988110e-02f, -1.58740208e-02f, -4.01903689e-02f, -1.62002072e-02f,
  6.90154284e-02f, -4.58713574e-03f, -1.06853303e-02f, -3.85761075e-02f, -1.97533723e-02f, -8.32149237e-02f, 9.87772737e-03f, 1.12537764e-01f, 9.58154202e-02f, 2.18833890e-02f,
  -5.36616966e-02f, -6.09053895e-02f, 1.01939228e-03f, -2.50177346e-02f, 3.23922746e-02f, 7.57651869e-03f, 5.87699339e-02f, 2.49122512e-02f, -6.67561889e-02f, 7.72436857e-02f,
  -1.01915151e-02f, 2.49147732e-02f, -7.53042474e-02f, 1.38814487e-02f, 3.10712233e-02f, 1.35188736e-02f, 5.24767488e-02f, 7.95401819e-03f, -6.10609865e-03f, 1.63870323e-02f,
  -5.83242141e-02f, 5.56936339e-02f, 7.39040747e-02f, -8.54492188e-03f, 6.72179449e-04f, -6.68982416e-03f, -6.62034899e-02f, -6.22879006e-02f, 3.80454883e-02f, 7.10600428e-03f,
  -9.83403847e-02f, -6.32433742e-02f, 3.11225038e-02f, -8.19715261e-02f, 3.41507196e-02f, -4.30964828e-02f, 5.68295792e-02f, -2.91441865e-02f, 2.71434337e-02f, -1.08342782e-01f,
  2.68864501e-02f, -1.39019797e-02f, -4.69382387e-03f, -7.65159901e-04f, -6.92349076e-02f, 8.60344693e-02f, 1.02173574e-01f, -1.00132905e-01f, 8.95258114e-02f, 7.41548911e-02f,
  9.47029218e-02f, -5.19326609e-03f, 5.12462333e-02f, -4.18467224e-02f, 4.92804833e-02f, -1.10177957e-02f, 2.92901080e-02f, -9.61559545e-03f, 5.98287163e-03f, -3.96306962e-02f,
  7.00642541e-03f, -3.86763513e-02f, -7.71463960e-02f, -1.73709411e-02f, 3.86267714e-02f, 1.39236584e-01f, 9.80520472e-02f, 1.91965625e-01f, 2.38879826e-02f, 6.35625646e-02f,
  -1.56095967e-01f, -1.38684601e-01f, -9.65309292e-02f, -5.22054695e-02f, 5.87759987e-02f, 2.46591736e-02f, 1.10589318e-01f, 7.92864114e-02f, 1.70468956e-01f, 1.65831566e-01f,
  -2.28973981e-02f, 3.24593447e-02f, -5.30672912e-03f, 2.61325706e-02f, -1.37835398e-01f, 5.78026474e-03f, -6.06325082e-02f, -9.67359170e-02f, -9.94826928e-02f, -1.94269881e-01f,
  -2.28687659e-01f, -1.89969048e-01f, 1.18460961e-01f, -1.90388691e-02f, -2.17378624e-02f, 4.98419330e-02f, -1.64907239e-02f, -4.94785085e-02f, 7.28422552e-02f, 5.74578978e-02f,
  -3.61372642e-02f, 9.70417808e-04f, 1.06544495e-02f, 1.66887399e-02f, 5.03835268e-02f, 9.00164172e-02f, 3.69380563e-02f, 1.82739086e-02f, 9.77774500e-04f, -2.14154902e-03f,
  -5.95391952e-02f, -1.63007647e-01f, 3.67754139e-02f, -1.24550220e-02f, 2.90070404e-03f, 1.26030939e-02f, -1.39057919e-01f, -7.51280040e-02f, 1.20642530e-02f, 5.41539863e-02f,
  1.91208441e-02f, -5.83040528e-03f, 3.11230123e-02f, 5.87880425e-02f, 8.45539123e-02f, 7.44192116e-03f, -2.10361113e-03f, 3.66034098e-02f, 2.99944431e-02f, 5.88312373e-02f,
  -2.89494041e-02f, -7.95445591e-02f, 4.74283844e-02f, 1.32567454e-02f, 1.02390926e-02f, -5.84852183e-03f, 2.24343129e-02f, 1.51370792e-02f, -6.74376171e-03f, 4.11929414e-02f,
  -7.14569911e-02f, 2.27866992e-02f, -6.43955991e-02f, -2.86206398e-02f, -2.84923683e-03f, 1.31435236e-02f, -1.18701868e-02f, -8.27821866e-02f, 6.13935329e-02f, -4.89304364e-02f,
  1.82971761e-01f, -9.57840681e-02f, 2.04424169e-02f, 1.22440659e-01f, 1.78655963e-02f, 1.00402534e-02f, -6.92785680e-02f, 3.46919484e-02f, -7.29776621e-02f, -2.30445322e-02f,
  1.73362792e-02f, 6.73109815e-02f, -6.79022819e-02f, -1.29480837e-02f, 1.16092324e-01f, 1.09695852e-01f, 2.01879129e-01f, 6.19169772e-02f, -1.24532152e-02f, -4.75496911e-02f,
  1.14072748e-01f, 1.26491338e-01f, 1.88253909e-01f, 1.23099700e-01f, 1.36225708e-02f, 8.48973319e-02f, 1.29582986e-01f, 1.47000864e-01f, 2.06796184e-01f, 3.38699788e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.01399124e-02f, 8.51761624e-02f, 7.70717412e-02f, -6.60166442e-02f, -7.82249048e-02f, 5.52834794e-02f, 1.84098452e-01f, -1.55643634e-02f, -8.22639093e-02f, 1.17298134e-01f,
  4.82356772e-02f, -1.45534173e-01f, 1.10504562e-02f, 8.75311811e-03f, -1.08532898e-01f, 1.27322853e-01f, 9.13573802e-02f, -1.25702262e-01f, -1.36245504e-01f, -7.69396201e-02f,
  -8.51971507e-02f, -1.75287068e-01f, -7.11184889e-02f, -3.89788835e-03f, 4.59598824e-02f, 2.48814989e-02f, -2.50804536e-02f, 1.32357189e-02f, 4.35588770e-02f, -6.72673881e-02f,
  1.46685624e-02f, -5.59819639e-02f, -1.29914299e-01f, -1.34631664e-01f, -2.58222874e-02f, 4.20276932e-02f, 2.67012138e-02f, -8.76451936e-03f, -8.89890343e-02f, -2.52111666e-02f,
  -4.34979275e-02f, 2.89171431e-02f, -9.46059451e-02f, 5.89721687e-02f, -1.16096782e-02f, -5.47862798e-02f, 5.82234077e-02f, -4.02638949e-02f, 5.22219501e-02f, 4.67288010e-02f,
  -7.97691718e-02f, -7.39862351e-03f, 2.45347414e-02f, 1.41695440e-02f, 5.20531088e-02f, -4.17373667e-04f, -9.12066847e-02f, 3.56481746e-02f, -1.08781919e-01f, -7.29831010e-02f,
  -3.60154547e-02f, 1.18611068e-01f, 7.14263832e-03f, -5.89874648e-02f, 1.80459525e-02f, 7.74032474e-02f, -1.85874794e-02f, 4.39058729e-02f, -5.21934368e-02f, 3.90058793e-02f,
  4.37645428e-02f, -1.95651595e-02f, 1.58578740e-04f, 3.86600308e-02f, 1.13702230e-02f, 9.55261886e-02f, -5.80080524e-02f, -1.76104587e-02f, 6.02713563e-02f, -8.53351597e-03f,
  -1.20112840e-02f, 6.54890984e-02f, -2.45510079e-02f, -5.44336550e-02f, -3.84642594e-02f, 5.20745069e-02f, -1.62625443e-02f, 7.16257766e-02f, -7.30862394e-02f, -7.96068013e-02f,
  -1.55660629e-01f, -8.16233680e-02f, 3.21089360e-03f, -6.01808541e-02f, 6.25227690e-02f, 4.28872705e-02f, 5.47457561e-02f, 5.57703823e-02f, 3.72297736e-03f, 6.17685989e-02f,
  7.04582706e-02f, -2.16953307e-02f, 6.61882684e-02f, 7.82411546e-02f, -9.90853459e-02f, 5.03293648e-02f, 4.62193415e-02f, -4.38968204e-02f, -9.98914465e-02f, -5.51082604e-02f,
  -1.77032631e-02f, 2.00955803e-03f, -9.23988521e-02f, -1.94236673e-02f, -6.40801862e-02f, 1.57613158e-02f, 9.18104220e-03f, 3.30573730e-02f, -8.70287195e-02f, -4.44446802e-02f,
  -1.70942336e-01f, 2.10409500e-02f, 1.82919689e-02f, -6.46862239e-02f, 1.19621716e-01f, 5.62822819e-02f, 1.41039252e-01f, 6.36420846e-02f, 3.30894403e-02f, 5.37987165e-02f,
  -1.48883052e-02f, -5.19414954e-02f, 6.91289548e-03f, 1.06027581e-01f, 3.60825732e-02f, 1.23716041e-01f, 1.58289328e-01f, 4.64397632e-02f, -1.35862112e-01f, -3.76450866e-02f,
  1.00301109e-01f, -9.65354685e-03f, -2.10210010e-01f, -7.46354014e-02f, 3.79194245e-02f, 3.47583406e-02f, 3.57790105e-02f, 5.57500534e-02f, 1.00580990e-01f, 1.20307915e-01f,
  -8.61294940e-02f, -1.36331484e-01f, 4.32847515e-02f, -1.71763189e-02f, -9.10306126e-02f, -3.57881039e-02f, -6.39157649e-03f, -7.20315948e-02f, 6.47895411e-02f, -3.22514283e-03f,
  1.52192321e-02f, -9.64006186e-02f, 3.19412298e-04f, -7.44573995e-02f, -1.77684873e-02f, -4.92472164e-02f, -8.45500678e-02f, -3.85837667e-02f, 1.04339449e-02f, -7.62533993e-02f,
  1.27567565e-02f, -8.91886353e-02f, -7.81494975e-02f, 5.67420684e-02f, 5.78627810e-02f, -3.26997903e-03f, -1.10346377e-01f, 5.47703123e-03f, -1.65664092e-01f, -8.74841735e-02f,
  2.11236905e-02f, 4.15751562e-02f, 3.12590376e-02f, -2.22696047e-02f, 5.56439161e-03f, 1.39806625e-02f, 7.48677105e-02f, -7.57736713e-02f, -2.37717889e-02f, -4.48868647e-02f,
  3.01604941e-02f, -2.36180164e-02f, -5.50659932e-02f, -8.25230107e-02f, -5.61628528e-02f, -5.94761707e-02f, 2.57888604e-02f, 4.47647646e-03f, -1.96420643e-02f, -6.47729635e-02f,
  7.57327601e-02f, -4.28084210e-02f, 8.22879001e-03f, 1.13362096e-01f, 8.49170685e-02f, -8.87814313e-02f, -8.82294774e-02f, -3.07515054e-03f, 3.97867262e-02f, -9.00943279e-02f,
  -1.19208813e-01f, -9.04389471e-02f, 1.53787946e-02f, 2.19488656e-03f, -2.27934644e-02f, 4.45459262e-02f, -4.80645038e-02f, 4.92434949e-02f, -4.64398935e-02f, 2.24694461e-02f,
  3.81946526e-02f, 5.65320402e-02f, -7.84998387e-02f, 6.50125518e-02f, -9.74492282e-02f, -9.86102968e-02f, -1.36423577e-02f, 8.10308456e-02f, -7.24675646e-03f, -6.64521307e-02f,
  -5.41633507e-03f, -1.43536493e-01f, -8.54227766e-02f, -8.53751451e-02f, 1.98071636e-02f, -8.36763307e-02f, -2.51943059e-02f, -7.72469789e-02f, -2.88378093e-02f, -1.14614762e-01f,
  -1.25830337e-01f, -5.94246797e-02f, 9.17303655e-03f, -1.00132897e-01f, -1.23410420e-02f, -1.01150587e-01f, -1.96292102e-01f, 3.48241515e-02f, 2.94350050e-02f, -1.10659368e-01f,
  -3.16907465e-02f, -1.03575885e-01f, 9.76587608e-02f, 1.53666973e-01f, 1.66321397e-01f, 7.74086863e-02f, 1.91757549e-02f, 2.22381055e-01f, 1.21061303e-01f, -4.01668511e-02f,
  5.86438924e-02f, -3.90101544e-04f, 6.16814122e-02f, 1.40980288e-01f, 2.80022272e-03f, 2.59411819e-02f, 1.44907460e-01f, 7.29010254e-02f, 1.02793552e-01f, 1.14191934e-01f,
  4.71464507e-02f, 4.31659222e-02f, 1.38167217e-01f, 8.20670873e-02f, -1.62749738e-02f, 1.98610630e-02f, 7.23179989e-03f, 1.30470559e-01f, -1.84180476e-02f, -3.06000914e-02f,
  1.65372044e-02f, -5.28046116e-02f, 3.30574922e-02f, 1.64907693e-03f, -8.61441493e-02f, -2.60527972e-02f, -5.66441612e-03f, 1.29321858e-01f, 8.81424621e-02f, -6.01842590e-02f,
  3.21336724e-02f, -1.00015946e-01f, -4.92681190e-02f, -8.32727849e-02f, -1.87138580e-02f, 9.93088260e-02f, 3.38973850e-02f, 2.03263406e-02f, 3.90063077e-02f, 1.22823147e-02f,
  8.08877964e-03f, 8.56374502e-02f, -7.13658798e-03f, 1.72080174e-02f, 3.52797844e-02f, 2.47375462e-02f, -1.14864381e-02f, -3.16888727e-02f, -1.38543984e-02f, 4.77050729e-02f,
  -2.82668974e-02f, 4.46647443e-02f, -1.35246525e-02f, -1.08622620e-02f, 3.83321233e-02f, -2.41198409e-02f, 3.84652847e-03f, 7.45142475e-02f, 2.50172596e-02f, 1.46970851e-02f,
  2.48754546e-02f, 6.25062808e-02f, 6.83100671e-02f, -6.68224646e-03f, -2.97232121e-02f, 1.09666608e-01f, -6.73068166e-02f, 5.40452078e-02f, -5.95501699e-02f, 5.14853187e-02f,
  -1.62351057e-01f, 2.33181436e-02f, -2.52779410e-03f, 5.68834506e-02f, 2.03221198e-02f, 1.00279357e-02f, 5.21390559e-03f, -4.61325869e-02f, 1.96432341e-02f, 5.37054287e-03f,
  -6.00311086e-02f, -2.96399519e-02f, -1.05154119e-01f, 1.52228831e-03f, -3.12707983e-02f, -1.04821421e-01f, -6.55154437e-02f, 2.85276724e-03f, -3.38784754e-02f, 1.45202866e-02f,
  5.76402321e-02f, -1.44042209e-01f, -4.56474535e-02f, -7.43567944e-02f, 3.91831994e-02f, -1.49910003e-01f, -1.45445660e-01f, -7.12608248e-02f, -8.28961059e-02f, -1.45491332e-01f,
  -2.48559508e-02f, 5.40544204e-02f, 7.21775070e-02f, 7.20856190e-02f, 3.95333953e-02f, 1.11958817e-01f, 3.21603306e-02f, 1.32608578e-01f, 2.23376378e-02f, 1.87493693e-02f,
  1.15635157e-01f, -3.71470787e-02f, 5.59116229e-02f, 7.97739848e-02f, 3.89140584e-02f, -4.40190695e-02f, -3.27100083e-02f, -1.66283343e-02f, -9.35271680e-02f, 1.43896099e-02f,
  -2.06459090e-02f, 9.27752703e-02f, -2.39246581e-02f, 8.20337906e-02f, 1.00271799e-01f, 8.26645941e-02f, -4.52365614e-02f, -3.70556936e-02f, 2.80760564e-02f, -6.90991208e-02f,
  -1.68752342e-01f, -4.65468969e-04f, 1.83702763e-02f, 9.33744572e-03f, -2.45786142e-02f, 8.56492817e-02f, -9.52069415e-04f, -7.06483796e-02f, -1.63903739e-02f, 3.71196866e-02f,
  8.29559639e-02f, 7.46100470e-02f, 8.11413303e-02f, -2.19841413e-02f, 3.49771976e-02f, -8.42069909e-02f, 2.33396911e-03f, 1.37302158e-02f, 1.31004844e-02f, 3.40946466e-02f,
  3.73546891e-02f, 6.85239136e-02f, 1.50838802e-02f, -3.03908670e-03f, -2.00868156e-02f, -1.13192135e-02f, 7.09429830e-02f, 3.01692560e-02f, -7.87303001e-02f, 7.74679706e-02f,
  -3.17031629e-02f, -6.15716800e-02f, 3.82887945e-02f, 6.66424632e-02f, -3.16272154e-02f, 7.28795007e-02f, 6.27960414e-02f, -1.81907099e-02f, 1.32927326e-02f, 5.75634167e-02f,
  -4.51483130e-02f, -8.57654139e-02f, 3.27380560e-02f, 2.32239850e-02f, 4.10364605e-02f, 3.65594439e-02f, 5.09774685e-03f, -9.09130350e-02f, 4.50266190e-02f, 4.43581194e-02f,
  8.49647596e-02f, -7.95191675e-02f, 5.14029525e-04f, -6.00139499e-02f, -7.35740885e-02f, -1.11512942e-02f, 1.28406798e-02f, -6.77789077e-02f, 5.29585965e-03f, -6.05774894e-02f,
  -4.41913866e-02f, -6.41494542e-02f, -8.73180479e-02f, -8.01032037e-02f, 2.15806309e-02f, 8.79854336e-02f, 6.73456416e-02f, 2.68716048e-02f, 1.02385052e-01f, -7.10183159e-02f,
  2.33812556e-02f, -6.55184239e-02f, 2.00606231e-03f, 5.71160428e-02f, 2.20965948e-02f, -7.72146434e-02f, 6.28798380e-02f, 3.35752368e-02f, 7.80145526e-02f, 2.58173011e-02f,
  7.74666592e-02f, 5.46394140e-02f, 3.72645259e-02f, -4.74976785e-02f, -5.08347042e-02f, 7.07810149e-02f, -8.95967428e-03f, 2.03517284e-02f, 4.70634513e-02f, 9.61791351e-02f,
  2.15914994e-01f, -8.65431577e-02f, -2.90467501e-01f, 4.60373797e-02f, -2.28155345e-01f, -2.16355011e-01f, -1.64078861e-01f, 7.66521767e-02f, 2.96163615e-02f, -2.37983927e-01f,
  -3.95112634e-02f, 3.64755839e-02f, -3.71653326e-02f, -8.77282619e-02f, -6.11918606e-02f, -2.58387595e-01f, -2.61650443e-01f, -9.20316111e-03f, -8.89410973e-02f, -1.35240883e-01f,
  -1.07476171e-02f, -1.41806677e-01f, 1.17110617e-01f, -8.24086182e-03f, -4.76622991e-02f, 8.37805029e-03f, -1.68715224e-01f, -7.98757002e-02f, -8.83322507e-02f, -2.13907987e-01f,
  -3.67348969e-01f, -1.46960597e-02f, -1.10001899e-01f, 2.51248907e-02f, -1.13106288e-01f, 2.87609603e-02f, -1.11785173e-01f, 9.75814685e-02f, 1.00852497e-01f, 1.95575915e-02f,
  1.75083913e-02f, -8.41233879e-03f, 5.04836552e-02f, 2.92582177e-02f, 7.84959048e-02f, -7.15179592e-02f, 8.09106380e-02f, 6.77804872e-02f, -6.53776377e-02f, 4.79280688e-02f,
  -5.75499609e-02f, -2.68517379e-02f, 1.45882871e-02f, 1.03668258e-01f, -1.28279561e-02f, -6.15534037e-02f, -3.64274457e-02f, -1.91856939e-02f, 3.22460644e-02f, -7.18795136e-02f,
  -1.05804563e-01f, 1.79347955e-02f, -2.50510033e-02f, 6.71265498e-02f, 1.75428223e-02f, -2.01004278e-02f, 1.71404704e-02f, 3.95614170e-02f, -3.48417945e-02f, -4.79540089e-03f,
  7.75843039e-02f, 1.43223908e-02f, -2.93232151e-03f, 7.23719038e-03f, -9.96413529e-02f, 9.56593733e-03f, 6.69621900e-02f, -1.54059110e-02f, 4.94628884e-02f, -4.10660990e-02f,
  -2.07846723e-02f, 7.43148848e-02f, 7.57216141e-02f, -4.19916771e-02f, -2.47306228e-02f, -6.04541637e-02f, -8.86413157e-02f, 9.71927494e-03f, 2.38199942e-02f, -8.85338336e-03f,
  1.22637358e-02f, 3.03699914e-02f, -3.87620553e-02f, 1.32283330e-01f, 2.62765530e-02f, -5.10486327e-02f, 5.15682017e-03f, 1.77873354e-02f, -1.39929242e-02f, -9.35806893e-03f,
  -7.39508774e-03f, 8.66299495e-02f, 1.98907014e-02f, -5.60565144e-02f, -6.01897947e-02f, 1.33377202e-02f, 2.39592120e-02f, 3.06169260e-02f, -5.72968200e-02f, 6.60051331e-02f,
  -5.96491359e-02f, 1.40596309e-03f, 5.06974086e-02f, 7.29120523e-03f, 1.22045927e-01f, 9.04786289e-02f, 3.75925675e-02f, -1.94460712e-02f, 1.18239745e-01f, -7.84656033e-02f,
  -1.89696193e-01f, -6.74445555e-03f, 9.53996480e-02f, 4.88319620e-03f, 8.82059485e-02f, 2.73400377e-02f, 1.33022621e-01f, 1.04048096e-01f, 2.63000596e-02f, 3.88106219e-02f,
  5.17021306e-02f, 1.76170141e-01f, 1.33807078e-01f, 1.06036112e-01f, 5.56905419e-02f, 1.55548498e-01f, 7.08900690e-02f, 7.55093917e-02f, 3.18654180e-02f, 6.48147240e-02f,
  -1.51307313e-02f, 4.88332054e-03f, -4.49830573e-03f, 9.06353816e-03f, 5.15181050e-02f, 1.46260578e-02f, 1.68666895e-02f, -9.91294384e-02f, -6.78227246e-02f, 8.44057575e-02f,
  1.95836663e-01f, -1.11359999e-01f, 4.56125103e-02f, -7.67325163e-02f, -1.14739098e-01f, 1.44854244e-02f, 4.43870537e-02f, -1.42783687e-01f, -9.97420847e-02f, -1.11462653e-01f,
  -6.19475963e-03f, -5.98711036e-02f, -5.27430326e-02f, 7.58917816e-03f, -9.38360468e-02f, 2.36007906e-02f, -8.90271142e-02f, -4.73654903e-02f, -7.17912009e-03f, 5.67658022e-02f,
  8.17070827e-02f, 1.64151061e-02f, -8.80906507e-02f, 7.22886994e-02f, 1.03863459e-02f, 7.44018033e-02f, -9.10320804e-02f, 4.55440953e-02f, -4.57132943e-02f, -1.20424233e-01f,
  4.46924344e-02f, 1.52658904e-02f, 5.85288741e-02f, 7.15509430e-02f, -4.20380244e-03f, 1.40862223e-02f, 6.43908232e-02f, 7.75035992e-02f, 1.01998411e-02f, -4.05045263e-02f,
  -1.19664818e-02f, 8.37234706e-02f, 5.11199310e-02f, -3.94335464e-02f, 2.11995281e-02f, -2.76923906e-02f, 6.22867886e-03f, -6.79405360e-03f, 7.04068094e-02f, -5.60373850e-02f,
  -7.38946795e-02f, 5.97799430e-03f, -8.24505165e-02f, -4.29463983e-02f, -5.13560101e-02f, 6.22408129e-02f, 2.66653132e-02f, -5.27141318e-02f, 3.24376002e-02f, -2.45681033e-02f,
  3.78497578e-02f, 7.37894699e-03f, 4.83172424e-02f, 5.85365556e-02f, -6.33899644e-02f, -9.95941013e-02f, 8.87807906e-02f, -3.49864393e-04f, -7.00903535e-02f, 4.42815684e-02f,
  -8.22669044e-02f, 1.83998030e-02f, 6.10252991e-02f, -4.91969325e-02f, 1.48980860e-02f, -1.23092430e-02f, -3.23975384e-02f, 8.57149139e-02f, 3.88525352e-02f, -1.04099825e-01f,
  3.88920642e-02f, 2.56951265e-02f, 1.13724597e-01f, 1.67777091e-01f, 2.41518021e-02f, 6.39117956e-02f, 7.67674446e-02f, 6.43046200e-02f, 6.24695793e-02f, 4.58692722e-02f,
  3.22427452e-02f, 1.50225952e-01f, 1.21206313e-01f, -2.04070807e-02f, 2.84715686e-02f, 7.74594620e-02f, 1.89026117e-01f, 1.01479270e-01f, -6.20300807e-02f, 4.70024049e-02f,
  3.64918411e-02f, -8.95663947e-02f, -4.62318845e-02f, -7.62861595e-02f, 7.92999640e-02f, -3.76210362e-02f, -5.90125285e-02f, 3.84043120e-02f, -9.09038857e-02f, -6.02044500e-02f,
  -1.02947652e-01f, -3.77896205e-02f, -7.02791587e-02f, -5.09933047e-02f, 4.21989262e-02f, -1.74167007e-01f, 5.87644614e-02f, -3.93765382e-02f, 5.49488589e-02f, -1.19533658e-01f,
  -3.07638999e-02f, 1.26097038e-01f, -3.54255997e-02f, -7.55281374e-02f, 3.63898128e-02f, 1.03833936e-01f, 3.74835730e-02f, 8.59952569e-02f, -9.43385588e-04f, 1.20621979e-01f,
  2.56889742e-02f, -5.25318785e-03f, 4.53074127e-02f, 1.61029138e-02f, 6.17135279e-02f, 3.11016496e-02f, 3.54131944e-02f, 6.27294853e-02f, -4.07926477e-02f, 1.35734215e-01f,
  6.54107407e-02f, -4.18604240e-02f, -2.05847453e-02f, 2.08770763e-03f, -7.27163330e-02f, -2.62527131e-02f, 9.95325968e-02f, -9.12980139e-02f, -3.58063169e-02f, 3.39444145e-03f,
  -1.53048718e-02f, 5.80575988e-02f, 4.54909205e-02f, -6.33866861e-02f, -6.16773143e-02f, -1.61411259e-02f, 1.03020146e-02f, -8.71380493e-02f, -3.09283234e-04f, 1.15444101e-02f,
  -1.62785817e-02f, -5.41084819e-02f, -1.67041887e-02f, 1.83563363e-02f, -3.72682698e-02f, -5.28703332e-02f, 8.05192590e-02f, 5.97072169e-02f, 7.16861486e-02f, 3.69808450e-02f,
  -2.91530378e-02f, -3.15262675e-02f, 6.03611879e-02f, 1.59616321e-02f, -7.84137473e-02f, 5.15131094e-02f, -9.11885872e-02f, -2.91882940e-02f, -2.22983602e-02f, 3.97050232e-02f,
  5.69870546e-02f, -8.04899707e-02f, 1.96162667e-02f, 6.69141486e-02f, -5.48620000e-02f, 1.77156017e-03f, -2.12309398e-02f, 2.08312664e-02f, 2.41620746e-02f, 9.70479250e-02f,
  9.31160301e-02f, 7.30097964e-02f, 5.17649539e-02f, 1.23391718e-01f, 8.56646225e-02f, 9.58116427e-02f, -5.08986413e-02f, -2.24635974e-02f, -5.09691611e-02f, 1.21150389e-01f,
  -1.71400327e-02f, -9.03327838e-02f, -6.91522565e-03f, -2.56383456e-02f, -4.34023961e-02f, -1.39045417e-01f, -2.32443977e-02f, -6.75812885e-02f, -4.16890308e-02f, 9.20788851e-03f,
  4.18806106e-01f, 1.01872705e-01f, -7.47673810e-02f, 3.92676666e-02f, 4.57133986e-02f, -1.44795692e-02f, 7.25813815e-03f, 1.95191637e-01f, 1.42630890e-01f, 9.38214511e-02f,
  1.61640227e-01f, 1.22940473e-01f, 2.08870962e-01f, 2.03962728e-01f, 1.88544035e-01f, -4.05196175e-02f, -1.13205746e-01f, -7.03539476e-02f, 1.06946126e-01f, -5.88971414e-02f,
  -9.02396291e-02f, -3.68518233e-02f, 5.35548851e-02f, -6.00921642e-03f, -2.87700091e-02f, -8.46509561e-02f, 5.50381579e-02f, -4.90231626e-02f, -2.07195934e-02f, -1.21912077e-01f,
  -1.64391518e-01f, 3.17046642e-02f, 1.84614956e-02f, 1.28266960e-01f, -2.69035269e-02f, 3.64522003e-02f, 2.74373330e-02f, -6.56506270e-02f, 7.50802606e-02f, 5.08003943e-02f,
  -6.24754280e-02f, 5.01265489e-02f, 8.16706493e-02f, -1.24232937e-02f, -2.75185821e-03f, -5.94664784e-03f, -5.84357604e-02f, 2.01570410e-02f, 7.52173737e-03f, 5.03902957e-02f,
  -3.84256952e-02f, -4.35445122e-02f, -5.50483800e-02f, 6.41543418e-03f, 1.05923429e-01f, 3.90039124e-02f, -5.25376350e-02f, -4.62678820e-02f, 1.04667872e-01f, 1.74155142e-02f,
  7.11434754e-03f, 2.96916477e-02f, -2.80659441e-02f, 8.14200342e-02f, 6.74655149e-03f, 5.89665491e-03f, -8.32244605e-02f, 3.64116691e-02f, -5.71207181e-02f, 6.69986531e-02f,
  -3.67146940e-03f, 1.08053580e-01f, 3.56403999e-02f, -1.94614884e-02f, 4.91128536e-03f, -2.74070427e-02f, -1.12149194e-01f, 6.19721599e-02f, 5.07030599e-02f, -8.58243257e-02f,
  4.86351848e-02f, -4.55215126e-02f, -8.17309245e-02f, 2.31203604e-02f, -5.40773533e-02f, 1.34549402e-02f, 4.60265651e-02f, 6.64190426e-02f, 7.19344839e-02f, 5.33355102e-02f,
  8.31889510e-02f, 1.97052926e-01f, -6.74111322e-02f, 8.33696201e-02f, -1.33543074e-01f, 1.70502849e-02f, -1.28325718e-02f, 6.75938092e-03f, -4.32307497e-02f, -8.64094794e-02f,
  2.92700715e-02f, -3.60744298e-02f, 4.49430309e-02f, -8.20807517e-02f, -1.02916658e-01f, 4.96700443e-02f, 2.76909582e-02f, 1.50978798e-02f, -1.02882788e-01f, -9.72698405e-02f,
  1.70595031e-02f, 5.94778210e-02f, 3.33541236e-03f, 2.32940894e-02f, -5.75034991e-02f, 1.46699458e-01f, -2.22876016e-02f, 4.57721241e-02f, 1.10500576e-02f, 1.23881996e-01f,
  -4.24486160e-01f, -3.90097320e-01f, -4.68035340e-02f, -2.22538993e-01f, -5.16103841e-02f, 1.77898705e-02f, -1.97603002e-01f, 1.46466464e-01f, -7.52820075e-02f, -2.42259115e-01f,
  -1.31920740e-01f, 6.38099164e-02f, -1.92371700e-02f, 1.54483154e-01f, 1.51126087e-01f, -2.31103346e-01f, -2.49449685e-01f, 4.89480086e-02f, 3.66342306e-01f, 2.23852724e-01f,
  -8.82971473e-03f, -4.24177945e-02f, 1.57110840e-01f, 1.80660963e-01f, -1.55564398e-01f, -1.22371159e-01f, -1.17961779e-01f, -1.73354000e-01f, -1.63093135e-01f, -4.53135431e-01f,
  -1.68141887e-01f, -1.05800912e-01f, 1.25077724e-01f, -3.47664952e-03f, -9.92876198e-03f, 2.02595331e-02f, -4.59086965e-04f, -7.02889403e-03f, -2.47860458e-02f, -4.51648608e-02f,
  7.08330423e-03f, 8.65603760e-02f, -4.63419687e-03f, 7.66587257e-02f, 4.97647300e-02f, 2.94652916e-02f, 1.23366207e-01f, 1.34787127e-01f, 1.18688978e-01f, 1.15643796e-02f,
  -9.15637538e-02f, -1.23400249e-01f, -1.27277210e-01f, 7.32237995e-02f, 8.42196867e-02f, 1.09179743e-01f, 3.57595570e-02f, -7.71821737e-02f, 1.26773734e-02f, -2.95545250e-01f,
  -3.17699765e-03f, -9.51188058e-03f, 1.03477938e-02f, 1.36433952e-02f, -1.26847224e-02f, 1.09665869e-02f, -2.08199359e-02f, -4.59001362e-02f, 8.12274069e-02f, -5.28577156e-02f,
  4.41055931e-02f, -1.67194605e-02f, -3.63678858e-03f, -7.15572685e-02f, -3.69263813e-02f, 1.87937263e-02f, 1.13325277e-02f, -4.26385961e-02f, -1.54317440e-02f, -1.90635528e-02f,
  7.81968329e-03f, 2.42058504e-02f, -3.13005503e-03f, 5.04291803e-02f, -1.03149666e-02f, 1.83079187e-02f, 2.75439583e-02f, 7.90273398e-02f, -1.09109459e-02f, 1.24072637e-02f,
  -1.59933716e-01f, 1.45725042e-01f, -2.47420475e-01f, -2.82228980e-02f, -1.38969436e-01f, -3.19913067e-02f, -7.12040290e-02f, 7.00655952e-02f, 1.56868827e-02f, 2.04174891e-02f,
  6.54632449e-02f, -5.86438961e-02f, -1.20201372e-01f, 6.97615892e-02f, 8.11532065e-02f, 3.41208279e-02f, -4.65245359e-02f, -3.99405397e-02f, 2.68027820e-02f, -3.04879565e-02f,
  6.92946836e-03f, -1.63104683e-01f, -1.39741167e-01f, -1.20824173e-01f, -9.02371109e-02f, -1.17725521e-01f, -1.25337839e-01f, -1.80354062e-02f, -1.27377957e-01f, -2.59533912e-01f,
  -1.16830217e-02f, 1.07253641e-01f, -8.37479532e-02f, -1.69085786e-02f, 3.08284126e-02f, -8.51922035e-02f, -3.29595245e-02f, -1.01834983e-01f, 6.08352236e-02f, 9.23165455e-02f,
  8.44956860e-02f, -2.23649275e-02f, 4.62295935e-02f, 2.82849297e-02f, 2.81877778e-02f, -7.82503933e-03f, -5.63664436e-02f, 2.88531855e-02f, 3.78749482e-02f, 4.04467201e-03f,
  2.14469247e-02f, -8.41055885e-02f, 2.12858338e-02f, -3.05813667e-03f, 5.23783490e-02f, -6.67338073e-03f, 3.21943089e-02f, -7.53997639e-02f, 1.50959343e-02f, 3.35051045e-02f,
  4.99749882e-03f, 2.20790859e-02f, 2.40734406e-03f, 3.20481397e-02f, 9.15050283e-02f, -7.12719187e-03f, -1.61443613e-02f, -3.99596617e-02f, 4.28642109e-02f, 2.65541635e-02f,
  7.69246146e-02f, 1.10759139e-01f, 9.22312737e-02f, -2.83313431e-02f, -4.49998379e-02f, -3.17693390e-02f, 4.38659862e-02f, 9.69547555e-02f, -1.49345249e-02f, -4.48910752e-03f,
  6.92694187e-02f, -1.58492886e-02f, 1.83301009e-02f, 1.08993435e-02f, 3.38435285e-02f, 8.86576325e-02f, 4.74531353e-02f, 1.08392417e-01f, 5.67852557e-02f, 7.25045651e-02f,
  -7.50915930e-02f, 1.89639591e-02f, -6.76230416e-02f, -7.45931268e-02f, -5.29240519e-02f, -7.17072412e-02f, -1.63875110e-02f, 1.10831088e-03f, -3.25837024e-02f, -7.54706487e-02f,
  1.31169865e-02f, -2.56369524e-02f, 7.38545731e-02f, -8.57866704e-02f, 2.83799376e-02f, 1.13897631e-02f, 2.42826273e-03f, -1.64812687e-03f, 4.69651036e-02f, 5.37892617e-02f,
  5.16177574e-03f, 1.57888252e-02f, 2.25940328e-02f, 4.27312218e-02f, 8.37961491e-03f, 2.80887578e-02f, 7.98528716e-02f, 6.73181564e-03f, 4.94025741e-03f, -8.29837769e-02f,
  7.31333718e-02f, -1.06237851e-01f, 3.23343463e-02f, -2.82024709e-03f, 5.12418523e-02f, 4.64589000e-02f, 2.96893958e-02f, 9.77642555e-03f, -5.38632413e-03f, 7.32954815e-02f,
  -1.64992060e-03f, -3.97105664e-02f, -1.76572911e-02f, 8.02751109e-02f, 3.34587991e-02f, 3.81538235e-02f, -7.36497343e-02f, 9.17875692e-02f, -2.93388292e-02f, 7.16305375e-02f,
  3.10522038e-02f, -3.11578456e-02f, -5.36217131e-02f, -1.76523477e-02f, 7.41826138e-03f, -4.62974869e-02f, -2.74147326e-03f, 7.54915923e-02f, -3.10997898e-03f, -4.83624451e-02f,
  2.77906507e-01f, -1.23859562e-01f, -1.21655516e-01f, -4.65593189e-02f, -1.54410169e-01f, -1.45394892e-01f, -1.57364070e-01f, 3.04262154e-02f, -5.06291315e-02f, -1.51209339e-01f,
  1.05843013e-02f, 2.64941379e-02f, -1.37417987e-02f, -4.97507714e-02f, -4.63409722e-02f, -7.35817179e-02f, -2.77900342e-02f, -8.65207389e-02f, -6.43480718e-02f, 2.90347431e-02f,
  -9.41208098e-03f, -3.01353708e-02f, -4.68100682e-02f, 1.73499230e-02f, 4.27117422e-02f, -5.92667982e-02f, -1.56120360e-01f, -1.17126964e-02f, -1.63002741e-02f, -5.48787601e-02f,
  -9.62986350e-02f, 1.10517535e-02f, 5.29695898e-02f, 1.15415037e-01f, 7.22854137e-02f, -1.49983307e-02f, -4.83118929e-02f, 7.18118101e-02f, 7.23680928e-02f, -3.48809846e-02f,
  5.22687137e-02f, -3.68250497e-02f, 6.38718978e-02f, -7.18387123e-03f, 8.78207609e-02f, -6.17239345e-03f, 9.47336014e-03f, 6.56220242e-02f, -3.07965418e-03f, -1.20225199e-01f,
  2.31633987e-02f, -5.22389859e-02f, 1.79092251e-02f, 4.44177911e-02f, -7.16911852e-02f, 8.23987424e-02f, -8.93107429e-02f, 6.24034274e-03f, 1.91072114e-02f, 9.95635241e-02f,
  -2.20030383e-03f, 5.55325411e-02f, 4.42873538e-02f, -4.43885513e-02f, 4.42193635e-02f, 9.21819955e-02f, -5.93186803e-02f, 7.02713504e-02f, 5.22994623e-02f, 6.28591031e-02f,
  -8.96875113e-02f, -2.64439490e-02f, 1.86654516e-02f, -4.38537076e-02f, -1.11314140e-01f, -9.76413675e-03f, -7.07565472e-02f, 6.65986985e-02f, -5.94343990e-02f, -1.44105246e-02f,
  1.83953848e-02f, 1.05782915e-02f, 8.52728356e-03f, -3.19222617e-03f, -4.91140597e-02f, -1.88520290e-02f, 3.14027146e-02f, -5.27848117e-03f, 3.96892428e-02f, 7.44107068e-02f,
  7.54651555e-04f, 9.16935131e-02f, 4.74861674e-02f, -5.15647009e-02f, 6.82707205e-02f, -2.91111805e-02f, -8.93579051e-02f, 4.05647010e-02f, -3.49174663e-02f, 5.74368462e-02f,
  3.54814553e-03f, 7.19973519e-02f, -7.25378096e-02f, 5.73958596e-03f, 9.16167870e-02f, 3.43161747e-02f, -1.72834471e-02f, 2.29650531e-02f, 8.62998888e-02f, -1.04950219e-01f,
  3.77179421e-02f, 4.58783768e-02f, 5.72310835e-02f, 3.66988555e-02f, 1.09844521e-01f, 9.86433402e-02f, -4.98308279e-02f, 9.77624059e-02f, -2.00586990e-02f, 2.78056972e-02f,
  -3.79640162e-01f, -8.76640826e-02f, 2.58197803e-02f, 1.91524923e-01f, 1.87810600e-01f, 2.01456204e-01f, 8.16863105e-02f, 1.66192740e-01f, 1.24596581e-01f, 1.35842785e-01f,
  -2.31388840e-03f, 1.91838354e-01f, 1.95142046e-01f, 1.42415419e-01f, 1.70742854e-01f, 1.85088351e-01f, 1.82287365e-01f, 1.30370140e-01f, 7.04886671e-03f, 7.89318234e-02f,
  1.51936367e-01f, -4.72022705e-02f, -2.17657387e-01f, 6.91611366e-03f, 1.40587360e-01f, 1.19305700e-01f, -3.31450440e-02f, 3.22011998e-03f, -4.36013639e-02f, 3.27473320e-02f,
  4.29879911e-02f, -2.56390393e-01f, 1.01794988e-01f, -5.89337153e-03f, 2.14811545e-02f, -1.45152032e-01f, -1.24181705e-02f, -6.55628964e-02f, -7.71713108e-02f, 6.16802387e-02f,
  5.57009876e-02f, -1.56011079e-02f, 3.99545915e-02f, -2.59726178e-02f, -9.96556804e-02f, -4.27288525e-02f, -1.28986686e-01f, -2.95353495e-02f, 3.22255082e-02f, -7.16930553e-02f,
  1.32010683e-01f, -2.70709824e-02f, -1.54103979e-01f, -3.29057127e-02f, -4.96938229e-02f, 6.76055402e-02f, -2.56653409e-02f, -2.87079383e-02f, -2.14197244e-02f, -2.38879933e-04f,
  5.41460626e-02f, -3.01116593e-02f, 2.01843884e-02f, 3.70012559e-02f, -2.63855737e-02f, 3.65034863e-02f, -3.43166478e-02f, 6.58478364e-02f, 3.11089959e-02f, 3.58489528e-03f,
  -2.80345362e-02f, -1.86379328e-02f, 6.39080778e-02f, 8.23193565e-02f, 9.25583765e-02f, -6.41040578e-02f, -4.88213263e-02f, 3.37164216e-02f, -9.16683227e-02f, -1.08649150e-01f,
  -3.30046900e-02f, 5.96830659e-02f, -4.08818796e-02f, 7.16184825e-03f, -8.16515088e-02f, 4.45435978e-02f, -4.64812256e-02f, -7.30180442e-02f, -4.12532091e-02f, -8.67563114e-02f,
  7.49779493e-02f, 3.07581052e-02f, 8.72112811e-02f, -9.02062573e-04f, -4.54731882e-02f, -9.67637077e-02f, 1.33001513e-03f, -2.54026689e-02f, 4.53407951e-02f, -1.63073745e-02f,
  -9.28978473e-02f, 4.55521494e-02f, -4.86228950e-02f, 3.02566197e-02f, 4.38151434e-02f, 3.58907878e-02f, 2.75208671e-02f, 9.14246365e-02f, -1.62784569e-02f, 1.00726403e-01f,
  4.51380797e-02f, 8.56158361e-02f, 1.95197277e-02f, 5.18452600e-02f, 4.73920219e-02f, 8.82602483e-02f, -1.76280364e-02f, 6.14699647e-02f, 3.20119858e-02f, -9.65300296e-03f,
  -9.54567865e-02f, -9.50761586e-02f, -1.63504690e-01f, -2.47967672e-02f, 2.61796862e-02f, 3.73097733e-02f, -6.84851035e-02f, 4.79173288e-02f, -6.67837495e-03f, -4.32446897e-02f,
  -9.50152874e-02f, 4.45384346e-02f, -8.74633566e-02f, 6.25696704e-02f, 7.75571093e-02f, -2.59750467e-02f, -1.32095858e-01f, -8.47664922e-02f, 4.70587648e-02f, -4.44069207e-02f,
  -7.20950365e-02f, 4.15167511e-02f, 5.47153465e-02f, -3.40933390e-02f, -6.12829551e-02f, 3.31692286e-02f, -3.47936489e-02f, -2.14207359e-02f, -2.74939230e-03f, -1.42040238e-01f,
  -1.27085641e-01f, -2.83358414e-02f, -5.37296347e-02f, 7.76321068e-02f, -5.81955910e-02f, 3.41389701e-02f, 3.24783288e-02f, -8.87673348e-02f, -3.44600938e-02f, -2.02792343e-02f,
  2.38097589e-02f, 4.31042354e-05f, 8.06134269e-02f, -4.36686948e-02f, -1.27788829e-02f, -5.03907464e-02f, 4.75609936e-02f, -5.37954308e-02f, 2.02230047e-02f, 4.52468246e-02f,
  6.59569427e-02f, 1.06987739e-02f, 6.97083548e-02f, 5.56523241e-02f, 1.03083991e-01f, -8.99047032e-03f, 9.23321620e-02f, -2.95854267e-02f, -2.54213363e-02f, 3.70935351e-02f,
  9.05305743e-02f, 5.31141311e-02f, -7.55451247e-02f, 2.31510606e-02f, 6.46060035e-02f, -8.44723731e-02f, 2.31361296e-02f, 3.83659229e-02f, -3.30698192e-02f, -2.81222034e-02f,
  -7.57633746e-02f, 6.09508082e-02f, -4.00356762e-02f, 1.47518739e-02f, 1.59296133e-02f, -6.79845437e-02f, -1.24352500e-02f, -2.54424587e-02f, 4.13616151e-02f, -5.50138913e-02f,
  -1.94732659e-03f, -1.65568069e-02f, -7.51679344e-03f, 5.08308969e-02f, -1.03410028e-01f, -8.50080475e-02f, 1.52065819e-02f, 8.80872160e-02f, 4.63313758e-02f, -2.10197177e-02f,
  -4.89399063e-05f, -1.22490283e-02f, -2.13820878e-02f, 2.15293057e-02f, -2.72565102e-03f, 1.59671996e-02f, 5.60512906e-03f, -5.60936853e-02f, -7.85785764e-02f, -2.38691345e-02f,
  -3.41079719e-02f, 8.87859054e-03f, 7.90489465e-02f, 7.69497231e-02f, 1.05958082e-01f, 4.55055982e-02f, 4.79140924e-03f, 3.57291773e-02f, 4.78202365e-02f, 2.84447446e-02f,
  -3.23347673e-02f, -6.67119622e-02f, 1.92513913e-02f, 7.45185763e-02f, -1.88339893e-02f, 4.78934087e-02f, -6.86381608e-02f, -7.48776346e-02f, -1.57553256e-02f, -3.38679776e-02f,
  -1.00736104e-01f, -1.26721188e-01f, 7.82267749e-03f, -1.73525661e-02f, 3.29450495e-03f, 1.67843644e-02f, -6.91676140e-02f, -1.09681472e-01f, -3.58897112e-02f, -1.05265349e-01f,
  -1.02987234e-03f, -9.03878286e-02f, -7.11980835e-02f, -1.79253370e-02f, 6.07814975e-02f, 1.25148939e-02f, 1.11393882e-02f, -3.56427021e-02f, 7.94912502e-02f, 8.54971819e-03f,
  4.52724732e-02f, 3.87477390e-02f, -1.33330366e-02f, 3.28519791e-02f, -6.30764440e-02f, -3.31262648e-02f, -7.62898698e-02f, -9.78789665e-03f, 8.00308734e-02f, 1.83942560e-02f,
  2.38039042e-03f, 2.05979235e-02f, 2.00650096e-02f, 2.76447590e-02f, 2.82831781e-04f, 4.86299489e-03f, -8.00077394e-02f, -6.87364265e-02f, 2.84016039e-02f, -5.60470335e-02f,
  1.47393707e-03f, 3.51275876e-02f, 1.53847104e-02f, 2.64217705e-02f, -8.21462199e-02f, 2.88343094e-02f, 1.38819625e-03f, 7.32442737e-02f, -6.75022751e-02f, -4.18678187e-02f,
  -3.53366137e-02f, 1.04485638e-02f, 4.37489338e-02f, 4.70825620e-02f, 6.81540295e-02f, -5.02844937e-02f, 2.66101174e-02f, 1.16124712e-01f, 7.86427632e-02f, 5.89525253e-02f,
  4.88869324e-02f, 7.83238634e-02f, 7.79187903e-02f, 6.36537967e-04f, -5.27143367e-02f, -7.43685588e-02f, -4.63413075e-02f, 1.81489605e-02f, -3.18692811e-02f, -3.98056582e-02f,
  5.77324852e-02f, -2.44881567e-02f, -8.54566395e-02f, 1.46233244e-02f, -6.21366240e-02f, 4.14016284e-02f, -7.55436197e-02f, -1.05657978e-02f, 6.12703599e-02f, -4.95242104e-02f,
  4.65437286e-02f, 9.88813955e-03f, -7.95930158e-03f, 6.71900064e-02f, -1.75951328e-02f, 7.25447610e-02f, 7.98534378e-02f, 6.08683825e-02f, 8.38667750e-02f, 1.03799336e-01f,
  -1.07622966e-01f, -1.52720483e-02f, 6.89947829e-02f, -7.11969100e-03f, 2.22735424e-02f, 3.70359495e-02f, 7.56674111e-02f, -8.74706954e-02f, 6.49672607e-03f, -1.09026264e-02f,
  3.44275869e-02f, -2.88716499e-02f, 3.30927446e-02f, -1.88264828e-02f, 4.91192117e-02f, 7.55746965e-04f, 4.15904187e-02f, -5.97231612e-02f, 5.63832819e-02f, 4.36563860e-04f,
  -4.44948114e-02f, -3.89805958e-02f, -5.05426154e-02f, -2.81550121e-02f, 1.26504516e-02f, -1.59358024e-03f, -2.08735205e-02f, 7.65819624e-02f, 1.95668908e-04f, -5.97260939e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  8.02164376e-02f, -9.10110585e-03f, 1.70779824e-01f, -3.04511841e-03f, 1.88910831e-02f, 1.18364170e-01f, 4.21499833e-02f, 1.73849151e-01f, 2.42236689e-01f, -5.44096194e-02f,
  9.51419026e-03f, 1.01187341e-01f, 7.60607943e-02f, 1.04133144e-03f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -1.33942053e-01f, -1.38670027e-01f, 1.33231744e-01f, 4.84080315e-02f, 9.31554362e-02f, 1.68093801e-01f, 1.17289618e-01f, 2.66925506e-02f, -1.55321926e-01f, 7.78462365e-02f,
  -7.89285377e-02f, 7.57032707e-02f, -2.42824629e-02f, -1.40407845e-01f, -9.70601477e-03f, -1.07648224e-02f, -1.61072746e-01f, -7.05005601e-02f, -7.13087246e-02f, -5.83116114e-02f,
  3.23045403e-02f, 9.27785703e-04f, 6.52601346e-02f, 3.87397408e-02f, -1.27155304e-01f, -1.75462782e-01f, -1.48253217e-01f, -2.68100560e-01f, -1.69467598e-01f, 1.54459864e-01f,
  -7.51501545e-02f, 9.00269747e-02f, -1.44083247e-01f, 1.82733178e-01f, 6.23330362e-02f, -3.17308791e-02f, -2.87239272e-02f, -7.58987740e-02f, 9.60166287e-03f, 3.20658498e-02f,
  -8.38307440e-02f, -4.09595342e-03f, -4.90632430e-02f, 3.65247205e-02f, 2.96337288e-02f, 9.65478271e-02f, 1.02624167e-02f, 9.81603339e-02f, -1.89297765e-01f, -6.01371638e-02f,
  -1.05059043e-01f, 3.73669751e-02f, -1.27101243e-01f, 5.88087440e-02f, -1.31016254e-01f, 5.25532961e-02f, 9.36886743e-02f, 2.06329450e-02f, -3.63553703e-01f, 1.14899009e-01f,
  3.56155969e-02f, 9.06108394e-02f, -1.71642601e-01f, -7.94566348e-02f, 8.93380791e-02f, -4.67931889e-02f, 4.28350456e-02f, 3.53336707e-02f, -1.07021304e-02f, 7.03702448e-04f,
  -1.12626165e-01f, -1.03969306e-01f, 1.17608070e-01f, -9.63026732e-02f, -3.80084738e-02f, 2.03396693e-01f, -5.21388371e-03f, -1.36602744e-02f, 6.14475533e-02f, 7.65165910e-02f,
  -1.36109978e-01f, -9.89105105e-02f, -1.10072717e-01f, 4.52016890e-02f, 5.42152487e-02f, 1.21568158e-01f, -1.15793779e-01f, 1.39679477e-01f, -1.35107830e-01f, -1.00653633e-01f,
  -9.31511819e-02f, -2.17524283e-02f, 1.96153462e-01f, -2.64300257e-01f, 2.72490233e-01f, -1.67120546e-01f, -1.42100215e-01f, -2.40498949e-02f, 1.13091484e-01f, -2.07450986e-01f,
  1.03626966e-01f, 1.23029584e-02f, -4.53563482e-02f, -1.60886526e-01f, 8.78144726e-02f, 6.25118762e-02f, -2.57737786e-01f, -1.08549282e-01f, 9.55021661e-03f, -9.49574634e-02f,
  -2.81019151e-01f, 2.82630641e-02f, 9.34033915e-02f, -2.78776467e-01f, -1.21220611e-01f, 1.69937462e-01f, 2.64096618e-01f, -1.24790929e-01f, -2.12097228e-01f, 7.22952485e-02f,
  3.22224125e-02f, -2.20749706e-01f, 7.75012523e-02f, 1.67179435e-01f, -1.44893482e-01f, 4.75757383e-02f, -1.04753330e-01f, 7.05436319e-02f, -1.88984666e-02f, -1.59694731e-01f,
  4.32004370e-02f, 9.27221775e-03f, 7.89875612e-02f, -7.35215917e-02f, 5.16818836e-02f, -1.71429038e-01f, 6.52558878e-02f, -1.60689846e-01f, 1.71163306e-01f, -5.02597690e-02f,
  3.74326808e-03f, 7.09023848e-02f, 2.30146423e-02f, 1.44337595e-01f, -1.66160092e-01f, -1.05330393e-01f, -1.20287858e-01f, -4.02702391e-02f, -3.49105969e-02f, 8.98375958e-02f,
  -1.28095329e-01f, -1.00442655e-01f, 1.15979522e-01f, 3.18180889e-01f, -2.31951088e-01f, -1.60105929e-01f, -1.60282493e-01f, 2.05931634e-01f, 2.29888712e-03f, 1.31559327e-01f,
  2.82985032e-01f, 4.56928909e-02f, 2.20014453e-01f, -3.18896286e-02f, 4.21467006e-01f, -1.23286813e-01f, -1.27127752e-01f, -3.43548834e-01f, 4.82844301e-02f, 2.25175936e-02f,
  -9.43902954e-02f, -1.11285567e-01f, 2.22656146e-01f, -1.95629150e-01f, 1.41239673e-01f, 2.67599165e-01f, -7.68847242e-02f, -1.20502874e-01f, -9.80799794e-02f, 4.96677719e-02f,
  1.69455290e-01f, 5.11552989e-02f, -1.71320699e-03f, -1.49756804e-01f, 1.61976546e-01f, 1.12407990e-02f, 3.82582515e-01f, -1.22296261e-02f, -5.39428368e-02f, -1.76206037e-01f,
  1.85683079e-03f, 1.14126466e-01f, -2.11368546e-01f, 6.66212738e-02f, 1.43988669e-01f, 2.12466083e-02f, 9.17917788e-02f, -1.20447405e-01f, -4.87980358e-02f, 1.55434772e-01f,
  1.78913310e-01f, -2.63286643e-02f, -3.47320363e-02f, -2.16210298e-02f, -8.77228528e-02f, -2.23776177e-01f, 5.44365682e-02f, 1.57756791e-01f, 4.75990474e-02f, 1.66544858e-02f,
  -5.49185723e-02f, 9.52498019e-02f, -1.32384850e-02f, 1.00765247e-02f, -1.51663274e-01f, -8.33811611e-03f, 9.86301005e-02f, 1.61929414e-01f, -1.28851295e-01f, -3.37396443e-01f,
  -1.20489486e-02f, -2.27593463e-02f, 1.69365957e-01f, -1.77335024e-01f, 1.03858404e-01f, 2.71083981e-01f, 1.53193295e-01f, -4.43777405e-02f, 3.23813319e-01f, 1.26744658e-01f,
  -2.78991491e-01f, -1.70160383e-01f, 2.78783858e-01f, 2.29192391e-01f, 2.64312569e-02f, -1.68484065e-03f, 2.30817884e-01f, 1.06822409e-01f, 5.43153509e-02f, -1.44276574e-01f,
  -3.72879393e-02f, -2.13972896e-01f, 8.02588314e-02f, 1.41892746e-01f, 1.06729396e-01f, 7.10783824e-02f, -1.52819812e-01f, -6.08106926e-02f, -1.15041621e-01f, -1.77744418e-01f,
  -3.46813258e-03f, 5.16368123e-03f, 1.01274818e-01f, -1.51683558e-02f, -8.24935511e-02f, 8.53982344e-02f, -1.70916185e-01f, -4.61124070e-02f, -4.97012399e-02f, 1.76324263e-01f,
  1.63353272e-02f, 8.53720158e-02f, 1.28018232e-02f, 8.31312314e-02f, -8.97515789e-02f, -1.03579320e-01f, -1.51919842e-01f, 8.06760937e-02f, -2.28389967e-02f, -1.97978780e-01f,
  4.70789112e-02f, 4.40173373e-02f, -1.66072130e-01f, -2.74318475e-02f, -3.18408795e-02f, 7.03732893e-02f, -5.81849776e-02f, 3.27701494e-02f, -7.70020112e-02f, -5.89195415e-02f,
  -1.08806357e-01f, -1.60107717e-01f, -1.81501552e-01f, -3.61847728e-01f, -1.98792413e-01f, -4.67132516e-02f, -2.78761595e-01f, -7.97837526e-02f, -1.89177796e-01f, 2.87459314e-01f,
  -3.29655670e-02f, 4.47661057e-02f, -8.46409798e-02f, -1.09922163e-01f, 3.24894115e-02f, 4.69583794e-02f, 1.47213899e-02f, 2.88512222e-02f, 4.46963571e-02f, 2.73882300e-01f,
  2.20346317e-01f, 3.83768603e-02f, 1.09797008e-01f, -2.03732878e-01f, -2.00511709e-01f, 1.60246432e-01f, 4.01269011e-02f, 6.63821027e-02f, 1.19198253e-02f, -1.32748723e-01f,
  -1.68879658e-01f, -9.09408778e-02f, -3.04681696e-02f, -2.64820725e-01f, -2.61450738e-01f, 8.92370045e-02f, 2.95992922e-02f, 1.29295990e-01f, -1.61227882e-01f, 4.21895459e-02f,
  1.98344383e-02f, -5.77037744e-02f, -1.19909339e-01f, -7.77357891e-02f, 7.17466548e-02f, -1.94907516e-01f, -1.47659019e-01f, -5.39968461e-02f, -4.80131432e-02f, -6.41393960e-02f,
  -5.72500266e-02f, 8.01553875e-02f, -3.67474221e-02f, 1.36473909e-01f, -1.76922902e-02f, -7.98990652e-02f, 7.96746835e-02f, -8.05624947e-03f, 1.24791652e-01f, -4.57158238e-02f,
  -1.12175561e-01f, 9.70060751e-02f, -1.64161876e-01f, -4.28791754e-02f, 1.29209295e-01f, -2.50828505e-01f, 1.52798399e-01f, 2.03637674e-01f, 2.18475670e-01f, -3.57514173e-01f,
  2.18424335e-01f, -1.14844874e-01f, -4.67190854e-02f, 5.41788107e-03f, -1.10983059e-01f, -1.58314317e-01f, 3.08378153e-02f, 4.67447154e-02f, -6.78921193e-02f, 2.21372098e-01f,
  -1.00318156e-02f, 1.35155454e-01f, -4.70260121e-02f, -3.05389576e-02f, -5.16886413e-02f, -7.55971530e-03f, -1.39461756e-01f, -6.06861785e-02f, 1.67000040e-01f, -1.27666056e-01f,
  8.73157680e-02f, 3.86022851e-02f, 1.93266451e-01f, -9.30445492e-02f, 4.70924526e-02f, -1.59726362e-04f, 7.83029422e-02f, -9.89620984e-02f, 2.65081316e-01f, 8.31003338e-02f,
  -1.16887420e-01f, -9.00033338e-04f, -7.44069666e-02f, 9.85911041e-02f, 3.13337259e-02f, 2.95731146e-02f, -3.80473062e-02f, -3.88980322e-02f, -2.62441915e-02f, -5.17983884e-02f,
  2.97931656e-02f, 1.86860040e-01f, 2.20904633e-01f, 1.25183254e-01f, -1.04415551e-01f, 7.63759091e-02f, 1.72455028e-01f, 3.16168755e-01f, -4.91931327e-02f, -1.75449606e-02f,
  1.60450414e-02f, -2.41891239e-02f, 9.40523297e-02f, 8.49647895e-02f, -6.81345388e-02f, 2.76555568e-02f, 2.25021020e-01f, -1.23231281e-02f, -2.20458254e-01f, -3.29630882e-01f,
  1.10241309e-01f, 4.90801372e-02f, 1.25069886e-01f, 8.81150663e-02f, -2.30147466e-01f, 6.53067082e-02f, -1.29772713e-02f, 6.29823059e-02f, 1.12368450e-01f, -1.98087335e-01f,
  -2.03969821e-01f, -3.64701287e-03f, -1.03891425e-01f, 1.92254037e-01f, 7.76569843e-02f, 2.64648438e-01f, 1.11411244e-01f, -1.13029703e-01f, -1.98117971e-01f, 2.25666955e-01f,
  -7.86756203e-02f, -2.91221619e-01f, -6.29956052e-02f, 4.46895510e-02f, -1.22990616e-01f, -1.99788034e-01f, -5.66583090e-02f, 7.89949819e-02f, -3.86626646e-02f, -7.75599033e-02f,
  6.38601854e-02f, -4.03061658e-02f, -1.35497972e-01f, -7.99371861e-03f, 5.96168563e-02f, -1.06420241e-01f, -1.40597954e-01f, 9.20638889e-02f, -1.25882953e-01f, -7.92840347e-02f,
  -6.18238449e-02f, -9.30993631e-02f, 7.81154782e-02f, -1.10090047e-01f, -6.51935115e-02f, 1.51134208e-01f, 1.98614914e-02f, 8.68526474e-02f, 5.93964532e-02f, 6.33818954e-02f,
  -1.87302046e-02f, 7.12943375e-02f, -5.28124832e-02f, 1.13633096e-01f, -7.10314082e-04f, 9.61557869e-03f, 1.38859168e-01f, 8.84566642e-03f, -7.37316813e-03f, 3.57685275e-02f,
  -3.21052819e-02f, -6.12180158e-02f, -1.03985354e-01f, -2.51419693e-01f, -1.73962265e-01f, 1.51542768e-01f, -3.11865122e-03f, -1.63732514e-01f, -1.76208168e-01f, 2.51716133e-02f,
  1.38841420e-02f, 1.93753943e-01f, 1.84263423e-01f, -4.13821131e-01f, -3.99735607e-02f, -5.98647259e-03f, -1.29491776e-01f, 3.51600379e-01f, 1.88241608e-03f, 3.98473799e-01f,
  1.94955617e-02f, -1.67666841e-02f, -1.22531675e-01f, 4.52565812e-02f, -8.53956416e-02f, -1.47929430e-01f, -1.58778653e-01f, -1.93109468e-01f, 2.58169156e-02f, -4.09715017e-03f,
  6.96050674e-02f, -6.38344185e-03f, 8.39943662e-02f, -1.67917028e-01f, -3.25435102e-02f, 1.81832626e-01f, -4.00801718e-01f, 1.68954298e-01f, 7.04539120e-02f, -6.69895038e-02f,
  -4.98484075e-02f, -5.01196980e-02f, -1.71018347e-01f, -9.42877010e-02f, -5.50626256e-02f, 1.48808300e-01f, -7.89508149e-02f, -1.32234529e-01f, 1.08847052e-01f, 1.87408745e-01f,
  1.14590913e-01f, -1.20520197e-01f, -5.71241267e-02f, 2.13521775e-02f, -7.92435277e-03f, 9.94040743e-02f, -9.22924280e-02f, 7.33409822e-02f, -1.43750727e-01f, 8.25651363e-02f,
  1.04970358e-01f, -2.86042821e-02f, -1.01398394e-01f, -2.66178995e-02f, -1.16805576e-01f, -5.80963641e-02f, -1.36593625e-01f, -2.37226143e-01f, -1.95810020e-01f, -1.76263556e-01f,
  -2.83341091e-02f, -6.25096858e-02f, -2.57998824e-01f, -2.39797756e-01f, 1.35729715e-01f, 9.87540781e-02f, 1.57342583e-01f, -2.54908532e-01f, 1.61267683e-01f, -1.19737580e-01f,
  -2.15448543e-01f, 1.51647493e-01f, 1.44007325e-01f, 2.23567009e-01f, 2.71510705e-03f, -2.60901395e-02f, -5.61098009e-03f, 7.40334019e-02f, -2.56762989e-02f, -2.30595395e-01f,
  -7.72735924e-02f, 1.41196959e-02f, 5.53757064e-02f, -6.78181872e-02f, 1.09034441e-01f, 8.22431147e-02f, 1.96884573e-02f, -1.74535230e-01f, 8.19252208e-02f, -7.10755065e-02f,
  -3.27969521e-01f, -7.66969174e-02f, 1.94731243e-02f, 1.64062511e-02f, -3.74833122e-02f, 7.17735216e-02f, -1.31237051e-02f, -4.65034470e-02f, -2.31250450e-01f, 1.63831487e-02f,
  -1.05929837e-01f, 3.13355885e-02f, 1.39338225e-01f, 8.27428028e-02f, 1.41294375e-01f, 6.20343909e-03f, -1.12416849e-01f, -5.28702065e-02f, 1.64361402e-01f, 1.44124314e-01f,
  -7.18615055e-02f, -8.01558942e-02f, 7.01631308e-02f, -2.71179341e-02f, -1.36969134e-01f, 5.03022075e-02f, -5.60431704e-02f, -5.59010394e-02f, -7.40892589e-02f, 1.13091245e-01f,
  -1.91452503e-01f, -1.83626190e-01f, -3.63984108e-02f, -3.54786217e-01f, -1.07385628e-01f, -8.96386653e-02f, -3.34350854e-01f, -4.43297774e-02f, -1.24749310e-01f, 1.89126253e-01f,
  4.72606644e-02f, 3.74923348e-02f, -1.22730076e-01f, -1.99176729e-01f, -5.39230667e-02f, 1.27555624e-01f, -1.63713515e-01f, -5.04801534e-02f, 2.85938919e-01f, 2.24921852e-01f,
  9.01164785e-02f, 2.68508315e-01f, 1.70505106e-01f, -1.75951689e-01f, 6.29425645e-02f, 1.70171142e-01f, -4.93644085e-03f, -2.12740973e-01f, 7.74154300e-03f, -3.47649902e-02f,
  6.41808333e-03f, -4.12251502e-02f, -7.19114840e-02f, -1.45995077e-02f, -2.64441818e-01f, -1.95469484e-02f, 3.67232151e-02f, -1.79038003e-01f, -1.30534366e-01f, -1.18724443e-01f,
  -8.90223458e-02f, -1.34904951e-01f, -1.17326669e-01f, -1.02525197e-01f, 2.74707619e-02f, 1.59346059e-01f, -1.30607948e-01f, 8.89200419e-02f, 8.22816696e-03f, -2.70240195e-02f,
  -8.66257176e-02f, 5.65082580e-03f, -1.71029389e-01f, -1.35125026e-01f, 4.71323989e-02f, 8.83238912e-02f, -1.53242424e-01f, 7.74632990e-02f, 5.00974543e-02f, -1.82662472e-01f,
  4.21103947e-02f, -1.50459990e-01f, 6.35071099e-02f, -1.76344037e-01f, 2.12579556e-02f, -3.07890207e-01f, 1.62504509e-01f, 2.81964213e-01f, 3.72674972e-01f, -1.56130627e-01f,
  2.10342675e-01f, -1.34939522e-01f, -1.74547255e-01f, -9.37084705e-02f, 4.42023762e-02f, -1.83626279e-01f, -7.47676194e-02f, 9.08442661e-02f, -4.50583780e-03f, 2.88181007e-01f,
  2.20640272e-01f, 1.81083173e-01f, -1.98827043e-01f, -2.31360316e-01f, -4.72808219e-02f, -2.17626859e-02f, -2.67472118e-01f, 1.31075690e-02f, -1.15611609e-02f, -3.06967020e-01f,
  -6.95123300e-02f, 1.33233115e-01f, 1.59085661e-01f, 5.19796908e-02f, 1.58522859e-01f, 6.71842620e-02f, -1.06149189e-01f, 1.22361675e-01f, 3.14218774e-02f, 3.30608748e-02f,
  9.77425873e-02f, 8.22323486e-02f, -3.66237722e-02f, 4.01066467e-02f, -6.25528768e-02f, 1.51223868e-01f, -1.37927055e-01f, 2.65482496e-02f, 1.93124060e-02f, -2.05620736e-01f,
  -1.26465142e-01f, 7.84320384e-03f, -1.91623062e-01f, -3.64971496e-02f, -1.06551960e-01f, 1.06867403e-03f, 1.27460852e-01f, 9.17448625e-02f, 2.25811694e-02f, -9.81499553e-02f,
  1.61906019e-01f, -6.86710849e-02f, 1.57361820e-01f, 1.65903121e-01f, -3.49361124e-03f, 2.23857477e-01f, -1.41906172e-01f, -4.96733077e-02f, 2.55045510e-04f, 3.12444032e-03f,
  -2.56812304e-01f, -1.30117744e-01f, 4.21340242e-02f, -7.30376691e-02f, -1.55424312e-01f, -1.83501750e-01f, 1.34318769e-02f, 3.29758763e-01f, -8.29169005e-02f, -1.73632607e-01f,
  1.52391687e-01f, 1.46985233e-01f, -2.68595040e-01f, 4.06223275e-02f, -2.61842608e-02f, 2.30278507e-01f, -1.07580818e-01f, 8.18392709e-02f, 2.48979047e-01f, 2.41065193e-02f,
  -1.05444625e-01f, 7.10404292e-02f, -1.20362677e-01f, -2.37793252e-01f, 5.45772053e-02f, 8.95032734e-02f, 1.83068424e-01f, -7.70868957e-02f, -2.50372022e-01f, 7.78692290e-02f,
  2.37724949e-02f, -4.01529782e-02f, -1.55971676e-01f, -2.69186273e-02f, -2.27184206e-01f, 6.25140965e-02f, -4.40814532e-02f, -7.00139254e-02f, 1.16406009e-01f, -1.99379742e-01f,
  -3.13131772e-02f, 2.29421481e-02f, -4.62983698e-02f, -2.29496248e-02f, -4.69019078e-02f, 1.50538072e-01f, 3.43894698e-02f, -2.74335005e-04f, -4.08331975e-02f, -4.32996526e-02f,
  -7.38738924e-02f, -2.17502087e-01f, 1.16046861e-01f, 3.75510082e-02f, -5.47555126e-02f, 1.49659798e-01f, -1.48115635e-01f, -1.96277380e-01f, 3.04285754e-02f, -1.93542987e-02f,
  -3.81954834e-02f, 7.88457692e-02f, 6.24351129e-02f, -8.92429128e-02f, -1.58707872e-01f, -3.22491586e-01f, 1.33998349e-01f, -2.42469981e-01f, 5.85623793e-02f, -3.41988176e-01f,
  8.70624930e-02f, 1.82028815e-01f, 9.25948322e-02f, -9.52496082e-02f, -9.20058042e-02f, -1.93847835e-01f, -8.77269432e-02f, 4.09265496e-02f, 2.18693763e-01f, -9.18084830e-02f,
  -7.40931705e-02f, -1.33260921e-01f, -1.41671989e-02f, 1.57427583e-02f, 9.78040621e-02f, -2.32305035e-01f, -4.36472557e-02f, -8.71011242e-02f, -1.85771689e-01f, -3.10751386e-02f,
  1.33111060e-01f, 5.96842766e-02f, 3.60330604e-02f, 1.35285392e-01f, -8.79880637e-02f, -1.39792427e-01f, 3.46940875e-01f, -1.07217096e-01f, -1.06907770e-01f, -2.16039661e-02f,
  1.03481628e-01f, 1.38374045e-01f, -4.63707000e-02f, -1.39434367e-01f, 1.61904737e-01f, 4.25124392e-02f, -4.64928485e-02f, 1.44521669e-01f, -4.27408852e-02f, 1.62299156e-01f,
  -6.49762526e-02f, 5.42192683e-02f, -1.72447279e-01f, 5.61854802e-02f, -1.76487744e-01f, -3.00694197e-01f, -9.89659950e-02f, -1.16541021e-01f, 3.81257087e-02f, 1.87085867e-01f,
  -8.45091492e-02f, -1.03938296e-01f, 1.31380334e-01f, -6.51052520e-02f, 1.24175295e-01f, -1.37584552e-01f, 5.41193001e-02f, -1.13943778e-01f, 6.30559474e-02f, -8.74197334e-02f,
  5.42260781e-02f, -1.37323901e-01f, -2.00490877e-01f, -2.03203604e-01f, -3.10296621e-02f, 2.94105820e-02f, 1.61995552e-02f, 7.41538107e-02f, -2.91297227e-01f, -1.90839060e-02f,
  2.08842546e-01f, 2.78893501e-01f, -1.21781804e-01f, -2.36393005e-01f, 1.35973975e-01f, -2.52530277e-02f, -1.21928424e-01f, 5.06585352e-02f, -2.82971151e-02f, -2.07299903e-01f,
  -4.82730754e-03f, 4.84404750e-02f, -8.88763368e-02f, -1.78391989e-02f, -1.58515841e-01f, 8.97004176e-03f, 1.46895602e-01f, 1.54711112e-01f, -1.42050952e-01f, 1.02048166e-01f,
  -1.77604511e-01f, 6.62929863e-02f, 6.17631972e-02f, 2.76774347e-01f, 9.56758931e-02f, 3.47854979e-02f, -4.32528295e-02f, -2.08783858e-02f, -1.28034085e-01f, 2.06738431e-02f,
  -1.25988618e-01f, -2.30287164e-02f, 1.11620679e-01f, -9.78680700e-02f, 6.94210036e-03f, 9.02860165e-02f, 1.23624347e-01f, -1.89919621e-02f, -3.28639112e-02f, 1.47551477e-01f,
  -8.02567694e-03f, 1.44999042e-01f, -2.09185168e-01f, 2.06652679e-03f, -1.17968075e-01f, 5.34288213e-02f, 8.74316841e-02f, -6.68583885e-02f, 1.19854666e-01f, -9.26128328e-02f,
  -1.36238486e-02f, 2.08797961e-01f, -1.47732854e-01f, -2.61208028e-01f, -1.80221587e-01f, 3.55403721e-01f, -1.50424158e-02f, -3.82165046e-04f, 2.42590576e-01f, 1.73984002e-02f,
  2.33088747e-01f, 4.82369363e-02f, 1.49289116e-01f, -9.86876711e-02f, -4.75431308e-02f, -2.47493401e-01f, 1.56889006e-01f, 1.13425314e-01f, 2.49134734e-01f, 1.40755475e-02f,
  1.40065001e-03f, -1.43111095e-01f, 2.90112883e-01f, 7.56652579e-02f, 8.72009099e-02f, -2.19655782e-02f, 1.11109495e-01f, 8.34242534e-03f, 8.31813216e-02f, 9.91479754e-02f,
  7.37099946e-02f, -1.11508854e-01f, -6.40716497e-03f, 8.99176970e-02f, 9.36839506e-02f, 2.11424530e-02f, -8.13176110e-02f, -9.05746147e-02f, 3.43533382e-02f, 6.50983974e-02f,
  1.79536909e-01f, 1.22178949e-01f, 3.21327522e-02f, 1.05999388e-01f, 8.43227580e-02f, -4.29901704e-02f, -4.47216369e-02f, 3.73198055e-02f, -2.54488573e-03f, 1.21751718e-01f,
  1.20070338e-01f, -1.02066636e-01f, 1.05337091e-02f, -1.97885502e-02f, 3.18692811e-02f, -6.13942146e-02f, 1.88415259e-01f, 1.45816028e-01f, -1.14807747e-01f, 3.60078621e-03f,
  -9.57112685e-02f, -5.32296896e-02f, 2.00928655e-02f, -9.78249088e-02f, 1.63650051e-01f, -1.89600855e-01f, 1.32100120e-01f, 9.89072770e-02f, 7.19582438e-02f, -1.71478078e-01f,
  6.20734878e-02f, -8.24482366e-02f, -2.51434054e-02f, -8.82475451e-02f, -2.35362902e-01f, 2.10916132e-01f, -1.68444335e-01f, -2.61165947e-01f, 2.71245033e-01f, 3.84820551e-02f,
  -1.69895962e-02f, -2.79644370e-01f, 1.45654693e-01f, 2.82570198e-02f, -2.52070516e-01f, -6.65959194e-02f, 1.47015467e-01f, -9.03272480e-02f, 5.37625365e-02f, 1.48025304e-01f,
  -1.25105903e-01f, -1.51070595e-01f, 1.15747172e-02f, 5.38510550e-03f, 2.19192252e-01f, -5.11196181e-02f, -1.24213815e-01f, 4.21392806e-02f, 2.41970584e-01f, -8.02283064e-02f,
  1.22409068e-01f, 1.38494074e-01f, 7.70848170e-02f, -1.12978354e-01f, 1.15596600e-01f, -1.10360682e-01f, -2.27896109e-01f, -1.22972578e-01f, -7.82382675e-03f, -1.30364776e-01f,
  -2.53188163e-02f, 4.27050143e-02f, 1.64150149e-02f, -2.55370624e-02f, -3.96861434e-02f, -8.14558715e-02f, -8.17790180e-02f, 1.44432709e-01f, -5.00274636e-02f, 1.06964551e-01f,
  -1.30501494e-01f, 3.44553366e-02f, 7.24091381e-02f, 1.38936350e-02f, -3.96724418e-02f, -8.56462866e-02f, 3.44997980e-02f, 2.30211932e-02f, -1.27972871e-01f, -5.37785441e-02f,
  2.46369198e-01f, 1.53702617e-01f, -8.07249993e-02f, 2.39190325e-01f, -5.11104055e-03f, 1.38524994e-01f, 2.36277469e-02f, -1.73224255e-01f, 1.42679408e-01f, -1.55304559e-02f,
  7.42397383e-02f, -1.19857781e-01f, 2.08601058e-02f, -1.30711719e-02f, 1.19208144e-02f, 1.13495268e-01f, 2.90926192e-02f, -1.16504908e-01f, -4.87993918e-02f, -1.34437993e-01f,
  5.70684075e-02f, 3.05006541e-02f, 1.01499461e-01f, -1.72080755e-01f, 9.41426456e-02f, -1.27071157e-01f, -6.35190457e-02f, 3.31557728e-02f, 1.04905009e-01f, 3.74069400e-02f,
  3.23122740e-02f, 1.93641216e-01f, -5.71594313e-02f, -9.95518565e-02f, -6.95968494e-02f, -1.00221850e-01f, -9.68180075e-02f, -7.10726604e-02f, 1.91687003e-01f, -3.26213017e-02f,
  -3.13175358e-02f, -2.27732912e-01f, -3.47084142e-02f, 1.06469482e-01f, 5.75113334e-02f, 1.12640671e-02f, 1.28528342e-01f, 6.97539300e-02f, -1.37210488e-01f, -4.72192205e-02f,
  -1.18761234e-01f, -3.13494466e-02f, 9.23997164e-02f, -7.49842869e-03f, 1.64927647e-01f, 1.53477922e-01f, 9.56442878e-02f, 8.67613591e-03f, -9.74659845e-02f, 3.90904630e-03f,
  -4.60449085e-02f, -9.78766009e-02f, 6.53028116e-02f, -2.66115427e-01f, 8.80451724e-02f, 3.22813123e-01f, 1.55117139e-01f, -2.61092037e-01f, 3.36069986e-02f, 3.10169980e-02f,
  -1.85089424e-01f, -4.57449615e-01f, -1.83328882e-01f, -5.43529950e-02f, -3.92758220e-01f, -1.84012026e-01f, 2.05535054e-01f, 2.18653321e-01f, -5.05917333e-02f, -1.45157233e-01f,
  -9.04074982e-02f, -2.55688727e-01f, -1.36326388e-01f, -6.81491196e-02f, -1.35854091e-02f, -3.76159772e-02f, 6.63881972e-02f, -1.84327625e-02f, -1.81061715e-01f, -1.45218760e-01f,
  -1.94003526e-02f, -8.84885490e-02f, 1.66623831e-01f, -9.14313719e-02f, 2.53086537e-02f, 3.79333347e-02f, 1.57542974e-01f, -6.65489677e-03f, 1.64302662e-01f, 4.60849591e-02f,
  9.07820240e-02f, -5.21222353e-02f, -3.04427613e-02f, -1.82856441e-01f, 1.16909370e-01f, -9.85532850e-02f, 5.54688461e-02f, 6.64185435e-02f, 1.28498068e-02f, 1.07699744e-01f,
  -6.62105531e-02f, 1.18783973e-01f, -1.95847392e-01f, -1.44253016e-01f, -2.27611735e-01f, -3.45027328e-01f, 1.07061364e-01f, 9.93772075e-02f, -1.76833421e-01f, 7.81509280e-02f,
  -5.52062467e-02f, -2.05036148e-01f, -6.47432730e-02f, -1.92467555e-01f, 8.82632658e-02f, 5.34012653e-02f, -7.62051046e-02f, -7.22805224e-03f, 6.98970556e-02f, 7.14202821e-02f,
  2.81935811e-01f, -1.25416815e-01f, -5.53711392e-02f, -2.05084998e-02f, -9.51442774e-03f, -5.85151725e-02f, -5.23442067e-02f, -5.39880991e-02f, -1.58071741e-01f, 6.42175749e-02f,
  6.05918355e-02f, 1.19669154e-01f, -5.75164985e-03f, -2.22839490e-02f, 3.25766467e-02f, -5.27223349e-02f, -1.23973601e-01f, 4.72509898e-02f, -5.01743108e-02f, -2.10695922e-01f,
  1.18597694e-01f, -1.43583208e-01f, -7.77876079e-02f, 2.14398071e-01f, 4.23333868e-02f, 1.10275261e-01f, 2.09612027e-01f, 5.28175710e-03f, -7.68342763e-02f, 6.95516244e-02f,
  -7.14822114e-02f, -3.11629456e-02f, 1.14150994e-01f, 3.40157121e-01f, 2.72573698e-02f, -4.10538055e-02f, 2.00542640e-02f, 8.26937780e-02f, 4.40222844e-02f, 6.01647235e-02f,
  9.37968269e-02f, -8.42529237e-02f, -1.25529161e-02f, 1.16166070e-01f, 1.59243643e-01f, 1.12305507e-01f, 6.06107488e-02f, 3.52263600e-02f, -5.38878478e-02f, 1.48819342e-01f,
  -2.28996873e-02f, -2.71219518e-02f, 2.40965020e-02f, -8.36369246e-02f, -9.71325412e-02f, 1.17449602e-02f, -1.55417677e-02f, 2.50090547e-02f, 6.66585714e-02f, -6.57716617e-02f,
  1.02654852e-01f, -5.80190346e-02f, 6.54063299e-02f, -4.98169847e-02f, 1.24086402e-01f, 7.52336308e-02f, 2.28621408e-01f, -1.34687245e-01f, 2.02443272e-01f, -2.29928121e-02f,
  2.79838413e-01f, -1.16637133e-01f, 1.27753094e-01f, 7.63714090e-02f, -1.49732322e-01f, -1.95537090e-01f, 1.79913729e-01f, 7.37363519e-03f, -1.44525662e-01f, -1.67044029e-01f,
  -5.38282394e-02f, 1.95866060e-02f, 6.87838346e-02f, 4.67585400e-02f, 6.37402907e-02f, -1.94153741e-01f, -6.44729361e-02f, -5.70353568e-02f, 1.73951447e-01f, -1.55855089e-01f,
  -1.14352822e-01f, -8.95532221e-02f, 7.62655884e-02f, -1.52369633e-01f, 4.70998973e-01f, -9.65950415e-02f, -8.68105069e-02f, -2.07057148e-01f, 6.27966151e-02f, 1.49527222e-01f,
  1.13466375e-01f, -8.13128147e-03f, -2.31705979e-02f, 1.26574677e-03f, 1.76196665e-01f, 7.94934183e-02f, 3.37568186e-02f, 1.80112913e-01f, 2.73410618e-01f, 1.50423914e-01f,
  2.49918383e-02f, 1.22151628e-01f, -8.61995891e-02f, 1.16259284e-01f, -6.16880208e-02f, 7.29976594e-02f, 1.04989357e-01f, 1.23879269e-01f, 1.31917983e-01f, 2.83328015e-02f,
  1.11320712e-01f, 4.06022631e-02f, 6.43379241e-02f, -1.37745127e-01f, 1.17895991e-01f, -2.46384904e-01f, 1.02273397e-01f, -5.77711202e-02f, 1.71281114e-01f, -1.86351255e-01f,
  -4.35135365e-02f, -2.53480405e-01f, -1.56774148e-02f, -1.18969064e-02f, 1.82360023e-01f, 1.09940227e-02f, -1.66944578e-01f, -2.60783106e-01f, -7.41975978e-02f, 2.18409598e-01f,
  2.35087395e-01f, -1.22232614e-02f, 1.45374000e-01f, -2.00777501e-01f, -2.01087385e-01f, 1.64514601e-01f, 9.88039970e-02f, -6.54360875e-02f, 1.26776725e-01f, -5.94491251e-02f,
  -7.73442462e-02f, -2.13094614e-02f, 2.60694444e-01f, -3.90035957e-02f, 1.85463220e-01f, -1.46299496e-01f, -1.25487030e-01f, -2.85913069e-02f, 2.71296650e-01f, -1.21094808e-01f,
  -1.53953871e-02f, -1.64491400e-01f, 3.53722908e-02f, 9.59469303e-02f, 1.44232482e-01f, -5.09058079e-03f, 4.95210774e-02f, -2.00195655e-01f, -4.05974388e-02f, 2.19806492e-01f,
  -1.05296843e-01f, 1.52800791e-02f, 4.22866121e-02f, -5.91841200e-03f, -2.12218165e-02f, -1.80822145e-02f, 7.00646266e-03f, -1.24879964e-01f, -4.05682512e-02f, -1.10838257e-01f,
  1.65652409e-01f, 8.75341967e-02f, 4.31829691e-02f, -9.81432125e-02f, 3.51744681e-03f, -1.04288489e-03f, 5.65295480e-02f, 4.26439233e-02f, -9.19019207e-02f, -3.47852468e-01f,
  3.07820924e-02f, 7.80414939e-02f, 2.66361326e-01f, -2.19009906e-01f, -2.85536405e-02f, -9.03407559e-02f, -2.76164293e-01f, -1.56520620e-01f, 1.42813185e-02f, 2.78685475e-03f,
  -3.48278970e-01f, -1.81036830e-01f, 1.11536890e-01f, 3.46090168e-01f, 1.76163949e-02f, -1.22270867e-01f, -6.81664199e-02f, -1.72029510e-01f, -1.81930110e-01f, 1.55267417e-01f,
  -7.37598762e-02f, -1.43414825e-01f, 1.43528312e-01f, -7.76038170e-02f, -9.92721245e-02f, -1.27921775e-01f, -7.12704659e-02f, -5.39895669e-02f, 2.93232501e-01f, -6.34075776e-02f,
  -6.85997903e-02f, 3.25562842e-02f, 1.42313853e-01f, 6.93112984e-02f, 9.34118703e-02f, 5.46050034e-02f, -5.33186570e-02f, -1.02496147e-01f, 1.79464430e-01f, 5.24783023e-02f,
  1.32456869e-01f, -5.76931005e-03f, 6.89474270e-02f, 9.79759395e-02f, -1.13488995e-01f, 6.97226077e-02f, -9.07842517e-02f, 5.44439144e-02f, -1.18736671e-02f, -6.37806654e-02f,
  -1.14326261e-01f, -7.37104118e-02f, -1.60672683e-02f, 1.16340883e-01f, 4.19955403e-02f, 5.61139397e-02f, -3.35789621e-02f, -1.26196608e-01f, -1.63797494e-02f, -1.12605251e-01f,
  1.36929408e-01f, 3.25895846e-02f, 1.49437413e-01f, 2.36871317e-01f, 1.65326610e-01f, 3.46270591e-01f, -1.32136112e-02f, -9.06688496e-02f, 2.73181707e-01f, 3.02306730e-02f,
  -7.77196651e-03f, -3.23805422e-01f, -3.16425741e-01f, 3.43521833e-01f, -1.69090211e-01f, 8.92074630e-02f, 1.43999696e-01f, -9.31776967e-03f, 6.38362914e-02f, -1.66983336e-01f,
  -1.64254960e-02f, -1.60050377e-01f, -2.26884764e-02f, 5.05509414e-02f, 5.70829399e-02f, 1.00969709e-01f, 1.25337660e-01f, 2.20458671e-01f, 9.72984359e-02f, 1.75169408e-01f,
  -1.50323868e-01f, 3.26946639e-02f, 2.29079917e-01f, 6.82943165e-02f, -1.24165587e-01f, -4.18124497e-02f, 1.68583199e-01f, -1.58062205e-01f, 7.07790628e-02f, 2.32590318e-01f,
  1.16143331e-01f, 7.43067786e-02f, 3.04860296e-03f, 9.90200862e-02f, -6.86935754e-03f, 2.77992319e-02f, -1.50659516e-01f, -9.43965912e-02f, 1.72419474e-01f, -2.20646728e-02f,
  1.88116431e-01f, 1.14544995e-01f, -1.45501852e-01f, -4.78960127e-02f, -3.98752838e-02f, 2.35252753e-01f, 2.17175148e-02f, 5.33958972e-02f, -4.94210683e-02f, -9.98317972e-02f,
  4.64737788e-02f, -1.01025328e-02f, -5.32992650e-03f, -3.95624749e-02f, -1.08810412e-02f, -6.03672899e-02f, -1.04893431e-01f, 1.31172286e-02f, 7.63225928e-02f, 4.02242094e-02f,
  -1.56902388e-01f, 1.21758327e-01f, -2.31764093e-01f, 8.31783488e-02f, -1.42862260e-01f, 8.11036304e-02f, 6.00886010e-02f, 5.59984520e-03f, -2.42224231e-01f, -8.80386904e-02f,
  1.01815164e-01f, -4.87762801e-02f, -1.23469949e-01f, -7.59672699e-03f, 2.01040313e-01f, 1.22997232e-01f, -4.15800698e-02f, 1.32473022e-01f, 1.86718985e-01f, -9.86642390e-02f,
  -8.76805261e-02f, 2.08160326e-01f, 1.82015002e-02f, -5.11054993e-02f, 2.60359012e-02f, 7.74913952e-02f, -8.40763599e-02f, 3.49499434e-02f, -1.04516536e-01f, 1.00593254e-01f,
  -3.86978894e-01f, -1.31338567e-01f, -2.54252832e-02f, -1.99300170e-01f, 5.85656539e-02f, -1.20323505e-02f, -4.86518554e-02f, -8.65397602e-02f, -1.83605194e-01f, 1.47818541e-02f,
  8.66045728e-02f, -8.80423188e-02f, -1.88246241e-03f, -1.87127605e-01f, 1.36579778e-02f, 8.83131940e-03f, -1.38783753e-01f, -6.10512942e-02f, 1.09658623e-02f, -2.59634517e-02f,
  7.62413368e-02f, -1.01285158e-02f, -1.04759492e-01f, -1.47242159e-01f, -1.18931383e-02f, 7.93487877e-02f, 7.91311041e-02f, 4.02706936e-02f, -1.44149318e-01f, 1.19848616e-01f,
  3.27680111e-02f, -4.76188622e-02f, 7.65386745e-02f, 1.27892599e-01f, 1.19294181e-01f, -2.33812053e-02f, 1.88563064e-01f, 2.00457245e-01f, 1.11703172e-01f, -2.70690978e-01f,
  5.14598005e-02f, -1.57986492e-01f, 9.67918113e-02f, -3.18886130e-04f, 2.69651134e-02f, -1.28996074e-01f, -3.85186784e-02f, 7.28930696e-04f, 5.66053800e-02f, -2.31636956e-01f,
  -1.42552346e-01f, -5.74563816e-02f, -1.03282295e-01f, 2.52309471e-01f, 1.11387357e-01f, -1.74873963e-01f, 1.15414396e-01f, -1.65597454e-01f, -3.40425186e-02f, -3.69092785e-02f,
  6.16962761e-02f, -1.32761717e-01f, 8.03824738e-02f, -1.02742635e-01f, 2.27729365e-01f, 1.13907970e-01f, 7.85948113e-02f, -1.97546378e-01f, 6.51993752e-02f, 1.17008351e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.41957670e-01f, -6.30570129e-02f, -8.40238109e-03f, 2.17372417e-01f, -1.15696669e-01f, 1.18673369e-01f, 2.17911690e-01f, 2.47872487e-01f, 1.12781294e-01f, 1.80793658e-01f,
  1.98928267e-01f, -8.57296512e-02f, -1.53450400e-01f, -1.13475002e-01f, 2.81159375e-02f, 1.01791717e-01f, 7.18903244e-02f, 2.27685645e-01f, -3.54747437e-02f, -1.12503216e-01f,
  1.03405036e-01f, 5.87466955e-02f, 1.70947686e-01f, 9.62837040e-02f, 2.35907316e-01f, -1.45594239e-01f, 1.38316855e-01f, -2.62090683e-01f, -1.07982177e-02f, 1.79496273e-01f,
  -1.14730336e-01f, -2.80860901e-01f, 1.42314434e-01f, -2.60158796e-02f, 1.48996413e-01f, 1.04603477e-01f, -3.61718833e-02f, -4.30824220e-01f, 2.14950100e-01f, 4.60378230e-02f,
  1.13841899e-01f, -3.45957905e-01f, 2.87575573e-01f, 4.83200960e-02f, -1.30314857e-01f, 2.68163793e-02f, 3.74435425e-01f, -2.07487106e-01f, -7.40257278e-02f, 2.56206334e-01f,
  -2.09571019e-01f, 2.27719173e-02f, 1.36462227e-01f, -7.65257105e-02f, 3.29134077e-01f, 1.59982607e-01f, -7.71239698e-02f, 3.38348627e-01f, 2.08319917e-01f, 4.00946252e-02f,
  1.51359245e-01f, 9.22074541e-02f, 1.94919761e-02f, -6.79552555e-02f, -5.86728193e-02f, -7.78143182e-02f, 7.00441599e-02f, 1.32536853e-03f, -2.00563837e-02f, -2.33304761e-02f,
  5.63250929e-02f, 1.57948032e-01f, -1.34216160e-01f, 1.36173755e-01f, -4.05779444e-02f, -9.79480222e-02f, 1.57391448e-02f, -1.34371266e-01f, 1.99394245e-02f, 1.23194329e-01f,
  7.39851370e-02f, -1.91780720e-02f, -4.55505494e-03f, -1.08881883e-01f, -6.16337694e-02f, 1.49336338e-01f, -5.57718314e-02f, -8.33439082e-02f, -2.39120331e-02f, 1.10653639e-01f,
  5.67164756e-02f, -7.70505443e-02f, -6.11895435e-02f, -1.14973567e-01f, 6.31135181e-02f, -2.62003932e-02f, 1.04454216e-02f, 3.58296447e-02f, 7.84818381e-02f, -7.59380907e-02f,
  7.60268718e-02f, -1.91153213e-01f, -5.78920357e-02f, 1.36316046e-01f, 3.51417661e-02f, -1.50995910e-01f, -3.49229351e-02f, 5.14233038e-02f, 4.56593893e-02f, -6.34713396e-02f,
  1.20328311e-02f, -5.23185357e-02f, -2.16289349e-02f, 7.41232410e-02f, -1.26708969e-01f, -1.09609015e-01f, 4.89322655e-02f, 6.05236404e-02f, 1.98186263e-01f, -7.17370510e-02f,
  3.10632084e-02f, 4.49023210e-02f, 3.33805606e-02f, 1.53755192e-02f, 4.76514846e-02f, -1.11081362e-01f, 8.38449895e-02f, -4.59607728e-02f, 2.18233955e-03f, -1.88121926e-02f,
  1.45962462e-01f, -5.75741753e-03f, 8.06342885e-02f, 2.16603518e-01f, -2.45601777e-02f, -1.62386462e-01f, -2.16854885e-01f, 6.31589582e-03f, 1.60877973e-01f, 6.29792437e-02f,
  1.08234659e-01f, -8.92627016e-02f, 1.63971633e-01f, 1.27148792e-01f, 1.26895741e-01f, 2.07811162e-01f, 1.93303883e-01f, 1.99311212e-01f, -1.73371248e-02f, -1.01759592e-02f,
  5.37052425e-03f, 1.85905501e-01f, 1.90872326e-01f, 1.23763857e-02f, -1.03020437e-01f, 1.81996033e-01f, -1.03465483e-01f, 3.90692800e-02f, -1.43863447e-02f, 1.68797150e-02f,
  -2.07993224e-01f, -1.81695789e-01f, -2.28421047e-01f, 1.32082924e-01f, 9.75775495e-02f, 2.19380945e-01f, -4.05483786e-03f, -8.53788778e-02f, -1.98367283e-01f, 4.95540909e-02f,
  -1.21341214e-01f, 1.25933287e-03f, 5.98974638e-02f, 7.31209815e-02f, -2.11842954e-01f, 7.09161013e-02f, -1.09249547e-01f, -5.70391864e-02f, 1.25157371e-01f, -3.68667804e-02f,
  -1.21704996e-01f, -8.14505592e-02f, -9.20528695e-02f, 1.06684148e-01f, 1.06508173e-01f, 4.74017411e-02f, -1.38935745e-01f, -9.36469585e-02f, -8.05885568e-02f, -1.02422908e-02f,
  1.20934539e-01f, -6.80766404e-02f, -1.45959985e-02f, 1.16356269e-01f, 7.14460015e-02f, 5.94264381e-02f, 2.55227029e-01f, -8.25151503e-02f, -3.87525260e-02f, -2.56056488e-02f,
  -1.47848614e-02f, -3.85768972e-02f, 7.24968240e-02f, 2.33783484e-01f, 3.46627206e-01f, 2.89568841e-01f, 1.09710902e-01f, 4.33547944e-02f, 1.34015996e-02f, 1.10611923e-01f,
  1.10810764e-01f, 3.14124197e-01f, 1.86080500e-01f, 2.01929674e-01f, 2.11493671e-01f, 1.53865471e-01f, -4.03078012e-02f, -2.83608437e-02f, -5.02450429e-02f, 2.87639648e-01f,
  1.65811837e-01f, -8.21277127e-02f, -2.45308116e-01f, 1.00653740e-02f, -2.07601897e-02f, -1.22711368e-01f, -1.23826982e-02f, -3.91597599e-01f, 7.80180991e-02f, 1.18545525e-01f,
  -2.37291440e-01f, 1.96850657e-01f, -5.41610159e-02f, 4.00277734e-01f, -4.54935357e-02f, 1.39551371e-01f, 2.79056113e-02f, 1.61325812e-01f, -1.80476591e-01f, -1.14082754e-01f,
  1.56351537e-01f, -2.75964797e-01f, 8.77535269e-02f, 2.46756952e-02f, 4.47488502e-02f, 1.83458149e-01f, 1.08039424e-01f, -1.16418406e-01f, 2.00913221e-01f, 6.53471574e-02f,
  -1.82549000e-01f, 1.79571100e-02f, -9.59366858e-02f, -1.65647089e-01f, -8.71956199e-02f, -1.80262290e-02f, -2.21902058e-02f, -5.13142720e-02f, -1.76866546e-01f, -2.70723589e-02f,
  1.85577963e-02f, -1.21961981e-01f, -1.19485818e-01f, 4.32233922e-02f, 4.34404314e-02f, 7.23022316e-03f, 1.43285573e-01f, 9.81643274e-02f, -5.88312931e-02f, 2.94293556e-02f,
  1.14104822e-01f, 1.89576596e-02f, -5.29616745e-03f, 5.54465652e-02f, -1.07641615e-01f, 5.83981909e-02f, -9.42777917e-02f, 4.65363590e-03f, 1.12156138e-01f, 4.94336821e-02f,
  4.34472859e-02f, 1.00081749e-01f, 1.17893994e-01f, 1.98253706e-01f, 8.31361935e-02f, 5.76805370e-03f, -8.44032783e-03f, 1.59104113e-02f, 5.86112253e-02f, -8.18787664e-02f,
  -9.43135992e-02f, -1.17464602e-01f, -3.82468365e-02f, -1.84367850e-01f, 1.76984861e-01f, -5.66003099e-02f, -5.51470146e-02f, -1.51948184e-01f, -1.12241030e-01f, 2.99517252e-03f,
  -6.89325482e-02f, -1.35007218e-01f, 8.53661522e-02f, 9.63005498e-02f, 1.44694448e-01f, 1.68973617e-02f, -4.21742722e-02f, -6.14597015e-02f, -1.16227821e-01f, 9.45867002e-02f,
  1.35841340e-01f, -1.19311027e-02f, 8.68868008e-02f, 1.33596525e-01f, 2.75209218e-01f, 4.92303222e-02f, 1.34774521e-01f, 3.65778990e-02f, 1.06586576e-01f, 1.08994938e-01f,
  -1.80506369e-03f, 1.22210480e-01f, -2.13360116e-02f, 1.54164642e-01f, 5.70362285e-02f, 8.38662237e-02f, 1.60641540e-02f, 4.87879887e-02f, 1.44052178e-01f, 7.71646500e-02f,
  7.81170204e-02f, -1.59814265e-02f, 1.04686998e-01f, 1.94328576e-01f, 1.45772964e-01f, 3.13391387e-02f, 6.93743601e-02f, 6.89759552e-02f, 1.11450762e-01f, 1.84660420e-01f,
  8.52258205e-02f, 1.10000744e-01f, 2.41369978e-01f, 1.49495021e-01f, 1.03897264e-03f, 2.35429779e-01f, -1.69784084e-01f, -7.66841024e-02f, -1.04204103e-01f, 2.84311235e-01f,
  3.75347435e-02f, 1.15671391e-02f, 2.66205937e-01f, -1.44219249e-02f, 2.09039912e-01f, -3.17269303e-02f, 1.90156788e-01f, -3.85710411e-02f, 5.73794916e-02f, -4.65544574e-02f,
  -7.63291121e-02f, 1.15197390e-01f, 4.63494435e-02f, 1.56460896e-01f, 3.55302095e-02f, 8.77587497e-02f, 2.02597126e-01f, -4.80963029e-02f, 1.06229074e-01f, 1.23451486e-01f,
  4.04164270e-02f, -1.78389311e-01f, -2.67470907e-02f, 4.13632356e-02f, 8.09255019e-02f, -1.09867111e-01f, 1.75196439e-01f, 1.27045065e-01f, 1.19091190e-01f, -7.45480061e-02f,
  -3.07530295e-02f, -1.71671025e-02f, -1.17619466e-02f, 5.57082966e-02f, 9.77646932e-02f, 8.85593593e-02f, 2.76443034e-01f, 1.48588106e-01f, 1.31963506e-01f, 1.41998947e-01f,
  1.59158915e-01f, 1.55172110e-01f, 7.58248940e-02f, 1.58722699e-02f, -6.77792057e-02f, 2.35324398e-01f, 1.98232442e-01f, -1.01453885e-01f, 8.28636736e-02f, 2.37355269e-02f,
  -1.52760348e-03f, 1.08731508e-01f, -4.71962579e-02f, 1.11208096e-01f, 1.11347996e-01f, -4.82251309e-02f, 8.67952406e-02f, 2.17868567e-01f, -6.39790893e-02f, -4.61558253e-02f,
  -2.19456956e-01f, -2.02118129e-01f, -5.69629367e-04f, -2.23610505e-01f, 7.02586100e-02f, 5.98208793e-02f, -2.25662619e-01f, 1.32126734e-01f, -2.25329310e-01f, 2.27842987e-01f,
  7.40661174e-02f, 6.94904849e-03f, -5.98335974e-02f, -1.89312458e-01f, -2.17297763e-01f, -1.26151100e-01f, -2.99699698e-02f, 8.27525556e-02f, 8.15378055e-02f, 2.49649417e-02f,
  -8.43425393e-02f, 8.20641220e-02f, 6.47909641e-02f, 2.25434914e-01f, -6.50306407e-04f, 1.03048094e-01f, 1.15397446e-01f, -4.45908159e-02f, -1.86174735e-01f, 1.89687297e-01f,
  -9.70209315e-02f, -3.03416342e-01f, -9.72620621e-02f, 5.18959314e-02f, 1.03509165e-02f, 3.27335626e-01f, 3.99108119e-02f, 1.19140446e-01f, -4.24742959e-02f, -8.14555287e-02f,
  7.75271058e-02f, 5.56629971e-02f, -1.16438493e-01f, 1.52871355e-01f, 6.75446307e-03f, 8.93199593e-02f, 3.24412733e-02f, 2.05329925e-01f, 1.49325013e-01f, 3.60221937e-02f,
  -6.36052042e-02f, 7.40222558e-02f, 7.99197108e-02f, -5.03636040e-02f, 5.24869747e-02f, 1.12010099e-01f, 9.68728065e-02f, -8.62075295e-03f, -1.56537518e-02f, 2.34941505e-02f,
  1.66499808e-01f, -3.16025428e-02f, 5.92942014e-02f, 1.13426827e-01f, 1.32365257e-01f, 4.92098480e-02f, 1.73927367e-01f, 1.94318563e-01f, 1.74883664e-01f, -1.92875326e-01f,
  3.01473737e-02f, -3.97314802e-02f, 1.71687663e-01f, 1.39544681e-01f, 7.89384078e-03f, -1.68407828e-01f, 1.14317082e-01f, 5.25409589e-03f, 2.54866183e-01f, -1.42662242e-01f,
  6.10061288e-02f, -8.80671665e-03f, -1.63123295e-01f, -2.67041586e-02f, 1.10854983e-01f, 1.55047188e-02f, -4.70517427e-02f, 8.76133814e-02f, -1.05974771e-01f, -2.89781801e-02f,
  9.16174352e-02f, -2.57899910e-02f, 1.24586336e-01f, -9.45971999e-03f, 1.02951378e-02f, 2.01413393e-01f, 1.33525565e-01f, 4.20184843e-02f, 1.22861251e-01f, -6.20743260e-02f,
  1.20510556e-01f, 1.23961374e-01f, -9.77021381e-02f, -9.57393497e-02f, 5.36584761e-03f, 2.59935167e-02f, -8.12101662e-02f, -9.65193436e-02f, -6.03390224e-02f, -7.24242330e-02f,
  -9.36355740e-02f, 6.45721927e-02f, 1.02502756e-01f, 1.25277787e-01f, 1.35930628e-01f, 8.51620883e-02f, 3.87609750e-02f, 1.15337566e-01f, 9.77188125e-02f, 9.17729214e-02f,
  1.73729077e-01f, 3.49250250e-03f, -2.93234270e-02f, -3.13863456e-02f, 1.06372043e-01f, 1.00020431e-01f, 1.98479936e-01f, 2.00020283e-01f, 4.24214415e-02f, -1.32390961e-01f,
  6.91137910e-02f, 1.97100312e-01f, 7.40927979e-02f, 7.82998875e-02f, 1.78419843e-01f, -2.94287857e-02f, 9.91721898e-02f, 1.56494588e-01f, 1.07917257e-01f, -2.17624730e-03f,
  2.85523739e-02f, -1.86825264e-02f, 1.59375563e-01f, -1.71101376e-01f, 1.06760718e-01f, -7.30196387e-02f, 1.54755861e-01f, 1.93936266e-02f, 1.42653614e-01f, 1.64508119e-01f,
  1.13613121e-01f, -3.72524075e-02f, 1.00512654e-01f, 1.23640545e-01f, -7.41673037e-02f, 3.25354957e-03f, -8.86423364e-02f, 1.29555672e-01f, -2.72358712e-02f, 4.00293767e-02f,
  1.81485236e-01f, -8.86268094e-02f, -1.06903948e-01f, 1.44065199e-02f, 3.08285542e-02f, -8.10510889e-02f, -8.49063993e-02f, 5.43945059e-02f, -6.78356066e-02f, 1.72264889e-01f,
  2.05361232e-01f, -1.17375754e-01f, -1.41603015e-02f, 1.34484157e-01f, 1.19281396e-01f, -3.66798192e-02f, 5.76999746e-02f, 1.14283971e-01f, -3.89167815e-02f, -1.16947964e-01f,
  6.81727454e-02f, 1.04627095e-01f, 1.23205252e-01f, 3.32786441e-02f, 5.80656379e-02f, 1.63459331e-02f, 1.28424779e-01f, 1.34107649e-01f, 3.56514826e-02f, 4.99354266e-02f,
  1.10407107e-01f, -7.23575205e-02f, -1.67037204e-01f, -1.51774272e-01f, -6.69397116e-02f, -1.92630038e-01f, 2.57238820e-02f, -1.57138467e-01f, 7.73415789e-02f, 8.52384791e-02f,
  1.49141088e-01f, -1.44134417e-01f, 2.09874600e-01f, -9.54062790e-02f, -1.10467799e-01f, 1.86903030e-01f, 2.71650814e-02f, 1.80593669e-01f, -8.24442226e-03f, 8.01595673e-02f,
  9.33441222e-02f, 1.55474856e-01f, 9.77140814e-02f, -1.98683724e-01f, -9.81682166e-03f, 1.05078235e-01f, -9.38663706e-02f, 2.99286675e-02f, 4.49400907e-03f, 4.38124724e-02f,
  7.23949745e-02f, -4.40730155e-03f, 1.56696826e-01f, 1.27795219e-01f, 5.68954162e-02f, -3.11539266e-02f, 1.92370918e-02f, -1.01999700e-01f, 1.08532943e-01f, -5.58921583e-02f,
  2.91143209e-02f, 7.37886354e-02f, 2.03965185e-03f, 1.49401695e-01f, 8.94761905e-02f, -1.10041294e-02f, 3.89092080e-02f, 2.08074078e-01f, -1.44957557e-01f, 9.52244401e-02f,
  -2.86755301e-02f, -7.86724389e-02f, -1.40835956e-01f, -5.32336198e-02f, 6.31587505e-02f, 1.96396671e-02f, -4.29377295e-02f, -9.31416005e-02f, 9.29391161e-02f, -9.58354473e-02f,
  1.58999950e-01f, 4.77128103e-02f, 7.74056613e-02f, -4.05656844e-02f, 1.65444419e-01f, 1.72017037e-03f, -2.62411237e-02f, -2.80590728e-02f, 7.33870566e-02f, -7.58766010e-02f,
  1.04566224e-01f, -1.84509337e-01f, 1.46122470e-01f, 9.49123353e-02f, -9.37145799e-02f, 1.14341184e-01f, -5.01683913e-03f, -5.85012101e-02f, -7.14309067e-02f, 5.40440492e-02f,
  1.60204604e-01f, -1.81885734e-01f, -6.57239333e-02f, -3.82086076e-02f, 4.80802543e-02f, -5.88567629e-02f, 9.15671587e-02f, 2.69508883e-02f, -3.83600816e-02f, 4.10115011e-02f,
  9.10962671e-02f, 1.95446357e-01f, 9.61527452e-02f, 7.60827586e-02f, 7.78042972e-02f, 1.94789037e-01f, -6.98828176e-02f, 1.80375487e-01f, -5.29225245e-02f, 9.30815190e-02f,
  -2.62462571e-02f, 3.33776832e-01f, -6.97555020e-02f, -9.37273353e-02f, -3.41767482e-02f, -9.41560939e-02f, -1.37026027e-01f, 1.76765367e-01f, -7.01417550e-02f, -6.58274442e-02f,
  3.57203744e-02f, -1.46578229e-03f, -9.09588337e-02f, 1.20281659e-01f, 1.52396798e-01f, 1.50337905e-01f, 7.42953643e-02f, 1.50682017e-01f, 8.82748738e-02f, 3.97113264e-02f,
  -6.24814406e-02f, 1.45215482e-01f, -2.86672506e-02f, 9.64451283e-02f, 1.83097254e-02f, 2.06678286e-01f, 4.25304435e-02f, -5.96399121e-02f, 1.07452303e-01f, 9.57295448e-02f,
  -1.46926463e-01f, 9.40706879e-02f, -9.44023728e-02f, 3.99423391e-02f, 1.32216215e-02f, 1.92613900e-02f, 1.89357042e-01f, 1.42954409e-01f, 8.54210705e-02f, -2.04192519e-01f,
  1.74178466e-01f, 5.80760976e-03f, 7.02977329e-02f, 5.38133979e-02f, -2.62997076e-02f, 1.58101663e-01f, 6.37275353e-02f, -3.30632776e-02f, 1.08476087e-01f, 7.55720725e-03f,
  1.85389966e-01f, -7.67434686e-02f, -7.82211497e-02f, 6.81516156e-02f, 1.01570845e-01f, -5.05876122e-03f, 4.00662515e-03f, -3.38990465e-02f, 5.10030463e-02f, -1.36176080e-01f,
  1.73733994e-01f, 1.04624726e-01f, 1.32907748e-01f, 2.64379550e-02f, 9.90314037e-02f, -1.65936232e-01f, -6.85453638e-02f, -3.38695198e-02f, 6.09787628e-02f, 2.33618659e-03f,
  1.34428263e-01f, -4.71614599e-02f, 1.40193269e-01f, 1.82586938e-01f, 1.26692533e-01f, 1.78345051e-02f, -1.15270004e-01f, -6.75752312e-02f, -1.44460186e-01f, 1.02678061e-01f,
  9.92806554e-02f, -5.86988181e-02f, 1.12273507e-01f, -7.51770101e-03f, -1.45104423e-01f, 2.94281803e-02f, 7.00204372e-02f, 6.38027862e-02f, 1.07069001e-01f, -8.70836079e-02f,
  -7.04075992e-02f, 6.90604523e-02f, 6.35766611e-02f, -1.47505045e-01f, 1.29038677e-01f, -1.45775795e-01f, -2.22914554e-02f, 1.95929214e-01f, 1.17549174e-01f, 8.24505016e-02f,
  4.49037962e-02f, 6.45599291e-02f, 3.10791600e-02f, 2.25577742e-01f, -5.11222966e-02f, -1.83939189e-01f, 1.97250426e-01f, 2.09818985e-02f, -6.64088354e-02f, -2.51434833e-01f,
  -6.46655485e-02f, -1.17633447e-01f, -4.03368585e-02f, 8.70101303e-02f, 2.82656252e-02f, 1.84812211e-02f, -2.69533899e-02f, -4.20641201e-03f, 4.87454571e-02f, -1.19894557e-01f,
  -9.76692587e-02f, -1.06972858e-01f, -1.06561393e-01f, 2.25747913e-01f, -9.97018367e-02f, 9.48957130e-02f, -3.61396745e-02f, 1.79157108e-02f, 4.54778001e-02f, 1.88872367e-01f,
  -1.19963251e-01f, 7.33599514e-02f, 4.31318171e-02f, 9.05128047e-02f, 1.56449392e-01f, -3.55672650e-03f, 3.78242359e-02f, -3.69060673e-02f, 8.15040544e-02f, 1.70030035e-02f,
  -6.86698258e-02f, -5.19688651e-02f, 1.56410262e-02f, 4.50261496e-02f, -5.54485135e-02f, 3.34448889e-02f, -3.58102880e-02f, -9.93015692e-02f, 1.12760767e-01f, -3.86325493e-02f,
  -2.31880695e-02f, 9.05340835e-02f, -7.86626786e-02f, 4.78955023e-02f, -9.01440829e-02f, -2.01280392e-03f, 6.80705979e-02f, -9.17915925e-02f, 1.17361091e-01f, 5.58261685e-02f,
  -5.66165075e-02f, 4.82043847e-02f, 1.48624808e-01f, -7.30781779e-02f, -1.54402047e-01f, 6.73694313e-02f, -1.24061204e-01f, -6.48255646e-02f, -4.67977813e-03f, 1.16715342e-01f,
  1.63052857e-01f, -1.03154019e-01f, 2.64803693e-02f, -1.43533692e-01f, 6.49530664e-02f, -1.26069829e-01f, 1.18446432e-01f, 4.09823209e-02f, -5.75424023e-02f, 1.21399388e-01f,
  -1.10964276e-01f, 4.36373428e-02f, -1.31850794e-01f, -1.01985283e-01f, -3.66619863e-02f, -4.99652773e-02f, -4.56539840e-02f, 7.28629604e-02f, -1.28109112e-01f, 1.21989511e-01f,
  -8.48614722e-02f, -1.61382202e-02f, -3.97853553e-02f, -1.66967791e-02f, -5.67016266e-02f, -8.52502510e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  1.42806560e-01f, 1.60750166e-01f, -1.93864387e-02f, 2.44105309e-01f, 6.00746600e-03f, -3.30463871e-02f, 4.95427921e-02f, 6.70612976e-02f, 5.57482652e-02f, 2.05527712e-02f,
  -6.94825053e-02f, 2.05899104e-01f, -4.47964780e-02f, 9.56578255e-02f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  -3.59772861e-01f, 1.30937040e-01f, -7.66282007e-02f, -1.13985382e-01f, -2.57410556e-01f, -1.05437741e-01f, 3.60963121e-02f, -1.28137618e-01f, -2.90125191e-01f, -1.36120602e-01f,
  3.73538071e-03f, -4.02124882e-01f, -3.22585136e-01f, 3.50730196e-02f, 3.09591088e-02f, -3.92644197e-01f, -3.60278375e-02f, -6.10671818e-01f, 7.81869888e-02f, -2.15826780e-01f,
  -2.63162374e-01f, -3.36562186e-01f, -2.81159341e-01f, -2.55607545e-01f, -2.55874068e-01f, -1.73998922e-01f, -7.03185936e-03f, 3.33649367e-01f, -3.72309864e-01f, -7.96817616e-02f,
  2.95582712e-01f, -1.85256228e-01f, -1.39123082e-01f, -1.48500875e-01f, -1.31103203e-01f, 2.21522242e-01f, -3.24280918e-01f, 4.56523716e-01f, 4.42717597e-02f, 7.23640174e-02f,
  -6.04113750e-02f, 2.22331174e-02f, 1.85818106e-01f, 1.77882627e-01f, 1.87511712e-01f, 3.65316682e-02f, 2.83352405e-01f, 7.26035684e-02f, -1.57234639e-01f, 3.19014251e-01f,
  2.87886739e-01f, 2.13574290e-01f, -2.58592051e-02f, -2.31121197e-01f, 4.68938023e-01f, -8.63010138e-02f, -2.38515139e-01f, 2.80646980e-01f, 7.15358034e-02f, 1.80312665e-03f,
  5.55722155e-02f, 1.66821018e-01f, -1.63485348e-01f, -7.73095936e-02f, 6.18520267e-02f, -1.66223392e-01f, -2.87266783e-02f, 1.25650853e-01f, 7.56263882e-02f, 1.57103404e-01f,
  2.07964391e-01f, 1.14702247e-01f, 1.37506500e-01f, 2.56072789e-01f, 2.81110883e-01f, -5.18576682e-01f, 2.14429647e-01f, -3.48555177e-01f, 1.26712292e-01f, -1.99373856e-01f,
  7.03565925e-02f, 1.50102573e-02f, -1.91062570e-01f, 2.60913879e-01f, -2.16928467e-01f, -2.92323921e-02f, -2.26670414e-01f, 3.63862485e-01f, -1.16649315e-01f, 2.14787409e-01f,
  -2.96754986e-01f, -3.15442950e-01f, -3.32186401e-01f, -1.59769475e-01f, -4.59988832e-01f, 7.46028647e-02f, -1.19474500e-01f, -1.61140397e-01f, -8.44449177e-02f, 1.66207254e-02f,
  3.48589450e-01f, 7.28083998e-02f, 4.53741223e-01f, 1.68583021e-01f, 2.07087472e-01f, 1.96723983e-01f, 8.17208141e-02f, 3.84172171e-01f, -1.19939677e-01f, 9.75610316e-02f,
  7.92648122e-02f, -4.54110056e-02f, 1.28258765e-01f, -2.61072479e-02f, 8.39434385e-01f, 1.50598884e-01f, -2.40716726e-01f, -6.83231771e-01f, 1.98217761e-02f, -1.20020173e-01f,
  -3.19703251e-01f, 3.87472183e-01f, 1.19900279e-01f, -1.99701473e-01f, 3.70460123e-01f, -2.23699003e-01f, 3.19147885e-01f, 1.13849156e-01f, -1.48079425e-01f, -1.18707150e-01f,
  1.21682435e-01f, 4.39719073e-02f, 1.81797445e-01f, 1.75779805e-01f, 1.33943275e-01f, 1.76682726e-01f, 3.69730949e-01f, 9.88873765e-02f, 2.01225370e-01f, 3.47610533e-01f,
  -2.80505776e-01f, -9.30676162e-02f, 6.61727488e-02f, -2.95801517e-02f, -1.19174317e-01f, 2.84726560e-01f, -2.40466729e-01f, -5.88401139e-01f, -5.06113529e-01f, 1.62867546e-01f,
  3.64198327e-01f, -1.83109995e-02f, 3.62700135e-01f, -2.92978436e-01f, 3.27532917e-01f, 2.32609734e-01f, 4.20611262e-01f, -4.53739524e-01f, 2.17614874e-01f, 3.55432272e-01f,
  -5.70283271e-02f, 1.33190617e-01f, -1.70876727e-01f, 7.47768059e-02f, 4.72237505e-02f, 3.34415913e-01f, -2.77892858e-01f, 1.17616095e-01f, 2.01260388e-01f, -1.12445757e-01f,
  1.16463237e-01f, -1.86501488e-01f, 3.33336890e-01f, -1.13540463e-01f, 2.28120551e-01f, -1.99512705e-01f, -1.43515721e-01f, 3.83682386e-03f, 2.19862968e-01f, -1.05363220e-01f,
  -2.40032867e-01f, -4.69675399e-02f, -1.78804278e-01f, 2.62772948e-01f, 5.73084950e-02f, 2.08574995e-01f, 8.15809220e-02f, 2.98616350e-01f, -7.80439004e-03f, 2.47151367e-02f,
  5.46033829e-02f, -1.18237920e-01f, -1.98920563e-01f, 1.70824379e-01f, -2.31932238e-01f, 1.95583135e-01f, -3.09579372e-01f, 1.54578999e-01f, 4.09556478e-02f, -2.96385642e-02f,
  -1.05531283e-01f, -2.87606746e-01f, 3.09866279e-01f, 2.91491449e-01f, 1.78577796e-01f, -4.02900398e-01f, 6.46713600e-02f, 2.80153304e-01f, 1.87036507e-02f, 4.32218552e-01f,
  -4.01910916e-02f, -2.94688642e-01f, 2.24250212e-01f, 1.69785097e-02f, -1.24484636e-02f, -4.38918583e-02f, -1.15603827e-01f, -1.55387118e-01f, 1.44333601e-01f, 5.36018908e-01f,
  1.47089601e-01f, -2.93447673e-01f, 2.32451856e-01f, -4.94669288e-01f, -4.06503022e-01f, -3.60963255e-01f, -1.40917271e-01f, -3.10140938e-01f, -4.15786132e-02f, -3.55901092e-01f,
  -3.32510978e-01f, 3.17581415e-01f, -1.33034065e-01f, 3.61183621e-02f, -6.92520738e-02f, -3.96398485e-01f, 4.95523699e-02f, 1.85848445e-01f, -6.38887465e-01f, 3.38126510e-01f,
  -4.97484803e-02f, 3.86756003e-01f, -3.71716022e-01f, -1.42537430e-02f, -2.82313093e-03f, 5.15960380e-02f, 1.06216155e-01f, 8.94976556e-02f, -1.82691619e-01f, 4.89330962e-02f,
  3.72581929e-01f, -1.64288700e-01f, -1.26797659e-02f, 1.40464287e-02f, -7.89254829e-02f, -1.38366490e-03f, -4.93956953e-02f, 3.24253291e-02f, 3.70403498e-01f, 9.77416337e-02f,
  -3.39940608e-01f, -7.18078911e-02f, 1.44827858e-01f, 2.25564331e-01f, 1.05769627e-01f, -2.39475876e-01f, -2.26344198e-01f, 2.63658464e-01f, 1.77538455e-01f, 2.44600568e-02f,
  1.00151412e-01f, 2.01710939e-01f, -1.39110778e-02f, 1.64682101e-02f, 2.48241290e-01f, -2.44662035e-02f, 9.59876627e-02f, 2.28291124e-01f, 2.58888870e-01f, -6.98967203e-02f,
  -3.51788104e-01f, -3.06023061e-01f, 2.07527190e-01f, -5.24875522e-02f, -3.95485222e-01f, -2.79268265e-01f, 3.44333440e-01f, 2.91836172e-01f, 3.89743179e-01f, -2.73049802e-01f,
  -3.10774624e-01f, 4.94756401e-01f, -2.69803017e-01f, -1.94326729e-01f, -4.81537670e-01f, -6.05877638e-02f, 1.63395733e-01f, 3.71178359e-01f, 5.28721094e-01f, 7.44499192e-02f,
  2.92132378e-01f, 3.49988282e-01f, 3.84989083e-01f, 3.54879349e-01f, -2.97062010e-01f, 4.22025114e-01f, -5.14555752e-01f, -1.70365930e-01f, -3.92561927e-02f, 3.87752086e-01f,
  7.81625062e-02f, -2.27549449e-02f, -2.05683172e-01f, -2.05976009e-01f, -2.41045967e-01f, -1.48148060e-01f, 9.29863006e-02f, -2.85060182e-02f, -3.53913270e-02f, -1.09233782e-01f,
  1.06004775e-01f, -2.08543479e-01f, -3.67473960e-01f, -1.85741827e-01f, 1.91722348e-01f, 2.85869181e-01f, 3.49665619e-02f, 2.82425761e-01f, 2.35656172e-01f, 2.11850494e-01f,
  7.39364102e-02f, 4.92697991e-02f, -5.00006191e-02f, 5.04480749e-02f, 1.30646795e-01f, -3.29093814e-01f, 2.65125986e-02f, 3.46316211e-02f, 1.26842797e-01f, 2.80440688e-01f,
  6.54989183e-02f, -6.34978246e-03f, 4.35401089e-02f, 1.96027815e-01f, 1.21485017e-01f, -3.16954315e-01f, -6.28342211e-01f, -3.90546173e-01f, -3.83952886e-01f, -3.10329616e-01f,
  -5.84258176e-02f, 3.55275184e-01f, 3.30069691e-01f, -1.88751847e-01f, 1.68250874e-01f, -2.77781874e-01f, -5.47446370e-01f, -3.31808269e-01f, 2.16355771e-01f, -3.15161675e-01f,
  4.19711322e-01f, -3.55710313e-02f, 3.82575959e-01f, -1.37913868e-01f, -4.00927514e-01f, 3.31429809e-01f, 2.38173857e-01f, 3.78764510e-01f, 2.94859171e-01f, -1.99280098e-01f,
  8.72736424e-02f, 5.94823956e-02f, 9.74688753e-02f, 2.79013246e-01f, 7.76093975e-02f, 7.72335082e-02f, -1.43477485e-01f, -6.87870830e-02f, -1.09291844e-01f, 1.17161661e-01f,
  -1.17144175e-02f, 1.09018661e-01f, -2.91935623e-01f, -4.97730374e-02f, -2.68535577e-02f, 2.47237515e-02f, 3.22280884e-01f, -2.47347638e-01f, -1.82765275e-01f, 1.34269178e-01f,
  5.80236875e-03f, -3.49347830e-01f, -4.30475265e-01f, -1.39109753e-02f, 2.46335968e-01f, -3.36656988e-01f, -1.71019435e-01f, -2.28287708e-02f, 1.87357813e-01f, 6.46644458e-02f,
  1.29076848e-02f, -1.56917289e-01f, -5.23523167e-02f, 4.55784574e-02f, -1.54138699e-01f, 1.42285928e-01f, -4.30027515e-01f, 1.81062929e-02f, 1.11820459e-01f, 2.00791284e-01f,
  1.72447771e-01f, 4.60409224e-02f, 1.25682801e-01f, 5.38888156e-01f, 1.26692489e-01f, 1.78914025e-01f, 1.23852603e-01f, 4.41590905e-01f, 6.06860220e-01f, -7.62812495e-02f,
  3.64103854e-01f, 2.45356485e-01f, -3.09967581e-04f, 1.55602813e-01f, -2.83334613e-01f, -1.59359977e-01f, -5.33775330e-01f, -1.56323850e-01f, 9.34500918e-02f, 2.64245450e-01f,
  -1.99170634e-01f, -3.93336624e-01f, -4.23371280e-03f, -1.91656709e-01f, 9.22119245e-03f, 1.71518400e-01f, -1.73604012e-01f, 2.71859825e-01f, 6.58381209e-02f, -1.05814040e-01f,
  -1.45332396e-01f, -2.38170549e-01f, -1.60946026e-01f, 4.40495878e-01f, 1.09111266e-02f, 2.01244056e-01f, -2.14323439e-02f, -6.84745312e-02f, -6.94360435e-02f, -7.58239776e-02f,
  -3.88493463e-02f, -4.93772924e-01f, -4.34021372e-03f, 1.26789898e-01f, -2.40591168e-01f, 1.76420331e-01f, 1.02779441e-01f, -2.64369994e-01f, 4.41309586e-02f, -2.17789933e-01f,
  1.16890548e-02f, -5.03374115e-02f, -5.89977987e-02f, 6.71571791e-02f, -3.34349245e-01f, -2.48286188e-01f, -2.30285078e-01f, 1.32630184e-01f, 2.12957814e-01f, 4.21070121e-02f,
  1.83249880e-02f, -3.03326041e-01f, -2.72951365e-01f, 2.68101636e-02f, 2.87883967e-01f, -6.83079064e-02f, 4.88938779e-01f, 2.87683845e-01f, 3.46231437e-03f, -5.57395160e-01f,
  3.09943315e-02f, 5.04379645e-02f, -3.19544017e-01f, 3.02875727e-01f, 4.19896752e-01f, 2.34435022e-01f, 3.36673677e-01f, -1.94124907e-01f, -5.92006668e-02f, -3.40487659e-01f,
  -4.05399680e-01f, 5.27234018e-01f, -2.00909317e-01f, -1.43106505e-01f, -1.55898660e-01f, 3.39625597e-01f, -3.31459910e-01f, -2.15465546e-01f, 6.61360286e-03f, 6.85629472e-02f,
  1.66210487e-01f, -1.68185145e-01f, -1.24969982e-01f, -2.26016030e-01f, 4.29569542e-01f, -4.67497893e-02f, 1.74051244e-02f, 1.47268295e-01f, 4.92782265e-01f, -7.18953907e-02f,
  -7.24359229e-02f, -5.97894415e-02f, -4.75580655e-02f, -7.93890841e-03f, 1.57548025e-01f, 1.14587553e-01f, -5.16651161e-02f, -5.19365191e-01f, 1.09826988e-02f, -9.51548517e-02f,
  1.14718955e-02f, -4.85170819e-02f, -6.51653767e-01f, 1.63128152e-01f, 1.54216979e-02f, 1.22118130e-01f, 1.86153185e-02f, 8.41476396e-02f, 3.80744040e-02f, -8.25118646e-03f,
  -6.43985346e-02f, 6.27078041e-02f, 3.35492909e-01f, -6.21276237e-02f, 3.04437846e-01f, -9.98335555e-02f, 5.69115393e-03f, 2.68041044e-01f, -4.16056663e-01f, -6.69013262e-02f,
  -2.03874838e-02f, 5.39699912e-01f, -1.68296412e-01f, 7.46250823e-02f, -2.64741898e-01f, -7.06785545e-02f, 4.99089658e-01f, -2.68959612e-01f, -2.19346389e-01f, -7.21793100e-02f,
  8.17858204e-02f, 2.70744085e-01f, 2.37854328e-02f, -1.52958751e-01f, -4.84084964e-01f, -1.39200836e-01f, -2.45506257e-01f, -2.66580224e-01f, -3.42061669e-01f, -6.55065626e-02f,
  4.08985078e-01f, -4.24684078e-01f, 1.89426318e-01f, -1.05676889e-01f, -1.69751748e-01f, -3.26644272e-01f, -4.35110219e-02f, 2.54460245e-01f, 5.04304826e-01f, -1.28571644e-01f,
  5.06148227e-02f, -1.65836260e-01f, -6.68471009e-02f, -1.26092494e-01f, 1.19275421e-01f, -1.12090260e-01f, 1.55627266e-01f, -1.84051424e-01f, -3.06430340e-01f, 2.92010128e-01f,
  3.97656888e-01f, -5.44844056e-03f, -3.10832262e-01f, -2.82859474e-01f, 1.39281049e-01f, 3.34876001e-01f, -9.64029804e-02f, 2.47511920e-02f, 1.36297390e-01f, 1.38525590e-01f,
  -1.17326202e-02f, 2.52402693e-01f, -5.63710406e-02f, 3.13871503e-01f, 3.55767757e-02f, 2.19666645e-01f, -3.25798780e-01f, -6.04114793e-02f, 2.50170231e-01f, 1.07415922e-01f,
  9.88968387e-02f, 7.78261870e-02f, 4.16184545e-01f, -5.40167570e-01f, 2.65255094e-01f, 5.02392128e-02f, 1.38893753e-01f, 3.91287655e-01f, 2.81629741e-01f, 5.02133429e-01f,
  1.45577505e-01f, 5.43078423e-01f, 2.70566165e-01f, 2.41644204e-01f, 2.10139647e-01f, -4.31659102e-01f, -2.41244093e-01f, -1.23900570e-01f, 2.94877857e-01f, 3.47988844e-01f,
  2.05486372e-01f, 1.91666707e-01f, 5.09273171e-01f, -4.48807180e-01f, 4.92634960e-02f, -1.24626055e-01f, -3.47845674e-01f, -1.29852399e-01f, -2.76020057e-02f, 5.01788557e-01f,
  -1.48212478e-01f, -3.77186269e-01f, 3.06331702e-02f, -3.17390114e-02f, -8.23435783e-02f, -1.25527412e-01f, -1.68276444e-01f, -3.20921481e-01f, -5.13966382e-02f, 1.23915942e-02f,
  1.84084311e-01f, 1.33973897e-01f, -6.97066411e-02f, 3.23390923e-02f, 9.22297984e-02f, 1.09478220e-01f, -1.99267250e-02f, -1.86600164e-01f, -2.70827740e-01f, 6.65296763e-02f,
  6.46996871e-02f, 1.89584687e-01f, 8.23845528e-03f, 1.61929652e-01f, -1.63919300e-01f, 6.58696815e-02f, -3.66379283e-02f, 2.49444902e-01f, -2.38293111e-02f, 1.38405293e-01f,
  3.29126030e-01f, 9.16348323e-02f, -1.39108077e-01f, 2.14593008e-01f, 1.80953369e-01f, 2.08290681e-01f, 1.47998825e-01f, -1.95085809e-01f, -4.61836606e-01f, 4.05635536e-02f,
  -6.09125830e-02f, -3.97199780e-01f, -3.60658795e-01f, -2.18837336e-01f, -2.99188703e-01f, -2.80866176e-01f, -7.85306394e-02f, -2.13921562e-01f, 4.31413464e-02f, -3.60880166e-01f,
  2.37523213e-01f, -1.84557691e-01f, 3.29079747e-01f, -2.08457008e-01f, -3.82504910e-01f, -4.22207326e-01f, 5.71883135e-02f, 1.66638672e-01f, -1.62765592e-01f, -1.07192853e-02f,
  -4.19284493e-01f, -5.64155765e-02f, 5.14835596e-01f, -1.04883924e-01f, -8.46598223e-02f, -3.59290481e-01f, 4.00718123e-01f, -2.04188183e-01f, -4.10840176e-02f, -2.61154830e-01f,
  -9.35124680e-02f, -2.93900728e-01f, 3.04908156e-01f, 2.29750603e-01f, -4.06828299e-02f, 8.05779397e-02f, -2.37442300e-01f, 4.90284115e-02f, 2.74489433e-01f, -2.25464597e-01f,
  3.35948765e-02f, 4.81363460e-02f, -3.88603960e-03f, 2.37989709e-01f, -1.13999940e-01f, 1.16546184e-01f, 1.64526209e-01f, -3.22036818e-02f, -2.44004518e-01f, -1.80387557e-01f,
  1.50267094e-01f, -4.68123615e-01f, -1.28067568e-01f, 9.24865007e-02f, 3.88250232e-01f, -3.38007331e-01f, 1.48693696e-01f, 3.46546434e-02f, 4.26918007e-02f, 1.22337334e-01f,
  -2.10439101e-01f, 5.16004503e-01f, 2.94702351e-01f, -1.15169607e-01f, -3.87656599e-01f, 2.17339136e-02f, 1.91834569e-01f, 1.88568622e-01f, -1.52103409e-01f, -3.80074859e-01f,
  3.56934398e-01f, -2.26654902e-01f, -2.85759449e-01f, 2.66247302e-01f, -4.63008940e-01f, 1.73611585e-02f, -3.93569678e-01f, -1.79155618e-01f, 7.66033456e-02f, -2.37711921e-01f,
  -3.58314157e-01f, -4.62998569e-01f, 5.40489368e-02f, -7.14184865e-02f, -1.59214243e-01f, 3.21554355e-02f, 1.51932836e-01f, 3.16063762e-01f, -1.00930370e-01f, 2.98140407e-01f,
  -3.39408875e-01f, 2.28710324e-02f, 1.89244553e-01f, 4.18412089e-02f, -1.67413577e-01f, 3.13028336e-01f, -1.21140547e-01f, -1.25857919e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.63574815e-02f, 9.92102474e-02f, -1.59174621e-01f, 1.35457173e-01f, -5.95716527e-03f, 2.50573531e-02f, -2.07396671e-02f, 1.73665322e-02f, 1.60747081e-01f, 1.43766537e-01f,
  -1.17636368e-01f, 7.31735528e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    