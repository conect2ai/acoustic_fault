/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  5.70653558e-01f, 5.78671455e-01f, 4.71761487e-02f, 3.47350240e-01f, -8.77297968e-02f, -1.06187582e-01f, 8.69009271e-02f, 1.66403577e-01f, 7.87239149e-02f, 1.28328443e-01f,
  -7.91187733e-02f, -2.52675384e-01f, -1.25572965e-01f, -2.00584173e-01f, -1.15413345e-01f, 1.15887441e-01f, 1.16730593e-01f, -1.89503834e-01f, -2.65197873e-01f, -2.74582505e-01f,
  -6.05917312e-02f, 2.49484211e-01f, 1.23722315e-01f, 6.10388182e-02f, 9.53738987e-02f, -7.26405829e-02f, 1.38771608e-01f, -5.83690330e-02f, -2.51040552e-02f, 1.29721716e-01f,
  -2.49060214e-01f, 1.69070184e-01f, -1.26793608e-01f, 2.23001856e-02f, -5.34691364e-02f, 7.22591653e-02f, -2.40349844e-02f, -3.51163885e-03f, -1.33510511e-02f, 9.19357613e-02f,
  -1.95060018e-02f, -6.66984217e-03f, -3.04755149e-03f, -1.18747137e-01f, 7.87239969e-02f, -3.04585733e-02f, -3.79233435e-02f, -6.00986695e-03f, -4.64232750e-02f, -6.07501231e-02f,
  -1.48269638e-01f, 5.93318883e-03f, -9.12610963e-02f, -1.03726916e-01f, -7.54144713e-02f, -1.78965684e-02f, -5.36281280e-02f, -4.34918627e-02f, 2.89610401e-02f, 2.15544835e-01f,
  2.35950172e-01f, 9.30966064e-02f, 4.11645286e-02f, -2.72120200e-02f, 2.09269468e-02f, -9.23398733e-02f, 6.31675273e-02f, 2.45465245e-03f, 6.88624904e-02f, 1.09359883e-02f,
  -4.99186702e-02f, -2.63249110e-02f, -4.92016226e-02f, 5.79148605e-02f, -4.21929397e-02f, -2.50844937e-03f, 7.43691251e-02f, 9.79356561e-03f, 7.14077009e-03f, -2.18880363e-02f,
  8.03877786e-03f, -4.43771221e-02f, 9.58600044e-02f, -3.19599733e-02f, 7.61062279e-03f, -1.06760033e-03f, 8.90606418e-02f, 7.63211073e-03f, 9.34825540e-02f, 1.36100486e-01f,
  -7.34799132e-02f, -1.70639321e-01f, -1.09892730e-02f, -1.00871092e-02f, 6.08452596e-03f, -7.17199035e-03f, 4.65202704e-02f, -1.47076352e-02f, 2.85306945e-02f, 2.86969524e-02f,
  -3.38548347e-02f, 5.05954437e-02f, 1.15477806e-02f, -4.99354023e-03f, -1.10054277e-01f, -3.71323116e-02f, 4.41041850e-02f, -1.11890463e-02f, -6.87033385e-02f, 1.46839302e-03f,
  6.76397309e-02f, -2.68160310e-02f, -1.40274595e-02f, -1.18707521e-02f, 4.61410685e-03f, -7.51432851e-02f, -1.42616972e-01f, -1.17653430e-01f, -6.64865747e-02f, 1.96724951e-01f,
  -1.16473056e-01f, 1.65312544e-01f, 3.87124151e-01f, -3.00254337e-02f, -1.39907420e-01f, -3.06054235e-01f, -4.65794474e-01f, -4.43532974e-01f, -6.19042218e-02f, 8.81850347e-03f,
  1.25043407e-01f, 3.16073895e-01f, 3.80395383e-01f, 1.56931177e-01f, 5.81631158e-03f, 5.60465781e-03f, 6.55855164e-02f, 2.00536653e-01f, -1.00269184e-01f, -3.14963400e-01f,
  -1.25403106e-01f, -1.88636202e-02f, 9.58502740e-02f, -5.30386753e-02f, -1.67520307e-02f, 6.58993348e-02f, 1.94262955e-02f, 3.61315124e-02f, 1.87840443e-02f, 3.92603874e-01f,
  3.62539470e-01f, -4.78948802e-02f, 9.74260364e-03f, 5.68462573e-02f, 1.39916137e-01f, 4.51553985e-02f, 3.67467217e-02f, 6.21816218e-02f, -2.70096902e-02f, 6.38047382e-02f,
  6.04343861e-02f, -1.30198698e-03f, 1.10750116e-01f, 9.02223587e-02f, -1.45585034e-02f, 2.32681502e-02f, 8.45684260e-02f, 1.25816390e-01f, 2.65279021e-02f, 7.25719556e-02f,
  6.30347580e-02f, -3.56169157e-02f, -5.13825715e-02f, -6.77726939e-02f, -4.62597944e-02f, 9.93793011e-02f, 4.40072082e-02f, -6.96555972e-02f, -6.22086506e-03f, -1.34175243e-02f,
  -1.57418862e-01f, 6.03390066e-03f, -6.08518869e-02f, 7.78186414e-03f, -2.72661094e-02f, 5.29595166e-02f, 1.79138836e-02f, 6.46241754e-02f, -2.81265546e-02f, -1.72801539e-02f,
  2.36581806e-02f, -7.08068758e-02f, 3.07481214e-02f, -4.58150022e-02f, 6.66421354e-02f, 1.08212819e-02f, -4.81584184e-02f, -6.12287335e-02f, 3.30589749e-02f, -9.74761881e-03f,
  2.25873739e-02f, 1.80585124e-03f, 6.32868111e-02f, -3.20797786e-02f, -1.46917785e-02f, 1.99097674e-02f, -1.31607205e-02f, -3.21593471e-02f, 3.19781154e-02f, -4.76846844e-02f,
  1.46103054e-01f, 1.23554247e-03f, 1.13061205e-01f, 3.26891653e-02f, 2.16032825e-02f, 1.32933632e-02f, 1.23046078e-01f, 3.34786177e-02f, 1.01797149e-01f, 4.73970734e-02f,
  5.24234772e-02f, 5.42385206e-02f, 1.37832612e-01f, 4.29919772e-02f, -2.90946942e-02f, -3.45894434e-02f, -2.30787974e-02f, 4.39842716e-02f, -6.80830935e-03f, -4.28002216e-02f,
  5.48145846e-02f, -1.34654298e-01f, 3.09629235e-02f, 4.26525669e-03f, -2.72166021e-02f, 1.39517143e-01f, 4.19787541e-02f, -5.54013811e-02f, 1.25703933e-02f, -1.31721392e-01f,
  -1.88492343e-01f, -1.64360642e-01f, 4.42198098e-01f, -2.89059371e-01f, -1.45872578e-01f, 1.53081223e-01f, 1.56195546e-02f, -1.41520441e-01f, -2.23327681e-01f, -1.43214837e-01f,
  -4.07744497e-01f, -4.00429994e-01f, -3.22528213e-01f, -2.10433528e-01f, -2.32329503e-01f, 7.72484541e-02f, -7.66735524e-02f, 5.19376397e-02f, -9.59677175e-02f, -2.25922883e-01f,
  -2.80416310e-01f, -1.91340566e-01f, -1.00761607e-01f, -2.15938076e-01f, -2.27250949e-01f, -2.63136864e-01f, -1.82754528e-02f, -1.22858889e-01f, -1.64987475e-01f, -1.40427232e-01f,
  3.05225421e-02f, -1.08548194e-01f, -7.22508878e-02f, -3.25709760e-01f, -2.69924194e-01f, -2.34724104e-01f, -2.35746786e-01f, -1.66664898e-01f, -2.31103852e-01f, -1.93855703e-01f,
  -1.92275584e-01f, -2.13309199e-01f, -3.01296651e-01f, -1.88447148e-01f, -1.80235043e-01f, -1.01913109e-01f, -2.27098733e-01f, -1.87294781e-01f, -1.84099510e-01f, -1.53747618e-01f,
  -2.98604310e-01f, -1.80177197e-01f, -2.35330183e-02f, -1.72046870e-01f, -6.95037246e-02f, -2.07807004e-01f, -2.07961708e-01f, -1.09562799e-01f, -6.06395081e-02f, -6.59613535e-02f,
  1.11262672e-01f, 1.18422411e-01f, 8.56277645e-02f, 1.95373714e-01f, 7.72854537e-02f, 7.57801309e-02f, 1.29249007e-01f, 1.68868810e-01f, 5.67835160e-02f, 2.55564421e-01f,
  6.32300898e-02f, 1.26997918e-01f, 1.65981889e-01f, 1.00646593e-01f, -2.84415134e-03f, 1.77857384e-01f, 1.10230230e-01f, 9.83897299e-02f, 1.33534998e-01f, 7.02038035e-02f,
  8.83752257e-02f, 1.77743480e-01f, 6.92269728e-02f, 1.29607439e-01f, 1.13117613e-01f, 8.82874206e-02f, 1.74498320e-01f, 1.42196804e-01f, 9.93837640e-02f, 1.78800032e-01f,
  -2.84864455e-01f, -1.95133120e-01f, -1.82183787e-01f, -2.33709797e-01f, -7.44096935e-02f, -8.54753703e-02f, -2.16380849e-01f, -1.65572181e-01f, -1.50398567e-01f, -2.05214918e-01f,
  -2.43664712e-01f, -1.45941496e-01f, -2.86220163e-01f, -1.31691083e-01f, -2.01960728e-01f, -1.36493251e-01f, -2.13087782e-01f, -1.41901433e-01f, -1.66499287e-01f, -1.52829647e-01f,
  -1.91852540e-01f, -8.15948695e-02f, -4.39454950e-02f, -1.07360475e-01f, -1.49071455e-01f, -1.89123020e-01f, 2.73835454e-02f, -2.27977131e-02f, 7.79299065e-03f, -1.09527390e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.32589036e-01f, -9.43616152e-01f, 1.43036038e-01f, -3.89562577e-01f, 3.04047763e-02f, 2.56360561e-01f, -2.62981057e-01f, -6.49352893e-02f, -1.47311121e-01f, -6.12277389e-01f,
  -4.59931850e-01f, 6.09506778e-02f, -1.21175446e-01f, 4.96537909e-02f, 1.21892124e-01f, -3.71094704e-01f, -1.48787081e-01f, 6.54389799e-01f, 9.32179332e-01f, 5.02309442e-01f,
  -1.31354660e-01f, 1.17910840e-01f, 2.91454822e-01f, 1.97412819e-01f, -5.16865253e-01f, 8.97849798e-02f, -2.04358637e-01f, -1.05126955e-01f, -3.86868954e-01f, -7.16229498e-01f,
  3.32800090e-01f, -2.53975779e-01f, 2.40699515e-01f, 1.15962746e-02f, 2.59409621e-02f, 4.61988337e-02f, 1.59288451e-01f, 3.71464007e-02f, -5.29979542e-02f, 3.29319350e-02f,
  -2.63169017e-02f, -4.54813130e-02f, 4.88833115e-02f, -6.61990494e-02f, 1.14960484e-01f, 4.45161797e-02f, 2.92457677e-02f, -9.20849815e-02f, -5.06216809e-02f, -1.08361043e-01f,
  -3.54640514e-01f, 1.66428741e-02f, 5.45831025e-02f, 8.97922739e-02f, -2.08301144e-03f, 2.98550785e-01f, -3.34749930e-02f, 3.70811149e-02f, 2.28409365e-01f, -2.18691915e-01f,
  1.89440712e-01f, -3.14761996e-02f, 8.17288086e-02f, 1.83252439e-01f, 1.18448608e-01f, 1.30043983e-01f, 1.03274398e-02f, 4.42836583e-02f, 2.12717876e-01f, 5.92712648e-02f,
  -1.30634487e-01f, -1.05919383e-01f, 8.79495293e-02f, -1.65316567e-01f, -3.04272026e-02f, -8.84519890e-02f, -1.07838467e-01f, 4.38917764e-02f, 9.84440446e-02f, 2.16677394e-02f,
  -1.99049618e-02f, 6.59896433e-03f, -7.31752589e-02f, -1.18929796e-01f, -9.42610428e-02f, -1.80964004e-02f, 3.81643027e-02f, 7.35803694e-02f, 7.75244236e-02f, -2.08564118e-01f,
  -8.52864459e-02f, 3.90797973e-01f, -9.80607197e-02f, -2.02783346e-02f, -6.54850677e-02f, -1.18048996e-01f, 2.44701598e-02f, -1.46375047e-02f, -1.22906685e-01f, 4.03168499e-02f,
  1.52737066e-01f, 1.51511386e-01f, -4.65755835e-02f, -6.59595504e-02f, 2.88768500e-01f, 1.88171521e-01f, -8.53975564e-02f, -8.93784091e-02f, -2.06976999e-02f, -1.84681609e-01f,
  -1.96110845e-01f, -2.30902452e-02f, 1.82050809e-01f, 6.64503127e-02f, -3.96896787e-02f, 2.97395319e-01f, 1.81804597e-01f, 9.98190120e-02f, 2.84351617e-01f, 2.37132646e-02f,
  -1.31692004e+00f, -1.11280417e-03f, -7.95212686e-01f, -1.05995858e+00f, -8.41592908e-01f, -6.91005588e-01f, 5.00210710e-02f, -1.67673633e-01f, -6.24797821e-01f, 5.63181303e-02f,
  2.62277514e-01f, 2.47124761e-01f, 9.49595794e-02f, 2.25980818e-01f, 1.29542768e-01f, -2.36980934e-02f, -5.66140652e-01f, -6.92631841e-01f, -3.87258410e-01f, 4.69194502e-02f,
  1.19708041e-02f, -6.48631275e-01f, -7.48658776e-01f, -4.44205195e-01f, -2.98608780e-01f, -1.99880347e-01f, -1.92197993e-01f, -6.71265900e-01f, -2.76087224e-01f, -7.08484232e-01f,
  6.49022043e-01f, -6.59490705e-01f, -1.04745202e-01f, -2.58073181e-01f, -9.53212082e-02f, -4.88908067e-02f, -1.40921324e-01f, -2.67557621e-01f, -5.97596951e-02f, -1.52916638e-02f,
  -1.68688774e-01f, -1.83989316e-01f, -1.68801039e-01f, 1.25696540e-01f, -2.02233180e-01f, 3.59844416e-02f, -6.70174183e-03f, -2.33604655e-01f, -1.44964695e-01f, 3.96977812e-01f,
  3.04234505e-01f, -1.85550943e-01f, 5.36601953e-02f, 3.35544378e-01f, 1.10986479e-01f, -2.10311636e-01f, 3.43223214e-01f, -9.17118937e-02f, -1.33445814e-01f, 2.67668247e-01f,
  -1.19892173e-02f, 8.39025229e-02f, -8.97954851e-02f, -1.47615403e-01f, 1.30850384e-02f, -8.89802277e-02f, -8.96330625e-02f, 1.82616878e-02f, 6.59662532e-03f, 1.71026707e-01f,
  1.05204366e-01f, -2.19257846e-02f, 5.15941679e-02f, -5.63900806e-02f, 7.70286471e-02f, -2.09698498e-01f, -1.33661525e-02f, 2.37208202e-01f, 1.72021035e-02f, -2.23142490e-01f,
  -1.06907070e-01f, -2.79472172e-02f, -8.05424452e-02f, 5.11582755e-02f, -7.27737769e-02f, -1.80676192e-01f, -1.15267150e-01f, 1.45770028e-01f, 3.44214290e-02f, -1.80787191e-01f,
  5.99213541e-01f, -4.65060771e-01f, 1.41942829e-01f, -8.71177688e-02f, -8.21343809e-02f, 7.69602507e-02f, -1.02295645e-01f, -3.23103042e-03f, -2.23439589e-01f, 1.86771881e-02f,
  -4.97029349e-02f, 1.14376508e-01f, 2.73757484e-02f, 2.41354987e-01f, -7.57054612e-02f, 2.19388120e-02f, 1.69322073e-01f, -1.55052217e-02f, -7.23726302e-02f, 2.15282604e-01f,
  1.60262585e-01f, 8.45579132e-02f, 3.05049837e-01f, 3.38175088e-01f, 1.08189814e-01f, -1.35812625e-01f, 2.87094414e-01f, 1.63226336e-01f, 1.04442418e-01f, 3.02325308e-01f,
  8.95673871e-01f, -1.68091878e-01f, 2.74862111e-01f, 2.26242870e-01f, 3.21159899e-01f, 2.77270615e-01f, 2.42369339e-01f, 2.58273572e-01f, 1.11257970e-01f, 2.53694743e-01f,
  1.01587959e-01f, 2.30018318e-01f, 1.23551451e-01f, 4.20376956e-02f, 3.20590325e-02f, -2.19048839e-02f, -8.57745931e-02f, 7.56512433e-02f, 2.36377060e-01f, 1.78004235e-01f,
  4.79806066e-02f, 1.05427109e-01f, 2.30227336e-01f, -3.27959657e-03f, 3.19847390e-02f, 2.06492934e-02f, 1.19160660e-01f, 8.67016464e-02f, 7.87870400e-03f, -3.06410134e-01f,
  -2.60241300e-01f, 1.39074266e-01f, 1.64063245e-01f, -1.00536831e-01f, -7.08209584e-03f, 6.22269176e-02f, -4.11048112e-03f, -1.23210542e-01f, -3.80941443e-02f, -7.26854578e-02f,
  -7.90836960e-02f, -5.21829352e-02f, 9.76940095e-02f, -2.98055168e-02f, 8.10630694e-02f, 7.95277655e-02f, -2.49811611e-03f, 3.25852260e-02f, -9.15732384e-02f, -1.71833172e-01f,
  -4.41231579e-02f, 1.23165458e-01f, -5.25147608e-03f, -3.57236043e-02f, -5.34772761e-02f, -5.68724796e-02f, -1.26625642e-01f, -3.80190909e-02f, 1.00326359e-01f, 9.70568322e-03f,
  2.25813270e-01f, 3.44689041e-01f, 2.21561491e-01f, -2.84044351e-02f, 2.29838714e-02f, -4.45076451e-02f, 2.13116799e-02f, -5.32321036e-02f, -6.02412410e-03f, 1.59960136e-01f,
  1.36893734e-01f, 7.69834816e-02f, 4.00920771e-02f, 3.00405800e-01f, 1.77955851e-01f, 2.37986624e-01f, 1.04853265e-01f, -3.86955254e-02f, 5.01575842e-02f, 1.13416970e-01f,
  1.98770806e-01f, -1.08571269e-01f, 1.75730959e-02f, -1.58088818e-01f, 6.18982054e-02f, 7.45466202e-02f, 2.05633178e-01f, 2.82977641e-01f, 2.62102365e-01f, 2.79831141e-01f,
  -6.58363923e-02f, 3.54566753e-01f, 5.70570827e-02f, -2.23735526e-01f, -1.26780823e-01f, -1.84702594e-02f, 6.25157878e-02f, -2.06398532e-01f, -2.98879117e-01f, -1.23807028e-01f,
  -1.83346316e-01f, -6.78512976e-02f, 2.26899330e-02f, -3.83793488e-02f, 1.51709914e-01f, 8.88673291e-02f, -2.57989336e-02f, -5.43296821e-02f, -2.52418667e-01f, -2.18057722e-01f,
  -7.39741549e-02f, 8.29927772e-02f, 3.91553156e-02f, -5.82107082e-02f, -1.11902971e-02f, 1.43540442e-01f, 7.17771202e-02f, 7.64859393e-02f, 7.75043294e-02f, 2.87749350e-01f,
  -9.33352709e-01f, 7.20673263e-01f, -1.03481126e+00f, -4.15103674e-01f, -1.04097255e-01f, -9.08655599e-02f, 5.55434167e-01f, 2.08905786e-01f, -8.24108627e-03f, 3.05657238e-01f,
  -1.16806664e-02f, -3.06024373e-01f, -2.23349616e-01f, -6.62022009e-02f, 1.61581412e-01f, 5.63530087e-01f, 3.48475277e-01f, -5.37265658e-01f, -5.51473677e-01f, 2.45248415e-02f,
  6.21951044e-01f, 2.32034817e-01f, -1.97602719e-01f, -2.26603165e-01f, -1.80566907e-02f, -6.50021806e-03f, -5.14191724e-02f, -2.18838125e-01f, 1.50308907e-01f, -6.83019310e-02f,
  -7.21108079e-01f, -6.54943824e-01f, -2.37252623e-01f, -2.02625185e-01f, -3.42394024e-01f, -1.82326868e-01f, -1.31992735e-02f, -4.23775196e-01f, -3.61783683e-01f, -9.00207534e-02f,
  -3.07676256e-01f, -3.70039135e-01f, -3.71813893e-01f, -3.49016488e-02f, -9.82147232e-02f, -4.74509262e-02f, 6.69872528e-03f, -3.87529165e-01f, -3.06579590e-01f, -3.85858148e-01f,
  3.36718380e-01f, -5.15807033e-01f, -9.42117155e-01f, 8.68305936e-02f, -1.79336429e-01f, -2.95907378e-01f, -4.23834324e-01f, -4.57788676e-01f, -3.02733511e-01f, -4.97458249e-01f,
  5.54530136e-02f, -7.90075362e-02f, 1.60069503e-02f, -5.64180315e-03f, 1.91754386e-01f, -4.98813465e-02f, 1.07938480e-02f, 8.57980624e-02f, -6.70401081e-02f, 2.48669870e-02f,
  -2.01104313e-01f, -1.60001323e-01f, -7.95659721e-02f, -1.09010272e-01f, -2.06185430e-01f, -8.04580525e-02f, 5.35972640e-02f, 3.07661623e-01f, 9.24555399e-03f, 5.63274994e-02f,
  -2.90621258e-02f, -3.70577313e-02f, -9.44495294e-03f, 1.91800252e-01f, 1.54383674e-01f, 2.49766856e-02f, 1.19370997e-01f, -9.70706567e-02f, -5.64466082e-02f, 8.60579386e-02f,
  2.99754798e-01f, 2.38051027e-01f, -2.22542629e-01f, 1.10848397e-01f, -1.59594223e-01f, -1.39439479e-01f, 1.06023654e-01f, 3.20625980e-03f, -2.16674745e-01f, -3.97213846e-02f,
  -1.25189513e-01f, -1.75767332e-01f, 1.13359049e-01f, 6.07768856e-02f, 4.24577761e-03f, -8.17977339e-02f, 3.65112901e-01f, -8.99933130e-02f, 4.73955125e-02f, -5.38043045e-02f,
  4.31692123e-01f, 1.72509998e-01f, -1.16743840e-01f, 3.19634355e-03f, 1.03739426e-01f, -1.75831318e-02f, -2.11509004e-01f, -2.55910195e-02f, -1.61881357e-01f, 4.93090510e-01f,
  5.70878088e-01f, -3.09636772e-01f, 2.23652199e-02f, -8.15519542e-02f, -4.38610733e-01f, -7.66952932e-01f, -8.12924802e-01f, -6.21136606e-01f, -2.66513914e-01f, -4.19449717e-01f,
  -2.56962627e-01f, 1.74862102e-01f, -1.09212615e-01f, 2.62722701e-01f, 3.34287062e-02f, -2.98977345e-01f, -2.39305869e-02f, 7.29093313e-01f, 7.68353343e-01f, 4.25636232e-01f,
  3.09739083e-01f, 5.15545368e-01f, 7.84269869e-01f, 4.32832688e-01f, 1.16891287e-01f, 2.29005367e-01f, -7.58548081e-02f, 2.95959085e-01f, 6.24724515e-02f, 4.71424073e-01f,
  6.29243195e-01f, -1.12487301e-01f, -3.38712960e-01f, 7.91428462e-02f, 2.68185884e-01f, 8.49944130e-02f, 8.57055467e-03f, 1.84525475e-01f, -5.82208894e-02f, -1.56522298e-03f,
  1.14226922e-01f, 1.29410535e-01f, -1.41575769e-01f, 1.31774753e-01f, 7.95957297e-02f, 1.09537132e-02f, 1.84966043e-01f, 1.25208333e-01f, 9.44783762e-02f, 7.37904757e-02f,
  5.40286005e-02f, -3.30103189e-02f, -3.26338440e-01f, -4.16837305e-01f, -3.81312519e-01f, 1.79843575e-01f, -1.47396669e-01f, 3.57214585e-02f, -2.37579316e-01f, 8.77195224e-02f,
  -2.45923296e-01f, 6.48294017e-02f, -7.64298588e-02f, -5.71752489e-02f, 2.03762520e-02f, -8.17037821e-02f, 4.01988886e-02f, 5.52717783e-02f, -9.13292989e-02f, -2.74420269e-02f,
  8.29439552e-04f, 9.55978408e-02f, 1.82919040e-01f, 4.60863672e-02f, 1.51353762e-01f, 1.07608810e-01f, 1.41709700e-01f, 3.10070068e-01f, 1.04685679e-01f, 1.29901350e-01f,
  1.48577645e-01f, -8.46421644e-02f, 1.09879971e-01f, 2.91382223e-01f, 1.07757144e-01f, 1.82899684e-01f, 1.54723391e-01f, 2.48858064e-01f, 2.14225352e-01f, 1.91913284e-02f,
  7.44578801e-03f, -3.08045119e-01f, -5.62705025e-02f, 4.69378904e-02f, -1.05857596e-01f, -2.58811377e-02f, 1.32050931e-01f, 1.75608560e-01f, 9.93740484e-02f, 8.07091594e-02f,
  -9.33367014e-02f, -1.17678203e-01f, -2.83638805e-01f, -6.20962877e-04f, 5.07857874e-02f, -2.81525880e-01f, -1.69127509e-02f, -4.73639630e-02f, 2.81378720e-02f, 7.39583820e-02f,
  -1.92241743e-01f, -3.74170810e-01f, -4.74253982e-01f, -6.63748145e-01f, -4.36158627e-01f, -3.62584621e-01f, -3.28740299e-01f, -3.50440145e-01f, -4.96562749e-01f, -5.87129056e-01f,
  1.38571131e+00f, 6.67155266e-01f, -6.15495779e-02f, 1.44249350e-01f, 6.87086880e-02f, 2.85666913e-01f, 4.53471035e-01f, 3.59186769e-01f, 1.41221657e-01f, 3.90677482e-01f,
  4.99704301e-01f, 3.60913336e-01f, 2.89343327e-01f, 2.80132771e-01f, 1.42352119e-01f, -3.70130390e-02f, -2.38115683e-01f, -1.23822488e-01f, -1.18596658e-01f, -1.42920436e-03f,
  8.72634165e-03f, 1.51809856e-01f, 1.71145082e-01f, -6.61431551e-02f, -2.74076797e-02f, -1.17471479e-01f, 5.02244122e-02f, 5.25280610e-02f, 9.77353007e-02f, -2.46012703e-01f,
  -4.80748713e-01f, 2.52919137e-01f, -1.36660725e-01f, 2.67748069e-02f, 4.90402570e-03f, -1.08229190e-01f, -5.95769733e-02f, -1.33401707e-01f, -1.04508936e-01f, -1.75914913e-01f,
  -1.42379567e-01f, -1.35037333e-01f, -1.86088815e-01f, -6.81736171e-02f, -2.08379731e-01f, -1.11020893e-01f, 4.77402098e-02f, -6.68234751e-03f, -1.15317971e-01f, -2.32744757e-02f,
  1.07252961e-02f, -3.38072926e-02f, -3.17425169e-02f, -9.10049379e-02f, 3.75238396e-02f, 1.51735786e-02f, 4.32985723e-02f, -2.81903893e-02f, -8.17816630e-02f, 1.46334752e-01f,
  3.26061584e-02f, 2.85775840e-01f, -3.07406168e-02f, 6.66413978e-02f, 1.52675465e-01f, -1.70662642e-01f, -8.41679648e-02f, 9.91651863e-02f, -2.54422668e-02f, -1.04962597e-02f,
  -1.96629331e-01f, -7.24536702e-02f, -2.67240368e-02f, -1.93600997e-01f, -1.71582684e-01f, -1.03860693e-02f, -1.65711418e-02f, -4.52591702e-02f, -2.07217991e-01f, -6.67758733e-02f,
  -1.46285802e-01f, -1.18111454e-01f, -1.33565858e-01f, -2.20506728e-01f, -1.38005139e-02f, -9.97636542e-02f, -1.64450318e-01f, 2.13551335e-03f, 1.05215669e-01f, -4.25142907e-02f,
  -3.06242436e-01f, -4.76481467e-02f, -4.22329269e-02f, 1.11639075e-01f, 3.81209515e-02f, 1.02315009e-01f, 1.66730091e-01f, -8.03704932e-02f, -1.64236858e-01f, -1.18470781e-01f,
  5.03139794e-02f, 1.04022674e-01f, 1.12423129e-01f, 2.50690058e-02f, -5.90862148e-02f, -6.42201826e-02f, 2.53538847e-01f, 2.49995708e-01f, 9.97055508e-03f, -7.96305239e-02f,
  1.16525456e-01f, 6.88109621e-02f, 2.29680464e-02f, -4.67427410e-02f, 1.65242463e-01f, 1.17250673e-01f, -4.10680100e-02f, 5.79759292e-02f, -4.44266945e-02f, 6.70502111e-02f,
  4.27058220e-01f, -5.16630411e-01f, 3.53492439e-01f, -1.21590823e-01f, -5.96817918e-02f, 1.10019483e-01f, -1.20948486e-01f, -3.93423922e-02f, -1.80223316e-01f, -3.34290266e-02f,
  -6.03214093e-02f, 3.48396510e-01f, 3.33484322e-01f, 2.42315188e-01f, 1.16762310e-01f, -8.70780945e-02f, -1.04766034e-01f, 3.58331710e-01f, 4.28086340e-01f, 1.22711606e-01f,
  -1.93483323e-01f, -7.40703419e-02f, 3.24059352e-02f, -2.46852878e-02f, -3.19083512e-01f, 1.29835874e-01f, -2.25388333e-01f, -2.00300545e-01f, -1.59098119e-01f, -2.93169320e-01f,
  3.54356855e-01f, -2.67267048e-01f, 1.68860093e-01f, -1.80185124e-01f, -9.17640924e-02f, -2.47165617e-02f, 1.88460410e-01f, -9.52878147e-02f, -1.22047320e-01f, -1.49948478e-01f,
  -4.53546681e-02f, 1.12138363e-02f, -4.17398252e-02f, -2.13789552e-01f, -2.03728080e-01f, -4.08702493e-02f, -1.28236040e-01f, -3.14102657e-02f, 2.14977507e-02f, 3.11813084e-03f,
  -2.09848523e-01f, -7.50391856e-02f, -1.43878488e-03f, 1.01207577e-01f, 9.56803337e-02f, 4.78919223e-02f, 3.31224836e-02f, 5.74857108e-02f, 5.51189184e-02f, 1.67813841e-02f,
  -2.82116723e-03f, 1.40203953e-01f, 2.25458309e-01f, 5.30149564e-02f, 1.56407177e-01f, 1.61593452e-01f, 3.26372162e-02f, 5.02161346e-02f, 2.06565228e-03f, 3.52831259e-02f,
  4.07921225e-02f, 7.31898472e-02f, 2.22962555e-02f, -7.84069151e-02f, 8.55770558e-02f, -5.39090112e-02f, 5.03781550e-02f, -6.95959572e-03f, 9.19394419e-02f, -1.62922367e-01f,
  1.64435029e-01f, -1.53341085e-01f, -6.19419515e-02f, 4.50624526e-02f, -1.76216751e-01f, 3.46880890e-02f, -3.13298777e-03f, -3.42741702e-03f, -1.79602802e-02f, -1.43907353e-01f,
  -8.91940072e-02f, 2.74233729e-01f, 2.03720704e-01f, 2.74358317e-02f, -1.17833905e-01f, -4.59428020e-02f, 1.51813388e-01f, -8.96716341e-02f, -2.24365517e-01f, -4.33653481e-02f,
  -1.63604766e-01f, 2.49535795e-02f, 1.35870175e-02f, -1.61341354e-02f, 1.76044926e-01f, -3.10185901e-03f, -1.62662581e-01f, 1.32696941e-01f, -1.11103512e-01f, -1.75423071e-01f,
  -1.37957096e-01f, 3.71871479e-02f, 3.33505243e-01f, 2.24484220e-01f, 1.13105372e-01f, 3.50922018e-01f, 2.04200447e-01f, 7.57984966e-02f, 1.70194447e-01f, 1.43818948e-02f,
  -5.51274531e-02f, 4.28777009e-01f, -1.78425789e-01f, 4.78383452e-01f, -1.17010556e-01f, -4.24231946e-01f, 6.69956505e-02f, 5.62627837e-02f, 3.42463970e-01f, 4.87167448e-01f,
  -8.99067819e-02f, -4.69782233e-01f, -2.84172148e-01f, -3.72307777e-01f, -6.57512605e-01f, 8.52854550e-02f, 7.89230838e-02f, -4.36380982e-01f, -8.82119298e-01f, -5.13565004e-01f,
  -2.25877970e-01f, 1.08227193e-01f, -1.88078046e-01f, -3.61880660e-02f, 3.14388216e-01f, -1.01358935e-01f, 3.18653017e-01f, -9.25566033e-02f, -2.75187016e-01f, 1.08524568e-01f,
  1.43715620e-01f, -3.45697373e-01f, -2.01347724e-01f, -2.04884738e-01f, 3.24444443e-01f, -1.69132367e-01f, -1.29938632e-01f, 1.53874487e-01f, -3.51423770e-02f, 1.39825106e-01f,
  -2.17242479e-01f, -2.10409299e-01f, -2.59304821e-01f, -2.56134242e-01f, -2.00117245e-01f, -1.63456753e-01f, -7.84157515e-02f, -3.41963440e-01f, -8.49407613e-02f, 2.95608547e-02f,
  -2.69724786e-01f, -5.32237768e-01f, -1.03631087e-01f, 1.19804954e-02f, -2.02289984e-01f, -5.05026519e-01f, 2.13691629e-02f, -2.22556844e-01f, -1.66693807e-01f, 6.49445593e-01f,
  1.89147606e-01f, 4.26432714e-02f, -1.44417867e-01f, 1.43520176e-01f, 9.36212242e-02f, 5.20486385e-02f, 1.32457525e-01f, 2.40338664e-03f, -8.63490254e-02f, 2.74962753e-01f,
  1.06250778e-01f, 2.46772766e-01f, 1.26245916e-01f, 6.16280399e-02f, -6.01501763e-02f, -9.50140134e-02f, 3.53385769e-02f, 1.89193681e-01f, -8.82964507e-02f, 3.52083743e-02f,
  -1.60758942e-01f, -6.03150129e-02f, -7.16958642e-02f, 2.06388637e-01f, -1.65192828e-01f, -1.44162759e-01f, -1.60516694e-01f, -2.35103250e-01f, -1.20720178e-01f, -1.81753188e-01f,
  6.75045609e-01f, -5.32925129e-01f, 1.84411675e-01f, -4.18656692e-02f, 1.72688156e-01f, -2.41170451e-02f, 3.49420086e-02f, 1.50376400e-02f, 2.45622285e-02f, 1.36498804e-03f,
  -3.12549770e-01f, -3.18709314e-02f, -4.82676327e-02f, -1.23441219e-03f, -1.83334783e-01f, -2.13884279e-01f, -3.11311940e-03f, 7.38856420e-02f, -6.60841018e-02f, 2.50387132e-01f,
  3.73112649e-01f, 1.45892397e-01f, 3.00917774e-01f, 4.61260885e-01f, -9.06830803e-02f, -1.98622674e-01f, 3.31582785e-01f, 1.00198172e-01f, -1.22897945e-01f, 1.02781439e+00f,
  5.46762109e-01f, -8.26208472e-01f, 5.63856661e-01f, 2.77590990e-01f, 1.88079730e-01f, 2.81237811e-01f, 1.75554305e-01f, -5.21747805e-02f, 1.18441116e-02f, -1.80217505e-01f,
  -5.04806459e-01f, -3.34683001e-01f, -7.97362402e-02f, -1.68106258e-01f, 8.41664989e-03f, 5.15394285e-02f, 2.10403726e-01f, 5.04433811e-01f, 6.08942568e-01f, 1.42559454e-01f,
  -2.88457572e-01f, 9.25050303e-02f, 2.11882114e-01f, -4.30582017e-02f, -2.45081797e-01f, 2.70735249e-02f, -4.78868783e-02f, -1.82978302e-01f, -2.45795548e-01f, -2.64184326e-01f,
  1.14606790e-01f, -5.72561324e-01f, 1.74316451e-01f, -2.71781623e-01f, -1.00081354e-01f, 3.47939953e-02f, 5.67762814e-02f, -1.07182190e-01f, -9.20749381e-02f, 1.54519537e-02f,
  -2.80389059e-02f, -2.43203983e-01f, -1.58414111e-01f, -2.00483456e-01f, 2.72667278e-02f, 7.62462839e-02f, -9.75503102e-02f, -8.41260105e-02f, -1.94438934e-01f, -2.10358456e-01f,
  -4.00241315e-01f, -1.68037161e-01f, 2.81309746e-02f, 4.00064047e-03f, -2.24815249e-01f, 5.26890047e-02f, -1.27732083e-01f, -1.43368155e-01f, -4.57071885e-02f, -3.04779429e-02f,
  -1.30136669e-01f, 6.45129681e-02f, -1.44246057e-01f, -7.88053796e-02f, -5.81773976e-03f, 4.28604037e-02f, 3.43436860e-02f, -7.12181851e-02f, 5.36134876e-02f, -1.87602770e-02f,
  -1.28158197e-01f, -4.51313630e-02f, -1.11562222e-01f, 6.66633062e-03f, -8.83988291e-02f, -3.11645102e-02f, 6.18427172e-02f, -6.26203492e-02f, -2.07268551e-01f, -4.85277288e-02f,
  -1.25089973e-01f, 7.49646826e-03f, -1.17359143e-02f, -1.17491536e-01f, -1.61328793e-01f, 9.42565128e-03f, -1.67330429e-02f, -1.59054503e-01f, 9.62293521e-03f, -4.42372970e-02f,
  8.13360661e-02f, -2.39060178e-01f, 1.20659225e-01f, -1.90496385e-01f, -6.41214475e-03f, -1.63517147e-01f, -2.54488364e-02f, -1.21254206e-01f, -1.44229129e-01f, 7.53113031e-02f,
  -4.89268042e-02f, 5.67596480e-02f, -9.32877958e-02f, -7.30983689e-02f, 2.18517184e-01f, 1.56687170e-01f, -1.29381701e-01f, 1.19857304e-01f, 1.66808683e-02f, -2.36864947e-02f,
  -4.21732804e-03f, 1.52801350e-01f, 4.49696273e-01f, 2.83369869e-01f, 3.33625078e-02f, 3.56232971e-01f, 1.56709462e-01f, 2.53433347e-01f, 2.36132205e-01f, 4.39384699e-01f,
  -7.20568419e-01f, -3.35794747e-01f, -4.63374585e-01f, 1.79676175e-01f, 5.32506526e-01f, 3.32365632e-02f, -2.75158048e-01f, -3.62797767e-01f, -3.53921950e-02f, -2.27594599e-01f,
  -6.82927445e-02f, 2.33908370e-01f, -6.70925328e-06f, 1.03817627e-01f, 3.04306988e-02f, 1.34215243e-02f, 3.03599179e-01f, 1.96947336e-01f, 2.67177194e-01f, 2.70259410e-01f,
  5.16994298e-01f, 1.84729576e-01f, -9.64431837e-02f, 8.67992789e-02f, 3.99423182e-01f, 2.67232805e-01f, -2.18164742e-01f, 1.86074227e-01f, 1.26786396e-01f, 4.58592504e-01f,
  -5.73600113e-01f, -5.29171884e-01f, 1.03761129e-01f, 2.06983864e-01f, 5.91434054e-02f, -2.15628684e-01f, -3.46089870e-01f, -1.08264178e-01f, 1.48183722e-02f, -1.41267449e-01f,
  1.10168509e-01f, -1.15593575e-01f, 8.58403072e-02f, -4.18856777e-02f, -2.09873125e-01f, -3.53865802e-01f, -8.94126296e-02f, -3.55979294e-01f, -3.52007717e-01f, -2.58149952e-01f,
  6.61497772e-01f, 3.49118024e-01f, -3.11444789e-01f, -3.09389442e-01f, -4.54319328e-01f, 1.24718085e-01f, -4.25013810e-01f, -1.01676032e-01f, -5.70700705e-01f, -2.53686249e-01f,
  -6.49942309e-02f, 1.37190446e-01f, -1.21428028e-01f, -3.14138502e-01f, 2.03452304e-01f, 6.20603152e-02f, 1.02863260e-01f, 3.10810730e-02f, 6.55625910e-02f, -1.73918679e-01f,
  -1.08603813e-01f, -9.63315666e-02f, -6.95288628e-02f, -1.35944903e-01f, 2.54648983e-01f, -2.02447157e-02f, 2.67544359e-01f, 2.94011738e-02f, 4.31346819e-02f, -3.26009750e-01f,
  -6.87177628e-02f, -1.54485449e-01f, -2.07235545e-01f, -3.25619988e-02f, -2.00648949e-01f, -2.79653996e-01f, -1.43091261e-01f, -2.07352173e-02f, -7.82596990e-02f, -2.70722836e-01f,
  -4.79410946e-01f, -2.00464010e-01f, -9.53375921e-03f, 4.06696722e-02f, 2.83068985e-01f, 1.48531616e-01f, -4.28903364e-02f, 2.00834963e-02f, -7.94879571e-02f, -8.46997574e-02f,
  -2.47585878e-01f, -1.16078682e-01f, -2.34335423e-01f, 6.57124892e-02f, -1.05325535e-01f, -8.26963633e-02f, 2.80168980e-01f, 1.93947569e-01f, -6.25010952e-02f, 7.80289173e-02f,
  2.00463250e-01f, 2.77346581e-01f, -7.47227222e-02f, -1.17911026e-01f, 6.06845655e-02f, 1.45230383e-01f, -1.45988435e-01f, -1.23092486e-02f, -5.22415280e-01f, -4.01408702e-01f,
  5.41294217e-02f, 7.22591460e-01f, 3.28502387e-01f, 5.35025597e-02f, -1.90042034e-01f, 6.02768101e-02f, 2.17068195e-01f, 2.16750950e-01f, -4.63468358e-02f, 2.16694120e-02f,
  -1.82555646e-01f, -2.83621818e-01f, -1.50797769e-01f, -8.82990435e-02f, 4.23356593e-02f, 5.72296120e-02f, 1.86553061e-01f, 2.10074261e-02f, -1.37272626e-01f, -3.80961299e-01f,
  -2.45159447e-01f, -1.17240667e-01f, -1.63341835e-01f, 2.99770944e-02f, 2.96180218e-01f, -1.06130049e-01f, 2.31830284e-01f, 1.94720775e-01f, 1.21467717e-01f, 4.84947145e-01f,
  -1.05738871e-01f, 6.03443503e-01f, -4.89557177e-01f, -2.61547804e-01f, 1.07473880e-03f, 1.40590414e-01f, 3.03595811e-02f, 1.21323429e-01f, -5.30375093e-02f, 5.01819374e-03f,
  6.73827976e-02f, -6.02410501e-03f, 1.42640337e-01f, 6.17791936e-02f, -1.29099386e-02f, -9.10916999e-02f, 1.69871971e-01f, 2.58288682e-01f, -1.06712896e-03f, 7.95239210e-02f,
  -1.35518849e-01f, -7.63187408e-02f, 8.14876556e-02f, -6.60937726e-02f, 1.37042046e-01f, -3.46322089e-01f, 7.15670586e-02f, 5.51126972e-02f, -8.99893641e-02f, 2.64473826e-01f,
  -9.20504779e-02f, 9.60555747e-02f, 5.78674562e-02f, 1.83224723e-01f, 5.26921861e-02f, 1.10775948e-01f, 1.36471242e-01f, -1.04048746e-02f, -1.26302242e-01f, 1.22237563e-01f,
  2.12576374e-01f, -1.57313287e-01f, 1.01504982e-01f, 4.52468134e-02f, -1.72527716e-01f, 2.52328068e-01f, 5.83489724e-02f, -1.15770504e-01f, -2.77233690e-01f, -3.80057693e-02f,
  -1.68677032e-01f, 1.63203906e-02f, -1.47170462e-02f, 1.58944398e-01f, -1.34116977e-01f, -8.92062380e-04f, -1.63041074e-02f, -1.85822714e-02f, -2.86487862e-02f, 1.76458769e-02f,
  -4.20972377e-01f, -3.77070099e-01f, -2.55350292e-01f, 1.68867245e-01f, 1.77128837e-01f, 2.30738912e-02f, 1.29204288e-01f, -6.66997507e-02f, -2.77530402e-02f, -9.12157260e-03f,
  -1.09166391e-01f, 1.34484665e-02f, 1.31274819e-01f, 1.02270916e-01f, -2.14047462e-01f, -1.57536045e-01f, -2.20634192e-01f, -2.26704136e-01f, -2.02529073e-01f, 2.22798958e-01f,
  3.86432111e-02f, -4.21578228e-01f, -5.38295746e-01f, -3.03600878e-01f, -2.91532427e-01f, -5.84430158e-01f, -1.83571771e-01f, -3.46766621e-01f, -4.92398143e-01f, -4.12185401e-01f,
  -3.68125647e-01f, 4.84265298e-01f, 7.28389084e-01f, -5.04769981e-01f, -5.89340627e-02f, 3.20290089e-01f, 8.05113256e-01f, 6.41744882e-02f, -4.41165656e-01f, 1.08229388e-02f,
  -1.76217094e-01f, -7.29374230e-01f, -3.52597147e-01f, -1.27859488e-01f, 2.52261668e-01f, 5.07035851e-01f, 5.15136540e-01f, 4.27946746e-01f, 6.18257970e-02f, -1.65260777e-01f,
  -1.30502701e-01f, -7.75107890e-02f, 6.74737319e-02f, 3.43125779e-03f, -2.68203974e-01f, -4.33195293e-01f, 2.92068332e-01f, 3.66736650e-02f, 2.50103414e-01f, 3.70273218e-02f,
  -2.59173453e-01f, 2.19922215e-02f, -1.03013694e-01f, -2.85677820e-01f, 1.91377569e-02f, 4.27584574e-02f, -4.78173904e-02f, -8.43115225e-02f, 6.97968667e-03f, 3.06574881e-01f,
  -7.41044953e-02f, -6.80036619e-02f, -1.73622459e-01f, 1.15695521e-01f, -1.42881319e-01f, 2.32968908e-02f, 3.03830832e-01f, 3.09437990e-01f, 3.42227459e-01f, 1.71386316e-01f,
  -7.92166218e-02f, -6.06369320e-03f, 7.38351271e-02f, 2.63789803e-01f, 4.21921164e-01f, -3.86798047e-02f, 1.85036615e-01f, -1.02428697e-01f, 1.47513464e-01f, -2.43869036e-01f,
  -2.36295983e-01f, 1.23684220e-02f, 2.48282626e-01f, 3.97620760e-02f, 1.41405966e-02f, 3.12710516e-02f, -6.12981543e-02f, -1.31703228e-01f, -4.32714932e-02f, 3.39648239e-02f,
  -2.18225736e-02f, -4.62725200e-02f, 1.52387936e-02f, -6.35651052e-02f, -3.98183048e-01f, 1.41569316e-01f, 4.21895459e-02f, -5.23631787e-03f, 6.89154565e-02f, 1.39513686e-01f,
  -4.43374328e-02f, -2.37381384e-02f, -8.21439326e-02f, 1.04926817e-01f, 5.78872412e-02f, -6.93866611e-02f, -1.54600799e-01f, 9.34418198e-03f, -1.81553617e-01f, -1.19441152e-01f,
  -5.37005782e-01f, 8.10868442e-01f, -3.74199778e-01f, -1.59516200e-01f, -2.19805196e-01f, -8.35769325e-02f, -2.65506983e-01f, -2.25859672e-01f, -2.10791498e-01f, -2.35547181e-02f,
  1.19860068e-01f, -2.70312548e-01f, 6.14659041e-02f, 1.48882583e-01f, -1.26077890e-01f, -2.53398567e-01f, -9.48683918e-02f, -1.36316702e-01f, 1.08631440e-01f, -1.29278332e-01f,
  1.19448118e-01f, 3.25795151e-02f, -4.26544636e-01f, -2.54758716e-01f, -5.19311965e-01f, -7.66039073e-01f, -3.40455532e-01f, -4.22929406e-01f, -9.68426168e-02f, -3.44214082e-01f,
  -6.41893446e-01f, 3.46041285e-02f, 3.34339499e-01f, -3.70453566e-01f, 3.53472739e-01f, 5.67316003e-02f, -2.24858806e-01f, -2.35279903e-01f, -1.93020180e-02f, -1.05128378e-01f,
  3.62651199e-01f, 1.85689509e-01f, -1.30334854e-01f, -2.99046814e-01f, -8.35893512e-01f, -5.82222819e-01f, -5.16984463e-01f, -5.45090616e-01f, -4.27713633e-01f, 1.92634482e-02f,
  -2.28579156e-02f, -2.96046823e-01f, -4.26304579e-01f, -2.63670087e-01f, -4.04850133e-02f, -8.82824436e-02f, -1.52301341e-02f, -8.06043670e-02f, 6.53493702e-02f, -1.16015926e-01f,
  -2.11474746e-02f, 2.16779917e-01f, 2.87233114e-01f, 1.55886054e-01f, 2.86742806e-01f, -6.62256358e-03f, 9.82394144e-02f, -6.13471642e-02f, 1.10838465e-01f, -1.26682475e-01f,
  9.60356221e-02f, 1.73491582e-01f, -1.52736858e-01f, 1.19770393e-01f, -3.33757102e-02f, -2.42062911e-01f, -9.32459906e-02f, -1.04455702e-01f, -2.22287089e-01f, 2.75445938e-01f,
  1.33284152e-01f, 1.00068308e-01f, -3.22492331e-01f, -2.15301573e-01f, -2.82119997e-02f, -7.56676048e-02f, 1.52910322e-01f, 1.31133767e-02f, -2.60827661e-01f, -1.71627104e-01f,
  -9.69386548e-02f, 6.80382997e-02f, 2.25669771e-01f, 2.61582807e-02f, -1.73227698e-01f, 1.03757814e-01f, -1.27623543e-01f, -1.36151254e-01f, -2.50097644e-02f, -5.65358698e-02f,
  1.18209705e-01f, 5.63206784e-02f, -1.04205869e-01f, -2.22765356e-01f, -2.06714109e-01f, 4.27330099e-02f, -2.01701801e-02f, -3.07367355e-01f, -1.05864249e-01f, -1.02614574e-01f,
  -1.31750569e-01f, 4.01781499e-02f, 2.22623479e-02f, -2.32303560e-01f, -4.14195918e-02f, -9.38448533e-02f, 1.45448446e-01f, 1.77099168e-01f, 2.30754107e-01f, 1.66782796e-01f,
  -2.75167555e-01f, 1.58996060e-01f, -2.17180222e-01f, -1.40290916e-01f, -1.85922366e-02f, 2.21707284e-01f, 2.18656268e-02f, 1.85244739e-01f, 1.55722275e-01f, -7.95372277e-02f,
  5.20730577e-03f, -2.95589536e-01f, -2.39229724e-01f, 1.12836681e-01f, 4.06983942e-02f, -2.25132748e-01f, -3.33011925e-01f, 1.78447384e-02f, -1.75797611e-01f, 2.42031574e-01f,
  -3.60095143e-01f, -6.14754915e-01f, -6.75308049e-01f, -4.82500136e-01f, -2.81189263e-01f, -5.48274159e-01f, -4.25010115e-01f, -2.16874018e-01f, -5.27841985e-01f, -7.53731906e-01f,
  9.50577915e-01f, 2.35670626e-01f, -5.48230529e-01f, 4.82765436e-01f, -2.86596328e-01f, -5.72533667e-01f, -3.98605317e-01f, -7.36628249e-02f, 2.00008303e-01f, 2.58725852e-01f,
  1.93943679e-01f, 2.63774097e-01f, 3.60925853e-01f, -2.89956257e-02f, -2.45239317e-01f, -1.10075891e-01f, -2.60997593e-01f, -3.89368087e-01f, -6.48112476e-01f, -4.02851880e-01f,
  -1.92592442e-01f, 7.26980716e-02f, 6.40683249e-02f, -9.97347310e-02f, 1.02189258e-01f, -8.99991989e-02f, 1.01566330e-01f, -6.17686957e-02f, -2.79149085e-01f, -1.13816164e-01f,
  -1.39682785e-01f, -3.17620710e-02f, -3.06342900e-01f, 3.70723270e-02f, -9.45856422e-02f, 1.67936966e-01f, -7.23762438e-02f, 1.28656015e-01f, 1.47372693e-01f, 1.48067698e-01f,
  1.69863962e-02f, 1.42552733e-01f, 5.33662736e-02f, -4.70041819e-02f, 4.86391149e-02f, -4.54018191e-02f, 1.85224470e-02f, -7.69758746e-02f, 9.46958810e-02f, 4.03419919e-02f,
  -6.00716379e-03f, -1.36020362e-01f, -1.69308990e-01f, -1.28450304e-01f, -1.06252201e-01f, -6.14350140e-02f, -1.55535132e-01f, -2.27923214e-01f, -2.35776335e-01f, 1.71278790e-01f,
  -9.17917863e-02f, 1.33907691e-01f, 1.30046234e-01f, 8.77976716e-02f, 2.97705799e-01f, 1.30380601e-01f, 1.12852864e-01f, 2.89970580e-02f, -7.53275082e-02f, -2.88682384e-03f,
  -1.33131683e-01f, 2.65168771e-02f, -1.22459643e-01f, 1.01518989e-01f, 2.28082895e-01f, 4.74621765e-02f, -1.11665204e-01f, 1.78733036e-01f, 2.04424039e-01f, 3.17302853e-01f,
  4.60385196e-02f, -1.89318806e-02f, 1.50206283e-01f, 4.79290113e-02f, -1.85558245e-01f, 2.78924648e-02f, 5.43720126e-02f, 1.08754173e-01f, 9.60111693e-02f, -3.52914967e-02f,
  5.49368024e-01f, -1.42422006e-01f, 1.69075251e-01f, -1.61918357e-01f, -1.13249362e-01f, 2.43430957e-02f, 2.22934544e-01f, -3.33074257e-02f, 8.47641602e-02f, 5.86674809e-02f,
  -9.40584838e-02f, 7.54876062e-02f, 9.50750336e-02f, -6.38021752e-02f, 3.97395790e-02f, 5.24738282e-02f, 2.34945312e-01f, 7.56991059e-02f, 1.33855313e-01f, 1.06658787e-01f,
  1.05042778e-01f, 4.70693968e-03f, 9.59397629e-02f, -5.75110316e-02f, 1.83128882e-02f, 1.96959712e-02f, -2.47519254e-03f, 2.23451294e-02f, -7.48638883e-02f, 2.75987029e-01f,
  -3.22251678e-01f, -5.68898678e-01f, -3.74221563e-01f, 3.66213977e-01f, 3.44138801e-01f, -3.12692136e-01f, -8.45600247e-01f, 1.54263481e-01f, 2.83768028e-01f, -5.65108597e-01f,
  -2.92524844e-01f, 2.84266233e-01f, -1.64539635e-01f, -1.50382236e-01f, -6.24695241e-01f, -9.55712080e-01f, -5.68057716e-01f, -2.08920538e-01f, 3.50752085e-01f, 5.35213888e-01f,
  2.54256278e-01f, 3.48505318e-01f, 3.21105033e-01f, 2.19216824e-01f, 1.94192320e-01f, 1.48006618e-01f, -3.44571114e-01f, -2.62182448e-02f, -3.88230324e-01f, -5.13214111e-01f,
  -7.19453514e-01f, -2.38366306e-01f, 3.06604933e-02f, 1.87866732e-01f, 1.06204234e-01f, -2.41322517e-01f, -1.14034653e-01f, 1.29282147e-01f, -7.27207884e-02f, -1.40097648e-01f,
  1.86238497e-01f, -2.29434427e-02f, 2.13457361e-01f, 7.98161104e-02f, 2.29049414e-01f, 1.78202823e-01f, 3.22076142e-01f, 1.13499865e-01f, -2.09363833e-01f, -1.14055663e-01f,
  1.23909876e-01f, 6.57353178e-02f, -1.23985268e-01f, -2.22428720e-02f, 2.15589404e-01f, 1.63075566e-01f, 7.60807618e-02f, 3.48584056e-01f, -3.54614198e-01f, -3.34453136e-01f,
  -7.72580355e-02f, -7.78328404e-02f, 6.27008900e-02f, 2.93554887e-02f, 4.72552478e-02f, -5.10231815e-02f, 3.58693046e-03f, -1.97680816e-01f, 8.77661183e-02f, 4.37008552e-02f,
  2.51493324e-02f, -8.34500417e-03f, 1.13591835e-01f, -1.40654862e-01f, -1.53735047e-02f, -8.58991146e-02f, -1.92763537e-01f, 7.56145280e-04f, -1.59660392e-02f, 6.69513047e-02f,
  1.58453621e-02f, 4.50273603e-02f, 2.72465825e-01f, 1.98646281e-02f, -1.69849142e-01f, -1.18399467e-02f, 6.59082755e-02f, 2.17925072e-01f, 2.57330865e-01f, -7.62326419e-02f,
  2.50136584e-01f, -2.23256126e-01f, -6.03842080e-01f, -2.06338558e-02f, -1.88686699e-02f, 2.21348971e-01f, -2.23357916e-01f, -5.18819243e-02f, -7.31235892e-02f, 6.72211125e-02f,
  4.14448716e-02f, -2.75789529e-01f, -1.32835597e-01f, 1.45820662e-01f, 5.53881787e-02f, -7.04881968e-03f, -5.99597245e-02f, -1.09781213e-01f, -1.75288185e-01f, 1.99811772e-01f,
  4.22205031e-02f, -3.28901201e-01f, -3.48713726e-01f, -3.83032739e-01f, 1.39202267e-01f, -3.55881333e-01f, -3.81983846e-01f, -1.52714401e-01f, -6.96560085e-01f, -7.38953829e-01f,
  -7.13399887e-01f, -7.97438383e-01f, -2.48453453e-01f, -1.10532367e+00f, -7.53433168e-01f, -7.58787915e-02f, -7.15904772e-01f, -3.41972888e-01f, -2.79286802e-01f, -6.54989064e-01f,
  -2.09769547e-01f, 1.39519200e-01f, 4.63212617e-02f, 3.07198882e-01f, 4.14350182e-01f, -3.73043507e-01f, -3.72941464e-01f, 1.45529941e-01f, 3.24216306e-01f, -1.63111314e-01f,
  -4.73939449e-01f, -6.12765014e-01f, -2.25626588e-01f, -2.22150758e-01f, -1.02349150e+00f, -4.35004532e-01f, -5.79806507e-01f, -5.79448342e-01f, -1.23663761e-01f, -8.94576848e-01f,
  -7.34334409e-01f, -4.78339583e-01f, 4.00513858e-01f, 2.61873871e-01f, -3.45678717e-01f, 1.15625814e-01f, -1.91235825e-01f, 5.80731705e-02f, 2.07940444e-01f, -2.04380646e-01f,
  -1.07031859e-01f, 7.23005757e-02f, -9.84074846e-02f, -1.79551661e-01f, -3.98424208e-01f, -5.13649620e-02f, 9.33377445e-02f, 1.69639364e-01f, 2.30455935e-01f, 1.02209672e-01f,
  8.83045867e-02f, 1.65015385e-02f, -6.46402873e-03f, 2.28921592e-01f, 9.17210728e-02f, 3.57708573e-01f, -2.13035434e-01f, -8.46784841e-03f, 2.64192790e-01f, -8.56817186e-01f,
  2.05015764e-02f, 2.17197891e-02f, 1.33497685e-01f, -1.14994690e-01f, 1.69993564e-01f, 2.47429490e-01f, -1.95025980e-01f, -2.33455092e-01f, 1.62550509e-01f, 2.51841787e-02f,
  6.40731528e-02f, 7.36434534e-02f, 8.47657304e-03f, -2.73124613e-02f, 1.42436251e-01f, 1.04326405e-01f, -2.43222117e-02f, -1.07800543e-01f, -5.54676615e-02f, 3.26513611e-02f,
  1.44452855e-01f, -2.94790026e-02f, 1.75213360e-03f, 2.62520146e-02f, 1.34904563e-01f, 4.86856773e-02f, -2.12276071e-01f, 7.21417740e-02f, -2.48189971e-01f, 5.41249402e-02f,
  -6.77579880e-01f, 8.95455956e-01f, -6.15396857e-01f, 1.12400778e-01f, -6.87631890e-02f, 1.70318872e-01f, -9.18423012e-02f, 1.89011231e-01f, -1.11760171e-02f, -5.13432503e-01f,
  -4.64361198e-02f, -1.86472565e-01f, -3.64331827e-02f, -1.09843928e-02f, 4.11297602e-04f, 3.25415358e-02f, -5.81365786e-02f, -2.32519761e-01f, 2.95157701e-01f, 8.41637105e-02f,
  1.27761990e-01f, 4.49725278e-02f, -3.74053866e-01f, -1.83612838e-01f, -1.94897577e-01f, 1.31083518e-01f, -3.15011203e-01f, -2.64641553e-01f, 9.83127356e-02f, -1.06576753e+00f,
  4.21837151e-01f, -1.13992006e-01f, 7.67457485e-01f, 3.91532034e-01f, -4.82502073e-01f, -6.70537651e-01f, -1.10873175e+00f, -5.66096723e-01f, 2.24730775e-01f, 1.31982602e-02f,
  -3.34579289e-01f, -4.52577442e-01f, 2.03044370e-01f, -3.11361104e-01f, -5.64548850e-01f, 1.03211058e-02f, 2.31648102e-01f, 3.09435248e-01f, -4.45575297e-01f, -8.46658587e-01f,
  -5.28582573e-01f, 9.58025362e-03f, 1.90440014e-01f, 4.81794849e-02f, 5.61555922e-01f, 1.80129126e-01f, 7.59928465e-01f, 4.18060482e-01f, 8.46567377e-02f, 8.73556554e-01f,
  5.19402683e-01f, 3.10248435e-01f, -1.36091903e-01f, 1.02395132e-01f, 2.61590749e-01f, 1.29707947e-01f, -1.93181083e-01f, 4.58583385e-01f, -2.25253366e-02f, 5.09707779e-02f,
  -4.88515198e-03f, -2.72441596e-01f, 1.08360328e-01f, -4.16871980e-02f, -1.50085852e-01f, -3.28914762e-01f, 2.91781127e-01f, 1.57365084e-01f, 2.29499847e-01f, 4.26623188e-02f,
  -4.80179012e-01f, -1.38940483e-01f, -6.93444237e-02f, -1.10120341e-01f, 1.66336700e-01f, 8.85609612e-02f, -9.92108583e-02f, 5.55380061e-02f, 9.10171196e-02f, 4.71508682e-01f,
  -1.66573733e-01f, 5.28409407e-02f, -3.64023261e-02f, -9.90425944e-02f, -1.97326109e-01f, -4.27721180e-02f, 2.74382792e-02f, -2.17955664e-01f, -5.46818506e-03f, 4.63628257e-03f,
  -2.53583372e-01f, -1.19156674e-01f, -4.91515100e-02f, -8.58372450e-02f, -4.50333394e-02f, 7.91959614e-02f, 2.09302716e-02f, -4.62746173e-02f, -6.93038628e-02f, 2.18508448e-02f,
  -1.67301074e-02f, 1.44447787e-02f, 2.53915876e-01f, -9.52422395e-02f, 1.87669285e-02f, 1.33004114e-01f, 7.73109794e-02f, -5.54748848e-02f, -1.35779232e-02f, 1.81280412e-02f,
  -1.05478518e-01f, -5.35093367e-01f, 1.51332885e-01f, -8.94315913e-03f, 1.80215403e-01f, 1.57522753e-01f, 1.69023439e-01f, -1.54062092e-01f, 7.30001554e-02f, -5.38356714e-02f,
  -2.30294764e-01f, -2.61263579e-01f, 2.13933140e-01f, 6.20298870e-02f, -3.68312687e-01f, -1.89523995e-02f, -3.47099751e-01f, -1.87958136e-01f, -1.94799528e-01f, -1.86388522e-01f,
  6.83086812e-02f, -5.42239666e-01f, -6.38854980e-01f, -1.73004314e-01f, -6.04897402e-02f, -3.92231107e-01f, -2.21152559e-01f, -1.10995568e-01f, -4.91651237e-01f, -5.41410327e-01f,
  1.03235161e+00f, 6.03335619e-01f, 5.68573415e-01f, 5.49853921e-01f, 1.00364700e-01f, 2.96912462e-01f, 4.06325519e-01f, 2.13681385e-01f, 3.02979890e-02f, 1.94917947e-01f,
  -5.90290725e-02f, -8.45068395e-02f, 1.64356194e-02f, 1.33280009e-01f, 2.19819710e-01f, 2.98430264e-01f, 1.93883985e-01f, 2.93331534e-01f, 1.22915350e-01f, 2.51334250e-01f,
  7.00132325e-02f, 2.02464297e-01f, 2.75004327e-01f, 1.30247027e-01f, 1.45563394e-01f, -4.37734425e-02f, 7.90087730e-02f, 6.35204762e-02f, 5.37456572e-02f, 2.73315072e-01f,
  -1.34968787e-01f, 4.61792082e-01f, -1.23971082e-01f, -1.59411117e-01f, -1.92208797e-01f, 3.56430560e-02f, 1.19531296e-01f, 6.34971680e-03f, -4.92714904e-02f, -6.77585322e-03f,
  -2.12106049e-01f, -1.08760476e-01f, -1.32090434e-01f, -1.20750792e-01f, -8.90186150e-03f, -2.25462224e-02f, -6.97541982e-02f, 5.44138439e-02f, 9.28665325e-02f, -1.15093105e-01f,
  -1.58530213e-02f, -3.55861634e-02f, 3.12780999e-02f, -1.91491339e-02f, 1.59167871e-02f, -1.56584874e-01f, 2.79785674e-02f, 2.54488289e-02f, -1.00284413e-01f, 1.64762571e-01f,
  -1.10441461e-01f, 1.71700343e-01f, 1.90750614e-01f, 1.43602833e-01f, 1.65578797e-01f, -5.23284264e-02f, -8.79438818e-02f, 1.10616954e-02f, 1.90895990e-01f, 5.51399961e-02f,
  -1.67771369e-01f, 4.17447053e-02f, 1.95909426e-01f, 3.59658524e-02f, 1.05661616e-01f, 2.47069933e-02f, -1.25188474e-02f, -1.40797600e-01f, 2.56421277e-03f, -1.55822545e-01f,
  -3.27254273e-02f, -1.82652429e-01f, -2.60083169e-01f, -8.46289173e-02f, -3.41452569e-01f, 1.27462093e-02f, -1.44148991e-03f, -5.02188280e-02f, -4.87889387e-02f, -2.09254071e-01f,
  -7.23111570e-01f, -2.66991615e-01f, -1.23991445e-01f, -1.34688169e-01f, -5.07109240e-02f, -1.21763527e-01f, 1.83998674e-01f, -4.98938374e-02f, -1.29247740e-01f, -9.57244039e-02f,
  -1.09499812e-01f, -1.09573066e-01f, -8.86502638e-02f, -3.26979049e-02f, -1.77020133e-01f, -2.10439920e-01f, -4.98605929e-02f, -1.06551647e-02f, -8.48614946e-02f, -9.60574597e-02f,
  -6.03964999e-02f, -1.65687948e-01f, -2.63954222e-01f, -1.76362377e-02f, -9.05247256e-02f, -2.98894465e-01f, -2.79736072e-01f, -1.97654128e-01f, -1.97168201e-01f, -1.44404158e-01f,
  -1.42109588e-01f, -2.17047602e-01f, -3.66851032e-01f, -5.68428695e-01f, -4.65644389e-01f, -2.20091060e-01f, -3.15274626e-01f, 1.28626093e-01f, -1.32512329e-02f, -1.78925306e-01f,
  -3.31764191e-01f, -3.25321972e-01f, -4.55300629e-01f, -1.36045963e-01f, -2.09294483e-02f, -8.84389728e-02f, -1.44836679e-01f, -1.22161180e-01f, 8.20536457e-04f, 5.03510594e-01f,
  3.60430963e-02f, -1.05732001e-01f, -1.75386872e-02f, 1.80246860e-01f, 7.93114305e-02f, -1.45186543e-01f, 4.13455255e-03f, -4.66257706e-03f, 1.26928315e-01f, -7.61503354e-02f,
  -2.53762811e-01f, 1.17870823e-01f, 1.03640795e-01f, -8.00262466e-02f, 2.17670966e-02f, 2.82466114e-01f, -6.54813973e-03f, -8.07116553e-02f, -4.08976860e-02f, 8.05674195e-02f,
  -3.92146289e-01f, 3.96043509e-01f, -3.76577586e-01f, 1.95724797e-02f, -6.64028972e-02f, 1.25417650e-01f, -1.20580040e-01f, 1.14250354e-01f, -1.63269132e-01f, 5.08852243e-01f,
  -1.58686519e-01f, -1.08204812e-01f, -4.14262801e-01f, 1.29718974e-01f, 4.81642187e-01f, -2.09728748e-01f, 7.63239413e-02f, 4.00545806e-01f, 2.95909554e-01f, 1.65114820e-01f,
  2.86908060e-01f, 4.05881852e-02f, 7.64405653e-02f, 6.55977475e-03f, 2.19495401e-01f, -1.46656975e-01f, 6.88608289e-02f, 4.62021492e-02f, -1.59517247e-02f, -5.93614429e-02f,
  1.76156893e-01f, 9.31869149e-02f, 1.64136574e-01f, 2.33518928e-01f, 4.41510752e-02f, -1.39304370e-01f, 9.46256295e-02f, 1.22239724e-01f, 9.62950662e-02f, 1.30214933e-02f,
  -1.49331570e-01f, 6.28313124e-02f, -2.43367866e-01f, 5.92390299e-02f, -7.98084885e-02f, 3.68512273e-01f, 1.85574755e-01f, -2.78292270e-03f, -1.78862095e-01f, 1.97652541e-02f,
  -6.67229295e-01f, 1.48293106e-02f, -8.50953534e-02f, -9.16964840e-03f, -8.32570624e-03f, 4.49962765e-01f, -9.06725824e-02f, 9.59625989e-02f, 6.15284517e-02f, 6.91855177e-02f,
  5.18725403e-02f, 3.69943455e-02f, -3.35252196e-01f, -7.02553764e-02f, 1.30413314e-02f, -3.92027013e-02f, -1.54017478e-01f, -3.88616174e-01f, -3.11914504e-01f, -1.77592766e-02f,
  -3.39269966e-01f, -3.20453048e-01f, -6.88917637e-01f, -5.19276142e-01f, -7.10588545e-02f, -4.32292491e-01f, -2.97622651e-01f, -2.59917825e-01f, -3.39355975e-01f, -5.07259309e-01f,
  -1.25811681e-01f, 1.58147618e-01f, 6.01054132e-01f, -7.90559202e-02f, 5.88434577e-01f, 5.42710602e-01f, 6.13561928e-01f, 3.36100191e-01f, -1.01798587e-01f, 2.70751745e-01f,
  1.82232812e-01f, -5.60038209e-01f, -5.11711359e-01f, -4.43945438e-01f, -3.02816808e-01f, 1.57647088e-01f, 1.66908950e-02f, -2.20728531e-01f, -3.35347146e-01f, -1.73013493e-01f,
  -3.83788347e-01f, -9.48484167e-02f, -1.99360192e-01f, -1.96365371e-01f, 9.26063955e-03f, -3.43123496e-01f, 2.10713521e-01f, 3.50505710e-01f, 1.48125470e-01f, -3.48428547e-01f,
  -1.66735113e-01f, 2.35156655e-01f, -3.96075040e-01f, -4.17586625e-01f, 7.58743361e-02f, -1.38957784e-01f, -9.52280089e-02f, -9.52660665e-03f, 1.37779117e-02f, -5.20251133e-03f,
  4.85720066e-03f, -5.51656298e-02f, -1.40280370e-02f, 9.13346782e-02f, 1.62514418e-01f, 7.89235160e-02f, 9.71220359e-02f, -1.58127204e-01f, -1.43828139e-01f, 7.04441518e-02f,
  2.19760314e-02f, 2.86530584e-01f, 2.75928646e-01f, 1.37947500e-01f, 2.45507341e-02f, -3.41817886e-02f, 1.88882157e-01f, 5.31713516e-02f, 1.45188794e-01f, -6.03380799e-02f,
  -1.07188419e-01f, 1.45745724e-01f, -1.22966029e-01f, 7.85594806e-02f, 4.44457904e-02f, -3.38004418e-02f, 6.45612692e-03f, 6.26173764e-02f, -5.16542420e-02f, 5.19988351e-02f,
  9.46745425e-02f, -5.71849123e-02f, 3.22128981e-01f, 6.48251399e-02f, -1.20906614e-01f, 6.55092523e-02f, 2.36764416e-01f, 1.45454407e-01f, 1.72360763e-01f, 1.90622717e-01f,
  -1.09523144e-02f, 6.62885904e-02f, 2.61309296e-01f, 7.54122958e-02f, 2.66215980e-01f, 1.49518445e-01f, 5.89081086e-03f, -3.80990915e-02f, 2.17423141e-01f, 3.24836910e-01f,
  -3.90090108e-01f, 1.24326497e-01f, -4.88205075e-01f, -2.27060169e-02f, 1.67142585e-01f, 4.21428382e-02f, -1.51791960e-01f, 5.10791913e-02f, 2.15483338e-01f, 1.04506016e-01f,
  1.11564144e-01f, -3.04410160e-02f, 1.01400837e-01f, 2.67212335e-02f, 7.44873732e-02f, 2.79330891e-02f, 3.26490104e-02f, 7.11380914e-02f, -3.27912085e-02f, 1.40606821e-01f,
  6.83275312e-02f, 1.15060069e-01f, -4.90302802e-04f, 7.15677887e-02f, 1.36615820e-02f, 3.27753387e-02f, 4.58260886e-02f, 4.15558554e-03f, 1.54056758e-01f, -8.00343081e-02f,
  -1.20411932e+00f, 5.42315364e-01f, 7.23761439e-01f, -2.70763606e-01f, 3.35539997e-01f, 2.13893294e-01f, 1.14694543e-01f, -3.42955500e-01f, -1.79030970e-01f, 1.96466327e-01f,
  2.38768160e-01f, -1.37695521e-01f, 2.14776218e-01f, -1.70630470e-01f, -3.44057649e-01f, 3.55675846e-01f, 4.62273926e-01f, -2.71373004e-01f, -7.60182202e-01f, -5.21654963e-01f,
  -1.67361423e-01f, -3.67249936e-01f, -6.27717018e-01f, -3.30658287e-01f, 2.13787124e-01f, 3.76068242e-03f, 4.32765812e-01f, 2.31997371e-01f, 3.40091676e-01f, 5.53275406e-01f,
  5.71241677e-01f, -2.45112125e-02f, -1.83213383e-01f, -2.41155073e-01f, 2.99192399e-01f, -3.67114425e-01f, -5.65051399e-02f, 1.04492635e-01f, -1.99410729e-02f, 1.16077125e-01f,
  2.38348186e-01f, -6.13551438e-02f, 1.22664906e-01f, -8.07045177e-02f, -1.71106264e-01f, -4.47591454e-01f, -1.57814965e-01f, -5.10466516e-01f, -3.88803333e-01f, -7.55711347e-02f,
  -3.67060862e-03f, -2.89085563e-02f, 2.27198191e-02f, -4.60964888e-02f, -4.16433252e-02f, -1.25096262e-01f, 7.00901523e-02f, -2.89460868e-01f, -3.25803071e-01f, -1.33135095e-01f,
  -7.20579848e-02f, 1.11512095e-01f, 2.80001145e-02f, 5.40905781e-02f, -1.28584370e-01f, 2.03294873e-01f, 1.77964926e-01f, -8.32246710e-03f, -7.65111223e-02f, -5.05863391e-02f,
  -1.16134845e-02f, 4.04493883e-02f, -1.04615442e-01f, 9.14721563e-02f, 1.18055038e-01f, -6.21707849e-02f, 3.19206752e-02f, -8.32387805e-03f, 1.46822423e-01f, 2.50496101e-02f,
  -9.38970372e-02f, 8.06840211e-02f, 3.18392739e-02f, -2.77858943e-01f, 1.80936337e-01f, 1.00014150e-01f, 7.61576220e-02f, 6.15603477e-02f, -5.92273101e-02f, 4.18296456e-02f,
  -3.45619619e-01f, -1.82731356e-02f, 1.33531645e-03f, -1.77800313e-01f, 1.40018702e-01f, -2.01321281e-02f, 1.28774151e-01f, -6.28856272e-02f, 1.40383810e-01f, -8.49116594e-02f,
  -1.10209949e-01f, -1.21138237e-01f, 1.66199610e-01f, -4.42242771e-02f, -1.42442942e-01f, 2.07672138e-02f, 7.84351975e-02f, -1.18420213e-01f, -3.03055674e-01f, -2.59456970e-02f,
  1.00827236e-02f, -5.39655864e-01f, -4.50119227e-01f, -1.64447382e-01f, -8.65429118e-02f, -3.77192676e-01f, -1.24921218e-01f, -4.24248070e-01f, -4.49658781e-01f, -5.73407888e-01f,
  -4.01116371e-01f, -3.71474296e-01f, -7.36656711e-02f, 3.30132037e-01f, 4.36998785e-01f, 1.17964879e-01f, -2.11568445e-01f, -1.79557558e-02f, 2.92378873e-01f, 5.44987768e-02f,
  2.07177565e-01f, 4.67050344e-01f, 3.22518349e-01f, 3.80184799e-01f, 1.60597801e-01f, 1.97628692e-01f, 3.52808535e-01f, 1.85999364e-01f, 1.01092674e-01f, 4.06147726e-03f,
  2.22206086e-01f, -8.26783404e-02f, -7.02388212e-02f, 7.60383159e-02f, 3.26912999e-01f, 4.77176934e-01f, 1.14097506e-01f, 2.54624009e-01f, 1.80057406e-01f, 3.07165921e-01f,
  1.64226264e-01f, -1.78987995e-01f, 2.13369012e-01f, 1.12316936e-01f, 4.14037108e-02f, -2.69818962e-01f, -5.82583137e-02f, -1.72162026e-01f, -1.24002725e-01f, -1.67201161e-01f,
  1.08763650e-01f, -6.69972152e-02f, 9.63442773e-02f, -1.39777482e-01f, -1.92904934e-01f, -2.23457649e-01f, -8.54749307e-02f, -7.24877492e-02f, 1.60288751e-01f, -4.32322770e-02f,
  2.44120300e-01f, -1.18360426e-02f, -6.69694245e-02f, -6.18632324e-03f, 7.58900940e-02f, 2.29046375e-01f, -5.31938300e-02f, -2.04203650e-02f, -7.09325522e-02f, -1.17248856e-01f,
  4.89253342e-01f, 2.94843286e-01f, 3.24450523e-01f, 1.59565344e-01f, 1.58731028e-01f, 4.82832640e-02f, 1.34695664e-01f, 9.34935212e-02f, 8.15995187e-02f, -1.13191446e-02f,
  2.25122139e-01f, 2.57039785e-01f, 2.66225985e-03f, -3.53096016e-02f, 9.78819653e-02f, -5.10883098e-03f, -5.93240932e-03f, -2.30078120e-02f, 1.75061867e-01f, 1.29411578e-01f,
  1.47638217e-01f, 9.86237526e-02f, -8.26499239e-02f, 1.20897091e-03f, 7.66114891e-02f, 1.27257794e-01f, 1.26116350e-01f, 9.07791555e-02f, -2.60776989e-02f, -2.78806835e-02f,
  1.98130012e-01f, 4.73813772e-01f, 1.78964972e-01f, -4.46018577e-02f, 1.58304032e-02f, -1.10752448e-01f, 1.29491970e-01f, -7.00086504e-02f, -6.10170998e-02f, -9.59151015e-02f,
  -8.59251246e-02f, -9.34128761e-02f, -1.11287206e-01f, 3.38697061e-02f, -4.45838384e-02f, -4.31788377e-02f, -6.44180626e-02f, 7.44152442e-02f, 1.97779030e-01f, 4.28194180e-02f,
  2.26632934e-02f, -1.03728950e-01f, 3.13393436e-02f, 6.28670081e-02f, 2.47219846e-01f, 1.68394178e-01f, 1.64504219e-02f, 7.73120299e-02f, -5.09644188e-02f, -1.31584704e-01f,
  -8.48517001e-01f, -6.61823750e-01f, 2.73943096e-01f, 2.75913596e-01f, 4.96924132e-01f, 4.88634914e-01f, 4.06982869e-01f, 3.07517290e-01f, 3.87402117e-01f, 1.80661827e-02f,
  -2.94161081e-01f, 4.77429107e-03f, 1.26635358e-01f, 1.70571476e-01f, 2.00619310e-01f, 3.48126113e-01f, 6.73298359e-01f, 3.64487857e-01f, 2.86132783e-01f, 3.34573239e-01f,
  2.53777951e-01f, 1.18971750e-01f, -2.18448266e-01f, 1.97960645e-01f, -3.67462523e-02f, 2.79639423e-01f, 1.27294183e-01f, 1.51961436e-02f, -1.43555984e-01f, 2.60154009e-02f,
  -3.86061311e-01f, -6.49447024e-01f, 2.01809093e-01f, -7.49658644e-02f, -2.18248874e-01f, -1.48579091e-01f, 1.66242495e-02f, -1.09742433e-01f, -5.46919629e-02f, 2.04619169e-01f,
  -5.43750077e-02f, -2.80921221e-01f, -3.10200434e-02f, -9.36626568e-02f, 6.12601079e-02f, 2.06447765e-03f, -2.68144161e-01f, 1.33019313e-02f, 1.36444956e-01f, -3.46764028e-02f,
  -1.64533839e-01f, 3.05361580e-03f, 2.26056665e-01f, 2.61466742e-01f, 2.92679630e-02f, 5.26152439e-02f, -1.67575881e-01f, -1.34984210e-01f, -1.86467730e-02f, 2.73497049e-02f,
  2.05287501e-01f, -9.46485400e-02f, -1.39737517e-01f, -4.13492247e-02f, -4.08106558e-02f, 7.48140514e-02f, -3.08054276e-02f, 8.10978860e-02f, 2.32589059e-02f, -1.38224638e-03f,
  2.24776641e-01f, 1.47577867e-01f, 8.21328089e-02f, 4.52041663e-02f, -6.02539293e-02f, -1.42508313e-01f, -5.32889105e-02f, -1.67579442e-01f, -1.58159897e-01f, -1.17335655e-01f,
  -3.58928591e-02f, 2.56309249e-02f, -1.66043893e-01f, 3.40760946e-02f, -1.91405881e-03f, 1.62230462e-01f, 8.22384357e-02f, -1.19328268e-01f, 4.52066548e-02f, -1.83430240e-02f,
  3.24134201e-01f, -1.11286215e-01f, -1.67413093e-02f, -2.07310915e-01f, -2.43266001e-01f, -3.35317403e-01f, -1.26293659e-01f, -2.87032779e-02f, -4.89323325e-02f, 2.69506928e-02f,
  -7.79222697e-02f, -3.21372896e-01f, -1.95011407e-01f, 4.19774614e-02f, 1.07507505e-01f, -3.41826468e-03f, -2.31867179e-01f, 6.14101440e-02f, 3.02697904e-02f, -2.35404074e-02f,
  -2.51027662e-02f, 2.97108471e-01f, 2.10300952e-01f, 2.87654787e-01f, 1.14996970e-01f, 2.89061219e-01f, -2.27755792e-02f, 4.62321639e-02f, 1.55731320e-01f, 2.74784058e-01f,
  3.95891368e-01f, 3.18399251e-01f, -3.19730073e-01f, 1.74832389e-01f, 8.39293778e-01f, 3.39744352e-02f, -3.97068024e-01f, -8.51934135e-01f, -1.20423459e-01f, 2.83401728e-01f,
  9.02752280e-01f, 5.04513144e-01f, -2.98723519e-01f, -3.77042264e-01f, -7.14872062e-01f, -8.03649068e-01f, -9.15315986e-01f, -1.03076267e+00f, -7.66746461e-01f, 1.14212066e-01f,
  3.85576755e-01f, 1.21199086e-01f, -1.57649890e-01f, -4.17686075e-01f, 3.44522029e-01f, 1.46055773e-01f, 1.71419792e-02f, 4.73668545e-01f, 2.16145828e-01f, 5.37571870e-02f,
  1.87432721e-01f, 1.80007610e-02f, -2.87674576e-01f, 2.99623013e-01f, 2.40717918e-01f, -2.35715315e-01f, -8.85338709e-02f, -3.54415476e-01f, -7.71265775e-02f, -1.21821716e-01f,
  7.06921339e-01f, 1.84164464e-01f, 9.85288769e-02f, -1.33356214e-01f, -1.39217060e-02f, -1.88090339e-01f, -4.35667366e-01f, -6.73364341e-01f, -6.22037053e-01f, -1.78231094e-02f,
  6.06958032e-01f, 7.29570389e-01f, 3.70282307e-02f, -3.67487848e-01f, -5.80258787e-01f, -1.49284244e-01f, -2.21939176e-01f, -2.63742238e-01f, -5.81032753e-01f, -6.09034836e-01f,
  -1.10772058e-01f, 1.60969764e-01f, 1.40497461e-01f, 1.05538093e-01f, 9.36422944e-02f, 1.66071713e-01f, -5.55036701e-02f, 7.11001903e-02f, -5.68140857e-03f, -3.87486033e-02f,
  -1.02171481e-01f, 2.35544727e-03f, -1.24474518e-01f, -5.79967536e-02f, -1.32406518e-01f, 4.83047068e-02f, 1.11784294e-01f, -2.39189506e-01f, -1.61921844e-01f, 2.80169770e-02f,
  -1.23890258e-01f, 2.98006516e-02f, 1.79481223e-01f, -1.32720262e-01f, -4.70087454e-02f, -2.55931586e-01f, -5.09845987e-02f, -1.28276184e-01f, -2.04060256e-01f, 2.03704871e-02f,
  1.54946953e-01f, 8.93901139e-02f, -7.35322535e-02f, -3.92474145e-01f, 4.18812521e-02f, 1.18149619e-03f, 3.07876885e-01f, -1.71558768e-01f, 9.53974351e-02f, -1.52384415e-01f,
  9.26587805e-02f, -1.70978438e-02f, 1.89148456e-01f, 1.71763655e-02f, 4.94698361e-02f, 1.32213950e-01f, -1.49929777e-01f, 1.81422576e-01f, -2.38724388e-02f, 3.39048266e-01f,
  -1.26239330e-01f, -1.17496148e-01f, -1.11564420e-01f, -2.04878718e-01f, -1.67950578e-02f, -2.38726661e-01f, -4.16983634e-01f, -2.67746508e-01f, -4.78145361e-01f, -5.95267475e-01f,
  1.28330624e+00f, -3.82384241e-01f, -1.19216049e+00f, 3.61033231e-01f, -3.58948529e-01f, -5.04562497e-01f, -2.49734715e-01f, 1.29760757e-01f, 3.12675804e-01f, -2.45366946e-01f,
  -2.75949806e-01f, -1.96639486e-02f, -3.52011397e-02f, -1.05892137e-01f, -1.28788957e-02f, -3.01410854e-01f, -3.12647939e-01f, -1.39926732e-01f, -4.34641577e-02f, -2.43052974e-01f,
  -3.71229686e-02f, 2.10363939e-01f, 4.15414453e-01f, -3.49947661e-02f, -4.27718461e-01f, -2.39151604e-02f, -5.05655348e-01f, -4.58632112e-01f, -5.35700798e-01f, -4.43097651e-01f,
  -7.64789462e-01f, -1.30194828e-01f, 1.53399140e-01f, 1.93839639e-01f, 3.66305076e-02f, 1.20718904e-01f, 3.70900296e-02f, 1.61298409e-01f, 3.08299392e-01f, 1.41663596e-01f,
  -7.18991160e-02f, 7.63084367e-02f, 9.09107327e-02f, -1.67205408e-02f, 5.01658432e-02f, -4.73981164e-02f, 2.45183762e-02f, 1.75332263e-01f, -3.08445524e-02f, -2.09809735e-01f,
  -2.17196926e-01f, 4.28431109e-02f, -2.46585626e-03f, 1.04645200e-01f, -1.04890555e-01f, 1.09769508e-01f, -1.18158914e-01f, -7.88278729e-02f, -5.10913767e-02f, 2.17257172e-01f,
  -1.19982488e-01f, -1.52891129e-01f, -6.75676987e-02f, 5.85081708e-03f, 1.01093620e-01f, 9.10663307e-02f, 5.59253022e-02f, 2.31237877e-02f, -2.14888100e-02f, 1.14544921e-01f,
  1.53913155e-01f, -1.02404794e-02f, 7.03463377e-03f, 7.00482950e-02f, -2.13701963e-01f, -4.03252281e-02f, 1.33329585e-01f, -1.00804046e-01f, -9.29643735e-02f, 1.88265204e-01f,
  5.43401241e-02f, -1.02195300e-01f, -5.76476268e-02f, -1.46267235e-01f, -2.24840671e-01f, -1.11509569e-01f, -1.98630869e-01f, -1.93259016e-01f, 2.58802194e-02f, -4.44664736e-04f,
  -1.14418594e-02f, 6.57075122e-02f, 1.94098383e-01f, 1.89709917e-01f, 1.24219162e-02f, -7.37265944e-02f, -2.74248272e-01f, -5.53661659e-02f, 1.23061957e-02f, -1.70235321e-01f,
  -2.77366310e-01f, -4.68071066e-02f, -2.96336830e-01f, -6.93987235e-02f, 1.26999289e-01f, -1.51584931e-02f, 2.97792312e-02f, 8.32872689e-02f, -1.87200487e-01f, -3.36024523e-01f,
  -2.51843184e-01f, 1.91251114e-01f, 3.46415430e-01f, 1.52070910e-01f, -2.90587787e-02f, 1.78931490e-01f, -9.09701884e-02f, -1.06791168e-01f, 3.36719118e-02f, 3.74392420e-01f,
  1.34774828e+00f, -5.32572269e-01f, -5.63737392e-01f, 4.79692698e-01f, -4.59846705e-01f, -5.13207197e-01f, -8.46076906e-01f, 1.12652123e-01f, 5.55990458e-01f, -6.02014959e-01f,
  -1.50912359e-01f, 6.17249846e-01f, 5.70071816e-01f, 5.38026094e-01f, 4.70924973e-01f, -9.08694446e-01f, -5.64100862e-01f, 1.16482548e-01f, 1.80933028e-01f, -3.67225081e-01f,
  -4.94299471e-01f, -1.20849207e-01f, 3.64320040e-01f, 2.69792855e-01f, -4.06575263e-01f, 3.05041987e-02f, -3.95665437e-01f, -3.90246928e-01f, -6.21229291e-01f, -8.82334590e-01f,
  -4.28108454e-01f, 1.23664424e-01f, -8.93268213e-02f, 2.92608887e-01f, -1.48532167e-01f, 1.73758008e-02f, 6.78104460e-02f, -1.32755369e-01f, -1.96741179e-01f, -1.58923462e-01f,
  2.79779769e-02f, -7.85976350e-02f, 1.68277368e-01f, -2.30467141e-01f, -5.44600785e-02f, -5.82962930e-02f, -7.07366243e-02f, -7.48276189e-02f, 5.68813980e-02f, -4.86558199e-01f,
  -5.32763898e-01f, -4.36078817e-01f, 2.57395604e-03f, -1.08243652e-01f, -1.09948151e-01f, 8.06696042e-02f, -4.24671739e-01f, -2.59341538e-01f, 7.81576633e-02f, -6.53647602e-01f,
  -1.92229271e-01f, -6.48136809e-02f, -8.20492581e-02f, 1.63643118e-02f, -7.93201327e-02f, 1.50039457e-02f, -2.59205736e-02f, -1.12926081e-01f, 4.14659735e-03f, -1.50839224e-01f,
  9.04593896e-03f, -1.77067384e-01f, 6.04642294e-02f, -4.34400439e-02f, -9.90641266e-02f, -1.30566895e-01f, 2.91389376e-02f, 3.90564352e-02f, -1.12886764e-02f, 4.03587855e-02f,
  -3.48558351e-02f, -1.55232444e-01f, 1.14734344e-01f, -1.06462926e-01f, 2.99490578e-02f, 1.71181187e-01f, 7.60580003e-02f, 1.03653697e-02f, 1.11508653e-01f, -2.02299327e-01f,
  4.80390489e-01f, 3.50046724e-01f, 4.57550101e-02f, 1.13338642e-01f, -1.81050256e-01f, -1.42725870e-01f, 4.14626934e-02f, -1.45296216e-01f, 4.23717983e-02f, 1.35910675e-01f,
  -1.61219269e-01f, 4.29642871e-02f, 9.76605620e-03f, -6.62362650e-02f, -2.91353047e-01f, 1.38944192e-02f, -1.48864582e-01f, -2.47979343e-01f, -1.24300987e-01f, -3.12180251e-01f,
  1.20495660e-02f, -2.05985144e-01f, 2.03585491e-01f, 1.35239497e-01f, -1.18323833e-01f, 2.42240191e-01f, -4.65099275e-01f, -4.32345331e-01f, 1.17613092e-01f, -5.34771681e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  7.24609077e-01f, 8.05433631e-01f, 8.36891294e-01f, 8.08538437e-01f, 7.42273867e-01f, 3.39485645e-01f, 8.21568727e-01f, 8.54548097e-01f, 1.03792644e+00f, 3.53212655e-01f,
  4.67874378e-01f, 1.29719567e+00f, 2.06921976e-02f, 1.16254652e+00f, 1.33538559e-01f, 5.13849258e-01f, 8.49779487e-01f, 6.88035488e-01f, 3.31039995e-01f, 8.89714062e-01f,
  5.78239143e-01f, 3.86902153e-01f, 7.48089552e-01f, 4.07828361e-01f, 5.81182182e-01f, 5.02857029e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -3.90404254e-01f, -4.81703073e-01f, -1.87342718e-01f, -2.49804914e-01f, -5.32536209e-01f, -3.49722117e-01f, 5.46274185e-01f, -4.13699523e-02f, -2.40295857e-01f, -3.80117595e-02f,
  3.90615389e-02f, 8.52235407e-02f, -3.68198939e-02f, -3.43516916e-01f, -9.66553450e-01f, 2.29146913e-01f, -6.01288617e-01f, -7.15690255e-01f, 2.95906961e-01f, -4.63820100e-01f,
  1.04439759e+00f, 3.15097243e-01f, -1.29310918e+00f, -3.94341946e-01f, 3.84498179e-01f, -4.89566594e-01f, -1.45425200e+00f, -4.24498141e-01f, -2.39644691e-01f, 1.30329877e-01f,
  -1.65130779e-01f, 4.18532789e-01f, 3.31250625e-03f, 9.32377502e-02f, 1.24045536e-01f, -1.51346326e-01f, -2.40102713e-03f, -2.48022482e-01f, 1.51357025e-01f, -4.10549939e-01f,
  4.19991910e-01f, -1.23899353e+00f, -3.56057614e-01f, 1.63030788e-01f, 4.25166428e-01f, -8.85349452e-01f, -4.72945683e-02f, -3.71244013e-01f, -6.21724844e-01f, -1.45133924e+00f,
  -8.60403895e-01f, 1.98380604e-01f, -7.33772755e-01f, 8.95868838e-01f, -8.85641158e-01f, 5.36854506e-01f, -7.76618302e-01f, -5.24584293e-01f, -6.10320568e-01f, 1.40539244e-01f,
  -1.19191661e-01f, -5.17041087e-01f, 5.79127610e-01f, 1.14315248e+00f, -4.44712639e-02f, 5.39018810e-02f, -4.87191007e-02f, -3.07852507e-01f, 5.26200831e-01f, 1.25846956e-02f,
  7.26362884e-01f, -9.79671299e-01f, -3.15289944e-01f, -2.05218643e-01f, 6.07684553e-01f, -3.15470815e-01f, 1.53966159e-01f, -7.03203559e-01f, 2.66239047e-01f, 1.99641764e-01f,
  -2.07703039e-01f, 8.08904409e-01f, -1.47301808e-01f, -7.91549504e-01f, 5.51518023e-01f, 4.92747515e-01f, 1.89077824e-01f, -9.25127506e-01f, 4.83646542e-02f, -4.42931890e-01f,
  -3.90604019e-01f, 3.14355642e-01f, -6.30411446e-01f, -9.67979491e-01f, -1.10605367e-01f, 2.77882516e-01f, -2.55139232e-01f, -5.23281209e-02f, 1.53386950e-01f, -5.25839567e-01f,
  -5.28564990e-01f, 5.16244061e-02f, -5.12169600e-01f, 3.95865113e-01f, -4.97134537e-01f, 5.48804700e-01f, -7.55081058e-01f, -8.52342248e-01f, -1.55375659e-01f, -4.94817555e-01f,
  -6.89997852e-01f, -3.62060815e-01f, -2.07508042e-01f, 7.07162857e-01f, 3.30032855e-01f, -1.28099155e+00f, -1.13741958e+00f, 7.33830094e-01f, -1.27186847e+00f, -5.18875837e-01f,
  4.10843939e-01f, 6.13214433e-01f, 4.60115194e-01f, -3.65656704e-01f, 2.95626014e-01f, -1.26489520e-01f, -8.95453572e-01f, -7.45253563e-01f, 5.92456423e-02f, 2.07855120e-01f,
  -3.38290334e-02f, 7.15801045e-02f, 2.26978377e-01f, -1.60070792e-01f, -6.91935897e-01f, 2.84118205e-01f, -2.82426387e-01f, -5.65827549e-01f, -8.37780714e-01f, 2.48580992e-01f,
  -3.71322602e-01f, 2.37683937e-01f, -8.98745179e-01f, -8.80751848e-01f, 5.14238775e-01f, -4.14300740e-01f, 3.56333822e-01f, 4.75665540e-01f, 2.86202710e-02f, -1.56670526e-01f,
  7.55497217e-01f, -7.29627192e-01f, 1.32158712e-01f, 1.52110204e-01f, 4.23145533e-01f, 7.83277079e-02f, 1.71289206e-01f, 1.20034732e-01f, -4.67110693e-01f, 6.98512942e-02f,
  1.61599353e-01f, 1.05565665e-02f, 8.44430253e-02f, 5.04943609e-01f, -2.15456128e-01f, -4.21409965e-01f, -6.72046006e-01f, -1.50971860e-01f, 5.12743533e-01f, 1.11592269e+00f,
  -1.65597692e-01f, 2.13400051e-01f, -6.57488048e-01f, 9.53495264e-01f, -5.33222500e-03f, -3.04689437e-01f, -9.25568342e-01f, -2.09371105e-01f, -6.25203848e-01f, 1.05043542e+00f,
  -5.22864819e-01f, -5.49147248e-01f, -4.93408352e-01f, -1.32532090e-01f, 4.59847832e-03f, -7.56985486e-01f, -1.11233687e+00f, -6.28264427e-01f, 2.10201144e-01f, 2.42266983e-01f,
  7.63974667e-01f, -1.10728249e-01f, -2.55642354e-01f, 3.78505252e-02f, 1.85787067e-01f, 3.42016399e-01f, 1.67196795e-01f, 1.11145545e-02f, -1.08314168e+00f, -7.06264377e-01f,
  -3.91146630e-01f, -8.19835961e-01f, 6.57408893e-01f, 4.64672327e-01f, -1.07458025e-01f, -7.44854510e-01f, -3.12681735e-01f, -5.71209192e-01f, 7.92270243e-01f, 6.51820004e-02f,
  -1.12089074e+00f, 2.61819512e-01f, -7.14703441e-01f, -8.24333012e-01f, 9.41907942e-01f, 2.57405579e-01f, 3.10121953e-01f, -1.11028218e+00f, -1.83874816e-01f, -4.17719156e-01f,
  -8.56368363e-01f, -1.14225757e+00f, -4.89628732e-01f, -4.50358599e-01f, -3.28476816e-01f, -1.14277136e-02f, -1.09602371e-02f, -1.22947417e-01f, -1.81075215e-01f, -2.84842253e-01f,
  -7.30465770e-01f, -8.83630216e-01f, -6.89496934e-01f, 9.61321950e-01f, -1.03131855e+00f, -2.30781540e-01f, -1.63710892e-01f, -5.07411420e-01f, -1.30566254e-01f, 5.93453825e-01f,
  4.81874138e-01f, 1.50116786e-01f, -1.72964513e-01f, -7.31902719e-02f, 2.09301651e-01f, -4.23780203e-01f, -6.19886696e-01f, -1.18759580e-01f, -4.53120619e-01f, -2.94991046e-01f,
  6.33523762e-01f, 4.28413272e-01f, 4.85738307e-01f, -4.58513200e-01f, -3.94511819e-01f, -6.20206237e-01f, 4.54908669e-01f, 7.22655877e-02f, -9.16405544e-02f, 1.04974657e-01f,
  -4.60068822e-01f, 2.14772865e-01f, 5.53110182e-01f, -1.03622615e+00f, 3.11974734e-01f, -4.80647594e-01f, -6.87730014e-01f, -8.68488491e-01f, 2.88793832e-01f, 3.89014482e-01f,
  9.50283885e-01f, 3.23049426e-01f, -3.70561182e-01f, 2.08126456e-01f, -1.94531158e-01f, -5.33686340e-01f, -3.10431600e-01f, -5.24630606e-01f, -5.08545876e-01f, 8.59443247e-02f,
  -4.03820366e-01f, 3.35699141e-01f, -1.83103248e-01f, -2.51603365e-01f, 4.25962001e-01f, -4.95983750e-01f, 2.65383214e-01f, -1.07546771e+00f, 3.18245202e-01f, -6.33076429e-01f,
  -3.64436418e-01f, 2.05219015e-01f, 2.42452681e-01f, -3.43034118e-01f, -6.68253839e-01f, -1.00657654e+00f, 8.67965966e-02f, -5.32679379e-01f, 5.86180687e-01f, 1.96817011e-01f,
  -3.95231426e-01f, -3.59614879e-01f, -2.61174530e-01f, 7.94080079e-01f, -3.22218597e-01f, -1.18739498e+00f, 4.41663980e-01f, -4.94714407e-03f, 4.18608129e-01f, -9.91583049e-01f,
  4.75763500e-01f, -4.22784597e-01f, -1.63362786e-01f, -1.24812402e-01f, 4.08380836e-01f, 2.96884239e-01f, -6.31207764e-01f, 1.12174881e+00f, -3.40823233e-01f, -5.57903588e-01f,
  -3.80906492e-01f, 2.34810606e-01f, 1.94475010e-01f, -7.76276529e-01f, 6.15719259e-01f, 3.47450882e-01f, 1.30933493e-01f, 7.56655157e-01f, 1.73306629e-01f, 4.83559847e-01f,
  1.06561251e-01f, -9.67885911e-01f, 7.88387954e-01f, 6.99932098e-01f, 1.57334566e-01f, -3.95602942e-01f, -1.68661207e-01f, -3.31935376e-01f, -8.35475251e-02f, -1.13341153e-01f,
  -6.68140948e-01f, -6.85790658e-01f, -4.92745191e-01f, -5.88289022e-01f, -6.98611736e-01f, -1.02395952e+00f, 4.67627168e-01f, -1.81267738e-01f, 4.22808044e-02f, -8.82332087e-01f,
  -9.32729483e-01f, -9.15092885e-01f, -1.26899809e-01f, 3.20143551e-01f, 7.20072910e-02f, 2.73576587e-01f, -2.36543924e-01f, 1.19200628e-02f, -5.64065933e-01f, -8.28761935e-01f,
  2.34301686e-01f, -6.77940726e-01f, -8.10686290e-01f, 8.28213170e-02f, -3.92318785e-01f, -3.94011468e-01f, -6.02469325e-01f, -7.38648891e-01f, 5.03259480e-01f, 1.07964289e+00f,
  -1.12181634e-03f, -1.27155393e-01f, -6.14167452e-01f, -6.49940789e-01f, -4.87709016e-01f, 4.08266246e-01f, -9.10221875e-01f, 9.13650155e-01f, 5.23222327e-01f, -5.54342270e-01f,
  -6.31784022e-01f, 7.90379941e-01f, -5.27537048e-01f, -1.53853178e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  1.97770312e-01f, -1.53667673e-01f, 3.62758160e-01f, -1.96572617e-01f, -1.83811292e-01f, 8.49406272e-02f, 1.68425024e-01f, -1.48341507e-01f, -4.06804025e-01f, 3.87507915e-01f,
  -3.92458469e-01f, -2.81726211e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    