/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.49895418e-01f, 1.96704820e-01f, 3.58592831e-02f, -2.76459247e-01f, -4.11757752e-02f, -4.63073969e-01f, -2.90827841e-01f, 5.40952794e-02f, -1.63827732e-01f, 1.08039685e-01f,
  -9.17947367e-02f, 1.49457335e-01f, 1.63455307e-01f, -2.94643074e-01f, -2.74612725e-01f, 1.70024112e-01f, -4.97861743e-01f, -1.37269303e-01f, 6.94655553e-02f, -1.71870649e-01f,
  -5.29551543e-02f, -2.45972723e-01f, -1.48366867e-02f, 1.75330073e-01f, -6.01043217e-02f, 1.43274009e-01f, 6.09041564e-03f, 2.65566736e-01f, -1.61581531e-01f, 1.48092024e-02f,
  -9.59393829e-02f, 1.14533946e-01f, 8.08145478e-02f, 1.95032898e-02f, -1.23932771e-01f, 5.98355457e-02f, -3.34175490e-02f, 3.00361104e-02f, 5.17019536e-04f, -2.03233678e-02f,
  -2.90393531e-02f, 7.85112754e-03f, -8.52446035e-02f, 6.71654940e-02f, -5.67115098e-03f, 9.83459726e-02f, 5.28525412e-02f, -5.59315979e-02f, 8.23398083e-02f, 5.09058423e-02f,
  6.78403452e-02f, -7.30576217e-02f, -1.91216856e-01f, 3.44547932e-03f, -2.50629000e-02f, 9.53032076e-02f, -3.03750206e-03f, 5.04288711e-02f, -1.05087548e-01f, -3.80013883e-02f,
  1.99967921e-02f, -4.83805276e-02f, -5.94430529e-02f, 5.17466627e-02f, -4.03396301e-02f, 4.23637703e-02f, -9.93102603e-03f, 5.30161671e-02f, 4.89089675e-02f, 3.12116239e-02f,
  -1.23338431e-01f, -1.31899770e-02f, 3.18831876e-02f, -6.29368052e-02f, -7.47059509e-02f, -5.37954783e-03f, -2.16661058e-02f, 4.99407761e-02f, -1.03248499e-01f, 2.30204538e-02f,
  6.07586652e-02f, -6.61682263e-02f, 3.81608978e-02f, -1.87025759e-02f, 3.47680487e-02f, -6.45348057e-03f, -1.11162663e-02f, 2.20601950e-02f, -6.79103434e-02f, -1.53767735e-01f,
  -9.28407386e-02f, -1.71275325e-02f, 4.37206328e-02f, -1.42674828e-02f, 9.69115943e-02f, 2.52353642e-02f, -1.26217064e-02f, -1.25657616e-03f, -1.54723329e-02f, -4.31647412e-02f,
  -1.65300798e-02f, -3.14693674e-02f, -6.24830052e-02f, 5.45539474e-03f, -7.26125389e-02f, 3.28081753e-03f, -7.93775916e-02f, -2.41261418e-03f, -1.06281869e-01f, -2.47582160e-02f,
  -3.57892700e-02f, -1.91538334e-02f, 5.84988408e-02f, -2.49218792e-02f, -6.97188033e-03f, -4.53984067e-02f, 2.58526672e-03f, -8.17297921e-02f, 1.63467471e-02f, 1.72947091e-03f,
  -1.07428215e-01f, -5.82545340e-01f, -1.99076369e-01f, -2.19153091e-01f, -9.46132839e-02f, -2.90703952e-01f, -3.01199444e-02f, -3.05575401e-01f, -1.45305976e-01f, -8.50485638e-02f,
  -6.40436560e-02f, 1.66540537e-02f, -7.11421072e-02f, -3.41303676e-01f, -1.46521553e-02f, -9.68215764e-02f, -3.13084841e-01f, -9.38513596e-03f, 1.10840499e-01f, -2.52908021e-01f,
  -4.13954668e-02f, 2.37172749e-02f, -2.93451577e-01f, 7.35349534e-03f, -2.09055007e-01f, 9.76280589e-03f, 1.40750781e-01f, 1.82265684e-01f, 3.42823081e-02f, 1.23936906e-01f,
  -1.81743852e-03f, -8.83290842e-02f, -8.86631981e-02f, -1.42611889e-02f, -1.54794127e-01f, 3.23276147e-02f, 5.68615310e-02f, 1.40498459e-01f, 2.48213317e-02f, 1.08624175e-02f,
  4.97167604e-03f, 8.31831247e-02f, 7.61029348e-02f, 2.64453981e-02f, -3.85653600e-02f, -3.45516317e-02f, -8.29506069e-02f, -1.23391315e-01f, -3.97414528e-02f, -1.58082187e-01f,
  -7.99069628e-02f, 7.37962965e-03f, -1.36793256e-01f, 3.56048644e-02f, -1.05124544e-02f, 1.45054115e-02f, -3.06078624e-02f, -2.20436268e-02f, -3.12923826e-02f, -1.11717194e-01f,
  -5.62023511e-03f, -2.27048751e-02f, -1.20621391e-01f, 1.33209795e-01f, -2.17845775e-02f, -7.46180012e-04f, 3.07010673e-02f, 7.86326379e-02f, 4.96558808e-02f, -1.30803987e-01f,
  4.83839251e-02f, -5.22629209e-02f, 5.45903891e-02f, -3.45507599e-02f, 3.02024954e-03f, 1.29280015e-04f, 3.79749015e-02f, 1.98409632e-02f, -3.29555646e-02f, 2.75019323e-03f,
  2.61700060e-02f, -1.98980793e-02f, 1.27005372e-02f, 1.23471012e-02f, -2.99369590e-03f, -1.13201980e-02f, 4.09570709e-03f, -1.03208192e-01f, -1.14230989e-02f, 1.10754371e-02f,
  -1.71321765e-01f, -2.13804871e-01f, -1.89681724e-02f, 1.36405930e-01f, 7.79006258e-02f, -1.09605305e-01f, 3.05018723e-02f, -1.28423562e-02f, 1.85326356e-02f, -2.51625236e-02f,
  -3.84254307e-02f, -4.20547053e-02f, -6.49680048e-02f, 6.72073364e-02f, 2.02918798e-02f, -6.98082596e-02f, 7.85760581e-02f, 1.50304779e-01f, 6.60819607e-03f, 2.65403837e-02f,
  -2.43235249e-02f, 4.96553220e-02f, 5.13982363e-02f, -1.37246251e-01f, 4.25918922e-02f, -1.02918083e-02f, -2.89396960e-02f, -1.35577703e-02f, 6.09027818e-02f, 3.79546545e-02f,
  -2.17819273e-01f, -5.30338526e-01f, -1.78017184e-01f, -2.45403200e-02f, 4.26224433e-02f, 7.51432218e-03f, 2.31715545e-01f, -1.94740057e-01f, -2.98229232e-03f, -1.05390422e-01f,
  -1.05016902e-02f, -1.36972979e-01f, 8.13058540e-02f, -1.75750554e-02f, 4.17303741e-01f, 2.70511687e-01f, -5.51093370e-02f, -1.54396787e-01f, -1.67355508e-01f, -1.90824285e-01f,
  -2.89210919e-02f, 1.93878144e-01f, 4.18599188e-01f, -2.22227529e-01f, -1.12472102e-01f, -3.01607013e-01f, 1.93594322e-01f, -1.97161868e-01f, -1.46054737e-02f, 8.88982266e-02f,
  -1.09474044e-02f, -1.22694604e-01f, 4.01475504e-02f, 5.17476862e-03f, 9.73675996e-02f, 2.90059391e-02f, -8.40390194e-03f, 6.46214038e-02f, 7.19161108e-02f, 8.11275374e-03f,
  6.70854598e-02f, 3.62748466e-02f, 6.35196418e-02f, 1.80627313e-02f, -6.26304895e-02f, -9.22988504e-02f, 2.03585196e-02f, 7.36099016e-03f, -1.14399888e-01f, 1.12269372e-01f,
  3.47641222e-02f, -2.26957444e-02f, 9.90336854e-03f, -1.03926724e-02f, -7.35518616e-03f, 5.11553250e-02f, 7.87801594e-02f, 2.66962703e-02f, 6.20304868e-02f, -4.31227870e-02f,
  5.95188700e-02f, -6.61317930e-02f, 3.13710049e-02f, 7.14113042e-02f, -3.66606303e-02f, 3.60367186e-02f, 6.54793754e-02f, 6.14238158e-02f, -3.76379490e-02f, -2.52795685e-02f,
  -2.88840663e-02f, -4.73915190e-02f, -7.61854695e-03f, 4.13790382e-02f, 4.02986035e-02f, -5.86142577e-02f, -4.82663326e-02f, -1.25695854e-01f, -1.30806595e-01f, 4.90457229e-02f,
  -1.05041511e-01f, -4.45528366e-02f, -8.18113536e-02f, 5.86934984e-02f, -4.54136776e-03f, 5.08231334e-02f, -1.32624105e-01f, 5.37941232e-02f, -1.98563486e-02f, 1.69231948e-02f,
  -2.65281975e-01f, -4.21470076e-01f, 4.75687496e-02f, -5.40551245e-02f, -5.08308597e-02f, -3.99917290e-02f, 3.19404267e-02f, 7.28549734e-02f, -4.82657664e-02f, -7.90811330e-02f,
  -3.59732099e-02f, 3.08053251e-02f, -1.26582965e-01f, -2.98638083e-02f, 5.48213674e-03f, 6.71478137e-02f, 6.52160719e-02f, -1.51227519e-01f, 5.41157797e-02f, -5.72224520e-02f,
  -1.30568333e-02f, 3.15272473e-02f, -7.42091332e-03f, -1.61651801e-02f, 2.17078365e-02f, 7.86231160e-02f, -1.51120931e-01f, 3.61662731e-02f, 2.68139075e-02f, -7.64556322e-03f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -7.02088296e-01f, 3.37656349e-01f, -3.60781968e-01f, -2.48265695e-02f, 1.66099399e-01f, -5.95845878e-01f, 1.72540665e-01f, 1.66137934e-01f, -6.57576323e-02f, 5.76223016e-01f,
  2.52047449e-01f, -2.39555448e-01f, 3.42512399e-01f, -4.35349256e-01f, -8.80411744e-01f, -3.43401283e-01f, -3.23319405e-01f, -1.29732087e-01f, -1.50227681e-01f, 3.53913695e-01f,
  -2.39383623e-01f, 1.74081877e-01f, -2.24836737e-01f, 5.61502099e-01f, 1.92127928e-01f, 2.48632461e-01f, 4.43188041e-01f, 2.98506081e-01f, -6.31558150e-02f, -1.99857458e-01f,
  -6.30722269e-02f, 1.91087678e-01f, -3.07964021e-03f, -7.32334927e-02f, 1.82650667e-02f, 1.40820190e-01f, 7.95052573e-02f, 2.88798846e-02f, -1.11600392e-01f, 2.54863184e-02f,
  4.23346423e-02f, 2.30424013e-02f, -1.26696810e-01f, 1.50623498e-02f, 1.38229579e-01f, -5.56977615e-02f, -9.23200324e-02f, -2.11561486e-01f, 6.21296801e-02f, -2.07881495e-01f,
  -9.35765281e-02f, -1.15175754e-01f, -5.66970631e-02f, 2.51116715e-02f, -1.38910204e-01f, 3.43408994e-02f, -1.89510316e-01f, -6.31748810e-02f, -4.27818261e-02f, -1.13552429e-01f,
  -2.32363157e-02f, -5.30882254e-02f, 8.61165673e-02f, 3.37517634e-02f, -8.19761232e-02f, 6.76033646e-02f, 6.27983510e-02f, 4.58359569e-02f, 4.92588198e-03f, 1.03051722e-01f,
  9.85417366e-02f, 1.07446991e-04f, 5.23754954e-02f, 6.67172894e-02f, -2.92050373e-02f, -3.02221645e-02f, -3.82567197e-02f, 9.03024077e-02f, -3.62135023e-02f, -2.39032935e-02f,
  1.48472428e-01f, -6.86382949e-02f, 5.10797184e-03f, 7.87066668e-02f, 1.37593001e-02f, 1.90373347e-03f, 2.46844217e-02f, -1.15434095e-01f, 4.76589687e-02f, 4.95776497e-02f,
  3.83301042e-02f, 3.62949073e-01f, 1.05894379e-01f, 7.71195218e-02f, 1.32875820e-03f, -3.84077639e-03f, -8.52282494e-02f, -2.86700055e-02f, -3.10284849e-02f, 7.13983970e-03f,
  1.02621734e-01f, 1.47144347e-01f, 7.75946602e-02f, -2.72693578e-02f, -1.40937008e-02f, 7.54615441e-02f, 1.47281349e-01f, 8.73066336e-02f, 9.04351324e-02f, -6.77050129e-02f,
  1.64566115e-01f, 1.81949794e-01f, 8.89863744e-02f, 1.22781210e-01f, 3.18037122e-02f, 1.26116186e-01f, 2.62379367e-02f, -6.14691600e-02f, 4.24100570e-02f, 5.86214513e-02f,
  3.61254454e-01f, 5.90289652e-01f, 4.15536880e-01f, 3.11105132e-01f, -3.10426325e-01f, 1.76652208e-01f, 1.22744970e-01f, 1.62923738e-01f, 8.01114857e-01f, 9.92176756e-02f,
  -4.84635741e-01f, 5.16312599e-01f, -3.38427573e-01f, -4.28963304e-02f, -4.23779011e-01f, -8.95252824e-02f, -1.08845584e-01f, 2.37727407e-02f, 2.17338428e-01f, -8.22733119e-02f,
  -9.06251073e-02f, -5.80948830e-01f, -3.40429187e-01f, -4.25216764e-01f, -1.31847069e-01f, 2.96124637e-01f, -4.75142360e-01f, 3.17220427e-02f, 4.26360592e-02f, 1.18192192e-02f,
  1.05499290e-02f, 4.26169373e-02f, -1.00054100e-01f, 1.40760243e-01f, -2.02358011e-02f, 4.87340875e-02f, 1.16016947e-01f, -5.00465631e-02f, 2.34877560e-02f, 1.45690337e-01f,
  3.63972709e-02f, -1.14102392e-02f, 9.10581574e-02f, -3.63727175e-02f, 2.50184983e-01f, 1.95341721e-01f, 7.03298301e-02f, 6.70342371e-02f, -9.10371635e-03f, -5.99589804e-03f,
  4.80493009e-02f, 1.07605308e-01f, 1.97648685e-02f, 8.45212713e-02f, -1.23501815e-01f, 1.46193579e-01f, 7.09154382e-02f, 7.79011473e-02f, 4.98875342e-02f, 2.37533838e-01f,
  -8.66356120e-02f, 3.31265368e-02f, -6.39801621e-02f, 2.98563149e-02f, -1.15123801e-01f, -8.29710513e-02f, 4.47098305e-03f, -8.73464718e-02f, -1.47775083e-03f, -2.73088813e-02f,
  1.20177604e-02f, 1.50630057e-01f, 1.39155956e-02f, 1.10204585e-01f, 3.32663441e-03f, 1.09227777e-01f, -1.32205412e-01f, 1.04327559e-01f, 2.85590030e-02f, 6.22218102e-02f,
  4.69171755e-05f, -5.00384085e-02f, -1.68797716e-01f, -1.02030694e-01f, -1.68837178e-02f, 3.81411612e-02f, 1.12966053e-01f, 2.28860490e-02f, -2.48505455e-02f, -1.50286227e-01f,
  -1.15832239e-01f, -2.66605243e-03f, -6.65280968e-02f, -3.46821398e-02f, -2.01334301e-02f, -4.51754257e-02f, -6.60149101e-03f, 5.65467924e-02f, 8.19595754e-02f, 1.93119189e-03f,
  -5.03992811e-02f, -4.33286205e-02f, -8.48730877e-02f, 6.30836561e-02f, -4.31452133e-02f, -1.06464617e-01f, -3.59451920e-02f, -1.55145628e-02f, -1.11253597e-01f, -2.64037983e-03f,
  -2.27279857e-01f, -1.12653017e-01f, -4.92078364e-02f, -1.44883096e-01f, -2.30314992e-02f, 2.00895127e-02f, 3.86577984e-03f, 4.56987955e-02f, -1.00944892e-01f, -3.22662294e-02f,
  2.42625117e-01f, -1.17309727e-01f, -6.28009856e-01f, -4.04690742e-01f, 1.87141806e-01f, 3.86874229e-01f, -3.57183874e-01f, 3.79257500e-02f, -6.01288497e-01f, -5.28212115e-02f,
  1.93390369e-01f, -3.41280043e-01f, -3.54295820e-01f, 4.98028040e-01f, 3.46915573e-01f, 1.10799059e-01f, 4.33911532e-01f, 3.61936808e-01f, 2.43015438e-01f, 7.70009458e-02f,
  2.13871568e-01f, 8.03498447e-01f, -1.71083156e-02f, 5.31235397e-01f, 4.63618457e-01f, -9.45993066e-02f, 1.77058533e-01f, -1.30848780e-01f, 2.90747553e-01f, 2.59300828e-01f,
  2.85001248e-01f, -7.91688114e-02f, -1.55169070e-01f, -4.63970974e-02f, 1.75604410e-02f, 5.14654024e-03f, -5.92172798e-03f, 9.84080583e-02f, -1.68644056e-01f, -7.56335109e-02f,
  -1.46220937e-01f, 1.26023330e-02f, -1.18072955e-02f, 6.25630692e-02f, 6.08057268e-02f, -4.16006483e-02f, -1.50291696e-01f, 4.02545594e-02f, -1.45143107e-01f, 6.90188706e-02f,
  -2.17692405e-01f, 6.23986088e-02f, 3.40261310e-02f, -2.80786939e-02f, -2.95302957e-01f, -1.96740732e-01f, -1.47140354e-01f, -1.97009891e-01f, 7.31153414e-02f, -7.33323619e-02f,
  3.12043820e-02f, 8.53945911e-02f, 7.91661441e-02f, 5.21141030e-02f, -1.47429984e-02f, -4.95761819e-02f, 1.22321382e-01f, 1.24675762e-02f, -9.59506333e-02f, 1.49876261e-02f,
  -6.45427182e-02f, -7.66881322e-03f, 4.11307113e-03f, -5.03814258e-02f, 6.65378273e-02f, 1.50836961e-04f, 1.62181780e-02f, -3.90570499e-02f, -1.68968663e-01f, 1.94810685e-02f,
  1.77692585e-02f, 5.80618456e-02f, 9.62432660e-03f, 1.69974908e-01f, 1.27788723e-01f, -1.85388580e-01f, 7.01511651e-02f, -7.21917301e-03f, 9.37489122e-02f, 9.10387486e-02f,
  1.01446167e-01f, -2.47862190e-01f, -2.29726911e-01f, 3.49526443e-02f, -9.08788294e-03f, 1.80943266e-01f, 4.41508964e-02f, 9.08155832e-03f, -5.03502861e-02f, 4.12462698e-03f,
  -5.18633910e-02f, -1.33229680e-02f, 5.24854623e-02f, -5.52547630e-03f, 1.38230860e-01f, 6.71783788e-03f, -6.89253211e-02f, -2.04062209e-01f, -1.00957111e-01f, -3.18093300e-02f,
  -1.79224126e-02f, -9.06266868e-02f, -3.29920053e-02f, -9.22971070e-02f, -9.68173444e-02f, -1.22096568e-01f, 4.96701151e-02f, 6.92207646e-03f, 2.10305661e-01f, -9.22449529e-02f,
  5.45099825e-02f, 1.68645859e-01f, -5.22768557e-01f, -3.77665192e-01f, -6.24143369e-02f, 2.80216366e-01f, 2.57724617e-02f, 2.32087255e-01f, 1.42858490e-01f, 4.24412161e-01f,
  3.47139597e-01f, -2.11603388e-01f, 3.35884869e-01f, 9.83094200e-02f, -1.11981265e-01f, 2.75276184e-01f, -2.14133039e-01f, -1.18395559e-01f, 3.27752233e-02f, -2.41181001e-01f,
  -1.57365754e-01f, 2.88506985e-01f, -4.70303893e-01f, 2.38515660e-01f, -2.31190383e-01f, -2.73355961e-01f, -1.19722404e-01f, -5.11803292e-02f, -1.88409254e-01f, 1.11433722e-01f,
  -9.22448784e-02f, 1.67180359e-01f, -2.00230777e-02f, -6.95347413e-02f, -1.15095757e-01f, 4.89219762e-02f, -1.79941997e-01f, -9.27789211e-02f, -3.54017839e-02f, 8.78009722e-02f,
  1.65835004e-02f, 1.71695203e-01f, 2.63752062e-02f, 1.48309216e-01f, 9.80985835e-02f, -3.89702022e-02f, -1.36377886e-01f, -1.14887118e-01f, -3.13336477e-02f, 1.83074903e-02f,
  -2.10961506e-01f, -7.87936300e-02f, -1.38962537e-01f, -1.07154168e-01f, -9.14319158e-02f, 5.91305196e-02f, -6.77940845e-02f, -2.45395526e-02f, -8.49799514e-02f, 3.72220203e-02f,
  6.86507449e-02f, 1.88327935e-02f, 2.15816393e-01f, 1.49490103e-01f, 3.77659388e-02f, 5.69158904e-02f, -9.13053378e-02f, -9.25405025e-02f, 9.38941836e-02f, -1.46901878e-02f,
  -6.22495115e-02f, -2.06460315e-03f, 2.45170414e-01f, 3.46510857e-02f, -5.14744781e-02f, 1.14745259e-01f, 1.04749791e-01f, 4.68091518e-02f, -2.06468269e-01f, 1.15352431e-02f,
  7.76703358e-02f, 4.94229496e-02f, 1.72320589e-01f, -3.76135446e-02f, 1.81741193e-02f, 3.59443761e-02f, 9.24959183e-02f, -5.27622886e-02f, -3.73464637e-02f, -6.30059615e-02f,
  -6.29385859e-02f, 2.57330030e-01f, 9.76913646e-02f, 1.22865096e-01f, -8.62682238e-02f, 1.53112605e-01f, -5.61530776e-02f, 1.18511263e-02f, -2.69225016e-02f, 2.57893980e-01f,
  -2.94948909e-02f, 1.73476674e-02f, -3.99187654e-02f, 4.24318165e-02f, -1.83387771e-01f, 2.03438982e-01f, -3.55724432e-02f, -9.23532099e-02f, -1.28564825e-02f, -1.07486233e-01f,
  -1.15217879e-01f, 1.86244422e-03f, -4.83409837e-02f, 4.04399866e-03f, -3.72080952e-02f, -1.18221436e-02f, 5.11462167e-02f, -2.04363428e-02f, -9.06918347e-02f, -1.35440171e-01f,
  -3.45737308e-01f, -1.03828460e-01f, 1.71640962e-01f, -2.47071102e-01f, -3.06987971e-01f, 1.93402022e-01f, 2.24595964e-01f, -3.82250309e-01f, 1.20273612e-01f, -2.84571052e-01f,
  -2.51198113e-01f, -1.05423242e-01f, 4.32260334e-01f, -6.09495640e-02f, 5.80042362e-01f, 6.13276660e-01f, 1.95975810e-01f, -5.24999648e-02f, 9.50243175e-02f, -3.93303186e-01f,
  -1.33635432e-01f, -4.82125968e-01f, 1.81428418e-01f, -5.14992297e-01f, -3.61486852e-01f, -2.78514504e-01f, -5.78638129e-02f, -9.32679791e-03f, -3.04070592e-01f, 1.32477470e-02f,
  -2.24208795e-02f, -1.59100667e-01f, -5.99474050e-02f, 3.24455313e-02f, -1.25058442e-01f, -1.47749633e-02f, 7.55316764e-03f, 1.09890871e-01f, 2.36604977e-02f, 9.28116869e-03f,
  3.64817567e-02f, -3.33915576e-02f, -1.48397818e-01f, 8.72673374e-03f, -9.60776582e-02f, -2.00933926e-02f, -5.92071144e-03f, -1.65179558e-02f, -1.39607012e-01f, 7.89865628e-02f,
  1.15731150e-01f, 2.13280618e-02f, 7.48991147e-02f, -3.53804454e-02f, 2.37659365e-02f, 4.35665958e-02f, 1.04487956e-01f, -1.23921391e-02f, 3.25768739e-02f, 2.24124957e-02f,
  -7.18100416e-03f, 1.95200115e-01f, 2.65604164e-02f, -2.66206041e-02f, -1.46559790e-01f, -1.48161039e-01f, -3.04517578e-02f, -6.93960637e-02f, -6.28392324e-02f, -7.98176154e-02f,
  -4.08677831e-02f, -6.30214587e-02f, 9.90234688e-03f, -2.99929194e-02f, -1.86363414e-01f, -2.08015610e-02f, 1.72628611e-02f, -1.58593103e-01f, -7.27550164e-02f, 4.45494540e-02f,
  -3.64846438e-02f, 1.24702863e-01f, -4.55825925e-02f, 6.36180863e-04f, -9.20352619e-03f, -3.12511576e-03f, -3.63618252e-03f, 3.54054905e-02f, 1.26503900e-01f, -3.84959020e-02f,
  1.20551758e-01f, -2.06171945e-01f, -8.04545879e-02f, -1.18624195e-01f, 3.73352505e-02f, 5.03790267e-02f, 7.01773092e-02f, -1.08629532e-01f, -1.44633040e-01f, 2.25122203e-03f,
  -1.18628807e-01f, -8.65228921e-02f, 4.62821312e-02f, 1.62005536e-02f, -2.89374124e-03f, -6.36302903e-02f, -1.18353236e-02f, 7.75973946e-02f, -9.83732119e-02f, -1.87120233e-02f,
  -5.03934994e-02f, -7.19357878e-02f, -2.72930693e-02f, -1.53311506e-01f, -5.93654364e-02f, -5.94517551e-02f, 9.83385486e-04f, -3.36355567e-02f, -8.63913968e-02f, 9.19917375e-02f,
  -9.18688118e-01f, 8.18343282e-01f, 3.72616410e-01f, -2.11948991e-01f, -1.31841019e-01f, -6.32011611e-03f, 2.69889887e-02f, 1.30069271e-01f, -7.14894980e-02f, 3.86495799e-01f,
  -1.40852779e-01f, 1.97335795e-01f, 1.57752261e-01f, 2.78976381e-01f, -6.77125990e-01f, 7.14407414e-02f, -2.39050183e-02f, 2.90813185e-02f, -1.71597805e-02f, -1.04634546e-01f,
  -2.01121986e-01f, -1.74413860e-01f, 1.37141898e-01f, 1.25034407e-01f, 1.22836374e-01f, 4.64482270e-02f, -2.94061631e-01f, 7.61463419e-02f, 1.31402493e-01f, -2.10090238e-03f,
  -2.79822379e-01f, -1.15922794e-01f, 6.35806397e-02f, 2.96838842e-02f, -9.98155475e-02f, -6.85413182e-02f, -1.36137649e-01f, -7.64943063e-02f, -2.51885615e-02f, -2.75175720e-02f,
  3.73025239e-02f, -8.52426589e-02f, -4.41394970e-02f, 6.71936944e-02f, 1.11338031e-02f, 1.31540388e-01f, 1.34973824e-01f, 9.69116837e-02f, 6.21601902e-02f, 1.35228500e-01f,
  2.27078304e-01f, 8.75619203e-02f, 5.73721863e-02f, 5.00112399e-02f, -5.19040897e-02f, 3.28487456e-02f, 1.98131874e-02f, 6.70918822e-02f, 2.95375064e-02f, -6.53651506e-02f,
  6.00477494e-03f, -7.53327757e-02f, 1.68126896e-01f, -1.50955975e-01f, 4.12147604e-02f, -2.49162223e-02f, 3.44719663e-02f, -1.02910131e-01f, -4.76160645e-03f, -4.97614369e-02f,
  -1.36043191e-01f, 8.55049193e-02f, -2.41134781e-03f, -6.73241094e-02f, -1.23258429e-02f, -2.88674012e-02f, 5.11544906e-02f, -1.54785970e-02f, -1.64273474e-02f, 3.41498433e-03f,
  -5.33529110e-02f, -2.20211912e-02f, 4.23613265e-02f, -6.74210638e-02f, -1.10510953e-01f, -4.86467965e-02f, -9.20431688e-03f, 1.57912746e-01f, -2.36796811e-02f, -1.72761962e-01f,
  -6.26131058e-01f, -5.22084653e-01f, -4.82156500e-02f, -1.16763376e-01f, -4.57733236e-02f, -4.71340418e-02f, -4.87981811e-02f, 5.74441776e-02f, -1.24401756e-01f, -3.45387533e-02f,
  9.67605226e-03f, 1.10262617e-01f, -1.54741138e-01f, -9.37509239e-02f, -2.32133660e-02f, -1.31416515e-01f, -1.66272283e-01f, -9.18421075e-02f, -2.12536141e-01f, -7.69468471e-02f,
  3.94964172e-03f, -1.12452872e-01f, -1.13067506e-02f, -4.60839793e-02f, -2.44997274e-02f, -1.00523047e-01f, -1.13837659e-01f, 9.91522297e-02f, -1.57934308e-01f, 1.07834436e-01f,
  3.68871719e-01f, -3.73628557e-01f, 1.65637389e-01f, 7.86307082e-02f, 3.53521675e-01f, -3.70953560e-01f, 1.15601853e-01f, 1.15347207e-01f, 4.78772014e-01f, -3.35028321e-01f,
  1.82911325e-02f, -1.05437681e-01f, 1.82487175e-01f, -2.38174304e-01f, 5.33525692e-03f, 2.17959005e-02f, -2.73184031e-01f, -3.51041555e-01f, 2.26536021e-01f, -1.06389761e-01f,
  -4.83134342e-03f, -2.95330077e-01f, -4.00308752e-03f, -3.16277057e-01f, -2.63254885e-02f, -2.38575339e-02f, -1.83713347e-01f, 8.68336633e-02f, -3.76928061e-01f, 1.54308407e-02f,
  -2.19058096e-01f, 9.96411741e-02f, 1.37567699e-01f, -1.00545257e-01f, -7.72271976e-02f, -5.74111938e-02f, 1.25335697e-02f, 1.27710938e-01f, 8.58668461e-02f, 8.96896329e-03f,
  3.23460391e-03f, -3.02734096e-02f, -1.27648517e-01f, -1.44509887e-02f, 2.24321149e-02f, -4.33802558e-03f, 1.27525225e-01f, 9.02014971e-03f, 7.57972896e-02f, 7.69039467e-02f,
  1.09034128e-01f, -2.38749348e-02f, 6.61321059e-02f, -1.27504095e-01f, 1.48227200e-01f, 9.97053385e-02f, 2.95002572e-02f, -1.03663184e-01f, -1.07578702e-01f, -8.23932216e-02f,
  1.37199340e-02f, 1.48413712e-02f, 4.27943766e-02f, 1.54339047e-02f, 7.07202852e-02f, 1.21227175e-01f, -1.21721914e-02f, -8.98498949e-03f, -5.84750473e-02f, -4.11180221e-02f,
  -1.01031112e-02f, 1.13133922e-01f, 3.64036448e-02f, -3.51089127e-02f, -5.05513661e-02f, 6.49805516e-02f, 1.93629775e-03f, -5.66567071e-02f, 9.06241089e-02f, -1.62472054e-02f,
  -2.53113396e-02f, -5.49536087e-02f, 5.37725799e-02f, 1.34755895e-01f, -7.70702213e-02f, 2.81500518e-02f, -3.34885903e-02f, 8.40812549e-02f, 1.14602812e-01f, -9.83238816e-02f,
  -6.84952736e-01f, -6.46274507e-01f, -3.07052173e-02f, 5.66877685e-02f, -1.27631202e-01f, -1.70820042e-01f, -1.87587775e-02f, -4.97737341e-02f, -1.64897934e-01f, 9.79425237e-02f,
  -1.29253745e-01f, -9.90321860e-02f, -6.55966103e-02f, 7.09775835e-02f, -2.12198213e-01f, 9.89996940e-02f, -1.04212649e-01f, -2.12718353e-01f, -2.30556369e-01f, -7.82248154e-02f,
  -5.97271919e-02f, -3.48385647e-02f, 1.74712129e-02f, 5.03873043e-02f, -8.97770002e-02f, 9.94651485e-03f, -9.62575749e-02f, -6.77670762e-02f, -8.14826787e-02f, -9.04826820e-02f,
  -7.73289263e-01f, 3.64914179e-01f, 5.53189993e-01f, 3.05637360e-01f, -1.05349161e-01f, -3.08299899e-01f, -2.85812438e-01f, -8.60568210e-02f, 3.73674445e-02f, -5.03141284e-01f,
  -2.88372546e-01f, -4.60693836e-02f, -1.54600758e-03f, 1.25064701e-01f, 4.87189323e-01f, 3.59014630e-01f, 2.59225875e-01f, 8.80073160e-02f, 5.88270724e-01f, 2.52667218e-01f,
  4.48540747e-01f, -1.97146852e-02f, 4.91914481e-01f, 1.92629382e-01f, 1.72090322e-01f, 3.29174340e-01f, 4.03305113e-01f, 5.19386351e-01f, 2.14768410e-01f, 2.15946674e-01f,
  -1.96504876e-01f, -1.13668904e-01f, -9.59555730e-02f, 2.16259081e-02f, -5.28258234e-02f, -1.37374997e-01f, 3.17236818e-02f, -1.13011159e-01f, 7.89655969e-02f, 8.07321351e-03f,
  -9.46213305e-02f, -3.11924890e-02f, 3.37709263e-02f, 1.13673240e-01f, -1.10797748e-01f, 7.67995045e-02f, 8.47601444e-02f, -7.08379745e-02f, -1.00167999e-02f, -6.91060275e-02f,
  1.10030256e-01f, -1.58050787e-02f, -4.82543670e-02f, 9.27818120e-02f, 1.51218697e-01f, 1.16071686e-01f, 4.31230776e-02f, 9.26842820e-03f, 4.22061458e-02f, 6.20762818e-02f,
  -1.57320872e-01f, 9.31187347e-02f, -8.49262029e-02f, 8.45621992e-03f, -9.64174885e-03f, 3.15482318e-02f, 1.14771895e-01f, -9.19001773e-02f, -1.23279067e-02f, -3.55853774e-02f,
  -7.31243342e-02f, 6.31209754e-04f, -1.43466927e-02f, -1.73364021e-02f, 5.81860133e-02f, -1.72015801e-01f, -2.71961559e-02f, 8.01546276e-02f, 8.71685594e-02f, -4.94853444e-02f,
  -5.28258644e-02f, 2.49792561e-02f, 2.27723166e-01f, -6.10604100e-02f, -2.05778241e-01f, -1.64811574e-02f, 9.01872218e-02f, -2.19794875e-03f, 3.44189368e-02f, 2.30032086e-01f,
  1.85965508e-01f, 5.85997880e-01f, 1.03063844e-01f, -1.38856292e-01f, 1.25127971e-01f, -1.76648982e-02f, 1.36827558e-01f, 5.90297300e-03f, 1.89325258e-01f, 4.58502769e-02f,
  -6.05019219e-02f, 8.34564865e-03f, -5.36088161e-02f, -9.33996066e-02f, 5.69930524e-02f, 8.28587562e-02f, 3.21724303e-02f, 6.03792630e-02f, 3.96877974e-02f, 1.07628830e-01f,
  8.29423815e-02f, -9.38671976e-02f, 1.00694545e-01f, 2.50877365e-02f, -2.13442534e-01f, -3.78725231e-02f, -9.52697173e-02f, -5.93408719e-02f, 1.77776530e-01f, 1.50811180e-01f,
  -2.75411546e-01f, 3.46246660e-01f, 2.08863437e-01f, -4.98904079e-01f, 2.88705409e-01f, 6.97060883e-01f, -1.73038289e-01f, 2.65040457e-01f, -5.40656567e-01f, 3.92365187e-01f,
  8.83307904e-02f, -4.46535617e-01f, -2.55773276e-01f, -4.88882065e-02f, -5.39395630e-01f, -2.79201508e-01f, 8.13537538e-02f, -7.07794772e-03f, -3.37577492e-01f, 1.36346251e-01f,
  -2.36033127e-01f, -2.18979239e-01f, -1.75771251e-01f, -4.49556224e-02f, 2.15111330e-01f, 7.71811306e-02f, 2.20606085e-02f, -1.96900681e-01f, 2.47122005e-01f, -1.52373552e-01f,
  7.73226544e-02f, -2.45395422e-01f, 2.01126412e-01f, 8.03734437e-02f, 2.48361737e-01f, 2.10313797e-01f, 1.09667957e-01f, -2.17163369e-01f, -2.77782619e-01f, -1.32182166e-01f,
  5.74301518e-02f, -1.76187217e-01f, -4.98335734e-02f, -2.39130273e-01f, -2.96922475e-02f, 1.41486406e-01f, -2.85995509e-02f, 2.02709332e-01f, 7.93036725e-03f, 2.48439498e-02f,
  -5.44931786e-03f, 1.75546274e-01f, 8.45344439e-02f, -3.94671820e-02f, -7.06550702e-02f, -3.38891707e-02f, 1.19102269e-01f, 4.38677110e-02f, 1.50290757e-01f, -4.46025766e-02f,
  -4.42015156e-02f, 1.60811707e-01f, 9.46692154e-02f, 1.10180929e-01f, -2.01271743e-01f, 2.44983919e-02f, -9.21990648e-02f, 5.54083511e-02f, -2.09195867e-01f, 1.86518710e-02f,
  -2.61785798e-02f, -8.49896520e-02f, -1.93149284e-01f, -1.89749710e-02f, 1.52883993e-03f, 1.15891872e-02f, -2.05575656e-02f, -4.78738993e-02f, -7.95777142e-02f, 9.74759459e-02f,
  -1.40287250e-01f, -6.63953200e-02f, -6.51061460e-02f, 3.99846993e-02f, 1.32199764e-01f, -2.15689421e-01f, -4.75682691e-02f, 5.78277837e-03f, 7.44417757e-02f, -1.02422079e-02f,
  6.83768466e-02f, -8.78010467e-02f, 5.27846143e-02f, -3.29227336e-02f, 8.58064219e-02f, 1.27400741e-01f, 8.33989382e-02f, 1.88549154e-03f, 2.36254800e-02f, 3.31335254e-02f,
  9.49471295e-02f, 9.14562568e-02f, 3.22680593e-01f, -1.15158282e-01f, -8.66000503e-02f, 1.80171713e-01f, -6.40044594e-03f, -1.20171957e-01f, 6.81908452e-04f, 1.49518758e-01f,
  2.13667065e-01f, -2.01656483e-03f, -7.50778019e-02f, 1.89731531e-02f, 4.52114195e-02f, 1.10141061e-01f, 8.53833705e-02f, -4.80320379e-02f, -5.20489030e-02f, -5.69952140e-03f,
  3.76494676e-01f, 3.14342156e-02f, -2.79839814e-01f, 1.32948086e-01f, 3.27666551e-02f, 5.55510938e-01f, 6.33100986e-01f, 7.44510666e-02f, 3.15122813e-01f, 1.33560210e-01f,
  -1.21920727e-01f, 2.27539524e-01f, -7.05443248e-02f, 1.90193206e-01f, 3.63994151e-01f, 8.33522677e-02f, 3.74299377e-01f, 1.95805997e-01f, 6.07935824e-02f, 1.46454453e-01f,
  2.00662702e-01f, 3.25979799e-01f, -3.48604769e-01f, -1.04243802e-02f, -5.74519560e-02f, -2.77414441e-01f, -3.83983642e-01f, -2.64093250e-01f, -1.35945618e-01f, 1.58327222e-01f,
  -2.80239503e-03f, -4.52097282e-02f, -1.19786881e-01f, 3.33937481e-02f, -4.26036045e-02f, 7.11787641e-02f, -8.24257657e-02f, -4.24832888e-02f, -3.89677100e-02f, 4.68724594e-02f,
  1.32229269e-01f, 7.84837604e-02f, 2.08639026e-01f, 2.80235503e-02f, 4.44469564e-02f, -5.73064983e-02f, -4.28372808e-02f, -8.51898864e-02f, -3.73317935e-02f, -3.23716700e-02f,
  -6.30117878e-02f, -1.92049786e-01f, -3.16081680e-02f, 6.92714751e-02f, -5.92962950e-02f, 1.37537271e-01f, 9.18985903e-02f, -1.45064920e-01f, 2.16225237e-02f, 1.38781548e-01f,
  3.78888771e-02f, 1.51840791e-01f, 5.67649603e-02f, -9.09191743e-02f, 7.10200816e-02f, -1.52035326e-01f, 2.41689850e-02f, -1.09786615e-01f, 6.34045601e-02f, -1.92982368e-02f,
  9.79558751e-03f, -6.37903288e-02f, -1.15366401e-02f, 7.52808675e-02f, 1.05904080e-01f, 1.06615193e-01f, 9.60481241e-02f, -5.87449074e-02f, -4.66581658e-02f, -2.17795745e-01f,
  -1.41496420e-01f, 8.01257268e-02f, 4.55751233e-02f, -9.11745504e-02f, -5.69529017e-04f, -6.58726767e-02f, -1.87508576e-02f, -9.78156626e-02f, -9.06794667e-02f, 6.64435700e-02f,
  7.28662536e-02f, 3.38229895e-01f, 2.21932065e-02f, 7.51597062e-02f, -1.30426228e-01f, 6.28300905e-02f, -4.67851060e-03f, 1.18468575e-01f, 8.70053247e-02f, 2.12990642e-01f,
  -1.14342188e-02f, -6.27049361e-04f, -8.02911818e-02f, -9.96950120e-02f, -1.38232082e-01f, 1.30517930e-01f, 1.71124443e-01f, -1.05857486e-02f, -2.06213593e-02f, -2.08877083e-02f,
  -1.22247614e-01f, 1.28827825e-01f, 1.44958496e-02f, 2.16988653e-01f, 1.01288028e-01f, -1.13038994e-01f, 1.17212974e-01f, -1.22522213e-01f, -4.95337695e-02f, -3.61006483e-02f,
  1.22044027e-01f, -5.10769367e-01f, 3.56518149e-01f, 9.00551021e-01f, 5.99790439e-02f, -6.12013936e-01f, -2.77252167e-01f, 2.77516812e-01f, 2.19227731e-01f, -5.75279057e-01f,
  1.26784116e-01f, -2.65135705e-01f, -4.07520920e-01f, 4.39343125e-01f, 4.54552978e-01f, -2.09086105e-01f, 2.38291830e-01f, -2.05328658e-01f, 1.67546973e-01f, 1.15189284e-01f,
  4.46319461e-01f, 2.88006067e-01f, 3.49702030e-01f, 1.87610403e-01f, -3.40769328e-02f, 2.29978785e-01f, 2.04562381e-01f, -8.38093609e-02f, 2.12868273e-01f, -1.08247012e-01f,
  -1.88125059e-01f, 3.51608545e-01f, 2.29400456e-01f, -1.20274484e-01f, 1.22969627e-01f, -1.30012617e-01f, -3.51233706e-02f, -8.47985297e-02f, 1.95350394e-01f, -5.46912067e-02f,
  -1.63559049e-01f, 2.77177263e-02f, 1.33656070e-01f, 1.10769093e-01f, -2.00857893e-02f, 1.05000146e-01f, -5.69094568e-02f, -8.61305892e-02f, -1.66059993e-02f, -8.05234239e-02f,
  -3.41097638e-02f, -2.92774271e-02f, 2.25611150e-01f, -5.79043180e-02f, 9.64132398e-02f, 5.83032593e-02f, -1.75758619e-02f, -7.50114471e-02f, -1.05402738e-01f, 1.48593351e-01f,
  -9.12834108e-02f, 8.23121890e-02f, -1.30332801e-02f, 6.61010146e-02f, 6.70052040e-03f, 1.29322678e-01f, -1.18867956e-01f, -4.07015346e-02f, 2.60778721e-02f, -1.11234970e-02f,
  -2.21014544e-02f, 1.45317838e-01f, 6.46352395e-02f, 1.35319559e-02f, 4.56162840e-02f, 1.25644347e-02f, 3.73801962e-02f, -4.99155000e-02f, 4.03084643e-02f, 1.37884691e-01f,
  8.86751115e-02f, -5.88593148e-02f, -8.35405737e-02f, -7.60397762e-02f, -9.36119556e-02f, 8.06946214e-03f, 7.26941675e-02f, -5.28096631e-02f, -2.82549392e-03f, 7.97009654e-03f,
  -4.24945891e-01f, 7.94542581e-02f, 6.73858151e-02f, 5.23567460e-02f, -1.53116230e-02f, -1.02179192e-01f, -3.46778370e-02f, -2.77449116e-02f, -9.51394215e-02f, 9.10977721e-02f,
  2.59947442e-02f, -4.41130064e-02f, -4.48509753e-02f, -2.00281423e-02f, 1.03668697e-01f, -1.31271452e-01f, -1.23609165e-02f, 1.11906300e-03f, 1.22607879e-01f, 1.07746355e-01f,
  4.53982018e-02f, -1.81884870e-01f, 1.53712463e-02f, 9.11593288e-02f, -1.14727886e-02f, -8.96784887e-02f, -1.40568502e-02f, 6.92874705e-03f, -6.66688532e-02f, 1.59800351e-02f,
  5.07233500e-01f, -1.56750325e-02f, 2.75518745e-01f, 3.64794761e-01f, 1.90492988e-01f, -1.20531015e-01f, -1.99516445e-01f, 3.74023557e-01f, -6.89207092e-02f, -2.14144722e-01f,
  -2.63633251e-01f, 1.80569470e-01f, -4.51405674e-01f, 1.29759222e-01f, -4.47524369e-01f, -5.30068040e-01f, 1.95853338e-01f, 2.67430744e-03f, 3.12055480e-02f, 2.89761394e-01f,
  3.02926421e-01f, 1.15086483e-02f, 2.42641270e-01f, 1.84704870e-01f, 3.79436612e-01f, 5.44121563e-01f, 2.06078980e-02f, -5.83879417e-04f, 3.00112724e-01f, -1.85665950e-01f,
  -1.74705777e-03f, -3.03432643e-02f, 1.34700745e-01f, -4.46322486e-02f, 5.82435913e-02f, 1.24019422e-01f, 7.45195746e-02f, -1.94415554e-01f, -4.56581637e-02f, 9.42384526e-02f,
  3.81441601e-02f, 2.40560800e-01f, -1.85933560e-02f, -2.05116868e-01f, 1.79858238e-01f, 1.03643410e-01f, 1.15508348e-01f, 1.62708223e-01f, 1.01924330e-01f, 1.96953818e-01f,
  9.98591557e-02f, 1.24412782e-01f, 3.05935927e-02f, 1.15739992e-02f, 3.65737751e-02f, 1.77570134e-01f, -3.44009586e-02f, 1.01039372e-01f, 3.93038280e-02f, 2.01800421e-01f,
  -5.84265515e-02f, -7.92621300e-02f, 1.71596408e-02f, 1.16180725e-01f, -6.96632117e-02f, 1.01183355e-01f, -7.00367838e-02f, -8.53026062e-02f, -8.51227622e-03f, -4.51326258e-02f,
  1.22250654e-01f, 5.65287583e-02f, -9.90283638e-02f, 1.47596747e-02f, 9.43130478e-02f, 1.01627462e-01f, 9.85418335e-02f, -4.62658936e-03f, 1.16423056e-01f, -1.59205496e-02f,
  -1.86230242e-01f, 1.19059935e-01f, -3.20385620e-02f, 1.11733288e-01f, -5.39275706e-02f, 3.94475535e-02f, -2.22147144e-02f, -4.39730287e-03f, 1.40292704e-01f, -5.05274348e-02f,
  -2.26049766e-01f, -2.42480174e-01f, 1.69499498e-02f, -4.86279987e-02f, -1.33752331e-01f, 4.02913801e-02f, -1.18399218e-01f, 5.69024570e-02f, -3.20121497e-02f, -1.13386810e-01f,
  1.23644240e-01f, 1.49259225e-01f, -8.18988681e-02f, 3.78466658e-02f, -1.21500045e-01f, -5.18131591e-02f, 1.04399592e-01f, -7.58815231e-03f, 1.05121927e-02f, 4.79129925e-02f,
  7.81629309e-02f, 6.18452765e-03f, 1.03296071e-01f, 8.23820829e-02f, 4.56623286e-02f, -7.43839443e-02f, -2.37980336e-02f, -4.30521965e-02f, -1.04061671e-01f, -7.71490633e-02f,
  8.76217008e-01f, -4.94392425e-01f, -2.36635536e-01f, 3.75541806e-01f, 2.96608865e-01f, 5.51967144e-01f, 7.25454390e-01f, -2.77157307e-01f, 3.06849238e-02f, -5.76319218e-01f,
  7.24386796e-02f, 3.36651243e-02f, -6.91832751e-02f, 3.55633706e-01f, 7.79241204e-01f, -1.24591008e-01f, 3.11869800e-01f, 3.90030384e-01f, -1.95482448e-01f, 1.62940755e-01f,
  1.56509697e-01f, 3.48807752e-01f, -1.80197984e-01f, -6.02966070e-01f, 4.40480649e-01f, -3.13779175e-01f, -2.28080332e-01f, -1.65582597e-01f, -1.91195413e-01f, 2.95651704e-01f,
  5.28455414e-02f, 5.50027117e-02f, 8.85295868e-02f, -1.24116905e-01f, -6.23427741e-02f, 1.14800185e-01f, -9.48559493e-03f, 1.49851680e-01f, 4.08347696e-02f, -5.67486845e-02f,
  9.60622430e-02f, 4.00948757e-03f, 5.05823195e-02f, 3.71840149e-02f, 2.45793566e-01f, 5.13887517e-02f, -4.45482321e-02f, -4.19292487e-02f, -2.20433414e-01f, -1.16420826e-02f,
  1.28821760e-01f, -3.50226015e-02f, 8.52614939e-02f, -2.01151133e-01f, -2.75086742e-02f, 1.15719084e-02f, -7.84469545e-02f, 3.90193313e-02f, 2.88266991e-03f, 1.48615256e-01f,
  -4.42536250e-02f, 2.86374148e-02f, 9.07380879e-02f, -5.75280897e-02f, 9.18685719e-02f, -3.11808418e-02f, 1.21468127e-01f, -9.18833017e-02f, -4.35107052e-02f, 3.37065943e-02f,
  2.13916432e-02f, 1.11113869e-01f, 9.35109258e-02f, -4.15306501e-02f, 1.45945810e-02f, -5.27536310e-02f, 3.18830684e-02f, -2.19262950e-02f, 6.06004596e-02f, 2.53717601e-02f,
  -3.20122950e-02f, -7.11902510e-03f, 2.93831229e-02f, -9.73467976e-02f, -4.36781831e-02f, -9.25226808e-02f, -1.00972153e-01f, 1.07294366e-01f, -1.06375679e-01f, 8.19671303e-02f,
  -1.07329160e-01f, -4.47638750e-01f, -2.08093803e-02f, -1.41335353e-01f, -5.02174385e-02f, -6.85650334e-02f, 4.10825461e-02f, -4.46742885e-02f, -1.53566122e-01f, 3.44251357e-02f,
  -8.03214833e-02f, 4.84076701e-02f, -2.74110166e-03f, 1.70643292e-02f, -8.41582119e-02f, 1.91463623e-02f, -4.10283171e-02f, -9.86639410e-02f, 2.59234309e-02f, -1.26128435e-01f,
  2.58745197e-02f, 3.71057987e-02f, 1.05923913e-01f, 4.66225222e-02f, -1.55752704e-01f, 6.59621134e-02f, -7.47305080e-02f, -8.79687145e-02f, -5.87781854e-02f, -6.74960241e-02f,
  -7.39439547e-01f, -3.58589888e-01f, 2.64790326e-01f, -2.37157822e-01f, -1.58270806e-01f, 2.88159132e-01f, 6.33180499e-01f, -3.34815025e-01f, -5.01064658e-01f, -1.63573362e-02f,
  3.48571718e-01f, 7.09741488e-02f, 4.03172314e-01f, 3.47498029e-01f, 5.23856342e-01f, 3.57832909e-01f, 2.32220739e-01f, 2.01766506e-01f, -1.14639126e-01f, -1.85588211e-01f,
  -6.23322511e-03f, 5.96602410e-02f, 5.34074843e-01f, -4.18415755e-01f, 6.27282783e-02f, -4.53046203e-01f, 8.17089602e-02f, 2.78099298e-01f, 7.02928677e-02f, 1.72508657e-01f,
  -2.26345032e-01f, -4.16643351e-01f, 5.42157795e-03f, -4.99888249e-02f, -1.85112115e-02f, 1.62644626e-03f, 1.16101190e-01f, 1.42344639e-01f, -9.72270593e-02f, -1.23931896e-02f,
  -4.79004905e-02f, -7.76759163e-02f, -2.41882131e-01f, 2.13723201e-02f, -2.55747914e-01f, -1.06897220e-01f, 1.77602340e-02f, 7.93555453e-02f, -4.35923338e-02f, 1.34651795e-01f,
  1.98970899e-01f, 2.10388564e-02f, 6.97090756e-03f, 7.53459781e-02f, 9.81821492e-02f, -9.00306553e-02f, 6.56163022e-02f, 1.81937426e-01f, -2.35927291e-02f, -8.00000876e-02f,
  -3.83011624e-02f, 1.32708845e-03f, -1.22023141e-02f, -7.66910166e-02f, -9.70892794e-03f, -4.31433320e-02f, 2.36510206e-03f, 5.55584617e-02f, 4.92882244e-02f, 4.87938523e-02f,
  -1.02164112e-01f, 1.58704148e-04f, -3.28734256e-02f, 6.47628382e-02f, 1.66852642e-02f, -8.83563682e-02f, 1.06617264e-01f, -2.80761905e-02f, -2.89800726e-02f, 4.07828763e-02f,
  8.19849968e-03f, -7.13603348e-02f, 3.53811346e-02f, 8.96316469e-02f, -4.71535400e-02f, 1.65429160e-01f, -8.84265378e-02f, -2.95598041e-02f, 2.80615017e-02f, 1.02180190e-01f,
  -5.05724609e-01f, -5.57794690e-01f, -1.36605725e-01f, -1.03511922e-01f, 1.15723172e-02f, 6.03784760e-03f, -6.98458999e-02f, -9.89191085e-02f, 1.02573950e-02f, 2.26280242e-02f,
  -6.98509589e-02f, 1.26035383e-03f, -1.51227623e-01f, 2.90616937e-02f, 6.53793395e-04f, 1.12245725e-02f, -8.42760280e-02f, -2.80786194e-02f, 7.80013725e-02f, -1.34988055e-01f,
  -1.18525796e-01f, -9.26123634e-02f, 5.95660321e-02f, -6.89245984e-02f, -2.96066478e-02f, 5.38763255e-02f, -2.79002726e-01f, -6.57815263e-02f, 1.20981082e-01f, 5.85787781e-02f,
  -1.89347908e-01f, -8.09807658e-01f, -3.95045161e-01f, 2.10958421e-02f, 4.52348083e-01f, 1.50027186e-01f, 1.53085783e-01f, -2.72308677e-01f, -3.62805724e-01f, -4.16652054e-01f,
  -5.79144210e-02f, -3.27750295e-01f, -4.09369349e-01f, -4.78913158e-01f, 1.82483345e-01f, -5.70254505e-01f, -1.67781532e-01f, -6.44817948e-02f, -3.75605285e-01f, -9.17962193e-02f,
  -5.87241948e-02f, -4.51346375e-02f, -9.26245749e-02f, 1.03780180e-01f, 1.75542802e-01f, 3.31011623e-01f, 5.20367265e-01f, 2.36871228e-01f, 3.58766973e-01f, 1.32363960e-01f,
  -1.29207820e-01f, -3.64317447e-01f, -4.19282168e-02f, -2.47237086e-02f, 1.24870703e-01f, 2.09611177e-01f, 1.67351425e-01f, 2.70761121e-02f, 1.97292492e-01f, -1.65778726e-01f,
  6.68287203e-02f, 7.65424892e-02f, -1.54850364e-01f, 1.41564701e-02f, 5.11664664e-03f, -3.44797596e-02f, -4.37969118e-02f, 4.58606817e-02f, -1.38920555e-02f, -1.79828301e-01f,
  -1.87626854e-01f, -9.95220914e-02f, 2.09508277e-02f, 4.67778137e-03f, -4.32815822e-03f, 1.08581604e-02f, 9.76486504e-02f, 1.68520689e-01f, -6.55195937e-02f, 2.57489868e-02f,
  -8.68330244e-03f, 9.59551521e-03f, -6.42333403e-02f, -2.03804567e-01f, -2.12827604e-02f, 8.51083398e-02f, -5.47803864e-02f, -7.42021576e-02f, -4.21297923e-02f, 9.85517539e-03f,
  9.03952122e-02f, -2.25685537e-02f, -7.54879462e-03f, 1.52568489e-01f, -1.50188459e-02f, 2.75261346e-02f, 1.02879182e-01f, 5.75429462e-02f, 9.29128528e-02f, 3.74693498e-02f,
  -4.88346256e-02f, 7.86114857e-02f, 1.38683766e-01f, 8.60011056e-02f, -1.72044739e-01f, -6.80242479e-03f, 5.15643619e-02f, -4.18883748e-02f, -7.52938772e-03f, 2.45437883e-02f,
  1.04626656e-01f, -2.10779861e-01f, -1.25765190e-01f, 9.39361304e-02f, -9.26727578e-02f, -4.17222157e-02f, -1.61024183e-01f, -1.55828863e-01f, 1.41847767e-02f, -9.68945175e-02f,
  2.45465159e-01f, 1.80238038e-01f, 7.07484931e-02f, -6.23589801e-03f, 1.42201588e-01f, 6.61995411e-02f, 8.75603929e-02f, 2.77725518e-01f, 8.32798928e-02f, 8.48772191e-03f,
  4.73032333e-02f, 1.59450203e-01f, -6.14955742e-03f, 3.65907662e-02f, 8.60780925e-02f, 1.30279943e-01f, 1.25488251e-01f, 3.84154655e-02f, -8.71847197e-03f, 5.43037169e-02f,
  -3.51550788e-01f, 8.55945572e-02f, 4.62710410e-01f, -6.67074919e-01f, 2.76002973e-01f, 4.80025187e-02f, -7.74867535e-02f, -2.45731220e-01f, -4.60233599e-01f, -4.28869843e-01f,
  -3.34408432e-01f, 3.91584396e-01f, 4.09723252e-01f, -4.15172607e-01f, 1.94352180e-01f, 1.34367704e-01f, -6.77557111e-01f, -3.47151101e-01f, 6.61633387e-02f, -2.31970772e-01f,
  -1.47438630e-01f, -3.48367870e-01f, 2.02205822e-01f, -1.74642131e-01f, -1.76572010e-01f, -6.01763986e-02f, -1.10394448e-01f, 4.23659265e-01f, -2.45867461e-01f, 2.16842607e-01f,
  -2.12124258e-01f, -2.60122865e-01f, 8.73215273e-02f, -5.11046909e-02f, -1.57658190e-01f, 7.02772364e-02f, 4.57731895e-02f, 2.57616162e-01f, -6.02353644e-03f, 5.70847467e-02f,
  1.97045758e-01f, 8.54722932e-02f, -1.67435959e-01f, 1.65412247e-01f, -1.23803541e-01f, -8.91419202e-02f, 2.53861044e-02f, -1.61799081e-02f, 6.19154386e-02f, 8.33997354e-02f,
  9.58838314e-02f, 4.23688181e-02f, -2.70855427e-02f, -1.80827007e-02f, 2.56227907e-02f, -7.85868764e-02f, -1.22224532e-01f, 2.21903801e-01f, -1.02545008e-01f, -1.82221591e-01f,
  1.11966483e-01f, 6.70257956e-02f, 1.60379663e-01f, 7.69855594e-03f, 7.18223900e-02f, -3.14993076e-02f, 1.50247011e-02f, -3.21158990e-02f, 2.00232808e-02f, 8.04684609e-02f,
  -4.77911867e-02f, -7.99435563e-03f, -1.40232131e-01f, -1.93402693e-01f, -4.47424203e-02f, -1.18212096e-01f, 1.70536116e-01f, -1.23831313e-02f, -5.52598536e-02f, -5.98936751e-02f,
  -2.45948844e-02f, -7.47397020e-02f, -4.39463779e-02f, 2.03544814e-02f, -3.16737848e-03f, 1.29243508e-01f, -1.00911014e-01f, 1.23088352e-01f, -1.00855745e-01f, 1.70649409e-01f,
  -3.86550844e-01f, -5.23094475e-01f, 1.67348579e-01f, -4.43778858e-02f, 9.90818292e-02f, -5.05016744e-02f, -3.53932232e-02f, -1.47186890e-01f, -1.45698741e-01f, -8.42405334e-02f,
  -1.98181883e-01f, -7.45100752e-02f, -4.19682860e-02f, -3.07077970e-02f, 5.17863035e-02f, -1.04634888e-01f, -2.47231983e-02f, -3.78232859e-02f, -1.08005621e-01f, -4.12488990e-02f,
  -1.07916109e-01f, 2.53769159e-02f, 6.36387095e-02f, -9.07385647e-02f, -1.82083771e-01f, -3.20608914e-02f, -8.35397020e-02f, 3.01749185e-02f, 5.76202422e-02f, -8.21174309e-02f,
  -2.40501136e-01f, -4.51188952e-01f, -1.65533021e-01f, 6.93989545e-03f, 4.87995684e-01f, -1.76655844e-01f, -6.05044782e-01f, 1.58104319e-02f, 1.51131481e-01f, -5.74224651e-01f,
  -1.48495585e-01f, -3.02256733e-01f, -6.16338551e-01f, 1.03368564e-02f, 2.70396978e-01f, -1.01557083e-01f, 8.40523541e-02f, -1.31413460e-01f, 2.26026207e-01f, -1.14444420e-01f,
  3.49445820e-01f, 7.76241869e-02f, -4.49445099e-02f, 3.50226343e-01f, -1.13060385e-01f, -1.03269815e-02f, -1.05264038e-01f, -7.53251314e-02f, -2.04178151e-02f, 1.91326141e-01f,
  -2.12891012e-01f, -1.35406330e-01f, -2.27967590e-01f, -4.20686975e-03f, -6.67641833e-02f, -6.19224720e-02f, -1.19644515e-01f, -5.49752600e-02f, 5.66670261e-02f, 1.21388836e-02f,
  -1.82217658e-01f, 2.14667916e-01f, 1.58210769e-01f, 9.04262364e-02f, 7.14067444e-02f, 1.77434489e-01f, 1.79811120e-01f, -2.10303441e-02f, -1.08009176e-02f, 3.15651968e-02f,
  1.20467767e-02f, 7.22791180e-02f, -4.31462117e-02f, -8.93078744e-04f, 6.52865395e-02f, 3.28075103e-02f, 9.12477523e-02f, -1.31140396e-01f, -1.67671423e-02f, 6.11209273e-02f,
  1.04528405e-01f, -1.55447140e-01f, -9.07935277e-02f, -8.65680277e-02f, -6.11754209e-02f, 9.31583643e-02f, 6.37424178e-03f, 3.79271470e-02f, -4.01140843e-03f, -5.78099815e-03f,
  1.00793645e-01f, -3.80370915e-02f, 1.04804493e-01f, -2.14678608e-02f, -2.48644501e-02f, 1.95184611e-02f, -1.08988032e-01f, 2.56487541e-02f, 3.29653248e-02f, 6.36149049e-02f,
  -4.39750925e-02f, 8.00907426e-03f, -1.07887290e-01f, 1.24874741e-01f, -9.29622948e-02f, -2.53252592e-02f, -7.31755942e-02f, 1.70181282e-02f, -8.33039507e-02f, -4.66911606e-02f,
  -8.45429003e-01f, -5.87301731e-01f, -1.33167088e-01f, 2.16711238e-02f, 2.10388843e-03f, 2.95356028e-02f, 1.82090521e-01f, 1.56024948e-01f, -2.15914026e-01f, -2.20737848e-02f,
  1.06369741e-02f, 5.47755733e-02f, -3.46011333e-02f, 1.05740562e-01f, 2.35267226e-02f, 3.25129889e-02f, -1.06429569e-01f, -1.17971204e-01f, -1.11229643e-01f, -4.02632877e-02f,
  -1.83057144e-01f, -2.47282013e-02f, -1.85955577e-02f, 1.44253388e-01f, -1.34655656e-02f, -4.12100963e-02f, 1.07352883e-02f, 9.35304463e-02f, 6.68487772e-02f, 7.14719621e-03f,
  -1.06109411e-01f, -1.53439835e-01f, 5.69477975e-01f, -2.32243612e-01f, 3.65382373e-01f, 5.04703522e-01f, 3.79481465e-01f, 3.87645394e-01f, 4.72040743e-01f, -3.04016650e-01f,
  -2.40902185e-01f, -4.77498382e-01f, 8.98175612e-02f, -3.85353327e-01f, 5.49191594e-01f, 3.63681883e-01f, -2.88462956e-02f, -2.16264501e-01f, 1.89215854e-01f, 9.78492498e-02f,
  4.40126471e-02f, -2.92400211e-01f, 2.13079434e-02f, -1.29393682e-01f, -1.55448765e-01f, -1.54640630e-01f, -3.48577976e-01f, 2.57935256e-01f, -3.61018568e-01f, 6.30077049e-02f,
  -1.53776094e-01f, -1.45207345e-01f, -2.44705379e-01f, 4.77063991e-02f, -5.79122314e-03f, -4.17887121e-02f, -6.53713569e-02f, 9.19788480e-02f, 4.07227725e-02f, 7.36863092e-02f,
  -8.06852207e-02f, 4.37273830e-02f, -3.36247459e-02f, 9.22262762e-03f, 2.12973267e-01f, 1.41635891e-02f, 1.22900657e-01f, 1.33663584e-02f, 7.34923407e-02f, 1.98586628e-01f,
  1.72715858e-02f, 5.83272912e-02f, 3.35277966e-03f, -6.39616465e-03f, 1.51960149e-01f, -5.63608147e-02f, 4.54871990e-02f, 3.50830182e-02f, -4.49913181e-02f, 1.61916941e-01f,
  7.55467564e-02f, 4.92870547e-02f, 7.90631305e-03f, -7.31023960e-03f, -5.49441949e-02f, 5.53239603e-03f, -2.05816813e-02f, -9.41973478e-02f, 3.02589275e-02f, -6.40312955e-02f,
  -9.50954407e-02f, -1.34239048e-01f, 6.79507852e-02f, 1.24579094e-01f, -6.84527829e-02f, -5.37678227e-02f, -1.44030929e-01f, -6.28010184e-02f, 2.44983565e-02f, -5.26125357e-03f,
  6.40230812e-03f, -6.66344771e-03f, -9.01238471e-02f, -1.16225794e-01f, 7.70830214e-02f, 1.24683425e-01f, -7.20272511e-02f, -1.18053770e-02f, -5.54486997e-02f, 3.66252623e-02f,
  -1.40498042e-01f, -1.83350295e-01f, -2.59110749e-01f, -2.67986298e-01f, -8.89331028e-02f, -9.90953743e-02f, 1.84516106e-02f, 6.25535473e-02f, 1.97490864e-02f, 5.97759634e-02f,
  7.07882941e-02f, -5.99450879e-02f, -4.11927216e-02f, 2.03626286e-02f, -1.54237766e-02f, 8.50031078e-02f, -4.17190194e-02f, -1.32697791e-01f, -8.93878937e-02f, -5.68823367e-02f,
  -1.03597447e-01f, -8.34345520e-02f, -3.72250974e-02f, -2.03577057e-01f, -8.73846784e-02f, -2.51886342e-02f, -5.45262769e-02f, -2.83502247e-02f, -1.52486330e-02f, -8.63523316e-03f,
  3.50070477e-01f, -9.97646004e-02f, 3.17012817e-01f, 3.27256590e-01f, 5.84848762e-01f, 4.75329131e-01f, 4.40278649e-01f, 3.63050848e-01f, 9.11753833e-01f, -3.96261126e-01f,
  -1.49749070e-01f, -1.83773756e-01f, -1.32519871e-01f, -1.42420769e-01f, 1.73369154e-01f, 1.37125611e-01f, 3.23240668e-01f, 1.82208821e-01f, 4.01083559e-01f, 1.13013402e-01f,
  1.91738263e-01f, -2.35343650e-01f, -3.05240512e-01f, -1.49983138e-01f, 1.34053603e-01f, -1.33141890e-01f, -4.42965597e-01f, 1.49964884e-01f, -4.75429386e-01f, 8.64340663e-02f,
  8.86042789e-03f, 3.82542610e-03f, -1.56726256e-01f, -7.66962320e-02f, 1.02329239e-01f, -5.47667444e-02f, -1.56273842e-01f, -1.10748224e-01f, 4.25848141e-02f, -3.23834457e-02f,
  -2.10154280e-02f, -3.21057260e-01f, -5.22879772e-02f, 5.02704978e-02f, 7.57845789e-02f, -1.27929628e-01f, -2.64544338e-02f, 6.41133338e-02f, -5.54870963e-02f, -2.42076609e-02f,
  -1.10554677e-02f, 9.40644443e-02f, 7.57283568e-02f, -4.63860966e-02f, -6.25782982e-02f, 3.39979515e-03f, -8.92114341e-02f, -6.64813221e-02f, 4.47146632e-02f, 3.50978114e-02f,
  3.90629470e-02f, 1.34882390e-01f, 1.02655683e-02f, -5.22794314e-02f, 1.63733959e-01f, 4.17340957e-02f, 2.67034583e-02f, 3.35583240e-02f, 2.38557801e-01f, -5.55126369e-02f,
  1.84102003e-02f, -4.16451581e-02f, 1.00836186e-02f, -1.73001364e-02f, 3.73402275e-02f, -3.22300419e-02f, -6.56700954e-02f, -2.99822967e-02f, 7.15332329e-02f, 6.05077259e-02f,
  7.99968988e-02f, 3.47118117e-02f, -3.99254682e-03f, 8.54450315e-02f, 4.09875400e-02f, -4.26509790e-02f, -9.44014862e-02f, 2.55155489e-02f, 9.81890336e-02f, 7.20420778e-02f,
  3.30597103e-01f, 1.18445829e-01f, -5.24300225e-02f, -2.82610536e-01f, 1.47013277e-01f, 4.26419079e-02f, 4.12132554e-02f, 4.96071652e-02f, 1.84355125e-01f, 7.68969357e-02f,
  -1.65505156e-01f, 1.40813114e-02f, 7.81241804e-02f, -5.76530620e-02f, -3.99222150e-02f, -2.34821904e-02f, -1.70161918e-01f, 1.06152013e-01f, 3.51497973e-03f, -2.05880955e-01f,
  -1.28016591e-01f, 1.51412152e-02f, -4.14380841e-02f, 3.43062505e-02f, -9.65216979e-02f, -1.48647353e-01f, 6.27853349e-02f, -5.13299629e-02f, 2.33835541e-02f, 9.10476521e-02f,
  2.13061735e-01f, -2.76267201e-01f, -2.84956425e-01f, -4.53300141e-02f, 5.90365864e-02f, 2.94121414e-01f, -1.85211338e-02f, 3.98833714e-02f, -6.45083547e-01f, -1.60608724e-01f,
  2.87125945e-01f, -2.88977008e-02f, -1.86681256e-01f, 2.48927653e-01f, 4.92049068e-01f, -3.22885662e-01f, 2.35486850e-01f, 1.41203910e-01f, -3.13060462e-01f, 2.76429802e-01f,
  4.00207676e-02f, 4.08949316e-01f, 1.81416869e-01f, 4.65002239e-01f, 2.29002371e-01f, 1.35065675e-01f, 5.11401653e-01f, 2.63909191e-01f, 5.69557250e-01f, 4.10256356e-01f,
  -7.52605572e-02f, -1.08755738e-01f, -7.91391209e-02f, -8.99284706e-02f, 1.89849034e-01f, 1.25712320e-01f, 7.79344812e-02f, 3.32569391e-01f, -1.31658465e-01f, 4.15305793e-02f,
  1.62921295e-01f, 4.33624610e-02f, 7.01308921e-02f, 2.82692839e-04f, -5.49735501e-02f, -7.63829574e-02f, -6.83186278e-02f, -2.00130433e-01f, -1.13605954e-01f, 5.71442880e-02f,
  -2.13257238e-01f, -1.71907455e-01f, -2.59815473e-02f, -2.27505527e-02f, 3.39446776e-02f, -7.37773180e-02f, -2.49884464e-02f, 1.62703946e-01f, -1.42290249e-01f, 9.39385667e-02f,
  2.18543068e-01f, -1.55896649e-01f, -1.53618073e-02f, -2.22214028e-01f, 5.18972389e-02f, -7.07230195e-02f, -8.96888748e-02f, 2.89260745e-02f, 4.72203866e-02f, 4.43967953e-02f,
  -1.11780874e-01f, 9.18964967e-02f, -4.97546718e-02f, -7.31506422e-02f, 7.23970458e-02f, -1.14665531e-01f, 1.03932805e-01f, 1.16257317e-01f, -1.77385211e-01f, -5.94444126e-02f,
  -1.31514832e-01f, 9.66613088e-03f, -4.08310927e-02f, 2.15037894e-02f, -1.39436156e-01f, 1.02243982e-02f, 3.74778709e-03f, -4.13342044e-02f, -9.33088455e-03f, 1.36652261e-01f,
  1.19435646e-01f, 3.51963788e-01f, -6.56925738e-02f, -1.37051105e-01f, 2.67886966e-02f, 7.90328309e-02f, -1.67562574e-01f, 1.83117285e-01f, 1.38323799e-01f, 1.91854149e-01f,
  1.52531922e-01f, 1.41654047e-04f, -1.42520666e-02f, -7.16045722e-02f, 8.45549032e-02f, 4.25330848e-02f, 5.56551144e-02f, -5.90123497e-02f, 3.24577987e-02f, 2.30940238e-01f,
  7.44645447e-02f, 1.30891368e-01f, 7.19059035e-02f, -6.15842976e-02f, -1.86852284e-03f, 8.30428526e-02f, 1.23646602e-01f, -7.22224861e-02f, 7.09392652e-02f, -1.40824988e-01f,
  -4.74406868e-01f, 4.45505977e-01f, -5.29534400e-01f, 4.93076324e-01f, -3.22369605e-01f, 4.84524071e-01f, 5.67281544e-01f, 1.23205744e-01f, 2.09160313e-01f, 6.95694745e-01f,
  3.58287960e-01f, -4.09865789e-02f, 5.31034805e-02f, 7.77933538e-01f, 2.44458482e-01f, 5.61420083e-01f, 6.69032395e-01f, 5.44222414e-01f, 4.88031469e-03f, 1.28825784e-01f,
  -3.92046981e-02f, 5.93645155e-01f, 5.57892695e-02f, 6.67169243e-02f, 8.20042565e-02f, -3.79123986e-01f, 7.66008943e-02f, -4.56364930e-01f, 4.29078162e-01f, 1.26212448e-01f,
  2.58261114e-01f, 6.22321572e-03f, -1.41988963e-01f, -6.73800260e-02f, -6.07284196e-02f, -1.31907731e-01f, -1.11795664e-02f, -1.20230891e-01f, -1.57397628e-01f, -7.54397213e-02f,
  -2.95694545e-02f, -2.03725863e-02f, 1.86550483e-01f, -1.76908039e-02f, -1.85024276e-01f, -7.17497692e-02f, -5.56867830e-02f, -3.86326611e-02f, 9.33202282e-02f, -1.15634382e-01f,
  -2.03522950e-01f, -6.13728464e-02f, -6.77895471e-02f, 2.15047985e-01f, -1.10572539e-01f, 8.94668861e-04f, 1.45906672e-01f, -1.05412848e-01f, 3.68718356e-02f, 1.10109217e-01f,
  4.31555845e-02f, 1.11154534e-01f, -3.53526846e-02f, -2.09933519e-02f, -4.55063991e-02f, -7.03939563e-03f, 8.70252848e-02f, -1.09481243e-02f, -1.30786955e-01f, 1.05980851e-01f,
  8.70262645e-03f, -1.03252552e-01f, 2.12275162e-02f, -2.18590237e-02f, 1.37642428e-01f, -1.06373252e-02f, -1.46732956e-01f, 1.41208023e-01f, -1.07214013e-02f, 8.98351613e-03f,
  6.27601594e-02f, -2.57492927e-03f, 1.74417514e-02f, 1.70909893e-02f, 2.18144149e-01f, -1.53429538e-01f, 1.12822831e-01f, -5.18592969e-02f, -1.10600265e-02f, -7.41639137e-02f,
  2.96113670e-01f, 4.93678957e-01f, 5.53521924e-02f, 4.08814326e-02f, 6.21191077e-02f, -9.14487168e-02f, 2.17039898e-01f, 2.19716802e-02f, 5.13340160e-02f, 6.25215322e-02f,
  2.21723299e-02f, -9.23538022e-03f, 1.02193188e-02f, -1.10655064e-02f, 7.32264444e-02f, 1.45978168e-01f, 2.25980937e-01f, -9.93930455e-03f, 1.37863547e-01f, 3.16276178e-02f,
  2.99563240e-02f, 4.07085894e-03f, -7.16166273e-02f, -4.31662947e-02f, 1.59497723e-01f, 3.84979062e-02f, -2.77958401e-02f, -1.20309375e-01f, -2.46000160e-02f, 1.63383380e-01f,
  -2.36042783e-01f, -2.23556668e-01f, -6.10154867e-01f, -3.74099910e-01f, -4.50705504e-03f, -5.78965843e-01f, -5.58222592e-01f, -2.53250331e-01f, 2.95022167e-02f, 1.60237163e-01f,
  -6.44477308e-02f, -1.10554986e-01f, 2.52639860e-01f, -5.16242683e-01f, -4.14619893e-01f, 1.45491123e-01f, -5.39447784e-01f, -2.59532273e-01f, -4.83290367e-02f, -1.62104115e-01f,
  -1.51596725e-01f, -2.08515733e-01f, -4.41434264e-01f, 1.48743913e-01f, -2.59101391e-01f, 8.64951238e-02f, 5.92103183e-01f, 1.72468759e-02f, -2.61429906e-01f, -1.32546023e-01f,
  -1.32828981e-01f, 9.92466956e-02f, -9.83639285e-02f, -1.12670787e-01f, -3.85304205e-02f, 6.26006126e-02f, -7.99938738e-02f, -7.21016899e-02f, -1.03566609e-02f, -4.51825820e-02f,
  9.32706445e-02f, 1.02866553e-01f, -3.57812876e-03f, 1.15478128e-01f, -5.53654414e-03f, -5.61334891e-03f, -1.29321486e-01f, -3.28582190e-02f, -6.02005310e-02f, -6.80067986e-02f,
  -2.21691251e-01f, -3.81796993e-02f, 2.08371338e-02f, 1.07620597e-01f, 2.56388262e-02f, -1.03811078e-01f, -4.70606126e-02f, 1.05185099e-01f, 6.71437308e-02f, 7.23026767e-02f,
  4.55275811e-02f, 1.51029661e-01f, -6.70633093e-02f, -4.33551483e-02f, -9.24760662e-03f, 7.28340074e-03f, -2.88043008e-03f, -5.63678592e-02f, -4.05253358e-02f, -2.88772918e-02f,
  -3.42628136e-02f, -2.77079865e-02f, -4.68217256e-03f, -1.08887538e-01f, 3.71946245e-02f, -7.65615627e-02f, -7.60576352e-02f, 3.05033326e-02f, -1.12154379e-01f, -8.95786062e-02f,
  9.56534147e-02f, -1.52860850e-01f, 3.87605629e-03f, 1.57769680e-01f, -8.82177800e-02f, 2.80067846e-02f, 9.70048308e-02f, -1.25270993e-01f, 4.31234315e-02f, 5.07657714e-02f,
  2.11089794e-02f, 1.81949869e-01f, -8.36288631e-02f, 1.07761426e-02f, 1.71341021e-02f, -4.79114577e-02f, -2.55699572e-03f, -4.68691885e-02f, -7.00802635e-03f, -3.38273868e-02f,
  1.81825608e-02f, 1.27476072e-02f, 1.73178673e-01f, -1.28205521e-02f, -1.95306111e-02f, -7.19481781e-02f, 1.13438480e-01f, 1.21422879e-01f, 7.36855939e-02f, 1.25770122e-01f,
  1.90903693e-01f, 7.46130422e-02f, -3.25412094e-03f, -8.59998050e-04f, 1.27432421e-01f, 4.89274003e-02f, -1.45877972e-02f, 2.74494272e-02f, 1.52407274e-01f, 6.56501576e-02f,
  -1.06225729e+00f, 7.25958526e-01f, -2.54218429e-01f, -1.50322542e-01f, 1.44356847e-01f, -1.88715395e-03f, 1.68331191e-01f, 7.06869289e-02f, 3.00335195e-02f, 2.64150679e-01f,
  2.23239094e-01f, -1.20237507e-01f, 4.24216717e-01f, 4.17009324e-01f, -4.78034973e-01f, 3.55940759e-01f, 5.76584898e-02f, 5.05437776e-02f, 2.05154225e-01f, -7.17536062e-02f,
  -1.16918772e-01f, 3.31249952e-01f, -2.73709167e-02f, 3.16555887e-01f, -1.52362689e-01f, -1.80794433e-01f, -2.67403305e-01f, 4.09626029e-02f, -8.05477425e-02f, 2.31130272e-02f,
  -3.12138379e-01f, -8.80362242e-02f, -2.54267573e-01f, -1.95157275e-01f, -2.48379201e-01f, -1.58805355e-01f, -2.53589243e-01f, 1.73554029e-02f, -4.43547554e-02f, 3.64800319e-02f,
  4.91168536e-02f, -6.74646869e-02f, 1.14162572e-01f, 1.04744814e-01f, -4.48394008e-02f, -1.84711106e-02f, 9.62576568e-02f, -1.12831295e-02f, 1.50510520e-01f, 5.79290017e-02f,
  1.68477505e-01f, -2.43021976e-02f, -6.23737238e-02f, 3.21034715e-02f, -9.37935710e-03f, 8.59545171e-02f, -4.58005928e-02f, -2.27902178e-02f, -1.09073080e-01f, -3.30509022e-02f,
  -3.13821412e-03f, -2.67446730e-02f, -4.89759259e-03f, 4.63095047e-02f, 1.07995532e-01f, 5.79435639e-02f, -4.13153553e-03f, -4.82861064e-02f, -8.73314515e-02f, -8.19952041e-02f,
  5.62098585e-02f, -2.86448319e-02f, -3.07347160e-02f, -7.18767270e-02f, 1.07113710e-02f, -6.03713058e-02f, -5.05512431e-02f, -1.31715924e-01f, 1.85906719e-02f, -1.23886980e-01f,
  -1.05258383e-01f, -7.20856851e-03f, 1.45034686e-01f, -4.83516566e-02f, -5.29033169e-02f, -3.56455962e-03f, 9.28813666e-02f, 8.89673606e-02f, -2.03609858e-02f, -6.89588785e-02f,
  -4.58194137e-01f, -4.76288050e-01f, -8.25662464e-02f, -6.92727715e-02f, -7.60329142e-02f, -3.69964764e-02f, -3.17744352e-02f, -1.79555155e-02f, -7.69328922e-02f, -3.55931297e-02f,
  -4.37946357e-02f, -1.82427298e-02f, -1.82576478e-01f, 1.78485010e-02f, 1.58284213e-02f, 7.56383166e-02f, -5.64850681e-02f, -1.85232814e-02f, -1.30005941e-01f, -6.29057065e-02f,
  -8.95143524e-02f, 1.11249154e-02f, 1.55552030e-02f, 6.06938079e-02f, -8.22731573e-03f, -8.54567215e-02f, -1.33031234e-01f, 2.86449865e-02f, -3.57422493e-02f, 3.77724282e-02f,
  8.38418245e-01f, 5.69156349e-01f, 2.91670144e-01f, 3.86788785e-01f, -3.68025571e-01f, -4.70667958e-01f, -1.67528346e-01f, -1.74470469e-01f, 1.59754068e-01f, 1.83872864e-01f,
  -3.60670090e-01f, 7.44352877e-01f, -2.11671501e-01f, 2.93066710e-01f, -8.65742657e-03f, -2.40837842e-01f, 2.14379221e-01f, 1.06690869e-01f, 2.38160156e-02f, 3.43237400e-01f,
  1.86850175e-01f, -5.43508865e-02f, 1.21197306e-01f, -3.04735094e-01f, 3.39759022e-01f, 2.00193942e-01f, -4.16672081e-02f, -3.98956448e-01f, 3.51858400e-02f, -1.89796343e-01f,
  -6.04212508e-02f, 2.98187971e-01f, 9.69209000e-02f, 7.51910359e-02f, 1.22030281e-01f, -9.60912257e-02f, -9.37348753e-02f, -5.87399006e-02f, -1.01012513e-01f, -4.95067723e-02f,
  2.46734291e-01f, 2.91756503e-02f, -5.79342060e-02f, -1.17358610e-01f, 1.09019272e-01f, 4.99237031e-02f, 9.95732546e-02f, 1.09966859e-01f, 4.36528251e-02f, 1.93080977e-01f,
  2.68455833e-01f, 1.16841421e-01f, 2.21214399e-01f, 1.21373750e-01f, 1.76242009e-01f, 8.20875391e-02f, 1.85277332e-02f, 5.54649793e-02f, 1.36213368e-02f, 2.20510870e-01f,
  1.62335396e-01f, -3.99843492e-02f, -4.41903025e-02f, -1.19333446e-01f, -3.44519168e-02f, -8.90887082e-02f, 4.93535213e-02f, -1.22589499e-01f, 5.18079265e-04f, -2.12780572e-02f,
  -2.71213025e-01f, 1.36563897e-01f, -4.61718552e-02f, -6.52933270e-02f, 4.97077219e-02f, 1.90716580e-01f, -1.28909713e-02f, -1.15061618e-01f, 9.72721204e-02f, 2.69616004e-02f,
  -1.08494967e-01f, -5.15144281e-02f, 7.57300928e-02f, -5.89021705e-02f, -2.68476397e-01f, -4.08562832e-02f, 1.59073561e-01f, 1.71589941e-01f, -1.51619002e-01f, -5.25510199e-02f,
  -2.76080985e-02f, 3.57120186e-01f, 1.26544729e-01f, 4.27176536e-04f, -1.06635578e-01f, -4.67253402e-02f, 8.85701564e-04f, 1.28193155e-01f, -2.13279501e-02f, -6.75600618e-02f,
  1.49604410e-01f, -1.21746123e-01f, -9.27316621e-02f, 1.06847174e-02f, -1.84657276e-02f, 4.05717790e-02f, 7.13982880e-02f, 6.45313859e-02f, 1.26137614e-01f, 5.27411792e-03f,
  -1.29015064e-02f, 8.91001970e-02f, 3.18939537e-02f, -7.92223290e-02f, 1.20952606e-01f, 3.82608362e-02f, 1.08360266e-02f, 8.03759992e-02f, 9.62081924e-02f, -1.52781941e-02f,
  -1.76550731e-01f, 2.14066491e-01f, 4.18260098e-01f, -3.07123691e-01f, -2.00777844e-01f, 2.94691235e-01f, 2.19592020e-01f, 5.52071910e-03f, -4.75388728e-02f, -1.09931506e-01f,
  -3.45759124e-01f, 3.14273298e-01f, 2.45209813e-01f, -2.39814207e-01f, 4.24407095e-01f, 5.37352324e-01f, -4.98390719e-02f, 4.02684178e-04f, -7.43649974e-02f, -2.53446132e-01f,
  -1.86236724e-01f, -4.80706334e-01f, 6.37068674e-02f, -1.50543883e-01f, -2.60400891e-01f, -6.15203269e-02f, -2.94853747e-01f, 1.51052726e-02f, -2.60657936e-01f, 2.49683838e-02f,
  1.34215802e-01f, -1.27538694e-02f, 9.07085016e-02f, 2.33831659e-01f, 3.64130251e-02f, -2.68446822e-02f, 1.50360584e-01f, 1.55355781e-01f, 2.69125048e-02f, -2.47014090e-02f,
  -5.02149062e-03f, 1.86472610e-01f, -4.71170694e-02f, 2.32604481e-02f, -2.71270186e-01f, -1.09660506e-01f, -1.35092333e-01f, -7.74261132e-02f, 1.51239231e-01f, 6.32826835e-02f,
  -7.05672801e-02f, 1.60250105e-02f, -2.32808843e-01f, 7.24748988e-03f, 3.42313014e-02f, -3.51063199e-02f, 1.95186481e-01f, 6.91077411e-02f, 1.65721718e-02f, 2.80089788e-02f,
  -2.00143546e-01f, -4.42673303e-02f, -1.31232524e-02f, -1.75559521e-03f, -1.48034379e-01f, 6.91868067e-02f, -1.06802575e-01f, -1.00112066e-01f, -9.34392288e-02f, -9.90808308e-02f,
  -2.77081747e-02f, 7.61653250e-03f, -4.94726747e-02f, -3.81535925e-02f, -1.55507669e-01f, -2.58008093e-02f, 1.18542388e-01f, 5.55652380e-02f, 7.68293277e-04f, 8.07880610e-02f,
  -3.83820571e-02f, -8.66929349e-03f, 3.64480279e-02f, 1.33502394e-01f, 1.56638816e-01f, -6.61063790e-02f, -8.22403952e-02f, 8.62620324e-02f, -8.44563451e-03f, -4.87901345e-02f,
  1.82242721e-01f, 2.78724074e-01f, 1.79147467e-01f, 2.02110097e-01f, 1.17875300e-01f, -1.76512018e-01f, 2.34575178e-02f, 1.05059901e-02f, 6.90742210e-02f, -1.00038327e-01f,
  -9.26886946e-02f, 1.56404376e-01f, -8.06344151e-02f, -1.21169351e-01f, 5.84830642e-02f, 7.97780752e-02f, 2.65426010e-01f, 2.97074933e-02f, 4.64859530e-02f, -1.39303491e-01f,
  -4.81998362e-02f, -5.60032576e-02f, -5.68734296e-02f, -7.90474471e-03f, 6.41847476e-02f, -6.56535923e-02f, -7.48842061e-02f, 1.11383356e-01f, 6.05739653e-02f, 1.59604758e-01f,
  -3.82955819e-01f, 3.30428593e-02f, -2.48490587e-01f, -2.76602626e-01f, -7.41058290e-01f, -1.71218425e-01f, 1.87866837e-02f, -2.32802734e-01f, 1.52131040e-02f, 3.42999786e-01f,
  -1.60335213e-01f, 1.07354090e-01f, 4.23888743e-01f, -2.93974668e-01f, 1.69775218e-01f, 5.50203383e-01f, -3.57029680e-03f, 3.64143312e-01f, -1.05968952e-01f, -4.55575399e-02f,
  -9.41913500e-02f, -7.89544508e-02f, -2.75659841e-02f, -2.64659911e-01f, -6.42493904e-01f, -3.24814826e-01f, -2.27170616e-01f, -3.55813384e-01f, -5.43188930e-01f, -4.41586077e-01f,
  -5.04800558e-01f, -3.21635544e-01f, -8.97408649e-02f, 2.37436146e-02f, -1.81528524e-01f, -5.16455583e-02f, -1.55500725e-01f, -2.49456544e-03f, -9.25037339e-02f, -1.04596140e-02f,
  1.68280572e-01f, -7.14365840e-02f, -1.66582521e-02f, 2.49878719e-01f, -1.06909670e-01f, -1.56535506e-01f, -1.73265681e-01f, -1.11068666e-01f, -8.82893726e-02f, -1.70142204e-01f,
  -2.23776065e-02f, -1.24516696e-01f, -1.24654487e-01f, 1.97648220e-02f, -2.25043625e-01f, -2.14600027e-01f, -6.80606738e-02f, -3.42419520e-02f, -1.11422509e-01f, -1.83552071e-01f,
  -5.70774153e-02f, 3.53290401e-02f, 7.37550184e-02f, -9.43799242e-02f, 2.02691913e-01f, -2.63350029e-02f, 6.63589761e-02f, -6.31700382e-02f, 1.68943807e-01f, -2.71109864e-02f,
  -4.82326001e-02f, 1.83153041e-02f, -6.06219545e-02f, 1.58046246e-01f, 7.16931149e-02f, 2.51431435e-01f, 1.26163438e-01f, 1.13539249e-02f, 9.06278472e-03f, -8.08897465e-02f,
  1.16634071e-02f, 4.75048311e-02f, 3.61394174e-02f, -3.46919782e-02f, -1.23750888e-01f, -2.09145341e-02f, -1.20462961e-01f, 1.51071865e-02f, 5.44194132e-02f, 8.07941556e-02f,
  -3.45499545e-01f, -2.14604944e-01f, 5.69774620e-02f, 1.55666787e-02f, 2.98480177e-03f, -1.25652533e-02f, 2.73830108e-02f, -1.37330830e-01f, -8.80987644e-02f, 1.48542479e-01f,
  1.91080466e-01f, 1.88406669e-02f, -1.35717615e-01f, -8.64443555e-02f, 1.70961604e-01f, -8.30227509e-02f, -1.54969469e-02f, -6.43993169e-02f, -5.91677316e-02f, -1.08740315e-01f,
  1.77883044e-01f, 1.45772323e-01f, 3.48435700e-01f, 5.01357429e-02f, 6.46334365e-02f, 1.01371586e-01f, -2.05830745e-02f, -3.36249843e-02f, -1.87105075e-01f, -1.60019442e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  3.01550746e-01f, 5.75328350e-01f, 4.46211874e-01f, 7.67365336e-01f, 6.25057518e-01f, 5.23561954e-01f, 5.06552994e-01f, 3.37578684e-01f, 7.35514581e-01f, 4.09800828e-01f,
  2.34853402e-01f, 6.59643173e-01f, 6.77113950e-01f, 4.68225360e-01f, 5.30010641e-01f, 6.84710205e-01f, 4.65063244e-01f, 4.92930681e-01f, 3.49037319e-01f, 7.31180727e-01f,
  4.89922881e-01f, 4.80845839e-01f, 4.78654951e-01f, 7.03723252e-01f, 5.09486020e-01f, 2.46306404e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -7.50210956e-02f, -1.35969728e-01f, -3.08729053e-01f, -2.22920328e-01f, -9.56010818e-02f, 6.59262955e-01f, 1.77488223e-01f, -6.33136749e-01f, 1.13345742e-01f, 5.89387771e-03f,
  3.10344756e-01f, 5.29224277e-01f, -3.88966531e-01f, -4.00500625e-01f, 2.64067024e-01f, -3.97362441e-01f, 5.20610027e-02f, -5.40392280e-01f, -4.52649564e-01f, 6.38837695e-01f,
  -4.54076767e-01f, -8.32101464e-01f, -6.78894997e-01f, -8.09931219e-01f, -9.64495242e-01f, -6.36994839e-01f, 7.75326192e-01f, -1.90593496e-01f, 5.27695239e-01f, -8.49874914e-01f,
  -2.77237855e-02f, 4.64486390e-01f, 4.31499891e-02f, -3.31576169e-01f, 2.49760449e-01f, -2.10869446e-01f, -6.15212560e-01f, -2.24876359e-01f, -6.73736036e-01f, -8.84415567e-01f,
  6.85993552e-01f, 5.11649966e-01f, -8.73141587e-01f, -7.48466074e-01f, -4.06539857e-01f, -8.16658080e-01f, 2.65201569e-01f, 4.67123032e-01f, -8.01770568e-01f, -2.93789171e-02f,
  6.78020060e-01f, -1.29569247e-01f, -4.50304925e-01f, -2.47032374e-01f, -6.96232438e-01f, -5.27939498e-01f, -7.65133351e-02f, 4.90587145e-01f, 6.38800442e-01f, -2.47772098e-01f,
  3.05745797e-03f, 1.42452806e-01f, -9.13655221e-01f, -8.08035970e-01f, -2.96135843e-01f, -1.85461342e-01f, -2.10749015e-01f, -2.75454581e-01f, 7.25389957e-01f, 3.90513957e-01f,
  -5.10771513e-01f, -2.88853347e-01f, 4.31634635e-01f, -8.31882060e-01f, -4.52965558e-01f, -1.70425415e-01f, -6.07995272e-01f, -2.71785378e-01f, -4.24775124e-01f, -6.14997856e-02f,
  6.02191150e-01f, 3.57417852e-01f, 1.72539413e-01f, -3.05178538e-02f, 6.95156932e-01f, -4.92660612e-01f, 8.50848556e-01f, -6.97244823e-01f, -6.45845175e-01f, 3.25584292e-01f,
  -5.26654832e-02f, -5.48409522e-01f, -4.85899448e-01f, -6.94359779e-01f, -6.53234078e-03f, -3.76123041e-01f, -8.78911376e-01f, -1.03291765e-01f, -1.83212757e-01f, 1.30922318e-01f,
  4.70481843e-01f, -3.97269070e-01f, 7.68623292e-01f, 2.58277333e-03f, -6.89559460e-01f, 5.16734421e-01f, -7.54451931e-01f, 6.02249742e-01f, 3.62877220e-01f, -4.34685260e-01f,
  -3.51272523e-01f, -3.21562469e-01f, 9.87843052e-02f, -6.60332620e-01f, -2.49900684e-01f, -7.53353775e-01f, -8.25985014e-01f, 4.66868758e-01f, 1.72960624e-01f, -5.07275224e-01f,
  -4.64236110e-01f, -8.07265222e-01f, -4.63021308e-01f, 3.93945992e-01f, 7.38328397e-01f, -3.08718354e-01f, -1.20857574e-01f, -9.35089663e-02f, 4.45854902e-01f, 1.52870297e-01f,
  3.98970634e-01f, 8.17270458e-01f, -3.93825799e-01f, 2.24338606e-01f, -8.01649213e-01f, 6.99193329e-02f, 4.98604774e-01f, 7.79313222e-02f, 2.67831504e-01f, 4.73966062e-01f,
  6.56357035e-02f, 5.46371520e-01f, 5.75996995e-01f, -6.44296110e-01f, -5.36902189e-01f, -2.97989786e-01f, -1.10139477e+00f, 1.81084409e-01f, -4.14730430e-01f, 5.35422504e-01f,
  4.41774487e-01f, 5.89885175e-01f, -2.01651245e-01f, -3.93441208e-02f, -8.17799270e-01f, -6.59140348e-01f, 3.54911298e-01f, -1.02735460e+00f, 5.26347637e-01f, -2.11469769e-01f,
  7.79723078e-02f, 9.59703103e-02f, 1.61865905e-01f, -7.65579045e-01f, -4.19457376e-01f, -6.09079063e-01f, -2.32041225e-01f, 5.70660114e-01f, -1.05191004e+00f, 1.87110335e-01f,
  2.85938591e-01f, -5.72105944e-01f, -6.62710488e-01f, 5.77762187e-01f, -4.45522338e-01f, 6.19442463e-01f, -5.28233349e-01f, -6.72060609e-01f, -1.06608979e-01f, -7.81539619e-01f,
  -4.87853616e-01f, -6.06947064e-01f, -4.38519239e-01f, 2.77165681e-01f, 5.80871046e-01f, -3.21537137e-01f, 2.35410184e-01f, -3.90858144e-01f, -1.48827836e-01f, 2.82662332e-01f,
  5.12893677e-01f, 7.93115258e-01f, -3.23114902e-01f, 2.83408631e-02f, 4.74262297e-01f, -1.61273241e-01f, -3.06442320e-01f, 5.99215209e-01f, 4.19628061e-02f, -3.61197814e-02f,
  -2.66090244e-01f, -1.18576899e-01f, 1.72364302e-02f, -7.29504764e-01f, 7.57683039e-01f, -8.35763335e-01f, -3.75181317e-01f, 1.14295885e-01f, 6.80273235e-01f, 4.34360504e-01f,
  6.26576424e-01f, -6.37147665e-01f, 1.23808697e-01f, -9.17850435e-01f, 4.76183504e-01f, 3.45471174e-01f, 7.67341852e-01f, -1.02905023e+00f, -8.67888451e-01f, -2.94230580e-01f,
  -3.79186481e-01f, 2.42946848e-01f, -4.38512981e-01f, -8.62275481e-01f, -3.15304399e-01f, -5.75423658e-01f, -2.21699178e-01f, 3.19772005e-01f, 3.82944465e-01f, 3.66717428e-01f,
  -7.11751401e-01f, 1.40352234e-01f, -1.05180562e-01f, 2.71072179e-01f, 3.79887044e-01f, -6.82678998e-01f, 3.45378757e-01f, 4.76464210e-03f, -5.16573787e-01f, -3.00685287e-01f,
  -1.66417941e-01f, -2.54175276e-01f, -6.43698692e-01f, -5.77823341e-01f, -1.15983952e-02f, 3.64443064e-01f, 4.08727527e-01f, 9.65625048e-02f, -3.21665287e-01f, -4.01568979e-01f,
  -5.09021044e-01f, 7.72562146e-01f, -5.29784620e-01f, 1.28324032e-01f, 2.75481880e-01f, 6.45133436e-01f, 1.54543683e-01f, -2.79295117e-01f, -5.10090850e-02f, -7.27234408e-02f,
  -3.11365485e-01f, -3.12381834e-01f, 3.76931503e-02f, -4.27585244e-01f, -1.45775422e-01f, -5.00907898e-01f, -3.19648355e-01f, -3.94839585e-01f, -2.23471478e-01f, 8.28816414e-01f,
  -5.55287421e-01f, -5.62958360e-01f, 6.73543096e-01f, 3.10825646e-01f, -8.23616624e-01f, -3.80304605e-01f, -4.55197960e-01f, -4.26358610e-01f, -3.95866007e-01f, -2.94619203e-01f,
  -4.00631338e-01f, 4.96888012e-01f, 1.38894647e-01f, -1.68823134e-02f, -3.69415760e-01f, 5.88561714e-01f, -3.15400064e-01f, -2.60595709e-01f, 2.91284442e-01f, 3.71000230e-01f,
  -4.05943155e-01f, -2.19087183e-01f, 7.04903483e-01f, 1.32833213e-01f, -3.28864962e-01f, -6.72416687e-01f, -3.89834136e-01f, -7.55001009e-01f, 5.27085662e-01f, -7.11018980e-01f,
  3.48346055e-01f, -1.63537562e-01f, -6.74379885e-01f, -7.61603490e-02f, -3.18213642e-01f, -7.64350057e-01f, 6.49341464e-01f, 7.38082588e-01f, 4.83155012e-01f, 6.73049092e-01f,
  -3.93912166e-01f, 2.09714696e-01f, -3.36600877e-02f, 2.49799550e-01f, -8.13251138e-01f, -2.05896884e-01f, -7.81797826e-01f, -6.36666000e-01f, 2.87526488e-01f, 1.23417690e-01f,
  5.32633662e-01f, 3.03576201e-01f, -9.65791754e-03f, 5.10460556e-01f, 4.78682876e-01f, -3.24507236e-01f, 6.15389764e-01f, -5.48960268e-01f, -3.56920391e-01f, -8.05073138e-03f,
  -1.65041253e-01f, -3.50518107e-01f, -5.73254347e-01f, -2.32085541e-01f, 7.80852795e-01f, -2.64109701e-01f, -5.91746271e-01f, 1.72000721e-01f, -5.13377190e-01f, -2.14442641e-01f,
  8.30621421e-01f, -1.08344316e-01f, -5.78198373e-01f, -1.69285610e-01f, 4.69904207e-02f, 3.67919445e-01f, -2.35242039e-01f, 4.83140439e-01f, -6.45123839e-01f, -5.95368207e-01f,
  -6.99214041e-01f, -2.67005593e-01f, 2.43591815e-01f, -2.91193593e-02f, -3.29184741e-01f, 3.88599992e-01f, -3.58990848e-01f, -4.62022185e-01f, -3.20235580e-01f, 8.67274404e-01f,
  -3.55307758e-01f, -6.97849631e-01f, -6.47932529e-01f, 6.01811290e-01f, 2.91461051e-02f, -2.70048976e-01f, 3.34615380e-01f, -5.21117747e-01f, -3.89589578e-01f, 8.20300758e-01f,
  -1.62854999e-01f, -3.35944653e-01f, -4.68554437e-01f, 1.70697734e-01f, -3.37442547e-01f, -4.92797017e-01f, -1.49192512e-01f, -4.36681569e-01f, -5.87405443e-01f, -6.20820999e-01f,
  -3.77310216e-01f, 8.81094396e-01f, 6.34997189e-02f, -2.12296814e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  2.03178469e-02f, 1.81285456e-01f, -2.91628521e-02f, 4.91205081e-02f, -2.32297517e-02f, -2.11835280e-02f, 5.44256456e-02f, -1.77700117e-01f, -1.65540148e-02f, -9.87498984e-02f,
  6.57500923e-02f, 2.06531361e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    