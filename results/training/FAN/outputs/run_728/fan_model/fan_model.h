/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 38 x 120)
const int L0_fan_Wp_rows = 38;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.03275031e-01f, 5.19228987e-02f, -1.56931967e-01f, 4.65722866e-02f, 1.66464165e-01f, 9.59208310e-02f, 1.25265852e-01f, 1.42667651e-01f, 5.37065614e-04f, 7.94415921e-02f,
  -1.24598339e-01f, -1.03547066e-01f, -8.77047554e-02f, -4.79313359e-02f, -9.64375660e-02f, 6.30617663e-02f, 2.84266919e-02f, 9.27987602e-03f, -1.19676683e-02f, -1.47879161e-02f,
  1.08653545e-01f, 2.33123042e-02f, 8.32463242e-03f, 7.65980706e-02f, 5.90788480e-03f, 9.94415730e-02f, 9.59210545e-02f, 8.10398981e-02f, 5.22453859e-02f, 4.20168862e-02f,
  -3.18012059e-01f, -4.77168784e-02f, -5.64926155e-02f, -9.41387266e-02f, -6.92773014e-02f, -4.21772934e-02f, -5.02603911e-02f, -1.10499464e-01f, -9.82436016e-02f, -3.42217796e-02f,
  -8.52581337e-02f, -5.55729233e-02f, -1.24454588e-01f, -6.44042268e-02f, -6.74736276e-02f, 2.24137772e-03f, -5.07160760e-02f, -1.01549819e-01f, -7.48149157e-02f, -1.46614760e-01f,
  6.16639340e-03f, -9.69571527e-03f, -1.72103494e-02f, -1.92803852e-02f, -1.51223674e-01f, -4.10827957e-02f, 3.60044241e-02f, -6.20054863e-02f, -1.02958046e-01f, 8.80646631e-02f,
  -4.15779464e-02f, 3.34667638e-02f, 1.73782725e-02f, 1.37469560e-01f, -2.21788678e-02f, 4.89328653e-02f, 1.05847180e-01f, 6.15433156e-02f, -1.82435233e-02f, 1.23675719e-01f,
  -2.50445995e-02f, -4.78741601e-02f, -3.99534293e-02f, 6.70906752e-02f, 1.83197614e-02f, 9.09007620e-03f, 7.94868567e-04f, -5.24914376e-02f, 6.66780677e-03f, 2.33473014e-02f,
  3.12312152e-02f, 1.83187693e-03f, -2.31917314e-02f, 6.97444826e-02f, -1.48228798e-02f, 1.55380070e-02f, 1.05148770e-01f, -9.75864846e-03f, 9.48844105e-02f, -2.72936597e-02f,
  4.23399992e-02f, -5.71168587e-02f, -1.23025596e-01f, -1.29364515e-02f, 3.24045159e-02f, -7.73861855e-02f, -1.10178992e-01f, -1.59338824e-02f, -8.22488293e-02f, 3.80759896e-03f,
  2.18327008e-02f, -6.82775974e-02f, -1.84003450e-02f, -1.21253850e-02f, 3.66117917e-02f, 1.43712843e-02f, 9.41314399e-02f, 6.55936152e-02f, -9.24468860e-02f, 9.29988921e-03f,
  3.89262824e-03f, -2.48091742e-02f, 6.91529189e-04f, 8.09832290e-02f, -6.78706393e-02f, 5.95258325e-02f, 7.17958063e-02f, 2.43040137e-02f, 1.04124486e-01f, 2.39494100e-01f,
  1.88393503e-01f, -2.41781324e-01f, -1.79539815e-01f, 6.77828258e-03f, -1.04418412e-01f, 1.70876253e-02f, -1.00683719e-01f, 7.23106489e-02f, 3.30572613e-02f, -2.66702492e-02f,
  -5.69752716e-02f, 7.36387298e-02f, -6.11038432e-02f, -3.09679043e-02f, -9.75155681e-02f, -1.67370796e-01f, -8.08931962e-02f, -1.10132515e-01f, -4.26665545e-02f, -1.51520416e-01f,
  -2.10841283e-01f, -6.50084540e-02f, -1.40340269e-01f, -1.45297185e-01f, -1.85307056e-01f, -1.84368528e-02f, -1.95984036e-01f, -1.36288330e-01f, -2.03335240e-01f, -2.31651992e-01f,
  -1.40974492e-01f, -5.29004410e-02f, -6.74242303e-02f, -1.36211533e-02f, -9.43326429e-02f, -9.81757566e-02f, -1.34746417e-01f, -1.36272430e-01f, -6.10329919e-02f, -5.65794967e-02f,
  -6.94995448e-02f, -1.98302716e-01f, -1.65780485e-01f, -1.70452833e-01f, -6.97952211e-02f, -1.33818567e-01f, -9.17124972e-02f, -2.05128655e-01f, -1.55037314e-01f, -1.31359458e-01f,
  -2.57720560e-01f, -2.21671119e-01f, 3.41899320e-02f, -8.48357901e-02f, -9.51380283e-02f, 2.19221804e-02f, -5.54231778e-02f, -2.94478443e-02f, 7.30869593e-03f, -3.46874408e-02f,
  -6.09608134e-03f, 1.62067398e-01f, 1.47723049e-01f, 1.38132155e-01f, 1.90195203e-01f, 1.58003733e-01f, 1.05338089e-01f, 1.64846912e-01f, 1.77964449e-01f, 1.74011216e-01f,
  1.42744422e-01f, 9.97438356e-02f, 2.22194538e-01f, 1.50788635e-01f, 1.83623061e-01f, 1.02918439e-01f, 8.93955380e-02f, 1.49304479e-01f, 7.98233449e-02f, 9.50123668e-02f,
  1.31951213e-01f, 1.48171455e-01f, 1.77997261e-01f, 9.69964787e-02f, 1.54122368e-01f, 2.22063825e-01f, 8.29478875e-02f, 1.61784843e-01f, 2.55485475e-01f, 2.12684676e-01f,
  1.19988516e-01f, -5.20344488e-02f, -2.48654503e-02f, -5.57194613e-02f, -1.10035054e-01f, -1.99474096e-01f, -6.49825782e-02f, -1.45423234e-01f, -1.47073433e-01f, -1.47864550e-01f,
  -1.22922912e-01f, -6.19066097e-02f, -7.41456449e-02f, -1.76694155e-01f, -7.25963265e-02f, -2.03471500e-02f, -1.27817839e-01f, -9.62138921e-02f, -7.83613324e-02f, -7.77694434e-02f,
  -4.56153192e-02f, -3.77857462e-02f, -3.29575763e-04f, 1.47058591e-02f, -7.76582137e-02f, 8.01010728e-02f, 7.15102395e-03f, -5.92447771e-03f, -2.85110939e-02f, 1.18635364e-01f,
  4.90210056e-01f, -1.86066657e-01f, -6.89363778e-02f, 2.62142003e-01f, 8.73938128e-02f, 2.51279294e-01f, 3.00249964e-01f, 2.63328403e-01f, 1.90899268e-01f, -8.25829431e-02f,
  -1.53031334e-01f, -1.30114287e-01f, -1.05060197e-01f, 1.88876770e-03f, 1.75202578e-01f, 2.00118851e-02f, 8.43361318e-02f, 2.40121052e-01f, 2.93662548e-01f, 1.82132229e-01f,
  6.25523180e-02f, 2.76987255e-01f, 2.72187352e-01f, 2.22489730e-01f, -1.04910441e-01f, 4.26798165e-02f, 9.06175468e-03f, -4.07653898e-02f, -6.53704803e-04f, -2.57019192e-01f,
  -1.63186982e-01f, 1.50969550e-01f, 1.94005758e-01f, 6.95196390e-02f, 4.99774963e-02f, 1.51435822e-01f, 8.95620584e-02f, 8.65588561e-02f, 2.25917563e-01f, 9.79026631e-02f,
  7.96873048e-02f, 8.73739049e-02f, 1.76702440e-01f, 1.05784930e-01f, 1.93283722e-01f, 1.70920968e-01f, 2.04290867e-01f, 2.55811721e-01f, 1.32489026e-01f, 1.00183405e-01f,
  -3.85051928e-02f, 1.03147954e-01f, 4.16308828e-02f, 2.53545910e-01f, 1.49841234e-01f, 1.41109362e-01f, 1.44250587e-01f, 1.00705191e-01f, 9.45519730e-02f, 5.83920926e-02f,
  2.53844392e-02f, 1.14311464e-03f, -7.05814809e-02f, -1.24053443e-02f, -5.66911884e-02f, -9.05396044e-02f, -8.30363184e-02f, -1.38966322e-01f, -5.04463203e-02f, -9.84639376e-02f,
  -1.14334837e-01f, -1.99767873e-01f, -1.69520546e-02f, -1.29118145e-01f, -1.21095143e-01f, -1.47489503e-01f, -9.12129954e-02f, -1.45945117e-01f, -1.31962568e-01f, -3.95017266e-02f,
  -1.20898478e-01f, -5.81944250e-02f, -1.95996746e-01f, -1.46862447e-01f, -9.49051678e-02f, -1.40103290e-03f, -1.54996946e-01f, -1.30171776e-01f, -7.59160593e-02f, -8.32324028e-02f,
  8.85126069e-02f, 1.93065658e-01f, 8.00202116e-02f, 1.23721041e-01f, 1.13233298e-01f, 9.43313241e-02f, 1.32499889e-01f, 1.65937483e-01f, 7.26741180e-02f, 6.64223060e-02f,
  7.77930319e-02f, 1.95947826e-01f, 2.79902648e-02f, 1.62685215e-01f, 1.74128205e-01f, 1.06851049e-01f, 1.52438536e-01f, 9.79366377e-02f, 3.27837206e-02f, 8.12450796e-02f,
  4.52300608e-02f, 8.84535909e-02f, 1.90225363e-01f, 1.75752699e-01f, 1.85910940e-01f, 7.56765381e-02f, 1.74194038e-01f, 2.19887018e-01f, 2.59231985e-01f, 2.25472987e-01f,
  -3.67912501e-01f, -4.00556833e-01f, -2.42688745e-01f, 7.76967704e-02f, 2.07619905e-01f, -2.07089689e-02f, -1.60125583e-01f, -2.21264094e-01f, -4.94835190e-02f, -9.66462940e-02f,
  9.68085155e-02f, 3.07231098e-01f, 1.99172884e-01f, 1.94249332e-01f, -1.59565538e-01f, -2.30737671e-01f, -9.02814418e-02f, -6.06668228e-03f, 4.77939062e-02f, 1.20854236e-01f,
  1.48817196e-01f, 7.98901469e-02f, -1.02611184e-01f, -1.31149858e-01f, 1.07225455e-01f, 2.67364502e-01f, -2.80391835e-02f, 5.11850603e-02f, 1.62223056e-02f, 1.74859673e-01f,
  1.72407687e-01f, -3.02127868e-01f, 1.29388288e-01f, 5.88422641e-02f, 2.73849517e-02f, -7.30445758e-02f, -1.93197895e-02f, -1.49849653e-01f, -6.40315190e-02f, -8.44590291e-02f,
  3.53679061e-02f, -2.11455002e-02f, 2.19810568e-02f, -4.51959632e-02f, -6.62560537e-02f, -9.61855650e-02f, -8.96693394e-02f, -7.58990571e-02f, -2.73546018e-02f, -8.15133229e-02f,
  6.17650636e-02f, -4.69591245e-02f, -8.05013478e-02f, -7.51215816e-02f, -1.53625786e-01f, -2.04126071e-03f, -1.57070681e-01f, -1.40310019e-01f, -8.51431787e-02f, -9.80493128e-02f,
  -1.87563132e-02f, 7.66997114e-02f, 9.63874720e-03f, -7.21701048e-03f, 4.74238843e-02f, 3.30650546e-02f, 1.03508040e-01f, 1.15316346e-01f, 2.69479007e-02f, 7.39275739e-02f,
  1.50949946e-02f, -5.49068023e-03f, 6.98486790e-02f, 1.23746153e-02f, 1.51989490e-01f, 2.07707752e-02f, 4.20463234e-02f, 4.31120046e-04f, 1.53228585e-02f, 2.89183073e-02f,
  9.10197869e-02f, 9.52132493e-02f, 9.46644768e-02f, -5.55424690e-02f, 7.96518773e-02f, 2.99244206e-02f, 3.41332965e-02f, 8.55130553e-02f, 4.77098860e-02f, 6.23280816e-02f,
  5.19641899e-02f, -1.31130919e-01f, 4.55521159e-02f, 2.79811062e-02f, -5.62726706e-02f, -1.34150743e-01f, 7.27091171e-03f, 2.47551464e-02f, -6.80158660e-02f, -3.45688537e-02f,
  -3.94886034e-03f, -3.41207534e-02f, -9.45300683e-02f, -6.89704418e-02f, 2.16248203e-02f, 5.49232122e-03f, 3.23376842e-02f, -1.44636584e-03f, -2.61220299e-02f, -2.89436281e-02f,
  -7.08700418e-02f, -3.46659832e-02f, 4.14198115e-02f, -5.44019742e-03f, -3.11093009e-03f, 1.66697711e-01f, 2.27306969e-02f, -1.32910497e-02f, 3.11692245e-02f, -6.11338392e-02f,
  -3.28357369e-01f, -1.28713638e-01f, -1.16549283e-01f, -2.41388768e-01f, 1.37394503e-01f, 2.45611131e-01f, 2.78733969e-01f, 8.21518674e-02f, -3.49357463e-02f, -6.37362525e-02f,
  1.97872147e-02f, 3.26316208e-02f, 1.51339434e-02f, 9.37523022e-02f, 1.21154785e-02f, 1.15988731e-01f, -2.27788347e-03f, -1.44040063e-01f, 1.23762883e-01f, 1.20207123e-01f,
  8.92580003e-02f, -1.44389257e-01f, -2.54205674e-01f, -1.42679170e-01f, -1.36090040e-01f, -4.38110940e-02f, -2.26457402e-01f, -1.35509029e-01f, -1.03334427e-01f, -2.23792985e-01f,
  -8.03557709e-02f, -2.29069740e-01f, 2.32583024e-02f, -1.36165157e-01f, -6.76261354e-03f, -4.77666408e-02f, 1.73222106e-02f, -1.03204727e-01f, -1.02069210e-02f, -1.42136902e-01f,
  -1.70579597e-01f, -7.33914673e-02f, 2.07451582e-02f, 8.97935126e-03f, -1.67790189e-01f, -2.87086843e-03f, -1.44295990e-01f, -1.66937009e-01f, 1.49681568e-02f, -7.60538355e-02f,
  -2.98097935e-02f, -3.42833735e-02f, -1.02920078e-01f, 5.97611405e-02f, -1.03313245e-01f, 6.55621290e-02f, 1.53170223e-03f, -2.81811580e-02f, 2.56762765e-02f, -2.10549265e-01f,
  5.67625687e-02f, -1.69902481e-02f, 2.54804287e-02f, 5.07902429e-02f, 2.64250692e-02f, -4.42152424e-03f, 8.28628242e-02f, -3.66283916e-02f, 8.23331922e-02f, 6.79505616e-02f,
  5.65501526e-02f, -2.70846970e-02f, 4.57935780e-02f, 3.85709181e-02f, -2.25462988e-02f, -2.27305554e-02f, 1.13723412e-01f, -1.58550926e-02f, -7.13445805e-03f, -3.81679051e-02f,
  3.32958773e-02f, -1.45556368e-02f, 3.30884405e-03f, -2.32359134e-02f, 5.76182716e-02f, -2.50376519e-02f, -1.47774825e-02f, -6.16428303e-03f, 6.84543252e-02f, 7.42571615e-03f,
  3.36550153e-03f, 2.02775486e-02f, -2.97634043e-02f, -4.14827913e-02f, -1.28765434e-01f, -6.50707260e-02f, -9.83403996e-02f, -9.81142968e-02f, -7.30845854e-02f, -1.21545494e-02f,
  -5.56784607e-02f, 5.74986869e-03f, -9.34622958e-02f, -1.31850079e-01f, -2.69395914e-02f, -2.27697100e-02f, -2.77126748e-02f, -1.16573386e-02f, 4.25946936e-02f, -7.05068111e-02f,
  2.45597400e-02f, 6.92878803e-03f, 1.04811534e-01f, 1.14972949e-01f, 6.56476095e-02f, 1.87606718e-02f, 1.10753536e-01f, 1.11640384e-02f, 4.29265052e-02f, 9.00293514e-02f,
  -5.01813293e-01f, -7.20322728e-02f, 7.42318481e-02f, -2.02714175e-01f, -7.75225982e-02f, -4.66309041e-02f, -2.20998853e-01f, -2.03228801e-01f, -1.67024985e-01f, 5.76215200e-02f,
  1.72898844e-01f, 2.56885588e-01f, 2.26658359e-01f, 7.64251202e-02f, -5.79560623e-02f, -8.88102204e-02f, 1.21720232e-01f, 6.91493675e-02f, 1.03127472e-01f, 1.28569990e-01f,
  1.94797263e-01f, -3.64210233e-02f, -9.03725252e-02f, -5.74352918e-03f, 8.88178274e-02f, 1.76979661e-01f, 1.19130246e-01f, 1.64387718e-01f, 1.44859120e-01f, 2.19945207e-01f,
  2.80346990e-01f, -2.47715518e-01f, -1.03525808e-02f, -1.10102538e-02f, 9.13587064e-02f, -3.43611538e-02f, -3.29991207e-02f, -6.38466775e-02f, -5.61483316e-02f, -1.10701635e-01f,
  5.44056743e-02f, 5.59779964e-02f, 2.43775938e-02f, 5.21561131e-02f, -9.29636955e-02f, 1.54355932e-02f, -3.72566469e-02f, 1.43598544e-03f, -3.59410308e-02f, 2.46550683e-02f,
  9.31775495e-02f, 5.35608754e-02f, 2.16788631e-02f, -1.77210756e-02f, -2.06697397e-02f, 1.13434354e-02f, -1.96518172e-02f, 3.67917418e-02f, -1.29399687e-01f, -8.75972360e-02f,
  -8.51048343e-03f, 1.49800465e-01f, 1.27912275e-02f, 7.18761533e-02f, -7.20892623e-02f, 3.90388966e-02f, 5.47940433e-02f, 2.26887520e-02f, 3.29364240e-02f, -2.39476059e-02f,
  -2.37671267e-02f, 1.48537278e-03f, 3.88899930e-02f, -2.58154720e-02f, 1.28633991e-01f, 1.90950390e-02f, 4.19762731e-02f, 6.17014393e-02f, 5.50544113e-02f, -2.15697996e-02f,
  -5.55291809e-02f, -1.04246009e-02f, 1.04345053e-01f, 2.44324133e-02f, 4.62088399e-02f, 5.44076264e-02f, 2.86096204e-02f, -3.26273814e-02f, -3.18456106e-02f, -2.36135162e-02f,
  -6.21905848e-02f, 8.08661245e-03f, -9.02599096e-02f, -5.86730614e-02f, -1.26123875e-01f, -5.24229556e-02f, -5.09112841e-03f, 1.60130933e-02f, 4.01532724e-02f, -4.08506021e-02f,
  2.25890316e-02f, -1.99348088e-02f, -3.38853523e-02f, 4.32101786e-02f, -5.65027520e-02f, -1.58220455e-02f, -5.67188449e-02f, -7.72496015e-02f, -3.39434892e-02f, -1.88707393e-02f,
  -3.60763445e-03f, -1.56397849e-01f, -3.67244147e-02f, -1.10261731e-01f, -7.25827878e-04f, -9.96683389e-02f, -6.07825220e-02f, -1.15749776e-01f, -1.46609753e-01f, -2.11333856e-01f,
  1.99964300e-01f, -6.27423823e-02f, 1.02014884e-01f, 1.75527651e-02f, 2.37419784e-01f, 5.59294038e-02f, 6.63936138e-02f, -5.33930473e-02f, -1.56188048e-02f, -6.12858236e-02f,
  -4.66435328e-02f, -1.70873716e-01f, -1.03156202e-01f, -1.59986690e-01f, -1.27354100e-01f, -3.76571044e-02f, -2.58303937e-02f, 4.84745242e-02f, 1.53858930e-01f, 9.78250355e-02f,
  1.52986765e-01f, 1.96544647e-01f, 1.20766863e-01f, -7.39765018e-02f, -1.46011621e-01f, -8.25169310e-02f, 2.25444734e-02f, 9.69192199e-03f, -6.68454543e-02f, -1.06231079e-01f,
  1.03866428e-01f, 4.55577075e-02f, 1.89664960e-02f, -2.62325052e-02f, 8.13404843e-02f, 3.77439335e-02f, -1.26567250e-03f, 6.18235394e-02f, 6.81181252e-02f, -4.07127738e-02f,
  -1.45741657e-03f, 6.68041557e-02f, -4.30042222e-02f, 3.97645347e-02f, 8.97924528e-02f, 2.74746958e-02f, -6.48686755e-03f, -1.00975379e-01f, -3.09348498e-02f, -5.95885888e-02f,
  -3.32738496e-02f, 1.76722512e-01f, 2.51320675e-02f, 5.81077971e-02f, -1.46726251e-01f, 2.09921543e-02f, -5.65070882e-02f, -9.38322321e-02f, 5.32599948e-02f, -1.15410611e-03f,
  4.12028730e-02f, -3.80966850e-02f, -6.54085129e-02f, -6.24437220e-02f, -9.82364044e-02f, -1.92461699e-01f, -1.11628748e-01f, -8.54042619e-02f, -1.34308726e-01f, -6.68490604e-02f,
  -6.54141307e-02f, -2.87187342e-02f, -8.69911984e-02f, -1.71268806e-01f, -1.17553852e-01f, -5.53923361e-02f, -1.21170551e-01f, -8.45032707e-02f, -3.73120531e-02f, -8.56383219e-02f,
  -1.22383118e-01f, -1.73293471e-01f, -5.89608438e-02f, -1.53304026e-01f, -6.52906150e-02f, -1.37000665e-01f, -1.47019804e-01f, -1.61215141e-01f, -1.42771780e-01f, -1.12956464e-01f,
  -6.39376417e-02f, 1.24456063e-01f, -4.28620465e-02f, -6.04710951e-02f, 2.72199046e-02f, 3.56857888e-02f, 7.10538849e-02f, 6.68205991e-02f, 7.93259516e-02f, 6.41128793e-03f,
  2.96399947e-02f, -8.68313611e-02f, -5.02009951e-02f, -2.02659033e-02f, 7.03589022e-02f, 3.43601033e-02f, 5.54092117e-02f, 9.91684124e-02f, 8.83105248e-02f, -3.63141522e-02f,
  2.58563161e-02f, 1.23285264e-01f, 6.34725243e-02f, -6.43374547e-02f, -2.98303366e-02f, -5.90146333e-02f, 8.18800777e-02f, -4.60592248e-02f, 6.09802455e-02f, 1.47333965e-01f,
  1.57780364e-01f, 1.61739200e-01f, -6.19938672e-02f, 2.30555445e-01f, 1.72874108e-01f, -1.01242393e-01f, -1.41404137e-01f, 6.51516020e-02f, 1.55940518e-01f, 2.14161754e-01f,
  2.15085030e-01f, 1.02342308e-01f, -7.78345466e-02f, -1.11017890e-01f, -2.39936098e-01f, -2.18217164e-01f, -1.04231663e-01f, -3.25185865e-01f, -3.85376513e-01f, -2.11605579e-01f,
  3.64739983e-03f, 8.73542354e-02f, 7.34346509e-02f, 8.87613893e-02f, 2.77571082e-01f, 7.01763555e-02f, 1.47911534e-01f, 2.08730534e-01f, 1.05314264e-02f, 2.06144080e-01f,
  -4.94547598e-02f, 1.91352874e-01f, -3.74630699e-03f, 3.14223990e-02f, 1.11587361e-01f, 7.02244043e-03f, 3.65581736e-02f, 7.26531446e-02f, 6.84072003e-02f, 5.74484766e-02f,
  1.62118688e-01f, 1.44152716e-02f, 1.23774998e-01f, 1.03540778e-01f, 1.57357574e-01f, 4.38325070e-02f, 1.01757810e-01f, -2.55897939e-02f, 3.09304614e-02f, 1.25753045e-01f,
  2.37789471e-02f, 1.98073670e-01f, 1.13998272e-01f, 3.37673426e-02f, 9.77075472e-02f, -5.57268262e-02f, 4.02624793e-02f, 2.61789896e-02f, 1.23829702e-02f, 8.02321732e-02f,
  -3.61424536e-02f, -4.08309661e-02f, -7.33165815e-02f, -7.09192967e-03f, -9.58525762e-02f, -5.12957759e-02f, -5.90684861e-02f, -6.24357611e-02f, -7.11186305e-02f, -1.12590566e-01f,
  -1.03958547e-02f, -4.06831838e-02f, -8.95461291e-02f, -9.10839364e-02f, -4.45129834e-02f, -1.22730635e-01f, -5.23520336e-02f, -5.39158285e-02f, -9.61231366e-02f, 6.76280484e-02f,
  -1.09213904e-01f, -8.31074566e-02f, 1.88736934e-02f, -1.69070408e-01f, -6.26076311e-02f, -6.65786117e-02f, -1.30904866e-02f, -6.87106885e-03f, -7.00414600e-03f, -4.49004918e-02f,
  1.52632356e-01f, -7.56014660e-02f, 6.54466376e-02f, 1.66913792e-02f, 1.03966579e-01f, 1.26364529e-01f, 1.27529144e-01f, -1.96951330e-02f, 1.35200575e-01f, 4.40335795e-02f,
  4.09530699e-02f, 6.79426119e-02f, 2.37127878e-02f, 3.34822163e-02f, 3.56127992e-02f, 4.55687568e-02f, 2.90183928e-02f, 1.84265543e-02f, -2.03810632e-02f, 6.57644421e-02f,
  1.05824664e-01f, 1.45339090e-02f, -1.10832766e-01f, -2.05612294e-02f, 5.32066375e-02f, 3.22640836e-02f, -9.56132710e-02f, -2.61308439e-03f, -4.88794968e-02f, -5.35911275e-03f,
  -6.06959080e-03f, -9.00959969e-02f, -8.15255642e-02f, -1.42669991e-01f, -1.49804652e-01f, -5.75925857e-02f, -6.50798827e-02f, 8.38335231e-02f, 4.30477150e-02f, 2.40660682e-02f,
  1.03499115e-01f, 2.51076400e-01f, 2.70323306e-01f, 1.21200733e-01f, 2.11705104e-01f, -2.75776465e-03f, -1.94754019e-01f, 6.94692358e-02f, 7.79106021e-02f, 1.75564352e-03f,
  4.62295897e-02f, -1.02649502e-01f, -2.13678386e-02f, -3.20674814e-02f, -3.52445431e-02f, 6.65413067e-02f, -9.44859684e-02f, -1.20941319e-01f, 6.62102178e-03f, -1.53970152e-01f,
  2.36832708e-01f, -1.86729692e-02f, 7.00795501e-02f, 5.53919263e-02f, 5.03318459e-02f, 1.29205152e-01f, -7.69993197e-03f, 1.43805472e-03f, 1.13391988e-01f, 8.85222293e-03f,
  2.09484645e-03f, 2.35810205e-02f, -1.68338306e-02f, 9.76187512e-02f, 1.20235607e-01f, 3.82257072e-04f, 9.54458937e-02f, 1.16877265e-01f, 8.62736851e-02f, 1.29784435e-01f,
  -3.68643142e-02f, 4.34363959e-03f, -3.59101109e-02f, 1.21359974e-01f, 8.51571038e-02f, -3.63952434e-03f, -2.93526426e-02f, 1.29069969e-01f, 1.07552849e-01f, -4.25964408e-02f,
  5.95220029e-02f, -4.07525189e-02f, 3.62103581e-02f, -7.84115121e-02f, -2.82880012e-02f, 1.64850503e-02f, -9.73985717e-02f, -1.24721184e-01f, 8.56514741e-03f, -9.48848650e-02f,
  -8.97845104e-02f, -1.23359971e-02f, -1.04828306e-01f, -8.96822289e-02f, -1.66043520e-01f, -1.70979887e-01f, -8.75286385e-02f, -6.65885732e-02f, -1.06808834e-01f, -2.29463875e-02f,
  -1.33128641e-02f, -1.00412004e-01f, -5.70849814e-02f, -4.13504951e-02f, -3.11129000e-02f, -4.28095423e-02f, -1.20784201e-01f, -8.79213139e-02f, -1.05674647e-01f, -1.37283444e-01f,
  2.07697421e-01f, 4.79008071e-02f, 3.03801484e-02f, 1.08139545e-01f, -8.65243971e-02f, 4.10670564e-02f, 3.41574512e-02f, -2.12101415e-02f, 4.14239168e-02f, 1.69986472e-01f,
  1.67055130e-01f, 5.00564724e-02f, -5.90343261e-04f, 5.78431599e-02f, 3.79170142e-02f, 3.45429704e-02f, -1.75913367e-02f, 5.18786348e-02f, -1.49753494e-02f, 1.02909155e-01f,
  1.06108338e-02f, 8.25029798e-03f, -4.36087511e-02f, 6.48044199e-02f, 2.69021913e-02f, 2.14492418e-02f, 1.01229444e-01f, -4.56910580e-02f, -7.05131330e-03f, -1.53249381e-02f,
  7.33300373e-02f, -1.26564592e-01f, -6.29759952e-02f, -4.35364209e-02f, 1.78480387e-01f, -8.53599608e-03f, -2.74932027e-01f, -2.10240707e-01f, -5.88170625e-02f, -1.19129933e-01f,
  1.75599128e-01f, 2.40195110e-01f, 2.92216409e-02f, 8.99952557e-03f, -1.12804182e-01f, -3.25983107e-01f, -3.48782450e-01f, -1.75008714e-01f, -7.32956976e-02f, -7.05630109e-02f,
  8.20488483e-02f, 6.90115318e-02f, 1.54384905e-02f, -8.63328353e-02f, 5.62581867e-02f, 3.30894031e-02f, -4.30490896e-02f, -2.05796156e-02f, -6.32084161e-02f, -4.23423424e-02f,
  -4.61224429e-02f, -7.29442248e-03f, 3.71091478e-02f, 9.93477255e-02f, 3.75694297e-02f, -1.27993762e-01f, -6.52599782e-02f, -1.66367050e-02f, 4.31620218e-02f, -7.75156589e-03f,
  3.82193886e-02f, 2.10659718e-03f, -6.85858876e-02f, 3.63319963e-02f, -1.24391258e-01f, -3.57600637e-02f, -1.50122419e-01f, -9.56348702e-02f, -1.20874062e-01f, -3.73868085e-02f,
  -5.32505475e-03f, 1.37356773e-01f, -5.22965752e-02f, -1.18219733e-01f, -1.07741185e-01f, 2.73628422e-04f, -1.60946585e-02f, -9.57923159e-02f, -7.26888925e-02f, -2.10935608e-01f,
  -3.41102742e-02f, 5.43064214e-02f, 1.19051009e-01f, 3.49023789e-02f, 8.45111459e-02f, 1.01172403e-01f, 1.31194945e-02f, 4.31383550e-02f, 3.45167108e-02f, -3.19252387e-02f,
  6.46003783e-02f, 6.60826564e-02f, 1.45814987e-02f, 3.42666768e-02f, 1.16836149e-02f, 2.18135864e-02f, 9.16752070e-02f, 7.18373060e-02f, 7.64063597e-02f, 2.74940543e-02f,
  1.42251914e-02f, 1.11747943e-01f, 1.04474843e-01f, -5.45587353e-02f, 1.56752802e-02f, -6.17276989e-02f, 7.65790269e-02f, 2.68385354e-02f, -3.00132111e-02f, -4.08368371e-02f,
  1.61043331e-01f, 1.50404051e-01f, -4.91107292e-02f, -7.48598427e-02f, 2.01222133e-02f, 2.15104371e-02f, 1.02219120e-01f, 4.63556610e-02f, 7.92083815e-02f, -8.57255906e-02f,
  1.08446240e-01f, 2.68093869e-02f, -5.38554415e-02f, -6.10750876e-02f, -2.38903519e-02f, 5.82932271e-02f, -5.45609742e-02f, 2.16526538e-02f, 6.89285696e-02f, 1.26346216e-01f,
  6.41754940e-02f, -5.67216575e-02f, 1.69003289e-02f, -4.81709931e-03f, 8.74942094e-02f, 1.17721654e-01f, 4.69944179e-02f, -3.49391773e-02f, -5.20311445e-02f, -1.81663260e-01f,
  -2.92249888e-01f, 8.22472945e-03f, -2.32643098e-01f, -2.98096985e-01f, -1.31572768e-01f, -1.65468618e-01f, -1.52655199e-01f, -8.12218487e-02f, -8.43831003e-02f, -1.28383204e-01f,
  -5.82723469e-02f, -1.88554734e-01f, -2.59719878e-01f, -2.40567759e-01f, -2.39915669e-01f, -2.46939316e-01f, -3.41044188e-01f, -3.53591979e-01f, -3.14572573e-01f, -1.11537144e-01f,
  -1.76659197e-01f, -2.26400167e-01f, -1.89347982e-01f, -2.90667593e-01f, -2.15547815e-01f, -1.36764944e-01f, -2.38179773e-01f, -1.49698183e-01f, -1.64511397e-01f, -1.83582902e-01f,
  -3.19043308e-01f, -8.32041651e-02f, -8.08899254e-02f, -8.77472460e-02f, -3.44115086e-02f, -5.14956526e-02f, -2.79711038e-02f, -1.60059631e-01f, -9.54776779e-02f, -9.63885635e-02f,
  -1.79595232e-01f, -1.25707939e-01f, -4.10718285e-02f, -2.03667775e-01f, -8.86151269e-02f, -9.57790241e-02f, -2.17205971e-01f, -1.80132151e-01f, -2.18242377e-01f, -6.78425282e-02f,
  -1.50683299e-01f, -1.75337419e-01f, -4.33015861e-02f, -9.78167281e-02f, -9.34280232e-02f, -9.71719548e-02f, -5.79463802e-02f, -2.98108011e-02f, -9.70877036e-02f, -1.15304142e-01f,
  7.31271356e-02f, 6.70104474e-02f, 4.98272181e-02f, 1.39253348e-01f, 3.65316793e-02f, 7.37800971e-02f, 3.01554184e-02f, 4.27647717e-02f, 5.30505143e-02f, 1.58541858e-01f,
  -5.42399753e-03f, 1.64793193e-01f, 4.13957760e-02f, 2.78764181e-02f, 6.93002641e-02f, 4.14806679e-02f, 6.14614561e-02f, 6.72158301e-02f, 4.35333699e-02f, 8.55981782e-02f,
  1.29833475e-01f, 2.46220566e-02f, 7.35290796e-02f, 2.86889710e-02f, 2.62866169e-02f, 2.23772489e-02f, -4.12599649e-03f, 1.74033344e-01f, 6.67484030e-02f, 5.79338223e-02f,
  -8.23727027e-02f, 4.03428748e-02f, -1.96703270e-01f, -9.19223949e-02f, -1.14539258e-01f, -7.33800605e-02f, -6.18570186e-02f, -9.47336778e-02f, -1.01303175e-01f, -1.05721235e-01f,
  2.53822096e-02f, -6.13741316e-02f, -1.49609536e-01f, -4.49614413e-02f, -5.95463738e-02f, -4.69553955e-02f, -3.88354100e-02f, -2.12941796e-01f, -3.90588045e-02f, -2.43870448e-02f,
  -6.69427142e-02f, 1.06167998e-02f, -2.47947406e-02f, -6.59714192e-02f, -1.00629538e-01f, 4.95379791e-03f, -1.32637188e-01f, -7.54215792e-02f, -7.28794038e-02f, -3.64740491e-02f,
  2.64511853e-01f, -5.01296036e-02f, 2.11977568e-02f, 1.92409307e-01f, -2.85302009e-03f, -1.30614892e-01f, -7.85966739e-02f, 1.97376218e-02f, 1.59011111e-01f, 1.62706986e-01f,
  2.16366902e-01f, 2.88757741e-01f, 2.81605959e-01f, 1.98353291e-01f, 1.28390476e-01f, 2.21650004e-02f, 1.77798763e-01f, 1.05099961e-01f, 1.81528702e-01f, 8.45418349e-02f,
  5.65828234e-02f, 8.29921216e-02f, 6.69017807e-02f, 9.41948965e-02f, -1.78152490e-02f, 2.30667591e-01f, 9.22479201e-03f, -4.70720157e-02f, 7.64915943e-02f, 1.71736583e-01f,
  2.55218029e-01f, -7.98784643e-02f, 1.23271652e-01f, 2.69175172e-01f, 3.26000564e-02f, 8.45363215e-02f, 1.61815286e-01f, 8.76690522e-02f, 1.79947689e-01f, 6.73984438e-02f,
  1.77600488e-01f, 1.68697372e-01f, 1.93358839e-01f, 7.20137730e-02f, 1.55528918e-01f, 4.83337343e-02f, 3.85065489e-02f, 1.09280385e-01f, 9.80183110e-02f, 1.23084523e-01f,
  1.40629873e-01f, 1.67818628e-02f, 7.11954236e-02f, 3.71531062e-02f, -7.11928830e-02f, 1.33329794e-01f, 1.13842282e-02f, 2.89209411e-02f, 1.80740617e-02f, 1.32161930e-01f,
  6.69225398e-03f, -1.35931134e-01f, -1.63009331e-01f, -4.75229323e-02f, -1.00816272e-01f, -5.58319502e-02f, -1.61194235e-01f, -1.08400829e-01f, -1.33693174e-01f, -1.42082646e-01f,
  -1.70152903e-01f, -5.76553307e-02f, -4.19164002e-02f, -4.19528782e-02f, -1.18577302e-01f, -1.19872548e-01f, -7.78585374e-02f, -1.26050264e-01f, -1.44553930e-01f, -1.47922114e-01f,
  -9.31725875e-02f, -1.07280791e-01f, -6.71780780e-02f, -6.88827559e-02f, -1.18259914e-01f, -1.32023126e-01f, -1.57054037e-01f, -1.44339159e-01f, -1.91035643e-01f, -1.19090423e-01f,
  1.72084749e-01f, -1.64406877e-02f, 2.60565698e-01f, 8.45486894e-02f, 6.06247410e-02f, 1.13553822e-01f, 1.95072234e-01f, 1.65469915e-01f, 6.42801598e-02f, 2.06843138e-01f,
  -1.70892756e-02f, 6.66128099e-02f, 1.61042899e-01f, 8.26885402e-02f, 8.79130289e-02f, 6.68768212e-02f, 9.09253657e-02f, 1.57335728e-01f, 5.00245802e-02f, 7.76001289e-02f,
  8.25451314e-02f, 2.65592456e-01f, 2.57589489e-01f, 2.13127658e-01f, 1.16117246e-01f, 2.40881428e-01f, 1.80474773e-01f, 1.14228569e-01f, 1.98485985e-01f, 2.91126251e-01f,
  6.73124343e-02f, -2.60536056e-02f, -2.53870070e-01f, 3.55734577e-04f, -3.73169541e-01f, -3.12724769e-01f, -2.02092871e-01f, 1.22156374e-01f, 2.37853527e-02f, 3.18673588e-02f,
  -1.34136081e-01f, -1.23698160e-01f, -4.32010880e-03f, 1.15523279e-01f, 8.71652365e-02f, -7.80565143e-02f, -5.45803234e-02f, -7.02960268e-02f, -1.32000551e-01f, -1.74018845e-01f,
  -1.55362323e-01f, -1.05403811e-01f, -4.23714193e-03f, 6.76399395e-02f, -9.89709496e-02f, -1.24561742e-01f, 4.30931002e-02f, -1.40287772e-01f, -1.68833271e-01f, -2.34467253e-01f,
  -2.83388317e-01f, -2.56961351e-03f, -6.55303970e-02f, -1.40262144e-02f, -1.91858575e-01f, 2.51543112e-02f, -7.94086605e-03f, -9.85164568e-03f, -3.01869195e-02f, -1.04934506e-01f,
  -1.64762303e-01f, -1.62146278e-02f, -1.52295768e-01f, 3.94830815e-02f, -9.44692865e-02f, 2.57627927e-02f, 9.39644128e-02f, 1.23509280e-01f, -3.72907221e-02f, -9.39855874e-02f,
  -1.91870317e-01f, -2.56868422e-01f, -1.14797741e-01f, 1.46074034e-02f, 8.36416557e-02f, -9.81622338e-02f, -1.26410827e-01f, 1.22963719e-03f, -7.69079924e-02f, 1.10204339e-01f,
  6.16963953e-02f, 1.14415251e-01f, -2.88801407e-03f, -2.04624385e-02f, 8.76659527e-02f, 3.30483280e-02f, 6.43900782e-02f, -6.32990804e-03f, 4.70024459e-02f, 4.14353535e-02f,
  1.53815001e-01f, -4.29265294e-03f, 7.69308731e-02f, -2.72628609e-02f, 5.49681298e-02f, 1.50037566e-02f, -9.85868201e-02f, 1.29907832e-01f, 2.19572354e-02f, 1.71902310e-02f,
  -7.03894943e-02f, 6.64558038e-02f, -2.28457693e-02f, 9.72153842e-02f, -3.94972973e-03f, 7.73296952e-02f, -2.64685322e-02f, 7.47469738e-02f, -5.52509464e-02f, -3.65242735e-02f,
  9.76693910e-03f, -3.31200287e-02f, -1.33479442e-02f, -8.07199627e-03f, -9.08637047e-02f, -5.26100444e-03f, -2.13665236e-02f, 6.85308129e-02f, -1.42035440e-01f, -6.70627877e-02f,
  2.79541630e-02f, -4.44426090e-02f, 4.14006971e-02f, -5.32421060e-02f, -1.12364590e-02f, -9.74296033e-02f, 3.83142270e-02f, -4.74682078e-02f, -2.69411039e-02f, 1.22217108e-02f,
  1.79113206e-02f, -1.07223727e-01f, -1.25388401e-02f, -6.56099319e-02f, -5.29591925e-02f, -9.23696905e-02f, -8.80778879e-02f, -1.95753332e-02f, -8.09351280e-02f, 1.26570672e-01f,
  4.65185165e-01f, -4.55632880e-02f, 1.72318481e-02f, 1.95609629e-02f, -2.14560419e-01f, -1.59825742e-01f, -2.19779655e-01f, -1.02923095e-01f, 2.49385796e-02f, -8.80278796e-02f,
  -1.95854101e-02f, 2.19183080e-02f, 9.92293656e-02f, 1.87048465e-02f, 1.56622291e-01f, -1.54079914e-01f, -1.42559987e-02f, 2.09188089e-01f, 1.60472140e-01f, -8.47138911e-02f,
  -1.04594328e-01f, 1.62962884e-01f, 1.71424940e-01f, 1.13029607e-01f, -2.19563097e-01f, -8.27519037e-03f, -1.09166980e-01f, -5.36145940e-02f, -1.71780333e-01f, -1.52608439e-01f,
  -3.78213190e-02f, -4.46947403e-02f, -7.19344765e-02f, -5.90702891e-02f, -5.58580644e-02f, -7.51025882e-03f, -4.81397994e-02f, -2.99756080e-02f, -3.56446169e-02f, -8.76125097e-02f,
  -1.02593869e-01f, -3.00841425e-02f, -1.17839962e-01f, -1.61221504e-01f, -1.02904230e-01f, -1.65061653e-02f, -2.45832670e-02f, -4.47414815e-03f, -1.02722906e-01f, -8.07093009e-02f,
  -1.63992956e-01f, -6.77113831e-02f, -1.37793288e-01f, -8.98684785e-02f, -1.51266918e-01f, -7.79169658e-03f, -2.77533811e-02f, -1.69862300e-01f, -9.58703384e-02f, -8.78210068e-02f,
  1.48384273e-01f, 2.04688450e-03f, 6.26117438e-02f, 3.19417678e-02f, 5.87469898e-02f, 6.80698231e-02f, -7.61763826e-02f, 2.86214892e-02f, -2.57325582e-02f, 8.98936912e-02f,
  3.02252378e-02f, -2.66815480e-02f, 8.37311968e-02f, 3.90342176e-02f, 1.42226536e-02f, 1.48140118e-02f, 3.40795668e-04f, 1.27375036e-01f, -2.76511349e-02f, -1.17666414e-02f,
  1.80102661e-02f, -4.40344177e-02f, 6.89321607e-02f, 8.93852338e-02f, -2.75057256e-02f, 3.46152149e-02f, 7.02591091e-02f, 4.85319048e-02f, -2.12054942e-02f, 5.16677089e-02f,
  1.38455525e-01f, 1.10222347e-01f, -1.00431591e-01f, -3.65251973e-02f, -9.41186547e-02f, 3.58458534e-02f, 1.47073483e-03f, -3.81070189e-02f, -6.29036799e-02f, -9.26918387e-02f,
  -6.20285422e-03f, 4.23971079e-02f, 2.46244222e-02f, -1.07447863e-01f, -4.12185676e-02f, -3.46839726e-02f, 5.50496057e-02f, -7.70829841e-02f, -3.37787755e-02f, -8.26588422e-02f,
  -9.20370147e-02f, -9.18305665e-02f, 7.67293945e-03f, -1.27516799e-02f, -5.08189574e-02f, 4.32834923e-02f, -7.91979507e-02f, -1.25186481e-02f, 1.48216998e-02f, 6.76883236e-02f,
  -4.67361599e-01f, -1.06394261e-01f, -6.78049549e-02f, -3.69025111e-01f, 1.54128624e-02f, 1.67658404e-01f, 1.76708862e-01f, 4.68817167e-02f, -1.39058501e-01f, -5.62965348e-02f,
  2.23440334e-01f, 3.36522944e-02f, 2.86041610e-02f, 1.68618515e-01f, 1.73966631e-01f, -1.11222386e-01f, -1.55596554e-01f, -9.73948091e-02f, 1.71612769e-01f, 8.72644410e-02f,
  1.01294341e-02f, -1.54945776e-01f, -7.03889057e-02f, 2.71653086e-02f, -7.85530210e-02f, 1.83697045e-02f, -1.00404456e-01f, -9.54585895e-02f, 1.31836325e-01f, -1.73653513e-01f,
  -4.44100387e-02f, 1.17815835e-02f, 1.31701529e-01f, 4.87256842e-03f, 1.32828178e-02f, 1.20957442e-01f, -1.43981986e-02f, 4.68475483e-02f, 9.36315730e-02f, -2.03703083e-02f,
  7.61981159e-02f, 6.71859598e-03f, 6.27658889e-02f, 3.92605029e-02f, 4.51204926e-02f, 1.12974919e-01f, 1.04276024e-01f, 6.48951977e-02f, 6.42146543e-02f, 4.93062027e-02f,
  8.04699063e-02f, 1.17253307e-02f, 7.90113024e-03f, 1.22784950e-01f, 6.31873682e-02f, 1.29868656e-01f, 1.33168980e-01f, 5.08941971e-02f, 2.62317389e-01f, -1.23921715e-01f,
  -4.49194424e-02f, -4.59002033e-02f, -4.92469855e-02f, -1.45653905e-02f, -4.33775745e-02f, -1.36280030e-01f, -5.61781041e-02f, -8.49259272e-02f, -7.70353749e-02f, -1.09091714e-01f,
  -8.36575180e-02f, 3.24679837e-02f, -9.68241543e-02f, -1.33743078e-01f, 1.70851350e-02f, -6.21793121e-02f, -1.39608428e-01f, -6.69905096e-02f, -4.86155637e-02f, -7.95773715e-02f,
  -7.00014532e-02f, -7.26468191e-02f, -3.10650449e-02f, -1.71405189e-02f, -5.16249985e-02f, -4.06843796e-02f, -4.63741347e-02f, -2.88178977e-02f, -8.87126178e-02f, -1.39794990e-01f,
  -1.07281908e-01f, 2.39450455e-01f, -1.27147719e-01f, 6.72527626e-02f, 6.08963370e-02f, 7.94252306e-02f, -1.32320328e-02f, 5.87786920e-02f, 1.55622642e-02f, -2.20762808e-02f,
  5.27051724e-02f, 6.58946782e-02f, -5.81554100e-02f, 7.50910193e-02f, 6.71158358e-02f, 5.11925519e-02f, 4.59505171e-02f, 3.37414630e-02f, 1.61740720e-01f, 3.48731726e-02f,
  8.40366632e-02f, -1.85599625e-02f, -1.44100755e-01f, 6.81775957e-02f, -1.12487609e-02f, 3.36276926e-02f, -6.78531528e-02f, 5.13375849e-02f, 7.23691583e-02f, -1.11771762e-01f,
  -2.96722818e-02f, 4.43852060e-02f, -4.69600270e-03f, -9.32456478e-02f, -1.88097097e-02f, 2.39956945e-01f, 2.36431688e-01f, 1.70799494e-02f, -1.36740580e-01f, 1.37086380e-02f,
  4.73278575e-02f, 9.73597635e-03f, 1.37140781e-01f, 2.44456958e-02f, 1.40805721e-01f, 1.30512923e-01f, -6.70498656e-03f, 7.88157955e-02f, 9.44708753e-03f, -7.59257153e-02f,
  -1.51335239e-01f, -2.40813300e-01f, -1.83623925e-01f, -9.28738564e-02f, -2.89116442e-01f, -1.69249579e-01f, -1.56909943e-01f, -1.27034560e-01f, 1.06042298e-02f, -2.99198329e-01f,
  -2.91017555e-02f, -7.56597966e-02f, 2.70733126e-02f, -8.84401351e-02f, -4.58765887e-02f, -3.76639776e-02f, -1.01903997e-01f, -1.17626779e-01f, -1.35314763e-01f, -1.44574732e-01f,
  -9.85121354e-02f, -6.28027543e-02f, -5.31852581e-02f, -1.28903002e-01f, -7.34627917e-02f, -9.36467722e-02f, -2.04435885e-01f, -6.86742961e-02f, -8.31886455e-02f, -5.76761318e-03f,
  -6.68423474e-02f, -8.70125741e-03f, -1.37217762e-03f, -1.35826655e-02f, -2.80491170e-02f, -1.34396190e-02f, -5.05371839e-02f, -1.30685732e-01f, 2.12616790e-02f, -1.50272459e-01f,
  -9.87608954e-02f, 1.23853296e-01f, 1.22687602e-02f, 1.15031101e-01f, 1.59581840e-01f, 4.32061478e-02f, 1.27678797e-01f, 7.84980729e-02f, 4.87796478e-02f, 8.68156273e-03f,
  3.81242074e-02f, 1.45488963e-01f, 5.05577959e-02f, 7.99451992e-02f, 1.01480156e-01f, 3.82830277e-02f, 1.19039305e-01f, 4.62974049e-02f, 1.05568089e-01f, 1.29517376e-01f,
  1.06764182e-01f, 9.45495591e-02f, 7.91035146e-02f, 5.11322208e-02f, 1.30919486e-01f, 6.95408359e-02f, 9.23638716e-02f, 5.64249381e-02f, 1.58349108e-02f, 8.56389757e-03f,
  -8.19408298e-02f, 5.78808673e-02f, 1.50753688e-02f, -9.96843074e-03f, -1.43790424e-01f, -6.18876070e-02f, -6.38326630e-02f, 1.50557915e-02f, -3.16191129e-02f, -6.14786372e-02f,
  -1.06048137e-02f, 5.90244308e-02f, -1.23104844e-02f, -4.78887819e-02f, -6.40533632e-03f, -1.18610129e-01f, -5.28153628e-02f, 7.64717832e-02f, 6.10226803e-02f, -1.70172110e-01f,
  -1.03728056e-01f, -1.12266699e-02f, 1.65407464e-01f, 1.24686100e-01f, 3.51045020e-02f, 1.79811388e-01f, 2.91801281e-02f, 7.26194084e-02f, 3.08982264e-02f, 1.33196721e-02f,
  -1.82758942e-01f, -7.96806887e-02f, 1.75506368e-01f, 7.31053576e-02f, 1.44728236e-02f, 1.62387967e-01f, 7.75999278e-02f, -3.44408266e-02f, -2.49739885e-02f, -8.69176984e-02f,
  -2.41198987e-02f, -1.02724276e-01f, -1.31169497e-03f, -1.06685854e-01f, -7.52814785e-02f, -3.79418023e-02f, 1.49476632e-01f, -3.32763344e-02f, 6.59915106e-03f, -1.94609780e-02f,
  2.59017330e-02f, -7.75066093e-02f, -2.24480361e-01f, -4.84293364e-02f, -8.19802359e-02f, -3.93781886e-02f, -1.97499488e-02f, -3.23495381e-02f, -8.08531791e-02f, 2.39678454e-02f,
  -3.24922614e-02f, -1.86949611e-01f, -1.08375654e-01f, -1.99554265e-01f, -9.51224416e-02f, -1.78130805e-01f, -1.92918018e-01f, -1.34148508e-01f, -1.50060266e-01f, -5.21294363e-02f,
  -6.26037195e-02f, -1.30752444e-01f, -1.48405805e-01f, -8.10938329e-02f, -9.44198221e-02f, -1.79364890e-01f, -2.58469284e-01f, -9.10255164e-02f, -7.97616094e-02f, -9.04783681e-02f,
  -1.55344129e-01f, -1.78480744e-01f, -1.08926140e-01f, -6.26976267e-02f, -9.50022861e-02f, -1.08946450e-02f, -1.34120062e-01f, -7.52248988e-02f, -1.10333160e-01f, -1.72764018e-01f,
  1.26201212e-01f, 1.34371743e-01f, 1.51100293e-01f, 3.33177038e-02f, 7.76093006e-02f, 7.93821514e-02f, 1.29836783e-01f, 8.89009684e-02f, 3.37398648e-02f, 5.20786643e-02f,
  1.12393007e-01f, 2.10837543e-01f, 1.56635568e-01f, 2.97353193e-02f, 5.41012548e-02f, 1.54845014e-01f, 8.54640454e-02f, 3.54757495e-02f, 8.19418021e-03f, 1.30237773e-01f,
  1.37010366e-01f, 1.19650185e-01f, 1.35801449e-01f, 6.43882081e-02f, 7.94881359e-02f, 2.09381312e-01f, 1.97280943e-01f, 5.58750965e-02f, 3.51104289e-02f, 1.23979971e-01f,
  -1.91094458e-01f, -2.40712170e-03f, -3.81165966e-02f, -2.44284287e-01f, -8.90819505e-02f, -1.61284760e-01f, -6.80343434e-02f, -1.25563920e-01f, -9.82577354e-02f, -7.64002204e-02f,
  -1.27438650e-01f, -2.09984094e-01f, -2.00469047e-01f, -1.62583709e-01f, -8.33391920e-02f, -1.60042912e-01f, -1.37581378e-01f, -4.83977757e-02f, -9.37031582e-02f, -2.28946090e-01f,
  -1.18763700e-01f, -1.54759854e-01f, -1.14003465e-01f, -2.75724605e-02f, -1.42384097e-01f, -1.37789637e-01f, -1.54123351e-01f, -1.41225964e-01f, -4.92780767e-02f, -6.12704307e-02f,
  1.63386196e-01f, 3.66987526e-01f, -5.68392500e-02f, 3.44854482e-02f, 6.35923371e-02f, 1.06316358e-01f, 3.23952675e-01f, 2.39489093e-01f, 8.13272968e-02f, 1.59542412e-01f,
  3.41263860e-01f, 1.63570359e-01f, 1.43965229e-01f, 1.51650876e-01f, 1.25864908e-01f, 3.50908609e-03f, -1.15966909e-01f, 5.96922403e-03f, -3.82197276e-02f, 1.59309536e-01f,
  5.86784855e-02f, 6.76251277e-02f, 4.98734675e-02f, 3.35113034e-02f, -3.10256192e-03f, 9.11829248e-02f, 1.10436141e-01f, 8.23528394e-02f, 8.54708850e-02f, -6.88359588e-02f,
  -1.57155488e-02f, 3.58064651e-01f, 1.10985212e-01f, 1.69005886e-01f, 2.63545722e-01f, 1.52081460e-01f, 2.77741760e-01f, 2.52525866e-01f, 2.82700568e-01f, 2.01273084e-01f,
  1.69530332e-01f, 2.07249492e-01f, 1.77759752e-01f, 1.76797241e-01f, 1.59702078e-01f, 2.26753905e-01f, 2.18970865e-01f, 1.56155854e-01f, 1.09037340e-01f, 2.98714012e-01f,
  2.19491526e-01f, 2.36647993e-01f, 2.65825182e-01f, 2.57650048e-01f, 2.36827493e-01f, 1.99138865e-01f, 2.63747662e-01f, 2.27389827e-01f, 2.31261939e-01f, 2.11228624e-01f,
  -1.98735416e-01f, -1.69475004e-01f, -7.23828524e-02f, -8.53097960e-02f, -1.46338001e-01f, -6.54021874e-02f, -8.08063969e-02f, -1.48409858e-01f, -6.12678118e-02f, -5.07295541e-02f,
  -8.95275399e-02f, -1.45111099e-01f, -3.71600650e-02f, -1.66298840e-02f, -6.89886138e-02f, -1.08454555e-01f, -3.58295962e-02f, 1.43958488e-02f, -7.34758228e-02f, -1.20012596e-01f,
  -4.74800766e-02f, -3.19360383e-02f, -7.03179762e-02f, -2.65723113e-02f, -7.68610239e-02f, 6.42706901e-02f, -1.31002977e-01f, -2.89961845e-02f, 3.73685658e-02f, -1.13243453e-01f,
  2.67760813e-01f, 1.80255800e-01f, 1.56402633e-01f, 1.02603085e-01f, 2.14617044e-01f, 1.89797550e-01f, 2.40257531e-01f, 2.39933029e-01f, 1.68244407e-01f, 2.46753216e-01f,
  2.48772040e-01f, 1.30291745e-01f, 1.94653064e-01f, 1.78404763e-01f, 2.19523683e-01f, 1.55355796e-01f, 2.48701364e-01f, 6.16784208e-02f, 1.51860669e-01f, 1.78732261e-01f,
  2.82854617e-01f, 2.02154472e-01f, 7.94529095e-02f, 2.42032573e-01f, 1.44555300e-01f, 1.29996046e-01f, 1.97636694e-01f, 2.08146408e-01f, 2.35083595e-01f, 9.27094668e-02f,
  -6.15468509e-02f, 8.20850208e-02f, 3.67817760e-01f, -1.73923045e-01f, -1.36469863e-02f, 1.62678227e-01f, 2.84896135e-01f, 1.35192201e-01f, -7.18772113e-02f, 5.04471771e-02f,
  -5.08654341e-02f, -5.62795438e-02f, 1.68098230e-02f, -3.22480015e-02f, 1.85847625e-01f, 2.29703575e-01f, 1.74625725e-01f, 2.10977659e-01f, 1.82420939e-01f, -1.29485920e-01f,
  -2.70730704e-01f, -1.92243323e-01f, -1.03220567e-01f, -1.41809419e-01f, -9.79503244e-02f, 1.21866744e-02f, 1.38686657e-01f, -7.69255757e-02f, 1.33991152e-01f, -1.10414244e-01f,
  1.39240444e-01f, 2.09282897e-02f, 1.52502954e-03f, -1.67595431e-01f, -9.07239616e-02f, -8.94186199e-02f, -6.55236989e-02f, -4.52814028e-02f, -8.11140835e-02f, -4.74371016e-02f,
  -3.10125146e-02f, -1.70135587e-01f, -7.93604180e-02f, -9.00353342e-02f, -1.04970790e-01f, 1.73980482e-02f, -7.66681805e-02f, 6.15459960e-03f, 3.83362733e-02f, 1.02337776e-03f,
  -1.84254333e-01f, -5.52362539e-02f, 1.29399031e-01f, 1.47694163e-02f, 7.98572823e-02f, 7.12721795e-02f, 1.31030623e-02f, -1.15444772e-01f, 9.68379602e-02f, 1.33238127e-02f,
  -1.86863530e-03f, 5.42175374e-04f, -7.58103132e-02f, 7.69007504e-02f, 5.92519296e-03f, 3.12179979e-02f, -4.85195499e-03f, 3.56057808e-02f, 2.32002288e-02f, 4.78232987e-02f,
  8.09435472e-02f, -6.06695772e-04f, 4.96439412e-02f, 9.38947350e-02f, -7.39746168e-02f, -5.75547153e-03f, -2.74509415e-02f, 1.20908087e-02f, 2.19571888e-02f, 2.49061696e-02f,
  8.35428387e-03f, 2.54306872e-03f, 9.16174501e-02f, -8.78762230e-02f, 1.00154720e-01f, -1.47918332e-02f, 4.85959426e-02f, 9.27258357e-02f, 3.71504953e-04f, 1.53791690e-02f,
  -7.53227547e-02f, -3.91697399e-02f, 2.89279502e-02f, -9.02170539e-02f, 1.44145256e-02f, -1.05313055e-01f, -3.14330570e-02f, -6.17398098e-02f, -7.86059275e-02f, -4.81337458e-02f,
  -8.94625392e-03f, -8.05383623e-02f, -5.11155203e-02f, -6.30835295e-02f, -8.80424771e-03f, 5.61098289e-03f, -9.16628018e-02f, -3.06357816e-02f, -9.18881819e-02f, -1.38772652e-01f,
  -1.00304253e-01f, 1.20927423e-01f, 1.06989317e-01f, 5.24718426e-02f, 5.00228927e-02f, -6.90769311e-03f, 1.45952344e-01f, 1.18000388e-01f, 4.79279384e-02f, 8.81738067e-02f,
  3.57866049e-01f, 3.08569610e-01f, -6.79865899e-03f, 2.23766088e-01f, 2.64592260e-01f, 1.34702295e-01f, 3.45770627e-01f, 2.15700373e-01f, 2.29849696e-01f, 1.82461426e-01f,
  2.18130164e-02f, -8.18428956e-03f, -6.72013983e-02f, 4.19304296e-02f, 3.98448259e-02f, 2.24000975e-01f, 2.60114670e-01f, 5.54827377e-02f, 1.40945479e-01f, 1.28382355e-01f,
  1.12041906e-01f, 2.32565612e-01f, 1.94217429e-01f, 1.53259814e-01f, 2.39793658e-01f, 8.52614865e-02f, 1.71789393e-01f, 1.69939265e-01f, 1.12305172e-01f, 2.87540704e-01f,
  -1.91161200e-01f, 3.65285538e-02f, 1.27716377e-01f, 1.52516887e-01f, 1.07394997e-03f, 1.08924188e-01f, 1.53623030e-01f, 1.27055332e-01f, 1.80674031e-01f, 2.12566659e-01f,
  5.10796206e-03f, 5.62439486e-02f, 1.31057993e-01f, 1.66026443e-01f, 5.53018861e-02f, 1.64023727e-01f, 8.52591544e-02f, 1.89392403e-01f, 3.59374508e-02f, 1.56771407e-01f,
  1.12332322e-01f, 1.95386082e-01f, 1.48415715e-01f, 1.06963843e-01f, -5.87740354e-03f, 5.95747977e-02f, 1.25674069e-01f, 6.85920417e-02f, 5.24130054e-02f, 1.78907484e-01f,
  1.07304342e-01f, -2.11253017e-01f, -1.29723161e-01f, -1.36240438e-01f, -1.11457840e-01f, -1.85669228e-01f, -1.18674055e-01f, -2.15773284e-01f, -1.38321519e-01f, -6.02636039e-02f,
  -1.05555758e-01f, -2.07616165e-01f, -1.99554190e-01f, -1.50488645e-01f, -1.92767650e-01f, -1.41425461e-01f, -9.71796140e-02f, -8.85718539e-02f, -1.15429282e-01f, -1.13290533e-01f,
  -1.97472498e-01f, -1.40054658e-01f, -1.59022406e-01f, -1.84298709e-01f, -1.23570800e-01f, -1.73769802e-01f, -4.79093492e-02f, -1.66392297e-01f, -8.82848725e-02f, 2.21171603e-02f,
  4.93359417e-02f, -1.41406283e-01f, 1.56576440e-01f, 1.63782164e-01f, 1.89226434e-01f, 1.48497626e-01f, 1.01894744e-01f, 1.10730737e-01f, 2.91113146e-02f, 1.21873453e-01f,
  7.94135407e-02f, 1.17565624e-01f, 3.83149050e-02f, 1.98277444e-01f, 1.60194457e-01f, 1.47680894e-01f, 1.60825267e-01f, 1.50572896e-01f, 1.21358335e-01f, 9.99712944e-02f,
  1.67503193e-01f, 2.44794592e-01f, 2.47731984e-01f, 1.09615579e-01f, 1.46987021e-01f, 1.19679540e-01f, 1.76172435e-01f, 1.34323686e-01f, 1.37898266e-01f, 3.13374400e-01f,
  1.55534431e-01f, 2.23941073e-01f, -1.18132174e-01f, 2.30401888e-01f, -2.75289744e-01f, -3.13772142e-01f, -6.15876243e-02f, -8.94420296e-02f, 4.03057709e-02f, 1.00403786e-01f,
  -1.38600856e-01f, -9.18483287e-02f, -2.84898039e-02f, -1.65428877e-01f, 5.55881578e-03f, 1.62251648e-02f, -2.10800450e-02f, 4.18727286e-02f, -1.91762716e-01f, -2.74207387e-02f,
  6.99293390e-02f, 2.35031337e-01f, 1.34110197e-01f, 6.78999647e-02f, 6.10035881e-02f, -1.34601712e-01f, 4.63549383e-02f, 1.11812480e-01f, -1.08490929e-01f, 5.28121255e-02f,
  -1.40009224e-02f, 4.41110693e-02f, -1.26397476e-01f, 8.48490000e-03f, -1.31653011e-01f, 3.93001996e-02f, -8.37402360e-04f, -4.00043279e-03f, -5.18871471e-02f, -4.93174605e-02f,
  -4.94727381e-02f, 5.46651147e-02f, 4.68542837e-02f, -4.77207005e-02f, 6.00592196e-02f, 8.16019624e-02f, 2.63523534e-02f, 5.17444871e-02f, -7.76176006e-02f, 4.36963663e-02f,
  1.08710773e-01f, -4.65575932e-03f, 4.93614562e-02f, -8.90595242e-02f, -7.55544230e-02f, -1.25259325e-01f, -6.21433221e-02f, -1.22932307e-01f, -1.29640959e-02f, -1.07439877e-02f,
  1.50661953e-02f, 2.57149339e-02f, 2.30972320e-02f, 9.06978175e-02f, 1.15183875e-01f, -5.49419504e-03f, 2.14025490e-02f, 7.63411373e-02f, 1.21228723e-02f, 7.85691291e-02f,
  -1.54283633e-02f, 1.74717624e-02f, 2.02362263e-03f, 6.75159171e-02f, 5.81122097e-03f, 1.55070871e-01f, 6.40807615e-04f, 1.02156170e-01f, 1.44247979e-01f, 5.08951116e-03f,
  1.66639909e-02f, 4.59220037e-02f, 4.03550686e-03f, 4.08383571e-02f, 4.18521985e-02f, 1.16710484e-01f, 5.64270914e-02f, 8.79320130e-02f, 1.02875747e-01f, 1.18543543e-02f,
  -1.30975749e-02f, -1.59008592e-01f, -3.68806235e-02f, -1.08641607e-03f, -1.24358833e-01f, -9.37015638e-02f, -1.20673366e-01f, -2.89993305e-02f, 2.01457795e-02f, -7.96037167e-02f,
  -4.70893122e-02f, 3.10205277e-02f, -1.05770566e-01f, 5.89485988e-02f, -1.49837703e-01f, -8.54177251e-02f, 1.38789251e-01f, -8.40434060e-03f, -4.94193938e-03f, 7.84397647e-02f,
  1.72017310e-02f, 2.28003040e-02f, -3.30708288e-02f, -7.58158565e-02f, -1.01974308e-01f, -4.45368094e-03f, 6.41398365e-04f, -8.17014351e-02f, -1.67557433e-01f, 6.42252266e-02f,
  4.58975852e-01f, 9.61432829e-02f, -8.72450024e-02f, 1.74304023e-01f, 1.29460379e-01f, 1.05169691e-01f, 2.68486917e-01f, 1.41604245e-01f, 2.06603259e-01f, 1.87323436e-01f,
  1.16750382e-01f, 1.26675963e-01f, 4.35765907e-02f, -1.18230898e-02f, -2.80877086e-03f, 4.77297045e-02f, -1.98641103e-02f, -3.05774696e-02f, 7.27388076e-04f, 1.48541167e-01f,
  -1.93176866e-02f, 1.22752085e-01f, 3.45470943e-02f, 3.62824313e-02f, 2.57185046e-02f, 5.19814193e-02f, -9.09027755e-02f, -7.72563592e-02f, -1.46309122e-01f, -1.19398408e-01f,
  -1.32566169e-01f, 4.74247225e-02f, 8.18649530e-02f, 1.69733223e-02f, -1.01280779e-01f, -6.44296333e-02f, 1.07569978e-01f, -2.43618637e-02f, 1.35079091e-02f, -1.73403963e-03f,
  -2.91878618e-02f, 5.82261905e-02f, -6.96471259e-02f, 3.49246077e-02f, 3.73433083e-02f, 8.10477808e-02f, -7.95733109e-02f, -2.89522149e-02f, 7.25199953e-02f, 2.01074425e-02f,
  -3.18815187e-02f, 1.13216124e-01f, 1.04875386e-01f, 8.45457241e-02f, 6.42272085e-02f, 4.55317684e-02f, -1.29057653e-02f, -1.11568272e-01f, 5.22176214e-02f, 9.06135663e-02f,
  -4.27030586e-02f, -8.90022889e-02f, -4.17453907e-02f, -1.21630237e-01f, -3.39085348e-02f, -3.88624631e-02f, 2.47783456e-02f, 4.81339060e-02f, -4.72703725e-02f, 1.44691765e-02f,
  2.85927951e-02f, 3.70537974e-02f, -4.45044003e-02f, -1.50509598e-02f, -4.94156368e-02f, -8.94035473e-02f, -7.46503025e-02f, -9.24285799e-02f, 4.74448083e-03f, 4.52946387e-02f,
  -8.60537887e-02f, 8.18020664e-03f, -4.78386916e-02f, -1.42977089e-02f, -2.82285642e-02f, -4.56858203e-02f, 1.96423326e-02f, -6.25415817e-02f, -9.57118627e-03f, 3.07998955e-02f,
  1.30734041e-01f, 8.18551928e-02f, 1.98115960e-01f, 1.03440866e-01f, -6.07584789e-03f, 6.62206635e-02f, 4.48530354e-02f, -1.84750184e-02f, -2.80657951e-02f, 3.98662798e-02f,
  -4.39774804e-02f, 7.25080222e-02f, 7.98604265e-02f, 1.14437863e-02f, 2.96846200e-02f, 7.03219250e-02f, 8.48146603e-02f, 1.08850457e-01f, 1.12588741e-01f, -5.57020716e-02f,
  1.06127933e-01f, 1.81369409e-01f, 2.88354248e-01f, 1.09925978e-01f, 1.59620926e-01f, 1.41315132e-01f, 2.90241949e-02f, 1.32937327e-01f, 1.03641421e-01f, 2.42673650e-01f,
  2.16428384e-01f, -2.21030653e-01f, -2.24936351e-01f, 5.67048341e-02f, 2.20424220e-01f, 2.30757579e-01f, -6.59532379e-03f, 1.62603110e-01f, 8.79968926e-02f, -9.66652334e-02f,
  -1.08315207e-01f, 8.21975172e-02f, 4.69184741e-02f, 1.51988700e-01f, 7.47789219e-02f, -4.22179140e-02f, -6.21289052e-02f, 1.79057360e-01f, 3.41360778e-01f, 2.52315640e-01f,
  2.45338127e-01f, 2.94264611e-02f, 7.20940232e-02f, 4.58139069e-02f, -1.03274442e-01f, 5.48730940e-02f, -1.55842483e-01f, 3.73694650e-03f, -4.92470302e-02f, -8.53803083e-02f,
  -1.98538467e-01f, -1.59058273e-01f, 1.99218929e-01f, 1.97761562e-02f, -1.28551170e-01f, 2.47906819e-02f, -5.84084466e-02f, -1.11188374e-01f, -7.12203905e-02f, 2.07058527e-02f,
  -4.94377241e-02f, -9.25234035e-02f, -2.53014974e-02f, 3.58771384e-02f, -3.41122225e-02f, -7.83984661e-02f, -8.62802267e-02f, 4.45027389e-02f, -6.12544268e-03f, -3.06543689e-02f,
  -1.05378050e-02f, 7.59473965e-02f, -4.51980578e-03f, -1.28413349e-01f, -9.96557251e-02f, 9.94919688e-02f, 2.73946151e-02f, 5.49899116e-02f, 5.18855378e-02f, -5.63495979e-02f,
  4.62612957e-02f, -3.61251906e-02f, 5.16390651e-02f, -5.10479473e-02f, -2.47357339e-02f, 5.96842356e-02f, 8.79158005e-02f, -1.30649414e-02f, 1.05614953e-01f, -1.24619909e-01f,
  5.35520725e-02f, 4.57440279e-02f, -1.74890403e-02f, 3.44874635e-02f, 1.80624099e-03f, -2.37778313e-02f, 3.77391763e-02f, -1.88684557e-02f, -5.55610172e-02f, -2.90374011e-02f,
  2.11592745e-02f, 7.92393088e-02f, 3.16646434e-02f, 5.69713674e-02f, 4.67930548e-02f, -1.63166467e-02f, 2.99741309e-02f, 4.75290343e-02f, -3.22144218e-02f, -4.74180914e-02f,
  -7.46575296e-02f, 1.03757389e-01f, 6.76068515e-02f, 9.93962586e-02f, -8.13277885e-02f, -4.38192375e-02f, -4.20415141e-02f, 7.23689049e-02f, 6.57280236e-02f, -2.54062135e-02f,
  9.89095792e-02f, 1.02076717e-01f, -3.14174481e-02f, -2.55161133e-02f, 3.25296372e-02f, 1.06129296e-01f, 1.20786112e-02f, -9.28558037e-03f, 9.06121582e-02f, -8.04404691e-02f,
  2.64680237e-02f, 4.03400734e-02f, 1.62423596e-01f, 6.10107034e-02f, 2.24916190e-02f, 1.89089686e-01f, -2.75749564e-02f, 2.32232474e-02f, 6.73142001e-02f, 1.12355463e-02f,
  1.25189349e-01f, 1.12911500e-01f, -1.72259256e-01f, 2.48350725e-01f, 1.81048155e-01f, 9.70065966e-02f, 1.96879461e-01f, 9.10758972e-02f, 1.21802807e-01f, 1.70150176e-01f,
  5.22714108e-02f, 1.14412814e-01f, 8.58618878e-03f, -9.03709084e-02f, -1.97017416e-01f, -1.37959719e-01f, -1.38165921e-01f, -1.68090567e-01f, 2.93696746e-02f, 2.16004327e-01f,
  2.04149619e-01f, 1.83514804e-01f, -7.73750897e-03f, 1.99373234e-02f, 1.63156837e-01f, 5.86220473e-02f, -1.81376450e-02f, 5.73276654e-02f, 2.69394163e-02f, 1.27205521e-01f,
  3.62757258e-02f, 3.10640559e-02f, 5.65718114e-02f, -5.10875173e-02f, 1.96478777e-02f, -1.93487052e-02f, 6.96947426e-02f, 1.52070448e-02f, -2.19977386e-02f, 6.55904636e-02f,
  5.48896194e-02f, 5.16139716e-02f, 4.79636751e-02f, 1.79145336e-02f, 2.45679170e-02f, 7.39635378e-02f, -5.20573184e-02f, -1.46572635e-01f, -1.14927076e-01f, -5.50468601e-02f,
  7.33095482e-02f, 1.22992940e-01f, -1.20020024e-01f, -6.14965446e-02f, 1.19529571e-02f, -1.09723605e-01f, -4.58176509e-02f, 4.97317612e-02f, -1.61688939e-01f, 4.06774320e-03f,
  8.80308300e-02f, -2.54615210e-02f, -5.00601530e-02f, -1.19925486e-02f, 7.13458331e-03f, -9.20133516e-02f, -1.86789986e-02f, 1.50827290e-02f, -6.38516396e-02f, -1.57478198e-01f,
  -3.77257057e-02f, -8.87887925e-02f, 1.75015703e-02f, -1.40064985e-01f, -7.83347785e-02f, -1.16656050e-01f, -6.27785921e-02f, 2.79769879e-02f, -7.72502869e-02f, -1.37704492e-01f,
  -5.30806966e-02f, -8.74002576e-02f, -4.63428795e-02f, -2.79186908e-02f, -2.89928378e-03f, 1.03626857e-02f, -1.17583513e-01f, -3.02009303e-02f, -1.38669372e-01f, -9.12771523e-02f,
  5.54170944e-02f, -2.16569096e-01f, 4.82462309e-02f, -8.30733329e-02f, 7.67538995e-02f, 4.18933704e-02f, 1.79706533e-02f, -8.52575898e-03f, 9.69177261e-02f, 9.93999839e-02f,
  1.22061826e-01f, -3.90931368e-02f, 1.81080475e-02f, 6.91079348e-02f, 9.23116282e-02f, 5.03860377e-02f, 5.47349919e-03f, 2.52447389e-02f, -8.74616802e-02f, 4.80587520e-02f,
  1.11168076e-03f, -4.09379192e-02f, -8.01868513e-02f, 4.85250242e-02f, 4.31585498e-02f, 4.99770902e-02f, 3.55148166e-02f, 5.76038621e-02f, -2.69512995e-03f, 9.62513983e-02f,
  3.40224534e-01f, -2.04616234e-01f, 2.20882446e-01f, -1.68440621e-02f, -5.72780259e-02f, -1.17016815e-01f, -2.01288715e-01f, -1.67090237e-01f, -2.92366259e-02f, -9.76345539e-02f,
  -2.84406003e-02f, -1.50365531e-01f, -1.43337280e-01f, -1.83202550e-02f, -8.41324329e-02f, -8.53050128e-02f, 3.23114358e-02f, 2.13999406e-01f, 1.43642826e-02f, 3.09414486e-03f,
  -1.89872026e-01f, 6.80351928e-02f, 1.74066395e-01f, -4.38294113e-02f, -1.75287843e-01f, -1.64398968e-01f, -5.82413226e-02f, 4.59916890e-02f, -7.31551573e-02f, 4.56357673e-02f,
  -7.85357654e-02f, 5.57916798e-02f, -1.75659582e-02f, 5.98574476e-03f, -3.11352368e-02f, -1.25126392e-01f, -6.17438219e-02f, -1.27331108e-01f, -1.11762024e-02f, -7.27878734e-02f,
  -5.41897602e-02f, -8.74218270e-02f, -1.07357122e-01f, -1.11951269e-02f, -1.28366560e-01f, -1.28062755e-01f, -8.43764618e-02f, 3.04133110e-02f, -3.53859663e-02f, -1.18542155e-02f,
  -6.08966723e-02f, 6.05528019e-02f, -6.11684397e-02f, -9.05399770e-02f, -8.07875618e-02f, 6.94985911e-02f, -8.98838192e-02f, 1.43269552e-02f, -8.21200013e-02f, -1.24928333e-01f,
  -6.11627325e-02f, 4.31081280e-02f, 5.20398617e-02f, -4.47146297e-02f, 2.00091954e-02f, 4.12519798e-02f, 5.21007180e-02f, 5.15478067e-02f, 8.96956623e-02f, 4.36477140e-02f,
  4.39801738e-02f, 4.91238199e-02f, -1.08809967e-03f, -3.48274373e-02f, -3.09626777e-02f, 1.19112559e-01f, 5.94478995e-02f, 1.10631529e-02f, 9.30676535e-02f, 4.18749563e-02f,
  1.42317802e-01f, 1.51084125e-01f, 9.71421674e-02f, 3.68304364e-02f, 1.35732628e-03f, 1.24762326e-01f, 7.64542818e-03f, 9.26340967e-02f, 1.08774682e-03f, 7.49112740e-02f,
  -3.61853749e-01f, 9.74713638e-03f, -1.48642465e-01f, -1.19136989e-01f, -5.04124127e-02f, -8.28981623e-02f, -2.15795841e-02f, -4.93575819e-02f, 1.73949156e-04f, -1.09661616e-01f,
  -1.47132486e-01f, -4.11783531e-02f, -1.45080075e-01f, -1.89744711e-01f, -9.42218155e-02f, -1.15380041e-01f, -1.47458166e-01f, -1.39290316e-03f, -8.94609243e-02f, -1.43984690e-01f,
  -1.18489228e-01f, 6.46618567e-03f, 1.04865380e-01f, -8.61441866e-02f, -2.51795631e-02f, 4.23823558e-02f, -5.51936477e-02f, -1.72093764e-01f, -5.83598949e-02f, -1.57575518e-01f,
  -5.28802454e-01f, 3.62461299e-01f, 1.39155015e-01f, -1.94298252e-01f, -3.47702242e-02f, -1.97476894e-02f, 2.09573552e-01f, -6.18658029e-03f, -2.28546876e-02f, 1.26562208e-01f,
  8.71753134e-03f, -1.09100819e-01f, 7.83928856e-02f, -1.62248295e-02f, 2.84601003e-02f, 3.37844074e-01f, 2.57226437e-01f, -3.62396576e-02f, -1.36833370e-01f, -6.47793859e-02f,
  6.55785203e-02f, -2.34178770e-02f, -2.14445978e-01f, 3.78486402e-02f, 1.83220461e-01f, -2.15095580e-02f, 2.34550729e-01f, 8.58936533e-02f, 2.09381074e-01f, 2.59521544e-01f,
  2.21641168e-01f, 9.63261649e-02f, -3.70429382e-02f, 2.21595075e-02f, 5.40781058e-02f, 3.96966450e-02f, 1.11155786e-01f, 1.49382547e-01f, 6.46911636e-02f, 1.06100835e-01f,
  3.36866826e-02f, 1.58469938e-02f, 8.57189819e-02f, 7.79745728e-02f, 1.20754972e-01f, 7.09439721e-03f, 2.15755086e-02f, 9.59351733e-02f, 2.41834000e-02f, 2.00127214e-01f,
  1.27482727e-01f, 1.32306352e-01f, -1.16914073e-02f, 7.73819489e-03f, 7.15465620e-02f, 1.50150741e-02f, 7.67429769e-02f, 1.87448636e-02f, 1.71483196e-02f, 1.01834595e-01f,
  1.95267722e-02f, -7.61160478e-02f, -2.69252900e-02f, -1.24996848e-01f, -1.10955335e-01f, -3.96075808e-02f, -3.65167633e-02f, -4.35805321e-02f, -9.04856622e-02f, -1.07626077e-02f,
  -2.15509832e-02f, -4.71405983e-02f, -7.97246248e-02f, -1.21018127e-01f, 9.05218814e-03f, -4.35865298e-02f, -8.49518180e-02f, -9.08892509e-03f, -5.43447658e-02f, -1.18592732e-01f,
  -8.31194445e-02f, -4.80260588e-02f, -4.34127599e-02f, -9.53555200e-03f, -3.01364213e-02f, 3.09103783e-02f, -5.15458686e-03f, -3.30971628e-02f, -8.46142173e-02f, -4.50697318e-02f,
  1.54070094e-01f, -1.46539092e-01f, 1.34423837e-01f, 9.84286293e-02f, 1.16017960e-01f, 5.59008494e-02f, 1.54819846e-01f, 1.74095929e-02f, 2.13758871e-02f, 4.22732942e-02f,
  7.11168647e-02f, 5.64191230e-02f, 1.42658874e-01f, 1.46750644e-01f, 3.99980135e-03f, -1.19395489e-02f, 1.97479874e-02f, 6.37542531e-02f, 6.23216145e-02f, 1.70892790e-01f,
  7.41822496e-02f, -2.45052502e-02f, 5.92940720e-03f, 7.85643458e-02f, 6.02106303e-02f, -7.85087645e-02f, 5.20190671e-02f, 1.06150702e-01f, 4.80269417e-02f, -2.02125404e-02f,
  -3.01111400e-01f, 1.57812014e-01f, 2.06283391e-01f, -5.12730516e-02f, 1.74078748e-01f, 1.76676497e-01f, 2.48204693e-01f, 2.86458224e-01f, -1.19492486e-02f, 6.58355281e-02f,
  1.34414613e-01f, 5.80664724e-03f, -6.69440255e-02f, 4.48844046e-04f, 2.21603438e-01f, 1.18576452e-01f, 1.19989336e-01f, 1.03393629e-01f, 1.09260790e-01f, 5.35765812e-02f,
  -2.93897223e-02f, -5.08582033e-02f, 6.55207634e-02f, 3.39076370e-02f, 5.28374612e-02f, -7.98535123e-02f, 2.03402206e-01f, 6.64360449e-02f, 2.47634485e-01f, -4.81006317e-02f,
  -4.97900210e-02f, 2.55756885e-01f, 1.46521732e-01f, 5.92749268e-02f, 2.00098857e-01f, 1.52138084e-01f, 1.03338763e-01f, 1.61691770e-01f, 1.38716921e-01f, 1.12817459e-01f,
  1.88264728e-01f, 1.03413194e-01f, 1.42347902e-01f, 9.68493670e-02f, 1.70533687e-01f, 1.48842901e-01f, 2.43040740e-01f, 8.62106904e-02f, 9.10190269e-02f, 1.96665004e-01f,
  1.40436098e-01f, 1.40257657e-01f, 1.15181088e-01f, 2.43525997e-01f, 2.97853589e-01f, 5.58665916e-02f, 2.92030662e-01f, 1.73605070e-01f, 3.15985948e-01f, 9.29223094e-03f,
  -1.34379297e-01f, -1.98184639e-01f, -4.11619768e-02f, -2.08483636e-01f, -1.52728185e-01f, -1.87307909e-01f, -1.59636334e-01f, -1.43129766e-01f, -9.74212289e-02f, -1.61216006e-01f,
  -9.00580287e-02f, -1.45054743e-01f, -1.39811069e-01f, -1.73562706e-01f, -2.39459381e-01f, -9.63126123e-02f, -1.55360505e-01f, -1.58820748e-01f, -1.08434163e-01f, -1.26137391e-01f,
  -1.38317004e-01f, -1.38999999e-01f, -7.26737604e-02f, -1.21768422e-01f, -9.35245901e-02f, -1.35424197e-01f, -1.39487445e-01f, -1.07132725e-01f, -1.55412212e-01f, -8.34981725e-02f,
  -2.24648014e-01f, 3.71551245e-01f, -1.56598181e-01f, 5.74587733e-02f, 1.08550854e-01f, 1.35456264e-01f, 1.27170952e-02f, 5.63472025e-02f, 9.21839774e-02f, -1.65459141e-02f,
  1.26544088e-01f, 1.14649713e-01f, 6.60639405e-02f, 1.84866473e-01f, 1.24916472e-01f, 7.94366226e-02f, 5.44941872e-02f, 8.33700690e-03f, 1.37074903e-01f, 6.96065351e-02f,
  1.12556241e-01f, 3.25410813e-02f, -8.16078484e-02f, 8.73678997e-02f, 1.08310111e-01f, -2.40824632e-02f, 1.57667585e-02f, 1.23767674e-01f, 6.25026375e-02f, -8.13552961e-02f,
  -1.71766236e-01f, -1.74185529e-01f, 5.37484977e-03f, -1.76681831e-01f, 2.11342834e-02f, -1.51075661e-01f, -2.24911168e-01f, -9.41307694e-02f, 5.67635819e-02f, -2.02259570e-01f,
  -1.16779216e-01f, 6.81852922e-02f, -4.53710277e-03f, -3.64508778e-02f, -1.64011523e-01f, -1.82976022e-01f, -1.55122235e-01f, -6.02497049e-02f, 2.40932181e-02f, -9.29505825e-02f,
  -1.23576246e-01f, -1.67776242e-01f, -4.56576236e-02f, 7.06799850e-02f, -1.15405107e-02f, 1.56538352e-01f, 1.29611539e-02f, -5.05754389e-02f, -8.25433433e-02f, -4.81419675e-02f,
  -4.77278791e-02f, -2.20796955e-03f, 3.07603210e-01f, 1.62192613e-01f, 1.30086407e-01f, 1.19098581e-01f, 1.59512274e-02f, 1.59354359e-01f, 1.13795936e-01f, 1.72626778e-01f,
  1.41678378e-01f, 6.56007826e-02f, 4.47078459e-02f, 1.03455462e-01f, 1.11555099e-01f, 1.79135591e-01f, 1.01480611e-01f, 1.99791357e-01f, 2.60603815e-01f, 5.59477732e-02f,
  3.48958485e-02f, 1.18933573e-01f, 1.25286147e-01f, 1.78314686e-01f, 1.93769321e-01f, 2.75092989e-01f, 2.22977415e-01f, 2.51394451e-01f, 1.86081916e-01f, 4.59265076e-02f,
  -8.79689232e-02f, -1.51387796e-01f, -2.19380967e-02f, -1.61202744e-01f, -6.66081682e-02f, -5.02732694e-02f, -1.89513192e-01f, -1.22708537e-01f, -1.19914390e-01f, -3.60241681e-02f,
  -1.88362092e-01f, -2.12291092e-01f, -1.52855173e-01f, -2.07215637e-01f, -2.00283751e-01f, -8.97756964e-02f, -1.30707443e-01f, -1.65255219e-01f, -8.25483426e-02f, -9.71610695e-02f,
  -6.33449405e-02f, -2.02989914e-02f, -5.51494919e-02f, -1.56793550e-01f, -1.64735794e-01f, -1.23867676e-01f, -1.75515547e-01f, -8.81384090e-02f, -3.08561046e-02f, -1.72267094e-01f,
  1.21459700e-01f, 2.49412090e-01f, 5.51483892e-02f, 1.15428142e-01f, 2.40842476e-01f, 1.56434342e-01f, 2.15606630e-01f, 1.72097132e-01f, 1.34108976e-01f, 3.11846402e-03f,
  1.16758369e-01f, 8.08415785e-02f, 6.24757223e-02f, 2.30845705e-01f, 6.07849509e-02f, 2.03389034e-01f, 2.48063840e-02f, 1.58415332e-01f, 2.25632071e-01f, 7.47946054e-02f,
  1.28233716e-01f, 1.48968533e-01f, 1.62686706e-01f, 1.50119066e-01f, 8.73132497e-02f, 1.40649587e-01f, 1.01314895e-01f, 1.66623697e-01f, 2.51030833e-01f, 1.15696736e-01f,
  -1.97626233e-01f, 4.70575094e-02f, -5.58691286e-02f, 1.01396620e-01f, 1.69872403e-01f, 1.23463022e-02f, -1.72957078e-01f, -6.27031624e-02f, 9.44265947e-02f, -6.81452975e-02f,
  -3.37524973e-02f, -1.41683137e-02f, 1.00529738e-01f, 1.24308959e-01f, 1.64258685e-02f, 7.67397732e-02f, 1.16981715e-01f, 6.12416565e-02f, 2.56563630e-02f, 6.23630658e-02f,
  1.07358590e-01f, 7.47864395e-02f, 6.40156716e-02f, 1.09590851e-01f, 1.50045022e-01f, 9.79536325e-02f, 3.13907601e-02f, 5.69902174e-02f, 1.58765078e-01f, 2.67145187e-01f,
  1.00053623e-01f, 5.95576465e-02f, 8.16953182e-02f, 1.28117740e-01f, 1.17158242e-01f, 1.73788983e-02f, 7.80612454e-02f, 1.68499738e-01f, 8.94434750e-02f, 1.51461273e-01f,
  1.31521747e-01f, 1.50298148e-01f, 1.06264159e-01f, 2.31565103e-01f, 1.66677341e-01f, 8.44158381e-02f, 1.23003744e-01f, 4.61640731e-02f, 7.63833523e-02f, 3.16968113e-02f,
  2.74270713e-01f, 1.21816806e-01f, 8.98890793e-02f, 7.85223246e-02f, 6.20962642e-02f, 8.26804116e-02f, -1.83436573e-02f, 5.92240393e-02f, -2.37870254e-02f, -2.56696274e-03f,
  -1.44363791e-02f, -1.87248051e-01f, -4.83593382e-02f, -1.79510549e-01f, -1.21918172e-01f, -1.86650418e-02f, -1.30738869e-01f, -2.32560001e-02f, -8.71974975e-02f, -8.87109786e-02f,
  -1.70545518e-01f, -1.57592356e-01f, -5.68934456e-02f, -2.15663165e-01f, -5.35981320e-02f, -1.87165171e-01f, -2.00128198e-01f, -1.50920361e-01f, -2.02701226e-01f, -2.24846676e-01f,
  -1.22167155e-01f, -5.29933758e-02f, -1.64753824e-01f, -9.99108478e-02f, -1.70495644e-01f, -1.72793269e-01f, -1.30195946e-01f, -1.86351493e-01f, -1.36296451e-01f, -2.01144472e-01f,
  9.23797041e-02f, -7.66920000e-02f, 1.28577063e-02f, 1.01529635e-01f, 1.34132922e-01f, 5.17041497e-02f, 1.19121023e-01f, 4.24087159e-02f, -1.82211064e-02f, 1.08881891e-02f,
  6.75253868e-02f, -5.58546698e-03f, 1.08836986e-01f, 1.79613918e-01f, 1.94677845e-01f, 1.61246240e-01f, 9.93567407e-02f, 9.10668448e-02f, 3.74027938e-02f, 5.94682544e-02f,
  6.81026652e-02f, 9.66821760e-02f, -7.70370439e-02f, -6.75193369e-02f, -1.38408765e-02f, 1.12862485e-02f, -2.57051969e-03f, 1.01470605e-01f, -4.47710939e-02f, -2.43625753e-02f,
  6.66235864e-01f, -1.90195546e-01f, 2.47099310e-01f, 3.06539029e-01f, 3.39063928e-02f, -8.94897506e-02f, -2.19694972e-01f, 3.78892161e-02f, 2.04484925e-01f, -1.15455883e-02f,
  8.19350332e-02f, 2.54172832e-01f, 2.27841243e-01f, 1.71251386e-01f, 1.55802727e-01f, 3.53903286e-02f, 1.11646809e-01f, 4.14388150e-01f, 3.17031205e-01f, 2.09407166e-01f,
  1.24712579e-01f, 1.95604801e-01f, 4.10188198e-01f, 2.76005477e-01f, 1.79653950e-02f, 1.42075121e-01f, -5.27949305e-03f, 1.47987440e-01f, -1.18132774e-02f, 1.38617665e-01f,
  7.22358823e-02f, 2.46877432e-01f, 3.16900492e-01f, 1.45464897e-01f, 1.46862999e-01f, 1.67260826e-01f, 1.43920243e-01f, 1.76671222e-01f, 2.22184911e-01f, 1.96298659e-01f,
  9.57361087e-02f, 2.06231982e-01f, 2.02481970e-01f, 1.71505108e-01f, 1.49406090e-01f, 1.65116668e-01f, 1.06421366e-01f, 3.21907133e-01f, 1.97305828e-01f, 7.14131892e-02f,
  9.58820209e-02f, 5.32809086e-02f, 1.91023767e-01f, 1.17675707e-01f, 1.81166813e-01f, 2.14783177e-01f, 1.06840000e-01f, 2.34606326e-01f, 1.98455155e-01f, 1.59273624e-01f,
  -7.69440755e-02f, -5.90738170e-02f, -1.47992685e-01f, -8.74919444e-02f, -1.84285507e-01f, -7.69623816e-02f, -9.40223411e-02f, -1.29593015e-01f, -9.85490456e-02f, -1.97700366e-01f,
  -9.57243815e-02f, -1.70600295e-01f, -7.47069567e-02f, -1.20780207e-01f, -1.42065272e-01f, -5.91208562e-02f, -6.63033649e-02f, -1.13237470e-01f, -1.69018224e-01f, -1.57175392e-01f,
  -9.04421434e-02f, -1.23256110e-01f, -7.84111470e-02f, -1.36539385e-01f, -1.27694309e-01f, -1.23714402e-01f, -2.01597922e-02f, -1.78602561e-01f, -1.66477039e-01f, -7.30087981e-02f,
  -9.93234739e-02f, 3.32861662e-01f, 1.73060611e-01f, 2.60564864e-01f, 1.77942649e-01f, 1.93853796e-01f, 2.14823544e-01f, 2.21207976e-01f, 1.96699798e-01f, 1.07955784e-01f,
  1.61250457e-01f, 2.49803096e-01f, 1.61577851e-01f, 4.31915708e-02f, 1.46343008e-01f, 1.75597996e-01f, 1.19941041e-01f, 1.34334922e-01f, 2.03279600e-01f, 1.94175243e-01f,
  7.84647930e-03f, 2.02857226e-01f, 2.36845613e-01f, 1.89483777e-01f, 1.51671603e-01f, 2.20836058e-01f, 8.51270705e-02f, 7.18135536e-02f, 1.96695179e-01f, 9.94414762e-02f,
  -3.26886177e-01f, -3.48873138e-01f, 2.50196457e-01f, -1.68880671e-01f, 2.34895181e-02f, 2.84628510e-01f, 5.99416904e-02f, 1.29177392e-01f, -1.19609080e-01f, -1.95414394e-01f,
  -1.04608782e-01f, -6.72774613e-02f, -7.54538849e-02f, 1.15087792e-01f, 2.08041087e-01f, -1.09428123e-01f, -1.33748576e-01f, 2.12163329e-01f, 3.83484781e-01f, 1.92857668e-01f,
  -2.01203674e-02f, 3.53868827e-02f, -7.89125264e-02f, 3.04919984e-02f, -1.45781174e-01f, 3.08290850e-02f, -2.04462763e-02f, -1.02496997e-01f, 6.23665117e-02f, -2.68804878e-01f,
  1.80055171e-01f, -3.70815322e-02f, 1.78305849e-01f, 3.63139808e-02f, 4.64957580e-03f, -7.82856494e-02f, 5.41288555e-02f, 7.72425681e-02f, -1.20708063e-01f, 6.20979071e-02f,
  3.94781865e-02f, -2.64524017e-02f, 6.77411333e-02f, 4.65522595e-02f, 9.07384455e-02f, 8.46257284e-02f, -6.67120144e-02f, -1.77900121e-02f, 2.49599498e-02f, -7.05959974e-03f,
  -5.72837219e-02f, -7.24925771e-02f, 6.33088946e-02f, 1.26556471e-01f, 2.63049491e-02f, 2.61070523e-02f, 1.23337403e-01f, -1.12271942e-02f, 1.35373861e-01f, -7.19305202e-02f,
  -3.94726694e-02f, -6.07904941e-02f, 4.03107069e-02f, 4.10770474e-04f, -1.08774249e-02f, -6.64280504e-02f, -9.10131410e-02f, -4.26227786e-02f, 2.09525228e-02f, -5.33753671e-02f,
  2.43477803e-02f, 4.95542921e-02f, 3.66554447e-02f, -2.93568969e-02f, 2.59769503e-02f, -4.18345630e-02f, -1.93244796e-02f, -5.23960739e-02f, 1.73564255e-02f, -6.08295165e-02f,
  -1.67050697e-02f, 7.54549578e-02f, -5.84002435e-02f, 9.25442129e-02f, -1.17200287e-03f, -1.53829828e-02f, 2.13022786e-03f, 6.38950756e-03f, -6.66959658e-02f, -6.93820715e-02f,
  1.55544639e-01f, 2.10403442e-01f, -1.67460725e-01f, -4.49397825e-02f, 6.82785138e-02f, -2.15730183e-02f, -2.31122151e-02f, 3.04953605e-02f, -7.61279976e-03f, 2.49306392e-02f,
  4.75823060e-02f, 3.87422554e-02f, 2.72459276e-02f, -3.41034830e-02f, 8.14648271e-02f, 1.85554083e-02f, -8.75317380e-02f, 1.91881862e-02f, -4.20888029e-02f, 3.46262455e-02f,
  -5.74957579e-02f, 1.02343103e-02f, -4.58162576e-02f, 7.84927160e-02f, -2.78895851e-02f, 5.55791706e-02f, 9.32670906e-02f, 8.63859802e-02f, 1.65618375e-01f, -1.22553878e-01f,
  -1.49231300e-01f, -3.35960120e-01f, -1.72963068e-02f, 4.88781333e-02f, 2.59823520e-02f, 1.43544391e-01f, 5.42021841e-02f, -2.54764128e-02f, -9.77858827e-02f, -1.53351724e-01f,
  -1.91381171e-01f, -5.74668385e-02f, -2.98561119e-02f, 9.46794376e-02f, 8.96733850e-02f, 1.03312232e-01f, 3.59162427e-02f, 1.16522886e-01f, 2.80698299e-01f, 9.61902887e-02f,
  3.46045904e-02f, 1.10709466e-01f, 1.14101797e-01f, -1.39680225e-02f, -7.13013113e-02f, -6.64695818e-03f, -1.11897312e-01f, -1.60934716e-01f, -7.31702056e-03f, -1.13659218e-01f,
  -1.11545578e-01f, -2.34341681e-01f, 1.47739589e-01f, -5.21745868e-02f, -1.40982419e-01f, -1.20515533e-01f, -1.04932770e-01f, -9.58461016e-02f, -1.21454954e-01f, -5.50268106e-02f,
  -1.28229767e-01f, -4.31314930e-02f, -2.96234451e-02f, -7.89571777e-02f, -1.49633706e-01f, -6.15802631e-02f, -1.58621177e-01f, -1.19524650e-01f, -1.46928996e-01f, -9.78111327e-02f,
  -1.19272940e-01f, -4.73261476e-02f, -8.98602679e-02f, -6.84215575e-02f, -2.02570215e-01f, 3.49394307e-02f, -1.88885987e-01f, -1.73284352e-01f, -3.05272546e-02f, -1.67980403e-01f,
  2.56126579e-02f, -5.98098785e-02f, 4.35724258e-02f, -3.58744487e-02f, 4.69963104e-02f, 4.57384400e-02f, 8.88071582e-02f, 5.70445228e-03f, 1.05913810e-01f, 9.97848883e-02f,
  1.22938035e-02f, 8.73623118e-02f, -3.62030119e-02f, 8.21724460e-02f, 6.58941120e-02f, 5.97866774e-02f, 2.41056699e-02f, 8.23246166e-02f, 6.58603087e-02f, 7.08494186e-02f,
  1.19220957e-01f, 4.63527441e-02f, 9.69014540e-02f, 6.38687015e-02f, -5.98398075e-02f, 8.68674368e-02f, 9.27345231e-02f, 7.62125850e-02f, -1.18900742e-02f, 8.99225473e-02f,
  -9.08199176e-02f, 1.18683957e-01f, -7.19657242e-02f, -7.06032738e-02f, -1.64755851e-01f, -1.54699862e-01f, -1.50005132e-01f, -1.38061956e-01f, -1.80806890e-01f, -7.57365376e-02f,
  -8.88182744e-02f, -8.12980086e-02f, -1.50049195e-01f, 4.39731497e-03f, 2.08996907e-02f, -7.74654746e-02f, -1.18918285e-01f, -8.54059234e-02f, -1.30339921e-01f, -1.57407790e-01f,
  -1.48084059e-01f, -4.83476445e-02f, 2.42945720e-02f, -8.76761004e-02f, -1.97409362e-01f, 8.02230984e-02f, 2.34217402e-02f, -1.12041317e-01f, -1.55955981e-02f, 5.73849045e-02f,
  2.94094771e-01f, 3.29205930e-01f, 3.71891379e-01f, 7.35994196e-04f, 8.12652260e-02f, 2.59570181e-01f, 3.57718468e-01f, 2.60486871e-01f, -2.50488576e-02f, 7.34023750e-03f,
  -1.46943346e-01f, -4.04166549e-01f, -1.99544147e-01f, -9.12619159e-02f, 5.69270030e-02f, 2.72339225e-01f, 2.79889971e-01f, 1.14082441e-01f, -5.99631155e-03f, -2.75170915e-02f,
  -1.72544926e-01f, -4.74673547e-02f, 3.98405567e-02f, 2.76809521e-02f, -1.03553995e-01f, -1.09600656e-01f, 1.69432566e-01f, 1.30761310e-01f, 8.20687264e-02f, 1.62398860e-01f,
  5.96574321e-02f, 2.64319867e-01f, -7.98743293e-02f, -3.54745835e-02f, -6.24690428e-02f, 3.13302279e-02f, 1.88020524e-02f, 8.83978307e-02f, -3.76487747e-02f, 9.94067043e-02f,
  -1.01463303e-01f, -3.70082743e-02f, -6.42321557e-02f, 3.31071541e-02f, 1.25806138e-01f, 1.44111561e-02f, 4.25651707e-02f, 1.34257376e-01f, 1.08452655e-01f, -4.27676452e-04f,
  -1.32404923e-01f, 1.23869494e-01f, 1.16333038e-01f, 4.86037433e-02f, 2.68166736e-02f, -8.62691849e-02f, 7.50125200e-02f, 5.01032621e-02f, 1.62102312e-01f, 2.59522647e-01f,
  -8.13938975e-02f, -4.00605835e-02f, 4.33386909e-03f, -7.06027448e-03f, -6.98247999e-02f, -2.35478804e-02f, -3.66312154e-02f, -4.51794006e-02f, 3.79908010e-02f, 5.94804855e-03f,
  3.17934295e-03f, 3.23335864e-02f, 9.88598767e-05f, -2.54573897e-02f, -1.90070756e-02f, -2.47415844e-02f, 3.31438966e-02f, -8.74001607e-02f, -9.02072638e-02f, -4.16381583e-02f,
  -4.50705588e-02f, 6.95798825e-03f, -3.13649215e-02f, 2.61563584e-02f, -2.55958969e-03f, 2.06233859e-02f, -5.85321942e-03f, -4.18949686e-02f, -2.25576535e-02f, 4.87862006e-02f,
  -1.65569857e-01f, 5.18886633e-02f, -3.81413847e-02f, 7.79067352e-02f, 7.76860937e-02f, 6.57903636e-03f, -7.43907839e-02f, 6.82866573e-02f, -6.97829761e-03f, 1.40719920e-01f,
  -2.62289476e-02f, -2.69074477e-02f, 3.52022648e-02f, 3.39760520e-02f, -5.10468297e-02f, 6.68333024e-02f, -1.72513891e-02f, -1.55865978e-02f, -6.55590892e-02f, -1.74390785e-02f,
  -6.64588287e-02f, 6.06515072e-02f, 1.40905619e-01f, 1.10001892e-01f, 4.40221168e-02f, -6.99133128e-02f, 9.76734683e-02f, -1.30180391e-02f, 1.82411239e-01f, 2.19516024e-01f,
  8.53665471e-02f, -1.70310333e-01f, 2.56128699e-01f, -1.59383770e-02f, -2.82651894e-02f, -1.96124483e-02f, 1.30438181e-02f, -1.10153757e-01f, -1.93663642e-01f, -1.41105801e-01f,
  -1.73050672e-01f, -2.70258814e-01f, -1.08597621e-01f, -1.66531950e-01f, -7.43529722e-02f, 6.08646683e-03f, 3.97454910e-02f, 8.60062391e-02f, -4.91358712e-02f, -2.59714931e-01f,
  -2.54054606e-01f, -1.63607314e-01f, -1.82943478e-01f, -5.36181480e-02f, -2.46704638e-01f, -2.19723955e-01f, -3.93696912e-02f, -8.90442580e-02f, -2.10746318e-01f, -3.12587976e-01f,
  -9.44461077e-02f, 1.57993659e-01f, -4.99623343e-02f, -1.81421444e-01f, 4.31406461e-02f, -5.13540097e-02f, -1.55962119e-02f, 3.14656720e-02f, -4.24836203e-02f, -1.49939060e-01f,
  -9.81206670e-02f, -1.53387859e-01f, 4.49738465e-02f, -2.08768249e-02f, -1.10929258e-01f, -1.13733284e-01f, 3.72412428e-02f, 3.34266126e-02f, 1.45254700e-04f, -1.41944110e-01f,
  -1.43745109e-01f, -1.69090903e-03f, -1.90934911e-03f, -2.94431616e-02f, -6.34081587e-02f, -4.29974459e-02f, -5.26319034e-02f, -8.16917885e-03f, -4.46426421e-02f, -1.19570650e-01f,
  -9.75247249e-02f, 5.59066534e-02f, 3.22912307e-03f, 1.07581548e-01f, -6.61603510e-02f, 8.20487214e-04f, -1.64324660e-02f, 3.18080485e-02f, -2.72244625e-02f, 1.80074573e-02f,
  3.01648807e-02f, 6.51705042e-02f, 1.60700548e-02f, 1.12085424e-01f, 1.77302416e-02f, 1.20756835e-01f, -1.76720396e-02f, -1.64233316e-02f, 1.16708919e-01f, 1.28051251e-01f,
  8.79025310e-02f, -1.65231358e-02f, 3.94867547e-02f, 1.45738721e-01f, -3.35962921e-02f, 9.98434499e-02f, -2.24393513e-02f, 1.01118818e-01f, 4.17297184e-02f, 1.07696988e-01f,
  -2.27458820e-01f, 1.65073752e-01f, -1.28414810e-01f, -1.04260661e-01f, 1.93517059e-02f, -1.26197994e-01f, -5.58817983e-02f, -9.96580496e-02f, -1.20426454e-01f, -3.58798467e-02f,
  -1.17126949e-01f, -7.12432563e-02f, -3.96189317e-02f, -1.09166346e-01f, -1.50110498e-01f, -2.09856898e-01f, -1.06879517e-01f, -1.02854766e-01f, -1.59580991e-01f, -1.99647576e-01f,
  -1.82261154e-01f, -1.00258194e-01f, -1.31086588e-01f, -1.76577285e-01f, -1.78311333e-01f, -5.26940525e-02f, -2.03491092e-01f, -2.41110027e-01f, 1.06722340e-02f, -2.51356959e-01f,
  3.20751965e-01f, -4.09062840e-02f, 1.60203174e-01f, 1.50657490e-01f, -1.58386692e-01f, -1.35938659e-01f, -1.79685280e-01f, -2.83011142e-03f, -1.31060457e-04f, -2.73564849e-02f,
  3.26787531e-02f, 3.20437774e-02f, 7.68648461e-02f, -4.31670882e-02f, 5.50876111e-02f, 5.13684973e-02f, 3.91046926e-02f, 1.85700133e-01f, 1.15175098e-01f, -9.15778335e-03f,
  -1.69190586e-01f, 1.05567046e-01f, 7.57997856e-02f, 7.12260455e-02f, 1.26466468e-01f, 2.55557131e-02f, 1.54030889e-01f, 1.69401392e-01f, 7.33048618e-02f, 3.94284055e-02f,
  2.67379135e-01f, 4.98645380e-02f, 1.31527148e-02f, -1.37406781e-01f, 4.59352247e-02f, 2.04614047e-02f, 6.47136495e-02f, 9.81605649e-02f, 2.14735251e-02f, 6.46831915e-02f,
  7.01636672e-02f, 4.11604978e-02f, 2.24867351e-02f, 4.39081946e-03f, 4.59635779e-02f, 3.83063667e-02f, 8.36546009e-04f, 3.15517746e-02f, 9.01308432e-02f, -4.25987393e-02f,
  -7.02811033e-02f, 2.33000759e-02f, 4.24559526e-02f, 8.31653997e-02f, 1.16725616e-01f, 9.23960209e-02f, 7.63465092e-02f, 9.62623507e-02f, 1.44809783e-01f, 4.53336537e-02f,
  -1.48167713e-02f, -1.77175496e-02f, -3.47299613e-02f, -4.12875926e-03f, 6.33425126e-03f, -7.13158473e-02f, -5.78650646e-03f, -3.20506468e-02f, 5.35971634e-02f, 4.67936993e-02f,
  6.61237340e-04f, -6.95276633e-02f, -4.35508341e-02f, 8.84302482e-02f, -1.23861656e-02f, -1.37147494e-02f, 1.24025866e-02f, 8.28959327e-03f, 6.49386719e-02f, -5.52378921e-03f,
  -2.54345164e-02f, 2.10202839e-02f, -3.16887610e-02f, -3.62766348e-02f, -1.72611829e-02f, 7.41548166e-02f, -2.31318809e-02f, -5.17895631e-02f, -5.56124970e-02f, -9.83895734e-02f,
  2.75745958e-01f, -4.61675450e-02f, 1.11107416e-01f, -6.99613709e-03f, -6.02991180e-03f, 5.99217042e-02f, 5.23925722e-02f, -2.70422082e-02f, 4.16651890e-02f, 3.45484875e-02f,
  2.20971089e-02f, 1.25023887e-01f, -2.41683442e-02f, -7.20715988e-03f, -2.19357032e-02f, -1.60159208e-02f, -7.88532794e-02f, 1.11013487e-01f, -3.64110456e-03f, -5.97756393e-02f,
  -1.00938872e-01f, 1.37905404e-01f, 8.27044919e-02f, 1.19025350e-01f, 7.13673159e-02f, 5.27862459e-02f, 1.54571667e-01f, 1.60147510e-02f, 5.99417649e-02f, 1.82100222e-01f,
  2.56803960e-01f, -2.78234899e-01f, -3.30533423e-02f, -3.78095210e-02f, -1.81421533e-01f, 1.46534488e-01f, 5.93776181e-02f, 1.77399650e-01f, 7.16279000e-02f, -1.98479220e-02f,
  -1.34520814e-01f, -1.55680105e-01f, -1.98492035e-02f, 1.73843466e-02f, 1.80988938e-01f, -7.58205280e-02f, -3.55058275e-02f, 3.38671356e-02f, 2.76190132e-01f, 1.05307199e-01f,
  -4.49847020e-02f, 5.10728918e-02f, 1.79583013e-01f, 7.98136070e-02f, -6.20383993e-02f, -1.63580757e-02f, -1.53507665e-01f, -1.26794115e-01f, -3.65959704e-02f, -1.86420679e-01f,
  -2.70302862e-01f, -4.08885740e-02f, 4.89259735e-02f, -1.16889931e-01f, -1.00259691e-01f, 2.79575177e-02f, 3.46759781e-02f, -4.39735036e-03f, 4.64481264e-02f, -7.18565285e-02f,
  -1.21801563e-01f, -3.87946318e-04f, -1.17121868e-01f, 7.36127347e-02f, 7.95459375e-02f, 5.92760481e-02f, -2.10162578e-03f, 1.46282777e-01f, -7.87987094e-03f, 7.40781426e-02f,
  -2.38079913e-02f, 1.15942275e-02f, 4.00248133e-02f, 1.26315296e-01f, 1.47687227e-01f, 6.07343428e-02f, 7.11265132e-02f, 3.85834873e-02f, 1.97989851e-01f, 1.71664581e-01f,
  -4.38170284e-02f, -4.69271690e-02f, -3.07764579e-02f, -1.97855476e-02f, 4.50229235e-02f, 5.05377874e-02f, 5.09584732e-02f, 5.85877039e-02f, -1.89894028e-02f, -5.93774533e-03f,
  1.68959089e-02f, 1.22292794e-01f, 4.94796608e-04f, -1.36146843e-02f, -2.03016065e-02f, 2.47071330e-02f, 2.05534566e-02f, 8.06725398e-02f, 3.69594097e-02f, 9.90656242e-02f,
  -1.93488318e-02f, 1.12674437e-01f, -2.24256832e-02f, 2.49154679e-02f, 1.10729478e-01f, 4.63913158e-02f, 6.94685653e-02f, 2.46187467e-02f, 1.45564303e-01f, 4.02526818e-02f,
  -3.33495773e-02f, 1.22361533e-01f, 7.36731896e-03f, 6.89864978e-02f, -2.09698733e-02f, -3.57391909e-02f, -1.16246559e-01f, -9.17745233e-02f, 1.24307815e-02f, 4.69285920e-02f,
  -5.18805422e-02f, -2.07455270e-02f, -6.08746447e-02f, -6.87865308e-03f, -5.51617518e-02f, 2.36302130e-02f, -5.91920950e-02f, -2.52515310e-03f, 3.67742106e-02f, -2.11962406e-02f,
  -5.63373566e-02f, 1.18530139e-01f, 6.72690794e-02f, -5.26365591e-04f, 8.77636522e-02f, 1.10386446e-01f, 1.59972720e-02f, 1.21882014e-01f, 1.83336869e-01f, 1.71385214e-01f,
  3.88588637e-01f, 2.06269279e-01f, 2.56612282e-02f, 1.97784859e-04f, -1.84875615e-02f, 1.37743577e-01f, 1.58415020e-01f, 1.01688318e-01f, 1.32385744e-02f, 5.46899885e-02f,
  -2.12258752e-02f, -5.78526631e-02f, 7.49614239e-02f, -5.26578687e-02f, 2.00937197e-01f, 5.06242514e-02f, -1.35154665e-01f, 8.41485187e-02f, 1.49676129e-01f, 1.39326127e-02f,
  -7.69255087e-02f, -1.92254111e-02f, 4.36171219e-02f, -1.12654651e-02f, 3.17001268e-02f, 6.29428998e-02f, 9.61248670e-03f, 4.20804583e-02f, 1.15881182e-01f, -5.89263104e-02f,
  8.70221257e-02f, 2.71393567e-01f, 9.10345763e-02f, -6.06536046e-02f, -3.85412350e-02f, 5.58497161e-02f, 1.23261012e-01f, 8.93027261e-02f, 5.94855323e-02f, 6.66730553e-02f,
  -4.33802009e-02f, 1.07065007e-01f, 1.01184964e-01f, -2.44529955e-02f, -5.44111291e-03f, 2.48633977e-02f, 9.18128935e-04f, 4.28649783e-02f, 1.20401353e-01f, -3.07694860e-02f,
  -1.27959892e-01f, 3.53081301e-02f, 1.67497620e-01f, 1.28451481e-01f, 2.85936333e-02f, 3.48103382e-02f, 1.17072858e-01f, 1.56246185e-01f, 2.25603342e-01f, 1.10500596e-01f,
  -3.61066759e-02f, -1.16717080e-02f, -1.14911430e-01f, 3.40857804e-02f, -4.98360880e-02f, -1.01902604e-01f, 1.00958524e-02f, -8.79046973e-03f, -9.50564072e-02f, 1.86999689e-03f,
  -3.50150354e-02f, -1.56274401e-02f, -5.41980304e-02f, 5.80371767e-02f, -9.08383448e-03f, 2.78087482e-02f, 2.07773820e-02f, 4.41902205e-02f, -6.11069240e-02f, -7.98470154e-02f,
  5.15940785e-02f, -1.66929383e-02f, -4.39371541e-02f, -7.27554634e-02f, -5.91960028e-02f, -3.93795557e-02f, -7.26064593e-02f, -1.11641988e-01f, -1.03703551e-01f, -9.19292495e-02f,
  -5.34001403e-02f, 1.88215226e-01f, 6.97371960e-02f, 6.25396967e-02f, 6.48351684e-02f, -1.98216434e-03f, 8.98227096e-02f, 5.74080758e-02f, 4.22132984e-02f, 1.61904141e-01f,
  1.45480588e-01f, 4.87091802e-02f, 8.22583679e-03f, 1.20025977e-01f, 5.99638447e-02f, 1.46125808e-01f, 3.10215224e-02f, 2.33535226e-02f, 1.03941731e-01f, 2.56123841e-02f,
  7.21399263e-02f, 2.89734118e-02f, 1.72189623e-01f, 1.31876115e-02f, 5.36915660e-02f, 1.76109239e-01f, 8.39352757e-02f, 2.09672406e-01f, 1.92483306e-01f, 2.46486455e-01f,
  2.50866890e-01f, 2.35912040e-01f, -1.09773129e-01f, 5.46543524e-02f, -5.34202270e-02f, 6.46625552e-03f, -9.63290110e-02f, -4.28432859e-02f, 8.26089084e-02f, 2.35015992e-02f,
  1.82602480e-01f, 1.11226074e-01f, -9.70908776e-02f, -1.38745174e-01f, -1.98298782e-01f, -1.54465243e-01f, -1.27715290e-01f, -1.34889513e-01f, -2.34308869e-01f, -1.69067979e-01f,
  -1.14119589e-01f, -7.43741393e-02f, -1.28943175e-01f, 3.02082486e-02f, 3.83648872e-02f, -6.33817390e-02f, 3.07834577e-02f, -6.42803451e-03f, -7.61276707e-02f, -6.49118125e-02f,
  -1.05565913e-01f, 1.45404056e-01f, -3.86363082e-02f, 1.98469236e-02f, 1.41559809e-01f, 1.66146189e-01f, 7.11645558e-02f, 4.76556346e-02f, -3.91274830e-03f, 3.12872380e-02f,
  5.62860183e-02f, 1.55708358e-01f, 1.19802088e-01f, 7.67359287e-02f, -1.01984153e-02f, -2.62209177e-02f, -2.90075410e-02f, -3.25825363e-02f, 6.12754636e-02f, 1.34584188e-01f,
  1.07811712e-01f, 5.42775281e-02f, 6.31587859e-03f, 1.78374781e-03f, 3.29293795e-02f, 8.84370804e-02f, 1.21825732e-01f, 1.55913949e-01f, 9.75646153e-02f, 1.27757609e-01f,
  -1.16480775e-01f, 2.15568803e-02f, 7.35589266e-02f, 8.58538821e-02f, -1.46817314e-02f, 4.20113793e-03f, -3.27318460e-02f, -7.05566406e-02f, -5.95521294e-02f, 1.00723900e-01f,
  -2.78468691e-02f, 2.85426732e-02f, 1.51657891e-02f, -4.38513309e-02f, 8.45294893e-02f, -1.64733715e-02f, -1.76984780e-02f, 3.41310203e-02f, 7.01682642e-02f, 2.95965374e-03f,
  -3.19319889e-02f, 3.48122269e-02f, -2.05026064e-02f, 7.37310871e-02f, -6.26364443e-03f, 6.39211088e-02f, -2.54284721e-02f, 5.75351827e-02f, 6.81079254e-02f, -3.25496718e-02f,
  5.49190491e-02f, 5.44619374e-02f, 4.03887667e-02f, 2.76740268e-02f, -5.79718826e-03f, 7.48891309e-02f, 1.49149239e-01f, 8.84366632e-02f, 6.39090240e-02f, 2.05229037e-02f,
  8.20083320e-02f, 1.33622035e-01f, 5.60817793e-02f, 1.03004249e-02f, -2.89139301e-02f, 1.03830993e-01f, -9.94324125e-03f, -1.83907282e-02f, 4.80544865e-02f, 1.32902622e-01f,
  2.03417819e-02f, -2.77418997e-02f, -5.56295365e-02f, 3.11618671e-02f, 1.30808959e-03f, -6.37984499e-02f, 5.16721047e-03f, 2.97217648e-02f, -1.77110191e-02f, -5.85042424e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.38049078e-01f, -2.20643990e-02f, -5.16981006e-01f, -2.22259149e-01f, -3.13498564e-02f, 1.28508940e-01f, 2.33457029e-01f, 1.22018613e-01f, -5.93753252e-03f, -4.98210788e-02f,
  -1.28470836e-02f, -9.55441967e-02f, -3.11797827e-01f, -3.95403169e-02f, -2.55497396e-02f, -7.24275038e-02f, -2.49970287e-01f, -2.96869129e-01f, -5.26292212e-02f, 3.44399512e-01f,
  2.25026831e-01f, -8.50765128e-03f, -1.30874202e-01f, 3.71668860e-03f, 2.22021528e-02f, -1.01827905e-01f, -3.02996457e-01f, -1.72926992e-01f, -7.43310228e-02f, -1.91502079e-01f,
  -2.54233062e-01f, -1.36054516e-01f, 7.93500245e-02f, -1.50093818e-02f, -9.19724479e-02f, -4.81050126e-02f, 6.25957027e-02f, -1.65097222e-01f, -6.41612336e-02f, -5.06684631e-02f,
  -4.22876216e-02f, 1.80429116e-01f, 4.98220921e-02f, 6.95967600e-02f, 8.82412419e-02f, 4.11170833e-02f, -1.82109207e-01f, -1.23948522e-01f, -1.59798905e-01f, 1.49458367e-03f,
  8.79616365e-02f, -1.25320315e-01f, -3.56166899e-01f, -4.54584099e-02f, 3.33786309e-02f, -1.89245686e-01f, -6.78765550e-02f, 8.10230449e-02f, -1.24946348e-01f, -1.78121984e-01f,
  1.91860378e-01f, 3.95151712e-02f, 4.55009341e-02f, -1.09036647e-01f, 4.59999181e-02f, -4.26274426e-02f, -1.69492587e-02f, 9.48295593e-02f, 2.85437405e-02f, -1.49305416e-02f,
  -3.58456001e-02f, -3.94293517e-02f, 1.14207398e-02f, 1.27658442e-01f, -7.39732711e-03f, -8.99365917e-02f, -5.89896226e-03f, 5.04887551e-02f, -6.46053702e-02f, 1.55028040e-02f,
  2.43866537e-02f, -1.09312953e-02f, -3.28962468e-02f, 4.58114147e-02f, 1.11590850e-03f, 2.98533123e-02f, 1.24294154e-01f, 5.84605262e-02f, -2.65621785e-02f, 4.62939665e-02f,
  -1.28846198e-01f, 1.12009002e-02f, -9.10862014e-02f, 9.98440161e-02f, -2.24527605e-02f, 8.23868290e-02f, 3.55429836e-02f, 1.30032167e-01f, -7.37357810e-02f, 1.11485235e-01f,
  6.00178540e-02f, 1.79180264e-01f, 6.65668165e-03f, 1.34032607e-01f, 1.13667056e-01f, 1.09505422e-01f, 2.97961421e-02f, -1.09499015e-01f, 3.39562558e-02f, -1.66075230e-02f,
  -1.40839204e-01f, -4.09007594e-02f, -3.15364420e-01f, -1.90953270e-01f, 9.24466401e-02f, -7.66688958e-02f, -1.87631771e-01f, 4.99007590e-02f, -1.24428906e-01f, -9.33198482e-02f,
  -2.42662966e-01f, -3.05106819e-01f, -8.16087276e-02f, 8.13794360e-02f, -3.83746587e-02f, -4.06436592e-01f, -7.09463894e-01f, -2.27305830e-01f, 7.12126447e-03f, -2.93625414e-01f,
  -1.32543638e-01f, 1.70094475e-01f, 1.47846779e-02f, 1.09321633e-02f, -2.05049291e-01f, -3.38386357e-01f, -3.51185948e-02f, 2.07212046e-01f, 1.93849787e-01f, 4.33870926e-02f,
  -2.25216169e-02f, 1.52683660e-01f, 3.08999330e-01f, 2.40933299e-01f, 2.00330302e-01f, 1.45034999e-01f, 5.91386482e-02f, 9.98147950e-02f, -4.01887707e-02f, 2.77641416e-01f,
  -9.38614532e-02f, 5.63890487e-02f, 3.26070786e-02f, 2.66061634e-01f, 8.92987102e-02f, -1.00643881e-01f, -4.62473109e-02f, 6.91159964e-02f, -1.17026716e-01f, 1.17190797e-02f,
  -1.27871605e-02f, 1.06701620e-01f, 2.94114649e-02f, -7.27107152e-02f, -6.33959845e-02f, -1.71165735e-01f, 5.54554239e-02f, 1.02323636e-01f, -8.84867013e-02f, -1.00193555e-02f,
  5.15472069e-02f, 5.33470809e-02f, -3.15443240e-02f, -1.22975610e-01f, -6.40902817e-02f, 1.75194070e-01f, -7.45342951e-03f, 1.57044247e-01f, -6.46017194e-02f, -5.63291833e-03f,
  1.64412819e-02f, 1.44683331e-01f, -9.33237970e-02f, -1.10870399e-01f, -9.52252075e-02f, -5.35724461e-02f, 1.18183590e-01f, -6.67799450e-03f, 1.61642525e-02f, -3.61043625e-02f,
  -6.92333952e-02f, -3.34102996e-02f, 9.89342704e-02f, 3.55752110e-02f, 2.14376003e-01f, 4.67097461e-02f, -6.16817735e-02f, 1.62572302e-02f, 8.47333595e-02f, -1.63982213e-02f,
  1.27643244e-02f, -7.51240999e-02f, 3.73848230e-02f, -1.86949652e-02f, -6.01289608e-02f, 8.92079771e-02f, 7.88960829e-02f, -8.11008457e-03f, 1.36919856e-01f, 5.80517389e-02f,
  -1.58632278e-01f, -7.57680386e-02f, -2.40215108e-01f, 5.93197495e-02f, -4.28797789e-02f, 1.14904149e-02f, 4.23520692e-02f, -9.21235904e-02f, -5.13634384e-02f, -4.60309461e-02f,
  -1.02142103e-01f, -7.37025067e-02f, -3.63933779e-02f, 4.21649851e-02f, -8.29452574e-02f, -1.32057726e-01f, -2.16235429e-01f, -1.30875692e-01f, -1.32001638e-01f, -8.19412842e-02f,
  -1.24520138e-01f, -3.48210543e-01f, -5.05343020e-01f, -4.69040185e-01f, -1.49708062e-01f, -2.27126300e-01f, -2.46894285e-01f, -1.40041351e-01f, -4.45269734e-01f, -6.53407335e-01f,
  5.05154431e-01f, -8.17383900e-02f, -2.24214464e-01f, 2.92414844e-01f, 1.51555046e-01f, -2.45580018e-01f, -5.88651359e-01f, -3.54616821e-01f, 3.53447586e-01f, 3.33773755e-02f,
  4.59362715e-02f, 1.33733265e-02f, 4.91819568e-02f, -2.02355877e-01f, -6.53539181e-01f, -4.06112552e-01f, -3.09288412e-01f, -4.24304843e-01f, -6.74591005e-01f, -4.71135348e-01f,
  -4.19470966e-02f, 3.59039903e-02f, -2.18068212e-01f, -1.67038530e-01f, 4.13808763e-01f, 2.59897381e-01f, 2.30556250e-01f, 1.56549588e-01f, -1.32323913e-02f, 4.30196881e-01f,
  1.94233835e-01f, 3.50999609e-02f, -3.08103889e-01f, -5.88422641e-02f, 1.61846504e-01f, -7.33504593e-02f, -2.44881406e-01f, 2.42199991e-02f, -6.39340654e-02f, -5.08618243e-02f,
  1.35841325e-01f, -1.29301578e-01f, 5.82518950e-02f, 1.80938770e-03f, -6.76784217e-02f, -1.16054185e-01f, -1.73648342e-01f, -2.80746490e-01f, -9.98483896e-02f, -1.11096106e-01f,
  -5.73863834e-02f, 4.19656262e-02f, -6.69860467e-02f, -2.07650796e-01f, -1.63014963e-01f, -7.17918295e-03f, -4.66959402e-02f, -4.84866230e-03f, -1.36890739e-01f, 2.52137631e-01f,
  -1.03347056e-01f, 3.92424986e-02f, 1.52319083e-02f, 5.65585010e-02f, -4.44412753e-02f, 1.16609894e-01f, 8.50242004e-02f, -4.08402085e-02f, -4.00427058e-02f, 3.59694026e-02f,
  -7.96777830e-02f, -4.98072989e-02f, -6.19527102e-02f, 2.58077569e-02f, -5.55369332e-02f, -3.56447906e-03f, 7.80636743e-02f, -7.74206296e-02f, -4.03198004e-02f, -1.61843572e-03f,
  -8.84517940e-05f, 1.19630061e-01f, 1.90232694e-01f, -1.71341412e-02f, -4.65665832e-02f, -2.91550998e-02f, 5.34650609e-02f, 3.91030172e-03f, -8.51970986e-02f, 1.39106410e-02f,
  3.54102850e-01f, -3.48739922e-01f, 2.16349676e-01f, -2.69793004e-01f, 7.89835528e-02f, -2.69001219e-02f, 9.94408652e-02f, -1.56391397e-01f, 7.48143643e-02f, -3.45975608e-02f,
  -1.61004201e-01f, -3.51606719e-02f, 1.12571992e-01f, -4.74772118e-02f, -2.04130158e-01f, -3.31882313e-02f, -1.88692749e-01f, 9.95353535e-02f, -1.47260517e-01f, 1.75734073e-01f,
  6.78647542e-03f, -2.01943859e-01f, 6.51301444e-02f, -1.31072104e-02f, 1.24443986e-01f, 8.46903713e-04f, 6.45375550e-02f, 3.76498625e-02f, -1.69728726e-01f, -3.69368754e-02f,
  3.36881220e-01f, -5.35564065e-01f, -1.47476181e-01f, -2.11553559e-01f, -1.99567482e-01f, -1.03155099e-01f, -6.14475787e-01f, -9.28663015e-02f, -1.61307293e-03f, -5.43196559e-01f,
  -1.28666192e-01f, 4.05159473e-01f, 2.93262094e-01f, 2.30585486e-01f, 2.74980545e-01f, -6.28943503e-01f, -4.06409264e-01f, 1.91085517e-01f, 4.81122792e-01f, -1.99348032e-02f,
  -2.54067242e-01f, -6.79609403e-02f, 1.95013523e-01f, 1.04603603e-01f, -5.34344077e-01f, 2.75372434e-02f, -3.14727694e-01f, -2.25317225e-01f, -2.44027555e-01f, -4.83220458e-01f,
  -3.62861603e-01f, 4.02445421e-02f, 1.97888419e-01f, 2.42203772e-01f, -1.24066539e-01f, 2.44313218e-02f, -4.38353121e-02f, 1.30115319e-02f, 2.96686348e-02f, -1.27745166e-01f,
  7.97881931e-02f, 1.90665290e-01f, 8.67178366e-02f, 3.07749398e-02f, -1.64776817e-02f, 8.41009989e-02f, -1.16752498e-02f, 1.03576176e-01f, 1.35707781e-01f, -2.19295561e-01f,
  -2.58853137e-01f, -2.35761814e-02f, 1.62887231e-01f, -7.03593418e-02f, 6.85556158e-02f, 3.04635227e-01f, -1.36227176e-01f, 5.54964542e-02f, 1.99313372e-01f, -4.82686818e-01f,
  -1.66679472e-01f, 2.39533316e-02f, -8.19824934e-02f, 3.26750353e-02f, -9.95751843e-02f, -4.27409122e-03f, -1.58957089e-03f, -2.07511038e-02f, 6.71215057e-02f, -7.63712376e-02f,
  6.83813691e-02f, -3.36976536e-02f, 2.74337847e-02f, -1.19639233e-01f, 1.86603889e-02f, -2.11070850e-02f, -7.04274327e-02f, -7.03220516e-02f, 3.80198732e-02f, -2.42164806e-02f,
  1.05573066e-01f, 9.96342115e-03f, 2.35027540e-02f, 3.75486016e-02f, 6.51595443e-02f, 1.21710829e-01f, 5.06550558e-02f, 9.73585695e-02f, -1.51587687e-02f, -6.88848943e-02f,
  6.98064268e-02f, 4.58094031e-01f, -2.93991297e-01f, 4.07892503e-02f, -9.17606279e-02f, 3.12806517e-02f, -1.02897793e-01f, -3.74150090e-02f, 9.82388854e-04f, 1.04278829e-02f,
  3.67947761e-03f, 9.36068408e-03f, 3.55610140e-02f, 2.84563266e-02f, -9.74279940e-02f, -4.39882502e-02f, -1.04928158e-01f, 1.13872640e-01f, 5.33247255e-02f, -3.00286114e-01f,
  -2.86827385e-01f, -2.74396297e-02f, 8.05380642e-02f, -6.48984015e-02f, -6.54513240e-02f, 2.02667832e-01f, -2.67740995e-01f, -1.77562162e-01f, 1.70572579e-01f, -5.11984468e-01f,
  -1.95434511e-01f, -3.63684446e-01f, -1.71055615e-01f, 6.01522289e-02f, -1.34872869e-01f, -2.74421990e-01f, -3.28399986e-01f, -7.73631707e-02f, 9.30577517e-02f, -1.37921527e-01f,
  -1.26130611e-01f, 3.96329686e-02f, 1.13893427e-01f, 9.18000340e-02f, 4.66922186e-02f, -1.36088908e-01f, 1.21745737e-02f, 1.17249094e-01f, 1.05633631e-01f, -1.16594084e-01f,
  2.49062926e-02f, 3.40807199e-01f, 3.80278856e-01f, 1.27452314e-01f, -1.66761771e-01f, -3.95481428e-03f, 9.46618766e-02f, -3.12633254e-02f, -1.96594283e-01f, -3.47768188e-01f,
  -2.34078854e-01f, -3.11711073e-01f, 1.02505207e-01f, 9.13500506e-03f, 2.08056979e-02f, -3.51116769e-02f, -1.00813419e-01f, 7.26720616e-02f, -1.28717288e-01f, -6.96846321e-02f,
  -2.23651938e-02f, -1.17159724e-01f, -6.16363809e-02f, -1.55930920e-02f, -4.47046496e-02f, -5.00606373e-02f, 2.38325328e-01f, 2.27479357e-02f, 1.25163272e-01f, -1.11352824e-01f,
  -1.83806807e-01f, -3.18862766e-01f, -2.28294358e-01f, -4.63708565e-02f, -8.59510154e-02f, 1.03696659e-01f, -1.36995852e-01f, -2.10830525e-01f, 1.24683054e-02f, -2.84467787e-01f,
  6.96080998e-02f, 9.85908210e-02f, 8.50213170e-02f, -2.06706449e-02f, 1.23297721e-01f, -5.85566089e-02f, -7.40202516e-02f, 6.02956768e-03f, -7.39480555e-02f, -8.48175138e-02f,
  -4.54218127e-02f, 8.74580741e-02f, 1.52326450e-02f, -1.22960478e-01f, -7.05234632e-02f, 1.30622769e-02f, -1.00925811e-01f, 1.34829834e-01f, 2.41706846e-03f, 3.22179794e-02f,
  -5.71224205e-02f, -3.71682160e-02f, 3.91429141e-02f, -1.52501315e-02f, -1.13293730e-01f, 8.63664672e-02f, 2.22299248e-02f, 1.93830431e-02f, 8.24984089e-02f, -6.79010749e-02f,
  2.57588059e-01f, 3.40750039e-01f, -1.09959602e-01f, -6.94641098e-02f, -1.06852323e-01f, 1.33993357e-01f, -1.18226586e-02f, 1.70686036e-01f, -8.99503287e-03f, -9.32546556e-02f,
  -1.55980423e-01f, -1.40367851e-01f, -6.08280078e-02f, 2.24256180e-02f, -5.81405386e-02f, -4.98960726e-02f, 4.71940171e-03f, -1.34670049e-01f, 8.47505406e-02f, -2.34233290e-02f,
  3.82385403e-02f, -2.12424189e-01f, -1.10151783e-01f, -5.43137416e-02f, -1.46837264e-01f, -7.80109614e-02f, -7.64283016e-02f, -1.39360204e-01f, 4.43452364e-03f, -7.57521577e-03f,
  3.21524650e-01f, -2.00241178e-01f, 2.72102654e-01f, 5.08837141e-02f, 1.86842397e-01f, 2.16390952e-01f, 1.38265416e-01f, 5.51991239e-02f, 4.82980199e-02f, 2.33720466e-02f,
  8.96070674e-02f, 1.66727513e-01f, 6.52327389e-02f, 9.38773081e-02f, 5.86708672e-02f, 7.50360787e-02f, -1.83652379e-02f, 1.03651695e-01f, 1.58744842e-01f, -6.92419382e-03f,
  -1.31284535e-01f, -1.02665938e-01f, -2.52818279e-02f, -2.27969512e-02f, -1.57362580e-01f, -3.36614600e-03f, -1.07809357e-01f, -2.65169621e-01f, -1.18911482e-01f, -2.39871249e-01f,
  -4.89721894e-02f, -1.15413005e-02f, -7.44350813e-03f, -1.93020165e-01f, -3.80085595e-03f, -4.29241210e-02f, 1.12879664e-01f, -1.33901551e-01f, -1.91598594e-01f, -1.49952829e-01f,
  -1.02930695e-01f, 2.87629035e-03f, 5.80592938e-02f, 1.83561035e-02f, -1.41546056e-01f, -9.16470075e-04f, 2.59508286e-02f, 1.40368855e-02f, -1.15851462e-02f, -8.10000002e-02f,
  4.74421009e-02f, 6.01048097e-02f, 1.56142056e-01f, 1.35005653e-01f, 1.00797094e-01f, -6.98052645e-02f, 2.54521053e-02f, 5.68971001e-02f, 1.30187005e-01f, 9.73408520e-02f,
  1.01392023e-01f, 1.91836372e-01f, 1.79566264e-01f, 8.64289030e-02f, 1.08778633e-01f, 6.18892685e-02f, -7.64069259e-02f, -7.12464601e-02f, 1.97923616e-01f, 1.52147651e-01f,
  4.98305783e-02f, 1.60069019e-01f, 6.73340112e-02f, 1.07939892e-01f, 1.24147080e-01f, -2.45503355e-02f, 9.94017422e-02f, 2.00096481e-02f, 2.48765443e-02f, -9.86005813e-02f,
  1.21460021e-01f, -7.05551878e-02f, -6.90547228e-02f, 3.50458957e-02f, -3.01701538e-02f, 7.22107366e-02f, 1.24385357e-01f, 7.35579357e-02f, -2.79004145e-02f, 2.99802404e-02f,
  -1.29048303e-01f, 1.38831362e-01f, -5.88608384e-02f, -1.28600761e-01f, -7.99847990e-02f, -8.70071724e-02f, 1.38051257e-01f, -1.83952510e-01f, -2.30394229e-01f, -2.62352645e-01f,
  -1.54854223e-01f, -3.64912935e-02f, 9.35346186e-02f, -1.23429559e-02f, 8.53769034e-02f, 5.63836060e-02f, -2.70987134e-02f, 6.14741035e-02f, -1.02491461e-01f, -1.11799529e-02f,
  2.31224615e-02f, 1.78506583e-01f, 1.69134855e-01f, 1.81612730e-01f, 1.03858106e-01f, 1.25726268e-01f, 1.28003225e-01f, 1.37605563e-01f, 9.86849740e-02f, 3.51845883e-02f,
  9.47751164e-01f, 2.85281658e-01f, -1.16447508e-01f, 2.15347201e-01f, -2.65393704e-02f, -4.26642969e-03f, 1.00170441e-01f, 1.05226353e-01f, 8.91470015e-02f, 2.77366638e-01f,
  3.03223461e-01f, 2.11311266e-01f, 2.66660959e-01f, 1.79191306e-01f, 1.74433395e-01f, -7.41925538e-02f, -1.64471064e-02f, 5.01013845e-02f, -2.51271427e-02f, 9.65119805e-03f,
  6.87086657e-02f, 1.76779225e-01f, 1.05981439e-01f, 1.22794718e-01f, -2.23453399e-02f, -1.63188484e-02f, 5.64325862e-02f, -6.97675860e-03f, -4.53243107e-02f, -2.10504234e-01f,
  -3.39251786e-01f, 2.34105393e-01f, -6.00683205e-02f, -1.47063006e-03f, -9.29611176e-02f, -1.52447689e-02f, 4.70707342e-02f, -9.30282772e-02f, -5.11929020e-02f, -7.62614459e-02f,
  -1.99206900e-02f, 4.00203057e-02f, -5.53848483e-02f, -5.13764024e-02f, -8.04278851e-02f, 2.72317398e-02f, 3.98554243e-02f, -6.02487400e-02f, -5.16198203e-02f, -2.54812017e-02f,
  3.84460716e-03f, 4.27760445e-02f, -1.31081149e-01f, -7.97227994e-02f, 7.89623782e-02f, -3.07069700e-02f, 4.39833589e-02f, -9.60997492e-02f, -1.69942137e-02f, -2.89356727e-02f,
  -7.46598840e-02f, -4.42800149e-02f, 1.03628278e-01f, 1.65681079e-01f, 2.83472806e-01f, 9.67350528e-02f, -1.05498463e-01f, -3.89664881e-02f, -1.77184232e-02f, -7.48653263e-02f,
  -1.83846191e-01f, -4.59265932e-02f, -4.76262867e-02f, 9.01033133e-02f, 1.74417362e-01f, 2.34949086e-02f, -2.18455523e-01f, -2.58209370e-02f, 5.58687188e-02f, 1.02291912e-01f,
  4.44263220e-02f, -2.17939973e-01f, -2.36578938e-02f, -1.87427253e-01f, -8.05701613e-02f, -5.71384765e-02f, -4.75817397e-02f, -2.83306791e-03f, 1.18957132e-01f, 2.10355986e-02f,
  -1.49202079e-01f, 3.02041560e-01f, -9.79305059e-03f, -1.15005806e-01f, -2.58068919e-01f, -8.25160965e-02f, 2.78609935e-02f, -5.31343855e-02f, -9.51918215e-02f, -1.71380281e-01f,
  -1.29280746e-01f, -3.39126624e-02f, 1.04315607e-02f, -1.61141064e-02f, -1.35908067e-01f, 2.13715434e-02f, -4.35488671e-02f, -4.18788120e-02f, -3.62290740e-02f, -1.22829087e-01f,
  -8.30125213e-02f, -7.64993057e-02f, -1.51569918e-01f, -4.92103174e-02f, -2.37039495e-02f, -2.11486481e-02f, -7.63582438e-02f, 7.77922198e-02f, -5.51756322e-02f, 1.09440029e-01f,
  -3.42894286e-01f, -2.37761550e-02f, -2.60436279e-03f, -1.00213423e-01f, 2.68957168e-01f, 2.96971917e-01f, 6.40060663e-01f, 2.84155428e-01f, -4.39732037e-02f, 1.45126686e-01f,
  2.96213720e-02f, -1.66674972e-01f, -1.20797805e-01f, -5.31076081e-03f, 1.79696411e-01f, 3.43450159e-01f, 1.64192572e-01f, -9.70944911e-02f, -8.56854990e-02f, 1.86477929e-01f,
  1.64532050e-01f, -7.81099871e-02f, -3.26485157e-01f, -1.03923552e-01f, -2.26242587e-01f, -1.66651204e-01f, -1.22773595e-01f, -2.21938663e-03f, 1.59580156e-01f, -6.70639202e-02f,
  -2.68154681e-01f, 1.98986009e-02f, 1.65304035e-01f, -2.56932378e-01f, -1.69299871e-01f, 3.04231439e-02f, 1.16148703e-01f, -2.66526770e-02f, 2.14307338e-01f, 1.04514800e-01f,
  -1.53835639e-01f, -1.47893682e-01f, -6.30179495e-02f, 1.46795260e-02f, -9.14385170e-02f, 5.29018007e-02f, -1.72834024e-01f, -1.68813020e-01f, -3.63786340e-01f, -1.38857931e-01f,
  1.13360405e-01f, -8.78203809e-02f, -1.60875648e-01f, 9.19743627e-02f, -1.24034248e-01f, -2.17089429e-01f, -1.62523821e-01f, -1.34316310e-01f, -8.07521790e-02f, -2.60557503e-01f,
  5.60586751e-02f, 1.06742664e-04f, -2.40133330e-02f, -1.29982188e-01f, -2.94925906e-02f, -7.75763812e-03f, -3.37644182e-02f, -1.28758214e-02f, -4.04555984e-02f, -3.56576517e-02f,
  -6.72872588e-02f, 7.06323907e-02f, -9.12580825e-03f, -3.35481167e-02f, -1.44209294e-02f, 1.39244363e-01f, 1.82730913e-01f, 3.72560285e-02f, -1.86423771e-03f, 4.90955524e-02f,
  2.61767227e-02f, -8.08770582e-02f, -2.49008253e-01f, -3.95763740e-02f, 8.34479649e-03f, -7.93885365e-02f, -2.02844031e-02f, -4.02937979e-02f, -1.01405770e-01f, 2.15833232e-01f,
  -2.20559016e-01f, 2.84132212e-01f, -2.10571796e-01f, -1.26925498e-01f, -1.40286997e-01f, 1.07227750e-02f, 6.06063381e-02f, 3.90937887e-02f, -9.56238899e-03f, -9.19726118e-02f,
  5.66258058e-02f, 3.46472599e-02f, -5.28650023e-02f, 1.51919022e-01f, 1.33058026e-01f, 5.15819639e-02f, 7.31779337e-02f, 4.83448878e-02f, -1.41398892e-01f, -5.96191324e-02f,
  5.52317873e-02f, 1.63207874e-01f, -1.77185051e-02f, 8.71151388e-02f, -6.96151108e-02f, -8.28302354e-02f, -1.65926799e-01f, -4.90304315e-03f, 6.21095225e-02f, 1.49991676e-01f,
  5.39612532e-01f, -1.13177761e-01f, -4.98122990e-01f, 3.16886038e-01f, -2.18388230e-01f, -2.72021472e-01f, -3.78363967e-01f, 6.98771551e-02f, 3.03651333e-01f, -2.95531303e-01f,
  -3.11463505e-01f, 5.78066483e-02f, -1.72764838e-01f, -1.79420277e-01f, -2.42357433e-01f, -4.22892034e-01f, -3.30411792e-01f, -6.82015568e-02f, 1.49690107e-01f, 1.83836684e-01f,
  1.15918681e-01f, 1.98712170e-01f, 2.76797086e-01f, 1.85012236e-01f, 1.56163126e-01f, 1.52397417e-02f, -1.73377991e-01f, 2.63310708e-02f, -2.73687989e-01f, 7.40095228e-02f,
  1.54010411e-02f, 3.23015213e-01f, -1.70661747e-01f, 9.54421759e-02f, -1.69542477e-01f, -1.11395800e-02f, -2.11690599e-03f, 8.60337541e-02f, -6.92364424e-02f, -1.94127969e-02f,
  -2.07640484e-01f, -3.66005935e-02f, 1.33999798e-03f, -3.91875878e-02f, 4.12704088e-02f, -3.75120230e-02f, -4.41616885e-02f, 1.85233708e-02f, -3.36169265e-02f, -3.02762608e-03f,
  -1.46675244e-01f, 2.52441987e-02f, -1.91695735e-01f, -1.27770066e-01f, 3.70289944e-02f, -7.26218000e-02f, -8.24057385e-02f, 1.65863022e-01f, -1.26676679e-01f, 2.07715541e-01f,
  1.56388462e-01f, -9.48458835e-02f, -1.11828908e-01f, -6.54743239e-02f, -3.92390564e-02f, -8.59055370e-02f, 5.02894558e-02f, 2.65568052e-03f, 3.50999050e-02f, -3.52659412e-02f,
  -2.56366543e-02f, 3.13014127e-02f, 3.15163024e-02f, 7.19099268e-02f, 1.24367103e-01f, 3.97339575e-02f, -3.17244641e-02f, 2.84804013e-02f, 4.99147624e-02f, 5.72887324e-02f,
  8.33118260e-02f, -1.27686068e-01f, -1.90241635e-02f, 3.82780135e-02f, -9.80133265e-02f, -3.68833505e-02f, 7.91259408e-02f, 4.14744504e-02f, 1.36967838e-01f, 6.80430904e-02f,
  5.50508760e-02f, -3.49510908e-01f, -3.55113335e-02f, -4.70747277e-02f, -1.15930952e-01f, -1.15852855e-01f, -1.14642940e-01f, -8.71909782e-02f, -8.23872685e-02f, -3.91036682e-02f,
  -1.56422704e-01f, -4.42313030e-02f, -2.00463962e-02f, -6.21270277e-02f, -1.12589290e-02f, -9.43540186e-02f, -3.11284989e-01f, -2.52036691e-01f, -1.77908063e-01f, -5.65853678e-02f,
  -1.40532926e-01f, -1.15696184e-01f, -2.06506297e-01f, -2.70662427e-01f, 8.39380324e-02f, -1.87144026e-01f, -2.53502011e-01f, -7.49865025e-02f, -4.10814524e-01f, -2.43370935e-01f,
  -4.61531729e-01f, -3.38838369e-01f, -2.71023303e-01f, -6.74469292e-01f, -1.08777754e-01f, 2.05633581e-01f, 2.20806133e-02f, 4.07252386e-02f, -1.53749466e-01f, -3.34833592e-01f,
  -1.82025775e-01f, -8.23622569e-02f, -2.73769945e-01f, -1.29598007e-01f, -7.81558156e-02f, -3.21626157e-01f, -4.17408496e-01f, -3.40572894e-01f, 1.36760831e-01f, 1.87719822e-01f,
  -4.49336432e-02f, -4.20533568e-01f, -2.67700881e-01f, -2.24463850e-01f, -4.61853057e-01f, -2.90913880e-01f, -4.18136567e-01f, -3.70953381e-01f, -9.26681384e-02f, -4.74902838e-01f,
  -3.51350367e-01f, 5.36294840e-02f, 2.44446158e-01f, -9.29505657e-03f, -2.22667485e-01f, 8.92717391e-02f, 4.97870184e-02f, 9.63114575e-03f, 1.45947948e-01f, -1.23812087e-01f,
  -6.67575374e-02f, 1.36940971e-01f, -1.05159722e-01f, 5.15470877e-02f, -1.37198523e-01f, 1.78366095e-01f, -5.81578985e-02f, -2.56540645e-02f, -1.10025093e-01f, 2.06927344e-01f,
  1.84739739e-01f, 4.56819311e-02f, 9.23455209e-02f, 1.07812524e-01f, 1.39971420e-01f, 4.41263542e-02f, 4.98939455e-02f, 1.27374992e-01f, 9.33974981e-02f, -2.92891979e-01f,
  -6.53076246e-02f, -1.57993004e-01f, 7.23883957e-02f, 6.74929619e-02f, 6.95097223e-02f, 6.75262585e-02f, -7.76851259e-04f, -2.01129969e-02f, 7.97891766e-02f, -1.17424056e-01f,
  -6.63474575e-02f, -3.83205488e-02f, -6.20315596e-02f, -1.02939315e-01f, -6.46502897e-02f, -2.71828920e-02f, -7.79864118e-02f, -2.75489092e-02f, 1.98698062e-02f, -3.94587182e-02f,
  1.01349533e-01f, 4.92427796e-02f, -1.89758137e-01f, 3.28316842e-03f, 7.65560195e-02f, -1.03902109e-01f, 6.60477802e-02f, -7.60511355e-03f, -6.18650131e-02f, 7.76395872e-02f,
  -4.34937268e-01f, 2.36867726e-01f, -3.79226208e-01f, 1.21364087e-01f, -5.08969016e-02f, 7.91615769e-02f, -6.99019581e-02f, 1.49292359e-02f, -3.58330794e-02f, -1.58447474e-01f,
  1.83898151e-01f, -1.04839101e-01f, -1.67656049e-01f, 4.73744757e-02f, -7.35439211e-02f, 1.18385427e-01f, 5.46253845e-03f, -1.87008262e-01f, 1.11062326e-01f, 4.78933081e-02f,
  -5.10192364e-02f, 1.41706601e-01f, -5.03936298e-02f, -1.50859103e-01f, -2.87704486e-02f, 2.22525597e-02f, -1.08245783e-01f, -6.61626756e-02f, 7.93840587e-02f, -3.90712351e-01f,
  2.45477572e-01f, -1.23057052e-01f, 1.80610284e-01f, 2.48952866e-01f, 4.22219813e-01f, 3.35392088e-01f, 1.53306767e-01f, 1.57309771e-01f, 1.46621123e-01f, 2.17141896e-01f,
  2.14707017e-01f, 1.00111872e-01f, 4.26052436e-02f, 7.49653652e-02f, -3.00848354e-02f, 1.47426322e-01f, 5.93165122e-02f, 1.14863649e-01f, 7.92493597e-02f, 1.43644467e-01f,
  8.15439895e-02f, 1.33884281e-01f, 1.36669487e-01f, 2.24187858e-02f, 6.09175116e-02f, 2.83859577e-02f, 1.91045541e-03f, 2.90465597e-02f, 1.10229820e-01f, -3.62306908e-02f,
  -2.00219855e-01f, -5.69733083e-02f, 9.35373269e-03f, -7.15099275e-02f, 4.36560996e-02f, -1.48433177e-02f, 7.81544484e-03f, -1.16361737e-01f, -1.88706927e-02f, -9.74318385e-02f,
  -1.11336552e-01f, -3.78107205e-02f, 1.09760337e-01f, 1.28690165e-03f, 4.79512624e-02f, 8.07637442e-03f, -1.42423809e-01f, -9.05920044e-02f, -1.06020160e-01f, -3.67716923e-02f,
  9.41083394e-03f, 9.29838270e-02f, 1.44597441e-01f, 7.99706355e-02f, -2.35110358e-03f, 7.96130598e-02f, -7.44648576e-02f, -8.55616108e-02f, -1.44606931e-02f, 6.02363646e-02f,
  3.83193672e-01f, 1.47877529e-01f, 1.52976811e-01f, 2.01310232e-01f, 5.48348203e-02f, 1.32627353e-01f, 7.91349560e-02f, 2.08418027e-01f, 2.92416334e-01f, 1.23402834e-01f,
  -8.77236426e-02f, 4.34894152e-02f, 9.75194871e-02f, 1.63037181e-01f, 2.09869593e-01f, 1.15964778e-01f, 9.80948955e-02f, 1.00352056e-01f, 9.31758583e-02f, 6.65997565e-02f,
  2.78946776e-02f, -4.12357897e-02f, 8.79954174e-02f, -1.22473218e-01f, -4.92435787e-03f, 1.30300581e-01f, 1.00089900e-01f, 1.36708975e-01f, 1.50555715e-01f, 1.48568109e-01f,
  -9.34750140e-02f, 1.95836857e-01f, 7.67681077e-02f, -8.05110559e-02f, -9.56743211e-02f, -9.04541984e-02f, 4.80385311e-02f, 9.68748331e-03f, -6.74263015e-02f, -3.98499370e-02f,
  2.09085215e-02f, 7.01968968e-02f, 2.61695012e-02f, 2.12195050e-02f, 5.08493260e-02f, 1.07284367e-01f, 1.61310052e-03f, 1.08499929e-01f, -5.53926826e-02f, -4.86173443e-02f,
  5.12305424e-02f, 1.37148336e-01f, 7.16976598e-02f, 2.39888683e-01f, 1.44985348e-01f, 2.43727952e-01f, 1.20715700e-01f, 6.03044257e-02f, 6.55685887e-02f, 1.30501673e-01f,
  6.41422644e-02f, 6.50942385e-01f, -7.26587951e-01f, 3.26653570e-01f, -1.76174685e-01f, -3.10444534e-01f, 2.53016412e-01f, 3.18482667e-01f, 3.28392267e-01f, 3.37674558e-01f,
  -2.35091180e-01f, -5.49796402e-01f, -2.49278918e-01f, -1.50268361e-01f, -1.88096270e-01f, 4.02700603e-01f, 4.20760751e-01f, -4.03733850e-01f, -6.48031414e-01f, -1.98489934e-01f,
  2.70870835e-01f, 3.27866465e-01f, 1.53680891e-02f, -6.69697300e-02f, 3.14854145e-01f, -1.39918074e-01f, 2.40672782e-01f, 7.08691925e-02f, 2.17200462e-02f, 2.36976787e-01f,
  -3.55419815e-01f, 1.87234581e-03f, -3.31381738e-01f, -1.81369901e-01f, -1.69108257e-01f, -3.83506007e-02f, -1.32407099e-01f, -1.44058138e-01f, -1.30985752e-01f, -6.88765245e-03f,
  -3.69244248e-01f, -2.12869912e-01f, -2.96668917e-01f, 1.00963391e-01f, -1.52404711e-01f, -2.19751000e-01f, 1.25258178e-01f, -6.18399903e-02f, -4.96424884e-02f, -2.59474486e-01f,
  1.89157531e-01f, -3.98258626e-01f, -4.92183417e-01f, 1.43470429e-02f, -2.27784902e-01f, -3.03166211e-01f, -1.54577643e-01f, -2.06748813e-01f, -2.33862087e-01f, 4.65395480e-01f,
  1.81213036e-01f, -4.80420515e-02f, -6.18921546e-03f, 1.29029915e-01f, 2.03406587e-01f, -1.16022937e-02f, 5.69085628e-02f, 8.95284489e-02f, -6.57876357e-02f, -7.59900212e-02f,
  -7.46690407e-02f, -3.69705516e-03f, -9.22539011e-02f, 5.13480641e-02f, -4.64666598e-02f, 6.93792943e-03f, -3.73442248e-02f, 2.42964625e-01f, -1.35350116e-02f, 7.95820579e-02f,
  -6.32312745e-02f, -1.21569388e-01f, -1.52759030e-01f, -7.89930224e-02f, 1.36543602e-01f, 5.21115959e-03f, 7.76395500e-02f, 4.23424542e-02f, 5.98304793e-02f, 9.28789452e-02f,
  3.11418205e-01f, 3.32132317e-02f, 1.34822816e-01f, 4.25898507e-02f, 5.11097535e-02f, -2.80128978e-02f, 1.36838451e-01f, 1.18032053e-01f, -4.93188687e-02f, -2.11793780e-01f,
  -3.02548140e-01f, -1.44032806e-01f, -4.26674187e-02f, -1.33581564e-01f, -2.97687322e-01f, -7.54161850e-02f, 3.16508174e-01f, -7.75520280e-02f, 6.41221330e-02f, 7.45841395e-03f,
  4.17722076e-01f, 1.44418702e-01f, -1.92616638e-02f, 1.48896277e-01f, 7.72399381e-02f, -4.40217182e-02f, -4.54845130e-02f, 5.15301488e-02f, -1.53437778e-01f, 8.08753490e-01f,
  2.35965520e-01f, 2.61855781e-01f, 2.53772110e-01f, 2.15605229e-01f, 1.98566467e-01f, 2.92891949e-01f, 3.07772964e-01f, 1.54924810e-01f, -3.94861139e-02f, 1.45426899e-01f,
  2.67654687e-01f, 8.15266818e-02f, 1.45954788e-01f, 1.39849260e-01f, 2.36904487e-01f, 1.24412507e-01f, 6.88095316e-02f, 9.31458622e-02f, 1.22345880e-01f, 5.44465296e-02f,
  -1.33783026e-02f, 2.16785800e-02f, 5.96365556e-02f, 8.40383843e-02f, -2.04857681e-02f, 1.04645230e-01f, 5.37200505e-03f, 1.20386638e-01f, 1.96061432e-01f, -8.73034224e-02f,
  -2.19726965e-01f, 1.36915252e-01f, -1.17933778e-02f, 1.88891012e-02f, 5.85753806e-02f, -5.34586646e-02f, -7.11518750e-02f, -1.51895031e-01f, -6.62198886e-02f, -1.31692767e-01f,
  -9.88552943e-02f, 7.83560239e-03f, -6.04758821e-02f, -3.46841514e-02f, -4.00756598e-02f, 2.43230090e-02f, -9.53370556e-02f, -6.84783459e-02f, 1.55242682e-01f, 4.41208854e-02f,
  3.05014607e-02f, -2.58668177e-02f, 7.23589137e-02f, 7.64372647e-02f, 2.21208856e-01f, 1.16484627e-01f, -4.83249985e-02f, -1.58783291e-02f, 8.08701441e-02f, 1.10570583e-02f,
  -2.95103099e-02f, 2.90388316e-01f, 2.34717518e-01f, -1.86683852e-02f, 1.98732205e-02f, -7.76125118e-02f, 4.27480321e-03f, 1.03403337e-01f, 6.77967593e-02f, 7.96171129e-02f,
  -4.06687222e-02f, 1.35399610e-01f, 2.92544141e-02f, 4.29729857e-02f, 7.43464977e-02f, 7.76922330e-02f, -2.59546209e-02f, 8.47832710e-02f, 6.61717579e-02f, -1.01662084e-01f,
  -1.54431639e-02f, -6.63292632e-02f, -2.55168319e-01f, -1.09021440e-01f, -2.53063291e-01f, 4.84113134e-02f, -8.58859345e-02f, -7.51717612e-02f, -8.32205266e-02f, -2.83929966e-02f,
  -4.82756913e-01f, 2.89441288e-01f, -1.44054994e-01f, -2.24292979e-01f, -8.44601393e-02f, -9.22656432e-02f, 5.52399457e-02f, -1.98370382e-01f, -1.83320120e-01f, -2.25143284e-01f,
  -9.66655016e-02f, -7.47529119e-02f, -2.98328940e-02f, -7.82177523e-02f, -9.98558700e-02f, -1.54575989e-01f, -1.57934949e-01f, -5.00864498e-02f, -4.72805761e-02f, -1.64938822e-01f,
  -4.56342008e-03f, -4.79712300e-02f, -1.59691855e-01f, -5.58069460e-02f, -5.78920022e-02f, -6.97733015e-02f, -1.30420968e-01f, -1.81493148e-01f, 8.50543287e-03f, -7.23248348e-02f,
  3.68080467e-01f, 2.70771652e-01f, 2.40458529e-02f, 5.91870658e-02f, -2.69696623e-01f, -3.59244436e-01f, -6.89735461e-04f, 5.59316352e-02f, -1.24757634e-02f, 6.26427010e-02f,
  -1.46393195e-01f, -3.84432048e-01f, -1.14428014e-01f, -2.00453207e-01f, -9.15794373e-02f, 2.19511837e-01f, 1.67860165e-01f, -1.30939201e-01f, -3.02236140e-01f, -2.49319464e-01f,
  -2.34798267e-01f, 1.41327128e-01f, 4.32790779e-02f, -2.61875950e-02f, 1.32025138e-01f, -1.37146845e-01f, 2.00439289e-01f, -1.95653010e-02f, -2.59529799e-01f, 1.39389634e-01f,
  3.25173467e-01f, -7.71749094e-02f, -2.05182537e-01f, -1.65308356e-01f, 1.16677545e-01f, -9.81800482e-02f, -1.05464876e-01f, 4.31942977e-02f, -1.36663586e-01f, -9.77068394e-02f,
  -9.06172171e-02f, -1.42547503e-01f, -1.82122394e-01f, -5.68145700e-03f, -7.98148960e-02f, -7.31160864e-03f, 2.29743104e-02f, 4.72772494e-02f, -4.25862223e-02f, 8.93978868e-03f,
  -7.24733397e-02f, -1.36129737e-01f, 1.94652565e-02f, 2.99639199e-02f, -2.10435800e-02f, -7.45891929e-02f, 1.09947994e-01f, -1.70500398e-01f, 1.50897978e-02f, 2.48384193e-01f,
  -2.71897316e-01f, -6.20227121e-03f, -8.25986732e-03f, -1.13816082e-01f, -1.47589326e-01f, -1.54535353e-01f, -1.07135713e-01f, 5.06992359e-03f, -8.24937373e-02f, 4.79975194e-02f,
  -1.32991254e-01f, -1.55744284e-01f, -1.05716370e-01f, -1.48647036e-02f, -1.58057269e-02f, -1.10157907e-01f, -3.61429038e-03f, 8.77972767e-02f, -1.32013364e-02f, -9.12804678e-02f,
  -3.98834124e-02f, 7.23391324e-02f, -6.59141690e-03f, 1.34330476e-02f, -9.63658094e-02f, -2.70822197e-02f, -1.17461771e-01f, -2.03272030e-01f, -4.95591015e-02f, 1.35881705e-02f,
  2.08615407e-01f, -5.44919193e-01f, 1.88160703e-01f, 8.93595517e-02f, 1.42909614e-02f, -8.64379779e-02f, -1.26746461e-01f, -2.75666535e-01f, 2.38767569e-03f, -1.23706087e-01f,
  -1.71236560e-01f, -1.00084282e-01f, 1.07658058e-01f, 6.39164299e-02f, 3.09132691e-02f, 5.27521521e-02f, 6.80999458e-02f, 7.87225515e-02f, 1.78965684e-02f, 7.68000931e-02f,
  3.13189514e-02f, -1.10320710e-02f, 1.19891413e-01f, 1.76110700e-01f, 1.31910041e-01f, -7.31911138e-02f, 7.95375034e-02f, -5.29877506e-02f, -1.57107469e-02f, 3.88983995e-01f,
  -9.65359688e-01f, 2.42973134e-01f, -1.68369517e-01f, -2.87222713e-01f, -2.56277949e-01f, -2.74066418e-01f, 3.53799425e-02f, -4.99479771e-02f, -2.00293377e-01f, 2.27926388e-01f,
  8.05713683e-02f, -2.77997315e-01f, -1.34606943e-01f, -2.07476124e-01f, -3.10793519e-01f, 9.60061550e-02f, -2.43978605e-01f, -6.59045756e-01f, -8.35560679e-01f, -3.64735872e-01f,
  -3.23702306e-01f, -5.79944313e-01f, -7.48118758e-01f, -4.26858634e-01f, 1.40557021e-01f, -3.01776022e-01f, -6.60960898e-02f, -3.70002508e-01f, -2.15785071e-01f, -1.44945860e-01f,
  1.87965915e-01f, -4.22468215e-01f, -6.77467957e-02f, -8.24136361e-02f, -1.42564112e-02f, 1.42683303e-02f, -1.26042575e-01f, -1.06487311e-01f, -9.59104002e-02f, 8.33524987e-02f,
  -1.16992526e-01f, 1.48187606e-02f, -1.94076851e-01f, 5.07608168e-02f, -4.41955440e-02f, -4.94938008e-02f, 5.25909066e-02f, -8.65094736e-02f, -4.92100678e-02f, 2.58837819e-01f,
  2.38065600e-01f, -9.20478925e-02f, 6.66873902e-02f, 2.67120898e-01f, -4.00286056e-02f, -1.22382529e-01f, 2.03336269e-01f, 8.57519433e-02f, -6.16694540e-02f, 2.96430647e-01f,
  -1.47010302e-02f, 1.91274241e-01f, 8.01849812e-02f, -9.81695503e-02f, 3.40358689e-02f, -4.07367200e-02f, -7.37938052e-03f, 1.28266305e-01f, -9.14422050e-02f, 1.76956043e-01f,
  1.86665133e-01f, 1.85246076e-02f, -8.08721632e-02f, -1.26531878e-02f, 5.81074618e-02f, -2.00083330e-02f, -3.90263386e-02f, 1.94931179e-01f, -1.86399631e-02f, 8.09043795e-02f,
  -1.56487197e-01f, 4.21335287e-02f, -5.96888103e-02f, 7.97286332e-02f, 1.75244529e-02f, -5.07364422e-02f, -1.21842548e-02f, -1.14862740e-01f, 1.98256318e-02f, -2.36096326e-02f,
  1.49143279e-01f, -4.68529850e-01f, 2.85029337e-02f, -5.15921973e-03f, 5.62248975e-02f, 1.39000073e-01f, -4.41521741e-02f, -1.09417081e-01f, -1.29887193e-01f, -1.69650391e-01f,
  -1.87656060e-01f, 7.72357807e-02f, -2.42662374e-02f, 2.20370695e-01f, 2.60046925e-02f, 3.74153778e-02f, 2.38617048e-01f, 6.13848157e-02f, -2.23790910e-02f, 3.04210871e-01f,
  2.98585713e-01f, 1.03673615e-01f, 1.50700554e-01f, 2.83159196e-01f, 1.67302173e-02f, -1.28689170e-01f, 1.86495736e-01f, 1.06200054e-01f, -4.86351699e-02f, 1.79386690e-01f,
  1.77087739e-01f, -3.00874114e-01f, -5.33636399e-02f, 1.37252286e-01f, 1.35234401e-01f, 5.14366478e-02f, -3.50144468e-02f, 4.86317202e-02f, 1.19042501e-01f, 7.82580823e-02f,
  1.03528440e-01f, 2.82875270e-01f, 2.29500636e-01f, 1.92539960e-01f, 2.13837758e-01f, 9.92464498e-02f, 8.89929608e-02f, 2.30963975e-01f, 2.00271577e-01f, 1.11503318e-01f,
  6.21129721e-02f, 4.79855901e-03f, -5.97114824e-02f, 3.41850445e-02f, 1.16898172e-01f, 1.31481752e-01f, 3.02031320e-02f, -1.60973370e-02f, 7.97460228e-03f, 1.19210824e-01f,
  8.83404166e-02f, -8.00549686e-02f, 1.40348971e-01f, 7.44764507e-02f, -6.58238381e-02f, -1.95291057e-01f, 2.24583503e-02f, -1.72626331e-01f, -1.30390868e-01f, -1.61861017e-01f,
  -5.41449431e-03f, -1.17700413e-01f, 1.17482670e-01f, -2.78085396e-02f, -5.56254648e-02f, -6.47914037e-02f, 4.42392044e-02f, 2.67222594e-03f, 6.04016259e-02f, 1.53874662e-02f,
  8.15930814e-02f, -1.31108854e-02f, -2.37979852e-02f, -1.69451758e-02f, 2.28139106e-02f, 7.90681317e-02f, -1.01362631e-01f, 7.96959922e-02f, 5.29151782e-02f, 1.10794837e-02f,
  4.15379167e-01f, 2.05190867e-01f, 3.04498762e-01f, 1.11357674e-01f, 1.37611553e-01f, 1.12510122e-01f, -2.45170668e-02f, 1.06631152e-01f, 6.52154088e-02f, 1.05626725e-01f,
  1.25094861e-01f, 1.01789214e-01f, -5.49725443e-02f, -5.95608763e-02f, 1.48482323e-01f, -3.40506807e-02f, 7.92835057e-02f, 3.53668034e-02f, 9.34233963e-02f, 4.70085517e-02f,
  1.09291427e-01f, 4.31364253e-02f, 9.97855235e-03f, -3.75923552e-02f, 1.03082068e-01f, 1.40349746e-01f, -5.06276675e-02f, -8.69180709e-02f, 9.48285013e-02f, -1.08906969e-01f,
  -2.32647344e-01f, 2.45210469e-01f, 2.50942200e-01f, -1.39715441e-03f, -1.11683324e-01f, -3.58771197e-02f, 1.00200057e-01f, -1.59242213e-01f, -1.59617186e-01f, -2.05563918e-01f,
  -7.21952394e-02f, -2.07888409e-02f, -4.84881699e-02f, 4.06205654e-02f, 3.39111425e-02f, 1.44702999e-03f, 9.22826007e-02f, -4.86125164e-02f, 3.77110578e-02f, -5.80564849e-02f,
  -1.03394955e-01f, 1.63169838e-02f, 4.96763028e-02f, 8.04836378e-02f, 1.22410804e-02f, 1.73062652e-01f, -4.05422486e-02f, -4.59458977e-02f, 3.82740870e-02f, -1.68069214e-01f,
  9.17540431e-01f, 1.17563613e-01f, 3.39419574e-01f, 1.26284391e-01f, 3.72260273e-01f, 4.30279285e-01f, 4.12699282e-01f, 2.26685092e-01f, 4.33727354e-02f, 2.62015253e-01f,
  1.87270977e-02f, -3.36211294e-01f, -1.30545318e-01f, -1.97381169e-01f, -4.09708694e-02f, 8.28080997e-02f, 7.55766481e-02f, 4.87168580e-02f, 1.28742188e-01f, 5.23876511e-02f,
  -1.73584282e-01f, 4.24535125e-02f, 1.19523630e-01f, -1.59472525e-02f, 2.12701540e-02f, -3.23157422e-02f, -3.47066671e-02f, 1.47401348e-01f, 2.35667955e-02f, -1.78614035e-01f,
  -2.13594615e-01f, 3.22275668e-01f, -2.48313352e-01f, -2.15549380e-01f, -9.88891199e-02f, -1.64613739e-01f, -2.87174433e-02f, -1.51535034e-01f, 1.89958178e-02f, 6.74632639e-02f,
  -1.00923270e-01f, -7.74669796e-02f, -8.21907818e-02f, -7.32569173e-02f, 6.35904893e-02f, -1.99563745e-02f, -7.69164860e-02f, -4.46321703e-02f, -1.37329906e-01f, -2.99375225e-02f,
  -2.55606860e-01f, 7.97987357e-02f, 1.33122176e-01f, 8.54963157e-03f, -8.44591409e-02f, -4.12080474e-02f, 4.23021913e-02f, -5.30701429e-02f, 8.71357918e-02f, -2.71480139e-02f,
  -3.98570746e-01f, -2.21781954e-02f, -4.84253839e-02f, 3.49122472e-02f, 6.10423610e-02f, 1.50940627e-01f, -6.30618036e-02f, -6.46376386e-02f, -6.30858764e-02f, -2.89660804e-02f,
  -1.99854985e-01f, -8.60279649e-02f, -2.86729150e-02f, -4.62298431e-02f, -2.02503160e-01f, -9.53585259e-04f, 3.50983329e-02f, -1.72712073e-01f, 4.12516221e-02f, -6.58563897e-02f,
  -9.71104726e-02f, -1.00728869e-02f, -2.90149692e-02f, -1.87643573e-01f, -7.39805028e-02f, 2.39583082e-03f, -4.85142916e-02f, -2.14314774e-01f, -4.86493856e-02f, 8.24077427e-02f,
  -4.30424035e-01f, -2.98758876e-02f, -8.65070000e-02f, -7.91039839e-02f, 1.77228358e-02f, -1.56204209e-01f, -2.06397846e-02f, -1.70993194e-01f, -4.52758819e-02f, 4.70771603e-02f,
  9.88571569e-02f, 7.74202915e-03f, -8.21059942e-02f, -8.22445080e-02f, 1.46825075e-01f, 3.35590281e-02f, -8.07384402e-02f, -1.73511639e-01f, -1.92165047e-01f, -9.50198695e-02f,
  -2.61871725e-01f, 9.85355824e-02f, 1.27637044e-01f, -3.66066545e-02f, 4.21024580e-03f, -5.67437783e-02f, 1.92619935e-02f, 2.51664198e-03f, -1.72898769e-02f, 6.27041608e-02f,
  1.02894232e-01f, -5.27616680e-01f, 3.40441138e-01f, -1.77303270e-01f, 4.03419249e-02f, 2.78963387e-01f, 1.15624696e-01f, 8.59719291e-02f, 6.88275546e-02f, -9.00432691e-02f,
  -3.83653939e-01f, -2.75699347e-01f, -3.49137843e-01f, -7.58458823e-02f, 2.39462312e-03f, 2.92358726e-01f, 3.64280432e-01f, 4.21748787e-01f, 4.61530238e-01f, 1.68086812e-01f,
  -7.74811283e-02f, -8.24475884e-02f, 1.30200777e-02f, -2.35045124e-02f, -1.99547634e-01f, -1.92309633e-01f, -7.27566704e-02f, -1.52192041e-01f, -1.86663643e-01f, -2.86704302e-01f,
  -6.68834150e-02f, -4.86066252e-01f, 9.23612341e-02f, -1.97397515e-01f, -1.63364038e-01f, 2.79462673e-02f, 3.88705023e-02f, -5.79458326e-02f, 9.41208284e-03f, 1.30244628e-01f,
  -6.83059916e-02f, -1.66762576e-01f, -7.71047920e-02f, -7.56888390e-02f, 9.29546915e-03f, 8.68322700e-02f, -1.30863875e-01f, -2.00763136e-01f, -1.77957311e-01f, -2.18472645e-01f,
  -1.62099361e-01f, -7.61857703e-02f, -8.00245255e-02f, -4.68522273e-02f, -1.47479698e-01f, -1.01767302e-01f, -5.36275208e-02f, -8.38299468e-02f, -9.51401517e-02f, 5.44667095e-02f,
  2.62975723e-01f, -9.25975442e-02f, -2.32731700e-01f, -7.67181069e-02f, -1.41252838e-02f, -4.79774997e-02f, -2.10461556e-04f, -1.12258650e-01f, -6.38080612e-02f, -5.35289757e-02f,
  -1.73824385e-01f, -7.45707899e-02f, -1.49978414e-01f, 2.00489368e-02f, -2.39610951e-02f, -1.76223725e-01f, 8.64723790e-03f, -3.47235985e-02f, -7.30082467e-02f, -2.22644642e-01f,
  -2.38196984e-01f, -8.08823183e-02f, -1.99469179e-03f, -1.50559321e-01f, -6.76856562e-02f, 4.05141106e-03f, 2.13738568e-02f, -7.20854998e-02f, -2.61458829e-02f, 1.24273757e-02f,
  -4.15471971e-01f, -1.79278310e-02f, 1.69794187e-01f, -1.52477786e-01f, -1.17027452e-02f, -1.51595427e-02f, -1.53037891e-01f, 4.13908772e-02f, -4.53479253e-02f, 1.19383089e-01f,
  -5.61622865e-02f, 1.03703447e-01f, -1.08704843e-01f, -5.31341359e-02f, 1.10907406e-01f, 1.40328690e-01f, -6.75195307e-02f, -5.67576615e-03f, -1.30233765e-01f, -8.04928467e-02f,
  -1.76217500e-02f, 1.53633103e-01f, 2.00640485e-01f, 1.65443406e-01f, 1.13863640e-01f, 2.10306853e-01f, 2.16421291e-01f, 2.00646535e-01f, 2.75744170e-01f, 4.90573436e-01f,
  -2.95297176e-01f, 6.60935938e-02f, -5.40630579e-01f, 3.36744279e-01f, 5.63072622e-01f, 1.64535195e-01f, -6.44923076e-02f, -1.45110324e-01f, 1.64748222e-01f, 1.79948360e-01f,
  3.97488534e-01f, 5.18981159e-01f, 2.54966050e-01f, 8.35243762e-02f, -1.97176993e-01f, -1.74799815e-01f, -8.44627097e-02f, -2.85879791e-01f, -1.44641399e-01f, 3.91006082e-01f,
  5.59391558e-01f, 2.43699983e-01f, -2.07842961e-01f, -4.44999300e-02f, 3.40523869e-01f, 4.47956204e-01f, -3.80003154e-02f, 2.96688557e-01f, 3.10461611e-01f, 1.34970665e-01f,
  -2.02470347e-02f, -2.50166118e-01f, 5.86550124e-02f, 4.57509726e-01f, 1.20708138e-01f, -1.98463842e-01f, -1.48889171e-02f, -1.46935493e-01f, 7.36436024e-02f, -6.72712997e-02f,
  1.64406046e-01f, 4.25273031e-02f, 3.73858184e-01f, -5.18417843e-02f, -5.50998971e-02f, -1.30512267e-01f, -2.42126226e-01f, -4.78771061e-01f, -4.54505324e-01f, -3.20621401e-01f,
  5.69737315e-01f, 4.33981746e-01f, -2.41180554e-01f, -2.00001016e-01f, -3.50035548e-01f, 2.73844749e-02f, -3.86495978e-01f, -2.89538771e-01f, -4.77069497e-01f, -4.40845340e-01f,
  7.34512061e-02f, -1.19733542e-01f, -8.43971670e-02f, -2.56060243e-01f, 4.19447273e-02f, 1.92350578e-02f, -1.05266590e-02f, 1.02203257e-01f, -5.39405551e-03f, -8.79638046e-02f,
  4.28812951e-02f, -1.39156595e-01f, -2.87005246e-01f, -2.33383011e-02f, 1.98653638e-01f, 2.85462420e-02f, 3.21138650e-02f, -8.48725364e-02f, -6.27296194e-02f, -1.48240715e-01f,
  -3.88411358e-02f, -1.09402910e-01f, -3.67772207e-02f, -1.38334662e-01f, -1.01142749e-01f, -1.45581678e-01f, -4.90467716e-03f, 1.36950210e-01f, 6.82538450e-02f, 7.55503103e-02f,
  2.03572363e-01f, -6.20813631e-02f, -3.36621515e-02f, -7.05084344e-03f, -2.44753230e-02f, -7.03684539e-02f, -4.22311947e-02f, -3.29739712e-02f, -8.25498626e-02f, -2.20149353e-01f,
  -1.33500576e-01f, -2.38967970e-01f, 6.29133731e-02f, -1.90126136e-01f, -7.17059076e-02f, 3.89388204e-02f, 4.66508232e-02f, -2.50755884e-02f, -3.30178320e-01f, -2.39534333e-01f,
  -1.78736851e-01f, -1.44215629e-01f, -1.69604972e-01f, -3.97584230e-01f, -2.29037374e-01f, 5.58562092e-02f, -3.01792979e-01f, -1.93064019e-01f, -3.39348167e-01f, -2.34584913e-01f,
  4.43950087e-01f, 4.79776770e-01f, 1.12636514e-01f, 2.06695855e-01f, 2.58287638e-02f, 3.65243614e-01f, 4.95016575e-01f, 3.89127284e-01f, 2.43123114e-01f, 3.00918847e-01f,
  2.04720721e-01f, 1.46087229e-01f, 2.16341510e-01f, 6.14604391e-02f, 2.69454062e-01f, 2.82721817e-01f, 1.53522849e-01f, -8.30544308e-02f, 6.52901232e-02f, 5.23330271e-02f,
  6.99445754e-02f, 8.19111690e-02f, -2.82817297e-02f, -3.84022808e-03f, -9.39756483e-02f, -8.67399573e-02f, 8.99574831e-02f, 5.40287979e-02f, -7.86249712e-02f, -1.65696442e-01f,
  -3.99838209e-01f, 1.36267364e-01f, -5.82100824e-02f, -8.94373581e-02f, -1.56886969e-02f, 9.48782340e-02f, 6.91165328e-02f, -5.39031141e-02f, 8.00805315e-02f, 3.54994833e-02f,
  8.42342991e-03f, -9.89518240e-02f, 8.42446014e-02f, -1.92685972e-03f, -1.07854649e-01f, -3.82714085e-02f, 3.93156819e-02f, 2.24475592e-01f, 5.96520491e-02f, 6.11938275e-02f,
  1.15965888e-01f, 3.87040488e-02f, 1.59446448e-01f, 1.36360258e-01f, 1.99961782e-01f, 4.67184745e-02f, -2.81972885e-02f, -1.29194427e-02f, -2.47124992e-02f, -5.11137163e-03f,
  1.18200570e-01f, 1.31844595e-01f, 4.02437411e-02f, 5.63623197e-02f, 2.25105546e-02f, 5.10139018e-02f, -1.32110104e-01f, 8.64708200e-02f, 2.55498346e-02f, 4.10299152e-02f,
  -7.12796971e-02f, 8.53840541e-03f, 5.28304577e-02f, -1.61730647e-01f, -1.49642512e-01f, -1.45176603e-02f, 7.06642075e-03f, -1.62189417e-02f, -1.09219402e-01f, 2.80963443e-02f,
  -1.13694139e-01f, 6.59987405e-02f, -1.49842054e-01f, -1.38433874e-01f, -1.24062702e-01f, -3.16881277e-02f, -5.88470697e-02f, 2.75496878e-02f, -5.06909844e-03f, 7.42945597e-02f,
  -4.76759151e-02f, -1.49443537e-01f, -1.31722853e-01f, 2.24773288e-02f, 2.34300457e-02f, 2.39518052e-03f, -7.47181177e-02f, -1.23158835e-01f, -5.40940054e-02f, -2.28901133e-02f,
  -7.03888107e-03f, 1.03220949e-02f, -1.01286463e-01f, 6.58781454e-02f, -2.12488472e-01f, -1.21274665e-01f, -1.13302981e-02f, 6.68900162e-02f, 1.22956194e-01f, 4.03105319e-02f,
  7.93410745e-03f, 2.50080042e-02f, -4.88007674e-03f, -4.24540825e-02f, 1.16496179e-02f, -1.24378577e-01f, -1.85826376e-01f, -1.09341100e-01f, -6.63725436e-02f, -2.24801004e-02f,
  -4.73068535e-01f, 2.90589869e-01f, 2.84351885e-01f, -1.64893895e-01f, -1.16166070e-01f, 1.22443989e-01f, 8.84885415e-02f, 1.16225645e-01f, 1.95390210e-02f, 2.41991729e-02f,
  -1.40032604e-01f, -1.66961610e-01f, 1.00635350e-01f, 4.27366644e-02f, 2.90865488e-02f, 2.61366338e-01f, 3.35860938e-01f, 4.78222780e-02f, -2.97209293e-01f, -2.96760857e-01f,
  -1.78656012e-01f, -3.30723584e-01f, -2.56757885e-01f, 5.30970097e-03f, 1.94702417e-01f, -8.73512998e-02f, 2.05328748e-01f, -4.44797426e-02f, 1.50472745e-01f, 3.60227078e-01f,
  -1.64301574e-01f, 4.77179252e-02f, -5.93859069e-02f, -2.05018923e-01f, 1.02532562e-02f, 1.03364415e-01f, -3.31116989e-02f, 5.22691235e-02f, 8.56483430e-02f, 8.77627432e-02f,
  -9.65577364e-02f, 1.05358265e-01f, -3.81393470e-02f, 4.05820385e-02f, -1.21233508e-01f, -5.69000691e-02f, -7.75550678e-02f, 3.87643501e-02f, -3.26620936e-02f, 4.46822569e-02f,
  2.94365026e-02f, -2.35643744e-01f, -1.85303673e-01f, 1.71219222e-02f, 1.99897587e-01f, -2.09222779e-01f, -4.28346768e-02f, 2.81815603e-02f, -4.29235622e-02f, 1.93001982e-02f,
  -1.79255418e-02f, -8.16107169e-02f, 4.61435281e-02f, 1.26507267e-01f, -4.40180376e-02f, 1.09105045e-03f, 1.00166112e-01f, 1.18976329e-02f, -1.98550969e-02f, -4.24395837e-02f,
  7.46622235e-02f, -1.23867430e-01f, 5.69945900e-03f, 2.21031010e-02f, -1.21662067e-02f, -8.83986726e-02f, -8.50041572e-04f, 4.42765541e-02f, -3.56136262e-02f, 9.85086337e-02f,
  -4.97481860e-02f, 7.28781819e-02f, -6.35696435e-03f, 8.85421261e-02f, 6.15881830e-02f, 1.51325222e-02f, -1.10195242e-01f, -7.39676803e-02f, -8.90732035e-02f, -1.92427307e-01f,
  -1.50002003e-01f, -1.27895325e-01f, -7.39769042e-02f, 8.93023424e-03f, -3.90808880e-02f, 9.68027487e-02f, -1.72308218e-02f, -1.00478902e-01f, -2.68740598e-02f, -4.46863808e-02f,
  -1.17587999e-01f, 9.80303157e-03f, 1.79182347e-02f, 4.64132205e-02f, -2.09587008e-01f, -5.83998524e-02f, -2.19462082e-01f, -1.78294837e-01f, -7.07479119e-02f, -2.73355916e-02f,
  9.64335054e-02f, -2.83322603e-01f, -5.14817178e-01f, -1.10017434e-01f, -1.89604998e-01f, -4.56738025e-01f, -2.75951535e-01f, -2.00296000e-01f, -3.06663811e-01f, -2.93497771e-01f,
  -6.86598361e-01f, 6.59606308e-02f, -2.59646237e-01f, -4.44136113e-01f, -1.74097821e-01f, 1.28548229e-02f, 2.71334797e-01f, 2.04412982e-01f, -7.56185055e-02f, 1.81496516e-01f,
  1.19083233e-01f, -1.30838737e-01f, -2.01987743e-01f, -6.73519000e-02f, -4.57859933e-02f, 5.31485816e-03f, -3.79902750e-01f, -5.25518894e-01f, -2.39443704e-01f, 1.44348517e-01f,
  -6.21792376e-02f, -2.91755825e-01f, -3.78403634e-01f, -1.10100023e-01f, -3.64872031e-02f, -1.54021785e-01f, -7.33359978e-02f, -2.82921225e-01f, -1.63588107e-01f, -2.93017060e-01f,
  2.94373959e-01f, -2.51043700e-02f, -3.82983834e-02f, -2.96759307e-01f, 1.12984190e-02f, 2.30957754e-02f, 2.00086623e-01f, -2.90904008e-02f, 4.49190736e-02f, 1.64156839e-01f,
  -6.22129701e-02f, 7.96764195e-02f, 1.48094539e-02f, -4.59050341e-03f, -3.79406661e-02f, -1.26360869e-02f, -2.52040088e-01f, -1.28332168e-01f, -1.04228616e-01f, 3.94083530e-01f,
  -6.61899149e-02f, -3.37602258e-01f, -2.65886158e-01f, 1.48226008e-01f, 3.48670334e-01f, -2.97258288e-01f, 2.60098159e-01f, 1.45748988e-01f, 9.91341844e-02f, 1.20631680e-01f,
  1.22452028e-01f, 1.54814301e-02f, -2.53112987e-02f, 3.69935483e-02f, 1.17185384e-01f, -2.41402779e-02f, -1.29823303e-02f, 6.49944171e-02f, 3.31446230e-02f, 7.21551627e-02f,
  1.49637789e-01f, 1.13831021e-01f, 1.44392610e-01f, 1.02050386e-01f, -1.86257903e-02f, -1.84353024e-01f, -7.23557696e-02f, 6.79586455e-02f, -4.00319919e-02f, -1.16998456e-01f,
  -1.44972280e-01f, -4.98744398e-02f, -1.02716543e-01f, 4.70266417e-02f, -1.58269033e-01f, -1.20728485e-01f, 3.80563959e-02f, 1.15575127e-01f, 5.01386970e-02f, -9.16029438e-02f,
  2.21347213e-01f, -1.90723807e-01f, 4.19822708e-03f, -6.16558827e-02f, -6.78828955e-02f, 1.98970258e-01f, -2.94780061e-02f, 1.26845902e-04f, -3.24260518e-02f, 1.93941072e-01f,
  1.00985341e-01f, 2.68099338e-01f, 2.10043907e-01f, 7.89251849e-02f, 4.75784242e-02f, 9.31567699e-02f, -1.65715039e-01f, -2.62070298e-01f, -7.84318671e-02f, 1.39416993e-01f,
  -6.11565448e-02f, -2.19838709e-01f, -3.76059413e-01f, -1.55885905e-01f, 1.76352963e-01f, -2.84007609e-01f, 7.96455964e-02f, 2.46247351e-01f, 2.01076781e-03f, 1.07001804e-01f,
  6.45208880e-02f, 3.13042939e-01f, -1.85981259e-01f, 2.17916802e-01f, -1.73505321e-01f, -2.78338462e-01f, -8.83313268e-02f, 3.48066799e-02f, 1.49654478e-01f, 3.03833067e-01f,
  1.40731081e-01f, -2.49369681e-01f, -3.80660817e-02f, -3.03608179e-01f, -3.98923516e-01f, 1.10698819e-01f, -9.26176906e-02f, -4.95720029e-01f, -6.55008733e-01f, -5.03930628e-01f,
  -3.08093965e-01f, -8.78095552e-02f, -1.64010420e-01f, -1.86767817e-01f, 1.18206382e-01f, -1.84577361e-01f, 1.26617685e-01f, -1.77065998e-01f, -3.13536257e-01f, -2.42104381e-02f,
  1.09250516e-01f, -6.25350922e-02f, -1.00129507e-01f, -1.33582249e-01f, 9.13586318e-02f, 8.19950923e-02f, 1.42048555e-03f, 3.49468738e-02f, 1.75315678e-01f, 2.48180777e-01f,
  8.84253308e-02f, 2.41154954e-02f, -7.10770488e-03f, 5.20889610e-02f, 1.03825389e-03f, -1.04345798e-01f, 1.10266834e-01f, 3.62445489e-02f, -2.00854149e-02f, 7.16051236e-02f,
  -3.97800235e-03f, -1.35527328e-01f, 8.02751863e-04f, 2.04061624e-02f, -1.70789465e-01f, -2.64124215e-01f, -1.05446026e-01f, -1.64720938e-01f, -8.60805362e-02f, 2.15312287e-01f,
  -3.59541401e-02f, 1.23114221e-01f, -7.21282810e-02f, 1.27610818e-01f, 2.24708349e-01f, 3.54508534e-02f, 1.58935219e-01f, 1.35844722e-01f, -1.37034282e-02f, 6.80676773e-02f,
  1.36277467e-01f, 2.14417875e-01f, 2.89797597e-02f, 1.11813143e-01f, 7.04322681e-02f, 8.93999124e-04f, -4.59647961e-02f, 1.00406267e-01f, 4.84821051e-02f, 2.86190897e-01f,
  2.42188517e-02f, -6.20924719e-02f, 8.33701119e-02f, 1.21722981e-01f, -3.06525715e-02f, -5.53806983e-02f, -3.64418887e-02f, 1.51509196e-02f, 5.56962239e-03f, 1.40688047e-02f,
  1.50993466e-01f, -2.90309668e-01f, 6.19999245e-02f, -1.25955557e-02f, -8.43045767e-03f, 1.15863398e-01f, -2.80716531e-02f, 6.13287836e-02f, 4.80774082e-02f, 5.62013686e-02f,
  -7.32441843e-02f, 8.45212713e-02f, 7.61715770e-02f, 8.86354893e-02f, 5.57341762e-02f, -8.66951197e-02f, -2.15303190e-02f, -5.73391132e-02f, -9.69234034e-02f, 6.74807131e-02f,
  1.39226377e-01f, 2.16317885e-02f, 1.24431841e-01f, 5.25474586e-02f, -8.18797201e-02f, -2.12025538e-01f, -1.34122977e-02f, 2.46975701e-02f, -7.14012682e-02f, 3.37479800e-01f,
  -3.33131790e-01f, 7.94293106e-01f, 1.33696526e-01f, -3.67592067e-01f, 2.52304107e-01f, 4.97976094e-01f, 6.67599320e-01f, 2.33136892e-01f, -2.35191673e-01f, 1.79241046e-01f,
  2.21786141e-01f, -2.56962448e-01f, -2.30620563e-01f, -8.34416226e-02f, -7.64149893e-03f, 3.67977917e-01f, 4.32011448e-02f, -2.90506989e-01f, -1.95963204e-01f, 7.89619684e-02f,
  6.55814186e-02f, -1.92097828e-01f, -3.35681379e-01f, -1.82188094e-01f, -1.33139817e-02f, -3.03646654e-01f, -3.93779762e-02f, -7.05016661e-04f, 2.55731612e-01f, -1.33476645e-01f,
  -2.54438996e-01f, 3.37525010e-01f, -3.17776829e-01f, -1.82081938e-01f, -8.06430057e-02f, -2.10710049e-01f, -8.42443481e-02f, -2.24750549e-01f, -8.01324993e-02f, -4.34692800e-02f,
  8.19833577e-02f, 6.77963570e-02f, -2.92572659e-03f, 1.31896153e-01f, 7.29529783e-02f, 1.53895572e-01f, 6.08267933e-02f, -8.93606246e-02f, -1.23421803e-01f, 2.13449836e-01f,
  1.07364915e-01f, 7.12024346e-02f, 5.28938584e-02f, 2.08856300e-01f, 2.11776033e-01f, -1.23723350e-01f, 1.76395133e-01f, 9.73758548e-02f, -5.12491167e-03f, -1.48223191e-01f,
  -1.16444156e-01f, 6.68888688e-02f, 1.19847536e-01f, 2.17707947e-01f, 4.28932384e-02f, -5.04918024e-02f, -3.11752711e-03f, -5.44614578e-03f, 4.98750322e-02f, 3.06830853e-02f,
  6.72051907e-02f, -9.85181630e-02f, 9.21688080e-02f, -3.81442644e-02f, -1.43197134e-01f, -1.77023541e-02f, -1.04783569e-02f, -3.86385955e-02f, -6.60121962e-02f, 3.71134561e-03f,
  -7.03348443e-02f, -7.51748309e-02f, -1.00927584e-01f, -7.47359321e-02f, 6.62689283e-02f, 7.52747282e-02f, -3.74318063e-02f, -5.62646315e-02f, 2.85868663e-02f, 1.37915045e-01f,
  -4.89849329e-01f, 9.71059427e-02f, -3.16189885e-01f, 1.29374474e-01f, -1.13306060e-01f, -1.53753430e-01f, -8.46763141e-03f, -3.33183035e-02f, 6.61599785e-02f, -2.10839193e-02f,
  1.58089831e-01f, -6.88304976e-02f, -4.79033664e-02f, 6.59366623e-02f, -1.29809991e-01f, 1.14173545e-02f, 1.22833326e-01f, -1.62533775e-01f, 1.54607021e-03f, 5.40073887e-02f,
  -2.89486535e-02f, -2.55834937e-01f, -3.52156848e-01f, -1.53349116e-01f, -1.00076847e-01f, -3.54281485e-01f, -1.80007666e-01f, -1.43487930e-01f, -1.92845568e-01f, -2.30844736e-01f,
  -1.88659593e-01f, 7.63671696e-02f, -1.12971246e-01f, -2.08622888e-01f, 1.91208720e-01f, 1.30634412e-01f, 1.25571474e-01f, -5.53497635e-02f, -3.13223958e-01f, -2.40978584e-01f,
  1.94099620e-01f, 1.54440925e-01f, -1.83184966e-01f, 3.37994695e-02f, 9.24497396e-02f, -2.27660224e-01f, -2.51601875e-01f, 1.46662779e-02f, 2.90229023e-01f, 3.54320347e-01f,
  1.12543069e-01f, 5.66320419e-02f, 9.02443305e-02f, -1.30902659e-02f, -2.06103921e-01f, -1.06751285e-01f, -2.06329480e-01f, 5.51509857e-02f, 4.32190038e-02f, -1.73378602e-01f,
  -1.61291078e-01f, -2.22082585e-02f, -2.65099183e-02f, 1.19671814e-01f, 5.65255992e-02f, -2.06805766e-01f, -9.26557258e-02f, -1.74298331e-01f, -6.95772171e-02f, -1.51641786e-01f,
  5.85947335e-02f, 3.50340344e-02f, -9.40192267e-02f, -6.64533004e-02f, -6.46355823e-02f, -5.37232570e-02f, -5.88958617e-03f, -4.45777774e-02f, -1.15321316e-01f, 1.35933971e-02f,
  2.95937926e-01f, 2.66121417e-01f, -9.43491701e-03f, -4.52020988e-02f, -2.01117441e-01f, 1.16944569e-03f, 3.86515483e-02f, -3.25570852e-02f, -8.95498544e-02f, -2.70898938e-01f,
  1.79770235e-02f, 8.49367529e-02f, -2.34735534e-02f, -2.91911922e-02f, 3.27421464e-02f, -6.69144690e-02f, -1.36381127e-02f, 7.28687420e-02f, -9.89423394e-02f, -2.15022881e-02f,
  7.47364014e-02f, -1.72245279e-02f, 1.01247288e-01f, -1.13426529e-01f, 2.03646682e-02f, 2.26104725e-03f, 1.10469326e-01f, -1.44390843e-03f, 9.37221721e-02f, -1.26447659e-02f,
  -1.12395380e-02f, -2.71997415e-02f, -5.13256304e-02f, -1.92827638e-03f, -4.38670702e-02f, 9.22573090e-05f, -6.67438209e-02f, -5.94319403e-02f, -6.44800588e-02f, 1.81834884e-02f,
  -2.40456492e-01f, 2.70532787e-01f, -2.86794215e-01f, 8.10049400e-02f, -4.57726046e-02f, 6.87026456e-02f, -1.02639748e-02f, 3.92043591e-02f, -1.20877147e-01f, -5.98116405e-03f,
  -2.34483462e-02f, 5.53085804e-02f, -2.56566584e-01f, 6.75707608e-02f, -3.39991711e-02f, -1.62423000e-01f, -4.65973392e-02f, -4.34619710e-02f, 1.63320750e-02f, 2.92852037e-02f,
  -7.12274462e-02f, -7.68557265e-02f, -2.74172425e-01f, -1.84640035e-01f, -9.59577784e-02f, -9.55953673e-02f, -2.19132707e-01f, -1.32886365e-01f, -2.26829782e-01f, -4.14810061e-01f,
  -4.42249209e-01f, -5.38767159e-01f, 5.62891513e-02f, -1.11493327e-01f, -2.42652684e-01f, -3.75418991e-01f, -5.99543452e-01f, -4.17392045e-01f, -2.20010221e-01f, -3.68441075e-01f,
  -2.23312169e-01f, 1.33080974e-01f, 2.09332556e-01f, -9.85875204e-02f, -3.85140002e-01f, -6.07899189e-01f, -3.25678796e-01f, -2.43963778e-01f, -2.46414483e-01f, -2.97993332e-01f,
  -3.58798504e-01f, -4.32994783e-01f, -3.28412443e-01f, -1.77178785e-01f, -3.08543015e-02f, 1.03148840e-01f, -2.73422040e-02f, -1.15654826e-01f, -2.29189545e-01f, -3.45425248e-01f,
  2.35382095e-01f, 8.97165015e-02f, -5.65908886e-02f, -2.26963267e-01f, -1.07862473e-01f, -2.69289985e-02f, 9.78635848e-02f, 4.93229181e-02f, 1.24091826e-01f, 1.73727311e-02f,
  -7.59438276e-02f, -5.21367975e-02f, 9.45022563e-04f, 1.51945323e-01f, 7.46924430e-02f, 1.99059001e-03f, 4.63057542e-03f, -1.06595010e-01f, 2.06889100e-02f, 5.93358912e-02f,
  -1.74988210e-02f, -1.88587353e-01f, 5.41056804e-02f, 1.69393703e-01f, 9.60776880e-02f, 1.07540958e-01f, 1.62050694e-01f, 9.03266817e-02f, 1.20152384e-01f, 6.13453835e-02f,
  -1.38163686e-01f, 1.38569148e-02f, -2.11243536e-02f, 3.13053094e-02f, 9.00909975e-02f, -1.02253936e-01f, 7.43381232e-02f, 3.86487469e-02f, -7.16280267e-02f, -1.36528283e-01f,
  -6.21472821e-02f, 4.04994860e-02f, 1.42560787e-02f, -1.62293747e-01f, -1.72899127e-01f, 6.45397883e-03f, -1.21060140e-01f, -5.09957522e-02f, -1.10261969e-01f, -9.19321775e-02f,
  -1.47409633e-01f, -8.56958237e-03f, 5.81371263e-02f, -6.73327520e-02f, -1.86737329e-01f, -3.05882245e-02f, 6.68819398e-02f, 2.33797319e-02f, 3.96261849e-02f, 3.09151914e-02f,
  2.75577813e-01f, -1.19102478e-01f, -1.35162296e-02f, 1.19941950e-01f, 2.00955272e-01f, -1.37814442e-02f, 3.04435641e-01f, 9.68621299e-02f, 6.94148466e-02f, 1.49308801e-01f,
  2.06834786e-02f, 5.61886057e-02f, 2.78832838e-02f, 7.53484741e-02f, 7.95316249e-02f, 7.18471482e-02f, -1.00893810e-01f, -1.13948785e-01f, -4.80524711e-02f, -5.63109815e-02f,
  -5.78968972e-02f, -1.04464367e-01f, 4.41492498e-02f, 1.24750711e-01f, 2.83581018e-02f, 5.18270731e-02f, 1.49720326e-01f, 1.28477216e-01f, 3.67146507e-02f, 1.07603334e-03f,
  -1.73602879e-01f, 1.56277642e-01f, 2.17013024e-02f, -1.74299598e-01f, 2.01170146e-01f, 4.46972735e-02f, -1.27652988e-01f, -3.64328623e-01f, -1.07713997e-01f, 4.35527898e-02f,
  2.41986156e-01f, 1.92192737e-02f, -2.12790251e-01f, -2.59598404e-01f, -5.68029583e-01f, -2.73946404e-01f, -2.91838288e-01f, -4.31478113e-01f, -4.60981786e-01f, -1.21944033e-01f,
  1.02236025e-01f, -1.41493678e-01f, -3.45969230e-01f, -2.74871439e-01f, -1.32764904e-02f, -2.50410065e-02f, 4.32148129e-02f, 1.89586275e-03f, 3.38647254e-02f, 1.12547196e-01f,
  -2.90641468e-02f, -1.25735909e-01f, -9.46240574e-02f, -1.29202083e-01f, 1.28040731e-01f, -4.44706902e-02f, -7.71363601e-02f, -3.89187299e-02f, 1.14090880e-03f, -1.38396591e-01f,
  8.13307539e-02f, -8.05359986e-03f, 1.05543509e-02f, 3.12911868e-02f, -1.51433855e-01f, -1.42721817e-01f, -1.46607935e-01f, -2.37929523e-01f, -9.81751680e-02f, 1.13883130e-01f,
  2.68727541e-01f, 2.01100916e-01f, -2.38858402e-01f, -4.63326573e-02f, -2.39417776e-01f, -9.33401063e-02f, -6.90424591e-02f, -5.21100722e-02f, -1.52004331e-01f, -1.21158801e-01f,
  -1.61936376e-02f, 9.09604598e-03f, 3.36326249e-02f, -4.12570648e-02f, -2.03038454e-02f, 6.83545843e-02f, -8.40340257e-02f, -6.90679252e-02f, -1.32712219e-02f, -3.44412774e-02f,
  1.19251333e-01f, 1.36814043e-01f, -6.01114053e-03f, -7.06220046e-02f, -2.14549765e-01f, -8.91550556e-02f, 6.63766637e-02f, -4.20607962e-02f, -2.24493425e-02f, -3.56699005e-02f,
  -1.00807138e-01f, -9.51045379e-02f, 8.99886638e-02f, -9.18047205e-02f, 4.52552177e-02f, -1.25418708e-01f, 6.67703003e-02f, -1.57708555e-01f, -2.45637253e-01f, -6.88173324e-02f,
  -2.29458660e-01f, 1.23901870e-02f, -8.89066309e-02f, -2.23680809e-01f, -2.88992506e-02f, 1.49581537e-01f, 1.00297406e-01f, -5.80637790e-02f, 1.14609785e-01f, -2.36384273e-02f,
  -1.74201295e-01f, -8.78713205e-02f, 5.72867803e-02f, 2.69205347e-02f, -1.17042996e-01f, -1.64717898e-01f, 8.41834769e-02f, 6.91867471e-02f, 2.12544147e-02f, 2.67669410e-01f,
  -3.65090631e-02f, -1.99252889e-01f, -3.71715754e-01f, -1.32174283e-01f, -1.09325036e-01f, -2.95933843e-01f, -2.70998865e-01f, -1.99484184e-01f, -3.08537126e-01f, -4.26227570e-01f,
  7.21241534e-01f, 5.49740382e-02f, 3.92381400e-02f, 2.23553315e-01f, -1.69042364e-01f, -2.27539122e-01f, -3.58479738e-01f, -1.31280810e-01f, 1.16150863e-01f, 1.80384055e-01f,
  2.35714957e-01f, 3.33626807e-01f, 2.40898028e-01f, 2.15280369e-01f, 1.85495149e-02f, 2.61231810e-02f, -2.62440480e-02f, 2.76387066e-01f, 1.46548882e-01f, 1.33287296e-01f,
  1.57168269e-01f, 1.55812025e-01f, 3.18492025e-01f, 2.14531407e-01f, 2.01272845e-01f, 2.72221476e-01f, 5.33305621e-03f, 8.98348242e-02f, 3.55002284e-02f, 3.18805277e-01f,
  3.43085498e-01f, 3.46931249e-01f, -8.63519534e-02f, 1.70753356e-02f, -2.66382154e-02f, 6.69358820e-02f, 3.82087752e-03f, 6.95182458e-02f, -1.14909016e-01f, -2.47266982e-02f,
  4.54829521e-02f, -6.60396181e-03f, -1.74456406e-02f, -1.60407946e-02f, -9.49509442e-02f, 1.45056406e-02f, -3.95896062e-02f, 1.85379833e-02f, -7.83293098e-02f, 3.21215205e-03f,
  -3.31685543e-02f, -1.15322113e-01f, -1.61559463e-01f, -1.55708253e-01f, -3.81329842e-02f, 2.30601020e-02f, 1.10963760e-02f, 1.09523416e-01f, -8.85087848e-02f, 1.27486050e-01f,
  8.15781504e-02f, 1.12556078e-01f, 1.02218986e-01f, 1.80628359e-01f, 1.96940437e-01f, 1.48636937e-01f, 1.04017509e-02f, -5.30256927e-02f, 1.25787169e-01f, 3.44021022e-02f,
  -1.35578904e-02f, 1.28690451e-01f, -8.75596516e-03f, -5.41362613e-02f, 4.96941879e-02f, -1.58882469e-01f, -6.69842586e-02f, -1.91202953e-01f, -7.65428245e-02f, -2.50731688e-02f,
  9.48785171e-02f, -3.79456170e-02f, 1.01118438e-01f, -3.55293863e-02f, -5.91404177e-02f, 8.67720470e-02f, 8.77345577e-02f, 1.34729464e-02f, 2.41198633e-02f, -5.00385091e-02f,
  -4.52477366e-01f, -1.21469006e-01f, 2.27222860e-01f, -1.48269208e-02f, 3.67760509e-02f, 3.49229835e-02f, 1.53611496e-01f, -5.53144403e-02f, -2.65989117e-02f, 6.14541844e-02f,
  -8.60509574e-02f, 5.15285544e-02f, -2.01743990e-01f, -1.13815203e-01f, -9.13280770e-02f, -3.92167382e-02f, 5.62491007e-02f, -1.03574738e-01f, -1.22156814e-01f, -4.21458036e-02f,
  -2.33918890e-01f, -2.41135851e-01f, -1.09906018e-01f, -2.38771513e-01f, -4.27112691e-02f, -4.16849405e-02f, -9.20464098e-02f, -3.62950489e-02f, -1.84549630e-01f, -5.74900210e-02f,
  7.17482090e-01f, 1.42589584e-01f, 1.47576123e-01f, 2.08971873e-01f, 2.04985157e-01f, -4.27790619e-02f, -4.96718809e-02f, -6.85450509e-02f, 1.17069654e-01f, 2.18043640e-01f,
  2.60140270e-01f, 1.33991778e-01f, 2.17777528e-02f, 9.91000533e-02f, -7.28392527e-02f, 8.74310848e-04f, -3.73068750e-02f, 7.16051161e-02f, 1.34421244e-01f, 1.56810686e-01f,
  6.61770552e-02f, 9.34711248e-02f, 2.19255731e-01f, 7.61098638e-02f, 1.76794738e-01f, -1.37083037e-02f, 1.50591321e-02f, 9.92143005e-02f, 2.44172569e-02f, 1.87611878e-01f,
  3.00074130e-01f, 3.54104310e-01f, -1.79874569e-01f, 1.19413242e-01f, 1.70428276e-01f, 8.61812383e-02f, -2.51866858e-02f, -2.91838148e-03f, -6.35187924e-02f, -9.45366621e-02f,
  -6.96888641e-02f, 7.89984912e-02f, -6.12943480e-03f, 6.92734793e-02f, 2.49700993e-02f, 4.99364845e-02f, 3.55413370e-03f, -8.11540857e-02f, -8.64424184e-02f, 7.48509020e-02f,
  1.34896144e-01f, 2.56369203e-01f, 4.23044078e-02f, -1.82562023e-01f, -6.01585284e-02f, 7.24335611e-02f, 6.91835582e-02f, 3.13716121e-02f, 4.93277423e-02f, 5.86714931e-02f,
  4.18051183e-02f, 2.44927987e-01f, 2.51819968e-01f, 2.40846291e-01f, 1.38140380e-01f, 8.76915976e-02f, 9.79900584e-02f, 8.44724178e-02f, 4.03555073e-02f, 6.04332760e-02f,
  8.72737914e-02f, 9.36955512e-02f, 1.76874399e-01f, 2.05904305e-01f, 2.61973381e-01f, 3.68455917e-01f, 3.30130816e-01f, 2.17356369e-01f, 1.29031464e-01f, 1.19072542e-01f,
  1.50086030e-01f, 8.43908191e-02f, 9.51261222e-02f, -1.15012996e-01f, 1.10589318e-01f, 3.19316536e-01f, 3.86114448e-01f, 2.75461137e-01f, 1.39410570e-01f, 2.43186399e-01f,
  -4.04707760e-01f, -2.04899698e-01f, 7.14545846e-02f, -1.26298040e-01f, -5.57478294e-02f, -1.32044256e-01f, -7.08364546e-02f, -7.90655613e-02f, -1.24994285e-01f, -9.71239731e-02f,
  3.54008079e-02f, 2.16439199e-02f, -1.26268389e-02f, -1.93307940e-02f, 4.36205193e-02f, 5.22380583e-02f, 2.71790046e-02f, 3.93461362e-02f, -1.25850692e-01f, 4.26348709e-02f,
  -1.12571731e-01f, -6.54823557e-02f, 4.40638848e-02f, -1.57717004e-01f, -4.32514884e-02f, -6.51698187e-02f, -1.19217649e-01f, -8.49749073e-02f, -4.95404229e-02f, -2.47067995e-02f,
  -3.08948517e-01f, 6.00297600e-02f, -6.16885662e-01f, 4.37965930e-01f, 2.81134427e-01f, 1.02294847e-01f, 3.07127357e-01f, 2.50947356e-01f, 2.73355067e-01f, 1.13242052e-01f,
  -1.69702485e-01f, -1.72630399e-01f, -2.73314416e-01f, -1.76777035e-01f, -2.11692020e-01f, 7.09003136e-02f, 1.20081566e-01f, -2.55159199e-01f, -2.38510400e-01f, 1.53125718e-01f,
  3.85283738e-01f, 3.68411809e-01f, 3.00513897e-02f, 9.53107327e-02f, 2.30313063e-01f, 2.52607744e-02f, 5.44873103e-02f, 1.21112384e-01f, -1.21131048e-01f, -5.86094037e-02f,
  -7.44489431e-01f, -2.36632913e-01f, -3.46552245e-02f, 1.18156120e-01f, -2.06012130e-01f, -2.04917237e-01f, -9.21669975e-02f, -1.73314273e-01f, -3.17559093e-02f, 4.65108901e-02f,
  1.16064936e-01f, -8.63988250e-02f, -1.77309813e-03f, 1.20208919e-01f, 1.07463509e-01f, -1.02904029e-02f, -2.50641406e-02f, -2.42999166e-01f, -2.75607526e-01f, -2.89071709e-01f,
  1.56608839e-02f, -2.24760130e-01f, -3.08511913e-01f, -1.21877966e-02f, -1.58101007e-01f, -1.31689459e-01f, -6.42444044e-02f, -1.76564932e-01f, -3.57334346e-01f, -9.91837606e-02f,
  -2.54728347e-01f, 3.61040421e-02f, 1.70078799e-01f, 1.94180191e-01f, 2.05638289e-01f, -4.78874780e-02f, 6.01851232e-02f, -1.82923712e-02f, 1.73479855e-01f, 1.42413661e-01f,
  -1.63286999e-01f, -9.79857594e-02f, -5.07060699e-02f, -1.03740416e-01f, 2.14458063e-01f, -1.26082778e-01f, -5.76389767e-02f, -1.76155791e-02f, -1.14376657e-01f, 2.95240525e-02f,
  -3.39763239e-02f, -3.45486924e-02f, 3.81515808e-02f, -4.62550633e-02f, -9.95875150e-02f, -6.52187839e-02f, 1.60492249e-02f, -3.26574668e-02f, -6.96276352e-02f, -2.20708642e-02f,
  2.95076758e-01f, -1.29917517e-01f, -1.52443752e-01f, 1.07986189e-01f, -5.85003681e-02f, -9.31450278e-02f, 6.27698668e-04f, -1.79322377e-01f, -2.62614079e-02f, -3.94880548e-02f,
  1.09860018e-01f, 1.42865896e-01f, 1.04874313e-01f, 1.74752563e-01f, -3.16404700e-02f, 4.31436412e-02f, 3.35564911e-02f, 2.18064208e-02f, 8.59149694e-02f, -9.50125605e-02f,
  2.69805491e-01f, 2.01168180e-01f, -2.74563748e-02f, 7.02063441e-02f, 1.13426782e-01f, 7.89045095e-02f, 1.34215042e-01f, 6.04801103e-02f, -1.46706834e-01f, 2.83621341e-01f,
  8.20730448e-01f, 1.41139925e-01f, -6.03665292e-01f, -5.28367087e-02f, -2.03695953e-01f, -1.76524892e-01f, 6.25928342e-02f, 4.49074470e-02f, 1.58890322e-01f, 8.09491649e-02f,
  -3.85103002e-02f, -4.85945642e-02f, -1.30629435e-01f, -1.69803843e-01f, -6.07342971e-03f, -6.71385452e-02f, -2.53490061e-01f, -2.39115775e-01f, -2.25131899e-01f, -1.78961176e-02f,
  -3.76310386e-02f, 2.98750633e-03f, -1.27608776e-01f, -9.83886272e-02f, -2.42824435e-01f, -1.65158018e-01f, -2.17834696e-01f, -2.75338203e-01f, -3.02850038e-01f, -3.10988933e-01f,
  -5.63679159e-01f, -2.43503422e-01f, 1.04233019e-01f, 9.40240175e-02f, 3.67501229e-02f, 1.71707779e-01f, 8.85064080e-02f, -1.12380572e-02f, 1.70974702e-01f, -6.06274139e-03f,
  1.00011230e-02f, -1.07861005e-01f, -1.10601403e-01f, -1.15589432e-01f, -8.86382237e-02f, 4.25999872e-02f, 1.61166385e-01f, 9.71171036e-02f, 3.71120962e-07f, -3.80958319e-02f,
  -7.71937966e-02f, 5.89318313e-02f, 6.93887398e-02f, 2.27716025e-02f, 1.98256150e-01f, -5.08849956e-02f, -4.18954110e-03f, -3.60897183e-02f, 6.66879937e-02f, 2.05491051e-01f,
  -5.57236895e-02f, 1.52793020e-01f, -1.41210616e-01f, 3.65334451e-02f, 8.56432393e-02f, 1.28344476e-01f, 8.57635140e-02f, 5.43341413e-02f, 6.30548671e-02f, 1.09637626e-01f,
  1.12050869e-01f, -1.31445065e-01f, -6.04993515e-02f, 8.68092943e-03f, -1.79533198e-01f, -6.46580160e-02f, 8.46945941e-02f, -1.14676043e-01f, -1.75943196e-01f, -5.69575019e-02f,
  3.07300445e-02f, 3.18596661e-02f, -1.38205633e-01f, -2.90937256e-02f, -5.73926084e-02f, -1.07692126e-02f, -7.91398510e-02f, 9.78484191e-03f, -3.99301462e-02f, 3.15515809e-02f,
  -2.87519395e-01f, -4.87569094e-01f, 1.12533040e-01f, 1.26439840e-01f, -9.12626907e-02f, 8.17653239e-02f, -7.09686801e-02f, 3.53233330e-02f, -7.04095140e-02f, 2.79302578e-02f,
  4.72301356e-02f, 5.36490344e-02f, -4.26544342e-03f, 7.98723921e-02f, -1.41862100e-02f, -7.80722778e-03f, 2.66044825e-01f, 1.84017271e-01f, 4.67794687e-02f, -7.27020344e-03f,
  1.91912755e-01f, 1.76053151e-01f, 1.48401961e-01f, 1.40541151e-01f, 1.91712976e-01f, 8.10948573e-03f, 7.74490610e-02f, 1.36797398e-03f, -5.23386523e-02f, 3.05064529e-01f,
  -1.54285893e-01f, -3.42920303e-01f, -2.83948690e-01f, -5.39430439e-01f, -3.37544262e-01f, -1.39112815e-01f, -1.84781507e-01f, -1.58606634e-01f, -1.46443352e-01f, -2.69332051e-01f,
  -6.11555800e-02f, 7.35234022e-02f, 3.06264590e-03f, 1.27029978e-03f, 1.14066802e-01f, -2.25262240e-01f, -1.95016310e-01f, -1.53603598e-01f, -8.42699781e-03f, -1.55027077e-01f,
  -2.62633771e-01f, -3.67367774e-01f, -2.64629066e-01f, -2.09224537e-01f, -3.79593611e-01f, -8.30259249e-02f, -1.72034696e-01f, -1.76055953e-01f, 5.70730753e-02f, -1.74842060e-01f,
  -3.15693825e-01f, -2.96673570e-02f, 4.39966246e-02f, 9.45086554e-02f, -1.74504012e-01f, -1.21001191e-02f, -1.04828820e-01f, -1.42851681e-01f, 7.24957511e-03f, -1.84244469e-01f,
  -1.28323529e-02f, -2.67459974e-02f, -4.01702225e-02f, 8.95122183e-04f, -2.05858976e-01f, -7.10537806e-02f, -1.14784069e-01f, 2.74785347e-02f, 8.49029887e-03f, 8.13774318e-02f,
  6.10572286e-02f, 4.66692671e-02f, 1.31203443e-01f, 1.35964215e-01f, 4.17970829e-02f, 1.30005971e-01f, -1.14699304e-02f, 1.78879857e-01f, 1.14613228e-01f, -7.03115091e-02f,
  -1.26306385e-01f, 4.34635021e-02f, 1.27352938e-01f, 6.30894303e-02f, 7.53674060e-02f, 1.55483007e-01f, -3.44574563e-02f, -5.10154990e-04f, 1.28437832e-01f, 6.67717075e-03f,
  -6.64943904e-02f, 1.24211796e-01f, -2.69602146e-02f, 1.72103252e-02f, 1.17726825e-01f, 3.68987806e-02f, 4.00723405e-02f, 8.64504185e-03f, 1.50348172e-01f, 5.37473448e-02f,
  1.64660543e-01f, 1.24691814e-01f, 5.36678247e-02f, -2.95501649e-02f, 7.48044550e-02f, 8.09117313e-03f, 4.11533453e-02f, 1.48935691e-01f, 8.25428590e-02f, 1.10375367e-01f,
  -3.92978758e-01f, 1.90674871e-01f, -8.53677988e-02f, 1.27942711e-01f, -9.02360529e-02f, 2.24449635e-02f, 6.42782031e-03f, -5.82616143e-02f, -5.71096353e-02f, -6.83018267e-02f,
  8.29098672e-02f, -5.63073792e-02f, -6.66122288e-02f, -1.55971963e-02f, -7.17950165e-02f, 1.04535148e-02f, 1.68361701e-04f, 4.96989638e-02f, 1.57714784e-01f, -6.21888302e-02f,
  1.43361792e-01f, 2.28580698e-01f, 1.00818947e-01f, 8.84553045e-02f, 1.49346486e-01f, 6.22446723e-02f, -2.48353910e-02f, 1.14788972e-01f, 1.80734232e-01f, -1.50997579e-01f,
  -1.01828325e+00f, -2.63394177e-01f, 6.89414591e-02f, 1.56417489e-01f, 2.38615155e-01f, 2.17278764e-01f, 1.66304782e-01f, 6.05475940e-02f, 1.72560990e-01f, -1.18652740e-02f,
  -4.88991961e-02f, 1.13500431e-01f, 8.24509561e-02f, 7.36362636e-02f, 8.34634677e-02f, 2.71928877e-01f, 2.20817387e-01f, 1.37259752e-01f, 4.81665507e-02f, 1.13754779e-01f,
  2.09844232e-01f, 4.36228653e-03f, -2.24771917e-01f, 6.02498767e-04f, 1.57838702e-01f, 2.58683950e-01f, 1.49325341e-01f, 1.65716827e-01f, 1.78280115e-01f, 3.08304727e-01f,
  5.62999129e-01f, -2.80312061e-01f, 3.91879752e-02f, -2.17498899e-01f, -1.22947060e-01f, -1.87679157e-01f, -9.21248123e-02f, -2.85646953e-02f, -1.84267238e-01f, 8.38490203e-03f,
  -1.32912830e-01f, -8.72097462e-02f, -2.02592704e-02f, -1.25824437e-01f, -1.08545609e-01f, -1.36498645e-01f, -1.09285459e-01f, 1.12207875e-01f, 1.17367595e-01f, 6.52219057e-02f,
  3.67377102e-02f, 9.63598117e-02f, 1.07885532e-01f, -4.47680764e-02f, 2.13213265e-03f, 1.22605283e-02f, -1.88799705e-02f, -5.99721856e-02f, 4.53573875e-02f, 3.02214455e-02f,
  -1.07070748e-02f, -9.56145599e-02f, 3.68416682e-02f, 1.68266594e-02f, 2.87410691e-02f, -4.31223735e-02f, 1.55859396e-01f, 2.16146000e-02f, 9.28886328e-03f, -1.20895274e-01f,
  1.34441584e-01f, 1.96118355e-01f, 1.12578012e-01f, 1.83001012e-02f, -6.01128209e-03f, 2.15052813e-02f, -4.95491512e-02f, 4.67872582e-02f, -1.62044652e-02f, 3.23229730e-02f,
  9.60672349e-02f, 2.56063901e-02f, -1.12998873e-01f, 4.86012641e-03f, -5.97340195e-03f, -7.08257556e-02f, 8.21315497e-02f, -1.17134370e-01f, -7.85220042e-02f, -7.56381825e-02f,
  5.45279384e-01f, -3.18510644e-02f, 6.31394684e-02f, 6.00674003e-02f, -3.73770706e-02f, -2.42857873e-01f, 1.03751026e-01f, 3.37715372e-02f, 1.28315300e-01f, 1.17483042e-01f,
  5.74967638e-02f, -1.74104884e-01f, -1.03586376e-01f, -6.01289980e-03f, -5.68394586e-02f, 5.02394363e-02f, -1.05036013e-01f, 6.88793287e-02f, 1.34998545e-01f, 1.34359986e-01f,
  -1.35111809e-01f, 8.92433152e-02f, 2.26659596e-01f, 1.11310139e-01f, 4.44187596e-03f, -2.30500568e-02f, 1.34823984e-03f, 8.39610845e-02f, 1.83860920e-02f, 3.44026908e-02f,
  8.04116204e-02f, -1.78731322e-01f, 4.19648170e-01f, 6.03745691e-02f, -3.91913563e-01f, -3.12034816e-01f, -3.32675785e-01f, -6.33551329e-02f, -1.11019939e-01f, -2.43877724e-01f,
  -4.04442996e-01f, -3.85347940e-02f, 1.14422448e-01f, 2.58165181e-01f, 2.95125157e-01f, 2.41357461e-01f, 4.52540815e-01f, 6.82395875e-01f, 3.68386328e-01f, -9.20256972e-03f,
  -2.77895145e-02f, 1.98595628e-01f, 3.69356096e-01f, 4.41374928e-01f, 1.52686343e-01f, 7.24379197e-02f, 7.73262158e-02f, 9.84039828e-02f, 3.03434879e-02f, 4.92208391e-01f,
  -2.35396832e-01f, -2.26465911e-01f, 2.01464090e-02f, -1.54162094e-01f, -3.37577015e-02f, 1.97492450e-01f, -6.62045553e-03f, 1.50328442e-01f, 5.19203208e-02f, 1.22719452e-01f,
  -5.64616062e-02f, 5.13495617e-02f, -6.25600293e-02f, -6.59678411e-03f, -2.85223760e-02f, -4.53455262e-02f, 2.74510711e-01f, 2.89425194e-01f, 1.96793273e-01f, -5.02013974e-02f,
  -2.09438093e-02f, -2.67405659e-01f, -2.59498507e-01f, -1.20275252e-01f, -2.12208852e-02f, 4.16535735e-02f, -1.32169589e-01f, -1.11367248e-01f, -1.82620630e-01f, 3.76339480e-02f,
  -8.54237303e-02f, 1.04116900e-02f, 3.33986692e-02f, 1.02536246e-01f, 7.25335106e-02f, 4.83633541e-02f, 1.45035237e-01f, 8.09464455e-02f, -5.83875701e-02f, 6.60182014e-02f,
  4.73250300e-02f, 1.57836340e-02f, 1.72354430e-01f, 2.18981169e-02f, -1.25489488e-01f, -3.49914916e-02f, 4.43973020e-02f, 2.47994997e-02f, -6.62219822e-02f, -2.77144071e-02f,
  -2.12510433e-02f, 8.09305385e-02f, 1.01278953e-01f, 2.95094222e-01f, -9.05122980e-02f, 6.19232003e-03f, 8.96305516e-02f, -1.04710005e-01f, -4.03163545e-02f, -1.87556475e-01f,
  -4.05809641e-01f, -1.23414911e-01f, -4.08363305e-02f, 1.73067600e-02f, -1.35085225e-01f, -7.01333582e-02f, -1.37713626e-01f, -5.35073578e-02f, -4.42565903e-02f, 9.27120447e-02f,
  -2.27959529e-01f, 4.26706765e-03f, -1.72461774e-02f, 1.28637642e-01f, -1.21737476e-02f, -2.23998785e-01f, -1.06751919e-01f, 8.47972184e-02f, 2.30852305e-03f, -1.04342839e-02f,
  5.41301593e-02f, -2.70922810e-01f, -3.00350040e-01f, -2.23407954e-01f, -2.26674482e-01f, -2.73828030e-01f, -2.40051210e-01f, -1.99645519e-01f, -3.33824307e-01f, -3.13551903e-01f,
  4.33390647e-01f, -2.04028040e-01f, -7.23455131e-01f, -1.24931566e-01f, -3.63134652e-01f, -3.02044213e-01f, -1.22791357e-01f, 9.01565999e-02f, -7.07719475e-02f, -2.37021625e-01f,
  -1.87701166e-01f, -7.70048797e-02f, -2.12811112e-01f, -5.79283535e-02f, 1.42938510e-01f, -2.62863338e-01f, -3.73101056e-01f, -1.76163539e-01f, 5.84125035e-02f, 1.10192701e-01f,
  6.21277802e-02f, 2.88351160e-02f, 2.01647088e-01f, -7.53971795e-03f, -2.49299332e-01f, -2.31834874e-01f, -4.16924119e-01f, -2.37868771e-01f, -1.83024615e-01f, -3.35728914e-01f,
  -3.29102010e-01f, -4.60000411e-02f, -1.00212350e-01f, 3.53161357e-02f, -1.80879503e-01f, 4.46153944e-03f, -1.64373983e-02f, 1.97999552e-02f, 1.10888630e-01f, -4.79794517e-02f,
  -7.18026683e-02f, 4.02408727e-02f, -7.35521466e-02f, -1.51475817e-01f, -4.51685451e-02f, 9.51123536e-02f, 4.39862832e-02f, -1.07983602e-02f, -1.62687942e-01f, -5.55728450e-02f,
  -3.36364731e-02f, -1.06856838e-01f, -6.22601062e-02f, -6.63426667e-02f, -5.59796616e-02f, -1.69309750e-01f, -1.08379416e-01f, -2.55359653e-02f, -1.44267038e-01f, 2.21702829e-02f,
  9.51435864e-02f, -9.07176062e-02f, -7.05669224e-02f, -5.56298904e-02f, 9.58194584e-02f, -5.75422570e-02f, 1.41179450e-02f, 9.26535055e-02f, 2.93382653e-03f, -4.05657403e-02f,
  1.33621600e-02f, -1.18918188e-01f, 7.04561472e-02f, 3.44295911e-02f, -4.58377227e-02f, -1.05512753e-01f, 6.55216398e-04f, 3.20002846e-02f, 5.02151586e-02f, 4.92798910e-02f,
  -4.98720855e-02f, -2.99174581e-02f, -6.69897571e-02f, 7.75662139e-02f, -1.44861490e-01f, -2.32731570e-02f, -7.32260346e-02f, 7.32700303e-02f, -2.08946690e-02f, -2.61360891e-02f,
  -4.82495911e-02f, -8.78282860e-02f, -2.73610335e-02f, 1.08352475e-01f, -8.93843919e-02f, -7.13130310e-02f, -2.75124442e-02f, 7.75887445e-02f, -1.26003057e-01f, -2.77076196e-02f,
  -7.86285102e-02f, 4.23552468e-02f, -8.24939236e-02f, 8.31761584e-02f, 6.74530640e-02f, 7.30992258e-02f, 1.33062571e-01f, -1.09096177e-01f, -4.76344451e-02f, 3.82681098e-03f,
  2.06737202e-02f, 1.64800435e-01f, 2.19261333e-01f, 1.92542486e-02f, 8.97078812e-02f, 3.55384313e-02f, -7.68486857e-02f, -5.22946194e-02f, 1.05983056e-01f, 3.09826523e-01f,
  -5.13774693e-01f, -8.14742222e-02f, 3.10340643e-01f, -1.61229581e-01f, 2.57958233e-01f, 4.36280161e-01f, 3.30629438e-01f, 1.36085629e-01f, -2.27167588e-02f, 9.35235471e-02f,
  -1.25249118e-01f, -4.45936710e-01f, -3.41130853e-01f, -3.53619993e-01f, -2.08839625e-01f, 1.14003450e-01f, 1.77760750e-01f, -1.90043539e-01f, -1.27652019e-01f, 1.14311606e-01f,
  -1.60972983e-01f, -2.82712102e-01f, -3.78513247e-01f, -2.03274772e-01f, -1.40799344e-01f, -3.50234389e-01f, -8.97363424e-02f, -3.96736525e-03f, 1.49881139e-01f, -1.01065300e-01f,
  2.82069650e-02f, 1.41208023e-01f, -1.10978581e-01f, -1.94275141e-01f, -1.60878133e-02f, -7.02937543e-02f, -5.58517687e-02f, 1.02076337e-01f, -1.55293953e-03f, 1.73513412e-01f,
  3.84983700e-03f, -1.33862302e-01f, -2.34634113e-02f, 8.95078555e-02f, 1.43225715e-01f, 1.05847567e-01f, 7.07421228e-02f, 8.05996284e-02f, 4.98844683e-02f, 9.45444927e-02f,
  1.69464853e-02f, 1.68708727e-01f, 2.79054999e-01f, 1.41552523e-01f, 4.38048020e-02f, -1.15621593e-02f, 8.95967633e-02f, 1.61330462e-01f, 1.81324258e-01f, -8.61153603e-02f,
  -9.43249390e-02f, -1.88277960e-01f, 4.48831953e-02f, -5.98821491e-02f, 4.35424000e-02f, 1.78137198e-02f, 5.87687232e-02f, -1.76647734e-02f, -1.27912596e-01f, -8.52721110e-02f,
  5.30606434e-02f, 1.80361047e-01f, 7.57587701e-02f, -2.83221416e-02f, -1.60252571e-01f, -3.25867869e-02f, 1.45797119e-01f, 2.75928602e-02f, 4.02339473e-02f, 1.41612381e-01f,
  6.38378933e-02f, 1.26262441e-01f, 2.74942759e-02f, 1.25280038e-01f, 2.49787197e-01f, 5.19385450e-02f, 1.69029638e-01f, 8.84825438e-02f, -1.35749385e-01f, -2.60666404e-02f,
  -1.88370526e-01f, 7.84210637e-02f, -1.40526667e-01f, -2.26006191e-02f, -1.90476757e-02f, -5.05087301e-02f, -8.14959705e-02f, 5.11451736e-02f, 1.51514381e-01f, 2.63390690e-01f,
  1.34519324e-01f, -7.26162195e-02f, 3.40989009e-02f, 5.60168102e-02f, -1.43309897e-02f, -1.09911757e-02f, -6.27231738e-03f, -7.50587210e-02f, 1.73797593e-01f, 1.72953144e-01f,
  9.02974457e-02f, 1.02815196e-01f, -8.82428326e-03f, 4.79004942e-02f, -3.69538716e-03f, -1.31550476e-01f, -1.37919039e-01f, -3.57174799e-02f, 3.81783023e-02f, -1.81912214e-01f,
  6.92967832e-01f, 5.09664953e-01f, 1.99073628e-01f, 1.48084819e-01f, -7.96013400e-02f, -1.47345096e-01f, -2.16624490e-03f, -6.34279773e-02f, -2.09081620e-01f, 1.56346753e-01f,
  4.71038297e-02f, -1.25157356e-01f, -1.43298849e-01f, -9.50868279e-02f, 3.80542353e-02f, 2.20541563e-02f, -1.45619407e-01f, 1.00501031e-01f, 8.43065679e-02f, 1.84448615e-01f,
  2.30092518e-02f, 1.49567917e-01f, 4.04738486e-01f, 1.40259072e-01f, 2.84886688e-01f, -2.84366659e-03f, 4.62508574e-02f, 1.33029744e-01f, 1.95179999e-01f, 4.37603712e-01f,
  2.91791499e-01f, 3.27798545e-01f, -1.56752795e-01f, 2.08537262e-02f, 5.72473966e-02f, 9.17925686e-02f, 5.69307841e-02f, -4.71360497e-02f, -9.02626067e-02f, -1.35679170e-01f,
  4.72281128e-02f, 3.93000431e-02f, -9.45436116e-03f, 1.80132743e-02f, -1.40670493e-01f, -2.34017689e-02f, -5.84616326e-02f, -3.43755409e-02f, -1.63859069e-01f, -1.00985304e-01f,
  -6.11051805e-02f, 5.76779582e-02f, -1.17754027e-01f, -3.66924942e-01f, -1.33246824e-01f, -2.96869963e-01f, -1.26814336e-01f, 1.11294743e-02f, -1.94166198e-01f, -7.38364905e-02f,
  -4.65726465e-01f, -9.74302292e-02f, -4.98356903e-03f, -1.13172442e-01f, -2.14878067e-01f, -1.88215926e-01f, -1.46535769e-01f, -6.62327483e-02f, -1.45227358e-01f, 3.00318208e-02f,
  -1.31850272e-01f, -1.97158962e-01f, -8.37218016e-02f, -9.85147655e-02f, -1.69525996e-01f, -6.98088780e-02f, -5.16520813e-02f, -8.16130415e-02f, -7.51179308e-02f, -2.32737232e-02f,
  -6.83431178e-02f, -4.13462054e-03f, -7.17407465e-02f, -6.29353076e-02f, -1.69881463e-01f, -2.25030094e-01f, -2.21206874e-01f, -1.94122002e-01f, -1.35725230e-01f, 1.16854206e-01f,
  -3.27927649e-01f, -1.11662425e-01f, 6.64229915e-02f, 2.57950693e-01f, 1.81943074e-01f, 1.91685721e-01f, 1.92067951e-01f, 1.18376404e-01f, 1.14341140e-01f, -2.02978437e-04f,
  4.27189730e-02f, 1.97918758e-01f, 7.06073940e-02f, 7.50620738e-02f, -1.57964118e-02f, -1.03853993e-01f, 8.29785466e-02f, 2.10381653e-02f, 1.68759767e-02f, 5.22864945e-02f,
  -1.28818825e-01f, -2.37263262e-01f, -2.45957687e-01f, -1.88746154e-01f, -2.31275558e-01f, -2.24146068e-01f, -1.31959662e-01f, -1.18850745e-01f, -1.71344101e-01f, -3.34799409e-01f,
  7.23929048e-01f, -2.12267548e-01f, -8.84982169e-01f, 2.06626207e-01f, -9.39744487e-02f, -2.58230925e-01f, -1.77535772e-01f, 1.63604006e-01f, 2.05379352e-01f, -1.65833920e-01f,
  -2.50494063e-01f, 5.46669774e-02f, -2.90980577e-01f, -1.19233832e-01f, -8.57041702e-02f, -4.84768093e-01f, -4.09298986e-01f, -3.98345739e-01f, 6.25784160e-04f, 4.91935611e-01f,
  3.06095928e-01f, 3.19619864e-01f, 1.55592188e-01f, -3.14150229e-02f, 3.36558744e-02f, 1.61648635e-02f, -4.97162193e-01f, -1.12336121e-01f, -1.92889541e-01f, -3.03574473e-01f,
  -3.66634160e-01f, -1.69874549e-01f, -1.82597741e-01f, 5.72973415e-02f, -1.05961658e-01f, 1.50210232e-01f, 5.89887351e-02f, -5.63450083e-02f, 1.37190297e-01f, -6.17789440e-02f,
  1.29676601e-02f, 1.37110278e-01f, -6.85694888e-02f, -9.10408646e-02f, 1.23477392e-01f, 1.26839459e-01f, 4.98455651e-02f, -7.48130158e-02f, -2.16860205e-01f, 6.45750016e-03f,
  6.33627325e-02f, -1.11922443e-01f, -3.22119713e-01f, -1.13834448e-01f, -6.95412979e-02f, -1.40911281e-01f, -1.40677199e-01f, 1.30315408e-01f, -2.94925392e-01f, 4.52082120e-02f,
  -4.93769534e-02f, -1.07552841e-01f, 8.29995945e-02f, 1.68319792e-01f, 2.41510734e-01f, -1.58158153e-01f, -4.95281480e-02f, 5.39586246e-02f, 3.10322689e-03f, 1.15516342e-01f,
  -5.80577217e-02f, -2.57247221e-02f, -1.77202765e-02f, -9.98672545e-02f, -1.29168659e-01f, -7.34293610e-02f, -1.21137492e-01f, 1.53219197e-02f, -2.61431076e-02f, 4.65991348e-02f,
  2.65421085e-02f, 6.47969767e-02f, 1.99516937e-02f, 9.46998373e-02f, -6.48823157e-02f, -1.31194100e-01f, -4.12935531e-03f, 7.95024335e-02f, 5.74836973e-03f, -6.41833246e-02f,
  1.91442534e-01f, -4.13865685e-01f, -2.49466896e-02f, -4.71753404e-02f, -5.95008954e-02f, -5.41247949e-02f, -1.05679601e-01f, -3.21388803e-02f, -2.00837813e-02f, 3.41347232e-02f,
  -7.61117712e-02f, 1.05689667e-01f, -1.95126370e-01f, 5.22050485e-02f, 1.40960723e-01f, 8.95431116e-02f, 1.41400546e-01f, -1.25868037e-01f, -6.72910884e-02f, 5.54075688e-02f,
  6.65513054e-02f, 5.83201759e-02f, 1.28889233e-01f, -1.70456059e-02f, 8.91317204e-02f, 1.86853223e-02f, -1.24849461e-01f, 1.11640235e-02f, -1.07764840e-01f, 2.24236861e-01f,
  -7.93980956e-01f, -6.64159879e-02f, -4.66582566e-01f, -9.62819159e-01f, -4.06541854e-01f, 2.39817351e-02f, 3.52824092e-01f, -1.06270455e-01f, -5.30455172e-01f, -2.39833668e-01f,
  1.00017756e-01f, 9.09214281e-03f, -1.89783290e-01f, 1.89026147e-01f, 3.96609157e-01f, 7.66274147e-03f, -3.34369510e-01f, 1.86632462e-02f, 4.45547938e-01f, 4.80553895e-01f,
  2.31704205e-01f, -1.44162759e-01f, -8.16939995e-02f, -1.41709268e-01f, -3.55485708e-01f, -6.78899363e-02f, -3.85199100e-01f, -2.41258100e-01f, 4.31467667e-02f, -4.71710861e-01f,
  2.30782881e-01f, -3.26680899e-01f, 2.62673404e-02f, -7.37923905e-02f, -9.73671898e-02f, -7.21700191e-02f, -1.60724260e-02f, -2.94354290e-01f, -1.38084173e-01f, -1.95055768e-01f,
  -2.66676813e-01f, -2.19260082e-02f, -1.09516189e-01f, 6.90451190e-02f, -1.37010336e-01f, -2.13982872e-04f, -1.45239756e-01f, -2.40562651e-02f, -7.15263709e-02f, 1.64346084e-01f,
  1.17143989e-01f, -5.67448922e-02f, -2.04272550e-02f, 9.73228291e-02f, 4.04588990e-02f, -7.32089803e-02f, 9.38200504e-02f, 3.35366577e-02f, 6.51470795e-02f, -2.07554907e-01f,
  -3.63478325e-02f, 1.29497528e-01f, 8.84791091e-02f, -2.32587829e-02f, 1.06160641e-01f, -4.36830968e-02f, -9.02911723e-02f, 7.88039565e-02f, 1.23673797e-01f, 8.50125030e-02f,
  -5.41993156e-02f, -7.39074349e-02f, 3.38074006e-02f, -6.98917508e-02f, 3.61290798e-02f, -1.40100703e-01f, 4.68293093e-02f, 1.56636477e-01f, -4.37275171e-02f, -1.14554979e-01f,
  -5.36112636e-02f, -2.67757028e-02f, -1.35413155e-01f, 1.08398862e-01f, 6.48023486e-02f, 1.78858750e-02f, -9.09121931e-02f, 2.21065238e-01f, -1.48831839e-02f, -7.12270103e-03f,
  2.36060880e-02f, 1.81024179e-01f, -6.73568845e-02f, -8.09956864e-02f, -2.21768588e-01f, -4.73854356e-02f, -1.05650425e-01f, -2.72121672e-02f, -2.92301893e-01f, 1.58047117e-02f,
  2.86888704e-02f, 7.38974512e-02f, -1.10286161e-01f, 6.68668421e-03f, 1.22796141e-01f, -1.85958296e-02f, 7.00784251e-02f, -8.67464617e-02f, 4.97708432e-02f, 3.51639092e-02f,
  -5.45939133e-02f, 1.28809005e-01f, 1.62153944e-01f, 5.11434786e-02f, 4.82276343e-02f, 1.93003282e-01f, 2.71755815e-01f, 2.45372012e-01f, 1.94352657e-01f, 1.41804188e-01f,
  1.59075800e-02f, 2.49549657e-01f, -2.93637455e-01f, -1.63875550e-01f, 7.45344907e-02f, 3.95059824e-01f, 5.85602760e-01f, 1.34215027e-01f, -1.55280024e-01f, 6.27462566e-02f,
  2.24670991e-01f, -1.54846460e-01f, -2.47506693e-01f, -1.66593507e-01f, 1.81590229e-01f, -1.06667355e-02f, -1.87055305e-01f, -2.42375284e-01f, -6.81026503e-02f, 3.09577435e-01f,
  1.63946018e-01f, 5.83950169e-02f, 1.04369178e-01f, -4.14493270e-02f, -2.48355627e-01f, -3.41636509e-01f, -1.48979679e-01f, -1.13576148e-02f, 8.44649747e-02f, -4.34077173e-01f,
  -1.82983965e-01f, 1.46658018e-01f, -4.66043055e-02f, -6.66261837e-02f, 2.57533304e-02f, 9.68136415e-02f, 1.06386408e-01f, -1.06061369e-01f, 1.23650983e-01f, -5.24731725e-02f,
  -5.80075756e-02f, 4.37580161e-02f, 1.05200514e-01f, -3.79852057e-02f, 1.20582119e-01f, 5.55972643e-02f, -3.53001505e-02f, 5.37341572e-02f, -1.51332067e-02f, -5.71106337e-02f,
  8.28843564e-02f, 1.47941142e-01f, 1.86882451e-01f, 9.03862268e-02f, 1.30509272e-01f, -3.57316509e-02f, 1.66965015e-02f, -4.51845042e-02f, 8.82220417e-02f, -1.20442100e-01f,
  -4.79820333e-02f, -1.61587875e-02f, 4.85968813e-02f, -1.00135572e-01f, 8.84744376e-02f, -1.36532247e-01f, -1.77676901e-01f, 5.07971309e-02f, 8.95920210e-03f, 2.37127896e-02f,
  6.56862259e-02f, 1.17514916e-01f, -3.94213311e-02f, 8.98652524e-02f, -1.48517326e-01f, -1.54467737e-02f, 1.02784112e-01f, 3.34605761e-02f, 8.22526664e-02f, 8.91072899e-02f,
  -2.61689033e-02f, 8.42389166e-02f, -2.23040096e-02f, 8.38397741e-02f, 1.42365545e-01f, -2.21980959e-02f, -1.09156005e-01f, 4.95183803e-02f, 1.03058711e-01f, 1.37452960e-01f,
  -6.56754524e-02f, 4.45730954e-01f, -1.11758664e-01f, -1.02881551e-01f, -7.11378157e-02f, 6.29791850e-03f, -7.64653161e-02f, -1.09277209e-02f, -8.67504403e-02f, -8.26056749e-02f,
  -5.40539660e-02f, -1.17436558e-01f, 1.03276446e-01f, 2.56940033e-02f, -4.39746417e-02f, -1.69183627e-01f, 6.63263500e-02f, -4.37979735e-02f, -1.52968429e-02f, -1.33065775e-01f,
  -7.83075206e-03f, -5.89441471e-02f, -1.45488396e-01f, -1.93731695e-01f, -1.79274734e-02f, -4.87058051e-02f, -1.39563039e-01f, -8.81835371e-02f, -9.23546031e-03f, -1.00061879e-01f,
  6.19007647e-01f, -4.90855157e-01f, 1.72627270e-02f, 1.22881696e-01f, 3.72411544e-03f, -5.49555868e-02f, -2.85299271e-01f, -2.06531137e-01f, -5.13798185e-03f, -3.67475338e-02f,
  -1.55159598e-02f, 1.25789970e-01f, 9.93462428e-02f, -1.70726031e-02f, 2.55787913e-02f, -1.44842491e-01f, 8.75001401e-03f, 5.91285005e-02f, 1.21650770e-01f, -1.51713297e-01f,
  -1.49645448e-01f, -3.59440856e-02f, 1.03846759e-01f, -8.65570083e-02f, -1.83517262e-01f, -2.41531897e-02f, -8.26997086e-02f, -1.02182508e-01f, -1.96436003e-01f, -8.39849412e-02f,
  -1.71796009e-01f, 1.71278358e-01f, 1.74649283e-01f, 6.12557046e-02f, -6.93012998e-02f, -3.96784133e-04f, 1.24687903e-01f, -1.49883211e-01f, -1.21966474e-01f, -1.56148374e-01f,
  -6.87894598e-02f, 9.71632823e-02f, 8.36137980e-02f, -6.65355325e-02f, -1.66042507e-01f, 3.67956869e-02f, 4.83313249e-03f, 5.89744709e-02f, -2.92641968e-02f, -1.05501525e-01f,
  -1.04722999e-01f, 2.10059602e-02f, -1.01851881e-03f, -7.23179728e-02f, 1.51547804e-01f, 1.33897901e-01f, -2.15687789e-02f, 8.27812329e-02f, 1.66615322e-01f, 7.89281621e-05f,
  -8.81182551e-02f, -1.31830692e-01f, 1.27524540e-01f, 1.98123187e-01f, 1.28103584e-01f, -3.63150635e-03f, -6.20707721e-02f, -5.22844531e-02f, 2.21920609e-01f, 7.49719068e-02f,
  -8.47119838e-02f, 8.78069475e-02f, 3.39040346e-02f, -4.94772270e-02f, 1.44121721e-01f, 1.48031162e-02f, -1.46901473e-01f, -1.30310282e-01f, 8.03327784e-02f, 1.33868650e-01f,
  1.35781705e-01f, -1.43634275e-01f, -1.75585955e-01f, -7.91937634e-02f, -1.16379157e-01f, -1.03273995e-01f, -5.84708564e-02f, -1.96719747e-02f, -3.41291586e-03f, -1.28833950e-01f,
  -1.77810952e-01f, 6.03807926e-01f, 2.87241608e-01f, 8.54484066e-02f, 1.45809380e-02f, -9.90049988e-02f, 2.97059238e-01f, 8.86568986e-03f, -7.42047951e-02f, -8.85945112e-02f,
  -1.44901238e-02f, 1.22487247e-01f, -2.25375723e-02f, -3.66900638e-02f, 9.77868438e-02f, 1.27766103e-01f, -8.56176950e-03f, 8.27795863e-02f, -7.00947121e-02f, -1.92788363e-01f,
  -1.44389778e-01f, -2.90781669e-02f, 1.16352595e-01f, 1.34548396e-01f, 1.08531155e-01f, 1.66474238e-01f, -2.52190642e-02f, -1.87669657e-02f, 8.97870809e-02f, -7.42867664e-02f,
  -5.50455749e-02f, 2.61609852e-01f, -2.40413651e-01f, 3.06997418e-01f, 3.16788018e-01f, 2.95328766e-01f, 1.96713045e-01f, 3.25486511e-01f, 2.03514859e-01f, 1.37977898e-01f,
  2.62861788e-01f, 3.17594677e-01f, 3.23973119e-01f, 1.73536479e-01f, 2.76762366e-01f, 1.74857080e-01f, 1.66399136e-01f, 9.52380302e-04f, -3.22737247e-02f, 1.34505972e-01f,
  3.46947312e-01f, 1.87723517e-01f, 3.44933160e-02f, 6.62847012e-02f, 8.56910497e-02f, 2.23523304e-01f, 1.28201917e-01f, 1.56825513e-01f, 3.08609724e-01f, 2.28483140e-01f,
  -3.41125190e-01f, -1.49291635e-01f, -5.41795641e-02f, 6.78020194e-02f, -8.06233361e-02f, -1.71850547e-01f, -9.24363062e-02f, -1.57613799e-01f, 6.22242652e-02f, -7.97987636e-03f,
  -2.91132536e-02f, -6.23733513e-02f, -8.14148635e-02f, -1.48641825e-01f, -1.00383371e-01f, -8.33068416e-02f, -5.86966099e-03f, -4.95613106e-02f, 4.64846343e-02f, -3.41559527e-04f,
  1.98523477e-02f, 2.10073143e-02f, -5.73003991e-03f, 9.96143324e-04f, -9.66304764e-02f, -9.07715932e-02f, -2.39572860e-03f, -1.44919287e-02f, -7.58745819e-02f, 2.44641174e-02f,
  5.69500960e-02f, -1.06960222e-01f, -2.40304172e-01f, -1.09308876e-01f, 1.13199931e-02f, -4.06619869e-02f, 8.01488105e-03f, 7.46597052e-02f, -8.08445439e-02f, -8.86173472e-02f,
  6.15817085e-02f, -1.17894143e-01f, -1.67455405e-01f, -1.20507836e-01f, -1.32357672e-01f, -1.42740101e-01f, 8.11950583e-03f, -1.73459008e-01f, -1.61853895e-01f, -1.51654691e-01f,
  -9.03255269e-02f, -8.20957497e-02f, -1.97929200e-02f, -1.16852969e-01f, 1.19047333e-02f, -1.23674691e-01f, 3.06985732e-02f, 3.25438823e-03f, -6.64402172e-02f, 1.58796012e-01f,
  1.64224848e-01f, -2.47162327e-01f, 2.52853185e-02f, 4.15447019e-02f, 6.76867962e-02f, -2.31273118e-02f, -1.82596706e-02f, -4.94481996e-02f, -3.73904291e-03f, -3.74984439e-03f,
  -8.16632509e-02f, -1.99791104e-01f, -4.26252149e-02f, -1.27944862e-02f, -1.70982704e-01f, -1.21116161e-01f, 7.37500563e-02f, 1.63864240e-01f, 5.26542924e-02f, 3.45114470e-02f,
  4.96718064e-02f, 2.42035068e-03f, -1.07255958e-01f, 5.76997250e-02f, -3.71065587e-02f, 3.41139697e-02f, -1.41901970e-01f, -4.65878770e-02f, -1.64513648e-01f, -2.47708820e-02f,
  5.10716796e-01f, 6.29378796e-01f, 3.98709744e-01f, -2.66978759e-02f, 7.46648237e-02f, 1.95938982e-02f, 1.32014707e-01f, 1.14093013e-01f, -1.75106376e-01f, 3.41724716e-02f,
  1.24837093e-01f, -2.96752542e-01f, -1.76141143e-01f, -1.82720289e-01f, -1.06963534e-02f, -1.72083732e-02f, -1.69487640e-01f, 1.71474405e-02f, -1.00608561e-02f, 6.18381202e-02f,
  -1.66703090e-01f, 1.39368847e-01f, 1.85065448e-01f, 6.56214580e-02f, 1.09541260e-01f, -2.53781587e-01f, 3.54425912e-03f, 3.04592282e-01f, 1.61343336e-01f, 1.23822093e-02f,
  1.60427228e-01f, 4.54869777e-01f, -6.18283927e-01f, -1.74475729e-01f, 1.64340913e-01f, 2.29438059e-02f, -1.11292489e-01f, 4.51503992e-02f, -6.64886534e-02f, -6.16016760e-02f,
  4.03237306e-02f, 1.69130862e-01f, 1.24844618e-01f, 3.97698730e-02f, 1.66782230e-01f, 5.11998916e-03f, 1.33276314e-01f, 2.16290966e-01f, -9.26566496e-02f, 1.34234831e-01f,
  -2.29397073e-01f, 1.02573045e-01f, 3.20177078e-01f, -6.24908023e-02f, 7.49431923e-02f, -2.04590484e-01f, 1.66713476e-01f, 1.85717434e-01f, 4.00009099e-03f, 3.98098268e-02f,
  -2.84411162e-01f, -1.07074273e-03f, 1.36090264e-01f, 1.41908780e-01f, -6.94658458e-02f, -5.01946397e-02f, -8.04567803e-03f, 4.90937755e-02f, 4.28597555e-02f, 1.19522080e-01f,
  -8.60102102e-02f, 1.13362279e-02f, 3.44034061e-02f, 3.56149338e-02f, -3.21182013e-01f, 1.02704108e-01f, 1.09107763e-01f, -6.03288747e-02f, -6.93427175e-02f, 8.78541544e-02f,
  -2.67323032e-02f, -4.75668609e-02f, 8.03838894e-02f, 6.94304481e-02f, -4.05787230e-02f, -1.76437706e-01f, -1.73614785e-01f, 3.48417014e-02f, -8.60278383e-02f, -6.30117282e-02f,
  -2.52622545e-01f, -1.28560206e-02f, -2.81601429e-01f, -8.23554695e-02f, 6.35603890e-02f, -1.11711122e-01f, -1.33047700e-01f, 6.52116537e-02f, 1.49694774e-02f, 4.18955199e-02f,
  5.46729192e-02f, -3.52973901e-02f, 1.45579740e-01f, 5.24761621e-03f, -7.92083293e-02f, -1.38372004e-01f, -6.45391196e-02f, -3.25565413e-02f, -1.15968503e-01f, 1.59574687e-01f,
  -1.34927675e-01f, -2.42096916e-01f, -3.01377594e-01f, -3.40254486e-01f, -1.52222723e-01f, -5.33847272e-01f, -1.44745439e-01f, -1.78728119e-01f, -2.60875851e-01f, -3.46291929e-01f,
  -3.52562517e-01f, -8.20581973e-01f, 4.98076677e-01f, -1.84883960e-02f, 3.20735544e-01f, 3.44512969e-01f, -8.03987235e-02f, -1.28469303e-01f, 1.79371592e-02f, -4.05440569e-01f,
  -6.16030991e-01f, -3.22668999e-01f, -4.07672852e-01f, -1.08817287e-01f, -1.16527183e-02f, -1.46806151e-01f, 3.29911500e-01f, 6.07360601e-01f, 6.09684110e-01f, 3.74458760e-01f,
  -5.90847954e-02f, 2.18630239e-01f, 2.18910500e-01f, 2.90779740e-01f, -1.95070148e-01f, 9.14107412e-02f, 2.39097122e-02f, -1.93538330e-02f, -2.03955099e-01f, -2.25809842e-01f,
  -2.49973536e-01f, -5.07884681e-01f, 3.22460890e-01f, -7.17991889e-02f, 1.78126860e-02f, -9.31077600e-02f, -1.71984974e-02f, -6.92177936e-03f, -1.83485448e-01f, -9.18002427e-02f,
  -9.19713154e-02f, -9.35825109e-02f, -1.17416151e-01f, -1.23080432e-01f, 1.49722621e-02f, -7.56678060e-02f, -6.88783675e-02f, -7.08118156e-02f, -6.88954024e-03f, -1.34454817e-01f,
  -3.36634517e-01f, 2.33354215e-02f, 6.38269261e-02f, 4.88595217e-02f, -9.63585265e-03f, 3.60311359e-01f, -1.07592538e-01f, -8.38405341e-02f, 8.69756937e-02f, -3.87370348e-01f,
  1.79495409e-01f, 5.12617417e-02f, -7.94942752e-02f, 3.51367407e-02f, 2.75931135e-02f, -4.22041193e-02f, 6.30362034e-02f, -1.32172555e-02f, -7.59762712e-04f, -6.50870726e-02f,
  5.27237775e-04f, -6.15759529e-02f, 9.93794650e-02f, -7.28025511e-02f, -5.94898760e-02f, -9.09476653e-02f, 2.76032463e-02f, -9.96977463e-02f, -4.38813046e-02f, 5.82383759e-02f,
  -5.77472970e-02f, -4.80923988e-02f, 1.29022365e-02f, -8.67253616e-02f, -4.49329056e-02f, -1.31266881e-02f, 5.96038811e-03f, -7.45699257e-02f, -1.69485778e-01f, -3.69379446e-02f,
  -2.64754117e-01f, 3.35945517e-01f, -1.53009757e-01f, -4.71371152e-02f, -1.75485741e-02f, 2.99129188e-02f, -4.48958129e-02f, 8.13599527e-02f, -1.41061470e-01f, -3.26582566e-02f,
  -3.71199511e-02f, -8.31969455e-02f, -5.20226322e-02f, 7.43119419e-02f, 1.89832166e-01f, 6.31187707e-02f, -1.05361030e-01f, 3.69421914e-02f, 5.49228266e-02f, 1.29189953e-01f,
  7.95759112e-02f, 1.22898214e-01f, 1.04504935e-01f, 1.15838591e-02f, -5.31875119e-02f, 3.44886839e-01f, 7.87454993e-02f, 1.26047269e-01f, 2.86441207e-01f, 3.17527354e-02f,
  5.74594915e-01f, -1.23176716e-01f, -4.02401716e-01f, 1.89670846e-01f, -1.04001932e-01f, -3.64136666e-01f, -5.02448559e-01f, -2.15972438e-01f, 1.82395160e-01f, -1.63291827e-01f,
  -1.60928369e-02f, 2.26084292e-01f, 5.76533787e-02f, -1.55635521e-01f, -3.62744451e-01f, -4.43547010e-01f, -3.79148990e-01f, -2.89165914e-01f, -3.11761975e-01f, -2.93595731e-01f,
  -4.63991091e-02f, 3.03109009e-02f, 3.49280350e-02f, -1.14981607e-01f, -1.17212981e-02f, 5.34516722e-02f, -1.63494021e-01f, -4.71623503e-02f, -2.29878575e-01f, -1.05811007e-01f,
  -3.41163456e-01f, -2.30675370e-01f, -3.20224285e-01f, 3.66529673e-02f, 8.43774676e-02f, 2.30650278e-03f, -1.32165447e-01f, 1.19482048e-01f, 8.41049328e-02f, -6.84761479e-02f,
  9.67006665e-03f, 1.11739859e-02f, 8.59376341e-02f, -5.80968335e-02f, -1.62075266e-01f, -9.09533501e-02f, 4.75004595e-03f, -1.17979594e-01f, -5.67457937e-02f, -1.37370706e-01f,
  2.22025942e-02f, -5.47053590e-02f, -1.10911191e-01f, -1.46737516e-01f, -1.94892466e-01f, 8.51422846e-02f, -1.70380637e-01f, -9.54214782e-02f, -1.19017109e-01f, 6.91289036e-03f,
  9.48494375e-02f, -7.50234816e-03f, -6.91917539e-02f, -4.41503264e-02f, 1.00942746e-01f, 1.06652394e-01f, 5.57815619e-02f, -1.47435024e-01f, -2.83397064e-02f, 2.23441925e-02f,
  -2.12829486e-02f, -7.00958818e-02f, 7.29890838e-02f, -6.35963380e-02f, -7.04983696e-02f, -6.65513873e-02f, -2.09168345e-02f, -1.67829156e-01f, -1.32625140e-02f, -2.69032270e-02f,
  9.36958101e-03f, -3.61142531e-02f, 1.52861759e-01f, -5.03380448e-02f, -1.42912924e-01f, -5.13157696e-02f, -3.26308459e-02f, -1.13675877e-01f, -6.95332065e-02f, -7.18959123e-02f,
  1.88158706e-01f, -1.64119959e-01f, 9.51140246e-04f, -1.59515679e-01f, -7.63494298e-02f, 1.45854009e-02f, 1.29884392e-01f, 2.84311417e-02f, 1.26492754e-01f, -1.74137335e-02f,
  -2.98269153e-01f, 4.26621512e-02f, 2.25753933e-02f, 5.07857837e-03f, -1.49469197e-01f, -6.57341182e-02f, -6.08841889e-04f, 3.06296814e-02f, -5.01604192e-02f, 1.91022038e-01f,
  -1.22098485e-02f, -2.20816672e-01f, 1.52034804e-01f, 6.74007088e-02f, 4.87206242e-04f, 6.54979721e-02f, -5.20975925e-02f, -1.20100759e-01f, -4.75197360e-02f, 4.38818932e-02f,
  4.86576080e-01f, -8.61245394e-02f, -4.89508420e-01f, -3.57647128e-02f, -4.26948309e-01f, -2.14128658e-01f, -1.54340997e-01f, 1.21522807e-01f, -3.85937057e-02f, -1.22519739e-01f,
  1.80604905e-01f, 7.03869045e-01f, 6.59470439e-01f, 4.14546072e-01f, 5.32359421e-01f, -2.82817721e-01f, -5.18536448e-01f, -1.20663613e-01f, 2.77380019e-01f, 1.07567981e-01f,
  -1.17679993e-02f, -1.23788454e-01f, 1.01579301e-01f, 3.73618901e-02f, -4.62712854e-01f, 1.05877761e-02f, -4.43631113e-01f, -5.06352425e-01f, -2.42176235e-01f, -7.35265255e-01f,
  1.59284547e-01f, -4.49264288e-01f, 5.69543540e-02f, 5.01288101e-02f, -1.39097109e-01f, 1.52345359e-01f, -1.65371686e-01f, -3.67353201e-01f, -5.32040931e-02f, -2.12362230e-01f,
  -1.10437535e-01f, 1.41109908e-02f, 8.39911848e-02f, 1.89556591e-02f, -1.98075518e-01f, -2.58263648e-02f, -2.56931663e-01f, -1.40482381e-01f, 2.60960520e-03f, -4.81250323e-02f,
  -1.25525773e-01f, -4.26398814e-01f, -2.23596707e-01f, -2.29362965e-01f, -1.93671167e-01f, -1.64890155e-01f, -4.52946544e-01f, -3.45088124e-01f, -8.90802890e-02f, -3.43176633e-01f,
  6.48399889e-02f, 3.03791352e-02f, -5.98969683e-02f, -1.23848021e-01f, 1.15330787e-02f, -4.10841331e-02f, 5.60700670e-02f, -6.20082989e-02f, -3.65020968e-02f, -4.69973087e-02f,
  1.44444168e-01f, 8.40006396e-03f, -2.53896303e-02f, -2.43547186e-02f, -9.39632207e-03f, -2.32381418e-01f, -5.30511653e-03f, 1.54638365e-01f, -6.87561706e-02f, 6.54610023e-02f,
  -2.10801661e-02f, -1.46334752e-01f, -6.24700077e-02f, 6.24473654e-02f, -1.47766456e-01f, -6.78714812e-02f, -7.34209046e-02f, 7.03523979e-02f, -3.01465280e-02f, -1.56686455e-01f,
  7.31923461e-01f, 1.99972779e-01f, 2.48273924e-01f, 1.97931379e-01f, -1.82990476e-01f, -6.09145351e-02f, -6.18826970e-03f, -8.93113762e-02f, -1.46808773e-01f, 3.11787575e-01f,
  3.98346372e-02f, 2.29230896e-01f, 1.22876644e-01f, -1.10536560e-01f, -7.72502571e-02f, -6.25732094e-02f, 1.13190554e-01f, -5.05298711e-02f, -7.06142113e-02f, -1.69838101e-01f,
  -5.70144057e-02f, 4.61585261e-02f, 3.29381257e-01f, 1.41996205e-01f, -1.01312779e-01f, 2.40293562e-01f, -4.43740934e-02f, 1.01140179e-01f, 4.47652221e-01f, 2.04579726e-01f,
  -3.65154147e-01f, -4.08749543e-02f, 2.81188607e-01f, -2.55726099e-01f, 1.68676481e-01f, -1.35836108e-02f, -3.66440594e-01f, -2.15919554e-01f, 4.54039983e-02f, -6.24701791e-02f,
  2.46401593e-01f, 1.82228640e-01f, -1.09098554e-02f, -9.79435593e-02f, -3.90995800e-01f, -3.63558412e-01f, -3.11677873e-01f, -2.28511065e-01f, -1.93989262e-01f, -1.14570104e-01f,
  1.60769429e-02f, -7.90195391e-02f, -1.89210385e-01f, -1.41630903e-01f, -7.84052759e-02f, -4.17499244e-02f, -1.15964292e-02f, -7.06312358e-02f, -5.52296005e-02f, -1.18444674e-01f,
  1.17317801e-02f, 6.41109943e-02f, 1.87245011e-01f, 1.58958197e-01f, 2.36933812e-01f, -1.36260673e-01f, -6.98048547e-02f, 1.62028288e-03f, -5.35372943e-02f, -3.31634395e-02f,
  1.50028244e-01f, 7.87986889e-02f, -9.51820686e-02f, 2.34729871e-02f, -8.48386660e-02f, -9.00486037e-02f, -2.51737963e-02f, -9.33092311e-02f, -1.45665511e-01f, 1.17850443e-02f,
  1.94550958e-02f, -2.30107289e-02f, -2.00191781e-01f, -1.29674673e-01f, -1.50726125e-01f, -5.69916070e-02f, -2.54178531e-02f, -9.31492969e-02f, -1.73319235e-01f, -2.87131220e-01f,
  -1.13743924e-01f, 2.08018851e-02f, 4.96040694e-02f, -2.97771068e-03f, -1.08390354e-01f, 4.25449610e-02f, -9.90368798e-02f, -8.04248154e-02f, 4.38907072e-02f, -6.72299564e-02f,
  5.90759963e-02f, -2.65031662e-02f, -1.60891823e-02f, -1.92414165e-01f, -7.12926909e-02f, -5.41924797e-02f, -1.56877283e-02f, -1.68447807e-01f, -1.50014743e-01f, -3.78252454e-02f,
  1.11013073e-02f, 6.00190321e-03f, 1.32656232e-01f, -7.48601854e-02f, 3.16118449e-02f, -2.35442277e-02f, 8.05259869e-02f, 1.37921453e-01f, 8.37081000e-02f, 8.48673657e-02f,
  -5.81972562e-02f, 2.06769317e-01f, -1.54468328e-01f, -3.11949234e-02f, -6.15552999e-02f, 1.72562420e-01f, 4.47879313e-03f, 1.29830211e-01f, 1.20125391e-01f, -1.14710480e-02f,
  5.22748977e-02f, -2.00779036e-01f, -6.21093847e-02f, 7.52828196e-02f, -7.11244196e-02f, -2.97714174e-02f, -2.35161230e-01f, -2.46761460e-02f, -7.44362473e-02f, 5.61717413e-02f,
  -1.55545816e-01f, -3.89144123e-01f, -4.94070917e-01f, -3.42789322e-01f, -2.49659985e-01f, -3.40811849e-01f, -2.43782833e-01f, -1.32864565e-01f, -3.32586914e-01f, -6.20786607e-01f,
  -1.79664686e-01f, 2.87763894e-01f, 4.46250796e-01f, -2.00123206e-01f, -1.78951949e-01f, -1.68797418e-01f, -1.41381606e-01f, -4.43012789e-02f, 1.33804688e-02f, 1.91708192e-01f,
  -1.87351238e-02f, -3.69451046e-01f, 7.50628635e-02f, -1.20651886e-01f, -1.61569655e-01f, 3.37046713e-01f, 3.15757424e-01f, -8.75663757e-02f, -4.79687274e-01f, -6.16234422e-01f,
  -3.72366786e-01f, -3.53334635e-01f, -2.05024213e-01f, -1.82674620e-02f, 2.46365964e-01f, -2.04626247e-02f, 3.93239617e-01f, 4.93511148e-02f, 2.25326478e-01f, 3.55027437e-01f,
  2.88799942e-01f, 3.35970074e-01f, -2.92132705e-01f, -3.67583632e-01f, -7.37824738e-02f, 5.17017357e-02f, 5.02016060e-02f, 1.07400782e-01f, 2.03760471e-02f, 1.72200873e-01f,
  -1.16585255e-01f, -3.43503430e-02f, -8.71644691e-02f, -5.77737987e-02f, -1.49353087e-01f, -1.67606786e-01f, 2.96112685e-03f, -1.21324081e-02f, -2.96897385e-02f, -4.37900610e-02f,
  -3.99575889e-01f, -2.81000912e-01f, 8.15116167e-02f, -3.08243837e-02f, 1.34135440e-01f, -1.98466539e-01f, 1.05592281e-01f, 2.64743660e-02f, 1.72945380e-01f, 2.37715468e-01f,
  1.84483118e-02f, 5.82116358e-02f, 7.23173982e-03f, 1.37544513e-01f, -1.56224549e-01f, 1.11609213e-02f, 4.95701060e-02f, -1.26279876e-01f, 6.01846306e-03f, -2.64735967e-02f,
  3.18611637e-02f, 7.43703172e-02f, -6.44776784e-03f, 1.43673062e-01f, 8.04145411e-02f, -4.20415364e-02f, -3.10965534e-02f, 8.87906775e-02f, 1.30110368e-01f, 6.81978911e-02f,
  -1.01684019e-01f, -1.11091614e-01f, -7.02088475e-02f, -2.34341621e-02f, 2.09861144e-01f, 6.62961826e-02f, 1.49315633e-02f, -5.32838255e-02f, -6.15495779e-02f, 9.85058174e-02f,
  -3.48981857e-01f, -1.97052702e-01f, 2.97099762e-02f, -1.41728163e-01f, 5.93617745e-03f, 2.07247380e-02f, 8.54638815e-02f, 9.62295011e-03f, -3.99229862e-03f, -1.10891968e-01f,
  -3.82715575e-02f, 6.49635866e-03f, 2.10861310e-01f, -8.85221437e-02f, -2.49785930e-01f, -4.84101884e-02f, -1.97784677e-01f, -3.42690945e-01f, -1.79982379e-01f, -1.64601579e-01f,
  -1.56035751e-01f, -3.26219112e-01f, -2.94196069e-01f, -1.50139496e-01f, -1.74571440e-01f, -4.63294625e-01f, -1.83940202e-01f, -1.84677258e-01f, -1.04478769e-01f, -1.82069570e-01f,
  3.41849625e-01f, 2.53189534e-01f, 3.41065079e-02f, 2.94858098e-01f, 2.79841840e-01f, 1.45775035e-01f, 3.73838007e-01f, 1.51207848e-02f, -2.73764059e-02f, 1.64235950e-01f,
  5.20876758e-02f, -2.93907672e-01f, -2.01685861e-01f, -4.16686326e-01f, -3.74989241e-01f, -1.11163884e-01f, -1.65495098e-01f, -3.50726396e-01f, -3.07310849e-01f, -6.46556318e-02f,
  7.05359783e-03f, 1.43429965e-01f, 4.34656404e-02f, -9.45616886e-02f, -6.54435009e-02f, -7.90970325e-02f, 1.26492366e-01f, 2.84607112e-01f, -9.18711498e-02f, -1.19609006e-01f,
  -1.88528717e-01f, 2.23356679e-01f, -2.26737261e-01f, -5.31953052e-02f, 1.04088396e-01f, -5.45279570e-02f, 3.65888774e-02f, 1.48606658e-01f, 1.38722971e-01f, 1.15730807e-01f,
  1.01461858e-01f, -1.79766188e-03f, 1.12938665e-01f, 9.81987864e-02f, 4.03970964e-02f, 3.92241701e-02f, -1.65051937e-01f, -1.43598244e-01f, -1.26914352e-01f, -8.12208280e-02f,
  2.35234965e-02f, 1.33080751e-01f, 1.36836246e-01f, -4.87626679e-02f, -1.07707813e-01f, 2.85441373e-02f, -3.35304439e-02f, -7.38534555e-02f, -1.36139780e-01f, -1.12589963e-01f,
  1.71443164e-01f, 4.85277884e-02f, 5.31992652e-02f, 4.33970205e-02f, -5.42844348e-02f, 3.28965150e-02f, 1.42343760e-01f, 1.39375150e-01f, 5.27585298e-02f, 6.40346929e-02f,
  2.20082738e-02f, 6.32999614e-02f, 1.38673753e-01f, 1.47755846e-01f, 6.32929653e-02f, 7.54734874e-02f, 1.20572142e-01f, 1.39096111e-01f, 5.17989807e-02f, 1.81434199e-01f,
  1.99079216e-02f, -1.20037012e-02f, 1.13397181e-01f, 4.47110422e-02f, 6.19377196e-02f, 1.52232107e-02f, 1.28248006e-01f, 2.15749964e-01f, 6.43320754e-02f, 1.30038843e-01f,
  2.61796534e-01f, 1.41726151e-01f, -5.09685986e-02f, -1.90834850e-01f, 1.42706454e-01f, -7.07765715e-03f, 1.12537712e-01f, 4.10827585e-02f, 1.44009620e-01f, -1.39248855e-02f,
  9.16194320e-02f, 2.77131367e-02f, 1.46630824e-01f, -1.50397164e-03f, -5.89703955e-03f, -4.64844459e-04f, 7.85278231e-02f, -8.13267604e-02f, -1.40534014e-01f, -3.60278562e-02f,
  -3.53623442e-02f, 9.17605236e-02f, 5.73024340e-02f, 8.77425540e-03f, -6.31999969e-02f, 3.11619276e-03f, 1.34006411e-01f, -2.68890522e-02f, -7.24170208e-02f, 1.07075751e-01f,
  -3.28480422e-01f, -3.03414203e-02f, 4.68790494e-02f, -2.18091294e-01f, 5.61514646e-02f, 3.29472482e-01f, 4.66977328e-01f, 1.05881870e-01f, -2.28625104e-01f, 7.08233789e-02f,
  -4.35483530e-02f, -4.73973364e-01f, -3.88718814e-01f, -3.33517224e-01f, -2.31602103e-01f, 2.01445967e-01f, 1.10801943e-01f, -2.28042156e-01f, -9.07332748e-02f, -3.02142464e-02f,
  -8.07672888e-02f, -1.57967806e-01f, -2.51314670e-01f, -1.39379621e-01f, -6.33637086e-02f, -2.84009844e-01f, 6.17709849e-03f, -1.60935014e-01f, -1.01392530e-01f, -2.24563450e-01f,
  2.67232120e-01f, -1.52535930e-01f, 3.39060053e-02f, -1.55610681e-01f, -1.25153819e-02f, -1.70460328e-01f, -1.28033161e-01f, -1.59551397e-01f, -1.16282918e-01f, 2.91222166e-02f,
  -3.34662460e-02f, 7.52573891e-04f, -5.01838326e-02f, -5.28124347e-02f, 1.05135344e-01f, 4.23454791e-02f, -7.62877837e-02f, -1.67171225e-01f, -9.06094834e-02f, 1.23654769e-04f,
  -7.80851617e-02f, -8.23620632e-02f, 6.05327412e-02f, 1.59552433e-02f, -1.73166886e-01f, -1.67871088e-01f, 8.13159999e-03f, 2.36479868e-03f, -5.26490659e-02f, 1.17130436e-01f,
  1.53834224e-01f, 8.84690508e-02f, -5.24329990e-02f, -1.10970102e-02f, -2.73769088e-02f, 3.59209478e-02f, 8.81233886e-02f, 3.70338224e-02f, 3.77619080e-02f, 5.29379733e-02f,
  -6.93891384e-03f, -1.38454497e-01f, 2.29636542e-02f, -2.49993261e-02f, -1.63495764e-01f, -1.91918351e-02f, -1.99056454e-02f, -1.15562556e-02f, -7.88924843e-02f, -9.57707874e-03f,
  -3.48123014e-02f, 1.14122488e-01f, 6.59075454e-02f, 1.88338831e-02f, -5.33308201e-02f, -1.22084677e-01f, -7.29832053e-02f, -8.99612680e-02f, 1.96944326e-02f, -2.17218399e-02f,
  -1.86128188e-02f, -2.46072948e-01f, 6.93180785e-02f, -2.37646431e-01f, -1.37436166e-02f, -1.78711012e-01f, -2.11619198e-01f, -1.53558433e-01f, -3.77510116e-02f, -8.77661705e-02f,
  -7.52201155e-02f, -5.02785370e-02f, 3.29451524e-02f, 6.85497001e-02f, 1.65860981e-01f, -5.49062192e-02f, -7.16460273e-02f, -7.85731226e-02f, -5.17129377e-02f, 3.47958691e-02f,
  3.80967334e-02f, 1.40906602e-01f, 2.16888592e-01f, 5.40253967e-02f, -7.66254812e-02f, -3.60842459e-02f, 2.76112467e-01f, 1.23827420e-01f, 1.53817711e-02f, 3.76193762e-01f,
  3.72920901e-01f, -8.47837552e-02f, -6.15321137e-02f, 1.78670242e-01f, -1.71220079e-01f, -3.44409049e-01f, -4.60416287e-01f, -3.31493840e-02f, 1.95624143e-01f, -6.03538342e-02f,
  -8.25046077e-02f, 5.00516258e-02f, 5.26918881e-02f, -3.14918235e-02f, -2.37396523e-01f, -4.50461507e-01f, -2.93729752e-01f, 3.30216847e-02f, 1.11823874e-02f, -7.86402598e-02f,
  -7.73653015e-02f, -3.63352336e-02f, 1.90304548e-01f, 9.95808244e-02f, 4.23687212e-02f, -6.33644918e-03f, -1.05447888e-01f, -3.73760499e-02f, -3.49354744e-01f, -2.42880732e-01f,
  -3.41968276e-02f, 1.27032340e-01f, 1.15002558e-01f, 2.13191301e-01f, 2.97532678e-01f, 1.93554342e-01f, 7.66438395e-02f, 2.62465835e-01f, 8.29257071e-02f, 1.33453771e-01f,
  6.08906895e-02f, 1.81368738e-01f, 1.46435976e-01f, 1.20131016e-01f, 1.73015475e-01f, 2.23074481e-01f, 1.38754502e-01f, 5.85125526e-04f, -5.07434681e-02f, 1.20182946e-01f,
  1.04470700e-01f, -3.11354105e-03f, 5.11664897e-03f, -7.13302493e-02f, 4.62910756e-02f, 6.11133762e-02f, 8.38190615e-02f, 1.51802987e-01f, 7.00254750e-04f, 2.71029007e-02f,
  -2.43539107e-03f, -3.97498719e-02f, 1.20178685e-01f, 1.10281885e-01f, -4.35038768e-02f, 1.36127872e-02f, -5.33443689e-02f, -1.81581303e-01f, -1.39921129e-01f, 6.25141189e-02f,
  -4.73124720e-02f, -1.30689621e-01f, -1.02758810e-01f, 6.86748326e-02f, 1.72554404e-01f, -2.63316669e-02f, -3.58479135e-02f, 8.43097121e-02f, -2.05272436e-02f, -4.16454673e-02f,
  -6.71266019e-02f, -1.03077088e-02f, 1.55452222e-01f, 1.95275340e-02f, 3.49553674e-02f, 1.81303442e-01f, 1.03468865e-01f, 1.08761340e-01f, -4.48989421e-02f, -1.41559869e-01f,
  1.46680176e-01f, -7.48334676e-02f, -1.46949172e-01f, -1.20400190e-01f, -9.50364023e-02f, 2.28930831e-01f, -1.47139281e-02f, 1.04745969e-01f, 1.94502056e-01f, 8.42993706e-02f,
  7.81899318e-02f, 1.06687985e-01f, 1.47229433e-01f, -5.17173931e-02f, -4.16294336e-02f, 1.23478591e-01f, 4.36268235e-03f, -8.10945779e-02f, -6.63637184e-03f, 1.28685281e-01f,
  9.28055495e-02f, -3.30726919e-03f, -1.37454435e-01f, -9.93608534e-02f, -7.46060535e-02f, -1.11369468e-01f, -7.59134144e-02f, 9.03480425e-02f, -1.08659402e-01f, -5.86074889e-02f,
  -8.10020685e-01f, 3.98663640e-01f, 4.68454123e-01f, -2.81840414e-01f, 2.47001991e-01f, 2.33986840e-01f, 1.41158789e-01f, -1.64024055e-01f, -2.34238237e-01f, 1.48246050e-01f,
  9.59407762e-02f, -2.27918044e-01f, 8.84111524e-02f, -2.08772700e-02f, -9.10411552e-02f, 3.49090487e-01f, 4.13502008e-01f, -1.04470879e-01f, -5.22778034e-01f, -4.14342880e-01f,
  -8.76264870e-02f, -2.10102960e-01f, -4.65370744e-01f, -1.99773043e-01f, 1.55531928e-01f, 6.50291005e-03f, 3.67080629e-01f, 9.35136303e-02f, 3.14466059e-01f, 3.20773005e-01f,
  -1.01394147e-01f, -5.36874980e-02f, -1.31878838e-01f, -8.84459615e-02f, 2.05049247e-01f, -2.67209917e-01f, -9.46749523e-02f, -5.38400002e-02f, -7.78702423e-02f, -3.12315859e-02f,
  1.27415821e-01f, 5.93979321e-02f, 9.36246291e-02f, -1.09968767e-01f, -2.21305043e-01f, -2.51536876e-01f, -2.06706569e-01f, -3.27572852e-01f, -1.54525772e-01f, -1.34725973e-01f,
  9.88329202e-02f, -1.21121958e-01f, 1.63293220e-02f, 1.07980578e-03f, 4.14662361e-02f, -1.67333066e-01f, -1.39257424e-02f, -1.86600745e-01f, -1.55127347e-01f, -3.16929907e-01f,
  1.20331785e-02f, 6.46941289e-02f, 7.10703284e-02f, 1.41972182e-02f, -1.67452842e-01f, 1.20626584e-01f, 1.43855169e-01f, 2.30815150e-02f, 7.92104080e-02f, -1.12899669e-01f,
  1.46174189e-02f, -1.15945056e-01f, 2.79504899e-02f, 5.33284508e-02f, -1.82746560e-03f, -6.71302900e-02f, -8.46903175e-02f, -3.19953784e-02f, 1.66644081e-01f, 1.47283804e-02f,
  -1.36519074e-01f, 9.25194323e-02f, 4.10690196e-02f, -1.36546090e-01f, 1.43695906e-01f, 1.31044373e-01f, -3.01728994e-02f, 1.42952744e-02f, -5.23373932e-02f, 4.80639897e-02f,
  -2.12875426e-01f, 1.90574348e-01f, -1.79878756e-01f, -4.46937233e-02f, 3.17865051e-02f, 2.27848645e-02f, 1.83667950e-02f, -4.62881662e-02f, -2.35524811e-02f, -2.06380516e-01f,
  4.19681855e-02f, -4.25771661e-02f, 1.52644232e-01f, -9.75720957e-02f, -2.81807750e-01f, -3.98407914e-02f, 2.79210731e-02f, -1.01340495e-01f, 4.25954256e-03f, -3.55009772e-02f,
  1.09042607e-01f, -3.13816547e-01f, -3.93313855e-01f, -1.91609725e-01f, -1.46399274e-01f, -4.01624858e-01f, -1.46910653e-01f, -3.28933775e-01f, -2.85845041e-01f, -4.60640162e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  1.53511658e-01f, 4.54707682e-01f, 3.41214627e-01f, 3.39546472e-01f, 4.49592918e-01f, 4.34932679e-01f, 6.80398107e-01f, 3.47264707e-01f, 3.21675867e-01f, 7.80430064e-02f,
  3.31501186e-01f, 6.27951622e-01f, 4.14157152e-01f, 5.45054197e-01f, 5.21838367e-01f, 3.68001580e-01f, 5.18512547e-01f, 6.72374368e-01f, 2.34292582e-01f, 1.76035553e-01f,
  3.89241308e-01f, 4.41655755e-01f, 5.65128088e-01f, 4.62178648e-01f, 3.45151424e-01f, 2.11101919e-01f, 3.90710920e-01f, 4.74550217e-01f, 3.76439571e-01f, 5.26080608e-01f,
  1.69625133e-01f, 8.04334953e-02f, 3.07810545e-01f, 5.19317150e-01f, 7.53792673e-02f, 3.20878923e-01f, 3.63111466e-01f, 2.07288980e-01f, 2.19522595e-01f, 4.26794976e-01f,
  5.84353626e-01f, 1.79458335e-01f, 5.08618772e-01f, 7.22274661e-01f, 3.50024879e-01f, 6.63102388e-01f, 2.39636272e-01f, 3.96831185e-01f, 5.11549056e-01f, 6.19271755e-01f,
  3.27956945e-01f, 4.28671211e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  1.58111844e-02f, -1.32265559e-03f, 3.35954428e-02f, -7.32156634e-02f, -6.87357932e-02f, -9.09385234e-02f, -2.25993004e-02f, -6.16713241e-02f, -1.62157208e-01f, -4.19724621e-02f,
  1.92960370e-02f, -1.23699546e-01f, -5.59265539e-03f, -2.13085674e-02f, -2.51413643e-01f, -6.17720447e-02f, -1.42390817e-01f, 4.20382507e-02f, -2.87737697e-01f, -1.87294930e-02f,
  -1.09108754e-01f, -1.17991053e-01f, -1.84134655e-02f, 1.32560894e-01f, -6.48349226e-02f, -1.37646198e-01f, 8.67612213e-02f, -1.71054080e-01f, -6.37296140e-02f, 9.80629772e-02f,
  -1.20736107e-01f, -1.68460220e-01f, -1.94865659e-01f, -1.20650984e-01f, -2.94943243e-01f, 6.01324290e-02f, 1.35129914e-02f, -5.24923764e-02f, -5.99349476e-02f, -8.73607397e-03f,
  3.41525018e-01f, 2.56936178e-02f, -1.25377085e-02f, 6.23043776e-02f, -1.13438051e-02f, 1.20250233e-01f, 9.47157890e-02f, 1.03570949e-02f, -2.35200915e-02f, -3.20252217e-02f,
  -1.28422737e-01f, 1.43285813e-02f, 1.19770423e-01f, -1.15266532e-01f, -1.51165694e-01f, 1.31141156e-01f, -2.25381151e-01f, -5.96116073e-02f, -6.02827668e-02f, -1.77512392e-01f,
  2.50545591e-01f, 1.57660797e-01f, -1.69637844e-01f, -3.20959032e-01f, -6.49429113e-02f, 2.97293835e-03f, 7.19979852e-02f, 4.53335531e-02f, 3.95411879e-01f, 2.94380989e-02f,
  -2.37404630e-02f, -5.73976748e-02f, -6.67381808e-02f, 1.84178814e-01f, 4.60514762e-02f, -4.83264066e-02f, 4.57194358e-01f, 2.76018679e-01f, -2.66534954e-01f, 3.08336347e-01f,
  9.50703621e-02f, -8.27994719e-02f, -1.22998409e-01f, -2.49247663e-02f, 5.28353393e-01f, 2.52741963e-01f, -4.64679629e-01f, -3.49722207e-01f, -2.76203007e-02f, -6.27703011e-01f,
  -2.48246685e-01f, -1.86651990e-01f, -3.47726405e-01f, -4.30070251e-01f, 7.33358562e-02f, 3.56991100e-03f, -3.81142020e-01f, 1.66633606e-01f, -3.01649928e-01f, 2.09408514e-02f,
  5.55476606e-01f, 4.24216501e-02f, 2.57779509e-02f, -1.99450809e-03f, -3.65230173e-01f, 3.08538944e-01f, 1.04889259e-01f, -2.08057817e-02f, -1.37534410e-01f, -5.32623194e-02f,
  3.67710084e-01f, 2.18104169e-01f, -6.25952601e-01f, 6.64795399e-01f, 3.56367677e-01f, 1.46575972e-01f, 4.44178320e-02f, -2.95384973e-01f, 4.58168909e-02f, 1.08996242e-01f,
  8.05968121e-02f, 2.66036279e-02f, 1.72818065e-01f, -8.34708273e-01f, -3.35287809e-01f, -2.72332072e-01f, 2.47897640e-01f, -8.28990519e-01f, 6.24928810e-02f, -1.06589817e-01f,
  1.67577222e-01f, 9.11316723e-02f, 9.76981223e-02f, 1.31638214e-01f, 5.36626801e-02f, -9.15607363e-02f, -1.72304250e-02f, -1.31493121e-01f, -2.01733291e-01f, -3.44988219e-02f,
  -3.78773287e-02f, -5.03384955e-02f, -5.76623017e-03f, 1.44523308e-02f, -1.24778040e-01f, 2.46305745e-02f, 1.57334924e-01f, 1.28595307e-01f, 1.09479100e-01f, 5.51986415e-03f,
  -1.18652331e-02f, -1.09829724e-01f, 8.17577466e-02f, -5.13354093e-02f, 5.83914705e-02f, -2.08145902e-01f, -1.21014146e-02f, -1.69066880e-02f, 2.67782688e-01f, -8.75682980e-02f,
  9.00539830e-02f, -8.96511320e-03f, -4.46989909e-02f, -8.88212323e-02f, -6.54364564e-03f, 2.16736998e-02f, 7.27137029e-02f, 1.63242698e-01f, 1.39434502e-01f, -1.32838398e-01f,
  5.38022853e-02f, -1.94757029e-01f, -5.33348843e-02f, -1.29124373e-01f, 2.03171656e-01f, 1.26566663e-01f, 6.12445809e-02f, 2.99633265e-01f, 8.99331346e-02f, 1.82812363e-01f,
  1.13960437e-01f, 1.94125757e-01f, -9.55010280e-02f, -1.25848547e-01f, 9.00068693e-03f, -1.85796261e-01f, -1.11228108e-01f, 9.75058600e-02f, 1.87348679e-01f, -1.09254345e-01f,
  4.25402001e-02f, -3.06440085e-01f, -1.36029109e-01f, 7.99505338e-02f, -1.97535738e-01f, 3.63938957e-01f, 1.80874661e-01f, 8.10146183e-02f, -1.71389446e-01f, 1.47165477e-01f,
  1.43652037e-01f, 4.39230949e-02f, 1.26494005e-01f, 1.45232216e-01f, -4.80298102e-01f, -7.26528585e-01f, -6.41469359e-02f, 8.62293065e-01f, 4.82842326e-02f, 2.01907277e-01f,
  4.12081301e-01f, -1.75545529e-01f, -1.95753500e-01f, 2.05865070e-01f, 7.50876218e-02f, -1.20293796e+00f, 4.43243712e-01f, -2.56885052e-01f, -3.57680321e-01f, 1.77620739e-01f,
  6.18015118e-02f, -4.43972908e-02f, -5.55682788e-03f, 5.08256294e-02f, -2.88582832e-01f, -6.83408320e-01f, -3.33473682e-01f, -6.43852353e-01f, -1.46072224e-01f, 8.45381916e-02f,
  -5.14088631e-01f, 3.34475636e-01f, 1.00923941e-01f, -8.81663084e-01f, 1.58686712e-01f, 3.94024134e-01f, -1.06426761e-01f, -2.83992290e-01f, 4.27012920e-01f, -3.93856406e-01f,
  -1.43070951e-01f, 9.70140025e-02f, 1.88720405e-01f, -6.22178391e-02f, 3.05983424e-01f, -2.59277280e-02f, -5.97809911e-01f, -1.73812330e-01f, 4.14051831e-01f, 8.44596207e-01f,
  -5.28123617e-01f, -4.78624851e-01f, -1.63483799e-01f, -5.35339057e-01f, 5.49707981e-03f, -6.05948210e-01f, -7.35043548e-03f, 1.17330387e-01f, -1.76240224e-02f, -3.15165557e-02f,
  1.33582398e-01f, -1.21064186e-02f, 6.17753640e-02f, 1.57990098e-01f, 9.60643068e-02f, 2.18315292e-02f, 1.89663932e-01f, 2.09100973e-02f, -8.45429115e-03f, 3.41826044e-02f,
  1.18063904e-01f, 5.64549267e-02f, -5.17171435e-02f, 1.38424663e-03f, 1.06409803e-01f, -7.26915672e-02f, 1.05108730e-01f, 7.46231601e-02f, 7.96585456e-02f, -7.62822479e-02f,
  1.37964850e-02f, 1.17805876e-01f, 1.21622324e-01f, 1.49081066e-01f, 1.30492777e-01f, 6.39353618e-02f, 1.96219720e-02f, 8.16438943e-02f, 8.92826095e-02f, 1.80173088e-02f,
  1.30780384e-01f, 2.05234692e-01f, 4.33182307e-02f, 4.47606221e-02f, -1.32115588e-01f, -1.82515979e-01f, 2.39060014e-01f, 1.28467828e-01f, -2.48463333e-01f, 1.74027100e-01f,
  7.31049553e-02f, -1.39462635e-01f, 6.83866963e-02f, 5.77798598e-02f, -1.09663732e-01f, -5.42791001e-02f, 2.89675951e-01f, 2.83265352e-01f, 1.50941133e-01f, -1.49306729e-01f,
  7.75023252e-02f, -1.64796785e-01f, -9.44248289e-02f, -2.54141629e-01f, -1.95506901e-01f, -9.10311937e-02f, 1.04123406e-01f, -2.60433614e-01f, 3.27488184e-01f, -2.07145289e-01f,
  4.77779470e-02f, 1.64633542e-01f, 3.16846892e-02f, 2.80061841e-01f, 1.39594212e-01f, 2.28263810e-01f, -2.43724436e-01f, 1.09966874e-01f, 2.06824169e-01f, -6.27234653e-02f,
  -1.07644185e-01f, -2.08818480e-01f, -3.57566655e-01f, 6.16977513e-01f, -5.34542382e-01f, 7.29660928e-01f, 8.01163137e-01f, -9.66529027e-02f, -1.63946867e-01f, -2.96768665e-01f,
  -4.52051386e-02f, -2.74222970e-01f, -3.70587222e-02f, -3.19208711e-01f, -6.13299683e-02f, -1.38143688e-01f, -4.01724875e-01f, 6.31237477e-02f, -4.76924866e-01f, 2.33464226e-01f,
  -5.01935601e-01f, -6.40537292e-02f, 1.57776251e-01f, -3.38745058e-01f, -4.07310009e-01f, -3.39341700e-01f, 3.16252649e-01f, -4.95359078e-02f, -1.51807800e-01f, -1.52037010e-01f,
  -2.95861483e-01f, -1.99798539e-01f, -2.53856659e-01f, -7.50064030e-02f, -3.48272622e-01f, 7.40626693e-01f, -3.81850779e-01f, -1.79839313e-01f, -2.02858523e-01f, -4.78867710e-01f,
  -1.29037485e-01f, 2.67660362e-03f, 1.13056913e-01f, -4.38194007e-01f, -2.88517147e-01f, 6.47434413e-01f, -5.82312681e-02f, -2.00005367e-01f, 2.58851320e-01f, -6.56921938e-02f,
  -2.58653432e-01f, -2.76995152e-01f, 3.24966133e-01f, 1.16992034e-01f, -9.13197696e-02f, -3.03527582e-02f, 6.09729961e-02f, 1.00639440e-01f, -9.10357758e-02f, -9.08689722e-02f,
  -2.50230711e-02f, -5.08195609e-02f, -7.26187527e-02f, 5.31348847e-02f, -8.47376809e-02f, 7.69520458e-03f, 1.07794896e-01f, -3.72271389e-02f, -4.75867718e-01f, 3.17279279e-04f,
  7.29198530e-02f, -4.02068533e-02f, 1.28415283e-02f, -1.03342742e-01f, -2.00235397e-01f, -1.36462495e-01f, -3.46547402e-02f, -1.53196111e-01f, -6.32943511e-02f, -1.02795502e-02f,
  -6.57442957e-02f, -7.16652051e-02f, -5.48526756e-02f, -9.41190571e-02f, 1.14872083e-01f, -4.25227452e-03f, 6.61165267e-02f, 4.53720652e-02f, -2.11712509e-01f, -1.02930874e-01f,
  6.71569929e-02f, 1.35475746e-03f, -1.63373306e-01f, -8.97040144e-02f, -1.81995407e-01f, -1.65684119e-01f, 1.42789483e-01f, 2.64305085e-01f, -1.24991452e-02f, -1.88245535e-01f,
  6.18653595e-02f, -7.81944245e-02f, 8.85671452e-02f, -1.29839137e-01f, 9.27059129e-02f, -2.61871129e-01f, 1.20293826e-01f, 1.35667756e-01f, -8.96427333e-02f, 9.33132842e-02f,
  1.37145475e-01f, -8.04429799e-02f, -1.60215005e-01f, -2.93686166e-02f, -5.82557321e-02f, -9.50229838e-02f, 4.33950722e-02f, 3.67498666e-01f, 2.16434807e-01f, 1.09214960e-02f,
  -5.22947237e-02f, -4.39262614e-02f, 2.47818008e-01f, -1.49469841e-02f, 4.71693650e-02f, 1.22935437e-02f, -2.43033886e-01f, 6.53151982e-03f, 4.95517103e-04f, -4.57487106e-02f,
  3.28824461e-01f, -4.30874646e-01f, -7.43484080e-01f, -2.36989006e-01f, -1.36004880e-01f, 4.42786813e-02f, -1.94532737e-01f, 4.21813816e-01f, -8.70498180e-01f, 4.09010679e-01f,
  -9.31624547e-02f, 2.11854987e-02f, 9.36282277e-02f, -5.42939484e-01f, 2.67160177e-01f, -1.99439645e-01f, -2.72615701e-01f, 1.77862197e-01f, -2.15634435e-01f, -3.13727140e-01f,
  3.45870137e-01f, 2.67251194e-01f, -2.42044970e-01f, 5.25507212e-01f, 1.98502451e-01f, -2.11667404e-01f, 2.75272846e-01f, -1.84574202e-01f, -4.39569116e-01f, -4.86688197e-01f,
  -1.05151072e-01f, 2.96613216e-01f, -3.76274973e-01f, -1.65609449e-01f, -2.38193139e-01f, 6.35165274e-01f, -1.25613302e-01f, -8.42983127e-01f, 5.75411320e-01f, 5.17471969e-01f,
  -4.57946092e-01f, -3.13304007e-01f, -2.26244166e-01f, 1.33447811e-01f, -4.96216416e-01f, -2.97644913e-01f, 1.74574375e-01f, 3.61382812e-01f, -4.38342452e-01f, 2.91617692e-01f,
  -7.50681937e-01f, 4.91598517e-01f, -1.11789033e-01f, 5.34258150e-02f, -1.91108346e-01f, -1.62400007e-02f, 1.42395139e-01f, 1.65431738e-01f, -7.22752735e-02f, -7.27599263e-02f,
  -6.24841265e-02f, 1.09607332e-04f, -1.84937462e-01f, -7.70035535e-02f, -4.53378074e-02f, -2.69668549e-03f, 2.87371039e-01f, 8.32298473e-02f, 9.97817442e-02f, 1.20555654e-01f,
  -2.30658185e-02f, -1.17741846e-01f, -4.41090725e-02f, -9.05220732e-02f, -1.14447348e-01f, 1.56036988e-01f, 1.38700083e-02f, 9.23236012e-02f, 7.80145004e-02f, -2.12281138e-01f,
  5.60155027e-02f, -1.22368805e-01f, 1.29365057e-01f, -8.31442252e-02f, -2.41955351e-02f, 5.24285026e-02f, 3.51460241e-02f, -2.57780045e-01f, -1.60255611e-01f, -1.62678972e-01f,
  -1.40640900e-01f, 1.09221458e-01f, -1.73696563e-01f, 5.78244962e-03f, -2.66760796e-01f, -1.58198047e-02f, -2.21892193e-01f, 2.86354899e-01f, 1.07746236e-01f, 5.50648570e-02f,
  4.02921491e-04f, -2.61779539e-02f, 1.49936080e-01f, -5.51133603e-02f, 2.62489736e-01f, -1.53488800e-01f, -9.82206240e-02f, 9.71751064e-02f, -3.57329659e-02f, -1.12253167e-01f,
  5.35744205e-02f, -1.21124290e-01f, -2.51928180e-01f, -8.81046727e-02f, -1.60482656e-02f, 9.00560319e-02f, 5.65706342e-02f, 4.56385054e-02f, 1.77097693e-02f, -9.51626673e-02f,
  -2.46220455e-01f, -1.72893673e-01f, -7.37356618e-02f, -7.03140050e-02f, -1.60230845e-02f, -7.58146048e-02f, -3.11411787e-02f, 2.64673799e-01f, -1.33847356e-01f, 1.52918175e-01f,
  6.21258616e-01f, -1.63692132e-01f, 4.78381775e-02f, -5.95617406e-02f, -8.45748708e-02f, -6.44198000e-01f, 8.96262750e-02f, -3.43689546e-02f, 1.20223826e-03f, 1.75206318e-01f,
  -3.55949610e-01f, 1.65223524e-01f, 3.51265669e-01f, 3.97964567e-02f, -4.44718376e-02f, -4.68053997e-01f, -3.07193369e-01f, 1.18731089e-01f, 3.22294921e-01f, 1.17230639e-01f,
  3.92190963e-01f, 1.98750757e-02f, -5.29867768e-01f, 3.10556799e-01f, 2.58109987e-01f, -2.81390548e-01f, 3.92975733e-02f, -2.19098344e-01f, -1.95936397e-01f, -1.08561979e-03f,
  3.31261009e-02f, -6.46858871e-01f, -3.74551356e-01f, -1.00915149e-01f, -1.77512318e-01f, -4.74718183e-01f, -8.07039499e-01f, -3.35692942e-01f, -1.50362581e-01f, 1.67348117e-01f,
  4.83909249e-02f, -4.71501708e-01f, 1.54828817e-01f, -3.34019631e-01f, 3.17998111e-01f, 6.29356086e-01f, 3.94723453e-02f, -2.09450409e-01f, 4.91754413e-02f, 3.17366123e-01f,
  -2.36885045e-02f, 1.27800778e-01f, 1.54983342e-01f, 8.19453225e-02f, -4.16938849e-02f, 2.51614582e-03f, 5.15001155e-02f, 1.50539011e-01f, 8.12995285e-02f, -2.07291897e-02f,
  8.85375123e-03f, 2.04020932e-01f, 1.47387730e-02f, 3.50348614e-02f, 9.89054292e-02f, 4.72282730e-02f, -1.99243333e-03f, 2.77187098e-02f, 1.30306035e-01f, 5.41718453e-02f,
  -1.45037770e-02f, 1.23514898e-01f, 1.23109259e-01f, -3.46148200e-02f, 4.83957827e-02f, 3.11061107e-02f, 1.30393328e-02f, 1.39409557e-01f, -2.07993973e-04f, 1.00277312e-01f,
  -4.17315960e-02f, -4.80782352e-02f, 5.14540821e-04f, -2.14036759e-02f, 1.35927722e-01f, 1.87936768e-01f, -4.56845164e-02f, -1.40007585e-01f, 1.75810799e-01f, 1.35212630e-01f,
  2.39657015e-01f, -2.22069994e-02f, -2.83464068e-03f, -2.65845001e-01f, 7.85986781e-02f, 2.11900517e-01f, -1.02244854e-01f, -2.97456770e-03f, 1.40508130e-01f, -4.59702387e-02f,
  2.99799562e-01f, 2.45185748e-01f, -2.42170334e-01f, 1.27015701e-02f, -7.73412660e-02f, 1.48944303e-01f, -1.71243533e-01f, 1.71074405e-01f, 1.35378480e-01f, 2.35189393e-01f,
  -4.04323339e-02f, -2.71785986e-02f, -5.75006679e-02f, -2.03702986e-01f, -1.09737203e-01f, -5.78199234e-03f, 2.36066594e-03f, -7.97402635e-02f, -4.32656527e-01f, -2.73895264e-02f,
  -4.16779779e-02f, -2.23932907e-01f, -9.68795083e-03f, 2.58716382e-02f, 4.07667942e-02f, 1.08292244e-01f, 1.54771686e-01f, -5.72068393e-01f, 2.08083808e-01f, -6.49643064e-01f,
  3.63431185e-01f, -1.92138106e-01f, 2.67747223e-01f, 1.24768563e-01f, 6.97797164e-02f, -4.69492376e-01f, -1.17499866e-01f, 1.09756935e+00f, -1.65787920e-01f, 3.65004748e-01f,
  9.92881656e-02f, -3.98742884e-01f, -8.94204341e-03f, 5.51838018e-02f, 3.72709006e-01f, 5.27265295e-02f, -6.32746279e-01f, 9.68304798e-02f, 5.66579044e-01f, -5.50006330e-01f,
  -4.40622002e-01f, -3.83585721e-01f, -8.65553692e-02f, -3.41786742e-01f, -1.13671221e-01f, 8.28955352e-01f, 3.07480723e-01f, -2.73016632e-01f, -2.21337199e-01f, -5.39824963e-01f,
  4.30549413e-01f, -3.88517112e-01f, -2.27868855e-01f, 5.54476261e-01f, -1.42500937e-01f, 2.79075444e-01f, -2.39013985e-01f, 1.65640503e-01f, -5.88706493e-01f, -3.67032826e-01f,
  2.54288673e-01f, 1.73043236e-01f, -5.22835314e-01f, -3.08848530e-01f, 5.06775022e-01f, 8.48486871e-02f, 3.67848724e-02f, -7.65864730e-01f, 1.55006349e-02f, 1.45075740e-02f,
  1.22185657e-02f, 8.15026984e-02f, -1.98964149e-01f, 1.40904829e-01f, 1.02421485e-01f, 4.88104746e-02f, -1.38458684e-02f, -9.64053944e-02f, -9.96042192e-02f, 1.37634976e-02f,
  1.32970691e-01f, -3.45107839e-02f, -9.20433179e-02f, 4.48497385e-03f, 3.16026881e-02f, 5.40495403e-02f, 1.12324871e-01f, 1.01209760e-01f, -1.52540267e-01f, 4.12680171e-02f,
  4.56141829e-02f, 6.94745257e-02f, 2.66400557e-02f, -6.82574436e-02f, 5.24381287e-02f, -9.37905684e-02f, 9.61051434e-02f, 5.76390605e-03f, -1.04996659e-01f, 9.00165215e-02f,
  -3.76556627e-02f, 8.67528319e-02f, 5.89241274e-02f, 1.63492650e-01f, 1.27636567e-01f, 1.82973802e-01f, -7.09582642e-02f, -1.90357536e-01f, -2.52294857e-02f, -3.67430538e-01f,
  -1.90350026e-01f, -3.83904502e-02f, -9.78930891e-02f, 7.36703724e-02f, -6.11613318e-02f, -3.33308846e-01f, -1.74829751e-01f, -6.10108078e-02f, 1.96477219e-01f, 1.76381201e-01f,
  -2.02325001e-01f, -1.75334677e-01f, -7.82954395e-02f, -2.38477886e-01f, -9.26910341e-03f, 1.38477862e-01f, 2.73439527e-01f, -1.07317373e-01f, -2.42373779e-01f, 2.15917733e-03f,
  1.39013976e-01f, 1.27187356e-01f, -2.60570556e-01f, -1.42763555e-01f, 1.42188519e-02f, 2.02218682e-01f, -2.08997414e-01f, -6.88531920e-02f, 3.27865690e-01f, 9.82854366e-02f,
  2.44024977e-01f, -8.20151716e-02f, 2.27204248e-01f, -7.67028034e-02f, -3.14576417e-01f, 2.57023036e-01f, -2.59943873e-01f, -3.34381044e-01f, -5.31052053e-01f, -1.39492542e-01f,
  -9.38726664e-02f, -4.28952098e-01f, 5.58277667e-01f, -1.56972900e-01f, -4.00264680e-01f, 1.42108768e-01f, -2.51649678e-01f, 5.03829658e-01f, -4.11447376e-01f, -2.18207300e-01f,
  -1.08335339e-01f, -2.38370523e-01f, -7.74457633e-01f, -2.86614764e-02f, 3.46447170e-01f, -1.43557012e-01f, -6.85664192e-02f, -2.14860693e-01f, -2.49307245e-01f, -4.50540274e-01f,
  -8.54951382e-01f, 4.39216346e-01f, 2.89664000e-01f, -5.60098112e-01f, 1.81929506e-02f, -2.80419767e-01f, -4.76717740e-01f, 7.01880872e-01f, -1.04552425e-01f, -5.61239958e-01f,
  5.31927764e-01f, -1.04775928e-01f, -6.26114979e-02f, -3.31331939e-01f, -1.45932073e-02f, -1.65916029e-02f, 3.68158668e-01f, -5.80409527e-01f, -5.98358929e-01f, -5.05841911e-01f,
  -7.06956744e-01f, 5.72121203e-01f, -3.86296332e-01f, -2.39841849e-01f, 2.27404218e-02f, -3.45389575e-01f, -2.96419468e-02f, 5.14998771e-02f, -1.82096548e-02f, 2.27766447e-02f,
  -4.98018377e-02f, -1.60560645e-02f, 2.40583755e-02f, -7.46929571e-02f, -1.22068606e-01f, -1.94864929e-01f, -1.09712951e-01f, 2.44066603e-02f, -2.14191899e-02f, -5.73762394e-02f,
  -1.85861858e-03f, 1.15902051e-01f, 8.88576324e-04f, -2.26996895e-02f, 3.69689912e-02f, -9.30562913e-02f, -4.40509357e-02f, -7.07718208e-02f, -5.55612929e-02f, -1.52903974e-01f,
  1.36209195e-02f, -3.46100219e-02f, -3.70882563e-02f, -4.12706807e-02f, -5.60531989e-02f, -8.73611774e-03f, -8.38451385e-02f, 1.15320578e-01f, 9.52494815e-02f, 3.29679474e-02f,
  -1.02276862e-01f, -1.47458538e-01f, 3.58211733e-02f, -1.52433589e-01f, 1.47599697e-01f, -1.89166423e-02f, 2.63217948e-02f, 1.37889042e-01f, 1.27275556e-01f, 8.13695118e-02f,
  -1.65216029e-01f, 5.84658496e-02f, -2.66292244e-02f, -1.00635730e-01f, -1.25896018e-02f, -1.69894695e-01f, -6.52874410e-02f, -1.24412172e-01f, 1.80835649e-02f, 1.59491956e-01f,
  3.77654694e-02f, -1.53956160e-01f, -8.54020491e-02f, 4.80150208e-02f, -2.10728258e-01f, 1.01741133e-02f, 4.04883549e-02f, 5.52474782e-02f, -2.12369651e-01f, 2.39176258e-01f,
  1.52503327e-01f, -8.55248719e-02f, 1.26217067e-01f, -3.29465806e-01f, 2.83439904e-02f, 2.30783690e-03f, 2.81007262e-03f, 3.94511446e-02f, -1.26476750e-01f, -1.61983985e-02f,
  -1.42020747e-01f, -1.76443845e-01f, 2.19227582e-01f, -1.44206524e-01f, -7.38470107e-02f, -7.05869049e-02f, -2.99573511e-01f, -1.08533613e-01f, -2.04115316e-01f, 2.91843235e-01f,
  -2.55700707e-01f, -1.91761479e-01f, -1.66328787e-03f, 4.45170015e-01f, -1.01816719e-02f, 8.00407529e-02f, -2.51269668e-01f, 8.74332413e-02f, -3.71310115e-01f, -2.78930485e-01f,
  3.16892534e-01f, 8.14002380e-02f, 4.85889792e-01f, -3.86538833e-01f, -2.71273166e-01f, 4.65130568e-01f, 1.23209916e-01f, -1.50362745e-01f, 2.08900422e-02f, -4.27871078e-01f,
  -5.77219248e-01f, 7.57963657e-01f, -4.04728562e-01f, -8.80416557e-02f, 4.20331955e-01f, 2.16194838e-01f, -1.13591872e-01f, 1.70929730e-01f, -5.73086321e-01f, 1.53726786e-02f,
  -3.30706656e-01f, -5.45292459e-02f, -3.06386184e-02f, 2.04591185e-01f, -3.45806599e-01f, 1.65255331e-02f, -1.04288302e-01f, -6.27775908e-01f, -2.72119462e-01f, -1.08646028e-01f,
  -1.91294193e-01f, -3.09169455e-03f, -1.85585946e-01f, 6.11440122e-01f, -7.75939273e-03f, 8.05162825e-03f, -1.07993893e-01f, 1.68936953e-01f, 3.41995396e-02f, -1.82884946e-01f,
  1.39351025e-01f, 9.14608911e-02f, 2.99991332e-02f, 1.02951951e-01f, 3.39466594e-02f, 3.79696526e-02f, 3.09769418e-02f, 1.55016810e-01f, 1.79112758e-02f, 5.54188751e-02f,
  -5.34451082e-02f, 6.43985271e-02f, -1.64731264e-01f, -1.00582473e-01f, 1.24475181e-01f, -1.52246818e-01f, -3.48268859e-02f, 5.95479123e-02f, 1.68912694e-01f, 1.31228000e-01f,
  6.50991723e-02f, -4.47175950e-02f, 2.96457801e-02f, 2.33935807e-02f, 9.57657397e-02f, 1.19510822e-01f, -1.87468886e-01f, 5.60284853e-02f, 1.29040360e-01f, -8.79362151e-02f,
  -3.88835929e-02f, 1.22410342e-01f, 2.16565400e-01f, 9.81924012e-02f, 2.69322217e-01f, -2.85804290e-02f, 1.25907287e-01f, -3.32721502e-01f, 1.50726393e-01f, -1.66305184e-01f,
  -1.60474673e-01f, -1.65689513e-01f, -1.21452637e-01f, 4.15446721e-02f, -2.14456096e-01f, -1.87121183e-01f, -2.15694919e-01f, 1.37513265e-01f, 2.40615249e-01f, -1.12870470e-01f,
  2.64163703e-01f, 1.42443463e-01f, -2.30770826e-01f, 8.66695717e-02f, 4.84944522e-01f, 2.11190850e-01f, 1.55615792e-01f, -8.05196241e-02f, -1.79164156e-01f, -1.81573331e-02f,
  -1.75188079e-01f, 4.88473922e-02f, 3.91076267e-01f, 1.69138595e-01f, 3.40827793e-01f, 5.82797751e-02f, 1.89578578e-01f, 2.83927262e-01f, 1.87065378e-01f, -2.71297872e-01f,
  -2.92737633e-01f, -2.42956668e-01f, -9.08362120e-02f, -2.89283931e-01f, -3.88221323e-01f, 1.86661318e-01f, -1.82749122e-01f, 4.18873519e-01f, -2.42326796e-01f, -1.99038506e-01f,
  1.92497998e-01f, 4.83915359e-02f, -2.46418253e-01f, 2.69720480e-02f, -5.51944613e-01f, -3.22300382e-02f, 5.18518984e-01f, 6.02363050e-01f, -1.18487664e-01f, -2.18229622e-01f,
  -2.43259922e-01f, -3.69275689e-01f, -1.54541418e-01f, -4.58992511e-01f, -3.25567514e-01f, 1.19223535e-01f, -1.03492305e-01f, -2.33211324e-01f, 1.04230843e-01f, 4.25203949e-01f,
  -1.89803913e-01f, -4.43393439e-01f, 8.65318924e-02f, -7.56444409e-02f, -2.18365416e-01f, 1.88413158e-01f, -2.39877313e-01f, -4.62165438e-02f, -2.72128105e-01f, -2.33370230e-01f,
  8.75781756e-03f, -3.53426188e-01f, -3.95066142e-01f, 1.00761843e+00f, -3.54995668e-01f, -6.11233532e-01f, -1.68943912e-01f, -2.91549921e-01f, 1.76931649e-01f, 4.62494731e-01f,
  -3.08168441e-01f, -1.42925158e-01f, 2.88513489e-02f, -5.58043271e-02f, -8.04992616e-02f, -1.21191954e-02f, 1.53370900e-02f, -2.32474282e-01f, -2.08029710e-03f, -5.85969388e-02f,
  3.91362645e-02f, -1.83589756e-03f, 1.28081605e-01f, -1.00575633e-01f, -1.68282501e-02f, -3.60477436e-03f, -6.28881007e-02f, -6.62582293e-02f, -1.34443551e-01f, -4.81562279e-02f,
  -2.45594084e-01f, 1.65829584e-01f, 2.57316940e-02f, 4.59764712e-02f, 7.50302225e-02f, -1.16808549e-01f, -6.41518757e-02f, 5.32572828e-02f, -5.01121208e-02f, 1.05765842e-01f,
  -1.01046942e-01f, 6.18613958e-02f, -5.00656739e-02f, 1.24060668e-01f, 7.66375512e-02f, 6.53579757e-02f, 4.84468677e-04f, -2.58689314e-01f, -9.22055617e-02f, -2.19853461e-01f,
  -8.60723555e-02f, -1.03492662e-01f, -3.45820487e-01f, 4.80444640e-01f, -3.92358154e-01f, 2.51853466e-01f, 2.31147543e-01f, 3.22823882e-01f, -1.28011063e-01f, 3.56946468e-01f,
  1.46524394e-02f, 2.23986655e-01f, -3.88586193e-01f, -6.52970970e-02f, -2.09908262e-01f, -2.27890775e-01f, -8.79544169e-02f, 1.25319157e-02f, -2.01826483e-01f, -1.37479231e-02f,
  1.14837065e-01f, -2.81984419e-01f, 2.75022760e-02f, 2.96413988e-01f, 1.51586443e-01f, 1.58236310e-01f, -1.47820637e-01f, -7.46455193e-02f, 2.80976593e-01f, -6.90141087e-03f,
  -3.31680387e-01f, -6.50062114e-02f, -4.67714220e-01f, -2.28772491e-01f, -2.04513632e-02f, -2.28781059e-01f, -2.67510593e-01f, 1.73267111e-01f, -1.76390618e-01f, 4.55902696e-01f,
  8.13536882e-01f, -5.47418475e-01f, -3.31687480e-01f, -2.38693282e-01f, -1.95665509e-01f, -3.36472005e-01f, 2.29097918e-01f, -4.57150280e-01f, -4.58943248e-02f, -2.29626343e-01f,
  -3.00920188e-01f, -3.33758533e-01f, -5.93040705e-01f, 4.94778082e-02f, -4.96924311e-01f, -3.21090788e-01f, 7.02220857e-01f, -7.12335348e-01f, -2.56080449e-01f, -5.70253730e-01f,
  5.25005087e-02f, -4.57383513e-01f, 2.21339405e-01f, 3.26627381e-02f, 6.84993446e-01f, 3.76084447e-01f, 3.26806813e-01f, -2.06058159e-01f, -2.74994016e-01f, -2.07163066e-01f,
  2.50167996e-01f, -7.68743083e-02f, -1.78128421e-01f, -2.98283428e-01f, 2.98536241e-01f, 3.39845031e-01f, -3.68119180e-01f, -3.31908286e-01f, 1.31518155e-01f, 3.10135465e-02f,
  3.12739983e-02f, -5.06467998e-01f, 4.58022773e-01f, -5.67693889e-01f, 2.96272755e-01f, -3.27273011e-01f, 2.06515118e-01f, -3.19447219e-01f, 1.24821521e-01f, 1.26223773e-01f,
  5.83101511e-02f, 3.94085981e-02f, -6.89650178e-02f, -1.10555582e-01f, -1.53986206e-02f, 1.40299082e-01f, -1.67168640e-02f, -6.25312179e-02f, 6.97636753e-02f, 8.70170593e-02f,
  2.23365128e-02f, 1.88601110e-02f, 1.29316136e-01f, 1.17229432e-01f, 1.95968732e-01f, -8.59134272e-02f, 8.12621862e-02f, 8.58288929e-02f, -1.16529139e-02f, -5.52969836e-02f,
  -5.83233871e-02f, 1.12887613e-01f, 1.04128838e-01f, 4.09010500e-02f, -1.08009323e-01f, -1.87992454e-02f, 2.10341178e-02f, 6.19504079e-02f, -8.57188925e-03f, -1.19319931e-01f,
  -1.39038607e-01f, 7.00273514e-02f, 7.11807609e-02f, -3.60895395e-02f, -5.39770387e-02f, 6.33275136e-02f, 1.20472819e-01f, 1.10713512e-01f, -7.70726055e-02f, 2.39826199e-02f,
  -2.22222075e-01f, 2.53127009e-01f, 2.69889742e-01f, 2.48474598e-01f, -1.14044152e-01f, -3.27739149e-01f, 2.05970451e-01f, 2.30199434e-02f, 1.09017611e-01f, 1.38974354e-01f,
  -8.25740099e-02f, -8.68701339e-02f, 4.07532342e-02f, 1.94718376e-01f, 5.11864051e-02f, 1.00303061e-01f, 2.43610889e-01f, -5.64338267e-02f, -9.44247283e-03f, 3.24593410e-02f,
  -1.81124777e-01f, -3.37321758e-02f, -2.28286579e-01f, 2.75669843e-01f, -1.10837415e-01f, 1.09767973e-01f, -4.86764722e-02f, -2.08400622e-01f, 2.69188285e-01f, 1.78030394e-02f,
  -2.54109561e-01f, -1.23190284e-01f, 2.05528244e-01f, -1.04783133e-01f, -8.76013190e-03f, -1.55853778e-01f, -2.95586497e-01f, -1.96832687e-01f, -2.63036013e-01f, -3.96263748e-01f,
  -1.51656717e-01f, 7.86784589e-02f, -2.39757314e-01f, -9.57192853e-02f, -3.27698439e-01f, -6.06025994e-01f, -2.91672498e-01f, -3.57246995e-01f, -1.34389997e-01f, 3.75764459e-01f,
  3.35157812e-01f, -2.33601123e-01f, -3.45735818e-01f, 1.89875588e-01f, -3.19588482e-02f, -4.89245355e-01f, -2.70061642e-01f, 4.14704680e-01f, 1.18280970e-01f, -3.10854673e-01f,
  -2.39051938e-01f, 4.83638257e-01f, -6.37824893e-01f, -1.90308660e-01f, 1.98597815e-02f, -9.44961756e-02f, -5.49589515e-01f, -2.38062844e-01f, 5.29613793e-01f, -1.16097525e-01f,
  -4.83210504e-01f, -4.59010541e-01f, -2.06658572e-01f, -4.84229505e-01f, 8.49233508e-01f, -4.04201061e-01f, -4.29864943e-01f, -1.90472603e-01f, -2.26789579e-01f, -3.20104063e-01f,
  -4.52694267e-01f, 4.84401822e-01f, -3.09186667e-01f, -3.02003503e-01f, -8.87200609e-02f, 4.38738227e-01f, -3.12775642e-01f, -2.11973533e-01f, -2.58760229e-02f, 4.27660905e-02f,
  3.32290381e-02f, -2.25519389e-01f, 1.45826861e-01f, -6.13564588e-02f, 7.90361390e-02f, -4.64760028e-02f, -1.32611440e-02f, 1.10805377e-01f, 8.52923393e-02f, 3.74796651e-02f,
  -3.54995802e-02f, -4.72660661e-02f, 8.37781802e-02f, 1.02273397e-01f, 4.12816964e-02f, 3.12579758e-02f, 2.92636566e-02f, 4.63267639e-02f, 3.39593031e-02f, 8.14975053e-02f,
  1.08655319e-01f, 5.34665845e-02f, 6.06984682e-02f, 9.55769792e-02f, -9.52545553e-03f, 6.73021227e-02f, 7.03899637e-02f, 4.91375811e-02f, 7.45948404e-02f, -5.83047532e-02f,
  -2.48403847e-01f, -1.09214015e-01f, 9.73406062e-02f, 2.07848195e-02f, -1.15365252e-01f, -2.42926180e-02f, 1.46682918e-01f, -6.98104799e-02f, 1.11987494e-01f, -2.46929765e-01f,
  -9.08678696e-02f, -2.97500283e-01f, 1.56716630e-01f, 1.36878416e-01f, -1.95987523e-01f, -7.08960071e-02f, 4.63191494e-02f, -1.52568772e-01f, -1.17571369e-01f, -4.67645861e-02f,
  -2.79144906e-02f, 1.80266678e-01f, 3.04424316e-02f, 8.75896141e-02f, 2.51265258e-01f, -6.38212934e-02f, 3.49568576e-02f, 1.70180783e-01f, -2.28048831e-01f, 1.98622108e-01f,
  1.28746018e-01f, 3.75793613e-02f, 3.45820814e-01f, -7.43864328e-02f, -2.78139412e-01f, -1.57000273e-01f, 2.63349060e-03f, -1.42020628e-01f, 1.28349513e-01f, 2.43454501e-01f,
  2.01593395e-02f, 2.17994023e-02f, 1.21590294e-01f, 2.03365162e-01f, -3.25591892e-01f, -3.11973155e-01f, -1.36315212e-01f, 2.00079735e-02f, -1.48151353e-01f, -1.06487302e-02f,
  7.28035271e-02f, 8.22909251e-02f, -3.58730465e-01f, -1.29316479e-01f, 2.48972010e-02f, -3.95706683e-01f, 2.07091883e-01f, 9.71093178e-02f, -4.37919229e-01f, -3.30545753e-01f,
  4.79649425e-01f, -6.59067929e-01f, -2.28822902e-01f, 6.70068562e-02f, -2.37321511e-01f, -1.08420104e-01f, 1.13593102e-01f, 7.06089437e-01f, 3.25719148e-01f, -2.37495303e-01f,
  1.67770982e-02f, -3.20074052e-01f, 1.32093206e-01f, -2.33383447e-01f, -3.99436265e-01f, -2.01896831e-01f, -4.68439460e-01f, -6.16856813e-01f, -9.92685258e-02f, 4.51041192e-01f,
  3.44751418e-01f, -2.51076996e-01f, -1.04706682e-01f, 6.64328158e-01f, -2.94086456e-01f, -1.28366515e-01f, 7.42437363e-01f, -3.33546847e-01f, -2.71491110e-01f, -4.28471804e-01f,
  -8.37152824e-02f, 1.45314798e-01f, 4.37688440e-01f, 2.69322276e-01f, -2.70980984e-01f, 2.66171038e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.90088987e-01f, 1.90210402e-01f, 1.85467452e-01f, -6.72409236e-02f, -7.22048134e-02f, 1.90741476e-02f, -5.76954857e-02f, 7.53591806e-02f, 1.32298451e-02f, 4.45788130e-02f,
  5.84336333e-02f, -3.25655565e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 38, 52
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    