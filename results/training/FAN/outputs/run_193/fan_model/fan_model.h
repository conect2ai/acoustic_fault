/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.26054928e-01f, -2.10712016e-01f, -1.33639038e-01f, 1.14838153e-01f, 3.83711576e-01f, -9.96031538e-02f, -2.09766954e-01f, 1.92430809e-01f, -1.75009016e-02f, -9.13407877e-02f,
  1.66563073e-03f, -1.01037554e-01f, -4.20251071e-01f, -8.36166516e-02f, -1.03182040e-01f, -5.42336702e-01f, 7.01622590e-02f, -1.01837106e-01f, -2.30125636e-02f, 2.33447969e-01f,
  1.13175631e-01f, 2.09191944e-02f, -1.53520763e-01f, 1.45805091e-01f, 1.74711719e-01f, 1.36528030e-01f, 1.86827511e-01f, -2.85838246e-02f, 1.65247083e-01f, -3.92442271e-02f,
  -6.88460246e-02f, -7.32893273e-02f, 4.56289127e-02f, -7.18540698e-02f, 3.91916819e-02f, 1.07721597e-01f, 5.21866009e-02f, -9.33150798e-02f, 5.98802231e-02f, -3.23975482e-03f,
  -6.25461861e-02f, 5.52967610e-03f, -4.34696786e-02f, -4.42016721e-02f, 1.68323606e-01f, 7.06149042e-02f, 2.93801147e-02f, 4.68783826e-02f, -9.21086688e-03f, -5.02161607e-02f,
  -4.21862639e-02f, -1.47704212e-02f, 9.20073614e-02f, -5.98991476e-02f, 3.47188562e-02f, 2.13701334e-02f, -4.60449196e-02f, -6.81559043e-03f, 2.04663854e-02f, 6.62802532e-02f,
  4.61032838e-02f, 4.11218293e-02f, -1.73891708e-02f, 8.10810179e-03f, -1.56003041e-02f, 3.51618975e-02f, 1.59547422e-02f, -5.58285192e-02f, 1.10420547e-02f, 3.16922665e-02f,
  3.55226025e-02f, 3.77320349e-02f, 2.67572310e-02f, 1.12826657e-02f, 4.22449075e-02f, 1.97209083e-02f, -3.78294364e-02f, -5.74274696e-02f, 7.79820308e-02f, 4.69830967e-02f,
  -5.24029545e-02f, 5.78774251e-02f, 2.72042514e-03f, 1.13269407e-02f, -1.43939932e-03f, -1.53859006e-03f, -1.05911838e-02f, 1.45279355e-02f, 7.80753139e-03f, 3.34100872e-02f,
  -3.06710526e-02f, 3.47964396e-03f, 2.68220324e-02f, -8.10443424e-03f, -3.94942984e-02f, 5.53463213e-02f, -4.25041020e-02f, 3.47973267e-03f, -6.68664649e-02f, -4.66896370e-02f,
  1.47308081e-01f, 4.69806083e-02f, 8.45772699e-02f, 2.03038827e-02f, -3.27078402e-02f, 1.00365402e-02f, -1.34167895e-02f, 1.72273740e-02f, 1.00974835e-01f, 2.45033056e-02f,
  8.33130181e-02f, 3.59302498e-02f, 1.43351322e-02f, 1.02649890e-01f, 9.62238666e-03f, -9.32310475e-04f, 1.33647576e-01f, -1.32069439e-02f, -3.40739563e-02f, -7.68383294e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  5.23915887e-01f, -3.06929380e-01f, -6.19635224e-01f, -3.21074836e-02f, 4.29617018e-01f, 3.41298848e-01f, -2.25155547e-01f, 1.62242606e-01f, -3.74218285e-01f, -9.34879854e-02f,
  2.38121465e-01f, -2.26743221e-01f, -6.04614854e-01f, 3.92754018e-01f, 3.95704806e-01f, -3.67293090e-01f, 4.70749617e-01f, 2.31816232e-01f, -1.70037583e-01f, 1.35205284e-01f,
  1.31699353e-01f, 7.79177785e-01f, -2.15604708e-01f, 4.52615559e-01f, 3.48542124e-01f, -1.19627006e-01f, 2.21596196e-01f, -2.44893700e-01f, 5.42826355e-01f, 3.86023909e-01f,
  4.72776033e-02f, -6.06626682e-02f, -1.39015630e-01f, -8.18343237e-02f, 4.33252528e-02f, 1.09610014e-01f, -4.12766412e-02f, 2.21156385e-02f, -7.16757998e-02f, -5.58110960e-02f,
  5.62724890e-03f, 4.92062569e-02f, 1.43669948e-01f, -1.81681581e-03f, 7.02179223e-02f, 7.27174152e-03f, -2.76342239e-02f, -1.00303970e-01f, -1.22598454e-01f, 1.48444278e-02f,
  -1.81834996e-01f, 5.01579940e-02f, -3.58142927e-02f, -5.15799522e-02f, -9.81428549e-02f, 1.96413361e-02f, -1.08128518e-01f, -6.00759424e-02f, -2.54120659e-02f, 8.84556919e-02f,
  1.89203665e-01f, -3.48885497e-03f, 3.05804722e-02f, -2.47104354e-02f, 6.21466003e-02f, -3.67615670e-02f, -1.36596002e-02f, 4.80657704e-02f, -4.21185419e-02f, 4.56574932e-02f,
  -6.64366484e-02f, 1.77681427e-02f, 4.50105295e-02f, 2.92595895e-03f, 6.84087202e-02f, -3.65963690e-02f, -1.38939144e-02f, 7.43987784e-02f, -6.70586675e-02f, -3.73012684e-02f,
  -1.05495654e-01f, 5.70256189e-02f, -1.29897697e-02f, 4.18777065e-03f, -1.07305627e-02f, -7.51817152e-02f, 1.02696665e-01f, -1.81777701e-02f, -9.69049558e-02f, 2.66237687e-02f,
  -2.96752583e-02f, 1.22264177e-01f, -1.80884778e-01f, -1.78104267e-02f, -6.25256896e-02f, 1.79767042e-01f, 1.36551438e-02f, 2.90766582e-02f, 1.25036351e-02f, 8.00119117e-02f,
  7.08849579e-02f, -2.03708299e-02f, 4.11629397e-03f, 3.19463946e-02f, 8.14616960e-03f, 6.96472898e-02f, 1.39508396e-02f, -1.15231201e-02f, 5.31173162e-02f, 1.81339771e-01f,
  2.75547970e-02f, 2.17304714e-02f, -3.94515060e-02f, -1.36551624e-02f, 6.41800538e-02f, -1.94115750e-02f, 5.05155139e-02f, -8.02922472e-02f, 7.49498010e-02f, -9.44948420e-02f,
  9.55378935e-02f, 3.93575668e-01f, 1.14191145e-01f, 2.23476849e-02f, -1.53383106e-01f, 1.30276039e-01f, -3.44229937e-02f, -3.84214930e-02f, 1.84819356e-01f, 3.34822267e-01f,
  -4.91919190e-01f, 5.34719169e-01f, -2.21103802e-01f, -2.28119358e-01f, -3.01645130e-01f, -1.91519707e-01f, 1.66523382e-02f, 1.63356408e-01f, -1.16197079e-01f, 9.07717794e-02f,
  -1.14733636e-01f, -4.17029858e-01f, -4.46299195e-01f, -2.62148052e-01f, -1.61209151e-01f, 1.22351579e-01f, -2.75580049e-01f, -2.06304759e-01f, -3.02118342e-02f, -1.21731982e-01f,
  -2.07936883e-01f, -1.73061505e-01f, 8.02690610e-02f, 7.53334016e-02f, -1.81278344e-02f, 1.06948890e-01f, 1.54896140e-01f, -9.42969993e-02f, -7.54232779e-02f, 2.87502427e-02f,
  1.69005826e-01f, -2.21635262e-03f, 5.33496588e-02f, -8.13211128e-02f, 4.94961441e-03f, 4.40581068e-02f, 3.30940895e-02f, -7.95256123e-02f, 7.07032382e-02f, -5.33285029e-02f,
  3.35646570e-02f, 8.86873677e-02f, -3.15166377e-02f, 4.92485836e-02f, -2.60416921e-02f, -3.51836607e-02f, 4.15651426e-02f, 7.50993118e-02f, 1.32271528e-01f, 6.37077913e-02f,
  4.40842621e-02f, 9.72246677e-02f, 4.28208224e-02f, -4.60823961e-02f, -7.23957121e-02f, -7.39602372e-02f, -1.23171257e-02f, -3.48683372e-02f, 3.31985503e-02f, 1.30237557e-03f,
  1.14455968e-02f, 5.17727993e-03f, -6.39935061e-02f, 7.22388253e-02f, -5.91900386e-02f, 4.19223532e-02f, 6.19396046e-02f, 1.29879992e-02f, 7.31219649e-02f, -9.92754623e-02f,
  -6.40963987e-02f, 1.37307318e-02f, -3.32944677e-03f, -1.79754458e-02f, -5.82893528e-02f, -2.54171044e-02f, 2.55333968e-02f, 4.89891805e-02f, -6.18464537e-02f, -3.62186204e-03f,
  1.85966760e-01f, 3.44107002e-01f, 8.17261264e-03f, 1.35204019e-02f, 1.14330603e-02f, 4.97290604e-02f, 7.20783174e-02f, -3.33974400e-04f, 7.48141706e-02f, 3.73361595e-02f,
  1.01838157e-01f, 3.95873301e-02f, 9.42163244e-02f, 1.44005744e-02f, -6.01192284e-03f, -2.60745622e-02f, 4.71259095e-02f, 9.12218392e-02f, 3.81245874e-02f, -4.85400902e-03f,
  1.38119832e-02f, 6.19495213e-02f, 2.97642257e-02f, 4.52993624e-02f, 6.69134185e-02f, 6.62822127e-02f, 1.36952654e-01f, 9.10668522e-02f, 3.95962372e-02f, 5.88306189e-02f,
  -5.69416225e-01f, 4.57448028e-02f, 5.38991034e-01f, -6.38904035e-01f, 2.17048734e-01f, 5.11438668e-01f, -1.86165553e-02f, 3.57388929e-02f, -4.32300061e-01f, -4.05800074e-01f,
  -2.31001094e-01f, -5.83271571e-02f, 1.91415384e-01f, -2.49832526e-01f, 3.18013459e-01f, 1.75445452e-01f, -2.29656324e-01f, -2.44900063e-01f, 1.14295945e-01f, -2.41372511e-01f,
  -7.05606639e-02f, -3.11070353e-01f, 3.07606429e-01f, 3.31449583e-02f, -2.54564490e-02f, -1.74273759e-01f, -2.08595186e-01f, 3.41048151e-01f, -1.23984836e-01f, 2.34930828e-01f,
  -1.07175268e-01f, -3.92328292e-01f, 7.06655532e-02f, 3.45074907e-02f, 5.78730414e-03f, -6.05598614e-02f, -7.28573045e-03f, 1.01700500e-01f, -2.40724478e-02f, -1.40603026e-02f,
  -9.36220586e-02f, 6.75249994e-02f, -1.06394604e-01f, 5.42645082e-02f, -3.40109644e-03f, 1.57747492e-02f, 1.20335862e-01f, 3.29572111e-02f, 7.68425018e-02f, 1.42886207e-01f,
  1.15196444e-01f, 1.22937940e-01f, 2.51134746e-02f, -3.19627337e-02f, 1.54119909e-01f, -1.42405555e-02f, 2.22143792e-02f, 1.29978612e-01f, 3.55508216e-02f, -5.82434274e-02f,
  -4.77650873e-02f, 5.99058084e-02f, 3.46129686e-02f, -1.18835652e-02f, 4.71147448e-02f, -3.22356783e-02f, 2.32937597e-02f, -4.63543739e-03f, 1.30450502e-02f, -3.46161402e-03f,
  -6.49219826e-02f, -4.85578105e-02f, -5.85377403e-02f, -1.68455709e-02f, -4.89574075e-02f, -1.16930410e-01f, 6.33398518e-02f, -2.06155442e-02f, 2.08151061e-02f, 4.49463166e-02f,
  -3.72168496e-02f, 4.68869023e-02f, -1.67409703e-02f, -2.12197937e-02f, 5.05409129e-02f, 6.56178296e-02f, -1.89895499e-02f, 6.90423399e-02f, -2.37948075e-02f, 2.49386933e-02f,
  -2.54019171e-01f, -4.00606871e-01f, -1.75168533e-02f, 1.10895755e-02f, -3.01925279e-02f, 6.16622716e-02f, 2.74773445e-02f, 2.93659437e-02f, -9.78228748e-02f, -5.08423634e-02f,
  7.40508037e-03f, -7.42793232e-02f, 4.91561070e-02f, -7.61231035e-03f, 1.35833751e-02f, -1.28751164e-02f, -1.02812417e-01f, -8.53360295e-02f, -3.85986678e-02f, 9.64778941e-03f,
  -3.71239670e-02f, -1.04922734e-01f, -1.99017953e-02f, -9.44796130e-02f, -1.11417904e-01f, -7.55861402e-02f, -6.73728064e-02f, 3.68928537e-02f, 3.04564610e-02f, 2.86305416e-02f,
  -2.79502366e-02f, 2.95358032e-01f, 2.08740205e-01f, 3.32540691e-01f, -6.17974363e-02f, -7.92815462e-02f, -2.95263883e-02f, 2.68455654e-01f, 4.34183747e-01f, 5.95750809e-02f,
  -1.74084082e-01f, 2.21017256e-01f, 2.11119056e-02f, -1.74123526e-03f, 2.80472636e-01f, 1.27390489e-01f, 3.59047353e-01f, -1.44664859e-02f, 2.44951561e-01f, 2.62229621e-01f,
  1.54670179e-01f, 6.32949397e-02f, -3.38544250e-02f, -3.75018939e-02f, 8.03795755e-02f, 5.91180287e-03f, 1.11896329e-01f, -6.25366345e-02f, -1.53675437e-01f, -1.03717279e-02f,
  -1.38491392e-01f, 1.71181127e-01f, -1.28720805e-01f, -6.95305318e-02f, 9.21370909e-02f, -1.44936919e-01f, -3.75574194e-02f, -1.34338573e-01f, -5.42827807e-02f, 4.89227436e-02f,
  -1.26975486e-02f, -9.83405113e-02f, -9.90054198e-03f, 1.22538060e-02f, 1.27997072e-02f, 4.44849692e-02f, 2.12436896e-02f, -8.19797069e-02f, -3.30450851e-03f, -2.57284455e-02f,
  -8.87114257e-02f, -6.25856370e-02f, -1.48103340e-02f, 4.73755691e-03f, -1.01162563e-03f, 3.20898443e-02f, 1.44538525e-02f, -3.57395224e-02f, 3.02400943e-02f, 6.01240024e-02f,
  1.40898541e-01f, -4.43737842e-02f, -6.24881461e-02f, -7.83804208e-02f, 6.53501004e-02f, -4.61393967e-02f, 7.00670183e-02f, -1.05913337e-02f, 3.99476588e-02f, 3.50769167e-03f,
  3.13426070e-02f, -5.73198013e-02f, 3.67185920e-02f, -5.35766967e-02f, 1.01102166e-01f, -7.46683870e-03f, -3.32362428e-02f, -5.60343359e-03f, 7.12136030e-02f, -7.00733960e-02f,
  9.32648852e-02f, 5.22796251e-02f, -1.22672310e-02f, -5.30159958e-02f, -2.61397157e-02f, -2.26201825e-02f, 3.82923409e-02f, 4.25557559e-03f, -7.59273991e-02f, 2.72149816e-02f,
  2.20617324e-01f, 6.73664093e-01f, 1.22731209e-01f, -5.03701791e-02f, 2.61945222e-02f, 1.46366388e-03f, 1.09655503e-02f, 5.40406629e-02f, 1.85533375e-01f, 1.15167327e-01f,
  7.17715099e-02f, 3.22783329e-02f, 6.93236887e-02f, -3.77970897e-02f, 3.10086031e-02f, 1.16307721e-01f, 7.93194473e-02f, 6.69512376e-02f, 2.17622086e-01f, -3.66551355e-02f,
  -1.41564282e-02f, 6.57081651e-03f, 2.59047691e-02f, -3.55196605e-03f, -4.54911962e-02f, -2.92246155e-02f, 7.72871971e-02f, -4.53779176e-02f, -3.17156203e-02f, 1.09638974e-01f,
  1.07519202e-01f, -6.71955571e-02f, -2.36179754e-01f, -5.75514585e-02f, -1.39321879e-01f, 4.76567656e-01f, 8.43045413e-01f, -2.33046010e-01f, -2.12568492e-01f, 5.26507080e-01f,
  5.35824180e-01f, -8.82278830e-02f, 4.71242756e-01f, 4.26706672e-01f, 6.46552369e-02f, 3.83490294e-01f, 3.08665395e-01f, 3.63424301e-01f, -1.73383102e-01f, -4.25508581e-02f,
  -2.34020245e-03f, 3.59894633e-01f, 1.87433045e-02f, -2.33575314e-01f, 2.55921721e-01f, -3.50370049e-01f, -3.53136263e-03f, -1.22827768e-01f, -8.32611993e-02f, 2.11214628e-02f,
  1.33459330e-01f, 7.58254454e-02f, -3.43911462e-02f, -1.07863478e-01f, 2.53026914e-02f, 6.14117607e-02f, 2.53649075e-02f, -2.05246545e-02f, -1.25807330e-01f, -4.40684184e-02f,
  6.34068102e-02f, -1.25656173e-01f, -9.14390534e-02f, -3.28869820e-02f, -3.56486030e-02f, -1.57477707e-01f, -1.03428714e-01f, -3.90175432e-02f, -9.46083292e-02f, 9.26719047e-03f,
  9.17391665e-03f, -2.77061965e-02f, 5.87235838e-02f, 9.98487603e-03f, 7.28156557e-03f, -9.08108726e-02f, -3.09556816e-02f, 2.41012536e-02f, -3.89475524e-02f, -3.81223187e-02f,
  -4.49380502e-02f, 7.09705353e-02f, 1.11887507e-01f, 1.76764186e-02f, -3.82238626e-02f, 2.74452521e-03f, 1.24948155e-02f, 4.55992632e-02f, -7.30969086e-02f, 9.19518694e-02f,
  -1.26284277e-02f, -3.76427770e-02f, -6.53646663e-02f, 3.96962464e-02f, 4.72700223e-02f, 8.33551213e-03f, 4.07119170e-02f, 2.73903925e-02f, 5.21946549e-02f, -4.86049950e-02f,
  5.19880354e-02f, -1.52855031e-02f, 1.16922483e-01f, 6.43786937e-02f, 7.47059137e-02f, 3.57461162e-02f, 7.31543750e-02f, 2.66560987e-02f, -2.03406196e-02f, 6.84289634e-02f,
  -1.34451315e-02f, -3.05315061e-03f, 3.22568417e-02f, -2.92776879e-02f, -8.85410085e-02f, 3.82885970e-02f, 2.88017727e-02f, -2.56256014e-02f, -5.64652756e-02f, -6.32172404e-03f,
  9.68098640e-02f, 2.09296998e-02f, 3.52787636e-02f, -2.52264664e-02f, -8.19499493e-02f, 1.47679567e-01f, 1.11811064e-01f, -7.27730095e-02f, -9.43372119e-03f, -1.29904121e-01f,
  -2.94646416e-02f, 3.65686268e-02f, -2.92903185e-02f, -6.04551919e-02f, -2.57072225e-02f, 1.10619701e-01f, -6.49225935e-02f, -7.31660500e-02f, 1.61930937e-02f, -2.43742149e-02f,
  1.31092653e-01f, 2.99617767e-01f, 3.07026237e-01f, 8.18388760e-02f, -2.54968792e-01f, -5.07752359e-01f, -3.53500634e-01f, 1.82311028e-01f, -8.48353803e-02f, 2.95535121e-02f,
  -4.35810573e-02f, 1.91502154e-01f, 1.25515640e-01f, -1.00292385e-01f, 4.66528907e-02f, -5.72460704e-02f, 7.14057833e-02f, -6.95462525e-02f, 8.00421610e-02f, 3.52342755e-01f,
  3.79194319e-01f, -1.36476085e-01f, 4.29170102e-01f, 1.92975238e-01f, 2.49105990e-01f, 4.57096696e-01f, 2.61301070e-01f, 7.10090995e-02f, 2.17327997e-01f, -1.98178411e-01f,
  -7.47304484e-02f, 1.44779488e-01f, 1.31932378e-01f, -1.12497799e-01f, 2.22024292e-01f, 9.53890383e-02f, 9.81386285e-03f, -1.09569013e-01f, -1.04748674e-01f, 4.86835800e-02f,
  1.01066353e-05f, 4.00621966e-02f, -6.74689040e-02f, -3.84733006e-02f, -1.00250244e-01f, 5.36337774e-03f, -4.99684215e-02f, 8.37374106e-02f, -6.02373965e-02f, 1.36913106e-01f,
  9.44483355e-02f, 2.16292460e-02f, 1.14061255e-02f, -2.36995192e-03f, 2.24869922e-02f, 9.39382007e-04f, -5.85846752e-02f, 1.08285151e-01f, -6.05201498e-02f, 1.78198349e-02f,
  8.09965059e-02f, -6.35614470e-02f, -8.46505985e-02f, -8.32384378e-02f, -3.55639048e-02f, 7.37109110e-02f, -5.48925027e-02f, -2.77444925e-02f, -1.78484935e-02f, -8.26098304e-03f,
  -1.74045097e-02f, 2.46255714e-02f, -1.90951731e-02f, -9.05609578e-02f, 1.25780683e-02f, -1.02019101e-01f, -4.96036448e-02f, 4.85364487e-03f, 1.09102335e-02f, -4.22238074e-02f,
  -2.77263243e-02f, -1.71523970e-02f, 2.48266235e-02f, -8.73947237e-03f, -1.06906913e-01f, -8.23336653e-03f, 7.62597248e-02f, 5.78773059e-02f, 6.62662387e-02f, -1.43412333e-02f,
  1.31201357e-01f, 2.62917995e-01f, 2.28133737e-04f, -1.51635453e-01f, 3.71428244e-02f, 1.84618123e-02f, -5.26485182e-02f, 6.08928166e-02f, 5.75608611e-02f, -2.48917211e-02f,
  1.02827214e-01f, -2.30679661e-02f, -3.05694547e-02f, -5.55063859e-02f, -1.42653119e-02f, 6.20171316e-02f, 5.90013526e-02f, -1.95549428e-02f, 1.46957077e-02f, 2.36869946e-01f,
  2.81781051e-02f, 3.33412252e-02f, 7.93003812e-02f, -9.52131376e-02f, -1.40510863e-02f, 6.42000362e-02f, -7.67592490e-02f, 4.58473489e-02f, 2.53422391e-02f, 5.59697254e-03f,
  -1.89693779e-01f, -4.99292344e-01f, 5.02859280e-02f, 4.10157502e-01f, -2.52109114e-02f, -1.52676329e-01f, -7.43784308e-02f, -7.09824562e-02f, -2.63173074e-01f, -2.95910418e-01f,
  9.07176286e-02f, -1.99480295e-01f, -2.02036381e-01f, 9.54367593e-02f, 2.34241560e-01f, -3.19551289e-01f, 5.61790951e-02f, -5.67467697e-02f, -2.35076174e-02f, 3.08168773e-03f,
  2.10675433e-01f, 2.87078470e-01f, 2.79653400e-01f, 2.95591295e-01f, 8.38163272e-02f, 4.02221531e-01f, 4.53895658e-01f, 2.52691239e-01f, 5.33745587e-01f, 1.82663202e-01f,
  -1.77022099e-01f, -5.54380976e-02f, 4.41574305e-03f, -1.02295503e-01f, 2.68158559e-02f, 3.56586054e-02f, 1.37147754e-01f, 1.85964957e-01f, 7.78080523e-02f, 6.77291490e-03f,
  -1.31595567e-01f, 1.75530277e-02f, 8.79196972e-02f, -3.13899922e-03f, -4.76503223e-02f, 2.86765071e-03f, -7.17282016e-03f, -2.69935150e-02f, 6.47499412e-03f, -4.11452949e-02f,
  -6.58639148e-02f, -6.15362823e-02f, 2.87725348e-02f, 1.06602512e-01f, 9.99300554e-02f, -3.85886291e-03f, 2.29625478e-02f, 5.89742884e-02f, 7.43722916e-03f, 4.18283269e-02f,
  -5.92185557e-02f, 9.92383882e-02f, 4.74707671e-02f, 9.68801975e-03f, 7.93332607e-02f, 1.90912820e-02f, 4.78535034e-02f, 3.60509334e-03f, 5.74047305e-02f, -4.34677452e-02f,
  3.38488780e-02f, 3.55924144e-02f, 4.69587324e-03f, -6.16595410e-02f, -4.50002588e-02f, -4.65112068e-02f, 3.26906629e-02f, 4.50238995e-02f, -7.13607967e-02f, 2.47959066e-02f,
  -5.67881316e-02f, 3.02273761e-02f, 3.34705273e-03f, 9.80385914e-02f, -5.55026866e-02f, 2.51403195e-03f, -2.09869277e-02f, 6.43497799e-04f, 1.75586101e-02f, 8.28370750e-02f,
  -1.55857205e-01f, 1.04177088e-01f, 3.39219868e-02f, 1.69718359e-02f, -1.34618478e-02f, -1.00513943e-01f, 3.17517552e-03f, -4.77748960e-02f, -8.16203132e-02f, -7.52591789e-02f,
  5.26061244e-02f, 7.52909109e-02f, -1.30578086e-01f, 7.21033663e-02f, 9.00211930e-02f, -2.23247074e-02f, 8.38066712e-02f, -4.95589748e-02f, 5.03417328e-02f, 7.65352370e-03f,
  -5.03155440e-02f, -4.66995984e-02f, -1.53526850e-02f, -5.68729825e-02f, 2.94937678e-02f, 4.25521471e-02f, -3.96386208e-03f, 1.48370471e-02f, 2.36866940e-02f, -1.17309494e-02f,
  6.41542152e-02f, -7.52143204e-01f, -3.09094250e-01f, -2.13411450e-01f, 3.48791443e-02f, -1.78176999e-01f, 4.73500900e-02f, -5.05641520e-01f, -4.60049123e-01f, -3.39136213e-01f,
  -9.23466682e-02f, 1.09458052e-01f, 1.67373627e-01f, -6.46096945e-01f, 3.29717129e-01f, -3.47538441e-02f, -4.87282664e-01f, -6.84544966e-02f, -1.55472592e-01f, -1.48129359e-01f,
  -2.14006230e-02f, -2.95101464e-01f, -6.26871809e-02f, -4.08407420e-01f, -2.37307817e-01f, -1.00325793e-01f, 4.68259364e-01f, 1.88442454e-01f, -1.91915691e-01f, 8.58563408e-02f,
  -2.31641114e-01f, -2.40483463e-01f, -1.18895903e-01f, -8.50307643e-02f, 2.11951975e-02f, 7.86475465e-02f, 2.19646513e-01f, 1.97328582e-01f, 2.41219252e-02f, -2.77751628e-02f,
  1.22715168e-01f, -2.74943132e-02f, -1.87361985e-01f, 1.17486648e-01f, -6.56617656e-02f, -6.63307086e-02f, -1.05996281e-01f, -1.04160821e-02f, -3.15641984e-02f, -6.63676951e-03f,
  -8.36217627e-02f, -2.41168384e-02f, -3.09802778e-02f, 6.20352812e-02f, 2.58600414e-02f, -6.45825788e-02f, 1.03744626e-01f, 1.40547991e-01f, -1.90624353e-02f, -3.17169703e-03f,
  5.82269579e-02f, 9.90839973e-02f, 4.01613023e-03f, -4.62535843e-02f, -8.62190686e-03f, -7.46101588e-02f, 2.13674121e-02f, 2.58971751e-02f, 1.44837080e-02f, 2.34254654e-02f,
  -4.16871253e-03f, -1.35992048e-02f, -2.81453859e-02f, -2.92854998e-02f, 6.68013394e-02f, 8.16524401e-02f, 1.05977580e-01f, -7.28053926e-03f, -5.03032170e-02f, -3.49671170e-02f,
  -9.29621607e-03f, 2.90696435e-02f, 1.08566126e-02f, 3.92625816e-02f, -5.25825620e-02f, 8.28672424e-02f, -7.93956518e-02f, -9.31038894e-03f, 2.40180735e-02f, 4.96462509e-02f,
  -6.21961467e-02f, -1.05057128e-01f, -1.02777183e-01f, 2.89222971e-02f, -4.77177575e-02f, -4.02116328e-02f, -5.80911189e-02f, -1.43417299e-01f, 1.13655487e-02f, -1.03331447e-01f,
  2.85690837e-02f, 6.52031526e-02f, 2.43469495e-02f, 4.44620885e-02f, 2.59515364e-02f, -1.22888021e-01f, 1.12753332e-01f, 6.65407702e-02f, 5.78487292e-02f, -8.75514373e-03f,
  4.03658636e-02f, 1.12371236e-01f, 7.37545788e-02f, -6.07235022e-02f, -1.44561809e-02f, 9.30719078e-02f, 1.89583618e-02f, 5.03427163e-02f, 2.51141377e-02f, 2.81807799e-02f,
  -9.63493466e-01f, 2.29645416e-01f, -2.34726340e-01f, -4.00098443e-01f, 8.68435204e-02f, 1.79055467e-01f, 8.34982321e-02f, -3.49377729e-02f, -4.31027114e-01f, 4.75481451e-01f,
  2.22592518e-01f, -5.23048282e-01f, 2.11563021e-01f, -2.89686583e-02f, -5.08759677e-01f, 7.27603119e-03f, 8.66652355e-02f, -2.53278110e-02f, -2.25597605e-01f, -3.00926846e-02f,
  -1.46171987e-01f, 9.36986357e-02f, 7.36665353e-02f, 3.50661963e-01f, 9.50899869e-02f, -5.67511842e-02f, 2.21848428e-01f, 1.51185244e-01f, 9.20021906e-02f, -6.29050359e-02f,
  -4.13287766e-02f, -1.78572580e-01f, -8.95888582e-02f, -7.11367056e-02f, 6.06745183e-02f, 8.92155245e-02f, 1.60154384e-02f, -7.63967261e-02f, -1.05757438e-01f, -6.12905584e-02f,
  -3.77424546e-02f, -1.29189566e-01f, -3.34003381e-02f, -1.25841089e-02f, -8.61878097e-02f, 7.19603002e-02f, 7.12864175e-02f, 7.71112442e-02f, 2.38712635e-02f, -3.10327932e-02f,
  9.45858657e-03f, 6.39409721e-02f, 3.35721523e-02f, -3.35661694e-02f, -5.18504605e-02f, 4.03836183e-02f, 1.83844678e-02f, -2.72104610e-02f, -4.92203701e-03f, -5.66291250e-02f,
  3.67445759e-02f, -6.30066991e-02f, 3.80212702e-02f, -2.14593764e-02f, -8.67142621e-03f, 5.15352264e-02f, -3.07434462e-02f, 5.11836000e-02f, 2.90423390e-02f, 9.31540430e-02f,
  -3.89626734e-02f, -7.88515210e-02f, -3.60719562e-02f, 2.04057861e-02f, 2.71159150e-02f, -7.27511942e-02f, 2.57672109e-02f, -9.18592978e-03f, -1.38686970e-02f, -1.66129563e-02f,
  -3.14816162e-02f, -9.90631711e-03f, 2.29704026e-02f, 9.09955502e-02f, -4.63721901e-02f, -1.77765358e-02f, 3.00699621e-02f, 5.02022058e-02f, -3.37967009e-04f, -1.35139162e-02f,
  -9.74865705e-02f, -1.24834545e-01f, -3.42834555e-02f, -3.54029052e-02f, 2.64904853e-02f, 1.47106815e-02f, -2.46815011e-02f, -5.22580557e-02f, 2.67205965e-02f, -4.85307239e-02f,
  5.84879480e-02f, 9.03016776e-02f, -1.95211580e-03f, -1.40853440e-02f, 1.87574001e-03f, 1.59494132e-02f, 1.53701119e-02f, -1.08496413e-01f, -1.62292700e-02f, 8.73562321e-02f,
  2.66066454e-02f, 4.02815118e-02f, 2.70664915e-02f, 1.18826717e-01f, 2.88862102e-02f, 1.02217011e-01f, -1.04000330e-01f, 9.49604064e-03f, 2.33183187e-02f, 7.73631483e-02f,
  -4.76175070e-01f, -1.75546240e-02f, -2.24107906e-01f, -5.63825667e-01f, 1.79934859e-01f, -7.66936541e-02f, -3.15309167e-01f, 5.14386743e-02f, -1.05704479e-01f, 2.20713004e-01f,
  3.97241265e-02f, -3.35021555e-01f, 1.87070683e-01f, -5.19185305e-01f, -3.79617989e-01f, -2.75447797e-02f, -4.31203395e-01f, -2.33417079e-01f, -8.79311487e-02f, -9.17754993e-02f,
  -2.05033183e-01f, -1.42689228e-01f, -2.14920089e-01f, 2.40380347e-01f, -2.46496096e-01f, 3.74324508e-02f, 2.78793275e-01f, 1.65729687e-01f, -8.33781809e-02f, -2.59802360e-02f,
  -1.24582730e-01f, 5.97760305e-02f, -5.23772910e-02f, -4.63046432e-02f, 3.13668288e-02f, 3.87946516e-02f, -5.15292361e-02f, -1.01868599e-03f, -5.38923778e-02f, -5.46300113e-02f,
  8.57568532e-03f, -4.01587319e-03f, -1.08234055e-01f, -1.35290129e-02f, 5.00483625e-03f, 3.86118256e-02f, 1.58596262e-02f, 8.33851937e-03f, -9.02640745e-02f, -5.64598851e-02f,
  -9.17804390e-02f, -3.75489667e-02f, 1.26939407e-02f, -3.26722302e-02f, -7.36136083e-03f, -1.26649775e-02f, -3.08264960e-02f, -2.97419522e-02f, 4.43643853e-02f, -9.20845494e-02f,
  2.06351634e-02f, 7.14880526e-02f, -5.79336621e-02f, -1.11193843e-02f, 3.61359082e-02f, -2.04741955e-02f, 3.70159885e-03f, -4.21399344e-03f, -4.60446998e-02f, 2.86308341e-02f,
  4.05750722e-02f, -5.47690056e-02f, -1.76978018e-02f, 2.28544455e-02f, -5.01695946e-02f, -4.77736332e-02f, -3.16427238e-02f, 4.77203466e-02f, -5.49916103e-02f, 4.27731982e-04f,
  1.13381289e-01f, -1.30613218e-03f, -1.74944866e-02f, 8.11283849e-03f, 5.06977700e-02f, 2.44932696e-02f, 2.28596125e-02f, -8.24192464e-02f, 1.81455798e-02f, 1.47578912e-02f,
  1.29117236e-01f, 9.36602876e-02f, 9.93778408e-02f, 8.92345831e-02f, 9.26189218e-03f, 4.23515476e-02f, 1.77525112e-03f, -6.39521852e-02f, -3.61107197e-03f, 5.47081567e-02f,
  9.65687409e-02f, 4.28801216e-02f, 7.18821064e-02f, -6.25014827e-02f, -5.27164638e-02f, 5.63411638e-02f, -8.84766225e-03f, 3.97983193e-02f, 3.24603505e-02f, 8.75270292e-02f,
  7.28002191e-02f, 4.80232686e-02f, -2.19814312e-02f, -2.19499581e-02f, 4.34457930e-03f, 3.87438945e-02f, 9.38813016e-02f, -2.72927396e-02f, 2.03036405e-02f, 5.67394309e-02f,
  -6.89059675e-01f, 6.24130845e-01f, -6.83904886e-02f, -2.79569626e-02f, -3.00835282e-01f, 3.65021139e-01f, 2.33859673e-01f, 3.93515453e-02f, 2.97218561e-01f, 2.93585479e-01f,
  -1.25119731e-01f, -1.20467814e-02f, 6.45205006e-02f, 2.88157254e-01f, 3.53450365e-02f, 3.01653564e-01f, 3.65193635e-01f, 2.22203881e-01f, 1.19754106e-01f, -8.46887454e-02f,
  -1.12474479e-01f, -5.57560027e-02f, -9.10665169e-02f, 2.88886018e-02f, -3.16435754e-01f, -1.79888666e-01f, -2.69388467e-01f, -5.58766574e-02f, -1.31813437e-02f, -8.28721300e-02f,
  -1.58648938e-01f, -2.95806676e-01f, -1.36305287e-01f, -1.62995309e-02f, -1.18892074e-01f, -6.50537908e-02f, -5.02679758e-02f, -4.43499126e-02f, 8.22523329e-03f, -4.22617197e-02f,
  -6.11054376e-02f, -5.35692126e-02f, 5.82754537e-02f, 2.96376646e-02f, 4.30034325e-02f, -4.84086834e-02f, -1.03277778e-02f, -3.48725286e-03f, -5.27334847e-02f, -7.37314224e-02f,
  -5.04742414e-02f, 1.55342082e-02f, -6.52659908e-02f, 7.38711208e-02f, -1.49459792e-02f, 1.03568714e-02f, 5.35710640e-02f, -2.55310591e-02f, -7.22434279e-03f, 3.49852480e-02f,
  3.88697139e-03f, 8.76538977e-02f, 2.00756174e-02f, -7.75689408e-02f, -1.26272617e-02f, -6.02594540e-02f, -4.89468127e-03f, -6.02231734e-02f, 5.00784256e-02f, 2.42838115e-02f,
  -3.60894911e-02f, -8.83886218e-03f, -8.31941236e-03f, 9.25482959e-02f, -1.23009849e-02f, 4.57141325e-02f, -4.50108387e-02f, -1.65155809e-02f, -3.98627669e-02f, 2.62624454e-02f,
  -7.48433080e-03f, 8.28936771e-02f, -3.28676961e-02f, -2.50313617e-02f, 4.56095599e-02f, -3.93190794e-02f, -2.83311307e-02f, 3.38836163e-02f, 3.83786522e-02f, -4.32073586e-02f,
  6.80259913e-02f, 7.52428025e-02f, -6.95735887e-02f, 3.97709245e-03f, 8.57771859e-02f, 9.43230093e-03f, 3.70812118e-02f, -2.85606980e-02f, 3.93383764e-02f, 5.21161817e-02f,
  -1.38716241e-02f, 4.32604291e-02f, -5.83100319e-02f, -1.07079661e-02f, 9.93242562e-02f, -1.89459734e-02f, -2.56264508e-02f, 1.58253442e-02f, -3.32208462e-02f, 1.65556576e-02f,
  2.16998011e-02f, -1.52994366e-02f, 8.30126554e-03f, -4.80633602e-02f, 2.36113500e-02f, -7.05652386e-02f, -5.84641099e-02f, -4.46647480e-02f, -2.30752677e-02f, 7.90138021e-02f,
  3.23614299e-01f, -7.05383062e-01f, 2.79848903e-01f, 2.94295192e-01f, 5.34380734e-01f, 2.44525746e-01f, 2.96692669e-01f, 1.55912086e-01f, 6.37822509e-01f, -6.29202902e-01f,
  -2.66911358e-01f, -2.67675132e-01f, -2.56966412e-01f, -2.00611427e-01f, 4.03851926e-01f, 1.35309964e-01f, 1.28200278e-02f, -1.41945750e-01f, 3.17134827e-01f, -5.03608361e-02f,
  2.92223454e-01f, -3.81738335e-01f, -1.23007879e-01f, -4.42305535e-01f, -1.31368443e-01f, -1.53525695e-01f, -2.78721631e-01f, -6.32104650e-02f, -4.75546688e-01f, -4.60571386e-02f,
  -7.32508078e-02f, -5.83082959e-02f, -4.81783226e-02f, -7.55457506e-02f, -6.58293888e-02f, 2.15415228e-02f, -6.46657273e-02f, 1.02509595e-02f, 7.76818544e-02f, 8.12265500e-02f,
  -6.05670847e-02f, 9.53116361e-03f, -6.69063674e-03f, 2.82653384e-02f, 1.35826096e-01f, -8.45370349e-03f, -1.97705571e-02f, 2.35610846e-02f, 1.84063036e-02f, 4.81883772e-02f,
  5.69298640e-02f, 1.13033298e-02f, 1.01824343e-01f, -1.03264868e-01f, 6.51499480e-02f, 5.94625212e-02f, 2.94403862e-02f, -1.23985726e-02f, -4.58341241e-02f, 7.89166912e-02f,
  3.62753607e-02f, -3.49289179e-02f, 6.90567121e-03f, -4.60005179e-02f, -5.74009530e-02f, -9.27969068e-03f, -6.08458892e-02f, -4.54587713e-02f, 1.71286110e-02f, 5.80852269e-04f,
  1.81556456e-02f, -5.71731962e-02f, 1.26829609e-01f, 5.07262386e-02f, -5.39203435e-02f, 6.09228574e-02f, -1.00359153e-02f, 7.36011332e-03f, 1.66268796e-02f, 1.75087303e-02f,
  -3.39380875e-02f, 4.28825207e-02f, -7.10404366e-02f, 3.44527438e-02f, -3.36069241e-02f, 1.12323528e-02f, -8.37676078e-02f, 3.53082679e-02f, 6.75867423e-02f, -5.51442206e-02f,
  -2.67821014e-01f, -3.85007352e-01f, -1.26139849e-01f, -7.12480024e-02f, -1.12684965e-01f, -1.05831780e-01f, 1.40637131e-02f, -3.29789221e-02f, -3.23415501e-03f, -1.96492970e-02f,
  -3.42043228e-02f, 3.38324271e-02f, -5.95484152e-02f, -8.14404935e-02f, -1.64275810e-01f, -5.53289801e-02f, -5.86962849e-02f, -1.05037093e-01f, -1.30906597e-01f, -1.56676173e-01f,
  -9.70353186e-02f, 4.20188240e-04f, -2.67086532e-02f, -2.42147036e-02f, -6.89205676e-02f, -7.96051472e-02f, -7.16266111e-02f, -3.02329455e-02f, -6.95778802e-02f, -8.82391725e-03f,
  -3.90109718e-01f, 1.97982877e-01f, -2.81785756e-01f, -4.27202970e-01f, -3.91508043e-02f, -6.14186943e-01f, -5.12688100e-01f, 1.38139464e-02f, 2.90827423e-01f, 9.01771411e-02f,
  -8.23372230e-03f, 1.56905577e-01f, 3.99115443e-01f, -3.27622861e-01f, -4.60382253e-01f, 1.09139845e-01f, -5.91668010e-01f, -3.36383045e-01f, 2.23049492e-01f, -3.13992709e-01f,
  -1.92044705e-01f, -7.48540685e-02f, -1.63961828e-01f, 1.81823060e-01f, -3.38266164e-01f, -5.93760572e-02f, -1.53711233e-02f, 2.86034286e-01f, -3.35197926e-01f, 5.97829558e-02f,
  -1.46684453e-01f, 1.92062199e-01f, -1.57794535e-01f, -3.66363563e-02f, -2.67325193e-01f, -1.40780494e-01f, -1.15146019e-01f, -6.05237996e-03f, 3.21448930e-02f, 5.18329293e-02f,
  4.50300500e-02f, 1.33928284e-02f, -6.93546608e-02f, 2.03349128e-01f, 5.16493432e-02f, 5.00825010e-02f, -5.41320108e-02f, -1.03184246e-01f, 4.20931503e-02f, -6.64815959e-03f,
  1.44484732e-02f, -1.05277538e-01f, -1.60122484e-01f, -3.72948311e-02f, -2.70908494e-02f, -1.33181987e-02f, -1.21706679e-01f, -7.62863606e-02f, -1.44592747e-01f, -4.82252240e-02f,
  -1.10294912e-02f, 1.78176239e-02f, -2.42716502e-02f, 3.80848050e-02f, -3.79648358e-02f, 4.78699282e-02f, -5.99896833e-02f, 3.29145864e-02f, 5.79854548e-02f, -4.32447717e-02f,
  -6.19388409e-02f, 2.75980458e-02f, 7.82489106e-02f, -1.04003631e-01f, -9.23969150e-02f, 2.43313499e-02f, -4.66657896e-03f, -3.06704342e-02f, -3.38214673e-02f, -3.74897793e-02f,
  7.75698572e-02f, -8.82732868e-02f, 5.61688058e-02f, 2.81404313e-02f, -5.47289625e-02f, 6.86867069e-03f, -8.33131094e-03f, 4.78222258e-02f, 2.12018332e-03f, -2.16759052e-02f,
  -2.02522725e-01f, -1.81001589e-01f, 5.14551587e-02f, 5.62420003e-02f, -2.75066495e-02f, -6.72906563e-02f, -3.90057787e-02f, -2.28678305e-02f, -1.15929335e-01f, -5.91541231e-02f,
  -9.02385786e-02f, -3.83804701e-02f, -1.21998407e-01f, 3.65686268e-02f, -3.71668697e-03f, -3.57721932e-02f, -5.56984469e-02f, -2.96851359e-02f, -1.43142149e-01f, -5.77653646e-02f,
  -5.26241213e-02f, 8.43686238e-02f, -2.27169357e-02f, -2.34875027e-02f, -3.66095155e-02f, -6.32708222e-02f, -2.98118703e-02f, 9.26118195e-02f, -4.39603291e-02f, -6.95819594e-03f,
  1.80238172e-01f, 3.34233046e-01f, 1.45343021e-01f, 1.25215620e-01f, 1.82397649e-01f, -1.84224471e-01f, -3.06764338e-02f, 1.34793416e-01f, 7.51228184e-02f, 1.68394461e-01f,
  -1.49258554e-01f, 2.55343974e-01f, -2.34220728e-01f, -2.27761492e-01f, -9.50896859e-01f, -6.95317864e-01f, -4.77277011e-01f, -1.58628345e-01f, -8.61956254e-02f, 3.10061388e-02f,
  -1.90246716e-01f, -2.19677135e-01f, -1.24521516e-01f, 2.28750840e-01f, 3.73251230e-01f, 3.67081285e-01f, -6.75745085e-02f, 2.80313760e-01f, 1.17178202e-01f, -1.54074803e-01f,
  -1.42085448e-01f, 1.02238640e-01f, 1.91117942e-01f, -6.87268935e-03f, -4.76472490e-02f, 7.83140212e-02f, -1.25208525e-02f, -4.24205400e-02f, 4.05540280e-02f, 4.34151664e-02f,
  3.18708830e-02f, -5.30528203e-02f, -2.93406248e-02f, -1.85009148e-02f, 2.33428240e-01f, 1.17288195e-01f, 3.59263904e-02f, 1.19842127e-01f, 1.45683572e-01f, 6.39159046e-03f,
  8.93064886e-02f, -4.93651838e-04f, 3.95117439e-02f, 5.92179149e-02f, -1.40703404e-02f, -2.88031418e-02f, -4.29863892e-02f, 2.20127162e-02f, 7.22502396e-02f, -2.81585474e-02f,
  4.76250388e-02f, -3.75798494e-02f, -3.45541760e-02f, 1.79210417e-02f, 4.54050535e-03f, -1.35791320e-02f, 8.55355524e-03f, 3.43791507e-02f, 3.27561125e-02f, 3.87100577e-02f,
  2.56706439e-02f, 1.09127872e-01f, 5.21066263e-02f, -2.71795876e-02f, 5.78823797e-02f, 7.56865144e-02f, -4.42408361e-02f, 4.54905964e-02f, 2.37949146e-03f, 2.39570551e-02f,
  -1.24244364e-02f, -3.30716036e-02f, 4.64479402e-02f, 3.25196311e-02f, -1.03110559e-01f, -2.70745512e-02f, 2.60952413e-02f, 7.85461515e-02f, -2.76330784e-02f, -1.17864739e-02f,
  -2.11569816e-01f, -2.30972871e-01f, 6.26250058e-02f, 8.66193622e-02f, 2.27145348e-02f, -1.01632908e-01f, -6.60385489e-02f, -1.51701691e-02f, -1.11813031e-01f, -7.34458193e-02f,
  4.30017374e-02f, 5.04040681e-02f, -5.37682995e-02f, 9.10950825e-03f, -5.20752855e-02f, -1.05142817e-01f, -4.99480553e-02f, -4.14595455e-02f, 1.52088478e-02f, 5.45427799e-02f,
  1.10441223e-01f, 4.23182100e-05f, 4.11043540e-02f, 2.35487125e-03f, 1.94002893e-02f, 6.05458766e-02f, 2.75026336e-02f, 1.57864504e-02f, -1.10548185e-02f, 2.01528170e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  2.68885374e-01f, 7.19453394e-01f, 4.54891860e-01f, 2.59103209e-01f, 4.82846886e-01f, 3.00000250e-01f, 2.24886745e-01f, 4.71512288e-01f, 5.93328416e-01f, 5.07276893e-01f,
  4.46593881e-01f, 7.09784687e-01f, 1.90865338e-01f, 5.95241070e-01f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -3.76991063e-01f, -3.09575528e-01f, -5.39499879e-01f, -5.36478341e-01f, -4.87032056e-01f, -3.45585704e-01f, 9.99923825e-01f, 1.47889974e-02f, -5.03946096e-03f, -2.37849325e-01f,
  9.38166976e-01f, 3.00443526e-02f, 7.01936543e-01f, -4.08845365e-01f, -3.22225064e-01f, -3.98533314e-01f, 4.47382629e-01f, 1.45017818e-01f, 1.27376509e+00f, -1.46361887e-01f,
  -3.90613884e-01f, 1.13770634e-01f, 7.78984725e-01f, -1.40225897e-02f, -6.37408912e-01f, 1.98940784e-01f, -1.07279778e-01f, -1.37548089e-01f, 5.91227002e-02f, -6.31708503e-01f,
  -3.27866793e-01f, -4.60183471e-01f, -6.62087351e-02f, 4.95375276e-01f, 1.19646037e+00f, -4.84940588e-01f, -3.65250409e-02f, -3.33372831e-01f, -6.06177866e-01f, -5.70931554e-01f,
  8.48090351e-01f, 1.60847511e-02f, -4.44961369e-01f, -1.50653511e-01f, -8.02514032e-02f, -2.18326226e-01f, -2.96986520e-01f, 8.89620483e-02f, 1.93835989e-01f, -2.00834304e-01f,
  -4.42087650e-01f, -3.32540452e-01f, 5.47456332e-02f, -2.38546744e-01f, -3.04532170e-01f, -4.12987113e-01f, -3.59057516e-01f, -4.87370759e-01f, 3.49900365e-01f, 5.94620109e-01f,
  -2.05987364e-01f, -5.86246967e-01f, 1.35522330e+00f, 6.36256635e-01f, 1.67908624e-01f, -4.02213782e-01f, -2.53857911e-01f, -1.40072525e-01f, 1.41775835e+00f, -2.31659546e-01f,
  -4.17448252e-01f, 2.72581756e-01f, -2.31724024e-01f, -4.61089343e-01f, 5.88813305e-01f, 3.89469713e-01f, 3.87379050e-01f, 2.01337889e-01f, 1.07888713e-01f, -3.40961039e-01f,
  5.59766069e-02f, -4.23192501e-01f, -5.47117531e-01f, 8.50378931e-01f, -4.37209874e-01f, 8.34919274e-01f, 1.07643142e-01f, -2.20200881e-01f, -1.08463606e-02f, -2.95049697e-01f,
  -5.39107621e-01f, -1.64973930e-01f, 8.56537938e-01f, 3.15200567e-01f, -2.80739337e-01f, -5.44648290e-01f, -1.05221709e-02f, 6.19351566e-01f, -2.85641223e-01f, -5.23491442e-01f,
  -4.69632745e-01f, 9.88525376e-02f, -6.64089620e-02f, 1.15562581e-01f, 6.72694296e-02f, -4.69205946e-01f, -1.43128827e-01f, -2.86453784e-01f, -4.87252116e-01f, 1.53872204e+00f,
  -1.27011567e-01f, 3.30189675e-01f, -7.92259872e-02f, -8.49808231e-02f, -2.73184001e-01f, 1.44090965e-01f, 5.42772077e-02f, -2.45967507e-02f, -6.20428264e-01f, 1.32744551e-01f,
  -3.34457189e-01f, 1.06401134e+00f, -5.43965399e-01f, 6.03216529e-01f, -2.50344038e-01f, 1.53043047e-01f, 8.49078000e-01f, -4.92751479e-01f, -1.49598479e-01f, 1.72457889e-01f,
  8.96628723e-02f, -2.65375882e-01f, -3.44488591e-01f, 7.86268115e-01f, -4.55662906e-01f, 1.12723196e+00f, 6.23362005e-01f, -1.69001132e-01f, -3.75909239e-01f, -2.21339315e-01f,
  -1.65962487e-01f, -4.23874825e-01f, -3.41241837e-01f, -2.07171485e-01f, 2.15354979e-01f, -5.73814809e-01f, -4.05135363e-01f, -3.52981210e-01f, 6.66793227e-01f, -4.57581669e-01f,
  4.72190589e-01f, -3.34342122e-01f, 1.85625330e-01f, 1.06165016e+00f, -3.19148600e-01f, -4.18294489e-01f, -6.59862936e-01f, 5.93839467e-01f, -3.91172051e-01f, -4.62202370e-01f,
  -5.21205187e-01f, 6.19830549e-01f, -3.87906916e-02f, 3.11378658e-01f, -3.16084385e-01f, -1.63906083e-01f, -3.12657684e-01f, 9.39093903e-02f, 3.47962230e-01f, 5.30431092e-01f,
  7.45731413e-01f, 8.60555470e-01f, -3.87858570e-01f, -5.35916030e-01f, -2.34493390e-01f, 5.01945376e-01f, 3.09830517e-01f, 4.17511165e-01f, -5.44925094e-01f, 9.43194807e-01f,
  -1.50716022e-01f, -9.13156942e-02f, -4.52357471e-01f, 4.00806576e-01f, -4.38462019e-01f, -2.79983640e-01f, -4.51923907e-01f, -5.33251226e-01f, -9.42863822e-02f, -2.56886512e-01f,
  -2.07154915e-01f, 1.17060852e+00f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -7.47617558e-02f, 5.59217036e-02f, -1.51306957e-01f, -2.17856213e-01f, 7.58395270e-02f, 5.16323984e-01f, 3.93044800e-01f, -3.76638979e-01f, -1.24880634e-01f, 3.77951056e-01f,
  -5.98656833e-02f, 2.55153626e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    