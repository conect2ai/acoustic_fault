/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.97412604e-01f, 1.40524432e-01f, 3.04528534e-01f, 5.64821512e-02f, -3.02329302e-01f, -1.30840704e-01f, -2.69236639e-02f, -6.15902320e-02f, 3.00521087e-02f, 9.33715776e-02f,
  2.81349327e-02f, 1.14048049e-01f, 1.10115938e-01f, 8.82858485e-02f, -1.77453145e-01f, 2.85000861e-01f, -1.35209098e-01f, 3.99212465e-02f, 1.59475684e-01f, -5.52038811e-02f,
  1.11185893e-01f, -8.69668424e-02f, 1.38945952e-01f, -9.88861471e-02f, -1.59952372e-01f, -4.69189230e-03f, -2.10630372e-01f, 6.74814805e-02f, -2.23744079e-01f, -9.72437188e-02f,
  -1.25497371e-01f, 1.42307431e-01f, 1.04182139e-01f, 1.35289490e-01f, -1.48854539e-01f, -4.14799526e-02f, -3.32336687e-02f, 7.73897916e-02f, -2.36306507e-02f, 3.47077027e-02f,
  -5.34995608e-02f, -8.24170187e-03f, -1.39845712e-02f, 1.08087108e-01f, 6.80200458e-02f, 3.16133499e-02f, -1.24580972e-02f, 3.05605009e-02f, 1.00442879e-01f, 5.71084693e-02f,
  8.16445425e-02f, 6.44334927e-02f, 5.42453490e-02f, 1.96182374e-02f, -1.93928517e-02f, 4.78910916e-02f, 2.11044457e-02f, -3.92810963e-02f, -8.38070288e-02f, -1.06576523e-02f,
  6.85314387e-02f, 3.93063668e-03f, 4.08585258e-02f, 2.73412317e-02f, -5.28502241e-02f, -3.44474204e-02f, -5.50798560e-03f, 1.34312743e-02f, -9.27923024e-02f, 8.92282929e-03f,
  -9.90126133e-02f, 7.18084676e-03f, -1.76632516e-02f, 3.19424830e-02f, 1.16362795e-02f, 3.18178870e-02f, -1.44626712e-02f, -8.81860107e-02f, -9.00301188e-02f, -3.57608274e-02f,
  -5.25949337e-02f, -4.78342846e-02f, -5.18580340e-02f, -1.10002300e-02f, 1.98098291e-02f, -1.28506683e-02f, 9.56632867e-02f, 5.71180545e-02f, 4.41762507e-02f, -1.16518317e-02f,
  -2.27204293e-01f, -8.42877552e-02f, 1.99814029e-02f, -8.60055536e-03f, -3.22194062e-02f, 3.12656090e-02f, 1.57632127e-01f, -2.61248797e-02f, -3.90532911e-02f, -3.67805082e-03f,
  6.10140376e-02f, -7.06117973e-02f, -1.69418812e-01f, 1.41829727e-02f, -3.31213586e-02f, -2.42096912e-02f, -5.10072149e-02f, -1.54195931e-02f, -7.09838793e-02f, -4.01776433e-02f,
  -4.05360796e-02f, -1.89904720e-02f, -4.96562710e-03f, -8.16786811e-02f, -4.46346104e-02f, -6.05547391e-02f, -9.77381691e-02f, 9.60367844e-02f, -5.42705059e-02f, 4.10493128e-02f,
  1.04525566e-01f, -4.32086550e-02f, -2.43621841e-02f, -3.49541083e-02f, 3.49893004e-01f, 4.78720777e-02f, -4.65284437e-01f, 2.64706433e-01f, -7.28157461e-02f, -7.83070028e-02f,
  1.43068001e-01f, -2.42933631e-01f, -5.42615093e-02f, 2.36307587e-02f, 8.05450752e-02f, -1.41946062e-01f, 9.00796428e-02f, -1.51896268e-01f, 8.40143953e-03f, 1.69466093e-01f,
  6.21545054e-02f, 1.94153100e-01f, 9.85833183e-02f, 2.27480441e-01f, 7.20355138e-02f, 3.67064327e-02f, 1.55573055e-01f, -4.56514657e-02f, 1.21301211e-01f, 4.16038185e-03f,
  1.10283494e-01f, 8.49846378e-02f, -8.89884457e-02f, -6.14017919e-02f, 1.13925368e-01f, -7.42659494e-02f, -4.89471890e-02f, -1.08115464e-01f, 1.01415357e-02f, 6.78189099e-02f,
  -3.52386087e-02f, 8.84565115e-02f, -8.24618712e-03f, -3.32534723e-02f, -2.12138742e-02f, -1.82699971e-02f, 3.10772248e-02f, 3.87617275e-02f, 1.09119089e-02f, 2.46865931e-03f,
  -5.11821732e-02f, 7.62663111e-02f, -8.58271308e-03f, 2.28267652e-03f, 8.29033852e-02f, 4.03243415e-02f, -4.46574166e-02f, 1.42342108e-03f, 4.83784042e-02f, 1.15592005e-02f,
  -3.28429937e-02f, -1.30709782e-02f, -4.05853391e-02f, 3.98743525e-02f, -9.79184546e-03f, 1.45152053e-02f, -7.92388245e-02f, 4.74711531e-04f, -7.60806277e-02f, -4.13377583e-02f,
  9.07834023e-02f, -5.42751253e-02f, 2.07479838e-02f, -4.30571064e-02f, -2.21288223e-02f, -9.53665655e-03f, -1.38694393e-02f, -5.96831441e-02f, 3.17588635e-02f, 5.40903695e-02f,
  2.16194168e-02f, -5.24566285e-02f, -6.15283847e-02f, 9.11466591e-03f, 4.54099998e-02f, -4.46954742e-02f, 5.85210184e-03f, -1.30371219e-02f, -1.08721163e-02f, -3.44890659e-03f,
  6.49820119e-02f, 8.26209635e-02f, 4.00784202e-02f, 2.36012507e-02f, -1.81013029e-02f, 2.06097048e-02f, 1.75778959e-02f, 7.60290250e-02f, -4.93087992e-02f, 5.47063202e-02f,
  4.34013689e-03f, -6.04693852e-02f, 8.56532827e-02f, 4.17620875e-02f, -2.91953199e-02f, 3.13772075e-03f, -1.03620887e-02f, 4.15297039e-02f, 8.15272704e-02f, 7.05178380e-02f,
  8.64209831e-02f, 3.93440574e-02f, -5.10423444e-02f, 6.26527518e-02f, 1.48909781e-02f, 3.25836651e-02f, -1.74844954e-02f, -3.63830440e-02f, 5.21595441e-02f, -7.32429475e-02f,
  6.32781088e-01f, 3.32954302e-02f, 1.47650912e-01f, 4.00616020e-01f, -8.69032219e-02f, 1.24191187e-01f, 1.20549753e-01f, -3.92664261e-02f, 4.24482703e-01f, -1.67729273e-01f,
  -1.10329045e-02f, 1.21089615e-01f, -1.17263138e-01f, 1.98539078e-01f, 1.97142884e-01f, 7.96468928e-02f, 2.79977858e-01f, 7.98728988e-02f, 1.18158787e-01f, 3.34170088e-02f,
  1.02577977e-01f, -3.97568457e-02f, -1.90845914e-02f, -1.99136034e-01f, 9.65754017e-02f, -2.93627270e-02f, -1.33823752e-01f, -1.67683780e-01f, -3.97980921e-02f, -8.84850919e-02f,
  -6.73561245e-02f, -7.99924135e-03f, -6.33066446e-02f, 1.07025374e-02f, -1.44033004e-02f, -6.63043484e-02f, -4.08580676e-02f, -8.90011489e-02f, -3.62759568e-02f, -3.25102080e-03f,
  -1.22217392e-03f, 3.44302617e-02f, 5.04812710e-02f, -4.50979024e-02f, 7.21680596e-02f, 6.65251613e-02f, 6.92881271e-02f, 5.67865409e-02f, -5.18794805e-02f, 4.11523469e-02f,
  1.28278947e-02f, 5.23060001e-02f, 5.86834848e-02f, 5.28903352e-03f, -6.57060510e-03f, 5.00681773e-02f, 1.31893624e-02f, -4.15346473e-02f, 7.86255375e-02f, 2.68381108e-02f,
  -2.23305188e-02f, -2.91898102e-02f, -2.83368751e-02f, 2.45182551e-02f, 2.17303298e-02f, -3.87076512e-02f, -1.12803020e-02f, -6.28332421e-02f, 4.54088561e-02f, 3.39451917e-02f,
  4.00076732e-02f, -5.22289379e-03f, 7.19020888e-02f, 9.49972309e-03f, -3.05003021e-03f, 1.67563800e-02f, -9.03533585e-03f, -3.20047699e-02f, 1.16835721e-01f, 2.49450793e-03f,
  -6.62266016e-02f, 2.61881147e-02f, -3.67963016e-02f, -1.16684511e-02f, -2.93722320e-02f, -2.94798352e-02f, 1.98285212e-03f, 6.30584508e-02f, -1.83096640e-02f, -1.21499235e-02f,
  1.99778378e-02f, -8.19944888e-02f, 3.54322344e-02f, -6.08781241e-02f, -2.31212769e-02f, 3.49945165e-02f, 3.33452299e-02f, 5.58293313e-02f, -2.54466524e-03f, 7.65023055e-03f,
  -9.24154930e-03f, 1.01933267e-03f, -4.89749722e-02f, 1.95785873e-02f, -4.76450920e-02f, -2.13054959e-02f, -6.60057142e-02f, 4.98621305e-03f, -5.86368069e-02f, 3.43881100e-02f,
  3.09719238e-02f, -3.79934460e-02f, 2.56074406e-03f, 3.08431196e-03f, 3.09564471e-02f, -7.45320320e-02f, 3.25230546e-02f, 5.14070876e-02f, -4.50574979e-02f, 1.78966857e-02f,
  -2.32756034e-01f, -1.41278043e-01f, 7.76887015e-02f, -1.65504232e-01f, -2.41136804e-01f, 1.69208273e-01f, -9.09896642e-02f, -1.16614558e-01f, -3.75153571e-01f, -5.57940127e-03f,
  -7.62605220e-02f, 5.12500368e-02f, 4.32524532e-02f, 3.55902389e-02f, 4.85834420e-01f, 1.89055353e-01f, 1.37639165e-01f, -7.74698853e-02f, -1.14857636e-01f, -6.11372739e-02f,
  -4.00051698e-02f, 1.42937511e-01f, 2.81557351e-01f, 4.92888577e-02f, -1.06925160e-01f, -1.11025870e-01f, 2.20163643e-01f, -7.79334679e-02f, 1.80296704e-01f, 9.14173797e-02f,
  9.31413025e-02f, -2.26290271e-01f, -9.64803621e-02f, 6.46121204e-02f, -6.30974583e-03f, -2.83277687e-02f, 3.47929448e-02f, 3.98813747e-02f, -6.87030256e-02f, -1.37386946e-02f,
  3.88708338e-02f, 1.10173963e-01f, 2.01482885e-02f, 4.06100340e-02f, -1.16810210e-01f, -4.01540846e-02f, -4.84994426e-03f, -2.12157723e-02f, -4.21670489e-02f, -2.22633481e-02f,
  3.11034396e-02f, -2.01754831e-02f, -6.75842687e-02f, -1.97668672e-02f, 3.94810699e-02f, -1.00683913e-01f, 4.15416807e-02f, 6.91758916e-02f, 4.94381115e-02f, -3.33543234e-02f,
  -1.38972152e-03f, -5.68133779e-02f, 2.63711400e-02f, 3.81215811e-02f, -7.71784559e-02f, -3.08935624e-02f, 2.11837310e-02f, 7.40173236e-02f, -1.06589094e-01f, -2.10043090e-05f,
  -9.22022685e-02f, -8.31825808e-02f, -6.48776367e-02f, -1.07022613e-01f, 1.89680196e-02f, -2.01514550e-02f, 4.05563749e-02f, -2.80138891e-04f, -6.34035841e-02f, -1.88860241e-02f,
  5.96990064e-02f, -2.28208806e-02f, -4.57201712e-02f, 1.61204301e-02f, 6.36434853e-02f, -8.47004913e-03f, -5.21274172e-02f, -2.15881374e-02f, -5.15635721e-02f, 4.25975844e-02f,
  4.76781465e-02f, 9.45658311e-02f, -5.08551579e-03f, 2.26368755e-02f, -3.30777802e-02f, 7.72142112e-02f, 6.44750893e-02f, -3.89157496e-02f, 2.37683253e-03f, -2.87110265e-03f,
  -1.96788125e-02f, -8.58793929e-02f, 3.30819488e-02f, -2.38262881e-02f, 2.75356844e-02f, 5.59694953e-02f, 4.50666361e-02f, -3.07253990e-02f, 2.77279466e-02f, 1.64363775e-02f,
  3.88304815e-02f, 2.52648741e-02f, -6.22983044e-03f, -3.06186248e-02f, -4.57616895e-02f, 3.47879045e-02f, -9.57924649e-02f, -1.80646218e-02f, 4.78570163e-02f, 2.98819016e-03f,
  -5.29395789e-02f, 1.95742205e-01f, 6.58997297e-02f, 1.61892086e-01f, -1.79904208e-01f, 4.80041742e-01f, 3.85292530e-01f, -1.57134607e-01f, -1.27032213e-02f, 1.32160202e-01f,
  -1.36669949e-02f, 2.21526176e-01f, 4.14003767e-02f, 3.74872684e-01f, 3.46443921e-01f, 1.99924842e-01f, 3.14659089e-01f, 1.53055072e-01f, -1.26351267e-02f, 7.14132041e-02f,
  -1.06637673e-02f, 8.38756487e-02f, 1.19241573e-01f, -1.16704255e-01f, -9.92770866e-02f, -2.05122396e-01f, -2.43211225e-01f, -9.80868936e-02f, 1.63044874e-02f, 8.73668939e-02f,
  2.33946666e-02f, -5.82620502e-02f, -4.34798971e-02f, 3.93489711e-02f, 3.64278220e-02f, 9.81897675e-03f, 4.58136126e-02f, 6.85282145e-03f, -1.53447120e-02f, 4.46459725e-02f,
  2.12170556e-02f, 2.16623154e-02f, 6.12649843e-02f, -5.13006654e-03f, -6.74577132e-02f, -4.23114188e-02f, -4.01258580e-02f, 5.36842570e-02f, 2.16862615e-02f, 8.06990936e-02f,
  -3.64387687e-03f, -3.61185375e-04f, 1.05316423e-01f, 2.63342578e-02f, -2.28722859e-02f, 6.95032477e-02f, 1.13140255e-01f, 5.38129620e-02f, -4.24747653e-02f, 3.75688598e-02f,
  2.09460277e-02f, 1.26398820e-02f, 5.34063997e-03f, -4.39365581e-02f, 7.67598972e-02f, -3.96160707e-02f, -3.47493944e-04f, 4.83840890e-02f, -1.23156801e-01f, 7.72944018e-02f,
  -3.97732370e-02f, -7.11519737e-03f, -2.01934576e-02f, -8.47314149e-02f, 3.22040804e-02f, -3.26296389e-02f, 2.60568578e-02f, -2.60486659e-02f, -3.75277475e-02f, -2.27251984e-02f,
  -9.08586197e-03f, 4.12335508e-02f, 3.50746140e-02f, -3.49333100e-02f, 3.37046534e-02f, -5.95112480e-02f, -4.62346077e-02f, -3.64799835e-02f, -6.33322895e-02f, 8.57415982e-03f,
  1.55454233e-01f, 1.26036510e-01f, -4.44137491e-02f, -1.64681971e-02f, 1.99879743e-02f, -3.36667225e-02f, 8.05694312e-02f, 3.05452123e-02f, -2.00294480e-02f, -3.28903273e-02f,
  -8.02870542e-02f, -2.85621379e-02f, -3.25050130e-02f, -5.38845062e-02f, 3.67717929e-02f, 3.65360081e-02f, 5.47279343e-02f, -8.86786208e-02f, 2.42585298e-02f, -6.30439967e-02f,
  -2.10449006e-02f, -4.36536446e-02f, -4.73526455e-02f, -2.23357067e-03f, 2.59986743e-02f, -7.33759180e-02f, -3.59005667e-02f, -7.59615973e-02f, -2.74491310e-03f, 2.76876185e-02f,
  -3.80066752e-01f, 3.45408380e-01f, 5.62042557e-02f, -5.64393923e-02f, -1.61842078e-01f, 2.59654745e-02f, -4.22705663e-03f, 8.70741606e-02f, -2.99954396e-02f, 2.58216977e-01f,
  5.73299527e-02f, -1.07294068e-01f, 1.65649280e-01f, 7.60735795e-02f, -2.62431681e-01f, 7.44649619e-02f, -3.72474119e-02f, -4.75563742e-02f, -1.37186162e-02f, 1.23967104e-01f,
  -8.63240287e-02f, -3.71401720e-02f, -1.11930788e-01f, 2.64510754e-02f, -9.10993516e-02f, -3.52653791e-03f, -5.84127568e-02f, 1.50253000e-02f, 5.89189380e-02f, -1.44590214e-01f,
  2.13212259e-02f, 9.90554318e-02f, -5.68278320e-02f, -1.33898808e-02f, -6.91947015e-03f, -2.40751226e-02f, -1.14436083e-01f, -3.37324180e-02f, -3.05178929e-02f, 1.64570950e-03f,
  -4.08711657e-02f, -7.87996650e-02f, -1.30003998e-02f, 3.38381603e-02f, 5.95735572e-02f, 5.77872097e-02f, 1.05123043e-01f, -1.80350728e-02f, 1.30797718e-02f, -3.25043052e-02f,
  -4.94251680e-03f, -1.75430961e-02f, -3.89139255e-04f, -1.16081629e-02f, -5.65235838e-02f, -9.28118750e-02f, -1.54227773e-02f, -3.29988338e-02f, 6.04316592e-03f, 4.19121124e-02f,
  6.70118332e-02f, 5.69679961e-03f, 3.12045049e-02f, 1.60893723e-02f, 1.44252628e-01f, -6.81757182e-03f, 1.06191725e-01f, 1.51990028e-02f, -4.86367531e-02f, 4.11722772e-02f,
  -4.94072214e-02f, -4.64755669e-02f, 1.55718634e-02f, -2.75471061e-03f, -9.72251594e-03f, -4.64655496e-02f, -3.01245321e-02f, -5.83446994e-02f, -6.32424504e-02f, -8.75776410e-02f,
  -6.97337762e-02f, -4.62497845e-02f, 5.09284884e-02f, -5.06060496e-02f, 5.38198017e-02f, 1.63621027e-02f, -5.21592833e-02f, 8.06764960e-02f, -1.86951272e-02f, -6.18146509e-02f,
  1.54009223e-01f, 3.59283656e-01f, 6.06364906e-02f, -3.34548741e-03f, 1.13021135e-01f, 3.99745777e-02f, -3.56639400e-02f, -4.80821840e-02f, 7.01740384e-02f, 4.03403714e-02f,
  -7.05764294e-02f, -4.02611569e-02f, 4.82152253e-02f, 2.60194251e-03f, -1.96727552e-03f, -1.83632947e-03f, -8.82563740e-02f, -7.50313252e-02f, -8.13989043e-02f, 3.64071392e-02f,
  3.48801799e-02f, 6.97965026e-02f, -1.63794216e-03f, -4.60503474e-02f, -3.49343568e-02f, 6.29465953e-02f, -3.56018282e-02f, 3.96332256e-02f, 3.41944061e-02f, 2.90984809e-02f,
  2.55201846e-01f, 2.41685003e-01f, 4.00478207e-02f, 1.91339672e-01f, 2.36777499e-01f, -1.49406984e-01f, -1.71788052e-01f, 1.64086208e-01f, 5.41905090e-02f, -1.03272483e-01f,
  -6.54614195e-02f, -9.66703799e-03f, -3.38794142e-01f, 8.94614160e-02f, -1.89247981e-01f, -2.20831141e-01f, 2.04048157e-01f, 1.93799343e-02f, 3.09770182e-02f, 2.53780872e-01f,
  2.06491575e-01f, 1.22430243e-01f, 9.81437266e-02f, 2.49764949e-01f, 1.31797539e-02f, 3.99791412e-02f, -1.05301216e-01f, -9.43225175e-02f, 3.84432226e-02f, -7.87080154e-02f,
  5.78572415e-02f, 1.80207774e-01f, 9.84552037e-03f, -5.74018545e-02f, 7.76829123e-02f, 3.62424180e-02f, 2.23577837e-03f, -1.32270068e-01f, -8.88608024e-02f, -7.51618966e-02f,
  -7.65886009e-02f, -5.06181829e-02f, 1.82388257e-02f, -1.19022779e-01f, -2.39189845e-02f, 1.11647481e-02f, 4.91283126e-02f, -4.55063805e-02f, 5.97853065e-02f, -3.26090455e-02f,
  -4.46107090e-02f, -4.09266092e-02f, -4.93191183e-02f, -6.66247979e-02f, -3.57571319e-02f, 4.16880660e-02f, 2.48491764e-02f, -4.01787646e-02f, 5.76837221e-03f, 1.38945803e-01f,
  -9.02866051e-02f, 6.69623539e-02f, -3.26973088e-02f, -3.22196409e-02f, -1.96798127e-02f, 6.24089651e-02f, -6.74265996e-02f, -3.31508107e-02f, -2.18332335e-02f, 8.60736333e-03f,
  -6.45457730e-02f, 5.65068200e-02f, 7.25503787e-02f, -1.74905341e-02f, 4.33058105e-02f, 4.63124216e-02f, -2.94800214e-02f, -7.10936636e-02f, 1.46539640e-02f, -4.38912213e-02f,
  3.36474143e-02f, 7.39102736e-02f, 3.69002298e-03f, 1.93123650e-02f, 2.27253176e-02f, -7.37127736e-02f, -3.16159949e-02f, 1.39650973e-02f, 1.06254062e-02f, 1.60575658e-02f,
  1.00249700e-01f, 2.92275697e-01f, -2.91153062e-02f, -1.09803230e-02f, -2.34349184e-02f, 1.75740495e-02f, 5.76454885e-02f, 2.45499350e-02f, -4.55464050e-02f, -6.81617763e-03f,
  -1.33530973e-02f, 3.17078009e-02f, 6.46184385e-02f, -4.96933348e-02f, -3.89570966e-02f, 6.30399585e-02f, -2.36779191e-02f, 2.60486212e-02f, 6.96889088e-02f, 1.43639101e-02f,
  3.80516089e-02f, -9.94098280e-03f, -1.16668623e-02f, 9.31543186e-02f, -3.83787453e-02f, 3.13146673e-02f, 7.22974613e-02f, 1.01712870e-03f, -8.93612504e-02f, -3.78469676e-02f,
  3.47057045e-01f, 2.04200566e-01f, 2.99874872e-01f, -6.54959157e-02f, -7.02970177e-02f, -2.59379428e-02f, 7.33620897e-02f, -8.80782083e-02f, -2.10553594e-02f, -1.45031184e-01f,
  -8.65895022e-03f, 1.16243973e-01f, 1.55095711e-01f, -1.36531278e-01f, 3.09419304e-01f, 1.77596435e-01f, -4.87310477e-02f, 4.01862487e-02f, -1.99147817e-02f, 6.24841154e-02f,
  3.95295732e-02f, -9.69074294e-02f, 6.44970089e-02f, -8.09017494e-02f, -6.88074455e-02f, -5.28765097e-02f, -4.62799817e-02f, 9.46847573e-02f, -9.49061438e-02f, 3.03358003e-03f,
  4.35543656e-02f, -1.05311528e-01f, -7.34266192e-02f, 5.43767475e-02f, 4.18460183e-02f, -5.76636083e-02f, 7.42712021e-02f, 2.69247312e-03f, 3.35814053e-04f, 3.58395167e-02f,
  -2.01651198e-03f, -5.34690879e-02f, -6.43014908e-02f, 3.38754579e-02f, 4.57263505e-03f, -2.77823326e-03f, -7.14754388e-02f, -4.11937125e-02f, -5.15924161e-03f, 7.40952743e-03f,
  -9.20405537e-02f, -6.46198466e-02f, -9.19997543e-02f, 3.15431319e-02f, -5.04254829e-03f, -3.21153365e-02f, -1.92605890e-02f, 4.29539233e-02f, 7.49138650e-03f, -9.66645032e-02f,
  1.60424840e-02f, -2.96459720e-03f, -5.09378724e-02f, 5.84286405e-03f, 4.75005284e-02f, -9.28502753e-02f, -7.91959651e-03f, -7.06527662e-03f, 1.12235202e-02f, -1.35993967e-02f,
  3.15116458e-02f, -2.36107185e-02f, 1.29660089e-02f, -8.45261142e-02f, -6.89694658e-02f, -1.04113124e-01f, 3.70566435e-02f, -2.61589997e-02f, -2.45368760e-02f, 2.66514383e-02f,
  -1.71517897e-02f, 6.41577272e-03f, 3.83145697e-02f, -2.83868536e-02f, 5.57734482e-02f, -6.38187106e-04f, -7.48788044e-02f, 1.72519740e-02f, 2.01959908e-02f, 2.29983386e-02f,
  1.98144376e-01f, 1.48709670e-01f, -1.10604182e-01f, -1.80604607e-02f, -2.80339242e-04f, -3.73607986e-02f, -4.16080058e-02f, 3.61950621e-02f, 6.35640025e-02f, -7.95468837e-02f,
  -2.24909838e-02f, -3.90017182e-02f, 1.08715594e-01f, 1.03936046e-02f, 2.26649139e-02f, -1.59575697e-02f, 3.12043093e-02f, -1.16098789e-03f, -3.05543505e-02f, -1.14787854e-02f,
  -6.71199895e-03f, 1.33563196e-02f, -6.62476420e-02f, -4.64439802e-02f, -7.94989392e-02f, -1.94476340e-02f, 2.94951797e-02f, -3.23761702e-02f, -2.01188144e-03f, -3.06812860e-02f,
  2.32317418e-01f, -7.46847913e-02f, 3.36603612e-01f, 1.93791345e-01f, -5.83178224e-03f, -2.25287020e-01f, 8.13688040e-02f, -1.62101779e-02f, 9.36393663e-02f, -1.95801422e-01f,
  -2.29213148e-01f, 2.39542812e-01f, -1.22562744e-01f, -2.17729714e-02f, 2.41249636e-01f, -9.43758041e-02f, 4.78726812e-02f, 7.37736970e-02f, 5.02758101e-02f, 2.04448346e-02f,
  1.30038202e-01f, -2.25498140e-01f, 7.94412643e-02f, -5.00761606e-02f, -8.26016515e-02f, 1.72579408e-01f, -1.87940076e-01f, 1.75745338e-01f, -1.15754031e-01f, 5.03149480e-02f,
  -1.40597299e-01f, 6.30377159e-02f, 2.50050705e-02f, -5.24808317e-02f, -8.94167721e-02f, -2.25515012e-02f, -1.63455103e-02f, 1.07992753e-01f, 5.62102683e-02f, 2.26505492e-02f,
  -1.86896026e-02f, 2.35359855e-02f, 1.38740102e-02f, 8.02769810e-02f, 5.83673874e-03f, 9.98250907e-04f, 2.01212522e-02f, -7.34574422e-02f, 6.38562590e-02f, -3.73511203e-02f,
  2.42323056e-02f, 2.68794093e-02f, 4.64703031e-02f, -2.27883663e-02f, 7.92835429e-02f, 2.35615149e-02f, 3.15650739e-02f, 8.57190639e-02f, -1.86029095e-02f, -2.14489289e-02f,
  8.06447119e-02f, -1.24245444e-02f, 4.97871526e-02f, -3.90129425e-02f, 2.53325161e-02f, -9.51012969e-02f, -9.76086184e-02f, -2.55463216e-02f, 2.83763511e-04f, -4.81683724e-02f,
  -1.20517485e-01f, -5.33173047e-02f, -2.99194306e-02f, -1.13370251e-02f, -2.56878100e-02f, -2.04569846e-02f, -8.05109832e-03f, 6.90581696e-03f, -3.54927480e-02f, -2.48375386e-02f,
  -2.22851546e-03f, -3.40220779e-02f, -4.86626066e-02f, -3.43565550e-03f, 4.10293229e-02f, 1.14751525e-01f, 7.84227997e-02f, 3.20955925e-02f, -3.73117137e-03f, 2.50650924e-02f,
  -2.94101715e-01f, -6.78642467e-02f, -3.19364630e-02f, -1.21733740e-01f, -1.04392003e-02f, -3.65052968e-02f, 8.61244798e-02f, 4.96324487e-02f, -1.80971697e-02f, -1.65189821e-02f,
  1.01084979e-02f, -8.20407718e-02f, 3.14974714e-05f, 2.69244816e-02f, 4.82851677e-02f, -5.08065298e-02f, -2.86449641e-02f, -1.08420793e-02f, -1.19743990e-02f, -6.40569106e-02f,
  -1.10556491e-01f, -5.48680723e-02f, 6.08306490e-02f, -1.15454022e-04f, -2.43563615e-02f, -1.91863701e-02f, 4.83642220e-02f, 3.07050534e-02f, 8.16669723e-04f, 6.99072611e-03f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.53189862e-01f, -4.71885115e-01f, 2.85516858e-01f, 3.70897293e-01f, 3.58915299e-01f, 1.24582760e-01f, 4.11500871e-01f, 5.69549575e-02f, 4.17905092e-01f, -3.62864435e-01f,
  -7.50795826e-02f, -1.35757491e-01f, -1.74930960e-01f, 4.64668451e-03f, 1.72988951e-01f, -4.06040847e-02f, 1.85839739e-02f, -3.21629010e-02f, 2.39621967e-01f, 9.99462754e-02f,
  1.41863525e-01f, -2.92614475e-03f, 9.21074003e-02f, -1.86437652e-01f, 2.48143431e-02f, 2.39172280e-02f, -2.74284959e-01f, 3.04775257e-02f, -1.67904526e-01f, 9.74006876e-02f,
  -8.13576654e-02f, 3.40301171e-02f, -7.68476948e-02f, -1.64997473e-01f, -1.37728825e-02f, -8.98382440e-02f, -6.11918420e-02f, 9.57398396e-03f, 1.39820874e-01f, 6.93953112e-02f,
  1.77727453e-02f, 2.99296584e-02f, 7.39712492e-02f, 1.09560847e-01f, 5.23041748e-02f, 3.74945253e-02f, 1.46841660e-01f, -2.40143780e-02f, 8.33440199e-03f, 1.66649057e-03f,
  6.37589693e-02f, -2.26078294e-02f, -5.32401800e-02f, -8.30555633e-02f, -2.59037912e-02f, 1.13686863e-02f, 6.51258975e-02f, -9.00189728e-02f, -5.45358211e-02f, 1.00116804e-01f,
  -1.01099283e-01f, 6.73280237e-03f, 6.29658103e-02f, 1.38785653e-02f, -2.35756673e-02f, 5.78451864e-02f, 1.21261319e-02f, -4.48310338e-02f, 4.48223874e-02f, -2.78895311e-02f,
  -2.10365150e-04f, 2.17956435e-02f, -3.67222331e-03f, 1.29985241e-02f, 5.68780042e-02f, 5.67468989e-04f, -1.03696764e-01f, -1.15282565e-01f, -2.04968583e-02f, 4.90291715e-02f,
  9.64992195e-02f, 7.12608313e-03f, -9.19332728e-02f, 1.03387013e-01f, 3.28237228e-02f, -7.31801465e-02f, -9.43168104e-02f, -8.09810832e-02f, 7.54333213e-02f, -4.98967394e-02f,
  -4.32654440e-01f, -3.40192735e-01f, -1.59452662e-01f, -1.14316203e-01f, -6.67971447e-02f, -8.26385692e-02f, 7.37737492e-02f, -1.19560800e-01f, -7.86420479e-02f, 7.11043552e-02f,
  -5.51891141e-02f, 1.31514145e-03f, -8.41112882e-02f, 6.28187060e-02f, -5.38624860e-02f, 5.68818450e-02f, -4.74508666e-02f, -1.86952919e-01f, -1.74453914e-01f, -1.23867795e-01f,
  -5.73846251e-02f, 2.53197718e-02f, 4.67941090e-02f, 5.31331114e-02f, -1.44231794e-02f, -1.65982712e-02f, -4.89147939e-02f, -4.93915081e-02f, -1.61575247e-02f, 1.23849269e-02f,
  1.48401670e-02f, -1.92761794e-01f, 1.42601863e-01f, -3.63301963e-01f, 1.78816356e-02f, 1.91457465e-01f, 8.71649459e-02f, -2.53829986e-01f, -1.16590448e-01f, -3.98560196e-01f,
  -1.85153067e-01f, -7.69403903e-03f, 3.71048212e-01f, -3.48488390e-01f, 6.93038821e-01f, 3.24969351e-01f, -9.89447385e-02f, -5.81812896e-02f, 5.13815023e-02f, -3.16216022e-01f,
  1.70197431e-02f, -3.08023632e-01f, 1.16698280e-01f, -2.99800724e-01f, -2.80291438e-01f, -2.62257159e-01f, -1.91503569e-01f, 1.44714072e-01f, -3.10978323e-01f, 6.22666590e-02f,
  -2.29153968e-02f, -9.92236063e-02f, -4.04310748e-02f, 8.21807012e-02f, -1.92889813e-02f, 9.00979564e-02f, 3.23169678e-02f, 9.46632624e-02f, 5.23718931e-02f, -2.59038657e-02f,
  -4.51652966e-02f, 8.80285632e-03f, -1.54564157e-01f, 1.42832343e-02f, -1.50004089e-01f, -9.39313844e-02f, -1.84661523e-03f, 6.03317004e-03f, -2.72619296e-02f, 3.17476466e-02f,
  7.31698796e-02f, 4.29316312e-02f, -1.03835642e-01f, -9.02026743e-02f, -3.95567389e-03f, 1.07420888e-02f, 8.15041177e-03f, 9.45288166e-02f, 8.99901148e-03f, -2.58826576e-02f,
  -2.88551077e-02f, 1.71638921e-01f, 6.02361336e-02f, -9.53213423e-02f, 1.44043900e-02f, -7.11807087e-02f, -1.40079735e-02f, 8.71208776e-03f, -5.14569413e-03f, -5.03918342e-02f,
  -9.10299495e-02f, -4.50654812e-02f, -4.62885052e-02f, 3.04872897e-02f, -6.17742278e-02f, -9.89338458e-02f, 2.40866095e-02f, 2.21003313e-02f, -9.17126313e-02f, 6.10153824e-02f,
  -6.24736659e-02f, -5.15832519e-03f, 2.11395454e-02f, -1.15067646e-01f, -4.63679023e-02f, 3.91272046e-02f, -4.79072146e-02f, 2.94011980e-02f, -8.91330373e-03f, 1.49006903e-01f,
  6.50437996e-02f, -1.37063369e-01f, -1.27846468e-02f, 9.77953617e-03f, 4.48003039e-02f, -3.84008400e-02f, 3.46727446e-02f, -9.40021276e-02f, -2.47013681e-02f, 8.33553914e-03f,
  -1.75535291e-01f, -4.35101390e-02f, 2.57091336e-02f, -2.96297092e-02f, 2.02343427e-02f, -4.61937897e-02f, -3.88555825e-02f, -1.80788524e-02f, -1.31922951e-02f, -2.80979951e-03f,
  -2.33018342e-02f, 2.14620121e-02f, 8.80430490e-02f, -1.00704513e-01f, -1.31394044e-01f, -4.56924215e-02f, 1.39106819e-02f, 6.20644465e-02f, 3.46471518e-02f, -1.33570714e-03f,
  -6.38752639e-01f, 3.72994781e-01f, -1.53908849e-01f, 3.05159807e-01f, -4.10094082e-01f, 2.46746436e-01f, 2.61073679e-01f, -7.89508745e-02f, -1.18566990e-01f, 3.26230645e-01f,
  1.27196044e-01f, -2.24048495e-01f, 1.25694081e-01f, 3.73707414e-01f, -4.13182490e-02f, 4.07698214e-01f, 3.30647945e-01f, 1.30974561e-01f, -5.53348325e-02f, -8.26526582e-02f,
  4.85789701e-02f, 1.32250369e-01f, 3.70291650e-01f, -2.11034287e-02f, -9.69542190e-02f, -1.97943509e-01f, 5.94427995e-02f, -1.95373446e-01f, 4.88221534e-02f, -7.01151565e-02f,
  -1.27316281e-01f, -3.07907879e-01f, -5.80779575e-02f, -1.39628053e-01f, -9.29473415e-02f, -7.21600652e-02f, -5.14019355e-02f, -6.99810684e-02f, -7.02111796e-02f, -4.62934598e-02f,
  -8.68899226e-02f, -1.81835771e-01f, -9.06699861e-04f, -1.30364805e-01f, -1.84924960e-01f, -2.52166931e-02f, 7.92138726e-02f, 6.92880154e-02f, 1.01893237e-02f, 3.52676250e-02f,
  -4.38284762e-02f, 1.39379576e-02f, 4.01715189e-02f, 1.59531265e-01f, 5.27031906e-02f, 4.86003421e-02f, 1.16306290e-01f, -5.27432151e-02f, -3.24180312e-02f, 2.40622070e-02f,
  -1.37468293e-01f, -7.90849179e-02f, -1.07441070e-02f, 1.04186889e-02f, 8.43521282e-02f, 6.66861385e-02f, 1.51487533e-02f, -4.44626138e-02f, 7.42924139e-02f, 9.55003798e-02f,
  -2.70251893e-02f, 1.65875759e-02f, -4.61033136e-02f, 1.52793810e-01f, 6.19995221e-03f, 4.68262658e-02f, 1.85996834e-02f, -8.01452324e-02f, 1.06292911e-01f, -1.05177360e-02f,
  6.51297569e-02f, -7.06173033e-02f, 5.88521063e-02f, 5.96736260e-02f, -2.66422853e-02f, 4.26482856e-02f, -1.88953727e-02f, 9.08480808e-02f, 6.54024184e-02f, -1.39251336e-01f,
  -6.89874291e-02f, -1.35345116e-01f, 7.28998408e-02f, -1.22650363e-01f, -3.12425829e-02f, 1.02050370e-02f, -2.43868325e-02f, -1.11298198e-02f, -7.52316741e-03f, -6.49511814e-02f,
  -4.80688363e-02f, 3.27459164e-02f, -6.29382506e-02f, -7.53702074e-02f, -6.73363451e-03f, 1.59097046e-01f, 3.66502330e-02f, -2.89784018e-02f, 1.04268864e-01f, -3.85975279e-02f,
  1.19026795e-01f, -7.31262937e-02f, -1.95473209e-02f, 4.01916131e-02f, 3.85720916e-02f, 2.52315737e-02f, -1.36523649e-01f, -5.83754443e-02f, -1.08796790e-01f, -1.29748471e-02f,
  8.81931093e-03f, 1.11271039e-01f, 1.08439401e-01f, 4.75260049e-01f, -1.13402896e-01f, -3.38570327e-01f, -2.07587853e-01f, 1.50013074e-01f, -1.59041390e-01f, -1.42919153e-01f,
  3.18730593e-01f, 3.96171287e-02f, 6.77247345e-03f, 4.98707145e-01f, 5.18512309e-01f, -7.80266384e-03f, 3.28844190e-01f, -1.92966573e-02f, 1.40147045e-01f, 2.57631004e-01f,
  2.48639539e-01f, 3.96964192e-01f, 3.59501332e-01f, 2.47053042e-01f, 2.04406157e-01f, 2.95339495e-01f, 4.52701330e-01f, 1.30177453e-01f, 4.12577450e-01f, 1.20814599e-01f,
  -2.08586112e-01f, 9.14295986e-02f, -7.17062317e-03f, -1.62470892e-01f, 1.23166248e-01f, -1.17992364e-01f, -9.08549652e-02f, 1.35005444e-01f, 8.49272832e-02f, 9.28997025e-02f,
  -7.72967413e-02f, 2.24052500e-02f, 8.67599845e-02f, 1.73249654e-03f, -1.07542992e-01f, 2.86691003e-02f, -3.52040865e-02f, 1.20138109e-03f, -5.01926802e-02f, -2.58392673e-02f,
  -7.09393173e-02f, -3.41050997e-02f, 2.23908611e-02f, 3.02928351e-02f, 6.68982267e-02f, -4.68241125e-02f, -6.57128245e-02f, -6.45776391e-02f, -7.60782734e-02f, 4.32791486e-02f,
  -6.38154745e-02f, 2.71999184e-02f, -7.68423900e-02f, 2.95943450e-02f, 9.61722285e-02f, 3.53106111e-02f, -1.56011600e-02f, 2.26030052e-02f, 3.87397185e-02f, 2.46723052e-02f,
  2.50745509e-02f, 6.17549568e-02f, -1.04434520e-01f, -3.90100367e-02f, -1.99598838e-02f, -5.41513078e-02f, 2.30437312e-02f, 5.71053661e-02f, -4.77177538e-02f, 5.26214540e-02f,
  2.81201769e-02f, 4.27443497e-02f, -1.93569381e-02f, -6.89854398e-02f, -6.10128231e-02f, 2.29431670e-02f, 1.62269697e-02f, -2.90026292e-02f, 7.13305920e-02f, 2.69814003e-02f,
  -3.79607119e-02f, 3.32862079e-01f, -3.17292586e-02f, -1.71351600e-02f, -6.99643837e-03f, 1.08014867e-02f, 9.94939543e-03f, 1.73507500e-02f, 8.30038190e-02f, 8.17828625e-02f,
  8.59304611e-03f, -4.89837565e-02f, -8.65182281e-02f, 1.89228375e-02f, 8.78846347e-02f, -3.35556865e-02f, 7.48736933e-02f, 7.71942921e-03f, 5.91499023e-02f, 1.32975057e-01f,
  1.52699826e-02f, 1.32309170e-02f, 2.62056012e-02f, -5.67420125e-02f, -3.48248817e-02f, -1.05871521e-02f, -3.96274365e-02f, -9.40391570e-02f, 6.44340664e-02f, 6.76945671e-02f,
  2.98342824e-01f, 7.31470644e-01f, 5.64796448e-01f, 4.91483212e-01f, -2.65406698e-01f, -3.72076780e-01f, -1.94679528e-01f, 2.08647460e-01f, 4.56669740e-02f, 1.39355347e-01f,
  -2.21447617e-01f, 5.50132692e-01f, -1.91157341e-01f, 2.95334160e-01f, -3.37390035e-01f, -2.44522810e-01f, 1.03311524e-01f, 1.51178420e-01f, 4.14323900e-03f, 3.30472082e-01f,
  7.22301379e-02f, -2.30541959e-01f, 1.67998150e-01f, -5.07589690e-02f, 3.17494392e-01f, 2.87317842e-01f, -7.06441253e-02f, -8.69486630e-02f, 2.40082264e-01f, -1.35497615e-01f,
  -1.18716426e-01f, 6.49378449e-02f, 1.92009509e-01f, -2.52794269e-02f, 1.38838291e-02f, -4.86856699e-02f, 2.17400268e-02f, -1.14138335e-01f, -4.71710116e-02f, 5.41511513e-02f,
  2.59718578e-02f, -7.61648566e-02f, 7.47969374e-02f, 1.91691779e-02f, 3.69516537e-02f, 1.22103557e-01f, -6.27194671e-03f, 8.58650357e-02f, 1.33546725e-01f, 1.50624439e-01f,
  1.93475679e-01f, 9.45543349e-02f, 1.45035116e-02f, -1.72660518e-02f, 9.83626842e-02f, -5.83922602e-02f, 4.37713079e-02f, 1.90402027e-02f, 6.98570162e-02f, 1.40872421e-02f,
  -8.25725347e-02f, 5.41354343e-03f, 1.56512503e-02f, 1.06412485e-01f, 3.24081816e-02f, -1.31894331e-02f, 4.77325134e-02f, -1.56607553e-02f, -4.45328802e-02f, -4.81063165e-02f,
  -7.47221112e-02f, 1.03829242e-01f, -7.37802386e-02f, 3.84066701e-02f, 6.26004562e-02f, 6.24781102e-02f, -3.98680940e-02f, -1.47152180e-02f, 3.92545126e-02f, 7.11545050e-02f,
  -3.90429124e-02f, -1.63171038e-01f, 7.03132078e-02f, -1.73629227e-03f, -1.67108506e-01f, 1.89890601e-02f, 9.28217098e-02f, 1.33268669e-01f, -4.12396677e-02f, -8.17377027e-03f,
  -8.30885172e-02f, 7.01872408e-02f, 1.09504998e-01f, 4.96152509e-03f, -2.89411098e-02f, 2.92444117e-02f, -3.66827883e-02f, 1.29336685e-01f, -2.79801730e-02f, -7.83045068e-02f,
  -6.10266021e-03f, -4.11843657e-02f, -4.43411097e-02f, -6.83208257e-02f, -8.55065659e-02f, 1.14165477e-01f, -4.35785670e-03f, -2.22287551e-02f, 1.21620391e-02f, 8.64518806e-02f,
  5.94840646e-02f, -5.45290150e-02f, -4.42473628e-02f, -7.33569562e-02f, -1.29586663e-02f, -7.22340047e-02f, 5.96451536e-02f, 3.47078145e-02f, 2.40213256e-02f, -1.11029744e-02f,
  -1.06347784e-01f, 8.68550409e-03f, -3.08963984e-01f, -2.75117815e-01f, -3.93192051e-03f, -4.60871994e-01f, -4.25940067e-01f, -2.11526096e-01f, 4.67040986e-02f, -1.82322972e-02f,
  -6.81967884e-02f, 6.53224736e-02f, 3.02838534e-01f, -2.72254884e-01f, 5.28875552e-02f, 2.60354757e-01f, -3.93573016e-01f, -1.93190038e-01f, 1.71714500e-01f, -1.65780336e-01f,
  -8.66243616e-02f, 5.45630865e-02f, -7.92151988e-02f, 7.12906942e-02f, -2.53298312e-01f, -6.69905171e-02f, 8.11491758e-02f, -8.96228850e-02f, -2.48454422e-01f, -1.34041794e-02f,
  -8.02248567e-02f, -7.89132118e-02f, -1.30809918e-01f, -1.79758519e-01f, -2.13523656e-01f, -5.13523929e-02f, -1.53042063e-01f, -8.38388689e-03f, -1.39940926e-03f, -6.55185357e-02f,
  8.72208402e-02f, 7.73471892e-02f, 3.77449878e-02f, 1.35752425e-01f, -3.67149152e-02f, 3.50204892e-02f, 1.69579238e-02f, -1.18884690e-01f, -4.44358289e-02f, 2.58950405e-02f,
  -1.20063061e-02f, -8.17295983e-02f, -1.40753418e-01f, 8.09610114e-02f, -8.16093013e-02f, -7.69531280e-02f, -6.74719289e-02f, 7.66604382e-04f, -1.01758033e-01f, -3.58171538e-02f,
  -6.06162772e-02f, 3.33083160e-02f, -4.75962423e-02f, 6.50058463e-02f, -6.89863879e-03f, -4.62940522e-02f, 1.60932355e-02f, 5.36405370e-02f, -6.45130724e-02f, 2.70408094e-02f,
  8.01393464e-02f, -3.80510353e-02f, 3.96776386e-02f, -3.96137908e-02f, -2.02456582e-02f, 4.53962665e-03f, 3.32050696e-02f, -1.42442686e-02f, 1.19470824e-02f, 2.19719741e-03f,
  1.21559547e-02f, -6.36586621e-02f, 6.48729950e-02f, 1.87399797e-02f, -1.30942270e-01f, 9.09281746e-02f, 2.00246298e-03f, -6.42240187e-03f, -3.99219394e-02f, -2.17602551e-02f,
  -4.74184826e-02f, -3.77967417e-01f, -2.70255376e-02f, -6.88102990e-02f, -3.21944728e-02f, -5.65343536e-02f, 6.38874322e-02f, 9.07547921e-02f, -2.25472584e-01f, -1.01158574e-01f,
  -2.90956199e-02f, -2.73482502e-02f, -1.87304653e-02f, 9.73274857e-02f, 1.01540715e-01f, 4.31516282e-02f, -3.93842123e-02f, 2.91091017e-02f, -2.12414920e-01f, -2.06807796e-02f,
  -6.08230941e-02f, 9.57620367e-02f, 6.37727156e-02f, 2.14769524e-02f, -1.38680646e-02f, -4.72232327e-02f, -1.47984177e-02f, -3.10997218e-02f, 5.98359155e-03f, -1.84588376e-02f,
  1.33531496e-01f, 1.44908935e-01f, -6.87748790e-02f, 1.40550807e-01f, -3.07650417e-01f, -2.89320827e-01f, -1.38172731e-01f, -6.47296896e-03f, 3.90670359e-01f, -1.22679891e-02f,
  -2.90610045e-01f, 2.47528076e-01f, -3.79022956e-02f, -2.51460016e-01f, 1.95969284e-01f, 1.25517204e-01f, 5.84329618e-03f, 2.57153455e-02f, 1.85516372e-01f, -1.17478937e-01f,
  2.24445939e-01f, -2.08535656e-01f, -1.67611554e-01f, -2.26668343e-01f, -3.13564807e-01f, 1.34160761e-02f, -1.09841779e-01f, -1.92899019e-01f, -3.07567835e-01f, -4.61059826e-04f,
  -9.16563943e-02f, 2.80653268e-01f, -5.77357747e-02f, 1.25165790e-01f, 1.76717935e-04f, -1.30691350e-01f, -5.89085519e-02f, -8.35063085e-02f, 2.78441533e-02f, -3.64865735e-02f,
  3.92832309e-02f, 5.78588210e-02f, 8.08275398e-03f, -1.62658006e-01f, -5.30359484e-02f, -1.48906395e-01f, 1.05037481e-01f, -7.63048902e-02f, 3.16728652e-02f, -1.40555337e-01f,
  -7.73095191e-02f, 1.35068158e-02f, -4.12621461e-02f, 1.39016762e-01f, 1.84251845e-01f, 6.71797469e-02f, -2.37240288e-02f, -4.44803573e-02f, 9.70985442e-02f, 1.55201778e-01f,
  8.25641826e-02f, -6.80711791e-02f, -9.45254341e-02f, -1.76445141e-01f, 3.12361568e-02f, 8.55339691e-02f, 3.36670205e-02f, -8.40664729e-02f, 1.52211428e-01f, -1.11550868e-01f,
  -5.54992519e-02f, -4.24422622e-02f, -1.77676380e-02f, -6.80672750e-02f, 7.38699920e-03f, 6.11524880e-02f, 3.61582153e-02f, -4.55792621e-02f, 1.34229317e-01f, -8.46390128e-02f,
  -2.32340544e-02f, 2.48431526e-02f, 6.01270050e-03f, -1.13342553e-01f, -6.25104904e-02f, 2.53416365e-03f, -7.34235421e-02f, -2.23329160e-02f, -7.67666399e-02f, -2.00518891e-01f,
  4.04640008e-03f, 3.63061041e-01f, 1.19609006e-01f, 1.92185387e-01f, 5.38313016e-02f, 4.30026054e-02f, -2.60994695e-02f, 1.15054231e-02f, 2.09387839e-01f, 3.90657876e-03f,
  -3.45861390e-02f, 3.48117240e-02f, 1.18260570e-02f, -8.94823149e-02f, 1.14337109e-01f, -4.19582501e-02f, 8.89447704e-03f, 1.47254989e-01f, 6.07872605e-02f, 3.68110538e-02f,
  -3.61593836e-03f, 3.48159373e-02f, 6.87408671e-02f, 6.91599771e-02f, -3.61546949e-02f, 1.38768060e-02f, -2.45048087e-02f, 1.29679680e-01f, -1.18691064e-01f, 7.59669244e-02f,
  -5.70649207e-01f, 3.02561313e-01f, -2.95332849e-01f, 2.59135738e-02f, 4.93252203e-02f, 3.52127343e-01f, 4.68059629e-01f, 1.84431702e-01f, 4.90756243e-01f, 4.12554711e-01f,
  1.47033870e-01f, -6.99049681e-02f, 1.40523121e-01f, 2.66304821e-01f, -2.07079142e-01f, 2.22067714e-01f, 1.57481506e-01f, 1.90606132e-01f, 1.46453291e-01f, 1.00349985e-01f,
  -6.96558431e-02f, 2.03401253e-01f, -3.32385063e-01f, -3.17953061e-03f, -7.33589455e-02f, -1.48690313e-01f, -1.34384602e-01f, -1.04036413e-01f, -5.30099794e-02f, 1.04428492e-01f,
  -8.53459314e-02f, 1.51304975e-01f, -2.07873926e-01f, -1.75706465e-02f, -2.59890780e-02f, -8.79538953e-02f, -3.50129232e-02f, -7.63383657e-02f, -1.62338987e-01f, 9.20741111e-02f,
  -6.91148592e-03f, -2.24637222e-02f, 1.66573912e-01f, 1.02223912e-02f, 1.58427432e-02f, -5.57860062e-02f, -1.35024518e-01f, -7.93909878e-02f, 8.57296735e-02f, -7.04335123e-02f,
  -1.11588344e-01f, -1.09018154e-01f, -6.38421103e-02f, 9.58898291e-02f, -1.40731111e-01f, 4.10518274e-02f, 3.61431651e-02f, -7.16041103e-02f, 4.36249655e-03f, 6.36257604e-02f,
  3.40861604e-02f, 1.47323161e-01f, 4.91569117e-02f, -4.18134369e-02f, -2.53167190e-02f, -9.57378671e-02f, -5.68287373e-02f, -5.85645474e-02f, -9.28649977e-02f, -6.01022579e-02f,
  1.36765108e-01f, -5.01212254e-02f, 3.99159193e-02f, -5.46978228e-02f, 4.55496795e-02f, 4.04738821e-03f, -9.22208279e-02f, 5.50596938e-02f, 3.54019739e-02f, -7.08002888e-04f,
  7.64712766e-02f, 1.12865068e-01f, -1.36063192e-02f, 9.65370163e-02f, -1.10688107e-03f, -7.70605281e-02f, 1.87914759e-01f, -5.19556366e-02f, -1.98981427e-02f, -6.86949072e-03f,
  3.98060203e-01f, 5.22847056e-01f, 6.27534166e-02f, 3.15624215e-02f, 8.60623792e-02f, -7.41233863e-03f, 5.62999994e-02f, -2.91050449e-02f, 1.29575029e-01f, 7.37833530e-02f,
  -5.95567748e-02f, 2.65092533e-02f, -3.57111357e-02f, -3.20133269e-02f, -1.67503022e-02f, 1.40700638e-01f, 8.09551254e-02f, 7.73928985e-02f, 3.37678716e-02f, -6.44142702e-02f,
  -1.33124396e-01f, 4.00735587e-02f, -1.63050033e-02f, -2.52822833e-03f, 2.97165047e-02f, 1.54519379e-02f, 8.07980224e-02f, -1.36447102e-01f, -9.10084397e-02f, 1.19829781e-01f,
  4.08819884e-01f, -3.24457705e-01f, -4.02207762e-01f, 9.87376645e-02f, 2.57888108e-01f, 2.06925139e-01f, 3.28405425e-02f, -6.62337318e-02f, -1.40980259e-01f, -1.05418459e-01f,
  2.85686970e-01f, -1.14530459e-01f, -3.69801044e-01f, 2.12410465e-01f, 4.70053971e-01f, -3.47504914e-01f, 2.53087819e-01f, 1.00059420e-01f, -1.27852008e-01f, 7.18289614e-02f,
  1.28895521e-01f, 5.38422942e-01f, -1.78740129e-01f, 7.49957487e-02f, 1.46081746e-01f, -1.90841094e-01f, 1.98449761e-01f, -2.67841339e-01f, 1.47623301e-01f, 1.20876782e-01f,
  7.96576887e-02f, -3.18316109e-02f, 4.40150760e-02f, -4.57386784e-02f, -2.11944133e-02f, 5.18590845e-02f, 8.23008269e-03f, 2.29261313e-02f, 5.60798589e-03f, -7.85383061e-02f,
  -9.55442935e-02f, 2.87767244e-03f, -2.06338130e-02f, 2.64879763e-02f, 2.72676468e-01f, 4.02860017e-03f, -7.12721273e-02f, -1.03006080e-01f, -8.94544199e-02f, -5.98782972e-02f,
  -1.44721940e-01f, -1.00546159e-01f, 6.27413392e-02f, -7.83030093e-02f, -4.95922007e-02f, 2.94700693e-02f, -1.41784325e-01f, -7.54488111e-02f, -8.48227218e-02f, 6.91069663e-03f,
  8.59311745e-02f, -7.08623007e-02f, 1.14421295e-02f, -2.64588334e-02f, 6.96417540e-02f, 5.74172698e-02f, 1.53399035e-01f, 3.57462279e-02f, 3.28032412e-02f, 9.40862149e-02f,
  -4.50520627e-02f, 6.69043511e-02f, -9.07027200e-02f, 1.11802638e-01f, 8.41986239e-02f, -5.98082244e-02f, -8.07809550e-03f, 4.34279963e-02f, -4.46715392e-02f, 3.60112898e-02f,
  -1.06143937e-01f, 1.51980305e-02f, -2.38746572e-02f, -1.26082459e-02f, -6.34455234e-02f, 1.20252289e-01f, 1.52912825e-01f, 2.59699188e-02f, -4.25089858e-02f, -7.14715943e-02f,
  2.96317451e-02f, -1.28131464e-01f, -6.89206049e-02f, 3.54923792e-02f, -9.57564712e-02f, 9.86588821e-02f, 2.37046788e-03f, 1.80876646e-02f, 5.96808568e-02f, -9.16036719e-04f,
  6.80150837e-03f, -9.19574499e-03f, -1.06526613e-01f, 7.13270456e-02f, 1.83400363e-02f, 7.70094991e-02f, -8.78939331e-02f, -3.21181081e-02f, 2.52812896e-02f, -2.61789514e-03f,
  -4.04682197e-03f, -5.17248511e-02f, -2.75744144e-02f, -6.32005930e-02f, 8.87852386e-02f, -5.91887161e-02f, 2.76207067e-02f, -1.51928635e-02f, 1.19722239e-03f, -2.46701799e-02f,
  4.35938537e-01f, -1.72978621e-02f, 6.66992739e-02f, -1.50910150e-02f, 5.73376566e-02f, 2.12988436e-01f, 2.58560359e-01f, -3.41489345e-01f, -5.14211118e-01f, 1.19253702e-01f,
  -4.87329699e-02f, 1.64910823e-01f, -2.78744083e-02f, -2.74784356e-01f, -3.19688439e-01f, -3.67612898e-01f, -6.95608556e-02f, 3.98847908e-02f, -2.05169916e-01f, 2.00763628e-01f,
  -1.38449326e-01f, -1.05062172e-01f, -1.06761858e-01f, -8.17301571e-02f, 2.47896984e-01f, 2.70205975e-01f, 1.47059023e-01f, 1.84849694e-01f, 2.72057772e-01f, -1.52163487e-02f,
  -7.86022693e-02f, -1.62123770e-01f, -1.17700268e-02f, -4.22086241e-03f, 9.59956273e-02f, 1.10657848e-01f, 2.18670502e-01f, 6.45445138e-02f, -3.37290391e-02f, -1.15363710e-02f,
  1.89979285e-01f, 7.06616417e-02f, -9.41344798e-02f, 2.21591759e-02f, 7.01447725e-02f, -2.98044067e-02f, -6.40080795e-02f, 9.63773578e-03f, -6.19598217e-02f, 8.66687149e-02f,
  4.41394523e-02f, 9.33845714e-02f, 1.17841363e-01f, 5.81246540e-02f, 1.04219103e-02f, -8.47347379e-02f, 1.23178244e-01f, 1.99033365e-01f, 1.60651933e-02f, 9.40388162e-03f,
  6.76599145e-02f, 6.75245523e-02f, 9.72121879e-02f, -1.33554056e-01f, -4.62958924e-02f, -5.19030988e-02f, -4.97244373e-02f, -4.30791155e-02f, 1.88093875e-02f, -6.19389489e-02f,
  -1.94240976e-02f, 5.33359349e-02f, -1.31958351e-01f, -3.50963697e-02f, 6.97221160e-02f, 2.25027781e-02f, 4.63200770e-02f, 1.45875335e-01f, 2.48684566e-02f, -6.78845346e-02f,
  -1.41219318e-01f, 3.15661430e-02f, 1.97461713e-02f, 2.39638854e-02f, -1.12833939e-01f, -9.46261082e-03f, -9.24850702e-02f, 3.34684104e-02f, -6.48425668e-02f, 3.19179259e-02f,
  -1.86843239e-02f, 7.24449828e-02f, -6.37490526e-02f, 2.94915419e-02f, -6.92249984e-02f, 3.43456380e-02f, -9.37813893e-02f, -5.36563993e-03f, -4.36816335e-04f, -5.70062995e-02f,
  2.21638456e-01f, 5.62889837e-02f, 3.91851030e-02f, 2.29094438e-02f, 2.16150703e-03f, 1.06248725e-02f, -7.34159537e-03f, 2.92042065e-02f, 2.92804595e-02f, 6.07410073e-02f,
  8.60189423e-02f, 1.64450556e-01f, 2.74691079e-02f, 3.13306302e-02f, 1.40693977e-01f, 1.84279665e-01f, 7.67881423e-02f, 1.11039758e-01f, 2.92981993e-02f, -3.81649658e-02f,
  -8.21830034e-01f, 6.69347942e-01f, 2.85919338e-01f, -4.67608094e-01f, 1.52246028e-01f, 1.54758722e-03f, -1.43191889e-01f, 1.62078276e-01f, -1.31375343e-01f, 1.63392961e-01f,
  -1.05642393e-01f, 1.44273281e-01f, 2.35743046e-01f, -9.25128683e-02f, -4.62201953e-01f, 5.13230190e-02f, -3.91950071e-01f, -2.17582420e-01f, -1.35854501e-02f, -4.11459431e-02f,
  -2.50554413e-01f, -2.36315295e-01f, -6.03976324e-02f, 3.26120973e-01f, 7.66966417e-02f, 9.86055165e-05f, -4.20309126e-01f, 2.69736141e-01f, -7.29004964e-02f, 1.74832538e-01f,
  -2.42567375e-01f, 1.21697932e-01f, -1.00110516e-01f, 1.04447164e-01f, -6.14783578e-02f, -1.07914619e-02f, -6.93734661e-02f, 4.39742915e-02f, -6.84376284e-02f, 5.12378477e-02f,
  5.30053414e-02f, 4.04770561e-02f, -2.85154246e-02f, 5.71794622e-02f, -2.61741374e-02f, 4.32697646e-02f, 9.99059230e-02f, -1.41139291e-02f, 4.40691821e-02f, 1.57721102e-01f,
  1.12217665e-01f, 9.57019255e-02f, -1.45772472e-01f, 5.43517666e-03f, -3.78315188e-02f, 1.19570820e-02f, 2.55243084e-03f, 6.36304542e-02f, 2.55560665e-03f, -4.00062017e-02f,
  8.03661570e-02f, -4.58292710e-03f, 2.13412698e-02f, 2.90285517e-02f, 5.10632992e-02f, 1.68991070e-02f, -7.80297890e-02f, -6.59129694e-02f, 3.87638733e-02f, -3.42251435e-02f,
  -1.09659739e-01f, 9.16920230e-02f, 1.67410467e-02f, -1.07872032e-01f, -8.36394131e-02f, -5.81749864e-02f, -1.57175317e-01f, 4.37216125e-02f, -3.65261063e-02f, 4.60158698e-02f,
  -1.69832204e-02f, -4.66893753e-03f, 1.13628112e-01f, -8.50363299e-02f, 3.98325501e-04f, -6.37758663e-03f, -2.06786375e-02f, 1.00759223e-01f, -6.93257898e-02f, -7.81541392e-02f,
  -5.72071552e-01f, -3.39453161e-01f, -1.06560513e-01f, 5.12155108e-02f, -9.00531560e-02f, -1.56141389e-02f, -1.81008279e-02f, -4.33854312e-02f, -3.08186542e-02f, -1.07591916e-02f,
  -5.08541204e-02f, -2.20050476e-02f, -1.34311423e-01f, -1.22085445e-01f, -8.34217295e-02f, -5.51514886e-02f, -1.65798888e-01f, -1.05905339e-01f, -1.45032108e-01f, -2.53688768e-02f,
  4.14571539e-03f, -6.32568747e-02f, -1.61302253e-03f, -1.05623575e-02f, -9.93670896e-02f, -6.23192787e-02f, -3.88055816e-02f, 5.54653034e-02f, 1.17148906e-02f, -4.53091372e-04f,
  4.02154565e-01f, 2.06669644e-01f, -2.06985995e-01f, -9.12096575e-02f, -1.43881962e-01f, 3.69790822e-01f, 2.70488828e-01f, 4.32381444e-02f, -5.63800223e-02f, 2.12706074e-01f,
  7.76574463e-02f, 1.21412389e-02f, 2.33376220e-01f, 3.02363604e-01f, 2.61250973e-01f, 2.44016066e-01f, 2.53744036e-01f, 1.26908988e-01f, -1.93983894e-02f, 2.37608075e-01f,
  1.09222092e-01f, 3.73525113e-01f, -3.26822698e-02f, -1.11479603e-01f, 1.88005984e-01f, -3.09343547e-01f, -1.75935492e-01f, -1.60457402e-01f, -1.72658920e-01f, 5.18684797e-02f,
  1.03018433e-01f, 4.05636476e-03f, -6.85689300e-02f, -3.34159881e-02f, -4.09755856e-03f, -1.28091872e-02f, -8.89545530e-02f, 1.89902761e-03f, -8.33204761e-02f, 1.78669933e-02f,
  5.66211790e-02f, 2.05177944e-02f, 7.54142702e-02f, -6.88503906e-02f, -2.73345374e-02f, -8.10614079e-02f, -5.07073179e-02f, -1.06977157e-01f, -5.89357466e-02f, 6.28951564e-02f,
  5.29555082e-02f, -1.01548873e-01f, -2.74746325e-02f, -3.08762174e-02f, -3.90493236e-02f, 7.43814781e-02f, 2.62743551e-02f, -7.12423027e-02f, 5.15627004e-02f, -5.38088428e-03f,
  -2.90506077e-03f, 2.33931355e-02f, 1.11422256e-01f, -2.58246791e-02f, 2.02462152e-02f, -2.36317869e-02f, -2.33922247e-02f, -7.76219741e-02f, -4.27973047e-02f, -7.53308460e-03f,
  -8.79442468e-02f, 9.20355767e-02f, 3.42434496e-02f, 4.33125310e-02f, 5.20373508e-02f, 1.59794614e-02f, -5.25257140e-02f, 4.38155653e-03f, -7.29369884e-03f, -4.76317070e-02f,
  -9.14892256e-02f, 4.25164364e-02f, 3.82197388e-02f, -4.21506241e-02f, 5.87772615e-02f, 9.41581186e-03f, 2.28798911e-02f, 3.43630835e-02f, -5.30573316e-02f, 5.43256551e-02f,
  4.31269128e-03f, 1.41326562e-01f, 2.84559745e-02f, -1.06876865e-02f, -1.14386976e-01f, 6.75526783e-02f, 9.12389904e-03f, 5.58083579e-02f, -3.66724730e-02f, 7.64245093e-02f,
  -1.58793502e-03f, 1.01942092e-03f, 6.16297009e-04f, -6.37376532e-02f, -5.63787110e-02f, 9.98634696e-02f, 2.01523136e-02f, -1.64562598e-01f, -3.71544845e-02f, -1.52748879e-02f,
  -3.76183763e-02f, 3.95622924e-02f, 3.23580503e-02f, 4.48811054e-03f, -2.00772136e-02f, -2.45240727e-03f, -7.09167421e-02f, -5.26185206e-04f, 9.99667402e-03f, -7.56198093e-02f,
  -8.34880412e-01f, -1.07874051e-01f, -3.54733855e-01f, 1.42204747e-01f, -5.09426892e-02f, -7.32766390e-02f, -2.29355648e-01f, -7.11352676e-02f, -4.03818518e-01f, 3.19789760e-02f,
  1.00298986e-01f, -3.13803166e-01f, -1.67993501e-01f, 2.71356910e-01f, -1.60417989e-01f, 1.04707725e-01f, 2.07904935e-01f, 9.08000916e-02f, -3.82693671e-03f, 7.34285265e-02f,
  1.00341573e-01f, 4.47711587e-01f, 1.25333622e-01f, 3.60154063e-01f, -7.62265250e-02f, 9.32315812e-02f, 1.62183896e-01f, 7.59066865e-02f, 2.59520561e-01f, -8.64357781e-03f,
  -1.20955266e-01f, -2.33782411e-01f, -4.89893705e-02f, -9.54931602e-03f, -4.66505140e-02f, -6.56668842e-02f, -1.18498011e-02f, 7.09554413e-03f, 5.96890301e-02f, 3.93283442e-02f,
  -1.41656801e-01f, -5.41558908e-03f, 1.14728265e-01f, 5.23915365e-02f, -1.19974390e-01f, 6.73157116e-03f, -6.28912300e-02f, -5.63551579e-03f, -5.95878772e-02f, -3.32491100e-02f,
  -8.92714038e-02f, 1.41666643e-02f, -5.42267375e-02f, 3.91476341e-02f, -1.10300474e-01f, 5.67142107e-02f, 7.24320263e-02f, -6.87737167e-02f, -4.77403328e-02f, -1.43652141e-01f,
  7.24899173e-02f, -3.92169766e-02f, -6.14546845e-03f, -4.49060313e-02f, -1.44314971e-02f, -1.23882638e-02f, 2.36175470e-02f, 2.72437241e-02f, -3.01019344e-02f, -3.22833769e-02f,
  6.51071817e-02f, -1.31988987e-01f, 4.10598293e-02f, -7.88226426e-02f, -2.74364688e-02f, -6.43626451e-02f, 5.00141196e-02f, 5.78592606e-02f, -1.99708510e-02f, 8.09432268e-02f,
  -1.40975401e-01f, 1.67636070e-02f, 8.67454393e-04f, 1.79276336e-02f, 3.43620144e-02f, -5.45221828e-02f, 6.39202669e-02f, -1.76721513e-02f, -5.36170080e-02f, 5.70264384e-02f,
  -2.35925451e-01f, -1.93621561e-01f, -7.60130491e-03f, -4.43066470e-02f, 6.80674240e-02f, -2.15034317e-02f, 6.53157085e-02f, -2.44640689e-02f, -4.92709316e-02f, -1.13767646e-01f,
  2.69866940e-02f, 4.51424234e-02f, 4.15073056e-03f, 6.72168657e-02f, 1.51238278e-01f, -2.23474723e-04f, 8.37332159e-02f, -5.48776314e-02f, -3.79307754e-02f, 7.27676749e-02f,
  -5.83666489e-02f, -5.09187765e-02f, 7.22253397e-02f, 4.16507237e-02f, 9.94114131e-02f, -2.87223831e-02f, 1.83678232e-02f, 2.46734880e-02f, 4.42447029e-02f, 6.02227189e-02f,
  -3.94872762e-02f, -3.72823715e-01f, 3.04522485e-01f, -2.58253198e-02f, 4.34539258e-01f, 4.38072711e-01f, 6.87785596e-02f, 3.22272539e-01f, 7.13964403e-02f, -4.09346610e-01f,
  1.08195795e-02f, -2.16819972e-01f, -2.46166706e-01f, 5.72291911e-02f, 3.00870627e-01f, 9.05287266e-03f, 1.45445913e-01f, -9.50332358e-02f, 1.58270553e-01f, 2.71198893e-04f,
  8.86939168e-02f, 4.73655388e-02f, 1.84940070e-01f, 3.37807499e-02f, -1.35375862e-03f, -1.64097995e-01f, -1.85568377e-01f, -5.15967142e-03f, 4.11271229e-02f, 1.16428196e-01f,
  7.31945932e-02f, -7.61466324e-02f, -2.70538982e-02f, 1.33853350e-02f, 3.24911289e-02f, -1.37855947e-01f, -1.04619995e-01f, -1.62512753e-02f, 6.26076758e-02f, -1.04268808e-02f,
  -1.01833172e-01f, 4.76995781e-02f, 8.59431997e-02f, 2.25741491e-02f, -1.21655203e-02f, 1.08685754e-01f, 1.28769547e-01f, 9.97998938e-02f, 3.82661894e-02f, 1.21236533e-01f,
  8.30659941e-02f, 1.05716541e-01f, 4.56353016e-02f, 2.34825201e-02f, 8.12547728e-02f, 5.69564961e-02f, 3.96599062e-02f, 4.72606644e-02f, 2.98522040e-02f, 1.93688512e-01f,
  9.20636952e-02f, -5.34996688e-02f, -6.07852712e-02f, -6.79884851e-02f, 5.98886125e-02f, 2.61016767e-02f, -6.53109401e-02f, -3.33786048e-02f, -1.03683569e-01f, 9.65274125e-03f,
  8.20040256e-02f, -6.24982677e-02f, 3.05885877e-02f, 1.83725881e-03f, -4.87058274e-02f, 5.21891862e-02f, -2.50037257e-02f, -6.08979911e-03f, 2.77657509e-02f, -2.48813722e-02f,
  -1.45305753e-01f, 3.49787660e-02f, 2.27549858e-02f, -1.27665801e-02f, 2.58286130e-02f, -5.82993142e-02f, -4.91198748e-02f, 5.43299913e-02f, 1.99394897e-02f, 4.29079589e-03f,
  -5.00166237e-01f, -4.99777168e-01f, 4.16558608e-03f, 9.17772483e-03f, -1.50173046e-02f, 5.62919630e-03f, -9.13843066e-02f, 6.13665283e-02f, -1.43076643e-01f, 3.21240909e-02f,
  -7.49067264e-03f, -6.22638464e-02f, -1.07903592e-01f, 1.45464744e-02f, -1.23143278e-01f, 1.08429622e-02f, -1.22383416e-01f, -1.62863672e-01f, -1.14880949e-01f, -1.03940563e-02f,
  -8.16522464e-02f, -7.15098232e-02f, -9.67921806e-04f, 4.20746468e-02f, -4.84707169e-02f, -3.95411439e-02f, -7.27525167e-03f, 1.70191117e-02f, 8.22865963e-03f, -5.45478007e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  5.99367201e-01f, 5.07293344e-01f, 8.10660496e-02f, 4.16129977e-02f, 2.85893440e-01f, 3.31281386e-02f, 2.65499264e-01f, 5.71575105e-01f, 2.93764442e-01f, 5.33068836e-01f,
  5.07899523e-01f, 3.48313689e-01f, 5.42274773e-01f, 5.24058580e-01f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -1.75461546e-01f, -1.58514321e-01f, 3.63163114e-01f, 2.11287811e-01f, -7.04646632e-02f, 5.30032180e-02f, -2.03769375e-02f, -6.33167997e-02f, -3.63573879e-02f, -1.81632623e-01f,
  -1.62768573e-01f, 2.41494253e-01f, 3.50696862e-01f, 4.08220887e-01f, -1.24603212e-02f, -2.33756661e-01f, 9.64985564e-02f, -1.83271915e-01f, -1.20662801e-01f, 3.78199071e-02f,
  2.81905115e-01f, 4.42240480e-03f, -2.98456639e-01f, -2.48458862e-01f, -3.11624229e-01f, 2.18216762e-01f, 9.80907232e-02f, 1.61273584e-01f, -2.03548342e-01f, 1.68956593e-01f,
  -6.07516356e-02f, 2.80813854e-02f, 1.72218949e-01f, 1.35071442e-01f, -2.74236530e-01f, -1.15583330e-01f, 8.46926868e-02f, 1.83169812e-01f, -2.50187516e-02f, 3.69250476e-02f,
  3.13946843e-01f, 2.18745306e-01f, -5.56811914e-02f, -4.45583723e-02f, -9.52429995e-02f, -2.18112364e-01f, 2.07428664e-01f, 1.55617625e-01f, 1.54686078e-01f, 2.71114320e-01f,
  -8.15295279e-02f, 2.29130667e-02f, -2.09130883e-01f, -4.31564031e-03f, 4.11271423e-01f, 2.89769024e-01f, 4.03720587e-01f, 7.50531107e-02f, -2.80495286e-01f, -1.12166196e-01f,
  1.43579766e-01f, -1.42787844e-01f, 5.10278232e-02f, -1.08952306e-01f, -1.44776374e-01f, -1.35400519e-01f, 6.04200410e-03f, -6.57480806e-02f, -2.14205682e-01f, 1.42308712e-01f,
  -1.74152553e-01f, -1.62459759e-03f, -6.58486709e-02f, 3.11311726e-02f, -1.06449559e-01f, 2.43929252e-01f, 1.30339488e-01f, 2.05823407e-01f, 2.08910733e-01f, 9.88143757e-02f,
  1.52088061e-01f, -1.86944857e-01f, -2.38195509e-01f, 4.08001430e-02f, 2.33752370e-01f, 1.44076332e-01f, 1.72026128e-01f, 1.45531252e-01f, 1.55104503e-01f, 2.55831599e-01f,
  -6.44295663e-02f, 1.86260976e-02f, -3.25826854e-01f, 1.42105341e-01f, -7.63954520e-02f, -3.02814245e-01f, -9.02227983e-02f, -1.88757718e-01f, 3.90093923e-02f, -1.68902740e-01f,
  2.65152872e-01f, -1.14527620e-01f, -1.30182460e-01f, -1.27157748e-01f, 1.07215136e-01f, 2.84689099e-01f, 7.20482841e-02f, -2.64611930e-01f, 1.04731113e-01f, -3.11077759e-02f,
  5.51011553e-03f, 1.29302666e-01f, -1.19634926e-01f, 2.79982895e-01f, -1.69900432e-01f, -1.38886005e-01f, -8.69396627e-02f, 5.94066642e-02f, 2.59850979e-01f, 8.05356652e-02f,
  1.71316400e-01f, -1.82240531e-01f, -7.68703520e-02f, -2.04678908e-01f, 3.84340763e-01f, -3.06832463e-01f, 2.36478835e-01f, 1.39339939e-01f, -1.43829565e-02f, -9.89992768e-02f,
  -8.82899091e-02f, 7.43720457e-02f, -3.71636450e-02f, 7.76221678e-02f, 6.11353070e-02f, -4.98184487e-02f, 2.34279092e-02f, -7.28625432e-03f, 1.75710529e-01f, -2.97089547e-01f,
  -1.33502558e-01f, -2.85987973e-01f, 2.96051204e-01f, 1.66646034e-01f, -2.25428417e-01f, -1.09583490e-01f, -2.10455090e-01f, -2.14803711e-01f, -1.01541042e-01f, -1.04010500e-01f,
  1.43552676e-01f, -3.65482271e-02f, -4.76685874e-02f, -7.66968802e-02f, -2.22886633e-02f, 1.76509827e-01f, 2.17391759e-01f, -2.65784919e-01f, 9.04100537e-02f, -5.19196466e-02f,
  3.86232906e-03f, -5.02243266e-02f, -2.28152126e-01f, -4.08564396e-02f, -2.20427945e-01f, 7.18008056e-02f, 1.34478316e-01f, 4.58849296e-02f, -3.51917855e-02f, -3.46743464e-02f,
  3.08218244e-02f, -1.56922713e-01f, 2.38378961e-02f, -3.87206934e-02f, 2.77790964e-01f, -4.56573442e-02f, -2.49995366e-01f, -2.06141353e-01f, -9.68117490e-02f, -2.10311860e-01f,
  2.14127779e-01f, -1.92574933e-01f, -2.68032014e-01f, -1.16298668e-01f, -1.84899822e-01f, 3.61857355e-01f, -4.03429270e-02f, -6.89929202e-02f, 4.64396328e-02f, 2.71771587e-02f,
  1.16924003e-01f, -1.24178305e-02f, 5.87766618e-02f, -1.54002592e-01f, -3.82992700e-02f, -3.60144638e-02f, -1.68306809e-02f, 6.81265965e-02f, -1.46837324e-01f, -1.25548604e-03f,
  8.29944611e-02f, -1.88070059e-01f, -4.54869047e-02f, 2.11490065e-01f, -1.52176052e-01f, -1.84801877e-01f, -1.83571771e-01f, 1.45203188e-01f, -7.67887756e-02f, 2.13715479e-01f,
  -1.78114116e-01f, -6.27622902e-02f, -2.86478817e-01f, 2.88947344e-01f, 2.07436398e-01f, 1.78334430e-01f, 2.78503776e-01f, -2.24173918e-01f, 7.30855316e-02f, 2.31000204e-02f,
  7.47303013e-04f, -3.23649794e-01f, 9.18878838e-02f, -1.34090528e-01f, 1.44730195e-01f, 2.11537909e-02f, -4.42115337e-01f, -6.05338104e-02f, -2.17914075e-01f, 2.03513235e-01f,
  2.11483881e-01f, 1.17152281e-01f, 1.42899737e-01f, -2.01576561e-01f, -1.06923535e-01f, 1.73205897e-01f, -3.42136264e-01f, -6.53245002e-02f, 2.47311562e-01f, 2.74338156e-01f,
  2.66527347e-02f, 3.61488499e-02f, -1.44867823e-02f, -1.21342592e-01f, -2.28988394e-01f, -2.86654294e-01f, 4.26238440e-02f, -3.63120846e-02f, 6.44812509e-02f, 2.52700955e-01f,
  -1.72890887e-01f, 1.24747030e-01f, -3.05427164e-02f, -1.66037381e-01f, 2.01776698e-02f, -2.25854352e-01f, 8.62910748e-02f, 1.80398300e-01f, 2.02577636e-01f, 8.29936191e-03f,
  2.00531669e-02f, 8.15086812e-02f, -7.76298493e-02f, 6.68848902e-02f, 4.62574288e-02f, -1.89391121e-01f, -1.74082801e-01f, 3.66738170e-01f, -1.97815910e-01f, 1.79501921e-01f,
  -2.79925883e-01f, -7.07201287e-02f, 2.65315950e-01f, 3.12340647e-01f, 1.48328498e-01f, 2.46698990e-01f, -2.58608460e-01f, 2.72053871e-02f, 2.19059482e-01f, 7.61596337e-02f,
  1.43211931e-01f, -2.44630098e-01f, -9.44160074e-02f, 8.83580446e-02f, -2.26948783e-01f, 3.19724646e-03f, -2.94709563e-01f, -8.35024863e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  5.65922335e-02f, 2.58460671e-01f, 2.60107994e-01f, 3.39811891e-01f, -5.05195819e-02f, 4.18001443e-01f, 4.85372990e-01f, 8.86255428e-02f, -5.09175397e-02f, -5.96953094e-01f,
  4.85351533e-01f, -2.07409501e-01f, 1.12577185e-01f, -6.89033940e-02f, 3.50998044e-01f, 1.26200423e-01f, 9.65885445e-02f, -7.19421327e-01f, -4.73966449e-01f, -1.06960900e-01f,
  -8.32249504e-03f, -2.77915150e-01f, -1.10984914e-01f, -2.09081650e-01f, -3.90559971e-01f, 2.59301782e-01f, 3.50663036e-01f, 5.37355840e-01f, -2.48508826e-01f, 4.15902466e-01f,
  -3.69803421e-02f, -9.78354141e-02f, 2.23149449e-01f, 2.81069487e-01f, -4.07508403e-01f, 1.27756521e-01f, -6.92989007e-02f, 2.18605071e-01f, 3.51296842e-01f, 1.84282660e-01f,
  9.20272544e-02f, -1.35081440e-01f, 2.53974050e-02f, -3.85034293e-01f, -4.88261849e-01f, -6.32517993e-01f, 4.09314662e-01f, 2.10015967e-01f, -3.61626893e-01f, -4.23549831e-01f,
  -3.02478433e-01f, -6.07171178e-01f, -4.23321247e-01f, -4.52797145e-01f, 5.28080821e-01f, 1.63702488e-01f, 1.89867675e-01f, 3.46308462e-02f, -1.69947222e-01f, 7.81687677e-01f,
  5.01416862e-01f, -5.27969539e-01f, 2.79696941e-01f, -5.24862766e-01f, 4.45456415e-01f, 4.82597053e-01f, -4.94896740e-01f, 1.58128571e-02f, 3.17792833e-01f, 1.96495444e-01f,
  3.22720349e-01f, 4.75233048e-01f, 2.66701132e-01f, 5.02310038e-01f, 2.97529310e-01f, -5.81191957e-01f, -6.37114406e-01f, -4.23851848e-01f, 9.95590687e-02f, 4.06306803e-01f,
  -1.78988218e-01f, 7.99835324e-02f, 4.14207995e-01f, 1.23050325e-01f, -3.51065397e-01f, -5.36521673e-01f, 2.26264402e-01f, 2.74336487e-01f, 5.47989428e-01f, 2.00889722e-01f,
  -1.70813039e-01f, -5.50248146e-01f, 7.86725819e-01f, -1.89410418e-03f, 3.26185077e-02f, 5.11509895e-01f, 2.63188183e-01f, 4.02291007e-02f, 3.46279502e-01f, 1.53671771e-01f,
  1.66272178e-01f, 5.27472794e-01f, 9.80683044e-02f, 3.09891373e-01f, 2.68590689e-01f, 1.70075208e-01f, -2.08000824e-01f, 2.46041402e-01f, -8.16563144e-02f, 2.36088157e-01f,
  4.12101388e-01f, 6.94033876e-02f, 2.90258884e-01f, 1.65648118e-01f, -1.07378237e-01f, -9.97262970e-02f, 3.19024593e-01f, 4.03670043e-01f, 6.39500141e-01f, -2.67438143e-01f,
  1.13791831e-01f, 3.55015635e-01f, -3.68068308e-01f, 3.37150782e-01f, 1.33216595e-02f, 1.68918088e-01f, -1.05461016e-01f, -1.27975047e-01f, -1.65418908e-02f, -3.75865921e-02f,
  3.81693095e-01f, 3.75027180e-01f, 4.26316172e-01f, -1.79665349e-02f, 3.80080268e-02f, 1.66686788e-01f, 3.80544886e-02f, -6.27879053e-02f, 7.04965591e-01f, -7.14948177e-01f,
  6.92428052e-01f, -1.06816411e-01f, 4.23198313e-01f, -9.07691568e-02f, -2.78572053e-01f, -3.42939824e-01f, -3.33178163e-01f, 1.03845954e-01f, 4.62983072e-01f, 6.99171126e-01f,
  8.12832564e-02f, -2.93248832e-01f, -2.47752354e-01f, 1.87848777e-01f, 5.41854501e-01f, 1.08059041e-01f, 4.13847834e-01f, 2.76868558e-03f, 8.47021103e-01f, 3.00254256e-01f,
  1.92581743e-01f, 2.27738917e-01f, 2.35752389e-01f, 3.30326408e-02f, 6.55202150e-01f, -9.20852497e-02f, -7.02428520e-02f, 2.76453733e-01f, 1.81259423e-01f, 3.81662607e-01f,
  4.38414440e-02f, -1.04679242e-01f, -1.60583094e-01f, -7.13493824e-02f, -2.37497374e-01f, 1.92004949e-01f, -2.62959506e-02f, 5.48165798e-01f, 5.97206235e-01f, 2.43701264e-01f,
  -2.95252770e-01f, 4.25034821e-01f, 6.18350446e-01f, -4.24983203e-01f, 8.81673098e-02f, -6.22787833e-01f, 2.53226876e-01f, 4.29804251e-02f, 6.55568063e-01f, -9.58116651e-02f,
  2.81050593e-01f, 5.86206794e-01f, 1.54351145e-01f, 2.70269930e-01f, 4.38245945e-02f, 1.14861438e-02f, 1.63225621e-01f, 1.98490947e-01f, 1.62400544e-01f, 2.39477620e-01f,
  1.91521913e-01f, 5.09920835e-01f, -3.51453364e-01f, -2.15765342e-01f, -1.66762978e-01f, -4.34047058e-02f, 4.54441011e-01f, -1.05430521e-01f, -2.70878583e-01f, -2.25187376e-01f,
  6.38334006e-02f, -2.70222306e-01f, 5.49648583e-01f, -5.78135371e-01f, 5.36589980e-01f, -1.51737839e-01f, -9.93577857e-03f, 5.73383451e-01f, -2.63430417e-01f, 1.98607534e-01f,
  6.60010636e-01f, 1.67822987e-01f, 4.30275202e-01f, 5.09260669e-02f, 2.79969007e-01f, 4.66312766e-01f, 5.57633162e-01f, 3.77943546e-01f, 4.35921967e-01f, 4.91600245e-01f,
  1.92816958e-01f, 3.58091831e-01f, 4.50559139e-01f, 9.41995531e-02f, -5.49281120e-01f, 5.15096188e-01f, 1.04553431e-01f, 5.28573990e-01f, -2.69317955e-01f, -4.53850448e-01f,
  5.73656261e-01f, 5.96924186e-01f, 4.96720165e-01f, 8.78340721e-01f, -2.05613866e-01f, -3.43297184e-01f, 2.88862675e-01f, 1.96513951e-01f, 2.60929078e-01f, -5.97667620e-02f,
  -3.10982943e-01f, 2.66796559e-01f, 1.67538598e-01f, -3.99100371e-02f, -5.74771285e-01f, 2.00693354e-01f, 2.96133995e-01f, 1.58895981e-02f, 4.87199157e-01f, 2.39498451e-01f,
  1.12546101e-01f, 1.97927818e-01f, -6.69811480e-03f, 6.07427619e-02f, 2.55557328e-01f, 4.37342048e-01f, -4.25846338e-01f, -2.10595161e-01f, 5.35469532e-01f, 3.35354507e-01f,
  2.08206326e-01f, -5.30268729e-01f, 2.92127460e-01f, 6.80864900e-02f, 2.96263129e-01f, 6.66388869e-01f, 2.80315429e-01f, -6.11185208e-02f, -3.11040640e-01f, 5.68398952e-01f,
  3.01696837e-01f, 3.03773224e-01f, -4.23709571e-01f, -1.97440028e-01f, 4.11888808e-01f, -1.28212586e-01f, 2.50371635e-01f, -7.27433190e-02f, 7.32367039e-02f, 1.49211228e-01f,
  -1.52224392e-01f, 8.44265446e-02f, 2.88345128e-01f, -7.18411282e-02f, 2.36890778e-01f, 2.48728469e-01f, 2.20636830e-01f, -2.44757041e-01f, 1.10948414e-01f, 6.30539656e-02f,
  -4.73035723e-01f, -2.85501271e-01f, -3.80948454e-01f, 4.63548839e-01f, -5.03051281e-01f, 2.16793358e-01f, 5.67217231e-01f, -2.78121084e-01f, -4.87478554e-01f, -5.66923395e-02f,
  -1.35480285e-01f, -2.08748683e-01f, -3.84942926e-02f, -2.54606426e-01f, 5.08147240e-01f, 2.26520121e-01f, -1.91342875e-01f, -4.02571917e-01f, 2.53636032e-01f, 4.17698741e-01f,
  8.69905502e-02f, -1.28185436e-01f, -2.08866864e-01f, 1.07231766e-01f, -2.27856204e-01f, -1.87649250e-01f, -2.41386592e-01f, 4.51206695e-03f, 1.32303685e-01f, 6.66247249e-01f,
  -4.11448479e-01f, -4.61656600e-01f, 9.79873538e-02f, -1.96044117e-01f, 2.69333512e-01f, -4.32556331e-01f, -8.56222510e-02f, -9.30254087e-02f, 3.09654027e-02f, 1.56956583e-01f,
  4.44920242e-01f, -1.29804179e-01f, -1.60549253e-01f, 7.07287014e-01f, 5.09925008e-01f, 4.56301689e-01f, -3.97541285e-01f, -3.09024602e-01f, 4.92193609e-01f, 1.51768997e-01f,
  5.28422713e-01f, -3.93405318e-01f, 6.03209548e-02f, 4.71897453e-01f, 2.95162797e-01f, 3.25292528e-01f, 2.44970247e-01f, 8.01475197e-02f, 4.49945241e-01f, 3.57936472e-01f,
  1.56336799e-01f, -5.61087549e-01f, 4.84805107e-01f, 2.05993280e-01f, 1.20291166e-01f, 8.28818977e-02f, -3.25405419e-01f, 4.31842878e-02f, -1.29021272e-01f, -4.74772751e-01f,
  5.04007757e-01f, 4.32995170e-01f, -1.39063165e-01f, -1.61133766e-01f, -5.79915464e-01f, -2.80353367e-01f, -3.66805643e-01f, 1.88730121e-01f, 6.89685047e-01f, 3.93188059e-01f,
  -8.91254693e-02f, 4.45278615e-01f, 1.26121625e-01f, 6.83677375e-01f, 2.19899163e-01f, 3.69277626e-01f, -1.72192514e-01f, 1.93925589e-01f, -2.93447435e-01f, 6.10010087e-01f,
  4.02423292e-01f, 4.88571256e-01f, 2.55576283e-01f, -2.94117570e-01f, 1.34300575e-01f, 5.08430243e-01f, -4.79019433e-01f, 7.26580620e-02f, 3.47051322e-01f, 6.43079519e-01f,
  4.65449616e-02f, -1.22424170e-01f, 2.02296376e-01f, -1.22336894e-01f, -8.94336477e-02f, 4.01168376e-01f, 2.85136312e-01f, -1.90609947e-01f, 6.54839098e-01f, 7.67231464e-01f,
  2.79326439e-01f, 2.86425561e-01f, -5.57259858e-01f, 4.92193162e-01f, -1.23344049e-01f, -4.18108478e-02f, 9.54594240e-02f, 1.11805819e-01f, 7.75507092e-01f, 2.39447683e-01f,
  1.46406472e-01f, 3.25464338e-01f, -1.30861178e-01f, 3.08496833e-01f, 2.65210271e-01f, 6.66926056e-03f, -2.57042944e-01f, 3.77355069e-01f, 4.70266104e-01f, 5.77448845e-01f,
  1.85604319e-01f, -2.65444398e-01f, 2.11271167e-01f, 2.02678278e-01f, -4.57806103e-02f, 1.93147510e-01f, 5.62013328e-01f, 6.22721255e-01f, 4.82950330e-01f, -3.62429559e-01f,
  -3.37880328e-02f, 3.98989439e-01f, 1.74700290e-01f, 4.22508776e-01f, 4.30514067e-02f, 4.77996796e-01f, 9.46768001e-02f, 2.69957688e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  1.65874705e-01f, 3.43655676e-01f, 2.77522922e-01f, 2.46349066e-01f, 4.47141171e-01f, 2.53387541e-01f, 3.31244946e-01f, 3.95153940e-01f, 3.79574269e-01f, 3.79199088e-01f,
  3.44699860e-01f, 5.11224687e-01f, 1.28162563e-01f, 2.07135633e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -3.67109627e-01f, 1.29965991e-01f, -6.04815707e-02f, 1.18783809e-01f, 5.83763346e-02f, -1.95007712e-01f, -2.81215668e-01f, -1.09768823e-01f, -3.66279393e-01f, 2.67063469e-01f,
  -4.24515963e-01f, 4.71088082e-01f, -1.32235095e-01f, -2.98360258e-01f, 3.41878772e-01f, -1.36749506e-01f, -4.22865391e-01f, -1.31769732e-01f, -2.66501568e-02f, -2.04590723e-01f,
  -7.89619267e-01f, 1.02793582e-01f, 2.81719983e-01f, -6.87602878e-01f, 5.43263853e-01f, -7.01814175e-01f, 2.40322262e-01f, -2.12121233e-01f, 6.25308454e-01f, -3.36401969e-01f,
  -3.96164447e-01f, 2.78537035e-01f, -3.92311364e-01f, -2.51390375e-02f, -3.85863669e-02f, -3.13409775e-01f, 2.49672625e-02f, 6.53508753e-02f, 1.20286494e-02f, -1.31302709e-02f,
  9.28233191e-02f, 2.90023088e-01f, -5.12072146e-01f, 4.04029876e-01f, -1.92711338e-01f, -1.29092157e-01f, 1.47432581e-01f, -4.10835624e-01f, -2.61465460e-01f, -2.09012941e-01f,
  8.21811438e-01f, -6.47735238e-01f, -5.60817897e-01f, -4.65273336e-02f, 2.71124184e-01f, -7.25013971e-01f, -2.60933161e-01f, -5.56383371e-01f, -6.64681494e-01f, -7.61721313e-01f,
  -7.42666125e-01f, 6.64870083e-01f, 3.86255771e-01f, 2.87852764e-01f, 1.80418432e-01f, -8.48622024e-02f, -1.34304211e-01f, 1.38002843e-01f, -9.23371911e-02f, 1.19188078e-01f,
  9.67297330e-02f, -6.52226880e-02f, 2.17101872e-01f, 3.03132623e-01f, -4.11113501e-01f, -3.42060745e-01f, 3.96250665e-01f, 4.70167175e-02f, -6.36539757e-02f, 4.62430835e-01f,
  -2.22818762e-01f, -3.23190153e-01f, -4.04242694e-01f, -3.25607121e-01f, -5.79784572e-01f, -5.71271241e-01f, 4.86549050e-01f, 2.91627288e-01f, -4.77292836e-01f, -6.98807955e-01f,
  -3.96018207e-01f, 5.54433048e-01f, -2.72699505e-01f, 4.00055379e-01f, -2.54517019e-01f, 4.37159464e-02f, -2.90840089e-01f, -3.20989639e-01f, 4.31526676e-02f, -1.30303958e-02f,
  -1.59735698e-02f, 6.40678555e-02f, 2.02869162e-01f, -5.03979251e-02f, -7.77023360e-02f, -3.23006630e-01f, 2.67304838e-01f, -1.78320229e-01f, 1.67303458e-01f, 1.73351020e-01f,
  3.59437674e-01f, -1.61572888e-01f, 3.80908489e-01f, -3.60031247e-01f, -5.13963044e-01f, 4.98677403e-01f, 5.72251141e-01f, -3.22853178e-01f, -1.69416547e-01f, -1.47548482e-01f,
  4.27479684e-01f, -7.31568336e-01f, -2.62869969e-02f, -3.33793133e-01f, 7.31541991e-01f, -8.01059186e-01f, -3.83262694e-01f, -8.01353872e-01f, 5.33146739e-01f, 2.61428952e-01f,
  3.34555432e-02f, 1.37881845e-01f, 4.35572594e-01f, 4.18979764e-01f, 8.90130997e-02f, -5.93748614e-02f, 5.04408598e-01f, -1.91915035e-01f, 5.01236498e-01f, -3.56700510e-01f,
  5.91576636e-01f, -8.00588802e-02f, 3.19482200e-02f, -5.85974753e-01f, -3.15038413e-01f, -5.38621902e-01f, -1.18823975e-01f, -6.66768491e-01f, 4.61418718e-01f, 4.30978574e-02f,
  4.68183249e-01f, 2.78173685e-01f, 1.35294944e-01f, 8.57007205e-02f, 2.63220370e-01f, -4.22850430e-01f, -1.80357676e-02f, -6.66928589e-02f, -9.63022530e-01f, -8.95869508e-02f,
  1.89084321e-01f, 1.07838444e-01f, -1.41481772e-01f, -1.83205664e-01f, -1.24898121e-01f, 4.59453315e-01f, 2.34472662e-01f, -1.04253665e-01f, 3.14548999e-01f, 5.06295562e-01f,
  5.96933305e-01f, 2.63770759e-01f, -3.68563414e-01f, -3.41358423e-01f, 2.76612729e-01f, -2.27220491e-01f, 6.69821620e-01f, 4.22007352e-01f, -2.42517933e-01f, -7.75550485e-01f,
  -6.32267818e-02f, 4.77794439e-01f, -8.78321409e-01f, -7.33430326e-01f, 6.26741052e-02f, 3.66073847e-01f, 1.16831444e-01f, -2.62528032e-01f, 1.05204433e-02f, -2.09960923e-01f,
  6.38617635e-01f, 2.82075644e-01f, 5.53557649e-02f, 2.86914766e-01f, -1.53945088e-01f, 1.30958915e-01f, -1.12516388e-01f, 1.30908132e-01f, 1.47956416e-01f, 3.90420049e-01f,
  8.12764391e-02f, -5.91222584e-01f, 7.89227802e-03f, -4.06808332e-02f, -2.97348797e-01f, -2.47304201e-01f, -1.52825445e-01f, -1.74466208e-01f, -8.64242241e-02f, 4.09947872e-01f,
  -3.37917268e-01f, -4.38287288e-01f, 7.22310126e-01f, -5.23011744e-01f, -7.90526927e-01f, 3.31193596e-01f, -4.24172223e-01f, -9.19840485e-02f, -6.35370612e-01f, 5.66658199e-01f,
  -2.36941785e-01f, 3.46646339e-01f, 3.10499668e-01f, -6.28078878e-01f, -2.92759567e-01f, -2.60220081e-01f, 2.16847286e-01f, 2.12741390e-01f, 1.55516014e-01f, -3.45526129e-01f,
  -5.74887544e-02f, 1.14947453e-01f, -1.02060266e-01f, -3.10494483e-01f, 1.39276803e-01f, 2.71422565e-01f, 3.32355797e-01f, -3.28838289e-01f, -3.47859174e-01f, 3.94878507e-01f,
  -1.67924732e-01f, 3.36665750e-01f, -2.48815134e-01f, -2.08484024e-01f, 2.72125006e-01f, -3.28320742e-01f, -4.51068312e-01f, -4.29258764e-01f, -7.30360448e-01f, 3.70668769e-01f,
  5.61316729e-01f, -2.42021918e-01f, 7.05207467e-01f, -4.59412366e-01f, -1.04397438e-01f, -5.02150357e-01f, -3.01598087e-02f, -8.24188665e-02f, -1.30556107e-01f, 9.03813168e-03f,
  1.41930133e-01f, -2.66285092e-01f, -3.20359498e-01f, 3.99397034e-03f, 1.81206271e-01f, -3.04989576e-01f, 3.27205479e-01f, 1.78461820e-01f, 3.60658497e-01f, 1.64046854e-01f,
  -1.59170628e-01f, 2.08881855e-01f, -2.39132509e-01f, 3.89925651e-02f, -4.06759977e-01f, -2.58118808e-01f, -3.52312267e-01f, 4.21508789e-01f, 4.33810294e-01f, 3.82156789e-01f,
  -5.38578629e-01f, -5.31619370e-01f, -4.14203286e-01f, -3.91471118e-01f, -6.54910505e-02f, -7.70912170e-01f, 3.91434491e-01f, 4.71309155e-01f, 4.96596983e-03f, 1.66420698e-01f,
  -3.92551720e-02f, -8.12174603e-02f, -2.20531285e-01f, -2.34463289e-01f, 2.11781487e-02f, -2.09141225e-01f, -4.71644133e-01f, 4.60765064e-01f, -3.11012030e-01f, -4.04926151e-01f,
  -3.90748560e-01f, -1.84418783e-01f, -2.81303644e-01f, -1.47350341e-01f, -2.90144175e-01f, 2.45394006e-01f, -2.57528335e-01f, -1.74796253e-01f, -8.09413850e-01f, -8.97658244e-02f,
  -4.61947054e-01f, 1.83502600e-01f, -7.04331160e-01f, 7.57267237e-01f, 3.18224907e-01f, -1.94188595e-01f, -4.95568663e-01f, 3.27283621e-01f, -8.17467868e-01f, 4.17042226e-01f,
  8.82722661e-02f, 3.43317866e-01f, 2.37786070e-01f, 9.74857286e-02f, -3.76704097e-01f, 1.10328458e-01f, 1.10799745e-01f, -1.70290112e-01f, 9.30408761e-02f, -1.18689328e-01f,
  -7.03921467e-02f, -3.31886202e-01f, -4.40776467e-01f, 4.15860444e-01f, 5.16690969e-01f, -1.31000914e-02f, 4.71390575e-01f, -4.88000035e-01f, 6.49094045e-01f, 7.66706944e-01f,
  -9.06391740e-02f, -1.25473719e-02f, 2.70296842e-01f, -4.83380795e-01f, 1.07215479e-01f, -4.36812907e-01f, -4.97176945e-01f, 2.32706264e-01f, -4.11906779e-01f, 1.37045890e-01f,
  1.13734104e-01f, -5.33329546e-01f, -1.04355171e-01f, -2.82052249e-01f, 4.98529151e-02f, -1.63525134e-01f, 9.93661657e-02f, -1.57011509e-01f, 3.44633758e-02f, 7.11386800e-02f,
  -2.07928032e-01f, -1.63266301e-01f, 1.49772942e-01f, -4.52574566e-02f, 3.62923592e-01f, 3.54428709e-01f, -1.74745396e-01f, 4.06639844e-01f, 2.68113106e-01f, 3.12297076e-01f,
  -1.08149037e-01f, 4.15978551e-01f, 5.39433993e-02f, 4.32115763e-01f, -6.28609121e-01f, 3.41018409e-01f, 4.38307375e-01f, 3.05641800e-01f, -5.63178957e-01f, 5.64110279e-02f,
  -5.31244755e-01f, -6.12665355e-01f, -2.02879950e-01f, 9.94789228e-02f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  2.30599269e-02f, -1.26624510e-01f, -8.92588571e-02f, -5.33558540e-02f, 4.15055230e-02f, 6.15855306e-02f, 1.47678718e-01f, -6.83347089e-03f, -7.88297597e-03f, 1.26045421e-01f,
  -6.70582578e-02f, 2.96313427e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    