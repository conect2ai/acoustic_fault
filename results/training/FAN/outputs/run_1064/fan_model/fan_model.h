/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.38665189e-02f, -2.87707299e-01f, -5.00081740e-02f, 9.93821304e-03f, -1.61597311e-01f, -1.78467527e-01f, -4.63821650e-01f, -1.84528857e-01f, 1.57145619e-01f, -6.03756681e-02f,
  -6.01130016e-02f, 2.44606975e-02f, -1.06914848e-01f, -3.61235142e-02f, -9.88692939e-02f, -1.20738447e-01f, -1.25183761e-01f, -2.03561615e-02f, 3.63715994e-03f, 6.47865608e-02f,
  -1.05235586e-02f, -1.37686595e-01f, 1.75125003e-01f, 9.04754698e-02f, -2.68151537e-02f, 9.68988910e-02f, 5.07160239e-02f, -2.98367757e-02f, 7.08693340e-02f, 8.99152234e-02f,
  1.21823378e-01f, -5.96620776e-02f, 8.42540488e-02f, 1.19508132e-01f, -3.47718224e-02f, 9.60987136e-02f, -4.63724788e-03f, 1.07084394e-01f, -1.93530321e-02f, -1.09380316e-02f,
  4.85474244e-03f, 8.78927857e-02f, -3.00162239e-04f, 4.92790863e-02f, 2.96902880e-02f, -6.27250299e-02f, 6.85124919e-02f, 9.33151543e-02f, 6.85155019e-02f, 1.12079278e-01f,
  1.27501087e-02f, 3.20225779e-04f, -1.07535049e-02f, -7.59724304e-02f, 7.09024295e-02f, -1.85130761e-04f, -6.54564425e-02f, 7.22995102e-02f, 6.99600503e-02f, 1.23923533e-01f,
  4.54769693e-02f, 3.68666351e-02f, 4.99018878e-02f, 6.89258054e-02f, -1.91842411e-02f, 8.88778195e-02f, -1.71425119e-02f, 1.97883770e-02f, 9.33706854e-03f, 2.20240504e-02f,
  7.41881505e-02f, 7.34594911e-02f, 4.52634059e-02f, -3.70466895e-02f, -1.55690098e-02f, -3.22266072e-02f, -1.15819247e-02f, 4.83296514e-02f, 3.56362574e-02f, 6.50617406e-02f,
  5.76423034e-02f, 5.15773669e-02f, 4.17066505e-03f, 3.58253829e-02f, 1.14615157e-01f, 6.86788931e-02f, 2.96697952e-02f, 6.55800104e-02f, -5.80146946e-02f, 3.95434313e-02f,
  -2.14056984e-01f, -1.65495835e-02f, -7.44918361e-02f, -3.57819758e-02f, 8.30261875e-03f, 4.95683178e-02f, -9.54266489e-02f, -7.75998384e-02f, 3.76477209e-03f, -2.51019243e-02f,
  6.51787519e-02f, -3.88791598e-02f, -9.56682563e-02f, 5.03747985e-02f, 5.26574589e-02f, -8.19916576e-02f, 1.93389673e-02f, -1.39054909e-01f, 1.04176044e-01f, 2.11138241e-02f,
  -1.29282391e-02f, -1.16443746e-01f, -1.55234039e-01f, -1.95596814e-01f, 1.02847803e-03f, -4.53133285e-02f, -4.89062183e-02f, -6.48401827e-02f, -1.37051299e-01f, -2.32219592e-01f,
  1.28624132e-02f, -3.63138646e-01f, 3.17868054e-01f, 1.10162415e-01f, 2.35767916e-01f, -4.70114723e-02f, -1.47910222e-01f, -4.70506810e-02f, 7.96261709e-03f, -1.18773147e-01f,
  -1.43036902e-01f, -2.66578496e-02f, -9.19966474e-02f, -9.02555287e-02f, -6.42272830e-02f, 6.58160076e-02f, 3.40847850e-01f, 1.92772835e-01f, 2.43749008e-01f, -3.75863053e-02f,
  6.85077757e-02f, 9.79897678e-02f, 1.87050328e-01f, 1.93021312e-01f, 1.43128917e-01f, 1.41719744e-01f, 2.22203881e-01f, 8.76154900e-02f, 7.67628402e-02f, 2.98236817e-01f,
  3.22238654e-02f, -1.84748292e-01f, 1.78137407e-01f, 7.48492032e-02f, 1.27882957e-01f, 8.10436159e-02f, -1.64620206e-02f, 7.85364211e-02f, -5.58496825e-03f, 9.41060707e-02f,
  1.43984361e-02f, 8.53260458e-02f, 1.34257808e-01f, 2.92690210e-02f, 8.81606564e-02f, 4.14761156e-02f, 5.03398068e-02f, 1.60944089e-01f, 4.40642200e-02f, -8.76235515e-02f,
  4.80637178e-02f, 1.61293879e-01f, 5.47167473e-02f, -3.87405641e-02f, 3.40429246e-02f, 1.27518713e-01f, -5.94327366e-03f, 1.45200836e-02f, -8.99567455e-03f, 8.85153040e-02f,
  1.22958422e-01f, 7.14418292e-02f, -6.17124587e-02f, -8.73652995e-02f, -1.44857660e-01f, -6.47632405e-02f, -4.16378975e-02f, -8.10698718e-02f, 5.42104878e-02f, 2.21804809e-03f,
  -1.69600565e-02f, -9.53560472e-02f, -3.17804217e-02f, -3.14549766e-02f, -1.11771673e-02f, -3.89881060e-02f, 2.17683706e-02f, -1.48020059e-01f, -8.99091363e-02f, -8.54745209e-02f,
  -7.58075621e-03f, -3.03545222e-02f, 3.86158936e-02f, -2.22490393e-02f, -3.12694833e-02f, -3.02581303e-02f, -5.38749546e-02f, -9.99189243e-02f, -1.20656483e-01f, -7.73618519e-02f,
  -2.16503337e-01f, 9.31342244e-02f, 1.27192577e-02f, 4.56311926e-02f, 1.06371060e-01f, 2.76650544e-02f, 5.04065380e-02f, 9.07231048e-02f, 2.97714733e-02f, 5.15544564e-02f,
  -1.63790826e-02f, 1.95045359e-02f, -5.99912852e-02f, 5.63187413e-02f, 1.52673125e-01f, 6.03783801e-02f, -3.17633674e-02f, 1.31958798e-01f, 4.90359291e-02f, 7.94392601e-02f,
  3.47493179e-02f, 7.25741535e-02f, 1.54598402e-02f, -1.11030135e-02f, 7.20431730e-02f, 1.39631733e-01f, 9.67108905e-02f, 8.25446174e-02f, 7.47719705e-02f, -4.92687570e-04f,
  1.70400456e-01f, 2.96632141e-01f, 3.17618251e-01f, 2.79386103e-01f, 2.84854770e-01f, 1.78134695e-01f, 2.62065738e-01f, 7.70155117e-02f, 1.58665760e-03f, 1.72921166e-01f,
  5.12112603e-02f, -1.93243846e-01f, -2.56538000e-02f, -1.51046395e-01f, -7.66204000e-02f, 2.05860600e-01f, 2.80466408e-01f, -3.00501287e-03f, -2.19639823e-01f, -1.02595769e-01f,
  9.89870951e-02f, 4.91861701e-02f, -1.40891463e-01f, -3.57672460e-02f, 1.34687543e-01f, 4.84239357e-03f, 8.73438418e-02f, 1.70658797e-01f, 1.77505434e-01f, 2.64337212e-01f,
  -5.34879752e-02f, 2.87151486e-01f, -2.99494229e-02f, 3.13656516e-02f, 3.94577682e-02f, 3.57490815e-02f, 2.22719484e-03f, 5.29480278e-02f, 6.11627614e-03f, 5.65665551e-02f,
  3.87927368e-02f, 1.06185498e-02f, 1.40034944e-01f, 9.88878608e-02f, 1.28260806e-01f, 9.17088985e-02f, 4.71056513e-02f, 4.51243445e-02f, 1.16422407e-01f, 5.27834743e-02f,
  1.72478870e-01f, 1.24623179e-01f, 1.59677997e-01f, 9.61298943e-02f, 5.39629422e-02f, 1.67336166e-02f, 3.10203973e-02f, 1.16045013e-01f, 6.89161122e-02f, 7.57332295e-02f,
  -1.60261706e-01f, -1.09779440e-01f, 7.79602751e-02f, 2.35725697e-02f, -6.94631785e-02f, -1.14284474e-02f, 4.89248522e-02f, -2.45798081e-02f, -1.65468361e-02f, -6.21535890e-02f,
  7.78528228e-02f, 4.69919890e-02f, -5.59205040e-02f, 4.88209277e-02f, -7.09555149e-02f, 5.36792055e-02f, 9.61318016e-02f, 1.63757149e-02f, 1.57404281e-02f, 1.65796168e-02f,
  2.62735579e-02f, -5.02250344e-02f, 1.99643569e-03f, 7.15045780e-02f, -9.23819374e-03f, 6.19721599e-02f, 4.15208191e-02f, -6.05485775e-02f, 2.52885092e-02f, 4.65937518e-02f,
  -2.09387705e-01f, 1.26205891e-01f, 9.98317078e-03f, -2.42426004e-02f, 7.96898901e-02f, 4.23238613e-02f, 6.84512928e-02f, 5.19412234e-02f, 9.21329856e-02f, 8.62479210e-02f,
  6.93645189e-03f, 6.65200725e-02f, -2.00715777e-03f, 1.83145478e-02f, 5.00316881e-02f, -7.58594740e-03f, 2.19650771e-02f, 4.90252115e-02f, 1.27472114e-02f, -3.36598750e-04f,
  1.25020772e-01f, 1.98634624e-01f, 4.44100052e-02f, -4.17228881e-03f, 2.96512935e-02f, 6.96009845e-02f, -9.88337304e-03f, 8.22305083e-02f, -1.81958470e-02f, 7.59927407e-02f,
  4.72611517e-01f, -4.15964693e-01f, -1.99333504e-01f, 4.50422093e-02f, -1.71637550e-01f, -3.00179720e-01f, -3.33068669e-01f, -1.59600362e-01f, 1.02209054e-01f, -1.73377439e-01f,
  -2.13212222e-01f, 2.17880875e-01f, 2.15784490e-01f, 9.94153321e-02f, 1.55241922e-01f, -2.20919818e-01f, -1.78605486e-02f, 3.60246420e-01f, 3.50170106e-01f, 1.29397169e-01f,
  2.08157562e-02f, 2.39513725e-01f, 1.97418928e-01f, 1.87273383e-01f, -4.81797792e-02f, 1.01108558e-01f, -1.92526966e-01f, -5.19406796e-02f, -1.60320953e-01f, 5.38961627e-02f,
  3.66387889e-02f, -1.89327523e-01f, 8.90140608e-02f, -4.51057367e-02f, -1.09317899e-01f, -1.90518796e-02f, -3.79752256e-02f, 2.54498255e-02f, -9.81818140e-02f, 6.19022641e-04f,
  -5.62120751e-02f, -1.65298302e-02f, 4.37973514e-02f, -1.60550509e-04f, -1.38372675e-01f, -4.33158390e-02f, -2.43671685e-02f, 6.86828885e-03f, -3.67087573e-02f, -1.54025659e-01f,
  -7.60891885e-02f, -1.17725179e-01f, -1.83573425e-01f, -8.37791115e-02f, 1.74958110e-02f, 1.26711443e-01f, -1.50867552e-01f, 3.20865214e-02f, -1.82764065e-02f, -7.11925551e-02f,
  -1.42781764e-01f, -6.80163950e-02f, -2.88734213e-03f, 6.51794150e-02f, -1.65235084e-02f, -2.87387893e-02f, 4.71628681e-02f, 1.86953023e-02f, 3.24486643e-02f, 1.48193222e-02f,
  3.78331281e-02f, -9.12185013e-03f, 6.51269555e-02f, -1.33862877e-02f, 1.23065822e-01f, -8.72252602e-03f, 7.13337883e-02f, 1.97410025e-02f, 2.96025593e-02f, -3.92325968e-02f,
  1.43354341e-01f, 3.88219878e-02f, 8.34885314e-02f, 6.82403073e-02f, 3.33813354e-02f, 3.88132520e-02f, 9.07567590e-02f, -9.36259981e-03f, 1.00020960e-01f, -5.44683710e-02f,
  2.99971527e-03f, -1.51974618e-01f, 7.20964819e-02f, 1.59930274e-01f, 2.07983498e-02f, -2.09702477e-02f, 7.24530667e-02f, 2.77240053e-02f, -1.33302296e-02f, 7.43965656e-02f,
  -7.44195208e-02f, 2.31795404e-02f, -2.51456015e-02f, -3.66629548e-02f, 9.13621560e-02f, 3.73189747e-02f, -1.11994870e-01f, 8.51344839e-02f, -1.24898031e-02f, -8.57765379e-04f,
  -4.99788001e-02f, -1.04335234e-01f, 9.64291617e-02f, -6.76865280e-02f, 2.58781016e-02f, 1.14668183e-01f, 2.29777787e-02f, 3.29956599e-02f, 1.53164100e-03f, -1.16033860e-01f,
  -5.63526675e-02f, 4.65174735e-01f, 5.65563858e-01f, 3.47432405e-01f, 3.87489200e-01f, 1.79104283e-01f, 2.40313351e-01f, 2.03592688e-01f, 1.64513946e-01f, 2.65858948e-01f,
  3.56345296e-01f, 3.04733694e-01f, 3.46118480e-01f, 3.57363075e-01f, 1.60411358e-01f, 3.47783476e-01f, 3.85637820e-01f, 2.10371137e-01f, 1.70455530e-01f, 9.65743214e-02f,
  3.09278309e-01f, 2.13622734e-01f, 1.09738149e-01f, 1.45081341e-01f, 3.50199848e-01f, 1.99934483e-01f, 4.43910748e-01f, 2.34488666e-01f, 2.31158420e-01f, 5.16596913e-01f,
  4.57306713e-01f, 1.44049764e-01f, 1.39883801e-01f, 1.12576142e-01f, 1.83734402e-01f, 9.00425240e-02f, 2.90021181e-01f, 8.50034133e-02f, 1.02393180e-01f, 2.20985666e-01f,
  2.37696394e-01f, 1.88858300e-01f, 2.17945799e-01f, 2.60445893e-01f, 1.23950280e-01f, 5.87472506e-02f, 1.15418471e-01f, 9.84591320e-02f, 1.06992893e-01f, 2.24275663e-01f,
  2.05544472e-01f, 2.81647503e-01f, 2.20386848e-01f, 8.12758282e-02f, 5.66598549e-02f, 1.44022897e-01f, 1.00214981e-01f, 2.38298140e-02f, 6.30121753e-02f, 7.02175722e-02f,
  -8.67387094e-03f, 4.03544605e-02f, -1.37678191e-01f, -1.89284816e-01f, -2.13738456e-01f, -2.18927875e-01f, -2.04896480e-01f, -1.59402221e-01f, -1.85713917e-01f, -1.86513677e-01f,
  -1.16010778e-01f, -2.48738360e-02f, -1.17541082e-01f, -1.51931852e-01f, -1.39034092e-02f, -1.13489449e-01f, -1.96836621e-01f, -1.51534319e-01f, -1.82098806e-01f, -1.58938766e-01f,
  -2.11435914e-01f, -2.67855465e-01f, -1.12569146e-01f, -2.81208038e-01f, -6.65942580e-02f, -1.74849734e-01f, -7.84381106e-02f, -7.15422183e-02f, -4.33079973e-02f, -1.55243233e-01f,
  1.46675169e-01f, 1.25332072e-01f, 9.51089337e-02f, 4.68879193e-02f, 1.20253280e-01f, -4.52306541e-03f, 1.42136842e-01f, 6.00337517e-03f, 2.81851441e-02f, 8.38168636e-02f,
  6.75768480e-02f, 1.89180374e-01f, 1.85956821e-01f, 1.53990671e-01f, 1.62201703e-01f, 5.66768236e-02f, 3.01579516e-02f, 1.73947573e-01f, 1.00607321e-01f, 6.70584366e-02f,
  1.61010429e-01f, 5.83023727e-02f, 6.18693128e-04f, 5.68568893e-02f, 2.28008069e-02f, 1.43460706e-02f, 8.13958496e-02f, 7.57100508e-02f, -2.13408638e-02f, -7.42717609e-02f,
  2.49473542e-01f, 1.93444058e-01f, 3.34293723e-01f, 3.11290205e-01f, 2.34600961e-01f, 9.91330519e-02f, 1.16611198e-01f, -6.03467692e-03f, 6.94811717e-02f, 2.11435810e-01f,
  1.17719565e-02f, 2.15466786e-02f, 1.54695526e-01f, 1.49482369e-01f, 1.89361855e-01f, 1.84474304e-01f, 2.37043649e-01f, 2.63497800e-01f, 1.56692997e-01f, 9.88072976e-02f,
  1.49996966e-01f, 2.23324731e-01f, 2.89827228e-01f, 7.64823332e-02f, 1.61447152e-01f, 8.03368092e-02f, 2.44818002e-01f, 2.00355768e-01f, 2.04979286e-01f, 1.85724586e-01f,
  -1.47637688e-02f, 8.62688422e-02f, -3.30087915e-02f, 2.61821114e-02f, 8.13280866e-02f, 2.78822668e-02f, 2.79879160e-02f, -3.93705443e-03f, 5.48438132e-02f, 4.26390171e-02f,
  5.32398783e-02f, -4.36135903e-02f, -1.75289568e-02f, -5.31578250e-03f, 9.82633606e-02f, 7.50864297e-02f, 1.01051919e-01f, 1.61296472e-01f, 1.31447330e-01f, 6.53040931e-02f,
  7.52942413e-02f, -4.81513049e-03f, -2.67858654e-02f, -8.54460616e-03f, -4.92803417e-02f, 1.31400868e-01f, 8.53761584e-02f, 7.86125101e-03f, 9.63780284e-02f, -9.18028951e-02f,
  1.17864907e-02f, -5.82351908e-02f, -7.32271969e-02f, -2.47446485e-02f, -9.20581222e-02f, -6.23252839e-02f, -5.59570976e-02f, -8.26260224e-02f, -2.67826337e-02f, -1.16445377e-01f,
  -6.16072193e-02f, -1.76668279e-02f, 4.58310060e-02f, 2.76036859e-02f, -1.01279803e-01f, -1.95836592e-02f, -1.17214680e-01f, -2.67896764e-02f, -4.44853045e-02f, -7.23850504e-02f,
  -5.97533360e-02f, -4.41669114e-02f, -8.66415724e-02f, -7.09865391e-02f, -5.74245341e-02f, -6.06199400e-03f, -1.00884639e-01f, -1.10889897e-01f, -1.37462839e-02f, -3.96799482e-02f,
  -1.81736112e-01f, 1.61252826e-01f, 7.18834475e-02f, 3.04138586e-02f, -6.83669522e-02f, -6.12488426e-02f, 5.40885404e-02f, -5.96880093e-02f, -4.50587040e-03f, 8.18444937e-02f,
  6.75460249e-02f, -9.10184998e-03f, 3.97820622e-02f, -5.21545075e-02f, -1.62803810e-02f, -4.21173349e-02f, -5.65708652e-02f, 6.06438108e-02f, -2.60704495e-02f, -2.25827303e-02f,
  3.92864086e-02f, -1.19109362e-01f, -1.73911974e-01f, -1.23374857e-01f, -5.96848987e-02f, -7.16684833e-02f, -3.48796584e-02f, -1.19840980e-01f, -7.85571337e-02f, -1.41711190e-01f,
  6.79683685e-01f, 2.91893393e-01f, 3.46640080e-01f, 4.38566953e-01f, 1.23599775e-01f, 1.06212765e-01f, 1.03452496e-01f, 2.24352598e-01f, 2.68009663e-01f, 3.54157805e-01f,
  2.04940408e-01f, 1.75993562e-01f, 2.13783503e-01f, 9.35258791e-02f, 2.14093417e-01f, 2.08369419e-01f, 1.75632268e-01f, 2.56031215e-01f, 2.24064469e-01f, 5.14402613e-02f,
  -2.82252971e-02f, 1.50541231e-01f, 1.75636530e-01f, 1.75424486e-01f, 6.61218911e-02f, 1.56351432e-01f, 3.03492308e-01f, 2.13631481e-01f, 6.75264671e-02f, 1.34217426e-01f,
  1.99450701e-01f, 2.00476542e-01f, 6.55277148e-02f, 1.42146677e-01f, 7.01722875e-02f, 2.46039733e-01f, 1.46865726e-01f, 2.25487188e-01f, 1.07018985e-01f, 1.43690825e-01f,
  3.78674157e-02f, 1.68896824e-01f, 5.98086454e-02f, 8.57562944e-02f, 9.66657549e-02f, 2.17202976e-01f, 2.19406545e-01f, 1.67197138e-01f, 2.36875385e-01f, 1.30340397e-01f,
  1.54880702e-01f, 2.27936119e-01f, 1.73578575e-01f, 1.93003550e-01f, 1.65965885e-01f, 8.91351774e-02f, 1.24271229e-01f, 1.79684877e-01f, 2.58182585e-01f, 3.17510843e-01f,
  -2.37792879e-02f, -1.81625560e-01f, -1.52497530e-01f, -1.19236186e-01f, -2.07591295e-01f, -2.36614898e-01f, -1.76897332e-01f, -2.43134096e-01f, -2.34925076e-01f, -1.23407379e-01f,
  -2.14836180e-01f, -1.12265311e-01f, -1.55400217e-01f, -9.93831530e-02f, -2.37787828e-01f, -1.56674996e-01f, -1.82599530e-01f, -1.62092358e-01f, -2.09861711e-01f, -2.31157184e-01f,
  -2.40127489e-01f, -1.97222486e-01f, -1.61429211e-01f, -2.72869736e-01f, -2.16621339e-01f, -1.45374194e-01f, -1.52793512e-01f, -1.99837923e-01f, -1.85104534e-01f, -1.88527182e-01f,
  2.83628196e-01f, 2.34275330e-02f, 3.17478359e-01f, 1.21498458e-01f, 1.96756765e-01f, 1.14838123e-01f, 1.27325311e-01f, 1.62887573e-01f, 2.34472215e-01f, 2.45185673e-01f,
  1.45187095e-01f, 1.76342547e-01f, 1.49929613e-01f, 1.57617941e-01f, 1.10977255e-01f, 2.53690958e-01f, 1.51876301e-01f, 2.30384737e-01f, 1.73886567e-01f, 2.03834265e-01f,
  1.58646002e-01f, 3.12400609e-01f, 4.27526534e-01f, 2.83720076e-01f, 1.87851802e-01f, 2.96354830e-01f, 2.77183324e-01f, 1.61211535e-01f, 3.13285887e-01f, 4.29909408e-01f,
  1.49695585e-02f, 5.68179071e-01f, 5.38175106e-02f, -3.06276232e-02f, 1.49649650e-01f, 5.38563617e-02f, 3.56298923e-01f, 1.20045274e-01f, 1.75916068e-02f, 4.15927082e-01f,
  2.61434257e-01f, 2.47634389e-02f, 3.01685184e-02f, 3.62017937e-02f, 1.13851354e-01f, 1.53783500e-01f, 9.22591165e-02f, -1.99762836e-01f, -1.70716807e-01f, 4.97354753e-02f,
  1.04464367e-01f, 8.02601352e-02f, 1.30396351e-01f, 1.50394380e-01f, 3.52075011e-01f, -1.10405858e-03f, 3.10497850e-01f, 2.38076985e-01f, 2.99979031e-01f, 3.08596849e-01f,
  3.10346514e-01f, 4.26608771e-01f, -4.73943092e-02f, 1.79389223e-01f, 2.55677402e-01f, 1.07091218e-01f, 1.92150697e-01f, 1.55967608e-01f, 2.28524134e-01f, 2.53085434e-01f,
  2.01024562e-01f, 1.35794818e-01f, 1.53528571e-01f, 1.72084361e-01f, 2.68322527e-01f, 1.32973254e-01f, 2.88545668e-01f, 1.15873739e-01f, 8.91542062e-02f, 2.12283537e-01f,
  2.61966050e-01f, 2.53805190e-01f, 1.38885319e-01f, 9.79108065e-02f, 1.12427332e-01f, -5.39708370e-03f, 2.82813191e-01f, 1.24613956e-01f, 6.97693378e-02f, 3.49203706e-01f,
  -9.36775357e-02f, -1.45180643e-01f, -1.83787689e-01f, -1.80530161e-01f, -1.56665027e-01f, -2.35511139e-01f, -1.66562945e-01f, -1.72908410e-01f, -2.28756517e-01f, -1.41876251e-01f,
  -2.39403471e-01f, -1.85306326e-01f, -2.10030109e-01f, -1.34018585e-01f, -2.35539138e-01f, -1.12980023e-01f, -2.18079165e-01f, -1.56754896e-01f, -2.08857596e-01f, -1.02000818e-01f,
  -1.91734269e-01f, -1.66755244e-01f, -9.99367163e-02f, -1.95775822e-01f, -1.99881509e-01f, -2.76728451e-01f, -2.45751277e-01f, -1.02881990e-01f, -1.88675672e-01f, -1.17247529e-01f,
  2.70636171e-01f, -8.88373703e-02f, 1.41397491e-01f, 1.87911019e-01f, 1.68481782e-01f, 2.37278387e-01f, 1.51095748e-01f, 1.68031752e-01f, 1.37193069e-01f, 1.59096777e-01f,
  1.87613830e-01f, 1.87364593e-01f, 2.62945920e-01f, 2.09076107e-01f, 1.03335589e-01f, 1.21520035e-01f, 1.96475193e-01f, 1.61588266e-01f, 1.00483976e-01f, 2.56131172e-01f,
  1.83167264e-01f, 4.13212776e-02f, 1.33940279e-02f, 1.13124222e-01f, 1.32229134e-01f, -5.76499216e-02f, 8.81352872e-02f, 5.31748682e-02f, -3.95814590e-02f, 1.04102381e-01f,
  4.15327121e-03f, 5.42031765e-01f, -4.90213960e-01f, -5.08141518e-02f, 2.19382215e-02f, 1.40576452e-01f, 4.06774789e-01f, 3.23987722e-01f, 1.28742173e-01f, 1.35481983e-01f,
  1.93916455e-01f, -1.88489631e-02f, 3.78764719e-02f, -8.22234973e-02f, 2.61869617e-02f, 1.59361258e-01f, -8.19727033e-02f, -2.30376557e-01f, -2.20432684e-01f, -6.51024058e-02f,
  1.66455612e-01f, 1.04158677e-01f, 3.70135643e-02f, -3.49759124e-02f, -7.75380656e-02f, -1.17330573e-01f, -3.82541455e-02f, -1.38005495e-01f, 3.71723883e-02f, -2.76178956e-01f,
  -3.81549627e-01f, 2.17082039e-01f, -9.06346291e-02f, 1.29450396e-01f, -5.43198995e-02f, -3.78201045e-02f, 3.48124541e-02f, 4.21294197e-02f, 2.83210836e-02f, -4.55615520e-02f,
  -7.48914331e-02f, 8.24375674e-02f, -5.15015572e-02f, 2.63151508e-02f, 1.21212922e-01f, 9.45336744e-02f, 5.01381457e-02f, 4.06246074e-02f, -7.03066513e-02f, 3.06405555e-02f,
  1.12796701e-01f, -5.73273674e-02f, -8.78647435e-03f, 4.53735292e-02f, -1.74683090e-02f, -1.21423639e-01f, 4.23009098e-02f, -7.03186840e-02f, -5.07117100e-02f, 3.34761329e-02f,
  -8.52836668e-03f, -7.57879317e-02f, -8.09748620e-02f, 1.39018400e-02f, -3.24934945e-02f, -3.31651769e-03f, -6.58703595e-02f, -5.13365231e-02f, 1.68908630e-02f, -1.83192380e-02f,
  -3.37187797e-02f, 4.69124615e-02f, -3.89749855e-02f, 1.49121443e-02f, -1.86437629e-02f, 1.19463122e-02f, 1.91972964e-02f, -3.96536291e-02f, -3.23645286e-02f, 1.40898181e-02f,
  -6.16367608e-02f, -1.65436223e-01f, -1.04631819e-02f, 4.59974967e-02f, 6.91265091e-02f, 6.23233989e-02f, 7.14398772e-02f, 8.86893570e-02f, 5.81892990e-02f, 8.50746185e-02f,
  5.57754152e-02f, 9.73459035e-02f, -5.81241325e-02f, 4.38387319e-02f, -5.08729741e-03f, -1.22078443e-02f, 9.27417800e-02f, 4.09660628e-03f, -3.08253057e-02f, 8.00020918e-02f,
  2.96449009e-02f, 5.20440154e-02f, 7.33363554e-02f, 3.26272547e-02f, -4.07535769e-02f, 2.16679424e-02f, 8.51299241e-02f, -1.08209789e-01f, -2.68237689e-03f, 6.98964000e-02f,
  1.24660298e-01f, -1.78764127e-02f, -7.48627931e-02f, 5.00705764e-02f, 3.48858163e-02f, -1.81891967e-03f, 5.80783049e-03f, -1.70958578e-03f, -1.18831791e-01f, 1.25024542e-01f,
  -2.42298663e-01f, -3.61904353e-01f, -3.32235187e-01f, 5.57421409e-02f, 3.38851176e-02f, -8.49456117e-02f, -8.66622254e-02f, 5.02180792e-02f, 1.55817926e-01f, 3.36862840e-02f,
  1.57052115e-01f, 3.76797974e-01f, 2.57114142e-01f, 1.33073568e-01f, 8.96650553e-02f, -2.57010728e-01f, -1.22365147e-01f, -5.96541874e-02f, 2.04916388e-01f, 1.71571210e-01f,
  2.73221731e-01f, 1.79337889e-01f, 2.11916447e-01f, 6.88900501e-02f, 9.25837979e-02f, 2.50995547e-01f, -6.11716695e-02f, -2.46038083e-02f, -1.18596405e-01f, -2.06999213e-01f,
  -1.00193851e-01f, -1.93174422e-01f, 1.19170524e-01f, 7.94605911e-02f, 1.03466548e-02f, 4.27555442e-02f, -5.24992533e-02f, 4.85410169e-02f, 1.13669217e-01f, 1.61733087e-02f,
  6.53430820e-02f, 9.17974785e-02f, 3.51587236e-02f, 9.78868306e-02f, -8.90847016e-03f, -3.16276327e-02f, 1.11625634e-01f, -5.27716614e-02f, 8.71596951e-03f, -1.40308484e-01f,
  -3.84786241e-02f, -1.81008726e-02f, -6.30621274e-04f, 5.78627847e-02f, 8.76786932e-03f, 1.91300914e-01f, -2.56932597e-03f, 2.69147083e-02f, -7.14607686e-02f, -7.37360939e-02f,
  -4.06772196e-02f, -1.50235400e-01f, -9.02034715e-03f, -1.39333494e-02f, 1.05049554e-02f, -2.70375647e-02f, -2.43126247e-02f, 1.85681339e-02f, 3.02224923e-02f, -1.77961200e-01f,
  6.52198046e-02f, 2.51097735e-02f, 4.02580090e-02f, 2.75804996e-02f, 6.16137125e-02f, -6.07287325e-02f, -9.48811173e-02f, 3.97838503e-02f, -5.66673605e-03f, 4.93052788e-02f,
  -1.34612271e-03f, -1.50462221e-02f, 7.45236948e-02f, 9.52832587e-03f, -3.53528671e-02f, 7.30512962e-02f, 3.36543024e-02f, -3.07396147e-02f, -6.45032153e-02f, -2.78780032e-02f,
  4.27905202e-01f, 1.42607987e-01f, 3.92173156e-02f, -2.64486473e-04f, -4.91715483e-02f, 5.98178208e-02f, 2.46637911e-02f, 6.97983280e-02f, 4.19755243e-02f, 7.37652406e-02f,
  9.65666175e-02f, 5.74639775e-02f, 1.81640480e-02f, 1.00157052e-01f, 1.02718242e-01f, 3.43169346e-02f, 2.61752009e-02f, 1.09385021e-01f, -4.42247428e-02f, -2.86453031e-03f,
  -3.53424698e-02f, -2.85015814e-02f, -1.51179722e-02f, -3.61773558e-03f, -6.65779412e-02f, 9.54274088e-02f, -3.79790813e-02f, -2.10389160e-02f, 1.25761583e-01f, 4.33452465e-02f,
  3.14308882e-01f, -1.48446456e-01f, 1.63530946e-01f, 1.23183757e-01f, 1.82099506e-01f, 1.69103920e-01f, 3.69175583e-01f, 3.44181716e-01f, -1.36449123e-02f, -6.33579716e-02f,
  -1.56638354e-01f, -2.28838459e-01f, -2.66537219e-01f, -8.31365436e-02f, 1.36370659e-01f, 9.83354524e-02f, 1.61354654e-02f, 9.06542465e-02f, 2.09623531e-01f, 9.89892781e-02f,
  -6.54138699e-02f, 9.72855017e-02f, 2.67590106e-01f, 1.79754511e-01f, -2.07328312e-02f, -7.02106059e-02f, -2.69926316e-03f, 7.94213172e-03f, -1.19933337e-01f, -1.48334593e-01f,
  -2.85152018e-01f, 4.17403840e-02f, 1.31149068e-01f, 6.24741602e-04f, 1.45001411e-02f, 4.64543030e-02f, 4.63019833e-02f, 1.36028871e-01f, 3.05953231e-02f, 6.67857099e-03f,
  -5.00890575e-02f, 2.59052176e-04f, -5.99545538e-02f, 7.78590590e-02f, 6.43646121e-02f, 1.27710387e-01f, 1.22284643e-01f, 2.10533082e-01f, 3.59864645e-02f, -7.44462293e-03f,
  -4.54566143e-02f, 6.19716346e-02f, 8.45386535e-02f, 9.51097235e-02f, 7.87098184e-02f, 4.30684835e-02f, 1.63819030e-01f, 6.10149093e-02f, 1.64700419e-01f, 1.40277714e-01f,
  -1.09400190e-01f, 2.04272307e-02f, 5.55514954e-02f, 5.65092936e-02f, 8.25445279e-02f, -8.59925151e-02f, -2.48247534e-02f, 8.75241086e-02f, 4.38430943e-02f, 7.60067329e-02f,
  3.98603790e-02f, -3.30615640e-02f, 4.21549520e-03f, 5.41222505e-02f, -4.51238751e-02f, 1.75432153e-02f, 4.76756357e-02f, 1.22219101e-02f, 4.29091007e-02f, 2.86691505e-02f,
  1.25148995e-02f, 1.47295952e-01f, 3.88457030e-02f, 6.00878038e-02f, 3.46023217e-02f, 1.20703571e-01f, 8.95822793e-02f, 8.84828269e-02f, 5.08938208e-02f, 1.36404950e-02f,
  -1.04862444e-01f, -4.68483148e-03f, -1.52306944e-01f, -4.46578721e-03f, 2.03593653e-02f, -2.69656889e-02f, -5.67880124e-02f, -4.44612317e-02f, -5.86995706e-02f, 7.23688081e-02f,
  6.12293258e-02f, 1.08961225e-01f, -4.53851707e-02f, 2.74491906e-02f, 1.13241471e-01f, 5.31631820e-02f, 5.42363971e-02f, 4.65471186e-02f, -4.00854237e-02f, 2.91216113e-02f,
  -2.42784247e-02f, 1.40922159e-01f, 1.22167416e-01f, 2.04836875e-02f, -3.41621153e-02f, -7.82585219e-02f, 2.71195974e-02f, 6.79097846e-02f, 8.98718908e-02f, 2.77776182e-01f,
  4.82044905e-01f, -3.63167763e-01f, 5.11989966e-02f, 1.26237527e-01f, -1.57629341e-01f, -1.14874393e-01f, -3.47357571e-01f, -1.00470625e-03f, 3.41256559e-01f, 2.10965741e-02f,
  -3.65947299e-02f, 1.21418394e-01f, 1.69843376e-01f, 8.93681198e-02f, 3.58725078e-02f, -6.71684518e-02f, 7.61719374e-03f, 1.27660081e-01f, 1.83705956e-01f, -2.10511615e-03f,
  -1.57376334e-01f, -7.37941116e-02f, 9.23360586e-02f, -2.14749221e-02f, 3.65743227e-02f, 2.38622710e-01f, 1.11668520e-01f, -4.98769246e-02f, -7.11714402e-02f, -2.51144241e-03f,
  2.52227455e-01f, -6.00055500e-04f, 9.96768698e-02f, 4.30243611e-02f, 6.24773316e-02f, 1.45056412e-01f, 1.51796594e-01f, 8.86132345e-02f, 1.11755833e-01f, 1.03852049e-01f,
  1.78959146e-02f, -3.20021845e-02f, -3.43322381e-02f, 4.40741368e-02f, -6.48627132e-02f, -3.89693119e-02f, -5.60049564e-02f, 6.59297854e-02f, 4.36052978e-02f, -1.00646749e-01f,
  -1.10014133e-01f, -1.80143356e-01f, 1.00280248e-01f, 3.77002358e-02f, -9.64199007e-03f, 5.47844023e-02f, 4.83722016e-02f, 1.06528677e-01f, 9.20578614e-02f, 2.52421260e-01f,
  1.09265618e-01f, 1.22621074e-01f, -1.18703851e-02f, 2.90108398e-02f, -2.62414897e-03f, -2.72079743e-02f, -2.26970040e-03f, -1.05148591e-01f, -6.63385093e-02f, -7.74911642e-02f,
  -4.58542146e-02f, -3.23228128e-02f, -6.36493117e-02f, 1.66688748e-02f, 1.55314477e-02f, -1.23799574e-02f, -6.14572465e-02f, -8.78124610e-02f, -1.76332384e-01f, -1.31700233e-01f,
  -6.21834770e-03f, -3.82400118e-02f, -3.55968401e-02f, -1.07015744e-01f, -6.64544851e-02f, -1.27046511e-01f, -7.78483879e-03f, -6.34778962e-02f, 8.79138801e-03f, -4.46294397e-02f,
  3.06513160e-01f, -1.62440434e-01f, 1.81618616e-01f, 1.41127467e-01f, -1.55777009e-02f, 7.09474534e-02f, -1.46865416e-02f, -1.30812451e-02f, 3.84983271e-02f, -2.83756666e-02f,
  2.34331619e-02f, 7.65016526e-02f, 6.94710538e-02f, 5.62740490e-02f, 6.80035725e-02f, 1.96276396e-03f, -1.71772260e-02f, 8.47065151e-02f, 1.02940969e-01f, -2.48452742e-02f,
  3.84031795e-02f, 1.76444948e-02f, 2.10618109e-01f, 5.32012060e-02f, 5.50747439e-02f, 2.68199116e-01f, 1.55571297e-01f, 1.21558912e-01f, 2.38296300e-01f, 2.06273928e-01f,
  -3.90178233e-01f, -2.82558918e-01f, -3.88860077e-01f, -1.27970338e-01f, 3.31225246e-02f, -6.20550588e-02f, -1.78644389e-01f, -6.57020807e-02f, 4.38596532e-02f, -1.28062055e-01f,
  -9.98218358e-02f, 1.67871818e-01f, 3.99096943e-02f, 1.59329861e-01f, 2.70293094e-02f, -1.68251812e-01f, 7.72993127e-03f, 7.14751258e-02f, 5.74511588e-02f, 1.18486851e-01f,
  1.96215227e-01f, 1.37953997e-01f, -7.41914846e-03f, 2.30911493e-01f, 1.87097624e-01f, 2.04210430e-01f, -6.65929019e-02f, -7.56447688e-02f, -3.23938131e-02f, 8.58113691e-02f,
  -1.34747118e-01f, -1.29830837e-01f, 1.82910144e-01f, 2.59854108e-01f, 1.46432266e-01f, 5.78481369e-02f, 8.25362578e-02f, 1.28829211e-01f, 4.45780344e-02f, -3.42404912e-03f,
  6.76902011e-02f, 8.08372572e-02f, 1.95067480e-01f, 1.18144266e-01f, 9.32093039e-02f, 9.11776870e-02f, 6.74394295e-02f, 1.09508842e-01f, 5.36574498e-02f, 4.17415202e-02f,
  2.20690995e-01f, -2.96818502e-02f, -3.28477249e-02f, -3.36339921e-02f, 8.17035213e-02f, 9.08668563e-02f, 3.73397209e-02f, 2.18285806e-02f, -4.08045342e-03f, 3.13916244e-02f,
  -7.96404108e-02f, -2.34026071e-02f, -5.50823584e-02f, -5.13632260e-02f, -5.50924130e-02f, -8.15070048e-02f, -6.24770410e-02f, -5.07349633e-02f, -9.87585187e-02f, -4.99870703e-02f,
  -8.06869492e-02f, -1.36339381e-01f, -2.50678584e-02f, -4.19075266e-02f, -2.10549142e-02f, -5.23945969e-03f, -7.46925771e-02f, -9.70480870e-03f, -9.41325910e-03f, -9.00679454e-02f,
  -1.08315699e-01f, -2.34279055e-02f, -1.55936852e-02f, 8.30811039e-02f, -4.58799899e-02f, -1.22486383e-01f, -1.51124792e-02f, -8.57817978e-02f, -2.86615025e-02f, -8.50138664e-02f,
  -2.13285293e-02f, 1.04163244e-01f, -9.92287043e-03f, 1.00238740e-01f, 4.01640609e-02f, 1.27310187e-01f, 1.14084356e-01f, 7.92402849e-02f, 3.12638842e-02f, 1.00434005e-01f,
  1.41200319e-01f, 1.47987098e-01f, 1.40428007e-01f, 1.14554919e-01f, 7.47419670e-02f, 9.27308202e-02f, 1.36680901e-01f, 2.79018823e-02f, 6.79544583e-02f, 1.33711919e-01f,
  1.25937819e-01f, 2.62003373e-02f, -1.00447267e-01f, -2.68278979e-02f, -7.62282088e-02f, -5.68682887e-02f, -1.12587415e-01f, -6.83800578e-02f, -5.32469377e-02f, -3.84252309e-03f,
  1.46062583e-01f, -1.38059169e-01f, -2.73334473e-01f, 2.08069965e-01f, 3.15329403e-01f, 3.70974183e-01f, 3.62586766e-01f, 1.70235038e-01f, 2.21744254e-01f, 9.82748941e-02f,
  9.11632627e-02f, 2.04356700e-01f, -7.62161389e-02f, 9.59702767e-03f, -8.58700946e-02f, -1.38955534e-01f, -2.23374709e-01f, -1.56634971e-01f, 7.11707100e-02f, 4.35228765e-01f,
  2.41441876e-01f, 4.81122658e-02f, -9.60698631e-03f, -1.20222941e-03f, 1.19732387e-01f, 7.16962060e-03f, -1.74254835e-01f, 1.68057933e-01f, 1.31015033e-01f, -1.03276610e-01f,
  -6.90839663e-02f, 1.18513368e-01f, -4.07239236e-03f, -2.48921923e-02f, 5.51304743e-02f, -1.02689669e-01f, -5.94087839e-02f, -4.22757976e-02f, 1.11349775e-02f, -7.46466639e-03f,
  1.18113570e-01f, -3.03550344e-02f, 1.18972678e-02f, 9.65474918e-02f, 2.47974414e-02f, 5.81629612e-02f, -6.98551163e-02f, 6.96076546e-03f, -5.71718216e-02f, 5.79240248e-02f,
  1.21323436e-01f, 4.65136021e-02f, 1.22613162e-01f, -3.67122553e-02f, 1.11909799e-01f, -1.94362886e-02f, 7.98272062e-03f, 4.61312570e-02f, -3.12710702e-02f, -8.13357309e-02f,
  4.68692072e-02f, -8.19384307e-02f, 3.81956585e-02f, -3.78664918e-02f, 6.83773495e-03f, -7.95840919e-02f, -9.54224393e-02f, 6.75029084e-02f, -9.83808935e-03f, -8.55019167e-02f,
  -6.97018057e-02f, -1.39469504e-02f, -1.17110588e-01f, -5.57114333e-02f, -6.70663714e-02f, -3.64849751e-04f, 6.04905076e-02f, -9.51595604e-02f, 1.66803170e-02f, 6.75664609e-03f,
  -4.65811901e-02f, -1.64173264e-02f, -1.41780199e-02f, -3.74617353e-02f, 4.50635366e-02f, -8.41382518e-02f, 2.08868664e-02f, 1.86525285e-02f, -1.79869588e-02f, -4.86670583e-02f,
  -6.53548315e-02f, 3.44020724e-02f, 4.46378998e-02f, 5.34021109e-02f, 2.46165860e-02f, 1.87342912e-02f, 6.20643236e-02f, 5.32807894e-02f, 9.06141847e-02f, 6.03135377e-02f,
  -9.32795089e-03f, -5.56683056e-02f, -2.91554723e-02f, 1.35582071e-02f, 1.52235717e-01f, 2.81831510e-02f, -1.50178876e-02f, 1.82369202e-02f, 1.05200499e-01f, -4.10978012e-02f,
  -1.06330469e-01f, 8.53787065e-02f, 6.93430081e-02f, -2.35943068e-02f, 1.16314784e-01f, 7.96942860e-02f, -7.74801970e-02f, -1.10072847e-02f, 4.92318422e-02f, -1.56853423e-01f,
  -1.34298384e-01f, 2.95139074e-01f, 1.61158785e-01f, 6.94197044e-02f, -1.08073661e-02f, 1.57154679e-01f, 2.59013087e-01f, 8.41632262e-02f, 6.70373067e-02f, 1.41852081e-01f,
  -1.91454552e-02f, -1.81353539e-01f, -6.91394508e-02f, 6.23684004e-02f, 1.03999592e-01f, 4.26492542e-01f, 2.59609699e-01f, 9.34194699e-02f, 1.89742111e-02f, 1.29791945e-01f,
  1.98077992e-01f, 4.87372503e-02f, 1.68872193e-01f, 1.39258757e-01f, 4.03174907e-01f, 1.13732614e-01f, 3.03156227e-01f, 3.11906755e-01f, 3.35773915e-01f, 3.86116624e-01f,
  2.25109220e-01f, -1.49304355e-02f, 8.23145825e-03f, -8.23560804e-02f, 2.74955127e-02f, 1.77615374e-01f, 8.09097588e-02f, 7.64285177e-02f, 2.56334879e-02f, 1.66494101e-01f,
  3.81813571e-02f, 1.13106295e-01f, 1.07071690e-01f, 5.63229583e-02f, 9.83314067e-02f, 1.51256621e-01f, 8.29937458e-02f, 8.41692612e-02f, 4.99597900e-02f, 2.05954298e-01f,
  5.35632968e-02f, 2.02027500e-01f, 1.50634810e-01f, 2.10257724e-01f, 2.62336105e-01f, 4.58092913e-02f, 2.14108899e-01f, 2.39337519e-01f, 1.97720662e-01f, 3.82130772e-01f,
  -6.94113690e-03f, -1.38068095e-01f, -9.05151740e-02f, -1.21145643e-01f, -4.69562374e-02f, -7.18828514e-02f, -3.44160311e-02f, -1.11417502e-01f, 2.18056448e-04f, 9.35248192e-03f,
  -1.70066133e-01f, -3.29898596e-02f, -1.17412739e-01f, -1.52378418e-02f, -7.35032707e-02f, -7.64719024e-02f, -8.03066567e-02f, 3.48055582e-05f, -2.09361780e-02f, -4.31754738e-02f,
  -9.11029428e-02f, -1.12231635e-01f, -6.41539171e-02f, -9.18609872e-02f, -8.72604102e-02f, -9.35950801e-02f, -6.81388900e-02f, -1.84042051e-01f, -1.79904044e-01f, -1.64163738e-01f,
  4.00045328e-02f, -1.73478335e-01f, 2.17382416e-01f, 1.90389439e-01f, 1.32152081e-01f, 1.31762803e-01f, 1.24636956e-01f, 7.73360729e-02f, 5.54400170e-03f, 2.00397357e-01f,
  1.87436268e-01f, 8.24052766e-02f, 1.15634017e-01f, 2.31122419e-01f, 1.66713148e-01f, 1.52448311e-01f, 2.28575096e-01f, 1.42234027e-01f, 1.49981692e-01f, 1.86932236e-01f,
  1.23541117e-01f, 2.42162600e-01f, 2.56055713e-01f, 1.61406979e-01f, 2.67393440e-01f, 7.75687844e-02f, 3.11420411e-01f, 3.45520109e-01f, 2.88433015e-01f, 4.27400857e-01f,
  -5.08472145e-01f, 4.16192383e-01f, 2.47762144e-01f, -2.51376539e-01f, -1.04285158e-01f, 2.34293938e-02f, 3.58950406e-01f, 1.47282839e-01f, 6.90661520e-02f, 1.00095794e-01f,
  -1.03057720e-01f, -2.48525515e-01f, 3.82318310e-02f, 3.83926881e-03f, 1.16739683e-01f, 3.19281548e-01f, 2.39272490e-01f, -1.30578741e-01f, -2.37786204e-01f, -1.09583147e-01f,
  -5.31976409e-02f, -1.27145201e-01f, -1.80555031e-01f, 1.96325462e-02f, 1.26931965e-01f, -1.00361854e-01f, 2.79012203e-01f, 5.24509065e-02f, 1.04013823e-01f, 6.54377937e-02f,
  4.52131219e-02f, -2.69201323e-02f, -1.32900000e-01f, -8.39577615e-02f, 8.43977034e-02f, 8.84214938e-02f, -7.27988482e-02f, 5.18173613e-02f, 3.36331390e-02f, 4.84230481e-02f,
  -5.12576997e-02f, 4.21421118e-02f, -1.16341850e-02f, 1.33040905e-01f, 1.08738318e-02f, 8.01716819e-02f, 1.10388599e-01f, 9.66484398e-02f, 4.01751101e-02f, 1.81792542e-01f,
  6.04551435e-02f, -1.30709112e-01f, 4.07642201e-02f, 1.97276697e-01f, 7.27695823e-02f, -1.18327335e-01f, 1.40290678e-01f, 7.70635381e-02f, 5.29546589e-02f, 1.35218039e-01f,
  -1.14464492e-01f, 3.75629286e-03f, -6.99820137e-03f, 2.55080755e-03f, 2.71370150e-02f, 7.13771814e-03f, 3.33489999e-02f, 8.82421527e-03f, -6.94170818e-02f, 3.83277051e-02f,
  -7.83054996e-03f, 2.96372380e-02f, 1.95754413e-02f, -3.04951463e-02f, -7.89566562e-02f, 6.41880184e-02f, -3.56741585e-02f, 5.05387001e-02f, -6.10699281e-02f, 3.27840485e-02f,
  -5.98661751e-02f, 3.49363536e-02f, 3.07866111e-02f, 6.93153590e-02f, 3.67853567e-02f, -7.29756337e-03f, 6.63435459e-03f, -6.75088763e-02f, 2.35739481e-02f, 6.35746941e-02f,
  4.04247567e-02f, -2.03565136e-01f, 6.34739175e-03f, 3.13193304e-03f, -6.48719445e-02f, 4.53582918e-03f, -5.37916161e-02f, -2.10541971e-02f, -1.57539934e-01f, 2.04763766e-02f,
  -2.92171165e-02f, -5.81847280e-02f, -1.64767765e-02f, 1.97917856e-02f, -9.08659305e-03f, -8.41389075e-02f, 2.22591143e-02f, -3.80335152e-02f, 4.96746115e-02f, 5.10209315e-02f,
  1.11934647e-01f, -4.65507992e-02f, -1.57760635e-01f, -1.55144660e-02f, 7.71125108e-02f, -2.06458256e-01f, 3.44115449e-03f, 2.16505434e-02f, -6.09700531e-02f, 3.55156548e-02f,
  -1.70877159e-01f, -3.82057309e-01f, -1.25344813e-01f, -2.38925051e-02f, 1.80691898e-01f, 7.18932226e-02f, -1.72727987e-01f, -3.90426181e-02f, 9.22629908e-02f, -1.59449860e-01f,
  -2.41510961e-02f, 7.23443460e-03f, -3.12349312e-02f, 1.71280354e-02f, 3.85656096e-02f, -1.18945971e-01f, -2.67766323e-02f, 2.45904475e-01f, 3.43184918e-01f, 3.02194208e-01f,
  2.16687858e-01f, 2.01627463e-01f, 2.15464398e-01f, 7.41729364e-02f, 7.59454891e-02f, 1.81309357e-01f, 3.02332640e-02f, 7.71651976e-03f, 1.03250377e-01f, -1.04095362e-01f,
  7.42096081e-02f, -2.23264381e-01f, 3.07927877e-01f, 1.89398438e-01f, 1.43075943e-01f, 7.22359717e-02f, 5.75448051e-02f, 4.38244231e-02f, 1.12730116e-01f, 1.01292305e-01f,
  1.55763090e-01f, 2.17941418e-01f, -1.76177770e-02f, 1.64417624e-01f, 6.69097751e-02f, 1.76530942e-01f, 8.33651349e-02f, -3.36907208e-02f, 7.81674497e-03f, 1.04864843e-01f,
  1.22136541e-01f, 1.53079882e-01f, 7.03814402e-02f, 1.93594750e-02f, 6.03175350e-02f, 2.55887181e-01f, -2.54107825e-02f, 1.64948419e-01f, 7.19849691e-02f, -5.74041158e-02f,
  1.48216188e-01f, -7.24410787e-02f, -1.12759173e-01f, -1.00066029e-01f, -1.09160259e-01f, -9.25203189e-02f, -1.00582734e-01f, -7.86625668e-02f, -3.14828791e-02f, -8.91098008e-03f,
  -5.01599833e-02f, -5.05134501e-02f, -6.87926933e-02f, -2.12896273e-01f, -9.69781652e-02f, -1.62089914e-01f, -4.39052805e-02f, -1.09290123e-01f, -2.81918831e-02f, -1.20247096e-01f,
  -3.14636566e-02f, -6.66374117e-02f, -4.61558253e-02f, -1.99212849e-01f, -1.58119828e-01f, -7.16084242e-02f, -4.65347357e-02f, -5.07799052e-02f, -9.54469889e-02f, -7.05873920e-03f,
  -1.22870594e-01f, 2.19243407e-01f, 4.40242179e-02f, 9.81903002e-02f, 1.33223101e-01f, 1.22126572e-01f, 9.42421928e-02f, 1.66555017e-01f, 1.20465964e-01f, 1.18765488e-01f,
  1.86934143e-01f, 7.89314806e-02f, 5.94093427e-02f, 7.91573599e-02f, 2.75088757e-01f, 2.35293180e-01f, 9.34989974e-02f, 3.69551070e-02f, 1.32037029e-01f, 6.65777698e-02f,
  1.07934594e-01f, 1.90999404e-01f, 1.73934177e-01f, 9.43042114e-02f, 1.30831093e-01f, 2.48908430e-01f, 1.43755734e-01f, 1.74552307e-01f, 1.20795891e-01f, 1.18970238e-02f,
  -4.31654543e-01f, 1.97072417e-01f, -2.50381082e-01f, 6.75442964e-02f, -7.83931985e-02f, -2.54629642e-01f, -3.76748651e-01f, -1.35241687e-01f, 6.01553842e-02f, -2.17372067e-02f,
  5.34004271e-02f, 1.07219234e-01f, 1.37424752e-01f, -3.19928415e-02f, -2.34774277e-01f, -6.32622391e-02f, -8.82085785e-02f, -2.00248554e-01f, -2.76200116e-01f, -4.02791202e-02f,
  1.40494391e-01f, 8.91965777e-02f, 6.46867156e-02f, 1.41322702e-01f, 3.47913623e-01f, 2.10670441e-01f, 1.74621359e-01f, 1.02449963e-02f, 8.29845667e-02f, 3.01672935e-01f,
  2.63438858e-02f, -1.04044281e-01f, -1.25009278e-02f, 9.54866186e-02f, 7.37111345e-02f, -1.01612180e-01f, -1.19034797e-01f, 3.69616151e-02f, 3.50028537e-02f, 7.45297549e-03f,
  -4.09220345e-03f, 3.45194265e-02f, 7.13069597e-03f, 5.14921844e-02f, 2.59366189e-03f, 3.00906021e-02f, 9.28326026e-02f, 3.02698407e-02f, 6.43292144e-02f, 3.38132717e-02f,
  1.98001429e-01f, -7.49247670e-02f, -4.56108153e-02f, -4.92420197e-02f, -5.38052879e-02f, -5.95960803e-02f, -6.67503253e-02f, -1.27798663e-02f, -2.97245886e-02f, 8.25715512e-02f,
  1.61250811e-02f, 4.09212038e-02f, -5.05357161e-02f, -8.93459376e-03f, -2.62092873e-02f, -4.12412547e-02f, -1.08322557e-02f, -4.30268534e-02f, 8.54209065e-03f, -7.23411888e-02f,
  -1.61438975e-02f, -4.88541601e-03f, -1.69524411e-03f, -7.25214481e-02f, 4.72011752e-02f, -5.76627366e-02f, -6.00055829e-02f, 4.12994400e-02f, -2.51645483e-02f, -1.93598047e-02f,
  -9.49723125e-02f, -7.80984238e-02f, 2.08493080e-02f, 4.99487948e-03f, -6.11231662e-04f, -2.25552102e-03f, -2.92816889e-02f, -3.90036479e-02f, -4.89383414e-02f, -3.44494097e-02f,
  2.85227776e-01f, -2.39513740e-01f, 5.68530038e-02f, 4.86187339e-02f, -5.58175929e-02f, 1.24143913e-01f, 4.91500609e-02f, -3.79123446e-03f, 2.20067687e-02f, 9.31326821e-02f,
  4.14636172e-03f, 5.33442833e-02f, 4.60769087e-02f, 3.94227356e-02f, -3.66975926e-02f, -6.13367260e-02f, 9.42323506e-02f, 3.79571952e-02f, -4.15006466e-02f, 1.47828206e-01f,
  2.73819230e-02f, -6.54703155e-02f, -4.41420451e-02f, 3.31812329e-03f, -1.70836858e-02f, -9.51614082e-02f, 3.34129632e-02f, -3.24200168e-02f, -1.86671034e-01f, -8.34332779e-02f,
  1.25294462e-01f, 3.02915037e-01f, 1.92107171e-01f, 1.15003381e-02f, 4.58611958e-02f, 1.09300911e-01f, -2.38446072e-02f, -7.85617158e-02f, -1.03904203e-01f, -5.02363022e-04f,
  2.62256056e-01f, -3.75544466e-02f, 4.01649214e-02f, -1.25770390e-01f, -1.95552126e-01f, -2.49696374e-01f, -2.94521391e-01f, -2.84942776e-01f, -2.71803051e-01f, -3.02607268e-01f,
  -2.68259645e-01f, -1.67693570e-01f, -1.53079972e-01f, -5.62352464e-02f, -7.62604624e-02f, -1.06390089e-01f, 2.35884771e-01f, 1.20039217e-01f, 1.84774294e-01f, -7.12073296e-02f,
  7.61262327e-02f, 2.35910937e-01f, -2.60528568e-02f, -3.59168625e-03f, 1.25642791e-01f, 3.35807875e-02f, 1.91186652e-01f, 9.75922644e-02f, 1.32309005e-01f, -5.57760000e-02f,
  1.74415648e-01f, 2.58323569e-02f, 1.29678801e-01f, 1.53264418e-01f, 1.21225089e-01f, -3.08491141e-02f, 1.56670939e-02f, 4.06168327e-02f, -1.00241350e-02f, 3.05805765e-02f,
  -4.93762922e-03f, 8.17569196e-02f, 1.01334602e-01f, 6.88071772e-02f, 1.15871236e-01f, 4.04917784e-02f, 1.25742674e-01f, 1.43024042e-01f, 1.13167740e-01f, 1.42403111e-01f,
  -4.28097770e-02f, 2.07049660e-02f, -5.02017513e-02f, -1.64006874e-02f, -8.23944956e-02f, -1.59901336e-01f, -9.46466997e-02f, -1.88806832e-01f, -1.27213463e-01f, -9.64407846e-02f,
  -1.53487444e-01f, -3.11802961e-02f, -1.34242550e-01f, -1.76732451e-01f, -1.96409628e-01f, -1.46599263e-01f, -1.52812019e-01f, -2.63180465e-01f, -1.86571181e-01f, -8.91575068e-02f,
  -1.02557868e-01f, -8.41633081e-02f, -5.25787771e-02f, -1.23712324e-01f, -1.03971161e-01f, -1.43066570e-01f, -1.15916125e-01f, -1.14834696e-01f, -1.09223276e-01f, -1.33247092e-01f,
  1.96803734e-01f, 2.60932475e-01f, -9.54143405e-02f, -7.00588897e-02f, 4.95812558e-02f, 1.14629768e-01f, 5.00326417e-02f, -3.97249423e-02f, 1.28822386e-01f, 2.62477752e-02f,
  5.79573400e-03f, -2.89760120e-02f, 3.14317644e-02f, 1.03538759e-01f, 1.35531351e-02f, 1.32809523e-02f, -6.97628632e-02f, 3.62607799e-02f, 6.29445612e-02f, 9.25627723e-02f,
  -2.29318794e-02f, -6.00539148e-02f, -2.47914568e-01f, -4.00099792e-02f, -8.48911405e-02f, -1.34645730e-01f, 2.77026184e-03f, 6.09897226e-02f, -2.86562704e-02f, -8.43614638e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.11939499e-01f, 2.30788857e-01f, -1.25227642e+00f, 8.72384235e-02f, -8.10155794e-02f, -3.65510076e-01f, -3.94252956e-01f, -3.46521646e-01f, 7.34053776e-02f, 4.48927842e-02f,
  9.56199914e-02f, -6.48965612e-02f, -5.56647956e-01f, -1.49117976e-01f, -4.86156464e-01f, -4.70792562e-01f, -3.89676541e-01f, -5.11753440e-01f, -1.60809964e-01f, 9.09328282e-01f,
  8.12926531e-01f, 4.75315630e-01f, 3.23772103e-01f, 1.52940258e-01f, 6.41839147e-01f, 3.06714147e-01f, -6.55971467e-02f, 4.16647524e-01f, 2.93237954e-01f, 4.82491106e-02f,
  -7.35356808e-02f, -2.00088441e-01f, -2.59876877e-01f, 2.11283743e-01f, -2.68936902e-02f, 5.68735674e-02f, -1.27067473e-02f, -3.52764934e-01f, -3.57872993e-01f, -1.42790005e-01f,
  -1.25378892e-02f, 1.44838333e-01f, -1.59157902e-01f, 1.12244070e-01f, 5.17871156e-02f, -1.92268923e-01f, 9.73585770e-02f, -5.13426721e-01f, -7.30158567e-01f, 3.20834778e-02f,
  4.09410566e-01f, 2.00402394e-01f, -5.30402780e-01f, -2.33579978e-01f, -2.67235130e-01f, -2.04287499e-01f, -1.66274920e-01f, 1.90732200e-02f, -4.80154425e-01f, 3.67514044e-02f,
  1.67744398e-01f, -7.16870651e-02f, 1.86798221e-03f, 1.71906561e-01f, 2.66272336e-01f, -1.36893138e-01f, 7.15051144e-02f, 2.42651105e-01f, -3.17042284e-02f, -2.90713236e-02f,
  -1.35481164e-01f, -1.98558524e-01f, -1.52432844e-01f, -1.35403931e-01f, -6.20040409e-02f, -1.36684999e-01f, -9.83021483e-02f, 1.79025427e-01f, -6.87549561e-02f, -1.32501632e-01f,
  5.79341240e-02f, -1.29650310e-01f, -1.81480601e-01f, -2.42884066e-02f, 2.89048161e-02f, -9.34956819e-02f, 1.26274422e-01f, 6.89377543e-03f, -1.32022664e-01f, 9.14188009e-03f,
  1.63154557e-01f, -3.81373852e-01f, 5.35838380e-02f, 5.81226572e-02f, 4.75013182e-02f, 6.83940426e-02f, 5.84776923e-02f, 2.49973789e-01f, -1.88374132e-01f, -4.34071338e-03f,
  3.19874585e-02f, -1.22138850e-01f, -1.64050981e-01f, -1.35019436e-01f, 1.36669785e-01f, -7.40266666e-02f, 4.56456214e-01f, -1.67813107e-01f, -1.87917501e-01f, 1.97155029e-01f,
  1.21158354e-01f, -7.86477551e-02f, 1.07909121e-01f, -4.93674248e-01f, -4.73792851e-03f, -1.85570985e-01f, -8.85087922e-02f, 8.17775801e-02f, -3.47939283e-01f, 1.87688917e-01f,
  1.23180175e+00f, -3.27103287e-01f, -9.34630632e-01f, 5.73325336e-01f, -4.02459763e-02f, 1.20736677e-02f, -2.10072398e-01f, 4.26750064e-01f, 3.68868887e-01f, -3.72304887e-01f,
  7.11178109e-02f, 8.08851063e-01f, 2.63383210e-01f, 1.26062185e-01f, 4.13218029e-02f, -7.88139284e-01f, -9.51604187e-01f, -3.74532551e-01f, 4.20972466e-01f, 5.99625409e-01f,
  2.08497912e-01f, 1.43676415e-01f, 1.59446806e-01f, 1.34736970e-01f, -1.76971629e-01f, 7.58366799e-03f, -8.19877028e-01f, -3.92084837e-01f, -4.47519541e-01f, -1.02625144e+00f,
  -2.91386724e-01f, 1.52092636e-01f, 5.38242944e-02f, 8.51978064e-02f, -1.55059069e-01f, 1.05151959e-01f, 4.75747325e-03f, -4.27324921e-01f, 3.08609009e-02f, -3.88754845e-01f,
  -6.11939132e-02f, 5.11468723e-02f, 1.87273726e-01f, -1.81548342e-01f, -9.70336050e-02f, 3.77464034e-02f, -2.62183964e-01f, -1.03827573e-01f, -1.84406981e-01f, -1.16353698e-01f,
  -1.80948362e-01f, -3.66949975e-01f, -5.14414907e-01f, -4.80501682e-01f, -1.80067971e-01f, -6.07396029e-02f, -5.07645011e-01f, -2.51420110e-01f, -2.56717443e-01f, -7.94676900e-01f,
  2.71241530e-03f, -1.15978457e-02f, 8.40049088e-02f, 5.33807054e-02f, 2.24151880e-01f, -4.53686081e-02f, -2.38516852e-02f, 6.19103052e-02f, 7.20380023e-02f, -9.99410301e-02f,
  -4.87758219e-02f, -5.35038225e-02f, -7.02811182e-02f, -1.60777554e-01f, -5.10429107e-02f, -1.72841072e-01f, -1.89249605e-01f, -1.36444137e-01f, -5.52162342e-02f, -1.13041833e-01f,
  6.91947564e-02f, 7.83399027e-03f, -1.66305631e-01f, 2.15766594e-01f, -9.00566578e-02f, -3.77666838e-02f, 1.44410402e-01f, 1.88581243e-01f, 3.13412786e-01f, 2.52209231e-02f,
  5.78411043e-01f, -1.14611455e-03f, -1.45836204e-01f, 1.91169277e-01f, -1.50021315e-01f, -3.05961698e-01f, 9.30333696e-03f, -1.13512747e-01f, 1.27484247e-01f, 2.00347796e-01f,
  -3.56741026e-02f, 2.13028014e-01f, -7.43191391e-02f, -1.55372724e-01f, 1.00829070e-02f, 8.00899416e-02f, 3.48437540e-02f, -7.62938857e-02f, -6.40290231e-02f, -1.20789014e-01f,
  -1.48951054e-01f, -1.51278883e-01f, 1.65422454e-01f, -2.22160146e-01f, 6.83998391e-02f, 2.89580464e-01f, -4.38837588e-01f, -2.90646255e-01f, 6.97717071e-02f, -2.00970441e-01f,
  -8.80127549e-01f, -3.66794646e-01f, 2.92511225e-01f, -1.23028167e-01f, -4.59183119e-02f, 4.77028638e-02f, -6.40640333e-02f, -9.33794156e-02f, -5.83454827e-03f, 3.71196829e-02f,
  8.69977549e-02f, 2.45698437e-01f, 1.68153629e-01f, 1.96151122e-01f, -4.90465499e-02f, 3.68981846e-02f, 2.78038122e-02f, -1.79637279e-02f, 2.14912649e-02f, -2.75588334e-02f,
  -2.13316634e-01f, -2.44174242e-01f, -3.53107840e-01f, -8.29915255e-02f, 7.11174086e-02f, 2.25934863e-01f, 3.31380293e-02f, -6.77836593e-03f, 4.64213081e-02f, 8.67309689e-04f,
  5.74706495e-01f, -3.06072249e-03f, 8.64994824e-02f, -4.28809710e-02f, -2.49011219e-02f, -1.25386402e-01f, -2.42757183e-02f, 2.59354748e-02f, -4.50097397e-02f, 6.56683892e-02f,
  2.04554349e-02f, -1.14191053e-02f, 4.08667363e-02f, 1.99333400e-01f, 1.95891649e-01f, 1.51250228e-01f, 6.30065426e-02f, 1.79285649e-02f, 1.36227921e-01f, 1.09726496e-01f,
  1.63791478e-01f, 1.40130341e-01f, 2.52655029e-01f, 5.32331206e-02f, -2.42545400e-02f, 8.98523927e-02f, 2.19872266e-01f, 1.41638279e-01f, 1.69736102e-01f, 4.14622240e-02f,
  7.84361288e-02f, -2.91559268e-02f, 1.49864316e-01f, 3.20439368e-01f, 1.04207046e-01f, 6.83032870e-02f, 1.35823295e-01f, -5.48313037e-02f, -6.63089007e-02f, -4.63625193e-02f,
  2.25879401e-02f, 1.61613926e-01f, 1.36827499e-01f, -1.62758157e-01f, -2.94140652e-02f, 4.35547866e-02f, -3.81805785e-02f, 3.77266072e-02f, 9.61568952e-02f, 6.66261092e-02f,
  1.16887949e-02f, 6.20528357e-03f, 6.06025122e-02f, 8.07226375e-02f, 1.33975476e-01f, 1.88378856e-01f, 4.75902930e-02f, 5.71552031e-02f, 2.59558149e-02f, -1.86796978e-01f,
  6.27354681e-01f, 1.96703188e-02f, 2.34514964e-03f, 3.50356735e-02f, -1.55088052e-01f, -8.26150328e-02f, -3.54606733e-02f, 2.26435065e-02f, -3.49053033e-02f, 1.94760382e-01f,
  1.31722957e-01f, -1.28343910e-01f, -7.83582479e-02f, -2.30952725e-02f, 7.51725286e-02f, 1.28567830e-01f, -1.73713163e-01f, 9.46817771e-02f, 9.90046933e-02f, 1.04400381e-01f,
  -1.33225590e-01f, 1.67928755e-01f, 3.26650470e-01f, 8.45281929e-02f, -3.77233773e-02f, 2.61737630e-02f, 1.78820014e-01f, 1.50601357e-01f, 1.82625338e-01f, 1.11028329e-01f,
  1.67878553e-01f, 3.87645252e-02f, 4.17320877e-01f, 1.77736774e-01f, -1.68250173e-01f, -5.79734623e-01f, -9.67198014e-01f, -6.07897520e-01f, 1.31902903e-01f, -5.62669039e-02f,
  -3.56810614e-02f, -3.97542752e-02f, 5.74322268e-02f, -2.29800679e-02f, -2.94825494e-01f, -2.62500376e-01f, 1.37360394e-01f, 9.91786644e-02f, -2.51135886e-01f, -4.54784960e-01f,
  -2.07045913e-01f, 2.13063732e-02f, 1.01016551e-01f, 7.98963234e-02f, 4.59723532e-01f, 2.77237922e-01f, 3.47359210e-01f, 2.54289001e-01f, 1.64290130e-01f, 7.08431959e-01f,
  4.89793032e-01f, 1.35241255e-01f, -2.85600692e-01f, 1.48180813e-01f, 3.41645002e-01f, 7.19028711e-02f, -9.77892205e-02f, 2.95662254e-01f, -7.44122937e-02f, 1.13166563e-01f,
  1.57050133e-01f, 6.54155761e-02f, -1.42921612e-01f, 5.68345785e-02f, -1.29574448e-01f, -2.81430274e-01f, 9.74826217e-02f, 3.11033130e-02f, 3.00005078e-02f, 1.27131045e-01f,
  -4.62999940e-02f, -2.15203822e-01f, -2.78482556e-01f, -1.91830665e-01f, -9.23926011e-02f, 1.06987692e-01f, -8.52631629e-02f, 1.91863060e-01f, 5.73282614e-02f, 2.43488967e-01f,
  -9.00560021e-02f, 1.47818625e-01f, 1.01464927e-01f, 8.45545456e-02f, -3.97610804e-03f, 8.01335573e-02f, 6.86932579e-02f, -1.00063071e-01f, 6.45293742e-02f, 2.71622445e-02f,
  -6.76931739e-02f, 5.49936928e-02f, -2.20663869e-03f, 7.00025409e-02f, 2.23879457e-01f, 1.00874580e-01f, 1.32808432e-01f, -3.02972384e-02f, 1.83569714e-02f, -2.56628334e-03f,
  -7.05954656e-02f, 4.59050387e-02f, 2.37926126e-01f, 1.71328299e-02f, 4.85471003e-02f, 1.46786809e-01f, 1.90026134e-01f, 9.21478122e-02f, 1.95921473e-02f, 1.71774209e-01f,
  -1.02965020e-01f, -3.53613615e-01f, 1.61856920e-01f, -8.59605242e-03f, 2.23533958e-01f, 1.45503089e-01f, 1.62042484e-01f, 1.13832682e-01f, 2.29673475e-01f, -9.55982208e-02f,
  -6.79506883e-02f, -1.34501532e-01f, -3.16340365e-02f, -4.88679968e-02f, -1.59325287e-01f, -2.52389461e-02f, -6.56417832e-02f, -5.41428030e-02f, -1.71765983e-01f, 1.99097082e-01f,
  -1.04638070e-01f, -5.91282368e-01f, -7.35205293e-01f, -4.48966116e-01f, -1.86740786e-01f, -4.02575433e-01f, -1.84644923e-01f, -9.65891704e-02f, -3.92245919e-01f, -5.48663437e-01f,
  -2.47709155e-01f, -9.72893775e-01f, -4.23350990e-01f, -8.18400502e-01f, -7.18066454e-01f, -4.95708615e-01f, -8.01189423e-01f, -2.24556893e-01f, -1.79015338e-01f, -6.72536850e-01f,
  -2.19998136e-01f, 3.73633981e-01f, 1.65354863e-01f, 4.09418792e-01f, 4.42174643e-01f, -6.75186932e-01f, -2.82992333e-01f, 4.25428987e-01f, 6.36904299e-01f, -1.53275281e-01f,
  -4.08854723e-01f, -1.08206816e-01f, 4.29280758e-01f, 2.67494563e-02f, -1.06074595e+00f, -7.82868341e-02f, -5.18554986e-01f, -4.12906855e-01f, -2.53650516e-01f, -7.53912330e-01f,
  -5.89451551e-01f, -4.35755640e-01f, 3.09304446e-01f, 4.53854233e-01f, -1.38290048e-01f, 1.21841148e-01f, -2.25794446e-02f, 1.79949552e-01f, -1.17582576e-02f, -1.93449974e-01f,
  -7.23316520e-02f, 2.92185694e-01f, -3.14811170e-02f, 6.54746145e-02f, -3.50187451e-01f, 2.31411252e-02f, 2.34512389e-01f, 1.41903996e-01f, -2.96311211e-02f, -2.49241009e-01f,
  -3.74730676e-01f, -2.60689706e-01f, -1.23562664e-01f, 7.28231715e-03f, 3.88670564e-02f, 4.09515858e-01f, -1.78072602e-01f, -4.03236970e-02f, 1.41446039e-01f, -9.54985321e-01f,
  -2.17195049e-01f, -1.46896988e-01f, -5.63674420e-02f, 2.62909569e-02f, -5.86792827e-02f, -5.72135709e-02f, 2.01719236e-02f, -7.64514953e-02f, -3.30435894e-02f, -1.87866241e-01f,
  4.31961566e-02f, 8.50763172e-02f, 3.08717132e-01f, -2.16045007e-01f, -1.09487310e-01f, -6.05796687e-02f, -7.57814422e-02f, -1.93590090e-01f, -1.16659431e-02f, 2.38625407e-02f,
  1.41456991e-01f, 4.12238277e-02f, -1.42387465e-01f, 1.94918260e-01f, 1.97051838e-01f, 2.22036615e-02f, -5.98187465e-03f, 1.07317187e-01f, -3.06626409e-01f, -6.14771582e-02f,
  -3.91673476e-01f, 7.78078318e-01f, -4.38058257e-01f, 2.25320369e-01f, -1.30280465e-01f, 5.89554012e-02f, -6.95053907e-03f, 2.48901159e-01f, 8.66974071e-02f, -2.09438980e-01f,
  -6.09707907e-02f, 1.10002629e-01f, -2.02034742e-01f, 6.91047832e-02f, 6.23728074e-02f, -1.50088090e-02f, 9.37649086e-02f, -2.27531753e-02f, 5.18702455e-02f, -1.52429178e-01f,
  -1.42854258e-01f, -8.47855434e-02f, -4.29025665e-02f, 1.04343863e-02f, -2.02259064e-01f, 1.23688452e-01f, -3.46793532e-01f, -3.12751293e-01f, 2.03025848e-01f, -8.09658825e-01f,
  -1.12294805e+00f, 1.93235546e-01f, 1.72632664e-01f, -5.06231487e-01f, -7.58121192e-01f, -6.71433330e-01f, -5.34281731e-01f, -2.28027716e-01f, -3.14135730e-01f, -1.13322817e-01f,
  -5.40988892e-02f, 7.88670704e-02f, 3.91648263e-01f, 2.21423984e-01f, 1.54711396e-01f, 5.31741418e-02f, -6.09401949e-02f, -1.81070328e-01f, -4.51056629e-01f, -6.99562967e-01f,
  -3.10831428e-01f, -2.81361222e-01f, -2.91706949e-01f, -4.35422212e-02f, 4.15158644e-02f, 6.80495203e-02f, 2.55354881e-01f, -2.24488750e-01f, -4.08598542e-01f, -2.15797096e-01f,
  3.15545976e-01f, -5.75564802e-01f, -7.99219534e-02f, -1.23760894e-01f, 1.72539249e-01f, -1.38467178e-01f, -1.66200265e-01f, -1.18937619e-01f, -8.01303834e-02f, -4.31686714e-02f,
  2.65203160e-03f, -3.96018550e-02f, -9.70755741e-02f, 7.57953450e-02f, -5.15522212e-02f, 7.15194196e-02f, 2.17040434e-01f, -7.90932328e-02f, 5.82855307e-02f, 1.62326425e-01f,
  5.77714145e-02f, -2.93973088e-01f, -4.78900149e-02f, 1.29050955e-01f, -3.85078834e-03f, -1.09555654e-01f, -6.18541725e-02f, -2.41037011e-01f, -1.17058925e-01f, 7.36459345e-02f,
  1.38237834e-01f, 1.77135825e-01f, -4.33364231e-03f, 9.32674408e-02f, 3.46275717e-02f, 3.30584981e-02f, -4.16581407e-02f, 1.57078668e-01f, -1.41496271e-01f, 1.80844679e-01f,
  -1.45253748e-01f, -1.51706278e-01f, -1.17301792e-01f, -7.89604411e-02f, 2.85358820e-02f, -1.92208678e-01f, -1.91861212e-01f, 2.03753173e-01f, 1.94604173e-02f, -8.86793658e-02f,
  -2.11975455e-01f, -1.58462539e-01f, -9.34327021e-02f, 1.79561228e-02f, -1.30507931e-01f, 1.36817396e-02f, -9.53411460e-02f, 5.08215688e-02f, 1.60320420e-02f, -2.16944575e-01f,
  4.05604273e-01f, -3.30768883e-01f, 1.73111875e-02f, 2.14330554e-02f, -5.48172668e-02f, 1.15644306e-01f, 7.77059942e-02f, -7.00925291e-02f, -1.61870524e-01f, -1.61359683e-01f,
  -1.14829972e-01f, 4.43676561e-02f, 1.49181142e-01f, 6.77125677e-02f, -1.69072747e-02f, 4.76984587e-03f, 9.26041156e-02f, -5.57337552e-02f, -4.42491919e-02f, 1.71118841e-01f,
  4.23478365e-01f, -3.94241847e-02f, 2.25321546e-01f, 2.23524481e-01f, -3.83532885e-03f, -6.38601780e-02f, 3.07545424e-01f, 9.25713181e-02f, 1.21489950e-01f, 3.61323327e-01f,
  -8.93542469e-01f, 3.63275588e-01f, 3.47568125e-01f, -4.08646792e-01f, 8.07267730e-04f, 2.26292923e-01f, 5.34057796e-01f, 1.51139190e-02f, -2.97525227e-01f, 6.32732958e-02f,
  -4.64566387e-02f, -3.89701724e-01f, 4.93104979e-02f, 1.41923279e-01f, 1.82617903e-01f, 5.58745623e-01f, 5.78480721e-01f, 4.02346328e-02f, -4.67224330e-01f, -5.29391885e-01f,
  8.37667063e-02f, -1.65816426e-01f, -3.06072742e-01f, -1.43873364e-01f, -1.52961180e-01f, -1.06984815e-02f, 4.17413473e-01f, -4.92717363e-02f, 3.52191657e-01f, 1.39098287e-01f,
  -4.16538656e-01f, -3.58959883e-01f, 1.21790521e-01f, -2.18181416e-01f, -5.22718169e-02f, 7.27950755e-05f, 1.49480198e-02f, -5.62871099e-02f, 1.32652581e-01f, -2.38607898e-01f,
  -1.29365414e-01f, 5.12339324e-02f, -2.66003102e-01f, 9.71527919e-02f, -3.13821912e-01f, -2.21729815e-01f, -1.26471132e-01f, -1.35084704e-01f, 2.53985915e-02f, -3.07830542e-01f,
  4.06391531e-01f, -4.33852524e-01f, -3.89600188e-01f, 1.54270545e-01f, -4.90562730e-02f, -2.32400578e-02f, 4.57238257e-02f, -3.04551691e-01f, 2.99145412e-02f, -4.21752989e-01f,
  -8.92409384e-02f, -2.25537997e-02f, 1.22888230e-01f, 2.95208424e-01f, 2.95996875e-01f, 1.55446520e-02f, 1.66687503e-01f, 7.49439374e-02f, -2.11624298e-02f, -2.59856228e-02f,
  2.90748719e-02f, -2.91973054e-01f, -1.21329382e-01f, -1.09686926e-01f, 3.92915159e-02f, 2.80158240e-02f, 1.15233380e-02f, 1.75602838e-01f, 1.55911699e-01f, 2.86502779e-01f,
  -2.80524977e-02f, -1.03729494e-01f, -9.81242955e-02f, -3.40932794e-02f, 7.83479363e-02f, 2.22253919e-01f, -1.56785965e-01f, -1.71447709e-01f, -1.52128950e-01f, -1.05651192e-01f,
  -1.93075776e-01f, 7.91385651e-01f, -4.02958304e-01f, 3.19935769e-01f, 1.28948212e-01f, 3.38147283e-01f, 3.40175331e-01f, 2.39762172e-01f, 7.39370286e-02f, -1.59449890e-01f,
  -4.90980893e-02f, -2.96201613e-02f, 2.05237329e-01f, 1.21325679e-01f, -3.80062789e-01f, -8.87966752e-02f, 2.14957550e-01f, -2.23674849e-01f, 5.57986349e-02f, -2.01126024e-01f,
  1.98133290e-01f, -2.73972481e-01f, -6.46968663e-01f, -4.14351672e-02f, -1.42709166e-01f, -3.24631721e-01f, -1.93029806e-01f, -3.22540164e-01f, 7.83890784e-02f, -2.81936258e-01f,
  1.05537045e+00f, 1.65068254e-01f, -1.85017392e-01f, -4.31619324e-02f, -5.63901961e-01f, -6.50365353e-01f, -6.92243040e-01f, -3.09629291e-01f, -6.87609538e-02f, 1.05649583e-01f,
  1.84961502e-02f, 1.11373365e-01f, 2.24633124e-02f, 1.76683262e-01f, 4.64708619e-02f, -8.05531591e-02f, -2.34726131e-01f, 1.63579479e-01f, 2.53048062e-01f, 2.43656456e-01f,
  9.97127369e-02f, 2.11146191e-01f, 3.82642806e-01f, 7.80805945e-02f, 1.80088311e-01f, 1.80199891e-01f, -7.16501176e-02f, -1.49087720e-02f, 4.71427999e-02f, 3.21798623e-01f,
  5.72683096e-01f, 3.22732091e-01f, -5.08400192e-03f, 3.40205356e-02f, -1.17385993e-02f, 2.08321020e-01f, 1.47243738e-01f, -5.09147085e-02f, -7.06647485e-02f, -5.40374331e-02f,
  7.30131194e-02f, 9.19666588e-02f, -1.05929695e-01f, -1.38298497e-01f, -1.94671109e-01f, -2.58799735e-03f, -1.18780293e-01f, 5.49329072e-02f, -1.59239918e-01f, -1.89818896e-03f,
  -5.12873121e-02f, -1.76036417e-01f, -3.88702035e-01f, -3.64050180e-01f, 1.40324142e-02f, -7.71133900e-02f, -7.31351674e-02f, -6.73869029e-02f, -1.48985013e-01f, -5.17899543e-03f,
  -1.62704632e-01f, -7.76546523e-02f, -1.03440247e-01f, -1.26946688e-01f, -2.75658593e-02f, -8.31112266e-02f, 4.54640985e-02f, -5.61821088e-02f, 2.78551206e-02f, 6.09493181e-02f,
  -8.70604664e-02f, -3.03802323e-02f, -6.34488165e-02f, 6.34818152e-02f, 3.29478122e-02f, -8.64070207e-02f, 1.44985225e-02f, -8.12677965e-02f, -1.56361610e-01f, -3.71102504e-02f,
  3.74123425e-04f, -8.04125294e-02f, -7.90315941e-02f, -5.69073968e-02f, -1.13833033e-01f, -2.45229691e-01f, -4.57683690e-02f, -1.05003417e-01f, -1.15799770e-01f, 1.05364665e-01f,
  -1.27398334e-02f, -2.62658566e-01f, 4.06087548e-01f, 2.91168600e-01f, 1.92512289e-01f, 7.80473426e-02f, 1.08237036e-01f, 1.62691578e-01f, -1.81697551e-02f, 6.28736839e-02f,
  1.12467021e-01f, 1.94570363e-01f, 2.56705433e-02f, 2.44018082e-02f, -1.35240844e-02f, 5.41146323e-02f, 5.94606921e-02f, 1.38542861e-01f, 1.41399065e-02f, 3.44448052e-02f,
  -1.06530979e-01f, -2.93558419e-01f, -1.64029345e-01f, -2.80749053e-01f, 8.26699734e-02f, -1.12572378e-02f, -1.26748353e-01f, 3.42515558e-02f, -1.35048866e-01f, -1.88748062e-01f,
  -2.46813208e-01f, -9.81546938e-01f, 6.01321399e-01f, 4.48539592e-02f, 3.06687921e-01f, 6.84679672e-02f, -2.93816209e-01f, -3.19089383e-01f, -1.64800167e-01f, -9.12791118e-02f,
  -4.40462142e-01f, -2.49273822e-01f, -1.96555592e-02f, -3.44872475e-01f, -5.60177267e-01f, -1.39987692e-01f, 1.09938376e-01f, 1.45387664e-01f, 1.70668289e-01f, -2.42673293e-01f,
  -3.88884962e-01f, -1.30555332e-01f, -1.49595141e-01f, 1.05186179e-02f, 2.57423848e-01f, 6.53352886e-02f, 2.73651332e-01f, 7.20006675e-02f, -1.41428962e-01f, 2.49428377e-01f,
  3.65817070e-01f, -8.51819143e-02f, 1.46030739e-01f, -4.16765869e-01f, -1.13792680e-01f, -1.49063587e-01f, -4.84405346e-02f, 7.49102160e-02f, -1.49562120e-01f, -2.82766321e-03f,
  -1.31894812e-01f, 1.55036533e-02f, -2.53702085e-02f, -6.35933504e-02f, 6.32524043e-02f, 1.03812004e-02f, -1.08244941e-01f, -1.73189387e-01f, -1.58038363e-01f, -2.37195060e-01f,
  -2.71479607e-01f, -5.88256344e-02f, 1.48950130e-01f, -7.38379359e-02f, -1.89327568e-01f, -4.30425629e-03f, -4.62430082e-02f, -1.35062978e-01f, 1.86619516e-02f, 5.98490238e-02f,
  -6.21343143e-02f, -1.43020719e-01f, -7.49959499e-02f, 4.11058888e-02f, -1.41117990e-03f, 3.27060372e-02f, 8.40235502e-02f, -1.05208702e-01f, -1.41119435e-01f, -1.12279303e-01f,
  -1.15772739e-01f, 5.80852814e-02f, -6.43507838e-02f, 2.20593493e-02f, -1.14630193e-01f, -9.85275730e-02f, -9.10087749e-02f, -2.18865663e-01f, -8.20848048e-02f, -1.83182925e-01f,
  -1.17349900e-01f, -4.06408347e-02f, 1.27882669e-02f, -8.67163949e-03f, -4.00593020e-02f, -4.81168553e-02f, -4.32585441e-02f, -8.98719281e-02f, -2.49170139e-02f, 1.72483120e-02f,
  -1.22126918e-02f, 7.95079246e-02f, 2.95582265e-01f, -8.45273137e-02f, 3.96930091e-02f, -1.82769582e-01f, 9.93994474e-02f, -3.69779319e-02f, -1.98100396e-02f, 5.65539971e-02f,
  -5.79045899e-02f, 7.15140700e-02f, 1.12884276e-01f, -4.53656502e-02f, 1.61880985e-01f, 1.78259805e-01f, -2.66258746e-01f, -9.18684900e-03f, -9.11973566e-02f, -1.42014265e-01f,
  -3.03642929e-01f, 1.26155857e-02f, 9.29593295e-02f, 1.26554251e-01f, -4.11431631e-03f, 2.39546895e-01f, 3.10453653e-01f, 2.54422426e-01f, 2.29014322e-01f, 2.33717576e-01f,
  -9.69447196e-01f, 6.38193250e-01f, 3.02306980e-01f, -8.76570493e-02f, 3.66435438e-01f, 5.39955013e-02f, 7.13842884e-02f, -4.31683302e-01f, 1.06665261e-01f, 3.71047050e-01f,
  5.11577487e-01f, -1.06658943e-01f, 1.51496127e-01f, -1.28796071e-01f, -4.32633787e-01f, 5.01922131e-01f, 4.16885346e-01f, -4.12236422e-01f, -1.00468659e+00f, -5.72098076e-01f,
  6.81504011e-02f, -4.29799378e-01f, -8.23835433e-01f, -3.71578276e-01f, 3.68536979e-01f, -5.82320876e-02f, 2.85474122e-01f, 1.92426026e-01f, 3.75765890e-01f, 7.67210007e-01f,
  3.19273859e-01f, 3.37853938e-01f, -5.89012280e-02f, -1.19553856e-03f, 1.37469307e-01f, -1.29899725e-01f, -7.92896375e-02f, 8.04153532e-02f, 1.71149727e-02f, 1.09719902e-01f,
  1.58336222e-01f, 1.87521838e-02f, 1.20972537e-01f, 5.79813756e-02f, -1.20304100e-01f, -2.63127238e-01f, -6.90920874e-02f, -3.89146149e-01f, -3.45011592e-01f, 1.48981348e-01f,
  3.48659247e-01f, 2.76972167e-02f, 5.35240360e-02f, -1.23509459e-01f, 2.66472455e-02f, -3.08793753e-01f, -2.04156846e-01f, -5.06379664e-01f, -4.61350024e-01f, -2.95004994e-01f,
  2.17099916e-02f, -1.38907563e-02f, 1.12749606e-01f, 2.43148152e-02f, -2.29472652e-01f, 6.94784373e-02f, 1.63774103e-01f, 4.32287045e-02f, -1.54257149e-01f, -2.86374301e-01f,
  1.31721452e-01f, -6.86977431e-02f, -1.11474268e-01f, 7.03428462e-02f, -7.45327473e-02f, -1.10289067e-01f, -6.89687878e-02f, -8.47289041e-02f, -2.26290412e-02f, -1.96851477e-01f,
  -2.53470778e-03f, -4.04981896e-03f, -2.79007126e-02f, -1.83488056e-01f, 3.16740513e-01f, 6.51183426e-02f, 9.87606943e-02f, -1.39883950e-01f, -2.44406983e-01f, 6.70401528e-02f,
  -3.72593135e-01f, -7.59305432e-02f, 6.40163422e-02f, -6.77477121e-02f, -5.64638525e-03f, -9.91120120e-04f, 1.26269087e-01f, -6.57213181e-02f, 1.88399106e-01f, -4.90913168e-03f,
  -5.01274206e-02f, -1.22398011e-01f, 1.35758981e-01f, -2.36154068e-02f, -3.64209473e-01f, 5.35342842e-02f, 1.68227613e-01f, 3.27582061e-02f, -2.11016670e-01f, -3.87176052e-02f,
  -1.29322946e-01f, -5.73421896e-01f, -4.74685758e-01f, -1.00902200e-01f, -2.12946124e-02f, -4.02192235e-01f, -3.43094558e-01f, -5.54039419e-01f, -5.16750813e-01f, -5.49350739e-01f,
  -9.59317207e-01f, -4.59363669e-01f, 1.77384332e-01f, -4.98483717e-01f, 3.15640926e-01f, -1.77595973e-01f, -8.78904343e-01f, -7.11813748e-01f, -2.51086563e-01f, -3.57573688e-01f,
  4.53757256e-01f, 5.47432065e-01f, -3.17716151e-02f, 1.72257930e-01f, -7.41646290e-01f, -7.97610223e-01f, -5.00697434e-01f, -1.71032712e-01f, 2.33927339e-01f, 3.82754296e-01f,
  1.62189558e-01f, -1.40764127e-02f, -2.20650937e-02f, -1.70207284e-02f, -3.05412710e-03f, 1.41095459e-01f, 1.73534825e-01f, 1.36427030e-01f, 5.09079956e-02f, -9.92246866e-02f,
  3.30722630e-02f, -4.02258992e-01f, 2.68045574e-01f, 2.39803284e-01f, 3.34422797e-01f, -5.81184477e-02f, -1.84858620e-01f, -1.42978176e-01f, 4.45199013e-02f, -5.52471727e-04f,
  3.46759647e-01f, 2.18465611e-01f, 3.65784019e-02f, 1.43859789e-01f, -1.30273089e-01f, -7.07636476e-02f, -8.91225263e-02f, 1.23754013e-02f, -2.11342394e-01f, -5.49239591e-02f,
  2.94051111e-01f, 4.30256017e-02f, -4.95085835e-01f, -2.10974798e-01f, -3.66428345e-01f, 1.54308736e-01f, 3.06108177e-01f, 2.37069964e-01f, -3.29556257e-01f, -5.95625877e-01f,
  2.78207846e-02f, 3.36330943e-02f, 1.04392774e-03f, -2.36343052e-02f, -1.60251204e-02f, 3.90722565e-02f, -4.92576547e-02f, 3.63919698e-02f, 1.52833343e-01f, -8.20688158e-02f,
  -6.96179420e-02f, 1.00157475e-02f, 7.79998256e-03f, -2.21086651e-01f, 1.13344796e-01f, -1.17347978e-01f, -9.39736366e-02f, -9.27193090e-02f, 4.16429564e-02f, 1.89628527e-02f,
  9.24725609e-04f, 1.32585868e-01f, 1.02292709e-01f, 1.28472388e-01f, -3.29425782e-02f, 2.24552527e-02f, 7.26184621e-02f, 2.74732858e-01f, 1.29465759e-01f, 5.92987686e-02f,
  -1.30883440e-01f, 5.05042851e-01f, -5.04849851e-01f, -1.15381010e-01f, -2.13430431e-02f, 1.66981056e-01f, 1.11406259e-02f, 8.48657393e-04f, 1.17533216e-02f, 1.39944227e-02f,
  6.32520467e-02f, -1.59624904e-01f, -2.99839348e-01f, 2.49200061e-01f, 7.16566145e-02f, -5.04726171e-02f, -4.17930633e-01f, 1.23210531e-02f, -9.75730419e-02f, 7.58820251e-02f,
  -3.19637537e-01f, -5.79657972e-01f, -6.40482485e-01f, -4.36991721e-01f, -3.19122791e-01f, -3.54743749e-01f, -2.40560308e-01f, -1.06837049e-01f, -6.00152433e-01f, -9.63719368e-01f,
  -1.57840893e-01f, 7.65713453e-01f, 4.75000322e-01f, -5.31255543e-01f, 4.75525677e-01f, 5.66260993e-01f, 6.25579536e-01f, -1.35689512e-01f, -5.35450220e-01f, 2.86953568e-01f,
  5.36369264e-01f, -4.73109111e-02f, -1.93759590e-01f, -2.87847608e-01f, -2.57029772e-01f, -1.78694755e-01f, -3.39901507e-01f, -4.31525588e-01f, -3.69467884e-01f, -7.44493678e-02f,
  -1.89093858e-01f, -3.50896567e-01f, -3.92796993e-01f, -2.98396200e-01f, -1.63486600e-01f, -3.30641717e-01f, 2.17049658e-01f, 1.74960554e-01f, 4.67903256e-01f, -3.25820208e-01f,
  3.31701756e-01f, 2.11944133e-01f, -5.32373786e-01f, -1.45728767e-01f, 1.82322398e-01f, -2.62425691e-01f, -4.72311117e-02f, -4.16446149e-01f, -6.25601560e-02f, -1.65121153e-01f,
  1.33612886e-01f, 1.34873271e-01f, -5.04472591e-02f, 2.63411533e-02f, -1.14072353e-01f, -3.25582549e-02f, -5.80369942e-02f, -2.83444852e-01f, -6.14847578e-02f, 2.10558861e-01f,
  2.08067700e-01f, 3.27573568e-01f, 2.94901252e-01f, -1.43645834e-02f, 1.86013803e-02f, 6.96772486e-02f, 3.98479015e-01f, 8.83320495e-02f, 1.09508127e-01f, -2.04377145e-01f,
  -2.31073439e-01f, 1.15860514e-01f, 1.73009977e-01f, -6.67027980e-02f, 5.71674444e-02f, -7.31557235e-02f, -8.79349038e-02f, 4.91700917e-02f, 4.92618084e-02f, -6.35750145e-02f,
  -4.50932719e-02f, 7.27205945e-04f, -1.02911636e-01f, -1.56378686e-01f, -3.38033676e-01f, -2.08706222e-03f, -1.20654389e-01f, -9.54193175e-02f, -2.80609392e-02f, -6.72880188e-02f,
  -5.04593030e-02f, -7.97415078e-02f, -5.20678833e-02f, -1.89404756e-01f, -1.79223150e-01f, -1.20426208e-01f, -2.10931018e-01f, 7.72461146e-02f, 8.35086964e-03f, 2.80968547e-02f,
  -3.49709868e-01f, 7.01156557e-02f, -2.63926178e-01f, -9.87392664e-02f, 1.51771963e-01f, 1.08189881e-01f, 9.08759385e-02f, -7.41308108e-02f, 2.88378727e-02f, -2.24315077e-01f,
  2.55888462e-01f, -6.79165544e-03f, -1.02351755e-02f, -1.16371691e-01f, -1.63394287e-01f, -2.15627812e-02f, -1.10951327e-01f, -3.97121459e-02f, -5.99209368e-02f, 2.37456456e-01f,
  -7.91739747e-02f, -2.76988924e-01f, -2.32401371e-01f, -2.52770543e-01f, -2.95418024e-01f, -3.35478902e-01f, 1.59793168e-01f, -8.49922537e-04f, 2.77153496e-02f, -3.05323243e-01f,
  2.17524618e-02f, 2.47184813e-01f, 3.66563946e-01f, -2.85240322e-01f, 1.51168212e-01f, 4.68974203e-01f, 6.26629770e-01f, 6.45666644e-02f, -1.51318371e-01f, 1.97053909e-01f,
  6.86191097e-02f, -1.96697086e-01f, -8.71087387e-02f, -1.11132219e-01f, 1.46995470e-01f, 3.28438610e-01f, 9.36863571e-03f, -2.59407721e-02f, -1.60150185e-01f, -1.11054599e-01f,
  -2.17047796e-01f, -2.40630060e-01f, -2.83735305e-01f, -2.05942526e-01f, -2.14200482e-01f, -1.09262727e-01f, 1.32469321e-02f, -7.37838596e-02f, 1.15298763e-01f, 2.77380506e-03f,
  8.63926858e-02f, 7.50466762e-03f, -7.47789219e-02f, -3.20960015e-01f, -1.19341120e-01f, -1.35375082e-01f, 1.13524467e-01f, -1.11352623e-01f, -5.25670722e-02f, -5.69053181e-02f,
  -1.27918258e-01f, -9.74620730e-02f, -5.67730702e-02f, -7.56966174e-02f, 2.51135174e-02f, -3.84267196e-02f, -1.74112186e-01f, -1.51206508e-01f, -1.28095627e-01f, -7.26108178e-02f,
  -8.92868713e-02f, 1.08924218e-01f, 1.44721374e-01f, 1.90017790e-01f, 1.03023142e-01f, 1.45791052e-02f, 8.66563246e-02f, 3.53680812e-02f, 6.98682740e-02f, 2.36660354e-02f,
  1.66264504e-01f, 3.84960026e-02f, 7.06396103e-02f, 2.73614079e-01f, 6.12123311e-02f, -7.13255405e-02f, 8.97331536e-02f, 1.92994267e-01f, 1.86900735e-01f, 1.65335625e-01f,
  3.66244078e-01f, 3.06590468e-01f, 1.07937939e-01f, 2.98947990e-01f, 2.45899037e-01f, 1.71387330e-01f, 5.22450149e-01f, 4.07838613e-01f, 3.30212802e-01f, 1.72213465e-01f,
  1.33014053e-01f, 3.85044605e-01f, 2.52083242e-01f, 1.86624244e-01f, 3.93511772e-01f, 2.68189669e-01f, 4.84809577e-01f, 3.23163867e-01f, 2.43903786e-01f, 3.47269118e-01f,
  -1.28547594e-01f, 2.87104875e-01f, 1.57090098e-01f, -2.08045334e-01f, -5.51899336e-02f, -1.21448375e-01f, -1.04763955e-01f, -1.74118802e-01f, -1.97632998e-01f, 4.65988554e-02f,
  1.76211670e-02f, -2.99639497e-02f, 1.55938521e-01f, -3.43566872e-02f, 1.15048893e-01f, 7.11687803e-02f, -5.52733615e-02f, -7.50873820e-04f, -1.64324552e-01f, 4.76064160e-03f,
  6.92324191e-02f, 1.42806649e-01f, 1.24362931e-01f, 2.15268239e-01f, 1.13943920e-01f, 1.69513002e-01f, 3.05585086e-01f, 1.18668541e-01f, 1.53812289e-01f, 2.77994126e-01f,
  8.56670380e-01f, 2.16297403e-01f, 2.65196860e-01f, 2.99714655e-01f, 1.69816926e-01f, 1.04157567e-01f, 1.18390908e-02f, 1.14482045e-01f, 2.95530528e-01f, 3.14213157e-01f,
  2.80847847e-01f, 3.22396249e-01f, 3.98467541e-01f, 2.12720796e-01f, 3.14808697e-01f, 7.97193125e-02f, 5.45701794e-02f, 3.12483698e-01f, 2.09214017e-01f, 2.90561110e-01f,
  2.14910716e-01f, 1.35736138e-01f, 3.42355281e-01f, 1.89085141e-01f, 8.40800032e-02f, 1.71906307e-01f, 7.11833462e-02f, 1.80145845e-01f, 4.82007116e-02f, 5.69262914e-02f,
  -1.22057624e-01f, 1.10504009e-01f, 8.63593444e-02f, -3.40480991e-02f, 5.84279513e-03f, -4.80596945e-02f, 1.56418439e-02f, -1.62416846e-01f, -2.39558339e-01f, -2.82648653e-01f,
  -9.14261937e-02f, 3.00390720e-02f, 5.97616695e-02f, -1.56675234e-01f, -1.15754694e-01f, -1.23097315e-01f, 7.15253726e-02f, 5.89010566e-02f, -5.14315367e-02f, 3.68140452e-02f,
  -5.10989763e-02f, 7.25653470e-02f, -9.62245166e-02f, 9.91223194e-03f, 1.12593509e-01f, 2.89865099e-02f, 2.06390861e-02f, 7.82151222e-02f, 1.33671612e-01f, 1.12194166e-01f,
  3.37652981e-01f, 4.15736616e-01f, 2.86694139e-01f, 3.65931958e-01f, 2.54907012e-01f, 1.60371959e-01f, 5.00308722e-02f, 6.46726489e-02f, 2.64925897e-01f, 2.79032379e-01f,
  -1.15620583e-01f, 1.52791530e-01f, 1.61467358e-01f, 1.11485355e-01f, 1.46559462e-01f, 4.59178463e-02f, -8.56370851e-02f, 4.76615056e-02f, 2.33075744e-03f, 7.94801116e-02f,
  2.05113485e-01f, -7.01234713e-02f, -1.96300864e-01f, -6.22528568e-02f, -2.25323275e-01f, 3.55959572e-02f, 4.30829562e-02f, -7.86820948e-02f, -4.75398079e-02f, -1.16092823e-01f,
  -1.69902921e-01f, 3.28565300e-01f, 2.13861749e-01f, -4.00205376e-03f, -7.51683712e-02f, -5.65304980e-02f, 1.22143775e-01f, -1.47765771e-01f, -2.56700486e-01f, -2.66684353e-01f,
  -2.01764137e-01f, -3.15871090e-03f, -1.06003188e-01f, -4.61234059e-03f, -2.10550074e-02f, -1.55958742e-01f, 1.26293540e-01f, 1.31125197e-01f, 5.16234413e-02f, -3.27800289e-02f,
  -1.10034771e-01f, -1.01420984e-01f, -4.40818928e-02f, -3.15369815e-02f, 2.08599284e-01f, 7.04147518e-02f, -9.19719692e-03f, 3.66992541e-02f, 1.57528110e-02f, 2.90890783e-02f,
  -3.88949245e-01f, 7.81402290e-02f, -6.04113698e-01f, 2.07618922e-02f, 1.83696616e-02f, 2.51344174e-01f, 5.58516800e-01f, 8.53526831e-01f, 7.64437914e-01f, 4.14815754e-01f,
  -1.46667540e-01f, -7.90298522e-01f, -9.59290802e-01f, -6.03053212e-01f, -6.87894642e-01f, -1.74992122e-02f, -5.05459011e-01f, -1.06614077e+00f, -8.68212342e-01f, 6.83427155e-02f,
  -1.69742227e-01f, -5.71400344e-01f, -7.13384211e-01f, -4.54246461e-01f, -1.26590222e-01f, -8.38238716e-01f, -5.82938194e-01f, -6.15914524e-01f, -6.92734182e-01f, -9.13488030e-01f,
  -8.79165679e-02f, 9.21472162e-02f, 5.70370480e-02f, -2.61837959e-01f, 9.56581533e-02f, -1.37071609e-01f, 1.22250050e-01f, -7.77572691e-02f, -2.82903343e-01f, 2.98781395e-01f,
  -4.18597430e-01f, 2.14122549e-01f, -2.14560814e-02f, -3.85017127e-01f, -6.91266432e-02f, 8.74966010e-02f, -1.32990018e-01f, -2.12113082e-01f, -9.46976021e-02f, 3.81839037e-01f,
  1.97471708e-01f, -4.04241562e-01f, -6.19783759e-01f, 2.52352417e-01f, 5.06090403e-01f, -2.27519929e-01f, 3.88278924e-02f, 1.39011100e-01f, -2.15216145e-01f, -3.22432905e-01f,
  3.58642429e-01f, 3.75879221e-02f, 1.66551501e-01f, 3.39636989e-02f, 4.45668027e-02f, -1.84343755e-03f, -5.57803921e-02f, -7.88688511e-02f, 8.81528482e-02f, 8.87328312e-02f,
  1.81221753e-01f, 2.56948203e-01f, 4.47071716e-02f, 2.15858504e-01f, -7.08001107e-02f, 2.05676556e-02f, -1.49919055e-02f, -6.12445809e-02f, -2.27105603e-01f, -2.14385808e-01f,
  -2.91730851e-01f, 1.15795158e-01f, -9.62729231e-02f, 5.32285776e-03f, -1.14961453e-01f, 9.59680304e-02f, 2.30283827e-01f, 9.60301012e-02f, 3.15230846e-01f, 1.26691535e-01f,
  -1.43307731e-01f, -1.21513948e-01f, -1.19198009e-01f, 2.57585421e-02f, 3.49712968e-01f, 7.13829044e-03f, -2.27173179e-01f, 1.31951004e-01f, 4.64671850e-02f, 2.59110004e-01f,
  -5.10243922e-02f, 2.35285625e-01f, 8.12964737e-02f, -6.70390427e-02f, 4.95867245e-02f, -3.19854580e-02f, -1.61020420e-02f, -3.16334993e-01f, -1.04967527e-01f, 2.25941062e-01f,
  5.41433096e-02f, -3.61014664e-01f, -6.06849134e-01f, -2.06982583e-01f, 1.92167789e-01f, -8.00700903e-01f, -5.54576993e-01f, -4.87670526e-02f, -4.78151053e-01f, -1.61712989e-01f,
  -3.35429281e-01f, 1.92948543e-02f, -5.05538821e-01f, -4.63378161e-01f, -6.10663295e-01f, -5.67650259e-01f, -5.75182438e-01f, -1.18332572e-01f, -2.03708455e-01f, -4.56479281e-01f,
  -7.67729431e-02f, 4.97219384e-01f, 3.04591388e-01f, -3.98913352e-03f, -7.60811791e-02f, -5.97260654e-01f, -8.21348608e-01f, -3.97082925e-01f, -3.58155936e-01f, -5.72294772e-01f,
  -3.80188167e-01f, -4.06248420e-01f, -4.04092491e-01f, -2.04955444e-01f, -2.67570410e-02f, 2.23454937e-01f, -3.44099373e-01f, -3.37905288e-01f, -3.46747011e-01f, -4.07267869e-01f,
  4.73360658e-01f, -1.46594658e-01f, -6.41928464e-02f, 2.63275690e-02f, -1.08307503e-01f, 1.59228027e-01f, 9.23945233e-02f, 6.27801791e-02f, -4.99906689e-02f, -8.92737955e-02f,
  -8.62500519e-02f, -1.01660758e-01f, 1.91889346e-01f, 5.94268851e-02f, -9.38719139e-02f, -2.92467654e-01f, -5.09320915e-01f, -3.46812695e-01f, -2.86456406e-01f, -2.82274187e-01f,
  -3.00877094e-01f, -4.29465622e-01f, 9.61429849e-02f, 3.66402529e-02f, 1.28865480e-01f, -8.14834461e-02f, 2.25034356e-01f, 2.40634188e-01f, 2.61132214e-02f, 2.42847949e-01f,
  -5.14115319e-02f, 2.06845045e-01f, 4.31878716e-02f, 6.87985793e-02f, 9.73806232e-02f, 1.95677847e-01f, 1.03680141e-01f, 8.17648843e-02f, 1.18290246e-01f, 2.00344205e-01f,
  5.13169840e-02f, 1.48055917e-02f, 4.80097607e-02f, -5.91987371e-02f, 1.74178055e-03f, -1.69345990e-01f, 7.61307478e-02f, 1.45360366e-01f, 5.29603921e-02f, 4.07113768e-02f,
  1.54943794e-01f, -1.49948865e-01f, -2.92039406e-03f, 3.23180944e-01f, -1.29660979e-01f, -2.13069603e-01f, -1.94087308e-02f, 1.50140271e-01f, -3.28210257e-02f, -3.38517368e-01f,
  7.72873342e-01f, -3.19868594e-01f, 1.83503002e-01f, 2.54048526e-01f, -1.98055938e-01f, 3.49949971e-02f, 1.62774436e-02f, -2.41136193e-01f, 2.27252334e-01f, 1.29560292e-01f,
  -3.39996256e-02f, 1.61296278e-01f, 1.52059540e-01f, 4.77168709e-02f, -1.36737674e-01f, -2.21205041e-01f, -3.28825563e-01f, -5.58642372e-02f, -2.04371989e-01f, -1.06092431e-01f,
  -1.43843517e-01f, -2.69376725e-01f, 2.48468295e-01f, 2.58050978e-01f, 1.76159427e-01f, 3.45302485e-02f, 2.22148106e-01f, 2.47625455e-01f, 1.16110742e-01f, 1.64032429e-01f,
  3.04210126e-01f, 8.36342454e-01f, -6.38399422e-01f, 5.64430535e-01f, -3.73934478e-01f, -6.27724230e-01f, 4.88242432e-02f, 4.30325627e-01f, 2.76735306e-01f, 1.76182613e-01f,
  -5.43314517e-01f, -5.87388575e-01f, -2.11506620e-01f, -2.42253587e-01f, -2.30569348e-01f, 3.92262936e-01f, 5.53949475e-01f, -3.11786324e-01f, -5.52748024e-01f, -2.41032124e-01f,
  2.07642049e-01f, 6.08126879e-01f, 2.89120674e-01f, -1.42584285e-02f, 4.27089572e-01f, 3.40108313e-02f, 2.62003213e-01f, 1.01761833e-01f, -2.44219020e-01f, 3.55343521e-01f,
  -7.81116605e-01f, -1.54869527e-01f, -3.24176937e-01f, -1.83607042e-01f, -4.00322556e-01f, 1.14622712e-02f, -1.55614868e-01f, 4.15304042e-02f, -9.14836898e-02f, -1.66388806e-02f,
  -1.52477682e-01f, -1.25378191e-01f, -2.80807436e-01f, 8.22208971e-02f, -1.86361730e-01f, -4.20229584e-01f, 5.40629625e-01f, 1.81689218e-01f, 1.41610280e-01f, -2.68265337e-01f,
  -9.60397199e-02f, -4.18405324e-01f, -6.28894866e-01f, -4.41695973e-02f, -2.07139298e-01f, -3.08494508e-01f, -9.88021865e-02f, -1.74111292e-01f, -2.26088569e-01f, 6.66277468e-01f,
  -1.04960024e-01f, -1.12830192e-01f, 5.72461896e-02f, 8.95920172e-02f, 1.49894297e-01f, -1.52175397e-01f, 7.56067857e-02f, 1.16646186e-01f, 5.20507898e-03f, 4.26218137e-02f,
  -5.32429628e-02f, 3.69282551e-02f, -1.25448778e-01f, -1.32505238e-01f, 3.40234041e-02f, -5.61961941e-02f, -2.45785043e-01f, 2.74672538e-01f, -8.21254253e-02f, 4.89541478e-02f,
  -2.69638957e-03f, 1.95532423e-02f, 7.05086738e-02f, 1.19930163e-01f, -4.31764573e-02f, -5.31427450e-02f, 6.87271804e-02f, -5.28536513e-02f, 1.36659220e-01f, -5.75029589e-02f,
  3.75660479e-01f, -3.57156813e-01f, 1.28826618e-01f, -1.19738825e-01f, -5.30714355e-02f, -2.07343698e-01f, 2.76251719e-03f, -8.01064596e-02f, -2.01435536e-01f, -2.16828197e-01f,
  -2.88947582e-01f, -1.70565218e-01f, -2.66768318e-02f, -6.82830065e-03f, 2.70146858e-02f, -2.40503594e-01f, 1.80310503e-01f, -7.31845275e-02f, 1.04508646e-01f, 2.02103574e-02f,
  4.71594363e-01f, 1.59702241e-01f, -3.57632115e-02f, 1.88590258e-01f, -5.58433309e-02f, -2.64626861e-01f, 1.79994732e-01f, -9.41008702e-02f, -2.38115549e-01f, 8.65312099e-01f,
  -9.87758994e-01f, -2.87626743e-01f, 3.41777682e-01f, -6.03112161e-01f, 2.98587501e-01f, 7.45747328e-01f, 9.02174056e-01f, 2.92120695e-01f, -3.63289118e-01f, 1.71025530e-01f,
  -2.91540176e-01f, -6.27100050e-01f, -5.92418194e-01f, -3.26061666e-01f, 5.66851124e-02f, 7.03028679e-01f, 4.70569670e-01f, 7.43833408e-02f, 2.17218995e-01f, 3.73062432e-01f,
  1.08055249e-01f, -2.99382925e-01f, -4.69990849e-01f, -3.27556580e-01f, -2.96536684e-01f, -2.48131767e-01f, -1.43503621e-01f, -2.70175874e-01f, 3.07311267e-02f, -1.37263849e-01f,
  3.28671873e-01f, -4.58532155e-01f, 1.00178286e-01f, -3.47115189e-01f, -1.39035210e-01f, -1.09787859e-01f, 1.70407221e-01f, -3.20107430e-01f, -2.13689610e-01f, -3.39327119e-02f,
  -3.61177653e-01f, -2.24906474e-01f, -3.63433331e-01f, 4.24223254e-03f, 2.40229238e-02f, 1.14690689e-02f, -9.21399146e-02f, -3.58502865e-01f, -3.62106174e-01f, 1.34877432e-02f,
  -8.00665990e-02f, -8.02559182e-02f, 1.13416929e-02f, -3.12411264e-02f, -7.92738721e-02f, -1.22665249e-01f, -5.10614887e-02f, -6.36131093e-02f, -1.33607045e-01f, 3.77308466e-02f,
  7.93600231e-02f, 4.39504124e-02f, 1.01116747e-01f, 5.68205789e-02f, 7.37554505e-02f, 7.06111491e-02f, 6.00527041e-02f, 4.46150862e-02f, 1.17675979e-02f, -8.53863657e-02f,
  3.96603383e-02f, 6.54948801e-02f, 6.70399442e-02f, -2.71824598e-02f, -1.11740604e-01f, -2.49226034e-01f, 5.21009192e-02f, -1.26734406e-01f, -1.15341358e-01f, -8.27439800e-02f,
  -1.52444839e-01f, -8.92405063e-02f, -2.00720549e-01f, 4.80775088e-02f, 2.06382144e-02f, -1.13148719e-01f, -1.47200823e-02f, -1.36023507e-01f, -2.20833793e-01f, -6.19405061e-02f,
  4.51455498e-03f, -1.19774073e-01f, -5.59202507e-02f, -1.85993448e-01f, -7.60344267e-02f, -3.71010676e-02f, -1.52636558e-01f, -5.69753796e-02f, -4.42046747e-02f, -1.85968764e-02f,
  -6.65065348e-02f, -8.26766267e-02f, -1.10016994e-01f, 1.13583826e-01f, 2.88125604e-01f, 2.26023301e-01f, 3.02460212e-02f, -1.96957495e-02f, -6.22586608e-02f, 1.52421771e-02f,
  9.32284966e-02f, 2.48067811e-01f, 3.42839271e-01f, 2.54858255e-01f, 1.05283603e-01f, 1.65684015e-01f, 2.35908598e-01f, 3.34552377e-01f, 3.36499393e-01f, 5.94497919e-01f,
  8.22295964e-01f, 3.51671278e-01f, -6.56604826e-01f, 5.82678199e-01f, -2.21763089e-01f, -7.98316240e-01f, -7.37677693e-01f, -1.57648891e-01f, 4.50605810e-01f, 3.70452344e-01f,
  -3.21602374e-02f, -1.72346100e-01f, 1.26412109e-01f, -5.53020954e-01f, -9.36018944e-01f, -3.83671254e-01f, -3.11050743e-01f, -6.92333937e-01f, -1.14865148e+00f, -8.84915948e-01f,
  -3.73193711e-01f, 3.55199687e-02f, -2.89561450e-01f, -3.25572759e-01f, 3.62291843e-01f, -1.08368192e-02f, 1.36557102e-01f, -1.06714860e-01f, -3.86742055e-01f, 2.35382840e-01f,
  -2.04764977e-01f, -7.29673356e-02f, -2.95877159e-01f, 4.39433604e-02f, 2.41883591e-01f, 1.05405070e-01f, -1.78339586e-01f, 2.18811825e-01f, 2.14367524e-01f, 1.31495953e-01f,
  -2.05554757e-02f, -3.12687904e-01f, -2.08651677e-01f, -2.68801540e-01f, -2.12926880e-01f, -2.86797702e-01f, -1.03076458e-01f, -4.20540422e-01f, -1.34923279e-01f, -2.04593927e-01f,
  -3.00866991e-01f, -4.38597441e-01f, -3.73847216e-01f, -2.92552441e-01f, -3.76944929e-01f, -3.07970971e-01f, -1.83090687e-01f, -1.84663236e-01f, -3.01779121e-01f, 6.78745866e-01f,
  1.03894152e-01f, 1.73862055e-02f, -6.86691552e-02f, -1.64873656e-02f, 1.14017703e-01f, 6.29642382e-02f, 6.02059141e-02f, -1.54822037e-01f, -1.19393237e-01f, 7.47280195e-02f,
  -7.84545019e-02f, 8.95044729e-02f, 3.03960554e-02f, 1.29906058e-01f, -1.30400166e-01f, -1.28173307e-01f, 7.90285096e-02f, -8.65590796e-02f, -2.52564758e-01f, 1.49926722e-01f,
  -5.40709458e-02f, -1.01221882e-01f, 8.76302570e-02f, 9.30015743e-02f, -7.12997243e-02f, -6.27101958e-02f, 2.19601626e-03f, -1.33409500e-01f, -1.11976691e-01f, -8.33726302e-02f,
  4.91155297e-01f, -3.81499439e-01f, 5.25492191e-01f, -1.62623331e-01f, -1.17114350e-01f, 1.37784243e-01f, 1.69622183e-01f, -1.37830302e-01f, 1.87140435e-01f, -1.37758255e-01f,
  -4.56827044e-01f, -6.03584871e-02f, 4.40396294e-02f, -1.23451315e-01f, -3.12738836e-01f, -1.01107530e-01f, -2.14020848e-01f, -3.65895815e-02f, -2.15413287e-01f, 1.77294597e-01f,
  1.46324605e-01f, -8.70590806e-02f, 9.47271511e-02f, 2.74789959e-01f, -7.64548704e-02f, -4.85191010e-02f, 1.09856039e-01f, -2.77016852e-02f, -1.74791723e-01f, 7.24390328e-01f,
  -8.35946262e-01f, -8.14930573e-02f, -2.99637914e-01f, 5.40842116e-01f, 6.91570640e-01f, -3.92434485e-02f, -3.51858437e-01f, -3.04804713e-01f, 2.82959193e-01f, -1.05381332e-01f,
  1.07999586e-01f, 4.01239634e-01f, 3.95619750e-01f, 1.32081583e-01f, -4.62702781e-01f, -2.25193240e-02f, 3.25705916e-01f, -3.97644341e-01f, -4.85124737e-01f, -2.36007795e-01f,
  3.26201349e-01f, 4.10735607e-02f, -4.48277593e-01f, -1.32578731e-01f, 4.94400352e-01f, 3.05582196e-01f, 9.69863832e-02f, 2.17862397e-01f, -2.75433809e-02f, 4.18240041e-01f,
  -3.90120059e-01f, -2.83727080e-01f, -9.91443247e-02f, 3.24763983e-01f, 2.55725712e-01f, -6.36985540e-01f, -4.36359525e-01f, -1.01096511e-01f, -8.48586932e-02f, -2.42899075e-01f,
  2.82837689e-01f, -2.69677967e-01f, 3.24972868e-01f, -1.14661902e-01f, -1.93569362e-01f, -3.24545354e-01f, -1.49343878e-01f, -3.85909796e-01f, -4.07399595e-01f, -2.80627578e-01f,
  8.16122890e-01f, 3.91769975e-01f, -2.56897770e-02f, -1.61412224e-01f, -2.08326221e-01f, 1.49552226e-02f, -4.13587838e-01f, -4.86361474e-01f, -8.86156023e-01f, -6.85481727e-01f,
  7.59918839e-02f, 9.08446833e-02f, 1.14071064e-01f, 2.64582764e-02f, 3.20714451e-02f, 9.63688046e-02f, 2.15961754e-01f, 1.48783177e-01f, 2.58958060e-02f, 1.83589067e-02f,
  1.57645810e-02f, 1.96358822e-02f, -3.69200930e-02f, -5.31080738e-02f, 6.26314059e-02f, -1.78682078e-02f, -6.19483925e-02f, -2.01431632e-01f, 1.29851745e-02f, -9.61553082e-02f,
  -3.82404141e-02f, -8.88394341e-02f, 2.61030465e-01f, -6.62133321e-02f, -6.23135008e-02f, -1.05150677e-01f, 4.86754142e-02f, -6.34167939e-02f, 7.74803609e-02f, 7.65898153e-02f,
  -4.32126001e-02f, -3.39441150e-01f, -8.93175676e-02f, -1.12797610e-01f, 1.84698105e-01f, 1.40852034e-02f, -2.78341621e-02f, -1.40149653e-01f, 2.25904077e-01f, -1.69650957e-01f,
  -2.74618059e-01f, -2.04804823e-01f, 1.73519462e-01f, -6.24288209e-02f, -2.34687984e-01f, 8.81460980e-02f, 1.04017749e-01f, 2.76748538e-01f, -1.15439966e-01f, 1.72899187e-01f,
  9.07949060e-02f, -2.31440425e-01f, -2.41561428e-01f, -1.29264951e-01f, 2.34105319e-01f, 4.87720184e-02f, -4.22247589e-01f, -5.01426518e-01f, -6.08450294e-01f, -6.84996784e-01f,
  -1.14854181e+00f, 1.87860206e-01f, 2.65164319e-02f, -3.69760960e-01f, 1.63999572e-01f, 3.78559649e-01f, 5.97011626e-01f, 3.50858539e-01f, -9.69314203e-02f, 1.80394307e-01f,
  -7.93587342e-02f, 2.63274256e-02f, 5.48165105e-02f, 2.69510895e-02f, 2.59014040e-01f, 5.64292192e-01f, 4.47019488e-01f, -4.12474014e-02f, -2.93914415e-02f, 1.79904327e-01f,
  2.72621095e-01f, -2.34194264e-01f, -4.53344166e-01f, -8.53307471e-02f, 4.17267382e-02f, -3.31908539e-02f, 2.77717002e-02f, -3.80723178e-02f, 1.73394844e-01f, 8.55118036e-02f,
  2.10129946e-01f, -5.52078426e-01f, 1.09406121e-01f, -1.20609127e-01f, -1.75229669e-01f, -1.80205733e-01f, -1.01273824e-02f, -8.22377503e-02f, 7.91885406e-02f, 2.04994887e-01f,
  6.32020459e-02f, -1.07112378e-01f, -1.17302269e-01f, 4.48420551e-03f, -5.08640297e-02f, -3.77670601e-02f, -2.08278239e-01f, 1.41090555e-02f, 9.28346664e-02f, 8.57365578e-02f,
  -1.51876761e-02f, -1.51878223e-01f, 5.25239930e-02f, 1.27456561e-01f, -4.56498601e-02f, -4.22283895e-02f, 2.59658452e-02f, -5.41222468e-02f, -3.34641449e-02f, -6.99921548e-02f,
  2.14589775e-01f, 1.47050038e-01f, -2.51023382e-01f, -2.99574018e-01f, -1.58153892e-01f, -6.76864833e-02f, 5.22201695e-02f, 1.39418542e-01f, -8.11686274e-03f, -4.84674573e-02f,
  5.39905280e-02f, 8.80113840e-02f, 5.29278256e-02f, 3.68636884e-02f, -3.60252149e-02f, -1.06101921e-02f, 2.70582009e-02f, -5.62586598e-02f, -2.02894896e-01f, -1.88129678e-01f,
  -1.06283687e-01f, 1.55705556e-01f, -1.48863360e-01f, -1.31314294e-02f, 6.66024536e-02f, -7.46814385e-02f, 1.01174846e-01f, 1.27882719e-01f, 1.42001491e-02f, 2.32717976e-01f,
  3.92220438e-01f, -3.90876889e-01f, 1.76748186e-01f, -9.73663330e-02f, -1.96460366e-01f, -1.33541390e-01f, -1.58520326e-01f, -1.17972068e-01f, 9.96573940e-02f, 9.41263735e-02f,
  -8.89138952e-02f, -9.37009305e-02f, -1.75563842e-02f, 3.42467539e-02f, -6.10356499e-03f, -2.74301022e-02f, -1.88950181e-01f, 7.06481487e-02f, 1.53181285e-01f, 2.89183781e-02f,
  1.38784528e-01f, 8.91728029e-02f, 1.60793751e-01f, 2.12034553e-01f, 8.24896768e-02f, 1.13695517e-01f, 1.55283988e-01f, 1.12175690e-02f, 7.21324608e-02f, 2.58010268e-01f,
  -5.33388674e-01f, -4.17389631e-01f, -1.02197838e+00f, -8.73156250e-01f, -6.87826812e-01f, -9.32586007e-03f, 1.72865823e-01f, 2.17802927e-01f, -3.58442515e-01f, -4.23215270e-01f,
  -9.82989073e-02f, -1.83533728e-01f, -4.62464750e-01f, -5.09559587e-02f, 4.82465595e-01f, -2.07962230e-01f, -4.63455349e-01f, -3.21180642e-01f, -1.09922320e-01f, 7.79107958e-02f,
  -1.11250699e-01f, -4.77077305e-01f, -1.82762995e-01f, -2.45634288e-01f, -4.62222338e-01f, -3.23015660e-01f, -6.22020364e-01f, -3.42172831e-01f, 2.50115365e-01f, -4.64388072e-01f,
  -6.60253048e-01f, -1.85144469e-01f, -6.41915649e-02f, 8.05503577e-02f, -3.43834668e-01f, -6.05360977e-02f, -1.55445337e-01f, -3.48876156e-02f, -2.61544492e-02f, -1.98159561e-01f,
  -2.51168728e-01f, 7.14338645e-02f, -1.54305920e-01f, -1.02696195e-01f, -2.94083029e-01f, 3.42087187e-02f, -1.67106632e-02f, -3.59779596e-02f, 1.32840574e-01f, 1.18613675e-01f,
  1.94681451e-01f, 3.52499448e-02f, -2.73691490e-02f, 1.44887581e-01f, 1.54207706e-01f, -9.18031260e-02f, 1.51735255e-02f, 2.21723288e-01f, 2.80765682e-01f, -1.25183463e-01f,
  1.59414902e-01f, -1.67969972e-01f, 8.56085494e-02f, -2.11665183e-02f, 1.14785492e-01f, 1.22508638e-01f, -1.04689375e-02f, 4.91015576e-02f, 7.03688115e-02f, 9.58557576e-02f,
  6.13825954e-02f, 3.65849920e-02f, 2.74692364e-02f, 2.59152595e-02f, 3.28575112e-02f, -3.75674255e-02f, 1.73111752e-01f, 9.63388234e-02f, 3.85906100e-02f, 2.89519299e-02f,
  6.09241519e-03f, 9.16700438e-02f, -7.96015263e-02f, 1.56799093e-01f, 2.86295980e-01f, 3.63391005e-02f, 1.06927855e-02f, 2.12413564e-01f, -8.80923942e-02f, 4.61972542e-02f,
  -6.77467585e-01f, 6.76371336e-01f, -2.11809948e-01f, -4.44050655e-02f, -1.51860505e-01f, -6.04897849e-02f, -2.69300163e-01f, -6.71997592e-02f, -2.22106636e-01f, -2.72037446e-01f,
  6.27193451e-02f, -1.32894889e-01f, -6.06249198e-02f, 4.33558486e-02f, -1.26855597e-01f, -2.86098924e-02f, -4.00153641e-03f, -1.43612579e-01f, 1.87619448e-01f, 3.54774334e-02f,
  1.55842185e-01f, 2.55288810e-01f, -5.95944561e-02f, -3.01469490e-02f, 1.01924062e-01f, -9.75232124e-02f, -1.18698645e-02f, 1.33448273e-01f, 3.57756257e-01f, 9.37616825e-02f,
  1.19078493e+00f, -4.96349752e-01f, -6.02498591e-01f, 2.53148228e-01f, 1.62813663e-01f, 1.97573230e-01f, -1.23783402e-01f, 2.58060426e-01f, 4.19159144e-01f, -1.50342897e-01f,
  -7.07949623e-02f, 1.91241771e-03f, -1.95586041e-01f, -1.65337741e-01f, -8.19982216e-02f, -3.89237761e-01f, -3.51702213e-01f, -6.57599270e-02f, 1.57589138e-01f, 2.23812982e-01f,
  6.18327148e-02f, 1.97547659e-01f, 1.29918307e-01f, -2.80704647e-02f, -3.64364058e-01f, -2.48776689e-01f, -3.86133283e-01f, -2.89930612e-01f, -5.11492550e-01f, -6.25603735e-01f,
  -7.21325636e-01f, -2.67712057e-01f, 1.68109298e-01f, 3.18560079e-02f, 2.82188449e-02f, 1.71883732e-01f, 1.28662214e-01f, 6.37942553e-02f, 1.36526465e-01f, 5.50731681e-02f,
  -1.32209048e-01f, -5.17376028e-02f, -3.30361002e-03f, -5.02912030e-02f, 9.40655619e-02f, -2.57484410e-02f, 5.28345443e-02f, 1.06545255e-01f, -1.22798741e-01f, -1.53816208e-01f,
  -1.95340902e-01f, 1.64881709e-03f, 1.33317977e-01f, 7.19008967e-02f, 1.41323298e-01f, 2.28276453e-03f, -1.14683934e-01f, -5.01885451e-02f, 1.80701479e-01f, 2.11966485e-01f,
  -1.29087433e-01f, 1.09161615e-01f, -4.04720865e-02f, 8.58875886e-02f, 3.06361705e-01f, 1.86613113e-01f, 1.24790512e-01f, 1.13514438e-01f, 8.11611563e-02f, 1.45959273e-01f,
  -5.85870370e-02f, -8.08822829e-03f, 6.70131817e-02f, 4.82924581e-02f, -2.93582343e-02f, -1.53194368e-01f, -1.14373742e-02f, 2.15829331e-02f, -1.56336322e-01f, 4.40928601e-02f,
  -1.35627855e-02f, -1.44714549e-01f, -1.15784869e-01f, -1.04709707e-01f, -2.14434832e-01f, 1.44563476e-02f, -2.10785374e-01f, -1.24692433e-01f, -6.08421937e-02f, -4.90080193e-03f,
  -2.81379130e-02f, -6.65244162e-02f, -5.25587006e-03f, -1.32567078e-01f, -1.26237497e-01f, -5.31801470e-02f, -1.85598761e-01f, -1.09920822e-01f, -1.18095778e-01f, -2.84227431e-02f,
  -6.33296818e-02f, -3.53498012e-02f, -1.09190263e-01f, -3.96442115e-02f, 1.84073702e-01f, 1.86676383e-01f, 2.00350091e-01f, 7.65531650e-03f, -8.49544927e-02f, -8.23984668e-02f,
  -5.60504645e-02f, 1.79579020e-01f, 2.41607338e-01f, 2.26975888e-01f, 1.78626224e-01f, 2.12172285e-01f, 8.02720115e-02f, 1.93462908e-01f, 8.87703374e-02f, 5.54129601e-01f,
  -9.77050424e-01f, -6.80754423e-01f, 1.32384837e-01f, -5.26646554e-01f, -1.52352780e-01f, 6.73718303e-02f, -6.22899473e-01f, 5.48555404e-02f, 1.94328334e-02f, -6.34373903e-01f,
  -1.18445016e-01f, -3.45646665e-02f, -3.16152900e-01f, 8.90253112e-02f, -4.10649516e-02f, -4.25116092e-01f, -1.53973892e-01f, 2.50112265e-02f, 3.83324414e-01f, 2.24427832e-03f,
  -1.86354890e-01f, -3.72642130e-01f, 3.07190921e-02f, 5.84948771e-02f, -5.52063525e-01f, -2.89937258e-01f, -1.11864857e-01f, -2.04489633e-01f, -1.30819380e-01f, -7.26119220e-01f,
  -5.83325684e-01f, -5.97282089e-02f, 4.52491909e-01f, -9.48651284e-02f, -2.77946502e-01f, -4.86168005e-02f, -7.58976815e-03f, 2.69512802e-01f, 2.21939519e-01f, 8.84171203e-02f,
  2.81159371e-01f, 7.91967139e-02f, -9.23301652e-02f, -9.87942293e-02f, -6.09685965e-02f, 1.36585295e-01f, 1.64169267e-01f, 1.48046255e-01f, 5.39686065e-03f, 1.98995043e-02f,
  -5.38523681e-02f, -1.39554381e-01f, 2.45659128e-01f, 4.24427867e-01f, 2.43859008e-01f, 1.61346838e-01f, 1.84893847e-01f, 2.28115693e-01f, 2.68351644e-01f, -5.54223597e-01f,
  -3.45047638e-02f, -1.71869293e-01f, -2.21915357e-02f, 5.94953746e-02f, -1.05078809e-01f, 1.24474563e-01f, -4.58520949e-02f, -3.59601937e-02f, 7.13129118e-02f, -6.34262338e-02f,
  1.95420146e-01f, -4.19539623e-02f, 2.68022288e-02f, -7.42964894e-02f, 1.68131903e-01f, -1.18692383e-01f, -6.41955361e-02f, 9.02082548e-02f, 1.42461628e-01f, -9.29549560e-02f,
  1.68390181e-02f, -7.82919452e-02f, -2.85266177e-03f, -6.16250634e-02f, 9.73377526e-02f, 4.84047569e-02f, -9.58143100e-02f, 7.14280903e-02f, 1.40155837e-01f, 2.61264652e-01f,
  -4.97196883e-01f, 4.84605759e-01f, -6.89767897e-01f, -2.68965792e-02f, -9.80134755e-02f, 1.28603131e-01f, -1.53115869e-01f, 1.66810513e-01f, -1.52644098e-01f, -2.75566518e-01f,
  2.07994878e-01f, -1.52739704e-01f, -2.23531216e-01f, 2.14165077e-02f, 2.16106828e-02f, 1.01972774e-01f, 8.39942619e-02f, -1.47955820e-01f, 5.67748547e-02f, 2.34763864e-02f,
  -4.52800021e-02f, -5.99886402e-02f, -4.45850700e-01f, -1.46389544e-01f, -1.98950291e-01f, -1.93242088e-01f, -2.32777685e-01f, -1.99972466e-01f, -1.82616562e-01f, -9.95930552e-01f,
  6.57309532e-01f, 4.95037615e-01f, 1.88952059e-01f, 1.87150657e-01f, 1.88150093e-01f, 1.33594364e-01f, 3.67108196e-01f, 1.43382266e-01f, -7.94777796e-02f, 1.53732881e-01f,
  -1.13828136e-02f, -5.57721555e-01f, -3.97724599e-01f, -4.04230207e-01f, -2.16040477e-01f, 1.09869711e-01f, 4.98935878e-02f, -1.89618737e-01f, -6.50613785e-01f, -4.67348933e-01f,
  -4.08344686e-01f, 5.90165779e-02f, 2.91234016e-01f, -1.48713924e-02f, -1.10449800e-02f, -4.62886155e-01f, 1.73596561e-01f, 3.31811994e-01f, -1.21612921e-02f, -3.33269984e-02f,
  2.29799420e-01f, 6.41958594e-01f, -7.00891376e-01f, -2.66095608e-01f, 1.85129680e-02f, 3.66850831e-02f, 6.36068881e-02f, 1.70429781e-01f, 1.71322867e-01f, 1.82607397e-01f,
  4.86549176e-02f, 8.13481435e-02f, 1.92405432e-01f, 5.29449433e-02f, 1.99662015e-01f, 2.66137579e-03f, 2.10560948e-01f, 9.28082019e-02f, -4.15604040e-02f, 8.27679634e-02f,
  -2.17532724e-01f, 1.35749251e-01f, 2.62396872e-01f, -1.18670978e-01f, -2.02547777e-02f, -2.55180985e-01f, -9.98733416e-02f, -4.95446473e-02f, -1.73845202e-01f, 1.13048010e-01f,
  -1.40319213e-01f, 5.98595217e-02f, -7.84340873e-02f, 1.95944007e-03f, 5.91108203e-03f, 1.55689925e-01f, 1.92216083e-01f, -6.60173967e-03f, -1.38055747e-02f, 1.19872361e-01f,
  6.55892491e-02f, 4.73347194e-02f, 2.59988636e-01f, 2.46963531e-01f, 1.11556746e-01f, 1.01847529e-01f, 1.25431895e-01f, 2.20279954e-02f, 1.19456299e-01f, 2.61088014e-01f,
  -4.81849834e-02f, 1.55532942e-03f, 9.32086483e-02f, -4.89735566e-02f, -5.05177341e-02f, 4.07307670e-02f, -3.24535333e-02f, 2.16146875e-02f, 2.83299796e-02f, 2.22266957e-01f,
  -1.74344815e-02f, -4.35341448e-02f, -2.36008659e-01f, -1.98036835e-01f, 2.49723569e-01f, 1.62621289e-01f, 1.07535020e-01f, 7.69861415e-02f, 1.24233693e-01f, 6.73457384e-02f,
  -1.77947395e-02f, 1.87975779e-01f, 3.23572844e-01f, 2.52902746e-01f, -5.68422824e-02f, 4.17443849e-02f, 1.79534420e-01f, -1.17851049e-01f, -1.42820016e-01f, 5.08950576e-02f,
  1.22544365e-02f, -9.74925905e-02f, -9.30491760e-02f, -2.54448950e-01f, -2.64599212e-02f, -5.48129737e-01f, -1.82539865e-01f, -4.42073643e-02f, -3.04300964e-01f, -1.94978602e-02f,
  -1.22912824e-02f, 3.30380648e-01f, 5.46595216e-01f, -3.30610871e-01f, -4.72805172e-01f, -5.27957343e-02f, 2.49352112e-01f, 1.09595150e-01f, -3.23018521e-01f, -2.48662844e-01f,
  -6.47337139e-01f, -5.83589315e-01f, -3.22168648e-01f, -1.74672544e-01f, 1.69419661e-01f, 2.72075593e-01f, 3.21531922e-01f, 4.32056010e-01f, 1.80664465e-01f, -1.20535180e-01f,
  -1.90594003e-01f, 4.82783131e-02f, 1.96004823e-01f, 3.67069036e-01f, 1.66802451e-01f, -2.36635417e-01f, 1.67743176e-01f, -6.96035475e-02f, 1.07813247e-01f, 2.04927325e-01f,
  -4.21917170e-01f, 4.44824219e-01f, -2.76561435e-02f, -3.44461262e-01f, -3.26570064e-01f, -9.59026143e-02f, 1.60542682e-01f, 5.36452122e-02f, -4.15525213e-02f, 1.97156534e-01f,
  -3.71145159e-01f, -3.21302749e-02f, -3.28288436e-01f, -1.36842862e-01f, -2.74125785e-01f, -5.05584106e-02f, 1.71013668e-01f, 4.35628712e-01f, 2.76809603e-01f, -2.87365671e-02f,
  -4.62187380e-01f, -4.78258431e-01f, -8.04617852e-02f, 2.28913575e-01f, 4.05005783e-01f, -2.12985322e-01f, 1.36261135e-01f, 2.14232430e-01f, 2.89284736e-01f, 2.32858881e-01f,
  -8.12620521e-02f, -2.81435978e-02f, 2.75531057e-02f, 2.54583806e-01f, -1.36489600e-01f, -1.13730684e-01f, -2.65178308e-02f, -1.07477807e-01f, -4.85629663e-02f, 6.61259666e-02f,
  9.91370454e-02f, -1.49662226e-01f, 2.30728239e-01f, -6.94985390e-02f, -3.39211553e-01f, -3.74871418e-02f, -8.00169334e-02f, -3.12923938e-02f, -2.21651912e-01f, -7.10505471e-02f,
  -1.73137158e-01f, 6.42668903e-02f, -1.06536083e-01f, 1.36137262e-01f, 5.54461144e-02f, 1.69115379e-01f, -3.94255668e-02f, -8.68038926e-03f, -1.79275796e-02f, 1.08705446e-01f,
  -5.90748131e-01f, 1.94177926e-01f, -1.34207919e-01f, 2.81429797e-01f, -3.62145491e-02f, -6.25337437e-02f, -1.03376813e-01f, -1.56319186e-01f, -1.73077673e-01f, 5.11382967e-02f,
  1.21893194e-02f, -7.05420449e-02f, -5.07864319e-02f, 2.23905854e-02f, -2.82602966e-01f, -2.06532046e-01f, -4.70714301e-01f, -2.95372963e-01f, -2.60313034e-01f, -4.79582995e-02f,
  -2.06372142e-01f, -2.91792870e-01f, -7.06587076e-01f, -2.15375915e-01f, -2.58729607e-01f, -6.46244347e-01f, -1.85068995e-01f, -2.05093578e-01f, -3.40268165e-01f, -4.18345183e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  4.19126570e-01f, 4.34555978e-01f, 1.32006586e-01f, 6.04601502e-01f, 5.76413035e-01f, 7.54298031e-01f, 5.05971789e-01f, 6.75239503e-01f, 8.07750702e-01f, 3.50365728e-01f,
  4.65207607e-01f, 8.91884387e-01f, 5.99039853e-01f, 8.85526955e-01f, 1.40782565e-01f, 7.38632679e-01f, 8.41606677e-01f, 1.14620292e+00f, 5.93948603e-01f, 8.33408609e-02f,
  7.18154550e-01f, 4.85873930e-02f, 8.78453732e-01f, 4.86980975e-01f, 9.87145662e-01f, 8.95745039e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -8.25336277e-02f, -1.61572888e-01f, -4.66299921e-01f, 9.30614118e-03f, -8.23336095e-02f, 4.47508730e-02f, -6.07461557e-02f, -1.42491028e-01f, -3.36239152e-02f, -3.26422125e-01f,
  9.98796001e-02f, 1.03483582e-02f, -2.72992492e-01f, -1.81548983e-01f, -8.26293305e-02f, -2.06097439e-02f, -3.21665853e-02f, -7.58413300e-02f, -2.84341276e-02f, 2.34828383e-01f,
  -1.78422462e-02f, -6.81111589e-02f, 9.44031700e-02f, 2.65080500e-02f, 2.36124676e-02f, -1.62897214e-01f, -2.00369954e-01f, 1.31654575e-01f, 2.25909486e-01f, 7.02575892e-02f,
  7.18097389e-02f, 2.46427894e-01f, 2.76861697e-01f, 1.19675644e-01f, -2.76424080e-01f, 1.71628475e-01f, 1.06322527e-01f, -5.63383708e-03f, 6.51339650e-01f, 7.27030337e-01f,
  2.14147896e-01f, -3.99912417e-01f, 3.56753200e-01f, -2.71336734e-01f, -9.02791858e-01f, -4.56187159e-01f, -8.18199039e-01f, -1.22752011e+00f, 3.21884394e-01f, -1.77403748e-01f,
  -7.24242806e-01f, -6.78564489e-01f, 3.37626338e-01f, 1.71992809e-01f, -6.94710553e-01f, -4.61624891e-01f, -2.83076704e-01f, -1.04231358e-01f, -1.07032454e+00f, 2.73353994e-01f,
  2.81191528e-01f, 3.81575197e-01f, -7.90141821e-01f, -2.12082982e-01f, 8.09110478e-02f, 9.04840603e-02f, 2.05578506e-01f, 1.09570205e-01f, -1.45979375e-01f, -2.66970515e-01f,
  3.17286402e-02f, -2.00084969e-01f, 1.59381822e-01f, 7.78092816e-02f, 2.18361735e-01f, -9.01933759e-02f, 1.16258539e-01f, 1.68829843e-01f, -2.66092941e-02f, -1.74034134e-01f,
  -1.52798332e-02f, 9.77877825e-02f, -1.04194783e-01f, -1.17563516e-01f, -1.27447054e-01f, -1.57102823e-01f, 3.07235658e-01f, 3.54277007e-02f, -5.86894862e-02f, 1.87411338e-01f,
  -2.77301759e-01f, -1.65319428e-01f, 3.56320500e-01f, -3.37015428e-02f, 3.52387339e-01f, -1.78688392e-01f, 4.84658293e-02f, -2.91688293e-01f, -3.07420433e-01f, 7.46638924e-02f,
  -2.36114576e-01f, -4.46472270e-03f, -1.16841984e+00f, 9.35670614e-01f, -1.91481188e-01f, -7.60947704e-01f, 9.30764973e-01f, -4.05593067e-01f, -6.27460361e-01f, 1.45064622e-01f,
  -3.26917648e-01f, -2.59854287e-01f, -8.51903915e-01f, -1.13952413e-01f, 4.46589924e-02f, 4.73535627e-01f, -1.41131949e+00f, 5.52324355e-01f, -1.22928214e+00f, -8.82058263e-01f,
  6.68973997e-02f, -2.57724792e-01f, -4.12646651e-01f, 4.59882647e-01f, 4.48924512e-01f, 2.02041700e-01f, -9.89761412e-01f, -1.02266812e+00f, -2.85234358e-02f, 8.62552077e-02f,
  5.67350276e-02f, -1.29974753e-01f, 1.98526740e-01f, 1.13170102e-01f, -1.87160783e-02f, -2.42326467e-04f, 4.21506092e-02f, 9.39467922e-02f, 6.78137094e-02f, 2.24032283e-01f,
  -8.37668106e-02f, -9.09418464e-02f, -9.98226032e-02f, -6.01174422e-02f, 1.38620928e-01f, 8.13792199e-02f, -8.26201290e-02f, 3.59483659e-01f, 2.58156270e-01f, -3.15906048e-01f,
  2.95427561e-01f, 1.80815369e-01f, 2.60142326e-01f, -1.97819442e-01f, -3.09861451e-01f, -4.72888947e-01f, 3.66342694e-01f, -1.97190698e-02f, 9.23094973e-02f, 2.01266810e-01f,
  -2.31496871e-01f, -2.43968695e-01f, -5.33686168e-02f, 3.86926144e-01f, 9.45153534e-02f, -5.36791757e-02f, -9.37148154e-01f, -7.05340087e-01f, 1.63708866e-01f, 4.13354635e-01f,
  1.08487594e+00f, 1.22709766e-01f, 5.71685731e-01f, -5.84540963e-02f, 9.63714421e-02f, -6.97941840e-01f, 7.98349440e-01f, -6.43570304e-01f, -5.14874339e-01f, 3.95847159e-03f,
  -9.39811051e-01f, -4.72300321e-01f, -3.15632373e-02f, -5.36052465e-01f, -9.46886480e-01f, -1.06686227e-01f, -1.05180454e+00f, -4.58383232e-01f, -9.07445252e-02f, 5.53344309e-01f,
  -6.83488727e-01f, 6.29394412e-01f, -8.87445286e-02f, 3.78490947e-02f, 5.42293563e-02f, -8.08686972e-01f, 2.03348696e-01f, 1.90266341e-01f, -9.13835391e-02f, -2.86302328e-01f,
  -2.74829239e-01f, -1.77622318e-01f, -1.41606674e-01f, -2.27844745e-01f, -8.26496407e-02f, -9.28861350e-02f, -1.32721961e-01f, -3.97188812e-01f, 1.23005815e-01f, -1.16995901e-01f,
  -5.19734547e-02f, 2.45895963e-02f, -2.41037369e-01f, -1.05390675e-01f, -3.23243111e-01f, -1.80048302e-01f, -2.04787016e-01f, -8.28149617e-02f, 1.01578094e-01f, 9.13909227e-02f,
  -3.68944317e-01f, -2.34084520e-02f, -4.89788353e-01f, 3.03194262e-02f, -3.65961827e-02f, -1.66962445e-01f, 2.27573588e-01f, 2.03586429e-01f, -8.62164572e-02f, 5.94784915e-02f,
  -1.76995784e-01f, -7.36951709e-01f, -4.58575100e-01f, -3.04386169e-01f, 1.36289120e-01f, -1.66769922e-02f, 5.61668634e-01f, -9.77190375e-01f, -7.35630155e-01f, 4.60381538e-01f,
  2.01315925e-01f, 4.21317190e-01f, 2.81706780e-01f, -8.14928651e-01f, 2.38236949e-01f, -2.58775413e-01f, -9.32055056e-01f, 8.08086574e-01f, -6.49286270e-01f, -5.72999418e-01f,
  2.63089746e-01f, 6.02482200e-01f, -1.07122004e+00f, 3.38585824e-01f, -5.40612519e-01f, 2.59250790e-01f, -1.21979423e-01f, -1.62115365e-01f, 1.32263556e-01f, -1.65623203e-02f,
  -7.97933992e-03f, -1.19426310e-01f, 8.90221298e-02f, -1.53458834e-01f, -1.33707806e-01f, -7.93447569e-02f, -7.16640940e-03f, -2.61775285e-01f, 2.25978062e-01f, -1.31700024e-01f,
  -3.83054733e-01f, -1.14193380e-01f, -9.60383639e-02f, -1.66226625e-01f, -3.18505704e-01f, 1.59089297e-01f, -6.74936101e-02f, -2.20715046e-01f, -4.89775211e-01f, -3.71652782e-01f,
  -2.36845493e-01f, 4.50242218e-03f, 1.73464477e-01f, -1.89190894e-01f, -1.69587761e-01f, -1.00328036e-01f, 1.55523464e-01f, 3.33278142e-02f, -1.65891141e-01f, -2.14138687e-01f,
  1.18350856e-01f, -8.52267444e-02f, 3.03687334e-01f, 8.61174837e-02f, -2.88982064e-01f, -3.20569038e-01f, 1.68234468e-01f, 4.51654017e-01f, -1.98395103e-01f, 5.30101597e-01f,
  -3.59057724e-01f, -5.30622482e-01f, 9.46622416e-02f, 3.41658711e-01f, 5.69099858e-02f, 1.72817394e-01f, -2.31732681e-01f, 4.53036278e-02f, 1.60589159e-01f, 1.56351745e-01f,
  8.40470493e-02f, -1.31135893e+00f, 5.47822058e-01f, 7.76455030e-02f, -1.09835915e-01f, -2.44935125e-01f, -3.29800665e-01f, 9.31838229e-02f, 1.41496837e-01f, -6.33577853e-02f,
  5.66525310e-02f, -1.38145518e-02f, -1.07070003e-02f, 1.34460121e-01f, -9.10902172e-02f, -4.92020622e-02f, 4.52422611e-02f, 1.40723482e-01f, -1.03950396e-01f, 5.93207330e-02f,
  1.95883647e-01f, 3.20035905e-01f, 4.99027036e-02f, -6.60554767e-02f, 2.91427314e-01f, 2.54771411e-01f, 2.35349432e-01f, -1.56917505e-03f, 2.11806461e-01f, -8.91856104e-02f,
  -2.70708233e-01f, 8.01602029e-04f, 4.94903848e-02f, -9.53967050e-02f, -1.39355227e-01f, 1.28983289e-01f, -7.36862272e-02f, 4.64901000e-01f, -1.32191449e-01f, 1.25690892e-01f,
  1.24744959e-01f, 4.83329147e-02f, -3.55875269e-02f, -1.63276374e-01f, -3.77866738e-02f, -2.42684022e-01f, 1.52505249e-01f, -1.90538481e-01f, 7.79625893e-01f, 2.83096224e-01f,
  -2.54763633e-01f, -7.06098020e-01f, -3.03718656e-01f, 1.08322650e-01f, 1.36258304e-02f, -8.89042914e-02f, -7.88748085e-01f, -8.70970249e-01f, -8.64798725e-01f, -9.55984890e-01f,
  -2.20072970e-01f, -2.50490546e-01f, 2.73057759e-01f, 1.15186766e-01f, 1.23974073e+00f, -3.68428499e-01f, 8.37819457e-01f, -4.00063396e-01f, 2.32951373e-01f, -4.48184200e-02f,
  4.01025921e-01f, -7.61524022e-01f, 4.95747417e-01f, -1.35942352e+00f, -2.38605831e-02f, -3.48143727e-02f, 7.53543302e-02f, 9.13031697e-02f, 1.55778497e-01f, -2.59287000e-01f,
  -7.10242465e-02f, 5.52628487e-02f, 1.67639986e-01f, -4.00859676e-02f, 5.71535043e-02f, 1.98888019e-01f, 1.21048272e-01f, 7.47895753e-03f, -4.42980565e-02f, -1.11540139e-01f,
  -2.10110396e-02f, 1.35310650e-01f, 2.01811031e-01f, 3.56693685e-01f, 6.79980367e-02f, 1.97007909e-01f, 4.70261365e-01f, 2.28481725e-01f, 2.39649355e-01f, 2.20453933e-01f,
  3.17827255e-01f, -1.99988231e-01f, -3.55992019e-01f, 7.72842169e-02f, 3.57255638e-02f, -2.07878619e-01f, -3.01565707e-01f, 2.63682067e-01f, 6.16604164e-02f, -2.81058699e-01f,
  1.57746315e-01f, -2.14558542e-01f, 4.37354576e-03f, -8.48087609e-01f, -3.68861437e-01f, 7.87371933e-01f, -8.19988966e-01f, -2.68122315e-01f, -3.60046893e-01f, 8.83333743e-01f,
  -4.28696454e-01f, -2.15552136e-01f, -9.34777558e-01f, -9.94375050e-01f, -3.78048122e-01f, -1.00828387e-01f, -5.47203660e-01f, -7.30524540e-01f, 6.63456917e-01f, -5.87620318e-01f,
  -8.45991552e-01f, -8.99348736e-01f, -3.25506896e-01f, -5.18130541e-01f, -4.80667949e-01f, -5.67610204e-01f, 4.27542478e-01f, 1.04378259e+00f, -1.87700540e-01f, -4.30766679e-02f,
  -9.95517895e-02f, 1.55611858e-01f, -1.81008711e-01f, -5.82425147e-02f, -3.53718579e-01f, 1.51388170e-02f, -4.33512479e-02f, 1.90602601e-01f, -1.82404026e-01f, -4.71169949e-01f,
  -2.41262540e-01f, -4.76136729e-02f, 1.27378702e-02f, -6.80863857e-02f, -4.44186740e-02f, -8.81038532e-02f, -2.47051701e-01f, -2.94383727e-02f, 3.18704173e-02f, 1.60381585e-01f,
  -8.40091780e-02f, 2.41459340e-01f, 4.87767421e-02f, 3.25954817e-02f, -2.49833271e-01f, 8.39779899e-02f, -4.83935103e-02f, -8.47485885e-02f, -3.89005020e-02f, 1.59295857e-01f,
  1.38441265e-01f, 6.67705163e-02f, 3.47598940e-01f, -1.12982079e-01f, 1.51771784e-01f, -1.96985975e-01f, -1.94135427e-01f, -5.73710501e-01f, 7.15256333e-02f, -5.98463058e-01f,
  -5.17544806e-01f, -4.81262058e-01f, 7.14429915e-01f, -7.88149297e-01f, -1.66921183e-01f, 6.17192864e-01f, -1.03659548e-01f, -4.37149763e-01f, -3.35371792e-01f, -1.13360047e-01f,
  -3.24257553e-01f, -3.95250112e-01f, 5.76456726e-01f, 4.91038799e-01f, -2.41545007e-01f, 6.39172077e-01f, 5.26225746e-01f, -6.59500420e-01f, -1.09114301e+00f, -4.84783985e-02f,
  -7.49022543e-01f, 1.53192610e-01f, 4.94338609e-02f, -1.05262868e-01f, 1.69998527e-01f, 3.06814760e-01f, 3.37197557e-02f, 1.22171782e-01f, -8.32556922e-04f, -1.39185600e-02f,
  2.02652320e-01f, 2.49132246e-01f, -4.80057746e-01f, 1.32201649e-02f, 1.88054293e-01f, 1.21420197e-01f, -8.42904449e-02f, 1.87597126e-01f, 1.14743449e-01f, -1.42461926e-01f,
  -1.35724217e-01f, -4.09189492e-01f, 4.44390386e-01f, 3.13316673e-01f, 2.42317811e-01f, -1.17750399e-01f, 1.30865434e-02f, 1.84803948e-01f, -3.75537843e-01f, -2.13671803e-01f,
  -4.83072363e-02f, 4.42537516e-01f, 2.46897370e-01f, -3.15097004e-01f, 3.48187566e-01f, 3.85173231e-01f, -4.97644156e-01f, 2.11506173e-01f, -3.00026476e-01f, -5.80511153e-01f,
  -3.30682993e-01f, -1.03763664e+00f, -2.53696740e-01f, -4.61804479e-01f, -4.28958476e-01f, -1.01739824e+00f, -4.89212364e-01f, -5.95883548e-01f, 9.39017653e-01f, -2.56357282e-01f,
  -4.32819903e-01f, -6.07494056e-01f, 3.40499699e-01f, -1.47029325e-01f, -3.55642140e-01f, -7.16531336e-01f, 4.00315732e-01f, 1.06745756e+00f, -6.41374588e-01f, -1.09776683e-01f,
  -3.43016488e-03f, -6.27921760e-01f, -3.08259893e-02f, -4.20633614e-01f, -9.90771204e-02f, 4.07589912e-01f, -8.57652426e-02f, -2.95241326e-02f, -8.11545586e-04f, -7.33007342e-02f,
  -5.49470037e-02f, 3.67442280e-01f, -4.90239039e-02f, 1.40941173e-01f, 2.47780666e-01f, 4.08173800e-02f, -1.48086995e-01f, 2.62642205e-01f, 1.06575880e-02f, -5.38498573e-02f,
  1.32801995e-01f, -5.51307127e-02f, 2.85549641e-01f, -1.42347559e-01f, -6.85979351e-02f, 2.32675642e-01f, 9.15204287e-02f, 5.69663420e-02f, 1.99289814e-01f, 6.52707294e-02f,
  1.35513142e-01f, -1.19849995e-01f, 1.56245559e-01f, -3.49577129e-01f, 1.25191495e-01f, -5.77606976e-01f, -2.60552227e-01f, 4.00902599e-01f, 8.99851099e-02f, -9.14193764e-02f,
  -4.57412809e-01f, 1.68351665e-01f, 3.39390427e-01f, 2.16251209e-01f, 7.49749005e-01f, -4.26233560e-01f, -4.82065268e-02f, 6.74677670e-01f, -5.18670678e-01f, -9.90339696e-01f,
  -3.10280442e-01f, 3.42756569e-01f, 4.47385758e-01f, 5.30528903e-01f, 8.85635555e-01f, -9.24560428e-02f, 2.04847276e-01f, -1.83500499e-01f, -8.01595211e-01f, -5.76285124e-01f,
  -3.80747050e-01f, -6.66676104e-01f, 5.81875741e-01f, 7.86190212e-01f, -1.06252778e+00f, -6.95118129e-01f, -5.78341961e-01f, -7.93563783e-01f, 5.43272197e-02f, -9.64061558e-01f,
  1.33771315e-01f, 3.99762243e-02f, -9.80127752e-02f, 1.63223132e-01f, 1.21966295e-01f, -9.80677158e-02f, 2.09506914e-01f, 5.06788604e-02f, -1.69957578e-02f, -9.69788656e-02f,
  7.40001723e-02f, 1.68390319e-01f, 1.00730471e-01f, 5.15547320e-02f, 1.51305562e-02f, -2.90905107e-02f, 1.49386585e-01f, 7.43551645e-04f, 1.71688497e-01f, -2.93072015e-01f,
  -3.89540493e-01f, -5.70924997e-01f, 6.42935410e-02f, 1.50215998e-01f, -1.53549299e-01f, -1.60224903e-02f, 1.20078884e-02f, -3.11468720e-01f, 3.15357774e-01f, -5.14324069e-01f,
  4.83446330e-01f, -1.57370418e-01f, -4.08027261e-01f, 9.01399478e-02f, 3.60224634e-01f, -9.60812569e-02f, 1.03455886e-01f, -1.89467460e-01f, -1.87659681e-01f, -1.56681702e-01f,
  -1.76531762e-01f, -4.95791048e-01f, -4.92526799e-01f, 6.00110590e-01f, -2.79134601e-01f, -2.86827952e-01f, 1.65722579e-01f, -4.87521082e-01f, -2.35365499e-02f, 9.00325254e-02f,
  2.65678942e-01f, -5.61432838e-01f, -4.40550894e-01f, 7.97102749e-01f, -6.95193589e-01f, 6.50034487e-01f, -1.74745902e-01f, -3.66550058e-01f, 3.15233588e-01f, -6.20043635e-01f,
  -1.30131543e+00f, -8.07361364e-01f, -7.41445363e-01f, -7.05048025e-01f, 1.38174845e-02f, 2.16780066e-01f, -3.48173946e-01f, -1.78096488e-01f, 8.92656147e-02f, 1.01805203e-01f,
  1.38646010e-02f, 5.24446070e-02f, 2.38096751e-02f, -1.44621864e-01f, 1.25866532e-01f, -3.44086438e-01f, 1.13438472e-01f, 1.63981661e-01f, 1.82357833e-01f, 1.25479788e-01f,
  -4.00827527e-02f, 1.01543263e-01f, 2.06734806e-01f, -5.37749171e-01f, -1.32908300e-01f, 1.74797401e-01f, -8.83065104e-01f, 9.28939953e-02f, 2.33924598e-01f, 1.61697775e-01f,
  4.07914072e-01f, 3.76679689e-01f, -3.95679057e-01f, 3.23121488e-01f, -3.58754694e-01f, -4.31801736e-01f, 4.41060066e-01f, -2.68312395e-02f, 2.00590193e-01f, -3.32270414e-01f,
  -4.11948681e-01f, 3.31638038e-01f, -7.00944424e-01f, -3.95535648e-01f, -3.14739168e-01f, -7.03327954e-01f, -4.92045730e-01f, -6.46895528e-01f, 2.54098922e-01f, -2.58436382e-01f,
  -6.06111050e-01f, 3.02814215e-01f, -2.66090065e-01f, 1.15361607e+00f, 1.83192760e-01f, -4.13702577e-02f, -3.45903873e-01f, -4.47811306e-01f, -5.42441666e-01f, -3.12391371e-01f,
  -5.58954954e-01f, 5.73656335e-02f, -7.51877069e-01f, 1.57192349e-02f, -8.16871822e-01f, -2.65189201e-01f, 9.51348364e-01f, 6.17425382e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -2.61558861e-01f, 2.25053057e-01f, 2.25014076e-01f, -3.82601142e-01f, -7.72873089e-02f, 1.21168800e-01f, -5.78218736e-02f, -8.95372406e-02f, -2.99633145e-01f, -2.53910944e-02f,
  -4.27619427e-01f, 1.44405693e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    