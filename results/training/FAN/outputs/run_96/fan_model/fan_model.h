/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.89195842e-01f, 1.62400946e-01f, -1.64786771e-01f, -5.86960912e-02f, 3.86066318e-01f, -5.23776188e-02f, -1.79415047e-01f, 1.60832971e-01f, -2.18132645e-01f, 5.92401624e-03f,
  1.07054878e-02f, 1.01386853e-01f, -3.38651016e-02f, -1.37254689e-02f, -2.32965663e-01f, -3.30282718e-01f, -2.67213345e-01f, -1.47634581e-01f, -1.15787081e-01f, 6.48126677e-02f,
  -3.56038995e-02f, 3.63332659e-01f, -1.44804269e-01f, 2.95348376e-01f, 2.63322294e-01f, 8.65896642e-02f, 2.62984782e-01f, 5.77472523e-02f, 7.51412734e-02f, 9.28052515e-02f,
  -1.48563370e-01f, 6.80366009e-02f, -5.20801283e-02f, -5.70915081e-02f, -2.91397031e-02f, -5.81025612e-03f, -5.70559595e-03f, -4.53979056e-03f, -1.17741175e-01f, -6.84112161e-02f,
  6.06931783e-02f, 1.18692964e-01f, 3.18430513e-02f, -1.21302931e-02f, 1.14221230e-01f, -3.05000264e-02f, -2.04108912e-03f, -1.12635851e-01f, 9.06359330e-02f, 5.58868758e-02f,
  -2.04724316e-02f, -5.15629835e-02f, 1.51409646e-02f, 4.28735279e-02f, 7.10521787e-02f, -3.42796706e-02f, -9.67751071e-02f, 1.13704463e-03f, -9.82403159e-02f, -6.71945587e-02f,
  1.05961122e-01f, 4.11635414e-02f, 1.07665591e-01f, -6.49452358e-02f, -3.50832753e-03f, 1.79823544e-02f, 4.70631048e-02f, 3.92023921e-02f, -1.23207923e-02f, 9.02254209e-02f,
  -1.82292908e-02f, 3.48219164e-02f, 1.32165225e-02f, -3.99084017e-03f, 2.47648135e-02f, -2.02538632e-02f, -1.07956585e-02f, 3.66725586e-02f, -3.44881341e-02f, -5.13179228e-02f,
  1.29598414e-03f, -6.83754161e-02f, 6.36958480e-02f, 2.38782298e-02f, -5.01138456e-02f, 1.23304026e-02f, 1.49411902e-01f, -4.61916700e-02f, -8.83994326e-02f, 1.11058785e-03f,
  3.24631296e-02f, 1.52743787e-01f, -2.74824109e-02f, 9.24371555e-03f, -5.15179522e-02f, 3.89902852e-03f, -5.07839695e-02f, 1.29735634e-01f, -1.79902446e-02f, 3.44928354e-02f,
  8.21648836e-02f, -3.77336144e-03f, -5.69102950e-02f, 2.60082539e-02f, -3.27710211e-02f, 6.05484881e-02f, 1.14413284e-01f, -9.90961790e-02f, 5.69023900e-02f, 6.70425370e-02f,
  1.61749616e-01f, 2.93212682e-02f, 4.60288823e-02f, -1.35439094e-02f, 3.65021974e-02f, 1.81194935e-02f, 2.40381174e-02f, 9.33738519e-03f, 1.26717184e-02f, -1.58276185e-01f,
  -9.99264792e-02f, 1.30088568e-01f, 1.96825340e-01f, -6.92880601e-02f, -8.36084932e-02f, -2.41638348e-01f, -2.11255103e-01f, 7.56572783e-02f, 1.43862575e-01f, 1.22173399e-01f,
  -9.52904597e-02f, 1.23332195e-01f, -5.09467581e-03f, -1.93545476e-01f, -4.02501404e-01f, -5.20413369e-02f, -3.25781614e-01f, -1.56745553e-01f, 1.43399443e-02f, -1.23663478e-01f,
  -3.23673263e-02f, -4.19290036e-01f, 4.20948351e-03f, -1.44202039e-01f, -7.28822798e-02f, 1.33548364e-01f, 7.99306110e-03f, 7.96635374e-02f, -4.86744158e-02f, -1.07622683e-01f,
  -1.18402027e-01f, 1.11309424e-01f, 2.01419387e-02f, -3.97035666e-02f, -5.76779433e-02f, -5.16385175e-02f, -1.14240654e-01f, 2.06723362e-02f, 2.58827638e-02f, 5.72248437e-02f,
  2.77375374e-02f, -5.75951934e-02f, 3.43391648e-03f, -2.54430100e-02f, 8.90940020e-04f, 6.25856072e-02f, 3.41807976e-02f, 9.93814841e-02f, 2.93686837e-02f, 9.77486297e-02f,
  1.76707599e-02f, 1.26297846e-01f, 3.45225520e-02f, 7.15563893e-02f, 4.93188985e-02f, 3.76749001e-02f, 3.92170548e-02f, 3.67225744e-02f, 5.09199798e-02f, 6.33152872e-02f,
  2.99909469e-02f, -4.93378751e-02f, -1.09422453e-01f, 1.44314319e-02f, -6.78025335e-02f, -1.35679413e-02f, -4.25794311e-02f, -1.11164398e-01f, -4.65139002e-02f, -1.48910582e-01f,
  -1.22824810e-01f, -1.70047861e-02f, -2.21299566e-02f, -2.40388326e-02f, -7.52940029e-03f, 7.66488016e-02f, 2.51231194e-02f, -2.40813512e-02f, -1.45467371e-01f, -1.30255163e-01f,
  5.89925312e-02f, -1.17223337e-01f, -9.68755931e-02f, -3.22672874e-02f, -6.01132549e-02f, 1.61275700e-01f, 3.40677425e-02f, 1.11462772e-01f, 1.72937050e-01f, -1.33346230e-01f,
  -9.33465064e-02f, -1.37928575e-01f, -6.89714476e-02f, -8.67374167e-02f, -8.90007243e-02f, -8.57817456e-02f, -6.42197505e-02f, -8.97910669e-02f, -1.55435372e-02f, -9.29094944e-03f,
  -1.61334220e-02f, -1.84190124e-02f, 7.61038586e-02f, -8.77475217e-02f, -3.04502789e-02f, -5.89988614e-03f, -5.13584800e-02f, -6.78998244e-04f, -1.00319624e-01f, -9.54509433e-03f,
  1.94318239e-02f, 5.05679334e-03f, -3.76457460e-02f, -1.42405052e-02f, -4.15168144e-02f, 2.50491332e-02f, 3.48116383e-02f, 7.50255883e-02f, -4.32070084e-02f, 8.68546143e-02f,
  2.50832140e-01f, -1.65561676e-01f, 1.42999575e-01f, -7.03907833e-02f, 1.11944236e-01f, 7.40178823e-02f, 1.30940184e-01f, -7.83953965e-02f, 5.86542152e-02f, -4.41883773e-01f,
  -3.63866955e-01f, 1.05562091e-01f, -8.96146744e-02f, -2.11133957e-01f, 2.08384678e-01f, -1.89595997e-01f, 5.76332808e-02f, -2.49043405e-02f, 1.93838283e-01f, 6.56452328e-02f,
  4.48800204e-03f, -1.13326564e-01f, -6.73601255e-02f, -5.96421249e-02f, 3.80797312e-02f, 4.83987071e-02f, -3.09491456e-01f, 1.14199400e-01f, -2.89460301e-01f, 1.16014248e-02f,
  6.54273480e-02f, 1.68600112e-01f, 1.74233943e-01f, 1.76544338e-01f, 1.22059390e-01f, 1.13157727e-01f, 1.19825892e-01f, 5.73655367e-02f, 1.67644590e-01f, -1.22401558e-01f,
  -2.01458689e-02f, 4.51663956e-02f, -1.66190669e-01f, 1.13466034e-04f, 5.09810857e-02f, -5.99269383e-02f, 1.13312481e-02f, 4.61093783e-02f, 6.28308952e-02f, -6.31162012e-03f,
  -5.20302616e-02f, -8.24658871e-02f, 3.31641058e-03f, -1.15530483e-01f, 4.95091872e-03f, 1.98532864e-02f, 9.75177437e-03f, -4.56224196e-02f, -6.43158853e-02f, 1.51162851e-04f,
  -2.42310762e-02f, 2.11564243e-01f, 5.87957464e-02f, 1.10867329e-01f, 3.06184869e-02f, -2.13298369e-02f, 7.82120600e-02f, 3.34602930e-02f, 1.07672080e-01f, 1.02388293e-01f,
  6.83141425e-02f, 9.45452452e-02f, 1.02809630e-01f, 1.35920048e-01f, -1.02667855e-02f, -8.67875479e-03f, -2.64961869e-02f, -5.13567822e-03f, 1.20132051e-01f, -1.49992900e-02f,
  -3.17952856e-02f, -1.59187503e-02f, 5.49873151e-02f, 3.31480131e-02f, -6.40152618e-02f, -1.21594602e-02f, -1.05631255e-01f, -5.34154102e-02f, -1.30118411e-02f, 3.87718864e-02f,
  7.21233487e-02f, -5.50579578e-02f, 1.04164846e-01f, 6.92901984e-02f, -9.34333354e-03f, -1.05604067e-01f, 1.35460407e-01f, -5.68588264e-03f, 6.91984370e-02f, -8.09768736e-02f,
  1.49335330e-02f, -1.09946020e-01f, 7.10175512e-03f, 5.02703376e-02f, -1.28060877e-01f, -1.32751673e-01f, -1.23378653e-02f, 1.52242398e-02f, -7.27514774e-02f, -1.48860708e-01f,
  1.40819745e-03f, -6.85591623e-02f, -7.16204643e-02f, -1.19939759e-01f, -1.44252837e-01f, -7.36623779e-02f, -6.78742006e-02f, 4.02105600e-03f, -7.82947466e-02f, -4.40686159e-02f,
  5.22650629e-02f, 5.14438599e-02f, 6.54178113e-02f, -1.70861527e-01f, -2.24054143e-01f, -3.16131890e-01f, -1.41940355e-01f, -2.10229188e-01f, -2.03437418e-01f, 1.22087903e-01f,
  -1.81174338e-01f, 1.29905686e-01f, 1.26747981e-01f, -2.71117687e-01f, -2.75920242e-01f, 4.25084643e-02f, -2.68292516e-01f, -1.14529230e-01f, -1.35638028e-01f, 4.18517040e-03f,
  -8.25357810e-02f, -9.94566754e-02f, -1.47243626e-02f, -7.08756000e-02f, 1.83640439e-02f, 1.21932708e-01f, 2.17691511e-02f, 2.28834059e-02f, -1.51859000e-02f, -1.03737958e-01f,
  -4.57863919e-02f, -9.08413529e-02f, 6.23073662e-03f, -8.80231056e-03f, 3.52546806e-03f, 9.95974466e-02f, 2.65504327e-02f, -3.75519991e-02f, 2.66803615e-02f, 1.04813159e-01f,
  9.96232256e-02f, 7.32759610e-02f, 5.42472163e-03f, 3.00945919e-02f, 1.08816341e-01f, 6.48909286e-02f, -1.68064218e-02f, 7.37789180e-03f, 3.74983512e-02f, 1.12245157e-01f,
  5.91648035e-02f, 1.53647363e-01f, 2.70045977e-02f, 4.66472097e-02f, 1.45201134e-02f, -6.63793236e-02f, -2.77779084e-02f, 5.34560010e-02f, 5.70411198e-02f, 2.20915526e-02f,
  6.47413954e-02f, -3.78589481e-02f, -4.75344323e-02f, -9.47235525e-03f, -1.09332830e-01f, -9.36139300e-02f, -1.27500683e-01f, -3.30274031e-02f, -6.90988675e-02f, -3.78308892e-02f,
  -1.09628744e-01f, -1.08701490e-01f, -1.12140879e-01f, -1.29817069e-01f, -1.37422280e-02f, -2.15556491e-02f, 2.86123324e-02f, -6.79525286e-02f, -3.46184634e-02f, -1.13112673e-01f,
  -1.84297729e-02f, -1.71500757e-01f, -3.04255215e-03f, 1.17823653e-01f, -1.11389488e-01f, -4.76389751e-03f, -7.87330605e-03f, -1.24706258e-03f, -1.24354817e-01f, -3.30534242e-02f,
  -2.54821599e-01f, -2.40066782e-01f, -1.23546213e-01f, 2.66365651e-02f, -1.37908962e-02f, -8.18256214e-02f, -7.07156807e-02f, -1.87181860e-01f, -6.70158491e-02f, -7.53762200e-02f,
  -3.85134947e-03f, -6.15986325e-02f, 7.94796422e-02f, -1.65721141e-02f, 4.86177467e-02f, -3.15688662e-02f, 3.30387726e-02f, -1.85342968e-01f, 8.16171169e-02f, 2.22109370e-02f,
  1.06988929e-01f, 5.14390618e-02f, -1.80210527e-02f, -4.92952541e-02f, 1.82687696e-02f, 6.03931956e-02f, -2.27380563e-02f, 1.55293085e-02f, 1.09733887e-01f, 2.60903537e-02f,
  5.76725602e-01f, -3.45858335e-01f, 3.71802412e-02f, 1.95066035e-01f, 1.79939136e-01f, 2.00296178e-01f, 6.95251152e-02f, 2.93187555e-02f, 5.70837222e-02f, -2.94946492e-01f,
  1.46263018e-01f, -1.01370867e-02f, -1.59189790e-01f, -8.14119726e-02f, 3.31093490e-01f, -1.96562842e-01f, 1.56255007e-01f, 1.33316107e-02f, 9.41492021e-02f, 8.13715309e-02f,
  1.55895740e-01f, 3.82562019e-02f, 2.07953885e-01f, -1.06451511e-01f, 7.57377222e-02f, 5.04244603e-02f, -3.30906152e-03f, -1.95677727e-01f, 2.65069157e-02f, -1.25505356e-02f,
  1.39187470e-01f, 7.26853823e-03f, 1.75818484e-02f, -3.03466115e-02f, 4.87807877e-02f, -6.36990890e-02f, 7.56530538e-02f, -5.72172105e-02f, 1.14377523e-02f, -5.88593539e-03f,
  6.47337548e-03f, 5.94501235e-02f, 1.40791330e-02f, -2.82122362e-02f, -2.68134419e-02f, -7.45918155e-02f, -2.55283695e-02f, 6.58772737e-02f, 3.18060815e-02f, 4.84063514e-02f,
  -6.54298067e-02f, -2.43169926e-02f, -4.79144119e-02f, -3.87767702e-02f, 6.43660277e-02f, -1.22945243e-02f, 4.10211012e-02f, 4.72772196e-02f, -8.82416144e-02f, -2.58810893e-02f,
  -4.59249057e-02f, 3.93719077e-02f, -2.92348154e-02f, -1.48567539e-02f, -3.20699811e-02f, 1.03161270e-02f, -5.55532463e-02f, -3.77997980e-02f, -1.21441940e-02f, 2.09271554e-02f,
  2.93058567e-02f, -5.87715418e-04f, -6.70243576e-02f, 9.53149702e-03f, -2.62539778e-02f, 2.22903714e-02f, 1.54924849e-02f, 2.71129832e-02f, 1.46518573e-01f, 1.04688801e-01f,
  -8.52112174e-02f, -4.02902476e-02f, -5.04833832e-03f, 1.52230397e-01f, -5.17990850e-02f, -5.03955707e-02f, -3.01234592e-02f, -1.12948991e-01f, 3.97395268e-02f, 4.54066470e-02f,
  1.59147516e-01f, -5.27850762e-02f, -3.70293530e-03f, -1.08777862e-02f, -1.07632868e-01f, -1.15490474e-01f, -6.02080300e-02f, 2.74142027e-02f, -8.21140409e-02f, 7.22409645e-03f,
  1.17384657e-01f, -1.43366680e-02f, -3.64591181e-02f, 5.14161624e-02f, 7.21888095e-02f, 5.03125079e-02f, 1.45600587e-02f, 2.39631720e-02f, 4.15078551e-02f, 1.19228370e-01f,
  2.10804287e-02f, -4.50666696e-02f, -6.79628477e-02f, 7.46132340e-03f, 8.67350921e-02f, 6.46232069e-02f, 4.55068462e-02f, 3.77805158e-02f, -5.93866222e-02f, -1.41038120e-01f,
  2.53477961e-01f, -2.94035047e-01f, 9.63138863e-02f, -7.99226388e-02f, -3.62928867e-01f, -1.41285256e-01f, -3.22103407e-03f, -2.66525447e-01f, -2.54861474e-01f, -6.88019544e-02f,
  -1.55902073e-01f, 5.27864508e-02f, -3.85272577e-02f, 1.73647925e-02f, 2.01857030e-01f, -2.72568427e-02f, 6.64826930e-02f, -1.24782674e-01f, -2.29266778e-01f, 9.83249675e-03f,
  -8.78558531e-02f, -1.66838393e-01f, 1.91947997e-01f, -2.13506132e-01f, -8.41931719e-03f, 8.45432095e-03f, 8.68909135e-02f, -1.35079980e-01f, 1.04094245e-01f, -7.90681690e-02f,
  8.60152319e-02f, 8.36783797e-02f, 2.18905076e-01f, 2.42268876e-03f, 1.71075121e-01f, 1.32499009e-01f, 1.84362214e-02f, 7.84720108e-03f, -1.20828347e-03f, -5.95457572e-03f,
  -1.98235456e-02f, 2.20781043e-02f, -3.81881595e-02f, -3.83548774e-02f, -1.61132142e-01f, 7.05922768e-02f, -5.92529103e-02f, -8.48965906e-03f, -2.59513762e-02f, 5.33933006e-02f,
  4.92671598e-03f, 5.65769374e-02f, 6.46860991e-03f, -7.39695653e-02f, 5.39387614e-02f, -4.92811687e-02f, 1.77573234e-01f, 3.15944776e-02f, 3.30096968e-02f, 1.19042717e-01f,
  5.73292971e-02f, -2.61100046e-02f, -3.35634430e-03f, -6.90714419e-02f, -6.31633634e-03f, 3.51176262e-02f, -1.47613660e-01f, -7.71085126e-03f, 5.19056469e-02f, 4.07256791e-03f,
  7.48869218e-03f, -1.89768914e-02f, -1.58098862e-01f, -8.40241238e-02f, 8.31189826e-02f, 6.28460124e-02f, 1.17145488e-02f, -6.08767606e-02f, -1.60267353e-01f, 4.94100852e-04f,
  -5.96315674e-02f, -7.63386786e-02f, -1.18702976e-03f, -1.20340087e-01f, -5.29783517e-02f, -4.38498557e-02f, -9.36906487e-02f, 5.55361509e-02f, -5.91824017e-02f, -2.51122918e-02f,
  -4.71600145e-02f, -2.27026761e-01f, -1.23280073e-02f, -5.44442087e-02f, 3.32259201e-02f, -4.23741015e-03f, -5.64377755e-03f, -1.37367137e-02f, -7.06040561e-02f, 1.12474605e-01f,
  -4.27410305e-02f, 4.67441194e-02f, 3.81795950e-02f, -1.89849034e-01f, 4.02010530e-02f, -4.36604321e-02f, -6.25787675e-03f, -1.62662342e-01f, 1.94086153e-02f, -3.71744186e-02f,
  5.02578579e-02f, -6.74302503e-02f, 2.71192640e-02f, -8.68495274e-03f, 3.17042284e-02f, 9.90441348e-03f, 4.49353121e-02f, -4.38971892e-02f, -8.77299532e-02f, 2.16344632e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.74393192e-01f, -4.96516585e-01f, 4.51625884e-01f, 4.26844686e-01f, -8.76977593e-02f, -2.76110232e-01f, 3.08381259e-01f, -3.81872088e-01f, -7.68347159e-02f, -4.12790120e-01f,
  -3.34451318e-01f, 3.86230946e-01f, -5.49087703e-01f, 2.52438366e-01f, 6.03187919e-01f, -3.21407109e-01f, 2.66033993e-03f, 1.00744806e-01f, 2.16872375e-02f, -7.88702369e-02f,
  4.12366837e-02f, -7.04908520e-02f, 1.69852629e-01f, -1.47207290e-01f, 3.77164297e-02f, 2.28088602e-01f, 1.87042475e-01f, 5.33247292e-02f, 3.96493256e-01f, 2.25973740e-01f,
  -2.69417793e-01f, 6.75120857e-03f, -2.75408644e-02f, -1.40111903e-02f, -1.95387691e-01f, -4.49866615e-02f, 1.81230620e-01f, 1.95299894e-01f, 1.15281507e-01f, -4.25610729e-02f,
  -3.19008529e-02f, 1.13587148e-01f, 8.50308165e-02f, 4.23530154e-02f, -3.86672579e-02f, 4.08085957e-02f, 4.19238135e-02f, -1.54735342e-01f, 7.58033246e-02f, 7.63769001e-02f,
  -1.35994200e-02f, -2.11427018e-01f, -5.27864583e-02f, 1.72170962e-03f, 1.54217109e-01f, -5.69648147e-02f, 9.71282199e-02f, 7.94792548e-02f, 4.64276969e-02f, 9.96612757e-02f,
  -1.90710705e-02f, -6.05728291e-02f, -2.69690305e-02f, 6.13331832e-02f, -4.52829190e-02f, -8.27539538e-04f, -3.26673836e-02f, -5.90715036e-02f, 5.03875874e-02f, -1.42452300e-01f,
  1.91646405e-02f, 1.35241756e-02f, 7.67509639e-02f, -8.14876780e-02f, -1.42282923e-03f, 6.16609380e-02f, 1.08126312e-01f, -3.04969735e-02f, -6.43716753e-02f, 2.48378068e-02f,
  4.74215113e-02f, 4.26984727e-02f, -8.05422142e-02f, -5.78225665e-02f, -7.31425062e-02f, -5.90814352e-02f, -5.77793494e-02f, 2.27324273e-02f, -6.43788427e-02f, -3.27118039e-02f,
  -5.10364950e-01f, -1.16284736e-01f, -7.93205127e-02f, -1.27854437e-01f, 9.86525789e-03f, -1.18033335e-01f, 5.28286211e-02f, -9.40810069e-02f, -5.49624972e-02f, 9.50822141e-03f,
  -1.45250097e-01f, 3.71966586e-02f, -1.99772771e-02f, -2.44261534e-03f, 5.36795594e-02f, -3.60213704e-02f, 1.19616136e-01f, -9.71561074e-02f, -4.59573083e-02f, -1.38882129e-02f,
  -1.87677070e-02f, -8.05388764e-02f, 1.14727169e-02f, -3.33092846e-02f, -3.26255448e-02f, -9.35714096e-02f, 5.59152663e-02f, -3.17519605e-02f, -1.64720248e-02f, 3.06350496e-02f,
  -4.35088962e-01f, 2.24551186e-01f, 3.61808926e-01f, -2.94313967e-01f, 2.10812509e-01f, 6.09252393e-01f, 2.66170055e-01f, 1.27716828e-02f, -2.36328855e-01f, -1.45809218e-01f,
  -3.93029563e-02f, 7.24124908e-02f, 3.21895480e-01f, -1.10499553e-01f, 3.15424204e-01f, 2.99929649e-01f, -3.66708301e-02f, 3.92993279e-02f, -3.61768939e-02f, -3.64309177e-02f,
  4.03476693e-02f, -1.99122112e-02f, 2.78966546e-01f, -1.84341744e-01f, 9.37273428e-02f, -2.42453516e-01f, -2.02879921e-01f, 2.56913424e-01f, -1.25404418e-01f, 1.66347623e-01f,
  -2.37867367e-02f, -3.06468755e-01f, 8.24664906e-02f, 9.12630111e-02f, 2.33439747e-02f, -1.34177757e-02f, 5.85974976e-02f, 1.34166285e-01f, -7.77252018e-02f, 1.97898969e-02f,
  -3.74583504e-03f, -8.62141047e-03f, -1.43659607e-01f, 4.94973697e-02f, 7.10539967e-02f, -1.59375109e-02f, 1.50768369e-01f, 1.76188946e-01f, 1.61219597e-01f, 9.81292799e-02f,
  2.27801263e-01f, 1.35100961e-01f, 5.19155562e-02f, 6.66849762e-02f, 9.48685631e-02f, 2.03243773e-02f, 1.12212226e-02f, 1.08307354e-01f, 1.48431748e-01f, -5.39409481e-02f,
  -1.69962812e-02f, 7.08258525e-03f, 7.69205019e-02f, 1.06854020e-02f, -2.40815524e-02f, -9.52036828e-02f, 1.81156397e-02f, 1.91748273e-02f, -3.24118808e-02f, 2.52335593e-02f,
  -1.08839855e-01f, -1.42489430e-02f, -1.04957417e-01f, 9.24333408e-02f, -6.90861046e-02f, -6.82437420e-02f, 8.98212716e-02f, -4.99286056e-02f, -5.94038777e-02f, -1.50559083e-01f,
  -1.61678828e-02f, -8.45587924e-02f, -2.95713940e-03f, -1.30767701e-02f, -2.22395500e-03f, 8.82693008e-02f, -7.35142604e-02f, 1.07736126e-01f, -1.20586492e-02f, 9.96867381e-03f,
  1.05736993e-01f, -1.70679912e-01f, -2.84030475e-02f, 2.33598687e-02f, 9.72245075e-03f, 1.58635914e-01f, 1.33210309e-02f, -4.33706008e-02f, -9.92011651e-02f, 6.64678216e-02f,
  -5.64825721e-03f, -1.13022134e-01f, -1.65523414e-03f, 1.12769492e-01f, -5.41514978e-02f, 3.92370820e-02f, -1.73980684e-03f, -3.86395641e-02f, 7.17617795e-02f, -3.85450460e-02f,
  -2.24895068e-02f, -2.19173804e-02f, -5.80384172e-02f, -3.66501994e-02f, -1.41806722e-01f, 6.87831789e-02f, -1.05886348e-01f, -6.01402111e-03f, 7.69516006e-02f, -1.25439344e-02f,
  -9.96210128e-02f, -5.20808659e-02f, -4.88157980e-02f, 2.76689768e-01f, -5.55796511e-02f, 4.40337211e-01f, 5.41519284e-01f, 6.14720508e-02f, 4.43423212e-01f, 1.59674063e-01f,
  2.71480471e-01f, -3.81376036e-02f, 1.53490722e-01f, 3.55237365e-01f, 1.64178267e-01f, 2.20139191e-01f, 3.18206459e-01f, 2.42810354e-01f, -8.02780017e-02f, 5.93244378e-03f,
  4.51315567e-02f, 1.35068074e-01f, -2.81292796e-02f, -3.48845512e-01f, -8.16379637e-02f, -3.14034730e-01f, -1.31481841e-01f, -1.45169169e-01f, -4.38196622e-02f, 5.64096794e-02f,
  -1.21150896e-01f, -1.47646457e-01f, -1.69387206e-01f, -5.49660027e-02f, -1.98737439e-02f, -4.08111047e-03f, 9.05660796e-04f, 8.47197883e-03f, -6.97448803e-03f, -2.77065616e-02f,
  4.43872483e-03f, -1.04235247e-01f, 6.86719939e-02f, 5.45050949e-02f, -1.18841399e-02f, -1.18115678e-01f, -3.44159529e-02f, 3.28632258e-02f, -4.59038094e-02f, -9.55371652e-03f,
  2.52446607e-02f, 5.54074571e-02f, 6.64120540e-02f, 4.89213206e-02f, -2.88271438e-02f, 1.74911097e-02f, 4.45723781e-05f, 1.06472641e-01f, -6.95118401e-03f, 6.81013018e-02f,
  -1.35716097e-02f, -1.24653727e-02f, -4.26351652e-02f, -1.12565160e-01f, 3.37327644e-02f, -1.01263627e-01f, -1.47666074e-02f, -5.01967557e-02f, -7.14057907e-02f, 4.07991968e-02f,
  5.90780713e-02f, -5.85657842e-02f, 2.15469636e-02f, 1.94044877e-02f, -5.83004057e-02f, 4.77953907e-03f, 7.21576512e-02f, -3.71796750e-02f, 7.99132735e-02f, 6.90331310e-02f,
  2.83530238e-03f, 8.91605485e-03f, 5.59243485e-02f, -1.58952493e-02f, -6.46206066e-02f, -2.79963110e-02f, -2.97707617e-02f, 4.86019626e-02f, 8.96403715e-02f, -6.66833594e-02f,
  2.25406382e-02f, 4.64308495e-03f, -1.40339416e-02f, -9.40345787e-03f, -4.33071144e-02f, -5.20326421e-02f, -1.35627892e-02f, -3.49930152e-02f, 1.46267377e-02f, -4.79367143e-03f,
  -4.44278419e-02f, -2.76605655e-02f, -5.54947816e-02f, -2.61515100e-02f, -8.97429660e-02f, 6.87502101e-02f, -8.37909523e-03f, -6.48243800e-02f, 5.79741672e-02f, -2.84974314e-02f,
  -3.70457470e-02f, -2.50133802e-03f, -3.92315052e-02f, 1.24164727e-02f, -2.21557468e-02f, 3.71181443e-02f, 1.98997930e-02f, -4.14979607e-02f, -2.13391222e-02f, 1.21840119e-01f,
  4.78260577e-01f, 2.64561772e-01f, -7.92268068e-02f, 4.88366699e-03f, -2.26941705e-01f, 9.92719904e-02f, -7.74575025e-02f, 1.24524593e-01f, -1.36444464e-01f, 2.53561527e-01f,
  -9.40356031e-03f, 1.63719267e-01f, -3.20151486e-02f, 2.11537093e-01f, 1.20880656e-01f, -2.57276446e-01f, 2.36519843e-01f, 7.56155029e-02f, -1.17027223e-01f, 3.30939561e-01f,
  1.15337320e-01f, 3.49400818e-01f, -3.17353867e-02f, 1.77537367e-01f, 3.78907442e-01f, 1.55001909e-01f, 1.73152089e-01f, -9.30271521e-02f, 1.68071866e-01f, 8.72469600e-03f,
  2.87108477e-02f, 9.29567963e-03f, -2.47711800e-02f, -4.11761291e-02f, -3.95278111e-02f, 2.57664956e-02f, 3.91101204e-02f, -2.03078493e-01f, -5.28183505e-02f, -5.72282635e-02f,
  3.62472348e-02f, 6.40114322e-02f, 4.38846089e-02f, -2.12043356e-02f, 1.50335029e-01f, 1.11388287e-03f, -1.00411095e-01f, -2.67326608e-02f, 9.84190148e-04f, 1.59443721e-01f,
  8.38237852e-02f, -1.13229342e-01f, 1.60788059e-01f, -1.56169832e-01f, -1.41274533e-03f, -4.13778648e-02f, -3.58593240e-02f, 7.37545416e-02f, 7.09658638e-02f, -3.96563113e-02f,
  1.78736895e-01f, 2.17674971e-02f, 5.86093739e-02f, 3.03452145e-02f, -5.75482547e-02f, -1.96700752e-01f, 1.72174517e-02f, -9.94476154e-02f, -4.27940525e-02f, -4.63070627e-03f,
  -6.92479014e-02f, -5.00040501e-02f, -3.37037034e-02f, 1.33993169e-02f, 8.63946527e-02f, -1.28788513e-03f, -3.44837345e-02f, 5.21083660e-02f, -6.13619573e-02f, -7.02624619e-02f,
  -9.52576995e-02f, 7.13775158e-02f, 3.06325220e-02f, -3.38744856e-02f, 8.19446053e-03f, -1.27093345e-02f, 1.31648213e-01f, 9.71852466e-02f, -1.30165458e-01f, 4.80043180e-02f,
  -1.22660277e-02f, 3.22110891e-01f, -1.42007985e-03f, -9.48019102e-02f, -1.25886157e-01f, -3.29809524e-02f, 3.97362933e-02f, 6.92841187e-02f, 5.42162694e-02f, 3.98677327e-02f,
  1.11212969e-01f, -9.90412571e-03f, -1.99647080e-02f, 8.64257962e-02f, -7.87499398e-02f, 1.43731013e-01f, 5.24201468e-02f, -8.91255960e-02f, -4.86456193e-02f, 1.68704867e-01f,
  6.49649799e-02f, 1.15306817e-01f, 3.45510952e-02f, -1.96903244e-01f, -5.17308479e-03f, 5.03659155e-03f, 9.64770690e-02f, -7.47559965e-02f, 3.04148514e-02f, -2.22502083e-01f,
  -1.61120385e-01f, 1.78540275e-01f, 7.99584165e-02f, -5.12482166e-01f, 1.21297218e-01f, 5.24849057e-01f, -5.82599118e-02f, 5.99977411e-02f, -4.98004436e-01f, 2.13493153e-01f,
  1.94763452e-01f, -3.46999913e-01f, -5.00923768e-03f, -1.10466644e-01f, -4.22560163e-02f, -1.79191735e-02f, -3.48007726e-03f, -8.41210485e-02f, -1.01956137e-01f, 9.08117890e-02f,
  -1.42472014e-01f, -5.52598760e-02f, 4.79710735e-02f, 1.30732611e-01f, 1.48256466e-01f, 1.19763222e-02f, 1.44560277e-01f, 5.18241972e-02f, 6.69985935e-02f, -3.25567573e-02f,
  1.68372780e-01f, -1.33007810e-01f, 6.79384470e-02f, -1.85003802e-02f, 2.10869819e-01f, 8.30086470e-02f, 7.23756552e-02f, -7.92836249e-02f, -2.28473440e-01f, -1.27118424e-01f,
  -1.34732693e-01f, -2.52421856e-01f, -6.81590140e-02f, -3.78937200e-02f, -8.11247677e-02f, -1.15781777e-01f, -5.71617372e-02f, 3.22158337e-02f, -4.66540344e-02f, 5.48280105e-02f,
  -5.33724912e-02f, -7.93287084e-02f, 8.10730085e-02f, -1.62828341e-01f, -1.74039334e-01f, 1.60657223e-02f, 4.92535792e-02f, 5.87704629e-02f, -1.65173449e-02f, -6.82551637e-02f,
  7.83564802e-03f, 7.09395558e-02f, 6.70538023e-02f, 4.03797030e-02f, 7.51458928e-02f, 7.39269182e-02f, 5.07169105e-02f, -7.13393744e-03f, -7.39910379e-02f, 6.78987503e-02f,
  -4.91377898e-02f, -6.35798573e-02f, -3.38146314e-02f, -7.09636286e-02f, -4.88161705e-02f, -8.24705511e-02f, 3.48852836e-02f, -1.72929484e-02f, -4.78622504e-02f, 1.73698202e-01f,
  -6.42773211e-02f, 3.89441848e-02f, -1.30140737e-01f, -2.48974264e-02f, 5.63973933e-02f, -1.44988090e-01f, -2.93889437e-02f, 2.69398130e-02f, 1.56240627e-01f, 3.05897109e-02f,
  1.85256153e-01f, 1.90353245e-01f, 2.82249823e-02f, -1.24288857e-01f, 7.18968362e-02f, 1.66464567e-01f, 6.63357079e-02f, 8.58740285e-02f, -6.18251823e-02f, 1.22736124e-02f,
  7.41539076e-02f, -7.06126094e-02f, 2.18604833e-01f, 1.25113344e-02f, -2.46139064e-01f, 1.82888389e-01f, -5.11502661e-02f, -1.48801073e-01f, -7.56680295e-02f, 1.40194908e-01f,
  1.28882080e-01f, -1.09413922e-01f, -2.01578274e-01f, -1.04018457e-01f, -1.07330889e-01f, 1.15761749e-01f, 1.59906372e-01f, -8.42171386e-02f, -3.57731096e-02f, -1.46282449e-01f,
  -6.21575177e-01f, 3.14577818e-01f, -2.14013696e-01f, 7.57205933e-02f, -3.03693898e-02f, -4.80343640e-01f, 1.08052529e-02f, 1.04999416e-01f, -1.66373521e-01f, 3.49041641e-01f,
  2.61095494e-01f, -1.30428568e-01f, 1.95468321e-01f, 2.01535642e-01f, -5.26790261e-01f, 7.18580261e-02f, -6.06359728e-02f, 1.45426691e-02f, -3.14529575e-02f, 8.09651017e-02f,
  -1.62520945e-01f, 1.91147253e-01f, 7.01515377e-02f, 2.68779397e-01f, 1.67497229e-02f, 1.38560712e-01f, 4.11188483e-01f, 5.84117509e-02f, 1.48276627e-01f, -1.94402307e-01f,
  -2.38849208e-01f, 2.44672805e-01f, 9.66602489e-02f, -1.19697280e-01f, -6.92563206e-02f, -5.75328805e-02f, -1.09914439e-02f, -2.58009639e-02f, 8.07003826e-02f, -4.97394353e-02f,
  8.06191354e-04f, 1.17662484e-02f, 1.08043151e-02f, 5.42246215e-02f, -7.66802058e-02f, 1.75954085e-02f, -1.03844196e-01f, -8.64569247e-02f, -1.13132626e-01f, -1.21647708e-01f,
  -6.27554581e-02f, -1.37037382e-01f, -3.79768386e-02f, 4.23343881e-04f, 5.43292053e-03f, -2.56673824e-02f, -1.58409979e-02f, 2.04593260e-02f, -1.24019302e-01f, -4.98822704e-02f,
  -4.52698469e-02f, -8.11611414e-02f, 5.41412532e-02f, -3.99817787e-02f, 4.93835751e-03f, 5.04606329e-02f, 1.96440946e-02f, -3.25762704e-02f, 6.77148774e-02f, 1.01709040e-02f,
  -9.62353945e-02f, 1.23106372e-02f, 1.00296438e-01f, 6.98320046e-02f, 2.99996529e-02f, -2.75887828e-02f, -5.94060346e-02f, 6.53965622e-02f, -5.93026988e-02f, 7.07101598e-02f,
  -6.60895407e-02f, -1.07870616e-01f, 5.87919839e-02f, -4.66772951e-02f, -1.11143664e-01f, 5.61284460e-02f, 1.62374601e-02f, 1.50845796e-02f, -1.96876843e-03f, -3.38615067e-02f,
  -1.28190994e-01f, 1.88390389e-01f, 4.18974124e-02f, -6.34338707e-02f, 2.67412309e-02f, -5.64807355e-02f, 5.66420145e-02f, -8.05303920e-03f, -5.35422377e-02f, -1.86814219e-02f,
  -5.47105670e-02f, 1.15461379e-01f, -1.15646929e-01f, 4.16929722e-02f, 1.31880390e-02f, -4.03155908e-02f, 8.20530951e-02f, 2.83067822e-02f, -3.66081297e-02f, -2.94717122e-02f,
  9.28423852e-02f, 2.04659627e-05f, 1.77733619e-02f, -6.91138254e-03f, 1.07930578e-01f, -1.93458963e-02f, -6.38932884e-02f, -2.21546479e-02f, 2.03343313e-02f, 3.73747759e-02f,
  -6.14670396e-01f, 4.26757276e-01f, 5.14413536e-01f, -1.42022237e-01f, -1.03945836e-01f, 1.81678474e-01f, 1.94138840e-01f, -1.20498225e-01f, -2.64643013e-01f, 4.94000167e-02f,
  4.82823290e-02f, 2.84866750e-01f, 2.05924824e-01f, -7.40443496e-03f, -2.41708800e-01f, -2.03198120e-02f, -1.30199060e-01f, -5.25482334e-02f, -1.02734240e-03f, -1.51665017e-01f,
  -1.73426390e-01f, -2.81211257e-01f, 2.47971207e-01f, -1.81294426e-01f, 1.75174043e-01f, 1.04375042e-01f, -2.71739781e-01f, 1.09339215e-01f, -4.68697697e-02f, 1.57434225e-01f,
  3.06627946e-03f, -2.77592480e-01f, 7.78701231e-02f, 5.17721027e-02f, -4.62116562e-02f, -6.78637847e-02f, -1.79482214e-02f, 9.39000547e-02f, -4.96059060e-02f, -4.90727909e-02f,
  7.13720024e-02f, 5.31629100e-02f, -1.18889667e-01f, 4.20622304e-02f, -1.15246259e-01f, 3.82515416e-02f, 2.20245153e-01f, 1.48524240e-01f, 1.46978810e-01f, -2.88088527e-03f,
  1.65180594e-01f, 2.07330197e-01f, 7.96687976e-02f, 7.61448145e-02f, 1.02652885e-01f, 1.04644649e-01f, 6.05926514e-02f, -3.02052195e-03f, 6.68018311e-02f, -1.19512081e-01f,
  -2.62499988e-01f, 1.96847767e-02f, 1.00515991e-01f, -1.83233712e-03f, 2.68373881e-02f, 5.06026074e-02f, 1.93308163e-02f, 4.65375260e-02f, 1.16285428e-01f, -2.67636939e-03f,
  -1.23782448e-01f, 7.82126188e-02f, -1.30683720e-01f, -3.50878462e-02f, -7.37452284e-02f, -4.59122881e-02f, 7.44531751e-02f, 7.82814473e-02f, -3.21527869e-02f, 6.68685511e-03f,
  3.50351296e-02f, -5.68768522e-03f, -6.30872324e-02f, 4.59277630e-02f, 5.87946102e-02f, 7.79221058e-02f, 7.35983476e-02f, 7.87048638e-02f, -3.66721069e-03f, -3.27220745e-02f,
  -3.79460990e-01f, -6.05372131e-01f, 3.10766837e-03f, -3.52014415e-02f, 5.38807549e-02f, 2.92280782e-02f, -4.83735949e-02f, 9.66621041e-02f, -1.18631229e-01f, -9.49718207e-02f,
  1.75260138e-02f, 6.46350384e-02f, -4.34167311e-02f, 8.23051259e-02f, -8.21573734e-02f, 1.34945437e-02f, -6.45451248e-02f, 2.42050700e-02f, -6.65437356e-02f, -1.20577440e-01f,
  3.68676074e-02f, -9.90387723e-02f, 5.86395524e-02f, -1.32625908e-01f, -1.59469470e-01f, 5.76052405e-02f, -1.29202873e-01f, -3.74832191e-02f, -9.78147313e-02f, 2.22056583e-02f,
  5.86010739e-02f, -5.78099370e-01f, -1.40361518e-01f, 1.48404106e-01f, 2.61980504e-01f, 1.29807249e-01f, 7.49325752e-03f, 9.64750797e-02f, -1.28221035e-01f, -2.23818347e-01f,
  -5.52572459e-02f, -3.93178135e-01f, -3.10512602e-01f, -9.87981036e-02f, -1.71439461e-02f, -2.38949686e-01f, 2.29571890e-02f, 8.38571787e-03f, 8.12281389e-03f, -1.24561451e-02f,
  9.24540162e-02f, 2.61543155e-01f, 4.33224738e-02f, 1.76899567e-01f, 1.68971330e-01f, 1.60184324e-01f, 1.20379299e-01f, -2.62122601e-02f, 1.40894204e-01f, 6.72059483e-04f,
  -9.84073505e-02f, -4.98097055e-02f, 1.71711132e-01f, -1.90795604e-02f, 1.15214013e-01f, 4.13421951e-02f, -2.71660816e-02f, -9.84320194e-02f, 1.48167640e-01f, 7.27760196e-02f,
  -4.55832854e-02f, 9.69543755e-02f, 1.11013673e-01f, 1.29979588e-02f, 1.27435640e-01f, 2.23416928e-02f, 4.75533493e-02f, 2.31095012e-02f, -1.77513883e-02f, 2.55049691e-02f,
  -7.26295412e-02f, -8.72258171e-02f, 2.52734479e-02f, 2.93727014e-02f, 7.29462970e-03f, 1.19030751e-01f, 3.25217173e-02f, -2.92257071e-02f, 7.30948299e-02f, 4.54594418e-02f,
  1.26821920e-01f, 3.32459249e-02f, -8.15419555e-02f, -6.26026616e-02f, -9.25415605e-02f, 3.62795852e-02f, -4.86432090e-02f, 4.59206328e-02f, -3.59912552e-02f, -1.50891647e-01f,
  5.27058952e-02f, -5.44029064e-02f, -1.12576187e-01f, 6.72875717e-02f, 1.50350854e-02f, -6.31561056e-02f, -1.39812842e-01f, -1.33686550e-02f, 1.34101450e-01f, 6.31837696e-02f,
  -1.11401312e-01f, 5.35779558e-02f, -3.86003852e-02f, 6.14537820e-02f, -3.50134410e-02f, -1.70626994e-02f, 1.07748225e-01f, -1.07177764e-01f, -5.73469549e-02f, 1.81835257e-02f,
  -2.90270269e-01f, -1.67091668e-01f, -1.63414124e-02f, -5.07991016e-02f, -6.95461705e-02f, -1.13597833e-01f, -6.51786774e-02f, 5.03149107e-02f, -1.47085935e-01f, 4.96188924e-02f,
  1.63160190e-02f, 1.19091243e-01f, -3.79167125e-02f, 9.13250521e-02f, -1.06558306e-02f, 2.04462279e-02f, -5.24382386e-03f, -1.46209538e-01f, -5.76066263e-02f, 1.05933789e-02f,
  5.69784380e-02f, 1.48425112e-02f, -4.70746271e-02f, 1.12502150e-01f, 1.19980954e-01f, 4.89815809e-02f, -3.73209342e-02f, 2.54314411e-02f, 2.67854296e-02f, -5.34371845e-02f,
  2.89236903e-01f, -2.01413110e-02f, 2.21103460e-01f, 2.53196597e-01f, 1.86045587e-01f, 2.19735339e-01f, 2.71858335e-01f, 2.92931974e-01f, 5.96707940e-01f, -2.46172532e-01f,
  -3.70464176e-01f, -1.71423733e-01f, -1.78799108e-01f, -2.31908962e-01f, 2.20824480e-01f, 9.82673243e-02f, 1.38947353e-01f, -1.03253886e-01f, 2.69987613e-01f, -1.26089901e-01f,
  -8.04349855e-02f, -4.97351229e-01f, -3.54092270e-01f, -3.18415433e-01f, -2.37346292e-01f, 6.45799413e-02f, -5.33016026e-01f, 2.58801989e-02f, -4.48674232e-01f, -5.52406833e-02f,
  -2.78043225e-02f, 1.42316043e-01f, 5.78726933e-04f, -8.31667159e-04f, 1.37109309e-01f, -5.52860759e-02f, -1.87348858e-01f, -6.93898601e-03f, 2.39142865e-01f, 3.48003283e-02f,
  -1.16866186e-01f, -7.52199888e-02f, 1.07139625e-01f, -6.22274987e-02f, 5.71244061e-02f, -3.87343913e-02f, -5.98419383e-02f, -4.92617674e-03f, -8.22031498e-02f, -1.15742967e-01f,
  -5.54144494e-02f, 3.81915495e-02f, 7.58512914e-02f, 7.91352391e-02f, 1.19565308e-01f, 7.04845041e-02f, 8.43684152e-02f, -8.70068893e-02f, 3.89284529e-02f, 1.33344576e-01f,
  -1.18563734e-01f, 1.51467353e-01f, 1.15851685e-02f, 2.74443142e-02f, 2.18630284e-02f, -5.20330481e-03f, -2.48282254e-02f, -5.83572946e-02f, 1.37586236e-01f, -1.59266829e-01f,
  4.18599397e-02f, 3.65145802e-02f, 3.07511315e-02f, -2.56045125e-02f, -3.49321030e-02f, 9.48138684e-02f, -5.91563806e-02f, 5.46718277e-02f, 2.84529570e-02f, -7.88773298e-02f,
  -2.77911616e-03f, 2.93286499e-02f, -4.94272485e-02f, -9.79484618e-02f, -3.34108584e-02f, 6.46421462e-02f, -1.24876857e-01f, -7.25727305e-02f, -2.24424899e-03f, -1.63992003e-01f,
  5.55214286e-02f, 1.39956623e-01f, -7.16905249e-03f, -9.46976915e-02f, 3.23952511e-02f, -9.83642936e-02f, 3.42988176e-03f, -1.24912625e-02f, 1.42259210e-01f, -3.74838822e-02f,
  -1.13307156e-01f, -1.93353407e-02f, 9.13248211e-03f, -2.29409281e-02f, -4.74799201e-02f, -5.81997745e-02f, -1.43051818e-01f, 1.62134487e-02f, 7.37776384e-02f, -1.63340524e-01f,
  -2.08632424e-01f, 9.19674858e-02f, 3.72700766e-02f, 5.30049540e-02f, -2.79245134e-02f, -2.64462475e-02f, 1.48429543e-01f, -6.95187896e-02f, -5.08344024e-02f, 9.09126848e-02f,
  4.42545712e-01f, -1.25613168e-01f, -6.87219575e-02f, 3.37869763e-01f, 2.15700448e-01f, 1.09410658e-01f, -7.32040703e-02f, 3.69556427e-01f, 3.21507573e-01f, -2.03330755e-01f,
  1.65333062e-01f, -8.74398351e-02f, -2.65493780e-01f, 2.98675239e-01f, 2.79438227e-01f, -1.83258474e-01f, 3.97125989e-01f, 1.58877984e-01f, 1.38964102e-01f, 2.50741392e-01f,
  3.14105183e-01f, 3.01120996e-01f, -6.89288881e-03f, 1.31914601e-01f, 1.78109318e-01f, 6.59549609e-02f, -3.41361687e-02f, -3.41837972e-01f, 1.35403290e-01f, 4.93068099e-02f,
  2.21809950e-02f, 1.01539448e-01f, -2.95990556e-02f, -1.49414286e-01f, 2.85205357e-02f, -1.24275066e-01f, -1.77783556e-02f, -2.43197769e-01f, -1.34137496e-01f, -4.69487421e-02f,
  -9.59628224e-02f, 1.69627443e-02f, 1.23423778e-01f, 2.41834368e-03f, 1.09038381e-02f, 3.42699140e-02f, 3.18933614e-02f, 1.94161609e-02f, 1.79253574e-02f, -4.30377107e-03f,
  -3.57868932e-02f, -9.56223011e-02f, 3.27654034e-02f, -4.24537510e-02f, -1.01599526e-02f, 1.04884408e-01f, 1.04860244e-02f, -1.23673409e-01f, -1.80407509e-01f, 4.66044657e-02f,
  1.06225438e-01f, -1.01700202e-01f, -9.62233394e-02f, -1.46170437e-01f, -4.47766595e-02f, 1.99506525e-02f, 1.01161867e-01f, -5.24518490e-02f, -3.58056906e-03f, 9.62456502e-03f,
  -2.97417603e-02f, 1.04305148e-01f, 6.31423220e-02f, -4.24771160e-02f, 9.37386751e-02f, 1.47692987e-03f, -6.74614832e-02f, 1.69801041e-01f, 9.30886418e-02f, 6.67539388e-02f,
  -4.57540341e-02f, 5.21233417e-02f, -1.26647919e-01f, 5.95678948e-02f, 2.61195488e-02f, -7.19338581e-02f, 1.28655091e-01f, 7.71640167e-02f, -7.88114667e-02f, 4.71423902e-02f,
  8.91872961e-03f, 2.10590199e-01f, -3.28460298e-02f, -9.24021825e-02f, -9.23024863e-02f, 4.44415435e-02f, 5.29992813e-03f, 1.60029441e-01f, -1.29755978e-02f, 7.10711181e-02f,
  1.05006933e-01f, -1.05769612e-01f, -7.60707632e-02f, 8.13525617e-02f, 4.07292396e-02f, 7.30032027e-02f, 1.46704474e-02f, -1.69098619e-02f, 1.12859562e-01f, 1.72920823e-01f,
  -4.39130142e-02f, -6.32936284e-02f, -8.70067105e-02f, 3.65703329e-02f, 5.73083349e-02f, -1.40737575e-02f, 5.89905865e-02f, -3.79040241e-02f, 2.39525624e-02f, 2.89919656e-02f,
  2.75600076e-01f, -4.31810617e-01f, -4.71915424e-01f, -2.00205043e-01f, -8.75849128e-02f, 9.53919888e-02f, 7.37024397e-02f, -1.79348990e-01f, -1.26091510e-01f, 9.89845395e-02f,
  3.48457962e-01f, 5.39977178e-02f, 2.80683905e-01f, 2.26856455e-01f, 3.66020828e-01f, 4.77614969e-01f, 1.72804967e-01f, 2.49218732e-01f, 9.85478386e-02f, -1.67440608e-01f,
  1.44882342e-02f, 2.08423153e-01f, 1.31810069e-01f, -3.05955082e-01f, -4.32363562e-02f, -2.95132548e-01f, 1.26181141e-01f, -4.88046668e-02f, 5.43747284e-02f, 1.15614466e-01f,
  1.97369069e-01f, -6.33491650e-02f, -1.24941520e-01f, 5.03811389e-02f, -9.56140310e-02f, 2.10359357e-02f, 8.64701793e-02f, -8.83483607e-03f, 6.95767850e-02f, 9.23192315e-03f,
  5.40297031e-02f, -3.60533595e-02f, -1.62918180e-01f, 3.01625263e-02f, -5.24303541e-02f, -1.03021443e-01f, -3.12249381e-02f, 1.51438847e-01f, -1.12557620e-01f, 3.74400020e-02f,
  5.76665904e-03f, -2.18020026e-02f, 7.33433887e-02f, -2.58385707e-02f, -1.26916885e-01f, -1.21399350e-01f, -2.21097544e-02f, 1.68858469e-02f, -2.11588144e-02f, -1.07670911e-01f,
  -8.77315402e-02f, 1.92015454e-01f, 5.25004342e-02f, 8.87846202e-02f, -4.15012911e-02f, -6.46742806e-02f, 1.78400770e-01f, 1.19472280e-01f, -9.70829427e-02f, 5.79375727e-03f,
  4.42391895e-02f, -1.13146536e-01f, 9.52666178e-02f, 1.41622499e-01f, 1.70470476e-02f, -3.12137306e-02f, 3.76907140e-02f, -8.67615547e-03f, -7.47342557e-02f, 3.84624787e-02f,
  1.12379260e-01f, -2.97096912e-02f, -2.81442292e-02f, -2.08953563e-02f, 1.72003821e-01f, -3.70932333e-02f, 8.08440149e-02f, 1.11328680e-02f, 7.28917792e-02f, 3.17904390e-02f,
  -8.86898190e-02f, -2.77955443e-01f, -4.33455594e-02f, 7.13817123e-03f, 1.27621423e-02f, -5.22018932e-02f, 1.12361442e-02f, -1.64524689e-01f, -2.44120751e-02f, -1.39128761e-02f,
  -7.66158476e-02f, -1.26284674e-01f, 1.32409986e-02f, 8.08881596e-02f, -1.37596458e-01f, -4.69229072e-02f, 7.33849257e-02f, 4.74149473e-02f, -1.05796553e-01f, -9.19975564e-02f,
  -9.92816612e-02f, -6.83048368e-02f, 6.98288828e-02f, -1.52224854e-01f, -1.89044788e-01f, 1.77842863e-02f, -2.27216274e-01f, -3.34641486e-02f, -5.30203357e-02f, -4.63310704e-02f,
  3.59572500e-01f, -1.87280208e-01f, -1.49652839e-01f, -6.92624366e-03f, 2.60413796e-01f, 3.81368667e-01f, 2.33172968e-01f, -2.09512830e-01f, -3.29973727e-01f, 2.10435339e-03f,
  2.23002005e-02f, 1.51043400e-01f, -1.84640720e-01f, -9.30819809e-02f, 5.08778319e-02f, -2.35711709e-01f, 6.10302836e-02f, 1.77197069e-01f, -2.77766287e-01f, 1.56069070e-01f,
  -3.66626047e-02f, -1.36628384e-02f, -3.45669240e-01f, -4.52991724e-02f, 3.00056607e-01f, 1.24594651e-01f, 1.58321485e-01f, 1.50349528e-01f, 2.01004103e-01f, 4.75556217e-02f,
  -1.09043136e-01f, -1.76078215e-01f, -1.25641637e-02f, -3.30527946e-02f, 6.72010481e-02f, 8.45829695e-02f, 1.61004961e-01f, 7.68289901e-03f, 3.19252238e-02f, -1.27230391e-01f,
  9.79404002e-02f, 4.37053442e-02f, -1.46100864e-01f, -6.77672541e-03f, -4.46248129e-02f, 1.04821354e-01f, 2.71441787e-02f, 2.32564490e-02f, -7.22414069e-03f, -5.40057849e-03f,
  -7.15991408e-02f, -1.24076806e-01f, -1.65122852e-03f, 1.31610751e-01f, 7.77164027e-02f, 3.36270221e-02f, -1.99254081e-02f, 2.40738168e-01f, 2.90386993e-02f, 6.08331263e-02f,
  -4.55477983e-02f, 1.60627186e-01f, 1.28193259e-01f, -4.25960943e-02f, 1.49083668e-02f, -5.93336336e-02f, 9.35616270e-02f, 7.61216786e-03f, 1.80761497e-02f, 1.00378044e-01f,
  1.01435773e-01f, 6.76779523e-02f, -2.05049306e-01f, 9.31700617e-02f, 7.47637171e-03f, -1.42513305e-01f, 3.21282782e-02f, 1.48661003e-01f, 3.63752730e-02f, -2.23126095e-02f,
  -6.19391762e-02f, -1.69516802e-02f, 3.25216390e-02f, -3.47535051e-02f, -8.33386555e-02f, -1.56841066e-03f, -6.19132631e-02f, -9.32902377e-03f, -1.92949370e-01f, 7.89859667e-02f,
  -8.17503128e-03f, -7.25837275e-02f, -1.65546641e-01f, 3.84852514e-02f, -3.02070975e-02f, 6.84475675e-02f, 7.15881167e-03f, 4.67483364e-02f, 3.53315957e-02f, -8.04049894e-02f,
  1.85808688e-01f, 4.26089168e-02f, -2.66047847e-02f, 9.74672139e-02f, -8.39048997e-02f, 1.08680893e-02f, 1.38700947e-01f, 2.30338171e-01f, -2.92329080e-02f, 7.57406885e-03f,
  1.71430334e-01f, 1.49702266e-01f, 8.03277791e-02f, 9.39890370e-02f, 6.95487559e-02f, 4.87297550e-02f, -6.31267205e-02f, 7.60212764e-02f, -7.04868650e-03f, -3.76891606e-02f,
  1.45505354e-01f, 3.06054711e-01f, -2.94241637e-01f, -6.84560984e-02f, -8.94354880e-02f, 3.99081379e-01f, 3.07702661e-01f, 4.60565239e-02f, 6.75327629e-02f, 4.13124561e-01f,
  8.33272189e-03f, 1.75896555e-01f, 8.99377093e-02f, 2.72974432e-01f, 1.04868591e-01f, 2.55776644e-01f, 3.78132939e-01f, 2.53642589e-01f, 2.63311844e-02f, 5.04596606e-02f,
  1.92730892e-02f, 4.89150316e-01f, -2.68527418e-01f, 1.29216954e-01f, 1.76973566e-02f, -2.16362879e-01f, -1.51733086e-01f, -9.08192396e-02f, -7.53900735e-03f, 1.44435629e-01f,
  3.28262895e-02f, 6.31803870e-02f, -8.20521191e-02f, 5.75759932e-02f, -5.87014481e-03f, -6.50229752e-02f, 8.01990777e-02f, 2.07446283e-03f, -1.63405240e-01f, -1.23956567e-03f,
  1.56166777e-01f, 4.61502634e-02f, 1.04747951e-01f, -1.13282472e-01f, -4.13111113e-02f, -8.47310275e-02f, -1.25812247e-01f, -1.59763172e-01f, 3.70590799e-02f, -6.61118468e-03f,
  -8.02984685e-02f, -6.03306703e-02f, -1.02896273e-01f, 1.12731785e-01f, -6.97675422e-02f, 7.28534013e-02f, 5.27370945e-02f, -6.45424500e-02f, 9.82048437e-02f, 9.68118161e-02f,
  3.16282138e-02f, 1.51179269e-01f, 8.45180079e-02f, -2.44878381e-02f, 3.86557542e-02f, -1.55826965e-02f, 2.28449460e-02f, 3.60653340e-03f, -1.13960207e-01f, 4.31660153e-02f,
  -9.90156457e-02f, -5.99733517e-02f, -3.29268239e-02f, 5.01923151e-02f, 8.52815062e-02f, 2.50175055e-02f, -2.51346417e-02f, 6.42914921e-02f, -9.27998945e-02f, -9.27166194e-02f,
  -4.78948615e-02f, 5.34150191e-02f, -1.95858185e-03f, -1.28215253e-01f, 7.96048641e-02f, -1.48853630e-01f, 7.82354325e-02f, -8.76887962e-02f, -1.41453937e-01f, -4.17820401e-02f,
  1.05272226e-01f, 2.78302401e-01f, -7.66655430e-02f, 4.35363166e-02f, 3.98578569e-02f, 1.43957073e-02f, 3.53501104e-02f, 6.91497102e-02f, 1.09301493e-01f, 1.21111371e-01f,
  9.42405537e-02f, 6.12368807e-02f, -1.41319439e-01f, -8.74123499e-02f, -6.99617267e-02f, 9.06184018e-02f, 1.04985759e-01f, 5.65055571e-02f, -9.75653604e-02f, -3.92522700e-02f,
  -2.11226102e-03f, 9.67832655e-02f, 9.55317467e-02f, 1.19321048e-01f, 8.67333040e-02f, 5.19752689e-02f, -7.77640715e-02f, -1.43354265e-02f, -5.67689864e-03f, 4.28319396e-03f,
  -1.58997759e-01f, -4.39576432e-02f, 1.12841263e-01f, 2.80386955e-01f, -5.50913215e-01f, 4.69285585e-02f, 4.74325538e-01f, -1.96713060e-01f, 1.06209427e-01f, 1.22225769e-01f,
  -1.38803646e-02f, 9.61999297e-02f, 2.09696233e-01f, 2.88102210e-01f, 2.55821437e-01f, 2.89210051e-01f, 2.65443712e-01f, 1.82914093e-01f, -1.61794737e-01f, 8.03346559e-02f,
  8.62196088e-02f, 6.10928647e-02f, 2.25156128e-01f, -2.26295605e-01f, -1.24287896e-01f, -2.34126523e-01f, 7.18737915e-02f, -6.73158765e-02f, -6.05185814e-02f, -4.73442823e-02f,
  -2.11013928e-01f, 4.47653409e-04f, -8.00721627e-03f, 9.27258283e-03f, -9.18334201e-02f, -2.58776732e-02f, 8.77749547e-02f, 1.82100207e-01f, 4.96404059e-02f, -1.31974310e-01f,
  -4.94039953e-02f, -1.33291423e-01f, -1.67576835e-01f, 5.10472171e-02f, -1.69959202e-01f, -1.09835245e-01f, -1.44635856e-01f, 1.25529319e-02f, 3.27741466e-02f, -3.22733149e-02f,
  -2.36229170e-02f, -1.06371723e-01f, 4.41430025e-02f, 3.18548419e-02f, 1.72243151e-03f, -2.33924109e-02f, 1.20893024e-01f, 4.29237336e-02f, -7.80980140e-02f, -1.72197640e-01f,
  7.42258951e-02f, 1.11720510e-01f, 2.70333998e-02f, 2.21109279e-02f, -4.22552563e-02f, -6.43538609e-02f, -2.67252000e-03f, -1.18591212e-01f, 6.69971481e-02f, -2.25793365e-02f,
  -1.51110888e-01f, -2.65875384e-02f, -2.67587155e-02f, -4.93554696e-02f, 1.97892021e-02f, 1.43012837e-01f, 1.79977231e-02f, -1.35426804e-01f, -2.06930321e-02f, 2.17794767e-03f,
  1.42329231e-01f, -6.89812303e-02f, -1.00834623e-01f, 6.01711161e-02f, 1.98047403e-02f, 1.97482742e-02f, -1.30340485e-02f, -6.26764819e-02f, 6.53458759e-02f, 1.17746316e-01f,
  -2.94827446e-02f, 8.71261656e-02f, -1.54484380e-02f, -1.86003432e-01f, 7.25191832e-03f, -1.57697067e-01f, 1.17760524e-01f, -2.24466575e-03f, 3.53720151e-02f, 1.02898730e-02f,
  -3.64479539e-03f, 3.21264798e-03f, -2.01933369e-01f, 1.66115649e-02f, 3.31150033e-02f, 7.51941130e-02f, 1.24825485e-01f, -6.28543571e-02f, 4.66937907e-02f, -4.02434282e-02f,
  7.63226897e-02f, -4.27081920e-02f, 4.74587455e-02f, -4.11639251e-02f, 1.55941360e-02f, 5.34254964e-03f, -7.78297782e-02f, -6.70954399e-03f, -1.56399891e-01f, 8.34137350e-02f,
  -2.85241365e-01f, -6.07247293e-01f, -2.85238743e-01f, 2.50124872e-01f, 2.45884165e-01f, 3.06934446e-01f, -7.06252903e-02f, -7.42894858e-02f, -1.05274513e-01f, -1.10422894e-02f,
  2.11745352e-01f, -3.79397601e-01f, -2.25186765e-01f, -1.39663905e-01f, -1.29717886e-01f, -4.43575174e-01f, 2.37142324e-01f, 5.80513403e-02f, -1.73155963e-01f, -8.57662186e-02f,
  -1.03138804e-01f, 1.37040362e-01f, -1.24921858e-01f, 1.98588386e-01f, 1.58538096e-04f, 3.14807482e-02f, 2.74889469e-01f, -7.05555677e-02f, 2.89429069e-01f, -6.66026212e-03f,
  1.29755571e-01f, -2.54081160e-01f, -1.52891979e-01f, 4.31622788e-02f, 3.71286310e-02f, 1.63224265e-01f, 2.21492350e-01f, -1.14644483e-01f, -2.50730608e-02f, -5.47855198e-02f,
  8.60973224e-02f, -6.80580735e-02f, -7.51209557e-02f, -7.20209256e-02f, 8.66256654e-02f, -1.95691772e-02f, -1.00111455e-01f, 1.51706293e-01f, -7.41641596e-02f, -3.00064623e-01f,
  -1.11506410e-01f, 5.98869547e-02f, 2.34034643e-01f, 1.89501885e-02f, -5.40486388e-02f, 1.91657338e-02f, -4.37949859e-02f, -1.17448971e-01f, 9.09808800e-02f, -1.10038057e-01f,
  -2.85405815e-02f, -6.38713241e-02f, -5.65914474e-02f, 1.46496430e-01f, -1.05152398e-01f, 5.43433577e-02f, 7.33042434e-02f, -2.39890311e-02f, -1.41170353e-01f, -7.02715218e-02f,
  8.44298750e-02f, -2.10311487e-01f, 1.03461472e-02f, 5.68791702e-02f, -5.87012991e-03f, 5.28770871e-03f, 5.48780300e-02f, 2.61007324e-02f, 1.63108602e-01f, -2.37407051e-02f,
  7.14233220e-02f, 5.50123453e-02f, -4.17665727e-02f, 5.14114648e-02f, 6.40659556e-02f, -1.10096104e-01f, 1.91784911e-02f, 6.63775280e-02f, 1.16632119e-01f, 1.89846724e-01f,
  1.19253211e-01f, -1.92127332e-01f, -6.77504539e-02f, 5.02550974e-02f, -5.07431291e-02f, 9.24051180e-02f, -1.54302446e-02f, -6.39285296e-02f, 5.19450940e-02f, -1.01442859e-02f,
  1.90400571e-01f, 4.36045043e-02f, 3.34341735e-01f, 3.65313813e-02f, 9.07255188e-02f, -5.67353591e-02f, 1.58685148e-01f, 7.41339847e-02f, 2.07705617e-01f, 8.19889456e-02f,
  2.23533124e-01f, 6.72418326e-02f, 1.32435918e-01f, 1.17515527e-01f, 1.65740699e-01f, 3.48241180e-02f, 2.49536354e-02f, 5.35932428e-04f, 1.29005194e-01f, -1.67299248e-02f,
  -6.65520728e-02f, -4.60068695e-02f, 1.65140241e-01f, 3.42877269e-01f, 2.45773122e-02f, -3.14356178e-01f, -2.18703449e-01f, -1.13980554e-01f, 5.56828342e-02f, -4.30910915e-01f,
  -1.24811232e-01f, -1.36944413e-01f, -4.36730415e-01f, 2.49468967e-01f, 2.45286122e-01f, -6.48906380e-02f, 3.16659838e-01f, -9.00609978e-03f, 1.58629999e-01f, -6.30596280e-02f,
  1.49184838e-01f, 1.68308005e-01f, 2.66022474e-01f, 1.74037427e-01f, 1.36838153e-01f, 3.24789733e-01f, 1.61140442e-01f, 1.03641465e-01f, 2.41050437e-01f, 2.35029861e-01f,
  5.13704531e-02f, 2.08870679e-01f, 1.00295492e-01f, 1.44946441e-01f, -1.57370344e-02f, -8.64993855e-02f, -9.83655304e-02f, 6.29274547e-02f, 1.29266400e-02f, 9.43622924e-03f,
  -6.40422851e-02f, 1.58219695e-01f, 2.13393748e-01f, -2.76314579e-02f, -1.79949664e-02f, 1.87444627e-01f, 1.06505863e-01f, -1.35447219e-01f, -3.85206975e-02f, -3.91959734e-02f,
  -3.21472995e-02f, 6.21008910e-02f, -1.32337222e-02f, 1.68950707e-01f, 3.24630171e-01f, 2.62685359e-01f, 3.09930556e-02f, 1.57193523e-02f, 1.28063783e-01f, 1.43079787e-01f,
  -8.03901814e-04f, -1.12658434e-01f, 2.26771384e-02f, -1.03800952e-01f, -4.71300213e-03f, 9.86592695e-02f, -2.72944774e-02f, -1.30334198e-01f, 8.88639614e-02f, -9.12931710e-02f,
  9.04483125e-02f, 1.14203073e-01f, 1.60545632e-02f, -5.27282469e-02f, 5.74964918e-02f, 2.04309057e-02f, -3.36626098e-02f, 4.13516276e-02f, -1.03954668e-03f, -2.82556303e-02f,
  1.61451194e-02f, 2.57725809e-02f, -2.43446697e-03f, -7.42166638e-02f, 1.35731222e-02f, 6.28616288e-02f, 3.73498350e-02f, -4.64376993e-02f, -1.46124229e-01f, -6.58703223e-02f,
  1.88656926e-01f, 4.21937704e-01f, 2.70636436e-02f, 1.03084065e-01f, 5.64024933e-02f, -7.53492042e-02f, 3.19969095e-02f, 4.19671759e-02f, 2.92959839e-01f, -5.41853793e-02f,
  -1.10592516e-02f, 2.51999050e-02f, -6.49086982e-02f, -2.68282052e-02f, 1.00279830e-01f, -6.68883175e-02f, 2.60698199e-02f, 9.45523307e-02f, 2.43839994e-01f, 7.47313425e-02f,
  -6.42792806e-02f, -1.37977898e-01f, 1.03185356e-01f, 1.03201404e-01f, 1.13425829e-01f, 7.72173852e-02f, -1.12595521e-01f, 7.93465301e-02f, 1.72143593e-01f, 1.39827132e-01f,
  -2.69692183e-01f, 3.42997700e-01f, -2.75450855e-01f, 2.36204505e-01f, 9.17860400e-03f, 4.53181058e-01f, 1.57778785e-01f, 2.07152199e-02f, -4.26091328e-02f, 4.61104602e-01f,
  -1.79901589e-02f, 3.64862196e-02f, -2.15126902e-01f, 4.80221927e-01f, 2.64917493e-01f, 9.07527730e-02f, 5.12217343e-01f, 2.10876837e-01f, -2.86703114e-03f, 1.18048288e-01f,
  -1.51289878e-02f, 4.83508378e-01f, -7.15711638e-02f, 1.71934843e-01f, 1.19028538e-01f, -2.02801421e-01f, 1.75966620e-01f, -2.50765711e-01f, 4.25807059e-01f, 1.87453210e-01f,
  -4.69959714e-02f, -5.12034185e-02f, -7.28362352e-02f, -9.81727168e-02f, 7.89342821e-02f, 4.19441387e-02f, 1.00867622e-01f, -8.35244060e-02f, -1.62287861e-01f, 3.93942110e-02f,
  4.49041603e-03f, 2.31629256e-02f, 5.04948199e-02f, -3.61232199e-02f, -1.12973243e-01f, -9.99331847e-02f, -5.68013005e-02f, -9.29964930e-02f, 3.50307785e-02f, -5.82973920e-02f,
  -1.66196957e-01f, -6.65770471e-02f, -6.62484253e-03f, 5.32176830e-02f, -1.37068436e-01f, 5.91192953e-03f, 1.88229695e-01f, -1.19596608e-01f, 1.08757854e-01f, 2.96223938e-01f,
  -5.40603362e-02f, 1.57809645e-01f, -4.06917408e-02f, -8.19974914e-02f, 6.07390665e-02f, 2.28409972e-02f, 1.26902223e-01f, 9.24419165e-02f, -7.30515346e-02f, 1.54935315e-01f,
  1.34851739e-01f, -4.64176424e-02f, 2.73525510e-02f, 4.92349230e-02f, 6.70875758e-02f, 3.51819545e-02f, -2.39365473e-01f, 9.21766907e-02f, -8.34292397e-02f, -8.08841288e-02f,
  -2.67825965e-02f, 1.57488450e-01f, -4.21590768e-02f, -4.32047956e-02f, 8.36731270e-02f, -1.51609346e-01f, 1.88233227e-01f, 7.15594068e-02f, -1.26507342e-01f, -2.47985665e-02f,
  3.25494766e-01f, 5.04293025e-01f, -2.33939346e-02f, -2.47161686e-02f, 6.57935813e-02f, 3.63373086e-02f, 9.23485383e-02f, 1.35843977e-02f, 1.12165272e-01f, 1.20464824e-01f,
  1.07468804e-02f, -1.69836637e-02f, -9.27817356e-03f, -7.57110864e-02f, 3.45660336e-02f, 1.29044488e-01f, 1.19151413e-01f, 3.67200114e-02f, 1.61615506e-01f, 6.58044219e-02f,
  -2.68478431e-02f, -2.61418298e-02f, 4.82798330e-02f, -4.21836972e-03f, 1.86790705e-01f, -3.71461175e-02f, 3.86790708e-02f, 3.64688295e-03f, -8.24607536e-03f, 1.57410800e-01f,
  -5.52049339e-01f, 3.68329912e-01f, -1.81290597e-01f, 7.30611756e-03f, 9.94717553e-02f, 4.20733571e-01f, 2.16076255e-01f, -1.77787527e-01f, -3.83637249e-01f, 2.48107806e-01f,
  3.82877380e-01f, -3.13086420e-01f, 1.81307763e-01f, 3.55399549e-01f, -4.04974222e-02f, 3.36640596e-01f, 3.36312324e-01f, 1.71051830e-01f, -4.89779077e-02f, -1.59948334e-01f,
  -1.61407456e-01f, 3.91620934e-01f, 1.56579778e-01f, 1.11111984e-01f, 8.32941383e-02f, -2.80482441e-01f, 1.07538655e-01f, -2.48155355e-01f, 3.05453509e-01f, 3.56854498e-02f,
  3.64009812e-02f, -1.96184725e-01f, -2.84285903e-01f, -2.02881500e-01f, 1.31238112e-02f, -1.67363822e-01f, -2.50219345e-01f, -4.17818911e-02f, -1.35052472e-01f, 4.34633866e-02f,
  -1.27813414e-01f, -9.17598456e-02f, 5.70938922e-02f, -2.38122419e-01f, -3.42433564e-02f, 1.52125359e-02f, 2.69725546e-02f, 1.24527924e-02f, -6.62897378e-02f, 8.04778039e-02f,
  -3.13224122e-02f, 2.02499658e-01f, 6.24378249e-02f, 1.76950380e-01f, 1.18107945e-01f, 8.91018063e-02f, 1.68823209e-02f, -4.01657820e-03f, 2.16586679e-01f, 4.18915972e-02f,
  5.24713509e-02f, -8.11980441e-02f, -9.70632359e-02f, -1.20439045e-01f, 6.57808557e-02f, 5.33935241e-02f, -1.05851330e-03f, 1.78033002e-02f, -8.56126770e-02f, 1.06615074e-01f,
  -1.77721195e-02f, -1.11369519e-02f, -2.54825294e-01f, -1.80207267e-02f, -2.30776332e-02f, -7.56166801e-02f, -7.55915046e-02f, -7.38220289e-02f, 9.02477466e-03f, 1.03051506e-01f,
  -1.48039564e-01f, 3.20057757e-02f, 1.48657724e-01f, 3.98196317e-02f, -1.25897406e-02f, 2.82260794e-02f, -1.29386678e-01f, 5.64497299e-02f, -3.73420976e-02f, -9.65349600e-02f,
  1.39881432e-01f, -1.62812665e-01f, -1.26345009e-01f, -3.61609608e-02f, -7.24882167e-03f, 2.48016044e-02f, -2.11605489e-01f, 4.75875810e-02f, -2.06016488e-02f, 3.71151743e-03f,
  -5.38048595e-02f, 1.06394012e-02f, 3.72120664e-02f, -1.08001446e-02f, 2.84986254e-02f, 9.48988646e-02f, -8.83141682e-02f, -1.77102819e-01f, -1.51158897e-02f, 5.54405749e-02f,
  -3.88993397e-02f, 9.18807636e-04f, -4.68546618e-03f, 2.12907329e-01f, 1.28378734e-01f, 4.90698814e-02f, 8.86800140e-03f, 1.17043220e-02f, 1.75558105e-01f, 1.24869086e-01f,
  5.19681156e-01f, 1.96148694e-01f, 3.52579355e-01f, 3.46012384e-01f, -5.89568242e-02f, -3.15876335e-01f, -2.73450315e-02f, 1.72335163e-01f, 3.83131713e-01f, -1.29442781e-01f,
  -1.36724725e-01f, 1.55477241e-01f, -2.55053639e-01f, 1.96475416e-01f, -2.07466215e-01f, -3.48488539e-01f, 3.15821350e-01f, -4.99846740e-03f, 4.89940383e-02f, 2.59597510e-01f,
  2.05986336e-01f, -1.99238017e-01f, 7.94476941e-02f, -1.75549805e-01f, 3.45892042e-01f, 3.13407063e-01f, -4.78640571e-02f, -1.28591359e-01f, 1.27359673e-01f, -2.28957206e-01f,
  -1.90451294e-02f, 9.77513045e-02f, 1.26228809e-01f, -8.46875831e-02f, 1.58772275e-01f, -1.84766911e-02f, 2.19248794e-02f, -1.04931958e-01f, -2.75663771e-02f, -4.19699289e-02f,
  2.69827191e-02f, -8.57125074e-02f, 5.11344569e-03f, -3.01163225e-03f, 1.24104023e-01f, 4.70191538e-02f, 2.05935463e-01f, 8.51667821e-02f, 6.36641532e-02f, 1.48735881e-01f,
  1.54620126e-01f, 1.98488068e-02f, 1.90375954e-01f, 1.99994259e-02f, 1.09459311e-01f, 4.73734364e-02f, -6.16532527e-02f, 2.86947917e-02f, 5.18016033e-02f, -6.06373046e-03f,
  -7.93636963e-02f, -8.09985772e-02f, -6.30718470e-02f, -2.57073008e-02f, -2.42974684e-02f, 7.91948941e-03f, 5.62191270e-02f, -6.39382079e-02f, 9.21463147e-02f, 6.89398795e-02f,
  4.05238606e-02f, 7.19039589e-02f, 2.70237438e-02f, 1.74660403e-02f, 1.75619032e-02f, 7.12220818e-02f, -9.74501669e-02f, -5.63575178e-02f, 2.14500397e-01f, 3.21130678e-02f,
  -1.74267918e-01f, -1.02278672e-01f, 1.00853173e-02f, 3.47838327e-02f, -7.34907687e-02f, -8.13601166e-03f, -4.05774172e-03f, -2.51083765e-02f, -6.92667291e-02f, 1.32272929e-01f,
  8.27072710e-02f, 9.26401094e-02f, -5.00687025e-02f, -1.41367093e-02f, -5.94723374e-02f, -6.79246411e-02f, 1.56483836e-02f, 1.81938931e-01f, 1.28226504e-01f, -1.12703562e-01f,
  2.80005150e-02f, 8.68399590e-02f, -7.87715241e-02f, 1.81624759e-02f, 5.73407598e-02f, 1.38148203e-01f, -4.01432440e-02f, -3.34882252e-02f, 9.09070820e-02f, 1.00177884e-01f,
  2.86434051e-02f, -9.42526907e-02f, 1.13481112e-01f, 1.24481536e-01f, 6.82744756e-02f, 4.14970750e-03f, -4.82876562e-02f, 7.72193372e-02f, 7.49446079e-02f, -6.08223267e-02f,
  6.83485046e-02f, 6.96002394e-02f, 2.69009352e-01f, 3.27965140e-01f, 3.52677166e-01f, 1.84657648e-01f, 4.54354063e-02f, 2.78705597e-01f, 3.34082872e-01f, -1.55527815e-01f,
  -1.13561958e-01f, -1.48658589e-01f, -1.10899940e-01f, 2.47297473e-02f, -1.11245578e-02f, 2.15279106e-02f, 8.25304314e-02f, -1.91831216e-01f, 2.41168648e-01f, 1.37585729e-01f,
  2.05051064e-01f, -1.19638473e-01f, 1.96026191e-01f, -2.41484195e-02f, 1.64310411e-01f, 9.42459628e-02f, -2.40863219e-01f, -1.28422510e-02f, -1.85680628e-01f, -4.26982306e-02f,
  4.04908322e-02f, 1.27861798e-01f, -2.31855698e-02f, 2.66555883e-02f, -1.96552891e-02f, -9.02065635e-02f, -1.04423426e-01f, -5.25173917e-02f, 7.85941184e-02f, 9.30588320e-02f,
  -5.98467551e-02f, 5.09398691e-02f, -1.50031537e-01f, 3.28108072e-02f, 3.11005618e-02f, 8.11311454e-02f, 1.85963720e-01f, 1.88678578e-01f, 6.94769248e-02f, 9.17192549e-02f,
  1.09931372e-01f, 7.80936778e-02f, 1.33846596e-01f, -9.97377113e-02f, 1.43859714e-01f, 1.41110912e-01f, -1.55514739e-02f, -1.27113700e-01f, -9.83410794e-03f, 2.83782966e-02f,
  -4.52756025e-02f, -4.65184152e-02f, 1.56556636e-01f, 5.85267656e-02f, -5.43062463e-02f, 1.15728723e-02f, -5.26649766e-02f, -1.22904301e-01f, -4.98044305e-02f, -3.63242067e-02f,
  2.16224939e-02f, 1.51940240e-02f, 1.10629849e-01f, 6.42773882e-02f, 1.79667808e-02f, 4.19851840e-02f, 2.96138451e-02f, -2.29048301e-02f, -1.22917378e-02f, -2.47916467e-02f,
  7.36815780e-02f, 2.00817063e-02f, 1.92520791e-03f, 1.29256591e-01f, 5.87408952e-02f, 2.65470818e-02f, 4.70230579e-02f, 1.43030390e-01f, 8.96526203e-02f, -1.44351840e-01f,
  -2.54514545e-01f, -2.66297936e-01f, -1.62787244e-01f, 1.99024454e-02f, -1.61330268e-01f, -4.33738902e-02f, 1.08442411e-01f, 6.70871213e-02f, -1.14269711e-01f, 9.43685621e-02f,
  2.68077515e-02f, -4.14256006e-02f, -3.05794757e-02f, 4.74961363e-02f, -1.07064389e-01f, 1.03894971e-01f, -2.15955693e-02f, -9.22221467e-02f, -1.16859853e-01f, -1.50247321e-01f,
  -8.61725435e-02f, -7.90606886e-02f, -8.37126300e-02f, 5.62942736e-02f, -9.98061746e-02f, -7.55675361e-02f, -6.17033727e-02f, -3.60803455e-02f, -2.16215979e-02f, -7.40086436e-02f,
  -1.77899390e-01f, 2.69949913e-01f, 2.46890392e-02f, -1.22963950e-01f, -4.24450487e-02f, -2.69131035e-01f, -4.15137380e-01f, 1.14126205e-01f, -1.05064288e-01f, -2.23082587e-01f,
  -1.67551532e-01f, 1.81505159e-02f, 1.02042131e-01f, -1.28914982e-01f, 3.83599669e-01f, 9.75262821e-02f, 9.51803923e-02f, -1.83968738e-01f, 1.78386807e-01f, 1.12475716e-01f,
  1.97243899e-01f, 4.15485166e-03f, 3.12329948e-01f, 1.95386663e-01f, -1.21808432e-01f, 4.14450467e-02f, 1.49997726e-01f, 4.55293469e-02f, -9.63747501e-02f, 3.47822048e-02f,
  -2.01189816e-01f, -4.34774570e-02f, -1.44105077e-01f, -1.27782926e-01f, -8.52724090e-02f, -1.79037020e-01f, 1.11646613e-03f, -5.22617884e-02f, -9.58762392e-02f, -1.23497665e-01f,
  2.99120061e-02f, -4.68718484e-02f, 1.03255883e-02f, -3.13412249e-02f, -1.61058262e-01f, -1.71595588e-02f, 1.73365176e-01f, -2.90045030e-02f, 3.82488593e-02f, 1.51927084e-01f,
  1.78286374e-01f, -9.16340351e-02f, -1.48776239e-02f, 9.30959210e-02f, 1.59467280e-01f, -1.22338161e-01f, -1.47080690e-01f, -3.02234525e-03f, -2.46362500e-02f, -1.16028346e-01f,
  9.45252478e-02f, -1.70745403e-01f, -8.88637900e-02f, -1.30300775e-01f, -9.25770998e-02f, 1.05035361e-02f, -3.22717875e-02f, -1.19996056e-01f, 6.89067170e-02f, -6.44169375e-02f,
  -8.71715397e-02f, -1.20757788e-01f, -8.56643021e-02f, -1.10060006e-01f, -2.51865294e-02f, -4.27171811e-02f, 9.23878551e-02f, 1.04477644e-01f, 6.33327737e-02f, 1.93241390e-03f,
  -2.90122367e-02f, -2.41265744e-02f, -5.52490279e-02f, 4.38834094e-02f, -1.11053884e-01f, 2.65972037e-02f, -2.61322223e-02f, 1.74745135e-02f, 2.31405329e-02f, 2.54978269e-01f,
  1.33000731e-01f, 1.81984529e-01f, 3.50660235e-02f, 1.54388072e-02f, 8.16955697e-03f, 2.55360045e-02f, 2.49751378e-02f, 4.83627506e-02f, 1.89627871e-01f, 5.36431000e-03f,
  -1.97045747e-02f, -1.40844211e-01f, -1.14005342e-01f, -2.38560904e-02f, 2.36767218e-01f, 1.11302897e-01f, 5.12107275e-02f, -4.86593507e-02f, 7.05930963e-02f, 1.57545522e-01f,
  4.58514243e-02f, -1.54542744e-01f, 9.65714902e-02f, -1.29346540e-02f, 8.23417529e-02f, 2.23496798e-02f, -1.93332825e-02f, 4.70954031e-02f, 1.62607834e-01f, -3.17424685e-02f,
  2.19645172e-01f, -2.25265905e-01f, -3.85324597e-01f, -1.60279050e-01f, -7.80287310e-02f, -4.42845136e-01f, -1.76373526e-01f, -2.19506219e-01f, 1.86345652e-02f, -1.91312167e-03f,
  7.70198181e-02f, -4.79107089e-02f, 1.91287369e-01f, -1.79889277e-01f, -2.99251936e-02f, 3.32930237e-01f, -4.84500408e-01f, -2.83769816e-01f, 1.67530373e-01f, -1.79939359e-01f,
  -1.17386550e-01f, 4.81631570e-02f, -1.47349596e-01f, -9.76312608e-02f, -4.31585424e-02f, -1.83696672e-02f, 1.36935025e-01f, 2.29637638e-01f, -2.15138689e-01f, 1.09655047e-02f,
  1.16737355e-02f, 2.74141669e-01f, 2.34452952e-02f, -5.21798655e-02f, -6.63564056e-02f, 8.83303061e-02f, -5.49971052e-02f, -3.62878926e-02f, 2.35289097e-01f, -2.76593026e-02f,
  -2.21369751e-02f, 1.93085715e-01f, -8.31615701e-02f, 1.46713138e-01f, 7.37101883e-02f, 7.33798519e-02f, 4.75199036e-02f, -1.16224825e-01f, -1.36432022e-01f, 1.26495855e-02f,
  -2.46458743e-02f, -4.20394994e-04f, 4.07755598e-02f, -7.53958672e-02f, -6.28147796e-02f, 6.16214089e-02f, 3.61036696e-02f, -1.06510356e-01f, 4.79795001e-02f, -3.83543223e-02f,
  9.22413170e-02f, 2.15163007e-01f, 4.95914705e-02f, 2.49189585e-02f, 9.55699310e-02f, 2.22866703e-02f, -2.08403692e-02f, -1.02577269e-01f, 8.44445899e-02f, -6.70314655e-02f,
  -1.87103841e-02f, -1.13340348e-01f, 1.30508214e-01f, 6.19647913e-02f, -1.03586819e-02f, 1.46800160e-01f, 1.75676476e-02f, -8.32040012e-02f, -9.74370688e-02f, -1.95730209e-01f,
  1.39729396e-01f, 2.33067777e-02f, 1.97547898e-02f, -1.00061804e-01f, 6.82262853e-02f, 9.47382525e-02f, 1.92149822e-02f, 9.52067822e-02f, -7.56103173e-02f, -9.25522000e-02f,
  -1.64179951e-01f, -3.83035429e-02f, -2.95700673e-02f, -7.24678263e-02f, -3.81734744e-02f, 5.31993993e-02f, -1.07225683e-02f, -3.65306616e-01f, 3.88253108e-02f, 4.12875563e-02f,
  -2.51692593e-01f, 1.25900298e-01f, -6.17629923e-02f, 1.21840695e-02f, -4.68069725e-02f, -1.53889492e-01f, 2.01851279e-02f, -1.06245354e-01f, -1.03313737e-01f, -2.08707884e-01f,
  -1.87188685e-02f, 8.22522119e-02f, 1.48481891e-01f, 4.22595516e-02f, -2.11175367e-01f, -1.36258313e-02f, -1.39650721e-02f, -7.20033003e-03f, 3.24549899e-03f, -1.16174042e-01f,
  1.90792203e-01f, 2.51370728e-01f, 8.29194710e-02f, -9.54983905e-02f, -1.27611578e-01f, -3.05272937e-01f, -3.16211134e-01f, -4.85762395e-02f, 1.91042364e-01f, 1.91031665e-01f,
  -1.51814431e-01f, 3.74489337e-01f, -7.99814686e-02f, -2.43155554e-01f, -2.70512670e-01f, 6.71302080e-02f, -3.65581214e-01f, -1.11008808e-01f, 1.53167352e-01f, -3.10909450e-01f,
  -1.78554505e-01f, -4.47335571e-01f, -1.47033378e-01f, -3.10443193e-01f, -2.94218034e-01f, 3.84356715e-02f, -2.32990995e-01f, -1.29602477e-01f, -5.70367202e-02f, -7.53820091e-02f,
  1.36324251e-02f, 1.40100971e-01f, 8.63719657e-02f, 7.21682608e-02f, -8.60994384e-02f, -7.76761547e-02f, -1.46586850e-01f, 2.94946749e-02f, 2.18967889e-02f, 8.53873119e-02f,
  9.29402709e-02f, 8.40956569e-02f, -9.44151953e-02f, 2.85485536e-02f, -3.27576920e-02f, 9.04714018e-02f, 5.37006930e-02f, 2.90394612e-02f, 3.98296937e-02f, 6.53273687e-02f,
  -1.39230471e-02f, 7.49847889e-02f, -1.30102605e-01f, 4.95171696e-02f, 3.30499299e-02f, 3.35677005e-02f, 6.81041256e-02f, 7.51681551e-02f, 8.70670974e-02f, 1.07469186e-01f,
  1.49401873e-02f, -9.94098485e-02f, -5.10023795e-02f, 7.21915215e-02f, 2.86128428e-02f, -5.18596247e-02f, -6.06723316e-02f, 4.40959893e-02f, -1.27936648e-02f, 3.32922069e-03f,
  2.43056845e-02f, 1.57967761e-01f, -5.35927787e-02f, -1.11245207e-01f, 4.56377212e-03f, 1.50275275e-01f, -3.07440199e-02f, -2.10005436e-02f, -1.04549646e-01f, 6.22181594e-02f,
  2.07169149e-02f, -1.39677450e-01f, 1.39675485e-02f, -3.83427739e-02f, -7.44717866e-02f, 5.64307943e-02f, -7.27702007e-02f, 6.62633255e-02f, 2.68644635e-02f, -2.46647045e-01f,
  -7.68525898e-02f, -9.70185623e-02f, 3.72191705e-02f, 1.81061670e-01f, 7.59312734e-02f, -4.01538657e-03f, -4.92954589e-02f, -5.84575534e-02f, -4.02542250e-03f, 1.36218974e-02f,
  -1.21189915e-01f, 4.96120751e-02f, -6.55803755e-02f, -3.47259804e-03f, 4.49724402e-03f, -1.83348626e-01f, -1.16378896e-01f, -2.00695172e-02f, -5.04628904e-02f, 5.33240475e-02f,
  -1.07234403e-01f, 4.12600674e-03f, 1.86821911e-02f, 1.20936157e-02f, 1.69721879e-02f, 1.55134136e-02f, 9.36104134e-02f, 1.44107714e-01f, -7.38374516e-02f, 1.26551446e-02f,
  7.33251810e-01f, -4.05145645e-01f, -3.09589989e-02f, 3.48052651e-01f, 3.88762325e-01f, 2.28496328e-01f, 5.00415862e-01f, 9.80001315e-02f, 3.94014359e-01f, -1.84929058e-01f,
  1.31396338e-01f, -1.70057952e-01f, 5.46669103e-02f, -1.64851337e-03f, 4.92232144e-01f, -5.04186638e-02f, 2.42224693e-01f, 1.42089576e-01f, 2.28228122e-02f, 1.78675517e-01f,
  2.62451500e-01f, 3.06364864e-01f, 4.56568785e-02f, -1.58353522e-01f, 1.80586308e-01f, -2.62290061e-01f, -1.01245947e-01f, -1.54608980e-01f, -3.58385175e-01f, 1.76693723e-02f,
  3.20957601e-02f, 5.40456623e-02f, -1.46062505e-02f, -1.14279315e-01f, 6.53012693e-02f, 6.81810006e-02f, -6.12043478e-02f, 5.70761552e-03f, 1.19552150e-01f, 9.17807743e-02f,
  3.43385967e-03f, -8.39563981e-02f, -2.04788763e-02f, 3.10744531e-03f, 8.97684172e-02f, -4.94991653e-02f, -4.10379730e-02f, -6.83654239e-03f, -7.13121295e-02f, 3.95749137e-03f,
  1.23391896e-01f, -8.92098397e-02f, 1.38842523e-01f, -1.16976358e-01f, 1.38979005e-02f, -7.58298393e-03f, -1.54334918e-01f, -6.42037466e-02f, -4.79913689e-02f, -1.70702208e-03f,
  2.32034009e-02f, -5.29420488e-02f, 1.06337473e-01f, 2.74917353e-02f, 4.49859686e-02f, 6.02781493e-03f, 1.10584192e-01f, -8.58820602e-02f, -4.49092165e-02f, 1.94039494e-02f,
  1.25495372e-02f, 1.40198588e-01f, -4.62613292e-02f, 7.32009858e-02f, 9.21996012e-02f, -3.57383899e-02f, 9.86536965e-02f, -1.13127328e-01f, 3.40522453e-02f, 6.30980358e-02f,
  -8.30516405e-03f, 4.47430946e-02f, 5.34123778e-02f, -1.30422801e-01f, -5.67894941e-03f, 5.86170889e-02f, -8.78201202e-02f, 4.27537365e-03f, -8.47373903e-02f, 1.98173627e-01f,
  -7.41437525e-02f, -2.20090479e-01f, -7.30134500e-03f, -6.05936907e-02f, -1.48362920e-01f, 6.28799647e-02f, -2.96471082e-02f, 8.78227279e-02f, -6.03427105e-02f, 3.00465934e-02f,
  -5.97499087e-02f, 5.56111634e-02f, 2.83157034e-03f, 5.28193489e-02f, -1.49827614e-01f, 1.75235540e-01f, -1.58915773e-01f, 1.74712222e-02f, -1.78403198e-03f, -1.33213311e-01f,
  -8.26639533e-02f, 1.20325722e-01f, -3.12159155e-02f, 7.44518042e-02f, -5.52690104e-02f, -5.85432015e-02f, -8.92922804e-02f, -1.06494814e-01f, 1.07605997e-02f, -1.80799328e-02f,
  -4.00136299e-02f, 3.24669152e-01f, 2.03257576e-01f, 3.27456474e-01f, -8.48728642e-02f, -4.61774290e-01f, -1.90323368e-01f, 9.41440538e-02f, 1.00789256e-01f, 1.51049092e-01f,
  -1.28294528e-01f, 3.60072553e-01f, 3.49312089e-02f, -1.54253110e-01f, -4.73628074e-01f, -3.30675483e-01f, -4.21273662e-03f, -1.33746162e-01f, 1.72394857e-01f, 2.07869530e-01f,
  5.89420274e-02f, -2.41902649e-01f, 1.04166031e-01f, 1.16605312e-01f, 9.97477323e-02f, 4.35125887e-01f, 2.82387584e-01f, 1.01414286e-01f, 2.19223708e-01f, -1.29858240e-01f,
  -2.09827140e-01f, 1.05604105e-01f, 9.09696966e-02f, -7.46121705e-02f, 1.11969568e-01f, -8.45467299e-02f, -5.43193482e-02f, -8.92422050e-02f, 3.85734849e-02f, 1.71171561e-01f,
  -2.56214594e-03f, 1.01478219e-01f, 1.04700208e-01f, 3.32193747e-02f, -8.08098689e-02f, 2.38942489e-01f, -4.38689962e-02f, 6.13686861e-03f, 5.21101728e-02f, -6.16706302e-03f,
  8.11385512e-02f, 2.70916391e-02f, -2.04895996e-02f, 7.69940317e-02f, 1.39813825e-01f, 1.72492117e-02f, 3.29195969e-02f, -6.47090469e-03f, 1.54984757e-01f, 6.05909526e-02f,
  -1.20065235e-01f, 8.53159651e-02f, 1.03144616e-01f, -3.01950816e-02f, 3.48275937e-02f, -6.25380361e-03f, -9.11859050e-02f, -7.39667341e-02f, 9.18796379e-03f, -2.87208892e-02f,
  5.01399813e-03f, 5.99627532e-02f, -1.13442749e-01f, 9.37340036e-02f, 9.73128676e-02f, -3.37430425e-02f, 9.86879412e-03f, 6.69859573e-02f, 5.37891872e-04f, 1.09641859e-02f,
  -2.33977977e-02f, -4.56552096e-02f, 1.44689038e-01f, -1.42194286e-01f, -1.38317272e-01f, 1.47933245e-01f, 5.71498461e-02f, -4.48730029e-02f, -5.03928885e-02f, 5.54080941e-02f,
  2.26383898e-02f, 2.59281218e-01f, 8.33222717e-02f, -1.19413413e-01f, 3.49254049e-02f, -3.03678736e-02f, -1.97843775e-01f, -6.17176592e-02f, 1.61644086e-01f, -5.06949574e-02f,
  -5.30667193e-02f, 1.63354903e-01f, 5.59635609e-02f, -1.49240792e-01f, -3.64312832e-03f, 1.94031429e-02f, 7.47499168e-02f, -2.62235315e-03f, 1.76825717e-01f, 9.21267942e-02f,
  1.72233507e-01f, 1.14510618e-01f, 5.68756759e-02f, 4.42372076e-02f, 4.52628767e-04f, -1.12337954e-02f, 4.47691306e-02f, 1.70334820e-02f, 1.79918017e-02f, 1.64729953e-01f,
  -6.75892174e-01f, 3.62890691e-01f, -3.10806066e-01f, -8.27914178e-02f, -3.77081223e-02f, -4.08538461e-01f, -5.68936067e-03f, 1.64139926e-01f, -1.91055924e-01f, 4.15058970e-01f,
  3.38666767e-01f, -2.78678179e-01f, 3.01701307e-01f, 1.06240332e-01f, -4.42576140e-01f, -7.21241832e-02f, -8.11069552e-03f, -3.15988734e-02f, -1.99727803e-01f, 1.40968665e-01f,
  -1.99516475e-01f, 2.31818065e-01f, 1.41404927e-01f, 2.19458133e-01f, -8.84681754e-03f, -3.80630344e-02f, 4.12441492e-01f, 4.16753441e-02f, 1.53037176e-01f, -9.85494033e-02f,
  4.02706936e-02f, 1.31776676e-01f, 8.58073458e-02f, -4.14846614e-02f, 1.63888689e-02f, 1.44620955e-01f, -3.12770605e-02f, -4.45974916e-02f, -7.75747597e-02f, -4.10445146e-02f,
  2.13853847e-02f, -5.15559316e-02f, -1.22303359e-01f, -2.28938777e-02f, -6.15310967e-02f, -7.99521506e-02f, 5.34067117e-02f, -5.84548153e-02f, 4.82629472e-03f, -5.84994704e-02f,
  -5.92811145e-02f, -5.15420958e-02f, -3.00963838e-02f, -5.17501980e-02f, -1.00787625e-01f, -8.59497339e-02f, -1.39584601e-01f, 5.20534366e-02f, -6.86118230e-02f, -1.06823422e-01f,
  8.90133809e-03f, -8.49502757e-02f, -5.42929433e-02f, 7.24153072e-02f, -5.95317818e-02f, 5.63743860e-02f, -6.42841235e-02f, 1.34310983e-02f, -1.25320524e-01f, 4.69805449e-02f,
  5.56783983e-03f, -1.02991454e-01f, 1.21178433e-01f, -2.35496163e-02f, 1.47343902e-02f, -3.00641973e-02f, -2.51623038e-02f, 5.01479283e-02f, 6.89258203e-02f, -7.05315769e-02f,
  1.27792716e-01f, -3.37452441e-02f, -2.49065496e-02f, 1.29693389e-01f, 1.06352679e-01f, -1.12933971e-01f, 7.07776025e-02f, -4.95778397e-02f, 2.13795342e-02f, -3.43694799e-02f,
  1.57811403e-01f, 2.80278504e-01f, 5.42584024e-02f, 3.07197608e-02f, 2.33034641e-02f, -8.05115402e-02f, 2.00433517e-03f, -6.50256425e-02f, -3.43376733e-02f, -6.42710552e-02f,
  6.29532784e-02f, 4.21908535e-02f, 3.32722813e-02f, -2.42559407e-02f, 4.14784476e-02f, 6.65195137e-02f, 2.02839270e-01f, -2.65367832e-02f, 1.02053933e-01f, 1.59929723e-01f,
  6.41001835e-02f, -2.82959510e-02f, -9.55200493e-02f, -1.00457311e-01f, 9.03438590e-03f, 1.95468381e-01f, 8.85099918e-03f, 4.55640815e-02f, 3.12584303e-02f, 1.46816298e-01f,
  -1.74937770e-01f, -2.91668475e-01f, 3.23948830e-01f, -2.30471805e-01f, 3.74616414e-01f, 7.94063210e-02f, -3.70397836e-01f, 1.40895233e-01f, 1.70449466e-01f, -4.02936071e-01f,
  -8.59060138e-02f, -1.73172951e-01f, -6.95756301e-02f, -2.29653209e-01f, 2.40865394e-01f, 1.83813468e-01f, -1.23175092e-01f, -1.88471690e-01f, 2.60877609e-01f, -1.39595419e-01f,
  1.17197335e-01f, -1.86109543e-01f, 1.03747450e-01f, 2.27652669e-01f, 2.39672717e-02f, -1.13446131e-01f, -1.09491177e-01f, 1.22337438e-01f, -1.86165646e-01f, 1.77205414e-01f,
  -1.93266928e-01f, -2.56277442e-01f, -1.45365000e-01f, -9.31898598e-03f, -5.99172935e-02f, -2.46798992e-02f, -5.39391451e-02f, -4.40716743e-02f, -1.51923094e-02f, 4.50590216e-02f,
  -8.23826790e-02f, 1.65066183e-01f, -1.71632357e-02f, -7.39187002e-02f, 3.06256153e-02f, 1.08311318e-01f, 1.07340202e-01f, 2.44593844e-02f, 3.05454619e-02f, 1.50866106e-01f,
  1.06321529e-01f, 6.08012341e-02f, 5.15577532e-02f, -2.06443807e-03f, 1.91003770e-01f, -2.01151855e-02f, 4.48062792e-02f, -1.09194117e-02f, -1.22182714e-02f, 1.61138475e-01f,
  1.72850683e-01f, 5.97321168e-02f, -2.61523444e-02f, -4.99064550e-02f, -7.28285834e-02f, 5.04482873e-02f, -3.71094421e-03f, -6.05359450e-02f, -2.82486826e-02f, -9.41317342e-03f,
  4.79732193e-02f, -5.85756078e-02f, 6.42486289e-02f, 3.88458930e-02f, -7.21379817e-02f, -7.77631905e-03f, -1.43077105e-01f, -5.35357744e-02f, 7.59321004e-02f, -6.81035817e-02f,
  -5.32991998e-02f, 3.85119841e-02f, 1.67427491e-02f, 2.09337529e-02f, -8.11326504e-02f, -1.13873206e-01f, -5.33605777e-02f, 7.08764121e-02f, -2.30103685e-03f, -9.11636185e-03f,
  -6.29753828e-01f, -5.52065194e-01f, -1.40646189e-01f, -2.17977446e-02f, -9.85871926e-02f, 1.08309649e-02f, 8.68958328e-03f, 8.16504881e-02f, -1.17327124e-01f, 4.78579365e-02f,
  2.19951360e-03f, 2.72909040e-03f, -6.34684041e-02f, 3.26700159e-04f, -7.60342926e-02f, -2.10433770e-02f, -1.36734203e-01f, -1.66771740e-01f, -1.27780616e-01f, -4.90363166e-02f,
  -1.52705964e-02f, -1.14164930e-02f, 1.08311810e-02f, 6.70718774e-02f, 4.71084155e-02f, -8.04610625e-02f, -6.68399483e-02f, 1.10872008e-01f, 3.08758840e-02f, 7.88258240e-02f,
  -3.31269175e-01f, -5.50052114e-02f, -1.43435776e-01f, -3.07747543e-01f, 3.01697612e-01f, 4.31776866e-02f, 4.86864410e-02f, 2.86469996e-01f, 1.30806506e-01f, 1.07991949e-01f,
  8.80787969e-02f, -4.33266610e-01f, 1.01042733e-01f, -4.97223705e-01f, -3.15293819e-01f, -2.73770303e-01f, -4.05138105e-01f, -3.50299925e-01f, 6.12842515e-02f, -6.27010316e-02f,
  -2.81834096e-01f, -2.48226985e-01f, -2.21292496e-01f, 3.24542284e-01f, -9.57643762e-02f, 1.27260700e-01f, 3.42036076e-02f, 3.60682219e-01f, -1.43576473e-01f, -1.52413966e-02f,
  -4.18762565e-02f, 4.51441593e-02f, 8.90877694e-02f, -4.12490219e-03f, 9.54138041e-02f, 8.07999596e-02f, -1.13500372e-01f, 3.41693088e-02f, 1.71716481e-01f, 1.47345606e-02f,
  -1.03342220e-01f, -8.78240541e-02f, -1.44597515e-01f, 3.84070128e-02f, 1.42995179e-01f, 8.86541605e-02f, -9.52576846e-02f, 9.82253626e-02f, 1.89994350e-02f, -2.14039519e-01f,
  -5.89587241e-02f, -8.32068399e-02f, -7.78075457e-02f, -1.71872541e-01f, -8.36423561e-02f, 2.16591451e-02f, -6.62110671e-02f, -1.06545746e-01f, 6.18658736e-02f, -2.24367157e-02f,
  -4.00439166e-02f, 2.29371805e-02f, -9.49083641e-03f, 1.08194306e-01f, 1.17671341e-01f, -2.06517112e-02f, -1.69897750e-02f, -1.05053782e-01f, 8.11568201e-02f, -6.66347668e-02f,
  5.79603352e-02f, 5.44976369e-02f, -3.67629826e-02f, 2.59615034e-02f, -9.36658531e-02f, -3.60650867e-02f, -8.03880766e-03f, -2.14364201e-01f, -8.87777358e-02f, 5.49982078e-02f,
  1.25251561e-01f, -2.31087487e-02f, -5.46231382e-02f, -1.56122800e-02f, 1.56753376e-01f, 1.31378531e-01f, -4.80662696e-02f, -8.36912841e-02f, 1.32014439e-01f, -8.89526010e-02f,
  1.21764161e-01f, -4.23178775e-03f, 2.14906052e-01f, 4.31446321e-02f, 7.95841515e-02f, 1.48653053e-02f, -7.38084167e-02f, -1.86100468e-01f, 9.85415950e-02f, 4.81434576e-02f,
  -5.23159951e-02f, 1.30959496e-01f, 7.07208589e-02f, -8.85990635e-02f, 2.35432349e-02f, -5.11255674e-02f, -8.39627385e-02f, 6.25512600e-02f, 1.27209365e-01f, -1.85200237e-02f,
  7.17318952e-02f, 8.83641392e-02f, -1.71563756e-02f, 8.91699791e-02f, -6.79825023e-02f, -2.40706047e-03f, 6.30184561e-02f, 1.71660855e-02f, -3.19706574e-02f, -4.75820005e-02f,
  1.49926975e-01f, 6.17846511e-02f, -2.27944478e-01f, 3.58155310e-01f, 2.54729390e-01f, 3.88268352e-01f, 2.22442433e-01f, 1.68122768e-01f, 3.42252314e-01f, 4.91043478e-02f,
  4.11357015e-01f, -2.69124001e-01f, -2.80176420e-02f, 4.53005493e-01f, -7.68599436e-02f, 2.04818770e-01f, 3.42188478e-01f, 2.27986082e-01f, 1.45213738e-01f, 4.36968282e-02f,
  -3.72905005e-03f, 1.68985590e-01f, -2.39805683e-01f, -1.62694961e-01f, 1.09232917e-01f, -2.73020297e-01f, -1.58261806e-01f, -3.18718046e-01f, 3.14643141e-03f, -5.76181971e-02f,
  1.10268943e-01f, 1.70902476e-01f, 1.03396609e-01f, -1.06283121e-01f, -4.65877866e-03f, -2.30868980e-02f, -1.30801663e-01f, -2.14178786e-01f, -1.36661485e-01f, 1.04789123e-01f,
  -3.43106128e-02f, -9.44333300e-02f, 2.38072462e-02f, -3.89979854e-02f, 7.31750801e-02f, 7.71881938e-02f, 1.03976279e-01f, 1.38942137e-01f, 7.28850365e-02f, -9.29906815e-02f,
  2.28922609e-02f, 4.62766513e-02f, 2.13493422e-01f, -9.97771695e-02f, -4.41322401e-02f, 1.02190031e-02f, 3.02270614e-02f, -5.81729598e-02f, -3.56510165e-03f, 1.73439547e-01f,
  -9.11360160e-02f, 4.64226166e-03f, 6.61544502e-02f, -4.54272442e-02f, 3.60400490e-02f, 4.86594252e-02f, -5.87256043e-04f, 4.58143204e-02f, -1.26468558e-02f, 1.65590584e-01f,
  1.86721846e-01f, 1.11701816e-01f, 1.92899153e-01f, 7.12802215e-03f, 1.57886267e-01f, 5.09012155e-02f, -4.64766100e-03f, 9.96044353e-02f, 8.81913006e-02f, -2.03318391e-02f,
  1.91459283e-02f, 1.46164939e-01f, 9.50995907e-02f, -1.42998204e-01f, 2.39500646e-02f, -6.21610694e-02f, 5.21540903e-02f, 2.42080718e-01f, 4.83057760e-02f, -3.70216891e-02f,
  1.88013457e-03f, -1.32551491e-01f, 8.02311897e-02f, 7.71212876e-02f, -1.07569911e-01f, 1.36153355e-01f, -1.16482958e-01f, 4.57991920e-02f, -7.76747838e-02f, 6.13001846e-02f,
  5.31369150e-02f, -3.00380145e-03f, 1.09887971e-02f, -7.64346495e-03f, -1.42398804e-01f, 1.12935685e-01f, 4.27367724e-03f, -6.33544661e-03f, 9.74809402e-04f, -7.27357566e-02f,
  -1.62085339e-01f, 1.80215738e-03f, -1.01404972e-01f, 8.50184336e-02f, -2.70926487e-03f, -7.46744722e-02f, 1.72750428e-02f, -7.68458694e-02f, -2.31423508e-02f, 7.33044818e-02f,
  6.14336848e-01f, 2.32860800e-02f, 1.78844154e-01f, 4.63335216e-01f, -2.70347483e-02f, -2.31978789e-01f, -1.54443264e-01f, 4.33566570e-02f, 2.85255108e-02f, -2.15876848e-01f,
  -4.74502705e-03f, 4.70279008e-02f, -2.44836897e-01f, 3.24798375e-01f, -5.40209301e-02f, -3.29115212e-01f, 1.13731906e-01f, 4.31671217e-02f, -9.78980772e-03f, 2.51516312e-01f,
  1.65628180e-01f, -1.06784500e-01f, 1.28453344e-01f, -9.27318539e-03f, 3.41896683e-01f, 1.46077037e-01f, -1.17852733e-01f, -8.59186798e-02f, 3.07832267e-02f, -1.10903725e-01f,
  5.67513108e-02f, 1.57732144e-01f, 1.57094762e-01f, 8.86951312e-02f, 1.11451954e-01f, 5.80824427e-02f, 3.21423933e-02f, -2.23084733e-01f, 5.49265882e-03f, -1.00699633e-01f,
  -2.58721318e-02f, -3.53508852e-02f, -1.48960128e-01f, -1.79985594e-02f, 1.69569477e-01f, 1.53180175e-02f, 8.15976039e-02f, 1.25203252e-01f, -7.75111020e-02f, 1.39742449e-01f,
  8.86590332e-02f, -8.40939879e-02f, 8.82506371e-02f, -1.36039466e-01f, -1.28726110e-01f, -1.79006215e-02f, -1.83030918e-01f, -9.87720564e-02f, -1.52799487e-01f, -9.61083919e-03f,
  -4.40570302e-02f, -2.95204446e-02f, -2.86953151e-03f, 1.34980574e-01f, -3.54640782e-02f, -2.87210289e-02f, 9.06600505e-02f, -4.20565307e-02f, -4.32290696e-02f, 9.93248634e-03f,
  -2.34055445e-02f, 6.38784468e-02f, 4.87824231e-02f, -1.61318779e-02f, 4.68777269e-02f, 3.97446603e-02f, -1.35128088e-02f, -1.26693144e-01f, -2.05676653e-03f, 1.25820087e-02f,
  -5.55145415e-03f, -4.37159315e-02f, 3.78575455e-03f, 2.87677553e-02f, -5.81162944e-02f, -1.34461582e-01f, 8.71868581e-02f, 4.52439897e-02f, 1.95701644e-02f, 4.32097614e-02f,
  -3.38117816e-02f, -2.00449064e-01f, -3.31951939e-02f, -1.44698635e-01f, -2.15910636e-02f, 1.08977176e-01f, 3.97153907e-02f, 1.61608905e-02f, -7.35899284e-02f, -6.12280145e-02f,
  3.07799666e-04f, -6.35390207e-02f, -6.29111901e-02f, 2.07482681e-01f, 2.63029784e-02f, -3.49057131e-02f, -1.18902341e-01f, -1.14135988e-01f, -1.75758258e-01f, -3.16166170e-02f,
  -7.52287358e-02f, -1.38061762e-01f, 1.78345200e-02f, -1.95181787e-01f, -9.43821594e-02f, -6.58086762e-02f, -1.17692485e-01f, 8.37184489e-02f, -8.31509158e-02f, -7.88583159e-02f,
  -1.47129521e-01f, 2.37998143e-01f, 5.06566763e-02f, 1.71631888e-01f, -1.34343296e-01f, -1.65570527e-01f, 1.10497363e-01f, -1.18786603e-01f, 1.75137550e-01f, 1.83449253e-01f,
  -1.64832860e-01f, 4.03764099e-01f, -1.37984306e-02f, -2.93874145e-01f, -6.78948700e-01f, -2.28797898e-01f, -5.09316754e-03f, 1.32243469e-01f, 1.83681384e-01f, 1.22198336e-01f,
  -1.52870670e-01f, -2.60218829e-01f, -4.00266200e-01f, 2.61041964e-03f, 1.92147464e-01f, 3.56138855e-01f, -9.66358185e-02f, 9.32350084e-02f, 2.97155529e-02f, -7.51897693e-02f,
  -4.36503738e-02f, 8.51264894e-02f, 5.56012578e-02f, 4.43071313e-02f, -3.21317166e-02f, -1.31700244e-02f, -3.17949802e-02f, -4.52776961e-02f, -6.63636327e-02f, 1.05667897e-01f,
  1.76239595e-01f, -2.05647908e-02f, 1.49432108e-01f, -1.74469978e-01f, -4.06198250e-03f, 5.76835591e-03f, -1.31666353e-02f, -1.09128416e-01f, 1.07797913e-01f, -8.08841288e-02f,
  3.17383371e-02f, 4.43784185e-02f, -3.77668738e-02f, 2.10678026e-01f, 7.63531998e-02f, 7.62185827e-02f, 8.28817952e-03f, -8.17486793e-02f, 1.70377359e-01f, 1.12884253e-01f,
  2.21303292e-02f, 3.81899290e-02f, -8.49581510e-02f, -9.97135341e-02f, -1.07741207e-01f, 6.02559596e-02f, -1.13678381e-01f, -3.25206444e-02f, -4.70626121e-03f, 7.72810355e-03f,
  5.46305589e-02f, 1.52573716e-02f, -5.37626371e-02f, -6.79091960e-02f, 9.20712650e-02f, 1.80097427e-02f, -1.34368911e-01f, 8.88816416e-02f, 1.15573227e-01f, -1.42999440e-01f,
  2.98572052e-02f, 2.64171027e-02f, 1.24128275e-01f, 2.73511782e-02f, -1.63550600e-01f, 3.50595266e-03f, 2.96706297e-02f, -5.81819862e-02f, 8.58695805e-03f, -4.66059111e-02f,
  1.13064989e-01f, 3.79687071e-01f, 6.55042976e-02f, 1.07077010e-01f, 4.47799116e-02f, -3.79903167e-02f, -4.19432484e-02f, 1.44923921e-03f, 1.61982685e-01f, 5.34116663e-02f,
  -2.64419727e-02f, 1.46072477e-01f, 3.68646421e-02f, -1.80057004e-01f, -7.86812529e-02f, -8.42320174e-02f, 4.27906103e-02f, 1.10621072e-01f, 1.83592349e-01f, -6.75601587e-02f,
  1.66695938e-02f, 1.01146884e-01f, 8.10113400e-02f, 1.48277119e-01f, 1.92646965e-01f, 1.05372183e-01f, 5.25602400e-02f, -9.31647513e-03f, 7.34958127e-02f, 1.40104428e-01f,
  1.66337118e-01f, -6.28596768e-02f, -5.27323306e-01f, -2.64703244e-01f, -1.53533489e-01f, 2.08770156e-01f, 1.66412070e-01f, -1.92044291e-03f, -1.14781551e-01f, 3.62176955e-01f,
  -1.13165677e-02f, -4.94180061e-02f, 2.32120156e-01f, -2.24587992e-01f, -3.84752229e-02f, -9.15043522e-03f, -2.39259079e-02f, 6.95354044e-02f, -2.32574224e-01f, 1.90231070e-01f,
  3.55923176e-02f, 2.49299541e-01f, -4.02898937e-01f, 8.28294232e-02f, 2.97607630e-02f, -2.73054570e-01f, 5.95007129e-02f, -1.07659698e-01f, -9.52993259e-02f, -4.69159894e-02f,
  -1.59795314e-01f, -8.05441812e-02f, -1.89505473e-01f, -3.88172083e-02f, -1.89758930e-02f, 2.60449629e-02f, 5.27328905e-03f, -4.87668291e-02f, -1.30335346e-01f, -8.70421827e-02f,
  2.05751732e-01f, -1.98493130e-03f, 1.02934951e-03f, -5.55180386e-02f, 7.34355971e-02f, -3.13785747e-02f, -1.36771902e-01f, 6.96954057e-02f, -2.64213886e-02f, -4.42937352e-02f,
  -7.48324022e-02f, -9.99890640e-02f, 1.03589557e-02f, -1.67758949e-02f, 4.78077476e-04f, -9.01004076e-02f, 2.80481372e-02f, -2.21287105e-02f, 1.21103704e-01f, -1.05837584e-01f,
  3.22521478e-02f, 6.02082908e-02f, 6.59841821e-02f, -1.03703417e-01f, -3.46914679e-02f, -6.93890452e-02f, 6.81401119e-02f, -5.26061505e-02f, -5.91532178e-02f, 4.89893444e-02f,
  3.48432995e-02f, 1.20064199e-01f, 4.32941057e-02f, 6.76341057e-02f, 7.83170238e-02f, 1.53633803e-01f, 8.27167854e-02f, 7.26742893e-02f, -2.86171287e-02f, -6.17539957e-02f,
  -1.15308806e-01f, -3.27164754e-02f, -1.88230760e-02f, 2.13865340e-02f, -6.28273264e-02f, 9.67460871e-02f, 8.72787833e-02f, -8.04272071e-02f, -4.37473841e-02f, 1.41940400e-01f,
  -4.07986669e-03f, 2.47036129e-01f, -3.87539566e-02f, 2.85757035e-02f, -6.99587399e-03f, 1.14898078e-01f, 3.00792158e-02f, 3.30631286e-02f, -9.85549465e-02f, 1.99289009e-01f,
  1.69382215e-01f, 2.67289579e-02f, 1.89618975e-01f, -1.41201049e-01f, -6.34713247e-02f, 8.75131413e-02f, 1.18459336e-01f, 6.01463467e-02f, -3.54968123e-02f, -1.54971695e-02f,
  1.51712000e-01f, 2.56578088e-01f, 1.77031323e-01f, 1.39740497e-01f, 1.89496234e-01f, 1.50610618e-02f, -1.25171142e-02f, -5.57787642e-02f, 7.27508515e-02f, -2.18766823e-01f,
  -1.89512931e-02f, 1.65363885e-02f, -5.63387498e-02f, -1.97932869e-01f, 6.73592314e-02f, -3.92156780e-01f, -2.85352111e-01f, -6.38761595e-02f, 1.55197695e-01f, -5.97194545e-02f,
  -3.25104408e-02f, 1.26227498e-01f, 1.55163482e-01f, -3.28967452e-01f, -2.33578086e-01f, 1.35743320e-01f, -3.32717597e-01f, -2.59449005e-01f, 1.11888357e-01f, -2.87174672e-01f,
  -1.18711740e-01f, -3.16332191e-01f, -1.22753553e-01f, -8.72535333e-02f, -1.95612013e-01f, 3.77737172e-02f, -5.11932038e-02f, 4.95604612e-02f, -1.71054140e-01f, 8.79921839e-02f,
  -1.25625208e-01f, -3.40775736e-02f, -1.17681110e-02f, -5.49927354e-02f, -2.21014306e-01f, -5.92557006e-02f, -3.27470563e-02f, 5.22277355e-02f, -3.23274881e-02f, 1.85576789e-02f,
  3.01078651e-02f, 9.68587324e-02f, 5.10660820e-02f, 1.15934499e-01f, -5.72909862e-02f, 6.47508958e-03f, 2.19393205e-02f, -1.05098272e-02f, 7.79526383e-02f, -8.81385431e-02f,
  -1.25784585e-02f, -9.98524833e-04f, 9.66389198e-03f, -3.57325748e-02f, 9.31857750e-02f, 1.20892398e-01f, -5.99696003e-02f, -2.11025774e-02f, -3.11582536e-02f, 5.27052321e-02f,
  -3.07362117e-02f, -4.87746894e-02f, -8.93521905e-02f, 9.03796703e-02f, -7.52551556e-02f, 7.67400265e-02f, 5.28853387e-02f, -2.24494888e-03f, 8.48868117e-03f, -8.36509839e-02f,
  -3.32380794e-02f, 4.73857224e-02f, 1.11727290e-01f, -1.13418758e-01f, -4.25537042e-02f, 2.18396038e-02f, -7.16582462e-02f, 1.15785599e-02f, 1.88556034e-02f, -1.18314207e-01f,
  1.21043138e-02f, -3.74004655e-02f, 6.69706389e-02f, 8.95300433e-02f, -2.42072176e-02f, 5.53225987e-02f, -5.24710827e-02f, -2.57179588e-02f, 3.61318476e-02f, -7.07388744e-02f,
  -2.67189711e-01f, -3.46916050e-01f, -3.80807072e-02f, 1.11298263e-01f, -1.49159670e-01f, -8.48096386e-02f, 2.04824191e-02f, 7.47785494e-02f, -1.83928981e-01f, -6.53095543e-02f,
  -2.98666321e-02f, -1.32206455e-01f, 3.24921422e-02f, 1.28331482e-01f, -8.52398649e-02f, -3.57316993e-02f, -9.94371101e-02f, 7.42733926e-02f, -8.79973918e-02f, -8.72233510e-02f,
  -5.72555959e-02f, -1.11597657e-01f, -9.88609418e-02f, -7.66986758e-02f, -7.28051960e-02f, 1.79111511e-02f, -2.41821874e-02f, 1.53961137e-01f, -7.24009946e-02f, 1.35330604e-02f,
  5.57196856e-01f, 3.31260532e-01f, 1.23987511e-01f, 4.47016984e-01f, 2.38568429e-02f, 2.57886082e-01f, 4.73632962e-01f, -1.85052156e-02f, 3.91515732e-01f, 1.18741304e-01f,
  -1.19462766e-01f, 3.62791300e-01f, -2.27829739e-01f, 2.38577574e-01f, -1.97040603e-01f, -1.87876686e-01f, 3.76103312e-01f, 3.37298304e-01f, -2.10323632e-02f, 1.60599366e-01f,
  6.10158369e-02f, -5.69193736e-02f, -9.00283903e-02f, -2.05397829e-01f, 2.18308419e-01f, 2.08087005e-02f, -4.02910590e-01f, -1.51966527e-01f, -4.74662811e-05f, -7.75341690e-02f,
  7.79541284e-02f, 1.01732455e-01f, 4.45017517e-02f, -2.96228658e-02f, 3.54846916e-03f, 9.84486938e-02f, 8.21223408e-02f, -1.25786781e-01f, -6.38250709e-02f, -2.56103501e-02f,
  1.85643911e-01f, -7.44630992e-02f, -7.23760352e-02f, -1.22445814e-01f, 1.29061639e-01f, -7.88788721e-02f, 5.47931939e-02f, 4.29632254e-02f, 3.01609072e-03f, -1.40901860e-02f,
  1.93767235e-01f, 2.63935253e-02f, 1.43415943e-01f, 8.87589455e-02f, -3.70281748e-02f, 1.07951455e-01f, 8.07449222e-02f, -5.43815037e-03f, -2.40400676e-02f, 9.80107486e-02f,
  -1.64617393e-02f, 8.44634324e-02f, -5.32170758e-03f, 2.70490255e-02f, -4.99623939e-02f, -4.90326397e-02f, 1.50603548e-01f, -3.51434834e-02f, 1.92943420e-02f, -5.77930696e-02f,
  -6.60663322e-02f, 3.86607051e-02f, -5.81197776e-02f, 7.28446096e-02f, 1.51456334e-02f, 1.01091325e-01f, -1.24053158e-01f, -3.64662781e-02f, 9.64180082e-02f, 5.02819084e-02f,
  -1.31570131e-01f, 4.88379709e-02f, -7.44262757e-03f, -2.06489861e-02f, 2.85949912e-02f, -1.26743346e-01f, -2.83813551e-02f, 8.03598203e-03f, -3.25075425e-02f, 7.24273222e-03f,
  -2.14176252e-02f, -1.54011305e-02f, -2.30474249e-02f, -3.56252678e-02f, -5.84122203e-02f, 2.06272267e-02f, 5.14792725e-02f, 7.34991282e-02f, 2.35413034e-02f, -3.02913063e-03f,
  1.04086213e-01f, 9.90858003e-02f, -6.25620112e-02f, -3.80255021e-02f, 2.50140224e-02f, -6.95750341e-02f, -1.26858661e-03f, -5.13878651e-03f, -1.28386661e-01f, -4.13433611e-02f,
  3.59378792e-02f, 1.06494784e-01f, 1.41422540e-01f, 1.11938395e-01f, 1.02677666e-01f, -6.51817024e-02f, 6.61228374e-02f, 4.69754003e-02f, 7.64687371e-04f, -3.54081243e-02f,
  -1.56675801e-01f, 5.81678212e-01f, 2.58078456e-01f, -6.56552687e-02f, -2.46433690e-01f, 3.81197304e-01f, 2.81939924e-01f, 2.20636293e-01f, 3.87586266e-01f, 2.08977446e-01f,
  -3.33176374e-01f, 3.66911083e-01f, 2.77981963e-02f, 1.33503973e-01f, -1.65055424e-01f, -1.08684748e-01f, 4.97402512e-02f, 1.36702642e-01f, 1.16405018e-01f, -9.15996656e-02f,
  -2.59724170e-01f, -3.46522599e-01f, -3.42527628e-01f, -1.11607701e-01f, -5.89261800e-02f, 8.93322229e-02f, -4.01387572e-01f, 1.06861763e-01f, 5.09342849e-02f, 1.35883138e-01f,
  2.82863807e-02f, 1.19100854e-01f, 9.71653014e-02f, 2.46225566e-01f, 3.52834761e-02f, -5.62405586e-02f, 2.89409468e-03f, 2.48182943e-04f, 9.30093694e-04f, 4.45222817e-02f,
  -8.13578963e-02f, -3.26214768e-02f, 5.54173477e-02f, -3.70904170e-02f, 2.03651518e-01f, 2.19630197e-01f, 2.16041412e-03f, -9.62505862e-02f, 4.90137115e-02f, 3.99834178e-02f,
  3.50115038e-02f, 9.30187181e-02f, -9.23129842e-02f, 5.01103699e-02f, -2.43177954e-02f, -4.52256799e-02f, 9.41969827e-03f, 4.55373302e-02f, 6.82186261e-02f, 1.05796754e-01f,
  6.96056262e-02f, -1.50323167e-01f, -4.77908663e-02f, -8.99831131e-02f, 9.48722735e-02f, 1.08129270e-02f, -7.45898485e-02f, -1.39320847e-02f, 5.10313222e-03f, -1.06495231e-01f,
  -5.46864234e-02f, 4.82319370e-02f, -5.86293824e-02f, -1.35854213e-02f, -3.58779058e-02f, 2.01402660e-02f, -2.19836906e-01f, -4.05240320e-02f, 1.40565159e-02f, -9.14293975e-02f,
  2.18973923e-02f, -5.56879342e-02f, 1.87691059e-02f, -1.74859494e-01f, -9.68532637e-03f, 2.78913788e-02f, 4.78602946e-02f, 6.13722876e-02f, 4.53363609e-04f, -1.21224903e-01f,
  1.57991886e-01f, 3.04343015e-01f, 3.14465798e-02f, 1.86376676e-01f, 2.88043451e-02f, 1.06076337e-01f, -2.96615567e-02f, 5.82609251e-02f, 2.16293409e-01f, 1.04380660e-01f,
  -1.38598680e-01f, 2.97330078e-02f, -6.03803471e-02f, -1.57890171e-01f, 9.66669619e-02f, 1.47975981e-01f, -4.56820615e-02f, -1.20278923e-02f, 6.03289763e-03f, -3.87695059e-02f,
  -1.04347221e-03f, -2.94135660e-02f, 2.72865333e-02f, -6.38530776e-02f, -1.10865213e-01f, -1.52014390e-01f, 1.23722687e-01f, 4.24439386e-02f, -1.22589968e-01f, 1.90928206e-02f,
  3.59747618e-01f, -4.85388845e-01f, -3.70851308e-01f, -1.81874722e-01f, 4.31001991e-01f, 2.96747297e-01f, 1.50301993e-01f, -1.43466726e-01f, -4.31192160e-01f, -2.32271284e-01f,
  2.87246406e-01f, -1.13394760e-01f, -4.56380509e-02f, 2.02779561e-01f, 6.60148978e-01f, -1.84559450e-01f, 1.48231819e-01f, 1.26316324e-01f, -1.00194857e-01f, 1.14696778e-01f,
  2.24117786e-01f, 4.64967966e-01f, 8.61669257e-02f, 1.53879061e-01f, 2.96705216e-01f, -2.88909405e-01f, 1.73722312e-01f, -2.08557677e-02f, 1.73765957e-01f, 2.09290624e-01f,
  4.59244438e-02f, -9.17116851e-02f, 5.13894744e-02f, -1.58031538e-01f, -1.37052767e-03f, 1.10701792e-01f, 3.86330299e-02f, 8.64144322e-03f, -1.66270565e-02f, -5.27014472e-02f,
  -5.33944778e-02f, -7.59425014e-02f, -8.60294327e-02f, 4.84124795e-02f, 7.03390092e-02f, -1.45408139e-01f, -8.27734768e-02f, -9.81594622e-02f, -7.86617771e-02f, 2.79142186e-02f,
  -9.35187414e-02f, -1.42447919e-01f, 5.65745495e-02f, -1.65013850e-01f, -7.75568187e-02f, -1.15178078e-01f, -1.64299935e-01f, 6.37797490e-02f, -9.11702216e-02f, -1.00002922e-01f,
  -7.92271271e-03f, 5.94136566e-02f, 2.33619306e-02f, 3.15718609e-03f, 7.94627070e-02f, -1.41962856e-01f, 6.75794035e-02f, 1.12828068e-01f, -4.92291562e-02f, 1.06005901e-02f,
  6.46874234e-02f, 1.36469044e-02f, 1.76378880e-02f, 1.97572391e-02f, 3.31570655e-02f, -1.04641333e-01f, 7.79653527e-03f, 9.10097957e-02f, 4.83442321e-02f, 1.16412587e-01f,
  -8.75781998e-02f, 1.89700037e-01f, 2.73580309e-02f, 7.79436678e-02f, 6.61116987e-02f, -5.00802808e-02f, 2.52352003e-02f, -1.47834234e-02f, -3.89414728e-02f, 4.02923934e-02f,
  -1.04214223e-02f, -8.56210515e-02f, -7.41360113e-02f, 1.95704121e-02f, -2.04296615e-02f, 5.01874760e-02f, 2.17019059e-02f, -8.89203325e-02f, -7.98709840e-02f, 8.83768722e-02f,
  7.32894540e-02f, -1.22849949e-01f, -1.25321999e-01f, 9.50851589e-02f, -3.49023491e-02f, -1.06231950e-01f, -5.53746819e-02f, -1.42525211e-01f, -1.52660673e-03f, 1.44702056e-02f,
  -2.03155875e-02f, -2.49258392e-02f, -4.09406498e-02f, -8.29638764e-02f, -1.13748632e-01f, 4.48843651e-02f, 2.38441639e-02f, -9.15932804e-02f, 1.16927616e-01f, -1.27379149e-01f,
  2.17258438e-01f, -3.66134375e-01f, 2.39011005e-01f, 4.92298186e-01f, -1.45107254e-01f, 4.14836715e-04f, 4.18573588e-01f, -1.47153258e-01f, 2.31332287e-01f, -2.97904372e-01f,
  1.30507173e-02f, 1.34953707e-01f, 2.71868169e-01f, -1.61098570e-01f, 2.58288264e-01f, 3.47240061e-01f, 1.11792542e-01f, 1.97288558e-01f, 6.72308579e-02f, -4.01952006e-02f,
  5.70233949e-02f, -1.93016559e-01f, 1.79285988e-01f, -4.68365341e-01f, -2.16012135e-01f, -9.99041572e-02f, -1.29220888e-01f, 2.37814169e-02f, -2.54848421e-01f, 3.31363082e-02f,
  -1.09998630e-02f, 4.11225669e-02f, -1.18773617e-01f, -1.05100825e-01f, 1.16675533e-03f, -3.58934924e-02f, 9.26323086e-02f, 1.47298813e-01f, 8.46784040e-02f, -2.46249028e-02f,
  1.00732796e-01f, 5.58747277e-02f, -2.69054621e-02f, -2.97716316e-02f, -5.00935130e-04f, -1.02873974e-01f, 4.17367369e-02f, -7.64346421e-02f, -6.88673258e-02f, 5.01211695e-02f,
  -5.35008274e-02f, 2.99975518e-02f, 4.37860899e-02f, 7.56004974e-02f, 1.12035811e-01f, 9.17641371e-02f, 1.18353978e-01f, 1.11629255e-01f, 7.45256543e-02f, 7.89469630e-02f,
  5.57187684e-02f, -4.66862973e-03f, -8.46800879e-02f, -6.58713058e-02f, -5.34553416e-02f, -2.15435357e-04f, -7.88147300e-02f, -1.96200535e-02f, 1.17804036e-01f, 3.85559276e-02f,
  6.12894248e-04f, -4.51338179e-02f, -9.85290930e-02f, -2.82829385e-02f, 1.16229296e-01f, -5.26759624e-02f, 7.50756487e-02f, -2.02765130e-02f, -1.57522107e-03f, -1.11120656e-01f,
  2.20532045e-02f, 4.40150797e-02f, -6.19730493e-03f, 5.12908660e-02f, -2.98243463e-02f, 1.39669999e-01f, 1.02785071e-02f, -3.64013240e-02f, -2.55088247e-02f, 1.02668867e-01f,
  2.18549967e-01f, 2.59972930e-01f, 1.47853103e-02f, -3.91920321e-02f, 7.34244706e-03f, -1.52777016e-01f, -3.45081411e-04f, -6.71428367e-02f, 1.20822251e-01f, -6.78397790e-02f,
  -3.58701311e-02f, 5.60009070e-02f, 3.26016583e-02f, -7.62370378e-02f, 1.23111472e-01f, -1.39410079e-01f, 2.19612941e-01f, 1.08970460e-02f, 1.41740739e-01f, 1.48653388e-02f,
  -2.57174354e-02f, 5.91491051e-02f, 9.83419046e-02f, -3.81768085e-02f, -1.21045075e-02f, 1.09304108e-01f, 1.64358132e-02f, -6.98456690e-02f, 1.43322438e-01f, 1.11499272e-01f,
  2.06125185e-01f, 2.85596736e-02f, -2.59605497e-01f, -1.30064353e-01f, -2.65995622e-01f, -2.19560474e-01f, -2.77421683e-01f, -7.67821521e-02f, 2.61087924e-01f, 1.26744762e-01f,
  -3.30534935e-01f, 3.77559245e-01f, 8.73754993e-02f, -3.29807162e-01f, 1.68673649e-01f, 2.00994343e-01f, -1.02409005e-01f, 2.14122124e-02f, 1.22705042e-01f, -7.57492930e-02f,
  -9.24926177e-02f, -2.87679881e-01f, -2.69401491e-01f, -1.65620551e-01f, -3.50584418e-01f, -1.84071839e-01f, -2.33765811e-01f, -2.00734839e-01f, -3.86933804e-01f, -1.63294598e-01f,
  -1.86088115e-01f, 3.95654552e-02f, -6.99826106e-02f, 1.11574069e-01f, 4.76864167e-02f, 3.66190751e-03f, -1.28610894e-01f, -1.91915222e-02f, 7.06222057e-02f, 5.72900511e-02f,
  2.16733739e-01f, 8.74916688e-02f, 1.61207870e-01f, -1.26838610e-01f, -6.71979859e-02f, 6.84349891e-03f, 8.04233849e-02f, -8.86114407e-03f, 2.13120319e-03f, 1.51673323e-02f,
  2.72920430e-02f, 1.25020012e-01f, -5.09314835e-02f, 1.83145151e-01f, 2.96245050e-02f, -7.26138521e-03f, 1.02120496e-01f, -4.76180539e-02f, 1.09542862e-01f, 1.67969242e-01f,
  -7.83998668e-02f, -2.78180162e-03f, -1.11878864e-01f, -5.01359627e-02f, -2.19487678e-02f, -4.68113795e-02f, -6.98420545e-03f, -9.72461849e-02f, 4.91933785e-02f, -8.53018165e-02f,
  -3.65614332e-02f, -5.25335036e-02f, -7.66326562e-02f, 1.72816917e-01f, -4.65552025e-02f, -1.03708711e-02f, -3.65261734e-02f, 1.59057286e-02f, 3.06464173e-03f, 9.95456576e-02f,
  -5.15572615e-02f, 1.25990408e-02f, 6.45382504e-04f, -6.55652732e-02f, -1.53675988e-01f, 1.67109743e-01f, 4.40898985e-02f, 2.77247597e-02f, -1.14200357e-03f, 2.75834017e-02f,
  -4.04518135e-02f, 5.52947335e-02f, -2.18066759e-02f, 3.47546041e-02f, 1.54505828e-02f, 6.31344318e-02f, -5.75026236e-02f, 7.39769936e-02f, 2.02612430e-02f, 1.00632841e-02f,
  7.59457275e-02f, 1.10363044e-01f, 8.08223113e-02f, -2.28350729e-01f, 1.60467565e-01f, -6.63703904e-02f, 9.43592340e-02f, 1.40633419e-01f, 1.99610665e-01f, 6.66884333e-02f,
  6.57894313e-02f, 1.84776440e-01f, 2.12959409e-01f, 2.05236614e-01f, 1.51006788e-01f, 1.66348834e-02f, 1.52259141e-01f, -2.89207827e-02f, 8.29800218e-02f, 1.21135280e-01f,
  -2.05318376e-01f, 1.68047827e-02f, -3.91449094e-01f, -1.27428388e-02f, -6.59673512e-02f, 1.38297409e-01f, 2.65140712e-01f, -1.08578853e-01f, -1.87565103e-01f, 3.97787720e-01f,
  3.53684068e-01f, -3.00106555e-01f, 2.33483583e-01f, 3.46580207e-01f, -3.58050317e-01f, 1.75047502e-01f, 2.58947849e-01f, 2.50334114e-01f, -9.49761719e-02f, -3.93876955e-02f,
  -7.86775500e-02f, 4.58468974e-01f, -7.29017854e-02f, 9.56676975e-02f, 1.94672495e-02f, -1.81596696e-01f, 2.57506728e-01f, -1.77919582e-01f, 2.90137619e-01f, 3.20518464e-02f,
  1.69080079e-01f, -1.90060914e-01f, -6.06859177e-02f, -2.69261133e-02f, -1.74019504e-02f, 1.86257407e-01f, 1.81988597e-01f, -1.07051663e-01f, -1.16121322e-01f, 7.53050065e-03f,
  -7.18419477e-02f, -8.07816721e-03f, -1.59137473e-02f, -4.67847250e-02f, 1.24538928e-01f, -1.10015227e-03f, -2.10408811e-02f, -4.20192443e-02f, -4.13585342e-02f, -5.78979328e-02f,
  -6.11582361e-02f, -9.01024714e-02f, 2.22706292e-02f, -3.80366109e-02f, -1.51117474e-01f, -1.80420168e-02f, -9.92868990e-02f, -4.58219834e-02f, -2.97429934e-02f, -9.07955989e-02f,
  5.57394065e-02f, 8.67064521e-02f, 1.23315156e-01f, -6.52812887e-03f, -4.16706838e-02f, 5.05520497e-03f, 7.38168433e-02f, -8.71460512e-03f, -1.86284512e-01f, -5.77952294e-03f,
  -7.11613894e-03f, -5.94112389e-02f, 1.09431729e-01f, 8.45009759e-02f, 1.91599969e-02f, -7.61390552e-02f, -7.50867948e-02f, 2.85211615e-02f, -3.37455259e-03f, -1.13210045e-01f,
  9.42721218e-03f, 2.59475689e-02f, 6.80335704e-03f, 8.10800493e-02f, 8.64454135e-02f, -1.72196224e-01f, 1.34001136e-01f, -3.28233242e-02f, 6.71976507e-02f, 2.61273514e-02f,
  4.58081476e-02f, -8.53174925e-02f, -5.75254411e-02f, 2.58933883e-02f, -2.31260918e-02f, 4.91841435e-02f, 1.04840279e-01f, -7.30692819e-02f, -3.73145714e-02f, -8.36945102e-02f,
  1.24243591e-02f, 1.34862708e-02f, 7.44483396e-02f, -3.64642963e-02f, -8.84122327e-02f, 3.92150432e-02f, 9.23872590e-02f, -2.21166294e-02f, -4.53814529e-02f, -8.51805881e-02f,
  1.16967440e-01f, 4.36674803e-02f, -1.15792669e-01f, -3.31242941e-02f, 1.12008350e-02f, 9.96269807e-02f, -8.51380229e-02f, -9.21580568e-02f, 3.00080925e-02f, 3.44675817e-02f,
  -6.73127592e-01f, 2.70288605e-02f, 1.50700569e-01f, -1.84666574e-01f, -5.17971255e-02f, 2.61110425e-01f, 5.74701466e-02f, -4.13655974e-02f, -2.28683114e-01f, -1.12845205e-01f,
  -7.86872953e-02f, -1.23964474e-01f, 2.38999203e-02f, 2.73443192e-01f, 9.22958180e-02f, 2.25965023e-01f, 1.45085037e-01f, -4.27871235e-02f, -5.89650907e-02f, -2.20862493e-01f,
  2.24104058e-02f, 1.58749849e-01f, 1.34480938e-01f, 1.73471317e-01f, 8.44930578e-03f, -9.70158055e-02f, -7.64232427e-02f, 8.74487385e-02f, 1.50644302e-01f, 1.59571752e-01f,
  -2.44921610e-01f, -3.78258795e-01f, -2.15864688e-01f, -1.07897647e-01f, 1.01977009e-02f, -1.12112150e-01f, -1.15644252e-02f, 9.49962884e-02f, -1.92392953e-02f, 1.20848352e-02f,
  -4.64571677e-02f, 8.81279632e-02f, -4.75258566e-03f, -2.73288116e-02f, -1.24560840e-01f, 6.80475757e-02f, 1.01582043e-01f, 9.06054750e-02f, 1.59563613e-03f, 7.17697516e-02f,
  2.52217464e-02f, 4.83172797e-02f, 3.55698988e-02f, 1.55669883e-01f, 1.46519586e-01f, 3.90899135e-03f, 6.38855025e-02f, -2.53366269e-02f, 8.50254968e-02f, 3.43875401e-02f,
  6.36842102e-02f, 3.05686165e-02f, -7.05520287e-02f, -3.46647426e-02f, -4.63899970e-02f, 6.54974282e-02f, -5.67906909e-02f, -5.89580555e-03f, 4.14367355e-02f, -5.48960827e-03f,
  9.61008668e-03f, 4.02953811e-02f, -1.12350404e-01f, -7.87491444e-03f, -8.19406632e-05f, 4.83650900e-03f, -5.97074926e-02f, 2.69112014e-03f, 7.28403553e-02f, -7.46928481e-03f,
  -9.82376263e-02f, -1.06603421e-01f, 2.78365165e-02f, -1.93565004e-02f, -6.20897971e-02f, -1.35965571e-01f, 6.34553209e-02f, -9.12995823e-03f, -1.01984203e-01f, -1.57400612e-02f,
  -5.77650189e-01f, -4.81506139e-01f, 4.58032824e-03f, 2.22506374e-02f, -2.13545095e-02f, -9.04331654e-02f, -3.45709734e-02f, 2.92859245e-02f, -2.53672190e-02f, -5.74421659e-02f,
  -3.45011652e-02f, 1.27247497e-01f, -1.16005041e-01f, -8.44378844e-02f, 7.28039369e-02f, -2.36920230e-02f, -1.16705470e-01f, -7.58190379e-02f, -1.19566873e-01f, -2.99489293e-02f,
  -4.94389571e-02f, -7.62761012e-03f, 1.92022383e-01f, 4.28946614e-02f, 8.07461292e-02f, -9.29247588e-02f, -1.71854019e-01f, 9.22163017e-03f, 9.00733992e-02f, 1.10598348e-01f,
  -1.81248188e-01f, -3.41295272e-01f, 8.60130265e-02f, -3.19951415e-01f, 6.14959747e-02f, 4.30354416e-01f, 2.61166751e-01f, -8.87726322e-02f, -3.55985969e-01f, -4.60401438e-02f,
  -2.79414430e-02f, -1.61724821e-01f, 1.37820929e-01f, -4.58632767e-01f, 4.30626988e-01f, -7.84666911e-02f, -2.41902232e-01f, -7.84660727e-02f, -3.37412924e-01f, -3.06476168e-02f,
  -1.26902968e-01f, -3.39142978e-01f, -2.96152458e-02f, -3.44037682e-01f, -3.86488795e-01f, -1.37258887e-01f, 1.73040152e-01f, 2.08135486e-01f, -2.61400659e-02f, -1.23329267e-01f,
  -1.45124480e-01f, -2.52669483e-01f, -1.11612499e-01f, -8.76104739e-03f, 1.43020898e-01f, 5.35132997e-02f, 5.90606853e-02f, 8.77598599e-02f, 5.95071390e-02f, 1.94775816e-02f,
  6.45233691e-02f, -8.33165497e-02f, -1.66206732e-01f, 6.28637299e-02f, -1.30909234e-01f, -1.15140073e-01f, -9.18985754e-02f, -1.03974029e-01f, -1.25635669e-01f, 1.25173833e-02f,
  -1.40639246e-02f, 8.13227445e-02f, -1.47524118e-01f, -9.83420759e-03f, -7.08728507e-02f, -9.85703170e-02f, 1.71397954e-01f, 2.05639526e-01f, -1.43678695e-01f, 1.32848367e-01f,
  6.66035786e-02f, 6.33237511e-02f, 6.34353980e-02f, -1.52403817e-01f, -9.12997033e-03f, 1.35836992e-02f, -1.13562262e-02f, -9.34107602e-02f, -1.62903816e-02f, -1.39027208e-01f,
  -3.81533206e-02f, -1.03774043e-02f, -1.35199338e-01f, -3.43766212e-02f, -1.04650036e-02f, -2.95289187e-03f, 2.81981770e-02f, -1.29761209e-03f, -3.29927094e-02f, 1.03869379e-01f,
  -1.34000510e-01f, 2.33326592e-02f, 7.19748512e-02f, -1.99179109e-02f, 9.29456875e-02f, 1.29189119e-01f, -9.03270319e-02f, 1.17841668e-01f, -3.71483527e-02f, 6.72462881e-02f,
  2.30160609e-01f, 1.34888202e-01f, -1.43680841e-01f, -1.56177700e-01f, 1.90076027e-02f, 1.46208331e-01f, -1.78544387e-01f, -1.64111361e-01f, 1.45479620e-01f, -1.02274250e-02f,
  5.70854768e-02f, 2.35001352e-02f, -2.85587199e-02f, -7.78864697e-02f, 7.72466362e-02f, 3.85122783e-02f, -2.06132829e-02f, 4.12126891e-02f, 8.56235027e-02f, 9.09390207e-03f,
  -4.38740291e-02f, -5.14587667e-03f, -9.17855203e-02f, -1.25309199e-01f, -1.76505521e-01f, 1.39329597e-01f, 8.90360996e-02f, 4.03478108e-02f, -3.60159725e-02f, 2.62449905e-02f,
  -1.70122117e-01f, -3.65964025e-01f, -1.40033504e-02f, 1.65490806e-01f, 8.97569135e-02f, -2.54662544e-01f, -1.90185860e-01f, 1.52045950e-01f, 3.83140221e-02f, -2.44701654e-01f,
  -1.54234603e-01f, -1.46212220e-01f, -4.42580163e-01f, -1.97645515e-01f, -1.47432950e-03f, -6.15248084e-01f, 3.01632851e-01f, -1.42421588e-01f, -8.27264711e-02f, 1.91442147e-01f,
  2.07369059e-01f, 7.86485076e-02f, 3.41152668e-01f, 3.60032737e-01f, 4.82712314e-02f, 2.99052119e-01f, 4.66600984e-01f, 1.26216829e-01f, 3.93185019e-01f, 5.37652485e-02f,
  -3.12134270e-02f, -9.58819762e-02f, -3.67474109e-02f, -4.58738171e-02f, 1.71954215e-01f, 3.52425538e-02f, 1.19125478e-01f, -7.61511624e-02f, 1.08805194e-01f, -3.09659746e-02f,
  6.31802157e-02f, 5.46194650e-02f, -1.04093231e-01f, -2.84994040e-02f, 8.57141763e-02f, -3.21301036e-02f, 7.23151118e-02f, 7.10596591e-02f, 1.05703093e-01f, -2.20661853e-02f,
  3.97919640e-02f, -9.69014093e-02f, 1.68311983e-01f, -3.62964696e-03f, 9.70884040e-02f, 9.38577205e-02f, -4.61703427e-02f, 1.12637714e-01f, -4.95543070e-02f, 7.58230090e-02f,
  1.00730591e-01f, -1.61172584e-01f, -9.42397565e-02f, -1.85641974e-01f, -1.27299756e-01f, -3.42894718e-02f, -5.68136647e-02f, -7.26504624e-02f, 5.68314232e-02f, 3.77825997e-03f,
  -1.45583209e-02f, -2.25120038e-02f, -2.14064680e-02f, -3.81296426e-02f, -2.39763930e-02f, 9.69139300e-03f, 5.54789677e-02f, -8.00314769e-02f, 1.35014504e-01f, -1.47900926e-02f,
  -1.36314586e-01f, 1.55501589e-02f, -8.66860989e-03f, 8.96661878e-02f, -1.32371679e-01f, 2.64182519e-02f, 8.58165398e-02f, -9.19752270e-02f, 3.82311828e-02f, 4.48703356e-02f,
  1.39723375e-01f, 4.43151444e-02f, 1.08455271e-02f, -7.42361764e-04f, -1.11521140e-01f, -1.49528623e-01f, -7.25979656e-02f, 5.60704432e-03f, -5.33269194e-04f, -6.49872720e-02f,
  2.51199812e-01f, 9.16440636e-02f, -1.65439993e-01f, -3.24381702e-02f, 2.17800111e-01f, 5.59561588e-02f, 7.18345046e-02f, 1.18695632e-01f, 1.80351451e-01f, 2.43861005e-01f,
  1.77167431e-02f, -1.23438686e-01f, 9.54644978e-02f, 5.62915802e-02f, 3.32631245e-02f, 1.16946846e-01f, -1.40280828e-01f, 1.22758806e-01f, 4.87139337e-02f, -7.88706392e-02f,
  -7.35555172e-01f, 3.27461332e-01f, 2.59745747e-01f, -3.22749615e-01f, -3.14787805e-01f, 3.89774591e-01f, 8.00213963e-02f, 1.57003671e-01f, 9.13517699e-02f, 3.26088101e-01f,
  -5.39601333e-02f, -1.03493527e-01f, 3.78456831e-01f, -2.05533486e-02f, 3.86371389e-02f, 4.70547944e-01f, 9.99744758e-02f, 3.48870270e-02f, -3.49975154e-02f, -3.78686301e-02f,
  -1.42087325e-01f, -2.48189852e-01f, 3.41195688e-02f, -2.89582554e-02f, -3.60752106e-01f, -2.26304948e-01f, -3.85876685e-01f, -1.14224022e-02f, -3.72658700e-01f, -1.94686905e-01f,
  -2.46805340e-01f, -3.08259755e-01f, -6.12954050e-02f, 7.68294856e-02f, -7.68680871e-02f, 4.85875718e-02f, -3.87051702e-02f, 3.40053774e-02f, -1.68394685e-01f, 4.34707524e-03f,
  7.64255002e-02f, 2.36755572e-02f, -1.82011157e-01f, 8.21271539e-02f, -2.63327118e-02f, -9.46963206e-02f, -4.80682254e-02f, -1.57626756e-02f, -8.97094905e-02f, 7.23919133e-04f,
  8.16245228e-02f, 4.26957421e-02f, -3.47561948e-02f, -1.85852572e-02f, -1.73629552e-01f, -2.38746740e-02f, 4.76300642e-02f, -3.41772288e-02f, -1.30218610e-01f, -8.60571861e-02f,
  -5.85595705e-02f, 1.17514566e-01f, 9.94107649e-02f, 1.17325373e-01f, -2.83969250e-02f, -8.86038840e-02f, 7.78369233e-02f, -3.88791524e-02f, 1.32615007e-02f, -3.22044753e-02f,
  -1.30659953e-01f, 4.98320386e-02f, -3.52578536e-02f, 5.81748001e-02f, 4.04735170e-02f, 1.09870359e-01f, -2.51585990e-02f, -4.70102988e-02f, 8.50827545e-02f, -1.89909968e-03f,
  -3.85454185e-02f, -1.39582023e-01f, -1.93682700e-01f, 1.31380428e-02f, 5.56191057e-02f, 4.43116874e-02f, 6.57735094e-02f, 5.09313233e-02f, 1.77748669e-02f, -8.53869170e-02f,
  -2.39765614e-01f, -3.18415433e-01f, -2.60154717e-02f, -1.09910041e-01f, 1.66239634e-01f, 5.73979095e-02f, 9.81322676e-02f, 4.36399542e-02f, -4.23991755e-02f, 8.88521224e-02f,
  5.20250238e-02f, -6.08226061e-02f, -1.01814359e-01f, 7.79156685e-02f, 9.10131931e-02f, 7.52140209e-02f, -9.42882076e-02f, 9.70164388e-02f, -4.75515723e-02f, -4.40921411e-02f,
  3.75143215e-02f, 7.30565339e-02f, 1.72193706e-01f, -1.07795894e-01f, -9.96647682e-03f, -3.64662595e-02f, -1.25570297e-01f, 6.53924346e-02f, -1.32507071e-01f, 2.38324292e-02f,
  -2.25528851e-01f, 1.37211174e-01f, 7.85527527e-02f, -1.25126675e-01f, -3.26572329e-01f, -3.61558467e-01f, -4.32621539e-01f, 7.67544983e-03f, -1.60601929e-01f, -1.49740681e-01f,
  -1.91035464e-01f, 1.14256311e-02f, 1.88359082e-01f, -7.18975887e-02f, 2.52080739e-01f, 3.68319482e-01f, 9.44481641e-02f, -2.57291812e-02f, 3.52981478e-01f, 2.19682232e-01f,
  2.06997588e-01f, -1.63942445e-02f, 4.79284197e-01f, 2.07636848e-01f, 4.82087880e-02f, 2.58016258e-01f, 2.48129830e-01f, 1.21102899e-01f, -7.53518716e-02f, -6.70617819e-02f,
  -3.32613140e-02f, 1.16252035e-01f, 1.00071475e-01f, 5.08312322e-02f, 1.95804998e-01f, -2.02256098e-01f, -1.00237556e-01f, 2.84555461e-02f, -1.44172177e-01f, -3.28529589e-02f,
  4.46549058e-03f, 1.22919707e-02f, 4.11189981e-02f, -7.17712566e-02f, -3.08452427e-01f, -2.92978492e-02f, 1.59609541e-01f, 7.53946677e-02f, 3.80393863e-02f, 4.00818586e-02f,
  5.57165109e-02f, 8.16151872e-02f, -1.08004786e-01f, 3.26237716e-02f, 7.13948458e-02f, -6.89605623e-02f, -4.84721549e-02f, 5.55220386e-03f, 1.08179925e-02f, -1.00179940e-01f,
  7.82333408e-03f, -2.04195529e-02f, 9.52298474e-03f, -2.14216541e-02f, 1.78359766e-02f, 1.39453653e-02f, -1.72666728e-01f, 4.07892652e-02f, 3.78806479e-02f, -2.71565141e-03f,
  -4.16319072e-02f, 2.28231549e-02f, -6.93932222e-03f, -6.82707727e-02f, -4.17013094e-02f, -5.65026328e-03f, 7.37841427e-02f, 6.04888424e-03f, -5.68702817e-02f, 7.15260506e-02f,
  -4.03872319e-02f, -2.64333993e-01f, 2.90110577e-02f, -2.96517294e-02f, -1.09137699e-01f, 7.96786398e-02f, -4.36749868e-02f, -3.72109488e-02f, 1.66462779e-01f, 6.62270114e-02f,
  2.16016024e-01f, 3.20840806e-01f, 2.15680450e-01f, -3.50802913e-02f, 1.35653734e-01f, 5.80121987e-02f, 1.15736444e-02f, -3.36852558e-02f, 1.02162592e-01f, 3.45037784e-03f,
  -8.14064667e-02f, -3.80987041e-02f, 1.12453051e-01f, -7.51805380e-02f, 2.88433135e-02f, 1.02747314e-01f, -2.14182846e-02f, 4.19533625e-03f, 8.16021021e-03f, 1.63693547e-01f,
  5.17433509e-02f, -3.05622462e-02f, -8.45445096e-02f, 7.54796118e-02f, -1.34780943e-01f, 5.89909405e-02f, 5.91683015e-02f, 2.13208352e-03f, -7.78029952e-03f, 1.60295945e-02f,
  -7.80322134e-01f, 3.78895819e-01f, 2.90130347e-01f, -1.01876423e-01f, -1.79596677e-01f, 3.88510883e-01f, 1.33355364e-01f, 5.76983057e-02f, 2.54917949e-01f, 2.76608676e-01f,
  -7.31213242e-02f, -2.06018165e-01f, 1.95869729e-01f, 4.79269698e-02f, -1.76845267e-01f, 3.79672855e-01f, 2.11693272e-01f, 1.58008814e-01f, 1.45343736e-01f, -2.57883817e-01f,
  -2.19727397e-01f, -1.60902709e-01f, -7.73594379e-02f, 2.90226433e-02f, -1.37728572e-01f, -9.06707197e-02f, -1.58881694e-01f, 5.92638701e-02f, -6.53752312e-02f, 1.31778508e-01f,
  -1.81201443e-01f, -1.45410314e-01f, -3.02864641e-01f, 8.12831335e-03f, -2.15810791e-01f, 8.76527745e-03f, 7.72570968e-02f, -7.57516325e-02f, -2.85287108e-02f, -4.25059088e-02f,
  4.87491116e-02f, -7.50238374e-02f, -1.22715183e-01f, 7.91732669e-02f, -2.89823133e-02f, -9.85895842e-02f, -4.06608880e-02f, 3.52808973e-03f, -6.76420853e-02f, 5.91278309e-03f,
  -1.41248941e-01f, -1.17161889e-02f, 5.03268875e-02f, 1.28671238e-02f, -3.77850085e-02f, 1.19002126e-01f, 6.20657690e-02f, -2.99626235e-02f, -6.40213937e-02f, 3.28573175e-02f,
  3.80196534e-02f, 1.02046154e-01f, -1.10994235e-01f, 2.11701058e-02f, -6.95280284e-02f, -1.42647833e-01f, -2.39757020e-02f, -1.67946443e-01f, 5.46758659e-02f, -3.50584611e-02f,
  -4.52073887e-02f, -1.21198483e-01f, 2.71982346e-02f, -3.00553180e-02f, 1.39572658e-02f, -6.11275323e-02f, -1.06609695e-01f, -8.41434449e-02f, -2.43893191e-02f, -5.23781255e-02f,
  5.58859855e-02f, 9.58739817e-02f, -7.60144591e-02f, -1.06426105e-02f, 7.90778641e-03f, -2.55464800e-02f, 3.62510756e-02f, -6.25735521e-02f, 1.50797218e-02f, 1.32085025e-01f,
  1.75838023e-02f, 1.06967390e-01f, -1.29627600e-01f, -2.82592416e-01f, -2.99132913e-02f, -6.38503805e-02f, 1.07840776e-01f, -8.89573246e-02f, 8.53000879e-02f, -2.29834784e-02f,
  3.75860222e-02f, -3.37709226e-02f, -5.51276281e-02f, 6.21356480e-02f, -1.29787019e-02f, 3.76169644e-02f, -8.39650854e-02f, 5.73399924e-02f, -6.07561842e-02f, -9.85999852e-02f,
  -2.58714974e-01f, -1.75289121e-02f, 9.83846039e-02f, -1.01455010e-01f, -5.14297299e-02f, -5.89709207e-02f, -1.67307630e-01f, 5.80948684e-03f, -2.69914512e-02f, 9.79547203e-02f,
  -2.26739228e-01f, 3.06461036e-01f, -1.03518635e-01f, -1.60714462e-01f, 2.29908720e-01f, -2.20869824e-01f, -3.26879546e-02f, 1.40124485e-01f, 7.11538689e-03f, 2.37860903e-01f,
  -6.17509000e-02f, 9.11824554e-02f, 2.05574781e-02f, -2.94313073e-01f, -6.81336701e-01f, -2.88125873e-01f, -4.49131876e-01f, -1.17826067e-01f, -8.55034143e-02f, -1.10430485e-02f,
  -9.08803642e-02f, -1.66434735e-01f, -2.94564188e-01f, 4.65935558e-01f, 2.33317956e-01f, 2.85309255e-01f, -3.35788950e-02f, 3.35773587e-01f, -3.13304886e-02f, 1.50815144e-01f,
  -8.12657699e-02f, 1.27876282e-01f, 4.00753655e-02f, -1.10859107e-02f, -9.13181007e-02f, 7.27169635e-03f, -1.07075840e-01f, -1.08593255e-01f, -7.15104714e-02f, -5.51318750e-02f,
  -1.33454325e-02f, 2.40355469e-02f, 1.10430447e-02f, 1.18911773e-01f, 1.14708133e-01f, 7.76278302e-02f, -6.78980276e-02f, 1.87896695e-02f, 8.72005895e-02f, -9.10720602e-02f,
  -8.99270475e-02f, -1.23981506e-01f, -9.41155553e-02f, -1.36035085e-02f, -4.56948131e-02f, 1.47817060e-01f, -1.72571689e-02f, -1.12389745e-02f, 2.29794290e-02f, -5.27192503e-02f,
  9.04840454e-02f, 4.26845662e-02f, 8.01573768e-02f, 7.50608742e-02f, -2.12316066e-02f, -2.64638606e-02f, 1.75159406e-02f, -3.19084637e-02f, 3.32951955e-02f, 4.38920222e-03f,
  3.38262767e-02f, -4.55562919e-02f, -3.28551792e-02f, -2.35652942e-02f, -8.12990442e-02f, -5.89486659e-02f, 1.23813413e-02f, -6.55028131e-03f, -1.54036075e-01f, -3.19235958e-02f,
  2.56410781e-02f, -9.63150188e-02f, 9.16505978e-02f, 2.36989073e-02f, -6.19647615e-02f, 1.05561934e-01f, -3.24207582e-02f, -5.63386641e-02f, -7.92287067e-02f, 7.21456558e-02f,
  -1.68686315e-01f, -9.97211114e-02f, -1.03927618e-02f, 4.32217158e-02f, -1.51126385e-02f, -8.32805783e-02f, -6.67796582e-02f, -1.42040569e-02f, -1.16172716e-01f, -8.50288942e-03f,
  -4.16798629e-02f, 2.99893282e-02f, 5.53330332e-02f, 3.18270409e-03f, -9.96082798e-02f, -1.57219857e-01f, -9.24756899e-02f, 5.65484129e-02f, 2.02761665e-02f, 4.47075292e-02f,
  1.32752946e-02f, 4.74799015e-02f, -2.99824476e-02f, 7.92614743e-02f, 3.37762274e-02f, 2.97065638e-02f, 1.93226919e-01f, 1.10139228e-01f, -1.30030841e-01f, -3.33569050e-02f,
  1.26655594e-01f, -2.52967030e-01f, 4.27459300e-01f, -9.08470154e-02f, 2.08943933e-01f, 3.95377129e-01f, 2.89779842e-01f, 8.08853284e-02f, 2.56355554e-01f, -4.46873456e-01f,
  -2.62951314e-01f, -1.54749125e-01f, 1.40187919e-01f, -2.92710096e-01f, 5.54676235e-01f, 3.00892353e-01f, -1.94939487e-02f, -2.26665735e-02f, 1.24829598e-01f, 1.59957167e-03f,
  1.99412946e-02f, -2.74346352e-01f, -4.04172726e-02f, -3.39130729e-01f, -1.08060993e-01f, -2.54382789e-01f, -3.23944658e-01f, 1.59191579e-01f, -3.89508933e-01f, 1.11343734e-01f,
  -4.26825434e-02f, -9.42088068e-02f, -1.05665810e-01f, -2.90385596e-02f, -7.84498081e-02f, 6.76651448e-02f, 1.54024720e-01f, 1.89655706e-01f, -2.40327865e-02f, -7.13092908e-02f,
  2.48021237e-03f, 1.39470529e-02f, -2.08180845e-01f, -7.97330402e-03f, 5.88736087e-02f, -4.37358841e-02f, -1.53553756e-02f, -3.48696187e-02f, -1.57263111e-02f, 1.46574914e-01f,
  1.31412894e-01f, 4.24994482e-03f, 5.30816428e-02f, -3.27156112e-02f, -1.85386371e-02f, -8.31696019e-02f, 6.32523298e-02f, 7.29203671e-02f, -1.43333431e-02f, 1.56736858e-02f,
  5.91726266e-02f, 1.30383581e-01f, -3.98980789e-02f, -5.00668585e-02f, -3.77675146e-02f, -4.82565090e-02f, -5.19401543e-02f, -1.30511507e-01f, 1.24110794e-03f, -3.59675884e-02f,
  -7.99636692e-02f, -6.12556338e-02f, 1.51069254e-01f, 1.09071076e-01f, -2.67097279e-02f, -4.65442240e-03f, -6.08192980e-02f, 6.76436830e-05f, -5.51492581e-03f, -1.52923772e-02f,
  9.57961157e-02f, -2.40632519e-02f, -8.67914930e-02f, 2.04398315e-02f, 1.61871146e-02f, 3.14587615e-02f, 3.49078514e-03f, 7.95508623e-02f, -1.58955175e-02f, 7.76713938e-02f,
  -1.95082128e-01f, -2.04127133e-01f, -1.38518408e-01f, -1.53443485e-01f, -2.08626166e-02f, -9.29185897e-02f, 1.39036268e-01f, -6.35680556e-02f, 2.59552039e-02f, 2.56720129e-02f,
  5.72952963e-02f, -1.11952916e-01f, -3.42196152e-02f, 3.30568217e-02f, -5.13044894e-02f, 3.54559831e-02f, -8.30718130e-03f, -1.10744141e-01f, -1.63503245e-01f, -6.23577051e-02f,
  -1.01376690e-01f, -5.23675829e-02f, 9.30000246e-02f, -1.53069094e-01f, -1.04109354e-01f, -9.88309309e-02f, -1.01443209e-01f, -2.63150875e-02f, 7.43175074e-02f, 3.58324982e-02f,
  -2.48143926e-01f, -2.92292297e-01f, -4.22733217e-01f, -4.90835965e-01f, 3.04818302e-01f, 3.36284816e-01f, -4.66015249e-01f, -1.66214213e-01f, -4.29002345e-01f, -1.08723275e-01f,
  -6.24626130e-02f, -2.71118939e-01f, -5.44703186e-01f, -9.00245737e-03f, 2.86511537e-02f, -1.65765330e-01f, 1.02889240e-01f, 8.68554190e-02f, 1.45540640e-01f, -6.72238693e-03f,
  3.80148962e-02f, 2.35907450e-01f, -2.20611259e-01f, 3.69807214e-01f, -7.85506219e-02f, 7.56194144e-02f, 1.66805625e-01f, -4.10103314e-02f, 1.93722367e-01f, 1.03886865e-01f,
  5.81044219e-02f, -1.31282836e-01f, -2.13016029e-02f, -2.90841218e-02f, -8.68167654e-02f, 2.91493889e-02f, 5.32395765e-02f, 3.17869224e-02f, -1.54681444e-01f, -1.70266908e-02f,
  -1.38486803e-01f, -4.08948213e-02f, 3.25376540e-02f, 7.25075603e-02f, 1.26168150e-02f, 1.32586807e-02f, -2.83278059e-02f, 7.36516044e-02f, -4.26144488e-02f, -1.52217805e-01f,
  -1.13613322e-01f, -8.14079307e-04f, 2.06085797e-02f, -1.42088518e-01f, -2.36545101e-01f, -4.67302911e-02f, 5.82779348e-02f, -4.55411971e-02f, 4.13054377e-02f, -6.40314445e-02f,
  -2.17852499e-02f, 2.04296671e-02f, 1.83366183e-02f, -1.09468564e-01f, -3.41713615e-02f, 4.53315265e-02f, 1.56223938e-01f, 2.39643417e-02f, -6.10802369e-03f, 1.71657447e-02f,
  -1.42484024e-01f, 2.82528847e-02f, 2.33827792e-02f, 1.60152823e-01f, 3.72413658e-02f, 1.76380098e-01f, 1.32481679e-01f, 6.47721579e-03f, -2.28645831e-01f, 6.52282238e-02f,
  8.53920653e-02f, 1.68214366e-01f, -7.44075626e-02f, 1.54515021e-02f, 6.60639107e-02f, -6.54861331e-02f, 4.67543118e-02f, 3.26197036e-02f, 1.37673974e-01f, -1.08817801e-01f,
  -6.69622514e-03f, -2.47726403e-02f, -8.24949518e-02f, 7.06320107e-02f, 1.67925339e-02f, 7.75615722e-02f, 1.64717920e-02f, -1.15927018e-03f, -2.38855798e-02f, 8.28007683e-02f,
  -2.24035196e-02f, -3.33081884e-03f, 2.20907733e-01f, 7.41698816e-02f, 5.53377271e-02f, -3.66822667e-02f, -6.00745855e-03f, 6.25397861e-02f, -2.68683247e-02f, 4.23593782e-02f,
  1.47362752e-02f, 1.34549186e-01f, -1.56584442e-01f, 3.66770960e-02f, -7.50115365e-02f, -6.96991086e-02f, 1.83140472e-01f, -2.45399550e-02f, 1.25873685e-02f, -7.55199641e-02f,
  3.26044410e-01f, -1.34467140e-01f, -3.22176248e-01f, 1.72959998e-01f, 1.59049317e-01f, 8.45536813e-02f, -9.47294235e-02f, 1.06569409e-01f, -3.87633473e-01f, -6.24488778e-02f,
  1.88863009e-01f, 3.96877620e-03f, -1.76186159e-01f, 4.37780231e-01f, 4.22432423e-01f, -1.13675363e-01f, 2.91275412e-01f, 1.58397183e-01f, -2.44660199e-01f, 3.25587951e-02f,
  9.06452909e-02f, 5.11485815e-01f, 1.21049270e-01f, 3.15082222e-01f, 3.90835553e-01f, -4.36285026e-02f, 4.18708146e-01f, -3.61347832e-02f, 2.72392690e-01f, 3.76584232e-01f,
  -1.57012269e-02f, 2.49940269e-02f, -1.03531465e-01f, 2.54167262e-02f, 1.00617953e-01f, 1.01109877e-01f, 7.73702562e-02f, 2.69024611e-01f, -4.45986539e-02f, 1.66354254e-02f,
  1.41807288e-01f, 1.32688075e-01f, 1.74702387e-02f, 9.63151008e-02f, -6.57071024e-02f, 2.93143392e-02f, -1.71639323e-01f, 2.01451033e-03f, -2.00040206e-01f, 2.21781284e-02f,
  -1.04954682e-01f, -8.19070786e-02f, 1.18311681e-01f, 6.12610057e-02f, -1.60376340e-01f, -5.35473004e-02f, -1.49799481e-01f, -2.89192218e-02f, 4.94178124e-02f, 3.87509689e-02f,
  1.86415911e-01f, 1.01043046e-01f, -4.46958700e-03f, -4.92974110e-02f, -7.09039643e-02f, -9.99327097e-03f, -9.97749157e-03f, -1.06851704e-01f, -2.58460082e-02f, -3.93390507e-02f,
  -1.35401711e-01f, 3.99474166e-02f, -8.65032990e-03f, 3.64447795e-02f, 7.29354098e-02f, 3.43795796e-03f, 3.78404520e-02f, 6.40261173e-02f, -1.99819624e-01f, -6.50563613e-02f,
  6.11245371e-02f, -7.51514807e-02f, -1.38499469e-01f, 3.01742135e-03f, -6.24537375e-03f, -1.87078621e-02f, 7.72756115e-02f, -1.70239583e-02f, 1.75122544e-02f, 2.36820608e-01f,
  -2.66574845e-02f, 3.92292514e-02f, -1.47916570e-01f, -7.68600479e-02f, -7.00127557e-02f, 6.61153570e-02f, 7.93897957e-02f, 1.78108647e-01f, 5.75326830e-02f, -8.63014013e-02f,
  1.66319281e-01f, -3.79558019e-02f, -2.92057618e-02f, 4.05367799e-02f, 1.25272833e-02f, -9.06015094e-03f, -2.44969688e-02f, -1.65015329e-02f, 3.16361152e-02f, -2.42752265e-02f,
  1.04781374e-01f, -5.15321493e-02f, 1.32214725e-01f, -1.31587818e-01f, 2.26866696e-02f, -4.16208990e-02f, -7.73236826e-02f, 2.05691252e-02f, 3.08585502e-02f, -2.76393238e-02f,
  -8.39664787e-02f, 1.21541567e-01f, 4.82948244e-01f, -1.87543631e-01f, 7.38884928e-03f, 1.84791982e-01f, -2.51165450e-01f, 1.15057737e-01f, -4.27015126e-02f, 1.89653069e-01f,
  -2.11752772e-01f, 1.07021049e-01f, -3.18256378e-01f, 1.21579023e-05f, -3.18398744e-01f, -3.20363849e-01f, -1.14551850e-01f, -1.01524875e-01f, -2.29690030e-01f, -6.76900670e-02f,
  -1.39065847e-01f, -4.12810683e-01f, 1.60253167e-01f, -1.39640656e-03f, 2.56698251e-01f, 3.16016793e-01f, -1.21919990e-01f, -7.03116087e-03f, 2.24939734e-01f, 9.21456795e-03f,
  -3.96275036e-02f, -1.10301204e-01f, 2.05237463e-01f, 7.52286687e-02f, 4.65895459e-02f, 2.14628056e-02f, 1.04333714e-01f, -3.84209096e-03f, -3.53205204e-02f, 1.33081242e-01f,
  1.11386500e-01f, 1.82270810e-01f, 7.07971537e-03f, -1.17865853e-01f, 6.61525428e-02f, 1.44055570e-02f, 1.33286849e-01f, 1.04420759e-01f, 9.11466032e-02f, 7.34713972e-02f,
  6.84626102e-02f, 2.69285947e-01f, 1.07064791e-01f, -1.46309296e-02f, 1.22090407e-01f, 8.89850184e-02f, 7.62187466e-02f, 2.12472603e-01f, -5.94302081e-02f, 1.25149295e-01f,
  4.79655340e-02f, -8.52543414e-02f, -1.02559470e-01f, -7.33745098e-02f, -1.40211314e-01f, -2.17921156e-02f, -1.16259359e-01f, -2.08535381e-02f, -3.90811870e-03f, 4.52982970e-02f,
  3.96464951e-02f, -4.16126475e-02f, -6.17615432e-02f, 1.04597785e-01f, -5.77958077e-02f, -1.41528651e-01f, 3.55374552e-02f, 3.76140773e-02f, 2.33101714e-02f, 1.24117415e-02f,
  -1.79779321e-01f, -7.70924538e-02f, -7.74133280e-02f, 3.69368605e-02f, 5.91977267e-03f, 7.02471286e-02f, 1.30812064e-01f, 2.93706562e-02f, -4.22204956e-02f, -7.21605867e-02f,
  -1.36365950e-01f, -1.57060891e-01f, -8.90601333e-03f, -5.27868271e-02f, -1.18908085e-01f, -8.09312016e-02f, 3.82255614e-02f, 1.18590854e-01f, -4.86814380e-02f, -1.08030558e-01f,
  2.08031103e-01f, 8.35347474e-02f, 4.07089032e-02f, -3.61287780e-02f, 3.26366164e-02f, -2.22233515e-02f, -1.06059365e-01f, -2.04642117e-02f, 1.19705498e-01f, 6.46080226e-02f,
  -2.92024929e-02f, 7.54269632e-03f, -1.32691278e-03f, -1.98369604e-02f, 2.96291001e-02f, 3.22095193e-02f, -8.67323801e-02f, 1.28478169e-01f, -6.40014932e-02f, 7.58066699e-02f,
  -2.66660780e-01f, -2.06027687e-01f, 1.72597691e-01f, -3.65464777e-01f, 2.22479105e-01f, -1.69415493e-02f, 1.85379580e-01f, -3.21195990e-01f, -3.51794481e-01f, -2.72616476e-01f,
  -4.19834889e-02f, 2.00008646e-01f, 4.06212747e-01f, -4.60151285e-01f, 1.75753415e-01f, 1.41615212e-01f, -4.76645499e-01f, -1.73326433e-01f, -4.47550118e-02f, -2.31179610e-01f,
  -1.63699985e-01f, -2.96224147e-01f, 1.26181766e-01f, -2.97861040e-01f, -2.05767512e-01f, -2.06684679e-01f, 4.61451374e-02f, 3.20975870e-01f, -3.37090731e-01f, 1.49654463e-01f,
  -1.83362976e-01f, -3.11642766e-01f, 2.58735996e-02f, -7.71015957e-02f, -5.28952591e-02f, 7.44261965e-02f, 1.23021724e-02f, 2.23435000e-01f, 4.87635918e-02f, 6.58572931e-03f,
  1.93881497e-01f, -2.35762075e-02f, -6.01358600e-02f, 1.00376122e-01f, -1.03389524e-01f, -4.82361689e-02f, 3.15516884e-03f, -6.53503686e-02f, -6.47582561e-02f, 4.60376553e-02f,
  6.83086962e-02f, -2.47180462e-02f, -5.79497367e-02f, 3.61379832e-02f, 1.02377206e-01f, -5.01270555e-02f, -4.45369594e-02f, 1.85470760e-01f, -6.57288879e-02f, -1.96495757e-01f,
  -8.90656561e-02f, -2.56864466e-02f, 2.89943721e-02f, -2.35244352e-02f, -3.19065992e-03f, 6.29019588e-02f, 5.26077673e-02f, -2.04107296e-02f, 4.80074659e-02f, -3.77420038e-02f,
  -9.04957429e-02f, 3.63353454e-02f, -1.01458251e-01f, -4.82287221e-02f, -3.55119482e-02f, -9.64720920e-02f, 2.34097064e-01f, 3.07583604e-02f, -7.92315602e-02f, -3.36172879e-02f,
  4.89072688e-02f, -6.22765198e-02f, 4.66960557e-02f, 6.65716380e-02f, -3.55026424e-02f, 4.76730205e-02f, -1.86220948e-02f, 4.03554030e-02f, 9.15826391e-03f, 1.48113891e-01f,
  -1.35549381e-01f, -3.74766111e-01f, 2.13639904e-02f, -2.86569316e-02f, 4.24588360e-02f, 2.12251749e-02f, -9.49992519e-03f, -1.09687142e-01f, -1.48907944e-03f, -2.21844781e-02f,
  -7.70266950e-02f, 3.13775986e-02f, -1.17696822e-01f, -3.38177271e-02f, 1.84129719e-02f, 1.54760648e-02f, 1.39294639e-01f, 7.55792856e-02f, 6.02085739e-02f, -7.20118284e-02f,
  -5.53181907e-03f, -5.82959652e-02f, 8.94479454e-02f, -7.66177028e-02f, -2.81372704e-02f, 1.26953945e-01f, -2.21024454e-02f, -8.62286612e-02f, 7.02253506e-02f, 3.28721069e-02f,
  -6.57180011e-01f, 3.11613381e-01f, -2.63587594e-01f, -1.76195428e-01f, -2.44208187e-01f, -1.43377885e-01f, 1.23763435e-01f, 1.70695335e-01f, 2.42111206e-01f, 3.68357331e-01f,
  1.09797023e-01f, 1.54893726e-01f, 4.95564371e-01f, 1.01649709e-01f, -3.11036855e-01f, 2.90072590e-01f, -1.84336409e-01f, 2.86609530e-02f, -4.66077216e-02f, 6.38112426e-02f,
  -5.51305003e-02f, 1.49528295e-01f, -2.43295401e-01f, 1.25266045e-01f, -4.06824410e-01f, -2.88163036e-01f, -3.46183985e-01f, -3.40204798e-02f, -4.41260785e-01f, -2.19484225e-01f,
  -5.53090930e-01f, -1.53532967e-01f, -9.18867067e-02f, -2.18043432e-01f, -2.20287621e-01f, -1.14388593e-01f, -2.15715989e-01f, 5.90932369e-02f, -6.88118339e-02f, -1.16807453e-01f,
  1.01241089e-01f, -5.16192801e-02f, -1.67194735e-02f, 1.70950308e-01f, -3.75536047e-02f, -1.22573055e-01f, -1.46836951e-01f, -1.75682589e-01f, 6.42066821e-02f, -4.21796702e-02f,
  9.84274670e-02f, -4.63402830e-02f, -1.48192927e-01f, -7.90277496e-02f, -3.56152713e-01f, -1.08375616e-01f, -8.57833028e-02f, -1.43724963e-01f, -1.77063391e-01f, -2.18867451e-01f,
  3.07572819e-02f, -4.34727557e-02f, 2.19993833e-02f, 4.92412038e-03f, 6.01503477e-02f, -6.03619963e-02f, 9.69553292e-02f, -3.23991254e-02f, -5.41572087e-02f, -5.76763116e-02f,
  -1.35411501e-01f, -1.03305005e-01f, -6.49371073e-02f, -5.95704205e-02f, 1.83224604e-02f, 8.06247294e-02f, 1.43986223e-02f, -4.39208597e-02f, 6.37232885e-02f, -1.21143557e-01f,
  5.63735627e-02f, -1.03894129e-01f, -1.08145073e-01f, -4.77652773e-02f, -7.64342174e-02f, -3.53141762e-02f, -2.72118039e-02f, -1.79459453e-02f, 4.61265445e-02f, -2.74963621e-02f,
  -6.10831618e-01f, -5.35684168e-01f, 9.89374593e-02f, -1.59788787e-01f, 6.67306110e-02f, 5.14175184e-02f, 6.20668009e-02f, -2.72144787e-02f, -9.73451063e-02f, 7.49313384e-02f,
  1.15098856e-01f, -5.69610447e-02f, -2.13016808e-01f, 6.76406920e-02f, 1.27513453e-01f, 3.55011895e-02f, 6.88195974e-02f, 4.60576750e-02f, -1.01668447e-01f, -7.14958236e-02f,
  2.66373549e-02f, 8.01127404e-02f, 1.70410767e-01f, -1.65521000e-02f, -8.83453339e-02f, -5.46615645e-02f, -1.08431101e-01f, -1.41667230e-02f, -2.13955671e-01f, -9.90780815e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  4.41773534e-01f, 4.36213046e-01f, 3.11510801e-01f, 3.49038839e-01f, 4.31964517e-01f, 3.36587220e-01f, 4.36602682e-01f, 3.25199962e-01f, 3.73107076e-01f, 3.69051486e-01f,
  3.13638270e-01f, 5.82431614e-01f, 2.88876951e-01f, 2.49833882e-01f, 3.03222418e-01f, 7.00482652e-02f, 4.85793740e-01f, 2.04056695e-01f, 4.47985888e-01f, 2.82042533e-01f,
  4.25815642e-01f, 2.99007386e-01f, 2.12524667e-01f, 3.00989658e-01f, 3.95232201e-01f, 4.09496456e-01f, 4.40099537e-01f, 4.43032593e-01f, 2.28476450e-01f, 3.41879606e-01f,
  3.85238796e-01f, 4.35525894e-01f, 1.81461796e-01f, 4.03120011e-01f, 4.55401480e-01f, 3.48355681e-01f, 3.52791309e-01f, 1.42553568e-01f, 2.90301234e-01f, 3.19951266e-01f,
  4.59079027e-01f, 3.61845016e-01f, 3.66051555e-01f, 2.20948547e-01f, 3.62210929e-01f, 2.89270908e-01f, 6.02551699e-01f, 4.55157220e-01f, 2.19357595e-01f, 4.14326578e-01f,
  3.62562060e-01f, 2.52338082e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -3.43390346e-01f, 8.30809474e-02f, -4.21980470e-01f, 1.38616055e-01f, -3.50434363e-01f, -1.36199966e-01f, -2.37147301e-01f, -8.52268562e-02f, -3.29174250e-01f, 8.32863525e-02f,
  -3.36145163e-01f, 2.69428700e-01f, -1.57917395e-01f, -9.44371223e-02f, 3.77906829e-01f, -4.92884994e-01f, 7.01631606e-02f, 3.84549499e-01f, 2.07726806e-01f, -1.04227096e-01f,
  -6.90199256e-01f, -5.78988373e-01f, 4.08493519e-01f, -5.05609930e-01f, 1.15941688e-01f, 5.33526301e-01f, 2.76340008e-01f, -5.16431816e-02f, 1.89064667e-01f, 5.09336412e-01f,
  -2.16672301e-01f, -1.62452072e-01f, -6.17303729e-01f, -2.08545446e-01f, -4.22928154e-01f, -5.34593105e-01f, -1.12902232e-01f, 4.87585396e-01f, -6.47592366e-01f, -2.32994631e-01f,
  2.30788857e-01f, -1.20824091e-01f, 5.46754599e-02f, -3.04109231e-02f, -3.68318677e-01f, -1.27482176e-01f, -2.18201190e-01f, -3.51465136e-01f, 6.06748573e-02f, -5.24641991e-01f,
  6.12816691e-01f, 3.22323799e-01f, -2.80488998e-01f, -2.66127259e-01f, 3.44946206e-01f, 1.42331421e-01f, 3.14194113e-01f, -4.37971890e-01f, -4.60425347e-01f, -4.64235067e-01f,
  -3.41889173e-01f, -2.87465841e-01f, -4.57491130e-01f, 3.97415757e-01f, 1.73011303e-01f, -2.16028899e-01f, -1.59066856e-01f, -3.06821287e-01f, 1.46066219e-01f, -2.49325588e-01f,
  5.10780811e-01f, -1.55955598e-01f, -4.11959767e-01f, 1.19402334e-02f, 2.71721393e-01f, -2.97273993e-01f, -1.05145586e+00f, 1.21543221e-02f, 2.87789792e-01f, 5.48261046e-01f,
  1.11999676e-01f, -2.98075497e-01f, -4.27655727e-01f, -1.69239119e-01f, -4.85994428e-01f, 2.08693191e-01f, 4.15172845e-01f, 2.75637805e-01f, 3.58949423e-01f, -2.77963400e-01f,
  -1.44459814e-01f, -2.17160568e-01f, 5.68834782e-01f, 5.15737116e-01f, -1.71742395e-01f, -1.70707241e-01f, -2.64861882e-01f, 2.94338733e-01f, -1.90752178e-01f, 2.85832226e-01f,
  -5.34761131e-01f, -2.99277335e-01f, -4.36993539e-01f, -4.21219319e-01f, 3.79675746e-01f, 1.34415105e-01f, -4.23893929e-01f, 3.16977203e-01f, -2.57787377e-01f, 1.67643860e-01f,
  1.23676971e-01f, 5.08784771e-01f, -2.77758986e-01f, -3.14158380e-01f, 2.91581064e-01f, -2.78075546e-01f, -2.90333549e-03f, -5.16796052e-01f, -8.35257173e-01f, -2.39615694e-01f,
  -4.40250039e-01f, -1.66679367e-01f, -6.59311771e-01f, 1.36690468e-01f, 5.34808695e-01f, -2.80668646e-01f, -2.44779870e-01f, -4.95163679e-01f, -1.78477868e-01f, -2.73946881e-01f,
  7.18218386e-02f, -1.60945624e-01f, -8.23286846e-02f, 1.13141583e-02f, -1.34891495e-01f, 2.38561686e-02f, -3.01361755e-02f, -2.66254216e-01f, -4.13293689e-02f, 3.59569669e-01f,
  6.20724618e-01f, -4.79709029e-01f, -3.21514428e-01f, -2.80736357e-01f, -5.79197824e-01f, -2.33820558e-01f, -2.56519288e-01f, 5.00207722e-01f, -4.63202894e-01f, 3.11392456e-01f,
  1.97989166e-01f, 2.49062791e-01f, -1.72247484e-01f, -2.06384256e-01f, 4.98089224e-01f, 3.98513645e-01f, 1.52400821e-01f, -2.41968021e-01f, -1.83998719e-01f, -3.02600533e-01f,
  -1.97177708e-01f, -5.21775305e-01f, -2.05989525e-01f, -1.81443185e-01f, -3.50094080e-01f, -4.48967546e-01f, 7.31633306e-02f, -9.14082304e-02f, -2.80716509e-01f, 3.70724276e-02f,
  -3.04895163e-01f, -5.53272784e-01f, -1.54066145e-01f, -3.84811074e-01f, -2.89628327e-01f, 4.74231929e-01f, -1.92139879e-01f, -1.59605667e-01f, 7.99396355e-03f, 3.11901331e-01f,
  -3.49490732e-01f, 4.23555493e-01f, -1.45418212e-01f, -4.74153489e-01f, -3.61100823e-01f, -2.29179244e-02f, -3.61652017e-01f, 6.69287384e-01f, 4.52632189e-01f, 1.78541571e-01f,
  -3.04002732e-01f, -1.89390615e-01f, -1.99545458e-01f, -1.13425918e-01f, -3.42218601e-03f, -6.88239634e-02f, -4.54279751e-01f, -2.47623682e-01f, 5.07597625e-01f, 2.07024574e-01f,
  -3.78562114e-03f, 8.05792511e-02f, -2.47972354e-01f, -3.75184923e-01f, -2.30863824e-01f, -2.92509794e-01f, -4.89322096e-01f, -2.23386809e-01f, -1.81769848e-01f, 6.22758865e-01f,
  1.97473079e-01f, -2.58760393e-01f, -4.49575096e-01f, -1.27525017e-01f, -4.20764238e-01f, -5.30754983e-01f, -7.08732638e-04f, -3.34801942e-01f, -6.59882367e-01f, 1.51319643e-02f,
  -4.94594276e-01f, -3.44865978e-01f, -4.62378442e-01f, -2.52023906e-01f, 5.27603850e-02f, 4.37428325e-01f, 1.75883383e-01f, -1.45857662e-01f, 1.84370831e-01f, 4.79947954e-01f,
  1.36836365e-01f, 3.90048146e-01f, -2.21076384e-01f, -3.28102976e-01f, 2.88434803e-01f, 9.58010554e-03f, 4.34678763e-01f, -3.20824325e-01f, 2.65644521e-01f, -2.34831601e-01f,
  -7.42802694e-02f, -3.31363857e-01f, 4.47773822e-02f, 4.54279967e-02f, -7.03922212e-01f, -6.24604225e-01f, 2.61721034e-02f, -4.69452411e-01f, 5.26090376e-02f, 6.67773068e-01f,
  -3.97307634e-01f, -1.44065589e-01f, -2.61271626e-01f, -2.96869606e-01f, 2.35509425e-01f, 7.57016242e-01f, 3.31656128e-01f, 1.00427806e-01f, 4.46468480e-02f, 2.94186085e-01f,
  5.22822291e-02f, 1.27129048e-01f, -4.57656980e-01f, 1.08794592e-01f, 2.50266463e-01f, -2.52271518e-02f, -2.49392599e-01f, -2.06221178e-01f, -5.48018813e-01f, 5.82681596e-01f,
  -2.68260390e-01f, -1.87400118e-01f, 5.76628029e-01f, -4.28146780e-01f, 5.06726503e-01f, 1.30377829e-01f, 4.73306216e-02f, -3.60222250e-01f, -2.28958160e-01f, -4.23835635e-01f,
  -1.83973759e-01f, -3.78158242e-01f, -2.89647430e-01f, -1.39621824e-01f, -4.19930369e-01f, 3.06184620e-01f, -2.75761843e-01f, 3.38419795e-01f, 3.24698627e-01f, -2.16518790e-01f,
  4.61943895e-02f, -5.13105452e-01f, -4.97460216e-01f, -2.18138412e-01f, 5.09195030e-01f, 9.34986025e-02f, -1.47823393e-01f, -8.85142833e-02f, -4.49673116e-01f, -5.94568670e-01f,
  -8.10682774e-02f, -6.70019746e-01f, 3.18603188e-01f, 6.72537759e-02f, -8.97704899e-01f, -3.49827260e-01f, -3.00034642e-01f, 6.15504026e-01f, 2.18564346e-01f, -6.66943118e-02f,
  4.46901798e-01f, 5.77426910e-01f, 3.89300913e-01f, -2.07639217e-01f, 3.60470682e-01f, 3.74451041e-01f, -2.56871104e-01f, 3.69800240e-01f, 2.20298562e-02f, -2.87286397e-02f,
  2.16883197e-02f, 3.32116991e-01f, 2.45466456e-01f, -1.03394441e-01f, 4.08789158e-01f, -1.49020046e-01f, -3.59197944e-01f, -3.78256798e-01f, 4.27348703e-01f, -2.44585127e-01f,
  -3.68816517e-02f, -4.17599618e-01f, 2.10644647e-01f, -7.48061668e-03f, 3.25188071e-01f, 2.20283791e-02f, -3.34024191e-01f, -4.86722857e-01f, -5.67314088e-01f, -4.85054195e-01f,
  4.35425937e-01f, 1.12659469e-01f, -3.04166824e-01f, 5.51273637e-02f, 3.76427948e-01f, 2.57745713e-01f, -4.02881771e-01f, 3.18306535e-01f, 2.39528254e-01f, -4.36081409e-01f,
  7.90509209e-02f, 2.50442810e-02f, 6.44231308e-03f, -4.55027759e-01f, -1.67246431e-01f, -2.04092056e-01f, -1.91310104e-02f, -6.94874406e-01f, -4.91343290e-01f, -2.61750877e-01f,
  3.52986120e-02f, -4.20523465e-01f, 3.57511580e-01f, 4.28125679e-01f, -3.96432370e-01f, 2.90432960e-01f, 4.80145991e-01f, -8.11943591e-01f, 1.85128301e-01f, 4.63957220e-01f,
  -2.27834731e-01f, -5.61883569e-01f, 8.15906003e-02f, -1.98111147e-01f, 4.00093287e-01f, -3.41020636e-02f, 4.13907498e-01f, -3.10181886e-01f, 1.75535217e-01f, -4.80082959e-01f,
  -6.25376403e-01f, -5.00018179e-01f, -6.02499843e-01f, 4.90988076e-01f, 6.28776401e-02f, 1.85659572e-01f, -2.67976105e-01f, -3.21673416e-02f, -4.29883629e-01f, -3.18480749e-03f,
  -2.00272828e-01f, 2.28073448e-02f, -1.44947125e-02f, -1.87298179e-01f, 2.85989881e-01f, 1.13251016e-01f, 1.08333617e-01f, -4.37746644e-01f, 2.34123811e-01f, -4.39720333e-01f,
  -2.96614766e-01f, -2.89302498e-01f, -5.29935598e-01f, 4.57220137e-01f, 5.47844291e-01f, 3.69605720e-01f, -1.57184787e-02f, -2.13873200e-02f, -3.31888378e-01f, -9.33070779e-02f,
  2.02800915e-01f, -1.37462154e-01f, -7.18658209e-01f, -4.98602539e-01f, 4.10265207e-01f, 5.75343132e-01f, -3.38627458e-01f, 1.20182015e-01f, -1.20742060e-01f, 6.83062077e-01f,
  -1.10276319e-01f, -1.18284121e-01f, 4.35386151e-01f, 4.79219913e-01f, 5.23602486e-01f, 5.04498720e-01f, -4.26326096e-01f, -4.83217955e-01f, 1.50855064e-01f, 3.96185845e-01f,
  -6.30546570e-01f, -2.17748940e-01f, 1.23499937e-01f, -2.69681658e-03f, -2.35946253e-01f, -2.15422407e-01f, -5.89597404e-01f, 3.33949208e-01f, -5.51384509e-01f, -1.79432556e-01f,
  -5.73512554e-01f, 7.58155584e-02f, 3.74073863e-01f, -4.72730517e-01f, -4.09090906e-01f, -7.35242143e-02f, -7.23457038e-01f, -5.79817235e-01f, -2.86138188e-02f, -2.98996150e-01f,
  -2.90442370e-02f, -1.91698089e-01f, 2.30232388e-01f, 5.00166789e-02f, -4.50362340e-02f, 1.74228802e-01f, -2.10416645e-01f, 1.75401852e-01f, -7.32073933e-02f, 9.76113603e-02f,
  1.30141184e-01f, -4.46661204e-01f, -2.50774324e-01f, -3.90638918e-01f, -3.04326475e-01f, -2.99616873e-01f, -3.26033771e-01f, -3.70040953e-01f, 2.59445518e-01f, -1.97157472e-01f,
  2.20784962e-01f, -2.34518766e-01f, -3.27936700e-03f, -2.89612591e-01f, -1.24030806e-01f, 1.39002698e-02f, -2.58259416e-01f, -3.04038197e-01f, -1.76591650e-01f, -3.67851108e-01f,
  5.03837943e-01f, 3.97788078e-01f, 4.20098633e-01f, -3.35490942e-01f, -1.07962735e-01f, -3.96323800e-01f, 2.81123430e-01f, 2.64280736e-02f, -3.33671421e-01f, -2.38383919e-01f,
  -2.12537065e-01f, 1.08890936e-01f, 5.34301400e-01f, -2.79936999e-01f, -4.52141404e-01f, -3.21671426e-01f, -2.69564819e-02f, 6.17964268e-01f, -3.62466127e-01f, -4.11257505e-01f,
  1.82037115e-01f, 9.95645225e-02f, 1.49564281e-01f, 2.57355094e-01f, 5.84818088e-02f, -3.87365192e-01f, 2.30044037e-01f, 1.17085271e-01f, -1.73293486e-01f, -3.11000079e-01f,
  3.50509733e-01f, 2.08910301e-01f, -1.33150265e-01f, -2.56124977e-02f, -1.09574504e-01f, -2.84038726e-02f, 1.42696686e-02f, 1.20139718e-01f, 1.73878029e-01f, -2.16378607e-02f,
  -3.51382643e-01f, -2.57114381e-01f, -5.11335656e-02f, 2.07290709e-01f, 2.56297253e-02f, -2.17426255e-01f, -2.65071899e-01f, 3.31525654e-01f, -2.83742845e-01f, 3.09370995e-01f,
  -1.72846735e-01f, -1.96948975e-01f, -3.95486772e-01f, 3.65560502e-01f, -6.79904401e-01f, -3.39568257e-01f, -2.84556597e-01f, 1.60119429e-01f, -3.57920945e-01f, 3.88435960e-01f,
  2.08285376e-01f, -2.25821093e-01f, 4.02879685e-01f, 1.98685303e-02f, 5.69052815e-01f, -3.22361678e-01f, -1.54712290e-01f, -1.50428042e-01f, 4.86713678e-01f, 1.71257332e-01f,
  -1.61338344e-01f, -5.38067758e-01f, -3.58348548e-01f, 1.97286829e-01f, -1.06465042e-01f, -2.00403348e-01f, -2.49268472e-01f, -3.24666709e-01f, -5.27074873e-01f, -4.64049056e-02f,
  1.94138169e-01f, -1.89768121e-01f, -4.67788994e-01f, -3.00103396e-01f, -2.15315685e-01f, 5.01044273e-01f, -1.06942259e-01f, 4.48124707e-01f, -2.98687994e-01f, -3.57547671e-01f,
  -3.47328514e-01f, -3.69773418e-01f, 2.84664065e-01f, -3.30988139e-01f, -2.42947802e-01f, -2.34057918e-01f, -2.39505339e-02f, 1.77320302e-01f, -1.71613857e-01f, 2.41770476e-01f,
  -9.46000740e-02f, -1.13895372e-01f, -1.50900453e-01f, -2.95657009e-01f, 3.17378253e-01f, 8.79391879e-02f, 3.05963725e-01f, 4.97608483e-01f, 4.85754669e-01f, 4.43020403e-01f,
  1.49252132e-01f, -4.43765938e-01f, -1.39609486e-01f, -1.37139201e-01f, 3.22439879e-01f, -4.50410657e-02f, -6.72438368e-02f, -5.02746522e-01f, 3.54481190e-01f, 3.80005807e-01f,
  -4.87720579e-01f, 4.25699711e-01f, -1.98063686e-01f, -3.18193585e-01f, -6.24723315e-01f, -3.51669520e-01f, -5.39687455e-01f, -3.15857947e-01f, -2.74239033e-01f, 1.12539276e-01f,
  -2.64545768e-01f, 3.53323787e-01f, -2.10501969e-01f, -1.35599792e-01f, -4.12570350e-02f, -5.81602216e-01f, -6.26362324e-01f, -3.33881259e-01f, -2.34266371e-01f, -1.74113624e-02f,
  -2.07457408e-01f, -3.42309445e-01f, -3.76962632e-01f, 4.93579358e-01f, 6.17438555e-01f, -1.75629139e-01f, -2.46642396e-01f, 8.64589214e-02f, 5.87065339e-01f, -4.75578159e-01f,
  -1.90522745e-01f, -3.57726872e-01f, -4.74361539e-01f, -2.66451061e-01f, 4.83770072e-01f, -3.80602181e-01f, 1.57911003e-01f, -1.76402122e-01f, 7.48384237e-01f, -3.33941311e-01f,
  -4.81043048e-02f, 1.85953110e-01f, 5.69509976e-02f, 5.78763448e-02f, 2.10012496e-01f, 2.19421566e-01f, 1.67016253e-01f, 3.10375839e-01f, -1.66503653e-01f, 2.31210247e-01f,
  -2.50202656e-01f, -8.54828730e-02f, -5.16680419e-01f, -2.91757256e-01f, -2.95040369e-01f, -5.35143837e-02f, 4.13977891e-01f, 2.31936604e-01f, -5.48754036e-01f, 2.64905483e-01f,
  -2.56115139e-01f, -3.32259685e-01f, -4.92582321e-01f, 4.39782470e-01f, -2.81719387e-01f, -2.64813840e-01f, 5.93956828e-01f, -6.94121182e-01f, 6.80401176e-02f, -1.20351769e-01f,
  -1.82379279e-02f, -2.82117069e-01f, -1.03162982e-01f, -1.35941401e-01f, -4.39922541e-01f, -3.50894630e-01f, 3.26509207e-01f, 3.78002763e-01f, -3.77778769e-01f, 4.11210984e-01f,
  -2.52593696e-01f, -6.11345232e-01f, 3.10424984e-01f, 5.28766811e-01f, -2.21630827e-01f, -3.47912341e-01f, -3.47407579e-01f, -5.63850328e-02f, -2.20193490e-01f, 1.49222221e-02f,
  3.09946775e-01f, -3.33766401e-01f, 5.93958855e-01f, 4.88280833e-01f, -3.60795557e-01f, -2.89438665e-01f, -3.58593687e-02f, 3.12519431e-01f, -1.72962263e-01f, 5.39903343e-01f,
  -2.06326589e-01f, 2.62118995e-01f, 6.80397451e-02f, -7.94094026e-01f, 1.83051005e-01f, -8.97512659e-02f, -3.75472009e-02f, -7.28446543e-02f, 1.87729269e-01f, 1.93191811e-01f,
  3.46669070e-02f, 3.71521205e-01f, 2.59377837e-01f, 3.96136940e-01f, -8.35036263e-02f, 2.11561233e-01f, 1.12762809e-01f, -3.20904180e-02f, -3.80865991e-01f, 2.67632097e-01f,
  -1.92912459e-01f, -1.73425913e-01f, 5.06164074e-01f, -2.94490427e-01f, -8.50844756e-02f, -1.50286436e-01f, -1.86708242e-01f, 2.55474538e-01f, -3.57799798e-01f, -2.12232947e-01f,
  -4.02964771e-01f, -4.70785111e-01f, -3.73887569e-01f, -2.84420073e-01f, 6.24270260e-01f, 1.42707631e-01f, -3.66770655e-01f, -4.20649767e-01f, 4.84913081e-01f, -4.03816640e-01f,
  4.16558981e-01f, -2.77901351e-01f, -3.45574319e-01f, -5.56417584e-01f, -1.59484819e-01f, 5.84797919e-01f, 3.55961442e-01f, -3.54371160e-01f, 2.07883231e-02f, 6.04393363e-01f,
  4.79193568e-01f, -2.10119843e-01f, -3.49224061e-01f, 1.01169914e-01f, -2.71304846e-01f, -1.51240557e-01f, -3.93996596e-01f, -1.62836522e-01f, -1.79911494e-01f, -3.14720899e-01f,
  -2.79795885e-01f, 2.39194602e-01f, -2.50582993e-01f, -1.39617965e-01f, -2.34235615e-01f, 5.89190185e-01f, -1.39490083e-01f, -1.83395281e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -2.53097657e-02f, 9.96443257e-02f, -1.98231712e-02f, -7.62953609e-02f, 1.78905264e-01f, 2.45766640e-02f, -2.95053534e-02f, -1.59488231e-01f, -8.63116831e-02f, 3.98505218e-02f,
  -2.43266183e-03f, -3.38355601e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    