/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  5.00476718e-01f, 2.83244550e-01f, 4.29199368e-01f, -9.73071251e-03f, 1.66281998e-01f, 2.59490460e-01f, 3.54435563e-01f, 2.00277921e-02f, -2.25027695e-01f, 5.61066307e-02f,
  -7.33227283e-02f, -2.65906602e-01f, -2.86638767e-01f, -1.41577929e-01f, 1.43326104e-01f, 1.78327948e-01f, 2.95781344e-01f, 1.53262466e-01f, 2.97584292e-02f, 1.01128919e-02f,
  -4.17654170e-03f, 1.41713440e-01f, 1.69704139e-01f, -9.13032666e-02f, -1.84142008e-01f, -2.47845948e-01f, -8.61670449e-02f, 6.02069951e-04f, -3.65647674e-02f, 2.17722908e-01f,
  -1.64422601e-01f, 2.26386771e-01f, -5.93580157e-02f, -4.49650437e-02f, -5.47705255e-02f, 6.46319762e-02f, 7.31469784e-03f, -1.11307792e-01f, -3.06514073e-02f, 6.65988866e-03f,
  2.75725685e-02f, 3.44617516e-02f, 4.35451679e-02f, -1.29236594e-01f, 7.79299885e-02f, -5.98285161e-02f, 6.51244372e-02f, 1.18847534e-01f, 3.43583934e-02f, -4.68631275e-02f,
  4.98239137e-02f, 2.33131275e-01f, 2.25746900e-01f, -3.03359795e-02f, 7.74902944e-03f, 5.13242222e-02f, 1.45461522e-02f, -5.19140176e-02f, 2.70379451e-03f, -5.40168323e-02f,
  6.14645556e-02f, -1.60251930e-02f, 3.49531621e-02f, 2.32600402e-02f, -1.66209824e-02f, -5.69099486e-02f, 4.72590066e-02f, -9.31991488e-02f, -6.01608157e-02f, 1.59526744e-03f,
  -1.70164381e-03f, 3.88157703e-02f, -3.37081216e-02f, 5.63407466e-02f, -5.13376556e-02f, 2.74397316e-04f, 2.02308241e-02f, -5.17372787e-02f, -8.00292641e-02f, -6.64523395e-04f,
  6.62919180e-03f, -4.85996827e-02f, -2.35765427e-02f, -1.85131766e-02f, 1.00613683e-01f, 3.26001234e-02f, -2.19150838e-02f, -6.39205053e-02f, -4.15550917e-02f, 8.25373679e-02f,
  -5.41809738e-01f, 4.45545241e-02f, 2.40386855e-02f, -5.17811514e-02f, 2.21088901e-02f, -7.88327381e-02f, -8.04384053e-03f, -2.24546101e-02f, 3.79709378e-02f, -2.69952901e-02f,
  6.36559874e-02f, -1.58114638e-02f, -3.74399461e-02f, 4.17078137e-02f, 4.44773026e-03f, -1.22740129e-02f, -1.97279360e-02f, -2.97498982e-02f, -4.27337643e-03f, -4.89075705e-02f,
  -7.72893950e-02f, 9.35643353e-03f, -1.24052018e-01f, -1.29774600e-01f, -8.17695335e-02f, 9.85995904e-02f, -6.36386126e-02f, -8.77104253e-02f, 1.61483049e-01f, -4.66271490e-02f,
  1.48287132e-01f, -4.86828238e-02f, -7.04835653e-01f, 4.98425543e-01f, -1.25139821e-02f, -4.71740365e-01f, -7.20582485e-01f, -1.10967077e-01f, 2.93943644e-01f, -1.02338843e-01f,
  -1.75603584e-03f, 2.52167583e-01f, 1.32440031e-01f, 7.13797361e-02f, -2.10917830e-01f, -3.34597141e-01f, -1.70953900e-01f, -1.68037444e-01f, -1.70971513e-01f, -2.07378268e-01f,
  2.61761725e-01f, 2.26871088e-01f, 1.94262981e-01f, 6.00580834e-02f, 2.14108855e-01f, 1.78956464e-01f, -2.27567535e-02f, 1.24767303e-01f, -8.23127925e-02f, 2.35457748e-01f,
  -1.48520812e-01f, -1.11813201e-02f, -1.00320578e-01f, 1.52270362e-01f, 6.04348928e-02f, -1.33147603e-02f, -1.48656266e-02f, 5.32268547e-02f, 5.77323586e-02f, -2.43793949e-02f,
  1.05902493e-01f, 8.04475620e-02f, 1.11743927e-01f, 4.15086560e-02f, -9.92782041e-03f, -4.54470851e-02f, 3.29119451e-02f, -1.17239892e-01f, -1.11732200e-01f, -9.39783454e-02f,
  9.85644683e-02f, 6.21297248e-02f, -1.59532666e-01f, -1.71330541e-01f, -9.31054428e-02f, 1.08633578e-01f, -7.86827803e-02f, -2.38398556e-02f, -1.61671028e-01f, 1.75602380e-02f,
  7.05529889e-03f, -2.65685283e-02f, -3.27081420e-02f, -1.59000908e-03f, 3.20657194e-02f, 3.07954978e-02f, -2.12041661e-02f, -5.08995838e-02f, -2.99543887e-02f, -1.58399753e-02f,
  4.74084774e-03f, -5.67141362e-03f, -1.57665089e-02f, -2.60158852e-02f, 4.09972928e-02f, -5.68043180e-02f, 7.67568708e-04f, -1.01533020e-02f, 3.25052366e-02f, 3.84533964e-02f,
  -8.65146425e-03f, -5.65838665e-02f, 6.97248131e-02f, -6.65445579e-03f, 7.20418477e-03f, -4.39830832e-02f, 7.26262778e-02f, 2.76706275e-03f, 8.58845636e-02f, 1.15227345e-02f,
  2.17243180e-01f, -1.59962535e-01f, 1.78284213e-01f, -1.55710215e-02f, 4.31323424e-02f, 1.10785052e-01f, 6.23671450e-02f, 3.41013260e-02f, 7.70745426e-02f, 1.94020160e-02f,
  -7.28397572e-04f, 2.56047230e-02f, -8.00225884e-03f, -4.27964255e-02f, -3.29832360e-02f, 3.36511619e-03f, 3.55863459e-02f, 4.37242724e-02f, 2.16841674e-03f, 6.60955906e-02f,
  4.11834642e-02f, -1.31771237e-01f, 3.56336981e-02f, -9.10756886e-02f, 5.91250844e-02f, -4.95470352e-02f, -9.90810394e-02f, 1.12207129e-03f, -1.73984304e-01f, -7.38542005e-02f,
  1.16399336e+00f, -1.94506511e-01f, -2.31373832e-01f, 3.99499267e-01f, 4.40826779e-03f, -9.36876982e-03f, -1.66293710e-01f, 7.51007572e-02f, 1.33922428e-01f, -1.43302560e-01f,
  1.69860005e-01f, 1.55177370e-01f, 3.65049765e-02f, 2.94977380e-03f, 1.22183055e-01f, -3.55970651e-01f, -4.33929235e-01f, -8.61408131e-04f, 1.45874798e-01f, -2.24635806e-02f,
  -2.03293413e-01f, 1.22601800e-01f, 3.70531678e-01f, 7.43174851e-02f, -1.62635699e-01f, -1.06627621e-01f, -4.10634205e-02f, 1.74412981e-01f, -1.68098763e-01f, -4.44073528e-01f,
  -1.33147210e-01f, 2.26683348e-01f, -1.09672554e-01f, -2.59183832e-02f, -8.63846689e-02f, 1.32005382e-02f, -6.33661449e-02f, 6.18035682e-02f, 3.00347246e-02f, -1.24574669e-01f,
  2.80582421e-02f, -5.29326312e-02f, 5.34206368e-02f, -3.18858549e-02f, 1.22953812e-02f, -4.04976569e-02f, -3.15467194e-02f, 5.88821955e-02f, 5.95012913e-03f, -1.02071427e-01f,
  -1.65100813e-01f, 8.80089179e-02f, 1.80050403e-01f, -9.91163179e-02f, 8.38673264e-02f, 4.19498235e-02f, 3.01745199e-02f, 1.16654538e-01f, 1.36845201e-01f, -4.40542065e-02f,
  -9.03243572e-03f, 1.27106812e-02f, 3.86204524e-03f, 1.05078621e-02f, 3.12680081e-02f, 4.26415540e-02f, -4.18201648e-02f, 2.45078299e-02f, 1.12029389e-02f, 4.86771427e-02f,
  -6.32320344e-02f, 2.39505395e-02f, -1.95066091e-02f, 6.05085753e-02f, 3.13122803e-03f, 2.89314869e-03f, 4.19760495e-02f, -2.33531054e-02f, 6.42875163e-03f, 7.88101647e-03f,
  -7.87386484e-03f, -3.77219729e-03f, -5.19033372e-02f, -1.24550993e-02f, -8.64553750e-02f, 2.07688427e-03f, 8.72304849e-03f, -2.13012211e-02f, 5.36435656e-02f, 2.37316974e-02f,
  8.32394511e-02f, 1.99851859e-02f, -6.45067394e-02f, 5.28335348e-02f, 2.54599005e-02f, 6.09656377e-03f, -1.90066379e-02f, -3.35278176e-02f, -3.29849459e-02f, -1.15604908e-03f,
  1.36230337e-02f, 2.27135774e-02f, 3.26839983e-02f, -5.13231792e-02f, 3.42128240e-02f, 2.60908064e-03f, 7.01526329e-02f, 6.69072270e-02f, -4.90591377e-02f, 8.42997432e-03f,
  -8.11918825e-03f, -3.27573121e-02f, -2.74881604e-04f, 3.69658344e-03f, 9.07966495e-02f, -5.44878561e-03f, -1.40668094e-01f, 1.84642430e-02f, 7.87604675e-02f, -1.36134982e-01f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.01300192e-01f, -1.69202104e-01f, -1.69183329e-01f, -1.42038450e-01f, -4.46858071e-02f, -2.02645525e-01f, -4.89339739e-01f, -4.07037050e-01f, -3.34573835e-02f, -1.04158044e-01f,
  7.35495687e-02f, -9.24663842e-02f, -2.70232856e-01f, -2.62189299e-01f, -5.87557316e-01f, -3.88311028e-01f, -4.06270742e-01f, -4.25348341e-01f, -3.51830095e-01f, -2.09728703e-01f,
  -7.02176020e-02f, -3.17988425e-01f, -2.72047609e-01f, -2.44926021e-01f, 4.97012250e-02f, -7.36326277e-02f, 8.47303681e-03f, -8.06369409e-02f, 3.63932066e-02f, -6.38055801e-02f,
  -1.15855470e-01f, 9.20935422e-02f, -2.95872632e-02f, -3.10103521e-02f, 1.34412065e-01f, 4.77336273e-02f, 6.51110634e-02f, -4.84821051e-02f, 4.93471250e-02f, -6.91220015e-02f,
  5.82756437e-02f, -7.50560453e-03f, -1.38677144e-02f, -2.30626892e-02f, -1.51788667e-01f, -1.42145202e-01f, -6.60403073e-02f, -2.42505655e-01f, -8.60656053e-02f, 7.34545514e-02f,
  3.81105691e-02f, -9.98180881e-02f, -2.97722638e-01f, -1.95293538e-02f, -3.12251803e-02f, -1.25192627e-01f, -1.28424644e-01f, -1.10279739e-01f, -2.08820552e-01f, -2.99995184e-01f,
  -2.43013855e-02f, 1.55714259e-01f, 7.24834427e-02f, 1.67107340e-02f, -7.00385347e-02f, 1.69834960e-02f, -2.94174049e-02f, -7.74668111e-03f, -5.92119731e-02f, -2.01890916e-02f,
  1.83515865e-02f, 7.74541944e-02f, 5.87095656e-02f, -8.27311203e-02f, -1.90943424e-02f, 4.05797036e-03f, 2.83732433e-02f, -9.75837037e-02f, -6.66563138e-02f, 1.12785976e-02f,
  -3.62922847e-02f, -2.51243841e-02f, 6.45348430e-02f, -9.98857915e-02f, 3.08221206e-02f, -5.40369935e-02f, 1.03938449e-02f, -2.66725291e-03f, 2.91767959e-02f, -1.23508219e-02f,
  -3.09250325e-01f, 7.74815679e-02f, -1.65005207e-01f, -1.53515190e-01f, -2.50085089e-02f, 4.01604036e-03f, 4.94970493e-02f, 2.03336477e-02f, 1.22768871e-01f, -1.21734068e-01f,
  -4.94222809e-03f, -1.13501705e-01f, -1.06961921e-01f, -2.04143636e-02f, -9.70007330e-02f, -9.69889536e-02f, -2.31474683e-01f, -1.33722812e-01f, -1.42150298e-01f, 4.33275290e-02f,
  -1.92847058e-01f, -4.20066297e-01f, -3.48453879e-01f, -2.89970964e-01f, -1.98915765e-01f, -2.06144229e-01f, -2.99036026e-01f, -3.00485194e-01f, -4.89531696e-01f, -6.02044523e-01f,
  -1.85193881e-01f, -1.68723390e-01f, -7.64472842e-01f, -3.73681605e-01f, -3.14524293e-01f, -4.15336266e-02f, 1.50912061e-01f, 1.42476693e-01f, -1.56223670e-01f, -4.48012389e-02f,
  2.15834491e-02f, -4.39342968e-02f, -1.08561762e-01f, -2.02251021e-02f, 7.90084675e-02f, -9.42715630e-02f, -4.13464367e-01f, -3.04674655e-01f, 1.84428860e-02f, 2.20232025e-01f,
  1.08463399e-01f, -7.82981049e-03f, -1.03003167e-01f, -1.76384166e-01f, -2.80849487e-01f, -3.04626703e-01f, -3.73633534e-01f, -3.23705912e-01f, -2.33189344e-01f, -3.55714947e-01f,
  -3.32621075e-02f, -4.09019053e-01f, 4.71615195e-02f, 3.23449671e-02f, -1.47229150e-01f, 6.73780739e-02f, -7.10048974e-02f, -1.68597445e-01f, -1.17246415e-02f, -5.75894080e-02f,
  -1.53634876e-01f, -1.17096595e-01f, -5.91079779e-02f, -9.02402103e-02f, -2.65851077e-02f, -4.54246439e-02f, -3.18002999e-02f, -1.66106015e-01f, -7.61768371e-02f, 5.29827550e-03f,
  2.39664130e-02f, -1.49250060e-01f, -4.41712551e-02f, -8.14970955e-02f, -1.68983027e-01f, -1.19381703e-01f, -2.58024801e-02f, -1.83427468e-01f, -2.14147761e-01f, 8.81289088e-05f,
  1.06578119e-01f, -2.83122435e-03f, -6.24381863e-02f, 7.60705993e-02f, 5.30278683e-02f, 2.65113055e-03f, -1.45927109e-02f, 1.04935005e-01f, 3.78295369e-02f, 5.04253656e-02f,
  5.32184467e-02f, 1.39991231e-02f, 3.91634926e-03f, 2.49762051e-02f, -5.27494811e-02f, -4.66561019e-02f, 1.34919910e-02f, 1.02107018e-01f, 9.41148587e-03f, -7.57191405e-02f,
  2.30578855e-02f, -9.16312486e-02f, -5.57801686e-02f, 4.11615521e-02f, -1.59639239e-01f, -6.68824539e-02f, 2.08028927e-02f, -6.67727366e-03f, -2.01593153e-02f, -8.74064490e-02f,
  3.36988866e-01f, -1.75599903e-01f, 8.37087631e-02f, 6.94395602e-02f, -1.94301769e-01f, -5.62693812e-02f, -4.62726802e-02f, -4.63045426e-02f, -6.45804480e-02f, 6.38992190e-02f,
  -4.30447236e-02f, 4.96901125e-02f, -3.85150798e-02f, 5.42412214e-02f, 4.14717719e-02f, 8.73484015e-02f, 8.31159428e-02f, -1.73232274e-03f, -1.50813922e-01f, -1.97412469e-03f,
  -2.21997742e-02f, 9.89692286e-02f, 3.13596427e-01f, 1.48269653e-01f, 4.78773843e-03f, -3.68158072e-02f, 8.51747096e-02f, 1.35107264e-01f, 5.97097948e-02f, 5.31338990e-01f,
  -3.03373992e-01f, -2.10980669e-01f, 2.93582320e-01f, -2.94487923e-01f, -4.75540668e-01f, -2.73203582e-01f, -4.72630590e-01f, -1.91499233e-01f, -2.19423786e-01f, -1.95184320e-01f,
  -4.30554062e-01f, -2.05368668e-01f, 1.33485585e-01f, 3.17289501e-01f, 3.67742121e-01f, 2.07289517e-01f, 2.92786062e-01f, 6.59124196e-01f, 3.98532093e-01f, -8.47968180e-03f,
  7.33678713e-02f, 2.91445315e-01f, 4.65253860e-01f, 2.49829590e-01f, 1.50633063e-02f, 9.29551274e-02f, 2.05361590e-01f, 1.08213782e-01f, 5.73876500e-02f, 1.32250920e-01f,
  -1.82970867e-01f, -3.02328497e-01f, 9.78757069e-02f, -6.16278499e-02f, -4.35242848e-03f, 1.79777324e-01f, -6.82135895e-02f, 1.29540205e-01f, 2.35475358e-02f, -3.03823855e-02f,
  -1.33063063e-01f, -3.68040539e-02f, -3.29121314e-02f, 5.18454239e-02f, -8.81223101e-03f, -5.03168739e-02f, 1.99911401e-01f, 2.84534127e-01f, 2.59004414e-01f, 2.30306182e-02f,
  -1.02864690e-01f, -2.30639100e-01f, -1.75877094e-01f, -6.64901808e-02f, 1.30273134e-01f, 7.87123442e-02f, -6.26259595e-02f, -1.00548409e-01f, 5.62583469e-02f, -9.18578953e-02f,
  6.58074301e-03f, -4.02668379e-02f, -5.84073411e-03f, -5.60268462e-02f, 3.71031761e-02f, -7.50787258e-02f, 7.35811591e-02f, -6.01342507e-02f, 3.00928261e-02f, -4.02403623e-02f,
  2.97888611e-02f, 2.07086913e-02f, 5.33494279e-02f, -4.86609200e-03f, -1.67786684e-02f, -4.51098429e-03f, -9.84705519e-03f, 5.48209362e-02f, 1.15113705e-02f, 5.37234843e-02f,
  -4.48312126e-02f, 5.40236793e-02f, -7.23510087e-02f, 1.12047330e-01f, 6.83092931e-03f, 2.81333793e-02f, 3.54477912e-02f, -1.01426765e-01f, 9.49211325e-03f, -5.02903610e-02f,
  -2.49547899e-01f, 1.75823644e-01f, -1.40711814e-01f, 1.45925740e-02f, -6.78062961e-02f, 3.88410762e-02f, -1.40949294e-01f, 3.16115096e-02f, -1.22531891e-01f, -1.05473911e-02f,
  -1.80671632e-01f, -8.08354840e-03f, -9.15810838e-02f, 3.06504332e-02f, -1.49599528e-02f, -1.68449655e-01f, -6.26316816e-02f, 1.83748715e-02f, -8.25852249e-03f, -4.19270806e-02f,
  -3.64844613e-02f, -2.36220494e-01f, -2.78273851e-01f, -2.55842656e-01f, -2.06834957e-01f, -2.79547900e-01f, -2.09408358e-01f, -1.79786861e-01f, -1.55105636e-01f, -3.00555319e-01f,
  -2.70444244e-01f, 9.14265141e-02f, -2.32783839e-01f, 3.44819933e-01f, 3.98167223e-01f, 2.49370053e-01f, 2.35499531e-01f, 2.52120703e-01f, 3.24522376e-01f, 2.59654105e-01f,
  2.18086645e-01f, 4.03847337e-01f, 3.48641008e-01f, 2.76984245e-01f, 1.20067544e-01f, 2.50951380e-01f, 2.33092040e-01f, -1.77125465e-02f, 5.48788831e-02f, 2.65922248e-01f,
  4.22815561e-01f, 6.41750917e-02f, -1.33617401e-01f, 4.62618098e-02f, 3.46838057e-01f, 2.97352791e-01f, 9.05810371e-02f, 1.39715135e-01f, 1.28784582e-01f, 2.47416630e-01f,
  -1.00824647e-01f, -2.65166551e-01f, 7.67250806e-02f, 1.82226330e-01f, -5.11204489e-02f, -1.29556254e-01f, -3.05797383e-02f, -1.79567009e-01f, -7.86745250e-02f, -1.43118287e-02f,
  3.67608033e-02f, -1.21956699e-01f, 9.49051827e-02f, -1.01214215e-01f, -1.44730911e-01f, -1.26964644e-01f, -1.33928716e-01f, -1.55949462e-02f, 4.17966209e-02f, 2.19390877e-02f,
  2.33984023e-01f, -2.02388484e-02f, -2.21862614e-01f, -9.26103741e-02f, -6.16419967e-03f, 2.54885424e-02f, -6.22333884e-02f, -2.39136033e-02f, -1.39542416e-01f, -9.61194411e-02f,
  3.76446471e-02f, -4.78072986e-02f, -1.84219591e-02f, -5.73309921e-02f, 8.60571638e-02f, -3.28037031e-02f, 1.00086845e-01f, 7.24251866e-02f, 3.97905968e-02f, -8.09438899e-02f,
  -1.43538993e-02f, 4.49607149e-02f, -5.14698476e-02f, 3.09631284e-02f, 1.22647509e-01f, -2.63445284e-02f, -6.20030239e-03f, 4.06850986e-02f, -6.64149001e-02f, -6.68206513e-02f,
  3.40396427e-02f, 2.97661144e-02f, -1.67471424e-01f, -6.62926063e-02f, -9.64767858e-02f, -3.09157297e-02f, -9.19785276e-02f, 2.00619791e-02f, -4.04912047e-02f, -6.20828643e-02f,
  2.81166798e-03f, -7.43029267e-02f, 1.90700248e-01f, 2.15770751e-02f, -3.32227163e-02f, -1.73740357e-01f, 2.63387524e-02f, -8.48914385e-02f, -8.64981264e-02f, -3.34796272e-02f,
  -9.62249637e-02f, -1.97134286e-01f, 8.78427364e-03f, -1.11220591e-01f, -1.02152899e-01f, -6.53900281e-02f, -4.66500856e-02f, -4.60784845e-02f, 6.66802302e-02f, -3.31999324e-02f,
  4.05483842e-02f, -1.08513646e-01f, -2.11777613e-01f, -1.53962430e-02f, 7.89769888e-02f, 3.70068774e-02f, -2.14584917e-01f, -1.45901248e-01f, -1.48051187e-01f, -1.73637941e-01f,
  -6.44691229e-01f, 2.74163932e-01f, 9.86913592e-03f, -3.10315490e-01f, -1.58362165e-01f, -9.65359733e-02f, 9.27638635e-02f, -1.43689245e-01f, -1.31133437e-01f, -1.71577018e-02f,
  -2.34779119e-02f, -5.41990995e-03f, -1.78627372e-02f, 1.60679728e-01f, 2.13334039e-02f, 2.46730313e-01f, 2.68494129e-01f, -2.67552771e-02f, -2.01781601e-01f, 5.14298640e-02f,
  1.22311756e-01f, -2.47924298e-01f, -2.86999553e-01f, -4.50684540e-02f, 2.32281670e-01f, 1.17639475e-01f, 7.30736628e-02f, 1.25852332e-01f, 2.67911851e-01f, 4.62120891e-01f,
  4.88852918e-01f, -7.51553923e-02f, -5.92907928e-02f, -1.52551224e-02f, -8.83296505e-02f, 2.94175744e-02f, -5.03293611e-02f, 1.12647833e-02f, -1.22158617e-01f, -5.04026487e-02f,
  1.69061385e-02f, -6.19930029e-02f, -1.05426852e-02f, -2.07390096e-02f, -4.04458717e-02f, 5.29580750e-02f, -8.99310037e-02f, -1.11013263e-01f, -1.31543994e-01f, 1.15823053e-01f,
  5.65582328e-02f, -7.66424602e-03f, -2.33667463e-01f, -1.29763126e-01f, -2.61841938e-02f, -2.58612842e-03f, 4.84763682e-02f, 1.02304876e-01f, 3.32576223e-02f, 1.28786311e-01f,
  1.78285304e-03f, 9.95940194e-02f, 1.29095912e-02f, 6.34151474e-02f, 2.77221333e-02f, 3.66347916e-02f, 8.87783989e-02f, 3.17063630e-02f, -6.91331830e-03f, -1.19148269e-02f,
  -4.90824021e-02f, -3.45648453e-03f, -2.60678791e-02f, -1.41624203e-02f, 1.12134397e-01f, -3.12309768e-02f, 9.22834501e-02f, -6.70742914e-02f, 4.98053767e-02f, -7.80189261e-02f,
  1.05469860e-02f, -4.02769260e-02f, -2.00721323e-02f, 4.13470753e-02f, 8.75334069e-03f, -8.57831538e-03f, 8.70033577e-02f, -1.28644649e-02f, -4.72323922e-03f, -2.56355368e-02f,
  -2.11508140e-01f, -2.91084886e-01f, 6.82173669e-02f, 1.01504112e-02f, -5.35215475e-02f, 5.10258563e-02f, -1.03656547e-02f, -3.51684876e-02f, -6.58801422e-02f, 6.91884607e-02f,
  -5.61713837e-02f, 3.00819911e-02f, -6.46087676e-02f, -1.36590805e-02f, -1.55194730e-01f, -1.05415493e-01f, -1.62432954e-01f, -2.60822419e-02f, -6.51396662e-02f, 2.82279612e-03f,
  -5.53584434e-02f, -2.65655011e-01f, -3.24388325e-01f, -9.98880118e-02f, -4.66356762e-02f, -1.94095358e-01f, -9.93449837e-02f, 3.31864767e-02f, -1.89209312e-01f, -1.81049868e-01f,
  -6.90035224e-02f, 3.44288021e-01f, 1.82589740e-02f, -3.01378578e-01f, -4.86409664e-01f, -4.44634050e-01f, -1.04169801e-01f, -3.38928968e-01f, -2.24786207e-01f, 2.12809239e-02f,
  5.36578968e-02f, 1.43258512e-01f, 3.15827549e-01f, 1.72979146e-01f, 5.25949560e-02f, 1.33234799e-01f, 1.18306682e-01f, 8.50001723e-03f, -1.92055941e-01f, -4.14840490e-01f,
  -2.30076998e-01f, -2.77296782e-01f, -1.85956642e-01f, -1.01257369e-01f, -1.11654982e-01f, -2.71452516e-02f, -5.97248264e-02f, -1.21238388e-01f, -6.35971725e-02f, -6.97544962e-03f,
  3.93480211e-01f, -1.95648432e-01f, -1.45307437e-01f, -1.08383082e-01f, 2.52729235e-03f, -4.98655103e-02f, 8.34117830e-02f, -9.27304700e-02f, -9.98848956e-03f, -3.07437778e-02f,
  -8.26496258e-02f, -5.72340265e-02f, -5.96455894e-02f, -1.35672480e-01f, -1.27200469e-01f, -1.61891431e-01f, -5.04172146e-02f, -1.26840606e-01f, -1.42985746e-01f, -4.91752438e-02f,
  -1.34580642e-01f, -1.81873247e-01f, -3.13928984e-02f, -8.57495144e-02f, -1.96710631e-01f, -3.87095893e-03f, -4.39738408e-02f, -2.89304107e-01f, -1.32223770e-01f, 5.17435409e-02f,
  -3.92512158e-02f, 1.48881942e-01f, 2.41213664e-02f, -2.86574271e-02f, -2.04055663e-02f, 3.28756273e-02f, 6.12811260e-02f, 6.07288852e-02f, -3.88216712e-02f, 3.65368165e-02f,
  -2.73674261e-02f, 4.29245159e-02f, 1.93420872e-02f, 1.15994707e-01f, 4.75014560e-02f, -9.58396569e-02f, -5.99070527e-02f, 8.85590762e-02f, 1.69893689e-02f, -7.25844502e-02f,
  -4.18691821e-02f, -5.35314344e-02f, -6.63575754e-02f, 1.00960853e-02f, -7.93655068e-02f, -5.31979427e-02f, 3.48528959e-02f, -6.39522150e-02f, 1.01157892e-02f, -8.78339037e-02f,
  4.87246275e-01f, 2.78606452e-02f, 2.09086463e-01f, 1.08628467e-01f, -6.57640770e-02f, -3.82235721e-02f, 1.26188695e-01f, -8.17708448e-02f, 9.35468078e-02f, -3.01759932e-02f,
  -1.06887273e-01f, 6.91092685e-02f, 6.67150468e-02f, -9.53756794e-02f, -1.06168896e-01f, -1.34480476e-01f, 2.97963023e-02f, 7.20787644e-02f, -2.42246911e-02f, -1.49845496e-01f,
  -3.52750905e-02f, -4.86989692e-03f, 2.96713352e-01f, 1.99665874e-01f, -8.31601024e-03f, 2.76769698e-01f, 3.27800155e-01f, 4.95508425e-02f, 2.29452148e-01f, 3.14825237e-01f,
  3.66060853e-01f, -8.23927760e-01f, -3.10202807e-01f, -2.10350543e-01f, -2.78319657e-01f, -1.20845653e-01f, -2.54694194e-01f, -3.78460772e-02f, 1.99591946e-02f, -4.06151980e-01f,
  -8.80522728e-02f, 3.94865245e-01f, 2.86372036e-01f, 2.40861565e-01f, 3.97849798e-01f, -3.06848228e-01f, -3.40365082e-01f, 3.14406335e-01f, 7.13458776e-01f, 2.99961418e-01f,
  -8.49377066e-02f, -3.76350321e-02f, 3.40828776e-01f, 2.55350471e-02f, -3.56033921e-01f, 6.37909919e-02f, -3.77388060e-01f, -1.28389880e-01f, -1.37078717e-01f, -4.27211106e-01f,
  -2.21795022e-01f, -9.50817391e-03f, 3.23669344e-01f, 1.56362250e-01f, -1.69852197e-01f, 8.11921339e-03f, -5.54776611e-03f, -1.97282117e-02f, -2.23573521e-02f, -7.74203464e-02f,
  2.89834589e-02f, 3.20501141e-02f, 1.89398527e-02f, -7.13251233e-02f, 1.92433912e-02f, 3.83227132e-02f, -2.25595781e-03f, 1.32672027e-01f, 1.24641918e-01f, -9.39153284e-02f,
  -2.22076714e-01f, -8.88053998e-02f, -5.27921543e-02f, 1.04109935e-01f, 1.03412442e-01f, 2.06311256e-01f, 3.07920258e-02f, 2.09611461e-01f, 1.29216582e-01f, -1.08140282e-01f,
  -7.12132230e-02f, 2.65048798e-02f, 7.99742192e-02f, 4.24169973e-02f, -2.26992294e-02f, 9.02722217e-03f, -3.23009938e-02f, 3.64921894e-03f, 1.33057073e-01f, -2.05070078e-02f,
  4.93981317e-03f, -7.39095956e-02f, -2.56799217e-02f, -4.12116572e-02f, 1.22129591e-02f, -7.16731027e-02f, 4.54869233e-02f, -2.97229979e-02f, 4.77535129e-02f, -7.55543336e-02f,
  9.44537520e-02f, 1.49108912e-03f, -4.53705192e-02f, 2.67343726e-02f, -5.17374501e-02f, -3.34521011e-02f, 5.66799156e-02f, 3.65115739e-02f, 4.33800034e-02f, -7.69656897e-02f,
  -4.07557115e-02f, 3.29820871e-01f, -9.22919959e-02f, 1.96423888e-01f, -1.35256693e-01f, -4.01508994e-02f, 3.72673408e-03f, -1.86214969e-02f, -7.78493211e-02f, -4.18844037e-02f,
  -4.84932140e-02f, 1.84221640e-01f, -1.30351409e-01f, -7.20279664e-02f, 2.76007000e-02f, 2.54914425e-02f, -6.79144785e-02f, 5.08841574e-02f, 9.91987661e-02f, -1.53882772e-01f,
  -1.84784174e-01f, -3.52392681e-02f, 1.53234288e-01f, 1.89388581e-02f, -2.52049626e-03f, 2.22434968e-01f, -2.13277899e-02f, 6.58793747e-03f, 1.50766850e-01f, -2.91626155e-01f,
  1.38162792e-01f, 1.45862028e-01f, -2.48428777e-01f, 4.39711928e-01f, 2.15724826e-01f, -1.73931438e-02f, 5.22029214e-02f, 1.01101957e-01f, 3.10020208e-01f, 6.33454248e-02f,
  -1.75098151e-01f, -2.11452797e-01f, -1.30031809e-01f, -2.55283087e-01f, -1.43145308e-01f, 2.80018859e-02f, 2.15231851e-01f, -9.23184305e-02f, -2.66882807e-01f, -6.85587600e-02f,
  1.50233462e-01f, 1.47937179e-01f, 1.39804110e-01f, -6.09173626e-03f, 1.99777596e-02f, 7.65738413e-02f, 1.90234140e-01f, -2.19657067e-02f, -2.30830476e-01f, 1.00089759e-01f,
  -4.76269543e-01f, -3.13076407e-01f, -6.26812056e-02f, -6.77026510e-02f, -9.16766971e-02f, -9.94042605e-02f, -1.11415550e-01f, -5.60228117e-02f, -1.12278476e-01f, 7.72290304e-03f,
  -9.22654346e-02f, -9.73107964e-02f, -1.75049111e-01f, -1.53067425e-01f, 2.97689810e-02f, -4.54435907e-02f, -1.88380759e-02f, -1.88706696e-01f, -1.63475215e-01f, -1.23843893e-01f,
  -9.70680639e-02f, -2.47519255e-01f, -1.84147969e-01f, -7.27428943e-02f, -2.03609124e-01f, -1.32602707e-01f, -2.31479824e-01f, -1.11214995e-01f, -2.46285170e-01f, 1.99788928e-01f,
  3.61010246e-02f, 5.76682680e-04f, 2.66347756e-03f, 6.86869547e-02f, 2.87849233e-02f, 1.80466548e-02f, -2.90334392e-02f, 1.14919089e-01f, 1.63972974e-02f, 7.06788525e-02f,
  1.17472578e-02f, -3.38103697e-02f, 1.88492090e-02f, 6.45295903e-02f, -2.34608594e-02f, -4.75844257e-02f, 3.69270705e-02f, 7.52813444e-02f, -3.35342512e-02f, 9.93112382e-03f,
  -3.28495465e-02f, 3.35216299e-02f, 3.47618051e-02f, -1.66760292e-02f, -1.03928275e-01f, 3.29676233e-02f, -9.22341198e-02f, -5.70996776e-02f, -3.33545804e-02f, -1.86235867e-02f,
  4.15666699e-01f, -3.21552008e-01f, -3.31008919e-02f, 5.14372438e-02f, 3.68798375e-02f, -4.74115945e-02f, 1.53111937e-02f, -4.72011603e-03f, -9.37469974e-02f, 7.06259832e-02f,
  -2.42068380e-01f, -1.26400158e-01f, -4.21531238e-02f, -4.90273461e-02f, 1.30808949e-02f, -7.16740042e-02f, 1.99924365e-01f, 5.38031459e-02f, -2.95212567e-02f, 4.83252443e-02f,
  7.31029436e-02f, 1.51444912e-01f, 1.80756778e-01f, 1.23425283e-01f, 2.31672153e-02f, 8.63338448e-03f, 9.78107229e-02f, 1.44999877e-01f, 6.21069260e-02f, 5.43926179e-01f,
  3.82229209e-01f, -6.04602933e-01f, 3.93917322e-01f, 8.67452174e-02f, 1.92689180e-01f, 2.01198608e-01f, -1.09516911e-01f, 3.93028446e-02f, 2.23817416e-02f, -9.02430415e-02f,
  -2.49440581e-01f, -6.36646450e-02f, -1.91213470e-02f, -1.50201947e-03f, -2.23437008e-02f, 1.09424628e-03f, 1.83661059e-01f, 4.95175540e-01f, 6.03851676e-01f, 1.19886801e-01f,
  -1.20506279e-01f, -9.33418199e-02f, 3.76442485e-02f, 3.19719897e-03f, -1.54788882e-01f, -1.01412868e-03f, -1.43922167e-02f, -2.06425041e-01f, -1.90818235e-01f, -6.33765617e-03f,
  4.15319614e-02f, -2.98530281e-01f, 2.70514429e-01f, -2.03726247e-01f, -7.02371299e-02f, 4.21738587e-02f, 9.56306756e-02f, 2.10524052e-02f, -7.47907115e-03f, -7.43686035e-02f,
  -1.95132226e-01f, -7.29588196e-02f, -4.37431596e-02f, -1.41073009e-02f, -1.88758131e-02f, 9.09454376e-02f, -8.68639126e-02f, 3.52224447e-02f, -5.00130765e-02f, -1.44824728e-01f,
  -2.91544795e-01f, -1.12941220e-01f, 1.18815280e-01f, 4.06116396e-02f, -1.11164838e-01f, 9.36367661e-02f, -1.24081150e-01f, -1.22346424e-01f, 7.38770352e-04f, -1.07440516e-01f,
  4.28104885e-02f, 1.27643481e-01f, -1.66811589e-02f, 4.35354896e-02f, 1.63235664e-02f, 4.81706820e-02f, 4.41162884e-02f, 6.88102003e-03f, 1.96514037e-02f, 1.42272282e-02f,
  -1.81069523e-02f, 5.99386431e-02f, 8.79351348e-02f, 1.13769379e-02f, -1.07327197e-02f, -6.80652820e-03f, 8.19070861e-02f, -1.12358205e-01f, 4.25759517e-02f, -8.31376296e-03f,
  5.21636084e-02f, -8.26254208e-03f, 2.29981281e-02f, -7.12918490e-02f, -6.27196357e-02f, 6.34419098e-02f, -1.54577410e-02f, -7.83615038e-02f, -4.31279093e-03f, -4.46113609e-02f,
  -1.23137057e-01f, 1.01970993e-01f, 1.90311894e-01f, 1.95347331e-02f, -1.95018649e-02f, -1.81634694e-01f, -6.99709728e-02f, -3.24407257e-02f, -1.32909209e-01f, 3.06788366e-02f,
  -1.41781181e-01f, -3.70576866e-02f, -8.17863718e-02f, -1.08138248e-01f, 2.41719604e-01f, 8.30778703e-02f, -1.39698014e-01f, 2.42060237e-02f, -1.19456954e-01f, -1.75653338e-01f,
  -2.98761249e-01f, 2.22757503e-01f, 3.56247663e-01f, 2.28902459e-01f, 3.93871963e-03f, 3.43251914e-01f, 1.93823680e-01f, 1.11445285e-01f, 3.37680072e-01f, 1.38468444e-01f,
  1.13074708e+00f, 6.12655103e-01f, 4.44704354e-01f, 2.04755902e-01f, -1.01903766e-01f, -1.21256188e-01f, -2.19852105e-02f, -1.14188343e-01f, -1.75499603e-01f, 9.59443823e-02f,
  1.44096419e-01f, -1.35130584e-01f, -1.75565287e-01f, -1.66366041e-01f, 3.71944942e-02f, -1.75995138e-02f, 5.89796202e-03f, 3.06178451e-01f, 9.95010510e-02f, 7.46667013e-02f,
  1.90833444e-03f, 2.29133174e-01f, 3.72152060e-01f, 2.02318937e-01f, 7.82837868e-02f, -1.37714043e-01f, 7.85539672e-02f, 2.99735874e-01f, 2.23358363e-01f, 3.35847437e-01f,
  5.38386941e-01f, 6.75103784e-01f, -4.37858105e-01f, -1.27208993e-01f, 1.02139696e-01f, 4.82866354e-02f, 1.84477642e-02f, -2.39349883e-02f, -3.27971689e-02f, 9.23149381e-03f,
  4.22232971e-02f, 7.77163506e-02f, -5.89606948e-02f, -9.34110358e-02f, 5.80372438e-02f, -2.58159451e-02f, 1.96366925e-02f, 1.60897717e-01f, -2.34890673e-02f, 1.09990612e-01f,
  -1.17147759e-01f, 9.51292589e-02f, 1.76836863e-01f, -2.55466133e-01f, -7.75024444e-02f, -6.94037452e-02f, -4.14126087e-03f, -2.93549523e-02f, -2.17993115e-03f, 3.10210586e-02f,
  -1.60956576e-01f, 4.21394370e-02f, 4.59076315e-02f, 2.56595877e-03f, 6.60246909e-02f, -1.04268484e-01f, -1.27386935e-02f, -3.70970331e-02f, 2.34026965e-02f, -1.35420365e-02f,
  -5.96570000e-02f, 1.37680927e-02f, -2.04473622e-02f, -1.28968628e-02f, -1.07311711e-01f, 6.62892461e-02f, 2.89728921e-02f, 2.70131808e-02f, 4.29723831e-03f, -5.43318391e-02f,
  -2.21628905e-03f, 2.81004310e-02f, -3.55247855e-02f, -8.12535957e-02f, -2.06972053e-03f, -3.74407321e-02f, 5.38860522e-02f, -4.61642370e-02f, -3.55242044e-02f, 5.76508641e-02f,
  -3.43908638e-01f, -3.09833288e-01f, -5.79560921e-03f, 3.49146985e-02f, 1.12072855e-01f, -2.81561092e-02f, 8.66828710e-02f, -1.80374905e-02f, 8.26567113e-02f, 2.69820858e-02f,
  5.47879860e-02f, 3.18144006e-03f, 1.23375300e-02f, -5.98398894e-02f, -1.04511239e-01f, -5.96101619e-02f, -1.05215684e-01f, -4.26767841e-02f, -1.74246177e-01f, 6.80529252e-02f,
  -1.30691662e-01f, -1.55202821e-01f, -1.46062180e-01f, -3.59834820e-01f, -1.37547269e-01f, -3.10756981e-01f, -1.74108669e-01f, -2.02054620e-01f, -2.56993473e-01f, -3.37281823e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  3.91579479e-01f, 3.80451322e-01f, 4.19372171e-01f, -2.04463955e-02f, 4.60670292e-01f, 4.98206526e-01f, 3.62203032e-01f, 6.69979930e-01f, 4.36382085e-01f, 5.34225166e-01f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -6.10543191e-01f, -4.75493342e-01f, -1.28991827e-01f, -1.79070104e-02f, 3.33589315e-01f, 6.45605326e-01f, 7.22138703e-01f, 7.96935439e-01f, -9.93718281e-02f, -2.10379869e-01f,
  -4.50810879e-01f, -8.59476626e-01f, 9.55459774e-01f, -1.59999564e-01f, -4.02229071e-01f, -4.19229746e-01f, 2.48677000e-01f, 2.43319809e-01f, -6.47650123e-01f, -3.34188670e-01f,
  1.61517307e-01f, 1.01112449e+00f, -1.45603403e-01f, 2.88374901e-01f, -4.82847005e-01f, 6.55420899e-01f, -4.86833334e-01f, 7.26321638e-01f, 1.18239057e+00f, -5.28756320e-01f,
  5.77952504e-01f, 1.93844914e-01f, 3.50821435e-01f, 4.90893483e-01f, 4.60365921e-01f, 4.98873368e-02f, 3.98110896e-01f, -2.08776951e-01f, 1.87358350e-01f, -6.68966293e-01f,
  1.40126085e+00f, -6.80836141e-01f, -3.22744787e-01f, -2.65539676e-01f, 6.21230841e-01f, -1.62866756e-01f, 1.60634190e-01f, -3.32006425e-01f, 5.79591572e-01f, 7.76357949e-02f,
  -6.64392710e-01f, -3.91758382e-01f, -1.28384674e+00f, -1.00851297e+00f, 8.10623050e-01f, 2.31129795e-01f, -7.95244873e-02f, -1.89366847e-01f, 5.65621912e-01f, -1.29430577e-01f,
  -3.58031690e-01f, -5.87742448e-01f, 3.32024619e-02f, -5.20677924e-01f, -6.85795665e-01f, 2.70294011e-01f, 3.21251571e-01f, -4.11780626e-01f, 1.21446705e+00f, -2.40475371e-01f,
  1.09198856e+00f, -4.65495825e-01f, -5.09279013e-01f, -1.35455905e-02f, 3.21407944e-01f, 2.87819117e-01f, -7.91902483e-01f, 2.17846557e-01f, -3.08714032e-01f, -4.71759468e-01f,
  2.63079822e-01f, 1.42908245e-01f, 5.85489988e-01f, -5.28109431e-01f, 8.43031883e-01f, 5.62172949e-01f, -2.55219609e-01f, 8.15039158e-01f, -2.38268554e-01f, 3.46481651e-01f,
  -7.20287263e-01f, 3.77130836e-01f, -5.81086338e-01f, 1.08631873e+00f, -2.94015557e-01f, -3.48159909e-01f, -1.62204891e-01f, 6.44558728e-01f, 1.24123313e-01f, 9.64764535e-01f,
  3.33584160e-01f, -5.32404594e-02f, -8.30401719e-01f, -3.96726340e-01f, 5.60417831e-01f, -6.68083787e-01f, 3.03292632e-01f, -7.79486820e-02f, 5.73175475e-02f, -2.83344865e-01f,
  -1.33894980e-01f, 1.09246349e+00f, -1.89700514e-01f, 9.14583802e-02f, -5.35955787e-01f, 4.65387821e-01f, 1.59134060e-01f, -7.56337404e-01f, -2.41923124e-01f, -3.90299499e-01f,
  1.10084169e-01f, 9.18638229e-01f, 4.37562615e-01f, -3.82112175e-01f, -5.28056286e-02f, 3.99600059e-01f, -3.50850046e-01f, -7.54570007e-01f, 1.11439146e-01f, -5.17395616e-01f,
  5.56298554e-01f, 4.85949904e-01f, -7.92091250e-01f, 1.61550380e-02f, -5.45625746e-01f, -2.08363518e-01f, -3.06406826e-01f, -2.14624390e-01f, -3.90101403e-01f, -2.01768070e-01f,
  5.95651940e-02f, 5.59726238e-01f, 1.38237989e+00f, -1.36639655e-01f, 9.60370600e-01f, -1.06019187e+00f, 5.89560270e-01f, 2.25901589e-01f, 9.20407712e-01f, -4.33933362e-02f,
  6.23169184e-01f, -5.97283423e-01f, -7.03682899e-02f, 1.78446621e-01f, 3.84577245e-01f, -1.42525285e-01f, -4.53905910e-01f, -1.27060831e-01f, -3.56336325e-01f, 5.51342249e-01f,
  -7.47515976e-01f, 7.27331564e-02f, -6.30284488e-01f, -3.87092710e-01f, -7.81827986e-01f, -1.08389688e+00f, -6.85137391e-01f, 6.32908762e-01f, 9.23659354e-02f, -1.62440822e-01f,
  3.55078787e-01f, 1.04924750e+00f, -4.26598650e-04f, 1.07100504e-02f, 2.03298956e-01f, -3.50625783e-01f, -7.43968010e-01f, -2.15753004e-01f, -3.52477849e-01f, 1.73005030e-01f,
  -1.32712340e+00f, 7.92786837e-01f, -2.37457976e-01f, -2.73967057e-01f, -8.67120564e-01f, -3.22153628e-01f, -4.27719980e-01f, -3.11048627e-01f, -3.06779832e-01f, -3.16813707e-01f,
  -4.30467278e-01f, 1.27522933e+00f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -5.47708631e-01f, -3.12965363e-01f, -4.86490084e-03f, 4.76260148e-02f, 1.06424972e-01f, 5.67379773e-01f, -3.21009070e-01f, -1.49074495e-01f, 1.55531287e-01f, 1.12725973e-01f,
  -1.53794676e-01f, 4.41097796e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    