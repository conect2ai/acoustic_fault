/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.38103354e-01f, -2.91006565e-02f, 2.28426382e-02f, 4.18425411e-01f, 1.24940954e-01f, -1.24021061e-01f, -2.24950999e-01f, -3.03405784e-02f, 5.74527532e-02f, 7.04392344e-02f,
  9.94054750e-02f, 1.99764565e-01f, 5.41037507e-02f, 1.57931950e-02f, -1.95478141e-01f, -1.13514066e-01f, 7.32035786e-02f, 1.31293908e-01f, -9.44488421e-02f, -1.01104967e-01f,
  6.92263842e-02f, 2.61846334e-01f, 2.88536876e-01f, 6.55058622e-02f, 1.61997110e-01f, -1.70321524e-04f, 2.34510869e-01f, 1.56887189e-01f, -2.22734556e-01f, 1.35401905e-01f,
  -7.13582709e-02f, -5.23385070e-02f, 1.28690982e-02f, 2.84223966e-02f, 6.05402291e-02f, 3.37496921e-02f, -4.61610816e-02f, 6.20523505e-02f, 2.78559607e-02f, -2.18464732e-02f,
  1.10744826e-01f, -3.19152363e-02f, -2.31185146e-02f, 1.15048461e-01f, 3.19149159e-02f, -7.44988769e-02f, -8.52316897e-03f, -7.33260214e-02f, -7.67309591e-02f, -2.35663410e-02f,
  -2.55294032e-02f, -1.40037062e-02f, 9.55131948e-02f, -8.87907669e-02f, -2.06441656e-01f, -1.59386452e-03f, -1.62599221e-01f, -1.21283494e-01f, -1.13368079e-01f, -7.93616697e-02f,
  1.61436815e-02f, -3.80248390e-02f, 5.18584996e-02f, 5.19287772e-03f, -2.90876739e-02f, -8.37782677e-03f, -5.14605688e-03f, -5.28711639e-02f, 1.01419548e-02f, 1.61870345e-02f,
  1.89501531e-02f, -2.04219036e-02f, -8.15023948e-03f, 1.01948909e-01f, 4.29720432e-02f, 1.89891104e-02f, -7.73358569e-02f, -3.60396765e-02f, 4.33102027e-02f, 3.42717953e-02f,
  -2.93562170e-02f, -4.77691554e-02f, 1.05861217e-01f, -1.23459876e-01f, 5.43591827e-02f, 2.28157137e-02f, -3.01247928e-02f, -6.72691911e-02f, 1.41928736e-02f, 2.96863094e-02f,
  1.78637236e-01f, -1.56390760e-02f, 7.97601715e-02f, 2.89058350e-02f, 5.04423045e-02f, -4.79733683e-02f, 4.20205370e-02f, -8.95881839e-03f, 1.41510135e-02f, -3.38276215e-02f,
  -1.05638616e-01f, 5.10085747e-03f, 5.89643372e-03f, -7.24501759e-02f, 2.51060668e-02f, 9.22661126e-02f, 3.20515148e-02f, 5.90458326e-02f, -8.96496326e-03f, -2.71272529e-02f,
  1.65676400e-02f, -2.63378099e-02f, 3.53045426e-02f, -1.79151464e-02f, -1.17257750e-02f, 4.35900725e-02f, 3.28811780e-02f, -2.43031047e-02f, -4.03299592e-02f, 5.33753671e-02f,
  2.00658396e-01f, -3.27346772e-01f, 1.35739729e-01f, 1.23102896e-01f, 2.56136470e-02f, 9.25145000e-02f, -2.29847997e-01f, -1.23298001e-02f, 1.24644469e-02f, -1.86746150e-01f,
  1.42126735e-02f, 6.53448701e-02f, 2.64226217e-02f, 5.13292439e-02f, 5.02592586e-02f, -2.73691207e-01f, -2.89270014e-01f, 6.58205897e-02f, 3.64465892e-01f, 1.30742446e-01f,
  -5.13752773e-02f, 3.54790986e-02f, 1.57012910e-01f, 1.44496057e-02f, -1.53945133e-01f, 2.24293768e-01f, -4.59530316e-02f, -5.89146502e-02f, -4.87269089e-02f, -3.62163812e-01f,
  3.22292559e-02f, 1.50254788e-02f, 1.58583429e-02f, 2.64516119e-02f, 3.21051925e-02f, 1.02735367e-02f, -1.50425620e-02f, -8.35820362e-02f, 6.11624196e-02f, -1.29835039e-01f,
  -6.61995858e-02f, -5.55825941e-02f, 9.67037454e-02f, -7.06189871e-02f, -3.46438624e-02f, -4.48699407e-02f, -1.57764629e-02f, 4.86124977e-02f, 8.14362150e-03f, -6.65711090e-02f,
  -6.60568476e-02f, -2.22610459e-02f, 6.59722611e-02f, -7.05170780e-02f, 3.98086496e-02f, 1.03815868e-01f, 2.50759674e-03f, -3.36506441e-02f, 7.96702877e-02f, -1.19183913e-01f,
  2.35978290e-02f, -1.13629000e-02f, -5.35669439e-02f, -1.54278120e-02f, 2.81649493e-02f, -4.11152951e-02f, 2.27298196e-02f, -4.38712770e-03f, -3.52040939e-02f, -9.03167482e-03f,
  6.24604858e-02f, -2.60816999e-02f, 1.45790447e-02f, -3.08184568e-02f, -4.71013784e-02f, -6.22978024e-02f, 3.42828222e-02f, -5.02611212e-02f, 3.66472527e-02f, 1.30327884e-02f,
  1.59105696e-02f, 5.01055494e-02f, 3.63449082e-02f, 2.97865998e-02f, -1.14037059e-02f, -2.85062604e-02f, -5.09154461e-02f, 6.76721195e-03f, -2.84694321e-03f, -5.27046807e-02f,
  1.64820567e-01f, -9.95719060e-03f, -2.43086484e-03f, 6.57016784e-02f, 1.22466743e-01f, -3.19125107e-03f, -1.33566279e-02f, -2.75516659e-02f, -1.98789015e-02f, 1.99295338e-02f,
  2.86046285e-02f, 5.87945664e-03f, -1.37011372e-02f, 3.78391556e-02f, 6.19813241e-02f, -6.58439891e-03f, 2.17162929e-02f, 1.80554032e-01f, -1.91896893e-02f, 6.19419590e-02f,
  -1.76199507e-02f, 5.46982735e-02f, 9.24036801e-02f, -2.15282440e-02f, 9.31557789e-02f, 1.89231917e-01f, 8.10329691e-02f, 1.70650616e-01f, 2.40893707e-01f, 1.34814501e-01f,
  1.58991098e-01f, -2.18117461e-01f, -8.40608999e-02f, 1.46746337e-01f, -9.55772102e-02f, -2.52466649e-01f, -5.46461105e-01f, -1.61830232e-01f, 6.55303299e-02f, -1.12542681e-01f,
  -3.53548005e-02f, 1.52677715e-01f, 2.00061619e-01f, 1.22534670e-01f, -5.54241687e-02f, -2.00743884e-01f, -8.38007703e-02f, 8.06193724e-02f, 9.71174166e-02f, -4.84500139e-04f,
  1.75861139e-02f, 9.05618668e-02f, 1.65681124e-01f, 5.56691550e-02f, 5.89549877e-02f, 1.62080467e-01f, -4.28562276e-02f, 1.68580178e-03f, 7.44791105e-02f, 1.31864980e-01f,
  -1.51599407e-01f, 1.46915354e-02f, 5.95281310e-02f, 1.86556622e-01f, 4.02592542e-03f, 8.18321295e-03f, -9.58647430e-02f, -2.25813761e-02f, 1.16885267e-02f, -1.54633289e-02f,
  -2.23358558e-03f, 3.43227684e-02f, 6.40941113e-02f, -8.25783145e-03f, 5.26651964e-02f, -4.08676863e-02f, -3.44926864e-02f, -1.63274594e-02f, -2.25104298e-02f, -1.13072552e-01f,
  -2.03270484e-02f, -8.24964140e-04f, -6.83003217e-02f, 1.11159850e-02f, 3.73388338e-03f, 7.02175125e-02f, -4.99154963e-02f, 4.33159433e-02f, 9.89417583e-02f, 2.06006248e-03f,
  3.41708735e-02f, 5.00669051e-03f, -4.36145179e-02f, -8.28139856e-03f, -1.22304978e-02f, 1.30650010e-02f, 1.37912810e-01f, -2.30282377e-02f, 6.20233379e-02f, -2.23746877e-02f,
  7.47446669e-03f, -4.11206950e-03f, -4.64689285e-02f, -4.00605984e-02f, 4.60365005e-02f, -5.16307950e-02f, -5.76017499e-02f, 3.96452704e-03f, 3.78500260e-02f, 3.45188491e-02f,
  -1.55906577e-03f, 1.84206152e-03f, -8.57638661e-03f, -6.62403181e-03f, 3.08360532e-02f, -2.99357977e-02f, 4.76626828e-02f, -2.14702077e-02f, 9.97252986e-02f, -1.09217828e-03f,
  -4.50110026e-02f, 1.02611385e-01f, -1.17909230e-01f, -7.43795261e-02f, 2.29233839e-02f, 3.58795449e-02f, -3.65245081e-02f, -2.66672242e-02f, 8.80094543e-02f, -2.59733349e-02f,
  -1.06648682e-02f, 6.00683726e-02f, -6.20744787e-02f, 7.95838535e-02f, 7.11384416e-02f, 6.62980182e-03f, -3.77025409e-03f, 1.84238553e-02f, 2.19667871e-02f, -5.03275804e-02f,
  -1.72891334e-01f, -4.46837619e-02f, -6.09919168e-02f, -1.06064290e-01f, -5.68626309e-03f, -1.63151603e-02f, -1.47135243e-01f, -8.10690895e-02f, -1.46262929e-01f, -2.74865359e-01f,
  -1.81939736e-01f, -1.60001770e-01f, 3.30960006e-01f, -2.52017289e-01f, -4.23945151e-02f, 5.94532974e-02f, 2.18224749e-01f, -1.81721687e-01f, -2.58940041e-01f, -1.61200818e-02f,
  -2.31812999e-01f, -1.78102106e-01f, -1.62088886e-01f, 8.19775090e-02f, 1.26058683e-01f, 2.20961645e-01f, 2.59889394e-01f, 3.37279797e-01f, 2.11974174e-01f, 9.89873707e-02f,
  -4.08986621e-02f, -1.67130455e-02f, -9.41855535e-02f, -6.02396429e-02f, -9.06306133e-02f, -4.66547310e-02f, -6.13264479e-02f, 7.12079331e-02f, -7.20682144e-02f, 2.09303051e-01f,
  3.71494949e-01f, -5.17296270e-02f, 1.41612883e-03f, -2.35834569e-02f, 4.67627719e-02f, -1.63472779e-02f, 2.42153611e-02f, 3.22648929e-03f, -1.49730086e-01f, 1.13938991e-02f,
  -9.05420035e-02f, -8.42388645e-02f, -3.20897922e-02f, 3.24820243e-02f, 2.04193406e-02f, -2.69311871e-02f, -7.44357705e-02f, -1.62457898e-02f, 3.62456851e-02f, 3.59821059e-02f,
  -7.04808235e-02f, -1.60989612e-02f, 1.15597293e-01f, 2.59565637e-02f, 5.28763793e-02f, -1.16273817e-02f, -3.09821609e-02f, 6.60357922e-02f, 4.86877486e-02f, -7.89119527e-02f,
  -8.27928167e-03f, 1.80021729e-02f, 4.13293317e-02f, -3.99230644e-02f, -4.09455262e-02f, -5.26415557e-02f, 5.37161976e-02f, -5.52229434e-02f, -2.78044716e-02f, -1.83332115e-02f,
  -8.78948197e-02f, 9.34279338e-02f, -9.21786670e-03f, -4.41061594e-02f, 6.49290206e-03f, 3.96564417e-02f, -7.01842681e-02f, -3.21455710e-02f, 3.62354913e-03f, -1.23996083e-02f,
  -2.25643702e-02f, 7.71087687e-03f, 3.71875130e-02f, 4.16229367e-02f, 3.46104912e-02f, -1.44828176e-02f, 1.48990015e-02f, -3.72469202e-02f, -1.11410944e-02f, -6.93472922e-02f,
  -2.00004056e-01f, 9.02052745e-02f, 2.19396725e-02f, -2.67960615e-02f, -1.37193622e-02f, -3.20066661e-02f, 3.92794535e-02f, -1.74893532e-02f, 1.69294495e-02f, -5.91526628e-02f,
  -2.63441354e-02f, 3.69817466e-02f, 9.67011973e-03f, -4.36312109e-02f, 8.41378644e-02f, -1.74630582e-02f, -6.59076218e-03f, -8.88168626e-03f, 6.52485266e-02f, -9.27110948e-03f,
  -1.03818275e-01f, -3.78700159e-02f, -1.47192096e-02f, 1.04464777e-02f, -4.08701971e-03f, -4.73814793e-02f, 5.29100411e-02f, -3.10772154e-02f, 9.41762775e-02f, -1.18752189e-01f,
  -1.07185952e-01f, 3.10894430e-01f, 2.54986376e-01f, 4.83211465e-02f, -6.67159110e-02f, -1.40177503e-01f, -4.19580517e-03f, -6.60080314e-02f, -8.76808837e-02f, 1.29712835e-01f,
  1.67268246e-01f, -8.39591846e-02f, -7.34031722e-02f, -1.42723233e-01f, 5.42759139e-04f, 1.33571014e-01f, 9.98490676e-02f, -1.64245069e-01f, -4.24403280e-01f, -1.70883894e-01f,
  -1.14473507e-01f, -1.54771479e-02f, 7.70006478e-02f, -1.36839926e-01f, 1.38043225e-01f, -2.14056388e-01f, 2.01674283e-01f, 2.46494383e-01f, 7.96089619e-02f, 3.52323651e-01f,
  1.59562245e-01f, 3.19318682e-01f, -1.97320893e-01f, 8.49094149e-03f, 1.44167751e-01f, -1.99970622e-02f, -3.41361575e-02f, -4.14208360e-02f, 3.72523181e-02f, 1.79697741e-02f,
  -1.22124637e-02f, -3.06911264e-02f, 3.49495262e-02f, -2.01078337e-02f, -1.64958816e-02f, -3.30723263e-02f, 8.87579694e-02f, 8.62399712e-02f, 7.64399767e-02f, 5.66713773e-02f,
  1.64519280e-01f, 1.27456769e-01f, 1.59965027e-02f, 8.64789858e-02f, 4.05962542e-02f, -3.73930074e-02f, 1.78620651e-01f, 9.95658934e-02f, 2.68985722e-02f, 1.08137041e-01f,
  5.55476313e-03f, 3.82586084e-02f, 9.62480088e-04f, 3.01935542e-02f, -1.10718638e-01f, -2.83513963e-02f, 5.61408997e-02f, 8.88311565e-02f, -6.39757887e-02f, -3.86742875e-02f,
  1.02722831e-03f, 5.01646772e-02f, -2.56744474e-02f, -1.19411293e-02f, -6.27413765e-02f, 4.02694121e-02f, 1.77203137e-02f, 2.48614680e-02f, -3.64072584e-02f, -6.44426569e-02f,
  -6.07257485e-02f, 4.21309005e-03f, -3.18868756e-02f, 2.84430869e-02f, 6.57815337e-02f, -1.31454710e-02f, 7.87041187e-02f, -3.12106479e-02f, -3.23055945e-02f, -7.08816871e-02f,
  -1.24146588e-01f, 8.34585577e-02f, -6.69655874e-02f, 8.01983941e-03f, -3.33921723e-02f, -4.05857414e-02f, 6.02521971e-02f, 3.45130824e-02f, 6.97190240e-02f, -3.80796827e-02f,
  6.91219047e-02f, -8.22144598e-02f, 1.40301669e-02f, 4.43250425e-02f, -8.68506730e-02f, -3.25153815e-03f, 4.39105779e-02f, -1.65911037e-02f, -5.06530795e-03f, -3.85783650e-02f,
  -4.17341962e-02f, -1.41288176e-01f, -2.09354594e-01f, -4.74880636e-02f, -4.24184315e-02f, -9.92435142e-02f, -1.22405544e-01f, -7.73937181e-02f, -6.34757355e-02f, -2.73301333e-01f,
  4.35657829e-01f, -8.55612010e-03f, 1.05585456e-01f, 1.83571488e-01f, 1.31043792e-01f, -1.13409750e-01f, -1.35830373e-01f, -2.15651676e-01f, -1.61559179e-01f, 6.47105128e-02f,
  6.90668309e-03f, 2.07976028e-01f, 2.49728225e-02f, -5.53067811e-02f, 7.27641061e-02f, -3.50012593e-02f, 1.91833097e-02f, 1.31856158e-01f, 2.52042532e-01f, 9.60287452e-02f,
  1.33008063e-01f, 2.63300955e-01f, 1.97250009e-01f, -1.40051767e-02f, 4.88891453e-02f, 1.16722174e-01f, 9.65069532e-02f, 9.30703580e-02f, 2.73270849e-02f, 3.46886545e-01f,
  1.88148171e-01f, 1.13044247e-01f, -2.29951032e-02f, 5.48721626e-02f, 4.31003831e-02f, -3.92635986e-02f, 1.49740120e-02f, 6.54959083e-02f, 2.06820071e-02f, -2.10821629e-03f,
  1.10413991e-01f, -4.52111922e-02f, 4.80967388e-02f, 3.90880443e-02f, -9.46771540e-03f, -1.71422176e-02f, -8.16847831e-02f, 2.28375942e-02f, -2.25290712e-02f, -7.41574019e-02f,
  7.90251605e-03f, 9.51482877e-02f, 3.59846581e-06f, -1.56339243e-01f, -1.51603505e-01f, 1.47522807e-01f, -1.14172336e-03f, -7.93746039e-02f, 3.65523584e-02f, 5.15139066e-02f,
  4.40734066e-03f, -1.87157057e-02f, 1.03880267e-03f, 6.82815686e-02f, 2.91872397e-02f, -5.18110543e-02f, 1.92993861e-02f, 3.14599574e-02f, -2.64506713e-02f, 5.81862871e-03f,
  -6.08022586e-02f, 3.29928193e-03f, -2.72413511e-02f, -1.09329913e-02f, -2.41092741e-02f, 1.62107404e-02f, 1.26682711e-03f, -1.00770947e-02f, -9.54162516e-03f, -6.68237656e-02f,
  1.77584812e-02f, -1.13965586e-01f, 1.83888320e-02f, -6.15864918e-02f, -3.56146805e-02f, 4.44832537e-03f, 2.47171037e-02f, -5.16441427e-02f, 6.64339215e-02f, 8.67894292e-02f,
  1.39019594e-01f, -1.72301844e-01f, 1.62081122e-02f, 1.23400160e-03f, 5.25129726e-04f, -8.69575962e-02f, 2.83515211e-02f, 2.08579041e-02f, 6.04368262e-02f, 2.88877264e-02f,
  -5.23780175e-02f, -5.93947619e-02f, 3.40183862e-02f, -4.82241102e-02f, -9.22918972e-03f, -1.27378777e-02f, 3.78401205e-02f, 6.61988482e-02f, -9.75605473e-02f, -4.15302850e-02f,
  -1.00496657e-01f, -5.45083061e-02f, 1.18026756e-01f, -1.77734159e-02f, -3.66901830e-02f, 1.03192329e-01f, -2.96885762e-02f, 4.36961986e-02f, -2.78020836e-02f, 8.27415287e-03f,
  5.51525593e-01f, -1.87169477e-01f, 4.42666531e-01f, 2.65976578e-01f, 2.22694591e-01f, 8.19882974e-02f, -3.25651728e-02f, 7.17878863e-02f, 9.36434716e-02f, 5.16679026e-02f,
  -1.20788075e-01f, -2.38573328e-01f, -1.30134702e-01f, -2.06533283e-01f, -1.00647025e-02f, -2.48410832e-02f, 1.71596125e-01f, 1.94277361e-01f, 1.48709550e-01f, 1.43876910e-01f,
  -8.98660347e-02f, 1.57649875e-01f, 1.46073669e-01f, -5.22080734e-02f, 1.69193745e-01f, -2.00460196e-01f, 7.25858063e-02f, 5.36460020e-02f, -1.20241299e-01f, 8.60966295e-02f,
  -5.68497851e-02f, 3.56120676e-01f, 6.61202073e-02f, 8.24913234e-02f, -2.00903416e-02f, 8.60302988e-03f, 1.89246535e-02f, 8.55230093e-02f, -8.64492133e-02f, 6.85230419e-02f,
  1.38815884e-02f, -2.67040171e-02f, 4.32910062e-02f, -1.05874641e-02f, 7.24042952e-02f, 6.13464862e-02f, 4.07124497e-02f, 9.37464088e-02f, 2.44193524e-03f, -4.59083915e-03f,
  -4.68030013e-02f, -3.10095884e-02f, 2.24518731e-01f, 7.78369084e-02f, 8.74794200e-02f, 8.75250474e-02f, 2.82060844e-03f, 1.33857921e-01f, 3.09863780e-02f, 6.57691155e-03f,
  -4.69902036e-04f, -3.39744277e-02f, 3.14342491e-02f, 7.70186773e-03f, -1.32518709e-02f, -9.06112343e-02f, -1.29403844e-02f, -6.15136810e-02f, -2.27290392e-02f, 3.83320218e-03f,
  2.45597307e-03f, 1.95144732e-02f, -1.72002632e-02f, 8.45549181e-02f, -7.05024600e-02f, 9.16555822e-02f, -3.78642008e-02f, -3.23866121e-03f, 4.44992911e-03f, 3.63307334e-02f,
  -5.00577465e-02f, 1.22007402e-02f, 2.90199416e-03f, -8.77227187e-02f, 2.14576107e-02f, 8.21118206e-02f, -3.52705121e-02f, -5.32935075e-02f, 2.70381314e-03f, 1.03697263e-01f,
  -1.95545986e-01f, 4.64130640e-02f, -7.14268386e-02f, -7.21008554e-02f, 3.53977433e-03f, -2.85147540e-02f, -4.26213406e-02f, 5.11680217e-03f, -5.34432521e-03f, -5.58289737e-02f,
  7.41527528e-02f, 4.54563834e-02f, -6.90834271e-03f, -7.05319047e-02f, 2.86646932e-02f, -5.44553204e-03f, -1.09888144e-01f, 1.23127140e-02f, -7.30080716e-03f, -1.89195517e-02f,
  -2.60045417e-02f, -1.62173882e-02f, -7.03783184e-02f, -8.03852007e-02f, -1.10342093e-01f, -8.37840363e-02f, -8.63694921e-02f, -2.62470823e-02f, -9.58899334e-02f, -2.05186725e-01f,
  -6.60717309e-01f, -3.84752899e-01f, 2.09548511e-03f, -6.66254107e-03f, 1.08163945e-01f, -1.31894737e-01f, -3.96604031e-01f, -1.03435554e-01f, 1.91206902e-01f, -1.07761212e-01f,
  -8.17673504e-02f, 9.74225029e-02f, -1.81680638e-02f, 6.08821549e-02f, -1.74968138e-01f, -9.06137452e-02f, 9.94675681e-02f, 4.22532111e-02f, -3.55129428e-02f, 1.29901811e-01f,
  1.33788800e-02f, -1.51431724e-01f, -9.13815051e-02f, -7.07993954e-02f, 1.76569179e-01f, 1.12116091e-01f, 1.19075328e-01f, 5.56083508e-02f, 7.59638473e-02f, 2.96060771e-01f,
  3.76597419e-02f, -2.14644764e-02f, 4.64134179e-02f, 3.12056337e-02f, 1.19418696e-01f, -6.27219453e-02f, -8.58225822e-02f, 1.54242562e-02f, -2.89548747e-02f, 7.69982859e-02f,
  1.02117583e-01f, 1.02703080e-01f, 4.87891324e-02f, 1.23450801e-01f, -1.02626666e-01f, 6.34689182e-02f, 5.82454950e-02f, -1.77640971e-02f, 1.72405615e-02f, 5.11500426e-02f,
  4.04439121e-02f, 7.49209672e-02f, -1.40384659e-01f, -3.04917023e-02f, -4.07373384e-02f, 2.00309977e-01f, 2.81449202e-02f, 1.52605832e-01f, 1.25740822e-02f, -8.96416605e-02f,
  -1.25955623e-02f, 1.96301192e-02f, 3.13192755e-02f, -4.24743295e-02f, -1.25369877e-01f, 2.28487281e-03f, 1.99546237e-02f, -1.51477391e-02f, -1.29578286e-03f, -8.50023925e-02f,
  8.30463544e-02f, -3.27669270e-02f, 8.06610584e-02f, -9.01984498e-02f, -3.27349901e-02f, 9.39230025e-02f, -1.14387386e-02f, -2.17967704e-02f, 4.46299277e-02f, 3.89744565e-02f,
  3.49849067e-03f, 8.82796198e-02f, -6.39829924e-03f, 7.97320455e-02f, 4.14003693e-02f, 8.94989967e-02f, 5.10686338e-02f, -3.94611210e-02f, -3.23476493e-02f, -1.35792224e-02f,
  -3.09982240e-01f, 8.67282450e-02f, -2.59998441e-02f, -6.47090971e-02f, 2.23558210e-02f, 1.47409707e-01f, -1.60971824e-02f, 5.12158945e-02f, 1.04554556e-01f, -1.02247946e-01f,
  4.76423167e-02f, -5.99777810e-02f, -1.74545478e-02f, -5.86689860e-02f, -2.73074750e-02f, -4.08395790e-02f, -5.24925552e-02f, -2.46441364e-02f, 4.36584204e-02f, 4.36137654e-02f,
  -7.35843331e-02f, -1.69269904e-01f, -1.95656672e-01f, -1.60760149e-01f, -6.51141256e-02f, -1.86154470e-01f, -1.18302040e-01f, -9.12064537e-02f, -1.42050102e-01f, -5.11191070e-01f,
  2.08570912e-01f, 1.05261900e-01f, 1.20034534e-02f, 3.24439973e-01f, 7.57142305e-02f, -6.44799471e-02f, 2.80602109e-02f, 3.47236395e-02f, 1.55390173e-01f, 1.90139890e-01f,
  -1.36658669e-01f, -1.49881423e-01f, -1.88095614e-01f, -7.22517371e-02f, -1.19216852e-01f, 3.53193246e-02f, 2.58111298e-01f, -1.33097962e-01f, -2.74260670e-01f, -1.35836795e-01f,
  7.25574046e-02f, 1.67814001e-01f, 1.05486438e-02f, -6.62011579e-02f, 2.46198267e-01f, -6.64093569e-02f, 8.97391215e-02f, 7.06896558e-02f, -2.76781082e-01f, 4.37810421e-01f,
  -1.50100291e-01f, 8.94324705e-02f, 1.25529681e-04f, 3.51779051e-02f, -3.77470367e-02f, -6.67048444e-04f, 2.32123211e-02f, -4.22517061e-02f, -8.10136870e-02f, -7.41100824e-03f,
  -1.63167566e-02f, 3.74869779e-02f, 9.10643190e-02f, -9.07001421e-02f, 1.25957102e-01f, 9.31096748e-02f, 6.19985349e-02f, 3.29315811e-02f, 2.93569546e-02f, -3.09878774e-02f,
  3.95057574e-02f, -3.80318575e-02f, -1.76807363e-02f, -1.72507055e-02f, -6.86357319e-02f, 6.34019822e-02f, -5.08664474e-02f, 2.91207042e-02f, -5.43896817e-02f, 1.68961182e-01f,
  6.17533457e-04f, 3.14752758e-03f, -8.53268504e-02f, 4.87657823e-03f, 7.93710798e-02f, -3.69522944e-02f, 4.94548120e-02f, -1.01102991e-02f, -1.38367629e-02f, 7.35806301e-02f,
  -6.41494570e-03f, 3.94855849e-02f, 7.61399344e-02f, -9.74133834e-02f, -1.81227960e-02f, 1.49451802e-02f, 2.75688842e-02f, -1.31426323e-02f, -4.21457849e-02f, 4.85835522e-02f,
  -4.01850753e-02f, -6.71117976e-02f, 4.27171141e-02f, -1.90107431e-02f, -1.37849664e-02f, 7.26038590e-03f, 4.36003087e-03f, -1.69824958e-02f, 9.26977918e-02f, -2.95560602e-02f,
  8.83488283e-02f, -2.01197654e-01f, 5.06083071e-02f, 1.29334424e-02f, 2.94697983e-03f, -3.41264941e-02f, -2.01117061e-02f, -1.21852890e-01f, 6.33209106e-03f, 8.08025226e-02f,
  -8.77847746e-02f, -2.34575514e-02f, -3.05336043e-02f, 2.91862688e-03f, 1.18719088e-02f, -7.73856565e-02f, 2.24126279e-02f, 4.04130816e-02f, -6.11599088e-02f, -1.43164664e-03f,
  5.75869530e-03f, 6.61343262e-02f, 1.27502307e-01f, 2.71830913e-02f, 6.70171380e-02f, 2.18453631e-02f, -2.54718512e-02f, 2.26640720e-02f, -1.04841307e-01f, 1.75703660e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  9.13690850e-02f, 1.17097922e-01f, -5.96404448e-02f, 4.05076779e-02f, -4.27587442e-02f, -4.53238413e-02f, -6.18715733e-02f, -1.60580722e-03f, 1.37981579e-01f, 2.53917109e-02f,
  6.80803880e-02f, -1.00165149e-02f, 2.09207647e-02f, -9.78151932e-02f, 2.08693910e-02f, -1.20280117e-01f, 1.76729355e-02f, -6.02155663e-02f, -1.09097011e-01f, -2.07880549e-02f,
  2.50448585e-02f, -6.69440196e-04f, 4.35337611e-02f, -9.11389664e-02f, -3.87768727e-03f, -3.09174843e-02f, -1.63347868e-03f, -6.40865089e-03f, -1.26944453e-01f, -6.99820369e-02f,
  1.12697065e-01f, -2.79799886e-02f, -1.13696709e-01f, 8.03581774e-02f, 8.77262652e-02f, -3.62254940e-02f, -2.99552847e-02f, -9.67581198e-02f, 3.75997014e-02f, 6.69327751e-02f,
  -4.32001352e-02f, -4.96366061e-02f, 1.74096525e-02f, -6.96821604e-03f, -3.59302796e-02f, 5.30811585e-02f, -1.98864806e-02f, -9.24768448e-02f, -7.09040165e-02f, -1.02954982e-02f,
  -7.50665590e-02f, -7.15413764e-02f, -9.16106105e-02f, -7.43824318e-02f, -1.08198009e-01f, 1.44176483e-02f, -8.40520933e-02f, -7.23125562e-02f, -4.13292423e-02f, -4.45205607e-02f,
  -8.31497600e-04f, 7.58711528e-03f, 9.26731061e-03f, -6.38854504e-02f, 5.64131103e-02f, 1.32622132e-02f, -5.08065186e-02f, -9.06992778e-02f, -7.63676763e-02f, -7.72697628e-02f,
  -1.50358351e-02f, -9.85709205e-03f, -2.07223073e-02f, -7.04153627e-02f, -5.66824398e-04f, 6.66038096e-02f, -3.77230742e-03f, 3.80103244e-03f, -5.96776530e-02f, -3.06290388e-02f,
  -1.31052537e-02f, -5.52793331e-02f, -5.56076244e-02f, -7.69605562e-02f, -4.86155376e-02f, -2.34307330e-02f, 6.95657656e-02f, 1.51820695e-02f, 6.16988651e-02f, -6.03690557e-02f,
  1.58548117e-01f, -1.34911925e-01f, 7.20398948e-02f, 9.64223128e-03f, -1.63661111e-02f, 5.46729341e-02f, -6.93795383e-02f, 2.96990089e-02f, 5.98607399e-02f, 6.18801042e-02f,
  -7.09545612e-02f, 1.97837912e-02f, -2.44964510e-02f, -8.19351003e-02f, 7.27518126e-02f, -3.63800526e-02f, 8.93900767e-02f, -4.39296998e-02f, 5.39577706e-03f, -4.78978567e-02f,
  7.10456744e-02f, -4.15005125e-02f, -2.78009418e-02f, 2.82459892e-03f, -1.59001984e-02f, -8.50609541e-02f, -4.22295220e-02f, 8.25746432e-02f, -3.00416369e-02f, 1.18338026e-01f,
  4.68015186e-02f, -1.20522834e-01f, -5.07688001e-02f, -1.68366600e-02f, -1.60783038e-01f, -1.07095286e-01f, -1.52793810e-01f, -7.82301798e-02f, -4.13498245e-02f, -6.99299872e-02f,
  -1.02017604e-01f, 5.44667542e-02f, 5.79649210e-02f, 7.72078037e-02f, 2.15421827e-03f, -1.83864772e-01f, -1.51449934e-01f, 1.59106520e-03f, 8.65584686e-02f, -1.42420977e-01f,
  -1.60913289e-01f, 4.09210026e-02f, 9.98459533e-02f, -6.48905188e-02f, -6.64063469e-02f, 6.97507113e-02f, -1.02323527e-02f, -8.41316953e-02f, 4.90093976e-02f, 6.46949280e-03f,
  -3.17178443e-02f, -9.25421016e-04f, 4.29711789e-02f, 6.85391203e-02f, 3.96982878e-02f, 4.01649363e-02f, 6.04020851e-03f, 2.82180030e-02f, 6.10658480e-03f, -3.45631391e-02f,
  -2.05047261e-02f, 3.16540524e-02f, -7.76218623e-02f, 9.56685245e-02f, -5.21097630e-02f, 6.56927228e-02f, -4.43977453e-02f, 9.89820734e-02f, -1.25572113e-02f, -4.21080701e-02f,
  -1.33387791e-02f, -1.98816564e-02f, -3.37005518e-02f, 5.45610376e-02f, 9.16307643e-02f, 3.83152701e-02f, -4.11330228e-04f, 1.21517507e-02f, 1.50919661e-01f, 1.53053671e-01f,
  -4.35869917e-02f, -1.01271421e-02f, 6.26468956e-02f, 1.80743709e-02f, -3.60621996e-02f, -3.83485220e-02f, 9.11276191e-02f, -4.91193011e-02f, 3.54514793e-02f, -2.37864051e-02f,
  -2.81333942e-02f, 2.32352261e-02f, 9.24393237e-02f, -1.38978520e-02f, -2.35888548e-02f, 4.07166667e-02f, -9.11622718e-02f, 2.06263624e-02f, 6.14382839e-03f, 5.42552173e-02f,
  2.08856314e-02f, -7.85754398e-02f, 2.19633766e-02f, -6.34374022e-02f, 4.48010825e-02f, -2.25771051e-02f, -3.80687341e-02f, -6.75953180e-02f, -3.94592024e-02f, -5.06140031e-02f,
  6.80719619e-04f, 1.81371234e-02f, 2.13535875e-02f, 1.12705380e-01f, 2.03901227e-03f, -1.90357771e-02f, 7.53604993e-02f, 4.79486994e-02f, 7.56517332e-03f, -9.04698074e-02f,
  -7.21632317e-02f, -4.65412997e-02f, 9.76863503e-03f, -1.39525831e-02f, 4.84429412e-02f, -8.76681358e-02f, -8.23621303e-02f, 4.40539420e-02f, -8.85962322e-02f, -2.96570770e-02f,
  -1.25266284e-01f, -6.46754652e-02f, 8.37004706e-02f, 1.11226059e-01f, -1.35842769e-03f, 6.06395304e-02f, 4.25838353e-03f, 9.35709327e-02f, 2.26721335e-02f, -5.62331975e-02f,
  -6.80055246e-02f, 1.97180912e-01f, 1.61552150e-02f, 6.70397878e-02f, -1.56805888e-01f, -1.23139143e-01f, -3.96912768e-02f, 5.15725203e-02f, 7.10730031e-02f, -9.95133631e-03f,
  -2.40312442e-01f, -3.97416577e-02f, 8.33290741e-02f, 1.55056581e-01f, 1.27259120e-01f, 1.48259491e-01f, 1.79930270e-01f, 1.83029965e-01f, 8.25933442e-02f, -2.92778276e-02f,
  6.95928782e-02f, 3.92219387e-02f, 7.72424266e-02f, 2.01474860e-01f, 2.70420372e-01f, 1.02759309e-01f, -2.14504991e-02f, 1.04617499e-01f, 8.02270696e-02f, 3.39280039e-01f,
  -4.31064889e-02f, -4.29325104e-02f, -1.45241097e-01f, -1.26729831e-02f, -1.50751136e-02f, 6.06849305e-02f, -1.71254091e-02f, -6.89296052e-03f, -2.18750369e-02f, 2.64459178e-02f,
  -6.34494722e-02f, 4.33293916e-03f, 3.55132320e-03f, -6.83606742e-03f, -1.48629779e-02f, 5.03497086e-02f, 1.79912344e-01f, 1.64735079e-01f, 6.92117140e-02f, -2.77946983e-02f,
  -4.52527367e-02f, -2.94264294e-02f, -6.53579757e-02f, -8.02797303e-02f, 7.05304667e-02f, -7.53150508e-02f, -8.93811956e-02f, 3.06164697e-02f, -7.94957057e-02f, 1.05529524e-01f,
  3.46007990e-04f, 1.75087526e-02f, -8.38771313e-02f, 3.84359546e-02f, 4.08639759e-02f, 4.37553860e-02f, 1.85286589e-02f, -2.04320103e-02f, 3.47675756e-02f, 8.14205036e-02f,
  -3.05563584e-02f, -1.02864571e-01f, -1.14465074e-03f, 3.92751675e-03f, -9.79000106e-02f, -8.94567817e-02f, 2.98356768e-02f, 3.91298272e-02f, -4.93215695e-02f, 9.47621744e-03f,
  1.03789158e-01f, 1.04778968e-01f, -4.76315729e-02f, 7.67802298e-02f, -2.07531489e-02f, -3.74631695e-02f, -1.34312641e-02f, 4.62227017e-02f, -5.70834093e-02f, -8.58941004e-02f,
  -1.47743642e-01f, -2.68054038e-01f, 1.10816300e-01f, 2.40515471e-01f, -1.72552932e-02f, 4.05610688e-02f, -9.99230891e-02f, 4.48591895e-02f, -1.19765371e-01f, 6.83839023e-02f,
  -1.19256690e-01f, 3.28482836e-02f, -4.78100777e-02f, 3.47130522e-02f, -9.62566584e-02f, -1.20140709e-01f, 8.18021316e-03f, 2.34018285e-02f, -7.76214749e-02f, -8.99195224e-02f,
  5.38029373e-02f, -5.81501834e-02f, -1.08049132e-01f, -1.02344556e-02f, -5.48395142e-02f, -5.64761870e-02f, -1.36222377e-01f, -3.87411192e-02f, -1.67428508e-01f, -1.13175668e-01f,
  -1.52780768e-02f, -2.70667106e-01f, -2.62612849e-01f, 1.13146879e-01f, -1.19657420e-01f, -3.07199750e-02f, -2.74054915e-01f, 7.18361139e-02f, 1.53810591e-01f, -2.89363444e-01f,
  -8.78787711e-02f, 6.97733685e-02f, -8.46560374e-02f, -1.16373613e-01f, -5.81675917e-02f, -2.19432533e-01f, -2.40159199e-01f, -9.47912857e-02f, 8.24091434e-02f, 3.47519964e-02f,
  -4.70774509e-02f, -3.42956856e-02f, 1.00911893e-01f, 5.07131852e-02f, -1.88361332e-01f, 6.16661832e-03f, -1.12066925e-01f, -1.15161672e-01f, -1.33197963e-01f, -2.38994196e-01f,
  -1.77651137e-01f, 1.02988988e-01f, 1.13181017e-01f, -6.80752993e-02f, -8.55352916e-03f, -6.66750781e-03f, 1.47126587e-02f, -6.80419952e-02f, 4.26146314e-02f, -5.63140512e-02f,
  -1.12302657e-02f, 9.23865512e-02f, 4.48135287e-02f, -3.32001932e-02f, 7.46385679e-02f, -4.22148593e-02f, 7.21811131e-02f, -1.66619830e-02f, 2.39414312e-02f, -6.63487390e-02f,
  -7.94604123e-02f, -2.15827338e-02f, -1.28183393e-02f, 6.03277571e-02f, -5.37655652e-02f, 5.03776595e-02f, 2.95878835e-02f, 7.19352216e-02f, 7.61370733e-02f, -1.13805041e-01f,
  -7.39776157e-03f, -2.99517270e-02f, -1.49784209e-02f, 3.38752917e-03f, -6.11971244e-02f, -3.60300881e-03f, -2.04032436e-02f, -5.43147251e-02f, -9.66998842e-03f, -5.47854975e-02f,
  -1.36523806e-02f, 4.66310456e-02f, 8.81867036e-02f, -8.26239288e-02f, -9.99033302e-02f, 7.62259914e-03f, 8.27417988e-03f, -1.21371977e-01f, -1.18533932e-01f, -4.09162939e-02f,
  -5.30839600e-02f, -9.47975889e-02f, -1.04008904e-02f, 1.86203532e-02f, -4.65563759e-02f, -1.56492889e-02f, 8.65509734e-02f, 1.37500733e-01f, 3.62585187e-02f, -1.87070742e-02f,
  -2.02770270e-02f, 1.26565993e-01f, -1.22795768e-01f, 4.99492660e-02f, -9.95458141e-02f, -7.00718686e-02f, 6.86447136e-03f, 1.09939598e-01f, -2.34484896e-02f, 2.65569352e-02f,
  8.74843355e-03f, -5.97811751e-02f, 1.20637743e-02f, -2.76829209e-02f, 5.46224676e-02f, 5.26431017e-02f, -4.83902544e-02f, 5.86430542e-03f, 4.34288830e-02f, -2.46248469e-02f,
  -8.66267383e-02f, -1.40006334e-01f, 4.90700342e-02f, -9.41221043e-02f, -1.31471595e-02f, -6.13837168e-02f, -1.48249090e-01f, -1.35670498e-01f, 6.94604078e-03f, -3.07568580e-01f,
  -2.87963580e-02f, -1.15056515e-01f, -3.71233337e-02f, 2.58771986e-01f, 2.78045863e-01f, 1.67254567e-01f, 1.45502359e-01f, 1.70624584e-01f, 2.10944772e-01f, 3.81598100e-02f,
  -8.16022903e-02f, 3.68902348e-02f, 1.41294286e-01f, 3.68577540e-02f, 4.45503257e-02f, 1.51120305e-01f, 1.54740945e-01f, -5.71980514e-02f, 1.66807637e-01f, 1.51682049e-01f,
  1.00674249e-01f, -1.19966529e-01f, -2.08911732e-01f, -2.76166908e-02f, -4.80725802e-03f, 1.39441997e-01f, -6.36540428e-02f, -1.34671375e-01f, 1.16722696e-02f, -3.92984599e-02f,
  -1.45607561e-01f, -2.41253212e-01f, 1.03590943e-01f, 1.16486121e-02f, -1.31575927e-01f, -5.57996519e-02f, 3.32721905e-03f, -1.69640884e-01f, 5.36660757e-03f, 5.64196184e-02f,
  7.37426151e-03f, -8.62344280e-02f, -5.65719977e-02f, -9.30034295e-02f, -1.14865294e-02f, 5.48287705e-02f, -6.92398325e-02f, -1.19555265e-01f, 6.56885579e-02f, 1.85212437e-02f,
  -3.67563255e-02f, -1.04662843e-01f, -2.60879770e-02f, 1.26559967e-02f, 7.85519779e-02f, 6.51030764e-02f, -3.75094898e-02f, 2.67705340e-02f, -7.18144253e-02f, -4.55852598e-02f,
  3.57534774e-02f, 1.50406249e-02f, 2.60494612e-02f, 5.65073593e-03f, 1.87432095e-02f, -2.39160750e-03f, 1.76605135e-02f, -4.48259786e-02f, -5.94284968e-04f, 6.80416897e-02f,
  -5.19071072e-02f, 7.37587288e-02f, 8.17203373e-02f, 3.03314775e-02f, -8.29196498e-02f, -2.98421532e-02f, 3.96024212e-02f, -5.30510815e-03f, -8.84345323e-02f, -8.84994864e-02f,
  2.48412229e-02f, 6.01430349e-02f, -1.25855327e-01f, -1.08698204e-01f, 5.36087528e-02f, 7.67027773e-03f, -2.41850372e-02f, 7.24407062e-02f, 8.64083618e-02f, -4.91904914e-02f,
  5.92746809e-02f, 6.65781572e-02f, 1.97569691e-02f, 3.19395363e-02f, -9.90111306e-02f, -2.29889434e-02f, 2.53020003e-02f, -2.40596626e-02f, 6.69487566e-02f, -7.84187578e-03f,
  -1.27628567e-02f, -1.05252294e-02f, -7.25267828e-02f, -1.47878807e-02f, 4.94801402e-02f, 1.15260482e-01f, -6.63562417e-02f, 1.12258911e-01f, -4.79571149e-02f, -5.81013486e-02f,
  -2.72029359e-02f, 8.89993981e-02f, 6.44943789e-02f, 1.45502284e-01f, 7.74992332e-02f, 8.49477351e-02f, 3.19124502e-03f, 6.03436567e-02f, 1.15325190e-01f, 1.96054056e-02f,
  -1.14442194e-02f, -3.52003844e-03f, 3.33213620e-02f, 8.79763905e-03f, 1.34259999e-01f, 8.57533514e-02f, 8.34093913e-02f, 1.28619641e-01f, -1.38786444e-02f, -3.83905997e-03f,
  1.13384593e-02f, 1.34721166e-02f, 3.84723172e-02f, -1.45913679e-02f, 6.90229097e-03f, 3.76025736e-02f, -1.42513467e-02f, 6.55769631e-02f, 1.32378176e-01f, -4.14812267e-02f,
  6.89439029e-02f, 6.42555729e-02f, 2.60645133e-02f, -7.21335933e-02f, -3.70444283e-02f, 4.74843942e-02f, -1.36376452e-02f, -6.87489435e-02f, 9.02007073e-02f, -3.90777811e-02f,
  9.84612480e-02f, 8.04819018e-02f, 1.18997246e-01f, -5.43973893e-02f, 3.00210565e-02f, 2.46625934e-02f, 6.78064525e-02f, 2.99142953e-02f, -8.60982109e-03f, -1.90499779e-02f,
  2.29706848e-03f, 6.37007728e-02f, 3.62692997e-02f, -6.25510588e-02f, -3.78847532e-02f, -5.30333668e-02f, -8.14550295e-02f, 5.68499789e-02f, -3.75501700e-02f, -6.07190002e-03f,
  6.13166892e-04f, 4.73252237e-02f, 1.84952188e-02f, -7.28230849e-02f, -2.53126975e-02f, 6.55826330e-02f, -1.29459100e-02f, 5.23502678e-02f, 2.99036056e-02f, 1.86669268e-02f,
  -5.88813052e-02f, -9.11150053e-02f, -4.12876112e-03f, -8.72378889e-03f, -4.05524438e-03f, 4.25578803e-02f, 5.56336083e-02f, -1.08168414e-02f, -2.38366984e-02f, 5.22398464e-02f,
  4.47946526e-02f, -2.22479161e-02f, 5.66743352e-02f, -8.81239492e-03f, 9.61556938e-03f, -6.67875707e-02f, 8.31012875e-02f, 4.43020556e-03f, -3.23412418e-02f, 1.80900134e-02f,
  2.39656176e-02f, -1.16857672e-02f, 6.58714175e-02f, 5.95342629e-02f, 6.85902387e-02f, -8.99500847e-02f, 6.20568097e-02f, -1.10391513e-01f, 4.49921377e-02f, -8.54137540e-03f,
  6.13376573e-02f, -4.90848608e-02f, -1.99809577e-02f, -1.90178882e-02f, 6.45476654e-02f, -7.94207025e-03f, 8.95240810e-03f, 7.14968890e-02f, 5.29508591e-02f, 1.05515234e-01f,
  5.52704260e-02f, -4.40451037e-03f, 3.93996052e-02f, 7.09954277e-02f, 6.09771051e-02f, -5.83214825e-03f, -1.52435843e-02f, -6.57431735e-03f, 5.83324907e-03f, 4.00645658e-02f,
  1.20742656e-02f, 7.40692914e-02f, 6.12012781e-02f, -3.38390877e-04f, -5.34107117e-03f, 1.02991574e-01f, -3.82019058e-02f, 7.35454336e-02f, -2.30878778e-02f, -4.46586423e-02f,
  3.02984446e-01f, -1.03909001e-01f, -3.34144086e-02f, 2.36601233e-01f, 1.81301236e-02f, -1.17582522e-01f, -1.61653370e-01f, 1.01052634e-01f, 1.26145519e-02f, -8.40492267e-03f,
  1.09740607e-01f, 2.87901938e-01f, 2.57784277e-01f, 2.50537843e-01f, 1.18044861e-01f, 9.34604257e-02f, -7.39359856e-02f, 9.99212712e-02f, 1.06158189e-01f, 8.11420530e-02f,
  1.00857481e-01f, -4.20426503e-02f, -2.16005780e-02f, 5.57357781e-02f, -5.12646325e-02f, -2.38604918e-02f, 3.19467708e-02f, -3.00651323e-03f, -1.48744300e-01f, -1.05702283e-03f,
  7.74355512e-03f, 1.08428031e-01f, 8.28612149e-02f, 1.75457060e-01f, -7.71420971e-02f, 1.05555579e-01f, -3.58898658e-03f, -1.09340422e-01f, -5.70759736e-02f, 4.48858086e-03f,
  -8.38276595e-02f, 2.12353952e-02f, 2.00081300e-02f, -1.36983648e-01f, -1.47528574e-01f, 4.88782302e-03f, 3.36781070e-02f, 8.22086409e-02f, 1.01265736e-01f, 2.07642075e-02f,
  2.74226498e-02f, -7.64147416e-02f, -6.56245053e-02f, 7.78930038e-02f, 2.31706016e-02f, 7.97341838e-02f, -6.60723150e-02f, -1.09177800e-02f, -1.10075134e-03f, 1.94041524e-02f,
  9.80958268e-02f, 6.97732391e-03f, 1.02359556e-01f, -1.96261611e-02f, 3.55763384e-03f, -7.75611103e-02f, 4.36959453e-02f, 2.27254536e-02f, 8.18951502e-02f, -4.54677157e-02f,
  1.46428533e-02f, -3.93910743e-02f, -1.76643301e-02f, 2.43057106e-02f, 4.25039046e-02f, -9.01786312e-02f, 6.72766045e-02f, 5.30086644e-02f, -5.09868935e-02f, -1.13205882e-02f,
  6.77186809e-03f, -2.91280784e-02f, 7.08319852e-03f, 4.05049585e-02f, 4.04535644e-02f, 3.96250896e-02f, 2.93966141e-02f, -5.72516918e-02f, -6.38959035e-02f, -6.32432029e-02f,
  -8.25611949e-02f, 2.68263400e-01f, 1.89060554e-01f, 2.63506789e-02f, -1.36199117e-01f, -3.75664467e-03f, 1.19512610e-01f, 2.90057715e-02f, -3.32499808e-03f, -4.53135855e-02f,
  2.79369727e-02f, -1.32928491e-02f, 5.89801781e-02f, -4.41856608e-02f, 2.71753799e-02f, -7.18651041e-02f, -9.27300565e-03f, 2.21306607e-02f, 7.83780664e-02f, 2.38765255e-02f,
  -3.75931412e-02f, -3.77304517e-02f, 6.69251159e-02f, 2.63681784e-02f, 3.54932132e-03f, -8.47473368e-03f, -4.10751952e-03f, -9.41487327e-02f, -6.34177923e-02f, -6.05046414e-02f,
  8.14608671e-03f, 6.03512512e-04f, 8.10786858e-02f, 1.76789522e-01f, 1.44741684e-02f, 7.20765069e-02f, 5.52736036e-02f, 8.18660259e-02f, 1.16909333e-01f, 1.01204135e-01f,
  7.37044513e-02f, 2.32428953e-01f, 8.00011605e-02f, 2.02663034e-01f, 6.97929263e-02f, 5.40329097e-03f, 1.71549302e-02f, 8.69715512e-02f, 1.16414987e-01f, 9.04592201e-02f,
  1.04327962e-01f, 7.78491348e-02f, 6.82808599e-03f, 6.39447421e-02f, 7.93918148e-02f, 5.32443821e-02f, 3.46710272e-02f, -4.80409227e-02f, 5.26757129e-02f, 5.21315553e-04f,
  2.15416662e-02f, -8.99738744e-02f, 1.18319750e-01f, 5.49636334e-02f, 5.89875653e-02f, -1.03334747e-01f, -8.06771666e-02f, -5.82259595e-02f, -5.40058352e-02f, 4.72778417e-02f,
  -4.90350910e-02f, -9.48631167e-02f, 7.34411553e-02f, -3.38716462e-04f, -6.91824481e-02f, -4.58149947e-02f, -1.72627927e-03f, 3.84520628e-02f, 4.97880913e-02f, -7.86896273e-02f,
  -3.59395333e-02f, -5.77483922e-02f, -9.42839980e-02f, 5.20843565e-02f, 5.29902577e-02f, 6.61846474e-02f, -3.00016701e-02f, 1.51802925e-02f, 6.27087727e-02f, -5.79045527e-02f,
  6.94082603e-02f, 3.85308564e-02f, 8.93494412e-02f, 5.64364269e-02f, 6.56609759e-02f, -2.13424750e-02f, 4.47850488e-02f, -6.46647140e-02f, 9.69073363e-03f, -6.09807409e-02f,
  -1.26516512e-02f, 3.49788442e-02f, 6.29947782e-02f, -6.40500411e-02f, 8.27998891e-02f, -7.12115271e-03f, -7.49795958e-02f, -3.01765017e-02f, 5.80647867e-03f, -8.74274150e-02f,
  -5.04423045e-02f, 6.84717149e-02f, -1.25100696e-03f, 5.56580871e-02f, 2.85444711e-03f, 5.96163496e-02f, 1.19874235e-02f, -6.31720722e-02f, -2.80600153e-02f, -7.60136098e-02f,
  -6.08300567e-02f, 6.92999288e-02f, 1.32983446e-01f, -6.42917007e-02f, -4.23458107e-02f, -5.10381013e-02f, -4.18651626e-02f, -7.23132715e-02f, -2.33928040e-02f, -1.41540259e-01f,
  -1.11905381e-01f, -5.12526408e-02f, 4.96388897e-02f, -1.01283021e-01f, -1.10772558e-01f, 1.60693042e-02f, 2.33914051e-02f, 6.51431978e-02f, -2.57466622e-02f, -1.34793594e-01f,
  -4.56958637e-03f, 2.01268569e-02f, 3.34115811e-02f, -7.21137598e-02f, -6.76423684e-02f, 1.02724180e-01f, -5.32200269e-04f, -9.48142406e-05f, -5.17573170e-02f, 1.77567732e-02f,
  1.60483271e-01f, 8.81226510e-02f, 8.12174845e-03f, 2.33711451e-01f, 5.05560413e-02f, -1.79090485e-01f, -3.59167129e-01f, -1.55468822e-01f, 7.58738518e-02f, 7.75494725e-02f,
  6.57481328e-02f, -4.33600023e-02f, -1.10489413e-01f, -7.67236352e-02f, -3.30981970e-01f, -2.41259918e-01f, -3.79386842e-02f, -2.69424915e-01f, -3.13748807e-01f, -2.04867795e-01f,
  -1.54873356e-01f, -4.95909527e-02f, -1.02102391e-01f, -4.93714288e-02f, 1.37858018e-01f, 4.25712317e-02f, 1.83932617e-01f, 1.44200787e-01f, -1.04390919e-01f, 3.70130926e-01f,
  2.94721693e-01f, 2.00277176e-02f, -1.11573108e-01f, -4.10664193e-02f, 4.80923131e-02f, -8.48256797e-02f, 3.24409492e-02f, 8.58959258e-02f, -3.94101776e-02f, -5.12993662e-03f,
  6.49353117e-02f, -2.48182677e-02f, 3.84652219e-03f, -3.39577757e-02f, -4.53696251e-02f, -1.60602480e-01f, -7.12677017e-02f, -1.32240668e-01f, -1.29377037e-01f, -7.26662278e-02f,
  -1.43724218e-01f, -8.42252001e-02f, 1.69779118e-02f, -8.20596144e-02f, 2.90797884e-03f, -3.51388715e-02f, 9.44449157e-02f, 8.45279694e-02f, 9.57002118e-03f, 9.75824594e-02f,
  2.34941803e-02f, -3.15789692e-02f, 9.41841006e-02f, -9.77336522e-03f, -2.57539246e-02f, 2.17712894e-02f, -2.69858260e-02f, 2.15171855e-02f, -2.58189421e-02f, -5.93148768e-02f,
  -2.87801065e-02f, -3.98216546e-02f, 5.52138314e-02f, -6.03693770e-03f, 4.43998910e-02f, -1.84546467e-02f, -6.69315597e-03f, -7.64400065e-02f, -2.95550153e-02f, -2.37278454e-02f,
  1.21974060e-02f, -3.71574759e-02f, 2.66270582e-02f, 6.16389420e-03f, -1.96680520e-02f, -1.85344424e-02f, 4.05212641e-02f, -1.00672401e-01f, -6.75649419e-02f, -4.99626389e-03f,
  2.29104489e-01f, -1.55589685e-01f, 1.27888203e-01f, -8.87110606e-02f, 4.96400520e-02f, 5.50710373e-02f, 1.40009597e-01f, -3.37944701e-02f, 5.92813268e-03f, -5.02276719e-02f,
  -1.24984264e-01f, -1.10677481e-02f, -1.69963520e-02f, -6.44283593e-02f, -6.73082843e-02f, 9.79834143e-03f, -1.09731898e-01f, -1.42817246e-02f, 1.05122495e-02f, 1.40376538e-01f,
  -2.67175119e-02f, -2.85011902e-02f, -7.63889551e-02f, -3.12489197e-02f, 3.28000113e-02f, 3.65406051e-02f, -7.90525228e-02f, -3.82643901e-02f, -1.13638945e-01f, 1.69909821e-04f,
  -2.05676869e-01f, -1.43089205e-01f, 1.63390103e-03f, 6.94364831e-02f, 6.72177523e-02f, 5.35052307e-02f, 6.31910190e-02f, 8.24402869e-02f, -6.67014206e-03f, -7.60670155e-02f,
  -1.32757902e-01f, -7.16892863e-03f, -2.36753505e-02f, 4.53325100e-02f, -5.38843591e-03f, 7.55917467e-03f, 1.00682661e-01f, 2.25448608e-02f, 1.64081216e-01f, 1.12048835e-01f,
  -6.22363649e-02f, 1.47600845e-02f, -4.95900325e-02f, -5.13876937e-02f, -7.27206990e-02f, 4.23974954e-02f, 2.39989143e-02f, 3.83228883e-02f, 4.81863618e-02f, -1.02467082e-01f,
  4.55531329e-02f, -1.00855657e-03f, 3.56162079e-02f, -7.66343400e-02f, 4.46209721e-02f, -1.38182081e-02f, 7.86588043e-02f, -9.24576819e-02f, 6.71105506e-03f, -9.15105343e-02f,
  -3.38172074e-03f, -3.14511620e-02f, -2.13388894e-02f, -1.81279108e-02f, -5.52850589e-02f, -2.24993024e-02f, -1.47425979e-01f, -9.60252210e-02f, 5.79701886e-02f, -8.23925734e-02f,
  -4.93356884e-02f, -3.18543166e-02f, 9.12933797e-03f, -6.84366375e-02f, 4.77373898e-02f, 9.90885645e-02f, 2.55848151e-02f, 2.09159609e-02f, -4.29050252e-02f, -4.39457446e-02f,
  9.78823900e-02f, -6.40473738e-02f, -7.06279092e-03f, -3.27180512e-02f, -2.41645388e-02f, 5.15073128e-02f, 2.70007700e-02f, -3.12178470e-02f, 2.93444097e-02f, -4.25129533e-02f,
  6.87209098e-03f, 7.61893159e-03f, 8.81158002e-03f, -5.93754612e-02f, -3.86718735e-02f, -3.10189594e-02f, -5.70859164e-02f, 5.04233688e-02f, -3.90217965e-03f, -1.06747064e-03f,
  -3.74069400e-02f, -8.39441363e-03f, -1.58486217e-02f, 2.14370284e-02f, -7.33456314e-02f, -1.45916594e-02f, 5.09500988e-02f, 2.82513127e-02f, -3.67633067e-02f, -1.37320254e-02f,
  -1.09757448e-03f, 1.31489530e-01f, 1.11907579e-01f, -8.09110701e-02f, 4.81693335e-02f, -6.58362210e-02f, -3.56908515e-02f, 9.45323855e-02f, -6.76032342e-03f, -8.09900870e-04f,
  -2.84407125e-03f, 1.07061550e-01f, 1.08528021e-03f, 5.43180555e-02f, 6.72868937e-02f, 9.33629349e-02f, 1.26858766e-03f, -1.59101337e-02f, 1.11193508e-02f, 7.02098683e-02f,
  -9.14327949e-02f, 9.63961110e-02f, 1.07154757e-01f, 7.06078559e-02f, 1.04062147e-01f, 1.58052534e-01f, -1.80947874e-02f, 5.70238046e-02f, -3.75097208e-02f, 4.47185077e-02f,
  -9.36875027e-03f, -3.46982554e-02f, -9.98323336e-02f, 5.71610369e-02f, -9.90252420e-02f, -1.11266062e-01f, -1.28305092e-01f, -5.48188947e-02f, -4.22750451e-02f, 7.33043160e-03f,
  4.46197428e-02f, 3.73572186e-02f, -1.01918750e-01f, -9.89605933e-02f, -1.97844990e-02f, -1.30468547e-01f, -9.60077196e-02f, -1.56900898e-01f, -9.61286724e-02f, -1.22937597e-01f,
  3.00081167e-02f, -5.31408824e-02f, -4.68248464e-02f, 2.01601461e-02f, 1.59184813e-01f, 1.35013029e-01f, 1.18946292e-01f, 2.63235997e-03f, -1.73337478e-02f, -1.32025797e-02f,
  8.34923908e-02f, -5.65066710e-02f, 8.06178339e-03f, 9.08717290e-02f, 5.56400158e-02f, 6.69302717e-02f, -5.30940406e-02f, -8.02404359e-02f, -3.04445717e-02f, 8.02094489e-02f,
  7.91652352e-02f, -5.57521246e-02f, 3.34221311e-02f, 3.59502845e-02f, 3.48430276e-02f, 7.20547959e-02f, 1.16400719e-02f, 5.14751263e-02f, 2.58537605e-02f, -1.29958550e-02f,
  9.74297747e-02f, 6.78400397e-02f, 8.53253379e-02f, 1.07867733e-01f, 9.08119753e-02f, -5.34760840e-02f, 1.51915669e-01f, 1.59300178e-01f, 1.21138506e-01f, 6.86201900e-02f,
  -5.85689582e-03f, 2.56638508e-02f, -2.96916813e-02f, 2.86351703e-02f, 6.06237277e-02f, -5.28676882e-02f, 3.68585289e-02f, -8.04492757e-02f, -1.84234027e-02f, 3.71121801e-02f,
  1.83441937e-02f, 7.81833287e-03f, -1.53238280e-03f, 2.43263990e-02f, -1.61610190e-02f, 6.95108902e-03f, 4.80340198e-02f, 8.84419493e-03f, 9.85525399e-02f, -2.23829728e-02f,
  -2.72869486e-02f, 1.22595720e-01f, 8.45758319e-02f, 2.28677709e-02f, -2.27098409e-02f, 2.87465081e-02f, -2.54395511e-02f, -5.25939688e-02f, -6.00260086e-02f, -1.28636137e-01f,
  6.48977906e-02f, -6.49970695e-02f, -1.01131909e-02f, -5.69768138e-02f, -2.41388790e-02f, 2.15573683e-02f, 4.79432121e-02f, 1.59425084e-02f, 7.93491006e-02f, 5.53739443e-02f,
  5.73939551e-03f, -8.63172635e-02f, 2.75962390e-02f, 1.16172723e-01f, -1.72791034e-02f, 6.81895837e-02f, 1.45220637e-01f, -1.57622772e-03f, 4.10478972e-02f, 1.32577851e-01f,
  1.52268812e-01f, -2.40672473e-02f, 6.34442046e-02f, 5.41232564e-02f, 1.11677825e-01f, -4.29078229e-02f, -4.77785245e-02f, 1.15543909e-01f, -6.13913424e-02f, 7.18378201e-02f,
  -5.30755997e-01f, -1.68452427e-01f, -2.25302689e-02f, 1.85733244e-01f, 1.59264520e-01f, 1.40011862e-01f, 2.36559287e-01f, 1.16658986e-01f, 1.63560733e-01f, -9.82820988e-02f,
  -9.59062502e-02f, 6.43296167e-02f, 2.08707657e-02f, 6.87785819e-02f, 4.91376817e-02f, 9.82679576e-02f, 2.68083036e-01f, 1.19503900e-01f, 5.06562665e-02f, -1.01462901e-02f,
  -1.39611587e-02f, -7.83422515e-02f, -1.97017878e-01f, 6.50979728e-02f, 1.61040202e-01f, 7.37006366e-02f, 8.85344818e-02f, -4.72668000e-02f, -7.26546794e-02f, 3.11657507e-02f,
  -3.27777863e-01f, -3.56102318e-01f, 2.18081430e-01f, -1.83463171e-02f, 1.93637609e-02f, -9.78337601e-02f, 2.99204374e-04f, -1.61633924e-01f, 3.05947233e-02f, -4.19899123e-03f,
  4.10179086e-02f, -2.40686964e-02f, 1.07440554e-01f, -3.83995585e-02f, -5.24747297e-02f, -9.26931947e-02f, -7.34629035e-02f, -3.23452838e-02f, 7.89407939e-02f, -3.42907943e-02f,
  1.47264659e-01f, -2.51956955e-02f, -1.34079814e-01f, 7.15103149e-02f, 1.21341586e-01f, -5.59564587e-03f, 1.38853258e-02f, -4.50162925e-02f, -1.78410008e-03f, -1.84970126e-01f,
  3.28735933e-02f, 1.07016517e-02f, -1.94866229e-02f, -5.56496941e-02f, 5.52668702e-04f, 5.54899275e-02f, -3.52608040e-02f, 1.52485818e-02f, -1.16584788e-03f, -3.35694179e-02f,
  4.03953046e-02f, 3.95514183e-02f, -1.52780237e-02f, 7.74625689e-03f, 4.03098725e-02f, 3.06112412e-02f, 1.86202824e-02f, 2.78230477e-02f, 6.31431350e-03f, -9.08391271e-03f,
  -4.43398952e-02f, 1.57845337e-02f, -9.47921164e-03f, -2.91314162e-02f, 2.40869019e-02f, 1.19573042e-01f, 3.22210081e-02f, -1.01683162e-01f, -1.70315877e-02f, -5.46878614e-02f,
  -1.33242220e-01f, 2.15136018e-02f, -3.50895524e-02f, -4.56583947e-02f, -2.63146330e-02f, -8.76994729e-02f, 4.12032306e-02f, -6.79950938e-02f, -4.01354879e-02f, 3.55724730e-02f,
  -7.51964897e-02f, -7.56994486e-02f, -3.41242626e-02f, -1.48586649e-02f, -3.28251757e-02f, -5.75996563e-02f, -4.64175344e-02f, 4.29227725e-02f, 6.20929226e-02f, -4.51077633e-02f,
  9.91053283e-02f, 1.28995702e-02f, 2.35288646e-02f, 1.40542492e-01f, -3.19465213e-02f, 1.42707292e-03f, -2.17103176e-02f, 1.31981317e-02f, -1.69972964e-02f, 2.83878967e-02f,
  1.23618722e-01f, 7.92293623e-02f, 1.73031956e-01f, -1.14495471e-01f, -1.12732593e-02f, 2.42854745e-04f, 2.54340265e-02f, 3.31124961e-02f, -1.39518157e-01f, -3.32889594e-02f,
  -2.53768880e-02f, -1.17886148e-01f, -7.24551380e-02f, -8.98049325e-02f, -6.81211203e-02f, 1.33297652e-01f, -4.26813029e-02f, 9.55469161e-02f, 5.65363616e-02f, 5.74175417e-02f,
  1.93755492e-03f, 6.74202293e-02f, -8.30776244e-02f, -5.54302819e-02f, 5.60740661e-03f, -2.13529486e-02f, 4.77859704e-03f, -6.73460066e-02f, 2.83073150e-02f, -8.99563581e-02f,
  1.37162983e-01f, -2.65950933e-02f, 7.30172778e-03f, -1.63782328e-01f, -2.36095265e-02f, 6.70259893e-02f, -7.39848688e-02f, -1.20563261e-01f, -5.51851094e-02f, 4.66197580e-02f,
  5.95385917e-02f, -7.69473519e-03f, 8.67173262e-03f, -7.45812878e-02f, 5.48720062e-02f, 2.71662674e-03f, -1.07504137e-01f, -2.61857938e-02f, 2.37516570e-03f, -8.67138878e-02f,
  5.38559407e-02f, 6.69510290e-02f, 8.28263164e-02f, -1.84539296e-02f, 5.77693917e-02f, 6.25925232e-03f, 2.95649096e-03f, -1.47103444e-02f, 1.01519153e-02f, 2.75328364e-02f,
  1.39189437e-02f, 4.97181853e-03f, -4.85221297e-02f, -4.60300818e-02f, -3.64050828e-02f, -8.02107714e-03f, -2.70046499e-02f, -1.76232122e-02f, -5.48848845e-02f, 1.01272143e-01f,
  3.32727581e-02f, 2.94558909e-02f, 6.84351847e-02f, -3.08824535e-02f, -1.88765191e-02f, 8.93728901e-03f, -7.45105743e-02f, -4.93247323e-02f, -6.45370334e-02f, 8.16984251e-02f,
  6.60459399e-02f, 7.89005589e-03f, -1.07931755e-02f, 3.35788727e-02f, 7.08421841e-02f, 3.02104484e-02f, -3.41198687e-03f, 7.73025770e-03f, 7.26472139e-02f, -1.32976007e-02f,
  -7.58693516e-02f, 5.45002334e-02f, -3.57260555e-02f, -4.73113991e-02f, 3.27221155e-02f, -1.54351965e-02f, -6.15303330e-02f, -1.04969405e-01f, 7.61377439e-02f, -1.47457886e-02f,
  -3.73103395e-02f, 4.98409383e-02f, -7.80825911e-04f, 2.42810044e-02f, 9.80923176e-02f, -6.41620383e-02f, -5.37985079e-02f, 3.62541527e-02f, -1.37953619e-02f, 5.33867776e-02f,
  -7.92883113e-02f, 1.54848779e-02f, -8.71024653e-02f, -5.71583584e-02f, -1.20889530e-01f, 1.66387819e-02f, 9.14057568e-02f, -7.48703852e-02f, 3.42977047e-02f, 9.97987669e-03f,
  1.81368664e-01f, -1.76082358e-01f, -1.75713357e-02f, -9.84049886e-02f, -2.09026448e-02f, -1.22396663e-01f, -7.84797296e-02f, -5.38196899e-02f, -7.14973211e-02f, -5.90483360e-02f,
  -5.42553216e-02f, -1.59047041e-02f, 1.29460663e-01f, 1.72869395e-02f, 5.24236970e-02f, 8.81183371e-02f, -1.20187746e-02f, 1.44155547e-01f, 1.12742618e-01f, -6.02677511e-03f,
  -1.52774870e-01f, -9.09093022e-02f, 1.50587624e-02f, 6.60902541e-03f, -2.11083405e-02f, 8.21436271e-02f, -1.32626370e-01f, -3.14745940e-02f, -1.46517366e-01f, -6.74003363e-02f,
  8.92635062e-02f, -1.23902820e-01f, -8.01589638e-02f, 9.17859189e-03f, -5.02325920e-03f, 5.39470129e-02f, 1.72075466e-04f, 6.09586649e-02f, 1.75590664e-02f, -2.19783876e-02f,
  3.61544872e-03f, 4.50172350e-02f, 6.83597103e-02f, -3.84008363e-02f, 6.76382706e-02f, -4.10289913e-02f, -2.02154554e-02f, 6.19065240e-02f, 1.72294825e-02f, -1.31715998e-01f,
  -9.88000035e-02f, -1.73444338e-02f, 8.95268396e-02f, -3.89520153e-02f, -6.72285333e-02f, 8.26829076e-02f, -5.56215225e-03f, -3.48613411e-03f, -4.83030193e-02f, 3.86398248e-02f,
  -9.30330157e-03f, 2.99549326e-02f, 7.95320943e-02f, 9.90912318e-02f, 3.78073251e-04f, -1.42455259e-02f, 3.24148983e-02f, 7.25520924e-02f, -1.94891598e-02f, -2.31579635e-02f,
  4.68521528e-02f, -1.54430512e-02f, 6.98322952e-02f, 2.89022028e-02f, -7.65939578e-02f, 2.03027278e-02f, 7.98899233e-02f, -4.05878648e-02f, 2.85298079e-02f, -1.13527417e-01f,
  -4.81716022e-02f, 3.15275439e-03f, -8.64343718e-02f, 7.85684139e-02f, -1.10854506e-01f, -3.32686082e-02f, 7.49610439e-02f, -4.54220101e-02f, -4.30101436e-03f, -6.13540299e-02f,
  2.76763111e-01f, 8.91486555e-02f, 9.35809687e-03f, 8.52995887e-02f, -1.65413041e-03f, -4.45064157e-02f, -1.52738648e-03f, -1.00616515e-02f, -2.15720367e-02f, -2.98709124e-02f,
  -7.48155564e-02f, 3.54887210e-02f, -7.49540180e-02f, -5.34863062e-02f, -3.53546292e-02f, -2.99473107e-02f, -7.38025382e-02f, 4.64361422e-02f, 6.24754839e-02f, -9.12097283e-03f,
  9.54145938e-03f, 1.85651943e-01f, 2.41103068e-01f, 1.31380796e-01f, 4.11671288e-02f, 1.42546013e-01f, 1.42921701e-01f, -4.41597514e-02f, 6.71899691e-02f, 2.03911677e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  -1.06134126e-02f, 4.27995697e-02f, -1.14229834e-02f, 1.74050897e-01f, 5.49277384e-03f, -1.05072215e-01f, 1.43891245e-01f, 4.07783091e-02f, 8.99863690e-02f, -6.89321607e-02f,
  -1.58128440e-02f, 8.00420120e-02f, -1.24630276e-02f, 1.68825179e-01f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  3.66558731e-01f, -1.07377976e-01f, -3.62978615e-02f, -1.12816907e-01f, -1.10716142e-01f, 1.59673855e-01f, -4.36096936e-01f, 8.49665031e-02f, -5.97930700e-02f, 2.13742495e-01f,
  -1.20986581e-01f, -2.65998185e-01f, 5.32320105e-02f, 2.23049194e-01f, 2.56712615e-01f, 3.56493443e-01f, -4.45937693e-01f, 1.93067044e-01f, 2.06721917e-01f, -6.94607273e-02f,
  1.26529112e-01f, -2.28464976e-01f, -1.85527176e-01f, 1.17158473e-01f, 8.93706270e-03f, 1.49250761e-01f, 1.56837627e-01f, 7.05086067e-02f, 3.62658203e-02f, -1.67735308e-01f,
  1.98859245e-01f, 4.46831919e-02f, 1.27289623e-01f, 2.04351604e-01f, 4.02227566e-02f, -5.65000474e-02f, 2.04775035e-01f, -3.21063071e-01f, 2.60057688e-01f, -1.87459946e-01f,
  3.29186171e-02f, 4.67601530e-02f, -2.68454462e-01f, -5.60405217e-02f, -2.51715004e-01f, 4.16924715e-01f, -4.71758507e-02f, 9.98950005e-02f, 1.39664948e-01f, 5.87845445e-01f,
  6.45843595e-02f, -1.94361866e-01f, -1.32952809e-01f, -2.24196002e-01f, -2.51297981e-01f, 1.17258288e-01f, 1.46389231e-01f, -8.71240199e-02f, 4.52078551e-01f, -1.55685931e-01f,
  8.90461579e-02f, -3.94214541e-01f, -7.46277422e-02f, -1.65933132e-01f, 2.91817814e-01f, -8.27248618e-02f, -1.21774361e-01f, 5.67924492e-02f, -1.13459051e-01f, 2.26360768e-01f,
  -3.08581084e-01f, 1.82702422e-01f, -1.72402784e-01f, -4.35284199e-03f, -1.69397503e-01f, -1.71070054e-01f, 4.72119927e-01f, 1.49713233e-01f, 1.96611285e-01f, 2.71839470e-01f,
  -1.74759433e-01f, 2.20008902e-02f, -1.00104406e-01f, 8.16926807e-02f, 2.38129452e-01f, -1.10705703e-01f, -2.35067531e-01f, 2.19101901e-03f, -3.12543660e-01f, -1.11287825e-01f,
  1.30052730e-01f, -2.92447656e-02f, -4.96029779e-02f, 4.22353595e-02f, 5.56150544e-03f, 1.45274386e-01f, 4.76099402e-01f, 1.62988052e-01f, -1.03554875e-02f, 3.02259419e-02f,
  -1.51679903e-01f, 4.60036069e-01f, -2.23079652e-01f, 2.93203384e-01f, 1.79580793e-01f, -1.05934262e-01f, 9.29586142e-02f, -3.37216817e-02f, 4.42074925e-01f, -2.30570793e-01f,
  1.61103189e-01f, 2.87461281e-01f, -4.13005173e-01f, -1.39402360e-01f, -5.14076725e-02f, 4.76665683e-02f, 4.62072669e-03f, -1.25900105e-01f, -9.07935500e-02f, -7.61449859e-02f,
  -1.82986081e-01f, 1.08758785e-01f, -1.46448627e-01f, 1.26950011e-01f, -8.77176076e-02f, -2.92730570e-01f, 2.43012890e-01f, 2.79947817e-01f, 1.20305814e-01f, -2.91081257e-02f,
  2.79305279e-01f, -6.98848143e-02f, 7.10733309e-02f, 3.30289215e-01f, 3.68507318e-02f, 1.01920299e-01f, 1.87589064e-01f, -6.17831945e-02f, 1.14919312e-01f, -2.68541843e-01f,
  -3.50792136e-04f, -2.08112493e-01f, 1.45838574e-01f, -1.19978776e-02f, -4.47142690e-01f, 1.80346906e-01f, -5.70367090e-03f, -1.56296149e-01f, -1.49724156e-01f, -2.32976913e-01f,
  3.44324827e-01f, 1.65112708e-02f, 1.00781836e-01f, -1.70878619e-01f, -2.32975557e-01f, 4.18669544e-02f, 6.88183606e-02f, 1.30998880e-01f, -5.47708236e-02f, 3.32338154e-01f,
  1.22100987e-01f, -2.57260539e-03f, 4.74746451e-02f, -6.95349742e-03f, -5.26813418e-02f, -1.41472280e-01f, 1.62281334e-01f, -1.60451591e-01f, 9.29869562e-02f, 3.17011625e-01f,
  -1.15788616e-01f, -2.42147028e-01f, 4.14889306e-02f, 1.25575960e-01f, 1.92659438e-01f, 3.98427695e-01f, 2.14223787e-02f, 4.01318401e-01f, 8.48552436e-02f, -1.53536350e-01f,
  9.04216841e-02f, 1.33554097e-02f, 1.30274177e-01f, 1.41940773e-01f, 8.96699652e-02f, 6.47954270e-02f, 1.24711156e-01f, 7.35752136e-02f, -1.60965696e-01f, 1.09569214e-01f,
  3.25709321e-02f, -5.12905605e-02f, 1.56853616e-01f, -2.27512494e-01f, 1.84759408e-01f, 1.62709638e-01f, -2.51483083e-01f, 4.89435643e-02f, -4.54052657e-01f, 3.72639030e-01f,
  -1.88164294e-01f, -1.27381846e-01f, 2.19434053e-01f, -6.15969039e-02f, 1.88739970e-01f, -1.07380219e-01f, 1.39851183e-01f, 2.61381179e-01f, -5.01768649e-01f, -8.25831145e-02f,
  1.39600281e-02f, 8.15662146e-02f, 1.13291964e-02f, -7.57393762e-02f, 1.84407160e-01f, 1.47701889e-01f, 2.89335281e-01f, -1.20618664e-01f, -3.47725749e-02f, -1.75256282e-01f,
  -1.46672025e-01f, -2.24823847e-01f, 1.27836391e-01f, 2.65476793e-01f, -1.47583932e-01f, -6.25444576e-02f, 6.47640275e-03f, 1.53436333e-01f, -3.46718580e-01f, 1.45359278e-01f,
  -2.23048508e-01f, 9.37541053e-02f, -2.22423851e-01f, -1.46027789e-01f, 2.26531833e-01f, 6.69469088e-02f, -8.67684409e-02f, -2.19125405e-01f, 2.40815297e-01f, 1.45029962e-01f,
  -2.97730327e-01f, -2.85156816e-01f, -5.94447255e-02f, -5.09583391e-02f, -2.06123263e-01f, 3.28270137e-01f, 8.18921104e-02f, 2.20607176e-01f, 2.03818679e-01f, -2.28700221e-01f,
  -4.22144949e-01f, 2.29619384e-01f, -4.79151979e-02f, 6.34995103e-02f, 1.16067514e-01f, -8.85389000e-02f, -1.69093341e-01f, -1.29697934e-01f, 1.54924303e-01f, -3.16079706e-02f,
  -1.85231522e-01f, 8.66843015e-02f, -2.77401414e-02f, -5.98341711e-02f, -2.01203441e-03f, -8.37062001e-02f, 3.57330561e-01f, -1.53153419e-01f, -2.59133220e-01f, -2.00018868e-01f,
  1.60983831e-01f, -1.02840774e-01f, -4.52788264e-01f, -2.95520395e-01f, -1.30341709e-01f, 7.36552998e-02f, -2.76098967e-01f, 1.81637794e-01f, 9.85860080e-03f, -5.86559065e-03f,
  -7.05506802e-02f, 3.18724103e-02f, -2.95295864e-01f, -1.60095487e-02f, -2.91018099e-01f, -1.50574654e-01f, 5.14394045e-02f, 1.50587022e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  3.68036270e-01f, 4.86438453e-01f, 3.25301349e-01f, -1.35652289e-01f, 1.61567077e-01f, 2.87128806e-01f, 3.05972964e-01f, -1.31486773e-01f, 2.72392303e-01f, -1.42250881e-01f,
  2.73024708e-01f, 4.25698847e-01f, -7.98641264e-01f, -2.85879314e-01f, -4.00059015e-01f, -3.27606320e-01f, -7.58767501e-02f, -2.01365091e-02f, 2.01472953e-01f, 3.18003446e-01f,
  -1.96012687e-02f, 4.43634301e-01f, -2.06604436e-01f, -1.13995023e-01f, 6.61909953e-02f, 4.97809760e-02f, 2.29536712e-01f, -2.06853330e-01f, 1.45296499e-01f, -1.90135360e-01f,
  -2.83040464e-01f, 1.59781680e-01f, 6.22011535e-02f, 1.30039141e-01f, 1.81768626e-01f, -1.46809489e-01f, -4.41138968e-02f, -1.28308371e-01f, 2.24783674e-01f, 9.85830873e-02f,
  1.46855459e-01f, -1.13919139e-01f, 1.48466796e-01f, 3.23718451e-02f, -2.25233018e-01f, 1.95283517e-01f, -2.06930950e-01f, -2.53727376e-01f, 1.76988676e-01f, -1.69598863e-01f,
  -1.58569977e-01f, -1.16907433e-03f, -3.74115035e-02f, 8.94908910e-04f, -1.23840615e-01f, -1.16379887e-01f, 5.18413540e-03f, 6.59551546e-02f, 1.73477992e-01f, -1.62533909e-01f,
  2.59651363e-01f, 1.49155542e-01f, -1.36277586e-01f, -6.71188906e-03f, -1.62180230e-01f, -6.87386235e-03f, -6.50275275e-02f, 9.22674239e-02f, -4.45758402e-02f, -9.59898159e-02f,
  -8.14305767e-02f, 5.83199263e-02f, 5.77138923e-02f, 1.63851768e-01f, -1.00305744e-01f, 1.14681572e-01f, -8.45726505e-02f, 1.61292031e-01f, 3.10865212e-02f, -6.76092356e-02f,
  2.50943840e-01f, 4.51106727e-02f, -1.43283427e-01f, -1.42030761e-01f, -2.52122302e-02f, 7.15178996e-02f, -2.02771291e-01f, 1.09099425e-01f, -1.27051562e-01f, -5.63729852e-02f,
  -9.55374315e-02f, 1.19212279e-02f, -2.67425389e-03f, -1.51326418e-01f, 1.04095995e-01f, -1.23703912e-01f, 2.33488843e-01f, 3.13458085e-01f, -3.66109572e-02f, 3.49491090e-02f,
  1.36133909e-01f, 3.51531617e-02f, -1.31834850e-01f, -1.14446893e-01f, 2.37381339e-01f, 1.64660767e-01f, -2.89027095e-01f, 1.71615630e-01f, -1.07189380e-02f, 2.45814607e-01f,
  -8.25085584e-03f, 7.41001219e-02f, -4.40397076e-02f, 2.27618441e-01f, 5.22571336e-03f, -9.42023918e-02f, -1.96014019e-03f, 1.21898605e-02f, -2.70629078e-01f, -1.37157083e-01f,
  -1.04442492e-01f, -1.48574695e-01f, 2.88463145e-01f, -1.99654400e-01f, 2.17403442e-01f, -1.07096069e-01f, -8.50833803e-02f, 1.20739259e-01f, -1.96468562e-01f, 2.76334643e-01f,
  1.20376140e-01f, 7.33810142e-02f, 1.99655607e-01f, -2.78781086e-01f, 2.67374218e-01f, 6.58802241e-02f, 1.48194000e-01f, -1.79986693e-02f, -2.36073822e-01f, 1.44613937e-01f,
  -2.50356108e-01f, 1.93645153e-02f, -1.00222699e-01f, -1.94314286e-01f, 2.86958903e-01f, -3.40941474e-02f, 1.61023349e-01f, -7.13631585e-02f, -2.29449943e-02f, 3.33299577e-01f,
  -1.42262019e-02f, -9.65583846e-02f, -5.96644059e-02f, 3.62982899e-02f, 3.79365295e-01f, -9.57611725e-02f, 1.02058582e-01f, -1.29123911e-01f, 1.10233933e-01f, -7.90046230e-02f,
  4.04047519e-01f, -2.56446935e-02f, 4.86483052e-02f, 2.52048135e-01f, 2.16558725e-01f, 7.57730752e-02f, 2.86796421e-01f, -1.22123901e-02f, 1.87714264e-01f, 2.23735869e-01f,
  1.05637707e-01f, 4.70318884e-01f, 4.73591797e-02f, 2.42149815e-01f, -2.87857149e-02f, 3.55072767e-01f, 2.62292027e-01f, 9.36556011e-02f, -1.63523674e-01f, 1.94954768e-01f,
  2.95624994e-02f, 9.05752331e-02f, -1.88667119e-01f, -1.17353126e-01f, 3.96326214e-01f, 2.01308727e-01f, 1.34803116e-01f, 6.19004890e-02f, -1.54227406e-01f, 1.79067805e-01f,
  -1.66578572e-02f, 9.78122726e-02f, 7.42687285e-02f, 9.67212021e-03f, 2.45634675e-01f, 2.32073590e-01f, 1.75286047e-02f, 3.38998400e-02f, -1.08760953e-01f, -8.49862918e-02f,
  2.29945749e-01f, -4.47648317e-02f, -3.60522680e-02f, -2.63005197e-01f, 1.87519312e-01f, -1.87519994e-02f, 1.25969291e-01f, 3.02785993e-01f, 3.97311188e-02f, 4.75968391e-01f,
  -1.31088775e-02f, -6.87471330e-02f, 3.04006636e-01f, -2.23341003e-01f, -7.06500560e-02f, -1.38402775e-01f, -5.89367785e-02f, -1.51195750e-01f, -1.12245746e-01f, -1.15252882e-01f,
  -1.22483157e-01f, 1.11478612e-01f, 1.14421040e-01f, -1.26113892e-01f, 1.74487963e-01f, 1.21834129e-01f, 1.58023342e-01f, 2.29777042e-02f, 2.29762629e-01f, 2.59901434e-01f,
  3.42977017e-01f, -3.74962948e-02f, 1.65383622e-01f, 1.24000400e-01f, 7.22947419e-02f, 2.58885533e-01f, -1.73019186e-01f, -4.98488992e-02f, 2.57480349e-02f, 1.76243037e-01f,
  8.47529396e-02f, -1.31289989e-01f, 1.58059821e-01f, -1.80367436e-02f, 2.83904299e-02f, 1.17365763e-01f, 8.89930800e-02f, -8.62962306e-02f, 2.21623257e-01f, 5.88803515e-02f,
  1.56136796e-01f, -9.06213596e-02f, 9.89090875e-02f, 1.22045004e-03f, -1.25499174e-01f, -1.64647564e-01f, 1.38194844e-01f, -1.38474494e-01f, 2.16212228e-01f, -1.37852142e-02f,
  -1.26200110e-01f, -5.05755842e-02f, 3.91802117e-02f, -1.10134594e-01f, 8.64534453e-02f, 4.92294841e-02f, 3.69572252e-01f, 1.56752467e-01f, -4.70936835e-01f, -2.38136381e-01f,
  -2.27105454e-01f, -3.22433412e-01f, -6.84387609e-02f, -1.70452863e-01f, 1.94589552e-02f, 1.18046805e-01f, 6.25356361e-02f, 2.32799545e-01f, -1.74585178e-01f, -1.25001401e-01f,
  1.92630678e-01f, 2.75093585e-01f, 1.97168902e-01f, -1.21023349e-01f, 1.13220498e-01f, 7.33375698e-02f, -1.17763467e-01f, 9.66287702e-02f, 8.00231546e-02f, -8.31161439e-02f,
  -8.09127167e-02f, 2.60732979e-01f, -2.34607514e-03f, 1.05399843e-02f, 1.36503622e-01f, 1.53479710e-01f, 7.80716166e-02f, 1.19999334e-01f, 3.65491629e-01f, 2.93012738e-01f,
  -6.04841411e-02f, -1.42755732e-01f, -3.14416699e-02f, 8.36334303e-02f, 1.55253366e-01f, -3.03654015e-01f, -1.80668384e-01f, -1.63545588e-03f, -1.25393895e-02f, 3.91057193e-01f,
  3.43037732e-02f, -1.82863340e-01f, 2.82645881e-01f, 9.83505473e-02f, -2.18297482e-01f, -2.04870358e-01f, -8.32376108e-02f, 1.41591609e-01f, 1.87528152e-02f, -8.43940675e-03f,
  1.52998954e-01f, 9.90099367e-03f, 1.47300765e-01f, 3.84591341e-01f, 1.45211086e-01f, 4.24642494e-04f, -3.11178677e-02f, 9.42172483e-02f, 2.30771571e-01f, 2.17591897e-01f,
  -2.96959758e-01f, 2.18980059e-01f, 9.87306237e-03f, 6.24528527e-01f, 2.72031546e-01f, 3.81244898e-01f, 2.61114955e-01f, 2.28073463e-01f, -5.65331466e-02f, 2.38698125e-02f,
  5.10706663e-01f, 4.10515778e-02f, -4.29220468e-01f, 6.84663951e-02f, 9.83064324e-02f, -1.69464245e-01f, 1.11715190e-01f, -1.55969456e-01f, 1.27730846e-01f, -3.31348628e-01f,
  -4.14169114e-03f, -8.48107561e-02f, 4.37482297e-01f, -2.89558738e-01f, 2.10271239e-01f, 2.54561335e-01f, 1.80884987e-01f, 4.48456764e-01f, 4.32452261e-01f, -9.48012322e-02f,
  6.81614801e-02f, 3.88069510e-01f, -1.19141765e-01f, 3.14678222e-01f, 2.37214237e-01f, 7.06688240e-02f, 2.06237733e-01f, 2.74655282e-01f, 3.09817582e-01f, 2.76103020e-01f,
  -1.54841304e-01f, 6.90901503e-02f, 2.65168548e-01f, 1.04938023e-01f, 1.27415657e-01f, 7.85916746e-02f, 1.18573181e-01f, 8.46800208e-02f, -2.13445559e-01f, 2.30463669e-01f,
  -2.16747522e-01f, 5.28882682e-01f, 9.10983980e-03f, 1.14721984e-01f, 1.59780364e-02f, -2.70136148e-02f, 1.27502784e-01f, 1.95940644e-01f, -1.00414105e-01f, 2.63543744e-02f,
  -5.64335063e-02f, 6.75643384e-02f, -8.76424834e-02f, 2.71811932e-01f, 1.22618869e-01f, 4.87048589e-02f, -1.58828869e-01f, 1.87388793e-01f, 1.36600211e-01f, -1.07269667e-01f,
  9.20381621e-02f, 1.16194107e-01f, 9.34732109e-02f, 1.82625186e-02f, 2.63683319e-01f, -8.16273019e-02f, 1.80209503e-02f, -3.23151648e-02f, 4.14595008e-01f, 3.28328669e-01f,
  1.47416607e-01f, -9.06172469e-02f, 1.41562939e-01f, -5.63725606e-02f, -1.09466538e-01f, -1.61527231e-01f, 7.49383569e-02f, -1.66898757e-01f, 1.19344704e-01f, 5.91420606e-02f,
  -2.81381537e-03f, 2.26683170e-01f, 1.72723904e-01f, 8.32494572e-02f, -1.33256227e-01f, -5.04847569e-03f, 9.13091749e-02f, -1.91473559e-01f, 1.91390608e-02f, 8.58749449e-03f,
  -2.26970227e-03f, -8.15718248e-02f, -5.99779673e-02f, 2.53418505e-01f, -8.60882029e-02f, -1.85672954e-01f, 2.67424196e-01f, -1.36274740e-01f, 3.34344327e-01f, 9.27975103e-02f,
  -6.42593354e-02f, 2.40443930e-01f, -1.74060017e-01f, -2.91001401e-03f, 4.75784652e-02f, 3.79005104e-01f, -1.90108463e-01f, 2.36317992e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  2.33478054e-01f, 1.53292522e-01f, 2.18845382e-01f, 1.47427231e-01f, 1.46071047e-01f, 2.96103001e-01f, 2.72625774e-01f, 4.13722470e-02f, 4.40120995e-02f, 2.05686450e-01f,
  3.58226627e-01f, 2.42364138e-01f, 1.38049886e-01f, 9.55516323e-02f
};

// L2_fan_Wp (Shape: 9 x 32)
const int L2_fan_Wp_rows = 9;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  8.86167660e-02f, 4.16070104e-01f, 1.16074942e-01f, -6.51733652e-02f, -2.19489038e-01f, 5.31424470e-02f, 2.14185908e-01f, 3.73808265e-01f, 3.64248067e-01f, -8.35905671e-02f,
  -1.57725260e-01f, -2.48867959e-01f, 4.74241465e-01f, 2.54415363e-01f, 1.33892655e-01f, 2.35699013e-01f, 3.41328055e-01f, 3.37116092e-01f, 2.88804442e-01f, -1.70692936e-01f,
  -1.92208454e-01f, 2.40583271e-02f, 2.61940379e-02f, -5.20232618e-02f, -1.44499600e-01f, 2.01307461e-01f, -1.14126578e-02f, 2.14446187e-01f, -3.98782253e-01f, -1.35131180e-02f,
  9.01886672e-02f, -9.18275863e-02f, 3.53394270e-01f, 1.74836934e-01f, 3.18715513e-01f, -1.43081978e-01f, 6.15326166e-02f, 7.83109590e-02f, 3.68214488e-01f, 2.12715678e-02f,
  6.73978254e-02f, 3.27707797e-01f, 2.33996451e-01f, 3.00347656e-01f, 2.92622566e-01f, 3.17394853e-01f, 3.65502298e-01f, 2.52693981e-01f, -2.66844809e-01f, 1.75593778e-01f,
  1.59796283e-01f, -2.90885627e-01f, -1.55079380e-01f, -1.17465004e-01f, -1.44906089e-01f, 7.57071823e-02f, 2.83219606e-01f, -1.47703573e-01f, -2.66670018e-01f, -1.86231524e-01f,
  2.87140995e-01f, 1.80521831e-01f, -7.83459619e-02f, -1.12783711e-03f, -1.04951240e-01f, -2.09911227e-01f, -1.00956790e-01f, -1.34634867e-01f, -9.58332717e-02f, 6.27341866e-02f,
  9.60223600e-02f, -2.44486675e-01f, -1.74466908e-01f, -4.81029958e-01f, -2.23853663e-01f, -2.42599063e-02f, 1.12851493e-01f, -2.60866553e-01f, -4.59260911e-01f, -3.88713270e-01f,
  -6.17806613e-02f, 3.16396087e-01f, 4.19993758e-01f, 1.32665306e-01f, 1.14310801e-01f, -2.49879714e-02f, -2.88018063e-02f, -2.07129419e-01f, -1.60598233e-01f, -6.50087595e-02f,
  3.48068267e-01f, 1.26954347e-01f, -1.58174232e-01f, -4.04119760e-01f, 5.21417335e-02f, -3.27587873e-02f, -1.41598374e-01f, -2.02982083e-01f, -5.96238710e-02f, 2.54497916e-01f,
  1.72055066e-01f, -8.31865594e-02f, 1.97134152e-01f, -2.09054589e-01f, -2.65372545e-01f, -1.05248377e-01f, 3.36325765e-01f, -6.46235943e-02f, -5.52843153e-01f, -4.02285665e-01f,
  8.92119482e-02f, -2.86291152e-01f, -1.92474321e-01f, -1.41024962e-01f, -6.04055487e-02f, 6.79903179e-02f, 1.12894200e-01f, 1.67974487e-01f, 2.79761553e-01f, 5.65436631e-02f,
  1.14759855e-01f, -8.95731226e-02f, -2.34810468e-02f, 6.50421381e-02f, 2.64552265e-01f, 4.74121682e-02f, 8.21564123e-02f, -1.07047834e-01f, 3.84000868e-01f, -1.73520431e-01f,
  2.63578027e-01f, -1.04132958e-01f, -1.70685038e-01f, -9.54937562e-02f, -1.03843749e-01f, -1.43408820e-01f, -2.28162408e-02f, -2.36620858e-01f, 2.77995884e-01f, -3.51382881e-01f,
  -2.61048645e-01f, 8.80334377e-02f, 1.63184702e-01f, -2.60560155e-01f, -2.34842524e-01f, 5.12173437e-02f, 2.03654394e-01f, 1.38664559e-01f, -1.53463960e-01f, 7.35217184e-02f,
  -2.56355349e-02f, 2.03554899e-01f, -1.26409143e-01f, 2.27833539e-01f, 7.00960979e-02f, -2.12601870e-01f, -3.85147512e-01f, 1.77801684e-01f, -6.57617971e-02f, 2.86231846e-01f,
  1.68207631e-01f, 6.00175513e-03f, -1.03562243e-01f, 2.22477168e-01f, -5.28006889e-02f, 3.72727700e-02f, 1.28282132e-02f, -3.79607338e-03f, 1.50441706e-01f, -2.14114767e-02f,
  6.37956038e-02f, -3.09302866e-01f, 2.78110504e-02f, 1.57499135e-01f, -6.43173531e-02f, -2.47588847e-02f, 9.09655020e-02f, 9.76314098e-02f, 5.37114501e-01f, 1.63667664e-01f,
  -7.78339803e-02f, 1.17160127e-01f, 1.74667820e-01f, 1.58031806e-02f, -2.06527427e-01f, -5.88311581e-03f, 3.16758692e-01f, -1.26382276e-01f, -1.97627708e-01f, -3.75581861e-01f,
  8.50307643e-02f, -2.10890427e-01f, 2.41784051e-01f, 3.47876251e-01f, 1.78914383e-01f, -1.76382974e-01f, -5.30682392e-02f, 5.60469627e-02f, 5.98053746e-02f, 2.91852981e-01f,
  2.56853044e-01f, 2.49596417e-01f, -1.62371799e-01f, 2.20097452e-01f, 5.25903761e-01f, 4.90877777e-01f, -7.76528493e-02f, 4.95886236e-01f, 2.01987877e-01f, 1.48693532e-01f,
  -6.98052570e-02f, -4.94939424e-02f, -2.21130818e-01f, -1.96134020e-02f, -2.89590985e-01f, -1.91361487e-01f, -1.12958051e-01f, 3.64865400e-02f, -1.18995244e-02f, 3.41698863e-02f,
  -1.53546780e-01f, -9.04386565e-02f, -5.59892319e-02f, 1.05716191e-01f, -9.66236219e-02f, 2.53220677e-01f, 7.53858089e-02f, -2.35304072e-01f, -7.41941929e-02f, 6.36011213e-02f,
  5.68409115e-02f, 3.84508222e-02f, 2.71035582e-01f, -2.44418979e-01f, -3.90824258e-01f, -4.88350587e-03f, 2.24056453e-01f, 1.45014152e-01f, -1.93023570e-02f, 2.27509793e-02f,
  1.80065915e-01f, 1.29743278e-01f, -2.47288272e-01f, -9.78428721e-02f, 1.09145798e-01f, -3.00320655e-01f, -1.55392617e-01f, -6.54379874e-02f, 7.35542998e-02f, -2.22592428e-02f,
  -2.54569918e-01f, 1.40963972e-01f, -1.72751829e-01f, 3.82586688e-01f, -3.34709495e-01f, 1.14706188e-01f, 1.13698266e-01f, -1.65601656e-01f, 1.09282233e-01f, -3.02644134e-01f,
  -3.33183944e-01f, -3.12266320e-01f, -3.48584533e-01f, -2.03374207e-01f, -2.09724665e-01f, -1.85398117e-01f, -1.11767620e-01f, 2.39853814e-01f, 5.15231602e-02f, 4.47447896e-02f,
  -8.53454322e-02f, -4.52862978e-02f, 4.22928259e-02f, -2.47075051e-01f, 7.66865239e-02f, -1.80604625e-02f, -2.00338155e-01f, 1.05773665e-01f, -2.12086290e-01f, 2.23184675e-01f,
  -2.14015588e-01f, 1.01886317e-01f, 7.91785400e-03f, 1.79935291e-01f, -1.45368725e-01f, 3.18260640e-01f, -9.72573310e-02f, 2.05977913e-03f
};

// L2_fan_Wp_bar (Shape: 14 x 32)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  5.98922037e-02f, 2.39733890e-01f, 5.81039935e-02f, -5.44322655e-02f, -2.31840387e-01f, -3.28029506e-02f, 1.50395960e-01f, 2.04073220e-01f, -1.66461691e-01f, 3.10310125e-01f,
  -4.36270386e-02f, 3.13883424e-01f, 1.16059296e-01f, 6.66350052e-02f, 6.18652642e-01f, 1.04060099e-01f, 3.04003321e-02f, 3.73284728e-03f, -5.45179248e-01f, -7.07787322e-03f,
  -1.50736928e-01f, -4.68273796e-02f, -3.44095737e-01f, 4.22492884e-02f, 4.50720131e-01f, -2.93459501e-02f, -2.97375351e-01f, -2.05123946e-01f, -6.65938929e-02f, 6.32494569e-01f,
  -1.95983738e-01f, 4.66637105e-01f, -2.65704449e-02f, 4.20215428e-02f, 6.95159286e-02f, -9.03307125e-02f, 2.19259903e-01f, 1.27843723e-01f, -1.34333417e-01f, 1.52645871e-01f,
  8.09473172e-02f, -1.35551587e-01f, -2.59013325e-01f, -8.89461413e-02f, -4.34097499e-02f, -1.64092496e-01f, -1.35283381e-01f, -1.15845986e-01f, -7.49751404e-02f, -7.90455006e-03f,
  7.23200366e-02f, 1.52815104e-01f, -1.62721500e-01f, 7.77583346e-02f, 8.61140117e-02f, 3.41026664e-01f, -1.90856934e-01f, 9.25039575e-02f, -2.77264360e-02f, 2.92403609e-01f,
  -4.34161685e-02f, 1.60923660e-01f, -1.26131907e-01f, -1.87885284e-01f, -1.36085585e-01f, 2.94710129e-01f, -2.66177505e-01f, 3.35011035e-01f, 1.11480221e-01f, -2.51430571e-01f,
  -8.69340822e-02f, -8.34279358e-02f, -1.75992578e-01f, -2.87075520e-01f, -3.31413537e-01f, -4.28176433e-01f, -3.15195732e-02f, 2.54711270e-01f, -3.44765447e-02f, 2.60584801e-01f,
  2.56845504e-01f, 2.57363439e-01f, 7.72382021e-01f, 6.54613227e-02f, -2.00593457e-01f, -2.24167392e-01f, -1.87126234e-01f, 5.31873405e-01f, -2.32569113e-01f, 3.54040325e-01f,
  4.96807396e-01f, 5.71835101e-01f, -1.17922634e-01f, 5.64616859e-01f, 2.80573279e-01f, 1.25803053e-01f, 2.99959600e-01f, -8.10725391e-02f, -7.47887418e-02f, 2.15544492e-01f,
  7.92106688e-02f, 6.49076030e-02f, 1.58232041e-02f, -1.07928447e-01f, 4.22911234e-02f, -8.22681095e-03f, 2.77082205e-01f, -2.85497725e-01f, -2.17177555e-01f, -1.86076805e-01f,
  1.33989707e-01f, -8.07394683e-02f, -3.03996384e-01f, -1.09217167e-01f, 3.18031162e-01f, 2.16365210e-03f, -8.62364620e-02f, -2.96624331e-03f, 1.70857310e-01f, 1.45583957e-01f,
  -3.12659256e-02f, 2.13155881e-01f, 3.15296254e-03f, -2.38356590e-01f, 3.03775191e-01f, 1.52680621e-01f, 3.36011976e-01f, -7.85308629e-02f, 2.25016735e-02f, 4.27080058e-02f,
  -1.39997989e-01f, 7.89330974e-02f, -2.47134537e-01f, -9.90894884e-02f, 3.77742946e-03f, -4.00839038e-02f, 1.28500700e-01f, -6.29353337e-03f, -1.17929295e-01f, 3.71641666e-02f,
  7.96928406e-02f, -7.45705739e-02f, -3.44588384e-02f, 1.77106604e-01f, -6.97639138e-02f, 8.80031753e-03f, -5.66620789e-02f, 6.17603809e-02f, -1.59111276e-01f, 8.32806453e-02f,
  -1.49941117e-01f, -4.38850224e-02f, -1.36062965e-01f, 1.25411764e-01f, -1.79811209e-01f, -2.34361142e-02f, -1.15306191e-01f, -1.26105458e-01f, -8.28404501e-02f, -9.28490087e-02f,
  -2.21332118e-01f, -4.31590565e-02f, 3.70855406e-02f, -8.76092818e-03f, -1.64444014e-01f, 1.55591846e-01f, -1.87429368e-01f, -9.93924141e-02f, 1.05210058e-01f, -1.11696079e-01f,
  2.31005885e-02f, -2.22608149e-01f, -2.19357416e-01f, -1.76520392e-01f, -1.10537924e-01f, -9.43219736e-02f, 6.23017251e-02f, -1.04904480e-01f, 4.71007526e-01f, 1.11602575e-01f,
  -9.94020998e-02f, -8.54853764e-02f, 3.51766050e-01f, -4.25073430e-02f, -2.12841272e-01f, -2.34986961e-04f, 4.91330400e-02f, 5.40680662e-02f, -3.29773091e-02f, -5.00091389e-02f,
  6.47638664e-02f, -1.29084205e-02f, -1.15261853e-01f, -3.44054662e-02f, -5.82127832e-02f, -1.20908774e-01f, 8.76604021e-02f, 2.67832935e-01f, 2.21746027e-01f, 1.72163755e-01f,
  1.92923337e-01f, 1.32491931e-01f, 1.89111941e-02f, 3.81079584e-01f, 3.31434458e-01f, -9.98005047e-02f, 1.81230202e-01f, 3.78374517e-01f, -1.82759110e-02f, -3.42738889e-02f,
  -1.65355206e-01f, -9.96200889e-02f, 1.38920560e-01f, 2.82224596e-01f, -7.80332983e-02f, -1.21539064e-01f, 2.76010841e-01f, 9.50548053e-02f, -2.37145871e-02f, -1.32276192e-01f,
  2.79617310e-01f, -1.17109217e-01f, 6.97859153e-02f, 1.44181699e-01f, 1.01679228e-01f, -8.43346789e-02f, -7.24081919e-02f, 2.09900647e-01f, -8.13451111e-02f, 1.52204245e-01f,
  1.18192472e-01f, 2.04091296e-01f, 2.48798914e-02f, -3.04548621e-01f, -1.27073437e-01f, -1.04044423e-01f, 2.20459187e-03f, -1.70489475e-01f, -6.94214255e-02f, -2.49967098e-01f,
  1.05001301e-01f, -2.08389997e-01f, -9.38215256e-02f, 1.25752846e-02f, 2.13811830e-01f, -8.69919434e-02f, 5.82412705e-02f, 1.72545582e-01f, -5.34546673e-02f, 1.20869003e-01f,
  -2.05290645e-01f, -1.83496792e-02f, 9.62027907e-02f, 2.59069074e-02f, -9.64019354e-03f, -1.55806839e-01f, -1.17908917e-01f, -1.44792005e-01f, 7.03465566e-02f, -2.05968432e-02f,
  2.34451547e-01f, -1.44913986e-01f, 2.98310876e-01f, 1.40568838e-01f, 8.00765455e-02f, 3.96807015e-01f, 3.92658472e-01f, 2.64587939e-01f, 4.33906578e-02f, 5.75552210e-02f,
  4.18503493e-01f, 2.54339218e-01f, 1.94675047e-02f, -4.43689048e-01f, -3.90883952e-01f, -2.22872615e-01f, 6.45882487e-02f, 2.66355246e-01f, -2.30834007e-01f, 3.34308326e-01f,
  3.01411301e-01f, -7.29085431e-02f, -1.11844599e-01f, -2.15625539e-02f, 5.99497259e-01f, 1.84843436e-01f, 2.41090864e-01f, -2.17208296e-01f, 6.79072142e-02f, 1.63625643e-01f,
  1.11197516e-01f, 4.45389986e-01f, 2.95871608e-02f, 4.58328992e-01f, 2.61969507e-01f, 5.98407798e-02f, 5.86378813e-01f, -3.84166658e-01f, 4.89232212e-01f, -5.11187017e-01f,
  -4.18748558e-01f, -2.48346448e-01f, -7.71985762e-03f, -5.50771117e-01f, -4.91970897e-01f, -2.37858906e-01f, 5.36846220e-01f, 2.89772451e-01f, 3.33149917e-02f, 2.18920738e-01f,
  3.95956755e-01f, -1.99351773e-01f, 5.84407859e-02f, 1.97599113e-01f, 9.55725685e-02f, -9.84764397e-02f, -1.04824014e-01f, -1.45687312e-01f, -1.47289842e-01f, 8.28530453e-03f,
  -4.54206504e-02f, -1.36657491e-01f, 4.32619303e-02f, 9.59441513e-02f, 8.70644748e-02f, 6.42277226e-02f, -7.74737075e-02f, -2.65184399e-02f, 1.94702566e-01f, 2.14941844e-01f,
  -9.05019194e-02f, 1.25265494e-01f, 1.26236290e-01f, -7.33095407e-02f, 9.66379941e-02f, -5.44793271e-02f, 2.91668531e-02f, 9.04918537e-02f, -1.69430077e-02f, -1.62225217e-01f,
  1.48564801e-01f, 8.13944265e-02f, -1.66669548e-01f, 1.21508412e-01f, -9.38896313e-02f, -1.46404162e-01f, -4.15195199e-03f, 4.06311415e-02f, 2.20595643e-01f, -1.12636089e-02f,
  -1.07733801e-03f, -3.66569683e-02f, 2.52761245e-01f, -2.09175378e-01f, 2.93259565e-02f, 2.50853866e-01f, 2.22736776e-01f, -9.91118923e-02f, -6.56164065e-02f, -1.12738527e-01f,
  -1.02888346e-01f, -1.70571685e-01f, 1.04699999e-01f, 1.10852554e-01f, -4.27688062e-01f, -4.65417355e-02f, 1.05045274e-01f, -3.70490611e-01f, -8.70185196e-02f, -2.70772040e-01f,
  -6.52327240e-02f, -9.72788632e-02f, -1.50686085e-01f, -1.10444263e-01f, 2.34137937e-01f, 1.92211047e-01f, 1.81870554e-02f, 1.11262135e-01f, -1.09393239e-01f, 1.00219466e-01f,
  7.20808804e-02f, 5.33102155e-01f, -2.18819529e-02f, 1.83830991e-01f, 6.91420808e-02f, -2.23342717e-01f, -2.01803800e-02f, 3.16343531e-02f, -1.65220082e-01f, -1.08177967e-01f,
  -1.51796266e-01f, -1.33456402e-02f, -1.52641609e-01f, 1.20874301e-01f, -5.18478788e-02f, -1.11154132e-02f, -1.86519653e-01f, -6.87859580e-02f, 2.94795483e-01f, -1.55865714e-01f,
  -1.03295613e-02f, -7.24598542e-02f, -2.38207012e-01f, -1.48667455e-01f, 9.77455899e-02f, 6.86904415e-02f, -8.54628906e-02f, 1.00746363e-01f, 1.85104147e-01f, -3.67032401e-02f,
  -4.03663255e-02f, -1.07675195e-01f, 2.10710779e-01f, 3.06346387e-01f, 2.98872828e-01f, 8.47356319e-02f, 3.44421297e-01f, -2.62109399e-01f, 1.76723510e-01f, 2.16104940e-01f,
  2.03478321e-01f, 1.48565292e-01f, 3.19993973e-01f, -1.52157485e-01f, -2.66455376e-04f, 9.94076282e-02f, 6.99945569e-01f, 2.72378057e-01f, 1.86998725e-01f, -4.31296796e-01f,
  2.17022255e-01f, -6.73764795e-02f, -4.58925933e-01f, -4.76813555e-01f, 1.58177793e-01f, 2.01943636e-01f, 6.84525892e-02f, 4.29881215e-01f, 4.69833799e-02f, 4.73424584e-01f,
  1.55494018e-02f, 3.04865539e-01f, -2.28848755e-01f, 7.80913085e-02f, 6.52033925e-01f, 2.36503735e-01f, -1.57752529e-01f, -3.86502594e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  2.39971355e-01f, -7.16065988e-02f, 1.01500653e-01f, -5.93420379e-02f, -1.66253030e-01f, -3.92590091e-02f, 2.83330560e-01f, 2.13001832e-01f, 2.50711262e-01f, 3.06133062e-01f,
  1.04777522e-01f, -1.05355695e-01f, 1.49571210e-01f, 1.13120876e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -3.39885563e-01f, -6.43432796e-01f, -5.41181266e-01f, 3.14197928e-01f, 7.91276768e-02f, -2.91315079e-01f, 5.24892146e-03f, -4.93250825e-02f, -7.50283077e-02f, 1.10868983e-01f,
  -7.88913488e-01f, -5.87126948e-02f, 2.88959593e-01f, -1.32366329e-01f, -1.29213547e-02f, -6.22405112e-01f, -1.03497662e-01f, -5.44083118e-02f, -2.17761800e-01f, 5.88104390e-02f,
  4.82187986e-01f, 3.88314389e-02f, -1.05713136e-01f, 5.03100514e-01f, 1.12406358e-01f, 4.98053618e-02f, -3.43174577e-01f, 4.46696520e-01f, -3.89605351e-02f, -1.64616957e-01f,
  6.67065382e-02f, -7.92365313e-01f, -2.01149046e-01f, 6.95290744e-01f, -6.11841500e-01f, 1.91447720e-01f, 4.04708721e-02f, -1.97425798e-01f, 2.28987277e-01f, 1.93460077e-01f,
  -8.84830952e-02f, 1.34626374e-01f, -2.14526862e-01f, 8.18718374e-02f, -6.36035979e-01f, -1.39469475e-01f, 1.17470212e-01f, 6.18154943e-01f, 6.97482144e-03f, -2.40551513e-02f,
  -3.11551213e-01f, 1.52358741e-01f, 1.17210853e+00f, -5.86258024e-02f, -8.56354162e-02f, 3.78541946e-02f, -3.15386683e-01f, -1.71638429e-01f, 2.55333841e-01f, -5.93136132e-01f,
  -1.00170344e-01f, -2.34611809e-01f, 9.34110209e-02f, -4.67256278e-01f, 3.73887002e-01f, 1.72643811e-01f, 5.27789712e-01f, 2.93120742e-01f, -4.88579869e-02f, 3.52816910e-01f,
  5.20053625e-01f, 2.14182854e-01f, 1.74177453e-01f, 4.08417165e-01f, 5.71160674e-01f, -5.49837887e-01f, 4.93470788e-01f, 6.92885667e-02f, -1.84204429e-02f, -3.96077603e-01f,
  1.96797829e-02f, 3.11729640e-01f, -4.56566781e-01f, 3.56909156e-01f, 3.00225407e-01f, 9.31378677e-02f, -8.01484287e-02f, -1.74878940e-01f, -1.41396418e-01f, 2.45151803e-01f,
  -4.60805558e-02f, -1.51065528e-01f, 4.25599255e-02f, 3.89766023e-02f, -2.12827697e-01f, 6.79481030e-01f, 5.59341669e-01f, 5.50045729e-01f, 7.15337038e-01f, 2.34486118e-01f,
  3.48819911e-01f, 5.06679058e-01f, 3.65643859e-01f, 4.82520431e-01f, -2.14412794e-01f, 3.40498477e-01f, -6.79973006e-01f, 5.63378513e-01f, 3.22006494e-01f, -2.25624032e-02f,
  5.42972624e-01f, -5.82332313e-01f, -9.12070740e-03f, -4.92046714e-01f, -3.74580353e-01f, 1.32659927e-01f, -4.22661573e-01f, -2.30834931e-02f, -2.08666176e-01f, 2.73652468e-02f,
  -1.93549365e-01f, 2.72522390e-01f, -4.31314230e-01f, 6.94429576e-01f, -2.32199326e-01f, -5.15149068e-03f, -9.04410034e-02f, -2.41746172e-01f, 3.24783504e-01f, 2.78608561e-01f,
  4.88901921e-02f, -2.10469469e-01f, -4.27511126e-01f, -4.81991231e-01f, -1.94017783e-01f, -6.65937543e-01f, -2.57108547e-02f, -2.58017808e-01f, -6.58017159e-01f, 4.59415525e-01f,
  1.99902460e-01f, 1.82158485e-01f, 1.75497949e-01f, -2.22557440e-01f, -1.43549576e-01f, 1.31777301e-01f, 2.82382779e-02f, -5.73778078e-02f, -1.82119504e-01f, 3.98408890e-01f,
  1.29744828e-01f, 3.65468085e-01f, -1.68434456e-01f, -1.67235091e-01f, -5.22551477e-01f, 5.28983235e-01f, -5.74649014e-02f, -1.07272424e-01f, 1.14236303e-01f, 5.36042392e-01f,
  -4.38380182e-01f, 1.36266500e-01f, 3.87966603e-01f, 6.02860093e-01f, -1.26147002e-01f, -2.17572138e-01f, 6.53434634e-01f, 2.22104147e-01f, -7.21417144e-02f, 1.32216185e-01f,
  6.41481161e-01f, 4.28927094e-01f, -4.43680584e-01f, 4.37369704e-01f, 2.37074703e-01f, 7.29380429e-01f, -3.29638779e-01f, -5.05614400e-01f, -1.30448833e-01f, -3.38840991e-01f,
  2.23235324e-01f, 3.81903231e-01f, -4.56974246e-02f, -1.02502927e-01f, -5.86261116e-02f, -1.55843914e-01f, -2.90514082e-01f, 7.06057191e-01f, -5.62155843e-02f, -1.57554537e-01f,
  -4.23713960e-02f, -1.18032828e-01f, -1.67845637e-01f, -1.85099944e-01f, -2.87876129e-01f, -3.65804344e-01f, -1.67082250e-01f, -3.83515626e-01f, 1.00119308e-01f, -2.44084641e-01f,
  -3.19797575e-01f, -6.11179829e-01f, -1.13671906e-01f, -1.08261928e-01f, 3.04354072e-01f, -5.71078002e-01f, -3.37870061e-01f, -5.63039184e-01f, -4.79759395e-01f, -1.00033842e-01f,
  1.42482843e-03f, -1.88574791e-01f, -4.70584452e-01f, 1.56771943e-01f, 4.22945954e-02f, -9.61708724e-02f, 3.82680774e-01f, -1.68440372e-01f, 6.76387131e-01f, -7.30438888e-01f,
  7.37740472e-02f, -1.05960928e-01f, 3.09459060e-01f, 4.64509696e-01f, 3.51309106e-02f, -2.44155645e-01f, -3.07142258e-01f, 7.19047263e-02f, -3.65442008e-01f, -5.33622503e-01f,
  1.94224030e-01f, 2.77488269e-02f, -1.12596728e-01f, -4.32269514e-01f, -1.89067230e-01f, 1.19784236e-01f, 4.12630051e-01f, -7.24463165e-02f, 4.57841996e-03f, -2.62490273e-01f,
  2.53756016e-01f, 4.66232479e-01f, 5.07479429e-01f, -2.80322488e-02f, 3.10698032e-01f, 5.04957810e-02f, 9.97080356e-02f, -1.80126429e-01f, -2.75002599e-01f, -1.47396997e-01f,
  1.44305646e-01f, -2.52977580e-01f, 4.26861420e-02f, 4.84210551e-01f, 2.92840689e-01f, -1.56588867e-01f, -3.07507426e-01f, -6.41099632e-01f, -3.67868245e-01f, -2.41828814e-01f,
  2.14788511e-01f, 1.61161616e-01f, -4.33116555e-01f, -3.65963280e-01f, 7.05929846e-02f, 4.93107051e-01f, 1.36165187e-01f, -6.43839777e-01f, -6.88297451e-01f, -6.08737990e-02f,
  -3.33636254e-01f, 3.40110272e-01f, 4.46180463e-01f, 2.87030458e-01f, 9.22529519e-01f, -2.22742960e-01f, -2.26754740e-01f, -3.27983260e-01f, 1.84795663e-01f, -2.66742080e-01f,
  6.18874282e-02f, -4.47485149e-02f, 1.84633091e-01f, -2.77325034e-01f, -1.38876706e-01f, -2.34015644e-01f, 1.25833213e-01f, -3.73895735e-01f, 4.33899648e-02f, 1.43879980e-01f,
  1.03124864e-01f, -6.72853947e-01f, 5.40339425e-02f, 7.10337535e-02f, -5.56514084e-01f, -3.47633749e-01f, -4.16021841e-03f, -5.08046567e-01f, 4.53358442e-01f, -6.28464580e-01f,
  1.97261810e-01f, 3.18456054e-01f, -1.40695587e-01f, -1.10506862e-01f, -3.48964572e-01f, 4.18068692e-02f, -3.72672915e-01f, -5.94461635e-02f, -4.70945120e-01f, 5.40534317e-01f,
  8.95609334e-03f, -8.33128095e-02f, -2.50696778e-01f, 1.27048776e-01f, 2.16097027e-01f, -2.13454105e-02f, -1.08187590e-02f, 4.31508482e-01f, 2.59671450e-01f, 5.63250184e-01f,
  -3.45353395e-01f, -1.82167776e-02f, 9.81909275e-01f, -4.09308970e-01f, 4.10958439e-01f, 5.93666971e-01f, -6.02411389e-01f, 5.41442573e-01f, 4.32496339e-01f, 7.36663103e-01f,
  8.28753233e-01f, 1.30181521e-01f, -7.52627552e-01f, -1.69590354e-01f, 4.46081489e-01f, 5.17831147e-01f, 3.80998105e-01f, -1.74589023e-01f, -3.87219936e-01f, 3.79507281e-02f,
  -1.78223327e-01f, -8.42216983e-02f, 2.91991979e-02f, -1.82341691e-02f, 2.25828737e-01f, -2.14980200e-01f, -3.38014215e-01f, -2.71067023e-01f, 3.27772088e-02f, -3.16243082e-01f,
  -3.37481976e-01f, -4.48076516e-01f, 6.89046502e-01f, -4.15849358e-01f, -6.21765077e-01f, 7.55497754e-01f, -1.24948762e-01f, 2.07153738e-01f, 7.68619105e-02f, 1.51749894e-01f,
  -1.29615277e-01f, 2.57530928e-01f, 1.54667601e-01f, -2.75553137e-01f, -1.51285827e-01f, -6.72720432e-01f, -3.23183656e-01f, 7.43330300e-01f, -1.13621086e-01f, -3.54743391e-01f,
  1.85549393e-01f, -1.14581779e-01f, -6.06675565e-01f, -2.48654827e-01f, -1.69408396e-01f, -1.89536184e-01f, 4.51297551e-01f, -1.35593489e-02f, 6.47279143e-01f, -3.68522078e-01f,
  2.78722882e-01f, -3.68905306e-01f, -1.02311872e-01f, 2.54031539e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.71737611e-01f, 3.90798338e-02f, -9.25465450e-02f, 1.93045780e-01f, -2.27129564e-01f, 7.93549418e-03f, -1.65884688e-01f, -2.05089122e-01f, -6.26367107e-02f, -1.22231789e-01f,
  4.30069745e-01f, 1.73003241e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    