/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.61308067e-02f, -8.60853940e-02f, -3.04683298e-01f, 4.42389660e-02f, -1.99562218e-02f, 8.79302546e-02f, -4.25903164e-02f, 1.50272265e-01f, 1.85269013e-01f, -4.84617427e-03f,
  -6.59451559e-02f, 2.30784789e-01f, 1.05327405e-02f, 4.24231663e-02f, 3.03056911e-02f, -7.68204406e-02f, -6.81132963e-03f, -4.57673632e-02f, 1.20048605e-01f, 2.79015213e-01f,
  2.81863332e-01f, 1.40571624e-01f, 1.19021095e-01f, 8.68392736e-02f, 2.67032664e-02f, 1.46688238e-01f, -2.37758651e-01f, -1.31506115e-01f, -1.05855040e-01f, -2.13073581e-01f,
  -4.12406594e-01f, -2.05403447e-01f, 4.66312617e-02f, -1.96364839e-02f, -5.25898747e-02f, -8.17906037e-02f, -1.62057076e-02f, -2.78334264e-02f, -1.98114589e-02f, -4.27801087e-02f,
  -1.42737746e-01f, 3.63961863e-03f, -2.92488816e-03f, -3.48616466e-02f, -1.29317388e-01f, -1.61780026e-02f, -6.31714389e-02f, -1.48325413e-01f, -1.38158292e-01f, -6.94597885e-02f,
  8.46493691e-02f, -2.06614509e-01f, -1.65960103e-01f, -4.41033840e-02f, -3.15410607e-02f, 1.21161873e-02f, -2.05567211e-01f, -6.13180958e-02f, -1.33377597e-01f, -1.54685885e-01f,
  9.63685801e-04f, -1.59003168e-01f, -3.93303037e-02f, 2.07572673e-02f, 5.72997965e-02f, -6.03899695e-02f, 7.62062846e-03f, -1.88737852e-03f, 9.00977850e-02f, -1.75305866e-02f,
  6.73178434e-02f, 2.05301885e-02f, 3.31759267e-02f, -5.29255122e-02f, -1.37740606e-03f, -4.83452007e-02f, 4.78386916e-02f, -5.12400754e-02f, 5.14248805e-03f, 4.90566492e-02f,
  4.17288803e-02f, 3.68227325e-02f, -2.62412261e-02f, 9.51389894e-02f, -2.18180884e-02f, 3.80716138e-02f, -9.51477140e-03f, 8.84944871e-02f, 1.11232147e-01f, -5.53939864e-02f,
  1.17714025e-01f, -2.67608576e-02f, 4.72771712e-02f, 7.04364330e-02f, -8.07693601e-02f, 5.89802908e-03f, -9.20859352e-02f, -1.20140882e-02f, -1.01266012e-01f, -4.30485122e-02f,
  -3.18855979e-02f, -1.32333627e-02f, -3.88514027e-02f, -5.32804132e-02f, -4.64148074e-03f, 7.78963193e-02f, -1.23085827e-03f, -3.25621404e-02f, 2.39226818e-02f, 5.42426705e-02f,
  -8.29483848e-03f, 8.83389190e-02f, 1.12583609e-02f, -9.53061655e-02f, -1.00097461e-02f, -3.33070196e-02f, -1.20136656e-01f, 3.63796856e-03f, -2.91286409e-02f, 1.50964782e-01f,
  9.18357223e-02f, -2.63430588e-02f, -1.15305416e-01f, 2.52367910e-02f, -6.89665154e-02f, 5.32671483e-03f, -2.35943124e-01f, 6.84016943e-02f, 1.61098242e-01f, -1.33982552e-02f,
  1.58386588e-01f, 3.55972022e-01f, 3.89306694e-01f, 2.18186259e-01f, 9.68194082e-02f, -1.60836995e-01f, -5.55569716e-02f, 1.01081334e-01f, 1.87531039e-01f, 9.47251767e-02f,
  8.10310990e-02f, 1.11479715e-01f, 4.63714711e-02f, 7.13317990e-02f, -7.55748004e-02f, 2.30319276e-01f, -1.53397638e-02f, -2.83665415e-02f, 3.92737389e-02f, -1.88871339e-01f,
  3.42497006e-02f, 1.48086557e-02f, 1.58889934e-01f, 1.99059412e-01f, 1.97707087e-01f, 1.26307026e-01f, 5.74941412e-02f, 1.72757059e-01f, 1.75145492e-01f, 1.08852088e-01f,
  1.44141153e-01f, 8.72483626e-02f, 8.63873661e-02f, 4.42935973e-02f, 9.88546237e-02f, 1.27390817e-01f, 1.68812647e-01f, 1.15084000e-01f, 1.04150109e-01f, 1.17874354e-01f,
  6.34947792e-02f, 3.57153527e-02f, 5.93656190e-02f, 1.72202080e-01f, 9.60587561e-02f, 2.03483760e-01f, 4.32922319e-03f, -8.88528675e-03f, 1.90972775e-01f, -8.26018229e-02f,
  1.41245499e-01f, -4.81630974e-02f, -1.75637286e-02f, -1.05959676e-01f, -8.83598179e-02f, 3.20402756e-02f, -9.88972709e-02f, 2.85155699e-02f, -8.29992443e-02f, -1.22459456e-01f,
  -3.73997912e-03f, -1.56445742e-01f, -7.12799802e-02f, -8.21362585e-02f, -1.77930854e-02f, -1.07703485e-01f, 2.55382732e-02f, -8.30868483e-02f, -4.02190574e-02f, -3.62988487e-02f,
  -2.26820586e-03f, -2.43139602e-02f, -7.12738708e-02f, -4.77794521e-02f, -1.02772973e-01f, -3.92808504e-02f, -1.42018095e-01f, -7.92715773e-02f, -8.90703723e-02f, -9.21038687e-02f,
  1.03638269e-01f, 2.69346684e-01f, 4.66030352e-02f, 3.47856209e-02f, 1.64443776e-01f, 1.25210732e-01f, 1.50523409e-01f, 1.21450581e-01f, 1.48348108e-01f, 7.73210004e-02f,
  1.33653641e-01f, 7.81475827e-02f, 1.93961084e-01f, 1.20889790e-01f, 1.18762910e-01f, 1.44146204e-01f, 2.73763891e-02f, 1.02412947e-01f, 5.50713055e-02f, 1.83647111e-01f,
  2.23513693e-02f, 1.21560708e-01f, 1.01670891e-01f, 1.44438520e-01f, 1.11617357e-01f, 1.13975391e-01f, 1.14201702e-01f, 1.48126870e-01f, 1.75229460e-01f, 1.77839939e-02f,
  -5.37505522e-02f, -9.21125561e-02f, 3.28489125e-01f, 6.45874068e-02f, -3.72251794e-02f, 6.07275516e-02f, -1.49772689e-01f, -3.76652032e-02f, -3.41230407e-02f, 1.26607999e-01f,
  1.08487681e-01f, 2.85102397e-01f, 1.11615591e-01f, 2.15353504e-01f, 2.69274004e-02f, 3.63002494e-02f, -5.80518320e-03f, 1.89920411e-01f, 3.38946551e-01f, 7.00270310e-02f,
  5.85400462e-02f, 7.48527646e-02f, 1.29113510e-01f, 1.15744494e-01f, 4.59298398e-03f, 4.86756973e-02f, -5.42148389e-03f, 8.80729109e-02f, 1.02694638e-01f, 3.19543034e-01f,
  3.88642341e-01f, -6.16277494e-02f, 1.29963577e-01f, -4.80885021e-02f, 2.41056806e-03f, 4.63569723e-02f, 1.56887427e-01f, 2.71896552e-02f, -3.52262519e-02f, 3.06202322e-02f,
  9.39138010e-02f, -2.21288530e-03f, -4.75801565e-02f, -7.59347517e-04f, 1.93702001e-02f, 6.32657856e-03f, -5.12581728e-02f, 1.10877752e-01f, 7.94875100e-02f, 1.13955634e-02f,
  -8.94551203e-02f, 6.46967366e-02f, 1.45378202e-01f, -7.95695037e-02f, -9.80994757e-03f, 3.18100490e-02f, 9.38525796e-02f, 6.53465241e-02f, 4.45949547e-02f, 1.47140428e-01f,
  -6.71424046e-02f, 5.54864877e-04f, -1.25168398e-01f, -8.85054991e-02f, -6.61938414e-02f, -1.78517979e-02f, 8.85678753e-02f, -5.02511188e-02f, 2.69923266e-02f, 2.36971700e-03f,
  3.75179719e-04f, -1.10196741e-02f, 9.37256590e-03f, -6.73691332e-02f, 2.38286071e-02f, -2.07689386e-02f, 9.88611281e-02f, 2.06176620e-02f, -3.01661287e-02f, -1.10498611e-02f,
  8.13219417e-03f, -6.04547141e-03f, -2.63389274e-02f, -1.69810595e-03f, -7.06896409e-02f, 8.03883672e-02f, 2.87839794e-03f, -5.22730723e-02f, -2.58203261e-02f, -2.52409317e-02f,
  1.57487631e-01f, -4.18528132e-02f, 8.74086767e-02f, 9.90533903e-02f, 1.51850982e-02f, 9.54326466e-02f, 1.38400272e-02f, 1.27697811e-01f, 1.96131617e-02f, 1.57099143e-01f,
  7.86123499e-02f, 6.07217327e-02f, 1.03481580e-02f, -3.96303646e-02f, 5.83006293e-02f, 3.67170982e-02f, -5.65618016e-02f, 6.87122196e-02f, 1.03931203e-01f, 2.59232894e-02f,
  -7.56923854e-02f, 1.56454332e-02f, 7.61197731e-02f, 4.90026586e-02f, 9.95796989e-04f, 2.16540005e-02f, 1.30270332e-01f, 1.24230012e-01f, 1.64100468e-01f, 8.01816285e-02f,
  4.43514884e-01f, -2.35377908e-01f, -5.75345382e-03f, 1.36633053e-01f, -1.96002275e-01f, -1.88503191e-01f, -1.85196728e-01f, -4.79476005e-02f, -1.46924788e-02f, -1.16372414e-01f,
  -1.24045938e-01f, 6.53846636e-02f, 4.94560637e-02f, 3.84714603e-02f, -1.10675238e-01f, -2.40311146e-01f, -1.31539434e-01f, 1.05122559e-01f, 1.92914233e-01f, 1.08292557e-01f,
  -4.42907633e-03f, -7.62241930e-02f, 9.77978259e-02f, -1.67826880e-02f, -9.50843543e-02f, 9.81873721e-02f, -1.92877382e-01f, -7.76774660e-02f, -1.86925262e-01f, -8.58932510e-02f,
  9.56962779e-02f, 4.18837601e-03f, -4.22651060e-02f, -1.54167950e-01f, -1.87451899e-01f, -3.83839905e-02f, -8.33255947e-02f, -5.87068386e-02f, -1.07464939e-01f, -1.45102113e-01f,
  -9.29533467e-02f, -4.06187251e-02f, -3.55322622e-02f, -5.01557402e-02f, 3.96759398e-02f, 1.12607726e-03f, 1.16943391e-02f, 2.86833979e-02f, -9.58676934e-02f, -3.08144707e-02f,
  -3.69191878e-02f, -1.70669600e-01f, -1.52023584e-01f, -1.84560254e-01f, -1.24438226e-01f, -1.21155299e-01f, -1.17784075e-01f, -8.95336494e-02f, -3.48882638e-02f, 8.01765546e-02f,
  6.65599247e-03f, -7.07673281e-02f, 5.20185195e-02f, 2.25111637e-02f, -2.48040035e-02f, 6.70500398e-02f, -9.29307193e-02f, 2.52791997e-02f, -1.68825965e-02f, -5.82266226e-02f,
  -6.43774346e-02f, -1.22287199e-02f, 9.49108750e-02f, 1.26513587e-02f, 5.25834747e-02f, -2.07067002e-02f, 3.15660983e-02f, 1.04063461e-02f, -7.17834244e-03f, 1.28732342e-02f,
  -2.01399066e-02f, 9.46837962e-02f, 1.90807134e-02f, 3.66091281e-02f, -5.71090616e-02f, 6.20912760e-03f, 8.78291801e-02f, -1.65107232e-02f, 3.95479649e-02f, -7.26795644e-02f,
  1.79472327e-01f, -1.78411081e-01f, 2.72607822e-02f, 2.62932200e-02f, 2.55592354e-02f, 7.65226968e-03f, 2.48011295e-02f, 3.23104374e-02f, -4.81253415e-02f, -6.01740461e-03f,
  -4.10508402e-02f, 2.75344569e-02f, 6.14420325e-02f, -4.03902642e-02f, 4.55837436e-02f, 3.17613445e-02f, -2.87840236e-02f, -2.44490895e-02f, -8.48955885e-02f, -3.65195167e-03f,
  1.90353524e-02f, 9.89760160e-02f, 1.28090963e-01f, 4.08604415e-03f, 8.13268423e-02f, 7.30087683e-02f, 6.84217066e-02f, 8.06447864e-02f, -4.60590459e-02f, 4.51925695e-02f,
  -3.61809224e-01f, 2.87510425e-01f, 1.78443819e-01f, -1.62950560e-01f, -2.83525474e-02f, 6.71817139e-02f, 1.13460816e-01f, -9.33282077e-02f, -1.72533572e-01f, 5.72165698e-02f,
  4.73545380e-02f, -1.17871329e-01f, -9.68998894e-02f, -1.12664349e-01f, -1.76499754e-01f, 3.36881429e-02f, 3.54531631e-02f, -1.66151211e-01f, -3.05662274e-01f, -2.44074762e-01f,
  4.28019911e-02f, 6.22948147e-02f, -8.67165625e-02f, -1.75741047e-01f, 1.26401126e-01f, -1.48853213e-01f, 2.21970245e-01f, 1.42487576e-02f, 8.75594243e-02f, 1.89748883e-01f,
  2.31972560e-01f, 3.70254889e-02f, -1.78005710e-01f, 2.06219498e-02f, 1.10541575e-01f, -1.29186600e-01f, -5.71546480e-02f, -4.86952178e-02f, -1.35781169e-02f, -5.53227998e-02f,
  -5.67732495e-04f, -5.04950806e-02f, -7.50026777e-02f, -3.71088050e-02f, 3.40431184e-02f, 3.04315817e-02f, 1.11350298e-01f, 4.84972857e-02f, -9.02480111e-02f, -1.01436162e-02f,
  -2.71042380e-02f, 5.62847666e-02f, 1.09400354e-01f, 4.55648117e-02f, -1.77217536e-02f, -7.70085379e-02f, 1.23708002e-01f, 3.40361893e-02f, -1.19951621e-01f, -7.27753118e-02f,
  -4.02107053e-02f, -5.82281761e-02f, 1.57432221e-02f, -1.27283623e-02f, 2.59429868e-02f, -3.58463079e-02f, 2.53123976e-02f, 2.36309189e-02f, -4.44820039e-02f, -2.95547284e-02f,
  3.73455435e-02f, 5.29165417e-02f, -4.89926822e-02f, -1.89123228e-02f, 4.89856005e-02f, 9.97456908e-02f, 5.73755503e-02f, 1.06391683e-01f, -1.31111238e-02f, -4.08543181e-03f,
  9.96499062e-02f, -3.28379567e-03f, 3.92755866e-02f, -5.00438213e-02f, 4.92109619e-02f, -6.24817610e-02f, -2.42312942e-02f, 1.18819304e-01f, 4.47775461e-02f, 3.15265320e-02f,
  -1.66684557e-02f, 4.47256584e-03f, -1.30088553e-01f, -7.32543692e-02f, 8.00748169e-02f, -4.28640805e-02f, 3.00287809e-02f, 3.64690050e-02f, 5.55581041e-02f, -2.40324140e-02f,
  3.64381596e-02f, -3.89283001e-02f, 5.66314757e-02f, -5.27322665e-02f, -1.11441977e-01f, -5.36788255e-02f, 7.96586871e-02f, -1.05730727e-01f, -5.96116297e-02f, 4.21118587e-02f,
  8.77459645e-02f, -1.16602018e-01f, -1.60854489e-01f, -1.03851609e-01f, -9.30088609e-02f, -5.35510257e-02f, -6.13587797e-02f, -1.12005379e-02f, -1.66723117e-01f, -1.09333292e-01f,
  -4.24608916e-01f, -1.26038760e-01f, 1.99273944e-01f, -2.69495964e-01f, 1.21365443e-01f, 1.05690777e-01f, -2.18854081e-02f, -1.37773648e-01f, -8.70788172e-02f, -8.19744095e-02f,
  5.45909479e-02f, 6.93169162e-02f, 6.60696402e-02f, 1.09502546e-01f, -1.51189584e-02f, -1.39405429e-01f, -1.15265027e-01f, -5.28204180e-02f, 2.07958400e-01f, 4.14263941e-02f,
  3.77698503e-02f, -6.80039749e-02f, -7.40666464e-02f, -4.75554913e-03f, -1.92229450e-01f, -1.54239342e-01f, -1.71861753e-01f, -1.00970402e-01f, -9.05137956e-02f, -3.75672877e-01f,
  4.68479395e-02f, -1.67483941e-01f, 1.34126723e-01f, -8.66611451e-02f, -7.45818913e-02f, -1.90639321e-03f, -2.64696945e-02f, -7.36194625e-02f, -1.07519096e-02f, 3.94263677e-03f,
  -1.03364497e-01f, 2.84672230e-02f, -3.03429272e-02f, -2.17997693e-02f, -9.70594957e-02f, -1.66751500e-02f, 7.59398267e-02f, 5.86485304e-02f, -4.74894680e-02f, 5.42573333e-02f,
  1.05859548e-01f, 1.96400434e-02f, -1.36117777e-02f, 9.88959447e-02f, 2.04762220e-02f, -2.79018357e-02f, -2.38752794e-02f, -8.01569596e-02f, -1.06202468e-01f, -2.70363808e-01f,
  1.42574133e-02f, -1.35556264e-02f, 4.91750203e-02f, -1.04938112e-01f, -1.62503943e-02f, 1.19698625e-02f, -8.87129679e-02f, -4.78458628e-02f, 5.97589575e-02f, 7.36266607e-03f,
  6.77992105e-02f, -4.74637039e-02f, -9.09264237e-02f, -1.20516077e-01f, -1.39967486e-01f, 4.67168093e-02f, -1.95495058e-02f, -1.40634432e-01f, -3.82888466e-02f, -2.28240285e-02f,
  -2.54757851e-02f, 8.07332769e-02f, 2.60433219e-02f, 4.68929037e-02f, 9.29612145e-02f, 1.07034594e-02f, -9.00859237e-02f, -7.52784908e-02f, -4.38636681e-03f, -3.40547343e-03f,
  -4.15909551e-02f, 1.57472696e-02f, -1.15671724e-01f, -1.54858351e-01f, -8.39097202e-02f, -1.72834266e-02f, -1.24504499e-01f, 5.95648913e-03f, -3.79422046e-02f, -4.36297059e-02f,
  1.24649331e-02f, -1.63168177e-01f, -1.13958940e-01f, 8.34896341e-02f, 6.01840355e-02f, -1.05722219e-01f, 2.89942767e-03f, 2.34411806e-02f, 2.02621650e-02f, -1.24870867e-01f,
  -6.10565618e-02f, 3.79321910e-02f, -6.65924400e-02f, -5.07120825e-02f, -1.14388607e-01f, -1.64296225e-01f, -9.54866558e-02f, -7.83557743e-02f, -6.44995421e-02f, -3.09182465e-01f,
  1.61158174e-01f, -9.95042622e-02f, 1.71457320e-01f, 5.69535606e-02f, -7.44533315e-02f, -3.01571965e-01f, -2.44124070e-01f, -1.41945228e-01f, -9.38173831e-02f, -7.13924551e-03f,
  7.15767220e-02f, 2.28777096e-01f, 1.29123747e-01f, -6.38317242e-02f, -1.24344289e-01f, -1.81613937e-01f, -6.93300888e-02f, 9.04443115e-02f, -3.59994476e-03f, -1.81206524e-01f,
  -1.20662950e-01f, 4.60224459e-03f, 1.22768000e-01f, 1.10135274e-02f, 4.74785119e-02f, 1.21623650e-01f, -1.59296449e-02f, 9.62067842e-02f, -8.17968920e-02f, 1.13256201e-01f,
  2.01229617e-01f, 1.50224995e-02f, -1.63226530e-01f, -1.12638317e-01f, 1.11652046e-01f, 4.96514514e-02f, 4.50362489e-02f, -4.61122282e-02f, 4.80156951e-02f, 3.64943147e-02f,
  4.73973434e-03f, -3.27833667e-02f, -1.50155593e-02f, 4.84826043e-02f, -4.20382656e-02f, -8.07350129e-02f, -8.54402930e-02f, 2.10574642e-02f, -1.88808981e-02f, -8.16174895e-02f,
  -1.29486382e-01f, -3.53410654e-02f, 1.28749102e-01f, -1.45407736e-01f, -1.09032549e-01f, -1.06651699e-02f, -1.36863198e-02f, -3.60058397e-02f, 5.46348165e-04f, 4.86738048e-02f,
  -1.02462955e-01f, 5.41178435e-02f, 3.25951427e-02f, 8.47602561e-02f, 6.47105509e-03f, 1.83131304e-02f, 7.27731287e-02f, 1.38916150e-02f, -1.12074077e-01f, 2.49593612e-03f,
  -6.67795464e-02f, 4.96657118e-02f, -6.25775754e-02f, 8.33084062e-03f, 4.41390090e-02f, 7.92966783e-02f, -1.07201198e-02f, -1.39213987e-02f, 4.41980362e-02f, -1.52857658e-02f,
  5.66364862e-02f, -2.85647772e-02f, 2.25691814e-02f, 1.91014335e-02f, -3.21618915e-02f, -2.13357769e-02f, 7.42001310e-02f, -5.12856618e-02f, 3.59422117e-02f, 3.25092934e-02f,
  8.61141235e-02f, -1.14591278e-01f, 1.58292055e-02f, -1.02831803e-01f, -7.77394027e-02f, -9.25903674e-03f, -2.53373869e-02f, -6.22232445e-02f, 5.62628638e-03f, -1.05807945e-01f,
  -5.76246195e-02f, 4.48083729e-02f, -1.15547590e-02f, -5.26970439e-02f, -6.86673746e-02f, -5.74840009e-02f, -1.03272080e-01f, -2.02101581e-02f, -1.17072545e-01f, -2.71874405e-02f,
  -5.66529781e-02f, -1.45470545e-01f, -5.14239296e-02f, -7.36176893e-02f, -1.38995379e-01f, -1.46398932e-01f, -4.85810712e-02f, -9.49797332e-02f, -1.45663783e-01f, -2.00421795e-01f,
  5.34207225e-02f, 7.92215616e-02f, -8.41817930e-02f, 7.80172125e-02f, 1.08646527e-01f, 5.41181006e-02f, 7.78667107e-02f, 2.78302263e-02f, -2.07202770e-02f, 1.29284948e-01f,
  7.50175118e-02f, 5.00687361e-02f, 1.19530015e-01f, 4.72456031e-03f, -2.46436670e-02f, 1.02386579e-01f, -1.98496003e-02f, 1.82329081e-02f, -5.74973710e-02f, 1.04490742e-01f,
  1.63473383e-01f, 2.64896359e-02f, -9.93891954e-02f, -5.42828515e-02f, 1.33510828e-01f, 1.29352659e-01f, -1.59995947e-02f, -2.36127432e-02f, -1.54319555e-01f, 1.63720414e-01f,
  1.77858204e-01f, -1.99544027e-01f, -1.37734145e-01f, 6.10815510e-02f, -1.10270582e-01f, -8.19183215e-02f, -7.28514837e-03f, -1.22670539e-01f, -1.37937486e-01f, -6.64693415e-02f,
  -5.99432364e-02f, -6.95621520e-02f, -5.08863963e-02f, -2.90515553e-02f, -1.37755573e-02f, 5.64550087e-02f, -1.43962547e-01f, -4.88102250e-02f, -1.09043598e-01f, -4.12534550e-02f,
  -3.92028987e-02f, -1.08056806e-01f, -1.26613766e-01f, -6.00089543e-02f, -1.82729691e-01f, -1.10526539e-01f, -2.18705669e-01f, -1.30784661e-01f, -7.18460456e-02f, 9.68981162e-03f,
  -3.85910720e-02f, -1.06228605e-01f, -7.88132399e-02f, 7.38650486e-02f, -7.08337799e-02f, 2.08375938e-02f, 1.76173002e-02f, -9.25784558e-02f, 2.93960627e-02f, -2.92503685e-02f,
  1.72122121e-02f, -1.10726848e-01f, 5.02304174e-02f, 2.00165324e-02f, -1.15326323e-01f, -1.63758889e-01f, -9.38837305e-02f, -6.53409809e-02f, -7.58667365e-02f, -1.29767403e-01f,
  -7.71287456e-02f, -1.92534789e-01f, -1.39340356e-01f, -1.20505087e-01f, -1.68877512e-01f, -1.21923178e-01f, -7.49308020e-02f, 2.92738974e-02f, -8.95969719e-02f, -1.01783417e-01f,
  1.53751522e-01f, -1.50047287e-01f, 1.03753150e-01f, -1.07129164e-01f, -7.87671655e-03f, -8.62548798e-02f, -7.81328185e-04f, -1.83192760e-01f, -9.71409157e-02f, -6.03947341e-02f,
  -5.06616794e-02f, -9.22185602e-04f, -1.24778990e-02f, -1.44330516e-01f, -6.29295483e-02f, -1.16576672e-01f, -5.13698384e-02f, 4.59781662e-02f, -5.59379160e-02f, -1.91018656e-01f,
  -7.44097307e-02f, -1.98962297e-02f, -1.01908147e-01f, -3.53788808e-02f, -1.77828103e-01f, -4.03187908e-02f, -4.33086045e-02f, -5.18781133e-02f, 1.45125948e-03f, 4.79781702e-02f,
  9.76292491e-02f, -3.34345460e-01f, -1.38186470e-01f, 7.49123422e-03f, 4.12550941e-02f, 3.21640521e-02f, 5.11284210e-02f, 2.69782376e-02f, 1.29695237e-01f, -1.64364412e-01f,
  -7.10373670e-02f, 1.14684820e-01f, 3.67286964e-03f, -5.16607389e-02f, 6.46868125e-02f, -1.62430972e-01f, -1.46090910e-01f, 1.93827022e-02f, 2.50759363e-01f, 2.05694944e-01f,
  1.35546371e-01f, 5.69963548e-03f, 2.37855297e-02f, 9.22970921e-02f, -2.18086615e-01f, 1.41395375e-01f, -1.86284050e-01f, -1.04922816e-01f, -1.76058292e-01f, -2.78523684e-01f,
  -5.41209884e-04f, -2.52260417e-01f, 1.09224096e-01f, -6.22418150e-02f, -1.10704660e-01f, -8.15965384e-02f, 3.93437184e-02f, -1.94679186e-01f, -1.12041444e-01f, -8.38504583e-02f,
  -6.94685802e-02f, -1.51695162e-01f, 3.73942554e-02f, -6.65697851e-04f, -9.92788821e-02f, 3.85487564e-02f, -1.59536406e-01f, -3.49074900e-02f, -8.50685909e-02f, -4.58194502e-02f,
  -6.04445785e-02f, -3.93270850e-02f, -2.32726950e-02f, -4.62419912e-02f, -6.26089498e-02f, 3.57368328e-02f, -8.14065263e-02f, -6.44954853e-03f, -5.73294535e-02f, -1.20252103e-01f,
  4.82897162e-02f, -1.48565443e-02f, -4.26003002e-02f, 2.26539858e-02f, 3.03042885e-02f, -7.64762163e-02f, -3.53504568e-02f, 2.32619811e-02f, 4.04836200e-02f, -3.34001742e-02f,
  -3.11590992e-02f, -1.75821818e-02f, -3.18899788e-02f, -6.37794705e-03f, 7.19513418e-03f, -3.19988467e-02f, -5.31016029e-02f, -6.53534904e-02f, -3.16370875e-02f, -1.24896295e-01f,
  -3.23929265e-02f, 4.18344513e-02f, 2.49774940e-02f, -4.82211076e-03f, -8.03911313e-02f, -4.51197103e-02f, -4.80594262e-02f, 5.51796071e-02f, -4.67329398e-02f, -3.90818007e-02f,
  2.42705792e-01f, -6.42915592e-02f, 2.73009613e-02f, 7.61899129e-02f, -3.64864245e-03f, 6.82498142e-02f, -4.37530354e-02f, 5.56118926e-03f, -2.29647476e-02f, 6.43808348e-03f,
  4.08610143e-02f, -1.38105070e-02f, -6.25612289e-02f, -2.37788428e-02f, 1.57162622e-01f, 1.09954588e-02f, 2.04584319e-02f, 8.70859325e-02f, 5.16878664e-02f, 2.10906547e-02f,
  7.88249522e-02f, 4.07008976e-02f, 8.83551538e-02f, 1.85019806e-01f, 1.23845145e-01f, 2.20555380e-01f, 1.34571120e-01f, 1.35693148e-01f, 1.51465818e-01f, 2.26930231e-01f,
  2.98450857e-01f, -3.77256349e-02f, 1.00468695e-01f, 2.31651261e-01f, 1.85797941e-02f, 6.00922620e-04f, 1.35401726e-01f, 3.39798741e-02f, -1.41673144e-02f, -6.16949312e-02f,
  -1.24944337e-01f, -1.76501960e-01f, -1.57118272e-02f, -1.46594495e-01f, 7.98934102e-02f, 1.54521376e-01f, 2.34928116e-01f, 8.42192322e-02f, 1.14905328e-01f, 2.15307809e-02f,
  -1.04370192e-01f, 4.47950587e-02f, 1.23355716e-01f, -9.63917840e-03f, 8.02172571e-02f, -2.79962663e-02f, 7.65886344e-03f, 3.14089060e-02f, -9.29347202e-02f, 1.04035787e-01f,
  1.58805668e-01f, 2.01370999e-01f, -2.98220515e-02f, -4.57764827e-02f, -9.44473147e-02f, -9.06185899e-03f, -5.82314432e-02f, 6.11535795e-02f, 2.13963594e-02f, 3.74070071e-02f,
  -9.15220156e-02f, -3.65910828e-02f, -6.82981685e-02f, 8.79154168e-03f, 8.91221985e-02f, 7.01981504e-03f, 6.21488579e-02f, 5.26985936e-02f, 2.74379142e-02f, -4.76722531e-02f,
  -1.29698649e-01f, -2.25291271e-02f, 1.36068478e-01f, 5.19724935e-02f, -2.48320904e-02f, -1.78448260e-02f, 4.29563299e-02f, -2.70343293e-02f, -1.41200367e-02f, -1.42850149e-02f,
  -4.66887206e-02f, 2.59542670e-02f, -1.48509967e-03f, -6.34030625e-02f, -1.55189214e-03f, -4.81244884e-02f, -6.89003291e-03f, 1.39104098e-03f, -2.75676139e-03f, 3.11277919e-02f,
  -7.42275454e-03f, -4.96803150e-02f, -2.85303406e-02f, -3.26934196e-02f, 4.11868542e-02f, 4.98195812e-02f, 9.58737452e-03f, -4.42855284e-02f, 2.13974398e-02f, -4.37217811e-03f,
  -1.59159936e-02f, -3.03090159e-02f, 2.78003011e-02f, 7.92757515e-03f, -9.78041217e-02f, -4.49579693e-02f, 2.88536418e-02f, -1.14912316e-01f, 7.68371001e-02f, 2.44173016e-02f,
  -3.04718944e-03f, -1.92400292e-01f, 6.36027604e-02f, -6.23016097e-02f, -7.20345369e-03f, -6.58629388e-02f, 2.10928242e-03f, 3.03922873e-02f, -1.04728684e-01f, -8.56158510e-02f,
  -8.20298716e-02f, 5.15052006e-02f, 8.29241425e-03f, -7.78655708e-02f, -3.07152644e-02f, 3.57484967e-02f, -7.93762133e-02f, 6.88188672e-02f, -4.23902124e-02f, -6.80688582e-03f,
  -2.83371080e-02f, 4.78146337e-02f, 1.28928339e-02f, -5.04451171e-02f, -1.55135002e-02f, 5.64881936e-02f, -3.88223864e-02f, -4.28475626e-02f, 3.53363007e-02f, 1.71240084e-02f,
  3.53979766e-02f, -3.75270307e-01f, 1.04227342e-01f, -7.43604302e-02f, -1.83466047e-01f, 1.02278911e-01f, -1.24288276e-01f, 3.85476723e-02f, -1.76593417e-03f, -1.06467135e-01f,
  -1.20637037e-01f, 7.63239041e-02f, -2.55623423e-02f, -1.71437487e-02f, 1.11653298e-01f, -5.33094145e-02f, -1.48301661e-01f, 2.30615392e-01f, 4.06824470e-01f, 2.05027133e-01f,
  -1.26499593e-01f, -2.06334647e-02f, 1.04054727e-01f, -1.50775723e-02f, -1.28771901e-01f, 1.07031375e-01f, -2.11907923e-01f, -1.67386636e-01f, -1.15030415e-01f, -3.41603100e-01f,
  6.69301525e-02f, -1.30959824e-01f, 1.78945780e-01f, 3.25091444e-02f, 1.29140718e-02f, 3.16994898e-02f, 5.61888963e-02f, -3.87618579e-02f, 2.13588066e-02f, 2.88663805e-02f,
  1.76391806e-02f, -2.63914205e-02f, 2.76505444e-02f, 4.25975807e-02f, 2.74844002e-02f, 1.66624933e-01f, 3.06172911e-02f, 1.80046245e-01f, 8.37136060e-02f, 8.88979435e-02f,
  -7.46185333e-02f, -3.09922826e-02f, 7.39764981e-03f, 8.31603333e-02f, 1.21808693e-01f, -1.85475610e-02f, -3.03442590e-02f, 1.53300613e-02f, 1.93086803e-01f, -5.34901321e-02f,
  5.39798290e-02f, 3.88568453e-03f, 8.08192343e-02f, -3.18093151e-02f, -1.18145654e-02f, 5.80646060e-02f, -2.98876259e-02f, -2.50494443e-02f, 4.74079465e-03f, 1.41224042e-01f,
  -2.61761784e-03f, 1.06549025e-01f, 1.08282976e-02f, 1.22504979e-01f, -3.39057744e-02f, 4.32064980e-02f, -4.71520331e-03f, 8.34810063e-02f, 1.18960217e-01f, -5.22055067e-02f,
  3.21755335e-02f, 2.19748933e-02f, 8.49543586e-02f, 8.15940276e-02f, 3.17108519e-02f, -1.51884081e-02f, 6.70017004e-02f, 4.68448661e-02f, 1.19544737e-01f, -2.62790676e-02f,
  1.19078290e-02f, 1.12342156e-01f, 4.63301614e-02f, 2.70463396e-02f, 9.57456306e-02f, 1.17032724e-02f, -9.73343253e-02f, -2.64359899e-02f, -6.65881634e-02f, -2.47183926e-02f,
  -4.42731082e-02f, 4.49315347e-02f, -2.68344712e-02f, -5.19382022e-03f, 3.51303257e-02f, 3.98658626e-02f, -3.86877209e-02f, 3.84388603e-02f, -4.98206588e-04f, -6.33577779e-02f,
  -7.86285847e-02f, 5.42205647e-02f, -1.93299837e-02f, -6.20878227e-02f, -3.09972912e-02f, 1.06832765e-01f, 9.99240391e-03f, 7.67417476e-02f, 2.21866429e-01f, 1.09552003e-01f,
  5.99009454e-01f, -1.39718547e-01f, -5.70428744e-02f, 1.57522142e-01f, -2.38708884e-01f, -1.97604656e-01f, -2.50919342e-01f, -9.40530933e-03f, 1.96726963e-01f, -1.10760756e-01f,
  -2.79157996e-01f, 1.40557543e-03f, -7.48157129e-02f, -1.12224691e-01f, -4.64394502e-02f, -6.71994761e-02f, -1.30519450e-01f, 8.80732536e-02f, 2.11455956e-01f, -3.14921364e-02f,
  1.45775126e-02f, 2.09185854e-01f, 2.48516962e-01f, 1.48907557e-01f, 1.09044261e-01f, 6.91915378e-02f, -6.93399310e-02f, -1.37393996e-01f, -2.43537128e-01f, 4.91451770e-02f,
  2.94782389e-02f, 1.85700059e-02f, 3.34283896e-02f, -2.20120903e-02f, -9.65842456e-02f, 9.31664482e-02f, 2.88833175e-02f, 8.90115574e-02f, -6.78662583e-02f, -1.34355240e-02f,
  -1.44943938e-01f, -9.00797844e-02f, -1.21194936e-01f, 4.64364095e-03f, -1.16783399e-02f, 9.11216885e-02f, -1.39629534e-02f, 8.90816897e-02f, -5.25324494e-02f, -5.08774891e-02f,
  -1.58360571e-01f, -5.62432930e-02f, 4.81708385e-02f, -2.86719203e-02f, -1.13123812e-01f, 6.86101168e-02f, -2.82132328e-02f, 6.47295862e-02f, 6.22875281e-02f, 2.06928149e-01f,
  -4.03835215e-02f, 1.15395691e-02f, -6.29794747e-02f, 6.81674331e-02f, 1.21991280e-02f, -1.41320601e-01f, 7.03448653e-02f, -1.36371339e-02f, 5.46414442e-02f, -2.35894602e-02f,
  1.55460406e-02f, 2.93705030e-03f, -4.14248593e-02f, 5.39355800e-02f, -1.97385084e-02f, -4.13105674e-02f, -6.28827587e-02f, 1.70779210e-02f, -5.17683439e-02f, -5.55391833e-02f,
  -6.14427170e-03f, -8.08153749e-02f, -5.68480194e-02f, -5.18711768e-02f, -1.55087700e-02f, 1.03782766e-01f, 2.83374935e-02f, 1.57927535e-02f, 4.53251749e-02f, 5.95134720e-02f,
  5.15027009e-02f, -3.39391202e-01f, 4.52521592e-02f, 4.11051838e-03f, -4.27177781e-03f, -2.75807511e-02f, -5.77400289e-02f, 4.48564030e-02f, -6.44193441e-02f, 3.42272036e-02f,
  2.12154388e-02f, 9.08495858e-02f, -1.11176409e-01f, -1.30894706e-02f, -8.33739247e-03f, 5.35556376e-02f, -2.53861677e-02f, 4.95484844e-02f, -3.98955122e-02f, -5.26637435e-02f,
  2.54549421e-02f, 6.04125783e-02f, 9.16793644e-02f, 8.02195165e-03f, 2.75013670e-02f, 1.51126534e-01f, -2.32482050e-02f, 1.15126677e-01f, 1.18404903e-01f, 2.90629566e-01f,
  2.08728537e-01f, 2.77792215e-02f, 1.23891488e-01f, 1.97295204e-01f, 1.58104777e-01f, 2.09326297e-01f, 2.73817450e-01f, 2.16929406e-01f, 9.57665965e-02f, 3.95671949e-02f,
  -8.26260448e-02f, -1.21988170e-01f, -7.72766992e-02f, -1.85409449e-02f, 1.34415194e-01f, 2.25471675e-01f, 1.44209564e-01f, 7.36447871e-02f, 2.19845995e-02f, 1.16772823e-01f,
  6.45437166e-02f, 1.10717118e-01f, 2.13474557e-02f, 4.32211272e-02f, 1.15833653e-03f, -1.89236812e-02f, -6.76339120e-03f, -1.52759170e-02f, -6.61791023e-03f, 5.60746565e-02f,
  -9.03552026e-02f, 1.32224515e-01f, -4.46968935e-02f, -7.60220140e-02f, -2.05082297e-02f, 1.15222581e-01f, 2.86687966e-02f, -5.70496321e-02f, -9.02376398e-02f, 1.07664004e-01f,
  3.45162451e-02f, -1.39573440e-02f, 5.41487560e-02f, 7.25308247e-03f, 5.71786799e-02f, 5.46196625e-02f, -8.12497642e-03f, 1.06215671e-01f, 1.13491148e-01f, 1.79882329e-02f,
  4.64739418e-03f, 9.54002608e-03f, 2.09702983e-01f, 5.25286831e-02f, 4.96284217e-02f, 5.42045981e-02f, 1.01841733e-01f, 1.01289183e-01f, 1.32334009e-01f, 5.85361496e-02f,
  -9.30062030e-03f, -1.09418750e-01f, -1.03115618e-01f, -1.33959681e-01f, -1.56248644e-01f, -8.91802832e-02f, -1.13010086e-01f, -1.16554879e-01f, -3.37100998e-02f, -1.80001765e-01f,
  -1.16157241e-01f, -7.34203458e-02f, -7.04517663e-02f, -3.28846872e-02f, -1.62820607e-01f, -6.34219423e-02f, -9.85567644e-02f, -1.23553671e-01f, -6.22764640e-02f, -1.56606421e-01f,
  -1.27761036e-01f, -4.34836671e-02f, -1.45761296e-01f, -1.07367039e-01f, -9.91983935e-02f, -1.92857265e-01f, -6.15332089e-02f, -1.81853995e-01f, -5.88922249e-03f, 8.54509417e-03f,
  -7.42009878e-02f, -1.05132433e-02f, 1.93062145e-02f, 7.04970062e-02f, 3.42641249e-02f, -1.62740890e-02f, -1.41358767e-02f, -4.26862203e-02f, -6.78143417e-03f, -1.13739604e-02f,
  5.95264062e-02f, -6.39503226e-02f, 1.08595014e-01f, -1.25094457e-02f, 5.16707785e-02f, 7.92497769e-02f, 4.55857068e-02f, -2.42974702e-03f, 4.82657067e-02f, -8.65716860e-02f,
  8.31136405e-02f, -7.15424120e-03f, -5.61432075e-03f, 1.37580857e-02f, -1.76371299e-02f, -1.46396952e-02f, 2.80386545e-02f, 1.16330953e-02f, 1.54928401e-01f, 6.55680001e-02f,
  3.83265823e-01f, 2.74146557e-01f, -3.40776682e-01f, 2.68771768e-01f, 1.26144201e-01f, 5.20537328e-03f, 1.70303077e-01f, 1.30543634e-01f, 2.12294161e-01f, 1.24256045e-01f,
  7.15348870e-03f, 1.79482214e-02f, -7.23567158e-02f, -1.22880250e-01f, 5.76109812e-02f, 1.16543204e-01f, 1.14800625e-01f, -9.25048962e-02f, -1.13696493e-01f, -1.24718241e-01f,
  1.97375175e-02f, 2.59698242e-01f, 1.23539180e-01f, 6.95266575e-02f, 1.24528974e-01f, 7.80907087e-03f, 8.23401958e-02f, 1.04821600e-01f, -9.42404270e-02f, -2.99789365e-02f,
  -3.34718198e-01f, 4.38625924e-02f, 1.15508735e-01f, 1.81089386e-01f, -9.96188354e-03f, 1.56191558e-01f, 1.63831990e-02f, 8.66103098e-02f, 1.43161789e-01f, 1.14684172e-01f,
  6.87331930e-02f, 8.16921890e-02f, 1.61456913e-01f, 9.47842598e-02f, 4.73610312e-02f, 6.06078543e-02f, 8.93864259e-02f, 1.09978043e-01f, 1.73683688e-01f, -4.22718637e-02f,
  1.74653918e-01f, 8.75017941e-02f, 9.81760696e-02f, 9.99054909e-02f, 7.70589337e-02f, 6.65376801e-03f, 4.01682779e-02f, -1.00828577e-02f, 8.18628643e-04f, 1.94834366e-01f,
  3.30055989e-02f, -1.19114354e-01f, -6.26878589e-02f, 3.23049724e-02f, -4.08502147e-02f, -3.88624072e-02f, -8.37809667e-02f, -1.20955266e-01f, -3.78670692e-02f, 7.08258003e-02f,
  1.81764793e-02f, -2.44364887e-02f, -4.64202352e-02f, 1.96929425e-02f, -1.10490965e-02f, -5.73758036e-02f, -8.66361037e-02f, 1.72710163e-04f, -1.05461039e-01f, -5.08351112e-03f,
  -4.03709263e-02f, -1.19178355e-01f, -8.74252990e-02f, -6.27342910e-02f, -6.20131902e-02f, -1.17311761e-01f, -5.33564240e-02f, -6.67896494e-02f, -5.58180660e-02f, 1.29595529e-02f,
  3.13333154e-01f, 1.99502304e-01f, 9.78062898e-02f, 2.26450846e-01f, 1.43330544e-01f, 7.10045174e-02f, 1.43022746e-01f, 1.12907611e-01f, 1.01765990e-01f, 7.96264187e-02f,
  2.00622566e-02f, 1.67098626e-01f, 1.02979325e-01f, 2.66179796e-02f, 1.92708567e-01f, 2.91803088e-02f, 2.01525062e-01f, 1.23284757e-01f, 1.09463058e-01f, 1.02224424e-01f,
  2.12053135e-01f, 1.94742486e-01f, 3.28312740e-02f, 6.78548217e-02f, 1.12216711e-01f, 1.71089947e-01f, 9.95606482e-02f, 6.44318610e-02f, 1.68934137e-01f, 3.27808022e-01f,
  -1.36623047e-02f, 2.34994143e-01f, 1.67482540e-01f, -1.57513812e-01f, -1.16108563e-02f, 1.28393188e-01f, 2.43367434e-01f, 8.83030370e-02f, -9.85718295e-02f, 2.30964907e-02f,
  -3.19951400e-02f, -1.09742388e-01f, -8.47936124e-02f, -3.04197706e-02f, 9.96911153e-02f, 1.98165089e-01f, 9.28784683e-02f, -3.77675705e-02f, 1.08816892e-01f, 1.90040525e-02f,
  -1.08578354e-01f, -6.53191656e-02f, -3.76712605e-02f, 7.01022223e-02f, -1.82698667e-01f, -8.66987035e-02f, 6.07594699e-02f, -2.40917131e-02f, 9.16035026e-02f, -2.32669875e-01f,
  -1.14653870e-01f, 8.58898461e-02f, -2.41033044e-02f, -1.97752770e-02f, 7.48046041e-02f, -1.03819463e-02f, -7.06748478e-03f, 4.42598760e-02f, 4.48462926e-02f, -4.89684269e-02f,
  2.71208212e-03f, 5.81836365e-02f, -9.97298583e-02f, -9.35650542e-02f, 9.72865373e-02f, -1.05384849e-02f, 2.87093557e-02f, 8.94953310e-02f, 1.04109347e-01f, -2.67462563e-02f,
  -1.31926209e-01f, 1.00715337e-02f, -1.06767602e-02f, 2.85059046e-02f, 4.24217246e-02f, 7.55303204e-02f, 9.44361910e-02f, -8.99875164e-02f, 7.12283775e-02f, -1.37493610e-02f,
  -4.95146178e-02f, 6.75460673e-04f, -5.86991571e-02f, 3.15813608e-02f, -5.26099913e-02f, 1.79845411e-02f, -3.05613950e-02f, 3.54726352e-02f, -5.13447113e-02f, 1.89841092e-02f,
  1.50766829e-02f, -3.58195081e-02f, -1.36480153e-01f, -7.79294968e-02f, 3.04572750e-02f, -9.42053925e-03f, 2.83669475e-02f, -3.43780853e-02f, -8.08086544e-02f, 1.48503352e-02f,
  -7.22376034e-02f, -7.93747827e-02f, -3.73659991e-02f, -8.25097412e-02f, 4.17622142e-02f, -2.23932303e-02f, -1.08895972e-02f, 6.60500210e-03f, -1.38947487e-01f, -4.67688292e-02f,
  7.07705617e-02f, 2.84418792e-01f, -1.12592228e-01f, -1.19654313e-02f, 3.58804055e-02f, -1.36737553e-02f, 8.94020051e-02f, 8.58242661e-02f, 8.31916928e-03f, 3.40014175e-02f,
  3.82425375e-02f, -4.40512337e-02f, -1.43817645e-02f, 1.30293980e-01f, 1.44859385e-02f, 1.45441676e-02f, 6.72117025e-02f, 3.09089571e-02f, 1.34431869e-02f, -2.54967976e-02f,
  2.86567933e-03f, 6.80291951e-02f, -3.72466892e-02f, 1.22565627e-01f, -4.79805395e-02f, -4.28171344e-02f, 1.35365069e-01f, 5.50958291e-02f, 2.02152252e-01f, 1.40135080e-01f,
  -8.17665644e-03f, 1.10085979e-01f, 6.96744118e-03f, 5.76547682e-02f, 4.24335487e-02f, 1.69599593e-01f, 2.64562279e-01f, 1.13073207e-01f, 1.38711229e-01f, 7.68761635e-02f,
  -9.81964990e-02f, 9.21470206e-03f, -4.52867523e-02f, -6.55663535e-02f, 4.78455722e-02f, 1.98657721e-01f, 2.50081956e-01f, 1.56109527e-01f, -5.16609997e-02f, -3.07764616e-02f,
  7.11430907e-02f, -5.12658097e-02f, 5.46329506e-02f, 1.30428061e-01f, 2.28959396e-01f, 1.06369376e-01f, 1.31431609e-01f, 8.21956471e-02f, 8.62929299e-02f, 3.78116041e-01f,
  1.50265828e-01f, -1.29608303e-01f, 5.66643514e-02f, 2.42377929e-02f, -2.24212352e-02f, 7.57504180e-02f, 5.09523414e-02f, 2.11584810e-02f, 7.41210505e-02f, 3.62589955e-02f,
  -8.47220719e-02f, -1.12825446e-02f, -4.60512005e-02f, 1.10907465e-01f, 5.03219143e-02f, -3.15874666e-02f, -3.72684598e-02f, 1.00223750e-01f, 3.09721213e-02f, 2.32390612e-02f,
  -1.40852714e-02f, 3.25407716e-03f, 5.15816659e-02f, 5.69857024e-02f, 1.07905924e-01f, 2.09548902e-02f, -1.98019035e-02f, 1.38681307e-01f, -5.09597594e-03f, 2.28962198e-01f,
  8.11572820e-02f, -9.75499302e-02f, -9.74980146e-02f, -6.16419762e-02f, 4.03772742e-02f, 5.07205836e-02f, -3.39433365e-02f, -5.04364073e-02f, -6.44768178e-02f, -3.14032398e-02f,
  -6.27761483e-02f, -2.01006024e-03f, -3.74783650e-02f, -1.14478050e-02f, -2.57175490e-02f, -6.70591816e-02f, 2.55696755e-02f, 1.76370181e-02f, -3.65622304e-02f, 1.49146281e-02f,
  -5.26364408e-02f, -1.22870421e-02f, 5.53182419e-03f, 1.96217839e-02f, -4.99505512e-02f, -1.60733715e-01f, 1.41565604e-02f, -1.24395870e-01f, -1.85496733e-02f, -2.53477283e-02f,
  1.38863459e-01f, -2.85474807e-01f, 2.78237194e-01f, 4.51432317e-02f, 1.17119350e-01f, 9.78909880e-02f, -6.80974592e-03f, 9.98813193e-03f, -4.60601076e-02f, 1.45319983e-01f,
  2.63818353e-02f, -4.13801819e-02f, 5.99711798e-02f, 9.62208584e-02f, 3.94319594e-02f, 2.31736749e-02f, -3.16651538e-02f, 1.62581392e-02f, 1.40379474e-01f, 8.04784521e-02f,
  1.53374583e-01f, 8.44871178e-02f, 4.31049168e-02f, 1.98213533e-01f, 7.05647394e-02f, 1.10748872e-01f, 1.52481511e-01f, 2.20922679e-01f, 4.10366356e-02f, 3.43824238e-01f,
  -3.85957241e-01f, 1.32486433e-01f, 3.62304114e-02f, -2.54144073e-01f, 7.64077976e-02f, 1.84800640e-01f, 2.52256930e-01f, -3.12142447e-02f, -9.78718027e-02f, -4.84030172e-02f,
  4.20673676e-02f, 4.02921215e-02f, -7.24414736e-02f, 1.17666334e-01f, 5.35090417e-02f, 1.53619766e-01f, -1.33969402e-02f, -2.86295777e-03f, 8.25585648e-02f, 1.99426174e-01f,
  5.84454313e-02f, -1.68760359e-01f, -1.05328090e-01f, 6.23430759e-02f, -1.27501398e-01f, 4.31218445e-02f, 3.27207260e-02f, -1.98010355e-02f, 2.36502767e-01f, -1.49797127e-01f,
  1.00883685e-01f, 6.15609959e-02f, 6.63340613e-02f, 5.48242368e-02f, 5.41494898e-02f, -1.15385065e-02f, 2.77550966e-02f, 3.16187553e-02f, -1.97146200e-02f, 3.00885309e-02f,
  2.40599457e-02f, 1.00833498e-01f, 6.94170222e-02f, 1.23501629e-01f, 1.20840007e-02f, 8.00783187e-02f, -3.18366028e-02f, 2.20937151e-02f, 3.82690504e-02f, 6.72858953e-02f,
  5.02857827e-02f, 8.63483548e-02f, 7.92469010e-02f, 7.99465850e-02f, 1.58563435e-01f, 1.20173603e-01f, 1.13789357e-01f, 1.51101619e-01f, 1.74257338e-01f, -7.05313087e-02f,
  -3.18860332e-03f, -1.01554848e-01f, -1.22617800e-02f, 2.94513348e-03f, -9.16683823e-02f, -5.97572364e-02f, -3.29727829e-02f, -7.07544610e-02f, 2.29124557e-02f, -1.29901811e-01f,
  2.34399531e-02f, 4.98732328e-02f, -8.96542668e-02f, -1.44389585e-01f, -1.10955425e-02f, -9.16742161e-02f, -5.67724481e-02f, -4.56639193e-02f, -8.77012238e-02f, -1.26167148e-01f,
  -3.07886824e-02f, -7.10919127e-02f, -1.45108730e-01f, -9.62274596e-02f, -8.50397646e-02f, -4.13003489e-02f, -5.87627105e-02f, 7.01912073e-03f, -8.70529860e-02f, 3.22618918e-03f,
  -1.80582449e-01f, 2.07954660e-01f, -8.50973055e-02f, 2.92558242e-02f, 3.94090936e-02f, 8.65596607e-02f, 2.80128355e-04f, 2.08955463e-02f, 5.62616251e-02f, 8.92790630e-02f,
  1.21967606e-01f, 2.49282084e-02f, 6.52053356e-02f, -6.23558946e-02f, 6.44772574e-02f, 5.13113774e-02f, -5.16974032e-02f, -3.65272947e-02f, 1.17932208e-01f, 6.21052012e-02f,
  -1.84297673e-02f, -7.92623982e-02f, -7.51569271e-02f, -1.04267271e-02f, 1.04075372e-01f, -6.06434345e-02f, -1.59025770e-02f, -2.67387517e-02f, 2.09512492e-03f, -2.09974006e-01f,
  3.39495810e-03f, 2.94451043e-02f, 2.34946027e-01f, -1.03343902e-02f, -2.60044113e-02f, -1.24506630e-01f, -3.80928069e-03f, -4.32356782e-02f, 8.18635803e-03f, 1.59197241e-01f,
  9.18598566e-03f, -6.13512471e-02f, -4.86036390e-02f, -5.60336486e-02f, 3.78271863e-02f, 1.87552437e-01f, 2.60203928e-01f, 1.54652894e-01f, -9.77323130e-02f, -5.76326661e-02f,
  -1.02983192e-01f, -7.92747065e-02f, -1.57098323e-01f, -3.84690017e-02f, 1.19902089e-01f, -2.15139445e-02f, 1.67662397e-01f, 2.58698259e-02f, 6.72026202e-02f, 3.97769094e-01f,
  2.70789295e-01f, 4.10033874e-02f, 1.06128760e-01f, -8.03230479e-02f, -4.64870706e-02f, -8.63966867e-02f, -6.13800697e-02f, -6.08162358e-02f, -6.16734140e-02f, 3.33175361e-02f,
  5.21355383e-02f, -7.17762709e-02f, -3.35363369e-03f, 1.53685613e-02f, -7.10937828e-02f, 5.93356714e-02f, -2.63971779e-02f, 1.02493040e-01f, 9.68163535e-02f, 1.75264746e-01f,
  8.04948881e-02f, 4.72668484e-02f, -7.57046714e-02f, -2.92612500e-02f, 9.60707664e-02f, -6.71823695e-03f, 7.56056085e-02f, -3.26164514e-02f, 4.65667136e-02f, 2.56928831e-01f,
  8.24398026e-02f, 1.26186628e-02f, 3.87056470e-02f, 4.10641804e-02f, -3.42248753e-02f, -6.76074112e-03f, 1.33476881e-02f, 7.91206062e-02f, -3.42111401e-02f, 6.40599877e-02f,
  -3.43941711e-02f, -6.74162409e-04f, 6.56328350e-02f, 1.97593495e-02f, 1.12595424e-01f, 8.74037743e-02f, -5.05667329e-02f, 7.29906335e-02f, -2.26370171e-02f, 2.05010027e-02f,
  2.75291260e-02f, 8.97380412e-02f, 2.15648189e-02f, 6.33310750e-02f, 6.05017208e-02f, 8.10434371e-02f, 3.12050041e-02f, 8.17701744e-04f, -9.40497220e-02f, -7.67547339e-02f,
  -1.63641438e-01f, -9.24977437e-02f, 2.16140658e-01f, -1.77846458e-02f, 4.47578281e-02f, -1.54545752e-03f, 8.87711346e-02f, -6.18731715e-02f, -8.09897259e-02f, 5.45218438e-02f,
  1.91245656e-02f, 1.54787421e-01f, 3.27523164e-02f, 1.24658057e-02f, -4.17129435e-02f, -1.30219301e-02f, 2.67775748e-02f, 6.67948574e-02f, 2.60157771e-02f, 1.90926269e-02f,
  1.89490877e-02f, -6.69139922e-02f, -6.06606081e-02f, 9.31696892e-02f, 1.86645368e-04f, 1.02706049e-02f, 7.04405606e-02f, 1.79052856e-02f, -1.28797770e-01f, -1.87077634e-02f,
  3.22874263e-02f, 2.51945078e-01f, 6.68354183e-02f, -1.01877274e-02f, 2.78026104e-01f, 3.77092361e-01f, 3.82385820e-01f, 2.79046923e-01f, 1.51101261e-01f, 1.58797309e-01f,
  2.07455188e-01f, -1.68399751e-01f, -1.67829916e-01f, -1.03705458e-01f, -6.07693195e-02f, 2.60904729e-02f, 1.19394958e-01f, -1.91188216e-01f, -1.10431544e-01f, 1.33460656e-01f,
  4.40455154e-02f, 2.79761292e-02f, -2.50679497e-02f, -6.99979365e-02f, -3.32177505e-02f, -1.27591997e-01f, 7.18423352e-02f, 4.35861200e-02f, 1.14591002e-01f, -8.59661177e-02f,
  -3.31801891e-01f, 2.41035491e-01f, 1.10164002e-01f, -2.26533469e-02f, 3.88339385e-02f, -4.12008464e-02f, 2.10698489e-02f, 4.99831773e-02f, 1.04258671e-01f, 4.52606492e-02f,
  -5.45162894e-02f, 2.81603243e-02f, -7.26798326e-02f, -3.31482068e-02f, 8.58804807e-02f, -1.87655166e-02f, 2.73917569e-03f, -8.54562894e-02f, 2.35001724e-02f, 6.26274645e-02f,
  -1.85881611e-02f, 1.70621321e-01f, 1.51555806e-01f, 1.01573601e-01f, 7.00331703e-02f, -9.56496671e-02f, 3.28112617e-02f, 1.11075044e-01f, 8.29713345e-02f, 9.61580575e-02f,
  4.68937494e-03f, 9.35601816e-03f, 1.20432906e-01f, 6.09570229e-03f, 1.55524060e-01f, 3.42574157e-02f, -3.53597775e-02f, 6.80576712e-02f, -2.17838660e-02f, 1.63441524e-02f,
  -4.10120599e-02f, -2.62592640e-02f, -3.28404233e-02f, 1.59238577e-02f, 6.27634749e-02f, 5.05547691e-03f, -9.03348438e-03f, -5.95164346e-03f, -5.61811477e-02f, 7.78732225e-02f,
  -1.03466541e-01f, 4.22925502e-02f, 2.32393797e-02f, -8.55473801e-02f, -7.50014372e-03f, -8.93339515e-02f, -9.14826915e-02f, -3.16464491e-02f, 1.45890480e-02f, 3.29306982e-02f,
  -1.90294027e-01f, 9.48488787e-02f, -4.30630557e-02f, -2.30351016e-02f, 2.86530685e-02f, 1.35273905e-02f, -5.87994978e-03f, 6.51360825e-02f, 1.93156358e-02f, 6.43120781e-02f,
  1.32642016e-01f, 6.26025647e-02f, -3.17731388e-02f, -7.45462021e-03f, 7.89076462e-02f, 9.99951139e-02f, 2.17255838e-02f, -4.43540933e-03f, 1.34508656e-02f, 3.20640281e-02f,
  6.36603385e-02f, 1.70837298e-01f, 5.23083135e-02f, 1.19803227e-01f, 9.89566147e-02f, -2.58845068e-03f, 1.15778662e-01f, 2.39780713e-02f, 5.68230748e-02f, 1.98731512e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  5.31422079e-01f, 3.90243791e-02f, -6.74362421e-01f, 1.29408404e-01f, -3.07078063e-01f, -3.65759850e-01f, -3.39830577e-01f, 1.87821403e-01f, 2.94640809e-01f, -1.01432011e-01f,
  -3.20870057e-03f, 1.51255280e-01f, -4.07725796e-02f, -9.45486352e-02f, -9.77464542e-02f, -2.93556213e-01f, -3.83924216e-01f, -2.40032390e-01f, 5.89607097e-02f, 3.32517773e-02f,
  7.96873793e-02f, 1.89769447e-01f, 7.23800957e-02f, 1.46888241e-01f, 2.17149742e-02f, 3.82722393e-02f, -1.27986535e-01f, -1.59944162e-01f, -2.25297958e-01f, -2.18111560e-01f,
  -4.62236851e-01f, -1.54851511e-01f, -1.84684232e-01f, 1.87337562e-01f, -8.74406192e-03f, 3.27414013e-02f, -4.92077768e-02f, 6.01481944e-02f, 1.19189415e-02f, 1.09437227e-01f,
  3.50202508e-02f, 1.08948037e-01f, -1.99300959e-03f, -2.11002100e-02f, 8.29851106e-02f, 4.14818898e-02f, 5.72370403e-02f, -1.77488744e-01f, -9.64676216e-02f, 4.52116132e-02f,
  -7.89673999e-03f, -1.14959598e-01f, -1.93540409e-01f, -9.43167135e-02f, -1.73761562e-01f, -9.37862694e-02f, -1.23264015e-01f, -1.01274811e-01f, -2.49093279e-01f, -9.29077119e-02f,
  -6.22717142e-02f, -1.10265911e-01f, 9.78294611e-02f, 1.09572314e-01f, 2.16375574e-01f, 1.45496950e-01f, 1.69216376e-02f, -4.02807705e-02f, 7.62629882e-02f, 4.10258994e-02f,
  -8.48814696e-02f, -3.32819223e-02f, -3.80751006e-02f, -9.23135951e-02f, -2.97318362e-02f, -3.45993675e-02f, -1.16095044e-01f, 2.09734142e-02f, 1.98368225e-02f, 1.10700749e-01f,
  8.96942765e-02f, -2.09181216e-02f, 3.04853022e-02f, 1.48447067e-01f, -7.23511726e-02f, -6.07884005e-02f, -8.52689967e-02f, 4.73243222e-02f, 5.76297082e-02f, -7.72345439e-02f,
  2.97725290e-01f, -3.01169306e-01f, 6.84441701e-02f, 4.70785871e-02f, 3.10452841e-02f, 2.00295472e-03f, 1.07325673e-01f, 6.05368018e-02f, 1.98980048e-01f, 1.95214331e-01f,
  -3.30005251e-02f, 6.98140040e-02f, -4.21972834e-02f, -8.81933570e-02f, 9.15940478e-03f, -2.72557400e-02f, 1.51139081e-01f, -5.35285175e-02f, -6.40827268e-02f, 6.97461218e-02f,
  2.15586293e-02f, 1.54230684e-01f, 4.79036979e-02f, 1.29224248e-02f, -3.57627450e-03f, 3.90655547e-02f, -9.83395512e-05f, -6.40881211e-02f, -1.11645915e-01f, 1.90659046e-01f,
  -5.18088460e-01f, 3.32963802e-02f, -5.12745418e-02f, -1.06857389e-01f, -1.33139178e-01f, -1.90087810e-01f, -2.12013304e-01f, -1.74079508e-01f, -1.27787128e-01f, 2.41083894e-02f,
  -1.46700740e-02f, 2.15029959e-02f, 6.77998289e-02f, -1.96548834e-01f, -3.16901386e-01f, -2.47427359e-01f, -2.07864359e-01f, -3.10157090e-01f, -4.44717944e-01f, -3.72286618e-01f,
  -2.46102527e-01f, -2.50976443e-01f, -3.51779878e-01f, -2.72377163e-01f, 1.61136955e-01f, -2.36118007e-02f, 8.93689767e-02f, -1.08305886e-01f, -1.32590815e-01f, 3.19673494e-02f,
  1.58786789e-01f, 3.09485234e-02f, 4.77349386e-02f, 3.33041325e-03f, 4.06208932e-02f, 9.51514672e-03f, 2.61382833e-02f, -4.41116430e-02f, 9.18352157e-02f, 1.07884228e-01f,
  -7.38127381e-02f, -5.17824069e-02f, -5.03105335e-02f, 1.05906129e-01f, 1.19782224e-01f, 2.73300540e-02f, 4.04248163e-02f, 1.00592099e-01f, 5.53845242e-02f, 6.61560968e-02f,
  6.95591196e-02f, -6.50868714e-02f, 1.44135848e-01f, 2.30089545e-01f, 7.64909433e-03f, 9.55150947e-02f, 9.82092842e-02f, 1.85169384e-01f, 1.92892969e-01f, 3.10172319e-01f,
  -1.55529082e-01f, -5.67253008e-02f, 3.32446918e-02f, 1.13139302e-01f, 1.05633557e-01f, 1.27816156e-01f, 1.71750840e-02f, 1.00892279e-02f, 3.36833484e-02f, 8.23402107e-02f,
  1.98115304e-01f, 5.65136634e-02f, 5.08117676e-02f, 9.66979861e-02f, 8.92778113e-02f, 8.52982886e-03f, -6.08737245e-02f, 1.01769149e-01f, 1.30617484e-01f, 3.92269380e-02f,
  1.17377028e-01f, 9.72113200e-03f, -2.14899201e-02f, 3.30778137e-02f, 6.27874956e-02f, -3.35291103e-02f, -4.20755409e-02f, 3.12920585e-02f, -4.98810709e-02f, -1.09352224e-01f,
  3.09495717e-01f, -2.07757607e-01f, 1.08342201e-01f, -1.23376846e-02f, -1.47479903e-02f, 6.57506883e-02f, -1.07761640e-02f, 3.64839137e-02f, 5.34091555e-02f, 1.50376245e-01f,
  -8.86059999e-02f, -7.70407990e-02f, 8.03588256e-02f, 5.93105741e-02f, -3.93983945e-02f, 4.73468266e-02f, 6.50742799e-02f, 4.09678854e-02f, 4.07052077e-02f, 8.45042989e-02f,
  -5.54401018e-02f, -6.98757321e-02f, 1.22103147e-01f, 1.11226961e-01f, 1.26582459e-01f, -1.17985964e-01f, 1.53531268e-01f, 1.48561761e-01f, -9.46551096e-03f, 9.86737534e-02f,
  -4.79223579e-01f, 1.92411423e-01f, -1.56418040e-01f, -1.99462231e-02f, 2.25685276e-02f, -3.10422391e-01f, -7.25350454e-02f, -7.01312646e-02f, -1.00754626e-01f, 7.07460865e-02f,
  1.71887681e-01f, -6.88541532e-02f, -5.56897931e-02f, -7.37179592e-02f, -2.71687567e-01f, -1.71199262e-01f, -1.20048791e-01f, -4.13473338e-01f, -5.87789893e-01f, -2.73095578e-01f,
  -1.25335112e-01f, -3.24751735e-01f, -3.94749939e-01f, -2.29815319e-01f, 2.19254553e-01f, -1.71170682e-02f, 1.55673297e-02f, -1.40440211e-01f, -1.54454410e-01f, 1.41378313e-01f,
  7.54004810e-04f, -1.52663559e-01f, 2.92115360e-02f, -8.83683264e-02f, 1.03802225e-02f, -1.17253475e-01f, -3.00593786e-02f, 4.60265167e-02f, 3.60397100e-02f, -2.15901099e-02f,
  -8.19223523e-02f, 6.47227019e-02f, -6.88246191e-02f, 1.79661494e-02f, 2.77206227e-02f, -8.79487619e-02f, 1.03446320e-01f, 5.03634587e-02f, -2.89086327e-02f, 1.12988703e-01f,
  1.20017655e-01f, -7.49823675e-02f, -3.98877747e-02f, 2.84242220e-02f, -8.16991925e-02f, -1.41774073e-01f, 1.92375794e-01f, 7.35613257e-02f, 1.17229847e-02f, 2.68891066e-01f,
  -1.08092077e-01f, 3.74485590e-02f, 2.65757348e-02f, 6.12593181e-02f, -4.18303795e-02f, 1.81098673e-02f, 2.40819287e-02f, 1.00494869e-01f, -1.57123730e-01f, 2.50108987e-02f,
  1.69446483e-01f, 4.73963581e-02f, -1.48225814e-01f, -1.15338499e-02f, -5.61253279e-02f, 3.29004824e-02f, -5.12352288e-02f, -1.52929937e-02f, 8.65868255e-02f, 2.09280495e-02f,
  -3.19194533e-02f, 2.87070572e-02f, 9.79354009e-02f, -3.70814577e-02f, 7.20058680e-02f, 1.34362448e-02f, -4.70142066e-02f, -1.20628662e-01f, -3.05629447e-02f, -6.59786761e-02f,
  1.85720712e-01f, -3.04817379e-01f, 3.71479578e-02f, 1.01221509e-01f, -2.73661083e-03f, -1.46267517e-03f, 3.37890424e-02f, 1.05659977e-01f, 8.98859799e-02f, 3.43366526e-02f,
  -1.50073782e-01f, -5.07970899e-02f, 2.69670151e-02f, 1.49920657e-01f, -6.28551915e-02f, -1.09591864e-01f, 1.05246328e-01f, 2.52032615e-02f, -2.94042397e-02f, 1.91663533e-01f,
  1.74517199e-01f, 4.60767746e-02f, 6.35236129e-02f, 2.12976962e-01f, -7.87934009e-03f, -8.25490355e-02f, 1.41903430e-01f, 5.69247082e-02f, -1.08579300e-01f, 1.44141838e-01f,
  -5.65583169e-01f, -1.08326823e-01f, 1.04480967e-01f, -2.36218363e-01f, -1.52095966e-02f, -1.46497145e-01f, -3.22465668e-04f, -2.55996287e-01f, -2.15183735e-01f, -1.07458699e-03f,
  3.17459591e-02f, 1.27726451e-01f, 2.00298652e-01f, 8.32359791e-02f, -1.25458449e-01f, -1.05050325e-01f, -9.96486843e-02f, -1.64168477e-01f, -8.31187367e-02f, 4.29911949e-02f,
  3.06371227e-02f, -1.35674858e-02f, -1.68800548e-01f, -1.39821380e-01f, 1.78440452e-01f, 1.07484460e-01f, 1.59997225e-01f, 2.85158474e-02f, 1.57675520e-01f, 1.54242128e-01f,
  4.22970206e-01f, -1.38759032e-01f, -1.45875871e-01f, -1.75353229e-01f, 7.92380422e-03f, -6.90344051e-02f, -3.74903567e-02f, -1.16095662e-01f, -1.26051545e-01f, -1.15741268e-01f,
  -6.97020292e-02f, 3.46255954e-03f, 1.37974964e-02f, 2.71715634e-02f, 2.58953664e-02f, 2.21529789e-02f, -1.04404621e-01f, -1.04049109e-01f, -1.37360856e-01f, 4.78852876e-02f,
  1.18315443e-01f, 7.56829605e-02f, -5.48789103e-04f, -3.59816961e-02f, 1.61847733e-02f, -2.32627690e-02f, 6.45531937e-02f, -1.77999884e-02f, -5.77024743e-02f, 4.75056767e-02f,
  -5.79559989e-02f, 1.39300212e-01f, -4.44593951e-02f, -1.14727635e-02f, 1.40147600e-02f, 7.60210827e-02f, 8.56659003e-03f, 9.14472938e-02f, 6.37438372e-02f, 7.43426532e-02f,
  -6.40807450e-02f, -1.20261297e-01f, -5.89497648e-02f, -1.48371905e-01f, 2.48254910e-02f, -3.46339010e-02f, -4.55762148e-02f, -7.12893009e-02f, -1.81718040e-02f, 3.96291912e-02f,
  -1.72450335e-03f, -2.62288079e-02f, -1.30479392e-02f, 4.61491570e-02f, -5.94945289e-02f, 3.72020015e-03f, 3.37286480e-02f, -1.43389907e-02f, 1.00724772e-01f, -1.19215967e-02f,
  1.27473637e-01f, -2.27625981e-01f, 1.02629542e-01f, -2.38593630e-02f, -9.48615663e-04f, -9.43440273e-02f, -2.94814371e-02f, -1.61985219e-01f, -1.84915289e-01f, -5.39896153e-02f,
  -6.63883146e-03f, 2.74618100e-02f, 4.51074988e-02f, 9.04693007e-02f, 4.89318296e-02f, 9.32283998e-02f, -5.12492051e-03f, 4.05962691e-02f, -1.60526261e-01f, 3.86394188e-02f,
  -7.14603961e-02f, -2.45235134e-02f, 1.15076005e-01f, -1.16738211e-02f, 2.58845929e-03f, 1.05991162e-01f, 1.31383866e-01f, 1.79237112e-01f, 7.60247186e-02f, 1.15415908e-01f,
  1.80715278e-01f, -2.64837682e-01f, -3.84905905e-01f, -1.42316520e-01f, -2.70059019e-01f, -1.33720130e-01f, -3.40851992e-01f, -8.54396075e-02f, -5.27259521e-02f, -3.58856440e-01f,
  -2.01488167e-01f, 1.48796037e-01f, 7.34644160e-02f, 1.05430841e-01f, 1.41972095e-01f, -4.20791894e-01f, -2.29037285e-01f, 6.21845685e-02f, 2.32463464e-01f, 1.27855772e-02f,
  -4.78801429e-02f, -1.24578588e-02f, 1.50098979e-01f, 1.70055822e-01f, -2.04393953e-01f, 1.48616470e-02f, -1.97171673e-01f, -1.56016260e-01f, -1.62022457e-01f, -3.37100744e-01f,
  -3.24099541e-01f, -5.83212934e-02f, 8.11052993e-02f, 1.74730927e-01f, -1.71927363e-01f, 1.41706809e-01f, 7.79533312e-02f, 2.55170148e-02f, 1.42397493e-01f, -1.27223715e-01f,
  -8.88427254e-03f, 3.84568051e-02f, 1.52842790e-01f, 4.48989719e-02f, -4.10333350e-02f, -6.59854040e-02f, 2.74338517e-02f, 1.62614733e-01f, 7.95429349e-02f, -1.66631103e-01f,
  -8.44315439e-02f, -2.46858448e-02f, 1.00300215e-01f, -3.22186686e-02f, 6.49812445e-03f, 1.20084155e-02f, -8.28592479e-02f, 4.14345367e-03f, 1.11676276e-01f, -2.84831166e-01f,
  -1.22535557e-01f, -5.40684536e-02f, 4.22758348e-02f, -4.08504577e-03f, 7.74512067e-02f, -2.04529576e-02f, 3.94173563e-02f, 1.29081290e-02f, 6.17021462e-04f, -1.73028279e-02f,
  9.00408626e-02f, -4.94667180e-02f, 6.46974742e-02f, 1.48269907e-02f, 2.66144332e-03f, 8.43786169e-03f, -4.29672785e-02f, -2.95635685e-02f, 1.02211818e-01f, -1.36127323e-02f,
  1.86737608e-02f, 4.39402014e-02f, -5.56558073e-02f, 3.40914540e-02f, 3.38795152e-03f, -6.13660626e-02f, -1.94832904e-03f, 6.37896284e-02f, -4.01210152e-02f, -4.83103395e-02f,
  9.00188461e-02f, 2.09141761e-01f, -2.35214218e-01f, 8.77328366e-02f, -1.02554671e-01f, -5.42818680e-02f, -7.59260133e-02f, 1.26000270e-01f, -4.84039932e-02f, -2.33505387e-02f,
  1.36917278e-01f, 1.10566072e-01f, -6.88394532e-02f, -8.20117667e-02f, 5.51405512e-02f, -3.64869535e-02f, 1.17818579e-01f, 9.06469673e-02f, 1.63900435e-01f, -7.62921721e-02f,
  -8.38512480e-02f, 9.24731195e-02f, 1.12530708e-01f, 6.21918514e-02f, -5.88596053e-02f, 4.62687425e-02f, -1.61222126e-02f, -1.48145765e-01f, 6.13929033e-02f, -5.97430728e-02f,
  -5.74814975e-01f, -1.33320242e-01f, -3.85485798e-01f, -2.46654764e-01f, 8.65956023e-02f, 2.91701645e-01f, 4.23809737e-01f, 5.28254472e-02f, -6.22625574e-02f, 1.98795944e-02f,
  9.76294801e-02f, 1.08239636e-01f, -1.06348284e-01f, 4.34576645e-02f, 2.71678180e-01f, 9.88715366e-02f, 1.63546264e-01f, -1.15072317e-01f, 1.19935311e-01f, 2.81502336e-01f,
  2.30605483e-01f, -1.73575535e-01f, -2.33511463e-01f, 2.06253417e-02f, -1.10890687e-01f, -1.17844999e-01f, -1.45079792e-01f, -2.11221725e-01f, 1.08471178e-01f, -1.99316770e-01f,
  -1.51203632e-01f, -1.85673848e-01f, 1.18107915e-01f, -1.02954149e-01f, -1.26208201e-01f, -2.45263681e-01f, -4.93625365e-02f, -2.62382746e-01f, -3.10385339e-02f, -1.12051010e-01f,
  -1.49532378e-01f, 5.11973649e-02f, -8.89987424e-02f, 4.07113507e-02f, -8.48089755e-02f, 2.28602439e-02f, -3.60155925e-02f, -8.06503892e-02f, -1.83829501e-01f, -1.91247575e-02f,
  4.82052974e-02f, -3.06738149e-02f, -2.45330676e-01f, 3.38596478e-02f, -1.68999314e-01f, -9.74130630e-02f, 2.99095456e-02f, -1.20353848e-01f, -8.86004046e-02f, -3.59134138e-01f,
  4.67237942e-02f, 9.15368274e-02f, 4.44518998e-02f, 6.48333281e-02f, 7.30604604e-02f, 4.71476689e-02f, 4.55451161e-02f, 1.10542126e-01f, 4.71069068e-02f, 4.74281330e-03f,
  -5.72295412e-02f, -2.25857496e-02f, -5.38321696e-02f, -2.48856656e-02f, 4.99662012e-02f, 2.63768192e-02f, 5.20043038e-02f, 1.09204844e-01f, 9.28103551e-02f, -6.53993785e-02f,
  6.33407012e-02f, -1.55971736e-01f, -1.64144620e-01f, -2.74258591e-02f, 1.48935720e-01f, -1.74797382e-02f, 8.57547671e-03f, -1.33808898e-02f, -1.44690678e-01f, -5.61466217e-02f,
  -4.16323692e-02f, 1.75632238e-01f, -2.12634668e-01f, 1.69147104e-02f, -6.59708381e-02f, -1.77457541e-01f, 7.95698084e-04f, -2.37678103e-02f, -5.13290893e-03f, 4.81462739e-02f,
  1.35507077e-01f, 1.83357811e-03f, -2.82901395e-02f, 7.27015734e-02f, 1.15098350e-01f, 5.27005992e-04f, -1.77814532e-02f, -2.38302890e-02f, -8.40733934e-04f, -8.17605704e-02f,
  -1.61011189e-01f, -1.27108365e-01f, -3.24216098e-01f, -1.68680534e-01f, -7.89460167e-02f, -1.25363395e-01f, -2.87007570e-01f, -2.16628984e-01f, -6.56591579e-02f, -2.74104029e-01f,
  -2.72535861e-01f, -4.32201862e-01f, -1.01875067e-01f, -2.21274585e-01f, -1.85646623e-01f, -8.13968629e-02f, -3.69447410e-01f, 4.31026965e-02f, 4.46919091e-02f, -4.05835837e-01f,
  -1.59289911e-01f, 1.37262970e-01f, -1.84249490e-01f, -6.49457574e-02f, -1.66425779e-02f, -3.53218317e-01f, -3.32399666e-01f, -9.33869928e-02f, 2.76362807e-01f, 2.25564867e-01f,
  7.83365592e-02f, 5.06812008e-03f, 6.92760199e-02f, 6.33993596e-02f, -1.81178734e-01f, 1.22826861e-03f, -2.02777505e-01f, -1.52270690e-01f, -8.15397352e-02f, -4.42634404e-01f,
  -2.00848311e-01f, 1.12544857e-01f, 1.58170775e-01f, 1.08883038e-01f, -8.50443542e-02f, 4.59683314e-02f, 7.52232131e-03f, -6.73036277e-02f, -2.98882537e-02f, 4.99699339e-02f,
  1.00502297e-01f, 1.13203205e-01f, -1.21241935e-01f, -3.76071744e-02f, -7.05614015e-02f, 2.26903800e-02f, 4.51662531e-03f, 1.04891889e-01f, 6.50335252e-02f, -6.15789369e-02f,
  2.98886430e-02f, 6.55487254e-02f, -4.20566164e-02f, 7.96912685e-02f, 2.44080320e-01f, 1.57492578e-01f, 1.28949612e-01f, 1.79053828e-01f, 9.92450342e-02f, -1.98759541e-01f,
  -7.19179064e-02f, -1.39420480e-01f, 1.37698511e-02f, 1.90815721e-02f, 6.49655936e-04f, -4.68022153e-02f, -1.23936273e-01f, -3.64744104e-02f, 3.85850705e-02f, -6.68322369e-02f,
  -8.53569582e-02f, 5.47566228e-02f, 3.50104980e-02f, -2.06854209e-01f, -1.12616882e-01f, -1.07744701e-01f, -1.29344851e-01f, -8.34402591e-02f, 1.25950873e-01f, -7.78726339e-02f,
  1.19530961e-01f, 6.81851432e-02f, -1.02946162e-02f, 5.68971448e-02f, -7.58146681e-03f, -1.27698272e-01f, 3.37015875e-02f, 9.02147293e-02f, 8.57840329e-02f, -4.29241918e-03f,
  -2.84144580e-01f, 3.23377818e-01f, -2.22093418e-01f, 2.08922923e-01f, 7.56693725e-03f, 1.52004689e-01f, 6.84202909e-02f, -1.13190059e-02f, 2.44458043e-03f, 5.90385497e-02f,
  1.96374580e-01f, -5.92647353e-03f, -1.31686643e-01f, 5.30534051e-02f, 9.13382098e-02f, 1.17631197e-01f, 4.71696742e-02f, -7.05055669e-02f, 5.65754548e-02f, -2.25641094e-02f,
  -3.79452333e-02f, -1.50062948e-01f, -8.74252096e-02f, -6.72733784e-02f, 9.40190703e-02f, 6.33779028e-03f, -1.13247328e-01f, 2.76035885e-03f, -1.23627566e-01f, -4.20496583e-01f,
  -1.48776561e-01f, 2.54363380e-02f, -8.56810343e-03f, 1.03866704e-01f, 1.02423206e-01f, -9.96477008e-02f, -2.62343615e-01f, -1.90472558e-01f, 1.45323634e-01f, -5.00910282e-02f,
  1.39115483e-01f, 1.27898455e-01f, -5.78620210e-02f, -2.65132725e-01f, -4.42399383e-01f, -2.50742823e-01f, -1.13664806e-01f, -2.99490750e-01f, -3.60334277e-01f, -6.73326924e-02f,
  4.53946330e-02f, -1.54215312e-02f, -2.11378127e-01f, -3.35991569e-02f, 2.56146818e-01f, 8.54866132e-02f, 2.72136688e-01f, 4.38054018e-02f, 4.13164124e-02f, -2.03243596e-03f,
  -8.04433599e-02f, 1.30244717e-01f, 1.37268931e-01f, -8.14645439e-02f, 6.44376725e-02f, -1.12681627e-01f, -4.90910150e-02f, 6.09071329e-02f, 5.17803151e-03f, -1.15481943e-01f,
  -3.75293121e-02f, 2.18447521e-02f, 3.78258191e-02f, -1.36197776e-01f, -6.94421977e-02f, -2.29540229e-01f, -6.88417107e-02f, -1.78361177e-01f, -1.04883820e-01f, -1.48013040e-01f,
  -1.94076151e-01f, -1.14108853e-01f, -1.67410791e-01f, -8.20181817e-02f, -1.52483255e-01f, -4.58938032e-02f, 5.87308444e-02f, 1.42795891e-01f, -1.03069924e-01f, -3.87579277e-02f,
  4.51991558e-02f, 1.07635655e-01f, 4.95615341e-02f, -6.66291220e-03f, -1.16222769e-01f, 7.82169625e-02f, 1.44338729e-02f, -8.27035233e-02f, 6.47431761e-02f, -5.81785478e-02f,
  3.45370024e-02f, 1.60570771e-01f, -2.42682435e-02f, 4.53447402e-02f, -4.65991162e-02f, -3.13035585e-02f, -4.22632322e-02f, -1.65971026e-01f, -1.51090818e-02f, -5.96074052e-02f,
  -5.73260300e-02f, -5.20546436e-02f, 7.88048878e-02f, -5.69159202e-02f, -4.26503830e-02f, -1.64973792e-02f, -4.70463112e-02f, -1.33115619e-01f, -5.58848716e-02f, 5.45050278e-02f,
  -5.64650334e-02f, 6.47354573e-02f, 6.04060180e-02f, -1.23490840e-01f, -4.05956358e-02f, 5.40672243e-02f, -1.31696789e-02f, -4.50790823e-02f, 6.37215152e-02f, -1.05835430e-01f,
  -4.29783799e-02f, -2.40143389e-02f, -1.16523439e-02f, -2.59935632e-02f, -9.33990553e-02f, 7.24131148e-03f, -8.13722089e-02f, -5.52456826e-02f, -1.87244818e-01f, -2.37803981e-02f,
  -2.73672100e-02f, -1.76168308e-01f, -2.79524356e-01f, -1.56399965e-01f, 1.50277272e-01f, -8.68916810e-02f, -6.30382970e-02f, -9.80972275e-02f, -2.00380221e-01f, -2.60389149e-01f,
  3.00283819e-01f, -7.67359674e-01f, 4.57389653e-01f, -8.21911842e-02f, -1.21374996e-02f, 1.59074157e-01f, -2.34214976e-01f, -9.33755934e-02f, 9.74386334e-02f, -2.96223581e-01f,
  -4.81931895e-01f, -1.43618524e-01f, -6.83249757e-02f, -6.30126894e-02f, 6.35578930e-02f, -4.31649573e-02f, 1.89788193e-01f, 4.82608706e-01f, 5.78328609e-01f, 6.37598261e-02f,
  -2.17495129e-01f, 5.89012261e-03f, 2.73006737e-01f, 1.02716275e-01f, -1.93457127e-01f, -4.85777892e-02f, 8.42646789e-03f, -3.24911997e-02f, -1.42781228e-01f, -1.38908327e-01f,
  5.57046905e-02f, -2.05645606e-01f, 1.56390190e-01f, -6.42162338e-02f, -1.61158010e-01f, -6.79384544e-02f, -8.50624144e-02f, 3.08019854e-03f, -4.12536897e-02f, 2.70100869e-02f,
  -1.24523759e-01f, 1.04347616e-02f, 3.80055159e-02f, -4.22410158e-05f, -2.93469597e-02f, -1.04527390e-02f, 1.15836980e-02f, -1.31123558e-01f, -1.16748968e-02f, -1.17679864e-01f,
  -3.20202351e-01f, -6.64358363e-02f, 1.05405971e-01f, -3.41175264e-03f, -3.85940261e-02f, 6.77652210e-02f, -8.43200982e-02f, -9.34769493e-03f, 1.65814105e-02f, -1.36579752e-01f,
  3.93554755e-03f, 5.45315119e-03f, -8.26599002e-02f, -1.26989469e-01f, -8.69303048e-02f, -4.28379001e-03f, 4.60093282e-02f, -5.72660230e-02f, -7.11703748e-02f, -3.68673652e-02f,
  -5.79413027e-02f, 4.07573581e-02f, 3.10883205e-02f, 4.17270809e-02f, -7.82826990e-02f, 2.28738878e-02f, 3.28972749e-02f, -8.68855044e-02f, 6.00304268e-02f, -3.29920510e-03f,
  -1.18619710e-01f, 2.09784321e-03f, -1.08589241e-02f, -6.67264238e-02f, -1.18280426e-01f, 5.79487495e-02f, 1.91943087e-02f, 5.68537926e-03f, -6.18459983e-03f, -9.92117822e-02f,
  -1.38920933e-01f, 4.61565815e-02f, 1.06615931e-01f, 9.27148536e-02f, 7.63445050e-02f, -6.59883544e-02f, -4.57908548e-02f, -6.86347187e-02f, 9.93149653e-02f, 1.91515356e-01f,
  3.26187722e-02f, 1.76714644e-01f, 5.80700561e-02f, -1.77310705e-01f, 3.47934663e-02f, 8.73657390e-02f, -1.71230257e-01f, 8.45673122e-03f, -5.75927682e-02f, -1.25300452e-01f,
  -1.49307147e-01f, 2.38937512e-02f, 1.33436024e-01f, 2.10605003e-02f, -6.76910207e-02f, 2.45334119e-01f, -4.14218102e-03f, 1.36282235e-01f, 1.89054236e-01f, 2.93325800e-02f,
  3.14245582e-01f, 1.40681937e-01f, 2.90639073e-01f, 4.06962007e-01f, 2.79080540e-01f, 4.10651505e-01f, 3.96401733e-01f, 2.79714316e-01f, 2.57723480e-01f, 1.08365461e-01f,
  2.59297609e-01f, 2.57472843e-01f, 1.62045285e-01f, 1.53961569e-01f, 1.09395973e-01f, 9.89862829e-02f, 1.13583028e-01f, 1.17999122e-01f, 1.58025622e-01f, 7.16236085e-02f,
  -3.32106091e-02f, 8.13896880e-02f, -5.89707531e-02f, 5.44070154e-02f, 3.55113000e-02f, 6.06871769e-02f, 6.85854331e-02f, 5.49186915e-02f, 1.65766627e-01f, -1.95835475e-02f,
  -3.48968953e-02f, 1.63708866e-01f, 2.42223926e-02f, -8.29180479e-02f, -4.47241105e-02f, -2.29192689e-01f, 3.79333422e-02f, -1.81947630e-02f, -6.73408248e-03f, -8.34642723e-02f,
  -1.03016168e-01f, -1.11952282e-01f, 1.09987795e-01f, -7.66474530e-02f, -8.06438699e-02f, -2.00326651e-01f, 6.88445475e-03f, 1.68801874e-01f, 1.89360306e-01f, 6.38312027e-02f,
  -1.86730288e-02f, 1.69636384e-01f, 1.80099174e-01f, 1.17426790e-01f, 4.13828306e-02f, 8.69067609e-02f, -1.39272232e-02f, -7.37438351e-02f, 1.45386104e-02f, -1.05679169e-01f,
  1.48648664e-01f, 1.32358536e-01f, 1.19715542e-01f, 1.43221691e-01f, 3.51978093e-02f, 8.40676129e-02f, 8.80079530e-03f, 1.77747495e-02f, 6.36828467e-02f, -8.53309929e-02f,
  -4.34485711e-02f, 2.46860459e-01f, 1.72876015e-01f, 1.04041636e-01f, -1.25359534e-03f, 1.14159204e-01f, 4.26025875e-02f, 3.97407450e-02f, 4.35233209e-03f, 6.09493032e-02f,
  1.39974251e-01f, 8.57080817e-02f, -2.64355931e-02f, -4.48536724e-02f, 1.25567079e-01f, 1.44268855e-01f, -6.89181965e-03f, 2.65695397e-02f, 5.31095974e-02f, -4.95467000e-02f,
  8.03512260e-02f, 4.09349889e-01f, -5.30868508e-02f, -1.04988791e-01f, -1.05174758e-01f, -7.52254650e-02f, 6.68943897e-02f, -9.46165714e-03f, -9.27226767e-02f, -1.30789727e-01f,
  -3.83844040e-02f, -3.38608213e-02f, -7.83074275e-02f, 2.58345529e-02f, -1.15382008e-01f, -1.10686310e-01f, -9.04390886e-02f, 5.36321625e-02f, -2.75994707e-02f, -1.85737714e-01f,
  -2.47882139e-02f, 1.53419837e-01f, 7.57759437e-02f, 1.28475025e-01f, -9.82474685e-02f, 5.92632592e-02f, -7.04931095e-02f, -1.11173727e-01f, 3.32888439e-02f, -1.02370441e-01f,
  2.30715554e-02f, -1.99187584e-02f, -3.87752861e-01f, -9.31990594e-02f, -7.51935467e-02f, -1.66067392e-01f, -2.59372983e-02f, 1.24612831e-01f, 1.03053555e-01f, 2.62289052e-03f,
  9.89898369e-02f, 1.11640878e-01f, 6.04018122e-02f, -9.51853208e-03f, 5.99007644e-02f, -1.84575945e-01f, -1.77430600e-01f, -1.64163187e-01f, 1.44725129e-01f, 2.03007028e-01f,
  2.19470188e-01f, 4.13305536e-02f, 1.68531314e-01f, 5.95641136e-02f, -1.30106464e-01f, -7.82983676e-02f, -1.79518700e-01f, -1.84222266e-01f, -2.33718947e-01f, -5.04924774e-01f,
  -3.02363455e-01f, -1.64168507e-01f, -4.43244427e-02f, 5.48659936e-02f, -4.92888168e-02f, 5.99059500e-02f, 1.67910710e-01f, -4.34742644e-02f, 1.66683629e-01f, 1.02351144e-01f,
  -1.02435544e-01f, 1.75104681e-02f, 1.67661589e-02f, 1.41693488e-01f, 6.60692453e-02f, 1.26632005e-01f, 1.22722164e-01f, 4.69713584e-02f, -1.77547932e-01f, -8.75780731e-02f,
  1.44476248e-02f, -1.87831149e-01f, -2.08938107e-01f, -7.26217106e-02f, -9.01691802e-03f, 9.93352663e-03f, -1.67264510e-02f, -1.32276058e-01f, -6.57096207e-02f, -6.32075593e-02f,
  1.24596767e-01f, -6.39814660e-02f, -1.27070859e-01f, 5.62374853e-02f, -1.64475385e-02f, -3.75755094e-02f, -1.48839682e-01f, -9.93320495e-02f, -5.38168941e-03f, 6.80961907e-02f,
  1.51958376e-01f, -1.17055677e-01f, -1.06202289e-02f, -2.83048078e-02f, -8.00593644e-02f, -1.54058002e-02f, -4.50880155e-02f, -1.37831286e-01f, 4.01560403e-03f, -4.49465699e-02f,
  -3.22685167e-02f, -9.76355597e-02f, -9.19277221e-02f, 1.39682069e-02f, -9.75530893e-02f, -8.18871334e-03f, 8.97900909e-02f, 1.14989288e-01f, 1.55900478e-01f, 2.15925261e-01f,
  2.21869349e-01f, -2.42515504e-02f, 1.17060589e-02f, -5.72948605e-02f, -1.09822549e-01f, -7.30924367e-04f, -1.55816793e-01f, -6.69103814e-03f, -3.23111936e-02f, 9.13337469e-02f,
  2.92167021e-03f, -1.16730323e-02f, 8.53837642e-04f, 7.22781522e-03f, 9.17734504e-02f, 8.84207617e-03f, -4.46237624e-02f, -6.94200695e-02f, -1.37868717e-01f, 1.85795166e-02f,
  3.36601511e-02f, -1.26282051e-01f, 9.24256910e-03f, -3.90634798e-02f, 4.98772673e-02f, -2.00370955e-03f, 5.31669613e-03f, -7.76944384e-02f, -6.94049615e-03f, 1.02511726e-01f,
  2.09342077e-01f, -1.46438390e-01f, -9.17892605e-02f, 3.15538704e-01f, 2.40503758e-01f, -2.95836627e-01f, -4.56626028e-01f, -2.19983682e-01f, 1.51124418e-01f, -4.17442583e-02f,
  1.13735035e-01f, 1.35646448e-01f, 8.36221874e-02f, -1.05050005e-01f, -5.36194682e-01f, -4.64755595e-01f, -2.58600980e-01f, -2.77743071e-01f, -2.08400279e-01f, -2.27499142e-01f,
  3.27424966e-02f, -4.01502885e-02f, -1.67533621e-01f, -4.03440297e-02f, 2.48556688e-01f, 2.61371344e-01f, 1.82345361e-01f, 7.09429085e-02f, -2.81577930e-02f, 1.90894321e-01f,
  6.53810352e-02f, 1.61248431e-01f, 4.53309752e-02f, 1.79674163e-01f, 1.13988616e-01f, 2.92516593e-02f, 2.17289086e-02f, 1.37159694e-02f, 9.30679440e-02f, -5.68934754e-02f,
  2.01431826e-01f, 4.67992909e-02f, 1.47803918e-01f, 1.81002870e-01f, -4.87512425e-02f, -1.66957140e-01f, -7.94787332e-02f, -2.19292387e-01f, -1.64064392e-01f, -4.42792773e-02f,
  1.78934205e-02f, 7.22716823e-02f, -1.63916260e-01f, -1.30663946e-01f, -1.57701597e-01f, 1.20735623e-01f, 3.75420004e-02f, 1.26835015e-02f, -1.51342422e-01f, 1.21341206e-01f,
  5.42633496e-02f, -5.62854037e-02f, 2.01165024e-02f, -9.68494490e-02f, -3.57394852e-02f, 9.94905606e-02f, 8.71683955e-02f, -2.20234599e-02f, -1.11472353e-01f, -1.70321781e-02f,
  -2.46678255e-02f, 3.40650566e-02f, -1.77229091e-03f, -5.77727929e-02f, -2.66594682e-02f, 4.40723635e-02f, -5.96529394e-02f, -1.45186380e-01f, -1.84269369e-01f, -1.97425950e-02f,
  -6.88506067e-02f, -3.76744283e-04f, 1.00590937e-01f, 5.07668965e-02f, 2.51156799e-02f, 1.87804326e-02f, 7.31436014e-02f, 6.87134713e-02f, 6.35114610e-02f, -1.33143610e-03f,
  1.10674754e-01f, -1.83659300e-01f, 8.87388811e-02f, -1.63285270e-01f, -4.17576507e-02f, 8.54831859e-02f, 8.13973323e-02f, -8.29603747e-02f, 1.03655480e-01f, -2.95168348e-02f,
  -3.49744894e-02f, 3.70759480e-02f, 4.02548872e-02f, -3.66218500e-02f, -4.42571715e-02f, 7.49714393e-03f, -1.66508958e-01f, -2.62979027e-02f, -1.28592774e-01f, -1.02225943e-02f,
  6.86034421e-03f, -1.97532356e-01f, -7.43191913e-02f, -1.77652672e-01f, 2.93969233e-02f, -7.17057427e-03f, -6.97677061e-02f, 1.67108793e-02f, -2.03559145e-01f, -1.99698105e-01f,
  2.73019284e-01f, -1.58651903e-01f, 2.98740089e-01f, 1.41274249e-02f, -1.50079489e-01f, 5.89104258e-02f, -3.64322402e-02f, -9.14950296e-02f, -3.49649712e-02f, -5.12256147e-03f,
  1.49369746e-01f, 3.48358989e-01f, 2.93094903e-01f, 3.18244189e-01f, 2.42049888e-01f, 7.68761188e-02f, -7.44901178e-03f, 3.26742321e-01f, 2.66788542e-01f, 1.16320774e-01f,
  9.52622574e-03f, -1.12842210e-01f, 6.81665838e-02f, 3.02729011e-02f, -1.46494985e-01f, 1.77418962e-01f, -7.02157617e-02f, -3.71681638e-02f, 7.94929340e-02f, 5.36289774e-02f,
  3.08813542e-01f, -1.37940809e-01f, 1.18352517e-01f, -4.57829870e-02f, -7.99021509e-04f, -1.50173575e-01f, 1.09036513e-01f, -5.26533043e-03f, -4.48967144e-02f, -1.02187559e-01f,
  8.27837214e-02f, 5.47370246e-06f, -8.72716382e-02f, -1.01648912e-01f, -1.61888897e-01f, -2.66250372e-02f, -1.48697093e-01f, -8.65151286e-02f, 1.29450068e-01f, 7.60684013e-02f,
  -1.45192191e-01f, -3.95608507e-02f, 1.13219634e-01f, 1.17462324e-02f, 9.65851247e-02f, -4.36602756e-02f, -1.22355099e-03f, 2.47845724e-02f, 1.09211858e-02f, 4.30378206e-02f,
  -1.94938034e-02f, 7.82112181e-02f, 1.77369922e-01f, 1.60621647e-02f, 6.66583031e-02f, 1.76690504e-01f, -5.14784008e-02f, 6.18886128e-02f, -3.38582732e-02f, -8.31424221e-02f,
  6.14260398e-02f, 1.66874170e-01f, 8.34682658e-02f, 8.16869065e-02f, 8.75717029e-02f, -1.09998502e-01f, -1.04404621e-01f, -3.87536995e-02f, 4.71538715e-02f, 6.39030635e-02f,
  -4.31982242e-02f, -1.11232907e-01f, -9.90830548e-03f, 5.20780049e-02f, 6.02755323e-02f, 4.43394631e-02f, 8.31107795e-02f, -1.84104778e-02f, -7.48840272e-02f, -7.06369728e-02f,
  -1.26783073e-01f, 1.86440721e-01f, 1.23049378e-01f, 7.12250099e-02f, -1.11442521e-01f, -1.36311352e-01f, 6.73142225e-02f, -4.98882569e-02f, -1.59809932e-01f, 2.60649864e-02f,
  -2.43251976e-02f, 2.70818695e-02f, -1.11510873e-01f, -7.24612325e-02f, -3.60312574e-02f, -4.72450890e-02f, -9.28030983e-02f, -1.09102912e-02f, 8.53494033e-02f, -1.40107581e-02f,
  -2.05556601e-02f, -3.97846997e-02f, 1.00261040e-01f, 4.37434837e-02f, 5.29710464e-02f, 5.65789714e-02f, 7.74548650e-02f, -5.77976741e-02f, 5.15787825e-02f, 7.43140504e-02f,
  -4.07669902e-01f, 1.25606120e-01f, -9.70370322e-03f, -4.41787876e-02f, -1.59605607e-01f, -8.22616294e-02f, -5.79905249e-02f, -3.71300802e-02f, -7.54671171e-02f, 6.78743795e-02f,
  -4.15777303e-02f, 1.92746356e-01f, 1.52086779e-01f, 2.35806495e-01f, 2.08411321e-01f, 3.26017678e-01f, 2.22747505e-01f, 1.32543091e-02f, 1.42176971e-02f, 4.89844270e-02f,
  2.22509384e-01f, 6.22673891e-02f, 7.08454987e-03f, 1.11741513e-01f, 2.63043009e-02f, 1.74269855e-01f, 2.20235378e-01f, -6.19099941e-03f, 1.80743054e-01f, 3.28032255e-01f,
  4.26561773e-01f, -1.89231426e-01f, -1.10007608e-02f, -2.00939178e-02f, -1.29797131e-01f, -1.41569048e-01f, -2.50880271e-02f, -8.03226158e-02f, -1.62193239e-01f, -6.33318722e-02f,
  -1.38512468e-02f, -1.69289172e-01f, -1.88905224e-01f, -1.69988632e-01f, -1.73265904e-01f, -2.63798721e-02f, -1.01583347e-01f, -9.37689617e-02f, 2.77222302e-02f, 2.22599437e-03f,
  -1.89081412e-02f, -2.04713747e-01f, -1.45509556e-01f, -1.29115060e-01f, 2.04960499e-02f, -2.25091875e-02f, -5.82596958e-02f, -1.88856304e-01f, -2.00787336e-01f, -1.21739551e-01f,
  -3.44605930e-02f, -1.36554968e-02f, 4.36719321e-03f, -9.94028896e-02f, -5.36237992e-02f, -4.94936667e-02f, 4.41615358e-02f, 1.02033541e-01f, 6.83171535e-03f, 2.91690510e-02f,
  -8.50265697e-02f, -1.63723994e-02f, -1.63163215e-01f, -4.64957096e-02f, 1.95134245e-02f, -1.11642763e-01f, -9.06097442e-02f, 9.05705988e-02f, -2.26988912e-01f, -1.41249210e-01f,
  -1.41722575e-01f, -1.67898927e-02f, -1.57206580e-02f, -1.52122667e-02f, -8.14978555e-02f, -1.76541179e-01f, 7.62532651e-03f, -5.05622402e-02f, -9.25360918e-02f, -3.78728309e-03f,
  4.89739984e-01f, -1.19103700e-01f, 2.19174519e-01f, 4.01940122e-02f, 5.98965771e-03f, -1.96252987e-02f, 5.71027435e-02f, -1.90012828e-02f, -6.39836595e-04f, 5.94855323e-02f,
  4.27660113e-03f, 2.30108853e-02f, 4.36857492e-02f, 1.18157133e-01f, -1.14269536e-02f, 3.94813232e-02f, 4.59370576e-02f, 1.46624804e-01f, 7.53260031e-02f, 7.79959857e-02f,
  7.07599744e-02f, -1.08337607e-02f, 1.28139332e-01f, 9.40386131e-02f, 1.73748180e-01f, 1.50827214e-01f, 1.15838386e-01f, -5.91999628e-02f, 1.21844955e-01f, 4.46285540e-03f,
  1.95958927e-01f, 1.65945608e-02f, -2.17517003e-01f, 2.46936027e-02f, -3.03736955e-01f, -1.70255810e-01f, -3.31052929e-01f, -1.01619840e-01f, -7.33072460e-02f, -1.97778448e-01f,
  -1.13296323e-01f, 2.54102349e-01f, 1.57569095e-01f, 1.49140283e-01f, 1.31013870e-01f, -3.49243730e-01f, -3.34740818e-01f, 9.90914740e-03f, 1.08785257e-01f, -9.44482535e-03f,
  -1.79164991e-01f, -1.42530194e-02f, 1.29975453e-01f, 1.86227763e-03f, -4.29998189e-02f, 8.33364949e-02f, -1.99950233e-01f, 1.70661155e-02f, -1.76041335e-01f, -3.09981942e-01f,
  4.07769829e-02f, -1.92947164e-02f, -1.23243548e-01f, -9.99423489e-03f, 2.26375740e-02f, -9.66147557e-02f, 2.97937222e-04f, -5.76105453e-02f, -8.59957337e-02f, -1.77603275e-01f,
  7.71421790e-02f, 5.94927482e-02f, 1.47627011e-01f, -4.27482184e-03f, -2.17542388e-02f, -1.26743406e-01f, 1.30690206e-02f, -8.01962242e-02f, -6.07532784e-02f, -1.48922697e-01f,
  -1.67078942e-01f, -1.52835175e-01f, -2.33255755e-02f, -3.30553502e-02f, -4.11439873e-02f, 1.68327242e-02f, 5.52417673e-02f, -9.67652127e-02f, 9.33793709e-02f, -1.05958320e-01f,
  2.68995366e-03f, 2.86715962e-02f, -7.32273608e-02f, -6.98154941e-02f, -4.05770447e-03f, -2.75278166e-02f, 4.30095829e-02f, -1.51746431e-02f, 8.80610954e-04f, 1.54441252e-01f,
  9.09982529e-03f, -1.20259538e-01f, -5.37604885e-03f, -9.32017900e-03f, 6.67981654e-02f, 1.60695929e-02f, 4.07182314e-02f, 8.88587385e-02f, -7.62363598e-02f, 1.62391085e-02f,
  5.89197762e-02f, 1.89554952e-02f, 4.26117610e-03f, 1.06381558e-01f, -7.50997812e-02f, -6.03443105e-03f, 7.08864406e-02f, 1.03240281e-01f, 1.43462703e-01f, -1.25612795e-01f,
  3.44295263e-01f, 6.87208548e-02f, -7.83670917e-02f, 1.37477547e-01f, -9.38887894e-03f, -1.13824382e-01f, 1.49051081e-02f, -1.54560935e-02f, -3.71827856e-02f, 3.48305553e-02f,
  5.87879233e-02f, 7.73929358e-02f, 1.09257266e-01f, 2.21649334e-02f, 5.55285215e-02f, -2.10361898e-01f, -9.56699327e-02f, -2.37353202e-02f, 5.78618050e-02f, -4.82826158e-02f,
  -8.02493989e-02f, 3.01541425e-02f, 1.73588842e-01f, 1.69324607e-01f, 1.24082476e-01f, 6.92476332e-02f, 1.40562072e-01f, 6.94451332e-02f, 2.06801713e-01f, 1.37653083e-01f,
  4.40647900e-01f, -4.24001515e-02f, 1.33707657e-01f, 9.14203301e-02f, -1.98546126e-01f, -3.27790111e-01f, -4.16435033e-01f, -1.81651175e-01f, -7.98534006e-02f, 1.20482882e-02f,
  7.06157237e-02f, 2.75420576e-01f, 1.52472690e-01f, 1.25846133e-01f, -4.68300357e-02f, -1.26540661e-01f, 9.00112242e-02f, 2.37660602e-01f, 2.20639884e-01f, 1.68964356e-01f,
  1.06758818e-01f, 1.02981046e-01f, 2.86011428e-01f, 3.93284969e-02f, 1.32557899e-01f, 1.42919108e-01f, 3.69179286e-02f, 2.29284495e-01f, 1.84360281e-01f, 3.77495885e-01f,
  1.48847878e-01f, 2.51116723e-01f, 1.01075016e-01f, 2.26429522e-01f, 1.73565358e-01f, -1.92802642e-02f, -2.73677353e-02f, -5.54502346e-02f, -2.83563100e-02f, -1.32718563e-01f,
  -4.25611474e-02f, 8.01842511e-02f, 5.76939993e-02f, 1.32025620e-02f, 1.21386759e-02f, -2.67095696e-02f, 2.83293370e-02f, 5.78016602e-02f, -6.00786507e-02f, 2.73065106e-03f,
  2.70059202e-02f, 1.47867769e-01f, -8.08681697e-02f, -1.61471099e-01f, 8.95891264e-02f, 1.10176675e-01f, -8.32556188e-02f, 1.54650658e-02f, 1.00189736e-02f, 4.87724245e-02f,
  6.22895770e-02f, 1.44200429e-01f, 1.32298976e-01f, 5.27848452e-02f, 4.75933179e-02f, 8.64514560e-02f, 8.55758935e-02f, -8.92333761e-02f, 4.05828021e-02f, 9.13536027e-02f,
  5.20440824e-02f, -3.95679325e-02f, -4.50924374e-02f, -6.60119392e-03f, 6.86853565e-03f, 2.21603550e-02f, -1.24069853e-02f, 5.95862083e-02f, -3.96639407e-02f, -1.02478169e-01f,
  -3.04155778e-02f, -1.60519909e-02f, -3.31800012e-03f, 1.63552479e-03f, 2.09746417e-02f, 1.07058533e-01f, 2.55521741e-02f, 3.55304591e-02f, 5.55430613e-02f, -7.58492947e-03f,
  -5.60856104e-01f, 1.45647088e-02f, 1.33685812e-01f, 1.27390578e-01f, -2.24118344e-02f, 1.86373815e-02f, 5.13890535e-02f, 6.67538270e-02f, -9.96670201e-02f, -1.34093091e-01f,
  -1.14975721e-01f, 9.88255665e-02f, -4.93663326e-02f, 7.76339555e-03f, -1.41660586e-01f, -7.07387850e-02f, 5.34435660e-02f, -9.31375474e-02f, -2.35585943e-02f, -1.49162441e-01f,
  1.02169653e-02f, -2.35970274e-01f, -1.78204492e-01f, -2.06476599e-01f, 1.66932365e-03f, -3.92268936e-04f, -6.54747859e-02f, -9.29950327e-02f, -1.86831132e-01f, -1.26902297e-01f,
  4.43848431e-01f, -4.56299037e-01f, 2.24960446e-02f, 1.59160092e-01f, -7.33647449e-03f, -2.35817373e-01f, -5.81318021e-01f, -1.18669525e-01f, 1.19822539e-01f, -1.98106900e-01f,
  1.24472536e-01f, 4.73223060e-01f, 3.58298749e-01f, 2.07003325e-01f, 2.31957436e-02f, -4.52673942e-01f, -3.30267578e-01f, 1.44136176e-01f, 3.66657943e-01f, 7.54449069e-02f,
  -1.63281918e-01f, 2.41033528e-02f, 9.33429450e-02f, 5.94088472e-02f, -1.00721337e-01f, 4.91147786e-02f, -2.60275185e-01f, -8.00262392e-02f, -9.53506380e-02f, -2.00002149e-01f,
  3.26932669e-02f, 6.93040043e-02f, -1.53474081e-02f, 1.91622153e-01f, 4.76906337e-02f, -5.61476825e-03f, -1.38130069e-01f, -7.99403116e-02f, -7.95220584e-03f, 4.70935851e-02f,
  9.50127319e-02f, 7.15857223e-02f, -1.95762981e-02f, 9.22823548e-02f, -9.22158733e-02f, 6.05159923e-02f, -1.10837761e-02f, 1.72480699e-02f, 3.12172323e-02f, -1.35143876e-01f,
  5.23771048e-02f, -2.31316630e-02f, 8.19594562e-02f, -1.64741740e-01f, 2.95503214e-02f, 2.65143573e-01f, -1.13665968e-01f, -6.63107785e-04f, 4.34193425e-02f, -1.99888185e-01f,
  -7.95130990e-03f, 4.29916047e-02f, -3.72702838e-03f, 7.45880976e-02f, -4.45030071e-03f, -2.89217290e-02f, 1.25778317e-01f, -6.61901757e-02f, 8.43398646e-03f, -1.17343001e-03f,
  4.10799868e-02f, -2.93446630e-02f, -4.27623875e-02f, -1.06832892e-01f, 1.17978357e-01f, 6.56395359e-03f, -1.70996469e-02f, -5.91247678e-02f, -3.82560380e-02f, 5.03806323e-02f,
  6.18312284e-02f, 2.91878097e-02f, 4.75398451e-02f, 1.00203760e-01f, 1.34115908e-02f, 7.43531138e-02f, 2.76960377e-02f, -3.50233354e-02f, -4.04289588e-02f, -6.51572598e-04f,
  -9.20655355e-02f, 1.99825853e-01f, 2.07000505e-02f, 5.84216118e-02f, -2.31855921e-02f, -1.30959824e-02f, 4.55453955e-02f, 1.15861736e-01f, 1.15486465e-01f, 3.25776227e-02f,
  -2.22780872e-02f, -9.51182023e-02f, -1.08920984e-01f, 2.26156693e-02f, -8.50944743e-02f, 5.27636744e-02f, 1.17222823e-01f, 1.07576355e-01f, 1.51713967e-01f, 7.38603855e-03f,
  -1.04911208e-01f, -8.05343539e-02f, -1.25563249e-01f, -1.16080746e-01f, -1.35502312e-02f, 1.27468854e-01f, -1.73169538e-01f, -4.88723665e-02f, -5.33118583e-02f, -4.74781275e-01f,
  -3.70597064e-01f, -2.91820496e-01f, -4.87250209e-01f, 2.25785911e-01f, 1.85526833e-01f, 1.92794651e-02f, -1.02623761e-01f, 1.04991393e-02f, 3.81253809e-02f, -2.54325941e-02f,
  -4.49197292e-02f, 1.52067378e-01f, 9.22291353e-02f, 9.50022936e-02f, -1.04980089e-03f, 1.03001900e-01f, 1.43955410e-01f, -1.57766938e-01f, 1.14692096e-02f, 1.42291889e-01f,
  3.27437282e-01f, 1.30600929e-01f, -7.92239904e-02f, 1.93607524e-01f, 2.82677263e-01f, 1.85601786e-01f, -7.39218146e-02f, 1.27260476e-01f, 4.79013361e-02f, 3.24099898e-01f,
  -1.89551592e-01f, -1.29394114e-01f, -1.94523821e-03f, 2.32517287e-01f, -3.45920846e-02f, -2.36663446e-01f, -1.65237173e-01f, -2.19181076e-01f, -2.64653359e-02f, 3.45751457e-03f,
  5.09337299e-02f, -1.28066853e-01f, 1.16336063e-01f, 1.43636204e-02f, 1.04173899e-01f, -9.06336755e-02f, -2.10717171e-01f, -2.09943220e-01f, -1.16000853e-01f, -2.07059488e-01f,
  3.59469861e-01f, 2.02376291e-01f, -1.67891830e-01f, -1.71030089e-01f, -2.64580976e-02f, 2.87019778e-02f, -1.14520416e-01f, 1.98244937e-02f, -2.21024796e-01f, -5.96869364e-02f,
  4.64485623e-02f, -2.66103372e-02f, -4.86050956e-02f, -9.98568758e-02f, 2.82578776e-03f, 3.87289040e-02f, 6.75891489e-02f, 1.99526027e-01f, -8.20854399e-03f, -1.45860076e-01f,
  -5.30506484e-02f, -2.44651525e-03f, 1.14066750e-01f, -1.65013336e-02f, 1.67054936e-01f, -1.06717795e-02f, 1.47212029e-01f, 9.68514308e-02f, 9.73326266e-02f, -1.33099869e-01f,
  3.79035063e-02f, -1.38595514e-02f, -3.08960304e-02f, 1.63660541e-01f, -2.79179662e-02f, -2.92174555e-02f, 2.01817572e-01f, 1.45802572e-01f, -9.12040994e-02f, -1.07267700e-01f,
  1.00516062e-02f, -1.93682700e-01f, 6.74807653e-02f, 1.52734160e-01f, 1.31881125e-02f, -6.60075620e-02f, 2.45092344e-02f, 9.65885669e-02f, -1.25921309e-01f, -1.46831691e-01f,
  -4.96649295e-02f, -1.90250143e-01f, 1.29282735e-02f, 1.92800667e-02f, -9.29706451e-03f, -5.96063882e-02f, 7.04987869e-02f, 1.25223830e-01f, 4.17896286e-02f, -1.62498094e-02f,
  -5.95974997e-02f, 1.33381143e-01f, -6.15321025e-02f, -2.08641350e-01f, 2.63402779e-02f, -5.40230945e-02f, -1.65974706e-01f, -1.14987910e-01f, -3.06319088e-01f, -3.34247291e-01f,
  3.15834761e-01f, -1.79725334e-01f, 3.54789376e-01f, 2.08919376e-01f, 1.67601198e-01f, 2.12895036e-01f, 3.30478176e-02f, 3.45140812e-03f, 1.43016025e-01f, 7.69491792e-02f,
  6.38798103e-02f, 2.93476488e-02f, 2.91187852e-03f, -5.62776066e-02f, 1.21208914e-01f, 7.75195053e-03f, -1.49724092e-02f, 9.29561257e-02f, 8.66229385e-02f, -2.09641382e-02f,
  -1.08789384e-01f, -1.34768844e-01f, -5.94487227e-03f, -5.79403713e-02f, -1.51415646e-01f, 4.56713848e-02f, 5.97800035e-03f, -5.55480421e-02f, -8.58639181e-02f, 6.83517754e-02f,
  3.75922263e-01f, 1.18607529e-01f, 1.39261559e-01f, 9.29863602e-02f, 5.49654476e-02f, 7.51374215e-02f, 1.79855391e-01f, 6.14249520e-02f, 2.75339019e-02f, 1.19302003e-02f,
  7.15177134e-02f, -2.29767291e-03f, -8.62730742e-02f, -1.29295319e-01f, -1.95445847e-02f, -8.42994824e-03f, -1.47426486e-01f, 1.05844736e-01f, 1.37458190e-01f, 9.02887881e-02f,
  -1.38620520e-02f, -1.09577496e-02f, 5.45221008e-02f, 3.33776623e-02f, 1.20069012e-01f, 1.42763540e-01f, -2.02305820e-02f, 9.73130241e-02f, 3.38240489e-02f, 2.61355881e-02f,
  1.67229906e-01f, 3.60259563e-02f, 3.95210348e-02f, -6.66167296e-04f, 1.74128003e-02f, 1.84668139e-01f, 8.27395543e-02f, -6.60775825e-02f, -6.66712672e-02f, -1.51796281e-01f,
  -3.87348048e-02f, 1.98764026e-01f, 2.01612458e-01f, -9.75364726e-03f, 2.63345242e-02f, 1.37932450e-01f, 1.29013881e-01f, 1.01599798e-01f, -2.30608918e-02f, 1.43100312e-02f,
  5.98352700e-02f, -2.30064467e-02f, -1.89533755e-02f, -1.27092391e-01f, 4.82464731e-02f, 1.51984747e-02f, 3.92124206e-02f, -6.76307380e-02f, -1.12590812e-01f, -1.36753470e-01f,
  2.51535028e-01f, 2.64071465e-01f, 1.33945927e-01f, -1.02812327e-01f, 1.25343557e-02f, -2.01217476e-02f, 3.54043767e-02f, -1.00740373e-01f, 5.03082424e-02f, 1.01375222e-01f,
  1.20072901e-01f, -1.00518903e-02f, -1.44250557e-01f, -9.18522701e-02f, 5.36222868e-02f, 6.54630288e-02f, 1.05890883e-02f, 5.77945113e-02f, 1.59716964e-01f, 1.36651501e-01f,
  1.81080122e-02f, 1.49043873e-01f, 2.71135867e-01f, 1.35575518e-01f, 1.32364661e-01f, 1.09770939e-01f, -4.40001786e-02f, 1.03295870e-01f, 4.77454178e-02f, -2.41862647e-02f,
  -2.29810655e-01f, 3.04677114e-02f, -2.12108996e-02f, 6.24310523e-02f, 4.35564555e-02f, 1.12889707e-01f, 1.36232913e-01f, 7.78299645e-02f, 1.12688109e-01f, 1.84378386e-01f,
  2.38620564e-01f, 3.85278285e-01f, 2.55344272e-01f, 2.25617811e-01f, 2.01326594e-01f, 9.13182721e-02f, -1.23936132e-01f, 5.55722751e-02f, 1.73310891e-01f, 2.07118914e-01f,
  1.39088079e-01f, 7.02361092e-02f, 8.80002044e-03f, -7.62974024e-02f, -5.49712814e-02f, 2.20019758e-01f, -5.72264753e-02f, -6.73875511e-02f, 7.93252233e-03f, -9.22860354e-02f,
  2.26252094e-01f, -1.45334244e-01f, 1.44196525e-01f, -1.37388200e-01f, -8.61820299e-03f, -1.35451406e-01f, 3.72985117e-02f, -1.98623434e-01f, -8.89232159e-02f, 5.84949292e-02f,
  -1.19994506e-01f, -2.12514132e-01f, -7.60251284e-02f, -1.37023225e-01f, -7.76495710e-02f, -1.58023924e-01f, -2.63773203e-01f, -9.80463326e-02f, -7.15530142e-02f, -6.23483583e-03f,
  5.61708547e-02f, -5.90926595e-02f, 3.02486215e-03f, 9.78735164e-02f, 1.31221442e-02f, -1.51566043e-02f, -5.86444838e-03f, -1.69002727e-01f, -1.04842238e-01f, -8.18867311e-02f,
  1.97546318e-01f, -8.16385895e-02f, -1.52881667e-01f, 8.95452648e-02f, 1.73436806e-01f, 1.91733278e-02f, -1.60093252e-02f, -5.64549267e-02f, -1.10336013e-01f, -2.59933788e-02f,
  6.65900335e-02f, 2.43594740e-02f, -5.15958015e-03f, 6.17552288e-02f, 1.27057403e-01f, -2.50127725e-02f, -1.73459798e-01f, 3.45010986e-03f, 3.50980856e-03f, 1.74453165e-02f,
  -1.96590349e-02f, -2.54534721e-01f, -7.62449875e-02f, -1.40166774e-01f, -1.04253806e-01f, -5.94755635e-02f, -1.57662462e-02f, -7.21047772e-03f, -4.19620126e-02f, -1.34911045e-01f,
  2.31478497e-01f, 1.96006566e-01f, 1.07161179e-01f, -7.41463900e-02f, -1.72146127e-01f, -1.21533111e-01f, 1.35417819e-01f, -7.03677386e-02f, -1.10529095e-01f, 9.36813578e-02f,
  -7.22314939e-02f, -1.14749661e-02f, 3.05509195e-03f, -1.72412038e-01f, 4.73326370e-02f, -9.70261544e-02f, -9.23387855e-02f, -6.19876683e-02f, -9.66222808e-02f, -1.42248914e-01f,
  -4.11883220e-02f, 4.02559340e-02f, 7.20585957e-02f, 1.50377467e-01f, 1.25222236e-01f, 1.96870431e-01f, 1.06382854e-01f, 8.13670754e-02f, 5.00823483e-02f, 1.22804902e-01f,
  -8.69444236e-02f, -2.49344520e-02f, -2.13336378e-01f, 8.04896206e-02f, 2.00290587e-02f, -4.42708544e-02f, -4.07699719e-02f, -7.54201114e-02f, -4.25742334e-03f, -1.31971436e-02f,
  -2.13292420e-01f, -7.46879280e-02f, 8.50104634e-03f, 2.57728193e-02f, 5.09563535e-02f, 2.03018218e-01f, 3.08749169e-01f, 2.13670865e-01f, -2.34945659e-02f, 3.51887122e-02f,
  1.37828201e-01f, 6.35247603e-02f, -1.22419067e-01f, 2.76494697e-02f, 1.41026422e-01f, -7.74217099e-02f, -1.89207479e-01f, -7.53279254e-02f, 5.33508584e-02f, 5.38254499e-01f,
  -1.49838358e-01f, -2.20171332e-01f, -1.27558053e-01f, -6.11452088e-02f, -1.73881039e-01f, 6.09488692e-03f, -1.00716367e-01f, 1.33706806e-02f, -1.52361840e-01f, 5.80269210e-02f,
  3.20035890e-02f, 6.03174269e-02f, 8.80134776e-02f, 4.68393937e-02f, -2.25682277e-02f, -2.30951812e-02f, 1.02567054e-01f, -1.00982757e-02f, -9.75508764e-02f, -7.54451305e-02f,
  1.36608794e-01f, -1.06412105e-01f, -1.91134915e-01f, -1.21449471e-01f, -1.75435022e-02f, -1.87604249e-01f, -2.31989488e-01f, -6.73117191e-02f, -2.38489687e-01f, 1.14336915e-01f,
  -2.80583054e-02f, 6.88531622e-02f, 1.46964148e-01f, 2.15919644e-01f, 7.42088854e-02f, -2.01496258e-02f, 1.69017136e-01f, -6.24472741e-03f, 9.39931944e-02f, 1.31338194e-01f,
  -6.30135164e-02f, -1.83148179e-02f, -1.05291583e-01f, -1.33200049e-01f, -9.35477763e-02f, -9.50957648e-03f, 1.44842431e-01f, 4.45361957e-02f, -6.25210330e-02f, -1.77341402e-01f,
  -2.59765461e-02f, 2.27244731e-04f, -1.42851532e-01f, 1.39630929e-01f, -6.13200478e-03f, 4.76676151e-02f, 6.33819103e-02f, -6.58095852e-02f, -9.84493941e-02f, 2.40994636e-02f,
  -1.81312993e-01f, -1.83881924e-01f, -3.45604271e-02f, -8.98231659e-03f, -7.39062876e-02f, -1.42408550e-01f, -5.46407402e-02f, -7.40401819e-02f, -3.57498452e-02f, -7.00219907e-03f,
  -1.33762956e-01f, -3.20732296e-02f, 1.25552509e-02f, 8.40945914e-02f, 1.43785641e-01f, -9.69572589e-02f, 1.72346234e-01f, 1.25250533e-01f, 3.01864464e-02f, 2.29453091e-02f,
  1.29539073e-01f, -4.96657612e-03f, 5.24406508e-02f, 6.67809397e-02f, 6.88188300e-02f, -6.65054098e-02f, -6.26147389e-02f, 6.36053970e-04f, -2.94861585e-01f, 6.26666704e-03f,
  6.11047566e-01f, -5.71221232e-01f, -1.80068254e-01f, 1.55882925e-01f, 3.54629457e-02f, 3.04435223e-01f, 8.35179538e-02f, 9.06017646e-02f, 2.77831316e-01f, -1.22337967e-01f,
  -1.83937296e-01f, -9.54560414e-02f, -1.57538354e-01f, -8.94189700e-02f, 1.89090427e-02f, -5.93510494e-02f, 3.88721414e-02f, 1.19042024e-01f, 2.91766167e-01f, 2.94809025e-02f,
  -8.71376097e-02f, 1.34183560e-02f, -9.09153372e-03f, -1.96631346e-02f, -2.72747159e-01f, -5.94211444e-02f, -1.58112019e-01f, -2.20662162e-01f, -3.20469171e-01f, -3.98417920e-01f,
  -1.77496195e-01f, -2.18632475e-01f, 8.04836378e-02f, -9.33381263e-03f, -1.05006546e-01f, 9.03895795e-02f, 3.79382670e-02f, 3.89821343e-02f, -3.77863348e-02f, 9.68185440e-03f,
  3.12864073e-02f, -9.53005068e-03f, -4.84907441e-02f, -2.27564331e-02f, 2.40968671e-02f, 5.58060408e-02f, -1.36652932e-01f, -2.79498957e-02f, -8.61767232e-02f, -1.67234510e-01f,
  -2.41128698e-01f, 8.35874528e-02f, 8.17460343e-02f, 1.11461997e-01f, 5.08161075e-02f, 1.43442869e-01f, -3.73661406e-02f, -7.56085888e-02f, 4.33685370e-02f, 8.71845633e-02f,
  6.51386678e-02f, 6.08438700e-02f, -3.36514860e-02f, -4.82450575e-02f, 9.38150734e-02f, 8.36449489e-02f, 6.90100342e-02f, 2.99872179e-02f, 1.41724721e-01f, 1.01409346e-01f,
  4.92380112e-02f, -2.67335190e-03f, -4.01207618e-02f, -3.85502130e-02f, -9.16348323e-02f, -9.29543450e-02f, 9.55477804e-02f, -1.68871015e-01f, -7.33376518e-02f, -2.21814085e-02f,
  -1.02985881e-01f, -8.66368413e-03f, -9.64026302e-02f, -1.53061703e-01f, -1.62769452e-01f, -3.60516198e-02f, -8.69798511e-02f, -1.09233893e-01f, 2.88185664e-02f, 5.35955653e-02f,
  1.40686601e-01f, 3.20538059e-02f, 1.47566661e-01f, -2.87723797e-03f, -4.47918884e-02f, -1.55748621e-01f, -1.83068424e-01f, -6.65081665e-02f, -8.44120514e-03f, -3.36616151e-02f,
  -1.34747699e-01f, 9.12499987e-03f, -1.67902380e-01f, 4.22810726e-02f, 2.50890464e-01f, 1.03200957e-01f, -1.31600741e-02f, 2.53817788e-03f, -4.15701903e-02f, -3.70772034e-02f,
  -7.37110004e-02f, 1.79005057e-01f, 2.37111405e-01f, 1.26549453e-01f, 1.38086185e-01f, 2.44229242e-01f, 9.12692547e-02f, 3.52054648e-02f, 1.01872772e-01f, 1.78245679e-01f,
  6.03631258e-01f, 1.82217002e-01f, 1.36424795e-01f, 1.57762095e-01f, -6.47076592e-02f, -3.11785966e-01f, -3.11113298e-01f, -2.06231728e-01f, 1.02822676e-01f, 8.57219100e-02f,
  2.68786903e-02f, -6.18744828e-02f, 5.43484762e-02f, -9.42221805e-02f, -1.25641957e-01f, -4.47983518e-02f, 9.59492102e-02f, 2.67779771e-02f, -2.95868039e-01f, -2.63666600e-01f,
  -2.50212047e-02f, 8.48699659e-02f, 1.09980717e-01f, -1.79864708e-02f, 2.84077823e-01f, -8.02730247e-02f, 2.89055761e-02f, 1.11338213e-01f, 7.61917830e-02f, 5.15853524e-01f,
  1.11789994e-01f, 1.39083341e-01f, -3.36907357e-01f, 2.59093102e-02f, 3.22268084e-02f, 9.49634388e-02f, -1.56098148e-02f, 2.64542013e-01f, 1.05481390e-02f, 1.94444269e-01f,
  1.99820250e-01f, 8.02858546e-02f, -8.48230254e-03f, 2.78902557e-02f, -1.67988539e-02f, -9.50453281e-02f, 1.05995804e-01f, 2.84650587e-02f, 9.25504640e-02f, 5.37225641e-02f,
  -5.65646142e-02f, 2.77641625e-03f, -1.55872673e-01f, -2.15373784e-01f, 2.87060663e-02f, -9.32620242e-02f, -1.96310967e-01f, 9.89420805e-03f, -2.62543052e-01f, 2.95007795e-01f,
  -8.97500291e-02f, -7.93345124e-02f, 2.45930087e-02f, 7.02748299e-02f, 2.77282968e-02f, 7.48855099e-02f, -1.66410627e-03f, -3.39509286e-02f, -1.18620722e-02f, 1.30125592e-02f,
  -3.44894780e-03f, -6.52325675e-02f, 1.97562817e-02f, 6.33814111e-02f, -4.26907949e-02f, -7.53876567e-02f, -9.23191663e-03f, -2.95173731e-02f, -5.85479289e-02f, 5.51937288e-03f,
  -6.45466372e-02f, 4.51067910e-02f, 7.96961412e-02f, 1.23507239e-01f, 9.47395992e-03f, -4.57498990e-02f, 4.95004617e-02f, -7.35283643e-02f, -6.85561299e-02f, 1.89729836e-02f,
  -2.05940232e-01f, -3.10072809e-01f, -4.64136824e-02f, 2.88327254e-04f, 1.00139096e-01f, -6.79856092e-02f, 7.19120577e-02f, -3.16829346e-02f, -6.50972053e-02f, 4.58768122e-02f,
  -1.61456347e-01f, -1.61438286e-02f, 8.21231380e-02f, -5.54936193e-02f, -1.69034839e-01f, -8.02481323e-02f, 3.05241905e-02f, -5.20620123e-02f, -8.67240801e-02f, -3.68036218e-02f,
  4.11488079e-02f, -3.44596475e-01f, -2.79291838e-01f, -1.43594414e-01f, -1.04031026e-01f, -3.52100551e-01f, -2.75309384e-01f, -1.67191088e-01f, -4.34459567e-01f, -2.72736937e-01f,
  -4.56733018e-01f, 1.08018585e-01f, 1.34451360e-01f, -1.59884095e-01f, -6.71311468e-02f, -4.98403609e-02f, -2.50513494e-01f, -9.20649767e-02f, -3.19525786e-02f, -5.37072346e-02f,
  -5.57287373e-02f, -1.36513621e-01f, -4.31059226e-02f, -7.10110739e-02f, -3.11673760e-01f, -1.56789109e-01f, -1.35110408e-01f, -1.34640068e-01f, -3.00825208e-01f, -1.53367072e-01f,
  -1.62355602e-01f, -2.36231908e-01f, -2.37223417e-01f, -1.23710237e-01f, 8.92136618e-02f, 9.50886086e-02f, 2.25377753e-01f, 4.93772812e-02f, 5.50726652e-02f, -4.85344678e-02f,
  -9.11388621e-02f, -9.89811048e-02f, 1.96861789e-01f, -1.27795324e-01f, -4.14911471e-02f, -1.66948829e-02f, -1.07685886e-01f, 4.01640311e-02f, -4.55339551e-02f, -1.09567143e-01f,
  -1.65640935e-01f, -5.60669377e-02f, -8.18428546e-02f, 1.10431021e-04f, -1.79247662e-01f, -8.47372115e-02f, -3.62475365e-02f, -9.16223451e-02f, 7.08469823e-02f, -5.67585453e-02f,
  -3.44327204e-02f, -1.83508649e-01f, -6.88493028e-02f, 8.00094381e-02f, -6.55568540e-02f, 4.35370132e-02f, 9.95943099e-02f, 3.98656912e-02f, 7.76053816e-02f, 8.64269361e-02f,
  9.03789476e-02f, 9.29687917e-02f, -5.03794663e-03f, -1.55577779e-01f, -1.87920228e-01f, 7.93592781e-02f, 2.92266663e-02f, 3.89608443e-02f, 6.00649901e-02f, -7.48337656e-02f,
  -1.21348783e-01f, -2.10855510e-02f, 2.96642184e-02f, -1.11317560e-02f, -2.77447840e-03f, -8.38595182e-02f, -2.81508155e-02f, 1.24491937e-03f, -6.98393360e-02f, 8.90156180e-02f,
  -6.16847500e-02f, 4.12604958e-02f, -1.29352817e-02f, 4.99079861e-02f, -7.04190955e-02f, -7.20337778e-02f, -3.50534543e-02f, -5.57893030e-02f, -5.15953489e-02f, -1.80767803e-03f,
  -6.90933540e-02f, 1.75471112e-01f, -1.36680558e-01f, -6.11861125e-02f, -6.86452165e-02f, 4.54419926e-02f, -4.49380726e-02f, -2.55490635e-02f, -1.15373142e-01f, -1.21669352e-01f,
  -1.06241457e-01f, -6.23724982e-02f, -3.84086408e-02f, 1.12222712e-02f, -7.43232369e-02f, -9.01895948e-03f, -2.32618283e-02f, -3.12618800e-02f, -5.05640097e-02f, -3.22090685e-02f,
  -8.42636973e-02f, -2.93079823e-01f, -2.55254686e-01f, 9.20376927e-02f, -4.62013781e-02f, -3.61434221e-02f, 1.24275021e-01f, 4.72813398e-02f, -1.01629503e-01f, 9.09714494e-03f,
  -2.93660969e-01f, -4.86243069e-02f, 5.03100865e-02f, -5.34636751e-02f, -1.02357522e-01f, -7.13848323e-02f, -1.82892084e-01f, -1.73401937e-01f, -1.96695119e-01f, -1.22355014e-01f,
  1.98907368e-02f, 1.66369855e-01f, 1.59583986e-01f, 1.01911128e-01f, 1.36501282e-01f, -1.41563714e-01f, -2.09006101e-01f, -1.71751343e-02f, -2.93434169e-02f, -4.73488122e-02f,
  -4.43642475e-02f, -1.46779418e-01f, -9.28937942e-02f, -1.53448522e-01f, 5.73315956e-02f, 8.95967782e-02f, -1.12416536e-01f, -9.20512527e-02f, -1.08868271e-01f, 1.55837210e-02f,
  5.16304731e-01f, -2.77506970e-02f, 1.40926227e-01f, -4.69447635e-02f, 4.48669270e-02f, 1.80646945e-02f, 9.78961736e-02f, 1.77845154e-02f, -2.90905759e-02f, -6.19693007e-03f,
  -4.69809473e-02f, 2.52031796e-02f, -2.20434815e-02f, 2.90147290e-02f, -1.02666795e-01f, -2.00914741e-02f, -1.62848011e-01f, 5.88948897e-04f, -7.85379391e-03f, 1.04375102e-01f,
  -4.20319960e-02f, -2.30622757e-02f, 1.92019828e-02f, -2.00484712e-02f, -1.33151650e-01f, -1.15967929e-01f, 7.73395821e-02f, 2.96373176e-03f, 8.36386438e-03f, 2.28343625e-02f,
  5.71079105e-02f, 1.03440017e-01f, 6.60787448e-02f, 2.76926719e-02f, -9.84893367e-02f, -8.28948244e-02f, -1.07973181e-01f, -7.41033331e-02f, -3.22960913e-02f, 3.95703241e-02f,
  -9.63377729e-02f, -2.56331917e-02f, -5.29733784e-02f, -6.90830052e-02f, 1.09477274e-01f, -3.60381529e-02f, -3.26625705e-02f, 7.79870749e-02f, 2.43405681e-02f, 5.07202707e-02f,
  1.90515183e-02f, 9.72781796e-03f, -9.96970683e-02f, -1.19698301e-01f, -2.35449299e-02f, -4.14331220e-02f, -4.66302373e-02f, -8.74474272e-02f, 8.87083169e-03f, -6.75163269e-02f,
  3.62507343e-01f, 8.24661106e-02f, 1.14213079e-01f, 3.23968753e-02f, -1.00459419e-01f, 6.16852492e-02f, 2.03375489e-01f, 3.31146754e-02f, 2.85655726e-02f, 1.13124713e-01f,
  -3.34545821e-02f, -4.54220222e-03f, 4.20263112e-02f, 6.69596046e-02f, -1.69544965e-02f, 1.33927330e-01f, -7.15749711e-02f, 1.09550603e-01f, -3.79085205e-02f, 5.93206622e-02f,
  -1.21713951e-01f, -4.72110137e-02f, 3.18125449e-02f, 4.11124043e-02f, 3.47195566e-02f, 1.36806846e-01f, 1.41237423e-01f, 5.44745065e-02f, 1.89974550e-02f, -5.59707060e-02f,
  -3.43969315e-01f, -1.15721814e-01f, -2.23176345e-01f, -5.60802877e-01f, -1.96428150e-01f, 1.17656156e-01f, 1.08510936e-02f, 9.71571058e-02f, -2.48487905e-01f, -2.41062820e-01f,
  -1.45970672e-01f, -2.14189306e-01f, -2.39016756e-01f, -6.18718863e-02f, 1.85966894e-01f, -1.38836637e-01f, -2.02585384e-01f, -5.10699525e-02f, 5.62507957e-02f, 6.34771138e-02f,
  -2.07654312e-02f, -8.15607607e-02f, -1.11105658e-01f, -8.11164528e-02f, -3.56795967e-01f, -2.38038644e-01f, -2.03619614e-01f, -1.98575780e-01f, 9.18575078e-02f, -2.82469541e-01f,
  -2.35630989e-01f, -1.73119038e-01f, 1.59959942e-01f, -2.76075881e-02f, -2.56746233e-01f, -1.86176263e-02f, -6.08386286e-03f, -1.35123610e-01f, -1.22206226e-01f, -1.07155934e-01f,
  -2.46758118e-01f, -3.32828350e-02f, -1.02492288e-01f, -4.86598276e-02f, -2.77166039e-01f, 4.93887300e-03f, -1.08846262e-01f, 5.56723997e-02f, -4.92303185e-02f, -1.23885702e-02f,
  2.75936117e-03f, -4.87655923e-02f, 2.34636944e-02f, 1.54135793e-01f, 1.21514268e-01f, 6.81067854e-02f, 2.72364710e-02f, 8.38744119e-02f, 1.80663422e-01f, -9.87772867e-02f,
  6.80230930e-02f, -1.23396851e-02f, 1.18008941e-01f, 3.26492870e-03f, 8.49002972e-02f, 5.20641804e-02f, -6.45724759e-02f, 4.01982432e-03f, 1.05870143e-02f, -9.45695192e-02f,
  8.58851671e-02f, 1.27631724e-01f, 7.13602006e-02f, -7.61784837e-02f, -1.02540597e-01f, -1.26331439e-02f, 5.88584319e-02f, 2.62186117e-02f, -4.68536541e-02f, -1.22348312e-02f,
  8.29861164e-02f, 4.65676747e-02f, -9.43645462e-02f, 1.98809236e-01f, 6.59601390e-02f, -3.16838548e-02f, 5.52227087e-02f, 6.02374785e-02f, -1.01761101e-02f, 5.91217652e-02f,
  -3.46863538e-01f, 1.53961450e-01f, -2.55714476e-01f, -9.19676572e-02f, -7.44120330e-02f, 3.17800641e-02f, -1.65325344e-01f, -2.30194724e-04f, -1.47132605e-01f, 2.19911989e-02f,
  1.07989214e-01f, -8.24375153e-02f, -1.30552009e-01f, -1.60084907e-02f, -7.20292479e-02f, 7.06352144e-02f, 1.20842196e-01f, -2.79978421e-02f, 3.91758122e-02f, 2.07494386e-02f,
  1.02939345e-01f, 1.66714489e-01f, 1.11531802e-01f, 1.34549826e-01f, 3.34531739e-02f, 6.34889901e-02f, 2.08904352e-02f, 2.93345265e-02f, 1.58330694e-01f, -1.42368758e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.37112632e-01f, 1.06417403e-01f, 2.45650619e-01f, 1.17374353e-01f, 3.16646807e-02f, 2.21446604e-01f, 1.11356661e-01f, 3.44697684e-02f, 2.90862232e-01f, 8.47370774e-02f,
  1.14683822e-01f, 8.33523870e-02f, 2.37560749e-01f, -3.87031958e-02f, 1.42699629e-01f, 1.88613430e-01f, 3.02154034e-01f, -3.89090814e-02f, -1.54342711e-01f, 2.87234992e-01f,
  1.49298176e-01f, 1.96900934e-01f, 1.99050054e-01f, 1.13844082e-01f, -8.83024633e-02f, 2.00229138e-01f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -2.85550933e-02f, 1.00298077e-01f, -7.26467744e-02f, -2.60338970e-02f, 1.52245313e-01f, -1.63901690e-02f, -6.07610643e-02f, 1.04693606e-01f, 5.15363589e-02f, 2.26018071e-01f,
  3.20232511e-02f, 9.10948813e-02f, 2.90282369e-02f, 5.61442599e-02f, -3.45539786e-02f, 9.90404040e-02f, -6.82298839e-02f, 5.35059385e-02f, -6.69165552e-02f, 5.83573207e-02f,
  -2.52588391e-02f, -1.04554787e-01f, -1.46560863e-01f, 1.17756136e-01f, 1.13764703e-01f, -4.34341580e-02f, 1.57586820e-02f, -3.91937718e-02f, -5.86404018e-02f, -7.58235455e-02f,
  -8.15657675e-02f, -3.80131975e-02f, 1.52316719e-01f, -4.34553139e-02f, 2.76128147e-02f, -1.36455938e-01f, -1.78916126e-01f, 1.15029536e-01f, 9.85360295e-02f, -7.52796605e-03f,
  1.51741430e-01f, -1.76796038e-02f, -1.07265480e-01f, 1.52259886e-01f, 1.67560250e-01f, 3.13860416e-01f, -8.97138193e-02f, 4.44580764e-02f, 1.32992953e-01f, 1.15518756e-01f,
  -8.33304375e-02f, -5.74766174e-02f, -1.14747427e-01f, 2.51617022e-02f, -3.35384130e-01f, 1.74856812e-01f, -1.34710401e-01f, -1.36942603e-02f, 4.75723073e-02f, -1.18458703e-01f,
  -1.31870553e-01f, 6.97433054e-02f, -8.72501507e-02f, -5.67588583e-02f, 5.05547374e-02f, -1.37966618e-01f, 6.50406331e-02f, -8.35761800e-02f, 7.34048337e-02f, 7.48429913e-03f,
  1.87831774e-01f, -1.68015137e-02f, 7.79634044e-02f, 7.35470373e-03f, 2.08813742e-01f, 6.25100285e-02f, -7.75031373e-02f, 9.24095586e-02f, 1.10356107e-01f, -1.73894558e-02f,
  5.35440072e-02f, -8.31270963e-02f, 9.29557625e-03f, 2.39364535e-01f, 8.02460709e-04f, -3.58588202e-03f, 2.47929454e-01f, -2.78058499e-01f, -1.66950554e-01f, -5.82994819e-02f,
  7.77371004e-02f, 1.46682039e-01f, 2.04650417e-01f, 1.72547340e-01f, 4.36292559e-01f, 4.12536375e-02f, 2.13533610e-01f, 3.27091590e-02f, -6.12539127e-02f, -7.62166008e-02f,
  -2.45591402e-01f, -1.52853251e-01f, 1.31082296e-01f, -1.38601780e-01f, -1.53081328e-01f, -2.41129592e-01f, 2.65909404e-01f, -1.18675664e-01f, 9.44004878e-02f, -7.48072416e-02f,
  3.49142373e-01f, -4.99734208e-02f, 1.17753461e-01f, -1.46189645e-01f, -7.87596926e-02f, -4.39354666e-02f, -1.03920354e-02f, 5.01843095e-02f, 4.85737510e-02f, -7.58773461e-02f,
  -2.18952652e-02f, -1.66881368e-01f, 1.86163001e-02f, 1.46093354e-01f, 5.15568741e-02f, -1.23276316e-01f, -5.93933612e-02f, 7.08089098e-02f, 2.76716892e-02f, 8.76397341e-02f,
  -1.42835334e-01f, 5.76769970e-02f, -1.56373546e-01f, 8.56476948e-02f, -8.35544094e-02f, 8.23861063e-02f, 4.92706932e-02f, 5.58366552e-02f, -1.23466112e-01f, 2.15792447e-01f,
  -1.23728616e-02f, -5.60231581e-02f, -1.04086235e-01f, 1.73720136e-01f, 4.51739207e-02f, 1.20320678e-01f, -1.17115840e-01f, 5.57084009e-02f, 1.10255376e-01f, -9.48333219e-02f,
  1.29073635e-01f, 5.84732555e-02f, 3.07669770e-02f, 9.65068862e-02f, 2.03511529e-02f, 8.91282037e-02f, 6.17015734e-03f, -1.07431233e-01f, -2.00895116e-01f, 4.14904766e-02f,
  -5.49364239e-02f, 8.35833549e-02f, -1.98293310e-02f, -8.84286314e-03f, -6.26577884e-02f, -3.95684466e-02f, 1.76362112e-01f, 3.67950648e-02f, 2.95557708e-01f, 3.32088619e-01f,
  -5.13385199e-02f, 2.67292233e-03f, -1.58887058e-02f, 7.24481195e-02f, -1.67464703e-01f, 1.03257239e-01f, 1.91577703e-01f, 2.56238848e-01f, 5.37302308e-02f, -1.43106026e-03f,
  1.16264105e-01f, -1.18082888e-01f, -2.18552500e-02f, 9.22208093e-03f, -1.36391863e-01f, 1.81326002e-01f, -2.18498796e-01f, -2.59061307e-01f, -1.70613751e-01f, 1.82476312e-01f,
  -5.04920296e-02f, 6.16627149e-02f, -1.04266942e-01f, 1.79455858e-02f, 5.99265024e-02f, -2.62830947e-02f, 1.09278135e-01f, -2.08101392e-01f, -1.05378181e-01f, 8.37846175e-02f,
  4.30244692e-02f, -6.96231797e-02f, 8.92470330e-02f, -4.26079482e-02f, 7.90014584e-03f, -3.60937379e-02f, -4.57214527e-02f, -6.23779483e-02f, -8.49483162e-02f, -2.40245406e-02f,
  5.59684597e-02f, 1.83932871e-01f, 1.01859175e-01f, -1.01597972e-01f, 1.57895878e-01f, 1.09008223e-01f, -5.24393842e-02f, -1.24878012e-01f, -9.23348591e-02f, -1.25608370e-01f,
  7.49384519e-03f, 9.19682439e-03f, 3.80056091e-02f, -9.41921845e-02f, -1.45108318e-02f, -1.36647493e-01f, 5.65375108e-03f, 9.09844637e-02f, -4.70934473e-02f, -1.22856475e-01f,
  7.67532140e-02f, -8.14563558e-02f, 9.18138698e-02f, 4.94218059e-02f, -1.62535176e-01f, 2.78409839e-01f, 2.95318570e-02f, -3.80278639e-02f, -4.58697751e-02f, -3.88938040e-02f,
  3.19750085e-02f, -1.58209488e-01f, -1.38430819e-01f, 2.43302122e-01f, -1.22738771e-01f, 2.60198832e-01f, 1.24770589e-02f, 4.76429202e-02f, -1.32871911e-01f, -1.88453034e-01f,
  1.47665396e-01f, 4.75810915e-02f, 1.02824140e-02f, -3.73462476e-02f, -1.30839590e-02f, -6.55838251e-02f, -1.13918766e-01f, -1.10947289e-01f, -6.17077723e-02f, 4.20088023e-02f,
  -2.44704112e-02f, -1.57702863e-01f, 1.46811441e-01f, 5.70183806e-02f, 1.29779354e-01f, 5.69461808e-02f, -4.03392455e-03f, -1.39728375e-02f, 9.52543989e-02f, 7.06596533e-04f,
  -8.98300707e-02f, -1.67371601e-01f, -1.09130414e-02f, -6.97680861e-02f, 9.00272932e-03f, -1.22519664e-01f, 1.54576138e-01f, 5.82469739e-02f, 2.47778203e-02f, 1.77761421e-01f,
  7.86914155e-02f, -8.36238787e-02f, -4.42859456e-02f, 3.28797847e-02f, 1.00369584e-02f, 9.57187191e-02f, -1.99765757e-01f, -2.12026760e-02f, -6.09707348e-02f, -5.78732938e-02f,
  -1.11419812e-01f, 1.52684316e-01f, -5.03058285e-02f, 1.59184128e-01f, 7.98805803e-03f, -3.79303866e-03f, 3.86903598e-03f, 9.54661518e-03f, -4.59136739e-02f, 3.05177212e-01f,
  3.84326160e-01f, 1.75990999e-01f, -2.08682165e-01f, 1.95323713e-02f, 6.10511713e-02f, 2.15438545e-01f, -1.54550925e-01f, -1.28114566e-01f, -7.04996064e-02f, 1.04488440e-01f,
  2.63353065e-02f, 1.74306482e-01f, -7.94915948e-03f, -4.73062061e-02f, -3.52761932e-02f, 4.95571233e-02f, -1.39367089e-01f, -6.68732002e-02f, -8.61888230e-02f, 9.23329070e-02f,
  -3.54898795e-02f, -1.02434047e-02f, 2.40136683e-02f, 1.14994779e-01f, 9.19246003e-02f, 4.80252840e-02f, -8.36271793e-03f, -6.46287799e-02f, 1.69757634e-01f, 3.99776101e-02f,
  8.42318237e-02f, 1.58770129e-01f, -4.80701849e-02f, 5.06400503e-03f, 1.32684588e-01f, -1.15271404e-01f, -7.42996624e-03f, -6.68333024e-02f, -4.66738362e-03f, -5.14062643e-02f,
  1.33466925e-02f, 4.56374697e-02f, 1.20622113e-01f, -4.25268523e-02f, 2.37407554e-02f, -8.34217444e-02f, 6.01654835e-02f, 1.22582555e-01f, 1.38427213e-01f, -9.01490003e-02f,
  7.92509690e-02f, 5.07093444e-02f, 5.04555553e-02f, -6.76417053e-02f, 3.29119866e-05f, -3.96026410e-02f, 3.05593237e-02f, 1.97322723e-02f, -2.19439298e-01f, -2.49793395e-01f,
  -2.13673204e-01f, -4.00587590e-03f, -2.26419076e-01f, -7.74428844e-02f, -1.85585245e-01f, -1.10527210e-01f, 1.43185258e-01f, 6.05410449e-02f, -5.46047874e-02f, 7.95387700e-02f,
  1.72040500e-02f, 1.88173637e-01f, 7.42962258e-03f, 5.08920476e-02f, -6.37694374e-02f, 3.03838372e-01f, 1.18591465e-01f, 1.98234394e-01f, 2.32593596e-01f, -4.28197049e-02f,
  9.58528221e-02f, -2.00805575e-01f, -3.87384966e-02f, -9.42226201e-02f, -1.15823559e-01f, -1.08280666e-01f, 4.96644853e-03f, -1.52435020e-01f, -9.35204253e-02f, -3.84690501e-02f,
  -6.27265275e-02f, -7.59154186e-02f, -3.78263295e-02f, -1.41043395e-01f, 7.60190114e-02f, 1.34341400e-02f, 2.25296943e-03f, 7.98414201e-02f, -6.53593093e-02f, -1.45480365e-01f,
  2.25472869e-03f, -2.07108051e-01f, -5.45262434e-02f, -1.57258675e-01f, 1.19289689e-01f, -4.69447765e-03f, 1.57283783e-01f, -7.43604847e-04f, 7.59787485e-02f, 1.20144524e-02f,
  -5.21871671e-02f, 3.69679630e-02f, -3.51891182e-02f, -4.56968956e-02f, 5.18323332e-02f, 8.24261382e-02f, 3.26796845e-02f, -4.95649911e-02f, -1.17108881e-01f, 1.18304431e-01f,
  -9.12309662e-02f, 4.96967733e-02f, -5.70042478e-03f, 1.66437224e-01f, -7.96744600e-02f, -3.33667964e-01f, 2.70994157e-01f, 5.73266707e-02f, 1.89882219e-01f, 1.33544594e-01f,
  -1.53834760e-01f, 1.62291721e-01f, 2.04989351e-02f, 5.32144755e-02f, 9.09503251e-02f, -1.86012879e-01f, 4.44489606e-02f, -8.55965763e-02f, 4.16432261e-01f, 1.01097584e-01f,
  5.62515669e-02f, 2.47535203e-02f, -2.96030045e-01f, 1.68600976e-02f, -2.53314257e-01f, 2.15758011e-02f, -1.53443083e-01f, -6.80742711e-02f, 6.50964901e-02f, -7.95820653e-02f,
  9.79373381e-02f, 2.20599040e-01f, 5.20423427e-02f, 1.58806950e-01f, 8.35855976e-02f, 1.88024733e-02f, 7.31887147e-02f, 7.46043250e-02f, 1.35782838e-01f, 9.48342979e-02f,
  -2.27699848e-03f, 4.15548719e-02f, -4.45652716e-02f, 8.59028026e-02f, 4.86218445e-02f, 3.09082400e-02f, 3.97778489e-02f, 9.06736255e-02f, 4.54673031e-03f, -1.59413293e-02f,
  -4.93221506e-02f, -2.02381015e-01f, -3.85946147e-02f, 4.72054817e-02f, 4.47492152e-02f, 2.13702649e-01f, 1.70069829e-01f, 6.51120543e-02f, 1.33202896e-01f, 3.52971628e-02f,
  -5.01129851e-02f, 6.57904893e-02f, 1.23459853e-01f, -1.34942025e-01f, 5.48325814e-02f, -2.43161783e-01f, 1.19226433e-01f, 9.19432193e-02f, -2.92456113e-02f, 2.04710990e-01f,
  1.96456611e-01f, -3.04806083e-02f, 8.88185948e-03f, -2.44971827e-01f, 2.50796437e-01f, -3.65205109e-02f, 9.55018774e-02f, -3.33216369e-01f, 1.24170907e-01f, -1.31221786e-01f,
  1.66344285e-01f, -1.77537590e-01f, 2.24230457e-02f, -9.14253518e-02f, -4.23438065e-02f, 1.59801945e-01f, 4.73254248e-02f, 3.17783296e-01f, -1.27670363e-01f, -1.61040589e-01f,
  -6.57463893e-02f, -1.18817195e-01f, 3.08955833e-02f, 6.43833876e-02f, 1.49579197e-01f, 7.60913640e-02f, 2.66727665e-03f, -2.30135843e-02f, 2.09158599e-01f, -6.43139298e-04f,
  -7.00571537e-02f, 4.68644686e-02f, 2.97136754e-02f, 8.70262310e-02f, -5.98965511e-02f, 5.15193678e-02f, 4.70660217e-02f, 1.47648126e-01f, 8.56531318e-03f, 4.69380468e-02f,
  -3.38308066e-02f, -4.30921875e-02f, 1.03133661e-03f, -9.01975855e-02f, -6.48659989e-02f, -1.33011982e-01f, 8.03291425e-02f, 1.61398426e-01f, -2.01802671e-01f, 2.96259462e-03f,
  2.63724606e-02f, 8.37100819e-02f, -4.16648649e-02f, -1.55030772e-01f, -1.18076250e-01f, 7.58892968e-02f, 4.98952754e-02f, -9.79339108e-02f, -9.45524201e-02f, 1.23475865e-02f,
  -3.50478943e-03f, 1.88204840e-01f, 1.65070906e-01f, -1.90761704e-02f, 2.75028735e-01f, -1.87298823e-02f, 2.12025955e-01f, 4.52333204e-02f, 4.52447347e-02f, 6.80352896e-02f,
  2.26567090e-01f, -2.40785733e-01f, -2.72354055e-02f, -1.08578384e-01f, 9.47666243e-02f, 3.29797007e-02f, -1.16814539e-01f, -1.96992576e-01f, -2.21898943e-01f, -1.39213242e-02f,
  -2.27087334e-01f, 1.51696920e-01f, -2.73055524e-01f, 1.36402100e-01f, -3.02912872e-02f, 2.44190261e-01f, 2.71143224e-02f, 6.89331368e-02f, -1.44643188e-01f, 2.30042234e-01f,
  -4.19890471e-02f, 1.09326363e-01f, -4.88800332e-02f, 8.95243660e-02f, 7.20240399e-02f, 3.43389027e-02f, 1.86396874e-02f, -1.24978060e-02f, -1.36016384e-01f, 5.47567718e-02f,
  6.24673031e-02f, 7.90791214e-02f, 1.28762815e-02f, 1.07409097e-01f, 1.09663025e-01f, -1.14715159e-01f, 6.59785122e-02f, 1.32457152e-01f, 1.40121087e-01f, 6.44447282e-02f,
  5.00215441e-02f, 9.63524953e-02f, 6.72459155e-02f, -1.74258009e-01f, -3.81837524e-02f, -1.43217146e-01f, 1.41058519e-01f, -3.45535316e-02f, -4.84408140e-02f, -7.25655556e-02f,
  -9.90552530e-02f, -1.33266002e-01f, 6.38096631e-02f, -4.30809110e-02f, 3.72234806e-02f, 4.18282747e-02f, 2.16690004e-02f, 6.03393838e-02f, -1.36060685e-01f, -3.54937345e-01f,
  -1.42239541e-01f, -8.22930634e-02f, 1.66948333e-01f, 2.92277485e-02f, -4.45482396e-02f, 1.05195798e-01f, 1.94629699e-01f, 1.83630601e-01f, 8.26311950e-03f, 1.79972351e-01f,
  2.23106608e-01f, -2.86781877e-01f, 1.52241647e-01f, -1.50557254e-02f, 2.23074295e-02f, 2.10849959e-02f, 2.31799021e-01f, 6.01579957e-02f, 5.60472300e-03f, -1.52532458e-01f,
  4.65268269e-02f, -1.07753146e-02f, -1.17434993e-01f, -3.01503614e-02f, -4.66045365e-02f, -4.33187820e-02f, -2.05541700e-02f, -1.04805432e-01f, 3.73543538e-02f, -4.51396145e-02f,
  1.38962284e-01f, 2.77388126e-01f, -3.92946899e-02f, 1.62014022e-01f, 3.45417939e-04f, 1.40112231e-03f, 1.03769004e-01f, 1.72455236e-02f, 2.87869647e-02f, 2.21605226e-01f,
  1.05182692e-01f, -4.58000749e-02f, 9.56225246e-02f, -2.91644067e-01f, -9.18434411e-02f, -2.53024176e-02f, -3.67762819e-02f, 2.07944557e-01f, 2.21675858e-02f, 9.90242213e-02f,
  1.13621511e-01f, -3.64950523e-02f, -1.98467895e-02f, 5.98209277e-02f, 9.25215334e-02f, -5.46026565e-02f, -1.04892358e-01f, 1.38076484e-01f, 3.57469648e-01f, 1.78233892e-01f,
  -3.11670103e-03f, 3.70013341e-02f, 1.01982601e-01f, -2.46830180e-01f, -1.83968246e-01f, -4.48994488e-02f, 8.49008262e-02f, 4.78365496e-02f, 1.32483050e-01f, -8.23900774e-02f,
  -1.41254440e-01f, 4.29134555e-02f, 1.61182135e-01f, 5.23815975e-02f, 8.23623985e-02f, -1.80367291e-01f, 1.62126407e-01f, 9.02013704e-02f, -2.27256343e-01f, 1.05367586e-01f,
  -1.43013567e-01f, 1.12198390e-01f, 1.22853190e-01f, -3.33054066e-02f, 1.30278524e-02f, -1.08212315e-01f, -4.10071611e-02f, -1.07243150e-01f, 4.93341312e-02f, -8.51811916e-02f,
  6.23666607e-02f, 7.62510076e-02f, -6.59366995e-02f, 8.92221462e-03f, 3.72482277e-02f, 7.05667436e-02f, -4.26385663e-02f, 1.61241710e-01f, 6.82764053e-02f, 7.40195960e-02f,
  1.08356431e-01f, -1.05128199e-01f, 1.19075611e-01f, -1.41637310e-01f, 1.03651337e-01f, 4.51005846e-02f, 2.51471158e-02f, 1.74052596e-01f, -2.28774431e-03f, 1.62530050e-01f,
  4.83254008e-02f, -4.23205271e-02f, -1.43483141e-02f, 7.72380009e-02f, 8.97808298e-02f, 6.24205098e-02f, -1.16012551e-01f, -2.48711351e-02f, 1.02585535e-02f, -1.91061601e-01f,
  1.35702163e-01f, -7.34503055e-03f, -1.92440197e-01f, 1.33541241e-01f, -1.85445040e-01f, 7.21433759e-02f, 8.64299163e-02f, -2.93093175e-01f, 2.02593938e-01f, 1.93115652e-01f,
  1.06595412e-01f, -2.03699544e-01f, 4.07991335e-02f, 1.49766147e-01f, 3.35549079e-02f, 1.24767981e-01f, 6.82344064e-02f, 1.77026808e-01f, 4.66036707e-01f, 5.17913438e-02f,
  -6.79006055e-02f, -1.45313486e-01f, -8.21514726e-02f, -2.35306889e-01f, 2.12121516e-01f, -7.10260421e-02f, 1.86843991e-01f, -9.75831971e-02f, 9.74161625e-02f, 5.93798980e-02f,
  -6.09421581e-02f, -1.64666235e-01f, 2.04788838e-02f, -7.76908249e-02f, -9.98162627e-02f, -1.06699187e-02f, -7.51707256e-02f, -1.57171220e-01f, -1.02884360e-01f, -2.36509666e-01f,
  6.69584097e-03f, -2.35590022e-02f, -5.57886809e-02f, -5.06801978e-02f, -1.40270710e-01f, -1.51606068e-01f, 2.61328812e-03f, 4.52646724e-04f, -9.38603133e-02f, -2.35906281e-02f,
  9.20423418e-02f, -2.24519707e-02f, -5.65913394e-02f, -1.04419172e-01f, 4.94814813e-02f, -3.73615772e-02f, 5.57619296e-02f, -9.07225609e-02f, 2.27754861e-02f, 8.18607360e-02f,
  4.28117923e-02f, -1.74574763e-01f, 2.54302304e-02f, 8.51136148e-02f, 1.44273266e-01f, -1.73896663e-02f, 1.80306613e-01f, 1.26280193e-03f, -1.56166777e-01f, -1.24788314e-01f,
  -2.18427077e-01f, 1.06421344e-01f, 1.03775943e-02f, 1.73382640e-01f, -7.05469921e-02f, -1.35035306e-01f, -8.26497227e-02f, 2.52248287e-01f, -1.25548869e-01f, -7.81357139e-02f,
  -5.34831397e-02f, 6.82150349e-02f, -8.69625807e-02f, 1.70942947e-01f, 1.64586991e-01f, -4.39938009e-02f, -1.44196057e-03f, 1.46839172e-01f, 2.48979721e-02f, 1.16267517e-01f,
  3.79727669e-02f, -2.17873961e-01f, 1.27408668e-01f, -4.68040034e-02f, -1.37737632e-01f, -1.54832572e-01f, -1.14745773e-01f, 2.18372256e-01f, -1.03370823e-01f, 3.22887003e-02f,
  -5.87522835e-02f, 6.44864216e-02f, -1.28927544e-01f, -8.60965103e-02f, -1.82320457e-02f, -2.84183435e-02f, 6.78456873e-02f, 7.12456629e-02f, -2.93205287e-02f, -6.01217486e-02f,
  -6.35627210e-02f, -6.64775372e-02f, -1.42158940e-01f, -3.68601531e-02f, 2.18691994e-02f, 4.57739420e-02f, 1.08944386e-01f, 2.18587652e-01f, 1.13736376e-01f, -1.94884941e-01f,
  1.23493604e-01f, -1.09382443e-01f, 1.68015659e-01f, -8.06668028e-03f, 1.38207063e-01f, -2.47637421e-01f, -2.39144899e-02f, -1.97842464e-01f, -6.54322281e-03f, -1.28712058e-01f,
  -9.01214406e-03f, -9.02846456e-02f, -2.00565487e-01f, -1.35149360e-01f, 1.51542559e-01f, -1.31654188e-01f, -1.74405485e-01f, -1.69223000e-03f, 1.99354067e-02f, 6.48571327e-02f,
  -2.39006549e-01f, 7.84958303e-02f, -6.53417595e-03f, 1.27613544e-01f, -2.05793213e-02f, 2.43454590e-01f, 6.38198331e-02f, 7.86346272e-02f, 7.96536207e-02f, -1.07570708e-01f,
  2.20401824e-01f, 1.10056281e-01f, 2.97537297e-01f, -9.07313526e-02f, -5.38620213e-03f, -1.83558062e-01f, 3.94616611e-02f, -3.71095873e-02f, 2.06568819e-02f, 1.24004297e-01f,
  -1.08196981e-01f, 1.71329290e-01f, 1.03884749e-01f, 1.22046784e-01f, 1.04271434e-02f, 4.60738922e-03f, -2.23226007e-02f, 2.25719124e-01f, 3.74833755e-02f, 5.81903942e-02f,
  8.07730332e-02f, -2.20724121e-02f, 6.62722737e-02f, 3.74876568e-03f, -1.02007493e-01f, -2.58819044e-01f, 1.80826727e-02f, 2.20322728e-01f, -3.15903239e-02f, 2.10735068e-01f,
  1.04348913e-01f, 2.48106673e-01f, -2.32867151e-03f, -2.81643450e-01f, 4.25767601e-02f, -7.66188204e-02f, -1.53904017e-02f, -7.76440930e-03f, -1.48688272e-01f, -1.17269255e-01f,
  -1.12287864e-01f, -5.38384505e-02f, 7.87661448e-02f, -9.22613218e-02f, -8.54324624e-02f, -8.46545771e-02f, -3.10860872e-02f, 3.30672935e-02f, 2.84071676e-02f, -1.66124165e-01f,
  2.65900083e-02f, -2.20804829e-02f, 2.01058432e-01f, -3.59882154e-02f, -1.45528793e-01f, -5.08340262e-02f, 2.47290228e-02f, 1.26872182e-01f, 1.75011270e-02f, 3.57351005e-02f,
  4.97060895e-01f, -2.68896848e-01f, 1.22927740e-01f, -2.62514930e-02f, -4.33259681e-02f, -7.31257722e-02f, 4.27391350e-01f, 2.73608007e-02f, 9.48571861e-02f, -2.12279305e-01f,
  -2.94778049e-02f, 5.15894778e-03f, 9.30794328e-02f, -8.47920496e-03f, -7.58205876e-02f, -1.84942022e-01f, 9.51704383e-02f, 1.83298022e-01f, -6.90236464e-02f, 6.58743903e-02f,
  1.20017491e-02f, 2.60781683e-02f, 9.51605942e-03f, 1.57880168e-02f, -1.92478579e-02f, -2.01644804e-02f, 1.43113971e-01f, -1.47427127e-01f, 6.68135956e-02f, 3.68797369e-02f,
  -4.15335130e-03f, 4.74376865e-02f, -4.72879484e-02f, -7.21485913e-02f, -3.63215990e-02f, -4.64353487e-02f, -2.68940516e-02f, 5.43878861e-02f, 7.53540965e-03f, -8.55514705e-02f,
  -7.16542155e-02f, -5.30196875e-02f, -2.43473858e-01f, -2.84624696e-02f, 9.22287535e-03f, 2.88069993e-01f, -5.08794375e-02f, -7.60025829e-02f, -2.01533750e-01f, 1.09153472e-01f,
  9.07790437e-02f, 2.23283455e-01f, -1.37595817e-01f, 3.27132374e-01f, 2.70200700e-01f, -7.79471174e-02f, -2.24706918e-01f, -5.26093617e-02f, 6.15397580e-02f, -8.08465108e-02f,
  -7.55877793e-02f, -7.46598393e-02f, -1.24019884e-01f, -3.34988423e-02f, -1.70441866e-01f, 2.95631200e-01f, -2.91845426e-02f, 2.56920248e-01f, 7.42480457e-02f, -1.16544433e-01f,
  -3.15912396e-01f, -2.75626350e-02f, 1.53551906e-01f, 1.85333937e-01f, -2.96894927e-03f, -3.10540758e-02f, -5.23371436e-02f, 1.28274634e-01f, 1.42381161e-01f, -5.77095198e-03f,
  4.97628972e-02f, 8.19624737e-02f, -5.35151176e-02f, 1.38255088e-02f, -6.30171299e-02f, 1.94428805e-02f, 6.62345067e-02f, 1.42278122e-02f, 8.06647390e-02f, -2.59298664e-02f,
  1.13880575e-01f, -8.84274021e-02f, 8.47977325e-02f, -1.30398005e-01f, -8.54250565e-02f, 1.61080018e-01f, 9.16612670e-02f, 1.65945962e-02f, -3.53808105e-02f, 1.68269441e-01f,
  -2.20857598e-02f, -6.26322702e-02f, 1.94553733e-02f, -8.04147124e-03f, -3.91740389e-02f, -2.63415501e-02f, -8.66953433e-02f, -6.72211349e-02f, 1.95378438e-01f, -2.70254258e-02f,
  1.38053596e-01f, -5.29195555e-02f, -1.40479416e-01f, 1.54397398e-01f, 9.77902114e-02f, 2.25553766e-01f, -7.04732090e-02f, -2.12820068e-01f, -1.84524119e-01f, -2.04706043e-02f,
  1.54306442e-01f, 2.32388452e-02f, -9.28803831e-02f, 1.03041433e-01f, 1.16029106e-01f, -2.06209756e-02f, -1.04256667e-01f, 2.86801279e-01f, 2.65544020e-02f, -3.05046052e-01f,
  -8.90814066e-02f, 1.67591451e-03f, 5.15379570e-02f, 9.55391326e-04f, 3.55341911e-01f, 1.17689222e-02f, -3.89707275e-02f, -2.88969308e-01f, -1.74036250e-02f, -9.76107270e-03f,
  -1.05459578e-01f, 1.77322045e-01f, -4.29043286e-02f, -1.46619426e-02f, -7.38694519e-02f, 9.16616619e-02f, -1.37776837e-01f, -5.72548807e-03f, -1.00125752e-01f, 1.88212141e-01f,
  1.19613104e-01f, 7.91391432e-02f, -1.00359472e-03f, -4.19315062e-02f, 1.46862492e-01f, -8.73232484e-02f, 7.51065928e-03f, -5.07763773e-03f, -6.27589151e-02f, 6.95170090e-02f,
  2.60180403e-02f, -3.00532673e-02f, -8.41107743e-04f, 1.94861278e-01f, 1.39006674e-01f, 1.49958327e-01f, -1.97654292e-01f, 4.47529480e-02f, 1.34833872e-01f, -2.93497611e-02f,
  -1.20777443e-01f, -1.34987935e-01f, -3.00442781e-02f, 1.38673648e-01f, 1.07749276e-01f, 1.16671232e-04f, 4.43058126e-02f, -1.44553989e-01f, -8.71360973e-02f, 2.77809829e-01f,
  2.36933697e-02f, -1.71621069e-01f, 2.38501295e-01f, -1.32555708e-01f, 1.17951259e-01f, 1.17691178e-02f, 1.41995596e-02f, 1.32632911e-01f, 8.80864710e-02f, -1.12377673e-01f,
  1.24335706e-01f, 2.47707739e-01f, 3.78083259e-01f, 3.50682028e-02f, -6.95689470e-02f, 3.04768570e-02f, -7.09877536e-02f, -6.27870709e-02f, 6.63935617e-02f, -1.68244448e-02f,
  -3.30331246e-03f, 2.69436352e-02f, 6.98669255e-02f, -7.69292340e-02f, -8.37685633e-03f, -8.14387351e-02f, -1.20000713e-01f, 1.65687114e-01f, 6.68186769e-02f, 3.88130099e-02f,
  9.51370746e-02f, 1.41016513e-01f, -6.06936999e-02f, 1.08563662e-01f, -1.57623276e-01f, 9.06764269e-02f, 9.81990248e-02f, -1.35630332e-02f, 9.83765931e-04f, -1.16611704e-01f,
  -1.18692347e-03f, -3.55364084e-02f, 4.62116906e-03f, 7.86118135e-02f, 1.28687844e-01f, -1.19832113e-01f, 1.27677202e-01f, 5.70969023e-02f, -9.91388261e-02f, -5.27776405e-02f,
  -5.87123632e-02f, -1.43350437e-01f, 1.32871330e-01f, 1.18083237e-02f, 4.18193080e-02f, -1.50961846e-01f, -6.68247938e-02f, -1.27337471e-01f, -6.16142564e-02f, -2.08376460e-02f,
  -5.08219227e-02f, -3.79931241e-01f, -2.10873067e-01f, -8.96790698e-02f, 2.47466132e-01f, -7.90252462e-02f, 5.09226918e-02f, 5.72444797e-02f, 3.14910114e-01f, -4.96295989e-02f,
  -1.18540190e-01f, 2.78402239e-01f, 1.00456923e-01f, 5.21334670e-02f, 4.55829985e-02f, 1.80778921e-01f, 3.40618223e-01f, 1.99160352e-01f, -5.02943657e-02f, -1.53899774e-01f,
  -3.06149088e-02f, -5.47742993e-02f, 2.87192047e-01f, -1.16787173e-01f, -1.15175210e-01f, -7.06121605e-03f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.34251326e-01f, 1.61037475e-01f, 1.35301247e-01f, 3.79417948e-02f, 1.19368903e-01f, -9.93032530e-02f, 1.60025343e-01f, 1.51878580e-01f, 1.12551406e-01f, 3.21398497e-01f,
  1.65471565e-02f, 9.13293138e-02f, 1.07896954e-01f, 1.74492076e-01f, 9.08687860e-02f, -2.32592933e-02f, 2.16821596e-01f, 1.52794734e-01f, -1.62686989e-01f, 2.09296346e-01f,
  1.41978398e-01f, -6.05050027e-02f, -5.76563105e-02f, -7.93229863e-02f, 2.02751026e-01f, 1.55879393e-01f, -9.91297290e-02f, 6.08735383e-02f, -4.28946093e-02f, 4.47051227e-02f,
  -8.32911655e-02f, -2.00682715e-01f, 2.37841476e-02f, 2.04823583e-01f, -1.29874244e-01f, -7.47866035e-02f, -5.91065437e-02f, -3.60755399e-02f, 2.38153309e-01f, 1.12445563e-01f,
  9.98306572e-02f, -1.63747132e-01f, 1.31833836e-01f, -1.26060527e-02f, 3.25667530e-01f, 1.15601271e-01f, 1.43573701e-01f, -1.13596544e-01f, -2.18231939e-02f, 1.50719315e-01f,
  -2.19921954e-02f, -2.66252279e-01f, 1.60001472e-01f, -1.31576322e-02f, 1.70622230e-01f, 1.35161147e-01f, -1.15646951e-01f, -3.82576175e-02f, -7.51422420e-02f, 3.09864908e-01f,
  7.86159262e-02f, 8.53098780e-02f, -6.63652569e-02f, -5.80928065e-02f, 1.75827041e-01f, 7.22725466e-02f, 1.03288554e-01f, 1.75394684e-01f, 1.22125790e-01f, -2.84998585e-02f,
  1.17956296e-01f, 5.88308983e-02f, -5.55712916e-02f, 2.58717746e-01f, -7.58951604e-02f, -2.26218745e-01f, 1.88976228e-01f, 1.40692607e-01f, 1.87169716e-01f, -9.79553312e-02f,
  1.69523492e-01f, 1.54151097e-01f, -1.99915208e-02f, -1.36775330e-01f, -3.13744336e-01f, 1.01557963e-01f, -1.63418800e-01f, -2.03676403e-01f, -3.38699698e-01f, -1.32481277e-01f,
  1.19399756e-01f, 6.18221797e-02f, 3.42323899e-01f, 2.64336783e-02f, 2.41134450e-01f, 1.51428446e-01f, -2.53824331e-02f, 7.03857318e-02f, 3.77045125e-01f, -1.28420740e-01f,
  2.76436448e-01f, 2.74161875e-01f, -3.36232185e-01f, -3.46023105e-02f, -6.44104406e-02f, 1.62275791e-01f, -3.57321978e-01f, 8.37894455e-02f, -1.99627578e-01f, -5.91551736e-02f,
  5.13655663e-01f, -6.00561835e-02f, -3.58228654e-01f, -2.43893668e-01f, -2.13215873e-01f, -1.62424877e-01f, -3.14667374e-01f, -5.33575341e-02f, -5.77909589e-01f, 3.59805748e-02f,
  -2.43075565e-02f, -3.93301956e-02f, 1.96563289e-01f, 4.53608543e-01f, 2.77942389e-01f, -3.37058097e-01f, -8.14694464e-02f, -1.19216621e-01f, 7.48142600e-02f, 1.84771836e-01f,
  8.53116363e-02f, 1.13183193e-01f, 7.98225403e-02f, 4.73288409e-02f, 1.94206506e-01f, 8.35305266e-03f, 1.67184919e-01f, 2.41481408e-01f, -1.38634294e-01f, 2.59754777e-01f,
  7.68852755e-02f, 1.89447254e-01f, -6.03390345e-03f, 2.07676664e-01f, 2.49052495e-01f, 8.14178213e-02f, 1.36520356e-01f, 3.12264692e-02f, 1.29761159e-01f, 7.79909864e-02f,
  1.14140168e-01f, -1.48777544e-01f, 1.44937828e-01f, 1.52793407e-01f, 4.02138345e-02f, 2.06836954e-01f, -2.33536795e-01f, 6.43275380e-02f, -1.33516267e-01f, -6.79433048e-02f,
  -4.24939618e-02f, -1.22834392e-01f, -3.91949387e-03f, 8.31017792e-02f, 1.21994741e-01f, -1.39546901e-01f, 2.08847970e-02f, -2.34036043e-01f, 3.78046669e-02f, 2.33019069e-01f,
  1.79322019e-01f, -2.44708527e-02f, 1.86780676e-01f, 8.36687535e-02f, 4.67639416e-02f, 6.58482611e-02f, -5.92415733e-03f, 3.56356502e-01f, 1.85572520e-01f, -7.54587278e-02f,
  3.28513563e-01f, 4.13498938e-01f, 4.36814785e-01f, 1.62546962e-01f, -9.37299654e-02f, 2.95126110e-01f, -3.03404313e-02f, -9.06756073e-02f, 3.21453623e-02f, 1.26105130e-01f,
  -1.24521263e-01f, 4.74675559e-02f, 7.11008087e-02f, -2.59405989e-02f, 7.08731706e-04f, 5.57034947e-02f, 2.24254206e-01f, 1.75991043e-01f, 1.32493198e-01f, -1.12747878e-01f,
  1.77769661e-02f, 9.08061340e-02f, 2.10254416e-01f, 5.24495766e-02f, 1.25824854e-01f, 1.36741981e-01f, 1.51724935e-01f, 1.04320310e-01f, 6.23960830e-02f, 1.12833582e-01f,
  1.58202633e-01f, 2.51004994e-01f, -1.18493386e-01f, -5.96338399e-02f, 4.23861481e-02f, -1.27546653e-01f, -1.68426707e-01f, -1.42622128e-01f, 1.62393391e-01f, 9.41809490e-02f,
  -1.26816332e-01f, -3.72032106e-01f, -1.23068113e-02f, 1.49746209e-01f, 1.19745739e-01f, -2.48388052e-01f, 3.46818537e-01f, -2.07780302e-02f, 6.43633157e-02f, -1.30588952e-02f,
  5.27765512e-01f, 1.68616965e-01f, 2.35267013e-01f, 9.18867067e-03f, 8.04754496e-02f, 2.12695464e-01f, -1.70187831e-01f, 6.52554482e-02f, -4.82376486e-01f, 3.18804570e-02f,
  2.24153385e-01f, 3.79614353e-01f, 3.47886570e-02f, 2.70360440e-01f, 1.08802237e-01f, -2.78884977e-01f, -1.33447677e-01f, 5.31468987e-01f, -3.83242704e-02f, 4.67014015e-01f,
  1.19957045e-01f, 1.44204041e-02f, 5.38588455e-03f, -5.91645390e-02f, -9.14350301e-02f, -1.36695174e-03f, -4.91692796e-02f, 1.26831755e-01f, 4.85136919e-02f, 1.90842599e-01f,
  5.40131656e-03f, 2.20112607e-01f, 1.24348380e-01f, 3.87616293e-03f, 2.22915068e-01f, 1.67366400e-01f, 1.37749508e-01f, 3.16030085e-01f, 1.00005619e-01f, 1.28274411e-01f,
  1.56789929e-01f, 1.83883786e-01f, 1.94229543e-01f, 1.47945181e-01f, 4.10643779e-02f, 3.82858403e-02f, 1.16219774e-01f, 1.85255662e-01f, 1.17666982e-01f, -3.24421078e-01f,
  1.43658429e-01f, 8.17902684e-02f, -1.06437236e-01f, 1.40339464e-01f, -9.32952389e-02f, 3.37350607e-01f, 7.32916668e-02f, -5.99592216e-02f, -9.95195061e-02f, 2.09471524e-01f,
  -1.69022813e-01f, 6.00749776e-02f, 1.68140717e-02f, -3.00391287e-01f, -1.30471522e-02f, -3.38453352e-02f, -2.03914613e-01f, -8.82028490e-02f, 2.83895016e-01f, -5.50456382e-02f,
  1.49363831e-01f, -4.65521365e-02f, 1.47912636e-01f, 7.99159035e-02f, 2.83818960e-01f, -1.59147277e-01f, 3.36619169e-01f, -2.24305689e-03f, 2.60237545e-01f, 2.34618813e-01f,
  3.69125843e-01f, 8.14822018e-02f, -2.17055842e-01f, 1.09424852e-01f, -5.96021265e-02f, 1.83630046e-02f, -2.74482965e-01f, 3.99971567e-02f, -4.37357500e-02f, 3.22626233e-02f,
  9.33096744e-03f, 2.99741160e-02f, 1.71835706e-01f, 1.66597441e-01f, 3.62669714e-02f, 1.14001960e-01f, 4.92012985e-02f, -3.81509997e-02f, 7.62283728e-02f, 6.89125359e-02f,
  9.80758965e-02f, -1.12090364e-01f, 5.76047576e-04f, 8.13709870e-02f, 5.01164272e-02f, 2.57959217e-01f, 2.75059380e-02f, 2.61030436e-01f, -4.06189188e-02f, -1.91821069e-01f,
  -2.09490672e-01f, -2.59174675e-01f, -2.31784821e-01f, 3.64695072e-01f, -3.20831500e-02f, -1.46188334e-01f, -1.04419544e-01f, -2.47676849e-01f, 7.59242699e-02f, -1.52955860e-01f,
  -4.40918595e-01f, 9.50413793e-02f, 8.85054320e-02f, 2.82537788e-01f, -1.88627437e-01f, 1.01629294e-01f, 7.29592741e-02f, 3.53836387e-01f, -1.39358208e-01f, 1.54932849e-02f,
  -1.44596556e-02f, -6.24014065e-02f, -1.02831004e-02f, 4.00330037e-01f, -3.34724858e-02f, 4.18568850e-02f, -2.54909784e-01f, 1.30663246e-01f, 4.62980848e-03f, -1.43161446e-01f,
  -3.11111301e-01f, -2.31920585e-01f, 1.30462907e-02f, -2.96359528e-02f, -4.19528514e-01f, -1.65364131e-01f, -1.83146209e-01f, 5.85260205e-02f, -7.41418526e-02f, -2.63264745e-01f,
  -5.39796054e-02f, 1.31504029e-01f, -1.24376990e-01f, 1.79739445e-01f, -1.51384380e-02f, -4.85109128e-02f, 1.26271054e-01f, 9.32016969e-02f, -4.09882478e-02f, -4.35194783e-02f,
  3.41549180e-02f, -6.00059181e-02f, 1.16808586e-01f, 3.38797607e-02f, 8.19149837e-02f, 2.54373718e-02f, 7.49719441e-02f, 6.25002682e-02f, -3.18330452e-02f, -1.80624709e-01f,
  -2.04633623e-02f, -1.01572581e-01f, 5.14614023e-02f, 1.32490650e-01f, 9.63049009e-02f, -2.47325312e-04f, 4.96006012e-02f, -2.69806921e-01f, -1.29743693e-02f, 1.06291480e-01f,
  -6.18601218e-02f, 1.97333679e-01f, -6.25316203e-02f, 4.43408452e-03f, 1.66205376e-01f, 7.07137883e-02f, 7.51768723e-02f, -1.42732233e-01f, -1.87863801e-02f, -8.65756348e-02f,
  -1.60074472e-01f, 9.01667848e-02f, 2.81398356e-01f, -8.40611756e-02f, -1.87454075e-01f, -1.98932946e-01f, 2.46018812e-01f, 3.53762135e-02f, 1.96890727e-01f, -1.62061647e-01f,
  5.05853221e-02f, 2.21167982e-01f, 8.70551392e-02f, 1.02645397e-01f, 1.26216933e-01f, -1.55836359e-01f, 1.82340309e-01f, -8.97219554e-02f, 2.50999182e-01f, 9.66712385e-02f,
  2.05125824e-01f, 1.06726095e-01f, -3.71515639e-02f, 1.64080128e-01f, -3.30689996e-01f, -9.83818248e-03f, 4.96118888e-02f, 1.16787493e-01f, -2.76402235e-02f, -2.53751390e-02f,
  -1.77926756e-02f, -5.57209738e-02f, 8.51771086e-02f, -2.22011626e-01f, -4.45728451e-02f, 4.81273653e-03f, -2.61213314e-02f, -7.04357922e-02f, -1.13413863e-01f, -1.57389998e-01f,
  1.49809912e-01f, -4.27215472e-02f, -3.15761194e-02f, -3.76050733e-02f, -1.12148613e-01f, -3.83937284e-02f, 1.35467857e-01f, -5.81936873e-02f, -1.24468870e-01f, 6.86167553e-03f,
  -9.95592400e-02f, 7.90660307e-02f, 1.04720287e-01f, -6.43427894e-02f, -1.95788927e-02f, -1.17198586e-01f, -2.66557708e-02f, 4.96797217e-03f, -2.97108263e-01f, -8.77525359e-02f,
  -7.91018233e-02f, 6.48375601e-02f, -1.20922066e-01f, 1.90143764e-01f, -3.13978381e-02f, 1.77998766e-01f, -1.10882759e-01f, 2.55474180e-01f, 1.83872402e-01f, -1.20991714e-01f,
  -1.27330273e-01f, 4.28426564e-01f, 2.06650645e-01f, 2.08868116e-01f, -1.96331546e-01f, -2.56748468e-01f, 7.25879148e-02f, 1.26074970e-01f, -2.93764412e-01f, -3.98841053e-01f,
  -7.05949590e-02f, -1.92560032e-01f, -1.17341829e-02f, -2.42060646e-02f, 9.95589197e-02f, -9.25948024e-02f, -1.37577787e-01f, -1.99443907e-01f, 2.26308890e-02f, 3.29150528e-01f,
  -1.43586695e-01f, 2.17315435e-01f, -1.40548468e-01f, 2.30867732e-02f, 1.84408426e-01f, -8.26655254e-02f, -7.57579431e-02f, -1.94767579e-01f, -8.70072097e-02f, 3.93451080e-02f,
  6.94951648e-03f, -2.31658757e-01f, 1.31779477e-01f, -2.19751745e-02f, -4.33302186e-02f, 4.56824200e-03f, -8.97494033e-02f, 1.19206809e-01f, 4.27657068e-02f, -2.19258040e-01f,
  4.85791825e-02f, 3.50498676e-01f, 1.31841183e-01f, 7.37979636e-03f, 8.66289288e-02f, -1.88579522e-02f, 5.45001181e-04f, -8.52006823e-02f, 1.00181308e-02f, 3.02488059e-01f,
  5.68785481e-02f, 7.92225450e-02f, 6.83580339e-02f, -1.03885412e-01f, -2.46537998e-01f, 1.56130016e-01f, 5.98296262e-02f, 2.67381847e-01f, -1.73557580e-01f, 1.65326819e-01f,
  -8.17788532e-05f, 4.30256724e-02f, -8.30807388e-02f, 2.49643460e-01f, 1.83349386e-01f, 3.25563371e-01f, 2.89253324e-01f, -2.33714432e-02f, -6.29826561e-02f, -1.61800504e-01f,
  1.63621902e-01f, -1.34572744e-01f, -1.75233915e-01f, -9.55910608e-03f, 1.04080155e-01f, -2.30858237e-01f, 6.40408769e-02f, 1.78505644e-01f, 6.23028390e-02f, -1.62186176e-02f,
  -1.59592479e-01f, -2.95807809e-01f, -3.59131068e-01f, 6.54734448e-02f, 5.78589961e-02f, 2.28978321e-01f, -4.83926088e-02f, 6.34755865e-02f, 1.44729361e-01f, 3.31860706e-02f,
  1.00714542e-01f, -1.17826499e-01f, -2.84041315e-02f, 4.41332906e-03f, 1.03650086e-01f, 6.46575838e-02f, -2.60484987e-03f, 8.16638097e-02f, 1.34425670e-01f, 6.90551624e-02f,
  -3.40114050e-02f, -1.31272316e-01f, -3.85726616e-02f, 4.69179004e-02f, 7.05861747e-02f, -9.25049111e-02f, 1.64547592e-01f, -4.84473817e-02f, -1.57179415e-01f, 1.86237041e-02f,
  7.92589113e-02f, 7.51023889e-02f, 9.67660546e-02f, -2.16401860e-01f, -6.20892160e-02f, -1.28676608e-01f, -1.81489989e-01f, 1.29994303e-01f, -6.85297176e-02f, 1.22829907e-01f,
  -1.66693538e-01f, -2.41192486e-02f, -9.76241082e-02f, 2.95571506e-01f, -1.32672310e-01f, 1.43007070e-01f, 1.69735387e-01f, 2.39513745e-03f, -3.66068408e-02f, 2.92346001e-01f,
  1.04839958e-01f, 1.88550696e-01f, -2.06481308e-01f, -1.02480792e-01f, -5.99949108e-03f, 3.18607569e-01f, -3.53226304e-01f, -2.92653412e-01f, 3.88160832e-02f, -3.94716635e-02f,
  -8.83625299e-02f, -7.23222122e-02f, -2.69013271e-02f, 1.28831668e-02f, -2.53898919e-01f, 5.01865596e-02f, 1.65188953e-01f, 2.62774676e-01f, -1.26559645e-01f, 9.54489335e-02f,
  2.57988781e-01f, -1.41867012e-01f, -1.04003856e-02f, 2.04850174e-02f, 4.84706201e-02f, 1.96250025e-02f, -7.20910728e-02f, 1.83179185e-01f, 9.58111584e-02f, -1.53675005e-02f,
  -5.07926121e-02f, -7.37636834e-02f, 1.01513699e-01f, 7.49296993e-02f, 6.84959441e-02f, 8.90544206e-02f, -1.30063564e-01f, -1.18483663e-01f, 2.72929966e-01f, 8.49872008e-02f,
  -6.21773787e-02f, 6.60328120e-02f, -1.87271878e-01f, 1.26781121e-01f, -2.49846429e-01f, 1.24632426e-01f, 5.65277860e-02f, -3.43667775e-01f, 7.45211840e-02f, -3.81636262e-01f,
  1.59906417e-01f, 5.29234558e-02f, 7.20320195e-02f, -2.01845527e-01f, 2.51268536e-01f, 3.68564129e-02f, 2.19435841e-01f, -9.54168513e-02f, 4.07632589e-02f, -1.71927392e-01f,
  -1.76009685e-01f, 1.18616618e-01f, -2.18836382e-01f, 8.11918378e-02f, -1.89455241e-01f, 2.52641942e-02f, -3.87715250e-01f, -2.11231448e-02f, -2.30670050e-01f, 1.65717587e-01f,
  -4.44959886e-02f, 5.09743243e-02f, -2.75689155e-01f, 3.17870915e-01f, -1.72933117e-02f, 3.35813761e-01f, -2.18571439e-01f, -5.47842607e-02f, 4.26241636e-01f, -2.33205885e-01f,
  3.39359343e-01f, -2.11046174e-01f, -3.07720453e-01f, -3.96909654e-01f, 1.48606643e-01f, -2.44884696e-02f, -7.52307400e-02f, 4.78939079e-02f, 1.43636093e-01f, -1.37534097e-01f,
  3.65431607e-02f, 1.00652002e-01f, -5.83501980e-02f, 1.33995682e-01f, -1.28626451e-01f, 1.71174750e-01f, -1.24065410e-02f, 1.82907104e-01f, 6.67687654e-02f, -2.61808038e-02f,
  1.16583958e-01f, 2.00439125e-01f, 9.93205607e-02f, -2.89922953e-01f, -5.88719323e-02f, 2.06762180e-01f, -9.60741118e-02f, 2.86666274e-01f, 1.29611284e-01f, 3.94524671e-02f,
  1.33853527e-02f, -2.32364044e-01f, -7.50367343e-02f, -1.01332597e-01f, -2.20082790e-01f, -1.01252586e-01f, -1.41483083e-01f, -3.02614179e-02f, -9.78676900e-02f, 1.74802110e-01f,
  6.91822767e-02f, 1.33473411e-01f, -2.05654591e-01f, 1.25022441e-01f, 2.71965921e-01f, 2.03208029e-01f, -1.65846854e-01f, -9.98581797e-02f, 6.68985099e-02f, 2.64195114e-01f,
  -8.66896734e-02f, -3.14525403e-02f, -1.30845383e-01f, 2.45131269e-01f, 5.21259122e-02f, 7.51095191e-02f, 7.54743516e-02f, 1.90054461e-01f, 1.76563725e-01f, 3.78855094e-02f,
  -1.34734198e-01f, 1.25751093e-01f, -2.03301340e-01f, -3.59024256e-01f, 2.22445711e-01f, 2.50190198e-01f, -4.62774970e-02f, -1.82988897e-01f, 4.90773916e-02f, -1.09893724e-01f,
  1.55435622e-01f, 7.90096968e-02f, -9.05061215e-02f, 5.85328229e-02f, 2.24564835e-01f, -7.23331273e-02f, 8.49738568e-02f, 5.30333705e-02f, 3.43987755e-02f, -6.12816289e-02f,
  1.51109740e-01f, 1.16404466e-01f, -5.12450188e-03f, 1.59934759e-02f, 1.35537805e-02f, -4.55162153e-02f, 3.01700830e-02f, 5.86948022e-02f, 1.80062577e-01f, -1.09198950e-01f,
  1.68415084e-01f, -2.60275453e-01f, -1.84474457e-02f, -6.29813671e-02f, -1.08693421e-01f, 1.71862081e-01f, 1.22512672e-02f, 2.42602706e-01f, 2.93283224e-01f, 3.82920615e-02f,
  8.14689416e-03f, -6.84048384e-02f, -1.66471019e-01f, 9.70430896e-02f, 3.19136903e-02f, 3.94840278e-02f, 5.31192571e-02f, -2.05706343e-01f, -1.90703824e-01f, -1.91558793e-01f,
  3.50843728e-01f, 1.16795816e-01f, 1.79528221e-01f, -5.43960780e-02f, 2.37624049e-01f, 3.70221674e-01f, 1.95599720e-01f, -1.10916667e-01f, 1.48895711e-01f, -2.35140119e-02f,
  1.39228448e-01f, 1.75865814e-02f, 2.65947282e-01f, 2.23083305e-03f, 9.60712787e-03f, 1.21422140e-02f, -1.56281553e-02f, 1.09640725e-01f, -2.69443542e-01f, 1.96718443e-02f,
  -4.83151600e-02f, 2.94421017e-01f, -4.61133979e-02f, 5.42476028e-02f, 9.49383378e-02f, 8.97445604e-02f, -7.23699704e-02f, -7.24051371e-02f, 3.08637284e-02f, 5.65868616e-02f,
  1.97517797e-02f, 7.12889654e-04f, 8.96769613e-02f, -1.37658179e-01f, 2.75382493e-02f, -5.72090670e-02f, 7.34346583e-02f, -1.16147986e-02f, -4.56727017e-03f, 1.47069454e-01f,
  1.13277286e-01f, -1.00583591e-01f, 2.24719495e-02f, -7.47436285e-02f, -1.88002080e-01f, 1.65988505e-01f, 6.72232360e-02f, -1.83366895e-01f, -2.30763224e-03f, -1.43875197e-01f,
  5.62531874e-02f, -3.24727711e-03f, -1.75079331e-01f, -4.05476503e-02f, -1.86091632e-01f, 4.89994921e-02f, -8.13017879e-03f, 1.39644638e-01f, -2.92032771e-02f, 3.93240079e-02f,
  -4.38810021e-01f, 2.84531452e-02f, 6.62356988e-02f, 1.61122471e-01f, -1.00860961e-01f, 3.45605224e-01f, 8.74016508e-02f, 5.68300039e-02f, 2.52067178e-01f, 1.45293429e-01f,
  -9.42076668e-02f, -2.69467652e-01f, -1.65691227e-02f, -5.72350025e-02f, -1.78678572e-01f, -2.02947184e-01f, -1.98034137e-01f, -1.44863918e-01f, 5.57489954e-02f, 9.37043969e-03f,
  -3.51024605e-02f, -7.77374506e-02f, -4.51317765e-02f, 1.71851888e-02f, 5.91073073e-02f, 4.01398778e-01f, 3.38900208e-01f, 1.81820527e-01f, 2.60280725e-02f, 6.40300363e-02f,
  1.14913650e-01f, -1.23551622e-01f, -3.59741747e-02f, -4.15382953e-03f, 3.64869386e-02f, 1.68829232e-01f, 4.93536927e-02f, 1.14520021e-01f, 7.44270235e-02f, 1.87685549e-01f,
  -1.38102742e-02f, 1.62163645e-01f, 1.76967323e-01f, 1.92583382e-01f, -2.64832750e-02f, 1.50073379e-01f, 2.72910237e-01f, 2.09356114e-01f, -1.06137924e-01f, 1.20103464e-01f,
  2.37248629e-01f, 2.38008603e-01f, -1.49942830e-01f, -7.28434101e-02f, -8.94834325e-02f, 7.56001920e-02f, -1.74527973e-01f, -1.55051529e-01f, -1.96793422e-01f, -1.27933368e-01f,
  -1.25467300e-01f, 7.57896677e-02f, -1.33787505e-02f, -3.07689130e-01f, -7.01343119e-02f, -1.34697258e-02f, -2.12074772e-01f, -4.12594713e-02f, 8.35400894e-02f, 1.26135066e-01f,
  2.89174795e-01f, 8.73466432e-02f, 4.07764882e-01f, -1.70561269e-01f, -2.18361728e-02f, 2.77750939e-01f, 7.02083856e-02f, -1.28296822e-01f, -6.60693645e-02f, 3.22513640e-01f,
  4.79957044e-01f, 2.32569337e-01f, -2.02720225e-01f, -8.72343853e-02f, 3.56147252e-02f, -2.22827524e-01f, -2.97358576e-02f, 1.16041191e-01f, -2.32992113e-01f, 3.18722683e-03f,
  1.99233651e-01f, 6.84812590e-02f, 2.77281463e-01f, 1.86430067e-01f, 1.37652606e-01f, -1.28225356e-01f, 2.86960248e-02f, 1.29608661e-01f, 2.28088960e-01f, 1.77121624e-01f,
  1.91160560e-01f, -1.57738209e-01f, 1.03325285e-01f, 2.78484263e-02f, 5.97289056e-02f, 8.36376697e-02f, -5.19630350e-02f, 3.39119703e-01f, 3.32389884e-02f, -3.56648892e-01f,
  -5.10570481e-02f, 1.54700518e-01f, -2.63773322e-01f, 1.58253789e-01f, 1.47149697e-01f, 1.33919522e-01f, -8.71324390e-02f, -2.07684919e-01f, 4.22208719e-02f, -5.57443351e-02f,
  -1.00777172e-01f, -6.97424216e-03f, -3.33957940e-01f, 2.65014589e-01f, -4.23678309e-01f, 2.65173823e-01f, -3.57396118e-02f, -1.71234339e-01f, -3.50955993e-01f, -2.29573071e-01f,
  -1.11533999e-01f, 3.33381556e-02f, 1.73350833e-02f, 3.58538687e-01f, 1.50360525e-01f, 1.15745537e-01f, 1.58027589e-01f, -2.59954572e-01f, -1.67299479e-01f, -1.32985532e-01f,
  9.54635069e-02f, -6.95040599e-02f, -1.78418949e-01f, 2.45533124e-01f, 1.07668646e-01f, -3.34042236e-02f, -1.31794959e-01f, 4.74595353e-02f, 2.42317587e-01f, -2.23943725e-01f,
  1.26448898e-02f, 1.34801298e-01f, -9.26957428e-02f, 1.27874523e-01f, 2.47289566e-03f, 8.65717754e-02f, 1.01742588e-01f, 1.23402476e-01f, 4.63033170e-02f, 2.09998265e-02f,
  2.21955299e-01f, 1.06507786e-01f, 1.59784928e-01f, 2.44979307e-01f, 1.55683428e-01f, 2.37233579e-01f, 9.65250880e-02f, 1.42979190e-01f, 1.22069679e-01f, 1.21961132e-01f,
  1.91237703e-01f, 1.44140586e-01f, 8.66031572e-02f, 9.37991310e-03f, 7.63914781e-04f, -1.00763567e-01f, 5.05764782e-02f, 3.35647054e-02f, -8.02037343e-02f, 2.90082097e-01f,
  6.06376678e-03f, 1.90416854e-02f, -7.49642448e-03f, -6.30598664e-02f, 1.04983926e-01f, -5.11620343e-02f, 4.77402061e-02f, -7.84109607e-02f, 1.19443079e-02f, -2.13740245e-01f,
  1.61340169e-03f, -2.33856146e-03f, 3.88005793e-01f, 2.94028908e-01f, 2.03176230e-01f, 1.23733975e-01f, -6.96999058e-02f, -3.59683305e-01f, 2.04417091e-02f, 5.31896837e-02f,
  -1.10116802e-01f, -2.67345369e-01f, -4.51821238e-02f, 2.58222729e-01f, -7.84505904e-03f, 4.64950763e-02f, 2.17642725e-01f, 1.35427698e-01f, 1.22072235e-01f, 1.83926895e-01f,
  -6.97004190e-03f, 6.24284074e-02f, -3.14324200e-02f, 2.68879890e-01f, 2.17208922e-01f, 5.75568937e-02f, 1.94409922e-01f, -2.05660954e-01f, 3.10360193e-02f, 8.07417780e-02f,
  -5.52900918e-02f, 1.02941655e-01f, 7.61197507e-02f, 3.43348719e-02f, 1.01429425e-01f, 1.01013355e-01f, 2.22286792e-03f, 1.71709567e-01f, 5.00775278e-02f, -5.58339134e-02f,
  -9.56846178e-02f, 1.07889071e-01f, 1.72032520e-01f, 1.01541884e-01f, 1.06846951e-01f, -8.37082863e-02f, 2.77551770e-01f, -1.61296141e-03f, -8.67758542e-02f, 2.01048315e-01f,
  2.50731528e-01f, 2.23406196e-01f, -2.90936083e-01f, 2.78191447e-01f, 1.36351302e-01f, -1.13347083e-01f, -6.12835661e-02f, -1.07504278e-01f, 1.91235274e-01f, 7.09985122e-02f,
  -7.48770759e-02f, -2.03057081e-01f, -2.83797737e-02f, -2.05912925e-02f, 2.10558265e-01f, -7.16601238e-02f, -6.79306313e-02f, 1.59480602e-01f, -2.01771662e-01f, 3.53879295e-02f,
  -1.24994040e-01f, -3.66617113e-01f, -4.18745819e-03f, 2.60390341e-02f, -1.71781942e-01f, -7.02582747e-02f, -1.19014814e-01f, 2.99632791e-02f, -8.76132175e-02f, 5.19210473e-02f,
  -2.90448457e-01f, 3.77328157e-01f, 2.01631561e-01f, -1.68261543e-01f, -1.93304953e-03f, -1.30254418e-01f, 7.97066391e-02f, -5.46214581e-01f, 4.31989044e-01f, -2.93392986e-01f,
  6.91887736e-02f, -1.97263196e-01f, 1.51332140e-01f, 5.09195887e-02f, 1.69551030e-01f, 1.59383163e-01f, 1.42905176e-01f, -7.73452446e-02f, 1.83629975e-01f, 1.37047082e-01f,
  1.46720558e-01f, -4.59851250e-02f, 4.91039604e-02f, 1.19006159e-02f, -5.94706833e-02f, -3.04030925e-02f, 5.02936263e-03f, -1.65625028e-02f, 9.93983587e-04f, 2.51564533e-01f,
  -2.96302438e-02f, -3.82874548e-01f, -4.99423482e-02f, 1.39104435e-02f, -2.57288665e-01f, 4.03255194e-01f, 1.31059542e-01f, 1.01135857e-01f, -8.99210274e-02f, -2.71572024e-01f,
  5.37394136e-02f, -1.66254744e-01f, -4.51314032e-01f, 1.50287122e-01f, 1.98406018e-02f, 2.41193861e-01f, -2.04821810e-01f, -8.00786093e-02f, -1.07855961e-01f, 2.60370940e-01f,
  -2.92731255e-01f, 3.46712291e-01f, 2.44277213e-02f, 1.68042630e-02f, -1.08021282e-01f, 1.91464379e-01f, -7.65743852e-02f, 9.17524919e-02f, -8.12637135e-02f, 2.49850944e-01f,
  -1.87784180e-01f, 2.36192495e-02f, -2.02411577e-01f, -1.79989174e-01f, -4.01664712e-02f, 4.49803891e-03f, -1.75222158e-01f, -4.48442370e-01f, -5.30539528e-02f, -3.01653775e-03f,
  -9.30671990e-02f, -1.57835647e-01f, 4.27529681e-03f, 9.13574770e-02f, -2.10361004e-01f, 2.78589547e-01f, -4.05758396e-02f, 1.82851225e-01f, -4.91607971e-02f, 2.92313099e-02f,
  1.01706885e-01f, -3.99748869e-02f, -2.43529826e-02f, -1.99693292e-02f, 5.82747981e-02f, 1.90258130e-01f, 4.99354117e-02f, 1.46097854e-01f, 7.67021393e-03f, 8.95283073e-02f,
  1.31975412e-01f, -1.43812925e-01f, 1.30850613e-01f, 1.31969109e-01f, 2.08555330e-02f, 1.30936718e-02f, -6.63393959e-02f, 1.05947748e-01f, 1.48876518e-01f, 8.59793127e-02f,
  3.76724079e-02f, 1.57360360e-01f, 1.52408173e-02f, -3.29915993e-02f, -1.16755709e-01f, -1.78485215e-01f, -4.34128270e-02f, -1.12769470e-01f, -8.92144963e-02f, 4.81785908e-02f,
  1.69273078e-01f, -5.41683435e-02f, -7.43689155e-03f, 3.42810191e-02f, 1.75087392e-01f, 2.13879526e-01f, 2.84736931e-01f, 9.46863517e-02f, -1.64366096e-01f, -1.27468765e-01f,
  -1.53137177e-01f, 2.45922804e-01f, -2.96617121e-01f, -2.26486668e-01f, 1.90505087e-01f, 3.32269996e-01f, -1.99132431e-02f, -1.48037523e-02f, 1.23027481e-01f, -4.16204594e-02f,
  -1.16104521e-01f, 1.15286797e-01f, -1.24508105e-01f, 2.03632534e-01f, -4.56349440e-02f, -8.74161497e-02f, 1.36249334e-01f, 6.76123500e-02f, 9.65977460e-02f, -1.55189663e-01f,
  1.44449443e-01f, 1.53561771e-01f, -9.74325463e-02f, 5.13912849e-02f, 1.03661165e-01f, -3.14397104e-02f, 3.43019068e-02f, -4.63604629e-02f, 5.99996261e-02f, 2.94298172e-01f,
  3.50944027e-02f, 1.46761820e-01f, 1.30894957e-02f, 1.28705621e-01f, 5.15016913e-02f, 4.91996072e-02f, 3.44701074e-02f, 1.86743394e-01f, -1.11524237e-03f, -9.41950977e-02f,
  1.09500878e-01f, 2.01917648e-01f, -8.32549110e-02f, 2.05202669e-01f, 1.11944690e-01f, 3.35437320e-02f, 4.33217846e-02f, -2.10560128e-01f, -2.12460652e-01f, -1.43847126e-03f,
  7.62099586e-03f, -9.31309462e-02f, -4.08626758e-02f, -1.29420280e-01f, -1.34152710e-01f, -1.08189911e-01f, 2.45420218e-01f, -1.30928576e-01f, -2.17745155e-01f, 1.50559083e-01f,
  1.83472604e-01f, -7.40817040e-02f, -5.73191009e-02f, -1.82891771e-01f, 4.46721911e-02f, 2.79864579e-01f, 6.37571141e-02f, -1.66484401e-01f, -9.71469581e-02f, 3.46663296e-01f,
  -1.61905244e-01f, -4.97987047e-02f, -1.48534954e-01f, 2.20566869e-01f, 2.92882264e-01f, 1.76536083e-01f, -9.63924173e-03f, -2.16478348e-01f, -8.74912515e-02f, -3.73485863e-01f,
  3.01436931e-01f, 9.19163078e-02f, 1.06392920e-01f, -2.61571795e-01f, -5.88491466e-03f, 2.14959919e-01f, 1.71594486e-01f, 8.19671005e-02f, 2.19090179e-01f, 2.78425831e-02f,
  9.50597152e-02f, 1.64655909e-01f, 6.58084974e-02f, 1.77147001e-01f, 1.50940716e-01f, 2.79130280e-01f, 1.31358832e-01f, 1.29721850e-01f, 1.64568037e-01f, 1.66468814e-01f,
  3.77698839e-02f, 1.50415614e-01f, 1.64488658e-01f, 3.01117241e-01f, 3.50305028e-02f, -1.60096973e-01f, 5.65707730e-03f, -1.76867902e-01f, -1.24266557e-01f, 6.29186705e-02f,
  -2.03465894e-01f, 1.06341831e-01f, 4.47614230e-02f, 2.00598966e-02f, -1.39505360e-02f, -2.32964993e-01f, 6.30136430e-02f, 1.46211460e-01f, 1.05339184e-01f, 9.33726057e-02f,
  -8.69835094e-02f, 1.22128464e-01f, 3.34428251e-01f, 3.55872750e-01f, 1.81250181e-02f, 7.32029974e-02f, 3.75008881e-02f, 2.82653898e-01f, 1.14330217e-01f, 6.90832436e-02f,
  5.80316149e-02f, -1.85889021e-01f, 2.41387665e-01f, -2.56748684e-02f, 2.83691529e-02f, -3.54619622e-01f, 1.38152927e-01f, -1.74011905e-02f, 1.55060351e-01f, 1.79288715e-01f,
  7.01007172e-02f, 1.14711411e-01f, -1.82890836e-02f, 7.67492801e-02f, -1.88271612e-01f, 1.10384308e-01f, 4.62937616e-02f, 9.69967619e-02f, 1.78996176e-01f, -1.94724910e-02f,
  -1.41677950e-02f, 7.32677663e-03f, 2.06186250e-01f, 1.90039858e-01f, 1.54155716e-01f, 1.42874241e-01f, 2.53378823e-02f, 1.34190023e-01f, 2.12640762e-01f, -1.12966467e-02f,
  6.65078387e-02f, 9.95744839e-02f, 1.84736580e-01f, -8.02363306e-02f, 1.70280948e-01f, 9.40028653e-02f, 9.32829157e-02f, -9.38195214e-02f, 3.20385396e-02f, 1.78511456e-01f,
  8.63762349e-02f, -4.10364382e-03f, -4.77485396e-02f, -1.23064229e-02f, -5.68807311e-03f, -1.29405349e-01f, 1.65905714e-01f, 1.92364037e-01f, 1.75948516e-01f, -7.26585388e-02f,
  1.28543144e-02f, 1.83976129e-01f, -7.86283836e-02f, 3.87806408e-02f, 1.39156207e-01f, 2.28057634e-02f, -4.65457439e-01f, -5.62221371e-02f, -3.97332609e-01f, -2.10142374e-01f,
  2.82258302e-01f, -1.73213005e-01f, 3.11299860e-01f, -1.93869665e-01f, 5.89994669e-01f, 5.96013032e-02f, -3.44851494e-01f, -3.15969378e-01f, 1.38228433e-02f, -1.73337996e-01f,
  1.84916630e-01f, 2.50238121e-01f, 1.66053891e-01f, -3.97731215e-01f, 6.46905601e-02f, -4.80446704e-02f, 6.51028380e-02f, 1.08814083e-01f, 3.29718828e-01f, -8.86692330e-02f,
  -5.29810265e-02f, 1.18123487e-01f, -3.41621265e-02f, 1.48390502e-01f, -1.05011221e-02f, 2.16836959e-01f, 9.12405998e-02f, 3.29062164e-01f, 1.20873950e-01f, 1.57911330e-01f,
  8.68003292e-04f, 1.06481567e-01f, 6.34180903e-02f, 2.33857140e-01f, -1.48055017e-01f, 1.35347679e-01f, 1.18780717e-01f, -8.13939869e-02f, 2.81000465e-01f, 1.05055735e-01f,
  2.84168124e-02f, 6.65677711e-03f, -2.44779717e-02f, 1.28225744e-01f, 7.24575892e-02f, -5.91143314e-03f, 9.18649584e-02f, -3.13968724e-03f, 8.10611770e-02f, 2.70091772e-01f,
  -1.90379396e-01f, 1.29483849e-01f, 1.13267645e-01f, -2.51957983e-01f, -2.12237671e-01f, 1.39651662e-02f, 2.17026204e-01f, -1.90672092e-03f, 5.05222902e-02f, -2.20314160e-01f,
  -7.98114091e-02f, 1.29767507e-01f, 2.46642828e-01f, 3.61111432e-01f, -2.56731093e-01f, -2.23222613e-01f, -3.93119037e-01f, -3.12261850e-01f, 1.82257697e-01f, -2.46919736e-01f,
  1.47060961e-01f, -1.29238561e-01f, 1.23110443e-01f, 1.22892052e-01f, 1.73451275e-01f, -5.06580435e-02f, -3.43562275e-01f, -2.05037087e-01f, -3.10569674e-01f, 2.84157932e-01f,
  9.92838442e-02f, 3.75555712e-03f, -2.61376023e-01f, -1.31853044e-01f, 1.12110123e-01f, 3.56219672e-02f, 4.16966379e-02f, 6.15708344e-02f, 9.70528349e-02f, 8.08539242e-02f,
  6.17149137e-02f, -1.47558212e-01f, 9.45931226e-02f, 2.16512159e-01f, -2.12486446e-01f, 6.75717890e-02f, 9.41342413e-02f, -1.42275676e-01f, 7.77078494e-02f, 1.81214921e-02f,
  2.46478662e-01f, -1.46585032e-01f, 1.66023314e-01f, 1.55064315e-01f, 3.07420548e-02f, -9.13515016e-02f, -2.00438470e-01f, 4.12395410e-02f, 2.63830721e-02f, -1.55476630e-01f,
  -2.64551401e-01f, 9.10512134e-02f, 7.77746066e-02f, -1.51364163e-01f, 2.86582559e-01f, 2.46344313e-01f, 2.17409968e-01f, 2.90035605e-01f, -3.73162515e-02f, 1.23053491e-02f,
  2.19907641e-01f, -8.74225721e-02f, 2.78375268e-01f, 2.15643778e-01f, -5.02430558e-01f, -2.55672306e-01f, -3.31154495e-01f, 2.53394227e-02f, -4.41044569e-01f, -2.74959832e-01f,
  -1.53416172e-01f, -2.08786547e-01f, 3.87172461e-01f, -1.17928162e-01f, -3.58308107e-01f, -3.49534601e-01f, 6.37426376e-02f, -6.73161522e-02f, -2.49613315e-01f, 1.29362330e-01f,
  -2.01021984e-01f, -2.82262087e-01f, -6.64683655e-02f, -8.55450258e-02f, 1.28772378e-01f, 3.23157191e-01f, 4.32838142e-01f, -4.82059628e-01f, -8.49138349e-02f, -2.52930135e-01f,
  5.26304496e-03f, 1.61545768e-01f, 4.55304468e-03f, -5.72416186e-02f, 2.70772845e-01f, 2.16545895e-01f, 9.89426523e-02f, 8.75202119e-02f, 2.39981949e-01f, 3.17641199e-01f,
  1.24262959e-01f, 3.68470210e-04f, 1.75894931e-01f, 1.00308597e-01f, 2.01799303e-01f, 1.70523733e-01f, 5.12506068e-03f, 2.85952240e-01f, 2.44600382e-02f, 2.53661573e-02f,
  -7.64729753e-02f, -4.00410295e-01f, -1.28210545e-01f, 4.75493856e-02f, -2.30172724e-01f, -2.17755809e-01f, 5.36935255e-02f, -1.83973879e-01f, 1.13819607e-01f, -4.68889326e-01f,
  5.02745360e-02f, 8.62292107e-03f, 3.88855070e-01f, 2.15951819e-02f, -5.46507277e-02f, -1.41287386e-01f, -9.97497290e-02f, 1.96312159e-01f, 2.53592879e-01f, -7.61362463e-02f,
  2.59546995e-01f, -1.26027897e-01f, 4.76095034e-03f, 2.85543054e-01f, -1.79338992e-01f, 1.18906960e-01f, -2.51292855e-01f, 2.24967912e-01f, 7.18542039e-02f, 8.16077217e-02f,
  -4.05586451e-01f, 6.09295107e-02f, 6.37867898e-02f, -1.61271110e-01f, -5.22147715e-01f, 1.97080538e-01f, -2.25867733e-01f, 5.11545613e-02f, 1.26443356e-01f, -1.35875821e-01f,
  1.04878217e-01f, 1.02028221e-01f, -4.60963100e-01f, 2.05340222e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  2.15775579e-01f, 1.16361395e-01f, -2.14888481e-03f, 2.20702574e-01f, 5.17346896e-02f, 2.03959689e-01f, -6.17506392e-02f, 9.98630151e-02f, -1.87087450e-02f, 1.67781591e-01f,
  9.21281651e-02f, 1.16377987e-01f, -8.05157647e-02f, 1.67465322e-02f, 2.62081213e-02f, 1.94866285e-01f, 1.03798479e-01f, 2.95052320e-01f, 1.75748825e-01f, 5.44008911e-02f,
  1.17296062e-01f, 2.62398869e-01f, 1.95259854e-01f, 1.28250211e-01f, 9.08891037e-02f, 3.18055153e-01f
};

// L2_fan_Wp (Shape: 19 x 64)
const int L2_fan_Wp_rows = 19;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  1.88759193e-02f, -1.20486274e-01f, -1.10619590e-01f, 6.53237402e-02f, -1.62363648e-01f, 6.36409372e-02f, 4.49259691e-02f, 8.22239369e-03f, 8.96420479e-02f, 4.80271317e-02f,
  -2.92582437e-03f, -8.73528868e-02f, -1.22571118e-01f, 7.42694139e-02f, -1.05022550e-01f, -9.03233141e-02f, -2.17921808e-01f, -1.73786342e-01f, 5.04191853e-02f, 2.20545307e-01f,
  9.50616598e-02f, -1.54898927e-01f, -3.23616117e-02f, 3.61545458e-02f, -6.13905042e-02f, -1.31851688e-01f, 3.42658199e-02f, 1.08567983e-01f, -1.49952276e-02f, 2.62170825e-02f,
  -2.53448393e-02f, 1.34503141e-01f, -6.83584064e-02f, -2.98799247e-01f, 2.96198189e-01f, -7.27566108e-02f, -1.07018903e-01f, -1.07011031e-02f, -4.41754051e-02f, 1.93972796e-01f,
  -2.09992588e-01f, 1.50827542e-01f, -2.16345012e-01f, 5.72022935e-03f, 1.66459426e-01f, 2.53687710e-01f, 2.06469551e-01f, 5.01009375e-02f, 1.12664394e-01f, -1.35585651e-01f,
  -1.93679780e-01f, 2.79580444e-01f, -1.51205122e-01f, -1.51876107e-01f, 9.70946923e-02f, -1.69450253e-01f, -2.39226073e-01f, 1.48694858e-01f, -3.00884899e-02f, 9.42152292e-02f,
  1.87922254e-01f, -2.72975136e-02f, 2.76812732e-01f, 1.90767437e-01f, 7.49819577e-02f, -5.87273873e-02f, -4.09562029e-02f, -2.35804003e-02f, -2.17470285e-02f, 1.92767885e-02f,
  -6.14096271e-03f, -4.20180196e-03f, 1.53971955e-01f, 2.26651635e-02f, 7.13190287e-02f, -8.38302001e-02f, -1.09600546e-02f, -2.28775255e-02f, -1.13398492e-01f, 4.67891106e-03f,
  -1.14070877e-01f, 1.17559321e-01f, 7.04056919e-02f, 8.44391249e-03f, 2.73264259e-01f, -3.09263617e-02f, -6.66891932e-02f, 1.15350215e-02f, 2.45004445e-02f, 1.87250927e-01f,
  8.27607363e-02f, 1.65475979e-01f, 3.21094841e-02f, 5.37537187e-02f, -1.49682224e-01f, 1.25835717e-01f, 1.11793675e-01f, -2.45310485e-01f, -1.75002486e-01f, -1.59366444e-01f,
  1.53716758e-01f, 1.58772334e-01f, 5.59357703e-02f, 6.63684905e-02f, -7.84897879e-02f, -7.34133273e-02f, 5.01435734e-02f, -6.63655549e-02f, 2.37962425e-01f, -8.14332962e-02f,
  4.08658572e-02f, 4.48509827e-02f, -3.62318866e-02f, -1.04340829e-01f, 2.52438486e-01f, 5.68954609e-02f, 1.38611058e-02f, 2.10242331e-01f, -4.46876399e-02f, -2.95724859e-03f,
  -1.92293331e-01f, -4.75307517e-02f, -1.95691273e-01f, 3.17215733e-02f, 1.34329289e-01f, -3.07067260e-02f, 2.73820281e-01f, -4.50038090e-02f, 1.29519999e-01f, -3.03746480e-03f,
  9.52812806e-02f, -8.86038225e-03f, -3.18677984e-02f, 1.02842711e-01f, -7.89410025e-02f, 1.55978119e-02f, 4.42895554e-02f, 1.01644732e-01f, 1.11490220e-01f, 2.51288619e-02f,
  4.23146822e-02f, -1.62767082e-01f, 1.77180663e-01f, -1.29541010e-01f, -1.94404554e-02f, 8.96023512e-02f, -5.05277067e-02f, -5.41706719e-02f, -2.69179493e-01f, 2.41354689e-01f,
  -1.58542737e-01f, 1.37922913e-01f, 1.39189679e-02f, 2.05537006e-01f, 6.75656348e-02f, 1.42052352e-01f, 2.03201137e-02f, 6.77796230e-02f, -2.93749630e-01f, -1.54662207e-01f,
  -1.16546387e-02f, -9.45111886e-02f, -5.79065643e-02f, 2.23518605e-03f, 2.38738805e-01f, -2.92491484e-02f, 1.32743837e-02f, 7.28934724e-03f, 1.26426639e-02f, 3.79937477e-02f,
  -2.64196424e-04f, 1.83393970e-01f, -1.18727684e-01f, 3.40750776e-02f, -6.54150397e-02f, 1.14049815e-01f, -1.39619336e-01f, 9.03853178e-02f, -1.81076944e-01f, 8.64307731e-02f,
  -1.44505158e-01f, 1.58206411e-02f, -6.46886453e-02f, -2.91869938e-02f, 1.92239612e-01f, -8.67459178e-02f, -5.45320809e-02f, 1.00801766e-01f, -6.93063885e-02f, 2.54209876e-01f,
  1.88572754e-04f, -1.76654294e-01f, -3.57410014e-02f, 1.57359228e-01f, -2.67858654e-02f, 1.66458756e-01f, -5.51671498e-02f, 5.64306555e-03f, 4.75727879e-02f, 4.00870889e-02f,
  -1.00318287e-02f, -5.74964844e-02f, -6.02694713e-02f, 1.57016695e-01f, -7.85745867e-03f, -4.71202582e-02f, -6.63001928e-03f, 7.69651011e-02f, -1.77868027e-02f, 2.07495689e-02f,
  1.09709695e-01f, -1.52612217e-02f, -2.35392764e-01f, 7.91813731e-02f, -1.10009715e-01f, 2.25382559e-02f, -1.83556248e-02f, -1.08132146e-01f, -2.13228062e-01f, -6.34722933e-02f,
  1.76527515e-01f, -5.93564138e-02f, 9.57069322e-02f, -4.98419628e-02f, -4.70792465e-02f, 3.50638062e-01f, 3.14166024e-02f, 1.80400833e-01f, -1.55308679e-01f, -1.47370562e-01f,
  -8.38493481e-02f, -6.19878955e-02f, 3.19257081e-02f, 1.13143876e-01f, -1.26363099e-01f, -7.01124445e-02f, -2.52537310e-01f, -1.14631452e-01f, 1.16621934e-01f, -5.26296869e-02f,
  7.15828389e-02f, 1.43397734e-01f, -2.92671084e-01f, -9.40074325e-02f, -1.18517160e-01f, -3.53951342e-02f, 5.00282133e-03f, 1.50950298e-01f, -7.01007666e-03f, 1.00589832e-02f,
  1.11420348e-01f, -7.56549537e-02f, -1.80950016e-01f, 8.68082792e-02f, -1.27436921e-01f, 1.02491118e-01f, -1.13784953e-03f, -4.69329059e-02f, 2.73251552e-02f, -1.55517653e-01f,
  -1.34723723e-01f, -8.28012004e-02f, 1.00233465e-01f, -5.79639040e-02f, -4.20935079e-02f, -1.06715523e-01f, 4.88396324e-02f, -3.21077816e-02f, 9.85617116e-02f, -5.77983893e-02f,
  1.99401695e-02f, -2.27202833e-01f, -2.02967748e-02f, -1.51423588e-01f, -1.43486127e-01f, 2.58905023e-01f, -1.63077787e-01f, 2.28149787e-01f, -6.46141842e-02f, 1.65115237e-01f,
  -1.65507853e-01f, 6.94966316e-02f, -5.59811145e-02f, 4.19872478e-02f, -1.64648131e-01f, -1.16315506e-01f, -7.20273107e-02f, 6.96490705e-03f, -1.47338072e-02f, -1.87685385e-01f,
  1.57498538e-01f, 1.77681282e-01f, -1.78861786e-02f, -7.28802755e-02f, -7.83252493e-02f, -1.70922011e-01f, 5.31136570e-03f, -1.05188005e-01f, 1.76174529e-02f, 1.78003237e-01f,
  4.12294939e-02f, 1.53267980e-01f, 2.30647668e-01f, 9.70647857e-02f, -6.24874569e-02f, -6.41511157e-02f, 4.99679409e-02f, 1.48316711e-01f, 1.88585762e-02f, 8.35681930e-02f,
  -1.80162728e-01f, -9.56780910e-02f, 3.07117283e-01f, -8.28048512e-02f, 4.23437618e-02f, 4.80604731e-02f, -1.54340342e-01f, -1.04597524e-01f, -1.51542768e-01f, -8.85343179e-02f,
  -5.71887707e-04f, 3.78069393e-02f, -8.46628845e-03f, 2.01488361e-01f, 7.18289465e-02f, 2.43296381e-02f, 2.54416972e-01f, -3.37018864e-03f, 2.39240795e-01f, 1.55758992e-01f,
  8.38835016e-02f, 1.65319458e-01f, -3.77293490e-02f, 5.60276546e-02f, -1.26865715e-01f, 1.52498290e-01f, 2.40946524e-02f, 6.63575605e-02f, -7.57655054e-02f, 4.97397408e-02f,
  9.67669487e-02f, -2.63839394e-01f, -1.91961840e-01f, -1.73015997e-01f, 1.12173557e-01f, -1.58793226e-01f, 9.33222771e-02f, 1.49139732e-01f, 1.36684343e-01f, -3.06124389e-01f,
  5.65237664e-02f, 2.56260991e-01f, 2.35073090e-01f, -1.31930634e-01f, -1.91287398e-01f, -1.34954587e-01f, -2.92452961e-01f, -8.20508674e-02f, 8.78808126e-02f, 3.05772759e-02f,
  -1.97532266e-01f, -4.14474756e-02f, -6.84412345e-02f, 1.95463195e-01f, 1.94586869e-02f, -1.73217535e-01f, 7.78063759e-02f, -4.35550697e-02f, 1.15132198e-01f, -1.37122110e-01f,
  9.11855549e-02f, 3.28008570e-02f, -1.43801317e-01f, 1.60682842e-01f, -1.73572928e-01f, 1.15323938e-01f, 3.34000476e-02f, -1.13635838e-01f, -1.61646336e-01f, -5.99403009e-02f,
  1.48131385e-01f, -5.67484312e-02f, 2.52419233e-01f, 6.92045093e-02f, -1.27275512e-01f, 1.21637128e-01f, -6.36279508e-02f, 1.85159564e-01f, 1.60685539e-01f, 2.25960314e-01f,
  2.32567996e-01f, -6.50354922e-02f, 1.07814685e-01f, 1.79355279e-01f, 2.49901652e-01f, 5.12671806e-02f, -2.59446979e-01f, -7.83108640e-03f, -4.33273204e-02f, -1.27572492e-01f,
  -3.92969400e-02f, 1.07423447e-01f, -1.67650044e-01f, 4.42126133e-02f, -2.23416001e-01f, 9.26961452e-02f, 5.72251081e-02f, -8.54405612e-02f, -1.09346896e-01f, 1.39083071e-02f,
  -1.70804709e-01f, 2.24902064e-01f, 8.00597593e-02f, -9.99126136e-02f, 1.71574652e-01f, 7.46457875e-02f, -1.25777692e-01f, 2.51077935e-02f, 1.91280559e-01f, 5.70453666e-02f,
  -2.34043792e-01f, -7.82405362e-02f, -3.16102393e-02f, -1.17099203e-01f, -1.65371709e-02f, -9.38004851e-02f, 2.59261709e-02f, 9.24757496e-03f, -1.52538255e-01f, -3.42921279e-02f,
  4.62106355e-02f, -8.50260183e-02f, -1.99653760e-01f, 9.28820595e-02f, -6.81512058e-02f, 1.41334563e-01f, 1.22009091e-01f, 1.79122344e-01f, -4.78549525e-02f, 7.29258507e-02f,
  2.72293061e-01f, 1.40895426e-01f, 1.36938125e-01f, -7.57748336e-02f, 1.48119599e-01f, 1.88330561e-01f, -2.25962147e-01f, -1.23132542e-01f, 3.79451700e-02f, -1.17080677e-02f,
  3.59207927e-03f, -6.29173592e-02f, -1.73973814e-01f, 5.49999140e-02f, -2.14655653e-01f, -1.62748709e-01f, -8.36966261e-02f, -1.61973402e-01f, -2.39977598e-01f, 9.06154811e-02f,
  2.90700188e-03f, -1.01713873e-01f, 9.12950858e-02f, -1.43569559e-01f, -1.92407817e-01f, -1.63025618e-01f, 5.31871654e-02f, 7.84059465e-02f, 5.92534393e-02f, 1.16967395e-01f,
  2.52036065e-01f, -1.21331938e-01f, -4.81654070e-02f, -2.66380548e-01f, -7.03648403e-02f, -3.26165795e-01f, -4.89973240e-02f, -5.97285330e-02f, 2.65518218e-01f, 2.25006007e-02f,
  1.09409571e-01f, 1.82688877e-01f, 8.07647482e-02f, 1.52265623e-01f, 2.35223308e-01f, -1.22765221e-01f, -1.24283649e-01f, -8.70600790e-02f, 3.40646207e-02f, 7.42324442e-02f,
  5.63501306e-02f, -1.51835933e-01f, -9.01005641e-02f, -6.57808408e-02f, 3.31482738e-01f, -1.11514265e-02f, 5.01348302e-02f, 4.62021126e-04f, -1.19580433e-01f, -4.09408845e-02f,
  6.38985857e-02f, -3.03571695e-03f, 7.68858343e-02f, 1.98957935e-01f, -2.31430188e-01f, -9.39757563e-03f, -2.67187525e-02f, -1.40627020e-03f, -1.96003810e-01f, 5.25682308e-02f,
  6.15149662e-02f, -2.73926556e-01f, 1.08222984e-01f, 3.14831026e-02f, -1.57861173e-01f, 1.11867055e-01f, 2.90966872e-02f, -1.66869517e-02f, -8.97614956e-02f, -1.61030635e-01f,
  1.86888173e-01f, -9.25421268e-02f, -1.21062897e-01f, 5.29419109e-02f, -2.70285100e-01f, -8.29613116e-03f, 6.13641106e-02f, 5.09018712e-02f, -3.07749808e-01f, -1.04528656e-02f,
  5.43650575e-02f, -1.74339205e-01f, 2.96391040e-01f, 1.69137999e-01f, 1.36726692e-01f, -1.07311793e-01f, -4.83763739e-02f, -3.82446498e-01f, 1.51619375e-01f, 1.06014512e-01f,
  1.43776193e-01f, 1.89280838e-01f, 2.53407031e-01f, -1.90199062e-01f, -1.30169988e-01f, -1.15733787e-01f, 1.13473408e-01f, 9.18297991e-02f, 1.37690574e-01f, 1.03347190e-01f,
  4.35565338e-02f, 8.69622231e-02f, -4.32082415e-02f, 6.34800345e-02f, 2.43695691e-01f, -2.40303993e-01f, -2.42908616e-02f, 3.86353433e-02f, 2.34761328e-01f, -1.73263535e-01f,
  1.67658001e-01f, -2.46109143e-01f, -6.99174926e-02f, -1.59151759e-02f, 7.32498169e-02f, -1.23547412e-01f, 1.77740052e-01f, 2.79710516e-02f, -3.45907956e-01f, -1.12546310e-01f,
  -3.85463275e-02f, 1.66746557e-01f, 7.63293495e-03f, 2.59363592e-01f, 1.37890145e-01f, -1.74971208e-01f, 1.23319082e-01f, 1.16684407e-01f, -5.52960895e-02f, 2.40921035e-01f,
  -1.27168834e-01f, -1.82734311e-01f, 9.62447822e-02f, -1.36792094e-01f, 1.89518780e-01f, 1.98472664e-01f, 2.86289334e-01f, -3.29742171e-02f, 1.01763070e-01f, -1.12357549e-01f,
  1.48198426e-01f, -1.19620234e-01f, 3.37390229e-02f, 6.53806478e-02f, 1.63283765e-01f, 9.25177410e-02f, -2.32871398e-01f, -7.32279867e-02f, 5.80614135e-02f, -5.89139722e-02f,
  -3.71987343e-01f, -8.73555094e-02f, 7.06150979e-02f, 1.83394134e-01f, -8.76650661e-02f, 8.76655206e-02f, 2.57772416e-01f, 5.72426952e-02f, -1.56290665e-01f, -1.41911194e-01f,
  5.22190034e-02f, 1.41462833e-01f, -1.36599630e-01f, -2.68143058e-01f, -7.07246289e-02f, 5.81683144e-02f, -1.09381691e-01f, -1.85108766e-01f, -2.31867917e-02f, 5.83350770e-02f,
  -1.56486154e-01f, 1.13166064e-01f, 3.93035710e-02f, 1.85617339e-02f, -9.33263525e-02f, 1.69045120e-01f, 8.53398666e-02f, 1.00436501e-01f, -5.87658696e-02f, 8.15151632e-02f,
  -1.28830627e-01f, 1.69859692e-01f, 2.23444611e-01f, 1.76991940e-01f, -1.04301788e-01f, -6.56539500e-02f, 4.50062752e-02f, 5.13036549e-02f, 2.44233772e-01f, -7.58506283e-02f,
  -1.68257281e-02f, 1.13907307e-01f, 2.28441283e-02f, 1.17101751e-01f, -2.24482287e-02f, -1.30885035e-01f, -9.68474299e-02f, -1.39759937e-02f, -2.05046851e-02f, 8.45776498e-02f,
  -6.65756539e-02f, -4.67213579e-02f, 1.73285857e-01f, -1.42120332e-01f, 1.30485907e-01f, 6.66497946e-02f, 2.23563984e-01f, 1.78725094e-01f, 1.86252832e-01f, 8.17364752e-02f,
  4.06929292e-03f, 1.14040278e-01f, -1.19856909e-01f, -1.68734286e-02f, 8.98789540e-02f, 1.27485529e-01f, -3.62801889e-04f, 1.83478355e-01f, -2.06081793e-02f, 1.56381249e-01f,
  1.79857276e-02f, -3.22455429e-02f, -2.29516208e-01f, 1.19005144e-01f, 2.14108840e-01f, 8.29422995e-02f, 1.24663681e-01f, 1.21874675e-01f, 7.56731350e-03f, -1.60517409e-01f,
  2.42291898e-01f, 1.20107383e-01f, 4.65658717e-02f, -1.75864175e-01f, -3.15852724e-02f, -8.16678181e-02f, -1.34239540e-01f, 7.30616376e-02f, 2.43127649e-03f, 2.49429606e-02f,
  -1.03285350e-01f, -2.47292951e-01f, 1.33260936e-01f, -1.18260667e-01f, 9.77687836e-02f, -1.13074690e-01f, -1.66789219e-01f, 1.78203285e-01f, 5.78778908e-02f, 1.24852538e-01f,
  -3.32902253e-01f, 8.64163414e-03f, -5.86893689e-03f, -3.20653543e-02f, -1.25037253e-01f, -2.48179138e-01f, -1.52542293e-01f, -4.60679755e-02f, 1.13031499e-01f, 2.11394951e-01f,
  1.69023409e-01f, -4.20796163e-02f, -2.31861711e-01f, -1.39451563e-01f, -1.60277978e-01f, -1.80950567e-01f, -1.88369662e-01f, -1.88265331e-02f, -2.25481205e-02f, -1.49858549e-01f,
  -7.00628087e-02f, -6.71364740e-02f, -1.44580677e-01f, -7.33437613e-02f, 5.94093055e-02f, -1.45693868e-01f, -5.50157987e-02f, -2.72248656e-01f, -2.21766278e-01f, 6.03558868e-02f,
  5.44955134e-02f, -2.32264340e-01f, -5.31417131e-02f, -2.46685475e-01f, -2.53700882e-01f, 1.97254226e-01f, 2.57469956e-02f, -2.77428418e-01f, 2.10345104e-01f, -7.12477565e-02f,
  -1.47196800e-01f, 4.00999859e-02f, -1.15297735e-01f, -7.25862682e-02f, 1.02637755e-02f, 1.21554032e-01f, -9.72014964e-02f, 3.27998884e-02f, 2.13475779e-01f, 8.21751133e-02f,
  1.51777625e-01f, -9.53225493e-02f, 2.12400705e-01f, -1.60042942e-02f, 1.99238881e-01f, 1.13440253e-01f, -9.81950462e-02f, -1.09774964e-02f, -2.78378706e-02f, 1.19241871e-01f,
  -5.23482375e-02f, -1.07656971e-01f, -1.43388465e-01f, 9.99909863e-02f, -1.08763255e-01f, 3.93710062e-02f, -6.58583343e-02f, -6.46917615e-03f, 1.58995256e-01f, 4.27843481e-02f,
  -8.55363235e-02f, 4.51989956e-02f, -1.71296820e-01f, -2.25561708e-02f, 3.24106850e-02f, -1.55645302e-02f, 2.50065655e-01f, 5.04032150e-02f, 8.69802162e-02f, -1.46471322e-01f,
  -1.55783132e-01f, -9.61210728e-02f, -6.85507730e-02f, -8.88905823e-02f, -1.15082018e-01f, -1.07743777e-01f, -2.77136993e-02f, 1.82922199e-01f, -8.33834559e-02f, 1.65778086e-01f,
  -3.55663449e-02f, 2.77378947e-01f, -2.23095104e-01f, 8.22640210e-02f, -9.93930101e-02f, 4.17594641e-01f, 7.04880506e-02f, 7.60496780e-02f, 4.07592691e-02f, -2.09331125e-01f,
  -1.65994748e-01f, -1.59310490e-01f, 5.57344519e-02f, 8.86045024e-02f, 6.93225339e-02f, -1.04804419e-01f, 1.24304473e-01f, -8.21004901e-03f, -1.23317182e-01f, -1.21623337e-01f,
  -3.15502770e-02f, -4.44757529e-02f, -1.37393802e-01f, 1.78526685e-01f, 2.95984037e-02f, 1.33465573e-01f, -6.36048689e-02f, 9.59857479e-02f, -2.91589975e-01f, 2.09021512e-02f,
  3.29693891e-02f, -1.40744656e-01f, 1.08888127e-01f, -1.77235603e-01f, -6.79979753e-03f, 1.44557193e-01f, 7.72691295e-02f, 5.57419695e-02f, -1.53528467e-01f, -1.77188981e-02f,
  -5.05967215e-02f, 2.68707164e-02f, -2.77767070e-02f, -3.26645523e-01f, 7.32804239e-02f, -1.49420455e-01f, -2.05710605e-01f, -4.22804132e-02f, 5.56140989e-02f, -8.01042691e-02f,
  -1.26091421e-01f, 3.62795368e-02f, -1.75338119e-01f, -1.06154107e-01f, 1.23319961e-01f, -6.24112412e-02f, 4.10564467e-02f, -1.17560342e-01f, 1.16721787e-01f, -5.92908822e-02f,
  4.00317013e-02f, -4.02360372e-02f, -2.64605302e-02f, -1.06590398e-01f, -4.60786521e-02f, 1.78430706e-01f, -2.79866736e-02f, 2.12503448e-01f, -1.91551462e-01f, -2.88988426e-02f,
  -1.42208874e-01f, 5.98897319e-03f, 1.11502968e-02f, 1.84148237e-01f, -1.68993592e-01f, -2.09947377e-02f, -4.73184977e-03f, -2.85047770e-01f, -2.33942326e-02f, -5.57683408e-03f,
  2.32547998e-01f, -8.80256146e-02f, 1.16398819e-01f, 1.92379311e-01f, -9.68389586e-02f, -4.43315879e-02f, 9.12937745e-02f, -6.21083286e-03f, -6.05479330e-02f, 1.19393460e-01f,
  2.72032935e-02f, -4.69873920e-02f, 1.42765984e-01f, -3.80038917e-02f, 2.23391816e-01f, 3.46857384e-02f, -1.61757529e-01f, -1.60818487e-01f, -2.84744650e-01f, 7.88724143e-03f,
  -1.33077335e-02f, -1.00467846e-01f, -2.29632884e-01f, -1.83313981e-01f, -1.36900291e-01f, 2.01703995e-01f, 9.15194899e-02f, -7.51148909e-02f, -6.67403545e-03f, -9.86124575e-02f,
  8.03111792e-02f, -3.93084809e-02f, -1.09610848e-01f, -3.03607173e-02f, 4.32922654e-02f, 1.64606974e-01f, -6.04605414e-02f, 1.74540803e-01f, -2.47011166e-02f, -5.38528636e-02f,
  1.25562742e-01f, -9.76964161e-02f, 1.34572834e-01f, 6.91385567e-02f, 9.24555510e-02f, 1.62402466e-01f, 1.27396509e-01f, 1.66409671e-01f, 8.94124135e-02f, -1.19580124e-02f,
  2.36921787e-01f, -1.70448184e-01f, 2.73343652e-01f, 8.04524943e-02f, -2.44283546e-02f, 7.37712858e-03f, -2.10772410e-01f, -1.56965345e-01f, -7.75175467e-02f, 1.60140023e-02f,
  -5.27671762e-02f, 1.45627096e-01f, -3.82927433e-02f, -5.89230023e-02f, -3.93074937e-03f, 1.36567801e-01f, 2.85995658e-03f, 9.52555090e-02f, 5.57212271e-02f, 1.50231197e-01f,
  -1.46166101e-01f, -1.60307437e-01f, 1.26154393e-01f, -6.93596601e-02f, -1.87865406e-01f, -7.49128684e-02f, -2.37579385e-04f, -6.60700724e-02f, -1.87285766e-01f, -1.11454073e-02f,
  -1.13633834e-01f, -1.50134966e-01f, 5.09876423e-02f, -5.05482107e-02f, -3.03024560e-01f, 5.48054501e-02f, -9.24885795e-02f, 3.46081793e-01f, 2.02135406e-02f, -8.84437338e-02f,
  -1.40415683e-01f, -2.10516322e-02f, -7.47231990e-02f, 1.39845893e-01f, 5.49649522e-02f, -1.78752571e-01f, 2.27840573e-01f, 2.67567746e-02f, 1.55836850e-01f, 7.15431795e-02f,
  -2.43059784e-01f, 1.31558850e-01f, -1.84677020e-01f, 9.33483185e-04f, -1.03780977e-01f, 9.66173932e-02f, 5.30515471e-03f, 1.34040087e-01f, -4.39153798e-02f, -3.58084887e-02f,
  -1.62595183e-01f, -8.17962959e-02f, -1.08880445e-01f, -1.98934868e-01f, 2.53599435e-02f, -2.12785065e-01f, -9.48789790e-02f, 2.28875265e-01f, -5.20076193e-02f, -9.46658775e-02f,
  3.75059457e-03f, 7.14619085e-02f, -1.75085038e-01f, 8.28672387e-03f, -9.62547138e-02f, 1.82496533e-02f, -2.23425880e-01f, -2.00990424e-01f, 5.61570600e-02f, 3.02502751e-01f,
  -7.75586218e-02f, 4.55714986e-02f, 7.94645306e-03f, 1.82710856e-01f, -1.53826460e-01f, -1.51464701e-01f, -9.68563631e-02f, 9.19279736e-03f, 1.60306424e-01f, -5.47715165e-02f,
  -2.15044498e-01f, 1.25745639e-01f, -2.99641881e-02f, -1.15994535e-01f, 1.39253782e-02f, -2.48564295e-02f, 1.17358163e-01f, 7.09380731e-02f, -4.27464321e-02f, -1.14198312e-01f,
  -2.84108479e-04f, 2.58796811e-01f, 2.09570467e-01f, 2.63438612e-01f, -3.84095237e-02f, -9.79315192e-02f, -5.53238466e-02f, 2.25800765e-03f, -1.83698479e-02f, -1.04110621e-01f,
  1.30176425e-01f, -5.36407642e-02f, 1.23117127e-01f, -6.44513741e-02f, -1.44494399e-01f, 9.71610695e-02f, -1.13653302e-01f, -9.06344429e-02f, -1.38268664e-01f, 5.76345958e-02f,
  -2.08733797e-01f, 8.22492465e-02f, -2.30709855e-02f, 2.88778208e-02f, 1.51170164e-01f, -3.57072264e-01f, 1.49122685e-01f, -2.39556551e-01f, 4.85948734e-02f, -1.51746228e-01f,
  1.93512574e-01f, -5.77448728e-03f, 5.06054275e-02f, -1.24216881e-02f, -3.20101343e-02f, 1.93403155e-01f, 1.20338783e-01f, -1.69018686e-01f, 5.72783931e-04f, -1.42503485e-01f,
  -1.47707239e-01f, 1.10809237e-01f, 1.41168788e-01f, 1.34489834e-01f, 1.65052544e-02f, 2.00112816e-02f, 1.13929987e-01f, -7.31066242e-02f, 2.40719110e-01f, -7.73169845e-02f,
  -1.24350116e-02f, -6.77915383e-03f, 1.24040850e-01f, -1.53333351e-01f, 1.37827188e-01f, 7.84157738e-02f, -7.32424110e-02f, 1.02799840e-01f, -1.44201413e-01f, -2.66153775e-02f,
  -1.16527796e-01f, -1.26937196e-01f, -1.71885788e-01f, -3.81775722e-02f, 8.59312117e-02f, 1.65609300e-01f, 1.39351010e-01f, 1.83054030e-01f, -4.07410040e-02f, 4.10448276e-02f,
  4.61379699e-02f, -1.32203400e-01f, -6.91487715e-02f, -2.86916763e-01f, -4.54182737e-02f, -1.47273347e-01f, -2.65875496e-02f, 6.74472526e-02f, -5.67480773e-02f, 1.56828581e-04f,
  1.43482596e-01f, 2.45731231e-02f, -8.04907084e-02f, -1.61827670e-03f, -1.14377610e-01f, -1.03610106e-01f, 1.11454763e-02f, 1.93733767e-01f, -8.43220577e-02f, 4.89498638e-02f,
  9.20897201e-02f, 1.33820459e-01f, -9.43786278e-02f, 1.07266925e-01f, -6.53392673e-02f, 3.13330412e-01f, -1.55189440e-01f, 1.71425864e-02f, -1.48761749e-01f, -1.67878345e-01f,
  -2.31385916e-01f, -2.05624044e-01f, -1.80450007e-01f, -6.29365221e-02f, 1.44413831e-02f, -1.29193440e-01f, 1.39324814e-01f, -2.24400222e-01f, -8.01256523e-02f, 1.78586066e-01f,
  4.68918355e-04f, 2.02421740e-01f, 2.58887019e-02f, 1.30395398e-01f, 1.25994638e-01f, 1.72589526e-01f, -1.55133814e-01f, 1.78955253e-02f, -8.00247490e-02f, -1.17627166e-01f,
  -1.49578191e-04f, -1.52074575e-01f, -1.01843715e-01f, -1.69561967e-01f, -6.37767315e-02f, 1.18883550e-01f, -2.13995397e-01f, -9.65709090e-02f, -1.27990767e-01f, -2.17406884e-01f,
  -1.21516898e-01f, 2.61405945e-01f, -3.58190089e-02f, 4.88044173e-02f, 9.54683463e-04f, -3.83241288e-02f, -1.04195908e-01f, 2.58782282e-02f, -3.08867674e-02f, 8.23435485e-02f,
  1.16091281e-01f, -1.01876125e-01f, -5.86452447e-02f, -2.47229394e-02f, 9.29000750e-02f, 4.26959023e-02f, -6.82346290e-05f, 1.77215829e-01f, 1.77583005e-02f, -5.72968051e-02f,
  5.46141341e-02f, -1.46699175e-01f, 3.36558789e-01f, -6.57650530e-02f, -8.91619176e-02f, -9.59211122e-03f, 1.23930559e-01f, -2.46839076e-02f, 4.57643829e-02f, -2.67177552e-01f,
  -4.32967916e-02f, 7.12909997e-02f, 1.23812206e-01f, 3.92651297e-02f, 1.53377920e-01f, 9.83641371e-02f, -7.57675692e-02f, 1.43139353e-02f, 3.22440773e-01f, 1.51179373e-01f,
  4.40466031e-02f, 2.35342264e-01f, -3.30246948e-02f, 9.17216167e-02f, -8.68923143e-02f, -1.82887986e-01f, 5.75776808e-02f, -6.88509420e-02f, 1.38122262e-02f, -1.20483592e-01f,
  1.13568231e-01f, -1.62787020e-01f, -1.38162058e-02f, -2.32843682e-01f, 3.62380110e-02f, -3.68623994e-02f, 2.01881468e-01f, 7.28676766e-02f, 7.57934302e-02f, -3.48695181e-03f,
  3.71930785e-02f, 6.14813901e-03f, 5.86672463e-02f, -3.60099137e-01f, 4.11589622e-01f, 1.03232056e-01f
};

// L2_fan_Wp_bar (Shape: 26 x 64)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  1.13273293e-01f, 1.99850753e-01f, 1.11089580e-01f, 3.40181589e-02f, -2.24330336e-01f, -1.32502735e-01f, -4.39477265e-02f, 2.25533500e-01f, -7.28840306e-02f, -4.22859602e-02f,
  3.11223477e-01f, 1.54544888e-02f, 1.57583013e-01f, -3.30778241e-01f, 1.88419029e-01f, -2.80975759e-01f, -5.79388216e-02f, -1.61704645e-01f, 9.48626921e-02f, 1.31691977e-01f,
  -3.78110595e-02f, 2.44295239e-01f, 1.94689706e-01f, 2.39549652e-02f, -9.46264267e-02f, -1.57483459e-01f, 2.44302489e-02f, -5.12015522e-01f, -4.91438687e-01f, 1.27391517e-01f,
  -2.59875488e-02f, -1.60332009e-01f, 2.48559877e-01f, -1.37270674e-01f, 2.27730751e-01f, 1.01547830e-01f, 1.02204889e-01f, -3.18636268e-01f, -2.49294452e-02f, 1.54024646e-01f,
  -9.25838854e-03f, 1.76743090e-01f, 3.36395167e-02f, 2.12158650e-01f, -1.73451126e-01f, 3.08894575e-01f, 3.07278574e-01f, 2.61410922e-01f, 2.83964425e-01f, 1.05711803e-01f,
  -1.82259068e-01f, 1.12455867e-01f, 1.57259524e-01f, 2.51709074e-01f, -8.37214440e-02f, 3.29177767e-01f, 4.47233588e-01f, 1.34905055e-01f, -4.51769941e-02f, 2.17493311e-01f,
  -2.47223116e-02f, -2.01836661e-01f, 3.32231075e-01f, 3.78918946e-02f, -4.53061387e-02f, -3.48615274e-03f, 3.72944474e-02f, -1.42445758e-01f, 2.98888963e-02f, 3.69808823e-01f,
  -2.49362774e-02f, 2.20971078e-01f, -1.96694776e-01f, -3.30097117e-02f, -4.03296947e-02f, 6.23321310e-02f, -2.63202548e-01f, 6.45158216e-02f, 2.95819137e-02f, 8.36001858e-02f,
  7.20812678e-02f, 7.04655573e-02f, -2.01959804e-01f, -7.37191513e-02f, -1.73240513e-01f, 2.39304066e-01f, -4.36467271e-05f, 1.77456364e-01f, 5.44496477e-02f, 2.72396535e-01f,
  -8.12910870e-02f, -1.57975271e-01f, -4.16927524e-02f, 1.34685099e-01f, 2.55097952e-02f, -3.03695112e-01f, 1.00025937e-01f, 3.83173853e-01f, 1.47291765e-01f, 1.39358521e-01f,
  3.27306718e-01f, 2.61038691e-01f, 8.17086473e-02f, -2.87104338e-01f, 3.02968204e-01f, 1.00468978e-01f, 3.79126102e-01f, -1.17140859e-01f, 1.82069317e-02f, 2.40789384e-01f,
  1.14683300e-01f, 1.13423854e-01f, -1.27737805e-01f, 1.06086083e-01f, 1.14124194e-01f, 4.92849573e-02f, 3.21293294e-01f, 1.79079995e-01f, 2.87038624e-01f, 4.78721969e-02f,
  -1.75915748e-01f, 1.90441445e-01f, 2.22381413e-01f, 4.20871019e-01f, -4.91584167e-02f, 8.28730017e-02f, -4.43145871e-01f, -3.11935037e-01f, 9.77851450e-02f, 1.84426650e-01f,
  6.43598214e-02f, 5.88531680e-02f, 2.44100288e-01f, -4.36794050e-02f, 2.05534324e-01f, 1.77329909e-02f, 1.88451812e-01f, 2.70097405e-01f, 2.10312411e-01f, -2.63372511e-02f,
  -4.74497490e-02f, 2.49419242e-01f, 8.80424157e-02f, 2.38546401e-01f, 2.89792389e-01f, 2.77015567e-01f, 2.84151703e-01f, -2.10698247e-01f, 9.57838669e-02f, -1.37854427e-01f,
  -3.49025905e-01f, -1.59512237e-02f, 2.94014603e-01f, 2.17379928e-01f, -3.25364359e-02f, -1.91240966e-01f, 1.42271563e-01f, 1.04085803e-01f, 1.71936274e-01f, -2.55851686e-01f,
  2.69960940e-01f, 3.96833330e-01f, -2.87300557e-01f, 1.10684685e-01f, -9.14622173e-02f, 5.27415752e-01f, 1.72675163e-01f, -1.89874828e-01f, 6.31484613e-02f, -3.21323246e-01f,
  2.61982530e-01f, 2.27003962e-01f, 1.19765721e-01f, -1.69094075e-02f, -2.65112042e-01f, 6.50780648e-02f, -1.60575092e-01f, 3.13335285e-02f, 1.55696601e-01f, 4.11571972e-02f,
  -2.05502398e-02f, 1.89677805e-01f, 5.66508695e-02f, 6.31631613e-02f, 3.82983685e-01f, -1.71369076e-01f, -5.89283109e-02f, -4.88880761e-02f, 2.85766631e-01f, -3.70556600e-02f,
  1.36602759e-01f, 2.98516881e-02f, 3.02631438e-01f, 1.08384408e-01f, 7.23248273e-02f, 1.08719636e-02f, 1.79408520e-01f, 1.02489069e-01f, -1.75571144e-01f, 7.09055215e-02f,
  1.41583011e-01f, 9.48543102e-02f, -2.26818532e-01f, 8.80198702e-02f, -3.77358980e-02f, -6.18856102e-02f, 4.47656959e-02f, -7.97147155e-02f, 8.13070238e-02f, -2.54634712e-02f,
  9.61785689e-02f, -1.46673232e-01f, 2.01778978e-01f, 2.79417217e-01f, -1.70002550e-01f, -1.59691110e-01f, -6.31900057e-02f, -1.34106487e-01f, 3.47552270e-01f, 2.10972026e-01f,
  1.23470828e-01f, 7.58886859e-02f, -2.78670490e-01f, -2.71153659e-01f, -2.55083680e-01f, -1.17190287e-01f, -6.23825043e-02f, -1.42038599e-01f, 3.20625097e-01f, 1.57091173e-03f,
  7.09974440e-03f, 1.17663339e-01f, 1.12717859e-01f, 2.13465422e-01f, 2.23281175e-01f, -2.04067171e-01f, 2.48497240e-02f, -7.02517806e-03f, -1.03527628e-01f, 1.46781595e-03f,
  -1.31913677e-01f, -1.24243028e-01f, -3.71366106e-02f, -2.45947346e-01f, -2.78085977e-01f, -2.26892278e-01f, 2.03322202e-01f, -1.82141408e-01f, -3.43654335e-01f, 6.66819513e-02f,
  -2.22364277e-01f, 2.43154570e-01f, -1.72807723e-01f, 1.87033564e-01f, -3.69923525e-02f, 1.29485294e-01f, 2.30028555e-01f, 1.22191347e-01f, 1.04780965e-01f, 1.73491254e-01f,
  1.05051219e-01f, 3.67643476e-01f, 3.06433946e-01f, 8.84414464e-02f, 1.37975037e-01f, 2.83080310e-01f, 3.01415950e-01f, 1.59059063e-01f, 3.07378508e-02f, 6.95460662e-02f,
  1.61715150e-01f, 7.24795833e-02f, 3.69767964e-01f, 1.40853554e-01f, -6.67546466e-02f, 1.76697955e-01f, 2.36802563e-01f, 9.39380750e-02f, -2.01893330e-01f, -1.40281022e-01f,
  2.31457815e-01f, -1.91110119e-01f, 2.47002721e-01f, 3.87843966e-01f, 2.13061739e-02f, 2.06601806e-02f, -1.40891910e-01f, -2.90629238e-01f, 2.55245954e-01f, -2.26940632e-01f,
  -2.29325593e-02f, 8.47830027e-02f, -8.64034966e-02f, 1.01977743e-01f, 1.99226066e-01f, 3.74591142e-01f, -6.51986152e-02f, -2.36102894e-01f, 1.28000244e-01f, 2.39847913e-01f,
  -1.00243278e-01f, -6.23108409e-02f, -1.46616220e-01f, -7.62061402e-02f, -2.65063822e-01f, -6.24728836e-02f, 1.08355381e-01f, 1.78600281e-01f, 3.29199463e-01f, 4.00790423e-01f,
  -7.91603699e-02f, -1.82959810e-01f, 5.50892174e-01f, -7.70984292e-02f, -1.43485487e-01f, 9.58693698e-02f, 2.61953235e-01f, 2.50175327e-01f, 2.57765502e-01f, 1.20358476e-02f,
  -7.17653707e-02f, -1.70441806e-01f, 3.44479233e-02f, -9.89674255e-02f, -2.56988168e-01f, -5.95551319e-02f, -3.47500980e-01f, 1.79753918e-02f, -2.16345593e-01f, -2.30256438e-01f,
  1.88485309e-01f, -1.33615106e-01f, 3.63747150e-01f, -3.40114683e-01f, -1.30396765e-02f, -4.27641928e-01f, 1.10952824e-01f, -5.59669593e-03f, -3.54004316e-02f, 2.12083355e-01f,
  6.86100498e-02f, 3.07049286e-02f, 4.65723395e-01f, -5.73914172e-03f, -1.29706293e-01f, 7.16367215e-02f, -1.46421775e-01f, -1.37878790e-01f, -3.42028111e-01f, 1.91397041e-01f,
  -1.57294244e-01f, -8.04951414e-02f, -1.20155588e-02f, -2.50221103e-01f, 3.31563979e-01f, -2.22186923e-01f, -3.25320810e-02f, -3.58678132e-01f, 7.72754997e-02f, 1.34015545e-01f,
  1.65768370e-01f, 1.56902164e-01f, 2.16370448e-02f, 1.65580735e-01f, 1.65216401e-02f, 2.68366754e-01f, 2.14774996e-01f, 1.56480536e-01f, 1.59291849e-01f, 1.51451305e-01f,
  3.91162820e-02f, 2.38939375e-01f, 1.90449253e-01f, 3.12008619e-01f, -1.85805008e-01f, 1.56010777e-01f, 9.21801478e-02f, 1.81640983e-01f, 8.42914060e-02f, 2.12072089e-01f,
  -1.81869984e-01f, -1.57805547e-01f, -1.70365557e-01f, -5.86121455e-02f, -3.71607952e-02f, -1.00328580e-01f, -1.82059243e-01f, -1.60978377e-01f, 7.47616291e-02f, -2.38217756e-01f,
  -9.76553932e-02f, 8.83781165e-03f, -1.76575735e-01f, 5.05091809e-02f, 6.08268194e-02f, -6.44133314e-02f, -1.04084983e-01f, 1.46607280e-01f, 1.11581981e-01f, 3.24036516e-02f,
  1.96594179e-01f, 9.29743052e-03f, 2.62210995e-01f, 7.81216696e-02f, 2.59014189e-01f, 6.30502403e-02f, -7.95612186e-02f, -1.13600209e-01f, -5.62637560e-02f, 1.37031287e-01f,
  2.23219320e-01f, 9.45963860e-02f, 3.44194635e-03f, 3.51949573e-01f, 1.67790148e-02f, -5.11699170e-02f, -2.76071668e-01f, 8.60935003e-02f, -2.27716938e-02f, -2.83413529e-02f,
  9.02200565e-02f, 2.09336326e-01f, 2.81396091e-01f, 2.76265085e-01f, 3.54599729e-02f, 5.12221828e-02f, 2.00320154e-01f, -1.64498299e-01f, 3.11779410e-01f, -5.11072623e-03f,
  -1.13902651e-01f, -4.68417704e-02f, -1.29368424e-01f, -6.36187056e-03f, 2.29125947e-01f, -1.43665150e-01f, 6.08953312e-02f, -3.18290234e-01f, 3.00888211e-01f, -1.32098809e-01f,
  -1.30659103e-01f, 1.51053891e-01f, 6.71003610e-02f, 2.49218971e-01f, 2.02352658e-01f, 8.16406831e-02f, 7.17301890e-02f, 6.54024705e-02f, 9.90520045e-02f, -1.46349473e-02f,
  -4.82723601e-02f, -1.44675627e-01f, 1.00150011e-01f, -6.22992180e-02f, -6.16527312e-02f, -1.11932293e-01f, -5.05660027e-02f, 9.66004804e-02f, -1.26479715e-01f, 1.58885598e-01f,
  -8.22316632e-02f, 4.97471765e-02f, 2.94668406e-01f, -1.41050667e-01f, 2.15122029e-01f, 9.85169131e-03f, -4.81496081e-02f, -2.96374977e-01f, -1.12582073e-01f, 2.65006065e-01f,
  -1.61620051e-01f, -1.49484366e-01f, -8.06621239e-02f, -8.96016061e-02f, 3.86853367e-01f, -8.70860997e-04f, 1.51082560e-01f, 3.73063177e-01f, -6.95029199e-02f, -1.70087516e-01f,
  -2.18442038e-01f, 3.87144312e-02f, 1.00017972e-01f, 1.99392408e-01f, 1.88993141e-01f, 1.61031008e-01f, 1.83270186e-01f, 2.88755804e-01f, 2.53878534e-01f, 2.45195270e-01f,
  2.28395537e-01f, -1.02748506e-01f, -1.20245283e-02f, -1.62471592e-01f, 1.01120457e-01f, -2.26485550e-01f, -1.05036229e-01f, -2.04486009e-02f, 1.63681716e-01f, -1.25865281e-01f,
  -2.31751904e-01f, -3.71475935e-01f, 3.79314013e-02f, -2.10441388e-02f, -2.39392053e-02f, 1.32646218e-01f, -3.80071372e-01f, 1.14923999e-01f, 6.49066865e-02f, 4.02503312e-01f,
  6.58745840e-02f, -3.10481191e-01f, 1.31463856e-01f, 7.12812021e-02f, -4.55505997e-02f, -1.13072917e-01f, 1.04671352e-01f, -3.52724910e-01f, 1.94584224e-02f, -5.55063859e-02f,
  2.77218083e-03f, 1.70556396e-01f, 4.14288379e-02f, -8.46407786e-02f, 2.03460827e-02f, -5.00824116e-02f, 2.65391201e-01f, 1.36598736e-01f, 1.03110872e-01f, 1.12715364e-01f,
  1.64012432e-01f, -2.83902287e-01f, 2.61334591e-02f, 3.19767743e-02f, -2.50230044e-01f, -3.99491265e-02f, -1.54180899e-01f, -1.02462128e-01f, 2.54230946e-01f, -2.39021815e-02f,
  3.28513831e-01f, 3.25505137e-01f, -4.46837842e-02f, -6.98174462e-02f, -1.44765317e-01f, 1.28951252e-01f, -1.30478486e-01f, -3.18372734e-02f, 1.53164968e-01f, 1.66665271e-01f,
  6.73950613e-02f, 2.17671409e-01f, 1.52580082e-01f, 1.76440075e-01f, 3.45910415e-02f, -1.44315556e-01f, 9.53188837e-02f, 3.28499302e-02f, -1.27547622e-01f, 6.38677850e-02f,
  -1.30874828e-01f, 4.23839726e-02f, 6.63572997e-02f, -5.13039082e-02f, -1.97611839e-01f, -3.63888085e-01f, 1.77177593e-01f, -1.58511296e-01f, -2.45257951e-02f, 2.60477006e-01f,
  -1.85507778e-02f, 1.22093581e-01f, 2.10460469e-01f, 1.72644868e-01f, 2.15370283e-01f, -8.94752666e-02f, -5.37451357e-03f, -1.63362604e-02f, -3.69605306e-03f, 1.52598664e-01f,
  -3.29805687e-02f, -1.94545284e-01f, 1.58675551e-01f, 2.13422567e-01f, -3.78251560e-02f, 6.96598068e-02f, -2.91294128e-01f, -1.28440723e-01f, 5.04451811e-01f, 8.35742685e-04f,
  -8.25327006e-04f, 1.92615524e-01f, 2.19717905e-01f, -1.25031069e-01f, 6.34359494e-02f, 4.27253217e-01f, -8.26786608e-02f, 1.44784570e-01f, 1.49014488e-01f, 1.97757795e-01f,
  -1.99375570e-01f, 5.55860065e-02f, -5.67370355e-02f, -2.22825911e-02f, -2.19183579e-01f, 2.80702114e-01f, -2.23474398e-01f, 1.68477133e-01f, -1.37227550e-01f, 1.33446194e-02f,
  2.66705453e-01f, -2.11468831e-01f, -1.75842077e-01f, -2.90082783e-01f, 1.77771494e-01f, 1.80627838e-01f, 1.55531257e-01f, 4.25743192e-01f, -1.49377972e-01f, 5.92285693e-02f,
  -2.19294131e-01f, 3.24076355e-01f, -1.76663980e-01f, 2.22154275e-01f, 8.56490210e-02f, 1.99792162e-01f, -1.29475668e-01f, -2.35503837e-01f, 8.81528333e-02f, -1.85097575e-01f,
  2.67175794e-01f, 3.68363187e-02f, -1.07083857e-01f, 1.95893720e-01f, 1.68016359e-01f, 2.70473272e-01f, -5.13669789e-01f, -2.18641654e-01f, -3.01489592e-01f, 4.55473006e-01f,
  -1.52525932e-01f, -1.43370032e-01f, 4.43890423e-01f, -1.28524780e-01f, -2.26209790e-01f, -1.42463207e-01f, 4.63785902e-02f, 3.29568349e-02f, -2.16059372e-01f, 2.83621252e-02f,
  -2.54659235e-01f, 2.52268352e-02f, 3.61948043e-01f, 6.03330880e-02f, 7.13002980e-02f, 1.83407277e-01f, 2.01658264e-01f, -1.38700949e-02f, -7.68803954e-02f, -3.64390835e-02f,
  -2.64877349e-01f, -1.42063247e-02f, 5.96983321e-02f, 1.19486436e-01f, -3.63319889e-02f, 4.20656919e-01f, -2.95843154e-01f, -2.21047625e-01f, -2.08820850e-01f, -6.91355318e-02f,
  -2.63986379e-01f, 1.20115802e-01f, -1.79071620e-01f, 8.51285681e-02f, -3.29947658e-02f, -3.16319555e-01f, -3.86311933e-02f, -1.96185447e-02f, 2.51127869e-01f, 1.10226143e-02f,
  1.84525535e-01f, 4.51309085e-01f, 6.74370024e-03f, 2.17817307e-01f, 9.31522101e-02f, 2.23028958e-01f, -1.39702350e-01f, 1.42466128e-01f, 1.70169622e-01f, 1.87182695e-01f,
  3.24090809e-01f, 2.13702232e-01f, 1.16297610e-01f, 5.07025011e-02f, -7.69338831e-02f, -1.45586371e-01f, -7.36676082e-02f, 2.05349876e-03f, 9.31781232e-02f, 1.74829941e-02f,
  -2.06595346e-01f, -3.23981375e-01f, -4.28285748e-01f, 2.81771809e-01f, 9.89550874e-02f, 1.99967772e-02f, 2.15410694e-01f, 1.20197594e-01f, 1.24491192e-01f, -1.08853579e-01f,
  1.88293800e-01f, 6.09220043e-02f, -8.85061920e-02f, 2.74925195e-02f, -3.58605325e-01f, 4.85093556e-02f, 2.67992258e-01f, 1.62272587e-01f, 5.99237420e-02f, 2.79035538e-01f,
  1.50758594e-01f, 1.02405526e-01f, 9.51466560e-02f, 5.29025085e-02f, 3.91079485e-01f, -6.09936193e-02f, 5.39798662e-02f, -5.38695902e-02f, 2.84902871e-01f, -2.04789504e-01f,
  1.49600074e-01f, 1.09941736e-02f, 1.34912848e-01f, -6.31362423e-02f, -3.99173498e-01f, 1.08860411e-01f, -3.89903374e-02f, -9.09695923e-02f, -2.80992389e-01f, -3.03521067e-01f,
  -3.38303834e-01f, -1.08535103e-01f, -3.74045372e-02f, 4.09247488e-01f, -2.09590152e-01f, 4.59775478e-01f, -1.26085384e-02f, 1.19994983e-01f, -3.66967022e-02f, -1.00627832e-01f,
  -3.25128168e-01f, -1.51794091e-01f, 2.13194296e-01f, -2.69583166e-01f, 1.73423693e-01f, -8.73621181e-02f, -3.76125813e-01f, -9.18999985e-02f, 7.01970086e-02f, 7.68072344e-03f,
  -1.74726635e-01f, 9.86660495e-02f, -2.03277722e-01f, -3.56403440e-02f, -1.20005831e-01f, 1.38055414e-01f, 1.80041462e-01f, 5.61333537e-01f, -8.67414996e-02f, -1.55970603e-01f,
  1.40571937e-01f, -1.19719394e-01f, 2.09983766e-01f, -3.91881950e-02f, 3.07785179e-02f, -2.68344674e-02f, -8.74892846e-02f, -4.70899977e-02f, -1.49639010e-01f, 5.04044704e-02f,
  -4.58043292e-02f, 1.06042273e-01f, 1.55559614e-01f, 2.65714228e-01f, 2.16708690e-01f, 1.37929067e-01f, 1.52363442e-02f, -4.13186044e-01f, -5.77154458e-01f, 2.08556026e-01f,
  -2.50235587e-01f, 1.04401506e-01f, -3.28730196e-02f, 1.29816830e-01f, -2.84030348e-01f, -1.67409763e-01f, 3.27867538e-01f, -5.45694567e-02f, -1.58873629e-02f, 7.41711184e-02f,
  1.63384546e-02f, 5.27226090e-01f, -1.92968994e-01f, 2.26595342e-01f, 1.08149081e-01f, 1.99849114e-01f, -3.10444925e-02f, -3.84999901e-01f, 3.92607421e-01f, 1.53944165e-01f,
  2.83590645e-01f, 8.15473869e-02f, 9.89456922e-02f, -1.41726300e-01f, -3.18430781e-01f, -4.74655852e-02f, -1.25683278e-01f, 2.29321808e-01f, -5.98409101e-02f, -1.85548902e-01f,
  1.49347082e-01f, 2.20410582e-02f, 2.01224655e-01f, 2.15583257e-02f, -4.75235395e-02f, 6.21633865e-02f, 1.42400429e-01f, 6.72330111e-02f, 7.15680234e-03f, 9.17877555e-02f,
  -4.50362742e-01f, -1.62310883e-01f, 1.47869825e-01f, 2.06157386e-01f, 2.08726659e-01f, 2.29172960e-01f, 2.75873274e-01f, 8.67901146e-02f, 8.08886290e-02f, 1.37667820e-01f,
  1.73542887e-01f, 9.87415854e-03f, 1.94840491e-01f, 2.14686871e-01f, 4.46517259e-01f, 1.22521743e-01f, 1.62205771e-01f, 5.12520894e-02f, 1.27653167e-01f, 2.55365431e-01f,
  4.54525977e-01f, -3.07662517e-01f, 5.91140240e-02f, -2.26368815e-01f, -1.70987304e-02f, -3.84953357e-02f, 3.36014122e-01f, -1.51088730e-01f, -1.48145437e-01f, -3.90023410e-01f,
  1.86213717e-01f, 2.38995384e-02f, 2.98177358e-03f, 2.21757288e-03f, 3.13781112e-01f, 8.54118466e-02f, -2.04492986e-01f, 1.98988244e-01f, -1.36616006e-01f, 1.66520894e-01f,
  -3.78363520e-01f, 3.40389043e-01f, -1.47382095e-01f, 9.33908224e-02f, -2.35446095e-01f, 2.90998816e-01f, -2.86693633e-01f, -5.92384040e-02f, -2.25556538e-01f, 2.01854762e-02f,
  2.31832653e-01f, 1.88302219e-01f, -1.98604420e-01f, -3.37109566e-02f, -3.59218210e-01f, 1.65411577e-01f, 1.89930536e-02f, 4.68431562e-01f, 4.01108682e-01f, -2.20611557e-01f,
  5.73693141e-02f, -1.57503039e-01f, 3.56326729e-01f, -9.85802114e-02f, 4.81059223e-01f, 9.33558196e-02f, 1.78939700e-01f, 2.02423066e-01f, -3.63443345e-01f, -2.65595242e-02f,
  -4.92825881e-02f, -1.61287501e-01f, 2.50282079e-01f, -2.82873027e-02f, -3.70335542e-02f, 2.83019632e-01f, 3.27461004e-01f, 3.99977230e-02f, -3.05397451e-01f, -4.62182909e-02f,
  9.99735221e-02f, 1.67982101e-01f, -4.81816242e-03f, 3.47499549e-02f, 8.39107409e-02f, 3.75156045e-01f, -2.08119288e-01f, 3.39249521e-01f, -1.40341818e-01f, -1.31268263e-01f,
  -4.05071557e-01f, -1.94315296e-02f, 1.57133237e-01f, 5.24683952e-01f, -1.27360492e-03f, 2.20745489e-01f, -8.14336166e-02f, -2.21746877e-01f, -2.71458030e-01f, -2.60253072e-01f,
  2.04559654e-01f, -4.97447103e-02f, -3.13856930e-01f, -3.56859416e-01f, 1.13675892e-01f, -1.32708609e-01f, 4.11857441e-02f, 2.20668241e-01f, 1.44559354e-01f, 4.53902110e-02f,
  3.29125896e-02f, 1.67341501e-01f, 5.88285066e-02f, 1.41482994e-01f, -4.08279508e-01f, 2.41435170e-02f, -1.19589075e-01f, -1.39723942e-01f, -2.16131330e-01f, -1.90132469e-01f,
  3.35068494e-01f, -2.55110681e-01f, -9.17175636e-02f, 2.12223053e-01f, 1.08273007e-01f, 2.36465722e-01f, -1.67805821e-01f, 1.47939593e-01f, -3.97398502e-01f, 1.50018141e-01f,
  7.64925256e-02f, 1.12358734e-01f, 1.92245647e-01f, 1.79259300e-01f, 1.95985600e-01f, 2.01740533e-01f, 2.91566014e-01f, 3.98642421e-02f, 3.15571964e-01f, 2.49239430e-01f,
  2.19246924e-01f, 1.62038565e-01f, 1.41875789e-01f, 2.19425485e-01f, 7.54529759e-02f, 3.84831458e-01f, 4.01173383e-01f, 1.69668406e-01f, 1.21048830e-01f, 2.73997307e-01f,
  1.55159915e-02f, 1.03202455e-01f, -2.97672778e-01f, 1.27181843e-01f, -9.88144353e-02f, -2.18050648e-03f, 4.43106443e-02f, 4.53014374e-01f, 1.81143135e-01f, 1.86265066e-01f,
  -1.07109621e-01f, -3.31691504e-02f, -2.74871476e-02f, 9.41718444e-02f, -9.16388482e-02f, 9.97094288e-02f, -3.61986667e-01f, -9.85793024e-02f, 1.98349327e-01f, 1.72310129e-01f,
  -1.26562610e-01f, -4.69003506e-02f, -5.26859500e-02f, 3.92393231e-01f, -2.36523569e-01f, 1.43891081e-01f, -5.17420053e-01f, 2.32590273e-01f, -2.16921911e-01f, 2.03349888e-01f,
  -1.51055664e-01f, -1.97944883e-02f, 2.59744227e-02f, -4.35848460e-02f, 2.49631405e-02f, -5.82894087e-02f, 4.82938915e-01f, 1.55922785e-01f, 2.01695576e-01f, 1.48758098e-01f,
  -9.97805223e-02f, -1.05893977e-01f, 3.82204019e-02f, 3.82554859e-01f, 2.20547870e-01f, 4.48693447e-02f, -5.15558124e-02f, 2.56504804e-01f, 1.71163201e-01f, 9.11459923e-02f,
  6.64624721e-02f, 1.04517993e-02f, 2.07440089e-02f, 1.40495628e-01f, 2.30701864e-02f, 7.55575439e-03f, 1.56135485e-02f, 7.45485025e-03f, 1.53206944e-01f, 1.25057280e-01f,
  2.05359325e-01f, 6.22995086e-02f, -3.99540998e-02f, 2.72910506e-01f, -1.78752586e-01f, 3.53769422e-01f, 1.79887757e-01f, 1.95619255e-01f, -1.89300820e-01f, -1.27369538e-01f,
  1.86848864e-01f, 4.41130459e-01f, 3.03334385e-01f, 1.18465684e-01f, 3.01371604e-01f, -1.51192203e-01f, -1.42224208e-01f, 3.44618708e-01f, 2.90110320e-01f, 4.29672688e-01f,
  2.17164770e-01f, -1.55854926e-01f, 1.90701351e-01f, -1.77955896e-01f, 3.56789380e-01f, 1.16774105e-01f, 1.76826566e-01f, -1.52450323e-01f, -3.79698336e-01f, -2.33807061e-02f,
  -3.32915634e-01f, 6.89722300e-02f, -1.46718487e-01f, 3.52528572e-01f, -3.80390495e-01f, -3.48149687e-01f, 3.93742412e-01f, 2.29173414e-02f, 2.03727499e-01f, -4.67700213e-02f,
  -9.41006318e-02f, 2.41344884e-01f, 2.65746385e-01f, 7.74453133e-02f, -2.84895658e-01f, 2.65019208e-01f, -5.44117630e-01f, -1.27020776e-01f, 1.68265954e-01f, 1.92781296e-02f,
  -2.50841323e-02f, 3.06747645e-01f, 3.31880093e-01f, 4.30805862e-01f, 3.86014372e-01f, 1.79626212e-01f, 8.45312979e-03f, 2.04133868e-01f, 2.14099884e-02f, 3.20704758e-01f,
  -9.14842065e-04f, 7.86777660e-02f, -1.53134530e-02f, 7.92701840e-02f, 2.99217582e-01f, 1.15407757e-01f, -1.88199610e-01f, 2.59214997e-01f, -5.51727414e-02f, 2.59693533e-01f,
  1.70727342e-01f, 7.46862544e-03f, 1.35807455e-01f, -2.58103579e-01f, 9.63160396e-02f, 2.04953015e-01f, 5.52019663e-02f, -1.39788836e-01f, -8.34879503e-02f, -2.59869456e-01f,
  1.51518667e-02f, 2.54324317e-04f, 3.78681943e-02f, 7.48024508e-02f, -4.28380102e-01f, 2.43186746e-02f, -1.81429237e-02f, -1.05086505e-01f, -6.63895207e-03f, 2.29761582e-02f,
  6.78121671e-02f, 3.58751237e-01f, -3.29693854e-01f, 6.14907816e-02f, -1.27292141e-01f, 5.67711256e-02f, -2.44380876e-01f, 2.19966117e-02f, -1.84221014e-01f, 6.76939487e-02f,
  1.78073555e-01f, 5.33399761e-01f, 7.64661357e-02f, 1.44097909e-01f, 3.49482179e-01f, 2.82771960e-02f, 1.97428390e-01f, 1.50789067e-01f, -2.37712134e-02f, 3.60917270e-01f,
  -4.58802968e-01f, 3.73010904e-01f, 9.79275480e-02f, 4.39963900e-02f, -1.13487035e-01f, 3.09686232e-02f, -1.29597291e-01f, -1.17426008e-01f, -1.54418617e-01f, 3.37480754e-03f,
  -3.10078822e-02f, -5.39976768e-02f, -2.36875609e-01f, 1.16529755e-01f, 1.14732385e-01f, -1.90629959e-01f, 2.43352383e-01f, -3.39186192e-02f, 6.70325756e-02f, 5.53158745e-02f,
  1.25055000e-01f, -6.06432483e-02f, 2.88779944e-01f, 1.25613824e-01f, 1.26328720e-02f, -7.42758214e-02f, 1.03505239e-01f, -1.54064491e-01f, 4.12079066e-01f, -1.14159897e-01f,
  -1.04448363e-01f, 2.78025001e-01f, 1.03552751e-01f, -2.07012072e-01f, -1.89413294e-01f, -9.47841629e-02f, 1.88321277e-01f, -4.78111673e-03f, 4.23839211e-01f, 2.69481111e-02f,
  2.33536929e-01f, 4.12805349e-01f, 1.03322685e-01f, 2.45522127e-01f, 1.60008296e-01f, -1.45292148e-01f, 1.81149915e-01f, -5.62025234e-02f, 6.91331923e-02f, 3.52920666e-02f,
  2.03618735e-01f, -1.05387188e-01f, 7.98081905e-02f, -3.07970047e-01f, -8.40667412e-02f, -1.72433063e-01f, 1.23547316e-01f, 1.54674500e-01f, -3.14902812e-01f, 2.09531024e-01f,
  -2.18529448e-01f, 8.96091685e-02f, 3.87451542e-03f, 2.79303253e-01f, 4.25580144e-01f, -5.22139072e-02f, 7.78911286e-04f, 1.07683256e-01f, 1.34821177e-01f, -2.67292634e-02f,
  2.05631629e-01f, -2.69971341e-01f, -3.15009281e-02f, -3.41529734e-02f, -2.65790820e-01f, -1.61441669e-01f, -6.97561577e-02f, -1.10112072e-03f, 2.18597278e-01f, -5.00761718e-02f,
  1.66024461e-01f, 9.62064266e-02f, -2.69148797e-02f, 1.58847272e-01f, 1.38189584e-01f, -5.33467591e-01f, -2.14017089e-02f, -2.18924135e-01f, 6.79740729e-03f, -1.79162875e-01f,
  2.29801297e-01f, -7.95945302e-02f, -7.83185214e-02f, -6.17124021e-01f, 1.65520802e-01f, 2.05497533e-01f, 1.33796796e-01f, 9.29189175e-02f, 2.11921837e-02f, 4.15295959e-01f,
  -2.77745783e-01f, 2.61947643e-02f, 2.93593884e-01f, 1.38943449e-01f, -4.47820835e-02f, 1.16524048e-01f, 3.24839503e-01f, 1.24051109e-01f, 7.75983259e-02f, -3.27621222e-01f,
  1.17823677e-02f, -3.99263710e-01f, -1.01001665e-01f, -1.89535737e-01f, 3.44422519e-01f, -1.73779447e-02f, 1.31742299e-01f, -2.83815831e-01f, 1.04502968e-01f, -1.19981147e-01f,
  -3.28051001e-02f, 3.77794564e-01f, -2.50816911e-01f, -1.28741547e-01f, 1.45334557e-01f, -5.81124984e-02f, 9.15849656e-02f, -1.21481679e-02f, 1.75365761e-01f, -1.76688150e-01f,
  -7.94973969e-03f, 6.11630194e-02f, -5.95700704e-02f, -3.39820921e-01f, 7.91809708e-02f, -4.16759223e-01f, -9.04842764e-02f, -5.01484908e-02f, 8.21588859e-02f, 6.65301681e-02f,
  -9.32000205e-02f, -8.92124232e-03f, 5.10490984e-02f, 2.50238739e-02f, 2.51650602e-01f, 5.05484268e-02f, 1.66841388e-01f, -5.10319136e-02f, 2.15069100e-01f, -2.05408204e-02f,
  -1.77172720e-01f, 1.12259343e-01f, -1.29139632e-01f, -5.99459670e-02f, -1.50463864e-01f, 2.75964856e-01f, -2.40744315e-02f, -6.78897500e-02f, -3.52988318e-02f, 2.36836508e-01f,
  2.74160202e-03f, -2.13758543e-01f, -1.67697489e-01f, 3.23508143e-01f, -2.63993777e-02f, -2.66419500e-02f, 2.51076192e-01f, 1.66325137e-01f, 2.44287416e-01f, -4.07902062e-01f,
  1.50632709e-01f, 1.95622250e-01f, 2.47509152e-01f, -2.67129272e-01f, 8.62066448e-02f, 9.88109112e-02f, 3.00475154e-02f, 1.67450786e-01f, -2.19054833e-01f, 1.76900476e-01f,
  2.06870511e-01f, -2.62270793e-02f, -1.03003167e-01f, -4.27121907e-01f, 1.25959367e-01f, -2.59001136e-01f, -3.51746857e-01f, 4.79625836e-02f, 8.35059807e-02f, 4.25014049e-02f,
  -5.71681634e-02f, 1.48148671e-01f, -3.06452662e-01f, -1.85125217e-01f, -1.94064379e-02f, 1.53575316e-01f, 3.17160964e-01f, 1.95216700e-01f, 1.11205690e-01f, 3.95551234e-01f,
  1.63343102e-01f, 2.22954050e-01f, -3.53357494e-02f, 4.87222411e-02f, -2.69573880e-03f, 7.10805878e-02f, 6.44337013e-02f, 7.19852597e-02f, 8.50515589e-02f, 1.42473415e-01f,
  2.41108730e-01f, 3.17516178e-02f, -7.49145076e-02f, 2.77464300e-01f, 2.61149466e-01f, 2.48690873e-01f, 2.78874636e-01f, 8.99891257e-02f, 5.56262657e-02f, 9.21985880e-02f,
  5.55128045e-02f, 2.20507197e-03f, -2.51850396e-01f, -6.39781356e-02f, -3.00250590e-01f, -1.99678332e-01f, 1.72940791e-01f, -1.76946044e-01f, 1.72377706e-01f, -1.40522821e-02f,
  -2.26735651e-01f, 6.19678348e-02f, 1.05042413e-01f, -1.12198263e-01f, 1.52249560e-01f, 2.03289539e-01f, 9.59283188e-02f, 4.30419981e-01f, -7.09207216e-03f, 1.33174345e-01f,
  6.28120452e-02f, 1.01295963e-01f, 4.03477512e-02f, -8.13635588e-02f, 2.87326109e-02f, 9.60193053e-02f, 2.23169014e-01f, 3.69294733e-01f, -8.16295072e-02f, -7.62259811e-02f,
  1.40878141e-01f, -2.48240065e-02f, -1.64889637e-02f, 2.95514345e-01f, -5.92074096e-02f, -2.28317738e-01f, -1.68302089e-01f, 3.94245565e-01f, 1.36107758e-01f, 2.20516607e-01f,
  2.49378040e-01f, 2.17789769e-01f, 1.63075298e-01f, 7.13537484e-02f, 7.83722177e-02f, 8.50979015e-02f, 5.92623949e-02f, 1.43509954e-01f, -1.84206486e-01f, 1.57933667e-01f,
  3.49575877e-01f, 2.92569418e-02f, -3.85814384e-02f, 1.83101043e-01f, 1.64988548e-01f, -1.63428318e-02f, 1.95536435e-01f, 1.85756370e-01f, 2.25238293e-01f, 2.15372905e-01f,
  6.62824810e-02f, 1.71696439e-01f, -3.09518278e-02f, 1.16125807e-01f, 2.50099525e-02f, -9.85359773e-02f, -2.14960828e-01f, -2.09696680e-01f, -4.12572145e-01f, 2.61276644e-02f,
  1.60663366e-01f, -2.29592860e-01f, -1.63913190e-01f, -1.10113502e-01f, -1.81067437e-01f, 2.41308436e-02f, 4.37836573e-02f, -1.59159094e-01f, -5.16354516e-02f, 2.78550953e-01f,
  -6.06633127e-02f, 3.51466626e-01f, -7.71037266e-02f, -1.49283856e-02f, -2.42572978e-01f, 1.37913391e-01f, 1.89855665e-01f, -1.13317072e-01f, -4.41466682e-02f, -1.79001004e-01f,
  -1.52041703e-01f, -6.31579906e-02f, 4.06425409e-02f, 8.43058527e-02f, 1.09821104e-01f, -1.75008271e-02f, 7.61450082e-02f, 1.56930372e-01f, -3.38186204e-01f, -4.25734632e-02f,
  -1.68981135e-01f, 4.97315407e-01f, 1.59710035e-01f, 2.25626290e-01f, 2.59653658e-01f, 1.83585688e-01f, 2.25002378e-01f, 1.62124798e-01f, 4.00616899e-02f, 1.33431256e-01f,
  -7.36487359e-02f, 3.81104499e-02f, 5.97835109e-02f, -4.00375985e-02f, 4.02117461e-01f, 3.76329161e-02f, -1.15981542e-01f, 3.54222089e-01f, 6.26584888e-02f, 2.44123101e-01f,
  1.90026000e-01f, -1.71000257e-01f, -2.01858133e-01f, -1.99745357e-01f, 1.10994071e-01f, 1.79120842e-02f, 1.44633695e-01f, -1.48483440e-01f, -4.82593060e-01f, -1.81828737e-01f,
  4.65268075e-01f, -3.54092568e-02f, 5.91557324e-01f, 2.38972127e-01f, 5.37162200e-02f, 5.55063844e-01f, -1.33421272e-01f, 2.05752000e-01f, 1.95135593e-01f, -4.41363640e-03f,
  5.60841225e-02f, -1.89431058e-03f, 2.31087282e-01f, 1.76731020e-01f, -7.93409199e-02f, 5.45025058e-02f, -4.19268191e-01f, -2.33909432e-02f, -2.94571906e-01f, 7.25992024e-02f,
  3.85945022e-01f, 3.65511954e-01f, -4.13195044e-01f, -3.17283958e-01f, 1.29812628e-01f, 1.29840136e-01f, 3.18245411e-01f, 3.99945319e-01f, 1.29891757e-03f, 2.19777435e-01f,
  3.94561976e-01f, -1.49963498e-01f, 2.32507028e-02f, -9.54325963e-03f, 1.13116436e-01f, 1.07272945e-01f, -4.77809198e-02f, 1.73747331e-01f, 1.25092611e-01f, 9.99213830e-02f,
  8.30556899e-02f, 1.44397199e-01f, 6.47783801e-02f, 1.74018443e-01f, -1.33592799e-01f, -1.52558208e-01f, 2.20868766e-01f, 1.14871420e-01f, -2.22800300e-01f, 1.08538181e-01f,
  -6.50143251e-02f, 1.44956410e-01f, -1.02237612e-01f, 1.64651796e-01f, -6.61642626e-02f, -5.30095771e-03f, 2.41505846e-01f, -1.48294449e-01f, 3.44453245e-01f, -2.99011916e-02f,
  1.76908538e-01f, 1.77310988e-01f, -2.59726435e-01f, -2.10445002e-01f, -2.58552462e-01f, -1.82411313e-01f, 2.02778891e-01f, -1.71069592e-01f, 1.65218771e-01f, 5.98062202e-02f,
  -8.38798378e-03f, 1.41958013e-01f, 1.36236161e-01f, 2.00296193e-01f, 1.63546845e-01f, -1.30519271e-01f, 9.27309021e-02f, -2.88179576e-01f, 2.73506016e-01f, -8.51068273e-02f,
  7.85144493e-02f, 3.24698955e-01f, 3.90536815e-01f, -6.82346476e-03f, -8.55080318e-04f, 2.03246027e-01f, 1.92265898e-01f, -3.88533734e-02f, 4.26477343e-01f, 5.16901612e-01f,
  9.92654040e-02f, 1.90801457e-01f, 7.28756702e-03f, -1.30695626e-01f, 3.52846324e-01f, 2.85393745e-01f, 3.91722262e-01f, -2.95312613e-01f, 2.56556332e-01f, -2.61984691e-02f,
  1.69215798e-02f, -2.35113606e-01f, 2.87011474e-01f, 1.19303599e-01f, -5.20796329e-02f, -8.24445114e-02f, 2.58403659e-01f, -5.24866469e-02f, 2.11401686e-01f, 2.51761436e-01f,
  1.13706641e-01f, 8.16033259e-02f, 2.72163481e-01f, -1.98197532e-02f, 2.14645714e-01f, -2.49309503e-02f, 3.49135429e-01f, 9.41790044e-02f, 1.79344192e-01f, -7.23914802e-02f,
  2.35497281e-02f, -1.01116441e-01f, -3.96750480e-01f, 1.13682918e-01f, 2.91162938e-01f, 2.52990332e-02f, 1.55904934e-01f, -7.20208511e-02f, 7.38820583e-02f, 2.26255190e-02f,
  -2.18179271e-01f, -7.74088874e-03f, 6.96980283e-02f, 3.84815261e-02f, -2.14181751e-01f, -1.01250261e-01f, -4.35007438e-02f, -7.92096257e-02f, 5.10301953e-03f, 2.29549021e-01f,
  3.03333458e-02f, 4.10836488e-01f, -1.32134885e-01f, 3.14634651e-01f, 1.31008074e-01f, 7.89485648e-02f, -1.03131570e-01f, 1.06168233e-01f, 1.02502637e-01f, 8.76142532e-02f,
  2.22788155e-01f, 3.14921588e-01f, -2.46817008e-01f, -1.00468189e-01f, -2.41324916e-01f, -1.89963982e-01f, 6.06114268e-01f, -1.69215873e-01f, -2.27199137e-01f, -8.22623074e-02f,
  9.49974358e-02f, 6.76571876e-02f, 1.42278001e-01f, 1.67664677e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  3.77736837e-02f, 2.42833700e-02f, 8.47549960e-02f, -4.54393327e-02f, 1.33456871e-01f, -1.15116566e-01f, 1.44373938e-01f, -2.62042098e-02f, -1.71730090e-02f, 1.00313343e-01f,
  9.05655473e-02f, 2.26448700e-01f, 1.74784750e-01f, 2.21498221e-01f, 2.13992521e-01f, 1.11947738e-01f, 1.12795785e-01f, 2.19742984e-01f, -2.09793430e-02f, -3.71194854e-02f,
  -2.26187948e-02f, -3.15392613e-02f, 1.48000956e-01f, 2.54285723e-01f, 4.49628271e-02f, 1.80922657e-01f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  1.32427812e-01f, 8.66195560e-02f, -5.23574874e-02f, -3.23045313e-01f, -2.18417589e-02f, -3.01610529e-01f, -2.93141127e-01f, -4.90772426e-02f, -8.18094239e-02f, -2.29495429e-02f,
  -2.95964807e-01f, 3.17984968e-02f, -1.25022130e-02f, -2.28094682e-01f, -3.18537988e-02f, -4.53951478e-01f, 3.48201431e-02f, -4.50403094e-02f, -1.60282269e-01f, -1.30891353e-01f,
  2.71444499e-01f, 9.44286585e-02f, -6.00572787e-02f, 1.67220563e-01f, 3.78616489e-02f, -2.49141991e-01f, 3.22010845e-01f, 7.04004318e-02f, -2.02845871e-01f, 1.43918782e-01f,
  1.18640102e-01f, 2.26267397e-01f, -6.04448877e-02f, 2.06514895e-01f, -1.72791690e-01f, -8.94649774e-02f, 8.71988684e-02f, 6.87139407e-02f, 1.67970493e-01f, 1.59054264e-01f,
  -2.86436230e-01f, 9.15267467e-02f, -9.73263085e-02f, 2.40364432e-01f, 1.69442862e-01f, -3.22041176e-02f, -7.43358955e-02f, 1.27410755e-01f, 1.82216205e-02f, -5.00621438e-01f,
  -1.51373476e-01f, 1.39088050e-01f, 8.68786424e-02f, -2.97685206e-01f, -3.86978686e-02f, -3.81384909e-01f, 2.43936077e-01f, -3.10423046e-01f, 1.51035905e-01f, 1.73126325e-01f,
  -7.23332614e-02f, -3.66021633e-01f, 1.51122779e-01f, -4.88514841e-01f, -7.93085173e-02f, -1.50879651e-01f, 1.43008947e-01f, -2.35222459e-01f, 2.24894390e-01f, 2.56981909e-01f,
  -1.80498604e-02f, -1.23855267e-02f, -2.43141651e-01f, -2.95763731e-01f, -5.63250631e-02f, 5.25920540e-02f, -2.15804040e-01f, 1.21265545e-01f, 1.25042364e-01f, 1.62681237e-01f,
  4.10771184e-03f, 2.14702994e-01f, 3.95105183e-02f, -5.30958593e-01f, 3.91339093e-01f, 7.14332759e-02f, -2.52771080e-01f, -9.45049301e-02f, -1.91594243e-01f, -3.07981223e-01f,
  -2.31121391e-01f, -2.16640741e-01f, -1.96934432e-01f, 1.54500350e-01f, 3.40480477e-01f, 2.66221277e-02f, 1.80519700e-01f, 2.71621048e-02f, -4.08657312e-01f, 3.59346479e-01f,
  -1.36909783e-01f, 1.12854853e-01f, -4.07142967e-01f, 2.05511943e-01f, 2.45744541e-01f, 8.58352706e-02f, -1.62912413e-01f, -2.19413444e-01f, 1.57309696e-01f, 1.87894329e-01f,
  1.97089747e-01f, -3.81384492e-01f, 1.16484858e-01f, -1.58986509e-01f, 3.47714543e-01f, -1.32681400e-01f, -6.65431470e-02f, -3.42536628e-01f, -1.96634278e-01f, -4.74244744e-01f,
  1.22789003e-01f, 3.04664880e-01f, 3.12043697e-01f, -1.84200987e-01f, -2.48810679e-01f, -3.77303034e-01f, -3.21289748e-02f, -1.79933347e-02f, -2.67698556e-01f, 6.10670336e-02f,
  5.12956381e-02f, 7.58999586e-03f, 1.00682929e-01f, 2.68918127e-01f, 2.77776853e-03f, -1.12692649e-02f, 1.58420473e-01f, -1.34606689e-01f, 3.97217609e-02f, -4.38865244e-01f,
  2.07981512e-01f, 1.51897848e-01f, -9.23296511e-02f, 1.38591528e-01f, 8.73819590e-02f, -3.51407230e-02f, 8.69518295e-02f, -1.35812685e-01f, 1.29789293e-01f, -1.50302380e-01f,
  -2.21184924e-01f, -3.55405398e-02f, -1.55010317e-02f, 2.35964611e-01f, -1.84086874e-01f, 2.50755519e-01f, -3.67043853e-01f, 1.13772450e-03f, 9.17594321e-03f, -1.55303180e-01f,
  -2.00987041e-01f, -1.76249426e-02f, -3.29877496e-01f, 2.17033267e-01f, -1.72195509e-01f, -2.27422360e-03f, -3.85390699e-01f, 2.60495365e-01f, 2.63433814e-01f, -3.14144850e-01f,
  4.36931312e-01f, -6.22856691e-02f, 7.97861665e-02f, -3.38792920e-01f, -2.51253545e-01f, -6.72900200e-01f, -1.49195209e-01f, -3.31800818e-01f, 1.15668893e-01f, -4.89976168e-01f,
  -9.28577036e-02f, -1.55214854e-02f, 2.54480749e-01f, 2.71072298e-01f, -1.93587303e-01f, -2.36567631e-01f, -2.74952322e-01f, 2.74043828e-01f, -3.54689628e-01f, -8.52185264e-02f,
  4.00002539e-01f, -6.23149335e-01f, 1.71994846e-02f, 2.91086864e-02f, -4.06752199e-01f, 9.60440338e-02f, -3.46244305e-01f, 1.37847707e-01f, -1.92481086e-01f, -1.30898833e-01f,
  2.02640072e-02f, -2.60535181e-01f, 2.95696735e-01f, 3.04788172e-01f, -2.32827589e-02f, -4.46076058e-02f, 7.92163312e-02f, -5.60807437e-02f, 1.48525983e-01f, -1.00405842e-01f,
  -3.75178874e-01f, 2.13649571e-01f, -5.25385840e-03f, 1.93432748e-01f, -9.08165649e-02f, 7.92907104e-02f, -3.41926575e-01f, 2.77681142e-01f, -2.43616119e-01f, -1.29404172e-01f,
  3.27734113e-01f, -1.88845277e-01f, 1.29498094e-01f, 2.35083714e-01f, 1.62531570e-01f, -3.53290178e-02f, 1.62260588e-02f, -2.36536101e-01f, 7.36671686e-02f, -2.11123198e-01f,
  2.87128627e-01f, 3.28670219e-02f, -2.66352087e-01f, -1.20935343e-01f, 1.50478721e-01f, 1.97924539e-01f, -3.06656897e-01f, -3.25199552e-02f, -3.89151365e-01f, 4.05366831e-02f,
  1.96760133e-01f, -3.96868467e-01f, -5.33979297e-01f, -2.60165036e-01f, 2.87689287e-02f, 1.44737750e-01f, -1.39121071e-01f, 1.94789201e-01f, -3.11913401e-01f, -3.28588299e-02f,
  -2.38909274e-01f, 1.91189021e-01f, 4.07899078e-03f, -4.68173832e-01f, 3.01512536e-02f, 8.91036466e-02f, -3.29937041e-02f, -3.28097820e-01f, -5.47290444e-02f, 8.08153152e-02f,
  3.07242513e-01f, -1.36193037e-01f, 1.68785572e-01f, -1.50437906e-01f, 1.23358503e-01f, 2.10077062e-01f, -2.92464733e-01f, -3.27017546e-01f, -1.54778689e-01f, -4.11117226e-02f,
  -2.68295974e-01f, 1.51010696e-02f, -3.92215848e-01f, 1.47501245e-01f, 2.03736246e-01f, 1.45694718e-01f, -1.55642733e-01f, 2.06474036e-01f, 2.79719740e-01f, 3.33607882e-01f,
  1.57771528e-01f, 1.75763875e-01f, -1.77201837e-01f, -4.87871528e-01f, 3.91389102e-01f, -2.97550187e-02f, -3.31879973e-01f, 1.14241935e-01f, 4.44254369e-01f, -3.69923532e-01f,
  -1.53932765e-01f, -2.28238061e-01f, 9.01337266e-02f, -2.71535486e-01f, -2.79228259e-02f, 2.08232608e-02f, 3.46829109e-02f, -2.09295824e-01f, -1.53205290e-01f, 8.99078976e-03f,
  1.41101733e-01f, -3.80469948e-01f, 2.81948317e-03f, 2.22132951e-01f, 1.09112419e-01f, -2.50824720e-01f, -1.39166100e-03f, -3.06680769e-01f, 1.51533335e-01f, 2.83803374e-01f,
  1.94443375e-01f, -8.81692469e-02f, -1.21968716e-01f, -3.63816768e-01f, 7.33986050e-02f, -1.05194010e-01f, -1.01296581e-01f, 1.07629590e-01f, -5.74452318e-02f, -4.35841978e-02f,
  7.38268271e-02f, 1.92026734e-01f, 1.13126859e-01f, 2.66560346e-01f, -5.91011085e-02f, 1.68897390e-01f, 2.21265569e-01f, -1.52480170e-01f, 2.34064624e-01f, 2.31366307e-02f,
  -4.15622406e-02f, 1.71517819e-01f, 3.52243185e-01f, 2.39561573e-01f, 1.19224880e-02f, 3.91040668e-02f, 1.55265480e-01f, 1.47464722e-01f, 1.58016443e-01f, 2.75022805e-01f,
  1.81743309e-01f, 1.18742757e-01f, -3.67166847e-01f, -1.04774669e-01f, 3.89196686e-02f, -1.81387037e-01f, -1.97868332e-01f, 3.47271711e-01f, -2.83753365e-01f, -3.42226550e-02f,
  1.56097397e-01f, 2.17197627e-01f, -9.48133972e-03f, 8.52590948e-02f, 2.03357607e-01f, 2.23543271e-01f, 2.82781005e-01f, -5.18996865e-02f, -3.98393601e-01f, -1.17041901e-01f,
  -1.67036384e-01f, 2.93608338e-01f, -4.90479693e-02f, -3.97176623e-01f, 1.86663046e-01f, -3.35237070e-04f, 6.85445964e-02f, 1.96940288e-01f, -1.20716587e-01f, 2.97693014e-01f,
  -1.13762580e-01f, -4.87371773e-01f, 1.79274783e-01f, 2.33471721e-01f, 1.78339295e-02f, 1.02451123e-01f, 1.52207658e-01f, -3.61948580e-01f, -6.83670938e-02f, 1.29577145e-01f,
  2.66899168e-01f, -3.54408294e-01f, -3.58340770e-01f, -1.33725241e-01f, 9.89181846e-02f, 1.84241965e-01f, 6.40940387e-03f, 1.09752826e-01f, -1.30289748e-01f, 2.11220250e-01f,
  1.88001469e-01f, 2.57701844e-01f, 1.54282644e-01f, 1.64653659e-01f, 2.66514182e-01f, 2.04912364e-01f, -8.53911974e-03f, -3.60566713e-02f, 1.95582449e-01f, 1.45026952e-01f,
  1.00474700e-01f, 7.31803030e-02f, 1.19923882e-01f, -5.76865263e-02f, 1.73022211e-01f, -3.56733859e-01f, 1.19012557e-01f, 1.20287761e-01f, 3.18157375e-01f, -3.00163105e-02f,
  4.11067754e-01f, 5.02716005e-01f, 1.63579807e-01f, -3.00981671e-01f, -6.28830045e-02f, -3.32065150e-02f, -1.95992202e-01f, -2.43244961e-01f, 1.13681495e-01f, 4.11577970e-01f,
  6.02976531e-02f, -1.06546469e-01f, 2.32897848e-01f, -4.17698354e-01f, 1.31271314e-02f, -2.04941317e-01f, -3.57837796e-01f, -1.01042099e-01f, -6.83908761e-02f, -2.13440433e-01f,
  -1.85530595e-02f, -4.10851181e-01f, -5.10832906e-01f, 8.02771077e-02f, -3.32566679e-01f, 3.24344933e-01f, 2.21600726e-01f, -5.06639540e-01f, -5.91382563e-01f, -1.68323830e-01f,
  1.18384905e-01f, 3.91204327e-01f, 2.95333657e-02f, -5.57567596e-01f, -2.21321985e-01f, 2.75900364e-01f, 1.96247503e-01f, -2.80099779e-01f, 1.11840688e-01f, -1.26312569e-01f,
  1.45250175e-03f, 3.91273759e-02f, 1.46653503e-01f, 8.56723711e-02f, -2.22175881e-01f, 6.64806971e-03f, -1.76922046e-02f, -9.19888820e-03f, 6.99286610e-02f, -4.36194241e-02f,
  -3.43811482e-01f, -3.23125511e-01f, 5.54898567e-02f, -6.13030344e-02f, -2.63871670e-01f, 1.85737684e-01f, 1.47449046e-01f, 3.15190703e-01f, -7.39971399e-02f, -1.35479391e-01f,
  2.08891809e-01f, 8.42577815e-02f, 2.19192430e-01f, -2.44971290e-01f, -1.52255014e-01f, -4.02387798e-01f, -2.85647124e-01f, -1.65006667e-01f, 1.41588002e-01f, -2.95074850e-01f,
  2.29062989e-01f, -9.47511420e-02f, 1.77200750e-01f, 8.32193568e-02f, 2.51680493e-01f, -7.24773109e-02f, 6.04621619e-02f, -4.09706295e-01f, -3.93764108e-01f, -2.83583999e-01f,
  -5.25101483e-01f, 1.95059121e-01f, -8.30799118e-02f, -2.11193636e-01f, -1.62019998e-01f, 3.25403064e-01f, 4.13690716e-01f, 3.58724743e-01f, -7.14043528e-02f, -3.20787132e-02f,
  -5.85124969e-01f, -3.27609479e-01f, -3.57443750e-01f, -2.67975889e-02f, 6.09923527e-02f, -1.60956994e-01f, -1.91361085e-02f, 1.68167353e-01f, 1.91124693e-01f, -1.26054600e-01f,
  -3.03836942e-01f, 1.76493794e-01f, 6.08569495e-02f, -1.70593266e-03f, 1.94736347e-02f, -1.13232650e-01f, -3.15643996e-01f, -8.40581357e-02f, -5.06546907e-02f, -1.33646995e-01f,
  9.03038215e-03f, 1.07576102e-01f, 4.77165505e-02f, 2.29262725e-01f, -1.46968633e-01f, -1.02331720e-01f, -1.14197746e-01f, -2.86141187e-01f, -1.86343879e-01f, -2.63306171e-01f,
  -3.67912322e-01f, 4.10336584e-01f, 1.89138398e-01f, 3.30995806e-02f, -3.43639344e-01f, -2.14781612e-01f, 1.97210312e-01f, -2.72829026e-01f, 9.82520133e-02f, 3.59416574e-01f,
  1.66269436e-01f, -3.09756082e-02f, -2.80821204e-01f, -9.75483134e-02f, -2.41628662e-01f, 2.82200813e-01f, 3.66218984e-01f, 1.57873109e-01f, -2.53661782e-01f, 2.79108375e-01f,
  -1.28729776e-01f, -3.15778852e-01f, 8.79697949e-02f, 1.57412253e-02f, 3.81590754e-01f, 4.48192060e-02f, 1.53644517e-01f, 1.76686540e-01f, 2.19105616e-01f, -2.15860277e-01f,
  -2.84535974e-01f, 1.62317947e-01f, -4.74749237e-01f, 8.03734288e-02f, -4.51291203e-01f, 5.49578108e-02f, -2.65412271e-01f, -4.64775085e-01f, 2.61484146e-01f, -8.00646748e-03f,
  -5.10013282e-01f, -2.61378884e-01f, -3.88567090e-01f, -4.39673632e-01f, -1.25955194e-01f, 3.20572376e-01f, -1.60503611e-01f, -7.03275725e-02f, -1.34564817e-01f, -8.50977078e-02f,
  1.21170089e-01f, 1.92484241e-02f, 1.91259623e-01f, -3.87448296e-02f, 1.74675837e-01f, -1.33520573e-01f, 8.55713710e-02f, -5.22054508e-02f, 2.41366357e-01f, 1.37909368e-01f,
  -1.65653974e-01f, 1.84845492e-01f, -4.60562371e-02f, -1.73020959e-01f, -1.54840246e-01f, -1.11386433e-01f, -3.19045991e-01f, -1.93708465e-01f, 3.10260415e-01f, -2.36824915e-01f,
  -2.54649073e-01f, 2.06775978e-01f, 4.92169738e-01f, 8.64008740e-02f, -3.45204473e-01f, 7.41379037e-02f, 1.38033628e-01f, 2.98278406e-02f, -4.04784046e-02f, -1.40733972e-01f,
  5.50247245e-02f, -3.46044004e-01f, -2.59150863e-01f, 2.86790282e-01f, 4.31938097e-02f, 1.84861824e-01f, -3.23045909e-01f, -1.62029475e-01f, -3.87239307e-01f, 2.54527871e-02f,
  -4.14585829e-01f, -1.61819950e-01f, -2.65042216e-01f, 1.25729412e-01f, 1.08554758e-01f, -2.02937260e-01f, 3.71404588e-01f, -1.03738770e-01f, -5.07104456e-01f, -7.76553676e-02f,
  2.26220012e-01f, 2.97500696e-02f, -9.43316370e-02f, 1.52594477e-01f, -4.53040779e-01f, -1.28369480e-01f, 1.17031010e-02f, 3.13179314e-01f, -6.36343732e-02f, -3.06410670e-01f,
  1.51851222e-01f, -1.71324849e-01f, -2.42568225e-01f, -4.82203905e-03f, -6.09138235e-02f, -2.12072209e-01f, -2.64830947e-01f, 1.91736788e-01f, -2.70251274e-01f, 8.49442333e-02f,
  -1.40152529e-01f, -1.90884378e-02f, 6.83281347e-02f, -3.59089434e-01f, -6.46116808e-02f, -1.89964473e-01f, 9.17633846e-02f, -2.60486640e-02f, -1.47022292e-01f, -7.23971575e-02f,
  -3.36071879e-01f, 1.60367116e-01f, 3.77250552e-01f, -1.72451168e-01f, -1.16438217e-01f, 4.34930742e-01f, 3.40097278e-01f, 1.51353553e-01f, 2.39860162e-01f, 9.83537510e-02f,
  -1.97940439e-01f, 2.55975246e-01f, -2.27345854e-01f, 2.97972322e-01f, 1.63701326e-01f, -2.93862730e-01f, -2.52682745e-01f, -4.22113270e-01f, -1.16851963e-01f, 1.12187095e-01f,
  -2.70942360e-01f, 1.88831389e-01f, 5.67035712e-02f, -1.90535206e-02f, 2.53431704e-02f, 3.05979759e-01f, 1.57702103e-01f, -1.45867571e-01f, -6.87332928e-01f, -1.98926583e-01f,
  2.25266382e-01f, -2.52160221e-01f, 1.78895161e-01f, -7.01926500e-02f, 3.25080216e-01f, 1.36438176e-01f, 2.01293573e-01f, -2.28629649e-01f, 8.33008885e-02f, -3.09122860e-01f,
  -4.64475095e-01f, -3.45657952e-02f, -5.26817799e-01f, -1.51315451e-01f, 1.34963691e-01f, 1.42614484e-01f, 6.41293451e-02f, 1.00942701e-01f, 1.21774673e-01f, -1.63432807e-01f,
  1.08958244e-01f, 6.85913116e-03f, -9.76033658e-02f, 7.94185251e-02f, 4.71466035e-03f, -8.71002525e-02f, 1.08499788e-01f, -1.44686162e-01f, 5.85265048e-02f, -1.37946457e-01f,
  1.94356844e-01f, 2.68963519e-02f, -3.61500829e-02f, -3.42277467e-01f, -6.37709424e-02f, 2.71746576e-01f, 1.30693614e-01f, -2.00272709e-01f, 1.55414179e-01f, 1.73558235e-01f,
  -2.61299253e-01f, -4.21511382e-01f, 2.20215052e-01f, 2.97802426e-02f, -1.35565937e-01f, -8.14178884e-02f, -2.66852200e-01f, 2.80194759e-01f, 6.66834600e-03f, -1.83551818e-01f,
  -2.13322818e-01f, 2.82589346e-01f, 6.19195439e-02f, -1.61500886e-01f, 3.26807410e-01f, -1.11984782e-01f, 1.51448280e-01f, -3.31599802e-01f, -5.17885983e-01f, -1.47002891e-01f,
  -1.96622267e-01f, -3.68591458e-01f, -2.38886669e-01f, 1.84941348e-02f, 7.69874305e-02f, 3.20251703e-01f, -2.41258249e-01f, 3.73478413e-01f, -3.43856782e-01f, 1.33156627e-01f,
  -3.13739300e-01f, -2.72335917e-01f, -1.32603407e-01f, 1.63779125e-01f, 2.02010348e-01f, 2.43838858e-02f, -8.70069563e-02f, 2.12548167e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.71369776e-01f, 9.50239822e-02f, 4.32157144e-03f, -3.75123918e-02f, -4.78860587e-02f, 2.25518756e-02f, 3.45204547e-02f, 8.37464333e-02f, -5.12934811e-02f, 5.98595999e-02f,
  -9.23647359e-02f, 6.17037006e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    