/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.52421882e-03f, -6.90561980e-02f, -3.13383460e-01f, 9.59338024e-02f, 1.10820360e-01f, 7.59840906e-02f, 2.26037726e-01f, 6.35876805e-02f, 4.05795462e-02f, 1.48629369e-02f,
  -1.89275816e-01f, -1.41851068e-01f, -1.83638245e-01f, -1.65233389e-01f, 4.35652249e-02f, 2.67609805e-01f, 2.19271258e-01f, -1.34740114e-01f, 2.80720256e-02f, 6.52340949e-02f,
  1.22293212e-01f, 2.07993779e-02f, -1.85468316e-01f, 7.82352537e-02f, 2.10489705e-02f, 7.01257586e-02f, -6.22817054e-02f, -8.35626125e-02f, -2.16348674e-02f, -1.71274349e-01f,
  -2.31237814e-01f, -3.67616028e-01f, 7.63584301e-02f, 2.24274714e-02f, -8.84727016e-02f, 1.22552194e-01f, 6.62846267e-02f, -1.48923201e-02f, 5.09017892e-02f, 8.83857906e-03f,
  -1.09231628e-01f, 2.07700878e-02f, -2.37312149e-02f, -3.99317965e-02f, 2.88166311e-02f, -2.27691811e-02f, 7.62568489e-02f, -1.01812273e-01f, -5.71630485e-02f, 6.03632769e-03f,
  9.23313648e-02f, -1.67192181e-03f, -1.14061326e-01f, 9.37010497e-02f, -2.13388205e-02f, -8.55891034e-02f, -1.37095109e-01f, -2.61718277e-02f, -8.18718597e-02f, 5.82321882e-02f,
  7.96139762e-02f, -7.59736225e-02f, -7.00619584e-03f, -4.03803261e-03f, 2.32929718e-02f, -7.96438903e-02f, 1.71266012e-02f, -5.38670234e-02f, 4.00292724e-02f, -3.48272435e-02f,
  2.13341508e-02f, 5.51254675e-02f, -1.66716482e-02f, 4.19651642e-02f, 4.31383289e-02f, -5.15743755e-02f, -2.22952254e-02f, 1.26617430e-02f, -3.34441550e-02f, -2.87082419e-02f,
  -3.04114241e-02f, -4.14723158e-02f, -6.78575337e-02f, -1.05213737e-02f, -7.81068811e-03f, -6.68083429e-02f, -1.54974805e-02f, 1.84632279e-02f, -2.39298679e-02f, -1.88707318e-02f,
  2.50091374e-01f, 8.36596545e-03f, -7.40300566e-02f, -2.84045376e-03f, 3.36142862e-03f, 8.46240576e-03f, -5.36342785e-02f, -2.97817551e-02f, -3.70900892e-02f, -2.20541917e-02f,
  -2.96656489e-02f, 3.36254537e-02f, -5.70812449e-02f, 6.28223596e-03f, 6.27867579e-02f, 1.56775564e-02f, 2.77066454e-02f, 4.26347787e-03f, 1.07004084e-01f, 7.23269284e-02f,
  1.21173836e-01f, 9.27580670e-02f, 6.36160001e-02f, 1.43454000e-02f, 2.83236559e-02f, 7.29394779e-02f, 2.49820296e-02f, -1.26590924e-02f, 1.02762684e-01f, 2.06068650e-01f,
  -1.55937985e-01f, 1.52114466e-01f, -2.77353048e-01f, 5.19117117e-02f, 2.76270002e-01f, 2.19071761e-01f, 6.84895646e-03f, 1.10545428e-02f, 1.98375121e-01f, 4.39578816e-02f,
  1.00545995e-01f, -3.29496153e-02f, -2.23729849e-01f, -3.06576490e-02f, -3.22879016e-01f, -2.05675006e-01f, -2.42876142e-01f, -4.49294716e-01f, -2.37865165e-01f, 1.23983823e-01f,
  2.14886487e-01f, -9.92520433e-03f, -2.90346086e-01f, -4.71685678e-02f, 7.36643523e-02f, 6.16049655e-02f, 4.27148193e-02f, -1.18532693e-02f, 1.16539039e-01f, 3.54504748e-03f,
  4.82391799e-03f, 5.41274697e-02f, -1.45757243e-01f, -4.01329063e-02f, 1.52567225e-02f, 2.85237189e-02f, 2.26213969e-02f, -8.42621699e-02f, -2.95845582e-03f, -6.79856911e-02f,
  -7.77729750e-02f, -6.39235135e-03f, -7.71618411e-02f, 9.19711143e-02f, 2.19686404e-02f, -4.96883318e-02f, -1.10316120e-01f, -1.76137447e-01f, -1.07569754e-01f, 3.31547521e-02f,
  7.39343464e-02f, -6.44173473e-02f, -1.07567810e-01f, -5.82131483e-02f, -2.80505065e-02f, -3.01799476e-02f, 9.80977621e-03f, 1.67027265e-02f, -1.51013389e-01f, 1.27292067e-01f,
  -6.37951419e-02f, -1.90927759e-02f, 3.74540337e-03f, -1.55145070e-02f, 1.23291546e-02f, 4.03421521e-02f, -9.97152878e-04f, 1.83145497e-02f, 2.42471904e-03f, -1.53305056e-02f,
  2.91165467e-02f, 3.39116827e-02f, -9.99217760e-03f, 8.41674116e-03f, -5.42735029e-03f, 5.02172932e-02f, 8.09093192e-03f, -4.01665680e-02f, -4.99788672e-02f, 1.51397865e-02f,
  -1.98972244e-02f, -5.72623163e-02f, 7.94439018e-03f, -1.52127082e-02f, -1.44966645e-02f, -1.06270351e-02f, -1.65753532e-02f, 5.65984510e-02f, -9.06958282e-02f, -4.54271771e-03f,
  1.19845197e-01f, -1.41373590e-01f, 3.05091729e-03f, -2.64104530e-02f, -3.61780785e-02f, -2.78205220e-02f, 8.56801420e-02f, -3.15049104e-02f, 2.71657910e-02f, -1.38822999e-02f,
  4.65825126e-02f, -4.90498915e-02f, 1.83961224e-02f, 1.01167429e-02f, -2.58911829e-02f, 2.43326593e-02f, -3.94971948e-03f, 4.08868454e-02f, -2.14201901e-02f, 6.96651936e-02f,
  -8.23178366e-02f, -5.62858880e-02f, -3.04882657e-02f, -2.82024052e-02f, 2.00700909e-02f, 2.20332085e-03f, 5.76550178e-02f, 5.82245141e-02f, -1.09487355e-01f, 4.55492847e-02f,
  -1.09635085e-01f, 4.20846224e-01f, 1.70638025e-01f, 4.93178144e-02f, 2.44232208e-01f, 4.67334799e-02f, 5.86891592e-01f, -2.46513058e-02f, -1.56243309e-01f, 3.10401112e-01f,
  1.95693061e-01f, -2.74711013e-01f, -3.57903898e-01f, -2.09869310e-01f, -1.34761557e-01f, 1.30202994e-01f, 6.87529743e-02f, -2.88812757e-01f, -3.27869594e-01f, 1.91127658e-01f,
  9.02988166e-02f, 1.26559213e-01f, -1.16760366e-01f, -1.01989128e-01f, 2.23322228e-01f, -2.89641172e-01f, 1.33491069e-01f, 9.26217809e-02f, -1.76632833e-02f, 1.75505757e-01f,
  1.23884313e-01f, 2.90751129e-01f, -1.38951287e-01f, -4.40089367e-02f, 5.85130081e-02f, -6.04180247e-02f, -7.58343749e-03f, -3.94391455e-02f, -8.41156673e-03f, 2.14477256e-02f,
  8.37879032e-02f, -1.79583281e-02f, -1.36742536e-02f, -8.34214687e-03f, 7.68371597e-02f, 3.58888730e-02f, -6.06764108e-02f, 5.22988550e-02f, -1.95284318e-02f, 5.35937734e-02f,
  3.03105656e-02f, 1.56712487e-01f, 2.52461106e-01f, 6.70157969e-02f, -5.38506880e-02f, -2.96041444e-02f, 1.10179581e-01f, 2.39694882e-02f, -3.94732580e-02f, 6.13988712e-02f,
  -5.49547328e-03f, 1.93249900e-02f, -8.59649107e-03f, 8.31781421e-03f, -5.15030522e-04f, 2.23759878e-02f, -1.68092095e-03f, 1.83075890e-02f, -3.78947356e-03f, -5.61872423e-02f,
  9.50408727e-03f, 7.63664162e-03f, 2.83295736e-02f, 3.97078879e-02f, -4.33836915e-02f, 4.99103554e-02f, 1.80344079e-02f, 3.52765881e-02f, -2.39972118e-03f, -4.77249920e-03f,
  -1.70488060e-02f, 3.22842263e-02f, 6.39310777e-02f, -1.06398538e-02f, 2.83398386e-02f, -5.93626834e-02f, -1.97302792e-02f, -2.97421850e-02f, -1.43261058e-02f, -5.36008039e-03f,
  -1.31177649e-01f, -8.88016671e-02f, -6.63076267e-02f, -2.54134554e-02f, 2.87120473e-02f, -2.89175165e-04f, -4.26108390e-03f, 2.66663861e-02f, -3.02662831e-02f, 9.24247131e-02f,
  6.98634088e-02f, -7.02496022e-02f, 4.87657785e-02f, -1.73407868e-02f, -1.90597065e-02f, 2.40760446e-02f, 1.15462998e-03f, -7.61713684e-02f, -7.03635905e-03f, 1.81841813e-02f,
  2.44984590e-02f, -1.02751523e-01f, -8.56800452e-02f, -6.41622320e-02f, 2.51210704e-02f, -1.55765936e-01f, -4.34470392e-04f, -1.99177898e-02f, -6.66263998e-02f, -2.70682797e-02f,
  -9.98167992e-01f, 1.81726087e-02f, 1.45824319e-02f, -2.06904054e-01f, 2.03710169e-01f, 6.74247965e-02f, -9.72481668e-02f, 1.24157500e-02f, -7.67519549e-02f, -1.10945046e-01f,
  4.07955498e-02f, 1.67364597e-01f, 1.37216255e-01f, 1.65471688e-01f, 2.49345303e-02f, 5.77824973e-02f, -1.03356959e-02f, -4.29083146e-02f, 1.22252434e-01f, 1.01405770e-01f,
  1.37464494e-01f, -1.69298574e-01f, -2.12690234e-01f, 1.06067978e-01f, -1.01035550e-01f, 2.03457028e-01f, 6.47240952e-02f, -1.11110434e-01f, 1.08413756e-01f, -1.08042516e-01f,
  1.55732799e-02f, -1.61524266e-01f, 1.31064296e-01f, -1.54283773e-02f, 5.08411229e-02f, -3.52195613e-02f, -3.04840598e-02f, -2.98118386e-02f, -1.43192690e-02f, -7.71560986e-03f,
  2.45078206e-02f, -6.74592005e-03f, -9.96271893e-02f, 7.12215975e-02f, -7.97299892e-02f, -2.91871279e-02f, 3.33524980e-02f, -6.24469258e-02f, -3.34712565e-02f, -3.03059798e-02f,
  1.33483782e-01f, 2.43728440e-02f, -1.08821787e-01f, 5.94983883e-02f, -2.54462077e-03f, 2.53399387e-02f, 7.39863068e-02f, 1.09061170e-02f, 1.11061588e-01f, -9.04686302e-02f,
  -6.15620520e-03f, 1.07284551e-02f, 8.31575412e-03f, -1.72947161e-02f, 6.36613555e-03f, -2.55228262e-02f, 3.55404476e-03f, -9.91426036e-03f, 1.96067523e-02f, -2.63520274e-02f,
  1.47617012e-02f, -2.03383509e-02f, 1.29997153e-02f, -6.55938610e-02f, 4.31349874e-02f, -4.52379398e-02f, 1.35892106e-03f, -1.67173916e-03f, 1.94859970e-02f, 5.29094739e-03f,
  -3.04311682e-02f, 2.15385593e-02f, 1.19565902e-02f, 1.66102294e-02f, 7.27725681e-04f, -8.64270609e-03f, -2.85538174e-02f, -4.54393588e-02f, 2.33815555e-02f, 1.25782914e-04f,
  -1.18536197e-01f, 1.25526771e-01f, -9.64286774e-02f, 3.38527299e-02f, 1.64881013e-02f, 6.43383339e-02f, -2.57141143e-02f, 2.72518955e-03f, 3.41095543e-03f, -4.79847100e-03f,
  5.82962239e-04f, -7.55391642e-02f, 9.26486999e-02f, -9.89663135e-03f, 6.51222169e-02f, -1.75121007e-03f, 3.96357290e-03f, 1.01891691e-02f, 2.37276498e-02f, 4.28724661e-02f,
  -1.95811335e-02f, -5.88081144e-02f, -4.21464778e-02f, -6.46777637e-03f, 1.33051435e-02f, -5.75013040e-03f, -5.73619530e-02f, -2.57022846e-02f, -5.83095960e-02f, -2.17599392e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.89291489e-01f, -1.50285512e-01f, -2.07176313e-01f, 2.00851634e-01f, -3.37932594e-02f, 7.77571229e-03f, -9.09974948e-02f, 1.37638539e-01f, 1.91332147e-01f, -8.78530294e-02f,
  8.85590687e-02f, 1.49740055e-01f, 4.56996709e-02f, -2.30822004e-02f, 4.55454066e-02f, -2.12681696e-01f, -2.69141704e-01f, -4.59392834e-03f, 1.64525345e-01f, 1.33377388e-01f,
  -1.89431128e-03f, 9.06179175e-02f, 9.33507308e-02f, 3.25488001e-02f, -2.86448151e-02f, -8.39146823e-02f, -2.45634109e-01f, -1.40308663e-01f, -2.05310106e-01f, -3.95322829e-01f,
  -1.28834933e-01f, 1.09565601e-01f, 7.30588213e-02f, -1.30261471e-02f, -8.53364915e-02f, 1.87835135e-02f, 4.97872718e-02f, -3.51682268e-02f, 4.65406850e-03f, -2.27040295e-02f,
  -2.99213342e-02f, 1.65324169e-03f, 6.38535097e-02f, -6.87937513e-02f, -4.98903170e-02f, -6.45500328e-03f, -5.04844151e-02f, 3.58891226e-02f, -1.07475773e-01f, 5.04345028e-03f,
  -4.17982154e-02f, -9.93453339e-02f, -1.02885000e-01f, -3.06275785e-02f, 5.87704778e-02f, -1.54376552e-02f, -2.91593466e-02f, -4.18703929e-02f, -5.32903597e-02f, -1.59722984e-01f,
  1.90964341e-02f, 2.57765260e-02f, 1.55720650e-03f, -2.90996023e-02f, 6.77611530e-02f, 2.43513193e-03f, 1.08686127e-02f, 6.65031597e-02f, -1.37213874e-03f, -4.90293317e-02f,
  -7.98418820e-02f, 5.99472113e-02f, 1.81979407e-02f, 7.39013329e-02f, -5.13812713e-02f, -6.77137915e-03f, 9.16729216e-03f, 2.67620999e-02f, 4.35025133e-02f, 7.64360502e-02f,
  -9.39732194e-02f, -3.10820658e-02f, -1.54948365e-02f, -2.23508775e-02f, -8.06212872e-02f, -4.77245376e-02f, 1.38342809e-02f, -9.49911848e-02f, 3.75286900e-02f, -6.65019974e-02f,
  4.99155782e-02f, 1.26251638e-01f, -9.80457477e-03f, 1.02001190e-01f, 2.51889694e-03f, -1.81326363e-02f, 1.89554505e-03f, -1.23161143e-02f, 3.02512217e-02f, 5.71915992e-02f,
  2.77267210e-02f, 2.63623819e-02f, -3.09919138e-02f, 9.19149816e-03f, 5.49975187e-02f, 7.13576302e-02f, -9.52047184e-02f, 4.20367718e-02f, 9.79027525e-02f, -1.89207140e-02f,
  -1.33631185e-01f, 6.40677214e-02f, 8.19878429e-02f, 5.14321700e-02f, -1.76340416e-02f, 1.32814869e-01f, -8.38002712e-02f, -2.41761915e-02f, 8.79385788e-03f, -1.22431107e-01f,
  2.31092766e-01f, 1.83949485e-01f, 2.88505435e-01f, 2.47107908e-01f, 4.07415897e-01f, 2.26521090e-01f, 4.70337808e-01f, 2.58058399e-01f, 3.42705892e-03f, 3.59859434e-03f,
  6.87563717e-02f, -4.02207375e-02f, 6.84048980e-02f, -1.33938566e-01f, 1.13713622e-01f, 1.22996956e-01f, 1.44572467e-01f, 1.90541819e-02f, 1.23011820e-01f, -2.07000207e-02f,
  -1.24728292e-01f, 6.76153749e-02f, -9.53867435e-02f, 2.11409181e-02f, 1.90045368e-02f, -1.82479937e-02f, -2.44532563e-02f, 8.27993602e-02f, -4.05878089e-02f, -1.57924026e-01f,
  -7.50545785e-02f, 1.85978398e-01f, -3.24676447e-02f, -1.18367948e-01f, -2.11365242e-03f, -1.74791545e-01f, -1.16962709e-01f, -8.24816525e-02f, -4.73892391e-02f, -9.26516503e-02f,
  -3.57671268e-02f, -1.57208845e-01f, 6.72473162e-02f, -2.07217261e-02f, 7.15350509e-02f, 4.47233245e-02f, -2.77517065e-02f, 5.73086068e-02f, 3.30041386e-02f, -3.60216536e-02f,
  -1.37867499e-02f, -2.39659771e-02f, 1.61726967e-01f, 7.86866248e-02f, 5.84474541e-02f, -1.23344632e-02f, 1.40367031e-01f, 3.88983488e-02f, 2.25598887e-01f, -1.46730825e-01f,
  -7.44003356e-02f, 4.68075089e-02f, -1.28244143e-03f, 3.32458951e-02f, -3.63398083e-02f, 3.26813534e-02f, -1.08185746e-02f, 1.97125617e-02f, 7.22855851e-02f, -3.42562310e-02f,
  -1.15428671e-01f, 3.25915664e-02f, 2.59769429e-02f, 3.32202390e-02f, 1.92228779e-02f, 4.62966822e-02f, 6.02593506e-03f, -8.51975195e-03f, -8.55843052e-02f, -1.80662423e-02f,
  1.26192933e-02f, 1.10039646e-02f, 3.88016924e-02f, 4.70474809e-02f, 2.73565818e-02f, 6.55250773e-02f, -6.25857860e-02f, 3.65294963e-02f, -2.48744022e-02f, -6.83311373e-02f,
  -2.14493889e-02f, 1.11909971e-01f, -7.40621611e-02f, -1.17344424e-01f, 7.79716671e-02f, -1.60162762e-01f, 5.24134450e-02f, -3.51588167e-02f, -1.64517593e-02f, -2.70050708e-02f,
  1.42964469e-02f, -5.42206876e-02f, 8.22067633e-02f, -9.81524959e-03f, -3.11707966e-02f, -5.31331524e-02f, -8.12506750e-02f, 1.42846450e-01f, -5.23593202e-02f, -1.49390608e-01f,
  -6.14240132e-02f, -6.81612939e-02f, 2.93677915e-02f, 8.18157569e-02f, 9.85375699e-03f, 7.75561621e-03f, -1.76286064e-02f, -6.32298812e-02f, 4.53442968e-02f, -1.27391994e-01f,
  2.74083838e-02f, -3.34207825e-02f, 1.59656122e-01f, 2.69486159e-02f, 6.04504347e-02f, 7.17432350e-02f, 6.97562844e-02f, 4.33444828e-02f, -4.63326424e-02f, 6.01334982e-02f,
  -1.24720544e-01f, -1.56128481e-01f, -1.79613810e-02f, -8.57943818e-02f, -6.42245561e-02f, -5.12991566e-03f, -2.31908523e-02f, 2.17259787e-02f, 2.03566089e-01f, 9.59145948e-02f,
  4.23380770e-02f, 2.60605640e-03f, -8.25591851e-04f, 1.11204563e-02f, -1.08363420e-01f, 1.07013667e-02f, -5.81756160e-02f, -5.28881252e-02f, 5.28346421e-03f, -2.13727430e-02f,
  1.39845744e-01f, -2.85610408e-01f, 8.87111854e-03f, -7.29391277e-02f, -9.91601944e-02f, -1.04822546e-01f, 2.31771953e-02f, -2.35698503e-02f, -1.33320270e-02f, 5.34555241e-02f,
  -1.15958281e-01f, -3.19970511e-02f, -1.08363561e-01f, 4.06086678e-03f, 9.38930139e-02f, 2.32831500e-02f, -7.12574199e-02f, -8.68736356e-02f, -1.27598539e-01f, -1.57584473e-01f,
  -1.93144917e-01f, -7.99789727e-02f, -5.49804885e-03f, -1.01964749e-01f, -1.49105713e-01f, -1.55857643e-02f, -1.40035257e-01f, -1.56834051e-01f, -1.26519874e-01f, 4.79995273e-02f,
  -6.39576018e-02f, -7.85932131e-03f, 2.92456932e-02f, 1.59933958e-02f, 4.82167602e-02f, 5.22697270e-02f, -1.58651676e-02f, 3.73462588e-02f, -1.13106929e-02f, 2.02578809e-02f,
  -1.22284880e-02f, -4.70504463e-02f, -2.83309929e-02f, 9.16716829e-02f, -6.08481169e-02f, -8.26421902e-02f, -4.10975851e-02f, 3.30574103e-02f, -3.83171067e-02f, 6.36960939e-02f,
  -1.58664882e-02f, -3.25700268e-02f, 6.25498071e-02f, 8.71806219e-02f, -1.06960021e-01f, -6.91710040e-02f, 1.96927749e-02f, -8.12622383e-02f, 1.58269014e-02f, -2.63637062e-02f,
  2.54979372e-01f, -2.01839462e-01f, 1.63475364e-01f, 2.50151921e-02f, 6.22842321e-03f, -1.46491438e-01f, 1.88567687e-03f, -7.04506263e-02f, -1.39271496e-02f, 1.01097293e-01f,
  1.59710255e-02f, -7.17627406e-02f, 8.49682689e-02f, -6.05657250e-02f, 1.60723940e-01f, 8.77005681e-02f, 1.22222230e-02f, -1.57133937e-02f, -1.26233011e-01f, -7.57541806e-02f,
  4.32593673e-02f, 2.01622024e-01f, 2.86291987e-01f, 1.38581544e-01f, -7.93352500e-02f, 1.56244278e-01f, 1.44782722e-01f, 2.19771534e-01f, 1.40255600e-01f, 3.75327557e-01f,
  -3.03589582e-01f, -1.75724313e-01f, 6.24003038e-02f, 4.69690785e-02f, 2.77201980e-01f, 2.82229692e-01f, 2.12340519e-01f, 9.46516916e-02f, 7.81593658e-03f, 8.61114487e-02f,
  -1.19226344e-01f, -2.82144070e-01f, -1.78847939e-01f, -1.35386840e-01f, 2.22643763e-02f, 7.89780319e-02f, 3.02356571e-01f, -4.56504114e-02f, -6.75636483e-03f, 6.22248203e-02f,
  1.44910634e-01f, -7.08265752e-02f, -1.61284566e-01f, -1.03464603e-01f, -7.28861243e-02f, 4.13023420e-02f, 8.39713290e-02f, -3.48374769e-02f, -1.10034943e-01f, -6.18430227e-02f,
  -1.20861016e-01f, 1.60427671e-02f, 4.12910581e-02f, -1.12683743e-01f, -3.12207770e-02f, -9.16349813e-02f, -8.25196356e-02f, 2.63140127e-02f, -9.45143849e-02f, -4.97016646e-02f,
  1.49185415e-02f, -1.01345696e-01f, -1.30065084e-01f, 2.58550383e-02f, 8.36566612e-02f, -2.87940037e-02f, -7.16978088e-02f, -1.30043417e-01f, 1.16080940e-02f, -1.00411261e-02f,
  -5.62536605e-02f, -5.82347438e-02f, 7.89790750e-02f, 6.37506694e-02f, 4.45695296e-02f, 6.82870522e-02f, 3.43778133e-02f, -7.08426908e-02f, 1.53190205e-02f, -1.11322708e-01f,
  1.00380316e-01f, -6.59656748e-02f, 2.93954667e-02f, 1.61456168e-02f, -3.15543935e-02f, -1.32201361e-02f, 1.28759146e-02f, 6.26802742e-02f, 9.30904038e-03f, -4.16865312e-02f,
  -5.96174505e-03f, 3.63530181e-02f, 8.59779790e-02f, -2.99272239e-02f, -5.29755168e-02f, -2.67728120e-02f, 3.14684324e-02f, -3.90256085e-02f, 3.30688548e-03f, 7.29622841e-02f,
  3.84671817e-04f, 8.01875144e-02f, 5.48899584e-02f, -5.89292236e-02f, 3.93364839e-02f, -9.30381753e-03f, -1.63651281e-03f, -6.51026443e-02f, 3.36587541e-02f, 7.93733299e-02f,
  -6.90588355e-02f, 1.22392088e-01f, 3.42798233e-02f, 6.45252038e-03f, 1.32011652e-01f, -4.73940410e-02f, -4.59417254e-02f, -1.14641245e-02f, -7.19418302e-02f, -1.31568713e-02f,
  -9.75471884e-02f, -4.10973169e-02f, 4.71976548e-02f, 2.67677736e-02f, -4.46114466e-02f, -1.70690510e-02f, -5.92269488e-02f, 1.06195837e-01f, 7.62013942e-02f, 4.15834039e-02f,
  3.94221172e-02f, 8.37137699e-02f, 1.62956387e-01f, 7.46223927e-02f, 8.55039507e-02f, 1.61042482e-01f, 5.49522005e-02f, 5.74904867e-02f, 1.15125269e-01f, 1.07877411e-01f,
  7.03076869e-02f, -1.31768594e-02f, 4.94433753e-02f, 5.62226847e-02f, 2.10773852e-02f, -2.71947145e-01f, -4.27383482e-01f, -2.07565725e-01f, 5.21962196e-02f, -1.01613551e-01f,
  -4.88739973e-03f, 4.60363477e-02f, -6.71867430e-02f, -1.34629905e-01f, -1.79265097e-01f, -9.56015140e-02f, 5.55916838e-02f, 1.69692226e-02f, -1.38361141e-01f, -4.98988479e-02f,
  -7.72835687e-02f, 6.54607937e-02f, 3.55326640e-03f, 8.24099116e-05f, 6.52031600e-02f, 1.51625201e-01f, 2.14792609e-01f, 7.77844489e-02f, 3.47493067e-02f, 2.08841756e-01f,
  9.45568681e-02f, 2.82174665e-02f, 1.60180517e-02f, 4.95600402e-02f, 8.49057361e-02f, 1.04068844e-02f, -1.03767645e-02f, 6.82300795e-03f, 8.85855481e-02f, -2.12296601e-02f,
  5.47372438e-02f, 3.84112969e-02f, -2.98677012e-02f, 3.77611816e-02f, -4.82225157e-02f, -3.10491696e-02f, 5.58115914e-03f, -6.13292195e-02f, -6.92608356e-02f, -2.13693734e-02f,
  7.88282081e-02f, -6.23771362e-02f, -1.28329843e-01f, -1.59734324e-01f, -6.39961809e-02f, -7.01915100e-03f, -1.33314475e-01f, 5.26898317e-02f, -5.65654272e-03f, 7.16243014e-02f,
  4.57499139e-02f, 3.55405058e-03f, 4.97555770e-02f, -1.82557534e-02f, -3.04320753e-02f, 5.86706027e-02f, -2.78813131e-02f, -7.08364649e-03f, -5.23577109e-02f, -3.33465450e-03f,
  1.02526471e-02f, 2.24160720e-02f, 1.37348147e-02f, 1.08506352e-01f, 4.67096493e-02f, 1.85278826e-03f, -4.53386195e-02f, 2.42153089e-02f, -2.89684590e-02f, 5.21624312e-02f,
  -7.65412897e-02f, 2.60582920e-02f, 4.11296114e-02f, -3.21180280e-03f, -4.19764966e-02f, 3.57069857e-02f, 1.58478562e-02f, -8.90224949e-02f, -5.67762740e-02f, 4.72744042e-03f,
  1.20254019e-02f, -7.17182606e-02f, -4.48238887e-02f, 5.49233444e-02f, 4.69703302e-02f, 5.97376525e-02f, 5.22932634e-02f, 1.42929573e-02f, 3.32702138e-02f, -7.18267858e-02f,
  -8.26428235e-02f, -5.02686463e-02f, 3.40640289e-03f, -8.30054507e-02f, -7.32130334e-02f, -8.96432772e-02f, -1.51617387e-02f, -3.15574370e-02f, -1.28797609e-02f, 2.13746633e-02f,
  -6.53862357e-02f, -1.73436522e-01f, -2.46106625e-01f, -8.43840986e-02f, -7.87103027e-02f, -6.40938953e-02f, -2.48303190e-01f, -1.24257833e-01f, -2.89249688e-01f, -2.90241629e-01f,
  3.10424156e-03f, 4.80739474e-02f, -4.64152843e-01f, 4.91611399e-02f, -1.16287187e-01f, -2.25298271e-01f, -2.92003244e-01f, 1.98303238e-01f, 2.54330963e-01f, -2.25875288e-01f,
  -9.13428962e-02f, 6.17000982e-02f, -9.89266485e-02f, -7.24990293e-02f, -2.18438610e-01f, -2.16614172e-01f, -3.58442694e-01f, -1.93705246e-01f, -1.07650414e-01f, 6.43148273e-02f,
  3.36402934e-03f, 3.50817591e-02f, -8.35357606e-03f, 1.17353432e-01f, 6.67631030e-02f, 3.00918017e-02f, -1.23655021e-01f, -3.42095904e-02f, -1.04082711e-01f, -2.83207089e-01f,
  -4.11781281e-01f, 8.28639865e-02f, 3.50758694e-02f, 5.88376075e-02f, 1.06918057e-02f, -9.09351259e-02f, -8.25800151e-02f, 3.96800563e-02f, 9.15046185e-02f, 4.57261056e-02f,
  5.99352829e-02f, 2.63006389e-02f, 2.57585552e-02f, 1.20283542e-02f, 7.54567310e-02f, 2.02226564e-02f, 1.49453394e-02f, -2.34795827e-02f, 4.12385836e-02f, -6.34738803e-02f,
  -3.44657041e-02f, 3.48779708e-02f, 1.09231278e-01f, 1.36357442e-01f, 4.78071272e-02f, -9.55938175e-03f, 6.15213625e-02f, 1.52279675e-01f, 2.37763114e-02f, 1.87651187e-01f,
  -1.26896454e-02f, -2.56735068e-02f, 1.56134069e-02f, 6.86323717e-02f, -2.49893516e-02f, 2.74288580e-02f, -1.90100931e-02f, -1.94399264e-02f, 2.54529547e-02f, -1.98945287e-04f,
  6.72895536e-02f, -7.96016604e-02f, -1.59343611e-02f, -3.23564708e-02f, -4.14916463e-02f, 5.78555837e-02f, -5.58967292e-02f, 4.85670455e-02f, -5.67229092e-02f, -4.87240069e-02f,
  9.71656367e-02f, 7.87003264e-02f, 8.58159643e-03f, 1.14765778e-01f, -2.17254739e-02f, 5.09293415e-02f, 5.09051792e-02f, -1.59277639e-03f, 1.99310686e-02f, -1.24490168e-02f,
  2.31056631e-01f, -1.85063869e-01f, -4.92735300e-03f, -1.72731634e-02f, 1.75256003e-02f, -3.79088335e-03f, -6.58416674e-02f, 8.67387876e-02f, -1.71585791e-02f, -2.50196327e-02f,
  5.89805171e-02f, -8.28903448e-03f, -3.08339894e-02f, -4.94132787e-02f, -9.10582170e-02f, -5.84626682e-02f, 1.94819361e-01f, -5.80477640e-02f, -7.64302388e-02f, 5.65927364e-02f,
  8.71885568e-02f, 5.59706278e-02f, 6.69857413e-02f, -3.23129036e-02f, 8.83314759e-02f, -1.25995621e-01f, -2.25013532e-02f, -5.61878458e-03f, -5.34856319e-02f, 6.23509698e-02f,
  -6.85945079e-02f, 2.05704227e-01f, 1.35986492e-01f, -4.19999436e-02f, -7.01745600e-02f, 1.44750299e-02f, 8.55729431e-02f, 2.22370066e-02f, -8.42648819e-02f, 8.11730698e-03f,
  2.50692368e-01f, 2.79387176e-01f, 2.20578507e-01f, 2.15077877e-01f, 8.23632032e-02f, -4.19325456e-02f, -1.14274889e-01f, 2.46438682e-02f, 1.24676883e-01f, 6.51124865e-02f,
  2.38460880e-02f, -2.94667818e-02f, -4.91894782e-02f, 9.74646490e-03f, -1.02427579e-01f, 1.11346036e-01f, -7.10120052e-02f, -1.47980690e-01f, -9.44567248e-02f, -2.08241120e-01f,
  2.70199120e-01f, -1.21378370e-01f, -3.93634290e-03f, 3.31036039e-02f, -4.94883545e-02f, -7.88605958e-02f, 6.86705392e-03f, -6.95607439e-02f, 7.82891084e-03f, -2.80793514e-02f,
  -1.63735338e-02f, -7.62659917e-03f, -3.14994715e-02f, -3.37510183e-02f, -7.97917023e-02f, 1.71156023e-02f, -1.50133729e-01f, 9.66397375e-02f, 1.54878227e-02f, -1.01459309e-01f,
  1.11525521e-01f, -4.41657603e-02f, 1.13496095e-01f, 9.01010185e-02f, 2.18822174e-02f, 6.21583350e-02f, 6.92285672e-02f, -6.82539353e-03f, 3.22316065e-02f, 1.10260323e-01f,
  1.80500627e-01f, -7.12232962e-02f, 1.40019720e-02f, 8.25462565e-02f, 7.08883107e-02f, 3.65425758e-02f, -1.74698099e-01f, 6.89499751e-02f, 7.08605647e-02f, -9.38275754e-02f,
  1.13031834e-01f, -1.21046752e-02f, 2.26381645e-02f, 1.16278790e-01f, -5.90318292e-02f, -1.42375067e-01f, 1.22652180e-03f, -3.35094072e-02f, 5.13733318e-03f, -4.46378887e-02f,
  1.06614381e-01f, -1.10091589e-01f, -9.72559154e-02f, -5.16655520e-02f, 3.18224914e-02f, 9.07956436e-02f, -9.68954805e-03f, 1.51759326e-01f, 2.72237211e-02f, -7.44766667e-02f,
  2.09848762e-01f, 4.75063212e-02f, -2.07312778e-02f, -3.07012182e-02f, -1.69833452e-01f, -5.39734326e-02f, 4.21178341e-03f, 1.75787881e-02f, -1.04810581e-01f, -9.52627417e-03f,
  -1.15599940e-02f, 7.56588578e-02f, 7.24017329e-04f, 3.82731631e-02f, 9.83404927e-03f, 5.62785640e-02f, -7.35321194e-02f, 2.80611981e-02f, -4.22399789e-02f, -9.44035500e-02f,
  4.31999477e-04f, 1.39623716e-01f, 1.47942871e-01f, 1.70233160e-01f, 1.64052879e-03f, 3.07426676e-02f, 9.95848030e-02f, 9.30139944e-02f, 1.31596074e-01f, 2.63618618e-01f,
  -2.48985201e-01f, 2.12232888e-01f, -3.47322017e-01f, -2.03156099e-01f, 1.05779402e-01f, -5.39931580e-02f, 1.93372220e-01f, -1.63797498e-01f, -1.43769845e-01f, 9.10047740e-02f,
  1.39947429e-01f, 8.41139033e-02f, 6.26553148e-02f, 1.17712200e-01f, -8.73122178e-03f, 1.76875234e-01f, 2.54846662e-01f, -3.57953459e-02f, -1.39340654e-01f, -8.20378065e-02f,
  2.04174995e-01f, 6.10682368e-03f, -3.70618433e-01f, -1.06284559e-01f, 1.12795331e-01f, 6.10239292e-03f, 1.20905116e-02f, -1.43074384e-02f, 1.01168789e-01f, 2.89637476e-01f,
  7.01361150e-02f, -2.36583456e-01f, 4.42884229e-02f, 1.17184073e-01f, 7.14101922e-03f, -7.00588152e-02f, 4.30809185e-02f, 4.37932014e-02f, 2.00043265e-02f, -6.05829805e-02f,
  6.58849403e-02f, 3.01500037e-02f, 2.82549653e-02f, -9.40660909e-02f, -1.14308372e-01f, 3.40035558e-02f, -1.29661500e-01f, -8.50799978e-02f, -1.81189045e-01f, -2.23339200e-02f,
  1.54560044e-01f, 3.02682538e-02f, -1.60668775e-01f, -9.54780802e-02f, -8.96038115e-02f, -6.48067296e-02f, -6.79457784e-02f, -3.90695557e-02f, -9.49798077e-02f, -1.11267686e-01f,
  6.23699650e-02f, 3.75477225e-02f, 6.07700497e-02f, 6.29117538e-04f, 2.30227336e-02f, 2.37609744e-02f, -2.56270147e-03f, 7.75272250e-02f, -4.02536476e-03f, -5.76619729e-02f,
  7.51742627e-03f, -5.14690652e-02f, -3.27650122e-02f, -3.52292769e-02f, -3.12167145e-02f, 1.87022466e-04f, 4.35549673e-03f, 6.72118291e-02f, -8.93687923e-03f, 1.95245650e-02f,
  1.91343073e-02f, -7.20463544e-02f, -6.80818856e-02f, -5.38697187e-03f, 5.22050038e-02f, -2.95902938e-02f, 7.06551149e-02f, -1.00280885e-02f, -7.84049109e-02f, 1.07686697e-02f,
  -1.88997254e-01f, 1.13224238e-01f, 4.39838991e-02f, 6.76557748e-03f, -4.68064658e-02f, -6.06018044e-02f, 1.77083984e-02f, -1.12448502e-02f, 5.09716617e-03f, 1.82040352e-02f,
  7.24156061e-03f, 3.26161156e-03f, -1.77267995e-02f, 9.49983951e-03f, -4.77354825e-02f, -5.06778471e-02f, 6.88572600e-02f, 2.28625163e-02f, 1.05774859e-02f, -1.51247963e-01f,
  -1.61440298e-03f, 2.54245736e-02f, -5.66637740e-02f, -2.76067574e-03f, -2.19428483e-02f, -1.48750106e-02f, -1.21948339e-01f, -1.09026231e-01f, -7.90357441e-02f, -8.77725780e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  3.29821885e-01f, 2.05283925e-01f, 3.18670690e-01f, 2.72890572e-02f, 1.58580273e-01f, 4.63441432e-01f, 8.51594508e-02f, 4.98442240e-02f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  2.80845344e-01f, 1.11024968e-01f, 1.91524737e-02f, 3.48338515e-01f, 4.73274320e-01f, -2.45937183e-01f, -3.34188789e-01f, -3.94461811e-01f, 4.46432084e-01f, 5.11715040e-02f,
  3.08340460e-01f, -1.12792403e-01f, -2.38311395e-01f, 3.27138156e-01f, 3.27597409e-01f, -3.36056560e-01f, 3.50992173e-01f, -5.68278246e-02f, 3.62011731e-01f, 2.63948917e-01f,
  1.31451488e-01f, 2.84958649e-02f, -2.61366218e-01f, 6.11637950e-01f, 1.46246895e-01f, -3.49510759e-01f, 3.88614058e-01f, -2.83408135e-01f, -8.34960565e-02f, 6.66547418e-02f,
  1.23025076e-02f, -3.83338481e-01f, -1.99502125e-01f, 3.77274990e-01f, 5.54327905e-01f, 1.66068990e-02f, 5.55147529e-01f, 3.32507044e-01f, 3.08154970e-01f, 3.70490402e-01f,
  -5.92186935e-02f, 3.90588082e-02f, 2.26482805e-02f, 4.20910299e-01f, -2.42406905e-01f, -8.31189752e-02f, 6.35493547e-02f, 4.49396074e-01f, -1.79462582e-01f, -2.09122494e-01f,
  5.35734832e-01f, -2.53723204e-01f, 7.49532208e-02f, 4.94109422e-01f, 1.60077333e-01f, 9.40949082e-01f, 2.49333978e-02f, 5.85191883e-02f, 1.41898012e-02f, -1.19735552e-02f,
  4.60943840e-02f, 2.21702442e-01f, 1.71281412e-01f, 3.04681838e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  3.27088274e-02f, 2.12793529e-01f, 7.66324699e-01f, 4.85256314e-01f, -1.93073079e-01f, -3.19691122e-01f, -7.46969059e-02f, -5.53218782e-01f, -1.96840614e-01f, -1.96123913e-01f,
  6.37745440e-01f, 1.16561979e-01f, 7.20218778e-01f, 3.76203321e-02f, -1.60308763e-01f, -3.34827214e-01f, -1.46071061e-01f, -1.98561355e-01f, -7.86780566e-02f, -2.39096880e-01f,
  2.94092000e-02f, 1.66387051e-01f, -1.95384949e-01f, -2.49406546e-01f, 3.61837387e-01f, 2.05332980e-01f, 7.18106553e-02f, -3.71795759e-04f, 2.49567509e-01f, 3.53159487e-01f,
  9.15286839e-02f, -2.18316451e-01f, 3.38081419e-02f, -2.04776004e-01f, -2.26962328e-01f, 1.59617215e-01f, 1.95768774e-01f, -7.56736025e-02f, -1.22019365e-01f, -5.81047460e-02f,
  -2.32956052e-01f, -2.13888332e-01f, 1.47031739e-01f, 1.41042918e-01f, -1.85077459e-01f, 4.56333868e-02f, -5.92310391e-02f, 1.35518163e-01f, 9.30666551e-02f, 2.81490624e-01f,
  -2.91128367e-01f, 1.88335046e-01f, -1.87047571e-01f, 1.40034422e-01f, 1.11022465e-01f, -3.14419437e-03f, -1.08785212e-01f, 2.37731740e-01f, 4.42883700e-01f, 1.84123099e-01f,
  -1.76651478e-01f, 2.33609498e-01f, 1.83767065e-01f, -2.30437800e-01f, 1.56123534e-01f, 5.07242322e-01f, -4.13038790e-01f, 1.20962195e-01f, 4.90344405e-01f, -1.12786636e-01f,
  7.65237287e-02f, -8.93235445e-01f, 3.87044460e-01f, 6.84424162e-01f, 2.67373592e-01f, 4.41741705e-01f, -2.64968514e-01f, 1.21364951e-01f, -5.90016544e-01f, 2.02956334e-01f,
  7.02512488e-02f, -1.01942509e-01f, -7.87095428e-02f, 3.73768173e-02f, 1.20311789e-01f, -1.98644310e-01f, -1.32585198e-01f, -3.07823688e-01f, -6.73850179e-02f, 1.17425837e-01f,
  -1.15016982e-01f, 1.16881527e-01f, -1.63745061e-01f, -1.84123382e-01f, -1.42429411e-01f, -5.81302010e-02f, 6.05980039e-01f, 4.16294076e-02f, -5.84824026e-01f, 1.57166675e-01f,
  -3.53245139e-01f, -2.35735461e-01f, -4.70819712e-01f, 3.63868296e-01f, 7.01680303e-01f, 3.33152831e-01f, -2.00824495e-02f, -3.39805275e-01f, -1.85155883e-01f, 4.09035563e-01f,
  3.34313840e-01f, -5.18615425e-01f, 2.44781226e-01f, -6.04208075e-02f, 2.66507000e-01f, -1.55294701e-01f, 1.30155057e-01f, 6.20933771e-01f, -1.30167911e-02f, -2.23306432e-01f,
  3.93284410e-01f, -3.66638601e-01f, -3.01836520e-01f, 7.73600265e-02f, 3.64995927e-01f, 8.35698724e-01f, -2.41943792e-01f, -8.45926232e-04f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  3.94351840e-01f, -1.85919285e-01f, -3.20289046e-01f, 8.07144120e-02f, 5.99668384e-01f, -2.74227299e-02f, 4.25762355e-01f, 1.84402242e-01f
};

// L2_fan_Wp (Shape: 4 x 16)
const int L2_fan_Wp_rows = 4;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -1.72077820e-01f, -5.25716878e-02f, -1.03312254e-01f, -3.85490298e-01f, 3.08256865e-01f, -8.20272207e-01f, -5.15340269e-01f, -1.13535905e+00f, 6.63065836e-02f, 1.53047010e-01f,
  7.63257816e-02f, -1.11566812e-01f, 2.50191033e-01f, 3.00054848e-01f, 9.19652805e-02f, -3.29218835e-01f, -5.97932518e-01f, 1.10510662e-01f, -4.24981803e-01f, -9.40467417e-02f,
  -3.59614015e-01f, 2.84426231e-02f, 7.76335716e-01f, 6.80717707e-01f, -4.06425506e-01f, 6.47987425e-02f, 1.34879693e-01f, -1.59878716e-01f, 1.07396372e-01f, -7.18620047e-03f,
  -2.17302702e-02f, 6.73816502e-01f, -4.23761249e-01f, -2.53160745e-01f, -4.05043513e-01f, 1.07646741e-01f, -9.12292004e-02f, 6.94287300e-01f, 2.40906365e-02f, 8.01383615e-01f,
  -1.95861354e-01f, 2.06681445e-01f, 1.13176480e-01f, -1.65554985e-01f, -4.76341873e-01f, 2.19639074e-02f, 3.84629786e-01f, 3.78008813e-01f, 9.78084952e-02f, -3.22939187e-01f,
  3.90567869e-01f, 9.95983779e-02f, 3.31987232e-01f, 4.67753887e-01f, -7.59576678e-01f, 3.91621321e-01f, 1.33193582e-01f, -3.67184319e-02f, -7.74974376e-02f, 6.87535331e-02f,
  -6.75816774e-01f, -1.27973752e-02f, 6.95701599e-01f, -1.24092594e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 16)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  -2.49702185e-01f, -3.83355469e-01f, 5.06986827e-02f, 3.15984398e-01f, 4.42092568e-01f, 6.57487094e-01f, 4.85168755e-01f, 2.94097275e-01f, 5.67616880e-01f, -2.93200165e-01f,
  -2.61450093e-02f, 2.98241168e-01f, 6.70427233e-02f, -2.21854568e-01f, 5.16474200e-03f, -6.81806862e-01f, -3.82617980e-01f, 2.15703219e-01f, 5.61822832e-01f, 4.51935418e-02f,
  7.63366938e-01f, 3.01026970e-01f, -2.69398123e-01f, -4.37815875e-01f, 2.41338536e-01f, 2.66964495e-01f, -1.42011032e-01f, 3.48696746e-02f, 4.83669639e-01f, 6.33907020e-02f,
  4.63580042e-01f, 4.68445957e-01f, 1.22736275e+00f, 1.10806072e+00f, 3.12843442e-01f, 5.14842212e-01f, -9.90563110e-02f, 2.61626929e-01f, -3.75276417e-01f, -4.30478871e-01f,
  9.25691962e-01f, -3.21580052e-01f, -2.63977200e-01f, -2.82643020e-01f, -4.84932333e-01f, 9.51387361e-02f, -6.92469716e-01f, 2.80946344e-01f, 4.34189528e-01f, 4.28860113e-02f,
  -1.42301872e-01f, -2.11073801e-01f, -3.66426796e-01f, -6.27643049e-01f, -6.75658137e-02f, -3.33642364e-01f, -3.44944835e-01f, 5.18568838e-03f, -8.03755894e-02f, 2.77945727e-01f,
  9.09806192e-01f, 1.95208907e-01f, 4.82779145e-01f, -2.74241120e-01f, 6.43789470e-01f, -2.67091960e-01f, -2.13510036e-01f, -2.28736714e-01f, -2.24899724e-02f, -2.74382144e-01f,
  1.89122111e-01f, 1.34078100e-01f, -2.40583390e-01f, -8.57754648e-02f, -2.27521867e-01f, 1.71564683e-01f, 6.71414018e-01f, -6.74332976e-02f, -1.91277608e-01f, -7.82912448e-02f,
  -4.52976018e-01f, 3.88981938e-01f, 4.22466069e-01f, 1.92432538e-01f, 3.93480211e-01f, -1.46549836e-01f, 4.14289236e-01f, -4.39417392e-01f, 7.65829980e-01f, 1.22167170e-01f,
  1.13309078e-01f, 9.60021764e-02f, 6.47504985e-01f, 2.33542230e-02f, -9.56594169e-01f, 2.27437541e-01f, 1.00021273e-01f, -1.05505688e-02f, 2.08859354e-01f, -9.27848294e-02f,
  -1.15697108e-01f, -2.00244531e-01f, 6.04507886e-02f, 1.61985353e-01f, 6.61634877e-02f, 2.05910727e-01f, 5.63924527e-03f, -2.20334217e-01f, -4.01878469e-02f, -1.26984388e-01f,
  -1.40987292e-01f, -1.26804516e-01f, -1.60222098e-01f, 1.34553969e-01f, -4.27966118e-02f, 2.12693289e-02f, -1.36574551e-01f, 6.17677271e-02f, -2.64927864e-01f, -1.30355299e-01f,
  -1.37282640e-01f, -2.56072462e-01f, 1.41633928e-01f, 1.52647272e-02f, -2.66069859e-01f, -4.71491851e-02f, -1.40930461e-02f, 1.07598051e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  4.19440180e-01f, 9.40841734e-02f, 4.64161575e-01f, 4.42866683e-01f, 1.59551993e-01f, -1.76052734e-01f, -4.30892929e-02f, -2.27025360e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  -6.54237628e-01f, -7.85760581e-01f, -1.16505456e+00f, -9.32014704e-01f, -3.84647638e-01f, 9.00164723e-01f, -8.87838528e-02f, 4.87865806e-01f, -4.64364767e-01f, 7.30138659e-01f,
  -8.57018530e-01f, -4.15225804e-01f, -7.26791993e-02f, -2.69682109e-01f, -1.00029632e-01f, -1.84459046e-01f, 5.80211759e-01f, 5.25500536e-01f, 9.43294048e-01f, 5.94195843e-01f,
  9.39781964e-01f, -2.23328993e-01f, -1.33894518e-01f, 6.81890190e-01f, -2.42266834e-01f, 5.94128191e-01f, -6.53876245e-01f, 6.07623219e-01f, -2.94689387e-01f, -2.93294162e-01f,
  -1.05316207e-01f, -3.28267440e-02f, 9.11234200e-01f, -6.89672470e-01f, 1.02389503e+00f, -7.22596228e-01f, -2.65339822e-01f, -8.34244132e-01f, -3.54750693e-01f, 5.52144945e-01f,
  2.06869856e-01f, 1.61015019e-01f, 8.98945749e-01f, -2.07532167e-01f, -1.71354607e-01f, -7.73697317e-01f, 2.87984535e-02f, 2.75055110e-01f, -1.02481675e+00f, -1.02551520e+00f,
  2.61872828e-01f, 1.08016980e+00f, -7.07601190e-01f, 1.18025064e+00f, 1.13791394e+00f, -7.28004515e-01f, -2.49716729e-01f, -4.18163985e-01f, 5.08491278e-01f, 6.10061064e-02f,
  6.03654049e-02f, -4.01778221e-01f, 1.02368556e-01f, -5.13143241e-02f, -6.48190320e-01f, 5.99077225e-01f, -5.97418189e-01f, -3.56826037e-01f, -4.54666853e-01f, 1.07796252e+00f,
  1.10113180e+00f, 9.60453331e-01f, -4.41190392e-01f, 2.67796010e-01f, 7.55578160e-01f, -1.89573377e-01f, -3.19788992e-01f, -1.95520222e-02f, 3.71355377e-02f, 3.49499136e-02f,
  8.20355177e-01f, 4.37185317e-01f, 7.66502082e-01f, 9.41015065e-01f, -4.19914514e-01f, 4.66732889e-01f, 1.35006309e-01f, -2.18168125e-01f, -9.48584899e-02f, 6.21162593e-01f,
  -5.66589892e-01f, -5.26353240e-01f, -3.66827190e-01f, 8.17150533e-01f, -2.88914591e-01f, -1.39580250e-01f, 2.62698457e-02f, -7.69864738e-01f, -1.03949869e+00f, 6.92978740e-01f,
  1.17381728e+00f, -6.45595431e-01f, -3.25821906e-01f, -2.96171188e-01f, -3.67209673e-01f, -1.02537394e-01f, 8.86914968e-01f, -1.34884221e-02f, -2.17774957e-01f, 3.87066394e-01f,
  1.17999695e-01f, -5.10090403e-03f, 5.92358887e-01f, 1.95427224e-01f, -1.93497896e-01f, -9.17660713e-01f, 4.29827303e-01f, 2.85177797e-01f, -9.34130311e-01f, -7.03021765e-01f,
  3.85258794e-02f, -7.38518536e-01f, -3.11888725e-01f, 8.86492610e-01f, 7.01493263e-01f, -4.08318400e-01f, 1.96290880e-01f, 1.01450883e-01f, -1.16409868e-01f, 7.18629509e-02f,
  -5.33853173e-01f, -7.73098290e-01f, 6.96359873e-01f, -5.09789288e-01f, -3.40414554e-01f, -5.63281476e-01f, 4.55378652e-01f, 3.50869745e-02f, -2.86598772e-01f, -6.74582124e-02f,
  -7.76715055e-02f, 1.09664285e+00f, 1.17380626e-01f, 2.16795191e-01f, 5.98967910e-01f, 4.32637721e-01f, 4.94534224e-01f, 7.68081486e-01f, -7.22232044e-01f, -7.71328986e-01f,
  -9.18287694e-01f, 1.14021462e-03f, -2.43568450e-01f, -4.15704221e-01f, 1.04202473e+00f, -2.74644434e-01f, -1.01139687e-01f, 3.51932526e-01f, 2.44901329e-01f, -7.62182847e-02f,
  -3.25656652e-01f, 5.67872405e-01f, 8.28546226e-01f, -7.12768734e-01f, -1.02960026e+00f, -5.19858360e-01f, 9.00539696e-01f, 7.40970671e-01f, 1.13510561e+00f, -1.70153230e-01f,
  -4.93481547e-01f, -4.13563728e-01f, 2.99279727e-02f, -6.47931397e-02f, -1.09571718e-01f, 1.33533210e-01f, -6.71146154e-01f, -6.66240990e-01f, -8.14955115e-01f, 3.08867544e-01f,
  6.40496552e-01f, -7.18874633e-01f, -1.43273219e-01f, -9.36290801e-01f, -2.86309510e-01f, -4.64764014e-02f, -6.05439186e-01f, 7.05022097e-01f, 5.13767004e-01f, 2.89722625e-02f,
  -1.25377327e-01f, 5.93486894e-03f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  3.24425042e-01f, 7.75161684e-02f, -1.11599229e-01f, 4.99524862e-01f, -2.45452061e-01f, 1.24588683e-01f, -3.33718151e-01f, 2.31101327e-02f, -2.84789413e-01f, -2.36138821e-01f,
  1.06557362e-01f, 1.16770016e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    