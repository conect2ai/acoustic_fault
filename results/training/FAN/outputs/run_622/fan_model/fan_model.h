/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.46758109e-01f, -6.47645593e-02f, 5.41535735e-01f, 1.10019602e-01f, 4.49718326e-01f, 1.04439728e-01f, 4.19515222e-01f, -2.67485343e-02f, -1.17644720e-01f, 1.98312029e-01f,
  1.78977326e-02f, -1.04712687e-01f, 1.01564102e-01f, -9.35298353e-02f, 1.94773134e-02f, 2.58280665e-01f, 4.29177314e-01f, 1.72664747e-01f, -9.40875895e-03f, 7.07269087e-02f,
  -1.37786847e-02f, 1.15270495e-01f, -1.11173376e-01f, -3.07382434e-03f, -2.19709110e-02f, -9.68523994e-02f, 3.51515293e-01f, 2.76887249e-02f, -2.23069191e-01f, 1.57623310e-02f,
  1.31051421e-01f, 8.99200961e-02f, 7.58775696e-02f, -7.57367238e-02f, 3.89840938e-02f, -7.07820356e-02f, 6.03305288e-02f, -1.27209695e-02f, -2.30734050e-02f, -6.70870990e-02f,
  1.81179404e-01f, 3.19587104e-02f, -2.65067071e-02f, -3.55950445e-02f, 4.47732434e-02f, -2.95596151e-03f, 3.92791145e-02f, 1.38167813e-02f, 4.49010804e-02f, 1.80552658e-02f,
  -1.01751285e-02f, 1.07661963e-01f, 4.11070548e-02f, -1.56128053e-02f, -6.17339881e-03f, -3.45024699e-03f, -1.49154261e-01f, -1.48750231e-01f, 8.12203810e-02f, -1.37435406e-01f,
  2.27296595e-02f, -1.92557997e-03f, -3.52791362e-02f, -2.64248084e-02f, 3.70158292e-02f, 6.81051286e-03f, -2.75248066e-02f, 3.62842605e-02f, -1.79415592e-03f, -5.81397861e-02f,
  6.73815608e-02f, -3.28036171e-04f, -2.38382202e-02f, 7.46307299e-02f, 7.28156278e-03f, -3.21964584e-02f, 3.29844579e-02f, -9.54398885e-03f, -8.86264816e-03f, -5.69706298e-02f,
  4.01180005e-03f, 1.00449314e-02f, 2.88699102e-02f, -1.39769614e-02f, 3.35372053e-02f, -1.81524165e-03f, 9.86306556e-03f, -6.61050454e-02f, 5.59097528e-03f, 2.60768346e-02f,
  -1.58459947e-01f, 5.53034954e-02f, -1.14763394e-01f, 1.41988304e-02f, -2.47337506e-03f, -6.50179610e-02f, -6.17802404e-02f, -5.26073854e-03f, -1.83992609e-02f, 4.54316661e-02f,
  -3.97583768e-02f, 1.55013492e-02f, 5.05228043e-02f, -7.45633394e-02f, 8.11503679e-02f, -5.31075001e-02f, -9.62564424e-02f, 5.78983501e-03f, -6.80082440e-02f, 2.98940763e-03f,
  -6.59195036e-02f, -6.09638309e-03f, -6.95023239e-02f, -2.78872997e-03f, -8.08079243e-02f, 6.43482208e-02f, -1.25454903e-01f, -1.53539171e-02f, 3.90660390e-02f, 4.62238416e-02f,
  8.28128010e-02f, -9.51369256e-02f, 1.57894805e-01f, 4.27802414e-01f, 1.21333517e-01f, -6.70126900e-02f, -2.44737506e-01f, -1.60737097e-01f, 6.95910975e-02f, -1.62591055e-01f,
  -1.71221942e-02f, 1.71198070e-01f, -1.16189316e-01f, 4.41102721e-02f, -1.19121093e-02f, -1.36619493e-01f, 8.20935592e-02f, 2.43758559e-01f, 9.17429328e-02f, 7.15085864e-02f,
  1.69895723e-01f, 2.37707213e-01f, 3.37542295e-01f, 1.65939614e-01f, 4.27983291e-02f, -5.86904660e-02f, -1.21521361e-01f, 1.37753293e-01f, -1.25596851e-01f, 2.55618572e-01f,
  -2.29733735e-02f, 4.57502343e-02f, 2.78860535e-02f, 1.15349092e-01f, -3.70279290e-02f, -5.88076487e-02f, 2.93629803e-03f, 6.91985618e-03f, -5.34607377e-03f, 1.37395086e-02f,
  5.83451055e-02f, -1.19877998e-02f, 1.26164734e-01f, 2.26203725e-02f, 7.55083933e-02f, 3.52225788e-02f, -9.17529017e-02f, 1.12993859e-01f, -1.33862498e-03f, -1.43225506e-01f,
  5.09648174e-02f, 1.19550392e-01f, -6.30828887e-02f, -1.27834171e-01f, -1.20359488e-01f, 8.35227445e-02f, -2.42125504e-02f, 1.28159495e-02f, -5.96933439e-02f, 6.59695268e-02f,
  -1.75457224e-02f, 2.99855247e-02f, 8.84858891e-03f, 4.24571596e-02f, -3.01812943e-02f, 2.64428593e-02f, -7.69305741e-03f, 4.87823300e-02f, -1.42503725e-02f, 5.45753315e-02f,
  6.11096472e-02f, -1.14300720e-01f, 1.04039952e-01f, 5.33686727e-02f, -6.53639585e-02f, 3.92445028e-02f, -3.09670568e-02f, 4.07256670e-02f, 5.12410030e-02f, 5.23721147e-03f,
  4.34462205e-02f, 8.52999017e-02f, 5.89097068e-02f, -3.14317085e-03f, 5.41889705e-02f, -8.79421644e-03f, -1.12400837e-01f, 1.73208546e-02f, 5.09126969e-02f, 3.41059640e-02f,
  -2.58443356e-01f, 5.42516001e-02f, -9.36905444e-02f, -3.10701746e-02f, 3.72417644e-03f, -7.87685215e-02f, -5.83780650e-03f, -4.99087311e-02f, 6.37663230e-02f, 3.08496431e-02f,
  3.34763229e-02f, -6.66306494e-03f, 7.36871734e-03f, -6.34255782e-02f, 1.05527759e-01f, -8.11056793e-02f, -9.59145725e-02f, -5.53592518e-02f, -1.00084499e-01f, 1.03679104e-02f,
  1.15394825e-02f, -5.55244684e-02f, -4.45097089e-02f, -4.24151383e-02f, -7.06721768e-02f, -1.84548460e-02f, -1.55288935e-01f, -1.02950394e-01f, -1.60923064e-01f, -3.32342327e-01f,
  -3.40504289e-01f, 5.27466416e-01f, -1.50048032e-01f, 3.02686375e-02f, 1.43144980e-01f, -1.84065446e-01f, 1.62517250e-01f, 2.16531172e-01f, -9.47591960e-02f, 2.33811483e-01f,
  6.95455968e-02f, 7.70124719e-02f, 9.52959713e-03f, 1.44491136e-01f, -8.44013691e-02f, 2.99673378e-01f, 1.33064007e-02f, -2.58892998e-02f, -4.76654649e-01f, -2.43413284e-01f,
  6.38199523e-02f, -7.09370617e-03f, -2.59181917e-01f, -1.74786583e-01f, 1.77185088e-01f, -2.44525135e-01f, 5.38782403e-02f, -1.16059572e-01f, 1.40948355e-01f, 7.64511406e-01f,
  1.97027996e-02f, 1.21311486e-01f, -1.24694340e-01f, -6.62657395e-02f, 2.01806389e-02f, 7.80741917e-03f, 6.80525303e-02f, 5.10207284e-03f, 1.07136117e-02f, 4.00083326e-02f,
  1.12494580e-01f, -1.82196796e-02f, -4.25066575e-02f, 3.18472879e-03f, 4.40070741e-02f, 4.49063741e-02f, -7.75591284e-02f, 3.51152476e-03f, -3.21457162e-02f, 3.79161313e-02f,
  1.06486067e-01f, 6.05877154e-02f, 1.16593763e-01f, 2.03331839e-02f, -2.20497679e-02f, -1.49798989e-01f, 4.24143579e-03f, 3.93262804e-02f, -2.72657387e-02f, 1.23708382e-01f,
  -8.63984507e-03f, -1.35744475e-02f, -6.26398996e-02f, -3.91195677e-02f, -6.77355975e-02f, 3.46267782e-02f, -6.63520023e-02f, -3.52007188e-02f, -9.02885664e-03f, -1.34170754e-02f,
  -8.63667056e-02f, -2.90341605e-03f, 8.48449990e-02f, -6.79391203e-03f, 5.51186595e-03f, -1.30800232e-02f, 1.05618509e-02f, -2.80800299e-03f, -6.35414291e-03f, -2.20539086e-02f,
  -4.44584601e-02f, 8.09259340e-02f, -3.37667987e-02f, 3.75376157e-02f, -1.69083979e-02f, -1.16370786e-02f, 8.68519209e-03f, -4.03424166e-02f, -2.47358084e-02f, 2.89752036e-02f,
  2.21501254e-02f, -1.62031114e-01f, 1.40607476e-01f, 1.17098264e-01f, 5.79246357e-02f, 5.93185388e-02f, 5.40658981e-02f, 4.24580500e-02f, 1.81927241e-03f, 1.03647210e-01f,
  2.08536722e-02f, 2.55851615e-02f, 3.26042324e-02f, 1.94948111e-02f, -6.80597275e-02f, 2.78324280e-02f, 3.95267680e-02f, -1.32908309e-02f, 5.88946007e-02f, 3.86361480e-02f,
  -1.20760156e-02f, -1.02040498e-02f, -1.21544592e-01f, 2.00465098e-02f, 5.62975146e-02f, -5.33364527e-02f, -6.01264909e-02f, -2.44259275e-02f, -7.57721737e-02f, -6.98839650e-02f,
  6.21512592e-01f, -8.29922557e-02f, 2.79960543e-01f, 2.99645841e-01f, -1.22824244e-01f, -6.60716966e-02f, -2.89051491e-03f, 7.52145573e-02f, -2.41876096e-02f, -2.43901163e-01f,
  -1.86819106e-01f, -1.59661993e-01f, -7.29043782e-02f, -5.99482050e-03f, 1.66300580e-01f, 4.56275903e-02f, 4.19084251e-01f, 3.62161070e-01f, 2.35388771e-01f, -6.28987551e-02f,
  -1.77375808e-01f, 1.26723781e-01f, 2.90063202e-01f, 1.22707590e-01f, 5.81940971e-02f, -2.83091161e-02f, 1.01172455e-01f, 1.75418630e-01f, -1.82057068e-01f, 4.44211990e-01f,
  7.88424388e-02f, 2.04235569e-01f, 5.21654338e-02f, -2.78258696e-02f, -1.27378821e-01f, 6.58753067e-02f, 9.39922631e-02f, 2.44694263e-01f, 8.41544382e-03f, -1.89502724e-02f,
  1.16129098e-02f, -8.08803737e-03f, 8.32043067e-02f, 5.91097325e-02f, 8.25492367e-02f, 2.58591305e-02f, 1.45829201e-01f, 1.59602419e-01f, 9.28840563e-02f, -9.57647786e-02f,
  -6.20710663e-03f, 7.59709403e-02f, 3.78635712e-02f, 4.31172401e-02f, 1.49226248e-01f, 5.48215546e-02f, 9.05007124e-03f, 1.21247388e-01f, 5.05550094e-02f, 7.28662163e-02f,
  1.91659145e-02f, -1.07082082e-02f, 2.13710275e-02f, -1.99839361e-02f, -2.38990542e-02f, -9.81149971e-02f, 6.43217266e-02f, -2.64536496e-02f, 3.77599373e-02f, -7.37413689e-02f,
  4.69285063e-02f, -4.75727357e-02f, 1.52320052e-02f, 2.41078157e-03f, -8.68751667e-03f, 3.46386917e-02f, 2.43562050e-02f, 2.83034593e-02f, -2.13874653e-02f, -1.52610410e-02f,
  1.62001383e-02f, -4.02920917e-02f, -4.45603132e-02f, 7.86899775e-03f, 5.49295638e-03f, 1.95431504e-02f, 4.02737111e-02f, -6.51489422e-02f, -4.50322367e-02f, -2.86458321e-02f,
  -1.67336762e-01f, -2.10250560e-02f, -5.60293347e-02f, 4.67372537e-02f, 3.12736332e-02f, -1.31407797e-01f, -5.09642549e-02f, -1.50880190e-02f, -2.24360358e-02f, -5.39250113e-02f,
  -4.74353321e-02f, 4.40298915e-02f, -5.03340587e-02f, -3.85767571e-03f, 6.36863941e-03f, 5.78075089e-02f, -1.01450689e-01f, 2.30174847e-02f, 2.23331992e-02f, 9.23552259e-04f,
  -4.96783257e-02f, -1.18686631e-01f, -1.39842406e-01f, -4.01054733e-02f, -6.53397590e-02f, -3.80643387e-03f, -8.92988592e-02f, -1.14666507e-01f, -4.11540270e-02f, -2.60179311e-01f,
  1.64700985e-01f, 2.29601517e-01f, -1.69654772e-01f, 2.57258534e-01f, -1.48252487e-01f, -3.65685135e-01f, -1.38926640e-01f, 9.41351429e-02f, -1.06181875e-01f, -4.39460613e-02f,
  -1.06397621e-01f, 2.32252672e-01f, 7.22180866e-03f, 6.15122281e-02f, 4.78431992e-02f, -1.92718625e-01f, -2.42599949e-01f, 2.44590342e-02f, -6.19349033e-02f, 1.92790002e-01f,
  3.50856110e-02f, 2.43140921e-01f, 9.17689875e-02f, 1.04088485e-02f, 1.60929367e-01f, 1.82764586e-02f, -1.50064910e-02f, 2.50393867e-01f, -8.56804848e-03f, 6.10640168e-01f,
  6.49184734e-02f, 1.52586490e-01f, 3.27292108e-03f, 2.63170190e-02f, -4.00300883e-02f, 1.67399980e-02f, 1.03218970e-03f, 3.92955132e-02f, -3.68641503e-02f, 9.74573195e-02f,
  -5.74136600e-02f, -3.24338339e-02f, -1.10831317e-02f, 7.68546015e-02f, 5.59267253e-02f, 2.27344763e-02f, -1.48759224e-02f, 6.95146322e-02f, 1.26250265e-02f, -8.59143883e-02f,
  -1.16401441e-01f, 8.44624452e-03f, 1.22910388e-01f, -2.20244199e-01f, -1.14118099e-01f, -2.49027852e-02f, 5.63589558e-02f, 1.96565583e-01f, 5.63139804e-02f, 4.31695014e-01f,
  7.05794320e-02f, -2.10368447e-02f, -2.54944470e-02f, 5.14682606e-02f, -2.44491156e-02f, -2.54940055e-02f, -2.34103599e-03f, 6.19572289e-02f, -3.31252739e-02f, 1.28274811e-02f,
  4.16447408e-02f, -7.79970735e-02f, -1.64210722e-02f, 6.01210035e-02f, -4.18865457e-02f, -1.82783883e-02f, -5.23883067e-02f, 6.26552179e-02f, -1.22641325e-02f, -3.01446929e-03f,
  3.42020616e-02f, -1.16370499e-01f, 2.19735280e-02f, -2.41883639e-02f, -1.05297655e-01f, -3.98975238e-02f, -2.57677659e-02f, 6.60516620e-02f, 3.35140713e-02f, -5.83801307e-02f,
  3.45764011e-01f, -2.50821799e-01f, 1.18013516e-01f, 4.37140204e-02f, -5.31912819e-02f, 2.99240910e-02f, -9.13597271e-02f, -9.39488262e-02f, -1.08754255e-01f, 2.90942024e-02f,
  -5.14925383e-02f, 1.32781477e-03f, -4.50487249e-02f, 1.11347809e-02f, 1.12337150e-01f, -9.17340890e-02f, -7.29650557e-02f, 7.02355579e-02f, -2.48748576e-04f, -2.42457539e-02f,
  -8.36304128e-02f, 5.56681119e-02f, 1.71611175e-01f, 4.72475924e-02f, 2.09620386e-01f, -9.45486203e-02f, 4.64557484e-02f, 2.55022328e-02f, -4.02943492e-02f, 1.20134577e-01f,
  -4.89463717e-01f, 7.36533925e-02f, -1.96190506e-01f, 1.64854657e-02f, 3.31126936e-02f, -3.02937925e-01f, -1.71366930e-01f, -1.70511797e-01f, -1.30462557e-01f, -6.24562725e-02f,
  -4.23017144e-02f, 1.87515974e-01f, 6.49354011e-02f, 3.38939637e-01f, -2.22815961e-01f, 9.98466909e-02f, 7.96516761e-02f, 1.55206546e-01f, -1.44753277e-01f, 1.67780332e-02f,
  3.69809240e-01f, -2.45047193e-02f, -1.55629590e-01f, -1.03096403e-01f, 2.98070997e-01f, 2.12657914e-01f, -6.57942193e-03f, -5.97867668e-02f, 4.40370105e-03f, 7.34621465e-01f,
  3.74606252e-02f, -1.61052570e-01f, 7.39966473e-03f, 4.05108817e-02f, 1.20745283e-02f, -5.87822869e-02f, 7.31078461e-02f, -2.81572975e-02f, -2.93923598e-02f, -6.53077438e-02f,
  6.02582917e-02f, -4.56674173e-02f, 6.10966831e-02f, 4.72525060e-02f, -2.34861318e-02f, 1.22497149e-01f, -1.61350500e-02f, -3.82142253e-02f, -2.48820037e-02f, -1.66813191e-02f,
  1.24124818e-01f, -2.94286460e-02f, -1.46166265e-01f, -5.91083467e-02f, -1.91600665e-01f, 7.02005848e-02f, -2.84697302e-02f, 5.32331392e-02f, -1.21793143e-01f, -4.82046138e-03f,
  -2.44967956e-02f, 8.98146443e-03f, 6.32293941e-03f, 4.71437862e-03f, 2.82378849e-02f, 3.67535055e-02f, 6.52167052e-02f, 3.34856063e-02f, 3.52972485e-02f, -8.42849016e-02f,
  1.06362484e-01f, -4.80836742e-02f, -4.65549380e-02f, 2.37517734e-03f, 1.16647467e-01f, 1.86690502e-02f, -2.94140428e-02f, 4.09528101e-03f, 3.04469317e-02f, -2.74262596e-02f,
  1.50913158e-02f, -7.91131631e-02f, 4.73727770e-02f, -2.90940516e-02f, 2.31978819e-02f, 8.15665051e-02f, 3.29454523e-03f, 1.11525990e-01f, -5.52025400e-02f, -8.67895782e-02f,
  4.47054729e-02f, 4.79977131e-02f, 4.18869331e-02f, -5.19404523e-02f, -6.52205050e-02f, -1.62553266e-02f, 1.43116023e-02f, -1.79694630e-02f, 9.10850056e-03f, -1.69119164e-02f,
  -1.24939762e-01f, -3.59005518e-02f, 2.25476418e-02f, -1.04934834e-02f, -2.65570860e-02f, -3.05547416e-02f, 1.20190270e-02f, 3.84837165e-02f, -1.72874928e-02f, -3.66209187e-02f,
  -5.44154271e-02f, -1.02146208e-01f, -1.87015668e-01f, -6.02701865e-02f, 1.20899402e-01f, -1.42422020e-02f, 1.49207041e-02f, -7.67604858e-02f, -1.31408557e-01f, -1.74018800e-01f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  8.14607322e-01f, -5.91684759e-01f, -2.86094487e-01f, 3.80402267e-01f, -6.16963543e-02f, 1.62596330e-01f, -1.51254699e-01f, 5.96282482e-02f, 2.81945288e-01f, -7.93393701e-05f,
  -1.06536774e-02f, 3.50522637e-01f, 1.83295131e-01f, 7.37631088e-03f, 1.16412818e-01f, -1.28175601e-01f, -1.24521941e-01f, -7.11533353e-02f, 1.94041833e-01f, 2.49995828e-01f,
  9.79950950e-02f, -1.78011909e-01f, -3.43430974e-02f, 8.51720721e-02f, -1.49749860e-01f, 1.94027111e-01f, -2.29576200e-01f, -3.07396382e-01f, -1.59097031e-01f, -3.84163827e-01f,
  4.19863984e-02f, -8.10000673e-02f, 2.67684042e-01f, 1.23343155e-01f, -1.26086041e-01f, -1.33149512e-02f, 5.05719148e-02f, -1.34859100e-01f, 3.55324782e-02f, 1.97685640e-02f,
  1.05475590e-01f, -3.82079035e-02f, 2.46052686e-02f, -2.03671977e-01f, -2.73315760e-04f, -6.05110303e-02f, -1.35016605e-01f, 4.20871675e-02f, 8.61741155e-02f, 2.05844454e-02f,
  -8.05407092e-02f, 2.55206767e-02f, -6.88160136e-02f, 7.97086209e-02f, 1.81221142e-02f, -2.49901577e-03f, -1.15145154e-01f, -7.54982010e-02f, 8.97117630e-02f, -5.43209948e-02f,
  -1.38392104e-02f, -7.29006203e-03f, -1.27758533e-01f, -7.54404441e-02f, 5.67365289e-02f, 5.66075668e-02f, -4.21746410e-02f, -7.57442191e-02f, 4.15672697e-02f, -7.09526762e-02f,
  -6.25075474e-02f, -2.10192166e-02f, 5.29043749e-02f, 2.56245602e-02f, -4.02134135e-02f, -6.09537922e-02f, -9.46739763e-02f, 5.03165312e-02f, 5.53472573e-03f, 1.24210841e-03f,
  -1.61450747e-02f, 1.21506676e-01f, -1.70833524e-02f, -1.47057459e-01f, -3.40196304e-02f, -3.38915456e-03f, 1.18042678e-02f, -7.68403560e-02f, -1.67451128e-02f, 5.02136983e-02f,
  1.83500662e-01f, -1.29006626e-02f, 7.20532760e-02f, 3.36049683e-02f, 4.54725735e-02f, 4.80798483e-02f, 4.92950529e-02f, 6.23450615e-02f, -9.78854895e-02f, 9.62806493e-02f,
  6.93076253e-02f, 4.27119508e-02f, -1.98085476e-02f, -5.63732274e-02f, 1.43140689e-01f, 1.32073596e-01f, -7.13741116e-04f, 1.09485053e-01f, 3.67015693e-03f, 3.54233161e-02f,
  -5.14505543e-02f, 1.75753251e-01f, 2.21619144e-01f, 1.43483683e-01f, 6.54684529e-02f, 2.74328351e-01f, -1.12160571e-01f, -5.35170808e-02f, 2.33534351e-01f, 1.36732176e-01f,
  -8.12261462e-01f, -9.03154612e-02f, -5.99617213e-02f, -6.76249683e-01f, 6.14312887e-02f, 3.73582959e-01f, 1.10037461e-01f, 7.48680234e-02f, -4.82179644e-03f, -1.35847315e-01f,
  -1.84518859e-01f, -2.80306250e-01f, -2.61070907e-01f, 1.01729766e-01f, 2.70287273e-03f, 2.42883638e-01f, -2.38612786e-01f, -3.55156779e-01f, -1.89485058e-01f, 2.01335818e-01f,
  -5.41462339e-02f, -5.25873303e-01f, -4.45444554e-01f, 1.08087510e-01f, -3.98998074e-02f, -4.60700728e-02f, -2.22750921e-02f, -1.04203478e-01f, 5.44177949e-01f, 3.92931700e-02f,
  -1.15445323e-01f, 5.72190247e-02f, 8.89632255e-02f, 5.80611713e-02f, -7.32202008e-02f, 4.92195524e-02f, -3.66526879e-02f, -8.61916915e-02f, 1.02777220e-02f, 5.22836298e-02f,
  -1.54822871e-01f, -2.31136568e-02f, -1.49354726e-01f, -3.67523469e-02f, -4.87075038e-02f, 7.50686973e-02f, 8.68209675e-02f, -1.29652262e-01f, -7.85609037e-02f, 1.24542698e-01f,
  1.47109225e-01f, 2.08000049e-01f, 1.66757405e-01f, 1.76382631e-01f, 1.91001758e-01f, -7.01563284e-02f, 2.14389965e-01f, 1.48020819e-01f, 2.44917214e-01f, 4.19040024e-02f,
  -3.46166603e-02f, 7.36876726e-02f, 9.50953066e-02f, 2.68770810e-02f, -1.30679429e-01f, -3.90597209e-02f, 1.08102914e-02f, 5.76280989e-02f, -2.57089380e-02f, -1.03210516e-01f,
  3.18704396e-02f, -1.73250064e-02f, -3.12514752e-02f, -1.54482275e-01f, -2.53885854e-02f, 5.64195216e-02f, -5.39436229e-02f, -4.05894183e-02f, 3.23739043e-03f, 5.97127825e-02f,
  5.12626581e-03f, 2.27703340e-02f, -1.32606030e-01f, -4.03163992e-02f, 8.68186355e-02f, -1.57427080e-02f, -2.93491669e-02f, 8.62921849e-02f, -3.78052890e-02f, 3.46589386e-02f,
  -3.89985293e-01f, 1.91256955e-01f, -2.21978188e-01f, 1.35659859e-01f, -2.09101364e-02f, 3.48985940e-02f, -3.53891142e-02f, 1.67287830e-02f, -3.22337896e-02f, -1.67429745e-02f,
  8.55382085e-02f, -1.97796114e-02f, -1.66593686e-01f, 1.42327890e-01f, 1.24504603e-02f, 1.67898715e-01f, 6.37760833e-02f, -2.76145805e-02f, 2.17902631e-01f, 2.61450522e-02f,
  -4.51288521e-02f, 1.09567918e-01f, -5.61806373e-02f, -5.16890101e-02f, -2.61386037e-02f, -1.05655402e-01f, -9.27952081e-02f, -1.21516483e-02f, -2.15065312e-02f, -2.21653894e-01f,
  -5.06102920e-01f, -2.26419076e-01f, -2.68692710e-02f, -6.71046078e-02f, -7.92529341e-03f, 1.84351504e-01f, -2.89631784e-01f, 2.84510255e-01f, 3.32497537e-01f, -4.85109776e-01f,
  1.11178972e-01f, 1.45856962e-01f, -1.46746010e-01f, -1.91777185e-01f, -4.22613442e-01f, -3.73184621e-01f, -5.64145923e-01f, -2.52422184e-01f, 2.92841673e-01f, 4.99329984e-01f,
  3.14328208e-05f, -1.65300071e-01f, -1.03892731e-02f, 1.48015693e-01f, -4.59898151e-02f, -4.84638521e-03f, -2.42437169e-01f, -2.26003498e-01f, 4.46497388e-02f, -8.35823834e-01f,
  -2.79067367e-01f, 2.50913650e-01f, 6.11789785e-02f, -6.63595572e-02f, 2.54834257e-02f, 1.13677688e-01f, 3.85370590e-02f, -1.40164733e-01f, -9.55362245e-03f, -4.60210629e-02f,
  -8.38497430e-02f, 2.14842096e-01f, 3.10209137e-03f, -4.09448706e-02f, -6.00797534e-02f, 1.04099378e-01f, 1.30364746e-01f, 3.38392965e-02f, -5.08025289e-02f, 1.14517823e-01f,
  -1.23770170e-01f, -3.56366225e-02f, -1.11909464e-01f, 1.30397975e-01f, 5.82959838e-02f, -2.62008291e-02f, 1.66600555e-01f, 1.06054679e-01f, -1.46792099e-01f, -2.77384490e-01f,
  5.28679341e-02f, -7.22690746e-02f, -2.47197282e-02f, 3.99485901e-02f, -5.65235578e-02f, 9.90016982e-02f, -1.92416329e-02f, -9.89597887e-02f, 7.11854696e-02f, -1.49428889e-01f,
  4.10399251e-02f, -1.62677150e-02f, 6.97329938e-02f, 3.05690076e-02f, 6.72514215e-02f, -4.21658009e-02f, -2.14283187e-02f, 8.57994333e-03f, 1.11995369e-01f, -7.31891096e-02f,
  -2.96429992e-02f, -6.24043914e-03f, -1.05224639e-01f, 1.87429741e-01f, -1.12004183e-01f, 1.87266413e-02f, -1.42880529e-01f, 2.88502369e-02f, 1.83259025e-02f, 6.27202317e-02f,
  6.81734011e-02f, -5.09484783e-02f, -2.09634364e-01f, 5.91995753e-02f, -2.67427154e-02f, -3.02078389e-02f, 1.93707682e-02f, -6.89521879e-02f, 8.17197282e-03f, -2.35342830e-02f,
  6.80983812e-02f, -1.52302444e-01f, 4.32768045e-03f, 4.32818048e-02f, -4.51531187e-02f, 2.15617716e-02f, -1.48770913e-01f, -1.92020863e-01f, 7.38410950e-02f, 1.13923222e-01f,
  -3.73251289e-02f, -8.50729123e-02f, -3.68173897e-01f, -1.79201961e-01f, 1.89947654e-02f, -1.05531372e-01f, -5.28886542e-02f, 3.22523266e-02f, -2.10579097e-01f, -3.46090019e-01f,
  2.46122796e-02f, -9.97148976e-02f, 4.41192299e-01f, 3.08640748e-01f, 5.84324896e-01f, 3.63236964e-01f, 7.42380917e-01f, 1.47218585e-01f, 7.35393688e-02f, 5.28309196e-02f,
  -2.08468754e-02f, -3.21987838e-01f, -2.86133289e-01f, -2.80723661e-01f, -1.77572802e-01f, 3.18472207e-01f, 3.40977162e-01f, -1.29998416e-01f, 1.20987482e-01f, 2.94103742e-01f,
  -1.46975636e-01f, 5.80135658e-02f, -2.69710422e-01f, -1.04891457e-01f, 1.98861480e-01f, -8.17158669e-02f, 1.32096171e-01f, 2.62388736e-01f, -8.82467106e-02f, -9.73643064e-02f,
  -1.44573659e-01f, 1.94165841e-01f, 1.72388609e-02f, -4.75798063e-02f, -1.65058821e-02f, -1.68867275e-01f, 6.17758073e-02f, -1.17088556e-01f, -1.19313784e-02f, -5.93855716e-02f,
  4.46371511e-02f, -1.08368926e-01f, 1.45468608e-01f, -3.17472927e-02f, 1.03604764e-01f, 8.54118466e-02f, 1.22316545e-02f, -7.51956692e-03f, 5.12559935e-02f, -2.69092787e-02f,
  -1.15719222e-01f, 2.10410982e-01f, 3.45820427e-01f, 1.67894617e-01f, -2.61296257e-02f, 6.69342577e-02f, 9.73942801e-02f, 4.22057658e-02f, 1.71749935e-01f, -1.51370972e-01f,
  -5.27166203e-02f, -4.48564999e-02f, 4.33165580e-02f, 1.46461623e-02f, -1.11503795e-01f, -3.51480432e-02f, 4.98577170e-02f, 6.17891476e-02f, 8.98204520e-02f, -5.74507974e-02f,
  4.99719754e-02f, -2.24308819e-02f, -2.19961759e-02f, 8.29509571e-02f, -1.80941433e-01f, 1.26183495e-01f, 5.50414585e-02f, -9.17348564e-02f, 2.74203923e-02f, -4.64860648e-02f,
  2.19743624e-02f, 6.08746596e-02f, -3.51182446e-02f, -6.48622448e-03f, 3.95051800e-02f, -5.82452640e-02f, -7.29504153e-02f, 4.79478203e-02f, -6.79590851e-02f, 5.79760559e-02f,
  -1.53061658e-01f, 1.09712027e-01f, -7.84981251e-02f, -8.18115324e-02f, -4.25059628e-03f, -6.77669570e-02f, 2.20163772e-03f, -2.16612797e-02f, -7.27177933e-02f, 1.18476441e-02f,
  3.65236960e-02f, -7.18248934e-02f, -2.33651455e-02f, -4.76630293e-02f, 9.35296267e-02f, -3.44587080e-02f, -1.22365700e-02f, 2.19326164e-03f, 9.13945120e-03f, 1.87143236e-02f,
  -1.07341371e-01f, 7.59940594e-02f, 3.39521375e-03f, 1.01356693e-01f, -6.19571656e-02f, -9.29941982e-02f, 2.64725424e-02f, 4.85810488e-02f, 8.93193558e-02f, -4.62570861e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  4.65449810e-01f, -3.94751012e-01f, -4.86679077e-01f, -1.85833514e-01f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -2.06039965e-01f, 4.81184497e-02f, 3.03230017e-01f, -5.06015792e-02f, 9.34868455e-02f, 4.10333484e-01f, -4.51488972e-01f, -2.38131642e-01f, -1.94925562e-01f, -3.02171767e-01f,
  1.97577979e-02f, -1.53727651e-01f, 4.97032374e-01f, 3.01135361e-01f, 2.96636075e-01f, -2.96738625e-01f, -2.10357204e-01f, -2.29228184e-01f, 8.16842243e-02f, -3.46590549e-01f,
  -1.81598172e-01f, 3.73954773e-01f, -3.72112960e-01f, 8.01535770e-02f, 2.86648333e-01f, -1.14846505e-01f, 1.60155669e-01f, -7.73512423e-02f, -3.69962931e-01f, -3.67864281e-01f,
  -2.91550785e-01f, 1.16256185e-01f, 1.95610180e-01f, -9.69079360e-02f, 1.90235898e-01f, -8.91842693e-02f, -4.63813208e-02f, -2.82310337e-01f, -5.34503497e-02f, 9.80948806e-02f,
  7.12700367e-01f, -1.87330127e-01f, 2.61029273e-01f, 4.28348243e-01f, -1.48367837e-01f, 3.98372203e-01f, -2.16378897e-01f, -1.58262640e-01f, 6.75650835e-01f, -1.95675284e-01f,
  3.82861644e-01f, -1.00232117e-01f, -1.19146816e-02f, -6.16164319e-02f, 2.97628175e-02f, -1.38038605e-01f, -1.88072711e-01f, 1.46849796e-01f, 2.42904127e-01f, -2.06104264e-01f,
  -2.73539990e-01f, 2.29721740e-01f, -7.13134930e-02f, -4.24720161e-03f, 1.60159022e-01f, -1.87284961e-01f, 3.09093207e-01f, 7.96663165e-02f, -1.39247492e-01f, 1.82045728e-01f,
  -2.77695030e-01f, 2.43510813e-01f, 3.83415580e-01f, 1.03567299e-02f, 1.73763275e-01f, 4.43659455e-01f, -2.17232034e-01f, 3.24578941e-01f, -2.56976515e-01f, -4.05279189e-01f,
  1.60058826e-01f, 2.36045137e-01f, -1.26899574e-02f, -5.57358861e-01f, -2.21948445e-01f, 2.74975270e-01f, 1.64157242e-01f, -1.36141911e-01f, -3.30022499e-02f, -3.07000995e-01f,
  1.00571945e-01f, -1.61262244e-01f, -1.28995165e-01f, 1.95954263e-01f, 3.43912393e-01f, -2.84205288e-01f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -6.47205055e-01f, 2.82607049e-01f, -7.34200794e-03f, 4.77943480e-01f, 4.09823507e-01f, 1.29044488e-01f, 3.03180456e-01f, -1.43516228e-01f, -3.39458823e-01f, -8.53601098e-03f,
  4.31604907e-02f, -3.06906283e-01f, 3.81077796e-01f, 1.37477055e-01f, -1.16963409e-01f, 4.24608618e-01f, -2.88524091e-01f, -3.13370556e-01f, -2.18183637e-01f, -3.79376352e-01f,
  -4.05244716e-02f, 7.03257471e-02f, -1.07310936e-01f, 3.95467401e-01f, -1.87014639e-01f, 1.84075072e-01f, -4.59876321e-02f, 1.94679567e-04f, 3.31894577e-01f, 3.06248516e-01f,
  1.60898060e-01f, 6.17432892e-02f, 1.48952961e-01f, 3.07753474e-01f, 3.86580378e-01f, 1.99870333e-01f, -7.65189007e-02f, 2.82437801e-01f, -4.69027489e-01f, -7.84290850e-01f,
  1.56331629e-01f, -6.80638015e-01f, -4.95244488e-02f, -2.22071439e-01f, -1.63457945e-01f, 4.46342736e-01f, 7.50911057e-01f, -7.29536057e-01f, 7.98532486e-01f, -3.39010805e-01f,
  2.02120934e-02f, -4.49285507e-01f, 2.84859687e-01f, 4.09707159e-01f, 2.95984954e-01f, -1.77197725e-01f, -6.80032790e-01f, -7.01070130e-02f, 4.58312444e-02f, 7.68076181e-02f,
  2.77795047e-01f, 3.33864689e-01f, -1.57470584e-01f, -8.54020044e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  -1.05626196e-01f, -1.78561732e-01f, 2.29031980e-01f, 2.26369992e-01f
};

// L2_fan_Wp (Shape: 6 x 16)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  3.35308343e-01f, 5.05232215e-01f, 4.60282743e-01f, 2.96814114e-01f, -4.87320907e-02f, 2.31489673e-01f, -4.57767278e-01f, 4.72572863e-01f, 3.39179903e-01f, -6.59187660e-02f,
  7.05209598e-02f, -2.83938140e-01f, -1.30299419e-01f, -3.81954879e-01f, -1.61723718e-01f, -5.82537986e-02f, 1.46805039e-02f, -1.51032820e-01f, -2.16408655e-01f, 2.34263718e-01f,
  4.79486771e-02f, 3.58693630e-01f, -1.02965713e-01f, 1.13743536e-01f, -8.61322522e-01f, 9.64677110e-02f, -6.63726449e-01f, -1.41091540e-01f, 3.85979146e-01f, 7.88146406e-02f,
  -6.93554357e-02f, 1.67585880e-01f, -2.30252743e-01f, -2.22900450e-01f, 1.27221137e-01f, 5.99901266e-02f, 4.11717385e-01f, -1.44934908e-01f, 6.32655263e-01f, -1.60845771e-01f,
  2.22104728e-01f, -4.97918487e-01f, -9.37021971e-02f, 1.63651362e-01f, -1.34522533e-02f, 4.83778983e-01f, 2.51846910e-01f, -2.21972652e-02f, -3.72055396e-02f, 8.98819983e-01f,
  -8.16642307e-03f, -1.81810811e-01f, 3.80369782e-01f, 1.02674499e-01f, 3.97743940e-01f, -9.10841208e-03f, 7.57474601e-01f, 4.52427417e-01f, 6.44782960e-01f, 3.54368508e-01f,
  -4.63556856e-01f, -3.15772146e-01f, -6.30155578e-02f, -1.37422010e-01f, -1.33800115e-02f, 1.54480189e-01f, -1.97711308e-02f, -1.75131410e-01f, 3.75932734e-03f, -2.00163484e-01f,
  -3.74524474e-01f, -3.69294912e-01f, -4.45119858e-01f, -1.27503633e-01f, -2.74497177e-02f, -9.01359797e-01f, 2.81229258e-01f, 6.02421053e-02f, -1.47045910e-01f, -2.24776670e-01f,
  -2.95790434e-01f, -7.38571286e-01f, -4.11741108e-01f, -3.24797571e-01f, -3.19305778e-01f, -4.96015310e-01f, 8.21046770e-01f, -6.22730553e-01f, -1.85214385e-01f, 3.85932148e-01f,
  -2.69333929e-01f, -4.61183727e-01f, 2.04192400e-01f, 1.45428032e-01f, 9.33892131e-02f, 2.63831139e-01f
};

// L2_fan_Wp_bar (Shape: 4 x 16)
const int L2_fan_Wp_bar_rows = 4;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  3.10541183e-01f, 5.24429440e-01f, 3.38729024e-01f, 6.45905435e-01f, -7.83399493e-02f, 5.30802906e-01f, -2.20260590e-01f, -7.22849905e-01f, -9.58781719e-01f, -8.21790993e-02f,
  -7.54742563e-01f, -5.90482473e-01f, 8.54295969e-01f, -3.68604034e-01f, 1.58724323e-01f, -1.88637152e-01f, -4.32476163e-01f, 6.72614396e-01f, 2.31597438e-01f, 5.24796724e-01f,
  7.20081210e-01f, -3.71509761e-01f, 2.11760789e-01f, -4.60729599e-01f, -4.18436497e-01f, -8.84754121e-01f, -1.36148125e-01f, 4.81053382e-01f, 2.89132178e-01f, 5.19962050e-02f,
  1.11679363e+00f, -2.37609699e-01f, -1.17890790e-01f, 3.41568947e-01f, 3.00613582e-01f, 3.16516697e-01f, 2.84990132e-01f, -3.52854639e-01f, 3.29313725e-01f, -6.90753996e-01f,
  -1.42924869e-02f, -2.37671271e-01f, 1.72786310e-01f, 5.76138079e-01f, 1.16823077e-01f, 4.96962249e-01f, 9.60057020e-01f, 1.43883809e-01f, 8.86361226e-02f, 5.33215404e-01f,
  1.48566410e-01f, 2.56464690e-01f, 2.53886789e-01f, 4.73137468e-01f, 4.03951317e-01f, 1.88662827e-01f, -2.29377881e-01f, 7.41091847e-01f, 3.83077472e-01f, 5.76509595e-01f,
  -9.85617995e-01f, -3.49290729e-01f, 3.13474275e-02f, 8.06399405e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 4)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 4;
const float L2_fan_Bp_bar_data[] = {
  3.68725091e-01f, 4.05561537e-01f, 1.50537118e-01f, 4.42994952e-01f
};

// L3_fan_Wp (Shape: 6 x 16)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  -6.17114663e-01f, 4.19642270e-01f, 1.87063456e-01f, 1.29902497e-01f, -3.40018898e-01f, 3.69883418e-01f, 2.94189185e-01f, -2.78238617e-02f, -1.98508054e-01f, -3.38908195e-01f,
  2.02040061e-01f, -6.31898522e-01f, 7.02571869e-02f, 1.46707892e-01f, 3.36958468e-01f, -7.70622253e-01f, -6.49107471e-02f, 2.75023252e-01f, -4.81560938e-02f, 6.04824543e-01f,
  -7.82909036e-01f, -4.13359076e-01f, -2.62781322e-01f, -7.79071003e-02f, 3.54308188e-01f, -9.00247600e-03f, -4.32409912e-01f, 2.01636702e-01f, -5.61599612e-01f, 2.05181792e-01f,
  1.57290787e-01f, 3.31050068e-01f, 1.03954107e-01f, 4.60757107e-01f, -3.02457631e-01f, 5.46231270e-01f, 1.66591406e-01f, 1.68956727e-01f, -2.85200596e-01f, -1.73920974e-01f,
  6.05195224e-01f, 4.64470267e-01f, -2.32281476e-01f, -8.95044804e-02f, -9.87556428e-02f, -2.08888680e-01f, 6.77269548e-02f, 5.52490473e-01f, -5.19204438e-01f, -3.03342547e-02f,
  -4.77464914e-01f, -3.93977612e-01f, -2.95192033e-01f, -8.29204679e-01f, 1.27411008e-01f, -7.69129276e-01f, 9.36053023e-02f, 1.86369605e-02f, -2.85626322e-01f, 7.72423744e-01f,
  -1.26692280e-01f, -2.00453743e-01f, 2.85673052e-01f, -1.15023702e-01f, 2.30236366e-01f, 7.44223595e-01f, 5.50298691e-01f, 7.62918591e-01f, 2.12777182e-01f, -6.28453344e-02f,
  2.83244282e-01f, 3.91433865e-01f, -7.08698213e-01f, -6.40413864e-03f, 1.32232588e-02f, -3.70352000e-01f, 5.22984490e-02f, -4.41531241e-02f, -2.45856851e-01f, 3.24650526e-01f,
  -3.25756550e-01f, -2.93228868e-02f, 8.05227607e-02f, 1.86810821e-01f, 2.81711280e-01f, -1.36255682e-01f, 8.01048040e-01f, 5.36898434e-01f, -6.05835497e-01f, -6.90689459e-02f,
  5.87169707e-01f, -6.91780508e-01f, 4.73963588e-01f, 8.13777074e-02f, -3.36487532e-01f, -9.12326947e-02f
};

// L3_fan_Wp_bar (Shape: 4 x 16)
const int L3_fan_Wp_bar_rows = 4;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  2.69980785e-02f, 7.87629843e-01f, -2.09641591e-01f, 3.53010058e-01f, 8.75991881e-01f, 2.28029877e-01f, -9.00210798e-01f, -1.44649535e-01f, 1.05806363e+00f, -7.19870985e-01f,
  -2.30289754e-02f, 6.54654562e-01f, 9.16521251e-02f, 1.05928385e+00f, 9.62522149e-01f, -1.30934036e+00f, 7.04322755e-01f, -1.00987160e+00f, 2.79444069e-01f, 3.49240333e-01f,
  4.16359276e-01f, 9.83541071e-01f, 1.75336376e-01f, 1.55101728e+00f, -3.70320261e-01f, -8.34997177e-01f, 9.61785316e-01f, -4.39838588e-01f, 1.47997522e+00f, 5.77366352e-01f,
  2.99680065e-02f, -3.63155365e-01f, 3.23490620e-01f, 4.89878833e-01f, -1.95661277e-01f, 7.19774187e-01f, 3.31746787e-02f, 1.09577906e+00f, -8.65605593e-01f, 4.26901847e-01f,
  1.16486526e+00f, -4.55534011e-01f, -3.27467412e-01f, 5.95939100e-01f, -1.18706107e-01f, 7.68771946e-01f, 9.30878222e-01f, 6.98158860e-01f, 1.84124378e-20f, -1.01249305e-19f,
  -8.52469721e-20f, 2.08375068e-20f, -3.47523197e-20f, -2.05179873e-20f, 1.84580604e-20f, -9.57165907e-20f, -1.10948223e-19f, -1.92788901e-21f, -1.43147521e-19f, 3.97515796e-20f,
  -5.86374651e-15f, -6.65373551e-28f, -1.00756471e-20f, -1.38901574e-20f
};

// L3_fan_Bp_bar (Shape: 1 x 4)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 4;
const float L3_fan_Bp_bar_data[] = {
  1.45623907e-01f, 5.69910467e-01f, -6.80739060e-02f, -1.92181663e-19f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  -1.29085481e+00f, 7.87476599e-01f, 1.34142989e-03f, 7.06195906e-02f, -2.19549075e-01f, 1.70364603e-01f, 1.31440908e-01f, 1.31308782e+00f, -1.46457100e+00f, 7.33215332e-01f,
  -1.79866910e-01f, -9.44166780e-01f, 3.75275165e-01f, -4.85412031e-01f, 1.34059474e-01f, 1.28996999e-21f, 3.03423703e-01f, -5.58856308e-01f, -9.69639301e-01f, 3.39810193e-01f,
  -6.61355257e-01f, 8.57985914e-01f, 6.10115886e-01f, -4.95720208e-01f, -1.04105282e+00f, -2.78017104e-01f, -8.42792571e-01f, 5.04248679e-01f, 1.52204216e-01f, 7.03231692e-02f,
  -2.86552906e-01f, -1.56742636e-22f, 1.58980921e-01f, 7.72601962e-01f, 2.08791241e-01f, -9.12292063e-01f, -7.32161999e-01f, -8.34785581e-01f, -3.53310555e-01f, -6.80678427e-01f,
  7.89592862e-01f, 1.21332455e+00f, -1.21513259e+00f, 7.92926908e-01f, -9.69763398e-01f, 1.88338742e-01f, 2.50112891e-01f, 1.40141683e-22f, 5.95843494e-01f, -3.26243967e-01f,
  -7.90018365e-02f, -9.79277968e-01f, 2.94191367e-03f, 6.95051104e-02f, -5.73538721e-01f, -3.43693078e-01f, 3.60219717e-01f, 1.42435253e+00f, -2.36576721e-02f, -1.07757851e-01f,
  4.98497188e-01f, -1.99921310e+00f, 3.08346331e-01f, 1.15061661e-22f, 2.48498097e-01f, -1.25343060e+00f, 2.09338844e-01f, 1.18629432e+00f, 6.78766072e-01f, -1.62786424e+00f,
  1.17021382e+00f, -3.04799024e-02f, 1.03665686e+00f, -7.34219491e-01f, -8.92794728e-01f, -1.02759171e+00f, 4.07927722e-01f, -5.62061250e-01f, 5.78580797e-02f, 2.70838954e-15f,
  6.54995501e-01f, 2.25791290e-01f, 6.14529610e-01f, -1.28402579e+00f, 1.68042290e+00f, 6.31861091e-01f, 4.89105165e-01f, 7.80493617e-01f, 3.08427185e-01f, 6.87541187e-01f,
  1.17662823e+00f, -1.59921683e-02f, -8.19050819e-02f, 4.97675985e-02f, 1.46075234e-01f, -1.10695789e-22f, -4.44988608e-01f, 4.71929491e-01f, -3.98388505e-01f, 1.19594038e+00f,
  -1.09949338e+00f, 1.63977253e+00f, -1.49625504e+00f, 1.70165741e+00f, 9.93844271e-01f, 6.15749955e-01f, 7.19085097e-01f, 1.13816094e-02f, 3.84483516e-01f, -2.30927348e-01f,
  -6.00388169e-01f, 9.61232582e-21f, -1.35423541e+00f, 6.16773665e-01f, 1.12670255e+00f, -8.46410751e-01f, -7.11525083e-01f, -1.14668834e+00f, 1.10268652e+00f, -1.26118958e+00f,
  -1.03433478e+00f, -6.55907094e-01f, 1.17156029e+00f, -1.65143147e-01f, 3.57477553e-02f, 1.05274739e-02f, -6.28213465e-01f, -5.82860924e-23f, 8.09881687e-02f, -6.26801014e-01f,
  -6.93877637e-01f, 7.08306491e-01f, 1.37180030e+00f, -1.10988593e+00f, -8.01457703e-01f, 3.87708455e-01f, -8.86355221e-01f, 3.06092687e-02f, -1.01598108e+00f, 9.84441042e-01f,
  -7.41581976e-01f, 5.00645161e-01f, -1.24433923e+00f, -1.20355688e-22f, 1.83232009e+00f, 8.91294479e-01f, 9.67184901e-01f, 9.96533811e-01f, -8.18493307e-01f, 2.57463828e-02f,
  -7.48503327e-01f, -2.48481560e+00f, 1.23041523e+00f, -1.53289711e+00f, 7.92868912e-01f, 1.55609596e+00f, -5.19250929e-01f, -5.08409739e-01f, -4.41069454e-01f, -6.45077366e-21f,
  -1.05205679e+00f, -8.36794794e-01f, -5.78498781e-01f, 3.08905929e-01f, 1.10726082e+00f, -9.47697103e-01f, -8.37573528e-01f, 6.01657808e-01f, -2.12397918e-01f, -9.56216991e-01f,
  4.12724465e-01f, -1.07934630e+00f, -8.79000008e-01f, -8.47178102e-01f, 7.01127291e-01f, 2.49261820e-22f, -1.27593383e-01f, -7.34273314e-01f, -3.71721953e-01f, -1.15570199e+00f,
  1.90895349e-01f, 8.72101545e-01f, 1.42853701e+00f, -3.26413438e-02f, -3.70028496e-01f, -1.09320208e-01f, 4.87688214e-01f, -1.29013348e+00f, -1.75433660e+00f, 6.42529726e-01f,
  -1.67822969e+00f, -7.53052868e-23f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -7.29700327e-01f, -2.99054503e-01f, -3.08508407e-02f, -1.21937066e-01f, -7.38491774e-01f, -6.89508617e-01f, 8.16543221e-01f, 3.02666485e-01f, 9.35397372e-02f, 6.02610290e-01f,
  1.09060621e-02f, 1.58274129e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    