/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.06088057e-01f, -7.85223395e-02f, -6.16411567e-01f, 2.86627233e-01f, 3.43514234e-01f, 2.98202634e-01f, 2.03910038e-01f, 2.90570110e-01f, 1.40286386e-01f, 4.51834314e-02f,
  -1.62954420e-01f, 8.95420313e-02f, -2.47546565e-02f, -5.23077175e-02f, -2.77045071e-02f, -4.20755483e-02f, -1.33347735e-01f, -3.69440049e-01f, -1.10774845e-01f, 1.17453590e-01f,
  1.79291442e-01f, 1.86370891e-02f, -2.71028608e-01f, -1.24205619e-01f, -2.29622293e-02f, 9.87072708e-04f, -3.57795656e-01f, -2.44298831e-01f, -2.07957000e-01f, -3.65965396e-01f,
  -4.38501388e-01f, 1.40638771e-02f, 1.53305009e-02f, -1.03793088e-02f, -1.33125037e-01f, -6.07770123e-02f, -6.11703796e-03f, -1.59346029e-01f, 6.54077604e-02f, -3.15237185e-03f,
  -1.00662939e-01f, -3.47988345e-02f, -6.60720021e-02f, -1.07637927e-01f, -5.33568896e-02f, 8.46064091e-03f, -9.16908607e-02f, -1.07564397e-01f, -1.65533096e-01f, -9.63141620e-02f,
  3.71753797e-02f, -1.09121308e-01f, -1.64038032e-01f, 2.00874396e-02f, -1.53374940e-01f, -1.08387381e-01f, -1.73307657e-01f, -9.12345424e-02f, -2.35052556e-01f, -4.44819331e-02f,
  4.42297496e-02f, -7.61130592e-03f, 7.89666697e-02f, 4.04736064e-02f, 5.51256016e-02f, 5.14108734e-03f, -4.77489876e-03f, -1.07846307e-02f, -4.91784178e-02f, 1.97618529e-02f,
  6.70486912e-02f, 1.70119014e-02f, -3.86407003e-02f, 1.12023130e-02f, 4.22529317e-02f, -4.33660783e-02f, 6.05946779e-02f, -4.77871709e-02f, -3.89417708e-02f, 4.09316421e-02f,
  1.08146919e-02f, -6.58349767e-02f, -7.53776031e-03f, -6.21732697e-02f, 1.68238208e-02f, 2.75146449e-03f, 8.10395107e-02f, 7.69530609e-02f, 9.43013653e-02f, 6.68173656e-02f,
  2.60601908e-01f, -9.61045846e-02f, 9.69187021e-02f, -8.85043442e-02f, -4.52881940e-02f, -8.53365809e-02f, -1.72200613e-02f, -4.74394560e-02f, -5.65281287e-02f, -1.43629462e-02f,
  -4.99321111e-02f, -3.69688086e-02f, -1.00831822e-01f, -9.50407982e-02f, 1.73354838e-02f, -2.67541986e-02f, -2.77092196e-02f, -4.52698693e-02f, -8.01410452e-02f, -8.66451114e-02f,
  -3.40498239e-02f, 9.46353972e-02f, 1.41837224e-01f, 5.36047108e-02f, -3.32924910e-02f, 1.67895660e-01f, 9.12171304e-02f, 6.25148043e-02f, 1.66280970e-01f, 2.62046129e-01f,
  -5.72271168e-01f, 5.05468786e-01f, 2.56705046e-01f, 1.24605345e-02f, 2.24736854e-01f, 2.42233008e-01f, 4.42484736e-01f, 1.62061408e-01f, -1.24072090e-01f, 5.56273498e-02f,
  1.49891838e-01f, -1.97920874e-01f, -1.76879093e-01f, -2.29493678e-01f, -7.05475584e-02f, 1.90264970e-01f, 5.54852448e-02f, -1.63928568e-01f, -2.45707154e-01f, -7.28194863e-02f,
  6.37871772e-02f, 1.40127599e-01f, 6.36019220e-04f, -1.48862973e-01f, -7.86579251e-02f, -2.24679962e-01f, 2.01618791e-01f, 1.37319848e-01f, -1.66994184e-02f, -2.52043694e-01f,
  -1.82586253e-01f, -8.97180010e-03f, -2.12130353e-01f, -1.37406364e-01f, 5.36008030e-02f, -1.49601728e-01f, -5.20880930e-02f, -5.51551618e-02f, 1.60075556e-02f, -3.66419703e-02f,
  -8.12922344e-02f, -5.01927584e-02f, -7.53193200e-02f, -4.29129601e-02f, 4.93917912e-02f, -1.99615769e-02f, -1.12876907e-01f, -3.36216912e-02f, 1.99694261e-02f, -4.98853214e-02f,
  2.77244765e-03f, 2.47087106e-02f, 1.28172398e-01f, 1.18837990e-01f, 3.02569419e-02f, -1.80324748e-01f, -1.55026661e-02f, -1.25855207e-01f, -1.86612662e-02f, -9.71737579e-02f,
  -7.84666685e-04f, 8.01210031e-02f, -2.39213207e-03f, 1.98290408e-01f, 4.70699482e-02f, 7.68739879e-02f, -1.54189076e-02f, 8.53083208e-02f, -1.51417591e-02f, 9.53929201e-02f,
  7.80352652e-02f, 8.02874938e-02f, -4.91158059e-03f, 1.35576442e-01f, -2.60508023e-02f, 1.41922742e-01f, 7.22769136e-03f, 3.49694416e-02f, 7.17912167e-02f, 6.73851967e-02f,
  2.74531282e-02f, 1.80434100e-02f, 7.39113241e-02f, 8.33039060e-02f, 8.95759240e-02f, 1.55495778e-02f, 1.19678155e-02f, 8.75215009e-02f, 9.52340066e-02f, 1.01305850e-01f,
  9.05863792e-02f, 1.17356539e-01f, -1.55690163e-01f, -1.23768106e-01f, -1.57998160e-01f, -6.53528124e-02f, -1.83943212e-02f, -6.60437793e-02f, -9.77870524e-02f, -5.73671386e-02f,
  1.21454978e-02f, -9.96364504e-02f, 6.24711858e-03f, -3.66396978e-02f, 2.77990121e-02f, 5.18728700e-03f, 5.80841750e-02f, -1.51219904e-01f, -7.00877830e-02f, -1.37804751e-03f,
  5.32436147e-02f, -1.73059124e-02f, -7.05546886e-02f, -3.37866507e-03f, 3.05255558e-02f, -1.36876374e-01f, 1.79403741e-02f, -3.64523008e-02f, -4.95704822e-02f, 1.79034427e-01f,
  -4.87988204e-01f, 5.93502894e-02f, 2.36424863e-01f, -2.18397573e-01f, 3.47251706e-02f, 2.42549926e-01f, 2.69987166e-01f, -9.32455137e-02f, -1.94612712e-01f, -2.71656532e-02f,
  -2.64230192e-01f, -3.37118685e-01f, -2.90305048e-01f, -1.09971501e-01f, -1.49480209e-01f, 2.05908686e-01f, 2.15133741e-01f, 1.59490898e-01f, 1.10276610e-01f, 6.74053729e-02f,
  2.58959290e-02f, -3.33669148e-02f, -3.32938135e-02f, 9.72124934e-02f, 6.08057827e-02f, -9.39930901e-02f, 1.06360994e-01f, -2.00586040e-02f, 1.56672940e-01f, 3.66245359e-01f,
  1.50806680e-01f, 7.74516165e-03f, -8.41246396e-02f, -5.80862798e-02f, 4.07471955e-02f, -3.10185906e-02f, 6.61200061e-02f, -1.91557743e-02f, 2.37729549e-02f, 5.45962155e-02f,
  2.69702189e-02f, -2.02432424e-02f, -2.88573559e-02f, 4.16732430e-02f, 2.82580517e-02f, 1.23016676e-02f, -7.17196763e-02f, 1.15922846e-01f, -1.42658539e-02f, 8.07733014e-02f,
  1.10477127e-01f, 5.46245575e-02f, 8.16603750e-02f, -5.72177470e-02f, -2.92964075e-02f, -4.15828428e-04f, 1.04056522e-01f, 6.33172393e-02f, 3.67696211e-02f, 1.04061373e-01f,
  5.00972122e-02f, -9.55738593e-03f, 4.17861007e-02f, 2.04540212e-02f, -1.71182118e-02f, -2.80336058e-03f, -4.79120836e-02f, -7.18268193e-03f, 4.58131209e-02f, -2.46930644e-02f,
  -4.66199033e-02f, 1.58639830e-02f, -2.55147405e-02f, -1.04315560e-02f, -2.39485018e-02f, 2.40639634e-02f, 3.89774479e-02f, -5.49789667e-02f, -2.95646396e-02f, -9.03293937e-02f,
  -1.16004853e-03f, 6.53042272e-03f, -6.05941676e-02f, 2.68364865e-02f, -8.32528993e-03f, 5.56354001e-02f, -2.60437038e-02f, -1.75516568e-02f, -4.30874266e-02f, 2.37716306e-02f,
  -3.86083454e-01f, -1.79483950e-01f, -7.76513591e-02f, -8.44404697e-02f, -2.20259242e-02f, -4.40833382e-02f, -1.13545425e-01f, -3.95198129e-02f, -8.55231062e-02f, -2.56427918e-02f,
  -1.73418280e-02f, -4.72832844e-02f, -8.66491571e-02f, 1.32019399e-02f, -4.38652635e-02f, -6.49235919e-02f, -4.65874746e-02f, -6.59725592e-02f, 1.81142036e-02f, -2.21718270e-02f,
  -3.23934518e-02f, -3.06791086e-02f, -1.26052663e-01f, -9.87443551e-02f, -7.21402988e-02f, -1.48492396e-01f, -1.72791537e-02f, -1.19445985e-02f, -1.70630172e-01f, -1.05072282e-01f,
  6.13356650e-01f, 2.13372424e-01f, 3.13222408e-01f, 2.93948203e-02f, -1.70458090e-02f, 1.76159725e-01f, 3.79044682e-01f, 1.93430796e-01f, -2.32302807e-02f, 1.44709364e-01f,
  -6.79193586e-02f, -2.06393287e-01f, -1.65265024e-01f, -1.61634728e-01f, 2.24796146e-01f, 3.72290820e-01f, 3.95305902e-01f, 8.85312185e-02f, 6.96969107e-02f, -2.97701284e-02f,
  -2.16929674e-01f, 3.79100963e-02f, 7.49466270e-02f, 5.07567264e-03f, -5.11356182e-02f, -1.35217249e-01f, 4.78746332e-02f, 4.68458198e-02f, 1.28110528e-01f, -9.09529924e-02f,
  1.28450161e-02f, 1.66968763e-01f, -4.74371724e-02f, -1.05413370e-01f, -4.69564274e-02f, 1.01118654e-01f, 4.92353328e-02f, -3.23364288e-02f, 1.58569571e-02f, 7.82101378e-02f,
  -1.12984972e-02f, -3.34232487e-02f, 6.44038841e-02f, -5.58496043e-02f, 9.01035070e-02f, 4.89224494e-02f, 1.57920063e-01f, 1.04099020e-01f, 4.10056747e-02f, 6.97477460e-02f,
  -2.46599372e-02f, 1.24036282e-01f, 2.29779601e-01f, 1.49015024e-01f, 9.74417925e-02f, -1.27985626e-02f, 1.00326248e-01f, 7.03340918e-02f, 1.18797362e-01f, 1.12595744e-01f,
  -5.96415857e-03f, -6.43884763e-02f, -8.93671140e-02f, 6.64205700e-02f, -6.88683093e-02f, -5.45273572e-02f, -5.97205535e-02f, -5.39906509e-02f, -2.60232445e-02f, -5.29147573e-02f,
  -9.94602218e-02f, -5.67534752e-02f, -1.44070148e-01f, -8.77047926e-02f, -1.33450314e-01f, -6.33727685e-02f, -1.42935395e-01f, -6.43358529e-02f, -6.39868379e-02f, -1.08299606e-01f,
  -3.63099165e-02f, -6.12031110e-02f, -1.24673873e-01f, -1.09623000e-01f, -3.20015587e-02f, -2.25001369e-02f, -3.30746025e-02f, -1.50426373e-01f, -8.65272526e-03f, 1.76207386e-02f,
  -2.41609901e-01f, -1.51071483e-02f, 3.76250744e-02f, 7.28875697e-02f, -6.02042228e-02f, 3.08357030e-02f, -6.46918193e-02f, -1.15538891e-02f, -1.14824824e-01f, 9.47635770e-02f,
  2.08901744e-02f, 2.63353195e-02f, 1.10348482e-02f, 6.36897460e-02f, 1.25672132e-01f, 1.04326978e-01f, 1.77389383e-01f, 6.81714714e-02f, -2.58326326e-02f, 4.05607559e-02f,
  1.01186074e-01f, 1.32931545e-01f, 1.87877417e-01f, 1.31334782e-01f, 7.93150216e-02f, 3.72121371e-02f, 1.09839782e-01f, -9.26662982e-03f, 1.18208431e-01f, 3.18143487e-01f,
  -8.70001197e-01f, 1.61228374e-01f, -1.77924857e-01f, -3.05799842e-01f, 2.92393863e-01f, 9.39602107e-02f, 1.80466160e-01f, -9.00039002e-02f, -1.15280189e-01f, -3.38542722e-02f,
  1.12662956e-01f, 6.84557334e-02f, 4.83704805e-02f, 2.16599461e-02f, -2.08850484e-02f, -2.78344452e-02f, -2.46370658e-02f, -1.21573329e-01f, -2.07780376e-01f, 7.08915591e-02f,
  1.63146660e-01f, -1.76039338e-01f, -2.05293894e-01f, -1.16079547e-01f, 5.66481426e-02f, -5.87419346e-02f, -3.70197487e-03f, 5.06788380e-02f, 7.23405257e-02f, -1.08818799e-01f,
  -2.41365269e-01f, -1.78685889e-01f, 4.58443835e-02f, 2.07660384e-02f, 5.74886575e-02f, -1.58824533e-01f, -6.70623854e-02f, -1.07912876e-01f, -5.13324440e-02f, -1.36179447e-01f,
  6.91808835e-02f, -5.49207740e-02f, -3.12544070e-02f, -2.65683662e-02f, -4.76370528e-02f, -6.56292215e-02f, -7.41869286e-02f, -1.20648563e-01f, -1.00320959e-02f, 3.86641710e-03f,
  1.94029346e-01f, -4.34396900e-02f, -3.70685868e-02f, 3.31627056e-02f, 8.60832930e-02f, 6.45084009e-02f, -3.31526459e-03f, 5.03843017e-02f, -1.80034209e-02f, -2.48066068e-01f,
  -4.23422270e-02f, 7.03616589e-02f, 9.85862315e-02f, -9.82384309e-02f, -1.45776644e-02f, 1.72038209e-02f, -4.29899693e-02f, 1.73918530e-02f, -3.47063295e-03f, -3.34643270e-03f,
  -1.19809955e-02f, -1.35253451e-03f, 1.03860814e-02f, -7.17053413e-02f, 7.16249272e-02f, 6.16629198e-02f, 2.55607776e-02f, 4.12504226e-02f, 2.80213468e-02f, 1.81578211e-02f,
  -4.24882099e-02f, 8.02977532e-02f, 1.54169668e-02f, -1.39278751e-02f, 1.17619686e-01f, 1.84594467e-02f, -2.12574806e-02f, 6.85410798e-02f, -4.31021163e-03f, 3.20188031e-02f,
  -1.21067680e-01f, 3.19451243e-01f, -1.60384834e-01f, -2.81741694e-02f, -8.36913008e-03f, 4.93559465e-02f, -2.15149932e-02f, 4.99606598e-03f, 8.47471803e-02f, -2.89619602e-02f,
  1.01268455e-01f, -3.49028297e-02f, 2.28862986e-02f, -1.54972300e-02f, -7.82913193e-02f, -4.67082709e-02f, 5.11233285e-02f, -6.58745542e-02f, 6.89130723e-02f, -7.75065506e-04f,
  8.13339204e-02f, -1.33426413e-01f, -2.33945042e-01f, 7.07072252e-03f, 1.47729171e-02f, -6.00145124e-02f, 3.01806387e-02f, -7.56107718e-02f, -1.16547219e-01f, -2.96714395e-01f,
  -5.56396723e-01f, -2.72607923e-01f, 4.11100656e-01f, -1.38533801e-01f, 9.75491852e-02f, 2.07768589e-01f, 2.37155437e-01f, 1.26993544e-02f, -6.92581311e-02f, 9.49953794e-02f,
  -2.56027192e-01f, -3.00321370e-01f, 2.56471913e-02f, 7.86680877e-02f, 3.04954380e-01f, 5.26336372e-01f, 5.20991206e-01f, 3.72940093e-01f, 2.22157940e-01f, 2.05538869e-02f,
  -4.45502326e-02f, 2.15872210e-02f, -2.20097210e-02f, 1.80477604e-01f, -2.18310744e-01f, 3.98952626e-02f, 1.44920722e-01f, -1.87063515e-01f, -1.44923404e-01f, -1.83987960e-01f,
  -1.19166315e-01f, -3.84450704e-01f, 2.22315758e-01f, -4.40481380e-02f, 4.48984616e-02f, 2.19995342e-03f, -4.62505184e-02f, 7.29720965e-02f, -1.78827867e-02f, 1.07844062e-01f,
  3.36567312e-02f, 4.78624552e-02f, -8.90098233e-03f, -5.28039522e-02f, -3.02057415e-02f, 8.94602202e-03f, 1.29609808e-01f, 1.32107988e-01f, 1.00484535e-01f, -2.27908250e-02f,
  -2.90850922e-02f, -8.01174492e-02f, 1.76830553e-02f, 1.30785808e-01f, 3.57412361e-02f, 1.31224543e-01f, -6.76110294e-03f, -1.00041851e-01f, 1.36339162e-02f, -1.89713761e-02f,
  8.40098262e-02f, 9.26162004e-02f, -7.56472945e-02f, -1.05030715e-01f, -7.06908852e-02f, -1.30536675e-03f, -5.76970130e-02f, -5.53479418e-02f, 2.25720592e-02f, -3.21146324e-02f,
  -2.32312083e-02f, -2.76971105e-02f, -2.12423783e-03f, -1.87603813e-02f, 3.62414084e-02f, -6.69685155e-02f, -8.80025625e-02f, -4.28174883e-02f, 8.57483596e-03f, -9.08714831e-02f,
  -2.64165904e-02f, 2.85977293e-02f, -5.74729033e-02f, -4.71118884e-03f, -6.04973510e-02f, -2.54153851e-02f, -3.58495787e-02f, -1.59056485e-01f, -5.39193973e-02f, -6.82084188e-02f,
  -4.49022911e-02f, 1.49593115e-01f, -7.14077950e-02f, 7.35475272e-02f, 3.23279090e-02f, 3.41316387e-02f, 6.00605644e-03f, 6.57798573e-02f, -5.79661131e-02f, -3.07803508e-02f,
  -3.58069986e-02f, -1.35899230e-03f, 2.89658811e-02f, 5.52174523e-02f, 1.08683392e-01f, 1.93403773e-02f, 1.08336218e-01f, 5.36923744e-02f, 3.27632427e-02f, -3.18812504e-02f,
  1.21126391e-01f, 1.39053330e-01f, 1.02587290e-01f, 1.33973598e-01f, 5.25561022e-03f, 1.18261710e-01f, 3.34367342e-02f, 3.09967883e-02f, 2.55164117e-01f, 1.27506241e-01f,
  -2.18609452e-01f, -2.67236799e-01f, -4.18472260e-01f, 1.17096595e-01f, 1.47562176e-01f, -1.65838212e-01f, -4.53491807e-01f, -1.15502529e-01f, 2.50503451e-01f, -1.39189065e-01f,
  1.40994906e-01f, 4.10321087e-01f, 1.97356567e-01f, 2.22690292e-02f, -1.92680404e-01f, -3.81055802e-01f, -3.69023442e-01f, -2.09365338e-01f, -3.09299380e-02f, 1.01101324e-01f,
  1.69894144e-01f, 7.86871165e-02f, 9.13117677e-02f, 1.98067222e-02f, -1.12599820e-01f, 9.88525823e-02f, -2.68736601e-01f, -8.37549344e-02f, -2.07637474e-01f, -2.66792148e-01f,
  -3.34404051e-01f, -1.24538317e-01f, -2.46473821e-03f, 1.80038571e-01f, -1.79742492e-05f, -3.45888995e-02f, -8.46817791e-02f, 1.27457557e-02f, 6.44860938e-02f, -7.73170516e-02f,
  9.47307199e-02f, 1.05807915e-01f, 8.10061321e-02f, -1.78467424e-03f, -1.11116919e-04f, 1.18919904e-03f, -8.05477872e-02f, -5.13845272e-02f, -4.16944511e-02f, 6.49180589e-03f,
  2.32258320e-01f, 1.17368132e-01f, -2.70150509e-02f, -2.83407629e-04f, -2.42315885e-02f, 3.00153960e-02f, -1.18526444e-01f, -6.54920861e-02f, -2.00210422e-01f, -2.21762165e-01f,
  2.00505078e-01f, 4.40432318e-02f, 6.73719794e-02f, -2.08858196e-02f, 2.51472779e-02f, 8.82782880e-03f, 7.26349875e-02f, 4.63255197e-02f, 4.32996713e-02f, -1.87739283e-02f,
  1.07115477e-01f, -6.77487254e-02f, 2.51225159e-02f, -7.30856732e-02f, 6.76735267e-02f, 2.03284272e-03f, 1.38914064e-02f, 1.26638096e-02f, 5.88468648e-02f, 7.88596459e-03f,
  4.74957330e-03f, 1.13584884e-02f, 5.53690381e-02f, 1.20702488e-02f, -5.28402701e-02f, -1.47884488e-02f, -4.52757217e-02f, 7.80362189e-02f, 4.85175028e-02f, 2.94475872e-02f,
  -5.54922931e-02f, 4.38593552e-02f, -7.69983903e-02f, -7.66390041e-02f, 5.76652922e-02f, -2.29729507e-02f, 4.09737229e-02f, -9.04101506e-02f, 2.13238839e-02f, -8.58196095e-02f,
  5.14072850e-02f, -8.02087784e-02f, -3.48854847e-02f, -7.68408296e-04f, -3.08838692e-02f, -2.16779839e-02f, 1.05890958e-02f, -1.38226589e-02f, -4.72052433e-02f, 2.31206603e-02f,
  -1.86764263e-02f, -5.28579615e-02f, -1.45847872e-01f, -1.41889025e-02f, -2.63166688e-02f, -1.33466395e-02f, -1.73092172e-01f, -1.00949533e-01f, -1.64580852e-01f, -2.91978270e-01f,
  6.27119243e-01f, -2.39659324e-01f, 4.32827383e-01f, 1.87222093e-01f, -1.22545034e-01f, -6.93956215e-04f, -2.11266786e-01f, -1.36852667e-01f, 7.70261660e-02f, -1.12979040e-02f,
  -2.71563560e-01f, -9.97239873e-02f, -1.07671417e-01f, -1.37584716e-01f, -8.23611990e-02f, 1.05633684e-01f, 1.83338016e-01f, 2.37055376e-01f, 1.75192103e-01f, -6.96964860e-02f,
  -2.04717353e-01f, -2.86768433e-02f, 7.27591589e-02f, 4.95625986e-03f, -1.74053665e-02f, 6.34995699e-02f, 1.91236362e-01f, -6.42836001e-03f, 7.21259648e-03f, 3.66450876e-01f,
  2.80321062e-01f, 3.56591865e-02f, 1.07310712e-01f, -3.54928374e-02f, 1.44371949e-02f, 1.65639162e-01f, 1.51367635e-02f, 8.69940594e-02f, -4.03090864e-02f, 1.04750097e-01f,
  -2.28209123e-02f, 5.14164492e-02f, -1.69208925e-02f, 2.45977249e-02f, 3.05264760e-02f, 3.56930196e-02f, 3.09082344e-02f, 1.35591596e-01f, 1.66818976e-01f, -4.85913642e-02f,
  -2.76193544e-02f, 1.72686711e-01f, 9.48010832e-02f, 8.04586262e-02f, 1.01604693e-01f, 1.35656938e-01f, 1.30120264e-02f, 6.83783069e-02f, 1.37327179e-01f, 1.32736698e-01f,
  3.32700531e-03f, 1.15151778e-01f, -4.89192307e-02f, -1.12223715e-01f, -2.85614259e-03f, -2.30794549e-02f, 3.12143322e-02f, -5.41375950e-02f, -9.02720839e-02f, 6.90179095e-02f,
  -4.78842035e-02f, -6.63076807e-03f, -4.52727042e-02f, 2.97153201e-02f, -4.49962132e-02f, 7.03184381e-02f, 6.66046515e-02f, -7.81221315e-02f, -4.32728119e-02f, -3.73272933e-02f,
  8.07625242e-03f, 6.57451153e-02f, 4.07572649e-02f, -9.04114544e-02f, 9.41141322e-03f, 4.62115789e-03f, 8.29784870e-02f, -9.69643444e-02f, -8.46597105e-02f, -2.37232642e-04f,
  -1.08536184e-01f, -1.82379380e-01f, 1.17587142e-01f, 7.60048702e-02f, 8.66432786e-02f, 1.09271193e-02f, 5.43623790e-02f, 4.28649131e-03f, 4.37845066e-02f, 1.39591992e-02f,
  1.28620137e-02f, 8.98960158e-02f, -3.75696309e-02f, 8.55836645e-03f, -7.27889389e-02f, 7.49441376e-03f, -3.45523134e-02f, 9.24050286e-02f, 1.45875448e-02f, 8.50970224e-02f,
  2.96560898e-02f, 1.73592880e-01f, 9.95815545e-02f, 1.21141747e-01f, 5.07190488e-02f, 1.08596876e-01f, 2.25707833e-02f, 1.11803949e-01f, 6.58750907e-02f, 1.32660583e-01f,
  -5.52663088e-01f, 4.46208924e-01f, 2.42135823e-01f, -3.48544747e-01f, 2.23155364e-01f, 2.87454724e-01f, 6.08119488e-01f, 9.32997242e-02f, -2.78411359e-01f, 9.83029455e-02f,
  1.94465250e-01f, -1.81325376e-01f, -1.62583575e-01f, -1.30443856e-01f, 1.17522679e-01f, 3.65423381e-01f, 1.07518345e-01f, -1.82484552e-01f, -1.79045171e-01f, -1.28409624e-01f,
  -2.85766628e-02f, -1.57091960e-01f, -3.15414190e-01f, -2.70114034e-01f, 5.86108826e-02f, 1.07811885e-02f, 1.99119776e-01f, 6.10884279e-02f, 2.88187206e-01f, -6.00805134e-03f,
  1.26402989e-01f, -7.70881656e-04f, -1.48959070e-01f, -1.30896091e-01f, 2.44050287e-02f, -6.07964918e-02f, 5.75202033e-02f, -8.03775936e-02f, -5.61749004e-02f, -5.39588369e-02f,
  -3.88968028e-02f, -1.12043470e-02f, 6.73536072e-03f, -4.81194556e-02f, -4.73142564e-02f, 4.66775075e-02f, -1.31100371e-01f, -1.21446602e-01f, 6.90200999e-02f, 2.78388076e-02f,
  -3.84171784e-04f, 5.61204478e-02f, 1.32954702e-01f, 3.63336988e-02f, 1.18350461e-02f, -1.62032023e-01f, 1.21489927e-01f, 6.76954836e-02f, 5.97963892e-02f, 1.81481130e-02f,
  -1.88711360e-01f, -3.67693156e-02f, 4.50148173e-02f, 5.33285253e-02f, 1.07170306e-01f, 7.49514848e-02f, 2.69846059e-02f, 1.00429431e-01f, -1.36273876e-02f, 6.62126988e-02f,
  3.27579677e-02f, 2.49124970e-02f, 8.16973075e-02f, 1.21015236e-02f, 9.05741565e-03f, 9.33442116e-02f, 5.15071563e-02f, -2.36077867e-02f, 6.87997565e-02f, 1.98032446e-02f,
  6.36312217e-02f, 2.16162372e-02f, 1.20392144e-02f, 1.34023735e-02f, -4.57979040e-03f, 3.37991416e-02f, -3.50986496e-02f, 5.91636710e-02f, 4.12026681e-02f, 2.89718360e-02f,
  -4.93199676e-02f, 1.18595688e-02f, -7.86305666e-02f, -1.55179977e-01f, -3.67603302e-02f, -9.59194377e-02f, -5.18247150e-02f, -9.82866623e-03f, -3.09994128e-02f, -6.39816672e-02f,
  -7.02543035e-02f, -6.82612807e-02f, 6.15228117e-02f, 4.34180945e-02f, -1.34762069e-02f, -4.23800796e-02f, -2.89966334e-02f, -1.83094069e-02f, -5.18333800e-02f, -7.18459338e-02f,
  -3.89738493e-02f, 1.01557761e-01f, 9.26391259e-02f, 1.35115653e-01f, -6.82412535e-02f, -7.45895430e-02f, 9.94464010e-02f, 2.00813194e-03f, 7.05173910e-02f, 1.68536082e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.22263408e+00f, 3.76764238e-01f, 2.87234113e-02f, 5.20816684e-01f, 2.01860607e-01f, -8.23248997e-02f, -9.55490991e-02f, 1.42898979e-02f, 1.43911183e-01f, 3.57072979e-01f,
  3.53645027e-01f, 3.91835898e-01f, 2.78375000e-01f, 3.11365187e-01f, 1.02546319e-01f, 2.84210686e-03f, -1.08091697e-01f, 1.42757952e-01f, 1.42723620e-01f, 2.63152242e-01f,
  3.71188700e-01f, 2.08507031e-01f, 1.52362615e-01f, 1.37306631e-01f, 2.81564534e-01f, 1.70616269e-01f, 7.81417787e-02f, 8.17852989e-02f, 2.81295449e-01f, 3.71509850e-01f,
  5.80712199e-01f, 2.28726402e-01f, -2.35276222e-01f, 5.95199615e-02f, 1.18041961e-02f, -4.18873355e-02f, 3.97309512e-02f, -7.43907318e-02f, 9.84693989e-02f, -6.66111261e-02f,
  9.49418638e-03f, 3.54225188e-02f, 2.00080369e-02f, -9.19491239e-03f, -1.46043628e-01f, -1.56343818e-01f, -1.29499570e-01f, -6.39052317e-02f, -7.99527764e-02f, 8.69359523e-02f,
  1.58714756e-01f, -4.55659218e-02f, -1.59747988e-01f, -1.71614155e-01f, 8.77943709e-02f, 8.42417590e-03f, -1.15287274e-01f, -1.68011133e-02f, -1.07829347e-01f, 4.72348109e-02f,
  3.44995677e-01f, 2.41360292e-01f, 2.03183264e-01f, 1.28176853e-01f, 1.10605441e-01f, -5.84058836e-02f, -1.37996161e-02f, -1.53832482e-02f, 1.49578318e-01f, -3.58956605e-02f,
  -1.51512325e-01f, 5.60871437e-02f, 1.07360713e-01f, 1.19913496e-01f, 2.05213904e-01f, 1.21884942e-01f, -3.36650461e-02f, -3.99542972e-02f, 1.21495957e-02f, -1.13498524e-01f,
  3.98844220e-02f, -2.78980583e-01f, -1.24414086e-01f, -1.46216258e-01f, -2.86177844e-01f, 4.39903550e-02f, 1.67109922e-01f, 1.10345662e-01f, 3.62349674e-02f, 9.85817611e-02f,
  -3.34673345e-01f, -2.23033458e-01f, 6.29035830e-02f, -8.54217485e-02f, -1.21864349e-01f, -3.15652676e-02f, 1.12922058e-01f, -1.32562518e-01f, -8.69642422e-02f, 4.85232100e-03f,
  -9.58446041e-02f, 6.55585667e-03f, 3.15620974e-02f, -1.90103382e-01f, -2.76846468e-01f, -1.71884894e-01f, -2.08380613e-02f, 1.71756500e-03f, -1.83108270e-01f, -1.70465484e-01f,
  -9.19641331e-02f, -2.93968737e-01f, -2.54453212e-01f, -2.07993969e-01f, -1.47654817e-01f, -1.02574788e-01f, -2.74484217e-01f, -1.65553942e-01f, -3.03177625e-01f, -1.46229059e-01f,
  2.48595819e-01f, -2.57386059e-01f, 6.09068096e-01f, 5.19145250e-01f, 7.32618034e-01f, 9.33567762e-01f, 8.53073955e-01f, 5.31186640e-01f, 3.05468380e-01f, 2.13714331e-01f,
  9.40979179e-03f, -1.73565924e-01f, -7.12199137e-02f, 3.18181552e-02f, 1.96968138e-01f, 2.90188223e-01f, 3.37098747e-01f, 1.42777428e-01f, 1.46637380e-01f, 1.30726844e-01f,
  5.97137772e-02f, 1.10521697e-01f, -7.82952011e-02f, -1.82110276e-02f, -3.75309512e-02f, -6.90775812e-02f, 1.15460642e-01f, 1.54941127e-01f, -2.07023788e-02f, -5.16061664e-01f,
  -3.31723630e-01f, 5.03465086e-02f, -1.01702690e-01f, -3.03788841e-01f, -1.29416615e-01f, -3.63625973e-01f, -7.76228681e-02f, -3.01068991e-01f, -2.31079906e-01f, -2.11705849e-01f,
  -2.62306593e-02f, -4.75411639e-02f, 1.24649487e-01f, -4.99288850e-02f, 1.45293744e-02f, -4.43667807e-02f, -7.69967735e-02f, 1.52038783e-01f, 2.27730200e-01f, -2.02586632e-02f,
  2.59124804e-02f, 2.07456380e-01f, 2.36361206e-01f, 1.55624747e-01f, 1.82977244e-01f, -2.11653411e-02f, -2.22848672e-02f, -7.46194720e-02f, -8.49912222e-03f, -1.40321985e-01f,
  -6.24619983e-03f, -4.71682101e-02f, 2.03377739e-01f, 2.76850294e-02f, 2.80165616e-02f, -4.48994972e-02f, 4.67784330e-02f, 2.22458661e-01f, 2.80365974e-01f, 1.41346484e-01f,
  -1.25270747e-02f, 8.54340717e-02f, 1.32843331e-01f, 2.14936608e-03f, -6.40279204e-02f, 1.20032076e-02f, 6.81741163e-03f, -5.10426238e-02f, 7.97301903e-02f, 1.10844150e-01f,
  2.24008515e-01f, 1.06115229e-01f, -8.91037956e-02f, 1.69664212e-02f, 5.55221699e-02f, 5.04170917e-02f, -7.62004256e-02f, -6.29614443e-02f, 1.30536109e-02f, -9.80302393e-02f,
  -3.91347595e-02f, 5.29409468e-01f, -1.50942385e-01f, -7.79896975e-02f, 9.52951238e-03f, -1.61188394e-01f, 4.05423678e-02f, -1.74440444e-01f, -2.23210528e-01f, -1.99320484e-02f,
  2.23986711e-02f, -1.01393908e-01f, 4.85533103e-02f, -1.06013548e-02f, 8.85370001e-02f, 6.77471533e-02f, -3.38920876e-02f, 1.84897333e-01f, -2.87061371e-02f, -2.23484933e-01f,
  -3.80498134e-02f, 3.02685171e-01f, 2.31833369e-01f, 8.19299072e-02f, -5.33258989e-02f, -2.60953475e-02f, -1.84978932e-01f, -4.25930172e-02f, 1.29120767e-01f, -1.97120816e-01f,
  3.56334001e-01f, 9.32855010e-01f, 6.43956602e-01f, -2.51879901e-01f, -5.84700033e-02f, 1.21151712e-02f, 3.49937648e-01f, 2.43599966e-01f, -6.63335323e-02f, 1.47992939e-01f,
  -1.48295417e-01f, -4.41788524e-01f, -1.22705452e-01f, -7.98782706e-02f, -2.29068995e-02f, 2.12635353e-01f, 2.01402247e-01f, 7.25454092e-02f, -3.74064296e-01f, -5.79508245e-01f,
  -4.39073533e-01f, -1.55400157e-01f, -2.68595144e-02f, -6.56117573e-02f, 1.87746733e-01f, -4.03919011e-01f, 3.28966945e-01f, 2.68406153e-01f, 1.23970978e-01f, 3.14133197e-01f,
  1.55353993e-01f, 7.94278502e-01f, -9.13485110e-01f, -2.35621139e-01f, 3.02091390e-01f, -1.64174095e-01f, -3.02310705e-01f, 1.20266624e-01f, 4.28754315e-02f, 6.64914846e-02f,
  -5.33973835e-02f, -5.10040559e-02f, 1.68366984e-01f, 6.09375425e-02f, 5.31987101e-02f, -9.54945013e-02f, 1.69513196e-01f, 1.50791153e-01f, 3.36366482e-02f, 6.24045655e-02f,
  -3.23005110e-01f, -6.81508780e-02f, 3.18866640e-01f, 7.64290690e-02f, 3.51254612e-01f, -1.37228593e-01f, 3.15654963e-01f, 7.36292973e-02f, 8.83232728e-02f, 2.15118099e-02f,
  -4.70811874e-01f, 1.60034955e-01f, 1.12779371e-01f, -1.92282889e-02f, -6.57687485e-02f, -7.38743916e-02f, -1.93464197e-02f, -9.25687328e-02f, -1.75950732e-02f, 6.31513819e-02f,
  -8.59951004e-02f, -2.04030544e-01f, -3.82784680e-02f, -1.20333888e-01f, -2.98398525e-01f, 1.51925862e-01f, 5.50885424e-02f, -4.39971760e-02f, -8.37277249e-02f, 3.67438719e-02f,
  -4.83433306e-02f, 1.28998458e-01f, -2.80072577e-02f, -4.74297162e-03f, -2.08040178e-01f, -1.78507924e-01f, -2.09791988e-01f, -4.82723452e-02f, -8.98921192e-02f, -1.19464651e-01f,
  -2.55406439e-01f, -2.06799105e-01f, -4.47847933e-01f, 1.72294602e-01f, 2.83929914e-01f, 2.46337354e-01f, -1.57894604e-02f, 6.88041896e-02f, 2.01047122e-01f, 1.09838685e-02f,
  7.39072487e-02f, -8.37848708e-02f, 3.40481579e-01f, 8.05019401e-03f, -4.02066290e-01f, -2.03306064e-01f, -2.40101561e-01f, -1.69706196e-01f, -2.77151227e-01f, 6.41767010e-02f,
  -9.03532729e-02f, -4.07956034e-01f, -6.47901118e-01f, -2.16992706e-01f, -3.21816891e-01f, -8.37305009e-01f, -3.62238377e-01f, -2.63230026e-01f, -4.04710889e-01f, -6.52378619e-01f,
  -3.13174307e-01f, 1.16777696e-01f, -1.22546542e+00f, -1.21714890e+00f, -8.16384971e-01f, 8.07595812e-03f, 6.94332182e-01f, 3.17838758e-01f, -5.37055612e-01f, 3.85271176e-03f,
  3.17738116e-01f, 1.57678753e-01f, -2.80061424e-01f, 2.12673038e-01f, 7.32286274e-01f, 6.19822331e-02f, -4.83169317e-01f, -2.73368359e-01f, 2.78911442e-01f, 6.06104732e-01f,
  3.76991034e-01f, -3.69490772e-01f, -1.93440035e-01f, -1.50635198e-01f, -7.63229549e-01f, -3.29149514e-01f, -9.08927500e-01f, -6.51396096e-01f, 1.55614659e-01f, -7.26618588e-01f,
  -2.54756957e-01f, -6.13983989e-01f, 1.95412617e-02f, 1.53965846e-01f, -2.46936977e-01f, 1.39580935e-01f, 1.79733500e-01f, -3.13068181e-01f, -5.27583575e-03f, -1.61655456e-01f,
  -3.24823290e-01f, 1.42928183e-01f, -1.86008915e-01f, -5.61391301e-02f, -3.18116695e-01f, -6.93353713e-02f, -2.44029224e-01f, 1.87573079e-02f, -2.22658217e-01f, 7.48964921e-02f,
  7.11716935e-02f, -8.51920694e-02f, -2.51983106e-01f, 9.10414755e-02f, -7.31970444e-02f, -2.65161514e-01f, -2.67110709e-02f, -1.28168687e-01f, -1.27066940e-01f, -1.89254940e-01f,
  4.52205203e-02f, -1.22626647e-01f, 2.00786628e-02f, 5.03901280e-02f, 1.74111426e-01f, -8.15548301e-02f, -1.13561779e-01f, 1.56027123e-01f, 2.13770662e-02f, 8.08572993e-02f,
  1.98259633e-02f, -9.16825235e-02f, -4.24381724e-04f, -1.07467733e-02f, -8.92947763e-02f, -1.65734887e-01f, 4.29940820e-02f, 2.16597021e-01f, -1.04090765e-01f, -2.71276422e-02f,
  7.90514797e-02f, 7.68012460e-03f, -2.85270512e-01f, 1.60587743e-01f, 1.19071960e-01f, -7.01972470e-02f, 4.67514694e-02f, 2.89450079e-01f, 7.10212290e-02f, -1.16201952e-01f,
  2.49024741e-02f, 2.51901001e-01f, -2.55608819e-02f, 1.59057006e-01f, -2.24431038e-01f, -1.49520680e-01f, -1.99349135e-01f, 7.20198601e-02f, -2.21546531e-01f, 3.49695683e-02f,
  1.42587172e-02f, 8.50197300e-02f, -1.40790522e-01f, 1.00239329e-01f, 3.91112305e-02f, -3.64607386e-02f, 3.41027498e-01f, 3.89460251e-02f, 4.22313884e-02f, -1.04339540e-01f,
  6.57176599e-02f, 3.60831976e-01f, 4.22240436e-01f, 9.97880623e-02f, 5.09495623e-02f, 1.86495543e-01f, 1.68705404e-01f, 9.37061161e-02f, 5.49645364e-01f, 6.10923111e-01f,
  1.30966246e+00f, -3.35426837e-01f, -6.66954279e-01f, 2.78209716e-01f, 3.42332572e-02f, 6.63450062e-02f, 9.91951153e-02f, 3.27629685e-01f, 2.71447092e-01f, 4.62392159e-02f,
  -1.07327215e-01f, -7.14153871e-02f, -1.40411943e-01f, -9.67361704e-02f, 1.10692173e-01f, -1.23266347e-01f, -1.27754092e-01f, -2.03114059e-02f, 1.59609675e-01f, 3.14989656e-01f,
  9.25463438e-02f, 2.11406112e-01f, 3.78917605e-01f, 1.82676520e-02f, -3.66405189e-01f, -1.88908190e-01f, -2.57840723e-01f, -2.95539171e-01f, -2.54584700e-01f, -4.38027591e-01f,
  -7.83375144e-01f, -1.87036723e-01f, 1.68760091e-01f, 5.56306876e-02f, -9.09070447e-02f, 5.44140525e-02f, 1.17424272e-01f, 7.45008811e-02f, 5.68343289e-02f, 2.16556285e-02f,
  -4.51874360e-02f, -1.17565162e-01f, -1.21118218e-01f, -1.71545044e-01f, 4.30348851e-02f, -1.70684587e-02f, -9.22443997e-03f, -2.20588055e-02f, -1.13999046e-01f, -1.96180761e-01f,
  -1.84992298e-01f, -6.72133937e-02f, -9.89225809e-04f, 1.03733085e-01f, 7.22522959e-02f, 3.19083780e-02f, -1.11004114e-01f, 2.51934454e-02f, -4.91026696e-03f, 1.95885181e-01f,
  -2.82478314e-02f, 4.01004888e-02f, -9.39703453e-03f, 6.83472604e-02f, 1.76138893e-01f, 2.29100391e-01f, 9.84538049e-02f, 1.68551460e-01f, 1.28509149e-01f, 2.16011003e-01f,
  2.33504884e-02f, -9.64324027e-02f, 7.90921226e-02f, 1.22403078e-01f, -2.07302913e-01f, -1.20359465e-01f, -3.89912236e-03f, -9.74342898e-02f, -9.33689475e-02f, -8.33682045e-02f,
  7.87961632e-02f, -9.91276726e-02f, 9.44697967e-05f, -1.66423902e-01f, -1.84346139e-01f, -4.79717143e-02f, -1.34964943e-01f, -9.26158726e-02f, -4.42877132e-03f, 3.81284254e-03f,
  -1.77314766e-02f, -1.21975109e-01f, -5.73837906e-02f, -3.64969261e-02f, -1.71010703e-01f, -5.10442480e-02f, -7.96978772e-02f, -1.39635414e-01f, -7.40305185e-02f, -6.71411455e-02f,
  -1.77314028e-01f, 8.52294043e-02f, -6.90792724e-02f, 3.55586335e-02f, 2.48058319e-01f, 1.13588244e-01f, 1.36083141e-01f, 2.30493620e-02f, -8.10078382e-02f, -1.76379457e-01f,
  -1.42550664e-02f, 3.12382966e-01f, 2.98881322e-01f, 2.84292608e-01f, 2.22295105e-01f, 1.07506610e-01f, 1.20676152e-01f, 2.34848317e-02f, 1.33167550e-01f, 5.21084607e-01f,
  -1.13205290e+00f, 4.06807721e-01f, -1.33638084e-01f, -2.97399223e-01f, -3.44651863e-02f, 2.34790832e-01f, 4.60380584e-01f, 3.38828862e-01f, 1.55450612e-01f, 2.09991649e-01f,
  5.00138886e-02f, 7.26170605e-03f, 1.58736020e-01f, 9.65814367e-02f, 1.08456902e-01f, 5.72572708e-01f, 4.34845865e-01f, -1.49636999e-01f, -3.16824019e-01f, 7.35767186e-03f,
  1.77261293e-01f, -4.92249094e-02f, -3.06034893e-01f, 8.86232592e-03f, 1.66607842e-01f, 3.09845582e-02f, 1.20173879e-01f, -1.73885655e-02f, 7.19929263e-02f, 3.12822670e-01f,
  -5.49569465e-02f, -5.90614974e-01f, 8.52813274e-02f, -7.36860558e-02f, -8.10752511e-02f, -6.17572591e-02f, -3.27850953e-02f, -1.56942084e-02f, 2.23873816e-02f, 1.95087358e-01f,
  -6.21685572e-02f, -1.84920013e-01f, -2.08581775e-01f, 2.84792408e-02f, 2.34758984e-02f, -1.06463075e-01f, -9.79071483e-02f, 6.11770153e-02f, 1.51498362e-01f, 1.26783162e-01f,
  4.90005538e-02f, -1.33876100e-01f, 2.34462693e-02f, 1.70545220e-01f, -1.09860487e-01f, -4.39941101e-02f, -3.87196988e-02f, -4.23981063e-02f, -1.00609295e-01f, 5.66531494e-02f,
  1.83404580e-01f, 1.25481412e-01f, -1.31139711e-01f, -1.19924754e-01f, -6.37436211e-02f, 3.05422321e-02f, -5.43251820e-02f, 3.62842754e-02f, -9.47677046e-02f, -4.39141765e-02f,
  -1.33084841e-02f, -3.82013507e-02f, -5.12940763e-03f, -2.16100384e-02f, -3.98162231e-02f, -4.24512066e-02f, 9.70412418e-03f, 5.18836491e-02f, -1.07361414e-01f, -9.57265273e-02f,
  -1.89420283e-01f, 4.43127044e-02f, -3.34815718e-02f, 6.06985502e-02f, 4.45135236e-02f, -7.17259496e-02f, 1.64792296e-02f, -8.01339447e-02f, 6.17009774e-02f, 1.67160287e-01f,
  4.60528255e-01f, -3.80928755e-01f, 6.93846121e-02f, 9.79385823e-02f, -1.24466009e-01f, -1.38369709e-01f, -6.64052293e-02f, -7.17668608e-02f, 8.49360526e-02f, 3.81244123e-02f,
  -1.28101498e-01f, -4.43934230e-03f, -1.77298635e-02f, -7.33916685e-02f, -1.96791723e-01f, -3.68128307e-02f, -3.97047587e-03f, 5.38744144e-02f, 1.19881235e-01f, 1.69828579e-01f,
  1.79458231e-01f, 5.61639853e-03f, 5.58176450e-02f, 1.17027968e-01f, -6.45714346e-03f, 1.97938783e-03f, -1.93826985e-02f, 2.41324697e-02f, 2.02707965e-02f, 3.22093010e-01f,
  -7.64555633e-01f, -1.07289958e+00f, 6.54017448e-01f, -8.37224364e-01f, 4.58136052e-01f, 1.03282547e+00f, 6.51309073e-01f, -3.95984203e-02f, -4.04588312e-01f, -2.93372750e-01f,
  -1.63270280e-01f, -1.29089445e-01f, -3.33095700e-01f, -1.33295283e-01f, -1.11512087e-01f, 1.57339588e-01f, 7.81092346e-02f, 2.61137664e-01f, 8.07165086e-01f, 6.98434830e-01f,
  -3.62319918e-03f, -5.58540583e-01f, -6.02946699e-01f, -2.14450419e-01f, -3.93233865e-01f, -6.67327866e-02f, -3.09605837e-01f, -5.30596733e-01f, -2.28276253e-02f, -6.09643817e-01f,
  4.86883730e-01f, -4.41030264e-01f, 2.08415240e-01f, -2.51057714e-01f, -1.97035611e-01f, -1.04022838e-01f, 1.39894411e-01f, -3.08692455e-01f, -1.74676716e-01f, -1.51051983e-01f,
  -2.40652204e-01f, -1.22188948e-01f, -1.02814399e-02f, -5.40574417e-02f, -7.11471587e-02f, -1.76279768e-02f, -2.30620921e-01f, -3.57441306e-01f, -2.94373304e-01f, 1.32928059e-01f,
  -1.84738994e-01f, 3.21004726e-02f, 1.53804719e-01f, 1.68881118e-01f, 7.25541189e-02f, 1.19980454e-01f, -1.13254346e-01f, 7.16808066e-02f, 5.36755733e-02f, -3.54460597e-01f,
  4.59170640e-02f, 5.95110543e-02f, 1.78353354e-01f, 3.10513712e-02f, -8.56085643e-02f, 1.28478214e-01f, 1.58333611e-02f, 1.13042362e-01f, 8.08626488e-02f, 1.53724700e-02f,
  4.54418994e-02f, -1.30879447e-01f, -5.39918467e-02f, -1.42258599e-01f, -6.97454959e-02f, -1.27602339e-01f, -6.43194988e-02f, -2.14172617e-01f, -8.32789987e-02f, -2.44882911e-01f,
  -1.44512922e-01f, 4.78668362e-02f, -1.29922941e-01f, -1.36978611e-01f, -5.49624823e-02f, -1.20009914e-01f, -2.83408072e-02f, 1.21189076e-02f, -2.97072623e-02f, 4.78542410e-02f,
  5.81241027e-02f, 2.16234341e-01f, -2.65579745e-02f, -1.57290518e-01f, -2.36177426e-02f, -1.12993546e-01f, -4.41508703e-02f, -1.53709920e-02f, -1.51039541e-01f, 1.60894066e-01f,
  1.60478532e-01f, 1.34121859e-02f, -1.19922936e-01f, 5.91354929e-02f, 3.10167164e-01f, 1.38402715e-01f, -2.00877532e-01f, -9.27966386e-02f, -3.88453417e-02f, -8.58142748e-02f,
  -1.30710274e-01f, 2.05174863e-01f, 1.59268290e-01f, 2.82106012e-01f, 8.30390379e-02f, 5.08063972e-01f, 3.25877011e-01f, 3.46147209e-01f, 3.43377918e-01f, -2.99830139e-02f,
  -7.39354670e-01f, 4.02879640e-02f, -1.31811213e+00f, 6.80305123e-01f, 6.10381365e-01f, -3.90166074e-01f, -6.38121009e-01f, -3.41731340e-01f, 5.27260780e-01f, -1.65766373e-01f,
  -2.81585813e-01f, 1.09068133e-01f, -9.28769633e-03f, -2.39127845e-01f, -5.70619285e-01f, -4.35385071e-02f, 3.18495959e-01f, -5.38086772e-01f, -5.38075507e-01f, 7.77469128e-02f,
  8.75864387e-01f, 7.18481719e-01f, 1.43282831e-01f, -5.53848781e-02f, 6.74397588e-01f, 5.09942532e-01f, 1.91990137e-01f, 3.74276519e-01f, -1.63674667e-01f, 2.98391223e-01f,
  -9.78450835e-01f, -6.09918892e-01f, -3.19902629e-01f, 3.10181051e-01f, -1.61366642e-01f, -3.95731747e-01f, -2.10356891e-01f, 6.05248213e-02f, -7.91465584e-03f, 7.08999634e-02f,
  1.88922599e-01f, -6.74436986e-02f, 3.40750039e-01f, 2.29473352e-01f, 1.36815935e-01f, -2.03348339e-01f, -1.57484338e-01f, -6.59804225e-01f, -5.91700852e-01f, -5.80488205e-01f,
  7.04158723e-01f, 5.72480857e-02f, -5.46413004e-01f, -2.45525956e-01f, -6.11278772e-01f, -5.57751283e-02f, -5.36379635e-01f, -4.29232985e-01f, -8.79177332e-01f, -2.24017918e-01f,
  -1.32644147e-01f, -1.65085778e-01f, 8.20448622e-02f, 1.16443083e-01f, 7.62848184e-02f, 2.23795012e-01f, 1.67230859e-01f, 1.77866474e-01f, 5.97040132e-02f, 1.50579005e-01f,
  5.72507754e-02f, -1.87458768e-01f, -4.12393175e-02f, -1.50252402e-01f, -2.79895309e-02f, -2.07248643e-01f, -8.68591070e-02f, -1.15763046e-01f, -3.84360179e-02f, -1.36637643e-01f,
  -3.92041206e-02f, -1.75830349e-01f, 1.55477583e-01f, -3.83685678e-02f, -2.32970610e-01f, -3.15602154e-01f, 5.26711568e-02f, -1.08595662e-01f, -5.05507514e-02f, -3.95369940e-02f,
  6.69946909e-01f, -2.26320878e-01f, -1.85331330e-02f, -8.71759206e-02f, 1.02538064e-01f, 1.89271882e-01f, -3.18555199e-02f, -1.27624005e-01f, -1.46951312e-02f, -1.50109753e-01f,
  -1.29015803e-01f, -3.36428463e-01f, 2.91531771e-01f, 1.58395842e-02f, -1.57984644e-01f, 2.16168925e-01f, 1.91867247e-01f, 7.05782846e-02f, 2.05495223e-01f, 6.73916489e-02f,
  3.32761288e-01f, 1.11843511e-01f, -1.37557179e-01f, -2.58242220e-01f, 1.27235040e-01f, 9.32857767e-02f, -1.24609247e-01f, -1.45814642e-01f, -5.81190050e-01f, 1.66066676e-01f,
  -3.03333610e-01f, 2.96686530e-01f, -9.40249145e-01f, 1.72225982e-02f, -6.95261598e-01f, -7.76333153e-01f, -3.79361182e-01f, 4.85264450e-01f, 3.77763897e-01f, -1.50124282e-01f,
  -2.58749902e-01f, -1.28382504e-01f, -4.79843728e-02f, -3.00657511e-01f, -4.70009983e-01f, -5.05100489e-01f, -7.79189527e-01f, -8.29651296e-01f, -9.18394387e-01f, -6.78079963e-01f,
  -5.60538113e-01f, -2.97248870e-01f, -4.15368497e-01f, -3.95743996e-01f, 1.52978972e-01f, -5.58284000e-02f, -7.08703138e-03f, -3.13174129e-01f, -6.09904051e-01f, -3.94448817e-01f,
  2.15189278e-01f, -6.38762489e-02f, -2.82400567e-02f, -2.58943558e-01f, 2.53535032e-01f, 1.59155488e-01f, -9.26194713e-02f, 2.39318445e-01f, 2.61117518e-01f, 1.39251441e-01f,
  -1.89264312e-01f, 8.26532468e-02f, 1.50177762e-01f, 1.38347289e-02f, 5.13802804e-02f, -1.23720072e-01f, -3.84895951e-02f, -1.59202710e-01f, 1.27454065e-02f, 4.24623862e-02f,
  -2.33336389e-01f, -5.12713909e-01f, -1.26441240e-01f, 8.49042833e-02f, 1.72892854e-01f, -3.89566094e-01f, 3.61569792e-01f, 8.75126347e-02f, -8.65632221e-02f, 4.55484957e-01f,
  6.95349500e-02f, 2.62771904e-01f, -4.79371138e-02f, 5.21587655e-02f, 1.17144309e-01f, 5.28273694e-02f, 2.40292009e-02f, 1.11531861e-01f, 2.06130873e-02f, 1.11743495e-01f,
  1.29347548e-01f, 2.91366875e-02f, 1.17024846e-01f, -8.08616541e-03f, -1.12460390e-01f, -1.59793168e-01f, -1.36335313e-01f, 1.53718144e-01f, -1.04573838e-01f, -2.30796989e-02f,
  -1.06269270e-02f, 3.27230208e-02f, -3.37024480e-02f, 8.68153349e-02f, -1.88334793e-01f, -4.29978892e-02f, -5.36854006e-02f, 4.10132483e-02f, -4.17361297e-02f, -1.46798909e-01f,
  9.51529443e-01f, -7.31563509e-01f, 2.02100590e-01f, 7.58049265e-02f, -9.99286119e-03f, 1.66260988e-01f, 3.19157280e-02f, 1.68751683e-02f, 9.04983934e-03f, 1.47714093e-02f,
  -1.82676092e-01f, 1.58615679e-01f, 2.47708410e-02f, 1.96470603e-01f, -4.21121791e-02f, -1.62820652e-01f, -9.80304182e-02f, -6.45898655e-02f, -1.37861431e-01f, 2.52498627e-01f,
  5.75390719e-02f, -2.35013276e-01f, 3.14702652e-02f, 2.39680856e-01f, 1.31416142e-01f, -3.32666934e-01f, 2.82198280e-01f, 2.56845415e-01f, -1.56526953e-01f, 7.48963237e-01f,
  -7.66628802e-01f, 5.59391737e-01f, 5.41129947e-01f, -2.20971867e-01f, -6.48681894e-02f, -1.35308504e-01f, -1.26346812e-01f, -2.27149650e-01f, -1.83407888e-01f, 3.24923068e-01f,
  -5.09353764e-02f, -2.16940612e-01f, 1.08591639e-01f, 1.43170888e-02f, -8.35850909e-02f, 6.60259902e-01f, 5.85114598e-01f, 5.10057844e-02f, -6.42903566e-01f, -4.58580405e-01f,
  -9.32447761e-02f, -3.48704606e-01f, -4.46905077e-01f, -9.22627822e-02f, 5.23171008e-01f, -1.15258418e-01f, 2.77544945e-01f, 1.13992296e-01f, 5.08858323e-01f, 1.23867989e+00f,
  2.12000445e-01f, 2.56796271e-01f, -1.78079084e-01f, -1.20145395e-01f, 7.26545230e-02f, 2.02480838e-01f, 3.79883349e-02f, 1.44538954e-01f, 1.91913307e-01f, 2.15139687e-01f,
  1.18906848e-01f, 2.72997737e-01f, 6.25088811e-02f, 9.46601555e-02f, -1.88891113e-01f, -2.65885025e-01f, 1.88056100e-02f, -1.64942876e-01f, -6.13120943e-02f, 2.04139367e-01f,
  3.44953001e-01f, -1.91381454e-01f, -3.40850651e-01f, -1.23334177e-01f, 2.68284410e-01f, -4.01288718e-01f, -2.09516007e-02f, 4.03488800e-02f, -3.87169152e-01f, 4.04042691e-01f,
  -7.27696717e-02f, -1.86453145e-02f, -2.14964096e-02f, 2.58445591e-01f, 1.79822110e-02f, 1.92744076e-01f, 2.71255672e-01f, 3.77261639e-02f, 8.31670463e-02f, 5.95047101e-02f,
  -1.34683354e-02f, -4.25479636e-02f, -3.77117023e-02f, 1.31213456e-01f, 3.27919386e-02f, -1.86488733e-01f, 2.04295367e-02f, -2.06099376e-01f, 2.36076815e-03f, 3.44195478e-02f,
  -2.42901556e-02f, 6.62049605e-03f, 6.64497539e-03f, -7.69592375e-02f, 1.09846279e-01f, 1.22732349e-01f, 2.16976956e-01f, -5.01124114e-02f, -2.02297062e-01f, 1.48007408e-01f,
  -5.64883113e-01f, -1.82032004e-01f, 9.14220139e-02f, 1.18410699e-02f, 1.06817484e-02f, -1.28624989e-02f, 6.94151446e-02f, -1.94016069e-01f, -1.64335191e-01f, -2.57815480e-01f,
  -1.52418315e-01f, -5.33297285e-02f, 1.86463237e-01f, 2.56096311e-02f, -2.88418919e-01f, -2.57790416e-01f, -2.61157658e-02f, -2.39743859e-01f, -6.45459741e-02f, -2.92016473e-02f,
  4.37421016e-02f, -5.77951550e-01f, -8.15704107e-01f, -5.49331844e-01f, -2.85498202e-01f, -7.84439147e-01f, -3.55427295e-01f, -3.75637889e-01f, -6.99780941e-01f, -5.81443965e-01f,
  2.69171577e-02f, 8.28241408e-01f, -2.76404798e-01f, 2.71123230e-01f, 5.02066851e-01f, 8.43401849e-02f, 2.20675483e-01f, -2.14291245e-01f, 1.37254193e-01f, 7.13530660e-01f,
  4.50673968e-01f, -4.89350349e-01f, -7.54613042e-01f, -8.72223496e-01f, -1.26329482e+00f, -5.61880589e-01f, -5.52735925e-01f, -1.46291065e+00f, -1.32578075e+00f, -2.14962602e-01f,
  6.21166788e-02f, -3.75025421e-01f, -6.66591585e-01f, -5.25667071e-01f, 2.45247379e-01f, -4.95382249e-01f, -3.04073095e-02f, 5.72175942e-02f, -2.97920443e-02f, 1.67035982e-01f,
  -7.07253516e-02f, 2.03701273e-01f, -3.23867798e-01f, 8.28477275e-03f, 3.22786987e-01f, -3.42823938e-02f, -2.04925522e-01f, -1.49082348e-01f, 2.32878514e-02f, -2.16207579e-01f,
  3.25077698e-02f, -3.41428667e-02f, -1.57066301e-01f, -8.17641616e-02f, -1.76602066e-01f, -2.40073875e-01f, -4.47603576e-02f, -4.07325655e-01f, -1.50020257e-01f, 2.55036384e-01f,
  6.63765669e-01f, 2.23459318e-01f, -1.50477722e-01f, 1.01917498e-01f, 1.30584627e-01f, -4.94539961e-02f, 3.51765603e-01f, 1.36427149e-01f, -1.13209806e-01f, 2.61049211e-01f,
  2.10266083e-01f, -1.35688305e-01f, -4.56276461e-02f, 5.92086725e-02f, 9.74424183e-02f, 6.36845129e-03f, -1.13636367e-02f, 5.96428476e-02f, -9.18371752e-02f, -1.24562204e-01f,
  8.43018875e-04f, 2.49497116e-01f, -6.88971803e-02f, -1.79815620e-01f, -2.66466677e-01f, -3.97801362e-02f, 1.68801602e-02f, -5.10300398e-02f, -1.35999605e-01f, 2.62718275e-03f,
  -1.78014278e-01f, 3.00838565e-03f, 7.02610835e-02f, -1.41433746e-01f, 1.57098487e-01f, 1.16259120e-01f, -9.73095652e-03f, 7.99746364e-02f, 5.25279669e-03f, -4.89940979e-02f,
  -4.49456096e-01f, -1.68394819e-01f, -1.60046369e-01f, -3.69829953e-01f, -3.85437184e-03f, 1.52942389e-01f, 1.07043356e-01f, 1.57300547e-01f, 1.38924152e-01f, 1.61467910e-01f,
  2.98771672e-02f, 3.26669626e-02f, -9.00909305e-02f, 1.07589282e-01f, -4.98675033e-02f, -1.46752223e-01f, 2.12171301e-01f, -8.65554065e-02f, -2.32056126e-01f, 3.44282120e-01f,
  2.02780202e-01f, -1.41008511e-01f, -2.39220694e-01f, 5.37636578e-02f, 1.99144464e-02f, -6.01580620e-01f, -4.68405932e-01f, -1.40558571e-01f, -5.00654638e-01f, 7.13882223e-02f,
  2.91919261e-01f, -3.21311861e-01f, 1.65451989e-01f, 1.79253951e-01f, -1.08543672e-01f, -4.93905663e-01f, -7.32896626e-01f, -3.34306329e-01f, -8.33054446e-03f, 1.11618623e-01f,
  4.92097944e-01f, 6.52848959e-01f, 6.80899084e-01f, 4.33572799e-01f, 4.84914444e-02f, -2.15631649e-01f, -2.69782543e-01f, -6.79842830e-02f, -3.01405992e-02f, -9.36677232e-02f,
  -1.77669287e-01f, -3.62482578e-01f, -1.06634736e-01f, -1.15964651e-01f, 1.39483869e-01f, 4.37988758e-01f, 1.36897013e-01f, 9.24636703e-03f, -3.58265638e-02f, 1.58638686e-01f,
  6.16128862e-01f, -1.95191596e-02f, 1.43983722e-01f, -5.94946258e-02f, -8.71426240e-03f, -7.38404691e-03f, 2.94384696e-02f, 3.45549472e-02f, -1.23949297e-01f, -1.29883483e-01f,
  -1.38839670e-02f, 1.12846233e-01f, -1.45191886e-02f, -7.45475888e-02f, -7.98655823e-02f, -5.93244657e-02f, -1.01750873e-01f, -1.27609774e-01f, -3.53700444e-02f, 1.28586248e-01f,
  5.68881296e-02f, -6.18050210e-02f, -4.13262174e-02f, -2.12053061e-02f, -5.26944101e-02f, 4.73320484e-02f, 2.96434257e-02f, 7.68929273e-02f, 2.55462192e-02f, 1.23798721e-01f,
  2.02645571e-03f, 1.37614220e-01f, 1.37173876e-01f, 2.36026555e-01f, 9.31673199e-02f, -6.18633665e-02f, -3.62561271e-02f, -1.54324025e-01f, 3.87842208e-02f, -1.16971642e-01f,
  -5.93059883e-02f, 1.22349061e-01f, -8.09370503e-02f, 1.02126030e-02f, 1.22419514e-01f, -9.76251438e-02f, -4.56024259e-02f, 4.67387624e-02f, 7.41950050e-02f, 1.44407135e-02f,
  -7.51849860e-02f, -1.24845497e-01f, 3.58115584e-02f, -1.69800416e-01f, -9.82026905e-02f, 6.66329414e-02f, -4.82305884e-02f, 2.41885558e-02f, -3.94155420e-02f, -2.45767459e-01f,
  1.94673657e-01f, 7.25901723e-02f, 3.23736429e-01f, 8.10392424e-02f, -1.80109128e-01f, -3.29443887e-02f, 1.80222496e-01f, 4.37849835e-02f, -1.79859310e-01f, -8.34920928e-02f,
  -3.92289124e-02f, 4.88510495e-03f, -2.19754651e-02f, -6.23781867e-02f, -3.02583966e-02f, 4.91361879e-02f, 7.09964260e-02f, 2.15887755e-01f, -4.10864726e-02f, -6.68958947e-02f,
  -1.86411709e-01f, -2.50162277e-02f, 1.78605497e-01f, 7.68157542e-02f, 5.05097434e-02f, 2.16533646e-01f, 1.28675401e-01f, 1.13526499e-02f, 1.48515850e-01f, 8.62223934e-03f,
  -6.27109110e-01f, -9.23977077e-01f, 1.94237933e-01f, -8.80347490e-01f, -5.40733993e-01f, -1.90467209e-01f, -1.12434614e+00f, -4.10218030e-01f, -1.04987450e-01f, -9.36087847e-01f,
  -2.66057849e-01f, 3.64975661e-01f, 3.79524648e-01f, 4.10788924e-01f, 2.53318727e-01f, -9.85389054e-01f, -3.91835779e-01f, 3.30313891e-01f, 5.24326742e-01f, -4.64200318e-01f,
  -6.40482724e-01f, -5.70157647e-01f, -4.71905209e-02f, -2.93170866e-02f, -7.45277762e-01f, -1.60130844e-01f, -2.06714898e-01f, -3.46877098e-01f, -2.51377136e-01f, -6.92932963e-01f,
  -6.89741313e-01f, 1.54419035e-01f, 5.03702521e-01f, 3.41720730e-01f, -3.03670377e-01f, 2.29462370e-01f, -5.60887516e-01f, -4.04121242e-02f, 1.10502250e-01f, -9.55744013e-02f,
  -1.50221780e-01f, 1.92057446e-01f, 3.92625868e-01f, 2.75776058e-01f, -3.10130894e-01f, -1.24709897e-01f, 1.68631226e-02f, 3.37622091e-02f, 1.04503967e-01f, -9.43389386e-02f,
  -1.27331302e-01f, -9.09330323e-02f, 3.77289265e-01f, 3.63589197e-01f, 3.44735801e-01f, 4.01084930e-01f, -2.60673910e-01f, 1.61582559e-01f, 4.69460934e-01f, -1.04709661e+00f,
  -8.24700445e-02f, 1.01619111e-02f, -1.34476379e-01f, -4.99185510e-02f, -5.19330539e-02f, 4.01351750e-02f, 1.21475793e-01f, 2.65705487e-04f, 1.52884126e-01f, 6.87927101e-03f,
  6.67888224e-02f, 1.27967328e-01f, -7.30146542e-02f, -2.44688556e-01f, 5.73547557e-02f, -1.90482616e-01f, -5.72827011e-02f, -1.46903887e-01f, -9.95166451e-02f, -7.88868740e-02f,
  7.16272742e-02f, -8.23086053e-02f, 9.15173348e-03f, -5.63908741e-02f, 2.00048923e-01f, 1.86401401e-02f, 3.15406956e-02f, 2.04992980e-01f, -9.33781192e-02f, 1.55976370e-01f,
  -4.03999090e-01f, 7.52515376e-01f, -4.64855105e-01f, 1.06616411e-02f, -2.05740020e-01f, 1.48789927e-01f, -1.70102105e-01f, 1.29912063e-01f, 8.50463957e-02f, -3.17980558e-01f,
  -9.69649628e-02f, -2.11717114e-01f, 3.65681946e-02f, 3.80114503e-02f, -2.18625963e-01f, 7.99623132e-02f, -3.48349661e-01f, -7.95592070e-02f, 3.13660234e-01f, -1.65369183e-01f,
  3.64993811e-02f, -6.17349669e-02f, -3.09405386e-01f, -1.76954508e-01f, -1.64443314e-01f, 4.40052837e-01f, -2.61187702e-01f, -2.31366843e-01f, 2.78689981e-01f, -1.02300239e+00f,
  2.71672964e-01f, -6.87963247e-01f, -6.28268570e-02f, -3.76441419e-01f, -6.63661838e-01f, -3.25530767e-01f, -4.01866615e-01f, 4.68405157e-01f, -9.05148406e-03f, -6.75924718e-01f,
  -9.17908311e-01f, -2.13909745e-01f, -3.55998069e-01f, 1.52710691e-01f, 5.40549397e-01f, -7.22991526e-01f, -4.72619325e-01f, 5.19340992e-01f, 1.11793923e+00f, 8.29269171e-01f,
  -5.56210987e-03f, 3.17740142e-01f, 7.23408997e-01f, 6.86152458e-01f, -4.04360861e-01f, -9.00343433e-02f, -3.69229168e-01f, -1.94639906e-01f, -1.38246700e-01f, -5.06172895e-01f,
  -3.34403545e-01f, 1.12409033e-01f, 2.65039474e-01f, 1.99513789e-02f, -1.77239582e-01f, 1.72009140e-01f, 6.55325055e-02f, 9.37948450e-02f, -2.69756000e-02f, 3.85821685e-02f,
  -3.58928859e-01f, 2.12591767e-01f, -4.50983532e-02f, -5.63053004e-02f, 9.44978297e-02f, 3.02409768e-01f, 3.37470651e-01f, 3.97458076e-01f, 1.97591081e-01f, 7.06221582e-03f,
  -3.12445730e-01f, -3.42653900e-01f, -3.92145425e-01f, 3.59336548e-02f, 4.64124829e-01f, 1.09151065e-01f, 2.91421562e-01f, 6.00489676e-01f, 3.84684801e-01f, -5.92580102e-02f,
  -1.76103991e-02f, -1.36054456e-01f, 1.29573271e-01f, 9.69120637e-02f, -9.74765047e-02f, -7.01706037e-02f, -7.48955365e-03f, -4.17952463e-02f, 1.81219086e-01f, 2.72455625e-02f,
  7.38282576e-02f, -9.67698917e-02f, 1.01885356e-01f, -1.10362172e-01f, -8.57852846e-02f, 1.75275523e-02f, -1.89546138e-01f, 1.57622889e-01f, -6.00910857e-02f, -7.30224624e-02f,
  2.10128680e-01f, 9.14205611e-02f, -1.15331918e-01f, 2.73520589e-01f, -1.72017831e-02f, 1.73675954e-01f, 1.60703938e-02f, 1.01452082e-01f, 1.75010078e-02f, -1.12918243e-01f,
  -4.56964135e-01f, -1.31535612e-03f, -4.66982216e-01f, 2.24039584e-01f, -2.63739645e-01f, -5.64730028e-03f, -1.38317555e-01f, 1.73988298e-03f, -2.16196805e-01f, 1.24338545e-01f,
  2.15642080e-01f, 1.60039344e-03f, -2.13513568e-01f, 1.11811943e-01f, 5.98324870e-04f, -2.45261639e-01f, -3.97120386e-01f, -2.87345260e-01f, -2.19048429e-02f, 1.74011849e-02f,
  1.60376787e-01f, -2.43645936e-01f, -6.21247053e-01f, -5.90145350e-01f, -1.96106851e-01f, -5.57429790e-01f, -2.69026965e-01f, -1.85577989e-01f, -3.69412422e-01f, -6.77896082e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  7.11194515e-01f, 9.70334053e-01f, 7.88183749e-01f, 5.88072538e-01f, 1.06422603e+00f, 9.53051925e-01f, 1.13894975e+00f, 8.36303234e-01f, 6.11377895e-01f, 8.35525572e-01f,
  1.05925453e+00f, 1.08934820e+00f, 5.37041843e-01f, 5.35225570e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -1.99290544e-01f, -1.97734550e-01f, 9.13529284e-03f, -4.34959561e-01f, -3.19127440e-01f, -4.87705320e-01f, -6.16839409e-01f, -5.19159436e-01f, -4.35804278e-01f, 4.16363657e-01f,
  -3.31257254e-01f, 2.81477366e-02f, 1.45699129e-01f, 6.72942162e-01f, -7.90391564e-02f, 1.09617367e-01f, -1.95023283e-01f, -3.48925322e-01f, -6.47309542e-01f, -7.92744100e-01f,
  -7.31220305e-01f, 1.28024802e-01f, 2.92820871e-01f, -8.83706689e-01f, -2.12764055e-01f, 2.86795888e-02f, -5.79775162e-02f, -1.72198784e+00f, 8.28526020e-02f, 2.08395496e-01f,
  1.59956425e-01f, 1.18815029e+00f, 1.88405603e-01f, -1.61886513e-01f, -3.06973815e-01f, 3.09928417e-01f, 2.10517764e-01f, 1.92191288e-01f, 8.17511454e-02f, 2.24391147e-01f,
  -4.41770926e-02f, 4.71972585e-01f, -4.36818987e-01f, -2.72900134e-01f, -1.44806564e-01f, -3.83946061e-01f, -7.72576407e-02f, 4.83628303e-01f, -7.36639798e-02f, -3.97197574e-01f,
  7.30093598e-01f, 1.47661909e-01f, -5.59030235e-01f, 6.38054848e-01f, 5.12501836e-01f, -7.73302615e-01f, -4.46428984e-01f, -1.01868331e+00f, -2.21172094e-01f, -1.12936211e+00f,
  -1.80062139e+00f, 1.09697767e-01f, 1.20893455e+00f, -3.22926790e-01f, -1.15074806e-01f, 1.69436455e-01f, 2.45105058e-01f, 2.49751925e-01f, 2.28571221e-01f, 1.78833500e-01f,
  1.37147352e-01f, 1.96379513e-01f, -5.90240285e-02f, -5.64655364e-01f, -3.10930073e-01f, 1.98353723e-01f, -2.85965592e-01f, 2.30069146e-01f, 7.87726998e-01f, 3.50738019e-01f,
  3.82809751e-02f, -4.88952607e-01f, -9.54661906e-01f, -7.51315355e-02f, -1.88686311e-01f, -1.31958735e+00f, 1.66068189e-02f, -1.08119822e+00f, -2.25805305e-02f, -2.55886763e-01f,
  -1.01569414e+00f, -1.08089343e-01f, -1.01539886e+00f, 2.76617169e-01f, 1.02524066e+00f, 1.29749286e+00f, 1.49785936e-01f, -2.36340731e-01f, -2.84510344e-01f, -5.62997088e-02f,
  -1.24567866e+00f, 4.72758770e-01f, 2.92091407e-02f, -4.27367568e-01f, -3.84205401e-01f, -4.58449125e-01f, -1.36300221e-01f, 6.32349193e-01f, -1.41009167e-01f, 7.30827987e-01f,
  2.72880733e-01f, 5.68486862e-02f, 1.20711535e-01f, 7.20256448e-01f, -9.48402047e-01f, -3.49746794e-01f, -2.88945492e-02f, 7.69750655e-01f, -6.26369596e-01f, 6.41588390e-01f,
  7.67501116e-01f, -1.41863453e+00f, -5.29134035e-01f, 7.74370968e-01f, 2.82698363e-01f, -1.74655199e+00f, 2.06158504e-01f, -1.00672448e+00f, -6.54810071e-02f, 1.22229911e-01f,
  6.76869601e-02f, -2.09627748e-01f, 1.65972948e-01f, -3.08907807e-01f, -2.57745564e-01f, -2.11102888e-01f, 1.26181602e-01f, -4.15724367e-01f, -9.79249999e-02f, -2.20237881e-01f,
  -6.88024564e-04f, 2.56138474e-01f, -3.51805091e-01f, 3.04102302e-01f, -3.26192468e-01f, -1.09037526e-01f, -6.83287799e-01f, 1.69558212e-01f, -6.76331017e-03f, -1.19425142e+00f,
  -5.16932726e-01f, 1.74357668e-01f, -8.05035412e-01f, -1.06798366e-01f, 7.31836796e-01f, 3.51876199e-01f, 4.81951863e-01f, 1.91497162e-01f, 2.53084749e-01f, -1.01854503e+00f,
  -1.87078670e-01f, 2.48793587e-01f, -7.77706504e-02f, 3.15939873e-01f, 1.31738037e-01f, 3.67067099e-01f, 3.29052627e-01f, 2.53742695e-01f, 4.23259348e-01f, 6.70852184e-01f,
  3.29002023e-01f, -6.36705875e-01f, -1.16911530e-01f, -4.45871145e-01f, -3.42934847e-01f, 4.53907661e-02f, -5.41470587e-01f, -3.74629468e-01f, 1.72990963e-01f, -4.20294493e-01f,
  -1.21251667e+00f, 6.11170411e-01f, 6.19703829e-01f, 3.76200736e-01f, -1.24910057e+00f, 1.00838339e+00f, 4.61719245e-01f, -1.64042842e+00f, 3.11113507e-01f, -5.43022037e-01f,
  -6.91435933e-01f, -1.30155659e+00f, -3.33912164e-01f, 3.34801003e-02f, -4.07588691e-01f, 1.20786138e-01f, -4.96484846e-01f, -2.54625410e-01f, -1.32274702e-01f, -3.34983110e-01f,
  5.39533757e-02f, -4.58439261e-01f, -6.45155787e-01f, 3.09871227e-01f, 6.37237072e-01f, -7.42090583e-01f, -5.52083552e-01f, -6.35189295e-01f, 5.46185374e-01f, -3.61776382e-01f,
  2.04674363e-01f, -9.59239185e-01f, 4.96647328e-01f, -3.60794850e-02f, -1.54414549e-01f, 1.49637878e-01f, -9.96073782e-01f, -9.68997538e-01f, -6.48455739e-01f, 8.04793000e-01f,
  -1.21785975e+00f, 1.67980462e-01f, -1.23506379e+00f, 8.54425967e-01f, 1.37927625e-02f, -1.36749774e-01f, -3.04572850e-01f, 5.29639609e-02f, -6.00845098e-01f, -2.81039715e-01f,
  -6.05228506e-02f, -1.74055286e-02f, -1.22422472e-01f, 6.38424098e-01f, 1.80407718e-01f, 4.26684059e-02f, -1.17247574e-01f, 2.30394647e-01f, 1.54086307e-01f, 2.73300350e-01f,
  -4.32185084e-01f, 9.46555287e-02f, -6.16573751e-01f, 2.03701273e-01f, -1.69948027e-01f, -6.68263912e-01f, -7.52381265e-01f, 7.60375619e-01f, 1.02190509e-01f, 8.79955709e-01f,
  -6.65270209e-01f, 5.90897024e-01f, -4.61710066e-01f, -1.67702392e-01f, -4.31538224e-01f, -7.76336789e-01f, 2.13092670e-01f, 1.65325239e-01f, 3.34208250e-01f, -1.08364478e-01f,
  -2.23948099e-02f, -3.08052540e-01f, -1.19515710e-01f, -5.76651454e-01f, 4.17182088e-01f, 6.03725612e-01f, 3.86484750e-02f, 2.38551870e-01f, 3.21435839e-01f, -7.02820301e-01f,
  5.67821503e-01f, -6.26439273e-01f, 4.43808407e-01f, 2.11089803e-03f, -3.90919089e-01f, 3.88138235e-01f, -1.19967890e+00f, -4.12249625e-01f, 3.18669260e-01f, -2.30161756e-01f,
  1.18900394e+00f, -1.20243505e-01f, -8.69562864e-01f, -3.48366201e-02f, -7.25484252e-01f, -7.67645717e-01f, -5.26871860e-01f, -4.60761748e-02f, 2.35276982e-01f, 4.59773391e-02f,
  5.06834872e-02f, 2.69694850e-02f, 3.91194820e-01f, -5.68033934e-01f, -1.22271456e-01f, 1.65666148e-01f, 6.83373213e-02f, -9.20421124e-01f, -3.72566760e-01f, 2.77969807e-01f,
  -7.46270597e-01f, 1.61889315e-01f, -5.56749761e-01f, 6.74056172e-01f, -6.96306825e-02f, -5.38670719e-01f, 5.76898515e-01f, -8.37228596e-01f, -3.90317768e-01f, -6.69798791e-01f,
  -1.17044508e+00f, -1.13047814e+00f, -7.34085202e-01f, 1.09707189e+00f, -1.04878950e+00f, 2.82617837e-01f, 8.98480713e-01f, 5.55259645e-01f, -7.42363691e-01f, -8.66041601e-01f,
  1.99252799e-01f, 2.32532263e-01f, 3.57893556e-01f, 7.37434924e-02f, 3.12666744e-01f, 1.58243880e-01f, 4.18776553e-03f, 2.16144502e-01f, -1.32869229e-01f, -1.82647586e-01f,
  3.03558916e-01f, -1.12443510e-02f, -2.35723361e-01f, 6.17482373e-03f, 1.82096690e-01f, -3.87647122e-01f, -3.45789969e-01f, 5.39656699e-01f, -2.44088322e-01f, -1.06513464e+00f,
  -4.08673316e-01f, 5.78282952e-01f, -1.22934937e+00f, 6.25081956e-01f, 9.70847189e-01f, -2.55545378e-01f, 3.37580085e-01f, -3.27270985e-01f, -1.19737017e+00f, -3.47385474e-04f,
  -7.16499627e-01f, -3.88764977e-01f, 3.46925706e-01f, -2.19916493e-01f, 1.73175171e-01f, -1.50728464e-01f, 4.41514462e-01f, 4.07027006e-01f, 6.75808266e-02f, 4.19264644e-01f,
  2.22031772e-02f, -4.07388389e-01f, 6.99625254e-01f, 6.42715469e-02f, 4.84812528e-01f, 1.70678705e-01f, -1.97536722e-01f, 5.26341833e-02f, -1.67405248e-01f, 8.80729020e-01f,
  -1.18063122e-01f, 5.86081862e-01f, 1.14740252e+00f, -6.33787453e-01f, -3.36996138e-01f, -7.42703080e-01f, -5.49920619e-01f, -1.31607425e+00f, -9.42307711e-01f, -3.23478580e-01f,
  7.44505882e-01f, -1.24857795e+00f, -5.76829374e-01f, -1.03194928e+00f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  3.42871010e-01f, -2.03453258e-01f, 6.40490949e-01f, -4.27324027e-01f, -7.87312165e-02f, 1.14989117e-01f, 6.44266427e-01f, -5.01487195e-01f, -2.88970888e-01f, 5.13409041e-02f,
  -5.88282347e-01f, 3.13002795e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    