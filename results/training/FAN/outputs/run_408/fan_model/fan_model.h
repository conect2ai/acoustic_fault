/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.76164612e-01f, -2.77938992e-01f, -2.93277532e-01f, -4.05691303e-02f, 1.72217429e-01f, -6.93490282e-02f, 5.03080450e-02f, -7.46468231e-02f, -1.93388358e-01f, -1.36500727e-02f,
  1.13118403e-01f, -1.95322335e-01f, -3.05670407e-02f, -5.53436158e-03f, 1.24697804e-01f, -7.53637478e-02f, -6.34201691e-02f, 1.05283320e-01f, -5.77360019e-02f, 3.59639376e-02f,
  2.00796574e-02f, 1.11686788e-01f, -5.60961850e-02f, -1.04151383e-01f, 5.48209772e-02f, -1.94044665e-01f, 6.81427270e-02f, -8.01205188e-02f, 3.11917681e-02f, -6.00982681e-02f,
  8.40410665e-02f, -8.82906839e-02f, -4.76264767e-02f, -6.42817765e-02f, -2.89556365e-02f, -2.63954699e-02f, 4.70592603e-02f, -4.33238130e-03f, -4.11962681e-02f, 5.60541125e-03f,
  3.08805164e-02f, 1.10669089e-02f, -4.63280939e-02f, 1.75857928e-03f, -2.81075202e-02f, -3.92090180e-04f, -4.76995371e-02f, -1.10714026e-02f, -1.82262864e-02f, -2.96612550e-02f,
  -1.69210732e-02f, 7.68391266e-02f, 3.18842120e-02f, -7.42272884e-02f, -6.68102875e-02f, -6.50320202e-02f, -6.29106387e-02f, -3.66905145e-02f, 1.13064516e-02f, -7.03111067e-02f,
  2.78312899e-02f, -2.40051579e-02f, -2.64938083e-03f, 3.00327297e-02f, 2.89813876e-02f, 7.74634182e-02f, 3.93263660e-02f, 4.20073755e-02f, -3.50379460e-02f, 4.67117615e-02f,
  -1.80637594e-02f, 4.07720432e-02f, 2.42611766e-02f, 2.20004655e-02f, 7.08104894e-02f, 1.11193806e-01f, 5.29728234e-02f, -4.35339436e-02f, -4.88612950e-02f, 4.22958359e-02f,
  8.94820020e-02f, 2.18171030e-02f, -8.75740722e-02f, -2.42574024e-03f, 5.61317131e-02f, -2.24968232e-02f, 5.12844399e-02f, 3.82090948e-05f, -1.65305175e-02f, 6.32386431e-02f,
  -9.42005366e-02f, -2.29498580e-01f, -5.47443926e-02f, -2.82388180e-02f, -6.82056695e-02f, 3.51304151e-02f, -3.17966193e-02f, 2.60445140e-02f, -2.13642940e-02f, -1.26820076e-02f,
  -2.95315739e-02f, -3.03272288e-02f, 2.59790868e-02f, 7.11754784e-02f, -5.88868558e-02f, -9.53583568e-02f, -2.05198210e-02f, -4.63254303e-02f, -9.51574650e-03f, 8.35548062e-03f,
  5.56964763e-02f, -4.47704792e-02f, 3.38917077e-02f, 7.46793523e-02f, 1.94652611e-03f, -1.20246888e-03f, -7.25417510e-02f, -7.69131780e-02f, 1.94062646e-02f, -2.10849978e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.02893150e-01f, -4.56329346e-01f, -6.80602908e-01f, -3.12220216e-01f, 3.99747759e-01f, 4.39385295e-01f, -4.33594435e-02f, -8.64546746e-02f, -4.25419450e-01f, 1.76359028e-01f,
  3.71580333e-01f, -1.49332926e-01f, -2.52068341e-01f, -6.70122076e-03f, -2.20443547e-01f, -4.11523372e-01f, 4.55526775e-03f, -3.71987112e-02f, -3.32759768e-01f, 5.54272383e-02f,
  -1.87687054e-01f, 2.28095949e-01f, -2.68837631e-01f, 2.49719962e-01f, 2.04576686e-01f, 9.43682194e-02f, 2.19166219e-01f, 5.03715724e-02f, 5.95043778e-01f, 2.05572009e-01f,
  -6.75676316e-02f, -2.50035733e-01f, -3.54696736e-02f, -1.70174763e-01f, 5.76237328e-02f, 9.64908600e-02f, -8.78626630e-02f, 8.56010094e-02f, -5.44677563e-02f, -3.75018269e-02f,
  -3.01711820e-02f, 6.36001974e-02f, 5.08481525e-02f, -8.04024786e-02f, -2.96769701e-02f, 4.80305515e-02f, 5.67482971e-03f, -8.94976780e-02f, -1.72310039e-01f, -4.31284457e-02f,
  -1.70899451e-01f, 1.86227914e-02f, -8.58679935e-02f, 3.05160768e-02f, 5.46288863e-03f, -8.33668485e-02f, 4.81079705e-03f, 7.96696022e-02f, 1.97810922e-02f, 3.40041965e-02f,
  -1.57740004e-02f, 2.09772885e-02f, -5.06347418e-02f, -1.76872294e-02f, -4.08738591e-02f, 5.88815995e-02f, -5.32794110e-02f, -2.39495579e-02f, -4.53378372e-02f, 3.92805710e-02f,
  -1.38154700e-02f, -8.10598806e-02f, -2.05201991e-02f, 9.30312946e-02f, 1.01164855e-01f, -1.69056863e-01f, -3.11265215e-02f, 7.07003325e-02f, 1.52897909e-01f, -8.76656249e-02f,
  -8.01904127e-02f, -5.39687946e-02f, 1.13678932e-01f, 4.11035642e-02f, -1.71623260e-01f, 4.75879572e-02f, -1.44119991e-03f, -2.13292241e-02f, -1.08439764e-02f, 3.54717299e-02f,
  4.30093408e-02f, 9.63515118e-02f, -4.50343974e-02f, 3.51739898e-02f, 1.97139266e-03f, 1.31366521e-01f, -1.42087609e-01f, -2.40439456e-02f, 1.04645072e-02f, -7.87119120e-02f,
  1.54755920e-01f, 2.03502756e-02f, 1.21885277e-01f, 1.73420776e-02f, 5.51630519e-02f, 1.08385198e-01f, 1.74337216e-02f, 6.52979016e-02f, 6.79007471e-02f, 1.02037661e-01f,
  7.65676200e-02f, 6.21944703e-02f, 5.01348812e-04f, -1.32772848e-02f, 1.31812274e-01f, 1.47206873e-01f, 1.11389205e-01f, 9.45126414e-02f, -5.77953681e-02f, -7.35668931e-03f,
  -9.75287378e-01f, 4.60518122e-01f, -2.00744078e-01f, -3.85264486e-01f, -6.29407838e-02f, -4.40161496e-01f, -3.28464538e-01f, -3.57980281e-02f, -1.53553814e-01f, 6.83923289e-02f,
  1.42741147e-02f, 3.42068938e-03f, 2.11844131e-01f, -6.64201453e-02f, -3.15187484e-01f, 1.53827310e-01f, -4.00945157e-01f, -2.22579271e-01f, 1.70144122e-02f, -1.62703335e-01f,
  -1.50058091e-01f, 1.49421945e-01f, -5.67967035e-02f, 4.36481088e-01f, -1.87047914e-01f, -1.27353922e-01f, -9.24135372e-02f, 1.90044001e-01f, -3.76549624e-02f, -4.19685729e-02f,
  -5.32193124e-01f, -2.85958678e-01f, -2.46077180e-01f, -1.39379546e-01f, -2.64183402e-01f, -4.82132249e-02f, -1.47520393e-01f, -8.63439590e-02f, -3.22902910e-02f, -2.56707072e-02f,
  -2.26414558e-02f, 7.05976188e-02f, 6.74167201e-02f, 6.63076937e-02f, -4.96514812e-02f, 1.22134155e-02f, 3.66784856e-02f, -7.72198290e-02f, 4.35832813e-02f, 4.11959141e-02f,
  1.39581561e-01f, -5.50852977e-02f, -1.28390834e-01f, -1.57827120e-02f, -6.63572624e-02f, -6.82258932e-03f, -1.53966667e-02f, 1.25061631e-01f, 9.18416865e-03f, -3.98297831e-02f,
  6.91603869e-02f, -2.28926197e-01f, -7.94103891e-02f, -4.06834384e-04f, 5.44018783e-02f, 1.31504014e-01f, 8.15577954e-02f, 5.12865931e-02f, -7.00651184e-02f, 6.45182002e-03f,
  -5.05320728e-02f, 2.51257140e-02f, -5.43709919e-02f, -7.76323900e-02f, -8.46213326e-02f, -1.21253252e-01f, -1.87601764e-02f, -8.78067464e-02f, -6.49845153e-02f, -5.71096577e-02f,
  3.46350409e-02f, -7.38465413e-02f, 1.06040888e-01f, -5.39771654e-02f, -9.36034694e-02f, 1.11100465e-01f, 5.61297350e-02f, 5.80645390e-02f, -4.57987329e-03f, -2.08191797e-01f,
  -6.85228288e-01f, -3.54215860e-01f, -2.88054720e-02f, 5.89763559e-02f, -2.25813724e-02f, -5.64969294e-02f, -1.42970145e-01f, -2.63030315e-03f, -1.88362166e-01f, 1.02745732e-02f,
  -8.61007124e-02f, -6.55094460e-02f, -1.09344922e-01f, -5.00143729e-02f, -3.57928313e-02f, -4.61867191e-02f, -1.18091755e-01f, -1.06989533e-01f, -1.75701380e-01f, -9.94951185e-03f,
  7.12808147e-02f, -1.91907287e-02f, 1.58540890e-01f, -3.18319574e-02f, -1.54077679e-01f, -6.71514422e-02f, -1.34730846e-01f, 6.03777654e-02f, 2.47169435e-02f, 3.03692929e-02f,
  -6.54857635e-01f, 4.03111011e-01f, -1.73324481e-01f, -9.06173978e-03f, -3.42729092e-02f, 1.12980753e-01f, -1.92242086e-01f, 1.74487978e-01f, 5.93084581e-02f, 1.41635284e-01f,
  2.49128155e-02f, -3.60458903e-02f, 2.27233529e-01f, 6.31313026e-02f, -4.38963830e-01f, 2.03161746e-01f, -1.64980248e-01f, -2.87085597e-04f, 2.07272246e-01f, 1.41773239e-01f,
  -1.17014177e-01f, 2.15029880e-01f, -2.29549840e-01f, 9.94270816e-02f, -2.37723783e-01f, -1.58499047e-01f, -3.37570399e-01f, 5.78859486e-02f, -3.21497291e-01f, -1.63090646e-01f,
  -5.44243753e-01f, -1.10148869e-01f, -4.30972010e-01f, -2.17015296e-01f, -1.78981945e-01f, -2.38990903e-01f, -1.67908698e-01f, 7.50219747e-02f, 1.00772895e-01f, 1.25859767e-01f,
  8.91140196e-03f, -9.86253144e-05f, 1.38335869e-01f, 1.47965714e-01f, -6.04905263e-02f, -1.20381840e-01f, -1.34041235e-01f, -5.30188270e-02f, 6.48610368e-02f, 9.88769066e-03f,
  -7.05646425e-02f, 1.65463295e-02f, -1.61105260e-01f, -1.51313707e-01f, -1.30147189e-01f, -1.54316857e-01f, -1.52764246e-01f, -5.98753355e-02f, -2.18823269e-01f, -1.95950598e-01f,
  -3.76172513e-02f, 6.73820376e-02f, -1.77009419e-01f, -4.19299938e-02f, 5.92441186e-02f, 4.97394875e-02f, 3.05733010e-02f, -7.48856738e-02f, -8.38594735e-02f, -1.07013769e-02f,
  -5.88658415e-02f, -1.06563732e-01f, 1.61328793e-01f, -2.59529217e-03f, 1.13215283e-01f, -6.68283179e-02f, -8.50485731e-03f, 7.84264505e-02f, -3.14823575e-02f, -1.08646914e-01f,
  8.63896608e-02f, 1.25393849e-02f, -1.27585068e-01f, -2.89357305e-02f, -7.32856169e-02f, 6.50588349e-02f, 9.39838141e-02f, 3.44666280e-02f, -9.04581323e-02f, 1.17490463e-01f,
  -2.72663534e-01f, -1.48732349e-01f, -9.01694298e-02f, -1.84188798e-01f, -8.08018669e-02f, -6.59360215e-02f, -5.26379533e-02f, -7.06461892e-02f, -4.49608564e-02f, -3.42047103e-02f,
  -1.12679876e-01f, 9.05983988e-03f, -1.18470699e-01f, 3.33131552e-02f, 1.00044638e-01f, -1.29118308e-01f, -6.41653165e-02f, 1.02233924e-02f, -1.77952513e-01f, -2.44410243e-02f,
  -3.68605517e-02f, -6.49700407e-03f, -6.43749833e-02f, 7.93406963e-02f, -4.35124524e-02f, -1.66053042e-01f, 1.71046685e-02f, -1.43039227e-01f, -1.91800386e-01f, -6.89561144e-02f,
  -2.21712917e-01f, 4.25401241e-01f, -5.33598721e-01f, 1.57444492e-01f, -2.64110953e-01f, 5.39175808e-01f, 7.12834418e-01f, -6.13080114e-02f, 7.83423260e-02f, 6.98492706e-01f,
  3.65950584e-01f, 1.29163504e-01f, 1.12336151e-01f, 7.00663984e-01f, -8.44561160e-02f, 3.95040184e-01f, 5.57814837e-01f, 5.14401972e-01f, -2.22139303e-02f, 1.91430718e-01f,
  -1.27021804e-01f, 4.41577494e-01f, -2.41676316e-01f, -5.21257967e-02f, 8.77991840e-02f, -3.29039335e-01f, 1.70625392e-02f, -3.16345930e-01f, 1.78398490e-01f, 6.23244792e-02f,
  8.37952718e-02f, 4.97669727e-03f, -1.40473843e-01f, -1.00898728e-01f, -7.67281577e-02f, -4.53041606e-02f, -1.12445103e-02f, -8.44326541e-02f, -1.23935916e-01f, 6.76369220e-02f,
  5.33012450e-02f, -3.07173915e-02f, 1.06041674e-02f, -7.55012929e-02f, -7.62056783e-02f, -1.63270846e-01f, -1.14920892e-01f, -5.54582514e-02f, 1.22348517e-02f, -6.96901083e-02f,
  -6.03915192e-02f, 3.82582396e-02f, -2.32029706e-02f, 5.70880994e-02f, -1.28121808e-01f, 7.42669031e-02f, 1.17179595e-01f, 2.00600866e-02f, 1.28106251e-01f, -8.69836845e-03f,
  2.16258746e-02f, 9.34353750e-03f, 9.42171514e-02f, -5.45541048e-02f, -5.37076220e-02f, -9.75908786e-02f, 1.77025683e-02f, 3.57345603e-02f, -1.26989633e-01f, 6.40610009e-02f,
  -1.95369143e-02f, 2.10060342e-03f, 5.38280085e-02f, 3.55886593e-02f, 2.03680739e-01f, 5.68629354e-02f, -6.03017360e-02f, 8.22563842e-02f, -4.45218058e-03f, -5.22290878e-02f,
  -1.39312930e-02f, 1.49849564e-01f, 5.48679661e-03f, -2.38034744e-02f, 4.92250063e-02f, 7.04733096e-03f, 1.46851465e-01f, -6.40167072e-02f, -6.34936467e-02f, 7.37551823e-02f,
  2.97696620e-01f, 3.27796787e-01f, 3.11151370e-02f, 1.57433751e-04f, -3.45467590e-02f, -1.41699798e-02f, -2.92766490e-03f, -1.19570252e-02f, 1.14337146e-01f, 3.01871002e-02f,
  1.59232300e-02f, -3.47555280e-02f, 7.60680437e-02f, -5.68771288e-02f, -3.52210179e-02f, 2.03577474e-01f, 1.40264452e-01f, -1.90600846e-02f, 9.56135839e-02f, -1.09536104e-01f,
  3.85428369e-02f, -8.30494706e-03f, -3.44137843e-05f, 3.13746370e-03f, -1.81958359e-02f, 3.20876688e-02f, 1.01134188e-01f, -5.17556854e-02f, -1.20695747e-01f, 1.04173891e-01f,
  4.92264241e-01f, 1.58683494e-01f, -7.43411258e-02f, 1.42170727e-01f, -3.47859383e-01f, -2.78883070e-01f, -4.71106142e-01f, -5.29999770e-02f, -3.62948596e-01f, 6.26786947e-02f,
  7.51511306e-02f, 2.47905776e-02f, -8.40726346e-02f, 3.81711394e-01f, 3.82185936e-01f, 3.45028378e-02f, 3.52468014e-01f, 3.47764231e-02f, -2.46445283e-01f, 2.81082511e-01f,
  1.72557369e-01f, 4.16827530e-01f, 2.67733574e-01f, 3.38974118e-01f, -2.18922570e-02f, 3.48810069e-02f, 3.15909743e-01f, -9.81602743e-02f, 3.16287160e-01f, -2.43547163e-03f,
  1.65607408e-02f, 3.03623807e-02f, -5.00147641e-02f, -5.28672300e-02f, 1.03056207e-01f, -1.34446442e-01f, -2.32880756e-01f, -1.79191932e-01f, -2.57242471e-01f, -1.16451077e-01f,
  -5.03106834e-03f, 1.10343315e-01f, 1.68792859e-01f, 3.79403029e-03f, -2.27337405e-01f, 5.44741265e-02f, -4.39728647e-02f, -5.07502072e-02f, -8.42725262e-02f, 1.25646502e-01f,
  -8.46905261e-02f, -7.27080256e-02f, -6.42191619e-02f, 1.15742059e-02f, 4.40964028e-02f, 7.82216713e-02f, -1.04723252e-01f, 6.38035405e-03f, 1.73183028e-02f, -2.07216945e-03f,
  5.06723411e-02f, -1.82020560e-01f, 6.11808226e-02f, -2.12890599e-02f, 3.33252810e-02f, 3.02820634e-02f, -4.37040552e-02f, 1.37459815e-01f, 6.52472973e-02f, 1.69237807e-01f,
  5.85670434e-02f, 6.15475606e-03f, -8.16021711e-02f, -1.20798320e-01f, 3.85052972e-02f, 2.08052136e-02f, -7.37265646e-02f, 4.11194786e-02f, 3.91474068e-02f, 9.48715955e-02f,
  -1.39397725e-01f, -3.91505659e-02f, 1.01656593e-01f, -2.01083288e-01f, 5.69000356e-02f, -8.73172209e-02f, -3.66067933e-03f, 8.12742412e-02f, -1.93302050e-01f, -5.76419085e-02f,
  3.06947716e-02f, 3.56563926e-01f, 8.35046247e-02f, 1.10640442e-02f, 3.40330862e-02f, 2.45674744e-01f, -6.72449991e-02f, 3.63109887e-01f, 5.63636720e-02f, 2.01847814e-02f,
  1.15163870e-01f, -2.85519361e-02f, -1.72371000e-01f, -6.47315904e-02f, -8.15505683e-02f, 8.98262039e-02f, 1.33997008e-01f, -9.23653543e-02f, 5.24336956e-02f, 9.22811702e-02f,
  8.45278352e-02f, 4.71952691e-04f, 1.60977975e-01f, -5.79234734e-02f, 1.59342900e-01f, 1.32851377e-02f, -5.55102378e-02f, -8.88359323e-02f, 2.09109727e-02f, 9.37837437e-02f,
  -1.10469893e-01f, -1.53375328e-01f, -2.75997818e-01f, -2.99855888e-01f, -3.52687798e-02f, -6.25762224e-01f, -6.55307949e-01f, -3.12584728e-01f, 8.49242210e-02f, -7.10030124e-02f,
  -2.94186085e-01f, 4.93013719e-03f, -5.83013594e-02f, -5.68886042e-01f, -2.03726828e-01f, 1.22260153e-01f, -6.81144357e-01f, -3.29716802e-01f, 1.08659133e-01f, -3.12149793e-01f,
  -1.23693265e-01f, -3.77618104e-01f, -3.01556110e-01f, -4.81713265e-02f, -4.16521013e-01f, -6.90227151e-02f, 3.07482749e-01f, -4.79357429e-02f, -3.39092284e-01f, -1.08949155e-01f,
  -1.23510964e-01f, 2.76001282e-02f, -4.67853956e-02f, -1.19037993e-01f, -5.89389093e-02f, -2.02615000e-02f, -2.71513984e-02f, -2.71839127e-02f, 6.04113191e-02f, -5.46867400e-02f,
  -9.01341718e-03f, -3.27692181e-02f, -1.81271315e-01f, 9.99055505e-02f, 4.93461639e-02f, 2.64376663e-02f, -6.54128715e-02f, 1.23600684e-01f, -3.10854893e-02f, -1.13136463e-01f,
  -1.74904138e-01f, -4.75687953e-03f, -6.20873272e-02f, 2.70894542e-02f, 7.59573951e-02f, -1.61971360e-01f, -2.31580827e-02f, 1.09512769e-01f, -1.57239251e-02f, 1.04744405e-01f,
  -6.40311092e-02f, 8.18398371e-02f, -6.01575822e-02f, 4.75920103e-02f, -1.45852724e-02f, 2.73452159e-02f, -5.61571606e-02f, -1.52617674e-02f, 4.38303985e-02f, 4.11720462e-02f,
  -9.41528566e-03f, -5.74061014e-02f, -4.65886667e-03f, -3.99242230e-02f, 6.79663802e-03f, 1.04806989e-01f, -1.16483020e-02f, 1.98356770e-02f, -6.50231242e-02f, -9.18178409e-02f,
  2.46810336e-02f, 2.62088627e-02f, -1.72331464e-02f, 7.84329996e-02f, -5.66797815e-02f, -2.18268670e-03f, 7.47648329e-02f, -6.33959770e-02f, -3.53160165e-02f, 3.08906138e-02f,
  -1.78798288e-01f, -4.43906151e-03f, -3.57540697e-02f, -6.69166297e-02f, 1.73571575e-02f, 1.26329297e-02f, 3.87786403e-02f, -1.78563505e-01f, -4.30229791e-02f, 6.99270815e-02f,
  4.51333933e-02f, 6.85218275e-02f, 1.20613709e-01f, -3.41430157e-02f, -6.33077696e-02f, -6.61239922e-02f, 3.32549177e-02f, 5.92978299e-02f, 8.63267556e-02f, -4.24211174e-02f,
  1.62257627e-01f, 2.75756381e-02f, 7.27311475e-03f, -2.13211142e-02f, 5.76629341e-02f, 2.12333109e-02f, 1.36097521e-01f, -2.84645129e-02f, 1.13987448e-02f, 3.26454872e-03f,
  5.41145921e-01f, 2.31761456e-01f, 3.37339580e-01f, 3.56929958e-01f, 2.20641330e-01f, 7.66791478e-02f, 3.73848788e-02f, 3.14559162e-01f, 4.41949695e-01f, 1.55483708e-01f,
  -3.47984731e-01f, 1.72552660e-01f, -3.16511154e-01f, 1.85882002e-01f, -4.35675621e-01f, -2.55621910e-01f, -1.27804399e-01f, -5.39728850e-02f, -2.23942846e-03f, 1.02435820e-01f,
  -9.68359858e-02f, -4.07993317e-01f, -2.98717171e-01f, -3.08912337e-01f, 2.63577580e-01f, 2.55311698e-01f, -4.92788315e-01f, -1.08429268e-01f, 8.20999071e-02f, -1.68680742e-01f,
  -4.23474424e-03f, 2.01432526e-01f, 1.55461311e-01f, 5.22291884e-02f, 5.36217466e-02f, 1.90119535e-01f, 8.36772323e-02f, -1.34885535e-01f, -8.59586522e-02f, -1.42993883e-03f,
  1.92830581e-02f, -2.10028701e-02f, -1.61635187e-02f, -4.08489071e-02f, 1.11674018e-01f, 1.06591478e-01f, 1.10399336e-01f, 2.48238519e-01f, 1.19142219e-01f, 5.65221999e-03f,
  1.40969083e-01f, 1.87225699e-01f, 1.86379462e-01f, -4.58359942e-02f, 4.81066369e-02f, 6.32422343e-02f, -4.73187603e-02f, 9.59001780e-02f, 1.23519108e-01f, 7.81730115e-02f,
  1.09920437e-02f, 3.11372411e-02f, -6.20865561e-02f, -1.19712483e-02f, -3.61500084e-02f, -5.90550080e-02f, -2.70885415e-02f, -1.65793896e-01f, 7.52534643e-02f, -7.94600025e-02f,
  -3.13385986e-02f, 1.16714403e-01f, 6.49929196e-02f, -2.80390115e-04f, 5.05985096e-02f, 1.33574620e-01f, -7.35026374e-02f, 4.31764163e-02f, 3.24677378e-01f, 1.72487162e-02f,
  1.36958668e-03f, -1.26269177e-01f, -1.04604393e-01f, 1.08185625e-02f, -7.69368708e-02f, -1.61758229e-01f, 3.62691209e-02f, 1.30315259e-01f, -6.85588419e-02f, -1.16813764e-01f,
  -1.38838172e-01f, -2.18067631e-01f, -4.47772890e-02f, 7.85600021e-03f, -1.27635807e-01f, -4.52131666e-02f, -1.34761170e-01f, 9.04864445e-02f, -1.73336640e-01f, -2.94292904e-02f,
  1.24280706e-01f, -1.44320697e-01f, 4.64157425e-02f, 5.36257923e-02f, -3.91146913e-02f, -1.14960067e-01f, 9.77284163e-02f, -5.05945794e-02f, -2.37998702e-02f, -6.49254471e-02f,
  -2.77314913e-02f, -5.03349081e-02f, -1.92743707e-02f, 1.13534428e-01f, 8.98696408e-02f, 1.11713093e-02f, -4.02898267e-02f, 5.55710532e-02f, -2.26817336e-02f, -2.50850953e-02f,
  7.98229277e-02f, -1.44206777e-01f, -8.56174454e-02f, 2.04649106e-01f, 1.06396422e-01f, -2.74704725e-01f, -1.50430664e-01f, 2.12619632e-01f, -2.38448635e-01f, -1.87495798e-01f,
  1.26146510e-01f, -1.41751990e-01f, -2.20730841e-01f, 3.30322087e-01f, 4.60404456e-01f, -3.44526559e-01f, 2.17509702e-01f, 7.13670105e-02f, -1.17599875e-01f, 5.70756234e-02f,
  -1.24290213e-03f, 3.67808878e-01f, 1.36240572e-01f, 2.71750778e-01f, 1.30524457e-01f, 2.46180058e-01f, 3.24850947e-01f, -1.20583940e-02f, 4.59720105e-01f, 7.48434812e-02f,
  -6.82664812e-02f, 4.58226688e-02f, 7.00457245e-02f, -1.38883784e-01f, 5.38597144e-02f, 6.95728958e-02f, -3.81214656e-02f, 3.03825587e-02f, 3.23722996e-02f, -1.23945117e-01f,
  -4.33170050e-02f, 6.29526153e-02f, 1.56930506e-01f, 1.60884038e-01f, 1.49318948e-02f, 1.18249252e-01f, 1.29125848e-01f, 5.53617254e-02f, 5.59276119e-02f, -4.98802215e-02f,
  -5.33121489e-02f, -7.47122690e-02f, -8.65499824e-02f, 3.71503830e-02f, 4.14961874e-02f, 1.90041587e-03f, 1.56825818e-02f, 2.46160571e-03f, -5.91925234e-02f, -3.14173475e-02f,
  4.44517024e-02f, -8.66258517e-02f, -7.10756332e-02f, 1.14286095e-02f, -8.59691016e-03f, -6.22454137e-02f, -8.84774998e-02f, 8.58956054e-02f, -5.93098477e-02f, 1.17784720e-02f,
  -4.61790748e-02f, 1.98315196e-02f, -3.07157412e-02f, -9.76648703e-02f, -3.13337855e-02f, -1.31662622e-01f, 9.76192504e-02f, 1.06320009e-01f, -2.41671759e-03f, -2.61753276e-02f,
  -1.25600487e-01f, 4.48447019e-02f, 1.78295765e-02f, -1.03144934e-02f, 4.23436537e-02f, -1.18821301e-01f, 4.30717766e-02f, -7.18626603e-02f, -3.86299007e-02f, -3.01308874e-02f,
  9.90774557e-02f, -3.55294906e-02f, -6.82098642e-02f, 5.68290614e-02f, -7.47378916e-03f, -1.21732198e-01f, -1.80528797e-02f, -6.97607026e-02f, -4.21391651e-02f, -2.99419202e-02f,
  1.62467495e-01f, 8.79808962e-02f, -1.62803739e-01f, 9.77689549e-02f, 1.21381067e-01f, -9.52945277e-02f, -6.78765774e-02f, 1.57411825e-02f, 1.51147738e-01f, 6.65228739e-02f,
  -3.32933739e-02f, -3.06306966e-02f, -8.78658816e-02f, 7.50659183e-02f, 6.65146811e-03f, -2.95340307e-02f, 8.66844729e-02f, -4.45088074e-02f, 7.70175755e-02f, 6.26712898e-03f,
  5.44651389e-01f, -9.39930975e-02f, -1.03730727e-02f, 5.19604325e-01f, 3.36526275e-01f, 1.21414378e-01f, 1.96559727e-01f, 3.87329102e-01f, 5.26372492e-01f, -2.84769654e-01f,
  -8.10118485e-03f, -1.69321567e-01f, -2.24162504e-01f, 7.40844458e-02f, 2.78690130e-01f, -5.16054705e-02f, 3.90493929e-01f, -1.38486758e-01f, 1.90902561e-01f, 1.48314148e-01f,
  2.98020780e-01f, 6.57354966e-02f, -9.90508348e-02f, -1.86026935e-02f, 8.69765505e-02f, -9.62473359e-03f, -2.42854297e-01f, -3.06809634e-01f, -3.17026347e-01f, -8.58658850e-02f,
  -4.18878570e-02f, 3.94041352e-02f, 1.25221144e-02f, -1.35499135e-01f, 1.39671922e-01f, -3.60256173e-02f, -2.86413610e-01f, -1.25469074e-01f, 2.81568766e-02f, 2.24194378e-02f,
  -1.79968387e-01f, -1.38822116e-03f, 3.06607783e-02f, 3.31613123e-02f, 2.79077627e-02f, 2.96846312e-02f, 2.11277772e-02f, -7.23684654e-02f, -7.67457411e-02f, -5.94999501e-03f,
  8.11031610e-02f, -4.83769290e-02f, -1.87403541e-02f, -1.42346084e-01f, 6.04768237e-03f, 5.79145700e-02f, 7.23999217e-02f, -9.08211321e-02f, -4.41008396e-02f, 1.80843011e-01f,
  -1.72771737e-01f, 8.48066285e-02f, -7.73244426e-02f, 5.45597561e-02f, 1.26241669e-01f, 7.83802941e-02f, 4.98663224e-02f, 3.60330679e-02f, 4.51908400e-03f, -8.26678332e-03f,
  4.34361510e-02f, 2.77932640e-02f, -5.50750419e-02f, 7.44511709e-02f, 2.70717200e-02f, 3.40055414e-02f, -3.86363864e-02f, -1.37103915e-01f, -1.36978492e-01f, 3.39525193e-02f,
  -2.63266806e-02f, 1.11315385e-01f, -9.98109952e-02f, -2.53183693e-02f, -3.20712067e-02f, -1.46052893e-02f, 6.14439212e-02f, -7.16369227e-02f, 6.87168315e-02f, 6.70125559e-02f,
  9.76612270e-02f, 1.05744161e-01f, 4.96178074e-03f, -1.45910740e-01f, -7.70822391e-02f, 4.02622037e-02f, 1.65536180e-02f, -5.80630265e-02f, -5.05025461e-02f, 3.34041705e-03f,
  -7.78774023e-02f, -4.80286125e-03f, -2.20565014e-02f, 2.31683925e-02f, -5.48522323e-02f, 7.87554532e-02f, -1.02825910e-01f, -1.45050809e-01f, 8.21701158e-03f, 2.87212878e-02f,
  -2.99307611e-02f, 1.99534651e-02f, -1.13530345e-01f, 1.34168461e-01f, -1.04553057e-02f, -1.54698417e-01f, 2.73053885e-01f, -2.15890557e-02f, -5.13079017e-02f, 3.80084254e-02f,
  1.58964172e-02f, 1.15650795e-01f, 6.84351996e-02f, -3.89020056e-01f, 9.86431167e-02f, -1.06023431e-01f, -2.39597857e-02f, 9.14144441e-02f, -4.24794197e-01f, 1.85867280e-01f,
  -1.70650110e-02f, 5.08844778e-02f, 2.43237272e-01f, -2.28352576e-01f, -5.89064717e-01f, -3.39315623e-01f, -6.19593501e-01f, -7.37412795e-02f, -4.51169871e-02f, 1.99442342e-01f,
  -2.25672975e-01f, -2.41190270e-01f, -6.03008047e-02f, 1.78450555e-01f, 2.27060959e-01f, 2.47123644e-01f, 1.99924931e-02f, 2.19291180e-01f, 8.27244446e-02f, -2.14035481e-01f,
  1.47253737e-01f, 2.58592516e-01f, 1.55778959e-01f, 6.55525103e-02f, 7.36802071e-02f, 9.35144722e-02f, 1.53095827e-01f, 3.43352593e-02f, 9.65123624e-03f, 4.51909564e-02f,
  3.57505567e-02f, 8.38874280e-03f, 4.02745046e-02f, -1.08217254e-01f, 8.42305180e-03f, 1.24119088e-01f, -3.51277404e-02f, -5.05467728e-02f, 1.33370176e-01f, 5.10757789e-02f,
  7.30599985e-02f, 1.99611653e-02f, -1.47148073e-01f, -1.44309223e-01f, -1.46083847e-01f, 1.04951091e-01f, 1.10648721e-02f, -5.63471951e-02f, 9.99961495e-02f, -1.88078508e-01f,
  -8.68191570e-03f, 2.46643610e-02f, 1.17815100e-01f, 7.63519928e-02f, 6.96967095e-02f, 1.99216366e-01f, -5.99870123e-02f, 1.88119877e-02f, -7.15320259e-02f, 7.09619978e-03f,
  1.20116901e-02f, 5.21292314e-02f, 1.68430939e-01f, -1.46121427e-01f, -1.21844344e-01f, 3.68211046e-02f, 8.89969096e-02f, 1.32882744e-01f, -1.51993439e-01f, 5.55059202e-02f,
  4.27418761e-02f, -1.07870810e-02f, 2.81602181e-02f, -5.51190674e-02f, 2.03425407e-01f, -1.32111430e-01f, -4.04451005e-02f, -5.18880375e-02f, 5.04225492e-03f, -1.88147575e-02f,
  -9.19623822e-02f, -4.36780080e-02f, 1.05840489e-01f, 6.40511736e-02f, 2.90520694e-02f, 7.66054317e-02f, -1.75762072e-01f, -1.40207291e-01f, -2.36961558e-01f, -9.94433369e-03f,
  -5.14583662e-02f, -1.43658342e-02f, -1.01829395e-01f, 2.08331794e-02f, -1.26358747e-01f, -1.19453475e-01f, 7.62463585e-02f, -9.15594473e-02f, -1.21216752e-01f, 6.90646693e-02f,
  1.44546703e-01f, 9.21090767e-02f, -1.55168176e-01f, 9.35080498e-02f, -6.43966720e-02f, 3.08504421e-02f, -9.55968350e-02f, 2.06428543e-02f, 4.96978946e-02f, -1.38074279e-01f,
  3.53091285e-02f, -3.46718252e-01f, 4.72654551e-01f, -3.51610303e-01f, 1.29590973e-01f, 1.87571913e-01f, 2.39359736e-01f, -2.09521577e-01f, -2.55474925e-01f, -4.92600769e-01f,
  -8.56862143e-02f, 7.66968876e-02f, 2.46210188e-01f, -3.42630327e-01f, 7.14679420e-01f, 2.20426261e-01f, -1.46960884e-01f, -6.00950085e-02f, -2.73957551e-02f, -1.84397280e-01f,
  -1.10702552e-01f, -3.24796498e-01f, 2.24533394e-01f, -2.76144266e-01f, -1.01940662e-01f, -1.89822152e-01f, -1.23213768e-01f, 2.95208395e-01f, -2.45123804e-01f, 2.66231447e-01f,
  -6.28482550e-03f, -1.62279963e-01f, -8.79575238e-02f, -7.00788125e-02f, -7.64525011e-02f, -1.39782354e-02f, 6.59353510e-02f, 2.10859478e-01f, -1.01350248e-02f, 5.90948574e-02f,
  2.00471841e-02f, 3.06334402e-02f, -1.27257988e-01f, 6.62617609e-02f, -8.73644203e-02f, -2.95321923e-02f, -4.64896439e-03f, 8.54082629e-02f, 3.69193889e-02f, 1.03673406e-01f,
  1.35874689e-01f, 3.31028923e-02f, -5.04927635e-02f, -6.71606362e-02f, 1.20793387e-01f, -8.79066885e-02f, -2.94736447e-03f, 1.75424978e-01f, 4.98333806e-03f, -7.32376575e-02f,
  -2.12952159e-02f, 3.78969163e-02f, 4.09594737e-02f, -7.59511292e-02f, 3.64069194e-02f, -7.29858503e-02f, -1.34897046e-02f, 3.10620982e-02f, -1.80284008e-02f, -9.79339331e-02f,
  -4.59873788e-02f, -4.35568877e-02f, 3.00355982e-02f, 2.88584027e-02f, -3.59226316e-02f, -6.74977750e-02f, 5.92151023e-02f, -2.66293809e-03f, 1.49673049e-03f, 3.81561629e-02f,
  -3.95210087e-02f, 2.46728454e-02f, 5.46473376e-02f, -2.52893306e-02f, -1.94162596e-02f, 1.05349146e-01f, 6.15361473e-03f, 4.54384647e-02f, 5.25891408e-02f, 1.45622253e-01f,
  -4.54549074e-01f, -6.54315412e-01f, -1.08008087e-01f, -8.28705207e-02f, -5.37159331e-02f, -7.85600543e-02f, -7.38101453e-02f, -1.19040608e-02f, -7.21788928e-02f, -9.64225382e-02f,
  -3.08634471e-02f, -4.22032885e-02f, -3.00870351e-02f, -2.93191895e-02f, -8.25469475e-03f, -1.19294440e-02f, -7.61718079e-02f, -1.90485597e-01f, -1.37213185e-01f, -6.52192235e-02f,
  -7.38365278e-02f, -1.89855066e-03f, 9.45570022e-02f, -1.04729101e-01f, -9.66625959e-02f, 8.40452537e-02f, 3.18474434e-02f, -1.49809960e-02f, 6.01560399e-02f, 2.36580670e-02f,
  5.30214190e-01f, -3.07858348e-01f, 1.73976105e-02f, 3.91547978e-01f, -7.94331171e-03f, -1.52504236e-01f, 5.99446557e-02f, -6.41229330e-03f, -9.30413455e-02f, -3.81765991e-01f,
  1.77228764e-01f, -2.44239479e-01f, -1.79243043e-01f, 1.21650256e-01f, 1.64464727e-01f, -2.91207612e-01f, 1.40902832e-01f, -8.13664496e-03f, 7.23977461e-02f, 2.87893444e-01f,
  2.83691764e-01f, 3.59598786e-01f, 2.73401350e-01f, 2.00238705e-01f, 3.45244795e-01f, 2.62784094e-01f, 1.86750218e-01f, 2.62589175e-02f, 6.79001361e-02f, 2.76632439e-02f,
  -1.13931365e-01f, 1.03229113e-01f, 6.96021244e-02f, -1.82208959e-02f, -4.47045192e-02f, 8.63051489e-02f, 6.68374002e-02f, 1.38974795e-03f, 1.17446616e-01f, -1.64881110e-01f,
  5.93160801e-02f, 2.99197845e-02f, 7.16685206e-02f, -1.17082678e-01f, 5.37737757e-02f, -2.18223371e-02f, -6.36505485e-02f, 7.35582560e-02f, -1.59378663e-01f, 1.43159255e-02f,
  -1.06678642e-01f, 1.99621660e-03f, 1.60815135e-01f, -1.38379171e-01f, -1.19785137e-01f, 1.18011557e-01f, -1.90172240e-01f, -1.19999222e-01f, -7.59684369e-02f, 1.07021751e-02f,
  1.61865130e-01f, -5.72110340e-03f, 1.63170666e-01f, 6.24324754e-02f, -7.49078346e-03f, 7.46452063e-02f, -6.58329390e-03f, -1.56038567e-01f, -1.75920025e-01f, -3.32270376e-02f,
  1.24905454e-02f, -1.01146027e-01f, 9.99232754e-02f, -8.58701691e-02f, -8.13808069e-02f, 2.21050307e-02f, -1.04371249e-03f, 2.00939476e-02f, -3.55155347e-03f, -6.91001862e-02f,
  5.85670844e-02f, -7.40140826e-02f, 4.45131585e-02f, 1.78545520e-01f, 1.30692227e-02f, 3.05402670e-02f, 1.67465135e-02f, -6.70012906e-02f, 1.12741850e-02f, -3.21931168e-02f,
  -1.29902393e-01f, -1.11220255e-01f, -6.32982552e-02f, 1.48910191e-03f, -9.22774300e-02f, -5.44298664e-02f, 2.46929377e-03f, 6.54488057e-02f, 2.16281787e-02f, 1.18853681e-01f,
  -1.73159130e-02f, 2.20432710e-02f, 2.77210083e-02f, -2.58858018e-02f, -1.38122067e-01f, 5.20873629e-02f, -2.18703970e-02f, -2.73924395e-02f, -2.14065630e-02f, 1.49811665e-02f,
  4.50606830e-03f, 8.47830903e-03f, 1.45274788e-01f, 1.68210790e-02f, -4.89163958e-02f, -6.22497797e-02f, -2.26862356e-01f, 5.99339791e-02f, -1.07287705e-01f, -1.31022587e-01f,
  7.56287202e-02f, 5.26252806e-01f, 4.53572035e-01f, 3.11051190e-01f, -3.30889583e-01f, -4.77878183e-01f, -3.04686457e-01f, 9.83037278e-02f, -2.54213452e-01f, 1.49606571e-01f,
  -8.54439214e-02f, 4.51887608e-01f, -1.31965533e-01f, 8.51711817e-03f, -4.69641089e-01f, -3.45617712e-01f, -7.99015686e-02f, -6.35235533e-02f, -1.32127866e-01f, 2.81208485e-01f,
  3.67322005e-02f, -1.10860616e-01f, 4.26889211e-01f, 2.28196308e-01f, 2.42831752e-01f, 3.66677523e-01f, 3.76576781e-01f, 1.03829861e-01f, 5.02676547e-01f, -2.31986836e-01f,
  -2.34221131e-01f, -9.33621451e-02f, 1.77519798e-01f, -6.23299479e-02f, 1.14718586e-01f, -1.98755064e-03f, 3.08825187e-02f, -1.36330709e-01f, -4.59425896e-02f, 1.04821555e-01f,
  9.83201433e-03f, 1.03755757e-01f, 2.85491645e-02f, -1.12053126e-01f, -1.80893596e-02f, 8.75650942e-02f, 7.40549192e-02f, 6.84576184e-02f, 4.66503613e-02f, 8.50057155e-02f,
  1.30230784e-01f, 6.38428181e-02f, 5.71992733e-02f, -3.80406529e-03f, 1.45838767e-01f, -3.01623717e-03f, -1.02774063e-02f, 1.34401143e-01f, 9.28410590e-02f, 1.11565128e-01f,
  -4.66927364e-02f, -2.10895762e-02f, 1.39063140e-02f, 1.50593771e-02f, 7.99937025e-02f, -2.80521736e-02f, 1.74938329e-03f, -2.15982310e-02f, -3.85381058e-02f, -7.78592657e-04f,
  1.26485258e-01f, 9.98272374e-02f, -1.22155383e-01f, 1.38242573e-01f, 6.25782013e-02f, 5.03184907e-02f, 2.89846454e-02f, -7.36044422e-02f, 1.06869601e-02f, 3.39603834e-02f,
  -9.29424241e-02f, -1.78587269e-02f, 1.73215970e-01f, -1.95702892e-02f, -2.17903569e-01f, 1.38723597e-01f, 4.52647172e-02f, 7.19181672e-02f, 7.18867704e-02f, 5.51516078e-02f,
  -1.52717397e-01f, 2.67273724e-01f, 5.82887977e-02f, -1.11522742e-01f, -1.13246351e-01f, -5.75815402e-02f, -4.57868576e-02f, 1.03707485e-01f, 3.10801938e-02f, -7.79814087e-03f,
  -7.50400349e-02f, 3.55325527e-02f, 2.97641139e-02f, -1.22668818e-01f, -6.63242489e-02f, 3.64236943e-02f, -2.30176132e-02f, 5.80982603e-02f, 9.12130326e-02f, 1.08216137e-01f,
  1.39322966e-01f, 4.35992889e-02f, -2.65776049e-02f, -9.73019600e-02f, -6.98376894e-02f, 5.76687604e-02f, 7.59843066e-02f, 4.11175080e-02f, -1.90409739e-02f, 4.56817448e-03f,
  -8.62502396e-01f, 2.71898508e-01f, 3.03956382e-02f, -1.55124187e-01f, -3.61441314e-01f, 3.61358345e-01f, 2.04929218e-01f, -1.27755791e-01f, -2.63213009e-01f, 3.47792357e-01f,
  1.62072241e-01f, -5.30725777e-01f, 2.60623187e-01f, 3.71185452e-01f, -1.68107957e-01f, 3.64646822e-01f, 2.71668822e-01f, 1.36941746e-01f, -9.46055427e-02f, -2.07491770e-01f,
  -2.08513755e-02f, 1.92243740e-01f, 4.53999877e-01f, -2.92786509e-02f, 2.03648239e-01f, -1.14964642e-01f, 2.44886085e-01f, -2.84524083e-01f, 6.39801547e-02f, -2.24889278e-01f,
  -3.17950994e-01f, -3.93397957e-01f, -8.37165564e-02f, -1.11292601e-01f, -7.21858665e-02f, 6.45514280e-02f, -3.70729640e-02f, -8.16214681e-02f, -1.64980650e-01f, -7.67745972e-02f,
  -7.59241506e-02f, 1.91053934e-02f, -1.10671639e-01f, -7.60846287e-02f, -7.06682354e-02f, 6.24594353e-02f, 6.71019331e-02f, 7.21785724e-02f, -2.22344212e-02f, 1.93638578e-01f,
  1.38415262e-01f, 1.16809972e-01f, 1.50057346e-01f, 1.12988099e-01f, 2.93390062e-02f, 1.00232132e-01f, 7.52597824e-02f, -6.96879923e-02f, -6.20601214e-02f, 2.94766165e-02f,
  1.06211923e-01f, -4.50562797e-02f, 5.83409742e-02f, 4.16288003e-02f, 1.01175219e-01f, 3.21131498e-02f, -3.23926173e-02f, 5.60184531e-02f, 2.31716433e-03f, 9.94096994e-02f,
  1.20448150e-01f, -1.67728767e-01f, -4.58914228e-02f, 1.11878850e-01f, 1.50731113e-02f, 1.91076268e-02f, -8.99938215e-03f, 2.29916684e-02f, 8.20427239e-02f, -5.49639985e-02f,
  -1.85065456e-02f, -1.02008022e-01f, 1.40282616e-01f, 1.75804749e-01f, -1.42733136e-03f, 2.14527715e-02f, -4.83203158e-02f, 1.35308594e-01f, 1.02281183e-01f, -7.96967670e-02f,
  -5.16836166e-01f, -5.27759552e-01f, 7.40570724e-02f, -6.66895136e-02f, 2.78263912e-03f, 1.81589901e-01f, 3.56998220e-02f, -4.85006832e-02f, -9.37620178e-02f, -8.85571316e-02f,
  -7.73562714e-02f, -6.64739357e-03f, -1.30297512e-01f, 9.24830586e-02f, -2.36757845e-02f, 1.04699820e-01f, -1.26429111e-01f, -1.23573340e-01f, -8.29556510e-02f, -4.06551957e-02f,
  -2.89235953e-02f, -2.92664766e-02f, -8.45988169e-02f, 9.37892050e-02f, 9.57901850e-02f, 5.49784526e-02f, -1.13287084e-01f, -7.78669044e-02f, -1.18633442e-01f, 4.16464955e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  4.23429191e-01f, 3.27992529e-01f, 3.94348800e-01f, 4.07614350e-01f, 5.93081787e-02f, 2.21649617e-01f, 7.01747119e-01f, 4.91764359e-02f, 6.07261658e-01f, 4.73601431e-01f,
  5.77456653e-01f, 4.74535853e-01f, 4.67400432e-01f, 3.77288200e-02f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -1.42344251e-01f, 6.25553191e-01f, 6.77230731e-02f, -2.58258760e-01f, -7.89862592e-03f, 2.08133921e-01f, 3.86487991e-01f, 2.94058561e-01f, 5.23481630e-02f, 8.63428116e-02f,
  -2.42772922e-01f, 2.17324644e-01f, -3.29484016e-01f, -3.05343509e-01f, 4.81705129e-01f, 1.26473919e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  5.50474226e-01f, -7.27185249e-01f, -3.95879179e-01f, 4.72788185e-01f, 5.46602845e-01f, 5.11264026e-01f, 9.83980224e-02f, -4.83734429e-01f, 8.35842907e-01f, -3.58900070e-01f,
  3.03589165e-01f, 2.53223598e-01f, -3.41160297e-01f, 1.82747647e-01f, 4.59596723e-01f, 7.11121321e-01f, 1.82553381e-01f, -6.24531090e-01f, -1.87368751e-01f, -3.77778262e-01f,
  5.07223845e-01f, 9.55640897e-02f, 5.10307610e-01f, -2.59310633e-01f, -2.12363049e-01f, 5.82497001e-01f, 4.72293109e-01f, -4.69853282e-01f, -1.67635232e-01f, 4.54262644e-01f,
  7.63446629e-01f, -4.10180271e-01f, 2.94280738e-01f, 8.05042386e-01f, 7.83107877e-01f, -3.19626927e-01f, -2.50825554e-01f, 4.56994861e-01f, 4.86666746e-02f, 1.78704441e-01f,
  1.28654227e-01f, 7.66220093e-01f, 5.33949971e-01f, -1.30149648e-01f, 2.59275198e-01f, 7.83340096e-01f, -9.21899527e-02f, -1.59701467e-01f, 6.08766913e-01f, -9.78482723e-01f,
  -2.39680007e-01f, 3.00186813e-01f, 1.83539748e-01f, 1.21535651e-01f, -6.66931748e-01f, -6.73864186e-01f, 7.00277865e-01f, -1.51426256e-01f, 5.89930475e-01f, -1.49597794e-01f,
  2.38171622e-01f, 1.73255071e-01f, -3.19742262e-01f, 3.70402306e-01f, -1.44872526e-02f, 4.50651765e-01f, 7.60397196e-01f, 3.73898357e-01f, -5.50945615e-03f, -2.59162605e-01f,
  -4.91481066e-01f, 2.87669757e-03f, 6.96503520e-01f, -8.49554464e-02f, -4.04690862e-01f, 3.77455235e-01f, -3.44824731e-01f, -2.58081734e-01f, 6.38731480e-01f, -2.67854869e-01f,
  6.27747357e-01f, 5.04783504e-02f, 1.98744386e-01f, 6.37519717e-01f, 2.58096218e-01f, 2.52883404e-01f, -1.15094066e-01f, 7.15486109e-01f, -3.88225287e-01f, 8.00658464e-02f,
  -7.10715503e-02f, 2.75748760e-01f, 5.90009749e-01f, 5.16304113e-02f, -3.42316061e-01f, 6.55320644e-01f, 6.68533087e-01f, 6.02651238e-01f, 2.60776132e-01f, -1.04814559e-01f,
  -2.05838725e-01f, -3.65649551e-01f, 1.74741507e-01f, 3.80981714e-01f, 4.44796175e-01f, 5.78977585e-01f, 6.02743208e-01f, -1.10873222e-01f, 8.52385819e-01f, 1.57541126e-01f,
  5.90430975e-01f, -2.05776077e-02f, -6.66757822e-02f, 5.47657669e-01f, 7.40288138e-01f, 3.13916057e-01f, 4.47468497e-02f, 7.30503261e-01f, -1.29216425e-02f, 8.64463091e-01f,
  -2.33046830e-01f, 7.28411600e-02f, -3.05321105e-02f, 4.40611750e-01f, -5.03046095e-01f, 2.29861617e-01f, -3.14758927e-01f, 5.09909093e-01f, 2.66366005e-01f, -9.57743287e-01f,
  -2.15221018e-01f, 5.43339431e-01f, 5.56566894e-01f, 4.81600076e-01f, 3.16222906e-01f, -1.12942562e-01f, 5.94509602e-01f, -1.89129397e-01f, -1.74815115e-02f, 7.89515436e-01f,
  -1.45903945e-01f, 1.41356394e-01f, 5.39767861e-01f, -2.07311064e-02f, 6.10824585e-01f, -2.05362082e-01f, 9.01273191e-02f, 2.94495504e-02f, 6.26320481e-01f, 5.98095298e-01f,
  4.48346943e-01f, -4.15527411e-02f, 3.82608652e-01f, 2.02091783e-01f, 6.90736294e-01f, 1.91629410e-01f, 8.13058317e-02f, 5.23296714e-01f, -1.38379941e-02f, 5.10875642e-01f,
  1.42358541e-01f, 2.80138496e-02f, 1.36340231e-01f, -4.62276906e-01f, 2.36470699e-01f, 1.00672352e+00f, 5.17266870e-01f, -1.75254628e-01f, 6.55155778e-01f, 1.80623040e-01f,
  6.12085640e-01f, -1.84390888e-01f, -5.11823773e-01f, 3.06846410e-01f, 4.91398692e-01f, -1.09045349e-01f, 5.60229719e-01f, 1.68295234e-01f, 6.69560075e-01f, 1.95851400e-01f,
  -1.73096389e-01f, -3.60683352e-01f, -2.51092702e-01f, 1.65393967e-02f, 4.53926593e-01f, 4.82950926e-01f, 3.22385103e-01f, 5.30721009e-01f, 7.30309904e-01f, 4.85922158e-01f,
  5.03538251e-01f, 2.49100387e-01f, 4.04139638e-01f, -8.59726489e-01f, 5.85396230e-01f, 6.78198934e-01f, 5.82909405e-01f, 2.87879240e-02f, -1.85719252e-01f, 4.77889597e-01f,
  4.35759693e-01f, -4.81376082e-01f, -2.43496165e-01f, 4.34233963e-01f, -9.04858485e-02f, -5.18590450e-01f, 5.99732876e-01f, -4.69397753e-01f, 3.97379249e-01f, -6.78675413e-01f,
  -4.27521288e-01f, 6.20860279e-01f, 1.70330837e-01f, 5.51888347e-01f, 3.12864959e-01f, 4.29584384e-01f, -1.99360400e-01f, -2.16434017e-01f, -2.91682663e-03f, 2.71856666e-01f,
  5.11250138e-01f, -9.69478488e-02f, -4.56715643e-01f, 4.55602884e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  3.51357102e-01f, 5.47097802e-01f, 1.15644388e-01f, 7.61929572e-01f, 1.42904803e-01f, 3.52873206e-01f, 2.78170258e-01f, 2.63270289e-01f, 4.05292034e-01f, 6.26459837e-01f,
  4.69276547e-01f, 4.74480838e-01f, 5.87243736e-01f, 4.30778056e-01f
};

// L2_fan_Wp (Shape: 1 x 16)
const int L2_fan_Wp_rows = 1;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -2.13813528e-01f, 1.45140156e-01f, 5.71557283e-02f, 3.72331381e-01f, -1.47752553e-01f, 6.21532053e-02f, 1.30544193e-02f, -1.92541018e-01f, 1.70742258e-01f, -2.01234251e-01f,
  -1.51027367e-01f, 1.66883871e-01f, -3.78608592e-02f, -1.45881683e-01f, 2.23943725e-01f, -3.39963853e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 16)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  2.07770884e-01f, -5.90557694e-01f, -1.84845716e-01f, -5.00191033e-01f, -3.81348133e-01f, -8.91155622e-04f, 2.73667090e-02f, 7.59038925e-01f, 1.42353058e-01f, 2.18482241e-01f,
  2.63006061e-01f, 6.36707246e-02f, -9.67560112e-01f, 5.89937031e-01f, 6.30763948e-01f, 2.85684437e-01f, 2.32180990e-02f, 6.16424084e-01f, 2.29436129e-01f, 5.83942607e-02f,
  2.87919253e-01f, -7.97507942e-01f, 8.27061713e-01f, -1.79556489e-01f, 9.30513442e-01f, -5.45809865e-02f, 3.73884946e-01f, 1.04264142e-02f, 2.73559451e-01f, 7.51639009e-01f,
  6.38864040e-01f, -6.10377431e-01f, -1.26993313e-01f, -1.23092301e-01f, 4.60953504e-01f, 8.13137233e-01f, -2.41388336e-01f, 5.96050262e-01f, -1.75370723e-01f, -4.47450966e-01f,
  -3.60308983e-03f, -6.43223226e-01f, 5.27026415e-01f, 4.93052244e-01f, 6.77937031e-01f, 3.73703271e-01f, -1.41521767e-01f, -1.69224814e-02f, 1.73141077e-01f, -3.58054042e-01f,
  3.08263987e-01f, 6.31713450e-01f, -7.76050687e-02f, 6.87749445e-01f, -1.07615745e+00f, -1.60017252e-01f, 1.18235014e-01f, -2.87308246e-01f, 6.29462421e-01f, 4.15888667e-01f,
  3.16047281e-01f, -6.43460825e-02f, -3.72647911e-01f, 1.24417976e-01f, -4.69649315e-01f, -3.59168082e-01f, -3.67032588e-01f, 2.93369949e-01f, 1.88475221e-01f, -2.12716520e-01f,
  -7.49427021e-01f, 3.60379398e-01f, 8.54118049e-01f, -1.01493746e-01f, 9.17893648e-02f, 1.38981491e-01f, -3.15229148e-01f, 4.20468271e-01f, -2.36593947e-01f, 2.10941225e-01f,
  3.42994660e-01f, -6.29920244e-01f, 5.55567801e-01f, 2.15815067e-01f, -9.43212986e-01f, 4.01631624e-01f, -1.27490968e-01f, 4.76178080e-02f, -2.78110355e-01f, -4.45525385e-02f,
  5.02826214e-01f, -9.27364826e-03f, -7.75454193e-02f, 1.73486192e-02f, 9.48468626e-01f, 5.83818614e-01f, -1.25539824e-01f, 7.59127975e-01f, -8.16198826e-01f, -2.62868643e-01f,
  3.63704294e-01f, -3.89900982e-01f, 5.90244651e-01f, 4.13591594e-01f, 4.48628902e-01f, 8.65878463e-01f, -3.58193517e-01f, 2.05971539e-01f, 1.49876341e-01f, 5.26580691e-01f,
  2.25419655e-01f, 6.74821585e-02f, 2.18204632e-01f, -6.82065070e-01f, 2.27624297e-01f, -5.66399455e-01f, -1.13610558e-01f, 5.43125391e-01f, -8.39797854e-01f, 3.98423642e-01f,
  5.50987542e-01f, 1.44222632e-01f, -2.37500772e-01f, 3.33149076e-01f, -1.93557471e-01f, 4.79092568e-01f, -4.82197553e-01f, 2.50585824e-01f, -2.05265637e-02f, 8.89685214e-01f,
  -1.06985629e-01f, 4.41174656e-01f, 8.42793703e-01f, -8.97201359e-01f, 1.85665749e-02f, 3.19793046e-01f, -5.97078763e-02f, 8.08799982e-01f, -8.69590640e-02f, 4.49213445e-01f,
  5.27111232e-01f, 3.42235416e-02f, -1.36491686e-01f, 8.39055628e-02f, -1.30054578e-01f, -1.87295638e-02f, 6.35273218e-01f, -6.29688263e-01f, 1.17438532e-01f, 6.03040099e-01f,
  1.94933444e-01f, 1.83158293e-01f, 4.62965900e-03f, -3.49345133e-02f, 4.97532450e-02f, 3.19361985e-01f, -6.15063794e-02f, 4.52443898e-01f, -5.93040764e-01f, 1.55115560e-01f,
  3.99774551e-01f, 3.09268180e-02f, 8.86356056e-01f, -2.22208545e-01f, -3.54479373e-01f, 2.33597577e-01f, -2.48642787e-01f, 7.05667078e-01f, -7.57873714e-01f, 7.88033068e-01f,
  7.60617971e-01f, 6.33196235e-01f, 3.93561572e-01f, -2.25454539e-01f, 5.37291944e-01f, 8.23194385e-01f, 4.63872433e-01f, -5.25177181e-01f, 6.89983368e-02f, 6.79237247e-01f,
  7.39967942e-01f, 4.28101987e-01f, -6.37169123e-01f, -3.75816494e-01f, 7.11681843e-01f, -4.40517396e-01f, -3.82614940e-01f, 3.73200834e-01f, 7.25737333e-01f, -3.72518878e-03f,
  -2.07291767e-01f, -3.03856432e-01f, 1.39508456e-01f, -7.13016689e-01f, -3.87884937e-02f, 2.57190645e-01f, 1.92462876e-01f, 3.15274596e-01f, 2.82093108e-01f, 1.46212071e-01f,
  3.99096400e-01f, -6.25841022e-01f, -1.91797361e-01f, 3.94985914e-01f, -4.04986620e-01f, 7.98731089e-01f, -1.84758499e-01f, -4.49849200e-03f, 3.83376211e-01f, -3.95193696e-01f,
  -6.36388242e-01f, 2.43220344e-01f, 2.86242217e-01f, 1.64673939e-01f, -3.91172528e-01f, 4.87656623e-01f, 6.71933830e-01f, -3.36930454e-01f, -3.86312544e-01f, 6.63457885e-02f,
  -3.17813218e-01f, 3.29011500e-01f, 4.17828225e-02f, 6.56052172e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  4.96680796e-01f, -1.49631992e-01f, 2.36478642e-01f, 1.18538082e-01f, 3.01907301e-01f, 1.90351337e-01f, 2.90388912e-01f, 3.90033156e-01f, -1.74501911e-01f, -1.66169956e-01f,
  3.26833814e-01f, 4.09154505e-01f, 4.71065901e-02f, 1.30388573e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  -4.54981357e-01f, 5.09798825e-01f, -3.23181987e-01f, -8.10767829e-01f, -1.34556442e-01f, -3.93080804e-03f, -7.50382245e-01f, -5.70564717e-02f, -4.12169755e-01f, 4.39779937e-01f,
  2.37936392e-01f, 5.93989193e-01f, 5.04187346e-01f, -1.03745496e+00f, -7.14174867e-01f, -7.97755241e-01f, 1.02874950e-01f, -2.75080115e-01f, -4.74531114e-01f, -2.29635477e-01f,
  7.54039139e-02f, 1.24121442e-01f, 9.16324847e-04f, -9.25886393e-01f, 4.84889805e-01f, -5.74204922e-01f, 5.71523190e-01f, 1.74272418e-01f, 1.79259166e-01f, 5.92579730e-02f,
  -7.94583082e-01f, -6.98202431e-01f, 2.64145315e-01f, 3.66314262e-01f, -7.62945354e-01f, -3.94278613e-04f, -2.38985606e-02f, -3.87359828e-01f, -3.73901650e-02f, -1.20620906e-01f,
  5.21883309e-01f, -4.15557295e-01f, 4.06109452e-01f, -5.08455634e-01f, -8.37163746e-01f, 3.43170583e-01f, 2.68827826e-01f, 3.02588552e-01f, -3.60090673e-01f, -8.10174122e-02f,
  5.23810029e-01f, -6.76188096e-02f, -5.45699954e-01f, -8.79976094e-01f, -5.92143357e-01f, 4.76655722e-01f, -1.75625503e-01f, -7.21866906e-01f, -4.18280095e-01f, -8.97825211e-02f,
  5.58016658e-01f, -3.19847167e-01f, -7.03275323e-01f, -4.01759923e-01f, -1.20232902e-01f, -5.02834737e-01f, 4.15579438e-01f, -4.95897770e-01f, 8.34671557e-02f, 1.34584367e-01f,
  3.78423668e-02f, 5.17183721e-01f, -1.45375669e-01f, 3.18178385e-01f, -5.30443966e-01f, 1.70716599e-01f, 1.38974609e-02f, -7.27389872e-01f, 4.38623577e-01f, -1.04839273e-01f,
  6.74213171e-01f, -2.80847758e-01f, -4.81774122e-01f, -7.47126520e-01f, 3.27236742e-01f, 5.76218426e-01f, -7.19812870e-01f, 3.95797610e-01f, -8.42894614e-01f, -1.54008701e-01f,
  -2.97237813e-01f, -1.30570516e-01f, 2.32883826e-01f, 3.46243680e-01f, -3.41242582e-01f, -3.74237709e-02f, 3.67653787e-01f, 7.30659425e-01f, -5.00843585e-01f, -9.27654803e-02f,
  1.73042700e-01f, 3.10865551e-01f, 7.09791631e-02f, -8.88974786e-01f, -6.25436842e-01f, 1.93772897e-01f, -3.98288190e-01f, 4.45307195e-01f, -3.76157045e-01f, 4.96836156e-01f,
  3.42868924e-01f, -1.49809569e-01f, 7.25134835e-02f, 2.08563462e-01f, 2.79184848e-01f, -3.06653827e-01f, -9.00764465e-01f, -6.71086073e-01f, 5.50067544e-01f, 3.12660187e-02f,
  4.25756633e-01f, 1.63542628e-01f, -1.43917218e-01f, -6.56848073e-01f, 1.23876177e-01f, -6.38237596e-01f, -5.90871751e-01f, 6.15418017e-01f, -5.60662687e-01f, 1.91376820e-01f,
  -2.80044019e-01f, 1.43651098e-01f, 4.41925734e-01f, 4.55407053e-01f, 3.68619502e-01f, -3.08663607e-01f, -6.26192212e-01f, -9.68016624e-01f, 2.33410954e-01f, -6.15892410e-01f,
  -5.25812089e-01f, 1.29561886e-01f, 1.44869074e-01f, -2.65561551e-01f, 1.33054495e-01f, -5.14481366e-01f, 2.59976268e-01f, -3.24913204e-01f, -4.99435067e-01f, -2.00928390e-01f,
  4.43682879e-01f, -6.40480340e-01f, 1.82947531e-01f, 1.79957286e-01f, -5.47894359e-01f, 2.90574372e-01f, -5.66010416e-01f, 1.44670373e-02f, 4.83773232e-01f, 6.59398437e-01f,
  3.23865443e-01f, -1.51461437e-01f, -2.86513437e-02f, 6.35091841e-01f, -5.07626712e-01f, -7.33517110e-01f, -5.59506297e-01f, -3.51282299e-01f, 7.29481220e-01f, -7.74211764e-01f,
  4.74916637e-01f, -2.13695586e-01f, -7.10476488e-02f, -7.32992172e-01f, -1.42162189e-01f, -7.26491034e-01f, 1.40251085e-01f, 2.06710592e-01f, -5.02228975e-01f, 5.81612051e-01f,
  5.89106739e-01f, -4.08175468e-01f, -6.42574608e-01f, 2.55287737e-01f, -2.20957816e-01f, -6.34128273e-01f, -7.30603755e-01f, 5.05816519e-01f, -1.02321588e-01f, -3.07036310e-01f,
  -7.89020732e-02f, -4.99534309e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.89214692e-01f, 1.30668640e-01f, 9.30576995e-02f, -1.75484255e-01f, 1.28103003e-01f, 1.62426502e-01f, 2.33469903e-02f, -8.26930106e-02f, -4.19219658e-02f, 2.07705483e-01f,
  1.04456693e-01f, -2.77337521e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    