/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.41424251e-01f, -1.30862102e-01f, -1.47077322e-01f, -4.05537672e-02f, -1.63325951e-01f, -2.78079063e-01f, -2.76013941e-01f, -8.95579159e-02f, -3.18668634e-02f, -3.28469612e-02f,
  -3.89027335e-02f, 5.01500182e-02f, 1.23902626e-01f, 8.37531220e-03f, -6.21873625e-02f, 7.26551935e-03f, -2.03798953e-02f, -4.30057272e-02f, -7.83122331e-02f, -2.26748452e-01f,
  -8.19223598e-02f, -3.79384235e-02f, -1.06203467e-01f, 4.22723256e-02f, 1.22774810e-01f, 8.11270773e-02f, 1.80739343e-01f, 1.79604832e-02f, -1.17247172e-01f, 6.70069410e-03f,
  -4.09126990e-02f, -3.21995556e-01f, -1.31163910e-01f, -1.18385516e-01f, -1.98065117e-02f, -7.09851235e-02f, -1.04870051e-01f, 7.42093893e-03f, -1.11944132e-01f, -1.43413935e-02f,
  1.31139513e-02f, -1.28149852e-01f, -9.46700722e-02f, -3.62611823e-02f, -8.47667605e-02f, -7.77399763e-02f, 6.26610667e-02f, -1.09743878e-01f, -9.15783718e-02f, -2.62137894e-02f,
  -6.78643957e-02f, -8.90205428e-02f, -1.82190388e-01f, -7.91532546e-02f, -1.68685943e-01f, -9.76188630e-02f, -1.17917202e-01f, -1.92974150e-01f, -3.61402705e-02f, -1.24437205e-01f,
  7.53702782e-03f, 5.59195578e-02f, 6.76443279e-02f, -1.55395763e-02f, 7.56886080e-02f, 7.47690303e-03f, -1.70451473e-03f, 3.97184677e-02f, 7.32827187e-02f, -4.08161543e-02f,
  1.77261382e-02f, -1.33925676e-02f, 4.01913673e-02f, -3.64825800e-02f, 1.91309657e-02f, -9.76664647e-02f, 1.47329774e-02f, 1.11799553e-01f, 1.84602961e-02f, -4.43853810e-02f,
  5.70773333e-02f, 1.90981245e-03f, 1.02318130e-01f, 1.25973970e-02f, -4.12385762e-02f, 7.75680766e-02f, -2.84428969e-02f, 2.60236058e-02f, -3.39398421e-02f, -8.10201094e-02f,
  7.25826323e-02f, -3.55886556e-02f, -8.73697922e-02f, -5.25892824e-02f, -5.42411469e-02f, 5.05470298e-02f, -3.31274495e-02f, -2.58679185e-02f, -3.99445333e-02f, -7.37266764e-02f,
  -8.72150660e-02f, 7.15622096e-04f, -4.14440595e-02f, 1.34314364e-02f, -9.92146879e-03f, -5.41780703e-02f, 8.29034019e-03f, -3.49871553e-02f, 4.39445227e-02f, -5.24530821e-02f,
  9.30570513e-02f, -9.32387486e-02f, -4.54594791e-02f, 3.00666299e-02f, 4.39760229e-03f, -6.07570931e-02f, -2.40820572e-02f, 5.42513020e-02f, 6.95456611e-03f, -1.06160692e-03f,
  3.15685183e-01f, -2.16467336e-01f, -7.01302513e-02f, 1.21820390e-01f, -1.71123669e-01f, -2.79910564e-01f, -3.16728860e-01f, -1.27865836e-01f, -5.32044657e-02f, -3.86829525e-02f,
  -5.89405037e-02f, 7.60723799e-02f, 1.07689276e-01f, -1.37753552e-02f, -5.92080317e-03f, -3.79722089e-01f, -2.15126783e-01f, -2.73547638e-02f, 4.84569333e-02f, -9.25621018e-02f,
  -2.18807355e-01f, 3.15254740e-02f, 1.25772595e-01f, 2.58384291e-02f, -5.00256866e-02f, -3.74086723e-02f, -1.90157875e-01f, 5.85045069e-02f, -1.82984710e-01f, -1.29350081e-01f,
  -4.17631911e-03f, 6.05854057e-02f, -4.72139046e-02f, -3.05785686e-02f, 3.51719782e-02f, -8.05139244e-02f, -1.13527067e-02f, 5.06562851e-02f, 6.77728280e-03f, -1.00930177e-01f,
  2.80717034e-02f, -4.09863926e-02f, 3.87198143e-02f, -5.60042374e-02f, -1.69058330e-02f, -8.82809386e-02f, -1.84266418e-02f, 6.52920594e-03f, -9.36243832e-02f, -4.29096781e-02f,
  -6.52398318e-02f, -7.19168037e-02f, 2.39439160e-02f, -1.78515241e-01f, -8.96288753e-02f, -1.10627254e-02f, -2.30642799e-02f, -3.70919555e-02f, -3.68628874e-02f, -3.20013948e-02f,
  -6.02876022e-02f, 1.24309838e-01f, 1.95113886e-02f, 6.54823110e-02f, -2.21425830e-03f, 6.09447807e-02f, 5.70557937e-02f, 8.48541781e-02f, -1.81938168e-02f, 5.00895791e-02f,
  5.38920537e-02f, 3.73158716e-02f, 2.61746291e-02f, 7.86235854e-02f, 3.32071334e-02f, 6.58036694e-02f, -7.10869394e-03f, 2.47699004e-02f, 7.28098452e-02f, 9.65029597e-02f,
  1.23701617e-02f, 6.82849661e-02f, 8.44901875e-02f, 8.67151096e-02f, -2.37751915e-03f, 2.96751969e-02f, 8.03435892e-02f, 9.14595053e-02f, 8.07114542e-02f, 7.11112767e-02f,
  -2.23419257e-02f, 1.87613722e-02f, -8.87773484e-02f, -6.51629269e-02f, -7.90434256e-02f, -3.19317393e-02f, -8.38890970e-02f, 4.79875207e-02f, -7.25528076e-02f, -3.54559310e-02f,
  3.11496761e-02f, -8.51447042e-03f, 1.00257890e-02f, -5.07031418e-02f, -3.09460051e-02f, -1.20259933e-01f, -1.49358083e-02f, -5.02166040e-02f, -7.89773837e-02f, -8.98675993e-02f,
  -1.06255822e-01f, -1.58637613e-01f, -8.77543390e-02f, -1.34493858e-01f, -2.75851581e-02f, -3.98405567e-02f, -8.90210643e-02f, -4.26226407e-02f, -1.63333520e-01f, -2.67791569e-01f,
  -2.22191989e-01f, 2.27520689e-01f, 7.05071315e-02f, 1.52096048e-01f, -4.90811840e-03f, -1.68807223e-01f, -1.85942441e-01f, -8.42803717e-02f, 7.22502545e-02f, 1.62249997e-01f,
  1.13809623e-01f, 1.71478763e-02f, 9.90859419e-03f, -5.39469421e-02f, -1.28531247e-01f, 1.43343970e-01f, 1.20133460e-01f, -4.09456193e-02f, -2.23571435e-01f, -1.44556329e-01f,
  1.35105491e-01f, 2.48662401e-02f, 3.05724684e-02f, 3.15172523e-02f, 2.08670288e-01f, 5.47182187e-02f, 1.91830873e-01f, 1.35755673e-01f, 9.79940370e-02f, 3.46853793e-01f,
  8.68964419e-02f, -1.25688523e-01f, -2.80874921e-03f, -1.95211396e-02f, 6.23416342e-02f, 3.54410186e-02f, -1.93191152e-02f, -1.28638754e-02f, 4.76799719e-02f, 6.12618290e-02f,
  1.21399015e-02f, -5.08902334e-02f, 3.65038030e-02f, 2.14136615e-02f, 1.31840613e-02f, 7.10536018e-02f, 2.93070301e-02f, 5.98220192e-02f, -6.85037347e-04f, -1.83117706e-02f,
  4.09561321e-02f, 6.31137416e-02f, -3.00206207e-02f, -5.97922318e-02f, 3.28318104e-02f, 3.67735773e-02f, -1.36695395e-03f, -6.35138676e-02f, -6.07807226e-02f, 1.67867571e-01f,
  -1.36764288e-01f, -1.20602921e-01f, -3.76463644e-02f, -7.66006187e-02f, -5.41955754e-02f, 1.27406307e-02f, 5.75963631e-02f, -3.01075587e-03f, -7.35670701e-02f, 3.51465419e-02f,
  -6.35322509e-03f, -2.83466987e-02f, -5.99903576e-02f, -3.07920612e-02f, -2.75390632e-02f, -9.35790986e-02f, -7.30646309e-03f, 2.35752854e-02f, 1.79004278e-02f, -4.59146267e-03f,
  -3.60513628e-02f, -3.20666959e-03f, 2.88632512e-03f, 1.73926186e-02f, -5.28744236e-03f, -3.74474488e-02f, -5.78018129e-02f, -3.11467890e-02f, 3.17558297e-03f, -9.56659764e-03f,
  7.65379518e-02f, -1.38045833e-01f, 4.24879566e-02f, 2.13189404e-02f, 2.21033115e-02f, 5.86924627e-02f, 9.87727121e-02f, 6.02247156e-02f, 4.30466840e-03f, -1.17603038e-02f,
  1.73821114e-02f, -9.47755016e-03f, 7.23622665e-02f, -2.90839351e-03f, 7.33457655e-02f, 3.98106799e-02f, 1.42938728e-02f, 9.48630832e-03f, 5.11785299e-02f, 6.53440654e-02f,
  6.92085773e-02f, 2.61560432e-03f, -8.78334194e-02f, -4.88973483e-02f, -6.03516959e-02f, -6.90078884e-02f, -3.09385546e-02f, 1.56723578e-02f, -7.75868446e-02f, 2.49825269e-02f,
  -4.82530057e-01f, -2.09092051e-02f, 6.01402251e-03f, -3.53360027e-01f, -1.84519172e-01f, -1.24863677e-01f, 3.55815850e-02f, -1.83730684e-02f, -1.43231019e-01f, -5.46815582e-02f,
  -3.43103483e-02f, -1.14707917e-01f, 1.48624424e-02f, -3.32247019e-02f, -7.85981119e-02f, -8.24529603e-02f, -5.57586625e-02f, -1.08805202e-01f, -1.90737098e-01f, -1.60162479e-01f,
  -1.05111979e-01f, -1.48159638e-01f, -2.12277755e-01f, -4.14946377e-02f, -8.92487541e-02f, -2.00345013e-02f, -2.49590576e-02f, -1.01285614e-01f, -5.96118011e-02f, -8.25796947e-02f,
  -4.68544550e-02f, -1.12006702e-01f, -5.09741865e-02f, -9.99336466e-02f, 4.05745655e-02f, -6.96918145e-02f, -9.93656665e-02f, -1.00504868e-01f, -1.63708866e-01f, -6.41039237e-02f,
  -1.26753047e-01f, -1.04628079e-01f, -6.39570653e-02f, 4.34219614e-02f, -2.80639809e-02f, -6.27684891e-02f, -1.59192905e-02f, 3.04314587e-02f, -4.21444476e-02f, -5.96989021e-02f,
  -5.30373715e-02f, -1.01680160e-01f, -1.46690950e-01f, 6.95265383e-02f, 1.11458329e-02f, -1.40686482e-01f, 3.91801707e-02f, -6.04308359e-02f, -4.44606654e-02f, -1.01040229e-01f,
  2.68586501e-02f, 1.18929110e-01f, 1.08503841e-01f, 1.27793610e-01f, 1.55204505e-01f, 9.13163200e-02f, 1.41171694e-01f, 7.21219927e-02f, 4.05663950e-03f, 1.78629383e-01f,
  1.90435991e-01f, 6.67560548e-02f, 4.86408398e-02f, -1.70948207e-02f, 2.91956458e-02f, 4.18644659e-02f, 1.03747748e-01f, 9.85558480e-02f, 8.57449993e-02f, 4.14187908e-02f,
  1.62177637e-01f, 6.41139001e-02f, 4.92549948e-02f, 1.37151629e-01f, 1.46183342e-01f, 4.60319370e-02f, 1.04554564e-01f, 7.19930828e-02f, 1.63199276e-01f, 6.25577569e-02f,
  -1.28173828e-01f, -3.70110804e-03f, -2.02923402e-01f, -1.01422958e-01f, -2.04675123e-01f, -1.13751329e-01f, -1.25981212e-01f, -1.16246015e-01f, -8.09359774e-02f, -2.27951512e-01f,
  -1.17555521e-01f, -1.25670165e-01f, -1.21340021e-01f, -6.39994740e-02f, -1.74965546e-01f, -1.19464107e-01f, -1.10740334e-01f, -2.00918064e-01f, -3.28304619e-02f, -9.06991586e-02f,
  -5.76639846e-02f, -9.10858363e-02f, -2.23151863e-01f, -1.63410872e-01f, -1.54870659e-01f, -1.40127048e-01f, -1.39244199e-01f, -1.07016020e-01f, -1.37293145e-01f, -1.67045876e-01f,
  2.64802039e-01f, 1.04133360e-01f, -3.60379033e-02f, 2.95989335e-01f, 1.99645326e-01f, 5.58776595e-02f, 9.35182497e-02f, 1.15124032e-01f, 2.73386478e-01f, 9.60909948e-02f,
  7.58056194e-02f, -5.78865362e-03f, -3.70208062e-02f, -4.45711315e-02f, -5.39833307e-02f, 7.94282705e-02f, 1.98609054e-01f, 1.18781738e-01f, 1.27413571e-01f, 2.85855830e-01f,
  3.06295633e-01f, 2.35291600e-01f, 3.68716121e-01f, 3.00419509e-01f, 3.57825607e-01f, 2.85986722e-01f, 1.45443603e-01f, 1.74029112e-01f, 1.75695941e-01f, 2.84895897e-01f,
  -4.24471088e-02f, 2.83289831e-02f, 7.18760118e-02f, 1.16979629e-01f, 1.77727997e-01f, 1.61780968e-01f, 2.21315518e-01f, 1.84351400e-01f, 1.27670452e-01f, 1.52786911e-01f,
  1.20533288e-01f, 7.64980242e-02f, 1.47188812e-01f, 1.22955963e-01f, 5.48722371e-02f, 9.69974697e-02f, 9.23750401e-02f, 1.92594733e-02f, 1.18031703e-01f, 1.54568166e-01f,
  4.33379151e-02f, 3.36645283e-02f, 7.93796554e-02f, 5.66393435e-02f, 1.39378319e-02f, 1.25026092e-01f, 1.06312245e-01f, 1.23985380e-01f, 1.24540523e-01f, 2.25572526e-01f,
  -8.37178156e-02f, -4.87237563e-03f, 2.70967446e-02f, 5.60581759e-02f, 3.18207359e-03f, -4.50456813e-02f, 2.98730824e-02f, -6.18685549e-03f, 3.09310704e-02f, 1.37021601e-01f,
  -6.20505139e-02f, -1.02653550e-02f, -3.05656856e-03f, 1.08823022e-02f, -1.01153844e-03f, -7.72840530e-02f, 3.20638716e-03f, 4.88863466e-03f, -8.14927816e-02f, -6.98452368e-02f,
  1.08648548e-02f, 7.10728858e-03f, 5.47163114e-02f, -6.65548518e-02f, -1.19261011e-01f, -3.84788029e-02f, 3.47033590e-02f, -8.02916214e-02f, 2.94633433e-02f, 9.06515568e-02f,
  1.64314777e-01f, -7.94426054e-02f, 1.79040328e-01f, 1.37660608e-01f, 1.04311056e-01f, 1.08183652e-01f, 1.14621319e-01f, 1.18630797e-01f, 1.57762155e-01f, 1.05015270e-01f,
  1.48260459e-01f, 8.68985429e-02f, 5.93915842e-02f, 1.95526123e-01f, 2.51640320e-01f, 1.50701836e-01f, 1.00078061e-01f, 1.56078279e-01f, 4.90397066e-02f, 1.49879351e-01f,
  2.18279958e-01f, 1.01429746e-01f, 4.87650856e-02f, 1.02752097e-01f, 2.33779386e-01f, 1.53540447e-01f, 1.64161786e-01f, 2.11666346e-01f, 9.18403417e-02f, 2.30294704e-01f,
  3.63092609e-02f, -1.66612059e-01f, 4.46627624e-02f, -1.34719238e-01f, 2.04399414e-02f, -1.20796688e-01f, -2.30346128e-01f, -1.62669539e-01f, -5.82443513e-02f, -1.28712520e-01f,
  1.83665782e-01f, 1.66855797e-01f, 1.73086096e-02f, 2.77476236e-02f, -8.19463804e-02f, -1.99953854e-01f, -2.95568645e-01f, -1.26291648e-01f, 4.99334708e-02f, -8.93425494e-02f,
  -1.93056434e-01f, -1.16040915e-01f, -9.96608287e-02f, -6.13464555e-03f, -9.89857689e-02f, 3.75609696e-02f, 4.59574349e-02f, 4.24663834e-02f, 5.71215786e-02f, -1.27817959e-01f,
  9.00976881e-02f, 6.22224435e-02f, 5.05561903e-02f, -2.45257863e-03f, 3.75605896e-02f, 7.61723286e-03f, -7.90738016e-02f, -2.54110284e-02f, -2.53432896e-02f, -8.30723122e-02f,
  -2.68830601e-02f, 2.02889517e-02f, 4.80864272e-02f, 8.30960181e-03f, 5.26610278e-02f, 1.73312780e-02f, 8.82444251e-03f, -3.11963279e-02f, 2.85123195e-02f, 3.06462608e-02f,
  -2.18178686e-02f, 5.32868654e-02f, -2.22506234e-03f, -2.75537111e-02f, -4.24904898e-02f, 9.35070291e-02f, -5.73185906e-02f, 6.20838664e-02f, 4.12763655e-02f, -8.23517423e-03f,
  -7.91201666e-02f, 9.77943987e-02f, 8.33140537e-02f, 8.18893984e-02f, -2.15052869e-02f, 8.35777521e-02f, 5.46342656e-02f, 2.77854240e-04f, 2.06943089e-03f, 1.00117892e-01f,
  2.44047754e-02f, 6.74803928e-02f, 6.33629188e-02f, 9.53552648e-02f, 5.56453615e-02f, 2.91884579e-02f, 2.40398217e-02f, -4.80901338e-02f, 8.07606205e-02f, 4.52071764e-02f,
  1.01003051e-01f, 3.77547555e-02f, 9.04371664e-02f, 4.24747989e-02f, 5.26880212e-02f, 1.05531774e-01f, 5.60279936e-02f, 1.24408796e-01f, 4.38568890e-02f, 6.28012270e-02f,
  -4.28139791e-02f, 1.15450300e-01f, -4.00482444e-03f, -1.16492417e-02f, -9.80869234e-02f, 1.16744787e-02f, 6.20140657e-02f, -1.66667905e-02f, 7.77636617e-02f, -5.81570081e-02f,
  2.12962255e-02f, -8.21882784e-02f, -2.92995051e-02f, -4.87563238e-02f, -7.17105344e-02f, 2.43392377e-03f, -1.77791789e-01f, -5.52699417e-02f, -5.09408936e-02f, -4.38769460e-02f,
  -1.03860952e-01f, -1.98751092e-01f, -1.51417077e-01f, -9.88665000e-02f, -4.40227166e-02f, -1.37420908e-01f, -4.05327752e-02f, -9.35074314e-02f, -8.21139738e-02f, -2.92157382e-01f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -7.79190287e-02f, 1.16070472e-01f, 3.72342132e-02f, 3.86252031e-02f, -4.83217165e-02f, 8.95492956e-02f, 1.65551454e-01f, 1.77555531e-01f, -1.33102825e-02f, 1.39647976e-01f,
  1.93833008e-01f, 2.25150883e-01f, 2.19667450e-01f, 1.19452290e-01f, 9.89666730e-02f, -2.50926781e-02f, -7.45913312e-02f, -2.41517238e-02f, 2.79920865e-02f, 9.49489623e-02f,
  4.43802252e-02f, -8.32011178e-02f, -3.71281840e-02f, 2.13559996e-03f, -1.87400021e-02f, 3.75584438e-02f, -7.19172582e-02f, -8.61958116e-02f, 3.56500559e-02f, -7.47051090e-02f,
  3.16085905e-01f, -9.46210418e-03f, 6.87160045e-02f, -6.21140152e-02f, -1.02271497e-01f, 4.19219472e-02f, 9.43505540e-02f, 6.02074638e-02f, 4.26417068e-02f, 1.43163234e-01f,
  -9.08375829e-02f, -7.63540789e-02f, -1.78150758e-02f, 6.90725148e-02f, 6.74719065e-02f, 9.33996364e-02f, 6.45225719e-02f, 8.48688483e-02f, 1.07142456e-01f, 3.50443348e-02f,
  1.30925611e-01f, 9.55059156e-02f, 8.36821496e-02f, 1.43610224e-01f, 3.67711298e-02f, 6.84563071e-03f, 3.11369635e-02f, -2.96204388e-02f, 1.18678927e-01f, 4.24709544e-02f,
  6.92401528e-02f, 7.81542435e-02f, 3.56871076e-02f, 3.63830552e-02f, -2.85388809e-02f, 4.36729342e-02f, 1.85716763e-01f, 4.73571010e-02f, 6.24724813e-02f, -4.57302891e-02f,
  1.12238899e-01f, 1.07152835e-01f, 9.53918472e-02f, -5.17298607e-03f, 4.94183190e-02f, -2.55641155e-02f, 1.25879139e-01f, 9.72969085e-02f, -7.46352300e-02f, -8.60622600e-02f,
  -6.13057353e-02f, 5.31907901e-02f, -1.12727962e-01f, -6.51470646e-02f, -1.03054000e-02f, 5.29793240e-02f, 9.74553265e-03f, -1.15627430e-01f, -6.58037961e-02f, 3.91333401e-02f,
  4.34401035e-01f, -1.47468135e-01f, -8.29321519e-02f, -1.22272614e-02f, -1.28366187e-01f, 1.28696999e-03f, -4.19258513e-02f, -7.41691887e-02f, 1.23030350e-01f, 1.82065353e-01f,
  -8.65912158e-03f, -1.49156004e-02f, -5.24543822e-02f, -1.14649825e-01f, 1.99128892e-02f, 3.13602462e-02f, 8.44059736e-02f, 2.39798695e-01f, 1.57903638e-02f, -2.61490941e-02f,
  5.29179536e-02f, 1.00295871e-01f, 2.63522029e-01f, 1.02960885e-01f, -1.68533181e-03f, 1.24161907e-01f, 3.93003859e-02f, 8.28217417e-02f, -1.59770921e-02f, 1.30896881e-01f,
  -2.42641289e-03f, 1.17730170e-01f, -5.59553921e-01f, -6.14093691e-02f, -2.89979011e-01f, -6.80624023e-02f, 2.10218623e-01f, 3.39556396e-01f, 1.79615304e-01f, 1.88859567e-01f,
  -1.82330655e-03f, -6.46383613e-02f, -1.95076782e-02f, -1.79725379e-01f, -2.98833400e-02f, 1.34381782e-02f, -1.07244901e-01f, -3.69938880e-01f, -3.25517207e-01f, 1.50081411e-01f,
  2.54992068e-01f, 1.81961715e-01f, 1.44414708e-01f, 9.88896415e-02f, 4.24829461e-02f, 6.51041046e-02f, -1.04552768e-02f, -1.04381502e-01f, -1.25039890e-01f, -2.52082229e-01f,
  -3.10392380e-01f, -1.79038629e-01f, -2.16484994e-01f, 2.49906462e-02f, -1.74356997e-01f, -6.08171672e-02f, 4.77169566e-02f, -8.00628513e-02f, -2.65992410e-03f, 3.96355204e-02f,
  -7.75031075e-02f, -1.31116770e-02f, -6.92760348e-02f, 6.28634989e-02f, 9.12112892e-02f, 1.40105322e-01f, -3.01654581e-02f, -1.91681474e-01f, -1.84353024e-01f, -7.71550015e-02f,
  5.50653748e-02f, -3.63267332e-01f, -4.26269382e-01f, -1.24388874e-01f, -2.37614334e-01f, -2.98716843e-01f, -1.27590626e-01f, -1.91795036e-01f, -3.14174563e-01f, 1.67406023e-01f,
  -2.12951680e-03f, -5.37448898e-02f, -1.41520342e-02f, 1.22564755e-01f, 1.20829821e-01f, -8.82781018e-03f, -2.95786131e-02f, -2.92382967e-02f, 1.40049517e-01f, -3.25074084e-02f,
  -6.18741475e-02f, -7.51062762e-03f, -4.83635664e-02f, 5.41995466e-02f, -5.33731561e-03f, -1.18964106e-01f, -6.73846900e-02f, 9.26239640e-02f, 1.58223454e-02f, -6.41857982e-02f,
  -8.58182833e-02f, -9.13302153e-02f, 5.31309098e-02f, 3.32746208e-02f, -2.20255554e-02f, -7.26571530e-02f, 4.61975439e-03f, 6.03553317e-02f, 6.55207112e-02f, 7.38655031e-02f,
  5.02866507e-01f, -1.93853006e-01f, -2.61170398e-02f, 8.62575881e-03f, -1.36733666e-01f, -9.94044766e-02f, 4.74760570e-02f, -2.84694731e-02f, -1.29983753e-01f, -2.77821068e-02f,
  -3.72980498e-02f, 9.49534774e-02f, 7.16771707e-02f, 8.59499499e-02f, -1.75941866e-02f, 2.32821088e-02f, 2.15483740e-01f, -1.14790916e-01f, 4.37587593e-03f, 1.08747624e-01f,
  1.53522775e-01f, 6.64905831e-02f, 1.07651934e-01f, 5.25617823e-02f, 1.37555497e-02f, -1.18301876e-01f, 1.09287083e-01f, 2.29356945e-01f, -5.79934567e-02f, 4.26736236e-01f,
  -7.52939582e-01f, -1.70245618e-02f, 2.17903927e-01f, -6.42344654e-01f, -4.16503429e-01f, -2.28569135e-01f, -2.10823655e-01f, -5.66768587e-01f, -5.23828566e-01f, -1.40107319e-01f,
  1.49385557e-01f, 1.71583503e-01f, 9.92415622e-02f, 1.09143883e-01f, 9.15827006e-02f, 2.55835857e-02f, -2.63264239e-01f, -1.60530061e-01f, -6.43512458e-02f, -7.35697448e-02f,
  -2.04364479e-01f, -3.93976420e-01f, -4.11679238e-01f, -1.20472096e-01f, -2.51206070e-01f, -1.82258874e-01f, -1.59835979e-01f, -2.65661746e-01f, -9.73820835e-02f, -1.86827883e-01f,
  3.75767112e-01f, -3.17327619e-01f, 4.14954685e-02f, -1.17069706e-01f, -1.08440831e-01f, 2.94562727e-02f, -6.49494082e-02f, -6.16719835e-02f, 8.26030876e-03f, -1.08607545e-01f,
  -4.38973606e-02f, 2.33287159e-02f, -6.38603345e-02f, 4.47420180e-02f, -1.20444879e-01f, -1.02775104e-01f, 1.63540132e-02f, -1.71259701e-01f, 3.59473517e-03f, 2.34150991e-01f,
  1.19697832e-01f, -4.40034531e-02f, 8.98807123e-02f, 1.97285023e-02f, -3.69664989e-02f, 2.35231295e-02f, 1.09161101e-01f, 4.85321507e-04f, -1.07522391e-01f, -1.06738307e-01f,
  -1.97743252e-02f, 6.08609580e-02f, 7.21627548e-02f, 5.03973812e-02f, 2.09321175e-02f, -6.10655546e-02f, -3.69851142e-02f, 6.52639046e-02f, -8.05655960e-03f, 3.06607690e-03f,
  -1.51957227e-02f, -6.59494177e-02f, 5.03536910e-02f, -6.46431521e-02f, 1.88098196e-02f, 2.46264059e-02f, 5.49914092e-02f, -5.96322166e-03f, -3.46917957e-02f, -1.30406633e-01f,
  -9.47649553e-02f, 3.56847160e-02f, -9.84553248e-02f, -3.51011846e-03f, -1.47752697e-02f, -4.00028192e-02f, 1.03761040e-01f, 2.91162040e-02f, 8.46564174e-02f, 6.68493882e-02f,
  1.59415767e-01f, -2.52641328e-02f, -3.08006126e-02f, 3.40721458e-02f, 4.20555472e-02f, 4.80388701e-02f, 3.82081941e-02f, -1.25300765e-01f, -9.85088348e-02f, -2.28560641e-02f,
  -6.34466857e-02f, -4.48481962e-02f, 5.27335592e-02f, 1.37145191e-01f, 2.59160977e-02f, -1.81218283e-03f, 1.01973578e-01f, -3.71645926e-03f, 8.00789148e-02f, 1.27203524e-01f,
  7.61564076e-02f, -5.33834696e-02f, 4.60245945e-02f, 8.53259023e-03f, -6.97968304e-02f, 6.90954849e-02f, 1.48520812e-01f, 1.53751716e-01f, 1.29631147e-01f, -8.33750069e-02f,
  -4.09081995e-01f, -1.61310703e-01f, 1.83033407e-01f, 1.73572823e-03f, 6.91618696e-02f, -1.72873631e-01f, -2.85048336e-01f, -2.39564836e-01f, -9.65208262e-02f, -1.05409309e-01f,
  -2.03982830e-01f, -9.48500186e-02f, 9.38156843e-02f, 1.11725368e-01f, 4.92243171e-02f, 8.59485194e-02f, 2.87185639e-01f, 3.66066664e-01f, 4.58205529e-02f, -2.89681321e-03f,
  9.19764414e-02f, 6.14142418e-03f, 8.86039063e-02f, 1.74868271e-01f, 2.96855345e-03f, 1.09177366e-01f, 6.58671632e-02f, 5.37626147e-02f, 1.69539854e-01f, 3.66368026e-01f,
  -1.48944095e-01f, -2.23771408e-01f, -7.29535595e-02f, 1.48394018e-01f, 2.57073641e-01f, 5.70218489e-02f, 1.60273448e-01f, 1.97566986e-01f, 1.30869493e-01f, 5.31950481e-02f,
  1.40465379e-01f, -2.97762305e-02f, -3.99443172e-02f, -1.36150895e-02f, 1.58582088e-02f, -2.51979530e-01f, 6.27315864e-02f, 8.24655220e-03f, -4.37024981e-02f, -9.08525959e-02f,
  2.28682265e-01f, -3.48294340e-02f, -2.97663480e-01f, -2.35420302e-01f, -6.19245842e-02f, -5.49691953e-02f, -2.64299780e-01f, -1.75864249e-01f, -2.77628869e-01f, -2.37530768e-01f,
  -1.57483444e-01f, 1.27025127e-01f, 8.28898996e-02f, 6.16030581e-02f, 3.13070193e-02f, -4.58359113e-03f, 1.96283460e-01f, 1.32466003e-01f, 4.24428135e-02f, 7.87574947e-02f,
  -7.18412967e-03f, -9.09689665e-02f, 5.53681850e-02f, -1.25089988e-01f, -6.74958006e-02f, -2.95165484e-03f, -6.96759531e-03f, -3.28690279e-03f, -4.96889278e-02f, 2.21797694e-02f,
  -1.12355202e-01f, -5.57204448e-02f, 1.65952623e-01f, 8.78021941e-02f, -7.06380010e-02f, 4.86339740e-02f, 4.91202530e-03f, 1.77903026e-02f, -1.27149478e-01f, -1.65334672e-01f,
  -2.28473336e-01f, 1.95373803e-01f, -8.56371969e-03f, 1.63456708e-01f, 6.69234572e-03f, 7.65204383e-03f, -5.11382632e-02f, -3.45505483e-04f, -1.90879762e-01f, -1.50461778e-01f,
  -2.57248938e-01f, -1.60562590e-01f, -1.01249032e-01f, 5.01234941e-02f, 9.41130891e-03f, -1.79523095e-01f, 1.47120535e-01f, 1.41124269e-02f, 1.20394407e-02f, 5.23277968e-02f,
  1.57011732e-01f, -2.44721532e-01f, -3.98259431e-01f, -2.13871151e-01f, -1.71267599e-01f, -2.66534001e-01f, -1.30844325e-01f, -1.36702091e-01f, -2.96726972e-01f, -3.16379428e-01f,
  -2.17887968e-01f, 5.43543220e-01f, 2.89565355e-01f, -2.76064843e-01f, 1.50280446e-01f, 2.96251446e-01f, 3.89861256e-01f, 6.12756796e-02f, -2.38967985e-01f, 2.06771836e-01f,
  2.64486343e-01f, -2.47403920e-01f, -1.21671982e-01f, -5.60755990e-02f, 8.69269744e-02f, 2.29741082e-01f, 7.72881508e-02f, -1.37038127e-01f, -1.97865993e-01f, -2.21523851e-01f,
  -2.14439034e-01f, -1.79652780e-01f, -1.20352916e-01f, 1.58191100e-02f, -9.20203477e-02f, -1.81343749e-01f, 1.12076148e-01f, 3.07020340e-02f, 2.75395900e-01f, -1.03073686e-01f,
  -9.43648070e-02f, 2.16617703e-01f, -2.73371845e-01f, -8.80937204e-02f, 8.15830976e-02f, -1.45073101e-01f, 1.91945545e-02f, -6.41996562e-02f, 7.48401880e-02f, 1.33970097e-01f,
  -4.25042287e-02f, 5.40173873e-02f, -4.95073125e-02f, -1.28085896e-01f, -8.56802762e-02f, -6.57753348e-02f, -4.51942757e-02f, -1.25728682e-01f, -1.16083413e-01f, -8.37854147e-02f,
  -1.88649014e-01f, -9.65393335e-02f, 1.11658812e-01f, 3.20832320e-02f, 9.18752402e-02f, -1.05825134e-01f, 2.34630004e-01f, -9.41992104e-02f, 1.52918309e-01f, -1.93279162e-01f,
  1.42791588e-02f, 4.72224616e-02f, 9.10478458e-02f, 7.46289454e-03f, -5.82465194e-02f, -5.98708354e-02f, 2.56824605e-02f, -4.06744182e-02f, 1.21757835e-02f, -4.40137200e-02f,
  -4.38655242e-02f, 6.78766668e-02f, -4.15445939e-02f, 1.95636582e-02f, -3.05832513e-02f, 2.31214496e-03f, -2.55485363e-02f, -3.32643166e-02f, 3.00375149e-02f, 1.13445058e-01f,
  -1.06352819e-02f, 4.21213964e-03f, 9.24422666e-02f, -9.35705528e-02f, 7.46916309e-02f, 5.63197024e-02f, -8.25780034e-02f, 1.26658399e-02f, 7.49604590e-03f, 1.26326531e-01f,
  -2.42375791e-01f, 2.49032810e-01f, -2.16516688e-01f, 1.08986542e-01f, 6.08385839e-02f, 2.70011157e-01f, 6.45010769e-02f, -5.96800297e-02f, 7.64355659e-02f, 9.37003084e-03f,
  6.10162690e-02f, 1.39497668e-01f, 2.36908365e-02f, 1.54651767e-02f, -3.09947506e-02f, 3.27671431e-02f, -2.23576464e-03f, -1.15082167e-01f, -8.44695047e-02f, -1.93549678e-01f,
  -1.56322122e-01f, -2.05312654e-01f, -4.31557447e-01f, -6.36346787e-02f, -7.31756687e-02f, -1.95777342e-01f, -1.88109577e-02f, -1.09977797e-01f, 2.93821804e-02f, -8.70750174e-02f,
  -3.85481775e-01f, 9.26344916e-02f, 5.80889769e-02f, -1.65850148e-02f, 2.59621829e-01f, 2.98820853e-01f, 2.04489723e-01f, 7.30686560e-02f, -1.66152433e-01f, 8.85161757e-02f,
  8.64220634e-02f, -6.17146082e-02f, 2.48473473e-02f, 1.22755796e-01f, 1.17273919e-01f, 2.27190897e-01f, 2.59335749e-02f, 1.98325682e-02f, -5.25789820e-02f, 8.60118940e-02f,
  1.44487038e-01f, -1.23518795e-01f, -3.07322562e-01f, -7.30838329e-02f, 1.57492869e-02f, -1.22406214e-01f, -1.36945292e-01f, -3.48417424e-02f, 1.77548677e-01f, 2.52016801e-02f,
  -2.06065789e-01f, -1.86649680e-01f, 2.77031586e-02f, 1.43292854e-02f, 7.08413050e-02f, -1.26531601e-01f, 2.02394649e-02f, -1.81465983e-01f, 3.29528786e-02f, -2.09869012e-01f,
  -1.31702706e-01f, -1.16129123e-01f, 7.95252174e-02f, -6.80734739e-02f, -2.28120267e-01f, 1.46477828e-02f, -1.16084730e-02f, -5.74259758e-02f, -2.61735857e-01f, -3.43640670e-02f,
  2.72192210e-01f, 8.19992870e-02f, -1.24881342e-01f, 7.83662945e-02f, -1.33962426e-02f, -1.82267293e-01f, -1.33146524e-01f, 7.47087896e-02f, -2.30640262e-01f, -3.17729801e-01f,
  3.89528163e-02f, 8.58897530e-03f, 4.37465087e-02f, -3.89708653e-02f, 4.23669927e-02f, 5.33287264e-02f, 2.05576897e-01f, 1.17991485e-01f, -9.76847336e-02f, -5.71107380e-02f,
  1.20486587e-01f, 3.53615247e-02f, -1.01003036e-01f, -8.66528414e-03f, 7.27439299e-02f, -6.58945143e-02f, 1.38186842e-01f, -7.57024139e-02f, 2.18425859e-02f, -2.66641565e-02f,
  3.42752375e-02f, 6.69039711e-02f, -8.68493095e-02f, 2.23452020e-02f, 9.11310464e-02f, 7.04945475e-02f, -1.40596762e-01f, 4.47688550e-02f, -1.61174089e-01f, -2.76300818e-01f,
  -3.61524552e-01f, 1.79459840e-01f, -1.03206664e-01f, 8.66078120e-03f, -2.03222316e-02f, -9.66054127e-02f, 7.48947635e-02f, -6.99822232e-02f, -9.22747478e-02f, 5.10489605e-02f,
  1.57684505e-01f, -4.65540551e-02f, -2.55132824e-01f, 1.18038930e-01f, -1.76203232e-02f, -2.75610611e-02f, 1.35571957e-01f, 8.54094103e-02f, -2.16361254e-01f, -8.40243921e-02f,
  1.46885037e-01f, 5.06132562e-03f, -1.64587572e-01f, 2.70724948e-02f, -1.82726204e-01f, -1.45745918e-01f, -2.05334038e-01f, -1.79124787e-01f, -2.22520590e-01f, -1.60728082e-01f,
  2.85830498e-01f, -7.33964220e-02f, -4.13811862e-01f, -1.23653449e-01f, -2.81555623e-01f, -2.22712949e-01f, 3.51853110e-03f, 5.92312077e-03f, -5.35047837e-02f, 3.79126742e-02f,
  3.38043757e-02f, 2.32300550e-01f, 1.74733564e-01f, 3.12930077e-01f, 3.56781721e-01f, -8.72830302e-02f, -2.83411950e-01f, 4.57487181e-02f, 2.26067573e-01f, 3.71500216e-02f,
  1.00017495e-01f, -6.96067065e-02f, -7.98025448e-03f, -4.13522758e-02f, -3.14933091e-01f, 2.07995847e-02f, -2.70392716e-01f, -2.70134479e-01f, -2.10036889e-01f, -4.13823187e-01f,
  2.45210439e-01f, -3.80830437e-01f, -5.73164076e-02f, -4.52952087e-02f, -1.38187155e-01f, 9.48108584e-02f, 5.15497550e-02f, -1.58333689e-01f, -1.13800406e-01f, -4.72103991e-02f,
  -7.40766674e-02f, -9.56013873e-02f, 5.63374683e-02f, -6.82562739e-02f, -1.65414177e-02f, -2.49122921e-02f, -1.16193838e-01f, -1.03060417e-01f, -1.57770023e-01f, -2.04869211e-02f,
  7.02198874e-03f, -2.77005315e-01f, -2.88008541e-01f, -7.19832107e-02f, -2.26916134e-01f, -5.75811453e-02f, -1.83396652e-01f, -1.84660345e-01f, -8.99086520e-02f, -6.33802637e-02f,
  4.64490391e-02f, 4.10430394e-02f, 2.49594077e-02f, -5.90304099e-02f, 1.37935370e-01f, -8.03105533e-02f, -4.35924158e-02f, 1.47473067e-02f, 7.72149190e-02f, -6.93134451e-03f,
  2.20810007e-02f, -7.73075148e-02f, -1.69867069e-01f, 1.27701452e-02f, -5.78217953e-02f, -1.12251513e-01f, 1.74350534e-02f, 1.17022149e-01f, -4.10600901e-02f, 4.68479395e-02f,
  3.77338342e-02f, -2.31353678e-02f, 2.09267382e-02f, 5.09679131e-02f, -5.60509525e-02f, -4.87669231e-03f, 9.13115293e-02f, -2.44246586e-03f, 8.44221264e-02f, -1.63174551e-02f,
  2.89244890e-01f, -3.23639773e-02f, 1.52017875e-02f, 5.32568097e-02f, -1.61474258e-01f, -7.21537992e-02f, 1.04251705e-01f, -1.39669869e-02f, -5.13631105e-03f, 4.15933505e-02f,
  4.66220528e-02f, 4.62906249e-02f, 7.65882730e-02f, -5.98879624e-03f, -8.06618482e-03f, 1.18721239e-01f, 1.15421765e-01f, 1.22397237e-01f, 1.44756781e-02f, 4.63599674e-02f,
  -6.06965320e-03f, 7.57323503e-02f, 2.38122031e-01f, 1.22758701e-01f, 2.03778446e-02f, 2.58252293e-01f, 1.42861754e-02f, -1.95444729e-02f, 1.83280423e-01f, 2.48562261e-01f,
  -1.51699826e-01f, -6.08702004e-02f, 7.57827312e-02f, -1.13888472e-01f, -1.00481391e-01f, 5.33754751e-02f, 1.07506238e-01f, 7.63029531e-02f, 3.74391563e-02f, 7.51765911e-03f,
  9.86396074e-02f, 1.68438390e-01f, 2.84683347e-01f, 2.08428934e-01f, 2.04339340e-01f, 2.21285611e-01f, 1.75365154e-02f, 1.23757407e-01f, 1.25692487e-01f, 1.57764152e-01f,
  -5.45411650e-03f, -3.07613984e-02f, 9.84867215e-02f, 1.23981610e-01f, 4.72992845e-02f, 1.86780915e-02f, 1.59234658e-01f, 4.90669347e-02f, 1.45849675e-01f, 5.64917512e-02f,
  3.88684481e-01f, 2.89812423e-02f, 1.10343084e-01f, -5.62689789e-02f, -6.91193938e-02f, -2.36401018e-02f, -3.39016095e-02f, -1.57213360e-01f, -2.92055886e-02f, 1.45470649e-02f,
  -2.57359482e-02f, -1.17139257e-01f, -1.56789906e-02f, -1.31761461e-01f, -2.43241057e-01f, -3.22252735e-02f, -1.56878814e-01f, 1.25792027e-01f, 2.07938746e-01f, 1.30829945e-01f,
  -5.75802848e-02f, -1.16999544e-01f, 7.72084966e-02f, 1.11279294e-01f, 3.49812768e-02f, -2.09092274e-02f, 5.00200875e-02f, 2.25598123e-02f, -2.20821388e-02f, 3.83678749e-02f,
  3.05428773e-01f, 1.01703934e-01f, 4.51821759e-02f, 2.48908192e-01f, 8.12348127e-02f, 5.83818369e-02f, -1.07700869e-01f, 2.28304509e-02f, 6.22071475e-02f, -4.82036322e-02f,
  -6.61066622e-02f, 1.84723929e-01f, 9.33346748e-02f, -1.14677753e-02f, 6.10449798e-02f, -2.64048800e-02f, -4.86244215e-03f, 1.05013266e-01f, -1.72320735e-02f, 9.58342478e-02f,
  -3.12112812e-02f, -6.06948398e-02f, -1.02204435e-01f, -2.10973565e-02f, -4.71453059e-05f, -6.48397654e-02f, -1.70628279e-01f, -1.42307365e-02f, -1.16576560e-01f, -8.19436647e-03f,
  1.94896474e-01f, 3.01865846e-01f, 2.08766431e-01f, 7.93273300e-02f, -1.16371676e-01f, -1.91090241e-01f, -2.02239938e-02f, -1.46182686e-01f, -1.57105595e-01f, 5.91117032e-02f,
  -3.12604867e-02f, -1.58899799e-01f, -5.35380282e-02f, -1.61071792e-01f, -2.09625721e-01f, -9.38111469e-02f, -3.96309197e-02f, 5.95557801e-02f, 1.09394632e-01f, 6.10813908e-02f,
  -4.76515032e-02f, 4.24789079e-02f, 1.35913610e-01f, 1.35296449e-01f, -3.16297971e-02f, 1.44995123e-01f, 4.78203520e-02f, -2.59135552e-02f, -3.80234085e-02f, -9.95823890e-02f,
  4.21463698e-01f, -1.46480620e-01f, -2.51989275e-01f, -2.94838304e-04f, -2.54668206e-01f, -3.34793776e-01f, -3.34311157e-01f, -1.89769700e-01f, -1.45136595e-01f, -3.22173595e-01f,
  -1.84880853e-01f, 9.47059691e-02f, 3.84731255e-02f, 3.74073945e-02f, -7.05411956e-02f, -5.06109715e-01f, -4.20724571e-01f, -1.25889286e-01f, 1.42519558e-02f, -3.32068533e-01f,
  -2.18156129e-01f, -5.50968340e-03f, 1.17667846e-01f, -1.17085710e-01f, -2.03080997e-01f, -7.38131627e-02f, -3.60348254e-01f, -2.78555542e-01f, -2.73472816e-01f, -3.24294299e-01f,
  -4.47714329e-01f, -8.06260034e-02f, 1.11841634e-01f, 2.23518282e-01f, -3.33742425e-03f, 3.82402614e-02f, -8.50092678e-04f, 9.09750611e-02f, 9.60322320e-02f, -6.73780814e-02f,
  2.72162072e-03f, -1.17442437e-01f, 4.08047847e-02f, -4.96411845e-02f, -1.18489355e-01f, -5.82739264e-02f, -8.09970722e-02f, 1.41569436e-01f, 2.42889635e-02f, -1.71281248e-01f,
  -1.30912185e-01f, -1.97735235e-01f, -1.99595653e-03f, 1.51987314e-01f, -7.68008605e-02f, 1.68166921e-01f, -8.62903222e-02f, -2.24758089e-01f, 4.52535180e-03f, -8.09420124e-02f,
  9.36194137e-02f, 2.31618155e-03f, -9.27057341e-02f, -2.05888189e-02f, -1.42961917e-02f, -7.27237463e-02f, -7.70811457e-03f, -9.37775150e-02f, -7.81559497e-02f, 8.39008018e-02f,
  -3.78451757e-02f, -1.35535905e-02f, 9.11000371e-02f, 7.72608891e-02f, -1.28722012e-01f, -2.84640361e-02f, 3.36392485e-02f, -3.40645271e-03f, -6.97311908e-02f, -1.37379265e-03f,
  -7.50621259e-02f, -1.14335202e-01f, 1.14064207e-02f, 1.98763870e-02f, -1.71591803e-01f, -5.26220389e-02f, 4.26793396e-02f, 4.71138060e-02f, 6.71056211e-02f, 5.40806027e-03f,
  5.97359650e-02f, 6.74851835e-02f, -1.92879707e-01f, 3.84113789e-02f, -9.78886038e-02f, -2.20674314e-02f, 8.44996329e-03f, 1.05900198e-01f, 8.15936476e-02f, -1.13836668e-01f,
  -1.34332642e-01f, -6.75154850e-02f, -6.84103277e-03f, -9.22671705e-02f, -9.82232466e-02f, -7.72573873e-02f, -6.02355972e-02f, 3.39296386e-02f, -3.20131071e-02f, -1.10949174e-01f,
  4.91494350e-02f, 5.49533740e-02f, 2.73970038e-01f, 1.88811615e-01f, 2.59993002e-02f, -2.06259415e-02f, -8.14837515e-02f, -2.15171084e-01f, 6.56835809e-02f, 1.57140911e-01f,
  1.64862216e-01f, 3.58200699e-01f, 2.18498074e-02f, -1.49282336e-01f, 1.85244143e-01f, 1.80211321e-01f, 2.75861681e-01f, 3.54542792e-01f, 8.60143676e-02f, 6.90291822e-02f,
  2.46620089e-01f, 2.98558678e-02f, -2.10278332e-02f, -1.55217439e-01f, -2.34443560e-01f, -1.51992470e-01f, -1.71224907e-01f, -2.31727019e-01f, -1.58298939e-01f, 6.87668175e-02f,
  -3.69226113e-02f, 8.54359269e-02f, -2.83784084e-02f, -1.88980311e-01f, -1.98722892e-02f, -2.08984524e-01f, -1.59988865e-01f, -4.04537432e-02f, -2.34863773e-01f, -3.17073375e-01f,
  -1.61868036e-01f, 4.22580600e-01f, -1.38434276e-01f, 3.67670842e-02f, 7.44885951e-02f, 1.67834386e-02f, 2.00667098e-01f, 5.50022498e-02f, 1.89303592e-01f, 6.85306499e-03f,
  4.67161089e-02f, 1.61910683e-01f, 1.61698252e-01f, -8.53849426e-02f, 8.07357356e-02f, 6.05701692e-02f, 6.60863295e-02f, -1.00022703e-01f, -1.36835381e-01f, 8.99975002e-02f,
  8.58549699e-02f, -2.10679770e-02f, 1.42449498e-01f, 1.84484683e-02f, -5.95651194e-02f, -1.23368017e-01f, 2.49734163e-01f, 2.21396312e-02f, -1.74627617e-01f, -1.52697444e-01f,
  1.30410329e-01f, 1.31580830e-01f, 6.99810684e-03f, 1.19454399e-01f, 5.09323180e-02f, 5.63724972e-02f, -1.39067888e-01f, -1.29424438e-01f, -6.85960799e-02f, 1.84399039e-02f,
  3.78943272e-02f, -4.93755266e-02f, -1.42290890e-02f, -1.25734538e-01f, -1.31096095e-01f, 6.81123172e-04f, -3.81673276e-02f, -2.13378042e-01f, -2.24922672e-01f, -2.20987424e-02f,
  -8.66412893e-02f, -1.36263907e-01f, -1.03052981e-01f, -1.92958638e-01f, -1.22177921e-01f, -2.04962507e-01f, -1.00046828e-01f, 1.27415702e-01f, 2.35467762e-01f, 2.89607584e-01f,
  -8.70463550e-02f, 1.42673835e-01f, -2.60572404e-01f, -1.53532282e-01f, -8.65150020e-02f, -7.33161122e-02f, -4.92205583e-02f, -1.59585565e-01f, -5.46605252e-02f, -8.29889998e-02f,
  1.66815236e-01f, -1.01457024e-02f, 1.36430308e-01f, -8.76960456e-02f, 6.89533278e-02f, 6.42156452e-02f, -1.76413298e-01f, -2.81557173e-01f, -1.98922187e-01f, -1.66432355e-02f,
  -1.63150370e-01f, -2.57932574e-01f, -1.92303777e-01f, -2.78229535e-01f, -1.30635723e-01f, -1.43070489e-01f, -1.27162904e-01f, -2.09513247e-01f, -2.36066073e-01f, -1.10795267e-01f,
  6.21195614e-01f, 2.63779074e-01f, 3.06717008e-01f, -4.88210395e-02f, -2.71819115e-01f, -1.71461135e-01f, -1.70758694e-01f, 1.03339925e-01f, -3.31364088e-02f, -7.86937948e-04f,
  -4.16230969e-02f, -1.64275281e-02f, 9.38537419e-02f, 2.74068326e-01f, 3.41937512e-01f, 2.31303185e-01f, 1.27512276e-01f, 3.91656816e-01f, 2.57720500e-01f, 1.14995940e-02f,
  -6.56145439e-02f, 1.01291604e-01f, 3.23366672e-01f, 1.38140544e-01f, 1.60356358e-01f, 9.39918868e-03f, 3.30071449e-02f, -6.47833794e-02f, 1.57394201e-01f, 2.64991313e-01f,
  1.14749156e-01f, 3.13335329e-01f, -3.97746675e-02f, 4.12452631e-02f, -1.23177860e-02f, 1.49849802e-01f, -1.10027622e-02f, -7.83431754e-02f, -6.05483390e-02f, -1.54150382e-01f,
  6.55123740e-02f, -4.06565480e-02f, -2.63291001e-02f, -1.82635784e-01f, -2.36157048e-02f, 3.26248594e-02f, 1.61340069e-02f, -2.51947995e-03f, -1.37293078e-02f, 2.94596404e-02f,
  -1.05605081e-01f, -1.58265680e-01f, -9.18498188e-02f, -1.19900227e-01f, -2.37221848e-02f, -3.48113105e-02f, -1.01856522e-01f, 1.23513974e-01f, 7.93135762e-02f, 8.38266984e-02f,
  -1.20780878e-01f, 1.08328424e-02f, 1.24761693e-01f, -1.22908793e-01f, -4.87202778e-02f, -8.80659968e-02f, -1.91995446e-02f, -1.29284605e-01f, 4.96866517e-02f, -1.56669840e-02f,
  -3.59062776e-02f, 7.60448352e-02f, 4.70416024e-02f, 4.55345474e-02f, -2.94602495e-02f, 8.57234374e-02f, 1.07942067e-01f, -2.97566019e-02f, 3.54258344e-02f, 5.54001592e-02f,
  7.33460560e-02f, -2.25576703e-04f, -1.11077249e-01f, 4.97511849e-02f, -7.85362348e-02f, -4.17923927e-02f, -2.30574198e-02f, -7.24345772e-03f, -1.38087556e-01f, -7.42541105e-02f,
  -2.69407570e-01f, 2.96449065e-02f, 1.81877390e-01f, 1.75685003e-01f, 6.13826029e-02f, 1.15745030e-01f, 1.81498960e-01f, 9.43674818e-02f, -1.27488179e-02f, 5.05105918e-03f,
  -5.94865233e-02f, 7.65563101e-02f, 6.98812827e-02f, 2.44997125e-02f, -1.23054080e-01f, -1.09403200e-01f, 2.36267801e-02f, 3.38815129e-03f, 3.14747281e-02f, 4.25136322e-03f,
  -9.25403014e-02f, -1.30989671e-01f, -1.70528442e-01f, -3.50577980e-02f, -8.53701383e-02f, -4.41153198e-02f, -9.98348445e-02f, -1.08825296e-01f, -1.05837926e-01f, -1.63283691e-01f,
  -5.52442312e-01f, 5.35925888e-02f, -3.38458836e-01f, -2.31393307e-01f, 1.05587959e-01f, 1.76514536e-01f, 3.46562788e-02f, 6.17918409e-02f, -2.48505902e-02f, -5.36723547e-02f,
  2.63513196e-02f, 4.07665782e-02f, -1.27279118e-01f, -5.80521747e-02f, -1.63886368e-01f, -2.18140021e-01f, -9.19607952e-02f, -3.26576024e-01f, -9.38001424e-02f, 3.09826314e-01f,
  3.47304285e-01f, -6.83951937e-03f, -1.52164832e-01f, -7.75094628e-02f, 5.40058203e-02f, 2.92215906e-02f, -2.26265252e-01f, -1.74346238e-01f, 3.40983197e-02f, -3.20509300e-02f,
  -4.29429829e-01f, -2.01427281e-01f, 1.82863370e-01f, 1.17315114e-01f, 6.04683012e-02f, -6.38846233e-02f, 8.32605362e-02f, -2.44678363e-01f, 3.99188213e-02f, -6.92022592e-02f,
  -5.39921299e-02f, 3.55080068e-02f, 3.51016223e-02f, -7.58970529e-02f, 5.59484139e-02f, -1.70700178e-02f, -9.13978964e-02f, -1.25592798e-01f, -1.53746858e-01f, 5.27087785e-03f,
  1.70789450e-01f, -6.21486530e-02f, -2.94518590e-01f, 8.31367373e-02f, 1.13714755e-01f, -1.33063525e-01f, -5.91136795e-03f, 3.57296579e-02f, -1.91397578e-01f, -4.54071403e-01f,
  -3.91946770e-02f, -4.58379202e-02f, 1.97491944e-01f, -3.44565809e-02f, 1.07052401e-02f, -5.95723465e-02f, 2.90556159e-03f, -6.93891896e-04f, -5.38678840e-03f, -9.09953490e-02f,
  -1.52977537e-02f, -3.22213918e-02f, -6.74867406e-02f, -1.09512515e-01f, 8.85103717e-02f, 1.12235947e-02f, 6.96351975e-02f, 3.95748876e-02f, -6.99804500e-02f, -4.52691503e-02f,
  -1.46505209e-02f, 5.39695807e-02f, 2.21796799e-02f, 3.78811285e-02f, 2.01843847e-02f, -2.21413761e-01f, -9.93622988e-02f, -1.83622986e-02f, -1.03026576e-01f, -1.35266587e-01f,
  -2.92639494e-01f, -8.67966264e-02f, -1.96348622e-01f, 3.31095569e-02f, -2.41551865e-02f, 9.98115465e-02f, -1.25607923e-02f, -8.39292556e-02f, -2.21162494e-02f, 6.22563735e-02f,
  1.45423114e-01f, -2.48191934e-02f, -1.43911690e-01f, 1.11115083e-01f, 2.41474986e-01f, 8.44970495e-02f, 6.08369112e-02f, -1.30473092e-01f, 1.71074137e-01f, 1.40857831e-01f,
  -2.67377794e-02f, -1.77541792e-01f, -1.89340860e-01f, -1.94046974e-01f, 3.33382562e-02f, -1.63376898e-01f, -2.17505202e-01f, -8.14458877e-02f, -2.19489023e-01f, -3.76329780e-01f,
  2.77256131e-01f, -1.70611009e-01f, 7.85253122e-02f, 8.59468356e-02f, 1.13882851e-02f, 1.27766848e-01f, 1.76154405e-01f, 9.15847942e-02f, 7.22188950e-02f, 7.64089227e-02f,
  -5.73501252e-02f, -1.38564840e-01f, -1.94496632e-01f, -8.42426568e-02f, -5.47963753e-02f, 4.22871150e-02f, -1.09291956e-01f, 1.54582903e-01f, 2.07010627e-01f, 3.72753181e-02f,
  -8.45555365e-02f, 3.77891809e-02f, 1.01216137e-01f, 5.95929548e-02f, 2.94122584e-02f, -9.08169299e-02f, -1.42905135e-02f, -7.18158931e-02f, -9.77829471e-02f, 1.64782610e-02f,
  3.22529599e-02f, 8.05616230e-02f, 3.94893996e-02f, -2.24795580e-01f, -2.03758344e-01f, 2.07324326e-02f, 1.63887814e-01f, -4.14192975e-02f, -6.00554794e-02f, 7.79852271e-02f,
  -1.75987780e-01f, -1.42694786e-01f, -6.30058274e-02f, -2.55881231e-02f, 1.29732847e-01f, -1.58268977e-02f, -8.74296054e-02f, -8.01085606e-02f, 5.04362285e-02f, -2.47518625e-02f,
  -1.24266423e-01f, -6.02468513e-02f, 6.05968460e-02f, -1.00506067e-01f, -1.14677623e-01f, -3.85475904e-02f, 1.21261105e-02f, -9.10882279e-02f, -1.01271659e-01f, -3.04822344e-02f,
  -2.61614155e-02f, -1.40646607e-01f, -5.60328364e-02f, 1.57234296e-01f, 9.27006751e-02f, -2.33049877e-02f, 4.12527882e-02f, 4.45746109e-02f, 1.74800560e-01f, 2.04832628e-01f,
  1.32068023e-01f, 1.90675318e-01f, 1.44587651e-01f, 1.46907091e-01f, 1.10173501e-01f, 1.99939564e-01f, 4.31370027e-02f, -5.95232844e-02f, 9.87496227e-02f, 8.31108540e-02f,
  1.72928944e-01f, 1.65723100e-01f, 1.99104726e-01f, 1.65980786e-01f, 8.57367069e-02f, 1.17630392e-01f, 1.63541377e-01f, 9.70202535e-02f, 2.53222194e-02f, 1.48587406e-01f,
  2.31233668e-02f, -3.18471454e-02f, 8.08663368e-02f, -1.13891229e-01f, -8.75427797e-02f, -2.01605223e-02f, 1.87046803e-03f, -1.35729983e-01f, -1.68910995e-01f, 6.80015460e-02f,
  -3.03231403e-02f, -1.71352606e-02f, 6.90583289e-02f, -2.73145977e-02f, 9.06332508e-02f, -3.98365818e-02f, -2.69451104e-02f, 2.22969558e-02f, -7.01037562e-03f, -6.66406602e-02f,
  -5.51172532e-02f, 1.07187182e-02f, 2.82623861e-02f, -1.32321240e-02f, -1.12810850e-01f, 2.54122764e-02f, -3.27828713e-02f, 1.14209630e-01f, 8.03299323e-02f, 1.90562978e-01f,
  9.20163989e-02f, 1.71691068e-02f, 3.50938499e-01f, 1.18780792e-01f, 1.82096854e-01f, 3.50378305e-01f, 3.80368114e-01f, 2.25065708e-01f, -3.41689251e-02f, 4.82287742e-02f,
  9.39544477e-03f, -6.53801188e-02f, -1.67705700e-01f, -3.48812453e-02f, 1.08605614e-02f, 8.33438337e-02f, -7.44614601e-02f, -2.16657594e-02f, 1.45943210e-01f, 4.95135821e-02f,
  -1.21166967e-01f, 2.18299069e-02f, 7.99673796e-03f, -1.08405640e-02f, -7.39373416e-02f, -4.04229760e-02f, 5.80364428e-02f, -1.02911599e-01f, -7.72232004e-03f, -1.47575304e-01f,
  -1.70125365e-01f, 1.21232972e-01f, -2.80768201e-02f, -1.70057788e-01f, -1.69276401e-01f, -4.08853516e-02f, 7.50165954e-02f, -4.82246932e-03f, 2.92810947e-02f, 3.39544564e-02f,
  -1.68614443e-02f, -6.63095191e-02f, -1.19524263e-02f, -1.23352846e-02f, 6.01851717e-02f, 7.99491778e-02f, -1.19706511e-01f, 1.52458390e-02f, 2.99773626e-02f, 3.64469215e-02f,
  -1.80683397e-02f, 1.33558571e-01f, 1.83313906e-01f, 1.55738071e-01f, -2.36269599e-03f, 4.30169776e-02f, -3.89418118e-02f, 4.01281156e-02f, 2.27051564e-02f, -8.52877945e-02f,
  -2.60920115e-02f, 1.96965635e-02f, -6.31462857e-02f, 1.71252992e-02f, 9.63068306e-02f, 5.01739942e-02f, -5.30986972e-02f, 1.77238300e-03f, 1.89174905e-01f, 4.52402942e-02f,
  -5.82432840e-03f, 2.41856530e-01f, 1.65321574e-01f, 4.40159701e-02f, 2.65101995e-02f, 5.74731380e-02f, 1.22593716e-01f, 9.84963495e-03f, 1.49634987e-01f, 1.45648211e-01f,
  2.74427123e-02f, 1.26400426e-01f, 2.26844698e-02f, 1.58194631e-01f, 9.74861979e-02f, 6.52404949e-02f, 7.09266514e-02f, 1.53486773e-01f, 3.67188528e-02f, 1.32235602e-01f,
  -2.28478193e-01f, 1.62637562e-01f, -1.12656295e-01f, -1.28257915e-01f, -2.06028059e-01f, -4.96924259e-02f, 1.13211358e-02f, 1.57137681e-02f, -4.09506485e-02f, -1.05575375e-01f,
  -9.50985253e-02f, -1.70632854e-01f, 3.78078874e-03f, -6.98114634e-02f, -3.96632664e-02f, -1.42432877e-03f, -1.39060751e-01f, -4.77177501e-02f, 2.59507098e-03f, -7.85363689e-02f,
  -5.01114912e-02f, -2.07531545e-02f, 1.05906129e-01f, -5.81245944e-02f, 4.75528240e-02f, -8.89703929e-02f, 3.88095118e-02f, 7.07211345e-02f, -6.24774806e-02f, 6.59854561e-02f,
  2.29004472e-01f, 3.07012886e-01f, 2.03668594e-01f, 3.96132112e-01f, 2.16184765e-01f, 3.33451092e-01f, 3.60448629e-01f, 3.30112219e-01f, 1.90157577e-01f, 2.39469260e-01f,
  1.29774243e-01f, 2.53982514e-01f, 1.60609186e-01f, 1.42653733e-01f, 2.80910730e-01f, 3.29460174e-01f, 1.77022368e-01f, 2.13306770e-02f, 1.61089450e-01f, 2.41944462e-01f,
  1.71174496e-01f, 1.41820759e-01f, -1.30297542e-02f, 2.18638107e-01f, 9.93665233e-02f, 1.29848287e-01f, 2.00575352e-01f, 1.56320035e-01f, 1.86205015e-01f, 1.95673957e-01f,
  -4.34705794e-01f, -6.82528093e-02f, -1.40815852e-02f, -1.30422741e-01f, -6.52807429e-02f, -2.81348750e-02f, -8.73939395e-02f, -7.50362128e-02f, 4.93211634e-02f, 3.07370927e-02f,
  -1.88982904e-01f, -1.80938199e-01f, -2.31651589e-02f, -3.35119627e-02f, -6.81117252e-02f, -1.07972339e-01f, 2.39360356e-03f, 3.80307361e-02f, 1.39477268e-01f, -2.01453269e-02f,
  -1.87573973e-02f, 2.11163294e-02f, -5.32594249e-02f, 1.43169938e-02f, -1.44272456e-02f, 5.94928451e-02f, 9.97252204e-03f, -7.85062015e-02f, -7.75602162e-02f, 1.28343478e-01f,
  -1.91917662e-02f, 7.11665377e-02f, -1.12604856e-01f, -1.13494441e-01f, 4.60164696e-02f, 2.07176488e-02f, 4.26899306e-02f, 3.15072387e-02f, 8.70786011e-02f, -6.97055086e-03f,
  -4.58838493e-02f, -3.52570787e-02f, -1.69498939e-02f, -7.41844326e-02f, -1.45724684e-01f, -5.58251478e-02f, 8.04115385e-02f, -5.46006821e-02f, -1.70877993e-01f, -7.40338266e-02f,
  -1.41695201e-01f, 1.60777960e-02f, -2.07520142e-01f, -4.48238067e-02f, -2.02153679e-02f, -1.39626721e-02f, -1.34948850e-01f, -8.17578286e-02f, -6.41219616e-02f, -2.27359869e-02f,
  -1.76287949e-01f, -7.13048577e-02f, 8.32775831e-02f, 1.90712616e-01f, -8.65761414e-02f, -2.11659238e-01f, -8.65756795e-02f, -1.01842001e-01f, -9.76625010e-02f, -9.55175459e-02f,
  -7.76760653e-02f, -2.04107955e-01f, -1.35763407e-01f, -4.68305275e-02f, -1.76412016e-01f, -5.53726330e-02f, -4.80090715e-02f, 1.41471967e-01f, 9.65664685e-02f, -9.31819603e-02f,
  -7.63263134e-03f, 1.52317598e-01f, 5.69965430e-02f, 1.09396510e-01f, 9.47977379e-02f, 8.02202672e-02f, -5.56394272e-02f, 2.69099511e-03f, -6.53247386e-02f, -2.82563362e-02f,
  5.94796836e-01f, 1.91325724e-01f, 2.69797683e-01f, 1.14086650e-01f, -3.53993587e-02f, 2.41101142e-02f, 2.63956171e-02f, 3.58189568e-02f, -5.44739515e-03f, -3.96502130e-02f,
  -4.35785614e-02f, -7.35258684e-02f, -1.36194423e-01f, -6.81267977e-02f, 5.14370352e-02f, -5.03305644e-02f, -6.91368058e-02f, 2.56459475e-01f, 1.52948216e-01f, 1.49618641e-01f,
  -1.52871227e-02f, 2.26722583e-01f, 3.06084007e-01f, 1.15578331e-01f, -1.19726267e-02f, -3.31572033e-02f, 1.34337515e-01f, 4.70508710e-02f, 1.25279967e-02f, -1.61675110e-01f,
  -1.13394678e-01f, 2.13064298e-01f, -8.72776434e-02f, 5.70398569e-02f, 2.24283144e-01f, 2.19434828e-01f, 6.33378178e-02f, 1.54561073e-01f, -5.68732098e-02f, -5.50996736e-02f,
  -2.67311111e-02f, 1.71283722e-01f, 1.58601075e-01f, 4.67229672e-02f, 1.58077732e-01f, 9.78128240e-02f, 2.04853058e-01f, 1.00973502e-01f, 2.98461504e-02f, 2.68002711e-02f,
  1.99994748e-03f, 6.50466979e-02f, -5.55194356e-02f, -7.30503425e-02f, 7.85303935e-02f, -3.07946410e-02f, 3.65463570e-02f, -3.79585847e-02f, 9.63116139e-02f, 7.52574131e-02f,
  -2.19224006e-01f, 5.49363233e-02f, 2.67417639e-01f, 9.68158338e-03f, 2.10928321e-01f, -1.20837642e-02f, 2.20934991e-02f, -1.44200232e-02f, 1.62140220e-01f, 3.46432984e-01f,
  -4.57555167e-02f, 1.23236932e-01f, 1.16612040e-01f, 1.32499129e-01f, 1.28729105e-01f, 1.93154529e-01f, 5.05224355e-02f, 1.27790704e-01f, 9.53225344e-02f, 9.82632786e-02f,
  6.63222419e-03f, -5.40126711e-02f, 8.15864131e-02f, 1.61413312e-01f, -4.81877849e-02f, 5.51399738e-02f, -2.10482664e-02f, 1.63525224e-01f, 1.26575306e-01f, -9.70805530e-03f,
  -1.45810336e-01f, 2.32119843e-01f, -6.98446929e-02f, -5.83975874e-02f, 8.83498043e-03f, 7.68047050e-02f, -3.01142223e-02f, -5.16383015e-02f, -8.24388564e-02f, -2.94012260e-02f,
  -2.76908837e-02f, 7.84870982e-02f, 7.59748071e-02f, 1.53530434e-01f, 1.16441920e-01f, -7.53389671e-02f, -4.24603038e-02f, -1.55112401e-01f, -1.72144085e-01f, -3.09193488e-02f,
  -1.49073824e-01f, -1.39847651e-01f, -2.74402738e-01f, -1.66081175e-01f, -1.95927903e-01f, -3.07318270e-01f, -8.04250687e-02f, -1.13450103e-01f, -1.48996159e-01f, -2.60283053e-02f,
  -7.30639249e-02f, -3.11371125e-02f, -1.69580039e-02f, 2.01369077e-01f, 9.81328487e-02f, 1.02061871e-02f, -5.56176640e-02f, -3.74506265e-02f, 6.96301460e-02f, 7.06354231e-02f,
  8.70855302e-02f, 1.18654750e-01f, 2.15546235e-01f, 1.56650811e-01f, 1.31470695e-01f, 1.19980685e-02f, 2.68960506e-01f, 1.39689609e-01f, 3.33316363e-02f, -3.46371089e-03f,
  2.48114750e-01f, 2.52207398e-01f, 1.72438577e-01f, 7.57996663e-02f, 2.12325603e-02f, 1.99195936e-01f, 1.40272543e-01f, 1.51176542e-01f, 2.43276730e-02f, 7.08990395e-02f,
  -3.26638877e-01f, -9.74837095e-02f, -1.20674185e-01f, 1.62412170e-02f, -2.96562500e-02f, -1.18957423e-01f, -6.26639128e-02f, -5.48119098e-03f, -4.21565101e-02f, -4.42931764e-02f,
  -1.50023624e-01f, -1.02796115e-01f, 8.52332413e-02f, -3.41783948e-02f, -4.29641753e-02f, -5.45179658e-02f, 4.28517610e-02f, -1.74597755e-01f, -7.47149363e-02f, -1.68099895e-01f,
  7.46991858e-02f, -1.38593584e-01f, -2.16612935e-01f, -2.24559352e-01f, -1.75799608e-01f, -1.25273943e-01f, -1.34983480e-01f, -2.34063610e-01f, -1.35881215e-01f, -1.38413638e-01f,
  5.48601104e-03f, -1.73698291e-01f, -1.29142717e-01f, -3.83855142e-02f, 7.09865391e-02f, -6.65656989e-03f, -1.41381040e-01f, -1.44415781e-01f, -3.15481648e-02f, -1.49469092e-01f,
  1.99556854e-02f, -2.18371879e-02f, -2.37698495e-01f, -1.75548896e-01f, -3.09818294e-02f, -1.87995940e-01f, -1.49493992e-01f, -1.17176056e-01f, -7.55934939e-02f, -9.75684822e-02f,
  -4.40417528e-02f, -1.65644944e-01f, -7.28908852e-02f, -1.08274542e-01f, 7.89161026e-02f, -1.96114704e-02f, -7.53905848e-02f, -2.61312127e-02f, -1.14801498e-02f, -6.21990338e-02f,
  2.44946182e-02f, 1.83089927e-01f, -2.11248249e-01f, -1.50533631e-01f, -1.34873718e-01f, 6.25543445e-02f, -9.65226889e-02f, -5.36611304e-02f, -1.44510761e-01f, -2.35972762e-01f,
  -1.76015899e-01f, -1.39784813e-01f, -1.21960372e-01f, -9.66590717e-02f, -6.56368211e-02f, -4.86793295e-02f, -1.43884763e-01f, -7.30960444e-02f, -1.74273580e-01f, -8.12995881e-02f,
  -9.25142318e-02f, -2.93205649e-01f, -3.15399110e-01f, -9.90938544e-02f, -1.99485093e-01f, -2.71758251e-02f, -2.56181717e-01f, -2.44878918e-01f, -2.13921160e-01f, -2.49948278e-01f,
  4.03001338e-01f, -3.86460990e-01f, -3.01817000e-01f, -1.46451011e-01f, -1.54568046e-01f, -5.92598878e-02f, -2.63175696e-01f, -1.00987151e-01f, 1.40227797e-02f, -2.89450079e-01f,
  -7.78040886e-02f, 4.27887321e-01f, 1.87757105e-01f, 1.66183144e-01f, 2.52959937e-01f, -3.53546709e-01f, -2.89977968e-01f, 1.27494723e-01f, 4.05421406e-01f, 2.93351889e-01f,
  -5.41907037e-03f, 5.79016237e-03f, 1.59311250e-01f, 5.87168671e-02f, -4.30575669e-01f, 1.24874376e-02f, -3.56400639e-01f, -1.70361117e-01f, -1.48902550e-01f, -3.05936128e-01f,
  -2.45578185e-01f, -8.03975686e-02f, -9.52312537e-03f, 1.31621793e-01f, -1.63484186e-01f, 7.34600127e-02f, -7.52162635e-02f, -1.38897359e-01f, -7.49424174e-02f, -1.01434663e-01f,
  -3.90549377e-02f, -8.01278092e-03f, -5.97633123e-02f, -4.66504283e-02f, -2.95657273e-02f, 2.39550415e-02f, -2.07653999e-01f, 2.81723700e-02f, -4.34402637e-02f, -5.17687015e-02f,
  -4.73008603e-02f, 1.22098431e-01f, 3.99494395e-02f, -8.68066028e-02f, -4.94999113e-04f, 9.57940146e-02f, -1.19997516e-01f, 2.76476238e-02f, 8.06398392e-02f, -2.02989683e-01f,
  6.18100017e-02f, -5.98138198e-02f, -2.19332241e-02f, -1.20931506e-01f, 3.20805386e-02f, -1.11230835e-02f, -3.91152389e-02f, 4.08912040e-02f, 3.91756557e-02f, -6.73771724e-02f,
  8.37889314e-02f, 7.87452236e-02f, 1.11510515e-01f, -1.24670543e-01f, -1.01742372e-01f, -3.95469600e-03f, 9.79354009e-02f, -5.67718409e-02f, 3.06041278e-02f, -3.54637094e-02f,
  1.49575025e-01f, -9.27447602e-02f, 3.91724072e-02f, 8.82969354e-04f, 1.11392461e-01f, 1.55929744e-01f, -2.01336537e-02f, 5.80919459e-02f, 5.51923290e-02f, 3.57869826e-02f,
  -2.71841556e-01f, 1.95721626e-01f, -9.57779586e-02f, 1.83361635e-01f, -9.60618779e-02f, -9.56833921e-03f, -1.53618172e-01f, -1.28498329e-02f, -1.40751779e-01f, -1.10819347e-01f,
  -2.39543617e-02f, 1.06331393e-01f, -1.19179450e-01f, -8.34539160e-02f, 2.41279513e-01f, 5.59533201e-02f, -6.62838593e-02f, 2.18292490e-01f, 1.85922444e-01f, -1.31462663e-01f,
  3.72206010e-02f, 2.27440640e-01f, 1.47684976e-01f, 8.97800699e-02f, 1.10288955e-01f, 7.56479353e-02f, -1.08015113e-01f, 3.10913157e-02f, 2.06936762e-01f, -2.66563743e-01f,
  5.98251939e-01f, -6.26067305e-03f, 1.17769815e-01f, 8.92772228e-02f, -4.14490700e-01f, -2.44375631e-01f, -1.78617254e-01f, 6.98136613e-02f, 1.07149929e-01f, 3.22963633e-02f,
  -7.54139125e-02f, 7.97444656e-02f, 9.18926746e-02f, 1.14694834e-01f, 2.76025623e-01f, 5.25319651e-02f, 1.40579149e-01f, 2.66735137e-01f, 1.13764368e-01f, 4.92596142e-02f,
  -4.83424477e-02f, 1.96401104e-02f, 2.26404145e-01f, 1.78950936e-01f, -6.05570227e-02f, -1.02003850e-02f, 1.47487149e-02f, -6.53320700e-02f, 4.41290997e-02f, 2.31913477e-01f,
  -9.57846344e-02f, 1.73278555e-01f, 9.36329812e-02f, 2.89400443e-02f, -8.49297568e-02f, 1.17346488e-01f, 7.52571374e-02f, -8.21287110e-02f, -1.11828603e-01f, -1.34099990e-01f,
  -1.30152926e-01f, -2.08129529e-02f, -2.01698199e-01f, -4.30029482e-02f, -1.91400751e-01f, -1.21523060e-01f, 2.39516199e-02f, 5.37159480e-02f, 9.50380266e-02f, -9.73658487e-02f,
  -1.61874041e-01f, -1.87788859e-01f, -1.34400621e-01f, -1.92554027e-01f, 1.11466981e-01f, -2.58964244e-02f, -4.69238944e-02f, 8.47081095e-02f, 9.32677090e-03f, 1.22603342e-01f,
  -2.17385050e-02f, 4.99030165e-02f, -6.74014986e-02f, -4.20869421e-03f, -9.37925465e-03f, 1.38660672e-03f, -5.98015413e-02f, 5.51164988e-03f, 1.07981607e-01f, 3.75764258e-03f,
  -1.21996827e-01f, 5.08434651e-03f, 1.18468113e-01f, 2.58780154e-03f, -6.90660207e-03f, -4.18842956e-02f, 2.30913330e-02f, -3.46985757e-02f, -3.46020013e-02f, 5.74915409e-02f,
  -1.67513313e-03f, 1.96832716e-02f, -2.04864606e-01f, -1.86661348e-01f, -7.71716759e-02f, -6.54552281e-02f, -1.05434954e-01f, -2.60586776e-02f, -4.28899489e-02f, 1.60772875e-02f,
  -4.78541315e-01f, -7.23361298e-02f, 2.14305133e-01f, 2.48058379e-01f, 2.80824695e-02f, 6.23941701e-03f, 2.08528906e-01f, 3.14697400e-02f, -3.65577266e-02f, 2.59764232e-02f,
  2.17005070e-02f, 2.96256766e-02f, 3.90970483e-02f, 1.05330795e-02f, -1.69627964e-01f, -1.41676053e-01f, 2.65635289e-02f, 7.61284828e-02f, 3.58229466e-02f, -8.59935433e-02f,
  -3.22735645e-02f, -1.51633844e-01f, -1.91534925e-02f, -5.76134399e-02f, 5.05114645e-02f, -1.48383349e-01f, -1.38752088e-01f, -7.90961087e-02f, -1.47246882e-01f, -1.81554899e-01f,
  4.04626355e-02f, 1.17407128e-01f, 2.05408156e-01f, -1.44467488e-01f, 1.09904721e-01f, 3.03700477e-01f, 3.44768733e-01f, 1.33934066e-01f, -1.31161004e-01f, 3.80288027e-02f,
  -2.37640254e-02f, -4.51098084e-01f, -3.10253382e-01f, -2.24871203e-01f, 5.49617857e-02f, 1.45793065e-01f, 2.02493779e-02f, -8.22358057e-02f, 3.80310751e-02f, 1.40544325e-01f,
  -7.11220875e-02f, -1.26243988e-02f, -7.19503015e-02f, -8.04289356e-02f, -4.05728035e-02f, -1.95548624e-01f, 1.65910851e-02f, 1.27523512e-01f, 1.60010550e-02f, -1.48440614e-01f,
  -2.82280091e-02f, 1.61077619e-01f, -2.04580605e-01f, -9.01484564e-02f, 8.62948745e-02f, -1.86041445e-01f, -3.07593867e-02f, -2.01646894e-01f, -6.01610430e-02f, -4.88159731e-02f,
  -4.72395681e-02f, -1.48228239e-02f, 3.52888256e-02f, 7.97442794e-02f, 2.24226922e-01f, 9.97725576e-02f, 1.25019625e-01f, -1.68012250e-02f, -1.15717888e-01f, -5.70943356e-02f,
  -1.15428016e-01f, 1.57933459e-01f, 2.35042438e-01f, 9.11409594e-03f, 2.03272775e-02f, -5.90762980e-02f, 1.68401390e-01f, 6.63035586e-02f, 6.72888383e-02f, -1.69429094e-01f,
  -2.74709731e-01f, -1.25067979e-01f, -3.45163532e-02f, -7.03578442e-03f, 5.48830964e-02f, -1.06563792e-01f, -1.70631465e-02f, 3.41678481e-03f, -1.77341830e-02f, -1.22518605e-02f,
  -9.15827528e-02f, -1.52388349e-01f, -5.80816939e-02f, -9.53148231e-02f, -2.80611008e-01f, 1.75436158e-02f, 4.20899466e-02f, -4.79830317e-02f, 5.57271987e-02f, 1.08592816e-01f,
  -3.07738502e-02f, 5.90104498e-02f, -2.14983951e-02f, -3.30063514e-02f, -1.57466382e-01f, -1.07048944e-01f, -1.96536541e-01f, -8.02736357e-02f, -2.87288632e-02f, -1.20979346e-01f,
  -1.67350784e-01f, 2.64783382e-01f, -1.72834754e-01f, -7.58506879e-02f, 4.35158238e-03f, 1.72248371e-02f, -3.01441222e-01f, -1.94097772e-01f, 1.71538442e-02f, -5.65338135e-02f,
  6.45736158e-02f, -1.99494347e-01f, 7.69396052e-02f, -6.96004704e-02f, -6.76179081e-02f, 1.22940028e-02f, -1.16871893e-01f, -1.51908677e-02f, -4.33852263e-02f, 1.84965525e-02f,
  -1.25398040e-01f, 9.78202745e-02f, 3.61401178e-02f, -1.53881207e-01f, -2.15660125e-01f, -2.53888845e-01f, -6.82139248e-02f, -1.08937891e-02f, 6.79826662e-02f, -1.16897151e-01f,
  8.44608009e-01f, 4.03576583e-01f, 2.34767705e-01f, 1.42007589e-01f, 1.92164972e-01f, 1.92010522e-01f, 1.78568020e-01f, 1.06455341e-01f, 5.17903715e-02f, 9.99844670e-02f,
  1.60890490e-01f, 1.51593372e-01f, 1.18941568e-01f, 6.36232346e-02f, 3.90148023e-03f, 6.18208200e-02f, -2.53517851e-02f, -1.28055243e-02f, 2.66420934e-02f, 1.59751132e-01f,
  -1.29426382e-02f, 1.09540828e-01f, 2.02875808e-01f, 3.05685438e-02f, 8.59017819e-02f, 1.98337268e-02f, -1.29105635e-02f, 1.28624181e-03f, 1.29585356e-01f, 1.54207116e-02f,
  -2.95367330e-01f, 3.19544196e-01f, -7.89008513e-02f, 3.48835588e-02f, 7.99061880e-02f, -8.26125145e-02f, 9.11880806e-02f, 3.92202362e-02f, -1.03842258e-01f, -1.41314283e-01f,
  -7.63981342e-02f, -8.50287918e-03f, 1.95282719e-05f, -2.92040538e-02f, -4.78800684e-02f, -3.83890420e-02f, 9.86224338e-02f, -1.83147360e-02f, -1.15735985e-01f, 7.42808953e-02f,
  1.25355544e-02f, 2.75366083e-02f, 4.52986211e-02f, 6.52654693e-02f, 9.30179432e-02f, -5.41608930e-02f, 7.11588655e-04f, 2.23429389e-02f, 2.00053453e-02f, 4.66894805e-02f,
  -4.33277572e-03f, 1.32601142e-01f, 2.07994267e-01f, 8.41169506e-02f, 1.20180212e-01f, 8.72611851e-02f, -4.12098393e-02f, 1.84187796e-02f, 5.23113273e-02f, 3.97884883e-02f,
  -1.86226796e-02f, -1.22899367e-02f, 1.73085835e-02f, -1.74452402e-02f, -2.16193255e-02f, -5.76765984e-02f, -6.04270101e-02f, -9.21748057e-02f, 9.37092900e-02f, -1.10043436e-01f,
  -8.72596279e-02f, -1.27240568e-01f, 4.89082299e-02f, -3.92173529e-02f, -4.55576815e-02f, 2.99003683e-02f, -1.67165678e-02f, -2.30511744e-02f, -1.47572681e-02f, 9.05278400e-02f,
  -5.44268906e-01f, 2.71239188e-02f, -1.13028139e-02f, -1.19494140e-01f, -5.52364960e-02f, -8.17745775e-02f, 1.28851146e-01f, -1.16948020e-02f, -7.63556138e-02f, -1.97310418e-01f,
  -2.08330322e-02f, -7.93279931e-02f, -3.20774168e-02f, 9.93987694e-02f, -1.35466293e-01f, -1.08893938e-01f, -7.50055835e-02f, -8.38119388e-02f, -2.75485553e-02f, -1.44003123e-01f,
  -7.96399340e-02f, -7.16724526e-03f, -2.16373742e-01f, -8.40025693e-02f, -4.69655618e-02f, -6.55243844e-02f, -5.43604046e-02f, 1.43572397e-04f, -9.49781388e-02f, 6.42339960e-02f,
  -6.90747872e-02f, 2.19871864e-01f, 2.04548374e-01f, 1.20172940e-01f, 2.13822737e-01f, -1.93063188e-02f, -1.92392841e-01f, -2.95674175e-01f, 1.06495112e-01f, 2.08244890e-01f,
  1.73644617e-01f, 4.91767787e-05f, 1.45529667e-02f, -7.26329163e-02f, -3.10731590e-01f, 2.90909801e-02f, 1.40301257e-01f, -6.73899129e-02f, -4.55680877e-01f, -3.30868185e-01f,
  2.84166057e-02f, -4.48740423e-02f, -1.83396980e-01f, -4.34296504e-02f, 1.85139343e-01f, 4.84058000e-02f, 2.86852896e-01f, 2.27938071e-01f, 1.81232899e-01f, 4.18165475e-01f,
  1.02274731e-01f, 1.75800070e-01f, -2.62086421e-01f, -6.89830258e-02f, 2.18649060e-01f, -1.07459268e-02f, 4.58057690e-03f, 1.66673005e-01f, 3.43000097e-03f, 1.91986319e-02f,
  2.55283624e-01f, 6.84870854e-02f, 1.69520900e-01f, -1.00065351e-01f, -1.45559505e-01f, -2.57947654e-01f, -8.51496160e-02f, -2.93558985e-01f, -1.94860995e-01f, -1.22509338e-01f,
  5.31051122e-02f, -2.57976390e-02f, -3.82302180e-02f, -2.14088708e-01f, -1.68982111e-02f, -1.46980718e-01f, -2.53670607e-02f, -8.31480026e-02f, -1.45647287e-01f, -3.39030549e-02f,
  -6.16158545e-02f, 2.09480412e-02f, 3.60601470e-02f, 5.97789586e-02f, -6.44152611e-02f, 1.94831178e-01f, 1.70067117e-01f, -6.16954230e-02f, -5.44088446e-02f, -7.25536048e-02f,
  7.87236542e-02f, 5.29100485e-02f, 1.12961300e-01f, -2.40317043e-02f, 1.28746122e-01f, 5.35828024e-02f, 8.05734172e-02f, -1.63466245e-01f, -1.22712620e-01f, 2.44464092e-02f,
  6.11624308e-02f, 1.71271756e-01f, 2.32045025e-01f, -5.30534387e-02f, -3.85820791e-02f, -6.03783429e-02f, 8.62430334e-02f, 4.81303595e-02f, -4.87017035e-02f, 3.12064923e-02f,
  1.94392260e-02f, -1.23930648e-01f, 4.89882119e-02f, -2.74179410e-02f, 6.93550557e-02f, 3.98909301e-02f, 5.85617460e-02f, -1.37914360e-01f, 1.16646312e-01f, -2.49845445e-01f,
  -3.13841514e-02f, -6.12041093e-02f, 1.68865263e-01f, -9.21648964e-02f, -1.51484132e-01f, -7.34304637e-02f, 5.38170226e-02f, 3.86675298e-02f, -8.53566602e-02f, 4.41893190e-02f,
  -9.83907492e-04f, -2.64808476e-01f, -2.89899498e-01f, -1.43524051e-01f, 5.01703508e-02f, -2.43105993e-01f, -1.76066905e-01f, -1.99749812e-01f, -1.85815528e-01f, -2.37056196e-01f,
  5.94374418e-01f, -9.63947400e-02f, -3.16778600e-01f, 2.55893588e-01f, -2.78603643e-01f, -3.18275601e-01f, -5.46512492e-02f, 1.72798410e-01f, 2.16351613e-01f, 4.20177132e-02f,
  -2.53256261e-01f, -3.77652675e-01f, -3.49739760e-01f, -2.90878713e-01f, -1.50845036e-01f, 2.25696012e-01f, 1.38674766e-01f, 2.06628423e-02f, -6.50567487e-02f, -1.20725088e-01f,
  8.26329887e-02f, 4.15253848e-01f, 4.15792763e-01f, 9.00478363e-02f, -3.05181537e-02f, -1.58502445e-01f, 3.66370790e-02f, -3.44548337e-02f, -1.19758092e-01f, -3.47085036e-02f,
  -2.52170354e-01f, 3.39082107e-02f, -2.97273993e-01f, -5.01116216e-02f, -1.68753833e-01f, 4.65333015e-02f, -1.49788335e-01f, -7.32406043e-03f, -1.02876998e-01f, -1.91993974e-02f,
  -3.90125036e-01f, -1.75234333e-01f, -3.11123163e-01f, -9.22179893e-02f, 1.10062785e-01f, -8.93126205e-02f, 1.57845885e-01f, 6.67234436e-02f, 1.31502420e-01f, -1.15518034e-01f,
  -2.27498978e-01f, -1.39596313e-01f, -1.71063185e-01f, -4.66942787e-02f, -1.25511944e-01f, -1.93893060e-01f, -1.14877135e-01f, -2.34030396e-01f, -1.13745518e-01f, 3.23377281e-01f,
  7.87938759e-02f, 1.60749465e-01f, -1.93659067e-02f, 9.90990549e-02f, 3.35305147e-02f, 1.29628321e-02f, 8.12423825e-02f, 3.82136204e-03f, -1.55509934e-01f, -1.31806135e-01f,
  -5.04800789e-02f, -3.75269018e-02f, -8.55704248e-02f, -9.98825505e-02f, 5.02064228e-02f, -2.79569272e-02f, -8.84875059e-02f, 7.17436522e-02f, 6.52893446e-03f, 4.24346440e-02f,
  -1.78959277e-02f, -6.92835003e-02f, -8.24569687e-02f, 1.81494895e-02f, 8.22027326e-02f, 1.67219825e-02f, -1.27623156e-02f, -1.00890785e-01f, 3.30598764e-02f, 4.22323570e-02f,
  2.35683918e-01f, -1.87658742e-01f, -9.57097043e-04f, -1.44001022e-01f, -1.96058024e-02f, -1.02576032e-01f, -2.13755406e-02f, -9.95166153e-02f, 1.31711792e-02f, -2.92667359e-01f,
  -3.30445200e-01f, -1.76129818e-01f, -1.31578386e-01f, -2.21825726e-02f, -4.36791778e-02f, -1.12428702e-01f, 5.63735189e-03f, -7.84510076e-02f, 5.98065928e-02f, 1.63281746e-02f,
  1.58276945e-01f, 2.49415934e-01f, 1.86574593e-01f, -5.94654819e-03f, 5.62851541e-02f, -1.56473443e-02f, 9.35245529e-02f, 1.28463343e-01f, 7.30326250e-02f, 4.76682633e-01f,
  1.83962792e-01f, -3.81784230e-01f, 2.93786195e-03f, -6.76311180e-02f, -3.11439157e-01f, -3.28110129e-01f, -4.80773926e-01f, -2.42695451e-01f, -6.96629360e-02f, -1.97689548e-01f,
  -1.26407772e-01f, -1.05544599e-03f, 7.52825737e-02f, 4.43522707e-02f, 1.94871351e-02f, -3.10619086e-01f, -2.07148343e-01f, 2.19900891e-01f, 1.94467738e-01f, -1.73262462e-01f,
  -1.68873191e-01f, 8.40231031e-03f, 1.54693529e-01f, 8.90027434e-02f, -9.18803886e-02f, -1.46623001e-01f, -1.32720813e-01f, -3.37978452e-02f, -2.90627033e-01f, -3.00231993e-01f,
  -3.21422547e-01f, -7.79412687e-03f, 1.22521318e-01f, 2.21258342e-01f, 1.14564076e-01f, 6.16363809e-02f, 2.48341151e-02f, 7.60223940e-02f, 1.17631800e-01f, 7.29525611e-02f,
  -1.70190074e-02f, 1.38634399e-01f, 7.65155628e-02f, 4.09942120e-02f, 1.26056327e-02f, 1.15075223e-01f, 1.21548988e-01f, 6.46796003e-02f, -1.28686860e-01f, -1.60180330e-02f,
  -2.99719814e-03f, -2.67681796e-02f, -1.21412762e-01f, 3.26713771e-02f, -4.21840884e-02f, 1.55833773e-02f, 3.90736386e-02f, -1.11850500e-02f, 8.13668072e-02f, -1.79473653e-01f,
  2.96193641e-02f, -6.49544671e-02f, -1.12581849e-01f, -8.85389373e-02f, -1.13866620e-01f, 1.53109683e-02f, -8.34485963e-02f, -1.00963257e-01f, -1.34979617e-02f, 5.37812896e-02f,
  -1.11396052e-01f, -1.78023383e-01f, -1.67749058e-02f, -1.02087125e-01f, 4.16314751e-02f, -1.19591251e-01f, -1.40813544e-01f, -3.34294885e-02f, 1.15285665e-01f, 1.02287298e-03f,
  -3.26004326e-02f, -6.69690594e-02f, 1.07914805e-01f, -9.94678512e-02f, 6.49304362e-03f, -5.45609444e-02f, -3.57869454e-02f, 3.30062374e-03f, 2.00766101e-02f, -4.76817004e-02f,
  -1.33314922e-01f, 1.10166036e-01f, -1.25320759e-02f, 5.49719222e-02f, 2.53914706e-02f, 1.71547264e-01f, 5.51659800e-02f, 1.02742448e-01f, 2.05659047e-02f, 1.79232154e-02f,
  1.83761902e-02f, 1.43904760e-01f, 1.22649848e-01f, 2.74718553e-02f, 6.66829422e-02f, 1.48598015e-01f, 1.54727593e-01f, 8.90860520e-03f, -6.95176050e-02f, 5.48052490e-02f,
  8.80265757e-02f, -1.13395192e-01f, -2.97827329e-02f, -5.54883145e-02f, 1.60866859e-03f, 6.46175146e-02f, -1.04736984e-01f, -9.40783471e-02f, -7.22025707e-02f, -4.23824340e-02f,
  6.84048533e-01f, -2.00010762e-01f, -4.67975855e-01f, -6.35203049e-02f, -7.39678890e-02f, 9.33867097e-02f, 9.97011140e-02f, 1.79704756e-01f, 7.17823207e-02f, -1.46187633e-01f,
  -6.99889213e-02f, 9.23407003e-02f, -1.35372788e-01f, -7.96539560e-02f, 3.81954722e-02f, -1.10332750e-01f, -2.50541091e-01f, -6.56505227e-02f, 9.38249975e-02f, 8.82852376e-02f,
  5.14541753e-02f, 9.07659829e-02f, 7.73641542e-02f, -8.83734152e-02f, -2.52379566e-01f, -5.28422147e-02f, -3.39405656e-01f, -2.17856184e-01f, -2.20101163e-01f, -3.08828741e-01f,
  -3.09890598e-01f, -1.85542807e-01f, 1.27076283e-01f, 3.36294137e-02f, -4.56741303e-02f, 8.01939070e-02f, -1.04444418e-02f, 1.78449345e-03f, -4.57544848e-02f, -5.91862760e-02f,
  -4.95611280e-02f, 7.04669207e-02f, -2.14572120e-02f, 7.23827332e-02f, 8.72769803e-02f, -7.29804933e-02f, 3.51376049e-02f, 6.64470345e-02f, -3.68040754e-03f, -1.31797343e-01f,
  -9.87914577e-02f, 3.79763148e-03f, 3.75341699e-02f, 1.67255700e-01f, 1.63061563e-02f, 2.19830684e-02f, -7.85151683e-03f, 7.68129826e-02f, 1.00508720e-01f, 1.19837686e-01f,
  -2.66664207e-01f, 1.16572864e-01f, 1.06943585e-01f, 1.56610057e-01f, 1.87381998e-01f, 5.87172918e-02f, 9.92537439e-02f, 2.24278331e-01f, 2.85147488e-01f, 1.98678404e-01f,
  1.11532532e-01f, 4.26235087e-02f, 1.10487103e-01f, 2.35596541e-02f, -1.02466710e-01f, -7.86740184e-02f, -5.31104431e-02f, -7.64867365e-02f, 5.05847521e-02f, 3.04458309e-02f,
  1.03509426e-01f, -1.56236789e-03f, -1.28691971e-01f, -8.11140686e-02f, -1.95052058e-01f, -1.28569886e-01f, -1.19764216e-01f, -1.02017067e-01f, -2.66535617e-02f, -7.95443803e-02f,
  -1.04843890e-02f, -7.52272829e-02f, 3.51054333e-02f, 8.27956945e-02f, -1.20194532e-01f, -7.22523630e-02f, -1.05914205e-01f, 4.19108989e-03f, -9.94761884e-02f, -1.48607731e-01f,
  7.80364573e-02f, 1.08874582e-01f, -5.08383065e-02f, 4.29624096e-02f, 1.38723120e-01f, 1.27419531e-01f, -7.91588798e-03f, 1.35575429e-01f, -1.34095959e-02f, -9.05598775e-02f,
  -6.37420416e-02f, 2.33517945e-01f, 1.43056691e-01f, 1.18292965e-01f, 9.64443162e-02f, 1.77954555e-01f, 1.13443784e-01f, 1.15564398e-01f, 1.17702335e-01f, 2.76175261e-01f,
  -3.01171273e-01f, 5.09883285e-01f, 1.27496436e-01f, -1.94688812e-01f, 1.46906510e-01f, 2.00121492e-01f, 4.70507920e-01f, 1.42941788e-01f, -2.70061821e-01f, 1.13054968e-01f,
  3.07278365e-01f, -4.67641167e-02f, -2.30428064e-03f, 1.69693958e-02f, 1.85713582e-02f, 1.27962485e-01f, 1.78330556e-01f, -1.23543665e-01f, -1.68544009e-01f, -1.52605986e-02f,
  8.39030147e-02f, -1.79116964e-01f, -1.42624974e-01f, -1.13063760e-01f, -8.12586620e-02f, -2.41090506e-01f, 1.00135267e-01f, 3.19676027e-02f, 2.76944131e-01f, -5.93171008e-02f,
  -1.39097884e-01f, 1.65573806e-01f, -2.10225493e-01f, -1.65719733e-01f, -1.68140288e-02f, -1.99210897e-01f, -4.45547141e-02f, -6.33895248e-02f, 1.01014853e-01f, -8.66799951e-02f,
  2.66888961e-02f, 3.70225422e-02f, -1.99624039e-02f, -2.47357152e-02f, -1.19798435e-02f, -9.65203047e-02f, -1.73845172e-01f, -2.69911438e-01f, -2.60770977e-01f, -1.60419762e-01f,
  1.84874251e-01f, 2.09385842e-01f, 1.49010688e-01f, 1.15886040e-01f, -1.87526606e-02f, -2.78202415e-01f, 3.14145014e-02f, -3.58016789e-02f, 8.42581615e-02f, -2.90523082e-01f,
  -6.89051999e-03f, 1.30448565e-01f, 9.48160738e-02f, 5.84224239e-02f, -5.67708202e-02f, 1.80087239e-03f, 3.28860758e-03f, -7.27718044e-03f, -1.40924808e-02f, 5.20571508e-02f,
  -9.43576470e-02f, -1.47064909e-01f, 4.33388129e-02f, -2.07129475e-02f, 8.91218930e-02f, 2.55463049e-02f, 9.67808589e-02f, 1.08976560e-02f, -2.49057468e-02f, 3.52021074e-03f,
  6.14414662e-02f, -4.19581383e-02f, -4.36925776e-02f, -1.18241936e-01f, 8.96448418e-02f, -7.96565935e-02f, -8.38621706e-02f, -4.63685393e-02f, 6.94626570e-02f, 1.43604338e-01f,
  -2.25403205e-01f, 2.94186324e-01f, -2.16167867e-01f, 9.91098806e-02f, 2.07971737e-01f, 9.07985345e-02f, 9.44671407e-02f, 6.61093295e-02f, 1.38053700e-01f, -1.06235534e-01f,
  -8.12386349e-02f, 5.33676185e-02f, 5.67856170e-02f, -1.57968402e-01f, -1.25288352e-01f, 5.50717711e-02f, 8.24816599e-02f, -6.49363697e-02f, 6.73443219e-03f, -7.33075514e-02f,
  -3.78633626e-02f, -8.38703215e-02f, -3.25073957e-01f, -8.93714000e-03f, -1.17251668e-02f, -1.00393713e-01f, -3.27160917e-02f, -5.24556674e-02f, -8.94259587e-02f, -1.93390757e-01f,
  -7.01043308e-01f, -2.96122581e-01f, 6.99477782e-03f, -5.20350814e-01f, -1.33083552e-01f, 2.17306882e-01f, 2.64201701e-01f, -5.78931607e-02f, -2.90288597e-01f, -1.66044042e-01f,
  -5.10313995e-02f, -7.66707659e-02f, -2.15425313e-01f, 6.60227761e-02f, 6.46561012e-02f, -8.35572742e-03f, -1.49858117e-01f, -3.54591012e-02f, 1.91337883e-01f, 3.31926733e-01f,
  1.51492149e-01f, -2.55665749e-01f, -2.07835808e-01f, -1.49543941e-01f, -3.70027095e-01f, -9.75159332e-02f, -1.91212371e-01f, -2.40540192e-01f, 9.95990634e-02f, -3.33164632e-01f,
  9.98450443e-02f, -1.59350708e-01f, 7.83957243e-02f, -5.18133305e-02f, -4.55079637e-02f, -6.87564090e-02f, -1.37640222e-03f, -1.21424101e-01f, -4.11280766e-02f, -1.17034905e-01f,
  -9.76346508e-02f, 1.80509873e-03f, -1.74649805e-01f, -1.00038335e-01f, -1.54221142e-02f, 6.90932991e-03f, -1.37046367e-01f, -7.50898793e-02f, 2.29949113e-02f, 1.56696364e-02f,
  -1.24919321e-02f, 3.37237455e-02f, 8.06847122e-03f, -3.78915668e-02f, 7.46850222e-02f, 9.00223330e-02f, 1.08308151e-01f, 1.20508164e-01f, 6.48575872e-02f, -1.44428551e-01f,
  2.34316904e-02f, -1.34607881e-01f, -4.54121977e-02f, -5.30448221e-02f, 7.07698017e-02f, -5.29352687e-02f, 2.75487266e-03f, -4.89271581e-02f, -1.99188162e-02f, 2.04212777e-02f,
  -5.72609976e-02f, 4.59065959e-02f, -2.76159812e-02f, 5.93457073e-02f, -1.67807434e-02f, 5.05484594e-03f, 5.66016249e-02f, 4.87090461e-02f, 5.39312288e-02f, -5.21270111e-02f,
  -5.33114709e-02f, 6.38838038e-02f, -1.44052564e-03f, 4.86064106e-02f, 4.18075882e-02f, -6.11484237e-02f, 7.67189935e-02f, 7.55281746e-02f, 1.69107448e-02f, -1.08038597e-01f,
  -3.79438192e-01f, 1.24964789e-01f, -5.03445268e-02f, 3.10073141e-02f, -5.44533506e-02f, 5.03914356e-02f, -9.66805890e-02f, 7.42791668e-02f, -1.03093274e-01f, 6.09045886e-02f,
  1.14780441e-01f, 8.13071802e-03f, -1.52411750e-02f, -1.24308160e-02f, 6.14390261e-02f, 6.16642050e-02f, -3.98067199e-02f, -7.29202703e-02f, 1.35452434e-01f, -2.42636539e-02f,
  3.04610133e-02f, 9.64510348e-03f, -8.09986666e-02f, 8.24480206e-02f, 2.28254497e-02f, 1.58231944e-01f, 1.63409650e-01f, 9.60602704e-03f, 8.69507864e-02f, -7.10209757e-02f,
  -2.02546746e-01f, -3.50256450e-02f, -3.43064129e-01f, -3.27691674e-01f, -2.76888788e-01f, -2.82446623e-01f, -2.96167612e-01f, 1.10168613e-01f, -5.76682799e-02f, -1.81110069e-01f,
  -8.24383199e-02f, -4.55672927e-02f, -1.16585426e-01f, -2.09297672e-01f, -8.08376670e-02f, -5.31895496e-02f, -1.70688778e-01f, -2.54910082e-01f, -3.09925884e-01f, -4.01032835e-01f,
  -2.92949557e-01f, -1.01456456e-01f, -1.31997928e-01f, 2.40558460e-02f, -3.36857848e-02f, -7.99961388e-02f, -7.39972144e-02f, -1.93359882e-01f, -4.68780994e-02f, -9.70983431e-02f,
  6.52788132e-02f, -2.69887093e-02f, 1.17170773e-02f, -1.18474104e-01f, -9.36677083e-02f, -1.00743324e-02f, -1.58923179e-01f, 1.48765132e-01f, -1.36292323e-01f, -2.43148603e-03f,
  -2.20860705e-01f, -1.39738038e-01f, -1.50731906e-01f, 2.37153359e-02f, -1.56397015e-01f, -8.04447085e-02f, -2.29063407e-01f, -1.57429293e-01f, -1.72875971e-01f, -7.61938542e-02f,
  -2.13221714e-01f, -2.52990425e-01f, -8.53293091e-02f, -6.12658150e-02f, 5.03964573e-02f, -1.52562752e-01f, 3.68303470e-02f, -4.44807298e-02f, 8.78366232e-02f, 3.42162848e-01f,
  5.90042386e-04f, 8.76566619e-02f, -1.66016713e-01f, -4.26476970e-02f, -4.88858894e-02f, 1.18631013e-01f, 1.33802444e-01f, 1.07117981e-01f, 2.09269673e-02f, -1.16652483e-02f,
  6.49639815e-02f, 1.14668943e-01f, -2.96031833e-02f, 4.01925333e-02f, -5.67477196e-02f, -1.66654348e-01f, 3.56606133e-02f, -6.89949170e-02f, 5.36572747e-02f, 2.33772155e-02f,
  -8.00061300e-02f, 7.64309764e-02f, 1.18407030e-02f, 1.14123762e-01f, -5.17254695e-02f, 1.87427830e-02f, 4.70014662e-03f, 9.47858840e-02f, -7.52761215e-02f, -7.79751614e-02f,
  1.79625452e-01f, -7.91388601e-02f, -4.16763946e-02f, -2.13196892e-02f, -5.02804965e-02f, -4.42379067e-04f, -5.57705164e-02f, 1.11171797e-01f, 7.57236481e-02f, -2.12652306e-03f,
  -1.95678651e-01f, 8.56763422e-02f, -4.64401692e-02f, 1.59361795e-01f, -2.79875342e-02f, -9.45009664e-02f, -3.94121818e-02f, -1.32431164e-01f, -4.63376120e-02f, -3.37400176e-02f,
  -1.06489651e-01f, -5.14319353e-02f, -4.43632156e-02f, 3.04615535e-02f, 2.55513526e-02f, -1.31659538e-01f, 2.23386809e-01f, 7.94867948e-02f, 7.51072019e-02f, 2.99700588e-01f,
  -5.07435620e-01f, -1.60535306e-01f, -1.89418197e-01f, 1.64999261e-01f, 2.06697553e-01f, -6.52393401e-02f, -3.30262214e-01f, -1.42324880e-01f, 1.13349833e-01f, -1.63224861e-01f,
  1.21542074e-01f, 1.28482282e-01f, 9.83489603e-02f, -7.29113026e-03f, -1.22450046e-01f, 3.02635077e-02f, 1.46074966e-01f, -1.40912503e-01f, -1.55607715e-01f, -3.17958258e-02f,
  3.03266019e-01f, 1.00412071e-02f, -1.34559318e-01f, 5.55303544e-02f, 2.60414451e-01f, 1.19456202e-01f, 6.23369627e-02f, 4.94500175e-02f, 1.54663488e-01f, 1.04181752e-01f,
  -1.11701824e-01f, -1.88752741e-01f, 7.98204541e-02f, 2.31376529e-01f, 1.48141831e-01f, -2.41681978e-01f, -4.24694195e-02f, -4.31047417e-02f, -3.97936776e-02f, -1.68954283e-01f,
  2.36551762e-02f, -6.18552305e-02f, 1.41496450e-01f, 7.52365142e-02f, -1.22659013e-01f, -1.14697434e-01f, -8.49799365e-02f, -2.08911851e-01f, -3.19924682e-01f, -1.38736293e-01f,
  2.67795444e-01f, 1.00319900e-01f, -5.36713526e-02f, -1.42258644e-01f, -1.75352007e-01f, 4.42650169e-02f, -1.34396121e-01f, -1.45769000e-01f, -3.68800342e-01f, -3.86966377e-01f,
  1.99131444e-02f, 1.03167094e-01f, -7.99381733e-02f, -3.27658392e-02f, -4.98548709e-02f, 1.02421850e-01f, 1.86078772e-01f, 2.75034271e-02f, 1.59519017e-01f, -1.19685955e-01f,
  6.17572293e-02f, 6.81991596e-03f, 4.55877520e-02f, -1.19279632e-02f, 3.52987386e-02f, -3.54624800e-02f, 1.10313930e-02f, -1.09319806e-01f, 1.97321898e-03f, -9.11115929e-02f,
  -9.21859220e-03f, 4.37560603e-02f, 1.09797843e-01f, 6.20826036e-02f, -3.54789160e-02f, -1.43691361e-01f, -1.20891079e-01f, -6.42741546e-02f, -2.22216565e-02f, -1.04472630e-01f,
  -6.37234822e-02f, 1.77190572e-01f, -6.15510568e-02f, 1.12873144e-01f, 1.75335884e-01f, 9.68040749e-02f, -4.81534600e-02f, -1.00446671e-01f, 1.73832849e-02f, -1.36961922e-01f,
  -1.41898066e-01f, -1.74279198e-01f, 4.91998680e-02f, 9.19276550e-02f, -2.72726230e-02f, -2.74113417e-02f, 5.72597645e-02f, 2.85683274e-02f, 2.28711721e-02f, 4.64511290e-02f,
  8.77325013e-02f, -2.10081562e-01f, -2.28705689e-01f, -1.50596514e-01f, 5.53235300e-02f, -6.46010637e-02f, -8.64120424e-02f, -1.88665524e-01f, -9.22149569e-02f, -4.25286055e-01f,
  3.77963781e-01f, -2.94481128e-01f, -3.14788014e-01f, 3.77605110e-01f, 1.07552089e-01f, -1.96529314e-01f, -4.28424656e-01f, -6.17182069e-02f, 2.53419846e-01f, -1.93258420e-01f,
  1.46522209e-01f, 3.40647995e-01f, -2.88455281e-02f, -8.98521319e-02f, -2.35948861e-01f, -4.84973162e-01f, -4.23108071e-01f, -8.02766234e-02f, -7.10690767e-02f, 1.60329387e-01f,
  1.83014452e-01f, 1.88855067e-01f, 9.43603832e-03f, -5.67382909e-02f, 1.67831674e-01f, 4.60841209e-02f, -1.80793658e-01f, 1.96289527e-03f, -1.99806482e-01f, -1.19826674e-01f,
  -4.35816012e-02f, 6.87358454e-02f, -6.56860992e-02f, 2.98301950e-02f, 1.02158293e-01f, -3.89881060e-02f, -8.08672383e-02f, 1.33226346e-02f, -4.98534329e-02f, -8.76246840e-02f,
  7.11093396e-02f, -1.36179775e-02f, 1.00449234e-01f, 1.06243305e-01f, -9.80725791e-03f, 7.25358650e-02f, -2.16621622e-01f, -1.63803503e-01f, -1.96878016e-01f, -4.90562730e-02f,
  -3.22284624e-02f, 1.30826319e-02f, -8.80327225e-02f, -2.33877510e-01f, -1.11067310e-01f, 1.42858282e-01f, -1.59378901e-01f, 1.46666408e-01f, -2.08522409e-01f, -1.84204772e-01f,
  -2.02016905e-02f, -2.56425235e-02f, -1.65124871e-02f, 4.24931059e-03f, 1.50657237e-01f, 4.36226912e-02f, -1.93616394e-02f, 3.67627144e-02f, 1.26454048e-02f, -3.71281207e-02f,
  3.17711867e-02f, -9.56974179e-02f, -1.90748344e-03f, -8.06638524e-02f, -6.76512271e-02f, -3.20583619e-02f, -3.03034130e-02f, -6.99231327e-02f, -9.90792066e-02f, 8.26996118e-02f,
  5.23724370e-02f, -1.04636788e-01f, 5.48349135e-02f, 6.42678002e-03f, -1.03997037e-01f, -6.02539890e-02f, 4.09026854e-02f, 4.00843583e-02f, -3.21019068e-02f, -4.30588201e-02f,
  2.40868822e-01f, -7.82966018e-02f, -1.31483480e-01f, -7.78931975e-02f, -5.89311384e-02f, -7.26710707e-02f, 2.93721966e-02f, -8.82545635e-02f, 5.92427962e-02f, 1.39837235e-01f,
  -1.10207193e-01f, -3.63342697e-03f, -5.21467775e-02f, -5.02672186e-03f, -1.57692302e-02f, -6.02001045e-03f, -2.07328260e-01f, -3.66842225e-02f, -1.56932846e-01f, 3.05042952e-01f,
  -7.10486919e-02f, -2.55657494e-01f, 1.03797466e-01f, -7.13746548e-02f, -7.97765926e-02f, -2.15065945e-02f, -1.72757283e-01f, -4.18958142e-02f, -2.21819192e-01f, -2.87239909e-01f,
  5.37121236e-01f, -3.32429379e-01f, -2.69488811e-01f, 5.55911884e-02f, 7.29968995e-02f, 1.26811787e-01f, -2.15912871e-02f, 2.47202933e-01f, 1.54462308e-01f, 4.18695211e-02f,
  1.22076213e-01f, 3.24864715e-01f, 2.08080724e-01f, 2.01005861e-01f, 1.33425221e-01f, -1.15078703e-01f, -2.28053346e-01f, 3.51920612e-02f, 3.45214456e-01f, 2.32219160e-01f,
  7.71701755e-03f, -1.36104673e-02f, 1.40189260e-01f, 3.01203635e-02f, -2.27041781e-01f, -7.13112652e-02f, -3.06994408e-01f, -1.59905791e-01f, -1.99018911e-01f, -3.40507925e-01f,
  -2.53951907e-01f, -8.93265903e-02f, 9.60296392e-02f, -3.19371969e-02f, -1.89634934e-01f, 6.26515150e-02f, 5.17315380e-02f, -8.57584402e-02f, -6.61996081e-02f, -1.32961750e-01f,
  -1.54899389e-01f, -1.05309986e-01f, -8.34518671e-02f, -5.17413430e-02f, -1.40937433e-01f, 1.20635715e-03f, -1.04243703e-01f, -9.97491628e-02f, -7.11025074e-02f, -5.81352338e-02f,
  -4.81380075e-02f, 2.62702554e-02f, -9.35490057e-02f, 8.52089655e-03f, 1.44801542e-01f, 2.96342298e-02f, -1.23672031e-01f, -5.35735786e-02f, 6.30347654e-02f, -5.78259304e-02f,
  -8.23029876e-02f, -4.33286279e-02f, 1.37960166e-01f, 1.06314033e-01f, 2.37196058e-01f, 3.97066139e-02f, 1.48407063e-02f, 9.36079696e-02f, 1.33135274e-01f, 3.06876004e-02f,
  -5.54256402e-02f, -1.95412710e-03f, -1.57179479e-02f, 4.33632806e-02f, 4.71252352e-02f, -1.02367960e-01f, -6.36427179e-02f, 1.29813030e-01f, -3.15846950e-02f, 8.37761462e-02f,
  1.09662622e-01f, -8.73351991e-02f, -1.78110346e-01f, -7.93789029e-02f, 6.92793727e-02f, -7.41473734e-02f, -6.82487115e-02f, -2.05838140e-02f, 2.12272797e-02f, -2.03308426e-02f,
  -8.90784338e-02f, 1.86525971e-01f, 3.22268605e-02f, -7.75132924e-02f, -1.46002471e-01f, -7.62037784e-02f, 1.45108188e-02f, -6.82653114e-02f, 1.71837658e-02f, -7.20812082e-02f,
  -5.48217185e-02f, -7.67849386e-02f, -7.06298724e-02f, -4.59197573e-02f, 1.40270948e-01f, 7.99428746e-02f, 5.53001314e-02f, -2.69675348e-02f, 2.24310998e-02f, -4.18664590e-02f,
  -7.86204562e-02f, 7.72392750e-02f, 1.12128451e-01f, 6.92974702e-02f, 1.59041762e-01f, 2.73069650e-01f, 6.28398210e-02f, 5.58717363e-02f, 1.55056342e-01f, -7.32846651e-03f,
  -4.27559584e-01f, -3.65793109e-01f, 4.15603220e-01f, -1.88094243e-01f, -1.45133480e-01f, -1.35487795e-01f, -2.14026794e-01f, -1.35453984e-01f, 1.61567319e-03f, -1.98348194e-01f,
  -2.55448133e-01f, -2.82797724e-01f, -7.13507906e-02f, 6.73725829e-02f, 1.55321406e-02f, -2.38776114e-02f, 2.58378685e-01f, 3.49643558e-01f, 1.58554658e-01f, -2.67204463e-01f,
  -3.61570656e-01f, 3.24897356e-02f, 2.02429578e-01f, 1.40606746e-01f, -1.74242094e-01f, -3.78255174e-02f, 2.76692748e-01f, -2.61157826e-02f, 3.58207896e-03f, -1.31509244e-01f,
  -3.20491016e-01f, -7.51381069e-02f, 1.51003569e-01f, -1.93111151e-01f, -1.11908659e-01f, -4.03013490e-02f, -9.64430347e-02f, 1.54082015e-01f, -5.32812178e-02f, 8.05325061e-02f,
  -1.53013557e-01f, -2.26987768e-02f, -1.45109028e-01f, -9.07709450e-02f, -8.18754584e-02f, -1.54697865e-01f, 1.71056241e-01f, 2.96999067e-01f, 2.52800256e-01f, -2.29738548e-01f,
  -3.06889713e-01f, -3.31407338e-01f, -1.06243864e-01f, 4.89263460e-02f, 1.26102209e-01f, 6.71050623e-02f, 1.41028747e-01f, -1.17896713e-01f, 2.08006874e-01f, -9.14689749e-02f,
  7.26569891e-02f, -1.14297122e-02f, 9.14648268e-03f, 5.13519607e-02f, -7.51420623e-03f, 8.63574911e-03f, 1.12101518e-01f, -1.52952254e-01f, 5.65178134e-02f, -5.28068729e-02f,
  -2.24497006e-03f, 5.57179227e-02f, 2.35717576e-02f, 3.59614915e-03f, 5.69107719e-02f, 1.44610824e-02f, 4.80142608e-02f, -5.87868169e-02f, 1.10315032e-01f, 7.19768256e-02f,
  -1.18040862e-02f, 1.08571284e-01f, 1.41123459e-01f, -1.48455231e-02f, 5.91594055e-02f, 2.20702633e-01f, -5.48596829e-02f, 7.93547630e-02f, 4.68238071e-02f, -2.10650079e-02f,
  -1.67643830e-01f, 2.44161770e-01f, -2.53477156e-01f, -8.51264745e-02f, -1.54300675e-01f, 5.49420379e-02f, -2.13004854e-02f, -2.48226672e-02f, -2.07073912e-02f, 3.55833471e-02f,
  -3.81442830e-02f, -1.12722367e-01f, -4.84811142e-02f, 3.82522829e-02f, -1.37282714e-01f, -1.19641215e-01f, -2.43300036e-01f, -1.57771230e-01f, 5.19741960e-02f, -1.51229039e-01f,
  -6.75180405e-02f, -2.71161914e-01f, -4.02563363e-01f, -2.75774032e-01f, -1.80328012e-01f, -1.32935748e-01f, -1.02158688e-01f, -2.58993000e-01f, -2.00723693e-01f, -3.34748358e-01f,
  -4.00208294e-01f, 8.45823884e-02f, -1.91851392e-01f, 2.42999673e-01f, 2.87399739e-01f, 1.81281924e-01f, 1.17261432e-01f, 8.84445980e-02f, 1.75114438e-01f, -1.07155358e-02f,
  1.62268117e-01f, 2.18435720e-01f, 2.32916445e-01f, 1.14765480e-01f, 8.72022882e-02f, 1.74755245e-01f, 1.48473501e-01f, -4.66780029e-02f, -1.62752017e-01f, -9.23990905e-02f,
  2.26785645e-01f, 9.52132866e-02f, -1.07377954e-01f, -7.74531513e-02f, 1.29791051e-01f, 1.70918047e-01f, 1.13940880e-01f, -1.77944303e-02f, 1.42425641e-01f, -3.01884245e-02f,
  -1.62002683e-01f, -1.30871668e-01f, 1.00937365e-02f, -2.97055743e-03f, -7.48941228e-02f, -2.41490781e-01f, -1.44176230e-01f, -1.93220824e-01f, -1.08668402e-01f, -5.66744320e-02f,
  -6.73821494e-02f, -2.36695334e-01f, 1.30743712e-01f, -9.60860029e-03f, -1.26962289e-01f, -2.17621103e-01f, -1.13855712e-01f, -2.19396263e-01f, -1.40438914e-01f, -1.51111573e-01f,
  2.63662964e-01f, 2.64091995e-02f, -2.14179847e-02f, -4.15554717e-02f, -5.02858385e-02f, 6.85350224e-02f, -1.34208664e-01f, -1.91151917e-01f, -2.84194499e-01f, -3.53553623e-01f,
  1.02125779e-01f, 8.77119880e-03f, -1.36868944e-02f, -1.66174360e-02f, 1.77862961e-02f, 1.52792120e-02f, 1.13587484e-01f, 4.74767759e-02f, -1.13829710e-02f, -3.32063735e-02f,
  6.56195134e-02f, 9.80555043e-02f, 9.35709476e-03f, -4.38915007e-02f, 8.47797468e-02f, -7.74143729e-03f, -8.20079148e-02f, -5.41027561e-02f, 3.62142076e-04f, -1.52910084e-01f,
  6.88105002e-02f, -1.74987484e-02f, 7.37624168e-02f, 2.75019817e-02f, -9.60287377e-02f, 3.05954320e-03f, -7.36663714e-02f, 6.96120858e-02f, 1.76801793e-02f, 4.54357043e-02f,
  2.00403139e-01f, 1.46504566e-01f, 4.38560136e-02f, 4.08599190e-02f, -8.04496408e-02f, -1.42460003e-01f, 7.48000368e-02f, 2.07570605e-02f, -1.83508324e-03f, -2.32917685e-02f,
  -1.50946319e-01f, -8.37209076e-02f, 1.23909585e-01f, 2.63646035e-03f, -1.18625388e-01f, -2.34876834e-02f, 6.28179312e-02f, 6.70463890e-02f, -3.61516178e-02f, 1.86263807e-02f,
  -1.08584119e-02f, 4.78977449e-02f, -1.23797528e-01f, 4.37009521e-02f, 5.53219169e-02f, 1.49956957e-01f, -5.27171604e-02f, -7.35645220e-02f, -2.95948181e-02f, -1.03423811e-01f,
  -2.34414890e-01f, -7.24317506e-02f, 3.48280013e-01f, -1.37072980e-01f, -6.48754761e-02f, -7.88696259e-02f, -1.66488692e-01f, -2.25716710e-01f, -7.72003680e-02f, 2.45449343e-03f,
  -1.02306955e-01f, -1.78852245e-01f, 2.91441809e-02f, -1.90152470e-02f, -1.78956494e-01f, 1.72423691e-01f, -3.10471989e-02f, -2.52422504e-02f, -3.54029149e-01f, -4.10383612e-01f,
  -3.29139203e-01f, -1.33625463e-01f, -2.94214994e-01f, -9.02280584e-02f, -2.43868846e-02f, -5.18427342e-02f, 1.40197054e-01f, -1.15846302e-02f, -1.61709788e-03f, -6.78756693e-03f,
  3.65233034e-01f, -2.22210407e-01f, -6.64646924e-02f, -3.87390107e-01f, 7.59857222e-02f, -1.84669539e-01f, -3.82070690e-02f, 6.10555429e-03f, -4.43916805e-02f, -7.88539574e-02f,
  -1.98631778e-01f, -1.29746139e-01f, -2.67003775e-01f, -1.74158439e-01f, -1.73930421e-01f, -1.95714086e-01f, -6.59301430e-02f, -1.27299577e-01f, 1.28438950e-01f, 1.09391529e-02f,
  -1.72236279e-01f, -1.08457550e-01f, 1.07015550e-01f, 1.73897475e-01f, 3.94779146e-02f, -5.61026633e-02f, -6.30902546e-03f, -1.30710229e-01f, 4.45775092e-02f, 1.48006260e-01f,
  -2.60111801e-02f, 6.16942979e-02f, 4.14327625e-03f, 7.47425407e-02f, 4.53213640e-02f, 1.24698073e-01f, 1.25390261e-01f, 1.94310434e-02f, 1.39830355e-02f, 1.03291824e-01f,
  -8.48151073e-02f, 1.70830458e-01f, 1.68816611e-01f, 7.08803758e-02f, 3.10323369e-02f, -8.63960460e-02f, -1.21540166e-01f, -1.06203929e-01f, 8.28947946e-02f, -2.87039205e-02f,
  -8.06438252e-02f, -9.56394970e-02f, 2.78597809e-02f, -8.85850657e-03f, -3.64601538e-02f, -7.79746696e-02f, -1.17538929e-01f, -1.60931408e-01f, -1.21839307e-01f, -1.46790594e-01f,
  3.56875598e-01f, -1.00115031e-01f, 1.61038131e-01f, -3.05169560e-02f, 2.06196457e-02f, 6.48304075e-02f, 4.51889187e-02f, -5.59440665e-02f, 4.36484069e-02f, 4.96804938e-02f,
  -3.29300433e-01f, -1.61115140e-01f, 8.08396656e-03f, 9.19237509e-02f, -6.29977882e-02f, -1.70546025e-01f, -1.18437119e-01f, -1.68755390e-02f, -2.23750081e-02f, -1.90866441e-02f,
  -5.68115190e-02f, -1.04057649e-02f, 1.43366084e-01f, 3.42524171e-01f, 8.12361762e-02f, 1.43651694e-01f, 1.13530166e-01f, 1.43148631e-01f, 8.14139470e-02f, 2.02716902e-01f,
  -3.58035117e-01f, -2.69714594e-01f, 2.26418674e-03f, -2.09071323e-01f, 1.42329887e-01f, 7.15060234e-02f, -3.04455191e-01f, -9.72566754e-02f, -1.67930499e-01f, -2.30030671e-01f,
  -1.77463312e-02f, 4.54741009e-02f, -1.17968090e-01f, -6.87450916e-02f, -3.24839085e-01f, -4.68459606e-01f, -2.61441708e-01f, -1.59230232e-01f, 1.45728365e-01f, 1.37059510e-01f,
  2.88743246e-02f, -6.30344674e-02f, 1.87923778e-02f, -1.09391026e-02f, -3.09333093e-02f, 1.33745819e-01f, 1.36242723e-02f, 1.12914175e-01f, 1.05684049e-01f, 6.31347224e-02f,
  -2.36618251e-01f, -5.60324527e-02f, 2.81025499e-01f, 6.13350719e-02f, 1.45586699e-01f, -4.52161469e-02f, -5.80762289e-02f, 5.82634769e-02f, 5.29738702e-02f, -1.34427756e-01f,
  -2.54878514e-02f, -2.15515476e-02f, -4.57623303e-02f, -5.35436943e-02f, -1.14180222e-01f, -1.69993520e-01f, -7.61948675e-02f, -1.31000191e-01f, -9.09847170e-02f, -5.27372360e-02f,
  7.89994653e-03f, -1.21521158e-02f, -9.81985405e-02f, 5.31347245e-02f, -1.89367160e-02f, 1.72011688e-01f, 1.92746356e-01f, 2.69979507e-01f, 1.05978087e-01f, -1.94644421e-01f,
  1.57046705e-01f, 2.97641717e-02f, 7.81430006e-02f, 4.81431931e-02f, -2.37576105e-02f, -1.08638024e-02f, -1.25994697e-01f, -9.44328457e-02f, 7.61988759e-02f, -5.30360155e-02f,
  6.88770115e-02f, 8.94925520e-02f, 1.00349486e-01f, -4.37442586e-02f, 7.03917444e-02f, 5.22688068e-02f, -3.93427461e-02f, 8.96432158e-03f, 1.18254222e-01f, 9.72511023e-02f,
  -5.22041880e-02f, 3.19918357e-02f, -5.66706236e-04f, 9.28658918e-02f, 7.88583327e-03f, -1.04877483e-02f, 6.60726475e-03f, 3.16763222e-02f, -7.80421272e-02f, 2.44571902e-02f,
  -1.19215056e-01f, 2.72382945e-01f, -1.98634386e-01f, 3.40408348e-02f, 6.95166215e-02f, 4.44022641e-02f, 8.51998553e-02f, -5.39291799e-02f, -1.76630706e-01f, -8.03742334e-02f,
  -1.74168032e-02f, -2.06530273e-01f, -2.78799832e-01f, 6.06366545e-02f, 1.18053760e-02f, -5.42336181e-02f, -2.08825484e-01f, -5.13699539e-02f, -1.83130670e-02f, -9.22789425e-02f,
  -2.09382743e-01f, -1.62674844e-01f, -3.40253890e-01f, -1.95622519e-01f, -1.81816489e-01f, -1.90914460e-02f, -8.45295340e-02f, 4.27577272e-02f, 9.64908153e-02f, -2.83019602e-01f,
  -2.31378619e-03f, 4.24178451e-01f, 9.77071300e-02f, -5.04418090e-02f, 1.43261895e-01f, 1.82365179e-01f, 3.48772317e-01f, 2.35153019e-01f, 5.41427452e-03f, 3.11392069e-01f,
  2.12515041e-01f, -4.35458183e-01f, -1.84557170e-01f, -1.91374719e-01f, -4.77317683e-02f, 1.94238484e-01f, 8.85048602e-03f, -2.38767162e-01f, -5.59908211e-01f, -3.37728769e-01f,
  -2.28958353e-01f, -1.93891734e-01f, -2.18956143e-01f, -1.87042788e-01f, 1.11761622e-01f, -2.08661944e-01f, 4.40752991e-02f, 7.75829479e-02f, 2.00774506e-01f, 1.11817978e-01f,
  -1.23706475e-01f, 1.56453237e-01f, -4.64906484e-01f, -2.77560890e-01f, -2.93416120e-02f, -2.34529182e-01f, -2.23306134e-01f, -1.62377536e-01f, -1.63852498e-01f, 9.68295485e-02f,
  -1.48172960e-01f, -1.13333814e-01f, -1.26287654e-01f, -1.48287952e-01f, -1.67372182e-01f, -2.16985136e-01f, -5.54838143e-02f, -1.66723475e-01f, -1.17538720e-01f, 1.58563212e-01f,
  6.67317510e-02f, 1.12277359e-01f, 1.71350196e-01f, 1.74428314e-01f, 6.46234825e-02f, -9.82192308e-02f, 1.18864782e-01f, -9.44656059e-02f, 8.78667906e-02f, 2.30307221e-01f,
  4.23947759e-02f, 4.62943129e-02f, -9.02374834e-02f, 3.48514691e-02f, 2.71354597e-02f, -1.23020001e-01f, -8.27033371e-02f, -7.83996284e-03f, 3.16635557e-02f, -1.27599146e-02f,
  -5.19523583e-02f, 1.13981009e-01f, -9.74113401e-03f, 1.25884295e-01f, -6.31416915e-03f, -8.75029489e-02f, 2.19705645e-02f, 7.99592882e-02f, -2.80264430e-02f, -1.12369910e-01f,
  -5.69059514e-02f, 9.98407826e-02f, 3.00225988e-02f, 4.05678637e-02f, 7.92712420e-02f, -4.38423157e-02f, 2.60280520e-02f, 7.51119182e-02f, 8.05649310e-02f, 9.00472924e-02f,
  -4.49008465e-01f, -6.07121289e-02f, -1.10441983e-01f, -1.55725271e-01f, -3.50410230e-02f, -1.38649970e-01f, -1.70207202e-01f, 8.95558223e-02f, 1.82570711e-01f, 7.45756999e-02f,
  -1.22855216e-01f, -1.72223356e-02f, 1.32552415e-01f, -7.75342865e-04f, -2.09552780e-01f, -4.42674719e-02f, 1.22778220e-02f, 1.39235416e-02f, 4.49324362e-02f, 3.47351581e-02f,
  1.93347186e-01f, -1.84338596e-02f, 8.41214228e-03f, 6.39845356e-02f, 1.55842826e-01f, -9.93854403e-02f, -1.27754927e-01f, -1.88419014e-01f, -1.19212613e-01f, 1.47097960e-01f,
  4.27005768e-01f, -1.44119620e-01f, -4.60643649e-01f, 8.85899365e-03f, -1.47333696e-01f, -1.01399571e-01f, -9.36695337e-02f, 1.85478747e-01f, 1.24788538e-01f, -2.82794237e-01f,
  -2.97973812e-01f, -6.35609999e-02f, -2.91908443e-01f, -8.98272023e-02f, -9.06350315e-02f, -3.57609868e-01f, -2.97186285e-01f, -1.45350054e-01f, 4.46181595e-02f, 2.84576893e-01f,
  1.05694786e-01f, 1.43592477e-01f, 7.64803365e-02f, 4.48207036e-02f, -1.31682575e-01f, -1.13469765e-01f, -3.03774834e-01f, -8.14217255e-02f, -1.84240818e-01f, -3.15835208e-01f,
  -4.19676483e-01f, -1.50450945e-01f, -1.00398831e-01f, 1.08673811e-01f, -1.25928164e-01f, 3.54613811e-02f, -4.63631377e-02f, -8.63669142e-02f, 7.19230026e-02f, -1.00069709e-01f,
  -7.12371618e-02f, 1.59710780e-01f, -5.27327135e-02f, -7.11241513e-02f, -7.22233020e-03f, 4.92958389e-02f, -2.08733249e-02f, 1.51141454e-02f, -1.23494215e-01f, -5.00633158e-02f,
  -5.75291589e-02f, -6.78984299e-02f, -2.76570749e-02f, -3.02679930e-02f, -7.25128427e-02f, 6.41837046e-02f, -1.29526511e-01f, 3.53954397e-02f, 2.10096985e-02f, 5.89087568e-02f,
  -6.22922815e-02f, 1.02041885e-01f, 1.63201198e-01f, 9.43559557e-02f, 8.98500755e-02f, -4.00650650e-02f, -4.14938517e-02f, 1.73169896e-02f, -1.14779808e-02f, 2.40305532e-03f,
  5.01169004e-02f, 8.23455397e-03f, 7.34794140e-02f, -9.77919623e-02f, -1.02462687e-01f, -1.03249796e-01f, -6.01570755e-02f, -6.93068877e-02f, 6.52088504e-03f, 1.58456013e-01f,
  3.79272737e-02f, 1.47830881e-02f, -7.42100403e-02f, -5.42038865e-02f, -1.04181737e-01f, -6.18860275e-02f, -1.06335633e-01f, 7.75401518e-02f, 1.09626986e-01f, 1.97032820e-02f,
  -6.13778085e-02f, -5.70781678e-02f, -1.32818043e-01f, -4.88500437e-03f, -4.98791449e-02f, -4.28019427e-02f, -7.17345253e-02f, 8.78252834e-02f, -5.93800098e-02f, 5.69511438e-03f,
  -5.67812137e-02f, 1.35149099e-02f, -1.16603583e-01f, -3.51435132e-02f, 1.66386381e-01f, 1.19657792e-01f, -8.98086652e-02f, -9.08594877e-02f, 4.50759754e-02f, 5.05035743e-02f,
  -1.08994596e-01f, 1.89350739e-01f, 2.07454458e-01f, 8.47765058e-02f, 5.65383118e-03f, 1.33835092e-01f, 7.63624385e-02f, 9.21482816e-02f, 1.80653110e-01f, 8.09613615e-02f,
  -6.28151596e-02f, -7.41859432e-03f, 3.88546893e-03f, 2.00552627e-01f, 9.35957581e-02f, 4.27252427e-02f, -2.91572846e-02f, 2.37848107e-02f, 2.53620092e-02f, 1.02784514e-01f,
  1.54029354e-01f, 1.61235720e-01f, 2.31675908e-01f, 1.64858982e-01f, 1.85354903e-01f, 1.43537432e-01f, -3.86851723e-03f, 6.79351166e-02f, -4.51249965e-02f, 8.41168985e-02f,
  4.74761091e-02f, -7.83553571e-02f, -2.10678075e-02f, 1.06202461e-01f, -3.44670527e-02f, 1.67391717e-01f, -1.95943825e-02f, -2.63603590e-02f, 6.94705499e-03f, -7.31519684e-02f,
  3.37657750e-01f, 1.83157623e-01f, 4.43347059e-02f, 7.71727338e-02f, 3.82580906e-02f, -5.47100008e-02f, 3.58770154e-02f, -1.17951363e-01f, -9.20952708e-02f, -4.64338101e-02f,
  -1.17479879e-02f, 1.73568097e-03f, 1.72282413e-01f, -6.67241514e-02f, 7.14469850e-02f, 8.43570232e-02f, -3.86479199e-02f, 1.41921774e-01f, -3.37851048e-03f, 1.64931402e-01f,
  1.00685611e-01f, 1.50188372e-01f, 1.11346863e-01f, 2.33788311e-01f, 2.23747283e-01f, 1.60182580e-01f, 1.44201398e-01f, 1.42510891e-01f, 2.10043103e-01f, 7.84748569e-02f,
  2.86178201e-01f, 9.86297615e-03f, 2.23015487e-01f, 8.93783122e-02f, 7.42980540e-02f, 1.14307784e-01f, -8.34382921e-02f, 5.32060415e-02f, 2.30370648e-02f, 3.28256413e-02f,
  7.56547526e-02f, 3.00429910e-01f, -1.22883860e-02f, 9.86352637e-02f, 1.54574439e-01f, 1.09145217e-01f, -2.38190182e-02f, 1.34712070e-01f, 2.43129864e-01f, 9.08402428e-02f,
  2.14738861e-01f, 4.47546877e-02f, 1.08429892e-02f, -1.46562345e-02f, 6.50670305e-02f, 1.83788776e-01f, -5.32554416e-03f, 2.73207910e-02f, -1.81615353e-02f, -5.58083989e-02f,
  1.90419391e-01f, 5.46944916e-01f, 2.58995220e-02f, -3.20014171e-02f, -2.14563519e-01f, -1.07084692e-01f, 1.02683291e-01f, -2.49440894e-01f, -1.73452839e-01f, -5.52559085e-02f,
  1.49623696e-02f, -1.73402444e-01f, -6.41258657e-02f, 3.54334377e-02f, -1.40590802e-01f, -7.09953979e-02f, -6.06203713e-02f, -3.85357030e-02f, -4.19965805e-03f, 1.52619667e-02f,
  -1.95200279e-01f, -1.01535730e-02f, 7.20399544e-02f, 1.03006391e-02f, 2.71440446e-02f, 1.00433804e-01f, -6.65062517e-02f, 1.38972914e-02f, 1.04707852e-01f, -1.16885275e-01f,
  -7.45948851e-01f, -3.45219880e-01f, 1.43236592e-01f, -2.12004825e-01f, 2.53865540e-01f, 3.02468449e-01f, 3.25415015e-01f, -3.48346047e-02f, -2.32558092e-03f, 4.19447571e-02f,
  -2.98705310e-01f, -3.11355889e-01f, -2.78171599e-01f, -8.20909217e-02f, -6.65548816e-02f, 4.64601725e-01f, 4.81261313e-01f, 2.30246231e-01f, 1.28675476e-01f, 8.08764175e-02f,
  6.85532987e-02f, 7.39478320e-02f, -2.49868423e-01f, 2.06100428e-03f, -6.39689490e-02f, 4.37649973e-02f, 6.80099279e-02f, -5.67467771e-02f, 7.02940971e-02f, 4.81248014e-02f,
  2.05267385e-01f, -5.29166818e-01f, 1.04946017e-01f, -2.36969694e-01f, -1.68589711e-01f, -1.35092527e-01f, -1.41510721e-02f, -1.71528742e-01f, -9.97868925e-02f, 1.38712510e-01f,
  -9.02245119e-02f, -5.77617101e-02f, -6.49039373e-02f, -3.07072215e-02f, -3.80577147e-02f, 2.55094226e-02f, -1.53581187e-01f, -1.82394773e-01f, -3.95062044e-02f, 3.90841663e-02f,
  -4.57499065e-02f, -1.02039680e-01f, 1.09905146e-01f, 1.31316390e-03f, -1.33130215e-02f, 2.42228415e-02f, -1.35041224e-02f, -7.77839869e-02f, -5.87605126e-02f, -7.30747208e-02f,
  1.63536355e-01f, -1.21669527e-02f, -1.45999953e-01f, -9.29623246e-02f, -8.56113285e-02f, 1.65240034e-01f, 6.20075166e-02f, 8.53650719e-02f, 9.75783095e-02f, 2.17773616e-02f,
  2.39412338e-02f, 1.40772033e-02f, 4.01641289e-03f, 5.70591614e-02f, -1.33159488e-01f, -5.42228669e-02f, 8.86143942e-04f, -3.23552340e-02f, -4.24871109e-02f, -1.79939821e-01f,
  -1.08698562e-01f, 2.46120654e-02f, 4.08484042e-03f, 1.35966673e-01f, 3.14968079e-02f, -5.79804182e-02f, 1.18655533e-01f, 1.00883795e-02f, -1.43216061e-03f, 3.01187462e-03f,
  1.45887882e-01f, -9.19003114e-02f, 8.14725608e-02f, -9.67001170e-02f, -7.02836141e-02f, -1.66540846e-01f, -1.35921925e-01f, 6.21928386e-02f, 9.24409479e-02f, 8.69261697e-02f,
  6.75655231e-02f, -2.48919670e-02f, -2.83828285e-03f, 7.56939724e-02f, 1.81984767e-01f, 1.65411770e-01f, -7.94771686e-02f, 5.90561666e-02f, 3.20874453e-02f, 1.85398728e-01f,
  7.82982856e-02f, 1.73559859e-01f, 8.88271555e-02f, 2.11281851e-01f, 9.76606235e-02f, 2.11459979e-01f, 2.29606271e-01f, 7.36672506e-02f, 2.10490495e-01f, 2.15989813e-01f,
  -1.44995242e-01f, -3.69513303e-01f, -7.66155422e-02f, -2.39017576e-01f, 4.54837363e-03f, -1.78494394e-01f, -4.20073956e-01f, -3.14317852e-01f, -2.07801223e-01f, -4.62801933e-01f,
  -5.52097596e-02f, 4.09104943e-01f, 2.96430349e-01f, 2.19030619e-01f, 1.59214854e-01f, -4.48739469e-01f, -3.10982525e-01f, 2.90898710e-01f, 3.92343581e-01f, 9.50038657e-02f,
  9.69480053e-02f, 1.27072886e-01f, 2.92773694e-01f, 4.48209345e-02f, -2.03248143e-01f, 1.04545243e-01f, -9.61571410e-02f, 3.02565633e-03f, -1.92837659e-02f, -1.69529766e-01f,
  -1.11247217e-02f, -3.26207131e-01f, 1.47626206e-01f, 2.15642855e-01f, -9.88674164e-02f, 1.95909962e-02f, -8.64557624e-02f, -1.55750162e-03f, 6.74000103e-03f, -1.27539381e-01f,
  1.54580489e-01f, 2.81382613e-02f, 1.17068380e-01f, -8.61664489e-02f, -3.20928767e-02f, -1.32977352e-01f, -1.04085661e-01f, -1.42093971e-02f, 2.99773794e-02f, -1.19372264e-01f,
  -7.46599510e-02f, -1.17237106e-01f, 1.21954270e-01f, -2.36646328e-02f, -9.92972329e-02f, 1.11329831e-01f, -1.27978772e-02f, -1.43886790e-01f, -1.09496921e-01f, -4.67235297e-01f,
  -1.47134304e-01f, -5.58225363e-02f, -1.41187429e-01f, 1.02200769e-01f, -1.19491093e-01f, -3.27582024e-02f, -5.63723035e-02f, -1.42057970e-01f, -1.43301383e-01f, 3.63416523e-02f,
  -7.68715367e-02f, 5.06698005e-02f, 1.08875692e-01f, -7.04838783e-02f, -2.17133500e-02f, 4.21656147e-02f, 7.76184443e-03f, -1.29558593e-01f, -3.09073157e-03f, 6.14297464e-02f,
  1.62772685e-01f, 2.15974972e-02f, -2.21225852e-03f, -1.40696391e-02f, -4.52533737e-02f, -6.32921755e-02f, -5.18591926e-02f, 4.98314686e-02f, 4.86275852e-02f, -5.22952788e-02f,
  5.14754914e-02f, 3.49519581e-01f, -2.32570708e-01f, -5.05434237e-02f, -1.00561321e-01f, 1.07416825e-03f, -6.44141212e-02f, 6.52182009e-03f, 3.61806503e-03f, -5.77711612e-02f,
  5.11231311e-02f, -4.65655886e-02f, -2.69368999e-02f, 7.31289238e-02f, 2.31312998e-02f, 2.59618703e-02f, -1.11674301e-01f, 7.45100081e-02f, 2.69243062e-01f, -3.57245952e-02f,
  -1.36526868e-01f, -1.68133438e-01f, -5.87262176e-02f, -5.66741265e-02f, -1.00125328e-01f, 1.36497244e-01f, 1.04356736e-01f, -1.16094813e-01f, 6.25612959e-02f, -3.40316087e-01f,
  -3.57782125e-01f, -2.31394097e-02f, -1.67274252e-01f, 1.43116368e-02f, -5.00115901e-02f, -3.54351670e-01f, -4.53988045e-01f, -3.72846395e-01f, 2.10927613e-02f, 1.94794666e-02f,
  2.23437503e-01f, 8.69919807e-02f, 1.07319281e-01f, -2.46648043e-01f, -3.57574433e-01f, -3.61523777e-01f, -3.54137659e-01f, -4.91195619e-01f, -4.34064776e-01f, -2.34355807e-01f,
  -2.31180534e-01f, -3.40876609e-01f, -1.99138120e-01f, -2.56872654e-01f, 2.36649752e-01f, 4.98165153e-02f, 3.95340919e-02f, 3.54898535e-02f, -5.90200610e-02f, 4.07852717e-02f,
  2.72771060e-01f, 1.00824818e-01f, -1.15197860e-01f, -6.43949062e-02f, 1.80017538e-02f, -6.31658882e-02f, -1.84960470e-01f, 1.11583911e-01f, -2.36275103e-02f, 2.05965508e-02f,
  -2.87047550e-02f, -1.80283487e-02f, -3.15049887e-02f, -2.30998005e-04f, -4.85382900e-02f, 1.36117088e-02f, 1.48882389e-01f, 1.33733405e-02f, 6.44205287e-02f, 1.75493583e-01f,
  1.45870119e-01f, 2.75046728e-03f, 2.42650770e-02f, 2.29086485e-02f, 9.60709527e-02f, 1.04116060e-01f, 1.39279902e-01f, 1.42136201e-01f, 1.94158748e-01f, 2.13643372e-01f,
  -2.45424300e-01f, -1.92368334e-05f, 1.33193940e-01f, 9.53258723e-02f, 1.06934175e-01f, 2.55692564e-02f, 1.43104687e-01f, -8.78894329e-02f, -1.48243219e-01f, -7.16786236e-02f,
  1.67583659e-01f, 1.99741665e-02f, -1.01015270e-01f, 9.05369744e-02f, 6.79728836e-02f, -1.07115861e-02f, -1.54265957e-02f, 1.09672219e-01f, 5.72544783e-02f, 1.37800425e-01f,
  -5.55624766e-03f, 2.31859833e-02f, 7.98485577e-02f, 4.78818715e-02f, 1.15684472e-01f, 1.79751981e-02f, 3.57492678e-02f, 1.34790670e-02f, -2.11077668e-02f, 1.58124100e-02f,
  3.59310895e-01f, -5.93151972e-02f, 1.02183238e-01f, -7.46278092e-02f, 7.76220933e-02f, 1.16966113e-01f, 2.54126281e-01f, 3.56009007e-02f, -7.37823080e-03f, -3.18700038e-02f,
  7.07157627e-02f, -2.66011767e-02f, -2.71237846e-02f, 8.93785655e-02f, -1.49879172e-01f, 8.09691772e-02f, 1.84356254e-02f, 7.10135773e-02f, 1.59642547e-01f, 1.12505727e-01f,
  2.03987081e-02f, 7.46550411e-02f, 4.80851121e-02f, 1.22685947e-01f, 7.73489708e-03f, -7.41097108e-02f, 1.00267380e-01f, 1.37786984e-01f, -1.40137142e-02f, -9.27612484e-02f,
  5.15078247e-01f, -9.41027105e-02f, -2.02800855e-01f, 3.55553359e-01f, -1.55989990e-01f, -3.02522957e-01f, -3.67693096e-01f, -3.08568358e-01f, 4.16433886e-02f, -6.22451827e-02f,
  -5.92575036e-02f, 2.19937980e-01f, 7.30865821e-02f, -3.32775456e-03f, -1.77268863e-01f, -1.79735139e-01f, -1.27305493e-01f, 8.49481579e-03f, 3.73528572e-03f, -1.87172890e-02f,
  9.74983051e-02f, 1.44492522e-01f, 2.19952449e-01f, -5.89047596e-02f, 1.19525477e-01f, 1.06525891e-01f, -4.36861962e-02f, 1.02939956e-01f, 2.76233889e-02f, 2.54029304e-01f,
  4.44140971e-01f, 2.23478884e-01f, -1.95227340e-01f, 4.14344743e-02f, 1.00973748e-01f, -3.57309990e-02f, -1.34136125e-01f, 5.09826504e-02f, -7.96728060e-02f, -1.23055443e-01f,
  5.31260595e-02f, 4.10080142e-02f, 4.35118154e-02f, 1.57212168e-01f, 6.64475886e-03f, -1.61783278e-01f, -2.23366454e-01f, -1.74114972e-01f, -1.12963319e-01f, 9.89396423e-02f,
  2.65858062e-02f, 6.87128305e-02f, -1.16978429e-01f, -2.50861108e-01f, -3.66932862e-02f, -7.85263777e-02f, -2.49300689e-01f, 2.61360556e-02f, -2.37374827e-01f, 2.13847719e-02f,
  4.86009842e-04f, -1.97757371e-02f, -4.24520411e-02f, -1.13853410e-01f, -8.48986506e-02f, -4.84087393e-02f, -7.80274346e-03f, 5.78854932e-03f, 1.86597463e-02f, -1.59490287e-01f,
  -1.75486393e-02f, 6.17089607e-02f, 1.41143100e-02f, -3.29915881e-02f, -3.88769060e-02f, -7.56329000e-02f, 1.92866325e-02f, -4.94495742e-02f, 4.28586304e-02f, -2.78760097e-03f,
  -1.17033496e-02f, -5.81117161e-02f, -7.60645717e-02f, -5.72052412e-02f, 5.18435910e-02f, 5.98177454e-03f, 1.64031923e-01f, -6.14658259e-02f, 1.17955934e-02f, 3.55077413e-04f,
  1.03660055e-01f, -1.55554444e-01f, 2.41540186e-02f, -5.55700064e-02f, 4.83553074e-02f, -2.30582684e-01f, -1.35201529e-01f, 8.92410812e-04f, 2.42172293e-02f, -3.48757841e-02f,
  -8.90331343e-02f, -9.09075364e-02f, 3.46423090e-02f, 1.91915769e-03f, -7.13013019e-03f, 2.42541786e-02f, -3.29010114e-02f, -5.01479432e-02f, -1.61609679e-01f, 1.77371427e-01f,
  -1.55034691e-01f, -2.45425701e-01f, -2.78271805e-03f, -2.12566718e-01f, -9.37964022e-02f, -1.11375511e-01f, -2.04997554e-01f, -1.59298256e-01f, -2.04176828e-01f, -3.67171228e-01f,
  -2.02162161e-01f, 4.45249051e-01f, -2.59730130e-01f, -2.45219126e-01f, -9.88572370e-03f, 1.89822912e-01f, 3.58309686e-01f, 2.07306013e-01f, -1.90398619e-02f, -1.60619374e-02f,
  1.52253568e-01f, -2.24189684e-01f, -1.53925076e-01f, -2.59926021e-01f, -1.85051113e-01f, -2.40325425e-02f, -1.72830299e-01f, -4.33564216e-01f, -3.33148837e-01f, -3.86303887e-02f,
  -1.65340915e-01f, -2.87265807e-01f, -2.83297449e-01f, -2.87142128e-01f, -1.54480919e-01f, -4.06251132e-01f, -3.72467101e-01f, -2.14588702e-01f, -2.55723242e-02f, -3.84533584e-01f,
  -3.36293697e-01f, 1.08060367e-01f, -9.53870863e-02f, 3.87155451e-02f, 2.11177841e-02f, 5.94875924e-02f, 9.26815420e-02f, 1.39232680e-01f, 2.08426267e-01f, 1.09185040e-01f,
  6.64796531e-02f, -4.16362770e-02f, 9.00390744e-02f, 1.21987440e-01f, 4.39005420e-02f, 8.65166262e-02f, 2.42435724e-01f, 1.73185751e-01f, 2.22471893e-01f, 8.95315409e-02f,
  8.32764804e-02f, 1.69925138e-01f, 2.04014093e-01f, 8.09955522e-02f, 5.04555628e-02f, -3.37731931e-03f, 1.00547113e-01f, -2.84314854e-03f, 3.50066982e-02f, 5.27090989e-02f,
  1.40304580e-01f, 3.35742198e-02f, 2.34413929e-02f, -6.89537972e-02f, 1.65159643e-01f, 1.69936821e-01f, 4.16663997e-02f, -4.19545695e-02f, -4.25333083e-02f, 1.03023849e-01f,
  1.03544272e-01f, 5.05953543e-02f, -2.29726676e-02f, -1.06816426e-01f, -8.78827274e-02f, 1.10318527e-01f, 2.14953758e-02f, 1.30184025e-01f, 3.12284715e-02f, 1.45200253e-01f,
  -4.59765230e-04f, 5.72064370e-02f, 2.41117906e-02f, 6.53492734e-02f, 1.24824949e-01f, 6.39476180e-02f, 5.36334775e-02f, 5.36221080e-02f, 1.24976377e-03f, -2.74986159e-02f,
  -2.15792447e-01f, 4.53509875e-02f, -2.58467533e-02f, 6.30471334e-02f, -1.43112093e-02f, -3.02932709e-02f, -2.78791673e-02f, -8.92638564e-02f, -2.25812644e-02f, -5.46549447e-02f,
  6.43563941e-02f, -1.32891521e-01f, 5.01379818e-02f, 2.32354812e-02f, -7.52504319e-02f, -1.97829872e-01f, 1.30058080e-01f, -1.94623824e-02f, 7.70151913e-02f, 1.10698164e-01f,
  1.71646029e-01f, 1.20732732e-01f, 6.04935810e-02f, -1.07971080e-01f, -9.10105929e-02f, -7.45896995e-02f, -1.30051598e-01f, -1.48825906e-03f, -8.54617506e-02f, -7.90136829e-02f,
  7.31775090e-02f, 3.11687231e-01f, -5.25766432e-01f, 1.97647795e-01f, 1.52068315e-02f, -2.98739225e-01f, -6.07434101e-02f, 3.04539502e-02f, 5.60158715e-02f, 2.54219651e-01f,
  1.33244976e-01f, -1.09742731e-01f, -1.75217882e-01f, -3.15163612e-01f, -5.09820938e-01f, -1.11817561e-01f, -1.72722101e-01f, -5.13764322e-01f, -5.96418858e-01f, -1.86002076e-01f,
  2.74793953e-01f, 1.90634474e-01f, -1.24185465e-01f, -1.45388320e-01f, 2.42691234e-01f, 6.77477627e-04f, 3.79957445e-02f, -8.16905797e-02f, -3.27550098e-02f, 8.41760263e-03f,
  -3.91721010e-01f, -2.43643999e-01f, -1.28700733e-01f, 7.76300728e-02f, 6.67054057e-02f, 5.15151881e-02f, 7.62850642e-02f, -1.44182622e-01f, -1.00358434e-01f, -8.66704136e-02f,
  -5.58262691e-02f, -4.65518683e-02f, -6.97270110e-02f, -9.14013013e-02f, -7.52547756e-02f, -1.23473994e-01f, 2.06530914e-02f, -2.66153008e-01f, -1.59728512e-01f, -2.72800565e-01f,
  1.16611861e-01f, -9.42516476e-02f, -4.31974560e-01f, -1.36711031e-01f, -4.19327259e-01f, -2.59507149e-01f, -2.73992866e-01f, -2.48890683e-01f, -4.52642024e-01f, 9.69621316e-02f,
  1.30597979e-01f, 3.59119996e-02f, -8.73988308e-03f, 3.39714698e-02f, 1.47533372e-01f, 2.18877885e-02f, -8.41083452e-02f, -1.64344814e-02f, 6.21085539e-02f, -4.50816117e-02f,
  -4.23352467e-03f, -1.87581182e-02f, -2.57729962e-02f, 1.79954246e-02f, -1.09737441e-02f, -5.22118881e-02f, -7.53110508e-03f, 1.09325267e-01f, 4.44208086e-03f, 3.82627696e-02f,
  -4.27201465e-02f, -4.36127298e-02f, -3.35609214e-03f, -3.93990166e-02f, -4.28765938e-02f, -1.33779468e-02f, -5.12145227e-03f, -2.46475618e-02f, 3.22941914e-02f, -2.35302933e-02f,
  1.54900789e-01f, -1.80618837e-01f, 1.50112763e-01f, 5.52118616e-03f, -9.47274491e-02f, -9.92970890e-04f, 1.12271152e-01f, 3.55427489e-02f, -4.41132672e-02f, -4.08680625e-02f,
  -1.52125910e-01f, 4.35984274e-03f, -7.31855333e-02f, -2.31302995e-02f, -8.50238726e-02f, -7.90121332e-02f, 2.36827135e-01f, -3.29248607e-02f, 1.62269957e-02f, 1.28977112e-02f,
  1.43002912e-01f, 4.07376233e-03f, -2.81678047e-02f, 2.80389823e-02f, 4.40824069e-02f, 2.18601339e-03f, -4.05131467e-02f, 1.33029640e-01f, -3.40804935e-01f, 3.64899069e-01f,
  2.45842263e-01f, -8.00159350e-02f, -2.41827562e-01f, -6.72812909e-02f, -1.71825260e-01f, -5.18464185e-02f, 1.14232168e-01f, -4.92920019e-02f, -1.79652393e-01f, 2.97601372e-02f,
  -6.63114414e-02f, -1.73381552e-01f, -1.88437343e-01f, -4.06687744e-02f, 1.51485413e-01f, 1.78486213e-01f, 7.35616162e-02f, 6.10124059e-02f, -1.26716550e-02f, 4.21382636e-02f,
  8.95255432e-03f, -3.52144614e-02f, -4.67686839e-02f, -1.43370694e-02f, -8.24623257e-02f, -1.22467570e-01f, -2.12794557e-01f, -1.69146687e-01f, -1.29145578e-01f, -2.24320486e-01f,
  -8.26483443e-02f, -1.66983560e-01f, -6.07704856e-02f, 8.19849297e-02f, -1.14652030e-01f, 9.28865466e-03f, 5.01576215e-02f, -5.87779544e-02f, -5.97676933e-02f, -9.40649286e-02f,
  -1.30214393e-01f, -5.46476543e-02f, -4.24213707e-02f, -2.03999355e-01f, -9.26214159e-02f, -5.46805039e-02f, -3.81294228e-02f, -5.95006123e-02f, -1.24522738e-01f, -2.00467154e-01f,
  -1.70067206e-01f, -3.36389802e-02f, -6.02540523e-02f, -9.93478745e-02f, -9.79293287e-02f, -4.37202379e-02f, -4.77722473e-02f, -1.84456557e-01f, -1.38484359e-01f, 6.19108975e-02f,
  1.13619016e-02f, -9.61591452e-02f, -8.84831026e-02f, 8.21288675e-02f, 6.61393851e-02f, -2.71515604e-02f, 1.53491078e-02f, 8.70504603e-02f, -2.95230821e-02f, 7.52312317e-02f,
  6.23890832e-02f, 7.57587850e-02f, -2.63676862e-03f, 1.60869472e-02f, 6.49914220e-02f, 4.66954196e-03f, 1.26696199e-01f, 6.16130717e-02f, 1.68519106e-03f, 1.24109745e-01f,
  -9.47024859e-03f, 4.52210233e-02f, 3.22483666e-02f, 1.16610758e-01f, -5.13709970e-02f, 6.94769025e-02f, -3.46529819e-02f, 3.56257148e-02f, -5.79335820e-03f, 2.89466921e-02f,
  2.80720830e-01f, 1.56330124e-01f, 1.68841451e-01f, 9.10389051e-02f, -2.68323720e-02f, 8.28002915e-02f, 1.29849419e-01f, 1.01999193e-01f, -9.41591486e-02f, -7.02610537e-02f,
  -1.06969520e-01f, 1.32702276e-01f, 5.48518337e-02f, -5.13025261e-02f, 6.10493459e-02f, -1.70621034e-02f, 1.42668068e-01f, -6.36952817e-02f, 1.82560843e-03f, -2.14105342e-02f,
  1.25104219e-01f, 2.13940516e-01f, 2.75274217e-01f, 1.03731543e-01f, -8.89258832e-02f, 9.13064405e-02f, 7.39306062e-02f, 8.92338231e-02f, 1.29948393e-01f, 3.73628736e-01f,
  -4.23073977e-01f, -2.05203086e-01f, -1.35570183e-01f, -2.45088249e-01f, -1.46935284e-01f, 8.17012414e-02f, -1.28123581e-01f, 5.16237393e-02f, -1.03546670e-02f, -2.02614427e-01f,
  -2.89328806e-02f, -2.02351138e-02f, -1.86351284e-01f, -4.21595499e-02f, -2.24287167e-01f, -2.22716451e-01f, -1.98294654e-01f, -1.31072223e-01f, -1.78368203e-02f, 2.04339653e-01f,
  9.55754071e-02f, -1.18009388e-01f, -1.51536897e-01f, -1.05182854e-02f, -2.24418137e-02f, -1.06879309e-01f, -1.01861075e-01f, -2.27631658e-01f, -3.77827175e-02f, -3.20757926e-01f,
  4.34778631e-03f, 9.98643637e-02f, 2.66785681e-01f, -5.78077547e-02f, 5.54946717e-03f, 2.44303402e-02f, 1.19249023e-01f, -2.92166732e-02f, -7.41051277e-04f, -9.31259338e-03f,
  -1.11822091e-01f, 1.55289739e-01f, 1.55230779e-02f, 4.01555151e-02f, 5.64744547e-02f, -4.30227742e-02f, -3.83474231e-02f, -9.10609514e-02f, -8.70369822e-02f, 2.66458690e-02f,
  -9.05179903e-02f, -1.17009632e-01f, -1.54017776e-01f, -9.33177769e-02f, -9.33038013e-04f, -4.22826931e-02f, 8.50973129e-02f, 7.35968724e-02f, -1.22094072e-01f, -2.90670663e-01f,
  -8.71380605e-03f, 4.35103737e-02f, 7.98608139e-02f, -1.56923570e-02f, -1.11354180e-01f, 1.98285040e-02f, -1.70409173e-01f, -9.64954793e-02f, 5.02429977e-02f, -2.29240000e-01f,
  2.86129583e-02f, 9.92850512e-02f, 2.39691362e-02f, -3.75111103e-02f, 4.32143621e-02f, -2.73257196e-02f, 1.28201678e-01f, 7.80299455e-02f, -3.46507132e-02f, -8.20343122e-02f,
  3.72562148e-02f, 9.73214284e-02f, -3.78189683e-02f, -5.56261428e-02f, 3.33971791e-02f, -1.72106400e-02f, 1.32212996e-01f, 1.99698955e-01f, 6.43661544e-02f, 2.27747802e-02f,
  -1.68982491e-01f, 2.67123729e-02f, -1.23711675e-01f, -3.70191298e-02f, 7.04563782e-02f, -1.55624906e-02f, -1.87158138e-02f, 2.82642315e-03f, -1.02594301e-01f, 3.48781459e-02f,
  1.02063030e-01f, -5.13608642e-02f, -5.98813184e-02f, 1.28260195e-01f, 1.99362621e-01f, 1.58163950e-01f, -1.78927705e-01f, -1.29362285e-01f, 2.40263361e-02f, 7.73496777e-02f,
  -1.09959692e-01f, -1.83884069e-01f, -3.36182266e-01f, -1.51468605e-01f, -4.46355678e-02f, -1.21371701e-01f, -4.32503410e-02f, 3.69352475e-02f, -1.00416139e-01f, -3.19891125e-01f,
  2.70280749e-01f, -4.00547385e-01f, 2.57368773e-01f, -3.10125146e-02f, -1.35172099e-01f, 1.51931671e-02f, -1.64464787e-01f, 1.91180338e-03f, -2.00509373e-02f, 8.62468407e-03f,
  8.30023140e-02f, 2.38156080e-01f, 1.84935182e-01f, 1.87270463e-01f, 1.35602221e-01f, -1.29959509e-01f, -6.74502626e-02f, 3.34872931e-01f, 3.23002726e-01f, -9.41140130e-02f,
  -1.31537244e-01f, -2.13095933e-01f, 8.39332789e-02f, 4.02272977e-02f, -3.03261846e-01f, 6.68006241e-02f, -6.62893578e-02f, -2.68226206e-01f, -2.42146820e-01f, -1.88082591e-01f,
  2.02106357e-01f, -2.86243886e-01f, 1.24374807e-01f, -1.34150073e-01f, -2.95589007e-02f, -5.80140464e-02f, -8.40999112e-02f, -4.79208268e-02f, -1.52985737e-01f, -4.40289602e-02f,
  -1.57630697e-01f, -7.54356235e-02f, -5.36737847e-04f, -1.80735826e-01f, -2.00028583e-01f, -1.53087229e-01f, -1.02840729e-01f, -1.48728445e-01f, 7.20711201e-02f, -1.56591390e-03f,
  -6.79013208e-02f, -1.95559308e-01f, 3.44696641e-02f, 1.37401391e-02f, -7.20371008e-02f, 2.08043560e-01f, -5.57534248e-02f, -8.84177461e-02f, -3.22313532e-02f, -9.93852690e-02f,
  -1.02427319e-01f, 1.04339890e-01f, -2.42454484e-02f, -2.77573778e-03f, -2.81082932e-02f, -1.47464843e-02f, 1.01631574e-01f, -5.54081202e-02f, 1.59581099e-02f, -6.90726787e-02f,
  6.50828257e-02f, 4.48705666e-02f, -5.14147915e-02f, 2.49855705e-02f, 4.61563515e-03f, -1.58857450e-01f, -1.16448021e-02f, 3.64642665e-02f, 9.89268906e-03f, -2.51061264e-02f,
  5.05747497e-02f, -8.30260739e-02f, -1.58771053e-02f, 6.81278035e-02f, 1.05356462e-02f, 1.01006940e-01f, -5.04184850e-02f, 1.84145477e-02f, 3.33881602e-02f, -1.21799082e-01f,
  -3.17993648e-02f, 7.33297095e-02f, 3.08073107e-02f, -8.64442810e-02f, -1.01682946e-01f, -1.09460659e-01f, -3.19430344e-02f, 6.63650930e-02f, -1.06355418e-02f, 4.10390832e-02f,
  -1.41368479e-01f, 1.13813365e-02f, -5.05581275e-02f, -2.30815243e-02f, 1.00348936e-03f, -1.49766132e-01f, -8.18960741e-02f, 1.27483070e-01f, -3.89530906e-03f, -1.88231155e-01f,
  -6.19545020e-02f, -4.83952388e-02f, 1.39678106e-01f, 1.45836234e-01f, -2.82135652e-03f, 3.32123220e-01f, 9.08922404e-02f, 5.02263457e-02f, 1.68039575e-01f, 5.38298041e-02f,
  4.15127575e-01f, 3.28339338e-01f, 3.51295501e-01f, 5.65961078e-02f, -2.51148403e-01f, -3.51899296e-01f, -2.65775055e-01f, -2.23070100e-01f, -1.40700802e-01f, 1.49333542e-02f,
  -1.37936816e-01f, -1.18130393e-01f, -6.23398237e-02f, -1.13649994e-01f, -8.54455605e-02f, 2.66502593e-02f, 7.06883073e-02f, 9.73709896e-02f, -9.31447819e-02f, -1.75939187e-01f,
  -1.85307696e-01f, 1.82825625e-02f, 1.07331641e-01f, 7.18020424e-02f, 2.17648178e-01f, -1.33777604e-01f, 2.25468725e-01f, 1.74244866e-01f, 2.30336320e-02f, 3.83956254e-01f,
  3.41438234e-01f, 3.71912897e-01f, -4.27257806e-01f, -1.96728766e-01f, -3.89805995e-02f, 3.86412404e-02f, 3.33990343e-02f, 2.03113154e-01f, 8.41871798e-02f, 1.19415410e-01f,
  -1.00630686e-01f, 1.11861095e-01f, 7.09988177e-02f, -1.49046928e-01f, -9.86595079e-02f, -1.15438633e-01f, 1.65392347e-02f, 1.34384170e-01f, 1.85367331e-01f, 4.50786352e-02f,
  -2.27055252e-01f, 2.33944915e-02f, 9.29764286e-02f, -2.18018040e-01f, 8.97942856e-02f, -7.59196281e-02f, 1.20073499e-03f, 3.99289317e-02f, -1.03173047e-01f, 3.64905626e-01f,
  -6.22224472e-02f, -6.95557594e-02f, -1.01367600e-01f, 9.81139392e-02f, -5.38033694e-02f, -1.32140115e-01f, -9.07194689e-02f, -1.28177404e-01f, -6.61559626e-02f, -2.08215006e-02f,
  -1.35778740e-01f, 1.49993924e-02f, -3.48124653e-02f, -3.14951017e-02f, -1.48723349e-01f, -2.40929592e-02f, 5.31370007e-03f, 2.20907312e-02f, 1.04929404e-02f, -3.69324535e-02f,
  -5.25996238e-02f, -1.85664333e-02f, 1.26333833e-01f, 1.27212003e-01f, -3.60191092e-02f, 4.11854871e-02f, -3.09329350e-02f, -4.77918014e-02f, 1.77036315e-01f, 1.84914380e-01f,
  -2.89022624e-01f, -3.28982323e-01f, -8.79117474e-02f, -9.69174802e-02f, -3.24256830e-02f, -2.27476358e-01f, -2.84912474e-02f, -1.06882639e-01f, 3.15687172e-02f, -5.30017354e-03f,
  3.35905910e-03f, 3.22441421e-02f, 9.51966941e-02f, -1.77463517e-01f, -1.85598150e-01f, -8.05855617e-02f, -1.27635136e-01f, -1.55730695e-01f, -1.23276554e-01f, -1.11388333e-01f,
  -2.50811636e-01f, -3.42252195e-01f, -2.46491298e-01f, -7.28175864e-02f, -1.76456004e-01f, -2.72406876e-01f, -2.80505925e-01f, -2.88905591e-01f, -4.66298312e-01f, -1.73154891e-01f,
  -3.32972705e-01f, -5.90617180e-01f, 2.74590135e-01f, -1.18797801e-01f, 1.58533931e-01f, 1.59417033e-01f, 1.28127947e-01f, 3.02994549e-02f, -1.21068254e-01f, -1.11994911e-02f,
  -6.38306513e-02f, -1.87860206e-01f, -3.14010531e-02f, -1.18617430e-01f, -6.01050556e-02f, 8.68823379e-02f, 2.18007758e-01f, 2.60783345e-01f, 2.47069165e-01f, 5.83845563e-02f,
  -1.17059834e-01f, -6.71923310e-02f, -1.61724821e-01f, -3.90431136e-02f, -5.78917526e-02f, -6.08245376e-03f, 6.50091618e-02f, -1.61649033e-01f, -5.13985381e-02f, -1.80495977e-01f,
  2.81722248e-01f, -2.98042238e-01f, 9.69996080e-02f, -1.56981513e-01f, -5.99132925e-02f, -5.00511304e-02f, 1.65506860e-03f, -4.02456298e-02f, -1.47218660e-01f, 2.90173665e-02f,
  -1.44361407e-01f, -2.42712665e-02f, -7.87201077e-02f, -9.39978659e-03f, -2.86560804e-02f, -1.00398157e-02f, -6.31720992e-03f, -1.84068158e-01f, -2.45911032e-01f, -1.38850570e-01f,
  -5.46616353e-02f, -1.86335982e-03f, 6.01103008e-02f, 1.22112408e-02f, -4.05359790e-02f, -7.20207468e-02f, -2.65647508e-02f, -1.46538362e-01f, -8.72444361e-02f, -6.81452826e-02f,
  -5.97653836e-02f, 2.47317299e-01f, -1.57103129e-02f, 2.09318221e-01f, 4.39432897e-02f, 1.85097188e-01f, 4.77353446e-02f, 2.59476863e-02f, 1.01353653e-01f, 1.47863487e-02f,
  4.42080311e-02f, -6.77143876e-03f, 4.57984395e-02f, -3.91871482e-02f, -3.65703888e-02f, -1.20090783e-01f, 1.12753257e-01f, -1.17751993e-02f, 6.83780387e-02f, 6.96090097e-03f,
  1.95878930e-02f, -4.72874716e-02f, -5.49821630e-02f, 4.02579978e-02f, -8.51266608e-02f, -3.63259017e-02f, 2.52421573e-02f, 5.27264066e-02f, 7.00618923e-02f, -7.45566338e-02f,
  -1.74154993e-02f, 8.15797076e-02f, 1.50537536e-01f, -9.69142094e-02f, 4.26442036e-03f, -5.03545627e-02f, 9.03609097e-02f, -8.18087086e-02f, -1.32426962e-01f, -2.41232272e-02f,
  -1.78268086e-02f, -3.52607146e-02f, -3.73029001e-02f, 7.36806840e-02f, 1.36899620e-01f, 5.31628877e-02f, -2.94717923e-02f, 5.63039184e-02f, -1.67717993e-01f, -9.35676619e-02f,
  -3.63371707e-02f, 1.15509205e-01f, 5.94441406e-02f, 1.49881542e-01f, 1.15153514e-01f, 2.26721779e-01f, 1.53983518e-01f, 9.14217904e-02f, 3.70860994e-02f, 2.03685671e-01f,
  2.83988386e-01f, -6.29248098e-02f, -1.84490725e-01f, 1.60584390e-01f, 6.65612295e-02f, -1.51917294e-01f, -3.29088390e-01f, -1.37609601e-01f, 2.96939742e-02f, 9.01565477e-02f,
  9.38496739e-02f, 2.32853293e-01f, 1.36348233e-01f, 2.63901148e-02f, -1.35517254e-01f, -1.83389932e-02f, -9.60907084e-04f, -2.61969026e-02f, 1.10682920e-02f, 1.46623835e-01f,
  7.30178356e-02f, 9.27926376e-02f, 1.41449556e-01f, 6.88156411e-02f, 2.88557321e-01f, 2.84382045e-01f, 1.18973389e-01f, 2.29010642e-01f, 8.78384635e-02f, 2.41581514e-01f,
  1.11607447e-01f, -2.01896229e-03f, 1.99156571e-02f, 1.58999488e-01f, 9.52452123e-02f, -4.95400429e-02f, 3.28125358e-02f, 4.02348153e-02f, -1.63264992e-03f, -7.29159340e-02f,
  2.32153013e-02f, 8.48781392e-02f, -1.01193413e-01f, 1.81355607e-02f, -1.43145949e-01f, -1.22585045e-02f, -8.70224759e-02f, -1.56681418e-01f, -1.30394921e-02f, 5.09357154e-02f,
  4.56587560e-02f, -3.44721340e-02f, -1.39563814e-01f, -2.42807403e-01f, -1.34697974e-01f, 1.32446706e-01f, 4.42161337e-02f, -3.84116024e-02f, -1.05775565e-01f, 5.36454767e-02f,
  2.50372261e-01f, 8.31966251e-02f, 1.99251845e-01f, 1.68293551e-01f, 1.48986503e-01f, 2.27189168e-01f, 1.16698422e-01f, 1.53743088e-01f, 7.60408938e-02f, 1.38519198e-01f,
  2.94461399e-02f, 1.61090299e-01f, -2.89961621e-02f, 8.10113326e-02f, 2.02361003e-01f, 9.17162448e-02f, 1.21456750e-01f, 1.61574975e-01f, 1.39837980e-01f, -1.34127093e-02f,
  1.29706278e-01f, 3.22846603e-03f, 2.01703459e-01f, 2.69665066e-02f, 9.36317071e-02f, 5.36125749e-02f, 1.86957896e-01f, 1.25387952e-01f, 2.10509270e-01f, 1.15788050e-01f,
  -2.43477449e-01f, -2.03422844e-01f, 1.83896169e-01f, -7.54835755e-02f, 5.02279811e-02f, -1.16074476e-02f, 6.26040697e-02f, -1.83503702e-02f, 5.48147485e-02f, -8.93664733e-02f,
  2.22756993e-02f, -8.82072896e-02f, -1.28135368e-01f, -7.55056813e-02f, -1.35441452e-01f, -7.95806348e-02f, 1.34691983e-01f, -1.19285192e-02f, -5.50795905e-02f, -5.90870045e-02f,
  -4.81627546e-02f, -1.60156652e-01f, -1.35380760e-01f, -1.95714027e-01f, -7.58736581e-02f, 3.34960148e-02f, -6.83921948e-02f, -6.85994849e-02f, -7.57854730e-02f, -1.14664011e-01f,
  -2.73302615e-01f, -2.70190865e-01f, -2.00296398e-02f, -3.46882284e-01f, -3.89137752e-02f, 1.25712566e-02f, -1.12466067e-01f, -1.21448770e-01f, -4.64659929e-02f, -1.85567066e-01f,
  -1.22384511e-01f, -1.74978510e-01f, -2.25913584e-01f, -4.45394143e-02f, 9.90195759e-03f, -2.69652128e-01f, -2.39616856e-01f, -1.79876462e-01f, 2.41559055e-02f, 6.88621178e-02f,
  -7.13920519e-02f, -1.27732262e-01f, -1.35023639e-01f, -6.76335841e-02f, -1.90997973e-01f, -1.82897776e-01f, -1.16575778e-01f, -2.08607152e-01f, 1.39581750e-03f, -2.55955547e-01f,
  -1.60105243e-01f, 1.26038641e-01f, 2.24016950e-01f, -3.76817323e-02f, -6.30473867e-02f, 1.55684799e-01f, 7.44002163e-02f, -8.44551176e-02f, 7.51320198e-02f, -2.85505913e-02f,
  -1.50267437e-01f, -1.08880084e-02f, 5.55814356e-02f, -5.28715737e-02f, -8.00618604e-02f, 7.21340850e-02f, -4.61535342e-02f, -7.57744163e-02f, -1.62138641e-01f, 1.15456350e-01f,
  -1.64039046e-01f, -6.23052791e-02f, -5.40748052e-02f, 9.46073309e-02f, 2.08624125e-01f, 8.91363770e-02f, 9.89122987e-02f, 1.22093931e-01f, 4.79713492e-02f, -3.19061130e-01f,
  -1.06989138e-01f, -1.26449883e-01f, 8.83031171e-03f, -5.24714477e-02f, -6.24810606e-02f, 2.91255414e-02f, -1.20772727e-01f, -2.41570305e-02f, 2.03516241e-02f, -1.28921181e-01f,
  -3.22982371e-02f, -9.40790176e-02f, 2.78381072e-02f, -7.00205863e-02f, -8.40639919e-02f, -5.73869832e-02f, 1.18057076e-02f, 7.21245259e-02f, 7.76028857e-02f, -3.17872390e-02f,
  -1.33061394e-01f, 5.80792613e-02f, -1.17373556e-01f, 3.02767591e-03f, 5.20336404e-02f, -1.37658417e-01f, -4.91431914e-02f, 1.26066282e-01f, 3.06763723e-02f, -5.24022318e-02f,
  -2.91477233e-01f, 1.60360515e-01f, -2.29748353e-01f, 2.48859543e-02f, -8.35182369e-02f, -6.91822916e-02f, -1.60059869e-01f, 2.09102884e-01f, -1.02001533e-01f, -4.71005626e-02f,
  4.77382988e-02f, -1.08604640e-01f, -1.68532774e-01f, -3.37871513e-03f, -9.34324600e-03f, -4.69113281e-03f, -1.48729995e-01f, -1.06301680e-01f, 7.24856779e-02f, -3.68382758e-03f,
  -1.69550121e-01f, -6.44394057e-03f, -4.91695516e-02f, -1.03767037e-01f, -1.39644062e-02f, -2.06206851e-02f, -7.98789263e-02f, -1.77483544e-01f, -1.15578272e-03f, -2.42536023e-01f,
  3.76188397e-01f, -4.53051060e-01f, 2.55393296e-01f, 1.87329441e-01f, 2.89471120e-01f, 3.19783658e-01f, 1.24564186e-01f, 1.65810078e-01f, 1.32417500e-01f, -4.41810191e-02f,
  -1.96184054e-01f, -3.09738159e-01f, -9.92398486e-02f, -2.36925960e-01f, -5.81692532e-02f, 8.14798921e-02f, 1.22093163e-01f, 1.52382910e-01f, 1.79554686e-01f, 2.54327536e-01f,
  5.56610450e-02f, 3.40670198e-02f, 9.43649635e-02f, -6.06822670e-02f, 2.16038916e-02f, -6.50252774e-02f, -2.21315194e-02f, -5.27458638e-03f, -1.37781771e-02f, -2.42831763e-02f,
  -1.15212366e-01f, -1.00098573e-01f, -3.98375504e-02f, -1.76037937e-01f, -1.18281573e-01f, -6.15517832e-02f, 1.87144503e-02f, -3.31802852e-02f, -7.10848123e-02f, 1.74019579e-02f,
  -1.46574005e-01f, -4.41286946e-03f, -1.08729735e-01f, -3.83680500e-02f, 4.78756502e-02f, -2.41460949e-02f, -1.28235549e-01f, -1.65500686e-01f, -7.12901354e-02f, -1.83874503e-01f,
  -2.33592167e-01f, 2.80636195e-02f, 1.40747698e-02f, -7.94856101e-02f, -1.73439935e-01f, -4.63995002e-02f, -7.49474168e-02f, -4.30886447e-02f, -1.43275082e-01f, 2.44938172e-02f,
  -6.21229820e-02f, -2.85449680e-02f, 3.59433051e-03f, -1.58232395e-02f, -6.51657507e-02f, 1.45277873e-01f, 1.36466548e-01f, -7.52338693e-02f, -1.00226887e-01f, -1.61804304e-01f,
  -8.20526630e-02f, 5.02442271e-02f, -8.42309520e-02f, 9.70293432e-02f, -7.45538175e-02f, 4.96440828e-02f, -2.86815595e-02f, -1.36271387e-01f, -8.82553160e-02f, 2.65967916e-03f,
  -2.43727881e-02f, 4.38368879e-02f, 1.79612972e-02f, -1.84621543e-01f, -2.77377814e-02f, -4.97939996e-02f, -4.89089750e-02f, -1.61687419e-01f, -7.12489709e-02f, 5.05753644e-02f,
  -3.71498555e-01f, -5.48358448e-03f, 8.60029683e-02f, -4.20146622e-02f, 1.19018398e-01f, -6.16471060e-02f, -7.63607100e-02f, -1.23105654e-02f, -6.41277283e-02f, 8.03536475e-02f,
  -2.17237324e-02f, 9.68231261e-02f, -2.31146626e-02f, -1.14365809e-01f, 6.77579567e-02f, -1.47387935e-02f, -8.18344802e-02f, 1.91171467e-02f, -7.31936470e-03f, -5.44224270e-02f,
  -6.37497827e-02f, 6.45575151e-02f, 4.45896126e-02f, 4.70191427e-02f, 1.01609882e-02f, 1.85185239e-01f, 8.52107778e-02f, 1.10514455e-01f, 1.27458259e-01f, 1.77911460e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  -5.94860852e-01f, 3.71260285e-01f, 2.81746417e-01f, 3.06341708e-01f, 2.60704696e-01f, 6.59629405e-02f, 4.27780181e-01f, 1.73318908e-01f, 2.59688258e-01f, 1.16045929e-01f,
  -1.85772181e-02f, 1.68675318e-01f, 1.52147949e-01f, 1.57400459e-01f, 2.31957957e-01f, 4.33637083e-01f, 4.51943964e-01f, 1.44586265e-01f, 9.79478657e-03f, 3.13928246e-01f,
  3.84929568e-01f, 2.61959583e-01f, 4.23893720e-01f, 1.37910023e-01f, 1.87779248e-01f, 2.19275117e-01f, 1.13779135e-01f, 3.90716463e-01f, 9.07849595e-02f, 1.56761318e-01f,
  4.91440952e-01f, 3.43618065e-01f, 9.33592580e-03f, 3.44613492e-01f, 1.23063348e-01f, 3.63794029e-01f, 2.39197463e-01f, -1.61497802e-01f, 5.74754834e-01f, 3.44695479e-01f,
  3.71048898e-01f, 2.12470025e-01f, 5.06263554e-01f, 3.90995741e-01f, 3.06437135e-01f, 1.00252144e-01f, 5.29257476e-01f, 2.27849022e-01f, 2.99730748e-01f, 3.19487542e-01f,
  2.01569319e-01f, 2.38424361e-01f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -4.07722183e-02f, 8.23158026e-02f, 5.51736727e-02f, 2.56576762e-02f, -1.19743235e-01f, -5.09036519e-02f, 1.85190424e-01f, 1.14334464e-01f, -1.04164481e-01f, 1.48631856e-01f,
  -4.69073616e-02f, 1.17718004e-01f, -1.56728014e-01f, 2.28376761e-01f, 2.40668222e-01f, 1.80265382e-01f, 5.60716651e-02f, -1.31908040e-02f, 1.84074849e-01f, 1.85219832e-02f,
  2.53529161e-01f, 1.66829184e-01f, -4.22961526e-02f, 1.09783225e-01f, -1.09215878e-01f, 4.03303951e-02f, -1.82776049e-01f, 2.55321652e-01f, 1.47636652e-01f, 2.55380303e-01f,
  -1.20823547e-01f, 4.61308993e-02f, 5.30114509e-02f, -2.98458576e-01f, 5.67152500e-02f, 7.52933472e-02f, 2.03235839e-02f, 9.49168950e-02f, 2.81854182e-01f, 2.77426243e-02f,
  1.90593109e-01f, 1.40748173e-01f, 1.36180416e-01f, 1.31809250e-01f, 3.16770636e-02f, 8.06416571e-02f, 1.23683058e-01f, -7.34007210e-02f, 3.17281574e-01f, 8.40508565e-02f,
  -3.97812650e-02f, 2.66017288e-01f, 6.31406531e-02f, -2.31896907e-01f, 1.40870333e-01f, -2.07982324e-02f, -4.81545925e-02f, 2.03679502e-01f, -8.69610533e-02f, -1.50687858e-01f,
  6.68399110e-02f, -4.79904674e-02f, 4.58509997e-02f, -1.13627359e-01f, -1.10463835e-02f, 4.29467894e-02f, -4.07357179e-02f, -3.58666815e-02f, -7.94617608e-02f, -2.94752494e-02f,
  -5.16988561e-02f, 8.09716806e-02f, -1.02702044e-01f, 7.47811720e-02f, 2.07271222e-02f, -1.86277792e-01f, -1.40200898e-01f, -1.64621130e-01f, 3.24871354e-02f, -1.77094057e-01f,
  2.66891450e-01f, 1.64338902e-01f, -2.04377756e-01f, -1.87012374e-01f, -1.83512300e-01f, 1.69108987e-01f, 4.73778434e-02f, 6.98029548e-02f, 3.68527690e-04f, 4.44672890e-02f,
  -8.09216425e-02f, 8.90921950e-02f, -7.59229660e-02f, 1.05862506e-02f, 6.69165924e-02f, 2.72856623e-01f, 7.09723532e-02f, -1.29268646e-01f, -7.84179643e-02f, 9.21268109e-03f,
  -6.04589656e-02f, 2.52909273e-01f, 2.14333400e-01f, -6.28007874e-02f, -1.55495897e-01f, -2.02436581e-01f, -3.05618215e-02f, -7.14653656e-02f, -7.72124305e-02f, -1.54998049e-01f,
  -1.09918363e-01f, 2.37945855e-01f, 9.56599936e-02f, 2.22835504e-02f, -1.57943428e-01f, -1.94307923e-01f, -1.23310290e-01f, -3.00033707e-02f, 1.01789072e-01f, -1.41444311e-01f,
  -8.71532634e-02f, 2.07008072e-03f, -1.13218702e-01f, 1.94268301e-01f, -1.43739700e-01f, -4.73182835e-02f, 1.02523774e-01f, -6.42304569e-02f, 1.81227267e-01f, -1.00747682e-02f,
  4.82822116e-03f, 1.83303148e-01f, 6.36379719e-02f, 4.71552834e-02f, 5.87793700e-02f, 1.59376889e-01f, 2.33113825e-01f, 5.05490042e-02f, -4.63746265e-02f, -5.59257753e-02f,
  4.99693044e-02f, -1.49143100e-01f, -1.08344354e-01f, 5.67704551e-02f, 1.16214193e-01f, -1.47941455e-01f, -1.81310698e-01f, 2.54635066e-02f, -1.16229735e-01f, -7.69818574e-02f,
  1.13658570e-01f, -2.89331436e-01f, -3.33771878e-03f, -1.57354847e-01f, -1.04538538e-01f, -1.34463031e-02f, 8.48311186e-03f, -1.21853478e-01f, 8.48085154e-03f, 1.41671479e-01f,
  -4.53152247e-02f, 1.79814845e-01f, 1.08342648e-01f, 1.90930292e-01f, -4.35925759e-02f, -8.50635991e-02f, -2.00723559e-01f, 6.62364438e-02f, -4.03566174e-02f, 2.52346784e-01f,
  -3.56226712e-01f, 1.66306481e-01f, -2.75287740e-02f, 2.36766599e-02f, 8.70374497e-03f, 1.00054696e-01f, -1.94135860e-01f, -1.43428624e-01f, -4.07286972e-01f, -4.20778655e-02f,
  1.71342269e-01f, 1.94694191e-01f, 2.45490316e-02f, 5.13453744e-02f, 3.85334343e-03f, -1.06749713e-01f, -5.87372519e-02f, 2.82958359e-01f, 7.31809437e-02f, 1.32221177e-01f,
  -1.38203308e-01f, -3.42659168e-02f, 8.45366865e-02f, -2.97111291e-02f, 4.33619544e-02f, -5.27828634e-02f, -1.10287808e-01f, 8.90642479e-02f, 7.95644745e-02f, 5.25735244e-02f,
  1.44052863e-01f, 9.52602923e-02f, 9.56349745e-02f, 6.10660836e-02f, 1.77371338e-01f, 7.68245943e-03f, 5.43946493e-03f, -1.94346100e-01f, -1.33974791e-01f, 1.77970361e-02f,
  -2.60393977e-01f, 4.60127294e-02f, -1.02071196e-01f, 1.13670662e-01f, -3.61280069e-02f, 2.75361568e-01f, 3.74259017e-02f, -9.98786241e-02f, -1.86447769e-01f, -1.29989877e-01f,
  -1.22495241e-01f, -1.04092799e-01f, -2.21042652e-02f, -3.08192611e-01f, -1.81072235e-01f, 3.53585593e-02f, -1.85534135e-01f, -1.11477844e-01f, -2.40952894e-03f, -1.08307697e-01f,
  2.51780719e-01f, -2.08731323e-01f, 6.40082657e-02f, 8.83528069e-02f, -9.08192396e-02f, -1.39789507e-01f, -1.62387937e-01f, -1.47431716e-01f, 2.19406083e-01f, 1.19340412e-01f,
  6.77517951e-02f, 1.10806607e-01f, -2.87144277e-02f, 4.24018688e-02f, 1.12268552e-01f, -2.51163449e-02f, -5.84180839e-02f, 1.17262349e-01f, -2.51882881e-01f, 3.72674987e-02f,
  -3.30013037e-01f, -7.24780373e-03f, -1.83650494e-01f, 1.03600837e-01f, 6.34959638e-02f, -4.96614873e-02f, 8.49353746e-02f, 1.39127504e-02f, 2.30887663e-02f, 8.20587482e-03f,
  -7.26946257e-03f, -8.50315765e-02f, 3.51966321e-02f, 1.00493684e-01f, 1.87823415e-01f, -1.38827786e-01f, 1.60868675e-01f, -6.88005909e-02f, 2.65131965e-02f, 7.70935640e-02f,
  -2.55723178e-01f, 1.21387884e-01f, -2.70491421e-01f, -1.66637406e-01f, -1.91573471e-01f, -1.81737050e-01f, -1.17700836e-02f, 2.84349382e-01f, -2.42194217e-02f, 1.21203095e-01f,
  1.56327322e-01f, -1.55271003e-02f, -5.10317385e-02f, 7.24640563e-02f, 4.76884991e-02f, 4.66060862e-02f, -1.75539553e-02f, -2.13766292e-01f, -1.56868339e-01f, 8.67978483e-02f,
  2.83758581e-01f, 2.18423456e-01f, 7.98320621e-02f, -2.56293237e-01f, -1.62299395e-01f, 2.74807289e-02f, -5.65013755e-03f, 2.39376813e-01f, -6.62668049e-02f, -7.94225335e-02f,
  2.87498161e-02f, -1.22475922e-01f, -1.12288207e-01f, -9.55373198e-02f, 1.58080786e-01f, -1.94255635e-01f, -4.63463031e-02f, -1.37559533e-01f, 1.45441115e-01f, 2.76506186e-01f,
  -4.14556488e-02f, 1.57705322e-01f, -1.63545310e-02f, 2.18174723e-03f, -2.70065844e-01f, 2.09938914e-01f, -3.08234300e-02f, 3.71505201e-01f, 2.10057013e-02f, -1.12470426e-02f,
  -1.72635004e-01f, -1.35795817e-01f, -4.47208695e-02f, 8.64754766e-02f, -9.01791975e-02f, -1.16339773e-01f, 4.86402474e-02f, -1.11089006e-01f, 1.10026211e-01f, -1.27627850e-01f,
  1.00668825e-01f, -1.05101585e-01f, -8.89466330e-02f, 3.05160433e-01f, -4.91451249e-02f, -2.04163194e-01f, -3.10191095e-01f, -2.95931716e-02f, 1.39125541e-01f, 1.79990828e-02f,
  1.56310454e-01f, -5.91886155e-02f, -3.47932093e-02f, 1.28980458e-01f, -1.26858264e-01f, 9.22557488e-02f, 6.95791692e-02f, 2.90842019e-02f, 9.53434408e-02f, -3.65327932e-02f,
  -6.07720055e-02f, -2.55435437e-01f, 6.55975416e-02f, -1.79211363e-01f, 1.73846066e-01f, -4.44682725e-02f, 1.11630403e-01f, -1.34357512e-01f, 1.50372282e-01f, -6.31844550e-02f,
  3.08205038e-02f, 1.10248685e-01f, 2.00457156e-01f, -2.84029365e-01f, 1.30639046e-01f, -2.14900479e-01f, -4.69043851e-03f, -1.33448407e-01f, 2.43833631e-01f, -1.23283425e-02f,
  -2.33075410e-01f, -5.71231209e-02f, -6.80504069e-02f, 6.81754127e-02f, -1.27754286e-01f, 1.99211881e-01f, 9.51749608e-02f, 2.42757774e-03f, -2.74471462e-01f, -2.93907225e-01f,
  -8.24105069e-02f, 1.22433379e-02f, -4.97764014e-02f, -6.99307099e-02f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.77888535e-02f, 1.25012949e-01f, 1.48226693e-01f, 1.74609631e-01f, 1.57097399e-01f, 8.59781802e-02f, -2.84233829e-03f, -8.98146629e-02f, 7.72698596e-02f, -2.35305484e-02f,
  1.19213924e-01f, 2.41429382e-03f, 1.29399016e-01f, 2.04081610e-01f, 2.38871276e-01f, 2.12019354e-01f, -2.61977941e-01f, -2.91904002e-01f, 1.43575162e-01f, 2.91281760e-01f,
  8.76072347e-02f, -8.36155340e-02f, 4.73833904e-02f, -1.97812736e-01f, 3.20419401e-01f, 2.82161850e-02f, 2.69443601e-01f, 4.53758128e-02f, 4.10860218e-02f, -4.08347189e-01f,
  7.51193687e-02f, -2.75468230e-01f, -1.55947417e-01f, 2.89823502e-01f, 6.56510711e-01f, -1.65280417e-01f, -1.41333863e-01f, -3.20384324e-01f, -2.20444221e-02f, 1.16000541e-01f,
  -3.36803459e-02f, -1.08815804e-01f, -4.93808985e-02f, 1.62024349e-01f, -3.20439190e-02f, 3.62652093e-01f, 2.95474054e-03f, -4.12703305e-02f, -1.28383443e-01f, -3.09770554e-02f,
  2.73317069e-01f, 1.79387778e-02f, -1.51420295e-01f, -2.63191126e-02f, -4.20738995e-01f, 2.30931237e-01f, 3.14432867e-02f, 4.23542112e-02f, 2.67946422e-01f, 2.63802171e-01f,
  5.04047796e-03f, 1.07186839e-01f, -2.01267958e-01f, -2.61843149e-02f, -1.26322463e-01f, -2.11585507e-01f, -1.22272491e-01f, 3.67393680e-02f, -1.26034200e-01f, -2.67348677e-01f,
  1.34504214e-01f, -1.98817775e-02f, -2.66434729e-01f, -1.77952237e-02f, -7.08756968e-02f, -2.02022027e-02f, 5.43525033e-02f, -8.96482915e-02f, -2.61583887e-02f, -5.80733418e-02f,
  1.69943839e-01f, 2.68133074e-01f, -1.19844973e-02f, 4.53664698e-02f, 1.29361749e-01f, 6.78391661e-03f, -6.12504967e-02f, 1.58211082e-01f, -3.59875597e-02f, -9.03704856e-03f,
  -5.47060817e-02f, -3.53164881e-01f, -1.09631218e-01f, 4.55328465e-01f, 1.20546713e-01f, -2.98605468e-02f, 8.75175968e-02f, -3.18766803e-01f, -2.22425565e-01f, 1.74448565e-01f,
  2.50345856e-01f, 1.92533866e-01f, 2.99161315e-01f, 1.54294163e-01f, -4.67105545e-02f, 7.15983137e-02f, 2.30829775e-01f, -6.03898428e-02f, -1.86880492e-02f, -1.44261867e-01f,
  4.87402007e-02f, 3.71560641e-02f, 1.22299299e-01f, -8.06289725e-03f, -1.56616345e-01f, 2.60836452e-01f, 5.41013628e-02f, -2.34036371e-02f, 1.82522282e-01f, -2.14533314e-01f,
  1.14276353e-02f, 1.94402099e-01f, 4.86810021e-02f, -2.22033605e-01f, 1.42107159e-01f, 2.31474731e-02f, 2.67216384e-01f, 3.73043157e-02f, 8.70299265e-02f, 2.41137028e-01f,
  1.70527741e-01f, -1.08634979e-01f, 8.33479017e-02f, 2.40973994e-01f, 2.51014590e-01f, -1.15320362e-01f, -1.09545164e-01f, 2.30291575e-01f, -2.37783328e-01f, 7.42498562e-02f,
  -9.68792289e-02f, -1.51859775e-01f, 3.96103472e-01f, 3.21521729e-01f, 5.27742922e-01f, 1.30675688e-01f, -5.81178330e-02f, 2.11743832e-01f, 7.25626806e-03f, 9.40790474e-02f,
  -2.32667103e-01f, 1.24564774e-01f, 1.76599815e-01f, 1.92337275e-01f, -2.18079731e-01f, 2.95430738e-02f, 1.90803632e-02f, -1.49284840e-01f, -4.88507859e-02f, 5.26194811e-01f,
  1.04577160e-02f, 1.72889441e-01f, -4.48967069e-01f, 1.28068879e-01f, -1.65266410e-01f, 2.99527705e-01f, 3.29322904e-01f, -1.76867582e-02f, 1.21858910e-01f, -3.81678760e-01f,
  1.68750092e-01f, 4.18613791e-01f, 1.54538278e-03f, 2.97950447e-01f, 3.42306137e-01f, 1.30076125e-01f, -1.18613280e-01f, -1.73859239e-01f, 4.97627467e-01f, 1.48638368e-01f,
  1.10913359e-01f, -2.90049911e-01f, -2.20680479e-02f, -1.67095765e-01f, -8.94972682e-02f, 2.13251412e-01f, 3.74666601e-01f, 1.56176686e-01f, 3.05430591e-01f, -1.84848696e-01f,
  1.80604443e-01f, 1.27857223e-01f, 7.55885094e-02f, 1.12869665e-01f, 1.90341830e-01f, 3.81618435e-03f, 1.32008806e-01f, 6.61437213e-02f, -1.09287679e-01f, -6.03993125e-02f,
  3.13122980e-02f, 7.72631690e-02f, -3.59185487e-02f, 4.28076135e-03f, -8.58604349e-03f, 1.21488072e-01f, 3.17329228e-01f, -2.52405256e-01f, 4.55309689e-01f, -1.57885417e-01f,
  -1.01429865e-01f, -9.32809040e-02f, -4.83884886e-02f, 2.14746505e-01f, -1.19743221e-01f, 5.10904565e-02f, 1.11267939e-01f, 1.42083690e-01f, -2.59495229e-01f, 9.74674821e-02f,
  -1.46464333e-01f, -3.57625157e-01f, -6.46302328e-02f, 2.24948809e-01f, 2.17043415e-01f, 2.35468566e-01f, -2.36801028e-01f, -1.56484008e-01f, -1.72289029e-01f, 4.03280288e-01f,
  1.26411006e-01f, 1.57221109e-01f, 2.51425114e-02f, -3.33224721e-02f, -2.68905729e-01f, 1.36768416e-01f, -6.23417646e-02f, 3.39440346e-01f, 1.55174181e-01f, 6.20099425e-01f,
  -3.57070938e-02f, -6.54312456e-03f, 4.75949049e-02f, -8.93242285e-03f, 4.16892797e-01f, 5.79044130e-03f, 4.68230873e-01f, 2.33348608e-01f, -8.71276483e-02f, 2.94536889e-01f,
  -3.87025326e-02f, 1.70058191e-01f, 9.56583209e-03f, 9.70702767e-02f, 1.66390583e-01f, -2.45438069e-01f, 2.43132800e-01f, 2.93962270e-01f, 2.70681113e-01f, 2.33662322e-01f,
  1.27807990e-01f, 1.74035445e-01f, 3.08940671e-02f, 1.41576484e-01f, 1.11461438e-01f, -1.03087544e-01f, 1.35668710e-01f, 1.81988120e-01f, -1.15052119e-01f, -6.69994131e-02f,
  7.84786195e-02f, 2.66196370e-01f, 2.60487884e-01f, 2.07334399e-01f, -1.62411958e-01f, -2.93173313e-01f, 7.90736228e-02f, -4.89150546e-02f, 4.06859480e-02f, -1.44172594e-01f,
  -5.28140292e-02f, -2.30518878e-01f, 8.12721327e-02f, 4.00453061e-01f, 2.36645728e-01f, -2.11347297e-01f, 1.11114129e-01f, 3.27062130e-01f, 4.38056476e-02f, 3.79451156e-01f,
  3.36551636e-01f, 1.14492543e-01f, -1.59012467e-01f, 3.98800790e-01f, -2.20739529e-01f, 4.28836010e-02f, 1.45828247e-01f, -1.26381695e-01f, -4.01978701e-01f, 2.77870536e-01f,
  1.13407277e-01f, 1.04077153e-01f, -2.72298735e-02f, 3.78195196e-01f, -2.03705281e-01f, -2.81518459e-01f, 5.12749292e-02f, -7.79996663e-02f, 2.96636075e-02f, 1.17732115e-01f,
  3.86052430e-01f, 2.23646924e-01f, 1.24525227e-01f, -1.96423858e-01f, -1.11657880e-01f, 4.76262778e-01f, -1.35767862e-01f, 2.75520116e-01f, 8.51944461e-02f, -1.44284785e-01f,
  1.48090392e-01f, 5.96277229e-02f, -1.16836308e-02f, -8.12200308e-02f, 1.90443043e-02f, 9.35765207e-02f, 2.06334293e-01f, -1.03526592e-01f, 1.73155144e-01f, 5.87024428e-02f,
  -1.26328185e-01f, 1.16669685e-01f, -8.26433674e-02f, 1.47804826e-01f, 5.45545220e-01f, -2.36683995e-01f, 2.76899934e-01f, -6.46084398e-02f, -4.57266495e-02f, 6.50274456e-02f,
  -1.55954331e-01f, 2.65972942e-01f, -1.29272759e-01f, 1.74208418e-01f, -2.88240071e-02f, -5.99340275e-02f, -2.85989702e-01f, -2.38334835e-01f, -1.02460884e-01f, -2.75842190e-01f,
  -2.17049167e-01f, -3.52222249e-02f, -1.02869570e-02f, 2.64904648e-01f, -4.23464209e-01f, -6.91170022e-02f, -7.60983825e-02f, 1.41198426e-01f, 4.77737218e-01f, 3.18207949e-01f,
  2.46171802e-01f, -1.40225470e-01f, -1.71630979e-01f, -1.64423287e-02f, -4.91101928e-02f, 3.41620266e-01f, 2.26816326e-01f, 2.18418375e-01f, -3.14398296e-02f, -1.14939194e-02f,
  1.43241122e-01f, 1.57782584e-01f, 2.29917586e-01f, -1.69408336e-01f, 2.51661003e-01f, 1.44575581e-01f, -1.33164331e-01f, 3.14432144e-01f, 4.83178757e-02f, -8.25778395e-02f,
  5.35990708e-02f, -1.50265142e-01f, 1.94087133e-01f, -2.43541375e-01f, 1.09565921e-01f, 2.04664826e-01f, -1.07514374e-01f, 5.66240363e-02f, 2.00295538e-01f, 1.59136746e-02f,
  2.29601279e-01f, -7.05900714e-02f, -5.05795740e-02f, 1.70643955e-01f, -1.83708742e-01f, -6.96368292e-02f, -1.64365917e-02f, -7.30280057e-02f, 3.01538855e-01f, -4.04939428e-02f,
  -2.28096917e-01f, -2.13674292e-01f, 2.47098997e-01f, 1.70429163e-02f, 1.42460987e-01f, -1.37333497e-01f, 3.99955176e-02f, -2.65321851e-01f, -1.38703823e-01f, -1.50340453e-01f,
  -6.82985857e-02f, 3.82081747e-01f, 3.08237672e-02f, 3.04411888e-01f, 2.34688781e-02f, -2.77717024e-01f, 9.18829516e-02f, -6.67237267e-02f, 1.48859978e-01f, 2.46207461e-01f,
  1.77418292e-01f, -5.11686325e-01f, -1.84788331e-01f, 1.96235970e-01f, -1.26273870e-01f, 1.13673285e-01f, 2.54701614e-01f, 2.75403857e-01f, -1.23644747e-01f, 2.66120136e-01f,
  8.86136144e-02f, -2.70529717e-01f, 1.10640801e-01f, 1.48024976e-01f, -3.80382035e-03f, 3.29396695e-01f, 5.03087789e-02f, 7.42297471e-02f, -3.27051878e-01f, -2.94201195e-01f,
  1.63471997e-01f, 1.17498137e-01f, 3.61543804e-01f, 7.56014138e-02f, 2.27514565e-01f, -7.27390274e-02f, 9.09211263e-02f, -5.18355109e-02f, 7.04603642e-02f, 1.96903452e-01f,
  1.24878041e-01f, 1.92225933e-01f, 2.24488705e-01f, 1.68175027e-01f, -6.30108491e-02f, -6.39642328e-02f, -9.24548283e-02f, -8.51489380e-02f, 1.58619672e-01f, -2.61197407e-02f,
  -7.43030570e-04f, 3.33062977e-01f, -1.43260285e-01f, 1.63144782e-01f, 3.30663562e-01f, 1.14529364e-01f, -5.37040420e-02f, -2.56051749e-01f, 1.50509238e-01f, 3.79810899e-01f,
  -9.17780399e-02f, 1.74862280e-01f, -6.29339889e-02f, -4.60808948e-02f, -1.97133869e-01f, 3.17419946e-01f, 2.72492379e-01f, -3.89502525e-01f, -2.82948375e-01f, 3.90157282e-01f,
  -2.42814180e-02f, 1.90145507e-01f, 1.74276263e-01f, -2.68957973e-03f, 7.35356137e-02f, 3.99904639e-01f, 5.15411161e-02f, -1.65791679e-02f, 2.17581674e-01f, 2.84909327e-02f,
  -7.77292326e-02f, 3.00719827e-01f, 1.19638860e-01f, 1.16373509e-01f, 1.11575574e-01f, 4.56004322e-01f, 1.36829559e-02f, 5.35447374e-02f, -1.78293914e-01f, -1.27000690e-01f,
  -4.53218892e-02f, 1.58431515e-01f, 3.15037638e-01f, 4.71876264e-01f, 1.58463642e-01f, 1.45014459e-02f, -3.60855252e-01f, -1.15344971e-01f, -2.14114919e-01f, 1.89141527e-01f,
  -6.58514053e-02f, -1.05321288e-01f, 2.03534156e-01f, -3.95245962e-02f, 1.39339879e-01f, 1.16434477e-01f, 2.11113572e-01f, 1.87051833e-01f, 1.27787217e-01f, 1.92591012e-01f,
  2.55703121e-01f, 5.78254424e-02f, 3.65553856e-01f, 1.50605053e-01f, -2.54739285e-01f, -1.10278027e-02f, 1.26460820e-01f, 1.60576493e-01f, 2.47883368e-02f, -1.83778137e-01f,
  -2.53105104e-01f, -4.04139087e-02f, 1.97048873e-01f, 2.39881128e-01f, -7.14002028e-02f, -5.75775187e-03f, -1.53013617e-01f, -1.43275499e-01f, -1.49865001e-01f, -9.93846580e-02f,
  1.05683990e-01f, -1.79334894e-01f, -1.08563408e-01f, -2.66973495e-01f, 2.89868116e-02f, 3.42576504e-01f, 1.74102619e-01f, 1.54334486e-01f, -2.89344400e-01f, -1.61860466e-01f,
  -2.45609820e-01f, 1.16202027e-01f, 3.07228595e-01f, 3.59945476e-01f, -3.39508384e-01f, 1.30879655e-01f, -9.66080949e-02f, 5.58999553e-02f, 2.42342636e-01f, 2.77632684e-01f,
  1.45051643e-01f, 2.47001313e-02f, -1.81256935e-01f, 1.37044743e-01f, 4.16845024e-01f, 3.19269180e-01f, 2.08017245e-01f, 1.93741634e-01f, -2.81278491e-01f, 6.96846247e-02f,
  -1.35537401e-01f, 2.70834744e-01f, -3.51710618e-02f, 3.23710352e-01f, 1.65973648e-01f, -1.38753708e-02f, 9.60111432e-03f, 2.61432439e-01f, 1.88942000e-01f, 3.81287420e-03f,
  1.71274409e-01f, 8.69252980e-02f, 1.90324619e-01f, 2.88272172e-01f, 1.67568386e-01f, 7.46901333e-02f, 2.81007409e-01f, 1.25084475e-01f, -1.76514402e-01f, 1.17721520e-01f,
  -3.53833348e-01f, 1.12716213e-01f, -3.39963019e-01f, -1.04717255e-01f, 1.29836917e-01f, -2.07625538e-01f, 5.89151680e-02f, 3.06122005e-02f, -3.32775801e-01f, 3.51800621e-02f,
  -2.36732587e-02f, -5.65776229e-02f, 2.20966805e-02f, 9.56328362e-02f, 3.26148242e-01f, 3.47053893e-02f, -2.30963733e-02f, -3.02212059e-01f, -1.14116371e-02f, 1.08409271e-01f,
  2.00629294e-01f, 4.58339155e-02f, 3.72407585e-02f, -1.14054292e-01f, -2.64328718e-01f, -2.33493149e-02f, 3.77839088e-01f, 4.68164772e-01f, 1.48867711e-01f, 5.03207091e-04f,
  2.06949696e-01f, -7.65990652e-03f, 7.03916252e-02f, -1.51486367e-01f, 2.69010246e-01f, -3.60047445e-02f, -1.02732152e-01f, 2.05781460e-01f, 1.04792580e-01f, 1.81326807e-01f,
  1.96402043e-01f, 4.18328971e-01f, 5.52328639e-02f, 9.10993665e-02f, -1.06148189e-02f, -1.48714557e-01f, -9.98741984e-02f, 3.58082712e-01f, -1.64432883e-01f, -1.22571371e-01f,
  -1.44580631e-02f, -1.16883561e-01f, 3.93544845e-02f, -4.37589735e-02f, 1.54134944e-01f, -1.02119017e-02f, -2.27948502e-01f, 1.58136263e-01f, -8.10758770e-02f, -1.01068929e-01f,
  1.98312595e-01f, -2.56155040e-02f, -1.75506368e-01f, 2.88776699e-02f, -5.39840274e-02f, -2.64442235e-01f, -4.33619163e-04f, 1.94667086e-01f, 3.28951403e-02f, -2.09726989e-02f,
  1.20388635e-01f, 5.12937792e-02f, 5.61877452e-02f, 2.18219668e-01f, 5.39837638e-03f, 1.44416690e-01f, 2.20252983e-02f, -1.31561328e-02f, -6.15973063e-02f, 3.21418017e-01f,
  -1.80734210e-02f, 2.77308136e-01f, 1.85032323e-01f, -4.08538729e-02f, -2.98737109e-01f, 1.01491630e-01f, 4.31871973e-02f, 2.46638298e-01f, 1.18776008e-01f, -1.79657973e-02f,
  8.34817141e-02f, 3.10247213e-01f, 1.58930391e-01f, -2.91291028e-01f, 3.73539440e-02f, -8.91287327e-02f, 2.06820473e-01f, 4.66324650e-02f, 2.16316193e-01f, 6.42041559e-04f,
  -2.00007424e-01f, 7.69182295e-02f, 1.82494909e-01f, 2.92261243e-01f, 2.99428940e-01f, 1.27060682e-01f, 1.40877748e-02f, 2.95698252e-02f, 3.91425714e-02f, -1.88638985e-01f,
  -1.77326575e-01f, 1.98194623e-01f, 7.28872642e-02f, 4.97889007e-03f, -1.11076340e-01f, 1.42363936e-01f, 1.90325789e-02f, -8.19713622e-02f, -5.98287061e-02f, -2.08820403e-01f,
  6.35401346e-03f, 3.19058411e-02f, 1.36711285e-01f, -2.98049271e-01f, 9.51117501e-02f, -1.58846408e-01f, -4.43699881e-02f, -1.96933076e-01f, -5.54717898e-01f, 2.21482977e-01f,
  -3.33636075e-01f, 3.01559061e-01f, 7.25932866e-02f, 2.93879926e-01f, -5.85235953e-02f, -3.22930783e-01f, 7.08765164e-02f, 1.94993421e-01f, 4.52540517e-02f, -1.02374442e-01f,
  1.55975983e-01f, -6.30965736e-03f, 1.11124098e-01f, -2.24948805e-02f, 2.12197363e-01f, -8.98799971e-02f, 2.92324156e-01f, 1.55699164e-01f, 9.03399438e-02f, -1.06318884e-01f,
  1.01908229e-01f, -3.59508172e-02f, -1.93083510e-01f, -3.45882714e-01f, 1.75574452e-01f, 1.26650363e-01f, 9.58807543e-02f, -4.69733089e-01f, 2.51540393e-01f, -1.84195369e-01f,
  -1.27600282e-01f, -3.29653502e-01f, 1.12514034e-01f, 1.11947365e-01f, 3.25296760e-01f, -3.23176682e-01f, -4.33674715e-02f, 1.38732359e-01f, -1.54868156e-01f, 1.42664880e-01f,
  -9.50475037e-02f, -1.53966933e-01f, 3.07128690e-02f, 1.52967438e-01f, 2.08992913e-01f, 1.77089915e-01f, -1.64873317e-01f, 2.20492601e-01f, 1.19671814e-01f, 1.36100695e-01f,
  5.79760149e-02f, -7.72402361e-02f, 1.53045222e-01f, -1.58966213e-01f, -7.00184405e-02f, -1.22616641e-01f, -2.95078993e-01f, -2.31366470e-01f, 6.80993497e-02f, -1.89886376e-01f,
  -1.16800591e-01f, 4.98164222e-02f, 3.07448149e-01f, -2.00891457e-02f, -1.53283998e-01f, 2.55570769e-01f, 3.25862497e-01f, -7.53010213e-02f, -3.58490320e-03f, 9.93085280e-02f,
  -1.09307602e-01f, 1.77688271e-01f, 9.95957702e-02f, 7.28026107e-02f, -7.87694082e-02f, -2.21724138e-01f, 3.31797972e-02f, 4.50524479e-01f, -1.29674301e-01f, 5.52007705e-02f,
  -8.99570510e-02f, -3.92812848e-01f, -1.32911041e-01f, 1.19932787e-02f, 1.20000377e-01f, -2.38189816e-01f, 4.03684050e-01f, -1.17045697e-02f, -1.51847869e-01f, 7.06854612e-02f,
  3.13064396e-01f, -2.41110191e-01f, 6.03977926e-02f, -4.11827937e-02f, 1.04407631e-01f, -4.00219232e-01f, 1.89552084e-01f, -6.70684129e-02f, 1.87231794e-01f, 2.58098722e-01f,
  -4.97332513e-02f, 3.12951654e-02f, -1.79454744e-01f, -1.58956230e-01f, 7.64987469e-02f, 5.32956049e-02f, 2.11439505e-01f, -2.36795515e-01f, 1.21786937e-01f, -2.65179053e-02f,
  1.20473057e-01f, 1.27503321e-01f, 7.66755641e-02f, 4.25443538e-02f, 2.33895361e-01f, 8.24434981e-02f, 2.36786038e-01f, 1.21918209e-01f, 1.19124860e-01f, 2.03395188e-01f,
  1.90819740e-01f, -1.40011132e-01f, -4.70124632e-02f, 6.26839325e-02f, -1.41673073e-01f, -3.31409633e-01f, -1.16075441e-01f, 2.65162557e-01f, -4.17434126e-01f, 1.77369967e-01f,
  2.10418746e-01f, 3.92442867e-02f, 1.59867331e-01f, -2.46191025e-01f, 2.28654683e-01f, -2.00484842e-01f, 9.27367732e-02f, -1.19045392e-01f, 3.10825072e-02f, 1.84237540e-01f,
  1.81887791e-01f, 3.98104966e-01f, 3.48629475e-01f, -3.43746632e-01f, 2.50691861e-01f, 1.62406832e-01f, 4.67370003e-02f, 2.24950597e-01f, -9.67904776e-02f, -2.52212971e-01f,
  -2.10139919e-02f, -2.63753403e-02f, -1.03696309e-01f, 2.98392355e-01f, 6.06063046e-02f, -2.54847229e-01f, -3.06124054e-03f, -2.23510370e-01f, 2.79822275e-02f, -4.12651896e-01f,
  1.98666751e-01f, -2.77749412e-02f, -2.70342618e-01f, 1.78785220e-01f, 1.47798344e-01f, 3.14584583e-01f, -1.98260754e-01f, -2.35058665e-01f, 7.80346841e-02f, -1.59190044e-01f,
  2.55729765e-01f, 3.60211670e-01f, -8.93543735e-02f, 3.97482485e-01f, 2.24322855e-01f, -5.73898628e-02f, 4.82264571e-02f, 6.21913709e-02f, 1.23708606e-01f, 1.92184970e-01f,
  1.05539516e-01f, 2.38498986e-01f, 3.26781750e-01f, -2.36524284e-01f, 4.20568660e-02f, 1.75768733e-01f, -1.96999460e-01f, -5.72620928e-02f, -2.54610956e-01f, 2.22401142e-01f,
  3.03867877e-01f, 3.68644029e-01f, 1.06374929e-02f, 1.66731372e-01f, 3.87738973e-01f, 8.89409482e-02f, -7.84680396e-02f, -2.11697370e-01f, -6.66835234e-02f, 2.00125903e-01f,
  -1.30606994e-01f, 4.12582532e-02f, 6.51417077e-02f, -9.42318290e-02f, 2.85184562e-01f, 1.67624503e-01f, -2.02999249e-01f, -3.06491464e-01f, -1.96244463e-01f, -1.48244813e-01f,
  3.71431634e-02f, 4.49271128e-02f, -1.16538189e-01f, 2.48384550e-01f, 4.04693842e-01f, 1.73505098e-01f, 1.94246665e-01f, -2.41409108e-01f, 2.23484516e-01f, 1.96785301e-01f,
  2.71921366e-01f, -4.27413583e-02f, 1.08250789e-01f, 2.60762516e-02f, -1.53613061e-01f, 1.95746019e-04f, 4.46739495e-01f, 3.40059876e-01f, -1.79330930e-01f, -1.26547217e-01f,
  -1.23303659e-01f, 1.63742498e-01f, 1.03429012e-01f, -7.20610097e-02f, 2.16103479e-01f, -4.60383475e-01f, 1.27781555e-01f, 2.33697638e-01f, -2.98369545e-02f, -3.19716841e-01f,
  2.76106875e-02f, -1.27712600e-02f, 1.01075135e-01f, 1.13966636e-01f, 4.00226600e-02f, 2.93657124e-01f, 6.28272863e-03f, -4.97815274e-02f, -1.09095424e-01f, -1.22093759e-01f,
  -2.07628056e-01f, 2.94092931e-02f, -2.16238037e-01f, 5.92252612e-02f, 2.24013507e-01f, 1.56778619e-02f, 3.37028094e-02f, 8.90852958e-02f, 4.50300097e-01f, 7.89583400e-02f,
  1.83937445e-01f, -9.25196335e-02f, -2.00349800e-02f, -2.76052882e-03f, 1.21959165e-01f, 1.78048670e-01f, 1.04777232e-01f, 2.45291859e-01f, 2.67983019e-01f, 3.95906776e-01f,
  1.98870733e-01f, 1.18956350e-01f, 2.34549746e-01f, -4.64097589e-01f, 2.52016243e-02f, -9.62558854e-03f, 1.62640959e-01f, 1.08452998e-01f, 3.02825719e-01f, 1.88643813e-01f,
  -2.50782758e-01f, 2.42053363e-02f, 4.27176684e-01f, 1.91962793e-01f, 1.94217041e-02f, 1.13068864e-01f, 2.23494917e-02f, -2.79150963e-01f, 1.34192854e-01f, 1.54409679e-02f,
  -5.54736294e-02f, 3.11735660e-01f, -2.27071941e-01f, -1.92199543e-01f, 4.33664173e-02f, -2.67506205e-02f, 2.63497561e-01f, 8.28801244e-02f, 2.58991867e-01f, -3.98019761e-01f,
  1.05415517e-02f, -1.35494038e-01f, 1.33255944e-02f, 1.59866288e-02f, -8.30135681e-03f, 1.15954198e-01f, 1.34356603e-01f, 7.80327022e-02f, 1.87762547e-02f, -1.01376511e-01f,
  1.44872323e-01f, -6.07791618e-02f, 1.09948136e-01f, 4.00008149e-02f, -2.98150312e-02f, 5.43834604e-02f, -1.22047663e-01f, 1.09676301e-01f, 9.59951431e-02f, 3.81523579e-01f,
  2.22704381e-01f, 2.13266253e-01f, -4.05121952e-01f, -6.74117133e-02f, 3.92676182e-02f, 1.09303348e-01f, -1.73643142e-01f, 4.73517329e-01f, -6.13369159e-02f, -4.07841392e-02f,
  -2.60934196e-02f, -1.91351071e-01f, 2.68252581e-01f, -1.36633441e-01f, -1.37109175e-01f, -4.39369678e-02f, -1.07149623e-01f, 3.68735641e-01f, -3.37946087e-01f, 8.13227817e-02f,
  -2.66290367e-01f, 4.16301191e-01f, 2.34212115e-01f, 1.77688226e-01f, 5.87924480e-01f, 1.28646612e-01f, -1.36778235e-01f, 2.15973496e-01f, 2.34747335e-01f, -8.77313986e-02f,
  4.71338272e-01f, 2.75186479e-01f, 3.28458771e-02f, -2.93776579e-02f, 4.27529156e-01f, 7.65473396e-02f, 1.24720655e-01f, 2.29859445e-02f, 1.67071715e-01f, 2.91250110e-01f,
  -4.14874673e-01f, 3.06589574e-01f, -1.92286938e-01f, -1.76804259e-01f, 1.52072459e-01f, 1.76409200e-01f, 2.67268449e-01f, 2.20157027e-01f, 7.12804049e-02f, 1.92812249e-01f,
  1.35637462e-01f, 1.56958342e-01f, 1.81089699e-01f, -1.25485472e-02f, 6.27364814e-02f, -2.29165442e-02f, -8.42026696e-02f, 4.22551781e-02f, 2.71963924e-02f, 6.52019829e-02f,
  -2.17992634e-01f, -1.27230436e-01f, -1.12087555e-01f, 1.49473444e-01f, 3.74199361e-01f, 2.29379311e-01f, -4.87407744e-01f, -1.45974934e-01f, 1.19367979e-01f, -1.63662255e-01f,
  2.13016286e-01f, 5.18526807e-02f, 3.99193205e-02f, -1.07597195e-01f, 1.46277502e-01f, 3.25698644e-01f, 7.78484046e-02f, 2.59184808e-01f, -4.61381748e-02f, 3.07553172e-01f,
  -2.12918837e-02f, 1.85640261e-01f, 2.92106450e-01f, 1.16968885e-01f, -1.00250088e-01f, 1.98581636e-01f, -1.19234152e-01f, -3.23444635e-01f, -4.67098914e-02f, -2.90456295e-01f,
  -2.86020160e-01f, 6.84499562e-01f, 1.44667625e-01f, -1.67580433e-02f, 5.92833795e-02f, 2.51470923e-01f, 3.27720866e-02f, -2.47831658e-01f, 1.82840839e-01f, 1.51326254e-01f,
  -3.09793025e-01f, -1.19946882e-01f, -7.03606382e-02f, -1.63629919e-01f, 8.00268352e-02f, -4.06284742e-02f, -5.88307790e-02f, 2.74096519e-01f, 4.41615433e-02f, -7.38816038e-02f,
  1.69934686e-02f, 3.32882665e-02f, 7.98448026e-02f, 1.25421174e-02f, 8.44461396e-02f, 1.31104827e-01f, 1.98222071e-01f, 1.29828975e-01f, -1.58126965e-01f, 3.14704590e-02f,
  -3.16362493e-02f, -1.22566782e-01f, -1.70601442e-01f, 9.72263366e-02f, 1.68303214e-02f, -1.12894438e-01f, -1.40746891e-01f, 1.92129314e-01f, 1.95412189e-01f, 1.48558572e-01f,
  -3.97259220e-02f, 3.75617929e-02f, 7.03737065e-02f, 1.08429044e-02f, 2.67767280e-01f, 1.53360024e-01f, -4.98973541e-02f, -1.74848557e-01f, -8.10863748e-02f, 2.18809649e-01f,
  4.33183275e-02f, 3.42470616e-01f, 1.55326903e-01f, -1.40535027e-01f, 3.16562444e-01f, -2.56915428e-02f, -6.88368529e-02f, 2.39022866e-01f, -3.55440602e-02f, 2.26520877e-02f,
  2.10139707e-01f, -3.77895236e-02f, -6.70843851e-03f, 3.07678998e-01f, 1.28735155e-01f, 2.51967534e-02f, -2.19384804e-02f, -9.29647777e-03f, 1.82479337e-01f, -2.61243731e-02f,
  1.16093062e-01f, 4.90805171e-02f, -3.58836055e-01f, 2.77704179e-01f, 3.71648461e-01f, 3.97155374e-01f, -2.69897562e-02f, -2.69461900e-01f, 1.95124839e-02f, 1.33459911e-01f,
  1.79908901e-01f, 4.46720749e-01f, -8.66536051e-02f, 2.31482223e-01f, 2.27776304e-01f, 3.24046612e-02f, -3.55036557e-02f, -4.33428362e-02f, -2.94061843e-02f, 7.74893910e-02f,
  -1.50813619e-02f, 2.19813854e-01f, 3.04433614e-01f, -7.88417161e-02f, 3.21268886e-02f, 4.47947048e-02f, -7.99914002e-02f, -9.89854485e-02f, 3.27162221e-02f, 1.31721810e-01f,
  3.70280743e-01f, 9.29478705e-02f, 2.47401640e-01f, 3.03820103e-01f, 3.47149462e-01f, 4.18079972e-01f, 3.47995795e-02f, -1.79517433e-01f, 1.13096815e-02f, 2.51318246e-01f,
  -2.07946435e-01f, 2.97583919e-02f, 2.48528913e-01f, -1.11322492e-01f, 1.51647717e-01f, 3.18990201e-01f, 3.47527228e-02f, -1.64271995e-01f, 2.05965549e-01f, 9.54463109e-02f,
  -3.28495741e-01f, -2.62691379e-01f, -5.68366386e-02f, 2.45094478e-01f, 1.90023735e-01f, 1.85095757e-01f, 3.05149108e-01f, -3.43191028e-01f, 2.24535674e-01f, -3.09718307e-02f,
  1.89866319e-01f, 5.08258380e-02f, -5.37473299e-02f, -4.39511240e-02f, -1.32101595e-01f, 6.14128225e-02f, 2.72057116e-01f, 2.19635889e-01f, 4.74075526e-02f, -2.05665648e-01f,
  -2.09382270e-02f, 2.22188905e-02f, 9.30658579e-02f, -8.20900686e-03f, 1.28787562e-01f, -3.94660681e-01f, 5.28804734e-02f, -7.24621043e-02f, 1.37673542e-01f, -2.37598851e-01f,
  3.93343344e-02f, 1.49231091e-01f, 2.17227861e-01f, -4.81451042e-02f, 9.67119113e-02f, 2.48046041e-01f, 1.06806204e-01f, -8.85902569e-02f, -4.76745591e-02f, 1.20264500e-01f,
  -1.76858101e-02f, 6.02352358e-02f, 1.49260774e-01f, 3.02869678e-01f, 1.42419368e-01f, 1.26754612e-01f, 3.82596254e-02f, 2.19658881e-01f, 3.87731433e-01f, -4.22187820e-02f,
  1.92728359e-02f, 1.72770128e-01f, -1.80429965e-02f, 8.82382989e-02f, -1.36367232e-01f, -1.93596333e-01f, -1.71529979e-01f, -1.72808081e-01f, 3.04191828e-01f, 4.84474927e-01f,
  -1.52555510e-01f, -2.17814192e-01f, -3.34619498e-03f, -1.35871574e-01f, 2.42260029e-03f, 1.43464640e-01f, 3.54510069e-01f, -5.78666404e-02f, 8.17914978e-02f, 1.81071505e-01f,
  -3.51075791e-02f, 8.10880885e-02f, 2.93622375e-01f, -7.16215447e-02f, -2.59828474e-03f, -7.06766918e-02f, 1.95499182e-01f, -9.71713811e-02f, 2.18764424e-01f, -1.93801932e-02f,
  -7.04970658e-02f, 2.53728867e-01f, 1.50444761e-01f, 1.49484038e-01f, 2.14563414e-01f, -1.14639863e-01f, 1.61310017e-01f, 1.90627158e-01f, 1.92171380e-01f, -3.91414255e-01f,
  -5.22693507e-02f, -1.27418600e-02f, 9.78334397e-02f, -2.82600880e-01f, 2.27084070e-01f, 2.11380526e-01f, 7.57499635e-02f, -5.01045538e-03f, 1.28434049e-02f, 5.90768717e-02f,
  -2.35168785e-01f, -1.35365590e-01f, 1.39947370e-01f, -2.98697203e-01f, 3.47664833e-01f, 9.93228331e-03f, -1.32596418e-01f, 1.07086629e-01f, -3.01318973e-01f, 1.68845996e-01f,
  -5.64617813e-01f, 2.58954111e-02f, 5.67195900e-02f, -1.62031963e-01f, 5.10825124e-03f, -2.08898261e-01f, -1.47151142e-01f, -4.47882116e-02f, 2.65250236e-01f, 8.25093593e-03f,
  -4.74779643e-02f, 2.86011457e-01f, 4.92452495e-02f, -2.82102406e-01f, -5.82289807e-02f, 1.59568742e-01f, 1.59754418e-03f, 9.13404524e-02f, 2.24348828e-01f, -4.33230877e-01f,
  4.32238936e-01f, -2.25067332e-01f, -1.31949142e-01f, -9.46225747e-02f, -9.18734819e-03f, 2.54839391e-01f, 1.36832118e-01f, -5.43426037e-01f, -1.49997339e-01f, -8.76440331e-02f,
  -1.21321395e-01f, -2.70476013e-01f, 3.22429359e-01f, 9.48498324e-02f, 1.36573330e-01f, -1.66736335e-01f, -6.74387962e-02f, 4.00062680e-01f, 9.98322736e-04f, 1.18026681e-01f,
  1.55239254e-01f, -8.01071525e-02f, -3.43773142e-02f, 3.94482613e-01f, 2.39289790e-01f, 4.22776908e-01f, 1.72555540e-02f, 2.13751599e-01f, -1.93688031e-02f, -6.55158143e-03f,
  9.96647403e-02f, 2.10154250e-01f, 2.93094248e-01f, 1.18454412e-01f, -6.16688989e-02f, -5.99040836e-02f, 5.65763749e-02f, -3.90782533e-03f, 3.66154760e-02f, -1.56819057e-02f,
  1.30539760e-01f, 4.10382092e-01f, 7.67816603e-02f, -2.33769104e-01f, -2.12341443e-01f, -3.02005857e-01f, 1.36261404e-01f, -2.02781662e-01f, 1.93152413e-01f, 2.29482785e-01f,
  -4.71076407e-02f, -1.42707452e-01f, 7.28498027e-02f, -6.22343011e-02f, 1.83179185e-01f, 3.66248414e-02f, 4.07405198e-02f, -1.62843853e-01f, -1.56616606e-02f, 1.58525199e-01f,
  2.99685448e-01f, -5.09333760e-02f, 3.71206194e-01f, 8.26722607e-02f, 2.35796735e-01f, -1.48868948e-01f, -2.49383733e-01f, 2.30462685e-01f, -2.11135596e-01f, 2.28543371e-01f,
  4.07301411e-02f, -1.38678178e-01f, -1.16661310e-01f, 1.07061803e-01f, -1.78260997e-01f, 7.39818662e-02f, 1.34570822e-01f, -2.30822578e-01f, 3.94655690e-02f, -8.38674232e-02f,
  -5.91226220e-02f, 1.08359464e-01f, 3.25565279e-01f, 1.47545993e-01f, 1.52823552e-01f, 1.12321705e-01f, -2.23544412e-04f, -1.38584241e-01f, 3.04460991e-02f, 1.02399021e-01f,
  -3.57554406e-02f, 4.78290096e-02f, 1.32515118e-01f, 3.78865391e-01f, 2.79688910e-02f, 6.50368333e-02f, 2.41025954e-01f, 1.21480659e-01f, 1.74564049e-01f, 2.64950931e-01f,
  2.64643639e-01f, -4.41482700e-02f, 2.00493887e-01f, 1.25942498e-01f, -8.94027650e-02f, -1.78735271e-01f, -1.02489255e-01f, 3.59636694e-01f, -2.03991130e-01f, -1.14628680e-01f,
  -4.11165744e-01f, -4.25969288e-02f, 8.70048404e-02f, 1.52290314e-01f, 1.88218832e-01f, -7.13709593e-02f, 6.63505075e-03f, -1.27339825e-01f, -2.60854363e-01f, 8.44318345e-02f,
  1.59650624e-01f, 5.47338873e-02f, 1.11013800e-01f, -3.27716351e-01f, -4.87849675e-02f, 3.96252334e-01f, 1.37271434e-01f, 2.60093272e-01f, -3.32833201e-01f, -1.83244541e-01f,
  -2.99714476e-01f, 7.20873103e-03f, 2.04041243e-01f, 3.25874001e-01f, -1.61152124e-01f, 3.73893648e-01f, -1.62206724e-01f, 1.15000963e-01f, 1.70718163e-01f, 8.73793662e-02f,
  4.10283953e-02f, -1.49923697e-01f, 1.07360706e-02f, 1.92385271e-01f, 3.41123372e-01f, 4.59564149e-01f, -1.17881618e-01f, -6.94924593e-02f, -1.73946127e-01f, -1.75901260e-02f,
  1.51705936e-01f, 5.26951194e-01f, 8.28429461e-02f, 4.87774223e-01f, -2.53489278e-02f, 1.79960374e-02f, 8.46261438e-03f, 8.48727301e-02f, 5.10332398e-02f, 1.83148995e-01f,
  2.93096602e-01f, -1.66464003e-03f, 1.37416050e-01f, 1.77357439e-02f, 1.78446308e-01f, -9.07391906e-02f, 2.81799763e-01f, -7.91658312e-02f, -9.66164246e-02f, 2.90713280e-01f,
  -1.38926268e-01f, 4.87899706e-02f, -3.10377419e-01f, 1.72448218e-01f, -5.41890115e-02f, -3.02714378e-01f, 1.69711947e-01f, 4.05773818e-02f, -2.59273410e-01f, 1.99002400e-01f,
  -1.59745440e-01f, -9.39186364e-02f, 2.31840033e-02f, -1.11209303e-01f, 2.40835428e-01f, -1.62699416e-01f, -3.37089837e-01f, -3.29727709e-01f, 3.97002250e-02f, 2.00508252e-01f,
  6.69149384e-02f, 2.65834332e-01f, -8.08107555e-02f, 4.26705591e-02f, -3.26486558e-01f, -1.35689219e-02f, 3.34474802e-01f, 4.07782435e-01f, -1.36845876e-02f, -9.20250267e-02f,
  2.96225786e-01f, 6.12298660e-02f, 1.89818993e-01f, -1.23286329e-01f, 1.01924501e-01f, 9.36817378e-02f, -3.37174237e-02f, 1.58704698e-01f, 4.98399287e-01f, 1.69047773e-01f,
  -2.05710214e-02f, 3.15147966e-01f, -6.58062845e-02f, -8.10241252e-02f, 1.13402188e-01f, -1.30789399e-01f, -1.20863229e-01f, 2.30287746e-01f, 6.76517263e-02f, -1.81422666e-01f,
  9.92544368e-02f, 1.38947755e-01f, -1.92527175e-02f, 1.23873211e-01f, 9.94278491e-02f, -7.09196106e-02f, 2.30660453e-01f, -8.60697180e-02f, 2.94004649e-01f, 2.24115834e-01f,
  -2.19255239e-01f, 3.40289660e-02f, -5.12043014e-02f, 1.78475101e-02f, 2.77211815e-01f, 2.12767944e-01f, 3.85511756e-01f, 1.18340060e-01f, -8.35351050e-02f, 8.07513520e-02f,
  2.78128516e-02f, -1.43187657e-01f, -2.03913733e-01f, 4.35035340e-02f, 5.19983210e-02f, -7.75271729e-02f, -4.89710048e-02f, -2.15311944e-01f, 1.36075944e-01f, -4.26706344e-01f,
  -1.00244634e-01f, 3.36209163e-02f, -2.41558794e-02f, 3.02238017e-01f, -2.85360485e-01f, 1.52381752e-02f, -8.45217407e-02f, 1.45983055e-01f, 9.08385217e-02f, 1.30913898e-01f,
  2.18567178e-01f, -3.19990426e-01f, -3.66536677e-01f, 2.51685008e-02f, 2.83357680e-01f, 3.39068204e-01f, -5.06664813e-02f, 1.70549974e-01f, -2.05047846e-01f, -1.57199070e-01f,
  3.77821475e-01f, -2.93307658e-02f, 3.00621241e-01f, -5.05096242e-02f, 1.47708118e-01f, 4.38897088e-02f, -1.19540527e-01f, -2.72882059e-02f, 1.39655352e-01f, 9.02571436e-03f,
  2.39816219e-01f, 7.89483637e-03f, -1.35700583e-01f, -8.45999718e-02f, 1.70442268e-01f, 9.77250338e-02f, 1.62301034e-01f, 8.58845413e-02f, 5.81255145e-02f, -3.49531695e-03f,
  -1.55620545e-01f, -4.24790800e-01f, -6.32357225e-02f, -2.34591499e-01f, 2.49084458e-01f, -2.37437785e-01f, -2.04984263e-01f, 3.93633634e-01f, -1.61093339e-01f, 1.27986461e-01f,
  2.60176390e-01f, 3.84965129e-02f, -2.18737591e-02f, -7.77903721e-02f, -1.06274150e-01f, 2.68029779e-01f, -1.28801137e-01f, 4.85617220e-01f, 1.75603881e-01f, 4.39040305e-05f,
  1.58790112e-01f, -1.34472162e-01f, 3.74597646e-02f, -1.70206606e-01f, -3.96147013e-01f, 3.30883205e-01f, -1.26777133e-02f, 3.60518098e-01f, 3.88519078e-01f, -3.74056876e-01f,
  1.09702915e-01f, 3.15893620e-01f, 2.44070336e-01f, 2.29645474e-03f, 4.01854038e-01f, -6.77113160e-02f, -1.48546165e-02f, -2.69216802e-02f, 1.76118329e-01f, 1.80152431e-02f,
  1.53962806e-01f, 3.64217728e-01f, 3.14431667e-01f, -1.81103647e-01f, 6.12521470e-01f, -3.48048955e-01f, -2.50810217e-02f, -7.76623860e-02f, 1.75207078e-01f, 6.25646412e-01f,
  1.81251653e-02f, 3.32565486e-01f, -2.11294606e-01f, -1.03085086e-01f, 2.22378090e-01f, 1.77235133e-03f, 1.41130658e-02f, 1.38711840e-01f, 1.25089034e-01f, 4.78949733e-02f,
  7.34542832e-02f, -1.06995761e-01f, -1.04838461e-01f, -4.89485357e-03f, -9.41490754e-02f, -2.38524213e-01f, -1.36456728e-01f, -2.05648258e-01f, 2.89339006e-01f, -2.02961057e-01f,
  -7.38080740e-02f, 2.43122548e-01f, -1.99352503e-01f, 1.57677978e-01f, -1.52813435e-01f, 1.32324249e-01f, 2.32668016e-02f, -1.72255605e-01f, 1.27671584e-02f, 6.58984631e-02f,
  -2.43872151e-01f, 4.01133358e-01f, 1.24805592e-01f, 3.12866449e-01f, 1.31909460e-01f, -1.19376061e-02f, 1.60998300e-01f, 9.88160744e-02f, -1.43710062e-01f, 6.40328079e-02f,
  2.04047989e-02f, -2.08382145e-01f, 3.63883913e-01f, 6.33877441e-02f, 6.61770552e-02f, -7.49475062e-02f, 3.67600471e-01f, 6.96307868e-02f, 2.90394843e-01f, -1.05329059e-01f,
  3.69596034e-01f, 4.47148420e-02f, 1.79759815e-01f, -1.31270543e-01f, 1.44058585e-01f, 4.72704172e-02f, 3.68514895e-01f, -3.05478454e-01f, 3.73242408e-01f, -1.50471866e-01f,
  -1.45064726e-01f, -1.48656040e-01f, 2.09472656e-01f, 2.37847224e-01f, 1.27492160e-01f, 2.27951586e-01f, -4.09253091e-02f, -5.67106485e-01f, 4.05361466e-02f, 2.61364002e-02f,
  1.41437769e-01f, 3.53546977e-01f, 2.00258479e-01f, -4.93309908e-02f, 3.42320859e-01f, 3.52226257e-01f, 1.12249881e-01f, 1.74038038e-01f, 9.86580476e-02f, 1.61589652e-01f,
  3.27864647e-01f, -6.34227470e-02f, 1.10593304e-01f, -1.04732588e-01f, -8.80285949e-02f, 4.47377384e-01f, -2.49657959e-01f, -4.26373538e-03f, -3.10801148e-01f, -9.16717499e-02f,
  4.10137564e-01f, -5.35977371e-02f, 2.50700861e-01f, 8.45856741e-02f, 2.14987010e-01f, -7.62088504e-03f, 1.81138813e-01f, -2.20146567e-01f, 1.68591946e-01f, -1.06034234e-01f,
  7.09077120e-02f, 1.06240854e-01f, 2.96260238e-01f, -4.97015655e-01f, 2.50864416e-01f, 1.14030438e-02f, 4.56178278e-01f, 1.40123948e-01f, 2.41072834e-01f, -2.05463141e-01f,
  -3.24963510e-01f, 2.37504750e-01f, -8.74589011e-02f, 3.99387032e-01f, 2.14068010e-01f, -1.38544515e-01f, 2.87498176e-01f, 3.17118806e-03f, -1.44194022e-01f, 7.86842257e-02f,
  2.98544973e-01f, -1.31850570e-01f, -3.87944341e-01f, 3.58162746e-02f, 6.12483434e-02f, 3.29076737e-01f, 2.23319568e-02f, 4.02024180e-01f, 7.61117712e-02f, -8.78897216e-03f,
  3.21780238e-03f, 2.72949100e-01f, -3.43301296e-01f, 3.10093224e-01f, 3.54332589e-02f, -2.46193737e-01f, 1.63861036e-01f, 2.09850580e-01f, 1.93511739e-01f, 1.74684660e-03f,
  9.08124745e-02f, -5.01527302e-02f, -7.40622729e-02f, -3.72890122e-02f, 8.98813233e-02f, -3.23010474e-01f, -1.22780003e-01f, -1.68961480e-01f, 6.29421249e-02f, -1.02949729e-02f,
  8.16053748e-02f, -2.96448991e-02f, -1.63080133e-02f, 2.82164097e-01f, 1.53123006e-01f, 4.33474295e-02f, 1.54725164e-01f, -1.34992197e-01f, -6.67330995e-02f, -1.63446322e-01f,
  2.15480104e-01f, -1.52383342e-01f, -2.43180115e-02f, -2.46612772e-01f, 2.67282605e-01f, 1.09571867e-01f, -1.65013120e-01f, 9.38335210e-02f, -3.66740748e-02f, 3.13488245e-01f,
  -1.52848437e-01f, -2.39762485e-01f, 9.46087837e-02f, 3.78600180e-01f, 1.94941852e-02f, -5.35078272e-02f, 1.44602343e-01f, -6.39201477e-02f, 2.33440310e-01f, -3.79793406e-01f,
  2.60138214e-01f, 2.23387107e-01f, -1.54960096e-01f, 4.28159349e-02f, 6.34341389e-02f, 2.37351796e-05f, 4.90476191e-01f, -7.76554691e-04f, 8.78196657e-02f, 8.43365341e-02f,
  -5.96834049e-02f, 2.58806556e-01f, 1.87176734e-01f, -6.01495355e-02f, 2.76581466e-01f, -1.32127181e-01f, 2.46590778e-01f, 8.35364237e-02f, -7.49959201e-02f, 5.18582948e-02f,
  3.11898179e-02f, 1.56486839e-01f, 1.22836567e-01f, 4.62365858e-02f, 2.35433578e-02f, 1.28052369e-01f, 3.00200600e-02f, -2.57318020e-01f, 6.48679957e-02f, 1.33592978e-01f,
  1.03301212e-01f, -7.74752796e-02f, -2.63585504e-02f, 2.84251183e-01f, 4.17904034e-02f, 1.12511151e-01f, 7.86535069e-02f, -6.95747137e-02f, 2.54975855e-01f, -1.36740014e-01f,
  -3.97760421e-02f, -1.03289597e-01f, -1.17071271e-01f, 2.11470470e-01f, -3.52725871e-02f, 1.21373996e-01f, 4.82422672e-02f, 2.53896832e-01f, -1.95135977e-02f, -1.98322907e-01f,
  -1.85293689e-01f, 3.44930924e-02f, -1.03845693e-01f, -3.27543795e-01f, 2.31741607e-01f, 3.73254977e-02f, 1.55786887e-01f, -4.24490636e-03f, 3.53451163e-01f, -1.80542301e-02f,
  -1.25026792e-01f, -3.13793272e-01f, 1.63881078e-01f, -1.01833038e-01f, -3.66938189e-02f, 1.07481964e-01f, -9.33944210e-02f, -1.86842866e-03f, 2.00584367e-01f, -3.93919587e-01f,
  3.57646465e-01f, -2.05615357e-01f, -2.07543626e-01f, -1.50711965e-02f, 2.15071604e-01f, 2.35187054e-01f, 1.08743206e-01f, 1.01519503e-01f, -9.78561714e-02f, -5.20386755e-01f,
  1.59272835e-01f, -9.35119241e-02f, 1.32779166e-01f, 1.37839705e-01f, 2.01683804e-01f, 7.92393535e-02f, 1.38326243e-01f, 9.55630317e-02f, -2.06948929e-02f, 6.96763694e-02f,
  -4.51635867e-02f, -1.12302847e-01f, 1.70550100e-03f, -1.24249637e-01f, 1.25624835e-01f, -1.73224255e-01f, -9.96148884e-02f, 1.26288101e-01f, 2.88670301e-01f, 1.93397641e-01f,
  2.09530354e-01f, 3.54014337e-02f, 5.56439580e-03f, 2.06965923e-01f, -1.93745539e-01f, -4.82880324e-02f, -1.26614496e-01f, -2.01810505e-02f, 1.02777779e-01f, -9.10604373e-02f,
  1.30279899e-01f, -5.27625978e-02f, 3.82878892e-02f, -2.38611624e-01f, -9.54045355e-02f, 4.44526643e-01f, -1.45650700e-01f, 1.75014645e-01f, 1.60826430e-01f, -4.45356607e-01f,
  -6.21987320e-02f, 3.91082615e-01f, 2.51408905e-01f, 1.65254232e-02f, -5.07024266e-02f, -4.79265302e-01f, -3.26526910e-02f, 4.94334847e-02f, 1.17482878e-02f, 2.01217219e-01f,
  -1.11838818e-01f, 2.60696322e-01f, -9.76628661e-02f, -3.99392247e-02f, 4.71168488e-01f, -1.84887141e-01f, -7.82874674e-02f, -5.86500913e-02f, -1.78726483e-03f, 1.78023517e-01f,
  2.70367563e-01f, 1.27632484e-01f, 1.10165335e-01f, 9.50809047e-02f, 1.61658973e-01f, -1.64017141e-01f, -3.78645882e-02f, -6.81267008e-02f, 6.73465654e-02f, 2.87290841e-01f,
  1.54713139e-01f, 1.72054574e-01f, 8.31963494e-02f, 1.85739249e-01f, -2.98024803e-01f, -1.02766536e-01f, -1.10842392e-01f, -1.63245976e-01f, 1.17486723e-01f, -2.09655091e-01f,
  -1.56448632e-01f, -2.71301955e-01f, -3.66922855e-01f, -9.44111496e-02f, 2.36726433e-01f, 1.28211871e-01f, 1.12172604e-01f, -1.76504537e-01f, -3.36463124e-01f, -1.99248716e-01f,
  2.20646262e-01f, -4.30095851e-01f, 1.68820366e-01f, 4.29875255e-02f, -4.94486317e-02f, 2.28792384e-01f, 8.80455449e-02f, -6.41888753e-03f, 2.62170494e-01f, 4.32714313e-01f,
  2.46235415e-01f, 5.42553142e-02f, 2.85620749e-01f, 1.70309991e-02f, 1.68544888e-01f, -5.40336184e-02f, -1.36191100e-01f, -5.13869941e-01f, -6.00678802e-01f, -3.18513811e-01f,
  -6.87728748e-02f, 1.39562130e-01f, -2.73323685e-01f, -1.11780185e-02f, -2.74663299e-01f, 4.33519930e-01f, -6.76234439e-03f, -3.08325201e-01f, 1.92131653e-01f, -5.13163149e-01f,
  -1.94801912e-01f, 7.34131783e-02f, -1.51295573e-01f, -5.54481626e-01f, 2.18258038e-01f, -1.65774599e-01f, 1.64651036e-01f, 4.23405021e-01f, 2.16840312e-01f, -9.36634913e-02f,
  -4.84064259e-02f, 1.20805606e-01f, -4.93296199e-02f, -5.96709326e-02f, -1.54055178e-01f, -1.45977601e-01f, 7.82067478e-02f, -1.15178160e-01f, -1.64478943e-01f, -1.05964854e-01f,
  -2.94811934e-01f, -2.77999397e-02f, -3.10746878e-02f, -4.70955446e-02f, -1.74216777e-01f, 6.14065416e-02f, 1.00668818e-01f, -1.96354821e-01f, -3.75339948e-02f, 3.67490441e-01f,
  2.29989588e-01f, -7.06073791e-02f, 2.01525629e-01f, 1.36893556e-01f, -1.71006963e-01f, 1.98603138e-01f, 1.85550787e-02f, -2.02705935e-01f, -2.84671068e-01f, -1.22368127e-01f,
  -1.68402851e-01f, 4.64895487e-01f, -8.68944153e-02f, 8.22896138e-02f, -2.42890537e-01f, -3.07135731e-01f, -1.95093483e-01f, 7.42542967e-02f, 2.55482346e-01f, 7.00393617e-02f,
  3.65842521e-01f, 1.34846017e-01f, 9.77927595e-02f, 1.08985873e-02f, 4.11765903e-01f, 1.06597915e-02f, 1.03418216e-01f, -7.46674091e-02f, 2.30213404e-01f, -2.21404597e-01f,
  8.38742107e-02f, 7.14913085e-02f, -1.92138627e-01f, 2.65486509e-01f, -9.43532959e-02f, -2.16259420e-01f, 5.50384931e-02f, -1.96436539e-01f, 3.85803506e-02f, 1.88104153e-01f,
  5.55236302e-02f, -4.37151611e-01f, -3.53991747e-01f, -2.50747710e-01f, 1.66234732e-01f, -2.43323579e-01f, -7.05862567e-02f, 1.39199600e-01f, 8.68277103e-02f, 1.11712635e-01f,
  3.60931666e-03f, 1.05360970e-01f, -1.70835808e-01f, -9.18015838e-02f, -2.57108033e-01f, -7.03498945e-02f, -1.58598617e-01f, 4.46509160e-02f, -8.47395062e-02f, -3.40450168e-01f,
  -1.03195526e-01f, 1.33000836e-01f, 4.04644907e-01f, 1.82754532e-01f, -3.60470861e-02f, -5.14211729e-02f, 9.69467834e-02f, 3.04684974e-02f, -4.49171253e-02f, -3.83975245e-02f,
  8.05896223e-02f, -2.29299013e-02f, -3.54143888e-01f, 3.00513327e-01f, 6.24985248e-02f, 1.91289887e-01f, -1.39357403e-01f, 2.59614348e-01f, -3.19382995e-02f, 5.61470576e-02f,
  -3.47908556e-01f, 1.55792430e-01f, 6.25489950e-02f, 4.32729155e-01f, 2.48235255e-01f, -1.91751093e-01f, -7.26668723e-03f, -2.40098223e-01f, 1.36313915e-01f, 1.19258568e-01f,
  8.75015464e-03f, 1.13863563e-02f, 1.45887658e-01f, 2.24485219e-01f, -1.96793340e-02f, 1.98979035e-01f, 1.74990982e-01f, 3.18925917e-01f, -1.15283921e-01f, 1.12726502e-01f,
  1.49061948e-01f, -1.76711068e-01f, 1.24001466e-01f, -1.23900466e-01f, 2.35719293e-01f, 8.43292251e-02f, 2.03268174e-02f, 9.43499953e-02f, 1.01841830e-01f, 1.96609512e-01f,
  -3.39839756e-02f, 3.90576459e-02f, -8.11101124e-02f, 7.79021010e-02f, 6.09238409e-02f, 8.59179199e-02f, -1.14289142e-01f, 3.09169162e-02f, -1.28309473e-01f, -1.73501119e-01f,
  -7.43329450e-02f, -1.73339769e-01f, -2.07244471e-01f, -1.70692906e-01f, -1.34557143e-01f, -3.15308303e-01f, -8.70652720e-02f, -1.09583875e-02f, 2.71213531e-01f, 1.80302039e-02f,
  1.68573380e-01f, 6.33938536e-02f, 8.16035941e-02f, -6.37519062e-02f, 1.10884517e-01f, 7.19555691e-02f, 1.55399993e-01f, 2.17094645e-01f, -3.97687720e-04f, 2.06640512e-01f,
  5.98348044e-02f, 1.36983752e-01f, 3.99246365e-01f, -7.52829313e-02f, -3.07626396e-01f, -5.33626638e-02f, 3.66592668e-02f, 7.20163947e-03f, 1.59643307e-01f, 6.46594632e-03f,
  5.13841286e-02f, 4.19643641e-01f, 2.31278270e-01f, -3.47505838e-01f, 1.26712739e-01f, -1.47026360e-01f, 9.71627831e-02f, -1.56277329e-01f, 2.32885927e-01f, -9.53203812e-03f,
  -3.45366418e-01f, 1.40490234e-01f, 2.53154058e-02f, 2.54042149e-01f, 2.24574693e-02f, -1.85571432e-01f, 1.45121947e-01f, 3.69488224e-02f, 2.44485900e-01f, 1.28791733e-02f,
  -1.68139368e-01f, 1.33810297e-01f, 2.03046069e-01f, 1.13395579e-01f, 8.35006684e-02f, 1.09674305e-01f, 2.23999545e-01f, 1.01657793e-01f, 1.12122461e-01f, 4.32106555e-02f,
  -1.74649253e-01f, 7.79603943e-02f, -2.33545095e-01f, -1.46431729e-01f, -1.51884183e-01f, -1.38019174e-01f, -9.83199105e-02f, -8.39991197e-02f, -3.68648201e-01f, -8.24391693e-02f,
  3.15705016e-02f, -5.60732819e-02f, 1.94424782e-02f, -8.14555287e-02f, 4.01322335e-01f, -1.88658506e-01f, 3.45983207e-02f, -3.52187306e-01f, 3.84214789e-01f, 7.31068477e-02f,
  6.69025555e-02f, 5.12315452e-01f, 9.33308154e-02f, 2.98473537e-01f, 2.82501191e-01f, 3.22289050e-01f, 3.35654706e-01f, -2.30312943e-01f, 3.32647383e-01f, 2.23888844e-01f,
  1.86794877e-01f, -9.63247418e-02f, -2.63787597e-01f, -1.00355655e-01f, -3.34136873e-01f, -1.78329930e-01f, 3.63370657e-01f, 3.24243575e-01f, -1.15801930e-01f, 4.88141663e-02f,
  3.48667875e-02f, 6.18092790e-02f, 2.40360752e-01f, -2.37590462e-01f, 1.24133088e-01f, 1.44906774e-01f, -2.18212575e-01f, 4.09230553e-02f, 1.34029258e-02f, -3.34583253e-01f,
  3.74925375e-01f, -2.68234134e-01f, 2.18231872e-01f, 1.49174318e-01f, 7.63833448e-02f, 4.96385843e-02f, 2.39568695e-01f, 4.93239015e-02f, 1.67676598e-01f, 1.00926444e-01f,
  3.13058257e-01f, 2.19443172e-01f, 6.22359142e-02f, 5.12302555e-02f, 2.37615064e-01f, 5.36394008e-02f, -1.12731829e-01f, 7.13618249e-02f, -1.46720737e-01f, -7.07955807e-02f,
  -2.38320837e-03f, 4.70059484e-01f, 2.50637531e-01f, 6.57862946e-02f, -6.31508380e-02f, 4.50843276e-04f, 3.30431998e-01f, 9.59707126e-02f, 1.10160239e-01f, 2.03812152e-01f,
  -2.18548417e-01f, 6.31031170e-02f, -1.26163930e-01f, -3.10578436e-01f, -2.32647985e-01f, 9.39049050e-02f, 3.20183307e-01f, 3.06930155e-01f, -1.32761812e-02f, -3.65874946e-01f,
  2.78635956e-02f, -1.44870654e-01f, 3.20364386e-01f, 2.52639800e-01f, 2.58141428e-01f, -2.24571675e-01f, -3.44918743e-02f, 3.07981700e-01f, 2.11489379e-01f, 2.07341611e-01f,
  9.67546329e-02f, 2.27261409e-01f, 1.26090646e-01f, 1.45094544e-01f, 2.57060260e-01f, -4.16754093e-03f, 1.69475168e-01f, 2.70264950e-02f, -2.38800600e-01f, 2.20022157e-01f,
  9.67418700e-02f, -7.63597861e-02f, 2.66602010e-01f, 8.87343287e-02f, 1.56318024e-01f, 7.63162225e-02f, 3.90982330e-01f, -1.94371924e-01f, -2.69979797e-02f, -1.22856297e-01f,
  1.35727227e-01f, -3.09179038e-01f, 5.18830568e-02f, 2.82000005e-02f, 1.44437710e-02f, 1.97284162e-01f, 4.55364026e-02f, 2.87869386e-02f, -1.58095546e-02f, -7.82165676e-02f,
  -2.83477128e-01f, -2.06656381e-01f, -1.36083513e-01f, 1.77701935e-02f, 4.17481130e-03f, -1.54341444e-01f, 2.95136333e-01f, -1.47977591e-01f, -2.32137308e-01f, 4.06922400e-02f,
  2.62230426e-01f, 4.30788882e-02f, 1.61001563e-01f, -5.36182046e-01f, -6.75875470e-02f, -2.96332926e-01f, 2.32238412e-01f, 1.73303649e-01f, 3.18179987e-02f, 2.21521616e-01f,
  1.07454248e-01f, 1.48480862e-01f, -2.92365048e-02f, 6.51227236e-02f, 2.46897757e-01f, -2.33668998e-01f, 8.33428949e-02f, -1.13529153e-01f, 2.52398908e-01f, -2.30580449e-01f,
  2.08317235e-01f, -2.08712928e-02f, -1.05373666e-01f, 1.66478418e-02f, 3.23751599e-01f, 1.14841955e-02f, -3.50209884e-02f, 3.06424826e-01f, -6.46118000e-02f, -7.39547372e-01f,
  -5.38212955e-02f, 1.27444446e-01f, 2.31069461e-01f, 3.55170488e-01f, -1.39075473e-01f, -1.28828928e-01f, -3.38895798e-01f, -3.82437468e-01f, 1.18470758e-01f, 2.45066956e-02f,
  3.19877803e-01f, -3.10063452e-01f, 2.15732843e-01f, 1.66971937e-01f, 5.55649921e-02f, 5.10980338e-02f, 8.65515247e-02f, 1.69731513e-01f, 2.72050440e-01f, 8.23180154e-02f,
  -1.86089784e-01f, 1.24331258e-01f, 4.23180126e-02f, -1.69236705e-01f, -9.73190293e-02f, -1.55891344e-01f, 1.67393461e-01f, -2.07879379e-01f, -1.71334893e-01f, 1.13674670e-01f,
  3.23351711e-01f, 3.70128565e-02f, 3.02474141e-01f, -1.49180144e-01f, -3.27586047e-02f, -4.68471535e-02f, -1.82620194e-02f, 1.43905908e-01f, -6.53684661e-02f, -1.54622212e-01f,
  1.46563098e-01f, -5.76074719e-02f, -5.34319431e-02f, 3.07294726e-01f, 1.17439553e-01f, -3.29444140e-01f, 8.35058019e-02f, 3.82658303e-01f, 1.28364742e-01f, 1.32703468e-01f,
  3.41001928e-01f, -3.98029350e-02f, 1.75410762e-01f, 1.41674817e-01f, 2.25124225e-01f, 1.86558709e-01f, -3.24318826e-01f, -5.52137852e-01f, -7.04122894e-03f, 7.83557445e-03f,
  -2.20227122e-01f, 1.50239542e-01f, -6.26403689e-02f, 2.41512612e-01f, -8.62110555e-02f, -2.86286026e-01f, 2.73819596e-01f, -4.52349633e-01f, 7.30452836e-02f, -7.83320367e-02f,
  3.25825185e-01f, 1.20889619e-01f, 1.22960120e-01f, -5.39029054e-02f, 6.01341994e-03f, 3.82720947e-01f, 1.11282118e-01f, -1.99606523e-01f, 3.20236385e-02f, 1.51687162e-02f,
  9.21932608e-02f, 2.72822350e-01f, 2.01366872e-01f, 1.03421926e-01f, 1.67565092e-01f, 1.85624138e-01f, 4.16862853e-02f, 1.70123931e-02f, 5.95875829e-02f, -1.76272228e-01f,
  -7.10714981e-02f, -1.08295143e-01f, 2.83468161e-02f, 2.38522783e-01f, -1.00311033e-01f, 1.32093951e-01f, -5.81651986e-01f, -3.58141847e-02f, 3.78198683e-01f, 9.55267716e-03f,
  8.91968012e-02f, -1.86357692e-01f, 2.18952239e-01f, -1.89170897e-01f, 1.77556008e-01f, -1.20926425e-01f, 4.16138433e-02f, 1.63475946e-01f, 2.16569692e-01f, 1.12237304e-01f,
  2.42277756e-01f, -3.19853723e-01f, 7.80884847e-02f, -2.64243811e-01f, 5.15989125e-01f, 1.52605355e-01f, 6.02742173e-02f, -4.05518532e-01f, 3.75334620e-02f, 7.97915757e-02f,
  -3.54257792e-01f, -8.13734457e-02f, 1.87468916e-01f, -4.75253686e-02f, -9.53949019e-02f, 1.09358989e-01f, -2.63636738e-01f, -1.14289582e-01f, 4.49176058e-02f, -4.01477814e-01f,
  3.19973469e-01f, 1.14331685e-01f, -1.14447489e-01f, 2.74640292e-01f, -8.05533156e-02f, 1.06672205e-01f, 3.46234530e-01f, -2.61989981e-01f, 6.86441585e-02f, 2.38497049e-01f,
  1.86422274e-01f, 2.08368853e-01f, -2.38164321e-01f, 1.87243477e-01f, 7.84179121e-02f, -4.33525210e-03f, 2.56071895e-01f, 1.92289382e-01f, -1.42588848e-02f, 1.62122115e-01f,
  -5.49378898e-03f, 1.50339261e-01f, -7.28062391e-02f, -1.35601372e-01f, 2.05844507e-01f, -1.13431670e-01f, -8.22986215e-02f, 2.23173782e-01f, -1.11130811e-01f, -2.52652407e-01f,
  -1.83305740e-01f, -3.49437535e-01f, 2.63856202e-01f, -1.02158055e-01f, 1.69768274e-01f, 2.83028513e-01f, -2.43849009e-01f, 9.68506560e-02f, -3.05528361e-02f, -1.52084261e-01f,
  8.15775990e-03f, 1.00473307e-01f, 1.65389642e-01f, 8.48248601e-02f, 2.83135958e-02f, 8.11631307e-02f, 1.54309586e-01f, -1.09783344e-01f, 3.70188564e-01f, -1.67527865e-03f,
  2.61203438e-01f, -1.07524447e-01f, -4.36960369e-01f, 2.31825367e-01f, -7.56617635e-02f, 4.19588894e-01f, 1.18286446e-01f, -1.78743884e-01f, 1.21695012e-01f, 1.13644712e-02f,
  -1.30091906e-01f, 1.92394987e-01f, 1.75618738e-01f, -1.75402127e-02f, -2.50347108e-01f, -8.60601440e-02f, 1.51537225e-01f, 3.66727501e-01f, 3.65676254e-01f, 3.43705505e-01f,
  4.12502363e-02f, -4.86561880e-02f, -2.86274493e-01f, -5.80283888e-02f, -1.58372730e-01f, 4.91403751e-02f, -5.85870743e-02f, -9.57845896e-02f, -6.87549040e-02f, 2.36742884e-01f,
  1.11664303e-01f, 1.84486862e-02f, 3.95751223e-02f, 1.45876467e-01f, -8.18690658e-03f, -1.95231169e-01f, -2.93368071e-01f, 8.83815065e-02f, -1.77332714e-01f, 1.59585074e-01f,
  -2.21512467e-02f, 1.22256309e-01f, 3.53635669e-01f, -5.04781604e-01f, 4.61140215e-01f, 1.20143957e-01f, 1.72509834e-01f, 1.07550777e-01f, 6.12510219e-02f, 7.69652650e-02f,
  -1.11076266e-01f, 6.39890283e-02f, -5.09553403e-02f, 4.26323265e-02f, 2.57419676e-01f, 3.08276899e-02f, 7.46888295e-02f, 1.74767435e-01f, -1.15213245e-01f, 1.93812191e-01f,
  3.10449153e-01f, 9.29333121e-02f, -2.68413395e-01f, -2.53319889e-01f, 1.70963392e-01f, 3.27627033e-01f, 7.22403228e-02f, 2.81507432e-01f, -1.36978447e-01f, -1.18546464e-01f,
  1.87097922e-01f, -4.08727676e-02f, 5.99030145e-02f, 2.59292126e-01f, 8.84817168e-02f, 2.28125572e-01f, 8.26710761e-02f, 1.16722167e-01f, 6.50561452e-02f, -1.06384698e-02f,
  -3.64713045e-03f, -1.75735652e-01f, 1.74662009e-01f, 5.79035878e-02f, 1.69996932e-01f, -4.57507335e-02f, 2.22333789e-01f, -2.78382599e-01f, 2.96668112e-02f, -1.48530573e-01f,
  1.16041057e-01f, 3.97758558e-02f, -2.94286925e-02f, -1.46163180e-01f, 1.07110910e-01f, 8.38012546e-02f, 2.23364569e-02f, -1.43063009e-01f, -6.58669099e-02f, 7.65025914e-02f,
  -1.08759426e-01f, 1.40019059e-01f, -6.42582914e-03f, -6.90392554e-02f, 1.48475900e-01f, -9.31654721e-02f, -6.67308122e-02f, 9.45473388e-02f, 5.41242659e-02f, 2.23556414e-01f,
  -1.03513472e-01f, 1.99119836e-01f, 9.85330418e-02f, -8.02883580e-02f, 1.70056686e-01f, 2.53722876e-01f, -1.60105318e-01f, 7.23298565e-02f, 1.35577738e-01f, -1.78109646e-01f,
  2.70599816e-02f, 3.07479352e-01f, 5.06753509e-04f, -1.74225196e-02f, -7.84911588e-02f, 3.76002416e-02f, 5.62010594e-02f, -8.48848820e-02f, -9.30384174e-02f, -5.72437420e-02f,
  2.81833023e-01f, 1.03094473e-01f, 2.32931614e-01f, 1.22180320e-01f, 2.96501294e-02f, 4.06595320e-01f, -3.52491811e-02f, -2.91105688e-01f, 2.09441975e-01f, 6.16961010e-02f,
  5.57112619e-02f, 1.79857939e-01f, 4.88098115e-02f, 1.80373207e-01f, -9.10839364e-02f, -6.19712099e-02f, 1.07664913e-01f, 1.05991475e-01f, -1.48367345e-01f, 2.26482287e-01f,
  9.73130576e-03f, 1.02629781e-01f, 2.05675210e-03f, -9.06428695e-02f, 1.56460330e-01f, -3.91492806e-02f, 1.75900578e-01f, 2.57959276e-01f, 7.41892606e-02f, 1.38770387e-01f,
  1.07845105e-01f, 2.88465880e-02f, 2.02319771e-03f, -9.45702642e-02f, -1.95548922e-01f, 4.63283025e-02f, 1.95076898e-01f, 8.34764764e-02f, 8.63516629e-02f, 1.54991403e-01f,
  -2.19239146e-01f, 2.54638463e-01f, -1.94530055e-01f, 1.15068428e-01f, 8.79404619e-02f, -2.79925019e-01f, 1.38415202e-01f, 1.88137650e-01f, -1.69726372e-01f, 2.57212788e-01f,
  1.40377626e-01f, -2.28510122e-03f, -1.16496414e-01f, 1.10523231e-01f, 1.43061385e-01f, 3.68773997e-01f, -3.73304710e-02f, -1.00222118e-02f, -1.22435860e-01f, -3.88206095e-01f,
  2.66025633e-01f, 1.39755577e-01f, 3.29288989e-01f, -2.15659946e-01f, -1.01438008e-01f, 6.45950213e-02f, -3.11959367e-02f, 5.83369248e-02f, 3.49346012e-01f, 8.01794603e-02f,
  1.00397058e-02f, -1.94190234e-01f, 9.58890319e-02f, -1.57749772e-01f, 2.72483021e-01f, 1.33268118e-01f, 1.85463965e-01f, 1.64768368e-01f, -2.23174393e-01f, -7.89072141e-02f,
  2.08849609e-01f, 7.93490559e-02f, 9.05695260e-02f, 2.53447844e-03f, 8.77828225e-02f, -2.97967792e-01f, 6.55487701e-02f, 5.74096926e-02f, 1.78406894e-01f, 1.22046851e-01f,
  1.34269688e-02f, 2.07327195e-02f, 2.82100946e-01f, 1.96952865e-01f, 8.39798823e-02f, 1.24541074e-01f, -2.74976969e-01f, -5.36964722e-02f, -7.98735619e-02f, -1.74983025e-01f,
  -3.66029918e-01f, -2.00430855e-01f, 8.34308714e-02f, -1.58007875e-01f, 1.24857709e-01f, -2.76438624e-01f, 1.56706437e-01f, 1.76324919e-01f, -3.30883302e-02f, 1.35949701e-01f,
  -3.07032526e-01f, 1.86759964e-01f, 7.19126239e-02f, -2.45159622e-02f, 1.32379264e-01f, 1.26168042e-01f, 3.15376431e-01f, 2.14200243e-01f, 1.33023068e-01f, 1.92194447e-01f,
  2.71554500e-01f, 2.69984335e-01f, 3.84621471e-01f, 7.10175708e-02f, -1.07204616e-01f, 1.42207248e-02f, -1.07837595e-01f, 1.01497404e-01f, 1.14263862e-01f, -4.65450250e-02f,
  -3.87562454e-01f, -1.99396864e-01f, 1.13150775e-01f, -8.60644430e-02f, 1.55119866e-01f, -1.94797397e-01f, -1.11032285e-01f, 2.64636427e-01f, -4.91150647e-01f, -1.68477103e-01f,
  -3.36335331e-01f, -2.89410591e-01f, -1.82173774e-01f, -3.48766372e-02f, 2.41312161e-01f, -4.14377786e-02f, -1.21991679e-01f, -2.09770948e-01f, -4.03114855e-02f, 2.80649722e-01f,
  -1.68937340e-01f, 9.54052806e-02f, -2.14945927e-01f, -2.32918691e-02f, 1.38243660e-01f, 3.87762045e-03f, 1.95255771e-01f, -8.41820538e-02f, 6.03251196e-02f, 2.16551963e-02f,
  -1.08260192e-01f, -4.18440849e-01f, -1.57906004e-04f, -1.38810009e-01f, 1.78511888e-01f, -2.61310250e-01f, -9.88947079e-02f, 8.99695754e-02f, 3.45540382e-02f, 7.29908645e-02f,
  -1.88597023e-01f, 1.61893576e-01f, 4.43221852e-02f, -1.69128031e-01f, -2.16315091e-01f, -4.63003755e-01f, -2.49191597e-01f, 3.64894003e-01f, 1.91229969e-01f, 1.39052853e-01f,
  -9.84825268e-02f, -2.28880681e-02f, 5.38061000e-02f, -2.21531875e-02f, -1.05918407e-01f, 2.41676588e-02f, 4.47915643e-02f, 4.28108536e-02f, 5.13562381e-01f, -2.08305329e-01f,
  2.73595244e-01f, -1.30561054e-01f, 2.13744119e-01f, -6.90806955e-02f, 2.34329496e-02f, -3.42185438e-01f, 9.12313461e-02f, 1.11194111e-01f, -9.23447032e-03f, 1.91100955e-01f,
  -1.66227534e-01f, -3.26945454e-01f, 2.17666879e-01f, -3.22946548e-01f, 2.34969437e-01f, -3.40558022e-01f, 2.75508910e-02f, -1.34026289e-01f, -3.73001486e-01f, 1.07251987e-01f,
  7.02036545e-02f, 2.40036100e-02f, 1.80929229e-01f, -3.36423516e-02f, 2.58337766e-01f, -2.43847277e-02f, -2.36676991e-01f, 1.94947153e-01f, 1.10196680e-01f, -1.62084252e-01f,
  -4.72071320e-02f, 5.93735017e-02f, 2.05391124e-02f, -1.79319099e-01f, 1.01992570e-01f, 1.73526466e-01f, 1.07690535e-01f, -3.84960882e-02f, 9.16215852e-02f, -6.09780364e-02f,
  -2.74744809e-01f, 5.08425459e-02f, 1.02838702e-01f, 3.21181357e-01f, -7.26762339e-02f, 1.39707744e-01f, -1.26551270e-01f, -2.27552325e-01f, -1.19273150e-02f, 6.34581782e-03f,
  -1.58470735e-01f, 3.98327440e-01f, -2.93061465e-01f, -2.75258392e-01f, 1.77230716e-01f, -3.79322865e-03f, -6.36214344e-03f, 1.42451912e-01f, 3.96789312e-02f, 3.12785022e-02f,
  5.97505772e-04f, 3.17628235e-01f, -4.07791167e-01f, 9.07713026e-02f, -4.95594069e-02f, 1.25983566e-01f, 3.26585114e-01f, -8.55388343e-02f, 4.21407312e-01f, 2.75998861e-01f,
  -1.60615951e-01f, 6.99026883e-02f, 2.81567395e-01f, -2.32931897e-01f, 3.00369084e-01f, 7.58294910e-02f, 1.67864844e-01f, -1.70878366e-01f, -5.15575372e-02f, 2.02407554e-01f,
  -9.22596082e-02f, 5.79631329e-02f, -7.98324065e-04f, 5.11684678e-02f, -2.12116420e-01f, 3.26173604e-01f, -2.93150604e-01f, -2.78984755e-02f, -6.75668418e-02f, 1.54304653e-01f,
  6.65341020e-02f, -2.40488902e-01f, 3.28210667e-02f, 3.22248600e-02f, 2.27102134e-02f, 3.94228064e-02f, 2.06885025e-01f, -1.31241933e-01f, -4.97324131e-02f, 2.16263875e-01f,
  -1.42401025e-01f, 2.54376978e-01f, 3.58671099e-02f, 2.01477095e-01f, -2.44168237e-01f, -1.93783611e-01f, 8.45590308e-02f, 2.24995106e-01f, 1.16581313e-01f, -1.24510810e-01f,
  -1.44523710e-01f, -2.20878601e-01f, 1.78375304e-01f, 4.61631306e-02f, -7.34095424e-02f, 1.01716526e-01f, -1.21824563e-01f, -1.10100672e-01f, -1.65725321e-01f, -2.20852852e-01f,
  2.02896267e-01f, 4.24686313e-01f, 2.03841515e-02f, -1.45295337e-01f, -2.29494557e-01f, 9.84525904e-02f, -2.35363498e-01f, 1.66485921e-01f, -4.36244048e-02f, 2.11834088e-02f,
  7.73617774e-02f, 2.04072863e-01f, 3.55679303e-01f, 2.07415864e-01f, 1.38015211e-01f, 3.58907849e-01f, 2.43913513e-02f, 1.77722335e-01f, 3.57626200e-01f, 7.75533691e-02f,
  7.78474361e-02f, 1.33819655e-01f, -2.06478000e-01f, 2.64500529e-01f, 2.04235017e-01f, 1.73729807e-01f, 1.78000718e-01f, -2.38918319e-01f, -6.79909810e-02f, 2.47431278e-01f,
  2.54590809e-01f, 3.21496837e-02f, -1.07645571e-01f, 1.06658833e-02f, 2.61540264e-01f, -1.28586784e-01f, 1.60164699e-01f, 1.35227486e-01f, 2.30508074e-01f, 4.59185801e-02f,
  4.86339703e-02f, 1.17287569e-01f, 2.06888676e-01f, -9.73684490e-02f, 1.75179660e-01f, 1.27201602e-02f, 1.43476829e-01f, -1.36605129e-01f, -1.16985366e-01f, 2.50099391e-01f,
  2.17956841e-01f, -7.19553679e-02f, 1.39284268e-01f, -2.22218521e-02f, -3.40761500e-03f, -1.69540256e-01f, 9.20265168e-02f, 1.88847587e-01f, -3.52252185e-01f, 1.47096187e-01f,
  -3.05882171e-02f, -1.03313275e-01f, -3.89199331e-02f, 8.89013037e-02f, 1.97379813e-01f, -3.35575879e-01f, -3.22616637e-01f, 3.33489239e-01f, 7.59010017e-02f, 3.82111758e-01f,
  1.39147863e-01f, -7.04996735e-02f, -3.80226821e-02f, 4.59403515e-01f, -1.72825515e-01f, 1.87986776e-01f, 1.38260409e-01f, 7.02302530e-02f, -1.54335067e-01f, -1.64523348e-01f,
  2.11392537e-01f, 2.79083997e-01f, -3.27731110e-02f, 3.64036202e-01f, 5.18757775e-02f, -2.61684228e-02f, 2.50081718e-02f, -1.75016478e-01f, 3.08856428e-01f, 4.61968631e-02f,
  4.59153622e-01f, 4.54056889e-01f, 6.74563795e-02f, 1.14123352e-01f, -1.65085971e-01f, -4.95852903e-02f, -6.26953766e-02f, 1.37810856e-01f, 7.11817667e-02f, -1.12000361e-01f,
  1.70202449e-01f, 2.01847196e-01f, 1.62841067e-01f, 1.93015516e-01f, 1.63530841e-01f, 1.63955986e-01f, 4.82683815e-02f, 2.42610589e-01f, -5.69652542e-02f, 1.08139239e-01f,
  5.05142920e-02f, 6.78711906e-02f, 1.09425962e-01f, 3.35736156e-01f, -1.99366003e-01f, 7.57208318e-02f, -2.61190891e-01f, -2.61961877e-01f, 2.19101563e-01f, -1.59709588e-01f,
  2.01083824e-01f, 8.97684842e-02f, -5.36714904e-02f, -4.03837301e-02f, -7.02774897e-02f, -1.24437109e-01f, 9.14331228e-02f, 1.30775169e-01f, 6.26785234e-02f, 2.44802192e-01f,
  1.08238898e-01f, -3.31331223e-01f, 3.07094324e-02f, -2.94495583e-01f, 4.73521173e-01f, 1.88343346e-01f, 3.18423152e-01f, -4.24461216e-01f, -2.45999038e-01f, 6.49141222e-02f,
  -1.29257336e-01f, 4.34134334e-01f, 1.55881926e-01f, 6.51739538e-02f, 8.88092294e-02f, 1.35553047e-01f, -8.23239014e-02f, -9.47760344e-02f, 2.63418287e-01f, -1.79642275e-01f,
  -3.93311270e-02f, 2.85055637e-01f, 7.83685371e-02f, 2.87951618e-01f, 5.78793511e-02f, 1.86914355e-01f, 1.22396648e-01f, -4.44789752e-02f, 6.18971214e-02f, -1.09183677e-01f,
  2.15114770e-03f, -1.68940663e-01f, 7.75343478e-02f, 7.60086551e-02f, 1.23813562e-01f, 1.07433479e-02f, 1.14604505e-02f, 1.15038902e-01f, 1.32093448e-02f, 2.91022882e-02f,
  1.05434813e-01f, -4.82172286e-03f, 2.06072733e-01f, -1.89344808e-02f, 9.78056118e-02f, 8.64201337e-02f, 9.06774923e-02f, 1.30408704e-01f, 9.00411755e-02f, -2.80336559e-01f,
  -3.58182847e-01f, -1.07280821e-01f, 3.14213574e-01f, 1.75209362e-02f, 2.42397815e-01f, 7.31190369e-02f, -1.06117971e-01f, -8.84952694e-02f, 9.50393602e-02f, -2.50730440e-02f,
  -1.59549918e-02f, -1.37467101e-01f, -3.32648456e-02f, -1.70377747e-03f, -1.65629104e-01f, -6.67751282e-02f, 2.25579187e-01f, 3.24640684e-02f, 2.56698102e-01f, -1.09099038e-02f,
  2.14753434e-01f, -3.62296432e-01f, -3.64180952e-01f, 1.73956692e-01f, -1.01153404e-01f, 3.07090104e-01f, 1.67830691e-01f, -2.86951751e-01f, 9.26548168e-02f, 2.27001160e-01f,
  -1.37890354e-01f, -2.36197174e-01f, 1.78748891e-01f, -1.75573766e-01f, 2.80294836e-01f, 1.26825079e-01f, 1.90312639e-01f, 1.85804576e-01f, -4.09398340e-02f, 2.83767860e-02f,
  4.52270135e-02f, 4.58929837e-02f, 9.38740969e-02f, -4.44793366e-02f, 2.27886543e-01f, 5.96140958e-02f, 1.17707653e-02f, 1.60371050e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  2.21912503e-01f, -8.36945139e-03f, 2.08120063e-01f, 2.56337255e-01f, 3.07022989e-01f, 4.08320595e-03f, 1.16880514e-01f, 1.05814263e-01f, 1.04516909e-01f, 2.07214192e-01f,
  1.10282861e-01f, 2.34381169e-01f, 2.06128150e-01f, 1.06874265e-01f, 1.96745768e-01f, 8.77453089e-02f, 1.00777067e-01f, 1.69275612e-01f, -2.61992365e-02f, 1.16254427e-01f,
  -1.73856080e-01f, 2.55426645e-01f, 1.81022063e-01f, 3.39329779e-01f, 1.41623423e-01f, 1.11965314e-01f, 1.40623972e-01f, 1.06464282e-01f, 6.59585819e-02f, 2.45355576e-01f,
  7.32814893e-02f, 2.04994977e-01f, 3.36267859e-01f, -1.46123275e-01f, 2.65791118e-01f, 5.22312112e-02f, 2.36036971e-01f, 2.73335539e-03f, 1.06253833e-01f, 3.24436307e-01f,
  2.90240139e-01f, 1.83279663e-01f, 8.60810578e-02f, -1.55182526e-01f, -1.04475357e-01f, 7.48699233e-02f, 8.59173387e-02f, -7.61875184e-03f, -3.02693974e-02f, 1.38016358e-01f,
  -1.44494195e-02f, 9.89766717e-02f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  -2.67077148e-01f, 3.59667419e-03f, -2.29291692e-01f, -2.47386798e-01f, -3.52455765e-01f, 7.37816468e-03f, -4.15968060e-01f, 4.61870700e-01f, -2.34793425e-01f, -2.80635990e-02f,
  1.65532097e-01f, 7.07278669e-01f, -5.42980194e-01f, 1.77270427e-01f, -1.53205544e-01f, 7.08672032e-02f, -4.46894974e-01f, 2.75398772e-02f, -3.12380530e-02f, 5.83962500e-02f,
  1.59694329e-02f, 5.34584187e-02f, 1.31764233e-01f, -2.56200522e-01f, 3.02748591e-01f, -1.71165213e-01f, -2.62150588e-03f, 6.80036396e-02f, 2.05837861e-02f, 9.69467983e-02f,
  1.60945758e-01f, -2.75963396e-01f, 2.70766437e-01f, -1.50293559e-01f, 6.72547296e-02f, -1.57308966e-01f, 1.51374161e-01f, -4.20190036e-01f, 2.50002164e-02f, 1.84986383e-01f,
  2.04742569e-02f, -3.06242764e-01f, -6.80002477e-03f, -4.39487666e-01f, -9.77023914e-02f, 3.28870922e-01f, -1.59151912e-01f, 1.91365764e-01f, -2.76149333e-01f, 1.48355424e-01f,
  -3.06697607e-01f, -3.42692971e-01f, -4.61616516e-01f, 4.82766293e-02f, -1.57399923e-01f, 1.73857182e-01f, 2.19339326e-01f, -1.58628330e-01f, -1.25188753e-01f, 2.47038633e-01f,
  1.30206332e-01f, -1.36690363e-01f, 9.45287421e-02f, -3.35576609e-02f, -4.32418466e-01f, -1.27263777e-02f, -1.07370764e-01f, -1.06023446e-01f, 2.59653866e-01f, 1.03093363e-01f,
  -3.10610145e-01f, -5.07527530e-01f, -2.93064207e-01f, -2.14129075e-01f, -2.94755280e-01f, 8.50005597e-02f, -1.49164349e-01f, 1.58611059e-01f, -3.93006533e-01f, -3.29271883e-01f,
  -1.69945955e-01f, -2.23213613e-01f, 1.43251717e-01f, -4.44250017e-01f, -4.31981757e-02f, -9.74888802e-02f, 1.13485485e-01f, 1.16131417e-01f, 2.47651145e-01f, 2.37760782e-01f,
  2.96710413e-02f, 3.15941036e-01f, -4.72746342e-01f, -2.60058224e-01f, 3.01631931e-02f, 8.12641457e-02f, 1.73544362e-01f, -1.10571206e-01f, 5.15211038e-02f, -1.76600963e-01f,
  1.09116416e-02f, -2.42049456e-01f, -7.53970027e-01f, -1.27755657e-01f, 1.98155627e-01f, 1.40927821e-01f, -8.79510939e-02f, -3.02340448e-01f, -7.17778057e-02f, 3.87414247e-01f,
  -1.11025989e-01f, 4.18378592e-01f, 1.89345926e-01f, 1.15592137e-01f, 1.43687174e-01f, -3.68499637e-01f, 7.35087469e-02f, 1.89048406e-02f, 1.59234226e-01f, -9.86785144e-02f,
  5.75616881e-02f, 1.07813068e-01f, -2.04943255e-01f, -3.71133178e-01f, 1.69252157e-01f, -2.77379125e-01f, 1.04347229e-01f, 1.06936410e-01f, 6.44472241e-02f, -2.05948739e-03f,
  -1.83548164e-02f, -6.86961487e-02f, 2.10511625e-01f, -1.94227517e-01f, 2.78052747e-01f, -2.78253794e-01f, 1.67022839e-01f, 7.36246780e-02f, -1.69599146e-01f, -2.62379408e-01f,
  -1.74251154e-01f, -1.23993374e-01f, 3.35940003e-01f, -2.04982042e-01f, 7.04713836e-02f, -4.24688160e-01f, 3.70278835e-01f, 2.01734394e-01f, -4.76614460e-02f, 2.25967512e-01f,
  -1.93171382e-01f, -2.79591918e-01f, -6.09960668e-02f, 4.17378880e-02f, 5.18368363e-01f, 2.08230928e-01f, -3.02426964e-02f, 2.65827954e-01f, 1.26123101e-01f, -1.84775278e-01f,
  8.83226246e-02f, -5.32425225e-01f, -3.42018992e-01f, 1.88105807e-01f, 6.54212609e-02f, -5.32107279e-02f, -5.27823806e-01f, -1.42133236e-01f, -2.28100091e-01f, -2.69030958e-01f,
  -1.46173695e-02f, -2.23456278e-01f, -3.31899375e-01f, -3.80781114e-01f, 2.04299316e-01f, -4.04477894e-01f, 2.66688436e-01f, 1.68799996e-01f, 5.10807037e-02f, -3.92721355e-01f,
  8.05893838e-02f, -5.31948745e-01f, -2.17010573e-01f, 1.06043361e-01f, 1.85812771e-01f, -3.47906321e-01f, -9.10464972e-02f, 1.88792676e-01f, 2.82412082e-01f, -5.35530865e-01f,
  9.02332962e-02f, -2.10732013e-01f, -1.53207093e-01f, -1.02642283e-01f, -7.52488151e-02f, -2.26563901e-01f, -2.59538472e-01f, -1.08813837e-01f, 1.11182593e-01f, 2.47437462e-01f,
  -3.98296088e-01f, 1.43507466e-01f, -4.63864148e-01f, -7.48281255e-02f, -5.02642989e-01f, 7.76223317e-02f, 2.37958997e-01f, 1.96333289e-01f, -1.17165968e-02f, 1.81265235e-01f,
  -4.87658858e-01f, 8.85207579e-02f, -3.19601744e-02f, -4.41387713e-01f, -3.40235345e-02f, -5.66176593e-01f, -7.16308728e-02f, -1.72021553e-01f, 2.80248910e-01f, 1.89911555e-02f,
  1.72504768e-01f, -2.73605525e-01f, -3.93244671e-03f, 3.27691227e-01f, 9.43160653e-02f, -3.81929815e-01f, -1.80902347e-01f, -5.17592013e-01f, -3.10928643e-01f, 1.48968711e-01f,
  2.05234304e-01f, 1.47850662e-01f, -5.78297079e-01f, 6.74244687e-02f, 2.49193504e-01f, 2.43463323e-01f, -2.36816913e-01f, 1.62386477e-01f, 5.25246151e-02f, -2.53790706e-01f,
  -3.54759634e-01f, -3.65061089e-02f, -2.31370553e-01f, 2.40680158e-01f, -2.76473105e-01f, -3.13204497e-01f, 1.43665269e-01f, 8.12744256e-03f, -1.31191552e-01f, -5.08695424e-01f,
  -3.38276476e-01f, 6.29194034e-03f, 4.99800369e-02f, 1.10676929e-01f, -5.03808856e-01f, -3.80055636e-01f, 3.53999943e-01f, 3.89197379e-01f, 8.52292776e-03f, 1.28339589e-01f,
  2.71369785e-01f, -1.79124810e-03f, 4.95124280e-01f, 1.76332548e-01f, 1.68361843e-01f, 2.09558994e-01f, 1.91612184e-01f, -3.29982847e-01f, 1.40374824e-01f, -9.17778015e-02f,
  7.70898610e-02f, 2.78294444e-01f, 7.95940906e-02f, 1.59266382e-01f, 4.46095653e-02f, -1.62468608e-02f, 3.25773627e-01f, -2.63820942e-02f, 1.21421302e-02f, 3.14276740e-02f,
  -3.94501001e-01f, -3.27562720e-01f, -2.77371585e-01f, -3.93429369e-01f, 1.07906185e-01f, -5.25683939e-01f, 4.69500199e-03f, -1.79014672e-02f, -1.13681920e-01f, -5.35900831e-01f,
  5.09705506e-02f, 1.44484892e-01f, 1.43739775e-01f, 2.45278746e-01f, 4.59815226e-02f, -7.97154829e-02f, -1.81953385e-02f, -1.01972982e-01f, -2.12898359e-01f, -3.64840448e-01f,
  -2.87586421e-01f, -1.57444239e-01f, -2.88926482e-01f, -1.16902798e-01f, -2.95572758e-01f, 7.78715909e-02f, 5.31433150e-02f, 1.06448764e-02f, -6.50119901e-01f, 4.92151156e-02f,
  1.66216761e-01f, 8.99987072e-02f, -8.05955082e-02f, 2.08993956e-01f, -5.48402034e-02f, 1.85762011e-02f, 2.20885366e-01f, 2.66896069e-01f, -9.42879636e-03f, 6.35604840e-03f,
  1.12290405e-01f, 8.76167864e-02f, 6.94142282e-02f, 3.23501043e-03f, -2.04553045e-02f, -2.48660356e-01f, 5.06742835e-01f, 4.02157987e-03f, -2.59477086e-02f, -1.40190870e-01f,
  5.16717553e-01f, 2.95326769e-01f, 1.15959212e-01f, -1.98874027e-01f, -5.51062584e-01f, -7.85279945e-02f, 3.78846610e-03f, -2.17535451e-01f, -1.55591384e-01f, 2.78906971e-01f,
  -6.88213035e-02f, 2.63062954e-01f, -7.17917979e-02f, -5.92176877e-02f, -1.94849372e-01f, -3.46512258e-01f, 1.32135436e-01f, 4.66188937e-02f, -2.13623941e-01f, -2.05152795e-01f,
  -2.92707205e-01f, -6.40666038e-02f, 2.21108701e-02f, 1.03117861e-02f, 2.61397362e-01f, -5.01806378e-01f, 3.14625204e-02f, -2.00589150e-01f, 1.62356421e-01f, 1.66290134e-01f,
  2.77220070e-01f, 6.54862747e-02f, 2.94700682e-01f, 1.39510324e-02f, -4.82665896e-01f, -1.81776702e-01f, -2.87660539e-01f, -2.06160650e-01f, 1.05814323e-01f, 1.03489839e-01f,
  -1.73566073e-01f, 2.29645714e-01f, 1.99924126e-01f, 3.68031055e-01f, -9.01883841e-03f, -1.86503544e-01f, 1.21299498e-01f, 1.04294186e-02f, 9.77169350e-03f, -3.20863277e-01f,
  -3.08556199e-01f, 2.83318609e-01f, 1.89239979e-01f, 1.08039759e-01f, -1.38434723e-01f, 8.86412933e-02f, -2.29103699e-01f, 1.37650162e-01f, -1.04090624e-01f, 1.23585351e-01f,
  -2.02488512e-01f, 2.46689886e-01f, 2.17394695e-01f, -3.50287348e-01f, 3.33064198e-01f, -1.98436052e-01f, 1.75271511e-01f, 1.13083862e-01f, -4.42381918e-01f, -1.42497241e-01f,
  2.56849974e-01f, 1.41866622e-03f, -1.07538261e-01f, -6.73632324e-02f, -7.71764293e-02f, -1.28286839e-01f, -4.71003979e-01f, 5.40682971e-02f, -3.02248955e-01f, 2.84396023e-01f,
  -5.18329859e-01f, -2.65967697e-01f, -7.37037122e-01f, 2.44443849e-01f, 2.02378735e-01f, -4.42064703e-01f, -2.69844204e-01f, 2.03403234e-01f, -6.71432586e-03f, 2.13523865e-01f,
  -5.30008435e-01f, -3.33843470e-01f, -3.95773828e-01f, -4.24636930e-01f, 3.60824585e-01f, -4.47706997e-01f, -2.58984208e-01f, 4.51966338e-02f, 4.67823893e-01f, 5.43482564e-02f,
  -1.70394629e-01f, -2.06841931e-01f, 2.42888168e-01f, -5.49737394e-01f, -3.64760458e-01f, 3.48319858e-01f, 3.37832868e-01f, -1.37360856e-01f, -5.49464405e-01f, 1.03530243e-01f,
  -3.13655883e-01f, 2.33298197e-01f, -3.39698419e-02f, -3.94530036e-02f, -2.11781919e-01f, -5.15764713e-01f, 9.00642946e-03f, -3.41759861e-01f, -2.05599487e-01f, -2.90852755e-01f,
  2.89196987e-02f, 2.66868714e-02f, -1.10424012e-01f, 1.66571699e-02f, -1.33611143e-01f, -1.00393578e-01f, -2.74246991e-01f, -6.50765793e-03f, -1.74460754e-01f, -1.59073010e-01f,
  3.18786427e-02f, -2.65452176e-01f, -3.22744809e-02f, -3.94634843e-01f, 1.58769295e-01f, -3.25640887e-01f, -2.79558718e-01f, 1.52956948e-01f, -2.80995041e-01f, 7.00436085e-02f,
  -1.20989434e-01f, 1.21571779e-01f, -1.79727346e-01f, -1.70562714e-01f, 3.02064002e-01f, -2.79197335e-01f, 2.29206726e-01f, 2.24758059e-01f, -2.97555417e-01f, 3.56481165e-01f,
  -5.19132137e-01f, -2.79318064e-01f, -4.63694006e-01f, -3.47806334e-01f, 2.87199646e-01f, 3.63914669e-01f, 4.82399791e-01f, 1.06541269e-01f, -1.23098247e-01f, 8.17664042e-02f,
  -1.71065316e-01f, 2.62945265e-01f, -3.62648517e-01f, -1.37555704e-01f, -1.77407891e-01f, -3.70111734e-01f, -5.20150781e-01f, -4.04027939e-01f, -8.01532865e-02f, -3.19844007e-01f,
  -4.72669482e-01f, -2.46224493e-01f, 5.94951659e-02f, 2.44027808e-01f, -9.79425460e-02f, -4.62870598e-02f, 6.44316599e-02f, 3.10902983e-01f, -3.36007506e-01f, 1.87298939e-01f,
  -2.09916696e-01f, -1.03135012e-01f, 1.40019864e-01f, 4.65666242e-02f, 4.19220291e-02f, -1.18846856e-01f, 5.37700318e-02f, 7.32381046e-02f, -3.34288567e-01f, -2.53672212e-01f,
  -2.78190374e-01f, -1.70473412e-01f, 1.12203486e-01f, -1.38224572e-01f, -4.82003717e-03f, 7.03857541e-02f, 1.08218648e-01f, -3.28378588e-01f, -1.56367466e-01f, -4.38912898e-01f,
  9.39591452e-02f, -1.97595969e-01f, -3.67821246e-01f, -4.68242943e-01f, -9.19952095e-02f, 8.50476548e-02f, 3.27942938e-01f, -1.37809440e-01f, -1.09657787e-01f, -1.39953857e-02f,
  4.58622202e-02f, 9.04890746e-02f, -2.36152947e-01f, -6.65448546e-01f, -3.66228104e-01f, 3.62317473e-01f, -1.49122030e-02f, -3.65777276e-02f, -3.13330293e-01f, -1.54266611e-01f,
  4.41613227e-01f, 4.03090864e-01f, -5.62681317e-01f, 1.91302612e-01f, 3.27573240e-01f, 2.57906765e-01f, 3.24565262e-01f, -3.45198780e-01f, 8.66699964e-02f, -1.09735802e-01f,
  3.12803388e-01f, -3.70143980e-01f, 3.00526023e-01f, 3.07938725e-01f, 2.18811870e-01f, -3.35377514e-01f, -7.16215074e-02f, -1.57311246e-01f, 2.04849750e-01f, -4.09658641e-01f,
  4.81824994e-01f, -1.95391297e-01f, -3.21400046e-01f, -2.83357322e-01f, -5.36715686e-02f, 1.40938088e-01f, 1.07505441e-01f, -4.37792111e-03f, -1.61167100e-01f, 2.94989049e-01f,
  -3.12440634e-01f, 1.48185402e-01f, -4.14371580e-01f, -4.98299927e-01f, 5.00129163e-01f, 4.02828574e-01f, 2.91683912e-01f, -1.13985203e-01f, -1.40001653e-02f, -1.79521233e-01f,
  -3.67065728e-01f, -5.33638103e-03f, 1.27808034e-01f, -3.83620352e-01f, -1.73898324e-01f, 1.09681733e-01f, 2.42548525e-01f, 2.67239332e-01f, 1.07081309e-01f, 1.04452915e-01f,
  -3.70874852e-01f, 2.66961098e-01f, -1.25661492e-01f, -5.04652560e-01f, 1.31254360e-01f, -2.15427458e-01f, 2.20220327e-01f, -2.39616871e-01f, -1.48737669e-01f, 2.32376844e-01f,
  -1.05873734e-01f, 4.29725468e-01f, 3.11817169e-01f, -5.84511235e-02f, -1.45050548e-02f, -5.94688177e-01f, 1.31079450e-01f, 2.14177832e-01f, -8.08101892e-02f, -1.21665560e-01f,
  -3.83353680e-01f, -1.85047388e-01f, -2.35567968e-02f, 1.73423812e-01f, -2.62467921e-01f, -3.35427105e-01f, -1.87667206e-01f, -6.20588303e-01f, 1.05085336e-01f, -8.36400315e-02f,
  -4.35394943e-01f, -6.13462552e-02f, -3.05856407e-01f, -2.67182410e-01f, -5.06412029e-01f, 2.47406811e-01f, -7.58091314e-03f, 2.47361362e-02f, 6.90871710e-03f, 1.11526459e-01f,
  1.47183865e-01f, -1.62877008e-01f, -4.13239859e-02f, -5.98439611e-02f, -6.76813126e-02f, 2.18644720e-02f, 2.13206947e-01f, -3.43278170e-01f, -1.09757632e-02f, -2.49612033e-01f,
  -2.37267017e-01f, -2.25364789e-02f, 2.46659636e-01f, -3.62982333e-01f, 2.72047371e-01f, 1.38046443e-01f, -2.67279893e-01f, 3.35356027e-01f, 2.46289641e-01f, -6.29188061e-01f,
  -4.10651684e-01f, -2.25564167e-01f, -4.80241150e-01f, -6.58985496e-01f, 2.79183060e-01f, -2.59159505e-01f, 3.86615723e-01f, 1.13560125e-01f, -2.56047189e-01f, -2.16184780e-01f,
  -4.03926849e-01f, 3.38028848e-01f, 8.37502554e-02f, -4.00370151e-01f, -1.30832139e-02f, -3.27111423e-01f, -2.18714029e-01f, 3.98076981e-01f, -2.47655228e-01f, -3.83855045e-01f,
  -2.41342127e-01f, 1.16259627e-01f, 1.57758221e-01f, 2.23621577e-01f, -2.68932164e-01f, -2.33889088e-01f, -4.54104304e-01f, -2.94374168e-01f, -5.44247508e-01f, 1.51012182e-01f,
  2.13426769e-01f, 1.65674061e-01f, 1.71798751e-01f, -3.24979395e-01f, 8.70492011e-02f, -8.51735711e-01f, -5.84211469e-01f, -5.21420121e-01f, 9.48024094e-02f, -2.62993366e-01f,
  -4.30963337e-01f, 3.16144153e-02f, -1.75417244e-01f, 1.47998422e-01f, 5.64851463e-02f, -9.35923606e-02f, 2.36504838e-01f, -1.22026853e-01f, 3.52554768e-03f, 1.49749473e-01f,
  -1.56476915e-01f, 4.48255181e-01f, 2.83131242e-01f, -8.32377374e-02f, -4.24890995e-01f, -1.93567574e-01f, -5.29734135e-01f, -4.86315906e-01f, 7.03548342e-02f, 3.56678963e-01f,
  2.12541327e-01f, -2.12829858e-01f, -3.90829355e-01f, 3.97597402e-01f, -3.99551570e-01f, -2.77412504e-01f, 1.77234992e-01f, -2.21959054e-01f, -2.87311465e-01f, -2.25566044e-01f,
  -3.84931445e-01f, 4.81708311e-02f, -3.12814802e-01f, 3.10610384e-01f, -5.34241684e-02f, -2.67927021e-01f, -3.10890228e-01f, -4.24229577e-02f, 7.09652603e-02f, -3.22470307e-01f,
  -1.44442797e-01f, -1.24878660e-01f, 9.15014520e-02f, -2.76230812e-01f, -3.21572930e-01f, 6.04308955e-02f, -2.60696113e-01f, 2.03256950e-01f, 2.43433341e-01f, -6.56337440e-02f,
  3.16981912e-01f, 1.97453678e-01f, 2.16879264e-01f, -3.30068737e-01f, -1.59207925e-01f, 2.71942914e-01f, -2.35894665e-01f, 1.42116547e-01f, 2.07736179e-01f, -2.98010111e-01f,
  -1.37056261e-01f, 2.19156966e-01f, -3.69757622e-01f, -1.66931659e-01f, -3.72032583e-01f, 2.09020287e-01f, -2.56938726e-01f, -2.72962362e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.84403881e-01f, 8.90092403e-02f, 1.59375221e-01f, -5.94857633e-02f, 8.24824627e-03f, 8.23209584e-02f, 1.31803066e-01f, 5.83073646e-02f, -1.02143297e-02f, 8.55777860e-02f,
  -7.13249967e-02f, 6.58371821e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    